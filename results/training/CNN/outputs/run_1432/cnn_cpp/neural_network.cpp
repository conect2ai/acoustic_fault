#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.20906852f, -0.06613686f, 0.11266272f, 0.43039632f, -0.42364356f, 0.61066228f, -0.23849811f, 0.01932932f, 
    -0.16805343f, -0.24455985f, -0.27645361f, 0.06988156f, 0.69889230f, -0.55668402f, -0.07122014f, -0.13865057f, 
    -0.21171272f, 0.29392609f, 0.12963663f, 0.09716508f, -0.18121558f, 0.03882457f, -0.10184538f, 0.09464347f, 
    0.10538196f, 0.23971885f, -0.06322284f, -0.48976949f, -0.28369787f, -0.04387486f, 0.24297953f, 0.12062508f, 
    -0.06323522f, -0.39816159f, 0.37375510f, 0.03959391f, -0.10171788f, 0.12797400f, -0.18896514f, 0.24938159f, 
    -0.22539279f, -0.28746703f, -0.08649530f, -0.27159932f, 0.03066344f, -0.06017870f, 0.36989710f, 0.37527364f, 
    0.07886346f, 0.40847561f, 0.94743973f, -0.18702747f, -0.08411454f, 0.53782469f, 0.25046501f, -0.28043845f, 
    0.15495847f, -0.31875297f, -0.45647702f, -0.44953576f, 0.07159989f, -0.07055826f, 0.27263430f, -0.10167950f, 
    -0.15188533f, -0.09697638f, 0.21084251f, 0.25218320f, -0.04663280f, -0.02268052f, -0.02125531f, -0.21034548f, 
    0.06695733f, 0.21726480f, -0.16251829f, -0.41246614f, 0.17674698f, 0.28816223f, -0.76941013f, -0.45520714f, 
    -0.35969636f, 0.24874562f, 0.42238230f, 0.43677497f, 0.16863273f, -0.42844579f, -0.24269068f, -0.17785928f, 
    0.39533240f, 0.16984075f, -0.27218652f, 0.14688636f, -0.01660202f, 0.24896038f, -0.20559849f, -0.03353874f, 
    0.23439488f, 0.05607923f, -0.19123520f, -0.07611660f, 0.05751204f, 0.23848583f, 0.29975170f, -0.05332600f, 
    -0.27747399f, -0.57020664f, -0.02221732f, 0.29066449f, -0.08080029f, -0.23375811f, -0.05964911f, -0.47286490f, 
    -0.13388661f, -0.12209687f, 0.29747987f, 0.02997971f, -0.00705507f, 0.09723507f, 0.12099620f, -0.27916437f, 
    -0.21649554f, -0.26421604f, -0.26924041f, -0.39227551f, -0.57179308f, 0.00438552f, 0.38734323f, 0.08827610f, 
    0.40052581f, -0.07699211f, -0.24577506f, -0.08900420f, 0.16638325f, 0.25345314f, 0.17644581f, 0.16787827f, 
    -0.17434673f, -0.01317386f, -0.13310808f, -0.18164338f, 0.12564594f, -0.11929357f, 0.06431309f, -0.00147074f, 
    0.10382560f, -0.26860806f, -0.03701026f, -0.25308064f, -0.10275586f, -0.48769534f, 0.74242091f, 0.31246069f, 
    -0.27619833f, -0.25763318f, -0.23839030f, 0.40145767f, 0.53167981f, 0.43876114f, 0.00402769f, -0.40109050f, 
    -0.36048293f, 0.12556750f, -0.15383796f, -0.20761758f, -0.02401548f, 0.50987113f, -0.22344883f, -0.19990811f, 
    -0.21069235f, -0.32936361f, 0.11101310f, 0.00669433f, 0.17365116f, 0.03322886f, -0.03435719f, -0.46173134f, 
    -0.54445654f, -0.51496309f, -0.58929634f, -0.26860744f, 0.14066127f, -0.06404530f, -0.04605152f, -0.14835832f, 
    0.30339947f, -0.35636920f, -0.36496273f, -0.17086959f, 0.08597902f, -0.19366308f, -0.21709551f, -0.50149852f, 
    -0.12230399f, 0.04532382f, -0.49904689f, -0.02982176f, -0.08856039f, -0.15107994f, -0.03426217f, 0.07652564f, 
    -0.96729541f, 0.19338980f, -0.46518070f, -0.45388365f, -0.00828588f, -0.27355975f, -0.16035648f, -0.20210043f, 
    0.28108567f, 0.06753191f, 0.08874817f, -0.40432614f, -0.10142802f, -0.58844084f, -0.10213308f, 0.25164929f, 
    0.14812426f, 0.01177185f, 0.13267350f, -0.07318582f, -0.09588715f, -0.16896467f, -0.18167844f, -0.02250680f, 
    -0.04301716f, 0.46248367f, 0.39403379f, 0.40071976f, 0.17707931f, 0.24116196f, -0.01031475f, -0.13616449f, 
    0.36693203f, -0.26874894f, -0.22270489f, -0.15132967f, 0.04261226f, 0.16650742f, 0.04779714f, -0.07120641f, 
    0.13407624f, 0.06383036f, -0.25384921f, -0.21827276f, 0.28894380f, 0.03458833f, 0.17526676f, -0.16199617f, 
    -0.19044770f, 0.22216563f, -0.16953285f, 0.33161792f, 0.02848705f, 0.39700502f, -0.36482865f, 0.03548393f, 
    -0.26647553f, 0.02649087f, -0.09964562f, 0.68518251f, 0.19974551f, 0.43104661f, -0.31621575f, -0.43859732f, 
    0.28825855f, -0.17105466f, -0.01862885f, -0.13559408f, 0.04061685f, -0.19457217f, 0.12580365f, 0.07731203f, 
    0.09553769f, -0.11328455f, 0.07576270f, -0.18566456f, -0.75383383f, -0.09139272f, 0.64177758f, -0.04057325f, 
    -0.49964121f, -0.18974455f, -0.90715367f, -0.29867536f, 0.05933017f, 0.29847080f, 0.17096652f, 0.07023111f, 
    0.11883443f, 0.12194418f, -0.35692501f, -0.00605793f, -0.01472533f, 0.02923424f, -0.17553535f, 0.24677087f, 
    -0.20345344f, -0.32058367f, 0.34265527f, 0.23468657f, -0.81438428f, -0.63724911f, -0.38605398f, 0.31328121f, 
    0.61738527f, -0.43548167f, -0.58738518f, -0.08401176f, 0.04094543f, 0.11818602f, 0.28736678f, 0.19574486f, 
    0.03643528f, 0.47692776f, 0.03373456f, 0.31047931f, -0.00621505f, 0.10266472f, -0.13178439f, -0.25872290f, 
    -0.20415016f, 0.03154469f, 0.13430832f, -0.15576990f, -0.22097242f, -0.95597714f, -1.00498712f, -0.70703846f, 
    0.32626683f, 0.17135635f, 0.43152982f, 0.45076936f, 0.07288567f, 0.23209906f, 0.66139889f, 0.33834139f, 
    0.01459627f, 0.03666807f, 0.09246837f, 0.02184135f, -0.06979965f, -0.22571342f, -0.11459636f, 0.05609937f, 
    0.15909526f, -0.03555419f, -0.17035456f, 0.06051856f, 0.24960624f, -0.18639071f, 0.50975788f, 0.60570574f, 
    -0.19679108f, -0.37545207f, -0.47990012f, -0.33435568f, -0.46721214f, -0.35264686f, -0.55502474f, -0.52897805f, 
    0.26648727f, 0.47643581f, -0.12073009f, 0.12937875f, -0.05344658f, -0.08909605f, -0.23355970f, 0.11586958f, 
    -0.31942961f, -0.20414431f, 0.01583536f, -0.26249939f, -0.03406542f, 0.02599050f, -0.21608202f, -0.38848180f, 
    -0.66873193f, 0.05610805f, 0.40989673f, 0.84824020f, 0.28246436f, 0.25578645f, -0.43829629f, -0.27634031f, 
    0.07702834f, -0.24657701f, 0.14363526f, -0.40776449f, -0.10113683f, -0.11157217f, 0.09504344f, -0.22070320f, 
    0.01764310f, 0.01829874f, -0.13889758f, -0.14389561f, 0.17463546f, 0.04275589f, -0.04244195f, 0.10459070f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04453116f, 0.10155772f, 0.15336256f, 0.26420420f, -0.12405136f, -0.09981741f, 0.19299945f, -0.29950225f, 
    0.11073948f, -0.17530331f, 0.29042897f, 0.06504918f, -0.02194017f, 0.16375685f, -0.02699670f, 0.20888713f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07061128f, -0.20723917f, -0.00838371f, -0.03617118f, 0.09661864f, -0.04295699f, 0.09184417f, 0.08095516f, 
    -0.01785837f, -0.08144464f, -0.01243145f, 0.12152841f, 0.13656227f, -0.12466580f, 0.08670150f, 0.07108481f, 
    0.01210571f, 0.39516801f, 0.06177815f, -0.01951895f, 0.15715452f, 0.05475021f, 0.26033875f, 0.21607849f, 
    -0.22269960f, 0.17224018f, 0.04369101f, 0.17826451f, 0.06992374f, -0.05946941f, 0.09755237f, 0.05447388f, 
    0.11006107f, -0.02241609f, 0.10738174f, 0.00969587f, 0.17229567f, 0.26621103f, 0.01900785f, 0.16730666f, 
    0.09620963f, 0.06037670f, 0.03048224f, 0.15524718f, -0.01338307f, -0.04584524f, 0.07597042f, 0.12071728f, 
    -0.00562028f, 0.05284751f, -0.10023069f, 0.06455148f, 0.03596299f, -0.07911677f, -0.14517437f, -0.18362576f, 
    -0.07262344f, -0.14566019f, -0.05480952f, -0.09789393f, -0.24044788f, -0.00844619f, -0.11237562f, -0.21132152f, 
    -0.09887057f, -0.13622294f, -0.12569852f, 0.00778009f, 0.14167392f, -0.01451436f, 0.08177906f, -0.03921482f, 
    0.25802335f, 0.02901377f, 0.24151784f, 0.09993012f, -0.02381120f, -0.05060911f, 0.08908265f, 0.02082822f, 
    -0.11873975f, 0.00225849f, -0.04907510f, 0.06659849f, 0.02369732f, 0.09404179f, 0.17320618f, 0.39727473f, 
    -0.04095634f, 0.01342657f, 0.12450550f, -0.00219373f, 0.11042339f, 0.06849936f, 0.06087684f, -0.18389714f, 
    0.15120603f, -0.04928979f, -0.01924018f, 0.18094149f, 0.10644982f, -0.01733704f, 0.00264365f, -0.32879689f, 
    0.06867014f, -0.01570311f, -0.00869230f, 0.03834809f, -0.58300036f, -0.35269284f, -0.24578962f, -0.35787085f, 
    -0.02037027f, -0.05248874f, -0.09912903f, -0.09871653f, -0.01016657f, 0.05407216f, -0.07002221f, 0.07008106f, 
    -0.06917503f, -0.07007188f, 0.02776307f, -0.29270935f, 0.05358630f, 0.11345622f, -0.06759986f, -0.05941695f, 
    0.03998053f, 0.02424877f, -0.06359667f, 0.01918725f, 0.02738900f, 0.05241534f, -0.00289667f, 0.17828880f, 
    -0.09658322f, -0.02148043f, -0.11663852f, 0.08975028f, -0.05260907f, 0.00969708f, 0.12499156f, 0.08950968f, 
    -0.04684084f, -0.04228669f, -0.19884595f, 0.22433101f, 0.04560788f, -0.02787882f, 0.09469079f, 0.02064764f, 
    -0.01662243f, 0.04336649f, -0.04832689f, -0.01439950f, 0.09755579f, -0.05769463f, -0.02909407f, 0.02332305f, 
    0.04176846f, 0.16422123f, -0.02459063f, -0.01046824f, -0.02549400f, 0.07874329f, 0.03954223f, 0.09575254f, 
    -0.15000647f, 0.00074060f, 0.20807448f, 0.05141582f, -0.02032785f, 0.06226961f, 0.00279553f, 0.13317643f, 
    0.02000492f, -0.11691421f, -0.06281020f, 0.03087430f, -0.13922359f, 0.07128523f, -0.12621367f, 0.03389186f, 
    0.02339872f, -0.00187719f, -0.02708659f, 0.04840954f, -0.05379609f, -0.04425122f, -0.18897492f, 0.04787767f, 
    0.06542443f, 0.05121180f, -0.02337096f, -0.04413376f, -0.02303777f, -0.00063908f, -0.04764605f, 0.02157006f, 
    -0.07498139f, -0.07326663f, -0.02291418f, 0.00801514f, -0.02764018f, -0.06511108f, 0.06278451f, -0.00220885f, 
    0.01838559f, 0.03913375f, -0.07054687f, 0.05614053f, 0.03783983f, -0.03230825f, -0.03096718f, -0.05387189f, 
    -0.06625783f, 0.02895542f, 0.06222698f, -0.06091340f, -0.00735402f, -0.03079433f, 0.00014079f, 0.03591329f, 
    -0.04315753f, -0.05858351f, -0.05568444f, -0.04408501f, -0.01376573f, -0.03146130f, -0.01697955f, 0.05115294f, 
    -0.01832270f, -0.06313256f, -0.01970690f, -0.06509437f, 0.05643133f, -0.05827164f, 0.04704086f, -0.05705875f, 
    -0.02662885f, 0.04212899f, -0.01871003f, 0.02187773f, -0.01780192f, 0.01990408f, 0.02900223f, -0.01764721f, 
    0.01288603f, 0.00250949f, 0.01982623f, -0.01036510f, 0.02857612f, -0.01327970f, -0.01856644f, -0.04915039f, 
    0.01125803f, 0.03683886f, -0.02373895f, 0.02379886f, 0.01671541f, 0.02353737f, 0.01031459f, -0.01406935f, 
    -0.05858363f, -0.03187855f, 0.02554060f, -0.01447038f, 0.00960316f, 0.04466443f, -0.02475276f, -0.01463758f, 
    0.02301092f, -0.05323193f, -0.06850834f, 0.04252583f, -0.02966195f, 0.03425185f, -0.03227475f, 0.03040952f, 
    0.00666517f, 0.03871791f, -0.03796859f, -0.02338808f, 0.01136016f, -0.04582921f, -0.01725238f, -0.07619072f, 
    -0.04963074f, -0.00743093f, -0.03474760f, 0.05155644f, -0.05577016f, -0.01583278f, -0.01457235f, -0.07504585f, 
    0.04459173f, 0.05117808f, -0.04570661f, -0.00029970f, -0.04451644f, -0.01247926f, -0.07348989f, 0.05138800f, 
    0.05147794f, -0.07341370f, 0.03848082f, 0.02696046f, -0.07500911f, 0.00158719f, 0.04645082f, 0.02886708f, 
    -0.06428871f, -0.03310302f, -0.06331006f, -0.04825170f, -0.06754652f, 0.02783973f, 0.02692911f, 0.02539509f, 
    -0.03609437f, 0.02713377f, 0.06756826f, -0.07197350f, -0.01966598f, 0.05823161f, 0.05934440f, -0.04912542f, 
    -0.01924270f, -0.03073245f, -0.03056720f, -0.01559077f, 0.02385860f, -0.06188131f, 0.00203049f, 0.00962126f, 
    -0.02456705f, -0.03412474f, 0.02079392f, 0.02427750f, 0.00822956f, -0.00518053f, -0.02481641f, 0.02274486f, 
    -0.00631092f, 0.03867344f, 0.01011821f, 0.00256192f, -0.04611599f, -0.05520888f, 0.03413639f, 0.06143763f, 
    -0.01151210f, -0.00363824f, -0.06874958f, -0.00442492f, -0.04865424f, -0.01911584f, -0.02392072f, 0.00036494f, 
    0.05018873f, -0.01848988f, -0.06017635f, -0.06065963f, 0.01966311f, 0.01254631f, 0.02063233f, -0.01624752f, 
    0.01941592f, -0.03975462f, 0.04754143f, -0.03545634f, -0.07449766f, -0.06293526f, 0.02307246f, -0.06936959f, 
    -0.06825710f, -0.02232145f, 0.03066524f, 0.06199397f, 0.01713522f, 0.03391252f, 0.04249456f, 0.02224942f, 
    0.18480445f, 0.15665454f, -0.12093897f, -0.20677534f, 0.06106708f, -0.13132249f, -0.04512293f, -0.17127457f, 
    0.04243663f, -0.01312719f, 0.04435227f, -0.01121168f, 0.09108915f, 0.06970911f, -0.07505567f, 0.16250783f, 
    0.11326101f, 0.07655850f, 0.05460641f, 0.01750368f, 0.03265805f, 0.05174743f, 0.06173567f, -0.07173869f, 
    -0.19196594f, 0.08074234f, -0.12548284f, -0.18598603f, -0.13855258f, -0.16372740f, -0.04395388f, -0.13198346f, 
    -0.03634989f, 0.00556770f, 0.18662925f, 0.09165610f, -0.29800898f, 0.06253909f, 0.20163131f, 0.05493708f, 
    0.24589923f, 0.13182561f, -0.21289650f, -0.22821586f, -0.08753298f, -0.10118496f, -0.02047916f, -0.01882107f, 
    -0.06290549f, -0.14190033f, 0.01925004f, -0.10961036f, 0.11612551f, -0.16374505f, -0.06291425f, -0.11723827f, 
    -0.11174234f, -0.03243498f, 0.00675490f, 0.02553961f, -0.07615940f, -0.15685378f, -0.01169590f, -0.14958251f, 
    -0.01348636f, -0.08435561f, -0.04202719f, -0.00883789f, -0.11378579f, -0.09515580f, 0.18480343f, 0.04824595f, 
    0.23432784f, -0.28426287f, -0.32205254f, -0.09592355f, 0.04289633f, 0.05128309f, 0.05659636f, 0.09549426f, 
    -0.03507648f, 0.11615641f, -0.03937256f, 0.12409607f, 0.24401806f, 0.25985008f, 0.28326556f, 0.28089401f, 
    0.09239744f, -0.04687309f, -0.08030736f, -0.00872302f, 0.01530263f, -0.12855843f, -0.00691829f, -0.19612397f, 
    0.23137121f, 0.37038887f, 0.02834332f, 0.12847053f, 0.17124361f, 0.24318209f, -0.03769675f, -0.05615092f, 
    -0.00062499f, -0.03824805f, -0.14225627f, -0.03675917f, -0.25017264f, -0.31781453f, -0.18662873f, -0.09717308f, 
    -0.10940753f, -0.07637799f, -0.04053703f, -0.04437318f, 0.03576241f, 0.07754941f, 0.08762086f, 0.08555295f, 
    -0.33308461f, -0.13963296f, -0.10632639f, -0.26476380f, 0.07130956f, 0.03946159f, -0.08839177f, 0.07086139f, 
    -0.05501449f, -0.02863186f, 0.18203683f, -0.05238241f, 0.08891410f, 0.45440292f, 0.32012135f, 0.18173578f, 
    -0.00267168f, -0.02153535f, -0.14814728f, 0.09360382f, 0.05319126f, 0.02788893f, -0.01514339f, 0.00637157f, 
    0.00558931f, 0.35224968f, 0.25487179f, 0.11199541f, -0.15343639f, 0.26723915f, 0.27575159f, 0.11541929f, 
    0.13728535f, -0.03098962f, -0.05498900f, 0.00657544f, 0.18195018f, 0.06321844f, -0.15875717f, 0.11382356f, 
    0.00693937f, 0.01836973f, 0.19835308f, 0.19313714f, 0.09334017f, 0.19681150f, -0.02769342f, -0.19884697f, 
    0.22285548f, 0.14281380f, 0.01818111f, 0.03669642f, 0.02919828f, 0.03010640f, 0.02997702f, -0.01652364f, 
    -0.13307276f, -0.07841216f, -0.06595036f, 0.04102176f, 0.03493271f, -0.26648486f, -0.14072788f, 0.01706854f, 
    -0.07047325f, -0.02040158f, 0.06460924f, 0.08743789f, 0.03654610f, 0.06496287f, -0.10559900f, 0.08298177f, 
    0.02469722f, 0.22511055f, 0.00038640f, 0.12104373f, 0.16852164f, -0.03089361f, 0.17606767f, 0.04356644f, 
    0.08155102f, 0.03683907f, -0.10548060f, 0.07980607f, -0.22815402f, -0.15175942f, 0.05784435f, -0.01799571f, 
    0.06336895f, -0.01403877f, 0.00916534f, 0.06244172f, 0.07832576f, 0.06358480f, 0.08192583f, 0.06853556f, 
    -0.18515170f, -0.07090113f, -0.11161785f, 0.03307675f, 0.02743359f, 0.20959382f, -0.07188547f, -0.02850628f, 
    0.05230626f, -0.03937987f, -0.08741477f, -0.05389588f, 0.10572956f, -0.10156253f, 0.21446648f, 0.12182216f, 
    0.28749055f, 0.15718426f, 0.06920406f, 0.15593009f, 0.03493370f, 0.01718538f, 0.05827040f, 0.07110612f, 
    -0.04190799f, 0.02264248f, -0.08892270f, -0.05072482f, 0.03544907f, 0.08381767f, 0.07135439f, 0.15450044f, 
    0.30080906f, 0.05279075f, -0.00335625f, -0.00965956f, 0.09094741f, 0.07142928f, -0.04898636f, -0.07998284f, 
    -0.09675040f, -0.02417437f, 0.04579285f, 0.11481903f, 0.07989573f, -0.02025360f, -0.12446145f, -0.18362935f, 
    -0.14206125f, 0.02121285f, 0.02058648f, -0.10530948f, -0.06217192f, -0.05263044f, -0.14820391f, 0.00748740f, 
    -0.06706112f, -0.02372177f, 0.25128976f, 0.20893021f, -0.39804187f, -0.33017707f, -0.24631183f, -0.33020338f, 
    0.20598422f, -0.00750385f, 0.06086276f, 0.16074602f, 0.11565939f, 0.05786917f, 0.00795292f, 0.14137048f, 
    -0.18252450f, -0.23861051f, -0.12867402f, -0.03011311f, -0.19594128f, -0.04901218f, 0.12105941f, 0.25328660f, 
    -0.04701115f, 0.01850932f, 0.06159669f, 0.08754540f, -0.06895289f, 0.09633932f, 0.04367882f, -0.09516720f, 
    -0.14347331f, -0.01899933f, 0.02053165f, -0.20255795f, -0.20493183f, -0.07586149f, -0.07273805f, -0.11058233f, 
    0.17595118f, 0.01911455f, -0.07944391f, 0.20356077f, -0.04578741f, -0.22840096f, 0.06146656f, 0.10267296f, 
    -0.02425078f, 0.01053821f, 0.15853788f, 0.06535709f, 0.12820803f, -0.37013862f, -0.05035381f, -0.07454444f, 
    0.13587122f, 0.00498974f, 0.01999028f, 0.01982021f, 0.28909320f, 0.06654023f, 0.06080982f, 0.07032747f, 
    0.13114436f, -0.13773201f, -0.00398784f, -0.22019239f, 0.01974239f, 0.09351533f, 0.15199992f, -0.02977205f, 
    0.11356719f, -0.03235144f, -0.01077071f, -0.02559176f, -0.21288462f, -0.05630814f, -0.17859235f, -0.24198899f, 
    0.01671816f, 0.03509542f, 0.12742858f, 0.01010219f, 0.12496353f, 0.06430843f, 0.12393086f, -0.17380244f, 
    0.14785522f, -0.15018520f, -0.30800202f, -0.13083054f, 0.12441532f, 0.08178106f, 0.01715958f, -0.04591138f, 
    0.07609404f, -0.03111172f, 0.06945461f, 0.03789949f, 0.39435568f, 0.11321156f, 0.11708520f, -0.02526808f, 
    -0.03571980f, -0.06885847f, 0.04572968f, -0.06042964f, 0.12508033f, -0.04754842f, 0.09666976f, 0.10235629f, 
    0.25271940f, 0.06416190f, 0.01120705f, 0.08528657f, 0.04305741f, 0.08350995f, 0.08943980f, 0.03400220f, 
    0.13189781f, -0.03021820f, 0.09830956f, 0.03001119f, -0.04694577f, -0.12199916f, 0.00214303f, -0.20628281f, 
    -0.03146367f, 0.00751002f, 0.10488882f, -0.07044715f, -0.04568286f, 0.10831670f, 0.10532613f, 0.20617345f, 
    -0.14777806f, -0.28953391f, 0.07351527f, -0.22977464f, 0.10684736f, 0.15214488f, -0.05173815f, 0.21324183f, 
    0.05737153f, -0.02096288f, 0.03890872f, -0.08114168f, -0.45305043f, 0.03628955f, -0.07150395f, -0.04354735f, 
    0.05840263f, -0.07735598f, -0.00464900f, 0.08084334f, 0.04900829f, 0.12927689f, -0.06263462f, -0.01189799f, 
    -0.12461587f, -0.09524500f, 0.09403795f, -0.05457135f, -0.01272868f, 0.13905893f, 0.17257376f, 0.15803201f, 
    -0.07076911f, -0.02345133f, 0.00938496f, -0.12132416f, -0.02325472f, -0.06521810f, -0.06217731f, -0.02793149f, 
    0.04043028f, 0.02347155f, -0.04591112f, -0.03275779f, -0.18167275f, -0.16969761f, 0.00217419f, -0.00068734f, 
    -0.48705369f, 0.06125775f, -0.06165936f, 0.10336225f, -0.02492388f, -0.11939299f, -0.05896597f, -0.09099883f, 
    0.22504582f, 0.04001644f, -0.00104085f, 0.00246977f, 0.06507093f, 0.06862980f, 0.00103738f, -0.23422416f, 
    0.12080747f, 0.09428521f, -0.05774706f, 0.08430705f, 0.09588232f, -0.03457912f, -0.03895959f, -0.01278318f, 
    -0.22354040f, 0.20161498f, -0.02722142f, 0.01735028f, -0.01642980f, 0.21741611f, 0.16793230f, 0.15170875f, 
    0.08102509f, -0.02914577f, -0.02006285f, -0.02056119f, -0.00836773f, 0.01110391f, 0.00047965f, 0.15031676f, 
    0.04975135f, -0.03432067f, 0.15123035f, 0.00566100f, -0.02114426f, 0.04077104f, 0.06974571f, 0.00532035f, 
    0.00739439f, -0.06860156f, 0.24378619f, -0.05152471f, 0.01325822f, -0.00462183f, -0.02425074f, -0.04780497f, 
    -0.02093221f, 0.01491124f, 0.27549565f, 0.04034674f, 0.16560146f, 0.01191322f, 0.33126929f, -0.12017800f, 
    -0.02609322f, 0.17320919f, -0.01668689f, -0.12963553f, 0.04107698f, 0.04930979f, 0.01791174f, -0.07203378f, 
    0.07065614f, 0.11805870f, 0.09444377f, -0.08355018f, 0.14237373f, -0.03973241f, 0.02187455f, -0.04611898f, 
    -0.08814585f, -0.02983971f, -0.05663541f, -0.05586448f, 0.37684327f, 0.04397869f, -0.08504535f, -0.23653734f, 
    -0.05849293f, -0.07260597f, -0.10201338f, -0.15198235f, 0.14987217f, 0.10409890f, -0.03716915f, -0.10488179f, 
    0.16682051f, 0.16257077f, -0.08824605f, 0.03389398f, -0.00302869f, -0.11304846f, 0.09367202f, 0.06835928f, 
    0.00803294f, -0.02609065f, 0.08995872f, -0.16168381f, 0.38738933f, -0.32958329f, 0.44069219f, -0.03332471f, 
    -0.05428220f, 0.05125772f, -0.00256495f, -0.10776889f, 0.00433333f, -0.04641869f, 0.01338041f, -0.01913176f, 
    0.16341634f, -0.07909095f, -0.34596157f, -0.46185952f, 0.22259943f, -0.12658390f, 0.22355424f, 0.10756958f, 
    -0.19080004f, -0.00740560f, -0.15690732f, -0.03236374f, -0.18696709f, -0.03180611f, -0.24562804f, 0.01600084f, 
    0.28084153f, 0.16927400f, -0.14015479f, 0.09586067f, -0.01377266f, -0.27293453f, -0.02206841f, -0.08739325f, 
    -0.01422087f, 0.41040763f, 0.01983529f, 0.36321121f, 0.10200059f, -0.04367236f, 0.24879883f, -0.08312117f, 
    -0.10098190f, -0.07304221f, -0.25768682f, 0.12678325f, -0.00327044f, -0.04330897f, 0.25005752f, 0.11538383f, 
    -0.08107459f, 0.09104611f, -0.18209542f, -0.04724835f, 0.17717151f, -0.14273714f, 0.15212503f, 0.03544263f, 
    0.05711857f, 0.18645775f, 0.09896626f, 0.16269852f, 0.03542218f, -0.01003879f, -0.28769696f, -0.14735548f, 
    0.24612318f, 0.03566315f, 0.08051997f, 0.19078162f, -0.07989772f, -0.12558027f, 0.13881297f, -0.00019151f, 
    -0.09100939f, -0.20215552f, -0.31986579f, 0.01991479f, 0.16280581f, 0.21868362f, 0.06220751f, 0.03216175f, 
    -0.02270017f, -0.02444022f, -0.14005181f, 0.12263737f, 0.08901438f, -0.10426923f, -0.18233712f, 0.01678912f, 
    -0.03876582f, 0.01315975f, 0.07414360f, 0.13803364f, 0.04358584f, 0.07059637f, 0.22282554f, 0.40570876f, 
    -0.00755570f, 0.15244350f, 0.01450906f, -0.07437565f, -0.07747117f, 0.02049424f, 0.15929814f, 0.05478276f, 
    0.21187453f, -0.06004223f, -0.02343214f, -0.00288485f, 0.14582935f, 0.17209281f, 0.03782843f, 0.00045188f, 
    0.02076998f, -0.02934980f, 0.04100510f, -0.07204587f, 0.01705349f, -0.15090226f, -0.17400958f, 0.17001709f, 
    0.05205622f, -0.04260384f, -0.25418639f, 0.12666495f, -0.20390478f, -0.07638879f, -0.09498267f, -0.20714942f, 
    -0.12449608f, 0.15105353f, -0.08669381f, -0.17113815f, 0.17681716f, -0.31361547f, -0.16122338f, -0.23206070f, 
    -0.16549893f, -0.07067604f, -0.08192021f, -0.05472395f, 0.11830877f, 0.24108036f, -0.01193909f, 0.18948348f, 
    -0.06396608f, -0.06876901f, 0.04334502f, -0.16691412f, -0.28129536f, 0.03224162f, -0.13068709f, 0.06118676f, 
    0.11483786f, 0.05940195f, -0.00480545f, 0.00189318f, -0.22522734f, -0.00810198f, -0.05403174f, 0.01625751f, 
    0.03232700f, 0.19553573f, 0.04932300f, 0.19519891f, 0.03634956f, -0.00735649f, -0.11282846f, 0.12521106f, 
    -0.04589439f, -0.02164059f, 0.10532970f, -0.28249270f, -0.00956447f, 0.07963122f, -0.01293046f, 0.05252013f, 
    0.12968840f, 0.16302195f, 0.12993287f, 0.14277725f, 0.12325303f, 0.18932401f, -0.08356723f, 0.11944739f, 
    0.14041445f, -0.08287901f, 0.03552464f, 0.10855452f, -0.18141374f, 0.11615098f, -0.20770970f, 0.09308378f, 
    0.01657932f, 0.01439525f, 0.00631470f, -0.11881251f, -0.22644272f, -0.02253349f, -0.11177168f, 0.04296568f, 
    -0.08844572f, -0.30414233f, -0.04448069f, 0.08934428f, -0.01978212f, 0.10607173f, -0.00839728f, -0.12317248f, 
    0.14563179f, -0.03575386f, 0.02599659f, 0.06180870f, 0.17646174f, -0.05886924f, -0.01686414f, -0.04953560f, 
    0.03882630f, 0.01297603f, 0.03432807f, 0.04260790f, -0.13135386f, 0.03674032f, -0.10031901f, -0.04450954f, 
    -0.06020241f, -0.31788820f, -0.19455782f, -0.21473253f, 0.08207077f, 0.08952335f, -0.03725836f, 0.04160818f, 
    -0.06691395f, -0.04225601f, -0.04294285f, -0.01823843f, -0.23939227f, 0.16349375f, -0.12985073f, -0.15424894f, 
    -0.03829421f, -0.26514333f, -0.04693253f, 0.07188776f, 0.13222089f, 0.10475232f, -0.07267778f, 0.01919105f, 
    -0.10889808f, -0.01563209f, 0.02101342f, 0.06863131f, 0.04402849f, 0.05195189f, 0.13322325f, -0.00213722f, 
    -0.03493715f, -0.06856480f, 0.11224746f, 0.14922374f, 0.00059661f, -0.04713017f, -0.03556688f, 0.00474304f, 
    -0.04333598f, -0.02928691f, -0.00068579f, -0.05193791f, 0.03368337f, 0.07428101f, -0.02699994f, 0.10151552f, 
    0.08436583f, -0.11597288f, 0.03205947f, -0.13578828f, -0.02430920f, -0.09583005f, 0.09175647f, -0.00970692f, 
    0.12200617f, 0.11885184f, 0.00467325f, -0.05890360f, -0.02520439f, 0.15792023f, 0.08262043f, 0.08675149f, 
    -0.07581190f, 0.01218315f, 0.05161463f, -0.04905449f, 0.08127432f, -0.02823019f, -0.00357290f, 0.00851461f, 
    -0.19912876f, 0.08275365f, 0.11259660f, 0.14730355f, -0.03523932f, 0.11012203f, -0.01010723f, -0.09982110f, 
    0.13711365f, 0.05495973f, 0.02070131f, -0.03054287f, -0.21598460f, -0.16051720f, -0.18060826f, 0.00206873f, 
    0.11056913f, 0.07131793f, 0.04593342f, 0.01000572f, 0.03156062f, 0.00674232f, -0.01566811f, -0.05256059f, 
    -0.08923295f, 0.02578062f, -0.06478758f, 0.00345456f, -0.04193113f, 0.14525117f, 0.06398360f, 0.05681765f, 
    0.05054018f, -0.01987191f, -0.00176547f, -0.02718041f, -0.07893800f, -0.00475511f, 0.11882436f, -0.04665150f, 
    -0.01046655f, 0.09031235f, -0.16732392f, -0.03446681f, -0.10440707f, -0.03568775f, 0.00594175f, -0.02540234f, 
    -0.22902936f, 0.06595156f, 0.05034783f, 0.08528727f, -0.17715517f, -0.09748401f, -0.13136792f, 0.07977667f, 
    -0.00829926f, 0.07571653f, 0.07310364f, 0.13699792f, 0.14296852f, 0.24403660f, 0.41789091f, 0.37192869f, 
    -0.10222104f, -0.13438307f, -0.10320115f, -0.02760256f, 0.07108039f, 0.12860875f, 0.04692565f, 0.10951333f, 
    0.09298061f, 0.10879702f, -0.08574403f, -0.07963835f, 0.04620203f, -0.02519955f, 0.06570928f, 0.06734299f, 
    0.08727103f, 0.11766854f, 0.00383983f, 0.11014542f, -0.10525171f, -0.40621313f, 0.25065845f, 0.28608453f, 
    0.03445057f, 0.08246989f, -0.00455591f, 0.00875837f, -0.13750012f, 0.01686865f, 0.05348013f, 0.10344816f, 
    -0.23379041f, -0.13971345f, -0.14432058f, -0.12075867f, 0.10259540f, -0.06425038f, -0.06551446f, 0.03354264f, 
    -0.13278987f, 0.06304026f, -0.01316089f, -0.04521893f, -0.18851882f, -0.14935435f, 0.01497800f, -0.19625935f, 
    0.13653415f, -0.03189047f, -0.07415230f, 0.00132569f, 0.08361446f, 0.04794437f, -0.09258725f, 0.00083146f, 
    -0.04613178f, -0.14222555f, 0.01532311f, 0.01380104f, 0.23685755f, 0.21727695f, 0.30376011f, 0.14794527f, 
    0.07462991f, 0.05509947f, -0.04535331f, -0.06560580f, 0.22108497f, 0.13196115f, -0.15769431f, 0.12090233f, 
    0.04060565f, 0.03666041f, 0.07009625f, 0.05043762f, 0.13096952f, 0.01057175f, 0.01726788f, 0.16653174f, 
    0.13522847f, 0.03528310f, -0.25817424f, 0.03110665f, -0.04790801f, 0.02108723f, -0.01623945f, -0.04537662f, 
    0.21569078f, 0.10778735f, 0.14869516f, -0.07526015f, 0.01465003f, -0.07589485f, -0.10700744f, -0.04457201f, 
    -0.06972903f, -0.06203366f, 0.03902060f, -0.01536810f, -0.00296051f, 0.11369473f, 0.02443573f, 0.04124283f, 
    -0.23117472f, 0.13233113f, 0.16177364f, -0.34072092f, 0.00098895f, 0.01112558f, -0.11930226f, -0.01930059f, 
    0.02715188f, -0.01119172f, 0.15590847f, -0.01452315f, -0.20508745f, -0.12616108f, -0.03671262f, 0.03135963f, 
    0.00185431f, -0.04661381f, -0.04265958f, 0.00759017f, -0.12500648f, -0.04086410f, 0.00742274f, 0.03729780f, 
    -0.20356837f, -0.07969701f, 0.11055076f, 0.09625170f, 0.00176857f, -0.16793744f, 0.06145617f, 0.19956203f, 
    -0.07851606f, -0.02058181f, 0.03228894f, 0.07981674f, -0.13124642f, 0.11952873f, -0.05037612f, -0.02304821f, 
    0.09729666f, 0.07702743f, 0.04403559f, 0.07739262f, -0.02065751f, -0.12885088f, -0.08595627f, 0.02510466f, 
    0.23910497f, 0.04625098f, -0.13520966f, 0.30466810f, 0.00543902f, -0.13600871f, 0.06576534f, 0.04008397f, 
    0.10634837f, 0.07280342f, 0.06691069f, 0.07845873f, 0.18425591f, -0.25276342f, -0.02470336f, 0.05765132f, 
    0.07640588f, -0.01688467f, 0.11773559f, 0.13031484f, -0.12045501f, -0.04387520f, -0.05218176f, -0.08359571f, 
    -0.08183399f, -0.30100760f, -0.01093539f, 0.18084309f, -0.05056910f, -0.10991487f, -0.22567827f, -0.05006248f, 
    0.07756636f, 0.00634475f, 0.08400753f, -0.01012790f, -0.35793132f, -0.16197631f, 0.29845476f, 0.17910229f, 
    -0.07096851f, -0.07447653f, 0.01103244f, 0.01207111f, 0.18892585f, 0.09719788f, 0.19580221f, 0.12521870f, 
    -0.12145016f, 0.00496917f, 0.07411106f, -0.17634729f, -0.07283736f, 0.09060779f, 0.03200044f, -0.07300860f, 
    0.04987009f, 0.09627133f, -0.00017098f, -0.03530267f, 0.00741142f, 0.22549550f, 0.06745534f, -0.06986507f, 
    0.11842630f, 0.06146467f, -0.12989616f, -0.01047338f, -0.07899226f, -0.04380360f, 0.09138768f, 0.01105783f, 
    0.13561207f, 0.14598878f, -0.03038475f, -0.11185681f, 0.00084538f, -0.04551759f, 0.22521892f, -0.02501470f, 
    0.17515236f, 0.08175454f, -0.00128212f, -0.12086717f, 0.25367045f, -0.00997120f, 0.02035015f, -0.13142084f, 
    0.02265875f, -0.00041535f, 0.08921714f, 0.15398201f, -0.11532224f, -0.14673634f, -0.17248741f, -0.16072305f, 
    0.19793713f, -0.08516185f, 0.07364373f, -0.30630749f, 0.07787924f, -0.11558675f, 0.01057843f, 0.07851977f, 
    -0.07181263f, -0.12289863f, 0.12777150f, 0.02459514f, -0.51097310f, 0.12077767f, -0.09566087f, -0.19710986f, 
    0.06737039f, -0.15579121f, 0.07779474f, -0.12058377f, -0.03680276f, 0.19540039f, 0.14006241f, -0.04195493f, 
    0.01238997f, -0.07929050f, -0.03806726f, -0.03328583f, 0.09442701f, -0.05550432f, 0.04891937f, -0.04066525f, 
    0.05678466f, 0.02393484f, 0.01188422f, 0.08821464f, 0.10979794f, 0.08091667f, 0.05033006f, 0.04844284f, 
    0.00779830f, -0.01548711f, -0.02741100f, -0.08617091f, 0.13063912f, 0.09142287f, 0.13654639f, 0.15390974f, 
    0.27255794f, 0.19416347f, -0.03809848f, 0.02222767f, 0.02692409f, -0.02606204f, 0.11612774f, -0.05384482f, 
    0.12661409f, -0.02932878f, -0.11034631f, -0.10881684f, 0.03383157f, 0.14237224f, 0.13264182f, -0.13527685f, 
    0.02247751f, -0.07492081f, 0.04712184f, 0.01655274f, 0.00512813f, -0.00532516f, -0.00160847f, -0.08075193f, 
    -0.13153931f, 0.14032105f, 0.13164762f, -0.03989125f, 0.04699019f, -0.05547213f, 0.02381192f, 0.02004356f, 
    0.08895192f, 0.02492796f, -0.11714204f, -0.06388784f, 0.13817953f, 0.13786457f, -0.08368746f, 0.16617672f, 
    0.05291597f, 0.00857055f, 0.03250188f, -0.00468066f, 0.07347853f, 0.07889106f, -0.03325140f, 0.03219049f, 
    0.04384758f, -0.16691421f, 0.17888021f, -0.06008848f, 0.08581470f, 0.10573257f, -0.00784751f, 0.00722383f, 
    0.05050638f, -0.02124958f, -0.04235622f, -0.07518537f, -0.00223174f, -0.01481116f, 0.22203133f, 0.03457447f, 
    -0.03427687f, -0.00013460f, 0.00739653f, -0.01688390f, -0.02747336f, -0.03202243f, -0.10729325f, 0.00232412f, 
    0.06784367f, -0.17923512f, 0.16588949f, 0.08466621f, 0.09253038f, 0.09701348f, -0.08680896f, 0.03131235f, 
    0.03141726f, 0.06502141f, 0.00774712f, 0.04773072f, 0.59380287f, 0.10627818f, 0.24587940f, 0.23997161f, 
    -0.14518139f, -0.19593544f, -0.02818499f, -0.16251391f, -0.05623396f, 0.05459445f, 0.07857127f, 0.23572344f, 
    0.08984118f, 0.09966379f, -0.06450257f, -0.05970120f, -0.01548513f, 0.02095261f, 0.00224893f, 0.03288696f, 
    -0.00436700f, 0.02992150f, 0.01324124f, -0.09903723f, 0.10037609f, -0.46975794f, 0.26997682f, 0.11305376f, 
    0.09204904f, 0.10193290f, 0.00616757f, 0.01567424f, -0.01128092f, 0.09457961f, -0.15851365f, -0.18592933f, 
    -0.00993712f, 0.06809949f, 0.06497510f, 0.20640832f, 0.00668932f, 0.11079016f, -0.02888241f, 0.05573690f, 
    0.00582959f, -0.01788308f, 0.01746902f, 0.03784672f, -0.08107117f, -0.01300936f, 0.03282070f, 0.07595473f, 
    0.02141883f, 0.05469492f, 0.08883451f, -0.12682104f, 0.03921786f, 0.09282365f, 0.15980379f, 0.17132427f, 
    -0.17446150f, 0.13009594f, 0.13897994f, 0.13816376f, -0.04715707f, -0.00801828f, 0.06060482f, 0.01991107f, 
    0.08908863f, 0.08571880f, 0.01106364f, 0.01716137f, 0.21656339f, -0.02111159f, 0.00711192f, 0.22753438f, 
    0.06867138f, 0.13668270f, 0.06982492f, 0.10707185f, -0.08580544f, -0.05961701f, -0.04450569f, -0.02737398f, 
    -0.02021141f, 0.02257601f, 0.06680159f, 0.03919764f, -0.02959134f, 0.06296731f, 0.03769428f, 0.00684818f, 
    -0.12323217f, -0.05349980f, -0.14981446f, -0.12442105f, -0.03994412f, -0.02752860f, -0.09419376f, -0.16223522f, 
    -0.18405095f, -0.04199200f, -0.06446192f, 0.01829321f, -0.10772190f, -0.07844819f, -0.15850715f, -0.13661596f, 
    -0.19939139f, 0.15009545f, 0.21911296f, 0.18283325f, -0.02175435f, 0.02090299f, -0.10441856f, -0.03269750f, 
    -0.14076152f, -0.03167484f, -0.02964754f, 0.28680968f, 0.08061492f, -0.24554549f, -0.26453087f, -0.02048673f, 
    0.18372777f, 0.13255145f, 0.04390528f, 0.15397595f, 0.10713471f, 0.08665178f, -0.04321326f, 0.03656710f, 
    0.18742453f, -0.12327176f, -0.12192278f, -0.02316929f, 0.12682736f, 0.08107206f, -0.01031700f, -0.04879605f, 
    -0.00252168f, -0.03451135f, -0.01804674f, -0.00429562f, -0.11342912f, 0.07953768f, 0.06804340f, -0.00908023f, 
    -0.13424006f, -0.17190400f, 0.00667603f, -0.02789596f, 0.05773381f, -0.03127607f, 0.01710171f, 0.05701642f, 
    0.14515786f, 0.06979295f, 0.12546359f, -0.09109928f, -0.05716275f, 0.06990930f, -0.05299269f, -0.13530453f, 
    -0.07842056f, 0.09601044f, 0.11051873f, 0.16379438f, 0.13919881f, 0.05963860f, -0.13779208f, 0.03248041f, 
    -0.04740734f, 0.08094946f, 0.10636672f, 0.06951312f, 0.03040754f, 0.03491253f, 0.17250241f, 0.13132967f, 
    0.12502542f, 0.10615005f, -0.32254040f, -0.08785641f, 0.06160861f, 0.19681925f, 0.10173215f, 0.06744788f, 
    -0.03437047f, -0.06660326f, -0.13944679f, 0.02334120f, -0.07816290f, -0.14461014f, -0.48041663f, -0.36899883f, 
    0.06225147f, 0.15142450f, -0.05456347f, -0.06931140f, 0.06024385f, 0.04714658f, -0.01226374f, -0.15522094f, 
    -0.22452775f, -0.16406731f, 0.18944238f, 0.10608289f, 0.06003444f, 0.09403341f, -0.03850426f, 0.14359067f, 
    -0.08735865f, -0.01443775f, 0.03782313f, 0.03862973f, 0.07381833f, 0.34140414f, -0.02982098f, -0.22390234f, 
    -0.06470142f, -0.00307453f, -0.06160541f, -0.06347910f, 0.03756661f, 0.01027348f, -0.03361395f, 0.13843282f, 
    0.13913310f, 0.02264747f, -0.17554180f, -0.14456187f, 0.02446433f, 0.00292630f, 0.05202487f, 0.05944774f, 
    0.06722088f, -0.06626583f, 0.08466126f, -0.11263425f, -0.14645620f, -0.22266239f, -0.05352788f, -0.03149511f, 
    0.02835914f, 0.20680177f, -0.09264439f, 0.03459049f, -0.05216618f, 0.05138173f, -0.05433498f, -0.00125088f, 
    -0.04218342f, 0.11375938f, 0.06523844f, -0.09985177f, -0.16989185f, -0.12464216f, 0.03338205f, -0.15418296f, 
    -0.13493446f, -0.07395900f, 0.13699603f, -0.00315884f, -0.06638291f, -0.14309795f, 0.08029117f, 0.01934502f, 
    0.12825651f, 0.08877069f, -0.00899128f, 0.12854342f, -0.13120005f, 0.02800060f, 0.10905441f, 0.09919294f, 
    0.13111694f, -0.02606797f, 0.03213073f, 0.02518722f, 0.15046023f, 0.08993549f, 0.04787166f, 0.04986769f, 
    0.09585864f, 0.10778501f, 0.03192672f, 0.09720831f, -0.11198372f, -0.09870780f, -0.05295705f, -0.13610724f, 
    0.03259256f, -0.05988539f, -0.01394804f, -0.04089483f, -0.05667342f, 0.10465983f, 0.13325487f, -0.03664585f, 
    -0.14653994f, -0.04018426f, -0.03181179f, 0.01702106f, 0.00136083f, -0.07629515f, -0.04687747f, 0.04905341f, 
    -0.12436394f, 0.06753074f, 0.06209973f, 0.14478301f, 0.20368908f, 0.17221704f, 0.25145683f, 0.39025840f, 
    0.06179184f, -0.10019799f, -0.04917097f, 0.08988876f, 0.12238208f, 0.08329712f, 0.28231099f, 0.00989523f, 
    0.30687249f, 0.08489671f, -0.01942269f, 0.03543502f, 0.08900333f, 0.00296935f, -0.08868465f, -0.16856255f, 
    0.18301857f, 0.14249757f, -0.01565696f, 0.02959517f, -0.14287435f, -0.14477903f, -0.16341007f, -0.25426120f, 
    -0.04111438f, -0.00453071f, -0.07645100f, 0.05106095f, -0.07807603f, -0.01924426f, -0.04505581f, 0.01861573f, 
    -0.11689112f, -0.10229634f, -0.14065294f, -0.24744639f, -0.05531591f, -0.09690262f, -0.06308077f, -0.05057222f, 
    0.06424433f, 0.01767123f, -0.14817032f, -0.08435809f, 0.04608543f, 0.18697454f, -0.10410146f, 0.23923957f, 
    -0.15349090f, -0.15799499f, -0.01567575f, 0.07491440f, -0.08877126f, -0.06844613f, 0.06015789f, 0.10632575f, 
    0.06729261f, 0.10954706f, -0.04767369f, 0.16852908f, -0.10892951f, 0.08908331f, 0.07476775f, 0.11479376f, 
    0.35651082f, 0.08563042f, -0.04054265f, 0.06969839f, 0.15504666f, -0.02551605f, -0.16415687f, 0.06273825f, 
    -0.00222433f, -0.02464255f, 0.09899592f, -0.01588495f, -0.07947760f, 0.09141939f, 0.07492512f, 0.04316089f, 
    -0.00115905f, 0.05628594f, 0.18568017f, -0.01143537f, 0.06316867f, 0.05963095f, 0.10516418f, 0.15563764f, 
    0.03654139f, 0.02060820f, 0.09085117f, 0.32339510f, -0.11456793f, 0.01224312f, -0.01106904f, 0.10150987f, 
    0.01705317f, -0.03411163f, -0.03485233f, -0.00559041f, -0.00988648f, 0.05183998f, -0.10795782f, 0.02894749f, 
    0.05724623f, -0.07491691f, -0.05792195f, -0.04057960f, -0.07385840f, 0.05027151f, -0.05109823f, -0.01721911f, 
    -0.00924317f, 0.05903318f, -0.07809401f, 0.03221022f, -0.05970339f, 0.00901204f, -0.00293386f, 0.00984486f, 
    0.06079821f, 0.00390976f, -0.01441002f, 0.02120373f, -0.05984171f, 0.06199323f, 0.00619137f, -0.05829260f, 
    -0.01204806f, 0.01511030f, -0.04387472f, 0.03402404f, -0.03315251f, 0.03529017f, -0.04583402f, 0.04186245f, 
    -0.05243245f, -0.06814513f, -0.03919652f, -0.02099795f, 0.00954269f, 0.02869244f, -0.04103649f, 0.03547009f, 
    0.02756276f, -0.01656984f, 0.04904277f, 0.05768310f, 0.01916181f, 0.05004896f, 0.04874948f, 0.01007561f, 
    -0.04046366f, -0.02714079f, -0.01137350f, -0.08023236f, -0.04723844f, -0.05648495f, 0.05753265f, 0.02743712f, 
    0.02540060f, -0.01197710f, -0.00961172f, -0.07020605f, 0.00068269f, 0.05911968f, -0.07718143f, -0.02807290f, 
    0.01238833f, 0.01587414f, -0.06789016f, 0.05583744f, -0.02591903f, -0.02074676f, 0.00620708f, -0.02890538f, 
    0.03209644f, -0.07019912f, -0.03029256f, -0.01988897f, 0.06222440f, -0.02145281f, -0.00043717f, -0.02701977f, 
    -0.06087612f, 0.04153455f, -0.00327670f, -0.05942756f, -0.06619813f, -0.04397522f, -0.07509688f, 0.04039149f, 
    0.02402943f, -0.02194215f, -0.03654913f, 0.05538806f, 0.03384167f, -0.04066610f, -0.03841574f, -0.01072558f, 
    -0.03470615f, -0.07298031f, -0.01147477f, -0.05128337f, 0.05430550f, -0.07749416f, -0.07058293f, -0.05447856f, 
    0.05456205f, -0.04507227f, -0.06181811f, -0.06577761f, -0.07500314f, -0.04006605f, 0.05789136f, -0.01611253f, 
    -0.06704447f, -0.03492640f, -0.03661346f, -0.04998256f, 0.03127717f, -0.07367973f, 0.02210845f, 0.04413602f, 
    0.04810697f, 0.03744233f, 0.04109300f, 0.04440691f, -0.02301719f, 0.04865206f, 0.04990035f, 0.05583812f, 
    -0.07971209f, 0.05157793f, -0.01614254f, -0.04903796f, -0.00837336f, 0.00050170f, -0.06570008f, 0.04949284f, 
    -0.06964044f, 0.05109435f, 0.01985684f, 0.03624712f, 0.02932220f, 0.06690276f, 0.03362972f, -0.06995483f, 
    0.02672839f, -0.02375651f, -0.03720830f, 0.05443566f, 0.04617953f, -0.04337720f, -0.02984449f, 0.00823663f, 
    -0.00978512f, -0.05183259f, -0.05806282f, -0.01721332f, -0.01030076f, 0.04877215f, -0.02254394f, 0.00616988f, 
    0.02104129f, -0.06667113f, -0.05127739f, -0.04834928f, -0.03786324f, 0.04332496f, 0.02469987f, 0.00666542f, 
    -0.07600561f, -0.06365407f, -0.03701744f, 0.03042733f, 0.02585567f, -0.04032029f, -0.02593559f, 0.00146517f, 
    -0.03045732f, 0.05695004f, 0.00660040f, -0.05191067f, 0.04712429f, -0.01789567f, -0.06292672f, 0.03964563f, 
    0.03081143f, -0.03049464f, -0.07113332f, -0.04442861f, 0.05995372f, -0.00457894f, 0.01879545f, -0.06148931f, 
    0.04138039f, -0.12009133f, 0.14492248f, -0.10504746f, -0.08874183f, 0.04053667f, -0.20445810f, 0.06300887f, 
    0.01990650f, 0.01952833f, 0.05416443f, -0.11806851f, 0.03584809f, -0.05074529f, -0.22802231f, -0.14982180f, 
    -0.07302147f, 0.08900844f, 0.03445917f, -0.17704250f, -0.00181404f, -0.16394810f, -0.12271045f, -0.13979340f, 
    0.24005099f, 0.15111926f, 0.17201944f, -0.08955178f, 0.20388086f, 0.02724056f, -0.07210124f, 0.23427863f, 
    -0.09984939f, -0.09286951f, -0.04301616f, -0.00145190f, -0.33197519f, -0.10022027f, -0.27023587f, -0.26159278f, 
    -0.05825802f, -0.13107085f, 0.24032976f, 0.04379483f, 0.05783392f, 0.08267294f, 0.06027118f, -0.11144723f, 
    0.20416009f, -0.00107680f, 0.12080756f, 0.11925201f, -0.10239471f, 0.05419274f, 0.09690648f, 0.10100567f, 
    0.22032027f, -0.00990500f, 0.02125392f, 0.01291060f, 0.08297995f, 0.07857474f, 0.19332604f, 0.23376444f, 
    -0.00095181f, -0.04566146f, -0.08716323f, -0.03938491f, 0.09918607f, -0.02494464f, 0.06907041f, 0.14212382f, 
    0.27072325f, 0.33842456f, 0.09438351f, 0.48737565f, 0.00290535f, -0.14767607f, 0.02207804f, -0.07436673f, 
    -0.07719420f, -0.13643298f, -0.20547956f, -0.20382345f, 0.00203878f, -0.38789034f, -0.24422891f, -0.36287263f, 
    0.06960648f, -0.01835280f, 0.02704216f, 0.04723951f, -0.00263766f, 0.13399915f, -0.00760818f, 0.11681926f, 
    -0.13217394f, -0.23845860f, -0.18951224f, -0.28924730f, 0.12304641f, -0.08392626f, -0.09653513f, 0.07761656f, 
    -0.05728422f, -0.05580822f, 0.06668282f, 0.11344419f, 0.34408745f, 0.17978665f, 0.05490238f, 0.12828872f, 
    0.04930163f, -0.06572776f, 0.03229315f, 0.01762126f, -0.08072606f, -0.11714002f, -0.01833215f, -0.05448033f, 
    -0.03498699f, 0.22860837f, 0.22540152f, 0.12158930f, -0.01384809f, 0.06556449f, -0.12933113f, -0.04591939f, 
    -0.09193600f, -0.06913581f, -0.14582233f, -0.03390983f, -0.21735074f, 0.07917686f, 0.06195341f, -0.00809853f, 
    0.04412273f, 0.15843993f, -0.03666805f, 0.12243396f, -0.00403376f, -0.05255383f, -0.07086971f, -0.00359873f, 
    0.13187264f, 0.00435317f, -0.03812667f, -0.05638123f, 0.02512032f, 0.10024934f, 0.16013548f, 0.01890540f, 
    0.06962865f, 0.11553924f, 0.13984397f, -0.01959690f, 0.26440111f, -0.15556261f, -0.20954491f, -0.09532093f, 
    -0.07546150f, -0.04488412f, -0.17499520f, -0.09248345f, 0.05033255f, -0.06867717f, -0.05028243f, 0.09951056f, 
    0.00033070f, 0.08457797f, -0.11292152f, 0.46597940f, -0.21011956f, 0.01167484f, 0.15839298f, 0.25155216f, 
    -0.04079244f, -0.00639875f, -0.01963002f, 0.05754653f, 0.08671620f, 0.00928619f, 0.21713020f, 0.04104140f, 
    0.03990865f, 0.08683296f, -0.05017440f, -0.11745942f, -0.01634803f, -0.03011178f, -0.06060451f, -0.02077309f, 
    0.03821142f, 0.14533666f, -0.28152397f, -0.25439364f, -0.01659483f, 0.00426500f, -0.23684496f, 0.02239421f, 
    -0.04874065f, 0.12949422f, -0.05928796f, -0.04530409f, -0.06783614f, 0.02862060f, -0.23301038f, -0.05724360f, 
    0.12456796f, -0.19305037f, -0.15584724f, -0.16602924f, 0.01079152f, -0.12454651f, -0.32862124f, -0.24137799f, 
    -0.12011729f, -0.72527331f, 0.09448042f, -0.13412817f, 0.19177774f, -0.03725310f, -0.09472300f, -0.07397879f, 
    0.02238443f, -0.02214434f, -0.17723301f, -0.03500829f, 0.16268891f, -0.07682052f, -0.02946147f, 0.13416372f, 
    -0.15688926f, -0.06752102f, -0.02065795f, -0.02440569f, 0.12726024f, 0.01429487f, -0.01039912f, -0.04031892f, 
    -0.10908359f, -0.04354088f, 0.13021733f, 0.10467628f, 0.01905386f, 0.07397483f, 0.06566803f, 0.18283622f, 
    0.24189427f, 0.14563005f, 0.15593079f, 0.03614514f, -0.06595793f, -0.24203950f, -0.18035801f, 0.16122426f, 
    0.07414755f, 0.08910671f, -0.07786799f, 0.02304355f, 0.05164696f, 0.12714435f, 0.13074714f, 0.26563713f, 
    -0.18588038f, 0.21646239f, -0.38534862f, 0.10930859f, 0.19989808f, -0.12952071f, -0.16911232f, 0.11690242f, 
    0.13809478f, -0.00272596f, 0.10056309f, -0.01814093f, 0.01249253f, -0.01498388f, -0.04946749f, -0.26291606f, 
    0.13314067f, 0.07961781f, -0.06507663f, -0.02469000f, -0.10061175f, 0.02528292f, 0.09253218f, 0.28886616f, 
    -0.05909025f, 0.20084603f, 0.04272397f, -0.02215682f, 0.03366080f, -0.00699239f, 0.20273520f, 0.35634238f, 
    -0.16836561f, -0.10370701f, 0.23771314f, 0.19527356f, -0.17628659f, -0.09265260f, -0.04022622f, 0.31310600f, 
    0.19165203f, -0.07984745f, -0.10665545f, -0.15584812f, -0.02918160f, -0.04679174f, 0.12228849f, -0.04124749f, 
    -0.07113307f, -0.06173282f, 0.02667498f, 0.13741690f, -0.03940634f, -0.21075967f, -0.22124407f, 0.09605147f, 
    0.08832901f, -0.01597516f, 0.09887517f, 0.06685840f, 0.35886174f, 0.07517928f, 0.28515986f, -0.15771429f, 
    0.27358156f, 0.08031155f, 0.21130091f, 0.13061574f, -0.08227993f, 0.00055330f, -0.32130215f, -0.11608729f, 
    0.42442080f, 0.04612169f, 0.33255205f, -0.08997805f, 0.13306642f, 0.03963282f, 0.03697246f, -0.05369463f, 
    0.14737782f, -0.07794636f, 0.12143821f, 0.17379616f, -0.26530725f, -0.11136337f, 0.14713673f, -0.12629452f, 
    0.13266158f, -0.11148258f, 0.13046780f, 0.25801381f, -0.01839298f, 0.02021267f, 0.02758649f, 0.06466719f, 
    0.12543920f, 0.24465647f, -0.00351212f, 0.01070111f, 0.07116914f, -0.03405125f, 0.07918855f, -0.20108485f, 
    0.06215680f, 0.09688297f, 0.07860095f, 0.01289988f, 0.29791030f, 0.29692623f, 0.34555253f, -0.12733075f, 
    -0.15321958f, -0.18236604f, -0.04573945f, 0.05431308f, -0.07531837f, -0.14002384f, -0.01598255f, -0.10182815f, 
    0.06476519f, 0.00666044f, 0.04422921f, 0.15001146f, 0.12623237f, 0.12861601f, 0.02270056f, -0.04372824f, 
    0.19593383f, 0.03555518f, 0.01664746f, 0.21110390f, 0.15343715f, -0.09670281f, -0.01900297f, 0.05725544f, 
    0.11982740f, 0.13510105f, 0.15466399f, 0.06323105f, 0.09336158f, 0.10811804f, 0.05746073f, 0.21937311f, 
    0.01597745f, 0.16094068f, -0.13416532f, -0.18155529f, -0.00713059f, 0.13636200f, -0.15027404f, 0.00748762f, 
    -0.00486232f, -0.06939759f, 0.07015033f, -0.00910982f, -0.30750665f, 0.11340658f, 0.07272723f, -0.06356586f, 
    0.15532011f, 0.05634296f, 0.04942747f, 0.15229848f, -0.06043770f, 0.10006199f, -0.03040008f, 0.09381110f, 
    -0.07232501f, -0.12647809f, 0.08041620f, -0.20544887f, -0.01689962f, 0.03967062f, -0.00540080f, -0.09309196f, 
    -0.28356564f, -0.00193944f, -0.15175761f, -0.11788750f, -0.06198667f, -0.04634470f, 0.00911655f, -0.08581287f, 
    -0.05923546f, -0.15088500f, -0.06651624f, -0.14211465f, -0.14557293f, -0.14627710f, -0.18145183f, -0.19331348f, 
    0.51942855f, -0.19294623f, 0.26796862f, 0.05432850f, -0.10204324f, -0.09654935f, 0.02281213f, -0.20612733f, 
    -0.19243009f, 0.09467515f, -0.11199016f, 0.16258112f, 0.27607101f, 0.19344671f, 0.16535546f, 0.13660122f, 
    0.06319722f, 0.04628342f, 0.13361788f, 0.06762245f, 0.14176261f, 0.06411160f, -0.06623827f, -0.25221252f, 
    0.18689576f, 0.23977560f, 0.08529849f, -0.00409115f, 0.16201034f, 0.12261204f, 0.03938952f, -0.12269962f, 
    0.11648055f, 0.07490091f, -0.12576565f, -0.18311031f, -0.07804975f, -0.05635915f, 0.02832517f, 0.00952003f, 
    -0.20594764f, -0.09588300f, 0.04544811f, -0.10706582f, -0.05130010f, 0.00945956f, -0.10965399f, -0.03840147f, 
    0.00350962f, -0.10571612f, 0.22548610f, -0.04483262f, 0.00089436f, 0.13776632f, 0.06047375f, 0.00240189f, 
    -0.04822780f, -0.01432607f, 0.01132369f, 0.10028509f, -0.18632746f, 0.14645226f, -0.04095795f, -0.01492692f, 
    -0.08323900f, 0.08868584f, -0.08717878f, -0.09738386f, 0.11730032f, -0.06645346f, 0.16885076f, 0.15644658f, 
    -0.38310963f, 0.19895124f, -0.09827433f, -0.07501906f, 0.03575890f, 0.01236480f, 0.06544329f, 0.00998424f, 
    -0.06833862f, 0.09317993f, -0.05299408f, -0.14181107f, 0.18826547f, 0.06146410f, -0.04266167f, -0.00966471f, 
    -0.05039643f, 0.01672477f, -0.08119378f, -0.18796803f, 0.11155982f, 0.08053077f, 0.03140324f, 0.13892570f, 
    0.12986779f, -0.21541156f, 0.04658787f, -0.23077568f, -0.07695367f, 0.00537697f, -0.14806783f, 0.04475350f, 
    0.09603588f, -0.00316775f, -0.10081250f, 0.01870961f, 0.03327689f, -0.21462636f, -0.07779013f, 0.18609208f, 
    -0.17457554f, 0.00497754f, 0.07181448f, 0.06646917f, 0.05977025f, -0.02213016f, -0.03820957f, 0.08022889f, 
    0.07335299f, 0.16015606f, -0.18046230f, -0.18346769f, 0.02907810f, -0.05209685f, -0.01407875f, -0.20829272f, 
    0.00533353f, 0.05719469f, -0.20814800f, -0.12525068f, 0.08083866f, 0.07965589f, -0.14432143f, 0.17231381f, 
    0.19229852f, 0.06589131f, -0.08041670f, -0.03003354f, -0.11123741f, -0.16995259f, 0.00044875f, -0.18039384f, 
    -0.01562948f, 0.11612986f, -0.05767256f, 0.02838951f, -0.31239584f, -0.13033698f, 0.10991663f, -0.29311454f, 
    -0.02912403f, 0.14282556f, 0.02811665f, 0.07345129f, 0.05960967f, -0.04724256f, 0.20096125f, 0.06895784f, 
    0.16011740f, 0.13182753f, -0.20426370f, -0.16777851f, -0.02951258f, -0.14084792f, -0.02793218f, 0.10243728f, 
    -0.11570197f, 0.00072740f, 0.15022166f, -0.06778154f, 0.08965475f, -0.05683559f, -0.10219869f, -0.06946360f, 
    0.05573993f, 0.09997189f, 0.17870371f, 0.21614537f, -0.12338585f, -0.17773326f, -0.08301966f, -0.00373029f, 
    0.03995369f, -0.08056730f, 0.05832042f, 0.09060144f, 0.17535910f, 0.16779797f, 0.20501922f, 0.15253672f, 
    0.09234548f, -0.13537806f, -0.35618773f, -0.09637267f, 0.08174261f, 0.00531017f, 0.01374402f, 0.02211688f, 
    -0.06754453f, 0.15107892f, 0.15458672f, 0.01354717f, 0.21960567f, 0.23455733f, 0.22923468f, 0.19861732f, 
    0.04649524f, -0.03778824f, -0.06108348f, -0.10776787f, -0.00608335f, -0.06261348f, 0.28287920f, 0.05483062f, 
    0.25108987f, 0.19330852f, 0.08705787f, 0.03489473f, -0.00250541f, 0.09322992f, -0.10345051f, -0.16231140f, 
    -0.07164030f, -0.01475845f, 0.03282525f, -0.03958418f, -0.14231732f, -0.12297514f, -0.18663484f, -0.07126518f, 
    0.07742200f, 0.03128671f, -0.12019435f, 0.09349115f, 0.09217891f, 0.07500321f, 0.00328774f, 0.10071520f, 
    -0.20646280f, -0.28838623f, -0.17776693f, -0.33509126f, -0.06329463f, -0.02925935f, -0.08382933f, 0.03530651f, 
    -0.05881928f, -0.01298870f, -0.05019274f, -0.18789950f, 0.18122445f, 0.40562651f, 0.10378099f, 0.21238966f, 
    -0.00570152f, -0.18108784f, 0.10094524f, -0.07999697f, -0.07794499f, -0.04611768f, -0.08423617f, -0.02404992f, 
    0.29647380f, 0.16223121f, 0.10369152f, 0.04049670f, -0.00864847f, 0.27822161f, 0.20327047f, -0.01387997f, 
    0.06781214f, -0.05726105f, -0.12020378f, 0.04465979f, 0.20646648f, 0.01285264f, -0.16650593f, 0.11430237f, 
    0.16431773f, -0.04750746f, 0.21787766f, 0.04835413f, -0.10276247f, -0.01685821f, 0.02216703f, 0.05798811f, 
    0.15112153f, 0.15525220f, 0.02330103f, 0.00862692f, -0.03299454f, 0.14899978f, -0.00466468f, 0.09965020f, 
    -0.03638177f, 0.02659309f, 0.10051954f, 0.05739296f, -0.08924235f, -0.00620175f, -0.25316778f, -0.20310158f, 
    0.00324251f, -0.11215292f, -0.00211820f, 0.08849312f, -0.11693785f, 0.03072007f, -0.02367945f, 0.07577149f, 
    0.04353340f, -0.05894655f, -0.23252597f, -0.05901704f, 0.04182053f, 0.10948082f, -0.14128764f, 0.00479125f, 
    0.04896123f, 0.07145202f, -0.07698997f, 0.00723278f, -0.00587141f, -0.02558593f, -0.26887742f, -0.30263382f, 
    0.04918119f, -0.10084047f, -0.05733526f, -0.11282539f, 0.06900528f, 0.04355925f, -0.16889456f, -0.09311823f, 
    0.30439860f, -0.65699887f, -0.06413809f, -0.22321078f, 0.05757242f, 0.06355441f, -0.09134297f, 0.04165974f, 
    0.06459201f, 0.06389360f, -0.24418575f, -0.15765296f, -0.07721678f, -0.04816557f, -0.16430064f, -0.11219796f, 
    -0.01416675f, -0.17442575f, -0.07705338f, 0.01827435f, 0.11330974f, 0.07926905f, -0.00796503f, -0.03866221f, 
    -0.13463919f, -0.09542085f, 0.01846383f, 0.12642215f, -0.03488095f, 0.06525071f, 0.05125226f, 0.37828287f, 
    0.12342896f, 0.04441497f, 0.03751786f, -0.05203200f, -0.14656472f, -0.27443761f, -0.19996011f, 0.12769218f, 
    0.06810962f, 0.19865899f, -0.05070253f, 0.00989706f, 0.02129707f, 0.06496379f, 0.05686248f, 0.12171503f, 
    -0.30422863f, 0.15251157f, -0.29137596f, 0.03398944f, 0.13531378f, -0.15358448f, -0.12174531f, -0.05464656f, 
    0.15779631f, 0.12861700f, 0.08653095f, -0.09062130f, 0.01770698f, 0.05390977f, 0.00722999f, -0.28255588f, 
    0.18253499f, 0.16625457f, 0.06006419f, 0.06091240f, -0.06532861f, -0.01941563f, -0.02149633f, 0.12403324f, 
    -0.11597671f, 0.15942429f, 0.18924980f, -0.07519970f, -0.00880711f, 0.02475521f, 0.12232933f, 0.27188057f, 
    -0.11416185f, -0.02853484f, 0.18003035f, 0.06871625f, -0.26313630f, -0.40499040f, -0.18181832f, 0.27818754f, 
    0.17230923f, -0.00404890f, -0.03199778f, -0.06538790f, 0.04173457f, 0.01374800f, 0.18661664f, -0.12826088f, 
    -0.17835239f, -0.11115950f, -0.09361748f, 0.24117479f, -0.03941550f, -0.06307592f, -0.05150682f, -0.02929099f, 
    0.15793596f, 0.02483105f, 0.14804278f, 0.01221063f, 0.39098778f, 0.02727455f, 0.19086780f, -0.10014601f, 
    0.19102322f, 0.11337136f, 0.20939749f, 0.12656081f, -0.10990345f, -0.03705641f, -0.11910648f, -0.00927565f, 
    0.29094934f, 0.13828027f, 0.45894682f, 0.05088455f, 0.09800451f, -0.12912917f, 0.07561605f, -0.08356465f, 
    0.19022173f, -0.04594354f, 0.08339036f, 0.09806866f, -0.23544823f, -0.27917847f, -0.02331324f, 0.07502310f, 
    0.07552051f, -0.14295311f, -0.11646532f, 0.00674821f, 0.10854363f, 0.00341537f, 0.03942508f, 0.08845654f, 
    0.17380466f, 0.30594695f, -0.06247139f, -0.01516329f, 0.03260993f, 0.05748038f, 0.15673594f, -0.04946625f, 
    -0.00616812f, 0.12359325f, 0.02337968f, -0.05246173f, 0.05790192f, 0.03698121f, 0.47274259f, 0.04193370f, 
    -0.15686181f, -0.02923090f, -0.08706838f, -0.09594306f, -0.09020994f, -0.02502832f, -0.04188752f, -0.04680950f, 
    0.13435131f, 0.00548797f, -0.14850231f, -0.03565247f, -0.05501860f, -0.23624505f, 0.06953280f, 0.14178629f, 
    -0.04197175f, -0.00874717f, -0.09121808f, -0.08956539f, -0.05075569f, 0.01197493f, 0.00342634f, 0.11306591f, 
    0.04236233f, 0.13728504f, -0.01684676f, -0.13450630f, 0.16325581f, -0.05868991f, 0.25068298f, 0.14097705f, 
    -0.05342684f, 0.22831453f, 0.20027460f, 0.16891880f, 0.01954603f, 0.06872611f, -0.00993815f, -0.07506985f, 
    0.22510324f, -0.00161859f, 0.09049962f, 0.04472525f, 0.09557246f, -0.01550726f, 0.04146964f, 0.16808471f, 
    0.03358338f, 0.00838251f, -0.03664103f, 0.15709800f, 0.00933333f, -0.13539600f, -0.15602341f, 0.05565937f, 
    -0.02875339f, 0.06353664f, -0.02687541f, 0.06166539f, -0.04412583f, -0.01978810f, -0.07698137f, -0.00210698f, 
    -0.01959335f, -0.13176921f, -0.16768499f, -0.30130386f, 0.09536547f, -0.04287693f, 0.06002374f, -0.00453799f, 
    -0.03629853f, 0.00941072f, -0.10247710f, 0.05728855f, -0.07714993f, -0.12102544f, 0.05969592f, -0.01640666f, 
    -0.13302439f, 0.34352660f, 0.02573987f, 0.14388604f, 0.03694808f, 0.14194383f, -0.05999167f, -0.02035438f, 
    0.10865150f, -0.11395928f, 0.06374783f, -0.08146759f, -0.14053096f, -0.15358381f, -0.01485070f, 0.15274741f, 
    0.06722270f, 0.00162732f, -0.15281825f, -0.00412654f, 0.07670950f, -0.02237158f, 0.04650386f, 0.13448915f, 
    -0.01309448f, -0.19569464f, -0.13663737f, 0.01136188f, -0.02727429f, -0.00747213f, 0.03657372f, 0.05303812f, 
    -0.02388358f, -0.07561713f, 0.02912874f, 0.24838531f, -0.01615765f, 0.05724808f, 0.02179579f, 0.12233140f, 
    -0.03298870f, -0.06668387f, 0.00284001f, -0.06501372f, 0.12021089f, 0.02854056f, 0.08475720f, 0.11140663f, 
    0.03782432f, 0.07810886f, 0.01795970f, 0.02698399f, 0.16527525f, -0.12176467f, -0.16828597f, 0.03273770f, 
    -0.07685392f, 0.08887944f, 0.08224801f, 0.06012792f, 0.25804120f, 0.07073539f, 0.26790410f, 0.17380500f, 
    0.02399017f, 0.17880897f, 0.09078263f, 0.03888870f, -0.09208697f, 0.09589148f, -0.01490211f, 0.01398947f, 
    0.19494796f, -0.14146751f, -0.11860551f, -0.11378599f, 0.06019256f, 0.06427118f, 0.13268802f, 0.01506610f, 
    -0.10292206f, -0.02032793f, 0.03973677f, 0.00963368f, 0.07858088f, -0.41254559f, -0.37889761f, -0.35856423f, 
    -0.00700918f, -0.01662944f, 0.02071187f, 0.03804778f, 0.05536351f, -0.04986679f, -0.07699105f, -0.16949192f, 
    -0.06730669f, 0.32852697f, 0.22085847f, 0.26141477f, 0.04634633f, -0.00278729f, -0.03364906f, -0.04236091f, 
    -0.15992229f, -0.15613468f, 0.13977189f, -0.02007992f, 0.24599595f, 0.28852776f, 0.23492618f, -0.38122118f, 
    -0.04909056f, -0.12501684f, 0.02721215f, 0.01101134f, 0.10578649f, 0.01926089f, -0.08268271f, 0.18126684f, 
    -0.06667443f, 0.00165410f, 0.03111362f, -0.01510917f, 0.00673774f, -0.07678778f, -0.03461572f, 0.01720444f, 
    -0.00768912f, 0.02559202f, -0.01114565f, 0.03089784f, -0.03421103f, 0.02386273f, -0.00065084f, 0.01316497f, 
    -0.02749484f, -0.07360873f, -0.04599912f, -0.00553715f, 0.01940881f, -0.06528412f, 0.02061092f, -0.05968481f, 
    0.05552399f, 0.05166938f, 0.04870075f, -0.03629270f, 0.05123106f, 0.01481573f, 0.00789086f, -0.02526131f, 
    -0.05800184f, -0.06921193f, 0.02300646f, -0.05576805f, -0.06145208f, -0.06344508f, -0.02451605f, -0.07631863f, 
    -0.00236727f, 0.02614981f, -0.07578862f, 0.04074130f, -0.04357383f, 0.00857331f, -0.05861030f, -0.04484486f, 
    -0.06690478f, -0.07055891f, -0.03898539f, 0.06462738f, 0.05094229f, -0.01024632f, -0.01965411f, -0.02112844f, 
    -0.06578477f, -0.07582477f, 0.04754661f, -0.05668572f, -0.00366260f, -0.00927260f, 0.00489536f, 0.02202595f, 
    -0.05639336f, -0.00978983f, -0.02814361f, 0.05789784f, 0.06106003f, -0.04734716f, 0.03193114f, -0.03298347f, 
    0.05171260f, 0.00400749f, -0.04971301f, -0.07551266f, 0.00175409f, -0.02142147f, 0.01961205f, -0.02464874f, 
    0.03822180f, -0.04117098f, -0.05028678f, -0.06016045f, 0.03916669f, -0.00547490f, -0.01112048f, -0.02296777f, 
    -0.00989661f, 0.02309873f, -0.02212251f, -0.04322013f, -0.00006327f, -0.07251565f, -0.00045687f, -0.00738721f, 
    0.02556337f, 0.04785996f, -0.04430450f, 0.05184839f, -0.07509527f, 0.05423084f, 0.00080435f, 0.00049942f, 
    0.01309782f, -0.06575049f, -0.06809392f, 0.04498845f, -0.05847609f, -0.00792675f, -0.01021720f, -0.06280451f, 
    0.06394072f, 0.04296682f, -0.07419508f, -0.04750727f, -0.03249409f, -0.06266961f, -0.03790843f, 0.04295423f, 
    -0.04663775f, -0.00851173f, -0.04986295f, 0.06126380f, 0.05545824f, -0.01134213f, -0.02793531f, 0.01805042f, 
    -0.00775875f, -0.06450191f, 0.02693171f, -0.00581126f, -0.06770969f, -0.02218079f, 0.04479229f, -0.01120301f, 
    -0.04394474f, -0.02819965f, 0.03840095f, 0.00990151f, 0.03139777f, 0.03599910f, 0.02989034f, -0.07060483f, 
    -0.06595413f, 0.06342480f, -0.01026395f, -0.06493982f, 0.00684284f, -0.03432415f, 0.03400460f, 0.05254593f, 
    -0.05365308f, -0.02141803f, -0.01111347f, -0.02652967f, 0.01545343f, 0.01632258f, 0.05425006f, -0.07071452f, 
    -0.04694324f, -0.00065861f, -0.05727169f, 0.00647775f, -0.04940473f, 0.03242141f, 0.05360485f, -0.01236849f, 
    0.03964426f, -0.00675410f, 0.03312714f, -0.02925316f, 0.00419886f, 0.04723432f, 0.02080158f, 0.01102320f, 
    0.03382867f, -0.05666184f, -0.02774480f, -0.04874399f, -0.01015576f, 0.04276042f, 0.04028624f, -0.06101664f, 
    -0.02275692f, -0.06411559f, 0.03006306f, 0.01378147f, 0.05427178f, -0.05941559f, -0.01055401f, -0.06794509f, 
    0.30527064f, -0.03532387f, 0.14837870f, 0.11746433f, -0.12234979f, 0.02698016f, 0.13436207f, -0.02408275f, 
    -0.03745859f, -0.06454892f, 0.15036480f, -0.03044867f, -0.11456155f, 0.03713528f, -0.14750178f, 0.15532374f, 
    -0.01099276f, 0.17832583f, -0.06707839f, -0.08462097f, -0.07242641f, 0.04906159f, 0.00310779f, 0.03939151f, 
    -0.14470771f, -0.03374444f, 0.03377104f, -0.09901308f, -0.21217564f, 0.07169844f, -0.16811533f, 0.05152583f, 
    -0.02283135f, -0.03254033f, 0.00452450f, -0.06897368f, -0.27165440f, 0.03865312f, 0.28995404f, 0.05288957f, 
    0.19799456f, -0.01102416f, -0.02450895f, -0.01880771f, -0.15124638f, 0.08980978f, -0.04506597f, -0.20400958f, 
    -0.26284277f, -0.11571044f, 0.06890893f, -0.12976579f, 0.09512436f, 0.05890988f, 0.08312888f, 0.06191295f, 
    -0.00711491f, 0.11284643f, -0.04006172f, -0.03681877f, -0.18073280f, -0.15338637f, -0.07683709f, -0.14063326f, 
    0.07058796f, 0.07897911f, 0.00941797f, 0.05342037f, -0.02604344f, -0.13666390f, 0.02938637f, 0.17910624f, 
    -0.43057656f, -0.08540194f, -0.19639944f, -0.01333117f, 0.00864731f, 0.10439182f, -0.10303760f, -0.00074214f, 
    0.08002811f, 0.02807783f, -0.15390566f, -0.00329199f, 0.00602944f, 0.10858085f, 0.10368585f, -0.07639736f, 
    0.08168910f, 0.02951217f, -0.04297026f, 0.24537458f, 0.13880046f, -0.08122059f, 0.04133709f, 0.01112419f, 
    -0.00976979f, 0.21260498f, 0.01866120f, -0.08544996f, 0.13725838f, 0.21296251f, 0.16842705f, 0.24640910f, 
    0.03898250f, -0.00408492f, 0.06485783f, 0.24982420f, -0.33917263f, -0.21650515f, -0.09951495f, -0.01967323f, 
    -0.07708271f, -0.02336220f, -0.04758061f, 0.01824618f, -0.02316681f, 0.04754876f, 0.01373597f, 0.04519447f, 
    -0.33577785f, -0.02743513f, -0.01233673f, -0.15510017f, -0.05572876f, -0.12439767f, 0.06206563f, 0.13245413f, 
    0.02455814f, -0.03780878f, 0.12999110f, 0.18363000f, 0.38311976f, 0.23018919f, 0.05652955f, -0.16405727f, 
    0.06538527f, 0.28379917f, 0.00427681f, 0.22989802f, -0.02380593f, 0.01943212f, 0.08653530f, 0.04990014f, 
    0.29224944f, 0.34541112f, 0.29500437f, 0.01553238f, 0.07439464f, 0.09500705f, 0.16184790f, 0.05324237f, 
    0.00660906f, -0.08786316f, -0.18020637f, 0.08514196f, -0.13371998f, -0.04344935f, -0.08329543f, 0.04004918f, 
    0.08136933f, 0.11269513f, 0.13441685f, 0.08518835f, -0.01261480f, -0.06177297f, -0.07091869f, -0.08442672f, 
    0.06543594f, 0.12874509f, 0.04342850f, 0.06044595f, 0.10023436f, 0.01772109f, 0.10133611f, -0.18089122f, 
    -0.06015599f, -0.06628024f, 0.12805623f, 0.02268430f, 0.22463557f, 0.06165436f, 0.27374658f, 0.11300016f, 
    -0.14258716f, 0.01579949f, 0.03136979f, 0.04301701f, 0.08528600f, 0.06926185f, 0.01993800f, 0.08812321f, 
    -0.17841899f, -0.13636683f, 0.09253322f, 0.11061896f, 0.03260105f, 0.23519161f, -0.04346524f, 0.01492435f, 
    0.19286071f, -0.23649594f, 0.02202620f, 0.08663669f, 0.14939761f, 0.01643513f, 0.02850254f, 0.01460921f, 
    0.09596447f, 0.19443759f, 0.05422436f, -0.12093669f, -0.18521635f, -0.07008279f, -0.01943184f, 0.00142953f, 
    -0.09400583f, -0.23678537f, 0.02893998f, 0.09611990f, -0.04149096f, 0.03050477f, -0.06053248f, 0.05821202f, 
    -0.08219590f, 0.02212539f, 0.06910489f, 0.04402561f, 0.11645379f, 0.01685566f, 0.05551212f, 0.01381713f, 
    0.13548362f, -0.11378833f, -0.10084588f, 0.02634358f, -0.05290405f, -0.05931600f, 0.07199928f, -0.05392919f, 
    -0.10859236f, -0.09310648f, 0.23701169f, -0.12909660f, -0.00029635f, 0.02895061f, 0.08695263f, -0.01089988f, 
    -0.06355423f, 0.06225702f, 0.06139407f, 0.12142625f, -0.03791795f, 0.01925303f, 0.16171552f, 0.11926565f, 
    0.04420671f, -0.00285529f, 0.00233927f, 0.03108840f, 0.18716247f, 0.02031965f, 0.09150473f, 0.08602235f, 
    0.11405165f, 0.11099102f, 0.15876737f, 0.23541589f, -0.04821947f, -0.00454782f, 0.07579514f, -0.03211813f, 
    -0.15994430f, 0.00465631f, -0.10556977f, 0.09004793f, 0.18958141f, 0.15194577f, -0.01418022f, 0.06738910f, 
    0.05378839f, 0.24192753f, 0.11629752f, -0.01172939f, 0.06091222f, -0.04509672f, -0.07061771f, -0.05355380f, 
    0.14384922f, 0.16144176f, -0.03386087f, -0.10616966f, 0.02319532f, 0.00877323f, -0.05898410f, -0.13256446f, 
    0.01676026f, -0.00254542f, -0.02007057f, -0.10474848f, -0.10731813f, -0.19318856f, -0.11869448f, 0.03325129f, 
    0.04222023f, 0.00668618f, 0.02173230f, 0.00433908f, 0.04036874f, -0.02531096f, 0.04518775f, 0.04716420f, 
    -0.13479668f, -0.08074472f, 0.10560538f, -0.19019857f, -0.06381778f, 0.28836378f, 0.04257949f, -0.04468624f, 
    -0.07158232f, 0.03116347f, -0.01382354f, -0.00549911f, 0.00623128f, 0.22032335f, -0.11520947f, -0.24401544f, 
    -0.00007845f, 0.00618492f, -0.08976845f, -0.01049088f, -0.00091070f, -0.02872065f, 0.14511573f, -0.08627173f, 
    -0.03102868f, 0.33149424f, -0.01436526f, -0.05117556f, 0.05980220f, 0.19399330f, 0.13066430f, 0.00408811f, 
    0.05778533f, 0.09188823f, -0.16288199f, 0.09183627f, 0.27137801f, 0.27019569f, 0.15673895f, 0.15085500f, 
    -0.04263081f, 0.02934611f, -0.16206802f, -0.15707475f, 0.00765354f, -0.04436917f, 0.01736079f, 0.10508575f, 
    0.05564458f, 0.04293730f, 0.01585080f, -0.10756352f, -0.05284915f, -0.00849334f, 0.17407191f, 0.20339942f, 
    -0.02545083f, -0.04682352f, -0.06137003f, -0.07216557f, -0.04940091f, 0.06199577f, 0.08763270f, 0.26885065f, 
    -0.02690910f, -0.01766875f, 0.03229078f, -0.09598403f, -0.09580084f, -0.01667399f, -0.07273152f, 0.07962564f, 
    0.03347922f, -0.05482244f, -0.06483260f, -0.02390746f, -0.08160023f, 0.02043951f, 0.00698455f, -0.05524176f, 
    0.02385066f, 0.01798560f, -0.05284211f, 0.05785713f, -0.07548423f, -0.02481381f, 0.04894033f, -0.02884940f, 
    -0.07135168f, -0.04130455f, -0.06200187f, 0.01876269f, -0.05843737f, -0.06568184f, -0.08088708f, 0.01907349f, 
    0.04199953f, 0.01427544f, -0.03349356f, -0.01573264f, 0.00015264f, 0.02607096f, 0.03957102f, -0.06385675f, 
    0.00585916f, -0.02448584f, -0.06530960f, -0.03364085f, 0.03347806f, 0.02885348f, 0.04847160f, -0.06505435f, 
    -0.01716427f, -0.04353121f, 0.04215561f, 0.02547511f, 0.04686796f, -0.07981960f, -0.03244117f, 0.03115659f, 
    -0.04995779f, -0.01787062f, -0.01339278f, 0.01538757f, -0.02013367f, 0.03911678f, 0.03627654f, 0.05146857f, 
    0.04515820f, 0.01977208f, 0.01160462f, -0.07840114f, -0.03262357f, 0.01042822f, 0.00342423f, -0.00802847f, 
    0.03041070f, -0.01649967f, -0.02335911f, 0.06063169f, -0.05468193f, 0.02636247f, 0.05597688f, -0.05645136f, 
    0.00475304f, -0.07654988f, 0.04978986f, 0.01620994f, 0.05290393f, -0.02485778f, -0.07051354f, 0.02758229f, 
    -0.02798389f, 0.00258682f, 0.01905898f, 0.05659131f, 0.04799495f, -0.06664569f, -0.03910297f, 0.04938494f, 
    -0.03791197f, 0.05553915f, -0.01608238f, -0.02882067f, 0.06401801f, 0.04023183f, -0.00516274f, 0.03064909f, 
    -0.06505650f, -0.06742819f, -0.00537106f, 0.01519928f, 0.00108390f, -0.06712985f, -0.02922012f, -0.07989565f, 
    -0.06928128f, 0.02821464f, -0.07569738f, -0.01682902f, 0.00055826f, -0.00132550f, -0.03189942f, -0.06285133f, 
    -0.06728040f, 0.01496075f, -0.05015177f, -0.02563924f, -0.04308759f, 0.03665441f, -0.02058755f, -0.02337550f, 
    -0.03713711f, 0.01102582f, 0.02294437f, -0.01845390f, 0.01499412f, -0.01598443f, -0.04982949f, -0.05229951f, 
    -0.01583473f, -0.08169547f, 0.05287739f, 0.04681495f, -0.06208435f, 0.02224765f, 0.01714831f, 0.02676112f, 
    0.03261459f, 0.05620079f, -0.07114618f, 0.02377260f, -0.06202593f, -0.05370281f, 0.02765151f, -0.01594415f, 
    -0.05642439f, -0.02234183f, -0.02176543f, 0.02743109f, 0.00237473f, 0.00400511f, 0.01264059f, 0.01010716f, 
    -0.05062854f, -0.03015723f, -0.02217916f, -0.07349119f, -0.06839371f, -0.03263893f, -0.07425593f, -0.07045722f, 
    0.02579956f, -0.04284853f, 0.00663964f, -0.06562383f, 0.05637543f, -0.03007836f, 0.05479646f, 0.05712143f, 
    -0.02170055f, -0.00493620f, 0.06047768f, -0.02837211f, 0.02357031f, -0.05966340f, 0.06051168f, -0.02970527f, 
    -0.06096624f, 0.00140146f, -0.04756985f, -0.06361529f, -0.01695268f, 0.01312464f, 0.03176612f, -0.06928785f, 
    0.03120597f, -0.05835326f, -0.07560153f, -0.03134915f, -0.00964450f, -0.05327172f, -0.05059578f, -0.06206870f, 
    0.09516872f, 0.03261045f, -0.21709903f, -0.13615330f, 0.04926133f, -0.02745155f, -0.01114971f, -0.03985085f, 
    0.06839304f, 0.09147576f, 0.17028567f, -0.06960819f, 0.21250644f, -0.13686647f, -0.05488813f, -0.04593209f, 
    -0.05784907f, 0.13074432f, 0.02154824f, -0.04299648f, -0.02513719f, -0.00802338f, -0.21481113f, -0.08424342f, 
    0.04425607f, -0.02437492f, -0.00035838f, -0.16768235f, 0.04553738f, -0.03171691f, 0.00326531f, 0.08649916f, 
    -0.10780451f, -0.05178526f, 0.02129418f, -0.00609893f, -0.36702740f, 0.23567960f, -0.07480319f, -0.15312468f, 
    0.12074034f, 0.07548086f, -0.02917134f, 0.02477524f, 0.10850296f, 0.00863831f, 0.03049597f, 0.02907825f, 
    -0.11858324f, -0.10386832f, -0.15992510f, -0.01606585f, 0.04473056f, -0.02220145f, -0.07159150f, -0.06737562f, 
    -0.00276679f, 0.07358634f, -0.02033633f, -0.02728472f, -0.06895564f, -0.08488669f, 0.01997023f, 0.18555738f, 
    0.06962180f, -0.02026461f, -0.05745044f, -0.07756870f, -0.02152976f, 0.09511139f, 0.03337922f, 0.16023193f, 
    0.39084300f, -0.02996089f, 0.01351222f, 0.02101842f, -0.08195604f, -0.13895649f, 0.05520682f, -0.02597938f, 
    -0.03575023f, 0.05735808f, -0.10081881f, -0.01692790f, 0.05062166f, 0.15064053f, 0.24263164f, 0.07168031f, 
    -0.02591062f, 0.04334429f, 0.05640134f, 0.08060367f, -0.01287804f, -0.14049168f, -0.11790975f, -0.07905809f, 
    -0.14942156f, 0.33811083f, 0.12176690f, 0.11730812f, 0.11046433f, 0.02209233f, 0.11189657f, 0.02985978f, 
    0.10858901f, -0.03950394f, 0.02347778f, 0.08535556f, -0.12093809f, -0.02252883f, -0.09953821f, 0.01985925f, 
    0.03676866f, 0.03298964f, 0.04359056f, 0.02207838f, -0.03636448f, 0.05747652f, -0.05935192f, 0.10600840f, 
    -0.06931376f, -0.04726845f, 0.17981200f, -0.03228901f, 0.09240668f, 0.10474521f, -0.00165830f, 0.12806933f, 
    0.10799443f, -0.01143766f, 0.05295093f, 0.12526868f, -0.04435752f, -0.18948682f, 0.10783017f, -0.14313719f, 
    -0.07396196f, 0.10097077f, 0.01726981f, 0.02564384f, -0.06361026f, -0.06759911f, 0.00966148f, -0.05167207f, 
    -0.18581463f, -0.21687654f, 0.14686270f, 0.13754781f, 0.14528966f, -0.11925658f, 0.02779176f, 0.01740904f, 
    0.01091853f, -0.02027335f, -0.05345600f, 0.03747138f, 0.26649666f, -0.07741129f, 0.36865738f, 0.34519175f, 
    -0.15864529f, -0.21042322f, -0.06565087f, -0.04689708f, 0.10502647f, -0.05061218f, 0.09880648f, 0.10140991f, 
    -0.04508942f, 0.18668912f, -0.15154329f, -0.25072443f, -0.01308012f, 0.02783358f, -0.03014756f, 0.03605479f, 
    0.06722369f, -0.00018835f, -0.08708844f, 0.04243958f, 0.11486620f, -0.20334773f, 0.44478244f, 0.18882260f, 
    0.02912941f, 0.16012038f, -0.00399889f, 0.13108456f, 0.06776373f, 0.07622002f, -0.06528724f, -0.07592357f, 
    -0.02166370f, -0.07274099f, 0.15288022f, 0.18180692f, 0.05322976f, 0.16373397f, -0.23643129f, 0.14839983f, 
    0.18095948f, 0.03137147f, 0.15246210f, 0.16155054f, -0.08336270f, 0.01270375f, 0.00930320f, 0.02349912f, 
    -0.06380834f, 0.04331571f, 0.03405360f, -0.10047618f, 0.14065188f, 0.31582215f, 0.15379797f, 0.25572360f, 
    -0.24566245f, -0.00875360f, -0.21432430f, -0.08423768f, 0.03575123f, 0.19012694f, -0.00371017f, 0.08698915f, 
    0.08181251f, -0.01634396f, 0.02019270f, -0.03809892f, 0.16487598f, 0.03100318f, 0.09140883f, 0.12163328f, 
    0.07536010f, 0.08791196f, 0.21218100f, 0.15046157f, -0.03472572f, 0.10086321f, -0.05547817f, 0.03656892f, 
    -0.01364065f, -0.14324370f, 0.17058934f, -0.11924828f, -0.03302271f, -0.05307776f, 0.06629355f, 0.06110585f, 
    -0.31453294f, -0.09273124f, -0.19638857f, -0.48727441f, -0.03896621f, 0.18141547f, -0.02315677f, -0.08011341f, 
    -0.15213574f, 0.07924129f, 0.02499906f, -0.04736720f, -0.37175936f, -0.32880449f, -0.16665457f, -0.24314286f, 
    0.25663757f, 0.18040720f, 0.14607057f, 0.00149458f, -0.15008667f, -0.19184238f, -0.13079467f, -0.06190640f, 
    -0.01033613f, 0.04901329f, -0.14630695f, 0.16465297f, 0.13396089f, -0.05414731f, -0.00125627f, -0.07596370f, 
    0.23352179f, 0.20265183f, 0.08889807f, 0.04819867f, 0.08492830f, -0.00715889f, -0.10150402f, -0.26886517f, 
    0.10874966f, 0.07498665f, 0.06177879f, 0.01676659f, 0.15574005f, 0.17157573f, 0.05102573f, 0.04037413f, 
    0.03581098f, -0.00192652f, -0.13536268f, -0.07917378f, -0.10990211f, -0.01322458f, 0.16672592f, 0.02201780f, 
    -0.14676236f, -0.19251597f, 0.11884876f, -0.08162519f, -0.12864332f, 0.01241467f, -0.05297060f, -0.10494728f, 
    0.27182657f, 0.01681412f, 0.14796573f, 0.11476582f, -0.05038711f, 0.12267432f, -0.24165618f, 0.08254708f, 
    0.06417848f, 0.10072940f, 0.13143562f, 0.07173841f, 0.01308842f, -0.00025110f, 0.04965298f, -0.18847489f, 
    0.07916937f, 0.17063238f, 0.11622880f, 0.05307319f, 0.21790457f, 0.10184728f, 0.15934375f, 0.03607662f, 
    -0.03363426f, 0.16371605f, -0.09406650f, -0.05822182f, 0.15101539f, 0.00692064f, 0.05868874f, 0.02619904f, 
    -0.01092698f, -0.05677056f, -0.00365112f, -0.08821376f, -0.25365633f, -0.13689823f, -0.17564587f, -0.31576282f, 
    -0.01592244f, 0.13942093f, -0.00490636f, -0.08528683f, 0.03439922f, 0.07296609f, -0.01828500f, -0.08335708f, 
    0.04180513f, -0.25073645f, 0.02118965f, -0.18340811f, 0.01052304f, -0.02839318f, -0.08464926f, 0.06457455f, 
    0.00301240f, -0.06066401f, -0.25472760f, -0.15661269f, 0.24932736f, 0.39927548f, 0.04257752f, -0.10085894f, 
    -0.24223515f, 0.02324909f, 0.03754284f, -0.04350814f, 0.06090432f, -0.05240568f, 0.00500753f, 0.09605594f, 
    -0.00214340f, 0.21763560f, 0.01900699f, 0.01091769f, 0.15857111f, 0.01667318f, 0.16708928f, -0.09841281f, 
    0.19893748f, 0.22078733f, -0.04405209f, 0.10895592f, -0.01898392f, -0.00958722f, -0.10350342f, 0.03238481f, 
    0.05977838f, 0.09073971f, -0.03772213f, 0.02053373f, -0.16223247f, 0.00802502f, -0.11153266f, -0.03220773f, 
    0.06518740f, 0.30973086f, -0.04160925f, 0.06948170f, -0.05549572f, -0.01266144f, 0.08643483f, -0.03013514f, 
    0.00515018f, 0.04990542f, -0.07259872f, -0.02577117f, -0.06674122f, 0.07114493f, 0.13997246f, -0.08340346f, 
    0.12539443f, 0.25495136f, 0.17640534f, 0.08997363f, -0.06203960f, -0.01268531f, 0.07597691f, 0.12015531f, 
    -0.04847101f, -0.12154870f, 0.12880029f, -0.20316117f, 0.10965911f, 0.12864728f, 0.13563780f, 0.00626711f, 
    -0.05055288f, 0.21106786f, 0.04952936f, 0.12992132f, -0.09683496f, -0.02472867f, -0.08396339f, -0.12852752f, 
    -0.06107036f, 0.01946149f, 0.07601698f, -0.10206323f, 0.11440251f, 0.10880996f, 0.00164327f, 0.03149668f, 
    0.12620658f, -0.15755895f, 0.23040661f, 0.06526247f, -0.12906609f, -0.07539436f, -0.02355973f, -0.12232362f, 
    -0.13500389f, 0.16988519f, 0.11620515f, 0.24649937f, 0.18602775f, 0.03180371f, 0.11526140f, -0.06658443f, 
    -0.05830468f, -0.11323345f, 0.04515423f, 0.12541111f, 0.05010639f, -0.04079799f, 0.10176611f, -0.16212940f, 
    0.12839060f, 0.14399457f, 0.09466132f, -0.05308441f, 0.06086528f, 0.06371372f, -0.00070972f, -0.17303063f, 
    -0.01332434f, 0.01124601f, -0.04737715f, -0.12065867f, 0.22592315f, 0.30285236f, 0.18213014f, -0.09291993f, 
    -0.08121403f, 0.02125783f, -0.07977729f, 0.14796142f, -0.12555058f, -0.05051240f, -0.02221249f, -0.05218218f, 
    0.28006062f, 0.18503001f, 0.05886000f, 0.17130314f, 0.08683192f, 0.07468208f, 0.07235119f, 0.01879489f, 
    -0.08057424f, -0.01161363f, -0.08903191f, 0.07774734f, -0.07925069f, -0.03017167f, -0.30017692f, -0.16141906f, 
    -0.04164227f, -0.27007103f, 0.00977640f, -0.01442463f, 0.05410514f, -0.06413262f, 0.10276677f, -0.09368645f, 
    -0.20421216f, -0.04246557f, -0.12483618f, -0.03336522f, -0.03157264f, -0.02918118f, 0.06257401f, -0.04753807f, 
    -0.00210515f, -0.06512681f, 0.03059791f, -0.17776054f, 0.04604524f, 0.03321432f, -0.13557699f, 0.13673832f, 
    -0.03521925f, -0.03422736f, 0.06996899f, 0.03893296f, 0.09363674f, 0.00919726f, 0.26473457f, 0.00112725f, 
    0.07302250f, -0.29526341f, -0.16490845f, -0.26086071f, -0.04008371f, 0.03748125f, -0.14018236f, 0.10110446f, 
    -0.00793877f, 0.24802256f, -0.04818004f, 0.27674323f, 0.05170950f, 0.03395540f, -0.36478785f, 0.23964439f, 
    0.02930076f, 0.02635762f, -0.08567084f, -0.07087444f, 0.01445055f, 0.10303532f, 0.05129029f, 0.11459400f, 
    0.07154192f, -0.10252886f, 0.12162730f, 0.11495961f, -0.01381703f, 0.15743357f, 0.23572965f, 0.03295893f, 
    -0.00351780f, -0.01158454f, 0.02523934f, 0.01273084f, 0.14381915f, 0.03341969f, 0.16352814f, -0.06866199f, 
    0.02854239f, -0.08843593f, 0.07807370f, 0.16686383f, -0.03052705f, -0.07323043f, 0.09247474f, -0.07749958f, 
    0.27332649f, -0.22354884f, -0.09399249f, -0.19421381f, 0.04066401f, 0.13738535f, 0.02326449f, 0.06033318f, 
    -0.00915819f, -0.14047606f, 0.01225385f, -0.04851076f, -0.18230826f, 0.18800673f, -0.08459370f, -0.20252322f, 
    0.14301826f, -0.03862355f, 0.08848271f, 0.03980866f, 0.07966188f, 0.19265752f, -0.04547554f, 0.02330043f, 
    0.04345519f, 0.11784337f, -0.27461845f, -0.10969003f, 0.05080135f, 0.02911802f, 0.08122934f, -0.06517907f, 
    -0.04618251f, -0.08633332f, 0.07062653f, 0.11024337f, 0.13848060f, -0.06316348f, -0.02154986f, -0.11333646f, 
    0.03509271f, -0.12777057f, 0.01228145f, 0.03154141f, 0.06970010f, 0.12669519f, -0.02035252f, -0.09910053f, 
    0.38705316f, -0.12458880f, -0.06983870f, -0.21318541f, -0.02084171f, 0.03644963f, -0.03954109f, -0.06892376f, 
    0.08327792f, -0.00213063f, -0.03167192f, 0.00406884f, -0.16860364f, 0.06256767f, 0.11964731f, -0.09530814f, 
    -0.05797440f, -0.09678590f, 0.15776272f, 0.12961620f, 0.12506701f, 0.05464209f, -0.10383145f, 0.04900928f, 
    -0.20950076f, 0.01507909f, 0.07367548f, 0.24780506f, -0.03262893f, -0.02359673f, 0.01360599f, 0.09820851f, 
    0.06816182f, 0.09959412f, -0.04550496f, 0.09400220f, 0.07207467f, -0.21312696f, 0.04637148f, -0.08901530f, 
    -0.12979136f, 0.10697192f, 0.03676259f, -0.07075531f, -0.11867347f, 0.00669765f, -0.05420533f, -0.08184288f, 
    -0.12563960f, 0.10139196f, -0.10152832f, 0.08522564f, -0.00269624f, -0.11886963f, 0.09567993f, 0.12187804f, 
    0.06600297f, -0.02096257f, 0.17169879f, -0.01561401f, -0.15636943f, -0.03152858f, 0.13974157f, 0.19753629f, 
    -0.07609268f, 0.07012250f, 0.02533502f, -0.00250054f, 0.10475802f, -0.08835428f, -0.08949756f, -0.05819420f, 
    -0.44304472f, -0.01438045f, 0.21867515f, 0.18181582f, -0.04188521f, 0.00326486f, -0.02227708f, 0.08632178f, 
    0.07784293f, 0.13021843f, 0.08270445f, -0.02891773f, -0.18993568f, 0.19910793f, 0.10948783f, 0.04363795f, 
    -0.12317632f, -0.06102472f, -0.09728610f, -0.06339256f, 0.12212408f, 0.08440787f, -0.02704816f, 0.10761482f, 
    0.17426139f, 0.05415303f, 0.09523231f, 0.03011026f, 0.02813191f, 0.03569174f, 0.02644713f, -0.08971715f, 
    0.01030338f, -0.08549722f, 0.10203576f, 0.03120307f, -0.15201117f, -0.51220024f, 0.19533719f, 0.30752411f, 
    -0.00735109f, -0.04625609f, -0.02668873f, 0.01472116f, 0.15254021f, -0.08943649f, -0.01422311f, 0.01394159f, 
    -0.16322517f, -0.19797166f, 0.23998582f, 0.13898459f, 0.07350021f, 0.10957431f, -0.01893165f, -0.00950190f, 
    -0.17905243f, -0.08013664f, -0.00371205f, 0.09713052f, -0.05129731f, 0.06851440f, 0.12025074f, 0.01200286f, 
    -0.07648103f, -0.12661196f, -0.17195959f, 0.02569580f, -0.11528882f, 0.04120298f, 0.13624115f, 0.05112107f, 
    0.09278530f, -0.49845079f, -0.05139784f, 0.09485234f, 0.24456318f, 0.31248993f, -0.00929363f, 0.17032312f, 
    0.11266518f, -0.06547845f, -0.09951726f, 0.02122228f, 0.41443333f, 0.17431818f, -0.03010052f, 0.07813983f, 
    -0.00256626f, -0.14956996f, 0.17164308f, 0.00013533f, 0.10883987f, 0.03565033f, 0.05459509f, 0.06285657f, 
    0.10920771f, 0.07459462f, -0.34192780f, 0.00388703f, 0.03254646f, -0.00262814f, 0.08767410f, 0.14310116f, 
    0.15163858f, -0.00164334f, 0.10162266f, 0.02858936f, -0.06325021f, -0.10804977f, -0.12423971f, -0.16943748f, 
    -0.08244702f, 0.03348774f, 0.05068307f, 0.00682389f, 0.13730448f, 0.12952366f, 0.11405980f, 0.02779980f, 
    -0.27713796f, 0.11380102f, 0.05345996f, -0.27971065f, 0.08689602f, -0.02809727f, -0.04889543f, 0.09243946f, 
    0.14117032f, -0.04549741f, 0.03100582f, -0.04214808f, -0.23500827f, -0.15923040f, -0.06337692f, -0.10641709f, 
    -0.15982884f, -0.03505643f, 0.02158406f, -0.01206676f, -0.01204458f, 0.04510342f, -0.08689004f, 0.14570062f, 
    -0.26504079f, -0.24073455f, 0.06608479f, 0.17706630f, -0.10350745f, -0.11711987f, 0.01704732f, 0.19860776f, 
    -0.03231208f, 0.05252564f, 0.16164178f, -0.02953460f, -0.22213997f, -0.22032531f, 0.04188484f, -0.06288679f, 
    0.02595867f, 0.12352005f, 0.00817608f, -0.04701833f, -0.03596235f, -0.02271392f, 0.09594988f, -0.00076461f, 
    -0.00708707f, 0.24488330f, -0.19524398f, 0.15753205f, -0.12084693f, -0.04389689f, 0.02563926f, 0.02891967f, 
    0.08566890f, 0.02301122f, 0.12651774f, 0.21982223f, 0.10950877f, -0.16239506f, 0.07346656f, 0.31993204f, 
    -0.01050221f, 0.04300968f, 0.00361229f, 0.00056165f, -0.04191423f, 0.11073673f, -0.04442236f, -0.11829779f, 
    -0.17681076f, 0.00662516f, 0.15675542f, 0.11094613f, -0.03170546f, -0.06796515f, -0.05576436f, 0.08770500f, 
    0.02652557f, 0.06652254f, 0.04745758f, -0.02255788f, -0.49074617f, 0.12253761f, 0.21516755f, 0.14221439f, 
    -0.04862757f, -0.03054730f, -0.16522141f, 0.11205868f, 0.00785680f, 0.00477967f, -0.00142280f, 0.10467418f, 
    -0.00288377f, 0.08639456f, 0.22183803f, 0.07804616f, -0.02196488f, 0.06481222f, 0.22778496f, 0.01651260f, 
    0.01008563f, -0.08727235f, 0.12574561f, -0.12369306f, -0.16390458f, 0.04111539f, 0.19193712f, 0.19554141f, 
    0.11022215f, -0.00075906f, -0.01902922f, 0.04551639f, -0.08557166f, 0.03417565f, 0.09971819f, 0.08406837f, 
    -0.12204628f, 0.19493264f, -0.13233869f, -0.20567422f, 0.17949104f, -0.14865331f, -0.04632860f, 0.00567704f, 
    0.02883453f, -0.06682672f, 0.00989302f, -0.15235691f, 0.02897650f, -0.11866820f, 0.04603456f, 0.16337237f, 
    0.05505769f, -0.19397201f, -0.13357712f, -0.01390707f, -0.12284318f, -0.37791356f, -0.29544905f, -0.28829029f, 
    -0.48148951f, -0.39005297f, -0.02515180f, 0.36599085f, 0.16124262f, 0.02298683f, 0.09053247f, -0.28975081f, 
    -0.08352445f, -0.15705870f, -0.22547480f, 0.07761554f, 0.27348465f, 0.07357522f, 0.15677415f, 0.14621779f, 
    -0.04821353f, 0.14359951f, -0.07505763f, 0.00480002f, 0.01537219f, -0.11241023f, 0.16337100f, 0.13397059f, 
    -0.06891402f, -0.15649417f, 0.10103998f, 0.01859152f, -0.03357145f, 0.01793152f, 0.09962778f, -0.12549478f, 
    0.34980583f, 0.17325373f, 0.25104651f, 0.43744630f, -0.07459298f, 0.07384159f, -0.09281412f, -0.05696994f, 
    -0.07415655f, -0.00913270f, 0.02500076f, -0.02889456f, 0.28561002f, 0.13763595f, 0.08867684f, 0.26663473f, 
    0.05199688f, -0.00326139f, 0.32535401f, -0.03464204f, 0.07585937f, -0.10388148f, 0.08581698f, 0.11008916f, 
    0.01159346f, 0.06622338f, 0.21218772f, 0.09619905f, -0.04492161f, -0.04071732f, 0.07654784f, 0.24028112f, 
    -0.15420964f, -0.07357342f, -0.00544215f, -0.14126244f, -0.06629086f, -0.07068872f, 0.14787698f, 0.24907351f, 
    0.09166136f, -0.17513099f, -0.05799341f, 0.13331677f, 0.01313587f, 0.09750503f, 0.09718925f, 0.02180427f, 
    0.01841697f, 0.15148094f, 0.06893014f, 0.10789728f, -0.22641052f, -0.07348002f, -0.06293590f, 0.16017209f, 
    0.07534029f, 0.07803068f, -0.08609616f, -0.18849322f, -0.26908004f, -0.26258782f, -0.26944849f, -0.09799505f, 
    0.31090724f, -0.10807662f, 0.08853415f, 0.04400927f, -0.00372081f, 0.05085669f, 0.01275146f, -0.12866718f, 
    0.07747646f, -0.01646079f, -0.01281055f, -0.06381479f, -0.09911687f, -0.14489569f, -0.10434981f, -0.15638267f, 
    0.11130832f, -0.09217313f, -0.02492124f, -0.02182820f, -0.03164714f, -0.11510466f, -0.12244283f, -0.14452548f, 
    -0.06546349f, -0.07025947f, -0.06525235f, -0.11304591f, -0.14540695f, -0.04868377f, -0.08811559f, 0.08082379f, 
    0.15385658f, 0.01696362f, -0.00905674f, 0.08716138f, 0.11286423f, 0.48160455f, 0.63341564f, 0.10149871f, 
    -0.16843568f, -0.25453091f, -0.06257225f, -0.05847456f, 0.00069895f, 0.10197671f, 0.12011692f, 0.07182135f, 
    0.15947166f, 0.04809025f, -0.01233279f, -0.14835364f, 0.12596600f, 0.10499695f, 0.03564561f, 0.02714433f, 
    0.19663656f, 0.02411894f, 0.02358058f, 0.14736418f, 0.35867450f, 0.23288795f, -0.05977923f, 0.07238865f, 
    0.24365442f, -0.13568191f, -0.00426993f, -0.02607322f, -0.16522682f, -0.05231867f, 0.13385744f, 0.08184758f, 
    -0.18239620f, -0.21698363f, 0.16520564f, 0.12854293f, 0.07008535f, 0.12565103f, 0.13900527f, 0.08036681f, 
    0.13979489f, 0.06974470f, 0.01445883f, 0.04927015f, 0.11963210f, -0.06889863f, 0.13214852f, -0.03629671f, 
    -0.06412926f, 0.04278039f, 0.15424958f, 0.03196880f, 0.00225366f, 0.13462393f, 0.09659167f, 0.07373106f, 
    0.15614477f, 0.22189014f, -0.03877009f, -0.07871553f, -0.09949198f, -0.09728045f, 0.05399171f, 0.15883982f, 
    -0.08657834f, -0.07271612f, 0.00255659f, -0.02167425f, 0.06388225f, 0.28184682f, -0.09281287f, -0.09343228f, 
    0.11005211f, 0.09746701f, 0.21650286f, 0.03706903f, -0.11157742f, 0.10552464f, 0.08314287f, 0.17238076f, 
    0.04512774f, -0.04213334f, -0.03349024f, -0.06956475f, -0.03317000f, 0.11430792f, 0.08646271f, -0.06529316f, 
    -0.16114132f, -0.04987855f, -0.04035523f, 0.13908167f, 0.00437469f, 0.02371116f, -0.00951295f, -0.05761309f, 
    -0.01512502f, 0.00545665f, -0.07813443f, -0.08503234f, 0.09188343f, 0.10259724f, -0.05439000f, -0.09123895f, 
    0.36449203f, 0.08827220f, 0.47887024f, 0.10549237f, -0.17078030f, -0.09490916f, 0.04384369f, -0.00338771f, 
    -0.12555647f, 0.08847222f, 0.05883119f, 0.15943946f, 0.13432333f, 0.00315067f, 0.00080532f, 0.09241606f, 
    -0.10779630f, 0.01941696f, 0.16127799f, 0.17266461f, 0.15608308f, 0.06924015f, 0.02907997f, -0.07889430f, 
    0.05477038f, -0.05494962f, -0.01032945f, 0.03145054f, 0.08923285f, -0.13848977f, -0.08918940f, -0.21156909f, 
    0.18953848f, 0.06828606f, -0.07032574f, -0.07193433f, 0.17076506f, 0.17814344f, -0.09548443f, -0.13207312f, 
    -0.02823863f, -0.13904189f, -0.00516765f, -0.02518309f, -0.05928195f, -0.00816936f, -0.03592082f, -0.03310707f, 
    0.14133540f, 0.02502080f, 0.04747046f, -0.10367102f, -0.05294214f, 0.21815521f, 0.04345631f, 0.01814700f, 
    -0.00007908f, 0.04937224f, -0.08600480f, -0.00588845f, -0.33781576f, -0.09961658f, -0.12780447f, 0.05297086f, 
    -0.16196376f, -0.15276960f, -0.14963880f, -0.05043263f, -0.02076118f, -0.07261465f, 0.15843107f, 0.04487509f, 
    -0.42501873f, -0.07974409f, -0.20938167f, 0.21467693f, 0.02390772f, -0.03646150f, 0.09139336f, 0.20253503f, 
    0.03616539f, 0.03603283f, -0.00816608f, 0.03970720f, 0.17976628f, -0.01603218f, 0.15142411f, 0.25200602f, 
    -0.14142269f, 0.00424031f, -0.16866797f, -0.16904038f, 0.04172197f, -0.02344493f, 0.08869869f, 0.15967011f, 
    -0.09503329f, -0.22109993f, 0.02176989f, -0.17043014f, -0.20138609f, -0.02730338f, 0.09248129f, 0.24153785f, 
    0.15671186f, 0.07434276f, -0.06288036f, 0.12877101f, -0.16373639f, -0.17246041f, 0.02360808f, 0.34117714f, 
    0.00483845f, 0.06897253f, -0.08587861f, 0.02829214f, -0.01500993f, 0.13793464f, -0.05013302f, 0.07107192f, 
    -0.08304692f, 0.22341554f, -0.19679160f, -0.10336924f, 0.02485661f, -0.00210626f, -0.08397554f, -0.01731922f, 
    0.07283884f, 0.03044006f, -0.05244232f, -0.08036222f, -0.10694166f, -0.15566351f, -0.05028085f, -0.09588289f, 
    0.00750356f, -0.02775412f, 0.00800183f, -0.04732229f, -0.00749175f, 0.01920586f, 0.01297601f, -0.03438323f, 
    -0.17327183f, 0.11508673f, -0.05158485f, 0.03831265f, -0.00197838f, 0.03731336f, 0.20975383f, -0.03753744f, 
    -0.00187656f, 0.08289234f, -0.07229397f, -0.07302086f, 0.15103444f, -0.04019161f, 0.01696215f, 0.12735933f, 
    0.06644280f, 0.20058978f, 0.07645445f, 0.03736447f, -0.11415024f, -0.16187164f, 0.08197417f, 0.08022773f, 
    -0.10458627f, -0.08503889f, 0.03259383f, -0.08826077f, -0.02990846f, 0.05788558f, -0.05379239f, -0.01584779f, 
    -0.00976054f, 0.19747595f, -0.00586625f, 0.07525593f, -0.03038892f, -0.01329150f, -0.05280629f, -0.02756424f, 
    -0.02552441f, -0.09341136f, -0.02573787f, -0.02077438f, 0.10071387f, 0.01019071f, 0.07407478f, 0.03915656f, 
    -0.15970616f, 0.05949898f, 0.22523220f, 0.05792283f, -0.11681698f, 0.00837963f, 0.03294782f, -0.05158489f, 
    -0.07504513f, -0.03734772f, 0.13995467f, 0.11873943f, 0.11408229f, -0.07753932f, -0.02937391f, -0.04892549f, 
    0.05029536f, 0.02263102f, -0.03387322f, -0.01254796f, -0.17649201f, -0.08641353f, 0.00451567f, 0.01446094f, 
    0.13458481f, 0.01236135f, -0.08330044f, -0.12500161f, 0.05507525f, -0.05722025f, 0.07702771f, -0.02389500f, 
    0.00276190f, -0.04801532f, -0.03837347f, -0.08293890f, -0.01766653f, 0.19294190f, -0.12958947f, -0.09935196f, 
    0.04012531f, -0.10759224f, -0.06212863f, 0.01647146f, -0.03074419f, -0.02339807f, -0.07595215f, 0.02386352f, 
    0.15792370f, -0.17991540f, 0.03618948f, -0.05375386f, 0.02368827f, 0.00103710f, -0.06715054f, -0.01883030f, 
    0.02406595f, 0.02015177f, -0.12217503f, -0.10761698f, 0.03070187f, -0.09051696f, -0.10867473f, -0.13636667f, 
    0.04770040f, -0.24211517f, 0.07098941f, 0.06404910f, -0.07706406f, -0.15078986f, 0.02557745f, -0.03659472f, 
    0.24203092f, -0.13820918f, -0.28943965f, -0.05475865f, 0.11114860f, 0.10311660f, 0.00702380f, 0.02177554f, 
    -0.07726433f, 0.01026817f, -0.01560739f, -0.00695881f, 0.29589787f, -0.12511821f, 0.00515704f, -0.07815208f, 
    -0.07008804f, -0.08986936f, 0.06214536f, -0.04766315f, -0.00794707f, -0.04636898f, 0.17932229f, -0.01828540f, 
    -0.11682872f, -0.17497650f, -0.16847804f, -0.05868520f, -0.09458645f, 0.10164841f, -0.04245892f, 0.08514113f, 
    0.00481806f, -0.00724283f, -0.06854187f, 0.10045789f, 0.23554203f, 0.29900467f, -0.19384146f, -0.23920603f, 
    0.05522267f, -0.14205536f, -0.16285980f, -0.09640223f, -0.03130223f, 0.06299147f, 0.04529316f, -0.05258936f, 
    0.03459589f, 0.02358638f, -0.04003921f, -0.02184056f, 0.01833445f, -0.02768955f, 0.04817364f, -0.05694133f, 
    0.01294648f, 0.03925275f, 0.03803758f, 0.00532949f, 0.03954211f, -0.05640001f, -0.01035629f, -0.05105304f, 
    0.05585231f, -0.00868525f, -0.01269926f, 0.04220267f, -0.00029651f, 0.01830355f, 0.05248515f, 0.05117225f, 
    -0.07953130f, 0.00633671f, 0.02284897f, -0.05436795f, 0.01599510f, 0.04873406f, -0.05568201f, -0.07075592f, 
    -0.06750397f, -0.01317078f, -0.00814828f, -0.04527434f, -0.04714929f, 0.02947655f, 0.04808947f, -0.02386946f, 
    -0.01032586f, -0.01266358f, 0.04525774f, -0.04193646f, 0.05175661f, -0.02926062f, -0.03749475f, -0.08183008f, 
    -0.00184578f, -0.06628450f, -0.05256623f, -0.03162144f, -0.07368578f, -0.02532860f, 0.03695652f, 0.06004571f, 
    0.05501721f, 0.01004472f, 0.00627459f, -0.01823423f, -0.07074148f, 0.02722743f, -0.03097516f, 0.00543892f, 
    0.04283560f, -0.04075860f, 0.02772528f, 0.04049905f, 0.04943164f, 0.03651971f, -0.03020607f, 0.03385855f, 
    0.04773225f, -0.04827967f, 0.02044886f, -0.01864783f, 0.00078688f, -0.01621169f, -0.01381027f, -0.00622030f, 
    -0.02772305f, -0.05845494f, 0.05316106f, -0.06376996f, -0.01036107f, 0.04630915f, -0.06906544f, 0.05723448f, 
    -0.04154231f, -0.05048225f, 0.00436144f, 0.02032718f, 0.06140909f, 0.01141122f, 0.04012932f, 0.01424566f, 
    -0.08037140f, -0.04094020f, -0.06118781f, -0.01729803f, -0.04587582f, 0.01554179f, -0.03035166f, 0.01134815f, 
    -0.00727814f, 0.02506207f, 0.05545849f, 0.05294777f, -0.08061420f, 0.03898066f, -0.08205336f, 0.02895461f, 
    -0.02064054f, -0.06003629f, -0.03732682f, -0.07599061f, 0.00052655f, -0.00164133f, -0.07521878f, 0.02698837f, 
    0.02269795f, -0.03242001f, 0.01113569f, 0.04296421f, -0.01704674f, -0.05070382f, -0.05832210f, -0.08055072f, 
    -0.07891270f, -0.07057100f, -0.07742406f, -0.07221254f, -0.01856472f, 0.01314469f, -0.05065884f, 0.03011602f, 
    -0.06273380f, 0.05413722f, -0.02204006f, 0.00328356f, -0.06983829f, 0.02320733f, -0.04959169f, 0.05228157f, 
    0.04748947f, -0.05671276f, -0.04457689f, -0.03645709f, -0.03357278f, -0.02122754f, -0.05502635f, -0.05403493f, 
    0.03612469f, -0.05636270f, 0.05651487f, -0.07276513f, 0.05504002f, 0.02820466f, -0.07370029f, -0.06036216f, 
    -0.01046469f, -0.06449635f, -0.07230219f, 0.03987197f, 0.00036160f, -0.00408179f, -0.00990890f, 0.02751706f, 
    -0.02864659f, -0.07873075f, -0.02560535f, -0.01017504f, -0.02043322f, -0.03272074f, -0.05015755f, 0.04744899f, 
    -0.01523256f, -0.04737448f, -0.03806772f, -0.05670126f, 0.02542591f, -0.00086497f, -0.04011528f, 0.02568237f, 
    0.03982203f, -0.03177099f, -0.02347066f, -0.06970228f, 0.03999358f, 0.00416594f, -0.02697304f, -0.00129983f, 
    0.17513150f, 0.42461386f, 0.06414643f, -0.27780879f, 0.09786250f, -0.13279814f, 0.01510327f, 0.07104273f, 
    -0.26763999f, 0.01531156f, 0.08972479f, -0.40099755f, -0.12833671f, 0.03097069f, -0.06147178f, 0.03159014f, 
    0.10473527f, 0.01525716f, -0.12947725f, -0.11868010f, -0.17293204f, -0.28897020f, -0.47786766f, -0.43468478f, 
    -0.49730745f, -0.10581831f, 0.22507045f, 0.20589525f, 0.04199258f, -0.06681313f, 0.09827914f, -0.05820619f, 
    -0.18064567f, -0.21053641f, -0.16519241f, -0.05571969f, 0.40537515f, 0.18287100f, 0.11187517f, 0.26708090f, 
    -0.04450718f, 0.14308375f, -0.03248393f, -0.09386927f, 0.02350975f, -0.14594479f, 0.14786473f, 0.03031925f, 
    0.02943670f, -0.01313342f, -0.01536883f, 0.17575072f, 0.16584353f, -0.07665648f, 0.09891953f, 0.06639325f, 
    0.26765412f, 0.12846734f, -0.01297986f, 0.39203486f, -0.04914096f, -0.12092092f, -0.10225402f, -0.11207694f, 
    0.02046104f, 0.05001814f, 0.01362931f, -0.12843429f, 0.21457849f, 0.13347018f, 0.21992274f, 0.43769088f, 
    -0.13650714f, 0.15445180f, -0.08533171f, 0.09119709f, 0.12639697f, -0.00889873f, 0.03444833f, -0.00028802f, 
    0.09226754f, -0.15336224f, 0.14656104f, 0.10775483f, -0.18007067f, -0.09710658f, 0.08726756f, 0.26890916f, 
    -0.08032398f, 0.02110595f, -0.04396369f, 0.01522345f, -0.09313105f, 0.04700365f, 0.19364452f, 0.12380290f, 
    0.08141699f, -0.01069290f, -0.08524700f, 0.03946313f, 0.10692346f, 0.01843455f, 0.04079244f, 0.19621663f, 
    -0.00641983f, -0.05364891f, 0.12139494f, 0.22014868f, -0.25999838f, 0.18483563f, -0.06106371f, 0.03689567f, 
    0.16048215f, 0.01659869f, -0.13736944f, -0.13833083f, -0.16345944f, -0.22210810f, -0.13666295f, -0.05344017f, 
    0.17407328f, -0.17736320f, 0.13932182f, -0.13582061f, -0.10674852f, 0.00593248f, -0.04942105f, -0.21536611f, 
    0.03945456f, 0.04445901f, -0.17170109f, 0.02897247f, 0.08985674f, -0.16550195f, 0.02916610f, 0.08935200f, 
    0.02792911f, -0.00315776f, 0.02599137f, 0.14868984f, -0.18229435f, -0.01953628f, -0.21241660f, -0.26929203f, 
    0.30355555f, -0.04279248f, 0.03069668f, -0.03923651f, -0.04396062f, 0.07052458f, -0.15603161f, -0.04421768f, 
    0.33323467f, 0.16380957f, 0.03739022f, 0.20995487f, 0.22736041f, 0.10170486f, 0.46211404f, 0.07417328f, 
    -0.19430295f, -0.14231920f, 0.05580507f, 0.10557487f, -0.02912685f, 0.11360536f, 0.11839710f, 0.04689179f, 
    -0.10945658f, 0.21254659f, -0.00618999f, 0.17022634f, -0.01659403f, -0.08005641f, -0.02601442f, -0.08852454f, 
    0.05567004f, 0.14892851f, 0.11148523f, 0.13173527f, 0.13547537f, 0.28934887f, -0.01072981f, 0.06029217f, 
    0.03686683f, -0.03504167f, -0.14123850f, -0.01593482f, -0.15018721f, -0.11349971f, -0.08786876f, 0.05985563f, 
    -0.01422171f, -0.24021052f, -0.25118613f, 0.12206217f, 0.11417808f, -0.16767587f, -0.24370497f, 0.03378235f, 
    -0.12317033f, 0.10964829f, -0.01054940f, 0.10114615f, -0.25123972f, -0.27514732f, 0.01837130f, 0.10086180f, 
    -0.01531728f, -0.01772831f, -0.04524196f, 0.00756674f, 0.34540904f, 0.11175955f, 0.27841762f, 0.08924762f, 
    -0.20127611f, -0.08201172f, -0.16869114f, 0.18209596f, 0.17968313f, 0.13023846f, -0.09250712f, -0.17695019f, 
    0.11316320f, -0.03960825f, -0.00564391f, 0.00564407f, 0.33831084f, -0.01223068f, 0.01650280f, 0.27138597f, 
    -0.02772518f, 0.08307806f, -0.08535922f, 0.31474948f, 0.15384942f, -0.10648640f, 0.04846718f, 0.12628566f, 
    0.00985312f, -0.08767329f, 0.09775805f, 0.17258243f, 0.03436846f, 0.21945617f, -0.05372027f, 0.16969542f, 
    -0.23938867f, -0.07358678f, -0.05363834f, -0.31997615f, -0.09618678f, 0.04440161f, -0.06791374f, 0.01880055f, 
    -0.00621018f, 0.02671039f, -0.00126436f, 0.01846428f, -0.05390793f, -0.04216477f, -0.04921941f, -0.19443806f, 
    -0.07494461f, 0.10840578f, 0.23664863f, 0.00806313f, -0.06123454f, 0.02618448f, 0.02302554f, 0.00039090f, 
    -0.06931324f, -0.02635382f, 0.06280118f, 0.05655327f, 0.03772656f, -0.08526435f, -0.07376035f, 0.15777928f, 
    -0.02843450f, -0.03289248f, 0.07929481f, 0.08618812f, 0.12518251f, 0.15688981f, -0.00507566f, 0.07138466f, 
    0.12074312f, -0.15937789f, -0.00956416f, 0.11485309f, 0.01424403f, 0.01756008f, -0.06100598f, -0.09349275f, 
    0.02719929f, 0.09621344f, 0.01648197f, 0.08723886f, -0.30439323f, -0.20116439f, -0.00482887f, 0.05020975f, 
    0.01992984f, -0.11769073f, -0.04069519f, -0.16518074f, -0.08780569f, -0.13267118f, 0.05243080f, -0.06429534f, 
    -0.01228022f, -0.08610277f, -0.02357572f, 0.18796673f, 0.03858696f, -0.12480994f, -0.15685780f, 0.03256128f, 
    0.13255128f, 0.00285435f, 0.15604861f, -0.00294335f, 0.18738249f, -0.03709846f, -0.05539325f, -0.02860423f, 
    -0.03922027f, 0.05989711f, 0.14967577f, -0.02439323f, 0.09519436f, 0.03610191f, 0.08725905f, 0.18853329f, 
    -0.01766758f, -0.04044209f, -0.09042326f, 0.01374063f, -0.12625954f, -0.13738666f, 0.14381941f, 0.08892942f, 
    -0.02561829f, -0.08730347f, 0.11819083f, 0.06870516f, -0.33852577f, -0.11793604f, 0.04157616f, -0.22414057f, 
    0.09549633f, 0.09109726f, 0.00937501f, -0.02133540f, 0.01933979f, -0.03966701f, -0.06269475f, -0.10827726f, 
    0.02840323f, 0.04014224f, 0.07120049f, -0.10381687f, -0.02020348f, -0.02952959f, -0.02081510f, 0.02916173f, 
    0.12170726f, -0.07301137f, -0.11206841f, 0.03388573f, 0.21075138f, 0.38420340f, 0.02955622f, -0.11093098f, 
    -0.04071033f, -0.00791070f, -0.00512343f, 0.06367187f, 0.04026760f, 0.00420857f, 0.05128108f, 0.10928497f, 
    -0.05591354f, 0.14537814f, -0.00734174f, -0.24441768f, -0.02535300f, 0.00018989f, -0.03291068f, 0.18559319f, 
    -0.17768000f, -0.01745527f, -0.14607246f, -0.16399369f, -0.18944366f, 0.08439106f, -0.20414019f, -0.08782484f, 
    0.01965719f, -0.08915656f, -0.08991221f, -0.21022412f, -0.01738314f, -0.33806270f, -0.20749250f, -0.26350585f, 
    0.24923977f, 0.13108590f, 0.02712514f, 0.01023140f, -0.00470524f, -0.05931133f, 0.20632252f, 0.00041000f, 
    -0.00875705f, 0.02267762f, -0.13358240f, -0.04539834f, 0.34421724f, -0.05661683f, 0.01964472f, 0.09600352f, 
    -0.16242920f, 0.04770755f, 0.03722231f, -0.12474107f, -0.03994255f, -0.07851336f, 0.02842901f, -0.11452235f, 
    0.16191608f, 0.13713405f, 0.14771138f, 0.06338239f, -0.00672391f, -0.03720497f, 0.08187115f, 0.22470392f, 
    0.22835277f, 0.25357002f, -0.03388209f, 0.19540547f, 0.03438809f, -0.20285375f, 0.12480093f, 0.04826479f, 
    -0.08737094f, -0.07693964f, -0.03461976f, 0.09750127f, 0.24293648f, 0.11446045f, 0.12139981f, 0.16141695f, 
    -0.01967891f, 0.14646785f, -0.22953257f, 0.25553793f, 0.06149966f, -0.07550899f, -0.07136368f, -0.04004281f, 
    -0.20811306f, -0.03945263f, 0.24099472f, 0.06429975f, 0.08882659f, -0.07676748f, -0.00500962f, 0.03162213f, 
    0.17918676f, 0.18883950f, 0.04354494f, 0.02266814f, -0.08256713f, 0.10643040f, 0.07707805f, 0.10403879f, 
    0.23246506f, -0.16986965f, -0.02550437f, -0.15553306f, 0.16250399f, -0.01353865f, 0.11868665f, 0.20449834f, 
    -0.19079009f, -0.14826170f, 0.07121668f, 0.08885944f, 0.22426714f, 0.12561312f, -0.05122499f, -0.11564849f, 
    0.10247706f, -0.09755451f, -0.23676021f, -0.08739069f, 0.00457515f, -0.00285099f, -0.06051226f, -0.07092902f, 
    -0.09895311f, 0.01423409f, 0.06912737f, 0.04999020f, -0.09377599f, -0.25438192f, -0.17141478f, -0.34661257f, 
    0.00000563f, -0.02872962f, -0.15572751f, 0.06214023f, 0.15258867f, 0.13593085f, 0.09663621f, 0.22708240f, 
    0.24045208f, 0.02329338f, 0.26586130f, 0.09042241f, -0.04811233f, -0.04236444f, -0.26024938f, -0.02844043f, 
    0.53965497f, 0.01604655f, -0.05674724f, -0.02615375f, 0.09695500f, 0.14699806f, 0.03451090f, 0.00767184f, 
    0.07282589f, 0.02150781f, 0.17069247f, 0.00986984f, 0.13995937f, -0.11332776f, -0.40021998f, -0.39691541f, 
    0.16340928f, 0.06929581f, 0.02395977f, -0.12619504f, 0.05925743f, 0.06175707f, 0.14657162f, 0.05044265f, 
    -0.04965655f, 0.17960981f, 0.14629750f, 0.32324725f, -0.01838647f, 0.11225411f, 0.11377067f, 0.24899805f, 
    -0.01358452f, 0.10212649f, 0.07977613f, 0.16827336f, 0.02713331f, 0.25940624f, -0.07407017f, -0.12066171f, 
    -0.05282359f, -0.16908644f, -0.17906626f, -0.17148286f, -0.22057092f, -0.14264561f, 0.00388824f, 0.00992913f, 
    0.17076099f, 0.11167921f, 0.10140477f, 0.11458977f, 0.09234864f, -0.03052889f, -0.03615379f, -0.08256193f, 
    0.10349809f, 0.07791475f, 0.09960433f, -0.01590277f, -0.15736191f, 0.07534201f, -0.08122139f, 0.04568565f, 
    0.03972061f, 0.05278476f, 0.01520964f, -0.09438372f, -0.01991953f, -0.01115484f, 0.08247963f, -0.02809960f, 
    -0.00830705f, 0.15458961f, -0.10266408f, -0.03882330f, -0.01397282f, 0.06954009f, -0.15430002f, 0.02931083f, 
    -0.03752108f, 0.08189453f, 0.03187682f, -0.04122950f, -0.25837669f, -0.11932506f, 0.18518266f, -0.12609597f, 
    0.15687834f, 0.10664304f, 0.00347635f, 0.04473447f, -0.05104555f, 0.09084998f, -0.05207969f, 0.07842255f, 
    -0.14091645f, -0.03684954f, 0.14527041f, -0.05407865f, 0.12915066f, 0.11387722f, -0.00142156f, 0.08552799f, 
    -0.03674883f, 0.04002355f, 0.03059577f, -0.15486057f, -0.07904106f, -0.11953019f, 0.00219390f, -0.03239130f, 
    0.07667100f, -0.01834089f, 0.03506984f, -0.04280986f, -0.22321102f, -0.14210849f, -0.11981610f, -0.03624458f, 
    0.10300918f, -0.19017802f, 0.02041605f, 0.05522747f, -0.06727061f, 0.06017321f, -0.05956056f, -0.06190241f, 
    0.00755958f, 0.11085112f, -0.05892596f, 0.11669515f, 0.01683694f, 0.13582844f, 0.05857866f, -0.26791137f, 
    0.09756506f, 0.03513536f, 0.01094085f, 0.25172579f, 0.15800536f, 0.03789482f, -0.03795049f, -0.08837080f, 
    -0.04201435f, 0.26873192f, 0.00502275f, -0.05494200f, 0.09127010f, 0.28248525f, 0.00705644f, 0.08548267f, 
    -0.01130266f, -0.00838240f, -0.01946171f, 0.01956180f, 0.02357329f, -0.01342512f, 0.18064290f, 0.09178996f, 
    -0.04157075f, -0.02071564f, -0.01792191f, -0.08322336f, -0.07208367f, 0.00534224f, -0.05407424f, 0.03445497f, 
    -0.02080908f, 0.24612546f, 0.08727002f, 0.09168267f, -0.04250927f, 0.04131200f, 0.04674093f, 0.09969399f, 
    -0.02644387f, 0.05240585f, 0.19897917f, 0.01442070f, 0.02846287f, 0.30739406f, 0.00145359f, -0.06738226f, 
    0.00608299f, -0.01356614f, 0.04166547f, -0.10516924f, 0.16768490f, 0.05660211f, 0.07089442f, -0.04015237f, 
    -0.09800743f, 0.31587550f, 0.06522599f, -0.13794775f, -0.08979861f, 0.01746193f, 0.23290960f, 0.08115496f, 
    0.01385619f, -0.14643602f, 0.03697542f, -0.12955560f, -0.16163296f, -0.01478480f, -0.35029426f, -0.13911699f, 
    0.02077079f, -0.06707140f, 0.15544276f, 0.03511656f, 0.16383608f, 0.11055232f, 0.02253618f, -0.23230310f, 
    0.29293939f, -0.11055569f, -0.00970644f, 0.04064130f, 0.03901023f, -0.06824517f, -0.05658815f, -0.00442436f, 
    -0.01323209f, -0.05481957f, 0.01731629f, 0.12999913f, 0.10422621f, -0.05279630f, 0.04457107f, 0.10883412f, 
    -0.18799745f, 0.04054686f, -0.00543852f, -0.02496591f, 0.01384932f, 0.06795395f, 0.07744130f, 0.20786478f, 
    -0.12763368f, 0.01280448f, 0.00914766f, -0.20174664f, 0.10661812f, 0.05081397f, -0.03220148f, 0.24184573f, 
    0.02198703f, 0.16507491f, -0.06594585f, -0.04050779f, -0.13087168f, -0.08685751f, 0.12116103f, -0.14111459f, 
    -0.04251491f, -0.08234127f, -0.03581744f, -0.03758740f, 0.15889883f, -0.04722577f, -0.03607501f, 0.02775205f, 
    0.03885542f, -0.06568815f, -0.03315981f, 0.00088567f, 0.20748031f, 0.12478694f, 0.20181713f, 0.18563595f, 
    0.02019172f, -0.02852203f, -0.01856943f, -0.06331290f, 0.28308359f, 0.03178401f, -0.14546585f, 0.13890721f, 
    -0.03980882f, 0.09951197f, 0.21685575f, 0.13743746f, 0.18540704f, 0.08033841f, 0.15363887f, 0.12102251f, 
    0.23251326f, 0.05634770f, -0.02024350f, 0.16027673f, -0.01306790f, 0.00048346f, -0.02198796f, 0.01507416f, 
    0.22512418f, 0.02974441f, -0.00956942f, 0.01980291f, 0.11223482f, 0.13602152f, -0.07731468f, 0.01136377f, 
    -0.06495658f, -0.09779853f, -0.06127988f, -0.04756299f, 0.11022894f, 0.10484961f, 0.05126334f, 0.03543021f, 
    -0.24662742f, 0.22137272f, 0.09915928f, -0.00104272f, 0.00049594f, -0.07388610f, -0.01397537f, -0.02637464f, 
    -0.05636190f, -0.09802177f, 0.10431691f, 0.03987897f, -0.13107648f, -0.25073779f, -0.06881478f, -0.07308789f, 
    -0.06141938f, 0.00593308f, 0.03915523f, 0.00374183f, -0.04830268f, 0.01346694f, 0.07429996f, 0.11208846f, 
    -0.06362910f, -0.07325825f, -0.07288218f, 0.00173046f, -0.00499560f, -0.11867196f, 0.04515491f, 0.06025083f, 
    -0.03795623f, 0.00713747f, -0.01622307f, 0.08037627f, 0.05818563f, 0.03589775f, -0.07939412f, -0.11521404f, 
    0.03955687f, -0.05646503f, -0.02558620f, 0.03650650f, -0.01939320f, 0.01339076f, -0.03596399f, -0.03401493f, 
    0.04965685f, -0.13293412f, 0.08795416f, 0.09777724f, -0.03045588f, 0.02649855f, -0.10113863f, -0.12584884f, 
    0.05327531f, 0.09359566f, -0.05777177f, -0.00627008f, -0.11797763f, -0.24964459f, -0.04047529f, -0.13554710f, 
    0.11255879f, -0.11395249f, 0.07752916f, 0.15094692f, 0.03210965f, 0.11592139f, -0.02605077f, 0.02843048f, 
    0.13705567f, -0.34477833f, -0.15190892f, 0.04342831f, 0.20329154f, -0.10805783f, -0.17888765f, 0.02341609f, 
    0.07739780f, 0.06307630f, 0.13174833f, 0.04381530f, 0.04242863f, -0.18914039f, 0.16167416f, -0.06200504f, 
    0.02550464f, -0.04356897f, -0.11144369f, -0.02309071f, 0.01808663f, 0.11036079f, 0.22596489f, 0.23669516f, 
    -0.22420616f, -0.00414834f, -0.00694422f, -0.00838696f, -0.13925171f, 0.05293853f, 0.10208272f, 0.04421271f, 
    0.03829389f, 0.13786276f, 0.02865892f, -0.03967199f, 0.10024989f, 0.15244827f, -0.00235527f, -0.16579325f, 
    0.11897665f, -0.05704215f, -0.15350519f, -0.06440103f, 0.03445248f, -0.08805711f, 0.00516367f, -0.06626241f, 
    -0.00682915f, 0.08976265f, -0.03381656f, 0.01364108f, 0.05675875f, 0.13585413f, 0.06102224f, -0.00859527f, 
    -0.04695857f, 0.04630337f, 0.09661491f, -0.07776316f, 0.11898255f, -0.05554732f, 0.04683087f, 0.06019311f, 
    0.06070727f, -0.05485814f, 0.07630449f, 0.07830244f, -0.11165059f, -0.08609983f, -0.09106414f, -0.13166410f, 
    -0.03137767f, -0.06944828f, -0.10241433f, -0.16423582f, 0.19158490f, -0.09226374f, 0.32815403f, 0.04251707f, 
    0.00231160f, -0.04988286f, -0.01805023f, 0.07287303f, -0.09393448f, 0.19741093f, 0.05605976f, -0.08516821f, 
    -0.05739415f, 0.11445134f, 0.07636933f, 0.01201408f, 0.10282967f, -0.01242581f, 0.19705822f, 0.08378736f, 
    -0.05694448f, -0.01715762f, -0.19341260f, -0.01683242f, -0.06028375f, -0.00184781f, 0.06842267f, -0.13500559f, 
    0.10478900f, 0.18471058f, 0.18020369f, 0.41034099f, 0.02292191f, 0.06482445f, -0.02399733f, 0.06972717f, 
    -0.02788365f, 0.03818214f, 0.02900514f, -0.01498614f, 0.14971395f, 0.20270453f, 0.03199054f, 0.20264499f, 
    0.33708072f, -0.10889949f, 0.08532106f, -0.06426816f, 0.06990973f, -0.06783111f, 0.07398944f, -0.00474671f, 
    -0.01037529f, 0.15864882f, -0.06894732f, 0.11645482f, 0.00818938f, 0.18863076f, 0.11302600f, 0.21816105f, 
    -0.20507227f, -0.15536492f, 0.05295890f, -0.00510577f, -0.14144671f, -0.03419016f, 0.02983182f, -0.02241440f, 
    -0.02253335f, 0.06751984f, -0.01019586f, 0.07465106f, -0.00293831f, 0.06241807f, 0.00384028f, -0.14056008f, 
    0.05697839f, 0.06380227f, -0.00004906f, -0.18327127f, 0.02324997f, 0.02972106f, -0.01214543f, -0.14589134f, 
    0.08449680f, 0.02392227f, 0.00630149f, 0.05738924f, 0.02782506f, -0.04498412f, -0.11203128f, 0.06468743f, 
    0.08960421f, -0.03270027f, 0.12547378f, -0.11885491f, -0.01141763f, 0.16915567f, 0.04765450f, 0.06779184f, 
    -0.04514407f, -0.07255854f, -0.16592759f, -0.07914159f, -0.34561452f, -0.08302672f, -0.09560847f, 0.00963744f, 
    -0.09784503f, -0.11773183f, -0.11946761f, -0.03057236f, -0.07028807f, -0.11350422f, -0.02944604f, -0.03589305f, 
    -0.23859584f, -0.11934582f, -0.00743168f, 0.11625224f, -0.18475719f, -0.07725688f, -0.08268400f, -0.08326625f, 
    0.01178294f, 0.03375386f, 0.11485802f, 0.03598177f, 0.25229338f, 0.30260292f, 0.46415979f, 0.33123624f, 
    -0.03100480f, -0.11516206f, -0.02688499f, -0.03675106f, 0.03340636f, 0.02222550f, -0.01032436f, 0.02727681f, 
    -0.03710780f, -0.09562020f, -0.13421996f, -0.23058082f, 0.02042192f, 0.17057048f, -0.00902784f, 0.04324613f, 
    0.07808091f, 0.00479415f, -0.11310675f, 0.12053672f, -0.17357220f, -0.25461364f, -0.09163311f, 0.33027694f, 
    0.15165670f, 0.15381350f, 0.00690781f, 0.04516751f, -0.05991459f, 0.00220949f, 0.02820244f, -0.14944817f, 
    -0.06724781f, 0.07991912f, -0.03261082f, 0.01460711f, 0.00569867f, 0.06126844f, -0.28444448f, 0.04025244f, 
    0.07062156f, -0.11536314f, 0.12132608f, 0.01694906f, 0.29120249f, 0.13711458f, 0.05056347f, 0.16274351f, 
    0.07947335f, 0.01770414f, -0.00288165f, -0.13636363f, 0.04415243f, 0.08783558f, 0.12854634f, -0.06278716f, 
    -0.13246822f, 0.01846890f, -0.12849163f, 0.18398346f, -0.05635539f, -0.11175270f, 0.15309404f, -0.14096449f, 
    0.06146858f, 0.02677676f, 0.05346953f, 0.05026016f, 0.26891434f, -0.06598169f, 0.04664366f, 0.10718771f, 
    0.06690697f, 0.08874550f, -0.11046247f, -0.05975062f, -0.01701650f, 0.02696122f, 0.15509912f, -0.16034752f, 
    -0.06438284f, -0.07606323f, 0.17384131f, 0.01062821f, -0.14388007f, -0.04067092f, -0.07380001f, -0.15164910f, 
    -0.09259346f, 0.11287057f, 0.06178231f, 0.22897908f, -0.09035560f, 0.01985938f, 0.13392255f, 0.08497986f, 
    0.04478133f, 0.01955673f, 0.06514212f, 0.10099359f, 0.25118357f, 0.09382275f, -0.02588406f, 0.19814453f, 
    0.36496204f, 0.19789435f, 0.22355689f, 0.26959568f, 0.08914810f, -0.01107213f, 0.15050061f, 0.07946996f, 
    -0.03029309f, 0.06361817f, 0.06364094f, 0.06298139f, 0.11822863f, 0.01706567f, 0.00847043f, 0.32182086f, 
    -0.02695810f, 0.12006924f, 0.08647642f, -0.05299832f, -0.09829142f, -0.15205543f, -0.01393203f, 0.07879814f, 
    0.25445271f, -0.04931803f, -0.15936707f, 0.06492491f, 0.03780004f, 0.08627091f, -0.00983402f, -0.15979147f, 
    -0.08196159f, -0.08714510f, -0.17715110f, -0.13165885f, -0.19852339f, -0.16226588f, -0.03795850f, -0.04595970f, 
    0.07420403f, 0.01132721f, -0.01225317f, 0.07281835f, 0.00167607f, 0.00846677f, -0.06358241f, 0.05688855f, 
    -0.01695755f, -0.31789508f, 0.23038128f, -0.25164318f, -0.02115187f, 0.19561052f, -0.08844197f, -0.17932214f, 
    0.04242156f, -0.03039467f, -0.06516908f, -0.06814907f, -0.13355865f, 0.08633364f, -0.06358346f, -0.11996438f, 
    0.03155785f, 0.11586022f, 0.00249634f, 0.02326141f, -0.15522994f, -0.11650585f, 0.01208992f, 0.02794449f, 
    0.05969774f, 0.13368715f, -0.21922044f, 0.01072439f, 0.00952384f, 0.16817071f, 0.07913388f, 0.07991840f, 
    -0.08791229f, -0.08363111f, -0.15244578f, 0.03574098f, 0.33810028f, 0.21285090f, 0.10467588f, -0.07112176f, 
    0.01639211f, 0.12422043f, -0.01394493f, -0.02441436f, -0.23820499f, -0.09109055f, -0.04437104f, 0.00852572f, 
    -0.10201690f, -0.11417931f, -0.05473968f, -0.10440783f, 0.02951831f, 0.11988643f, 0.08260755f, 0.19228290f, 
    0.02925936f, -0.14384769f, -0.06321750f, -0.01196262f, 0.05614847f, 0.12306482f, 0.00392299f, 0.00840413f, 
    -0.08465405f, -0.01636233f, 0.12115858f, -0.02803972f, -0.03209497f, 0.07909316f, -0.03169601f, -0.06026314f, 
    -0.19719516f, -0.24965186f, -0.08333743f, 0.06013352f, 0.11274251f, 0.17306077f, 0.02422656f, 0.10178038f, 
    0.18470766f, -0.23644111f, -0.09723464f, 0.10600420f, 0.21536589f, 0.10928626f, -0.19360623f, -0.10239092f, 
    0.02611356f, -0.05048009f, 0.00230384f, -0.16016446f, -0.01547296f, -0.00248263f, -0.12204442f, -0.10293401f, 
    0.41508341f, -0.56874269f, -0.13357706f, -0.15717860f, 0.10247050f, 0.07934536f, -0.11295897f, 0.12189609f, 
    0.02063317f, 0.03898630f, -0.18655869f, 0.08464093f, -0.05451601f, 0.01623949f, -0.17816459f, -0.15150321f, 
    0.02375891f, -0.14745538f, -0.03865449f, 0.01632475f, 0.06650797f, 0.00150852f, -0.05050861f, -0.02890132f, 
    -0.12057557f, -0.00119710f, 0.05910204f, 0.04641483f, -0.11719375f, -0.04106033f, -0.07492007f, 0.32909817f, 
    -0.01887244f, 0.03675402f, 0.13424693f, 0.15539934f, -0.19103433f, -0.11815265f, -0.05726349f, 0.18372476f, 
    0.00172440f, 0.00466641f, -0.08972427f, -0.18800452f, 0.05117756f, 0.10294320f, 0.11078247f, 0.12369701f, 
    -0.18269901f, 0.03738782f, -0.09502735f, 0.22415215f, 0.06072057f, -0.21924067f, 0.00571173f, -0.10302726f, 
    -0.07119837f, 0.04304203f, 0.01726738f, 0.01001086f, 0.40096989f, 0.13145979f, -0.00959230f, -0.11305645f, 
    0.13624133f, 0.14590389f, 0.03321034f, 0.03762035f, -0.01406228f, -0.09040651f, -0.12796590f, 0.14109521f, 
    0.11944160f, 0.20630260f, 0.29013589f, 0.02098235f, -0.00678908f, 0.01289648f, 0.07377496f, 0.13275592f, 
    -0.02824653f, -0.03578510f, -0.02291695f, -0.03760083f, -0.14828919f, -0.25716287f, -0.22702827f, -0.03401109f, 
    0.21431106f, 0.04974084f, 0.07772645f, 0.11100137f, 0.11721390f, -0.04636909f, 0.07408185f, -0.04793907f, 
    -0.26231918f, -0.13066839f, -0.03390805f, -0.07753932f, -0.09624844f, 0.13853368f, 0.00817877f, -0.33534887f, 
    -0.06800556f, -0.05833495f, 0.18033408f, 0.03648331f, 0.30884424f, 0.29999274f, 0.27307561f, 0.15016195f, 
    0.05926597f, 0.03121007f, 0.11690482f, 0.01616237f, -0.08908557f, -0.17447275f, -0.06784043f, -0.04792807f, 
    0.30597386f, 0.17968735f, 0.30204931f, 0.14616136f, 0.20080912f, 0.02363914f, 0.05176299f, 0.06119796f, 
    0.12309245f, -0.04620358f, -0.02758702f, -0.09311828f, -0.09224463f, -0.01865530f, -0.03611822f, 0.12886928f, 
    0.14533551f, -0.03443103f, -0.16056487f, -0.25405797f, 0.16698876f, -0.00667641f, 0.11730676f, 0.06073120f, 
    0.25843146f, 0.38473216f, 0.07819153f, 0.11475796f, 0.05607245f, 0.09910608f, 0.19122256f, 0.29174954f, 
    0.03010636f, 0.09110553f, 0.10077045f, 0.09078579f, -0.19071248f, -0.04632757f, 0.28257203f, 0.10247409f, 
    -0.05168447f, 0.02537293f, -0.07889217f, -0.27370858f, -0.01823350f, -0.07110430f, -0.13634034f, -0.07357328f, 
    0.38872564f, -0.05847761f, -0.08608900f, -0.23775062f, -0.01997321f, -0.20074393f, 0.29588291f, 0.08926055f, 
    -0.06379539f, 0.06212088f, 0.14720728f, -0.23139790f, -0.18437909f, -0.05876578f, -0.14560430f, 0.13940464f, 
    0.00836282f, 0.40126920f, -0.07936629f, 0.02816890f, 0.03956488f, -0.11236292f, -0.10530050f, -0.04161758f, 
    -0.44982344f, 0.57549369f, 0.13197282f, 0.01792271f, 0.07234471f, 0.07091094f, 0.10642262f, 0.12773091f, 
    -0.10039128f, -0.07102104f, 0.22120024f, -0.03642882f, -0.10732216f, 0.17274016f, 0.31043226f, -0.00638109f, 
    0.05417425f, 0.11025164f, 0.02596104f, -0.02772466f, 0.15934937f, 0.13488171f, 0.07158326f, 0.05257579f, 
    -0.00586320f, 0.08742623f, 0.20792679f, -0.03712977f, 0.12842938f, -0.08400115f, -0.10347401f, -0.22915347f, 
    0.07964601f, 0.04440477f, -0.08608008f, -0.06634746f, -0.08469038f, -0.03325934f, -0.00928918f, 0.02213035f, 
    0.13088226f, -0.10293090f, -0.10858204f, -0.12666903f, -0.09916640f, -0.04700201f, 0.03098636f, 0.10868928f, 
    0.27805910f, 0.02530623f, -0.18762212f, 0.17753328f, -0.10012358f, 0.05334627f, -0.23827939f, -0.05532213f, 
    0.21506542f, -0.07597412f, -0.15001349f, 0.08748202f, -0.33773667f, 0.26732042f, 0.37178054f, 0.16697642f, 
    0.07213456f, 0.14197896f, -0.04802500f, 0.05040935f, 0.02267222f, -0.06606825f, 0.05916570f, -0.14640602f, 
    0.06129642f, 0.09797961f, -0.13667691f, 0.11969493f, 0.19439337f, 0.09258933f, 0.00349518f, -0.04075372f, 
    0.01921890f, -0.07441711f, -0.02878769f, 0.18542790f, -0.00440581f, 0.10575441f, 0.12326796f, 0.08940431f, 
    -0.18295155f, -0.12213881f, -0.09401863f, -0.03447647f, 0.00967606f, 0.02614184f, -0.10493667f, 0.01752601f, 
    -0.20237832f, 0.30930403f, 0.16519588f, -0.11376514f, 0.04523198f, -0.10795649f, -0.01241401f, 0.12331650f, 
    -0.13926472f, 0.02583908f, 0.04526776f, 0.16450861f, 0.11306275f, 0.42253840f, 0.15038693f, 0.08121034f, 
    -0.00886485f, 0.30872980f, -0.10250817f, 0.11829376f, -0.11567259f, 0.05444627f, -0.03651598f, -0.05280422f, 
    -0.00116879f, 0.07138930f, 0.02229369f, -0.02468909f, 0.03071529f, 0.09072945f, -0.04575995f, 0.03529366f, 
    -0.15728326f, 0.06520315f, 0.11623195f, 0.31212431f, 0.14340027f, -0.21853189f, -0.05877396f, -0.00737502f, 
    -0.21278621f, -0.10434942f, 0.03520954f, -0.04174267f, 0.04598926f, 0.12570606f, -0.01009505f, 0.09380970f, 
    -0.33006346f, 0.02702885f, 0.16591536f, 0.14997166f, 0.22389434f, 0.04997310f, -0.13756414f, -0.10492855f, 
    -0.05706466f, -0.08103903f, 0.01089028f, 0.08535086f, -0.00606016f, 0.28067353f, -0.00845698f, 0.07030776f, 
    -0.20739859f, 0.04081493f, 0.05043666f, 0.11313911f, -0.15186344f, -0.12144174f, -0.25672299f, 0.02939796f, 
    -0.02771824f, 0.00150044f, 0.27344421f, 0.17854567f, 0.01655710f, 0.04592117f, 0.16475427f, 0.15773469f, 
    0.01883991f, 0.03002890f, -0.02553770f, 0.02245715f, -0.15948784f, 0.15281798f, -0.04915522f, 0.11612194f, 
    0.05163511f, 0.15344755f, -0.01653146f, -0.04478313f, -0.02835532f, 0.10671400f, 0.22605641f, 0.08697690f, 
    0.02477137f, 0.26961660f, 0.02530764f, 0.27238080f, -0.08398751f, 0.11251831f, 0.06611142f, 0.19600251f, 
    0.02246182f, -0.01097966f, -0.09904517f, -0.09704258f, 0.41888171f, -0.00300277f, 0.12602405f, 0.17369407f, 
    0.06313828f, 0.17182747f, 0.20239656f, 0.14127542f, -0.00355962f, 0.01780294f, 0.02236506f, 0.18420257f, 
    0.08390646f, 0.17347203f, 0.15800786f, -0.08991614f, -0.03312787f, -0.01574081f, -0.00072387f, 0.06821267f, 
    -0.08295113f, -0.03200419f, -0.19429731f, -0.01067043f, -0.04339714f, -0.13549763f, -0.03892585f, -0.18194363f, 
    -0.04017653f, -0.14428262f, -0.09030217f, -0.05024870f, 0.02834333f, 0.00875058f, -0.10797939f, -0.14373459f, 
    -0.26609880f, -0.14601025f, 0.13901792f, 0.08934090f, -0.15028164f, -0.04012755f, -0.08532336f, 0.03012551f, 
    -0.13846855f, 0.12467542f, 0.09431904f, 0.23818175f, 0.06997184f, -0.14539634f, -0.12186539f, 0.00647491f, 
    0.05844191f, -0.00847488f, -0.01689820f, 0.12275966f, 0.07807662f, 0.01070220f, 0.09984665f, 0.00846085f, 
    0.21595807f, -0.15895227f, -0.12099364f, 0.00590046f, 0.06284682f, 0.01612758f, -0.03886567f, 0.04021984f, 
    0.04846425f, 0.00842066f, -0.00708103f, -0.06367724f, 0.15335497f, 0.09809101f, 0.09385795f, -0.31623718f, 
    -0.08359322f, 0.00293714f, -0.08949573f, 0.05237541f, -0.07848082f, -0.02441997f, 0.05178634f, -0.04690418f, 
    -0.00310291f, 0.29800412f, -0.00761284f, 0.02423273f, -0.02585558f, 0.03672597f, 0.01273974f, -0.08696083f, 
    -0.00199097f, 0.00781912f, 0.02495424f, 0.21170980f, 0.10407832f, 0.14498965f, -0.27631956f, 0.31322414f, 
    0.06932808f, 0.03872647f, 0.07962951f, 0.09941679f, 0.08317774f, -0.01416912f, 0.08835942f, 0.05548827f, 
    0.04306786f, 0.16265796f, -0.21863103f, 0.01299347f, 0.08624671f, 0.15967940f, -0.10285290f, 0.02093320f, 
    -0.00358509f, -0.04151008f, -0.07948720f, -0.04204088f, -0.24627188f, -0.12539132f, -0.49325845f, -0.20127635f, 
    0.11132035f, 0.16074698f, 0.00112281f, -0.05832710f, 0.10050350f, 0.01350098f, 0.02015782f, -0.07187249f, 
    -0.11757108f, -0.24144664f, 0.17648630f, 0.10912289f, 0.10838368f, -0.02101219f, -0.01119202f, 0.14291190f, 
    -0.15613158f, 0.00301159f, 0.10761691f, 0.02592920f, -0.17756160f, 0.44567829f, -0.43758368f, 0.01583160f, 
    -0.09039170f, -0.08200952f, -0.09093667f, -0.18506236f, -0.03916131f, -0.04353156f, 0.08277378f, 0.13360570f, 
    0.01212639f, -0.04668224f, 0.27621791f, 0.00034724f, -0.00972751f, -0.03313305f, 0.17475230f, 0.01599686f, 
    -0.17168818f, -0.03413389f, -0.08794749f, -0.00653887f, -0.10880940f, 0.04230810f, 0.14388283f, -0.18889594f, 
    -0.00538654f, -0.08224479f, 0.03737375f, -0.00982465f, -0.09409376f, 0.02771579f, -0.08697875f, -0.08128481f, 
    0.15246776f, -0.11574356f, 0.10860869f, -0.10098632f, 0.09893523f, 0.11791349f, 0.16215779f, 0.14281823f, 
    0.06673508f, 0.02783553f, -0.07094860f, -0.09232429f, -0.02629586f, 0.12488810f, -0.06432623f, 0.05564057f, 
    0.06891824f, -0.11669046f, 0.26774096f, -0.06133751f, 0.08402093f, 0.06861944f, -0.07080999f, 0.14880964f, 
    0.18496644f, 0.13271205f, -0.26074642f, 0.01759695f, -0.00670211f, -0.00502874f, 0.09117532f, 0.03818038f, 
    0.24104655f, -0.03085902f, 0.01960963f, -0.09082368f, 0.12666437f, -0.05379634f, -0.18527134f, 0.00558938f, 
    0.00103073f, -0.05079671f, 0.00476724f, 0.02957535f, 0.09098910f, 0.20774585f, 0.03863502f, -0.03849249f, 
    -0.30212164f, 0.00146554f, -0.17253006f, -0.22560108f, 0.06194403f, 0.05012931f, -0.04344590f, -0.05674344f, 
    0.10798173f, 0.05146573f, 0.13902117f, 0.03937338f, -0.21074763f, -0.12896837f, -0.09412549f, -0.05191425f, 
    -0.00623741f, -0.13982661f, 0.01490406f, 0.04523488f, 0.07467525f, 0.17103244f, 0.05151422f, 0.12400745f, 
    -0.24505232f, -0.11915129f, 0.07200892f, 0.10386689f, -0.03885290f, -0.10113418f, 0.08384798f, 0.27096820f, 
    0.01224732f, 0.00473720f, 0.09815119f, 0.02849372f, 0.01077438f, -0.00121120f, 0.03428711f, -0.17647807f, 
    0.05889916f, 0.10469396f, 0.06215755f, -0.03169454f, -0.02498651f, -0.09127851f, -0.04585006f, 0.00253253f, 
    -0.00307389f, 0.20137239f, -0.19309390f, 0.10280824f, -0.06675243f, -0.04989110f, 0.14564699f, 0.07432947f, 
    0.00522692f, -0.02439028f, 0.11743503f, 0.06133948f, 0.08688586f, -0.21110877f, 0.15273088f, 0.44533116f, 
    -0.02261822f, 0.06808053f, 0.07756163f, 0.12164845f, 0.07645554f, 0.07993625f, -0.01060396f, 0.00437111f, 
    0.00369055f, -0.21339734f, 0.20191060f, 0.24523900f, -0.04028473f, -0.08587947f, -0.10211875f, 0.04862083f, 
    0.11881534f, 0.10426439f, 0.09434467f, -0.04287113f, -0.25354356f, 0.01342721f, 0.05919995f, 0.15656959f, 
    -0.02462128f, 0.02413048f, -0.05180082f, 0.09233776f, 0.12371793f, 0.13218066f, 0.13664351f, 0.08398316f, 
    -0.12271968f, 0.09226902f, 0.10444321f, 0.06919501f, -0.06667436f, 0.00571391f, 0.03559220f, -0.09726927f, 
    0.02107691f, 0.11309583f, 0.17641506f, 0.01352792f, -0.13066831f, -0.15357031f, 0.23430538f, 0.03010419f, 
    0.15704091f, -0.03982977f, -0.10454310f, -0.01428744f, -0.00687587f, -0.06784391f, 0.13846011f, -0.03245421f, 
    -0.00544926f, 0.08156616f, -0.04795669f, 0.05101572f, 0.05750520f, 0.07374284f, 0.28688636f, 0.17177136f, 
    -0.09315293f, -0.10863557f, -0.09414587f, -0.03497314f, -0.11582611f, -0.03807034f, 0.06518286f, -0.08308554f, 
    -0.09816422f, -0.00210354f, 0.07185674f, 0.03536855f, 0.06591614f, -0.03634311f, 0.05644339f, 0.07589243f, 
    -0.03940893f, 0.01752694f, 0.11452588f, 0.03113173f, 0.00932794f, 0.21917582f, 0.03567147f, -0.08076592f, 
    0.12332723f, 0.02886146f, 0.04749311f, -0.04191963f, -0.12338398f, -0.09095511f, 0.00012404f, 0.36580783f, 
    0.00591071f, 0.05136064f, 0.07982811f, 0.21708100f, -0.00108611f, 0.14680791f, 0.02506456f, 0.06776510f, 
    -0.08965803f, -0.05284268f, -0.11355779f, 0.08268990f, -0.02283623f, 0.04048974f, -0.02436899f, 0.03129366f, 
    0.10216624f, 0.07132393f, 0.09220498f, 0.06522335f, 0.13105640f, 0.09125878f, -0.00985311f, 0.00116634f, 
    -0.04016230f, 0.04016389f, -0.06244544f, 0.04070280f, 0.01004745f, 0.12355441f, 0.12385784f, -0.09688871f, 
    -0.06680851f, 0.25691348f, -0.04781317f, -0.08967129f, -0.07215758f, 0.07185791f, 0.01108707f, -0.02805075f, 
    0.09521504f, -0.18033263f, 0.05336211f, 0.01322851f, -0.37953356f, -0.21632339f, -0.15867864f, -0.14026305f, 
    0.03970521f, 0.07500356f, 0.04502846f, 0.10520114f, -0.07803635f, 0.07532481f, 0.00539760f, 0.13253371f, 
    -0.29422760f, -0.22431874f, -0.15337814f, -0.02175269f, -0.23525712f, -0.01234395f, 0.05839387f, 0.16082174f, 
    0.04718250f, 0.00192523f, -0.03821352f, 0.00685766f, 0.10055102f, 0.01756893f, 0.00391519f, 0.03053410f, 
    0.06468026f, -0.03484429f, 0.05457906f, -0.03453337f, -0.01591757f, 0.06588050f, -0.03776349f, -0.15491046f, 
    0.08578359f, -0.13615972f, 0.11901636f, 0.07235110f, 0.03990628f, -0.15285829f, 0.04115259f, -0.04763961f, 
    -0.02228982f, 0.13665703f, -0.16923186f, -0.01655846f, -0.20134927f, -0.39547047f, 0.17782117f, 0.33292282f, 
    -0.03423944f, -0.16247685f, 0.02043539f, -0.22597766f, 0.02542862f, 0.08040885f, 0.01693030f, 0.03737187f, 
    0.15245211f, -0.30840653f, 0.03462959f, -0.09969471f, 0.07024298f, -0.04878448f, -0.03515578f, 0.08820709f, 
    -0.06267169f, 0.17367545f, 0.15017757f, -0.06454584f, 0.19396898f, -0.13689902f, 0.05478099f, -0.11667219f, 
    0.10417776f, 0.02958455f, -0.01796423f, -0.06405348f, 0.04145113f, 0.00988483f, 0.02898101f, 0.12592579f, 
    0.05930457f, 0.05743062f, -0.23110777f, 0.00598259f, 0.04241700f, -0.00615993f, -0.00932570f, -0.21917896f, 
    -0.02175761f, 0.01586763f, 0.24840946f, -0.06774858f, 0.07188367f, -0.15219662f, 0.05030474f, 0.05385923f, 
    0.08180825f, -0.20871298f, -0.04357679f, 0.07564467f, 0.11019345f, -0.07977822f, -0.03327982f, -0.00023069f, 
    0.04967240f, 0.25266549f, -0.04927647f, -0.06848128f, 0.03744506f, -0.01725920f, 0.07556088f, 0.02697076f, 
    0.06921415f, 0.12249260f, 0.10908879f, -0.06167586f, 0.06138102f, -0.05903137f, 0.03504250f, 0.04525781f, 
    0.05529214f, 0.11303154f, 0.27429038f, 0.04302375f, 0.04657589f, 0.08523996f, 0.04391049f, -0.03944214f, 
    -0.02070552f, 0.30340287f, -0.05460181f, -0.14260499f, -0.02234280f, -0.24693625f, 0.21169104f, 0.11950749f, 
    -0.04071312f, 0.02129824f, 0.10080859f, 0.00902026f, -0.10297763f, 0.14302184f, 0.17178577f, -0.11407858f, 
    0.05196933f, 0.30396444f, 0.07966553f, 0.01790744f, -0.15978566f, -0.00260798f, 0.15491079f, 0.08225529f, 
    -0.00154773f, 0.02172730f, -0.07915754f, -0.03390090f, 0.02370260f, -0.04394254f, -0.02976796f, -0.11710491f, 
    -0.07042874f, -0.02352762f, -0.08763216f, 0.12089320f, 0.07656307f, 0.02582919f, 0.04751316f, -0.06622429f, 
    -0.02456724f, -0.03612930f, -0.03437614f, -0.06914675f, 0.05301934f, 0.11264844f, -0.03820134f, -0.02109471f, 
    0.23686653f, 0.01477820f, 0.08243012f, 0.12173457f, -0.05926796f, 0.01378280f, 0.02868077f, -0.01650645f, 
    -0.06385076f, 0.04215631f, -0.02586018f, 0.07066754f, 0.07091146f, 0.00177697f, 0.09381350f, 0.14993596f, 
    -0.02108243f, -0.05726420f, 0.13698271f, 0.06181560f, -0.00484082f, -0.02660149f, 0.03715483f, 0.02948747f, 
    0.20169120f, -0.12236291f, -0.07794920f, 0.00936735f, 0.07971119f, 0.01158745f, -0.02641204f, -0.11736666f, 
    0.05162964f, -0.01151662f, -0.19462110f, -0.20356363f, 0.15912977f, 0.19859202f, 0.06009398f, -0.13893119f, 
    -0.14521678f, -0.07221530f, 0.01269003f, -0.05664957f, -0.00231877f, 0.05405296f, -0.08178842f, -0.03824905f, 
    0.10434324f, 0.03216270f, 0.15487438f, -0.18061689f, 0.05004676f, 0.12367967f, -0.02422230f, 0.04099585f, 
    0.00336914f, -0.00146609f, -0.03087899f, -0.06791280f, -0.21696644f, -0.14318599f, -0.12375757f, 0.12656786f, 
    -0.07337797f, -0.13195398f, -0.07073754f, -0.08503891f, -0.03124038f, -0.01374220f, 0.10360364f, 0.10895444f, 
    -0.06390681f, -0.12269263f, -0.16279384f, 0.07231617f, 0.02809185f, 0.23083650f, -0.09850001f, 0.02354473f, 
    0.13666914f, -0.04400539f, 0.05546323f, -0.08311909f, 0.50782889f, -0.07540631f, -0.17545523f, -0.14835531f, 
    -0.03394823f, 0.04269675f, 0.10810295f, -0.13411377f, 0.00642536f, 0.03899673f, 0.11750329f, -0.10171767f, 
    -0.13445979f, -0.17271668f, -0.04204239f, 0.08432735f, 0.07495502f, 0.08060458f, -0.08516338f, 0.00438653f, 
    -0.04900996f, -0.13062003f, -0.10766919f, 0.27487728f, 0.22947095f, -0.18116288f, -0.22794347f, -0.08268954f, 
    0.08281845f, 0.03014319f, 0.01379507f, -0.01754117f, 0.04580598f, 0.07500716f, -0.14340216f, -0.14693409f, 
    0.14189500f, -0.00110860f, -0.06314754f, -0.07296790f, -0.05407942f, 0.15066051f, -0.05751431f, -0.00233519f, 
    0.08443851f, 0.01180487f, 0.05816254f, 0.05947614f, 0.16125868f, 0.02411065f, -0.08889656f, -0.25410137f, 
    -0.00514226f, -0.04612861f, 0.11421470f, -0.12931339f, 0.08977350f, -0.00083020f, -0.20720957f, 0.01400105f, 
    0.16932423f, -0.89075607f, -0.10489649f, -0.43665493f, 0.06060692f, 0.03987084f, -0.05431624f, 0.15640333f, 
    -0.06896164f, -0.01634086f, -0.20593022f, -0.11242346f, -0.30652189f, -0.15845634f, -0.21977109f, 0.01754542f, 
    0.11231355f, -0.03970010f, -0.06617024f, -0.14356254f, 0.13481744f, -0.03809603f, -0.10395386f, 0.03294595f, 
    -0.05048984f, -0.22017850f, 0.02078506f, 0.10157862f, -0.06208380f, 0.07694840f, 0.21423237f, 0.28932872f, 
    -0.02124485f, 0.03757497f, 0.05291829f, -0.19326918f, -0.10152992f, -0.06712633f, -0.08129396f, 0.35612443f, 
    0.01149245f, 0.14605731f, 0.00915787f, -0.17332762f, -0.12073836f, 0.02046952f, 0.05763357f, 0.00274205f, 
    -0.17869499f, 0.27122828f, -0.20805018f, 0.11682625f, -0.12204082f, -0.24265270f, 0.08329252f, -0.22892128f, 
    0.08394046f, 0.07314706f, -0.02085835f, -0.01002477f, 0.06506320f, 0.00758179f, -0.03553077f, -0.22202839f, 
    0.16984665f, 0.07067116f, 0.08983186f, 0.01412801f, 0.01549940f, -0.10569560f, -0.11580458f, 0.05840342f, 
    -0.11511018f, 0.27533999f, 0.17250907f, -0.13417086f, 0.11555260f, 0.09340014f, 0.13401660f, 0.33263153f, 
    0.05056353f, 0.00470794f, 0.06945340f, 0.01279425f, -0.20714222f, -0.29347146f, -0.11791838f, 0.36616424f, 
    0.10845616f, -0.18674496f, 0.17918012f, 0.04622919f, 0.00392587f, 0.10557866f, 0.08374692f, 0.06121757f, 
    -0.00718963f, -0.24496728f, 0.04613623f, 0.09533261f, -0.05423360f, 0.08465139f, -0.19054441f, 0.02672244f, 
    -0.01719174f, 0.02577033f, 0.31572977f, -0.01159848f, 0.20595005f, 0.04119233f, 0.28395793f, -0.18732522f, 
    0.08203133f, 0.17252108f, 0.22792487f, 0.14763144f, 0.05372664f, 0.00829386f, -0.01772215f, -0.05518278f, 
    0.18094897f, 0.08139057f, 0.27097124f, -0.02355244f, 0.17644928f, -0.13467260f, 0.06158185f, 0.09578329f, 
    0.13327919f, -0.00573112f, 0.03503574f, -0.12328531f, 0.10481724f, -0.21697260f, 0.00752243f, -0.10317947f, 
    0.10631756f, -0.17491497f, -0.08505588f, -0.08404279f, 0.05297533f, 0.07691257f, 0.18774025f, 0.09443668f, 
    0.19738077f, 0.11983091f, -0.19507056f, -0.09894405f, -0.05459877f, -0.03026077f, 0.13625890f, -0.07315141f, 
    -0.04213432f, 0.01444389f, -0.05096649f, -0.08011388f, 0.14343154f, -0.22680007f, 0.51802921f, 0.03103036f, 
    -0.02063523f, 0.00865789f, -0.01876321f, -0.07463031f, -0.07427601f, -0.03370896f, -0.01684993f, -0.13416170f, 
    -0.08260508f, 0.04270111f, -0.05864868f, 0.06197590f, -0.05736062f, -0.08426022f, 0.03916485f, 0.01083106f, 
    -0.03253758f, -0.01912005f, 0.00327987f, 0.02121993f, -0.07077017f, 0.00919577f, -0.03104622f, 0.00857782f, 
    0.02044342f, -0.04537824f, 0.01840425f, 0.04073409f, 0.01672905f, 0.08159342f, -0.00985925f, -0.03178966f, 
    0.02967237f, -0.00426876f, -0.03154736f, -0.00211044f, 0.01799107f, -0.09202575f, -0.01461439f, 0.04496315f, 
    -0.05644285f, -0.02768103f, 0.01594838f, -0.04487851f, -0.05015775f, -0.00842379f, 0.02164487f, -0.02382377f, 
    0.04551078f, -0.01715359f, 0.02018061f, -0.00285344f, -0.03610561f, -0.06394432f, -0.04655439f, 0.01159135f, 
    -0.05326053f, 0.00014058f, -0.03292160f, -0.03789905f, -0.00617996f, 0.01131017f, -0.03253183f, -0.06423724f, 
    0.01457794f, -0.03648606f, -0.05146946f, -0.07169048f, -0.05058516f, 0.03616920f, -0.00148755f, -0.02034944f, 
    0.01008505f, -0.02410406f, -0.05362441f, -0.07381988f, -0.00256312f, -0.05073916f, -0.03046833f, 0.01007272f, 
    0.01911803f, -0.04979446f, 0.03552521f, -0.03045026f, -0.05546077f, -0.09441669f, 0.00701015f, 0.04557874f, 
    0.02079963f, 0.06118428f, -0.01875603f, -0.01537538f, 0.05362907f, -0.00396612f, -0.02404046f, -0.04408575f, 
    -0.05494870f, -0.05434712f, -0.03568351f, 0.03582631f, -0.06256114f, -0.03294866f, -0.02638646f, -0.06317779f, 
    -0.06333290f, 0.06333521f, 0.00772590f, 0.00545103f, -0.05469164f, -0.04965343f, -0.01695050f, 0.02143758f, 
    0.00903635f, 0.04214159f, 0.00833385f, -0.02566304f, 0.04633284f, 0.01595267f, -0.06515604f, -0.02756532f, 
    -0.04162182f, -0.04870668f, 0.00928083f, 0.00811855f, -0.01587609f, 0.00928853f, -0.01367301f, 0.01755930f, 
    0.03056647f, -0.04513665f, -0.08260934f, 0.04428782f, -0.06182630f, -0.03066908f, 0.04595343f, -0.02134204f, 
    0.06700043f, 0.04359528f, 0.07870285f, -0.00569382f, 0.05319555f, -0.04241658f, 0.01223568f, 0.06173930f, 
    -0.02596794f, -0.04526635f, 0.01529441f, -0.05193052f, -0.00763036f, -0.00549390f, -0.02462716f, 0.00793645f, 
    -0.01060925f, -0.06312293f, -0.03805820f, -0.01634066f, 0.04238755f, -0.02670179f, 0.06709418f, -0.02500917f, 
    -0.05640562f, -0.07064623f, -0.06776837f, -0.05876743f, -0.05182174f, -0.02141713f, -0.01987740f, 0.05248176f, 
    -0.02420936f, -0.04030426f, -0.02724655f, 0.03886597f, -0.05807071f, 0.06819578f, 0.02575620f, 0.00167015f, 
    -0.00123026f, -0.00341583f, 0.00136934f, -0.02139756f, -0.04309920f, -0.04011032f, -0.01317086f, 0.06155291f, 
    0.01135752f, -0.03446956f, 0.02657566f, -0.06490302f, -0.04958717f, 0.01160298f, -0.05826489f, 0.00675552f, 
    -0.05729675f, 0.03820249f, -0.04138320f, 0.04537122f, -0.04475692f, 0.00492451f, -0.10220303f, -0.09021777f, 
    -0.00599626f, 0.14915158f, 0.24432051f, -0.11918551f, -0.02397533f, -0.03783436f, 0.11570395f, 0.12572710f, 
    -0.16630648f, -0.05070222f, -0.10078930f, -0.05743332f, -0.14463842f, 0.05843381f, 0.08455647f, -0.18702389f, 
    0.05917623f, -0.01209604f, -0.15587194f, -0.11931330f, -0.03822634f, 0.00092556f, 0.02815801f, 0.00613874f, 
    0.18826553f, -0.10396254f, 0.27486947f, 0.14234304f, 0.12834784f, 0.07319506f, 0.11832817f, 0.17729469f, 
    0.07333680f, 0.03001368f, -0.14278230f, -0.13076966f, 0.22593594f, 0.07997981f, -0.05815647f, 0.25849962f, 
    -0.03112442f, -0.01241470f, 0.18719016f, -0.04127198f, -0.11596277f, -0.12933609f, 0.06727687f, 0.09840105f, 
    0.12553056f, 0.14754078f, -0.18978544f, 0.16794682f, 0.02631748f, 0.03680729f, 0.02330874f, 0.06676050f, 
    0.16376248f, -0.11125255f, -0.01204609f, -0.09264563f, -0.04244918f, -0.18170805f, -0.15493794f, -0.20398262f, 
    -0.07104761f, 0.00615170f, 0.03863529f, -0.02982207f, 0.05187780f, 0.16847034f, 0.12835237f, 0.02584474f, 
    -0.49789864f, 0.20874284f, -0.08816510f, -0.04610819f, 0.03072599f, 0.01988815f, -0.15155257f, 0.04684399f, 
    -0.01969583f, -0.00643569f, 0.19245209f, -0.06792176f, -0.27095991f, -0.26676545f, -0.11531552f, 0.04003900f, 
    0.06519295f, -0.14640433f, -0.11706226f, -0.04626518f, 0.05423473f, 0.11195583f, 0.03555270f, 0.01736489f, 
    -0.08230248f, -0.29899478f, -0.03541104f, 0.01379934f, -0.05078041f, -0.08630431f, 0.06694763f, 0.27067268f, 
    -0.00702483f, -0.00342514f, 0.04890217f, -0.00531798f, -0.11861836f, 0.07783012f, -0.09281076f, -0.13344879f, 
    0.11802869f, -0.02786645f, 0.03472289f, 0.16851841f, -0.06570422f, -0.05655041f, 0.07105523f, -0.00329079f, 
    0.10650758f, 0.08505900f, -0.23101681f, 0.04994790f, -0.03412043f, -0.06870049f, 0.06873020f, -0.13727602f, 
    0.00996312f, -0.01235164f, 0.11573485f, 0.14242411f, 0.28070506f, -0.19966459f, 0.15678334f, 0.39347669f, 
    0.01386849f, 0.03826626f, 0.17280552f, 0.16255449f, -0.00845079f, 0.05741144f, -0.06828269f, -0.04083642f, 
    0.27626783f, -0.21009856f, 0.14321958f, 0.17496306f, 0.04879459f, -0.03763526f, -0.02638627f, 0.06084263f, 
    -0.00340355f, -0.06868804f, 0.00135186f, -0.03905559f, 0.00043406f, -0.28663757f, -0.11547770f, -0.07090474f, 
    0.03036519f, 0.01772857f, 0.05442782f, 0.09876854f, 0.17263123f, 0.11112179f, -0.02091006f, 0.02508797f, 
    -0.21907008f, 0.29933482f, 0.21988611f, 0.27461582f, -0.04510344f, -0.03411288f, 0.03383818f, 0.13762937f, 
    -0.02391611f, 0.01050920f, 0.10709671f, -0.13684157f, 0.03514965f, 0.13527736f, 0.19396399f, -0.04252556f, 
    0.12265493f, -0.05345364f, -0.16766666f, -0.04552614f, -0.02378490f, -0.01575155f, 0.03773235f, 0.07274990f, 
    0.33798096f, 0.26377708f, 0.00299561f, 0.12276606f, 0.10245458f, -0.01581464f, 0.12378003f, -0.01881901f, 
    0.13615341f, 0.14835946f, 0.09107193f, -0.11946958f, -0.17826580f, -0.12042616f, 0.02369328f, 0.00454482f, 
    0.02698363f, 0.08485194f, 0.05609869f, 0.01010253f, 0.08015681f, 0.11454079f, -0.00735132f, -0.00796643f, 
    -0.21984483f, -0.04826809f, 0.05679725f, -0.18605539f, 0.06343847f, 0.16026212f, -0.02739940f, 0.03566568f, 
    0.03530142f, 0.03242607f, 0.02455128f, -0.11403271f, -0.26780820f, 0.02757133f, 0.22315341f, 0.02360400f, 
    0.11344929f, 0.08891417f, 0.11223844f, -0.02234543f, -0.06869507f, 0.14426377f, -0.03130006f, 0.06582326f, 
    -0.18077326f, -0.14563327f, -0.02767309f, -0.08307511f, 0.04843409f, -0.04607870f, 0.00045656f, -0.10213931f, 
    -0.00528581f, -0.04133501f, -0.02335744f, -0.25083157f, -0.04101775f, -0.14066491f, -0.14289041f, -0.11390851f, 
    0.07614277f, -0.03522386f, -0.11376264f, -0.05035175f, -0.34828827f, -0.17224729f, -0.05636831f, -0.09782980f, 
    0.08806391f, -0.08641293f, -0.02013265f, -0.08347024f, -0.20064881f, 0.01022238f, -0.05974328f, -0.02810296f, 
    0.16476832f, 0.02032253f, 0.00806248f, 0.14294998f, -0.12541869f, 0.01308254f, 0.04382416f, -0.17490274f, 
    0.07895803f, -0.02492043f, 0.03707656f, 0.21095441f, -0.01121332f, -0.07609957f, 0.05600787f, -0.02651068f, 
    -0.24073763f, 0.25544104f, 0.00772282f, 0.06030612f, 0.11043628f, 0.09372246f, 0.12427394f, 0.20234141f, 
    0.00784580f, -0.12071478f, -0.11725571f, -0.02460821f, 0.05192449f, 0.13066003f, 0.16369069f, 0.17129390f, 
    -0.14366698f, -0.01412247f, 0.06860391f, -0.07366367f, -0.11403196f, -0.03319405f, -0.06277065f, 0.05323851f, 
    0.16666423f, 0.06077139f, 0.12357407f, 0.18133098f, 0.08823692f, -0.05361351f, -0.04308288f, 0.13639705f, 
    0.13589622f, 0.09020235f, 0.21442112f, 0.13706319f, 0.06614153f, -0.06682215f, 0.26880640f, -0.09075802f, 
    0.09759690f, 0.13451628f, 0.08065676f, -0.02006169f, 0.05512585f, 0.05617747f, 0.01140728f, -0.08068281f, 
    0.05275255f, -0.09436300f, 0.10127687f, -0.08600418f, 0.07217120f, 0.00655822f, -0.01979390f, -0.02301804f, 
    -0.07697628f, -0.13446152f, 0.13196442f, 0.02827521f, 0.00187432f, -0.06057514f, -0.17669573f, -0.29765001f, 
    -0.14251125f, -0.15567289f, 0.17082331f, 0.05630782f, 0.19676167f, 0.10569033f, 0.03469777f, -0.08428457f, 
    0.09748602f, -0.08631120f, -0.03787902f, 0.04715481f, 0.06198128f, -0.05091075f, -0.07867347f, -0.18050559f, 
    0.02916345f, 0.00576412f, -0.04631662f, -0.08316807f, 0.33806071f, -0.12039237f, 0.26473880f, -0.12297318f, 
    -0.14530531f, -0.07372354f, 0.10443256f, 0.09551008f, -0.00378204f, -0.10824112f, 0.00259098f, 0.02412278f, 
    0.26800591f, 0.15333915f, -0.19130778f, -0.31489497f, 0.01679759f, -0.15262568f, 0.21137288f, 0.04820170f, 
    0.02164472f, 0.14479439f, 0.13140239f, -0.23621136f, -0.08530059f, -0.22501995f, -0.04347891f, -0.28259563f, 
    0.03392360f, 0.16931209f, -0.00814203f, -0.05655672f, -0.01591228f, -0.02420072f, -0.07158817f, -0.00062219f, 
    0.19573461f, 0.11552404f, 0.25900370f, -0.14140874f, 0.06708186f, 0.02228627f, 0.27478656f, 0.26624489f, 
    0.07180750f, -0.08485712f, 0.13777420f, -0.09082503f, -0.42790356f, 0.13151957f, 0.01004213f, -0.14204112f, 
    0.08350275f, -0.02912312f, 0.24749492f, 0.06441595f, -0.07499938f, 0.09594522f, 0.06911841f, -0.02434142f, 
    0.07196890f, 0.00514138f, -0.19593881f, 0.00665525f, 0.04997460f, -0.03270935f, 0.10292649f, 0.01800754f, 
    0.25547439f, 0.03523746f, -0.12551539f, -0.15350491f, 0.03004462f, 0.02235288f, -0.07457722f, 0.10009452f, 
    0.01330706f, -0.05958819f, -0.05904222f, -0.06477086f, -0.11051589f, 0.07343551f, 0.14509405f, 0.12238168f, 
    -0.16007730f, 0.28333855f, -0.03277177f, 0.17101252f, 0.02702090f, 0.05278362f, 0.03332647f, -0.08382274f, 
    0.00871302f, -0.08205647f, 0.07392959f, 0.02823832f, -0.13284929f, 0.02807980f, 0.21917756f, -0.08729102f, 
    0.11197760f, -0.06129127f, -0.05579858f, 0.09865856f, -0.07367469f, -0.01626200f, 0.05357163f, 0.02519332f, 
    -0.19242328f, 0.18270367f, 0.11978414f, -0.00029384f, 0.08302554f, -0.14619119f, 0.07812369f, 0.01749120f, 
    0.03272865f, 0.00227203f, -0.01156195f, 0.10732047f, 0.17712544f, 0.28030080f, -0.15000862f, -0.01837096f, 
    0.00872089f, 0.02894650f, 0.07040930f, 0.01334534f, -0.00666090f, 0.01969269f, 0.01320770f, 0.00887276f, 
    -0.00939972f, -0.04915075f, 0.16698395f, 0.00846010f, 0.18343331f, -0.03422059f, -0.09236689f, 0.05567489f, 
    0.05346528f, 0.07206860f, -0.04325761f, 0.09583404f, 0.28444588f, -0.23731297f, 0.21664888f, 0.04446778f, 
    0.02935993f, 0.00798023f, 0.06480422f, 0.12481518f, -0.06663604f, -0.00975842f, -0.02593981f, 0.04300695f, 
    0.26878178f, -0.29563785f, 0.12965222f, 0.07141718f, 0.25250959f, -0.08135576f, -0.11361330f, -0.02822214f, 
    0.03710850f, -0.05018267f, 0.06501412f, -0.03460178f, 0.42275205f, -0.30431676f, -0.03570744f, 0.16057736f, 
    -0.00807940f, -0.17705554f, 0.10849077f, -0.05909510f, 0.12292445f, -0.03563157f, 0.15782821f, 0.07987459f, 
    -0.23858534f, 0.20225562f, -0.08409397f, 0.05125828f, 0.01757721f, -0.05497328f, -0.01301971f, -0.04112349f, 
    -0.05484176f, -0.02970449f, 0.11007783f, 0.00603576f, 0.14823261f, -0.19934514f, 0.26835510f, -0.13455814f, 
    0.10156499f, -0.04054660f, -0.03889463f, -0.05309237f, 0.03057865f, 0.06262593f, -0.15751745f, -0.04619489f, 
    -0.06828146f, 0.01281098f, 0.01805701f, 0.01637856f, -0.00346999f, -0.00228057f, -0.01393276f, 0.06434097f, 
    0.03569465f, 0.03244556f, -0.02423854f, -0.04638370f, 0.00182725f, 0.04381543f, -0.05784599f, -0.02830512f, 
    -0.03736338f, -0.04997606f, -0.03896081f, -0.02136318f, -0.01586745f, -0.00589074f, 0.00346173f, 0.05341649f, 
    0.00317496f, -0.02847755f, -0.03149929f, -0.02843036f, 0.00587661f, -0.03303216f, -0.06117952f, -0.07330190f, 
    -0.00421636f, 0.04191763f, -0.03848610f, 0.00924604f, 0.03430397f, 0.00309470f, -0.03815968f, -0.00986141f, 
    -0.03651982f, 0.04801303f, -0.07814824f, 0.00017542f, -0.07348678f, -0.02668400f, -0.07844380f, 0.03134931f, 
    0.00092682f, 0.03456127f, -0.06609455f, -0.02570363f, 0.03078604f, -0.02218536f, -0.06203587f, -0.03515691f, 
    0.01589775f, 0.01032448f, 0.04057712f, -0.01698338f, -0.06315624f, 0.04547568f, -0.02589726f, 0.05168847f, 
    0.01810076f, 0.03022381f, -0.04283427f, 0.00528797f, 0.00650825f, -0.04342996f, 0.00814070f, -0.01210414f, 
    0.02597300f, -0.02969215f, -0.05500096f, -0.02137996f, -0.07258308f, 0.02943115f, -0.04277761f, 0.00390387f, 
    0.05381239f, 0.05651949f, 0.03604122f, 0.05890517f, -0.00006764f, -0.07504096f, 0.06452071f, 0.04778032f, 
    -0.06365297f, 0.05945580f, 0.00466355f, 0.01563654f, -0.03691747f, 0.00133254f, 0.01879068f, 0.04960416f, 
    -0.05457653f, -0.01848276f, 0.03475469f, 0.00663502f, 0.04422067f, -0.00956027f, 0.03153853f, -0.02975428f, 
    -0.04171610f, 0.06275271f, 0.03271821f, -0.00691484f, 0.00092966f, -0.01079684f, 0.04772175f, -0.05259227f, 
    0.01000406f, 0.02264301f, -0.03585031f, 0.00939374f, -0.07998752f, -0.05793165f, 0.06140151f, 0.03006377f, 
    -0.04844389f, -0.05984436f, 0.04216628f, -0.01983903f, -0.01059902f, 0.00708088f, -0.00906787f, -0.07533811f, 
    0.04572718f, -0.03965265f, 0.03198594f, 0.06260794f, 0.04337404f, 0.05707965f, -0.00578149f, -0.05989000f, 
    -0.07545741f, -0.04064420f, 0.03879319f, -0.05049616f, -0.03413294f, 0.02035869f, -0.07211805f, 0.01206648f, 
    -0.03582683f, -0.01933487f, -0.06623778f, -0.06778318f, -0.07720301f, -0.00786429f, 0.02826886f, -0.05853104f, 
    0.03242895f, 0.06497902f, -0.03633944f, 0.01752726f, 0.03818678f, 0.01342367f, -0.04037147f, -0.01451260f, 
    -0.04614327f, -0.05644239f, 0.00890698f, -0.06491432f, 0.03438625f, -0.04362459f, 0.01436852f, -0.00551926f, 
    0.05920440f, -0.02355222f, -0.05200464f, 0.03722271f, -0.07865787f, -0.02408118f, -0.01732030f, -0.04028484f, 
    0.01157195f, 0.05310235f, -0.05844064f, -0.00038600f, 0.04646062f, -0.01779642f, -0.06151154f, 0.01602688f, 
    0.05069130f, -0.03328060f, -0.07179352f, 0.02342393f, 0.04981305f, -0.03081899f, 0.01539127f, -0.00692121f, 
    -0.13536111f, -0.12389338f, 0.20379986f, 0.09154557f, 0.03248933f, -0.05160388f, 0.19018713f, 0.02134967f, 
    -0.23972796f, -0.07015381f, -0.25974649f, 0.07672800f, -0.21125688f, -0.00128681f, -0.01594587f, 0.01009591f, 
    -0.02726354f, 0.00384277f, -0.11727177f, -0.01492715f, -0.09819809f, -0.01762164f, 0.10315837f, -0.03983752f, 
    0.02884449f, 0.01229962f, 0.05919546f, 0.24435569f, 0.06256071f, 0.01834615f, -0.04799046f, 0.02622574f, 
    0.04760715f, -0.01737172f, -0.17739195f, -0.04161882f, 0.27557415f, -0.04414834f, 0.06660764f, 0.01718585f, 
    -0.05563670f, -0.11937230f, 0.12732898f, 0.04671256f, 0.04014945f, -0.03782951f, -0.14484625f, 0.22652465f, 
    -0.02747653f, 0.22239375f, -0.05647431f, -0.09009703f, 0.00183777f, 0.00979353f, 0.01523271f, -0.03751482f, 
    0.04971462f, -0.12950434f, 0.05418409f, 0.06035839f, -0.09552509f, -0.10535254f, -0.16691411f, -0.18545014f, 
    -0.08163659f, -0.04275617f, 0.05861851f, 0.07649899f, 0.09985317f, 0.04920404f, -0.01055658f, -0.17152719f, 
    -0.37980652f, -0.13137217f, 0.14833349f, -0.27533674f, -0.05364515f, -0.06321039f, -0.10208491f, -0.02657762f, 
    0.05210226f, 0.04165109f, 0.13780278f, -0.01351107f, -0.20641400f, -0.15089229f, -0.15337829f, -0.07781598f, 
    -0.06797080f, -0.12834032f, 0.05565951f, -0.04297972f, 0.01705463f, 0.06768571f, 0.04471853f, 0.14050347f, 
    0.08288401f, -0.26861870f, -0.11785480f, 0.03376319f, -0.16838847f, -0.01726737f, -0.06630499f, 0.07328795f, 
    0.01255461f, 0.01039707f, 0.05959307f, -0.03206832f, -0.06205427f, -0.03683798f, 0.06993366f, -0.19590577f, 
    -0.05550071f, 0.04458460f, -0.06578990f, -0.04498873f, -0.07648394f, -0.04883983f, -0.07443739f, -0.07389797f, 
    0.02399677f, 0.27226523f, -0.24531671f, 0.06192372f, -0.07106905f, -0.19409712f, 0.12719671f, -0.09521174f, 
    -0.03683510f, 0.00342130f, 0.00415694f, 0.07800587f, 0.23945142f, 0.04683207f, -0.14805105f, 0.35755426f, 
    -0.02351375f, -0.09862325f, 0.06834314f, 0.02233646f, 0.06465735f, -0.03271289f, -0.04399283f, -0.04742296f, 
    -0.02946545f, 0.01281852f, 0.02300742f, -0.04866834f, -0.04408156f, 0.01473245f, -0.16900201f, 0.04190895f, 
    0.00388215f, -0.01128080f, 0.05453306f, -0.00219338f, -0.38706765f, 0.06865225f, -0.17556849f, -0.11095876f, 
    -0.05073062f, -0.06104026f, -0.07125739f, -0.02240430f, 0.12106977f, 0.01316873f, 0.00672143f, -0.02448808f, 
    0.00869372f, 0.03018021f, 0.12369731f, 0.18255769f, 0.09493580f, -0.00721534f, -0.01177676f, -0.01412947f, 
    -0.09776788f, 0.04578662f, 0.08662306f, -0.00189850f, -0.27385220f, 0.16499038f, -0.20622326f, 0.01523788f, 
    -0.01745061f, -0.09749725f, -0.15495077f, -0.16699266f, -0.14371367f, -0.01499817f, -0.03311935f, 0.03214205f, 
    -0.09883892f, 0.09325051f, 0.21252221f, 0.13547195f, 0.04436638f, 0.10005189f, 0.26812038f, 0.09676386f, 
    -0.09928124f, -0.10632659f, -0.25232664f, -0.01762311f, -0.27140301f, 0.07768314f, -0.10977081f, 0.09983467f, 
    0.07430319f, -0.09349345f, -0.03658190f, -0.04895883f, -0.12705228f, -0.04158316f, 0.08862341f, -0.00153552f, 
    -0.09668608f, 0.05843444f, -0.01582618f, 0.32600695f, -0.05224878f, 0.06395087f, 0.10527711f, 0.00845153f, 
    0.07162266f, 0.14768809f, -0.12815067f, -0.06957855f, 0.44874862f, -0.10657279f, 0.12843424f, 0.07266963f, 
    -0.07139798f, 0.05046267f, -0.02139715f, 0.01432161f, -0.03730316f, -0.13217238f, 0.00222270f, 0.29140067f, 
    0.08561692f, 0.12402507f, 0.09121553f, -0.05034357f, -0.00081174f, 0.07559510f, -0.05801006f, -0.00984669f, 
    0.14208397f, 0.11887342f, 0.07276089f, 0.29506224f, 0.00935115f, -0.00964867f, -0.08636962f, -0.19237930f, 
    -0.07874760f, 0.00989091f, -0.05119110f, 0.05247989f, 0.29381695f, 0.15470351f, 0.03572812f, -0.02954334f, 
    -0.44174102f, -0.18370648f, 0.21458536f, 0.19031224f, 0.05090429f, 0.06112820f, -0.13997437f, 0.03646391f, 
    -0.08410663f, 0.07365374f, 0.29699942f, 0.17556988f, 0.04306496f, -0.09446531f, -0.27713135f, -0.01861284f, 
    0.04049090f, 0.08511798f, 0.06232127f, -0.08430625f, -0.02386678f, 0.03713470f, 0.10462369f, 0.13966027f, 
    0.25958323f, -0.27208713f, -0.15809281f, -0.10480513f, -0.02961492f, 0.03968285f, -0.02915176f, 0.10965402f, 
    -0.00890315f, 0.00938957f, 0.04724613f, -0.07439636f, -0.05016986f, 0.05914452f, -0.00721259f, -0.13784048f, 
    -0.10752879f, 0.05819128f, -0.13842428f, 0.01385881f, -0.06425869f, 0.00461594f, 0.00831296f, -0.03364906f, 
    0.07546407f, 0.07893796f, -0.06366168f, 0.00019237f, -0.03567052f, -0.07075831f, 0.16816290f, -0.17238630f, 
    -0.05418808f, -0.01118969f, -0.06480093f, 0.06694328f, 0.04464493f, 0.19897971f, -0.20759204f, 0.16967945f, 
    0.03032651f, -0.13923857f, 0.11128336f, -0.01119665f, 0.05356913f, -0.01686198f, -0.07799803f, -0.07032690f, 
    0.20538771f, 0.19079430f, -0.13347356f, -0.08208846f, -0.08028413f, 0.14246313f, -0.14112066f, -0.04462906f, 
    -0.06130856f, -0.05668943f, -0.08805046f, -0.01478419f, -0.07143603f, 0.29355112f, -0.31285498f, -0.24774358f, 
    0.09163473f, 0.06706777f, 0.01274043f, -0.09089192f, -0.04354730f, 0.02259978f, 0.04387202f, 0.02171701f, 
    0.07828247f, -0.13594359f, 0.03518227f, 0.22860308f, 0.13012296f, 0.06447870f, 0.00200064f, 0.02975756f, 
    -0.02813237f, 0.04971988f, 0.15177058f, 0.02601471f, 0.03792804f, 0.39594483f, -0.31876966f, 0.01873795f, 
    0.08960366f, -0.07395937f, -0.01854309f, -0.06258712f, -0.13384120f, -0.06087051f, 0.16555461f, 0.05831847f, 
    -0.01507241f, 0.04581868f, 0.04023900f, -0.07359444f, -0.03471223f, 0.02655573f, -0.06157752f, 0.03750055f, 
    0.03289316f, -0.04245217f, 0.01641513f, -0.05620660f, -0.04288961f, -0.01284178f, -0.02765394f, 0.00086741f, 
    -0.01894082f, 0.06540459f, -0.01429178f, -0.04901132f, -0.03023371f, -0.05100539f, 0.03213158f, -0.02557245f, 
    -0.03895770f, 0.06435034f, -0.00242203f, 0.04254606f, -0.06568077f, -0.05299639f, -0.04444974f, -0.04545293f, 
    0.01625797f, -0.04177458f, -0.00482519f, -0.03621130f, 0.00943062f, 0.05913925f, -0.03137046f, -0.00292489f, 
    -0.05954336f, -0.00985993f, -0.00320349f, -0.05381073f, -0.04144545f, 0.04637894f, -0.04549100f, -0.06736726f, 
    0.02629193f, 0.00253633f, -0.06439564f, 0.05195843f, -0.05664723f, -0.07071779f, 0.06549335f, -0.05877615f, 
    -0.00381698f, 0.00317744f, 0.02064786f, 0.03981872f, 0.01650943f, 0.03250818f, 0.03370890f, -0.06426075f, 
    0.04567602f, 0.04828709f, -0.06383263f, -0.03048248f, 0.02735304f, 0.03934453f, -0.05310706f, 0.01217869f, 
    0.02742712f, -0.06450623f, 0.05344211f, -0.02498120f, -0.05218652f, 0.06422393f, 0.05455069f, 0.05102730f, 
    -0.03879607f, 0.05094411f, 0.00803282f, -0.02830865f, -0.06356708f, -0.05920892f, 0.00305324f, -0.03169666f, 
    -0.07214359f, 0.00178391f, 0.04921239f, -0.06492339f, 0.06019858f, -0.03467396f, 0.04221781f, 0.00932264f, 
    -0.03846417f, -0.00369799f, -0.02887898f, -0.05644466f, -0.02285158f, -0.03432807f, 0.01090607f, -0.02868538f, 
    0.02814516f, -0.04522237f, -0.01512947f, -0.03377229f, -0.06522959f, -0.06887381f, 0.04531879f, -0.03381425f, 
    -0.00717821f, -0.07087989f, 0.03026747f, -0.06015193f, -0.04570980f, 0.05650811f, -0.07323448f, -0.06418902f, 
    -0.00418506f, 0.06373854f, 0.03218370f, -0.05603580f, -0.00448532f, 0.05099586f, -0.04000664f, -0.01547725f, 
    0.06217096f, -0.01703006f, -0.07257811f, 0.01210272f, -0.04104312f, -0.02949498f, -0.00979560f, -0.06792884f, 
    -0.04046394f, -0.04028273f, 0.06307989f, 0.05102903f, -0.07543451f, -0.04207473f, -0.03231924f, -0.06442757f, 
    0.06192408f, 0.05978581f, -0.02516695f, 0.01150260f, -0.01399535f, -0.00430564f, 0.00390704f, 0.05397280f, 
    -0.04045853f, -0.03719180f, 0.04542782f, 0.05493516f, -0.02812335f, -0.03655974f, -0.01270008f, -0.07810523f, 
    0.01738568f, -0.01614754f, -0.05814906f, 0.00973352f, -0.07521348f, -0.02746696f, -0.05047433f, 0.03627458f, 
    0.02820721f, -0.03790278f, -0.05204042f, -0.03159442f, -0.07117456f, -0.07711319f, -0.06766375f, -0.04169230f, 
    -0.04714387f, -0.03035672f, 0.04104081f, 0.05586455f, 0.00073937f, 0.03162481f, -0.03772857f, -0.02459264f, 
    -0.06926250f, 0.00866228f, -0.01721280f, -0.05684807f, 0.00353407f, 0.02421405f, -0.01804144f, -0.03702185f, 
    -0.20815440f, 0.10550743f, 0.09944061f, 0.02793044f, 0.05621114f, 0.02497166f, -0.00723539f, 0.04692596f, 
    -0.07721855f, 0.05092625f, 0.10044143f, 0.03794970f, 0.02400388f, 0.16440730f, 0.04060249f, 0.11414932f, 
    0.03218262f, 0.05237669f, -0.09433108f, 0.09296018f, 0.00388292f, -0.08811481f, -0.09257668f, -0.17750670f, 
    0.02385437f, 0.34917685f, -0.05565624f, 0.18765838f, -0.06918638f, -0.07943572f, 0.20209967f, 0.03964852f, 
    -0.03986705f, -0.04034211f, 0.02552226f, -0.04563680f, 0.48423037f, -0.00174108f, 0.17623596f, 0.16993769f, 
    0.09151475f, 0.27536476f, 0.08866846f, -0.05591031f, 0.00809320f, -0.08292028f, 0.05560924f, 0.06973528f, 
    0.16656801f, 0.04266554f, 0.06817809f, -0.00251518f, -0.07157760f, 0.02607861f, 0.04892232f, -0.25751612f, 
    0.06921712f, 0.06807290f, -0.04782779f, 0.12795284f, 0.01164248f, 0.03713228f, 0.06599030f, -0.04886061f, 
    -0.12036962f, -0.05863178f, -0.03898020f, -0.00645385f, 0.25708169f, 0.16200718f, 0.06146422f, 0.07767384f, 
    0.72029847f, -0.01102012f, 0.23459935f, 0.04579102f, -0.00978728f, 0.00782636f, -0.07833535f, -0.02496381f, 
    -0.10263124f, 0.05863713f, 0.06205843f, 0.13844691f, -0.09884463f, 0.01542254f, 0.11260178f, 0.20546649f, 
    -0.11224769f, -0.05883458f, 0.09030917f, -0.01025134f, -0.04057823f, 0.13970433f, 0.13862452f, 0.06947187f, 
    0.23203611f, -0.13830942f, -0.02346413f, 0.06303085f, 0.07477085f, -0.06595399f, -0.11246645f, -0.10545520f, 
    -0.13581848f, -0.03295479f, 0.04955580f, 0.11274964f, 0.29354665f, 0.13927512f, 0.03960456f, -0.13087071f, 
    -0.18030855f, -0.07260874f, -0.09601561f, 0.01214088f, 0.04675845f, -0.01658014f, -0.08529921f, -0.07262953f, 
    0.15961155f, 0.32713482f, -0.07285087f, 0.02595923f, 0.04615347f, 0.06379312f, -0.00588644f, 0.12714472f, 
    0.06704416f, 0.02653825f, -0.18899404f, 0.10116662f, -0.37827834f, 0.03573997f, -0.21607360f, 0.17112860f, 
    0.04338862f, -0.05908502f, -0.00222636f, 0.13740993f, -0.03900505f, -0.11052039f, -0.07207501f, -0.09787511f, 
    -0.37355664f, -0.11165474f, -0.27495337f, 0.02378014f, 0.01019761f, -0.08817516f, -0.05670177f, 0.11767702f, 
    0.10105147f, 0.04272369f, -0.01022669f, -0.04651900f, -0.17396846f, 0.07986880f, -0.02935008f, -0.01158081f, 
    0.01096774f, 0.03385583f, 0.02410377f, 0.11760668f, -0.05587665f, 0.01741576f, 0.01118354f, 0.07166202f, 
    -0.20679638f, -0.29491597f, 0.11084425f, -0.02084901f, 0.10871531f, 0.14599273f, -0.12394505f, 0.02553066f, 
    -0.03594332f, 0.02593175f, -0.03807020f, 0.17564003f, -0.24862635f, 0.25608653f, -0.36160862f, 0.12642004f, 
    0.05570620f, -0.13276488f, 0.03821654f, -0.00365860f, -0.02801553f, 0.05469153f, -0.00937904f, 0.06367583f, 
    0.00653942f, -0.15022001f, -0.00766758f, -0.11497143f, -0.02098951f, -0.12830815f, 0.16384666f, 0.04486383f, 
    -0.13387211f, 0.06802634f, -0.03417105f, -0.24490137f, 0.18706492f, -0.07644110f, 0.20070110f, -0.08149561f, 
    0.00505506f, -0.15701622f, -0.10455887f, 0.04252674f, -0.14366093f, -0.13141982f, -0.01121814f, -0.12225708f, 
    0.08769508f, -0.16734660f, 0.01483852f, -0.21131206f, 0.14653350f, 0.04084715f, 0.06032946f, 0.05864433f, 
    -0.06170823f, -0.09885197f, 0.01520877f, -0.11573884f, -0.14550242f, 0.25164732f, -0.08695050f, -0.07640311f, 
    0.15210375f, 0.00970535f, 0.17457674f, -0.16983703f, -0.01016535f, -0.04320802f, 0.15503934f, 0.24141751f, 
    0.12325254f, 0.02116846f, -0.32375616f, 0.05432064f, -0.01719894f, 0.13438135f, 0.15004507f, -0.06010190f, 
    0.22231109f, 0.07398323f, 0.13492587f, 0.29792005f, 0.11170674f, 0.01942906f, -0.20228668f, -0.09952282f, 
    0.00042011f, 0.03884543f, 0.04347369f, -0.11007369f, 0.19893539f, 0.25175104f, 0.10625542f, 0.10741407f, 
    0.07519989f, 0.08763787f, 0.29457057f, -0.21698819f, -0.07973018f, -0.06349807f, -0.04944698f, -0.03176863f, 
    0.12183005f, 0.07752405f, 0.07332491f, 0.01961355f, -0.21381806f, -0.06176769f, 0.07326540f, 0.06953961f, 
    -0.00012807f, -0.17531411f, 0.03604309f, 0.07093567f, -0.01072678f, 0.04876430f, 0.05882807f, 0.18973511f, 
    -0.30460793f, -0.16046171f, -0.02899511f, 0.19441375f, 0.00209956f, -0.00104952f, 0.06853975f, 0.12898232f, 
    0.11959492f, 0.14164327f, 0.00022164f, 0.03158697f, -0.07271426f, 0.03742485f, -0.07521677f, -0.15473792f, 
    0.00096770f, 0.14024006f, 0.00953090f, -0.04531040f, -0.15438853f, -0.09491057f, -0.12114217f, 0.02111685f, 
    0.17889051f, 0.00819481f, -0.13191719f, -0.02985636f, 0.01478223f, -0.00557023f, 0.11223782f, 0.02271506f, 
    0.04581368f, -0.09169892f, -0.04660866f, 0.05581352f, -0.15281518f, -0.37503558f, 0.04965165f, 0.16925766f, 
    -0.07911725f, 0.06348515f, -0.10746726f, -0.07605312f, -0.12915069f, 0.11122677f, -0.06963554f, -0.16062218f, 
    -0.30966043f, -0.40720984f, 0.10605856f, 0.17296325f, -0.01728063f, -0.00101366f, -0.01944700f, 0.07013123f, 
    0.07295072f, 0.11912592f, 0.13296273f, -0.00671260f, 0.20153886f, 0.13307196f, 0.35106024f, 0.22388519f, 
    -0.18277523f, -0.15534104f, -0.13838413f, 0.12882847f, 0.10291540f, 0.14293343f, 0.11692297f, -0.01914717f, 
    -0.05956789f, 0.09457558f, -0.02201521f, -0.12735477f, 0.15088488f, 0.15799566f, 0.09908812f, 0.05046095f, 
    0.06923869f, -0.05123022f, 0.05935879f, 0.02780328f, -0.05409987f, -0.42332971f, 0.22997238f, 0.16197009f, 
    0.06284265f, 0.03190698f, -0.13617139f, -0.00782464f, 0.02143054f, 0.16071266f, 0.13076675f, -0.05249256f, 
    0.02115521f, 0.04519135f, 0.03067320f, -0.07079580f, 0.05706250f, 0.01815192f, -0.03919639f, -0.06356766f, 
    -0.04312266f, 0.06001332f, -0.01291079f, 0.05785068f, -0.03297454f, -0.01447674f, -0.07129505f, 0.03224830f, 
    -0.04875698f, 0.05061599f, -0.00593562f, -0.04498469f, 0.03224458f, -0.07365558f, 0.01468671f, -0.05375819f, 
    -0.02499177f, 0.05547536f, -0.01660642f, 0.01470672f, 0.05223806f, 0.00757621f, 0.05526947f, -0.04238051f, 
    -0.02584723f, -0.00127354f, -0.01736619f, -0.04327537f, -0.02364572f, -0.00597280f, -0.04926175f, -0.00377409f, 
    -0.02342029f, -0.07979323f, 0.01214127f, 0.00382106f, 0.02773045f, -0.02978953f, -0.00516984f, -0.00742433f, 
    0.06451329f, -0.05371573f, -0.02071144f, 0.04352916f, -0.07080974f, -0.00922020f, -0.06041972f, -0.02476046f, 
    0.03216351f, -0.03998814f, 0.00707816f, 0.03719690f, -0.04006208f, -0.00941731f, -0.06744901f, 0.04221096f, 
    -0.04789431f, -0.06799991f, 0.00137923f, 0.00115022f, -0.06735368f, 0.03645531f, 0.05753423f, 0.03255654f, 
    -0.04824605f, -0.01119852f, -0.06665525f, -0.05569771f, -0.06834154f, 0.06343146f, -0.05902877f, -0.03707451f, 
    0.01989520f, -0.05574842f, -0.06857368f, 0.03631708f, -0.05471490f, -0.08039945f, -0.00359580f, 0.03304282f, 
    -0.05985612f, -0.05623405f, 0.00167252f, -0.04155295f, -0.01130101f, -0.03168155f, 0.02286453f, 0.03615587f, 
    0.01729437f, 0.04166157f, 0.04347813f, -0.02698280f, 0.05405512f, 0.04041811f, -0.03687565f, 0.02636591f, 
    -0.08435661f, -0.03086347f, 0.03495174f, -0.00549190f, -0.05381753f, -0.00232596f, 0.02742871f, -0.05244826f, 
    -0.04668259f, -0.00620957f, -0.05917756f, -0.03799069f, -0.06254078f, -0.02649067f, -0.06062795f, -0.04242599f, 
    -0.00914050f, -0.01673476f, -0.06940392f, -0.03222778f, -0.07493057f, 0.01133854f, 0.03144424f, -0.04196249f, 
    0.02373540f, -0.01632303f, 0.04468907f, -0.06415953f, -0.02410719f, -0.05546055f, 0.03285912f, -0.01918529f, 
    -0.04389282f, -0.08520511f, -0.02293264f, 0.05295236f, 0.06133100f, -0.03136895f, -0.05638711f, -0.03741422f, 
    -0.08622348f, 0.03386931f, 0.00253205f, -0.02347420f, 0.01053913f, -0.04077466f, 0.04762382f, 0.02013208f, 
    0.04971076f, 0.01708889f, -0.01843371f, -0.05624808f, -0.08587645f, -0.03058135f, 0.00218233f, -0.05130644f, 
    -0.04714396f, -0.04662674f, -0.03473622f, -0.05315386f, -0.00435256f, -0.06551027f, -0.07365423f, -0.01279287f, 
    -0.03860172f, 0.00351601f, 0.05349990f, 0.04989142f, 0.05317262f, 0.05566134f, -0.03806573f, 0.04101669f, 
    -0.02238324f, -0.04477088f, 0.02562926f, 0.04512752f, -0.07914697f, 0.02989599f, -0.07945552f, -0.03464683f, 
    -0.01673517f, 0.04091957f, 0.02146885f, -0.02348184f, -0.03329780f, -0.02290523f, -0.01095815f, 0.04737335f, 
    0.04107773f, 0.11316670f, -0.11779674f, -0.12305388f, 0.04060091f, -0.05365031f, 0.11560695f, -0.05737072f, 
    0.01491394f, 0.01412302f, -0.08186967f, -0.06269567f, 0.06363081f, 0.00710555f, -0.14459005f, 0.01416805f, 
    0.02268847f, 0.20500943f, 0.02481220f, 0.09091117f, -0.11791597f, -0.07194322f, -0.11872362f, -0.23494555f, 
    0.04890263f, 0.20403288f, -0.08993525f, -0.02703745f, -0.11582375f, -0.11971073f, 0.10375376f, -0.02146530f, 
    0.00911974f, 0.00683626f, -0.00366976f, 0.06261663f, -0.27299163f, -0.05359767f, 0.17796728f, -0.08924701f, 
    0.10584292f, 0.02989453f, -0.16742502f, -0.15339853f, -0.10902857f, -0.05106198f, 0.00674651f, 0.06999371f, 
    -0.09107953f, -0.03949027f, 0.06747067f, -0.10868181f, 0.00636791f, -0.14162879f, -0.05403999f, -0.11800975f, 
    0.00294483f, 0.08958914f, 0.03257834f, 0.28745511f, -0.06318818f, -0.19297008f, 0.04509966f, -0.09826420f, 
    0.09292388f, -0.05451728f, 0.00054578f, 0.06604630f, 0.08733784f, 0.10326505f, 0.22821826f, 0.12049665f, 
    -0.14365509f, -0.28971425f, -0.37987259f, -0.13062678f, -0.07804568f, 0.09288401f, 0.08678866f, 0.02152352f, 
    -0.10343632f, 0.13325879f, 0.13768321f, 0.19124237f, 0.24959950f, 0.22056492f, 0.16151397f, 0.12408101f, 
    -0.02860760f, -0.03833439f, -0.12976159f, -0.05746594f, 0.02264557f, -0.09842287f, 0.10040255f, -0.10775158f, 
    0.14175902f, 0.18167864f, 0.06653766f, -0.00579201f, -0.01862934f, 0.06502340f, -0.03106036f, -0.11690082f, 
    -0.03510299f, 0.06749415f, -0.13035555f, -0.10564297f, -0.14457552f, -0.08993039f, -0.25585034f, -0.16797242f, 
    0.07001799f, 0.05982002f, -0.00774777f, 0.04942604f, 0.01921918f, 0.12851752f, -0.04085702f, 0.09482731f, 
    -0.29455045f, -0.17928372f, -0.10061726f, -0.33719125f, -0.06629249f, 0.02109996f, 0.01472818f, 0.06062350f, 
    -0.00212110f, -0.08007406f, -0.08481435f, -0.05255780f, 0.17597347f, 0.18043020f, 0.12833866f, 0.19200090f, 
    -0.06475970f, -0.12171099f, -0.09793577f, -0.07731166f, -0.08041174f, -0.09103649f, -0.06225251f, 0.00973293f, 
    0.19776075f, 0.20185304f, 0.14964205f, 0.12998633f, -0.14228517f, 0.19340631f, 0.16259477f, -0.04337708f, 
    0.12250250f, 0.04256022f, -0.11830063f, 0.00561510f, 0.38735086f, 0.10071793f, -0.04867704f, 0.26021042f, 
    0.01186972f, -0.08335673f, 0.14686185f, 0.01474155f, 0.10452490f, 0.11471152f, 0.10718451f, -0.06607696f, 
    0.08072329f, 0.01149925f, -0.06580341f, 0.06096444f, -0.05509828f, 0.08341163f, 0.02436905f, 0.01870761f, 
    0.01291729f, 0.00257108f, 0.04071220f, 0.22188380f, -0.16506785f, -0.33857068f, -0.14675932f, 0.16269790f, 
    -0.09126524f, 0.02182124f, 0.00275292f, -0.05262825f, -0.07433429f, 0.06709184f, -0.03206912f, -0.03788449f, 
    -0.22667128f, -0.18327618f, 0.03880161f, 0.16062303f, 0.07242689f, 0.13123041f, -0.16562371f, -0.01040425f, 
    0.14469993f, 0.15724351f, 0.07949635f, 0.10888813f, -0.19853860f, 0.03649489f, -0.06059237f, -0.09972323f, 
    -0.02139396f, -0.09071130f, -0.12774783f, -0.02977145f, 0.04939032f, 0.11783002f, 0.02980050f, 0.14473160f, 
    0.05869602f, -0.13475750f, -0.16699749f, -0.00275298f, 0.14792992f, 0.17898113f, -0.06100687f, 0.06819655f, 
    0.02516636f, 0.09691142f, -0.13934729f, -0.12148337f, 0.36010092f, -0.07525925f, -0.08445802f, 0.08471354f, 
    0.05952751f, -0.09881001f, 0.09365673f, 0.07597103f, 0.05481189f, 0.02612454f, -0.08770679f, -0.03520476f, 
    0.12996826f, -0.08864308f, 0.04634474f, -0.10417622f, 0.07544735f, 0.08912016f, 0.06037894f, 0.25541919f, 
    0.00135292f, 0.04071083f, 0.05455407f, -0.22594832f, -0.02047275f, -0.05873074f, -0.16564587f, 0.01696130f, 
    0.04072593f, 0.09603030f, 0.05391326f, -0.02644521f, -0.14230284f, -0.08882554f, -0.02529602f, 0.01515073f, 
    -0.01228478f, -0.03452128f, 0.04868640f, -0.14259554f, -0.09342038f, -0.05141810f, -0.10274638f, -0.03899142f, 
    -0.13511223f, 0.00174205f, -0.00028527f, 0.07888799f, 0.09436251f, -0.14732860f, -0.06288666f, -0.26797724f, 
    0.08758508f, 0.04235505f, -0.02099515f, -0.02965660f, 0.11243595f, -0.00362034f, 0.00839969f, 0.04231893f, 
    -0.12195017f, 0.11331908f, 0.21146189f, -0.15905295f, 0.04006989f, -0.03659043f, -0.01437402f, 0.17244184f, 
    0.06458322f, -0.03636939f, 0.18961902f, 0.07952818f, 0.08267362f, -0.04063633f, 0.01572102f, -0.02298755f, 
    0.03220571f, 0.10813228f, -0.03583636f, -0.04365814f, -0.01313762f, -0.04628988f, 0.00138566f, 0.05935011f, 
    -0.07979762f, 0.19465442f, -0.14546788f, 0.23760851f, -0.00322186f, 0.06199627f, 0.00029897f, 0.07153838f, 
    0.12639639f, 0.11504790f, 0.16330293f, 0.12029538f, 0.06970425f, -0.00618993f, -0.03896040f, -0.18167083f, 
    0.08292611f, 0.00021253f, 0.11972785f, 0.05787100f, 0.11278543f, 0.01008923f, 0.05452275f, -0.03754968f, 
    -0.09170208f, 0.03131012f, 0.11561262f, 0.00460473f, 0.14231275f, -0.18141183f, 0.05542213f, 0.03670730f, 
    0.02122358f, -0.01078152f, 0.06844249f, 0.06248949f, -0.47592521f, -0.17781420f, 0.01867171f, 0.16128321f, 
    0.03431449f, -0.10126532f, -0.07820027f, -0.02449337f, 0.06684085f, 0.00217470f, 0.05984529f, 0.13524424f, 
    0.03624469f, -0.16415393f, 0.03361786f, -0.19731504f, 0.01177156f, 0.04208008f, 0.05559687f, 0.07859652f, 
    -0.03602644f, 0.09374098f, -0.02662534f, 0.05568026f, -0.11009763f, 0.38409624f, -0.03001618f, 0.10173632f, 
    -0.08374925f, 0.03430443f, 0.04174203f, 0.00262889f, -0.05086660f, -0.09107253f, 0.11313975f, 0.04341951f, 
    -0.14019552f, 0.14839646f, 0.12088495f, 0.06726352f, 0.17746505f, 0.13312526f, 0.06819653f, 0.07875264f, 
    0.00419598f, 0.01724626f, -0.12685497f, -0.04938328f, -0.19123936f, 0.01150986f, 0.02426517f, 0.08620718f, 
    -0.02570539f, 0.03780509f, -0.00110481f, 0.05212581f, -0.11438254f, 0.10961937f, 0.01236053f, 0.08529593f, 
    -0.06882056f, 0.06538229f, -0.00997465f, 0.13514054f, 0.02028777f, 0.10325143f, 0.10586147f, -0.01312502f, 
    0.05983307f, 0.10778407f, -0.08935079f, -0.11905282f, 0.43938279f, 0.01562297f, 0.18501340f, 0.19662619f, 
    0.04389442f, 0.20494901f, 0.21799563f, 0.09068272f, 0.00822052f, -0.01218576f, -0.01470576f, 0.21374620f, 
    0.00763951f, -0.07811126f, -0.03815473f, -0.12673724f, -0.02907606f, 0.07591379f, 0.06234876f, 0.04239829f, 
    0.13298346f, 0.09521363f, 0.11726128f, 0.24062356f, 0.00606827f, 0.01832126f, -0.13446438f, -0.12749383f, 
    -0.04923012f, -0.08445726f, 0.06263414f, -0.06657431f, 0.00623117f, 0.02771364f, -0.02052297f, -0.00102630f, 
    -0.25512686f, -0.09333257f, 0.34819865f, -0.10232908f, -0.03497055f, 0.02537183f, -0.01958153f, -0.01959345f, 
    -0.08472845f, 0.09312765f, 0.31625685f, 0.26074341f, -0.03412998f, -0.22746924f, -0.33190569f, -0.10984484f, 
    -0.09101642f, -0.11725201f, -0.01233595f, 0.01595159f, 0.00081189f, 0.05490909f, 0.05970797f, 0.10637411f, 
    0.10001229f, -0.22508976f, -0.05712474f, -0.00302468f, -0.14384127f, -0.04582064f, 0.04617021f, 0.10861068f, 
    -0.06247981f, 0.02900866f, 0.09700283f, -0.06168579f, 0.01765102f, 0.07708627f, -0.00215803f, -0.22123823f, 
    -0.15744258f, 0.01249440f, -0.00216012f, -0.05842759f, -0.10912734f, -0.04327757f, -0.10418649f, 0.02871254f, 
    0.32272902f, -0.01137569f, -0.11379101f, 0.22095226f, -0.04885576f, -0.10297268f, 0.07663311f, -0.05622496f, 
    -0.02746316f, 0.03033525f, 0.05334983f, 0.07937113f, -0.12997238f, -0.29931703f, -0.40231735f, -0.05719746f, 
    0.09571375f, -0.15361440f, 0.00090888f, 0.03358213f, 0.05079152f, -0.00383648f, 0.12094288f, -0.03864520f, 
    -0.05465317f, -0.10319292f, -0.33326232f, -0.07378048f, -0.03353258f, 0.19325298f, -0.10631386f, 0.08576557f, 
    0.14230874f, -0.02453111f, 0.04044046f, -0.07112966f, -0.23591033f, 0.12247743f, -0.04800866f, -0.11950268f, 
    -0.08887288f, 0.02775526f, 0.03667103f, 0.04116159f, 0.06112909f, 0.01358097f, 0.21638416f, -0.07033230f, 
    -0.15878043f, -0.43188927f, -0.09748028f, -0.08805539f, 0.10328610f, 0.13701385f, 0.04380820f, -0.04036293f, 
    -0.02125101f, 0.10125619f, 0.07506888f, 0.02408875f, 0.20171784f, 0.27224264f, -0.25558156f, 0.00255009f, 
    0.03226700f, -0.06818643f, -0.03077057f, 0.02424586f, 0.07967982f, 0.03118940f, 0.12065855f, 0.16873616f, 
    0.01250866f, 0.11443140f, -0.18724829f, -0.33978018f, 0.03385388f, 0.00101251f, -0.08453150f, 0.02805662f, 
    0.07674908f, -0.01161695f, -0.10206090f, 0.12553672f, 0.23938912f, -0.07679664f, -0.21141163f, -0.10067677f, 
    0.09044522f, 0.05631753f, 0.08669940f, -0.04182116f, 0.18043390f, -0.01275243f, 0.06101544f, 0.06203433f, 
    -0.05448671f, 0.03337029f, -0.13066168f, -0.22419356f, 0.11315226f, -0.08900137f, -0.04080459f, 0.08296717f, 
    -0.05933435f, 0.04504715f, -0.03950549f, -0.01686649f, -0.15034045f, -0.02203800f, 0.03182639f, -0.02615400f, 
    -0.12449755f, -0.07534020f, -0.10053934f, -0.04199443f, 0.03834205f, -0.14059594f, -0.01541090f, -0.03273565f, 
    -0.22109742f, -0.05182781f, 0.05823616f, 0.00367797f, -0.08819906f, -0.05515128f, -0.08568270f, 0.01696427f, 
    0.00657050f, -0.05195321f, -0.07601971f, -0.03495654f, -0.15359637f, -0.17522834f, -0.05028445f, 0.03181070f, 
    -0.10648046f, -0.06728863f, -0.15844961f, -0.11701026f, 0.07296610f, -0.02951862f, 0.10892548f, 0.10858920f, 
    0.39428779f, 0.03382054f, -0.33183649f, 0.27515432f, 0.04920395f, -0.09277888f, 0.08005381f, -0.03245248f, 
    0.01517850f, 0.10382254f, 0.10335314f, -0.00066478f, 0.33592483f, 0.20016144f, 0.27420434f, 0.03400538f, 
    0.04477441f, 0.13731788f, 0.00376181f, -0.00300312f, -0.10248073f, -0.10642574f, -0.00930201f, 0.01309164f, 
    0.14425027f, 0.21416037f, 0.23888732f, -0.07859252f, 0.00088627f, 0.18816034f, 0.05205046f, 0.00630979f, 
    -0.06319582f, -0.05872101f, -0.13573025f, 0.01486682f, -0.29223847f, -0.33191869f, -0.34110609f, 0.07151654f, 
    -0.02537515f, -0.27268824f, -0.05201225f, -0.08813283f, 0.14020438f, 0.06502125f, -0.04168481f, 0.00964428f, 
    -0.17720546f, -0.38309029f, 0.10479105f, -0.14878213f, -0.06544271f, 0.04325105f, -0.22995515f, -0.05342188f, 
    0.09962374f, 0.06884212f, 0.04195204f, 0.04279524f, 0.14461455f, 0.35704809f, 0.54306370f, -0.02262637f, 
    0.03948722f, 0.12293229f, 0.10420099f, 0.20813905f, -0.20639145f, -0.10862877f, -0.14164788f, 0.01390482f, 
    0.24721855f, 0.09675062f, 0.07244223f, 0.09066185f, 0.15414409f, -0.03146222f, 0.04479019f, 0.00961768f, 
    0.00933077f, -0.11411355f, -0.11260683f, 0.05985336f, 0.16580997f, -0.13163342f, -0.17359373f, -0.22659464f, 
    0.08504552f, -0.07935949f, -0.02414902f, -0.06247691f, -0.04033607f, 0.05557606f, 0.06937391f, 0.24828665f, 
    -0.01357812f, 0.18696631f, -0.06459799f, 0.18772614f, -0.04694960f, 0.07334429f, 0.07942600f, 0.03854097f, 
    -0.10331384f, -0.07058965f, -0.09836403f, 0.00057370f, -0.04058925f, -0.01494706f, 0.22766961f, -0.07599360f, 
    -0.07252081f, -0.10965100f, -0.10898072f, 0.02148170f, -0.09729857f, -0.09994986f, -0.22958195f, -0.07155007f, 
    0.08518499f, -0.11187483f, -0.17743389f, 0.03517362f, 0.04973760f, -0.19675213f, -0.16917139f, -0.08558309f, 
    -0.06165904f, -0.12328660f, -0.11439006f, -0.07802838f, 0.22259554f, 0.18909459f, 0.09065700f, 0.18365569f, 
    0.04477671f, 0.05920694f, -0.02702725f, -0.01482447f, -0.03411834f, -0.06394745f, 0.01721842f, -0.17499450f, 
    0.07687993f, 0.09314699f, -0.07871251f, 0.02851329f, -0.08873501f, -0.12533890f, -0.35859570f, -0.38635227f, 
    0.02912728f, 0.08124832f, 0.05929648f, 0.02490515f, 0.03347452f, -0.36593750f, -0.09069457f, 0.07494172f, 
    -0.17375645f, 0.06225342f, -0.16965492f, -0.24921781f, 0.18114755f, -0.00840422f, -0.18496713f, 0.19065799f, 
    -0.08452721f, 0.06537830f, -0.00144034f, 0.03821414f, 0.05023798f, 0.06717052f, -0.12389617f, -0.09988086f, 
    0.13577421f, 0.00681878f, 0.15739053f, 0.10192073f, 0.03299426f, 0.04341506f, 0.13326500f, 0.11673534f, 
    0.04666420f, -0.02384149f, 0.04801520f, 0.04087914f, 0.08985294f, -0.05817980f, 0.02577605f, -0.05402546f, 
    0.63767678f, 0.12719066f, -0.08734360f, 0.13141669f, 0.13761534f, 0.12873943f, 0.04538050f, 0.00142381f, 
    -0.00332363f, 0.05818817f, 0.11110654f, -0.34003553f, 0.03595233f, 0.16168527f, -0.19574410f, -0.32428128f, 
    -0.19635524f, -0.23183528f, -0.00545604f, -0.07488716f, -0.02430357f, 0.13421181f, 0.02597410f, 0.04091872f, 
    -0.04115415f, -0.18377107f, -0.05690554f, 0.04694293f, -0.23147917f, 0.12033412f, -0.02262001f, -0.03156138f, 
    -0.07406723f, -0.07995614f, 0.11000675f, 0.07704975f, 0.16510281f, 0.00811874f, 0.17852619f, 0.23023643f, 
    -0.06765575f, -0.02596706f, -0.04031387f, -0.09386006f, 0.01280569f, -0.03664709f, 0.04856234f, 0.07086764f, 
    0.03450383f, 0.06097806f, -0.02994811f, 0.23188712f, -0.07829452f, -0.09973358f, 0.01390926f, -0.01482866f, 
    -0.13084659f, -0.00773320f, -0.02429314f, -0.07291063f, -0.14770752f, 0.27283740f, 0.34995380f, 0.10832188f, 
    0.18622081f, 0.26843873f, 0.18849888f, 0.08876664f, 0.07206596f, 0.00009438f, -0.09740373f, -0.03190518f, 
    -0.31237525f, 0.02230822f, 0.04629952f, -0.20727125f, -0.14910319f, 0.06902079f, 0.21391016f, 0.14915870f, 
    0.15171501f, 0.04471180f, 0.05470691f, -0.06014232f, -0.27948952f, -0.03306822f, -0.04234674f, -0.08851581f, 
    0.07739672f, 0.03730625f, 0.00758997f, 0.21428046f, -0.02760273f, 0.11749826f, 0.00628694f, -0.14031695f, 
    0.46813068f, 0.08865184f, -0.22337636f, -0.29009208f, 0.10955750f, 0.01122700f, -0.18463798f, -0.27853310f, 
    -0.10918164f, 0.02006774f, 0.08676071f, -0.05974984f, 0.08619436f, 0.03233829f, 0.12131157f, -0.07194316f, 
    -0.13229166f, -0.02633302f, 0.00243382f, 0.13041387f, 0.01320702f, -0.05680299f, 0.06807646f, 0.13627316f, 
    0.01581900f, 0.06771860f, 0.10577050f, -0.09452702f, 0.13994601f, 0.04978313f, 0.27736923f, 0.25476643f, 
    0.00703183f, -0.02569004f, -0.01204679f, -0.13190837f, -0.10733257f, 0.17600322f, -0.13006283f, -0.09599282f, 
    -0.03999022f, 0.22226684f, -0.04071703f, -0.03312507f, -0.08942758f, -0.24717814f, 0.01021221f, -0.10019711f, 
    0.32867867f, 0.28975716f, 0.15526785f, 0.08282801f, -0.13335490f, -0.02867301f, -0.06247970f, 0.12271557f, 
    -0.04020874f, -0.05709047f, -0.02254105f, -0.13114326f, 0.23301178f, -0.02973667f, 0.06251608f, -0.11474435f, 
    0.07728025f, -0.03143814f, 0.18477784f, -0.09114754f, 0.07244927f, 0.07743103f, -0.22486274f, 0.18215886f, 
    0.09625785f, 0.15952922f, -0.04455874f, 0.06946212f, -0.01366849f, -0.06925719f, -0.04545354f, 0.00390503f, 
    0.15828620f, -0.11555997f, -0.11498404f, -0.10157287f, 0.09623891f, -0.06767354f, -0.01993703f, 0.00258876f, 
    -0.07171093f, -0.07738346f, -0.00120220f, 0.01560956f, -0.13302651f, 0.01949799f, 0.00006095f, -0.09066778f, 
    0.06724561f, -0.04911935f, -0.20123141f, 0.07506289f, -0.02032867f, 0.11436298f, -0.16072246f, -0.00257883f, 
    -0.03731123f, 0.12544040f, 0.05582063f, -0.09056904f, -0.11103380f, -0.04522493f, 0.03169338f, -0.07567377f, 
    -0.05195245f, -0.19582878f, -0.17230670f, -0.11990363f, -0.02162654f, 0.11640298f, 0.04369660f, -0.08637143f, 
    0.04852330f, 0.07350443f, 0.11486049f, -0.13793705f, 0.12273648f, -0.03717206f, 0.14451593f, 0.23931760f, 
    -0.09526949f, -0.10512090f, 0.07449571f, 0.13855664f, 0.24427506f, 0.06277970f, 0.06951133f, -0.05379504f, 
    -0.05716174f, -0.01329711f, -0.05348304f, 0.02743921f, 0.06104178f, -0.02881376f, 0.00743160f, 0.05640236f, 
    -0.11968575f, 0.31782362f, -0.04543795f, 0.06537185f, -0.06438404f, -0.13139957f, 0.00422276f, 0.04724262f, 
    -0.04154074f, -0.02326623f, -0.03247695f, 0.17144127f, 0.19372019f, 0.20283873f, -0.07431557f, 0.24555705f, 
    0.05295422f, -0.03558980f, 0.20022517f, 0.11039180f, -0.09564011f, -0.07757595f, -0.02557688f, 0.01416472f, 
    -0.15703388f, -0.21064264f, -0.01813657f, -0.02233425f, 0.10302328f, -0.20038460f, -0.00330945f, 0.09644651f, 
    0.05050254f, -0.01870168f, -0.04171320f, -0.03439534f, -0.20429230f, -0.20620035f, -0.42767292f, -0.06578246f, 
    0.07587007f, -0.06411127f, 0.10559106f, -0.05074027f, 0.18220650f, 0.06075624f, 0.18371223f, 0.05613620f, 
    -0.21438849f, -0.12124965f, -0.03377911f, 0.31371045f, 0.01464445f, -0.05863491f, -0.09478942f, -0.05662723f, 
    -0.22267519f, 0.04603777f, 0.15193839f, -0.00772090f, -0.17624937f, 0.33988026f, -0.15282464f, 0.06048923f, 
    -0.06583806f, -0.01342327f, -0.06027672f, -0.08020344f, 0.00505244f, -0.08525556f, -0.05078487f, -0.01996262f, 
    0.02872996f, -0.13824512f, 0.04870688f, 0.17115898f, -0.00750888f, 0.03498354f, 0.10547520f, 0.09337468f, 
    -0.01502585f, 0.03151687f, 0.16594060f, -0.05392926f, 0.02131631f, -0.15726280f, 0.05439206f, -0.05014525f, 
    -0.08236144f, 0.01910951f, 0.02002360f, -0.00432335f, 0.06866705f, 0.17086093f, -0.00338795f, -0.01411861f, 
    -0.14825056f, -0.33916581f, 0.07838888f, -0.11692519f, 0.10312816f, 0.08740332f, -0.06890368f, -0.00527304f, 
    0.08968090f, -0.12644123f, 0.02257040f, 0.02198132f, -0.10833351f, 0.13005561f, -0.05749790f, -0.02540075f, 
    0.17741275f, -0.17400640f, 0.12894480f, 0.05388036f, -0.02499924f, 0.03505664f, 0.11510823f, 0.02336643f, 
    -0.02097649f, 0.09452215f, -0.24487592f, 0.08366863f, 0.07947623f, -0.03484324f, 0.11045952f, 0.02042157f, 
    0.07875761f, -0.06666576f, -0.10414001f, -0.26285163f, -0.13504250f, -0.12804325f, -0.31182283f, -0.10502486f, 
    -0.02550142f, 0.05723552f, -0.07449133f, -0.06592254f, -0.09144740f, 0.01478269f, 0.06016253f, -0.06907783f, 
    -0.22105581f, 0.04247700f, 0.01679379f, -0.23278847f, -0.05795537f, -0.10804576f, -0.11778934f, -0.04825590f, 
    0.22307391f, 0.06724311f, -0.08180723f, -0.05289901f, -0.20686150f, -0.08868026f, 0.08205374f, 0.02270528f, 
    -0.00108855f, -0.06217366f, 0.01490142f, 0.11585412f, 0.06032649f, 0.03697567f, 0.03768906f, -0.05448527f, 
    -0.21483040f, 0.07689311f, 0.09842607f, 0.13614452f, 0.01302370f, 0.08577520f, 0.14508328f, 0.20936970f, 
    0.08409877f, -0.05245057f, 0.03062443f, 0.16458286f, -0.42644680f, -0.19786689f, -0.02430297f, -0.05519857f, 
    -0.17329119f, -0.11308762f, 0.00395845f, -0.00593296f, 0.01689596f, -0.02288111f, 0.06159301f, 0.09740541f, 
    -0.12653761f, 0.22962916f, -0.19085576f, 0.12711108f, -0.00028312f, 0.03556402f, 0.06708115f, 0.16014220f, 
    0.04199114f, 0.00030470f, 0.28529525f, 0.22153388f, 0.20029363f, -0.19030471f, 0.17017610f, 0.08732147f, 
    0.01297791f, 0.15027599f, 0.01011995f, 0.06259238f, -0.01438136f, 0.02388697f, 0.06173564f, -0.12722713f, 
    -0.19080555f, -0.18629333f, 0.20624113f, 0.19092485f, 0.02828677f, -0.11771879f, 0.00854216f, -0.00027079f, 
    0.01688315f, -0.16661960f, 0.07034558f, 0.04386339f, -0.14613803f, -0.15947348f, 0.17394447f, 0.15481694f, 
    -0.10932697f, -0.13074356f, -0.09010947f, 0.14347859f, 0.11544263f, 0.01492381f, -0.07602079f, 0.02804972f, 
    -0.09598564f, 0.21361828f, 0.11222233f, 0.00135551f, 0.10738388f, -0.04502416f, -0.00184859f, -0.20176607f, 
    -0.13649148f, -0.06381573f, -0.02322989f, -0.10996728f, -0.02220314f, -0.05766116f, 0.43451068f, 0.00993706f, 
    -0.18784599f, 0.12506963f, -0.00621566f, 0.04982635f, 0.10856759f, 0.05791330f, -0.14711176f, 0.05790195f, 
    -0.06395007f, 0.07961661f, 0.04415237f, -0.13237926f, 0.04566196f, -0.03034648f, 0.00487010f, 0.04082254f, 
    -0.15736803f, -0.10881351f, -0.16886675f, -0.04420158f, 0.10625277f, 0.01201671f, 0.14575712f, -0.05132151f, 
    0.15340067f, -0.20763122f, -0.06180817f, -0.12993881f, -0.23293653f, -0.06543053f, 0.15388864f, -0.10545491f, 
    0.13601555f, -0.59736216f, 0.06624422f, -0.17997308f, 0.21928254f, 0.05722083f, 0.02566356f, 0.06951397f, 
    0.02171754f, -0.04131411f, -0.20491949f, -0.01747234f, -0.25175667f, 0.10515208f, -0.20452712f, -0.02593199f, 
    -0.05037296f, 0.05049738f, 0.02752671f, -0.07487143f, -0.03427612f, -0.02007297f, 0.12261726f, 0.00487645f, 
    -0.06343465f, 0.05369074f, -0.16129971f, 0.14591275f, 0.02710912f, 0.02838708f, 0.12575097f, 0.26846254f, 
    0.11230659f, -0.00201070f, 0.07527190f, 0.29404503f, 0.03330843f, -0.00381515f, -0.05901591f, 0.09102812f, 
    -0.04278522f, 0.10971526f, 0.13204861f, 0.10919562f, 0.22005787f, 0.10056558f, 0.18065415f, 0.15809682f, 
    -0.28900561f, 0.22427526f, -0.09074758f, 0.08356305f, 0.16318794f, -0.13023968f, 0.14060917f, 0.00426022f, 
    0.14372261f, -0.04392122f, 0.12580293f, -0.07347968f, -0.09618153f, -0.10380451f, -0.05541527f, -0.00255605f, 
    0.03332973f, -0.07555825f, -0.03307673f, 0.00247775f, 0.02670101f, 0.09953136f, -0.06579418f, 0.24069382f, 
    -0.15596806f, -0.16468605f, -0.01726554f, 0.07403399f, -0.04870156f, 0.02454044f, 0.10833524f, 0.18460456f, 
    -0.02672743f, -0.02777654f, 0.00341592f, 0.06372093f, -0.18594788f, -0.16345814f, -0.05782482f, 0.19706163f, 
    0.28024641f, 0.10671974f, 0.20283775f, -0.09772009f, -0.18209997f, -0.08813753f, 0.00723911f, 0.06369598f, 
    -0.00956974f, -0.18901962f, 0.00870734f, 0.00398634f, -0.11205161f, 0.02172433f, -0.00234290f, -0.28306410f, 
    -0.02105593f, -0.02576311f, 0.27533323f, 0.09319154f, 0.20995267f, -0.06270651f, 0.31768852f, 0.28266677f, 
    0.02431502f, 0.13755397f, 0.05932464f, -0.01108424f, 0.00528180f, 0.05875302f, -0.18492220f, 0.01962049f, 
    0.12434343f, -0.05907296f, 0.24313350f, 0.04242355f, -0.09788290f, 0.07785463f, -0.06860790f, 0.08448289f, 
    0.16697162f, 0.03985967f, -0.01353491f, -0.04004329f, 0.27666363f, 0.09705549f, 0.03304431f, -0.14177674f, 
    -0.17958045f, -0.06526458f, -0.17386900f, -0.02829870f, 0.08584093f, 0.03141206f, 0.07080682f, 0.01078770f, 
    0.09441835f, 0.45430684f, -0.02611459f, 0.33709460f, -0.04906318f, -0.01493309f, 0.17611822f, 0.09302320f, 
    0.16058080f, -0.03584781f, 0.16050246f, -0.13210140f, 0.04354138f, -0.46056604f, 0.38336253f, 0.04238354f, 
    0.06556457f, -0.02739943f, -0.16079703f, -0.18968540f, -0.08571131f, 0.04679991f, 0.02511449f, -0.02660948f, 
    0.03897623f, 0.03124645f, -0.03467283f, -0.06168888f, 0.10826522f, 0.15525152f, -0.17827679f, 0.10424730f, 
    0.12820268f, 0.12009685f, 0.01690471f, 0.05122042f, 0.05234929f, -0.12584278f, -0.06588157f, -0.23570977f, 
    -0.21524385f, -0.05122551f, 0.03276182f, -0.13310885f, 0.14831968f, 0.14269997f, -0.03891633f, 0.06402655f, 
    0.09876633f, -0.07082301f, -0.13946906f, -0.27371320f, 0.00839355f, 0.09183445f, -0.00948530f, -0.01589077f, 
    0.03122890f, -0.06819847f, -0.01888075f, -0.07239094f, -0.23492165f, 0.00008915f, -0.13001685f, 0.06145774f, 
    0.15934023f, -0.04555592f, 0.11469868f, -0.09235974f, 0.00004241f, 0.08429267f, 0.05486305f, 0.00159941f, 
    -0.06173619f, -0.25816438f, 0.04688757f, -0.06685667f, -0.05048355f, -0.00794980f, 0.11618013f, 0.09114217f, 
    -0.19625439f, -0.08154628f, -0.13695683f, -0.52336967f, -0.08293085f, -0.12254830f, -0.00657739f, 0.06633633f, 
    -0.11284700f, 0.01088541f, -0.14942761f, -0.16085367f, -0.27642033f, -0.23335329f, 0.00942467f, -0.06988775f, 
    0.18707392f, 0.10726603f, -0.20247336f, -0.07980803f, -0.16631120f, -0.05092328f, -0.01982244f, -0.14043097f, 
    -0.07680965f, 0.02954473f, 0.00386870f, 0.01647216f, 0.11807401f, -0.06885407f, -0.05439981f, -0.21510027f, 
    0.11479086f, 0.01666019f, 0.08767385f, 0.16341752f, -0.10274690f, -0.07565153f, -0.08378737f, -0.08307828f, 
    -0.00769614f, 0.17728294f, 0.07433146f, -0.11856119f, 0.00298719f, -0.08428386f, 0.01480968f, 0.10514247f, 
    -0.04456091f, -0.08868252f, -0.02109828f, 0.03794366f, 0.05965559f, -0.15414126f, -0.03941405f, -0.01060185f, 
    -0.16758066f, -0.23603776f, -0.10890389f, -0.12365142f, -0.08695254f, 0.09707803f, -0.02581065f, -0.07036228f, 
    0.05664513f, -0.00561723f, -0.06210396f, 0.17878619f, 0.01741336f, -0.08623976f, -0.14129207f, 0.03637211f, 
    0.18287304f, 0.06652048f, 0.02788216f, 0.06205607f, 0.08698864f, -0.11745283f, 0.27864176f, -0.01343296f, 
    0.02080334f, -0.00649389f, 0.12758331f, 0.06506766f, 0.09683939f, -0.09062374f, 0.01791831f, 0.07752010f, 
    0.09442730f, -0.15384717f, 0.00167667f, 0.09683173f, 0.27545336f, -0.03063669f, 0.10022587f, -0.03981787f, 
    -0.01045313f, -0.16556637f, 0.02034632f, -0.13716674f, -0.14854120f, -0.37061214f, -0.17349313f, -0.14978197f, 
    0.04448628f, -0.08132696f, -0.12547037f, -0.07429556f, 0.13271955f, -0.03189962f, 0.05837495f, 0.00351740f, 
    0.08361215f, -0.00455876f, -0.01852321f, 0.00514307f, -0.16494682f, -0.02293216f, -0.01448416f, 0.02416681f, 
    -0.08790774f, 0.01814279f, -0.11579514f, -0.15780559f, 0.11119542f, -0.11356846f, 0.28835586f, -0.16294187f, 
    -0.12471519f, 0.00791045f, -0.12064216f, 0.07703832f, 0.11107432f, 0.00127291f, -0.05918375f, -0.04142440f, 
    -0.11591901f, 0.15796438f, 0.08168913f, 0.05232491f, 0.01934756f, -0.06204629f, -0.06323764f, -0.07677524f, 
    0.21715671f, 0.08879902f, 0.14549734f, -0.08306379f, -0.11075410f, 0.05182291f, -0.13882603f, -0.15286978f, 
    -0.16838872f, 0.12660308f, -0.16454290f, -0.11212073f, -0.06967876f, -0.00515756f, -0.22658250f, -0.06742819f, 
    0.08707718f, 0.24926545f, -0.04431183f, -0.00196224f, -0.05118717f, -0.02017273f, -0.06879257f, -0.05373138f, 
    -0.03855610f, -0.08314593f, -0.00089065f, -0.05672566f, -0.00367318f, -0.17063349f, 0.22380522f, -0.05209763f, 
    -0.08039688f, 0.11189817f, 0.11132690f, 0.11120121f, 0.11146727f, 0.05857215f, -0.12451489f, -0.10354872f, 
    0.02933413f, 0.01801806f, 0.18451458f, 0.00217016f, 0.10684753f, 0.07144989f, 0.12791887f, 0.09604713f, 
    0.25599387f, 0.22049260f, 0.24220055f, 0.07805467f, 0.03053955f, 0.07685295f, 0.09169789f, 0.12333357f, 
    0.00807020f, -0.08875234f, -0.04945030f, -0.10873005f, 0.08278736f, 0.09041668f, -0.02564567f, -0.06265169f, 
    0.37457272f, 0.09080818f, -0.01420418f, 0.23177561f, -0.07721835f, 0.09836181f, -0.10014299f, -0.05457601f, 
    -0.16760370f, -0.11281601f, 0.06957380f, 0.04147705f, -0.38527757f, -0.11466052f, 0.01009178f, -0.21389198f, 
    0.02956787f, -0.05060133f, 0.09082798f, 0.21870413f, 0.15306810f, 0.03197992f, 0.16960770f, 0.14197771f, 
    -0.26509702f, 0.00507445f, 0.10643923f, -0.07138530f, -0.06057856f, -0.08477868f, 0.03368704f, 0.20806377f, 
    0.02776911f, 0.00587956f, 0.10839710f, 0.26258838f, 0.29859856f, 0.10581090f, 0.21261607f, 0.06583717f, 
    -0.06496857f, 0.05708778f, -0.14454059f, -0.11744411f, -0.14182426f, -0.04486790f, -0.15419465f, -0.09599155f, 
    0.05883952f, 0.36842379f, 0.14384353f, 0.28975573f, 0.08762029f, -0.11939152f, 0.00097953f, 0.19340990f, 
    -0.09258033f, 0.05620501f, -0.08698656f, -0.02713930f, -0.18448885f, -0.02691348f, -0.06675056f, -0.12387376f, 
    -0.01472426f, 0.17444947f, -0.01696671f, 0.10306487f, 0.11457781f, -0.16646942f, 0.04854342f, 0.04330767f, 
    -0.28990284f, -0.12409877f, -0.09571385f, -0.17057896f, 0.07010449f, -0.26228431f, 0.12154206f, 0.10164917f, 
    0.13200995f, -0.02184668f, -0.03980615f, -0.05528976f, -0.19513115f, -0.09827005f, -0.25897351f, -0.14744359f, 
    -0.14308211f, -0.17056677f, 0.00718941f, 0.09470142f, 0.01172688f, -0.02796350f, -0.00409788f, -0.08857476f, 
    0.07840156f, -0.20957483f, -0.14299148f, -0.17172471f, 0.17115690f, 0.09107670f, 0.01851567f, -0.00456516f, 
    0.09481555f, 0.01902022f, 0.17339718f, 0.19532880f, 0.01794499f, 0.24652852f, 0.14788295f, 0.26222670f, 
    -0.11545719f, -0.14690877f, 0.01884212f, -0.01976049f, -0.00174543f, -0.10502444f, 0.09293251f, 0.06803412f, 
    0.00560149f, -0.00594909f, 0.14281669f, -0.03582291f, -0.07396044f, 0.12920116f, 0.17632027f, -0.01400204f, 
    -0.10733669f, -0.08185521f, -0.05215851f, -0.10758566f, -0.20323426f, 0.05385720f, -0.08126157f, -0.02551147f, 
    0.06819803f, 0.12053019f, 0.05744337f, -0.00854335f, 0.08665823f, 0.06707171f, 0.07884188f, 0.14372145f, 
    -0.05473389f, 0.07593810f, 0.08661243f, 0.05597052f, 0.03649551f, 0.15272321f, 0.09308928f, 0.15204272f, 
    0.09847753f, 0.03438154f, 0.01595325f, -0.06787817f, 0.44244266f, 0.04434492f, -0.02716527f, 0.16235578f, 
    0.03253428f, -0.05822805f, 0.24731302f, 0.15026896f, 0.11903392f, 0.00207477f, -0.07969876f, 0.06630324f, 
    0.08342368f, 0.15261018f, -0.00523905f, 0.00221743f, -0.06884971f, -0.00102364f, -0.01601393f, 0.01885064f, 
    0.27404353f, 0.03490827f, -0.00935641f, 0.00143598f, 0.03607909f, 0.10756022f, -0.04129375f, -0.05192721f, 
    -0.04277031f, -0.08605190f, -0.01439850f, -0.01528657f, 0.00164091f, 0.05373408f, -0.06695018f, 0.00127332f, 
    -0.41540265f, 0.12935673f, 0.14197069f, 0.00433323f, 0.04494887f, 0.13009717f, -0.01443736f, 0.06000772f, 
    0.09599847f, -0.10899962f, 0.11883931f, 0.02322011f, -0.31493759f, -0.27583516f, -0.24622367f, -0.10935456f, 
    0.07923985f, 0.09107617f, 0.02175655f, 0.08808187f, -0.06342386f, 0.13516612f, 0.01901543f, 0.18034030f, 
    0.06225235f, -0.25909552f, -0.10135882f, 0.10104690f, -0.12206987f, -0.02384969f, 0.01718395f, 0.27217314f, 
    0.00621135f, 0.00437356f, 0.03516154f, 0.15460229f, 0.04657475f, 0.12283791f, 0.03126816f, -0.11461932f, 
    -0.06709552f, 0.02195084f, -0.01605755f, -0.01204231f, 0.09286858f, -0.07063799f, 0.05457602f, -0.10474364f, 
    0.16161428f, 0.00123181f, 0.06332809f, 0.01032872f, 0.04470980f, -0.08845199f, 0.06145637f, -0.01360451f, 
    -0.02474330f, 0.06328877f, -0.06721420f, 0.13297395f, 0.10926208f, -0.12719285f, -0.03880620f, 0.20664109f, 
    0.13519622f, 0.02357476f, 0.03761363f, 0.05641025f, -0.03031611f, 0.08642939f, 0.02633998f, -0.02814076f, 
    0.18772328f, -0.22955084f, -0.20242549f, -0.13829733f, 0.15476023f, 0.04298712f, -0.22568414f, -0.04588047f, 
    -0.05374458f, -0.00507188f, 0.01899687f, 0.08903042f, -0.13817553f, -0.10519474f, -0.13066392f, -0.15851609f, 
    0.10026195f, 0.02100246f, 0.01541354f, 0.02660369f, 0.03978587f, -0.02030711f, -0.09608395f, -0.02599379f, 
    -0.27421671f, -0.03338866f, 0.11404784f, 0.17071071f, 0.20253193f, 0.06847156f, 0.00981416f, -0.05638294f, 
    -0.03552989f, 0.03681979f, 0.34290987f, -0.09153122f, 0.10811637f, 0.39475369f, -0.12497614f, -0.01864009f, 
    0.07416002f, -0.07630815f, -0.06160560f, 0.02500013f, -0.01099029f, -0.03729072f, 0.04834736f, 0.07397476f, 
    0.15221463f, 0.00806193f, 0.30446583f, 0.12363745f, -0.02595939f, 0.04797831f, 0.26807404f, -0.05077476f, 
    -0.00479943f, 0.00522373f, 0.13289350f, -0.00850532f, 0.05024747f, 0.19261585f, -0.01136132f, 0.12802571f, 
    0.02406588f, 0.10360765f, -0.02023011f, 0.09506119f, -0.09550279f, -0.14763612f, -0.03173433f, -0.17020372f, 
    0.17285258f, 0.08441358f, -0.02034815f, -0.07427309f, -0.01922779f, 0.05009125f, -0.02337597f, 0.13505350f, 
    -0.12326187f, -0.11185795f, -0.03668981f, -0.02003811f, -0.07393604f, 0.07936571f, 0.11675641f, -0.10774538f, 
    0.05301905f, -0.05105154f, 0.08596333f, -0.08480550f, 0.01366131f, 0.19105925f, -0.01502675f, 0.10841861f, 
    -0.04263341f, 0.15525523f, -0.14920822f, -0.07404942f, 0.03261819f, 0.01047199f, 0.07623686f, -0.07353302f, 
    0.03406309f, -0.00123778f, 0.07011858f, 0.32215354f, 0.10124519f, -0.13218404f, -0.06077705f, -0.08570868f, 
    -0.00782081f, -0.03499952f, -0.02578352f, 0.02890285f, 0.03424732f, 0.12593548f, 0.00793726f, -0.04998382f, 
    0.37852699f, -0.14388679f, -0.01953398f, -0.11667884f, -0.03170737f, 0.00259583f, 0.01403127f, -0.05322905f, 
    -0.02348569f, -0.03722819f, 0.00961441f, 0.02997806f, -0.14242013f, 0.27716258f, 0.14874424f, 0.06749960f, 
    -0.09829105f, -0.03699463f, 0.12791711f, 0.06636135f, 0.04255117f, 0.02246088f, 0.02655727f, 0.03095456f, 
    -0.10177379f, 0.00029063f, -0.00407750f, 0.18556960f, 0.04279298f, 0.09054257f, 0.02092223f, -0.01032885f, 
    -0.04868316f, -0.01294380f, 0.03675026f, -0.00504548f, 0.26873797f, -0.06929936f, 0.04605404f, -0.00128486f, 
    -0.13877967f, 0.09198692f, -0.06111898f, 0.05978286f, -0.09110691f, -0.05195463f, -0.06666435f, -0.09831794f, 
    -0.05852034f, 0.21842481f, 0.07451215f, -0.02584602f, 0.01167997f, -0.08128250f, 0.14662135f, 0.06920061f, 
    -0.18607360f, -0.12333476f, -0.02329165f, -0.00185681f, -0.25097117f, 0.08751837f, -0.02822826f, 0.18368900f, 
    -0.06945152f, 0.01373490f, -0.16072798f, 0.00761751f, 0.09311870f, -0.03529833f, 0.03803451f, -0.06525203f, 
    -0.36450928f, -0.00668029f, 0.06380497f, 0.05278784f, -0.11158926f, -0.02795630f, -0.09392478f, 0.08588359f, 
    0.00681073f, 0.14446352f, -0.05621887f, -0.07288859f, -0.00568686f, 0.33620277f, -0.12194882f, 0.08628273f, 
    -0.11846732f, -0.06073309f, -0.00326053f, -0.00199875f, 0.00243121f, 0.10849332f, -0.02881847f, -0.03344810f, 
    0.06234933f, -0.13221793f, -0.01402335f, -0.02220110f, 0.05734772f, 0.00963527f, -0.05811080f, -0.04359034f, 
    0.02522863f, 0.04733102f, 0.10229715f, 0.17489912f, -0.21696518f, -0.33093607f, -0.26597238f, 0.28400260f, 
    0.06977459f, 0.04785619f, 0.09161891f, 0.01656517f, -0.01926417f, -0.08359650f, -0.00833436f, -0.00290935f, 
    -0.11090655f, -0.13787602f, 0.20471378f, 0.21116444f, 0.18639024f, 0.04863853f, 0.14662117f, 0.04151234f, 
    0.13633171f, 0.05214701f, 0.13232136f, 0.09941760f, -0.06890192f, -0.04907833f, 0.06605192f, -0.01467893f, 
    -0.19830197f, 0.15830852f, -0.06747878f, -0.01750289f, -0.16599827f, -0.03088281f, 0.00852640f, 0.10105350f, 
    0.00760936f, 0.39809975f, 0.04125024f, 0.14903629f, 0.00312243f, -0.04189254f, -0.02577857f, 0.12845887f, 
    -0.04138434f, -0.02572374f, 0.04975190f, -0.07410665f, 0.32187781f, 0.18518613f, 0.24712794f, -0.03565283f, 
    0.19812122f, 0.02777438f, 0.24450089f, 0.17638214f, 0.02702360f, 0.06197724f, -0.01155107f, 0.14030370f, 
    0.08124578f, 0.07199375f, 0.07926723f, -0.19477394f, -0.02624179f, -0.04579113f, 0.08833544f, -0.15667191f, 
    -0.01327914f, 0.00103717f, -0.01802567f, -0.04102129f, -0.05277944f, -0.01573120f, -0.12119801f, -0.01850230f, 
    -0.00732612f, -0.01516498f, 0.01073436f, -0.04849763f, 0.03570095f, -0.06095167f, -0.11439919f, 0.00037463f, 
    0.26607481f, -0.05942667f, 0.34541628f, -0.04173308f, -0.25167292f, -0.00835336f, -0.11997655f, -0.11778761f, 
    -0.08350517f, 0.04294427f, -0.05967792f, 0.28906980f, -0.09987861f, 0.08503751f, 0.09346291f, 0.13006681f, 
    -0.05785989f, -0.08826005f, 0.05907625f, 0.03742288f, 0.11505181f, 0.06149136f, 0.07684669f, -0.11789598f, 
    0.19221377f, 0.11958070f, 0.00613527f, 0.08564420f, 0.09729693f, -0.12367105f, -0.13671421f, -0.20513923f, 
    0.03725805f, -0.05367225f, 0.01565222f, -0.01463690f, 0.17990734f, 0.06694191f, 0.16526748f, -0.17867953f, 
    -0.09012603f, -0.08665495f, -0.11227713f, 0.05550329f, -0.03194086f, -0.04579892f, -0.12546469f, -0.12628503f, 
    0.09181338f, 0.35773757f, -0.04742580f, 0.06006915f, 0.03026818f, 0.03267707f, -0.00043301f, 0.07164154f, 
    -0.04482428f, -0.03771324f, -0.08285087f, 0.12898523f, -0.18744624f, 0.05528880f, -0.39152914f, 0.11055914f, 
    -0.12900317f, -0.09778236f, -0.05910688f, 0.05677749f, 0.04365031f, -0.04784409f, 0.22692208f, -0.07311827f, 
    -0.40107998f, -0.07460781f, -0.31201956f, 0.08812247f, 0.05899824f, -0.10000972f, -0.06315418f, 0.07415120f, 
    -0.01422156f, 0.00269028f, -0.08758634f, -0.05008791f, -0.11673932f, -0.08849320f, -0.07510842f, 0.22519384f, 
    -0.03784110f, 0.04988869f, -0.12847294f, -0.00290971f, 0.01119224f, -0.05577369f, 0.16342983f, 0.06051521f, 
    -0.16355856f, -0.29997978f, 0.20345645f, -0.12318902f, 0.10526365f, 0.05041013f, 0.03494405f, 0.02436565f, 
    0.01433242f, 0.05103680f, 0.03479984f, 0.15744108f, -0.18572803f, 0.31081036f, -0.25061092f, 0.37089381f, 
    -0.01196367f, -0.05033704f, 0.05667790f, -0.04327867f, 0.03522529f, 0.07622577f, 0.06942272f, 0.20013042f, 
    0.01126922f, 0.12129948f, -0.26471108f, -0.06444348f, 0.06862503f, -0.06035242f, -0.01929503f, -0.01449818f, 
    -0.08960249f, 0.21264333f, -0.01051285f, -0.06090119f, -0.08017513f, -0.15042336f, 0.17197700f, 0.00467542f, 
    -0.02836691f, 0.01401754f, -0.14052896f, 0.06475914f, 0.13695444f, -0.01820738f, -0.01301175f, -0.11105863f, 
    -0.38455996f, -0.09053617f, -0.12130063f, 0.13381687f, 0.02727627f, -0.04715263f, 0.17514926f, -0.26846305f, 
    0.13308597f, -0.03958983f, -0.03134794f, 0.05252256f, 0.31195056f, 0.15907715f, 0.09344182f, 0.23162141f, 
    0.10736200f, 0.11197623f, 0.05332619f, 0.15913732f, 0.05084162f, 0.06393657f, 0.08756714f, 0.10255659f, 
    0.03260756f, 0.04780454f, -0.16852815f, 0.05511938f, 0.11826167f, 0.06257760f, 0.12035419f, -0.02611613f, 
    0.14620182f, 0.06281857f, 0.08139746f, -0.33897167f, -0.06664065f, -0.06132497f, -0.29908967f, -0.24212879f, 
    -0.03742148f, -0.06397805f, -0.03337366f, 0.11051434f, -0.01998724f, 0.06106463f, 0.05029145f, 0.02696048f, 
    -0.04549415f, 0.04700663f, 0.23249282f, -0.29985526f, 0.01966724f, 0.06323849f, -0.20973551f, 0.05937414f, 
    0.07650745f, 0.14062792f, 0.16672057f, -0.04939772f, -0.14670794f, -0.16074459f, 0.04534882f, 0.08419902f, 
    -0.03429327f, -0.08560548f, 0.01945678f, 0.03760923f, -0.10864427f, -0.03941558f, 0.03766428f, 0.11328080f, 
    -0.00634861f, 0.05729198f, -0.05094659f, 0.12743440f, 0.10527512f, -0.06384968f, 0.01250535f, -0.01913284f, 
    0.01217932f, -0.01587477f, 0.08592506f, 0.20544146f, -0.34709039f, 0.15106742f, -0.07420240f, -0.18004423f, 
    -0.22513674f, -0.14554259f, -0.16920513f, -0.11669894f, -0.10739531f, -0.04351753f, -0.00405076f, 0.10105889f, 
    0.22463062f, 0.06572592f, -0.32814732f, 0.19013733f, 0.13014553f, -0.13290547f, -0.08606381f, 0.17140487f, 
    0.27542371f, 0.06619728f, 0.07919638f, 0.03212960f, 0.19622502f, -0.22727089f, -0.04157176f, 0.12912931f, 
    0.05584109f, 0.05890061f, 0.19035578f, 0.03051134f, -0.03651726f, 0.03376159f, -0.08236962f, 0.01250118f, 
    -0.10637376f, -0.27332231f, 0.01673409f, 0.10676095f, 0.01563479f, -0.03833291f, 0.00453782f, 0.04573049f, 
    0.12832119f, -0.16192749f, 0.13250834f, 0.08334944f, -0.36833599f, -0.17528720f, 0.25238609f, 0.00114234f, 
    -0.14586483f, -0.08097228f, 0.06586251f, 0.17748630f, 0.09180978f, 0.00053527f, 0.11962897f, 0.03836425f, 
    -0.14456080f, 0.03114761f, 0.09413672f, -0.13295543f, 0.10022461f, 0.05481935f, -0.15768072f, -0.19441384f, 
    -0.03423736f, -0.07397571f, -0.08825739f, 0.01978032f, 0.35501122f, 0.17136469f, -0.01361799f, -0.23315965f, 
    -0.07977714f, -0.06870676f, -0.00938410f, 0.13342254f, -0.03358688f, 0.01609059f, 0.12254512f, 0.13769391f, 
    0.03745178f, 0.19338676f, -0.08462968f, -0.20900315f, -0.16099754f, -0.09412409f, -0.14375556f, 0.10395797f, 
    -0.12095690f, -0.13636844f, -0.00506777f, -0.27012250f, -0.07985981f, -0.18817230f, -0.02496770f, -0.03398608f, 
    0.15049878f, 0.00789313f, -0.16838861f, -0.28218380f, 0.04330781f, -0.04172973f, -0.09245465f, -0.15286687f, 
    -0.26329079f, -0.17187357f, 0.23993833f, 0.14179179f, -0.00373006f, -0.01138017f, 0.01630930f, -0.01322972f, 
    -0.05035007f, 0.03075029f, -0.00166831f, -0.01946925f, 0.07317231f, 0.04482261f, -0.13337384f, 0.28275883f, 
    0.03360154f, 0.21530637f, 0.03580342f, 0.05798685f, -0.02078635f, -0.10657530f, 0.06300046f, 0.01557573f, 
    -0.00252086f, 0.02119371f, 0.06587875f, 0.20696394f, 0.07524903f, -0.00791084f, 0.02165829f, 0.16472982f, 
    0.22529072f, 0.05767009f, -0.02935099f, 0.06439222f, 0.00556190f, -0.02380284f, -0.06489458f, 0.09356830f, 
    -0.08289928f, 0.12276053f, -0.00139054f, 0.01936733f, 0.16753365f, 0.04159393f, 0.13900018f, 0.26250476f, 
    -0.30073741f, 0.23976845f, 0.09972107f, 0.23774396f, 0.11861324f, -0.19475858f, 0.06586891f, 0.07082419f, 
    0.07213914f, -0.05453374f, 0.02054640f, 0.02558481f, -0.21813129f, -0.12084990f, -0.07117491f, 0.13378027f, 
    0.03637087f, 0.06708597f, -0.11686668f, -0.05653028f, 0.02172494f, -0.06812547f, 0.01242056f, 0.04976156f, 
    0.01045720f, 0.04773494f, -0.08442772f, -0.03746228f, 0.10528278f, 0.06239265f, 0.15948872f, 0.09328036f, 
    -0.06286440f, -0.10206253f, -0.01474133f, 0.17409703f, -0.28041300f, 0.10155424f, -0.12688272f, 0.06361164f, 
    0.16584095f, -0.16197549f, -0.07454238f, -0.07609069f, -0.05856643f, -0.13781370f, -0.00556448f, 0.09467736f, 
    0.03772470f, -0.13250780f, 0.20985219f, -0.12934168f, -0.06869351f, 0.08887245f, -0.15015104f, -0.20923012f, 
    0.06761227f, -0.01441703f, 0.09318355f, 0.09098183f, 0.39671904f, -0.10467582f, 0.13778798f, -0.11016573f, 
    0.15485017f, 0.19658743f, 0.20949665f, 0.24999411f, -0.08447675f, 0.07879651f, -0.02261233f, -0.10940655f, 
    0.62089431f, -0.07883785f, -0.01791682f, 0.01156853f, 0.01632328f, 0.06099786f, 0.00814681f, 0.02017324f, 
    0.20229080f, -0.04670439f, 0.00565815f, 0.15662149f, 0.27682841f, -0.26510179f, 0.11273365f, 0.05012931f, 
    -0.04135631f, -0.08503911f, -0.11572133f, 0.03430914f, 0.02618710f, 0.06711565f, 0.08650459f, -0.03322910f, 
    -0.35180464f, 0.36120492f, -0.04881972f, 0.11133113f, -0.06889887f, -0.05246795f, 0.08439532f, -0.03216339f, 
    0.12289944f, 0.09226936f, 0.06701841f, -0.05807490f, 0.27385816f, 0.16185309f, 0.37095109f, -0.01599642f, 
    0.00499865f, 0.00466124f, -0.14612889f, -0.06190425f, -0.08169484f, -0.01947965f, 0.02153161f, 0.02607197f, 
    -0.01440791f, 0.02040868f, -0.03703631f, -0.02965812f, -0.07020324f, -0.05325833f, -0.05036689f, -0.01886342f, 
    0.00363997f, -0.05607231f, 0.04058162f, 0.00054716f, 0.02339944f, 0.03749442f, 0.00818340f, 0.04784578f, 
    -0.00084196f, -0.04468366f, 0.01160840f, -0.06339200f, -0.02189478f, -0.07257907f, -0.03850192f, -0.02646626f, 
    0.00064529f, -0.03070363f, -0.04193382f, -0.03580164f, -0.02244260f, 0.02827721f, -0.06426378f, 0.05444575f, 
    -0.03558635f, -0.07263723f, 0.03995762f, -0.06080766f, -0.04662384f, 0.00305460f, -0.00455623f, -0.04618210f, 
    0.00453332f, -0.01790036f, -0.04315104f, 0.03575799f, -0.06389608f, -0.03661976f, 0.04730330f, -0.04744900f, 
    -0.00972906f, -0.07002412f, 0.00156511f, -0.03499055f, -0.05990905f, 0.03783112f, -0.02916405f, 0.05984316f, 
    0.05277209f, 0.03983634f, 0.01732200f, -0.05903424f, 0.00847651f, 0.05225980f, -0.05138690f, -0.02478089f, 
    -0.01824316f, 0.07012168f, -0.00802922f, 0.04038830f, -0.06380088f, -0.04058278f, 0.04725273f, 0.00453555f, 
    0.03186247f, -0.04094309f, -0.02600736f, 0.01838580f, -0.04848161f, 0.02586968f, -0.05579700f, 0.01638334f, 
    -0.06080945f, 0.05657099f, -0.02770779f, -0.00859592f, -0.06424490f, 0.01537827f, 0.00995292f, -0.07751179f, 
    0.02223269f, -0.03547796f, -0.00071906f, -0.01195945f, 0.02332312f, 0.01376029f, -0.06297454f, 0.02489174f, 
    -0.00918778f, -0.02928429f, 0.04813887f, -0.05850528f, 0.03335850f, 0.01752901f, 0.05622767f, -0.03240475f, 
    0.01849826f, 0.01683480f, -0.00275791f, -0.03349223f, 0.04676756f, -0.01236347f, -0.01105368f, -0.07699186f, 
    -0.08519173f, -0.04063271f, 0.01309927f, -0.00144445f, -0.07532693f, 0.06288523f, -0.04490274f, 0.01786320f, 
    -0.04522429f, -0.05992164f, 0.03997084f, 0.02860220f, 0.01792168f, 0.00999984f, -0.06820849f, -0.03506373f, 
    0.01479577f, 0.04839101f, -0.07603543f, -0.00611039f, -0.01648723f, 0.00577180f, 0.01896497f, 0.03125377f, 
    -0.07252234f, 0.00843863f, 0.04647125f, -0.05004686f, -0.06487174f, -0.00153068f, -0.05477289f, -0.07178120f, 
    0.00828300f, 0.04191144f, -0.02244957f, -0.04499572f, -0.05486019f, -0.00897271f, 0.06597007f, 0.06104292f, 
    0.01610786f, 0.01790095f, 0.05434680f, -0.07634539f, -0.07622621f, 0.06379123f, 0.01889074f, 0.03279439f, 
    0.04528123f, 0.05687239f, 0.01595762f, -0.06211424f, 0.05016001f, 0.01427747f, 0.04434315f, -0.04818029f, 
    -0.00410755f, -0.08553743f, -0.02211120f, -0.02628184f, -0.00843572f, -0.07175057f, 0.01649482f, -0.07091891f, 
    -0.06473488f, 0.04286954f, 0.00297382f, 0.00204373f, -0.00082384f, -0.06824682f, 0.00594041f, -0.00079532f, 
    -0.01451353f, -0.03133295f, 0.02613405f, -0.06677668f, 0.07000726f, 0.05724508f, 0.05732737f, -0.05403554f, 
    -0.06330134f, 0.01265632f, 0.24477471f, 0.10596040f, 0.02954686f, 0.12501320f, 0.02169241f, 0.09018657f, 
    0.19756934f, -0.00185266f, -0.01930820f, 0.08906503f, 0.04404342f, 0.00677253f, 0.15899722f, 0.01150724f, 
    -0.08093040f, 0.08836164f, 0.09427073f, 0.00376370f, -0.03585494f, 0.14148869f, 0.17614488f, 0.10295372f, 
    0.05402579f, 0.21460743f, -0.09084479f, -0.03803063f, -0.11920267f, 0.06723982f, -0.08989584f, 0.11866816f, 
    -0.10399117f, -0.08630888f, -0.03132541f, 0.04519358f, 0.08196261f, 0.08936977f, 0.08018357f, -0.05933880f, 
    0.20587850f, 0.08789321f, 0.16658309f, 0.09974682f, -0.07112935f, 0.04848296f, -0.06019807f, 0.08185865f, 
    -0.03068816f, -0.11051616f, 0.07336023f, -0.07949973f, -0.00859199f, 0.02685307f, 0.06837238f, 0.01296870f, 
    -0.24929979f, -0.07936992f, -0.09554733f, -0.09198598f, -0.06693102f, -0.01500144f, 0.05963769f, -0.11165631f, 
    -0.06692887f, -0.00908612f, -0.00417191f, -0.00633224f, -0.01237655f, 0.01097234f, -0.10014813f, -0.19049840f, 
    0.40115291f, 0.05181245f, 0.35542858f, 0.05045833f, -0.20814550f, -0.12355099f, 0.04461434f, -0.04512601f, 
    -0.08265369f, 0.04828776f, -0.04326602f, 0.17105480f, 0.11055402f, 0.00981133f, -0.07759806f, 0.01977757f, 
    0.02050183f, 0.09373349f, 0.24046715f, 0.26768890f, 0.17528239f, 0.02365110f, -0.05876581f, -0.00721834f, 
    0.19708617f, -0.00438136f, -0.06792427f, -0.00615339f, 0.01190493f, 0.10228823f, -0.03577668f, -0.14256431f, 
    0.12302759f, 0.02074428f, -0.16001557f, -0.06573964f, 0.17814013f, 0.00064354f, 0.10775052f, -0.11654481f, 
    -0.16825576f, -0.14979054f, -0.03162517f, -0.10437595f, -0.13732292f, 0.01167386f, -0.04635808f, -0.05019011f, 
    0.19388820f, 0.00202418f, 0.11914845f, 0.07475509f, -0.11319985f, 0.10045860f, -0.04660066f, -0.00385700f, 
    0.06824446f, 0.12394936f, 0.09172307f, -0.04981420f, -0.37881652f, 0.02090774f, -0.10861515f, -0.01979994f, 
    -0.17046134f, -0.06083646f, -0.06600717f, -0.02498129f, 0.16129294f, 0.01231940f, 0.21145509f, 0.02583219f, 
    -0.43376541f, -0.03541303f, -0.16407549f, 0.03420841f, 0.03602540f, 0.00251650f, 0.12778124f, 0.09672544f, 
    -0.11206794f, 0.03957797f, -0.03028106f, -0.08632989f, -0.06688797f, -0.02114176f, -0.27997154f, -0.16133069f, 
    -0.02455090f, 0.05855337f, -0.03571936f, -0.13346061f, 0.10960320f, 0.03945668f, 0.04830490f, -0.14575623f, 
    -0.00485018f, -0.12551051f, 0.11979792f, -0.04905809f, -0.09780735f, 0.06702008f, 0.02967581f, 0.32859075f, 
    -0.02931621f, -0.14920586f, -0.09763380f, 0.10929779f, 0.08758508f, -0.17489710f, -0.00666215f, 0.23859148f, 
    -0.19797617f, -0.00665544f, 0.06511737f, -0.02476466f, 0.03699318f, 0.01126825f, -0.06317375f, 0.10147110f, 
    -0.09274418f, 0.10382178f, 0.01915863f, -0.01756865f, 0.12692240f, 0.01662217f, 0.06357073f, 0.08544011f, 
    -0.00233837f, 0.14572684f, -0.01998588f, 0.07033741f, -0.00823626f, -0.03959615f, 0.08712005f, 0.04259324f, 
    0.02034151f, -0.07504187f, -0.00715380f, 0.07869449f, 0.00922075f, -0.09900396f, 0.03582905f, -0.06924744f, 
    0.05637227f, 0.27253151f, -0.15569983f, 0.07509214f, 0.03345735f, -0.10335857f, 0.24111812f, -0.08207395f, 
    -0.03596606f, -0.04432521f, -0.01952330f, 0.05080417f, 0.28222838f, 0.01797139f, 0.12766188f, 0.16093256f, 
    -0.00466056f, 0.31405312f, 0.14913788f, -0.01232950f, -0.06968293f, -0.05419124f, 0.13945690f, 0.20721580f, 
    0.13787311f, -0.03039159f, -0.02621145f, 0.00816519f, -0.02323792f, -0.06681947f, -0.00569405f, -0.14876044f, 
    -0.01335689f, 0.15229005f, 0.07121170f, 0.08821863f, 0.05624564f, 0.07111438f, 0.12365010f, -0.04549437f, 
    -0.10124978f, 0.02309534f, -0.02985074f, 0.00545869f, 0.13381939f, 0.13151182f, -0.02260466f, -0.08024411f, 
    0.53159183f, -0.00677935f, 0.26748601f, -0.04437374f, 0.03621522f, 0.03546621f, 0.04404646f, -0.00465792f, 
    -0.07187559f, 0.11976440f, 0.13427819f, 0.15759693f, -0.02092944f, -0.02615694f, 0.02312943f, 0.20041499f, 
    -0.15664089f, -0.13532248f, 0.10914452f, -0.00550149f, 0.02503159f, 0.07517868f, 0.04965236f, -0.06354604f, 
    0.11568186f, -0.08701079f, 0.01521278f, 0.00474624f, -0.03453376f, -0.12559354f, -0.09848199f, -0.16673344f, 
    0.03437889f, 0.11048092f, 0.02265729f, -0.09410504f, 0.16090156f, 0.21095456f, -0.05650702f, -0.24769273f, 
    -0.08139917f, -0.02375639f, 0.00886049f, -0.03175741f, 0.05401802f, -0.05356602f, -0.14944759f, -0.08710842f, 
    0.24252552f, -0.03221263f, 0.05699526f, 0.00578434f, -0.04046815f, -0.01746881f, 0.04090738f, 0.01968490f, 
    0.06958736f, 0.05974147f, -0.25175971f, -0.01396650f, -0.39555231f, -0.19872166f, -0.24504019f, 0.07977029f, 
    -0.01238842f, -0.10730883f, -0.09355973f, 0.03005605f, 0.01575756f, -0.10361312f, -0.04450098f, -0.03557361f, 
    -0.18442532f, -0.13310328f, -0.20607786f, 0.10912639f, 0.02052261f, 0.08617223f, 0.01893318f, 0.10545235f, 
    0.12245103f, 0.02299905f, 0.12111069f, -0.07313921f, -0.07472227f, 0.11656797f, 0.04297071f, 0.04626190f, 
    0.08834061f, 0.07196546f, 0.03618005f, 0.04072635f, -0.04605352f, 0.10489446f, 0.11511243f, 0.02227362f, 
    -0.12869969f, -0.20156723f, -0.04055050f, -0.03037289f, 0.04632723f, 0.20166846f, -0.06167170f, 0.09650226f, 
    -0.01066088f, -0.06250239f, -0.13012761f, 0.25554591f, 0.01709169f, 0.17360696f, -0.33669072f, 0.04869822f, 
    0.15263756f, 0.05207333f, -0.11375379f, 0.06801060f, -0.03894434f, 0.10870322f, 0.09042069f, 0.00390939f, 
    -0.27566534f, -0.27535850f, 0.13975053f, 0.17948452f, -0.02804555f, 0.33877870f, 0.00384016f, 0.03675033f, 
    0.03721456f, -0.15364550f, 0.11064696f, 0.13148865f, 0.23165408f, 0.05546350f, 0.05330231f, -0.06807864f, 
    -0.00827650f, -0.03528972f, -0.03997842f, 0.08524439f, -0.08827827f, 0.04832693f, -0.09383073f, 0.16333480f, 
    -0.07276777f, -0.32497069f, 0.03547162f, -0.02129593f, 0.17760307f, 0.20933840f, 0.05418686f, 0.19501191f, 
    -0.10558986f, -0.04790630f, 0.00224691f, -0.05076506f, 0.19402567f, 0.33028078f, -0.10222556f, 0.01579399f, 
    -0.00040184f, -0.15339868f, 0.13906638f, 0.07689966f, 0.11041120f, 0.09027572f, -0.00166640f, -0.05813116f, 
    0.05269361f, -0.02713331f, -0.14664628f, 0.00530432f, -0.04123319f, 0.01043616f, 0.12958178f, 0.04088468f, 
    0.02079510f, 0.08854831f, 0.03142248f, 0.23618184f, -0.01085492f, -0.01689137f, -0.05081419f, -0.03861784f, 
    -0.01084361f, 0.04579514f, 0.00568892f, -0.10758854f, 0.25547564f, 0.10962056f, 0.07824834f, 0.21355209f, 
    -0.09690531f, -0.02857593f, 0.31827569f, -0.19695075f, -0.03951178f, -0.11108169f, 0.08184280f, -0.03748848f, 
    -0.02817027f, -0.10319848f, 0.00218687f, 0.03755209f, -0.09789674f, 0.00391386f, -0.01463178f, -0.00317450f, 
    -0.18312533f, 0.00947207f, 0.00658040f, 0.00025505f, -0.01284289f, -0.03831986f, -0.05701416f, -0.08265657f, 
    -0.17499791f, -0.09912728f, 0.09608617f, 0.04314678f, 0.02785811f, -0.13406664f, -0.00932807f, -0.07824512f, 
    0.04757413f, 0.02462063f, 0.11372555f, 0.05278215f, -0.19384529f, -0.19455977f, -0.07146493f, -0.14486058f, 
    0.08436440f, 0.13286556f, 0.03381047f, 0.07027659f, -0.02510187f, -0.03876222f, -0.05285242f, 0.00026230f, 
    0.09368989f, 0.05116245f, 0.02951130f, 0.01905164f, -0.05208028f, 0.18394855f, 0.08263993f, -0.08886667f, 
    0.02714945f, -0.08745062f, -0.01889285f, 0.10807869f, -0.20877005f, -0.16577086f, -0.13997146f, -0.15133359f, 
    -0.09803089f, 0.16489138f, -0.24899873f, -0.02236423f, -0.16567178f, -0.04716317f, -0.00435450f, -0.02230400f, 
    -0.36036587f, -0.09231681f, 0.02950373f, 0.10903826f, 0.03399777f, -0.14753743f, -0.29040682f, 0.07119886f, 
    -0.01928392f, 0.12649879f, -0.07973094f, 0.06865332f, 0.02997491f, 0.18306302f, 0.44731808f, 0.25735548f, 
    -0.09950809f, 0.02757094f, -0.25228947f, -0.08035795f, -0.01710670f, -0.02194786f, -0.05844794f, 0.11635223f, 
    -0.12974496f, -0.07279988f, -0.03526775f, -0.27830282f, 0.01976775f, -0.02946197f, 0.15316272f, 0.03862524f, 
    0.18770713f, 0.07888682f, 0.06526697f, 0.02025549f, -0.18688129f, -0.25086790f, 0.21251413f, 0.39940205f, 
    0.07221226f, 0.14446038f, -0.05637510f, 0.00773052f, -0.04360235f, -0.09906939f, 0.04261595f, -0.10350695f, 
    0.01275451f, -0.28425673f, 0.11528606f, 0.06393813f, 0.03627039f, 0.05348513f, -0.05202788f, 0.20153891f, 
    0.09675556f, 0.08626775f, 0.04057384f, 0.06021344f, -0.06884263f, 0.00058261f, -0.17785124f, 0.13780193f, 
    -0.00407277f, 0.15769741f, -0.08911945f, -0.06839285f, 0.09815924f, 0.17223455f, 0.13438666f, 0.20852074f, 
    0.05162118f, 0.20023507f, -0.02401597f, 0.21113469f, -0.03797984f, 0.10465820f, 0.05025528f, 0.10251278f, 
    0.01604141f, 0.07716006f, 0.06390332f, -0.00192855f, 0.29610530f, 0.16382416f, 0.21505941f, 0.17632127f, 
    0.07007650f, -0.00599199f, -0.03575788f, 0.09809754f, 0.12772791f, -0.02808236f, -0.04574157f, -0.03689985f, 
    0.09171586f, -0.07000496f, 0.17543255f, -0.14684825f, 0.07083537f, 0.04825069f, -0.04788604f, 0.04079329f, 
    -0.13372979f, -0.02190908f, -0.11291605f, -0.24573486f, -0.16498341f, -0.13710988f, -0.07666881f, -0.08890607f, 
    0.03079507f, -0.04735234f, -0.04974801f, 0.04775731f, -0.08962021f, -0.13873357f, -0.01685758f, 0.07366855f, 
    0.05503459f, -0.04037268f, -0.01827300f, 0.20489044f, 0.02202167f, -0.01611839f, -0.09717073f, -0.04051312f, 
    -0.07062521f, 0.02290762f, -0.04040381f, 0.12326330f, 0.06315181f, 0.03290599f, 0.05451628f, 0.02411038f, 
    0.18728420f, 0.17162532f, 0.09940842f, 0.14743292f, 0.13081922f, -0.05896595f, 0.03353819f, -0.17735653f, 
    0.21507500f, 0.10431618f, 0.14451776f, -0.04330914f, 0.12834102f, -0.04395834f, -0.01515241f, -0.14259817f, 
    0.01131178f, -0.02960210f, 0.02838434f, 0.04744734f, 0.00652642f, -0.01985196f, 0.04205611f, -0.06816915f, 
    0.01971733f, 0.03172201f, 0.06096150f, 0.03355866f, 0.01175213f, 0.04128349f, 0.14038195f, -0.00979195f, 
    -0.15410212f, 0.19840419f, 0.04879914f, 0.06810597f, 0.01920014f, 0.06041354f, -0.07863931f, 0.10223866f, 
    0.01862716f, -0.03655365f, 0.19375767f, 0.27637029f, 0.21849881f, 0.38935462f, -0.09911770f, -0.02699997f, 
    0.08478781f, 0.19888750f, 0.14650060f, 0.09118732f, -0.00078321f, 0.05879981f, 0.21393934f, 0.00721196f, 
    0.02631221f, 0.21421732f, 0.01345098f, 0.00395691f, 0.19811818f, 0.08264638f, 0.03100911f, 0.07823325f, 
    -0.03017143f, -0.06001921f, 0.00413157f, 0.15018582f, -0.22768751f, -0.28291300f, -0.22616279f, 0.01357329f, 
    0.02988914f, 0.00678961f, 0.03207897f, -0.01088433f, 0.01966730f, -0.03091071f, 0.06723869f, -0.06859842f, 
    -0.04428506f, -0.11633376f, 0.26401579f, 0.09004728f, 0.09607331f, 0.00209313f, 0.05787252f, 0.18474063f, 
    -0.13300174f, 0.00738795f, -0.00946254f, -0.01501101f, -0.17255217f, 0.62728167f, 0.01573753f, 0.15686300f, 
    -0.21331577f, -0.05079215f, 0.02135083f, -0.04225610f, -0.15416060f, -0.01312927f, -0.08789557f, 0.07189352f, 
    -0.24362567f, -0.13646352f, 0.15675066f, 0.10053300f, 0.11507228f, 0.15584309f, -0.15043688f, -0.01027787f, 
    0.00783814f, -0.11541596f, -0.06925176f, 0.08935235f, 0.00847819f, 0.12316815f, -0.10918834f, 0.07697309f, 
    -0.07942335f, -0.26526988f, -0.05850361f, -0.10858902f, -0.00972094f, 0.07106981f, -0.04735853f, 0.02736254f, 
    0.03691440f, -0.37266737f, -0.10666433f, 0.04787764f, 0.05314380f, 0.24621618f, -0.13441376f, 0.06514375f, 
    -0.02894959f, 0.07715982f, -0.17627883f, -0.10152457f, 0.43409079f, -0.09104820f, -0.15915261f, 0.04986813f, 
    -0.17146055f, -0.10361774f, 0.05635855f, -0.02895574f, 0.14988145f, -0.09923949f, -0.09149966f, -0.03124655f, 
    -0.11822309f, -0.11281349f, 0.04324457f, -0.05972353f, -0.05986260f, 0.10831347f, 0.07050776f, 0.23512603f, 
    0.08524188f, 0.09217647f, 0.26100016f, 0.07230669f, -0.01158664f, 0.00216110f, -0.09776303f, 0.01588773f, 
    -0.00044951f, 0.12870143f, 0.09496205f, 0.05660899f, 0.09349937f, 0.04372356f, 0.11790480f, 0.14793469f, 
    -0.15690623f, 0.07066976f, -0.12031302f, -0.03857235f, 0.08964645f, -0.02908834f, -0.05477884f, 0.07270510f, 
    0.06492858f, 0.00674255f, 0.06932367f, 0.02411517f, 0.12002988f, 0.00703632f, -0.15445183f, -0.24282014f, 
    0.11510751f, 0.05326051f, 0.06327542f, -0.13304402f, 0.02942955f, -0.02576192f, -0.09423699f, 0.02120005f, 
    0.00069739f, 0.02352820f, 0.11351436f, -0.16255136f, 0.00200738f, -0.03235565f, 0.09320624f, 0.24615873f, 
    -0.01015151f, -0.04472870f, 0.15395992f, 0.05741404f, -0.00418019f, -0.21583216f, -0.04558440f, 0.14880602f, 
    0.09875323f, 0.06535060f, 0.08345005f, 0.06200127f, -0.06724127f, -0.06209166f, -0.04474504f, -0.02083775f, 
    -0.05309050f, -0.11115529f, -0.08089513f, 0.17024894f, -0.05112405f, 0.06615833f, 0.06914270f, -0.02110964f, 
    0.00143899f, 0.08352362f, -0.00818129f, 0.05894156f, 0.07199354f, 0.16850260f, -0.00358077f, -0.25219434f, 
    0.16046464f, 0.02400976f, 0.07922954f, -0.05468740f, 0.07459901f, -0.05487251f, -0.07157522f, -0.04481047f, 
    0.06108936f, 0.18191688f, 0.12465353f, -0.14774263f, 0.06350333f, -0.00770665f, 0.06910772f, 0.05671963f, 
    -0.04146584f, -0.06000288f, -0.06550096f, -0.00302564f, -0.30351388f, 0.19519049f, 0.13560738f, -0.04855195f, 
    0.11487205f, -0.04732502f, -0.16306250f, -0.06466972f, -0.09556974f, 0.08818635f, 0.08431318f, 0.06755479f, 
    0.27787098f, -0.03582463f, -0.13203032f, -0.16524631f, 0.06278113f, 0.01617246f, 0.12175613f, 0.06514552f, 
    0.07072083f, 0.02599682f, 0.01538344f, -0.05610546f, 0.00044621f, 0.14303534f, 0.12458356f, 0.17131503f, 
    -0.01672675f, 0.00958144f, -0.01110370f, -0.02250003f, 0.00395660f, -0.03976995f, 0.15189989f, -0.08422214f, 
    -0.12663329f, -0.16255271f, 0.04411729f, 0.13897400f, 0.10182427f, 0.13205399f, -0.21278617f, -0.04244461f, 
    0.04099570f, 0.04653836f, -0.05133362f, 0.21919586f, 0.05176961f, -0.02578190f, 0.02417746f, 0.01848151f, 
    0.05549303f, 0.01303634f, -0.11629381f, -0.02161978f, -0.11191723f, -0.07650115f, -0.09371593f, -0.16265155f, 
    0.22623587f, -0.05645722f, 0.02140732f, 0.12111090f, 0.24328916f, 0.13866739f, 0.11232809f, -0.07525861f, 
    -0.01270981f, 0.02932598f, -0.14928983f, 0.01493545f, -0.28744212f, -0.25974196f, -0.26120591f, -0.19359955f, 
    0.00269636f, -0.02124650f, 0.04788432f, 0.18642150f, 0.04457502f, -0.11759651f, 0.09407104f, 0.02208869f, 
    0.10847939f, 0.05901848f, 0.17101832f, 0.00070154f, -0.20449165f, 0.18453665f, 0.22498003f, 0.20847726f, 
    -0.08951771f, 0.03304562f, 0.16947079f, 0.08635749f, -0.12184663f, -0.12700367f, 0.11242685f, 0.12721166f, 
    -0.09907935f, 0.01494703f, -0.02885212f, -0.03768044f, 0.34913719f, 0.22694077f, 0.27343050f, 0.30428377f, 
    0.45332807f, 0.13025470f, 0.10771913f, 0.23237942f, -0.06635805f, -0.06311403f, -0.03256057f, 0.03205676f, 
    -0.12449808f, 0.16970642f, 0.03763499f, -0.10617644f, -0.32060230f, -0.59696853f, -0.62613273f, -0.34988454f, 
    -0.10401822f, 0.18163098f, 0.20949818f, 0.19014470f, 0.03952033f, 0.00871660f, 0.02933082f, 0.11921536f, 
    -0.64450645f, -0.43693465f, -0.17009626f, -0.26651755f, -0.00004814f, 0.02009193f, -0.13461539f, -0.14813933f, 
    -0.14423673f, -0.06901504f, 0.10244566f, -0.03376651f, 0.14344972f, 0.03970435f, 0.10773771f, 0.19949935f, 
    0.02703894f, 0.07753570f, 0.05612993f, 0.04827749f, -0.09998759f, -0.03377756f, 0.01812818f, 0.04176437f, 
    0.13482152f, 0.21648163f, 0.04186499f, 0.20274602f, 0.04304116f, 0.11353220f, 0.00499212f, 0.04063944f, 
    0.06024081f, -0.05116904f, 0.08593756f, -0.03394353f, -0.33676723f, 0.06784904f, -0.12488560f, -0.12891036f, 
    -0.11325635f, 0.12078770f, -0.16310374f, -0.09832597f, -0.09908149f, -0.13054682f, -0.10528834f, -0.07572088f, 
    -0.45029828f, 0.25269607f, -0.03901842f, -0.29972762f, 0.07739704f, -0.13261516f, 0.14588675f, 0.02963836f, 
    0.00012456f, -0.10426001f, -0.02720626f, -0.07913169f, -0.01786343f, 0.13034131f, 0.00289883f, 0.00974231f, 
    -0.04684781f, -0.05067693f, -0.00058702f, 0.01211510f, 0.07625999f, 0.12420359f, -0.04290331f, 0.12576889f, 
    0.46222010f, 0.07651325f, 0.12308458f, -0.08180600f, -0.20128903f, -0.02219142f, 0.26441023f, 0.21975280f, 
    0.06559100f, -0.05225371f, -0.01701077f, 0.10329635f, -0.05944853f, 0.00188237f, 0.24932908f, 0.36407277f, 
    -0.03297302f, 0.03535417f, -0.14069779f, -0.06360946f, -0.19071060f, 0.03766187f, -0.02450734f, 0.16675772f, 
    0.03040634f, -0.05266307f, -0.00882475f, -0.08303165f, -0.01639349f, -0.05470546f, -0.01396230f, -0.00623726f, 
    -0.05068403f, 0.01674410f, 0.04017058f, -0.03933422f, -0.03145930f, 0.01905248f, 0.06060611f, -0.03526521f, 
    -0.03766358f, -0.02091581f, 0.02668296f, -0.08171602f, -0.03825619f, -0.01083295f, 0.04006051f, -0.04929910f, 
    -0.07899175f, 0.02784288f, 0.00765623f, -0.02645410f, 0.04441116f, -0.01613341f, -0.05562481f, -0.06716280f, 
    -0.06674143f, -0.02253984f, -0.01892957f, -0.03892378f, -0.05782075f, 0.03072805f, 0.04695326f, 0.06188376f, 
    -0.01724877f, 0.03994071f, -0.03927822f, -0.04935218f, -0.05214850f, -0.03148376f, 0.06479509f, 0.02085579f, 
    -0.02826617f, -0.02044945f, -0.00475313f, -0.05211831f, -0.03351877f, -0.03207881f, -0.00347010f, 0.03837894f, 
    -0.03018036f, 0.01916890f, 0.02375616f, -0.03962624f, -0.02255919f, 0.02684567f, -0.04327340f, -0.04718424f, 
    -0.00908557f, -0.05891116f, 0.00727815f, 0.03319549f, -0.06443232f, -0.00953901f, -0.08262883f, -0.05949194f, 
    -0.05941959f, 0.00034668f, 0.01633732f, -0.06237331f, 0.03182955f, 0.01942084f, -0.06860992f, 0.02651510f, 
    -0.03738552f, -0.00129038f, -0.07562981f, -0.05303403f, 0.02756654f, -0.06532975f, -0.06938476f, -0.00392636f, 
    -0.02670833f, 0.03658157f, -0.02566731f, 0.01806210f, 0.05718927f, -0.07161596f, -0.02959302f, -0.00638638f, 
    0.05375290f, -0.04814282f, -0.05758597f, -0.02279906f, 0.03664500f, -0.01199497f, 0.02634055f, -0.07312275f, 
    -0.07662180f, -0.03209699f, 0.00078317f, 0.03002280f, -0.01469439f, -0.01771849f, -0.06949317f, 0.00975992f, 
    -0.06855240f, 0.04648015f, 0.02726311f, -0.05082629f, -0.02669004f, -0.01808714f, -0.00298792f, -0.01452549f, 
    -0.05320926f, 0.05121563f, -0.01108799f, 0.04385427f, 0.01119057f, -0.04955987f, -0.03124607f, -0.01212209f, 
    0.01297539f, -0.02006890f, 0.00361536f, -0.05401594f, -0.04459710f, 0.00908844f, -0.00116987f, -0.05177281f, 
    0.00197678f, 0.03894136f, -0.05993812f, -0.03290606f, 0.01231826f, -0.04875549f, -0.02501619f, -0.04002668f, 
    0.02630613f, -0.01121964f, -0.03347349f, -0.03331122f, -0.07713053f, -0.07224727f, -0.01770363f, -0.04906155f, 
    -0.01526800f, -0.06335878f, -0.06259931f, 0.04739664f, 0.00039526f, -0.08320332f, -0.03480930f, -0.05292103f, 
    -0.03472419f, 0.01312294f, -0.02622017f, -0.00075081f, 0.05603322f, 0.01468017f, -0.03847724f, -0.00720913f, 
    0.04922925f, -0.06314488f, 0.00889812f, -0.02841875f, 0.03062837f, 0.03987036f, 0.01086916f, -0.03270921f, 
    -0.00459207f, -0.06226822f, -0.07019801f, 0.01123785f, 0.00724101f, -0.07603606f, 0.03285957f, -0.05501305f, 
    0.02557710f, 0.04407142f, 0.00858108f, -0.07311516f, 0.03051170f, -0.05053595f, -0.01274631f, -0.02580590f, 
    0.15906155f, 0.08667057f, 0.08737059f, 0.05492704f, 0.03250851f, 0.22427227f, -0.07393187f, 0.08500022f, 
    0.06924600f, 0.12132454f, 0.06283228f, 0.12287026f, -0.24328598f, 0.04826494f, -0.13761359f, -0.03306486f, 
    -0.00858584f, 0.05820778f, -0.01195163f, -0.05125283f, 0.14272393f, 0.23950735f, -0.02870763f, 0.23358144f, 
    -0.03779659f, -0.05945542f, -0.16924599f, -0.26152587f, 0.13035637f, 0.12940535f, -0.12470198f, 0.18951058f, 
    -0.11623096f, 0.07421531f, -0.08503447f, -0.08975678f, -0.11127274f, -0.10247766f, 0.03881077f, 0.00510429f, 
    0.07346182f, -0.05001950f, 0.08456630f, -0.02468513f, 0.00680289f, 0.13136086f, -0.11867528f, -0.00682660f, 
    -0.17914295f, -0.12992513f, 0.24146959f, -0.06309310f, -0.00158659f, 0.01826525f, 0.03120388f, 0.17656577f, 
    -0.22735047f, -0.07317837f, -0.03926451f, -0.30726847f, -0.09600233f, -0.13032438f, -0.08487619f, 0.09693974f, 
    0.00068245f, 0.03762674f, -0.06527890f, -0.16156054f, -0.25074425f, -0.27532172f, -0.06129404f, 0.00689859f, 
    -0.13462967f, 0.02159319f, -0.08414009f, 0.17227899f, -0.19996157f, -0.05663919f, -0.09220625f, -0.14949001f, 
    0.00166702f, 0.11025798f, -0.02437450f, 0.12910813f, 0.15533233f, -0.01299994f, -0.09522489f, -0.34144148f, 
    0.20535013f, 0.06237371f, -0.04994906f, 0.05701585f, 0.01240710f, -0.09907736f, -0.14072733f, -0.16426075f, 
    0.04362598f, 0.22080991f, 0.08371095f, -0.07707256f, 0.04862677f, 0.14623305f, 0.06337304f, 0.09700100f, 
    0.02037424f, -0.13453086f, 0.05876050f, -0.08047013f, 0.16788003f, 0.09945603f, 0.13726552f, 0.12401109f, 
    0.03783142f, -0.11207212f, -0.00332656f, -0.03237670f, -0.01162985f, -0.03108506f, -0.00730961f, -0.04188891f, 
    0.06549277f, 0.14698772f, 0.14899667f, 0.28948411f, -0.04502743f, -0.04362022f, -0.14703330f, 0.18002944f, 
    0.05356494f, 0.09886353f, 0.23285678f, 0.11612215f, 0.14177294f, 0.12085552f, 0.13903117f, -0.26836380f, 
    0.10549469f, 0.11302318f, 0.17910956f, 0.13388073f, 0.20512934f, 0.08045462f, 0.14905159f, 0.02805267f, 
    0.17382246f, 0.08329518f, -0.03314852f, -0.13318793f, 0.16905183f, -0.11559536f, 0.06377063f, -0.02603417f, 
    -0.00338951f, -0.00143870f, 0.01056948f, -0.06972695f, -0.14979725f, -0.20487563f, -0.32110193f, -0.12492355f, 
    0.10683323f, -0.00725799f, -0.06289200f, 0.00449988f, 0.14063217f, 0.00687756f, 0.10866542f, 0.00002026f, 
    0.06833080f, -0.14254510f, -0.11494862f, -0.14450389f, -0.06932379f, -0.08317020f, -0.03169364f, -0.05085701f, 
    -0.11099666f, 0.05265851f, -0.14088394f, -0.09045734f, 0.18132010f, 0.17654809f, 0.07294672f, -0.03431436f, 
    -0.18720829f, 0.01043166f, 0.08013008f, -0.10597514f, 0.03749824f, -0.00664621f, 0.06863380f, 0.00963430f, 
    -0.10255296f, 0.11925571f, -0.18177199f, -0.01023513f, 0.14264138f, 0.15042526f, -0.17664666f, 0.09795468f, 
    0.26839826f, 0.04260384f, -0.02886512f, 0.03420455f, 0.02422319f, -0.17767885f, 0.14182763f, -0.06884061f, 
    -0.12723942f, -0.01710025f, 0.09749310f, -0.03930139f, 0.16967677f, 0.01976438f, 0.02910283f, 0.11889822f, 
    -0.10164010f, 0.20071915f, -0.08955897f, -0.11267030f, 0.00747595f, -0.04437211f, 0.07999754f, -0.14943901f, 
    -0.00291029f, -0.05108261f, -0.02153271f, 0.02175311f, 0.15280077f, -0.05487017f, -0.02341967f, 0.22777064f, 
    0.20984825f, 0.21856907f, 0.04944007f, 0.09420995f, 0.06916703f, -0.02788246f, 0.15102857f, 0.01144539f, 
    -0.02622646f, -0.14536306f, 0.12502250f, 0.04572045f, -0.02992980f, 0.08613075f, 0.09613115f, 0.02710480f, 
    -0.03953290f, 0.09058739f, 0.06776860f, -0.16315870f, -0.02825778f, 0.05099368f, 0.06359853f, 0.03654633f, 
    -0.09846954f, -0.05514199f, -0.11020840f, -0.08610144f, -0.03949628f, -0.04776720f, -0.00555289f, 0.04384873f, 
    0.30975467f, 0.15282856f, 0.37619594f, 0.03105804f, -0.11636060f, -0.12246349f, 0.05221540f, -0.13045175f, 
    -0.21172802f, 0.07571016f, 0.06478097f, 0.07318413f, 0.24160053f, -0.03246301f, 0.05188650f, -0.02478259f, 
    0.10425793f, 0.01842927f, 0.13976337f, 0.12747721f, -0.04747727f, -0.04950868f, 0.07866345f, -0.05611183f, 
    0.13320442f, 0.08456516f, -0.05940259f, -0.04892376f, 0.06537209f, -0.03319782f, 0.01390719f, -0.15165016f, 
    0.06012395f, -0.01922249f, -0.02291520f, 0.05884046f, -0.02737829f, 0.13066821f, -0.02279791f, -0.01674690f, 
    -0.10532649f, -0.15482649f, -0.08822856f, -0.06724404f, -0.08970236f, -0.01249400f, -0.12301551f, -0.05109147f, 
    0.24627519f, -0.31796283f, 0.17716362f, 0.08819545f, -0.03934146f, 0.08100849f, -0.22081275f, -0.04031488f, 
    0.11569295f, 0.02422338f, -0.07644136f, 0.00239457f, -0.13516875f, -0.06323095f, -0.10265874f, -0.28957874f, 
    -0.00488039f, -0.13215074f, 0.07603814f, 0.05753686f, 0.09517446f, -0.17015819f, 0.17762415f, 0.12647821f, 
    0.00700629f, -0.15845408f, -0.24916658f, -0.03855993f, 0.15451264f, -0.06821303f, 0.14499047f, 0.03193167f, 
    0.02978040f, -0.03038943f, 0.00347807f, -0.06715971f, 0.12901731f, -0.10569476f, 0.17886670f, 0.01805789f, 
    -0.02129472f, 0.04806199f, 0.03246670f, 0.00765438f, 0.05601988f, -0.01225257f, 0.22053610f, 0.08456012f, 
    -0.00940021f, -0.10024066f, -0.08167499f, -0.15571128f, -0.11641660f, 0.08123498f, -0.04268699f, 0.17656903f, 
    0.13396613f, 0.05664638f, -0.11793289f, 0.20521359f, 0.40753639f, 0.15894687f, 0.06945696f, -0.12283039f, 
    -0.12879099f, -0.00089393f, 0.00055080f, 0.04216445f, 0.10999099f, 0.01654212f, 0.00017601f, 0.01982659f, 
    -0.00522029f, -0.16507113f, 0.01825631f, 0.02452963f, 0.06171277f, -0.10140977f, -0.08147940f, 0.09818178f, 
    0.09290878f, 0.14129470f, -0.01157191f, 0.08143596f, -0.03419375f, -0.10042747f, -0.08322286f, -0.00234156f, 
    0.03891208f, 0.12703867f, -0.08969892f, -0.10366171f, -0.08478395f, -0.08665269f, -0.11822101f, -0.12459508f, 
    0.22417386f, 0.07623691f, 0.14238773f, 0.14354530f, 0.37564251f, 0.17752911f, 0.06592316f, 0.00323325f, 
    -0.01386947f, -0.03609130f, -0.12843832f, -0.10780238f, -0.34740141f, -0.24692492f, -0.28616294f, -0.21925335f, 
    0.06231754f, -0.01961144f, 0.19700821f, 0.13055399f, 0.03970695f, -0.10287958f, 0.10146753f, 0.05179961f, 
    0.24470912f, 0.19993296f, 0.20018889f, 0.10364792f, -0.08257215f, 0.06289764f, 0.11437595f, 0.17063147f, 
    0.03278834f, -0.02174775f, 0.06242450f, -0.00585660f, -0.06518425f, 0.02261512f, 0.05131815f, 0.14838479f, 
    -0.05155881f, -0.04338335f, -0.03118118f, -0.09220809f, 0.27649060f, 0.02156260f, 0.11990052f, 0.20282029f, 
    0.35565168f, 0.28886783f, 0.21699840f, 0.46227691f, -0.05322704f, -0.11682928f, -0.05048228f, -0.08847972f, 
    -0.13791154f, -0.03504065f, -0.03779582f, -0.03357129f, -0.52012455f, -0.64591998f, -0.60867715f, -0.51042801f, 
    -0.00521532f, 0.11441243f, 0.09505319f, 0.16781007f, 0.09320803f, 0.05896399f, -0.00542395f, 0.15315785f, 
    -0.51316684f, -0.47099438f, -0.33624581f, -0.49312621f, 0.02636811f, 0.05843654f, -0.12744068f, -0.13655190f, 
    -0.10436118f, -0.03326081f, 0.12515074f, 0.15530276f, 0.19235964f, 0.15798335f, 0.18639794f, 0.22291401f, 
    0.12516204f, 0.02507691f, -0.01995151f, 0.03606639f, -0.10046516f, -0.01967246f, -0.03310204f, -0.01459507f, 
    0.17019305f, 0.26697609f, 0.21334426f, 0.18953621f, -0.06070081f, 0.08117177f, 0.02153849f, -0.09728473f, 
    -0.01666426f, -0.02526062f, 0.02469938f, -0.06591211f, -0.12181675f, 0.15802242f, -0.23662315f, -0.26137432f, 
    0.01590011f, 0.13777456f, 0.03915413f, 0.03270825f, -0.00287860f, -0.10228989f, -0.00978990f, -0.14871964f, 
    -0.17427219f, 0.00424128f, -0.18166471f, -0.19566819f, -0.00394797f, -0.06736775f, 0.08828608f, -0.10143723f, 
    -0.08328222f, 0.03905508f, 0.20080048f, -0.03056327f, 0.12865359f, -0.14044929f, -0.21342926f, -0.10204618f, 
    -0.25130251f, -0.01820246f, -0.05860193f, -0.03966108f, 0.25534707f, 0.05701559f, -0.05297430f, 0.23982303f, 
    0.21291970f, 0.00249721f, 0.01273103f, 0.15705150f, -0.05656055f, 0.01288013f, 0.17321384f, 0.27302939f, 
    0.00165572f, 0.07436325f, 0.02530278f, 0.03487112f, 0.20443845f, 0.18331364f, 0.34260517f, 0.07798057f, 
    -0.08905111f, 0.10448983f, -0.05256935f, -0.18594332f, -0.13183628f, 0.04155091f, 0.01377444f, 0.03762177f, 
    0.03255116f, -0.07760879f, 0.00193883f, 0.02624736f, -0.06450208f, -0.04880865f, 0.04412274f, -0.01260168f, 
    0.03088868f, -0.07153001f, -0.01197419f, 0.03300953f, 0.03304245f, -0.07053509f, 0.05835224f, -0.02325098f, 
    -0.07465190f, -0.06442870f, -0.05775839f, -0.00796070f, 0.04102360f, -0.01586405f, -0.03668196f, -0.03926722f, 
    0.04762701f, -0.04861944f, 0.05124152f, -0.02723866f, 0.02791748f, -0.07724936f, -0.05176231f, -0.05531375f, 
    -0.00032996f, -0.04038847f, -0.07237288f, 0.00637785f, 0.03012669f, -0.06361204f, 0.04550296f, 0.02429525f, 
    -0.08553465f, 0.00927226f, 0.02024017f, -0.00754686f, 0.02213436f, -0.04127661f, -0.00211120f, -0.02125226f, 
    0.05217130f, 0.06053814f, 0.05557084f, -0.04234442f, 0.04161065f, -0.03962583f, 0.00927863f, 0.03550230f, 
    0.02557594f, -0.06608201f, 0.03780735f, -0.07974005f, 0.03328017f, -0.00163267f, 0.02830581f, -0.06829718f, 
    0.02144319f, 0.03198946f, 0.03752610f, -0.07715257f, -0.04443266f, 0.00010708f, -0.00444184f, -0.04189986f, 
    -0.08441475f, 0.04483958f, -0.01038298f, -0.01758332f, -0.00006313f, 0.02899096f, -0.00157901f, -0.05443661f, 
    0.06065075f, 0.02796680f, -0.04723990f, -0.06874012f, -0.01064450f, -0.02011159f, -0.05877715f, 0.00632669f, 
    0.01360966f, -0.06308032f, -0.07094943f, -0.07516546f, 0.04357410f, 0.03542815f, -0.00799685f, 0.07068842f, 
    -0.07564664f, -0.02493153f, 0.00952282f, 0.04637885f, -0.03787673f, 0.00986911f, -0.07141703f, -0.03535200f, 
    -0.06139839f, -0.00000550f, -0.01194727f, -0.02142912f, 0.00936176f, -0.00115425f, -0.02636401f, 0.03950507f, 
    -0.04600369f, -0.05182979f, 0.04706334f, 0.05893748f, 0.05617442f, -0.05444114f, -0.04050511f, 0.00867922f, 
    -0.00374488f, 0.03199920f, -0.00666771f, 0.05019951f, 0.03582396f, -0.00216699f, -0.05884809f, 0.05854933f, 
    -0.08073976f, -0.00880065f, -0.01122373f, -0.02488354f, -0.04675101f, 0.02615308f, 0.01762820f, -0.00619052f, 
    -0.02119805f, 0.00472932f, -0.04822296f, 0.01459735f, -0.04989881f, -0.01977037f, 0.00770776f, -0.01631422f, 
    0.01997064f, -0.04460508f, -0.00411613f, -0.04523037f, -0.03254531f, -0.00950284f, 0.03807985f, -0.01185634f, 
    0.05463996f, -0.00976501f, -0.01416983f, -0.03467523f, -0.00790841f, -0.04439544f, 0.05942018f, -0.00945140f, 
    0.03004237f, 0.03768056f, -0.06028478f, 0.01669618f, -0.03433648f, 0.05124418f, -0.00362757f, 0.04131910f, 
    -0.02323213f, -0.00665144f, -0.00855436f, -0.04050524f, -0.05642113f, 0.02245149f, -0.06898718f, -0.04513234f, 
    -0.01891180f, -0.07739567f, -0.07155861f, 0.04156322f, -0.01292700f, 0.00031645f, -0.06052127f, 0.01365218f, 
    0.03986626f, -0.04468156f, 0.06445900f, 0.03394290f, 0.02513467f, -0.04851411f, -0.00186136f, -0.03753514f, 
    -0.23000467f, 0.00442380f, 0.13991615f, -0.22076413f, 0.04253603f, 0.03407042f, -0.04603397f, 0.26000315f, 
    -0.20024373f, -0.09504794f, -0.04414390f, 0.13206212f, -0.25373611f, -0.04935172f, 0.07807104f, -0.05900952f, 
    -0.14951088f, -0.08399992f, 0.05402539f, -0.11007757f, -0.22243111f, -0.29237550f, -0.26723200f, -0.20105059f, 
    0.24911700f, 0.44794837f, 0.03438224f, 0.26626858f, 0.05868566f, 0.02349408f, 0.26305133f, 0.15288472f, 
    -0.07848098f, -0.08679745f, -0.17564863f, 0.03840381f, 0.30323637f, 0.02041202f, -0.15583740f, 0.25414112f, 
    -0.14883503f, -0.02317738f, 0.18292843f, -0.07516801f, 0.03374921f, -0.08411045f, 0.08527843f, 0.21753003f, 
    0.23781508f, 0.03350427f, 0.10307080f, 0.20449458f, -0.03092265f, 0.06144384f, 0.17206466f, -0.05676913f, 
    0.05725739f, 0.18284921f, 0.11252493f, 0.14068162f, -0.10041220f, -0.01932363f, 0.12144276f, -0.00758768f, 
    -0.06499343f, -0.07273369f, -0.08023333f, -0.15482929f, 0.14389995f, 0.08014146f, 0.02948139f, 0.11626821f, 
    0.14809853f, 0.11788639f, 0.09221794f, 0.01395294f, -0.10085913f, -0.03952612f, -0.06010964f, 0.02030752f, 
    0.01322284f, 0.17657730f, 0.08680941f, 0.03876798f, 0.01458895f, -0.18323757f, -0.04101165f, 0.19191095f, 
    0.02744293f, -0.10036611f, 0.10923684f, -0.00322285f, 0.00492947f, 0.17562278f, -0.01662415f, 0.09030152f, 
    0.13736317f, -0.27412170f, 0.00943040f, -0.04414979f, 0.04417993f, -0.09684787f, -0.02857602f, 0.08110510f, 
    0.01888688f, 0.08047967f, 0.02291322f, -0.03814429f, 0.28216147f, 0.14711848f, -0.09911703f, -0.29329535f, 
    0.00470949f, -0.14806759f, -0.05863170f, 0.19411290f, -0.06047532f, -0.10687837f, -0.09873275f, -0.09988336f, 
    0.13157552f, -0.01916518f, -0.05403101f, 0.11468103f, -0.10909374f, 0.03971642f, -0.03551580f, -0.24395022f, 
    -0.01281779f, -0.05324171f, -0.15545534f, -0.10329151f, -0.12236860f, -0.06058282f, -0.16162397f, 0.21694982f, 
    -0.06835643f, -0.09666748f, -0.03580516f, 0.05543267f, -0.05311599f, -0.06273558f, -0.00552019f, -0.04854512f, 
    0.11989854f, -0.21986334f, -0.31575018f, 0.17095579f, 0.09292360f, 0.06900816f, 0.00893356f, 0.22512504f, 
    0.08202222f, 0.09245331f, 0.12787594f, -0.00153706f, 0.14815731f, -0.13457733f, -0.21867889f, -0.03030136f, 
    -0.01015607f, -0.02099098f, -0.18015496f, -0.06416653f, 0.02907849f, -0.04755567f, 0.03942318f, 0.06030591f, 
    -0.12204015f, 0.00911206f, 0.17410010f, 0.12074274f, 0.00805267f, 0.09054764f, 0.17700648f, 0.26937771f, 
    0.02635385f, 0.10511434f, -0.08391186f, 0.10234831f, -0.10519724f, 0.33460933f, -0.34967089f, -0.03026905f, 
    0.19329160f, -0.13248116f, -0.06650858f, 0.09279787f, -0.04773140f, 0.14011857f, 0.04661381f, 0.01557056f, 
    -0.02417546f, 0.07404770f, 0.21739054f, -0.04518618f, -0.04317255f, 0.07588939f, 0.04706428f, 0.10437598f, 
    -0.08027141f, -0.01821381f, -0.06190539f, -0.18713832f, -0.15564348f, 0.32035264f, -0.14698689f, -0.06327109f, 
    -0.16739199f, 0.00319307f, -0.08691315f, -0.17218220f, -0.20778216f, -0.12952478f, -0.29025236f, -0.22145820f, 
    0.22805756f, 0.22317731f, 0.18210304f, 0.03007736f, -0.07149131f, -0.09420604f, 0.04046955f, 0.25562891f, 
    -0.06774470f, 0.05104323f, -0.06165068f, -0.01154375f, 0.43859497f, 0.01139872f, 0.09212457f, 0.12792352f, 
    0.03806347f, 0.07542317f, 0.06432957f, -0.14880939f, 0.10507517f, -0.08374421f, -0.01601627f, -0.01399655f, 
    0.20759481f, 0.09508181f, 0.18072632f, 0.06114118f, 0.04729901f, -0.01744429f, 0.05847739f, 0.08268255f, 
    0.21410538f, 0.16903473f, -0.03644821f, 0.14715356f, 0.06965510f, -0.14106174f, 0.02204660f, 0.00278928f, 
    0.03501828f, -0.07364602f, -0.11749379f, -0.06558828f, 0.27119935f, 0.19668962f, 0.07705740f, 0.20799425f, 
    -0.07643834f, 0.18717703f, -0.19552496f, 0.10429356f, -0.00464496f, 0.13769272f, -0.07891244f, -0.00466983f, 
    -0.10038026f, 0.00347159f, 0.07971075f, 0.12907708f, -0.02654282f, -0.01417439f, 0.05180631f, 0.04615997f, 
    0.07090995f, 0.01579204f, 0.05669052f, -0.07821795f, 0.05466902f, 0.00061358f, -0.04866764f, -0.01977118f, 
    0.32064041f, -0.13165016f, 0.05882935f, -0.16556272f, 0.11152358f, -0.04909571f, 0.03742035f, 0.17041931f, 
    -0.07820304f, 0.00784985f, 0.05010658f, 0.13545109f, 0.22722667f, 0.19470349f, -0.05279006f, -0.27555296f, 
    0.04307163f, -0.13721834f, -0.22356997f, 0.21861626f, 0.10048842f, -0.05176042f, -0.04537658f, -0.13674685f, 
    -0.03156327f, 0.13952628f, 0.03375761f, -0.08505728f, -0.20133494f, -0.03012767f, -0.14100567f, -0.07086392f, 
    -0.04703515f, -0.00265473f, -0.15727203f, 0.06744769f, -0.14927228f, 0.01617298f, -0.18106024f, 0.18067555f, 
    0.08968361f, -0.06733517f, 0.05795002f, 0.03827376f, -0.03580287f, 0.04635529f, -0.13346270f, -0.10366350f, 
    0.33283827f, -0.04826440f, -0.07808176f, 0.01635793f, 0.12952684f, 0.11096665f, -0.03329280f, 0.01720341f, 
    -0.00895064f, 0.10984252f, 0.04655275f, 0.03529724f, 0.02284646f, -0.08170862f, -0.19321403f, 0.08406710f, 
    0.19608426f, -0.03884288f, -0.02911595f, -0.02503198f, -0.08949123f, 0.07205317f, -0.00732997f, 0.04397156f, 
    -0.21386708f, -0.09094220f, 0.12007676f, 0.19072907f, 0.04022425f, -0.03702325f, -0.00216490f, 0.05009647f, 
    -0.01360699f, 0.23762804f, 0.14887443f, 0.09684000f, -0.14700249f, 0.41626352f, -0.24105847f, 0.09819488f, 
    0.12111253f, -0.17336275f, -0.05508982f, -0.08177008f, -0.02930621f, -0.10140007f, -0.03246907f, -0.01467084f, 
    0.08642195f, 0.11411516f, -0.30281100f, -0.06871192f, 0.12086875f, 0.05940703f, -0.08950092f, 0.00883508f, 
    0.20405032f, 0.23663157f, 0.09866752f, 0.11256942f, -0.08799906f, -0.19728808f, -0.17582734f, -0.17677207f, 
    0.05337477f, 0.10071053f, 0.01024929f, -0.04459345f, 0.13217902f, 0.20449632f, 0.02595932f, 0.12035325f, 
    -0.26256037f, 0.04942124f, -0.18394624f, -0.23727742f, 0.00586785f, 0.13724935f, 0.06491829f, 0.02278461f, 
    -0.07002879f, 0.00038320f, 0.00358755f, -0.12444297f, -0.08720759f, -0.04930125f, 0.10449519f, 0.03036731f, 
    0.21436635f, 0.03654841f, -0.05302042f, 0.11542153f, 0.09325647f, 0.03174635f, 0.01021073f, 0.05576722f, 
    -0.10896346f, -0.22880433f, 0.20549186f, -0.11392955f, 0.03675557f, 0.03419339f, -0.05586146f, 0.09509026f, 
    -0.14953494f, 0.00708613f, -0.01109941f, -0.39697292f, -0.12411673f, -0.04034510f, -0.06840813f, 0.15125439f, 
    0.10462911f, -0.03861425f, -0.09837089f, -0.09751990f, -0.26174152f, -0.16054270f, -0.04090512f, -0.07834277f, 
    0.18781748f, -0.05204297f, 0.03589947f, -0.03309591f, -0.18091606f, -0.14698207f, -0.05045320f, -0.17958371f, 
    -0.03808621f, 0.08712380f, -0.00770480f, 0.16792354f, 0.18320809f, 0.05397804f, 0.04070111f, -0.11447697f, 
    0.13566399f, 0.14420213f, 0.00525866f, 0.07656262f, -0.05583103f, -0.10593002f, -0.02520528f, -0.15699989f, 
    0.12638201f, 0.23962519f, 0.15522078f, -0.16326022f, 0.05881165f, 0.02212493f, 0.08701542f, -0.02605538f, 
    0.10860139f, -0.03809824f, -0.00058385f, 0.05907017f, -0.17646804f, -0.01862210f, -0.02305178f, 0.11880074f, 
    0.00681639f, -0.12877586f, -0.09664861f, -0.16253076f, -0.13044602f, 0.01210683f, -0.06473450f, -0.04200465f, 
    0.07373904f, -0.22514597f, 0.03610980f, 0.23584884f, 0.10996813f, -0.04026002f, -0.25947040f, 0.25466532f, 
    0.21605201f, 0.03371079f, 0.07917812f, 0.06711819f, 0.17612623f, 0.02201563f, 0.09447812f, -0.31137732f, 
    0.04562546f, 0.05667741f, 0.19819893f, 0.09319579f, 0.11697908f, -0.01654439f, 0.20171261f, 0.03668658f, 
    0.17009823f, 0.06575724f, 0.02149456f, -0.15150891f, 0.14489223f, -0.05275120f, 0.21205769f, -0.05629782f, 
    0.06745929f, -0.09416915f, 0.03647131f, 0.04813166f, 0.06620987f, -0.28531003f, 0.03091931f, -0.08220509f, 
    0.01745765f, -0.05911676f, 0.04115612f, -0.04940102f, 0.15167344f, 0.03546022f, 0.14777195f, 0.07930747f, 
    0.10747270f, -0.10346610f, -0.19414763f, -0.20290622f, -0.03385926f, 0.09611223f, -0.11467052f, 0.00078027f, 
    -0.04612490f, 0.07140954f, -0.10053162f, 0.02105954f, 0.34424156f, 0.23991582f, 0.18801625f, -0.05138776f, 
    -0.18874799f, -0.08190756f, 0.08898151f, 0.07190581f, 0.04698236f, -0.00175796f, -0.07211772f, -0.03260994f, 
    -0.09807782f, -0.03166727f, -0.13629100f, 0.05583422f, -0.00633618f, -0.03335187f, -0.30493039f, -0.08522425f, 
    0.09455150f, 0.16197975f, 0.09850928f, -0.05457514f, 0.15932985f, 0.02291181f, -0.00689981f, 0.02450347f, 
    -0.02050778f, -0.21366778f, 0.09013307f, 0.01994021f, -0.03923271f, 0.02304191f, 0.09738690f, -0.03116847f, 
    0.13503352f, -0.04478873f, 0.03016167f, -0.00643145f, 0.06716181f, -0.00238652f, -0.12397641f, -0.22372067f, 
    -0.00141232f, -0.01705724f, 0.03081127f, 0.09850857f, -0.39252251f, -0.13187517f, -0.34253830f, -0.35315567f, 
    -0.26372260f, -0.00573717f, -0.03241252f, -0.12819871f, -0.03659333f, 0.06234216f, 0.09425903f, 0.05129795f, 
    -0.06500266f, -0.07214271f, -0.05255608f, -0.03002496f, -0.02043742f, -0.00177134f, 0.10547785f, 0.06961905f, 
    -0.04742798f, 0.10045908f, 0.16649941f, 0.17295115f, 0.05546386f, -0.01059496f, 0.10183883f, 0.08086398f, 
    0.06739144f, -0.02656194f, -0.00567167f, 0.01367670f, 0.27467018f, 0.07567023f, 0.06214987f, 0.05568922f, 
    0.61281806f, 0.03615841f, 0.21297461f, 0.16519728f, -0.02822311f, -0.05646248f, 0.11374309f, 0.06666909f, 
    0.19081528f, 0.20101385f, -0.03135805f, -0.13415971f, -0.36748573f, -0.43998441f, -0.34730801f, -0.31444296f, 
    -0.18021940f, 0.04361975f, 0.16463433f, 0.17076933f, -0.12843676f, -0.11528598f, -0.03883986f, 0.09133838f, 
    -0.36948338f, -0.33257765f, -0.29886487f, -0.03887913f, 0.13428928f, 0.16814469f, 0.00416257f, -0.16277365f, 
    -0.06065132f, -0.06300187f, -0.14966342f, -0.13723306f, 0.13908760f, 0.21866260f, 0.20462288f, 0.25849333f, 
    -0.03089706f, -0.03159869f, 0.01996590f, -0.03241139f, 0.08164302f, -0.00320466f, -0.03081865f, 0.06267736f, 
    0.26190576f, 0.12795456f, 0.04334867f, 0.22372614f, 0.06109392f, 0.09188139f, -0.00318085f, -0.00450043f, 
    0.07067195f, 0.04631645f, 0.04008103f, -0.14335366f, -0.29433936f, -0.15723705f, 0.01604354f, -0.33068407f, 
    0.21923234f, 0.32402444f, 0.19218746f, 0.01644904f, -0.07541504f, -0.11409923f, -0.00600525f, -0.00702657f, 
    -0.47346553f, -0.15427111f, -0.14402518f, -0.38109878f, -0.07459156f, 0.06128288f, -0.02345665f, -0.18619868f, 
    -0.16266516f, -0.23088053f, 0.11957419f, -0.03432979f, 0.09750587f, 0.07832249f, -0.06890680f, -0.13733691f, 
    -0.16205619f, -0.09305500f, -0.01282755f, 0.04122468f, 0.21108304f, 0.03833970f, -0.04314646f, 0.00062890f, 
    0.40549010f, 0.09877254f, 0.06869078f, 0.11832723f, -0.01091094f, -0.01234950f, 0.04786951f, 0.11590274f, 
    0.08731423f, -0.09262807f, -0.20598455f, 0.03849854f, 0.47293213f, 0.05851649f, 0.36661553f, 0.18938996f, 
    -0.04191549f, 0.02588880f, -0.06611760f, 0.04445884f, -0.09747258f, -0.01145139f, 0.01959506f, 0.02382720f, 
    0.03650855f, 0.10377291f, -0.28905895f, -0.14727953f, 0.07483600f, -0.03703387f, -0.06886661f, 0.13041569f, 
    0.08963726f, 0.06424662f, 0.11942413f, -0.10287253f, -0.03369496f, -0.14974776f, -0.03565236f, -0.07532693f, 
    -0.05269683f, 0.09985642f, 0.10972845f, -0.08460377f, 0.08290109f, 0.05981187f, 0.09452856f, 0.10626049f, 
    -0.13140091f, 0.18275769f, 0.04472207f, 0.04642554f, -0.00225623f, -0.13637611f, 0.18790773f, -0.10030251f, 
    0.03157415f, 0.02254467f, 0.05859421f, 0.06268826f, -0.01240837f, 0.02606964f, 0.05592164f, 0.13186997f, 
    0.14442782f, 0.20550798f, 0.06125354f, 0.18148716f, -0.09808689f, -0.03100478f, 0.07772284f, -0.04402459f, 
    0.00389633f, -0.17013109f, 0.21312422f, 0.10726286f, -0.02026429f, 0.02126042f, -0.08081690f, 0.02294243f, 
    -0.11258143f, 0.01783604f, -0.00606181f, -0.13593644f, -0.04067622f, 0.01304151f, 0.02494850f, -0.07096151f, 
    -0.00636379f, -0.06893305f, -0.10829376f, -0.07199886f, 0.07809757f, -0.00864243f, 0.08236943f, 0.01449708f, 
    0.09942419f, 0.24614879f, 0.18545341f, 0.32907882f, -0.14152756f, -0.09816254f, 0.09842183f, -0.00001846f, 
    -0.07476748f, -0.03036541f, -0.02657320f, 0.11737209f, 0.21590424f, -0.11244728f, 0.06260116f, 0.14173697f, 
    0.12929930f, 0.15094838f, 0.09728725f, 0.07586523f, 0.07368068f, 0.02650562f, 0.05003082f, -0.14726077f, 
    0.23364606f, -0.00066078f, -0.07609302f, -0.17407216f, 0.11283766f, 0.03298105f, -0.00582505f, -0.12851693f, 
    0.04757728f, -0.09087729f, -0.16698699f, -0.07337017f, 0.03072396f, 0.12357217f, -0.12642998f, -0.09007073f, 
    -0.00381693f, -0.08745898f, -0.09001424f, -0.03715148f, -0.00213469f, 0.00232880f, 0.00810121f, -0.01500946f, 
    0.10577413f, -0.25998348f, 0.15856643f, -0.06738047f, -0.01403414f, 0.02292693f, -0.20957944f, -0.03598699f, 
    0.00460555f, -0.04479219f, -0.12077292f, -0.11553176f, 0.00327774f, -0.10001794f, -0.10607851f, -0.16760869f, 
    0.05323698f, -0.09389490f, -0.03334210f, 0.08041038f, 0.01845364f, -0.05020887f, 0.19306834f, -0.01411367f, 
    0.25970921f, 0.02137299f, -0.27293053f, -0.03468902f, 0.15031543f, 0.20698507f, 0.15705499f, 0.00243593f, 
    0.02664878f, 0.02534708f, -0.06519990f, -0.04312709f, 0.50434196f, -0.18631135f, -0.03381879f, -0.16851258f, 
    -0.03801183f, -0.04819977f, 0.06462970f, -0.08798830f, 0.04074534f, -0.08331341f, 0.00986156f, 0.00783556f, 
    -0.19300534f, -0.09063471f, -0.05913058f, -0.07378738f, -0.00951919f, 0.10112111f, -0.11474815f, 0.14399774f, 
    0.08957087f, -0.08381213f, -0.08601442f, 0.16816959f, 0.37222239f, 0.17855944f, -0.00394832f, -0.17441621f, 
    -0.02902419f, 0.01227972f, 0.03607377f, 0.01597672f, 0.00720485f, 0.05676963f, -0.05588084f, -0.01047254f, 
    -0.02299119f, -0.05822506f, 0.17221896f, 0.24895325f, 0.08747556f, 0.07859209f, 0.00861284f, -0.01022145f, 
    -0.07708924f, -0.09136559f, -0.07064632f, 0.05157153f, 0.06344642f, 0.18610220f, 0.13011084f, 0.16630389f, 
    0.06918430f, -0.16470809f, 0.03020064f, 0.11509389f, 0.01841339f, 0.01082586f, 0.12310307f, 0.03134967f, 
    -0.15824573f, -0.32240877f, -0.21225917f, 0.00549592f, 0.03236127f, 0.24132434f, -0.09978918f, 0.04680627f, 
    0.13673422f, -0.03432656f, -0.14184523f, 0.04173835f, 0.23674454f, 0.01951572f, 0.03798585f, -0.00616087f, 
    -0.00885555f, -0.07677881f, 0.10053031f, 0.01622667f, 0.10409811f, 0.09023503f, -0.02167878f, 0.00911165f, 
    -0.01476496f, 0.12046154f, -0.06568495f, -0.08046405f, -0.10485301f, -0.01515735f, -0.00039051f, -0.03902948f, 
    0.04118324f, 0.01419809f, 0.18112415f, 0.07227667f, 0.09027983f, 0.01023398f, -0.09441301f, -0.10689186f, 
    -0.08988709f, 0.03760122f, 0.07524282f, 0.11005877f, 0.04120058f, 0.02264975f, -0.02919317f, -0.02730196f, 
    0.12181088f, -0.12271379f, 0.02721931f, -0.15631641f, 0.09209769f, 0.04226078f, 0.00741402f, 0.01229218f, 
    0.03177438f, 0.03629004f, -0.09878365f, 0.01302782f, -0.15410148f, 0.06659264f, -0.14042458f, -0.04091308f, 
    0.02725970f, 0.02310430f, 0.13687277f, 0.06250698f, 0.01638207f, 0.08222120f, 0.09122264f, 0.16136584f, 
    -0.19279794f, -0.17020957f, -0.04510221f, 0.27647501f, -0.27328843f, 0.21614152f, -0.02590482f, 0.11647271f, 
    -0.01667730f, -0.04987427f, 0.07467134f, 0.03876948f, -0.02900051f, -0.23614375f, 0.09065954f, 0.13880192f, 
    -0.12589648f, 0.03362035f, 0.08113634f, -0.05399658f, -0.09174943f, -0.08882114f, -0.08731513f, -0.06388910f, 
    0.04791974f, 0.15164468f, -0.10135748f, 0.17958380f, -0.02728048f, -0.11889210f, 0.11589106f, -0.03612387f, 
    -0.04185798f, -0.08228847f, 0.15552731f, 0.08582482f, -0.11159783f, 0.07389997f, 0.04083376f, 0.10057987f, 
    -0.02198598f, 0.17890050f, -0.01056519f, -0.06627741f, 0.15778884f, -0.04324001f, -0.11033164f, -0.02835727f, 
    -0.40835613f, 0.22063147f, 0.05279869f, -0.21681073f, -0.15492871f, 0.07706179f, -0.11272363f, 0.10530414f, 
    0.00888717f, -0.04483387f, 0.03410503f, -0.05898800f, -0.33069322f, 0.27256647f, -0.08171909f, -0.18624121f, 
    -0.08253852f, 0.06689083f, -0.08049791f, 0.02897173f, -0.01743394f, 0.08809330f, 0.02398824f, -0.02482080f, 
    0.43892148f, -0.11216634f, 0.17044875f, 0.01941444f, 0.10967628f, 0.02575984f, 0.07154382f, -0.14353466f, 
    0.04973909f, -0.01704262f, 0.08463630f, 0.01909961f, 0.02400572f, -0.21394981f, -0.03842527f, 0.04787085f, 
    -0.04223949f, -0.00138728f, 0.10270889f, 0.00987402f, 0.05000386f, -0.13342935f, 0.07397777f, 0.05762571f, 
    -0.00766589f, 0.07433809f, -0.21988320f, 0.16523783f, 0.09813552f, -0.06481701f, -0.24554642f, -0.07300606f, 
    -0.03282322f, 0.16624764f, -0.00860536f, 0.23497069f, -0.14044069f, 0.02908280f, 0.03330895f, 0.11513819f, 
    0.08493823f, -0.08651837f, 0.00950840f, 0.04632132f, 0.13758825f, 0.05487828f, -0.06735071f, -0.02731959f, 
    -0.31392890f, -0.16893934f, -0.40709010f, -0.02006812f, 0.02245420f, 0.02587402f, -0.20432046f, -0.26487198f, 
    0.05968895f, 0.02864679f, -0.05670453f, 0.05313420f, 0.19098568f, -0.16203842f, 0.21949150f, 0.21754466f, 
    0.03596699f, 0.22302929f, -0.15012924f, 0.04951721f, 0.08677100f, 0.11864664f, 0.05925684f, -0.04148491f, 
    -0.07359511f, -0.19358125f, 0.04245502f, 0.01360108f, -0.02860689f, 0.19223982f, -0.14086670f, 0.07625815f, 
    0.01804443f, 0.14942609f, 0.21396635f, 0.07223585f, -0.06782317f, -0.01602861f, -0.00641379f, 0.05777125f, 
    0.06568058f, -0.01089827f, -0.08244578f, 0.02649347f, 0.02073718f, -0.08821242f, -0.10147939f, -0.06249771f, 
    -0.03777979f, -0.16758510f, 0.10411560f, -0.28116313f, -0.05335986f, 0.02598762f, -0.04162515f, -0.01703177f, 
    0.01929320f, -0.07061747f, 0.07652571f, 0.07772990f, 0.12044785f, -0.01336630f, -0.05996365f, -0.20413193f, 
    -0.09445389f, 0.00652466f, 0.06727029f, 0.05339032f, -0.13603279f, -0.00055946f, -0.15999304f, 0.01601807f, 
    -0.03888489f, 0.04807599f, -0.04706091f, -0.06985875f, -0.01379599f, 0.16382523f, 0.15337464f, 0.17998007f, 
    0.00197079f, -0.02851832f, 0.14844687f, -0.03127644f, -0.29742426f, -0.10932422f, 0.01602404f, -0.03736886f, 
    -0.05078252f, -0.01893574f, 0.03129869f, -0.10784993f, -0.02434772f, -0.13200697f, 0.03803219f, -0.01009679f, 
    -0.02339370f, -0.22250155f, 0.00828827f, 0.08910532f, 0.03221752f, -0.04998498f, -0.02366081f, 0.06103776f, 
    -0.00316421f, 0.08018649f, 0.18736812f, 0.00790438f, -0.02674432f, -0.07782800f, -0.11369910f, -0.39615178f, 
    0.09868890f, 0.00054259f, 0.12784204f, 0.00221626f, 0.26277837f, 0.06975944f, -0.05802551f, 0.09153236f, 
    0.02293521f, 0.27017576f, 0.05600635f, -0.12540013f, -0.18248099f, 0.00756227f, 0.22888316f, 0.12871581f, 
    -0.01115375f, -0.00442055f, 0.01352576f, -0.03561199f, -0.25864708f, 0.30138001f, 0.21561636f, -0.02849234f, 
    0.13043244f, 0.08571380f, 0.09848129f, 0.11521882f, -0.03164436f, 0.13574785f, 0.02153601f, -0.00403574f, 
    0.18006599f, -0.21645539f, -0.26844686f, -0.29752204f, 0.06866016f, 0.13553099f, -0.09256147f, -0.17113997f, 
    0.07476361f, 0.01788418f, -0.13400203f, 0.00491278f, 0.40483317f, 0.26892480f, -0.02447006f, 0.06840594f, 
    0.01712280f, -0.07569125f, 0.06177300f, 0.07408024f, 0.10564856f, 0.03541243f, 0.15204510f, -0.00935735f, 
    -0.34408283f, -0.02509181f, 0.19341137f, 0.10849325f, 0.02624258f, 0.24338685f, -0.19827463f, 0.14846183f, 
    0.00005517f, 0.05390092f, 0.03961289f, -0.04144270f, -0.08376507f, 0.02638390f, 0.20029019f, 0.06556461f, 
    0.01468920f, -0.08575821f, 0.01204763f, 0.06434654f, -0.10228198f, 0.04459829f, -0.08311545f, -0.01286623f, 
    -0.13297014f, -0.23263319f, -0.13158648f, -0.05530259f, 0.12992086f, 0.20009576f, 0.03085533f, 0.06664008f, 
    -0.06528639f, 0.05786628f, -0.06118011f, -0.02300727f, 0.55946428f, 0.01891133f, 0.13563202f, 0.21174531f, 
    -0.08376934f, 0.09051670f, 0.19506679f, 0.06558545f, 0.17776977f, -0.03664947f, -0.04056277f, 0.12115263f, 
    0.11786368f, -0.05731703f, -0.14175783f, -0.16844949f, -0.12987618f, -0.04594518f, 0.15078199f, 0.08543167f, 
    0.01966083f, 0.00319022f, 0.03168130f, 0.03656053f, -0.02383263f, -0.03752751f, -0.14029057f, -0.05356412f, 
    -0.09837642f, -0.07044347f, 0.04693563f, 0.02012103f, 0.10762291f, 0.06258618f, 0.01157728f, 0.00273854f, 
    -0.16633049f, 0.03499647f, 0.27993509f, -0.36582261f, 0.03516857f, -0.00271123f, -0.01950213f, -0.02047505f, 
    -0.06324261f, 0.03484310f, 0.17967331f, 0.18272759f, -0.16954353f, -0.19485825f, -0.13513932f, -0.06921365f, 
    -0.10592546f, -0.09085092f, 0.03786398f, -0.01850617f, -0.00699785f, -0.05937798f, 0.00816856f, 0.02580205f, 
    -0.05329319f, -0.07132763f, 0.00783112f, 0.04315137f, -0.06608590f, -0.15462422f, 0.03426314f, 0.25865376f, 
    -0.07430097f, 0.02013076f, 0.05098547f, 0.07252863f, -0.02932540f, -0.09908109f, -0.02540808f, -0.20941763f, 
    -0.06408959f, -0.05084379f, 0.05956997f, 0.05587663f, -0.08151176f, -0.03156176f, 0.01172046f, -0.01021938f, 
    0.25790367f, 0.15575828f, -0.18591708f, 0.37731344f, -0.07818296f, -0.02557511f, 0.09478525f, 0.07884865f, 
    0.05821443f, 0.12325824f, 0.14491527f, 0.12575743f, -0.08836120f, -0.35821769f, -0.12926242f, -0.07030613f, 
    0.16074875f, 0.03263186f, 0.07111741f, 0.11483498f, 0.04298414f, 0.07564506f, 0.12102986f, -0.00680167f, 
    -0.27979681f, -0.14367783f, -0.16148329f, -0.06255712f, -0.05223030f, 0.00140125f, -0.06167360f, 0.06629302f, 
    0.29456162f, -0.04219046f, 0.11908166f, 0.01447141f, -0.41089445f, 0.03787270f, 0.23106813f, 0.15150245f, 
    -0.02181477f, -0.00218656f, -0.14666803f, 0.02107001f, 0.02960088f, 0.19471416f, 0.24080333f, -0.01837456f, 
    -0.06130410f, -0.35623181f, -0.09476046f, -0.15927649f, 0.04701496f, 0.08740875f, -0.04272379f, -0.13839351f, 
    -0.02943659f, 0.17612858f, 0.05385624f, 0.07901081f, 0.14317298f, 0.30305928f, -0.14879514f, 0.26841825f, 
    0.01954962f, 0.04871447f, -0.01486737f, -0.00958166f, -0.02658084f, -0.10259436f, 0.18635558f, 0.03729334f, 
    -0.00227610f, -0.00315672f, -0.04380046f, 0.05694198f, -0.01385704f, -0.03146597f, -0.04475888f, 0.04030519f, 
    -0.00576418f, 0.04231873f, 0.02744944f, -0.06686220f, 0.04115687f, 0.06157685f, -0.04745569f, -0.02880066f, 
    -0.04546287f, -0.04950883f, 0.01889233f, -0.06962951f, -0.05225789f, -0.01926720f, -0.02223751f, -0.05606556f, 
    0.04896928f, 0.02585671f, 0.02402749f, -0.07905862f, 0.02142084f, 0.01249030f, 0.04534770f, -0.04466349f, 
    -0.05310044f, -0.02882884f, 0.00792551f, 0.04820900f, -0.01236362f, 0.03736096f, 0.01786555f, 0.04064246f, 
    -0.00569328f, -0.03793810f, 0.04759877f, -0.08603213f, 0.01810957f, -0.04461977f, 0.00772484f, 0.00980523f, 
    0.06134822f, 0.05334982f, 0.01553034f, 0.01234158f, -0.04432148f, 0.01966256f, 0.04382239f, -0.07393832f, 
    -0.02802348f, -0.05975614f, 0.00360796f, -0.03663518f, -0.07688632f, -0.04704245f, -0.06719019f, 0.03657676f, 
    -0.03881104f, -0.07268681f, -0.04001772f, -0.05869925f, 0.00835828f, -0.03949419f, -0.05063133f, 0.04375162f, 
    0.02099352f, -0.02080988f, 0.00774926f, 0.00064837f, 0.04537341f, -0.01000326f, 0.02270200f, -0.02870107f, 
    -0.05712981f, 0.00903777f, 0.03281028f, 0.05676087f, 0.03903371f, -0.03062764f, -0.03915038f, -0.00894125f, 
    -0.06861574f, -0.06837469f, -0.02785158f, -0.03569935f, 0.06447282f, -0.07352242f, 0.03989244f, -0.04011719f, 
    0.05163645f, -0.03164125f, -0.06402314f, 0.04782560f, -0.04904176f, -0.02585009f, -0.05279527f, 0.03804272f, 
    -0.01640952f, -0.06748562f, 0.02407234f, -0.02958975f, -0.02507976f, 0.03055934f, 0.05609471f, 0.05128067f, 
    -0.07113510f, 0.03991094f, 0.04677626f, -0.05887156f, 0.01598395f, 0.02311002f, -0.04679566f, 0.04809289f, 
    -0.03660131f, -0.03246342f, -0.02229604f, -0.00300771f, -0.02119713f, 0.05269559f, 0.02490367f, -0.02284201f, 
    -0.08052225f, -0.05285281f, -0.01489688f, -0.07902147f, 0.02792136f, 0.04406149f, 0.01534410f, -0.02379202f, 
    0.04981807f, -0.03792287f, -0.01422521f, 0.03584105f, 0.00415836f, -0.02992363f, -0.01174046f, -0.05887687f, 
    -0.00656964f, 0.02691369f, 0.01291418f, -0.04654624f, 0.05298125f, -0.01351396f, -0.06039941f, 0.04399384f, 
    -0.05195889f, 0.05925119f, -0.07198530f, 0.05313843f, -0.06735357f, -0.04568669f, -0.06213778f, 0.01448549f, 
    -0.02839560f, 0.04168644f, 0.03274806f, -0.01882772f, -0.00591000f, -0.06063871f, -0.01624905f, -0.04277983f, 
    -0.01734972f, -0.02139357f, -0.04004264f, -0.01544479f, 0.03224101f, -0.00324209f, 0.01191876f, -0.00340196f, 
    -0.04981867f, -0.06515671f, 0.01696915f, 0.05642525f, -0.00177986f, -0.06188328f, 0.02945524f, -0.07437518f, 
    -0.03838412f, -0.01752885f, 0.00941960f, 0.05497685f, 0.04835125f, 0.05681081f, 0.02308479f, 0.00287159f, 
    0.00914594f, -0.02419580f, 0.02229862f, 0.02467926f, -0.00446243f, -0.02081846f, -0.02813980f, -0.06836706f, 
    0.01311454f, -0.04046464f, 0.03336297f, -0.03713136f, -0.01401388f, 0.00788632f, -0.04540962f, -0.03633928f, 
    -0.03586713f, 0.05202195f, 0.04507546f, 0.01143965f, 0.03553286f, 0.00835332f, -0.01594889f, -0.08403109f, 
    -0.02275564f, -0.03854813f, -0.01427467f, 0.01351201f, -0.04487980f, -0.04426927f, 0.04449926f, 0.04520765f, 
    0.02453695f, -0.05224630f, -0.03660517f, -0.04064580f, -0.04186871f, 0.05685483f, 0.05605895f, 0.05907046f, 
    -0.00272588f, -0.00271447f, 0.03691445f, 0.04480742f, 0.05183699f, 0.02598124f, 0.03882715f, 0.04623197f, 
    -0.01220265f, -0.03201067f, -0.04426812f, 0.04211043f, -0.02247491f, -0.05367411f, 0.01596748f, -0.08111943f, 
    -0.05680058f, 0.04502516f, -0.07108004f, -0.06657740f, -0.01012498f, 0.03395498f, 0.00486209f, -0.03494675f, 
    -0.04038159f, -0.01217443f, -0.00784289f, -0.02984377f, 0.01572438f, -0.01959642f, 0.01357955f, 0.01550037f, 
    -0.03892075f, -0.02898781f, -0.05263472f, -0.05112048f, 0.06005301f, 0.03983929f, 0.05805664f, 0.04327724f, 
    -0.03818883f, 0.04300928f, -0.02778149f, 0.04842638f, 0.01759040f, -0.03852124f, -0.05502857f, 0.06528845f, 
    -0.00948608f, -0.06386996f, -0.06671251f, -0.06052194f, 0.00784196f, -0.03439679f, 0.05914666f, 0.00575488f, 
    -0.06147203f, 0.01852956f, -0.05437801f, 0.01596886f, 0.02834736f, -0.00419578f, -0.04362451f, -0.06415431f, 
    -0.02159421f, 0.03690736f, 0.03953538f, -0.03972632f, -0.00871103f, -0.04717385f, -0.06947622f, -0.05994568f, 
    -0.00652729f, 0.01738025f, 0.00621818f, -0.07171979f, 0.02581336f, -0.07863621f, 0.02462926f, -0.07004712f, 
    -0.07248887f, -0.04448739f, 0.02455695f, -0.00142799f, -0.00662904f, -0.02171604f, -0.04027538f, 0.03981056f, 
    -0.03316924f, 0.05279895f, -0.05973744f, 0.04836256f, -0.00310261f, 0.03287200f, 0.01925969f, -0.00655651f, 
    -0.01097828f, -0.00212500f, -0.05906039f, -0.05020123f, 0.03447060f, 0.01562268f, 0.03835907f, -0.04914595f, 
    0.02827143f, -0.06463189f, -0.05024118f, 0.01582284f, -0.00693830f, 0.04511480f, -0.05968639f, -0.06787497f, 
    -0.07527605f, -0.00198879f, -0.04355102f, 0.00998550f, 0.01635686f, -0.04184060f, -0.02855158f, 0.05366075f, 
    0.00482854f, 0.01928666f, -0.02674936f, -0.02772210f, -0.06126800f, -0.07055371f, -0.00218116f, -0.05646671f, 
    0.03621003f, 0.05520380f, 0.05874533f, 0.00672033f, -0.06582107f, -0.04760834f, -0.04261916f, 0.00006861f, 
    -0.06896217f, -0.07387451f, 0.02174670f, 0.04384262f, -0.01555952f, -0.05441899f, 0.02801617f, -0.02470588f, 
    0.02024793f, -0.08394486f, -0.06385192f, -0.05305922f, -0.06596896f, 0.01084283f, 0.05722534f, -0.00028195f, 
    0.00203764f, 0.11501889f, 0.11447759f, 0.02542028f, -0.03076917f, 0.01589238f, 0.14339626f, -0.01909313f, 
    0.01694381f, 0.13144699f, -0.04440592f, 0.05543028f, -0.00524446f, 0.03541089f, -0.15102242f, 0.00356151f, 
    -0.04029696f, 0.06548472f, -0.02237052f, 0.09850387f, -0.04759739f, -0.14714196f, -0.01824072f, -0.10824808f, 
    0.13362183f, 0.30979815f, -0.05398286f, 0.10223764f, -0.11908435f, -0.17695905f, 0.07958671f, 0.01579675f, 
    -0.14212665f, 0.02181793f, -0.01527333f, -0.09604321f, -0.09055188f, -0.21738346f, 0.09062467f, -0.28477567f, 
    0.05252365f, 0.15207836f, 0.06241228f, -0.09102964f, -0.12377428f, -0.02632311f, -0.06589174f, 0.17934862f, 
    0.00208075f, 0.05096867f, -0.03711988f, -0.16203377f, 0.01826569f, -0.06384102f, 0.03006682f, -0.13755754f, 
    0.14504048f, 0.08850063f, 0.09547861f, 0.13062827f, -0.02522888f, -0.10304137f, 0.02548986f, 0.05131297f, 
    0.05135464f, -0.01485675f, 0.08528905f, 0.06315683f, 0.13190669f, 0.00160586f, -0.07581984f, -0.08695162f, 
    0.31779033f, -0.14852916f, -0.07415073f, 0.07691648f, -0.01986168f, -0.03964650f, -0.05890468f, 0.01378707f, 
    -0.01940677f, 0.21724737f, 0.10092497f, -0.01003515f, -0.12999597f, 0.01998121f, 0.17748821f, -0.06594209f, 
    -0.01007192f, -0.06568781f, 0.03129699f, -0.04715006f, -0.13650668f, -0.04923571f, -0.04354117f, 0.05507762f, 
    0.10215517f, 0.03910157f, 0.02344783f, -0.11753502f, -0.02743102f, 0.05197339f, -0.04245992f, -0.07890150f, 
    -0.09725307f, -0.00471691f, -0.08973034f, -0.16346541f, 0.24263918f, 0.13006200f, 0.14311165f, 0.02597022f, 
    -0.08683962f, -0.08098082f, 0.02522193f, 0.10247099f, -0.00963666f, -0.04580541f, -0.09967211f, -0.00727420f, 
    0.05860116f, 0.22901596f, -0.04001538f, 0.04101017f, 0.04366108f, -0.12686883f, 0.09362382f, 0.10214424f, 
    -0.08777976f, -0.12173536f, -0.06249835f, 0.02045729f, -0.26099369f, -0.01080467f, -0.34709769f, 0.00757102f, 
    0.05194840f, -0.18781048f, -0.04872857f, 0.03397563f, -0.07692066f, -0.19344252f, -0.12330754f, -0.05130897f, 
    -0.31305462f, -0.12501517f, -0.09297673f, -0.11179337f, -0.11583061f, -0.02007323f, -0.11692049f, -0.15232106f, 
    -0.01475018f, -0.11886166f, 0.00761504f, -0.07021441f, -0.03620922f, 0.01045422f, -0.23574145f, 0.03341943f, 
    -0.00283393f, -0.02376709f, -0.04825654f, -0.03504700f, -0.11074735f, -0.00039137f, 0.06425339f, -0.00528047f, 
    -0.04576123f, -0.30345294f, -0.10460467f, 0.04470975f, 0.08759728f, 0.14370488f, -0.07394098f, -0.09009506f, 
    -0.15618508f, -0.00555105f, 0.03285086f, 0.13897784f, -0.13262951f, 0.01020457f, -0.16008450f, 0.15548550f, 
    0.01529838f, -0.02771164f, 0.00671908f, 0.04683410f, 0.00810375f, -0.02496391f, 0.11251215f, 0.06052950f, 
    -0.28976357f, -0.18571661f, 0.10474535f, -0.02141401f, 0.01725543f, 0.09877131f, -0.08405980f, 0.05573181f, 
    -0.08652885f, 0.09505029f, 0.02935851f, -0.09671897f, 0.05137536f, 0.06084373f, 0.20345390f, -0.04246226f, 
    -0.05132822f, -0.26291609f, -0.20609370f, 0.07489468f, -0.16718711f, -0.09530441f, 0.00203471f, 0.00678992f, 
    0.01376070f, -0.43918562f, -0.00739143f, 0.19936498f, 0.14493190f, 0.16259606f, 0.13256450f, -0.07215086f, 
    0.13343573f, -0.04602974f, -0.10205173f, -0.01897641f, 0.50098532f, 0.26460546f, -0.13700396f, 0.21658643f, 
    -0.03361139f, -0.07921521f, 0.13090490f, 0.04290525f, 0.20426802f, -0.11101506f, 0.13609347f, -0.00538445f, 
    0.18956661f, -0.00489393f, -0.20689960f, 0.06230052f, -0.03609115f, 0.10415403f, 0.09991688f, 0.16649500f, 
    0.24846965f, 0.05993522f, 0.10991463f, 0.23024902f, 0.10120943f, -0.03121371f, -0.12461109f, 0.00594599f, 
    -0.03446542f, 0.15585603f, 0.01462241f, 0.07405820f, 0.16266772f, 0.21808103f, 0.07218953f, 0.02472365f, 
    -0.01655560f, 0.22715095f, 0.10288844f, -0.30688089f, 0.14115070f, -0.08362647f, 0.00004683f, 0.23474351f, 
    0.01480538f, 0.09102967f, 0.20902045f, -0.03832934f, -0.27422801f, -0.15320644f, -0.08849113f, 0.09492990f, 
    -0.03337603f, -0.01467943f, 0.04708303f, 0.01281517f, 0.06810102f, 0.04918520f, 0.04149891f, 0.24438968f, 
    -0.18634845f, -0.23687604f, 0.09256721f, 0.17140511f, -0.12630717f, -0.19028287f, 0.05037807f, 0.23803076f, 
    -0.11259785f, 0.13533969f, 0.17987894f, 0.23182790f, -0.03275909f, -0.04661630f, -0.03166851f, -0.10904414f, 
    0.18914071f, 0.16257851f, 0.05413967f, 0.02418664f, -0.12765828f, -0.03692604f, -0.03589956f, -0.03884923f, 
    0.18171841f, -0.05436252f, -0.20458099f, 0.09145447f, -0.03235206f, 0.05815706f, 0.00923572f, -0.03758204f, 
    0.21529979f, 0.11421212f, -0.08298786f, 0.08721331f, -0.16759723f, -0.30547759f, 0.03482633f, 0.31658915f, 
    0.08651296f, -0.01208792f, -0.10475769f, 0.02808199f, 0.01512471f, 0.05149028f, -0.19608863f, -0.13509835f, 
    -0.16911872f, -0.23729533f, 0.01346787f, 0.21959889f, 0.01084786f, -0.04035456f, -0.12742741f, -0.01556256f, 
    0.11065718f, 0.13257761f, 0.08652241f, 0.05827779f, -0.44828227f, 0.19717443f, 0.49377707f, 0.14309640f, 
    -0.01301340f, -0.00775736f, -0.14271414f, 0.26864111f, 0.02690265f, 0.09734878f, 0.05327178f, 0.14781684f, 
    -0.14999028f, -0.00036303f, 0.21392424f, 0.11400764f, -0.03248652f, 0.06290787f, 0.14404340f, 0.09279322f, 
    0.07775766f, 0.11564469f, 0.04787428f, 0.02795003f, -0.16079052f, 0.09317281f, -0.05386821f, 0.13057557f, 
    0.27313179f, 0.06357405f, -0.03601386f, -0.00894204f, -0.10504146f, -0.11257521f, 0.03021274f, 0.08574612f, 
    0.04052173f, 0.16840279f, 0.13573949f, -0.01454770f, 0.14030117f, 0.01739497f, 0.06341724f, 0.06869072f, 
    -0.03840537f, 0.18137917f, 0.08351627f, -0.03689053f, -0.24164931f, 0.01049779f, 0.19132711f, -0.05446125f, 
    -0.07628126f, 0.09091647f, 0.01649142f, 0.06529616f, -0.07554586f, 0.04084038f, 0.06380402f, 0.04191069f, 
    -0.06873590f, 0.36753163f, 0.13932675f, 0.07764255f, -0.12222853f, -0.00927215f, 0.06625267f, 0.07521862f, 
    -0.01534208f, -0.11117513f, 0.12533429f, -0.08337534f, 0.16877514f, 0.24074450f, 0.19670402f, 0.18730807f, 
    0.12085158f, 0.19435243f, 0.24154954f, 0.06946330f, -0.07855514f, 0.14342844f, 0.04395842f, 0.10455814f, 
    0.04832573f, 0.09486628f, -0.03643382f, 0.05901044f, 0.05524146f, 0.00735724f, 0.08917379f, -0.19857125f, 
    0.11317649f, -0.06310443f, -0.12273601f, -0.22679742f, 0.13939358f, -0.00146951f, -0.13906153f, -0.15355189f, 
    0.01890920f, -0.09582526f, -0.12092779f, 0.03150156f, -0.11629341f, -0.07428138f, -0.06850585f, -0.18892749f, 
    0.29144439f, 0.02365888f, 0.07059880f, -0.11686066f, -0.18232198f, 0.07136774f, -0.15329050f, -0.00958566f, 
    0.05770671f, 0.03050291f, 0.08627109f, 0.05307513f, -0.21153936f, -0.08606352f, 0.03456926f, 0.01789214f, 
    0.07760952f, -0.03862115f, -0.04116290f, 0.03607550f, 0.02684003f, 0.03181412f, 0.06561518f, -0.08018243f, 
    -0.09187345f, -0.00216957f, -0.04461864f, 0.17438252f, 0.06707981f, 0.02204580f, -0.04805074f, 0.04721893f, 
    0.02027937f, -0.07957716f, -0.01929024f, 0.16316468f, 0.09176044f, 0.14978211f, 0.12055060f, -0.17177105f, 
    -0.21481313f, -0.16923492f, -0.11444537f, -0.01204823f, 0.01527030f, 0.09610835f, 0.00688228f, -0.03493307f, 
    0.19477391f, 0.34560117f, -0.04311834f, 0.13974166f, 0.01408195f, -0.03900355f, -0.00552576f, 0.14471278f, 
    0.11381344f, 0.11363105f, -0.04685272f, 0.09363436f, -0.07134759f, -0.14211585f, 0.01742524f, 0.22856744f, 
    0.01899257f, -0.00347675f, -0.02910012f, 0.13293430f, 0.01753274f, 0.01839789f, 0.06063660f, -0.03423028f, 
    -0.14808142f, -0.30732659f, -0.09996449f, 0.18374699f, 0.11583829f, -0.02941101f, 0.03339701f, 0.05473695f, 
    0.02952444f, 0.05154594f, 0.13109317f, 0.05853809f, -0.24729107f, -0.28626087f, -0.20715587f, -0.06471972f, 
    -0.18391819f, -0.09379739f, 0.01592376f, 0.05844039f, 0.09477626f, 0.10561793f, -0.00951825f, -0.09723387f, 
    -0.28685662f, -0.11682302f, 0.20595671f, 0.10588922f, 0.06465568f, 0.06176990f, -0.05418221f, -0.15680020f, 
    -0.16178006f, -0.04035595f, 0.07820117f, 0.15772684f, -0.01792848f, 0.32562429f, -0.11665680f, 0.00123604f, 
    -0.00814625f, 0.04201349f, 0.03512224f, 0.05385253f, 0.14603110f, -0.06658450f, 0.01606020f, 0.08612850f, 
    0.12882377f, 0.05183174f, -0.34073791f, -0.06845463f, 0.10868863f, -0.21556939f, 0.16811910f, 0.03814247f, 
    0.02928345f, -0.10905804f, -0.01533649f, -0.03001205f, -0.14312504f, -0.16596293f, 0.01928859f, 0.00528992f, 
    0.13887562f, 0.15270822f, 0.02288963f, -0.07651840f, 0.08599441f, -0.01744568f, 0.02788857f, 0.24825215f, 
    -0.05557893f, 0.03704494f, 0.06553311f, 0.03664618f, 0.00376692f, 0.15488692f, -0.00542344f, 0.01244221f, 
    0.04543615f, 0.06312476f, 0.00041492f, -0.03693590f, -0.30749831f, -0.14032777f, 0.00424468f, 0.05519620f, 
    0.11755837f, 0.04732717f, 0.01544828f, 0.16969484f, 0.07494839f, -0.00603690f, -0.03294198f, 0.01834042f, 
    -0.15635325f, 0.01796458f, -0.00955864f, 0.05173445f, -0.04036747f, -0.07887705f, -0.02140480f, 0.00802091f, 
    0.15552826f, -0.02947703f, 0.14934894f, -0.18541229f, -0.05310369f, 0.08130553f, 0.00069224f, -0.02940940f, 
    -0.00278522f, -0.03630042f, -0.03733583f, -0.11265713f, -0.13308540f, -0.05686762f, 0.03530959f, 0.08107597f, 
    -0.41785008f, 0.21399629f, 0.14476570f, 0.05187876f, -0.02334113f, 0.05183749f, -0.04887129f, 0.02527072f, 
    -0.02257526f, -0.15830040f, 0.09757099f, 0.11050331f, -0.28584924f, -0.16268235f, -0.18680835f, -0.20033567f, 
    0.12028339f, -0.03510882f, -0.09399915f, 0.20039082f, 0.04097630f, -0.00819230f, -0.01521598f, 0.12863226f, 
    -0.12536089f, -0.06844234f, -0.25902131f, -0.19496153f, 0.00509343f, 0.12793212f, 0.08735782f, 0.01842948f, 
    0.01519037f, -0.06608311f, -0.05381515f, 0.18063045f, -0.19478139f, 0.02735072f, 0.08920149f, 0.15424889f, 
    0.08827190f, 0.01957601f, 0.07004126f, -0.05826021f, -0.02951484f, 0.00788248f, 0.01316539f, 0.03196838f, 
    0.10463624f, -0.03734922f, 0.15112680f, 0.13008332f, 0.16572364f, -0.12954582f, -0.01734711f, 0.03976739f, 
    -0.11179824f, 0.05842961f, 0.17071603f, 0.09297234f, 0.55700368f, -0.08710548f, 0.19372042f, -0.16024309f, 
    0.07755835f, 0.11114396f, 0.12489614f, -0.04272110f, 0.06388193f, 0.02378883f, 0.11520496f, -0.03289515f, 
    0.33164197f, -0.01940263f, -0.01163417f, -0.17790464f, 0.05549558f, -0.10002603f, 0.13901389f, -0.05317680f, 
    -0.03806259f, -0.12732758f, -0.01415794f, 0.05976048f, 0.07177854f, -0.29275894f, -0.09476741f, -0.23592763f, 
    -0.12461785f, -0.07140157f, 0.04135203f, 0.03034013f, 0.27385578f, -0.00608180f, 0.07892427f, -0.03914735f, 
    0.02730409f, 0.44649523f, -0.12881166f, -0.12930818f, 0.14139949f, -0.06813504f, 0.07474834f, 0.03921719f, 
    0.00189148f, -0.01415831f, 0.13199504f, -0.16302788f, 0.51834249f, 0.07670030f, 0.27670211f, -0.29273430f, 
    -0.08498930f, -0.03344521f, -0.00348630f, 0.02394116f, -0.03867096f, -0.13987686f, -0.08492409f, -0.00677352f, 
    0.15944543f, -0.03219158f, 0.36482337f, -0.05388007f, -0.04156127f, 0.13527209f, 0.15935507f, -0.04348756f, 
    -0.02796599f, -0.04205083f, 0.14142519f, 0.00534374f, -0.00453847f, 0.22377050f, -0.03552306f, 0.03795604f, 
    -0.05342557f, 0.12948304f, -0.15136811f, -0.01103173f, -0.24119781f, -0.09382157f, -0.18311228f, -0.07250743f, 
    0.15801626f, 0.13019218f, 0.13686736f, -0.09387125f, -0.02227967f, -0.03772666f, -0.01252900f, 0.32450610f, 
    -0.03426399f, -0.03585043f, 0.04053778f, -0.06348342f, -0.13756554f, 0.06745122f, 0.05613634f, -0.10274457f, 
    0.01498096f, -0.03010084f, 0.10489368f, -0.21529873f, -0.03872243f, 0.09967130f, -0.22142994f, -0.01423095f, 
    0.01921005f, 0.06263869f, 0.00928737f, -0.07127760f, 0.04670155f, -0.12733194f, -0.01528650f, -0.03506595f, 
    0.16946787f, 0.00770911f, -0.00050904f, 0.07749856f, 0.09255723f, -0.08943055f, -0.07904179f, -0.06619955f, 
    -0.03462728f, -0.04896004f, 0.07625409f, -0.02963070f, -0.11974613f, -0.05734917f, -0.05502374f, 0.08730881f, 
    0.29734036f, -0.16714300f, -0.12535350f, -0.00237468f, -0.10161960f, 0.01730335f, -0.09309215f, 0.04997237f, 
    0.09235050f, 0.02766849f, -0.17574510f, -0.12847371f, -0.16222309f, 0.14944027f, 0.06680588f, -0.10179719f, 
    -0.04164417f, -0.03969662f, -0.06731733f, 0.00478339f, -0.03913372f, -0.13747218f, -0.10514063f, -0.11931979f, 
    -0.15473706f, 0.11718274f, 0.12427201f, 0.11875877f, 0.01742490f, 0.05827566f, -0.02951047f, 0.14386126f, 
    -0.03792698f, -0.02830994f, 0.04695291f, 0.13113189f, 0.26853615f, 0.01896615f, 0.04608259f, 0.02098964f, 
    -0.03905918f, 0.04358586f, -0.08671451f, 0.15391752f, -0.01220550f, 0.06127414f, 0.02278587f, 0.04179547f, 
    -0.19761750f, 0.28415167f, 0.13760570f, 0.05173159f, -0.00419103f, -0.06010990f, 0.06104603f, 0.07310314f, 
    -0.13782836f, -0.07910912f, -0.04730486f, 0.16215067f, -0.11611064f, 0.11712320f, 0.06424376f, 0.07070506f, 
    0.12331466f, 0.02703377f, -0.02956180f, 0.06945181f, -0.03280738f, -0.10801834f, -0.13332635f, -0.11572553f, 
    -0.09635927f, 0.04554997f, 0.16622053f, 0.00840819f, 0.00753675f, -0.15940550f, -0.09727862f, -0.00468491f, 
    0.01440453f, 0.05264279f, -0.11035273f, 0.01950837f, -0.21613470f, 0.16804746f, -0.03637545f, 0.32931098f, 
    0.06227554f, -0.02407209f, 0.07150561f, 0.04789424f, 0.02236178f, 0.05438136f, -0.04516539f, 0.08287261f, 
    0.04512822f, -0.09789163f, 0.14501525f, 0.04698613f, 0.06088060f, -0.04181541f, -0.00793079f, -0.11103494f, 
    -0.07970092f, 0.00877827f, 0.15488771f, 0.05594736f, -0.22887434f, -0.13342606f, -0.11324885f, 0.37066466f, 
    0.06296863f, 0.05153610f, -0.00435178f, -0.08002344f, 0.06094769f, -0.03064310f, 0.04216307f, -0.05837019f, 
    -0.06956954f, 0.05742235f, -0.05952293f, 0.04957620f, -0.05673775f, -0.06826519f, 0.00115812f, -0.08234194f, 
    0.05929443f, -0.07138589f, -0.07762213f, 0.01341961f, -0.01561277f, 0.01027123f, -0.02574791f, 0.04926074f, 
    -0.05789949f, -0.00969260f, 0.03887012f, -0.02541429f, 0.05842740f, -0.07943287f, 0.06135751f, 0.01109007f, 
    -0.04667758f, -0.05280828f, 0.05715760f, 0.04636883f, -0.06970393f, -0.05396490f, 0.01073392f, 0.04260113f, 
    -0.01019042f, 0.00295435f, 0.04705052f, -0.00276353f, -0.00426364f, 0.00898930f, -0.08176076f, -0.03433410f, 
    -0.07493290f, 0.05879878f, -0.07701296f, -0.00838987f, -0.01858523f, -0.00247554f, -0.06673869f, 0.05529566f, 
    0.04950437f, -0.02127050f, -0.07921458f, -0.01121275f, 0.01233513f, 0.03620394f, -0.04842634f, -0.07460827f, 
    0.04850226f, -0.02636228f, 0.05739170f, 0.01281225f, -0.00090783f, 0.01387070f, 0.03374620f, -0.01067454f, 
    0.03360296f, -0.06369413f, 0.04477910f, -0.03359873f, 0.00321207f, 0.05706995f, 0.01496468f, -0.04590540f, 
    0.04108110f, -0.05465718f, 0.02397625f, -0.00467884f, -0.01873827f, -0.01198280f, 0.01197599f, 0.05505504f, 
    0.02504544f, 0.02680587f, 0.00817015f, -0.03485785f, -0.00197066f, 0.02396681f, -0.00944947f, 0.00320602f, 
    0.02112525f, -0.01166590f, -0.02589767f, 0.00853773f, -0.02836694f, 0.04803414f, -0.06307231f, 0.04129411f, 
    -0.06089948f, 0.05549622f, -0.07035591f, 0.00859541f, -0.00692516f, 0.02436815f, -0.04049369f, -0.01481138f, 
    0.00824142f, 0.05210095f, 0.03370446f, 0.03428485f, -0.05358598f, 0.04255374f, -0.01655371f, 0.04734789f, 
    -0.06283676f, -0.03647613f, 0.01224494f, 0.04037252f, 0.03568677f, -0.07459858f, -0.02647983f, -0.06840315f, 
    -0.02741827f, -0.07127140f, -0.03054138f, -0.00848170f, -0.02017911f, -0.02629304f, -0.03037087f, -0.01904939f, 
    -0.05877189f, -0.04060305f, 0.03510241f, -0.02130196f, -0.02128680f, 0.01031982f, -0.02294225f, 0.04438919f, 
    0.00261946f, -0.03461017f, 0.04640706f, -0.01226268f, 0.02664915f, -0.02446173f, 0.02162355f, -0.02328235f, 
    -0.06557740f, -0.00641048f, 0.01490551f, 0.02546855f, 0.03303213f, -0.03545457f, 0.00620222f, -0.02734677f, 
    -0.05763536f, 0.03796707f, -0.05401101f, -0.05568735f, 0.06377076f, -0.07201813f, -0.03499772f, -0.01428263f, 
    -0.08446749f, 0.01021313f, 0.03115229f, 0.04679696f, 0.00729421f, -0.02849196f, 0.00023486f, 0.01865784f, 
    -0.05971979f, -0.00880527f, -0.04684558f, -0.04863261f, 0.03281718f, -0.08355797f, -0.07377119f, -0.03329508f, 
    0.01275278f, -0.03715355f, -0.08155480f, 0.05283622f, 0.01501387f, 0.03280001f, -0.06172092f, -0.04866788f, 
    -0.04272463f, -0.02967701f, -0.01529192f, -0.05559637f, -0.07993965f, 0.01176614f, 0.02600948f, 0.03859138f, 
    -0.13621710f, 0.11216080f, 0.04555224f, 0.12507327f, 0.09704615f, -0.05217936f, 0.25647116f, -0.07682767f, 
    -0.04688011f, 0.21199858f, -0.06838534f, 0.10915607f, -0.29061559f, -0.13116226f, 0.10798147f, 0.10282612f, 
    0.01675528f, 0.08551195f, -0.05675082f, 0.06785944f, -0.09261633f, -0.06370004f, -0.03084787f, -0.05353774f, 
    0.00466485f, 0.26466033f, 0.00250504f, 0.31212381f, -0.02832559f, 0.03908665f, 0.28892705f, -0.02975858f, 
    0.06420080f, 0.01279930f, -0.15044929f, -0.11466818f, 0.37098873f, -0.07179738f, 0.18538396f, 0.14313589f, 
    0.15364227f, 0.22886208f, 0.09261660f, 0.09056134f, -0.08756948f, -0.09278471f, 0.04384441f, 0.14643581f, 
    0.09635001f, -0.04371325f, -0.04087215f, -0.14270426f, -0.03388108f, -0.05480053f, 0.08101948f, -0.07361879f, 
    0.21946624f, 0.17732407f, 0.08459960f, 0.16162558f, -0.04513806f, -0.01345727f, -0.16867632f, -0.28906831f, 
    -0.02532530f, -0.02223255f, -0.02826764f, 0.00066074f, 0.05382123f, 0.09527919f, 0.02014251f, -0.09665168f, 
    -0.10420704f, -0.13279599f, 0.15753864f, -0.20582932f, 0.00335669f, 0.05371544f, -0.13816658f, -0.06624297f, 
    -0.13101885f, 0.19174127f, 0.35960490f, 0.26301160f, -0.08577529f, -0.13517827f, -0.11883165f, 0.01286674f, 
    -0.01734607f, -0.13915902f, 0.07730337f, -0.07237858f, -0.04876999f, 0.06408145f, 0.07204244f, 0.02879266f, 
    0.21030945f, -0.07173590f, 0.02089901f, 0.06553620f, -0.01397934f, -0.05651489f, -0.02164772f, 0.03825908f, 
    -0.00803148f, -0.03879492f, -0.06926562f, -0.06848440f, 0.18254167f, 0.30032647f, 0.08614784f, -0.09957670f, 
    -0.07444794f, 0.03440544f, 0.06638906f, 0.11402868f, 0.00392485f, -0.03317913f, -0.01675041f, -0.03499298f, 
    0.35368639f, 0.22290146f, -0.21341608f, 0.19236761f, 0.05857818f, -0.12160879f, 0.14277615f, -0.02762908f, 
    0.07255821f, 0.01346886f, -0.05016940f, 0.00708804f, 0.15489589f, -0.12061183f, -0.29951206f, 0.15283464f, 
    -0.03158696f, -0.33951849f, 0.05026394f, 0.02838697f, -0.04099899f, 0.02043629f, -0.06243085f, -0.05984766f, 
    -0.01522446f, -0.19566074f, -0.24663311f, 0.06385941f, -0.07744019f, 0.07808939f, -0.11717105f, 0.05547238f, 
    0.09485546f, -0.06119106f, 0.04489275f, -0.04656208f, -0.17456843f, -0.08279652f, -0.04868805f, 0.10127615f, 
    -0.01183377f, -0.06891123f, 0.13642927f, 0.02399246f, 0.07047559f, 0.01051174f, 0.27087644f, -0.07541802f, 
    -0.01547851f, -0.23918229f, 0.00454042f, -0.06442913f, 0.11896036f, 0.13627367f, -0.05237116f, -0.06071287f, 
    0.02204094f, 0.04436825f, -0.04896941f, 0.04874479f, 0.12067287f, 0.26196918f, -0.33988291f, -0.12423447f, 
    0.09755100f, -0.09389948f, -0.02474247f, -0.08155235f, 0.06328310f, 0.05244813f, 0.17524666f, 0.16322149f, 
    0.00630403f, -0.09820548f, 0.13918282f, 0.12787876f, -0.05989165f, 0.08426272f, -0.25485367f, 0.06248311f, 
    -0.12076614f, -0.01360375f, 0.01911755f, 0.12181257f, -0.07624502f, 0.08543039f, -0.03049581f, 0.14946365f, 
    -0.01019357f, -0.12041319f, -0.06901933f, -0.08540552f, 0.10490455f, 0.11505266f, 0.13324113f, 0.07164699f, 
    -0.17022446f, -0.24589142f, -0.14907929f, 0.03016197f, 0.13025008f, 0.13936192f, -0.06105326f, 0.07944365f, 
    0.03158152f, 0.07736193f, -0.11066777f, 0.06996059f, 0.30819455f, -0.03422281f, 0.05132644f, 0.07005317f, 
    -0.03853619f, -0.00487250f, 0.02992966f, 0.06474744f, 0.09196793f, -0.03798565f, -0.10999621f, 0.04331119f, 
    -0.06342714f, -0.07495451f, 0.17076823f, 0.05926177f, -0.09560153f, -0.04514238f, -0.04642453f, 0.09973525f, 
    -0.09625935f, 0.00933818f, -0.07746568f, -0.23364532f, -0.05453027f, -0.06973946f, -0.15326229f, 0.00059593f, 
    -0.11631183f, -0.01173915f, 0.03000954f, 0.10859152f, -0.13788751f, -0.16710317f, -0.05960119f, -0.00920819f, 
    -0.32312876f, -0.16101119f, -0.22462304f, -0.01740048f, 0.13453919f, 0.02258354f, -0.07089049f, 0.14020312f, 
    0.12072532f, 0.05106370f, -0.00773746f, 0.00046859f, 0.13961120f, 0.03222116f, -0.08474562f, 0.02729871f, 
    0.12996542f, 0.12960233f, 0.05987638f, -0.05293521f, -0.08979801f, -0.02389845f, -0.03519865f, 0.04120968f, 
    0.15780756f, -0.03767198f, -0.06054520f, -0.02113579f, 0.08213067f, 0.06397722f, 0.17546770f, 0.15489523f, 
    -0.06269734f, -0.03347341f, 0.05950164f, 0.03767490f, -0.23878504f, -0.47794840f, 0.04819369f, 0.05315157f, 
    -0.03754937f, -0.06854840f, 0.07573906f, -0.04128507f, -0.03594540f, -0.06685071f, 0.09165214f, -0.00364455f, 
    -0.13869926f, -0.03907481f, -0.09470002f, 0.04501596f, -0.10327808f, -0.11847310f, -0.06201910f, -0.01295260f, 
    0.07511210f, 0.07508260f, 0.19421907f, -0.01050641f, 0.26422316f, 0.31956616f, 0.16772592f, -0.04723773f, 
    0.24210839f, 0.15736561f, 0.20296679f, 0.13350902f, 0.12067715f, 0.05584853f, -0.09741643f, 0.00191788f, 
    0.21630804f, 0.27455619f, 0.08039688f, -0.10836390f, 0.00473694f, 0.11244553f, -0.06659593f, -0.03282006f, 
    0.00149332f, 0.02238543f, -0.07382583f, 0.02816972f, -0.19778520f, 0.08692411f, -0.17764421f, -0.31657007f, 
    0.06684308f, 0.11207579f, -0.01722887f, 0.04279337f, -0.04164845f, -0.02405894f, -0.04677694f, -0.05002620f, 
    0.12620324f, 0.12261999f, 0.15881756f, 0.19232240f, 0.09071185f, -0.01256329f, -0.00295702f, -0.01272704f, 
    -0.11708566f, 0.02114076f, -0.04184231f, -0.26755679f, 0.22266991f, 0.44105008f, 0.10409068f, -0.33940890f, 
    -0.00701734f, 0.00996069f, 0.10911725f, -0.06345341f, 0.00723594f, -0.10555886f, -0.06188164f, -0.00382207f, 
    0.06520097f, -0.13955028f, -0.29616034f, -0.26907080f, -0.00695392f, 0.05992055f, 0.04662400f, 0.37043813f, 
    -0.10862210f, -0.09293438f, -0.15550929f, -0.07487896f, -0.09656233f, -0.14725998f, -0.43673193f, -0.08205049f, 
    -0.03241009f, 0.14217164f, -0.04977060f, -0.24731541f, -0.10174251f, -0.29525384f, -0.07570130f, -0.28612843f, 
    0.09478930f, -0.02706139f, 0.06337797f, 0.18226625f, 0.12042411f, -0.05984855f, 0.10355464f, 0.07280635f, 
    -0.25545523f, 0.01415135f, -0.13074538f, -0.05203701f, 0.05580242f, -0.04134882f, -0.00958597f, 0.16371007f, 
    0.02781211f, -0.04663831f, -0.05587301f, -0.02264612f, 0.21310166f, -0.16209188f, -0.03061481f, 0.07944526f, 
    0.18321550f, 0.00830986f, 0.13219967f, 0.21448241f, -0.00910599f, -0.03156219f, -0.04771754f, 0.17458792f, 
    0.23174661f, 0.08767077f, -0.00702779f, 0.29713500f, -0.16918540f, 0.00818365f, 0.05479188f, 0.14667022f, 
    -0.11612592f, -0.00834578f, -0.14166802f, -0.23232239f, 0.11032613f, 0.06552400f, 0.18346021f, 0.19986352f, 
    -0.21303339f, 0.05953638f, -0.03932589f, 0.34317499f, 0.14264363f, -0.07658321f, -0.06204107f, -0.03105545f, 
    -0.11614859f, 0.02251791f, -0.00439095f, -0.09329992f, 0.10556041f, 0.04780571f, 0.13244060f, 0.24759571f, 
    0.10358754f, 0.16970336f, -0.00026858f, -0.07474218f, 0.08452653f, 0.08839422f, 0.06730988f, 0.11062514f, 
    0.20617062f, 0.02675573f, 0.01587923f, -0.10895777f, 0.26522213f, 0.07997026f, 0.04721913f, -0.01313247f, 
    0.11242007f, 0.08825169f, 0.09853293f, 0.03376674f, -0.23284954f, -0.17342825f, -0.18638469f, 0.10846923f, 
    0.04862393f, -0.13703391f, -0.07621723f, -0.00403285f, -0.17043601f, -0.26554537f, -0.18650995f, -0.22499336f, 
    -0.19351439f, -0.20333558f, 0.10432968f, -0.25140896f, 0.04203749f, 0.09694371f, -0.16357093f, -0.46150914f, 
    -0.13850525f, -0.13728324f, -0.21574235f, 0.02114194f, 0.22109044f, 0.11934163f, -0.05053473f, -0.02000223f, 
    0.00636787f, -0.04755298f, 0.08943306f, 0.02487953f, -0.06458371f, -0.08875926f, 0.14040573f, -0.14236690f, 
    0.29271400f, 0.11373936f, -0.06879962f, 0.05903200f, 0.02593734f, 0.03335677f, -0.07515561f, 0.09398870f, 
    0.18499246f, 0.07453045f, 0.07648964f, 0.15462801f, 0.22335514f, 0.00727649f, 0.01302928f, 0.03273471f, 
    -0.16135007f, -0.08227340f, -0.34582028f, -0.32028726f, -0.03602419f, 0.11124334f, 0.11918531f, 0.02384478f, 
    -0.08741212f, 0.27467695f, 0.02706836f, 0.18517569f, 0.03983526f, 0.22665852f, 0.04151652f, 0.22395337f, 
    0.04601903f, 0.15513948f, 0.08382054f, 0.04657066f, -0.15332597f, 0.14245442f, 0.09814932f, 0.07674910f, 
    0.09236473f, 0.02768504f, -0.06772741f, -0.11321951f, -0.14723004f, -0.13583675f, -0.14006180f, -0.07937989f, 
    -0.05072608f, 0.10851920f, -0.28416055f, -0.14470640f, -0.04934372f, -0.12177189f, 0.00284410f, 0.14892949f, 
    -0.02777850f, 0.19019796f, 0.08052973f, 0.09903801f, -0.09509391f, -0.15636235f, 0.02514115f, -0.17548002f, 
    0.10274949f, -0.17611703f, -0.10674963f, -0.10265628f, 0.09084525f, 0.11164881f, -0.10083286f, 0.07459678f, 
    -0.24846318f, -0.24068271f, -0.14092074f, -0.11785248f, 0.36666358f, 0.13149431f, 0.08365760f, 0.13884772f, 
    -0.03022500f, 0.06675897f, -0.02917631f, 0.01931431f, -0.06591349f, 0.05338129f, 0.01684156f, 0.28583029f, 
    0.08378611f, 0.20100644f, -0.06749292f, 0.09985278f, 0.18571059f, -0.04001568f, 0.09183425f, 0.02290884f, 
    0.00618156f, -0.06054768f, -0.08380768f, -0.03641787f, 0.03482440f, 0.03692320f, -0.04544359f, 0.05491244f, 
    0.15139240f, 0.03227372f, 0.16338865f, 0.02037742f, -0.00762583f, 0.02866435f, -0.03890305f, -0.02277781f, 
    0.05249463f, 0.04343627f, -0.02118385f, 0.08658145f, 0.01620160f, 0.02660432f, 0.01950050f, 0.12515861f, 
    -0.05465525f, -0.15599136f, -0.15176646f, -0.19057971f, -0.06656561f, 0.01750873f, 0.03576585f, -0.02059518f, 
    0.05918146f, -0.14119588f, 0.17866158f, 0.07696275f, -0.30819121f, -0.08288241f, 0.06543945f, -0.08554672f, 
    0.03694796f, -0.00151896f, -0.03443237f, 0.12684427f, -0.15043034f, -0.07910028f, 0.02762175f, 0.12114945f, 
    -0.33276913f, 0.02716757f, 0.00074107f, 0.06365210f, -0.07097044f, 0.08124701f, 0.07708725f, 0.24716245f, 
    -0.10884041f, 0.03041139f, 0.15831849f, 0.14903744f, -0.12814085f, -0.06913029f, -0.06105852f, 0.00002154f, 
    0.07347989f, 0.09287088f, 0.14454125f, 0.03291827f, -0.10033115f, -0.04301075f, 0.00151499f, -0.06490890f, 
    0.07881464f, -0.28909618f, 0.17055818f, 0.10724198f, 0.13394229f, -0.00685258f, 0.00764924f, 0.13631229f, 
    0.06903188f, 0.00123667f, 0.10040838f, 0.00088936f, -0.00207350f, -0.23966847f, 0.04470440f, -0.31732026f, 
    0.05711395f, -0.02422919f, 0.02183364f, -0.00226325f, 0.05885331f, -0.03471012f, -0.10806973f, -0.05088974f, 
    0.04836176f, -0.18068628f, 0.17690840f, 0.10462961f, 0.14860271f, -0.19109364f, -0.02265747f, -0.01672232f, 
    -0.11196131f, -0.06087511f, -0.02419502f, -0.04205354f, -0.11502153f, -0.05881948f, 0.33129731f, 0.13209943f, 
    -0.02392408f, 0.01464111f, 0.00283362f, 0.12233928f, -0.05358319f, 0.02245274f, 0.04330431f, 0.02028176f, 
    0.00583513f, -0.03148028f, -0.18688111f, -0.20405449f, 0.07521614f, 0.10182134f, 0.09004877f, -0.20908116f, 
    0.09914911f, -0.05270719f, 0.00544289f, -0.07384875f, 0.31061924f, 0.01525782f, 0.30637699f, 0.03973695f, 
    0.12161439f, -0.13206333f, -0.06800147f, 0.07297084f, 0.01913162f, -0.04776127f, 0.03887232f, -0.09442252f, 
    0.21313207f, 0.29075092f, 0.22080520f, -0.00236433f, -0.09172164f, 0.11925158f, 0.14359787f, 0.01346690f, 
    -0.17982794f, -0.07874299f, 0.11973817f, -0.16410521f, 0.07842152f, 0.09485094f, 0.01702522f, 0.12738869f, 
    0.03181750f, 0.09872305f, 0.10961334f, -0.13225240f, -0.17073025f, -0.22978958f, -0.07233035f, -0.03266535f, 
    -0.40037718f, -0.07738108f, 0.15856527f, -0.07828917f, 0.02620075f, 0.01735391f, -0.01484510f, 0.11190890f, 
    -0.19506577f, -0.11953338f, 0.07826018f, 0.01611427f, -0.14383459f, 0.12753086f, 0.15686618f, 0.06740236f, 
    0.02091181f, 0.09897852f, 0.01434691f, -0.14789455f, 0.02028077f, 0.01147393f, -0.07922307f, 0.08809660f, 
    0.07401514f, 0.11801600f, 0.11897927f, 0.18960048f, 0.01097063f, 0.02719074f, -0.00676125f, -0.20088749f, 
    0.13563508f, 0.05788353f, -0.01633995f, 0.46330604f, 0.07990980f, 0.09280298f, 0.12977660f, -0.10104385f, 
    -0.04562052f, -0.03042102f, -0.06187310f, -0.26140806f, 0.11502331f, 0.04874200f, 0.07511913f, 0.11427199f, 
    -0.00959216f, 0.15594827f, -0.06222387f, 0.17796154f, -0.09650887f, -0.09017194f, 0.06261413f, -0.17239635f, 
    0.11793621f, -0.04701658f, -0.06602041f, 0.07586923f, -0.11514986f, 0.04915928f, 0.12456252f, 0.14558339f, 
    -0.06688699f, 0.04533492f, 0.05386954f, -0.02935269f, 0.12144964f, 0.00112326f, 0.05488233f, 0.06976462f, 
    0.06900616f, -0.01243958f, -0.18284555f, 0.04796910f, 0.08430239f, 0.17558706f, 0.02158182f, 0.12410666f, 
    0.07295433f, 0.09788789f, 0.02502887f, 0.04794170f, 0.01789826f, -0.05068358f, -0.14120777f, -0.06136746f, 
    -0.05365543f, -0.14388567f, -0.02750730f, -0.12180302f, -0.15820459f, -0.20861565f, -0.13974565f, -0.13912974f, 
    -0.03590302f, -0.05107659f, 0.34243751f, -0.32688379f, -0.13846293f, 0.22763111f, 0.11025690f, -0.24718617f, 
    -0.20544127f, -0.06022238f, -0.06381751f, 0.11566099f, -0.10024869f, 0.01969516f, 0.12469938f, 0.10936231f, 
    0.06493136f, 0.12005370f, -0.10708693f, -0.03561290f, 0.03913522f, 0.13649805f, -0.03630673f, -0.16460653f, 
    0.15949316f, 0.26151699f, -0.09794948f, -0.03832303f, -0.02909268f, 0.15994319f, 0.02058450f, 0.03650279f, 
    0.00649263f, 0.18825148f, -0.11680507f, 0.07390039f, 0.54434913f, 0.39383253f, 0.07548574f, -0.06295476f, 
    -0.23305704f, -0.15415759f, -0.12026072f, -0.16339536f, 0.10216194f, 0.09944698f, -0.08585336f, 0.02928625f, 
    -0.16024783f, 0.10755353f, 0.13602751f, 0.21628588f, 0.02795325f, 0.04012969f, 0.03087103f, 0.03930997f, 
    0.04395339f, -0.00689833f, 0.19584973f, -0.03182304f, 0.03558815f, -0.10485567f, 0.15295260f, 0.27659169f, 
    0.02386168f, -0.04394870f, 0.05774880f, -0.21612817f, 0.01629371f, -0.08087100f, -0.07697308f, 0.00996807f, 
    0.22185518f, 0.04000900f, 0.19415070f, -0.00493680f, -0.02672351f, 0.02680298f, -0.00155903f, 0.10122523f, 
    0.01569649f, 0.03742607f, 0.25022230f, -0.03398810f, 0.11224965f, 0.20310836f, 0.24527879f, 0.02618001f, 
    -0.26008055f, -0.01118098f, 0.09384900f, 0.07400120f, 0.05491043f, 0.07734235f, 0.18126793f, 0.06925444f, 
    0.07061435f, -0.02694092f, 0.08706536f, -0.24212405f, -0.01075499f, -0.00456214f, -0.26043412f, 0.12489989f, 
    0.00454467f, -0.03231230f, 0.10682945f, -0.05825065f, -0.39649710f, 0.17506750f, -0.00831692f, -0.15032084f, 
    0.01699489f, -0.06322002f, 0.12727338f, -0.04523095f, 0.01565619f, 0.21281584f, -0.08456042f, -0.11538272f, 
    -0.01847787f, -0.10851073f, -0.07688215f, 0.04931509f, 0.06204799f, 0.05668414f, -0.02898714f, -0.08109584f, 
    -0.08370424f, -0.12795150f, -0.07512261f, -0.18536611f, 0.08936815f, 0.03219796f, 0.06512903f, 0.04624565f, 
    0.02267728f, 0.08846521f, 0.02816748f, 0.00324388f, -0.02608527f, 0.05536313f, 0.03680111f, 0.00334363f, 
    0.29771802f, 0.18749325f, -0.16549276f, 0.03967776f, -0.02179662f, -0.02732432f, 0.09463929f, 0.04777222f, 
    0.18910189f, -0.09621742f, -0.26730895f, 0.08758064f, -0.07743391f, 0.06385343f, 0.13596836f, -0.01444177f, 
    0.08832379f, 0.03895675f, 0.05373283f, 0.12057380f, 0.03631848f, 0.07321384f, -0.13124052f, -0.05021182f, 
    -0.23301472f, 0.10000517f, 0.04072741f, 0.08745531f, 0.06249306f, 0.04603818f, -0.02322119f, 0.16554697f, 
    0.00717680f, -0.02496341f, -0.11025364f, 0.14066757f, 0.22067808f, 0.00892773f, -0.02917293f, 0.06761874f, 
    -0.15972804f, -0.15256794f, -0.03864730f, -0.06468038f, -0.00359112f, 0.04329371f, -0.02990083f, 0.09443939f, 
    -0.06927505f, 0.10146558f, 0.23405322f, 0.06539063f, -0.02298680f, 0.01597685f, -0.02402594f, 0.12892343f, 
    0.00603369f, 0.03394800f, 0.26843938f, 0.04911666f, -0.14215966f, 0.04289032f, 0.36498782f, 0.06840036f, 
    -0.02382162f, 0.23038857f, -0.10507151f, -0.08078940f, 0.05955805f, 0.05137247f, 0.12294357f, 0.04422968f, 
    -0.26726055f, -0.07094783f, 0.18515222f, 0.03615234f, 0.01606615f, 0.03141700f, 0.04945125f, 0.14407320f, 
    0.03081761f, 0.00670817f, 0.08148327f, -0.10653629f, 0.18624185f, -0.06069053f, -0.25285557f, -0.26891637f, 
    -0.03121346f, 0.04082966f, -0.10959136f, 0.04072499f, 0.08009248f, 0.08398679f, -0.12600884f, -0.19282569f, 
    -0.00147300f, 0.14087461f, 0.11704128f, 0.21672668f, -0.09464347f, -0.06699780f, 0.04848471f, 0.07390404f, 
    -0.01445387f, -0.25975493f, -0.01092605f, -0.10730852f, 0.05741780f, -0.37085629f, 0.28986153f, 0.07244903f, 
    -0.06209470f, 0.02291384f, 0.04719127f, 0.03341542f, 0.11448051f, 0.01206243f, -0.01661279f, -0.01847809f, 
    0.04442696f, -0.03176280f, -0.07523029f, 0.01137198f, 0.04756987f, -0.03676453f, 0.04962336f, 0.05206978f, 
    -0.07675495f, -0.02030082f, 0.01829886f, -0.07339723f, 0.04089829f, -0.02023980f, -0.04163468f, 0.03584489f, 
    -0.05008230f, -0.01588059f, -0.03775929f, -0.00296591f, -0.03241844f, -0.01391909f, -0.03467427f, -0.07039103f, 
    0.01703986f, 0.03442194f, 0.00848872f, 0.04204202f, 0.00173690f, 0.00205518f, -0.00424697f, 0.04718547f, 
    0.02003931f, -0.02163522f, -0.05776503f, 0.06921724f, -0.00580942f, 0.00066395f, -0.01356392f, 0.05587699f, 
    -0.01339754f, -0.07069853f, 0.05099234f, -0.05143706f, 0.00048814f, 0.05955644f, -0.05520751f, -0.04843525f, 
    -0.00758140f, -0.01605742f, -0.01779410f, 0.01869590f, -0.06525936f, -0.03991962f, 0.03239086f, 0.03657435f, 
    0.02276708f, 0.04922821f, -0.02598339f, 0.05228279f, 0.04490598f, -0.04891501f, -0.04924392f, 0.02068756f, 
    0.02951375f, 0.04838063f, -0.05888820f, -0.07689946f, 0.03474917f, 0.03937524f, 0.05650862f, 0.01418074f, 
    0.01158682f, 0.01987430f, -0.05740262f, -0.04536065f, -0.01848215f, 0.02464945f, 0.00287848f, -0.07288546f, 
    0.02576730f, -0.01391863f, -0.05238886f, -0.01516946f, -0.03307731f, -0.05548714f, 0.03432105f, -0.00895001f, 
    -0.03832938f, -0.01096063f, -0.07021919f, -0.03489974f, -0.07121167f, 0.03836265f, 0.05881210f, 0.04060702f, 
    -0.02467563f, 0.03594655f, 0.00680891f, 0.03852232f, 0.06124124f, 0.03123953f, 0.01476080f, 0.04996560f, 
    0.05006715f, -0.00787058f, -0.07035899f, -0.03742297f, -0.03710675f, -0.04508957f, -0.06234568f, 0.00688856f, 
    -0.05487073f, -0.05615357f, -0.01687817f, -0.01776723f, 0.01267811f, 0.01043953f, -0.01826650f, 0.00316397f, 
    0.01745353f, -0.06297233f, 0.05026956f, -0.05691691f, 0.02281108f, 0.05928671f, -0.07606026f, -0.04540275f, 
    -0.07026558f, -0.01043615f, -0.05278892f, -0.07898762f, -0.01692367f, -0.06132947f, 0.01169816f, 0.00810000f, 
    -0.04069299f, -0.06928761f, 0.04552352f, -0.04091273f, -0.07453053f, 0.00369044f, 0.05537747f, 0.04155382f, 
    -0.01493252f, 0.04196693f, -0.06053764f, -0.04163051f, 0.05796647f, -0.03694463f, -0.02272513f, -0.01044014f, 
    -0.03245096f, -0.02168704f, -0.06282096f, 0.01153736f, 0.03186110f, 0.01895290f, 0.01559462f, 0.05398038f, 
    0.06539523f, 0.03129724f, -0.04265886f, -0.06955776f, 0.03192085f, -0.02857344f, 0.00960863f, 0.00759386f, 
    -0.05087238f, -0.04944947f, 0.06117376f, 0.00997210f, -0.07380749f, -0.04970277f, -0.07363558f, -0.05561552f, 
    -0.06222864f, 0.02440487f, 0.01589358f, 0.00870803f, -0.07907249f, -0.07619745f, -0.06579684f, -0.07140726f, 
    0.04876402f, -0.02528937f, -0.02404707f, 0.05873245f, -0.00813903f, 0.05424692f, -0.00122520f, 0.05874345f, 
    0.08308447f, -0.04149358f, 0.12252999f, 0.05352999f, 0.02605502f, 0.09614093f, -0.02689692f, -0.13839966f, 
    0.20153804f, 0.05107089f, 0.10110518f, 0.06450648f, 0.10310519f, 0.02671753f, -0.08784346f, 0.07479027f, 
    0.03657262f, -0.05068044f, 0.04992141f, -0.06497926f, -0.12221640f, 0.00703944f, -0.04631409f, -0.10650121f, 
    0.05170257f, -0.03891748f, -0.11354746f, -0.10961082f, -0.06178162f, 0.01643413f, -0.13076438f, 0.07720288f, 
    -0.07220283f, -0.11662053f, 0.01295385f, -0.09922095f, -0.24576338f, 0.10573445f, 0.10969371f, -0.24637096f, 
    0.15629187f, 0.03392462f, 0.00258035f, -0.17826080f, 0.02025077f, 0.02533950f, -0.06327914f, -0.12294345f, 
    -0.13753437f, -0.12263840f, 0.00587256f, -0.23142961f, -0.07269388f, 0.05893594f, -0.00408496f, 0.00083775f, 
    -0.09143325f, 0.01391312f, 0.05244780f, 0.16676383f, -0.12103962f, -0.11415499f, -0.01030095f, 0.07342280f, 
    0.03661660f, -0.03979108f, -0.01508096f, -0.03893909f, -0.03874733f, -0.02507185f, 0.03326298f, 0.02445055f, 
    0.14854917f, -0.24150364f, 0.00637952f, -0.02307799f, -0.14179881f, -0.12965374f, 0.05379341f, -0.12972790f, 
    -0.17421289f, 0.07202903f, -0.03737672f, 0.12051284f, 0.21305265f, 0.18863560f, 0.10654229f, -0.15284239f, 
    -0.04769908f, 0.02258531f, 0.06469583f, 0.04801358f, 0.08382317f, -0.19173533f, -0.13056907f, -0.11519524f, 
    -0.01162670f, 0.30511364f, 0.15279135f, 0.00353550f, 0.07184307f, 0.04948350f, -0.02867352f, -0.00375479f, 
    0.00581212f, -0.01086747f, -0.04438162f, -0.07920387f, -0.06949598f, -0.11748980f, 0.00256017f, -0.00970314f, 
    0.03348932f, -0.02420585f, -0.01677238f, 0.07126461f, -0.07877109f, -0.05926075f, -0.03524172f, -0.08244977f, 
    -0.01201583f, 0.00382601f, -0.01909312f, -0.13528328f, -0.00097815f, 0.14974162f, 0.08665432f, 0.01533919f, 
    -0.05062362f, -0.05404171f, 0.13773541f, 0.07068060f, -0.08457001f, 0.19817357f, -0.03497948f, -0.24516727f, 
    0.04152408f, 0.10147912f, -0.11140575f, 0.06452242f, 0.06325707f, -0.15578432f, 0.09870679f, -0.06526659f, 
    -0.17525074f, 0.22970200f, 0.01634956f, 0.07925739f, -0.06522827f, -0.03575558f, 0.14169057f, -0.03179184f, 
    0.05087759f, -0.03942094f, -0.03974014f, 0.00512432f, 0.09137666f, 0.14471069f, 0.09510848f, 0.25051847f, 
    -0.12931794f, 0.02927074f, -0.00011493f, 0.04419618f, 0.02195629f, 0.08141782f, 0.01603029f, -0.03011804f, 
    0.17606579f, -0.08621179f, -0.13150199f, -0.20547692f, -0.08414976f, -0.06320821f, -0.00844954f, 0.01584572f, 
    -0.05613570f, -0.04082407f, -0.17394531f, 0.00113448f, -0.12102710f, -0.12127329f, -0.00618129f, 0.35862038f, 
    -0.08636173f, 0.11651897f, 0.06023637f, -0.02571604f, 0.00788757f, 0.02257501f, 0.00193623f, 0.00268934f, 
    -0.08517683f, -0.21260272f, -0.06993563f, -0.14592661f, 0.00481925f, -0.04889628f, 0.02075034f, -0.00837432f, 
    -0.16316463f, 0.04316133f, 0.12631857f, -0.16355373f, 0.02752851f, 0.07887220f, -0.08428251f, -0.04957493f, 
    0.01663961f, -0.09921008f, -0.17629509f, -0.14265612f, -0.05370780f, -0.01921560f, -0.27969825f, -0.28124908f, 
    -0.00188250f, -0.41137537f, 0.11712838f, -0.02162597f, 0.10285681f, -0.02540190f, -0.09446342f, 0.01133921f, 
    -0.01353979f, -0.02409582f, -0.01131664f, 0.06215682f, 0.02965923f, 0.09944205f, -0.01858495f, 0.03962838f, 
    -0.10411655f, -0.08081000f, 0.00073421f, 0.03690729f, 0.10488395f, -0.01441945f, 0.04926569f, -0.01963665f, 
    -0.17467432f, -0.00889844f, -0.18465371f, 0.13675795f, 0.09886263f, -0.04273243f, 0.00375896f, 0.10239918f, 
    0.29650918f, 0.03766650f, 0.00205180f, 0.13243243f, -0.13544916f, -0.28454703f, -0.26342165f, -0.03124971f, 
    0.02905131f, 0.07086007f, -0.06671352f, -0.05475472f, 0.08775658f, 0.08300829f, 0.07910291f, 0.32045743f, 
    -0.08014047f, -0.10279243f, -0.22845829f, -0.15184166f, 0.13561916f, -0.14524384f, -0.24604128f, 0.10931009f, 
    0.24814911f, -0.04398797f, -0.09038302f, -0.06449867f, -0.19886212f, 0.15404348f, 0.08129083f, -0.03445706f, 
    0.00209481f, 0.09796168f, 0.00522678f, -0.12964010f, -0.05271262f, -0.08134972f, -0.01280622f, 0.11045321f, 
    -0.13357584f, 0.02208924f, 0.10168184f, 0.11544172f, 0.05708939f, 0.08849386f, 0.13568415f, 0.12252082f, 
    -0.06718536f, 0.01395898f, 0.15871596f, 0.13577732f, -0.20188205f, -0.18732834f, -0.19121447f, 0.13627286f, 
    0.01903318f, -0.08584106f, 0.05274740f, 0.02289838f, -0.02272771f, 0.05611976f, 0.05291498f, 0.03069481f, 
    -0.20974354f, 0.00584823f, -0.11392987f, -0.00280034f, -0.09076831f, -0.00891381f, -0.01011048f, 0.00264978f, 
    0.02249195f, -0.01355559f, 0.04080687f, 0.16370037f, 0.27695426f, 0.11780521f, 0.12879285f, 0.09279726f, 
    0.13939886f, 0.21928042f, -0.00475293f, 0.13955253f, -0.23193911f, -0.10360323f, -0.14082995f, -0.24557617f, 
    0.05711559f, 0.11649002f, 0.31523049f, -0.00283077f, 0.01224257f, -0.06909071f, -0.07875448f, -0.05835792f, 
    0.10619915f, -0.10662708f, 0.11512983f, 0.19354813f, -0.18098412f, -0.04165785f, 0.23107180f, 0.15018526f, 
    -0.16681895f, -0.22441970f, -0.09922821f, 0.08748557f, 0.01939524f, -0.02140793f, 0.02386855f, 0.10430270f, 
    0.06332971f, 0.23320252f, 0.09910690f, 0.13072397f, 0.15789185f, 0.00869074f, 0.14297743f, -0.16347392f, 
    0.01169904f, 0.02718439f, 0.08879199f, -0.02563656f, -0.15968798f, 0.08437980f, 0.19952455f, 0.17645779f, 
    -0.12514357f, -0.00314057f, -0.04239536f, -0.06748835f, -0.09052759f, -0.08469047f, -0.12378695f, 0.00440127f, 
    -0.00103323f, -0.06125805f, 0.00956692f, -0.01773481f, -0.04664789f, 0.01255458f, -0.06491762f, -0.06344779f, 
    -0.04198105f, 0.03173087f, -0.05306942f, -0.03369686f, 0.03528730f, 0.00521875f, -0.00309567f, -0.03233631f, 
    -0.04612320f, -0.01112151f, -0.04904596f, -0.07763787f, 0.04419292f, 0.01787892f, -0.03478358f, 0.01781002f, 
    -0.03534728f, -0.00243763f, 0.02957951f, -0.02279995f, -0.01663481f, -0.06339017f, 0.05618894f, -0.01009228f, 
    0.00675272f, -0.02782926f, 0.02998353f, -0.03802742f, -0.06329323f, -0.01149832f, 0.00456403f, -0.02296241f, 
    0.01856330f, 0.03957096f, 0.03446325f, -0.06180061f, -0.03877477f, -0.07915337f, -0.06130946f, 0.00500817f, 
    0.03565257f, 0.00208639f, -0.01169821f, 0.00881134f, 0.01038323f, 0.00297335f, 0.06355195f, 0.01944776f, 
    0.06313704f, 0.04267424f, -0.01047290f, -0.01367709f, 0.04910814f, -0.00712062f, -0.06650289f, -0.01823213f, 
    0.02970979f, 0.00128444f, -0.05788516f, -0.06159737f, -0.02135508f, -0.06335688f, -0.00670986f, 0.04359341f, 
    -0.01321089f, 0.04331538f, -0.04208441f, -0.02342491f, -0.03360942f, 0.04116280f, -0.07086954f, 0.04720504f, 
    -0.05927852f, -0.07417332f, -0.03667986f, 0.02215916f, -0.01199902f, -0.06514983f, 0.01299546f, -0.06325991f, 
    -0.07851128f, 0.06027911f, -0.04726673f, 0.02688004f, -0.07104967f, -0.07315812f, -0.00142724f, 0.05207636f, 
    0.04887896f, 0.00511605f, 0.04100235f, -0.07129920f, 0.05080458f, -0.06793077f, -0.01760888f, 0.01029618f, 
    0.05790898f, 0.00856268f, -0.03991495f, 0.02885291f, -0.05272444f, -0.05103064f, -0.06158188f, -0.04316518f, 
    0.05638824f, 0.06916725f, -0.02615911f, -0.02517337f, -0.04871824f, -0.02222741f, -0.06697405f, -0.04454288f, 
    -0.03825109f, 0.02470118f, -0.05579451f, 0.04825094f, -0.06797720f, -0.05565128f, 0.01722366f, 0.03845159f, 
    0.01010542f, -0.05411767f, -0.01300155f, -0.05869528f, 0.00555340f, 0.05495973f, 0.04763446f, -0.06261958f, 
    0.03287846f, 0.05583559f, -0.04250669f, -0.02306278f, 0.05259197f, 0.01166527f, 0.00394945f, 0.02539365f, 
    0.01210029f, -0.07692453f, -0.06963468f, -0.08438864f, -0.04817940f, 0.06312535f, 0.04217727f, 0.01900190f, 
    0.03969436f, 0.02469710f, -0.03681546f, -0.02230901f, 0.00609484f, -0.04460590f, 0.00784975f, 0.04930015f, 
    0.05662094f, 0.06031829f, -0.01769059f, -0.05617818f, -0.02878581f, 0.00166177f, 0.07148545f, 0.03323638f, 
    0.03560542f, 0.03380234f, -0.01964790f, -0.01465941f, -0.08132034f, -0.05829267f, 0.06553531f, -0.06858393f, 
    -0.01644144f, -0.02839666f, -0.00304760f, 0.01280653f, -0.01928347f, 0.00126571f, -0.03174421f, 0.02971015f, 
    0.06030495f, 0.03541386f, -0.03591997f, -0.00664233f, 0.05631027f, 0.06028815f, -0.06722243f, -0.07268316f, 
    0.10028799f, -0.04823288f, -0.22645611f, 0.03615683f, 0.09167065f, -0.05714003f, -0.13124748f, 0.15876283f, 
    0.12932791f, 0.07128014f, 0.06111233f, 0.02319896f, -0.15124878f, -0.12398204f, -0.14468154f, 0.11349164f, 
    0.08038396f, 0.28750756f, -0.10192136f, -0.15151311f, 0.27898088f, 0.15453665f, 0.01379919f, 0.17981850f, 
    -0.28530559f, 0.34731501f, -0.08366712f, 0.20419255f, -0.01513595f, -0.02250461f, 0.04904410f, 0.03591966f, 
    0.03417260f, 0.04777170f, 0.17122358f, -0.06517950f, 0.28122196f, -0.05323511f, 0.16059582f, 0.12884101f, 
    0.04197830f, 0.19547150f, 0.02453236f, 0.20848282f, 0.04822440f, -0.01170697f, -0.00997562f, 0.06455988f, 
    0.00275414f, -0.02606745f, 0.34368137f, -0.03118394f, -0.04954048f, -0.03823475f, -0.04859969f, 0.01847883f, 
    -0.08611974f, 0.01950719f, -0.03402236f, -0.20620878f, -0.22963682f, -0.05835655f, 0.07895348f, 0.02934206f, 
    -0.04475718f, -0.06611622f, -0.16294345f, -0.07348661f, -0.05076073f, -0.19673912f, 0.04830838f, 0.07098649f, 
    0.29629126f, 0.06718847f, 0.12799720f, 0.22990647f, -0.06454951f, 0.03856601f, -0.03916168f, -0.09345381f, 
    -0.07646147f, -0.00414790f, -0.12930661f, 0.13623716f, 0.05734175f, 0.08360691f, 0.03913167f, 0.04646125f, 
    0.06313306f, 0.22745433f, 0.07325622f, 0.06439419f, -0.01006234f, 0.00162231f, 0.08675463f, -0.19736086f, 
    0.29543787f, 0.11487565f, -0.00072284f, -0.09898823f, 0.24911453f, 0.08690433f, 0.00727205f, -0.21025859f, 
    -0.06024204f, -0.12566078f, 0.00962345f, 0.10611273f, -0.04955825f, 0.10616713f, 0.04212577f, 0.08067221f, 
    -0.18277541f, -0.30248404f, -0.09568449f, -0.07959692f, -0.01296830f, -0.09222940f, -0.08123624f, -0.13824207f, 
    0.05098109f, 0.15185015f, 0.09140158f, -0.00497364f, 0.01649685f, 0.07909545f, -0.29470474f, 0.05822727f, 
    0.04826225f, 0.08935218f, 0.02344885f, 0.06226854f, 0.09371430f, 0.22917977f, -0.05026054f, -0.15042266f, 
    0.05645608f, 0.09264006f, 0.01293270f, 0.13753836f, -0.05605942f, 0.06426104f, 0.15536165f, 0.07458372f, 
    0.14920157f, 0.18747936f, -0.25264198f, -0.01110478f, 0.09070133f, 0.05480673f, 0.18195659f, 0.07447359f, 
    -0.10250703f, -0.07814401f, -0.06813546f, 0.11819537f, -0.13960470f, -0.37402654f, -0.30162370f, -0.20670123f, 
    0.05947287f, 0.00393512f, 0.00261348f, -0.10735126f, -0.02030984f, -0.00500900f, 0.02563483f, 0.07466046f, 
    -0.13110983f, -0.11629793f, 0.06972848f, -0.03069394f, 0.05532619f, 0.00128263f, -0.09203049f, 0.14422294f, 
    -0.08517253f, -0.00873953f, -0.06154210f, 0.17378585f, 0.16283670f, 0.53948492f, -0.07364351f, -0.06341595f, 
    -0.23882242f, 0.01382608f, 0.02324391f, -0.03669777f, -0.09787020f, -0.01199982f, -0.06107841f, 0.12109070f, 
    -0.07666123f, -0.17865553f, -0.13346231f, -0.18660349f, -0.06948085f, 0.01822217f, 0.04785296f, 0.18670885f, 
    -0.04539206f, -0.18545383f, -0.05953699f, -0.04414527f, 0.21717192f, 0.04821520f, -0.14548357f, -0.13879250f, 
    -0.04077838f, 0.25476503f, 0.02079001f, -0.03764588f, -0.00028614f, -0.19025025f, -0.12984686f, -0.22501995f, 
    0.29723218f, -0.06438501f, 0.16444528f, -0.12814315f, 0.03392924f, -0.03135936f, -0.00966192f, 0.16550110f, 
    -0.14305331f, 0.06265208f, 0.00335518f, -0.00949353f, -0.13278370f, 0.12199710f, -0.13132264f, -0.04689311f, 
    0.00513515f, -0.12760831f, -0.01950387f, -0.03025257f, 0.04485231f, -0.19212402f, -0.07177620f, -0.00915207f, 
    -0.14500850f, 0.08803915f, 0.00316915f, 0.13229553f, -0.03458020f, 0.02056538f, 0.03098537f, 0.14322288f, 
    -0.05331464f, 0.04771388f, -0.06286442f, 0.18094335f, -0.17612623f, -0.20072983f, -0.07786989f, 0.09926022f, 
    0.10468555f, 0.08798166f, -0.04888078f, -0.17831384f, 0.20936298f, 0.16446385f, 0.24637029f, 0.28102878f, 
    -0.02058705f, 0.13906610f, -0.24123283f, 0.28358504f, 0.04867786f, -0.07489424f, 0.01062150f, -0.04273235f, 
    -0.04517922f, 0.00109162f, 0.06706011f, -0.00607066f, 0.28099126f, 0.16349605f, 0.17564546f, -0.05706053f, 
    0.02262217f, 0.17365748f, 0.01865414f, -0.07243007f, 0.05758429f, 0.02108978f, -0.03862372f, -0.01593007f, 
    0.07672767f, 0.30641025f, 0.22835042f, -0.13943037f, 0.05936791f, 0.00332989f, 0.01834732f, 0.05259636f, 
    -0.04917791f, -0.00463925f, -0.07035288f, 0.11120518f, -0.14990357f, -0.24451201f, -0.21133296f, -0.00133066f, 
    0.15780288f, 0.00565093f, 0.06084739f, 0.06119442f, 0.14630409f, 0.11788343f, 0.09616353f, 0.04915334f, 
    -0.30145234f, -0.11814084f, 0.06719310f, -0.18431003f, -0.09368040f, 0.11108170f, 0.00712332f, -0.15637767f, 
    -0.13379912f, -0.00936216f, -0.00629432f, 0.00295880f, 0.28977576f, 0.40149698f, 0.31328565f, 0.15227409f, 
    0.02805802f, 0.09347332f, 0.02491105f, 0.23122519f, -0.14723270f, -0.02309603f, -0.01111465f, -0.11531094f, 
    0.40330148f, 0.18900466f, 0.19322085f, 0.28913799f, 0.08442122f, 0.01758924f, 0.18426035f, 0.08311326f, 
    -0.04057176f, 0.07383115f, -0.00822916f, 0.06065259f, 0.33725727f, -0.08342773f, 0.03510986f, 0.17140111f, 
    0.12413498f, -0.05996742f, -0.11883596f, -0.10379215f, 0.01136438f, -0.00800602f, 0.00691581f, 0.03049364f, 
    -0.06908500f, 0.49276093f, 0.18813719f, 0.26573774f, -0.01675215f, 0.02741747f, 0.12021857f, 0.30493471f, 
    -0.09127715f, 0.10439262f, 0.07765885f, 0.01010667f, -0.16218840f, -0.13841844f, 0.16836354f, 0.11659515f, 
    -0.09281226f, 0.01572663f, -0.03832676f, -0.11875799f, -0.11677290f, 0.05266147f, -0.15046231f, -0.05885939f, 
    0.09184977f, -0.17516065f, -0.08458647f, -0.02110873f, -0.00222116f, 0.24208002f, -0.08404336f, 0.00542239f, 
    0.13291362f, 0.08113220f, -0.00262659f, 0.06415987f, 0.31377766f, -0.08099795f, 0.09176616f, -0.16191436f, 
    -0.03407384f, -0.00123070f, 0.09006642f, 0.10862324f, 0.03729420f, 0.10933716f, 0.05112164f, 0.08325431f, 
    0.00507757f, -0.16315648f, -0.22314493f, -0.40610084f, 0.02467643f, -0.00296876f, -0.05495119f, 0.02982887f, 
    0.01374104f, -0.08731259f, 0.00834299f, 0.00083721f, -0.22287035f, 0.16715139f, -0.01976842f, 0.03997632f, 
    0.10548459f, 0.02291799f, 0.00529473f, -0.00690022f, 0.10674085f, 0.13656983f, 0.06806596f, -0.04694716f, 
    -0.06237840f, -0.14932418f, -0.10441654f, -0.13417220f, 0.01406226f, 0.08598331f, 0.07260242f, 0.01386676f, 
    -0.10659443f, -0.05218761f, -0.01567415f, -0.30671653f, -0.07958630f, -0.01934435f, -0.17894591f, 0.00091505f, 
    -0.04787171f, -0.06663593f, -0.07454658f, -0.03829242f, -0.06473911f, 0.02411065f, 0.05423606f, -0.10192688f, 
    0.39174122f, 0.05667800f, -0.04878165f, -0.27065027f, 0.03357897f, -0.11289305f, -0.01193790f, -0.15897550f, 
    0.01353934f, 0.01967254f, -0.00917495f, 0.01637490f, 0.05121520f, 0.02328580f, 0.13317853f, -0.05031096f, 
    0.06070909f, -0.00869168f, 0.09573089f, 0.16066830f, 0.05181992f, 0.04051390f, -0.08899474f, -0.04398880f, 
    -0.18887804f, 0.11890650f, 0.18054648f, 0.14809150f, -0.01451357f, 0.07482377f, 0.06910612f, 0.12964843f, 
    0.10653060f, -0.05495229f, -0.02623915f, -0.00007089f, -0.10752054f, -0.20257026f, -0.02515394f, 0.12148473f, 
    -0.02255115f, -0.07987063f, 0.07647889f, -0.15952300f, -0.04058933f, 0.04586442f, 0.04470244f, 0.09721758f, 
    0.05258802f, -0.12407721f, -0.08504135f, 0.03776060f, 0.07821104f, 0.01639823f, -0.13958688f, 0.09629335f, 
    0.12676719f, 0.14475790f, 0.30449018f, 0.09109779f, -0.20355219f, -0.12728554f, 0.23331058f, -0.00968550f, 
    -0.06233753f, 0.13164261f, 0.00581137f, 0.09154622f, 0.08349773f, -0.07249306f, -0.01468394f, 0.07903877f, 
    -0.44301581f, -0.26483473f, 0.13170598f, 0.27846918f, 0.09184268f, -0.16347553f, 0.00507223f, 0.12470716f, 
    0.20190567f, 0.01002389f, -0.04356289f, -0.07312988f, -0.09669113f, -0.08434705f, 0.14558379f, 0.09745847f, 
    -0.02403522f, -0.13645558f, -0.13447841f, -0.01021871f, 0.28716961f, 0.08419226f, 0.01392463f, 0.09537657f, 
    0.12933256f, 0.10568664f, 0.04359133f, -0.12985371f, -0.10696566f, 0.04992609f, 0.12795019f, -0.11226141f, 
    0.00417720f, -0.13464355f, -0.05861494f, -0.03190167f, -0.05564727f, -0.44921547f, 0.42765719f, 0.02081278f, 
    0.01648819f, -0.00463853f, 0.06820653f, 0.05796628f, 0.05439510f, -0.09015165f, -0.02764019f, -0.03498798f, 
    0.09652639f, -0.10406059f, -0.22591460f, -0.02105013f, -0.06084114f, -0.12007054f, 0.08175290f, -0.09091756f, 
    0.09172201f, -0.01413948f, -0.09232134f, -0.10548420f, 0.02900566f, -0.20720111f, -0.09303924f, -0.21615130f, 
    -0.07060813f, 0.03662545f, -0.10440131f, 0.06450640f, 0.15650843f, 0.01800433f, -0.01324937f, 0.01698382f, 
    0.22291346f, -0.03712893f, 0.03358385f, -0.18167886f, 0.08581437f, -0.07687490f, -0.01249640f, 0.01003201f, 
    -0.06789111f, -0.10396568f, -0.03744891f, -0.03171696f, -0.13450421f, 0.04844052f, -0.14664710f, -0.10223822f, 
    0.20059271f, -0.03697552f, -0.07910147f, 0.01482050f, 0.01089801f, -0.04177569f, 0.00561618f, 0.03437911f, 
    -0.00383534f, -0.06240737f, -0.17506400f, 0.08222703f, 0.07892041f, 0.16956760f, 0.08086905f, 0.07109842f, 
    -0.08693327f, -0.10817671f, -0.04648221f, -0.22920027f, 0.01710277f, -0.01515035f, -0.11110577f, 0.10163087f, 
    0.02570548f, -0.03049679f, -0.08351634f, 0.03778564f, -0.14956006f, 0.03477951f, -0.01114370f, -0.18370312f, 
    0.14232171f, 0.17641136f, 0.06278091f, -0.03145272f, 0.01329566f, 0.03982248f, 0.03912229f, -0.01601329f, 
    -0.01207116f, 0.12361009f, 0.00978160f, -0.09514347f, 0.17500518f, 0.11584409f, 0.17493221f, 0.02341731f, 
    0.04305241f, 0.04788672f, 0.09862710f, 0.07028127f, 0.15878104f, 0.08482059f, 0.03329080f, 0.00423817f, 
    -0.06709535f, 0.15810223f, 0.10602050f, 0.10045449f, 0.03733556f, -0.11562715f, -0.08031134f, -0.12968090f, 
    0.15202557f, 0.08523843f, -0.05992616f, 0.04589074f, 0.04306579f, 0.01251688f, -0.07247813f, 0.06346481f, 
    0.02218704f, 0.08830953f, -0.00833455f, -0.12966165f, -0.06281897f, -0.03129661f, -0.04533915f, -0.06584939f, 
    0.07648112f, 0.10806623f, -0.21399707f, 0.08510095f, 0.01025184f, 0.02202374f, -0.13628523f, -0.05290283f, 
    -0.00562848f, 0.03170789f, -0.00531044f, 0.02100280f, 0.18555032f, -0.12927061f, 0.12591118f, 0.18001719f, 
    -0.07348185f, -0.09922267f, -0.08329324f, 0.08404677f, 0.04385392f, -0.04044284f, 0.06534582f, 0.14543338f, 
    -0.10778009f, -0.09132151f, 0.16349378f, 0.14485216f, 0.05779111f, -0.19803250f, 0.10425654f, 0.09323730f, 
    0.14649469f, -0.13868138f, 0.05984192f, -0.05065589f, -0.10422124f, -0.21144529f, 0.07749898f, 0.19806686f, 
    -0.01812322f, -0.04082044f, 0.04129213f, 0.02573491f, 0.14709066f, -0.00148224f, -0.01954371f, 0.05598372f, 
    0.10539896f, 0.31503469f, 0.00047191f, -0.10647414f, -0.16820462f, 0.06011306f, 0.11435780f, -0.01835032f, 
    0.00735397f, 0.00290870f, -0.06367777f, 0.05115435f, -0.12200745f, -0.33627760f, 0.31955093f, 0.06482506f, 
    -0.06443413f, 0.07088134f, -0.06892633f, -0.04649138f, 0.04732653f, 0.01925438f, 0.02729611f, 0.12598273f, 
    0.24522132f, 0.12351111f, -0.12677994f, -0.17051476f, -0.00948471f, -0.14435631f, 0.10445807f, -0.02958758f, 
    0.08387618f, 0.03487620f, 0.05255857f, -0.12462185f, 0.21677844f, -0.02533376f, 0.00658509f, -0.05226949f, 
    -0.07583600f, -0.07754911f, -0.04803589f, 0.03461178f, -0.00242281f, -0.07271150f, -0.08660188f, -0.24032953f, 
    0.28700602f, 0.05240791f, 0.12288713f, -0.30064169f, -0.02506295f, -0.24752371f, -0.26657659f, -0.00917703f, 
    -0.06360229f, -0.01920951f, 0.01592392f, 0.01373005f, -0.46757486f, 0.01704574f, -0.07913830f, -0.13347092f, 
    0.02705687f, -0.12171230f, -0.04412008f, -0.06655235f, -0.06658534f, -0.03185900f, -0.03764661f, 0.05583654f, 
    -0.01091602f, -0.01932843f, -0.14071970f, 0.03845488f, 0.13225000f, 0.02986716f, -0.03364118f, -0.02550543f, 
    0.06572017f, -0.10495536f, -0.00049015f, -0.04098370f, 0.15220289f, -0.01271418f, 0.07251599f, 0.07192023f, 
    0.00538722f, 0.03271201f, -0.03016896f, -0.04625114f, -0.03955850f, -0.00612484f, 0.16482428f, -0.01663850f, 
    0.55970943f, 0.17305827f, -0.36357892f, 0.07774206f, 0.00496607f, 0.04763240f, 0.03184476f, 0.02854497f, 
    0.10834048f, 0.02713031f, -0.03321292f, -0.07051291f, 0.04787961f, 0.10262161f, 0.26307711f, -0.08832356f, 
    0.01701027f, -0.01540056f, -0.01196609f, 0.00544776f, 0.00224392f, 0.07345977f, 0.06441768f, -0.01731458f, 
    -0.21403310f, 0.27511904f, 0.17237322f, 0.05998714f, 0.02869388f, -0.03319887f, -0.02789327f, 0.16692162f, 
    0.04645196f, 0.02840738f, -0.06647827f, 0.08991236f, 0.29722843f, 0.18733828f, -0.06861357f, 0.21362741f, 
    -0.07189114f, -0.12070518f, -0.12880343f, -0.01367828f, -0.02406631f, 0.04853621f, 0.00549737f, 0.04276849f, 
    -0.02250577f, 0.09955203f, 0.00649786f, 0.09341224f, 0.11571396f, -0.07384031f, 0.02978464f, 0.06731281f, 
    0.05271993f, 0.02603795f, 0.06454661f, -0.03411771f, 0.01676553f, -0.00836801f, 0.33131036f, 0.14648186f, 
    -0.00474181f, 0.04670184f, 0.07019603f, -0.00779652f, -0.06715906f, 0.03882824f, -0.05860173f, 0.06346881f, 
    -0.15895788f, -0.10876265f, 0.20970632f, 0.11590998f, -0.07867692f, -0.13027737f, 0.12937768f, 0.09629876f, 
    0.08278684f, -0.05611427f, 0.17196479f, -0.09915785f, 0.22894257f, -0.20619929f, -0.10031182f, -0.05725045f, 
    -0.08175073f, -0.10690020f, 0.02246224f, 0.12756588f, 0.01085852f, 0.01795112f, 0.09046342f, 0.02084161f, 
    0.21619299f, 0.27079460f, 0.00119818f, 0.07701119f, -0.08804638f, 0.00411640f, 0.04238656f, -0.14584464f, 
    0.01835313f, -0.11902173f, 0.02704665f, -0.00561173f, -0.04428721f, -0.43953565f, 0.37670144f, 0.10307051f, 
    0.03902070f, 0.02668476f, -0.03529234f, 0.07936553f, 0.06564182f, 0.07534978f, -0.01383413f, 0.05529218f, 
    -0.05702229f, -0.18135509f, -0.06059748f, -0.11969109f, -0.05504348f, -0.08789003f, 0.16442086f, 0.06782214f, 
    0.01075542f, -0.01090828f, 0.00956603f, 0.02181109f, 0.10639801f, -0.11538811f, 0.02409313f, -0.17070846f, 
    0.05973646f, -0.02832315f, -0.04416100f, 0.01801548f, 0.03191886f, 0.03854757f, -0.02349290f, -0.02477323f, 
    0.19706698f, -0.17933781f, 0.03820541f, -0.05245602f, 0.04900305f, -0.03680354f, 0.07425756f, 0.13455851f, 
    -0.03933205f, -0.04890340f, -0.09770644f, -0.06709442f, -0.24456003f, 0.09667894f, -0.15334864f, -0.12572952f, 
    0.08560973f, -0.13689075f, 0.03494605f, 0.08612493f, 0.12381193f, 0.03060803f, 0.13997178f, 0.04049369f, 
    0.10123132f, 0.07260662f, -0.13579859f, 0.03380991f, 0.05468619f, 0.02347066f, 0.10706592f, 0.08252267f, 
    0.06530305f, -0.05166259f, 0.01785879f, 0.04361378f, -0.07141497f, 0.00113645f, -0.11268802f, 0.07951091f, 
    -0.06310119f, -0.05202786f, -0.01592625f, 0.01422938f, 0.13320082f, 0.11545989f, 0.19955228f, 0.04866314f, 
    -0.00539229f, 0.13374475f, 0.01786509f, -0.08397342f, 0.04334903f, -0.02998002f, 0.03816149f, 0.00399991f, 
    -0.03392741f, -0.02087102f, 0.12751351f, -0.06182733f, -0.09997186f, -0.01134957f, 0.07490621f, 0.05510835f, 
    -0.03224507f, 0.02495134f, 0.08999749f, -0.02206066f, 0.02357185f, 0.07977168f, 0.11742646f, 0.08303365f, 
    -0.19911204f, 0.07232827f, 0.12242566f, 0.12690906f, -0.02358621f, -0.07525627f, -0.03209872f, -0.01399039f, 
    0.00717111f, 0.08933092f, -0.02892897f, 0.13320185f, -0.09572887f, -0.10064817f, -0.20698451f, 0.02173348f, 
    -0.03841239f, 0.05896582f, 0.00578504f, 0.00649204f, -0.01482556f, -0.01965824f, -0.11307934f, -0.01333422f, 
    -0.10406789f, -0.02716417f, -0.24171922f, -0.02046368f, 0.05191950f, -0.11647087f, 0.03320787f, -0.01789958f, 
    0.04341102f, -0.01347791f, -0.00567799f, -0.02172930f, 0.13482401f, -0.19648112f, 0.19663177f, 0.24182963f, 
    -0.08641209f, -0.01990527f, -0.10212938f, 0.01689450f, -0.14988163f, -0.03727331f, -0.06396142f, -0.00364062f, 
    -0.05798274f, -0.14819233f, 0.18123813f, 0.17435686f, -0.06056162f, -0.05364562f, -0.06172327f, 0.05408831f, 
    0.15442793f, 0.07905657f, 0.10075410f, 0.12099168f, 0.10876749f, -0.19709882f, 0.18035153f, 0.25225946f, 
    -0.07714815f, -0.13987570f, -0.06183566f, -0.04958789f, 0.13448398f, 0.02183295f, -0.02076245f, 0.14219506f, 
    -0.09225331f, 0.31790155f, 0.01159356f, 0.08419657f, -0.04844748f, 0.02834434f, 0.10612217f, 0.08561067f, 
    0.07662532f, 0.02329103f, 0.02779218f, 0.02229967f, -0.10981944f, -0.39625469f, 0.39024970f, 0.06924579f, 
    0.10056976f, 0.09778874f, -0.05995563f, -0.02024366f, -0.10678701f, 0.01764642f, -0.11305800f, -0.03162555f, 
    -0.15171623f, -0.06403323f, 0.01472655f, -0.30538520f, -0.04629613f, -0.02371522f, 0.13955213f, 0.22787850f, 
    -0.15348306f, -0.09117779f, -0.15063043f, -0.12564792f, 0.00880983f, -0.12412342f, -0.07233653f, -0.30281240f, 
    -0.10763750f, -0.02390672f, -0.13638824f, -0.16023748f, -0.21860263f, -0.24142200f, -0.16717216f, -0.20745954f, 
    0.47688496f, 0.18822098f, 0.30816138f, -0.04622998f, -0.00403119f, -0.02127729f, 0.18814963f, 0.21223034f, 
    -0.00254553f, -0.04375659f, -0.10689203f, -0.02937532f, -0.01363457f, 0.04709494f, -0.38401324f, -0.07205646f, 
    -0.01799703f, -0.04446484f, 0.13244514f, -0.19356570f, 0.02033740f, -0.16480388f, 0.04760643f, 0.07247506f, 
    0.13922308f, 0.18359888f, -0.15471877f, 0.26401290f, 0.11242197f, 0.04088317f, 0.09564478f, 0.21924487f, 
    0.24816819f, 0.00064942f, -0.06057677f, 0.02666424f, -0.08822647f, -0.15343522f, 0.05841538f, 0.07098341f, 
    -0.02006132f, 0.00743677f, -0.03621075f, 0.00354057f, 0.11778095f, 0.13538438f, 0.14207065f, 0.08409887f, 
    -0.30884305f, 0.22741704f, -0.11512440f, 0.19946508f, -0.02729426f, -0.11517408f, -0.11326778f, 0.01586580f, 
    -0.07574531f, 0.06235162f, 0.27393430f, 0.06038740f, -0.09245510f, -0.10667861f, -0.04965276f, 0.02569818f, 
    0.01557907f, -0.13805647f, -0.03273803f, -0.06296817f, 0.12919487f, 0.06772902f, -0.04257620f, 0.08848504f, 
    -0.00831914f, -0.09488488f, 0.14672379f, -0.03690742f, 0.01211410f, -0.16975632f, -0.06612981f, 0.13353455f, 
    0.06122532f, 0.00931868f, 0.12536789f, 0.14801025f, 0.13304122f, 0.03555331f, -0.11090866f, -0.14584939f, 
    0.06597877f, -0.02367448f, 0.03934268f, 0.05579925f, -0.02022258f, 0.00403937f, 0.05350643f, 0.06991804f, 
    -0.13845390f, 0.03209099f, -0.13962200f, -0.05521704f, 0.02174248f, -0.08427265f, -0.14011657f, -0.19380489f, 
    0.04952365f, 0.01259916f, -0.09688675f, 0.11879616f, 0.18995532f, -0.19966908f, 0.04222431f, 0.32030454f, 
    0.06085819f, -0.07203715f, 0.07459108f, 0.08345621f, -0.11590626f, 0.01553517f, -0.19767313f, -0.02900154f, 
    0.37483627f, -0.23348083f, 0.14755166f, 0.29427898f, 0.10246184f, 0.07270307f, 0.00786849f, 0.07117656f, 
    0.10762280f, 0.11469178f, 0.04537742f, 0.07077233f, 0.22133733f, -0.36449218f, -0.09066527f, 0.08121590f, 
    0.04406608f, 0.01782525f, 0.03738059f, -0.00948003f, 0.13146716f, -0.09851052f, 0.06884605f, 0.13868485f, 
    -0.22015922f, 0.40803733f, 0.10968819f, 0.35672137f, -0.11339615f, -0.15473457f, 0.12936059f, 0.09988864f, 
    -0.00600809f, 0.11716408f, -0.01231710f, 0.01870354f, -0.12581877f, 0.10022947f, 0.16768686f, 0.07505146f, 
    0.14314866f, 0.04987786f, -0.18131518f, -0.13583955f, 0.01508043f, 0.13230868f, -0.03742149f, -0.02218268f, 
    -0.00997438f, 0.03377882f, 0.04058191f, -0.23723112f, -0.06608055f, -0.00947447f, -0.04358741f, -0.00421921f, 
    -0.09961461f, -0.01153359f, -0.17217350f, 0.02390700f, 0.10927846f, 0.13912898f, 0.06211209f, 0.12116588f, 
    0.02281705f, -0.08436821f, 0.00343074f, 0.20597635f, 0.05022819f, -0.12092172f, 0.06983377f, -0.21350382f, 
    0.14164367f, -0.01961675f, -0.21832843f, 0.03865043f, 0.12025967f, -0.02221444f, 0.02714607f, 0.02490806f, 
    0.05361987f, 0.07090542f, -0.10562406f, 0.00840657f, 0.26564929f, 0.04108987f, -0.07370839f, 0.03519759f, 
    -0.17744173f, 0.05057850f, -0.02796965f, -0.17978080f, 0.21283092f, 0.04699951f, 0.00741281f, 0.11474001f, 
    0.11421219f, 0.19205591f, -0.11717370f, 0.11764850f, 0.01718464f, -0.01387359f, -0.03301051f, -0.11662578f, 
    0.15495630f, 0.03179181f, 0.09081709f, 0.19375588f, 0.13092266f, -0.13850924f, -0.05696389f, -0.07799736f, 
    -0.05955291f, -0.01483540f, -0.02902229f, 0.09069312f, 0.22517455f, 0.06017668f, 0.11993680f, -0.05258562f, 
    0.63114327f, 0.01098624f, -0.19233042f, -0.12356152f, 0.16389178f, 0.01397420f, -0.02684310f, -0.00263448f, 
    0.06783226f, -0.00703293f, 0.04643832f, -0.04292433f, -0.16423666f, 0.16251183f, 0.18361242f, 0.22926010f, 
    -0.00164908f, -0.08167693f, 0.05481578f, 0.02984683f, -0.01106357f, 0.09173757f, 0.10081443f, 0.14716624f, 
    0.09546947f, -0.18104863f, 0.02781208f, 0.27131158f, -0.06666497f, 0.05545680f, 0.01153217f, 0.11299516f, 
    -0.10560231f, 0.01097411f, 0.03551169f, 0.09640095f, 0.16304934f, -0.20101151f, -0.04856753f, 0.05724315f, 
    -0.08108994f, -0.05225714f, -0.03465771f, -0.11188868f, 0.05410573f, -0.02169971f, -0.06682515f, -0.08069912f, 
    -0.00945663f, -0.00684289f, -0.08652250f, 0.06473883f, 0.01618193f, -0.17382175f, -0.05778002f, -0.05551478f, 
    0.03501866f, -0.06071620f, -0.12828366f, -0.07189129f, -0.22648431f, 0.07696387f, 0.30422345f, 0.43158469f, 
    0.12658547f, 0.12946710f, 0.14060652f, 0.08502579f, 0.09717514f, 0.00329882f, -0.13370389f, -0.00291688f, 
    -0.09175323f, 0.05530997f, 0.13276458f, 0.01654941f, -0.08703151f, -0.01553852f, -0.08725310f, 0.14473365f, 
    0.06981276f, 0.12045100f, 0.08604585f, 0.01398402f, -0.36668199f, 0.13037573f, -0.07664323f, -0.12741108f, 
    0.12461798f, 0.01865447f, 0.08688836f, 0.03687656f, 0.02051493f, 0.01242324f, -0.06254290f, -0.04338431f, 
    0.27856150f, 0.07345419f, 0.15179029f, 0.20999549f, 0.18868494f, 0.04955031f, 0.04054561f, -0.00500431f, 
    0.06067428f, -0.00927329f, 0.11905185f, 0.08786610f, -0.18108711f, -0.09487827f, -0.15647441f, 0.01173902f, 
    0.16024956f, -0.08914975f, 0.00849210f, 0.11391301f, -0.08291285f, -0.11392900f, 0.00846659f, -0.01524250f, 
    -0.23695026f, -0.13976645f, -0.19754674f, 0.01609545f, 0.01533672f, -0.00466392f, -0.22251248f, 0.13085036f, 
    0.09746854f, 0.09626966f, 0.11153205f, 0.05764900f, -0.05920895f, -0.18616670f, 0.17365532f, -0.03627737f, 
    -0.02775515f, -0.00774765f, -0.04778811f, -0.06264059f, 0.18017365f, 0.25785914f, 0.18034528f, 0.20768407f, 
    -0.43773863f, -0.08955383f, -0.04611398f, 0.17797048f, 0.01304920f, -0.06989168f, 0.12973407f, -0.10137665f, 
    -0.06534565f, -0.00368731f, 0.06169052f, 0.03035390f, 0.42769232f, 0.14780456f, -0.04305143f, 0.17400156f, 
    -0.00258058f, 0.21992721f, 0.10234186f, 0.19256930f, 0.04780010f, -0.08627494f, 0.14800817f, 0.06529158f, 
    0.02032410f, -0.09699322f, 0.10131483f, 0.04889077f, -0.07352544f, 0.10704084f, 0.04501887f, 0.06939092f, 
    -0.11624189f, 0.06006341f, 0.00899493f, -0.19035663f, -0.12528837f, 0.06135503f, -0.08900286f, -0.08633245f, 
    -0.06900318f, 0.01911449f, -0.11142825f, 0.00889686f, 0.01814961f, -0.05915416f, -0.01056644f, 0.03209576f, 
    0.07221023f, 0.17429896f, 0.48717028f, 0.02191743f, -0.08514017f, -0.03932941f, 0.00378492f, -0.03589278f, 
    -0.08043234f, 0.01298472f, 0.00923284f, 0.19886038f, 0.04585838f, -0.05627855f, -0.03144814f, 0.26330197f, 
    -0.08857539f, 0.03171310f, 0.06049747f, 0.01922736f, 0.08430938f, 0.07520760f, 0.01744269f, -0.04082014f, 
    0.05566289f, 0.03278880f, -0.05969431f, 0.12242633f, 0.13237275f, -0.03109903f, 0.07922240f, -0.11888848f, 
    0.07580239f, -0.00784881f, -0.04062355f, 0.03412508f, -0.47490022f, -0.00164891f, -0.11397064f, -0.16924252f, 
    -0.00480710f, -0.12773068f, -0.06781547f, -0.13239394f, -0.07879232f, -0.07133121f, -0.06988994f, 0.04050747f, 
    0.21745583f, -0.10399437f, -0.02411120f, 0.00525421f, -0.01018207f, 0.03462829f, -0.14193523f, -0.00632927f, 
    0.21665955f, -0.01033814f, 0.01197211f, 0.02731201f, -0.04206533f, -0.08735580f, -0.16748804f, -0.10091404f, 
    -0.04387679f, 0.07800018f, 0.05290095f, 0.08739288f, -0.09654213f, 0.06513553f, 0.07602952f, 0.13608809f, 
    -0.11203106f, -0.10011271f, -0.28398266f, 0.09254556f, 0.10653073f, -0.05251757f, 0.04932578f, 0.05257555f, 
    -0.04834312f, -0.08032277f, 0.01529905f, 0.11554299f, -0.09824672f, -0.16680059f, 0.22138633f, -0.07389332f, 
    -0.00163741f, 0.00722929f, -0.07147207f, -0.07148105f, 0.03364043f, -0.00889563f, 0.08511340f, -0.06887779f, 
    -0.23212102f, -0.17717572f, 0.15307222f, -0.17429720f, -0.04594404f, 0.01394528f, 0.08116654f, 0.15706013f, 
    0.08144522f, 0.02637379f, -0.16187337f, 0.07480947f, 0.14024712f, 0.35727096f, -0.01941348f, -0.01462093f, 
    -0.13726826f, -0.02517357f, -0.07014799f, 0.09198475f, -0.08032314f, 0.00606901f, 0.06814935f, 0.07045446f, 
    -0.01707897f, 0.00148198f, -0.07576437f, -0.02858034f, 0.03549945f, -0.05524084f, -0.00340470f, -0.01028574f, 
    -0.05686180f, 0.03991945f, -0.02168829f, -0.00801951f, -0.05044449f, 0.01274109f, -0.04589779f, -0.07428614f, 
    0.03156845f, -0.04103834f, 0.05557182f, 0.03184943f, -0.01180544f, -0.04486566f, 0.01198481f, -0.06105380f, 
    -0.00499495f, 0.01971178f, -0.03058643f, -0.01415975f, 0.03788290f, 0.04204316f, 0.05251170f, -0.05024312f, 
    -0.02415835f, -0.06306432f, -0.02226326f, 0.03634490f, 0.03441198f, 0.05028013f, 0.02910152f, -0.06299774f, 
    -0.04750726f, -0.04378951f, -0.05322490f, 0.03574130f, 0.03241605f, 0.03201348f, 0.02576508f, -0.07261399f, 
    0.02894941f, -0.01292642f, -0.02630345f, -0.01093885f, -0.01245151f, -0.03323872f, 0.00863567f, -0.04064375f, 
    0.01072537f, 0.03346639f, -0.05187069f, -0.01415354f, -0.06256213f, -0.04442960f, -0.04743728f, -0.01143726f, 
    -0.02779242f, 0.00149271f, -0.04973645f, -0.06451727f, 0.04001169f, -0.05304336f, -0.00634858f, -0.08638696f, 
    0.04065919f, -0.02632462f, 0.03330494f, -0.03950845f, -0.01853853f, -0.03701329f, 0.00722653f, -0.06539316f, 
    -0.02359445f, -0.07303023f, -0.06740476f, -0.06870948f, -0.06081017f, 0.01059523f, -0.04743550f, 0.07181453f, 
    -0.04022396f, 0.02768111f, -0.00382233f, -0.00770086f, -0.02974814f, 0.00880408f, 0.05385100f, -0.06323987f, 
    -0.03268335f, -0.04140629f, 0.00282564f, 0.00577332f, 0.00103826f, 0.04151112f, 0.02397428f, -0.02468155f, 
    0.03907516f, -0.00996251f, -0.07768995f, -0.01631864f, -0.04648766f, 0.04306056f, -0.05493182f, 0.03004326f, 
    -0.03799424f, -0.04553458f, -0.02488530f, -0.01952552f, -0.03478647f, -0.06243677f, -0.01019939f, -0.00163998f, 
    0.02419047f, -0.07674097f, -0.01837541f, -0.05905469f, -0.06826440f, 0.04290390f, 0.04212296f, -0.00494637f, 
    -0.01854404f, -0.03198918f, 0.05222751f, 0.03433007f, -0.06293033f, -0.02786141f, -0.07414094f, -0.07333476f, 
    -0.06638994f, 0.04243258f, 0.02077451f, -0.00585195f, -0.00187685f, -0.00999624f, -0.06301208f, -0.03397311f, 
    -0.03938762f, 0.02896259f, 0.05305603f, 0.03348481f, 0.02858544f, 0.03712351f, 0.05395865f, 0.03541088f, 
    0.04595812f, 0.04551206f, -0.06561723f, -0.00669099f, -0.07801067f, -0.03270711f, 0.00242188f, 0.05079508f, 
    0.02882375f, 0.00838748f, -0.04537052f, -0.06924792f, 0.00129389f, -0.04845275f, -0.03489817f, 0.00735970f, 
    0.00921881f, -0.02390152f, 0.01238311f, -0.01094158f, -0.07259739f, -0.01831437f, 0.03719378f, 0.03605170f, 
    -0.02475237f, 0.04287960f, 0.02400142f, -0.00497558f, -0.02231034f, 0.01371151f, 0.02242320f, 0.01153094f, 
    0.06003641f, -0.01047235f, 0.03856436f, 0.01354816f, -0.01933284f, 0.05614695f, 0.03951684f, -0.01721361f, 
    -0.13275217f, -0.15160020f, 0.26380870f, 0.06090576f, -0.13531201f, 0.23205416f, -0.34918660f, 0.06887861f, 
    -0.05135702f, 0.02518774f, 0.31935677f, -0.04112775f, 0.21498507f, 0.29545316f, 0.24563196f, 0.14795789f, 
    -0.17997187f, -0.09760381f, 0.12436974f, -0.19705671f, 0.21060713f, 0.05496952f, 0.19085242f, 0.07552594f, 
    -0.38478127f, -0.12078917f, 0.15284799f, -0.02662010f, -0.05076661f, 0.11159079f, -0.08487683f, 0.14516093f, 
    0.01315178f, -0.14222421f, 0.15449473f, 0.06477270f, 0.45250982f, 0.07575045f, 0.04678410f, 0.21303470f, 
    -0.11756155f, 0.10794155f, 0.18605557f, 0.00916950f, 0.07224244f, -0.01289507f, -0.05345594f, -0.17091572f, 
    -0.00251311f, -0.04615388f, -0.01768275f, 0.07627245f, 0.00775221f, -0.05287408f, 0.00564224f, -0.09537459f, 
    -0.13375634f, -0.06791391f, -0.13938080f, -0.32994163f, 0.04173388f, 0.07062305f, -0.05041860f, 0.07091723f, 
    -0.16582681f, -0.01258791f, -0.00392317f, -0.09023934f, 0.04065655f, 0.00957483f, 0.00236473f, -0.04278038f, 
    0.39039585f, 0.17191273f, -0.07804723f, 0.00932285f, 0.05064610f, 0.07745656f, 0.04224670f, -0.01017806f, 
    -0.00200139f, -0.19550501f, -0.11145365f, 0.07159872f, -0.07560922f, 0.03338801f, 0.15042810f, 0.06012221f, 
    0.05336160f, 0.04257435f, 0.02759024f, 0.06335746f, 0.00453539f, -0.02809476f, -0.02802494f, -0.13457759f, 
    0.01652486f, -0.02600926f, 0.05247769f, 0.12699445f, 0.04812574f, 0.07843025f, 0.10462710f, 0.11852396f, 
    -0.08289456f, 0.00146567f, -0.03919622f, 0.20811892f, -0.00051663f, -0.33633047f, -0.02634749f, -0.02616496f, 
    -0.19037694f, -0.19719502f, 0.07941171f, -0.18624471f, 0.05667917f, 0.07941840f, 0.10967910f, 0.08405019f, 
    0.00494300f, 0.00403123f, 0.21925980f, 0.05457423f, -0.00585895f, 0.11842731f, -0.22372170f, 0.08115430f, 
    0.04149418f, 0.09869047f, 0.14195091f, 0.18130562f, -0.27277553f, 0.01261518f, 0.19487415f, 0.02130440f, 
    0.06385080f, 0.27285013f, 0.03613466f, 0.11360922f, 0.05669679f, 0.10278662f, 0.10415099f, -0.08313268f, 
    -0.30914143f, -0.01428899f, -0.10134596f, 0.07058029f, 0.10068779f, -0.07168505f, 0.04717706f, 0.19659775f, 
    -0.08876397f, 0.08690733f, 0.00397394f, -0.00402129f, -0.29096809f, 0.05060608f, 0.16159575f, -0.36880228f, 
    0.01299950f, 0.02663631f, -0.22099832f, 0.06717810f, -0.00894203f, 0.10834391f, -0.09334144f, -0.12490547f, 
    -0.24804913f, -0.03979657f, 0.23061328f, -0.04082692f, -0.00326676f, 0.06378669f, 0.03109170f, 0.01525375f, 
    -0.03848521f, -0.19360603f, -0.08926701f, -0.00829679f, -0.16711152f, 0.29237783f, 0.09923077f, 0.08797050f, 
    -0.08831989f, -0.06056893f, 0.03286882f, 0.13009164f, 0.13956273f, -0.12177739f, 0.02628983f, -0.01530035f, 
    -0.18455108f, -0.40021533f, 0.26343161f, 0.03866405f, -0.09132957f, 0.13156787f, 0.04224388f, 0.11571879f, 
    -0.16431163f, -0.17006141f, -0.00706379f, 0.08622391f, 0.01089856f, 0.10457227f, -0.02031233f, 0.01691942f, 
    -0.00732404f, -0.07933246f, -0.00371549f, -0.03026758f, -0.00813548f, 0.06620958f, 0.23175377f, 0.01054822f, 
    0.23784080f, -0.08150010f, -0.07696727f, 0.12546530f, 0.04312013f, 0.11122520f, -0.00194362f, 0.12523614f, 
    0.10836525f, -0.00369550f, -0.12313298f, -0.06091701f, 0.30744705f, 0.03817719f, 0.00611684f, 0.06916596f, 
    0.02942825f, -0.05184548f, -0.00480988f, 0.06883162f, 0.01999276f, -0.03834045f, -0.01784986f, 0.07252689f, 
    -0.02117925f, 0.11531090f, -0.12655519f, -0.00903266f, -0.15997717f, -0.02728209f, -0.10553809f, -0.04704511f, 
    -0.16963883f, -0.10114967f, -0.16471440f, -0.20591061f, -0.18724950f, -0.15184893f, -0.09978719f, -0.10986021f, 
    -0.18796797f, -0.13797481f, -0.11663122f, 0.00070532f, 0.11566721f, 0.07850500f, 0.00230347f, -0.14035414f, 
    -0.03028169f, 0.01001205f, -0.02736430f, -0.09694524f, -0.00321663f, -0.05073913f, -0.17003062f, 0.02442123f, 
    -0.05956997f, 0.07364865f, -0.02070822f, -0.07485714f, -0.07328665f, -0.08152704f, -0.06439828f, 0.12304644f, 
    -0.09221655f, -0.01446810f, 0.03036771f, -0.01030586f, -0.01729590f, 0.14860488f, -0.07184448f, 0.08712436f, 
    0.08395781f, -0.22949852f, -0.00030666f, 0.14768293f, -0.09256981f, -0.00438079f, -0.11025473f, -0.01980245f, 
    -0.03883394f, -0.02140481f, 0.00542352f, -0.01678303f, -0.00807074f, -0.34806660f, -0.03198712f, -0.28232926f, 
    -0.09436044f, -0.02755843f, -0.01024661f, -0.03876814f, 0.06697306f, -0.08957671f, 0.05270121f, -0.02490313f, 
    -0.22194941f, 0.23374683f, -0.18199146f, 0.08833765f, -0.09091384f, -0.10058243f, 0.02300428f, -0.13656168f, 
    0.05897145f, -0.02178640f, 0.08634957f, 0.12700459f, 0.01863944f, 0.09194575f, 0.07950547f, 0.38960972f, 
    -0.02999387f, 0.15267649f, -0.00345359f, 0.10441955f, -0.06577742f, -0.05622546f, 0.03322775f, 0.04597897f, 
    -0.15019670f, 0.01857962f, -0.03142133f, 0.13577679f, 0.02214802f, -0.08361032f, -0.07872882f, 0.08992828f, 
    -0.05743523f, 0.00075351f, -0.04303491f, -0.09560383f, -0.49787638f, -0.01178117f, -0.25048912f, -0.13991347f, 
    -0.09106414f, 0.06521831f, -0.08918409f, -0.10948965f, 0.05159449f, -0.06553227f, -0.04664104f, -0.06559864f, 
    -0.06795980f, 0.06963494f, 0.29106867f, 0.13267961f, -0.09120177f, -0.03665486f, 0.06537085f, 0.12554561f, 
    -0.12732191f, -0.06776518f, 0.05650389f, -0.11263821f, -0.35253602f, 0.02522828f, -0.13764258f, 0.11142840f, 
    -0.11126300f, -0.07090317f, -0.12253116f, -0.04299474f, -0.00455698f, -0.01469078f, -0.09072760f, 0.07660429f, 
    -0.15656199f, -0.26684535f, -0.06503497f, -0.11715598f, 0.00385736f, 0.13160303f, 0.25087667f, 0.10918542f, 
    -0.08320705f, -0.00024256f, -0.02046791f, 0.03558833f, 0.24259238f, -0.15145910f, 0.04621316f, -0.22241749f, 
    0.03959310f, -0.16442092f, -0.00253236f, 0.14269592f, -0.06544115f, 0.10038802f, 0.04334143f, 0.09961172f, 
    -0.13839045f, -0.45294717f, 0.00106327f, 0.00021486f, 0.18036620f, 0.05063613f, 0.06263503f, -0.04643042f, 
    0.08386197f, -0.11200254f, -0.13564681f, -0.04769621f, -0.17734262f, 0.27327341f, -0.27603734f, -0.05808720f, 
    -0.12123019f, -0.03795708f, 0.04037492f, 0.09206902f, 0.10176923f, 0.07948028f, 0.10698759f, 0.06489634f, 
    0.13631089f, 0.17058581f, -0.17811085f, 0.11199825f, 0.05382214f, 0.10795109f, 0.10408093f, -0.01800789f, 
    0.09324661f, -0.08454905f, 0.15364881f, 0.22460896f, 0.13575952f, 0.07655277f, -0.07274747f, -0.03552196f, 
    -0.07080083f, -0.02703982f, 0.13243356f, -0.00247583f, 0.17078342f, 0.24232620f, 0.13312054f, 0.09326012f, 
    -0.12603690f, 0.13160156f, 0.27108264f, -0.15123343f, 0.14102970f, -0.11421205f, 0.10101234f, -0.06660429f, 
    0.21482956f, 0.08159690f, 0.17158562f, -0.00195896f, -0.22289823f, -0.11573073f, -0.06133045f, 0.14111955f, 
    -0.04695025f, 0.07842926f, 0.07333477f, 0.11584514f, 0.02693601f, 0.05342989f, 0.07057142f, 0.15747379f, 
    -0.24092975f, -0.22607324f, -0.15919672f, 0.09571942f, -0.10951053f, -0.00906496f, -0.08086421f, 0.04599328f, 
    0.04530662f, 0.08112792f, 0.08820761f, -0.03678777f, -0.29910401f, -0.15364683f, -0.18688460f, 0.01639959f, 
    0.05902501f, 0.03029799f, 0.11178856f, -0.13592856f, 0.00277705f, -0.08353876f, -0.08918697f, -0.04799183f, 
    0.22659719f, -0.13197464f, -0.10697615f, -0.08376510f, -0.01513206f, 0.03135653f, 0.08132847f, -0.07943935f, 
    0.05232569f, -0.13941960f, 0.04369640f, 0.08385065f, -0.02926813f, -0.35788009f, 0.11990058f, 0.21288666f, 
    -0.06395895f, 0.05576536f, -0.18579121f, -0.08412738f, -0.00962287f, 0.11718426f, -0.01143702f, 0.02137515f, 
    -0.12869701f, -0.14209464f, 0.09373008f, 0.15962709f, -0.00861133f, 0.01882571f, -0.14928652f, 0.04531515f, 
    -0.07444379f, 0.05198294f, 0.00986607f, 0.13722461f, 0.08881383f, 0.17975771f, 0.42487940f, 0.13653077f, 
    -0.20345783f, -0.09349021f, -0.23068109f, -0.06996724f, 0.07797113f, 0.01848227f, -0.03158535f, 0.03247007f, 
    -0.02535465f, 0.25560048f, 0.10467869f, 0.02210395f, 0.09129955f, 0.01628906f, 0.16245581f, -0.04680575f, 
    0.16639479f, 0.06910086f, 0.14607686f, 0.03212303f, 0.08530448f, -0.39360267f, 0.29067346f, 0.04081879f, 
    0.12660484f, 0.08568916f, -0.04084963f, 0.05573290f, -0.09493630f, 0.06627715f, 0.00571814f, -0.04055103f, 
    -0.05052848f, 0.07116083f, -0.02544961f, 0.02470030f, -0.06821635f, 0.06420595f, 0.03771104f, 0.01246024f, 
    -0.02172419f, -0.00012243f, -0.06314483f, -0.05282394f, 0.02009057f, 0.06449158f, 0.00183026f, -0.07403568f, 
    -0.00675913f, -0.01120183f, -0.07335316f, 0.00017205f, 0.04317934f, 0.02318906f, -0.03503199f, -0.02200567f, 
    0.03124903f, -0.03247952f, -0.07148227f, -0.03189284f, -0.04720489f, 0.00054041f, -0.01455175f, -0.04693234f, 
    -0.06897017f, -0.00355690f, 0.05611711f, 0.00994445f, 0.03090470f, 0.04526037f, 0.00890451f, 0.05955604f, 
    -0.07405765f, 0.03977304f, -0.07643495f, -0.00512749f, -0.05590322f, -0.05855805f, -0.00383989f, -0.07595055f, 
    -0.05137802f, 0.02120270f, -0.05831042f, -0.05823185f, 0.06129648f, -0.00461921f, -0.06598860f, -0.02543261f, 
    -0.06723902f, -0.05505395f, 0.06412353f, -0.04950371f, -0.06968586f, -0.04705787f, 0.05909815f, 0.00021169f, 
    0.01725768f, 0.00544628f, 0.04135798f, -0.05806221f, 0.00557115f, -0.04985698f, 0.03894687f, 0.03373673f, 
    0.04950488f, -0.01569411f, 0.06629964f, -0.05533403f, -0.05648561f, 0.06531627f, 0.00405040f, 0.06613900f, 
    -0.04684972f, -0.02380228f, -0.01629315f, 0.03555563f, -0.04744469f, 0.04248289f, 0.01019005f, 0.06168293f, 
    -0.01744320f, -0.00334448f, 0.00150876f, -0.05736725f, -0.05312139f, -0.03531797f, -0.04499648f, -0.05085830f, 
    0.01759533f, -0.02697525f, 0.03504423f, 0.06122584f, 0.01107460f, -0.06078007f, -0.04720575f, 0.06596237f, 
    -0.06821727f, 0.03420675f, -0.03847226f, 0.04412946f, -0.05035435f, -0.05120108f, -0.05417431f, -0.07151768f, 
    0.06313156f, 0.01404348f, -0.04678677f, 0.03002356f, -0.01747610f, 0.02896855f, 0.01387954f, -0.00595898f, 
    0.00091102f, 0.00918792f, 0.04565705f, 0.05380069f, 0.00636469f, -0.01479922f, -0.03081492f, 0.00350388f, 
    0.04007882f, -0.02526076f, -0.03118891f, 0.03125524f, 0.03319792f, 0.00540828f, 0.04097168f, -0.07267123f, 
    -0.07531630f, 0.02996731f, -0.02256284f, -0.06975547f, 0.04640859f, -0.06834813f, -0.02338433f, 0.05153095f, 
    -0.01487451f, -0.01187789f, 0.01176407f, -0.05492142f, 0.06004780f, -0.01273280f, 0.05757409f, -0.07247198f, 
    -0.05439514f, -0.01629980f, -0.01499269f, -0.05580847f, 0.01917555f, 0.05515708f, 0.06591433f, 0.02439552f, 
    -0.07440548f, -0.06159887f, -0.04314494f, -0.02920951f, -0.03064780f, -0.01219146f, -0.07090960f, -0.05953462f, 
    0.02945175f, -0.00347952f, -0.05885056f, 0.05960319f, -0.02383622f, -0.04344674f, 0.00044361f, -0.05936074f, 
    -0.04032110f, 0.04779849f, -0.07121927f, 0.00846167f, 0.00335633f, -0.06956169f, -0.01334941f, 0.04876501f, 
    0.04230836f, -0.06902675f, 0.05179277f, -0.05366699f, -0.05535196f, -0.04410565f, 0.01926677f, -0.04307223f, 
    -0.01303587f, 0.03012392f, 0.01529460f, -0.00972528f, -0.02141120f, -0.00178279f, 0.04309304f, 0.03330677f, 
    -0.00716035f, -0.03972571f, 0.05969670f, 0.06408963f, -0.05314678f, 0.04676969f, 0.01903014f, -0.05101499f, 
    -0.04895020f, -0.01849625f, -0.03157941f, -0.01320530f, 0.01860001f, -0.00937172f, -0.00880060f, 0.06198600f, 
    -0.07135169f, 0.02018863f, 0.03102722f, 0.01890700f, 0.03542660f, -0.00422840f, -0.03277769f, 0.00960093f, 
    -0.06812838f, -0.04445236f, 0.04521478f, 0.05191631f, -0.05061448f, 0.05313075f, 0.05041020f, -0.03246301f, 
    -0.01098394f, 0.01492709f, -0.07960285f, 0.02272023f, 0.02369290f, 0.00396236f, 0.02933799f, -0.04129055f, 
    -0.05353181f, 0.06629383f, -0.07227891f, 0.00613801f, 0.05017758f, -0.00791240f, 0.04351128f, -0.00170270f, 
    -0.01627115f, -0.03948859f, -0.02212197f, 0.00481518f, -0.03939734f, -0.01893115f, 0.04901834f, -0.06168152f, 
    -0.04295061f, -0.06477426f, -0.03003138f, 0.03605672f, 0.02386706f, 0.00957323f, 0.06721649f, -0.05442121f, 
    -0.00035749f, 0.03307699f, -0.04302200f, -0.01260167f, -0.02065477f, -0.08125614f, -0.05179579f, 0.00928033f, 
    -0.00539797f, -0.02269485f, -0.05051814f, 0.05766907f, 0.03623947f, -0.04243842f, -0.05288136f, -0.04778636f, 
    -0.07622977f, -0.01459949f, 0.04205508f, 0.03583904f, -0.07505742f, -0.00180196f, -0.03816699f, 0.00693443f, 
    0.00256061f, -0.07003719f, -0.00246844f, 0.02629075f, 0.04608839f, 0.00100892f, -0.01283164f, 0.04857629f, 
    0.01807820f, -0.05102487f, -0.07939614f, -0.00346346f, -0.04924784f, -0.02926909f, 0.00868823f, -0.02151188f, 
    -0.05199131f, -0.05460914f, 0.00567559f, 0.05345010f, -0.06286574f, -0.02184533f, -0.00708973f, -0.06884581f, 
    -0.01148207f, -0.06803703f, 0.00714308f, 0.01993706f, 0.02541668f, 0.03281279f, 0.05625515f, 0.00023210f, 
    -0.01623156f, 0.02655791f, -0.07711690f, -0.00209482f, -0.07222217f, -0.01882533f, -0.01516427f, -0.00907176f, 
    -0.05622330f, -0.01939169f, 0.01422655f, 0.05533436f, -0.00692095f, -0.00301370f, -0.06045767f, 0.01512715f, 
    0.06646264f, 0.05515809f, -0.02231646f, -0.06385390f, -0.06398914f, -0.01588314f, 0.03022260f, -0.02315946f, 
    -0.01716715f, -0.06746688f, 0.00485797f, -0.01497440f, 0.01487616f, 0.06249028f, -0.00144643f, -0.02610616f, 
    -0.07308276f, -0.06439649f, -0.02777539f, 0.00982552f, -0.03993760f, 0.03447642f, -0.06631517f, 0.04127717f, 
    -0.03158995f, 0.05301448f, -0.02389418f, -0.07746550f, 0.01809810f, 0.05469049f, -0.07118548f, -0.06769653f, 
    -0.04044835f, 0.03002497f, 0.01664090f, 0.01818925f, -0.07069701f, 0.01480781f, -0.03429410f, 0.06093081f, 
    0.05592418f, -0.02562561f, -0.03883180f, 0.03174539f, -0.00251668f, 0.02792761f, 0.06171780f, -0.02217746f, 
    -0.04332478f, -0.12734236f, 0.25027940f, 0.16404547f, 0.08138534f, 0.26512280f, -0.01465887f, -0.02114521f, 
    0.09760527f, -0.03310486f, -0.00264344f, 0.23947696f, 0.03966538f, 0.09986535f, -0.13557817f, 0.17844398f, 
    0.04738063f, -0.00470148f, 0.02821881f, 0.05974938f, 0.00142790f, 0.10406993f, 0.14484784f, 0.16136746f, 
    0.21190973f, 0.15564762f, -0.26000994f, -0.04711852f, 0.00389571f, 0.11684429f, -0.03389382f, 0.03820974f, 
    0.01043783f, -0.02009424f, -0.00688324f, -0.04389758f, 0.19558665f, -0.07765108f, 0.14146315f, -0.13279304f, 
    0.00091207f, 0.01211775f, 0.05127382f, 0.08809279f, 0.08687244f, 0.08154805f, -0.08708943f, 0.05509886f, 
    -0.06165903f, 0.02372470f, 0.22448385f, -0.14690618f, -0.17620240f, 0.12021687f, -0.05601867f, 0.04500221f, 
    -0.17590937f, 0.07148840f, 0.11145784f, -0.00947911f, -0.11604805f, -0.07118933f, 0.02176312f, 0.03479202f, 
    -0.08401749f, -0.07550838f, -0.07259258f, -0.03380940f, -0.08610386f, -0.03306344f, -0.18699756f, -0.10534714f, 
    0.44499072f, -0.15517664f, 0.22290859f, 0.01085114f, -0.15043208f, 0.08463269f, -0.05517478f, -0.13801517f, 
    -0.17470777f, 0.02697534f, -0.06321235f, 0.14726880f, 0.25572714f, 0.17068416f, -0.00077521f, -0.11633315f, 
    0.11293944f, 0.06513733f, 0.16547465f, 0.11675423f, 0.02737100f, 0.07319730f, -0.02282143f, -0.04987683f, 
    0.23091511f, 0.14749667f, 0.17201929f, 0.05442484f, 0.02073156f, 0.04473867f, -0.07566149f, -0.01260679f, 
    -0.02040325f, 0.08522078f, -0.02028146f, -0.08431927f, 0.23077717f, -0.04082984f, 0.13100997f, 0.07007542f, 
    -0.07322184f, 0.08076043f, -0.11306801f, -0.10637192f, 0.01160191f, -0.09696330f, -0.09223557f, -0.10652774f, 
    0.02180271f, 0.06839272f, 0.07010683f, 0.16868018f, 0.00314933f, 0.04991104f, 0.06885821f, 0.02796945f, 
    0.02664648f, 0.03186507f, -0.04378924f, -0.03336367f, -0.36300778f, 0.36209387f, -0.12941012f, -0.08701443f, 
    -0.06117130f, -0.11071011f, 0.01837190f, -0.00918400f, 0.25866649f, -0.11102924f, 0.13443661f, 0.05497314f, 
    -0.32220522f, 0.33675927f, -0.11237099f, -0.05270240f, 0.03656615f, 0.04455420f, -0.04570762f, 0.05779450f, 
    -0.05880719f, -0.00621902f, -0.13252327f, -0.08283112f, -0.26211402f, 0.14075203f, -0.21150845f, -0.10013849f, 
    0.08612785f, 0.00504199f, -0.12361606f, -0.16337176f, 0.04758141f, 0.07873514f, 0.08240060f, 0.15209880f, 
    0.43769366f, -0.32308453f, 0.13505244f, -0.13668068f, -0.05336114f, 0.01474276f, -0.00217949f, 0.11489286f, 
    0.07406507f, -0.01449891f, 0.04537991f, 0.10418183f, -0.13537733f, 0.11526033f, -0.28929695f, 0.29253283f, 
    -0.04429904f, -0.04155093f, 0.00659016f, -0.05926525f, -0.03044317f, -0.03467871f, -0.03281279f, 0.15776414f, 
    -0.04242290f, -0.17406306f, 0.22190355f, 0.01344273f, 0.05328921f, 0.17623563f, 0.12225577f, 0.04270908f, 
    0.06987189f, 0.10744829f, -0.15944342f, 0.11762629f, -0.05516224f, 0.17083023f, -0.09412942f, -0.07195007f, 
    -0.02664618f, -0.05547967f, -0.02891960f, -0.01635217f, -0.05227035f, 0.03115951f, 0.02630808f, -0.03437989f, 
    0.43932986f, -0.08832020f, -0.12346770f, -0.09890223f, 0.04615107f, 0.12552831f, -0.03445919f, 0.11361690f, 
    -0.06900445f, -0.01361128f, -0.18038712f, -0.08141991f, 0.01893404f, -0.05496154f, -0.16700105f, -0.18125014f, 
    0.04728438f, -0.15743352f, 0.06213573f, -0.00397986f, -0.02746866f, 0.14365284f, -0.06653255f, 0.04790416f, 
    0.08088408f, 0.07427029f, -0.06415615f, -0.00484720f, -0.00602524f, 0.04292440f, -0.04570177f, 0.22031491f, 
    0.07409267f, -0.00743675f, 0.00036498f, -0.12705362f, 0.00261631f, -0.04672461f, 0.01929932f, 0.09396847f, 
    0.04474653f, -0.04120861f, -0.02594796f, 0.02072645f, -0.09856743f, 0.00024770f, 0.01360847f, -0.08085224f, 
    0.03842533f, 0.01604912f, -0.18053707f, -0.04651079f, -0.00957199f, 0.02394929f, -0.12601098f, 0.00485235f, 
    -0.06914685f, 0.06610752f, 0.02820568f, -0.03141338f, 0.15060690f, 0.05703560f, 0.01040542f, -0.27404937f, 
    -0.02886227f, -0.10002603f, 0.03008480f, 0.08650243f, 0.08976790f, 0.06310460f, -0.09117148f, 0.14505868f, 
    -0.13327210f, 0.02265720f, 0.28790316f, -0.01392727f, -0.03588442f, -0.08227273f, -0.00118054f, 0.26062939f, 
    -0.00334241f, -0.05013512f, 0.02011165f, -0.07100897f, 0.14136629f, -0.05820317f, -0.01726825f, 0.01494817f, 
    0.02658128f, 0.11928035f, -0.13817732f, -0.00722449f, -0.08645505f, 0.03270924f, 0.07303697f, -0.04451878f, 
    -0.15967131f, 0.28053865f, -0.23452391f, 0.24691679f, -0.02132622f, -0.14599141f, 0.05673134f, 0.03363615f, 
    0.03096360f, 0.03839298f, 0.03447378f, 0.11078583f, 0.18846461f, 0.09507741f, 0.21432671f, 0.15481097f, 
    0.00378326f, -0.04641449f, 0.12098031f, 0.05903263f, 0.13674067f, 0.06384650f, -0.13183892f, 0.03391738f, 
    -0.01132410f, 0.08392111f, 0.31339768f, 0.07539029f, -0.01841416f, -0.13402481f, 0.05457129f, 0.04760741f, 
    0.15669970f, -0.01457500f, 0.15590164f, -0.11918618f, -0.24485502f, -0.05895462f, -0.27310285f, 0.01378638f, 
    0.05360566f, -0.06755343f, -0.07337148f, -0.00457337f, 0.06532030f, -0.02706110f, 0.08155214f, 0.10158151f, 
    0.28965142f, 0.07246065f, 0.08587278f, 0.20161836f, -0.08327620f, 0.02736125f, 0.13468078f, 0.03835504f, 
    -0.01889375f, -0.02254270f, 0.03883027f, 0.02665716f, -0.32916623f, -0.18557794f, 0.07210190f, 0.11876997f, 
    -0.04391081f, -0.02981743f, -0.10388010f, -0.01246691f, -0.02590228f, -0.10526651f, 0.04709689f, -0.01244976f, 
    -0.09330092f, -0.02691359f, -0.13079756f, -0.15240933f, 0.04081816f, -0.00814422f, 0.12431854f, 0.11000810f, 
    -0.03926569f, 0.02022593f, 0.08089772f, -0.01921816f, 0.12288446f, 0.16644809f, -0.12821046f, -0.04657641f, 
    0.09575523f, 0.16905993f, -0.01579143f, 0.05197082f, -0.11405138f, -0.11720654f, -0.14437081f, -0.27367342f, 
    0.03957340f, 0.09354139f, -0.03926861f, -0.04281981f, 0.03217154f, -0.03402680f, 0.17938347f, 0.23367852f, 
    -0.03802580f, -0.02237948f, 0.07493227f, 0.01626923f, 0.25303310f, 0.21857184f, 0.16134450f, -0.08004978f, 
    -0.05874667f, 0.07537755f, -0.10834431f, -0.03430163f, 0.07207503f, 0.01603626f, -0.05854149f, 0.09272137f, 
    -0.12213467f, 0.05614427f, -0.05218165f, 0.02372446f, -0.00909802f, -0.07073426f, -0.07908472f, -0.12097210f, 
    0.10617312f, 0.06756943f, 0.13307351f, 0.36931562f, -0.22128047f, -0.28116083f, -0.03993730f, -0.03869828f, 
    -0.01879193f, -0.04095660f, -0.11584012f, -0.02320193f, 0.23089601f, 0.14676690f, 0.18701120f, 0.30389813f, 
    0.29616511f, -0.23647200f, -0.22539304f, 0.03699386f, 0.06094659f, -0.08532898f, -0.10907576f, 0.02937268f, 
    -0.04295306f, -0.02663118f, 0.09487882f, 0.16537282f, 0.09785037f, 0.29618239f, 0.30522177f, 0.24893327f, 
    -0.03612888f, 0.05494679f, -0.11124267f, -0.11604305f, -0.06464786f, -0.15314659f, 0.07777914f, -0.09724719f, 
    0.29139739f, 0.17749071f, 0.17584060f, 0.07203247f, 0.01590179f, 0.07115632f, -0.06965493f, -0.07149415f, 
    -0.08546041f, 0.05940314f, -0.00849568f, 0.03074394f, -0.10016477f, -0.14791955f, -0.28561929f, -0.11907977f, 
    0.06767224f, 0.07962424f, 0.05046064f, 0.10043389f, 0.00926395f, -0.03696395f, 0.00131122f, -0.03723209f, 
    -0.35334411f, -0.07829989f, -0.01677799f, -0.22055779f, 0.06770705f, 0.09004627f, 0.02569796f, -0.00663641f, 
    -0.10783133f, -0.05736453f, -0.13196099f, -0.10678998f, 0.09052094f, 0.41233787f, 0.19041805f, 0.33347002f, 
    -0.02198197f, 0.07576829f, 0.01887558f, 0.02424547f, -0.14108838f, -0.19257526f, -0.12800395f, -0.06392809f, 
    0.19220011f, 0.14464070f, 0.09090542f, 0.11754120f, -0.01377857f, 0.01427949f, -0.07429713f, 0.02601171f, 
    -0.06316308f, -0.04753068f, 0.02137171f, 0.01007411f, 0.15964143f, 0.00894424f, 0.19102639f, 0.26649764f, 
    0.07740662f, -0.01485684f, 0.08168364f, -0.02393380f, 0.00324817f, 0.03147765f, 0.02641628f, 0.02789729f, 
    0.07955465f, 0.19987451f, 0.12289757f, 0.08719804f, 0.00472173f, 0.07331941f, 0.07240977f, 0.26990470f, 
    -0.03949914f, 0.05707305f, 0.08566215f, 0.16569272f, -0.30346739f, -0.05149882f, -0.20525900f, 0.17083278f, 
    0.04400103f, -0.03404092f, 0.00255122f, -0.12379672f, -0.12401422f, -0.01670150f, -0.11996971f, -0.04948956f, 
    0.02578216f, -0.06859820f, 0.02570014f, -0.00953742f, -0.05316520f, 0.05596023f, 0.05601900f, -0.00185213f, 
    0.02449314f, 0.05889961f, -0.05205668f, -0.05738164f, 0.03625815f, 0.00214353f, 0.02243484f, 0.06698494f, 
    -0.04904883f, -0.04180642f, -0.03983079f, -0.06212373f, -0.02512891f, 0.01235049f, -0.06722607f, 0.04910345f, 
    -0.03596095f, 0.06334255f, 0.00918158f, -0.04002086f, -0.06942662f, -0.07281131f, -0.02180651f, 0.05920766f, 
    0.02181567f, 0.01859826f, -0.02264522f, 0.01046520f, -0.05923419f, -0.05950439f, 0.00668720f, -0.06482483f, 
    0.01390741f, -0.03410200f, -0.04399814f, -0.06945335f, -0.04201935f, -0.03605064f, 0.00596580f, -0.02052051f, 
    -0.00998935f, -0.01590350f, 0.00837505f, 0.03896936f, 0.00145606f, 0.00105196f, 0.01844021f, 0.02720015f, 
    -0.01900068f, 0.01619850f, -0.04421533f, -0.00093006f, -0.05513007f, -0.01263888f, -0.02361700f, 0.04309000f, 
    0.05934981f, -0.01789987f, -0.02690067f, 0.00323478f, 0.03111659f, 0.00623707f, -0.03893489f, 0.02295529f, 
    -0.02542421f, 0.01756665f, -0.01584342f, -0.05642138f, 0.04436956f, 0.02498947f, 0.03166823f, -0.05720321f, 
    0.00109694f, 0.01318037f, -0.05669134f, 0.05125145f, -0.02551909f, -0.06702019f, -0.05865901f, -0.04880757f, 
    -0.00028184f, 0.03798978f, 0.01877358f, -0.04586112f, -0.03372043f, 0.00536613f, -0.02687219f, 0.05499111f, 
    -0.07678729f, -0.05348662f, -0.04999736f, 0.02003829f, -0.02467261f, -0.01582598f, 0.00927298f, -0.00161529f, 
    -0.02481545f, -0.07211260f, -0.02823981f, -0.00225969f, -0.04348776f, 0.05987145f, -0.04137485f, -0.04366115f, 
    -0.06762204f, 0.04987078f, 0.05460089f, -0.02662094f, -0.02056015f, 0.02516416f, 0.01755781f, -0.05014483f, 
    -0.06437195f, -0.06912050f, 0.03033807f, -0.06005645f, -0.06562891f, 0.02138660f, 0.03762816f, -0.01454685f, 
    -0.01783352f, 0.05170690f, -0.00725285f, -0.00182124f, 0.05391455f, -0.00904353f, -0.02246772f, 0.04516656f, 
    -0.05556199f, -0.06650310f, -0.04533469f, 0.06444997f, 0.01971629f, 0.03365463f, -0.01427752f, -0.05333081f, 
    -0.01343601f, -0.02745759f, 0.01881072f, 0.05936410f, -0.00517749f, 0.05797772f, 0.04572054f, 0.02531761f, 
    -0.02396873f, -0.03777588f, 0.07162828f, 0.00373773f, 0.00755872f, 0.02279669f, -0.06977725f, -0.00786877f, 
    -0.03467802f, 0.05530005f, -0.04108953f, -0.06465123f, 0.01238507f, 0.01893659f, -0.03154927f, -0.01461628f, 
    -0.04026584f, 0.02807556f, 0.02812537f, -0.02092955f, -0.06512016f, -0.04537912f, 0.04383199f, -0.00093925f, 
    -0.03960926f, 0.02696011f, -0.03798143f, 0.01127317f, -0.01637060f, -0.05483179f, -0.02908686f, -0.04925706f, 
    0.03951761f, 0.04343585f, -0.02188578f, 0.01216888f, -0.02638211f, 0.01553294f, -0.00318339f, -0.05959164f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.11251536f, -0.07416350f, -0.01299120f, 0.08409162f, 0.00826862f, -0.06097553f, 0.12643680f, 0.21856527f, 
    0.02556138f, -0.07158402f, 0.06638949f, 0.00220489f, -0.00217893f, 0.03503908f, 0.09634349f, -0.10769436f, 
    -0.02546898f, -0.09215219f, -0.00945821f, 0.06277803f, -0.08113141f, 0.04369593f, 0.15203182f, 0.14801645f, 
    0.17409205f, 0.15295258f, 0.06994992f, 0.05270781f, 0.12718676f, 0.02580227f, 0.01736270f, -0.02833257f, 
    0.08890362f, -0.18008503f, 0.00728715f, -0.00263891f, 0.11185120f, -0.12123104f, -0.05483541f, 0.15806811f, 
    0.06929399f, 0.12764463f, -0.00647786f, 0.08012000f, -0.02085252f, -0.04719567f, 0.03275643f, 0.17907365f, 
    0.11333849f, -0.03261548f, -0.04333540f, -0.08542807f, -0.02878211f, 0.19530143f, 0.17139496f, -0.06225608f, 
    -0.12746254f, 0.10441687f, 0.07769606f, -0.04419510f, -0.12980112f, 0.02364617f, 0.17234388f, -0.15369385f, 
    0.02477683f, 0.13492653f, -0.05603752f, 0.04873259f, 0.21842714f, 0.17982449f, -0.02824417f, 0.02372083f, 
    0.08057932f, 0.06110851f, 0.15981185f, 0.08005558f, 0.02484114f, 0.21292184f, -0.06878045f, 0.03120789f, 
    0.15020296f, 0.17211913f, -0.07100284f, -0.02954780f, -0.06900558f, 0.20252195f, 0.21864365f, -0.06064816f, 
    0.07033519f, 0.08521120f, 0.21380921f, -0.01779880f, 0.05320499f, 0.02064477f, 0.09728371f, 0.13180195f, 
    0.01747439f, 0.09071437f, 0.04907843f, 0.16718091f, 0.01057217f, -0.08026548f, 0.20058127f, -0.00839159f, 
    0.05577156f, -0.07890088f, 0.11388214f, -0.03284454f, 0.01808254f, 0.11430780f, -0.07941549f, 0.25233361f, 
    0.09593394f, 0.05221566f, 0.07152534f, -0.08224699f, -0.04123485f, 0.18621001f, -0.04011293f, 0.00171307f, 
    0.01314046f, 0.05023956f, -0.05148280f, -0.01227371f, 0.02068307f, 0.02417591f, -0.04220886f, -0.06541488f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.18394449f, -0.00822348f, 0.23865448f, -0.16630681f, 0.19118740f, 0.10940222f, 0.06181977f, -0.37525931f, 
    0.02316533f, -0.07606650f, 0.01637975f, -0.00335139f, -0.13682458f, 0.23541729f, -0.06106706f, 0.23963270f, 
    0.23207766f, -0.13203189f, -0.00482277f, 0.20261133f, 0.13636722f, 0.07342569f, -0.06457070f, -0.07905082f, 
    0.03808223f, -0.31144080f, -0.31046262f, 0.17608178f, -0.29834697f, 0.05330961f, 0.02334371f, 0.10740498f, 
    -0.18925297f, 0.12295108f, 0.13220899f, -0.28207013f, -0.02811757f, 0.17780402f, 0.18081860f, 0.01239993f, 
    -0.13027178f, -0.42770326f, -0.05204964f, -0.06689426f, 0.32794616f, -0.04652682f, -0.36558482f, -0.06771456f, 
    -0.07259170f, -0.02533605f, -0.13679598f, 0.09077758f, 0.01790381f, -0.39163786f, -0.54998130f, -0.03900780f, 
    0.23799810f, -0.04845692f, -0.15943801f, 0.10136850f, 0.03491478f, -0.31243718f, -0.24546850f, 0.01700699f, 
    -0.16275486f, 0.02614779f, -0.11886077f, -0.04840154f, -0.20365372f, -0.41543585f, 0.14884415f, -0.04445462f, 
    -0.23688945f, -0.35579133f, -0.09193944f, 0.00198638f, 0.21813932f, -0.40914601f, 0.02456523f, 0.20798945f, 
    -0.02107743f, -0.16375816f, -0.08740167f, -0.34634069f, 0.02973332f, 0.18772215f, -0.19943476f, 0.03885905f, 
    -0.00203399f, 0.17836210f, -0.16528083f, 0.06961959f, 0.07214431f, -0.01368577f, -0.33058017f, -0.50446081f, 
    -0.00572169f, 0.05043890f, -0.05915415f, -0.29984459f, 0.11292510f, 0.15422797f, 0.02434226f, 0.10461444f, 
    -0.17596520f, 0.07706982f, 0.16020104f, 0.07677143f, -0.06331801f, 0.07181996f, 0.15300246f, -0.34425238f, 
    -0.19074005f, -0.06275478f, -0.14273500f, -0.16281483f, -0.00992613f, -0.32064909f, 0.02304613f, -0.26822925f, 
    -0.20099588f, -0.40712810f, -0.04124970f, 0.02869818f, 0.05861968f, -0.05512399f, 0.07406270f, -0.04303065f, 
    0.21411724f, -0.04846685f, 0.22344336f, -0.17892186f, -0.05153844f, 0.01053313f, 0.08038060f, -0.22461164f, 
    0.05805361f, -0.06277852f, 0.15563975f, 0.07048896f, 0.28426993f, -0.47202286f, 0.38881508f, 0.11831656f, 
    -0.45830864f, -0.10144257f, 0.02985158f, -0.01717181f, -0.00840688f, -0.08236416f, 0.18953070f, 0.10046380f, 
    0.19964388f, 0.16345802f, -0.41564488f, -0.23214449f, 0.14349715f, -0.00345832f, 0.05158729f, -0.64257759f, 
    -0.03289555f, -0.20272133f, 0.08938924f, -0.09785798f, 0.12274821f, 0.02860772f, -0.01608134f, 0.13568558f, 
    -0.13542020f, -0.15358633f, -0.09292963f, 0.06948163f, -0.13114080f, 0.07099448f, -0.48034829f, 0.05243728f, 
    0.01063568f, 0.00979937f, -0.19149575f, -0.30915007f, -0.04897530f, 0.17376903f, -0.09435722f, 0.02319583f, 
    0.17443913f, -0.07274360f, -0.22845429f, 0.12390447f, -0.00758616f, -0.10643090f, -0.13803776f, -0.50765586f, 
    0.14615692f, 0.15950100f, -0.18097512f, 0.19619910f, 0.13665952f, -0.21345365f, -0.42414704f, -0.04552212f, 
    0.11406952f, 0.13599141f, -0.03648859f, 0.02891049f, -0.25917745f, 0.36618736f, 0.02308620f, 0.05322022f, 
    0.17549954f, 0.29929456f, -0.05097121f, 0.18423921f, -0.27254835f, 0.21941750f, 0.19177602f, 0.10121545f, 
    -0.01397755f, -0.02849019f, -0.21770626f, -0.02552943f, -0.04713532f, 0.06827307f, -0.49216992f, 0.06305097f, 
    -0.13636513f, -0.00171747f, -0.06202266f, -0.04638824f, -0.19212817f, -0.12955379f, -0.03888860f, -0.09814737f, 
    0.09815925f, -0.00569046f, 0.10596171f, -0.21614392f, 0.04392049f, 0.17268299f, 0.03964138f, 0.22749530f, 
    0.13839430f, 0.13664696f, 0.04649451f, -0.25932619f, 0.03000906f, 0.02423316f, -0.00475345f, -0.01729612f, 
    -0.02866014f, -0.17645627f, -0.03928052f, 0.03472928f, 0.25654235f, 0.01683337f, 0.10043379f, -0.03746464f, 
    0.05828977f, 0.07262859f, 0.00299802f, -0.11201444f, -0.19545671f, -0.13593371f, 0.06458379f, 0.14129283f, 
    0.05006242f, -0.19929719f, 0.02804885f, -0.03657992f, -0.40854943f, 0.05714796f, -0.19736417f, -0.08059772f, 
    -0.44385365f, -0.22906303f, -0.00855099f, -0.01263872f, -0.05094844f, -0.08973517f, 0.26740295f, -0.14427535f, 
    0.06451038f, -0.13301240f, -0.08094736f, 0.28911865f, 0.05577219f, 0.09164311f, 0.00941603f, 0.43258840f, 
    -0.03352118f, -0.21635640f, -0.08157131f, 0.02945732f, 0.17195755f, 0.07067393f, -0.52546877f, 0.26452333f, 
    -0.24514394f, -0.08819762f, -0.09167774f, 0.05575527f, -0.36505491f, 0.04668580f, -0.18826945f, 0.00032165f, 
    0.07275546f, -0.08026984f, -0.20314993f, -0.28032324f, -0.01578931f, 0.31020969f, 0.16878834f, 0.01305225f, 
    -0.02080852f, -0.00449240f, 0.02282421f, -0.20049633f, -0.15763536f, -0.12695645f, 0.12991327f, -0.43478635f, 
    -0.21495901f, 0.11301876f, -0.03516538f, 0.07459153f, 0.16110785f, 0.28620496f, 0.22770128f, -0.04912188f, 
    -0.14141999f, 0.11327211f, 0.11368313f, -0.02976565f, -0.09206338f, -0.78904986f, -0.08872209f, -0.20903210f, 
    0.11996375f, -0.92803383f, -0.03781614f, -0.02118375f, 0.16183585f, 0.05396461f, -0.28464741f, 0.06797505f, 
    -0.20316061f, 0.00040676f, 0.13978602f, -0.07680286f, 0.06149513f, 0.09749661f, 0.09527611f, 0.16565593f, 
    -0.05033256f, 0.12532075f, -0.06933542f, 0.03668519f, -0.37660381f, -0.17834361f, 0.15847282f, 0.14595385f, 
    -0.10268913f, 0.06319176f, 0.09973566f, 0.12009008f, -0.04212843f, 0.10896987f, -0.11307774f, -0.03009060f, 
    -0.04287905f, -0.05655817f, -0.01678693f, -0.15348174f, -0.05797673f, 0.15169957f, 0.00293125f, 0.11692078f, 
    -0.29298392f, 0.00542235f, -0.00218677f, 0.05873157f, -0.29145879f, -0.40003732f, 0.07372370f, 0.06040199f, 
    0.21067962f, 0.05484637f, -0.03290156f, -0.18655805f, -0.50349551f, 0.21981363f, -0.20449896f, 0.03065363f, 
    -0.52891755f, 0.21470363f, 0.10176738f, -0.06068135f, -0.08394276f, 0.02784467f, -0.25198495f, 0.11810382f, 
    -0.14709660f, 0.23046574f, 0.01471465f, -0.09698523f, -0.00917135f, -0.05679782f, -0.45261550f, -0.01562154f, 
    -0.17657195f, -0.36546025f, -0.01879219f, 0.13885772f, -0.12875161f, 0.09134681f, 0.05730117f, 0.11913512f, 
    0.20794505f, 0.23385860f, -0.15268131f, 0.07239656f, -0.17338786f, 0.29255864f, 0.03182058f, 0.03298492f, 
    0.13062786f, -0.21179515f, -0.43385693f, -0.01396949f, -0.41809836f, -0.08021716f, 0.08048485f, -0.34949932f, 
    -0.22596239f, -0.05477784f, 0.10933037f, 0.24769768f, -0.03698869f, 0.26826856f, -0.28065059f, -0.05636912f, 
    -0.07391389f, -0.04922617f, 0.13316751f, 0.04133995f, 0.08887816f, 0.00019184f, -0.20277654f, -0.10958543f, 
    -0.20684746f, -0.29426989f, 0.15257753f, -0.16679057f, 0.00199226f, 0.08425356f, 0.10977043f, 0.01719300f, 
    -0.10309293f, 0.11560594f, -0.13909110f, 0.14559318f, 0.01427484f, -0.30843228f, -0.07598065f, -0.19305561f, 
    -0.00059322f, -0.44834402f, 0.06878842f, 0.38367140f, 0.18751924f, -0.19381392f, -0.18084659f, 0.11030572f, 
    -0.02094523f, -0.10917165f, 0.04470863f, 0.03786136f, -0.02492853f, -0.04886312f, 0.08937724f, -0.00693001f, 
    -0.04262771f, -0.19623372f, -0.07506775f, 0.04620064f, 0.16789688f, 0.17212878f, -0.48412395f, -0.08975589f, 
    -0.31264374f, -0.01434302f, -0.25252017f, 0.03927033f, -0.01763024f, 0.22094491f, 0.02981356f, -0.39558363f, 
    -0.13132475f, -0.39479354f, -0.07085663f, 0.11701941f, 0.12214334f, 0.28002223f, 0.07114168f, 0.10843641f, 
    0.18165444f, -0.14184397f, 0.07598948f, -0.00264125f, -0.00394858f, -0.10438383f, 0.08790361f, -0.06992985f, 
    0.04138397f, -0.07204203f, 0.05770361f, -0.30632606f, 0.04608346f, 0.17414719f, 0.08870130f, -0.05833275f, 
    0.06785432f, -0.15823862f, 0.05313746f, 0.03389735f, -0.25247592f, 0.06594110f, -0.29113942f, 0.07662470f, 
    0.06272821f, 0.15649073f, -0.05812826f, 0.05611215f, -0.08015867f, 0.04263528f, -0.04375025f, -0.55994272f, 
    -0.34743640f, 0.14518100f, 0.16475663f, 0.01895283f, -0.19227065f, -0.20822644f, -0.02096955f, 0.07790028f, 
    -0.14771004f, 0.06579783f, -0.01809028f, -0.10377633f, -0.05517080f, -0.04913279f, 0.10704888f, 0.09984608f, 
    -0.16552928f, 0.12382637f, -0.00856285f, -0.05949195f, -0.03713885f, 0.00170641f, 0.16371411f, -0.05534792f, 
    0.07321959f, -0.08834440f, 0.09665833f, 0.05285977f, 0.00180012f, -0.18437871f, 0.09819808f, -0.02193520f, 
    0.10869037f, -0.19681473f, -0.36953562f, 0.02704767f, 0.12513538f, 0.17647463f, 0.10318535f, 0.26750791f, 
    -0.27000642f, -0.61804533f, 0.08204180f, 0.15952574f, -0.19176994f, -0.13556103f, 0.08163121f, -0.08019154f, 
    -0.23740277f, -0.24031781f, -0.01849239f, -0.02614066f, -0.07370406f, 0.05676802f, 0.07415064f, -0.27278316f, 
    -0.49099815f, -0.28769797f, -0.02842693f, -0.16403939f, 0.01604050f, -0.46566796f, 0.18206039f, -0.23118599f, 
    0.04986110f, -0.36619446f, -0.50169289f, 0.05773272f, -0.01686263f, 0.06695127f, 0.00474276f, -0.09034786f, 
    0.02052595f, 0.10578261f, -0.07177876f, -0.16395567f, 0.00754686f, 0.10889214f, -0.19818576f, 0.13127479f, 
    0.03535537f, 0.00806188f, -0.09634606f, 0.18629782f, 0.02897891f, -0.16385888f, 0.17425442f, -0.09025055f, 
    0.03003982f, 0.17824751f, 0.16309652f, 0.17631125f, 0.14852133f, -0.38987002f, -0.01865640f, -0.13488381f, 
    0.10077582f, 0.20887345f, -0.07098482f, -0.06115815f, -0.19237278f, 0.04816828f, 0.13611424f, 0.06114347f, 
    -0.10790937f, 0.02963150f, 0.04375448f, 0.15443498f, 0.16007185f, -0.22155988f, -0.02163759f, 0.03281226f, 
    -0.03840918f, -0.07282881f, -0.05163503f, 0.05153506f, 0.10071181f, 0.26124090f, -0.05716778f, -0.07213796f, 
    0.36505133f, 0.12655577f, -0.04132307f, 0.09920277f, -0.14184657f, -0.04811253f, 0.09005207f, 0.15975355f, 
    -0.25279209f, 0.09546746f, 0.09480999f, -0.29210383f, -0.19762115f, -0.12876105f, -0.04965098f, -0.24756485f, 
    0.06426420f, -0.06205877f, 0.08140845f, -0.03728553f, -0.25210011f, -0.13856301f, 0.09237756f, 0.03260124f, 
    -0.15981013f, 0.02127651f, 0.00001467f, -0.24896072f, 0.40394503f, 0.05745073f, -0.04089198f, 0.18596578f, 
    0.02824915f, 0.06827383f, -0.04331735f, -0.31424701f, 0.03275680f, -0.23512362f, -0.13304484f, 0.00031377f, 
    -0.14640242f, 0.17559636f, -0.18007690f, 0.09986398f, 0.07414974f, 0.02426878f, 0.27708316f, 0.02517163f, 
    0.23363194f, 0.31036451f, -0.00059924f, -0.09331734f, -0.14183158f, 0.17489558f, -0.03390815f, 0.00490822f, 
    -0.09909760f, -0.31798461f, -0.11293798f, 0.08394407f, 0.07807103f, 0.03033651f, -0.09312591f, 0.20268810f, 
    -0.07553919f, 0.03898970f, -0.03273809f, -0.55084491f, -0.20778461f, 0.25992081f, -0.04414074f, -0.13082856f, 
    0.04688099f, 0.08417767f, 0.02191872f, 0.00880801f, 0.00303394f, -0.21755557f, -0.06302512f, 0.02205453f, 
    0.16936372f, 0.00463992f, 0.05699201f, -0.23897164f, 0.16349511f, -0.19094835f, 0.13741566f, -0.29893631f, 
    0.10701890f, -0.04528936f, -0.00540427f, 0.12446050f, 0.02669961f, 0.05505173f, 0.01430041f, 0.21317653f, 
    0.13685964f, 0.14299545f, 0.11356406f, -0.08335764f, 0.03638798f, -0.06679728f, -0.01087950f, 0.13177183f, 
    0.04129557f, -0.23231949f, 0.05626866f, -0.00539555f, -0.03029674f, 0.13152853f, -0.06221707f, 0.05610043f, 
    -0.24892877f, 0.07400295f, -0.39969623f, 0.16980751f, -0.11073214f, -0.43853828f, 0.14235440f, 0.24237230f, 
    0.01808180f, -0.18414858f, -0.31061110f, -0.02791548f, -0.27279076f, -0.07664876f, -0.06381821f, -0.29528645f, 
    -0.34100750f, -0.24662034f, -0.04331908f, -0.30885762f, -0.17291157f, -0.06782450f, -0.08789846f, -0.10680640f, 
    0.10401355f, 0.29432160f, 0.29956484f, 0.38671443f, 0.03204349f, -0.01226033f, -0.06969741f, -0.02745963f, 
    0.07520881f, -0.36619905f, -0.15089321f, 0.07316468f, 0.14628834f, -0.07693765f, -0.38577521f, -0.64776927f, 
    -0.22459461f, 0.08659560f, 0.07397495f, -0.08249105f, -0.22899053f, 0.04274982f, -0.10975419f, 0.00841568f, 
    -0.16056015f, -0.05056253f, 0.07724362f, 0.17127693f, -0.01673875f, 0.10063012f, 0.23510396f, -0.02712826f, 
    -0.47451562f, 0.03884248f, 0.25740600f, -0.76339388f, -0.01030771f, -0.29019108f, -0.01525434f, 0.12451103f, 
    -0.19197725f, -0.04181056f, 0.03773110f, 0.16521837f, -0.03110500f, 0.29046634f, -0.26330963f, 0.06010730f, 
    -0.00069082f, 0.14249831f, 0.13106047f, -0.48023707f, 0.18514018f, 0.03206525f, 0.00816322f, -0.38723588f, 
    0.08068250f, -0.23246112f, -0.00660708f, -0.09476319f, -0.36910251f, -0.34172654f, 0.06983721f, -0.21103403f, 
    0.32780787f, 0.26948205f, 0.30390173f, -0.05874370f, -0.07577230f, -0.03669889f, 0.25484413f, -0.06246740f, 
    -0.09508085f, -0.08100162f, -0.02563268f, 0.24290246f, -0.11162462f, -0.62634456f, 0.15288071f, -0.22046371f, 
    -0.15286551f, 0.00193396f, -0.13081367f, -0.17451820f, 0.03996084f, -0.58566380f, -0.67754334f, 0.13099843f, 
    -0.00079945f, -0.07045775f, 0.01996144f, -0.37175623f, 0.14119002f, 0.00117063f, -0.00509856f, -0.14569645f, 
    -0.06741074f, 0.22191457f, -0.04704794f, -0.06760249f, 0.16546421f, 0.02031351f, -0.23353879f, -0.05647011f, 
    -0.29941860f, 0.07694706f, -0.15080659f, 0.09843570f, 0.20622388f, -0.38364303f, -0.28711742f, -0.14171450f, 
    0.18776581f, 0.08072382f, -0.35027447f, -0.02591642f, 0.13643864f, 0.05708756f, -0.11478534f, -0.09716614f, 
    -0.17540354f, 0.15372314f, -0.07705510f, -0.20583108f, -0.07062054f, 0.04243477f, -0.06613032f, -0.05804438f, 
    -0.21602345f, -0.06574497f, -0.25234896f, -0.12757707f, 0.01562417f, 0.13581923f, -0.01606415f, 0.20068701f, 
    -0.30916879f, 0.29985866f, -0.12853821f, 0.12569289f, -0.00417163f, 0.06387421f, -0.35264897f, -0.15714130f, 
    -0.04132829f, 0.01791736f, 0.18730326f, 0.23301144f, 0.21340938f, -0.09945920f, 0.25707075f, 0.08315208f, 
    0.21612577f, -0.05435481f, -0.19594339f, -0.02621742f, -0.06709603f, -0.13804665f, 0.05288330f, 0.02399977f, 
    -0.17580329f, -0.48985878f, -0.03592841f, 0.07878970f, -0.05177999f, -0.03682338f, -0.20325902f, 0.36978975f, 
    0.15116768f, -0.15679918f, 0.10761809f, -0.11228060f, -0.23120239f, -0.16682269f, 0.33058381f, -0.08128977f, 
    0.09266520f, 0.00716676f, -0.24927211f, -0.46385938f, -0.25152871f, -0.29884008f, -0.03997006f, -0.02829381f, 
    0.06585134f, -0.12605333f, 0.02947416f, 0.12006164f, 0.16846864f, -0.16331121f, 0.04173825f, 0.25923187f, 
    -0.17368707f, -0.27481100f, -0.11764736f, 0.04500518f, -0.01612629f, -0.08501542f, -0.15333523f, 0.07328448f, 
    0.07956678f, -0.04209469f, 0.02738103f, -0.11207242f, -0.17188595f, -0.06748316f, -0.05020191f, 0.34281370f, 
    0.22702797f, -0.09487521f, -0.18214542f, -0.42444333f, 0.00336592f, -0.14914018f, 0.04040932f, 0.07172079f, 
    -0.14951617f, 0.12894170f, 0.00968867f, 0.27847254f, 0.04908434f, -0.15788534f, -0.05741953f, 0.12614019f, 
    -0.21677615f, 0.01068649f, 0.02341817f, -0.03756585f, -0.43344718f, -0.15478466f, -0.40001824f, -0.03053304f, 
    0.08799853f, 0.05296796f, -0.07946493f, 0.26538625f, 0.23012541f, -0.11515900f, -0.09869242f, 0.05908933f, 
    -0.16409117f, 0.28241006f, 0.23929234f, -0.07337254f, -0.15266354f, -0.28747678f, -0.01332781f, -0.23874488f, 
    -0.30210361f, 0.20708832f, 0.07436521f, 0.19741565f, -0.14003731f, 0.00282334f, -0.18302073f, 0.19901709f, 
    0.20257680f, -0.38604188f, -0.09263487f, -0.30747819f, 0.02805114f, 0.15147355f, 0.08011155f, -0.18575567f, 
    0.25785193f, -0.20292783f, 0.18150832f, -0.03047288f, -0.28287354f, -0.17190504f, -0.60833251f, -0.00060502f, 
    0.16999385f, -0.09607061f, -0.00370097f, 0.07570992f, -0.12653857f, -0.05222487f, 0.17426580f, 0.23820674f, 
    0.07823613f, -0.07619622f, 0.08486971f, 0.20062484f, -0.02004464f, -0.29935387f, -0.12608494f, -0.10355444f, 
    -0.05957305f, 0.00224080f, 0.19097304f, -0.37623712f, -0.25727835f, -0.01665314f, 0.16592109f, -0.25206435f, 
    0.12639228f, -0.04818125f, 0.11171726f, -0.33250850f, 0.11951668f, 0.25081122f, 0.16635424f, 0.02375760f, 
    0.09895942f, -0.09607802f, -0.14725882f, 0.14484674f, -0.31570658f, -0.07718376f, 0.02627302f, 0.16089661f, 
    0.11188614f, 0.06855999f, -0.05056795f, -0.20809880f, -0.31349102f, 0.26721328f, -0.09992100f, 0.18014108f, 
    -0.14414354f, 0.07295334f, 0.04075555f, 0.03414841f, 0.02181249f, -0.06467656f, -0.45589316f, 0.14870976f, 
    0.31475583f, -0.23407386f, 0.00595666f, 0.21642037f, 0.02280990f, -0.33611411f, -0.05236750f, -0.36091551f, 
    -0.09471955f, -0.02692617f, -0.15487310f, -0.40880340f, -0.03746670f, 0.22040369f, -0.45308083f, -0.26337340f, 
    0.15674768f, -0.19309860f, -0.14921032f, -0.14513327f, -0.44961533f, 0.26638645f, -0.04059774f, -0.41819194f, 
    -0.04654391f, -0.09261112f, -0.03799749f, -0.05128553f, -0.22436899f, -0.16291262f, -0.54488349f, -0.07264120f, 
    -0.02343832f, -0.00967162f, -0.33687484f, -0.24395587f, 0.01708203f, -0.22106473f, 0.20681013f, 0.15454933f, 
    0.18709306f, -0.22561067f, 0.05912435f, 0.06975140f, 0.15995236f, -0.03263910f, -0.21243531f, -0.18585257f, 
    0.36587676f, -0.32168314f, 0.00821390f, -0.18391195f, 0.16763611f, 0.07224326f, 0.28443855f, -0.36150068f, 
    -0.07341687f, -0.01215412f, 0.14603584f, 0.04734592f, 0.20711982f, 0.04778622f, -0.02658965f, -0.02636609f, 
    -0.05165524f, -0.09955800f, -0.33550119f, 0.11452141f, 0.14615098f, -0.02564229f, 0.41382536f, -0.54825419f, 
    -0.39439595f, 0.01897922f, -0.02995897f, -0.14067420f, 0.35944510f, 0.03002271f, 0.07135597f, -0.49097142f, 
    0.14015795f, -0.08913995f, -0.09880903f, -0.27444753f, -0.06044735f, -0.20903286f, 0.13940699f, -0.04942347f, 
    -0.07531891f, 0.06308669f, -0.14131528f, -0.04017653f, -0.31225342f, -0.33673146f, 0.13321403f, 0.21640708f, 
    0.06892554f, -0.32908827f, -0.09963341f, -0.20289041f, -0.08038518f, -0.19062734f, 0.19169530f, -0.00691713f, 
    -0.02772008f, -0.07509486f, 0.27734929f, -0.19545552f, 0.08777086f, 0.15000445f, -0.09797327f, -0.26210022f, 
    0.08318400f, 0.05511138f, -0.05255186f, 0.12451386f, -0.04784306f, -0.17314120f, 0.01648968f, 0.01097320f, 
    -0.25459287f, -0.24770956f, 0.05211944f, 0.08131582f, -0.02923762f, -0.30518490f, 0.13565174f, -0.24421924f, 
    -0.08729633f, -0.16038974f, 0.06501613f, -0.16183376f, -0.35077924f, 0.27477109f, -0.04348503f, -0.16335841f, 
    -0.10093939f, 0.01141059f, 0.10275604f, 0.06944047f, 0.00019165f, -0.40047982f, 0.23327211f, 0.14207661f, 
    0.24974930f, 0.00380690f, 0.24231157f, 0.31225771f, -0.26017880f, 0.14557885f, -0.06949302f, -0.21581797f, 
    -0.05891717f, 0.26024291f, -0.09172193f, 0.04767463f, -0.24039920f, -0.03725028f, -0.03865603f, 0.00297466f, 
    0.11405117f, 0.00781751f, -0.05084170f, -0.05649308f, 0.07480297f, -0.34128460f, 0.09026403f, -0.33128190f, 
    -0.32191610f, 0.19093682f, -0.08129274f, -0.02144533f, -0.30465472f, -0.58012438f, 0.23575665f, -0.42438954f, 
    -0.66980267f, -0.13886695f, -0.03159242f, 0.08304327f, 0.26360679f, -0.06333997f, -0.32068262f, 0.23917395f, 
    -0.12392415f, 0.18768632f, 0.28455362f, -0.35624287f, 0.14718784f, -0.34796062f, -0.01411864f, -0.62050521f, 
    -0.02544110f, -0.52949727f, 0.08156317f, -0.22749460f, -0.01853308f, 0.11316736f, 0.00466150f, -0.02694589f, 
    0.19496103f, -0.02984096f, -0.03444619f, -0.09484502f, -0.32788882f, 0.07919032f, -0.09679850f, -0.10509439f, 
    -0.54059523f, -0.02409090f, 0.05929641f, 0.15002026f, -0.00112174f, 0.15556963f, -0.09181374f, -0.04955978f, 
    -0.33624861f, 0.08217047f, 0.04111838f, -0.21270998f, -0.16760828f, -0.04957004f, 0.12997119f, -0.20448296f, 
    -0.08732543f, -0.00336772f, 0.09866125f, 0.27172205f, 0.23557791f, -0.41354749f, -0.29694638f, 0.01359622f, 
    0.25390437f, -0.05148284f, 0.29323179f, 0.16980080f, 0.16193451f, 0.15244238f, -0.06110040f, 0.08775021f, 
    -0.14339548f, -0.51750875f, -0.05188311f, -0.26060501f, 0.04275338f, -0.29940543f, -0.37047485f, -0.18120304f, 
    0.26537150f, -0.01335275f, 0.18789278f, 0.05827449f, -0.04705923f, -0.20354611f, 0.04511591f, 0.03171922f, 
    -0.51123387f, 0.13997397f, -0.01823690f, -0.23876137f, 0.12819801f, -0.16937937f, -0.23470013f, 0.27775213f, 
    0.20696369f, 0.06589787f, 0.17263788f, -0.05579227f, -0.03346728f, 0.06623351f, -0.06285220f, 0.04962326f, 
    -0.35537237f, -0.44791222f, -0.24897821f, -0.45732296f, 0.00458988f, 0.06853041f, 0.01507811f, 0.38364395f, 
    0.28886095f, -0.01291123f, 0.07976811f, 0.00833844f, 0.31205717f, -0.05634094f, -0.09690136f, 0.03478875f, 
    -0.50772035f, -0.00590386f, -0.33284634f, 0.05932337f, -0.37372321f, -0.23451579f, -0.20495142f, 0.09942055f, 
    -0.05640500f, -0.01655567f, 0.04616009f, 0.01607329f, -0.02564618f, -0.14388128f, -0.19930202f, -0.02180738f, 
    -0.03387386f, -0.22302374f, 0.03873787f, -0.17564797f, -0.39816937f, 0.00409167f, -0.27916864f, -0.13049816f, 
    0.32068229f, 0.04953155f, 0.07991859f, -0.44865462f, 0.08650049f, 0.08527611f, 0.05499628f, -0.16833189f, 
    -0.34652731f, 0.26591656f, 0.05465087f, 0.05671087f, -0.03949364f, -0.46037677f, 0.02731886f, -0.10776902f, 
    0.28203243f, 0.22397347f, -0.02465171f, 0.03632006f, -0.43522400f, -0.05590904f, 0.16051751f, -0.05248227f, 
    0.11149105f, -0.05745028f, 0.23801953f, 0.27449107f, 0.01214903f, 0.27721357f, -0.01354054f, 0.05809388f, 
    0.08700324f, 0.25142634f, 0.24356091f, -0.38076374f, -0.15279746f, 0.32159746f, -0.30115503f, -0.37276092f, 
    0.05933506f, 0.15297247f, 0.20462210f, 0.22006443f, 0.28219971f, -0.11167715f, -0.36979878f, -0.05630550f, 
    0.00122764f, 0.13603938f, -0.13089383f, 0.12166733f, -0.01958804f, -0.15980516f, -0.03247818f, 0.12794951f, 
    -0.12744276f, -0.13568904f, -0.08492439f, 0.30707127f, 0.42117900f, -0.23403968f, -0.29998153f, -0.17852233f, 
    -0.08330090f, -0.27666906f, 0.18508340f, -0.03015501f, -0.08797917f, 0.23959650f, 0.00185101f, 0.22795463f, 
    -0.30973980f, 0.27741665f, -0.00885072f, 0.28538403f, -0.43225655f, -0.18223846f, -0.18999529f, -0.42172295f, 
    -0.19570944f, -0.09168508f, 0.04840819f, -0.06570884f, -0.05287110f, -0.06414539f, -0.02258206f, -0.46502087f, 
    -0.10237875f, -0.01791240f, -0.08843197f, 0.22779079f, 0.03956485f, -0.40768361f, 0.04941960f, -0.38032120f, 
    0.11679319f, -0.40780967f, -0.01517360f, -0.06222235f, 0.20925102f, 0.31116602f, 0.16859628f, -0.08046192f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13638209f, -0.01037943f, 0.06542142f, -0.07649363f, 0.07356076f, -0.05369204f, 0.09416422f, -0.04805514f, 
    0.04923625f, -0.01290400f, 0.06363080f, 0.04712320f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
