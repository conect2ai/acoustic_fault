#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.26814234f, -0.13913973f, -0.30146685f, 0.36282077f, -0.06376737f, -0.07882158f, 0.29344317f, -0.23581707f, 
    0.09713022f, 0.42850250f, 0.13227734f, -0.06881603f, 0.01571398f, 0.04233449f, 0.21879092f, 0.17794724f, 
    -0.13455006f, -0.06444035f, -0.06938965f, -0.31541312f, -0.04994131f, -0.26018256f, -0.10471628f, -0.09279754f, 
    -0.07131073f, 0.87754494f, 0.54162127f, 0.15405022f, -0.09936949f, 0.20955615f, -0.41564873f, -0.34175223f, 
    -0.54998100f, -0.25866935f, 0.14751527f, -0.21898237f, 0.30473948f, -0.16572787f, -0.15770954f, 0.41534331f, 
    0.10088109f, -0.22278632f, 0.05541008f, 0.39465588f, 0.00971663f, 0.12496363f, -0.22193943f, 0.23148723f, 
    0.05711747f, -0.24787742f, -0.88284898f, -0.69520783f, -0.43764278f, 0.43066314f, 0.65350616f, -0.42295411f, 
    -0.36650586f, 0.28736809f, 0.77011275f, 0.46789962f, 0.31914258f, 0.11568732f, 0.09005512f, 0.21823633f, 
    0.30975655f, 0.10342822f, -0.15678056f, -0.01677674f, -0.31833762f, -0.15393440f, -0.07647884f, -0.12796339f, 
    0.21429072f, -0.03542119f, 0.00048311f, 0.03284562f, -0.31059057f, -0.53497314f, -0.49692482f, -0.58086497f, 
    0.43231255f, -0.20034491f, -0.24225837f, 0.04853997f, -0.01907600f, 0.53131944f, 0.57015336f, 0.37518525f, 
    -0.23717149f, -0.34316212f, -0.14812641f, -0.13095172f, 0.51059520f, -0.35601044f, -0.35659361f, 0.15449812f, 
    -0.14272325f, -0.40407771f, 0.21679372f, -0.22865480f, 0.16056348f, -0.00411330f, 0.40811360f, -0.29890791f, 
    -0.69289458f, -0.79021484f, -0.50597805f, -0.58757335f, -0.46956256f, -0.74659109f, 0.29769668f, -0.08033783f, 
    -0.13416177f, -0.20676202f, 0.28987026f, 0.30996814f, 0.35077640f, 0.24428277f, 0.21896252f, 0.16412520f, 
    0.03452716f, -0.10817719f, -0.14071909f, -0.11290498f, 0.17579883f, -0.36621946f, -0.77916276f, -0.58459282f, 
    -0.52101326f, 0.14030932f, 0.88045794f, 0.88423431f, 0.27837598f, -0.11361526f, -0.03252393f, 0.44434544f, 
    0.27411151f, -0.09031222f, 0.08133737f, -0.35074928f, -0.09296318f, 0.05917966f, 0.26313055f, -0.54270697f, 
    -0.09947812f, -0.26802406f, 0.00398982f, -0.15644269f, 0.28165686f, -0.13768259f, -0.33748555f, -0.36916077f, 
    -0.76325148f, 0.37662110f, 0.01291329f, -0.19468299f, 0.27154580f, 0.02666950f, -0.29119954f, -0.57337022f, 
    -0.30246609f, -0.60395175f, -0.26793236f, 0.52872819f, -0.60281223f, 0.04137982f, -0.14682566f, 0.21406764f, 
    -0.16745748f, 0.09000062f, -0.05209839f, -0.06787066f, -0.03237665f, -0.19776554f, 0.22872771f, 0.63652164f, 
    0.24735817f, 0.37322995f, -0.30017835f, -0.80254322f, -0.32026914f, -0.31429943f, 0.10112547f, 0.24211673f, 
    0.37142947f, -0.17614214f, 0.01178835f, 0.44994649f, -0.53186864f, 0.28932241f, -0.16462997f, -0.04942873f, 
    0.17976955f, 0.00540405f, -0.19535807f, 0.06889775f, 0.09887141f, -0.10635171f, -0.09385546f, 0.19143686f, 
    -0.10323543f, 0.08288140f, 0.16763876f, -0.12380705f, 0.18802446f, -0.19337951f, -0.17313839f, -0.29556710f, 
    0.19995826f, 0.13216724f, 0.29360902f, 0.07176030f, -0.31223789f, -0.21679172f, 0.20554630f, 0.16899560f, 
    0.16510941f, -0.07196257f, 0.19521667f, 0.06713156f, 0.21726285f, 0.29987082f, -0.00833228f, 0.08375602f, 
    -0.12228899f, -0.39886194f, -0.39518663f, -0.43013981f, -0.09216335f, -0.04911431f, 0.10886858f, -0.29625174f, 
    0.37251416f, -0.38794920f, -0.06128632f, -0.01208620f, -0.28140911f, 0.50011724f, 0.02472267f, -0.19401734f, 
    0.10292009f, -0.24206971f, -0.03790336f, 0.06341930f, -0.09421376f, -0.08218424f, 0.15565416f, 0.26974583f, 
    0.20799831f, 0.25434855f, 0.61798298f, 0.73025876f, -0.31227511f, -0.47517321f, -0.16122420f, 0.21313561f, 
    0.36362454f, 0.00271743f, -0.44593555f, -0.15605688f, 0.73788720f, -0.53328210f, -0.18112689f, -0.18962629f, 
    0.16309057f, -0.23901676f, 0.18816119f, 0.01553948f, 0.01169916f, -0.10185961f, 0.00354289f, 0.12768106f, 
    0.13802953f, -0.17405026f, -0.18449537f, 0.79391903f, 0.33880755f, -0.27120659f, 0.04633486f, 0.43593565f, 
    -0.12001029f, 0.42039397f, 0.25913197f, 0.04486012f, -0.25288597f, -0.39918420f, 0.08581544f, 0.35272995f, 
    0.08184762f, -0.34195453f, 0.09179363f, -0.24942099f, -0.04132636f, 0.14835450f, -0.04834757f, -0.18670942f, 
    0.15658985f, 0.13459051f, -0.02310828f, 0.02978884f, 0.59757352f, -0.22321002f, -0.34023130f, -0.28207049f, 
    -0.27608815f, 0.39641210f, 0.30827442f, 0.38279879f, -0.02515165f, 0.10621787f, -0.03787865f, 0.57109070f, 
    -0.36431515f, -0.17353280f, -0.19604328f, -0.01988132f, -0.23050222f, -0.22603306f, 0.06895870f, 0.31566650f, 
    0.37045431f, 0.15641370f, 0.19942348f, 0.12345702f, 0.21895610f, -0.65248936f, -0.71758020f, -0.06159131f, 
    0.46104142f, -0.06734910f, -0.17671750f, -0.17523801f, -0.36528072f, -0.35262832f, -0.32618791f, -0.03583237f, 
    0.22434865f, -0.31464025f, -0.30492473f, -0.33036098f, 0.07801150f, -0.03335533f, -0.11351199f, -0.17074853f, 
    -0.06842069f, -0.26094627f, -0.04017085f, -0.19278105f, -0.19445202f, -0.31211051f, -0.31645718f, -0.00529059f, 
    -0.36302635f, 0.59146160f, -0.33758086f, -0.01329372f, -0.11786591f, -0.60549074f, -0.41027808f, -0.12093403f, 
    0.62869275f, -0.53147149f, -0.00523193f, 0.05032685f, 0.28891090f, -0.12973371f, -0.08567180f, 0.08582099f, 
    -0.41937459f, -0.44423985f, 0.23626052f, -0.25244176f, 0.25181842f, 0.22766908f, 0.10004264f, 0.45989263f, 
    0.28818479f, 0.30802903f, 0.38633752f, -0.07746889f, -0.74174297f, -0.52404487f, 0.54672360f, 0.32145658f, 
    0.09116984f, 0.22160642f, 0.31293505f, -0.22689119f, -0.17933093f, -0.07355093f, 0.11174301f, 0.14373639f, 
    -0.22910184f, -0.25624731f, -0.17789543f, -0.15363006f, 0.00680427f, 0.02908899f, 0.01204320f, 0.25325948f, 
    0.13390192f, -0.25990009f, -0.36434278f, 0.26193216f, -0.22579280f, -0.15185708f, 0.05010448f, -0.21122338f, 
    0.13060817f, 0.00846883f, 0.22518803f, -0.10449047f, 0.24561806f, 0.06319511f, -0.27755940f, -0.37343428f, 
    -0.07552893f, 0.08342776f, -0.28777054f, -0.35391173f, 0.32046977f, 0.31311327f, 0.17691669f, 0.25597620f, 
    0.37379938f, 0.53001225f, -0.58881879f, -0.22191113f, -0.12400945f, -0.57361263f, 0.01056320f, 0.26477459f, 
    0.20230669f, 0.57030684f, -0.79838371f, -0.01600207f, 0.00005248f, 0.04595425f, -0.06547263f, 0.31900504f, 
    0.08817803f, -0.07028414f, -0.22260551f, -0.29529396f, 0.12148171f, 0.12759081f, -0.47211769f, 0.20756772f, 
    0.36085418f, -0.24953674f, 0.10206009f, -0.66726011f, -0.56469733f, -0.52321929f, -0.35521758f, 0.04783860f, 
    -0.09982654f, 0.13107859f, 0.56824040f, 0.66810983f, 0.07781620f, -0.09622555f, -0.16897531f, -0.15076178f, 
    0.23409200f, -0.25791359f, -0.14455827f, 0.13207288f, 0.44955999f, 0.11225196f, 0.25426486f, -0.40124148f, 
    -0.06562158f, -0.22057861f, -0.01307935f, 0.10359522f, -0.52000612f, 0.67222029f, 0.04350394f, -0.20267433f, 
    -0.40286687f, -0.03865473f, 0.34266788f, -0.31451362f, -0.22293811f, -0.09985211f, -0.18042932f, -0.15706280f, 
    -0.13224036f, 0.51706618f, -0.20839095f, -0.18834439f, 0.02913601f, 0.02286480f, 0.02617666f, -0.06408822f, 
    -0.27973595f, -0.07570496f, -0.21490386f, -0.34538996f, -0.74518752f, -0.02483207f, -0.12602052f, -0.83604282f, 
    -0.44834229f, -0.02301449f, -0.10413790f, 0.35365912f, 0.26047459f, 0.05851781f, -0.26807398f, -0.33100721f, 
    -0.39306688f, -0.45334521f, 0.13826358f, 0.22777756f, 0.42419434f, 0.30980837f, 0.06894368f, 0.12243218f, 
    -0.19191332f, -0.02374687f, -0.17818685f, -0.37419665f, -0.51603818f, -0.04118411f, 0.25047925f, -0.13600653f, 
    0.35679874f, 0.33523872f, -0.36013907f, -0.41187707f, 0.00951004f, -0.02389563f, -0.26056489f, -0.10078394f, 
    -0.19198957f, 0.22971272f, -0.23554997f, -0.05017534f, 0.14412715f, 0.13906679f, 0.11821888f, -0.33128500f, 
    0.15941988f, -0.16284715f, 0.26618803f, 0.26997188f, 0.32043123f, 0.34373936f, 0.51347768f, -0.45311260f, 
    0.19640231f, 0.21533556f, 0.47396451f, -0.24334763f, 0.22531947f, -0.26246625f, -0.43201864f, -0.54153001f, 
    0.13672574f, -0.13714284f, -0.05721839f, -0.18794684f, -0.26283059f, -0.24285157f, -0.15575308f, 0.12141129f, 
    -0.07618266f, -0.04360763f, 0.12940104f, 0.09956890f, -0.05367976f, -0.27156195f, 0.02882251f, 0.37259632f, 
    -0.05431526f, -0.04197171f, 0.16040073f, 0.20039447f, -0.03886702f, 0.12912306f, 0.01762935f, 0.06213441f, 
    0.48862797f, 0.00919791f, -0.09883431f, -0.02257269f, 0.05655242f, 0.39893866f, -0.44891968f, 0.21317910f, 
    -0.24924897f, -0.30813953f, -0.41975024f, 0.19429518f, 0.07155780f, 0.15328741f, 0.15818661f, 0.03150280f, 
    0.92949694f, 0.16864644f, 0.21296869f, -0.17943966f, -0.67448598f, 0.56517583f, 0.05335403f, 0.03891239f, 
    -0.35997969f, 0.00931221f, -0.03984606f, -0.08929761f, -0.17134616f, 0.16344456f, -0.02075834f, 0.09117804f, 
    0.02368085f, 0.22234662f, -0.21433765f, -0.30366272f, -0.46503979f, -0.25307402f, -0.08166238f, 0.18016464f, 
    0.58573085f, 0.01360083f, -0.31228715f, -0.64188337f, -0.26349410f, -0.18898988f, -0.12858346f, -0.26048446f, 
    -0.07195375f, -0.35095447f, -0.39044422f, 0.41713157f, 0.21583611f, 0.14065933f, -0.23990187f, 0.23226568f, 
    -0.17952871f, 0.23087731f, 0.04081286f, -0.17345017f, 0.25455576f, -0.38471097f, 0.05860218f, -0.17371479f, 
    -0.25260410f, -0.03851186f, 0.41880620f, -0.47708353f, -0.62057304f, -0.43951574f, -0.23010579f, -0.22190715f, 
    -0.07763903f, 0.27912459f, -0.14742565f, -0.04579017f, -0.33826673f, -0.15727650f, -0.02311062f, -0.19855283f, 
    -0.05755490f, -0.17659406f, -0.20937793f, 0.14226671f, 0.29339916f, -0.37867129f, -0.24294254f, 0.09323295f, 
    0.15663953f, 0.17218514f, 0.21063799f, -0.65671301f, -0.14115791f, -0.62468261f, -0.23568273f, 0.24313463f, 
    0.44690651f, 0.14257693f, 0.48125294f, -0.48021936f, -0.46270600f, -0.32529750f, -0.13703783f, -0.39975029f, 
    -0.03176687f, -0.21868704f, 0.09584925f, -0.39610350f, -0.31057715f, 0.25332090f, -0.38241109f, 0.10619483f, 
    0.29999450f, -0.17120647f, -0.06730988f, -0.23862979f, 0.06614999f, 0.06610873f, -0.80053169f, -0.92692232f, 
    -0.82549423f, 0.54073012f, 0.56986076f, 0.26367015f, 0.21589245f, 0.02165669f, -0.20603669f, -0.15372786f, 
    -0.29475954f, -0.07533438f, 0.01488523f, -0.39242327f, -0.38841987f, 0.37712973f, -0.06616592f, 0.06667928f, 
    0.36089975f, -0.07721232f, -0.37563351f, 0.09042981f, 0.13788541f, 0.24614829f, 0.16346416f, 0.11399613f, 
    0.23506618f, 0.25860700f, -0.30960712f, 0.10155991f, 0.16314462f, 0.31439912f, 0.08083598f, 0.03531074f, 
    -0.24424067f, -0.28981954f, -0.21473040f, 0.16562736f, 0.10239819f, 0.16490042f, 0.21194348f, 0.16226077f, 
    0.07068774f, -0.12095528f, -0.17275554f, -0.31371379f, -0.28087690f, -0.39098242f, -0.52428997f, 0.48018149f, 
    0.33278847f, 0.37162820f, -0.01717632f, -0.21431009f, -0.40517455f, 0.13704973f, -0.10256528f, 0.21918586f, 
    -0.30638969f, 0.12964191f, 0.20460993f, 0.05252856f, -0.12892380f, 0.39124233f, -0.14337066f, 0.00198550f, 
    -0.24816930f, -0.21736577f, -0.38182834f, -0.17490095f, 0.02254097f, -0.04889103f, -0.48884654f, 0.52634656f, 
    0.75062931f, -0.61359930f, -0.30740646f, -0.41752714f, 0.24388523f, 0.07721512f, 0.26197094f, 0.00859999f, 
    -0.26150396f, -0.18202947f, -0.45417723f, 0.15900762f, 0.03334866f, -0.27167222f, 0.34111515f, 0.15677796f, 
    -0.06876283f, -0.19902569f, -0.29164487f, 0.09530797f, -0.10758969f, -0.18165448f, -0.08184092f, -0.41215304f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.14608689f, 0.10115717f, 0.02440651f, 0.13106869f, -0.09582534f, 0.10232352f, -0.19074276f, 0.11209706f, 
    0.24941434f, -0.03839557f, 0.08613008f, -0.09080429f, -0.19345051f, -0.26726881f, 0.16245557f, -0.03301866f, 
    -0.21867135f, 0.05268918f, 0.17502844f, 0.23616317f, -0.21421598f, 0.12625884f, 0.07766723f, 0.25022867f, 
    0.09792883f, -0.35300615f, 0.09509619f, 0.11914345f, -0.22430740f, -0.16187975f, 0.04001933f, 0.20766746f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.21292998f, 0.01750868f, -0.07669254f, 0.04706884f, -0.02951814f, -0.00270284f, -0.06749387f, -0.09335436f, 
    0.09444143f, -0.02361177f, 0.04135832f, 0.03002623f, 0.13116775f, 0.25204593f, 0.09576795f, 0.02751932f, 
    0.12705766f, 0.05674222f, -0.20573367f, -0.16137251f, -0.04552026f, -0.07703397f, -0.00233878f, -0.09334511f, 
    -0.67367458f, 0.17438339f, -0.47481874f, -0.20570266f, -0.14525402f, -0.06322114f, 0.01534995f, -0.04765208f, 
    -0.07622370f, 0.08639456f, -0.01175138f, 0.20726718f, 0.07951853f, -0.15102942f, -0.00789810f, 0.37514031f, 
    0.05055866f, 0.00898507f, 0.06666410f, 0.15829639f, 0.09328551f, 0.05678916f, 0.06344315f, 0.12736934f, 
    0.04606779f, -0.01734139f, 0.14113942f, -0.07047787f, -0.15561779f, -0.12403790f, -0.00582478f, 0.02346966f, 
    -0.07121807f, -0.08508909f, -0.10340772f, -0.03305359f, 0.47194242f, -0.28235427f, 0.12694196f, 0.25953817f, 
    -0.03954945f, -0.04022842f, 0.06156864f, 0.05811720f, 0.00595678f, 0.03962405f, 0.01414357f, -0.03296858f, 
    -0.08847445f, -0.02136325f, 0.35222831f, 0.17709023f, 0.04876241f, 0.02243211f, 0.15157790f, -0.11233895f, 
    0.07932235f, -0.02786670f, 0.06716420f, -0.13920097f, -0.01153222f, 0.12343614f, 0.48233438f, -0.30437136f, 
    0.13130277f, 0.26475883f, -0.07128268f, -0.17658445f, -0.02772919f, 0.15089032f, 0.26987463f, 0.11064697f, 
    -0.01673867f, 0.03925684f, -0.00914113f, 0.00989820f, 0.26796257f, 0.20788525f, 0.05085416f, 0.02401678f, 
    -0.13178819f, -0.04048725f, -0.11284045f, -0.00222074f, -0.01098955f, 0.10336337f, 0.14588740f, 0.26945710f, 
    -0.17397930f, 0.02553502f, 0.23713639f, 0.05557460f, -0.10008549f, -0.09594395f, -0.03275369f, -0.05389282f, 
    0.05062362f, -0.15330228f, 0.21255891f, 0.31464839f, -0.11529581f, 0.01663073f, -0.10377819f, -0.01438751f, 
    -0.28606412f, 0.06674289f, 0.08825554f, 0.20267442f, 0.17558642f, 0.12651981f, 0.08016592f, -0.04163330f, 
    -0.28819829f, 0.02640149f, -0.10840685f, -0.01485358f, -0.06447385f, -0.06159212f, -0.00994063f, 0.01519772f, 
    0.17144905f, -0.01347788f, 0.05772354f, -0.01878838f, 0.04493291f, 0.10253753f, -0.17062448f, 0.04579432f, 
    -0.19440565f, 0.12733135f, 0.00985035f, 0.01577208f, -0.15961930f, 0.04277257f, -0.04286028f, 0.11587279f, 
    -0.03236899f, 0.02126355f, 0.09951167f, 0.27399805f, 0.10473219f, 0.15583524f, -0.04647732f, 0.11868864f, 
    -0.20107584f, 0.10930935f, 0.03351193f, 0.10790358f, 0.20541623f, -0.20806208f, 0.31622580f, 0.07642575f, 
    0.01514584f, 0.09656778f, 0.05214358f, 0.08288777f, -0.05684479f, 0.25046811f, 0.15255113f, 0.03016528f, 
    -0.05312947f, -0.04442155f, -0.06458254f, -0.11485752f, -0.04858571f, 0.08133913f, -0.03551165f, 0.21668212f, 
    -0.13353977f, 0.26755539f, -0.02820253f, -0.05090802f, -0.09368353f, 0.00986767f, 0.03644745f, 0.06599534f, 
    0.00261981f, -0.04192081f, 0.06023167f, -0.10627022f, -0.00863600f, -0.16196017f, 0.53341311f, 0.15561737f, 
    -0.05905017f, 0.22606243f, 0.20341276f, 0.01982915f, 0.07746760f, -0.19053079f, -0.04173813f, -0.03279668f, 
    -0.13133590f, 0.22686009f, -0.21318196f, -0.01323060f, 0.05544870f, 0.12354033f, -0.10488945f, -0.00007515f, 
    0.03383984f, -0.07488296f, 0.08680070f, 0.07923409f, -0.11500068f, 0.18841362f, 0.34120640f, -0.20374176f, 
    0.07096273f, 0.06292836f, 0.04406038f, 0.06629539f, 0.10140003f, 0.10683724f, 0.15541461f, 0.11782283f, 
    0.13481939f, 0.11017121f, 0.14104883f, 0.14363113f, 0.13650715f, -0.18924895f, -0.31241649f, -0.18060842f, 
    -0.02313352f, 0.03171519f, -0.19912760f, 0.03491171f, -0.01959854f, -0.00528720f, -0.07558678f, 0.04846338f, 
    -0.00041093f, -0.00038338f, -0.11659878f, -0.17727175f, -0.20591137f, 0.08910240f, -0.12706110f, -0.03479510f, 
    0.04152171f, 0.24583466f, -0.05392326f, -0.03702332f, -0.09426843f, -0.03585497f, -0.25007537f, 0.03275016f, 
    -0.13838334f, -0.05564535f, 0.03331468f, 0.04756251f, -0.02934554f, 0.20556228f, 0.10969161f, 0.12048915f, 
    -0.10061511f, 0.03913202f, 0.08509085f, -0.07929975f, -0.08157451f, 0.08449255f, 0.15668797f, 0.10655085f, 
    0.30520341f, -0.09485310f, 0.23034385f, 0.22374971f, 0.06166814f, -0.17971294f, -0.09613822f, -0.09478197f, 
    0.09992716f, 0.33848950f, 0.14301662f, -0.00779830f, -0.01504890f, 0.10140127f, 0.08179385f, 0.36404410f, 
    -0.04317347f, 0.12669952f, -0.07876181f, -0.07970870f, 0.11665430f, 0.00919455f, -0.14074235f, 0.07748649f, 
    0.07337993f, 0.28341860f, 0.06181579f, 0.11016108f, 0.04590347f, 0.29773057f, 0.15839256f, -0.04067532f, 
    -0.01703848f, -0.13294588f, -0.14079452f, -0.02459536f, 0.14260782f, -0.12425934f, 0.23978660f, 0.47884169f, 
    0.06553147f, 0.10168378f, 0.06934922f, 0.10045472f, 0.11788470f, 0.05112863f, 0.00216280f, 0.18165387f, 
    0.49347672f, 0.29177812f, 0.52096391f, 0.18163864f, 0.10321592f, 0.11261759f, -0.00479373f, 0.15157284f, 
    -0.10008955f, -0.11663020f, 0.10656635f, -0.09555821f, -0.07562241f, -0.07023911f, -0.04131611f, 0.02530335f, 
    -0.13141061f, -0.01135963f, -0.07018539f, -0.07857040f, 0.11284480f, -0.05149193f, -0.09171306f, 0.00463904f, 
    -0.10966325f, 0.13746236f, 0.09260929f, -0.05271290f, 0.11229983f, 0.11034051f, -0.02448252f, -0.08484346f, 
    -0.02494323f, 0.20708093f, 0.02478325f, -0.06943199f, 0.22983688f, -0.09379756f, 0.37092158f, 0.13755530f, 
    0.00965908f, -0.06478624f, -0.19498357f, 0.15608966f, -0.12148931f, 0.00013863f, -0.09652629f, 0.27945960f, 
    -0.40959901f, -0.36796176f, -0.35817423f, 0.18648924f, -0.05206619f, 0.02135643f, 0.03343532f, -0.17474201f, 
    -0.10249332f, 0.25564650f, 0.09799568f, 0.26850015f, -0.05501685f, 0.15936670f, 0.12069691f, 0.12123879f, 
    -0.02542776f, -0.12575334f, 0.01564295f, -0.09975855f, -0.10818955f, 0.00175429f, -0.07005794f, 0.03807926f, 
    0.13418591f, 0.15881945f, 0.12298995f, -0.20750517f, 0.16578878f, 0.06911419f, 0.06306271f, -0.09980011f, 
    -0.08525946f, 0.15362453f, 0.02903671f, 0.13370305f, 0.17250542f, -0.06911317f, -0.11366018f, 0.14357448f, 
    0.10423915f, 0.02975909f, -0.13268600f, 0.01340731f, 0.00359678f, 0.11186664f, 0.03682672f, 0.33845606f, 
    0.21876858f, 0.11843714f, 0.00123201f, -0.09388802f, 0.06999378f, 0.12223891f, 0.00309614f, 0.16350833f, 
    0.07950387f, 0.17181376f, 0.14107648f, -0.03199130f, 0.43158123f, -0.22419788f, -0.41439053f, 0.16866097f, 
    0.08398728f, 0.05464581f, 0.17503452f, 0.13104863f, -0.05597845f, 0.04318546f, -0.16185345f, 0.03042538f, 
    0.28144771f, -0.08137169f, 0.18554173f, 0.04760339f, 0.05175709f, -0.01722967f, 0.08064891f, 0.16239311f, 
    0.00696226f, -0.11817005f, 0.12592629f, -0.12627737f, -0.16818945f, -0.43211275f, 0.19304845f, -0.17369080f, 
    -0.08240464f, 0.29178569f, -0.05770845f, -0.16175444f, -0.04938605f, -0.04480072f, -0.00589609f, -0.02321687f, 
    0.01946479f, -0.11436028f, 0.12429788f, 0.03564617f, -0.05808938f, -0.05809602f, -0.13575251f, 0.00640440f, 
    0.11899993f, -0.13754900f, -0.14784484f, -0.21295892f, 0.13753574f, 0.18338238f, 0.05085723f, 0.15552674f, 
    0.06835124f, -0.03364053f, 0.03034824f, -0.17656332f, -0.17494711f, -0.06974009f, -0.02168264f, -0.15815198f, 
    -0.36661607f, -0.36636996f, -0.23627158f, 0.27595851f, -0.12428798f, 0.06136315f, -0.02432037f, 0.08771485f, 
    0.13741076f, 0.11334443f, 0.10167049f, 0.04083988f, 0.00281131f, -0.27667865f, -0.51937598f, -0.11565272f, 
    0.01157578f, -0.15185255f, -0.13261223f, 0.05253726f, -0.05392790f, -0.13873923f, -0.03610171f, -0.07452457f, 
    0.22635181f, -0.00241934f, -0.27793729f, -0.04874273f, 0.01195375f, 0.04100185f, -0.06200181f, 0.08093290f, 
    -0.01164150f, -0.11943056f, -0.09378386f, 0.01826767f, 0.31390190f, 0.11108759f, -0.01634010f, 0.05154334f, 
    0.12927791f, 0.02078206f, 0.11120819f, 0.10992092f, -0.13467912f, -0.01951541f, -0.04667501f, 0.16459538f, 
    0.19858249f, 0.05788355f, 0.07466380f, -0.11738249f, 0.05788864f, -0.00110357f, 0.00641272f, -0.12660861f, 
    -0.10477744f, -0.02833992f, 0.02241485f, 0.01635447f, -0.52631396f, -0.39080524f, 0.23737119f, 0.13288732f, 
    -0.28775200f, 0.15583248f, -0.07509130f, -0.12263722f, -0.15185678f, 0.09297621f, -0.17322873f, 0.14502835f, 
    -0.11020662f, 0.10739053f, -0.00120657f, 0.15491398f, 0.06111444f, 0.14810261f, 0.04750698f, -0.17123295f, 
    -0.05614445f, -0.18540570f, -0.02242698f, -0.10154263f, 0.18383315f, -0.15196662f, 0.09174913f, -0.00109927f, 
    -0.17277993f, 0.01769608f, 0.21122377f, -0.16406406f, -0.04642252f, 0.01257864f, -0.04240865f, 0.22279514f, 
    0.04807888f, 0.15687108f, -0.02301695f, -0.01961804f, 0.09495559f, 0.19817740f, 0.13948177f, -0.03026530f, 
    0.02553610f, 0.03439900f, 0.02042019f, -0.01361745f, -0.16602869f, 0.07473320f, 0.04823540f, -0.18401502f, 
    -0.11376202f, -0.03081311f, -0.01736979f, -0.12006196f, 0.07856403f, -0.00525782f, 0.20993195f, 0.26375434f, 
    0.21482030f, 0.14732663f, 0.13761359f, 0.14026536f, 0.19329175f, 0.24104048f, 0.00278677f, 0.14559658f, 
    -0.01132818f, 0.06276710f, -0.02768582f, 0.34205478f, -0.07776465f, 0.04328477f, 0.20849568f, 0.04701153f, 
    0.05392201f, -0.16970812f, -0.05173365f, -0.11398834f, -0.25737545f, 0.07537019f, -0.23062256f, -0.21407688f, 
    0.10845666f, -0.05729857f, -0.05038219f, -0.04464490f, -0.02046255f, -0.06747646f, -0.08103065f, 0.04443413f, 
    -0.07754552f, -0.02581048f, 0.06971467f, 0.01161167f, -0.24557903f, -0.39636680f, -0.12915264f, 0.20912687f, 
    -0.12933055f, -0.05272154f, 0.02721874f, -0.15661143f, -0.09278821f, -0.00892625f, -0.12776090f, -0.01811588f, 
    -0.23048978f, -0.17662758f, 0.00510866f, 0.05313766f, -0.00661272f, -0.12547983f, -0.03995091f, -0.19360834f, 
    -0.16390467f, 0.05064490f, 0.04669254f, 0.00026850f, 0.32048193f, 0.05427900f, -0.05564499f, 0.10892165f, 
    0.17029624f, 0.06972075f, 0.01672946f, 0.04544710f, 0.04479320f, 0.10265902f, 0.12855603f, -0.06958906f, 
    0.05397430f, 0.13245793f, 0.04394060f, 0.20121312f, 0.02451245f, 0.05860779f, 0.10234513f, -0.14096440f, 
    0.03274381f, -0.15223014f, -0.12195394f, -0.09600005f, 0.30583587f, 0.03995810f, 0.05822288f, 0.15380304f, 
    0.08589426f, 0.13806014f, -0.01962231f, -0.00648592f, -0.10386156f, 0.07423873f, 0.05276580f, 0.17830092f, 
    0.27198461f, 0.06383512f, -0.00058857f, 0.14462745f, 0.11491413f, 0.16735265f, -0.09394911f, 0.06584425f, 
    0.09414469f, -0.01146752f, 0.05395414f, 0.06804308f, -0.13907149f, -0.23393266f, -0.16282640f, 0.15243308f, 
    0.11758799f, 0.03572718f, 0.06402699f, 0.01400764f, 0.03792325f, 0.04172182f, 0.11317745f, 0.26769909f, 
    -0.33476746f, 0.13975468f, 0.03693049f, -0.02087699f, -0.09411538f, -0.10144210f, -0.19519345f, -0.09351977f, 
    -0.07566062f, 0.08183244f, 0.05393313f, 0.14062089f, -0.28130403f, -0.21392931f, 0.14837737f, 0.08045242f, 
    -0.08780560f, 0.02715051f, 0.01687862f, -0.03297881f, 0.14579929f, 0.16915649f, 0.14718480f, 0.11457870f, 
    -0.14453207f, -0.16818604f, 0.01599611f, 0.09165309f, -0.01292303f, -0.05612312f, -0.04183738f, -0.07052207f, 
    -0.25884929f, 0.02915982f, -0.11759445f, -0.03132621f, -0.10426248f, 0.21167591f, -0.04689907f, -0.08943741f, 
    0.06210595f, -0.05655529f, 0.11468358f, 0.07130551f, 0.00327580f, 0.15568341f, 0.09130474f, -0.03126907f, 
    -0.20556000f, -0.04118868f, 0.24341641f, 0.17522876f, -0.03886490f, -0.07000761f, -0.00536732f, -0.09007668f, 
    -0.02305224f, -0.07740373f, 0.07158803f, 0.08587621f, 0.13748780f, 0.01681104f, 0.02061682f, -0.12583369f, 
    -0.04240471f, 0.10551205f, -0.12340966f, 0.14061591f, 0.07884765f, -0.03379548f, 0.15740925f, 0.14576304f, 
    0.20925176f, 0.11720955f, 0.05112841f, -0.24191658f, 0.03156369f, 0.04771564f, -0.08740275f, 0.21795459f, 
    -0.16554871f, 0.09228589f, 0.10792628f, 0.12399206f, 0.41820252f, -0.14238912f, -0.41069600f, 0.03455977f, 
    0.03510310f, 0.06095812f, -0.06314527f, 0.04171180f, -0.04706216f, -0.01140178f, 0.05552179f, -0.03398049f, 
    0.23347083f, 0.19175306f, 0.30625769f, 0.12643617f, 0.18950211f, 0.01809566f, 0.01375734f, 0.10726054f, 
    0.03217607f, -0.01067406f, -0.01507614f, 0.05985275f, -0.21760920f, -0.31260425f, 0.30544645f, -0.01659560f, 
    -0.12603348f, 0.22529911f, -0.06036126f, -0.15131970f, 0.11568782f, 0.14098141f, 0.03574444f, 0.25312617f, 
    -0.06123600f, -0.09082461f, 0.10327928f, -0.05678031f, -0.00885912f, 0.01376760f, -0.04052428f, 0.05343260f, 
    0.05261088f, -0.00882095f, 0.04876465f, 0.03526883f, 0.15016077f, 0.19257514f, 0.10258974f, 0.00616825f, 
    0.16060075f, 0.04316465f, 0.06422421f, -0.03598344f, -0.01814035f, -0.04223770f, 0.05894722f, 0.00820814f, 
    -0.17696527f, -0.26719001f, -0.41584077f, 0.18171413f, -0.17015271f, -0.00096112f, 0.15365589f, -0.03126573f, 
    0.03038467f, -0.01316092f, -0.08002814f, 0.00747998f, 0.12775090f, -0.22978242f, -0.29667398f, -0.01885139f, 
    -0.04734141f, 0.04769195f, -0.05739978f, -0.12103145f, -0.05342168f, 0.05715177f, -0.02029455f, -0.06577642f, 
    0.02021662f, -0.12615414f, -0.23799703f, -0.16599822f, 0.00965966f, -0.00625206f, 0.00249533f, -0.05887462f, 
    0.15152025f, 0.16895291f, 0.03634804f, 0.20971665f, 0.32782379f, 0.22183554f, 0.12471586f, -0.14997113f, 
    0.22506927f, 0.03557155f, 0.06276292f, 0.18464176f, 0.00881708f, 0.01111751f, -0.01201181f, 0.07744200f, 
    0.20259319f, 0.31314605f, 0.29756293f, -0.10950291f, -0.09032167f, 0.24807367f, 0.01112295f, 0.09139344f, 
    0.00541182f, -0.08492378f, 0.00981234f, 0.13658819f, -0.45097211f, -0.37585855f, 0.27731007f, 0.39735371f, 
    0.06431624f, 0.01561472f, -0.18776461f, -0.05998286f, 0.00572899f, -0.04396480f, -0.04018467f, 0.16339168f, 
    0.16102594f, 0.26514247f, 0.22629660f, 0.07549766f, -0.04424072f, 0.19780566f, -0.06591253f, -0.05224132f, 
    -0.00751917f, -0.10513740f, 0.20829163f, -0.02662840f, 0.29308426f, 0.04649438f, -0.10764258f, 0.01257908f, 
    -0.00083462f, 0.03779617f, 0.04734643f, 0.07728548f, -0.09393430f, 0.15052904f, -0.08997057f, 0.04962401f, 
    0.08888105f, -0.10519776f, 0.07322342f, -0.22913583f, 0.02888001f, -0.09745729f, 0.03049932f, -0.02318742f, 
    0.10248832f, 0.01859638f, 0.11517080f, -0.05404747f, 0.02929243f, -0.08970544f, 0.21106680f, -0.14623091f, 
    -0.00640830f, 0.03115513f, -0.02259116f, 0.04638514f, 0.11927691f, 0.11556973f, 0.07346568f, -0.01373890f, 
    0.05134059f, 0.22818184f, 0.12310345f, -0.10052954f, 0.11394417f, 0.07612197f, 0.04139733f, 0.16639431f, 
    -0.01348223f, -0.04648447f, 0.03357430f, 0.07046518f, -0.08923998f, -0.01778285f, 0.06735244f, 0.07530575f, 
    0.03420451f, 0.04685312f, 0.04683978f, -0.24768969f, -0.02657541f, 0.11006328f, -0.05831264f, -0.04468887f, 
    -0.01672838f, -0.24870610f, -0.16423573f, -0.14159621f, -0.05701721f, -0.08332598f, 0.09204555f, 0.10057352f, 
    -0.13217759f, 0.10037673f, -0.04145732f, -0.06119650f, -0.03186746f, -0.16160427f, 0.01435336f, 0.24150513f, 
    -0.17447345f, 0.00710188f, -0.06224980f, -0.08940542f, -0.05326148f, -0.04677010f, 0.08425814f, -0.15898341f, 
    0.03035128f, -0.35796353f, -0.32748258f, -0.01641261f, -0.09727621f, 0.06134313f, -0.01620235f, -0.13517384f, 
    -0.08643778f, -0.00936577f, 0.00662038f, 0.23575723f, 0.39965808f, 0.13441184f, 0.00613067f, 0.02925119f, 
    0.05007641f, 0.00143237f, 0.07323033f, 0.05339662f, -0.08176331f, 0.08919626f, -0.00744712f, -0.04773566f, 
    0.22136144f, 0.27012324f, 0.06344242f, -0.01050291f, 0.19925000f, 0.06560316f, 0.06352735f, -0.05361945f, 
    0.03254810f, 0.06035276f, -0.14026983f, 0.07899111f, 0.21540761f, 0.33122039f, 0.07424814f, 0.15101589f, 
    0.04792896f, 0.04687816f, 0.15418486f, 0.06939512f, -0.03227472f, 0.01591106f, -0.04761059f, 0.15846232f, 
    0.36520234f, 0.15616146f, -0.14051798f, -0.29502040f, 0.04786967f, 0.15780720f, 0.05983528f, 0.05112408f, 
    0.00937136f, -0.02369933f, 0.06438307f, 0.02926370f, -0.09766466f, -0.24713568f, -0.09200321f, -0.00916769f, 
    0.08670732f, 0.01338339f, -0.17495511f, -0.05458064f, 0.01724374f, 0.02968745f, 0.05952035f, 0.00877590f, 
    -0.43243900f, -0.01140112f, 0.22801267f, 0.18780865f, 0.06661257f, -0.07197578f, -0.10117485f, -0.08104375f, 
    -0.01855674f, -0.06115666f, -0.04510963f, 0.02226465f, 0.02750661f, -0.08630528f, -0.12043258f, 0.11121935f, 
    -0.05992819f, 0.01137758f, 0.17440745f, 0.03276633f, 0.08065875f, -0.05477399f, -0.00739554f, -0.02890933f, 
    0.03740650f, 0.01942081f, 0.03434438f, -0.02786384f, -0.02861347f, -0.01389244f, 0.01427732f, 0.02379242f, 
    0.02297505f, -0.02564814f, 0.02509839f, -0.02939702f, -0.02515644f, -0.01019771f, -0.00770857f, 0.01303777f, 
    -0.01885468f, 0.03066784f, -0.00726717f, -0.03002658f, -0.02282460f, 0.00581598f, 0.03416485f, -0.00194759f, 
    -0.03507153f, -0.04553163f, -0.04752977f, 0.00754588f, 0.01109728f, 0.00620862f, 0.03831065f, -0.03196686f, 
    -0.02625453f, -0.02658701f, -0.02903888f, 0.02221345f, 0.02412898f, -0.03052805f, -0.03808275f, 0.00896134f, 
    0.01885609f, -0.00115367f, -0.03605689f, -0.01679702f, 0.04207991f, -0.01691950f, -0.03757293f, 0.02286219f, 
    -0.05650965f, -0.03840971f, 0.01309473f, -0.01693444f, -0.02062277f, 0.01769989f, -0.03123437f, 0.04437888f, 
    -0.01327722f, 0.00439095f, -0.04609744f, 0.00167284f, -0.02023884f, -0.03676442f, 0.04433373f, -0.01648205f, 
    0.01011754f, -0.02667292f, -0.02298268f, 0.04490370f, -0.00350644f, -0.04669178f, -0.03903313f, 0.00900224f, 
    -0.05293591f, 0.01364938f, -0.05216439f, -0.01409842f, 0.01915321f, 0.00790991f, -0.04196163f, -0.00938848f, 
    -0.04568233f, -0.01930022f, -0.02243829f, -0.03187215f, -0.03480122f, -0.04306238f, 0.02297791f, 0.00371845f, 
    -0.02679510f, -0.01559610f, -0.01998372f, -0.01148643f, -0.00359339f, 0.04084971f, -0.00909954f, -0.04096159f, 
    -0.04493008f, -0.02844898f, -0.01184171f, 0.02620341f, 0.04182044f, -0.00729164f, -0.05068912f, -0.01550698f, 
    -0.01614810f, -0.01226800f, 0.01472756f, 0.04252385f, -0.03263813f, -0.01241634f, 0.03382531f, 0.03653500f, 
    -0.04915753f, -0.02182020f, -0.00435271f, 0.04157526f, 0.01166909f, 0.04256894f, -0.00770123f, 0.01082345f, 
    -0.04025028f, 0.03736991f, -0.02570432f, -0.04301656f, 0.00336151f, 0.03414744f, -0.04994277f, 0.01690554f, 
    -0.03994056f, 0.00815627f, -0.02117011f, -0.05143075f, -0.03250860f, -0.01880187f, -0.02725177f, -0.00554033f, 
    0.04909874f, 0.03487927f, -0.05582223f, -0.03987007f, 0.03798199f, 0.02889875f, -0.00500805f, 0.03182054f, 
    -0.02164333f, -0.00102868f, -0.02974784f, -0.05136569f, 0.02840982f, -0.02615421f, 0.00304711f, -0.01430146f, 
    -0.03708249f, 0.02608497f, -0.02648745f, -0.00239487f, 0.04277326f, -0.01960042f, 0.04419286f, 0.02954407f, 
    -0.03973338f, 0.03469431f, -0.03772786f, -0.02319243f, -0.01358131f, -0.03662539f, -0.04119792f, 0.01079114f, 
    -0.01821986f, 0.02635882f, -0.02884403f, -0.00989853f, -0.04759383f, 0.02046678f, 0.04164103f, 0.03226607f, 
    0.01645073f, -0.03494708f, 0.03212528f, 0.03280798f, 0.03422110f, -0.04384720f, 0.00872799f, -0.04556364f, 
    0.04422734f, -0.01663725f, 0.01623777f, -0.03246849f, -0.05041448f, 0.01942144f, -0.02427235f, -0.00747714f, 
    0.02852381f, -0.04704262f, 0.04084873f, -0.03215098f, 0.02401156f, -0.04573981f, 0.03056809f, -0.02967271f, 
    0.00499502f, -0.04321403f, 0.01482225f, 0.02470412f, -0.04626072f, 0.01526990f, 0.03150894f, 0.01239043f, 
    -0.00122944f, -0.05108766f, 0.03127863f, -0.04796705f, 0.01302357f, -0.04343441f, -0.01911103f, 0.00154167f, 
    -0.04878281f, 0.00931174f, 0.03571227f, 0.03489078f, -0.01605155f, 0.04518865f, -0.02600545f, -0.01719508f, 
    -0.03901117f, -0.00745114f, -0.00065798f, 0.01786852f, -0.00580205f, 0.03458906f, 0.01618667f, -0.04156367f, 
    -0.02002238f, -0.02955872f, -0.03561379f, -0.01511023f, -0.02690228f, -0.04150090f, 0.00137821f, 0.03533649f, 
    0.03847800f, 0.02945748f, -0.01319142f, 0.01022762f, 0.03766752f, -0.02962044f, 0.03032666f, -0.01352771f, 
    -0.01301172f, -0.02063404f, -0.02421023f, 0.00226393f, -0.04050532f, -0.01429252f, -0.04488482f, -0.04578370f, 
    0.03564221f, -0.03792980f, -0.00952421f, 0.02901574f, 0.01064416f, 0.02620289f, -0.04712218f, 0.03589442f, 
    -0.04802638f, -0.01367169f, 0.03338702f, -0.02821396f, 0.02924709f, -0.00943958f, -0.04214700f, -0.00524364f, 
    0.00509112f, -0.01163519f, 0.02747680f, 0.00737798f, -0.03283973f, 0.00284608f, 0.00120725f, 0.02251799f, 
    0.04472146f, -0.02540227f, -0.03797783f, 0.01757289f, -0.00267736f, -0.00495955f, -0.05112803f, 0.04218989f, 
    -0.01846734f, -0.01697203f, 0.02264105f, -0.03572557f, -0.05029039f, 0.04001458f, 0.01186126f, -0.01108763f, 
    -0.02141181f, -0.05470376f, -0.01818371f, 0.03657014f, -0.01790899f, -0.03042023f, 0.00519355f, -0.01108238f, 
    0.02195002f, -0.05571469f, -0.01640354f, -0.05009936f, -0.04339554f, -0.04253671f, 0.01379254f, 0.01302641f, 
    -0.05395510f, -0.03657742f, -0.00932570f, 0.04373288f, -0.03667912f, -0.04258841f, -0.04626078f, -0.00460177f, 
    -0.04405873f, -0.02553358f, 0.00776080f, -0.00309599f, -0.02871821f, -0.00930823f, -0.03880309f, 0.00282261f, 
    -0.02524645f, -0.05008890f, -0.02397595f, 0.03008691f, 0.02579880f, 0.04921786f, -0.03115969f, -0.01503119f, 
    -0.03450762f, -0.05218115f, -0.00814505f, -0.03736642f, -0.03619214f, -0.03720484f, -0.03820425f, 0.03852273f, 
    0.03629227f, -0.02314614f, -0.05656877f, -0.04365075f, -0.03368123f, 0.01878713f, -0.04466321f, -0.01223618f, 
    0.00271022f, 0.02379199f, -0.00783418f, -0.03391159f, -0.04129814f, 0.02686097f, -0.03433795f, 0.03021384f, 
    -0.05036034f, -0.03112362f, -0.02897283f, -0.00037036f, 0.01654294f, 0.03902513f, -0.04425866f, -0.01191810f, 
    -0.02715387f, 0.00692637f, -0.05342119f, -0.04562198f, -0.01639221f, -0.05386394f, 0.02413947f, 0.02399503f, 
    -0.01508494f, -0.02777749f, 0.03287421f, -0.03214016f, -0.04755412f, 0.00771366f, -0.03634488f, 0.02128698f, 
    0.17411231f, 0.00254486f, 0.03091012f, -0.05328395f, 0.03277727f, -0.10097051f, -0.03700214f, -0.06009685f, 
    0.11927775f, -0.12979902f, 0.01227010f, 0.15674075f, 0.37357301f, -0.17460959f, -0.42269316f, -0.15556209f, 
    0.14266054f, 0.15346766f, 0.15563612f, 0.10979707f, 0.12299776f, -0.10349134f, -0.03050811f, -0.06108795f, 
    -0.37544176f, -0.18274249f, 0.00358652f, 0.32856452f, -0.08537732f, -0.11229439f, -0.04440113f, 0.10892707f, 
    0.02009464f, -0.04156036f, 0.02820510f, 0.19795002f, 0.02884110f, 0.27076533f, 0.04241021f, -0.09657421f, 
    -0.11075477f, 0.01884782f, 0.07002902f, -0.06352355f, 0.09285737f, -0.11941703f, -0.07725581f, 0.01666393f, 
    -0.10435688f, 0.31309217f, 0.00890914f, -0.12067559f, 0.15820304f, 0.04344454f, -0.03773926f, 0.07336039f, 
    -0.05489760f, -0.03997937f, 0.06684554f, 0.09890238f, -0.08237777f, -0.18612534f, 0.26934239f, -0.16028535f, 
    -0.12672369f, -0.09747171f, -0.12123737f, -0.00002931f, 0.13779230f, -0.09658960f, 0.04786641f, 0.00032874f, 
    -0.22183472f, -0.01069778f, 0.39552590f, -0.01556655f, -0.05411457f, 0.01044956f, 0.09799788f, -0.08807827f, 
    0.05834788f, 0.01045676f, 0.00336155f, 0.08619580f, 0.26871115f, -0.15702963f, -0.03928722f, -0.04393904f, 
    -0.02413082f, -0.10328407f, 0.08043680f, 0.06476112f, 0.03062691f, 0.08514592f, 0.04324434f, -0.00020452f, 
    -0.09651274f, -0.05887615f, -0.01657445f, 0.05298577f, 0.08041014f, -0.03405634f, 0.03258878f, 0.10288505f, 
    0.10522081f, 0.10026301f, -0.07349283f, -0.11063696f, 0.01690572f, 0.10702888f, 0.12119971f, 0.18328954f, 
    0.03530343f, 0.00680522f, 0.21654171f, -0.03151358f, 0.00718960f, -0.02500193f, -0.08593149f, -0.00606104f, 
    0.34323943f, -0.00657134f, -0.08000238f, -0.30628869f, 0.31517920f, -0.00510380f, 0.05638788f, 0.10746904f, 
    -0.02780726f, -0.10132043f, 0.10436250f, -0.04285789f, 0.10919971f, 0.02071570f, 0.06010108f, 0.03799461f, 
    -0.16350572f, 0.07226104f, 0.00191173f, -0.11037035f, -0.02147216f, -0.00712059f, -0.00951346f, -0.12325301f, 
    0.11025491f, -0.12798667f, -0.05201402f, -0.13289246f, 0.00212953f, 0.04262370f, -0.10416733f, -0.04453799f, 
    0.17630567f, 0.02603810f, -0.08149121f, -0.02540480f, 0.12615909f, -0.06287332f, 0.25368163f, -0.04155822f, 
    -0.13649157f, 0.00367469f, 0.09117668f, -0.15679903f, 0.03356251f, 0.02009881f, 0.17651074f, 0.08067901f, 
    -0.21203227f, 0.08235748f, 0.27013242f, -0.16654772f, 0.03698608f, -0.17282481f, -0.02573876f, 0.04455362f, 
    -0.01142526f, -0.02974911f, 0.04676653f, 0.08339616f, 0.00237418f, -0.05331257f, -0.01682851f, -0.02048947f, 
    0.02738365f, -0.09601697f, 0.07205754f, -0.00388326f, 0.04712933f, -0.12794553f, -0.07458307f, -0.06606621f, 
    -0.09228708f, -0.00226835f, 0.12732670f, -0.19787018f, -0.06806374f, 0.08671237f, 0.05235475f, 0.10729397f, 
    -0.06041248f, -0.17939682f, 0.09462617f, -0.28034270f, 0.29396823f, 0.09796919f, 0.07943626f, 0.00113292f, 
    -0.02725420f, 0.06786365f, -0.10775445f, 0.09009193f, 0.19832303f, 0.17818135f, 0.04942698f, -0.02236432f, 
    0.01081216f, -0.06494793f, 0.01940070f, 0.02626098f, -0.06576491f, 0.10676944f, 0.02295431f, 0.04519759f, 
    0.17637639f, 0.02115829f, -0.07000475f, 0.05235249f, 0.08098331f, -0.03193817f, -0.04046524f, 0.05549196f, 
    0.12200783f, 0.07124065f, 0.03032360f, -0.04805263f, 0.02892168f, 0.05924449f, 0.10270219f, -0.08766747f, 
    -0.50169879f, 0.28818655f, 0.06979876f, -0.00001663f, -0.08490956f, 0.04723751f, 0.04097141f, -0.05432843f, 
    0.02539900f, -0.00977106f, 0.06764679f, -0.04297953f, -0.01368275f, -0.08519594f, -0.10190763f, -0.08848687f, 
    -0.01888893f, 0.25485370f, 0.19051960f, 0.06645378f, 0.07340708f, -0.02248713f, 0.04401504f, -0.00441172f, 
    0.15674366f, -0.36418286f, -0.16889706f, -0.21909223f, 0.09953613f, 0.07015524f, 0.06783389f, 0.05022397f, 
    -0.03615842f, -0.00391166f, -0.05303087f, 0.04571760f, 0.02574533f, -0.07840051f, -0.03496987f, 0.19430205f, 
    -0.01060743f, -0.06408679f, -0.04638546f, 0.06100105f, 0.02258481f, -0.05390634f, 0.20124587f, -0.10283113f, 
    0.36439604f, 0.16905242f, -0.18814914f, -0.34932080f, -0.01522366f, -0.05035097f, -0.00085622f, -0.00310271f, 
    0.01371285f, -0.01006685f, -0.05558535f, 0.07738517f, 0.15361814f, 0.27412698f, 0.27738759f, -0.04524768f, 
    -0.17601076f, 0.12646787f, 0.08108646f, -0.12080359f, 0.04259603f, -0.06269455f, 0.03070640f, 0.15076692f, 
    0.19356279f, 0.14243856f, 0.17268480f, -0.08723655f, 0.09148932f, 0.15154019f, 0.04414500f, 0.03284158f, 
    0.04708618f, -0.02517767f, -0.03826557f, 0.00659714f, -0.38089162f, -0.04489908f, 0.31662452f, -0.02594455f, 
    0.01340809f, 0.01768812f, -0.06395444f, 0.00801299f, 0.06751714f, 0.07045995f, -0.07292851f, 0.09090377f, 
    -0.29451978f, 0.22679520f, 0.10650606f, -0.34222338f, 0.02057378f, 0.01950607f, -0.08287553f, -0.12467889f, 
    0.04123201f, -0.03170446f, -0.10764753f, 0.01244618f, 0.03643729f, 0.01492700f, -0.08940513f, 0.07030012f, 
    0.04999420f, -0.04299809f, -0.14670976f, -0.10086624f, 0.06109665f, -0.00074192f, 0.06037127f, -0.03752264f, 
    -0.08765191f, -0.40010774f, -0.07622399f, 0.36471659f, 0.14063448f, 0.01613188f, -0.00287594f, -0.04621001f, 
    -0.06829444f, 0.07550717f, 0.02608074f, -0.01950407f, 0.27699304f, 0.30052394f, -0.09770411f, -0.24782372f, 
    -0.00895956f, 0.08277705f, -0.04342635f, 0.07997197f, 0.07412633f, -0.05282811f, 0.02994661f, 0.11289944f, 
    0.01032654f, -0.01297677f, 0.17560926f, -0.16933744f, -0.06862441f, -0.00578294f, -0.17864344f, -0.16212884f, 
    -0.09881974f, -0.12240288f, -0.01587144f, -0.17726724f, -0.38400543f, -0.06201547f, 0.04354209f, -0.37291086f, 
    -0.02289078f, 0.17700568f, 0.09944819f, 0.03203657f, 0.12547950f, 0.01192167f, 0.03296507f, -0.06250979f, 
    0.26209027f, 0.22268918f, -0.13563451f, 0.19547480f, -0.15761560f, -0.10660771f, -0.12201044f, -0.11071906f, 
    -0.03855415f, -0.02074661f, -0.08197182f, 0.19312510f, 0.20558693f, 0.11848054f, 0.28379881f, 0.15150453f, 
    0.11913769f, 0.12132113f, -0.07087584f, 0.12107875f, 0.02594194f, -0.33778131f, 0.03486490f, 0.21710993f, 
    -0.30610034f, -0.08807230f, 0.07175038f, 0.15127450f, -0.00633825f, 0.11090708f, 0.04795312f, 0.04307391f, 
    -0.03568331f, 0.08796211f, 0.00917140f, 0.10080672f, 0.81005222f, 0.19506742f, 0.70173621f, 0.11437218f, 
    0.04679453f, -0.09159474f, 0.00321663f, -0.01519280f, 0.02139439f, 0.05383020f, 0.05932061f, 0.13467805f, 
    -0.45788613f, 0.27100828f, -0.09780268f, -0.09604056f, -0.10315119f, 0.03658796f, -0.11095277f, 0.01229164f, 
    0.09336283f, 0.02405610f, -0.03760780f, -0.03013545f, -0.28048086f, 0.18373954f, -0.01505065f, -0.07695284f, 
    -0.19214138f, -0.02251278f, -0.17000701f, 0.05830574f, 0.18240608f, 0.07781585f, 0.34849304f, 0.28263772f, 
    -0.09864768f, -0.18505652f, -0.09857468f, -0.09308764f, 0.16509359f, 0.04595699f, 0.19366582f, 0.04879527f, 
    0.05649196f, 0.20162784f, 0.10874557f, 0.20237377f, -0.15250462f, -0.02673270f, 0.17368507f, 0.34966573f, 
    -0.19968535f, 0.02656113f, 0.19374079f, 0.09591239f, 0.02131096f, -0.04800787f, 0.07633285f, 0.15784241f, 
    0.07734218f, 0.10867631f, 0.14690833f, 0.15197639f, 0.01753194f, -0.20359805f, 0.16204998f, -0.05764265f, 
    0.07553776f, 0.18864432f, -0.24849558f, 0.03719464f, -0.56398654f, -0.16245583f, -0.13274929f, -0.19675949f, 
    -0.06037705f, -0.14007260f, 0.08390692f, -0.18295279f, -0.00085083f, -0.00427345f, 0.07244628f, 0.09046024f, 
    -0.01221548f, -0.00729275f, 0.12314431f, -0.29857042f, -0.13099276f, -0.17178623f, 0.04494014f, -0.04690990f, 
    0.09956699f, 0.21293433f, 0.23457766f, 0.15220542f, -0.43751359f, 0.00059082f, -0.05260576f, 0.11184911f, 
    -0.07980791f, 0.09728338f, -0.15061253f, 0.27969828f, 0.14144360f, 0.17092539f, -0.13973597f, -0.01566453f, 
    0.14522448f, 0.03830389f, 0.28285128f, 0.20096762f, 0.08466738f, 0.08646528f, 0.16889726f, 0.15058145f, 
    0.02631090f, -0.05011282f, -0.07188893f, 0.11413626f, -0.48587438f, -0.25544050f, -0.15885124f, -0.12214895f, 
    -0.07470953f, -0.04372030f, -0.08854069f, -0.09991981f, 0.13779362f, -0.06115528f, -0.04767988f, 0.08186997f, 
    0.08409300f, 0.20002560f, 0.04922390f, 0.06964937f, -0.11793249f, 0.25832647f, 0.01584102f, 0.04833583f, 
    0.08519586f, 0.14402239f, 0.27331257f, 0.32336846f, -0.15034747f, 0.72239399f, -0.32842213f, -0.09271496f, 
    -0.02699314f, 0.17354517f, -0.04555395f, -0.00471879f, -0.09564706f, 0.07424771f, 0.21385582f, -0.02419929f, 
    0.12581921f, 0.29193419f, 0.18726574f, 0.02395256f, -0.07370605f, -0.03938466f, -0.23629537f, 0.15880930f, 
    0.02937166f, 0.03511935f, -0.03332262f, -0.11494512f, -0.01030331f, 0.06700942f, 0.05672015f, 0.28282553f, 
    0.02042142f, 0.00067064f, 0.02986195f, 0.23720813f, -0.07444996f, -0.03297777f, -0.06379826f, -0.14021996f, 
    0.20488229f, 0.02138929f, 0.03216483f, 0.13137561f, 0.23615234f, -0.20525780f, -0.09820493f, 0.03825239f, 
    0.05395205f, 0.02113392f, -0.08094368f, -0.13010547f, -0.16517898f, -0.29341933f, -0.11899837f, 0.05718943f, 
    0.15967126f, 0.05870875f, 0.27886197f, 0.06717661f, 0.09013217f, -0.00706533f, 0.04998864f, 0.14358757f, 
    -0.27994320f, -0.05753213f, -0.05992423f, -0.00722233f, 0.05490569f, 0.14807691f, 0.07916082f, 0.08877958f, 
    0.00002875f, 0.03133922f, -0.08149485f, -0.04112402f, -0.01835490f, -0.04790566f, 0.14587916f, -0.04916893f, 
    -0.07956093f, -0.04818026f, -0.03424674f, -0.12855569f, 0.01636588f, 0.07162968f, 0.23641407f, 0.12393510f, 
    0.01017847f, 0.01515750f, -0.15953748f, 0.01497442f, -0.03852335f, -0.00019923f, -0.20007332f, 0.04402508f, 
    -0.02525437f, 0.15933241f, 0.03236932f, 0.00160380f, -0.23083097f, 0.13918947f, 0.13125198f, 0.27774400f, 
    0.06190300f, 0.09947259f, 0.06982833f, 0.21886270f, 0.11830301f, -0.01236079f, 0.10588174f, 0.09304440f, 
    -0.18287919f, 0.03185891f, 0.03200259f, 0.17416237f, -0.10343710f, 0.00405772f, 0.24816845f, -0.08153149f, 
    0.09285480f, 0.06264095f, 0.00908822f, 0.16297175f, 0.10795224f, 0.11620745f, -0.03743841f, 0.29456171f, 
    0.14837401f, 0.14159024f, -0.02509109f, 0.13147011f, 0.14657515f, 0.10372138f, -0.16341023f, -0.12081464f, 
    0.42006993f, 0.13712455f, 0.38869655f, 0.04395948f, 0.11212611f, -0.04515405f, 0.15967895f, -0.06816205f, 
    -0.07514756f, -0.12502721f, 0.05257756f, -0.07682219f, -0.16453809f, -0.13313036f, 0.04135621f, -0.20027907f, 
    -0.08561055f, -0.08860430f, -0.09874707f, -0.13492462f, -0.03480563f, 0.04891880f, 0.00782096f, 0.02667459f, 
    -0.08687645f, 0.23509623f, -0.02685053f, 0.11893922f, 0.02334094f, 0.11020131f, 0.04037347f, -0.00417805f, 
    0.01927095f, -0.06682654f, -0.11945868f, -0.05513724f, 0.10346285f, 0.27359927f, -0.14403118f, 0.37139663f, 
    0.07334048f, -0.14533675f, 0.05676031f, -0.14178459f, -0.04508541f, -0.04984839f, -0.17490104f, 0.05083358f, 
    0.03941049f, 0.01717416f, 0.00456266f, -0.01523810f, -0.01320298f, 0.00269766f, 0.01061398f, 0.01806318f, 
    -0.02237418f, 0.02950131f, -0.01727588f, -0.03624528f, -0.00678233f, 0.01254195f, -0.01581715f, 0.02509712f, 
    -0.04425141f, -0.02665161f, -0.04054438f, 0.03026218f, -0.03439324f, -0.05073433f, 0.04366802f, 0.02083204f, 
    0.01755496f, -0.04433423f, -0.00256548f, 0.02564805f, 0.00757543f, 0.01471447f, -0.02426810f, 0.04609447f, 
    0.03074267f, 0.00685477f, -0.03023201f, 0.00912467f, -0.06617729f, 0.01565970f, -0.04750061f, -0.02438487f, 
    0.00330249f, -0.01053592f, -0.04055920f, -0.00010616f, 0.00269127f, -0.03719197f, 0.00175239f, -0.04524022f, 
    0.01784133f, -0.05017248f, -0.01373758f, -0.03223256f, -0.01869239f, -0.04905979f, 0.00705263f, 0.03504800f, 
    -0.02935694f, -0.02284004f, 0.01161870f, 0.02798150f, -0.02306544f, -0.00883345f, -0.01189993f, 0.03955172f, 
    0.01946053f, -0.03439031f, -0.01636050f, 0.04006115f, -0.05688282f, -0.04610500f, 0.03860172f, 0.02566677f, 
    0.01324098f, 0.00806169f, 0.03083270f, -0.05808524f, -0.05966574f, 0.03568240f, -0.01542785f, -0.04124155f, 
    -0.05415930f, -0.01009287f, -0.00947326f, -0.05053271f, -0.01111856f, 0.02049288f, -0.02997356f, 0.00958102f, 
    0.02748840f, 0.00421412f, -0.02381403f, -0.00081965f, -0.05894266f, 0.02727174f, -0.05689087f, -0.01021446f, 
    0.01262758f, -0.04193191f, -0.00722964f, -0.03553793f, -0.04898226f, 0.02569576f, 0.00478506f, 0.01257906f, 
    -0.04701114f, 0.03432439f, -0.00251072f, -0.01805810f, 0.01081250f, -0.04322967f, -0.05174737f, -0.02386932f, 
    -0.02331720f, -0.04155912f, 0.01712485f, -0.04606574f, 0.03368568f, -0.04120502f, 0.01628146f, 0.03309770f, 
    0.02365853f, 0.03248503f, -0.02322298f, -0.03375015f, -0.02459258f, 0.01593863f, 0.00789437f, 0.00809134f, 
    0.02854256f, -0.04691253f, 0.02166886f, 0.03586366f, 0.01529647f, -0.00008555f, 0.03129527f, -0.01086532f, 
    -0.03935918f, 0.03386020f, 0.03594165f, -0.04977728f, 0.03391715f, -0.02578556f, -0.05217578f, 0.01558423f, 
    -0.03925367f, 0.03692757f, -0.00235736f, -0.04925742f, -0.02754137f, -0.01743396f, 0.02164370f, -0.02426626f, 
    0.02464977f, -0.03402593f, -0.03089649f, -0.04325259f, 0.04676140f, -0.03389057f, -0.03074601f, 0.03215504f, 
    0.02502927f, -0.05879320f, -0.00654073f, -0.02307808f, -0.04956854f, -0.05342868f, -0.05605968f, 0.04742399f, 
    0.01858141f, 0.00762285f, -0.01785055f, -0.04231726f, -0.03553060f, 0.04386176f, -0.03941671f, -0.05124922f, 
    -0.03851171f, -0.03887963f, 0.04093500f, -0.02179142f, 0.05166441f, 0.04202542f, 0.05737557f, 0.03968126f, 
    -0.00819540f, -0.02790963f, 0.04056646f, -0.03064769f, -0.00262213f, -0.04454222f, 0.03213738f, 0.01024908f, 
    -0.01302325f, 0.02884807f, -0.04973562f, 0.00576689f, -0.02293371f, -0.00490738f, -0.02612811f, -0.04490839f, 
    -0.01161664f, 0.04282874f, -0.05004827f, -0.04203774f, 0.01198403f, -0.02355003f, 0.02475736f, -0.05366851f, 
    0.03902060f, -0.01480262f, -0.01564380f, -0.04932407f, -0.00527077f, -0.02082497f, -0.04025936f, 0.03107644f, 
    -0.01657833f, 0.03178583f, 0.00226924f, -0.00019118f, -0.03048684f, -0.02569696f, -0.03656339f, 0.03085944f, 
    -0.02407470f, -0.00342960f, -0.00429129f, -0.00716926f, -0.00135477f, 0.02803175f, -0.05707267f, -0.04070064f, 
    -0.04492641f, -0.04111861f, 0.00193130f, 0.01532640f, 0.00831340f, 0.02960372f, 0.00507092f, 0.02673551f, 
    0.04189206f, 0.01622165f, -0.01249442f, 0.01074643f, 0.02859966f, -0.04102784f, -0.03491096f, -0.05857543f, 
    0.00740709f, -0.01859395f, 0.02959387f, -0.03478036f, -0.04910311f, -0.00697255f, -0.01766590f, -0.02791285f, 
    0.00140801f, 0.01580784f, 0.02123235f, -0.00921609f, 0.03300312f, 0.03019877f, -0.04614396f, 0.04037964f, 
    -0.02833224f, 0.05546577f, -0.03718342f, -0.00470162f, -0.02625827f, -0.01657668f, 0.00288865f, -0.00737172f, 
    -0.04303832f, -0.01406869f, 0.03732726f, -0.03938036f, 0.06245666f, -0.03951092f, -0.01200065f, -0.03182677f, 
    -0.05213092f, -0.05033828f, -0.00904106f, 0.01803580f, -0.03233824f, 0.02123372f, -0.01009925f, -0.01666714f, 
    -0.00969366f, 0.04516230f, 0.03789569f, -0.03169817f, -0.01339234f, -0.00889707f, -0.00875643f, 0.03050474f, 
    0.00150594f, 0.04513094f, -0.01671769f, -0.02013343f, 0.00429770f, -0.03565408f, -0.01208268f, -0.02258084f, 
    0.00884112f, 0.00984978f, -0.03968258f, 0.02572086f, 0.01806829f, -0.01747877f, -0.02958918f, 0.03494422f, 
    0.03255882f, -0.04384928f, -0.04506729f, -0.05721853f, 0.02911369f, -0.02284030f, -0.00811890f, -0.00230663f, 
    0.03631321f, -0.01728092f, -0.01131013f, 0.01528466f, -0.01835824f, 0.02332087f, -0.03877434f, 0.02989031f, 
    -0.04073741f, -0.01671484f, 0.00335238f, -0.00265451f, -0.00797223f, 0.02011567f, 0.01097333f, -0.05887632f, 
    0.04797082f, 0.01888799f, 0.00353595f, -0.01158904f, -0.03646561f, -0.05218634f, 0.01505089f, 0.02465494f, 
    -0.03046346f, -0.04038400f, 0.04445142f, 0.01631724f, 0.00034493f, -0.02791553f, 0.04552003f, 0.01263677f, 
    0.03017805f, -0.05289206f, -0.02840423f, 0.01358568f, 0.00567145f, 0.02422744f, -0.03393094f, 0.01509560f, 
    0.01378524f, 0.03368769f, 0.02862612f, -0.05355389f, -0.04712393f, -0.00629027f, -0.04884358f, -0.03963839f, 
    0.02172406f, -0.00834425f, -0.03742876f, -0.05718604f, -0.04065246f, 0.03098768f, -0.01850321f, -0.05085469f, 
    -0.05535167f, -0.02792745f, -0.03960143f, 0.00905927f, -0.03350373f, -0.04162870f, 0.00451559f, -0.03408667f, 
    -0.10771292f, -0.03618919f, -0.10625204f, -0.01218781f, -0.00396229f, 0.07040989f, 0.05032533f, 0.03061482f, 
    0.26152965f, 0.03670123f, 0.09599832f, 0.19052576f, 0.36754677f, 0.02259551f, 0.10041756f, 0.17037874f, 
    0.09156593f, -0.01435992f, -0.19089402f, -0.11387542f, -0.03920049f, -0.08923681f, -0.00293923f, 0.07792016f, 
    -0.04576635f, 0.15313597f, -0.15291707f, 0.06969521f, -0.10522587f, -0.04026954f, 0.03381118f, 0.02410521f, 
    -0.11129966f, 0.08748390f, 0.13596161f, 0.05055439f, 0.09330089f, 0.22137578f, 0.11006696f, 0.16570044f, 
    -0.05015615f, -0.17701548f, 0.04962412f, -0.06711166f, 0.06893747f, 0.38981131f, -0.07734291f, 0.09411968f, 
    -0.14136004f, -0.23284902f, -0.22495571f, -0.16486126f, -0.09442516f, -0.16250342f, -0.01565719f, -0.30181968f, 
    0.00614464f, -0.13285869f, -0.09507155f, -0.08537106f, -0.11046147f, 0.07155725f, 0.39663497f, -0.03195037f, 
    -0.07478409f, -0.24129048f, -0.03323010f, 0.16832753f, -0.05576086f, 0.04686004f, 0.03711662f, 0.06775486f, 
    -0.12913312f, -0.27527571f, 0.19909270f, 0.04117104f, 0.01069346f, -0.08519969f, 0.24377035f, -0.07921702f, 
    -0.02536384f, -0.04743958f, 0.05169069f, 0.04061877f, 0.31136182f, 0.11644249f, 0.11793230f, -0.24331608f, 
    0.15422545f, 0.08491938f, 0.11607443f, -0.06231622f, 0.04239367f, 0.06116762f, 0.02664429f, 0.01689247f, 
    0.10874614f, 0.01279384f, 0.00134251f, 0.18303399f, 0.02602679f, 0.10549168f, -0.05821163f, 0.01851379f, 
    -0.06484354f, -0.21406463f, -0.08763118f, 0.00340098f, 0.17715684f, -0.01997300f, 0.19186136f, -0.09053626f, 
    -0.21569327f, -0.11819057f, -0.08942538f, 0.06161577f, -0.29677597f, -0.11270408f, -0.17426743f, -0.18577503f, 
    0.26799592f, -0.06662235f, 0.39659980f, -0.06829245f, -0.04406177f, -0.06947073f, -0.19088794f, 0.04765506f, 
    -0.06458236f, 0.05397454f, 0.23829006f, 0.17926630f, 0.34810993f, 0.15199217f, 0.13740264f, 0.04147906f, 
    -0.07092329f, -0.07031810f, -0.02129667f, 0.23131268f, -0.00282786f, 0.02925318f, 0.01539271f, -0.04771001f, 
    0.05961723f, 0.06558711f, 0.09625041f, 0.11178098f, -0.03822578f, -0.01113761f, -0.01946983f, 0.08868419f, 
    -0.16958803f, -0.17011066f, -0.24289875f, -0.16559865f, -0.08768550f, -0.27517578f, -0.03303238f, 0.00169723f, 
    -0.05472055f, 0.11185633f, 0.01936002f, -0.09093630f, 0.08010942f, 0.07669193f, 0.01138917f, -0.02351141f, 
    -0.38672152f, -0.35124886f, -0.16501524f, 0.04835964f, -0.02556645f, -0.18494074f, -0.01250966f, -0.11312018f, 
    0.00309051f, 0.07876071f, 0.16157320f, -0.17267027f, 0.36185086f, 0.04886632f, -0.04574345f, 0.01552046f, 
    -0.15172040f, 0.09646966f, 0.11262303f, 0.08475563f, -0.00989939f, -0.00625989f, -0.00015673f, -0.06231460f, 
    -0.13786267f, -0.13244854f, -0.17069630f, -0.21486284f, 0.01654900f, -0.18401176f, 0.07018984f, -0.07680731f, 
    -0.05808981f, -0.25761303f, -0.17965107f, -0.27036819f, -0.23124555f, 0.03298928f, 0.55565667f, 0.17910144f, 
    -0.17775141f, -0.05595874f, 0.26682755f, -0.19670118f, 0.17094114f, -0.07365181f, -0.07434847f, -0.05285755f, 
    0.10293249f, 0.41049394f, -0.06621613f, 0.14923757f, 0.14179778f, 0.12799408f, 0.22531824f, -0.19769643f, 
    0.03947559f, 0.06738788f, 0.08399712f, 0.15916425f, 0.10663555f, 0.23667060f, -0.03694258f, -0.12774470f, 
    0.02797272f, 0.17300698f, 0.19571592f, -0.15667665f, 0.25132892f, 0.17251900f, 0.29274604f, 0.14402021f, 
    -0.10669792f, 0.21093641f, 0.06690751f, 0.14688173f, -0.13189845f, 0.21091935f, 0.06850681f, -0.13012885f, 
    -0.06310378f, 0.08265921f, 0.04036418f, 0.10281433f, -0.11301523f, 0.10425889f, -0.07273992f, -0.16468869f, 
    -0.19166939f, -0.07575925f, -0.13207909f, 0.12965685f, -0.22693433f, -0.06649203f, -0.17562592f, -0.13164578f, 
    0.10578985f, 0.18873453f, 0.04574929f, -0.06476685f, 0.08774192f, 0.01609476f, -0.05251040f, 0.03926772f, 
    0.07986338f, -0.06020190f, 0.03488484f, -0.01685641f, 0.12036449f, 0.03478225f, -0.05870276f, 0.08782398f, 
    0.09540989f, 0.02260321f, 0.06099463f, 0.07844288f, 0.06460322f, -0.06797280f, -0.13617437f, 0.03459435f, 
    0.33284029f, 0.20000789f, 0.49978361f, -0.10746869f, 0.02613013f, -0.01523781f, 0.07268012f, 0.00402570f, 
    -0.06822711f, 0.18813567f, 0.04645007f, -0.15982622f, -0.29591450f, 0.11486105f, 0.12473072f, -0.13079718f, 
    -0.15845177f, 0.04323745f, -0.14690387f, -0.17080405f, 0.19486547f, 0.06296475f, -0.07024146f, -0.16012663f, 
    -0.08845935f, 0.11461110f, 0.04814037f, -0.06506072f, -0.18040819f, -0.04822458f, 0.02138387f, 0.07261454f, 
    -0.11910047f, -0.12728950f, -0.00350171f, -0.16319209f, -0.18998908f, -0.38245764f, 0.42905045f, 0.11477088f, 
    0.05265138f, -0.07016611f, 0.00146051f, -0.03211275f, 0.10481412f, 0.00917881f, 0.15107760f, 0.10790654f, 
    -0.16407590f, 0.16096565f, 0.34874433f, -0.03335577f, -0.14467861f, -0.06306508f, 0.09071413f, 0.05283284f, 
    -0.06830363f, -0.00928371f, -0.11232382f, -0.02779190f, 0.07240057f, 0.10448021f, -0.12356091f, 0.11890403f, 
    -0.08858490f, -0.00954717f, 0.20720321f, 0.03821294f, 0.27309147f, 0.18142283f, 0.03549362f, 0.12414441f, 
    0.05622507f, -0.07211395f, -0.17288429f, -0.06694406f, 0.06436650f, 0.19574441f, -0.03631678f, 0.04683206f, 
    0.06589298f, 0.31958804f, 0.04477068f, 0.03978579f, 0.08768289f, -0.00411529f, 0.29973680f, -0.27866900f, 
    -0.01682308f, -0.06794220f, 0.01988506f, 0.14182074f, 0.15405464f, 0.25890383f, 0.21693200f, 0.22007413f, 
    -0.02353721f, -0.04274251f, -0.02024695f, 0.01104723f, -0.01963418f, -0.02986190f, 0.03201326f, 0.00812211f, 
    -0.01123835f, -0.02874566f, 0.04458655f, 0.00351918f, -0.03149202f, 0.03752904f, -0.02415998f, 0.02475391f, 
    0.00409614f, -0.01422101f, -0.04717823f, 0.03425960f, -0.04659417f, -0.04666891f, -0.02698902f, -0.00871119f, 
    0.00156856f, 0.01466786f, 0.02277542f, -0.06061422f, -0.01571152f, 0.01282047f, 0.04994252f, 0.04141778f, 
    0.04274172f, -0.03581047f, -0.02844552f, -0.05731924f, 0.02158098f, 0.00524802f, 0.01415287f, 0.03468632f, 
    -0.01614471f, -0.00918851f, 0.04468545f, 0.03807788f, -0.04633973f, 0.02538101f, -0.00338199f, 0.00975486f, 
    0.03302928f, -0.00215526f, -0.02814022f, 0.01135712f, -0.00958948f, 0.00669712f, 0.04016532f, -0.01461842f, 
    0.00467667f, -0.00115992f, -0.04948514f, 0.00384404f, 0.02776866f, -0.01619215f, 0.03201778f, 0.04018421f, 
    -0.02972247f, 0.02329203f, 0.04551141f, 0.02032545f, 0.04082560f, -0.05828598f, 0.03277368f, -0.05071185f, 
    0.00147082f, -0.01385974f, -0.05420202f, -0.02861422f, 0.04897875f, 0.04389289f, 0.03413317f, 0.00359087f, 
    0.02452878f, -0.02662409f, 0.04273855f, 0.00776174f, -0.02788375f, -0.03557084f, -0.03434826f, 0.01175203f, 
    -0.01254266f, 0.03883042f, -0.01493063f, -0.04854795f, 0.01179828f, -0.02171975f, 0.02439979f, 0.01857734f, 
    -0.03054253f, 0.02090256f, 0.00568854f, 0.02746571f, -0.04590313f, 0.02202140f, 0.02152845f, -0.05160493f, 
    0.03635102f, 0.03990314f, -0.01992053f, -0.01159135f, -0.05361409f, 0.03991576f, 0.00306943f, -0.03529365f, 
    -0.02321714f, 0.02804824f, 0.03398307f, -0.05155494f, 0.03071244f, 0.03605082f, -0.00379929f, 0.01683575f, 
    0.02323356f, 0.05283574f, 0.01907565f, 0.04612521f, -0.00395581f, -0.04873799f, 0.03261220f, -0.00223667f, 
    -0.01293204f, -0.01295596f, -0.05023084f, -0.00478828f, -0.01006731f, -0.00617461f, -0.04527067f, -0.04086456f, 
    -0.03073918f, -0.02835973f, -0.00575509f, 0.03168931f, -0.00378882f, -0.03748100f, -0.03148535f, 0.01882436f, 
    0.00257038f, 0.01778377f, 0.03156499f, 0.01071189f, -0.04659013f, -0.02501775f, -0.03726809f, 0.01772243f, 
    0.02342590f, 0.04509395f, -0.03482372f, -0.01159404f, 0.01358392f, -0.03387899f, 0.00436698f, -0.05096885f, 
    -0.00108010f, -0.03287415f, 0.02487740f, -0.01815447f, -0.01730899f, -0.03331609f, 0.02705917f, -0.02649659f, 
    -0.02475627f, -0.05280007f, 0.04492909f, -0.02869031f, 0.00740882f, -0.01132141f, 0.00692810f, -0.03299110f, 
    -0.01921066f, -0.01910827f, -0.04029317f, 0.01487259f, 0.05738771f, -0.00138157f, -0.02285607f, 0.05216164f, 
    -0.00397445f, -0.01811566f, -0.03655150f, 0.03112154f, 0.04118168f, -0.00571938f, -0.04409074f, -0.00059198f, 
    -0.02788649f, -0.05968092f, -0.02291720f, 0.01374452f, 0.02227728f, -0.02912028f, -0.02922379f, 0.01004142f, 
    0.02886987f, -0.03161931f, -0.02938215f, -0.01785633f, -0.04197680f, 0.02715119f, 0.03236914f, -0.04183717f, 
    -0.00209558f, 0.00067779f, 0.00171832f, 0.01372377f, -0.03121119f, 0.00711014f, 0.02684338f, 0.03469906f, 
    -0.04541438f, -0.01673661f, 0.01151633f, -0.04213672f, 0.01254987f, -0.04903039f, -0.02512711f, 0.02342213f, 
    0.00628124f, 0.00267527f, 0.04069278f, 0.01506354f, 0.02744602f, -0.05507614f, 0.03490528f, -0.02393134f, 
    -0.03424624f, 0.04289135f, -0.00349190f, -0.03718971f, 0.02616754f, -0.04098728f, 0.03822717f, -0.00627345f, 
    0.03424342f, 0.02327669f, -0.01463986f, 0.02617468f, 0.03571788f, -0.04508300f, -0.03836363f, 0.01186701f, 
    0.01128903f, -0.00364823f, -0.00980385f, -0.00772693f, 0.02454327f, -0.02215001f, 0.01576269f, -0.02568184f, 
    -0.04096841f, -0.01123205f, -0.04469417f, 0.02749051f, 0.01325765f, -0.02017687f, 0.00128590f, -0.00877270f, 
    -0.02468196f, -0.02007600f, -0.00833869f, -0.03832445f, -0.04613195f, -0.02884349f, 0.03963034f, -0.03227975f, 
    -0.00549705f, -0.03608229f, -0.00769081f, -0.03308751f, 0.00571724f, 0.04995127f, 0.03390593f, 0.00765050f, 
    -0.01552068f, 0.03677801f, -0.04976190f, -0.05213678f, -0.02526052f, -0.03328161f, -0.02075712f, -0.01394414f, 
    0.00416843f, -0.01979804f, 0.05358601f, -0.01101345f, 0.00183061f, -0.03154736f, 0.04295595f, 0.03527449f, 
    0.03322164f, 0.01083557f, 0.02556294f, -0.01729377f, -0.04288474f, -0.02539581f, 0.02419254f, -0.03076905f, 
    -0.05226780f, -0.04595158f, -0.01603151f, 0.02216301f, 0.01621031f, -0.02493096f, 0.00919781f, -0.01097853f, 
    0.00468127f, -0.01167206f, 0.02139947f, -0.03206635f, -0.05281723f, -0.04193496f, 0.02355392f, -0.02566938f, 
    -0.02113494f, -0.03052265f, -0.04099763f, 0.02821572f, -0.03635715f, -0.03120063f, -0.05001780f, 0.00163538f, 
    -0.02071931f, -0.02209079f, -0.04901798f, 0.04004500f, 0.01405775f, -0.04768076f, -0.03418760f, 0.00919571f, 
    0.01330781f, -0.03280820f, 0.03264796f, 0.00892106f, 0.01515150f, -0.03215566f, -0.01058444f, -0.00577673f, 
    -0.03750682f, 0.03243936f, -0.02908895f, 0.00247242f, 0.01283159f, -0.04575909f, 0.02306662f, 0.02568925f, 
    0.00184610f, -0.00102548f, -0.01067377f, -0.01470137f, 0.00611897f, -0.05263111f, -0.02662437f, -0.04290967f, 
    -0.03312054f, 0.04386473f, 0.03714522f, -0.04266859f, 0.02194814f, -0.00034235f, 0.03060638f, -0.02300109f, 
    -0.03594279f, -0.02875330f, 0.03742785f, 0.03345431f, -0.04280022f, 0.03146460f, -0.00581232f, 0.02702774f, 
    -0.01700026f, -0.04252491f, -0.04158622f, -0.05364591f, -0.02109756f, -0.00256291f, -0.01319247f, -0.00212620f, 
    0.21587639f, -0.17388600f, 0.05445628f, -0.07254464f, -0.17118010f, 0.00242421f, -0.17561281f, -0.09652107f, 
    0.01250242f, 0.14714082f, -0.16300821f, 0.11812554f, -0.07663660f, 0.17784142f, -0.18107015f, -0.20839818f, 
    0.07589283f, 0.05995659f, 0.23379080f, -0.09569655f, -0.06952203f, -0.18946928f, -0.09905959f, -0.00032305f, 
    0.46074671f, 0.15398353f, 0.46368343f, 0.26202631f, 0.08460790f, -0.15719381f, -0.14207111f, -0.22888409f, 
    0.11935765f, 0.08486759f, -0.02411371f, -0.06969111f, 0.05640157f, 0.07743365f, 0.27563706f, -0.03211621f, 
    -0.10245918f, -0.09893179f, -0.11962081f, -0.08693870f, 0.06600993f, -0.08241484f, -0.08919718f, 0.06338884f, 
    0.21788226f, 0.28047818f, 0.11828950f, 0.35465011f, -0.05074242f, 0.03860312f, 0.16569017f, 0.23737855f, 
    0.12374900f, 0.05368698f, 0.06195028f, -0.02589278f, 0.34075937f, 0.16176830f, 0.01929325f, 0.28409615f, 
    0.00262754f, 0.01555253f, -0.13813284f, -0.08197656f, 0.00241844f, -0.02538246f, -0.04194048f, 0.01279328f, 
    -0.02147572f, 0.09019564f, -0.13656996f, 0.08092535f, 0.09047302f, 0.06752158f, -0.11938808f, 0.19783424f, 
    0.02591148f, 0.11085098f, -0.03069043f, -0.05093371f, -0.30412188f, 0.16647547f, -0.37458038f, -0.15570942f, 
    -0.06181703f, -0.14485712f, -0.00892092f, -0.15739156f, -0.07217389f, -0.12373033f, -0.07638516f, -0.03611922f, 
    -0.05834179f, -0.06343776f, -0.20165147f, -0.28248757f, 0.00112468f, 0.03028843f, 0.01241247f, -0.15680614f, 
    -0.00715034f, -0.12833771f, -0.10534854f, -0.11111087f, 0.08107441f, 0.08499041f, -0.08813073f, -0.02425095f, 
    -0.01385404f, -0.05067773f, -0.10319355f, 0.15916088f, -0.10943303f, -0.20482303f, 0.05209170f, -0.15087087f, 
    -0.13529119f, 0.04166393f, 0.17683032f, -0.05604963f, -0.02611416f, 0.00904999f, 0.14162464f, -0.17704020f, 
    0.06591767f, -0.13910069f, -0.10061782f, 0.03470834f, -0.32622671f, -0.12913901f, 0.08944032f, -0.04428060f, 
    0.46356723f, -0.14451121f, 0.04738809f, -0.04067061f, 0.01930413f, -0.05213020f, -0.05639353f, 0.15578924f, 
    0.19751798f, 0.18504821f, 0.29391971f, -0.19643603f, 0.15283246f, -0.15847880f, 0.03454062f, -0.03129032f, 
    0.07440642f, -0.00066491f, -0.11664778f, -0.11514978f, 0.13537946f, 0.08684967f, 0.15152784f, 0.26443690f, 
    0.30165163f, 0.07362837f, 0.04183012f, 0.13230260f, 0.19291015f, 0.22603565f, 0.07570510f, 0.12966490f, 
    0.46694613f, 0.07434522f, -0.09795225f, 0.10987799f, -0.03287574f, 0.05655679f, -0.10656609f, 0.08691278f, 
    0.02554179f, -0.07859054f, -0.20763308f, -0.11351772f, -0.32236570f, -0.03328002f, -0.12526165f, 0.27354383f, 
    -0.05030901f, 0.24408500f, 0.00283255f, 0.09046271f, 0.01232711f, 0.02012667f, 0.14329457f, -0.19755416f, 
    0.18742189f, 0.01550074f, 0.11282595f, 0.25906658f, 0.03374416f, 0.08275403f, -0.13346443f, 0.04127352f, 
    -0.22521509f, -0.10929389f, -0.13854964f, -0.03365504f, 0.06332138f, 0.05348998f, -0.17298806f, -0.23949468f, 
    -0.01032438f, -0.12808293f, -0.21732599f, 0.08563286f, -0.15384927f, 0.07257113f, 0.00548812f, 0.02065530f, 
    0.15555243f, -0.12067843f, 0.18112786f, -0.32667959f, -0.10407697f, -0.10616646f, -0.05481882f, -0.23378520f, 
    -0.07783966f, 0.06638968f, -0.06523138f, 0.01028214f, -0.09732291f, 0.08265763f, -0.10556027f, 0.01867734f, 
    0.11459425f, -0.02650763f, 0.02174902f, 0.20462602f, -0.06755886f, -0.08851881f, -0.05968019f, 0.18319994f, 
    0.02091368f, -0.30562758f, -0.02649987f, 0.05674352f, 0.02880631f, -0.03995196f, -0.07743946f, -0.05320061f, 
    0.16553113f, -0.01581047f, 0.06744572f, 0.26583391f, -0.08971642f, -0.12192903f, 0.11488216f, -0.01023731f, 
    0.26708299f, -0.07645547f, -0.16903886f, 0.03227459f, -0.25076115f, -0.23441237f, -0.06692001f, -0.41146815f, 
    0.14990532f, -0.32498252f, 0.32465395f, 0.20744056f, 0.11340420f, 0.15019457f, -0.00586611f, 0.03911905f, 
    0.05770332f, -0.15190607f, -0.13324663f, -0.03724008f, 0.12465821f, -0.18875510f, 0.12867244f, 0.01187647f, 
    0.05508378f, 0.00029001f, -0.08457742f, -0.41777119f, -0.11112313f, -0.04545686f, -0.02465118f, -0.05898786f, 
    -0.03401157f, -0.04015831f, -0.04247791f, 0.16954750f, -0.01079498f, 0.00518394f, -0.07874495f, 0.15793492f, 
    -0.10910870f, 0.02249400f, -0.04237079f, -0.21345201f, 0.16144703f, -0.06029538f, 0.17674921f, 0.10376476f, 
    0.14242873f, -0.09360305f, 0.13723440f, 0.37134767f, 0.07189850f, -0.03419007f, 0.21983479f, 0.02482843f, 
    -0.04123072f, -0.12239134f, 0.02797184f, 0.11718328f, 0.06243575f, -0.02184671f, 0.13677485f, 0.03101057f, 
    -0.08171290f, 0.03268441f, 0.09583894f, 0.04607872f, 0.04546460f, 0.04620564f, -0.10172510f, 0.21380246f, 
    0.05752226f, 0.10322460f, -0.05534872f, 0.04279523f, 0.16839707f, -0.01650183f, -0.00247707f, -0.05559091f, 
    0.13214800f, -0.10218172f, -0.10028886f, -0.02665064f, 0.04248768f, -0.05638079f, -0.08093774f, 0.04055567f, 
    0.04909084f, -0.01409423f, 0.01750780f, 0.18663597f, -0.05935148f, -0.06551328f, -0.01765614f, -0.10054938f, 
    0.03122317f, 0.31361812f, 0.14899017f, 0.04055782f, 0.16837884f, 0.06522061f, 0.13861379f, 0.27906829f, 
    -0.01660641f, 0.04556571f, -0.04219118f, 0.13410538f, -0.07919265f, -0.00473177f, 0.04305740f, -0.12723228f, 
    0.13473874f, 0.01279630f, 0.11907513f, 0.08543527f, -0.30625618f, 0.17916247f, -0.08345139f, 0.18428501f, 
    -0.02680204f, -0.02324997f, 0.20824949f, -0.05337567f, 0.12837009f, 0.01387076f, 0.12625818f, 0.07914868f, 
    -0.03978109f, 0.04661412f, 0.01115810f, 0.02934818f, 0.04258979f, -0.01857108f, -0.01621800f, 0.02967229f, 
    -0.03656111f, 0.01720486f, 0.03951439f, -0.00341241f, 0.01646710f, 0.03469550f, -0.04363793f, 0.03532589f, 
    -0.04409985f, -0.05423597f, -0.04541772f, 0.02112174f, 0.02711655f, 0.03017317f, 0.00600822f, -0.04885967f, 
    -0.01749409f, -0.03529429f, 0.00865787f, 0.01396195f, 0.03590960f, -0.04982593f, -0.02702572f, 0.00489998f, 
    0.01237848f, -0.03820328f, -0.01935908f, 0.01009395f, -0.03340576f, 0.03778280f, 0.01002961f, -0.04906690f, 
    -0.01506942f, 0.00169645f, 0.03679358f, -0.03102645f, -0.01000804f, -0.01967543f, -0.03581997f, -0.03789200f, 
    -0.05163526f, 0.00265594f, 0.03558341f, 0.00946095f, 0.04403412f, -0.02484867f, -0.04476929f, -0.01912516f, 
    0.04439439f, 0.03901321f, 0.00174220f, 0.02577373f, 0.04760524f, 0.00177731f, 0.02213658f, 0.01781766f, 
    -0.02958256f, -0.04853474f, -0.05084760f, 0.02219614f, 0.02367199f, -0.05156046f, 0.02542401f, 0.03440347f, 
    0.01833792f, -0.00891228f, -0.01112669f, -0.03300720f, -0.02835649f, -0.03050141f, -0.05546896f, 0.02096569f, 
    0.00354157f, -0.03472144f, -0.04033703f, 0.03768529f, 0.04851507f, -0.04275995f, 0.03824549f, -0.02009134f, 
    -0.02735815f, 0.02839584f, 0.02467189f, -0.02049280f, 0.01662973f, -0.01884643f, 0.03994942f, -0.01331307f, 
    -0.04488933f, -0.03377180f, 0.00920955f, 0.03659582f, 0.00792071f, 0.02988119f, -0.00508395f, -0.03331718f, 
    -0.02963174f, 0.01204060f, -0.00477386f, -0.00683328f, 0.04374425f, 0.03617061f, -0.04367644f, 0.00570965f, 
    -0.05856734f, 0.03632760f, 0.01700706f, -0.00221184f, -0.01796814f, -0.00459950f, 0.03074717f, -0.04991588f, 
    -0.01533351f, 0.00206271f, -0.00981295f, -0.02691606f, 0.02784988f, -0.05484137f, 0.02417132f, 0.03936960f, 
    0.01215119f, -0.01654245f, -0.01107330f, 0.04311910f, 0.00225033f, -0.04970322f, -0.02895950f, 0.02978963f, 
    -0.02407181f, -0.03534558f, -0.05413288f, -0.01023137f, 0.03029098f, 0.03407212f, -0.03410423f, -0.02754734f, 
    -0.00904763f, -0.01471641f, 0.02888121f, -0.00528932f, 0.03448561f, -0.04724250f, -0.03913629f, -0.01629118f, 
    0.02929282f, -0.04893876f, -0.04396914f, -0.01079872f, -0.03558123f, -0.01554719f, -0.00658532f, -0.00298724f, 
    0.04435637f, -0.02239107f, -0.01843344f, -0.03180977f, -0.01648861f, -0.02346471f, 0.03990529f, 0.00169673f, 
    -0.02939717f, 0.02073344f, -0.02359627f, -0.00263836f, 0.00031164f, -0.04138874f, 0.03798304f, 0.00735251f, 
    -0.01803627f, -0.00318600f, 0.02839908f, 0.00410121f, -0.05372708f, -0.04765355f, 0.04697591f, 0.00770714f, 
    -0.05653428f, 0.00600710f, -0.00939102f, -0.02044227f, 0.02425263f, -0.01617817f, -0.04260062f, 0.00847996f, 
    0.03549298f, -0.04992726f, 0.01465111f, 0.03613477f, -0.02540057f, -0.01385088f, 0.03922951f, 0.03496034f, 
    -0.02036041f, -0.00246002f, -0.00244777f, -0.05743093f, -0.03219026f, -0.02022311f, 0.01183187f, -0.02390786f, 
    0.01824319f, 0.03457960f, 0.03901533f, -0.04592932f, -0.03537780f, 0.03918448f, 0.04204198f, -0.02126642f, 
    -0.01594276f, -0.01966283f, 0.03274581f, -0.02496340f, -0.04349194f, -0.03807237f, -0.03632552f, -0.00095731f, 
    -0.00261314f, 0.00631177f, -0.00049303f, 0.00480429f, -0.01854974f, -0.02067758f, -0.00351957f, -0.01347935f, 
    -0.00856113f, -0.00676258f, -0.01533010f, -0.02665975f, 0.01397563f, -0.02867199f, 0.02662372f, -0.04376018f, 
    0.03030949f, -0.00177939f, -0.05853483f, -0.02610619f, 0.01985170f, -0.01579324f, -0.03329531f, -0.01906786f, 
    -0.00588845f, -0.00270766f, 0.00456861f, 0.02684764f, -0.01152309f, 0.01897289f, -0.00506074f, 0.02034330f, 
    0.04409686f, -0.03571332f, 0.03451786f, -0.01652303f, 0.02089236f, -0.01098619f, -0.02830619f, -0.03302541f, 
    0.04027094f, 0.04150630f, -0.00614462f, -0.00160387f, 0.02560806f, -0.00035274f, -0.05304166f, -0.01849371f, 
    -0.00245551f, -0.05663927f, -0.05411756f, 0.00971720f, -0.03033019f, 0.00633137f, 0.04773398f, -0.02639424f, 
    0.03729777f, -0.04199024f, 0.04059033f, -0.02017280f, -0.00446669f, -0.03226054f, -0.04786485f, -0.03466091f, 
    -0.05307983f, 0.00672381f, -0.01334759f, -0.00698698f, 0.02496430f, 0.02273720f, 0.01302524f, 0.01709819f, 
    0.00036634f, 0.01494383f, 0.01521670f, 0.00326590f, 0.02619112f, -0.02064050f, 0.02266176f, -0.00034686f, 
    -0.01360787f, 0.00084685f, -0.00662303f, 0.02654902f, -0.01250132f, -0.04535171f, -0.01109652f, -0.01125782f, 
    -0.05256414f, 0.03541880f, 0.00572773f, 0.00626392f, 0.01667698f, -0.03097210f, -0.02152337f, 0.03993832f, 
    -0.02857668f, 0.02859636f, -0.05327271f, -0.05058650f, 0.02933713f, 0.02849641f, -0.04347587f, 0.01189684f, 
    0.02232717f, -0.00970043f, 0.00252361f, -0.00633278f, 0.02499213f, -0.02148109f, 0.02238189f, -0.04062341f, 
    -0.00511463f, -0.03435184f, -0.03405663f, -0.02613351f, -0.00021781f, -0.01796762f, -0.00382916f, 0.02696100f, 
    -0.03908467f, -0.05545130f, -0.00354541f, -0.03310148f, -0.00899674f, 0.02421580f, -0.01384145f, 0.03804442f, 
    -0.04751444f, 0.00965847f, -0.01717913f, -0.03512561f, -0.02050118f, -0.05154661f, -0.02705467f, 0.02922569f, 
    -0.00092796f, -0.01980294f, -0.01138026f, 0.01569959f, -0.00453258f, -0.03469808f, -0.05073074f, 0.03558799f, 
    0.00993563f, -0.01372696f, -0.05912004f, -0.04236193f, -0.02119943f, -0.01923255f, -0.05088581f, 0.00546244f, 
    -0.03771060f, 0.01740662f, 0.02916482f, -0.04678483f, -0.04458006f, 0.00020084f, -0.05153307f, 0.02980681f, 
    -0.00830272f, 0.01295098f, 0.04075957f, -0.02164268f, -0.01307021f, -0.00677661f, -0.00991670f, -0.03075167f, 
    0.03559949f, -0.05019443f, 0.02689353f, -0.03849122f, -0.04825196f, -0.04697248f, 0.03400765f, -0.04749101f, 
    -0.00336984f, -0.00014189f, 0.01864451f, 0.01816929f, 0.03485015f, 0.00705961f, 0.03373187f, -0.02367691f, 
    0.01325265f, 0.04825764f, 0.04053844f, 0.01692995f, 0.04387664f, -0.02654910f, 0.04280520f, -0.05436567f, 
    -0.03128247f, -0.01642307f, 0.01826756f, -0.04464372f, 0.02776407f, -0.03452387f, -0.00434191f, 0.02951237f, 
    -0.00244688f, -0.01680991f, 0.03746299f, -0.01043761f, 0.00543258f, -0.02929230f, -0.04452224f, -0.03713647f, 
    0.02229517f, -0.04546849f, 0.00802086f, 0.01850860f, -0.01460336f, -0.04973071f, 0.02644340f, -0.01145084f, 
    0.02279698f, 0.00474790f, -0.04608239f, -0.02416648f, -0.01251964f, -0.03269790f, -0.03676089f, -0.02313604f, 
    -0.04503106f, -0.00280637f, 0.00662354f, 0.00844200f, -0.05068653f, 0.03389684f, 0.01033576f, -0.01143788f, 
    0.02649112f, -0.03015049f, -0.02800649f, 0.03568554f, -0.01495111f, -0.04763008f, -0.00532576f, -0.00747534f, 
    -0.00631505f, -0.04214506f, 0.01522092f, 0.02483954f, 0.02966003f, 0.02181995f, -0.01256116f, -0.01277068f, 
    0.02796576f, -0.05307158f, -0.05529556f, 0.01779984f, -0.04546297f, -0.05779356f, -0.03494156f, 0.00869170f, 
    0.00148396f, 0.03296478f, -0.01136680f, 0.00930907f, 0.02056512f, 0.02364383f, -0.04110330f, 0.01674274f, 
    -0.03737956f, -0.05359359f, 0.01285410f, -0.00973636f, -0.02391742f, 0.03611610f, 0.01997357f, -0.04334461f, 
    0.02790727f, 0.01735826f, 0.03023944f, 0.02595608f, 0.01286474f, 0.01629110f, -0.01032712f, -0.03602813f, 
    -0.02929967f, -0.03268489f, 0.04059619f, -0.03289674f, -0.04772707f, 0.01126835f, -0.04290110f, 0.00027073f, 
    -0.03714360f, -0.00109497f, -0.04878482f, 0.01393803f, -0.00536551f, -0.05232712f, 0.04329283f, 0.00842265f, 
    0.00205970f, 0.02654940f, 0.02836377f, 0.02922796f, -0.00201924f, -0.00712108f, -0.04293455f, -0.00283389f, 
    -0.04350623f, -0.03068185f, 0.02743189f, -0.00685864f, -0.03661001f, -0.04431361f, -0.00788975f, -0.00020606f, 
    -0.01822867f, -0.01101549f, 0.01943807f, 0.00531640f, 0.00253784f, -0.00984509f, -0.00171988f, 0.00194777f, 
    -0.00651091f, 0.03749104f, -0.06221022f, -0.01458826f, -0.03818134f, 0.00645294f, -0.03246734f, -0.05310402f, 
    0.03239495f, 0.01186227f, -0.01192746f, 0.02450730f, -0.03484635f, -0.04554488f, 0.00865656f, 0.00542382f, 
    -0.03003208f, -0.04743132f, -0.02966434f, 0.01984740f, -0.00553209f, -0.00061319f, -0.00307861f, 0.02849005f, 
    0.00930039f, -0.01776427f, -0.05563590f, -0.05789171f, -0.01967990f, 0.01277747f, 0.02622936f, -0.01292252f, 
    -0.05578826f, -0.03534631f, -0.00612989f, -0.03779497f, -0.04911902f, -0.02951824f, 0.01394602f, 0.03810095f, 
    -0.05533755f, -0.03616551f, 0.01529056f, -0.01084848f, 0.04236446f, -0.02308090f, -0.04817070f, -0.03588942f, 
    -0.06415356f, 0.01142972f, -0.01126464f, 0.00271036f, -0.00928906f, -0.03673990f, -0.05038729f, -0.04045476f, 
    -0.00493363f, 0.03637015f, -0.00899498f, -0.01136581f, 0.01998436f, 0.02285111f, -0.03258122f, -0.01929934f, 
    0.02240598f, -0.01056864f, 0.00505732f, 0.02691718f, -0.03268859f, -0.03400872f, 0.00023093f, 0.02670194f, 
    -0.02995556f, 0.04271190f, -0.05494585f, -0.01907055f, 0.02244112f, -0.01363048f, 0.02272476f, -0.02921428f, 
    0.02779884f, 0.01049413f, 0.00176792f, -0.04978402f, -0.03165766f, -0.02796056f, 0.01941028f, -0.04036963f, 
    -0.00330706f, 0.04660352f, -0.00761080f, 0.03709830f, 0.01174435f, -0.02289330f, 0.03488038f, 0.01079083f, 
    -0.06419164f, -0.05342619f, 0.03246209f, 0.00286723f, 0.04122300f, -0.01212801f, 0.03437054f, -0.01067184f, 
    -0.01634451f, 0.00053714f, 0.00466541f, -0.03467121f, -0.02094386f, 0.01115017f, -0.03264021f, 0.02745401f, 
    -0.03282883f, -0.04446450f, -0.01221260f, -0.04107846f, 0.02591673f, -0.00643867f, 0.01870618f, -0.04987333f, 
    0.04087296f, -0.01556896f, 0.03506174f, 0.02267202f, -0.03018609f, -0.00623526f, -0.02913469f, -0.04654993f, 
    0.02959714f, -0.05345842f, -0.04682420f, -0.00271271f, 0.02294775f, 0.02110517f, 0.03958163f, 0.01732834f, 
    0.02439520f, 0.00599485f, -0.01887364f, 0.01976555f, -0.04935549f, -0.03412454f, -0.00899932f, 0.02798085f, 
    -0.03404534f, 0.02350319f, -0.04338173f, -0.01502746f, 0.02767146f, -0.05268289f, -0.01768351f, -0.00644939f, 
    0.00238189f, -0.06070079f, -0.01003061f, 0.00562012f, -0.01232363f, 0.03560416f, 0.02106721f, -0.04496165f, 
    0.03552108f, -0.03414769f, 0.02754591f, -0.02475456f, 0.01316515f, -0.01159334f, -0.04958247f, -0.05024558f, 
    0.03080882f, -0.03981257f, -0.06281786f, 0.00763281f, 0.01256246f, -0.00169144f, 0.03169309f, -0.00950146f, 
    0.03897147f, -0.05645561f, -0.01296221f, -0.04198569f, -0.02044868f, 0.01250695f, -0.02372629f, -0.05601998f, 
    -0.00914173f, -0.01778792f, 0.02506159f, 0.01579395f, -0.01743598f, -0.02771845f, 0.01849851f, -0.03627861f, 
    -0.01314339f, -0.00293363f, 0.00780937f, -0.00739315f, -0.00373094f, 0.02400286f, -0.05579337f, 0.02944370f, 
    0.01573107f, -0.00228228f, -0.02138567f, 0.00248212f, -0.01774404f, -0.02702910f, 0.01060232f, 0.01757069f, 
    -0.05583209f, -0.03278448f, 0.02587035f, -0.02551129f, -0.01014816f, -0.00651542f, 0.02962994f, -0.02814324f, 
    0.03701188f, 0.00408607f, -0.02942012f, -0.04765403f, -0.04978240f, -0.01530847f, -0.02698589f, -0.05842051f, 
    0.16429678f, -0.20862617f, 0.11702486f, -0.11203833f, -0.11922326f, -0.04981952f, -0.02582324f, -0.05910814f, 
    0.03047324f, 0.06558377f, 0.07517295f, -0.24183644f, -0.26207581f, -0.23733626f, 0.16740644f, -0.30014214f, 
    -0.09755819f, 0.02691686f, 0.02641838f, 0.18691351f, 0.08569525f, -0.07350846f, -0.00673877f, -0.04327885f, 
    0.63356555f, -0.21177319f, 0.21676607f, -0.06288061f, -0.10824845f, -0.04930650f, 0.04726383f, -0.04673953f, 
    0.17302920f, 0.11879545f, 0.15112571f, 0.04437065f, -0.10354743f, 0.06707333f, -0.00441988f, 0.00520579f, 
    0.13432923f, 0.09918281f, -0.01942415f, 0.07028560f, -0.00466202f, -0.03997676f, 0.12206884f, 0.08432649f, 
    -0.13538358f, -0.09872449f, 0.01154803f, -0.05046220f, 0.08024912f, 0.05951929f, -0.01554243f, -0.00798297f, 
    -0.10192230f, 0.05792578f, 0.06021989f, 0.06816368f, 0.09550986f, -0.00999043f, 0.10490803f, -0.15005255f, 
    -0.01742112f, -0.01217176f, -0.05181835f, 0.08641975f, 0.10808097f, 0.04756483f, -0.04457701f, 0.23752639f, 
    0.13061012f, 0.03337350f, -0.12323305f, -0.10164401f, 0.07751878f, -0.10507953f, -0.06349368f, 0.06311154f, 
    -0.02485380f, -0.04106285f, -0.05265407f, 0.03514140f, 0.25482181f, 0.11406285f, -0.53176713f, 0.31157047f, 
    -0.09038834f, -0.13015082f, -0.08292834f, 0.11343428f, 0.17066082f, 0.06088933f, -0.04549047f, 0.02102808f, 
    -0.04643810f, -0.16516469f, 0.00836082f, -0.12454516f, 0.02512862f, 0.08512788f, 0.00325736f, 0.09045647f, 
    0.07361721f, 0.03657997f, 0.08305789f, 0.02757271f, -0.15529074f, -0.10338712f, -0.23634657f, -0.10190345f, 
    0.24473199f, 0.13396868f, 0.17251967f, 0.04435740f, 0.05151970f, 0.04417451f, -0.04973001f, -0.01004828f, 
    0.24812207f, 0.27103516f, 0.04355940f, -0.44236696f, 0.18462044f, -0.10908597f, -0.13780339f, 0.03266954f, 
    0.25158364f, 0.06770989f, -0.11224671f, -0.10220359f, 0.04862909f, 0.06775404f, 0.19250634f, 0.17321919f, 
    -0.02192893f, -0.22887404f, -0.02524840f, -0.16307436f, -0.10360990f, 0.01862876f, -0.03331565f, -0.06228627f, 
    -0.26129127f, -0.18074599f, -0.12972869f, -0.03694314f, 0.11574505f, -0.08394899f, 0.08142652f, -0.21359032f, 
    0.08781816f, 0.20511326f, 0.01457774f, 0.11376472f, -0.11889374f, 0.03255973f, -0.16992931f, -0.06654450f, 
    0.17155290f, 0.03566520f, 0.20262770f, -0.00877007f, 0.04128302f, -0.13114634f, -0.00888623f, 0.08428163f, 
    0.06793365f, -0.20509301f, 0.02846789f, -0.29818031f, 0.13486324f, 0.28283569f, -0.08982608f, 0.15755396f, 
    0.06139956f, 0.04821838f, 0.14644484f, 0.02377684f, 0.04249446f, 0.06137005f, 0.09039313f, 0.21377112f, 
    0.07382821f, -0.08412386f, -0.15447117f, -0.14437754f, 0.10021102f, -0.06136309f, -0.18181275f, 0.09325062f, 
    0.03228340f, -0.10604682f, -0.02153953f, -0.05632610f, 0.04960122f, -0.03119120f, -0.09162582f, -0.01569587f, 
    0.04961504f, 0.13717346f, -0.01626085f, 0.10242587f, 0.05324995f, -0.15407164f, -0.34491369f, 0.05707768f, 
    0.15602542f, 0.05774808f, 0.25691581f, -0.26767159f, 0.11677107f, -0.03273418f, 0.04750005f, -0.07905550f, 
    0.21654893f, -0.29946613f, 0.13108675f, 0.10911531f, -0.03591759f, 0.09638590f, 0.03456853f, -0.07209221f, 
    -0.10312947f, -0.03249248f, 0.24989592f, 0.12703113f, 0.25333568f, -0.10815372f, -0.12972760f, 0.22529608f, 
    0.15139689f, 0.13972059f, 0.01232889f, -0.02858161f, 0.00806734f, 0.12462914f, 0.05486510f, -0.28010646f, 
    0.01277413f, 0.01875731f, 0.04965179f, 0.12912585f, 0.12756245f, 0.09267134f, 0.06924346f, 0.19243142f, 
    0.01136171f, -0.12384952f, -0.02784475f, 0.08284928f, -0.09680353f, 0.03423839f, -0.20450550f, 0.13513330f, 
    0.05826653f, -0.03804613f, 0.09078369f, -0.08993848f, 0.08025642f, 0.04048893f, 0.04905556f, 0.09939710f, 
    0.30442202f, 0.30224127f, 0.00234505f, 0.05988510f, 0.01819031f, 0.02735919f, 0.05775272f, -0.11922438f, 
    -0.06946276f, 0.04214362f, -0.01855177f, -0.03022163f, 0.20598249f, 0.03446700f, 0.35715702f, 0.24277595f, 
    -0.10432031f, -0.12125918f, -0.06558777f, 0.06482948f, 0.15517294f, 0.00976373f, 0.06056694f, 0.08266658f, 
    0.10471686f, 0.24471711f, 0.08980229f, -0.18357070f, -0.10805366f, -0.02698189f, -0.09696371f, 0.00197492f, 
    0.34000492f, 0.03171025f, 0.02193142f, 0.16248509f, -0.15022999f, -0.07185305f, -0.17534566f, -0.08274385f, 
    0.17321444f, -0.01548288f, 0.15284240f, 0.01539383f, -0.12464127f, -0.14204672f, -0.17336345f, 0.13019149f, 
    0.14818329f, 0.09786851f, 0.09738665f, -0.08011213f, 0.02905904f, -0.00606073f, 0.10003513f, -0.04660007f, 
    -0.02150596f, -0.04156212f, 0.10223357f, -0.05965015f, 0.03701097f, 0.16588803f, -0.11863812f, -0.12802081f, 
    0.06476831f, -0.04638574f, 0.17155962f, 0.13363636f, -0.01038270f, 0.05355106f, 0.09798270f, -0.01481379f, 
    -0.05381178f, -0.05729575f, -0.07906875f, 0.01308154f, 0.00274419f, -0.09909751f, 0.13546985f, -0.02088429f, 
    -0.12970172f, -0.05944882f, 0.09514242f, 0.07428461f, -0.05838688f, -0.17712694f, 0.14849232f, -0.04085424f, 
    -0.17130624f, -0.12221442f, -0.03118411f, -0.05410352f, -0.10361294f, 0.04271023f, 0.01592517f, -0.07346999f, 
    0.06658690f, -0.05375830f, -0.13067909f, 0.16822691f, -0.04764137f, -0.17301069f, 0.08020379f, 0.01234498f, 
    0.10823131f, -0.04125322f, 0.00296362f, -0.09428920f, 0.14537111f, 0.11764704f, -0.00330889f, 0.15933633f, 
    0.02372256f, -0.01370217f, -0.00746159f, 0.04480824f, 0.02880923f, 0.06111023f, 0.07872377f, -0.11711836f, 
    -0.02792459f, 0.04067075f, -0.05043339f, 0.01993448f, 0.03134360f, -0.00377394f, 0.01135557f, -0.04325202f, 
    -0.02202151f, 0.03321409f, 0.02974262f, 0.00399560f, -0.04171395f, -0.05333095f, -0.00270546f, 0.03651630f, 
    -0.03898079f, 0.00757326f, 0.02265545f, -0.04113303f, 0.00954391f, -0.00192361f, -0.00738242f, 0.03823647f, 
    -0.02200003f, 0.02495830f, -0.00676274f, 0.03327893f, -0.00383870f, -0.03562170f, -0.02659580f, -0.02015503f, 
    0.01044814f, 0.01124988f, 0.00022403f, -0.02380171f, -0.01563023f, -0.04820969f, 0.02196576f, -0.03030204f, 
    -0.04078877f, 0.02093795f, 0.00720482f, 0.00128547f, 0.02475237f, 0.02202732f, -0.00391590f, 0.00817618f, 
    0.03260546f, 0.02981481f, -0.04388988f, -0.05148293f, -0.03633224f, 0.01902553f, -0.00195284f, -0.02360663f, 
    0.00275310f, 0.04736694f, 0.01249072f, -0.02189428f, -0.03736259f, -0.04889078f, -0.04759093f, 0.03523151f, 
    0.01648187f, -0.04987908f, 0.04396850f, -0.00204860f, -0.01023052f, 0.03305436f, 0.00402426f, -0.01630198f, 
    0.00009882f, -0.01664799f, -0.04458980f, -0.00913507f, -0.05664106f, 0.03639937f, -0.01927061f, -0.05384399f, 
    -0.03826259f, -0.05367231f, -0.00330094f, 0.02442655f, -0.03642469f, 0.01861843f, 0.00423177f, 0.02530896f, 
    -0.05191819f, 0.01312045f, 0.03636614f, -0.03265366f, -0.02603611f, -0.01892853f, -0.03487834f, 0.01673979f, 
    -0.03794015f, -0.01397600f, -0.04384413f, -0.01371793f, 0.02659482f, 0.03467606f, 0.03873357f, -0.05571698f, 
    -0.03934629f, -0.02174921f, 0.01106096f, -0.04562150f, -0.01705110f, -0.05540202f, -0.02868199f, -0.05856755f, 
    -0.01511321f, -0.05406243f, 0.01384636f, -0.04320676f, -0.01149542f, -0.00246394f, 0.03529852f, -0.00917982f, 
    0.02718676f, 0.02796626f, -0.01248280f, 0.00556953f, 0.03281849f, -0.01307439f, -0.03035203f, -0.02761186f, 
    -0.05471746f, -0.03910517f, 0.02263854f, 0.01416454f, -0.01217542f, -0.04654108f, 0.00174992f, -0.03017072f, 
    -0.03403738f, 0.01803415f, 0.01216998f, -0.01263130f, 0.04744840f, -0.02026156f, -0.01876499f, 0.03766480f, 
    -0.01106645f, 0.04279482f, -0.00166558f, -0.00506573f, -0.01894131f, -0.03730835f, -0.01153712f, -0.00153294f, 
    0.00827256f, 0.05151060f, 0.00422524f, 0.04070465f, 0.02759901f, 0.03316285f, -0.04671324f, -0.00696002f, 
    0.00935667f, -0.04083803f, -0.04126103f, -0.03205815f, -0.04301768f, 0.01991128f, -0.01984798f, -0.04559710f, 
    0.03419345f, -0.01171103f, 0.02984202f, 0.03940234f, 0.04207246f, -0.02140342f, 0.01273277f, -0.00525335f, 
    0.01556395f, 0.01929401f, -0.04554480f, -0.04560098f, -0.00838918f, 0.02385292f, -0.04843201f, -0.02652922f, 
    -0.04368914f, -0.03878293f, -0.01309295f, 0.04161619f, -0.02778693f, -0.02508270f, 0.00585888f, -0.04097142f, 
    -0.04606190f, -0.03488256f, -0.00511313f, 0.02801303f, -0.05269808f, 0.03596344f, -0.01956332f, -0.01007134f, 
    -0.00467862f, 0.02096904f, 0.01005166f, -0.03616493f, -0.01510131f, -0.03034812f, -0.01382124f, -0.05982376f, 
    -0.04036583f, 0.03970641f, -0.00914866f, -0.01098404f, 0.05067641f, 0.03763632f, 0.01346657f, 0.02199162f, 
    0.01135141f, -0.00108102f, 0.03224503f, 0.04327645f, 0.03777041f, -0.02488737f, 0.03332173f, -0.05002467f, 
    -0.04618432f, -0.05236175f, -0.01504139f, -0.02478331f, -0.00463078f, -0.05120944f, -0.04322836f, -0.03376176f, 
    -0.02433404f, 0.00580753f, 0.03797416f, 0.01513364f, -0.02876137f, 0.03379210f, -0.05947012f, -0.04442076f, 
    0.01467913f, -0.03773469f, -0.05382793f, 0.01507576f, -0.06100180f, -0.02006816f, -0.01797146f, -0.01607408f, 
    0.04213659f, 0.00184395f, 0.01093462f, -0.00293579f, 0.03318176f, 0.02130595f, -0.04694968f, 0.00817983f, 
    0.02837361f, 0.03888375f, -0.02438929f, 0.03237391f, -0.02306191f, -0.00696074f, -0.00968007f, -0.02211334f, 
    -0.04448490f, -0.05147891f, -0.04117781f, -0.04911559f, 0.02354542f, -0.05614540f, -0.03879387f, -0.03672015f, 
    -0.00946697f, 0.01354483f, 0.01412717f, -0.00394621f, -0.01397768f, -0.05010583f, -0.02662777f, -0.05414968f, 
    -0.02144518f, -0.03916940f, 0.01550083f, 0.01146746f, 0.00725435f, 0.00831394f, -0.05437902f, 0.00224087f, 
    -0.03857604f, 0.02634221f, -0.02232856f, -0.01017338f, -0.03463724f, 0.00323826f, 0.01981695f, 0.01030596f, 
    0.01491161f, 0.00306168f, -0.03894555f, 0.01432909f, -0.02830455f, 0.02832569f, -0.02029351f, -0.00555283f, 
    0.03103336f, 0.01086243f, -0.00710244f, 0.00447899f, -0.01596189f, 0.01478079f, 0.01487766f, 0.02301780f, 
    -0.01083053f, 0.01596720f, -0.05553054f, -0.01909234f, -0.02286076f, 0.01173739f, 0.00188215f, -0.02152768f, 
    0.01916001f, -0.02987048f, -0.00184029f, 0.01662347f, -0.05377180f, 0.01164667f, -0.00339700f, -0.05918493f, 
    -0.03489290f, 0.01378581f, -0.02100809f, 0.03209962f, -0.03675007f, 0.01443539f, -0.05312653f, 0.01376425f, 
    -0.03606975f, -0.03213805f, -0.01705023f, -0.03039516f, -0.03247907f, -0.01758634f, -0.04934127f, -0.00724530f, 
    0.02200728f, 0.02630914f, 0.03789777f, -0.00534968f, -0.01157914f, 0.04458654f, 0.01250365f, -0.05417830f, 
    -0.01796118f, -0.04687845f, -0.03806762f, 0.02134050f, -0.04625254f, 0.02270398f, 0.02652804f, 0.00502399f, 
    0.03712182f, -0.00633126f, -0.00008807f, -0.01443905f, -0.01348228f, 0.01026566f, -0.00681832f, -0.00640540f, 
    0.00540005f, 0.00806886f, 0.03265943f, 0.01512825f, -0.05383692f, 0.02849681f, 0.03492106f, 0.02923060f, 
    0.01136301f, 0.02735565f, 0.01091797f, 0.03017838f, -0.05525988f, -0.00377451f, 0.03592379f, 0.03768553f, 
    -0.07855947f, -0.04015739f, -0.24464406f, -0.23414013f, 0.00933979f, -0.03288242f, -0.04629674f, -0.04015369f, 
    0.11178458f, 0.05928947f, 0.03557032f, -0.15623021f, 0.00872216f, -0.16679344f, 0.10264790f, 0.30724576f, 
    -0.01402666f, 0.03003739f, 0.16881287f, 0.10903658f, -0.02397710f, 0.03185588f, 0.00192481f, 0.00318510f, 
    0.18497820f, 0.00465844f, -0.03831148f, -0.11153210f, 0.09664844f, -0.05194581f, -0.10774925f, 0.07698487f, 
    0.14228006f, 0.08781341f, 0.01190840f, -0.08960048f, -0.16853593f, -0.09768815f, 0.07800609f, 0.17349891f, 
    0.17301089f, 0.07114729f, 0.14941561f, 0.12135011f, -0.07806130f, 0.09871026f, -0.00268674f, -0.14810866f, 
    0.10026500f, -0.17470174f, 0.21064593f, 0.37063780f, -0.13760629f, -0.10106052f, 0.12676510f, -0.10868393f, 
    0.06724401f, -0.02647526f, -0.18790177f, -0.07715675f, -0.50697654f, 0.34138921f, 0.00140517f, 0.09712265f, 
    0.11628715f, 0.03584512f, 0.10503068f, -0.07729032f, -0.06692378f, 0.13626708f, 0.09360622f, 0.17892031f, 
    0.02764486f, -0.11523413f, -0.34482437f, 0.08948412f, -0.02130333f, -0.00161120f, -0.05159602f, 0.06033822f, 
    -0.10623811f, 0.08206356f, -0.00504601f, 0.12260981f, 0.22250819f, 0.11002351f, -0.28962502f, 0.13953657f, 
    0.05046584f, -0.13171178f, 0.07844063f, 0.05805853f, -0.10303318f, 0.04204389f, 0.00959046f, -0.03296786f, 
    0.04437912f, -0.06588019f, -0.15955016f, -0.09330449f, 0.16807729f, 0.13595752f, 0.13237058f, 0.05101460f, 
    0.07448129f, -0.07945753f, 0.12907127f, 0.01695896f, -0.04602262f, -0.06714778f, -0.07520790f, -0.04302509f, 
    0.01418682f, -0.05361661f, -0.17325737f, 0.07807581f, 0.05137784f, 0.01846605f, 0.06787726f, 0.05201475f, 
    -0.07252917f, 0.17831412f, -0.01629508f, 0.24460709f, -0.04192519f, 0.09968955f, -0.25235930f, -0.09222675f, 
    0.05254231f, 0.05634274f, 0.06128933f, 0.01620355f, -0.27898252f, -0.11585376f, -0.01527399f, -0.14622876f, 
    0.09112607f, -0.03129081f, -0.15038367f, 0.03233711f, 0.04688566f, -0.05485004f, -0.08103588f, 0.13953292f, 
    -0.21118030f, -0.00767152f, -0.01252986f, 0.19378476f, 0.09118561f, -0.00576466f, 0.09847806f, -0.02696102f, 
    -0.01481907f, 0.05365293f, 0.23348625f, 0.02433967f, -0.35332704f, -0.08247608f, -0.09674355f, 0.24348493f, 
    0.04324985f, 0.01551193f, 0.02528883f, -0.04924355f, 0.06080768f, 0.05124180f, 0.12824973f, -0.03891670f, 
    0.14855130f, -0.03948985f, -0.12256077f, 0.27737466f, 0.05240681f, 0.04435225f, 0.10796907f, 0.02795869f, 
    0.09575409f, 0.01503334f, 0.04138318f, -0.03844856f, 0.41065720f, 0.17399254f, -0.26507017f, -0.18271773f, 
    -0.16022605f, -0.11303478f, 0.03787416f, 0.03394262f, -0.01346520f, 0.12737231f, 0.11685905f, -0.19222701f, 
    0.10812055f, -0.00393340f, -0.08059440f, 0.10720655f, 0.10161185f, -0.09079124f, 0.06582833f, 0.05793040f, 
    0.09060667f, 0.33034185f, -0.06568822f, 0.23603465f, -0.08093013f, 0.00049850f, 0.10274300f, 0.00726570f, 
    0.27574340f, -0.13953359f, 0.15537344f, 0.18408425f, -0.02309604f, -0.11416362f, 0.05623602f, -0.09312751f, 
    0.02108582f, 0.04164059f, -0.04547328f, 0.15173249f, 0.10063817f, 0.05688961f, 0.20902179f, 0.13771603f, 
    -0.17292023f, -0.10777903f, 0.16425928f, 0.11293039f, 0.01120846f, -0.00160508f, 0.02820634f, 0.25587386f, 
    0.04360694f, 0.08163315f, 0.12248134f, 0.15976276f, -0.00639707f, -0.03001485f, -0.03190188f, 0.17233789f, 
    0.38777435f, -0.30229282f, -0.07160081f, 0.05175135f, -0.01913141f, 0.00575222f, 0.13311023f, 0.07908607f, 
    -0.03168105f, -0.03402415f, 0.05944345f, 0.02815895f, 0.17425483f, -0.10155533f, 0.00911834f, -0.11931037f, 
    0.17098986f, -0.08458243f, -0.09752429f, 0.19358148f, 0.05117231f, 0.00200990f, -0.01470126f, -0.04281650f, 
    -0.02105285f, 0.28461790f, 0.31152004f, 0.42211777f, 0.13319705f, 0.18357745f, 0.00567590f, -0.05438998f, 
    0.06616174f, -0.12297567f, -0.04192886f, 0.00339602f, 0.06632236f, 0.18452695f, -0.09014057f, -0.26858610f, 
    0.07059245f, -0.03454513f, 0.00663455f, 0.01455747f, 0.00619846f, 0.01373354f, 0.02716256f, 0.21297801f, 
    -0.40498638f, 0.03382323f, 0.09028298f, 0.13368218f, 0.00791061f, -0.05814439f, 0.06978513f, 0.00937114f, 
    0.08945321f, 0.08665242f, 0.09429237f, -0.07756143f, -0.29000208f, -0.20203897f, -0.00316637f, 0.19344626f, 
    0.20987654f, 0.00029454f, -0.01685983f, 0.07702692f, -0.00479803f, -0.03673342f, 0.13191433f, -0.04162671f, 
    -0.07780918f, -0.19687732f, -0.05857137f, 0.10293648f, -0.13264371f, -0.12859327f, -0.12016840f, 0.08314822f, 
    0.01656814f, 0.11210407f, 0.18976510f, 0.09267181f, 0.09189004f, -0.05269561f, -0.23076521f, -0.06751997f, 
    0.05089914f, 0.04025492f, 0.04832747f, 0.07099877f, 0.01196845f, 0.08408662f, 0.13182750f, -0.01382387f, 
    0.08799314f, -0.21630140f, -0.03853467f, 0.40441909f, 0.10140801f, -0.09764729f, 0.10381012f, 0.02136978f, 
    -0.03495965f, 0.05896223f, 0.13078144f, 0.16735397f, -0.01224220f, 0.03811572f, -0.13511227f, -0.31627122f, 
    -0.14555001f, -0.08044671f, 0.09076472f, 0.10636424f, -0.05462001f, 0.11923502f, 0.11443552f, -0.03383849f, 
    0.27747807f, 0.22076687f, -0.11080634f, -0.33096036f, -0.12246557f, -0.00316195f, 0.06991979f, 0.00877285f, 
    0.17155828f, 0.02133809f, 0.13507904f, -0.02019458f, 0.10024479f, 0.04652813f, 0.02582029f, 0.08217384f, 
    -0.08826774f, 0.06735728f, -0.08268749f, 0.09147530f, 0.15441686f, 0.12656084f, 0.12477770f, -0.04502907f, 
    0.09969929f, -0.10454369f, -0.20971562f, 0.01660868f, -0.04129193f, -0.07660115f, 0.00372146f, 0.02210439f, 
    -0.04569975f, 0.16089180f, 0.06689332f, 0.17522584f, 0.53877419f, -0.24713600f, -0.37099519f, 0.12027693f, 
    0.03208466f, 0.03630852f, 0.23141775f, -0.26632094f, -0.09641113f, -0.08183762f, -0.06625630f, -0.03918448f, 
    -0.02165421f, 0.33655858f, 0.14388436f, -0.05911438f, 0.15674464f, 0.01374186f, 0.04068616f, 0.04382966f, 
    0.02640083f, 0.16236004f, -0.02218401f, 0.01441260f, 0.02364512f, 0.14884409f, 0.06314055f, 0.12009557f, 
    0.00849820f, 0.04858805f, -0.00749142f, -0.04866023f, 0.05478360f, 0.12494135f, -0.29670843f, 0.19850834f, 
    0.20179187f, 0.21836348f, 0.01272326f, 0.00334165f, 0.00019167f, 0.06995309f, 0.12448163f, 0.06331258f, 
    0.00529824f, 0.00128002f, -0.06346579f, -0.11201128f, 0.18307668f, -0.00548332f, -0.07067152f, 0.12239867f, 
    0.03250337f, 0.04810341f, 0.01501697f, 0.06255264f, -0.11523770f, 0.06280226f, -0.17186116f, 0.01567076f, 
    0.16529109f, -0.32191423f, 0.19079258f, -0.05010662f, 0.09924439f, -0.07581485f, 0.17089570f, 0.14940472f, 
    0.02412773f, -0.09416293f, -0.05165952f, 0.07461178f, 0.52294141f, -0.33943334f, -0.13584447f, -0.27227223f, 
    0.08235258f, -0.01776088f, 0.23433766f, 0.10413529f, -0.09619418f, 0.07648841f, -0.19169152f, -0.01108701f, 
    0.10168053f, -0.01834312f, -0.09822392f, 0.02706817f, -0.00429393f, 0.00312663f, -0.09355076f, -0.07954606f, 
    0.05047241f, -0.03398157f, -0.06675330f, -0.30571091f, 0.12496641f, 0.11209049f, -0.01644127f, 0.13716950f, 
    -0.02626183f, -0.06555723f, -0.01211429f, -0.10088453f, -0.18085104f, -0.06392870f, -0.12626944f, 0.00602237f, 
    -0.06781623f, -0.31316453f, -0.02953522f, 0.02016713f, -0.08378715f, 0.16650705f, 0.07612871f, 0.02757666f, 
    -0.06320967f, 0.04446300f, 0.28464949f, -0.04896422f, -0.35440582f, -0.12532282f, -0.05123558f, -0.08900126f, 
    0.18560652f, 0.02491146f, -0.02049096f, -0.07040334f, -0.09809884f, -0.05066258f, -0.15163809f, 0.01864178f, 
    0.24382702f, 0.12882255f, -0.10279865f, 0.17540491f, 0.13138691f, 0.09053758f, 0.06397217f, 0.10328870f, 
    -0.14255917f, -0.12368301f, 0.03816969f, -0.10273217f, 0.21748836f, 0.00251989f, -0.01869557f, 0.04873707f, 
    0.00900200f, 0.01267986f, 0.24058874f, 0.09707246f, 0.01472308f, 0.05898552f, 0.04181959f, 0.12393383f, 
    -0.07312778f, -0.14996372f, 0.08028384f, -0.13605967f, -0.00677762f, -0.15885836f, -0.04903157f, -0.06166630f, 
    -0.08056159f, 0.04689989f, -0.01769755f, -0.08360962f, -0.11079999f, -0.14472301f, -0.31338382f, -0.36230513f, 
    -0.14123668f, 0.12136594f, 0.08297440f, -0.02604087f, -0.02396059f, 0.09866671f, -0.06283230f, -0.03071612f, 
    -0.11716363f, 0.04533970f, -0.08140819f, 0.02169164f, 0.05124665f, 0.08169533f, 0.13160689f, -0.01220717f, 
    -0.07974844f, 0.04580991f, -0.19414665f, -0.13835979f, 0.16415103f, -0.03656514f, 0.19558601f, -0.07326175f, 
    -0.03423195f, 0.07865012f, 0.04837463f, 0.07811600f, 0.06197752f, -0.11672131f, 0.17457902f, 0.07051121f, 
    0.22301367f, 0.06571436f, 0.01898723f, 0.11878208f, 0.05774886f, 0.19235004f, 0.23265353f, 0.02677617f, 
    0.00424934f, -0.12452775f, -0.04798204f, 0.04372549f, -0.11642947f, -0.06632163f, -0.19285180f, -0.09537073f, 
    -0.04845858f, 0.11588217f, -0.02552691f, 0.02252163f, 0.09187447f, -0.11045907f, 0.29298466f, 0.25699717f, 
    -0.01851158f, 0.04216496f, 0.08267556f, 0.08296236f, 0.05561014f, 0.25099272f, -0.04674366f, 0.09711934f, 
    -0.05852910f, 0.03509498f, 0.00699784f, 0.24235797f, -0.15652765f, 0.00347386f, -0.00697770f, -0.09886077f, 
    0.09606492f, -0.09517924f, -0.10947347f, 0.03160432f, -0.09442544f, -0.06106822f, -0.23086391f, -0.19115381f, 
    -0.11481899f, -0.45193663f, -0.01769890f, 0.13202833f, 0.15498273f, 0.07913469f, -0.04969510f, -0.08656635f, 
    -0.03715088f, -0.04460746f, 0.00017753f, 0.02329979f, -0.03108605f, -0.32528776f, -0.28479490f, -0.17432620f, 
    0.06406343f, 0.01132722f, 0.07268099f, -0.04655784f, -0.09504841f, -0.05228610f, 0.02493777f, -0.02010262f, 
    0.50106972f, 0.00931505f, 0.01182372f, 0.03278747f, -0.06873865f, -0.14499651f, 0.11608154f, -0.11444192f, 
    -0.30427569f, 0.10020504f, 0.05211015f, -0.04195033f, 0.16445513f, -0.00127511f, 0.07140171f, -0.09179401f, 
    0.08638716f, 0.10828466f, 0.09530075f, -0.01999750f, 0.14142685f, -0.05250497f, 0.08519418f, -0.14442089f, 
    0.03033566f, 0.07326360f, -0.07138827f, 0.14201927f, -0.04508726f, 0.02360122f, 0.04960778f, 0.04671496f, 
    -0.03295214f, -0.11935557f, -0.14156446f, -0.00456784f, 0.08316586f, -0.12718740f, 0.00591362f, 0.05627087f, 
    0.09969310f, 0.03688592f, -0.10727017f, -0.06445066f, -0.14091378f, 0.09514930f, 0.09168295f, 0.17221610f, 
    0.12961109f, -0.03374905f, -0.08598143f, 0.15757763f, 0.06789678f, 0.13357027f, -0.10086706f, 0.08178911f, 
    -0.00215893f, -0.09959255f, 0.05131707f, 0.14669843f, -0.05688864f, -0.09717506f, -0.13717361f, 0.12685606f, 
    0.02316994f, 0.12998679f, 0.21849182f, 0.03923590f, 0.06507584f, 0.07582347f, 0.28064686f, 0.24039194f, 
    -0.11545148f, -0.13657358f, -0.27185676f, -0.00560426f, 0.01318609f, -0.02108879f, -0.04228789f, 0.15326855f, 
    -0.00721985f, 0.22189295f, -0.01357278f, 0.07023625f, -0.12110217f, -0.09588332f, 0.09062888f, -0.04940485f, 
    -0.06264159f, -0.04966832f, -0.02150971f, 0.02710618f, 0.05484498f, 0.14950128f, 0.20532654f, 0.35921323f, 
    -0.04218436f, -0.01989836f, -0.05312167f, 0.04705750f, 0.01287862f, -0.01100862f, 0.00450558f, -0.05085630f, 
    -0.01631221f, 0.02544741f, -0.03221216f, -0.02701603f, -0.04142313f, -0.01283998f, -0.02603709f, -0.04085035f, 
    -0.04969200f, -0.03445026f, -0.03663111f, -0.03621716f, -0.01169828f, -0.02617404f, 0.02727143f, -0.04758167f, 
    -0.02242894f, -0.04405385f, -0.04544469f, -0.04465327f, -0.07183102f, -0.04404542f, 0.02804102f, 0.02201655f, 
    0.03834835f, 0.02951918f, -0.04605782f, 0.03664605f, 0.01245828f, 0.00458882f, -0.01478086f, -0.00254385f, 
    -0.00110922f, -0.01123414f, -0.02556336f, -0.04120161f, 0.02774231f, 0.04596563f, -0.00357003f, -0.04550828f, 
    0.00810224f, -0.00214370f, -0.01685640f, -0.01811307f, -0.03001124f, 0.03119034f, -0.02904313f, 0.03148900f, 
    0.00911513f, 0.01518479f, 0.02114883f, 0.01907935f, 0.03134023f, 0.02903883f, 0.04287346f, 0.01535570f, 
    -0.04653359f, -0.01492448f, -0.06671793f, 0.02511641f, -0.06723304f, -0.06551553f, 0.01141791f, -0.02110498f, 
    0.04748737f, -0.02363536f, 0.04099723f, -0.03492176f, -0.04637281f, 0.04356548f, -0.00998526f, -0.04982292f, 
    0.04981203f, 0.00618539f, -0.04699299f, -0.00847427f, 0.00434066f, -0.01724989f, -0.06278101f, -0.03299564f, 
    -0.03647314f, -0.04722190f, 0.00434204f, -0.04942122f, -0.06850112f, -0.00984296f, -0.05588992f, -0.03347354f, 
    -0.03667316f, -0.02645450f, 0.02107473f, 0.02656371f, -0.01545679f, -0.01587039f, -0.04296393f, -0.03208710f, 
    0.02561277f, -0.00772970f, -0.02313043f, 0.01586030f, -0.02526558f, 0.01392084f, 0.03070734f, 0.02674224f, 
    0.02531468f, -0.00068721f, 0.03650770f, -0.02350187f, -0.04543107f, 0.02205955f, 0.01960147f, 0.02403858f, 
    -0.00266719f, -0.04463180f, -0.01713419f, 0.03692916f, -0.00753134f, -0.02825641f, -0.01204202f, -0.03360160f, 
    -0.03810489f, -0.03453952f, -0.00730355f, -0.04611536f, 0.00605793f, -0.00641050f, -0.06807823f, 0.01164682f, 
    -0.05913298f, -0.01242792f, 0.00476077f, -0.00077393f, -0.04352484f, -0.02730852f, -0.07218610f, -0.05680461f, 
    0.02434566f, -0.02522562f, -0.01776303f, 0.02854922f, 0.02804266f, 0.00749997f, 0.00211332f, -0.01012042f, 
    0.01679073f, 0.02824117f, -0.04241980f, 0.01371361f, -0.00361592f, 0.05043327f, -0.02516927f, -0.02626418f, 
    -0.04462455f, -0.01997340f, 0.00617371f, 0.01862075f, -0.01213027f, -0.02168737f, 0.04592161f, -0.04344530f, 
    -0.04429995f, -0.03050565f, 0.01613603f, -0.04464810f, 0.03924863f, 0.02397685f, 0.03991785f, -0.03117060f, 
    -0.02221898f, -0.00929821f, -0.04204098f, 0.03942418f, -0.03736065f, -0.02295382f, -0.03472853f, 0.00357552f, 
    -0.05926796f, -0.03315721f, 0.02590409f, -0.06992344f, 0.01690783f, -0.05600099f, -0.04146891f, -0.04691600f, 
    -0.02526735f, -0.04949324f, -0.04120420f, -0.04840200f, -0.03125561f, -0.03952130f, -0.07104017f, -0.03778284f, 
    -0.04778890f, -0.05563189f, -0.05006815f, -0.01787755f, -0.01535318f, 0.01125801f, -0.00444989f, -0.01686266f, 
    0.05067140f, 0.01978642f, -0.05279430f, -0.04908549f, -0.01661400f, -0.01028724f, -0.02667854f, 0.00136063f, 
    -0.05038792f, -0.02831515f, 0.00035885f, -0.02165217f, -0.04031997f, -0.01427827f, -0.03862790f, 0.00313464f, 
    0.00597337f, -0.02285225f, -0.06162174f, 0.02189710f, 0.03741242f, -0.03593854f, -0.04856242f, -0.03846136f, 
    -0.02961824f, -0.02588473f, -0.03128849f, -0.02230611f, -0.03929771f, -0.03392151f, -0.00562058f, -0.03627408f, 
    0.02200436f, 0.03750528f, 0.03057008f, 0.00746008f, -0.00105558f, 0.01431780f, -0.03704168f, -0.04773735f, 
    -0.03242012f, 0.03617824f, -0.04165489f, -0.02449411f, 0.02435494f, -0.06015987f, 0.01813094f, -0.06875162f, 
    -0.06493676f, -0.06008474f, 0.00809668f, -0.06861921f, -0.01157716f, -0.01076334f, -0.06581716f, -0.06824987f, 
    -0.03996748f, 0.04966631f, -0.03642857f, -0.01073335f, -0.03816577f, -0.01241055f, -0.02483379f, 0.02131279f, 
    0.01564510f, -0.01045933f, -0.03966865f, -0.00368361f, -0.05967680f, -0.06039164f, -0.04823460f, 0.00131353f, 
    -0.06577750f, -0.06901789f, -0.06109841f, 0.00853236f, -0.06060504f, -0.06658290f, -0.01790873f, 0.01938248f, 
    -0.00637960f, -0.00157561f, -0.05188306f, -0.02843717f, -0.03543250f, -0.03406313f, -0.06290429f, -0.03586641f, 
    -0.03136245f, -0.00956912f, -0.03123339f, -0.01226915f, -0.04081178f, -0.04254007f, 0.01414859f, -0.03798892f, 
    0.02477492f, 0.01014578f, 0.02511441f, -0.04773403f, -0.02445752f, 0.03845091f, 0.00683938f, 0.00492569f, 
    0.01043261f, 0.00977301f, 0.03375386f, 0.03483769f, -0.00795645f, -0.03440811f, -0.00350104f, 0.03629256f, 
    -0.00440936f, -0.03682290f, -0.00335244f, 0.05021929f, -0.03633532f, 0.00042469f, 0.00584163f, -0.02560874f, 
    0.04547804f, -0.00573728f, -0.03139318f, -0.00804217f, -0.04880183f, 0.02380466f, 0.01796544f, 0.01178845f, 
    -0.03691807f, 0.03527597f, -0.02078427f, -0.03566488f, -0.02768056f, -0.01832602f, -0.02661809f, 0.00098552f, 
    0.04830390f, 0.04089316f, 0.02633945f, 0.01618266f, -0.04925892f, 0.01961955f, -0.03796013f, -0.02961894f, 
    -0.05839166f, -0.04909644f, 0.02598509f, -0.06241830f, -0.06608889f, -0.01639285f, 0.00124680f, -0.01915504f, 
    -0.02307413f, -0.04054974f, -0.02314427f, 0.05056201f, -0.03221520f, 0.03462987f, -0.04378694f, -0.02522177f, 
    0.02184647f, 0.01345990f, -0.01047649f, 0.00885970f, -0.02345143f, -0.04737070f, -0.04963927f, -0.04536830f, 
    -0.04962468f, 0.01911751f, -0.01073380f, 0.02576106f, -0.00070066f, -0.02153313f, -0.03356199f, 0.02298827f, 
    0.03775273f, -0.10269893f, -0.11221042f, -0.06399544f, 0.02179117f, -0.07952530f, 0.06404601f, 0.08524510f, 
    0.15384828f, 0.06145458f, -0.16329317f, 0.33152777f, 0.32734099f, 0.10313497f, -0.21316688f, 0.11556988f, 
    0.18108384f, 0.14251783f, 0.16205199f, 0.23960906f, 0.02015288f, 0.01241432f, -0.05767402f, -0.04490451f, 
    -0.22130649f, -0.23774964f, 0.34124014f, 0.58196616f, 0.00351070f, -0.12713854f, -0.10263228f, 0.05068710f, 
    0.14236628f, -0.13988830f, 0.01723011f, -0.02324123f, 0.01682852f, 0.26748770f, 0.13263710f, -0.13450915f, 
    -0.18660165f, -0.07646716f, 0.04546569f, -0.10609088f, 0.09423548f, -0.05733756f, 0.10931078f, -0.13995221f, 
    0.11056649f, 0.35288596f, 0.14630570f, 0.18822137f, 0.12011006f, 0.00147175f, -0.05923287f, 0.01426950f, 
    -0.04194096f, -0.08431236f, 0.10714208f, 0.03078819f, -0.56796944f, 0.23231792f, -0.07722221f, -0.19906788f, 
    -0.06789493f, -0.00711122f, -0.12556295f, -0.01244257f, 0.06170828f, -0.14864835f, 0.09437586f, 0.07835998f, 
    -0.21596976f, -0.08953430f, 0.09690846f, 0.10337260f, -0.10282741f, 0.02198883f, -0.01702549f, 0.03334419f, 
    -0.12637539f, 0.00009935f, 0.03823729f, 0.19726534f, -0.10718308f, 0.01965239f, -0.06928675f, -0.05951573f, 
    -0.02483175f, -0.21020299f, 0.10828567f, 0.07819577f, 0.09702294f, -0.01925417f, -0.09512674f, -0.17510313f, 
    -0.06359424f, 0.07947579f, 0.00988562f, 0.10105501f, 0.00581317f, -0.17157874f, 0.07205606f, 0.10084123f, 
    0.09940282f, 0.05770687f, -0.08556662f, -0.12342656f, 0.14108400f, 0.11701018f, 0.10962453f, -0.10283489f, 
    0.11250396f, -0.02792647f, -0.08845887f, 0.08148966f, 0.04433234f, -0.08339773f, -0.05811136f, -0.13970624f, 
    0.24310461f, 0.24908698f, -0.20638262f, -0.23699383f, 0.17135464f, 0.08858716f, -0.06708477f, 0.08370138f, 
    0.05557301f, -0.09969585f, -0.04715474f, 0.03766076f, 0.31898588f, -0.18727812f, -0.13275975f, 0.00915105f, 
    0.00323666f, 0.17135733f, -0.05811761f, 0.06650981f, 0.16171534f, -0.12985176f, 0.03615255f, -0.13666388f, 
    -0.23849589f, -0.09501573f, -0.07284173f, -0.14877123f, 0.06165638f, 0.08832950f, -0.07036673f, -0.06075060f, 
    0.34246862f, -0.15735209f, -0.06584138f, 0.02650321f, 0.03185186f, -0.15960817f, 0.38868538f, 0.07563908f, 
    -0.03767257f, 0.04651471f, -0.03369396f, -0.20292309f, 0.09061641f, -0.02797674f, 0.17241569f, 0.04813502f, 
    -0.03995581f, 0.13674597f, 0.12298226f, 0.15134959f, -0.04230451f, 0.09124696f, -0.09053905f, 0.03327018f, 
    -0.04361806f, -0.15497766f, -0.15381503f, -0.13253266f, 0.21895605f, -0.18625836f, -0.10529786f, 0.19329850f, 
    0.00329053f, -0.01472005f, -0.00300199f, 0.17582139f, -0.06431857f, -0.02856163f, -0.05757349f, -0.21574308f, 
    0.24367689f, -0.19918907f, 0.09437638f, 0.02311892f, -0.00160851f, 0.13128377f, -0.11476401f, -0.05455545f, 
    -0.01454060f, -0.22459549f, -0.01178614f, -0.15841383f, 0.20424205f, 0.14371651f, 0.02735532f, -0.04377664f, 
    0.02718093f, -0.29018822f, -0.06056260f, 0.27290130f, -0.01324177f, 0.07351162f, -0.12881181f, -0.00943497f, 
    -0.05563019f, -0.05918482f, 0.10668465f, -0.09575178f, 0.06292941f, 0.04757651f, 0.14954738f, 0.15491644f, 
    -0.02136372f, -0.02188858f, -0.00135156f, 0.16020328f, 0.18807420f, 0.11754350f, -0.01664399f, 0.15880811f, 
    0.17797902f, 0.01608128f, 0.21292244f, 0.08498398f, 0.06901366f, 0.04522672f, -0.15429032f, 0.07128230f, 
    -0.27397063f, 0.10714462f, 0.07805701f, -0.10805604f, -0.16748911f, -0.10282119f, 0.28235370f, 0.04603253f, 
    0.00380822f, -0.12608640f, 0.31516981f, 0.08764432f, 0.19179899f, -0.02276204f, 0.08105846f, -0.05816941f, 
    -0.07553644f, 0.28961825f, -0.04552379f, 0.17361094f, 0.00588214f, -0.25808901f, 0.00890424f, -0.06320229f, 
    0.22321881f, -0.11951171f, 0.22662222f, 0.12860991f, 0.04830133f, 0.14419356f, 0.22088240f, 0.16051008f, 
    0.05449472f, -0.10432625f, -0.11846688f, -0.04808547f, 0.21139801f, -0.06705713f, -0.15048225f, 0.09074304f, 
    0.01253289f, -0.14530303f, -0.08889465f, 0.08856186f, -0.00932197f, -0.02261992f, -0.06529527f, 0.01233660f, 
    -0.21422052f, 0.10954928f, -0.33493790f, -0.18996292f, 0.04252738f, 0.07597259f, 0.00448317f, 0.10628025f, 
    -0.03990949f, 0.04775706f, 0.00725153f, 0.03912292f, 0.05902513f, 0.07465620f, 0.34804043f, -0.07226365f, 
    -0.02419801f, -0.02870105f, 0.03749582f, 0.08536430f, -0.02692513f, -0.14954054f, 0.03048049f, -0.02106254f, 
    0.04288663f, -0.09407762f, 0.23305246f, -0.10507097f, 0.06579841f, -0.02891977f, -0.25503811f, 0.13028310f, 
    -0.13341059f, -0.02423250f, 0.09668496f, -0.08208977f, -0.40605342f, 0.04511608f, 0.18501748f, -0.15300007f, 
    0.07737155f, 0.01653254f, -0.11047179f, 0.01342395f, 0.09700629f, -0.10473058f, 0.02647978f, 0.10033404f, 
    -0.48386702f, 0.07407537f, -0.09753782f, -0.39931971f, 0.02146855f, -0.08476747f, -0.13420920f, 0.11958474f, 
    -0.03104189f, 0.03729758f, -0.13603574f, 0.10558565f, 0.02731927f, -0.08364097f, -0.28212360f, 0.07478909f, 
    0.10635664f, -0.05126414f, 0.11209472f, 0.17856282f, 0.30345020f, 0.18585493f, 0.01093701f, 0.17848738f, 
    0.10874715f, -0.43689162f, 0.02362215f, 0.17941703f, 0.05707371f, 0.03919230f, 0.04629271f, 0.00478245f, 
    0.11377905f, -0.05370886f, 0.27580443f, 0.24117698f, 0.14765579f, 0.25963253f, -0.13258746f, -0.37005043f, 
    -0.06860964f, 0.15408318f, 0.06313152f, 0.10438580f, 0.14843711f, -0.01671048f, 0.14296812f, 0.04936942f, 
    -0.03189892f, -0.02011559f, 0.09366436f, -0.03887665f, -0.04732610f, -0.03779464f, -0.07054355f, -0.07374982f, 
    -0.03067531f, -0.06522647f, 0.09903558f, -0.19132543f, -0.04468032f, -0.02979226f, -0.03951250f, -0.21927482f, 
    0.02090492f, 0.06437153f, -0.06836921f, 0.08646240f, 0.02799630f, -0.06082272f, -0.08569794f, -0.05575498f, 
    -0.18635079f, -0.14756081f, -0.30372375f, -0.22632335f, -0.08268245f, 0.00179270f, -0.07114526f, -0.04358383f, 
    0.12705971f, 0.08162059f, 0.00079766f, 0.18501909f, -0.07554569f, -0.02500313f, -0.05855776f, -0.03985093f, 
    0.00166009f, 0.00804564f, 0.09713268f, 0.20159695f, 0.05405213f, -0.09332746f, -0.06317142f, 0.08877204f, 
    -0.13766700f, -0.01647298f, -0.02049862f, -0.29235449f, 0.00426431f, -0.02473712f, -0.03159208f, 0.02793708f, 
    -0.02994058f, -0.04670540f, -0.00406789f, 0.02025946f, 0.13665615f, -0.45467794f, -0.08670134f, -0.08964436f, 
    -0.14739646f, 0.01143354f, -0.00382840f, 0.09521401f, 0.15190855f, 0.02371938f, 0.05091029f, 0.02968202f, 
    0.09523389f, 0.16131726f, 0.21958749f, -0.02375676f, 0.15148243f, -0.03605641f, 0.04210623f, -0.05784035f, 
    0.08495829f, 0.02550362f, 0.07007029f, -0.06751912f, 0.26361406f, -0.10516860f, 0.04186420f, 0.10034639f, 
    0.05045449f, 0.01270799f, -0.03853109f, -0.09337541f, 0.16283129f, 0.15800641f, 0.16584459f, 0.17590249f, 
    -0.08628786f, -0.07079107f, 0.01611565f, -0.02933438f, 0.19559902f, 0.16819215f, 0.07768957f, 0.06307001f, 
    -0.05109925f, 0.02156764f, 0.02157439f, 0.03419353f, -0.04747772f, -0.08433487f, 0.00239531f, 0.04388600f, 
    0.12378102f, 0.17449155f, 0.28974795f, 0.10426547f, -0.00058252f, -0.02396263f, -0.13065365f, 0.06716180f, 
    0.13848582f, -0.05583009f, 0.07985467f, -0.07014019f, 0.01418751f, -0.07376048f, 0.04470642f, -0.03180706f, 
    -0.17801838f, -0.00082312f, 0.02502661f, 0.06398193f, 0.03232086f, 0.05160047f, 0.07750871f, 0.04028162f, 
    -0.19864896f, -0.09995582f, 0.06127271f, -0.19699784f, -0.09955293f, -0.00804003f, -0.01105402f, 0.02652713f, 
    0.06011010f, -0.25099486f, -0.10243883f, -0.12547712f, -0.05822323f, -0.03564371f, -0.14446934f, -0.08712322f, 
    -0.03026325f, 0.27129748f, 0.08939650f, 0.06081244f, 0.19006822f, 0.06316108f, 0.04086946f, -0.16337582f, 
    -0.06785298f, 0.06017782f, 0.15193459f, 0.06604063f, 0.05802938f, -0.12035806f, -0.04116960f, -0.01020531f, 
    -0.18927084f, 0.04797652f, 0.09670071f, -0.15085721f, 0.04321805f, -0.03248907f, 0.10207142f, 0.07653302f, 
    0.13135597f, 0.09139738f, 0.18707816f, 0.19849671f, 0.00787973f, 0.33141339f, 0.26776317f, -0.03984553f, 
    0.15492088f, -0.10642032f, -0.10442862f, -0.21134365f, 0.07189693f, -0.03601892f, -0.06039745f, 0.13673413f, 
    -0.14103583f, 0.09123642f, -0.00579978f, -0.19516632f, 0.01549719f, -0.01378727f, 0.11188631f, 0.02496980f, 
    0.07139182f, 0.03793033f, 0.08625837f, 0.04698085f, 0.19133121f, -0.06686350f, 0.04247667f, 0.05400859f, 
    0.07183769f, 0.33814681f, 0.05939018f, 0.00610088f, 0.18923347f, -0.11907972f, 0.04482670f, -0.00419911f, 
    0.00665711f, -0.35717425f, -0.16631709f, -0.04800685f, -0.00896877f, -0.00374884f, -0.06583796f, 0.04600082f, 
    0.14473228f, -0.02124605f, 0.09374536f, -0.02111609f, 0.18341041f, -0.04625489f, 0.12962905f, -0.07362740f, 
    0.22999306f, 0.12123135f, -0.00587127f, 0.01752025f, -0.01838204f, 0.13213299f, 0.06702007f, -0.25602096f, 
    -0.19440114f, 0.12845440f, -0.03784292f, 0.00831070f, 0.03391593f, -0.01120332f, -0.16149485f, 0.09387016f, 
    0.01721561f, 0.01856921f, -0.18817347f, -0.24184422f, -0.08467921f, 0.02041923f, -0.15932195f, 0.07202718f, 
    -0.00527110f, 0.04549070f, 0.14647274f, -0.13925816f, 0.00317032f, 0.15184365f, -0.00181354f, 0.12277381f, 
    0.20875311f, -0.00692062f, -0.28940803f, -0.22850670f, -0.00549711f, -0.11137513f, -0.09312007f, -0.03105367f, 
    -0.15887389f, 0.04888547f, 0.01573255f, -0.01803813f, -0.08883673f, 0.20264193f, 0.15482920f, 0.19467391f, 
    -0.19734108f, 0.00762921f, -0.05839720f, -0.02836319f, 0.07812091f, 0.12940748f, 0.13183410f, 0.06988911f, 
    0.46098834f, -0.04474731f, 0.09105118f, -0.05852536f, -0.14685777f, -0.04249257f, 0.00305655f, -0.09805118f, 
    0.23370247f, 0.03543349f, -0.06927220f, 0.25438464f, 0.08749928f, 0.10863117f, -0.01600208f, 0.01511874f, 
    -0.07724897f, 0.07171082f, 0.08259670f, -0.10002965f, -0.06833576f, -0.08156934f, -0.20174785f, 0.08267335f, 
    0.31528214f, 0.12467551f, -0.01659244f, 0.03829798f, 0.15539259f, 0.17632179f, 0.17822874f, 0.05505370f, 
    0.06843582f, -0.02802109f, -0.09343579f, 0.07959510f, -0.01308781f, 0.13002132f, 0.07575803f, 0.06028846f, 
    -0.02063914f, -0.07786613f, 0.09298757f, 0.12810053f, 0.05295739f, 0.12263884f, -0.03276819f, 0.01529774f, 
    0.10866774f, 0.09766375f, 0.06582770f, -0.18615329f, -0.04048895f, 0.05596397f, 0.03373906f, -0.03011437f, 
    -0.07259859f, -0.05507478f, 0.04338571f, -0.00798436f, -0.15516698f, -0.08234980f, 0.08292996f, -0.03966174f, 
    -0.02675284f, 0.01360740f, -0.15278871f, -0.11888904f, -0.19908735f, -0.18069197f, -0.05058079f, -0.21764517f, 
    -0.09192078f, -0.05230752f, 0.05513288f, 0.08758064f, 0.15156731f, 0.03242480f, 0.06306389f, 0.01707641f, 
    -0.05492490f, -0.04776235f, -0.21459302f, -0.20005783f, 0.23387691f, -0.04834067f, 0.05900222f, 0.19060381f, 
    0.05372662f, 0.03587987f, 0.00414305f, 0.11860268f, -0.12421915f, -0.15712059f, -0.19377959f, -0.03154350f, 
    0.19691895f, -0.10010367f, 0.05330918f, -0.09247482f, -0.06849494f, -0.00700042f, 0.04585589f, -0.02161519f, 
    -0.02649293f, 0.04775898f, 0.08111689f, -0.28295490f, -0.22991140f, -0.30030614f, 0.20786345f, -0.12944011f, 
    -0.02378867f, -0.04046804f, -0.02419066f, 0.20366742f, 0.04525507f, 0.00242146f, 0.02762119f, 0.01859235f, 
    0.85061342f, -0.38574386f, 0.17256665f, -0.11114084f, 0.00743845f, -0.09780294f, -0.00485923f, -0.06830824f, 
    0.20365614f, 0.03464200f, 0.09594140f, -0.03047388f, -0.08195455f, 0.04642756f, -0.06286111f, -0.00435320f, 
    -0.00234581f, 0.01053506f, -0.02180801f, 0.14943177f, -0.02343219f, -0.01192756f, 0.07812122f, -0.00826676f, 
    -0.00093221f, -0.13894676f, 0.08450515f, -0.16892932f, 0.05708385f, -0.02931682f, -0.05594005f, 0.00212323f, 
    -0.05753127f, -0.01060004f, -0.03304962f, 0.07723733f, -0.10193269f, 0.04119577f, -0.09489066f, -0.13226581f, 
    -0.08444753f, -0.01591852f, -0.00824302f, 0.12998137f, 0.07110998f, 0.02860294f, -0.06357023f, 0.12757543f, 
    0.32896322f, 0.12540096f, -0.09685908f, -0.02356431f, 0.14599724f, -0.11799245f, -0.14178103f, -0.02400680f, 
    -0.08854535f, -0.08662266f, -0.00255483f, 0.03340733f, 0.31303158f, -0.04726114f, -0.49327469f, 0.38265434f, 
    -0.06459702f, 0.03457675f, -0.03746165f, 0.02043077f, 0.01421330f, 0.05333877f, -0.13379773f, 0.01357822f, 
    -0.08146822f, -0.05478982f, 0.13315079f, -0.06190128f, 0.02487918f, 0.06395791f, -0.19734298f, 0.14529032f, 
    -0.07039168f, 0.04227215f, 0.06561831f, 0.02887540f, -0.09500493f, 0.01483980f, -0.14782040f, -0.11394526f, 
    0.33216104f, 0.17680795f, 0.16610950f, 0.01828018f, -0.01000018f, 0.11428861f, -0.09535412f, -0.05858910f, 
    -0.10635495f, 0.19302942f, -0.07921340f, -0.32939759f, 0.01941361f, 0.06739073f, -0.00049428f, 0.04208367f, 
    0.24604554f, -0.01280981f, -0.05401709f, -0.05234284f, 0.18410531f, 0.11247492f, 0.05636297f, 0.32202631f, 
    0.07401185f, -0.09305359f, 0.01822976f, -0.12116004f, -0.06749906f, -0.02137724f, 0.01254417f, -0.07071494f, 
    -0.19949952f, -0.14727010f, -0.12238984f, 0.19035912f, 0.08109410f, 0.05067757f, 0.07757764f, -0.12565799f, 
    -0.00901275f, 0.01655009f, -0.04725233f, 0.07359051f, 0.01338473f, 0.09638596f, -0.12269216f, -0.05660307f, 
    0.10712499f, 0.02194741f, 0.13944031f, 0.00349767f, 0.01557876f, -0.21694604f, -0.03075688f, -0.02731015f, 
    0.09221865f, -0.10005321f, 0.08464657f, -0.27994975f, 0.06559781f, 0.24580745f, -0.15568842f, 0.06074747f, 
    0.09025746f, 0.09035961f, 0.13686413f, 0.03614769f, 0.14158246f, -0.02064574f, 0.22077544f, 0.25553730f, 
    0.17508653f, -0.04228233f, -0.09736497f, -0.10851873f, 0.06405971f, -0.04521441f, -0.08938544f, 0.16012554f, 
    -0.01019703f, -0.04528705f, 0.09167407f, -0.08772590f, 0.07126882f, -0.08845988f, -0.02739660f, -0.03616398f, 
    -0.01009014f, -0.01350686f, -0.06016989f, 0.06476077f, 0.17144930f, -0.21350056f, -0.28330269f, 0.13918528f, 
    0.06087288f, 0.02267700f, 0.30735919f, -0.15326391f, -0.00266724f, 0.01264822f, 0.07024597f, -0.08418215f, 
    0.24640733f, -0.32563880f, 0.03996255f, -0.00163519f, -0.03337771f, -0.05414566f, 0.06884027f, -0.10281694f, 
    0.05148337f, -0.03965314f, 0.20213713f, 0.05892237f, 0.31321210f, -0.19276433f, -0.10351924f, 0.10801250f, 
    0.05548022f, 0.07827681f, -0.15331011f, -0.05986795f, 0.17726305f, 0.22095160f, 0.02665183f, -0.35629648f, 
    0.16308492f, 0.15294588f, 0.06410143f, 0.03385968f, 0.07080062f, 0.18773681f, 0.10678221f, 0.14150017f, 
    -0.02406444f, -0.10046717f, -0.09392041f, 0.03216598f, -0.09698364f, 0.11852253f, -0.14897648f, 0.06197230f, 
    0.03657971f, -0.06156998f, 0.00440937f, -0.16226533f, 0.04003091f, 0.09899298f, 0.03648667f, 0.04689091f, 
    0.28017303f, 0.26126471f, -0.16016994f, -0.07993095f, -0.11696635f, -0.10215048f, 0.09843137f, -0.18360151f, 
    -0.01741308f, 0.08753596f, -0.02405870f, -0.05654621f, 0.19097254f, 0.06839943f, 0.31504941f, 0.21265984f, 
    -0.03318508f, -0.01837903f, -0.09428572f, 0.00810403f, 0.11484210f, -0.04272365f, -0.03657228f, 0.02516520f, 
    -0.09198353f, 0.26114729f, 0.07044618f, -0.25703859f, -0.14379476f, 0.11138214f, -0.04698302f, -0.09966464f, 
    0.23269196f, -0.20210470f, 0.01044768f, 0.24978121f, 0.05664416f, 0.06102462f, -0.11122490f, -0.06914699f, 
    0.10092784f, -0.09550826f, 0.08851656f, -0.15476327f, -0.13432610f, -0.14336985f, -0.17080694f, 0.09199546f, 
    0.30575982f, 0.19407299f, 0.09922291f, -0.01981400f, 0.10853011f, -0.00421813f, 0.10523420f, -0.06587631f, 
    -0.03045521f, -0.06654174f, -0.00002830f, -0.00341041f, 0.16637726f, 0.28750357f, -0.09346902f, -0.10593736f, 
    0.09165122f, -0.02640629f, 0.20780829f, 0.01279961f, -0.11410860f, -0.02784893f, 0.11970371f, -0.02678550f, 
    0.08900969f, 0.00377825f, -0.11175992f, 0.02857030f, 0.03227394f, 0.09498281f, 0.07836326f, -0.01133588f, 
    -0.04707301f, -0.03267132f, 0.05801535f, 0.12461225f, 0.09529383f, -0.05044727f, 0.11899305f, 0.10982718f, 
    -0.07169237f, -0.00329674f, -0.08845333f, -0.10953699f, -0.10427142f, 0.07262436f, 0.10137780f, -0.04720010f, 
    0.01045956f, -0.16625759f, -0.12305462f, 0.05878824f, 0.03074718f, -0.09110363f, 0.07065103f, 0.01293649f, 
    0.08531658f, -0.09934192f, 0.02028630f, -0.12392180f, 0.12151272f, -0.07276268f, -0.02801193f, 0.04742431f, 
    -0.03907032f, 0.06181383f, 0.11287912f, 0.04789521f, -0.04340381f, 0.07534771f, 0.03884136f, -0.17707996f, 
    0.02862629f, 0.06084083f, -0.01172691f, 0.03976009f, -0.08217736f, 0.00360337f, 0.04190683f, 0.02181115f, 
    0.13820875f, 0.10104499f, -0.03933985f, 0.02422381f, 0.52164549f, 0.28182733f, -0.19013250f, -0.00945079f, 
    0.08519395f, -0.02224639f, 0.12321059f, -0.11668491f, -0.12807791f, -0.06824628f, 0.00168203f, 0.03146724f, 
    -0.11801378f, -0.02050920f, 0.47945216f, 0.18595587f, 0.03343573f, -0.07806437f, -0.03879325f, -0.08681244f, 
    0.02302865f, 0.04871293f, 0.12394907f, 0.01683976f, -0.21202208f, -0.23790160f, 0.41043547f, -0.34587646f, 
    -0.11429279f, -0.07571743f, -0.07327565f, 0.14907844f, -0.01180201f, 0.22220598f, 0.00251853f, 0.08298631f, 
    0.49399772f, 0.32661346f, 0.12584962f, -0.07885826f, -0.28845844f, -0.33301932f, 0.09254799f, 0.02348608f, 
    -0.15459923f, -0.05693984f, 0.04371557f, -0.13614650f, 0.11808324f, -0.00823290f, -0.10711884f, 0.13540566f, 
    -0.02477871f, -0.01103932f, -0.24796207f, -0.07459828f, -0.08681765f, 0.02631629f, 0.06550875f, 0.15189509f, 
    0.03834806f, -0.08801926f, -0.32472703f, 0.22642545f, 0.03932659f, -0.17942135f, -0.12097155f, 0.14994773f, 
    -0.02887559f, -0.04561252f, 0.07054763f, 0.15627821f, 0.14106277f, 0.45855486f, -0.00120512f, -0.27539334f, 
    -0.02895406f, 0.04598483f, 0.11197711f, 0.00574748f, 0.06610067f, -0.06588297f, 0.02792299f, 0.00393033f, 
    0.06476096f, 0.07908799f, -0.06036266f, -0.03713884f, 0.12197321f, 0.23801109f, 0.11712439f, -0.08791275f, 
    -0.08417226f, -0.13546558f, -0.10105864f, -0.14569995f, 0.06691539f, 0.00737146f, -0.06825071f, -0.39356190f, 
    -0.09681666f, -0.10250830f, -0.14519984f, 0.15503775f, -0.08792479f, -0.11565042f, 0.01410009f, -0.04498138f, 
    0.15019745f, -0.10982420f, 0.27907977f, -0.00073569f, -0.07560330f, -0.01213259f, -0.01659776f, -0.03595132f, 
    -0.08320680f, 0.01929160f, 0.07114656f, 0.16056773f, 0.29974952f, 0.14812669f, 0.15476437f, -0.02022650f, 
    0.13666688f, -0.16167040f, -0.10175903f, 0.09964715f, -0.01403971f, 0.08048052f, 0.01897456f, 0.06510051f, 
    0.06587096f, 0.05176809f, 0.12530720f, -0.05874903f, 0.09829579f, -0.00171561f, -0.09434288f, 0.00591127f, 
    0.00150351f, 0.06251717f, -0.06494430f, -0.08219255f, 0.01787742f, 0.02541487f, 0.17774084f, -0.14265427f, 
    0.14902554f, -0.06036323f, -0.07215175f, 0.10776502f, 0.10420320f, 0.11589687f, 0.04389979f, -0.00257537f, 
    0.16580960f, -0.10422878f, -0.23617789f, -0.00013077f, -0.23619790f, 0.00905176f, -0.10246313f, 0.12544549f, 
    0.09386239f, 0.01811641f, 0.04290730f, -0.08638769f, 0.39693660f, 0.22393554f, -0.15484835f, 0.26544595f, 
    0.03350361f, 0.06495885f, 0.02406935f, -0.01550016f, -0.09922484f, -0.00788096f, 0.03568356f, -0.08189958f, 
    0.17534874f, 0.09974242f, 0.07397337f, -0.00687459f, 0.01902561f, -0.10056628f, -0.15119815f, 0.09623605f, 
    0.08428688f, -0.00620848f, -0.05815946f, -0.13582554f, -0.11488893f, -0.28550476f, -0.03541831f, -0.11899766f, 
    0.06512260f, -0.13578305f, -0.09765282f, 0.04215259f, -0.02244263f, -0.08750943f, -0.04884407f, -0.05775833f, 
    0.37643525f, -0.37211263f, 0.15578473f, -0.55639726f, 0.10900465f, -0.19395968f, 0.10959277f, -0.25117236f, 
    -0.02432941f, 0.01044914f, 0.14708810f, 0.01164426f, 0.12718010f, 0.05407568f, 0.07155558f, -0.28274783f, 
    0.07458079f, 0.15211752f, 0.13957390f, 0.16337407f, 0.01048250f, 0.04254497f, 0.09279716f, 0.05888735f, 
    0.06158838f, -0.04248283f, 0.24011834f, -0.13853766f, -0.20993103f, -0.18140495f, -0.05759562f, -0.10341321f, 
    0.08890613f, -0.06013246f, 0.15625991f, 0.06815842f, 0.05625052f, 0.04928095f, -0.08669712f, -0.00317650f, 
    0.10325202f, 0.01677255f, -0.22784403f, -0.17489545f, -0.22754431f, -0.03383151f, -0.19334458f, -0.05563767f, 
    0.28872600f, -0.21570824f, 0.17933585f, -0.14266978f, 0.04095158f, 0.09012815f, -0.14981830f, 0.13669303f, 
    -0.04735932f, -0.00281125f, 0.03743972f, 0.05781794f, 0.35799634f, 0.20177321f, 0.19223072f, 0.04812846f, 
    -0.04610764f, 0.01839990f, 0.05813887f, -0.11369937f, 0.06001249f, 0.01757284f, -0.14121284f, -0.08276453f, 
    0.48044881f, -0.15255073f, 0.16627567f, 0.14226548f, -0.04298713f, 0.00743031f, 0.11067036f, 0.02869504f, 
    0.15721282f, 0.21056646f, -0.09430691f, -0.21946564f, 0.08258871f, -0.13338017f, 0.17513494f, -0.29282415f, 
    0.05676518f, -0.29453501f, 0.09909000f, 0.22398855f, 0.00307053f, 0.01624195f, -0.09550218f, -0.11019582f, 
    0.08601250f, -0.27132642f, -0.14023928f, -0.37445009f, -0.02410900f, -0.08243077f, 0.17985933f, 0.19125360f, 
    -0.20152614f, -0.02112141f, -0.07645893f, 0.03354232f, -0.12949090f, -0.06335997f, -0.06022307f, 0.19301872f, 
    -0.00045025f, 0.15662937f, 0.02359905f, 0.10296681f, 0.02855388f, 0.00069146f, 0.13997374f, 0.18887664f, 
    0.36602607f, -0.39797285f, -0.37948093f, -0.70738631f, -0.15072712f, -0.01772336f, 0.04142753f, 0.18422027f, 
    -0.00005108f, -0.02248062f, 0.01120584f, 0.15570226f, 0.00049227f, 0.04029360f, -0.07530078f, 0.06992435f, 
    -0.09749051f, 0.07193426f, 0.13746129f, 0.08018757f, 0.35773683f, 0.07813545f, 0.10440322f, 0.11929914f, 
    -0.12284339f, -0.04357163f, 0.01851674f, 0.07268945f, 0.10738585f, 0.02575763f, 0.04525683f, 0.04871922f, 
    0.07411475f, 0.09689002f, 0.03236280f, 0.01362115f, -0.03080042f, 0.00262914f, 0.10742640f, -0.00649098f, 
    0.05412699f, -0.15237147f, 0.24032067f, 0.19578826f, 0.03040202f, 0.03594393f, -0.01164351f, 0.14149253f, 
    0.07221440f, 0.05943708f, -0.18497834f, 0.03546175f, -0.11656683f, -0.04502938f, 0.03359624f, 0.04316394f, 
    0.24864811f, 0.13553977f, 0.02388825f, 0.14273895f, 0.27003145f, -0.02059302f, -0.09457336f, 0.12075081f, 
    0.12586623f, -0.01777056f, 0.09713071f, 0.12622225f, -0.10224919f, -0.06097833f, -0.01964626f, 0.04791705f, 
    -0.06638558f, -0.36873502f, 0.36532107f, 0.30558291f, 0.00771760f, -0.15351512f, -0.03581945f, -0.00413150f, 
    0.19164492f, 0.05067724f, 0.18723500f, 0.00262511f, -0.23384315f, -0.00934488f, 0.13009429f, -0.05158750f, 
    -0.13617828f, -0.14840291f, 0.09214279f, 0.00589771f, -0.02933120f, 0.29726821f, 0.07665752f, -0.16871752f, 
    0.18940488f, 0.05339569f, 0.24495021f, 0.15978436f, -0.08632824f, -0.19276252f, -0.02315483f, -0.01486245f, 
    0.02011819f, -0.09522138f, -0.08946970f, -0.02797103f, -0.65768540f, 0.28718457f, -0.21643727f, 0.00636411f, 
    -0.02000039f, -0.09345683f, -0.10542086f, -0.04308482f, 0.06266794f, -0.02741878f, 0.13030854f, 0.15544716f, 
    0.10238601f, -0.06374948f, -0.07853717f, 0.25688007f, 0.10920393f, -0.01665282f, -0.05413922f, 0.04407923f, 
    0.05507731f, 0.00260729f, 0.07535212f, 0.15238987f, 0.06877030f, 0.19718289f, -0.07830645f, -0.12426661f, 
    0.05466247f, -0.07345343f, 0.06766838f, -0.11168773f, 0.05364770f, 0.06487595f, -0.18415342f, -0.17776401f, 
    0.03652703f, 0.05500573f, 0.00299056f, -0.02191883f, 0.05674273f, 0.12990378f, 0.02325098f, 0.15521431f, 
    -0.02192454f, -0.08070060f, -0.03821079f, -0.05505774f, 0.08283629f, 0.02675131f, 0.02956768f, -0.21083343f, 
    0.13294469f, 0.04866149f, -0.16704212f, 0.11002155f, -0.01788855f, -0.05371304f, -0.12819622f, -0.25763014f, 
    0.01179681f, 0.13885517f, -0.06140978f, -0.27301651f, 0.00619869f, 0.05454651f, -0.26218092f, 0.01895325f, 
    0.07706453f, -0.05541751f, 0.14888269f, -0.03241611f, 0.42230389f, 0.06571724f, 0.08640197f, 0.01874368f, 
    0.02378093f, -0.02401597f, -0.10002960f, 0.22370246f, -0.07235122f, -0.09525056f, -0.07640246f, -0.15034775f, 
    -0.28777978f, -0.09537692f, -0.10572073f, 0.08393054f, 0.09980999f, 0.11047844f, -0.13356031f, 0.03732983f, 
    -0.02350924f, -0.07062759f, -0.09553459f, -0.01843536f, -0.19717011f, -0.16224068f, 0.05492204f, 0.15631253f, 
    0.12146974f, -0.02556321f, -0.02466443f, -0.19681354f, 0.23802677f, 0.04120381f, 0.05071928f, -0.04516278f, 
    -0.00164344f, 0.03471640f, -0.05208588f, 0.05342017f, -0.01053021f, 0.00333316f, -0.01929557f, 0.08842795f, 
    0.08761380f, 0.02688778f, 0.07728272f, -0.14957042f, 0.50874674f, 0.09750782f, -0.05896919f, 0.20982781f, 
    -0.03251141f, 0.03867148f, 0.03873078f, 0.08018654f, -0.08474293f, 0.05543886f, -0.08227839f, -0.12308611f, 
    0.10383932f, -0.17394432f, -0.00978730f, -0.06557906f, 0.09122747f, -0.16870803f, -0.01192470f, 0.00075318f, 
    0.05312989f, -0.07788450f, -0.18887182f, -0.22185180f, 0.00541590f, -0.30199051f, 0.13913032f, 0.18515289f, 
    0.05770090f, -0.32538357f, 0.16862933f, 0.10543884f, -0.13928914f, -0.08268670f, -0.08692391f, -0.15803593f, 
    0.25011274f, -0.27869391f, 0.12479902f, -0.12991329f, 0.11625975f, 0.01628691f, 0.15301430f, -0.16902517f, 
    -0.02832715f, 0.06716902f, 0.28175700f, 0.23266163f, 0.16221339f, 0.04609573f, 0.06229223f, 0.10679321f, 
    0.17030944f, 0.17445444f, 0.05378378f, 0.06176870f, 0.23076287f, 0.16039135f, -0.00891470f, -0.02556063f, 
    0.15909864f, 0.06332397f, 0.01411536f, -0.09234219f, -0.08605914f, 0.02661330f, 0.25662771f, 0.04429805f, 
    0.05642134f, -0.04777983f, 0.29516429f, 0.12536563f, 0.09968166f, 0.07072284f, -0.05385325f, -0.15296823f, 
    0.07855932f, 0.05516946f, -0.14552833f, 0.01994728f, -0.10073696f, -0.04293666f, -0.03704607f, -0.07246955f, 
    0.16975673f, 0.22610950f, 0.20277382f, 0.05160710f, 0.01326301f, 0.11147935f, -0.04226552f, 0.02866695f, 
    0.07482743f, -0.10070316f, 0.00788940f, -0.06148937f, 0.19915691f, 0.11581614f, -0.03771241f, -0.05095757f, 
    0.06773420f, -0.06412206f, 0.01301776f, 0.06280687f, 0.06981867f, -0.01933873f, -0.18662047f, -0.00346708f, 
    -0.08586578f, 0.01511737f, 0.14524192f, -0.10750455f, -0.02780860f, 0.06260861f, 0.14976101f, -0.01304737f, 
    0.06192594f, -0.09826628f, 0.05874651f, -0.07498844f, -0.06241705f, -0.12863572f, 0.09640757f, -0.12402270f, 
    0.01977088f, -0.16462012f, -0.02670453f, 0.00849307f, 0.02865846f, -0.01367703f, -0.02560929f, 0.01555821f, 
    0.21976626f, 0.03883650f, 0.25524363f, -0.23513402f, 0.03701752f, -0.09012868f, -0.11267158f, 0.02368771f, 
    -0.16117942f, 0.03503963f, 0.13969776f, -0.11121963f, -0.22970256f, 0.13947524f, 0.19865032f, -0.08715922f, 
    0.05630938f, 0.03384517f, -0.01063646f, -0.00214751f, 0.16920184f, -0.05964171f, 0.21580623f, 0.03867569f, 
    -0.05921268f, -0.01176394f, -0.29462638f, -0.26272690f, 0.04021728f, -0.08496443f, 0.02418317f, 0.14452910f, 
    -0.01843179f, 0.01603615f, 0.08032230f, 0.17617168f, 0.13511036f, -0.02666048f, -0.23736256f, -0.03473722f, 
    -0.05962837f, -0.07150568f, 0.16180260f, 0.12773338f, 0.21387120f, 0.18328303f, -0.00640341f, 0.06508522f, 
    0.17143232f, -0.10666373f, -0.07679141f, -0.08230902f, 0.09101476f, 0.02173297f, 0.13815850f, -0.09383689f, 
    0.17174190f, 0.14784776f, 0.24288240f, 0.00451458f, 0.26871791f, -0.01837181f, 0.14631605f, -0.34201264f, 
    -0.01304276f, 0.01932263f, 0.02554447f, 0.11413475f, 0.14177278f, 0.05596041f, 0.24302164f, 0.04661448f, 
    -0.32910985f, 0.01207380f, -0.12906781f, 0.04410637f, -0.07314935f, -0.05431078f, -0.13299178f, -0.15662687f, 
    0.01643253f, 0.04752057f, -0.00141559f, -0.12869401f, -0.34478387f, 0.24255873f, 0.39779940f, 0.21855831f, 
    0.07207017f, 0.03733005f, -0.13752267f, 0.09803657f, -0.08225210f, 0.11851136f, 0.03853584f, -0.03036599f, 
    -0.01780570f, -0.14273594f, -0.32250324f, -0.20709717f, 0.08201182f, 0.03824387f, 0.01347487f, -0.19085398f, 
    -0.04112037f, 0.08550744f, 0.06575903f, -0.00707136f, -0.09458994f, -0.24496450f, -0.15576978f, 0.25604475f, 
    0.09269741f, 0.00416974f, -0.01529150f, 0.04272842f, -0.08730526f, 0.10626204f, 0.19672221f, -0.03908363f, 
    0.15528734f, -0.17729734f, 0.29532757f, 0.20431907f, -0.22152245f, -0.04111199f, 0.01935339f, -0.03159569f, 
    0.02573382f, -0.08238761f, -0.14573283f, -0.10740852f, -0.19120127f, 0.15409417f, -0.15911059f, 0.25865138f, 
    0.07495245f, 0.03387445f, 0.08495478f, 0.03118078f, 0.02673718f, 0.05737571f, 0.08106817f, 0.03623017f, 
    0.23684989f, 0.18888076f, -0.10574256f, 0.28087032f, -0.00590206f, 0.04499183f, 0.02376041f, 0.02018000f, 
    0.05037961f, -0.06971783f, 0.04727891f, 0.01051952f, -0.29080597f, 0.10300684f, 0.41615251f, -0.04281161f, 
    0.15663813f, 0.23235548f, -0.15373793f, -0.14751446f, -0.11367875f, 0.04818105f, 0.15426195f, 0.15680782f, 
    -0.05409611f, 0.10627571f, 0.00431629f, -0.07079767f, 0.16396719f, 0.13984229f, 0.17102411f, 0.11269691f, 
    -0.04920559f, -0.00828659f, 0.09746476f, 0.13604991f, 0.05831775f, 0.02807750f, 0.11515229f, 0.05137316f, 
    0.00226728f, 0.02197382f, -0.01147893f, -0.04970297f, 0.05678993f, -0.01970500f, 0.01683942f, -0.12962832f, 
    -0.31941336f, 0.14368224f, 0.10622782f, 0.31428373f, -0.27068967f, 0.08050997f, -0.12139431f, -0.05193036f, 
    -0.05232577f, 0.07812092f, -0.15273631f, 0.12305114f, 0.18889476f, 0.12101746f, -0.02438643f, -0.14526892f, 
    -0.08703662f, 0.06868102f, -0.17268556f, 0.06804685f, -0.03251847f, -0.04389023f, -0.00491824f, 0.02563033f, 
    -0.19395174f, -0.03197761f, -0.05794017f, 0.00996280f, -0.02680186f, 0.16173823f, 0.06944881f, 0.05139886f, 
    -0.11149757f, 0.16215593f, 0.11478239f, 0.12146367f, -0.12960462f, 0.15810120f, -0.02758857f, 0.12176667f, 
    0.10550090f, 0.00232244f, 0.02144672f, 0.13620757f, 0.02293819f, -0.05731707f, -0.16115047f, -0.03702273f, 
    0.12053263f, 0.24479420f, -0.01714866f, 0.30085477f, 0.09186709f, 0.05316118f, 0.21119538f, 0.13918786f, 
    0.09186338f, 0.03926619f, -0.02394825f, 0.01093388f, 0.11885228f, 0.15918779f, 0.23797078f, 0.12707543f, 
    0.04046457f, -0.05280717f, -0.13383494f, -0.04724144f, -0.04718164f, 0.00187238f, 0.04110477f, -0.00284731f, 
    -0.00619349f, 0.07429118f, -0.13152313f, 0.05348148f, 0.06399032f, -0.08943779f, 0.03503169f, 0.02050811f, 
    0.03729248f, 0.11088823f, 0.06557087f, 0.14588188f, -0.15541600f, -0.15542975f, 0.31403521f, 0.23505847f, 
    0.09127875f, 0.04045402f, 0.28692490f, 0.08875407f, -0.09401073f, -0.08667848f, -0.11131475f, -0.04021428f, 
    -0.06490123f, 0.00464986f, -0.01037224f, -0.01195216f, 0.09281680f, 0.00646785f, -0.10146115f, -0.09422594f, 
    -0.14697297f, -0.02875262f, 0.17746930f, 0.04326223f, -0.05391468f, 0.12700903f, 0.31949773f, -0.02422884f, 
    0.01517118f, -0.03299977f, -0.03441688f, 0.04591461f, -0.02531230f, 0.00223394f, -0.16609591f, -0.02437253f, 
    0.54289961f, -0.00540056f, 0.12695035f, 0.13126186f, 0.13978231f, -0.11119916f, -0.05011060f, -0.04652408f, 
    -0.09297638f, -0.01975803f, -0.09132517f, 0.00374284f, 0.18898545f, 0.03519672f, 0.02841045f, 0.03485040f, 
    0.18857709f, -0.03425414f, -0.02851771f, -0.02949929f, 0.07168715f, 0.08378991f, 0.09211768f, 0.05000026f, 
    -0.01241162f, 0.52469939f, 0.09186901f, 0.18118085f, -0.10045375f, -0.05105819f, -0.08431075f, -0.01775764f, 
    -0.09819316f, -0.09869485f, -0.04152693f, -0.07194588f, -0.07070208f, 0.17449065f, -0.02787591f, -0.13274939f, 
    -0.00026806f, 0.05754070f, 0.01154072f, -0.05254205f, -0.04936290f, 0.11558740f, 0.05710658f, 0.16215833f, 
    -0.44752744f, -0.10303997f, 0.17471805f, 0.27684429f, 0.04213390f, -0.07835405f, -0.03282223f, -0.02874271f, 
    -0.02789724f, 0.01548994f, 0.07865809f, -0.05549949f, -0.09820791f, -0.11833771f, -0.12806323f, 0.31608334f, 
    0.20133908f, 0.05350965f, -0.10789178f, 0.05028448f, -0.01237837f, 0.01521267f, -0.05224754f, -0.06990894f, 
    0.06301083f, 0.18649665f, 0.10070282f, 0.09191430f, 0.00693147f, -0.02265984f, 0.05498154f, 0.04738098f, 
    -0.02533313f, 0.03839763f, 0.09003294f, -0.00481752f, 0.32802969f, 0.13143447f, -0.04772743f, 0.21181422f, 
    -0.00982017f, 0.08122463f, 0.09026053f, 0.09057353f, 0.02274851f, -0.10291278f, 0.03937310f, 0.02895980f, 
    0.53143919f, 0.13930786f, 0.20640434f, 0.32803658f, 0.03634271f, 0.06837557f, 0.08373237f, 0.12047400f, 
    -0.04717276f, -0.00961077f, 0.12300924f, -0.07302243f, -0.04385715f, -0.03233269f, -0.03756363f, -0.24750164f, 
    -0.06487890f, -0.03661750f, -0.13692872f, 0.00130768f, -0.06451136f, 0.01289589f, -0.11925644f, -0.09766643f, 
    0.05762056f, 0.31905589f, 0.19535057f, -0.24781799f, -0.01099585f, 0.05206830f, -0.04843424f, -0.17555395f, 
    -0.04363589f, 0.00846790f, 0.07572168f, -0.06685449f, 0.03105740f, -0.15498039f, 0.32652062f, 0.15512118f, 
    -0.01980773f, 0.05063841f, -0.10657775f, -0.05138085f, -0.07184538f, 0.04718237f, -0.07663932f, -0.10515501f, 
    -0.18735030f, 0.08956829f, -0.05533871f, -0.04181683f, 0.05370907f, -0.05446769f, -0.05500414f, -0.05291329f, 
    0.06630147f, -0.16532956f, -0.08953841f, 0.23002172f, 0.23392215f, 0.17593418f, -0.11135968f, 0.05547594f, 
    0.24289386f, 0.25305220f, 0.03760008f, 0.21123073f, -0.05763006f, 0.07233087f, 0.00088602f, -0.13947196f, 
    -0.78445560f, 0.01272771f, -0.23952332f, 0.41489023f, -0.10969269f, -0.10622734f, -0.00824261f, 0.12352628f, 
    0.03651000f, -0.16873340f, -0.00447136f, 0.13559459f, 0.14155455f, 0.25493500f, 0.13701621f, 0.08870079f, 
    -0.15950753f, -0.06681570f, 0.16633807f, 0.06335227f, 0.08852991f, -0.06585431f, 0.09957817f, -0.14212708f, 
    -0.15429249f, 0.19479759f, 0.01525097f, -0.00892698f, 0.01110719f, -0.11336102f, 0.02216337f, 0.07414579f, 
    -0.08906306f, -0.06289851f, -0.05828178f, -0.02628244f, -0.25566220f, 0.02719228f, 0.32171404f, 0.09648467f, 
    -0.07565860f, -0.05302108f, -0.10707385f, -0.04801090f, 0.14024341f, -0.03214970f, 0.19906004f, 0.00891589f, 
    -0.42593923f, 0.17538734f, 0.18272784f, 0.14383352f, -0.11098547f, 0.17540519f, 0.08095028f, -0.09761115f, 
    0.07504901f, 0.09966235f, 0.00023903f, 0.12330697f, -0.25970003f, -0.01119546f, 0.52622396f, -0.13243714f, 
    0.08655622f, -0.02275936f, 0.08479150f, -0.06021542f, -0.10053917f, 0.12937900f, 0.31235382f, 0.15961681f, 
    0.01373542f, 0.17390954f, -0.00167235f, 0.15228699f, 0.24284385f, 0.07457565f, 0.31332606f, 0.10037540f, 
    -0.05895627f, 0.09816817f, -0.00831841f, -0.02134421f, 0.11150548f, 0.04314511f, 0.43512467f, 0.25388610f, 
    -0.14555061f, -0.05661155f, 0.01346316f, 0.13293138f, -0.00025109f, -0.02123917f, -0.01926443f, -0.03863041f, 
    0.32288399f, 0.14074010f, 0.07073697f, 0.16906662f, -0.02081935f, -0.00652928f, 0.07175393f, -0.03728215f, 
    -0.19443038f, -0.06296124f, -0.09961929f, 0.25519416f, 0.18603763f, 0.02421764f, -0.00233273f, -0.13938618f, 
    -0.31083247f, 0.22930709f, 0.06408868f, 0.06432450f, 0.06210086f, -0.02235925f, 0.09673601f, 0.05845518f, 
    -0.04286336f, 0.00168585f, 0.16840613f, -0.09129564f, -0.08862974f, 0.12767372f, -0.11581928f, -0.01396804f, 
    0.08356369f, 0.09552988f, 0.04340432f, 0.06439445f, -0.03757668f, -0.09232540f, 0.24519055f, 0.00992155f, 
    -0.19758764f, 0.03519579f, -0.19207785f, -0.03973223f, 0.11000538f, 0.09404483f, 0.05599400f, -0.04224840f, 
    -0.15945812f, 0.27591920f, 0.08632069f, 0.35223126f, -0.04592225f, -0.13067774f, 0.24795565f, 0.13110365f, 
    0.02766439f, 0.01209011f, -0.03534042f, 0.15189742f, 0.13287628f, 0.13706817f, 0.08857174f, 0.08100565f, 
    0.06617703f, -0.06247249f, 0.00853993f, 0.12396255f, 0.01257200f, -0.10287753f, 0.21109718f, -0.02563052f, 
    0.07310186f, 0.03435521f, -0.05389722f, -0.16905907f, -0.06516272f, 0.00271619f, -0.02796110f, 0.08539936f, 
    -0.04832398f, -0.19168784f, 0.04177264f, -0.18333262f, -0.05332661f, 0.33797094f, 0.31202248f, 0.05286333f, 
    0.00476813f, 0.10670904f, -0.20096873f, 0.44560376f, 0.11756285f, -0.02470528f, -0.12591930f, -0.12401303f, 
    -0.23481525f, 0.21919452f, -0.01333223f, 0.02564728f, 0.09052636f, -0.10434535f, 0.00412386f, 0.22322449f, 
    0.12824810f, 0.03325058f, -0.02628816f, -0.07230886f, 0.18065907f, 0.17405343f, 0.18910883f, -0.00896824f, 
    0.13941579f, 0.03846851f, 0.28157049f, 0.15502371f, -0.00495379f, 0.10532079f, -0.06202131f, -0.01590904f, 
    -0.31225005f, 0.15793763f, -0.06618373f, -0.02419300f, -0.04532745f, -0.35361993f, 0.02968264f, -0.02357266f, 
    -0.12315208f, 0.05884129f, -0.02645970f, -0.22990967f, 0.13262460f, -0.11178246f, 0.02583512f, 0.04414390f, 
    0.00567284f, 0.33138010f, 0.12369308f, 0.08766777f, -0.00103344f, -0.05300615f, 0.11310363f, 0.08055360f, 
    -0.01386310f, -0.12179159f, 0.02066659f, 0.04414249f, -0.05622291f, 0.04196164f, 0.02504651f, 0.11330290f, 
    0.02856729f, -0.02607572f, -0.12053787f, -0.04865779f, -0.06513745f, 0.22133596f, -0.21283354f, -0.02243413f, 
    0.02168316f, 0.01313127f, 0.06005254f, 0.04190894f, -0.04279622f, 0.12067418f, 0.22165479f, 0.16809452f, 
    -0.04002279f, -0.11151123f, -0.14062950f, -0.02098941f, 0.02552604f, -0.10170841f, -0.05876456f, 0.06126233f, 
    -0.03813233f, 0.12966499f, -0.00088181f, 0.04010721f, -0.01495043f, 0.25684291f, 0.32004619f, 0.08436609f, 
    -0.20122418f, 0.03927622f, -0.12393347f, 0.05318417f, 0.04432425f, 0.07387834f, -0.02761510f, 0.02247906f, 
    0.04315080f, 0.02285945f, 0.16515884f, -0.05557381f, 0.03295799f, 0.18082063f, -0.18919986f, 0.16370626f, 
    0.01611010f, -0.02123604f, -0.00081247f, -0.01360981f, -0.30849230f, 0.01633194f, 0.39816856f, 0.12993856f, 
    -0.05756308f, -0.00582400f, -0.05464023f, 0.08742832f, 0.22626223f, 0.11591568f, -0.07908913f, 0.08608746f, 
    -0.16446458f, 0.24016251f, 0.28419507f, -0.23510942f, -0.05296310f, -0.07676417f, -0.00053801f, -0.04496006f, 
    -0.09176438f, -0.00782072f, -0.19686110f, -0.02024488f, -0.11887223f, -0.04803370f, -0.23724465f, -0.15834230f, 
    -0.07591467f, -0.02486330f, -0.00228435f, -0.00911714f, 0.12001726f, 0.04398638f, -0.10310161f, -0.10300855f, 
    0.02608606f, -0.24095652f, 0.14302984f, 0.01165481f, 0.18144758f, 0.16875714f, -0.02366455f, -0.01548567f, 
    0.07474972f, 0.10275698f, 0.04227144f, 0.14068963f, 0.32165536f, 0.15120347f, -0.06825378f, -0.18297544f, 
    0.06934115f, -0.04952747f, -0.03128190f, 0.10084147f, 0.01973562f, -0.04795800f, -0.09378455f, 0.07184396f, 
    -0.09170409f, -0.27595410f, -0.03048771f, -0.11523929f, 0.00536166f, 0.02634815f, -0.02781837f, 0.00584087f, 
    -0.01952952f, 0.10595425f, -0.07561062f, 0.23789407f, -0.24529648f, -0.03890012f, -0.07050063f, -0.06657075f, 
    0.09782302f, 0.18022341f, 0.12919742f, -0.01893487f, 0.05833749f, -0.01858122f, -0.04730181f, -0.01630656f, 
    0.12000268f, -0.04583993f, 0.25956208f, 0.35276863f, 0.02493928f, -0.16639709f, -0.02642050f, -0.00990527f, 
    0.00108797f, 0.03159931f, 0.00669670f, 0.00017545f, 0.17738828f, 0.29428846f, 0.08182121f, -0.08456386f, 
    -0.15682906f, 0.09750295f, 0.06730086f, -0.13278835f, 0.11886443f, -0.08904132f, 0.11996258f, 0.13814290f, 
    0.00856322f, 0.34071556f, 0.03201811f, 0.17936410f, 0.18454087f, 0.18439393f, -0.02688154f, 0.10210083f, 
    -0.05154648f, 0.01656912f, 0.15397023f, 0.03647156f, 0.22850676f, 0.27340007f, 0.24949495f, -0.00977318f, 
    0.05655906f, -0.02980718f, -0.13693930f, -0.02344128f, 0.06796895f, -0.13619831f, 0.03819282f, 0.06410076f, 
    -0.15303154f, -0.03770357f, 0.18112622f, -0.02203014f, -0.05762802f, 0.13432986f, -0.01119735f, 0.09830388f, 
    -0.00597229f, 0.00769767f, -0.04106903f, 0.08959605f, -0.43781668f, 0.02007691f, -0.11568960f, -0.01747757f, 
    -0.17637426f, -0.09120527f, -0.04001932f, -0.01489939f, 0.15489386f, 0.00398223f, -0.08586092f, -0.03911631f, 
    -0.14118746f, -0.10877795f, -0.01553977f, 0.05145270f, 0.02364681f, -0.11271743f, 0.03864880f, 0.10395471f, 
    0.19834100f, 0.05143858f, -0.10799022f, -0.01372512f, 0.12006874f, 0.10684262f, 0.11516542f, 0.13058449f, 
    0.02670155f, -0.01833691f, 0.00022316f, -0.04999864f, -0.03531243f, -0.22777833f, -0.09416781f, -0.09789083f, 
    -0.00415345f, 0.18918155f, -0.12235291f, -0.19575702f, 0.14542846f, 0.02508291f, 0.03373270f, -0.03383647f, 
    0.13792488f, -0.01228854f, -0.16032299f, 0.14844677f, -0.11555804f, -0.24164742f, -0.17374629f, -0.00736064f, 
    -0.02075194f, 0.10219253f, -0.04229038f, -0.13902138f, 0.06237210f, -0.16774513f, -0.03039855f, -0.07263528f, 
    -0.08346530f, 0.25539333f, 0.13285029f, -0.18278988f, -0.00511187f, 0.01727689f, -0.13884613f, -0.22146280f, 
    0.27180445f, -0.23623574f, -0.08318460f, -0.02720923f, 0.21148203f, 0.02960279f, 0.22219269f, 0.07013828f, 
    0.06983946f, -0.00402826f, -0.00867923f, 0.02622266f, 0.13610500f, 0.10978964f, 0.11759678f, 0.25494602f, 
    0.17735814f, 0.14181016f, 0.10494714f, -0.08180554f, 0.09049898f, 0.11464233f, -0.10055036f, 0.05153957f, 
    -0.11708982f, -0.21478224f, -0.19129634f, 0.04868148f, -0.46244505f, -0.25965658f, -0.03085314f, 0.24149884f, 
    -0.04046920f, 0.05124849f, -0.10933580f, 0.03443576f, 0.02673663f, -0.01604172f, -0.05151691f, 0.00400799f, 
    0.11278935f, -0.07938439f, 0.11240246f, 0.04273765f, 0.01227824f, 0.23554656f, -0.14821431f, -0.16950737f, 
    -0.25769055f, -0.28081715f, 0.00742340f, -0.17122880f, 0.20492230f, 0.17922707f, -0.08224563f, -0.18725464f, 
    0.06126529f, -0.08512617f, -0.04748303f, 0.04584333f, -0.00682395f, 0.10549510f, 0.02636012f, 0.02711563f, 
    0.01662383f, 0.13013987f, 0.14640158f, 0.07884737f, -0.06925962f, 0.05692234f, -0.01904367f, 0.14377800f, 
    0.05617127f, 0.07189067f, -0.02133397f, 0.04721108f, -0.04091703f, -0.00046129f, 0.02445515f, 0.22440027f, 
    0.06588399f, 0.05029908f, -0.03410875f, 0.03468426f, 0.06989943f, 0.04524137f, -0.02133432f, 0.15404798f, 
    -0.17422643f, 0.10474762f, 0.01715618f, 0.01510503f, 0.01781577f, -0.03683967f, 0.01081069f, -0.00508353f, 
    -0.01903780f, -0.09237235f, 0.14049537f, 0.25400561f, -0.02652972f, -0.15228640f, 0.20869973f, 0.11803354f, 
    0.01960130f, 0.09177577f, -0.00250638f, 0.12891117f, 0.00421504f, -0.28565401f, 0.04543476f, -0.07516496f, 
    0.10282843f, -0.20331135f, 0.13079834f, 0.15196264f, 0.05732305f, -0.00348567f, 0.13359272f, 0.07259283f, 
    -0.00409865f, -0.07569935f, -0.09556676f, 0.06682654f, 0.01471716f, -0.30908957f, -0.02742898f, 0.17710282f, 
    0.06544243f, -0.18735448f, -0.06670281f, 0.01844721f, -0.02384490f, -0.00099185f, 0.08131795f, 0.01858714f, 
    -0.32817632f, 0.17939213f, -0.31642488f, -0.26028058f, 0.11392339f, -0.01400494f, -0.22954212f, -0.02432201f, 
    -0.13288692f, 0.00414967f, 0.12923208f, 0.09542754f, 0.17624511f, 0.11250691f, 0.10795159f, -0.01378257f, 
    0.05374802f, 0.11520974f, 0.01956752f, 0.13846369f, 0.02403440f, -0.02916767f, 0.14721304f, 0.12795381f, 
    -0.10939222f, 0.03265751f, 0.13361935f, 0.08951513f, 0.15148965f, 0.09479791f, -0.06891717f, -0.02618147f, 
    -0.09536268f, -0.04989583f, 0.08797748f, 0.00674167f, -0.20392761f, 0.05365651f, 0.11627006f, -0.00357271f, 
    0.10529301f, 0.11925564f, -0.05629359f, 0.05400852f, 0.14329183f, 0.02372735f, 0.07190301f, 0.02363959f, 
    -0.21366681f, 0.22748637f, 0.09013803f, -0.11560161f, -0.05298874f, -0.02227346f, -0.20868789f, -0.03639218f, 
    -0.08691641f, 0.02383323f, -0.07144952f, 0.11653437f, -0.17949682f, -0.22048233f, -0.27502540f, 0.03621070f, 
    0.17454351f, -0.03396432f, -0.03457313f, 0.03419387f, 0.14663363f, 0.08321899f, -0.06502469f, 0.16348980f, 
    -0.12990008f, -0.19107646f, 0.01637335f, 0.24023329f, -0.02536555f, -0.07460744f, -0.11822335f, -0.06414473f, 
    0.05416144f, 0.00945208f, 0.11536592f, 0.18502338f, -0.14596404f, 0.32653564f, -0.06928996f, -0.04887582f, 
    -0.13490626f, 0.13935877f, 0.03861472f, -0.04014758f, 0.16906458f, 0.06395442f, 0.11877123f, 0.12374021f, 
    -0.04152792f, 0.02157014f, -0.04797458f, -0.05290638f, -0.02470114f, 0.03514770f, -0.02781045f, 0.00901593f, 
    -0.00018741f, -0.04852423f, -0.03670526f, -0.04745860f, 0.04356313f, 0.02017997f, 0.04537876f, -0.04240046f, 
    -0.00011572f, -0.02426348f, 0.00358894f, 0.03054974f, 0.00433800f, -0.05394480f, 0.03845428f, -0.01455194f, 
    -0.00587291f, 0.01131065f, 0.00017311f, -0.00243351f, 0.01735150f, 0.03321519f, -0.01641552f, 0.03019870f, 
    -0.04117598f, -0.00916351f, 0.02402763f, 0.03322614f, -0.00711401f, 0.02453800f, 0.02942319f, -0.02944389f, 
    0.00200186f, -0.03128407f, -0.02674515f, -0.01124755f, 0.00751499f, -0.00008686f, -0.00425930f, -0.04988219f, 
    -0.01543086f, 0.00839462f, 0.03195750f, 0.02040650f, -0.03688778f, -0.03180772f, 0.00843523f, 0.01166300f, 
    0.01097767f, 0.02472496f, 0.03024894f, -0.05451555f, 0.02237313f, 0.00307354f, 0.03008536f, 0.01239629f, 
    0.02115315f, 0.02121891f, -0.02980888f, 0.03165074f, -0.02747687f, 0.01006973f, 0.01970469f, 0.01841928f, 
    0.04585903f, 0.04166073f, -0.04655457f, -0.01004824f, -0.02952273f, -0.00728564f, 0.03840727f, -0.04061349f, 
    -0.03522668f, -0.00360933f, -0.02481461f, 0.03952394f, 0.04903569f, -0.01331104f, -0.01248851f, 0.03381436f, 
    -0.05431709f, 0.00201366f, -0.02145299f, 0.00859282f, 0.02528762f, 0.04260854f, -0.01071570f, -0.00392774f, 
    0.04259657f, 0.01322986f, -0.05646772f, 0.00526733f, -0.03510232f, 0.00778373f, 0.03430003f, -0.04352003f, 
    -0.03476106f, -0.02446713f, -0.02183804f, -0.03679090f, 0.01219993f, 0.01196889f, -0.04266025f, 0.01238666f, 
    -0.04492204f, 0.04851991f, -0.04836981f, 0.00423591f, 0.02789698f, -0.01298092f, -0.02505410f, 0.02735559f, 
    0.03262950f, -0.01824193f, -0.04401596f, -0.03863449f, -0.03275516f, 0.03366898f, -0.04219850f, -0.00169112f, 
    0.01121740f, -0.02610431f, 0.01215304f, 0.00247725f, -0.04003942f, -0.03043821f, -0.05120642f, -0.04961806f, 
    -0.04510813f, 0.02952383f, -0.01306573f, -0.04236347f, 0.03663134f, 0.01395249f, -0.03020665f, -0.02381539f, 
    -0.04927332f, -0.04076056f, 0.00973563f, -0.02866135f, -0.01155503f, -0.01510455f, -0.04461838f, -0.02261765f, 
    -0.02144380f, -0.03626923f, -0.03759198f, 0.01028125f, -0.04833363f, 0.00481138f, -0.03347572f, -0.01719342f, 
    0.03757963f, -0.00013215f, 0.00411602f, 0.02363705f, 0.03746000f, 0.04211085f, 0.02937517f, -0.03860020f, 
    0.02156941f, 0.01048782f, -0.03238054f, 0.01353006f, 0.01950517f, -0.04084846f, -0.01724020f, -0.05373086f, 
    -0.01354451f, -0.00737664f, 0.00464540f, -0.03114010f, -0.02043799f, 0.03743080f, -0.01530603f, -0.05007423f, 
    -0.02564532f, -0.02417382f, -0.03484248f, -0.01718719f, -0.01637408f, -0.05419292f, 0.02031684f, 0.00355063f, 
    -0.03252385f, 0.02769600f, 0.00672173f, 0.04351367f, -0.00361969f, -0.02153717f, 0.00334517f, -0.02830138f, 
    0.00080650f, -0.01200159f, -0.00884145f, 0.00994879f, -0.05166369f, 0.00709326f, -0.04243474f, 0.02775155f, 
    -0.04333255f, 0.02550934f, -0.01367300f, 0.03876072f, 0.03207919f, -0.03199365f, -0.04296666f, -0.02360098f, 
    -0.01110974f, 0.02416621f, -0.01107253f, -0.03716971f, -0.03876773f, -0.03096198f, 0.02757120f, 0.01646765f, 
    -0.05354366f, 0.04429189f, 0.02555176f, -0.01494457f, 0.01632700f, -0.03282958f, -0.05083429f, -0.03807040f, 
    -0.04698623f, -0.04357843f, 0.04510632f, -0.01690495f, -0.03596596f, -0.04303230f, -0.01961118f, -0.00392241f, 
    -0.05019025f, -0.00863175f, 0.01454577f, -0.02757400f, -0.04503222f, 0.02736293f, -0.01783925f, 0.02651714f, 
    -0.01411810f, -0.05231113f, -0.01419842f, 0.01469214f, -0.05052103f, 0.02287371f, -0.03028775f, 0.04600674f, 
    -0.03384329f, -0.00740392f, 0.01113910f, 0.03579928f, -0.01384568f, -0.00541672f, -0.01772415f, -0.00955695f, 
    -0.01465035f, 0.03789093f, -0.01051572f, 0.01495442f, -0.01523151f, -0.01529279f, -0.00690973f, 0.02870202f, 
    -0.04564498f, -0.03318273f, 0.01621839f, -0.02135426f, 0.00933469f, -0.04410332f, -0.00740986f, -0.02597815f, 
    -0.02225195f, -0.01060170f, -0.00864052f, -0.00030034f, -0.03330880f, -0.03563276f, 0.03835871f, 0.00298590f, 
    0.03740638f, 0.01107333f, -0.05029907f, 0.02470734f, 0.01803380f, 0.01698527f, -0.03792982f, 0.04475445f, 
    -0.01069047f, -0.03807770f, 0.02611327f, -0.01532350f, -0.01297160f, 0.02653222f, -0.00801362f, -0.03702142f, 
    -0.02553904f, -0.01273587f, -0.02526347f, -0.04435228f, 0.00457227f, -0.02925232f, -0.04813738f, -0.03958450f, 
    -0.01124528f, 0.00080707f, -0.03669062f, 0.01845085f, 0.02439662f, -0.00820210f, 0.01289780f, 0.01122894f, 
    -0.04340339f, -0.01678464f, -0.00552755f, 0.04152117f, -0.00192169f, 0.01999397f, -0.01071473f, -0.04071451f, 
    0.03773839f, 0.03177644f, 0.03439027f, -0.01401982f, -0.03641622f, 0.00079084f, 0.03218232f, 0.02198101f, 
    -0.02612107f, -0.02123089f, 0.03693148f, -0.00531409f, -0.00022260f, 0.00394981f, 0.00266373f, -0.05534603f, 
    -0.01272339f, 0.04434787f, 0.00954956f, 0.00502016f, 0.02875724f, 0.04939554f, -0.01728595f, 0.02738526f, 
    0.01441157f, 0.02544770f, -0.01307096f, -0.03357702f, 0.03753930f, 0.04067420f, 0.00265095f, 0.00521995f, 
    0.01558178f, -0.00038367f, -0.04328959f, -0.04992013f, 0.03671420f, 0.01561066f, 0.03181512f, 0.01768918f, 
    -0.03221871f, 0.03580457f, -0.05654765f, -0.01741423f, 0.03807871f, -0.02702487f, -0.00542327f, 0.03864355f, 
    0.01061349f, 0.01597096f, -0.05043081f, -0.04179978f, -0.01027475f, -0.05098012f, -0.03995496f, -0.00375386f, 
    0.02750357f, 0.08565161f, -0.03900380f, -0.04039162f, -0.01240532f, -0.03485659f, -0.02687385f, 0.02274704f, 
    0.02954843f, -0.08511671f, 0.15917304f, -0.14092517f, -0.23427667f, -0.02621933f, 0.28234476f, 0.17041427f, 
    -0.00203423f, 0.05981930f, -0.14336525f, 0.17922395f, -0.01617918f, 0.01987799f, -0.06321477f, -0.07710587f, 
    -0.02845239f, -0.34403056f, -0.31803173f, -0.30109677f, -0.01508666f, 0.03114283f, -0.01151047f, 0.04062000f, 
    0.06280422f, 0.01027592f, 0.03761721f, -0.08727065f, -0.15979894f, -0.06859901f, -0.17849377f, 0.05827852f, 
    -0.00571027f, -0.01790860f, 0.13659917f, 0.11748274f, -0.03060661f, -0.00252279f, 0.10301075f, -0.18926688f, 
    -0.21159765f, -0.38933134f, 0.03795978f, 0.00823250f, -0.00235216f, -0.01856501f, 0.00332342f, -0.05367070f, 
    0.03417309f, -0.00084737f, 0.03818684f, 0.05500958f, -0.57556462f, 0.02970181f, -0.24136490f, -0.18563201f, 
    -0.07495499f, 0.03768442f, 0.11793837f, -0.01097475f, 0.12121601f, 0.08386273f, 0.02438497f, 0.01297817f, 
    0.13545865f, 0.20037974f, -0.19178073f, 0.16250592f, -0.03942192f, 0.04980465f, -0.06245296f, -0.11183228f, 
    -0.02736301f, 0.13125373f, 0.07662152f, 0.17277858f, 0.06936308f, 0.05756701f, -0.00148200f, 0.33181363f, 
    0.13786118f, 0.06488745f, -0.00187537f, 0.06828996f, -0.04434301f, 0.08308444f, 0.02841521f, 0.10190970f, 
    -0.07653896f, 0.01645990f, 0.06261843f, -0.03323327f, 0.11127480f, 0.10576610f, 0.15535334f, 0.07505178f, 
    -0.06988696f, 0.02781045f, 0.09036223f, -0.04241368f, -0.21117982f, -0.16824479f, -0.04745618f, -0.05090388f, 
    0.11941961f, 0.10567697f, -0.01577799f, -0.01341791f, 0.12076141f, 0.13640057f, -0.00845816f, 0.04874068f, 
    0.05559564f, 0.32888949f, -0.07620254f, 0.16821133f, 0.06618145f, 0.05704703f, -0.12683858f, 0.02103923f, 
    -0.02725308f, 0.01287145f, -0.05807740f, 0.15791826f, 0.29142779f, 0.27178079f, 0.03893652f, 0.21554075f, 
    -0.14286911f, 0.02769615f, -0.07744348f, 0.04849530f, -0.06029572f, -0.03000534f, 0.00516078f, 0.03498661f, 
    -0.25734398f, -0.09520826f, -0.06601973f, 0.13262366f, -0.15824436f, 0.00475902f, 0.04388628f, -0.06770460f, 
    0.03089594f, 0.06812605f, 0.09849074f, -0.01070954f, -0.20551974f, 0.04296730f, -0.07091603f, 0.05974272f, 
    0.01308478f, 0.02549118f, -0.05271592f, -0.02764757f, -0.00745134f, 0.01927692f, -0.05134758f, -0.06450097f, 
    0.00413338f, 0.04192514f, -0.07967997f, 0.24886990f, 0.08824592f, 0.13512647f, 0.07782928f, 0.00506470f, 
    0.16139577f, 0.17226119f, 0.23552816f, 0.11713153f, 0.44529536f, 0.30151850f, 0.26684141f, 0.10856565f, 
    0.12441028f, -0.08143323f, -0.04417218f, -0.03445360f, -0.03798969f, -0.06487478f, 0.03278241f, -0.01894588f, 
    -0.18461885f, -0.11532928f, -0.20183656f, -0.12043045f, 0.04394994f, -0.08537830f, 0.11996900f, 0.07258213f, 
    0.07259082f, 0.19033910f, -0.01958831f, 0.24219805f, -0.05846005f, -0.04276623f, 0.06478531f, 0.18617585f, 
    0.07604764f, 0.12812151f, 0.11130680f, 0.11956713f, 0.12647699f, -0.02004753f, -0.07818838f, 0.07891735f, 
    -0.14012587f, -0.29443383f, -0.23388754f, -0.01775425f, -0.07664134f, -0.06488473f, -0.00469579f, 0.06707840f, 
    0.01773068f, -0.07623444f, 0.05656032f, -0.07398005f, 0.16817769f, 0.02321924f, 0.09930775f, 0.13875204f, 
    0.10815736f, 0.08702020f, 0.15999544f, 0.16306016f, 0.05554531f, 0.10692123f, -0.16664901f, -0.13592394f, 
    0.14503145f, -0.12485302f, -0.13337658f, 0.03185782f, -0.03271872f, -0.11609807f, 0.12262866f, 0.17069983f, 
    -0.04048435f, 0.04088663f, 0.08712098f, -0.23489650f, 0.07574359f, 0.03708128f, -0.04905504f, 0.02332305f, 
    0.11595535f, -0.01163965f, 0.06204898f, -0.12140214f, 0.08607753f, 0.07983419f, 0.06851497f, 0.06269888f, 
    0.00273522f, 0.53331923f, 0.07959525f, 0.21010873f, 0.00525101f, 0.00739328f, 0.02153832f, 0.00976946f, 
    -0.07176409f, 0.04505607f, -0.00346953f, 0.06101323f, 0.04084047f, 0.31761616f, 0.03484065f, 0.02547075f, 
    -0.07362179f, 0.01924573f, -0.00256108f, 0.06643055f, 0.06748701f, 0.15376559f, -0.04466668f, 0.15182570f, 
    -0.24126652f, 0.14116876f, 0.16255675f, 0.11173825f, 0.03580195f, -0.00435227f, 0.00477147f, -0.00493178f, 
    0.15259118f, -0.12357916f, -0.06315482f, 0.03291088f, -0.19508873f, -0.03893840f, -0.04888722f, 0.09888311f, 
    -0.03550363f, -0.02744684f, 0.03884987f, 0.02319444f, 0.07110190f, 0.02798673f, -0.01916027f, 0.10647122f, 
    0.03466120f, 0.06623874f, 0.05005292f, 0.03934754f, 0.00079360f, -0.03600651f, -0.19368407f, 0.05321530f, 
    0.12403992f, 0.12674409f, 0.05798589f, 0.17619567f, 0.09248883f, 0.12972169f, -0.12076949f, -0.10270079f, 
    -0.03289090f, -0.06002745f, 0.11240872f, 0.09549984f, 0.01647133f, 0.07433965f, 0.05770572f, -0.05485630f, 
    -0.04343927f, 0.03394717f, -0.02419695f, 0.25471365f, 0.01769367f, -0.06596600f, 0.00404696f, 0.12102613f, 
    0.09106475f, 0.01079190f, -0.00981180f, 0.04473860f, 0.03464635f, 0.00448222f, 0.06869894f, -0.09986990f, 
    -0.05311913f, -0.05673620f, -0.01602918f, -0.01050475f, -0.20851308f, -0.06855070f, -0.04545962f, -0.27443871f, 
    0.23857793f, 0.10468330f, 0.13398829f, -0.07169617f, -0.05008842f, -0.00516119f, 0.06025238f, 0.00831139f, 
    0.01310019f, -0.05002137f, 0.06047215f, -0.08014816f, 0.28864312f, -0.16633771f, -0.07747354f, 0.18719189f, 
    -0.01660147f, 0.14262033f, 0.02146502f, 0.07443039f, -0.05505460f, -0.04203527f, -0.02308327f, -0.14690205f, 
    -0.07697488f, -0.13586743f, -0.00839121f, -0.02950777f, 0.08665759f, -0.04960914f, -0.03787558f, 0.03285591f, 
    -0.01508683f, 0.00133310f, 0.00675456f, -0.21613209f, -0.27483130f, 0.01980275f, 0.24488747f, 0.09419674f, 
    -0.04495242f, 0.01764246f, -0.09743939f, 0.23337013f, 0.01878690f, 0.05057164f, 0.01618267f, -0.08006880f, 
    0.62743390f, -0.53653461f, -0.04007362f, -0.24593866f, 0.08199330f, -0.07023629f, 0.02347031f, -0.01053201f, 
    0.16501451f, -0.05635604f, 0.01396899f, -0.14925015f, -0.13390341f, -0.07832042f, -0.09434888f, -0.03572135f, 
    -0.01382924f, 0.19629446f, 0.15934275f, 0.15353607f, -0.06661201f, -0.13088211f, 0.01064327f, -0.22564423f, 
    0.16129091f, 0.05624719f, 0.31012437f, 0.37393054f, 0.01046325f, 0.01783914f, 0.05408068f, 0.01024411f, 
    0.06785768f, 0.00584513f, 0.01886256f, 0.05295346f, -0.44570231f, 0.18358099f, -0.49986178f, -0.13002172f, 
    -0.06638215f, 0.17310333f, 0.08620602f, 0.01529894f, 0.13372773f, 0.09299761f, 0.03482670f, 0.05416786f, 
    0.24986491f, 0.22206123f, -0.17146686f, 0.12692954f, -0.00354908f, 0.04048269f, -0.16405176f, 0.04389184f, 
    -0.09322447f, 0.07859042f, -0.04143364f, 0.16336872f, -0.18395816f, -0.08720104f, -0.24606405f, 0.49000901f, 
    0.06059243f, 0.06358889f, -0.18994200f, -0.06143458f, -0.09036167f, 0.13662009f, 0.01168312f, 0.07733413f, 
    -0.07213152f, 0.10005245f, 0.07021732f, -0.12268026f, -0.00328524f, -0.03167685f, 0.08106985f, 0.08391725f, 
    0.05208775f, 0.10600808f, 0.17274249f, -0.04830379f, 0.05263301f, -0.09599540f, -0.14963892f, -0.06387652f, 
    0.20053625f, 0.13572313f, -0.03166110f, 0.03395733f, 0.17636782f, 0.09640410f, -0.04536235f, 0.11231719f, 
    -0.48461565f, 0.38444084f, -0.20985332f, 0.09905401f, -0.02038377f, 0.23852055f, -0.03736546f, 0.00413362f, 
    0.04458191f, -0.08704809f, 0.02683734f, 0.12774052f, -0.10656147f, -0.02501984f, -0.07632531f, 0.14072394f, 
    -0.06484194f, 0.04996604f, -0.07558057f, -0.05484808f, 0.04188344f, 0.09357275f, 0.07284024f, 0.09078994f, 
    -0.26948407f, -0.10565319f, -0.06629684f, 0.08387038f, -0.05818864f, 0.05809298f, 0.11982962f, -0.17959371f, 
    0.17207277f, 0.03212197f, 0.14253299f, 0.07767242f, -0.03866835f, 0.18356584f, 0.13430496f, 0.01540926f, 
    0.05064401f, 0.02176906f, 0.03489187f, -0.07491546f, -0.03024265f, -0.10474514f, -0.13023660f, -0.01246102f, 
    0.29392138f, 0.12085741f, 0.04255993f, 0.17336835f, -0.00028804f, 0.23850533f, -0.04496882f, 0.06841324f, 
    0.10172638f, 0.00504012f, 0.10702989f, 0.06137991f, 0.12440314f, 0.12358727f, 0.09143037f, 0.15103686f, 
    0.10531871f, -0.13231814f, -0.09729899f, 0.02023543f, 0.08026038f, 0.04489205f, 0.15203944f, -0.08236874f, 
    0.24191847f, -0.00536561f, 0.06144220f, 0.05626954f, 0.10581042f, 0.05102142f, -0.06766241f, -0.00090436f, 
    0.04212418f, 0.16685407f, 0.00514446f, 0.27929151f, 0.02641451f, -0.08986373f, -0.18976243f, 0.17043474f, 
    0.28085780f, 0.08295231f, -0.04946906f, 0.15805294f, -0.04612451f, -0.06573015f, 0.05227283f, 0.15268271f, 
    0.12971343f, -0.36492231f, -0.04781831f, -0.16527025f, -0.01044224f, -0.11260077f, 0.12995453f, 0.15897225f, 
    -0.10391847f, -0.14426698f, 0.07337822f, 0.00673086f, 0.13994367f, -0.06129522f, 0.05646201f, 0.14656150f, 
    0.00532503f, -0.09250651f, -0.07424929f, 0.12067063f, -0.09288662f, 0.04168628f, -0.20920832f, -0.19377582f, 
    0.20856676f, -0.13327794f, -0.03224503f, -0.04018061f, 0.02866757f, -0.01395362f, 0.10342500f, 0.13238856f, 
    -0.11941272f, -0.10107553f, -0.02917574f, -0.15752017f, 0.12096115f, 0.09266378f, -0.00200167f, 0.06289016f, 
    0.16890952f, -0.15210705f, 0.00553863f, -0.06833751f, 0.22029260f, 0.09353592f, 0.11746667f, 0.03375329f, 
    0.06051267f, 0.28049210f, 0.10416751f, 0.15927126f, -0.20479500f, -0.12933156f, 0.05258987f, -0.03669314f, 
    0.02942133f, 0.00039599f, 0.01527287f, 0.00025324f, -0.01738385f, 0.12346794f, 0.03731364f, -0.19387221f, 
    0.02184800f, 0.01832773f, -0.02435421f, -0.01445691f, 0.11561550f, 0.10928381f, 0.04953202f, 0.15158422f, 
    -0.52109003f, -0.00980776f, -0.19713837f, 0.10476052f, -0.09114971f, 0.07438872f, 0.02773552f, -0.01662176f, 
    0.20654623f, -0.22508512f, 0.04035705f, 0.19619215f, 0.03452113f, 0.02278758f, -0.01671211f, 0.13857245f, 
    0.06998790f, -0.07552473f, 0.09322875f, 0.14506432f, -0.11990795f, -0.06959239f, -0.05888139f, 0.02371166f, 
    0.13148293f, -0.11754911f, 0.04231112f, 0.00500346f, 0.05507682f, -0.15197664f, -0.16392151f, 0.06432952f, 
    0.06285254f, 0.11049101f, 0.09770534f, 0.13977879f, 0.14812385f, 0.29332456f, -0.20723757f, -0.17598467f, 
    -0.10006370f, -0.02993738f, 0.05957738f, 0.07663033f, -0.10199347f, -0.06751239f, -0.01378495f, -0.11003908f, 
    -0.05340421f, -0.10444936f, -0.19435050f, 0.12573080f, 0.14993291f, -0.03029995f, -0.00127727f, 0.12890279f, 
    -0.00980916f, -0.01370347f, 0.08053901f, 0.04951832f, -0.02408813f, -0.07701931f, 0.04665738f, -0.12092309f, 
    -0.03712445f, 0.01370725f, -0.04664013f, 0.01878165f, -0.19107887f, 0.02139144f, 0.11992860f, -0.17964627f, 
    0.18880670f, -0.09789533f, 0.09327815f, -0.04401546f, -0.07832988f, -0.07752618f, 0.02160030f, 0.03271663f, 
    0.09245160f, -0.12509669f, 0.04709615f, 0.03876325f, 0.03897751f, -0.04792462f, -0.19536129f, 0.12780103f, 
    -0.03726973f, 0.25588605f, -0.00147851f, -0.06382187f, -0.12151771f, -0.10568991f, -0.06171697f, -0.29098889f, 
    -0.02254047f, 0.00169122f, -0.03869217f, 0.08222757f, -0.09405163f, -0.02810310f, -0.04291389f, 0.02271192f, 
    -0.10287961f, 0.12233773f, -0.10855155f, 0.15303257f, 0.33845520f, -0.01544252f, -0.44096068f, -0.06102882f, 
    0.07871955f, -0.01977357f, 0.27941871f, -0.20884927f, -0.02264190f, -0.01554047f, -0.02024606f, 0.00990980f, 
    -0.24158111f, 0.36037388f, 0.34606701f, 0.28250012f, 0.08958966f, 0.04132592f, 0.00156742f, 0.09895407f, 
    0.05143266f, 0.04580565f, -0.09015683f, 0.10994910f, 0.13857184f, 0.11839096f, 0.10614128f, -0.14497204f, 
    -0.00068677f, 0.07613181f, -0.04695764f, -0.05521379f, 0.03565472f, 0.17175271f, -0.18827635f, 0.07840984f, 
    0.22427598f, 0.37531886f, -0.09246111f, -0.09532184f, 0.01646879f, -0.00520512f, 0.05228921f, 0.09814133f, 
    0.06324428f, 0.08355936f, 0.03572436f, 0.00280154f, 0.35370779f, 0.01501707f, 0.01282742f, 0.20277953f, 
    0.08231273f, 0.07997669f, -0.13543727f, -0.07156621f, -0.04435354f, 0.01458948f, 0.05188282f, 0.01702641f, 
    0.10442723f, -0.11731336f, 0.22422713f, -0.05817155f, 0.02190008f, -0.03471209f, 0.06066890f, 0.11425500f, 
    0.13448489f, -0.06072550f, 0.00748940f, -0.00032762f, 0.21332733f, -0.15801877f, 0.05877041f, -0.17757075f, 
    -0.04635949f, -0.11772470f, 0.08774544f, -0.05030481f, 0.06671765f, 0.02103714f, -0.19395831f, -0.05036784f, 
    0.02876476f, -0.02578893f, -0.03259656f, 0.04289252f, -0.00533521f, 0.04947633f, -0.07266486f, -0.12591375f, 
    0.08044214f, 0.03972657f, -0.05163094f, -0.05108500f, 0.20939550f, 0.24482994f, 0.17758617f, 0.03550054f, 
    -0.03271925f, 0.01364634f, -0.01438591f, 0.04461873f, -0.07606910f, -0.02990134f, -0.04127128f, 0.00246576f, 
    0.02115216f, -0.46623337f, 0.06210216f, -0.19293903f, -0.05556289f, 0.13190255f, 0.09811799f, -0.11144636f, 
    0.00051180f, -0.05860294f, 0.09007985f, -0.14477882f, -0.13466404f, -0.26537853f, -0.00938469f, -0.19543669f, 
    0.10938260f, 0.00744575f, -0.00938684f, -0.01185782f, -0.04075585f, 0.01296380f, -0.09945586f, -0.01354190f, 
    0.13556972f, 0.03378867f, -0.03756401f, -0.16155164f, 0.05681074f, -0.03456400f, -0.01451701f, 0.09797624f, 
    0.02391211f, -0.02930240f, 0.07714965f, -0.01220094f, 0.31258675f, -0.01038594f, 0.04662110f, -0.09227769f, 
    -0.03270150f, -0.06612884f, 0.06318440f, -0.02204601f, 0.09600184f, 0.02867489f, 0.05276997f, -0.04642168f, 
    0.05440886f, -0.03071300f, 0.02109600f, -0.25009012f, -0.10190212f, -0.03300136f, -0.05733030f, -0.04280989f, 
    0.01094056f, -0.03958609f, -0.12968974f, -0.03368876f, -0.28239444f, -0.12460328f, -0.30420741f, -0.04175166f, 
    -0.02585709f, 0.12823339f, 0.10025924f, 0.02549091f, -0.07024931f, 0.03063318f, -0.08031558f, -0.09300292f, 
    0.05895818f, 0.18225014f, 0.03232425f, 0.02333320f, 0.13885541f, 0.09963518f, 0.09339985f, 0.07861623f, 
    -0.01434297f, 0.01293142f, 0.04980339f, -0.19546227f, 0.12186640f, -0.03956342f, -0.03079299f, -0.19202311f, 
    0.11465604f, -0.03135394f, -0.31572714f, 0.08031870f, -0.05011555f, -0.06715579f, 0.01707093f, -0.06673810f, 
    0.22544047f, 0.07525112f, 0.25255439f, 0.01087065f, 0.11042476f, 0.07935701f, 0.17663226f, 0.10826556f, 
    0.17246643f, 0.20093289f, -0.00164880f, 0.08692035f, -0.09353267f, -0.06718599f, -0.05479379f, -0.25550744f, 
    0.08991535f, 0.04758318f, 0.08610257f, -0.02526033f, 0.04194082f, -0.09364840f, 0.18649164f, 0.23894614f, 
    -0.24490738f, 0.12621479f, 0.20287424f, -0.05545907f, -0.03302876f, 0.09783821f, 0.04840267f, 0.05147143f, 
    0.07675945f, 0.06971406f, 0.10463728f, 0.21471286f, -0.03325397f, 0.01188095f, -0.02623830f, -0.09803974f, 
    0.00126889f, 0.13829955f, -0.06572887f, 0.16636442f, -0.05680782f, 0.00564232f, -0.02054433f, -0.05278398f, 
    0.03523080f, -0.57064700f, -0.02130699f, -0.21144162f, 0.10554238f, 0.07871919f, -0.06791014f, 0.00532016f, 
    0.03417054f, 0.01778902f, -0.03043172f, -0.06081753f, 0.07452417f, -0.28702411f, -0.23047991f, -0.05780995f, 
    -0.01965602f, 0.00995459f, -0.00913956f, -0.01656682f, -0.06191213f, 0.05679714f, -0.03629469f, -0.13117136f, 
    0.48808199f, -0.22051021f, -0.03614574f, -0.11299089f, -0.06612262f, -0.00558739f, 0.08562138f, -0.06233421f, 
    -0.12584868f, 0.04898241f, 0.02304216f, 0.01817527f, 0.29554427f, 0.09868188f, 0.06999169f, -0.24187966f, 
    0.00812660f, 0.01873006f, 0.09908867f, 0.03608027f, 0.07291330f, 0.00043451f, 0.15574369f, -0.08691071f, 
    0.13731499f, -0.08778389f, -0.09056918f, -0.09634742f, 0.04027420f, -0.00158522f, 0.03980016f, -0.02611782f, 
    0.00088331f, -0.07506517f, -0.00774818f, -0.01181836f, -0.00426895f, -0.05939689f, 0.08059832f, -0.01414680f, 
    0.01938252f, 0.05667102f, -0.03975140f, -0.13259633f, 0.07114694f, 0.05856510f, 0.02963097f, 0.16996720f, 
    0.02519949f, -0.02950920f, -0.15837578f, -0.35365951f, -0.00426241f, 0.19213045f, -0.00771152f, -0.05726555f, 
    0.02014187f, 0.04195029f, 0.06301331f, 0.04213531f, -0.13577162f, -0.00019632f, -0.06977824f, -0.00210479f, 
    0.07338342f, 0.10246433f, 0.02003858f, 0.11552801f, 0.17598727f, -0.08107957f, -0.06843086f, 0.11958979f, 
    -0.11549090f, -0.05491445f, -0.06194226f, 0.11359638f, 0.05765036f, 0.06002691f, 0.02195663f, 0.09480888f, 
    -0.06983486f, 0.06683905f, -0.06892696f, 0.02557014f, -0.17128700f, 0.11875912f, 0.01293796f, -0.17000245f, 
    0.04381020f, 0.01154606f, 0.06027225f, -0.00737574f, 0.07955741f, 0.10454274f, 0.01954903f, 0.18577901f, 
    -0.02308712f, -0.02686379f, -0.00830384f, -0.24467921f, -0.03721684f, -0.03979984f, 0.00954174f, 0.04809464f, 
    0.06912217f, 0.00876981f, 0.08904763f, 0.01264582f, -0.21806997f, -0.37273562f, 0.03494239f, -0.03534018f, 
    0.01903892f, 0.09328998f, 0.12315223f, 0.22065698f, 0.02047346f, -0.05521439f, 0.06741282f, 0.03389355f, 
    0.22704436f, 0.17005081f, -0.16614990f, 0.06817544f, -0.04731513f, -0.01747130f, -0.04498013f, 0.10300818f, 
    0.03315010f, 0.09221760f, 0.05112036f, 0.05368062f, 0.01339823f, 0.26946744f, 0.15502077f, 0.08332229f, 
    0.04364338f, 0.03412601f, 0.15808083f, -0.03267560f, 0.02817630f, 0.04771705f, -0.02151339f, -0.00663190f, 
    -0.33184379f, -0.36725467f, -0.11327459f, 0.18781005f, 0.07821378f, 0.07579765f, 0.07111610f, -0.20987271f, 
    0.07006803f, -0.02769583f, -0.07612199f, 0.01446422f, -0.20820338f, 0.41240829f, 0.67271477f, -0.10900620f, 
    0.01097246f, -0.11776305f, -0.09048797f, -0.03478616f, 0.09752607f, 0.05231192f, 0.13741469f, 0.17602445f, 
    -0.27988747f, -0.08863654f, -0.28405657f, -0.11166392f, -0.10628523f, 0.05675385f, 0.00264953f, 0.01630968f, 
    -0.10949177f, 0.07398851f, -0.02617720f, 0.19337526f, 0.22240105f, 0.13344252f, -0.27756080f, 0.21360724f, 
    -0.06618928f, -0.14893930f, 0.03278114f, 0.12358117f, -0.07685728f, 0.11700755f, 0.02095267f, 0.06048952f, 
    -0.05455168f, -0.17140658f, -0.15823579f, -0.09307323f, -0.00239197f, -0.03620545f, 0.13434084f, 0.13283521f, 
    0.00830933f, 0.01334237f, 0.05282624f, 0.01108545f, -0.30137298f, -0.11538406f, -0.01542918f, 0.06240464f, 
    -0.03716862f, -0.04772652f, -0.16990229f, 0.08210377f, -0.04723039f, 0.01245365f, 0.01962947f, 0.03805731f, 
    0.22946990f, 0.33547914f, 0.15818322f, 0.08102565f, 0.12730230f, -0.01972004f, -0.07240676f, -0.02961828f, 
    0.12940609f, -0.01561883f, 0.05645329f, 0.01506181f, -0.40862963f, -0.13991655f, 0.03762260f, -0.04676995f, 
    -0.08562493f, -0.15951778f, -0.09821164f, -0.08316427f, -0.02291774f, -0.01174184f, -0.05703836f, -0.04358652f, 
    -0.20977217f, 0.05585707f, 0.04251098f, 0.10172236f, -0.07734898f, -0.19253801f, 0.05648276f, -0.13538407f, 
    0.07883936f, -0.04895158f, 0.12745829f, -0.02878570f, -0.40456048f, -0.16390403f, -0.18098818f, 0.18650647f, 
    0.04059022f, 0.12720497f, -0.03216323f, -0.07323796f, 0.05107599f, 0.05966816f, 0.09307703f, 0.01369266f, 
    -0.07765260f, -0.21853212f, -0.10221161f, 0.22481999f, 0.08186740f, 0.03364758f, 0.02574730f, -0.03617239f, 
    -0.02201862f, 0.04609032f, 0.06584910f, -0.00387690f, 0.07628028f, -0.12227362f, -0.27384168f, -0.21024485f, 
    -0.10961483f, -0.04395644f, 0.05771510f, -0.02578587f, -0.05781733f, -0.02757928f, 0.01692994f, -0.11875780f, 
    -0.04879959f, -0.11855480f, 0.03544807f, 0.02248525f, -0.06505740f, 0.01005505f, 0.03723332f, -0.05295902f, 
    0.01841928f, 0.08616205f, -0.03120228f, 0.16519666f, -0.21066365f, 0.49324897f, -0.13967988f, -0.04863732f, 
    0.04247604f, 0.01860996f, 0.11218797f, 0.04315658f, 0.11420041f, 0.08235298f, 0.01310865f, -0.02609910f, 
    -0.06768401f, 0.42057669f, 0.07606792f, 0.41342497f, -0.01492624f, 0.12940748f, 0.14631295f, 0.15290077f, 
    0.08383892f, 0.04633510f, 0.05267955f, 0.06451435f, 0.07405441f, 0.05761689f, -0.10597514f, 0.42429864f, 
    0.04239771f, 0.16522785f, 0.14840257f, 0.02169633f, 0.11437470f, -0.00659415f, -0.00314008f, 0.09832885f, 
    0.02838870f, -0.18392286f, -0.08972159f, 0.09944224f, 0.06350011f, 0.05006221f, 0.23331602f, 0.14499685f, 
    -0.05127621f, -0.08539252f, 0.00571097f, -0.12800626f, -0.09039551f, -0.12569706f, -0.05249250f, -0.05672823f, 
    0.00277709f, 0.08306623f, 0.11326369f, 0.25391069f, 0.02578132f, -0.11845160f, 0.01030397f, 0.05071532f, 
    -0.27486452f, 0.30559981f, 0.16605499f, 0.35032448f, 0.22223343f, 0.08780085f, 0.07152988f, -0.01017523f, 
    0.01023352f, 0.04530232f, -0.06549288f, 0.00298056f, 0.10057876f, 0.06063660f, -0.01396910f, -0.13411535f, 
    -0.02597756f, 0.01651714f, -0.07494240f, 0.06859538f, -0.04473241f, 0.01677156f, 0.09228081f, 0.25201163f, 
    -0.25086898f, 0.28334123f, 0.09966814f, -0.18829201f, -0.01681395f, -0.07413710f, -0.09045339f, 0.06731657f, 
    -0.00561557f, 0.09353867f, 0.16486891f, -0.03230802f, -0.42764157f, -0.07854697f, -0.03536887f, -0.00642170f, 
    -0.06191871f, 0.02848101f, -0.06280401f, -0.00309499f, 0.02467215f, -0.02332451f, 0.14470840f, -0.01602315f, 
    -0.32563928f, -0.17124662f, -0.04837906f, 0.04027660f, -0.06795363f, -0.07426948f, -0.10803850f, 0.08600480f, 
    0.06731796f, 0.03112189f, 0.14857961f, 0.05136706f, -0.08150747f, -0.11251371f, -0.08697889f, -0.14703776f, 
    0.08183458f, -0.00197526f, 0.05499120f, 0.05454802f, 0.01921440f, 0.13797553f, 0.08361283f, -0.07729168f, 
    -0.27134374f, -0.09032041f, 0.16451153f, 0.38997996f, 0.00211945f, -0.13938861f, 0.19728704f, -0.01023907f, 
    0.09397816f, 0.03834420f, 0.06038704f, 0.10068958f, -0.02368094f, 0.02241608f, -0.09464882f, -0.08868195f, 
    -0.13789344f, -0.08453649f, 0.05534897f, -0.02890506f, 0.05873321f, 0.19394810f, 0.05496373f, 0.05695872f, 
    0.23810340f, 0.12167250f, -0.26755536f, -0.11310414f, -0.14612679f, 0.06743537f, 0.03853849f, 0.09596863f, 
    0.10837266f, 0.09479383f, 0.11544225f, 0.15506430f, 0.15597901f, 0.24587575f, -0.11053874f, -0.00317433f, 
    -0.09317791f, 0.02807056f, 0.09280591f, -0.00046616f, 0.21118255f, 0.16583763f, 0.20388012f, 0.00278245f, 
    0.00389033f, -0.26744890f, -0.06005713f, -0.13597070f, -0.16087398f, 0.06958914f, -0.02517285f, 0.10620299f, 
    0.11996988f, 0.07210991f, -0.02582955f, 0.23557745f, -0.30412343f, -0.16861115f, 0.34186906f, -0.04597323f, 
    0.00320194f, -0.08217438f, -0.07833063f, -0.10770907f, -0.00140368f, -0.05781040f, -0.11516999f, -0.03062455f, 
    0.50822192f, -0.25189131f, 0.08098901f, 0.20548420f, 0.07495528f, -0.02872782f, 0.00191670f, -0.14603841f, 
    0.17024605f, 0.09092493f, 0.02206633f, -0.11623874f, -0.02540509f, 0.13445538f, 0.20002364f, 0.20235243f, 
    -0.09555285f, -0.07372234f, 0.08564820f, -0.02061439f, 0.04186398f, 0.08126830f, 0.05495759f, 0.04046050f, 
    -0.14166175f, 0.00232701f, 0.22908030f, 0.47600472f, -0.09208149f, -0.00447958f, 0.11723718f, 0.09583364f, 
    0.15592049f, -0.04594124f, -0.07580122f, 0.00373621f, -0.03093457f, 0.27336520f, 0.25901407f, -0.08349952f, 
    -0.03738622f, -0.06209941f, 0.03097030f, 0.01466314f, 0.09318081f, 0.01921420f, 0.02309889f, -0.02136723f, 
    -0.30115873f, -0.09637357f, -0.10899610f, 0.05404464f, 0.00335061f, -0.10858629f, -0.02791254f, 0.15972975f, 
    -0.02961755f, -0.00351353f, 0.02149413f, 0.02624849f, -0.27462125f, 0.20130239f, -0.43059835f, -0.13350883f, 
    0.00905482f, 0.08005363f, -0.18953367f, -0.03373276f, -0.14103545f, 0.06323026f, -0.06403460f, -0.04128214f, 
    -0.02858038f, -0.15167622f, -0.19838178f, -0.14144164f, -0.01775720f, -0.00362496f, 0.02076470f, 0.02820731f, 
    -0.05040037f, -0.02214000f, -0.16622418f, 0.04166426f, -0.06855945f, -0.04743437f, 0.05469484f, -0.03737533f, 
    0.05950880f, -0.03767115f, 0.03241108f, 0.10546669f, 0.06652086f, -0.06992220f, -0.08677249f, -0.34392911f, 
    0.03753072f, 0.43020570f, 0.15338919f, -0.12973371f, -0.03706022f, -0.00394874f, 0.04980372f, -0.06867012f, 
    0.10287435f, -0.07932398f, 0.11340709f, -0.01332460f, 0.00166484f, -0.01411953f, -0.02515441f, 0.01231027f, 
    0.28276122f, -0.23748571f, -0.04335124f, 0.05908538f, -0.08551873f, 0.04952342f, 0.00828385f, -0.10504983f, 
    -0.35152084f, -0.06359050f, -0.15870801f, -0.28846002f, 0.03133896f, -0.10778414f, 0.15947898f, -0.28428525f, 
    -0.05715062f, -0.15745662f, -0.21909313f, -0.21966849f, -0.34597746f, -0.16770798f, 0.03476724f, 0.32877213f, 
    0.06862000f, -0.02808272f, -0.10600955f, 0.07486248f, 0.20372419f, 0.00563261f, 0.08535793f, 0.07666822f, 
    0.02540411f, -0.11525393f, 0.17808650f, 0.29757464f, 0.02645525f, -0.00536796f, -0.06922583f, 0.11245272f, 
    -0.00445178f, -0.10726193f, -0.14212476f, -0.21086237f, -0.01119285f, -0.19627616f, 0.06146836f, 0.12975901f, 
    -0.02848274f, -0.04568015f, -0.19340399f, -0.10004713f, -0.01108911f, -0.04797684f, -0.04873263f, -0.17621629f, 
    0.07433789f, -0.25364617f, 0.14754193f, 0.16980763f, 0.05395975f, 0.10184269f, 0.04597015f, -0.07038812f, 
    -0.37313968f, -0.11941101f, -0.40514424f, -0.40439749f, -0.23106855f, 0.36162263f, 0.02580171f, 0.25234282f, 
    -0.01379013f, -0.08127762f, 0.23697068f, -0.11410537f, -0.09222650f, -0.00325294f, -0.17239174f, 0.09054052f, 
    -0.00736074f, 0.05747340f, 0.06663103f, 0.11931859f, 0.08878536f, 0.20832497f, 0.03509378f, -0.24651992f, 
    -0.01675609f, 0.08605587f, -0.01465020f, 0.17894268f, 0.12818688f, 0.13233316f, -0.28541446f, 0.25071171f, 
    0.04314438f, 0.08423622f, 0.03425282f, -0.06106602f, 0.12674101f, 0.04938304f, -0.00196500f, 0.10405421f, 
    0.05177264f, -0.15525223f, 0.03745170f, 0.12853625f, 0.13462614f, 0.06555499f, 0.06129945f, 0.02688029f, 
    0.16202262f, -0.12790868f, 0.05919690f, 0.25447944f, 0.03168767f, 0.12421399f, 0.04663435f, 0.04877401f, 
    0.20589991f, -0.09722223f, -0.08701972f, -0.03114072f, -0.02127758f, -0.27430788f, -0.21292529f, -0.33846688f, 
    -0.02520676f, 0.34840748f, 0.30857384f, 0.27401075f, 0.04925937f, -0.01780760f, 0.03036317f, -0.02554465f, 
    0.06325305f, -0.08392796f, -0.08376779f, 0.03560743f, 0.13222252f, -0.28884757f, -0.05757561f, -0.17205453f, 
    0.17756198f, -0.14035729f, -0.19420992f, -0.09394567f, -0.05985507f, -0.10611147f, -0.05627698f, -0.01763940f, 
    -0.20419680f, 0.17226909f, 0.06289632f, -0.22966753f, -0.01138788f, 0.00578831f, -0.02102150f, 0.14136571f, 
    -0.06742541f, 0.01810098f, -0.08595587f, -0.17533390f, -0.33780044f, -0.05150926f, 0.10447685f, 0.04580435f, 
    -0.10045217f, -0.10955045f, -0.07055408f, 0.25648314f, 0.13253497f, -0.10707705f, 0.08130126f, 0.15891702f, 
    -0.28393117f, 0.06008804f, 0.14487337f, 0.11092558f, -0.10347967f, -0.14512588f, 0.12689933f, 0.03261629f, 
    -0.12653606f, 0.05044683f, 0.17642467f, -0.23776950f, -0.15045573f, 0.00937766f, 0.03926444f, 0.11785915f, 
    0.01937187f, -0.15949786f, 0.02849465f, 0.15223570f, 0.18288133f, -0.07482116f, 0.13465717f, -0.03454124f, 
    -0.23268208f, 0.07690751f, 0.10809631f, 0.14463048f, -0.04614850f, -0.01038046f, 0.18210991f, 0.10089457f, 
    -0.06909678f, -0.06293213f, -0.01454741f, 0.08838129f, -0.03511080f, -0.21758381f, 0.06255828f, -0.06575261f, 
    0.05237066f, 0.04285573f, 0.24808952f, -0.04812440f, 0.19568446f, 0.16561545f, -0.01820264f, 0.22848958f, 
    0.26587000f, -0.02750919f, -0.09782638f, -0.03153984f, -0.14752501f, -0.01102721f, 0.07866747f, -0.17605263f, 
    0.05874589f, 0.15879624f, 0.26228213f, 0.09695943f, -0.01178932f, 0.03292639f, 0.06724990f, 0.16885595f, 
    -0.04560857f, 0.05717487f, 0.16973753f, 0.04186900f, 0.04235391f, 0.07736357f, 0.31359589f, 0.20174415f, 
    0.04357201f, 0.03364643f, 0.05933506f, -0.06454114f, -0.02895328f, 0.03214689f, -0.03012055f, 0.06359784f, 
    0.05151084f, 0.02425866f, -0.16646852f, -0.15475859f, 0.34542689f, 0.02853719f, -0.13088964f, -0.05621537f, 
    -0.23017308f, -0.10429016f, 0.23659676f, -0.10172164f, 0.03398005f, -0.00821124f, 0.05682942f, 0.05708624f, 
    -0.45380762f, 0.48240235f, 0.06084814f, -0.09749477f, -0.12167105f, 0.07808863f, -0.02009180f, 0.02340675f, 
    -0.18053682f, -0.09700989f, -0.04221735f, 0.01504225f, -0.27013490f, -0.02340622f, 0.19738214f, -0.37138227f, 
    0.15699419f, 0.05352223f, -0.17213747f, -0.08419537f, 0.07041547f, 0.02432904f, 0.01191976f, 0.20628743f, 
    0.00062308f, 0.03368739f, -0.19984445f, -0.16752414f, 0.09991243f, -0.10558268f, 0.04122813f, -0.03373728f, 
    -0.12722658f, -0.00765306f, -0.05006023f, -0.00377795f, 0.34418485f, -0.15430678f, 0.52636755f, -0.11406662f, 
    0.09816908f, -0.09490636f, -0.13074557f, -0.03582771f, -0.15157087f, -0.00700011f, -0.02072420f, 0.10277564f, 
    -0.42531723f, -0.13148037f, -0.04782211f, -0.15603583f, 0.08711581f, 0.06776451f, -0.03251733f, -0.07434485f, 
    -0.11328831f, -0.04719660f, -0.03541524f, -0.20802346f, 0.39832085f, 0.24426459f, -0.14871994f, -0.06894731f, 
    -0.07578414f, -0.12267507f, 0.11440364f, 0.18075085f, 0.17675924f, -0.00570095f, 0.02610813f, -0.00882373f, 
    0.10906272f, -0.01064966f, -0.01955694f, 0.12909871f, -0.04911233f, -0.10657833f, -0.12340762f, -0.01812776f, 
    0.06150996f, 0.01828996f, 0.04361309f, 0.06923562f, -0.20242387f, -0.26976427f, -0.11928615f, 0.22229423f, 
    -0.01869692f, -0.09479497f, 0.05479236f, -0.04262460f, -0.07288051f, -0.04720342f, 0.11756447f, 0.08437675f, 
    0.73198777f, -0.11637092f, 0.14252558f, 0.04650617f, 0.13999838f, -0.25544578f, 0.20571645f, 0.05187637f, 
    0.08116918f, 0.22025049f, 0.03488690f, -0.18677859f, 0.15121910f, 0.15315321f, 0.21181825f, 0.12655777f, 
    0.09907686f, -0.10916416f, 0.02110624f, -0.06384079f, 0.03055177f, 0.05769444f, 0.02500329f, 0.06208578f, 
    0.28392747f, 0.13977571f, 0.09291840f, 0.08663720f, 0.09903284f, -0.12851788f, -0.02928403f, 0.06917332f, 
    0.16486010f, 0.17374119f, 0.03247377f, -0.01157409f, -0.12477171f, -0.08402170f, -0.02810167f, 0.29210323f, 
    0.05919156f, 0.16598426f, -0.05710419f, -0.09615857f, -0.14230715f, -0.16362369f, 0.05767104f, 0.03774358f, 
    -0.02518509f, -0.45165536f, -0.12117276f, -0.15952171f, 0.16139066f, -0.02041071f, -0.03262131f, -0.04519060f, 
    -0.12941234f, 0.00240528f, -0.08783793f, -0.04717182f, 0.17645946f, 0.03510629f, 0.04993014f, -0.00621383f, 
    -0.06279141f, 0.06426100f, 0.09571125f, -0.03577739f, 0.08242486f, 0.11825326f, -0.03852392f, 0.18326084f, 
    0.12537670f, 0.25658828f, 0.22181776f, 0.08674898f, -0.10557230f, -0.00655959f, -0.06512701f, 0.01751259f, 
    -0.02992301f, -0.10082988f, 0.11866210f, -0.00353852f, 0.16184576f, 0.12475639f, -0.37916607f, -0.36587775f, 
    -0.23778997f, -0.07187465f, 0.16310355f, -0.21744713f, 0.24380465f, 0.09955665f, 0.05675208f, -0.23627923f, 
    0.11564668f, 0.35489655f, 0.08181226f, 0.01713598f, -0.04636357f, -0.00546068f, -0.14300269f, 0.00436221f, 
    -0.13944897f, 0.05920696f, 0.01112334f, -0.10041000f, -0.03403957f, -0.12852572f, -0.15729982f, 0.02917705f, 
    -0.16470096f, -0.06275488f, 0.01305096f, -0.05789667f, -0.10982471f, -0.04929083f, 0.17631099f, -0.02777775f, 
    -0.14329121f, 0.05385672f, -0.15096195f, -0.03909626f, 0.13736732f, -0.05083791f, -0.11825981f, -0.05791953f, 
    -0.17846061f, -0.06509800f, -0.22000508f, -0.08588061f, 0.04666754f, 0.05743799f, 0.10283568f, 0.16699483f, 
    -0.11322420f, -0.01835921f, 0.11823121f, -0.01774449f, -0.07743142f, 0.00298362f, 0.01988206f, 0.09024500f, 
    0.11603417f, -0.07604388f, 0.10235933f, 0.17620517f, 0.04912256f, 0.05918549f, -0.10505193f, -0.04964813f, 
    -0.02497993f, 0.01043510f, 0.04660973f, 0.02329981f, 0.24830683f, 0.17393899f, 0.23820487f, 0.20492439f, 
    -0.03017407f, -0.00239068f, 0.00350200f, 0.14263622f, 0.10573928f, -0.02455625f, 0.02639554f, 0.02809067f, 
    0.52866828f, 0.05319681f, -0.10080446f, -0.01421857f, -0.00257657f, -0.03046820f, 0.10175906f, -0.04915120f, 
    0.19554619f, 0.40073740f, -0.04411112f, -0.10828586f, -0.49431744f, -0.40709642f, 0.09129031f, 0.05465361f, 
    0.02649511f, 0.08627380f, -0.00898448f, 0.13330276f, -0.18866469f, -0.06985314f, -0.05138045f, 0.04363551f, 
    -0.10014852f, -0.01410056f, -0.26269972f, 0.19371654f, 0.01941266f, 0.11124362f, 0.13634740f, -0.03703161f, 
    -0.04820053f, 0.00049753f, -0.02778639f, -0.16260344f, -0.33531857f, -0.35409588f, -0.13702741f, 0.06000476f, 
    -0.00802003f, 0.11441413f, 0.05249454f, -0.03000193f, -0.03189297f, -0.09366301f, -0.05629505f, -0.03342571f, 
    0.00638298f, -0.23340677f, -0.12338531f, -0.29327410f, -0.04238743f, -0.33882877f, -0.07191826f, -0.02373499f, 
    -0.02710672f, 0.14994244f, -0.00391959f, 0.03800954f, 0.05507741f, 0.05188806f, 0.12495405f, 0.16837887f, 
    0.02608618f, -0.03171237f, 0.06639471f, 0.05067408f, 0.12645721f, 0.07112287f, 0.05302905f, 0.12257420f, 
    -0.28946179f, 0.02711087f, -0.04565910f, 0.06312311f, -0.12626667f, -0.04860038f, 0.00171662f, 0.03083600f, 
    0.13900335f, 0.07358170f, -0.14722732f, 0.02941953f, 0.17151827f, 0.20061685f, -0.16731152f, -0.12126417f, 
    -0.00424131f, -0.24377613f, 0.00231020f, 0.14330541f, 0.13245977f, -0.00125147f, -0.01700280f, 0.02556599f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.24301487f, -0.15505472f, -0.00553325f, -0.03069679f, 0.19270878f, 0.12969165f, -0.04147566f, 0.06165348f, 
    0.01802746f, -0.11261335f, 0.03219014f, -0.04322258f, 0.14965895f, 0.01877011f, -0.07076176f, -0.10449129f, 
    0.02097629f, 0.10215750f, 0.18748735f, 0.06379718f, 0.04342343f, 0.03753657f, 0.00494087f, 0.20968762f, 
    0.09176261f, -0.05486056f, 0.00910436f, -0.08154100f, -0.06217037f, 0.13754407f, -0.08437277f, 0.14635803f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.18779537f, -0.22876602f, -0.28760663f, 0.04853426f, 0.35933021f, 0.17385077f, -0.00765302f, 0.34582308f, 
    -0.12416549f, 0.16570875f, -0.15548366f, 0.06171538f, -0.24898709f, -0.01052206f, 0.22142196f, 0.16119462f, 
    -0.05729913f, 0.23020801f, -0.14073850f, -0.41370410f, 0.04551117f, 0.07885291f, -0.09313533f, 0.28844765f, 
    0.11247817f, -0.05132668f, -0.15156363f, -0.25028646f, 0.13422938f, 0.30193391f, 0.24457255f, 0.03229395f, 
    0.03744223f, -0.04151350f, 0.01129446f, -0.02109538f, -0.02413078f, -0.07541730f, 0.17484118f, 0.17232895f, 
    0.17502119f, 0.07565389f, 0.02533074f, -0.00936754f, -0.13408417f, -0.01411005f, -0.21422051f, -0.12282986f, 
    -0.14441055f, -0.09673512f, -0.19303386f, -0.29280508f, 0.04292489f, -0.23359568f, -0.13850175f, -0.10479551f, 
    -0.20968224f, 0.03388906f, -0.17224547f, 0.17576538f, 0.37917805f, -0.40040651f, 0.09452961f, 0.15412651f, 
    -0.05476673f, 0.09688986f, -0.06207888f, 0.06226434f, -0.14852771f, -0.01160956f, 0.06826939f, 0.01751478f, 
    -0.00235951f, -0.02736844f, -0.16170131f, 0.01498433f, 0.06834222f, 0.14275743f, 0.02229143f, 0.04915696f, 
    0.14235659f, -0.13643354f, -0.05999799f, -0.07911496f, 0.11787640f, -0.12456702f, -0.18519688f, -0.07206890f, 
    -0.16820742f, 0.17289360f, -0.00414422f, -0.08031130f, 0.11350529f, -0.13163149f, 0.03346257f, -0.13473891f, 
    0.32879928f, -0.22635163f, -0.23549780f, -0.10784729f, -0.29407316f, 0.24733678f, 0.02393792f, 0.48021749f, 
    0.15431049f, -0.48012811f, -0.06126828f, 0.10071999f, 0.09932920f, 0.08877086f, 0.27734694f, 0.02303285f, 
    -0.00457907f, -0.34652436f, 0.23232768f, 0.06856765f, 0.44090778f, 0.22329561f, 0.18742263f, 0.01414586f, 
    -0.30364412f, -0.10870542f, 0.06465480f, -0.13115314f, 0.10273305f, 0.19875729f, -0.17885406f, -0.04967348f, 
    0.14478549f, 0.33569083f, 0.46582907f, 0.11012206f, -0.22213185f, 0.31695667f, 0.13025035f, -0.33945313f, 
    0.17462237f, 0.54706782f, -0.05893672f, -0.17579406f, -0.22786039f, 0.13263558f, -0.11916707f, -0.08567747f, 
    -0.04013109f, 0.25431317f, -0.09844928f, -0.26502123f, 0.13927148f, -0.06244089f, 0.07361017f, 0.11869274f, 
    0.33779511f, 0.16288939f, -0.29170820f, 0.05352751f, 0.10582738f, 0.00634658f, -0.15204142f, -0.01748355f, 
    0.22709779f, -0.00353579f, -0.01159551f, 0.09421428f, 0.15270361f, 0.15319926f, -0.00287098f, -0.25790522f, 
    -0.04946214f, 0.00253962f, -0.11676016f, 0.01248945f, 0.08912250f, 0.07771306f, 0.20465367f, -0.18049276f, 
    0.10494225f, -0.04147377f, 0.22309136f, -0.24200830f, -0.29709193f, -0.21510543f, 0.25541958f, 0.22156708f, 
    0.18484008f, 0.08415452f, -0.06459513f, 0.28816012f, 0.00306464f, -0.12367168f, -0.08549935f, -0.26792538f, 
    0.31072104f, 0.03188077f, 0.08533328f, 0.13802530f, 0.16126686f, -0.20692344f, 0.04518013f, 0.03780103f, 
    0.11921272f, -0.43880570f, -0.13607934f, -0.04094099f, -0.13235755f, 0.02321840f, 0.09880441f, -0.33740368f, 
    0.18223107f, 0.28212273f, 0.19487646f, -0.05958248f, -0.19511010f, 0.25293329f, 0.20775530f, 0.19769549f, 
    0.02721463f, -0.10977796f, 0.35959190f, 0.03943990f, -0.09882127f, -0.18768840f, -0.16428009f, -0.25958067f, 
    -0.12827490f, -0.38283941f, -0.08908419f, -0.05808285f, 0.03906254f, -0.00668725f, -0.10000001f, -0.02730918f, 
    -0.14939079f, 0.59208220f, -0.13646927f, -0.16901080f, 0.34742984f, -0.17771727f, 0.04427775f, -0.04768109f, 
    -0.10518914f, -0.05681060f, 0.27024508f, 0.12563953f, 0.34168997f, -0.09025788f, -0.34571186f, -0.19547008f, 
    0.02893586f, 0.12954561f, 0.02339535f, 0.06082105f, 0.11397106f, 0.20548584f, 0.15005946f, 0.25618103f, 
    -0.00859929f, -0.49750018f, -0.57595938f, 0.03728748f, 0.05096267f, 0.10509737f, -0.04313573f, 0.00154533f, 
    -0.00171962f, 0.06060112f, 0.10932653f, 0.06004725f, 0.12986483f, 0.09880377f, 0.29086253f, 0.11948220f, 
    -0.00141344f, -0.37684041f, 0.23643766f, 0.05254285f, -0.14399424f, 0.07638241f, -0.06473442f, 0.04554943f, 
    -0.14646034f, 0.09708200f, -0.04150063f, 0.02944924f, 0.03398632f, 0.31971708f, -0.19895852f, -0.20052770f, 
    0.10326013f, -0.17105979f, -0.21374322f, 0.01178399f, -0.18873322f, -0.09572333f, 0.01968195f, -0.04722828f, 
    0.08692293f, 0.40526813f, 0.01913933f, 0.11213138f, 0.33638957f, 0.12760690f, 0.06676320f, -0.39567488f, 
    0.11284909f, 0.14119059f, 0.10358446f, 0.13733557f, 0.28698543f, 0.21066044f, -0.01248298f, -0.07117651f, 
    -0.43943667f, -0.06836253f, 0.21432190f, 0.03178953f, -0.42863321f, -0.12770952f, -0.04875892f, 0.30272567f, 
    -0.00644868f, 0.12244181f, -0.15887301f, 0.12286123f, -0.45399505f, -0.13902192f, -0.10920006f, 0.16417131f, 
    0.04132580f, 0.52938831f, -0.06821592f, 0.09336954f, 0.04357698f, -0.15531607f, 0.40242004f, 0.11958100f, 
    0.07232909f, 0.21258463f, -0.28099087f, -0.05103765f, 0.27136168f, 0.33952960f, 0.31985158f, -0.02522201f, 
    -0.00669303f, -0.09724928f, 0.04289162f, 0.14185643f, -0.09107150f, -0.11736124f, 0.60316026f, -0.55003613f, 
    0.16001219f, 0.23749457f, 0.31161264f, -0.04069170f, 0.23428944f, -0.08487847f, 0.05430353f, 0.14628656f, 
    0.11915304f, -0.06004581f, -0.17034023f, -0.05768414f, 0.24899526f, 0.00672706f, -0.14157511f, 0.12945679f, 
    0.14827393f, 0.07903723f, 0.04925917f, 0.21705681f, 0.39298159f, 0.32666752f, 0.11109474f, -0.23450072f, 
    0.11626247f, 0.14472078f, -0.21504188f, -0.03711852f, 0.21306965f, -0.35953823f, -0.12602791f, 0.07389325f, 
    0.11936298f, 0.38702884f, 0.42258823f, -0.16223708f, -0.10650047f, 0.10460652f, -0.05884352f, -0.51576215f, 
    -0.08999673f, -0.09701144f, 0.01539875f, 0.00375608f, -0.20413037f, -0.08819257f, 0.17809604f, 0.34449661f, 
    -0.02284661f, -0.09751447f, 0.07527538f, -0.18763328f, 0.07208298f, 0.01586436f, 0.30971572f, 0.16978315f, 
    0.01755677f, -0.07688390f, -0.13978669f, -0.10624491f, 0.05922919f, -0.19451404f, -0.23757598f, -0.03253318f, 
    -0.09680085f, -0.01945161f, -0.10735834f, -0.16585554f, 0.08108725f, -0.13660213f, -0.11746287f, 0.07673747f, 
    0.06591006f, 0.08349652f, -0.03969375f, -0.01264679f, 0.06121327f, 0.16264629f, -0.14932100f, 0.04209877f, 
    0.05867374f, 0.01794830f, -0.12478133f, 0.06772417f, 0.09424166f, -0.17909193f, -0.06430703f, -0.08614463f, 
    -0.01169684f, -0.03010863f, -0.16175178f, 0.10597800f, -0.09963683f, -0.09227356f, -0.07714302f, -0.18750308f, 
    -0.00797349f, -0.46318695f, -0.35281125f, -0.00867722f, 0.07505602f, -0.14641888f, -0.00279754f, 0.05808665f, 
    0.06969180f, -0.41611823f, 0.14590585f, -0.11693175f, -0.11836948f, -0.04855282f, 0.18594022f, 0.34094107f, 
    -0.00862078f, 0.20845266f, -0.10857500f, -0.09283144f, -0.12770914f, 0.18713130f, -0.14256006f, 0.02840607f, 
    -0.14078704f, 0.02345104f, 0.21534120f, 0.02564711f, 0.12118374f, 0.17241427f, 0.10497487f, 0.08010853f, 
    -0.11010431f, 0.23566778f, 0.11733907f, 0.13710570f, 0.19793142f, -0.02384502f, -0.12389762f, -0.04492199f, 
    -0.08821838f, 0.67527717f, 0.07808164f, 0.16194385f, 0.16229758f, 0.05943910f, 0.21713747f, 0.30931893f, 
    0.11746531f, 0.36591870f, -0.08908539f, 0.07369346f, 0.15318134f, 0.21095352f, -0.20372953f, -0.14825700f, 
    0.22941153f, 0.17322661f, -0.18669599f, -0.01231904f, 0.33480141f, 0.04111684f, -0.22553489f, 0.14328408f, 
    0.12104611f, 0.01843104f, -0.23370098f, -0.04447144f, -0.11503409f, 0.19751567f, -0.14485532f, -0.13164435f, 
    0.12886094f, 0.32554492f, -0.12771878f, -0.11273500f, 0.18275432f, -0.03677356f, 0.26090881f, 0.10095838f, 
    -0.10144424f, -0.13875936f, -0.18894108f, 0.03944916f, 0.03937633f, -0.02022113f, -0.09216733f, -0.24271999f, 
    -0.08273628f, 0.14923735f, -0.07717924f, 0.14475250f, -0.22627130f, 0.20205666f, 0.45960888f, 0.16313995f, 
    0.24964654f, -0.05436586f, 0.15570155f, 0.08214731f, 0.05874823f, -0.05510324f, -0.13472067f, -0.15065767f, 
    0.13273133f, -0.23144427f, -0.02259883f, -0.08498412f, -0.19121481f, 0.10495776f, 0.03495428f, 0.03180444f, 
    -0.17239727f, -0.09554711f, -0.11505576f, -0.01376786f, -0.31017572f, 0.07216329f, -0.04817228f, 0.14494863f, 
    -0.04624396f, -0.07764670f, -0.17614534f, -0.07613326f, 0.22536620f, -0.08802794f, -0.11982795f, -0.40173835f, 
    0.26773250f, 0.31839883f, -0.12485689f, 0.06902310f, -0.18503508f, 0.08423668f, 0.02645843f, 0.36980447f, 
    0.02473637f, -0.00593146f, 0.08058052f, -0.16244011f, -0.02034672f, 0.15510222f, 0.14744657f, 0.21197861f, 
    -0.07209498f, -0.15266880f, -0.32726720f, -0.29379699f, -0.32847267f, 0.03011938f, 0.15630969f, 0.07017928f, 
    0.29902148f, 0.09561702f, -0.19725712f, -0.56477326f, -0.05088967f, 0.41919184f, 0.05511253f, 0.17513821f, 
    -0.08779312f, -0.26384473f, 0.17345348f, -0.17998366f, 0.15940699f, 0.12877667f, -0.12569328f, 0.00411359f, 
    0.00824669f, 0.14854307f, 0.10755922f, 0.00426590f, 0.18022549f, -0.11509461f, -0.17326134f, -0.30691025f, 
    -0.17452845f, 0.52886730f, -0.03736864f, 0.06528159f, 0.07405094f, 0.27746490f, -0.20078978f, 0.31926170f, 
    0.23340508f, 0.00435848f, -0.10179465f, -0.08451084f, 0.14174441f, 0.07156627f, 0.44465503f, -0.27298173f, 
    0.12886010f, -0.16755077f, 0.11271888f, 0.12855610f, 0.19230212f, 0.07940916f, -0.11017932f, 0.20344265f, 
    -0.15290619f, -0.58385086f, 0.06576807f, -0.01848023f, 0.19348691f, -0.16453731f, -0.25015348f, -0.27691329f, 
    -0.12488905f, 0.00206724f, 0.38852692f, 0.06543203f, -0.18941343f, -0.05759270f, 0.17602597f, 0.29967618f, 
    0.00632119f, 0.14565285f, 0.33660346f, 0.15696348f, -0.41110405f, 0.02051817f, 0.04725092f, -0.21739332f, 
    -0.06519091f, -0.18034910f, -0.37378955f, 0.05499788f, 0.13004141f, -0.34836951f, -0.16332501f, 0.42880753f, 
    -0.12735707f, 0.03154113f, -0.11640853f, -0.01252172f, 0.02420939f, 0.15756035f, 0.29471320f, 0.12364117f, 
    0.02251350f, 0.17116182f, -0.08183663f, -0.10326620f, 0.49610686f, 0.30406907f, -0.02279072f, 0.22549213f, 
    -0.13602796f, 0.03120893f, -0.08157751f, -0.24872392f, 0.00972580f, 0.19044258f, -0.25407791f, -0.05414512f, 
    0.21464676f, -0.07204746f, 0.05882742f, 0.07930858f, -0.57072723f, 0.21322942f, -0.09589601f, -0.11659344f, 
    -0.09900824f, 0.03532349f, 0.14556640f, 0.03466298f, 0.15818988f, -0.03742936f, 0.32536986f, -0.34622502f, 
    0.16817892f, -0.46418238f, 0.16448209f, 0.06888666f, 0.22925036f, -0.20657022f, 0.35086370f, 0.01421857f, 
    -0.16989002f, 0.08957569f, 0.21142925f, 0.16369946f, -0.27917349f, 0.28688869f, -0.02815446f, -0.18334095f, 
    -0.25612938f, 0.10702427f, -0.21387804f, 0.02570620f, -0.05723868f, 0.34848478f, -0.05822303f, -0.19971195f, 
    -0.15571436f, -0.21285596f, -0.02411207f, 0.13333933f, 0.10704775f, 0.06864177f, 0.01889198f, 0.11414862f, 
    0.10421997f, -0.09206449f, -0.03271284f, 0.28894743f, -0.32680932f, -0.21682841f, -0.01500003f, -0.20741877f, 
    -0.07725286f, 0.00971303f, 0.08812817f, -0.16228926f, 0.15936802f, -0.01136112f, -0.15201777f, 0.15209644f, 
    0.11998210f, 0.20004068f, 0.03031619f, 0.01022178f, 0.19285713f, 0.11576814f, 0.04920350f, -0.12462900f, 
    0.08536488f, -0.16187505f, 0.17419939f, -0.01373214f, 0.18277000f, 0.05947136f, 0.11869080f, 0.19430037f, 
    0.13087536f, -0.13466740f, 0.13185681f, -0.08308400f, 0.03637156f, -0.12227444f, -0.03988681f, 0.04380387f, 
    0.21522887f, -0.03496231f, -0.23710324f, -0.24633342f, 0.20416874f, -0.05941811f, -0.33750686f, 0.15011533f, 
    0.01918127f, -0.35005319f, -0.03636261f, 0.14001173f, 0.49708661f, 0.21981199f, 0.01425162f, -0.32241151f, 
    -0.10271515f, 0.00127822f, -0.02654044f, -0.09796968f, 0.30171973f, 0.04339284f, -0.13951875f, 0.02586884f, 
    0.16516049f, 0.16595167f, 0.40148017f, 0.19416118f, 0.03130313f, 0.13489364f, -0.18321630f, 0.27245733f, 
    0.01333423f, -0.15865347f, -0.07323472f, -0.03877446f, 0.05369323f, 0.10670771f, -0.28977299f, -0.11223422f, 
    0.36020631f, -0.25450554f, 0.08012398f, -0.10807676f, 0.21552767f, -0.02232966f, 0.00913243f, -0.15834692f, 
    0.00155593f, -0.39192510f, 0.10177740f, -0.05981700f, -0.05080554f, -0.10172813f, -0.06674864f, 0.02940138f, 
    -0.14322494f, -0.14364707f, 0.31395528f, 0.07165778f, 0.13385953f, 0.16984980f, 0.14632004f, 0.28323993f, 
    -0.18065107f, 0.00870958f, 0.29800501f, -0.05333524f, -0.16952361f, -0.14534566f, -0.63753146f, -0.13322252f, 
    -0.08063483f, 0.12923385f, -0.42267960f, -0.13063611f, 0.05009933f, -0.06797606f, 0.10852394f, 0.40867007f, 
    0.08068841f, -0.52501827f, 0.08084373f, 0.06299772f, 0.26317766f, -0.12032607f, -0.02254231f, 0.27217969f, 
    0.14988787f, 0.17786640f, 0.10078867f, 0.13339174f, -0.11270151f, -0.11877615f, -0.24813005f, 0.05957669f, 
    -0.03058668f, -0.08029467f, 0.11818586f, -0.19456293f, -0.16290881f, 0.36356992f, 0.02864100f, -0.00207331f, 
    -0.15403350f, -0.13423775f, -0.05998211f, 0.13022885f, -0.01825388f, 0.20818377f, -0.05681490f, -0.21001083f, 
    0.10008019f, -0.01786280f, 0.09043766f, 0.07778461f, 0.34709373f, 0.10795173f, 0.12992069f, -0.19169462f, 
    0.09560025f, 0.03589656f, -0.00526029f, 0.24268466f, -0.41864032f, 0.18252793f, 0.12796916f, 0.09133518f, 
    0.13434827f, -0.15877773f, 0.17282753f, 0.04489058f, -0.45417467f, 0.30168715f, 0.35980538f, -0.12444685f, 
    0.17503080f, 0.19520064f, 0.24486478f, 0.05543910f, -0.04369700f, -0.16548936f, -0.02393667f, -0.13627693f, 
    -0.17441674f, 0.07503701f, -0.00067732f, 0.15705869f, 0.20769414f, 0.14157838f, -0.05826319f, 0.23976830f, 
    -0.03171264f, -0.25655398f, 0.31633872f, 0.27774492f, 0.01321633f, -0.01393021f, -0.03160329f, -0.15892604f, 
    -0.02181967f, -0.01876563f, 0.04767443f, 0.16668907f, 0.20550349f, -0.36638165f, -0.30500263f, -0.17883274f, 
    0.22827245f, 0.28400230f, 0.03354886f, -0.04657790f, 0.28929809f, 0.02656404f, -0.15582107f, 0.40198451f, 
    0.10969461f, -0.06783222f, -0.05660584f, -0.01667805f, 0.10502177f, 0.12751392f, -0.36467713f, 0.08937661f, 
    0.04716816f, -0.13152847f, 0.16830355f, 0.19613649f, -0.18469274f, 0.09897546f, -0.01222312f, -0.09863613f, 
    0.21592855f, 0.16645491f, -0.35134566f, -0.39422229f, 0.02065402f, -0.07172883f, 0.30399320f, 0.42477331f, 
    -0.06432135f, -0.15325062f, -0.12873448f, 0.02082572f, 0.02092938f, -0.04144382f, 0.02700700f, -0.29325905f, 
    0.08631426f, -0.11415780f, 0.01296328f, 0.11228486f, 0.15943719f, 0.06114332f, 0.46170789f, -0.07033524f, 
    -0.14152603f, 0.27127880f, -0.15718806f, 0.25985509f, -0.46593136f, 0.18057510f, 0.06733339f, -0.11243035f, 
    0.23798548f, 0.06922264f, 0.30298173f, 0.35423127f, -0.18178743f, 0.43889230f, 0.35264432f, -0.11961494f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.09322388f, 0.04413188f, -0.03945104f, 0.26056731f, -0.07290922f, 0.19908860f, 0.03396101f, 0.00360071f, 
    0.28373048f, 0.00656717f, 0.03978383f, -0.09321990f, -0.12757149f, -0.22110389f, 0.00683599f, 0.04728490f, 
    0.02407611f, 0.25439054f, 0.00411516f, 0.21454510f, 0.02714372f, -0.00582151f, -0.15144366f, 0.04096727f, 
    0.02329852f, 0.06909704f, 0.19014502f, 0.19503084f, -0.00788569f, -0.09015381f, 0.20732830f, 0.13146961f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.52721775f, 0.18584658f, -0.25234762f, -0.52133965f, 0.21046814f, -0.05494751f, -0.10770724f, -0.09562434f, 
    -0.37061349f, -0.14648922f, -0.11244760f, 0.18057697f, 0.23947820f, 0.01220761f, 0.02514197f, 0.21496685f, 
    -0.33559665f, -0.12540077f, 0.11520886f, -0.27185151f, -0.44858837f, -0.17700887f, -0.16123439f, -0.31815979f, 
    0.13583536f, -0.42177957f, -0.19594973f, -0.18677710f, -0.21761914f, 0.40911010f, 0.13713856f, -0.40184709f, 
    -0.16641028f, 0.13275306f, 0.05971551f, 0.14940745f, -0.14888453f, 0.09169616f, 0.10045904f, 0.11223976f, 
    -0.14880286f, 0.33704671f, -0.92128867f, 0.22722924f, 0.31377807f, -0.00111852f, 0.00496375f, -0.17000704f, 
    0.05036944f, 0.33103943f, -0.14080568f, -0.29408926f, 0.21123162f, 0.00780305f, -0.08563147f, -0.20429906f, 
    0.14710593f, 0.09943040f, 0.32999274f, 0.10170426f, -0.23037100f, 0.13137551f, 0.21902856f, -0.41209102f, 
    0.03604871f, 0.41781837f, -0.06242500f, -0.02101282f, -0.06213162f, -0.00718466f, -0.01268289f, -0.29300502f, 
    -0.26035619f, -0.66804397f, -0.18827958f, -0.01353195f, -0.69958419f, -0.12707372f, -0.13930373f, -0.11760142f, 
    -0.10539982f, -0.22377315f, 0.40313205f, 0.20055582f, 0.24588871f, -0.31286246f, -0.09647746f, 0.26367733f, 
    -0.00299432f, -0.13154605f, -0.38032362f, 0.26644498f, 0.27376351f, -0.44149292f, 0.47325507f, 0.06835003f, 
    -0.26932862f, -0.50964409f, 0.01877019f, 0.04474082f, 0.02921963f, -0.07747680f, -0.02143625f, -0.72630018f, 
    -0.63263947f, -0.45973229f, 0.24586499f, -0.03335617f, 0.16919439f, -0.28284743f, -0.36902311f, 0.05741101f, 
    0.44117564f, -0.04954916f, 0.12773904f, -0.32288000f, -0.28940612f, -0.44962341f, 0.26784894f, -0.55876493f, 
    -0.03437591f, -0.54533398f, -0.14115508f, -0.46357992f, 0.18795614f, -0.06983609f, -0.15601672f, 0.31129059f, 
    0.38652983f, -0.15900113f, -0.29811230f, -0.57795477f, 0.16892944f, 0.21607462f, 0.05000968f, -0.03263026f, 
    0.03351266f, 0.31164736f, 0.09715272f, -0.17732172f, 0.00329486f, 0.07403868f, 0.12334695f, 0.12728520f, 
    -0.07270801f, -0.05215646f, 0.20430331f, -0.02699634f, -0.30715588f, -0.78304809f, -0.50555861f, 0.05513541f, 
    -0.03300146f, -0.12773851f, -0.20227826f, -0.17408490f, -0.15146697f, -0.31689507f, 0.04719457f, 0.03942980f, 
    -0.32605866f, 0.05588595f, -0.20326152f, -0.33459893f, 0.01400751f, 0.06691568f, 0.22675408f, 0.05279363f, 
    -0.38764346f, -0.22971860f, -0.29842067f, 0.13497822f, 0.02343882f, -0.10330544f, -0.16915014f, 0.14834638f, 
    -0.46287924f, -0.03031514f, -0.45575801f, 0.20205547f, 0.13455553f, -0.23953858f, -0.17447799f, -0.33933043f, 
    -0.05018882f, 0.29045635f, 0.10182368f, -0.26687616f, 0.25339657f, -0.06812928f, -0.21416856f, 0.32711759f, 
    0.34593049f, -0.10679058f, -0.06900960f, 0.15453184f, -0.66993994f, -0.67979056f, -0.29064924f, -0.03573237f, 
    0.25000530f, -0.39679715f, -0.27165824f, -0.18102506f, -0.55616069f, -0.15808809f, 0.42079371f, 0.16187049f, 
    0.01637357f, -0.39545736f, 0.12727903f, -0.20031784f, -0.32747191f, 0.15035497f, -0.47104639f, -0.00273645f, 
    -0.02253055f, 0.13073027f, -0.11323295f, 0.43381828f, -0.07498581f, -0.06850652f, -0.05931821f, 0.12789850f, 
    -0.17926301f, -0.20665377f, -0.09929226f, 0.03318779f, -0.35096925f, -0.40099680f, -0.26441959f, 0.05221846f, 
    -0.29865399f, -0.00105772f, 0.27345073f, 0.01740678f, -0.26507381f, -0.01559582f, -0.05359713f, -0.11608266f, 
    0.43606699f, -0.31204268f, -0.60177469f, 0.07201581f, 0.09424326f, -0.28537157f, 0.00400839f, -0.03460304f, 
    -0.65450490f, -0.07741243f, -0.50658900f, -0.01333786f, 0.26035681f, -0.15306200f, -0.06542148f, 0.20184314f, 
    -0.66321760f, -0.29164711f, -0.03277789f, 0.30717424f, -0.33925185f, 0.30971360f, 0.04682955f, -0.15061609f, 
    0.43579656f, -0.06267946f, 0.06594020f, -0.39427099f, -0.65435410f, -0.04658988f, -0.14830820f, -0.56213683f, 
    0.01442452f, -0.10793520f, -0.50442559f, -0.38344949f, -0.06359038f, -0.18053661f, 0.35097158f, -0.28759456f, 
    -0.57598001f, 0.17894353f, 0.12546583f, -0.19911084f, 0.03610852f, -0.15693158f, -0.73601067f, 0.12712738f, 
    0.19002773f, -0.48776942f, -0.01911262f, 0.04429401f, 0.16119030f, -0.45114288f, -0.54993778f, 0.09305846f, 
    -0.07586364f, -0.01083504f, 0.26251641f, 0.15596081f, -0.28865743f, 0.06925695f, -0.33552647f, 0.22303471f, 
    0.06476624f, -0.58728546f, -0.06380707f, 0.17265695f, -0.57004780f, 0.00282383f, -0.24505241f, 0.24398816f, 
    0.06472801f, 0.14406723f, -0.26632944f, -0.27168092f, -0.10044206f, -0.77134413f, 0.08913130f, -0.34291363f, 
    0.25330666f, -0.37075403f, -0.22856377f, 0.12518716f, 0.28515047f, 0.18101610f, 0.05104631f, -0.21758485f, 
    -0.12419469f, -0.58590305f, -0.46305731f, -0.75843996f, 0.23044668f, 0.08427200f, 0.09103502f, -0.47752735f, 
    -0.00219245f, -0.11560005f, 0.09313227f, -0.09492771f, 0.10485002f, -0.26240048f, 0.43710342f, -0.31029633f, 
    -0.06808117f, -0.09909962f, 0.22088191f, -0.45494309f, -0.03061794f, -0.57996804f, -0.50561875f, -0.21513210f, 
    -0.08381251f, -0.69391859f, 0.06382278f, 0.20544876f, -0.02430619f, -0.35784945f, 0.42401174f, -0.57340157f, 
    -0.16859919f, -0.06877958f, 0.41763768f, 0.22370972f, -0.11026139f, -0.03497021f, 0.29363599f, -0.16525614f, 
    -0.51914215f, -0.41158652f, -0.23786490f, 0.01231723f, 0.07128530f, 0.33572787f, -0.11828542f, -0.23286384f, 
    -0.31830344f, -0.29063973f, 0.15535662f, -0.01674112f, -0.12028943f, -0.48815110f, -0.32369205f, 0.01848149f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.08088271f, 0.17204973f, 0.28687918f, -0.12937081f, 0.12164919f, -0.03285149f, 0.08952524f, -0.15825887f, 
    0.00830513f, 0.02160183f, 0.15586862f, 0.14694326f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
