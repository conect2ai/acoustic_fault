#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.27740550f, -0.57093316f, -0.41562232f, -0.22086348f, -0.19864784f, -0.36852741f, 0.27192333f, 0.02664455f, 
    -0.26345244f, -0.05090626f, -0.23419030f, 0.08795001f, -0.36406609f, -0.05933834f, -0.17239805f, 0.03906209f, 
    -0.03954121f, -0.13105711f, -0.38444299f, 0.10102258f, -0.13199842f, -0.04536781f, 0.10558543f, -0.00470671f, 
    -0.01806630f, 0.17317712f, 0.26318011f, 0.37761375f, 0.10530908f, 0.24069199f, 0.20449625f, 0.35064986f, 
    0.25675452f, 0.34204373f, 0.47508296f, 0.04768579f, 0.19905175f, 0.16683543f, -0.23950911f, -0.02959105f, 
    0.01527460f, -0.04174535f, 0.26102296f, 0.21428922f, -0.27883971f, 0.27387702f, -0.08284698f, 0.25678247f, 
    -0.22670723f, -0.15940885f, 0.64609712f, 0.49495402f, 0.06757964f, 0.03069699f, -0.74264687f, 0.19469698f, 
    0.23488423f, -0.40277731f, -0.02658047f, 0.24703366f, 0.33656588f, 0.10085326f, -0.37012202f, 0.01252689f, 
    0.06961434f, 0.10951857f, 0.06703480f, -0.13028228f, -0.02763128f, 0.26618385f, -0.15778352f, 0.06669245f, 
    -0.05371383f, 0.04809690f, -0.08251642f, -0.55473202f, 0.60131788f, -0.09947006f, -0.37730563f, -0.13553111f, 
    -0.32893533f, 0.00417107f, 0.28499249f, -0.10925230f, -0.02586248f, 0.10994786f, 0.35838094f, -0.19394942f, 
    0.17329949f, 0.16377851f, 0.23303457f, 0.14047390f, -0.11192985f, -0.19974084f, -0.36118257f, -0.15515922f, 
    0.15842360f, 0.18695538f, -0.04665399f, 0.35161522f, 0.78437400f, 0.71827650f, 0.44664297f, -0.57322431f, 
    -0.07594526f, -0.38770571f, 0.31153455f, 0.16408689f, -0.06978238f, 0.30399761f, -0.00900214f, 0.13956280f, 
    0.00527573f, -0.09796400f, -0.23094456f, 0.06785934f, -0.04115793f, -0.14804938f, -0.22524986f, -0.05937397f, 
    -0.08864138f, 0.01588903f, -0.18540394f, 0.01488974f, -0.14743543f, -0.31784776f, -0.56964159f, -0.38338262f, 
    -0.04703473f, -0.24504013f, -0.21214411f, 0.47522393f, -0.53337759f, -0.27344257f, 0.27445331f, 0.00045181f, 
    0.26606402f, 0.12350922f, 0.19320408f, 0.32684037f, 0.06097597f, 0.10583403f, 0.26581249f, 0.05078484f, 
    0.15391186f, 0.24911152f, 0.05315836f, -0.19952594f, 0.07761000f, 0.23784409f, -0.44982621f, -0.48397732f, 
    -0.12482078f, -0.11635488f, 0.63599783f, 0.07766395f, 0.10073650f, -0.38282239f, 0.04764914f, -0.17321265f, 
    0.43370444f, 0.21107529f, 0.00229123f, -0.05546258f, 0.28178924f, 0.35833254f, 0.23744290f, 0.06620118f, 
    0.27158734f, 0.21071833f, -0.21563876f, 0.01928969f, -0.01854738f, 0.22701043f, 0.08018260f, 0.46988526f, 
    0.61270922f, 0.51421928f, 0.23833410f, 0.52375299f, -0.34235272f, 0.17779735f, -0.09777272f, -0.64899659f, 
    -0.22065562f, 0.18431896f, 0.05758765f, -0.12060146f, 0.07773782f, 0.25917721f, -0.07447924f, 0.10250508f, 
    0.10175487f, 0.21516059f, 0.14964928f, -0.04023078f, 0.05140491f, 0.08055218f, 0.29910171f, 0.16488503f, 
    0.26765609f, 0.10883629f, 0.09478591f, 0.49955904f, 0.24943677f, 0.25241101f, 0.47276399f, 0.49702770f, 
    0.31235638f, 0.28901637f, -0.36035815f, -0.21817657f, -0.28783548f, 0.01286875f, 0.10955635f, -0.09622116f, 
    -0.27338326f, 0.09775437f, 0.02311318f, 0.09596504f, 0.10580353f, -0.15304488f, -0.02642401f, 0.04775144f, 
    0.08339790f, 0.08257951f, -0.30737001f, -0.59090537f, -0.50702322f, -0.43122196f, 0.56413436f, 0.75450587f, 
    0.12431165f, -0.02133313f, 0.17780334f, -0.01632906f, -0.14451715f, -0.17186019f, -0.19640535f, -0.01460498f, 
    -0.24491265f, 0.08593100f, 0.24619687f, 0.19410208f, -0.08285515f, -0.10635085f, -0.06103840f, -0.08553366f, 
    -0.22650187f, 0.02572398f, -1.06952560f, 0.21988194f, -0.05213995f, -0.03555805f, -0.29033121f, 0.20549375f, 
    0.68512589f, 0.06435921f, 0.34246019f, 0.45131168f, -0.33361226f, 0.09165554f, 0.22500852f, -0.21039537f, 
    0.02187653f, -0.05181088f, 0.00656991f, 0.01975450f, -0.03651019f, -0.13221915f, -0.01277022f, -0.00910870f, 
    0.03042751f, -0.05180283f, 0.03935146f, -0.24238043f, -0.63194501f, 0.55783510f, 0.46581972f, -0.66329068f, 
    0.05452855f, -0.14649826f, 0.17404799f, -0.43209255f, -0.38607436f, -0.17358015f, -0.09671564f, -0.06430228f, 
    0.17784911f, 0.12710617f, -0.05742449f, 0.31518337f, -0.04445341f, 0.07040644f, -0.15464911f, -0.02979672f, 
    0.08583193f, 0.06589453f, 0.08800220f, 0.08281597f, -0.11443803f, -0.80069560f, -0.27185464f, 0.13362737f, 
    0.30089664f, -0.68381882f, 0.58647788f, 0.07755044f, -0.44548291f, 0.13517185f, 0.29307011f, -0.00262284f, 
    -0.04414383f, -0.15375048f, -0.08791702f, -0.28872755f, -0.01828699f, -0.00616495f, -0.09398876f, -0.16743559f, 
    -0.04706901f, -0.14013955f, 0.06472949f, -0.09270277f, -0.04839336f, 0.82462877f, 0.10870917f, 0.28897336f, 
    0.69596803f, 0.80348694f, 0.19116639f, -0.14078322f, -0.30202532f, 0.08276480f, 0.07942304f, 0.10931786f, 
    0.20325509f, -0.15306471f, 0.00018143f, -0.28541517f, -0.03111470f, -0.08990525f, -0.04149226f, -0.13945219f, 
    -0.22410263f, 0.09895577f, -0.06747627f, -0.05203484f, -0.07975736f, 0.03783872f, -0.13451691f, -0.23153909f, 
    -0.12893331f, 0.38934132f, -0.07818081f, -0.12124286f, 0.47192562f, 0.70259368f, -0.14758395f, -0.02348557f, 
    0.10914199f, 0.21920222f, 0.34625751f, 0.08649319f, 0.15201104f, -0.11000252f, -0.33533961f, -0.23744377f, 
    -0.10451804f, -0.37411365f, 0.04886610f, -0.04988690f, -0.07987450f, 0.41125852f, 0.01330452f, -0.47717687f, 
    0.56722754f, 0.49958017f, 0.52945250f, 0.18663377f, 0.29082718f, 0.19933696f, 0.25100538f, -0.15557721f, 
    -0.05290110f, 0.02054399f, -0.13338529f, -0.14513081f, -0.03958290f, -0.16670783f, 0.24868341f, 0.25306171f, 
    -0.29163614f, -0.22650295f, -0.13119206f, -0.14294337f, 0.07149785f, -0.10585085f, 0.23831756f, -0.26679012f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25618342f, 0.05007022f, 0.09751806f, -0.02362770f, 0.25778273f, -0.07404987f, 0.25722036f, -0.01970986f, 
    0.10991176f, 0.14611343f, -0.11571225f, 0.14181802f, 0.28441569f, 0.13821433f, 0.18877900f, -0.10002535f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01271398f, -0.14027975f, -0.21676128f, -0.03756675f, 0.11396310f, -0.11296171f, 0.00390584f, -0.06434154f, 
    0.06560793f, 0.01152577f, 0.01824554f, 0.00333046f, 0.30372825f, -0.03898611f, 0.08307677f, 0.10172488f, 
    0.06557704f, 0.01081464f, -0.00795492f, 0.04405663f, 0.06941598f, 0.04219605f, 0.03533548f, -0.04032855f, 
    0.23141292f, 0.07339815f, 0.00304412f, 0.00825583f, 0.03496556f, 0.00797777f, 0.03044184f, -0.07597761f, 
    0.04348880f, -0.06148798f, 0.02947831f, -0.04198803f, -0.14892226f, -0.01142801f, -0.13406438f, 0.02869842f, 
    -0.01865125f, 0.09710746f, 0.01200039f, 0.07681117f, 0.04163280f, -0.00746329f, 0.11482064f, 0.04916883f, 
    0.28861132f, 0.23677412f, -0.02392996f, 0.04455363f, 0.04815314f, -0.03055681f, 0.00972938f, -0.01545930f, 
    -0.01786284f, -0.06462991f, 0.09624167f, 0.09289545f, -0.14902891f, -0.17773651f, -0.08537310f, 0.06074808f, 
    0.19605897f, 0.04465895f, 0.14357752f, -0.03087955f, -0.01906870f, -0.04642308f, 0.06368515f, -0.04880218f, 
    0.05911073f, -0.02124751f, -0.04699186f, -0.04138107f, 0.01904984f, 0.00880887f, -0.04070763f, -0.07389078f, 
    -0.11472195f, -0.02461439f, -0.10804641f, 0.05949960f, 0.22456868f, 0.11072835f, -0.11155458f, 0.09951258f, 
    0.11129811f, 0.12221424f, 0.00992347f, -0.04543382f, -0.02548772f, 0.08284683f, 0.10292564f, 0.05831035f, 
    0.16126978f, 0.01593899f, 0.09215900f, -0.06201290f, 0.09289337f, 0.07068006f, -0.03778513f, 0.09153654f, 
    -0.01757660f, 0.02403851f, -0.11549089f, -0.02075209f, -0.00740691f, -0.07570808f, -0.07841101f, 0.06702851f, 
    0.12586723f, 0.00525315f, -0.17271191f, 0.04999382f, 0.10595064f, -0.07501626f, -0.00692006f, -0.08122336f, 
    -0.37417978f, -0.38687029f, -0.04472576f, 0.02615848f, 0.02502742f, 0.00688522f, 0.02395788f, 0.01384208f, 
    -0.06558606f, -0.03834933f, -0.01147530f, 0.04778535f, -0.14439899f, 0.05191857f, -0.05823324f, -0.10598394f, 
    -0.08812237f, 0.04225815f, -0.03380959f, 0.00318767f, -0.05581085f, 0.06478287f, -0.00758120f, 0.09634546f, 
    0.19874522f, -0.11261013f, -0.12738229f, -0.01165523f, 0.06511846f, 0.00776243f, 0.11255625f, 0.01393473f, 
    -0.03570426f, -0.03143979f, 0.13212720f, -0.04358319f, 0.00947198f, 0.16972098f, 0.21995717f, -0.16910549f, 
    0.03568882f, 0.05923084f, -0.00390415f, 0.08294529f, 0.03421728f, -0.07616346f, -0.06509802f, 0.04836713f, 
    0.04401820f, 0.05646856f, 0.09649059f, 0.08298103f, 0.02360314f, 0.05822356f, 0.08848777f, 0.02806889f, 
    -0.00552327f, -0.00406299f, 0.02976144f, -0.02373125f, 0.09274657f, -0.00782555f, 0.13711274f, -0.04561213f, 
    -0.04090531f, 0.06825925f, -0.05651867f, -0.00458653f, 0.02687984f, 0.03975482f, -0.00059847f, -0.09146905f, 
    0.19019890f, 0.07962956f, 0.09576903f, 0.00103907f, 0.08782898f, -0.03728686f, 0.04016384f, 0.04841072f, 
    0.06059803f, 0.06171481f, 0.13474789f, -0.07377160f, -0.14709546f, 0.07608790f, -0.09348939f, -0.14527822f, 
    0.05721266f, 0.02631098f, -0.03151958f, 0.00772995f, 0.01610168f, -0.06821732f, 0.00761130f, 0.09638058f, 
    -0.09006464f, -0.08090419f, 0.16643605f, 0.09582461f, 0.14836913f, -0.08464284f, 0.02925227f, 0.01285502f, 
    0.12175056f, 0.07402544f, 0.05716364f, 0.11808687f, 0.11267304f, -0.06964776f, 0.05190430f, 0.11763164f, 
    -0.02388551f, 0.12090498f, 0.07094534f, -0.01366658f, -0.11110969f, -0.01767156f, -0.02439971f, -0.01605448f, 
    -0.01524113f, -0.17012984f, 0.05861342f, 0.03276921f, 0.00366078f, 0.07884376f, 0.02836868f, -0.04888092f, 
    0.15141213f, -0.01122431f, 0.05724934f, -0.04223405f, 0.11052670f, -0.00489284f, -0.06034471f, -0.00180812f, 
    -0.05847509f, 0.05062259f, 0.07362368f, -0.03721593f, -0.02473434f, -0.03153148f, 0.05694130f, 0.00351301f, 
    0.24201010f, 0.12823297f, 0.13794109f, 0.18657483f, 0.14011225f, -0.02165249f, 0.12123005f, 0.02452361f, 
    -0.00761335f, 0.06224404f, 0.12176491f, -0.04031250f, 0.07259194f, -0.18966886f, -0.29390195f, -0.08320808f, 
    -0.00689960f, -0.01946650f, -0.07442784f, 0.04069375f, 0.15771529f, 0.02969070f, 0.00308876f, -0.05186667f, 
    -0.35444278f, -0.10536037f, -0.07650080f, -0.20193209f, 0.07620215f, -0.01602475f, 0.02061593f, 0.06505124f, 
    -0.01884451f, -0.01442445f, -0.07656850f, 0.02389354f, 0.15855013f, 0.00468753f, 0.05927406f, 0.16793889f, 
    -0.04492325f, -0.01317422f, 0.07514564f, -0.00569433f, -0.00047764f, 0.00588938f, 0.08626169f, 0.00450509f, 
    0.07308194f, 0.12159056f, -0.02047514f, 0.07742157f, 0.02069133f, 0.04432302f, 0.03092520f, 0.09833001f, 
    0.05736248f, 0.00794739f, 0.12754814f, -0.11137377f, 0.07790120f, -0.00773628f, 0.24289189f, 0.19790158f, 
    0.08575758f, -0.01686455f, 0.07352268f, -0.02317431f, 0.06643447f, 0.01092147f, 0.13076524f, -0.14525987f, 
    -0.07698645f, 0.04013402f, -0.07996989f, 0.07186644f, 0.09501987f, 0.04834256f, 0.14442463f, 0.04263167f, 
    -0.06428636f, 0.08951537f, 0.00471169f, -0.07919822f, -0.13137317f, 0.00567476f, -0.28309399f, -0.20111276f, 
    0.17026258f, -0.00759393f, -0.05169651f, 0.01902392f, 0.02270223f, -0.02100459f, 0.05680175f, 0.04289665f, 
    -0.23887040f, 0.18204762f, 0.01485277f, -0.04978188f, -0.01425872f, 0.05973904f, -0.00314216f, 0.05824905f, 
    0.19226092f, 0.07272313f, 0.01882217f, 0.02789929f, -0.30805251f, 0.00450358f, 0.04309822f, -0.20517935f, 
    0.04122870f, 0.06483136f, -0.13123919f, -0.07014566f, -0.03342143f, -0.01894416f, -0.07363431f, 0.10835855f, 
    -0.04874744f, 0.11835431f, 0.06055829f, 0.07708450f, 0.11956201f, 0.04327246f, 0.01587881f, 0.00194581f, 
    0.08347205f, -0.07707756f, -0.07873823f, -0.04123043f, 0.30987760f, 0.02286315f, -0.12974036f, 0.02745177f, 
    0.06138189f, -0.00837452f, 0.07151466f, 0.01131536f, -0.00559069f, -0.00136771f, 0.08515169f, -0.07896604f, 
    0.38132101f, -0.02492382f, -0.15976214f, -0.04131582f, 0.05551690f, 0.01559520f, -0.07965570f, -0.08307673f, 
    0.01904036f, 0.02867540f, -0.03869255f, 0.13572018f, 0.04572345f, 0.09945253f, 0.05288856f, 0.15399618f, 
    0.10144588f, -0.03374257f, -0.09537622f, 0.09629268f, 0.08319186f, 0.02812255f, 0.08645463f, -0.01292654f, 
    0.60801655f, 0.02686725f, -0.02897523f, -0.06062239f, 0.05284301f, -0.10753573f, -0.07893690f, -0.03901368f, 
    0.07404144f, 0.02489853f, -0.07924239f, 0.06429713f, 0.08255988f, 0.08824120f, -0.06563640f, 0.04872124f, 
    0.06848263f, 0.09864728f, 0.06001864f, -0.13635410f, 0.06608016f, 0.06002196f, 0.02222683f, -0.05804116f, 
    -0.02884672f, -0.00202143f, 0.10453121f, 0.10744528f, -0.03316650f, -0.04959326f, -0.02108310f, -0.13500261f, 
    -0.09765665f, 0.05885633f, -0.01565906f, 0.17147821f, 0.49221218f, -0.20787323f, -0.31583986f, 0.08433077f, 
    0.08622041f, 0.00924454f, -0.04892740f, -0.07430272f, -0.02165568f, -0.01905311f, 0.06723767f, 0.13329521f, 
    0.02629691f, 0.05117249f, -0.08210734f, -0.07513639f, 0.02579819f, 0.00287713f, 0.00272603f, -0.06309852f, 
    -0.03292444f, -0.06332713f, -0.07532659f, -0.10896537f, 0.08409674f, 0.15245675f, -0.11509378f, 0.13728504f, 
    0.00527652f, 0.01165900f, -0.16164285f, 0.10270227f, 0.00081505f, -0.08974317f, -0.02086139f, -0.13635033f, 
    -0.07735397f, -0.35569569f, 0.22380233f, 0.15126595f, 0.05092432f, -0.00294314f, -0.02221356f, -0.12759529f, 
    -0.01796754f, -0.06473163f, -0.01649275f, -0.01159555f, 0.06583466f, -0.02269014f, 0.10862764f, -0.00451409f, 
    -0.13740760f, -0.18414377f, -0.09178956f, 0.15682422f, 0.06381230f, 0.01079839f, 0.15194401f, 0.04676960f, 
    -0.20794109f, 0.02557416f, -0.14434208f, -0.05193074f, 0.05901773f, -0.03364768f, 0.09244078f, -0.12314985f, 
    -0.00457750f, 0.02866936f, 0.02651491f, -0.08059169f, -0.07760026f, -0.01884939f, -0.11369019f, -0.02173837f, 
    0.23603731f, -0.03573126f, 0.03036280f, -0.00061266f, -0.08147500f, -0.00892441f, -0.10533804f, 0.00785180f, 
    -0.06155235f, 0.07259597f, 0.04723510f, 0.00941949f, 0.01425978f, 0.07713351f, 0.05748859f, 0.00738758f, 
    0.09042319f, 0.09155557f, 0.03904782f, -0.01190440f, -0.13046694f, -0.06905694f, 0.28632665f, -0.11730012f, 
    0.02718275f, -0.02718592f, -0.13738702f, -0.06572258f, 0.15615955f, 0.03190355f, -0.15083410f, 0.06385864f, 
    0.14263974f, 0.12642661f, 0.02294497f, 0.12577613f, 0.06967854f, 0.17607826f, 0.00975884f, 0.14890879f, 
    0.01812403f, 0.09066702f, 0.10000083f, -0.02904727f, -0.08274913f, 0.03303806f, -0.05435663f, -0.06662172f, 
    0.12097184f, 0.04301218f, -0.04360507f, -0.16733420f, -0.07131874f, -0.04480835f, 0.01143569f, -0.06241434f, 
    -0.34409779f, 0.18660721f, 0.06039196f, 0.16542080f, 0.11176938f, 0.18495312f, 0.15198347f, 0.03707694f, 
    0.11356550f, 0.03256523f, 0.09742238f, 0.06629291f, 0.02313484f, -0.11807941f, 0.20466441f, 0.19790739f, 
    0.01809512f, -0.02240674f, -0.10902294f, 0.10839760f, -0.07241992f, -0.04489409f, -0.05640981f, 0.00979750f, 
    -0.32513201f, -0.26289287f, -0.00611829f, 0.28647310f, 0.06694564f, 0.13483836f, 0.03969466f, 0.02589735f, 
    0.01341451f, -0.08303458f, 0.08464742f, 0.04393123f, -0.09296913f, -0.24223652f, 0.01440521f, -0.17734180f, 
    0.01686281f, 0.04143508f, -0.04275679f, -0.01476282f, -0.03886910f, 0.08750888f, -0.06900249f, -0.06660543f, 
    0.21574178f, 0.02031415f, -0.14373456f, 0.04268630f, 0.12288250f, 0.04727913f, 0.01520958f, -0.08980171f, 
    -0.00936813f, 0.06471843f, -0.04227597f, -0.02454838f, -0.11714044f, -0.19858415f, 0.01689965f, -0.18156871f, 
    0.15849991f, -0.05438731f, -0.02945793f, -0.13692667f, -0.00024016f, -0.14886634f, -0.00859092f, -0.00900141f, 
    -0.25428179f, 0.02945889f, -0.11134098f, -0.35971248f, -0.00823107f, 0.03576544f, -0.06695539f, -0.11171592f, 
    -0.04429268f, -0.10501525f, 0.15231618f, 0.11190953f, -0.20864993f, 0.08721392f, -0.01616750f, 0.10937355f, 
    -0.01910017f, 0.08237877f, 0.03080896f, 0.10700930f, 0.07507636f, 0.07312067f, -0.08997403f, 0.07240058f, 
    0.49223077f, -0.06416134f, 0.03697991f, -0.01153599f, -0.07495333f, 0.02780857f, 0.04655199f, 0.18596265f, 
    -0.00799256f, -0.03041211f, 0.17017238f, 0.08677098f, 0.52222335f, -0.09559231f, -0.03607757f, 0.01519326f, 
    0.11434188f, -0.12667097f, 0.01241716f, 0.06844808f, 0.03114147f, -0.02404937f, 0.04814297f, 0.04494210f, 
    0.16515903f, -0.13039823f, 0.22614782f, -0.04607979f, 0.01181987f, 0.07179911f, 0.06734907f, 0.04751930f, 
    0.02952699f, 0.07811093f, 0.06652208f, 0.02431137f, -0.25079474f, 0.19086327f, -0.04160511f, -0.16518925f, 
    0.17650376f, -0.06080336f, -0.04427053f, -0.15308335f, 0.08119058f, -0.01138315f, 0.11076047f, 0.00303245f, 
    0.23659180f, 0.03914693f, 0.15454568f, -0.08846079f, -0.07674357f, 0.02135202f, 0.07660951f, 0.00299396f, 
    0.05726559f, 0.04545495f, -0.11219127f, -0.06073463f, 0.17177206f, -0.03855938f, -0.00460358f, -0.00680765f, 
    0.14151271f, -0.12194125f, -0.06538969f, 0.05712722f, 0.00072892f, -0.06926239f, 0.01474231f, 0.01737147f, 
    -0.11542092f, -0.12341264f, 0.19749582f, -0.13190404f, -0.22493298f, -0.03034125f, -0.05834623f, -0.02599021f, 
    0.03338473f, -0.05012895f, -0.03692816f, 0.10361613f, 0.20655729f, 0.07088067f, -0.02959789f, 0.24677910f, 
    -0.03590403f, 0.00092421f, 0.02601362f, -0.02116782f, 0.01525787f, 0.08664833f, 0.04106971f, -0.07653880f, 
    0.08906417f, -0.06117332f, -0.14736041f, 0.00242551f, -0.05366194f, -0.07559305f, 0.03303638f, -0.00020571f, 
    -0.05740805f, -0.10295060f, 0.01038700f, 0.11745115f, -0.03046259f, 0.17249772f, -0.04469472f, -0.37630510f, 
    0.01406072f, -0.03812297f, 0.05273914f, 0.06353419f, 0.02719794f, 0.02164259f, -0.00330514f, -0.04531536f, 
    0.07315791f, 0.09749672f, -0.22677809f, -0.09203293f, 0.14910208f, 0.04149100f, 0.05183890f, 0.00826928f, 
    0.11790481f, 0.07966138f, -0.02131351f, 0.11705703f, 0.15480453f, 0.16740949f, 0.06572905f, 0.09458019f, 
    -0.02130241f, -0.04623339f, -0.01961658f, -0.00086159f, 0.11247227f, -0.00230292f, 0.02462783f, 0.05275777f, 
    -0.07718007f, -0.11829434f, 0.02691754f, 0.06716444f, -0.05965053f, -0.12548114f, -0.10609522f, 0.00066449f, 
    0.13352393f, 0.01191112f, -0.06082743f, 0.04069375f, -0.10250729f, 0.07100391f, 0.10390168f, 0.11373901f, 
    0.16435464f, -0.06757861f, -0.04377015f, -0.07272250f, 0.01948045f, 0.01921769f, 0.01198827f, 0.03152866f, 
    0.10887011f, 0.00158750f, -0.11307092f, 0.30709425f, 0.08561798f, -0.09140132f, 0.14058226f, 0.05263443f, 
    -0.03837709f, 0.16089994f, -0.01227131f, -0.01459689f, -0.06132255f, -0.03041002f, 0.12650564f, 0.03992346f, 
    -0.11973047f, -0.08346228f, 0.01846982f, 0.00832716f, 0.00530895f, -0.05096596f, 0.05759043f, 0.00324251f, 
    0.16018599f, 0.05180850f, 0.09948062f, 0.05237034f, -0.09194837f, -0.05863257f, 0.01107057f, 0.01614899f, 
    0.09021489f, 0.10960499f, -0.00086910f, -0.00096843f, -0.21737666f, -0.30052879f, -0.12249532f, -0.35966378f, 
    0.04658637f, -0.03512105f, 0.04490461f, -0.01138132f, 0.11318887f, 0.05151447f, -0.07624923f, 0.24698284f, 
    0.28304043f, -0.03283978f, 0.13326354f, 0.04036963f, -0.05602366f, -0.04920918f, -0.02450905f, 0.07386450f, 
    -0.01532902f, 0.08564799f, 0.06977975f, 0.17065623f, 0.05783422f, -0.02711470f, 0.08053161f, 0.38001984f, 
    0.04344412f, 0.06195791f, -0.12030634f, -0.00024734f, 0.06272315f, 0.00393337f, 0.03918972f, -0.05914041f, 
    0.33633342f, -0.15184338f, -0.02393317f, 0.16084683f, 0.18423985f, -0.03977267f, 0.06640448f, -0.04887797f, 
    0.03647212f, 0.13383819f, 0.05560108f, -0.01958379f, 0.22908989f, -0.11923166f, -0.09965698f, 0.05450847f, 
    0.00501243f, 0.01241282f, -0.09548058f, -0.04969429f, -0.04074545f, -0.09631804f, 0.09512740f, 0.01866323f, 
    -0.05352359f, 0.04428769f, -0.02062155f, -0.05047420f, 0.04649580f, -0.06415482f, -0.00930137f, -0.03306304f, 
    -0.00758611f, -0.04688082f, 0.01901332f, -0.06222299f, 0.00149988f, -0.00885458f, 0.02008459f, 0.06588680f, 
    -0.07676897f, -0.03237154f, -0.02841194f, 0.05507732f, -0.06951153f, -0.06057077f, 0.03848841f, 0.01456328f, 
    0.02431440f, 0.04054618f, -0.06941767f, -0.03234122f, -0.00238110f, 0.01755005f, 0.04500606f, -0.07350493f, 
    -0.07089266f, 0.01774915f, 0.05388825f, -0.03648939f, 0.05660857f, -0.02555081f, -0.07021152f, -0.04218873f, 
    0.05596193f, 0.02208472f, 0.01905439f, -0.05136696f, 0.01478339f, 0.01164780f, 0.03663940f, -0.07029834f, 
    0.05659813f, -0.03209295f, 0.03163819f, 0.03342989f, -0.07049064f, -0.05210884f, -0.04939973f, -0.07170913f, 
    0.03318876f, 0.00380833f, 0.02637514f, 0.01112967f, -0.06384377f, -0.02810209f, 0.02933763f, -0.05679584f, 
    0.04892216f, -0.05056663f, 0.04440511f, 0.01258764f, -0.01704788f, -0.06531674f, -0.05133559f, -0.00901921f, 
    0.02964992f, -0.02018360f, -0.07158259f, 0.03443803f, -0.04579379f, 0.05220269f, 0.00209389f, -0.02359346f, 
    -0.03100497f, -0.06416889f, -0.02216362f, 0.03683982f, -0.06750070f, 0.04968535f, -0.01913534f, 0.06293599f, 
    0.00160361f, -0.06293996f, 0.00105359f, -0.01493966f, 0.02306335f, 0.05683352f, 0.01229078f, 0.04907427f, 
    -0.02496678f, 0.00878956f, -0.04382795f, -0.02139072f, 0.01990622f, 0.06463148f, 0.00431876f, -0.06406159f, 
    0.01454720f, 0.02030850f, -0.04322676f, -0.05667484f, -0.00600455f, -0.04330007f, 0.05947449f, 0.05239334f, 
    -0.03819093f, -0.02440277f, -0.01265936f, -0.02046546f, -0.00190287f, 0.00724764f, 0.05460860f, -0.03845601f, 
    -0.06465229f, -0.05953402f, 0.02315240f, -0.05176807f, -0.03266294f, 0.04927154f, 0.02763600f, 0.01031621f, 
    -0.06365731f, 0.02790598f, -0.06169403f, -0.06264749f, -0.02491016f, -0.03327901f, -0.01784214f, -0.05555397f, 
    0.02422303f, -0.06506611f, 0.00637348f, -0.07178154f, 0.05518235f, 0.03885641f, 0.04269008f, 0.01006020f, 
    -0.00550663f, -0.01774378f, -0.06510354f, -0.01194680f, 0.05730915f, -0.03864104f, -0.00782939f, -0.00566706f, 
    0.01768603f, 0.04834339f, -0.02248239f, 0.00858912f, -0.04552112f, -0.04683945f, 0.00443726f, -0.07702907f, 
    -0.02118116f, 0.00050740f, -0.03053459f, 0.04730454f, 0.03674975f, 0.02253724f, -0.03485209f, 0.06912117f, 
    -0.01787813f, -0.01613431f, 0.02232863f, -0.01639280f, -0.03043351f, 0.02472194f, 0.04301661f, -0.04736618f, 
    -0.06462231f, -0.07015158f, 0.01427559f, -0.02364988f, -0.03806749f, 0.04614997f, -0.03469125f, 0.06132544f, 
    -0.05393465f, -0.06081755f, -0.03008386f, -0.05358242f, -0.01134165f, -0.02644871f, -0.02979732f, -0.02051329f, 
    0.02182552f, 0.02488991f, 0.04857810f, -0.01912886f, -0.05866618f, 0.04019703f, -0.07783206f, -0.00271413f, 
    -0.00363875f, -0.01091301f, 0.01089712f, -0.02354989f, 0.00013771f, 0.03445458f, 0.01314045f, -0.04302589f, 
    0.02417885f, 0.04334787f, -0.06882179f, -0.01041417f, -0.03296140f, 0.02582217f, 0.02131484f, -0.05357388f, 
    0.03661213f, -0.04070084f, 0.04369076f, -0.05094478f, -0.04894505f, 0.02194228f, 0.02059518f, -0.02375282f, 
    -0.07616806f, 0.01808683f, -0.07567959f, 0.03769266f, 0.01207050f, 0.00231905f, -0.06849240f, 0.03172460f, 
    0.04743399f, 0.06232873f, -0.04613367f, 0.05561355f, -0.02986015f, 0.05899030f, -0.03913074f, -0.07765683f, 
    -0.07471908f, -0.04432131f, 0.00114333f, -0.05985830f, 0.00688452f, 0.02745049f, -0.02983767f, -0.04539056f, 
    -0.05560840f, -0.02621944f, -0.06353993f, 0.03542732f, 0.03789593f, 0.01285006f, -0.04488730f, 0.04923406f, 
    -0.05612174f, 0.03461866f, -0.01782390f, -0.00711146f, 0.04334214f, 0.02322763f, -0.05768085f, -0.05521605f, 
    -0.07278587f, 0.04738250f, -0.05082406f, -0.04546703f, 0.02378843f, -0.03834724f, 0.00852954f, 0.00065669f, 
    -0.01482760f, -0.05429467f, 0.00827128f, -0.00898027f, 0.04079773f, 0.03948981f, 0.00408441f, -0.02586092f, 
    0.01809395f, 0.04218792f, -0.03154191f, 0.00258876f, -0.03087378f, 0.04303744f, -0.00564070f, -0.03299155f, 
    0.00131269f, 0.03239280f, -0.06806637f, 0.01310044f, 0.00782592f, -0.02188586f, 0.01738557f, 0.00544784f, 
    0.05357412f, 0.03813316f, -0.00933179f, -0.05246034f, 0.04420485f, 0.05822518f, -0.07528630f, -0.06440715f, 
    -0.04880130f, -0.06212600f, -0.03452812f, 0.00229571f, -0.05425295f, -0.00637604f, -0.01370460f, 0.00519215f, 
    -0.00768306f, 0.03133429f, 0.05573548f, 0.00340085f, 0.05747368f, -0.05759330f, -0.00565519f, -0.02095187f, 
    0.01714857f, -0.02266822f, -0.04206356f, 0.03692607f, 0.03834266f, 0.04847097f, 0.00068527f, 0.02355304f, 
    0.03892541f, 0.06436256f, -0.02403147f, -0.02999220f, -0.04312743f, 0.02629608f, -0.03992469f, -0.06196322f, 
    0.04354264f, -0.01167441f, -0.07517912f, -0.01028128f, -0.04834935f, 0.00115619f, -0.07165211f, 0.00159096f, 
    -0.06716765f, -0.00195204f, -0.05578260f, 0.01143995f, -0.05736000f, -0.04816936f, 0.02924924f, -0.07826123f, 
    0.00418115f, -0.07999220f, -0.05850529f, -0.01552767f, -0.03034250f, -0.05131758f, -0.05529603f, 0.03765151f, 
    0.00514572f, 0.01613970f, 0.00052450f, 0.00692274f, 0.00848316f, -0.03980366f, 0.02782089f, -0.04048292f, 
    -0.01263921f, -0.04851234f, -0.07425295f, -0.06837015f, 0.03741803f, 0.00686451f, 0.03134825f, -0.01248151f, 
    0.04555287f, -0.02004493f, 0.05962054f, 0.03942392f, 0.00199854f, -0.00425605f, -0.05659896f, -0.05309979f, 
    -0.02142487f, -0.16798614f, -0.06762441f, -0.09911141f, -0.16342235f, -0.07859586f, -0.01564049f, -0.16240929f, 
    0.00264732f, -0.02016216f, -0.01327080f, 0.02947726f, 0.19379829f, 0.10155629f, 0.03337040f, 0.10885286f, 
    0.08786187f, -0.00001273f, -0.03139342f, 0.03034692f, 0.06609675f, 0.04034610f, -0.00390407f, 0.00695232f, 
    0.33312067f, 0.06392692f, -0.14421250f, 0.06457493f, -0.01427998f, 0.05286154f, 0.01429686f, 0.01106611f, 
    0.00290839f, 0.03440361f, -0.03956671f, 0.03765254f, -0.26598606f, 0.12601472f, -0.04505058f, -0.12972397f, 
    0.05188551f, 0.03010914f, -0.08645146f, -0.02650632f, 0.08745812f, 0.15662983f, 0.08139655f, 0.00614862f, 
    -0.03046899f, 0.32782447f, -0.19289421f, 0.01124893f, 0.06819538f, -0.06560271f, -0.07910882f, 0.08202261f, 
    0.17901362f, 0.01384203f, 0.03542302f, 0.08619555f, 0.07287902f, 0.01579019f, -0.14342187f, 0.00580276f, 
    0.07879088f, 0.01130701f, 0.10705030f, -0.01343626f, 0.05892695f, -0.02948507f, 0.18984902f, 0.01969051f, 
    -0.20323655f, -0.12457573f, 0.05404074f, -0.07353793f, -0.06780782f, -0.03913194f, -0.12450489f, 0.00824395f, 
    -0.03684343f, 0.03300760f, -0.10241707f, 0.12467246f, 0.05140989f, 0.22604263f, 0.19568314f, 0.11971299f, 
    -0.04896405f, 0.02663695f, 0.10006374f, 0.09361997f, -0.02301367f, 0.01659323f, -0.06942870f, 0.04126933f, 
    0.16878319f, -0.09866256f, 0.04258515f, 0.21595624f, -0.04922165f, 0.12662311f, -0.00922678f, 0.06142808f, 
    -0.05045689f, -0.00420870f, -0.01884490f, 0.00967734f, 0.27841756f, -0.05022631f, -0.11817138f, -0.24410795f, 
    0.11207339f, 0.01711449f, 0.05920888f, 0.05035907f, -0.03944080f, 0.03511107f, -0.02194931f, 0.00492002f, 
    0.12875360f, 0.12344229f, -0.04417471f, 0.01124743f, 0.00970879f, 0.10747441f, 0.00563410f, -0.01229148f, 
    0.05732462f, -0.00383418f, 0.01378262f, 0.03493825f, -0.28086120f, -0.11576138f, 0.05783083f, 0.09340380f, 
    0.00622883f, 0.02866163f, 0.11730020f, -0.00574178f, 0.10319377f, 0.10836747f, 0.04773568f, -0.04817283f, 
    0.16001943f, 0.12763372f, 0.06279186f, -0.01200172f, 0.02345057f, 0.00176593f, 0.02929974f, 0.00680502f, 
    0.15599352f, 0.01645574f, 0.13615772f, 0.11682650f, 0.15654689f, -0.02480280f, 0.26760426f, 0.28510359f, 
    -0.06426197f, 0.08224948f, 0.06440091f, 0.02376357f, 0.13585716f, 0.04581329f, -0.04288446f, -0.00008206f, 
    -0.02454510f, -0.08400896f, 0.02433408f, 0.04766409f, 0.02191023f, 0.03760397f, 0.09912983f, -0.05987458f, 
    0.17329559f, 0.02048761f, 0.12026805f, 0.07419886f, 0.05488094f, 0.02667962f, 0.19671029f, 0.10056356f, 
    0.01720958f, 0.01476028f, 0.00264320f, 0.05383996f, 0.13633701f, 0.04510415f, -0.02462465f, -0.01655139f, 
    -0.04947905f, 0.12861250f, 0.29051387f, 0.22019537f, 0.19711493f, 0.04183033f, 0.07446285f, 0.13962762f, 
    -0.07948928f, -0.00399133f, 0.06284723f, 0.11082208f, 0.03797024f, 0.01608892f, -0.02535372f, -0.12323198f, 
    -0.06149106f, 0.05360038f, -0.02749617f, 0.05231490f, 0.01154610f, 0.01868333f, 0.00608737f, 0.12145273f, 
    -0.16186944f, -0.21181040f, -0.05417116f, -0.21953617f, 0.03449833f, 0.06389296f, -0.13903116f, -0.02220934f, 
    -0.02761836f, 0.07499070f, -0.00579792f, 0.10484327f, 0.43152964f, 0.07547759f, -0.13619927f, -0.01822060f, 
    0.07587264f, 0.04862693f, 0.09421323f, 0.03500756f, 0.20326619f, -0.04227651f, -0.15968795f, 0.21910286f, 
    0.06533503f, -0.15000144f, 0.03185230f, -0.23325436f, -0.05858332f, -0.03983964f, 0.05579068f, -0.02172007f, 
    0.01524866f, 0.06625989f, -0.01801369f, -0.08000920f, 0.26432374f, 0.18722345f, 0.21230043f, 0.08256909f, 
    -0.07258611f, -0.08435957f, -0.15168937f, 0.15061431f, 0.02187869f, -0.14059013f, -0.01575058f, 0.10673980f, 
    0.01521460f, -0.05802083f, 0.09971537f, -0.15138274f, 0.00549432f, 0.00628233f, -0.01397096f, 0.06381538f, 
    0.01904824f, -0.05838984f, 0.06745600f, 0.03336121f, -0.16268146f, -0.11640735f, 0.19519199f, 0.21828631f, 
    0.00992678f, -0.01926413f, 0.00236397f, -0.05170501f, -0.02549962f, 0.06700858f, 0.10845905f, -0.05166652f, 
    0.12910947f, 0.08999085f, -0.08159261f, 0.04665798f, -0.12167439f, 0.04887123f, 0.12175693f, 0.01193324f, 
    0.14461203f, -0.00801345f, -0.01852081f, -0.02076617f, -0.06674026f, 0.07416726f, 0.12610531f, 0.20303319f, 
    -0.12394319f, 0.00566990f, 0.06614532f, 0.10929730f, -0.00430732f, -0.02154402f, 0.06408640f, 0.01360593f, 
    -0.33025298f, 0.33889109f, -0.06440847f, -0.08623310f, 0.15535012f, -0.02862304f, 0.03041205f, 0.04173892f, 
    -0.01288007f, 0.03743815f, -0.09920456f, -0.09948702f, -0.06103013f, 0.05264155f, 0.03667938f, -0.02031293f, 
    -0.06680462f, 0.15064152f, -0.12825532f, 0.07308190f, 0.04483762f, -0.07993922f, -0.01026826f, 0.04602028f, 
    -0.15640207f, -0.02700648f, 0.04200649f, -0.04687491f, 0.13708673f, 0.12783273f, -0.00348190f, 0.02038117f, 
    -0.07150494f, 0.09082094f, -0.03349956f, 0.02694034f, 0.12321591f, -0.20225500f, -0.03627292f, 0.39857560f, 
    0.22829157f, 0.02020340f, 0.01531738f, 0.05399708f, 0.03005232f, -0.05407411f, -0.11787859f, 0.04467762f, 
    0.03225140f, 0.10813016f, -0.10385730f, -0.06675439f, 0.09117819f, -0.10341869f, -0.00942021f, 0.11796974f, 
    -0.15508047f, -0.13279343f, -0.02569618f, -0.02333699f, -0.12291070f, 0.17047603f, -0.00408008f, 0.08217008f, 
    0.05595725f, 0.07487876f, -0.03074368f, 0.05433388f, -0.03438104f, 0.06832784f, -0.07478327f, 0.05781374f, 
    -0.24051578f, 0.11536969f, -0.10618618f, 0.20278919f, 0.09240834f, 0.00145049f, 0.16892655f, 0.20500532f, 
    -0.09726191f, 0.08488207f, 0.01711588f, 0.09783868f, -0.07590614f, 0.02315750f, 0.08015425f, -0.02107246f, 
    -0.05079800f, -0.01436331f, -0.03110731f, 0.08540361f, 0.11638299f, 0.00915281f, -0.12817958f, 0.04193365f, 
    0.06111220f, 0.13845560f, -0.16486137f, 0.02114888f, -0.02772186f, 0.07281488f, -0.12706393f, 0.09194229f, 
    0.04123824f, -0.02662458f, 0.06822563f, -0.05543608f, -0.04057553f, 0.03566276f, -0.00301461f, 0.18743864f, 
    0.08802517f, -0.13935569f, -0.09288148f, 0.16783157f, 0.04143967f, 0.04583164f, 0.07325517f, -0.05893006f, 
    0.05064412f, 0.03848907f, 0.05860713f, 0.03055211f, 0.03602913f, 0.04061925f, 0.01446770f, 0.04094739f, 
    -0.04431348f, 0.06060494f, 0.04734861f, -0.01083111f, -0.43347904f, -0.07418331f, 0.00670891f, -0.06663831f, 
    0.06350628f, -0.09063727f, -0.03400083f, 0.02837107f, 0.01241571f, -0.11444032f, -0.02555197f, 0.00676215f, 
    -0.20095514f, 0.04850516f, -0.10379231f, -0.02583128f, 0.01452581f, 0.02395569f, -0.04804625f, 0.12302255f, 
    0.05209091f, 0.02147571f, 0.05103807f, -0.00482216f, 0.16214019f, -0.13244386f, 0.27846456f, 0.09217484f, 
    0.13323374f, 0.04064874f, 0.05706469f, 0.03532507f, -0.09797986f, -0.18338014f, 0.02510147f, -0.01503262f, 
    -0.15421350f, 0.04987638f, 0.01760629f, -0.10131668f, -0.02170794f, 0.00190031f, -0.02903602f, -0.06986053f, 
    -0.03782263f, -0.15047374f, 0.11924404f, 0.00042451f, -0.21286701f, -0.11485213f, -0.12791461f, -0.08566909f, 
    -0.02630182f, 0.09229460f, -0.02102953f, 0.00930794f, 0.11851096f, -0.01350198f, -0.03357215f, 0.12201159f, 
    -0.24680515f, -0.06231322f, 0.11381471f, -0.10767564f, 0.06430288f, 0.06002184f, 0.03116802f, -0.09034333f, 
    -0.05977687f, -0.06698169f, -0.06262892f, 0.05316103f, 0.12495907f, 0.15138847f, 0.10521007f, 0.01111136f, 
    0.09205499f, 0.06783172f, -0.13910912f, 0.11416925f, -0.10496748f, -0.13761573f, 0.07236516f, 0.13883199f, 
    -0.49785167f, 0.17030546f, 0.11413889f, -0.11693882f, 0.09634060f, -0.10069950f, -0.02347082f, 0.01018084f, 
    -0.04214571f, 0.11708371f, -0.03076306f, 0.03675553f, 0.12783085f, -0.00113741f, 0.10422628f, 0.13341780f, 
    0.09282544f, 0.07921785f, 0.15787350f, 0.06751435f, 0.05195267f, 0.00735910f, -0.03528649f, 0.16078609f, 
    -0.18191420f, 0.04125840f, -0.05841113f, -0.16189301f, 0.13268122f, -0.06355048f, 0.10806523f, 0.01628493f, 
    -0.07867841f, 0.04869049f, -0.02013567f, 0.10558748f, 0.09484188f, 0.11013785f, 0.30367067f, 0.12321433f, 
    0.02232945f, 0.00689222f, 0.16212372f, 0.07838380f, 0.10402792f, 0.13246651f, -0.04917613f, 0.06679795f, 
    -0.05561657f, 0.00210297f, -0.00895674f, -0.03755133f, -0.05093899f, 0.03827665f, -0.06875919f, 0.01758976f, 
    0.03294351f, 0.00671089f, -0.07246633f, 0.05635180f, -0.06631014f, 0.01331689f, -0.03485488f, -0.07215039f, 
    -0.02855749f, -0.04638883f, -0.05428290f, 0.05833396f, 0.02508910f, -0.02468906f, -0.01127818f, 0.04668448f, 
    -0.07088993f, -0.05238984f, -0.05741220f, -0.03251597f, -0.06051413f, -0.06449748f, -0.03854768f, -0.02634751f, 
    0.00704820f, 0.04811630f, -0.07930189f, 0.03832312f, 0.03822202f, -0.05254024f, -0.04394209f, -0.00259906f, 
    0.02363711f, -0.03493470f, 0.02438452f, -0.03696603f, -0.07323141f, -0.00002726f, 0.02866463f, -0.00735546f, 
    -0.07623531f, -0.04569500f, -0.04994592f, 0.04201198f, -0.03420754f, 0.03979827f, 0.05973879f, 0.02991987f, 
    0.01304213f, -0.00012675f, 0.01109758f, 0.03504008f, 0.05096048f, 0.02822152f, 0.06138466f, -0.01038502f, 
    -0.05981735f, 0.01232222f, 0.05539320f, 0.00059138f, -0.05479039f, -0.03477373f, -0.06770571f, -0.03804135f, 
    0.00034431f, 0.03244293f, -0.06593111f, -0.03236778f, -0.07498798f, 0.04047204f, 0.05594864f, -0.04787681f, 
    0.03504167f, 0.03687824f, 0.01032973f, 0.05711511f, 0.02281070f, -0.05421066f, -0.01687310f, 0.05441834f, 
    -0.02547226f, 0.04521885f, -0.02790678f, 0.04006945f, -0.06082517f, 0.03143082f, 0.04471616f, 0.02366083f, 
    -0.06287953f, 0.00690314f, 0.06282057f, -0.05515725f, -0.07161207f, -0.02613250f, 0.05625616f, -0.04488894f, 
    -0.03674174f, -0.00572764f, -0.01830891f, -0.07169963f, -0.03074579f, -0.02799498f, -0.00643757f, 0.04558747f, 
    0.04327424f, -0.03320905f, -0.05616678f, -0.05792723f, 0.06191191f, -0.04391988f, -0.05032551f, -0.00756818f, 
    -0.02979137f, 0.03339703f, -0.02114674f, 0.02579460f, 0.03266224f, -0.06517340f, -0.02665264f, 0.05606115f, 
    0.01208580f, -0.06399111f, -0.01273346f, 0.03598652f, 0.02164563f, 0.01564746f, -0.07006656f, -0.00627866f, 
    -0.03671567f, 0.02485561f, 0.04917644f, -0.08141718f, 0.05023234f, 0.03573057f, -0.03225484f, -0.03927584f, 
    0.04599657f, -0.03057942f, -0.02283146f, 0.00019523f, -0.08409449f, -0.03225272f, -0.06986268f, -0.03240962f, 
    -0.02916291f, -0.03229834f, -0.06595021f, -0.03889680f, -0.00662252f, -0.02222257f, 0.03298386f, 0.03022198f, 
    -0.04495933f, -0.04616943f, 0.00126487f, -0.03947636f, 0.05675491f, 0.00278542f, 0.01540721f, -0.03744280f, 
    -0.05141138f, 0.02756968f, -0.04500658f, -0.07932913f, -0.04615897f, 0.03861967f, 0.00590353f, 0.00322283f, 
    0.00055453f, 0.06050352f, 0.01308715f, 0.01829500f, -0.03608304f, -0.03736679f, 0.05328522f, -0.07120859f, 
    -0.06563825f, -0.01771815f, 0.07067460f, -0.06035441f, -0.04563448f, -0.01765283f, 0.00886834f, 0.00270787f, 
    0.03969192f, -0.04179766f, 0.01228449f, 0.04752126f, -0.03699782f, 0.05308744f, -0.08494480f, -0.04171327f, 
    0.01433611f, -0.01786129f, 0.03564792f, -0.01605603f, 0.00539416f, 0.04402897f, -0.03185114f, -0.00960586f, 
    -0.00862401f, -0.03364263f, -0.02659935f, 0.02763029f, -0.03045448f, 0.05954243f, -0.02252268f, 0.02167898f, 
    -0.03035949f, 0.00742296f, -0.05606908f, 0.04753869f, -0.02031742f, -0.05615653f, 0.01182470f, 0.03998104f, 
    0.03302320f, -0.00392542f, -0.01332763f, -0.05747292f, -0.01084794f, -0.07789547f, -0.07910112f, -0.01313246f, 
    -0.03163033f, 0.00690022f, -0.06050630f, 0.00254016f, -0.03051442f, -0.08029690f, -0.05671554f, 0.03348710f, 
    0.01517850f, -0.03302437f, -0.05817492f, 0.02356326f, 0.00107072f, -0.04388463f, 0.05069359f, -0.05337538f, 
    0.00340065f, 0.04014200f, 0.01481367f, -0.00169504f, 0.00352667f, 0.04249452f, 0.04834774f, -0.07439492f, 
    -0.01287851f, 0.03341549f, 0.03610056f, -0.05706527f, 0.01794267f, 0.03968531f, -0.05235833f, -0.01940013f, 
    -0.07236169f, 0.05946657f, 0.03313401f, -0.01376614f, 0.01152446f, -0.03531129f, -0.05546732f, 0.00602617f, 
    0.01993647f, -0.01397541f, -0.06234897f, -0.02139590f, 0.06019079f, -0.01941309f, 0.05817778f, -0.00250566f, 
    0.02845874f, 0.01079985f, 0.06222764f, -0.03303999f, 0.00481642f, -0.00121719f, -0.07217540f, -0.04420974f, 
    -0.01487423f, -0.02592368f, 0.03736926f, 0.04263372f, 0.00778333f, -0.00541507f, 0.00653462f, 0.01367623f, 
    -0.05171152f, -0.05849636f, -0.04284519f, 0.02377972f, -0.02705526f, -0.00925538f, -0.06502865f, 0.00591933f, 
    -0.02486481f, -0.04792013f, -0.05019540f, -0.00416939f, 0.06074179f, -0.03164821f, 0.03992135f, -0.02316375f, 
    0.01610039f, 0.04718918f, -0.05031573f, -0.05400336f, 0.05484984f, -0.03776059f, -0.01629136f, 0.01291756f, 
    -0.04957121f, -0.02738918f, -0.08134314f, -0.01315204f, 0.03428051f, 0.02486523f, -0.05284377f, 0.04362162f, 
    0.03150314f, -0.01352686f, 0.05012652f, 0.03096999f, 0.01818009f, 0.02222566f, 0.05115301f, -0.02749007f, 
    -0.01399855f, -0.03355439f, -0.05279106f, -0.07342196f, -0.00456231f, -0.01465838f, -0.05132122f, -0.00179448f, 
    0.02958999f, 0.04082546f, -0.03497247f, 0.00062533f, 0.01301284f, -0.07694364f, -0.05549549f, -0.01552277f, 
    -0.07661259f, -0.03150896f, 0.04623451f, 0.03222848f, 0.02293810f, 0.05914491f, -0.05205980f, -0.03451458f, 
    0.05902616f, -0.03188819f, 0.05294305f, 0.01372985f, -0.00175306f, -0.03660096f, 0.03896710f, 0.04508488f, 
    0.00928789f, 0.00867211f, 0.00483542f, 0.01260107f, -0.03272881f, -0.01233399f, -0.06348940f, -0.05223279f, 
    -0.04274257f, -0.01568587f, -0.06796526f, -0.08174088f, -0.04165150f, -0.05848489f, -0.07403409f, 0.00712281f, 
    0.36886972f, 0.16083939f, 0.15385568f, 0.35200718f, -0.06770138f, -0.00944262f, 0.05880344f, 0.27071086f, 
    -0.10651622f, 0.00470470f, 0.09407756f, 0.18795523f, -0.05340686f, -0.02207652f, -0.01826085f, -0.15166606f, 
    0.00597978f, -0.01987941f, -0.12280704f, -0.00847282f, 0.03626916f, 0.03287616f, 0.04859877f, 0.08605680f, 
    0.05400842f, -0.03021292f, -0.24077831f, -0.13862795f, -0.10665987f, 0.09542799f, -0.10565802f, -0.00261013f, 
    0.05250982f, -0.08538276f, -0.03992262f, 0.05896760f, 0.08091450f, 0.20394221f, 0.21158902f, -0.04296701f, 
    0.07898012f, -0.22387515f, -0.04099587f, 0.03822849f, 0.11201554f, -0.04828509f, -0.17264293f, -0.16651261f, 
    0.06228257f, -0.10716386f, -0.07719745f, -0.08753582f, 0.04490265f, -0.00782510f, -0.06528590f, 0.06709412f, 
    0.03956382f, 0.04778468f, -0.08924473f, 0.05777236f, 0.16554525f, 0.24646448f, 0.18443196f, 0.06503565f, 
    0.03643626f, -0.07005998f, -0.03812830f, 0.09760173f, -0.02448692f, -0.20651577f, -0.18666226f, -0.01271121f, 
    -0.06218056f, 0.03357700f, 0.09873972f, 0.05358993f, 0.03520544f, 0.04243611f, 0.09057254f, 0.07737681f, 
    -0.06575208f, -0.10428213f, 0.03132237f, -0.11496014f, -0.15262245f, -0.30574253f, 0.37013251f, 0.06767787f, 
    0.06624402f, -0.06684719f, 0.03012208f, 0.05891955f, -0.13641147f, -0.19730006f, -0.04667793f, -0.26145080f, 
    -0.10278229f, 0.02951433f, 0.03766519f, -0.06402105f, -0.05232669f, -0.09994899f, 0.07777771f, -0.07954955f, 
    0.09955748f, 0.08834735f, 0.08217023f, -0.06436376f, 0.15331875f, 0.06061643f, -0.12215678f, 0.15456155f, 
    -0.03388718f, -0.05756923f, -0.02055572f, 0.03231752f, 0.01125136f, 0.03422194f, 0.00516186f, 0.15118629f, 
    -0.58678842f, 0.14742826f, 0.04641273f, -0.20347479f, 0.06245511f, 0.01314821f, -0.00516006f, 0.02748048f, 
    0.00302691f, -0.06890961f, 0.08337162f, 0.06688157f, 0.00708132f, 0.09720565f, 0.20371057f, 0.03803729f, 
    -0.09128291f, -0.01685357f, 0.05853698f, 0.13597864f, 0.00782665f, -0.16854437f, 0.07840812f, 0.17677003f, 
    0.03989118f, 0.05187381f, 0.10727872f, 0.05222366f, -0.00031599f, 0.08600757f, 0.07526914f, 0.03965378f, 
    0.01176045f, 0.03031202f, 0.03338401f, 0.04284423f, 0.15452327f, -0.21220647f, -0.09165298f, 0.05110721f, 
    0.01351686f, 0.10950171f, 0.00787488f, -0.05965008f, 0.00444320f, -0.02459310f, -0.08552314f, 0.06910695f, 
    0.11063458f, 0.06076192f, 0.11278274f, -0.08068591f, -0.07843805f, -0.14049019f, 0.02468243f, -0.01185356f, 
    -0.00067640f, 0.03934461f, -0.08300379f, 0.00353349f, 0.02849967f, -0.14532863f, -0.02705310f, -0.03077282f, 
    0.06080054f, -0.04507569f, 0.03086375f, 0.11444840f, -0.06493976f, 0.14211974f, 0.09327400f, 0.00915341f, 
    -0.07766318f, -0.06308835f, -0.01180533f, 0.00351218f, -0.04640425f, -0.05238799f, -0.02211348f, 0.02775371f, 
    -0.05126543f, 0.02983915f, -0.02895553f, -0.02623357f, -0.02572604f, -0.00682369f, 0.00735793f, -0.04234779f, 
    -0.00930804f, 0.03881468f, 0.06203186f, -0.03830284f, 0.02226392f, -0.00703623f, 0.05532172f, 0.06520524f, 
    -0.07350312f, -0.02376593f, -0.04361331f, 0.00433688f, -0.04738387f, -0.04835524f, -0.07389397f, -0.03172629f, 
    0.06221264f, -0.04452163f, -0.07248674f, -0.01632878f, 0.02108764f, -0.05273570f, -0.02406577f, -0.04397769f, 
    0.06872280f, -0.00518609f, 0.00399932f, 0.01824953f, -0.01056253f, -0.02023058f, -0.05523951f, -0.01407712f, 
    -0.03509368f, -0.07339264f, -0.04612894f, -0.04223632f, 0.02515153f, 0.00071009f, -0.04202944f, 0.07187899f, 
    -0.01279296f, 0.00221663f, 0.00120723f, -0.03827183f, 0.00097319f, 0.04609819f, -0.06748477f, 0.00752948f, 
    0.06466433f, -0.02206941f, 0.06831127f, 0.02866904f, 0.05839879f, 0.03813290f, -0.02785028f, 0.04674851f, 
    0.01042456f, -0.04231889f, 0.03187627f, 0.01970933f, -0.01710403f, 0.06128149f, 0.00707385f, -0.03234807f, 
    -0.04526137f, -0.07035457f, 0.04143664f, -0.05751865f, 0.01806245f, 0.03650156f, 0.06096212f, -0.04535045f, 
    -0.02605583f, 0.06279962f, 0.04547083f, 0.06078750f, -0.00749954f, 0.03454138f, -0.06127534f, -0.03117734f, 
    -0.04668787f, -0.03716409f, 0.06351757f, -0.05628462f, 0.01049962f, -0.03246851f, -0.05418336f, -0.07158628f, 
    0.04655055f, 0.01283840f, 0.03953505f, -0.00840495f, 0.02440753f, 0.05410996f, 0.02895733f, 0.02796432f, 
    -0.03461020f, 0.00291491f, -0.03117142f, -0.03647467f, 0.05336827f, -0.04018377f, 0.01569919f, -0.03559782f, 
    0.03641812f, 0.01658344f, -0.06782146f, 0.03136307f, -0.04654027f, -0.03959795f, -0.04141088f, 0.01169398f, 
    -0.07662761f, 0.03959073f, -0.02790515f, 0.04217006f, 0.04215101f, -0.04787192f, 0.03424007f, -0.02128870f, 
    0.05613689f, -0.00665624f, -0.02850799f, 0.00342309f, -0.04874477f, -0.06952669f, 0.04028343f, -0.00278592f, 
    0.04764295f, -0.03531956f, -0.07738226f, -0.01267748f, 0.03133680f, 0.01699339f, -0.03198347f, -0.03817697f, 
    0.06031577f, -0.00534237f, -0.03697969f, -0.03473528f, 0.02623988f, 0.00641978f, 0.01691667f, -0.00489761f, 
    -0.04904237f, 0.01308784f, 0.03163316f, -0.04917179f, 0.06048563f, -0.04554326f, -0.07595889f, -0.07268002f, 
    -0.03368504f, -0.01704656f, 0.05214011f, -0.02407000f, 0.04041466f, -0.01475626f, -0.02635765f, -0.03231798f, 
    -0.05527560f, 0.04578105f, -0.07309162f, 0.04054540f, 0.03979797f, -0.04144369f, -0.04913960f, 0.03813174f, 
    -0.00916856f, -0.04224889f, -0.03019168f, 0.04196992f, -0.05299237f, -0.03831207f, -0.07744430f, 0.03391062f, 
    0.07634714f, 0.18975846f, 0.19045827f, 0.11146443f, 0.16282935f, 0.06405160f, -0.00520505f, 0.10643305f, 
    -0.00258292f, 0.07007281f, -0.09878316f, 0.10912488f, 0.04817239f, 0.03884035f, 0.02295085f, -0.16259536f, 
    -0.02653288f, 0.03629870f, 0.15709800f, 0.03381738f, -0.07615807f, -0.09665750f, -0.00728075f, 0.01465646f, 
    -0.03157811f, -0.07443836f, 0.14245571f, -0.04548068f, 0.00277047f, 0.03393670f, -0.03795310f, 0.03050726f, 
    -0.02308920f, 0.05987727f, 0.00747710f, 0.01046222f, 0.31832945f, 0.10454834f, -0.03297239f, 0.18952303f, 
    0.08042176f, -0.05102980f, 0.02357220f, -0.14050707f, 0.04306800f, 0.03690622f, -0.03850013f, 0.04918961f, 
    -0.05420045f, -0.18627328f, 0.02775885f, -0.18995106f, -0.09662099f, -0.03895466f, 0.06576096f, 0.04600360f, 
    0.01130446f, 0.11010914f, -0.05571758f, -0.11672545f, 0.24657735f, 0.19720514f, 0.24961480f, 0.10552373f, 
    -0.06492689f, 0.11590283f, -0.01913173f, 0.01177787f, 0.02581300f, -0.12965937f, 0.09783529f, 0.03104969f, 
    -0.05142776f, 0.02164910f, 0.13278483f, -0.05184698f, 0.05697468f, -0.03230925f, -0.02249881f, 0.10645238f, 
    0.08151118f, 0.03067895f, 0.06434745f, -0.04451352f, 0.04752200f, -0.16023135f, 0.09372771f, 0.25905535f, 
    -0.06551062f, -0.05164732f, -0.06710906f, -0.09350385f, 0.02900876f, 0.10774676f, 0.00364920f, -0.01576967f, 
    -0.00554387f, 0.07745939f, 0.01948685f, -0.12466767f, -0.04754916f, -0.06207890f, 0.13200934f, 0.06614981f, 
    0.10417768f, 0.07131033f, -0.02040200f, 0.05114367f, -0.03033961f, 0.19942099f, -0.01701443f, 0.19409050f, 
    -0.13617186f, -0.10165757f, 0.15472294f, 0.03542429f, 0.04662214f, 0.02986740f, -0.00584244f, -0.02119844f, 
    -0.00388506f, 0.29417095f, -0.02058001f, 0.15793270f, 0.08430915f, -0.07128686f, 0.06900434f, 0.01224514f, 
    -0.06118791f, -0.01609333f, 0.01231851f, -0.05547629f, 0.12220041f, 0.01906082f, 0.13866356f, -0.05096018f, 
    -0.02469433f, 0.09539948f, -0.05650587f, 0.02250090f, 0.07122326f, -0.03180998f, -0.04282783f, -0.13009128f, 
    -0.12421118f, 0.18775003f, 0.03639198f, -0.15268114f, 0.06383818f, 0.04093017f, 0.06532180f, -0.03802291f, 
    -0.03373768f, -0.00257525f, -0.13523768f, 0.04153544f, 0.09076718f, -0.16988194f, -0.15235852f, 0.11929184f, 
    0.09511828f, -0.01524317f, -0.07735746f, -0.00065597f, -0.00203274f, 0.05058638f, -0.09417877f, 0.10848315f, 
    -0.16657345f, 0.15253465f, -0.08649038f, -0.15823126f, 0.03961789f, 0.02350003f, 0.04144422f, 0.05780445f, 
    -0.03186870f, -0.09873269f, 0.04099629f, -0.05383807f, -0.10761117f, 0.12518904f, 0.12656845f, -0.08015040f, 
    -0.01492458f, 0.05311469f, -0.05011737f, -0.00374017f, -0.10662960f, 0.15937585f, -0.04538386f, 0.01802779f, 
    -0.06831532f, -0.01219797f, -0.04847069f, 0.05298503f, -0.01085792f, -0.02251125f, 0.04143775f, -0.03979698f, 
    -0.05083174f, -0.03059835f, -0.05562658f, 0.02050057f, 0.05706337f, -0.03860806f, -0.04934524f, -0.04882558f, 
    0.03605874f, -0.03793592f, -0.01478127f, -0.05924921f, -0.03822322f, -0.03420020f, -0.07749987f, 0.03414314f, 
    -0.02900566f, -0.02355977f, -0.05069811f, -0.03293242f, -0.01867984f, 0.06016221f, -0.00133269f, -0.07365661f, 
    0.02212068f, -0.02500234f, -0.05077222f, -0.05324342f, 0.05481541f, -0.07011429f, 0.04632645f, -0.04853362f, 
    0.05203346f, -0.00394439f, -0.00820379f, 0.06141138f, -0.01591604f, 0.04582679f, 0.01478742f, 0.06181311f, 
    0.06024159f, -0.06772963f, -0.01317714f, -0.07593355f, -0.04217404f, -0.02445724f, -0.04286484f, 0.05892098f, 
    -0.07815193f, -0.04321233f, -0.03857225f, 0.02243477f, 0.06594144f, 0.01947189f, -0.02397312f, 0.01123104f, 
    0.04860862f, 0.06474833f, 0.01099140f, -0.00583005f, -0.04916099f, -0.01665119f, 0.05718285f, 0.02670491f, 
    -0.03452449f, -0.06076756f, -0.07241975f, -0.03769360f, -0.04701174f, -0.06455571f, 0.04272892f, 0.00514079f, 
    0.06582108f, -0.03842727f, 0.05890254f, 0.01423110f, -0.04396691f, -0.01346107f, 0.00483405f, 0.01082534f, 
    -0.02205322f, -0.05091383f, -0.00616658f, -0.00263526f, -0.04717596f, -0.02388759f, 0.01817275f, 0.01990765f, 
    -0.04258081f, -0.02799154f, 0.03238034f, 0.01562487f, 0.01192639f, -0.01235532f, -0.04592635f, 0.01340428f, 
    0.04033124f, -0.04718413f, -0.04521570f, -0.04286484f, -0.06366379f, 0.04102505f, -0.05047893f, 0.04768055f, 
    0.05496517f, -0.06105613f, -0.03325035f, -0.03198927f, 0.05731984f, -0.01128288f, 0.02884336f, 0.03427054f, 
    0.00981634f, 0.00145693f, -0.01859814f, 0.02624408f, -0.03770251f, -0.00414047f, -0.02454305f, -0.05095199f, 
    0.01529063f, -0.02329903f, 0.01035557f, 0.00589259f, -0.04271675f, 0.06199668f, 0.01535948f, -0.01903889f, 
    0.00601819f, -0.07731289f, 0.02632679f, -0.03481973f, 0.06103656f, 0.01923758f, 0.01751377f, 0.02223963f, 
    0.01059828f, -0.00561362f, 0.00391301f, -0.04157669f, -0.03139938f, 0.04543079f, -0.03611317f, -0.03911728f, 
    -0.01827688f, 0.02996614f, -0.00284174f, 0.03972417f, -0.04730874f, -0.06171793f, -0.00696767f, 0.02841853f, 
    0.01305815f, -0.04215429f, -0.04446626f, -0.03483816f, -0.05406320f, -0.05982076f, 0.02176283f, -0.02305336f, 
    0.05474571f, -0.02362385f, -0.06914497f, -0.01700837f, -0.04678618f, -0.01747046f, 0.02574285f, 0.05598355f, 
    -0.05961940f, 0.02759088f, -0.01923834f, 0.04675942f, -0.07453706f, -0.06348844f, -0.00637419f, 0.03082554f, 
    0.02331850f, 0.02881727f, 0.03904601f, 0.02084929f, 0.01977717f, -0.04468569f, 0.03732436f, 0.05735783f, 
    0.02113695f, 0.00413874f, -0.17594977f, -0.06609391f, 0.15217108f, 0.00188785f, 0.20805337f, -0.04559239f, 
    0.00730865f, -0.05326742f, -0.06452110f, 0.11586353f, -0.01465224f, -0.00516243f, -0.04181186f, -0.00617272f, 
    0.13320552f, 0.05733521f, -0.05666805f, 0.07838187f, 0.07296840f, -0.04379413f, 0.04750695f, -0.02550943f, 
    -0.18618201f, -0.03182149f, -0.13825823f, 0.13940534f, 0.14950600f, 0.14240012f, 0.02413385f, -0.06185972f, 
    -0.03044404f, 0.00479377f, 0.09185578f, 0.02632015f, -0.19589549f, 0.10514310f, -0.03907824f, 0.03332874f, 
    0.03124418f, 0.06548590f, 0.02766161f, -0.04546859f, 0.06594868f, 0.07759681f, 0.08891430f, 0.19743629f, 
    -0.17822446f, 0.00086095f, 0.00543738f, 0.15693212f, 0.05300162f, 0.11683097f, -0.06305382f, -0.01849530f, 
    0.05842257f, -0.02286793f, 0.07441384f, 0.09878725f, -0.19106612f, 0.00492084f, -0.28496528f, 0.04694874f, 
    -0.01932807f, 0.01066346f, 0.04586834f, 0.00372854f, 0.00373190f, 0.03701691f, 0.19031505f, 0.05807742f, 
    -0.12981778f, 0.16646992f, -0.03706845f, -0.15229893f, -0.05872649f, 0.06872626f, 0.06851570f, 0.01795474f, 
    0.05165847f, 0.06460817f, 0.06515712f, 0.18123114f, -0.11258545f, 0.01212888f, 0.19424663f, -0.08366804f, 
    0.01146853f, 0.05857754f, -0.04655318f, -0.04591633f, 0.02570553f, 0.09290063f, 0.15027702f, 0.15765157f, 
    0.08806250f, -0.00211624f, 0.13827205f, -0.24933340f, 0.02951708f, 0.11083598f, -0.14070193f, 0.04756776f, 
    0.06551398f, -0.00510148f, -0.04529724f, -0.07976262f, 0.03396443f, -0.04790993f, -0.23360394f, -0.01104442f, 
    -0.01902236f, 0.02556057f, -0.00985503f, 0.01910359f, 0.08289313f, -0.01478517f, 0.04418248f, 0.01431586f, 
    -0.31441933f, -0.07367716f, -0.12643094f, -0.06575970f, -0.14500032f, 0.05228693f, 0.06784195f, -0.09256397f, 
    0.00420965f, 0.04553873f, -0.02373840f, -0.01060606f, -0.07838390f, 0.15883310f, 0.20974679f, 0.17488283f, 
    -0.07305782f, 0.06041838f, -0.01955502f, 0.10000148f, -0.03493369f, 0.10914055f, -0.00428812f, -0.02826737f, 
    -0.17341605f, 0.03298973f, -0.01409141f, -0.14916243f, 0.10326266f, 0.13755308f, 0.01508846f, 0.08789555f, 
    0.14831294f, -0.02212342f, 0.04728335f, 0.12605658f, -0.03246467f, -0.05566240f, 0.11596651f, -0.12267723f, 
    0.01036972f, -0.07488839f, 0.02494919f, 0.06296751f, 0.15670842f, -0.06547642f, -0.03793379f, 0.11714821f, 
    -0.15421025f, -0.04984126f, 0.04865226f, -0.09637351f, 0.00400233f, -0.03698708f, 0.04744965f, 0.20254378f, 
    0.04997052f, -0.01621428f, 0.03193891f, 0.01566173f, -0.16753644f, 0.03536471f, 0.21255119f, -0.11027962f, 
    0.08332171f, -0.07853053f, 0.01254183f, 0.07607867f, 0.09979571f, 0.05014456f, -0.16583905f, 0.06206224f, 
    0.04752442f, 0.03963918f, -0.01874660f, 0.05044420f, 0.00185748f, -0.02809437f, -0.04002156f, 0.00479978f, 
    -0.00103870f, -0.07097775f, 0.01081432f, -0.05683104f, -0.04310030f, 0.03631224f, -0.04640293f, -0.05647889f, 
    -0.03282043f, -0.00027354f, -0.06122703f, -0.06902567f, -0.02535556f, 0.01945218f, -0.02446790f, 0.03004422f, 
    0.05097090f, 0.04531668f, -0.07042398f, -0.02037749f, -0.01255979f, -0.02500343f, -0.00749779f, 0.03016695f, 
    -0.02296257f, 0.00694884f, -0.06053152f, -0.03144587f, 0.00805090f, -0.02766388f, 0.00193195f, 0.00462476f, 
    0.04421945f, 0.05644790f, -0.01243706f, -0.07173338f, -0.05802543f, 0.02500278f, -0.05671091f, 0.04477292f, 
    -0.05401163f, -0.05709317f, -0.03883098f, -0.04477066f, -0.01970658f, -0.00887273f, -0.00244280f, -0.05179342f, 
    0.03244821f, 0.00167264f, -0.01497655f, 0.04843048f, 0.05831537f, -0.06191837f, -0.05041317f, -0.05110591f, 
    -0.03464109f, -0.00630773f, 0.04199195f, -0.01956131f, 0.02717451f, 0.02261240f, -0.00664866f, -0.01621922f, 
    -0.00404932f, 0.03908581f, 0.01501856f, -0.00353097f, -0.02952893f, 0.05113614f, -0.00667567f, 0.03992404f, 
    0.04790266f, -0.03503087f, -0.02548277f, 0.02524990f, -0.05099043f, 0.04745748f, -0.05036449f, 0.06481378f, 
    0.05212215f, -0.03673590f, 0.00694662f, -0.02070845f, -0.04764545f, 0.04824692f, -0.01513126f, 0.05844892f, 
    -0.00257784f, 0.00097801f, 0.05461090f, 0.01944504f, 0.00642805f, -0.07239281f, 0.03171273f, -0.01544162f, 
    -0.03639448f, -0.03586281f, -0.05028060f, 0.00611488f, 0.00865034f, -0.06145114f, 0.00649369f, 0.02439743f, 
    -0.01928174f, -0.03398323f, -0.01142474f, 0.04686211f, 0.01828011f, -0.07336049f, 0.01299496f, 0.04846964f, 
    -0.07317354f, -0.02684985f, -0.02828107f, -0.01628806f, -0.00960931f, -0.06861599f, -0.02881966f, -0.04053702f, 
    -0.07335474f, 0.05885141f, 0.00048183f, 0.00830701f, -0.06874914f, -0.01571490f, 0.00601429f, -0.05736589f, 
    -0.01872649f, -0.02960922f, 0.05297249f, 0.03330653f, -0.05179161f, 0.02736413f, 0.01589008f, -0.06897702f, 
    0.01163450f, 0.03197780f, -0.00772277f, 0.00315098f, 0.02605590f, -0.03541694f, -0.02876429f, -0.01970590f, 
    -0.01987647f, 0.02677457f, 0.05595210f, -0.06694005f, 0.01735730f, -0.04455793f, -0.04752161f, -0.05458806f, 
    0.04301890f, -0.05960612f, -0.01208606f, 0.03478349f, 0.03111506f, 0.06314489f, 0.01695826f, -0.07783123f, 
    -0.04170782f, 0.03479088f, -0.05214533f, -0.03218710f, -0.02801751f, -0.05030046f, 0.00928309f, -0.02100010f, 
    -0.07707473f, 0.01931804f, -0.02168583f, 0.05344597f, 0.03042043f, 0.00852794f, 0.04945870f, 0.03687436f, 
    -0.00636899f, -0.05542079f, -0.04362198f, 0.00432303f, 0.00492671f, -0.04645027f, 0.01472419f, 0.03397262f, 
    -0.14672421f, 0.19316982f, 0.10990334f, 0.08177831f, 0.10672858f, 0.09409938f, 0.09715223f, 0.13994871f, 
    0.01447020f, 0.10462796f, 0.07535688f, 0.04517370f, -0.26903158f, 0.02729289f, 0.05833403f, -0.09325486f, 
    -0.03815616f, 0.03525763f, 0.05781780f, -0.01283485f, 0.05672463f, 0.01160218f, -0.07383820f, 0.00729832f, 
    -0.09346130f, 0.15809703f, 0.09927478f, 0.16760576f, 0.00605273f, 0.03054901f, -0.07877836f, 0.07998430f, 
    0.01150556f, 0.01378760f, 0.08571990f, -0.04008865f, 0.06039858f, -0.06721856f, 0.13014393f, 0.21451028f, 
    -0.03153196f, -0.10346729f, -0.04874410f, 0.10428796f, -0.00263530f, -0.00508379f, 0.07586859f, -0.04436724f, 
    -0.05368502f, -0.11127582f, 0.11102733f, 0.02351195f, -0.06859793f, 0.08947361f, -0.01807564f, 0.04344686f, 
    -0.05599439f, 0.06875784f, -0.00754225f, -0.04542523f, -0.20696285f, 0.05747964f, 0.18933778f, 0.02718946f, 
    0.02866119f, 0.08937783f, -0.05821614f, 0.01753898f, 0.00812245f, -0.02663842f, -0.12415563f, 0.00643023f, 
    -0.08086098f, 0.11869644f, -0.02298584f, 0.13436513f, 0.00334112f, 0.08920453f, -0.04981737f, 0.11427812f, 
    0.08054242f, 0.05233539f, 0.00730146f, -0.14992344f, 0.05322343f, -0.18133171f, 0.10477269f, -0.10740464f, 
    0.01692078f, -0.15026768f, 0.01600482f, -0.01730085f, -0.00753398f, -0.10564488f, -0.03023001f, -0.14926489f, 
    -0.24843858f, -0.03090620f, -0.09389068f, -0.13175076f, -0.01284637f, 0.01888703f, 0.03437965f, -0.03866328f, 
    -0.03455691f, -0.12278712f, 0.04561958f, 0.09756713f, -0.22749265f, -0.11424320f, 0.05314741f, 0.12765773f, 
    0.00618208f, 0.13778390f, 0.08838309f, 0.05693531f, 0.11122315f, 0.15543084f, -0.03690153f, 0.18684983f, 
    0.04858799f, -0.00803675f, 0.16996996f, -0.11160959f, 0.03982127f, 0.02038253f, 0.05845029f, 0.00092118f, 
    0.02148933f, -0.05237184f, -0.02913390f, 0.06344619f, 0.20735332f, -0.02952909f, 0.16456594f, -0.04303526f, 
    0.16647142f, -0.01917109f, -0.05471250f, -0.02172817f, -0.07883292f, -0.09823437f, -0.00178186f, 0.04174348f, 
    -0.38347101f, 0.18323179f, 0.03463750f, -0.02872245f, 0.08356957f, -0.00782642f, 0.00701438f, 0.05689169f, 
    0.03722874f, 0.05222479f, -0.01541496f, 0.03747729f, 0.08449379f, 0.05252504f, -0.14141841f, -0.06907489f, 
    -0.06924443f, -0.06218820f, 0.07261439f, 0.00349949f, 0.05912206f, 0.12105443f, -0.00767826f, 0.09475441f, 
    -0.12380150f, 0.01969923f, -0.08937743f, -0.09660544f, 0.11472283f, 0.01790418f, 0.00214119f, -0.07371797f, 
    0.06045284f, 0.08038382f, 0.07305108f, 0.02949759f, 0.18512805f, 0.09977279f, 0.06860559f, -0.02216297f, 
    -0.05194243f, -0.05216584f, 0.01805762f, 0.10151786f, 0.01500361f, 0.09868227f, 0.08501863f, -0.00209967f, 
    -0.04060575f, 0.00595341f, 0.01130123f, 0.05748283f, 0.01922966f, -0.07050238f, -0.01320572f, 0.04642372f, 
    -0.03726453f, -0.05591403f, 0.03538727f, -0.01728003f, -0.06032385f, 0.00365547f, 0.04322438f, -0.02444717f, 
    0.00497685f, 0.02317753f, 0.06163806f, -0.07395110f, -0.06056675f, -0.06133900f, -0.04279941f, 0.00915795f, 
    0.04473740f, -0.02535786f, 0.06045241f, -0.01756020f, 0.01615573f, -0.07544222f, 0.01089345f, -0.02497248f, 
    -0.06774471f, 0.06711267f, 0.02039879f, 0.06929707f, -0.06549428f, 0.01333526f, -0.05650809f, 0.02638797f, 
    0.03852137f, -0.02004571f, -0.02670217f, 0.02219802f, -0.05615037f, -0.03387891f, 0.01895549f, -0.04899427f, 
    -0.05511844f, -0.02590922f, -0.08376153f, -0.01004782f, -0.04106160f, 0.00422321f, 0.04847854f, -0.03818161f, 
    0.02184770f, -0.00722839f, 0.08126453f, -0.06677026f, -0.04680933f, 0.01763049f, 0.02416018f, -0.04125671f, 
    -0.05411673f, -0.04883037f, -0.00074653f, -0.04112003f, -0.06114103f, 0.01322032f, -0.01491413f, 0.02740215f, 
    -0.06992138f, -0.01866446f, -0.02088531f, -0.02095773f, -0.02462269f, -0.07942758f, -0.03778446f, -0.03751875f, 
    0.05193977f, 0.02259259f, -0.03965238f, -0.08339739f, 0.03647047f, 0.01546178f, 0.01080812f, -0.01307172f, 
    0.00051727f, -0.06579094f, 0.05663827f, 0.04205772f, -0.05860918f, 0.06294590f, -0.03289811f, 0.01772604f, 
    0.06394540f, 0.07128187f, -0.06995454f, -0.06216855f, -0.04161902f, -0.06271772f, 0.01309771f, 0.00804473f, 
    0.06263620f, 0.07760606f, 0.05153591f, 0.02803957f, -0.05182337f, -0.06410038f, 0.03620923f, -0.06817302f, 
    -0.06840784f, 0.01844913f, 0.04278153f, -0.08219423f, 0.00136189f, 0.02048662f, -0.09901477f, 0.00205781f, 
    0.00381687f, -0.04023137f, 0.00140396f, -0.04906862f, 0.01749527f, -0.00782530f, 0.06271555f, -0.01972981f, 
    -0.05543092f, -0.07033065f, -0.02663744f, -0.04827414f, 0.02089641f, 0.04452973f, -0.03851761f, -0.06645852f, 
    0.01467065f, 0.00831868f, 0.01684066f, -0.05793687f, -0.06061580f, -0.07682714f, 0.03952482f, 0.02500047f, 
    -0.05256414f, -0.06897677f, -0.05943552f, -0.03483055f, 0.00632533f, -0.03936126f, -0.05929736f, 0.01270002f, 
    -0.00491630f, -0.03656609f, 0.00443128f, -0.06151344f, -0.01173829f, 0.03590012f, 0.04965641f, 0.01927697f, 
    -0.05444742f, 0.04054550f, 0.03176377f, -0.07028401f, -0.05527333f, 0.02644297f, 0.04970698f, -0.00180562f, 
    0.01812888f, -0.02163677f, -0.01044708f, 0.01457095f, 0.02363303f, 0.04227199f, -0.05657566f, -0.08386741f, 
    -0.04838895f, 0.04042847f, 0.04910450f, 0.04022625f, 0.04184688f, -0.03010214f, 0.00314471f, -0.04813424f, 
    0.02098106f, -0.08434857f, -0.01496817f, 0.03954260f, -0.03258202f, -0.03951908f, 0.04715994f, 0.05659496f, 
    0.13025239f, 0.13300683f, 0.10739328f, 0.07855584f, 0.14321238f, 0.04520549f, 0.10662191f, 0.14776513f, 
    -0.06232280f, -0.01506705f, 0.07660516f, 0.11992666f, -0.12818304f, 0.00831075f, 0.07109768f, -0.05156298f, 
    0.09973589f, 0.02620452f, -0.05606439f, 0.02387111f, 0.02817196f, 0.07974093f, 0.00544485f, 0.06028040f, 
    -0.24147344f, 0.04704266f, -0.08792274f, 0.10818804f, -0.06122629f, 0.12991774f, 0.01834416f, -0.02001012f, 
    0.08370321f, 0.03547706f, -0.03460832f, 0.05373179f, 0.11461985f, 0.03796592f, 0.13460173f, 0.16880012f, 
    -0.03142553f, -0.00718657f, -0.02907473f, -0.04140749f, 0.07572993f, 0.03369858f, -0.01637484f, -0.04401217f, 
    -0.17380561f, -0.29777497f, 0.09908281f, 0.10564357f, -0.05578621f, 0.14734001f, -0.00645929f, 0.07713105f, 
    -0.13245679f, 0.03677902f, -0.04654847f, -0.03479860f, -0.15011773f, 0.06252064f, 0.06656940f, -0.04833974f, 
    -0.01386946f, 0.04267154f, -0.14525111f, -0.02293683f, -0.07475536f, 0.01519399f, -0.06588236f, 0.08184844f, 
    -0.00850620f, 0.08500003f, -0.03819771f, 0.05923408f, -0.04674454f, -0.00042192f, 0.08275615f, 0.00160850f, 
    0.05251724f, 0.11180582f, 0.03680765f, -0.03264105f, -0.01126394f, -0.24184929f, 0.02077176f, -0.09626550f, 
    -0.11116715f, -0.10380013f, 0.03780059f, -0.07080065f, 0.10951906f, -0.03569948f, -0.09179941f, -0.01922487f, 
    -0.14903882f, 0.02965411f, 0.03536836f, -0.10423978f, 0.09577949f, 0.04220056f, -0.09618289f, -0.10106768f, 
    0.05224456f, -0.06652653f, 0.00615653f, 0.00953918f, -0.09115096f, 0.07462842f, -0.02846254f, 0.07597803f, 
    0.00946151f, 0.07488832f, 0.13953269f, -0.09599245f, 0.01171827f, 0.04744086f, 0.07089949f, 0.03005579f, 
    -0.12100434f, 0.05890674f, 0.07268076f, -0.01575827f, -0.00026611f, 0.08221439f, -0.11891750f, 0.00779255f, 
    0.01777042f, 0.06275630f, -0.02230356f, -0.07589105f, 0.23011877f, 0.15475170f, 0.16489992f, -0.08961735f, 
    0.03293435f, -0.00688921f, -0.06172162f, 0.08226208f, 0.04830140f, -0.11828819f, -0.04374167f, 0.01658574f, 
    -0.30251312f, 0.04894960f, 0.11999541f, -0.03422686f, 0.05890109f, 0.03862250f, 0.01695054f, -0.00725684f, 
    0.07614267f, 0.07654908f, -0.08964125f, -0.07456794f, -0.14024365f, 0.13765600f, -0.01322691f, -0.08480578f, 
    0.10779185f, -0.02548030f, -0.01657720f, -0.02267034f, -0.02367647f, 0.05349690f, -0.04597738f, 0.05845005f, 
    0.02095194f, -0.01188125f, -0.01993412f, -0.13584235f, -0.03865937f, 0.00360773f, 0.03388980f, 0.01860997f, 
    -0.08004018f, 0.08479778f, 0.00451625f, 0.08753783f, 0.03761410f, 0.00808003f, 0.17124775f, 0.04766594f, 
    0.01658810f, 0.05122302f, 0.05073911f, 0.08129677f, -0.06403007f, 0.05237536f, 0.01285709f, 0.02241337f, 
    -0.01775634f, -0.04179266f, -0.04666369f, -0.07415447f, 0.07079990f, -0.04260429f, 0.02354920f, 0.01330201f, 
    -0.04971756f, -0.00979361f, -0.04902688f, 0.00454235f, -0.00845341f, 0.04434236f, -0.03682905f, 0.05887381f, 
    -0.00607203f, -0.04524811f, -0.03699256f, -0.02253235f, 0.04899620f, -0.00963768f, 0.04444153f, -0.06722929f, 
    -0.04343751f, -0.06208392f, -0.07570742f, -0.02386336f, -0.03553256f, -0.01853773f, 0.02709485f, -0.02249155f, 
    -0.04361318f, 0.01424513f, -0.05114831f, 0.02371924f, -0.03081890f, -0.06717604f, -0.03259156f, 0.00771943f, 
    0.01894388f, 0.06530752f, -0.02845492f, -0.02963480f, 0.05463525f, -0.07574704f, -0.05369654f, 0.01686868f, 
    0.02605777f, -0.03596757f, 0.01287282f, 0.05565981f, 0.01672743f, 0.05054032f, 0.05766435f, -0.00830241f, 
    -0.02940372f, -0.04359080f, -0.04008053f, 0.00468234f, -0.07612375f, 0.00266553f, -0.05210929f, -0.06319141f, 
    -0.00089161f, 0.04904325f, -0.02090493f, -0.01044868f, -0.02868384f, -0.07657122f, -0.00449988f, -0.00745223f, 
    0.03223637f, -0.06856140f, -0.02044962f, 0.03316234f, 0.05557983f, -0.02841668f, 0.00248028f, -0.03676324f, 
    -0.03670778f, -0.05799595f, -0.01241903f, -0.05559780f, 0.04136829f, -0.00566729f, -0.04546524f, -0.05494835f, 
    -0.05174904f, -0.01555097f, -0.03362340f, 0.02038097f, 0.05407166f, -0.02251645f, -0.07286914f, -0.03122650f, 
    -0.03652328f, 0.00853154f, 0.02087259f, 0.01799388f, -0.00940071f, -0.00132852f, -0.02958099f, -0.06472645f, 
    0.05655143f, -0.05287452f, 0.03631095f, 0.05885054f, -0.00150220f, -0.05603062f, -0.01382674f, -0.01196354f, 
    0.03402317f, 0.03077241f, -0.04850115f, 0.05895387f, -0.03338940f, 0.04029280f, -0.03372409f, -0.02873977f, 
    -0.07446417f, 0.03640229f, -0.02326430f, 0.02412683f, -0.04496206f, -0.04425010f, 0.05184809f, -0.04894864f, 
    0.02445450f, -0.05650270f, -0.05619510f, -0.06940047f, 0.04456546f, -0.03691210f, 0.05198974f, 0.01712354f, 
    -0.00107476f, 0.01089227f, -0.06818280f, -0.07390498f, -0.05402160f, 0.02767445f, -0.00501797f, 0.05558072f, 
    -0.04520027f, -0.00662341f, -0.05084324f, 0.00825285f, -0.00128112f, 0.00345062f, -0.06122649f, 0.07448018f, 
    -0.02430943f, -0.00946448f, -0.05230639f, 0.06219843f, 0.00048861f, 0.02097581f, 0.02610244f, 0.00401093f, 
    -0.06975115f, 0.00382761f, -0.07119828f, 0.06242312f, -0.01124135f, 0.00761880f, 0.04167125f, 0.03596542f, 
    -0.06565958f, 0.04807629f, 0.05527450f, -0.00921000f, -0.04088614f, 0.06537380f, -0.04742463f, -0.05828874f, 
    -0.06486257f, 0.00061513f, 0.00824352f, 0.02073509f, 0.02597899f, -0.03897423f, 0.03512256f, -0.01498691f, 
    -0.00297245f, 0.00882632f, -0.07460395f, -0.07143909f, -0.06062201f, -0.07482903f, -0.01076972f, 0.04519150f, 
    0.05152840f, 0.05115075f, -0.01428283f, 0.04727751f, 0.01545644f, -0.06108401f, 0.05756671f, 0.18352480f, 
    0.04769315f, -0.03369040f, 0.15963626f, 0.03447360f, -0.20354582f, -0.12244763f, -0.09814815f, -0.18653680f, 
    -0.01794970f, 0.12662579f, -0.00776128f, -0.03196621f, -0.05033822f, -0.01234504f, 0.15016527f, 0.13070904f, 
    0.03047397f, -0.18255422f, 0.11498842f, 0.03741616f, 0.04301564f, 0.04484773f, -0.09622119f, -0.07141197f, 
    0.11747598f, 0.02902908f, 0.07144053f, 0.20260760f, -0.03875874f, 0.10288355f, -0.15052892f, -0.17952345f, 
    0.03918315f, -0.00113118f, 0.07430518f, -0.10504237f, -0.03144182f, 0.09876712f, -0.02236084f, -0.01175103f, 
    -0.09418841f, 0.08014714f, 0.05451743f, -0.16132009f, -0.03123939f, 0.07384247f, -0.02887571f, 0.00403519f, 
    0.18442178f, 0.15554947f, 0.06112337f, 0.05232181f, -0.01425753f, 0.15578079f, -0.13289346f, 0.01352884f, 
    0.04178756f, -0.10334947f, -0.05289078f, 0.13935213f, -0.02009720f, -0.06259008f, -0.05193460f, 0.03651750f, 
    -0.02043872f, 0.11810706f, 0.08593500f, 0.11728638f, 0.10787664f, 0.00595473f, -0.08596765f, 0.19465436f, 
    0.09328566f, -0.10007710f, 0.19416982f, -0.10713662f, -0.09805106f, -0.07524028f, -0.14176020f, 0.05462771f, 
    -0.01030054f, -0.00638400f, -0.09040531f, -0.06499790f, 0.13471593f, -0.07264584f, -0.07641155f, -0.16794470f, 
    -0.23594083f, -0.22892192f, -0.09277686f, -0.04032142f, 0.07885602f, 0.03547182f, -0.01549101f, 0.02775322f, 
    0.12677529f, 0.02375114f, 0.00326906f, 0.10087311f, 0.11838690f, -0.22686660f, 0.00988813f, -0.02209941f, 
    0.00041037f, 0.07044261f, 0.22155681f, 0.00504176f, -0.00708724f, 0.00229831f, 0.05023643f, 0.11684664f, 
    -0.28452268f, 0.37476119f, -0.09071265f, -0.28281406f, -0.08985212f, 0.07683870f, 0.04923326f, 0.03012475f, 
    -0.04522040f, 0.03334449f, -0.09660979f, 0.03158439f, -0.22420692f, -0.01697947f, 0.12477815f, 0.13232665f, 
    -0.00332035f, 0.13470617f, -0.07610939f, 0.01237166f, 0.15096229f, 0.06225710f, 0.00188643f, 0.02762397f, 
    -0.44519061f, 0.26160336f, -0.14042060f, 0.08887583f, 0.23102966f, 0.07564058f, 0.19111973f, 0.04030315f, 
    -0.04747551f, 0.14425094f, 0.04247776f, -0.03422986f, 0.44227868f, -0.22574121f, -0.12814388f, 0.09008949f, 
    -0.08117871f, -0.04838151f, -0.12946206f, 0.02080694f, 0.12356997f, 0.01554053f, -0.09355808f, 0.11514085f, 
    -0.35132685f, 0.06165858f, -0.05920077f, 0.15345027f, 0.19643541f, 0.03272984f, -0.02771406f, -0.01317303f, 
    0.06314717f, 0.09757812f, 0.02264636f, 0.06682762f, -0.37438461f, -0.04526822f, -0.02458163f, -0.07789674f, 
    -0.01767140f, 0.03308867f, -0.12207103f, 0.03158690f, -0.12169573f, -0.06605618f, 0.06916445f, 0.09649195f, 
    -0.00983164f, 0.16315928f, 0.10701885f, 0.04851150f, 0.16067915f, 0.06121361f, 0.03868862f, -0.06617042f, 
    0.13046223f, 0.09596265f, -0.10335672f, 0.01322469f, 0.07716110f, 0.16724007f, -0.03024033f, 0.01755912f, 
    0.01528340f, 0.09060469f, -0.02522170f, -0.10493270f, -0.07908420f, -0.06446204f, 0.13473128f, -0.08833005f, 
    0.06095827f, 0.03120411f, 0.05682681f, 0.04069032f, -0.09930838f, 0.00850373f, -0.00468042f, 0.03798048f, 
    0.08883078f, -0.00616208f, -0.03486178f, 0.12034778f, 0.22164714f, -0.01296701f, 0.04873939f, 0.14230469f, 
    0.03427541f, -0.03222542f, -0.04341076f, 0.02395800f, -0.02896282f, 0.05013473f, 0.05297037f, 0.03265473f, 
    0.27910444f, -0.14954707f, 0.05704089f, -0.01248790f, 0.05322145f, 0.03472165f, -0.02563749f, -0.13468806f, 
    -0.11160750f, 0.03500772f, -0.06556176f, -0.06806677f, 0.11924667f, 0.11695956f, 0.20506793f, 0.12138440f, 
    0.01036491f, 0.18695834f, 0.05188891f, -0.07375219f, 0.09588131f, 0.00193322f, -0.05088644f, -0.00854837f, 
    -0.10578501f, -0.00828444f, 0.05989437f, -0.03350799f, -0.05778103f, -0.03190104f, -0.01882905f, -0.11744628f, 
    0.00199089f, 0.02792485f, 0.11821055f, 0.08044859f, 0.15041168f, -0.34308168f, -0.14891298f, 0.09412264f, 
    0.11112822f, 0.00205694f, 0.00868682f, -0.06227560f, 0.00044292f, -0.02149196f, 0.05195143f, 0.07643077f, 
    -0.08782778f, 0.06571402f, -0.01629254f, -0.04834724f, 0.04229178f, -0.04479051f, 0.02172738f, -0.11182629f, 
    -0.07245542f, 0.03007529f, -0.03513062f, 0.06363159f, -0.03757834f, 0.04448064f, -0.03950008f, 0.14565997f, 
    -0.02808123f, 0.05570719f, 0.02392237f, -0.03544249f, -0.02362075f, 0.08200148f, 0.00777165f, -0.12475603f, 
    0.04601225f, -0.12927303f, 0.16922574f, 0.10337898f, 0.05379190f, -0.02356621f, 0.07908030f, -0.06052497f, 
    -0.00627189f, -0.00771818f, 0.13520007f, -0.01830237f, 0.24854840f, -0.16790022f, 0.19018921f, -0.13874125f, 
    0.05249108f, -0.00947012f, -0.06522870f, 0.05309784f, 0.02489499f, 0.01009458f, -0.01652244f, -0.00578895f, 
    -0.03427996f, 0.03351468f, 0.04846307f, -0.13059880f, 0.01340234f, -0.09340711f, 0.00587571f, -0.10238955f, 
    -0.01509089f, 0.13013658f, -0.03928902f, 0.09080300f, -0.10092086f, 0.10808644f, -0.12174779f, -0.12949893f, 
    0.16977520f, -0.05160008f, -0.10957643f, -0.12616320f, -0.03243752f, -0.06828622f, 0.01281435f, 0.06347895f, 
    0.09795318f, -0.08118010f, -0.01916954f, -0.06788318f, -0.06355090f, 0.06739803f, 0.06390142f, -0.10873450f, 
    0.06657322f, 0.02843045f, 0.09595587f, -0.07271551f, 0.04554150f, 0.06389400f, 0.24729607f, 0.01050179f, 
    0.00940019f, -0.01013793f, -0.08557607f, -0.04697804f, -0.04136790f, 0.00769892f, 0.00347935f, -0.00180773f, 
    -0.23045695f, -0.08675396f, -0.08358074f, -0.00091781f, -0.02013916f, 0.11696298f, -0.03618304f, -0.02965990f, 
    0.08288196f, 0.03392131f, 0.03040565f, -0.06775323f, 0.02876308f, -0.12997459f, 0.01435782f, 0.07046295f, 
    -0.03635997f, 0.04182086f, 0.02402347f, 0.02125125f, 0.01654239f, 0.04693614f, 0.01720219f, 0.01889032f, 
    0.35016605f, -0.00918919f, 0.10501067f, -0.05980713f, -0.01393074f, 0.02713609f, 0.14651577f, 0.05199295f, 
    0.01301020f, -0.01746879f, 0.08007572f, 0.09719783f, -0.10585998f, -0.00653912f, -0.07256427f, -0.08598952f, 
    -0.00289163f, 0.07768942f, 0.03925255f, 0.07582661f, -0.07348773f, -0.01177064f, 0.14247650f, 0.03771894f, 
    0.22334765f, 0.25360268f, 0.03040051f, -0.02756313f, 0.02755428f, 0.04154952f, 0.07658575f, -0.03601281f, 
    0.11313492f, -0.01219743f, 0.10652629f, 0.11113575f, 0.00284058f, -0.26388523f, -0.03102170f, 0.00163008f, 
    0.08792709f, 0.05150815f, 0.12105555f, 0.04124644f, -0.03171292f, 0.07354102f, -0.01504404f, 0.00935754f, 
    0.17505561f, -0.06334112f, -0.07288499f, 0.03631652f, 0.07745402f, 0.06899481f, -0.05915480f, 0.00915300f, 
    -0.04575056f, -0.06179728f, 0.03560869f, 0.06724149f, 0.22581406f, 0.21521877f, -0.25028306f, -0.01733749f, 
    0.15700172f, 0.05026516f, -0.06957244f, -0.07998844f, 0.04472035f, -0.04538243f, -0.04427079f, 0.13553308f, 
    0.10890803f, 0.09811784f, -0.06574252f, 0.18277769f, 0.05572195f, 0.05600030f, 0.08359248f, 0.09316615f, 
    0.04322848f, 0.10263091f, -0.03157870f, -0.00743601f, -0.09941365f, -0.10417730f, 0.12133087f, -0.07783721f, 
    0.13064753f, -0.01553498f, -0.00397836f, 0.11649564f, 0.07383139f, 0.01943437f, 0.01707746f, -0.01329025f, 
    0.27822852f, -0.11275171f, -0.02394121f, 0.04236275f, -0.00710244f, 0.14505185f, 0.08854352f, 0.08008000f, 
    0.02860039f, -0.10345782f, -0.06372450f, 0.07093368f, -0.14253500f, 0.01904137f, -0.14531057f, -0.12823640f, 
    -0.06589017f, 0.06821117f, -0.01820120f, 0.01494604f, -0.06321468f, -0.02044903f, 0.04728876f, 0.05007698f, 
    0.10036637f, -0.03260900f, -0.01714779f, 0.17904022f, 0.06322208f, -0.03087910f, 0.07603561f, 0.02625253f, 
    -0.02001502f, 0.01571309f, 0.11609855f, 0.03166363f, 0.01629650f, 0.09965508f, 0.05076718f, 0.01185595f, 
    0.12593079f, -0.04341305f, 0.01562924f, 0.09229033f, 0.09512739f, 0.07734957f, 0.04518816f, -0.04825984f, 
    -0.01048944f, 0.08296864f, -0.05805292f, 0.18403132f, 0.08526693f, -0.05834964f, -0.06852885f, 0.01625697f, 
    -0.03538192f, 0.05536641f, -0.04937817f, 0.01795927f, 0.04704192f, -0.01335783f, -0.12704420f, 0.03586458f, 
    -0.05506235f, 0.03923459f, -0.00245015f, -0.08798565f, 0.03769794f, -0.09387255f, -0.08878034f, 0.01479656f, 
    0.32777822f, -0.03192280f, 0.15145496f, -0.10245035f, -0.07040104f, 0.05138630f, -0.10439231f, -0.05616908f, 
    -0.02660126f, 0.01388764f, 0.04048895f, -0.02431574f, -0.21359982f, -0.00188588f, -0.07677148f, 0.01648531f, 
    0.12360201f, -0.03103909f, -0.01378651f, -0.00124312f, 0.00161535f, 0.01078825f, 0.07496001f, -0.01604548f, 
    -0.50693440f, -0.00393998f, 0.09297752f, 0.09567349f, -0.00595332f, 0.10899392f, 0.16605435f, 0.08067913f, 
    0.09108867f, -0.01679904f, 0.01148602f, 0.02118771f, -0.02675067f, -0.06340404f, 0.01436158f, -0.05501066f, 
    0.06834222f, 0.12469808f, 0.03767506f, -0.08211762f, -0.00052295f, 0.10280089f, -0.17567360f, -0.07126213f, 
    -0.41352269f, -0.03424542f, -0.08579189f, 0.10856606f, 0.01954963f, 0.08583403f, 0.10731869f, 0.02249478f, 
    -0.00453708f, -0.04780832f, -0.06327458f, 0.02195938f, 0.20359351f, -0.03188661f, 0.05609088f, -0.16218357f, 
    -0.13090904f, -0.00495358f, 0.02548795f, 0.06783027f, 0.01919362f, 0.12835585f, 0.05517817f, -0.02548594f, 
    0.11895738f, -0.02240117f, 0.19492504f, -0.03200088f, 0.04472922f, 0.10614383f, 0.03660803f, -0.09984234f, 
    -0.06248970f, 0.07196618f, 0.09394603f, 0.01556974f, -0.35419446f, -0.00176263f, 0.00329334f, -0.14189959f, 
    0.07720350f, -0.01734329f, 0.03095703f, 0.06342133f, -0.02562054f, -0.00617019f, -0.10935583f, -0.05691572f, 
    -0.08632134f, -0.13011740f, -0.08666562f, -0.08184656f, -0.05586681f, -0.07409127f, -0.09152166f, 0.12906021f, 
    0.00584013f, -0.05757339f, 0.09689616f, 0.07927860f, 0.26243171f, 0.10157102f, -0.06849647f, 0.00382865f, 
    -0.12091933f, -0.02366588f, 0.01334306f, 0.03641468f, 0.02445880f, -0.06093979f, 0.03371866f, 0.05258112f, 
    0.29625776f, 0.32378715f, -0.00664912f, 0.04982111f, -0.12892701f, -0.05905117f, 0.03256612f, 0.09652883f, 
    -0.02465494f, 0.07471410f, 0.08344392f, -0.06475427f, 0.15136489f, -0.11004477f, 0.00616077f, 0.18243298f, 
    0.19441891f, 0.02079949f, 0.13533801f, 0.06962386f, 0.06210600f, 0.01817339f, -0.14625017f, -0.00807544f, 
    0.42604563f, -0.00880628f, 0.07535634f, 0.14249165f, -0.12214778f, 0.03237586f, -0.11774281f, 0.00898187f, 
    0.07947186f, 0.01635049f, 0.01885027f, 0.10859690f, -0.18713246f, -0.00176010f, -0.06431651f, 0.07207146f, 
    -0.14205810f, 0.05981361f, 0.00518910f, -0.02157885f, 0.04231489f, -0.08782013f, 0.06479502f, -0.00510412f, 
    0.24011372f, 0.05372195f, 0.05561812f, 0.14438769f, -0.14229439f, -0.05324499f, 0.01385420f, -0.04905341f, 
    0.08737984f, 0.05470518f, -0.04088975f, 0.09022002f, -0.11679801f, -0.11400466f, -0.14222296f, -0.09118158f, 
    -0.00331444f, 0.04213307f, -0.02500602f, 0.03800173f, -0.01439063f, -0.04571410f, 0.02669595f, 0.02991671f, 
    0.09478884f, 0.11741719f, -0.12642923f, -0.09730988f, 0.05811871f, -0.03669930f, 0.01869736f, 0.01849983f, 
    -0.04660092f, 0.07333266f, 0.09677661f, 0.03370024f, -0.28583106f, 0.02261400f, -0.01380231f, 0.02639932f, 
    -0.00294001f, 0.03757340f, -0.02872998f, 0.12974058f, 0.00434695f, -0.01732533f, -0.13867171f, 0.03743669f, 
    -0.03826141f, 0.10298876f, 0.15537380f, 0.13438633f, -0.00831403f, 0.15287346f, -0.00209334f, 0.15471096f, 
    0.13466789f, 0.03003919f, 0.07323164f, -0.15728717f, -0.04145516f, -0.12817499f, 0.02509783f, 0.10799802f, 
    -0.05591682f, -0.15208966f, -0.03745052f, 0.02448753f, -0.07940270f, 0.06103781f, 0.04084334f, -0.12136776f, 
    -0.33147302f, -0.01481787f, 0.13407232f, 0.24575286f, -0.07127982f, 0.06995539f, 0.05999296f, 0.21610662f, 
    0.02725708f, 0.05275970f, 0.05035106f, -0.01714812f, -0.19224165f, 0.04919660f, 0.05732353f, -0.08469674f, 
    0.07834229f, 0.00391903f, -0.02181006f, -0.05342256f, -0.04914887f, -0.07956993f, -0.00582603f, -0.11161605f, 
    -0.08436030f, 0.03715716f, 0.01125268f, 0.07548951f, 0.03352623f, 0.05441739f, 0.01833801f, 0.04446079f, 
    0.05766850f, -0.00123900f, -0.07842228f, -0.19887489f, 0.09178784f, 0.13062720f, 0.28653061f, -0.07202869f, 
    0.10659092f, -0.10212241f, 0.00579515f, 0.09025328f, 0.02742053f, -0.12729858f, -0.15190108f, -0.19871768f, 
    -0.24454193f, 0.01138945f, 0.12923607f, -0.09447300f, 0.00962546f, 0.05016742f, 0.04118879f, 0.07425155f, 
    -0.05111931f, -0.09292655f, 0.12428365f, 0.10343741f, -0.26676935f, -0.30919570f, -0.03031082f, 0.07667096f, 
    0.03328517f, -0.01781946f, 0.14537124f, -0.06143908f, 0.11809748f, 0.11590850f, 0.02196492f, 0.15458843f, 
    -0.11830366f, 0.00678814f, -0.05312182f, -0.15165012f, -0.00224503f, 0.13208035f, -0.02934837f, 0.16024283f, 
    0.02823806f, 0.08417920f, -0.04657771f, 0.03895592f, 0.03959173f, -0.02335850f, 0.15482907f, -0.23567478f, 
    0.07636505f, 0.06889082f, 0.03670676f, -0.08004323f, 0.01693118f, -0.05771653f, -0.09845962f, 0.05354255f, 
    -0.01710772f, 0.21675678f, 0.04422127f, 0.05294701f, 0.01542807f, 0.06599495f, 0.06733892f, 0.02575523f, 
    -0.01496570f, 0.00263736f, -0.02224657f, 0.08812077f, 0.30605859f, 0.18869878f, 0.14654925f, -0.11612402f, 
    -0.18775822f, 0.09827457f, -0.02451636f, -0.03538800f, 0.12559307f, -0.00457899f, 0.07055486f, 0.03150646f, 
    0.01800587f, -0.09960410f, 0.01010690f, -0.04384888f, -0.02000220f, -0.03801784f, 0.13160941f, -0.01554888f, 
    0.02175979f, 0.09308872f, 0.05632075f, -0.01775651f, 0.27142599f, 0.02809165f, -0.03055733f, -0.02108215f, 
    0.12538400f, -0.08990762f, 0.08578763f, 0.10680918f, -0.03672548f, 0.10598788f, 0.14733207f, -0.05851208f, 
    0.07205597f, 0.13358708f, 0.18403023f, 0.12314944f, -0.04234336f, -0.00147964f, -0.01146171f, 0.17632835f, 
    0.00126223f, 0.10608547f, 0.05968422f, 0.00843089f, -0.04433744f, 0.00343797f, 0.06313959f, 0.03500829f, 
    -0.03751704f, 0.07414113f, -0.04451562f, -0.01594271f, -0.03554967f, 0.10028499f, 0.07189472f, -0.02926306f, 
    -0.34287110f, 0.10314526f, 0.02447321f, 0.03713322f, 0.07442746f, 0.02565610f, 0.09452806f, -0.03424827f, 
    0.06300449f, -0.00688300f, 0.01930805f, 0.15848507f, 0.14196108f, -0.10523842f, 0.02035346f, -0.01208324f, 
    -0.11821599f, 0.09802045f, 0.01028062f, 0.01148667f, 0.04997894f, -0.06413604f, -0.09268814f, 0.02975386f, 
    0.02173282f, -0.36047783f, 0.12832402f, 0.00917311f, -0.02826807f, 0.10956852f, 0.06107166f, -0.09478503f, 
    -0.01762624f, -0.00848468f, 0.02236598f, 0.03863197f, -0.07563922f, -0.00138971f, 0.10951956f, 0.04407566f, 
    -0.09685663f, 0.04836508f, -0.04812944f, -0.03160550f, -0.04640134f, 0.18953288f, -0.16102937f, 0.06546435f, 
    0.25942439f, 0.11397821f, -0.08633237f, 0.25689203f, -0.01381469f, -0.04494639f, 0.10671308f, -0.09760904f, 
    0.06460975f, 0.04122116f, 0.12704025f, 0.04061700f, -0.28848237f, -0.24675208f, -0.22687970f, -0.08980417f, 
    0.08697101f, -0.06538373f, -0.15490018f, -0.05616466f, 0.04440808f, -0.06453033f, -0.00238182f, -0.02530522f, 
    -0.03972781f, 0.03534348f, -0.21913986f, 0.12247918f, 0.06495873f, -0.11014880f, -0.06128000f, -0.14021391f, 
    0.17210689f, 0.11613842f, 0.08032685f, 0.05512023f, -0.09597072f, 0.15383986f, 0.06914297f, 0.19749826f, 
    -0.05863293f, 0.01121567f, 0.03659225f, -0.01194034f, 0.00232741f, 0.01529480f, 0.05262036f, -0.05985798f, 
    0.03372430f, 0.05467910f, 0.07452245f, -0.04984376f, 0.05543980f, 0.00350826f, 0.10185549f, 0.06414043f, 
    0.14151491f, 0.06021473f, 0.02840275f, -0.00697977f, 0.11296610f, 0.09105178f, -0.01016793f, -0.10097498f, 
    0.01455314f, -0.09243599f, -0.03845814f, -0.00046717f, -0.02776479f, -0.03042177f, 0.11160176f, 0.12500361f, 
    -0.04284944f, -0.12851828f, 0.10201438f, 0.17137706f, 0.04820308f, 0.07942066f, 0.02967251f, 0.10109273f, 
    -0.00415545f, 0.08062647f, 0.06112364f, 0.00374435f, -0.29323462f, 0.10711922f, -0.19634324f, -0.08989488f, 
    0.18185546f, -0.09056938f, -0.03033751f, -0.10216675f, -0.11836842f, -0.01225186f, -0.00115893f, -0.06192152f, 
    0.24585974f, 0.07808917f, -0.04679066f, 0.05243655f, -0.04753816f, -0.06795027f, -0.09193491f, 0.00262778f, 
    -0.01294613f, 0.10037383f, -0.12006970f, 0.02107369f, 0.04312103f, 0.04455777f, -0.11988460f, -0.03807870f, 
    0.08347111f, 0.09340766f, -0.12276247f, -0.08129060f, -0.00651971f, -0.03466795f, 0.03569543f, 0.15156582f, 
    0.13194315f, 0.11198775f, 0.09132095f, 0.10046764f, 0.01968681f, 0.05469869f, -0.03318497f, 0.04624215f, 
    0.04080138f, 0.13360144f, 0.07645845f, 0.06495707f, -0.16845986f, 0.04463881f, -0.08680392f, -0.12623492f, 
    -0.06293148f, -0.00629532f, 0.02931731f, -0.02169432f, 0.01983280f, -0.02029453f, 0.00716668f, 0.09088370f, 
    -0.01426879f, -0.02573545f, 0.11465593f, 0.06010737f, -0.08922041f, 0.03737315f, -0.01284536f, 0.08416172f, 
    0.09928505f, -0.07251995f, 0.15469457f, 0.05803715f, 0.04128338f, 0.04634253f, 0.14741826f, -0.00858157f, 
    0.11565685f, -0.14205961f, -0.02170631f, 0.13518691f, -0.01572158f, 0.09602930f, -0.08305993f, -0.07227087f, 
    -0.25046769f, -0.05375248f, -0.10167544f, 0.07615551f, 0.03815674f, 0.07091244f, 0.05053017f, 0.15208165f, 
    0.01609866f, 0.10637175f, -0.06552511f, 0.06805222f, 0.08922994f, 0.01080886f, -0.00991499f, -0.02427570f, 
    0.05833911f, 0.07332866f, 0.02485240f, 0.00886904f, -0.05300078f, -0.01408478f, 0.02250408f, 0.02720789f, 
    0.10107004f, -0.00148332f, 0.14569965f, 0.09165305f, 0.01633862f, 0.05192284f, 0.00858887f, -0.07783968f, 
    -0.00348354f, -0.02855979f, 0.11542573f, -0.04022568f, -0.14845400f, -0.30335540f, 0.03189087f, 0.07949931f, 
    0.22379050f, -0.07233067f, -0.00815455f, 0.01566731f, 0.05685233f, -0.07001293f, 0.00110873f, -0.12834099f, 
    -0.38771531f, 0.00404711f, -0.14314653f, -0.19339770f, 0.06294496f, -0.04710435f, -0.04303570f, -0.03903306f, 
    -0.10452113f, -0.08511911f, 0.10584481f, 0.03820881f, -0.18088268f, -0.07882269f, 0.09653438f, 0.07754650f, 
    0.00913511f, -0.03841744f, 0.07565199f, 0.03973152f, 0.01043151f, -0.02470783f, 0.02554693f, 0.07825820f, 
    0.22232845f, 0.30945379f, 0.11904421f, -0.08383028f, -0.03493120f, 0.06573792f, -0.00805416f, 0.15897831f, 
    0.03674214f, -0.01055558f, -0.05488423f, 0.01798331f, 0.16804631f, -0.21497998f, 0.05975598f, -0.17844540f, 
    0.04051748f, 0.01479259f, -0.12050184f, 0.01458019f, 0.07408314f, -0.02575671f, -0.06208203f, 0.08713226f, 
    0.10636442f, 0.13636430f, 0.22071202f, 0.11819444f, 0.06937414f, 0.08388744f, 0.07946113f, -0.00815093f, 
    0.01225446f, 0.17184944f, -0.02045907f, 0.07492827f, -0.01775379f, -0.13036011f, -0.09125047f, 0.00862880f, 
    0.03075908f, 0.07413576f, 0.07942747f, -0.05381927f, 0.09312455f, 0.09609691f, 0.02327839f, -0.03438809f, 
    0.18495356f, -0.00418186f, 0.10531700f, 0.06086440f, 0.09723942f, -0.00273115f, 0.01682845f, -0.13929604f, 
    0.11658017f, 0.16153347f, -0.03656900f, -0.07208403f, 0.02583834f, -0.14281808f, -0.08523126f, -0.01390061f, 
    0.03013944f, -0.09653233f, 0.03509686f, 0.12070269f, -0.00794546f, -0.00036111f, -0.01480606f, 0.04966779f, 
    -0.18624669f, 0.11397174f, -0.10677849f, 0.08228710f, 0.17223760f, -0.10689997f, 0.12364638f, 0.11033693f, 
    -0.05570346f, 0.02738889f, 0.01014418f, 0.10862888f, -0.11800899f, 0.04186852f, -0.11007179f, 0.02495544f, 
    0.03133149f, 0.08233841f, 0.02229094f, 0.11746741f, -0.01279689f, -0.00261270f, 0.11726926f, 0.04563343f, 
    -0.00140027f, -0.10883785f, 0.11046492f, -0.02011055f, 0.14791255f, 0.07621691f, -0.12148369f, 0.01676876f, 
    -0.04986935f, -0.03051629f, 0.05710165f, 0.10762879f, 0.32598373f, 0.07226003f, -0.12432474f, 0.05148015f, 
    -0.16621928f, 0.05227996f, 0.22847129f, -0.08081852f, -0.01491803f, 0.02049611f, 0.06482092f, 0.05175947f, 
    -0.10311537f, -0.07077145f, 0.01195689f, 0.19875081f, 0.04370306f, 0.07001798f, 0.08961886f, 0.01976799f, 
    0.05374800f, 0.11512532f, 0.10536073f, 0.03192041f, -0.09935550f, 0.11372912f, -0.04758096f, 0.05029384f, 
    -0.01624423f, 0.01305788f, -0.12112356f, 0.05529446f, -0.01384769f, -0.03312672f, 0.14294797f, 0.09445179f, 
    0.09513822f, 0.14854173f, 0.01121955f, 0.01499757f, 0.08544791f, -0.03385409f, -0.00533707f, 0.16141418f, 
    0.09558553f, 0.02021376f, 0.00058705f, 0.07830122f, -0.27097654f, -0.04423468f, 0.06054069f, 0.11498892f, 
    0.15657887f, -0.11665763f, -0.02925316f, 0.00900236f, -0.02372343f, 0.04959509f, 0.04544886f, -0.01666107f, 
    -0.16405690f, -0.03289022f, -0.07032756f, -0.10114699f, 0.05194330f, -0.03868584f, 0.01512664f, 0.01548392f, 
    -0.00812879f, 0.01401187f, 0.05754697f, 0.04587842f, -0.30778953f, -0.19352059f, 0.00340875f, 0.33899629f, 
    -0.19085062f, -0.10767411f, 0.05830941f, -0.02787440f, 0.00530890f, 0.05364975f, 0.02888419f, -0.02373591f, 
    -0.31002909f, 0.00803747f, 0.03717513f, 0.03445186f, -0.35813278f, 0.01907615f, -0.09479247f, -0.00515239f, 
    -0.08927529f, 0.07014994f, -0.17108540f, 0.04535376f, -0.17329824f, -0.03498894f, 0.18268831f, -0.41443941f, 
    -0.02238789f, 0.14956185f, -0.08202608f, 0.13896173f, 0.00682867f, -0.07446806f, -0.05382086f, 0.10748459f, 
    -0.36705059f, 0.17293026f, 0.06172397f, 0.03494186f, 0.24435985f, 0.08234952f, 0.13155420f, 0.09380540f, 
    0.06164731f, 0.09668299f, 0.09018137f, 0.07004442f, 0.09237582f, -0.11919414f, 0.00893501f, 0.03732578f, 
    0.25821990f, 0.00387570f, 0.04916713f, -0.03106507f, 0.19560842f, -0.03414679f, -0.02063857f, 0.10131251f, 
    -0.04328346f, 0.12712494f, -0.02758661f, 0.10196155f, 0.02654740f, -0.10442235f, 0.03581910f, 0.10233702f, 
    -0.06961440f, 0.02609006f, -0.07483065f, 0.01644433f, -0.01637833f, 0.04969391f, -0.07693724f, -0.06633423f, 
    0.11590219f, -0.03808092f, -0.04803017f, 0.14328007f, -0.00576710f, 0.08205582f, -0.10419102f, 0.11077630f, 
    0.20189451f, 0.07113003f, 0.07435824f, 0.08810350f, 0.06121526f, 0.01465647f, 0.16189757f, 0.07499497f, 
    0.05163787f, -0.09790733f, -0.03732512f, 0.03121773f, -0.01727003f, -0.09131612f, -0.00851049f, -0.09861042f, 
    0.05463861f, -0.05129976f, -0.09851410f, 0.03611301f, 0.03281503f, -0.08213695f, 0.14734842f, 0.11068072f, 
    -0.20862909f, -0.22109117f, -0.07105141f, -0.15895918f, 0.18785091f, -0.08269238f, 0.00828566f, -0.10733616f, 
    -0.05713552f, -0.00548082f, -0.03968383f, 0.20755057f, -0.02614249f, 0.07838640f, -0.06934740f, -0.08946428f, 
    0.13741577f, 0.15101071f, 0.11500375f, -0.02330122f, 0.11084689f, 0.09800614f, -0.08518037f, 0.09486847f, 
    0.03435800f, 0.10544521f, -0.07934394f, -0.12202213f, 0.04491155f, 0.02461643f, 0.01811159f, -0.14501143f, 
    0.14868946f, 0.02684436f, -0.03518472f, 0.04794329f, 0.13664784f, -0.00090192f, -0.21456617f, 0.10250957f, 
    0.01600171f, -0.02073738f, -0.02986338f, 0.08349280f, 0.04806859f, 0.06728038f, 0.08635654f, 0.09916186f, 
    0.15163633f, 0.04039067f, 0.02669698f, -0.07004533f, 0.06059543f, -0.08598629f, 0.11936584f, 0.04024576f, 
    -0.03279919f, -0.00749568f, 0.09203713f, 0.16224396f, -0.31812707f, 0.01315716f, -0.03023662f, -0.01190603f, 
    -0.09148529f, 0.04184504f, -0.09811958f, 0.01494622f, 0.06561690f, 0.07292227f, 0.17340113f, 0.18252110f, 
    0.24374396f, 0.11128401f, -0.01370329f, -0.10759104f, -0.10498446f, 0.07415119f, 0.00463157f, 0.01230931f, 
    0.12868211f, 0.12967567f, -0.11034405f, -0.12415953f, 0.40370673f, 0.16127656f, -0.09571232f, -0.09157611f, 
    0.06488563f, -0.06056051f, 0.01754939f, 0.13507171f, -0.01645996f, -0.05405039f, 0.07752175f, -0.10346155f, 
    -0.17980440f, 0.21155804f, -0.17843498f, -0.07557323f, -0.09793021f, 0.00686695f, 0.10618327f, 0.01908691f, 
    -0.06381694f, -0.05216816f, 0.07681271f, -0.08083358f, -0.21329506f, 0.16103354f, -0.00912147f, 0.45049310f, 
    -0.09048565f, 0.03896761f, 0.00685525f, 0.05105565f, 0.03945643f, 0.19540632f, 0.12351593f, -0.03107523f, 
    0.15057145f, 0.03169304f, -0.04525820f, 0.06364544f, 0.09684726f, 0.10849114f, 0.03395000f, 0.02504317f, 
    -0.00781292f, -0.04911131f, 0.02327099f, -0.00219852f, -0.09159008f, -0.22294307f, -0.07810145f, 0.16909212f, 
    0.06929407f, 0.00905289f, 0.01580608f, 0.01800742f, 0.08290040f, -0.04945193f, -0.06171271f, 0.03058694f, 
    -0.09474133f, 0.13480106f, -0.09449857f, -0.00205122f, -0.09050234f, 0.04114600f, -0.05545305f, 0.15478797f, 
    0.11652876f, -0.16513366f, -0.06031107f, -0.04458123f, -0.50118339f, 0.04313278f, -0.06685927f, -0.08440239f, 
    0.06090417f, 0.03183134f, -0.12869012f, -0.01546859f, 0.05188043f, -0.06084663f, -0.09674053f, 0.00135884f, 
    -0.50424361f, 0.02411823f, 0.15308541f, -0.01598373f, 0.12163571f, -0.11566367f, 0.22303358f, -0.02504963f, 
    -0.02564228f, -0.01870777f, -0.30409005f, 0.07777511f, 0.23105328f, 0.06385361f, -0.14013150f, 0.15268952f, 
    0.08923818f, 0.04540843f, 0.03851387f, 0.10409010f, 0.01792480f, 0.11494187f, 0.12884375f, -0.03890978f, 
    0.21433096f, 0.01267951f, -0.23200406f, 0.01308698f, -0.01832026f, -0.05299522f, -0.07745868f, -0.04087094f, 
    -0.07834852f, 0.02779398f, -0.05266793f, 0.13542035f, 0.09736350f, 0.32535842f, -0.03651660f, -0.02893391f, 
    0.14737205f, 0.03083683f, 0.11874773f, -0.02635838f, -0.00432648f, 0.01246352f, -0.01433408f, 0.23452763f, 
    -0.01479661f, -0.04500353f, -0.12891647f, -0.18586233f, 0.12904212f, 0.02579737f, -0.06118346f, -0.03105584f, 
    0.08774880f, 0.01999767f, 0.01550372f, -0.02585123f, -0.16031900f, 0.13427016f, -0.00982713f, 0.14501347f, 
    -0.17043605f, 0.04103215f, -0.03731259f, -0.14343221f, -0.01506759f, 0.12075846f, 0.08159149f, 0.20438635f, 
    -0.38728333f, 0.11141726f, -0.02210618f, -0.02776264f, -0.11263242f, -0.05194202f, -0.00369168f, 0.10706396f, 
    0.12266327f, 0.05458537f, 0.06123395f, 0.29620314f, -0.14379008f, 0.04441745f, 0.15617365f, 0.24157140f, 
    0.07774143f, -0.03430030f, -0.02859444f, -0.05304578f, 0.05185149f, 0.07442683f, 0.14332975f, 0.15867049f, 
    0.23270522f, 0.02455852f, 0.05654619f, 0.19748884f, -0.03340086f, 0.02000444f, -0.01145165f, -0.07098330f, 
    0.00821278f, 0.01010605f, 0.00382760f, -0.09440198f, -0.06959575f, 0.19314045f, -0.14713936f, 0.00260341f, 
    -0.16247776f, 0.08258651f, -0.04586156f, -0.05210297f, 0.06809346f, -0.00606897f, 0.04215414f, -0.10838666f, 
    0.02349888f, -0.04329492f, 0.15315446f, 0.10122037f, -0.17581683f, -0.05907621f, -0.04852456f, -0.13576531f, 
    -0.00215059f, 0.04232651f, -0.02957162f, -0.14826570f, -0.25559172f, -0.02486041f, 0.19924477f, -0.05294138f, 
    -0.04985961f, -0.00681766f, -0.08455099f, 0.11837423f, -0.00274723f, 0.10187972f, -0.06398901f, 0.04015746f, 
    -0.43382785f, 0.14066692f, -0.06531495f, -0.13310532f, 0.04308621f, 0.04448441f, 0.00470025f, -0.00087650f, 
    0.04749011f, -0.00200807f, 0.04498000f, 0.09714287f, 0.03666829f, -0.32344210f, 0.22453617f, 0.37485602f, 
    0.12380192f, -0.11954083f, -0.06578770f, 0.01717238f, 0.18370359f, 0.00501893f, -0.12902766f, 0.14306594f, 
    -0.00462471f, -0.00642379f, -0.06740899f, -0.06493758f, 0.09475575f, -0.02714406f, 0.16759937f, -0.00113299f, 
    -0.02384418f, 0.00418023f, 0.03464161f, 0.00970487f, -0.06508993f, 0.05473882f, 0.18698156f, 0.05094890f, 
    0.03495995f, -0.17755350f, -0.03290965f, 0.04853008f, 0.12231224f, 0.08130813f, -0.27480385f, 0.00138510f, 
    0.06107745f, -0.00799950f, -0.04780394f, -0.03621995f, 0.05353431f, -0.04220903f, 0.03264399f, -0.07394120f, 
    -0.00267655f, 0.05622250f, 0.01728757f, -0.03149533f, 0.05968450f, -0.06215543f, 0.00460688f, -0.02199170f, 
    -0.03009069f, -0.06968891f, -0.01659388f, -0.02045890f, -0.07246645f, -0.04071235f, 0.01416172f, 0.04619351f, 
    0.03980780f, -0.03714322f, -0.01333633f, -0.06129695f, 0.01780356f, 0.05111897f, 0.05572140f, -0.01502252f, 
    -0.01142805f, -0.02223228f, -0.07058243f, 0.01266927f, -0.01733597f, 0.00190029f, 0.01107556f, 0.01047263f, 
    -0.00591005f, -0.06993238f, 0.03734302f, 0.05481772f, 0.00392784f, -0.02442702f, 0.00439719f, -0.02250140f, 
    -0.07199527f, -0.00000831f, 0.02292235f, 0.04917896f, 0.02825374f, -0.07314780f, 0.00783771f, 0.03751710f, 
    -0.02467974f, -0.05937758f, 0.02550559f, -0.01401538f, -0.04814247f, 0.02136670f, 0.03615214f, -0.00377594f, 
    0.00904841f, 0.00581247f, 0.01289162f, 0.00872189f, 0.03872423f, -0.04611031f, 0.05588229f, 0.05047942f, 
    0.03275213f, -0.03328087f, 0.06386971f, -0.04520324f, -0.00920829f, -0.07326793f, 0.00305331f, -0.06273015f, 
    -0.05912941f, 0.06423621f, -0.05352953f, -0.06093251f, 0.02646555f, 0.02603709f, -0.05578580f, -0.03983149f, 
    -0.01545971f, -0.07202463f, 0.05618240f, 0.01580878f, -0.00338033f, 0.03542899f, -0.06092895f, 0.03829672f, 
    0.02236230f, -0.07247250f, -0.01120296f, -0.02618160f, -0.00260217f, -0.05985984f, -0.02095635f, -0.04631739f, 
    -0.03644624f, 0.04915570f, -0.06463254f, 0.02445470f, -0.03715127f, -0.01751902f, -0.05691478f, -0.00877567f, 
    0.00600309f, -0.03929762f, -0.06311340f, -0.00190820f, -0.06323619f, -0.02357224f, -0.02944348f, -0.06289390f, 
    -0.02744286f, -0.04593661f, -0.01303068f, 0.01294147f, -0.02359705f, -0.03448167f, 0.00073541f, 0.00645229f, 
    0.03602745f, -0.06990295f, 0.02339428f, -0.07863329f, 0.02693937f, 0.02498481f, 0.00439082f, -0.00178049f, 
    -0.03656553f, 0.02133175f, -0.06422945f, -0.01777166f, -0.01247918f, 0.01120225f, 0.03791319f, 0.06235001f, 
    0.06512179f, 0.02375421f, 0.02987486f, -0.07470293f, -0.04679200f, -0.00368694f, -0.04074172f, 0.04334281f, 
    0.03764953f, -0.01544308f, 0.03903040f, 0.04553450f, -0.02679926f, -0.00184679f, 0.03147824f, 0.04942566f, 
    -0.04622711f, -0.00540368f, 0.01359170f, -0.02576921f, 0.05893941f, -0.02758956f, -0.07233171f, -0.04615794f, 
    -0.03130977f, 0.00808157f, -0.06918139f, -0.04051611f, -0.05697292f, 0.02256256f, 0.01051929f, 0.00608510f, 
    0.06061418f, -0.01772380f, -0.06126176f, -0.07324665f, 0.06335505f, -0.00128990f, -0.06834902f, 0.05407280f, 
    0.04549010f, 0.02247083f, -0.06611540f, -0.06687938f, 0.06433165f, -0.03286699f, 0.00349670f, 0.01945898f, 
    0.23711316f, 0.01139599f, -0.28952470f, 0.01455913f, 0.04341114f, 0.07330304f, 0.02954316f, -0.13918650f, 
    -0.01003922f, -0.09238340f, 0.11690658f, -0.09015258f, -0.20444757f, 0.07953702f, 0.00775235f, -0.05052896f, 
    0.02930324f, 0.05111503f, 0.07356478f, 0.07654233f, -0.04051698f, -0.01783836f, -0.02974254f, 0.12798862f, 
    0.00992190f, 0.19249177f, 0.02527642f, 0.27851507f, 0.07947917f, 0.07884767f, 0.08774955f, 0.09312047f, 
    0.04833706f, 0.08272979f, 0.09562387f, -0.02899132f, -0.28643635f, -0.12860900f, 0.11460251f, 0.27496195f, 
    0.05895118f, -0.06068219f, -0.06166751f, 0.01816792f, -0.04438915f, -0.00465237f, 0.14136568f, -0.16752897f, 
    -0.23901035f, 0.06337932f, 0.13985902f, 0.26255962f, 0.04541948f, 0.07026257f, 0.00549100f, 0.07051032f, 
    -0.05021065f, -0.01123243f, 0.01964502f, 0.03593426f, -0.19307089f, -0.16637337f, -0.08106620f, -0.05078844f, 
    0.15852630f, 0.07446373f, 0.10127711f, -0.11288015f, -0.15925379f, -0.04185706f, 0.07418371f, 0.00108568f, 
    0.04037678f, 0.15565774f, 0.09219208f, -0.02732608f, -0.02963649f, 0.19854656f, 0.02477462f, -0.04790011f, 
    -0.03636906f, 0.05392111f, 0.01775671f, -0.01180094f, 0.20500135f, 0.01278906f, 0.00529250f, -0.14234976f, 
    -0.06116462f, -0.00319103f, 0.06301352f, 0.10903715f, 0.06657711f, -0.01131167f, -0.04860001f, -0.02912704f, 
    -0.11538710f, 0.03739398f, 0.19550042f, -0.39937058f, 0.01279327f, 0.04326613f, -0.02172121f, -0.01366497f, 
    -0.10929604f, -0.06893315f, -0.03887425f, 0.05454243f, -0.06583242f, -0.17325981f, -0.21839082f, -0.05232558f, 
    0.09775405f, 0.07706960f, 0.00496983f, -0.10974900f, 0.10209609f, 0.09986546f, -0.00125339f, 0.09142589f, 
    0.01713504f, -0.20682095f, 0.02605923f, -0.01726478f, -0.02526634f, 0.11082876f, -0.00831681f, 0.03239824f, 
    -0.06389838f, -0.00156291f, -0.01950578f, 0.08722439f, 0.27731368f, -0.01499443f, 0.20406826f, 0.25765666f, 
    0.07634956f, -0.09594887f, 0.04187738f, 0.01723856f, -0.01255000f, -0.10213823f, 0.04392273f, -0.05921122f, 
    0.06636961f, 0.04669633f, 0.05515744f, -0.05543570f, -0.00335715f, 0.06518807f, 0.09487186f, 0.09272394f, 
    0.05389343f, -0.08808116f, -0.03484623f, 0.04917831f, 0.03802696f, 0.11919308f, -0.00084540f, -0.49356100f, 
    -0.11525539f, 0.04332813f, 0.03317176f, 0.09137793f, 0.05140007f, 0.01412532f, 0.14600123f, 0.15432279f, 
    -0.17362916f, -0.05795396f, 0.10015280f, -0.08436721f, -0.01293739f, 0.06030179f, 0.07563284f, -0.03462015f, 
    0.14058922f, -0.00699963f, 0.12144031f, 0.05369029f, -0.02583942f, -0.07906755f, 0.17029418f, -0.13658006f, 
    0.03843874f, -0.09772155f, 0.16232142f, 0.03974144f, -0.00910861f, 0.02453973f, 0.12756436f, 0.04693399f, 
    0.04648238f, 0.04926101f, -0.00092825f, -0.00347330f, 0.01109465f, 0.02725419f, -0.01321046f, -0.02356661f, 
    0.00350533f, -0.04675004f, -0.00221686f, 0.02634554f, -0.07502893f, 0.04338887f, -0.04947415f, -0.03586211f, 
    -0.00744743f, 0.02269581f, -0.05800317f, 0.06115998f, -0.01029897f, 0.06621969f, -0.05104381f, -0.05416079f, 
    -0.04676720f, 0.03882476f, -0.03920637f, 0.00353720f, -0.00402431f, -0.03232659f, 0.01287433f, 0.01930997f, 
    0.06256210f, -0.04564766f, -0.02463138f, -0.01970611f, 0.02649168f, -0.02148686f, 0.04624104f, -0.01535262f, 
    0.06428579f, 0.02939885f, -0.00212804f, -0.07056190f, 0.04160738f, 0.02836275f, -0.05703063f, 0.05352172f, 
    0.02916586f, 0.00644458f, -0.02758779f, -0.07358377f, -0.04528795f, -0.06523472f, -0.03974105f, -0.04939390f, 
    -0.05869580f, -0.02985011f, -0.05853994f, 0.04443754f, -0.02528949f, 0.00168046f, -0.02237518f, -0.05046982f, 
    -0.04787247f, -0.06795927f, 0.03952833f, 0.01562928f, -0.05259999f, -0.03902367f, 0.03485093f, 0.03093021f, 
    -0.01096657f, -0.01752022f, -0.06271976f, 0.06606798f, -0.01494716f, -0.00505492f, 0.00677834f, 0.00643367f, 
    0.01403995f, 0.03886004f, -0.05040164f, 0.03690512f, 0.06175165f, -0.01500175f, 0.03113581f, 0.05405748f, 
    -0.05184843f, 0.05611768f, -0.04894756f, -0.02282207f, -0.07089052f, -0.00998299f, 0.06017470f, 0.00169034f, 
    0.06224583f, -0.02845038f, -0.06398202f, -0.06887800f, -0.03215176f, -0.02001216f, -0.02294360f, -0.00881207f, 
    -0.00340298f, -0.04772048f, -0.07139300f, 0.02974032f, -0.04847461f, -0.03016683f, 0.00325128f, -0.01219679f, 
    -0.01489059f, -0.00858248f, 0.01800371f, -0.03426678f, -0.06306475f, -0.02865078f, -0.00502754f, -0.03885150f, 
    -0.07031227f, -0.04661343f, 0.04113073f, -0.02751951f, -0.04649806f, -0.02891741f, 0.01912439f, -0.01914957f, 
    0.04377447f, -0.02207637f, -0.04185347f, -0.06777695f, -0.06629673f, 0.05020732f, 0.01008619f, -0.03920612f, 
    -0.04558413f, -0.06531923f, -0.02069964f, -0.07105937f, -0.00097638f, 0.03309685f, -0.03754625f, 0.05303209f, 
    -0.07097956f, 0.06058394f, 0.03055684f, 0.05111909f, -0.00791177f, -0.04641297f, -0.02854584f, 0.04355991f, 
    -0.03344508f, -0.03655140f, 0.00877192f, -0.04372801f, -0.06311232f, -0.02333583f, 0.04563726f, 0.02591002f, 
    -0.04584477f, -0.04387886f, -0.01745851f, 0.06259481f, -0.07620428f, 0.04150080f, -0.05952783f, -0.02778987f, 
    -0.05569679f, -0.02599015f, 0.02367903f, 0.02400673f, -0.00516632f, -0.03383189f, -0.06905229f, -0.00900800f, 
    -0.01124409f, 0.05578060f, 0.01091653f, 0.01919164f, -0.07464480f, 0.05256962f, -0.00470540f, -0.00490501f, 
    0.01988501f, -0.00679581f, -0.00007554f, -0.06915728f, -0.05526147f, 0.05541305f, 0.02879359f, 0.02279531f, 
    -0.00882863f, 0.21502036f, 0.02990644f, 0.12655704f, 0.23200905f, 0.08358776f, 0.16591260f, 0.14179689f, 
    0.02175600f, 0.04108120f, 0.09484904f, 0.05393546f, -0.26914370f, -0.11708260f, -0.07807573f, -0.12161557f, 
    0.07406635f, 0.04044896f, -0.05738940f, -0.12574564f, 0.00996207f, 0.03522994f, -0.00191761f, -0.00729111f, 
    -0.32580230f, 0.08644448f, 0.07488503f, 0.11158553f, 0.13076375f, -0.03027396f, 0.03907237f, -0.06681836f, 
    0.03409153f, 0.09233173f, 0.04680637f, 0.07607087f, -0.01964795f, -0.09010955f, 0.05635598f, 0.23659176f, 
    0.01598613f, 0.00702498f, 0.01036630f, -0.06040760f, -0.11869499f, 0.17359082f, -0.06500052f, 0.00628331f, 
    -0.23189624f, -0.16791266f, 0.14618640f, 0.05235568f, 0.02872262f, 0.01641774f, -0.00675775f, -0.12924735f, 
    -0.11681997f, -0.05857224f, 0.08778687f, 0.09308959f, -0.26427463f, -0.12510133f, 0.12485094f, -0.04362442f, 
    0.02113426f, -0.02488345f, 0.00806612f, 0.00214722f, 0.07109819f, 0.00885362f, -0.04879748f, 0.01585992f, 
    0.01108957f, 0.14586152f, -0.09139727f, 0.07175907f, 0.24684407f, 0.01344830f, -0.01564324f, 0.09035900f, 
    0.05342691f, 0.06181616f, 0.16352598f, 0.03050557f, -0.02393826f, -0.02712945f, -0.05281558f, -0.20554122f, 
    -0.08058605f, 0.01815138f, -0.16758931f, -0.08485601f, -0.16146582f, -0.15737890f, 0.07728998f, -0.05886182f, 
    -0.16529651f, 0.04294992f, -0.10205208f, -0.12044566f, -0.00878964f, -0.03637135f, -0.07344625f, -0.09731589f, 
    0.00914771f, -0.13718532f, 0.00032036f, 0.09819474f, -0.08262040f, 0.16825382f, -0.05038946f, -0.06819753f, 
    0.02328297f, 0.15111415f, 0.05862978f, 0.07795942f, 0.00679600f, 0.08907720f, -0.03019793f, 0.10597915f, 
    0.27202907f, -0.00211102f, -0.02613638f, -0.03552574f, 0.18707938f, 0.07876675f, 0.09159509f, 0.03710140f, 
    0.04851735f, -0.01687185f, 0.05942656f, 0.02400885f, 0.36458400f, 0.29308143f, -0.01667052f, 0.28074205f, 
    -0.00083057f, -0.00117897f, -0.07025047f, 0.03234185f, -0.08427523f, -0.04965464f, -0.06797650f, 0.00728352f, 
    -0.31474739f, 0.02550618f, -0.01734839f, -0.00498035f, 0.10520477f, 0.04343293f, 0.00383789f, 0.10247872f, 
    0.10713448f, -0.00489659f, -0.00293049f, 0.00871979f, -0.07344908f, 0.06557084f, -0.03578807f, -0.20349899f, 
    -0.00899613f, -0.20301084f, 0.00692069f, 0.02132701f, -0.06230785f, -0.01468575f, 0.15609416f, -0.05721065f, 
    -0.26526114f, 0.08092557f, -0.00146774f, -0.21734345f, -0.02387158f, 0.17410015f, -0.04182361f, 0.09848057f, 
    0.15323465f, 0.03594007f, -0.05686477f, 0.03970777f, -0.00306862f, 0.09664419f, -0.01463023f, -0.10603275f, 
    0.01951770f, -0.06715744f, 0.20502397f, 0.02011380f, -0.00397510f, -0.01083507f, -0.03543141f, 0.08937647f, 
    0.01284794f, 0.04046143f, -0.09606780f, -0.10556617f, -0.05587008f, -0.07755978f, -0.06295747f, -0.03356845f, 
    0.10018159f, 0.04694751f, 0.31037435f, 0.08641241f, -0.12025108f, -0.09115299f, -0.07916148f, -0.09882637f, 
    -0.10777295f, 0.14948970f, 0.00009625f, 0.08926933f, 0.05764678f, -0.07222839f, 0.00069315f, 0.05929108f, 
    0.11152817f, -0.24850701f, 0.16089484f, 0.00172749f, 0.03430056f, 0.03777895f, 0.05155969f, 0.00946650f, 
    0.03875805f, 0.05417570f, 0.03650655f, 0.09271105f, 0.03778364f, -0.01096803f, -0.07628585f, -0.19270654f, 
    -0.13063720f, 0.15296386f, 0.03287463f, 0.05068533f, -0.05625180f, 0.02250829f, 0.01603137f, -0.11700623f, 
    -0.08389477f, 0.21136226f, 0.09916110f, -0.06023036f, 0.04213000f, 0.05099312f, 0.05316773f, 0.10875166f, 
    0.15694687f, 0.16105719f, 0.07556103f, 0.00048587f, 0.09498335f, 0.07305724f, -0.09998430f, -0.05901581f, 
    -0.08574124f, -0.07666978f, 0.02578939f, 0.08760770f, -0.02467572f, -0.02231792f, -0.03444064f, -0.06537089f, 
    0.20311521f, 0.02018909f, 0.09421115f, 0.10506361f, 0.10843097f, -0.07977662f, -0.03219903f, 0.18283355f, 
    0.01945818f, -0.07599023f, -0.02358237f, -0.18204246f, 0.03241285f, 0.00139638f, -0.12598732f, -0.11813112f, 
    0.06285248f, 0.01985734f, 0.09501248f, 0.00764024f, 0.06020878f, -0.08473182f, -0.14992984f, -0.15089275f, 
    -0.26125216f, -0.20907779f, -0.14277084f, 0.04287191f, 0.04203838f, 0.06792267f, 0.05678688f, 0.09145718f, 
    -0.06667653f, 0.01790659f, -0.04500844f, 0.07319489f, 0.02941291f, -0.35335577f, 0.02332700f, 0.16211160f, 
    0.05256919f, -0.01853333f, 0.15048383f, -0.05281867f, -0.02006165f, 0.08520535f, 0.02668134f, 0.01735726f, 
    -0.24756192f, 0.13898547f, -0.02144254f, -0.10214706f, -0.11169075f, 0.07629780f, -0.07666022f, 0.11093415f, 
    -0.03672524f, 0.00255804f, -0.06965852f, -0.01223036f, -0.28866968f, -0.04451596f, 0.15965390f, -0.10735659f, 
    0.02838311f, 0.09481514f, 0.07516425f, 0.10156463f, 0.09158671f, -0.01445877f, 0.03683771f, 0.17427443f, 
    0.01292845f, 0.22233555f, 0.00849351f, 0.26913381f, 0.06880473f, 0.02250779f, 0.25253999f, 0.18006442f, 
    0.05316928f, 0.08814058f, 0.17595269f, 0.01589658f, 0.25330967f, -0.08846306f, -0.04322244f, -0.04545848f, 
    0.05506673f, 0.00988538f, -0.07879788f, 0.09573501f, 0.05846059f, 0.00158125f, -0.06194500f, 0.07273890f, 
    -0.19616437f, 0.09585902f, 0.03054790f, 0.21418953f, 0.09298003f, -0.09796862f, -0.05573134f, -0.00179476f, 
    -0.10700504f, 0.02393503f, -0.01741250f, -0.04944674f, -0.15723552f, -0.06399669f, -0.20417617f, -0.10191039f, 
    0.04466332f, 0.06024536f, -0.06902663f, 0.06588292f, -0.13171329f, -0.01238323f, 0.07397321f, 0.00070994f, 
    -0.02353573f, 0.07082146f, 0.04670514f, -0.00552334f, -0.05738787f, 0.08124970f, 0.08404060f, 0.08804889f, 
    -0.04605740f, 0.03323454f, -0.00076443f, -0.01584650f, -0.22825859f, 0.01284716f, 0.01406722f, -0.05957255f, 
    0.02358410f, -0.02461975f, -0.04603164f, -0.07009645f, -0.05590905f, 0.00510388f, -0.10360137f, -0.04298191f, 
    -0.33387870f, 0.21374863f, -0.03903966f, 0.07058926f, 0.04444227f, 0.08290069f, 0.03917215f, 0.07311097f, 
    0.10460022f, 0.08124830f, 0.10401731f, 0.05502950f, -0.01498750f, -0.16008443f, 0.06736211f, 0.06001206f, 
    0.09406226f, -0.01486473f, -0.09576554f, 0.08136255f, -0.12962516f, 0.06945269f, 0.02398523f, -0.04071739f, 
    -0.10363206f, -0.09245981f, 0.05195241f, 0.02336681f, 0.05613681f, -0.03352818f, -0.04979105f, 0.07039688f, 
    -0.01613350f, 0.03582418f, 0.03853682f, -0.03232096f, -0.14967535f, -0.09624733f, 0.03571882f, 0.02692584f, 
    -0.03881698f, 0.00386788f, 0.06500849f, 0.00655870f, -0.03252329f, 0.09865335f, -0.00806627f, 0.11250657f, 
    -0.10580948f, 0.11047953f, -0.01565604f, 0.12513393f, -0.03820091f, 0.10831986f, 0.11315077f, -0.02607801f, 
    0.04934540f, -0.03418832f, 0.12340677f, -0.01176550f, -0.12981547f, -0.06696896f, 0.00706623f, -0.16708235f, 
    -0.08022252f, -0.07878572f, -0.04649057f, 0.08810613f, -0.05560933f, -0.05396684f, -0.01293129f, -0.00012690f, 
    -0.22667825f, 0.02120381f, -0.10400374f, -0.05716806f, -0.02032136f, -0.01337201f, -0.03617722f, -0.11184996f, 
    0.06552871f, -0.11600418f, 0.14206249f, 0.01719238f, 0.01934316f, 0.10902361f, 0.02720150f, -0.13235694f, 
    0.04149535f, 0.08659247f, 0.10685944f, -0.04849094f, 0.04353855f, 0.11897378f, 0.01097813f, 0.05663143f, 
    0.53073394f, 0.10951430f, 0.22226997f, -0.02385387f, 0.14418124f, 0.07145795f, -0.00096097f, 0.14129469f, 
    0.08502885f, -0.05243624f, 0.11908747f, 0.02758036f, 0.37630475f, 0.03763668f, -0.01512553f, 0.15144852f, 
    0.13891037f, -0.03730405f, 0.02502200f, -0.00293221f, 0.00830962f, 0.04809842f, 0.05249313f, -0.08250007f, 
    -0.12706672f, 0.08022660f, 0.04651161f, 0.07750805f, -0.07166684f, -0.04642030f, -0.07134809f, -0.03875776f, 
    -0.01893974f, 0.02467544f, -0.08094433f, 0.09195688f, -0.15665723f, -0.01744399f, -0.09970351f, 0.01079602f, 
    -0.02418707f, -0.04900702f, 0.03853586f, -0.02562677f, 0.06114268f, 0.13621598f, 0.11321194f, 0.01186555f, 
    -0.08705343f, 0.03541127f, -0.04077008f, -0.06984080f, 0.09229612f, -0.06246083f, -0.07524984f, -0.08053744f, 
    0.13997556f, 0.06157367f, 0.05286158f, 0.01881602f, -0.00779049f, -0.03788156f, -0.01952787f, 0.02186153f, 
    -0.08353797f, -0.02648195f, 0.10642900f, 0.11193372f, 0.02364908f, -0.06046537f, 0.05114530f, 0.08334233f, 
    0.23933651f, 0.00574061f, -0.01104659f, 0.03825045f, -0.10177588f, 0.02199601f, -0.05023043f, 0.00666178f, 
    -0.02581301f, 0.03719268f, 0.12374479f, 0.08569806f, -0.10039017f, 0.00406612f, 0.04498077f, -0.05749933f, 
    0.02283747f, -0.06058563f, 0.02244277f, 0.05145186f, 0.14151441f, -0.00695638f, 0.01360097f, 0.15220568f, 
    0.12352505f, -0.06222186f, -0.02146243f, -0.01463121f, -0.08051863f, -0.01386063f, -0.09496506f, 0.03336447f, 
    -0.06672813f, 0.16418734f, 0.06219783f, -0.12305542f, -0.17613204f, 0.14608793f, -0.03440557f, -0.01457139f, 
    0.04646650f, -0.06394370f, 0.03820011f, 0.04002228f, 0.02689245f, -0.03802731f, 0.02294712f, 0.02328105f, 
    -0.21297905f, 0.22014938f, 0.03047483f, -0.08630839f, -0.03351197f, -0.00728855f, -0.06880201f, 0.12476724f, 
    0.10906989f, -0.03980728f, 0.07823765f, -0.05985475f, 0.11293887f, 0.14036137f, -0.12816751f, 0.02022838f, 
    0.04987486f, -0.12598300f, 0.02738650f, 0.03680889f, 0.01302235f, -0.06709647f, 0.03928582f, -0.03715514f, 
    -0.05832366f, -0.01907396f, 0.23018633f, -0.12216420f, -0.00885516f, 0.01320388f, 0.01181445f, 0.16902724f, 
    -0.07538599f, 0.00201867f, -0.08012540f, -0.04349384f, 0.05095894f, 0.25219166f, 0.30968702f, -0.00158494f, 
    -0.15694250f, 0.01673879f, 0.15866680f, 0.05664933f, -0.06044490f, 0.04541463f, -0.06795552f, -0.02719435f, 
    0.03875666f, -0.08808643f, 0.08642872f, -0.02088973f, -0.16180699f, 0.02577096f, -0.02409901f, 0.16325077f, 
    0.00899755f, 0.02081494f, -0.06790751f, -0.05127624f, 0.33025706f, -0.13658874f, -0.08482641f, -0.15677452f, 
    0.16048366f, 0.00784186f, 0.04235209f, -0.06112987f, 0.06824720f, 0.07972644f, -0.01595052f, 0.05625917f, 
    -0.11694746f, 0.22844437f, -0.18109153f, -0.11702085f, -0.02725065f, 0.00067970f, 0.04732009f, -0.03055941f, 
    -0.03445529f, 0.00217636f, 0.03367824f, 0.00542163f, -0.24326587f, 0.05985842f, 0.12688361f, 0.46238241f, 
    -0.07735252f, 0.13554603f, 0.00929784f, -0.03039987f, 0.09934423f, 0.03032016f, 0.07090984f, -0.03396184f, 
    0.18479851f, 0.07272530f, -0.05787280f, -0.02489769f, 0.04355293f, 0.07952366f, -0.03422752f, 0.08322704f, 
    0.06688575f, -0.03040881f, 0.04255760f, -0.03121678f, 0.33661696f, -0.12801644f, 0.10758257f, 0.11075398f, 
    -0.21872212f, 0.06659751f, 0.00614920f, 0.14861847f, 0.02141503f, -0.04582879f, -0.01935790f, -0.02968452f, 
    -0.28664044f, 0.08346298f, -0.06097998f, -0.03829063f, 0.05658155f, -0.01414114f, 0.04227154f, 0.07925151f, 
    0.07570819f, -0.04895600f, 0.07986065f, 0.01752965f, -0.22542372f, 0.05232068f, 0.07369700f, 0.05904699f, 
    0.06158275f, 0.04451659f, 0.08211391f, 0.09296473f, 0.04367956f, 0.11099595f, 0.07008577f, -0.00934672f, 
    -0.14506871f, -0.08644990f, -0.07008115f, -0.17662467f, -0.19456735f, -0.04571199f, -0.10846724f, 0.03344521f, 
    -0.04678625f, -0.05901322f, 0.02704038f, -0.01192469f, 0.14376833f, 0.07169472f, 0.06921691f, 0.21565096f, 
    0.04434538f, 0.03813304f, -0.03296715f, -0.00993092f, -0.00889943f, 0.06786694f, 0.03659771f, -0.06228125f, 
    -0.04066084f, 0.14740172f, 0.24253210f, -0.11378869f, -0.01516003f, 0.12500496f, 0.13884728f, 0.13820882f, 
    0.09602335f, -0.12617873f, 0.03474109f, 0.04352984f, 0.02538270f, -0.00488973f, 0.00563984f, -0.03427309f, 
    -0.08996450f, 0.05697455f, -0.00860993f, 0.08150560f, -0.10917644f, 0.04906068f, 0.04417088f, -0.00636477f, 
    0.07520115f, -0.07746319f, 0.02442342f, 0.10908976f, -0.00555346f, 0.12641151f, 0.02851582f, -0.11435036f, 
    0.02185085f, 0.00510436f, 0.08589634f, 0.10789144f, 0.05751475f, -0.23659661f, 0.01085421f, -0.09032810f, 
    0.04523378f, 0.07905314f, 0.12123839f, -0.02923290f, -0.04079091f, 0.05477928f, -0.11092123f, -0.01689675f, 
    0.22605166f, -0.08545297f, -0.04788451f, 0.00016434f, 0.01747518f, -0.04898938f, 0.02025537f, -0.14449011f, 
    -0.00846202f, 0.00962253f, -0.00464714f, -0.00584490f, 0.00887993f, 0.02858036f, -0.21698508f, -0.02525746f, 
    0.11981531f, 0.05649461f, -0.13695610f, -0.04504488f, 0.11236706f, -0.05609110f, -0.12727211f, 0.05716127f, 
    0.06905234f, 0.01775941f, -0.13561560f, 0.24147984f, 0.13015996f, -0.03215849f, -0.05408150f, -0.05704186f, 
    0.07745077f, -0.07556252f, 0.13483585f, 0.10123527f, -0.20568196f, 0.10316041f, 0.22914875f, 0.10089496f, 
    0.04551898f, 0.05807427f, -0.04664940f, 0.09674937f, 0.03370555f, -0.06501029f, -0.05094917f, -0.05965518f, 
    0.41392508f, -0.23871139f, 0.10999363f, 0.17936017f, -0.01073981f, -0.00158679f, 0.02243255f, 0.08554107f, 
    0.02276574f, -0.00560309f, 0.02236029f, 0.07382935f, 0.16922696f, -0.12504055f, -0.25393111f, -0.40891868f, 
    0.00972450f, -0.03789494f, -0.07590473f, -0.01857053f, -0.07917588f, -0.03247309f, 0.02666487f, 0.07763416f, 
    0.30171534f, -0.22621676f, 0.05280352f, 0.03593869f, -0.06617221f, -0.09151930f, -0.10095591f, 0.07444847f, 
    0.05409213f, -0.00742127f, -0.00389323f, 0.10355902f, -0.24737230f, 0.22705027f, 0.14801869f, 0.09201056f, 
    0.04374947f, -0.08370525f, -0.03031667f, -0.09426884f, 0.03729694f, -0.06808751f, 0.12011573f, -0.13942482f, 
    0.39096153f, 0.04700036f, -0.05346463f, 0.05206291f, 0.00370033f, -0.04588490f, 0.03631921f, 0.08944527f, 
    -0.03935024f, 0.08819155f, -0.09322482f, 0.03451428f, 0.31737176f, -0.00050477f, -0.19914515f, 0.12915264f, 
    0.01237429f, -0.01962079f, -0.05041778f, -0.09983229f, 0.02438132f, -0.10448489f, 0.09044310f, -0.08063571f, 
    0.17336205f, 0.16147487f, 0.03659917f, 0.07710373f, 0.18971968f, 0.05382191f, 0.07317543f, 0.09676033f, 
    -0.00307366f, 0.00369420f, -0.11722140f, 0.09427909f, -0.06300846f, 0.10935161f, 0.05749791f, -0.10185994f, 
    0.08810288f, -0.01018939f, 0.01271203f, 0.00617923f, 0.03298551f, -0.08614174f, 0.09453116f, 0.12113597f, 
    -0.15475520f, 0.07479635f, -0.06316467f, 0.13824815f, 0.04645261f, 0.02909464f, -0.02901335f, -0.05471965f, 
    0.05928285f, -0.00716931f, -0.04807176f, -0.10474792f, 0.10630218f, 0.05504895f, 0.03769876f, 0.30545869f, 
    0.02182911f, -0.14971901f, 0.02219300f, 0.04912350f, 0.04597425f, -0.04201094f, 0.01488570f, 0.02411978f, 
    0.02398890f, -0.10907785f, 0.09419958f, 0.18179961f, 0.00759774f, 0.08114733f, -0.00519525f, -0.00408027f, 
    -0.14272779f, 0.04146034f, 0.01040778f, -0.05173382f, -0.02068234f, 0.12709995f, 0.11802642f, -0.00009966f, 
    0.04472298f, 0.12648985f, 0.00268870f, -0.03738129f, 0.04823792f, -0.09988660f, -0.08329061f, 0.03496633f, 
    -0.00250868f, 0.09903280f, 0.08864787f, -0.10985088f, 0.09632500f, -0.02192155f, -0.03075669f, 0.00063131f, 
    0.04649634f, 0.11289930f, 0.00533046f, 0.01775210f, 0.09673516f, -0.26412955f, 0.16556054f, 0.10054087f, 
    0.03574935f, -0.10615677f, 0.00090498f, -0.08555499f, -0.04599493f, 0.03600717f, -0.07762872f, 0.02674954f, 
    -0.08285388f, 0.00453985f, 0.01515461f, -0.28943613f, 0.04353339f, -0.07944387f, -0.03783125f, -0.13543513f, 
    0.03416640f, -0.06181909f, 0.02193294f, -0.00770346f, -0.22287919f, 0.07570971f, -0.14120342f, 0.22314356f, 
    -0.02599394f, 0.08103660f, 0.04087538f, 0.08644532f, 0.02418598f, -0.00405496f, 0.04070929f, 0.02995870f, 
    -0.38278124f, -0.13679518f, 0.01638792f, 0.00894272f, 0.00690391f, 0.05372514f, -0.00416651f, -0.11170699f, 
    -0.04818648f, 0.01000784f, 0.07048932f, 0.01059327f, 0.26018041f, -0.02053624f, 0.12152269f, -0.03880768f, 
    0.05159588f, -0.02304199f, -0.04584834f, 0.08408715f, -0.10091112f, -0.10015143f, 0.01707800f, 0.00962239f, 
    -0.17938308f, 0.05986485f, 0.09838600f, -0.22574562f, 0.17170984f, 0.06981010f, 0.02472409f, -0.10194446f, 
    0.13029550f, 0.00137971f, -0.06079329f, 0.05689334f, -0.00800161f, 0.13461028f, -0.11687662f, -0.21242982f, 
    0.14741483f, 0.04191381f, -0.03942494f, -0.07011294f, -0.07383242f, -0.10974176f, -0.06857826f, 0.20487256f, 
    0.02745847f, -0.05918910f, 0.18420699f, -0.27821463f, -0.20146376f, 0.00009498f, 0.04407238f, 0.03735062f, 
    -0.01165939f, 0.07528234f, 0.07826234f, -0.06951842f, 0.14627956f, -0.03248650f, 0.18759209f, -0.00592307f, 
    0.04499113f, 0.07391725f, 0.04384512f, 0.01293819f, -0.02571672f, 0.20200531f, 0.01348498f, 0.03304548f, 
    -0.30345279f, -0.11998370f, -0.08110298f, 0.22568239f, 0.25094739f, 0.06684387f, 0.08288516f, 0.26190454f, 
    0.05285222f, 0.18548962f, 0.09388743f, 0.06092542f, -0.03272718f, -0.07532844f, 0.06770668f, -0.25693417f, 
    0.00200810f, -0.07221723f, -0.12498561f, 0.03950957f, -0.06900965f, 0.04898764f, 0.04733830f, 0.10956888f, 
    -0.25108448f, 0.05772419f, -0.10519353f, -0.09565235f, 0.05765737f, 0.09496617f, -0.14962687f, -0.03594626f, 
    0.01749463f, -0.09962568f, 0.05693096f, 0.02340859f, -0.19562998f, -0.03609799f, -0.07922780f, -0.05697932f, 
    0.07634250f, 0.02844937f, -0.04305930f, 0.08869246f, 0.10583878f, 0.03826874f, 0.16801587f, 0.15940088f, 
    -0.02376257f, -0.02934589f, 0.11786205f, -0.04693821f, 0.00075247f, -0.03800307f, 0.03000648f, -0.23069581f, 
    0.00374030f, 0.06653652f, -0.00441531f, 0.03266406f, -0.28136447f, -0.06994166f, -0.11959174f, -0.03961824f, 
    0.00703599f, -0.17639202f, -0.11164547f, 0.11455122f, 0.19732472f, 0.04547937f, 0.09268419f, -0.04157970f, 
    -0.07754912f, -0.02727770f, -0.08403817f, -0.08531412f, 0.09213618f, 0.01720167f, 0.02814185f, 0.04945773f, 
    0.14876048f, -0.02273052f, 0.17542659f, 0.13816711f, -0.15548921f, 0.11137249f, 0.28740454f, -0.03369867f, 
    -0.12093662f, 0.00593250f, -0.22841316f, -0.00866415f, -0.06309585f, 0.01103325f, 0.14796194f, 0.00377298f, 
    0.23641211f, 0.09658548f, 0.00659482f, 0.00164564f, 0.10846234f, 0.02027060f, 0.00974417f, -0.02355908f, 
    0.15914093f, 0.11844096f, 0.04110182f, 0.04915740f, -0.16909511f, -0.01517651f, 0.07896326f, -0.42127356f, 
    0.10021921f, 0.00361648f, 0.12481669f, 0.18978557f, 0.03855570f, 0.15577184f, 0.01904027f, 0.09165563f, 
    -0.30550712f, 0.14812103f, -0.27431688f, -0.43836054f, 0.17983738f, 0.06624606f, 0.07511517f, 0.10584505f, 
    0.01425708f, 0.12597452f, 0.04574706f, 0.12828875f, -0.26396966f, 0.20651224f, -0.20054637f, 0.17295663f, 
    0.02072803f, 0.08090048f, -0.19854626f, 0.05750036f, -0.01593965f, 0.02585398f, 0.03320841f, 0.06358699f, 
    -0.33527204f, -0.00987808f, 0.05789320f, 0.04415488f, 0.02524547f, 0.05781090f, -0.00404052f, -0.02832046f, 
    0.11716489f, 0.03762276f, 0.09016667f, -0.12747769f, 0.06648195f, 0.00582779f, 0.04133183f, 0.29625902f, 
    0.09496149f, 0.10762820f, -0.03069843f, -0.08691289f, -0.00030538f, -0.05495320f, -0.09105121f, 0.05243662f, 
    -0.12038393f, 0.14279528f, -0.32357490f, -0.15745766f, 0.04670520f, 0.12890573f, -0.06478690f, 0.13890693f, 
    -0.19067146f, -0.15849651f, 0.04237516f, -0.03799229f, -0.04161655f, 0.17926660f, 0.12527707f, 0.27244553f, 
    0.01000545f, 0.02553331f, 0.00933969f, -0.08154009f, -0.00266039f, -0.06982961f, 0.00271519f, 0.15506256f, 
    0.13023284f, -0.07264099f, -0.12204210f, -0.05685679f, -0.08265755f, 0.05976688f, 0.00590769f, -0.00383348f, 
    0.09910596f, 0.01712418f, -0.01107437f, 0.01399616f, 0.10361718f, -0.02600158f, 0.02578723f, 0.14506257f, 
    0.15340871f, -0.01917508f, -0.15640827f, -0.06656733f, 0.00993626f, 0.08810574f, 0.06210960f, -0.09576783f, 
    0.13133289f, 0.04101134f, -0.17023937f, 0.08587288f, -0.00253743f, 0.04402455f, 0.09393894f, 0.04603430f, 
    0.06638156f, -0.08211707f, 0.03558817f, 0.00637801f, -0.23923394f, 0.09968893f, 0.00290938f, -0.19515367f, 
    0.05893859f, 0.12653328f, -0.00285521f, 0.10366034f, 0.02353870f, 0.16565497f, -0.12078077f, 0.06519068f, 
    0.12743124f, 0.32838643f, -0.14253969f, 0.08972928f, 0.11189121f, 0.06898716f, 0.01052185f, -0.00233412f, 
    0.03867237f, 0.02196537f, -0.00903923f, 0.10480809f, 0.00055319f, -0.03684870f, -0.20299208f, -0.00024243f, 
    0.00330171f, -0.13757829f, 0.04665108f, -0.08905524f, 0.03789468f, 0.03983873f, -0.04944201f, 0.01547214f, 
    0.14479522f, 0.00798420f, -0.09616699f, 0.07980442f, 0.03170324f, -0.06006995f, -0.05707378f, -0.01077584f, 
    0.01025190f, -0.00380989f, 0.04869285f, 0.14307286f, -0.01741221f, 0.06306870f, -0.07059156f, 0.04819053f, 
    0.08616712f, 0.16314407f, 0.07902864f, -0.02503232f, -0.02768734f, -0.02127651f, 0.01910725f, 0.06563488f, 
    0.14191087f, -0.03891542f, 0.03240686f, 0.12538700f, 0.02607278f, -0.00050021f, -0.02707189f, 0.02046933f, 
    0.08903055f, 0.03458180f, -0.05056654f, -0.08792410f, 0.31155190f, -0.03331570f, -0.05591478f, -0.22363825f, 
    0.00067414f, -0.01869276f, -0.12230638f, 0.04770388f, 0.04363260f, -0.09186144f, 0.01247170f, 0.01378216f, 
    0.07686320f, 0.04782019f, -0.09529518f, -0.09324360f, -0.04530853f, 0.10107770f, -0.00174233f, -0.01787646f, 
    0.03700846f, 0.02189168f, 0.06389473f, 0.09236421f, -0.10906777f, 0.03406151f, -0.17316887f, 0.12944540f, 
    0.04104383f, -0.07304227f, 0.04201334f, 0.12050472f, 0.09329583f, 0.05166804f, 0.01040291f, 0.15116063f, 
    0.29671881f, -0.12794822f, 0.06319461f, 0.16919994f, 0.01625607f, 0.04591306f, -0.02611172f, 0.02201730f, 
    0.10403757f, 0.06456564f, 0.07840572f, 0.05429639f, -0.07782180f, -0.03737333f, 0.10780687f, 0.12661791f, 
    -0.01571440f, 0.05412227f, 0.06155732f, -0.05348933f, 0.01737631f, -0.07993022f, 0.11127395f, 0.04164413f, 
    0.28256616f, 0.02899002f, 0.06778329f, 0.17775810f, 0.06278743f, -0.08303439f, -0.01641513f, -0.12245081f, 
    0.03635386f, 0.10298552f, -0.08574059f, 0.03672625f, -0.10197770f, -0.06968763f, -0.05448246f, 0.01825543f, 
    0.05605470f, 0.03002755f, -0.05740454f, -0.11098720f, 0.12455718f, -0.10976198f, 0.01801234f, -0.05694294f, 
    0.12717886f, -0.15738660f, -0.13253416f, -0.05634531f, -0.01351986f, -0.04872799f, -0.02940429f, -0.06060841f, 
    0.11574223f, -0.07744563f, 0.01867141f, -0.07851233f, 0.03132465f, 0.04635158f, 0.20391655f, 0.02624758f, 
    0.05932823f, 0.04183455f, -0.01788945f, 0.06644635f, -0.03156199f, 0.04114350f, 0.06068403f, 0.12059422f, 
    -0.43661183f, 0.01724948f, 0.27178308f, -0.05941427f, 0.22847591f, 0.01012774f, 0.12479533f, 0.04158633f, 
    0.06205845f, -0.01950397f, -0.04130857f, 0.16417502f, -0.04003965f, -0.04052748f, 0.01237659f, 0.04793542f, 
    -0.11752574f, 0.16735545f, 0.15372244f, -0.13303065f, 0.04182430f, -0.04708677f, -0.05611387f, 0.21079989f, 
    -0.14565061f, -0.12996539f, 0.10471829f, 0.07580848f, 0.02287092f, 0.16551897f, 0.18583347f, -0.00056413f, 
    0.00026130f, -0.19184150f, 0.05384673f, 0.03844623f, 0.04714031f, -0.07766292f, -0.21519719f, -0.11810745f, 
    -0.07159810f, -0.04346808f, -0.05415203f, 0.12745011f, -0.00800962f, 0.14555310f, 0.03478196f, -0.08610039f, 
    0.31203029f, 0.03872446f, -0.08057583f, -0.06775285f, 0.06180188f, -0.04558488f, 0.09002150f, -0.01201815f, 
    0.06111755f, 0.11040530f, 0.09821478f, 0.15682994f, -0.26910570f, 0.16638170f, -0.00243824f, -0.18868840f, 
    -0.04613113f, 0.11646093f, -0.04882440f, 0.08731231f, 0.05172464f, 0.03169475f, 0.15254590f, 0.10780942f, 
    0.31527746f, 0.19703679f, -0.01016396f, -0.07289446f, 0.09498336f, 0.09375208f, -0.05443650f, 0.09242809f, 
    0.06791316f, 0.15618694f, -0.08036290f, -0.01615951f, 0.11097820f, 0.15140092f, -0.05128719f, -0.06700180f, 
    -0.07902054f, -0.14747269f, -0.02615897f, 0.16519584f, 0.05986867f, -0.07634702f, -0.01639696f, -0.12141646f, 
    -0.12772985f, -0.02961031f, -0.24775434f, -0.10080117f, -0.11959952f, -0.12929429f, 0.06556555f, 0.06978446f, 
    0.02662497f, -0.01385886f, 0.08095609f, -0.07382215f, 0.01416450f, 0.23646751f, -0.21139571f, 0.08205377f, 
    -0.03926760f, 0.08524023f, 0.06270597f, -0.05331475f, 0.01667643f, 0.11891238f, 0.13167131f, -0.14168069f, 
    0.29013759f, -0.21929604f, -0.14383806f, 0.08764942f, 0.02498009f, 0.14781243f, -0.13792291f, 0.15543994f, 
    0.01484869f, 0.00829894f, 0.04781204f, -0.09144784f, -0.20771803f, 0.11910429f, -0.08045080f, -0.26038843f, 
    0.10760160f, 0.03753689f, 0.04324216f, 0.07541262f, 0.10987429f, -0.09767491f, 0.06580381f, 0.07627003f, 
    0.15261614f, 0.21381116f, 0.01557627f, 0.08581888f, -0.24637580f, 0.11428493f, 0.04633213f, 0.23878904f, 
    -0.07556473f, -0.15153876f, -0.05592222f, -0.01732659f, -0.15422121f, 0.03916473f, -0.18315338f, -0.19460751f, 
    0.11251830f, 0.01960554f, -0.01287331f, -0.06553052f, 0.08146713f, 0.03869355f, 0.09917543f, -0.00461918f, 
    -0.19276871f, 0.06029044f, -0.08686389f, 0.14172363f, -0.12115252f, -0.12526156f, -0.13915206f, 0.18144056f, 
    0.15212767f, 0.01290848f, 0.03548838f, -0.00889687f, 0.07967653f, -0.13720784f, -0.02372384f, -0.13946082f, 
    -0.03664964f, 0.11614718f, 0.03340208f, -0.03761223f, 0.01329414f, -0.01929573f, 0.13800982f, 0.01524085f, 
    0.52699435f, 0.06243811f, -0.03658523f, -0.15833440f, 0.00219995f, 0.00940714f, 0.07654987f, 0.01693472f, 
    0.02074346f, -0.05993026f, 0.03847832f, 0.20582010f, -0.01005237f, 0.10924345f, 0.01816556f, -0.04786977f, 
    -0.00625000f, -0.04153438f, -0.22322148f, 0.10347109f, 0.05784316f, 0.04401685f, 0.01827415f, 0.05560734f, 
    0.68714154f, 0.20082435f, -0.06439978f, -0.05197168f, 0.06957642f, 0.09561292f, 0.02733885f, -0.01461628f, 
    0.06543659f, 0.11276430f, 0.01412213f, 0.15352452f, -0.02985136f, -0.10751871f, -0.20402527f, 0.06455806f, 
    -0.00438690f, -0.04636572f, 0.09064290f, -0.16691118f, -0.17895879f, -0.01972947f, -0.16916767f, 0.14829284f, 
    0.17654674f, -0.08693005f, -0.01137116f, 0.26447210f, 0.03341169f, -0.17514922f, 0.05189842f, 0.07041481f, 
    -0.10839059f, 0.02228582f, 0.18987001f, 0.08122336f, 0.37393391f, -0.07033748f, -0.37543231f, 0.04339373f, 
    0.23763534f, 0.11571590f, 0.02110720f, 0.06894328f, -0.18348555f, -0.09591043f, 0.11513755f, -0.00014403f, 
    -0.16454458f, 0.01217832f, -0.22674561f, 0.05636001f, 0.02539112f, -0.02731160f, -0.05152590f, -0.13246334f, 
    -0.00190796f, -0.03705205f, 0.10961156f, 0.07028709f, 0.10583245f, 0.02681905f, -0.07999372f, -0.11217187f, 
    0.04502020f, -0.10708738f, -0.00838124f, 0.07553153f, 0.06643844f, -0.06054847f, -0.14000231f, -0.05981272f, 
    0.00130788f, -0.15358993f, 0.04154168f, -0.12187809f, 0.05585801f, -0.05797005f, -0.04380971f, -0.04992153f, 
    0.00805962f, -0.08131585f, -0.04384055f, -0.04545438f, -0.02392223f, 0.17371704f, -0.03053968f, 0.07349651f, 
    -0.12450302f, -0.05364381f, 0.00448609f, 0.05196989f, -0.14155336f, -0.07079384f, 0.15701166f, 0.20490338f, 
    -0.40617698f, 0.10898106f, -0.12486164f, 0.26603141f, 0.05939129f, -0.05328576f, 0.03235107f, 0.00167149f, 
    0.00891574f, 0.09582245f, 0.05146492f, -0.12866287f, -0.02509035f, -0.07758646f, -0.25495514f, 0.05401196f, 
    0.25677839f, -0.04383256f, -0.03687964f, 0.01502998f, -0.04544970f, 0.03953249f, 0.00123177f, 0.06536908f, 
    -0.08682283f, 0.22684923f, -0.06672610f, 0.14638083f, 0.13456523f, -0.10081837f, -0.04079881f, -0.07361290f, 
    0.02287120f, 0.07919800f, -0.01082039f, -0.05578182f, -0.01293295f, -0.17154054f, -0.03539835f, 0.00621766f, 
    0.07083618f, 0.11170505f, -0.16310501f, -0.07335195f, 0.20398375f, 0.05107284f, -0.11196128f, 0.14017305f, 
    0.35406309f, -0.04041664f, -0.06172733f, 0.09099899f, -0.04275331f, -0.00483099f, -0.04558454f, -0.04389384f, 
    -0.04816688f, -0.01836068f, 0.01620105f, 0.07692197f, 0.15180787f, -0.03810958f, 0.09887630f, 0.02552591f, 
    0.07425896f, 0.00058881f, -0.00413090f, 0.03789865f, 0.14019015f, -0.02265788f, 0.14115438f, 0.04138209f, 
    0.13337974f, -0.07646065f, -0.12513585f, -0.03142541f, 0.13238434f, -0.06388121f, -0.04790337f, -0.03454694f, 
    -0.06225995f, -0.03091897f, -0.05351798f, -0.01319626f, -0.12710661f, 0.20489922f, -0.09020372f, -0.09963381f, 
    -0.01136244f, 0.02235870f, -0.02524237f, 0.03367594f, 0.12015087f, 0.01172287f, 0.00873276f, 0.05699788f, 
    0.12627552f, 0.24781175f, -0.06573202f, -0.08839411f, 0.04700311f, -0.00042831f, -0.02793650f, -0.05043072f, 
    0.13888393f, -0.08134849f, -0.05620662f, 0.12028344f, 0.28893816f, 0.13702583f, -0.13564178f, 0.10083289f, 
    -0.03882779f, -0.01021882f, -0.01499891f, 0.01143895f, -0.00578158f, 0.02165244f, 0.14774096f, -0.04369469f, 
    0.18562593f, 0.02089949f, 0.12824798f, -0.06568015f, -0.00797230f, 0.01295501f, 0.06435560f, -0.06863582f, 
    -0.09907629f, -0.00940567f, -0.05159041f, 0.02401617f, 0.05468231f, 0.13849343f, -0.04924114f, 0.09930883f, 
    -0.00858516f, 0.15530479f, 0.03704004f, 0.02448353f, -0.06708848f, 0.13593403f, 0.02787822f, 0.08641415f, 
    0.23093820f, 0.06639352f, 0.13204193f, -0.06206132f, 0.01217125f, 0.08456932f, 0.01464524f, 0.04112021f, 
    0.10368712f, 0.07894449f, -0.10088287f, -0.06031664f, 0.41730630f, 0.03275037f, -0.16286032f, -0.16062514f, 
    0.03750153f, 0.01334222f, -0.08708337f, 0.06735735f, -0.00318561f, -0.05225269f, -0.05510397f, -0.02013682f, 
    -0.30139348f, 0.11356248f, -0.16339356f, -0.10283408f, 0.05274175f, -0.05482896f, 0.03871927f, -0.07587510f, 
    -0.04170062f, 0.05270436f, 0.00236053f, -0.06527337f, -0.23073283f, 0.05985037f, 0.04924602f, 0.33957002f, 
    -0.15755224f, 0.03836865f, 0.11922671f, 0.03905778f, 0.06599490f, 0.06010167f, 0.02498638f, -0.06495252f, 
    0.40870667f, 0.00448999f, 0.00609440f, 0.08911785f, 0.05248999f, 0.07632779f, 0.01375677f, 0.05741028f, 
    -0.04380275f, -0.04109585f, 0.09116235f, -0.00835468f, 0.02462271f, -0.17005491f, 0.04781325f, 0.13095561f, 
    -0.02864861f, 0.11944012f, -0.03375454f, -0.00238715f, 0.02778383f, -0.03705472f, -0.04065720f, 0.06989387f, 
    0.00849329f, 0.01305885f, 0.07460435f, 0.05854154f, -0.00489323f, -0.03615734f, 0.02193331f, -0.02816270f, 
    0.05956462f, -0.03781863f, -0.05709688f, -0.03136199f, -0.22996119f, 0.02378533f, 0.03145940f, -0.05746836f, 
    0.04021326f, 0.08051461f, 0.01779094f, -0.07323220f, -0.05705686f, 0.03017212f, 0.00937369f, 0.01892662f, 
    -0.30049235f, 0.01133707f, -0.06032143f, 0.14417441f, 0.12499123f, 0.13483821f, 0.10892399f, 0.09391902f, 
    0.01580839f, 0.02283620f, -0.06270413f, -0.03141069f, 0.08055253f, 0.06734201f, 0.09029402f, -0.02660632f, 
    0.04086298f, -0.05735807f, -0.01436059f, 0.04973691f, 0.01424959f, 0.10366037f, -0.12033851f, -0.04459953f, 
    -0.00529152f, 0.13975196f, 0.01992396f, -0.04291041f, 0.06403483f, -0.03240136f, 0.05763969f, -0.06766663f, 
    -0.07461622f, 0.01577854f, -0.02331296f, 0.06403213f, 0.12668061f, -0.14234655f, 0.09406618f, 0.22227319f, 
    0.02671028f, 0.05844001f, -0.00123585f, 0.07925287f, -0.00722377f, -0.04086537f, 0.02835205f, 0.10593501f, 
    0.21211335f, -0.19959521f, 0.07664175f, -0.11844096f, -0.12281998f, -0.01825498f, 0.00169314f, 0.01554003f, 
    -0.13779660f, 0.01099201f, 0.00002534f, -0.11569594f, -0.25067866f, -0.16718704f, 0.11886223f, 0.05167236f, 
    -0.00262480f, -0.03038630f, -0.08714923f, -0.01216193f, -0.07021132f, -0.02794272f, 0.03188145f, 0.12228200f, 
    0.01486544f, -0.03316685f, -0.14652276f, -0.02634768f, 0.04006898f, 0.07303458f, 0.12129746f, -0.01548021f, 
    0.10033883f, 0.01685965f, 0.10425127f, 0.04961248f, 0.17335257f, 0.06593040f, -0.00986598f, -0.04624505f, 
    -0.16465591f, 0.00780550f, 0.02961234f, -0.01915758f, -0.04366838f, -0.07022854f, 0.03204931f, 0.16261531f, 
    0.11237220f, 0.25627166f, -0.04711142f, 0.19889562f, 0.04998418f, 0.06436023f, 0.06700443f, -0.05097482f, 
    0.11229473f, 0.03299696f, 0.03930257f, -0.07848646f, -0.05179375f, 0.20418756f, 0.08784376f, -0.03801990f, 
    0.04399558f, -0.00571269f, -0.05705024f, 0.06793745f, -0.02145252f, 0.03114927f, -0.00060049f, 0.07693671f, 
    0.28560555f, -0.09062538f, 0.17302404f, 0.01976770f, 0.17571002f, 0.07504611f, 0.11334891f, -0.02996040f, 
    0.00727057f, -0.04281503f, -0.01881081f, -0.00764085f, 0.18096209f, 0.31843054f, -0.10573613f, 0.01622622f, 
    -0.04395399f, -0.02847533f, -0.08832008f, -0.04132769f, -0.08869483f, -0.01223884f, 0.06929576f, -0.02720958f, 
    -0.32259786f, -0.07009496f, 0.00357030f, -0.02689549f, 0.00990811f, -0.00499511f, -0.17658658f, -0.12399432f, 
    -0.01289301f, 0.00631382f, -0.05558221f, -0.03966580f, -0.12907979f, 0.08332599f, -0.05332637f, -0.03882145f, 
    0.21715015f, -0.02830280f, 0.11192445f, -0.05283824f, -0.06616309f, 0.10512609f, -0.02416114f, 0.03040418f, 
    -0.15720119f, 0.15993965f, -0.18128516f, -0.10574976f, -0.02125118f, 0.05542605f, -0.08424330f, 0.08293552f, 
    -0.10455046f, 0.00693390f, 0.02473532f, 0.03550765f, 0.13235547f, 0.11659483f, 0.05488741f, 0.08321980f, 
    -0.08485984f, 0.09868468f, 0.04928468f, -0.02035434f, 0.14533365f, -0.05733460f, -0.17522649f, -0.04475120f, 
    0.04436698f, -0.06955304f, -0.01677200f, 0.15387881f, -0.00810457f, -0.01147960f, -0.02948187f, 0.04833668f, 
    -0.04201857f, 0.06728799f, 0.11158210f, 0.17409727f, 0.23640120f, -0.03467982f, 0.04580724f, 0.18595774f, 
    0.11148670f, 0.03672306f, -0.03089733f, 0.04970023f, 0.10710651f, 0.07670575f, -0.05422520f, 0.04053602f, 
    0.30290359f, 0.11308397f, -0.21323645f, 0.00814044f, -0.05142296f, 0.08299308f, -0.00975149f, 0.04506345f, 
    0.00799259f, -0.11661001f, 0.03382263f, -0.11814594f, -0.12620869f, 0.12124433f, -0.02395436f, -0.14622808f, 
    -0.08766139f, 0.01468414f, -0.04553017f, 0.03293331f, 0.02940541f, 0.01122462f, -0.01751157f, 0.07938908f, 
    0.16327500f, 0.19093351f, 0.02535705f, 0.11198701f, 0.08400606f, 0.06317978f, -0.03264144f, 0.05873932f, 
    0.14083789f, 0.10905532f, 0.08669961f, 0.08325796f, -0.11923058f, 0.11930315f, -0.08508777f, 0.04934094f, 
    0.02899042f, -0.06847416f, -0.02708648f, 0.01076188f, 0.09894221f, 0.09334680f, 0.03457819f, -0.08996715f, 
    -0.10817992f, 0.03970538f, -0.12557237f, -0.02345161f, -0.02874704f, -0.08480964f, -0.12358991f, 0.01120373f, 
    0.01839863f, 0.01017946f, -0.11225174f, -0.05243086f, 0.06696084f, 0.12775953f, 0.30340481f, 0.06396818f, 
    0.08680277f, -0.02036440f, -0.03507496f, 0.07337672f, -0.03802764f, 0.00077310f, 0.01689601f, -0.01712276f, 
    0.16167589f, 0.00344682f, 0.14344315f, 0.18326935f, -0.01563379f, 0.08903040f, 0.11706937f, 0.04967782f, 
    0.02296931f, -0.01282467f, 0.07137406f, 0.09512243f, -0.07718316f, -0.14484869f, -0.11968695f, -0.05161045f, 
    0.01623378f, -0.00372411f, -0.11584592f, 0.11469951f, 0.10178344f, 0.04264468f, 0.01864820f, 0.13448699f, 
    -0.26644832f, -0.14451599f, -0.01649676f, -0.01692867f, 0.03290102f, 0.01675141f, -0.07746071f, 0.02291518f, 
    0.08276121f, 0.09485967f, 0.03016195f, 0.10002518f, -0.18667400f, 0.05562173f, 0.01972597f, -0.16892523f, 
    0.06461929f, -0.00510490f, 0.13972746f, -0.00041411f, -0.03272241f, 0.03769225f, 0.11604676f, 0.30161160f, 
    0.17822631f, -0.01407484f, 0.11558353f, 0.11302057f, -0.08786231f, 0.08250495f, 0.03852506f, 0.05583705f, 
    0.04483924f, -0.06129136f, 0.17760932f, 0.05014552f, 0.28538486f, 0.09448697f, 0.24351436f, 0.00574073f, 
    -0.15047109f, 0.13667072f, 0.08639820f, 0.03053018f, 0.07001707f, -0.07714890f, -0.03785037f, 0.04986686f, 
    0.23183905f, -0.12972468f, 0.10965175f, 0.16731024f, 0.06516258f, -0.06860424f, 0.07072164f, -0.07365590f, 
    -0.02189585f, -0.01329783f, -0.02889752f, 0.04534527f, 0.41800570f, 0.05638654f, 0.05296546f, 0.19024895f, 
    0.06155741f, -0.00579048f, 0.09210636f, 0.05200111f, -0.01989355f, -0.04157652f, 0.21700957f, 0.02334328f, 
    0.06448589f, 0.00286560f, 0.02963572f, -0.01497605f, -0.01247145f, -0.00006088f, -0.00633545f, -0.05982299f, 
    0.01412444f, -0.03249468f, 0.01611612f, -0.02605399f, 0.01790765f, -0.00774795f, 0.06210763f, -0.01631304f, 
    -0.05928687f, 0.02351601f, 0.01151886f, -0.04486161f, 0.05852008f, -0.02729036f, 0.05035554f, -0.04222581f, 
    0.06041385f, -0.01581893f, 0.06794651f, -0.04323336f, -0.03286853f, 0.01675803f, -0.01833127f, 0.04519361f, 
    0.01309253f, -0.04893053f, 0.03089355f, 0.02792455f, 0.06817032f, -0.00009068f, -0.01939911f, -0.04996245f, 
    -0.05946928f, -0.00009602f, 0.01287768f, -0.07184598f, 0.00632138f, -0.01358374f, 0.02399774f, -0.03935734f, 
    -0.00266909f, -0.03371266f, -0.06952474f, -0.06196387f, -0.07086509f, -0.05233585f, 0.01670283f, -0.01793043f, 
    0.04324080f, 0.03448384f, -0.03225939f, -0.06012874f, -0.06339051f, -0.05598956f, -0.01515579f, 0.02760494f, 
    -0.02841764f, 0.05162903f, -0.06168317f, -0.03952340f, -0.00759619f, 0.01627739f, -0.06768030f, -0.04202808f, 
    0.04624297f, 0.05887493f, -0.01622091f, -0.06918833f, -0.00390979f, -0.02732599f, -0.05173549f, 0.06727058f, 
    -0.01461852f, -0.06793362f, -0.05988020f, 0.04295908f, -0.05527245f, 0.06717413f, 0.06303591f, -0.01165498f, 
    -0.01439742f, 0.01393749f, -0.02565827f, -0.01887191f, 0.05646874f, 0.05461043f, 0.00410924f, -0.02909970f, 
    -0.03195675f, -0.00194497f, 0.01906247f, -0.05256912f, -0.05934474f, 0.02323549f, -0.06131218f, -0.01716650f, 
    -0.02767814f, -0.03434779f, 0.01591101f, -0.06206881f, 0.02475797f, -0.06440023f, -0.03218573f, -0.00017773f, 
    -0.00602928f, -0.06320622f, -0.00191985f, -0.00262218f, 0.00864580f, 0.04167718f, 0.01485015f, 0.01181811f, 
    -0.01855384f, -0.05683389f, 0.03731627f, 0.00103671f, 0.06230665f, 0.01214843f, 0.03525035f, -0.01506092f, 
    -0.06586985f, 0.00607428f, -0.04789120f, -0.07151497f, 0.00183716f, -0.00127908f, -0.06808094f, 0.01611899f, 
    -0.02919081f, 0.06719510f, -0.06057445f, -0.04344443f, -0.01561256f, 0.05367821f, 0.02689932f, -0.06357995f, 
    0.05624960f, 0.03958844f, -0.06636144f, -0.06635567f, 0.06634884f, -0.03645707f, 0.00106586f, -0.03898083f, 
    0.02290897f, -0.00468053f, -0.01384344f, 0.03266560f, 0.03789781f, -0.07141228f, 0.00760709f, -0.03597565f, 
    0.03950432f, 0.05382893f, -0.06073167f, -0.06024129f, 0.04537437f, -0.06361430f, 0.03248088f, -0.07068687f, 
    0.00706689f, 0.03861376f, -0.00256920f, 0.04433512f, 0.00406854f, -0.04244622f, -0.04354598f, -0.04682978f, 
    0.06017425f, 0.01218655f, 0.04563901f, -0.03621224f, -0.00049161f, 0.03258948f, 0.02262732f, -0.02663288f, 
    0.04685678f, -0.06989568f, 0.01849833f, 0.02554956f, -0.03592763f, -0.07210473f, 0.00818007f, 0.01964235f, 
    0.17766877f, -0.06819375f, -0.04799122f, 0.00016076f, 0.04109404f, 0.00015670f, 0.02816071f, -0.05722166f, 
    0.09874482f, 0.01789890f, 0.12599932f, -0.00003426f, 0.04020135f, -0.03401263f, -0.06532865f, 0.00090714f, 
    0.03021696f, 0.04943651f, -0.09280267f, -0.02523394f, 0.05151889f, -0.08444976f, -0.00297689f, -0.04505615f, 
    0.20474458f, -0.06913179f, -0.07731891f, 0.07086716f, 0.06480648f, -0.03920046f, 0.01820110f, -0.07300877f, 
    -0.10263361f, 0.06040912f, -0.01073165f, -0.01231452f, -0.21514697f, 0.11174641f, -0.07412310f, -0.07988287f, 
    -0.00262525f, 0.03539610f, 0.01877195f, 0.04812571f, 0.02119868f, 0.01655642f, 0.06218437f, 0.03267407f, 
    0.05398016f, 0.28877896f, 0.03286517f, 0.13314757f, -0.01010842f, -0.05736591f, -0.12858294f, 0.01019736f, 
    0.08609276f, -0.07293501f, 0.03596270f, 0.15402697f, 0.04266172f, -0.07112996f, -0.25878686f, -0.00438040f, 
    0.08083840f, -0.00493802f, 0.06488901f, -0.02990381f, 0.06268532f, 0.00824541f, 0.08960348f, -0.02987244f, 
    0.04275694f, -0.08546937f, 0.01406771f, -0.09226467f, 0.08861708f, 0.05007557f, -0.02630588f, 0.04131409f, 
    -0.16102232f, 0.03911905f, -0.04865876f, 0.08948673f, 0.21700704f, 0.31229106f, -0.01794033f, -0.08571394f, 
    -0.09280920f, 0.08882131f, -0.01346235f, 0.01677408f, 0.00923778f, 0.07559848f, 0.00368350f, 0.11995644f, 
    0.09361599f, -0.11969389f, 0.04304024f, -0.02431267f, -0.00556388f, -0.05564107f, -0.02228089f, 0.08676786f, 
    0.02429978f, -0.01805343f, -0.13847080f, -0.03501321f, 0.26219860f, 0.00103554f, -0.20921281f, -0.16282156f, 
    0.05941382f, 0.03173123f, 0.00820926f, 0.00586689f, 0.00649948f, 0.02211879f, -0.02312453f, -0.00111002f, 
    -0.20017086f, -0.14450137f, -0.22543359f, -0.05532187f, -0.01045694f, 0.04476692f, -0.02932695f, -0.03125970f, 
    -0.01936104f, 0.09086730f, -0.02480788f, -0.03284784f, -0.16753292f, -0.02277381f, 0.00268192f, 0.25198582f, 
    -0.05701416f, -0.04948522f, 0.08729900f, 0.08533051f, 0.03370638f, 0.12718961f, 0.09435673f, 0.02008061f, 
    0.33385539f, 0.01795356f, -0.05778304f, 0.08280566f, 0.04415138f, 0.09902288f, 0.11894482f, 0.05902301f, 
    0.00521575f, -0.06546140f, 0.09139723f, -0.00235618f, 0.20130272f, 0.04519917f, 0.07933195f, -0.05916663f, 
    -0.23411083f, -0.05041537f, -0.06289817f, 0.04035532f, 0.11034415f, 0.02928849f, 0.06852136f, 0.09138819f, 
    -0.11455514f, -0.09294229f, 0.05087593f, 0.11666898f, -0.01162569f, -0.04793428f, 0.06947052f, -0.00632832f, 
    0.04402103f, -0.08587924f, 0.04056813f, 0.04036680f, -0.16897295f, -0.00648896f, 0.03150601f, -0.09359103f, 
    -0.05853030f, -0.02456752f, 0.03264304f, -0.07067505f, -0.00905081f, 0.04974355f, 0.02784297f, -0.01405309f, 
    -0.05248251f, 0.03518690f, 0.01018686f, 0.02830578f, 0.03120792f, -0.00920836f, 0.05546029f, -0.00287751f, 
    -0.03133994f, 0.01957428f, -0.04552113f, -0.01590484f, 0.05660981f, -0.04320663f, -0.02119484f, -0.03815180f, 
    0.02445849f, 0.04298830f, -0.08079050f, -0.03378978f, -0.07059339f, 0.02442834f, 0.00083324f, 0.02122103f, 
    0.04221527f, -0.07941031f, 0.01274552f, 0.05636659f, 0.04412404f, 0.05076139f, -0.02554082f, 0.05731963f, 
    -0.04450623f, -0.05745642f, -0.07016621f, -0.04888392f, -0.02179037f, 0.01251853f, -0.03723653f, -0.01706089f, 
    -0.02853907f, -0.07718562f, 0.02536076f, -0.03040093f, -0.01621230f, 0.04359534f, -0.06693155f, -0.02894922f, 
    -0.05436980f, -0.00837621f, -0.07207334f, 0.00215618f, 0.01727487f, -0.00434148f, -0.04579744f, 0.00507227f, 
    -0.06035210f, 0.04252091f, 0.06000215f, -0.03715458f, -0.02082657f, -0.07933079f, 0.04291517f, -0.04156557f, 
    -0.03080501f, -0.01886786f, 0.05735788f, -0.02919811f, 0.03697041f, -0.04722724f, -0.03603943f, 0.03386405f, 
    -0.01170776f, -0.07071855f, 0.01671165f, -0.07322174f, -0.00082314f, -0.02057540f, 0.03362981f, 0.03801395f, 
    0.01207209f, -0.06679776f, 0.04524741f, 0.03434078f, -0.06944296f, -0.06747980f, -0.05720959f, -0.02188749f, 
    -0.00276519f, 0.00301674f, 0.02934761f, -0.07262152f, 0.03145939f, 0.03476827f, -0.08394681f, 0.02316248f, 
    -0.06650225f, 0.04084644f, -0.07988012f, -0.06401227f, -0.07183257f, -0.06862900f, -0.01184216f, -0.02156854f, 
    0.01145301f, -0.03776170f, -0.07367539f, -0.07277742f, -0.08002018f, 0.05651516f, -0.04942092f, -0.07142266f, 
    0.02505785f, -0.01439190f, 0.03505310f, -0.04729627f, -0.01207875f, 0.04244187f, -0.06909703f, -0.07125603f, 
    -0.00168289f, 0.06824858f, 0.05451027f, -0.03619229f, -0.06857020f, 0.05795341f, 0.01373607f, 0.04627572f, 
    0.04365866f, -0.04543203f, -0.07309392f, -0.01156084f, 0.06007552f, 0.02717433f, 0.01715685f, -0.04879511f, 
    0.03614082f, -0.04981196f, 0.00344024f, 0.00658158f, -0.04713119f, 0.01794662f, -0.04858190f, 0.04088780f, 
    -0.05291654f, 0.06026632f, -0.00173948f, -0.02108018f, -0.06917511f, -0.02269478f, 0.02973934f, -0.03643446f, 
    0.00400249f, -0.01434469f, -0.07414223f, -0.02259073f, 0.06374338f, 0.04029511f, -0.06657168f, -0.00260463f, 
    -0.06488718f, -0.02730505f, -0.01069922f, -0.02253398f, 0.05672139f, -0.07429104f, 0.04113425f, 0.03547337f, 
    0.01261395f, -0.02204247f, -0.04265819f, 0.02899925f, -0.02038465f, -0.02787974f, -0.06119404f, -0.01879309f, 
    -0.03807822f, 0.05224615f, -0.00459988f, 0.05871803f, -0.01957817f, 0.04423550f, -0.00909299f, -0.02460500f, 
    -0.04331986f, 0.02395101f, -0.05735077f, -0.07646225f, 0.05621235f, -0.03632326f, 0.00380086f, -0.01634207f, 
    0.02415619f, -0.15663084f, -0.18712948f, -0.08528394f, -0.12927163f, -0.02227097f, -0.08457083f, -0.09269699f, 
    0.15484725f, -0.00941595f, 0.14174831f, -0.14391290f, 0.05668072f, -0.10467219f, 0.10867625f, 0.10287272f, 
    -0.01692481f, -0.03671703f, -0.00138634f, -0.03980035f, 0.02742673f, 0.02833053f, 0.08301257f, 0.00630045f, 
    0.22522888f, -0.02131477f, 0.16403876f, -0.00865956f, 0.09794103f, -0.10199876f, 0.11324030f, 0.05111391f, 
    -0.02583471f, -0.01416327f, 0.01746942f, 0.08627270f, -0.08840816f, -0.07535571f, -0.03106674f, -0.17488755f, 
    -0.16477862f, 0.13997070f, 0.01792468f, 0.01778479f, 0.04895265f, 0.04150342f, 0.11335586f, -0.09073884f, 
    0.12155303f, 0.24765587f, -0.01689569f, -0.01024409f, 0.11979247f, -0.03175939f, 0.10230524f, -0.03878579f, 
    0.08840650f, -0.02227788f, 0.07980372f, 0.05541719f, 0.00775470f, -0.12615788f, -0.26661116f, -0.02652485f, 
    0.05128034f, 0.08342196f, 0.05236266f, -0.00983108f, -0.00095915f, 0.10109010f, 0.05871950f, -0.09897508f, 
    0.24586059f, 0.01570733f, -0.05570328f, 0.00041107f, 0.06042441f, 0.02128593f, -0.00043803f, 0.05289960f, 
    -0.06361217f, -0.01257467f, -0.05780816f, 0.04129341f, 0.00534877f, 0.28049469f, -0.26495016f, -0.06877594f, 
    -0.04190902f, 0.16457252f, -0.03430425f, 0.04514999f, 0.04952127f, 0.03579447f, 0.02244540f, 0.09706898f, 
    0.06896902f, 0.01409344f, -0.01148514f, 0.23456316f, 0.05264373f, -0.02475486f, -0.03987964f, 0.14689794f, 
    0.10936099f, -0.00311661f, -0.10370103f, 0.10939485f, 0.19797182f, -0.06879876f, 0.05240824f, -0.08416204f, 
    0.12219246f, -0.04588858f, -0.04683388f, 0.06138089f, 0.07421716f, -0.02140843f, 0.08225645f, -0.07675626f, 
    0.20485710f, -0.01483807f, -0.15035906f, 0.01386814f, 0.03488330f, 0.08725824f, -0.06166064f, 0.04207573f, 
    -0.01260298f, 0.10768970f, 0.08935563f, -0.00752739f, -0.26313794f, 0.01191000f, -0.08352944f, 0.16698521f, 
    -0.05530343f, 0.02997336f, 0.08328107f, -0.02208401f, 0.06858852f, 0.04755760f, 0.09361862f, 0.01000567f, 
    0.30410871f, -0.05270277f, -0.02052370f, 0.19352341f, -0.02047616f, 0.00949015f, 0.05945765f, 0.10883341f, 
    -0.03391398f, 0.03210972f, 0.03563212f, 0.00910722f, 0.08704847f, 0.20956297f, 0.08853370f, -0.02531156f, 
    -0.07106676f, 0.04433824f, -0.08197560f, 0.09906578f, 0.02212279f, -0.02057893f, 0.12245935f, -0.04770175f, 
    -0.01679143f, -0.01645340f, 0.01502995f, 0.19028836f, -0.03642748f, 0.00545739f, -0.07455456f, -0.03759496f, 
    0.09035831f, -0.00828735f, 0.06472473f, 0.09180988f, -0.06229829f, -0.01357112f, -0.24275920f, -0.06464727f, 
    -0.04744972f, -0.00509767f, -0.03868614f, -0.05288506f, -0.00071330f, -0.15402044f, 0.03330493f, -0.01542854f, 
    0.11600924f, 0.00942421f, -0.01476550f, -0.04234402f, 0.12208877f, -0.04379804f, 0.06771727f, -0.11577243f, 
    0.14472803f, -0.09402318f, 0.10699342f, 0.02712013f, -0.00403650f, 0.03574573f, -0.01581264f, 0.02944651f, 
    -0.00228735f, 0.06818371f, 0.08017665f, 0.03815990f, 0.03307487f, -0.03303922f, 0.07711007f, 0.00226013f, 
    -0.02155332f, -0.07805578f, 0.31565714f, 0.02423266f, 0.20245740f, -0.00334196f, 0.06038476f, 0.01130651f, 
    0.08690713f, -0.08835542f, -0.09078661f, 0.12590224f, 0.29770625f, -0.03976187f, -0.07683170f, 0.03671667f, 
    -0.00989269f, 0.17508548f, 0.08182313f, -0.01988881f, -0.03553493f, -0.02868775f, 0.10616753f, 0.03112675f, 
    0.07277507f, -0.19347909f, 0.19703849f, 0.28525150f, 0.00079734f, 0.07990938f, 0.13060503f, -0.10071122f, 
    0.04946845f, -0.03669914f, 0.09916916f, 0.02691278f, 0.11474040f, -0.04931341f, 0.02147877f, 0.11132473f, 
    0.12188362f, 0.19079337f, 0.01233944f, 0.00475825f, 0.07254465f, 0.08781727f, 0.05912044f, -0.16665952f, 
    0.27737296f, 0.12138361f, 0.00083359f, 0.05577057f, 0.03031603f, 0.04555828f, -0.02028048f, 0.01060542f, 
    -0.00461914f, 0.02036275f, -0.02361075f, -0.00565317f, 0.02964775f, -0.06725936f, -0.29764855f, 0.01420665f, 
    0.10543125f, 0.00903535f, -0.07727434f, -0.05933435f, 0.16657713f, 0.09755921f, -0.07554109f, 0.09209725f, 
    -0.09831803f, -0.04660381f, -0.04458133f, -0.13305767f, 0.18521591f, -0.01641830f, 0.05558332f, 0.13683654f, 
    -0.01249398f, 0.02956781f, 0.02922429f, 0.06859870f, -0.14978442f, -0.12572256f, 0.11109534f, 0.27192765f, 
    -0.02011021f, -0.03283939f, 0.03465264f, 0.06934042f, 0.01533546f, 0.11006797f, 0.06907527f, -0.12908345f, 
    -0.08779985f, -0.38045678f, -0.03900235f, 0.16344525f, -0.15520163f, -0.00884339f, 0.04301919f, 0.13493386f, 
    -0.03368561f, 0.04218315f, 0.00917258f, 0.06393046f, 0.05641418f, -0.11984418f, 0.11503144f, -0.21546230f, 
    0.05697356f, 0.08764497f, -0.05556728f, 0.02534913f, 0.05608751f, -0.05002024f, 0.02356902f, 0.01621202f, 
    0.16224217f, 0.06768969f, -0.02046547f, -0.04176636f, 0.08171954f, 0.11449674f, 0.05815536f, 0.12256202f, 
    -0.05715151f, -0.02684894f, 0.04562596f, -0.03546525f, -0.06875794f, 0.25782889f, -0.04699919f, -0.35379758f, 
    0.08833311f, -0.09038591f, -0.09064730f, -0.02179541f, 0.01535524f, 0.02988663f, 0.00940804f, 0.08840457f, 
    0.03636759f, 0.03155649f, 0.02044255f, 0.06686337f, -0.11974870f, 0.14511220f, 0.05734146f, 0.10124113f, 
    -0.04692224f, 0.00336035f, -0.05650598f, -0.03076076f, 0.15766263f, -0.09529128f, -0.13635541f, -0.19494461f, 
    0.05747747f, 0.08662111f, -0.20812047f, 0.00989986f, -0.07261229f, 0.06410082f, -0.02724237f, -0.03830821f, 
    0.05637565f, 0.11132802f, 0.04582243f, -0.07071744f, -0.02491285f, 0.14931589f, -0.18060647f, 0.19408019f, 
    0.15715739f, 0.06129961f, 0.25453451f, 0.00827546f, -0.20757207f, -0.15718286f, -0.15996404f, -0.10923807f, 
    -0.13144770f, 0.18886776f, 0.06375855f, -0.02163713f, -0.10904559f, 0.05097036f, -0.12843898f, 0.03358231f, 
    0.24880646f, -0.17088209f, 0.19664450f, -0.07577117f, 0.04099653f, 0.11737932f, 0.07991687f, 0.12430190f, 
    0.11189143f, 0.08706729f, 0.14190046f, -0.00620213f, 0.04895465f, -0.18851298f, -0.04066132f, 0.12250233f, 
    -0.00175064f, -0.08385479f, 0.03234275f, 0.04129581f, -0.19016431f, -0.05850897f, -0.00921087f, -0.18345979f, 
    -0.07909826f, 0.05490363f, -0.02376812f, 0.05498416f, 0.06615310f, 0.17970154f, -0.00192577f, 0.06112775f, 
    -0.01883717f, 0.01522221f, 0.06353304f, 0.03031225f, 0.44173208f, -0.13500315f, 0.13661441f, -0.20885046f, 
    0.06212572f, -0.12711334f, 0.04680919f, -0.03410318f, 0.01513266f, -0.18272263f, -0.32345000f, -0.04860536f, 
    0.25040868f, -0.04740892f, 0.13984153f, 0.14467280f, 0.13832377f, -0.11179712f, -0.11416899f, 0.02713933f, 
    -0.07393532f, -0.05400996f, -0.10431623f, -0.28883800f, 0.24046966f, 0.08864938f, -0.05567583f, 0.06003944f, 
    0.16975027f, 0.01058404f, -0.12878391f, -0.16176564f, 0.01808726f, -0.29106104f, -0.09538448f, -0.13834623f, 
    -0.20406064f, -0.05796846f, -0.28037721f, -0.19722676f, 0.07911147f, 0.05598582f, 0.12692754f, 0.07697629f, 
    -0.11536986f, -0.05513066f, 0.16092093f, 0.20681348f, 0.07737025f, -0.16439134f, 0.20898721f, -0.07861882f, 
    -0.05806201f, -0.03618579f, 0.14460914f, 0.11703530f, -0.04257216f, -0.01941151f, -0.05668155f, 0.12348808f, 
    0.73247659f, 0.25539437f, 0.02983218f, -0.13701102f, -0.08022685f, 0.21299531f, 0.09972326f, 0.18460722f, 
    -0.12014545f, -0.15065669f, -0.11125258f, -0.03271917f, 0.23483135f, 0.00955210f, -0.02747354f, 0.08976515f, 
    0.01916175f, -0.01706945f, -0.19852716f, -0.10121778f, 0.10538885f, -0.02416883f, 0.02240156f, 0.06008209f, 
    0.15276337f, 0.27654630f, -0.02643736f, 0.07593588f, 0.08047997f, -0.03638564f, 0.02451210f, 0.08640884f, 
    -0.09090050f, 0.12492813f, -0.00692555f, 0.04396608f, 0.24232686f, 0.01468104f, -0.07967458f, 0.01740726f, 
    0.13948539f, -0.12029198f, -0.07298882f, -0.00724897f, 0.04772992f, 0.09590527f, 0.15296841f, 0.02356062f, 
    -0.14880928f, 0.08464420f, -0.13979317f, -0.12540796f, 0.08997213f, -0.04320315f, -0.00683602f, 0.09579744f, 
    0.17837891f, 0.12997848f, 0.01026384f, -0.16931915f, 0.15595290f, 0.07014944f, -0.14879172f, -0.08754685f, 
    0.08297852f, -0.07006326f, -0.20204033f, 0.09287512f, -0.17787498f, -0.05049961f, 0.18046099f, -0.04997311f, 
    0.00855128f, -0.01571899f, 0.04260786f, -0.03572154f, -0.04239729f, 0.05874252f, -0.02330904f, 0.04251242f, 
    -0.06149703f, -0.00385868f, -0.06462044f, -0.06007369f, -0.03128647f, -0.04966254f, -0.05620633f, -0.01711531f, 
    -0.07128324f, 0.03185073f, -0.07019478f, -0.06551282f, 0.00161435f, -0.08341636f, -0.01894582f, -0.00828147f, 
    0.02433529f, -0.03920841f, -0.00836109f, -0.03905666f, 0.01664159f, -0.02121873f, 0.04824294f, -0.03490415f, 
    0.06560660f, -0.05747904f, 0.00497992f, -0.06966843f, -0.03651475f, -0.05144522f, 0.05638394f, 0.01383641f, 
    0.04753679f, -0.05043197f, -0.04336090f, 0.03953809f, 0.06371125f, 0.05645294f, 0.05699541f, -0.06626787f, 
    -0.01448159f, 0.03480174f, -0.04812774f, -0.02725748f, -0.07231646f, -0.01044700f, -0.06004481f, -0.05020412f, 
    -0.02306937f, 0.01725848f, -0.02026240f, -0.04472091f, -0.08261757f, 0.05577900f, -0.02317632f, 0.03526716f, 
    -0.05804904f, 0.03021500f, 0.02669692f, -0.01406158f, -0.03076870f, -0.04155094f, -0.03806200f, -0.03338545f, 
    -0.02798183f, 0.01008368f, 0.05181288f, 0.05066907f, -0.02372717f, -0.01454032f, 0.02000297f, 0.01262498f, 
    -0.07285409f, -0.03330175f, -0.06317528f, -0.00214809f, -0.06266622f, -0.01031262f, -0.04415005f, -0.01993552f, 
    0.00240598f, -0.08086370f, 0.06935596f, 0.06084987f, 0.02977309f, 0.02960398f, 0.04854414f, 0.00304770f, 
    -0.01638403f, 0.02347191f, -0.06045363f, -0.04973134f, -0.01289828f, 0.05110905f, -0.04746035f, -0.06983750f, 
    -0.00749587f, -0.05029545f, -0.01719468f, 0.04775129f, -0.04158485f, -0.06337266f, -0.02857246f, -0.05516679f, 
    -0.04470965f, 0.03467477f, 0.04605035f, -0.00110754f, -0.01321581f, -0.00748797f, 0.01572332f, -0.04559929f, 
    -0.00265000f, -0.06729228f, -0.06326672f, 0.04407423f, 0.06682109f, 0.04893590f, 0.02831350f, -0.03128394f, 
    -0.03651698f, 0.05393796f, -0.01986306f, 0.01633443f, -0.06873148f, 0.03811441f, -0.07691756f, -0.01626975f, 
    0.04427392f, 0.04088597f, -0.01285067f, -0.04429950f, -0.01485892f, 0.05072476f, -0.07007689f, -0.04121488f, 
    0.07029600f, 0.04206811f, 0.06614836f, -0.01609021f, 0.05646006f, -0.02073873f, 0.04290860f, 0.04206543f, 
    -0.03091602f, 0.05535883f, -0.01027519f, 0.03222186f, 0.05779209f, -0.01117301f, -0.06065157f, 0.03560836f, 
    0.05161240f, 0.00839561f, 0.02090193f, 0.05790714f, -0.06945393f, -0.08100738f, -0.00054483f, -0.02287717f, 
    -0.07167725f, 0.00371499f, -0.03020359f, -0.04009724f, -0.05464037f, 0.01140481f, -0.03575094f, -0.01473697f, 
    -0.03764948f, -0.02962390f, 0.00154298f, -0.04059903f, 0.00700162f, 0.04019662f, -0.06807553f, 0.05795944f, 
    -0.00774980f, 0.03203140f, 0.04275884f, -0.06208965f, 0.03990886f, -0.00069030f, 0.02693494f, -0.05395138f, 
    -0.08763229f, -0.00307839f, -0.23270120f, -0.11209679f, 0.07249537f, -0.09506153f, 0.11671364f, 0.03803214f, 
    -0.05751500f, 0.06002896f, 0.12872937f, 0.13415834f, -0.00791572f, -0.01286246f, -0.06062078f, -0.08177213f, 
    -0.00279879f, 0.05545613f, -0.01804866f, 0.10108747f, 0.02621993f, 0.00888814f, 0.04313821f, 0.07829311f, 
    0.17529760f, 0.07374566f, 0.23396289f, 0.04556525f, 0.11149947f, 0.13626310f, -0.07205988f, 0.03524020f, 
    0.05581059f, 0.04899732f, 0.01622780f, -0.02245688f, -0.05351702f, -0.00625284f, -0.03615527f, 0.21471030f, 
    -0.00550422f, -0.08764219f, -0.06022785f, 0.11362922f, -0.13943546f, -0.10630079f, 0.16420498f, -0.09344183f, 
    -0.05267229f, 0.11148743f, 0.17279539f, 0.28172642f, -0.07310501f, 0.14804292f, 0.11723831f, 0.14351417f, 
    -0.02229471f, 0.00525669f, 0.09414840f, 0.11911289f, -0.10322402f, -0.14091296f, -0.21095441f, -0.14182314f, 
    0.10458812f, -0.03313072f, 0.02811625f, -0.02579830f, -0.15562607f, -0.03962445f, 0.07480351f, -0.16582333f, 
    0.10118510f, -0.05926177f, -0.05555619f, 0.02390538f, 0.01850705f, 0.01179637f, -0.11126058f, 0.03112613f, 
    -0.16331328f, 0.01581559f, -0.11462564f, 0.00118647f, 0.24431480f, 0.05976959f, 0.03212739f, -0.04311116f, 
    0.21063189f, -0.05403215f, 0.04265282f, -0.10399564f, -0.02103819f, -0.10762282f, -0.09557153f, -0.10402057f, 
    -0.07626811f, 0.04518210f, 0.00353758f, -0.35030600f, 0.13342397f, 0.06001562f, -0.08657569f, 0.09830102f, 
    -0.09807812f, -0.06743759f, 0.01550798f, 0.11560937f, -0.20553538f, -0.22518380f, 0.04890382f, 0.18129998f, 
    -0.05447939f, -0.04109319f, -0.00582285f, 0.02376741f, 0.05263677f, 0.03357165f, -0.00920346f, -0.02450946f, 
    -0.24599659f, -0.29014733f, -0.10504813f, -0.02329630f, -0.10636849f, -0.02083536f, -0.08055646f, 0.11389194f, 
    -0.06663695f, -0.04303240f, -0.15804514f, 0.07019988f, 0.04925274f, -0.21552826f, -0.01727492f, -0.20005429f, 
    0.04852080f, -0.00625364f, -0.06664238f, 0.05050389f, -0.03230666f, -0.07809961f, 0.09511052f, 0.06382887f, 
    0.15014356f, 0.00799432f, -0.02397567f, -0.10219397f, 0.18551332f, 0.04316261f, 0.14365675f, 0.02773133f, 
    0.04986086f, -0.04343152f, 0.13581769f, 0.08072761f, 0.19996138f, 0.31560799f, 0.03997821f, -0.42857930f, 
    -0.04392835f, -0.00377906f, 0.10739191f, 0.04785872f, 0.13582535f, -0.06390066f, 0.06996274f, 0.09960993f, 
    0.01974246f, 0.13995402f, 0.19138098f, -0.05634437f, 0.01450406f, 0.04498673f, 0.05868595f, -0.02096454f, 
    -0.01473673f, 0.03628075f, 0.09837705f, -0.03142114f, 0.19703576f, -0.03605155f, 0.07055236f, -0.21306248f, 
    0.02709314f, 0.02511420f, 0.00078747f, 0.07332782f, -0.02150358f, 0.13214868f, 0.00552215f, 0.01947028f, 
    -0.12549089f, 0.14408819f, 0.14799374f, 0.27998146f, 0.04191945f, 0.11387891f, 0.11778618f, 0.20288062f, 
    -0.07335531f, 0.12986475f, 0.01940014f, 0.14673443f, -0.07513700f, 0.07912060f, 0.09598488f, 0.03166482f, 
    -0.05496341f, -0.12010754f, 0.01914402f, -0.00350245f, 0.07266092f, 0.03571707f, -0.15313728f, 0.04182627f, 
    -0.13251045f, 0.15817387f, -0.23441881f, -0.00618351f, -0.07563398f, -0.03168320f, -0.11632473f, 0.01407327f, 
    -0.05943500f, -0.02575800f, 0.08377134f, -0.06470779f, -0.04166760f, -0.06592517f, 0.10476200f, 0.07390316f, 
    0.01754892f, -0.10437123f, -0.00630422f, 0.14925329f, 0.11036927f, 0.09461538f, -0.01546517f, 0.08163768f, 
    0.06145127f, -0.07459045f, 0.05856272f, -0.10033324f, -0.08367854f, -0.00799118f, -0.00625386f, -0.00036007f, 
    -0.12108989f, -0.02641092f, 0.01938134f, 0.01117400f, -0.19023444f, 0.12670910f, 0.15331417f, -0.01956705f, 
    0.06618591f, -0.06658256f, 0.02065038f, 0.02741712f, 0.04891461f, 0.03273629f, -0.06217622f, 0.02469460f, 
    -0.17111243f, 0.07635994f, -0.07302321f, 0.03174900f, 0.09860527f, 0.04283655f, -0.00568987f, -0.01471207f, 
    0.00111231f, 0.02163318f, 0.05343218f, 0.03908651f, -0.03846901f, 0.01496243f, 0.43637189f, 0.02916712f, 
    -0.07636112f, -0.01471789f, -0.02446747f, -0.03301274f, -0.00836755f, -0.13983335f, -0.05979378f, -0.05942005f, 
    0.17381330f, 0.07657504f, 0.02285505f, 0.18092285f, -0.13011926f, -0.03765462f, 0.07574901f, -0.14126629f, 
    0.04671080f, -0.00886313f, 0.06691875f, 0.01809316f, -0.00822485f, 0.18323670f, 0.08151235f, -0.10980594f, 
    0.11666011f, 0.05748565f, 0.04883830f, 0.03378730f, 0.13111196f, 0.06449302f, 0.10157656f, 0.10322541f, 
    -0.08322600f, 0.18564959f, 0.13149466f, -0.04164197f, 0.31562364f, 0.01858575f, 0.10567228f, 0.05830976f, 
    -0.03607819f, -0.02340011f, 0.12336493f, 0.09994146f, 0.18857838f, 0.25701603f, -0.11376137f, 0.04737917f, 
    0.08240906f, 0.04293477f, 0.01231741f, 0.12092292f, -0.03673613f, -0.02077338f, -0.00967218f, 0.05255952f, 
    -0.18402965f, -0.03453281f, 0.10535013f, -0.08186327f, -0.08789282f, -0.00445620f, -0.04968006f, -0.01070882f, 
    -0.07949689f, 0.07233423f, 0.01014364f, 0.06075070f, 0.12126035f, 0.04162250f, 0.05527215f, 0.30593184f, 
    -0.06251407f, 0.02708868f, 0.07844032f, -0.03184844f, -0.04224272f, 0.02135980f, -0.02379202f, -0.05995244f, 
    0.01283314f, 0.01454463f, -0.14394480f, -0.14351511f, 0.03064197f, 0.01343467f, 0.04058328f, 0.06902211f, 
    -0.08248777f, 0.05140853f, 0.00855029f, 0.10204721f, 0.21515183f, 0.24016033f, 0.14854708f, 0.31415424f, 
    -0.04218351f, 0.00196353f, 0.21197204f, 0.01178271f, 0.05986156f, 0.09112281f, 0.07690449f, 0.11719264f, 
    0.26766518f, 0.12748736f, 0.38987932f, 0.32671854f, 0.19102298f, 0.07200986f, 0.03320646f, 0.07857184f, 
    -0.12220725f, 0.09871520f, 0.09574731f, -0.02244715f, -0.10033438f, 0.00639420f, -0.02053518f, -0.03971630f, 
    0.07915343f, -0.01355601f, -0.10302679f, -0.01366621f, 0.08101299f, -0.10013516f, 0.03150600f, -0.09335813f, 
    -0.18917203f, -0.03312205f, -0.10412314f, 0.00188592f, 0.02751842f, -0.12758340f, -0.02812373f, -0.07136939f, 
    -0.16765194f, -0.06010633f, -0.17110476f, 0.14199525f, 0.28150031f, -0.15199810f, -0.04422551f, 0.06442212f, 
    -0.01179443f, -0.04140756f, -0.01543800f, -0.10584240f, -0.02387455f, -0.01916692f, -0.21545897f, 0.08920296f, 
    0.23330699f, -0.43531653f, 0.14334145f, -0.13499454f, -0.11414238f, -0.00311899f, -0.02659183f, -0.09053075f, 
    -0.03862725f, -0.07738163f, 0.18894280f, -0.04497433f, 0.24466553f, 0.19426954f, 0.29255226f, 0.30709860f, 
    -0.05513319f, 0.07676491f, 0.07033744f, 0.08720084f, -0.02062549f, -0.08521181f, -0.09638163f, -0.18771237f, 
    0.10590299f, 0.07000198f, -0.08434577f, -0.01780173f, 0.07881422f, 0.05208256f, 0.11432426f, 0.00683895f, 
    -0.04397649f, -0.04566009f, -0.10344505f, 0.01666216f, 0.05220548f, -0.03403965f, -0.07661082f, -0.13803376f, 
    -0.24738568f, -0.09574328f, -0.14888471f, -0.07829644f, 0.04787234f, -0.05393626f, -0.10844836f, -0.10842941f, 
    0.11370114f, -0.01780730f, 0.05987257f, 0.12414956f, -0.03750528f, -0.01705372f, 0.06722581f, -0.01282485f, 
    0.09921379f, 0.07067434f, -0.06206560f, -0.01332041f, 0.14171419f, 0.23358750f, 0.08802394f, 0.37895072f, 
    -0.00878857f, 0.06131304f, 0.09055982f, 0.08437409f, 0.09883682f, 0.08915591f, -0.01645919f, -0.05398166f, 
    -0.08212791f, -0.09529717f, 0.13736437f, 0.15660399f, 0.28764972f, -0.09114943f, 0.04118515f, -0.04737875f, 
    0.01740652f, 0.03541172f, 0.01795815f, 0.08584528f, 0.08134960f, 0.07016809f, 0.12982364f, 0.13820137f, 
    -0.08531424f, -0.10407682f, 0.07169274f, 0.01328420f, -0.10111617f, 0.04546661f, 0.00618163f, 0.16976875f, 
    0.09051064f, -0.04941623f, -0.03670447f, 0.03346047f, -0.09010365f, 0.08436819f, -0.12807894f, -0.01562396f, 
    -0.03289648f, 0.04039767f, 0.03978211f, -0.01385532f, -0.25815606f, 0.07783642f, -0.09489183f, -0.19864479f, 
    -0.11974663f, -0.04528322f, -0.00327106f, 0.06889839f, -0.01124137f, -0.00056790f, -0.00152466f, -0.08169117f, 
    0.04772839f, -0.18671970f, -0.07197222f, -0.07524741f, -0.14050597f, -0.05142183f, -0.10859306f, 0.15195692f, 
    0.04397238f, -0.02914176f, -0.01406874f, -0.01138608f, 0.03088877f, 0.05371545f, -0.06557611f, -0.14159630f, 
    -0.05621413f, 0.02350720f, 0.00361182f, 0.06418361f, -0.22456197f, 0.10564966f, 0.21815363f, 0.10393594f, 
    -0.30023524f, -0.04867828f, 0.06630301f, 0.05000950f, 0.13310975f, -0.01842915f, 0.03812438f, 0.09689624f, 
    -0.15718335f, 0.09663593f, 0.11184223f, 0.09875374f, 0.14044164f, 0.02312288f, 0.07299329f, 0.10518163f, 
    -0.07214750f, -0.01550180f, -0.03157387f, 0.04136460f, 0.05720807f, 0.02317738f, 0.00232009f, 0.01586508f, 
    0.24602115f, -0.08336353f, 0.03089035f, -0.06722912f, -0.14514184f, 0.02931500f, 0.02742011f, -0.02695101f, 
    -0.02067790f, 0.01936911f, -0.09642369f, -0.05104567f, 0.13208506f, -0.10585432f, -0.05986262f, -0.07609992f, 
    -0.04108038f, -0.02454010f, 0.09584299f, 0.06482080f, 0.01104413f, -0.01868720f, 0.12366149f, 0.08969963f, 
    0.10654669f, 0.18691576f, 0.15480657f, -0.18969089f, -0.16574654f, -0.10970774f, 0.02047284f, -0.01877250f, 
    0.00325630f, 0.07470860f, 0.09049714f, -0.02003536f, -0.04800788f, 0.02296901f, 0.14169319f, -0.00155511f, 
    0.12730169f, -0.01295753f, 0.02891726f, 0.12644190f, 0.03814889f, -0.11326122f, -0.03626897f, -0.12406471f, 
    -0.19389822f, -0.16361012f, 0.02974521f, -0.13488996f, 0.14429000f, 0.02219425f, -0.03487082f, 0.12607597f, 
    0.02394350f, -0.03760021f, 0.00890903f, -0.16143797f, 0.30720109f, 0.37603340f, 0.32199872f, 0.20886356f, 
    -0.18596552f, -0.05388851f, 0.07503111f, 0.02058322f, 0.03915287f, 0.02837486f, -0.01295282f, -0.01127091f, 
    0.37787405f, 0.12280589f, 0.07386077f, 0.24029972f, -0.02540206f, -0.00605741f, 0.15976518f, 0.01750605f, 
    -0.02865002f, 0.09245306f, 0.06184294f, 0.02551192f, -0.15523300f, -0.09307653f, 0.12590030f, 0.01729822f, 
    0.15376240f, 0.04305459f, 0.07929805f, 0.02209547f, 0.07854318f, 0.12882955f, 0.05832450f, 0.06124595f, 
    -0.11024572f, -0.08135337f, -0.08604283f, -0.00947233f, 0.17183125f, -0.00907967f, 0.08639792f, -0.04270738f, 
    -0.01792527f, 0.03760518f, -0.03057628f, 0.06000831f, -0.30443278f, 0.10424418f, -0.13765867f, -0.08484253f, 
    -0.04808552f, 0.13728076f, 0.01097887f, -0.02104357f, 0.04452178f, -0.02457763f, 0.08570316f, 0.04881656f, 
    -0.13070886f, 0.03735949f, -0.13985814f, -0.02547431f, 0.09790670f, 0.02434153f, -0.00739614f, -0.04454666f, 
    -0.03992567f, -0.07348609f, 0.03599868f, 0.01740926f, 0.49218017f, 0.09348440f, 0.29262671f, 0.28060880f, 
    -0.02235833f, 0.02053462f, -0.03906454f, 0.11204416f, 0.00299293f, 0.02372411f, -0.06990273f, 0.00397789f, 
    -0.15722482f, -0.01627146f, -0.15529750f, -0.08291081f, 0.03583534f, -0.02310216f, 0.05414754f, 0.05497126f, 
    -0.14793424f, -0.09130041f, 0.10225375f, 0.03143480f, 0.28266838f, 0.27126747f, 0.09376313f, 0.16167916f, 
    0.02987530f, 0.09565605f, 0.03840426f, -0.05499582f, 0.02309012f, 0.05407419f, 0.14959942f, -0.04479719f, 
    0.01098341f, -0.03160829f, -0.17530836f, 0.14357589f, 0.11746166f, 0.04678686f, 0.21878523f, -0.08083221f, 
    -0.08382916f, -0.08926813f, -0.15600924f, -0.00718169f, 0.12812543f, -0.06472247f, 0.03279750f, 0.02847191f, 
    0.10822174f, -0.01290014f, -0.11838713f, 0.09531198f, 0.12297323f, 0.03463607f, 0.06683661f, -0.03634878f, 
    -0.35344860f, 0.12371930f, -0.12864101f, 0.00184917f, 0.27342004f, 0.00898294f, 0.09435812f, -0.13812923f, 
    -0.04913447f, 0.02349801f, -0.00324687f, 0.12834249f, -0.12646224f, 0.05879471f, 0.06895301f, 0.07857148f, 
    -0.02380790f, 0.11910893f, 0.09312261f, -0.01877825f, 0.14321141f, 0.04853890f, -0.10813229f, 0.26146379f, 
    -0.07542092f, -0.02086928f, -0.03713559f, 0.15443480f, 0.06679607f, 0.00830450f, -0.02199674f, -0.01157639f, 
    -0.03890912f, -0.12341854f, 0.02661414f, 0.02991512f, -0.26391432f, -0.02553663f, -0.27163991f, -0.00687972f, 
    -0.03566644f, 0.04229889f, -0.03263098f, -0.04866602f, -0.00934897f, 0.19371018f, 0.15745361f, 0.03300063f, 
    0.04942903f, 0.18771310f, -0.16503474f, -0.03370810f, 0.09490775f, -0.05475257f, 0.11627261f, 0.02526685f, 
    0.04635368f, 0.13500418f, 0.02479832f, 0.32005441f, -0.19755316f, 0.08845764f, 0.08869262f, 0.02663334f, 
    -0.04955952f, 0.06809442f, -0.02285897f, -0.02095917f, 0.01553431f, 0.12615618f, 0.18323417f, 0.22635385f, 
    0.27959591f, 0.09403507f, 0.00188088f, -0.04528455f, -0.02758107f, 0.08054624f, -0.08853257f, 0.00963532f, 
    0.09179135f, 0.06237058f, -0.07736816f, -0.00619872f, 0.20046720f, 0.12423787f, -0.27288976f, -0.02917201f, 
    0.03507505f, 0.04726277f, -0.12843753f, 0.06495314f, 0.08739647f, -0.09869489f, 0.03664628f, -0.03170742f, 
    -0.31120512f, -0.15901649f, -0.10327167f, -0.00037184f, -0.00842542f, -0.01909070f, 0.01296935f, -0.07294939f, 
    -0.04584938f, 0.00331994f, 0.03590994f, -0.00805139f, 0.02459907f, 0.26909742f, -0.04601330f, 0.23563667f, 
    -0.02192430f, -0.11882731f, 0.01715299f, 0.04030728f, 0.00719374f, 0.17401525f, 0.04813327f, -0.00889724f, 
    -0.09209441f, -0.09614865f, -0.09774354f, -0.07161846f, 0.09843791f, -0.00007556f, 0.00980644f, -0.02051850f, 
    0.02068599f, -0.08156879f, -0.05921445f, -0.02286683f, -0.26203236f, 0.08826651f, 0.03946785f, -0.07994344f, 
    0.18151307f, -0.04849070f, 0.10054749f, 0.01556825f, 0.01905677f, -0.10902951f, -0.01109062f, 0.02303477f, 
    -0.11182158f, 0.13014771f, 0.03909405f, -0.06235731f, -0.10691296f, 0.02291716f, 0.04483204f, 0.24098343f, 
    -0.00497198f, -0.02421962f, -0.04981862f, 0.05164017f, -0.30230591f, 0.10357247f, 0.19003762f, -0.06895351f, 
    0.05647128f, -0.09215697f, -0.06791976f, 0.01772770f, 0.09803161f, 0.04919621f, -0.13188522f, 0.11033145f, 
    -0.41648421f, 0.03706418f, 0.04761908f, -0.11841458f, 0.07413813f, 0.08472516f, -0.00390506f, 0.08609957f, 
    0.03619555f, -0.00901984f, 0.05254116f, -0.06275851f, -0.18892968f, -0.07426201f, -0.00012746f, 0.10291623f, 
    -0.07672876f, 0.02258337f, 0.01422596f, 0.09239083f, -0.02988598f, 0.14815018f, -0.02647489f, -0.00560571f, 
    -0.09812576f, 0.02289705f, 0.29695824f, 0.04908000f, -0.06778003f, 0.07384562f, 0.14046526f, -0.00208237f, 
    0.10147431f, -0.01360184f, 0.02888801f, 0.01276390f, 0.19138777f, -0.24252850f, -0.04401541f, -0.00048126f, 
    -0.16764109f, 0.18053950f, 0.14184232f, 0.02595448f, -0.10938133f, -0.02643245f, 0.16702466f, 0.00828519f, 
    -0.07837255f, -0.07772966f, 0.22284743f, 0.05864473f, -0.07017466f, 0.01950101f, 0.10201594f, -0.06189630f, 
    0.06771712f, 0.05014603f, 0.01471606f, -0.00164000f, -0.25346172f, -0.01980258f, 0.11264557f, 0.05008377f, 
    -0.00504535f, 0.11684690f, -0.03036443f, -0.00190160f, -0.06437463f, 0.05623457f, -0.05275148f, -0.05503990f, 
    0.07684916f, 0.06621008f, -0.20852938f, 0.18141912f, 0.05422419f, 0.03584569f, -0.01695893f, 0.05682396f, 
    0.09570418f, 0.01488087f, 0.12311344f, -0.14293405f, 0.02792015f, 0.08131790f, -0.00261498f, -0.16399303f, 
    -0.02781742f, -0.03741873f, -0.14948916f, 0.01884445f, 0.15567388f, -0.09135836f, -0.05993949f, -0.01416006f, 
    -0.09506397f, -0.06015428f, 0.00196323f, 0.20222837f, 0.18790944f, -0.06151095f, 0.11914980f, 0.08035596f, 
    0.02095847f, 0.05586263f, 0.04738614f, 0.21167456f, -0.34985626f, -0.06638844f, 0.22897415f, 0.11676070f, 
    0.03402573f, -0.02572490f, 0.07083796f, -0.01292548f, 0.01247482f, 0.21930695f, 0.04892280f, 0.10153554f, 
    0.42136079f, -0.25425920f, 0.03001321f, 0.12040713f, 0.09526706f, -0.02781429f, 0.06249908f, 0.00654089f, 
    0.00086368f, 0.07861022f, -0.01748260f, 0.03392784f, -0.01024469f, 0.09798227f, -0.08808027f, -0.31100917f, 
    0.08043227f, 0.02775205f, -0.07124668f, -0.08789866f, -0.01876203f, -0.01866679f, 0.03567208f, 0.09047560f, 
    -0.34256965f, 0.09049085f, -0.08152710f, 0.04031928f, -0.00777474f, -0.12697092f, 0.03138453f, 0.12734258f, 
    -0.07484934f, 0.03655823f, -0.04486266f, 0.01120168f, 0.07499475f, 0.32858017f, 0.11040675f, -0.05654235f, 
    0.01864352f, -0.14605767f, -0.05559717f, 0.09195215f, 0.07604276f, 0.08966837f, 0.02594769f, -0.00776435f, 
    -0.09156387f, 0.06378848f, -0.26409504f, 0.11276717f, 0.09602834f, 0.12396309f, 0.04183158f, 0.04951911f, 
    -0.14434960f, 0.08099488f, 0.02313510f, 0.12825367f, 0.36125809f, 0.12537254f, -0.25417054f, 0.00395875f, 
    -0.11213139f, 0.09700697f, 0.04709569f, 0.05502453f, -0.06874011f, 0.01429507f, 0.09431466f, -0.00415646f, 
    -0.19162220f, -0.06150973f, 0.00527318f, -0.15034850f, -0.08831779f, 0.07109390f, -0.04510671f, 0.02555597f, 
    0.16936961f, -0.03152510f, 0.05624970f, -0.13617919f, 0.00131873f, -0.08659854f, -0.08015180f, 0.02842539f, 
    -0.05338571f, 0.05638308f, -0.00140700f, -0.05728363f, -0.09110700f, 0.08391673f, -0.09996036f, -0.07827879f, 
    0.02705185f, -0.04703623f, 0.11148609f, -0.04512317f, -0.00020123f, -0.03145469f, 0.21435358f, 0.06989609f, 
    0.07410186f, 0.09809797f, 0.08397955f, 0.18525396f, -0.02627582f, -0.01762646f, 0.03645538f, -0.19156083f, 
    0.08068909f, 0.05511910f, 0.04032952f, 0.07665212f, -0.00044188f, 0.09614827f, 0.02569815f, 0.02310247f, 
    0.04267670f, 0.03387483f, -0.07665351f, -0.21817724f, 0.09254648f, 0.04554717f, -0.06204484f, 0.03034559f, 
    0.04198378f, -0.03019634f, 0.09328308f, 0.07231214f, 0.17300634f, -0.16395132f, -0.06062256f, -0.09602530f, 
    -0.10266364f, 0.04435417f, -0.01655504f, 0.01655148f, 0.04295906f, 0.02914821f, 0.02183687f, 0.04326015f, 
    0.02084075f, -0.13614891f, 0.11239090f, 0.08181324f, 0.00527976f, 0.08364640f, 0.07843918f, 0.02510636f, 
    0.02573585f, -0.09414554f, 0.00729063f, 0.06720673f, -0.02602249f, 0.16606072f, -0.12193058f, -0.02625750f, 
    0.10120185f, -0.02899688f, -0.07571466f, 0.07992966f, 0.07390655f, -0.02740685f, 0.05966590f, 0.03197876f, 
    -0.01687866f, -0.01077089f, -0.16388527f, 0.25949702f, -0.05101666f, -0.02509390f, -0.03420158f, 0.07470939f, 
    0.02480875f, 0.07639263f, 0.10729915f, 0.04831885f, 0.20492181f, 0.08917943f, 0.20639893f, -0.22182244f, 
    0.04820189f, 0.02073315f, 0.11645553f, -0.01661440f, 0.01094919f, 0.03710692f, -0.02238957f, 0.05591933f, 
    0.69367200f, 0.31103647f, 0.02543766f, 0.03959014f, -0.05829868f, 0.04383893f, 0.00830892f, 0.03613352f, 
    0.09159711f, -0.08356908f, 0.05878870f, -0.07366817f, -0.15569679f, 0.08127366f, -0.22834378f, 0.26800716f, 
    -0.01097658f, -0.03539382f, 0.06058444f, 0.00977286f, 0.09744977f, 0.08332486f, 0.08340295f, -0.02700642f, 
    -0.02627968f, 0.11764157f, 0.04152668f, 0.13391323f, 0.00513603f, -0.11220095f, -0.00860740f, 0.06510235f, 
    0.06853081f, 0.13248998f, -0.06723598f, 0.09478955f, 0.06361422f, -0.16174881f, -0.03429133f, 0.29166105f, 
    0.11021796f, 0.00217469f, -0.05797988f, -0.03389542f, 0.05810776f, 0.05942684f, 0.15856677f, -0.11986724f, 
    0.01786986f, 0.10676109f, -0.18667416f, 0.07088313f, 0.15935293f, 0.03963554f, -0.07937639f, -0.09332885f, 
    0.18932967f, 0.14267777f, 0.08338957f, 0.03218068f, -0.15857850f, 0.01985396f, -0.17447609f, 0.06295381f, 
    -0.14451680f, -0.00685562f, -0.06568427f, -0.09331122f, 0.08357941f, -0.04527770f, 0.05474610f, 0.05040140f, 
    -0.07612080f, -0.17202948f, -0.00130907f, 0.04569612f, -0.05568250f, 0.06580853f, 0.02370812f, 0.06896783f, 
    0.04588387f, -0.04409967f, -0.09456038f, -0.00873941f, 0.23790199f, -0.00130087f, 0.15001810f, 0.07619465f, 
    0.00763471f, -0.08227437f, -0.00903346f, -0.02558924f, 0.04036956f, 0.00321727f, -0.01626378f, 0.01313919f, 
    0.15630405f, 0.10290238f, -0.08090397f, -0.04588058f, 0.07880941f, -0.12067416f, 0.07573072f, -0.03398145f, 
    -0.04398320f, -0.02675546f, -0.02074414f, -0.04771255f, -0.26477757f, -0.10655054f, -0.07444929f, -0.04738500f, 
    0.03800897f, 0.10944740f, 0.03915001f, 0.08401009f, 0.03596380f, 0.12806465f, 0.05573864f, 0.09727219f, 
    0.37308982f, 0.04107999f, 0.03174976f, -0.13075197f, 0.02575480f, -0.04623057f, 0.06937162f, -0.06884340f, 
    -0.10205096f, -0.10305251f, -0.01809409f, -0.03920529f, -0.07995611f, -0.16755378f, -0.12266006f, 0.03129022f, 
    0.01647983f, -0.05387297f, 0.02371040f, 0.08141781f, 0.02130155f, 0.02144959f, 0.01191003f, 0.01953846f, 
    -0.00635389f, -0.04159128f, -0.08594034f, -0.07287192f, 0.02391544f, 0.06209318f, 0.00377529f, -0.15855537f, 
    0.04167183f, -0.03442617f, -0.04611128f, 0.10981732f, 0.23474558f, 0.06626429f, 0.00479380f, 0.03644428f, 
    -0.01619054f, 0.05566396f, 0.00315008f, 0.06257179f, -0.17296343f, 0.09450552f, 0.02231808f, 0.10371653f, 
    0.24727850f, 0.16125551f, 0.13226065f, 0.24177037f, 0.01175881f, 0.05428421f, -0.08410518f, -0.08910711f, 
    0.05195120f, 0.09942903f, -0.05657375f, -0.05792238f, 0.19549768f, 0.22255710f, 0.02778185f, -0.20986412f, 
    0.19016102f, 0.02225103f, -0.10412736f, 0.00928630f, 0.10138582f, -0.00029462f, 0.07642424f, -0.05128223f, 
    0.28944603f, 0.01282017f, 0.03090499f, 0.05017341f, 0.13685416f, -0.06022694f, 0.14811347f, -0.10381511f, 
    0.08708080f, -0.00674457f, 0.18866631f, 0.06779329f, -0.04906707f, 0.13624842f, -0.26493534f, 0.26281875f, 
    -0.03604534f, -0.02603432f, -0.01091248f, 0.00406434f, -0.00660927f, 0.10205718f, 0.10839207f, -0.13655949f, 
    0.00522199f, -0.15741105f, -0.12253983f, -0.05638060f, -0.14759052f, -0.06618275f, -0.19279937f, -0.08386467f, 
    0.01427087f, 0.03321636f, 0.11941821f, 0.02680034f, -0.11806957f, 0.19216688f, 0.12280425f, 0.14512195f, 
    0.04188777f, -0.08820117f, -0.02137313f, 0.04175979f, -0.14316061f, -0.04411341f, -0.01869049f, -0.05853917f, 
    0.09662285f, 0.00917403f, 0.01673235f, -0.05710734f, -0.09064592f, 0.03651550f, -0.06819563f, -0.02141715f, 
    0.04682027f, 0.02577799f, 0.00219515f, -0.04106357f, 0.07110766f, 0.07999117f, 0.11828085f, 0.12734352f, 
    -0.06815773f, 0.05898189f, 0.09404807f, -0.17396671f, 0.02624083f, 0.02592559f, -0.03578895f, -0.11618970f, 
    0.36281359f, -0.10271563f, 0.05691014f, -0.11755673f, -0.04653223f, 0.01441275f, -0.06960268f, -0.09687282f, 
    0.06802475f, 0.03275969f, 0.01711612f, 0.10117232f, 0.13808873f, 0.06321332f, -0.10374700f, 0.03292628f, 
    0.01725481f, -0.01371113f, 0.00404503f, 0.04961662f, 0.09364068f, 0.01511339f, 0.15525058f, 0.03078786f, 
    0.27316040f, -0.10660233f, -0.12576289f, -0.05204516f, -0.07235665f, -0.03554709f, -0.06756477f, 0.02267482f, 
    0.02092738f, 0.01164606f, -0.00114534f, -0.09061269f, -0.09850043f, 0.29368547f, -0.00432661f, -0.18123281f, 
    0.18014675f, -0.01844479f, -0.02289161f, 0.05025304f, 0.09244860f, 0.08255737f, -0.01180527f, 0.05183163f, 
    0.02053848f, 0.25268692f, -0.13205445f, -0.07802118f, 0.08515575f, -0.02229569f, -0.02254209f, 0.05484382f, 
    0.05564549f, -0.05156815f, -0.05938279f, 0.09089813f, 0.41370502f, 0.13741314f, -0.06605148f, 0.06672058f, 
    0.02241693f, 0.02517509f, 0.05065175f, -0.02529663f, 0.13830782f, -0.00716966f, 0.15510798f, 0.00118427f, 
    -0.01208181f, -0.15845905f, 0.26918489f, -0.09743504f, -0.01070091f, -0.03213996f, -0.08592356f, 0.04389505f, 
    0.00132156f, 0.00900963f, -0.16266836f, 0.06533799f, 0.02753029f, 0.13546816f, 0.21201105f, 0.26856491f, 
    0.08055639f, 0.00309317f, 0.06668276f, 0.03335950f, -0.00575502f, 0.08261947f, -0.04009729f, -0.00134421f, 
    0.21545126f, -0.01828116f, 0.09019970f, -0.07693218f, -0.08628692f, 0.02691087f, -0.02190425f, 0.09940548f, 
    0.03731572f, 0.00408754f, 0.00403607f, -0.06151297f, 0.20629425f, -0.05246658f, -0.19512972f, 0.02773636f, 
    -0.06636757f, -0.06398273f, 0.00844858f, 0.01393338f, -0.04482192f, 0.00259948f, 0.04280883f, 0.02237546f, 
    -0.18224594f, 0.05364334f, -0.03385366f, 0.06969986f, -0.04910280f, 0.06525616f, -0.04317488f, 0.04438027f, 
    -0.08782456f, 0.03953091f, -0.03782887f, -0.01903969f, -0.10956500f, -0.16458982f, 0.13887282f, -0.00566712f, 
    -0.06645617f, 0.07434659f, -0.00943733f, 0.00605667f, 0.16153449f, 0.04400856f, 0.02364513f, 0.00275727f, 
    0.41810322f, 0.07448038f, 0.14624700f, 0.02434882f, -0.06464265f, 0.09437296f, -0.01565667f, 0.03003430f, 
    0.02850201f, -0.06156598f, 0.00650260f, 0.07608458f, 0.07946774f, -0.20290537f, 0.05824820f, 0.20046757f, 
    -0.06325322f, 0.06833228f, -0.05333593f, -0.00057980f, -0.03309487f, 0.00358289f, -0.04940053f, -0.01509616f, 
    0.19427067f, -0.08436536f, 0.20956597f, 0.01709842f, -0.01540231f, 0.01916994f, 0.03699569f, -0.01517129f, 
    0.09846627f, -0.10771278f, 0.04632622f, -0.04157759f, -0.06652543f, -0.09040801f, 0.14615931f, 0.09873893f, 
    0.10767752f, -0.00942470f, -0.05481656f, -0.11577540f, -0.04655156f, 0.03293993f, 0.05065900f, 0.00340093f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07205169f, 0.05922272f, 0.02868662f, 0.10658671f, -0.00169241f, -0.04042808f, -0.00994455f, 0.03423703f, 
    0.08114090f, 0.03027701f, -0.02878249f, 0.02872521f, -0.00249536f, -0.05645195f, 0.05824000f, 0.04526548f, 
    0.15900309f, -0.01334961f, 0.05700516f, -0.00141020f, 0.03222220f, 0.01123929f, 0.12657878f, -0.01661158f, 
    -0.02184264f, 0.07510538f, 0.01211335f, 0.11455415f, 0.04983925f, 0.23129740f, 0.08383849f, 0.10429400f, 
    -0.04154059f, 0.06150701f, 0.04803407f, -0.01404014f, 0.05685589f, -0.05416190f, 0.01849367f, -0.10462715f, 
    0.09847794f, 0.11722659f, 0.07405281f, 0.15828481f, 0.02079674f, 0.12930489f, -0.08308891f, 0.11119581f, 
    -0.04239393f, 0.00043336f, -0.00067921f, -0.01713924f, 0.07231753f, 0.05611147f, -0.00203502f, 0.08991031f, 
    0.04443165f, -0.05758182f, -0.06721639f, 0.16951326f, -0.01831903f, -0.02306242f, -0.00833816f, 0.08667701f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.14386739f, -0.08586077f, 0.36023137f, 0.19086178f, -0.00672274f, -0.05034762f, 0.06719669f, 0.02906488f, 
    -0.18082634f, 0.19454989f, -0.09996985f, 0.10224419f, -0.05353277f, -0.05646863f, 0.06111537f, 0.02366076f, 
    -0.02865072f, 0.00990586f, 0.08328768f, -0.03867994f, 0.04042332f, -0.07944658f, -0.39221832f, 0.41409314f, 
    -0.05455826f, -0.02115876f, 0.25785637f, -0.04294441f, 0.15183671f, 0.08771408f, -0.32400438f, 0.14783834f, 
    0.07170090f, 0.26357877f, 0.09071227f, 0.05545725f, -0.03658578f, -0.03830628f, -0.10647418f, 0.29768369f, 
    0.45124602f, -0.23793782f, -0.09657791f, -0.17291175f, -0.24657695f, -0.00348781f, 0.09108557f, 0.17053255f, 
    0.10672557f, 0.12421144f, -0.04657166f, 0.05941717f, 0.29154053f, 0.10319362f, 0.01406934f, 0.31867471f, 
    0.03086609f, 0.01835496f, 0.11643996f, -0.13286947f, 0.21260466f, -0.21386608f, -0.07477926f, 0.16594300f, 
    -0.01365182f, -0.03672519f, -0.05043738f, -0.00167689f, -0.10959341f, -0.05944739f, 0.09628175f, -0.01538778f, 
    -0.06516533f, 0.03427882f, -0.03663981f, 0.06250481f, -0.00404770f, -0.08851355f, -0.04670904f, -0.01980606f, 
    0.04328677f, -0.05324089f, -0.06353762f, -0.08921343f, -0.03133476f, -0.08566935f, 0.03568060f, -0.11676373f, 
    0.02734421f, 0.10096267f, -0.01318535f, -0.08032346f, -0.11176494f, -0.05329901f, -0.10616439f, -0.02311475f, 
    0.02580063f, -0.05554939f, 0.06278241f, -0.02376529f, 0.07902431f, -0.09991854f, -0.08223629f, -0.00456817f, 
    0.03591593f, -0.12031145f, -0.03594278f, -0.07524984f, 0.08340188f, 0.10789706f, 0.07678015f, -0.01814599f, 
    0.02457464f, -0.01384050f, 0.08154309f, 0.00319309f, -0.03692811f, 0.04014186f, 0.03715889f, 0.00830049f, 
    0.10870067f, 0.01506249f, 0.01409204f, -0.09211841f, -0.08668564f, 0.07899977f, 0.01960514f, -0.11477743f, 
    -0.07374555f, -0.02237015f, -0.04876332f, -0.00770503f, -0.12869900f, 0.11298996f, 0.01923609f, -0.11411744f, 
    0.00549474f, 0.29087079f, 0.03735253f, 0.07611541f, -0.13953750f, 0.07348014f, -0.04432561f, 0.01162336f, 
    -0.09093099f, -0.05648908f, 0.27159443f, -0.08302870f, 0.16126344f, 0.05100315f, 0.12188186f, -0.12120631f, 
    0.13614802f, -0.18413785f, 0.20465451f, 0.15358838f, 0.01618766f, 0.09170031f, -0.11586587f, -0.23655376f, 
    0.10550139f, -0.01833201f, -0.11550442f, 0.22376840f, 0.13987492f, 0.29681498f, -0.07025682f, 0.02393652f, 
    -0.12038563f, 0.31463575f, 0.14768139f, -0.16476187f, 0.48726827f, -0.16121665f, 0.39337867f, 0.05109187f, 
    -0.00565766f, -0.16390169f, 0.10738829f, 0.05089913f, -0.24815239f, 0.38091397f, 0.05292845f, 0.00138961f, 
    0.10760427f, -0.10637227f, 0.03296462f, -0.14844719f, 0.31997165f, 0.17114860f, 0.02349020f, -0.15772700f, 
    0.04691129f, 0.10984413f, -0.00708087f, -0.05411766f, -0.08505172f, 0.03157150f, -0.11452043f, -0.06873241f, 
    -0.05467461f, 0.06873456f, -0.10830972f, -0.04396651f, -0.00563078f, 0.02497452f, -0.01003751f, -0.05488676f, 
    0.08404780f, 0.04097934f, -0.01896091f, -0.04660333f, -0.07983880f, -0.03260192f, 0.11733990f, 0.09688529f, 
    -0.11076982f, -0.10506232f, -0.09318092f, -0.06440353f, 0.02576786f, 0.08305711f, 0.04277856f, 0.00270326f, 
    -0.12430814f, -0.05510110f, 0.06708868f, 0.04479660f, -0.03563384f, 0.05689496f, -0.12373129f, 0.04702754f, 
    -0.10766964f, -0.11178890f, -0.03707147f, -0.02603533f, -0.07819093f, -0.06553646f, -0.07482210f, 0.01102130f, 
    0.06735507f, 0.05902636f, -0.03237613f, -0.01063701f, -0.03001397f, -0.05795109f, -0.03062533f, -0.09173302f, 
    0.07210479f, -0.08598410f, -0.05839778f, -0.02213861f, 0.11651309f, 0.04506114f, -0.00813372f, -0.09973337f, 
    0.13959807f, 0.21220653f, 0.17140047f, 0.44944724f, -0.25411499f, -0.00184943f, -0.12064812f, -0.16063005f, 
    0.15120374f, 0.13056283f, 0.01582671f, -0.05541112f, -0.06981858f, 0.01469045f, 0.20216031f, 0.10212702f, 
    -0.09327501f, 0.04889346f, 0.04644048f, 0.11788368f, 0.13144089f, -0.11661954f, -0.36670873f, 0.11253745f, 
    -0.09425692f, -0.06033731f, -0.04353898f, 0.21305507f, -0.12867852f, -0.11713792f, 0.11147521f, -0.18222824f, 
    -0.05633126f, 0.05872735f, 0.01467319f, 0.13411240f, -0.23723058f, 0.14944527f, -0.11564381f, 0.23745400f, 
    0.28780034f, 0.03166935f, -0.17651494f, 0.28616017f, 0.01417488f, -0.01028034f, 0.32763809f, -0.17005289f, 
    0.05234395f, -0.15829888f, -0.05970868f, 0.07770301f, 0.19824463f, 0.08303454f, -0.08952199f, 0.12623261f, 
    0.14694093f, 0.11455639f, 0.13946283f, 0.07576962f, 0.12232710f, 0.00153147f, 0.23655204f, -0.20222971f, 
    0.00558341f, -0.04893719f, 0.01846606f, -0.03231784f, -0.08382851f, -0.12020350f, -0.11978026f, -0.00421494f, 
    0.00988131f, 0.00012880f, -0.07712170f, -0.06235958f, -0.06993978f, 0.01562534f, 0.09915628f, -0.00109373f, 
    0.09292601f, -0.04988787f, -0.03083171f, 0.07371605f, -0.11872528f, -0.10327803f, 0.11717170f, 0.08233859f, 
    -0.10131464f, 0.06178829f, 0.05095142f, -0.14170307f, -0.06378219f, -0.09920969f, 0.05011141f, -0.01579199f, 
    0.08163232f, 0.03501213f, -0.07590441f, 0.07494949f, 0.11927909f, -0.04025856f, -0.08841893f, -0.02311996f, 
    -0.11513647f, -0.01271076f, -0.05192436f, -0.11701054f, -0.02583013f, 0.02801796f, 0.00966641f, 0.08155295f, 
    -0.05892174f, -0.09848973f, -0.08557037f, -0.12088636f, -0.09756842f, -0.07646790f, 0.07904551f, 0.06045449f, 
    -0.03127396f, -0.06931914f, -0.09864502f, 0.00835839f, -0.10505752f, -0.10579317f, -0.05091065f, -0.10347325f, 
    -0.11680809f, -0.08947703f, -0.14576761f, 0.02436213f, -0.10248943f, 0.11711115f, 0.00430360f, -0.04490011f, 
    0.04424812f, 0.05879311f, 0.02667601f, -0.06006236f, -0.12389199f, -0.10141952f, -0.10001237f, -0.01380163f, 
    0.04760644f, 0.11795016f, -0.07564779f, -0.02612926f, -0.07583162f, 0.04490624f, -0.04643287f, 0.10747198f, 
    0.06045077f, 0.07021886f, -0.05279054f, -0.04853463f, -0.08994754f, 0.08050179f, -0.09011811f, -0.06735165f, 
    -0.08276801f, -0.10975405f, -0.11498035f, -0.07758810f, 0.06576318f, 0.05813650f, 0.09117112f, 0.12011899f, 
    -0.05352308f, 0.01777621f, -0.08226018f, -0.16129850f, 0.10757538f, -0.02907153f, 0.06243650f, 0.10902631f, 
    -0.03550789f, -0.08540185f, 0.04416458f, -0.10501759f, 0.05867363f, -0.01266181f, 0.06785080f, 0.11020576f, 
    -0.08874740f, -0.02799500f, -0.02603066f, -0.02118929f, -0.03760054f, -0.04054699f, -0.05342697f, -0.11307343f, 
    0.16757622f, -0.25159281f, 0.13180557f, 0.18830183f, 0.22001182f, -0.06666157f, -0.12186410f, 0.09755810f, 
    -0.02600392f, 0.03453110f, 0.03578742f, -0.06638601f, -0.16496702f, -0.02405922f, -0.11097756f, 0.01996912f, 
    -0.09828441f, -0.03893082f, -0.00976638f, -0.06564642f, -0.03922505f, -0.11866000f, -0.30582160f, 0.12982921f, 
    0.17000830f, -0.15664327f, 0.20683321f, -0.04107049f, -0.11954939f, 0.07334898f, -0.23834193f, 0.16537298f, 
    -0.02846347f, -0.04642132f, -0.08640315f, -0.00499222f, -0.13049348f, -0.13104624f, -0.06777790f, 0.44013116f, 
    0.09933085f, 0.05423668f, 0.14651521f, -0.07936221f, -0.21342540f, -0.04136434f, -0.02991383f, 0.18380310f, 
    -0.00796942f, -0.11387830f, -0.01223473f, 0.06433721f, 0.16268791f, -0.00050360f, 0.04068535f, 0.29868886f, 
    0.16628672f, 0.16244905f, 0.19369590f, -0.03805235f, 0.40369186f, 0.01103919f, 0.15162292f, 0.10096857f, 
    -0.03891402f, 0.24061367f, 0.40988114f, 0.04939011f, -0.20657599f, 0.04994565f, -0.12813528f, 0.07648883f, 
    0.24766487f, 0.08443382f, 0.06699467f, -0.09584304f, 0.11099873f, 0.01246587f, 0.32759044f, -0.07326291f, 
    -0.05801775f, -0.07030272f, 0.00279905f, -0.00526053f, 0.06087186f, 0.11205187f, -0.00016217f, 0.19725931f, 
    -0.00206381f, -0.16432555f, -0.12129017f, -0.16209328f, 0.12472897f, 0.09014571f, 0.21593556f, 0.08448340f, 
    -0.03370608f, 0.06125040f, -0.06114756f, -0.02110352f, -0.01301048f, -0.03066056f, 0.19087438f, -0.22202949f, 
    0.25245291f, -0.14186311f, -0.08000502f, -0.07430612f, 0.43168110f, 0.24142244f, 0.13750605f, -0.17047577f, 
    0.09874667f, 0.01768602f, -0.02058936f, -0.04717850f, 0.02868616f, 0.22227420f, 0.05499307f, 0.08679134f, 
    -0.01491295f, -0.28270638f, 0.07456145f, 0.08946171f, -0.36932901f, 0.12564275f, 0.05259052f, 0.07198664f, 
    -0.09909814f, -0.02071783f, -0.11360987f, 0.01322326f, 0.05324323f, 0.02099724f, -0.08270124f, -0.10048002f, 
    0.03808025f, -0.07946049f, 0.12363435f, -0.02254405f, 0.02523296f, 0.00967094f, 0.09526992f, 0.09768888f, 
    -0.19764197f, 0.02362195f, 0.13765025f, -0.04543941f, 0.08923574f, -0.10547341f, -0.10358126f, 0.06215639f, 
    0.03588472f, 0.00086981f, -0.05755134f, 0.23853771f, -0.02461280f, -0.00779061f, -0.10129976f, -0.20993721f, 
    -0.11080149f, -0.07945427f, 0.00544932f, 0.26985237f, -0.08383726f, 0.21657339f, 0.01583043f, 0.30705014f, 
    0.07205661f, 0.14630358f, -0.14168778f, 0.19308765f, -0.04587265f, -0.17180185f, 0.38860282f, -0.01094282f, 
    0.06016758f, -0.10512625f, 0.04987104f, -0.03689644f, 0.13579662f, 0.14999528f, 0.05283073f, -0.17370364f, 
    0.22242823f, 0.43827465f, 0.10275171f, 0.13196175f, 0.28092265f, 0.02594307f, 0.21422225f, -0.20074925f, 
    -0.14141960f, 0.28993741f, -0.03671203f, 0.34702599f, -0.11312373f, -0.10984185f, -0.11028921f, -0.05679658f, 
    -0.06074058f, 0.17597134f, 0.07255612f, 0.09312891f, -0.02803037f, -0.06179639f, 0.08440742f, -0.05998954f, 
    0.23532541f, 0.00076897f, 0.28397170f, 0.05587272f, 0.30810338f, 0.06748382f, 0.09231251f, -0.03439497f, 
    0.00438251f, -0.10007217f, 0.07917549f, 0.35373420f, 0.08689848f, 0.36822900f, -0.05750965f, 0.17392559f, 
    0.09628513f, 0.03146119f, 0.00582442f, 0.47054431f, -0.09669895f, 0.23006999f, -0.05716189f, -0.08302991f, 
    0.30678901f, -0.01951375f, -0.10394387f, 0.25325754f, 0.19923818f, -0.04487221f, 0.10605390f, -0.04474290f, 
    0.01111045f, -0.23590171f, -0.05179379f, -0.19036885f, 0.18621157f, -0.01741431f, 0.13173474f, 0.09904227f, 
    -0.01610201f, -0.02169043f, -0.08569672f, 0.31130150f, 0.03918027f, -0.06910972f, 0.02419177f, -0.26214477f, 
    -0.01713563f, -0.01701510f, 0.22177847f, 0.19083467f, -0.03095832f, 0.05938071f, -0.10972734f, 0.15127495f, 
    -0.39851022f, 0.04531023f, 0.05779177f, 0.08774992f, -0.07914752f, 0.03114837f, -0.24181622f, -0.03323855f, 
    -0.06668098f, 0.05907084f, 0.29307908f, -0.02199901f, 0.09980685f, 0.07469352f, 0.09193072f, 0.12460405f, 
    0.01371977f, -0.18408471f, 0.16964029f, -0.20180805f, 0.13166365f, -0.14255406f, -0.28124738f, -0.29156166f, 
    0.03161355f, 0.42790103f, 0.09861772f, 0.04898322f, 0.04809205f, 0.18775173f, 0.11417910f, -0.12478257f, 
    0.14154765f, -0.35082781f, 0.06733958f, -0.27956077f, 0.31047764f, 0.08351580f, -0.17364089f, 0.16269766f, 
    0.03509225f, 0.12583011f, -0.02543438f, -0.01134264f, 0.10178090f, 0.16201124f, 0.05800318f, 0.15149400f, 
    0.11040030f, -0.10550611f, 0.12050027f, -0.02238164f, 0.09572964f, 0.06014315f, 0.13135077f, -0.04374959f, 
    -0.12931068f, 0.03162887f, 0.08805646f, 0.13922840f, 0.11431666f, 0.10196103f, 0.09415136f, 0.18122329f, 
    0.01607799f, 0.19770557f, 0.10677849f, 0.09997331f, 0.37171361f, -0.03143237f, -0.00445074f, -0.05611899f, 
    0.14532344f, 0.10103412f, 0.02218633f, -0.11789510f, 0.16528566f, 0.09712631f, -0.20361502f, 0.18738124f, 
    -0.01579748f, -0.03344692f, -0.21233994f, 0.01217334f, -0.10118287f, -0.03251571f, 0.09266962f, 0.44924849f, 
    0.08600602f, -0.07633561f, -0.00850079f, 0.00113058f, -0.27105659f, 0.12291324f, 0.12854412f, -0.06890912f, 
    0.22853182f, 0.07835534f, 0.08914123f, 0.10255807f, -0.12550092f, 0.18598831f, 0.05571365f, 0.04986706f, 
    0.03072038f, 0.03247282f, -0.03399088f, -0.08205911f, -0.25523064f, -0.38363665f, 0.08366931f, -0.22462660f, 
    0.18779841f, 0.00011414f, -0.04047411f, 0.28830257f, -0.32264096f, -0.01562238f, 0.12369367f, 0.23561518f, 
    0.09372794f, -0.02617803f, -0.09801871f, 0.01632272f, -0.19151253f, 0.02074788f, -0.07148203f, 0.00364556f, 
    -0.05519404f, 0.02005201f, -0.11852883f, -0.09715693f, -0.17890546f, -0.10700250f, -0.12125292f, -0.06026272f, 
    0.15603314f, 0.05094859f, -0.00960931f, 0.08999523f, -0.07374335f, -0.02118432f, 0.13390990f, -0.25226021f, 
    0.21365556f, -0.00674756f, -0.03130674f, 0.00599320f, -0.18816838f, 0.21629752f, 0.18801844f, 0.03693432f, 
    -0.00286996f, 0.00076940f, 0.08540287f, 0.23716018f, 0.17637724f, 0.01709912f, 0.16846983f, -0.06460783f, 
    -0.19442013f, 0.40002081f, 0.00050535f, 0.32165790f, 0.01452967f, -0.10756402f, 0.15959382f, 0.06272911f, 
    0.05542450f, 0.25355035f, 0.07105911f, 0.18544473f, 0.10398096f, 0.03949255f, -0.03382520f, 0.07393272f, 
    0.12932502f, -0.05272634f, 0.13175614f, 0.24883233f, 0.32145044f, 0.11592952f, 0.10361084f, -0.21889247f, 
    0.13639319f, -0.12205967f, 0.20328300f, 0.17448503f, 0.06758029f, 0.09548291f, 0.07902545f, 0.09061141f, 
    0.10157765f, 0.06919256f, 0.00666249f, -0.07575838f, 0.21981865f, -0.01854063f, -0.09537318f, -0.08466333f, 
    0.15026174f, 0.03029238f, -0.09640957f, -0.00795536f, 0.13285799f, 0.09657723f, -0.13029559f, -0.01396090f, 
    -0.10220569f, 0.12323487f, -0.15333755f, 0.29853684f, 0.08664801f, -0.12833725f, 0.33938199f, 0.04372434f, 
    -0.11663035f, -0.08322322f, 0.05976841f, 0.13900442f, -0.13769494f, 0.14747685f, -0.04451752f, 0.16775526f, 
    -0.02879938f, 0.21920519f, 0.18669668f, 0.28796700f, 0.34690702f, 0.05786940f, 0.16596597f, 0.08748493f, 
    0.10854085f, 0.03327147f, 0.03857118f, -0.01360368f, -0.07202154f, -0.44539604f, 0.06612296f, -0.15409145f, 
    0.15541752f, 0.14880300f, -0.18626398f, 0.43184093f, -0.27498922f, -0.01716237f, 0.25919923f, 0.06422901f, 
    0.22282049f, -0.21082759f, -0.00533356f, 0.01485659f, -0.17150262f, -0.03320038f, 0.11560371f, 0.07706732f, 
    -0.24676466f, 0.30387264f, 0.00760454f, -0.11462340f, -0.23125851f, 0.06946578f, -0.02300495f, -0.07568432f, 
    0.26216197f, -0.11203104f, 0.00321038f, 0.11483099f, -0.02211785f, 0.08696781f, -0.29036012f, -0.24067053f, 
    0.15519556f, -0.08457837f, 0.03140172f, -0.40258139f, -0.25633138f, -0.31398031f, 0.04860476f, -0.10839183f, 
    0.06351548f, 0.22040255f, -0.07236372f, 0.21449791f, -0.26261210f, 0.06598453f, 0.05871854f, -0.13630800f, 
    -0.02951727f, 0.24349670f, 0.08475927f, 0.22664577f, 0.12325058f, 0.10146025f, 0.32887909f, 0.15101370f, 
    0.01558739f, 0.25996256f, -0.01018036f, 0.07480430f, -0.14047717f, -0.02772548f, 0.05119791f, 0.14114226f, 
    0.09818871f, -0.28714281f, 0.20056322f, 0.28186801f, -0.10409012f, 0.07370432f, 0.21429570f, -0.03054680f, 
    -0.06639253f, -0.08917950f, 0.04271546f, -0.11163479f, 0.01650210f, -0.04717834f, 0.11460426f, -0.12190144f, 
    -0.11258149f, -0.08638707f, 0.01688774f, 0.11051916f, -0.09299599f, -0.03719015f, 0.09388356f, 0.03960128f, 
    0.09311162f, 0.06307620f, -0.09918337f, -0.06271455f, -0.02140000f, 0.07291512f, -0.07589775f, 0.08436108f, 
    0.07729900f, 0.11589007f, -0.02524129f, -0.09301190f, -0.09230806f, -0.08135675f, 0.09643672f, 0.07127865f, 
    0.11418346f, -0.00065322f, -0.07172345f, -0.09436254f, -0.05665649f, 0.11195441f, 0.07586722f, 0.06628832f, 
    0.01936203f, 0.04210487f, -0.06486017f, -0.05047353f, -0.08376847f, -0.08740102f, -0.09823847f, -0.04727441f, 
    -0.03923929f, -0.09111196f, 0.02528594f, -0.08787926f, 0.02857177f, -0.01674792f, -0.04553443f, 0.11458419f, 
    0.01132350f, -0.03790797f, -0.05785823f, -0.02060728f, -0.07037748f, -0.10802320f, -0.07358439f, -0.02566704f, 
    0.08400419f, 0.10156836f, -0.12507501f, 0.16693649f, 0.04206633f, 0.09723887f, 0.06698621f, 0.03978173f, 
    -0.00176937f, -0.02758065f, -0.04615805f, 0.02791017f, 0.22985254f, 0.00019411f, 0.16065134f, 0.02382063f, 
    0.05457919f, -0.00790662f, -0.10771951f, 0.13894311f, 0.10245278f, -0.08000811f, -0.14570233f, -0.01857993f, 
    0.02146896f, 0.25782692f, 0.15432262f, -0.12168943f, 0.06772516f, 0.20863874f, 0.24050759f, -0.12779926f, 
    -0.06988609f, 0.19102380f, -0.08538418f, -0.03399428f, -0.10033844f, -0.22028224f, 0.10041717f, -0.00704357f, 
    0.29981211f, -0.01666077f, 0.08830535f, 0.37189209f, -0.17943323f, 0.11968883f, -0.18548764f, 0.08959213f, 
    -0.02941045f, 0.03667054f, -0.11673685f, -0.00861051f, 0.13290623f, -0.15928301f, -0.11753001f, 0.34905863f, 
    -0.05486958f, -0.15777640f, -0.07897124f, 0.14705326f, -0.20276561f, -0.12623295f, -0.08319093f, 0.28048190f, 
    -0.04275655f, 0.03300748f, -0.03856515f, 0.01547264f, 0.09953853f, -0.05179112f, 0.08071047f, -0.13176100f, 
    0.07893776f, 0.05226004f, 0.02115932f, 0.03344788f, 0.07549658f, -0.08785449f, -0.14894046f, 0.00847016f, 
    -0.10919235f, -0.00765171f, 0.09700763f, 0.08761662f, 0.06380575f, 0.07271080f, -0.09314822f, 0.01891622f, 
    -0.07310042f, -0.06686988f, -0.08880196f, 0.04053418f, 0.06423930f, 0.00380497f, -0.13568841f, 0.07280409f, 
    -0.06774411f, 0.08053499f, 0.03699534f, -0.09063154f, -0.12381840f, -0.04200269f, -0.07819937f, -0.12988314f, 
    -0.01511718f, 0.04311942f, -0.10544381f, -0.05964609f, 0.00067870f, 0.09909397f, 0.00616012f, -0.09619436f, 
    0.07119682f, -0.21717131f, 0.11201767f, -0.05451867f, 0.04528372f, 0.09846048f, 0.05588793f, 0.00141861f, 
    -0.08476186f, 0.02231043f, -0.04306827f, 0.09032842f, -0.12367477f, -0.12963851f, 0.02178160f, 0.07424711f, 
    -0.16272914f, -0.09216561f, -0.00264662f, 0.17678919f, -0.19582877f, 0.06287347f, -0.13059236f, -0.07761917f, 
    0.26457334f, 0.13493229f, -0.09832483f, -0.04597923f, 0.37128296f, -0.02018257f, 0.24668893f, -0.10949679f, 
    0.07010530f, 0.07397145f, 0.08765949f, -0.11011386f, 0.26932669f, 0.05215288f, 0.01321665f, 0.18701495f, 
    -0.14658612f, 0.10990456f, 0.17045841f, 0.03449338f, 0.11638842f, -0.09953607f, -0.00549417f, -0.13909160f, 
    -0.12405641f, 0.02972000f, -0.01532719f, -0.02189319f, -0.27561092f, -0.08267087f, -0.04694339f, -0.24144731f, 
    0.38954365f, 0.39317915f, 0.04869414f, -0.15787445f, -0.05033769f, 0.10570063f, 0.07483635f, 0.00228563f, 
    0.00057092f, -0.07005755f, 0.07381254f, -0.11880336f, -0.24322574f, -0.10430307f, -0.06622632f, -0.18945068f, 
    0.20218129f, 0.09768809f, 0.01721854f, 0.06915862f, -0.27838245f, -0.20899163f, 0.14674558f, 0.23607329f, 
    0.11773098f, -0.27279302f, -0.01273165f, -0.35099086f, 0.38802230f, 0.03625035f, -0.08046546f, 0.05920618f, 
    0.32787684f, 0.04971115f, -0.10441504f, -0.02994105f, 0.15448041f, -0.02468447f, 0.13328306f, 0.09271459f, 
    -0.06624667f, 0.10266254f, -0.29636019f, 0.05138350f, -0.01202046f, -0.12175630f, -0.07920773f, -0.08754089f, 
    -0.03195068f, -0.12756066f, -0.13937290f, 0.15745571f, -0.15657549f, 0.22067448f, 0.03601722f, 0.37210143f, 
    0.02039596f, -0.51641536f, -0.04703820f, -0.37820649f, -0.00124193f, -0.25721580f, -0.10009331f, 0.19017646f, 
    -0.04004323f, 0.15266952f, 0.08979960f, 0.08147161f, -0.05028848f, 0.17610998f, 0.14315376f, 0.22547694f, 
    -0.04915188f, -0.17124899f, -0.05938181f, 0.11339621f, -0.12324458f, -0.42139021f, -0.07782673f, -0.18615113f, 
    0.13044402f, 0.19760612f, 0.20731553f, 0.18023394f, 0.10282762f, 0.03358252f, 0.15607497f, 0.09538864f, 
    -0.07040786f, -0.20278411f, -0.27748796f, 0.05181529f, 0.12951589f, -0.07601284f, 0.06625462f, 0.04350692f, 
    0.22455189f, 0.09184830f, 0.08366565f, 0.00878109f, 0.19813229f, -0.06717276f, 0.03288631f, -0.12443379f, 
    0.29219499f, -0.00558625f, -0.07391420f, 0.01486716f, 0.13374321f, 0.08560362f, 0.14068677f, -0.23077704f, 
    -0.12172505f, 0.04959297f, 0.17007487f, -0.00802347f, 0.16091710f, 0.42493108f, 0.21651888f, 0.42316714f, 
    0.08154567f, -0.09372232f, 0.02375662f, -0.15406708f, 0.11365624f, -0.18544796f, 0.11904396f, 0.04526705f, 
    0.16763423f, 0.18107362f, 0.17123200f, 0.08638363f, -0.30465958f, 0.12589972f, -0.16930555f, 0.05949222f, 
    0.03164035f, -0.06212877f, 0.10872348f, -0.10429923f, -0.06180983f, -0.28984675f, -0.06204598f, 0.17431493f, 
    0.04289053f, -0.22571510f, 0.03695574f, 0.23561621f, -0.08106068f, -0.04885852f, -0.28561658f, 0.16071677f, 
    0.12523647f, 0.01771878f, -0.18855420f, -0.09849272f, 0.07963874f, -0.06160240f, -0.09898832f, 0.08404440f, 
    0.01254548f, 0.03164879f, 0.01625111f, -0.05159805f, 0.13987067f, 0.09907632f, -0.06678289f, -0.00739557f, 
    -0.12571445f, 0.06943058f, -0.12975127f, -0.06402896f, -0.11881129f, 0.01492776f, 0.28057703f, -0.09371398f, 
    0.02515930f, 0.21782716f, 0.17924665f, 0.00352239f, 0.00444608f, 0.07947227f, 0.03560664f, -0.29415491f, 
    -0.04115469f, 0.10011308f, -0.10492691f, -0.32372627f, 0.25768107f, -0.21098526f, 0.11427481f, -0.10077664f, 
    0.02387129f, -0.13062622f, 0.05936635f, 0.20860358f, -0.10518258f, 0.21609502f, -0.34564891f, 0.15290006f, 
    -0.01981758f, 0.23485370f, 0.10483225f, 0.08410389f, 0.27132398f, 0.10556808f, 0.09331176f, 0.26803789f, 
    -0.09974825f, 0.04864153f, 0.10977524f, -0.06919447f, -0.11102299f, -0.09965922f, -0.14936942f, 0.07365550f, 
    -0.13585936f, 0.10652972f, 0.22235562f, -0.12136740f, 0.03065673f, 0.00707813f, -0.08252713f, 0.01494642f, 
    0.21950392f, -0.08513493f, -0.03117664f, -0.07097957f, 0.27283669f, 0.03222083f, 0.23792863f, -0.06108168f, 
    -0.01038913f, -0.09485017f, 0.22757857f, -0.02358835f, 0.17933667f, 0.05773912f, 0.16919780f, 0.19747782f, 
    -0.11060727f, -0.12176005f, 0.12033418f, 0.03569900f, -0.06631171f, 0.03487597f, 0.03082224f, 0.14130324f, 
    -0.02066247f, -0.02850224f, -0.04546720f, 0.03034048f, 0.14137565f, -0.00048628f, -0.09476842f, -0.27441493f, 
    0.30068794f, -0.06669570f, -0.21255110f, -0.06429860f, 0.14791572f, -0.09209277f, -0.10464226f, 0.06877113f, 
    0.12492599f, -0.00517270f, -0.01489113f, -0.00418166f, 0.12504663f, 0.09140661f, -0.02410948f, 0.14041112f, 
    -0.05518958f, 0.36497548f, -0.00193874f, -0.10788977f, -0.13215974f, -0.15148243f, -0.11105984f, 0.04045348f, 
    0.23427266f, -0.09205664f, 0.17326620f, -0.03245528f, -0.01399053f, 0.10967566f, -0.07101214f, 0.22388314f, 
    -0.09576443f, 0.11513805f, 0.09717716f, -0.10175802f, -0.41772231f, 0.01989891f, -0.11265608f, -0.08467987f, 
    0.07763925f, -0.08377941f, 0.14287253f, 0.01972481f, -0.06812741f, -0.07561271f, -0.18821874f, -0.07797814f, 
    0.30027238f, -0.39038837f, 0.16153635f, -0.21122862f, -0.16696183f, -0.18595016f, -0.20095547f, -0.01823720f, 
    0.01196596f, 0.16641018f, -0.01511917f, 0.16869222f, -0.03692874f, -0.00607163f, 0.13420759f, 0.36125061f, 
    -0.01614300f, 0.28805903f, 0.09823568f, -0.02301988f, 0.09259101f, -0.03222555f, 0.43354285f, 0.06675270f, 
    -0.03293334f, 0.17833257f, -0.00684940f, 0.05518426f, -0.01340689f, 0.06482687f, 0.02393916f, 0.40854591f, 
    0.08383573f, -0.11604310f, 0.36655077f, 0.14626187f, 0.50476044f, 0.10551918f, 0.40439647f, -0.17619215f, 
    -0.02463338f, 0.19895056f, 0.07590972f, 0.31477380f, 0.18833417f, -0.00729237f, 0.02986228f, -0.05582222f, 
    0.08398043f, -0.02683150f, -0.08599743f, -0.03204343f, -0.23035447f, 0.01910948f, 0.03032138f, -0.11654726f, 
    -0.04795788f, 0.03746031f, 0.19801979f, 0.07355873f, 0.12358845f, 0.06759517f, 0.05454174f, 0.24193716f, 
    0.15470217f, 0.12793964f, -0.08691969f, 0.40432200f, 0.22327565f, 0.23446704f, 0.06376614f, 0.29319152f, 
    -0.03044809f, -0.09562679f, 0.10314941f, 0.07143397f, 0.10334849f, 0.05774281f, -0.27136159f, 0.18236147f, 
    -0.05324072f, -0.06345922f, 0.03928969f, 0.10214613f, 0.31319392f, -0.09368411f, -0.02970999f, -0.10226336f, 
    -0.01815414f, -0.31408015f, -0.06416707f, 0.04376093f, 0.13202678f, -0.00253990f, 0.04852090f, -0.02387947f, 
    -0.00787827f, -0.09095167f, -0.09455904f, 0.11573027f, 0.26759481f, 0.12674603f, -0.10889326f, -0.15551470f, 
    -0.09038731f, 0.03412143f, -0.01705565f, -0.05397745f, -0.11293484f, 0.04847389f, -0.01652497f, -0.11104705f, 
    -0.02119987f, -0.07758906f, -0.09893923f, 0.02646125f, -0.06025188f, -0.00276225f, -0.04902010f, -0.05933568f, 
    0.08435532f, -0.07517904f, -0.12441308f, -0.07850082f, 0.07127715f, -0.10651460f, 0.07617680f, 0.02060054f, 
    -0.11638844f, -0.11000428f, -0.07639208f, -0.07304959f, 0.04642497f, 0.06309444f, 0.05146749f, -0.10478450f, 
    0.07995458f, -0.07211030f, 0.05206202f, -0.06033991f, -0.01177863f, -0.11484057f, 0.07784592f, -0.07075787f, 
    -0.12375524f, -0.06471611f, 0.03429687f, -0.00665925f, -0.04955391f, 0.01630511f, -0.04048293f, -0.05182490f, 
    -0.01555485f, 0.00415005f, 0.01123127f, 0.07775457f, 0.08506704f, -0.00151516f, 0.09237331f, -0.12362606f, 
    0.10155830f, -0.09431314f, 0.00830706f, -0.09244657f, -0.01073479f, 0.10395516f, 0.05504139f, 0.00716496f, 
    -0.06236443f, 0.14448199f, -0.09086662f, 0.21633205f, -0.25213259f, 0.10050117f, -0.07238035f, -0.03647249f, 
    0.19447809f, 0.15117119f, -0.09268221f, -0.05487881f, 0.01894481f, -0.01601089f, 0.25841618f, -0.07909632f, 
    0.29767019f, 0.02177828f, 0.11401488f, -0.01421704f, 0.24314055f, -0.00228851f, 0.10381319f, -0.01301701f, 
    -0.09887536f, 0.06143987f, -0.01525977f, -0.07065684f, 0.13133745f, 0.31679785f, 0.18632624f, 0.05769906f, 
    0.02874830f, 0.25295943f, -0.05781452f, 0.35527155f, 0.09579302f, 0.18011250f, 0.16826726f, -0.22760360f, 
    0.30884477f, 0.08712170f, -0.10153280f, 0.15733652f, -0.18996912f, 0.02996087f, -0.00425884f, -0.06549174f, 
    -0.10131210f, -0.14459613f, -0.07767294f, -0.13930008f, 0.11484129f, 0.01091374f, 0.10925385f, 0.22723711f, 
    0.05134289f, -0.15424621f, -0.15378504f, 0.28271922f, 0.03627411f, -0.01872331f, -0.16031629f, -0.08294673f, 
    0.11557561f, 0.18666467f, 0.20890616f, -0.41614622f, 0.06499387f, 0.08700603f, -0.11750859f, 0.20441581f, 
    -0.00228632f, 0.01094587f, -0.01619942f, -0.00578427f, 0.04193545f, 0.11258094f, -0.11792612f, -0.10186566f, 
    0.14776753f, 0.05178031f, -0.16297099f, -0.10661217f, -0.18511152f, 0.11313786f, 0.35015625f, 0.04459190f, 
    0.20524536f, -0.15222651f, -0.05849252f, -0.21279609f, -0.10775755f, 0.17869774f, 0.27734432f, 0.32022381f, 
    -0.04047001f, 0.01548813f, 0.00283636f, -0.05321092f, 0.15832625f, -0.08285397f, 0.23037085f, -0.16864292f, 
    -0.22085297f, 0.18856457f, 0.18931629f, -0.25539139f, 0.19255687f, 0.27083558f, -0.13874212f, 0.13921484f, 
    0.09976840f, 0.44822884f, -0.05475459f, 0.26503545f, -0.11949722f, 0.07485030f, 0.03508620f, -0.05380377f, 
    0.01656009f, -0.16348878f, 0.20862217f, 0.07977781f, -0.16594674f, 0.10463434f, 0.03491633f, 0.18132462f, 
    0.23645735f, 0.03240940f, 0.37888983f, -0.33366105f, 0.05586208f, -0.04254423f, -0.02242380f, 0.00995110f, 
    -0.03033137f, 0.02015836f, 0.10548441f, -0.01528563f, -0.03751973f, 0.12043504f, 0.08017375f, 0.05851398f, 
    0.09976087f, -0.08197515f, -0.07827009f, -0.05371747f, -0.09984241f, -0.06509341f, 0.04887825f, 0.07970145f, 
    0.15606704f, -0.30496582f, -0.07059829f, 0.04289803f, -0.01860136f, 0.06141279f, 0.00406222f, 0.07147482f, 
    -0.10828575f, -0.06295212f, -0.00734356f, -0.25476214f, 0.08631963f, -0.30720323f, 0.04877240f, 0.06268644f, 
    0.18415312f, 0.11466652f, -0.01028844f, -0.05639496f, 0.20146345f, 0.12100615f, 0.09012143f, 0.14413549f, 
    -0.10213126f, 0.15763557f, -0.03006495f, 0.01193466f, 0.30340371f, -0.31642580f, -0.10261106f, 0.23978312f, 
    -0.01261877f, 0.22042650f, 0.17713785f, 0.08901477f, 0.07513110f, -0.18712752f, 0.05714914f, -0.00658861f, 
    -0.20334093f, 0.20270358f, -0.20211966f, 0.40516561f, 0.02261681f, 0.08656166f, -0.02643362f, 0.05261609f, 
    -0.18315451f, -0.13485195f, 0.11702627f, -0.11580441f, -0.07874684f, 0.00819453f, 0.23481892f, 0.09687214f, 
    -0.07369652f, -0.11220462f, 0.06553824f, 0.07321980f, 0.03685004f, -0.05227809f, -0.16641426f, 0.03562658f, 
    0.00428439f, 0.38595530f, 0.08176328f, -0.14901572f, 0.16638599f, -0.21985683f, 0.12793906f, -0.14633588f, 
    0.02996762f, 0.20046325f, -0.06014006f, 0.22695005f, -0.07212253f, 0.16509859f, 0.18555084f, 0.00748400f, 
    -0.20615974f, -0.23432803f, 0.08608565f, 0.05945333f, -0.32333466f, 0.05974901f, 0.00689597f, -0.08487830f, 
    0.04587708f, -0.03998980f, -0.06140948f, 0.12961338f, 0.01136347f, 0.35273719f, -0.11345890f, -0.15144639f, 
    0.10560071f, -0.19432563f, -0.11301509f, -0.09106192f, -0.01167391f, 0.25070280f, 0.07969043f, 0.01953328f, 
    0.09212471f, -0.08272041f, 0.09213774f, -0.40361813f, 0.17414892f, -0.05299151f, -0.08152531f, 0.18873660f, 
    0.39927781f, 0.14989530f, 0.04093432f, 0.10339494f, 0.13340273f, -0.03175808f, 0.33447495f, -0.00097705f, 
    -0.09300163f, 0.06563621f, 0.00398011f, 0.03926311f, -0.23715357f, -0.00275172f, 0.22269964f, 0.05431210f, 
    0.19769225f, -0.19628917f, -0.01249611f, -0.32518893f, 0.09733513f, 0.21268845f, 0.14685282f, 0.33458042f, 
    0.10702638f, -0.21304111f, -0.02505536f, -0.25259382f, 0.16896234f, -0.17423075f, 0.11773936f, -0.17477497f, 
    -0.12040132f, 0.17553832f, -0.11968843f, -0.25551814f, 0.08655943f, 0.15447845f, 0.05536525f, 0.05077358f, 
    -0.09972714f, 0.10088383f, 0.03094858f, -0.08049313f, -0.08879342f, 0.10944869f, -0.07400361f, -0.11851273f, 
    0.14424562f, -0.00943644f, 0.28372455f, -0.18300162f, -0.12334129f, 0.14712723f, 0.15442477f, 0.16780458f, 
    0.08026536f, -0.00524449f, -0.24827199f, 0.08131471f, -0.08068329f, 0.01842902f, -0.03783228f, 0.00971001f, 
    0.03026386f, 0.15255982f, 0.07088521f, -0.08457739f, 0.06680901f, 0.00216675f, -0.15149896f, -0.01456878f, 
    -0.01852050f, 0.01995552f, 0.10139316f, -0.06373690f, 0.09155115f, 0.02009360f, 0.45451429f, -0.21134187f, 
    -0.04120619f, -0.08218072f, 0.43274629f, 0.20405203f, 0.07035094f, 0.28199887f, -0.17068328f, -0.12969387f, 
    -0.05132088f, 0.19774015f, -0.04633234f, 0.14598200f, 0.46204114f, 0.06629754f, 0.00330933f, -0.07777227f, 
    -0.08336847f, 0.31626251f, -0.08950204f, 0.19384925f, -0.01134988f, -0.15273654f, 0.03634311f, 0.11966679f, 
    0.10564883f, 0.07051677f, -0.07331768f, 0.21983004f, 0.07651172f, 0.27914968f, -0.04004472f, 0.29395649f, 
    0.09792613f, -0.02100396f, 0.09756214f, -0.00025161f, 0.43226168f, -0.08361262f, -0.13614486f, -0.22159220f, 
    -0.17058286f, -0.00345303f, 0.08226801f, -0.13544168f, -0.00372153f, 0.04026513f, 0.07091692f, 0.18621927f, 
    0.11390939f, 0.32342497f, -0.05142225f, -0.08758401f, 0.30946517f, -0.04067431f, 0.07738021f, 0.06760421f, 
    -0.12656355f, 0.00812705f, 0.12017042f, -0.09716360f, 0.08683749f, 0.06268451f, 0.26359954f, 0.11216877f, 
    -0.15137824f, 0.06970283f, 0.16811818f, -0.12456170f, 0.00278610f, -0.01709250f, -0.06541133f, 0.27045670f, 
    0.03230650f, -0.17980620f, 0.03689625f, -0.02453617f, 0.00667748f, 0.16922353f, 0.16116384f, -0.28270468f, 
    0.03218998f, 0.34960753f, 0.10284395f, -0.42124292f, 0.22656666f, -0.04662549f, -0.03643298f, 0.14675188f, 
    0.03625667f, -0.11572722f, 0.06446014f, -0.16091304f, -0.31739447f, 0.16699389f, 0.08783131f, -0.30784222f, 
    0.25518167f, 0.06482447f, 0.09943481f, -0.12229646f, -0.12674673f, 0.10430700f, 0.00330102f, -0.01109065f, 
    -0.09094422f, 0.08972762f, -0.27473059f, -0.15466341f, 0.08819091f, 0.00310469f, 0.06169278f, 0.11880402f, 
    -0.03341699f, -0.39418501f, 0.08227215f, -0.08278132f, -0.35184503f, -0.03372422f, 0.14004818f, -0.11770079f, 
    0.01365103f, -0.00346682f, -0.08362339f, 0.04088539f, -0.05856528f, 0.04902096f, 0.13665256f, -0.16482288f, 
    0.07939354f, 0.25503349f, 0.01966440f, -0.05931788f, -0.10907443f, -0.00696004f, 0.26139310f, 0.22547430f, 
    -0.08721162f, -0.13569421f, -0.07155099f, 0.06762698f, 0.05877163f, 0.04210040f, 0.08653118f, 0.10787407f, 
    -0.38440660f, -0.11029260f, -0.04843823f, 0.15229045f, -0.43851283f, 0.14563812f, 0.05961106f, -0.04163077f, 
    0.11319722f, 0.14755000f, 0.02709029f, 0.24966379f, 0.09873728f, -0.02592088f, -0.11251474f, -0.31200546f, 
    -0.09576810f, 0.33730665f, 0.09271909f, 0.16060866f, 0.14949472f, 0.29613748f, 0.16818695f, 0.05470994f, 
    0.17149825f, -0.05062446f, 0.12540555f, 0.24297036f, -0.05850549f, -0.08498948f, -0.10969031f, 0.03309377f, 
    -0.32722420f, 0.05674884f, -0.08064544f, -0.04362338f, -0.12391149f, 0.01997627f, -0.14664553f, 0.05313896f, 
    0.18465251f, 0.03962319f, 0.04991609f, -0.00031868f, 0.08693220f, 0.09600580f, -0.27928573f, 0.14890900f, 
    0.10275454f, 0.05762785f, 0.21214312f, -0.32236627f, 0.10685800f, 0.02049853f, -0.20000240f, 0.13000715f, 
    0.04086967f, 0.35986647f, -0.02322930f, 0.09963643f, 0.07225674f, 0.03491615f, -0.02613023f, 0.09673287f, 
    0.21453895f, -0.26247072f, 0.01867082f, -0.09538859f, -0.19366348f, -0.05165705f, -0.09428854f, -0.05933544f, 
    0.02537817f, 0.18892477f, 0.11912605f, 0.06862280f, -0.00895452f, 0.11411986f, 0.05436252f, 0.31542644f, 
    0.05162502f, -0.45092067f, -0.06485137f, 0.01380535f, -0.04651840f, -0.05443123f, 0.03032373f, 0.02007511f, 
    0.03815838f, 0.02011990f, -0.12424258f, 0.11105712f, 0.08449767f, -0.10097019f, -0.10865279f, -0.11177272f, 
    0.09513945f, -0.05486999f, -0.08410031f, -0.03975797f, -0.07405267f, 0.10850568f, -0.11262940f, 0.01072897f, 
    0.12841229f, 0.03712095f, -0.02679789f, 0.10401112f, 0.03513819f, 0.11506394f, -0.02067750f, -0.06119294f, 
    -0.03892504f, 0.12444873f, 0.10873996f, -0.11460003f, -0.08968437f, -0.06252148f, 0.01427583f, -0.03838317f, 
    0.02187043f, -0.10692257f, 0.02701964f, -0.02050847f, -0.06498007f, -0.00900272f, -0.12429721f, -0.01241625f, 
    0.08244801f, 0.05554753f, -0.08551622f, -0.06869629f, -0.09408300f, -0.05185010f, -0.04056149f, -0.02778464f, 
    -0.01361676f, -0.02329649f, -0.04480711f, -0.07281449f, -0.07959893f, -0.07095667f, 0.06690143f, 0.05718004f, 
    -0.00220108f, 0.05926714f, 0.03041146f, 0.04325516f, -0.10498318f, 0.00704192f, -0.07315572f, -0.06812445f, 
    0.03410885f, -0.06143304f, -0.06355036f, -0.03712267f, 0.05990271f, 0.11165191f, -0.06873624f, 0.13525562f, 
    0.12945721f, -0.22799450f, -0.06831890f, -0.11701012f, -0.01388673f, 0.06298071f, -0.06713436f, 0.04336639f, 
    -0.05211014f, -0.03842102f, -0.26364899f, -0.02881604f, -0.17988214f, -0.12095181f, -0.05166723f, -0.12286288f, 
    0.00922021f, 0.25594380f, -0.19845478f, 0.09569340f, -0.05044387f, -0.28482455f, 0.41794851f, 0.04319497f, 
    -0.08643663f, 0.04622488f, -0.05481541f, 0.13991994f, -0.18396932f, 0.19800320f, 0.14162073f, 0.03701141f, 
    -0.29081517f, 0.22536243f, 0.23372045f, 0.12074526f, 0.01099386f, 0.30368859f, 0.12096455f, 0.05492609f, 
    0.12013447f, 0.12567829f, -0.00577637f, 0.04972135f, -0.13592473f, -0.01098331f, 0.00621238f, -0.26612076f, 
    0.16306838f, 0.30756712f, 0.06558318f, 0.28994897f, -0.21220236f, 0.15619998f, 0.26640546f, 0.13386284f, 
    -0.15336967f, 0.10112301f, -0.20703207f, 0.09447584f, -0.10594667f, 0.09864151f, -0.10277621f, -0.02335239f, 
    -0.02046045f, 0.30843180f, 0.03860882f, -0.05741245f, 0.07412227f, 0.02791274f, -0.08206054f, 0.04345159f, 
    0.11242633f, -0.05041113f, 0.25032118f, 0.07507621f, 0.23781380f, -0.02345222f, 0.38186300f, -0.15561081f, 
    0.00281076f, 0.04085868f, 0.18928729f, 0.04520712f, 0.04333837f, 0.02595429f, 0.14807625f, -0.04657613f, 
    0.04086841f, 0.17946480f, 0.06083957f, 0.38711444f, 0.06264164f, 0.12311961f, 0.05373340f, -0.19047390f, 
    0.08977195f, 0.33842254f, -0.01099775f, 0.22436428f, 0.13386680f, 0.08055068f, 0.22163524f, -0.02602553f, 
    0.10830209f, 0.07055598f, -0.01737460f, 0.11072733f, -0.22295694f, -0.09653410f, 0.11041041f, -0.15570359f, 
    0.18850394f, 0.07127247f, 0.04209374f, 0.16336754f, 0.08272787f, -0.06764047f, 0.08634647f, -0.26170474f, 
    -0.12730223f, 0.17745072f, -0.25841251f, 0.02406990f, 0.14199652f, 0.07059751f, -0.09142004f, 0.12296495f, 
    0.09616721f, 0.07187776f, -0.05781335f, -0.05332266f, 0.01264308f, 0.01194767f, 0.32590017f, 0.11961044f, 
    -0.27985331f, 0.00675142f, 0.23512277f, -0.13283120f, 0.11560884f, 0.03446381f, 0.24526970f, -0.01771527f, 
    0.01040997f, 0.05805659f, 0.18771790f, -0.18415119f, 0.10994183f, -0.01966021f, -0.16906771f, -0.17708555f, 
    0.09088989f, 0.15292560f, -0.02337803f, 0.04756775f, 0.19786170f, 0.18666874f, 0.17032024f, 0.03282939f, 
    0.07024896f, -0.12352638f, -0.13923915f, -0.31504318f, -0.08233918f, -0.10159057f, 0.02012996f, -0.01210365f, 
    0.06236851f, -0.16851896f, 0.12040816f, -0.01830265f, -0.08448698f, 0.52613270f, -0.06654538f, 0.08953689f, 
    0.02337917f, -0.16249309f, 0.19629258f, -0.41676477f, 0.23858020f, 0.05360050f, -0.20158926f, 0.09720054f, 
    -0.14321591f, -0.00803194f, -0.13128772f, -0.08197886f, -0.03497399f, 0.07378034f, -0.10937574f, 0.00889229f, 
    0.12615837f, -0.04198850f, -0.02979742f, -0.05293906f, 0.02698065f, 0.08364622f, -0.08112049f, -0.07545558f, 
    0.00238897f, 0.04626957f, 0.00824847f, -0.12067821f, -0.14936529f, -0.03823463f, 0.10970429f, -0.11808645f, 
    -0.04593331f, -0.05357999f, 0.07178532f, -0.30545253f, 0.00362078f, -0.13261384f, 0.04747602f, -0.01459553f, 
    -0.08068867f, 0.08928994f, -0.04406720f, 0.04702056f, 0.06911509f, 0.08485097f, -0.06756590f, 0.01339203f, 
    -0.10688969f, 0.19530015f, -0.01556286f, -0.04442161f, 0.01021350f, -0.01330758f, -0.07914003f, -0.02910456f, 
    0.11750975f, 0.08728134f, -0.07318756f, -0.05243744f, -0.18636115f, 0.18682671f, 0.03659508f, 0.05338547f, 
    -0.04794458f, 0.08722460f, 0.11127920f, 0.04424991f, 0.06438335f, 0.17856175f, 0.13919261f, 0.00078679f, 
    -0.14474989f, -0.10289472f, -0.04971582f, -0.07061367f, 0.01566661f, -0.07455343f, -0.03770826f, -0.16405386f, 
    -0.12704374f, -0.00338993f, -0.01736248f, -0.06297816f, 0.06414236f, -0.07457135f, -0.04652333f, -0.10616520f, 
    -0.05222438f, -0.02901089f, 0.01268246f, -0.04789382f, 0.04803625f, 0.04354997f, -0.03391482f, 0.00521575f, 
    0.02075251f, 0.02613288f, 0.09093670f, 0.08538982f, 0.00091111f, -0.15279374f, -0.02961085f, 0.04745276f, 
    -0.05728294f, 0.05948608f, -0.03252832f, -0.07048919f, -0.03712270f, -0.08451678f, 0.06508161f, -0.02049154f, 
    -0.10575034f, 0.04773591f, -0.16339903f, -0.11412220f, 0.03631909f, -0.04180414f, -0.05981411f, -0.02762739f, 
    -0.02387492f, -0.11265850f, 0.08688022f, 0.01907327f, -0.04943408f, 0.00350286f, 0.10888501f, -0.13318487f, 
    -0.12694257f, -0.08024404f, 0.03868628f, -0.12073272f, 0.01337745f, -0.06603000f, 0.05738837f, 0.05021200f, 
    0.01982662f, -0.12010193f, 0.04408849f, -0.05513807f, 0.19886044f, 0.06231121f, 0.01379360f, 0.20542169f, 
    0.04208532f, 0.37280372f, -0.08599676f, 0.12256482f, 0.05032950f, 0.03614373f, -0.11413480f, -0.11511707f, 
    0.00890997f, 0.01623005f, -0.00107929f, -0.07956404f, -0.10527094f, 0.10968465f, -0.04001736f, -0.08899905f, 
    0.21091969f, -0.19427297f, 0.12718447f, -0.11366507f, 0.18667439f, 0.10255512f, -0.08093295f, 0.16793802f, 
    -0.11096415f, -0.07774071f, 0.04655628f, 0.01040159f, 0.07307611f, 0.09049623f, 0.08813297f, -0.20047492f, 
    -0.04230570f, 0.00266735f, 0.09539080f, -0.40067074f, 0.40510881f, -0.08354347f, -0.10735975f, 0.14226785f, 
    -0.09221438f, 0.03385085f, 0.01290221f, -0.01600625f, -0.06709415f, 0.13896504f, 0.07053410f, 0.23129953f, 
    0.14440955f, -0.25438303f, -0.01600978f, -0.21092851f, -0.14083564f, 0.01820912f, 0.01247650f, 0.22119455f, 
    -0.05438811f, 0.13781179f, -0.25422716f, 0.20006637f, 0.04841305f, -0.10829355f, -0.05119752f, 0.11305780f, 
    0.06997312f, -0.29899183f, 0.08171090f, -0.04185851f, 0.03063084f, -0.04038020f, -0.05223386f, -0.09518407f, 
    -0.13671792f, -0.06289384f, -0.22455232f, -0.00802419f, -0.15103421f, -0.02921418f, 0.16724369f, -0.10056709f, 
    0.08529481f, 0.50265431f, -0.00753182f, 0.07258506f, 0.29369804f, -0.05382381f, 0.23784539f, -0.38936466f, 
    0.10263087f, -0.11307223f, -0.07367823f, -0.20443101f, 0.27269793f, 0.07538407f, 0.01297493f, 0.18860291f, 
    -0.12300897f, -0.34553444f, 0.26398501f, 0.23988871f, -0.25502431f, 0.20315616f, -0.27370763f, 0.06818197f, 
    0.10181536f, 0.15462208f, 0.00113934f, 0.19303505f, 0.16932923f, 0.38220817f, -0.02575781f, -0.13194878f, 
    -0.05891449f, 0.09563920f, -0.15103208f, -0.16213243f, -0.21763785f, 0.25330263f, 0.06630509f, 0.26412290f, 
    0.01617158f, -0.04641484f, 0.09997997f, -0.28379524f, -0.13153881f, -0.12333702f, 0.08418584f, -0.13911399f, 
    0.06810367f, 0.11721338f, -0.00837556f, 0.06144123f, 0.20076722f, 0.02321173f, 0.09076568f, -0.07949974f, 
    0.00096540f, 0.08717481f, 0.06753237f, 0.03737838f, -0.03670473f, 0.07039124f, 0.06670500f, -0.03751601f, 
    0.14515990f, -0.30416071f, 0.07732423f, 0.00611175f, -0.00135485f, 0.04640075f, 0.05446481f, -0.24766488f, 
    0.04334700f, -0.06981311f, -0.01748924f, -0.22246218f, 0.20452103f, -0.25382212f, 0.01222412f, -0.16550502f, 
    0.05799426f, 0.22525567f, 0.08561310f, 0.18132252f, 0.42802578f, 0.22246802f, 0.03632460f, 0.15698980f, 
    -0.04177228f, 0.10649142f, -0.07543191f, 0.00799183f, -0.01821649f, -0.03565200f, 0.10097159f, 0.32411337f, 
    0.10349485f, 0.12792203f, 0.18428873f, 0.07219496f, -0.09545790f, -0.07092034f, -0.03641934f, 0.01776423f, 
    -0.03315487f, 0.31267798f, 0.06789025f, 0.22016928f, 0.00359357f, 0.03299645f, 0.11932530f, -0.08404439f, 
    -0.01291803f, -0.23570216f, -0.10361207f, -0.02853916f, 0.12669662f, -0.01697734f, 0.18979283f, 0.03218517f, 
    0.10811129f, 0.05047569f, 0.04383163f, 0.02197587f, 0.15749866f, 0.07389877f, 0.04572364f, 0.21959110f, 
    -0.17655177f, 0.30302775f, 0.06008416f, 0.27781066f, 0.05642132f, 0.03630945f, 0.11266112f, -0.26310065f, 
    -0.01837452f, 0.07236016f, -0.07016044f, 0.11339233f, 0.26021531f, 0.05159183f, 0.13604207f, 0.09264996f, 
    0.17657815f, -0.48819906f, 0.00956632f, 0.03782508f, -0.15844458f, 0.17334718f, -0.39054561f, 0.04103940f, 
    0.06797084f, 0.14309594f, 0.00087271f, -0.02872326f, 0.16430993f, 0.10467103f, 0.01039431f, 0.11217056f, 
    -0.02694022f, 0.18323499f, -0.21946730f, 0.06719104f, -0.23309332f, -0.13013917f, -0.11520691f, 0.18619125f, 
    -0.01341310f, 0.28280380f, 0.30042404f, 0.02590995f, -0.08938430f, -0.05505423f, 0.00578260f, -0.06235151f, 
    -0.00835487f, -0.15856554f, 0.13399248f, 0.00815332f, 0.03001046f, 0.01875230f, 0.13091819f, -0.08824013f, 
    -0.13912474f, 0.04645211f, -0.05537321f, -0.14586958f, 0.09564480f, 0.00926686f, 0.18906221f, 0.27022877f, 
    0.03378871f, 0.18784553f, -0.05580004f, 0.38963753f, -0.07080551f, 0.02595508f, 0.09338013f, -0.19725372f, 
    -0.09792483f, 0.03055120f, -0.06673726f, 0.18409273f, 0.02041545f, 0.03190897f, -0.11911025f, 0.13699915f, 
    0.22226514f, -0.05089867f, 0.13917257f, 0.02560631f, 0.41600677f, -0.07616919f, 0.02363827f, 0.01510104f, 
    0.08740942f, -0.08904392f, 0.07973143f, -0.02899289f, 0.12351596f, -0.15185384f, 0.11301188f, 0.06655810f, 
    -0.04729851f, 0.40449452f, -0.20608851f, 0.17396043f, 0.07474873f, 0.11710571f, -0.00279543f, -0.20233582f, 
    0.04626760f, 0.21977384f, -0.03623852f, -0.44189295f, 0.07566322f, 0.09378938f, -0.02447681f, 0.07558132f, 
    0.24121584f, -0.08972988f, 0.06265641f, -0.01316336f, 0.34726772f, -0.03035209f, 0.16096947f, -0.11970142f, 
    0.17485996f, 0.11568632f, 0.00913537f, -0.01268589f, -0.06631104f, 0.03341855f, 0.42984816f, -0.15084860f, 
    -0.09443510f, 0.15452853f, -0.09260672f, -0.04101373f, -0.06748398f, -0.06962867f, 0.34099519f, 0.07954153f, 
    -0.08481800f, -0.18406425f, 0.12122376f, -0.06139971f, 0.12101017f, 0.00007644f, 0.28296930f, -0.28124073f, 
    -0.07844372f, 0.24784151f, 0.15018062f, 0.08666158f, -0.12617514f, 0.28198925f, -0.14821211f, -0.06352887f, 
    0.09915866f, 0.17104506f, 0.07563064f, 0.11294208f, -0.08324540f, -0.05621888f, 0.10357976f, -0.19347224f, 
    0.03466585f, 0.24480844f, 0.16437365f, 0.09583219f, 0.03471722f, 0.10069986f, -0.07098240f, 0.16488276f, 
    -0.06050093f, 0.01244423f, -0.14069352f, 0.03374559f, 0.00331807f, 0.06015487f, -0.08490785f, 0.04805303f, 
    0.06643350f, 0.07934245f, -0.06044219f, 0.10169005f, -0.10914366f, 0.10592294f, -0.06052059f, 0.08234694f, 
    -0.05869015f, -0.06548695f, 0.08093219f, 0.09783439f, -0.00807589f, -0.00840241f, -0.00988134f, 0.05226809f, 
    -0.09325562f, -0.03073717f, -0.09968834f, 0.02368893f, 0.03039837f, 0.09952394f, 0.06459079f, -0.08480787f, 
    -0.05140426f, -0.10093175f, 0.00013837f, -0.16094728f, -0.11150590f, 0.03183838f, -0.05284041f, 0.04079805f, 
    -0.11544790f, -0.03115054f, 0.08282696f, 0.06231746f, -0.04671649f, -0.06999102f, -0.05136912f, -0.03830271f, 
    0.08267571f, -0.01380873f, -0.07965618f, 0.04525199f, -0.03674488f, 0.06153583f, -0.07323185f, 0.00203848f, 
    -0.09395802f, -0.04594621f, -0.03331023f, -0.00554703f, 0.07373932f, -0.10611884f, -0.14259897f, -0.07089343f, 
    0.02036983f, -0.07617289f, 0.17396159f, -0.19533673f, 0.06054121f, -0.09287839f, -0.08725298f, -0.14169319f, 
    0.39322180f, -0.01751885f, 0.07431470f, 0.10235683f, 0.29803482f, -0.03813202f, 0.26933414f, -0.03898004f, 
    -0.07331103f, -0.03640087f, 0.19049373f, 0.01357596f, 0.11488342f, -0.10516256f, 0.21548429f, 0.08538116f, 
    -0.01764873f, -0.19095586f, -0.00803912f, 0.11943010f, -0.00843913f, 0.19345456f, 0.11735629f, -0.08024231f, 
    0.09527230f, -0.12616357f, -0.02762317f, 0.03782927f, 0.04426843f, -0.23950198f, 0.07447547f, -0.11733237f, 
    0.21346776f, 0.14280225f, -0.12535067f, -0.10523191f, 0.19491415f, -0.03563003f, 0.14551927f, 0.03331717f, 
    -0.00483860f, -0.11248317f, 0.06508477f, -0.16487898f, 0.17110378f, -0.13694964f, -0.00158528f, 0.12254394f, 
    0.11896999f, 0.35786915f, 0.25085771f, -0.20428792f, -0.01851573f, -0.12447309f, -0.13584980f, 0.13245218f, 
    -0.21430708f, -0.06463559f, -0.38984135f, 0.45534730f, 0.15274814f, -0.10742305f, 0.04631058f, -0.03525239f, 
    0.20363860f, -0.16325690f, 0.06331719f, 0.02619362f, 0.05046436f, -0.12926187f, 0.02546332f, 0.10642365f, 
    -0.07278146f, 0.09177545f, 0.07864553f, -0.06122930f, -0.01935596f, -0.05019848f, 0.00623672f, 0.06752268f, 
    0.11353977f, 0.33613995f, 0.25761211f, 0.25395271f, 0.26659450f, 0.06764041f, -0.09958617f, -0.08572429f, 
    0.12085598f, -0.19541016f, 0.09765633f, 0.20075823f, -0.06986630f, 0.23903789f, -0.09824041f, 0.38747376f, 
    0.00764020f, 0.07923987f, -0.01260615f, 0.15495370f, -0.36612123f, -0.27231178f, 0.00675251f, -0.03199600f, 
    -0.08696267f, -0.32236204f, -0.04915911f, -0.13837287f, 0.17504045f, 0.42964551f, -0.07158806f, -0.17968757f, 
    0.10275650f, 0.01218726f, 0.08612544f, -0.23410363f, 0.18127076f, 0.23388506f, -0.15574463f, -0.04216251f, 
    -0.09067448f, -0.05253033f, -0.00853128f, -0.02603970f, 0.03543305f, 0.04255994f, -0.00476906f, 0.05553288f, 
    -0.12490032f, -0.06338790f, 0.03877842f, 0.11809238f, -0.06808202f, 0.00143990f, 0.00604398f, 0.03781301f, 
    -0.00603914f, -0.02377171f, 0.03426798f, -0.00904675f, 0.07938029f, -0.02251126f, 0.11190812f, -0.07347273f, 
    -0.08424229f, -0.05864831f, 0.04226695f, -0.11841322f, -0.05492099f, -0.04623253f, 0.11070656f, -0.03882919f, 
    -0.12316555f, -0.02396359f, 0.00530161f, 0.11369991f, -0.06308913f, 0.01083287f, -0.11646958f, 0.01098449f, 
    -0.02258014f, 0.12462433f, -0.10267246f, -0.01348861f, 0.13097261f, -0.11292771f, 0.11803051f, -0.02048139f, 
    0.09913155f, 0.02047975f, -0.11139204f, -0.10188070f, -0.07148141f, -0.07040505f, -0.10405224f, -0.04699473f, 
    -0.03318128f, 0.10061945f, -0.10635392f, -0.09761502f, 0.05828859f, 0.11751874f, -0.00818692f, -0.05807013f, 
    -0.00069868f, -0.21176560f, -0.17977187f, -0.06131145f, 0.11532478f, 0.02271767f, 0.01467771f, 0.24056427f, 
    -0.14355183f, -0.02050935f, 0.11210659f, -0.07938481f, 0.32805541f, 0.01162896f, -0.14417163f, 0.07255457f, 
    0.19664060f, -0.07332620f, 0.05512489f, 0.03965527f, -0.06024513f, 0.09230033f, 0.01881383f, -0.20781265f, 
    -0.06366372f, 0.21627402f, 0.16785510f, -0.14100744f, 0.01459780f, -0.10536396f, -0.06754416f, 0.01780435f, 
    0.02468458f, 0.20691109f, 0.11953358f, -0.11957565f, 0.05641460f, 0.04530340f, 0.24908154f, -0.10379331f, 
    -0.06847664f, 0.03535874f, 0.08422486f, -0.06795727f, -0.26510835f, 0.12842156f, -0.27008155f, 0.20051400f, 
    0.03502761f, 0.31054789f, -0.03632635f, -0.00106871f, -0.21151069f, -0.12828575f, 0.11581834f, 0.07800151f, 
    0.08834565f, -0.15656851f, 0.12148520f, 0.10766542f, -0.19947487f, -0.03488526f, -0.05199595f, 0.22953869f, 
    0.10989331f, 0.24695601f, 0.02855515f, 0.06753922f, -0.06666359f, -0.09320000f, 0.10619778f, -0.03757567f, 
    -0.01587304f, 0.30235437f, 0.02093070f, -0.11839472f, 0.30419311f, -0.04462194f, -0.04633702f, -0.03969848f, 
    0.22976094f, -0.01446489f, 0.34033909f, -0.09154995f, 0.30411068f, -0.07792193f, 0.36878955f, -0.10577754f, 
    -0.06117401f, 0.01847585f, 0.32748482f, 0.00346303f, 0.03260456f, 0.34665054f, -0.07283356f, -0.05252238f, 
    -0.03873148f, 0.31409833f, -0.00367670f, 0.13270456f, 0.13868104f, 0.02226746f, -0.01520923f, -0.13389456f, 
    0.52984601f, 0.12085718f, 0.03650944f, -0.04788113f, -0.06112138f, -0.15092118f, -0.06477347f, 0.07302453f, 
    0.04056235f, 0.11012874f, 0.04532930f, -0.08189121f, 0.23704731f, -0.19385655f, -0.11179690f, 0.16492409f, 
    -0.00583425f, -0.02045553f, -0.05498171f, 0.17542838f, 0.00171858f, -0.03721729f, -0.20880345f, -0.03739050f, 
    -0.11731269f, -0.10702343f, -0.01586290f, -0.00942112f, -0.11590894f, -0.03557673f, -0.02376590f, -0.11652699f, 
    0.01676005f, 0.00362388f, -0.05231691f, 0.04608030f, 0.01098011f, 0.10356351f, 0.06299847f, 0.04309700f, 
    -0.00799214f, 0.02386413f, 0.04306600f, 0.12447209f, 0.07046082f, 0.05176639f, -0.10577550f, 0.05153154f, 
    0.06098917f, 0.07304773f, 0.02717806f, -0.10530222f, -0.06785496f, 0.00861884f, -0.04424084f, -0.10301262f, 
    -0.05747926f, 0.12999794f, -0.06418480f, -0.06125987f, 0.02075511f, -0.05686598f, -0.11946982f, -0.10994521f, 
    -0.05681009f, 0.08607225f, 0.01151249f, -0.00263993f, -0.06968027f, 0.12678815f, 0.04580910f, -0.12048706f, 
    -0.08441865f, -0.04235297f, -0.03897496f, -0.01079664f, -0.10371401f, 0.01252082f, -0.04027309f, 0.08519425f, 
    -0.00797878f, -0.10122932f, -0.12633398f, 0.01096774f, -0.11372767f, -0.04944253f, -0.06013547f, 0.12289524f, 
    0.09760301f, 0.00098207f, 0.21577929f, 0.15538365f, 0.30094382f, 0.01295739f, 0.08210233f, 0.14556095f, 
    -0.32444906f, -0.02804054f, 0.06994198f, 0.12091265f, -0.28424668f, -0.04509197f, -0.27522722f, -0.06481822f, 
    -0.10064533f, -0.08345335f, -0.00145618f, 0.10514734f, 0.02086089f, 0.07552965f, -0.38399351f, 0.19917175f, 
    0.25882241f, -0.06525961f, -0.03908831f, 0.27131075f, -0.14996253f, 0.05216891f, -0.23090290f, 0.00316158f, 
    -0.09813724f, -0.20396684f, -0.12756769f, -0.13529018f, -0.21643662f, 0.08742355f, -0.28275838f, 0.45409012f, 
    -0.14093056f, -0.19801322f, 0.26653299f, -0.06623740f, 0.34048235f, -0.14943936f, 0.13379531f, 0.21141733f, 
    -0.01016699f, 0.00655536f, -0.12074211f, 0.23804259f, 0.20700686f, 0.01976515f, -0.10405393f, 0.09089389f, 
    0.04092828f, 0.13330206f, 0.11784063f, -0.04063962f, 0.21056223f, 0.13539305f, 0.26438379f, -0.10572691f, 
    -0.26082796f, -0.08834988f, 0.07400960f, -0.13592568f, 0.08732540f, 0.09744658f, 0.07201363f, 0.06565721f, 
    0.26739049f, 0.20441939f, -0.08354237f, 0.09174783f, -0.13173254f, -0.01317342f, 0.34301567f, 0.11145127f, 
    0.00894008f, -0.05667990f, 0.17533596f, -0.10801838f, -0.00079220f, 0.07139519f, 0.21250728f, 0.16662672f, 
    -0.12659393f, -0.11916076f, -0.08081297f, -0.03627092f, 0.04247405f, -0.05390300f, 0.08169208f, 0.44527844f, 
    -0.01527395f, -0.06791601f, 0.01938958f, 0.18949564f, -0.14489485f, 0.03587002f, -0.05060615f, -0.06512132f, 
    0.06932919f, 0.15104538f, -0.13105255f, -0.30208743f, -0.19821016f, -0.21394493f, 0.06472838f, 0.06736714f, 
    -0.04984061f, -0.08999862f, 0.07479085f, -0.10150260f, -0.16723904f, 0.14647125f, -0.09062101f, -0.28435352f, 
    0.19204406f, 0.14986844f, 0.18734801f, -0.09151385f, 0.18527618f, 0.12476763f, 0.07064769f, -0.06531067f, 
    -0.10954744f, 0.06953344f, -0.26160192f, 0.09018999f, -0.01271970f, 0.06668252f, -0.09111188f, 0.02548928f, 
    -0.13320848f, -0.10138394f, 0.10077561f, 0.03927916f, -0.05693775f, -0.05111684f, -0.04509168f, -0.01117970f, 
    0.02078596f, -0.08676486f, 0.19028288f, 0.01577768f, -0.07045289f, -0.05108953f, 0.43548560f, -0.08583401f, 
    0.11991367f, 0.20076470f, 0.29308033f, 0.04010627f, 0.24458785f, 0.29134166f, -0.07408802f, -0.10276496f, 
    -0.11561242f, 0.12717177f, 0.04956184f, 0.11912670f, 0.42766076f, 0.05734334f, 0.03462720f, 0.09744389f, 
    -0.23517388f, -0.11969001f, -0.08123086f, -0.09437575f, 0.09134348f, -0.10430073f, -0.10471803f, 0.03504427f, 
    -0.09276709f, 0.03154397f, 0.03552393f, 0.15824944f, 0.15274939f, 0.57654935f, -0.01151413f, 0.04633868f, 
    -0.07778040f, -0.37570545f, 0.06125178f, -0.14779155f, 0.27985877f, 0.15399091f, -0.14251080f, -0.11457769f, 
    0.02401730f, -0.09061857f, -0.20875138f, 0.40504390f, 0.16068198f, -0.05603032f, -0.02176823f, 0.00714098f, 
    -0.15283644f, 0.20244873f, 0.02768328f, 0.12097244f, 0.18309097f, -0.06021027f, 0.00640541f, 0.03575991f, 
    -0.28006673f, -0.09075726f, 0.33006781f, 0.09450661f, 0.14121287f, 0.04750726f, -0.08252252f, 0.02252258f, 
    -0.00182268f, 0.17862450f, 0.17980123f, 0.06152264f, 0.29970127f, -0.08546669f, -0.25075030f, -0.13311550f, 
    -0.09230565f, 0.10116837f, 0.06165563f, 0.06367236f, -0.09875509f, 0.31134886f, 0.07337105f, 0.25080222f, 
    0.04945620f, -0.15720567f, 0.02728993f, -0.26770750f, -0.06013890f, -0.15878177f, 0.19408268f, 0.17023072f, 
    0.06482702f, -0.19515051f, -0.06836037f, -0.10484355f, -0.11797205f, 0.46503428f, -0.09095380f, -0.03449340f, 
    0.23876064f, -0.14141344f, 0.07914747f, -0.24276195f, 0.03956249f, 0.13599555f, 0.10614787f, -0.08115201f, 
    0.02411991f, -0.16982275f, -0.20528123f, -0.33509085f, -0.10818372f, 0.02535597f, -0.02278567f, 0.06802169f, 
    0.13815728f, 0.13998583f, 0.12928014f, 0.03396577f, 0.23183759f, 0.01768453f, -0.18384196f, 0.01967418f, 
    0.11108506f, -0.09093866f, -0.00227613f, 0.00415085f, 0.11149070f, 0.03331687f, -0.01273584f, -0.11825185f, 
    0.00984839f, -0.17859112f, 0.21574579f, -0.14782225f, -0.16063736f, -0.00534930f, 0.09674560f, 0.07392804f, 
    -0.10327972f, -0.00211416f, -0.03773113f, -0.05899107f, 0.05228973f, -0.11095943f, 0.11242674f, -0.00899802f, 
    -0.09149194f, 0.30785912f, -0.05842553f, -0.00423488f, -0.22071412f, 0.08133674f, -0.01837703f, 0.19451380f, 
    -0.02127992f, 0.04180049f, -0.03290467f, 0.00250636f, 0.07458253f, -0.30189615f, -0.01055153f, -0.01539461f, 
    0.20538273f, 0.34852391f, 0.29311287f, 0.07381458f, 0.17438272f, -0.05575287f, 0.14334331f, -0.11905601f, 
    0.03950529f, 0.09982575f, -0.18271360f, -0.09300332f, 0.08489335f, -0.02327146f, 0.03245436f, 0.16403443f, 
    -0.03021172f, -0.20240130f, 0.02466112f, 0.08787272f, -0.15441313f, 0.05556607f, -0.09760940f, 0.00623780f, 
    -0.07726217f, -0.02307764f, -0.22750589f, 0.07908020f, -0.12278290f, -0.04744266f, -0.22050422f, -0.04915811f, 
    0.02793415f, 0.17785171f, 0.00285888f, -0.17277606f, -0.12806727f, -0.31831446f, 0.04420158f, -0.36227995f, 
    0.11453874f, -0.02693537f, 0.03329375f, -0.09638725f, -0.05450153f, 0.02421261f, 0.23090824f, 0.05066409f, 
    -0.11620219f, 0.12137288f, 0.12380299f, 0.34624320f, 0.00751384f, 0.27209955f, -0.07642486f, 0.06929584f, 
    0.05076814f, 0.29674882f, -0.01447369f, 0.19011004f, -0.08493689f, 0.13509905f, 0.06320672f, 0.05020200f, 
    0.02609812f, 0.26207739f, 0.17213696f, -0.01280609f, -0.05397269f, 0.07110070f, 0.31176561f, 0.19329034f, 
    -0.19066104f, 0.20577247f, -0.21826530f, 0.32421163f, 0.04207622f, -0.05307582f, 0.02711463f, -0.24954003f, 
    0.21570015f, -0.02857803f, 0.07668104f, 0.08851240f, 0.31201124f, -0.02305192f, 0.10719521f, -0.03839158f, 
    0.01197952f, 0.08471326f, 0.22150317f, 0.00788200f, 0.10522866f, -0.11203571f, -0.09209425f, -0.02550325f, 
    -0.00653980f, 0.11555907f, 0.02345662f, 0.43769935f, 0.32075271f, 0.08687005f, 0.08750785f, -0.27686948f, 
    -0.02620260f, 0.06720350f, 0.08790718f, 0.21896909f, -0.08152163f, 0.22297536f, -0.07288924f, 0.03827213f, 
    0.25497967f, 0.17375430f, -0.08505572f, 0.00284307f, -0.25644049f, 0.07003965f, -0.08735721f, 0.09181442f, 
    -0.10181379f, -0.13619034f, 0.11601193f, -0.21375175f, 0.04988603f, -0.01057575f, -0.07914104f, -0.13077451f, 
    0.14998686f, 0.39492279f, -0.26148006f, -0.05119916f, -0.11888263f, -0.20796175f, -0.25318962f, -0.11681049f, 
    -0.02188026f, 0.14159593f, -0.01966056f, -0.10398000f, 0.09738296f, -0.04036921f, -0.04305467f, 0.01736057f, 
    0.02375626f, 0.03516393f, -0.02487942f, -0.11641356f, 0.07810510f, -0.10663403f, -0.22022535f, 0.04950343f, 
    -0.20416750f, -0.09462196f, -0.05570008f, 0.04823919f, -0.14416337f, -0.00978216f, 0.12468707f, -0.23152211f, 
    0.18181208f, 0.12939759f, -0.15708193f, 0.11138517f, 0.17349599f, -0.12378523f, 0.21765082f, -0.37108395f, 
    0.02403667f, -0.09163431f, 0.00093086f, -0.05486781f, 0.28915945f, -0.05560646f, 0.03348413f, 0.14026955f, 
    -0.31772584f, -0.07127466f, 0.22215803f, 0.13443087f, 0.53504461f, 0.22601318f, -0.09193197f, -0.00356868f, 
    -0.09728776f, 0.15671241f, -0.07481748f, 0.28018534f, -0.03692587f, 0.25758502f, -0.05189954f, 0.02331821f, 
    -0.03011231f, -0.15936427f, -0.13039240f, -0.08545310f, -0.02002301f, 0.25048468f, 0.03051114f, 0.05260725f, 
    0.16497807f, 0.21260081f, 0.36370113f, 0.01663587f, 0.14081864f, 0.08549587f, -0.09293721f, 0.09426115f, 
    -0.00845652f, -0.08694535f, -0.07145552f, 0.10672893f, -0.31130800f, 0.09353477f, 0.05889351f, 0.07173128f, 
    0.22658892f, -0.12103584f, -0.08839156f, -0.04258688f, 0.04838956f, -0.04986976f, 0.08234485f, 0.00095217f, 
    0.05717507f, -0.01064125f, -0.10120808f, -0.08471555f, 0.05324642f, 0.08087582f, 0.20259672f, 0.29312360f, 
    -0.11935743f, 0.00946586f, -0.04529116f, -0.01843053f, -0.00317982f, 0.15174022f, -0.02832089f, 0.07679299f, 
    -0.07672193f, -0.48413080f, 0.19885896f, -0.03385038f, 0.35563731f, 0.16639718f, -0.01677864f, 0.05125349f, 
    0.05345096f, 0.29982862f, -0.05757170f, 0.09667576f, 0.06868708f, 0.17357707f, 0.10738296f, 0.06773865f, 
    -0.16314726f, -0.23609027f, -0.17567055f, 0.22770722f, -0.19245356f, 0.21276730f, -0.05913522f, 0.17248233f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05081036f, -0.07738198f, 0.08604276f, 0.09437587f, -0.02195824f, 0.10916463f, 0.02390444f, -0.06285548f, 
    0.03705326f, 0.00885921f, 0.11754521f, -0.06065453f, 0.06318066f, 0.08448915f, 0.08934230f, -0.02017697f, 
    -0.02445234f, 0.16942021f, 0.09696784f, -0.09457971f, -0.02307700f, 0.12434033f, 0.10656233f, -0.08108462f, 
    -0.02155865f, 0.00980339f, -0.02782387f, -0.01603401f, 0.12408382f, -0.06324179f, 0.00809852f, -0.08913630f, 
    0.22455648f, 0.02876952f, 0.11811344f, -0.05798747f, 0.06754383f, -0.04776132f, 0.06787992f, -0.00065525f, 
    0.08968699f, -0.11951057f, 0.08443379f, 0.17272049f, 0.11858433f, -0.02227909f, 0.15071934f, -0.03248111f, 
    0.06422312f, 0.09921314f, 0.11224497f, -0.01133012f, 0.12512995f, 0.21852805f, -0.01245576f, -0.08078241f, 
    0.00024090f, 0.16989379f, 0.06539969f, -0.09882255f, 0.06190167f, -0.02096764f, 0.13522746f, 0.06652765f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.27507132f, -0.04805854f, 0.28233442f, 0.05798305f, -0.14146692f, -0.05980091f, -0.02023484f, -0.12519664f, 
    0.08419500f, 0.05757797f, -0.14221616f, 0.03904198f, -0.01416023f, 0.07678097f, -0.15693642f, 0.17466722f, 
    0.11264011f, -0.43978700f, -0.08832157f, -0.28670409f, -0.25715426f, -0.26138556f, -0.29747292f, -0.47232285f, 
    0.14608847f, -0.21496682f, -0.01683379f, -0.04999325f, 0.14646243f, -0.33837205f, 0.33874759f, 0.14060143f, 
    -0.02477285f, 0.28781259f, 0.27886003f, -0.11121575f, -0.01399849f, 0.22451270f, 0.16767663f, 0.28278670f, 
    0.36734718f, 0.04784294f, 0.10130662f, -0.05266434f, -0.21888837f, -0.41395578f, -0.52228945f, 0.06926210f, 
    -0.03802046f, -0.41101471f, 0.00418032f, 0.03856409f, 0.09209429f, -0.23358966f, 0.01018138f, -0.12764607f, 
    0.29424295f, 0.08636262f, 0.21126795f, -0.04797924f, 0.14085019f, -0.43172294f, 0.07338878f, 0.01374457f, 
    -0.21604186f, 0.09700081f, -0.16733374f, 0.08643698f, -0.42155212f, 0.04743303f, -0.12460504f, 0.02181528f, 
    -0.25065461f, -0.16216546f, -0.51838863f, -0.09280696f, 0.05393345f, 0.03779378f, 0.18610157f, 0.13241701f, 
    -0.07859838f, -0.01643709f, 0.10280419f, -0.15339848f, 0.25760308f, 0.09049799f, 0.23815911f, -0.03690677f, 
    0.13319263f, -0.36668748f, -0.08644893f, -0.40884954f, 0.18533550f, 0.21487761f, -0.29542276f, 0.12658872f, 
    -0.02464763f, 0.00192111f, 0.13644819f, -0.36383441f, 0.10653703f, 0.21644513f, -0.03284571f, -0.31725779f, 
    0.10771538f, -0.02690688f, -0.02370066f, 0.06142403f, 0.18235074f, -0.09552959f, 0.04362648f, 0.24177484f, 
    0.03253919f, 0.08044762f, -0.42029783f, 0.07930952f, 0.23196772f, -0.11947756f, -0.13094842f, 0.00183074f, 
    -0.24485897f, -0.19620185f, -0.29265445f, 0.28195968f, 0.30210808f, 0.22365609f, 0.18657373f, -0.11457081f, 
    0.03782668f, 0.12180594f, -0.09379414f, -0.00428815f, 0.12238500f, -0.05886891f, -0.10759261f, 0.15248773f, 
    -0.02608981f, 0.08854061f, -0.43357739f, -0.17063813f, -0.28360257f, -0.02311752f, -0.18055074f, -0.12667739f, 
    -0.04119265f, 0.15661429f, 0.08472194f, -0.46350288f, -0.04890887f, -0.04980852f, 0.18737596f, -0.44537598f, 
    0.07102663f, 0.01423415f, 0.07382292f, -0.27719787f, -0.02566580f, -0.05834111f, 0.24107599f, 0.14881612f, 
    -0.05944407f, -0.57561564f, 0.15237258f, -0.15113640f, 0.02176454f, 0.13561006f, -0.43381906f, 0.20317943f, 
    -0.04917706f, 0.09105766f, 0.02133578f, 0.38471925f, -0.06161352f, -0.08961548f, -0.21411112f, -0.20132864f, 
    0.11978400f, -0.07205819f, 0.40264535f, -0.02878551f, -0.14419805f, -0.50608724f, 0.07872382f, 0.11245197f, 
    -0.38499272f, 0.08119419f, 0.17082144f, -0.23318388f, 0.15810271f, -0.19706634f, 0.27549157f, 0.06505795f, 
    -0.29274583f, -0.02582093f, 0.14825247f, -0.01699615f, -0.39538482f, -0.07424854f, -0.11765665f, -0.31271693f, 
    0.13074046f, -0.30487290f, 0.09705997f, -0.07414395f, 0.09972958f, -0.22916782f, 0.16149631f, -0.44222209f, 
    -0.06960183f, 0.03694350f, 0.00390651f, 0.21025616f, 0.07628050f, 0.32811236f, 0.05522288f, -0.01361686f, 
    -0.81914562f, 0.07734109f, -0.08066649f, 0.08668437f, -0.00902461f, -0.43200281f, -0.02123058f, 0.05473202f, 
    0.08960423f, 0.27676302f, -0.44733235f, -0.04324074f, -0.02372501f, -0.07386243f, 0.13875638f, 0.13009450f, 
    0.04731441f, 0.03913481f, 0.21708956f, 0.10392822f, -0.00724626f, -0.05868891f, -0.06728674f, 0.03965785f, 
    -0.07749233f, -0.05432270f, 0.16885343f, -0.00696385f, 0.27924174f, 0.13957191f, 0.07646791f, -0.34832889f, 
    -0.04169754f, 0.07967098f, 0.21004388f, -0.36128828f, -0.57236344f, 0.19341725f, 0.12795249f, -0.09801832f, 
    0.01343799f, -0.01505313f, 0.13191341f, 0.03774527f, -0.00044144f, -0.00800811f, 0.00950340f, 0.09325361f, 
    -0.28874102f, 0.15940344f, 0.12018441f, -0.17979549f, -0.13516514f, 0.09019883f, -0.32753956f, -0.27227846f, 
    0.12130348f, -0.12948193f, -0.02910938f, 0.04210201f, 0.44622096f, 0.19250862f, -0.03676887f, 0.18864077f, 
    0.04504735f, 0.08650806f, 0.07177436f, 0.08708074f, -0.06188359f, 0.02469421f, -0.28372386f, 0.14939493f, 
    0.19829531f, 0.03530764f, 0.11082633f, -0.34357309f, 0.10235507f, -0.30606508f, 0.04523858f, 0.19503176f, 
    0.03196563f, 0.01705091f, -0.07329417f, -0.37681285f, 0.01769313f, -0.14592610f, -0.07067487f, -0.03093777f, 
    0.03644164f, 0.25116336f, 0.26905030f, -0.11082532f, -0.18998362f, 0.16507952f, 0.00300704f, -0.09089196f, 
    0.26289949f, 0.05138358f, 0.00418557f, 0.21877731f, -0.34064052f, 0.13201123f, -0.35171905f, -0.27779940f, 
    0.00106489f, 0.02496649f, -0.00434463f, 0.11045659f, 0.28288588f, 0.07063023f, 0.04490514f, -0.00007447f, 
    0.22343177f, -0.07660603f, 0.16346632f, -0.10002545f, 0.11288517f, 0.15309381f, 0.23677796f, 0.26627690f, 
    0.05405709f, 0.19791108f, -0.03205976f, 0.42407072f, 0.00415671f, 0.13599996f, -0.11643828f, -0.19329299f, 
    0.14974909f, -0.16524492f, 0.02510274f, 0.22925407f, 0.04900491f, 0.10455227f, -0.18494250f, -0.00530091f, 
    0.03076064f, -0.13816190f, -0.23752239f, 0.00596413f, 0.10598484f, 0.03452122f, 0.12297221f, -0.26158777f, 
    -0.06512891f, -0.05026003f, -0.02408436f, -0.36310652f, 0.18810739f, -0.33909523f, -0.02521773f, -0.10796543f, 
    -0.09134606f, 0.01545309f, -0.49179408f, -0.06256553f, 0.00648664f, 0.13870671f, 0.00295957f, -0.12133779f, 
    -0.14236374f, -0.21371540f, -0.23257712f, 0.06969104f, -0.04634668f, -0.44320035f, -0.19400921f, -0.03856605f, 
    0.28302255f, 0.05528612f, -0.09815165f, 0.06039687f, -0.16336305f, -0.07396159f, 0.09744462f, 0.16970657f, 
    -0.31329185f, -0.28197235f, -0.05637148f, 0.21793599f, -0.04520501f, -0.05772730f, -0.21651754f, 0.16506390f, 
    -0.02212535f, 0.22838627f, 0.04563593f, -0.56914133f, -0.67428893f, 0.16165568f, 0.17633046f, -0.23021792f, 
    0.13352226f, -0.17867298f, -0.08982830f, 0.04161899f, -0.02790304f, -0.10745793f, 0.21758509f, -0.39963201f, 
    0.16982813f, -0.24039607f, -0.11311837f, 0.37351036f, 0.06163523f, -0.22695172f, -0.03240691f, 0.10922038f, 
    0.06287473f, -0.07056659f, 0.09546611f, 0.03485455f, -0.19095643f, 0.15339543f, -0.24732706f, -0.31381217f, 
    0.06586780f, -0.53424090f, 0.01554889f, 0.01756581f, 0.35810700f, 0.21063033f, -0.00413739f, 0.04245026f, 
    -0.30233088f, 0.14222287f, 0.26975405f, -0.00684216f, -0.00887595f, -0.31898516f, -0.17363586f, -0.00360161f, 
    0.09133489f, -0.12056453f, -0.17784928f, -0.08295930f, 0.39442056f, -0.04774306f, -0.12879929f, -0.12989393f, 
    0.14042868f, 0.19270825f, 0.07871822f, -0.05095081f, 0.17964825f, -0.49417835f, 0.11700513f, -0.19280657f, 
    -0.04571007f, 0.00909828f, -0.10641075f, 0.27876255f, 0.07702108f, -0.32523146f, -0.15715633f, 0.21263364f, 
    -0.04517976f, -0.00357769f, -0.01902957f, -0.00259119f, -0.41396496f, -0.11244284f, 0.12978169f, -0.23271920f, 
    -0.25640014f, 0.05901530f, -0.06863895f, -0.45715359f, 0.09960007f, 0.04671469f, 0.01948693f, 0.05862377f, 
    0.00787252f, -0.07808796f, -0.43815562f, 0.02047432f, -0.24086955f, 0.24693021f, 0.18372315f, -0.01610207f, 
    -0.03865928f, 0.08950777f, 0.21807082f, -0.09477732f, -0.18563794f, 0.05632682f, 0.10212191f, -0.02438468f, 
    0.07272792f, -0.36254007f, 0.19547072f, -0.06668718f, 0.31465119f, 0.26191837f, -0.33271775f, -0.29749984f, 
    0.12820007f, -0.05085523f, -0.30521870f, -0.11123263f, -0.23407365f, 0.05809886f, -0.03039987f, 0.19965832f, 
    0.08950333f, -0.25569779f, -0.07437202f, -0.10661945f, 0.28750059f, -0.12783846f, 0.27715591f, -0.04352853f, 
    -0.06630215f, -0.12745680f, 0.03721421f, -0.19604582f, 0.31641781f, 0.16648619f, -0.41061488f, -0.04180196f, 
    0.09124683f, 0.20590605f, 0.09160186f, -0.25157347f, 0.17570151f, 0.18950254f, -0.23468889f, 0.25475743f, 
    -0.55826110f, 0.06809913f, -0.00901216f, 0.19066568f, 0.08284807f, 0.10509735f, -0.39597428f, -0.40095836f, 
    -0.02710474f, -0.07688668f, 0.21488805f, -0.24791284f, -0.25403026f, -0.25457588f, -0.06679656f, -0.07939117f, 
    -0.00802035f, -0.06638291f, -0.15975860f, -0.05281155f, -0.00529511f, -0.22035038f, 0.10122332f, 0.23700324f, 
    0.26157683f, -0.37103820f, -0.16116717f, -0.15758792f, -0.33121556f, -0.18305978f, -0.17933100f, 0.29258370f, 
    -0.01171445f, -0.10345622f, 0.33318737f, 0.10763896f, 0.25645074f, -0.02963736f, -0.08452125f, 0.09178053f, 
    -0.18746947f, 0.25457057f, 0.23207271f, 0.09855161f, -0.24591495f, 0.05227033f, 0.18511942f, -0.02105040f, 
    -0.10487786f, -0.28325814f, 0.05273337f, -0.14638677f, -0.31653273f, -0.38408878f, -0.19423364f, -0.25522211f, 
    0.19614577f, 0.32978675f, -0.10031152f, -0.15175761f, -0.11755913f, 0.04741330f, -0.08824708f, -0.49473995f, 
    0.15502666f, -0.23458366f, -0.31860122f, -0.06552198f, -0.03091946f, -0.13129517f, 0.10443817f, -0.07683386f, 
    -0.14989521f, 0.04044761f, -0.02442265f, -0.11545372f, 0.02410714f, -0.15738441f, 0.27400151f, -0.47840011f, 
    0.09317283f, -0.23186748f, 0.11181848f, 0.00501885f, -0.46323562f, 0.06186802f, 0.08219466f, 0.34733361f, 
    -0.22072817f, 0.08776580f, 0.19096474f, -0.22536710f, -0.24573679f, 0.11988654f, 0.30978057f, -0.02740785f, 
    -0.42277905f, 0.10463043f, -0.34612140f, 0.01862958f, -0.08600292f, -0.11875323f, 0.04044994f, -0.30415902f, 
    -0.03351219f, -0.09322079f, 0.19459994f, -0.26386207f, -0.00883438f, 0.13264653f, 0.18344432f, -0.30362532f, 
    0.05394840f, 0.17373697f, -0.04151947f, -0.25903127f, -0.12303285f, 0.15257306f, 0.09135476f, -0.06463787f, 
    -0.48832813f, 0.20473792f, -0.08745229f, 0.23374069f, 0.05617353f, -0.12440441f, 0.16352621f, -0.35130933f, 
    0.00610304f, -0.32843861f, 0.58127695f, -0.32053202f, -0.12753674f, 0.19934534f, 0.09168815f, -0.18065776f, 
    0.03084192f, -0.11578961f, -0.41795033f, 0.27460766f, -0.37431425f, 0.19436060f, 0.24468502f, 0.14231509f, 
    0.07913277f, -0.30438766f, 0.09823550f, 0.02065038f, -0.08898769f, 0.07892381f, -0.03723247f, -0.17300640f, 
    -0.12988167f, 0.08165894f, -0.47657251f, -0.27577168f, 0.02818383f, 0.00656587f, 0.08201958f, 0.19907276f, 
    0.06462888f, 0.06849930f, 0.01178044f, -0.02144665f, -0.20029156f, 0.06824426f, -0.09152262f, -0.17529520f, 
    0.32785407f, -0.49774593f, -0.02834223f, 0.14810136f, -0.29205933f, -0.07933546f, -0.45105463f, -0.29373592f, 
    0.05925447f, -0.01219473f, 0.10686333f, -0.30914330f, -0.27790311f, -0.11765772f, 0.26131022f, 0.20608415f, 
    -0.10196786f, 0.00794873f, 0.11464755f, 0.00127902f, 0.22573037f, 0.24982616f, -0.13927610f, 0.27059945f, 
    0.07513914f, -0.02778376f, -0.14491339f, 0.21947454f, 0.03891645f, -0.38905871f, -0.09872414f, 0.25047064f, 
    -0.02410420f, 0.06637726f, 0.12549151f, 0.03212219f, 0.24363627f, 0.16243035f, 0.10160676f, 0.08261391f, 
    -0.00909445f, 0.12095508f, -0.40527734f, -0.10309222f, -0.16869111f, 0.20737492f, 0.04859831f, -0.18645668f, 
    -0.10331335f, 0.17350101f, -0.19041903f, -0.25080916f, -0.13608758f, -0.46206546f, 0.12444717f, 0.21470264f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.01674411f, -0.11958852f, 0.07707567f, -0.06548521f, 0.06019212f, 0.10078163f, 0.07324483f, -0.08059375f, 
    -0.00993928f, -0.01139659f, -0.03417314f, 0.00485095f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
