#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.40163836f, -0.39963487f, -0.24661753f, 0.46740797f, -0.15745966f, -0.27272916f, -1.15374136f, -0.76951534f, 
    0.03812859f, -0.63229483f, 0.37490925f, 0.12575550f, 0.04803007f, 0.74870950f, -0.15533404f, -0.20177288f, 
    0.05730455f, -0.33946142f, -0.02192666f, -0.00531450f, -0.24016225f, -0.09352332f, 0.35481793f, -0.27318856f, 
    -0.39560840f, -0.62437743f, -0.48021349f, -0.49638021f, -0.57018805f, -0.20607457f, -0.20583665f, -0.55157161f, 
    -0.39840779f, -0.89483786f, -0.74794716f, -0.07083835f, -0.12935458f, -0.10337702f, -0.18899590f, -0.33742151f, 
    0.39801243f, -0.01390069f, -0.26052573f, 0.26499653f, -0.20982347f, 0.07980881f, 0.48125669f, 0.45215759f, 
    0.32091573f, 0.54303950f, -0.29775912f, -0.14936022f, -0.62704879f, -0.59005344f, -0.58355129f, 0.37215820f, 
    -0.41066080f, -0.46135515f, -0.44101965f, -0.70024610f, 0.53100085f, 0.35485798f, 0.76270986f, 0.35663849f, 
    0.33067167f, -0.16381258f, -0.25001138f, -0.38076115f, -0.08906157f, -0.49071360f, 0.00109087f, 0.19749469f, 
    0.53541303f, -0.30552214f, -0.11245663f, 0.37638348f, -0.76690143f, 0.33425990f, 0.70607102f, -0.43406782f, 
    -0.87972230f, -0.92510682f, -0.38456401f, -0.17616342f, 0.56762409f, -0.33924001f, -0.30334029f, -0.34166873f, 
    0.36765954f, 0.37511039f, 0.31681460f, -0.27553472f, 0.04205056f, 0.29198560f, 0.19405997f, 0.17189077f, 
    -0.17781012f, -0.53226811f, -0.08716726f, -0.25600466f, 1.01940000f, 0.36852390f, -0.37301174f, -0.26675999f, 
    -0.75014341f, 0.26991957f, 0.64894521f, 0.07186172f, -0.62576872f, -0.45960402f, -0.18860926f, 0.44556883f, 
    -0.40399337f, 0.29217142f, 0.27985182f, 0.38450733f, -0.41986060f, -0.22228681f, 0.29798394f, -0.42142680f, 
    0.15406351f, -0.18341261f, 0.10627191f, 0.21325867f, 0.31204656f, -1.11104250f, -0.12842813f, 0.69063038f, 
    -0.87287563f, -0.37658918f, 0.04930504f, 0.22199018f, -0.56848246f, -0.16036668f, 0.22900286f, -0.33361417f, 
    -0.35462821f, -0.36823592f, -0.42716628f, -0.17181093f, 0.27743202f, 0.38841385f, 0.22615086f, 0.24164484f, 
    0.24303649f, 0.12444374f, 0.20128073f, 0.08877768f, -0.18865541f, 0.10402308f, 1.17751682f, 0.13568883f, 
    0.43467358f, -0.61558783f, -0.92223448f, -0.09866975f, 0.18153380f, 0.21855570f, -0.25407284f, -0.00044557f, 
    -0.38700005f, -0.18812536f, 0.06391899f, 0.17018399f, -0.01296149f, -0.14165024f, -0.24965741f, 0.18815632f, 
    0.08843639f, -0.39066070f, -0.37683272f, -0.22826213f, -0.53008348f, -0.24130866f, -0.47461915f, 0.00136802f, 
    -0.96979886f, -1.02528167f, 0.31752059f, 0.32049930f, 0.52859753f, 0.89457113f, -0.06660569f, -0.40677571f, 
    -0.34366697f, -0.32908857f, -0.21277639f, -0.39386538f, -0.16137169f, 0.11075778f, -0.09643663f, 0.00462995f, 
    -0.03455232f, 0.31093499f, 0.22582918f, 0.45411247f, -0.37360641f, -0.36574748f, -0.44450316f, -0.56152940f, 
    -1.02935433f, -0.99195594f, -0.57662606f, -0.63706720f, -0.32520723f, 1.12316191f, -0.07350440f, -0.69830102f, 
    -0.15078571f, 1.22266746f, -0.31707647f, -0.48187900f, -0.15785378f, 0.51282692f, -0.16993774f, 0.15481354f, 
    0.07609782f, 0.07358585f, 0.05614929f, -0.28800112f, -0.01045595f, -0.07204683f, -0.07820585f, -0.08231328f, 
    0.14955659f, 0.43680075f, 0.21321705f, 0.47814918f, 0.61335599f, 0.24423790f, 0.13712046f, 0.07800205f, 
    0.18188921f, 0.22266197f, 0.12549251f, 0.26597834f, 0.20125911f, -0.29794016f, -0.21433444f, -0.34638643f, 
    0.30874121f, 0.20117544f, -0.10473013f, 0.10793590f, -0.07657772f, -0.42714056f, -0.33548099f, -0.30195975f, 
    -0.29983795f, -0.42601156f, -0.03063991f, -0.42445138f, -0.27277681f, -0.20484495f, -0.22713466f, 0.44530970f, 
    0.28617054f, 0.10224882f, 0.16453905f, 0.63135564f, -0.09696410f, 0.74571615f, -0.50095177f, -0.19356537f, 
    0.05305378f, -0.65724081f, 0.10360861f, -0.09112941f, 0.12613256f, -0.23361380f, -0.00741714f, 0.35594943f, 
    0.17494589f, 0.19939132f, 0.45361167f, 1.86803460f, -0.63064206f, -0.75343859f, -0.60234183f, -0.42488718f, 
    0.32924077f, 0.13289182f, 0.10235152f, 0.19310877f, -0.05444248f, 0.10806789f, 0.40790388f, 0.02073013f, 
    -0.53557092f, 0.04084307f, 0.20850044f, 0.24359670f, 0.10361227f, -0.43630034f, -0.06196776f, -0.20143770f, 
    -0.10020293f, -0.11020313f, 0.10679239f, -0.17672175f, -1.34213471f, 0.29610220f, 0.17570880f, -1.32495010f, 
    -0.83786631f, 0.74060112f, 0.45334503f, -0.06784805f, 0.02697407f, 0.30269712f, -0.01261975f, -0.38112485f, 
    -0.18701048f, -0.19839509f, 0.01745004f, -0.29015690f, -0.28330711f, -0.33505911f, -0.21453550f, 0.15404175f, 
    -0.10220475f, 0.08710249f, -0.08367822f, -0.10860989f, -0.27106521f, 0.75394636f, 0.98446226f, 0.68090242f, 
    0.27912900f, -0.19579084f, -0.56310570f, -0.21133369f, -0.31354639f, 0.02701184f, -0.23587364f, 0.16968113f, 
    -0.37686369f, 0.61473250f, -0.40683496f, -0.48282966f, 0.00686241f, -0.07418726f, 0.18870959f, 0.18634093f, 
    0.15351374f, 0.02223860f, 0.19677795f, -0.15087488f, 0.02296300f, 0.63689464f, -0.34801278f, -0.63148814f, 
    -0.82124746f, -0.32399675f, -0.71071166f, 0.05182031f, 0.17760575f, -0.09229933f, -0.03353200f, -0.45173529f, 
    0.35874081f, 0.00930807f, -0.12481201f, 0.64176112f, -0.55207926f, -0.38755506f, 0.14747053f, 0.08261891f, 
    -0.33214703f, -0.01502794f, -0.51111120f, -0.21636233f, 0.18781555f, 0.19487964f, -0.40171272f, -0.37742341f, 
    -0.10193206f, 0.68562520f, 0.31032789f, -0.22722542f, 0.61614013f, -0.29728454f, 0.43237138f, -0.01633609f, 
    -0.02910394f, -0.52090579f, 0.72774023f, -0.00334272f, -0.29362440f, -0.15993111f, 0.13145544f, 0.45167843f, 
    -0.60931504f, -0.34161502f, 0.04846811f, 0.05072892f, -0.02791769f, -0.09141363f, -0.07882570f, 0.08548359f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08945719f, 0.25658053f, -0.03670605f, 0.60472459f, 0.50542235f, 0.06317859f, 0.24939661f, 0.17679492f, 
    0.14170353f, -0.27404949f, 0.41918445f, 0.18325177f, 0.50443047f, 0.57956088f, -0.05824625f, 0.49400398f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06456345f, -0.04379334f, 0.04758623f, -0.00373366f, -0.00316883f, 0.04519747f, 0.01672258f, 0.01933027f, 
    0.01889179f, 0.01138669f, -0.00748427f, 0.00264937f, -0.06528123f, 0.00790508f, 0.01881478f, -0.04539780f, 
    -0.06986771f, -0.02730183f, 0.01870321f, 0.00315772f, -0.01693744f, -0.06803162f, -0.05819710f, -0.00158874f, 
    0.05470007f, -0.05299699f, 0.02595809f, -0.07695888f, -0.06791043f, 0.01103407f, -0.04010880f, 0.01777751f, 
    0.02530733f, -0.03197078f, 0.01555817f, -0.06950878f, -0.04719885f, -0.03097666f, -0.06722381f, 0.00256773f, 
    -0.08072038f, 0.05118064f, -0.00514911f, 0.04898879f, -0.05135499f, -0.06117176f, -0.06448890f, -0.02572697f, 
    0.04573623f, -0.00534781f, 0.01547042f, 0.00466360f, -0.00762812f, 0.00614952f, -0.07383768f, -0.04652426f, 
    0.00673127f, -0.02690643f, 0.01249128f, 0.02387779f, -0.04374715f, -0.05217385f, 0.01483904f, -0.05581098f, 
    -0.00757825f, -0.00670829f, 0.00416320f, -0.05037230f, 0.05391903f, -0.03911703f, -0.00622410f, 0.03453726f, 
    -0.03682740f, -0.07223432f, 0.02948954f, 0.03384137f, -0.00413157f, 0.06483964f, -0.00586935f, -0.07279477f, 
    0.04521960f, 0.04949262f, -0.05794062f, -0.01821068f, -0.01704038f, -0.02037771f, 0.01811710f, 0.04549256f, 
    -0.03646684f, 0.02248286f, 0.04876862f, 0.02310732f, -0.04192654f, -0.07215447f, -0.03088264f, -0.07879113f, 
    0.06828261f, -0.01549140f, -0.06143994f, 0.03550880f, 0.05937201f, -0.05681839f, 0.04940033f, -0.00515767f, 
    0.03753799f, 0.02314415f, -0.02464113f, 0.04803280f, 0.05146064f, 0.03699659f, -0.04425690f, -0.01239269f, 
    -0.06566043f, -0.03446619f, -0.04300803f, -0.08000187f, 0.04682341f, -0.02925856f, 0.02059535f, -0.03008912f, 
    -0.01343618f, 0.04172004f, -0.03164815f, -0.02884239f, -0.06784426f, -0.06221846f, -0.07058415f, -0.01418952f, 
    0.01052817f, -0.00960631f, -0.00731088f, 0.01688561f, 0.03084340f, -0.01166046f, -0.05802603f, 0.05632799f, 
    -0.08148918f, -0.01550591f, -0.05339975f, -0.04608287f, -0.02580987f, 0.01186348f, 0.04932470f, -0.03930524f, 
    -0.00853964f, -0.04614665f, -0.00365700f, 0.04824726f, -0.05729299f, -0.05626698f, 0.03262093f, 0.03687211f, 
    -0.04619946f, 0.05807646f, 0.00313790f, -0.01552729f, 0.02055742f, -0.07986096f, 0.04955699f, 0.01311844f, 
    -0.02612748f, 0.04390952f, 0.00269501f, -0.05387096f, -0.01992666f, -0.05350105f, 0.03309807f, -0.05289363f, 
    -0.03471547f, 0.02523714f, -0.04920140f, 0.06640785f, -0.06636342f, -0.00351214f, -0.04480052f, 0.00189954f, 
    -0.05561906f, -0.02215721f, 0.00993356f, 0.01705695f, 0.02272840f, 0.00278470f, -0.03748383f, 0.02548246f, 
    -0.01185238f, -0.04726037f, 0.04478116f, 0.03746180f, 0.01891589f, 0.02394444f, 0.04453467f, -0.06686853f, 
    0.01212424f, -0.05679005f, 0.00335069f, -0.06203403f, -0.07967660f, 0.01034445f, -0.01588416f, 0.03230290f, 
    0.03777697f, 0.00015387f, 0.04501940f, 0.02740171f, 0.04153789f, 0.02879239f, -0.00529479f, -0.03181402f, 
    0.00068526f, 0.03172220f, -0.00960163f, -0.05845838f, -0.03594273f, -0.03144014f, -0.08037291f, -0.00157372f, 
    0.06468778f, 0.00977407f, 0.00107717f, 0.01485561f, -0.03973645f, -0.03000855f, -0.07874729f, -0.05620001f, 
    -0.04842465f, 0.04636594f, -0.02875504f, -0.07322564f, 0.00888634f, 0.00636533f, -0.07542555f, 0.05624513f, 
    -0.00907668f, -0.02447630f, -0.06185982f, 0.02992409f, -0.03727997f, -0.07139716f, -0.03806511f, -0.04585930f, 
    -0.01952635f, -0.01582683f, -0.07123759f, -0.04159508f, 0.04654035f, -0.02459262f, -0.06844854f, -0.07530483f, 
    0.04905502f, -0.01408463f, -0.00107511f, -0.01145181f, 0.03046354f, -0.01452579f, -0.05254876f, -0.01276193f, 
    0.01822079f, -0.07333565f, 0.02568296f, 0.02817067f, -0.04637684f, -0.05689110f, -0.07043848f, -0.03841510f, 
    -0.07309108f, -0.04677060f, 0.06186183f, -0.04572639f, -0.03317141f, -0.05468911f, 0.02783774f, -0.04627344f, 
    -0.05012156f, 0.03949480f, 0.04925593f, -0.00610176f, -0.02304169f, -0.03669292f, 0.02072888f, -0.08075118f, 
    -0.07873905f, 0.05088727f, 0.04529831f, -0.07167953f, -0.01589371f, 0.02052163f, 0.04116194f, -0.00370627f, 
    -0.00189808f, -0.04386072f, -0.05746147f, 0.03290671f, -0.07998551f, 0.04822791f, -0.00092152f, 0.04676057f, 
    -0.07143801f, -0.00073125f, -0.06258795f, -0.02173825f, -0.00582134f, -0.01236483f, -0.00372037f, -0.04434360f, 
    0.03170856f, 0.03960349f, -0.03231701f, -0.00108880f, 0.01763058f, -0.07366374f, 0.01887943f, 0.05847363f, 
    -0.01366789f, 0.01473681f, 0.05698153f, 0.00745466f, -0.02666100f, -0.03012567f, -0.05582787f, 0.04013651f, 
    -0.07617895f, -0.02304429f, -0.00412632f, 0.05247860f, 0.00327762f, 0.05779158f, -0.07148501f, 0.02750743f, 
    0.02469386f, 0.01347073f, 0.01443654f, -0.01877815f, 0.02363609f, 0.01485358f, 0.02648506f, 0.06391595f, 
    0.02195919f, 0.03412175f, -0.07175371f, 0.04174237f, -0.04089143f, 0.03884927f, -0.05429025f, -0.01118339f, 
    -0.00015151f, -0.01719362f, 0.01239548f, 0.00577716f, 0.05236055f, -0.00604372f, -0.07088325f, 0.05208686f, 
    0.03148054f, 0.03274455f, -0.00201929f, -0.03599561f, -0.01738840f, -0.00169188f, -0.07746591f, 0.04804867f, 
    -0.02219503f, -0.07080179f, 0.04128394f, -0.07640276f, -0.03801158f, -0.00033082f, -0.07842277f, -0.05593456f, 
    -0.06091773f, 0.04673749f, -0.02966467f, -0.00501775f, -0.06602678f, 0.03661006f, 0.03032732f, -0.00216344f, 
    -0.08164876f, 0.03224610f, -0.05881675f, -0.07111017f, -0.07626350f, -0.07322287f, 0.01557320f, 0.03478782f, 
    0.07214903f, 0.55357891f, -0.41460231f, -0.38289374f, -0.06939483f, 0.05688799f, 0.20501937f, 0.01193632f, 
    0.01705395f, 0.09331735f, 0.11222658f, -0.01642637f, 0.04020854f, -0.03668239f, -0.23314460f, 0.03882474f, 
    0.01387995f, 0.20064130f, 0.35135585f, 0.17882575f, -0.06406511f, -0.01430643f, 0.02162267f, 0.07520068f, 
    0.08807639f, -0.29820564f, -0.16641013f, -0.09268087f, -0.00064419f, 0.04176986f, -0.11620830f, 0.18319255f, 
    -0.05586719f, 0.13378106f, 0.05007864f, 0.06389101f, -0.00118544f, 0.43726149f, -0.00034740f, -0.05331684f, 
    0.25410500f, 0.18683112f, -0.13653597f, 0.07308738f, -0.05084230f, -0.01501506f, 0.05044989f, -0.09112449f, 
    -0.11334521f, -0.44236428f, 0.17119750f, -0.00539104f, -0.06608615f, 0.09274859f, -0.14841962f, 0.02051624f, 
    0.06259914f, 0.03444998f, 0.06739000f, -0.04545321f, 0.46666676f, 0.30759543f, 0.17170136f, -0.07330058f, 
    0.12221524f, 0.05572862f, -0.01265232f, 0.27795178f, -0.12736943f, 0.00814669f, -0.02954339f, 0.02024286f, 
    -0.22631818f, -0.22225675f, 0.18361607f, 0.03558256f, 0.03100430f, -0.20442913f, -0.43265003f, -0.04944154f, 
    -0.03932305f, -0.05641956f, -0.18513957f, -0.15080686f, 0.55505431f, 0.02447431f, 0.01667881f, -0.03467881f, 
    -0.02805510f, 0.04738565f, -0.09073433f, -0.01682980f, 0.18581085f, -0.12725136f, 0.04493298f, -0.14225683f, 
    -0.12259862f, -0.03243107f, 0.02834486f, 0.33441094f, 0.23854505f, 0.10208162f, -0.15832946f, -0.12699936f, 
    -0.08465669f, -0.17742980f, -0.02946095f, 0.02359820f, -0.32542825f, -0.19841823f, -0.11613631f, 0.03512012f, 
    -0.02332761f, -0.01928871f, -0.06800554f, -0.02258770f, 0.08542678f, 0.17282879f, -0.01348075f, 0.03195587f, 
    0.15294413f, 0.14602812f, 0.06004051f, 0.14302474f, -0.07777034f, 0.03117050f, -0.02075033f, 0.05997756f, 
    0.08079734f, 0.24777059f, -0.16276905f, 0.20939030f, -0.04554363f, -0.05637662f, -0.23530462f, 0.08770292f, 
    -0.02887747f, 0.05601628f, -0.19603615f, -0.25002530f, 0.28762424f, 0.07423393f, -0.13618803f, 0.17944022f, 
    0.65648037f, 0.10578992f, 0.12203237f, 0.35413873f, 0.11700056f, 0.07115521f, -0.02369224f, 0.17225684f, 
    -0.02860829f, 0.08874624f, -0.02965390f, -0.08035941f, -0.19866313f, 0.14902078f, -0.03414247f, 0.00393541f, 
    0.04970091f, 0.21454206f, 0.10025686f, 0.15027994f, -0.06166572f, 0.00754836f, 0.22146228f, 0.06666783f, 
    0.03952414f, -0.06117136f, -0.17601292f, 0.02269617f, 0.02859725f, 0.07549256f, 0.19715610f, -0.07002980f, 
    0.12258465f, -0.17125276f, -0.02135426f, 0.00369278f, 0.08220987f, -0.05708464f, -0.11767741f, 0.07278007f, 
    0.01207589f, -0.03289764f, 0.00657373f, 0.18864143f, 0.22513512f, -0.00682604f, -0.03887681f, 0.05522100f, 
    0.20159309f, -0.32182389f, -0.10336125f, 0.11254562f, -0.18074627f, -0.15629077f, -0.18348819f, 0.11362576f, 
    0.11622502f, -0.14392793f, 0.05963214f, 0.00108653f, 0.16173182f, -0.04321045f, 0.07329254f, -0.01037842f, 
    -0.08832539f, -0.20914699f, -0.29595262f, -0.22019148f, -0.14529772f, -0.11669097f, -0.04015638f, -0.30268574f, 
    -0.11199179f, -0.11992600f, 0.05545683f, -0.35420224f, -0.00498931f, -0.09570272f, -0.13711491f, 0.05791398f, 
    0.15885082f, -0.05414360f, -0.04542883f, 0.00616012f, 0.23250641f, 0.06866083f, -0.15083565f, -0.27824420f, 
    -0.05105356f, -0.13268541f, 0.07626399f, -0.17987487f, 0.16983496f, -0.02531210f, 0.11459047f, 0.15923986f, 
    0.03079563f, 0.13894050f, -0.01530699f, 0.12275164f, -0.08736113f, -0.10702273f, 0.08999157f, 0.06895190f, 
    -0.01748893f, -0.03820878f, -0.08900896f, 0.05704459f, 0.32793406f, 0.22014110f, -0.10715348f, 0.06506900f, 
    -0.19350548f, 0.17459892f, -0.09640221f, -0.26868236f, 0.16977060f, 0.01233083f, -0.12000586f, 0.02193179f, 
    -0.05155960f, 0.17446904f, 0.34998471f, -0.21802130f, 0.00675668f, -0.12013166f, 0.05858234f, -0.13203585f, 
    0.20703638f, 0.25650972f, 0.25498280f, 0.44685498f, 0.10835417f, -0.33770195f, 0.18851975f, 0.33240384f, 
    0.02196303f, 0.13406649f, 0.10492028f, 0.01034887f, 0.22222084f, -0.17611994f, 0.30520025f, 0.24302731f, 
    0.48140576f, -0.00202569f, -0.06064580f, 0.23146144f, -0.09867960f, 0.17280175f, 0.08709962f, -0.00855519f, 
    0.00543943f, 0.14603451f, 0.21359830f, 0.11744773f, -0.12758639f, -0.15926990f, -0.05462043f, 0.03729858f, 
    -0.01516388f, 0.02516596f, 0.12379156f, 0.01919369f, 0.18877693f, 0.22660367f, 0.34052756f, 0.30410537f, 
    0.09624197f, 0.01832406f, -0.19504401f, 0.11830842f, 0.45281529f, 0.07166868f, 0.07068022f, 0.09550740f, 
    -0.10597244f, 0.11105534f, -0.26990971f, 0.13730426f, 0.02933061f, -0.06351475f, 0.50094157f, -0.00245976f, 
    -0.03345595f, -0.01954830f, -0.00689721f, -0.01934248f, 0.01207287f, 0.50227189f, 0.09773132f, 0.01377150f, 
    -0.14955494f, -0.07692856f, 0.04137071f, -0.11572668f, -0.12114734f, 0.03261050f, 0.03681719f, -0.06620853f, 
    -0.06246366f, -0.09641303f, 0.15286329f, 0.18819928f, 0.01551953f, 0.02556073f, 0.10818028f, -0.19125840f, 
    -0.08387629f, 0.08206977f, 0.15438372f, 0.15619448f, 0.03899419f, 0.07292832f, -0.15101822f, -0.01180268f, 
    0.06908315f, -0.30722418f, 0.23681207f, 0.01375698f, -0.12864615f, -0.12175220f, 0.07525829f, 0.15545455f, 
    -0.09852064f, -0.02099851f, 0.07843355f, -0.01015732f, -0.10724471f, 0.44569609f, -0.18477885f, -0.10498024f, 
    -0.02046196f, 0.13001360f, 0.15037616f, 0.03470970f, -0.00099349f, 0.21256837f, -0.05424359f, -0.07321803f, 
    -0.33783308f, 0.11779417f, -0.28296712f, -0.18605916f, 0.09988601f, 0.15085556f, 0.09998829f, 0.12797891f, 
    -0.09095690f, -0.01879843f, 0.07968306f, -0.03988606f, -0.11659785f, -0.26519001f, -0.28921288f, 0.23754349f, 
    0.08675457f, 0.11058734f, 0.16361700f, -0.11483425f, -0.12677366f, 0.14103001f, -0.01238470f, 0.01189818f, 
    -0.32475612f, -0.24107817f, 0.07018942f, 0.00423792f, 0.11904169f, 0.15565956f, 0.03298993f, 0.22646645f, 
    -0.02713688f, 0.19805223f, 0.08223590f, 0.01842819f, -0.19619285f, 0.03130786f, -0.17004116f, 0.22358468f, 
    0.10065828f, 0.29307380f, -0.04285564f, -0.09235445f, 0.03850117f, -0.06339971f, -0.06228965f, -0.11712611f, 
    0.26436505f, -0.04897913f, 0.37096238f, 0.15021454f, 0.06052263f, 0.00754183f, 0.08267496f, 0.02447209f, 
    0.17222655f, -0.01571049f, 0.24943289f, 0.04119541f, 0.36759061f, -0.06083502f, 0.07969589f, 0.03436524f, 
    0.18164387f, 0.07227854f, -0.15961660f, 0.22635850f, -0.06261842f, -0.06531840f, -0.22230603f, -0.04137349f, 
    0.16668195f, -0.02769944f, 0.16281341f, 0.20478016f, -0.01965910f, -0.12304004f, -0.06348071f, 0.17296262f, 
    0.19271484f, 0.00476496f, -0.00958325f, -0.10519593f, 0.48734298f, 0.18180202f, -0.10435090f, 0.16507556f, 
    0.12955312f, -0.04578051f, 0.10030401f, -0.04872160f, -0.00870404f, -0.07832538f, 0.15942855f, -0.28899026f, 
    0.13556747f, -0.12970297f, -0.05097513f, 0.07219909f, 0.39407492f, 0.09255550f, 0.08799105f, 0.11323480f, 
    -0.08268094f, 0.10605898f, -0.01290044f, -0.02477887f, -0.06404170f, 0.14686599f, 0.14766702f, -0.28314567f, 
    -0.20028444f, -0.11128753f, -0.12591289f, -0.18305404f, -0.02835567f, -0.21493405f, -0.26019299f, -0.16756432f, 
    -0.02927186f, 0.05692119f, 0.21895903f, -0.01047586f, -0.02251127f, 0.03605098f, 0.15461655f, 0.03791552f, 
    0.18091030f, 0.23363230f, -0.01679856f, 0.17472595f, 0.04472511f, 0.08512284f, -0.36735240f, 0.22105937f, 
    -0.02346050f, -0.01289533f, 0.25751454f, 0.09467489f, 0.06498999f, 0.24033339f, -0.12043724f, 0.24842067f, 
    0.79112548f, -0.06622814f, 0.10513685f, 0.25549340f, 0.18000568f, 0.22497375f, -0.03856912f, 0.23506862f, 
    -0.09657675f, 0.15886992f, -0.02424664f, -0.18088005f, -0.09603404f, 0.13856156f, 0.21129446f, -0.04922032f, 
    -0.09643099f, -0.08259047f, -0.19480242f, -0.17627379f, -0.19971596f, 0.10432708f, 0.14923257f, 0.13072023f, 
    -0.16458420f, -0.12587741f, 0.02172248f, 0.10990033f, 0.05826208f, 0.11675839f, 0.25229663f, 0.04499438f, 
    0.05114418f, -0.08682392f, -0.15748638f, -0.07628612f, 0.44169176f, 0.32688820f, 0.36701852f, 0.04782736f, 
    -0.11234554f, -0.07520940f, -0.03988812f, 0.19132543f, 0.14022832f, 0.07091451f, -0.00422833f, 0.01070378f, 
    -0.07147043f, 0.00655316f, 0.01266848f, -0.02578027f, -0.07442045f, 0.03280203f, 0.00406910f, 0.00911520f, 
    -0.06694388f, 0.05817673f, 0.00133844f, -0.07677278f, -0.07228876f, -0.06231644f, 0.05153078f, 0.00852595f, 
    0.00587873f, 0.03192873f, 0.01147392f, 0.05115615f, -0.02973945f, 0.01216510f, -0.02691162f, 0.01572627f, 
    -0.00899744f, -0.06275266f, 0.05566992f, 0.05532874f, 0.04757394f, 0.03464657f, -0.03917625f, -0.06133449f, 
    0.00845263f, 0.01285168f, -0.02729202f, -0.02831112f, -0.07319643f, 0.04490881f, -0.07229245f, 0.03446753f, 
    -0.07701471f, 0.05924868f, 0.00635054f, -0.01634191f, 0.02643993f, -0.04525312f, -0.04119417f, -0.04149956f, 
    -0.07889858f, 0.05355511f, 0.01429457f, -0.07028221f, -0.00934349f, -0.05798563f, -0.05984070f, -0.03277740f, 
    -0.07936931f, -0.05894999f, 0.03265385f, 0.03551040f, 0.06354201f, -0.02209927f, -0.00010962f, 0.04355088f, 
    0.05144583f, 0.01545631f, 0.02067914f, 0.05489498f, 0.02713191f, -0.07141443f, 0.00068672f, -0.00329899f, 
    0.02665305f, -0.02817813f, 0.05342030f, 0.04908038f, 0.00337775f, -0.06041310f, -0.01546865f, 0.00189816f, 
    0.04377950f, 0.03043574f, -0.04463139f, -0.06914049f, -0.07151176f, -0.03604180f, 0.00280939f, -0.02935029f, 
    -0.03231430f, -0.06137417f, -0.05429081f, 0.03325585f, -0.00761107f, -0.03612368f, 0.04651592f, -0.05514324f, 
    -0.04331413f, 0.04319441f, -0.07371154f, -0.06718483f, -0.05903214f, -0.02690229f, 0.01028560f, 0.05577280f, 
    -0.01264728f, 0.01962602f, -0.05853104f, 0.05642573f, -0.02395044f, 0.03520828f, 0.01355932f, 0.03102514f, 
    -0.02530589f, -0.06544476f, 0.05810644f, -0.05828645f, 0.05077239f, -0.02128595f, 0.05349540f, -0.03863993f, 
    -0.00783194f, -0.05806898f, -0.07146082f, 0.00664826f, -0.07548159f, -0.03885112f, -0.02903778f, -0.02192117f, 
    0.00772806f, -0.05397711f, -0.04273716f, -0.08252831f, -0.04953052f, -0.08219536f, -0.05379134f, 0.00265943f, 
    -0.01826581f, 0.03156546f, 0.01890879f, 0.02848409f, 0.03161989f, 0.00113956f, -0.01255419f, 0.01382839f, 
    -0.01107590f, -0.02163178f, 0.00132109f, -0.05205886f, -0.07638717f, 0.01059100f, 0.03584747f, -0.04439125f, 
    -0.00545434f, -0.03538708f, 0.02729584f, -0.05229928f, 0.01974753f, 0.04470916f, 0.00195178f, 0.05133046f, 
    -0.01814116f, -0.06347938f, 0.05424448f, 0.02371862f, 0.02414825f, 0.04755736f, -0.08108862f, 0.00250659f, 
    -0.00968426f, -0.07696991f, 0.04090086f, 0.05701182f, 0.00141384f, 0.00421439f, -0.06413005f, 0.01881844f, 
    -0.01949098f, 0.03372200f, 0.05646420f, -0.06210070f, -0.00015800f, -0.06689293f, 0.03625190f, 0.00122251f, 
    0.02648767f, 0.03083526f, 0.04236268f, 0.05837303f, -0.07101024f, 0.01334190f, -0.07458527f, -0.05276879f, 
    0.17688087f, -0.09000435f, 0.32013834f, 0.02650854f, 0.03041144f, 0.10417560f, 0.10379405f, -0.26648569f, 
    0.02925942f, -0.27411473f, -0.02716463f, 0.17873751f, -0.02606774f, 0.02221697f, 0.27227142f, 0.03227281f, 
    0.13366807f, 0.09718878f, 0.05900643f, -0.04136028f, -0.14353248f, -0.05889171f, -0.05465825f, 0.12038390f, 
    -0.39574191f, -0.23164450f, -0.11248373f, -0.18299451f, -0.16128545f, 0.10783920f, 0.03033355f, -0.02281800f, 
    -0.15067397f, -0.00475430f, -0.03151486f, 0.02417824f, 0.53502798f, 0.19076295f, 0.34001085f, 0.26681796f, 
    0.27791297f, -0.04500256f, 0.21204488f, 0.38974699f, 0.00103560f, 0.09593493f, 0.04599777f, -0.14278091f, 
    0.14990202f, -0.02074331f, -0.13123471f, -0.00097115f, 0.10215149f, 0.16767088f, 0.02502303f, 0.10795456f, 
    0.07866737f, 0.33684194f, 0.04862952f, 0.23676896f, -0.51678246f, 0.17394941f, 0.05382352f, 0.03560385f, 
    0.11471929f, -0.24582975f, 0.27117997f, 0.22263359f, -0.17429468f, -0.00945528f, -0.01467907f, -0.03617081f, 
    0.28793320f, -0.23249757f, 0.02684052f, 0.07808119f, 0.10410268f, 0.13394873f, -0.00587415f, 0.20615283f, 
    -0.15991023f, -0.17293702f, 0.01306209f, -0.33873984f, -0.07995560f, -0.04009619f, -0.11023874f, 0.01065988f, 
    -0.00059204f, 0.06254997f, 0.21158652f, 0.09045516f, -0.05210987f, 0.02637574f, 0.05253544f, -0.11807869f, 
    -0.35060149f, 0.06816745f, -0.13485478f, 0.01231854f, 0.17698266f, -0.17929894f, -0.05072058f, 0.00014026f, 
    -0.09588104f, -0.22418162f, -0.09763844f, 0.08539788f, 0.00325530f, 0.03137524f, -0.11512250f, -0.01926854f, 
    -0.01914166f, -0.10584009f, -0.20138311f, -0.05163416f, -0.08167814f, -0.08806315f, 0.06885105f, -0.13591221f, 
    -0.39000052f, -0.13168088f, -0.29341689f, 0.43844849f, -0.14488871f, 0.10413109f, -0.03597824f, -0.00902877f, 
    0.11868203f, 0.04662708f, 0.05479036f, 0.02091530f, 0.11085753f, -0.58944541f, -0.50137484f, 0.19807249f, 
    0.00175014f, 0.15996625f, 0.07160994f, 0.23735121f, 0.26856324f, -0.19986801f, -0.00165005f, 0.00162676f, 
    -0.62244409f, 0.05949910f, -0.18965517f, -0.16258141f, 0.08854345f, -0.02502175f, 0.14215809f, -0.06027989f, 
    0.09001707f, 0.13883419f, 0.15966478f, 0.05488923f, 0.26258880f, 0.29059094f, 0.23019493f, 0.19886975f, 
    0.22908315f, 0.15255372f, 0.02150522f, -0.08950362f, -0.18422401f, -0.04701246f, -0.07269742f, 0.04003454f, 
    0.03977115f, 0.04267000f, -0.11881457f, 0.01709264f, -0.08505409f, 0.07888699f, 0.12034769f, -0.06692325f, 
    0.11795975f, -0.25232872f, -0.06519233f, 0.06291821f, 0.09183361f, -0.12171440f, 0.07147811f, 0.25236437f, 
    0.16533394f, 0.04549456f, 0.07271937f, -0.00433440f, 0.29052916f, 0.01174434f, 0.25828192f, 0.50657731f, 
    0.09761504f, 0.14043027f, 0.21317525f, 0.30788651f, 0.23079108f, 0.06159657f, 0.11061505f, 0.17393599f, 
    0.04557449f, 0.15771501f, 0.09824902f, -0.03872239f, 0.07305571f, -0.14038837f, -0.09149854f, 0.12304761f, 
    0.02141819f, 0.11525535f, -0.09910446f, 0.28583327f, -0.17330725f, -0.08773593f, -0.13249502f, -0.19710481f, 
    0.29494855f, 0.04815821f, -0.04383820f, 0.36624551f, 0.07700627f, -0.00515231f, -0.05124991f, 0.02158000f, 
    0.19674957f, -0.03776511f, -0.04159444f, 0.06953753f, -0.14170744f, -0.04890687f, 0.19980286f, -0.21091142f, 
    -0.00323946f, -0.01304056f, 0.06881320f, -0.07458118f, 0.04956074f, 0.09592003f, -0.04314149f, 0.18188661f, 
    -0.15663838f, 0.42557892f, -0.09708028f, 0.36480936f, -0.01463563f, -0.01149619f, -0.03803930f, -0.14198042f, 
    -0.21167541f, -0.16333392f, -0.19471374f, -0.06147954f, 0.15132156f, -0.04100931f, -0.26915655f, -0.11992238f, 
    -0.16701482f, 0.09839360f, 0.12261586f, -0.15711862f, -0.14674182f, -0.10983437f, 0.01463823f, -0.16574843f, 
    -0.26221573f, -0.07671160f, -0.05715451f, 0.17621325f, -0.09743261f, -0.02481526f, 0.14233781f, 0.19613370f, 
    -0.03725264f, 0.16407867f, 0.06564889f, 0.24696718f, -0.16539350f, -0.02081168f, -0.12129750f, 0.16258323f, 
    0.03643952f, 0.27582145f, 0.16001588f, 0.13074201f, -0.07030083f, 0.06423450f, -0.05437608f, 0.22453757f, 
    0.33788672f, 0.41959256f, -0.26618129f, 0.05168519f, -0.02295402f, -0.04916374f, 0.15961401f, 0.08361360f, 
    0.06012028f, 0.13830458f, 0.09778120f, 0.03288557f, 0.20825487f, 0.20118411f, 0.13957259f, 0.00645358f, 
    -0.06194949f, 0.02434928f, 0.20005468f, 0.00836580f, 0.13851249f, 0.19981514f, 0.15364704f, 0.42739338f, 
    0.15107088f, 0.07055199f, -0.27501455f, -0.14465295f, -0.04428286f, 0.08448216f, -0.13398863f, -0.22728901f, 
    -0.13400421f, -0.19575986f, -0.16196865f, -0.46803224f, -0.32477295f, -0.27942768f, -0.03733882f, 0.64778328f, 
    -0.20035683f, -0.20294540f, -0.00363950f, 0.45098665f, -0.13597964f, 0.17157698f, 0.05269834f, 0.07108807f, 
    0.16018790f, -0.31782469f, -0.09850935f, -0.14902744f, -0.01212683f, 0.14287640f, 0.02629107f, 0.12094306f, 
    0.09532008f, -0.06120090f, -0.00446042f, 0.12765776f, 0.24290818f, 0.01823443f, 0.49751967f, -0.21391964f, 
    -0.07579958f, -0.09030235f, -0.36693835f, 0.03595058f, -0.12866908f, -0.23555566f, -0.20734574f, -0.57050300f, 
    0.22874087f, 0.07992961f, -0.23047470f, 0.08312643f, 0.08896136f, -0.12949826f, 0.06965344f, 0.20627685f, 
    0.09529772f, 0.30341741f, -0.01556103f, -0.08768976f, 0.14416207f, 0.02952022f, 0.41545236f, -0.17784494f, 
    -0.07297795f, 0.16543786f, -0.09723552f, -0.13392967f, -0.02137862f, 0.15676829f, -0.04141314f, -0.17502441f, 
    0.36370960f, -0.12951036f, -0.00043917f, -0.17763591f, 0.11712659f, 0.07317942f, -0.01382959f, 0.11967778f, 
    0.02627479f, -0.14937298f, 0.07644618f, -0.15297687f, -0.02359251f, 0.10106689f, -0.11058497f, -0.11480753f, 
    0.06461794f, 0.18551847f, 0.06968489f, 0.02643791f, 0.03016191f, 0.00233140f, 0.04208738f, 0.06018354f, 
    0.10140304f, 0.02327345f, -0.27393237f, 0.02232631f, 0.22805820f, 0.13857226f, 0.16340475f, -0.02751129f, 
    -0.09043150f, -0.07662150f, -0.12942924f, -0.15747020f, 0.12923101f, -0.00333266f, 0.28343081f, 0.31166312f, 
    -0.03678257f, 0.24690329f, 0.42867622f, -0.05824853f, -0.07428278f, -0.03231585f, 0.02628943f, 0.04603046f, 
    -0.91239357f, 0.27415067f, 0.11443391f, 0.09764974f, 0.17658012f, -0.23143905f, -0.10454071f, -0.16848691f, 
    0.20391822f, -0.10298656f, 0.12504140f, 0.07296869f, 0.23394792f, 0.03591633f, 0.25020301f, 0.12916809f, 
    0.17748654f, 0.05585160f, -0.13479103f, 0.29658380f, -0.07568077f, 0.18773142f, -0.10339392f, 0.08880622f, 
    -0.60245401f, -0.15341827f, -0.15368117f, 0.38489455f, -0.16365500f, 0.28244177f, -0.07139634f, 0.00132137f, 
    0.23519033f, 0.08246952f, 0.08028709f, 0.14382018f, 0.32203653f, 0.45708802f, -0.11419611f, -0.08737562f, 
    0.09363871f, 0.04602234f, 0.25065497f, 0.12429772f, -0.15351632f, 0.00364759f, 0.05190705f, 0.06240102f, 
    -0.01670712f, -0.33634949f, 0.19342607f, -0.21117829f, 0.11431571f, 0.16193449f, 0.09486503f, 0.12966222f, 
    0.06595258f, -0.25062743f, -0.22536919f, 0.09307735f, -0.23182814f, -0.09150302f, -0.01873900f, -0.21255577f, 
    -0.13284442f, 0.10432666f, 0.17616458f, -0.16863433f, -0.07220729f, -0.00864235f, -0.00511409f, -0.01628543f, 
    -0.13885297f, -0.37597007f, 0.17872997f, -0.03161275f, -0.07665483f, -0.04667139f, -0.08286965f, -0.07039678f, 
    0.13758862f, 0.03009785f, 0.29900229f, 0.12699941f, -0.81165433f, 0.25495780f, -0.06369536f, 0.16005334f, 
    -0.04334909f, 0.14042272f, 0.23356740f, -0.13374238f, -0.01993698f, 0.00184074f, 0.04337052f, 0.14255387f, 
    0.15980525f, -0.03430682f, 0.05802061f, 0.29839641f, 0.00917477f, 0.11984731f, 0.06456788f, 0.08801619f, 
    0.02091311f, 0.05927844f, 0.04624772f, 0.08903844f, -0.56564456f, 0.15193275f, -0.05495462f, 0.30927083f, 
    0.12944549f, -0.14202735f, -0.12851666f, 0.01946171f, -0.08979049f, -0.00021376f, 0.15945701f, -0.00980415f, 
    -0.14469478f, -0.23243907f, -0.19508302f, 0.03267941f, 0.07568821f, 0.28711215f, -0.08697721f, 0.03395770f, 
    -0.12195079f, -0.16769978f, -0.19887355f, 0.01454337f, -0.05072682f, 0.03407282f, -0.14482339f, -0.11975089f, 
    -0.15896152f, 0.03505786f, -0.15762293f, -0.02576315f, 0.20506221f, 0.00062779f, 0.02013656f, 0.26921451f, 
    0.22739224f, 0.01482393f, 0.28958327f, 0.15026890f, -0.03284461f, -0.27174956f, 0.32204133f, 0.05944912f, 
    0.21944275f, 0.06214239f, -0.09661711f, 0.01130500f, 0.17930348f, 0.51587546f, 0.29365346f, -0.34393486f, 
    -0.03492942f, 0.17995097f, 0.41147429f, 0.34667534f, -0.00162611f, 0.00550132f, 0.06359024f, -0.02571894f, 
    0.04010155f, -0.11356866f, -0.00683699f, -0.20476352f, -0.12138134f, 0.13392223f, 0.05893718f, 0.02755571f, 
    0.01380903f, -0.04056567f, -0.00692564f, -0.12401997f, 0.06785067f, 0.37035489f, 0.51836067f, -0.36303777f, 
    0.33152768f, -0.09274887f, -0.14657898f, 0.22115490f, -0.01230775f, 0.09139210f, 0.18875508f, 0.06301809f, 
    0.18916197f, 0.02789088f, -0.20662078f, -0.09568413f, -0.09611502f, 0.17731011f, -0.08500613f, -0.01574367f, 
    -0.12042874f, 0.20310643f, -0.25526476f, 0.25228369f, -0.34298068f, 0.35982099f, -0.03162712f, -0.28937799f, 
    -0.04668739f, -0.05786169f, 0.04658281f, 0.13250022f, -0.01764257f, -0.08410620f, 0.02858078f, -0.00693961f, 
    0.02208395f, 0.04068593f, 0.19135416f, -0.30353564f, 0.15874101f, 0.23545209f, -0.13335586f, -0.05743295f, 
    0.09739079f, -0.08078619f, 0.05058105f, -0.03087730f, -0.03094029f, -0.42903128f, 0.22972952f, -0.16298762f, 
    -0.07317235f, -0.05482239f, -0.05613058f, 0.23673174f, 0.06227000f, -0.12433741f, 0.02479478f, 0.19797087f, 
    0.16425778f, 0.33729717f, 0.24840428f, 0.13994347f, -0.13096081f, -0.03562928f, -0.32155132f, -0.09030222f, 
    0.22384906f, -0.11103477f, 0.03116852f, -0.15661296f, 0.13296038f, -0.05991338f, 0.03664055f, 0.32652795f, 
    -0.02141076f, 0.01291818f, 0.02272853f, -0.04172740f, 0.04776108f, -0.09141865f, 0.01018472f, 0.19658329f, 
    -0.05463132f, 0.05011838f, -0.04558818f, -0.23539095f, -0.08527308f, 0.05647933f, -0.12045987f, 0.03310857f, 
    -0.02734701f, -0.09094005f, -0.36283836f, -0.12977566f, 0.37986833f, -0.23464414f, 0.27848139f, -0.26496059f, 
    -0.01416770f, 0.00482835f, 0.08742239f, -0.05314184f, 0.14255798f, -0.13139646f, -0.09960429f, 0.08238541f, 
    -0.44070348f, 0.47516668f, -0.26512784f, -0.34836477f, -0.05243044f, 0.00745007f, -0.09117358f, 0.12203689f, 
    0.09836308f, 0.05103283f, -0.11319733f, -0.00353099f, 0.13702150f, 0.29657859f, 0.20550126f, 0.13206637f, 
    0.10722037f, -0.07419690f, -0.22003080f, 0.19583748f, -0.03137612f, -0.13097285f, -0.12901397f, -0.01485124f, 
    0.30166042f, 0.04732691f, -0.20239286f, -0.13379170f, 0.02891591f, -0.19136968f, 0.18129629f, 0.02313893f, 
    0.06975566f, -0.07993203f, 0.08257283f, -0.11675055f, 0.18277283f, 0.03448251f, -0.13406873f, 0.03428647f, 
    0.08057518f, 0.09000900f, 0.16669554f, 0.00591489f, 0.17778359f, 0.03227494f, -0.05877560f, 0.01802911f, 
    0.13700432f, 0.47707197f, 0.31564024f, 0.32028076f, 0.15927903f, -0.02762434f, 0.19406857f, 0.13259830f, 
    -0.13914321f, 0.08404972f, -0.10124945f, 0.04093063f, 0.11322011f, 0.30433038f, 0.38684484f, 0.31730559f, 
    -0.09352048f, 0.07987162f, 0.08578655f, 0.29197514f, 0.09661658f, 0.02479204f, 0.01890916f, 0.05968342f, 
    0.34682488f, 0.44929823f, 0.36800417f, 0.39048824f, 0.07425193f, 0.13081801f, 0.06514803f, 0.13968866f, 
    0.31714702f, -0.03248049f, -0.00285509f, 0.06329747f, 0.05531441f, 0.13479413f, 0.38469741f, 0.31035447f, 
    -0.12232303f, -0.25274989f, 0.01936550f, -0.05803895f, -0.08823243f, 0.01375553f, -0.07113969f, -0.00952642f, 
    -0.22626361f, 0.02901483f, -0.43202442f, -0.19534397f, 0.04495067f, -0.03799268f, 0.13635434f, 0.05142790f, 
    0.20660515f, 0.25624016f, -0.01943471f, -0.01980655f, -0.11514881f, -0.05540311f, 0.28769600f, 0.17326683f, 
    -0.07993633f, -0.23298177f, 0.06122246f, -0.07296119f, -0.05802289f, -0.08862407f, 0.10193732f, -0.05317468f, 
    -0.29130077f, 0.12514870f, -0.25245589f, 0.02211190f, -0.03066346f, 0.03438460f, -0.01416699f, -0.09747252f, 
    0.04236999f, -0.02288999f, -0.18380661f, -0.14943892f, -0.24710400f, 0.36497849f, 0.21713695f, 0.03253014f, 
    -0.17269109f, -0.02467308f, -0.19304381f, 0.26801157f, -0.24069443f, -0.00491224f, 0.03201531f, 0.01557198f, 
    -0.25409120f, 0.02603352f, 0.10657334f, 0.09051022f, -0.02006394f, 0.01720838f, -0.08827116f, -0.10838535f, 
    -0.03192300f, -0.10752399f, 0.01621958f, -0.03140309f, -0.09798940f, -0.29158056f, -0.06850579f, 0.00688442f, 
    -0.03383879f, 0.08564287f, -0.11659624f, -0.06902672f, 0.18765725f, 0.11868837f, 0.11474922f, 0.14649874f, 
    0.25279340f, -0.01330830f, -0.04970171f, -0.32907367f, 0.11922678f, 0.10798789f, 0.00220823f, -0.20924115f, 
    0.07986496f, -0.02409496f, 0.26502514f, 0.06115917f, -0.06893859f, 0.03709735f, 0.64449757f, -0.43092284f, 
    0.09705110f, 0.04789540f, -0.04664263f, -0.06548455f, 0.08244013f, -0.21895088f, -0.02950502f, -0.02483212f, 
    -0.04688169f, 0.06992196f, -0.01553116f, 0.01352006f, 0.27282739f, -0.00499510f, 0.09580050f, 0.17120768f, 
    -0.00741602f, 0.09824943f, -0.04580555f, 0.07915305f, 0.03121651f, -0.20366667f, -0.29353222f, 0.38362154f, 
    0.07204603f, 0.03519560f, 0.03374403f, 0.03456255f, 0.27452239f, -0.13480279f, -0.05336458f, -0.07771838f, 
    -0.01413008f, 0.23094705f, -0.06039842f, 0.09639888f, 0.16624159f, 0.01256816f, -0.02183698f, 0.07107476f, 
    0.07369976f, 0.05588762f, 0.08791567f, -0.07706751f, -0.10549071f, -0.22771072f, -0.23052935f, -0.06063873f, 
    0.21091698f, -0.07132693f, -0.10557258f, -0.04871280f, -0.10688961f, -0.13930309f, -0.14398088f, 0.06369463f, 
    0.42967024f, -0.01651703f, 0.19358847f, 0.05896384f, -0.04942447f, -0.00312083f, -0.23572668f, 0.26196644f, 
    0.07536079f, 0.18942413f, 0.03149731f, 0.09768069f, 0.06539545f, 0.05295323f, -0.09326708f, -0.05564705f, 
    0.00581139f, -0.09006584f, -0.30779546f, 0.19005971f, -0.14228606f, -0.24184111f, -0.09490216f, -0.23900799f, 
    0.38822728f, 0.17846026f, -0.14635301f, 0.18209445f, 0.00542585f, -0.02020001f, 0.00879669f, 0.14131604f, 
    0.22128759f, -0.20188440f, -0.12538691f, -0.06473299f, 0.25653335f, -0.13891339f, 0.14339316f, 0.11816473f, 
    -0.10576352f, 0.05515502f, 0.09464789f, -0.00812957f, 0.00410681f, 0.04477934f, -0.01622950f, 0.17004098f, 
    -0.55722731f, 0.17920612f, -0.45118126f, 0.11055975f, 0.24287233f, -0.00689390f, -0.18294607f, -0.19238323f, 
    0.05565948f, -0.48324168f, -0.14109649f, -0.13565370f, 0.00430127f, -0.08965813f, -0.13471229f, -0.02399391f, 
    -0.10218955f, 0.06670193f, 0.11743993f, -0.16492240f, 0.03219357f, -0.00205600f, -0.07886710f, -0.06248216f, 
    -0.48884359f, 0.30589458f, -0.18324424f, 0.09488230f, -0.05022832f, -0.07444429f, 0.20738988f, -0.19431376f, 
    0.13936964f, 0.15246442f, 0.13528675f, 0.44962212f, -0.10707474f, 0.09833065f, -0.08249334f, -0.07539898f, 
    0.09587494f, 0.37900162f, 0.13997580f, 0.10339761f, 0.20840646f, 0.16155152f, 0.13642497f, 0.32041308f, 
    -0.06476153f, 0.04715459f, 0.13197520f, 0.00668470f, -0.16845636f, 0.17373113f, 0.02754459f, -0.05836196f, 
    0.09782910f, 0.07381160f, -0.02458347f, 0.34219846f, -0.17416139f, -0.21101999f, -0.20889135f, 0.08212132f, 
    0.10703754f, 0.22064966f, 0.22511780f, -0.01236397f, 0.44048151f, 0.49858022f, 0.37872967f, 0.44341967f, 
    -0.03186892f, 0.12643205f, 0.09475031f, 0.26800698f, 0.09757739f, -0.23876274f, -0.20353298f, -0.34214285f, 
    -0.22784810f, -0.26415733f, -0.29178202f, -0.23048250f, -0.53030115f, 0.14275289f, 0.28521603f, 0.03901587f, 
    0.29811263f, 0.05853445f, 0.21174948f, -0.05176934f, 0.19401161f, 0.19593437f, 0.10706920f, 0.08832798f, 
    -0.12076911f, 0.01389425f, -0.02102829f, 0.30032995f, 0.09842002f, 0.08639170f, 0.19587560f, 0.06903072f, 
    0.03895275f, 0.02120746f, 0.21522938f, 0.40372047f, -0.35573331f, -0.18483184f, 0.08098779f, 0.40107927f, 
    0.39680126f, 0.08417594f, -0.01504954f, 0.01634061f, -0.15426399f, -0.20692706f, -0.32133719f, -0.65538800f, 
    0.12559061f, -0.02227546f, 0.04174205f, 0.18590319f, -0.00586294f, 0.08115156f, -0.14426839f, 0.18888484f, 
    0.01872581f, 0.16609019f, 0.08026924f, 0.23016883f, -0.15304703f, 0.02664368f, -0.01587763f, -0.12392969f, 
    0.06915949f, 0.03612847f, -0.29201400f, -0.38830772f, 0.06305370f, -0.01006151f, -0.14970039f, -0.00401552f, 
    -0.10435791f, 0.02784234f, 0.08461764f, 0.31406397f, 0.10617660f, 0.11369897f, -0.06255894f, -0.17534830f, 
    0.04615408f, 0.21112566f, -0.09717518f, 0.00468964f, -0.25832292f, -0.10980356f, 0.14712320f, 0.14252366f, 
    0.02390921f, -0.04880790f, -0.12225563f, 0.10022457f, 0.07487777f, -0.00963342f, 0.08535080f, 0.08166116f, 
    -0.02361991f, 0.17756878f, 0.23795328f, 0.26093224f, -0.09985141f, -0.19729066f, 0.18347862f, -0.12268301f, 
    0.08405598f, 0.16692232f, -0.06418119f, -0.07057306f, 0.07841087f, -0.30421379f, -0.06869373f, 0.36953184f, 
    -0.04302632f, 0.01057564f, 0.05193765f, 0.04659133f, -0.01780405f, -0.14350323f, -0.14490283f, 0.21298717f, 
    -0.26695129f, 0.15321501f, 0.02727329f, -0.23963812f, 0.07073329f, 0.04289893f, -0.14707905f, 0.18259421f, 
    0.08963569f, 0.10979768f, 0.08256359f, 0.08250505f, -0.44462740f, -0.41331077f, 0.07330482f, 0.39151427f, 
    -0.03399150f, -0.18566199f, 0.20745434f, -0.06928113f, 0.03607178f, -0.08202174f, 0.05224271f, -0.06883097f, 
    -0.00042569f, 0.28758597f, -0.19761230f, 0.00562027f, -0.09707256f, -0.17335196f, 0.26342583f, -0.01424789f, 
    -0.17217505f, 0.01906363f, -0.06476129f, -0.08030505f, -0.37603846f, 0.05600981f, 0.30198631f, -0.03138312f, 
    -0.10882627f, -0.01189569f, -0.04279977f, 0.09815555f, -0.05835184f, 0.28436136f, -0.01465271f, -0.05895608f, 
    -0.40393588f, -0.01435858f, 0.16762918f, 0.09309561f, -0.19744645f, -0.11435764f, 0.04829564f, 0.09658385f, 
    -0.05258141f, -0.00082479f, -0.04228713f, 0.30099043f, 0.08216727f, -0.00521752f, -0.05538800f, -0.10184419f, 
    -0.02468676f, 0.00328211f, 0.05942369f, 0.02785098f, 0.09927289f, 0.02413225f, 0.08516514f, 0.05139393f, 
    -0.01611816f, 0.04504020f, 0.18614677f, 0.03362871f, 0.05416378f, -0.03988507f, 0.00277115f, -0.08156964f, 
    0.06850122f, -0.13363442f, 0.33611029f, 0.18237007f, -0.13634749f, 0.28161827f, 0.03459218f, -0.07108034f, 
    0.04187074f, 0.01091760f, -0.00863734f, 0.00304172f, -0.10804258f, -0.19974132f, 0.07793824f, -0.06903200f, 
    -0.25284454f, -0.05533348f, 0.15612936f, 0.16392393f, -0.01616084f, -0.08889218f, 0.25354472f, -0.03383414f, 
    0.08248514f, 0.09437829f, 0.12464593f, 0.04412910f, -0.09563284f, -0.03478280f, -0.05266940f, 0.03100709f, 
    0.21443248f, 0.07589772f, 0.26348528f, 0.09171899f, 0.12668289f, 0.00913950f, -0.02965458f, -0.01160156f, 
    -0.10564830f, 0.31444868f, 0.22559653f, 0.00713152f, -0.09104127f, -0.11805595f, -0.06787500f, -0.02029392f, 
    0.05801656f, 0.18520577f, 0.11237637f, -0.00230426f, 0.10527345f, -0.26707420f, -0.17638317f, 0.27335772f, 
    0.08519142f, -0.00564897f, -0.05113267f, -0.02909482f, -0.03327584f, 0.06246154f, 0.02724340f, 0.08818492f, 
    0.32279846f, 0.15745819f, 0.22112206f, -0.12256320f, 0.04834045f, 0.05600244f, 0.03358267f, 0.16548860f, 
    0.10010953f, 0.20195414f, -0.05705098f, -0.05647409f, 0.05785702f, 0.16366412f, 0.03123165f, -0.36997852f, 
    0.09403590f, 0.12416964f, 0.26607385f, 0.31371489f, -0.00805806f, -0.19042395f, -0.03752926f, 0.19628562f, 
    0.41732696f, 0.44518712f, -0.16725338f, -0.11418898f, -0.07124384f, -0.09044933f, 0.03202952f, -0.04092732f, 
    0.03831267f, -0.01605094f, -0.07158072f, -0.03200631f, 0.23579979f, 0.14962785f, 0.16878767f, -0.29434663f, 
    0.20513678f, 0.04205049f, 0.26607820f, 0.13356836f, 0.01648543f, 0.00157284f, 0.00556021f, 0.06046730f, 
    -0.00105653f, 0.21655624f, 0.06229964f, -0.45701706f, -0.04082659f, -0.19790466f, 0.04297754f, -0.07235959f, 
    -0.00202320f, 0.29391694f, -0.11549122f, -0.04993016f, -0.23145391f, 0.08748021f, -0.16270566f, -0.13019766f, 
    0.07105258f, 0.22673616f, -0.00878156f, 0.18344164f, -0.08707156f, -0.14355382f, 0.12703705f, 0.10253175f, 
    0.07910870f, 0.05144170f, -0.18671396f, -0.15787789f, -0.08589491f, -0.05931483f, 0.01876955f, 0.01832293f, 
    0.14482473f, -0.01802408f, 0.06138185f, 0.15977320f, 0.10214450f, -0.06120798f, 0.11646525f, -0.21719162f, 
    -0.06033181f, 0.09598429f, -0.08063459f, 0.16738586f, 0.01990677f, 0.10449588f, -0.02752089f, 0.17968912f, 
    0.25097826f, -0.06175742f, -0.03333293f, -0.37323770f, -0.19108440f, 0.04400841f, -0.04855155f, 0.08050146f, 
    0.16920544f, -0.22844218f, -0.10276137f, 0.02019187f, 0.04804467f, -0.18205184f, 0.06197437f, 0.24468321f, 
    0.11564098f, 0.17343903f, 0.13667187f, 0.05877895f, -0.07430813f, 0.10572357f, 0.18948981f, 0.04771346f, 
    0.16761327f, -0.27508372f, 0.35030499f, -0.21334708f, -0.05386373f, 0.02251335f, -0.23685098f, -0.12919116f, 
    0.10911603f, 0.03329918f, 0.08582409f, -0.07417688f, 0.18179755f, -0.10499015f, 0.38874924f, -0.71579289f, 
    0.06867276f, -0.13927452f, -0.06843266f, 0.07286064f, 0.03642128f, -0.20197767f, 0.20170523f, -0.19387792f, 
    -0.28932190f, 0.19377764f, -0.13289300f, -0.38687402f, -0.12291085f, 0.05045178f, 0.15692915f, 0.20870370f, 
    0.22614601f, 0.01840133f, 0.00693896f, 0.09792279f, -0.29195666f, -0.21687496f, -0.93813598f, 0.19619986f, 
    0.20890760f, 0.13113602f, 0.34592798f, 0.13729359f, 0.16397484f, -0.09340684f, -0.25224686f, -0.04997802f, 
    0.15029304f, 0.17117797f, -0.11978151f, -0.10917566f, 0.15869476f, 0.16331786f, -0.14905463f, 0.07286833f, 
    0.05707639f, 0.10941079f, 0.12006886f, 0.00091242f, -0.22389236f, -0.03435351f, 0.21352585f, 0.13357976f, 
    -0.13278194f, 0.00817720f, -0.06758392f, -0.17382041f, 0.19125810f, -0.11930256f, 0.26979890f, 0.09223851f, 
    -0.29155910f, -0.05789706f, 0.05031357f, -0.12742499f, -0.00017356f, -0.00043111f, -0.09871421f, 0.02750639f, 
    0.24386518f, 0.15523310f, 0.08036603f, -0.02256664f, -0.36197585f, -0.10257861f, 0.03063286f, 0.09580142f, 
    0.12974651f, -0.01259350f, 0.09667886f, 0.11625366f, -0.03657191f, -0.12567799f, -0.07052468f, 0.08211731f, 
    0.13908994f, 0.30767369f, 0.16133717f, -0.15042977f, 0.00564600f, -0.22759412f, -0.04473579f, 0.01864481f, 
    0.14905363f, -0.20190623f, -0.01534533f, -0.01671436f, -0.18775921f, -0.28947666f, -0.29992604f, 0.30493891f, 
    -0.03693535f, 0.23650049f, 0.06094751f, -0.09426297f, 0.15638632f, 0.07249734f, 0.03640560f, 0.16502587f, 
    0.12879854f, 0.24504572f, -0.03458654f, -0.20799559f, 0.18928614f, -0.23094380f, 0.10851548f, -0.05687090f, 
    -0.04382378f, 0.05844836f, -0.08235922f, -0.10020504f, -0.50351298f, -0.53935659f, -0.20223789f, 0.20269589f, 
    -0.04122945f, 0.06525365f, -0.09978563f, -0.01409311f, -0.00852855f, -0.10767967f, 0.02191897f, 0.05037604f, 
    0.20381002f, 0.30323935f, -0.45447788f, -0.08145695f, 0.03034361f, -0.04840558f, 0.20185816f, -0.07579415f, 
    0.16018358f, 0.15666898f, 0.16531092f, 0.19135077f, -0.34322703f, 0.02402796f, 0.41917524f, -0.11776343f, 
    0.12871915f, 0.02705335f, -0.29626229f, -0.09610493f, 0.19550340f, 0.22550535f, 0.12191491f, 0.00326096f, 
    -0.17738250f, -0.25237679f, 0.46589348f, -0.08249617f, -0.06167935f, 0.07213186f, 0.00657051f, 0.02991733f, 
    0.13639039f, 0.01842685f, -0.07714497f, 0.07697715f, -0.07021904f, -0.31553271f, -0.09493238f, -0.17662129f, 
    -0.05021207f, 0.12008985f, 0.13093889f, -0.08432273f, 0.24617884f, 0.20506138f, 0.21886829f, 0.28674027f, 
    0.25055954f, 0.17727610f, 0.50039130f, 0.10211767f, -0.00435402f, -0.16974682f, -0.21412024f, -0.09559752f, 
    0.05912079f, -0.17818144f, 0.04712311f, 0.02531845f, 0.20568609f, 0.40910092f, -0.09668924f, -0.62049335f, 
    0.13459764f, 0.15824795f, 0.10484649f, -0.11656287f, 0.16955981f, 0.05132937f, 0.13624027f, 0.13038765f, 
    -0.02735904f, 0.08389258f, 0.35802433f, 0.24469572f, 0.10959247f, -0.09562525f, -0.04120111f, 0.06641468f, 
    0.18172649f, 0.06077161f, 0.07000149f, 0.26502442f, -0.49042648f, -0.46555313f, -0.44518200f, -0.06659888f, 
    0.06692478f, 0.04480572f, 0.17200132f, 0.13537437f, 0.16186546f, -0.04763643f, -0.16086689f, -0.07805218f, 
    -0.08618198f, 0.26312762f, 0.36176130f, 0.03196399f, 0.01593123f, -0.17709035f, -0.11408071f, 0.11380886f, 
    -0.06126988f, -0.07756528f, 0.08589030f, 0.00103063f, 0.30839735f, 0.14264295f, -0.04473649f, 0.11138770f, 
    0.02066726f, -0.13996558f, -0.22682135f, -0.08893449f, 0.16597830f, 0.09402847f, 0.01374876f, 0.11143423f, 
    0.03695374f, 0.02801448f, -0.01730251f, 0.03786470f, -0.03718409f, -0.06344533f, 0.00494480f, 0.02613692f, 
    -0.04679341f, -0.00218020f, -0.02199018f, -0.06159197f, 0.05556152f, -0.05062247f, -0.06892550f, 0.01977292f, 
    0.01108539f, -0.02380640f, 0.04440617f, -0.03379276f, 0.01188724f, -0.05513261f, -0.04107677f, 0.01343377f, 
    -0.06054691f, -0.08075846f, 0.02475000f, 0.02107750f, -0.06671236f, 0.00496018f, 0.03515052f, 0.02796255f, 
    0.02061097f, -0.05314567f, 0.06628619f, 0.05962399f, -0.05663529f, -0.04861424f, 0.02873899f, -0.01249356f, 
    -0.00743069f, -0.07618156f, 0.02148686f, -0.00409815f, -0.07186421f, 0.02032179f, 0.03025795f, 0.01089157f, 
    0.04465430f, 0.02100610f, -0.05440854f, 0.04791366f, -0.04992289f, 0.00214545f, -0.02951680f, -0.03197170f, 
    -0.06330182f, 0.04916102f, 0.04247272f, -0.05982530f, 0.04536745f, -0.01190079f, 0.05046478f, 0.05436742f, 
    0.05997976f, -0.05564004f, -0.03737624f, 0.05099929f, -0.05848642f, -0.05359639f, -0.00171582f, 0.03989077f, 
    -0.01635690f, 0.05335147f, 0.00267669f, -0.07040375f, 0.04309677f, 0.06197315f, -0.03479043f, -0.07583409f, 
    0.03311796f, 0.06312462f, -0.02431299f, -0.04231957f, -0.04070060f, 0.03663747f, 0.02879175f, 0.01150416f, 
    -0.05983815f, -0.06002120f, 0.00386544f, -0.01222036f, 0.02100462f, 0.04319475f, -0.02523645f, 0.01533987f, 
    0.03620829f, 0.03245616f, -0.02514675f, -0.01501230f, -0.04104123f, -0.02423695f, 0.03816905f, -0.01220789f, 
    0.04837046f, 0.06060980f, -0.05799183f, 0.02333683f, 0.04463199f, -0.07020608f, 0.02978761f, 0.01032222f, 
    -0.02439675f, -0.00281946f, 0.03533230f, -0.02486405f, -0.04054194f, -0.00166996f, -0.04302022f, -0.03208131f, 
    0.00169581f, 0.05784243f, 0.01080783f, -0.00344845f, -0.03679466f, -0.06999394f, -0.05294869f, -0.02038171f, 
    -0.00530389f, 0.02831121f, -0.07810603f, -0.02783103f, -0.02782319f, -0.07087712f, -0.03736393f, 0.00082232f, 
    -0.05403300f, 0.01787285f, -0.06093370f, -0.04784593f, 0.04712737f, -0.04470376f, -0.03082901f, -0.02829315f, 
    -0.01107532f, 0.06118816f, 0.01013083f, -0.06133486f, -0.07055239f, -0.03214880f, -0.01492447f, 0.03371017f, 
    -0.03983700f, 0.03821061f, -0.06775102f, 0.01637099f, -0.01747355f, -0.05350843f, 0.01971447f, -0.02929233f, 
    -0.04395843f, 0.04801876f, 0.01444587f, 0.03129005f, -0.03453166f, -0.02605589f, -0.04098247f, 0.02088920f, 
    0.03375106f, 0.02641764f, 0.05212356f, 0.03435653f, -0.03143191f, -0.07898284f, -0.04115130f, -0.01575407f, 
    -0.01162997f, -0.00927591f, -0.03434086f, 0.05386325f, -0.03431885f, -0.04562248f, -0.04722477f, -0.01155144f, 
    0.04017733f, 0.01335225f, 0.02640706f, -0.06047160f, -0.04685689f, -0.05012077f, -0.00742076f, -0.07632613f, 
    -0.07712647f, -0.22203223f, 0.19494264f, -0.04239913f, 0.00856620f, 0.00049351f, 0.01963238f, -0.10067989f, 
    0.08084793f, -0.11915644f, -0.03422789f, -0.02103059f, -0.02532743f, 0.22951530f, 0.21337755f, -0.23740664f, 
    0.02298451f, 0.03557024f, 0.16383943f, -0.02170677f, -0.09739966f, -0.04537664f, -0.12442952f, -0.08051535f, 
    -0.18092287f, 0.04358334f, -0.02097886f, -0.35479015f, -0.12677301f, -0.01685949f, 0.09126869f, -0.06870380f, 
    -0.15672642f, 0.04027325f, -0.07711398f, 0.02010158f, 0.34466550f, 0.13824704f, 0.09765779f, -0.09219997f, 
    0.28808308f, 0.00482392f, 0.10497451f, 0.30977261f, -0.00300701f, -0.05569188f, 0.19248463f, -0.00838736f, 
    0.69888145f, 0.01538582f, -0.04492111f, -0.24146295f, -0.03223750f, -0.01641835f, 0.15912195f, 0.01806729f, 
    -0.02049655f, 0.30210134f, -0.20846276f, 0.26714754f, -0.47633207f, 0.24171333f, -0.18508251f, -0.15298302f, 
    -0.06826738f, -0.01063668f, 0.10599083f, 0.22557873f, -0.01045855f, -0.01822970f, 0.07924850f, 0.00075166f, 
    0.60715920f, 0.04982172f, -0.08309679f, -0.33829570f, 0.11089028f, 0.12787837f, 0.15418606f, 0.00393861f, 
    0.03607398f, -0.03791597f, 0.16534315f, -0.07044505f, -0.10021824f, -0.30311108f, 0.22161545f, -0.01203375f, 
    -0.03528251f, 0.04121204f, 0.16902086f, -0.01515203f, 0.13923110f, 0.10913584f, 0.14164943f, 0.02182377f, 
    0.04054602f, 0.08030657f, 0.15792854f, 0.01901747f, 0.03748853f, 0.01092908f, -0.01698010f, 0.24787930f, 
    -0.00025127f, -0.09437250f, 0.00462993f, -0.10529126f, 0.12952456f, -0.00041578f, 0.00426877f, 0.22244163f, 
    0.05664961f, -0.03696619f, -0.12144227f, -0.09923419f, 0.01191720f, -0.05449966f, 0.26834601f, -0.02804571f, 
    -0.19207226f, 0.04356184f, 0.08983039f, 0.16215119f, -0.00487552f, 0.04512409f, -0.10170658f, 0.14437118f, 
    -0.04713807f, 0.01631801f, -0.10683700f, -0.06091341f, 0.72329408f, -0.26779926f, -0.06241924f, -0.35154426f, 
    0.13283697f, 0.03141769f, 0.16842221f, 0.11631044f, 0.26914605f, -0.00666756f, 0.04211833f, -0.16728452f, 
    -0.62133247f, 0.41226387f, 0.01629998f, -0.26379880f, -0.03435387f, -0.03227481f, 0.09104328f, -0.12730044f, 
    -0.00088456f, -0.04515691f, 0.09408803f, 0.13889503f, 0.22748576f, 0.11049841f, -0.28753990f, -0.11781694f, 
    0.14343099f, 0.02844572f, 0.07840060f, -0.07731014f, -0.16903488f, -0.09790944f, -0.18274584f, 0.14378224f, 
    0.06333163f, 0.10490017f, 0.12764600f, -0.12493880f, 0.04280781f, 0.01165184f, -0.10408942f, 0.07470182f, 
    0.02069009f, -0.04055107f, 0.11658286f, 0.00724043f, -0.14444603f, 0.12534909f, 0.03517506f, 0.36330220f, 
    0.05904782f, 0.13614558f, 0.08688853f, -0.04925197f, 0.27248576f, 0.05397320f, 0.24212739f, 0.37336197f, 
    -0.00757020f, -0.06012786f, -0.06139553f, -0.07550281f, -0.04216158f, 0.02311740f, -0.06439268f, -0.01328779f, 
    -0.00289350f, 0.02704645f, -0.07313694f, -0.00494811f, -0.05531579f, 0.00547929f, 0.03831805f, -0.05913291f, 
    0.05150114f, -0.02273832f, -0.08290685f, 0.03736011f, -0.02876090f, -0.01571059f, -0.00320206f, 0.02212959f, 
    0.00337914f, 0.05867399f, -0.03679259f, -0.00759501f, -0.05519627f, -0.02835419f, -0.07491501f, -0.05533797f, 
    -0.04226441f, 0.00252939f, 0.01789957f, -0.00777272f, -0.07159320f, -0.08012509f, -0.04580712f, 0.01338330f, 
    0.03869984f, 0.04404707f, -0.02867040f, -0.01606590f, -0.07258981f, -0.05225315f, -0.04459848f, -0.02776852f, 
    0.01052593f, -0.05857129f, 0.04721453f, -0.03471345f, 0.04490520f, -0.03005488f, 0.00864538f, 0.01895295f, 
    0.02528701f, 0.05504324f, -0.06839944f, -0.08408014f, 0.02641742f, -0.05929098f, 0.03374925f, -0.04300743f, 
    0.03181390f, 0.03778181f, -0.00065201f, 0.00466158f, 0.06130490f, -0.08744390f, 0.03735435f, -0.06358176f, 
    0.03911620f, 0.02590129f, -0.07626781f, 0.04824771f, -0.07262471f, -0.04402458f, 0.03657326f, 0.06206524f, 
    -0.03290670f, -0.04084891f, -0.03985607f, -0.04786306f, -0.02428036f, -0.09415295f, 0.03992268f, 0.02761080f, 
    -0.08784656f, -0.02504705f, 0.03796655f, -0.01868116f, 0.01941729f, -0.05883956f, 0.02660372f, -0.01542417f, 
    -0.02966773f, 0.05062877f, -0.08404636f, 0.01182210f, -0.03727686f, -0.06784236f, -0.07953401f, 0.05181238f, 
    0.03197942f, -0.07151596f, 0.02337679f, -0.06216307f, 0.06317396f, -0.07916199f, -0.06671642f, -0.03280273f, 
    0.07115503f, -0.03003902f, 0.03550131f, -0.03538664f, -0.01349514f, 0.02890801f, 0.02303408f, -0.01397800f, 
    -0.07119772f, -0.04979858f, -0.07360590f, -0.00370016f, 0.05008666f, 0.04183244f, -0.06777021f, 0.03007822f, 
    -0.07591179f, -0.05799190f, 0.04370799f, -0.00893284f, -0.02970206f, -0.03975743f, 0.03744775f, -0.08426350f, 
    0.06959889f, 0.05628790f, -0.06228057f, 0.03979000f, -0.00999894f, 0.02301312f, -0.04622348f, 0.00310054f, 
    -0.00222294f, -0.06806948f, -0.04730354f, -0.02311031f, 0.02876638f, -0.02519470f, -0.02629650f, 0.01103351f, 
    -0.07093439f, -0.02025052f, -0.01003354f, -0.02803145f, -0.06252311f, -0.03822668f, -0.02617911f, 0.01414308f, 
    0.02244853f, 0.03675984f, 0.00841303f, -0.07328270f, -0.07201581f, -0.03462955f, 0.05487566f, -0.02300370f, 
    -0.01089128f, 0.04958641f, -0.00074515f, -0.00498218f, -0.06529529f, 0.02112863f, -0.01239899f, -0.04027717f, 
    0.02205831f, -0.08319456f, 0.04846627f, 0.04498440f, -0.07138986f, -0.04843858f, 0.02495077f, 0.04867060f, 
    -0.04923346f, -0.02288684f, 0.01144103f, -0.03576345f, 0.04208231f, -0.03321406f, -0.07555973f, 0.05488572f, 
    -0.29232636f, 0.00970302f, -0.56662178f, -0.03931518f, -0.25668895f, 0.11967865f, 0.06412519f, 0.10600917f, 
    -0.14738503f, -0.01042154f, 0.14738938f, 0.07841948f, -0.02524428f, -0.31734630f, 0.02112702f, -0.17086296f, 
    -0.10869200f, -0.26213622f, -0.19946916f, -0.17552964f, 0.04533793f, 0.01028491f, 0.04436809f, -0.05306662f, 
    -0.12067228f, 0.11000437f, 0.38190383f, -0.12014504f, -0.32717571f, -0.12663406f, -0.10685223f, -0.01020323f, 
    -0.18268350f, -0.05320926f, -0.02056320f, 0.04816983f, 0.27712730f, 0.09586547f, -0.63245875f, 0.18289398f, 
    0.11837320f, -0.15341483f, 0.16573936f, 0.30016801f, 0.04555951f, -0.02063470f, 0.19902225f, 0.05290777f, 
    0.61782891f, -0.61954051f, 0.42214325f, -0.38105482f, 0.04157603f, -0.08199233f, 0.03721093f, 0.20999067f, 
    0.24895261f, -0.04694416f, 0.17134950f, 0.05369546f, -0.04005972f, -0.16266178f, 0.02618570f, 0.26273000f, 
    -0.10613555f, -0.08954712f, 0.29147127f, -0.17778359f, 0.00480800f, 0.08278452f, 0.10257918f, -0.04227365f, 
    0.31581068f, 0.18262838f, 0.09996193f, -0.39147180f, 0.02634998f, -0.15041699f, 0.19057313f, 0.19081728f, 
    0.08433307f, 0.26639447f, 0.11140469f, 0.10795989f, -0.32550365f, 0.05535397f, 0.10836640f, 0.29795602f, 
    0.07733822f, 0.00902670f, 0.08594756f, 0.02123187f, 0.29636329f, 0.22408670f, 0.11011298f, 0.04039223f, 
    -0.52125794f, 0.23485477f, 0.05264546f, 0.56953037f, 0.02615305f, -0.18090199f, 0.26649541f, -0.00795114f, 
    -0.00588409f, 0.15189019f, 0.20174952f, 0.15215510f, -0.27915096f, -0.22268014f, -0.39986742f, -0.15527804f, 
    -0.04389826f, -0.04733565f, -0.16516630f, 0.01932034f, 0.03192479f, 0.36082214f, 0.27638951f, -0.13928600f, 
    -0.12448155f, 0.29001802f, 0.17141736f, 0.58867788f, 0.06168025f, -0.34207293f, -0.14971176f, 0.05586469f, 
    -0.10427060f, 0.11247230f, -0.23611921f, 0.26305723f, -0.00556158f, 0.47529444f, 0.20792025f, -0.22335975f, 
    0.06709825f, 0.05176721f, -0.09638827f, 0.25608689f, 0.13201697f, 0.27131411f, 0.01336513f, -0.12698953f, 
    -0.18658151f, 0.31111944f, 0.53586400f, 0.10692058f, -0.00401524f, 0.07619447f, 0.16943760f, -0.31782717f, 
    0.06198197f, 0.13782622f, 0.19302434f, -0.01505500f, 0.03690831f, -0.23032047f, -0.14285927f, -0.11384239f, 
    0.17806856f, 0.39325190f, 0.33165452f, 0.02412209f, -0.02800872f, -0.00660565f, -0.02029225f, -0.10113527f, 
    -0.29273373f, 0.40054801f, 0.53636658f, 0.06158921f, 0.02854561f, 0.04186545f, -0.14366613f, 0.03513461f, 
    -0.07607672f, 0.05344240f, 0.09880937f, 0.05662658f, -0.29141784f, 0.06317528f, -0.14373396f, 0.26479760f, 
    0.11635269f, 0.07001344f, -0.01407139f, -0.04302896f, 0.19258782f, -0.11681262f, 0.25098079f, 0.46704647f, 
    -0.11339690f, -0.20010547f, -0.07403926f, 0.36022976f, -0.08975253f, -0.17357333f, -0.10703716f, 0.02981894f, 
    0.08187494f, 0.06983183f, 0.14892398f, -0.06900994f, -0.14912775f, -0.10081581f, 0.05095661f, 0.20338830f, 
    -0.01700528f, -0.08502126f, -0.02642477f, 0.09848901f, -0.25025910f, -0.16291849f, -0.02877647f, -0.25342575f, 
    -0.03676986f, 0.01621590f, 0.44172812f, -0.03332000f, -0.29389486f, -0.22736219f, -0.13750710f, 0.11660762f, 
    0.17033687f, 0.01388621f, 0.01674590f, -0.08287348f, -0.29868725f, -0.17635471f, -0.08686796f, 0.15238054f, 
    -0.02712558f, 0.11014283f, 0.14854485f, -0.23016751f, 0.10049913f, 0.02458373f, 0.10355265f, 0.20122470f, 
    -0.02652279f, 0.25688028f, -0.16142473f, 0.02351238f, -0.08216056f, 0.06768793f, 0.00541095f, 0.10144592f, 
    -0.15548800f, -0.28906831f, -0.07816473f, 0.01981754f, -0.09501611f, -0.31909630f, -0.11318692f, 0.12741284f, 
    -0.02752443f, 0.09020521f, -0.15910321f, -0.07585386f, 0.00825758f, -0.19996391f, -0.03579120f, 0.01738375f, 
    -0.01656971f, 0.33476073f, 0.06064209f, 0.12183809f, 0.19253558f, 0.12779467f, 0.24138258f, -0.16300657f, 
    0.14885136f, 0.28210747f, 0.20507604f, 0.32117531f, -0.22393946f, -0.24531865f, 0.16105630f, 0.01321871f, 
    -0.00438979f, 0.12874611f, -0.05878676f, 0.13111109f, 0.27853322f, 0.05472684f, 0.08156619f, 0.04370992f, 
    0.04345711f, -0.06610448f, 0.26994422f, 0.30387849f, -0.16580717f, 0.19754913f, 0.07502822f, -0.10319284f, 
    -0.01575661f, -0.01744149f, 0.10840359f, 0.12384520f, -0.22574228f, -0.06141908f, 0.05687727f, -0.01157505f, 
    -0.27787307f, -0.03458754f, 0.37851611f, 0.05904751f, 0.36241457f, 0.13584325f, 0.20970532f, 0.35495406f, 
    0.16524038f, 0.09595680f, -0.00535228f, -0.06121393f, 0.14595748f, -0.10979836f, -0.18070482f, -0.13331029f, 
    -0.03950271f, -0.20601833f, -0.29661167f, -0.19220735f, -0.14980653f, 0.09487373f, 0.32446694f, -0.09740740f, 
    0.02859960f, 0.08162059f, 0.21936817f, -0.10182228f, 0.08156841f, 0.25482687f, 0.21047288f, 0.10525595f, 
    0.02498940f, -0.10275739f, 0.24142167f, 0.20023394f, 0.07154886f, -0.04379013f, -0.11105181f, -0.04921630f, 
    0.00882136f, 0.01214676f, 0.13718072f, 0.26613671f, 0.01158301f, -0.07053276f, 0.25400990f, -0.16908750f, 
    0.13258700f, 0.01922618f, -0.12648349f, 0.17426080f, -0.06491572f, -0.17855358f, -0.39798293f, -0.39126748f, 
    -0.03591171f, -0.04264658f, 0.25707772f, 0.19194461f, -0.13707702f, -0.33722600f, 0.19813964f, 0.06951866f, 
    -0.02434309f, 0.16901192f, 0.08471848f, 0.00644160f, 0.31341878f, 0.47410721f, -0.32241249f, -0.22123134f, 
    -0.02990899f, 0.04796863f, -0.09648793f, -0.01487781f, 0.29685265f, 0.22194742f, -0.10936327f, -0.07748435f, 
    -0.04441553f, -0.40535596f, 0.15915254f, 0.11570415f, 0.09054181f, 0.11324503f, -0.07594867f, -0.26299852f, 
    0.12776288f, -0.19151668f, 0.09953497f, -0.05290142f, -0.31671876f, -0.12691031f, 0.05668874f, 0.18213336f, 
    0.21708885f, 0.07175795f, -0.01765477f, -0.16078067f, 0.07527426f, 0.06564267f, -0.04202415f, 0.06715637f, 
    -0.51116496f, -0.26785883f, -0.11713932f, 0.02855400f, -0.02315897f, 0.12995745f, 0.17183478f, -0.12264068f, 
    0.00704378f, -0.01123997f, 0.01890350f, 0.01897494f, 0.35928103f, -0.28295776f, 0.14210688f, 0.58117205f, 
    0.09561626f, 0.03662355f, 0.32051346f, 0.12618706f, 0.07904998f, -0.05632727f, -0.03421367f, -0.05391036f, 
    -0.35661861f, 0.11299352f, -0.14440800f, 0.26174632f, -0.01346110f, 0.05853573f, 0.10436199f, 0.09460843f, 
    0.07628890f, -0.07306575f, 0.20251770f, 0.13707618f, -0.13304238f, -0.06631161f, 0.19545595f, 0.07771722f, 
    0.28829342f, 0.04897156f, 0.13189973f, 0.11157360f, -0.06699301f, 0.05644189f, -0.03395894f, -0.03132923f, 
    0.13429359f, -0.09003042f, -0.16380106f, 0.19878714f, -0.02530401f, 0.22623359f, 0.02417958f, 0.06761977f, 
    0.10390061f, 0.12720457f, 0.16067268f, -0.17923822f, 0.03729590f, 0.45523047f, -0.32033709f, 0.05919377f, 
    0.01206830f, 0.05303088f, 0.39609221f, -0.10522902f, -0.02857618f, 0.03780388f, 0.04365564f, -0.04729891f, 
    -0.40391320f, -0.16289653f, 0.16503642f, -0.18631709f, 0.30914378f, 0.15880930f, 0.14776632f, 0.25661534f, 
    0.00355126f, -0.09056339f, -0.19588463f, 0.07021747f, 0.00843629f, 0.03514156f, -0.11635913f, -0.14577556f, 
    -0.03912528f, -0.12295774f, -0.04601176f, -0.10437653f, -0.26099882f, -0.23040678f, -0.10809321f, -0.30832851f, 
    -0.38995159f, -0.25095257f, -0.19491455f, 0.24894392f, -0.08925780f, 0.11192747f, 0.16372588f, 0.00517281f, 
    0.19811781f, 0.09670202f, 0.31621608f, 0.12171035f, -0.32790723f, 0.10754984f, -0.41054481f, 0.39546838f, 
    -0.00769826f, 0.16767059f, 0.41846246f, -0.01120847f, 0.06944098f, 0.05284962f, 0.14584106f, 0.11178029f, 
    -0.05792854f, -0.18250929f, -0.03819521f, 0.19863012f, 0.23401752f, 0.19473565f, 0.06488160f, -0.03922612f, 
    0.08185064f, 0.09397268f, 0.21105205f, 0.02270668f, 0.01114956f, 0.11974134f, 0.17672569f, -0.04862342f, 
    0.26207837f, -0.08820131f, -0.04083487f, -0.04552271f, -0.11754841f, 0.09810081f, 0.00811897f, 0.06740407f, 
    -0.21244131f, -0.29398516f, -0.04745841f, 0.08080555f, -0.04354279f, 0.28533873f, -0.05778752f, -0.10168068f, 
    -0.01150081f, -0.08410572f, -0.08303393f, 0.02974836f, -0.13544057f, -0.05879881f, -0.09858356f, -0.02006034f, 
    0.11327023f, -0.09844531f, -0.09286588f, -0.00456367f, 0.02945211f, 0.07679481f, 0.20748824f, 0.51823193f, 
    0.16698092f, -0.30859217f, -0.05389600f, 0.07412247f, 0.12649761f, 0.04331072f, 0.12405752f, 0.25084075f, 
    0.08844820f, -0.26928845f, 0.04706106f, -0.05606620f, -0.21138874f, -0.22222583f, -0.09276834f, 0.06897062f, 
    -0.06290133f, 0.12058902f, -0.00830092f, 0.05849986f, -0.03076893f, -0.02041902f, -0.06149133f, -0.11228768f, 
    -0.29721454f, -0.27437627f, -0.11535840f, -0.04553514f, -0.10128444f, 0.07011296f, 0.23551401f, 0.24981512f, 
    -0.09924874f, -0.06481140f, 0.02226303f, 0.01502390f, 0.13082623f, -0.12362729f, 0.07607981f, 0.15433122f, 
    0.02448487f, -0.11245969f, 0.27888688f, 0.15354471f, 0.03753731f, 0.12467097f, 0.13614494f, 0.01539859f, 
    -0.57334292f, 0.41155562f, 0.08417720f, 0.23045830f, -0.14091311f, 0.05244736f, 0.12368060f, 0.18990909f, 
    -0.01141900f, -0.15589659f, 0.18422094f, -0.00671639f, 0.07983734f, -0.13042641f, -0.07177630f, -0.17488879f, 
    -0.06669861f, 0.22209725f, 0.12570097f, 0.02382256f, 0.09552350f, -0.05947318f, -0.13305518f, -0.00084881f, 
    -0.07624066f, -0.25651696f, 0.31928164f, 0.14006300f, -0.08694332f, 0.03273543f, 0.22370179f, 0.16700740f, 
    0.12991518f, -0.00008738f, 0.23160139f, 0.12059300f, 0.14518872f, 0.26964048f, -0.23959565f, 0.13818270f, 
    0.12362962f, 0.07636414f, 0.10561944f, 0.24448918f, -0.03950710f, 0.08249433f, 0.09092554f, 0.04494942f, 
    -0.10507764f, -0.25059363f, -0.32569423f, -0.17135367f, -0.01193634f, 0.04798318f, 0.03121242f, 0.07380562f, 
    0.15491210f, 0.03646686f, 0.01226016f, 0.06035428f, 0.07550446f, 0.18273677f, 0.00501035f, -0.13929512f, 
    -0.12529750f, -0.01149773f, 0.01846877f, -0.16426134f, 0.02680997f, 0.13336486f, 0.04976723f, 0.06182973f, 
    -0.11197373f, -0.01515446f, 0.06913333f, 0.02958221f, 0.00882524f, -0.05299630f, 0.10202347f, -0.11095908f, 
    -0.21311678f, 0.19757669f, 0.21742781f, 0.04605045f, -0.66448784f, -0.31485710f, 0.63798034f, 0.21917263f, 
    -0.30927360f, 0.04877766f, 0.17691778f, 0.48505276f, -0.37320119f, 0.17334165f, 0.14981408f, 0.15700968f, 
    0.05646699f, -0.39326832f, -0.17648685f, -0.06907575f, -0.01435966f, 0.07098595f, 0.06634932f, 0.12393113f, 
    0.02737030f, 0.04996571f, 0.13747817f, 0.12460592f, 0.23136568f, 0.12924935f, 0.20651546f, 0.02512382f, 
    0.06009540f, -0.00735151f, 0.04433342f, -0.15739255f, -0.16867630f, 0.24276020f, -0.10770597f, -0.14692982f, 
    -0.27202699f, -0.53405088f, -0.26918566f, 0.12127067f, 0.01759902f, -0.03808296f, -0.01001411f, 0.30105969f, 
    0.03769901f, -0.02807557f, -0.03587497f, 0.03153703f, -0.24566023f, 0.52328736f, 0.09090579f, -0.10362171f, 
    -0.03222591f, 0.20421493f, -0.06031413f, 0.02760715f, 0.02089290f, 0.25340271f, -0.06557227f, 0.22102283f, 
    0.28609934f, 0.30830258f, 0.18276139f, -0.33155596f, 0.22104010f, 0.04785169f, 0.15628798f, 0.19610362f, 
    -0.13876273f, -0.09858701f, 0.15896817f, -0.05770102f, -0.55641961f, -0.38711613f, -0.35056469f, -0.12734956f, 
    0.02502070f, -0.00813662f, 0.19426461f, 0.15494567f, -0.07075807f, 0.08758250f, -0.04471451f, -0.01293867f, 
    0.29428023f, 0.45857596f, -0.20300059f, -0.52541983f, 0.21550655f, -0.12537485f, 0.07353065f, 0.26465392f, 
    0.03761411f, -0.05574681f, 0.09390491f, 0.04563445f, -0.06848051f, 0.19788785f, -0.17456932f, -0.05012456f, 
    -0.00539797f, 0.27693382f, 0.21192214f, -0.03963647f, -0.07087380f, 0.06226088f, 0.04378016f, -0.03668240f, 
    0.38438761f, 0.30711588f, 0.17254357f, -0.02190772f, -0.02892927f, -0.00859073f, 0.06468924f, -0.06974638f, 
    0.31073701f, 0.20853896f, -0.10175539f, 0.03847868f, -0.51138979f, -0.55677074f, -0.61197567f, -0.41184425f, 
    0.19284493f, 0.08327246f, -0.27652603f, 0.19727156f, 0.06335529f, -0.10970558f, -0.04646039f, 0.22093542f, 
    0.30223677f, 0.11341104f, -0.11367027f, 0.09555757f, -0.05524299f, 0.03469030f, 0.02275039f, 0.11277286f, 
    0.15758739f, 0.00723601f, 0.03422147f, 0.21219598f, 0.20638037f, -0.56886655f, 0.11183105f, -0.22537138f, 
    0.08100460f, 0.13830580f, -0.38278320f, 0.03543270f, 0.01637576f, -0.21183601f, 0.14151525f, -0.00907242f, 
    0.55302340f, -1.10141289f, -0.54242867f, -0.59167582f, -0.14367887f, 0.02957832f, -0.14796127f, 0.20207535f, 
    -0.04469780f, -0.07345296f, -0.01318012f, -0.18679500f, 0.08417300f, 0.09533761f, 0.21635620f, 0.07786122f, 
    0.04090404f, 0.01503994f, 0.00701547f, -0.09682031f, 0.43409649f, 0.09661569f, -0.08712184f, 0.02794032f, 
    0.23881428f, -0.15082403f, 0.38623360f, -0.22484760f, 0.01051076f, 0.01851929f, 0.07147562f, 0.02372402f, 
    0.09089842f, 0.24417900f, 0.08436416f, -0.13906538f, 0.21476716f, -0.01853429f, 0.36863512f, -0.50759786f, 
    0.06339084f, -0.03496256f, 0.12188336f, 0.24461836f, 0.22374362f, 0.15509716f, 0.16508000f, -0.03724043f, 
    -0.18901944f, -0.68513680f, -0.20409235f, -0.31243843f, -0.06781121f, 0.01351337f, -0.12442376f, 0.24272761f, 
    0.03437820f, 0.00296067f, 0.15058088f, 0.11191799f, 0.01849867f, 0.07306994f, -0.30327705f, 0.17797212f, 
    -0.11313055f, 0.04072807f, 0.02408707f, -0.09501305f, -0.09906256f, 0.04417634f, 0.03928345f, 0.02722687f, 
    -0.32430890f, -0.38070548f, -0.16992813f, -0.16164114f, -0.01821301f, -0.01205553f, -0.06888999f, 0.33892071f, 
    0.02122393f, -0.13785765f, 0.00048545f, -0.10609408f, 0.37907144f, 0.35552457f, 0.49663931f, -0.04831502f, 
    -0.07189937f, -0.05373427f, -0.05008931f, 0.12990329f, 0.33750430f, 0.06192228f, 0.10504978f, 0.00868128f, 
    -0.10653212f, 0.27643299f, -0.28635380f, -0.26904491f, -0.19018540f, -0.08896083f, 0.24118692f, 0.33238977f, 
    0.00461779f, -0.00331385f, 0.03517816f, 0.01722893f, 0.00224341f, 0.19062734f, 0.15333918f, 0.18425485f, 
    -0.03792586f, 0.12922888f, 0.41340634f, 0.26447544f, 0.02509787f, 0.04917420f, 0.11223710f, 0.12663861f, 
    0.27392519f, 0.05274891f, 0.28528205f, 0.10476115f, -0.08721098f, -0.04168135f, 0.04052252f, 0.28537557f, 
    0.10196315f, 0.04630926f, 0.03885063f, -0.02345258f, -0.35359943f, 0.13854308f, 0.02457529f, 0.11867201f, 
    0.21803947f, -0.04599738f, 0.00648483f, 0.03308499f, -0.01482859f, 0.08356952f, 0.03527363f, -0.07129333f, 
    -0.02650400f, -0.19403988f, -0.01936707f, -0.29678485f, -0.02025059f, 0.08056848f, -0.05102052f, -0.09339993f, 
    -0.03795542f, -0.02021135f, -0.05834110f, -0.06387869f, -0.16209853f, -0.28650570f, 0.03154638f, 0.00275347f, 
    -0.00937838f, 0.05258052f, -0.03892670f, 0.22033437f, 0.13335282f, 0.02700267f, 0.06028628f, 0.02000513f, 
    -0.04961320f, -0.05729131f, 0.17947350f, -0.09891569f, 0.16622804f, 0.09170172f, -0.07367878f, -0.07453562f, 
    -0.12127912f, 0.05512268f, -0.00457127f, -0.02711043f, 0.09302282f, -0.00230474f, 0.24393140f, -0.15128402f, 
    -0.04848683f, -0.12237186f, -0.25674841f, 0.12534638f, 0.07017940f, -0.19627357f, 0.04468674f, 0.01588190f, 
    0.07125431f, -0.15088087f, 0.13047569f, 0.33790702f, -0.01655441f, 0.15164874f, -0.14856079f, -0.18851787f, 
    0.08050474f, -0.13264047f, 0.07547790f, 0.00003330f, -0.13544530f, -0.25773063f, -0.01816750f, -0.05745651f, 
    -0.01235248f, -0.00318011f, -0.12858805f, -0.02297259f, -0.15347522f, -0.09036165f, -0.01858508f, 0.13063014f, 
    0.10427244f, 0.03523299f, 0.11423537f, -0.20141236f, 0.01150332f, 0.02792976f, -0.02002807f, 0.05165775f, 
    0.12574567f, 0.28491819f, -0.30231309f, 0.11000371f, 0.40908858f, 0.11851517f, 0.31989938f, -0.15558244f, 
    -0.15909423f, 0.04002297f, 0.01962624f, 0.05341147f, 0.04524982f, -0.07117409f, -0.07863788f, 0.09403934f, 
    0.35645297f, 0.21873550f, 0.15457755f, 0.10849831f, -0.02661712f, -0.15371837f, -0.06691693f, 0.14275551f, 
    0.06485845f, -0.00273826f, 0.00269381f, -0.08229294f, -0.24679118f, -0.08992877f, -0.15540335f, -0.14821707f, 
    0.01972282f, 0.02953400f, -0.19066010f, -0.00518187f, -0.01076693f, -0.01185425f, 0.01938744f, -0.05070756f, 
    -0.01869959f, -0.06365898f, -0.00602026f, -0.07963433f, -0.00574622f, -0.14983875f, 0.23420116f, 0.01987758f, 
    0.07204494f, -0.06282104f, 0.05669487f, 0.01009542f, 0.24860005f, 0.12725706f, -0.32916120f, -0.01646210f, 
    -0.01473429f, -0.14409652f, 0.06877888f, 0.06600641f, -0.09243275f, -0.09652641f, -0.22253206f, 0.03740594f, 
    0.08455441f, 0.01832713f, -0.15210269f, 0.05809343f, -0.10866629f, -0.07227159f, 0.17917204f, 0.24478190f, 
    -0.12188663f, -0.01498954f, 0.04267659f, -0.00334254f, 0.20223016f, 0.11646861f, 0.04490035f, 0.20075512f, 
    -0.12473671f, 0.01979653f, 0.17962594f, -0.03274902f, -0.02485645f, 0.00182685f, -0.04903812f, -0.05898774f, 
    0.11529715f, 0.16434617f, 0.09423260f, 0.06110942f, 0.03120155f, 0.16971077f, 0.05687518f, 0.08039669f, 
    -0.08264906f, 0.04912608f, 0.21388099f, 0.12732668f, -0.11241877f, 0.06124153f, 0.04048669f, -0.30818841f, 
    0.03035174f, 0.03363071f, -0.30971631f, -0.12050119f, -0.05177766f, 0.04668895f, 0.10752747f, -0.12876683f, 
    0.11636906f, -0.39159080f, -0.31678766f, 0.07084344f, -0.06531860f, 0.02971836f, 0.02653844f, -0.13922599f, 
    -0.26969191f, -0.31914112f, 0.09754938f, 0.00753636f, 0.49041948f, 0.20725691f, 0.05103971f, -0.09182706f, 
    0.08421480f, 0.26585409f, -0.18243147f, 0.01407213f, 0.16508724f, 0.00209765f, -0.20198850f, 0.06010043f, 
    0.05917745f, -0.37745371f, 0.25532347f, 0.11284789f, -0.09381391f, 0.07204627f, -0.23800637f, -0.10473994f, 
    -0.05893810f, 0.07208817f, 0.10978653f, 0.10234519f, 0.20896628f, 0.00504598f, -0.06423986f, 0.22205736f, 
    0.02250909f, -0.09624991f, 0.12530710f, -0.16267186f, 0.04412793f, -0.22799380f, 0.09334391f, 0.01945836f, 
    0.37111169f, 0.10166677f, 0.10226457f, 0.04558053f, 0.28123406f, 0.21280336f, 0.06733650f, -0.12379089f, 
    0.11530721f, 0.18560353f, 0.09705460f, -0.09327560f, -0.30557632f, -0.14657773f, 0.03807255f, -0.07548263f, 
    -0.05312480f, -0.00892640f, 0.02447362f, 0.12288161f, -0.33199432f, 0.02935683f, 0.02711010f, 0.07590683f, 
    0.04983537f, -0.06933586f, -0.18598478f, -0.21906656f, 0.23035532f, 0.06212524f, 0.03028188f, 0.06016072f, 
    0.07682167f, 0.12886429f, -0.25711954f, -0.15035200f, 0.28036949f, -0.21879345f, 0.16056760f, 0.25663501f, 
    -0.18124872f, -0.13999520f, 0.14091791f, -0.27706972f, -0.14253579f, 0.14388585f, -0.07034399f, 0.27471119f, 
    0.37191990f, 0.10259763f, -0.00132704f, 0.11011788f, 0.02482883f, 0.24495637f, -0.15625606f, -0.01769802f, 
    -0.08522301f, -0.07027565f, -0.00455028f, 0.00611472f, -0.39961305f, -0.32148170f, -0.24572635f, -0.55758524f, 
    0.03238243f, -0.03605562f, -0.25024411f, -0.05461613f, -0.05616885f, 0.09532336f, -0.02467932f, 0.02432081f, 
    0.20459975f, -0.08913127f, 0.10554188f, 0.15335543f, -0.00112839f, 0.17643492f, 0.15194763f, -0.01264834f, 
    0.01258120f, 0.03994706f, -0.03139935f, 0.03308617f, -0.34363133f, 0.34775707f, -0.51938850f, -0.47745535f, 
    -0.21374451f, -0.02758229f, -0.01287936f, 0.20471774f, -0.25839543f, 0.14675236f, -0.08123086f, -0.27446386f, 
    0.13048771f, 0.12222528f, -0.08907488f, -0.13064305f, 0.15678041f, 0.02085395f, 0.21344858f, -0.00302978f, 
    -0.10122837f, -0.02404150f, -0.07476013f, -0.07795718f, 0.08682317f, 0.20737773f, -0.18839084f, -0.38795212f, 
    0.01009766f, 0.28176689f, 0.24012661f, 0.16813020f, 0.00513111f, -0.05910607f, -0.04204905f, 0.04353924f, 
    0.06423717f, -0.09688552f, -0.32320729f, -0.06038641f, 0.03043894f, 0.07021709f, 0.08587725f, -0.07070147f, 
    -0.17994037f, -0.06905915f, -0.05296108f, -0.05639296f, -0.01315691f, 0.21330893f, 0.26247096f, -0.12800290f, 
    0.26460898f, -0.09990872f, 0.14997457f, 0.39384922f, -0.16494156f, 0.01829448f, -0.00983483f, 0.05247387f, 
    -0.39651811f, -0.17821138f, -0.04652599f, -0.05065851f, 0.12785172f, 0.15014020f, -0.17956755f, -0.03584132f, 
    0.02538600f, 0.26082486f, 0.24408633f, 0.11387438f, 0.22527067f, 0.37197405f, 0.28656700f, -0.15846087f, 
    0.10859342f, 0.09371253f, 0.12918581f, 0.15237772f, -0.12204599f, 0.07394199f, 0.04791530f, -0.08807368f, 
    -0.39447856f, -0.20315558f, 0.08811343f, -0.15544437f, -0.01570672f, -0.01588905f, -0.12676010f, -0.04691907f, 
    0.25470868f, -0.07616474f, 0.03320354f, -0.18469682f, 0.22640222f, 0.47258389f, -0.10372546f, -0.16924311f, 
    0.20069724f, -0.11878251f, 0.05201686f, 0.21842372f, -0.06861541f, 0.14396751f, -0.09180280f, 0.02110022f, 
    -0.25528684f, 0.25692561f, 0.32444993f, 0.17052671f, 0.21187377f, 0.00199203f, -0.09189110f, -0.08989108f, 
    0.05480588f, -0.08195642f, -0.01296616f, 0.01354264f, -0.06710079f, -0.03472228f, -0.13351046f, 0.22143085f, 
    0.02404896f, 0.03561097f, -0.01272438f, 0.01850558f, -0.04422426f, -0.09400786f, 0.02014057f, -0.07060170f, 
    -0.13246287f, 0.07783193f, -0.11111861f, -0.08752730f, -0.00771292f, 0.15158872f, -0.09407571f, -0.16983435f, 
    0.14209303f, 0.10248593f, 0.08267387f, 0.02934625f, -0.37092769f, 0.07580671f, -0.08848342f, 0.23491000f, 
    -0.12624630f, -0.10975601f, -0.21889061f, -0.02118466f, 0.02533869f, -0.11875185f, -0.11410823f, 0.21840775f, 
    0.25290161f, 0.29943836f, 0.05712199f, 0.05767014f, -0.01878901f, -0.03606431f, 0.10371519f, 0.16755594f, 
    0.16819531f, -0.03506808f, -0.15568614f, -0.02933799f, -0.04724072f, 0.05707770f, 0.32683969f, 0.10118658f, 
    0.22518419f, 0.09369136f, -0.12473902f, 0.25886968f, -0.09899074f, 0.04246118f, 0.07836058f, 0.00048655f, 
    0.06898469f, 0.22621761f, -0.22969911f, -0.10055704f, 0.12819895f, 0.20975021f, 0.06786184f, -0.03960332f, 
    -0.13697721f, -0.07442281f, -0.06529837f, 0.04940862f, -0.11135352f, -0.17778397f, -0.06410057f, 0.32706487f, 
    -0.04206420f, 0.01947832f, 0.10838921f, 0.03557921f, 0.13199553f, -0.07601289f, 0.07492209f, 0.24299121f, 
    -0.60537106f, -0.13720106f, -0.08394014f, 0.23011960f, 0.11159746f, 0.08585213f, -0.05772200f, -0.01241988f, 
    -0.09704316f, -0.20425928f, 0.01079612f, 0.00286792f, -0.27536923f, -0.12355793f, 0.20056036f, 0.28356048f, 
    -0.12180189f, -0.08835615f, 0.07011898f, -0.17849460f, -0.02201983f, -0.11844229f, -0.14417429f, -0.05224246f, 
    -0.42742050f, -0.19383006f, 0.52991545f, 0.21044438f, -0.02312207f, 0.04371247f, 0.11625989f, 0.11487710f, 
    0.07691080f, -0.08678690f, 0.10637661f, 0.06775265f, -0.40780240f, -0.13541719f, -0.26457849f, 0.46664587f, 
    -0.15649796f, -0.08785395f, -0.09728163f, 0.01884032f, 0.06870977f, 0.06755526f, -0.13531879f, 0.07719311f, 
    0.78806341f, -0.12555547f, -0.06903965f, 0.21977296f, 0.02236331f, -0.05152114f, 0.16365743f, 0.10234106f, 
    0.11348400f, 0.09892295f, 0.14145800f, 0.03868109f, -0.00959848f, -0.29963791f, 0.11150222f, -0.03207592f, 
    -0.08276088f, -0.17514496f, 0.07643507f, -0.16227944f, -0.10249779f, -0.14799064f, -0.09380846f, -0.09229988f, 
    0.58050877f, 0.12690051f, -0.02236682f, -0.09146374f, 0.05028625f, 0.04798517f, 0.10009272f, 0.02556029f, 
    0.12839027f, 0.02940444f, 0.05538759f, -0.11508629f, -0.21645959f, 0.31340080f, 0.01002547f, 0.09368759f, 
    -0.06001753f, -0.12764791f, -0.10176948f, 0.08091920f, 0.11873252f, 0.23577590f, 0.27709135f, -0.09267978f, 
    -0.17951402f, 0.05838510f, 0.27182728f, 0.31714121f, 0.08455249f, 0.01865362f, 0.03090677f, 0.05069660f, 
    -0.19981305f, -0.00240473f, 0.13092507f, 0.07198477f, 0.14820388f, 0.06562588f, -0.03248746f, 0.02832531f, 
    -0.00540945f, -0.08736353f, -0.09836622f, -0.03508751f, 0.28651324f, 0.15845066f, 0.06668393f, 0.18740182f, 
    -0.04805681f, 0.24114288f, -0.01663144f, 0.09354813f, 0.07953937f, -0.01974011f, -0.00383053f, 0.07932332f, 
    -0.07231975f, -0.04823321f, -0.03188896f, -0.07002481f, 0.29921216f, 0.11058562f, -0.16828997f, 0.09499759f, 
    0.08537429f, 0.11432602f, 0.06100889f, 0.13700131f, 0.27673125f, 0.19442093f, -0.03308421f, 0.15850976f, 
    0.22891939f, -0.03374162f, 0.34830508f, 0.22275913f, 0.08857586f, 0.00660478f, -0.02309426f, -0.06308859f, 
    0.00165253f, 0.13193536f, 0.05788207f, 0.10767993f, 0.20564270f, -0.07371446f, 0.19998425f, -0.21994400f, 
    -0.10179485f, 0.13315831f, -0.03944350f, -0.01662615f, -0.01109774f, -0.13443558f, 0.05739852f, -0.08808980f, 
    -0.27036574f, 0.16982749f, 0.31512639f, 0.10223200f, -0.04463358f, -0.14276189f, 0.15372436f, -0.00883897f, 
    -0.05100743f, 0.05284014f, 0.02206258f, -0.14953272f, 0.54589200f, 0.06426296f, 0.19294371f, 0.28393713f, 
    0.08072198f, -0.03688890f, -0.01132842f, 0.10883204f, 0.11074740f, 0.03488775f, -0.04717916f, 0.10793068f, 
    0.42963505f, 0.07497872f, 0.58913165f, 0.10165691f, 0.06718303f, 0.13062242f, -0.16316110f, 0.35929701f, 
    -0.13468684f, -0.07385054f, -0.06328901f, -0.07402012f, 0.20236377f, 0.37077615f, 0.30886680f, 0.24549855f, 
    0.07906565f, 0.05497961f, 0.11649004f, -0.06210809f, -0.06782015f, 0.06563429f, -0.03684340f, 0.00581044f, 
    0.45998597f, 0.38273373f, 0.11083093f, 0.08328796f, 0.17486036f, 0.11590724f, 0.01749928f, 0.29329622f, 
    0.00890044f, -0.16406064f, -0.00661885f, -0.04076668f, 0.35670689f, 0.14542331f, 0.32752082f, 0.00419567f, 
    -0.01460728f, -0.06999362f, -0.08694870f, -0.01000330f, -0.18763652f, -0.05282266f, 0.08171789f, -0.00337639f, 
    0.23218800f, 0.14197385f, -0.64463520f, 0.20586500f, 0.07267875f, -0.15803853f, 0.16303892f, -0.11064386f, 
    -0.05315180f, -0.00739531f, 0.00507111f, -0.37610576f, 0.10643473f, 0.30234331f, 0.06967379f, -0.10633456f, 
    0.10881646f, 0.05256125f, 0.06524700f, -0.10083992f, 0.01096201f, -0.06969313f, 0.04827202f, -0.03496018f, 
    0.18715623f, -0.28371212f, -0.09938428f, 0.14182314f, -0.15207507f, -0.03280498f, -0.01249559f, -0.13353020f, 
    0.15222649f, -0.01480257f, -0.01854594f, 0.05893842f, 0.23212500f, 0.51480049f, 0.03907130f, 0.27549571f, 
    0.07984504f, 0.13729714f, 0.14277625f, -0.12658302f, -0.08925964f, -0.03131216f, 0.11556780f, 0.12995158f, 
    0.29584774f, 0.13932084f, -0.09195884f, -0.37757355f, 0.24629042f, 0.10686653f, 0.00201760f, -0.09119829f, 
    -0.05896787f, -0.03183667f, 0.02969407f, 0.06322175f, -0.03610442f, -0.27150470f, 0.01275768f, 0.10074586f, 
    -0.00225029f, 0.06666295f, 0.02447037f, 0.06718171f, -0.19455904f, 0.04558108f, 0.25481984f, 0.08693569f, 
    -0.01027991f, -0.20129493f, -0.40862060f, -0.12819009f, 0.16412596f, 0.07656465f, -0.01380872f, -0.05845301f, 
    0.07124884f, 0.04691324f, -0.10766115f, -0.09020416f, 0.35210842f, -0.48805487f, -0.22570515f, 0.05219586f, 
    -0.13691141f, -0.15520611f, 0.13148308f, -0.15006791f, 0.15278323f, -0.06156412f, -0.10055861f, 0.17459753f, 
    -0.10163067f, 0.15053934f, -0.15721272f, -0.19517583f, 0.03781345f, -0.02233585f, 0.03677552f, -0.00256321f, 
    0.01643739f, 0.02663792f, 0.13317783f, 0.24049520f, 0.24424791f, -0.19117898f, -0.33497339f, 0.19193505f, 
    -0.06941041f, -0.11544685f, -0.08232903f, -0.19181609f, 0.05341970f, -0.10516328f, -0.24742880f, -0.04240418f, 
    0.35918131f, -0.02413488f, 0.11841667f, 0.18402314f, 0.21639746f, 0.24174838f, 0.05943007f, 0.08834574f, 
    -0.03509694f, 0.05786317f, -0.13486783f, -0.01771239f, -0.34706518f, -0.17189422f, -0.04980095f, -0.25341588f, 
    0.00550645f, -0.07157577f, -0.00205822f, -0.07472413f, -0.24670233f, 0.03477345f, 0.01885547f, 0.02545114f, 
    0.01039178f, 0.03113811f, 0.04310162f, 0.02742418f, 0.03535685f, 0.04663410f, 0.06163555f, 0.02892281f, 
    0.00856834f, -0.04858942f, 0.02239943f, 0.02807266f, -0.03611771f, -0.06692053f, 0.02558269f, -0.03247574f, 
    0.02402661f, 0.00507383f, 0.06064926f, 0.01983086f, 0.03383512f, 0.01037042f, -0.01943908f, 0.00720400f, 
    -0.04546308f, 0.00104216f, 0.05315029f, -0.05573509f, -0.03715723f, -0.07089942f, 0.07836964f, -0.02092687f, 
    -0.07720476f, 0.00374903f, 0.01050828f, 0.01498517f, -0.02785760f, 0.01129655f, 0.00311550f, -0.03428933f, 
    -0.02322628f, -0.06127472f, 0.08448391f, 0.05816860f, -0.02109268f, 0.00096363f, -0.03278459f, -0.08886515f, 
    0.05568187f, -0.11260760f, -0.01032776f, -0.03835200f, -0.03052083f, -0.04667963f, -0.03431955f, -0.06372005f, 
    0.01562645f, 0.00726403f, -0.08952872f, -0.03549348f, 0.01122440f, 0.04785011f, 0.01509787f, 0.05776302f, 
    0.09413864f, 0.00285098f, -0.05186889f, 0.03449706f, -0.00441774f, -0.09313680f, -0.10491198f, -0.05761499f, 
    -0.01220275f, 0.01928267f, 0.02445823f, -0.08655938f, 0.01453508f, 0.01464063f, -0.03485437f, -0.00258576f, 
    -0.02871239f, 0.06417023f, -0.04996012f, 0.02331929f, 0.08859690f, -0.00360943f, 0.01050213f, -0.02598204f, 
    -0.06641948f, 0.00525922f, -0.03758705f, -0.01386058f, -0.07358377f, -0.10017336f, 0.03423038f, -0.06404383f, 
    0.07441230f, -0.01942627f, 0.00151932f, 0.08961076f, -0.04522053f, -0.05619238f, -0.01690632f, 0.04395374f, 
    0.02105288f, 0.00994213f, -0.08653352f, -0.07125804f, -0.08370901f, -0.00432762f, -0.08104250f, -0.08263080f, 
    -0.07567214f, -0.00738901f, -0.04553696f, -0.04092627f, 0.05537815f, 0.04364136f, 0.02724133f, -0.06642717f, 
    -0.07506423f, -0.06828719f, -0.02841118f, -0.03226335f, -0.03650687f, -0.06827917f, -0.09455452f, 0.03187423f, 
    0.01996825f, -0.02517476f, -0.02122514f, -0.01071412f, -0.02116096f, -0.00776132f, -0.00845083f, 0.01409951f, 
    -0.07328048f, -0.03928908f, -0.07224733f, -0.07927907f, -0.02020715f, -0.02768357f, 0.04442531f, -0.07613788f, 
    -0.00316579f, 0.00578497f, 0.04713645f, -0.02418696f, -0.10676307f, -0.00114580f, -0.07489826f, 0.00230896f, 
    -0.09002317f, 0.02277594f, -0.04740819f, -0.03212231f, -0.10219910f, -0.09554609f, -0.04905218f, 0.00066355f, 
    -0.03663772f, -0.11637188f, -0.01277596f, -0.02498260f, 0.00875556f, -0.01644379f, 0.03175753f, -0.01118368f, 
    0.09826392f, 0.07855953f, -0.01054972f, 0.07713299f, -0.05235573f, -0.05371132f, 0.03982289f, 0.06755785f, 
    -0.03175048f, -0.09400075f, -0.11611358f, -0.06888149f, -0.10357239f, -0.03432378f, -0.01673776f, -0.06616078f, 
    -0.11995184f, -0.00870800f, -0.02715103f, -0.00497700f, 0.03317045f, 0.04538317f, -0.03571043f, 0.02181721f, 
    -0.01455562f, 0.03525966f, 0.02584621f, -0.01916902f, -0.06056989f, 0.02223097f, 0.01131689f, 0.01323246f, 
    -0.01387381f, -0.05099497f, -0.03611777f, -0.05101067f, -0.01333489f, -0.08433460f, -0.06300708f, -0.06102884f, 
    -0.07425395f, -0.06817951f, -0.06065694f, -0.06441292f, 0.03109769f, 0.06211904f, -0.01403186f, -0.06037863f, 
    -0.06505352f, -0.05275418f, -0.00870593f, 0.01430358f, -0.02783016f, -0.06061227f, 0.03041953f, -0.04399653f, 
    -0.04612295f, -0.01473886f, -0.05754919f, -0.03117969f, -0.06076766f, 0.04009351f, -0.01291708f, -0.01791077f, 
    -0.04713522f, 0.00255501f, 0.01952917f, -0.02691809f, -0.03416891f, -0.02569822f, -0.01695903f, -0.02576897f, 
    -0.03524600f, -0.01184324f, 0.04641437f, -0.04640234f, -0.08214726f, 0.02588562f, -0.04196592f, 0.00676282f, 
    0.03531320f, 0.05921398f, 0.03673082f, 0.01730142f, 0.02345230f, 0.02434913f, -0.08159511f, -0.07736980f, 
    -0.02592632f, 0.05070411f, -0.07203466f, -0.01225954f, 0.01672337f, -0.04360942f, 0.06792621f, -0.02291157f, 
    0.05136143f, -0.03066067f, -0.03400525f, 0.00069416f, 0.01260802f, 0.06128916f, -0.07185094f, -0.00163158f, 
    -0.08160610f, -0.00247131f, -0.00679209f, 0.01712102f, -0.00233388f, 0.06233076f, -0.01633980f, -0.01070650f, 
    0.04396510f, 0.03448629f, 0.03274488f, 0.02995882f, -0.04876935f, 0.00804677f, 0.05173792f, -0.00011971f, 
    0.05008697f, -0.03564480f, 0.02169483f, -0.07596739f, -0.02992723f, -0.03158541f, -0.01856476f, -0.02073980f, 
    0.00762357f, 0.02302907f, -0.07255915f, 0.05284253f, 0.02490222f, -0.08650652f, 0.03162068f, -0.04138371f, 
    -0.06937058f, -0.03509486f, 0.04704998f, 0.00969848f, -0.03034761f, 0.03844687f, -0.00000939f, -0.00346105f, 
    0.02800549f, 0.04453453f, -0.00908938f, -0.02328612f, -0.03893420f, 0.01997934f, 0.00757746f, -0.00152206f, 
    0.05567165f, -0.06674309f, 0.02799149f, -0.00464219f, 0.06707627f, 0.01183724f, -0.01108570f, -0.04373137f, 
    0.03062106f, -0.08221433f, -0.04490218f, 0.01636825f, -0.07312614f, 0.02147641f, 0.05699144f, -0.04840463f, 
    0.00279914f, 0.00339394f, 0.06613105f, -0.01239358f, -0.04568986f, -0.07733393f, -0.06416146f, -0.07709794f, 
    -0.06542525f, -0.05223552f, 0.03409256f, 0.02682004f, -0.04886166f, -0.08852854f, -0.02675217f, -0.07904454f, 
    0.01332707f, -0.02574448f, 0.01357702f, -0.08589385f, -0.07389405f, -0.03137800f, 0.02390170f, -0.03038913f, 
    0.02440524f, -0.07810538f, 0.01829986f, -0.05125501f, -0.00536656f, 0.01692123f, 0.04176887f, 0.05541799f, 
    -0.01551144f, -0.00763490f, 0.00439803f, -0.04125433f, -0.00001333f, 0.00403806f, 0.04074651f, -0.01035195f, 
    -0.04949246f, -0.07939583f, -0.06052122f, -0.00229932f, 0.04947520f, 0.01669177f, -0.02350761f, 0.02160241f, 
    0.16428691f, 0.27191046f, 0.27674565f, 0.11330233f, 0.22148050f, 0.17384855f, 0.18332137f, -0.03446330f, 
    0.16166247f, 0.17117172f, -0.17484692f, 0.04834908f, 0.39505142f, 0.20495829f, 0.14858645f, 0.16635787f, 
    0.03176729f, -0.10439996f, -0.07054103f, 0.20419943f, -0.01165247f, -0.09346721f, 0.00805110f, 0.04985302f, 
    0.34709159f, 0.15404828f, 0.14837119f, 0.23715366f, 0.14892839f, 0.11203092f, -0.17160523f, 0.19146048f, 
    0.21738417f, 0.02515462f, -0.08543165f, 0.00485807f, 0.10416699f, 0.15609734f, 0.19083990f, -0.36625239f, 
    0.12634532f, 0.20902523f, -0.07221106f, 0.08189269f, -0.05713918f, -0.04915486f, -0.13098849f, -0.03659970f, 
    0.17413831f, 0.03573641f, 0.05540403f, 0.14214328f, 0.14258324f, 0.14534491f, -0.11748704f, -0.02522851f, 
    -0.19425233f, 0.21164629f, -0.06668000f, -0.07944089f, -0.01367819f, 0.01141285f, -0.20325740f, 0.12868275f, 
    -0.06775893f, -0.13206856f, 0.22027083f, -0.11077718f, -0.20392853f, -0.06589571f, 0.09763277f, -0.12543930f, 
    -0.21946260f, -0.11854384f, -0.03997012f, -0.03963916f, 0.09363508f, -0.11518323f, -0.00616111f, 0.06223860f, 
    -0.13151507f, -0.15865490f, -0.27614224f, 0.10477966f, -0.12302335f, -0.31710300f, 0.03238519f, -0.07211055f, 
    -0.14517267f, 0.21768621f, -0.12425627f, 0.10630962f, -0.17083292f, 0.00694447f, -0.16497885f, 0.05289127f, 
    0.27156344f, 0.45115763f, -0.34116769f, 0.00577617f, -0.14630048f, -0.07564592f, 0.05881355f, -0.04051868f, 
    -0.20078781f, 0.07270292f, 0.05457655f, -0.03836714f, -0.04680987f, 0.04638569f, -0.07447353f, 0.02384928f, 
    -0.06096942f, -0.02808991f, -0.01819101f, 0.00287235f, 0.00325883f, 0.14178436f, -0.00559330f, 0.15854748f, 
    0.18589763f, 0.19011475f, -0.01743131f, -0.03842951f, -0.05945518f, -0.13229282f, -0.07494444f, -0.03187270f, 
    0.06736674f, -0.14836161f, 0.09418067f, -0.04088509f, 0.04899129f, -0.21957740f, -0.29715702f, 0.06966461f, 
    0.00895414f, -0.08179723f, -0.10321543f, 0.52707708f, 0.07700653f, -0.22355986f, 0.01390121f, -0.13338588f, 
    -0.00637842f, 0.00217919f, -0.17486897f, -0.11273344f, 0.00542218f, -0.08457589f, 0.02424181f, 0.26252183f, 
    -0.19014503f, -0.09673467f, -0.13739473f, 0.00171599f, 0.08518809f, 0.03903792f, 0.07799302f, 0.14909458f, 
    -0.06893429f, -0.08451871f, -0.00870839f, -0.06812099f, 0.01435934f, -0.02425247f, 0.01795519f, -0.03920754f, 
    0.31984800f, 0.42300421f, -0.10129473f, -0.05206054f, 0.23436020f, -0.12800223f, 0.08817913f, 0.10466697f, 
    -0.08786261f, 0.04170563f, -0.12365305f, 0.00340616f, 0.32547355f, -0.35901442f, 0.48592281f, -0.12661420f, 
    -0.09178483f, -0.06935002f, 0.13208286f, -0.13160785f, -0.13287431f, 0.18404046f, 0.22041720f, -0.38896286f, 
    -0.05965088f, -0.06717430f, -0.07763510f, 0.03400945f, -0.05668567f, -0.00041106f, 0.02744203f, -0.03096079f, 
    -0.04020024f, -0.02281173f, -0.05200334f, 0.00537059f, -0.00506780f, 0.02696191f, -0.00622754f, -0.04875380f, 
    0.01318750f, -0.00339789f, -0.05351965f, -0.06599843f, 0.01246544f, 0.05686469f, 0.04097081f, 0.01894696f, 
    0.00788677f, 0.04752401f, -0.07642873f, -0.01136039f, -0.06563946f, -0.03844271f, -0.05217846f, 0.02571253f, 
    -0.05054158f, 0.00687826f, -0.03813963f, 0.01058874f, -0.03133036f, -0.05736974f, -0.07079779f, -0.04556938f, 
    -0.00119721f, -0.06640530f, 0.00361380f, 0.05225765f, -0.01342222f, 0.04880572f, 0.04642242f, -0.07240677f, 
    -0.00016799f, 0.05984394f, -0.05181950f, -0.02273445f, -0.07570443f, -0.07969150f, -0.06956090f, -0.03122424f, 
    -0.02931147f, 0.05183635f, 0.04678058f, -0.05706760f, 0.05234018f, 0.02629807f, -0.05982079f, -0.03105309f, 
    -0.02410944f, -0.06124113f, -0.05489267f, -0.04899953f, -0.06113276f, 0.04121145f, 0.05431763f, 0.05068365f, 
    -0.06369638f, -0.01647862f, -0.04163623f, -0.01173411f, 0.03625244f, 0.04578326f, -0.04311640f, 0.03569123f, 
    -0.03205259f, -0.03921434f, 0.00251828f, -0.02971219f, 0.04235413f, -0.07296338f, 0.00504019f, -0.03745443f, 
    -0.00870730f, -0.06007110f, 0.05245104f, 0.03204304f, -0.03209816f, -0.04773904f, 0.01560024f, 0.05354292f, 
    0.01141140f, -0.04257261f, 0.01374970f, 0.05413586f, -0.06586522f, -0.02270796f, -0.06701577f, -0.02322693f, 
    -0.06160222f, -0.03310486f, -0.02972049f, -0.00650622f, -0.04213333f, -0.03764889f, -0.03052606f, -0.04966378f, 
    -0.02066613f, 0.05925989f, -0.07368211f, -0.07829503f, -0.03549876f, 0.04544906f, 0.04644430f, -0.04762992f, 
    0.02799379f, -0.00824756f, -0.02345143f, -0.06001109f, 0.01409079f, -0.04460109f, 0.05981682f, -0.03679031f, 
    -0.00001616f, -0.00316253f, 0.01349110f, -0.02441811f, 0.01710082f, -0.06691348f, -0.00837700f, -0.06886842f, 
    -0.06636323f, -0.02857260f, -0.02383482f, -0.07264463f, -0.05069637f, 0.03113501f, -0.06858047f, 0.04361190f, 
    0.02475561f, -0.03823762f, -0.07510705f, -0.01686055f, -0.01589686f, 0.06536496f, -0.02867050f, 0.04931705f, 
    -0.04257709f, -0.04595168f, 0.00909828f, 0.00859416f, 0.02813762f, -0.02467304f, 0.00635661f, -0.05159920f, 
    -0.01088817f, -0.07694825f, -0.05177547f, -0.04598157f, -0.02721472f, -0.06096416f, 0.03539092f, 0.06157465f, 
    0.02238772f, 0.02013831f, 0.02518721f, -0.06705356f, 0.02239536f, 0.03492130f, 0.02436413f, -0.00934867f, 
    0.04829168f, 0.05601449f, -0.03371206f, -0.05875302f, -0.00162427f, -0.03574571f, 0.03516117f, -0.06353936f, 
    0.01059020f, 0.04636941f, 0.00816313f, -0.01071340f, 0.04450645f, -0.05306352f, 0.05540613f, 0.02348792f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02117424f, 0.02461422f, 0.22828758f, 0.07935467f, 0.15253548f, 0.05451142f, 0.23223181f, -0.26023582f, 
    0.04322540f, 0.22944330f, -0.04439902f, -0.13200763f, 0.06548487f, 0.01832063f, 0.09247354f, 0.05548532f, 
    0.21828233f, -0.05692764f, 0.37126449f, 0.01003747f, 0.07116365f, 0.02583511f, 0.13807522f, 0.08157744f, 
    -0.11243535f, 0.07483131f, 0.13194725f, -0.21347241f, -0.05104816f, -0.00785150f, -0.15732564f, -0.03909239f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02388158f, -0.05439684f, 0.17554009f, 0.22994852f, -0.21028827f, -0.05075793f, -0.26107022f, 0.30583158f, 
    0.08496895f, 0.29892242f, -0.19934608f, 0.27566218f, -0.72757864f, 0.52419704f, -0.35135144f, -0.03689341f, 
    -0.03350026f, -0.04899708f, -0.45461950f, -0.39653394f, -0.45212224f, -0.47194907f, -0.23894633f, -0.02348984f, 
    0.34637734f, 0.23984227f, -0.61047572f, 0.27844527f, 0.13542081f, 0.02108334f, 0.28899482f, 0.05281644f, 
    -0.17065541f, -0.15114760f, 0.22944593f, 0.06023606f, 0.27854118f, -0.16604574f, 0.11400137f, -0.37885687f, 
    -0.78247726f, 0.30752674f, -0.11649088f, -1.03538668f, -0.40421820f, -0.28587985f, -0.30460620f, 0.06806441f, 
    0.25228485f, -0.06436641f, -0.05610478f, -0.02331760f, -0.17244375f, -0.07396853f, 0.39408994f, 0.25034440f, 
    0.63656455f, -0.04568668f, 0.24459910f, 0.17415886f, 0.06275574f, 0.00223515f, -0.10559122f, -0.09210216f, 
    -0.05999066f, -0.00127609f, 0.19463708f, 0.06031956f, 0.12642178f, 0.15566365f, -0.53593421f, -0.29427654f, 
    0.41524521f, 0.08416803f, -0.28978506f, 0.03181463f, 0.17305331f, -0.40671918f, 0.35608777f, 0.09135344f, 
    -0.08463678f, 0.01336020f, 0.21911295f, 0.37613577f, -0.06942856f, -0.36414263f, -0.73162377f, 0.14646916f, 
    -0.51970589f, 0.18084852f, 0.26704058f, -0.98212105f, -0.09017218f, -0.08081605f, -0.40602061f, 0.07369220f, 
    0.13666457f, 0.05760365f, 0.09124616f, -0.10464311f, 0.16636053f, -0.02375585f, -0.33884761f, 0.13197492f, 
    0.40424809f, -0.46521550f, 0.10869125f, 0.25846401f, -0.12353300f, -0.56029749f, -0.07023775f, 0.06987453f, 
    -0.81809002f, -0.19742131f, -0.20330961f, 0.17903693f, 0.12217042f, 0.50681841f, -0.53821957f, 0.01752942f, 
    0.25952691f, 0.10344093f, 0.13073950f, 0.17349941f, -0.15302925f, -0.04806105f, -0.17998120f, 0.01344136f, 
    0.06579413f, 0.05418672f, -0.14315541f, 0.03996365f, -0.48134550f, 0.15610540f, -0.10336329f, 0.24084745f, 
    -0.35300165f, 0.17824145f, 0.30774486f, 0.34541267f, 0.41075897f, -0.05257199f, 0.22481996f, -0.10421643f, 
    -0.22633453f, -0.09752696f, -0.14726152f, 0.37590963f, -0.34185910f, -0.69336802f, 0.11874538f, 0.03287568f, 
    -0.17934586f, -0.08954853f, 0.09719138f, 0.14834343f, -0.06853669f, -0.13107380f, 0.28713974f, -0.09588635f, 
    0.00204073f, -0.05318581f, -0.09702159f, -0.61270499f, -0.34155807f, -0.03168006f, 0.28317320f, -0.40260521f, 
    0.20994163f, 0.21901222f, 0.17041007f, -0.23924446f, 0.29192522f, 0.53951967f, 0.02536825f, 0.10032081f, 
    0.29063314f, -0.12268109f, -0.15131633f, -0.86359411f, 0.28119683f, -0.20902957f, -0.04094365f, -0.01372037f, 
    -0.33435193f, 0.20628500f, 0.00938303f, 0.20621626f, -0.15778711f, 0.08017104f, -0.09803163f, -0.07120518f, 
    0.00158568f, 0.07234401f, -0.43142098f, 0.20340031f, 0.04219726f, 0.10599274f, -0.18902509f, -0.46110669f, 
    -0.48401651f, -0.87442189f, -0.99546057f, 0.03062045f, 0.23028158f, -0.14606853f, 0.56892020f, 0.10662832f, 
    0.24425569f, 0.12245966f, 0.56239820f, 0.14277443f, 0.14538626f, -0.24999897f, 0.05580670f, -0.45195845f, 
    -0.38834652f, -0.54015142f, 0.29942146f, -0.45132360f, 0.08309770f, 0.16696827f, -0.33360827f, -0.07419563f, 
    -0.04121737f, -0.06110871f, -0.63680780f, 0.16686714f, 0.18629688f, -0.07970796f, -0.36509669f, 0.38982937f, 
    0.43479976f, -0.20768493f, -0.13983947f, -0.11825855f, 0.08117495f, 0.06280117f, 0.08994372f, 0.08309876f, 
    -0.20950501f, 0.10602604f, -0.86474323f, 0.26901841f, 0.19717039f, 0.27084312f, 0.48104089f, -0.48459530f, 
    -0.11314007f, -0.32089233f, 0.09851818f, -0.24478184f, 0.11830021f, -0.07325742f, -0.09908772f, -0.05325831f, 
    0.07436831f, -0.03872766f, 0.31273535f, -0.05152246f, 0.21553798f, 0.07043444f, 0.33011851f, -0.69510597f, 
    0.73551464f, -0.26971096f, -0.43771604f, -0.01814443f, 0.07414842f, -0.45436168f, -0.80808955f, 0.01570632f, 
    -0.17981337f, -0.11833854f, 0.00893301f, -0.31647399f, 0.41858169f, 0.39080963f, -0.09952927f, -0.24636815f, 
    -0.52442122f, 0.03742498f, -0.39168090f, -0.76271564f, 0.10056214f, 0.00349631f, -0.14165707f, -0.10318213f, 
    0.14443627f, 0.11944922f, -0.35789976f, 0.24166177f, -0.49909213f, -0.08510748f, -0.52643949f, -0.22212633f, 
    -0.17319396f, 0.11006834f, 0.18251450f, 0.25665694f, -0.00508339f, 0.70909983f, 0.24859264f, -0.08965316f, 
    0.11865030f, -0.05090784f, 0.34913683f, 0.28901157f, -0.65551394f, 0.11683474f, 0.18371411f, 0.19163473f, 
    -0.27361822f, -0.22287560f, -0.21649352f, -0.24633028f, 0.10755686f, -0.12371184f, -0.39161295f, -0.08840787f, 
    -0.12025551f, 0.13873912f, 0.33009395f, -0.86970651f, 0.50391060f, -0.13581614f, -0.12182626f, 0.28963634f, 
    -0.28872594f, -0.41134161f, 0.17712213f, -0.81792951f, 0.25110510f, -0.20695306f, -0.14142619f, -0.02105263f, 
    -0.42521170f, 0.00720337f, 0.41783342f, -0.91597676f, -0.21165588f, -0.06689528f, -0.30365998f, 0.05566895f, 
    -0.51525795f, 0.22369298f, 0.38891608f, -0.57548010f, -0.06451873f, 0.05542173f, 0.34438398f, 0.10221866f, 
    -0.12629050f, -0.05820478f, -0.54891241f, 0.26244700f, -0.19591558f, -0.13760376f, 0.32211423f, 0.37913501f, 
    -0.46902308f, 0.11096717f, -0.30031905f, -0.05537621f, -0.07443187f, -0.69001800f, -0.72263241f, 0.11914737f, 
    0.27862993f, -0.11822786f, 0.29220328f, 0.07200630f, 0.29044783f, 0.45209906f, -0.63242394f, -0.69392085f, 
    -0.36805701f, 0.10452932f, 0.27481326f, 0.02009545f, -0.07405245f, -0.02921748f, -0.16704555f, 0.03206911f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16603070f, -0.03685516f, 0.22758584f, -0.13826157f, -0.14854106f, 0.16872124f, 0.06471255f, -0.24760522f, 
    0.24006756f, 0.00711538f, 0.23773918f, -0.03932592f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
