#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.43768159f, 0.35840687f, 0.43250468f, 0.89680582f, -0.56261361f, 0.67555732f, 0.52350342f, -0.56275666f, 
    -0.85123360f, -1.44464362f, -1.44828832f, 1.50125659f, -0.07219556f, -0.19657224f, -0.78562123f, -0.38528678f, 
    -0.34509975f, 0.25203004f, 0.72814298f, -0.95655084f, 0.05261476f, 0.72212255f, 0.10173818f, 0.34283319f, 
    1.03397882f, 0.26003742f, 0.38784537f, -0.37582353f, 0.04441567f, 1.01724434f, 0.45825791f, 0.46255356f, 
    -0.03185381f, -0.12882887f, 0.48703372f, 0.15959185f, 0.67404097f, 0.36498061f, 0.50548559f, 0.33917472f, 
    0.47119009f, 0.48504555f, 0.56763172f, -0.34052140f, 0.53200340f, -1.24952054f, -0.75079405f, -0.99160326f, 
    -0.53158200f, -0.94281781f, -0.53429961f, 0.17484580f, -0.52621675f, -0.49900994f, -0.24877788f, -0.10949912f, 
    0.27490363f, 0.79856741f, 0.86017042f, 1.11053562f, -0.79076660f, -0.84451377f, 0.57818395f, 1.10360909f, 
    -0.07374708f, 0.97331959f, -0.50071275f, 0.24646445f, -1.02865994f, -0.00038763f, 0.25342515f, 0.37658721f, 
    -0.46362239f, 0.15538716f, 0.67472023f, 0.37288254f, -0.06896676f, 0.02099079f, 0.73197722f, -1.01386845f, 
    0.12558568f, -0.25269434f, 0.07271022f, -0.39853662f, -0.67073536f, 0.20986351f, -1.00836480f, 0.79928535f, 
    0.16223358f, 1.16186106f, 0.62095368f, -0.86650932f, 0.22099340f, -1.13337052f, 0.60398722f, -1.47046304f, 
    0.62381953f, -0.98002297f, -0.44025242f, 0.41569561f, 0.58304429f, 0.62128025f, -0.64069152f, 1.18052649f, 
    -0.24709576f, -0.26268169f, -0.44031540f, -0.36447418f, 0.52364302f, -0.17622553f, 0.21221957f, 0.97274178f, 
    1.04544461f, 0.88941574f, 0.07315809f, 0.72630495f, 0.11558229f, -0.09478304f, 0.38651788f, 0.57160747f, 
    -1.53806627f, -1.77939379f, -0.77858144f, -0.05361887f, 0.12065583f, 0.04998302f, -1.60095632f, -0.39816767f, 
    -0.05299721f, 0.70468599f, 0.33980626f, -0.47684518f, -0.74922997f, -0.68350053f, -0.84694314f, -1.54312384f, 
    -1.14109421f, -1.32980764f, 0.71673703f, 0.46769553f, 0.87952715f, 0.04347094f, 0.49873590f, -0.16531838f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24932767f, 0.70032597f, 0.35738495f, 0.74856520f, 0.26781785f, -0.29573426f, 0.15318456f, 0.52272087f, 
    0.64815772f, 0.07770865f, 0.24639377f, 0.57697880f, -0.46757409f, 0.71056259f, 0.55650699f, 0.84085059f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.12382144f, 0.45946780f, -0.16237198f, 0.02234902f, -0.02460612f, 0.03028224f, 0.22671455f, 0.19640578f, 
    -0.26819551f, 0.34826478f, -0.15210274f, -0.25407630f, -0.07539345f, -0.24567536f, -0.05496200f, 0.11903682f, 
    0.00166762f, -0.04008492f, -0.05728798f, -0.23235434f, -0.01613910f, 0.13979079f, 0.00135976f, 0.03671540f, 
    -0.17086360f, -0.09199960f, -0.36170283f, 0.11745448f, -0.05095306f, -0.25740969f, 0.08254891f, 0.17323788f, 
    0.02637887f, -0.12451993f, 0.05071687f, -0.36201680f, 0.14063008f, 0.09207498f, -0.10578045f, 0.10859496f, 
    0.17646042f, 0.09129105f, 0.17741022f, -0.00744490f, -0.01287354f, 0.27935749f, -0.26452073f, -0.07417890f, 
    -0.20101026f, 0.05657735f, 0.11672757f, -0.06765204f, -0.16487551f, 0.21359806f, -0.19821236f, -0.01943396f, 
    -0.60464692f, 0.11364231f, 0.10241393f, 0.09914398f, 0.01257785f, 0.10314503f, -0.18091772f, 0.17382044f, 
    0.05037963f, -0.20815393f, 0.10183826f, 0.06186958f, -0.12690967f, 0.14999340f, -0.13164657f, -0.15635616f, 
    0.41759032f, 0.07127068f, -0.31358743f, -0.02836479f, 0.35937744f, 0.08517070f, 0.15189266f, -0.12408371f, 
    -0.17557117f, -0.19168256f, -0.18464559f, -0.20196366f, 0.22887641f, 0.24415928f, -0.23413858f, -0.32808986f, 
    -0.41842619f, -0.60506320f, 0.18986158f, 0.11866893f, 0.25316471f, 0.50291777f, 0.05137731f, -0.01520518f, 
    0.16199341f, 0.06167612f, 0.12554765f, 0.24068929f, 0.58967358f, -0.11094355f, 0.07538340f, 0.04897222f, 
    0.03715660f, 0.16317028f, -0.06499951f, 0.06557565f, 0.02645527f, 0.11983184f, 0.07373939f, 0.25242138f, 
    0.13867801f, 0.16784455f, -0.27156365f, -0.45181879f, 0.18570060f, 0.05830566f, 0.49580485f, 0.12543669f, 
    0.44952103f, 0.24350210f, 0.29506737f, -0.04530453f, -0.08782776f, -0.08538974f, -0.00670855f, -0.25416327f, 
    -0.18087824f, -0.20929576f, -0.06995079f, 0.05738194f, 0.20708425f, 0.04986757f, 0.45105484f, 0.35480067f, 
    -0.56936032f, 0.14810203f, -0.18419403f, 0.02696362f, 0.14897674f, 0.03571258f, 0.07293230f, 0.22802952f, 
    -0.33437499f, 0.35373610f, 0.20764241f, -0.25007498f, -0.01395595f, 0.15326703f, 0.08883233f, 0.17006792f, 
    -0.18355648f, -0.12860489f, -0.57239836f, 0.05143390f, 0.15565698f, 0.05132542f, 0.24140996f, 0.19283713f, 
    -0.10030107f, -0.12665127f, -0.20344259f, 0.08185986f, -0.26578385f, -0.06233967f, 0.22233725f, -0.03684220f, 
    0.03391384f, 0.23267855f, 0.37500685f, 0.08541096f, 0.09087282f, -0.13746993f, 0.23652261f, -0.07887729f, 
    0.19194603f, 0.28086749f, 0.26330605f, 0.10413921f, 0.07967527f, 0.39818981f, -0.07572521f, -0.11138373f, 
    -0.11802027f, -0.21544454f, -0.10925875f, -0.06949613f, -0.02612415f, -0.01335461f, -0.16559534f, -0.17211348f, 
    -0.28150040f, -0.35532939f, -0.16616227f, 0.02488041f, 0.02057500f, -0.20412330f, -0.12475387f, -0.28289157f, 
    -0.10574962f, 0.02116305f, 0.02540558f, -0.08782281f, -0.21824387f, -0.42493972f, -0.27775115f, 0.24611928f, 
    0.45849001f, 0.35439152f, 0.26480606f, -0.04316904f, -0.16428839f, 0.35181344f, 0.21423674f, 0.45761386f, 
    0.04478018f, 0.49555814f, 0.18209909f, 0.13095753f, 0.33508831f, 0.31530169f, 0.00700444f, 0.62177336f, 
    0.39358178f, -0.22809958f, -0.17505129f, 0.33793429f, 0.11799949f, 0.09314283f, -0.12267271f, 0.39220062f, 
    0.65660542f, 0.43177274f, -0.47532395f, 0.17800128f, 0.01588239f, -0.15888059f, -0.07944635f, -0.03771297f, 
    0.01549789f, 0.12574705f, 0.00629629f, 0.19632736f, 0.18735644f, 0.01786027f, -0.26085418f, -0.17443524f, 
    -0.03099974f, 0.13604158f, 0.07092738f, -0.29275107f, -0.27937031f, 0.00843557f, -0.33293611f, -0.09825506f, 
    -0.03429436f, -0.17958997f, -0.14542623f, -0.12886992f, -0.05894975f, 0.12096225f, -0.33151272f, 0.11609054f, 
    0.30477273f, 0.17534824f, 0.10131110f, 0.29640073f, 0.33914673f, 0.02887370f, -0.01367698f, -0.21997209f, 
    0.03117790f, 0.14118010f, 0.12240759f, 0.27436918f, -0.20374580f, -0.25596449f, 0.03615870f, -0.05896317f, 
    -0.69501847f, -0.30121735f, -0.19671893f, 0.02036688f, -0.06635506f, -0.16970694f, -0.31423593f, 0.04081879f, 
    0.19688414f, 0.26292574f, 0.00688256f, 0.11001889f, 0.17940174f, -0.05813489f, 0.02889302f, -0.14766066f, 
    0.03019617f, -0.37006450f, 0.04601466f, -0.37659192f, 0.06804594f, -0.03657438f, 0.01438652f, 0.08177048f, 
    0.32680196f, 0.01434287f, 0.25688124f, 0.08831877f, -0.15013146f, 0.02253787f, -0.14664601f, -0.27762559f, 
    0.03593995f, 0.02376435f, 0.04037637f, 0.41478127f, 0.17374754f, 0.11759738f, -0.21116549f, -0.09859864f, 
    0.15999819f, -0.04160028f, -0.00456607f, 0.09118348f, 0.31219500f, 0.11500408f, 0.14300150f, -0.00576858f, 
    -0.26308766f, -0.09412622f, -0.02449394f, -0.04983070f, 0.09827541f, -0.50751001f, -0.22915299f, 0.25089318f, 
    -0.11713405f, -0.24287945f, 0.08886711f, 0.11799390f, 0.08079572f, 0.20957474f, 0.36986804f, -0.21133460f, 
    0.25238657f, -0.01603938f, -0.21012233f, -0.23387994f, -0.20482709f, -0.34852746f, 0.15168971f, 0.11030184f, 
    0.07530019f, -0.32330084f, -0.03600518f, 0.08711942f, 0.10910001f, 0.21556772f, 0.54540288f, 0.16836525f, 
    0.04858316f, 0.30620030f, -0.29486647f, 0.05366796f, 0.28397217f, -0.00173703f, 0.02752253f, -0.10899568f, 
    0.13363856f, 0.07978170f, 0.52406967f, 0.22559099f, 0.12614372f, 0.19249719f, 0.12316963f, -0.12573564f, 
    -0.23326147f, -0.00725112f, -0.39014024f, 0.82383281f, 0.23977120f, -0.06359719f, 0.04269608f, -0.11424246f, 
    -0.22049266f, 0.06448787f, 0.06222844f, 0.22740524f, 0.01108235f, 0.27092263f, 0.13360703f, 0.08806659f, 
    0.16948085f, 0.13414116f, -0.17079812f, 0.01625849f, 0.35498428f, 0.01534310f, 0.16179566f, -0.51490939f, 
    -0.27966353f, -0.24066314f, -0.03350822f, -0.02013651f, 0.17297073f, -0.43467247f, 0.46764562f, 0.47809806f, 
    -0.11857305f, -0.01828813f, -0.14811617f, 0.16219647f, -0.05072015f, 0.06609605f, -0.34921467f, -0.56737113f, 
    -0.80377275f, -0.02005507f, -0.21100466f, 0.11831524f, -0.03494057f, -0.19630978f, -0.14123467f, -0.01696873f, 
    -1.35151827f, -1.18115556f, -0.32031947f, 0.14809340f, -0.07096678f, 0.07289583f, -0.02624841f, -0.02595979f, 
    -0.34954137f, -0.19841708f, 0.09158911f, 0.16161603f, -0.02216910f, 0.02473988f, -0.02560994f, -0.13473473f, 
    -0.34080455f, 0.03955354f, -0.00491183f, -0.05183679f, -0.00047946f, 0.31991789f, -0.07315747f, -0.06324007f, 
    -0.18561985f, -0.12505385f, -0.00227767f, -0.20308714f, -0.24258885f, 0.20918317f, 0.08333424f, -0.01831093f, 
    0.04291065f, 0.30317116f, 0.29271123f, -0.19012040f, -0.22619927f, -0.14497799f, -0.01228665f, 0.04444398f, 
    0.02488526f, 0.06033337f, 0.10717594f, 0.10380830f, -0.08651173f, -0.21242848f, -0.18887869f, 0.06715973f, 
    -0.09121954f, -0.06599423f, -0.35532969f, -0.08721989f, 0.00089959f, 0.27081916f, 0.43541315f, 0.09325261f, 
    0.12051529f, -0.16199885f, 0.09826969f, 0.09047488f, 0.06017610f, -0.13793968f, -0.11946771f, -0.08445729f, 
    -0.10655840f, 0.04987128f, 0.15879534f, -0.01029306f, 0.10431401f, -0.23908399f, -0.13424598f, -0.60451150f, 
    -0.65344137f, -0.55855393f, 0.10079456f, 0.20655502f, 0.11198082f, 0.11802175f, 0.23602593f, -0.12377845f, 
    -0.22122516f, -0.13967231f, 0.18145010f, 0.23262635f, 0.04763531f, -0.10042202f, -0.02844979f, 0.00912078f, 
    -0.04433245f, 0.54350668f, 0.48597354f, 0.53961378f, -0.18048574f, 0.19995129f, -0.00947507f, 0.36439386f, 
    0.48181051f, 0.73379505f, 0.54727232f, 0.65217191f, 0.40445065f, 0.18751238f, 0.08843391f, -0.05547501f, 
    -0.03993139f, 0.03510826f, -0.26500401f, -0.09704542f, -0.44699121f, -0.00952936f, -0.06504209f, -0.03962892f, 
    0.06559075f, 0.05803322f, -0.28450695f, 0.01496418f, 0.18799874f, -0.21952334f, -0.18393916f, 0.05102698f, 
    0.08771809f, -0.07202730f, -0.13711183f, 0.01753573f, -0.12779498f, -0.11574434f, -0.16632690f, 0.46040329f, 
    0.13330592f, 0.08538085f, 0.18261443f, 0.07998328f, 0.17048652f, 0.19642481f, -0.49165753f, -0.34268451f, 
    -0.14570767f, -0.12661126f, 0.13813168f, -0.08508289f, -0.17695610f, -0.41547737f, -0.41645867f, 0.19501552f, 
    0.25111550f, -0.00519838f, 0.14533630f, 0.01700892f, -0.15829132f, 0.15012050f, -0.05845764f, -0.07213493f, 
    -0.05374868f, -0.38302338f, 0.03802992f, 0.02283068f, -0.00069790f, -0.19359618f, 0.02408413f, 0.07318591f, 
    -0.02410929f, 0.15575798f, -0.60650575f, -0.27356541f, 0.07528234f, 0.08556403f, 0.17008784f, 0.04386820f, 
    0.06409422f, 0.16289806f, 0.24092202f, 0.07092819f, -0.38213217f, -0.27542913f, -0.29486108f, 0.02229694f, 
    0.05784120f, 0.04855208f, 0.05103822f, -0.06919858f, 0.19119437f, 0.19468385f, -0.21417476f, -0.08450283f, 
    0.19587263f, 0.25939104f, -0.01548264f, 0.02073072f, 0.14307642f, 0.09050497f, 0.13443899f, 0.24124828f, 
    0.20194679f, -0.10375071f, 0.17753510f, 0.17162886f, 0.07953215f, 0.32687142f, 0.93570602f, 0.47778106f, 
    -0.19310479f, -0.22931786f, -0.06972968f, 0.03527160f, 0.00937107f, 0.20057511f, 0.05926555f, 0.07405940f, 
    0.53844082f, -0.34731010f, 0.09016807f, -0.36107191f, -0.09383773f, 0.17008260f, 0.02578902f, -0.18542553f, 
    -0.54161173f, -0.78555703f, 0.25511843f, -0.06879911f, -0.03228587f, 0.07025450f, -0.18465127f, -0.04772916f, 
    -0.17382312f, -0.15961777f, 0.12967998f, -0.03515582f, -0.04176454f, 0.00866400f, 0.09517875f, -0.19129223f, 
    0.07632805f, -0.10369527f, 0.29687783f, -0.34841019f, -0.01560038f, -0.17853536f, -0.03256802f, -0.10400474f, 
    -0.10931069f, -0.15868565f, -0.09398206f, -0.37948322f, -0.19817308f, -0.07009112f, -0.15003766f, 0.04466021f, 
    -0.01903290f, -0.15145975f, -0.18540946f, -0.12798592f, -0.15080775f, -0.02445839f, 0.09254497f, 0.05120865f, 
    -0.19966850f, 0.20594625f, 0.16104831f, 0.29735696f, 0.20253728f, 0.23663957f, 0.01762477f, -0.27694339f, 
    -0.47235775f, -0.32714102f, 0.08467830f, 0.10232203f, -0.14336157f, -0.04903461f, -0.14824820f, 0.22057213f, 
    -0.16341144f, -0.00188042f, -0.54550910f, -0.03559194f, -0.07555126f, 0.03950100f, -0.12984635f, -0.06944279f, 
    0.16862914f, 0.01169144f, -0.14599450f, 0.12099884f, 0.28536913f, 0.10962725f, 0.03403056f, 0.40220031f, 
    0.11054292f, 0.39241317f, 0.02054613f, -0.05958870f, 0.26312268f, 0.07686946f, 0.09131951f, 0.12610509f, 
    -0.02210675f, 0.01949957f, -0.08139504f, -0.07850201f, 0.02045410f, 0.02245544f, -0.07382555f, -0.10597347f, 
    -0.05983286f, 0.04364134f, 0.00760349f, -0.01013338f, -0.05255233f, -0.09435292f, -0.00898199f, 0.00082089f, 
    -0.07145829f, 0.05524072f, -0.05262393f, 0.03624352f, -0.01281023f, -0.00949802f, 0.04507954f, -0.05946410f, 
    -0.05728472f, -0.11292224f, -0.03555726f, 0.04850789f, 0.00928848f, -0.05925376f, 0.01833433f, 0.02227579f, 
    0.01664966f, 0.00467605f, -0.04934931f, -0.05686059f, 0.00491638f, -0.11240364f, -0.02283943f, -0.03078637f, 
    -0.09591077f, -0.06905424f, -0.11468147f, 0.02017170f, 0.00332994f, 0.03529898f, 0.00810196f, -0.05239258f, 
    -0.04151437f, -0.02423861f, -0.01837437f, -0.02864347f, 0.01189177f, 0.06141195f, -0.00609864f, -0.10382104f, 
    -0.07231973f, -0.01817863f, -0.04892617f, -0.02975914f, -0.00099055f, -0.10442007f, 0.01990313f, -0.00024880f, 
    -0.04219898f, -0.04332951f, -0.04684666f, -0.08154618f, -0.02157386f, 0.03933324f, -0.09885050f, -0.10872450f, 
    -0.01327726f, -0.04395827f, -0.04913679f, -0.05658394f, -0.04897409f, -0.05766550f, 0.02156616f, -0.06572833f, 
    -0.03111106f, -0.07373557f, 0.06770520f, -0.03366983f, 0.01392611f, -0.03301547f, -0.03879270f, -0.00167615f, 
    -0.08086081f, 0.02150288f, -0.06376018f, 0.04178869f, 0.03438785f, -0.01938622f, -0.06127872f, 0.03278432f, 
    -0.08897288f, -0.00509953f, -0.09113665f, 0.04889650f, -0.05727070f, -0.07280356f, 0.02700144f, 0.01952577f, 
    0.04550076f, -0.02513485f, 0.05654917f, -0.05651334f, 0.00234744f, -0.04602853f, 0.07220873f, -0.05559684f, 
    0.02661085f, -0.05368743f, -0.02603016f, -0.02227029f, -0.03648880f, 0.00665350f, -0.06618988f, -0.08543354f, 
    -0.04174845f, -0.05645409f, 0.04627653f, 0.00152855f, -0.03601685f, -0.10217813f, -0.00422282f, -0.08266383f, 
    -0.02195050f, -0.02177931f, -0.00960285f, 0.03139248f, 0.01845153f, -0.01374654f, -0.08385384f, -0.01871570f, 
    0.07000974f, -0.08244430f, 0.00067959f, -0.06092041f, 0.03041407f, -0.00513915f, -0.10049011f, 0.01366116f, 
    -0.02651343f, 0.04823053f, -0.07168418f, -0.06938493f, -0.04668830f, 0.04743419f, 0.02830653f, -0.01097033f, 
    -0.06265632f, 0.03103382f, -0.03886933f, -0.00131275f, -0.03634249f, -0.01922117f, 0.02541114f, 0.03096746f, 
    0.04065522f, 0.06742475f, 0.07193077f, -0.00757769f, -0.01512328f, 0.06295844f, 0.01579626f, 0.05113310f, 
    -0.08450135f, -0.06063001f, 0.06932028f, -0.04903301f, 0.06041655f, 0.05262912f, 0.00281243f, 0.05179305f, 
    -0.00659080f, 0.04942591f, -0.04741289f, 0.05450275f, 0.00716161f, -0.01106505f, 0.05220987f, 0.01153844f, 
    0.07166550f, -0.07506550f, -0.08186630f, 0.00439669f, -0.06776666f, -0.00879476f, -0.05955521f, 0.06514919f, 
    -0.04749137f, 0.04831338f, 0.05482938f, -0.03809830f, 0.00077934f, 0.03827959f, 0.03039187f, 0.00308715f, 
    -0.03350293f, -0.00782731f, 0.04381580f, 0.01130610f, -0.08748641f, -0.01189493f, 0.07365075f, -0.09142443f, 
    0.02050574f, -0.00710197f, -0.01622185f, -0.02659793f, -0.02755616f, -0.08088265f, 0.01444212f, -0.04936434f, 
    -0.08766086f, 0.04121850f, 0.02877451f, -0.05395153f, -0.07761658f, -0.05000804f, -0.07505009f, 0.00159225f, 
    0.03965498f, -0.05351753f, -0.01453380f, 0.03594221f, 0.00353522f, 0.02742249f, 0.05987665f, 0.02975512f, 
    -0.07140423f, -0.05652753f, -0.03427024f, 0.03106701f, -0.03060432f, -0.02867439f, -0.03026100f, -0.07949412f, 
    -0.08827052f, -0.08826959f, 0.04719258f, 0.00532146f, 0.02698794f, -0.04931741f, 0.07053833f, 0.01352634f, 
    -0.06451349f, -0.07083414f, -0.04491229f, -0.05346125f, -0.04202700f, -0.06096235f, -0.08406177f, 0.04503979f, 
    -0.02434333f, 0.01901546f, 0.06019792f, 0.00674320f, -0.02341373f, -0.06351582f, -0.02997386f, 0.02694018f, 
    0.04794075f, 0.05472833f, 0.04048653f, -0.08365569f, -0.08206894f, 0.01843300f, 0.03950736f, -0.09000276f, 
    -0.06748430f, -0.08517810f, 0.00106976f, 0.05866126f, -0.08753239f, -0.06788367f, -0.06578563f, -0.03547078f, 
    0.06898081f, -0.09191182f, 0.01784491f, -0.02533924f, -0.09318341f, -0.03901971f, 0.02420481f, -0.08400425f, 
    -0.70119685f, 0.20682067f, 0.56237966f, 0.07038144f, -0.13412845f, -0.02586957f, 0.36695006f, 0.30285332f, 
    0.16694783f, -0.14769118f, 0.54127258f, 0.22484905f, -0.20781150f, 0.48470843f, -0.12291098f, -0.09987544f, 
    -0.06226115f, 0.12250306f, 0.11756904f, -0.11289121f, 0.37026712f, -0.11616448f, 0.15118279f, 0.30904147f, 
    0.07997245f, -0.20735092f, -0.11793873f, 0.14971857f, -0.01106960f, -0.21609551f, -0.08521392f, 0.33520764f, 
    -0.16133223f, -0.03101339f, -0.27376282f, -0.05804472f, -0.02135794f, 0.22081509f, 0.18657885f, -0.04024109f, 
    -0.24456176f, 0.00728058f, 0.20483533f, 0.16265464f, 0.24266523f, -0.08795850f, -0.68554389f, 0.49259400f, 
    0.07672746f, -0.20008641f, -0.11698055f, 0.04735623f, -0.07714095f, 0.26150355f, -0.17840146f, 0.00639611f, 
    -0.49566999f, -0.04718668f, -0.16261096f, -0.17033519f, -0.08994557f, -0.15490684f, -0.08360840f, -0.39798018f, 
    0.13318609f, 0.02633330f, -0.34601092f, 0.28676081f, 0.20100974f, 0.02074120f, -0.07095750f, -0.15773447f, 
    -0.16421820f, -0.06662623f, 0.25330013f, -0.16259058f, -0.12151950f, -0.28628236f, 0.21708968f, -0.00126372f, 
    0.40449232f, -0.16163500f, 0.32706589f, 0.31014696f, 0.01777515f, -0.06155273f, -0.63791245f, 0.07293615f, 
    -0.14839183f, -0.00062495f, 0.17947295f, 0.29736760f, 1.29057825f, -0.38446894f, -0.02182757f, 0.18087511f, 
    0.11527551f, -0.22738273f, 0.03677038f, -0.39024583f, 0.47626606f, -0.29055062f, 0.06818704f, 0.12739576f, 
    0.04365801f, 0.06451324f, 0.01308641f, 0.18867876f, 0.37613177f, 0.03298733f, 0.14414661f, -0.08802888f, 
    -0.10104852f, 0.02832626f, -0.10634883f, -0.01231385f, 0.06850813f, -0.24467731f, 0.21738534f, 0.50825161f, 
    -0.18407696f, -0.23470677f, -0.38333368f, 0.04727485f, -0.03999115f, 0.02535387f, -0.14199421f, 0.06325983f, 
    0.36084056f, 0.05009332f, 0.42835894f, -0.11765461f, -0.00391479f, 0.01304256f, 0.07166652f, -0.56134892f, 
    0.64334464f, 0.49438730f, -0.26771179f, -0.42100194f, -0.20665410f, 0.33618930f, 0.25006968f, 0.08564091f, 
    -0.35085833f, 0.26801956f, -0.36544037f, 0.09602162f, 0.00976409f, 0.19862153f, 0.21626046f, 0.28898525f, 
    0.10778705f, -0.11267262f, 0.49905011f, -0.09534771f, 0.18144538f, -0.07644634f, -0.08170366f, -0.00534481f, 
    0.08811868f, -0.29056194f, 0.37565365f, 0.14374727f, 0.11349765f, -0.06536759f, -0.06270326f, 0.11676192f, 
    -0.01523938f, 0.04109623f, -0.05948738f, 0.20774466f, 0.05952631f, -0.80355567f, -0.03839156f, 0.00976017f, 
    -0.40866357f, 0.11445270f, 0.02914378f, -0.06246672f, -0.02374393f, -0.42915130f, -0.38184202f, -0.10785001f, 
    -0.08071481f, -0.09173048f, 0.04621712f, 0.12107679f, -0.12045921f, 0.18882979f, 0.26299837f, 0.03552877f, 
    0.18991771f, 0.23458610f, -0.08482395f, 0.02511878f, -0.02878283f, 0.12903284f, -0.22487548f, -0.53174573f, 
    -0.44069225f, 0.20703410f, -0.08516635f, -0.35860860f, 0.17300679f, 0.02514727f, 0.01000738f, -0.49625847f, 
    0.32064024f, 0.12420461f, -0.26743832f, -0.01983531f, 0.29792261f, -0.04015679f, 0.04665714f, -0.19516820f, 
    -0.17791936f, 0.53573072f, 0.38974899f, -0.06754132f, 0.30971631f, 0.14077249f, 0.23042753f, 0.00182952f, 
    0.21361046f, 0.06653990f, 0.33243972f, 0.03183357f, -0.09087476f, -0.04853856f, -0.01031404f, -0.20359631f, 
    -0.01081220f, -0.19898295f, -0.36526585f, 0.04254823f, 0.02560305f, -0.10204823f, 0.06402795f, -0.06828424f, 
    0.08440606f, -0.14731100f, 0.25803643f, 0.05982715f, -0.27362779f, 0.00243854f, 0.11617113f, 0.03166650f, 
    0.06210598f, -0.07676382f, -0.14419800f, -0.00032205f, 0.18916456f, -0.08447551f, -0.28747794f, 0.10146873f, 
    -0.20749828f, -0.45908284f, -0.10058968f, 0.14820328f, 0.06688649f, -0.02997290f, 0.24704504f, 0.31533372f, 
    -0.40695453f, 0.07760244f, -0.09706746f, 0.04994078f, -0.10207729f, 0.04769309f, 0.25423425f, 0.54107940f, 
    -0.30546054f, 0.07879348f, -0.07235643f, 0.17752238f, -0.04207798f, -0.05564956f, -0.09931421f, 0.04955221f, 
    -0.54164821f, -0.31071758f, 0.19564605f, 0.02964454f, 0.17205505f, 0.02640893f, 0.03840863f, 0.14860591f, 
    0.31490970f, 0.15988499f, 0.07438438f, -0.04679658f, -0.27597705f, -0.16822229f, 0.18438913f, 0.37983438f, 
    -0.10514446f, -1.24014556f, -0.11982068f, -0.13672252f, 0.01767576f, -0.03074823f, -0.09846493f, 0.06675014f, 
    0.00211750f, 0.13318188f, 0.23111512f, -0.10467165f, -0.28556761f, 0.12920147f, 0.08314838f, 0.28724161f, 
    0.00304641f, 0.00174676f, -0.10818022f, 0.04709323f, 0.09327057f, -0.09888636f, 0.00490182f, -0.15281196f, 
    -0.10972304f, -0.18482085f, 0.07106467f, 0.03281970f, 0.15294091f, -0.20650676f, 0.01213778f, -0.01855568f, 
    -0.12816127f, -0.04950523f, 0.01135711f, -0.07861389f, -0.14399669f, 0.52074164f, -1.16768873f, -0.28071433f, 
    -0.07171554f, -0.12709148f, -0.28747645f, 0.08804831f, -0.13335006f, -0.03632699f, 0.29107273f, 0.18734708f, 
    -0.21816105f, -0.08784838f, 0.14377055f, 0.08329063f, 0.03879820f, 0.00231428f, 0.30552948f, -0.21094176f, 
    -0.34829903f, 0.52020127f, 0.14655277f, 0.25288650f, 0.11893348f, -0.01809932f, -0.18992509f, -0.02088545f, 
    0.18803103f, 0.37621093f, 0.21280982f, -0.29605448f, -0.19486079f, -0.00551573f, -0.09585812f, 0.18587907f, 
    0.09974556f, 0.14849386f, 0.55559665f, 0.44241986f, -0.20872326f, -0.08883795f, -0.01441309f, -0.03155914f, 
    -0.33914590f, 0.02070450f, -0.37886888f, -0.18011332f, 0.23817402f, 0.17786470f, 0.16888466f, -0.04924940f, 
    0.18799973f, 0.00790863f, 0.18643099f, -0.07741518f, -0.02103769f, -0.11679394f, -0.05306309f, -0.00713358f, 
    0.02060494f, 0.37125984f, 0.20661320f, 0.05524756f, 0.05305426f, -0.01136128f, -0.16699456f, 0.05009848f, 
    -0.16635224f, -0.42519340f, -0.06266221f, 0.16326107f, -0.05853660f, -1.28105140f, -1.36782217f, -0.17832336f, 
    -0.02307052f, 0.12491369f, -0.03126845f, 0.02509339f, -0.06304701f, 0.00420062f, 0.04784628f, 0.14498752f, 
    -0.08206572f, -0.15937208f, 0.13405873f, 0.05940434f, 0.02856704f, 0.21195258f, 0.25133616f, 0.61095273f, 
    0.52113241f, -0.65917212f, -0.12896128f, -0.03403870f, -0.15122676f, 0.12687950f, 0.11857456f, 0.10264619f, 
    -0.02583641f, 0.11762789f, 0.21767335f, 0.06917514f, -0.05512011f, -0.21729341f, 0.02484613f, 0.17226946f, 
    -0.13271967f, 1.05790591f, -0.10656001f, -0.02024427f, 0.15362681f, 0.03146228f, -0.13641182f, -0.11449233f, 
    0.07568235f, -0.00451533f, 0.14289260f, 0.22537829f, -0.01792501f, -0.16281003f, -0.41875744f, 0.07588162f, 
    0.11119303f, -0.00006664f, 0.11072657f, 0.09960997f, 0.19071692f, 0.16003974f, 0.11892218f, 0.15686004f, 
    0.06523019f, 0.15810861f, 0.09821061f, 0.10864370f, -0.03735290f, -0.05602989f, 0.05408820f, -0.06927641f, 
    -0.25223026f, -0.04356463f, -0.01407986f, -0.01203785f, 0.07555830f, -0.68103349f, -0.74404055f, -0.16479748f, 
    -0.22364399f, -0.05057985f, -0.18557617f, -0.12592122f, -0.06514879f, 0.01983162f, -0.11890773f, -0.08907801f, 
    -0.36129430f, 0.25669527f, -0.11372821f, -0.02392667f, 0.04172249f, 0.07372410f, 0.10755347f, -0.00800325f, 
    -0.56766236f, 0.14873566f, 0.15571769f, 0.12576389f, -0.08867341f, 0.17101192f, 0.08637881f, 0.04419554f, 
    0.11852677f, 0.22531635f, 0.10842460f, -0.01509676f, 0.03362655f, -0.11391813f, -0.10074686f, 0.21311718f, 
    0.20944029f, -0.36970937f, -1.36940002f, -0.05884501f, -0.34216550f, -0.25335133f, -0.08944710f, -0.05563349f, 
    -0.00635155f, -0.12893124f, -0.97039223f, -0.86390209f, -0.19042666f, 0.08630649f, 0.12356395f, -0.16867590f, 
    0.08801895f, -0.00190239f, 0.26558176f, -0.02558472f, -0.02014668f, 0.04691762f, -0.14509964f, -0.05072368f, 
    -0.19264121f, 0.11761324f, 0.19852424f, -0.10903911f, -0.30519655f, -0.06336807f, -0.04858368f, -0.61668193f, 
    -0.46111909f, -0.44241896f, 0.11351973f, 0.03277726f, 0.01133057f, -0.87130147f, -0.59778577f, 0.09670752f, 
    -0.02481522f, 0.15487838f, -0.16412336f, 0.03603736f, 0.06336018f, 0.11372134f, 0.00211467f, -0.30461514f, 
    0.44919577f, 0.13043174f, 0.09966392f, 0.03605377f, 0.01339163f, -0.05858167f, 0.01493722f, 0.27832264f, 
    0.36221233f, 0.86460990f, -0.00187907f, 0.21235746f, 0.05970179f, -0.03563446f, -0.02106965f, 0.06260613f, 
    0.26570046f, -0.01420140f, 0.09573191f, 0.12294099f, 0.00812451f, 0.22439840f, 0.03549638f, 0.34463423f, 
    -0.07980546f, 0.08257800f, 0.09872727f, -0.18048452f, 0.22960353f, 0.15469076f, 0.06036587f, 0.01177698f, 
    -0.01630460f, -0.06913928f, 0.38115826f, 0.08737911f, 0.15005943f, 0.05064046f, 0.08240061f, 0.06300239f, 
    -0.30656844f, 0.18664177f, 0.03066155f, 0.18886177f, 0.03068559f, 0.12484893f, 0.30594820f, -0.03457370f, 
    0.04453903f, 0.11308853f, -0.04915446f, 0.10285252f, 0.10465735f, 0.00114030f, 0.08361906f, 0.16498989f, 
    0.10487276f, -0.07671016f, -0.11968119f, -0.07659049f, 0.13931477f, -0.13469227f, -0.08468684f, 0.29491529f, 
    -0.01092794f, -0.14102118f, -0.18662468f, -0.27390790f, 0.08925261f, 0.00254975f, 0.01795745f, -0.19011776f, 
    0.06005041f, -0.07854657f, -0.14917883f, -0.14151670f, 0.31504968f, -0.23453510f, 0.19620024f, 0.10581042f, 
    -0.24385260f, -0.13537818f, 0.27804199f, 0.11375333f, 0.27934200f, 0.05242473f, 0.21026166f, 0.31554365f, 
    0.19343776f, 0.28144011f, 0.34271407f, 0.42508194f, 0.04609855f, 0.28540283f, 0.44203338f, 0.23561721f, 
    0.27334464f, -0.17986520f, -0.33554184f, -0.42981407f, -0.30020386f, -0.02051943f, -0.12809515f, 0.11549343f, 
    0.05968429f, 0.11955032f, 0.12781963f, 0.04854565f, -0.52822626f, 0.23596072f, 0.14818344f, 0.01900553f, 
    -0.00397339f, 0.08604480f, 0.28031215f, 0.35509089f, 0.01149190f, 0.30140477f, 0.03067219f, -0.02187772f, 
    -0.05284875f, 0.27339321f, -0.18930414f, 0.13033742f, 0.34326676f, -0.05665198f, -0.03384478f, 0.04835321f, 
    0.09650876f, 0.06186992f, -0.18938385f, -0.02343608f, -0.04485244f, -0.18697819f, -0.29696324f, -0.65394270f, 
    0.26481944f, 0.27508974f, 0.16040970f, 0.22891246f, 0.23324309f, 0.27395216f, -0.28820127f, -0.19941004f, 
    0.14760666f, 0.20175797f, 0.17816140f, 0.11503422f, 0.29020035f, 0.11422585f, 0.00090841f, -0.31264979f, 
    0.34590143f, 0.29408669f, 0.14390981f, -0.10073885f, -0.06124561f, -0.21368498f, -0.17085686f, 0.05352629f, 
    0.04874616f, -0.05232535f, 0.02458217f, -0.08168965f, -0.04820326f, -0.02042164f, 0.01054001f, -0.06362364f, 
    -0.07167866f, -0.03642040f, -0.00423714f, -0.08193053f, -0.00425090f, -0.05081160f, -0.06215199f, -0.00875644f, 
    -0.00150482f, -0.00109745f, -0.00962391f, 0.07716268f, 0.06636978f, 0.01616582f, 0.04464831f, 0.06243381f, 
    -0.05858495f, -0.02820072f, -0.05658867f, 0.00255725f, 0.03237314f, -0.06488827f, 0.04334087f, 0.02275204f, 
    -0.05732614f, -0.03614656f, -0.01229595f, -0.04222625f, -0.09346581f, -0.06232003f, -0.00304681f, -0.02922972f, 
    0.01988414f, -0.03985709f, -0.03996209f, 0.02712915f, -0.05285652f, -0.07077026f, 0.05687568f, 0.00084380f, 
    0.03639548f, -0.00829264f, 0.02361826f, 0.01845430f, 0.03791265f, 0.00804309f, -0.03707000f, -0.03630314f, 
    -0.00087222f, -0.08127376f, -0.09765910f, 0.06562506f, -0.02072505f, -0.08033790f, -0.06563011f, -0.00890600f, 
    -0.00505287f, -0.04322422f, 0.01562671f, -0.08705864f, -0.07279189f, -0.04412916f, -0.01648852f, -0.00973765f, 
    -0.04007061f, -0.01465523f, -0.06566848f, 0.03263955f, -0.08382208f, -0.07469808f, 0.04759894f, 0.00740054f, 
    -0.05779484f, 0.05206212f, 0.03712592f, -0.02305182f, -0.02417132f, -0.05560787f, -0.06263007f, 0.01509491f, 
    -0.02418704f, 0.01446845f, 0.06233409f, -0.06054142f, 0.01615464f, -0.07079483f, 0.00798040f, 0.06098479f, 
    -0.08376636f, 0.00996432f, -0.07596815f, -0.00170178f, -0.04023115f, 0.00931591f, -0.02680865f, -0.06077842f, 
    0.02273910f, 0.03717337f, -0.07805264f, -0.06705210f, -0.03967910f, -0.05578084f, 0.03824759f, -0.07719812f, 
    -0.08110648f, -0.00476831f, -0.01886888f, 0.00113548f, 0.04461685f, -0.06061023f, -0.06444471f, -0.05554429f, 
    -0.05259052f, 0.01211525f, -0.01907459f, -0.00306596f, 0.00030138f, 0.01290960f, -0.07057451f, -0.04340126f, 
    -0.02115061f, -0.05923777f, 0.03651376f, 0.03192220f, 0.05373689f, -0.04653105f, -0.08357542f, -0.07047050f, 
    -0.05116594f, -0.04935686f, -0.03517360f, 0.01153380f, -0.00555093f, -0.01025664f, 0.06081624f, -0.08427899f, 
    0.09471584f, -0.61798704f, 0.42817765f, -0.02085069f, 0.00803152f, -0.14068469f, 0.23828879f, 0.13456157f, 
    0.15393619f, 0.52044207f, 0.29360336f, 0.20514426f, 0.17830899f, 0.06338584f, 0.24691503f, -0.03889593f, 
    0.16704182f, 0.11235426f, 0.24452239f, -0.02105977f, -0.31440446f, -0.01626440f, 0.12712336f, 0.21080688f, 
    -0.18785121f, 0.01523332f, 0.09081110f, 0.48220310f, -0.38461617f, 0.34259135f, -0.12805565f, -0.03907908f, 
    0.50414908f, 0.01885385f, 0.32049996f, -0.08440381f, 0.27708027f, -0.35615683f, 0.02648875f, -0.15201315f, 
    0.02788013f, 0.07070488f, -0.06467152f, 0.08073416f, 0.32444221f, 0.24876820f, 0.29279804f, -0.30050167f, 
    -0.06426962f, 0.17620577f, -0.07856408f, -0.00904055f, 0.17737104f, -0.16878688f, -0.52917719f, -0.34382588f, 
    -0.00110137f, 0.00496141f, -0.05934165f, -0.41190863f, 0.14898334f, 0.13771360f, -0.18282306f, -0.75565052f, 
    -0.57022113f, 0.01811988f, -0.29020500f, -0.29685131f, 0.09288064f, -0.03116008f, -0.05926577f, -0.01149307f, 
    0.13975726f, -0.22058009f, -0.46484929f, -0.19556189f, -0.03880932f, -0.21472302f, 0.02317713f, -0.04747400f, 
    -0.05562918f, -0.64502740f, -0.20343080f, 0.55167389f, -0.12775746f, 0.02804269f, 0.09053482f, -0.08390366f, 
    0.18191360f, 0.21803346f, -0.23788407f, 0.22943772f, 0.01535101f, -0.03343573f, -0.24752934f, 0.14438826f, 
    -0.18678448f, -0.04117385f, 0.00448520f, -0.09188757f, -0.74452966f, 0.69522011f, -0.05539839f, -0.08247416f, 
    -0.09633109f, 0.24836539f, 0.19838718f, -0.29983839f, 0.15073963f, -0.20044608f, 0.13077733f, -0.27143341f, 
    -0.40039405f, -0.16465189f, -0.12370379f, 0.03479547f, -0.03630068f, -1.10638463f, -0.37940481f, -0.29629964f, 
    -0.20515452f, -0.30985004f, -0.23746587f, 0.00551930f, 0.02928022f, 0.38284844f, 0.42175734f, 0.44223145f, 
    0.20054802f, 0.21179305f, 0.15518448f, -0.05328508f, 0.22619873f, 0.03795218f, -0.39224315f, 0.41229549f, 
    0.24951054f, 0.07669979f, 0.14249763f, 0.17911924f, -0.08169838f, -0.15467463f, 0.24529429f, -0.13218743f, 
    0.00916590f, -0.03833266f, -0.01850798f, 0.06029293f, -0.08551285f, -0.03869714f, 0.04404064f, -0.01376757f, 
    -0.08560684f, 0.06236647f, -0.00004827f, 0.04708977f, 0.01266963f, -0.00108971f, -0.01175553f, -0.08742607f, 
    -0.02196923f, -0.05432631f, -0.03301035f, 0.06802092f, 0.04856310f, 0.06572181f, 0.02360102f, -0.00253325f, 
    0.02717238f, -0.02987377f, -0.03408315f, -0.07546512f, -0.00076182f, 0.00350781f, -0.04835176f, 0.01959844f, 
    0.04939098f, 0.02384590f, -0.05682933f, -0.03343828f, -0.06954167f, -0.08126960f, 0.04592276f, 0.01421532f, 
    0.05247917f, -0.01791929f, 0.07237457f, -0.00856240f, -0.08346909f, -0.04388002f, -0.04702357f, -0.07907774f, 
    -0.02038168f, -0.01406254f, -0.07272195f, 0.02732730f, -0.00607987f, 0.05428553f, -0.09360220f, -0.07007920f, 
    -0.09034940f, -0.02849465f, 0.00025695f, 0.04369230f, -0.09146966f, -0.09965135f, 0.05171559f, 0.06982961f, 
    0.06735664f, -0.05266602f, -0.05855777f, -0.09405124f, 0.02437980f, 0.01189136f, -0.01574975f, 0.01798004f, 
    0.07107376f, -0.03879045f, -0.08028227f, 0.07204226f, 0.02112734f, 0.00713612f, -0.01937818f, 0.00056770f, 
    -0.04523813f, -0.02648507f, -0.07140330f, 0.07116881f, -0.07495201f, 0.02074532f, -0.07718083f, -0.02805953f, 
    -0.09367678f, -0.05239571f, 0.03061327f, -0.11116698f, -0.03470564f, 0.06498440f, 0.03917009f, -0.03404672f, 
    -0.08677230f, -0.08358599f, -0.05480875f, -0.00623600f, 0.06069176f, -0.00909812f, -0.02100106f, -0.06723221f, 
    -0.04027146f, 0.05260543f, 0.00739091f, -0.05262560f, 0.00486630f, 0.05268789f, -0.08747040f, -0.00447096f, 
    -0.00294778f, -0.00471434f, 0.03956548f, -0.04167480f, -0.05387438f, 0.06733028f, -0.03859883f, 0.04006865f, 
    -0.09812998f, 0.05059528f, -0.09363121f, -0.06266816f, 0.00720765f, -0.07201281f, -0.01120668f, -0.06362326f, 
    0.04248726f, 0.00348211f, -0.00694648f, -0.08550926f, -0.01012875f, -0.07253636f, -0.00925193f, -0.09986446f, 
    0.03229697f, 0.01973816f, -0.09213986f, -0.07329825f, -0.06024127f, 0.02786926f, 0.05892028f, 0.04742828f, 
    -0.30411488f, -0.55388170f, -0.06211758f, -0.06227665f, -0.26131314f, 0.08469754f, 0.05930174f, -0.14847942f, 
    0.01417932f, 1.03030193f, 0.16649160f, -0.49649066f, 0.01226493f, -0.12656808f, -0.17370972f, 0.00366156f, 
    0.04795635f, -0.18118504f, -0.00428714f, -0.31642351f, -0.21696691f, -0.33863711f, 0.03643755f, -0.25843379f, 
    0.28555089f, 0.00579999f, 0.18949838f, 0.25004482f, 0.25672001f, -0.60653359f, -0.09078185f, -0.13467348f, 
    0.30844048f, 0.17698191f, -0.17707478f, -0.08398768f, 0.38346496f, -0.16309386f, -0.07186753f, 0.14785458f, 
    -0.04839231f, -0.39123729f, 0.01511714f, 0.07438410f, -0.04911366f, 0.61217856f, 0.16724333f, -0.15205492f, 
    0.24209838f, 0.11146677f, -0.09826655f, -0.12308004f, 0.02858224f, 0.05069961f, 0.35131669f, 0.26198369f, 
    0.10687059f, -0.10108772f, 0.03952281f, -0.12090112f, 0.04684991f, 0.25433233f, -0.19437505f, -0.73060662f, 
    -0.21497694f, 0.33820969f, -0.29913864f, 0.12995440f, 0.27560323f, 0.28433779f, 0.16311470f, -0.32776195f, 
    -0.37020126f, -0.16489376f, -0.31015882f, -0.00500184f, -0.21719742f, -0.13428651f, 0.15003665f, 0.15882772f, 
    -0.42339414f, 0.88300705f, 0.52597833f, 0.18446900f, 0.01838064f, -0.16569506f, 0.20082074f, -0.00134643f, 
    0.41634518f, 0.19146846f, -0.17662100f, -0.09471182f, 0.09088085f, -0.24711923f, 0.13629302f, -0.09262266f, 
    -0.16217567f, -0.01062366f, 0.08755620f, -0.43046644f, -0.34550530f, 0.56516594f, 0.13990472f, -0.02050408f, 
    0.10589524f, -0.05042019f, -0.08848347f, 0.09878352f, 0.55148047f, 0.22863147f, 0.02548243f, -0.16950756f, 
    -0.09808917f, 0.15056902f, 0.00975370f, -0.27743852f, -0.11069249f, 0.00946572f, 0.39805019f, 0.27307078f, 
    -0.39397740f, -0.09250587f, -0.05305848f, -0.01581223f, -0.02693067f, 0.03253753f, 0.60368472f, 0.13789664f, 
    -0.13882087f, -0.25842288f, 0.08580370f, -0.35595047f, 0.03037778f, 0.03379108f, -0.09575479f, 0.17297080f, 
    -0.42108694f, 0.06826319f, 0.09329546f, 0.16897780f, -0.10511298f, 0.01247305f, -0.21694236f, 0.09447749f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.20372425f, 0.75346351f, -0.04887239f, 0.17748719f, 0.21532696f, -0.08949690f, 0.04972253f, 0.15832582f, 
    -0.10200527f, 0.03109857f, 0.18105026f, 0.80240351f, 0.01307136f, 0.19286296f, -0.00518206f, -0.32821396f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08713256f, -0.67233837f, 0.40476894f, 0.13255125f, 0.44920942f, 0.13621721f, 0.23768334f, -0.74929976f, 
    0.11885831f, 0.35090807f, -0.43315861f, -0.16638727f, 0.11487053f, 0.29461294f, 0.19025503f, 0.81909811f, 
    -0.63968211f, 0.06207043f, 0.25471720f, 0.18942299f, 0.16345863f, 0.20867397f, -0.22316660f, -0.44940725f, 
    0.02663765f, 0.08523965f, -0.44960827f, 0.17062093f, -0.07794884f, 0.68386441f, 0.13367814f, -0.19992612f, 
    0.16394410f, -0.53089106f, -0.18676482f, -0.42968389f, 0.41361389f, 0.20773685f, 0.01608465f, 0.10845884f, 
    -0.60398388f, -0.81186438f, 0.99379301f, 0.12053885f, 0.08418936f, 0.44545525f, 0.23105809f, -1.24724877f, 
    0.40979102f, -0.14832744f, -0.61077374f, -0.18173984f, -0.44984254f, 0.14546271f, 0.06519516f, -0.02831529f, 
    0.50387836f, 0.29739445f, -0.75129718f, -0.15693744f, 0.24630441f, -0.16329506f, -0.00513080f, 0.52383763f, 
    0.37870425f, -0.55413920f, 0.06140153f, 0.35606173f, 0.56622207f, -0.22947080f, -0.08342935f, 0.21211496f, 
    -0.45969108f, 0.04397688f, -0.65343052f, -0.23862211f, -0.22594450f, -0.33225062f, 0.16960971f, 0.13085271f, 
    -0.24227865f, 0.01252165f, -0.03170593f, 0.29805887f, 0.12235089f, -0.18072744f, -0.04418203f, -0.22449395f, 
    0.41857734f, -0.18614028f, -0.45479280f, 0.15225860f, -0.15049060f, 0.04998826f, -0.13321340f, -0.43831488f, 
    0.24065119f, -0.19222651f, -0.74264711f, -1.11558044f, -0.35020751f, -0.19622007f, -0.03185402f, -0.02583363f, 
    -0.28684637f, 1.00876129f, 0.52022636f, -0.01916204f, 0.04109891f, -0.73750716f, 0.11400434f, -1.21274817f, 
    0.08898029f, 0.21411434f, 0.52875185f, 0.06945114f, 0.17174158f, 0.19354519f, -0.02623809f, -0.21722420f, 
    0.00659805f, 0.24237241f, 0.32677045f, -0.53361601f, -0.21443227f, -0.18011253f, 0.04797750f, 0.20604476f, 
    -0.04983030f, 0.50072467f, -0.14659959f, 0.64891237f, -0.74078268f, -0.15348972f, 0.05522368f, -0.14305791f, 
    -1.30285561f, -0.87826675f, -0.00721677f, 0.10028006f, 0.08017664f, -1.37541735f, -0.04842589f, -0.64552170f, 
    0.60669732f, -0.11995266f, -0.76240551f, -0.87074172f, 0.93679267f, -0.21217461f, 0.08717517f, -0.08869935f, 
    0.03633152f, -0.29399478f, -0.57774806f, 0.11378647f, 0.15537909f, -0.83225942f, -0.18209313f, -0.98862612f, 
    -0.51372480f, 0.23352210f, -0.56959063f, -0.07273406f, -1.02506089f, -0.14754838f, -0.13441135f, 0.64461833f, 
    -0.74545586f, 0.49643359f, -0.30725205f, -0.17159756f, -0.08617470f, 1.03134429f, -0.06342707f, -0.43510479f, 
    0.15068856f, 0.34416932f, -0.59545571f, -0.81537837f, -0.80742431f, -0.20217790f, 0.07824717f, 0.38951379f, 
    0.10658721f, -0.26039588f, -0.61405110f, 0.09986856f, 0.05501550f, -1.79822886f, 0.06243785f, -0.83330023f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.79762572f, 0.58654904f, 0.08997598f, -0.13203181f, -0.13297820f, -0.25248516f, -0.11850429f, -0.44412759f, 
    0.13105370f, 0.17235184f, -0.27507111f, 0.31184825f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
