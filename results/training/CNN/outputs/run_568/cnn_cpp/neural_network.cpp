#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.80191666f, 0.50608861f, -0.22992763f, -0.09107236f, 0.41623086f, -0.15798964f, -0.88938540f, -0.06962644f, 
    -0.51922446f, 0.40273017f, 0.08714405f, 0.38088673f, -0.07568603f, 0.21740679f, -0.23104547f, 0.12290149f, 
    -0.08571764f, -0.08254907f, 0.12330511f, -0.02854295f, -0.29923490f, 0.02862139f, -0.09484690f, -0.28603750f, 
    -0.00496706f, -0.81370538f, -0.17307276f, -0.23939085f, -0.35156524f, -0.32096273f, 0.07088298f, 0.51933610f, 
    -0.46155381f, 0.35083362f, 0.20133221f, 0.33687842f, 0.06403419f, -0.07041615f, -0.18167423f, -0.12293945f, 
    0.22135425f, 0.26868522f, 0.15822254f, 0.13754365f, -0.22265774f, 0.32802400f, 0.07423224f, 0.15345721f, 
    -0.13501810f, 0.01955893f, -0.61091036f, -1.09987736f, -0.40755239f, -0.03856797f, 0.31513372f, -0.23388000f, 
    0.74149269f, 0.36392325f, 0.20907670f, -0.20723546f, -0.30408648f, 0.01439134f, -0.17834394f, 0.15772139f, 
    -0.21391557f, -0.16110542f, -0.01806057f, -0.09887236f, 0.02115133f, 0.04045032f, 0.03951490f, -0.08128168f, 
    0.14768803f, -0.03964037f, -0.05161671f, -0.27868351f, -1.21945059f, -0.65676588f, 0.39653909f, 0.37622941f, 
    -0.57634860f, 0.31267259f, 0.16584124f, -0.61817080f, 0.19368228f, 0.31390342f, 0.11205842f, -0.03394753f, 
    -0.04296058f, 0.34308684f, -0.10280718f, 0.17782506f, 0.15564591f, -0.21874313f, 0.04703800f, -0.02114051f, 
    -0.03437828f, -0.22038096f, -0.09228423f, -0.08847910f, -0.35076711f, 0.39182937f, -0.13624559f, 0.37785736f, 
    0.36704847f, -0.13903262f, 0.77530622f, 0.56732786f, -0.18457013f, 0.50627393f, -0.41600794f, -0.18826289f, 
    0.14941473f, -0.22443694f, 0.17293584f, -0.06548131f, -0.02873776f, -0.06854732f, -0.01117897f, -0.17468143f, 
    0.38902020f, 0.03135145f, -0.07500231f, 0.19755702f, 0.01750542f, 0.63096792f, 0.28459686f, 0.54924256f, 
    0.60101837f, 0.59668273f, -0.12094682f, -0.42761320f, 0.13141136f, -0.14297642f, 0.51341361f, -0.10418929f, 
    0.03696838f, -0.10465346f, 0.10980798f, 0.12368670f, -0.21223938f, -0.13879214f, 0.08556519f, 0.04744388f, 
    -0.30912215f, 0.50165325f, 0.09693491f, -0.10000260f, -0.11369529f, 0.09887904f, 0.90425098f, 0.75903970f, 
    0.85403293f, -0.43804714f, -0.52467674f, -0.26054013f, 0.15416470f, -0.12035941f, -0.07049841f, 0.18207082f, 
    0.03676031f, 0.30542049f, -0.19273107f, 0.06959834f, 0.10887247f, 0.13735445f, 0.01303523f, 0.18447021f, 
    0.05893018f, -0.12011512f, 0.12172053f, 0.11525522f, 0.01690169f, 0.04096063f, 0.40734649f, 0.62590432f, 
    0.34958646f, 0.40909576f, 0.43851182f, 0.39643380f, 0.75277382f, 0.56667477f, 0.17250216f, -0.26735276f, 
    -0.23183499f, -0.34295452f, -0.04108446f, 0.04942873f, 0.23272213f, -0.04147813f, 0.25724232f, 0.28499830f, 
    0.11515893f, 0.15726301f, 0.37526900f, -0.18310730f, 0.10310220f, -0.13649166f, -0.26383674f, 0.14335838f, 
    0.01142926f, 0.30049381f, 0.21494716f, 0.63060427f, -0.46044466f, -0.26232886f, -0.52571589f, -0.36195755f, 
    -0.37527269f, 0.06529416f, 0.02200490f, 0.38610587f, -0.13287841f, 0.20944476f, 0.14249457f, 0.27758199f, 
    -0.26780695f, 0.09538573f, -0.01416658f, 0.41059992f, -0.24165714f, 0.25765449f, 0.19407524f, 0.02340856f, 
    -0.04859836f, -0.83385718f, -0.09684406f, -0.25183570f, -0.64174378f, -0.46845973f, 0.26273778f, -0.18374977f, 
    -0.37396514f, 0.20904090f, 0.16638942f, -0.28555277f, -0.16865878f, -0.13999583f, 0.06536987f, 0.11023436f, 
    -0.18974192f, 0.19205830f, -0.19123748f, 0.20125805f, -0.02184283f, 0.23373403f, 0.02465467f, 0.29183379f, 
    0.49655041f, 0.24409121f, 0.18029903f, 0.15663382f, 0.78890210f, -0.13131869f, -0.27254221f, 0.02297991f, 
    -0.21501473f, 0.26860669f, 0.31885234f, -0.31122771f, -0.34028539f, 0.01246715f, -0.12751010f, -0.26769808f, 
    -0.53718555f, -0.05105359f, 0.01798699f, -0.26670587f, -0.50208664f, -0.55333745f, -0.17294428f, -0.16900712f, 
    -0.15626478f, 0.00043450f, -0.26445493f, -0.47718412f, -0.07637300f, 0.58294594f, 0.66083372f, -0.02634207f, 
    -0.59380883f, 0.15200725f, -0.05117123f, 0.35377470f, 0.21844843f, 0.18804906f, 0.03406604f, -0.44045848f, 
    -0.19463663f, -0.39003369f, 0.21984424f, -0.36262959f, -0.27877551f, -0.09140109f, -0.18983474f, 0.07022835f, 
    0.18155207f, 0.21603765f, 0.21381459f, -0.22990249f, 0.49356446f, 0.63730627f, 0.08047226f, 0.94589293f, 
    0.33516642f, 0.54482007f, -0.22474903f, 0.11455979f, 0.18570514f, 0.02737044f, 0.28369713f, 0.35984123f, 
    -0.17357852f, 0.01584031f, 0.11000097f, -0.05101741f, -0.14820282f, 0.27522579f, -0.37339610f, 0.06122999f, 
    -0.19456309f, -0.24797001f, 0.16713433f, 0.12594216f, 0.10154754f, 1.03354919f, 0.31693175f, 0.16785309f, 
    0.87781584f, 0.65190953f, -0.10114267f, -0.10606838f, -0.05562489f, 0.05121510f, -0.13725065f, -0.36848772f, 
    -0.03446251f, 0.10800720f, -0.10046767f, 0.05449139f, -0.08430863f, 0.05126198f, 0.23284122f, 0.21617275f, 
    0.20361897f, 0.13347131f, 0.08250055f, 0.13800980f, 0.02874230f, 0.27913961f, -0.36757284f, 0.58467788f, 
    0.43272161f, -0.22980112f, 0.28021887f, -1.03785348f, 0.10788275f, -0.23726623f, -0.73655689f, -0.62845057f, 
    0.15239979f, 0.21948165f, -0.18499471f, -0.08195363f, -0.06699252f, -0.18553098f, -0.00498125f, 0.07486844f, 
    -0.13491854f, -0.01842123f, 0.16404136f, 0.06833621f, 0.22438210f, 0.23274614f, -0.10461066f, -0.30676359f, 
    -0.31752205f, -0.83935797f, -0.44644818f, -0.15370192f, 0.39788133f, 0.44479257f, 0.48161176f, 0.53116816f, 
    0.61503899f, 0.01568820f, -0.17253242f, 0.28574848f, -0.21570048f, -0.31938982f, -0.10317679f, 0.02646909f, 
    0.10204764f, 0.07237433f, -0.27546287f, -0.12169982f, -0.13349418f, -0.28133801f, -0.03240994f, 0.09838732f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01006626f, 0.13186119f, 0.18188509f, 0.13947186f, 0.00484015f, 0.23772115f, 0.07164806f, -0.00556614f, 
    0.19387946f, -0.02494898f, 0.19850892f, 0.28164923f, 0.15027840f, -0.06012565f, 0.07616516f, 0.02299186f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21930157f, 0.06378545f, 0.00959060f, 0.13194376f, 0.09426083f, -0.11664476f, 0.02715977f, -0.03960067f, 
    0.04298890f, 0.00741995f, 0.05659691f, 0.06405507f, -0.00407804f, -0.10200317f, -0.13457540f, -0.04987473f, 
    -0.08507825f, 0.02098872f, -0.02043932f, 0.08799295f, 0.20257647f, -0.05658425f, -0.06778774f, 0.09261295f, 
    0.11078540f, 0.18060125f, -0.09702631f, -0.13034414f, 0.02532216f, -0.06542165f, 0.05526150f, -0.06226019f, 
    0.08652941f, -0.00269622f, -0.06585380f, -0.09873515f, 0.23081754f, 0.02182775f, 0.07142533f, -0.06473267f, 
    0.10052242f, 0.09088988f, -0.04453945f, 0.01197404f, -0.05360578f, -0.07446258f, 0.14601369f, 0.01071755f, 
    -0.14013635f, 0.13330509f, -0.11626346f, -0.09770320f, -0.03950467f, 0.11688603f, -0.07253210f, 0.00735028f, 
    0.09316051f, 0.03291218f, 0.08977960f, 0.00274891f, 0.06236953f, -0.00454430f, -0.05003447f, 0.18403748f, 
    0.03430628f, 0.04344777f, -0.08747786f, 0.11447575f, -0.00932537f, -0.01810457f, 0.03484132f, 0.03390013f, 
    0.06254523f, 0.23110628f, -0.29655051f, -0.03130015f, -0.01801856f, -0.01111886f, 0.05431787f, 0.05684191f, 
    0.00190867f, -0.00643214f, 0.04549238f, 0.15557332f, 0.09934538f, -0.21945669f, 0.34195650f, 0.07781133f, 
    -0.12932605f, 0.11342932f, -0.11902246f, -0.08994251f, -0.04030620f, 0.04203596f, 0.08721586f, -0.02086239f, 
    0.19788504f, 0.01589389f, -0.18737170f, -0.03782576f, 0.18034959f, -0.01925758f, 0.12967004f, -0.04555768f, 
    -0.02760198f, 0.14296551f, -0.04341919f, 0.19409651f, -0.36693537f, -0.02437283f, 0.11408891f, -0.05810866f, 
    0.02670454f, 0.06863764f, 0.07467484f, -0.07870100f, 0.14323427f, -0.03092945f, 0.04131918f, -0.03997304f, 
    -0.30749428f, 0.00772122f, -0.07153398f, 0.04658791f, -0.02729169f, 0.02303827f, 0.05995300f, -0.01466836f, 
    0.06873444f, -0.24278997f, -0.09527671f, -0.21232787f, -0.11883116f, 0.01781140f, -0.18719983f, -0.00934304f, 
    -0.01793674f, 0.06316524f, -0.01342108f, -0.02286892f, 0.04552048f, -0.10916068f, -0.08163612f, 0.10287962f, 
    0.20372677f, -0.18389623f, 0.06711597f, 0.16450541f, 0.15301463f, 0.02216363f, 0.05019010f, -0.07734790f, 
    0.01604568f, 0.08085015f, -0.06610487f, 0.11431555f, -0.02669823f, -0.15354121f, -0.01055631f, 0.12670432f, 
    -0.05234420f, -0.09911676f, -0.13709101f, -0.03171906f, -0.04555101f, 0.03986512f, 0.06220031f, 0.13854107f, 
    0.01886113f, 0.35282367f, -0.08877863f, 0.13530901f, 0.06505320f, 0.05887420f, 0.02836072f, 0.01372213f, 
    0.05282994f, 0.23922618f, 0.00723049f, -0.00064133f, 0.20910083f, 0.10489794f, 0.01960797f, -0.15289703f, 
    -0.04604506f, -0.01328275f, -0.17967612f, -0.04482288f, 0.06288145f, -0.15849590f, 0.05575138f, -0.08793023f, 
    -0.13484539f, -0.28673911f, 0.23762533f, -0.26832989f, 0.03900584f, -0.13698664f, 0.02015140f, -0.01606460f, 
    0.02607362f, -0.07537419f, -0.04448413f, 0.02864171f, 0.30902410f, 0.20952678f, 0.00965561f, 0.17297488f, 
    0.07329394f, 0.00048776f, 0.00806764f, -0.00517785f, -0.07595060f, -0.02507942f, -0.00392608f, -0.01566666f, 
    0.02217232f, -0.06064973f, -0.01614345f, -0.06892449f, 0.00776065f, 0.15763123f, -0.06295213f, 0.19851451f, 
    0.04603019f, 0.06514971f, -0.02559901f, -0.01315849f, 0.06744852f, -0.10187836f, -0.04028733f, 0.20172931f, 
    0.02372729f, 0.02493352f, -0.03412513f, -0.10172407f, -0.00830516f, -0.05938984f, 0.00624021f, 0.05120183f, 
    0.01782824f, 0.03831594f, -0.03694559f, 0.03545197f, 0.18426864f, 0.05448447f, -0.08240438f, 0.10276867f, 
    0.05911965f, -0.03438498f, 0.10539486f, 0.02904950f, 0.01061378f, 0.05505743f, 0.07070499f, -0.07916123f, 
    -0.04318691f, -0.04909931f, 0.07526025f, -0.00581662f, 0.01803698f, -0.02447500f, 0.02294872f, -0.00816453f, 
    -0.24853122f, -0.05505111f, 0.23418328f, -0.36703524f, 0.13551919f, -0.06549660f, -0.04531561f, 0.03442555f, 
    0.01524436f, 0.03876573f, 0.06547543f, 0.05343881f, -0.00489244f, 0.12053429f, -0.32692924f, -0.21973488f, 
    0.05626686f, 0.13064897f, 0.09648915f, 0.05561851f, -0.01636929f, 0.14726597f, -0.08875000f, -0.06939501f, 
    0.08809672f, 0.08569916f, 0.11672326f, -0.03077908f, -0.10883699f, -0.16828375f, -0.05596459f, -0.02639523f, 
    -0.00997980f, -0.01410604f, 0.06993356f, 0.11222867f, 0.16904777f, 0.08892401f, -0.09947418f, 0.30399844f, 
    0.26590282f, 0.04314582f, -0.13634992f, 0.02375030f, -0.00292635f, 0.11196806f, -0.10061678f, 0.08149543f, 
    0.02750235f, 0.01209843f, 0.12465465f, -0.13833739f, -0.08754303f, 0.14052539f, -0.11343163f, -0.06597873f, 
    -0.11328221f, -0.11878787f, 0.00477282f, 0.00105239f, 0.13972163f, -0.03576288f, -0.07687072f, -0.03111390f, 
    -0.00863359f, 0.18133405f, -0.01984747f, 0.13433482f, 0.04740771f, 0.04508515f, -0.04587429f, -0.02157376f, 
    0.00215388f, -0.01251455f, -0.10121474f, -0.03822166f, 0.04250700f, 0.04989091f, -0.03567841f, 0.05120439f, 
    -0.05891581f, 0.16414294f, 0.03425358f, -0.04196095f, 0.06749991f, 0.05013777f, -0.12344930f, 0.14386544f, 
    -0.15933080f, -0.01923341f, 0.05197182f, 0.13730851f, -0.03762538f, 0.02591418f, -0.06200630f, -0.03675139f, 
    0.05677281f, 0.12995467f, -0.00736006f, -0.04122901f, -0.12091959f, -0.08458474f, 0.02085475f, 0.00605694f, 
    -0.12024825f, -0.11387955f, 0.07333861f, -0.13599807f, 0.10084025f, 0.17204249f, -0.05984958f, 0.02016771f, 
    0.20223293f, -0.04710913f, 0.07931206f, -0.00462397f, 0.05160865f, -0.00926632f, -0.03668854f, -0.06983057f, 
    -0.03679439f, -0.04130222f, -0.05501110f, -0.00381333f, 0.06821157f, 0.03796475f, -0.01230402f, -0.07718721f, 
    0.01165002f, 0.03026353f, -0.04303418f, 0.03020201f, -0.03704631f, -0.00397677f, 0.02946065f, -0.04872077f, 
    -0.02402993f, 0.00033191f, -0.05639824f, -0.06019745f, 0.03768311f, 0.01841995f, -0.00418018f, 0.03057477f, 
    0.03665718f, 0.01144521f, 0.02669641f, 0.04366994f, -0.05167190f, 0.06430351f, -0.01145587f, -0.06866789f, 
    0.00152542f, -0.04383928f, -0.00270061f, -0.07152568f, 0.05208066f, -0.02187064f, 0.04287415f, 0.04161554f, 
    -0.00366191f, 0.05794529f, -0.04236631f, 0.00491849f, -0.03407646f, -0.05146640f, -0.03424726f, 0.01168085f, 
    0.00141021f, 0.00917045f, -0.06191052f, 0.00061966f, 0.03151788f, -0.00749296f, -0.01379569f, 0.03691852f, 
    -0.01224950f, -0.05449418f, -0.04461281f, 0.02389077f, -0.07378148f, 0.01885875f, 0.02577670f, -0.02180943f, 
    0.03373837f, -0.07009675f, -0.05963121f, -0.04996590f, 0.03679605f, -0.02119980f, 0.02477756f, -0.06575400f, 
    -0.01849395f, 0.03750066f, -0.02514378f, 0.02885159f, -0.03657871f, -0.02345281f, 0.04926864f, 0.05370570f, 
    0.01280498f, 0.02918820f, -0.02282647f, -0.03310779f, 0.01179981f, -0.01715595f, -0.05037725f, 0.00256347f, 
    -0.05067822f, -0.00928784f, 0.04380153f, -0.06321107f, -0.00474168f, -0.01903050f, -0.05648788f, 0.01679935f, 
    0.06483582f, -0.03682140f, 0.03169350f, -0.05467347f, 0.04728317f, 0.05401537f, 0.05415788f, -0.04319213f, 
    -0.01049266f, 0.00883123f, -0.01848226f, -0.01174898f, -0.05166641f, -0.07258290f, 0.04388336f, -0.01013185f, 
    0.03332763f, 0.04614280f, -0.04256891f, 0.02150313f, 0.04197216f, -0.06146782f, -0.04332358f, 0.02305475f, 
    0.03385192f, -0.02877756f, -0.03304324f, 0.05259804f, -0.05731292f, -0.06836556f, -0.07375828f, -0.01268092f, 
    -0.03061233f, -0.00110369f, -0.04836777f, 0.00953187f, 0.06103935f, -0.01210562f, -0.00586478f, 0.00163892f, 
    -0.02886306f, -0.03649511f, -0.07024143f, 0.01766711f, -0.00432110f, 0.05378815f, -0.07549976f, -0.05857180f, 
    0.02028432f, -0.01604100f, -0.06055974f, -0.00334096f, -0.02212384f, 0.03233885f, 0.05535381f, -0.03420552f, 
    -0.04483157f, -0.02422623f, -0.01604171f, 0.01857059f, 0.01247980f, -0.05368114f, -0.02594445f, -0.06695382f, 
    -0.04526430f, 0.05537635f, -0.02325187f, -0.02750315f, 0.00830485f, 0.03785948f, 0.06560549f, 0.04332118f, 
    -0.03551282f, 0.00477496f, 0.02356911f, 0.02565180f, -0.05370819f, 0.06426923f, 0.00593140f, -0.06287277f, 
    -0.06675645f, 0.00581929f, -0.02883446f, 0.00682268f, -0.03032918f, -0.03553796f, -0.04919758f, -0.00896235f, 
    -0.01078046f, -0.02470708f, 0.04098670f, 0.05829646f, -0.07234067f, -0.02875212f, -0.02388171f, -0.03726751f, 
    -0.06430721f, -0.00554293f, -0.06670973f, 0.06431389f, -0.09254358f, 0.16485591f, 0.03071920f, 0.06423146f, 
    0.08137327f, 0.09174837f, 0.03723870f, -0.16569030f, -0.15011832f, 0.05444745f, 0.06361064f, 0.13127880f, 
    0.10915961f, -0.03772163f, 0.04227540f, 0.13071202f, -0.10825787f, 0.11429031f, 0.02746045f, 0.02829398f, 
    0.11669811f, -0.12158702f, 0.10870387f, 0.17940396f, 0.06081815f, 0.02579118f, 0.04596579f, 0.09367064f, 
    -0.10395084f, -0.03510376f, 0.06546615f, 0.16351825f, 0.14888410f, 0.04419839f, -0.03633723f, 0.07441404f, 
    -0.09019404f, 0.04364584f, 0.00718401f, 0.05641906f, 0.10386807f, 0.04776852f, -0.07924032f, -0.05151658f, 
    0.11335839f, -0.11647719f, 0.09430457f, 0.02985845f, 0.04505055f, -0.07875163f, 0.14739154f, -0.17500570f, 
    -0.02824106f, 0.01443053f, -0.04609356f, 0.11872584f, -0.14364228f, 0.00698391f, 0.02134806f, -0.00991470f, 
    0.01018079f, 0.08418760f, 0.11637419f, -0.12204587f, 0.01685379f, 0.08313052f, 0.08110283f, -0.03379945f, 
    -0.21425523f, -0.20130225f, 0.13438305f, 0.17025252f, 0.12534106f, 0.02350202f, 0.12522346f, 0.02185103f, 
    0.05747976f, 0.03314643f, -0.07161880f, -0.22715919f, 0.08279455f, 0.12108743f, -0.16730116f, -0.04710642f, 
    -0.02354054f, -0.09651311f, -0.03243411f, 0.09394220f, -0.01241122f, -0.01212166f, -0.09926215f, -0.05388377f, 
    -0.19024493f, -0.13029103f, 0.11891087f, -0.00547512f, -0.13614602f, -0.00365901f, -0.08615351f, 0.08396804f, 
    -0.05961848f, -0.08996441f, -0.03781516f, -0.21917546f, 0.17849834f, 0.15120041f, 0.13298018f, -0.00336375f, 
    0.01957786f, -0.10281391f, -0.15607798f, 0.10907187f, -0.14677991f, -0.10166974f, 0.07907788f, 0.09520151f, 
    0.32260901f, 0.04694258f, 0.01070189f, 0.02142470f, -0.06784975f, 0.04979287f, 0.03756121f, 0.19281933f, 
    -0.06514533f, 0.29093009f, 0.00590285f, 0.21952565f, 0.06117417f, 0.01324318f, 0.24340740f, -0.02988148f, 
    0.09696599f, 0.04063064f, -0.00922355f, -0.06349893f, -0.07796074f, 0.06661040f, 0.13081463f, -0.13727884f, 
    -0.17729963f, 0.15843861f, -0.19631019f, -0.01859841f, -0.10371667f, -0.00417698f, 0.04594106f, 0.11413956f, 
    0.01078708f, -0.10495357f, 0.01363428f, -0.11165933f, 0.21671978f, 0.26356152f, 0.02045785f, -0.11287184f, 
    0.01901785f, 0.08731517f, 0.10685475f, -0.02578330f, -0.04211046f, -0.11273072f, -0.10994071f, -0.24044952f, 
    -0.04359537f, -0.11912508f, 0.18851990f, -0.05074002f, 0.03471735f, -0.00768382f, -0.03405186f, 0.08948911f, 
    -0.12156132f, -0.11746993f, -0.02544092f, -0.02700987f, -0.16917434f, -0.16473468f, 0.03451990f, 0.06080998f, 
    -0.00689283f, -0.05559961f, 0.13022588f, 0.11739022f, 0.01274539f, 0.11731330f, -0.03700361f, 0.04767347f, 
    0.13536197f, -0.05144728f, 0.13871424f, -0.14731586f, 0.03141387f, -0.17211771f, 0.10156921f, 0.07765668f, 
    0.07841871f, -0.02073052f, -0.01220965f, -0.01375939f, 0.06828318f, -0.19353138f, -0.12653300f, -0.03824105f, 
    0.01123422f, 0.04064067f, -0.11994795f, 0.01285395f, -0.00248873f, -0.03203190f, -0.03650028f, 0.00201239f, 
    -0.16968721f, 0.18446198f, -0.13556714f, 0.11749256f, -0.00121804f, 0.01323674f, 0.02638782f, -0.01989916f, 
    -0.02683605f, -0.00814568f, -0.06664478f, 0.10100570f, 0.13188671f, -0.04362168f, -0.14464946f, 0.09510256f, 
    0.09983407f, 0.07021033f, -0.09488463f, -0.04357906f, 0.06781622f, -0.10575128f, 0.11291837f, 0.02960257f, 
    0.04473769f, 0.18064106f, -0.08097618f, 0.02375583f, -0.00271710f, 0.08064914f, 0.07159282f, -0.08160347f, 
    0.03586282f, -0.03945354f, 0.11132926f, -0.02910599f, 0.35827905f, -0.02580529f, 0.06095168f, 0.14089289f, 
    0.00615038f, -0.02430868f, -0.06601600f, 0.02308446f, -0.04035906f, -0.03395418f, -0.00025606f, 0.06900597f, 
    0.59659201f, 0.18758157f, 0.00650400f, -0.23764975f, -0.27628636f, -0.04540985f, 0.02922107f, -0.05389928f, 
    -0.08020683f, -0.03499269f, 0.06814394f, -0.00046136f, 0.35248441f, 0.04139306f, 0.16669665f, -0.01624000f, 
    -0.08673450f, 0.06236498f, -0.02026820f, -0.01330287f, -0.05789439f, 0.06361926f, -0.08226847f, -0.03636315f, 
    -0.14185315f, -0.06875540f, -0.12036712f, -0.10226585f, 0.00024523f, 0.17119530f, -0.03932117f, 0.00438981f, 
    0.06012814f, -0.10640698f, 0.05583919f, 0.01721742f, -0.12773074f, -0.05445406f, 0.14577340f, -0.06777454f, 
    0.04761578f, -0.00826437f, -0.05942376f, -0.02041304f, -0.01520668f, -0.11914945f, -0.04157962f, 0.08223685f, 
    -0.01433867f, 0.14494871f, -0.02031693f, 0.02283854f, -0.13972388f, -0.06485103f, 0.03573333f, 0.02768526f, 
    0.06522115f, 0.01782580f, 0.06106167f, -0.08189477f, -0.05855384f, 0.07607853f, -0.13619022f, 0.07707375f, 
    -0.13272342f, 0.10671837f, -0.05730363f, -0.09741355f, 0.01530576f, 0.05894797f, 0.03483483f, -0.05018518f, 
    0.41854376f, -0.02962046f, 0.04689076f, 0.21560247f, -0.07186029f, -0.03530249f, 0.03327774f, 0.08853900f, 
    -0.05782297f, 0.00077418f, -0.01418415f, 0.03065908f, 0.42316076f, 0.07398701f, 0.05980154f, 0.36941567f, 
    -0.00654708f, 0.01503157f, -0.06810868f, 0.03286045f, -0.01090656f, -0.17017928f, -0.07197876f, -0.01704401f, 
    -0.06859142f, 0.07133909f, -0.14001715f, 0.04291173f, -0.06330866f, 0.01428233f, 0.04460644f, -0.01778850f, 
    0.06941304f, 0.09338202f, 0.14745229f, -0.05005489f, 0.13770841f, -0.01993062f, 0.12183502f, 0.11202721f, 
    0.18985450f, -0.03720388f, 0.00382917f, 0.13955782f, 0.10293147f, -0.01364672f, 0.08697218f, -0.04911951f, 
    -0.14563699f, 0.07473518f, 0.11178911f, -0.12435769f, 0.05803301f, 0.08074325f, 0.04510289f, -0.08052239f, 
    -0.00551911f, -0.06297038f, 0.02443483f, 0.02020190f, -0.09717446f, -0.09883414f, 0.02588312f, 0.13846673f, 
    0.15751654f, 0.03074770f, 0.08561565f, 0.09309755f, 0.07906333f, -0.08894666f, 0.05145350f, 0.10328916f, 
    0.40126321f, -0.24500489f, 0.14062990f, -0.02296031f, -0.01831950f, 0.04351413f, 0.05203997f, -0.09176509f, 
    0.00397303f, -0.03841889f, -0.09633158f, -0.00307428f, -0.00172250f, -0.04522762f, 0.07167203f, -0.02709072f, 
    -0.16707654f, -0.07853003f, -0.05256453f, 0.23500308f, 0.08868746f, 0.16405120f, 0.14163581f, 0.09138528f, 
    0.55811685f, 0.05457839f, 0.08517595f, -0.00468905f, -0.00894439f, 0.11283907f, -0.06594323f, -0.07914192f, 
    0.04779669f, 0.05686462f, 0.09813393f, -0.07449980f, -0.15394007f, 0.00400611f, 0.16085620f, 0.14672163f, 
    -0.06810042f, 0.08254594f, -0.02369862f, 0.11525863f, -0.04386259f, 0.11217698f, 0.01144965f, -0.15650573f, 
    -0.28012827f, -0.14042898f, -0.08139105f, 0.18843469f, 0.13891487f, 0.07703150f, 0.06558690f, -0.01441889f, 
    0.01268793f, -0.00383317f, -0.03746147f, -0.01222589f, 0.21001396f, 0.21178675f, -0.04905995f, 0.07249231f, 
    0.09396537f, 0.04443141f, -0.04317812f, 0.00017513f, 0.07651996f, 0.00868215f, 0.13345593f, 0.06008610f, 
    -0.13508378f, 0.03709240f, -0.09808770f, -0.08380342f, 0.02194422f, -0.16663256f, 0.06300207f, -0.04626136f, 
    -0.03365477f, 0.19448443f, -0.11462896f, 0.04142258f, -0.02069012f, 0.07764391f, 0.22268054f, 0.16177268f, 
    0.28737062f, 0.03446825f, 0.20499189f, 0.00450150f, 0.10117815f, -0.05669608f, 0.07838934f, 0.06293666f, 
    0.10087907f, -0.04745146f, -0.01561832f, 0.17077368f, 0.00792913f, 0.03758546f, -0.01694924f, 0.02282089f, 
    -0.01631454f, -0.12265997f, -0.01515558f, -0.01913710f, -0.08313609f, -0.13327080f, 0.09773953f, 0.20776263f, 
    0.02689873f, -0.05689542f, 0.03539321f, -0.02960416f, 0.20739824f, -0.07177639f, -0.22198957f, 0.05030163f, 
    -0.27790618f, 0.09969047f, -0.01392126f, 0.08247439f, -0.03955317f, -0.00345141f, -0.03059872f, -0.02131994f, 
    -0.09927414f, -0.08509894f, 0.00947990f, -0.12087044f, -0.05414019f, -0.17133793f, 0.09486055f, -0.04316192f, 
    -0.09464672f, -0.03681079f, 0.01728148f, 0.06468115f, -0.01991493f, 0.08348681f, 0.19218862f, -0.04426755f, 
    -0.00779115f, -0.04552859f, 0.06838488f, -0.30444396f, 0.13910796f, -0.06470229f, 0.18484882f, -0.02734140f, 
    0.04416211f, 0.03510043f, -0.07528248f, 0.28120145f, 0.17336464f, 0.10634973f, 0.07092454f, -0.08928604f, 
    -0.02595544f, 0.02258474f, 0.00433233f, -0.11021009f, -0.05094629f, -0.03642314f, 0.02566749f, 0.04890357f, 
    -0.29348597f, -0.17851953f, -0.15333043f, -0.00846361f, -0.02562187f, 0.13817948f, 0.11701645f, -0.08540691f, 
    0.05319567f, -0.06524476f, -0.10770567f, -0.02570985f, -0.02395068f, -0.18791178f, 0.01477353f, 0.07751849f, 
    -0.07955903f, -0.04808074f, 0.12827286f, 0.02254673f, 0.03178544f, 0.17208986f, 0.10894501f, -0.04025296f, 
    0.16270941f, -0.05746849f, -0.09327420f, 0.09562035f, -0.10719331f, 0.00626959f, 0.05511608f, -0.04076431f, 
    0.03810077f, -0.08963440f, -0.07608265f, 0.06203621f, 0.14230913f, -0.09656162f, -0.02880585f, -0.00024610f, 
    0.01515569f, -0.00120360f, 0.08209587f, 0.22906557f, 0.10384089f, 0.06919189f, -0.01628739f, -0.00311335f, 
    0.24598533f, 0.01563784f, -0.11694935f, 0.13087794f, -0.06902312f, 0.00898701f, -0.00160173f, -0.06226772f, 
    0.06590386f, 0.15401411f, -0.04560254f, 0.02674148f, -0.34927812f, -0.03245430f, 0.16227484f, 0.19674289f, 
    0.03734113f, -0.03769584f, 0.04800491f, -0.03612836f, 0.05509238f, 0.03943751f, 0.17194128f, 0.00206503f, 
    -0.45069441f, -0.12295060f, 0.08223832f, 0.05286795f, 0.11872415f, 0.15456340f, 0.04443550f, 0.02066476f, 
    0.07100514f, 0.02178476f, -0.07681677f, -0.02107239f, -0.04071389f, 0.13033107f, -0.13205440f, -0.13021304f, 
    0.18979809f, -0.03267922f, -0.12180295f, 0.13961866f, -0.01228816f, -0.00288347f, -0.00916457f, -0.05962837f, 
    -0.09822302f, -0.06195990f, 0.17199312f, -0.08227165f, -0.07512841f, 0.08628039f, -0.02173317f, 0.03221911f, 
    0.03278629f, 0.02236096f, 0.01091555f, 0.06369227f, 0.13017838f, -0.01353890f, 0.03108405f, 0.00269545f, 
    0.00446215f, -0.15097387f, -0.01431983f, 0.10601183f, 0.05493288f, 0.08831979f, -0.03183119f, -0.00936616f, 
    0.05793771f, 0.13505797f, 0.02929447f, -0.19428732f, -0.02557872f, 0.19240391f, 0.09654474f, 0.07497787f, 
    -0.04717747f, -0.02980358f, 0.02914515f, 0.15961860f, -0.16178180f, 0.10897239f, 0.01884163f, 0.04032982f, 
    0.06027005f, 0.09385898f, 0.07049268f, -0.00697890f, 0.02059053f, -0.01107660f, -0.15395184f, 0.03407053f, 
    -0.10983387f, -0.06498893f, -0.19517636f, 0.14731388f, 0.00698012f, -0.00628908f, -0.07213417f, 0.08686566f, 
    0.06756983f, -0.09552087f, -0.03372009f, -0.02239065f, 0.06740260f, -0.05380340f, 0.09988683f, 0.06107372f, 
    -0.12411091f, -0.08359502f, -0.01488550f, -0.01392557f, 0.10894709f, 0.09172744f, 0.05588532f, -0.03634420f, 
    0.00073306f, 0.24947010f, 0.16588455f, -0.17653200f, 0.01656619f, -0.01835639f, 0.01997654f, -0.09104742f, 
    0.05049979f, 0.05616815f, 0.09092627f, 0.14508848f, 0.03026733f, -0.04519584f, 0.09268647f, 0.23510996f, 
    -0.09144078f, -0.15188341f, 0.05789817f, 0.04131950f, -0.11042406f, -0.02823654f, 0.06652426f, -0.01932972f, 
    -0.04744852f, -0.09319518f, 0.14666565f, 0.02657901f, 0.05161401f, 0.06713270f, 0.16057247f, 0.00956274f, 
    0.00689951f, 0.06086543f, -0.03595678f, 0.05923120f, -0.13206497f, -0.25540054f, -0.02882184f, 0.16169879f, 
    -0.15351434f, -0.16190146f, -0.00196339f, 0.03245730f, -0.01120329f, -0.17320129f, 0.07721497f, 0.00852550f, 
    0.10609978f, -0.01299860f, -0.23166582f, 0.24643341f, -0.19186507f, -0.11844627f, 0.03204105f, -0.03960895f, 
    0.07900658f, 0.16687971f, -0.05148929f, -0.11798360f, -0.44187337f, 0.02291552f, -0.26458868f, 0.06248021f, 
    -0.02460383f, -0.08284412f, 0.00709562f, -0.04052506f, 0.02649842f, 0.06906494f, 0.00805212f, -0.00025301f, 
    0.12234569f, -0.19197567f, -0.11478549f, -0.16133581f, 0.06137385f, 0.03487989f, 0.10559991f, 0.00255568f, 
    0.01088641f, -0.04306776f, 0.09397927f, 0.12453442f, 0.05511708f, 0.15295275f, -0.29650968f, -0.12244428f, 
    0.05760217f, 0.13988598f, 0.08314238f, 0.08099357f, -0.02564920f, -0.06431768f, 0.00618017f, 0.09621587f, 
    0.54848576f, -0.09698601f, 0.20243984f, -0.22078916f, 0.03539700f, 0.02166233f, 0.12210704f, 0.05532276f, 
    -0.07705074f, 0.05030605f, 0.12795202f, 0.11915257f, 0.21496534f, 0.25397658f, -0.19312127f, -0.28591913f, 
    0.02084482f, 0.00095221f, 0.09530275f, -0.09009380f, 0.07213420f, 0.07076856f, 0.01703945f, 0.07387610f, 
    -0.21744667f, -0.01874287f, -0.04956421f, -0.16231875f, 0.19181012f, 0.11119097f, -0.00041002f, 0.08519138f, 
    0.05773847f, 0.21426326f, 0.09591908f, 0.09064180f, -0.51323986f, -0.17731723f, 0.13190117f, 0.17644624f, 
    -0.30143458f, -0.21003120f, 0.02406392f, -0.00679899f, 0.06375699f, 0.04026468f, 0.12699442f, -0.04042443f, 
    -0.07443155f, -0.09559862f, -0.04826888f, -0.01677000f, 0.11945455f, 0.20489947f, -0.01529574f, 0.06134652f, 
    0.09373354f, -0.08044255f, 0.10407554f, 0.09051020f, 0.04450420f, -0.02342910f, -0.07990693f, 0.09415036f, 
    0.06912562f, 0.04169788f, 0.13960956f, 0.05324367f, 0.07579241f, 0.07154976f, -0.00194516f, 0.10593844f, 
    0.01524250f, 0.29693815f, 0.09625828f, -0.33004120f, 0.29014596f, 0.12023901f, 0.07581299f, 0.08804637f, 
    -0.01842245f, 0.09743521f, 0.05503396f, 0.13891707f, -0.17304459f, 0.05376848f, -0.39989096f, -0.38545206f, 
    0.13976797f, -0.11895750f, 0.10252128f, -0.00212139f, -0.14440951f, -0.04364985f, 0.00643376f, 0.07271627f, 
    -0.14224394f, -0.42152402f, -0.14405610f, 0.01346876f, -0.18855019f, 0.05518388f, 0.02485833f, 0.03201134f, 
    0.07274021f, 0.04954753f, 0.10133231f, -0.01179268f, 0.19808114f, -0.10065207f, 0.04852189f, -0.14613388f, 
    -0.02330474f, 0.09285840f, -0.03700500f, 0.08438638f, 0.04318721f, -0.02576256f, -0.02282721f, -0.05034852f, 
    -0.01637922f, 0.02593384f, -0.17920217f, 0.02933898f, 0.16871785f, -0.02602109f, 0.04929640f, 0.02285107f, 
    0.00743365f, 0.15240000f, -0.02334820f, 0.00461111f, -0.17786910f, -0.18623303f, -0.14833416f, 0.06156680f, 
    -0.00246051f, -0.07194956f, 0.12969035f, 0.00606146f, 0.03452444f, 0.05315412f, 0.15669619f, 0.04820088f, 
    0.48990625f, -0.03753705f, 0.11951768f, 0.23475409f, -0.08184522f, 0.02224937f, 0.03017681f, 0.00551103f, 
    -0.11789966f, -0.05643057f, -0.02445030f, 0.06117333f, 0.43638158f, 0.14025109f, 0.05686729f, 0.10428227f, 
    0.03253018f, 0.03229821f, 0.01321534f, -0.05119938f, 0.03748495f, 0.05760362f, 0.16370161f, -0.04610620f, 
    0.30829912f, -0.02205880f, -0.11460973f, 0.00526901f, 0.14131892f, 0.02394147f, 0.00676232f, -0.00541916f, 
    -0.05093670f, 0.16466972f, 0.06527212f, 0.11859324f, -0.19514838f, 0.11501734f, -0.05713705f, -0.03421116f, 
    0.02311948f, 0.04593242f, 0.04606517f, -0.07158785f, -0.03023852f, 0.01544202f, -0.04895043f, 0.01307577f, 
    0.48951590f, -0.12973909f, 0.10888572f, -0.01442868f, 0.01553274f, -0.00638483f, -0.02824260f, -0.03471241f, 
    -0.02558113f, -0.06977552f, 0.10406946f, 0.06997170f, -0.03266181f, -0.03200162f, -0.05519879f, -0.12154103f, 
    0.01898701f, 0.10945892f, -0.05549299f, -0.01824543f, -0.02953430f, 0.03798678f, -0.06071930f, -0.02454491f, 
    0.06352160f, 0.00233130f, -0.00258038f, -0.08151623f, 0.02578982f, -0.07023807f, 0.18543430f, -0.04270647f, 
    0.04350059f, -0.11807173f, -0.00067910f, -0.01886321f, -0.21964882f, 0.13795319f, 0.17857841f, 0.00796052f, 
    0.06220993f, -0.15246341f, -0.22974429f, 0.00523787f, -0.10176663f, -0.14723754f, 0.10120631f, -0.03230284f, 
    0.06803960f, 0.03423711f, 0.06993708f, -0.12871608f, -0.04457577f, 0.09092361f, -0.14603192f, 0.09986352f, 
    0.00145057f, -0.07194123f, 0.13611525f, 0.00396121f, -0.01760482f, 0.16728866f, 0.11531679f, -0.07564046f, 
    -0.10357819f, 0.13520931f, -0.09757173f, -0.14426610f, -0.08441082f, 0.02371319f, 0.05171461f, -0.02026540f, 
    -0.17058600f, 0.00854084f, -0.04247872f, -0.03303840f, 0.14568870f, 0.00954676f, -0.06040124f, 0.01091399f, 
    -0.01591940f, 0.12997521f, -0.03881225f, 0.01352121f, -0.12894222f, 0.09325339f, -0.18672417f, 0.09267437f, 
    0.11715139f, -0.02885997f, 0.05430669f, -0.10860382f, -0.08885843f, -0.04976476f, -0.19709517f, -0.26872560f, 
    0.14962813f, 0.22160107f, -0.20581290f, -0.15093838f, -0.25842282f, 0.10171358f, 0.00667502f, 0.06521069f, 
    0.04887944f, 0.02787460f, 0.11541776f, -0.14187855f, 0.20850073f, -0.23947558f, 0.13785848f, 0.13804267f, 
    -0.05439655f, -0.03405594f, -0.08939860f, 0.18674792f, -0.04118329f, 0.02268477f, 0.11524709f, 0.00013055f, 
    -0.13792031f, -0.01657626f, -0.35721415f, 0.32338721f, 0.20921768f, 0.27504158f, 0.01925792f, 0.00082978f, 
    0.21173085f, 0.01110170f, 0.02198409f, 0.09016005f, -0.05393566f, 0.26129127f, 0.06906689f, 0.06619352f, 
    -0.10752720f, 0.07431745f, 0.06957154f, 0.05005894f, -0.11136505f, 0.05191165f, 0.20490068f, -0.10698432f, 
    0.46214759f, -0.01913939f, 0.26343894f, 0.11839549f, -0.03620227f, -0.17381312f, 0.16396828f, 0.13491392f, 
    0.00054014f, -0.08637518f, 0.14897180f, 0.07706922f, 0.22247256f, 0.02668706f, 0.18630038f, 0.13668458f, 
    -0.09130625f, -0.08051693f, 0.08347299f, 0.03283553f, -0.10555822f, 0.11314344f, 0.04653991f, 0.05393097f, 
    -0.38351455f, -0.10933252f, -0.18731667f, -0.01071504f, 0.02214301f, 0.03741116f, 0.03508254f, 0.09703322f, 
    0.04158320f, 0.16165611f, -0.04209137f, 0.28516522f, -0.21238296f, -0.06922519f, -0.27543631f, -0.16501603f, 
    0.09430292f, 0.03211853f, 0.04791448f, -0.17099613f, -0.07080533f, -0.07866489f, 0.09010231f, 0.02954033f, 
    -0.19153759f, -0.23882945f, 0.01460479f, 0.22321050f, 0.24487606f, 0.07636865f, 0.03690935f, -0.05287013f, 
    -0.12408108f, -0.00055074f, -0.03190789f, 0.11305973f, -0.11782020f, -0.34968799f, -0.01101477f, -0.07045417f, 
    -0.06355661f, -0.04023015f, 0.00591204f, -0.05644963f, -0.03798341f, 0.07035623f, -0.05161494f, -0.03958664f, 
    -0.02916356f, -0.05240222f, -0.02281553f, 0.10903940f, 0.25799316f, 0.04491173f, 0.08059154f, 0.13515258f, 
    -0.12516248f, -0.07977292f, 0.04370530f, -0.08506442f, 0.08196417f, 0.30323935f, 0.21032178f, -0.00446068f, 
    -0.01334215f, -0.18697661f, -0.13227214f, -0.02493888f, -0.03051502f, 0.04441129f, 0.12692223f, 0.04725636f, 
    0.04692330f, -0.13008015f, -0.05629245f, 0.04006378f, 0.05051117f, -0.03733039f, -0.00496520f, 0.21564054f, 
    0.07829928f, 0.05971837f, 0.03704027f, 0.20078942f, -0.22914718f, 0.08070482f, 0.20314343f, -0.07127646f, 
    0.13566360f, 0.05473231f, 0.12048564f, -0.07786374f, -0.05975554f, -0.03965300f, 0.16244683f, 0.08706322f, 
    -0.33947894f, -0.01919482f, -0.16919325f, -0.13522880f, 0.19004749f, -0.09430949f, 0.02418345f, 0.04853965f, 
    0.01054868f, -0.05214595f, 0.07302657f, -0.06265269f, -0.21227810f, -0.02549454f, -0.08674216f, -0.40625629f, 
    -0.01371838f, -0.01345855f, -0.00904445f, 0.01375272f, 0.14234005f, -0.04240290f, -0.09674656f, -0.11819404f, 
    -0.02071182f, 0.12225154f, 0.01933363f, -0.00746208f, 0.19442195f, 0.13276210f, 0.01302111f, 0.12223047f, 
    -0.17310791f, 0.05705385f, 0.00009518f, 0.07088351f, 0.01266458f, -0.03901196f, 0.05338455f, -0.13834560f, 
    -0.15051663f, 0.01220642f, 0.16140895f, 0.00263025f, -0.01350283f, 0.04363923f, 0.06034198f, 0.10304739f, 
    0.07514167f, -0.00578532f, 0.18047738f, 0.14550820f, -0.12392651f, -0.04773234f, 0.09967694f, 0.07064317f, 
    0.00703624f, 0.01777641f, 0.07053328f, -0.08062012f, 0.19389708f, 0.23074761f, 0.11924935f, -0.01566804f, 
    0.03127197f, 0.08240198f, 0.06274550f, 0.02316192f, -0.01816975f, -0.05297798f, -0.01490376f, 0.08804508f, 
    -0.42241809f, 0.39376417f, -0.12446108f, -0.04286947f, 0.09145282f, 0.02540685f, 0.14974542f, 0.13761009f, 
    -0.02820341f, 0.11943322f, -0.00650852f, 0.00505353f, -0.20109959f, 0.01203572f, 0.10488719f, 0.14192392f, 
    0.09467683f, 0.09376208f, 0.11981370f, -0.00531341f, 0.03248470f, -0.03190490f, -0.10174693f, -0.02387761f, 
    -0.37400183f, 0.08491613f, -0.01542360f, -0.17408364f, -0.04202941f, -0.00161267f, 0.04740806f, 0.09177259f, 
    0.04066897f, -0.11037683f, 0.06113553f, -0.05637844f, 0.06592729f, -0.25204960f, -0.12140613f, 0.02274101f, 
    -0.02281883f, 0.05552834f, -0.03915633f, -0.11435477f, -0.02566454f, -0.00320734f, -0.11389603f, -0.00726281f, 
    -0.12576336f, 0.14381218f, -0.06440074f, -0.29256511f, -0.09105081f, -0.05679714f, 0.00471594f, 0.13414302f, 
    0.00936213f, 0.03665268f, -0.12582564f, -0.00369386f, -0.30561051f, -0.10620861f, -0.01835658f, 0.01871519f, 
    0.04714106f, -0.04090705f, 0.17001632f, -0.03365680f, -0.06632034f, 0.03221328f, -0.07679956f, 0.13103625f, 
    0.23678164f, -0.06019192f, 0.04930257f, 0.08599532f, -0.06165751f, 0.01641987f, -0.07424200f, 0.13070174f, 
    -0.08594803f, -0.18938184f, 0.05528168f, 0.07848933f, 0.19493283f, -0.09403870f, -0.06268144f, 0.01061766f, 
    0.20922475f, 0.05630020f, 0.11888679f, 0.17844221f, -0.07193812f, 0.00841922f, 0.10041706f, 0.05172475f, 
    0.09401642f, 0.12821411f, 0.08453920f, 0.06645598f, -0.05014300f, -0.04895186f, 0.16511597f, -0.10197996f, 
    -0.04045611f, 0.14661470f, -0.01022990f, -0.13189620f, -0.05904641f, 0.17337894f, -0.01368718f, 0.00470270f, 
    -0.01524202f, 0.02575414f, 0.01637078f, 0.12826221f, 0.00640376f, -0.01539887f, 0.04549932f, 0.04357453f, 
    0.01416632f, -0.15866838f, -0.04964915f, -0.05225205f, -0.08173914f, -0.02769991f, -0.02322821f, -0.03839298f, 
    -0.12135057f, 0.06517971f, -0.03690163f, -0.01885831f, 0.13971476f, -0.22055502f, -0.00343087f, 0.01237034f, 
    -0.02557793f, 0.00109218f, 0.02062253f, 0.00301092f, -0.06250453f, -0.06646276f, -0.08814689f, 0.14197695f, 
    0.08340738f, 0.08816172f, 0.15830588f, 0.27466109f, 0.04048878f, -0.08911887f, 0.07861253f, 0.01353311f, 
    -0.03474198f, -0.04223575f, -0.00345493f, -0.05788398f, 0.05079409f, 0.14254735f, -0.21059492f, -0.02427651f, 
    0.09896435f, 0.04132935f, 0.01580334f, -0.00989077f, -0.04469411f, 0.02355789f, -0.03722934f, -0.00387834f, 
    0.15735461f, -0.08529695f, -0.11613743f, 0.14100987f, 0.12593549f, 0.05632932f, 0.11379961f, -0.02613591f, 
    0.09391722f, 0.07100170f, -0.01259086f, 0.01618832f, 0.17855000f, 0.04268301f, -0.06380825f, -0.05381803f, 
    -0.16646151f, -0.10345338f, -0.05353595f, 0.04747365f, 0.02580063f, 0.03004975f, -0.01635565f, 0.00239115f, 
    -0.22520390f, 0.17517576f, 0.02249835f, 0.03621775f, -0.13238095f, -0.00739351f, 0.06365027f, 0.04734290f, 
    -0.02404628f, -0.05222225f, 0.09571399f, -0.02279299f, 0.10760204f, -0.10524421f, -0.01295427f, 0.17760533f, 
    -0.02178649f, 0.10955065f, 0.03943433f, -0.09671504f, 0.00467595f, -0.01693665f, -0.07770956f, 0.08923912f, 
    -0.02333063f, 0.10192870f, -0.20455325f, 0.17477353f, 0.00124197f, -0.04543064f, -0.06778336f, 0.00535891f, 
    -0.01926536f, 0.13209581f, -0.06568658f, 0.09648252f, 0.01533984f, -0.14856993f, -0.10234407f, 0.21636884f, 
    0.02560349f, -0.02683459f, -0.02970986f, -0.04878838f, 0.04893505f, 0.04767237f, 0.07244565f, 0.01456226f, 
    0.28930700f, 0.21149153f, -0.19004112f, -0.17506459f, -0.14142394f, -0.00729791f, 0.02144822f, 0.06694651f, 
    0.07581931f, 0.01835697f, -0.00383378f, 0.12666741f, 0.07293093f, -0.27919593f, 0.09532414f, 0.10500040f, 
    -0.00973809f, 0.02936721f, -0.02232382f, -0.02500190f, -0.06609689f, 0.02230784f, -0.03810233f, -0.02844811f, 
    0.10372154f, -0.16071111f, -0.07193230f, 0.13965292f, 0.09028140f, 0.03244122f, -0.00401645f, 0.00779937f, 
    0.16927300f, -0.05647148f, 0.10155474f, 0.09606424f, 0.12697490f, 0.05022784f, 0.10879326f, -0.30030701f, 
    -0.14905871f, -0.07368666f, -0.04312908f, 0.04461599f, 0.07120327f, -0.02780920f, 0.03672016f, -0.08210679f, 
    -0.08293901f, 0.14317511f, -0.02006768f, -0.20164959f, -0.08364241f, -0.02822380f, 0.01869144f, -0.02749405f, 
    0.03686216f, -0.04550898f, 0.01035789f, -0.00394920f, -0.15652375f, 0.12590626f, -0.06617069f, 0.09443571f, 
    0.07303495f, 0.03856371f, -0.03329154f, -0.09094111f, -0.09992918f, 0.02091652f, 0.05063149f, -0.01192244f, 
    0.19446386f, -0.16158676f, -0.09791408f, 0.27657619f, 0.11784366f, -0.07589581f, 0.07177185f, 0.06973430f, 
    0.02831965f, 0.10955182f, 0.04232088f, -0.03991606f, 0.12539180f, -0.12087185f, -0.04203159f, 0.29332116f, 
    0.06967331f, 0.04410310f, -0.04623200f, -0.09018616f, 0.05845446f, -0.01682030f, -0.08073154f, -0.03519739f, 
    -0.14302939f, 0.35291812f, -0.02161506f, 0.01665699f, -0.01864613f, 0.14310299f, -0.02496127f, -0.12290525f, 
    0.10398037f, 0.02593408f, 0.12592573f, -0.15452826f, 0.20604528f, -0.03305052f, 0.00749775f, -0.05180525f, 
    -0.01687364f, -0.07535690f, -0.00580018f, 0.10376202f, 0.02025201f, 0.02740100f, 0.04289164f, -0.05471452f, 
    -0.24555999f, -0.24848686f, -0.06212034f, 0.04775715f, 0.02557605f, 0.10462487f, -0.02372168f, 0.02993902f, 
    0.01245384f, 0.10250100f, 0.05499420f, -0.02104897f, 0.06235391f, 0.26671368f, 0.14214747f, 0.01848297f, 
    -0.12717398f, -0.01178401f, 0.00883632f, 0.01048737f, -0.05028790f, 0.00063719f, 0.10492749f, -0.00768752f, 
    -0.09985761f, -0.04864193f, 0.09881520f, -0.00780685f, -0.00824309f, -0.07147887f, 0.03125498f, 0.04377142f, 
    0.01198913f, -0.03902303f, -0.00337175f, 0.05526172f, 0.16909309f, -0.14657581f, 0.11713716f, 0.13806577f, 
    -0.09517854f, -0.00523096f, 0.05211788f, -0.00720636f, 0.00436180f, 0.07233687f, -0.04980510f, 0.05682132f, 
    -0.00879334f, 0.04692932f, -0.05386708f, 0.04951235f, -0.00776437f, -0.10068599f, 0.07429683f, -0.03858363f, 
    0.10067529f, 0.09741858f, 0.00977024f, -0.00284978f, -0.09222218f, -0.18626580f, 0.08073833f, 0.09432454f, 
    -0.04289338f, -0.07489932f, 0.02966140f, -0.06163203f, 0.07584912f, 0.15326856f, 0.04144247f, 0.00477415f, 
    -0.64041823f, -0.16578861f, -0.03377412f, -0.12691283f, 0.10718537f, 0.00565257f, 0.07017043f, -0.00515724f, 
    0.03075320f, 0.05750284f, -0.14613524f, 0.05262144f, -0.17819051f, -0.03559038f, -0.24300893f, -0.09095800f, 
    0.01528171f, -0.04242219f, -0.04860257f, 0.10352004f, -0.07644715f, 0.06270139f, 0.01503546f, -0.01194139f, 
    -0.11002575f, -0.10312623f, 0.00841305f, 0.15413205f, -0.08889058f, -0.04771262f, -0.02470176f, 0.09014776f, 
    0.04478183f, 0.02157638f, -0.00403298f, 0.07719341f, 0.33614486f, 0.17913762f, -0.01122136f, 0.11621770f, 
    0.10830044f, -0.05305717f, 0.02906363f, -0.05772411f, 0.01952753f, 0.00449003f, -0.03657500f, 0.10129765f, 
    0.16193843f, 0.15323710f, 0.02207859f, -0.17773005f, -0.01123645f, -0.04527320f, -0.02263856f, -0.01153122f, 
    -0.03994530f, 0.01994359f, -0.06951124f, 0.05820397f, -0.00344923f, 0.01360026f, -0.02779841f, 0.07170138f, 
    0.07251804f, 0.05963090f, -0.04029400f, 0.03336109f, 0.07100510f, 0.00882638f, 0.04781685f, 0.00697631f, 
    -0.02186883f, 0.04924462f, -0.08405205f, 0.06077026f, 0.00883763f, -0.01970413f, 0.06291719f, 0.06977370f, 
    0.06758205f, 0.06400760f, -0.00396686f, -0.00123361f, 0.13937253f, -0.08827014f, -0.00172758f, 0.12434130f, 
    -0.00186712f, -0.01453167f, 0.02490413f, 0.07041498f, 0.03067002f, 0.12916742f, 0.00880213f, 0.08297952f, 
    -0.16432528f, 0.10701916f, 0.37647936f, 0.00135228f, 0.07607576f, -0.09459858f, -0.04931290f, -0.08040421f, 
    0.04325864f, -0.01044790f, -0.02617163f, -0.04593755f, 0.05252178f, 0.22634938f, -0.03945914f, 0.16977219f, 
    -0.02861607f, -0.09850664f, 0.10608746f, 0.01449905f, 0.04895410f, 0.02161174f, 0.08928505f, -0.08401100f, 
    0.05596137f, -0.14906451f, 0.10993902f, -0.24030483f, 0.19396232f, -0.10322057f, 0.19248781f, 0.04049565f, 
    0.01095530f, 0.00431769f, -0.03731179f, -0.11466227f, 0.21644962f, -0.08476746f, -0.08801351f, 0.01776506f, 
    0.01731114f, -0.03742751f, 0.01188087f, 0.07526559f, 0.01808355f, -0.01823078f, 0.03982875f, 0.05849311f, 
    0.26589578f, -0.13529526f, 0.09831157f, 0.07044281f, -0.14582637f, 0.06876835f, 0.07152724f, 0.23187415f, 
    -0.06770810f, 0.03113554f, 0.00775241f, 0.02815526f, 0.33360216f, -0.15810178f, -0.12802717f, 0.22641149f, 
    -0.05842114f, -0.05179130f, -0.19482788f, 0.05093224f, -0.04657783f, -0.04720294f, 0.11393525f, 0.11679646f, 
    0.43587986f, 0.06333884f, -0.13700865f, 0.15710941f, 0.13304302f, 0.01792212f, -0.14524989f, -0.09785403f, 
    0.00331704f, 0.18268330f, -0.01747827f, 0.01979271f, -0.07166573f, -0.09038828f, 0.10465556f, 0.09822319f, 
    -0.02019748f, -0.03413121f, 0.01877610f, 0.00472862f, -0.10035282f, -0.00162427f, 0.05648031f, 0.02116489f, 
    -0.02726609f, 0.11438534f, 0.02059981f, -0.15856335f, 0.02575396f, 0.08531436f, -0.06254702f, -0.05753970f, 
    -0.03652845f, 0.02247153f, -0.01441769f, 0.15852331f, 0.06201032f, -0.04051550f, -0.07375666f, 0.01477292f, 
    0.02719798f, 0.11059558f, 0.00301912f, 0.04101609f, -0.04989013f, 0.05138315f, 0.00316822f, 0.09883361f, 
    -0.14735056f, 0.05383223f, -0.13790162f, -0.03151880f, 0.04036693f, 0.03473610f, -0.02145193f, -0.04111356f, 
    0.01086553f, 0.10044187f, -0.03655047f, 0.06307970f, 0.06838215f, 0.02921516f, 0.02126870f, -0.17723008f, 
    0.08367779f, 0.02337790f, -0.07019776f, 0.03760678f, -0.00026337f, 0.02746575f, 0.03706248f, 0.07127719f, 
    -0.11431377f, 0.07273898f, 0.00928469f, -0.01660233f, -0.12568243f, -0.03261026f, 0.03322144f, -0.03328803f, 
    0.03457380f, -0.18878648f, -0.06210108f, -0.01104193f, -0.01298738f, 0.00128020f, -0.01040137f, 0.13866934f, 
    -0.00178391f, 0.07354228f, -0.08312899f, -0.12227578f, 0.05879576f, -0.17945834f, -0.08332869f, 0.06267007f, 
    0.03292078f, 0.00227604f, -0.03895594f, 0.19124077f, 0.00592331f, -0.00646591f, -0.11298232f, 0.08822223f, 
    -0.08622045f, 0.15268385f, -0.07226703f, -0.04979903f, 0.01085222f, -0.09757496f, -0.25615594f, 0.31590194f, 
    -0.05450200f, 0.01697443f, -0.05896695f, 0.07689797f, -0.01366930f, 0.04301578f, -0.06492365f, -0.06688509f, 
    0.02617884f, 0.31255317f, -0.22825517f, -0.33069924f, 0.04006703f, 0.17014690f, 0.03913241f, 0.04287656f, 
    0.10892247f, -0.07963225f, 0.11263948f, -0.03936783f, 0.32298490f, 0.15046760f, 0.11058686f, -0.15567406f, 
    0.02792437f, -0.01276775f, -0.04854817f, 0.11245119f, 0.07024942f, -0.05380523f, -0.07517216f, -0.04843580f, 
    -0.18189771f, -0.08830079f, 0.19850388f, 0.13301378f, 0.07420025f, 0.18393517f, 0.01818914f, -0.16508643f, 
    -0.03393707f, -0.09899625f, 0.00959634f, -0.03242522f, 0.31633106f, -0.35131583f, 0.14621946f, 0.26055661f, 
    -0.01705402f, -0.00280016f, 0.15622938f, 0.00043452f, -0.07047504f, 0.04865375f, 0.04065271f, 0.06493095f, 
    -0.06883710f, 0.06477455f, -0.21872182f, 0.28185180f, -0.04774532f, 0.06421285f, 0.10885473f, 0.23248670f, 
    -0.06205257f, 0.03818605f, 0.06025314f, 0.01518789f, 0.13211770f, -0.12212078f, -0.18431173f, 0.21711050f, 
    0.09214062f, -0.02468980f, 0.03194285f, 0.07101837f, -0.06025144f, 0.04647133f, -0.00530965f, 0.08859248f, 
    0.23190339f, -0.32926869f, -0.24392800f, -0.22131224f, 0.15789753f, -0.04882865f, 0.13129963f, -0.04244579f, 
    0.04288635f, 0.02649822f, 0.01664615f, 0.13302422f, -0.20715939f, -0.12407333f, -0.11888727f, 0.02537507f, 
    0.23918395f, 0.04333584f, -0.11457793f, -0.23737890f, -0.04585318f, -0.03161741f, -0.02119086f, -0.00299411f, 
    -0.06955622f, -0.21806993f, 0.35685340f, -0.14799716f, 0.09841811f, 0.16970643f, -0.00950086f, -0.09177354f, 
    -0.01312746f, 0.02073805f, -0.08385773f, 0.05178536f, -0.27470663f, 0.07985033f, -0.13830259f, -0.28619456f, 
    0.24034287f, -0.01397873f, 0.01782604f, 0.00024882f, 0.02580603f, -0.07976627f, -0.04838635f, -0.01972541f, 
    -0.03482612f, 0.14210400f, 0.16460943f, -0.00783984f, 0.06474278f, 0.10635482f, -0.00302493f, 0.08323303f, 
    0.02124769f, -0.15473469f, -0.15735666f, -0.03138826f, 0.15387943f, -0.40136787f, 0.07334238f, 0.13191830f, 
    0.07555741f, -0.10655767f, -0.29734883f, -0.09441316f, 0.03904421f, -0.00390576f, -0.05961287f, 0.03118976f, 
    0.25270006f, 0.07045250f, -0.02117448f, -0.07275172f, -0.03427613f, 0.17105985f, 0.03940590f, 0.01203296f, 
    0.03487744f, 0.09937896f, 0.19840580f, 0.21715346f, 0.22317928f, 0.06362918f, -0.01271846f, 0.00121543f, 
    -0.05825085f, 0.12475771f, -0.10983811f, 0.02253877f, 0.09163968f, 0.20537806f, 0.06937984f, 0.16699101f, 
    -0.12718095f, 0.14359853f, -0.03743690f, -0.18288152f, 0.14766820f, 0.03694791f, -0.14425342f, -0.00504363f, 
    0.01489116f, -0.03676079f, 0.07400382f, -0.03256492f, -0.15428883f, 0.00958001f, -0.20725332f, -0.15026563f, 
    0.16621391f, 0.00192056f, 0.07863680f, -0.01730809f, -0.12911925f, -0.10830655f, 0.00293009f, -0.07465734f, 
    0.31036115f, 0.16668685f, 0.07467554f, -0.04140173f, -0.12337854f, 0.01262798f, -0.07363430f, 0.08398039f, 
    0.00297155f, -0.04300151f, 0.04585390f, -0.05277500f, 0.04815693f, 0.09048324f, 0.01735171f, 0.17565434f, 
    0.00059981f, -0.07408052f, 0.15568534f, 0.15535687f, -0.13504118f, 0.04233035f, -0.05969680f, 0.06955814f, 
    -0.06848943f, 0.00157746f, -0.03636817f, -0.06623985f, -0.07442429f, -0.06866171f, -0.00373836f, -0.02928317f, 
    -0.02950657f, -0.00680441f, 0.01748909f, 0.01833900f, 0.00048733f, 0.07024876f, -0.05000483f, -0.03691955f, 
    0.05858522f, -0.02359952f, -0.05276278f, -0.02511441f, -0.06184070f, -0.05444318f, 0.05200830f, -0.06089161f, 
    -0.06396141f, -0.07020828f, -0.00379778f, 0.05136611f, 0.04428557f, 0.04084561f, 0.02659956f, -0.07087391f, 
    -0.05079436f, 0.02478170f, -0.05989422f, 0.05349253f, -0.03750744f, -0.04447959f, 0.06160506f, 0.06525078f, 
    0.02784890f, -0.05656957f, 0.00293523f, -0.03532158f, -0.00136493f, -0.00776203f, -0.04663529f, 0.05328665f, 
    -0.07180525f, 0.05293171f, 0.00587272f, -0.01129802f, 0.01222173f, -0.06305271f, -0.01777948f, -0.05318694f, 
    0.01654467f, -0.02361612f, 0.03726446f, -0.04664467f, -0.05913869f, -0.05063067f, 0.00211041f, 0.01234270f, 
    0.02527613f, 0.05593140f, -0.00458455f, 0.04479833f, -0.02663629f, 0.01493110f, 0.06693602f, -0.01151520f, 
    0.05299157f, -0.05619379f, 0.03872748f, -0.00623768f, -0.07853964f, -0.02560567f, 0.02859223f, 0.02971500f, 
    -0.05924723f, -0.02034788f, 0.03461460f, -0.02184605f, -0.02486709f, -0.06193063f, -0.00350684f, -0.06725452f, 
    0.00568932f, -0.03871127f, -0.04875603f, -0.05200823f, -0.06811758f, -0.00497312f, -0.07094535f, 0.03536857f, 
    0.01793315f, -0.05988825f, -0.04411932f, -0.03670168f, 0.03041681f, -0.00931832f, 0.04531964f, -0.04705919f, 
    0.01620801f, 0.01430544f, -0.02921138f, 0.00138660f, -0.07141254f, 0.06170306f, 0.01283860f, -0.00526828f, 
    0.00977667f, 0.04903619f, 0.04455079f, 0.04476125f, 0.04482080f, -0.02666823f, -0.05870620f, -0.03556615f, 
    -0.01902568f, -0.01958643f, -0.00983307f, -0.05077801f, 0.00688940f, 0.06620477f, -0.00704083f, 0.01831589f, 
    -0.03879743f, -0.02370572f, -0.07046027f, 0.03176201f, -0.00533075f, 0.02541200f, -0.01072782f, 0.03590890f, 
    0.05500967f, 0.06400785f, 0.01615682f, 0.04709506f, 0.06478052f, -0.03578677f, 0.03887786f, 0.02350119f, 
    0.05739598f, 0.02086691f, 0.05580819f, -0.04640946f, 0.06174131f, -0.04003720f, -0.04700411f, -0.06683730f, 
    -0.02991614f, -0.06881658f, -0.00587734f, 0.03451216f, -0.03505206f, -0.00797186f, 0.04211487f, -0.05674624f, 
    -0.06109652f, -0.03401349f, -0.01339883f, -0.02979392f, -0.03031883f, -0.00665807f, 0.02865397f, 0.00398676f, 
    -0.01943755f, -0.01762756f, 0.00813059f, 0.03515331f, 0.04058328f, 0.04187564f, -0.01380624f, -0.01282043f, 
    0.04631595f, -0.02377155f, -0.05775912f, 0.01512220f, 0.04852029f, 0.03056973f, -0.06675479f, 0.03711837f, 
    -0.02686911f, -0.06317101f, -0.04904643f, 0.00789732f, 0.02431894f, -0.01078218f, -0.03928527f, -0.01827701f, 
    0.39928192f, 0.11025870f, 0.35615185f, -0.09048119f, 0.02148786f, 0.15710171f, -0.00829914f, 0.08026193f, 
    -0.03055119f, -0.10918935f, 0.05736633f, -0.09774817f, 0.38699895f, 0.02488610f, 0.05723045f, -0.06887919f, 
    -0.06235300f, -0.04855301f, -0.06475569f, -0.01260526f, 0.03936901f, 0.11472263f, -0.03585012f, -0.02153759f, 
    0.06974072f, 0.17635992f, -0.00737128f, 0.20694187f, -0.09473006f, -0.00574291f, 0.15586194f, 0.14160433f, 
    -0.00970054f, 0.11121112f, 0.08650965f, -0.00135805f, 0.07878668f, -0.03026001f, 0.09601190f, 0.16879423f, 
    -0.10524702f, -0.04454128f, 0.01601590f, 0.02803339f, -0.02839223f, 0.03584424f, -0.02319939f, 0.04511831f, 
    0.10329584f, -0.14954506f, 0.07455941f, 0.02530173f, -0.00971748f, 0.02030237f, -0.02963073f, -0.10640117f, 
    0.12357412f, 0.09190387f, 0.03232164f, 0.08383375f, 0.03329817f, -0.18934579f, -0.12102406f, 0.06829011f, 
    -0.14304422f, 0.07541515f, -0.12263616f, -0.22685829f, -0.19052804f, -0.03396491f, 0.02209347f, -0.16200885f, 
    -0.08213854f, 0.17539442f, 0.04371607f, 0.15853710f, 0.12344202f, 0.01250080f, -0.09665101f, -0.07026479f, 
    -0.18767498f, 0.05257519f, -0.15451194f, 0.12323934f, -0.04077926f, -0.13534306f, -0.17699143f, 0.08529007f, 
    0.04677349f, -0.10644630f, 0.02581389f, -0.01294873f, 0.07525206f, -0.10295720f, 0.11454649f, 0.15025754f, 
    0.11036002f, 0.08760565f, -0.07963942f, 0.08021340f, 0.17854835f, -0.00243370f, -0.20288731f, 0.04977150f, 
    0.02451105f, 0.05144630f, -0.02716990f, 0.12390222f, 0.19488706f, 0.05845998f, 0.07986598f, -0.35520220f, 
    0.02350190f, 0.02932240f, -0.09450616f, -0.05668121f, 0.22462846f, 0.06631982f, 0.00877987f, 0.13841593f, 
    0.07278443f, -0.00476911f, -0.11365315f, 0.03834145f, -0.10607471f, -0.04585471f, -0.08866344f, -0.04940196f, 
    -0.04869242f, 0.19257243f, -0.06597734f, -0.01817189f, 0.11786586f, -0.08972726f, -0.06491009f, 0.33881071f, 
    0.06746442f, -0.06081317f, -0.22600399f, 0.06730165f, 0.02551633f, -0.01256083f, 0.03159778f, 0.01165606f, 
    0.06033149f, 0.00399197f, -0.23258102f, 0.03392167f, -0.02803272f, -0.13034245f, -0.02352457f, 0.03411537f, 
    0.01722254f, 0.13460140f, 0.05146314f, -0.13672361f, -0.13289742f, -0.08530690f, -0.28213239f, -0.06558570f, 
    -0.18759921f, -0.06703103f, 0.04376488f, -0.04113568f, 0.05178982f, 0.01774557f, 0.04372102f, 0.10400519f, 
    -0.06715064f, 0.18409055f, -0.05802169f, -0.07299951f, 0.14565411f, 0.05495868f, 0.02287837f, 0.02150172f, 
    -0.03919638f, -0.07496251f, -0.06492791f, 0.15679267f, 0.26801324f, 0.23603629f, -0.19820580f, -0.41718420f, 
    -0.08603989f, -0.04855626f, 0.07440300f, 0.00257685f, 0.00981762f, 0.03516504f, -0.11738286f, 0.11145625f, 
    0.02760250f, 0.17216764f, -0.04453216f, -0.25837439f, 0.19148414f, 0.01779521f, -0.07802358f, 0.04541643f, 
    0.10822432f, -0.01954944f, -0.00653168f, -0.05361683f, 0.03680353f, -0.29876301f, -0.15631065f, -0.02271823f, 
    0.01939034f, 0.03119414f, 0.05809584f, -0.05282462f, -0.02572982f, 0.14047833f, -0.04266379f, -0.01570836f, 
    0.44093877f, -0.30954784f, 0.01263668f, -0.05457614f, -0.06385958f, -0.01993243f, -0.05019238f, 0.01354886f, 
    0.05411664f, -0.11562501f, -0.04471999f, 0.12542698f, 0.11282571f, 0.04710258f, -0.05662370f, -0.07152618f, 
    -0.02553117f, 0.01544616f, -0.04889100f, 0.08528636f, -0.00248283f, 0.03924495f, 0.02409763f, 0.09707613f, 
    0.37671056f, -0.01104885f, -0.03985029f, 0.16911198f, 0.13026096f, 0.05168536f, -0.05013584f, -0.02986914f, 
    0.12388358f, 0.16255984f, 0.05667501f, 0.00085149f, 0.05325709f, 0.21565542f, 0.14276373f, -0.14160326f, 
    0.05755488f, 0.04206584f, 0.00731764f, 0.16048172f, 0.02817057f, 0.06827524f, 0.06494188f, 0.06938461f, 
    0.09308585f, 0.12445892f, 0.00869584f, 0.20645183f, 0.07312059f, 0.07473408f, -0.15920581f, 0.00559820f, 
    0.07116503f, 0.01189950f, 0.06662406f, 0.05341850f, 0.15703601f, -0.04390449f, 0.07064429f, -0.00199838f, 
    -0.06720497f, 0.06568952f, -0.04471069f, -0.01332885f, -0.04677386f, 0.03931077f, 0.14464337f, -0.08869749f, 
    -0.04938257f, 0.12151555f, -0.07578007f, -0.13887140f, 0.07770054f, -0.01695525f, 0.10040130f, -0.14038719f, 
    -0.03591430f, 0.06261326f, -0.09495642f, 0.06564823f, -0.29372770f, -0.02066134f, 0.00676698f, -0.11348287f, 
    -0.14599748f, 0.07035209f, -0.16748586f, -0.06924150f, 0.01020652f, 0.10102703f, 0.03508713f, -0.02839921f, 
    -0.21203688f, -0.00403393f, 0.01251246f, -0.06260177f, -0.02420005f, 0.06582756f, -0.01772937f, -0.03729542f, 
    0.02400921f, -0.11189917f, 0.00643731f, -0.06672977f, 0.14672723f, -0.27930161f, 0.02142723f, -0.06464902f, 
    0.00797848f, -0.03003587f, -0.06162699f, -0.07755088f, 0.06803160f, -0.14407514f, 0.05305887f, 0.05101153f, 
    -0.06820828f, 0.02161531f, 0.10959280f, -0.02048157f, -0.02835590f, -0.03855388f, -0.06664973f, 0.03346126f, 
    0.06000971f, 0.02010597f, -0.03191239f, 0.15577373f, -0.10156276f, 0.03153789f, 0.08570716f, 0.00470796f, 
    -0.02208773f, 0.02927758f, 0.02456192f, 0.01974066f, -0.05604793f, 0.15356673f, 0.04019592f, -0.02699145f, 
    0.02056554f, 0.00081079f, -0.26891026f, -0.26197693f, 0.09318139f, 0.14788032f, 0.08824359f, -0.00116822f, 
    0.05199007f, 0.00862869f, 0.03229323f, 0.14307895f, 0.16998327f, -0.09820875f, 0.22720343f, 0.02470651f, 
    -0.00701898f, 0.00715745f, -0.07308208f, 0.06716137f, 0.01269924f, -0.00054821f, 0.06320283f, 0.03202720f, 
    0.03777855f, 0.00942766f, -0.01141248f, 0.00566308f, 0.06020062f, 0.02457914f, 0.03960536f, 0.00877959f, 
    -0.03907584f, 0.02086272f, -0.04068564f, -0.04938290f, -0.02610838f, 0.05783242f, -0.01989971f, -0.01104798f, 
    0.02093519f, -0.07338636f, -0.07328876f, -0.02519552f, -0.06920184f, -0.00635135f, 0.06415415f, -0.04556291f, 
    0.02187682f, -0.05259038f, 0.02342135f, -0.04611248f, -0.00155900f, -0.06889899f, -0.05027834f, -0.05790472f, 
    -0.05361004f, 0.01024303f, -0.06819684f, -0.04235301f, 0.03478749f, -0.02756440f, -0.02727450f, 0.04730088f, 
    -0.06370257f, 0.04346110f, 0.02153481f, -0.02492843f, 0.00457330f, -0.03109753f, -0.06025607f, -0.02203792f, 
    -0.03228248f, 0.03587124f, -0.03572280f, -0.05273474f, -0.07022835f, 0.02281635f, -0.06102229f, 0.01896060f, 
    -0.01607077f, 0.00249834f, -0.06320438f, 0.00433388f, 0.00428217f, 0.02133984f, 0.02554167f, 0.05888973f, 
    0.05372601f, -0.05468131f, -0.02737489f, 0.03649310f, 0.06610601f, -0.04943857f, -0.05515664f, -0.05900945f, 
    -0.06526523f, -0.06624026f, 0.04228783f, -0.01919105f, -0.06307326f, -0.03267117f, -0.01314252f, 0.01368246f, 
    0.02811018f, -0.05596615f, -0.07649364f, -0.07152697f, -0.01177663f, -0.06591267f, -0.06684603f, 0.01605439f, 
    -0.00613087f, -0.04050127f, 0.03922998f, -0.00830338f, -0.05495223f, -0.04985739f, -0.00610938f, -0.07087478f, 
    0.03749903f, -0.02435710f, 0.05957540f, 0.02231185f, -0.01851283f, -0.00843293f, -0.02540897f, 0.02084504f, 
    0.01637481f, 0.00734747f, 0.03862257f, 0.05639324f, -0.00300682f, -0.04728947f, -0.02396931f, 0.04147575f, 
    -0.00663192f, 0.02348068f, -0.05974691f, 0.01879524f, 0.04338094f, 0.01366920f, 0.01182455f, -0.05141503f, 
    0.06367528f, -0.07285454f, 0.03335111f, -0.01352628f, 0.03283954f, -0.00958444f, -0.05170351f, 0.03854742f, 
    0.02438360f, -0.05786536f, -0.01951610f, -0.02687190f, -0.00074365f, -0.02774085f, 0.00366227f, -0.02638879f, 
    -0.02697561f, 0.02725900f, 0.03783229f, 0.06388125f, -0.05045455f, 0.01650055f, 0.04724944f, 0.03802765f, 
    -0.01043152f, -0.02459287f, -0.06997279f, 0.06610113f, 0.02230221f, 0.04027584f, 0.03113319f, -0.03370657f, 
    0.03627623f, -0.06136794f, 0.05996543f, 0.00870313f, -0.02746328f, -0.00099192f, -0.01136656f, 0.06568935f, 
    0.00919690f, 0.04219531f, 0.02310070f, -0.03316540f, -0.07706193f, -0.02900201f, -0.04221343f, -0.01938634f, 
    -0.01202186f, -0.01086590f, -0.05314646f, 0.00763956f, -0.05859588f, -0.01550216f, -0.02234096f, -0.07567714f, 
    0.02362683f, 0.05342604f, -0.03938562f, -0.05259989f, 0.00629091f, -0.01049652f, -0.01419513f, -0.05205899f, 
    0.03251122f, -0.02336398f, -0.00831183f, -0.06583197f, 0.06523215f, -0.04856005f, -0.04702427f, -0.03239227f, 
    -0.00280171f, -0.03037575f, 0.03691554f, -0.05511578f, -0.01066736f, 0.04578536f, -0.03745046f, 0.01417978f, 
    0.02361706f, -0.03919698f, -0.03474567f, 0.05281909f, 0.00735235f, 0.01409809f, 0.01994858f, 0.04711992f, 
    0.00697955f, -0.04380946f, 0.04064534f, 0.05029383f, -0.07107584f, -0.04546321f, 0.05106381f, -0.00480467f, 
    -0.01758379f, -0.04909033f, -0.03860326f, -0.01950508f, -0.02950479f, 0.03472606f, -0.03938149f, 0.03657962f, 
    -0.08221777f, -0.05400074f, -0.01420717f, -0.05185859f, -0.02096578f, -0.06362723f, -0.03955070f, -0.06390380f, 
    -0.02657838f, 0.00721457f, -0.06343032f, -0.02782243f, 0.01437920f, 0.01988554f, 0.02529689f, -0.06882674f, 
    0.04513978f, -0.06401415f, 0.00480604f, -0.00061690f, -0.08378451f, 0.00000405f, -0.02499797f, 0.05799594f, 
    -0.05829116f, 0.04415842f, 0.01503119f, -0.05542659f, 0.03950465f, 0.01441742f, -0.02160103f, 0.03153214f, 
    0.04804046f, 0.03247159f, 0.02670917f, 0.03000859f, -0.03408951f, -0.01806640f, 0.04065849f, -0.07582244f, 
    -0.02930753f, 0.05080247f, -0.00676764f, 0.04153035f, 0.05555426f, -0.04885886f, -0.03195596f, 0.02736169f, 
    -0.02271871f, -0.02855798f, 0.05031268f, -0.03876067f, -0.01764175f, -0.07975648f, 0.03581729f, 0.01499979f, 
    -0.05991761f, 0.01525796f, -0.05322180f, -0.01371399f, 0.02696518f, -0.06110422f, -0.04308421f, 0.01969173f, 
    -0.03380286f, -0.04678125f, 0.00282189f, 0.02161491f, -0.06937239f, 0.03643614f, 0.03834105f, -0.03942618f, 
    0.03290636f, -0.01351634f, 0.03599500f, -0.01263938f, 0.03143179f, 0.01010013f, -0.06118432f, 0.03265850f, 
    -0.06938742f, -0.02725851f, 0.01472977f, -0.05558446f, 0.01055212f, 0.00460704f, -0.02252850f, 0.05358648f, 
    -0.08206343f, 0.03968704f, -0.02006418f, 0.03701035f, 0.04295319f, -0.00709581f, 0.00810852f, 0.04597233f, 
    -0.06965512f, 0.03023455f, 0.04802429f, -0.08008767f, -0.04790593f, -0.02153919f, 0.01405289f, 0.04162550f, 
    -0.01804850f, -0.07343261f, -0.00813030f, -0.03046288f, 0.00662994f, 0.02400566f, 0.02561859f, 0.00120499f, 
    -0.04023617f, -0.05826567f, 0.01039048f, -0.08381620f, -0.03680274f, -0.04147972f, -0.03758229f, 0.01674385f, 
    0.03754909f, -0.06409782f, 0.00089955f, 0.06494701f, -0.00997826f, 0.02961709f, 0.00649932f, 0.04248873f, 
    0.05440597f, -0.06730712f, -0.04526910f, 0.02741309f, 0.05329261f, 0.06092569f, -0.00719397f, -0.03030636f, 
    -0.01667176f, -0.03945912f, 0.00639898f, -0.03089947f, 0.02247131f, -0.00794286f, 0.03098669f, 0.00525527f, 
    0.00579400f, 0.04787963f, -0.05716093f, 0.04888985f, -0.07328385f, 0.05195413f, 0.02686051f, -0.05441849f, 
    -0.04949017f, -0.04640048f, -0.04373289f, 0.05668613f, -0.07664949f, -0.00018434f, -0.05195925f, 0.03027472f, 
    0.23822980f, -0.14087243f, 0.01343693f, 0.12115739f, 0.10295149f, 0.04944358f, 0.13403682f, 0.14494589f, 
    0.02649065f, 0.02349379f, 0.03623410f, 0.02641897f, 0.19269057f, 0.34900096f, 0.05750993f, -0.08996928f, 
    -0.13393500f, 0.01781194f, -0.09066605f, 0.17600280f, -0.02202140f, -0.04772210f, -0.07501297f, -0.03655270f, 
    0.00857402f, 0.14691606f, -0.04545835f, -0.01628062f, -0.07686318f, -0.07186145f, 0.13313916f, 0.15089752f, 
    -0.06521417f, 0.03684388f, 0.09086446f, 0.02441928f, 0.29387787f, -0.10649969f, 0.04506156f, 0.15210141f, 
    -0.00761632f, 0.13673286f, -0.02989881f, 0.01741162f, 0.02282085f, 0.01682889f, 0.10544376f, 0.03754057f, 
    -0.40122369f, 0.20730405f, 0.02987832f, -0.00243738f, -0.08880290f, 0.00865246f, -0.02775654f, -0.04272764f, 
    0.07386435f, 0.08801731f, 0.10003253f, -0.00505047f, 0.11009047f, -0.14988098f, -0.11939248f, 0.10362840f, 
    -0.13905481f, -0.00312694f, 0.06514176f, -0.14831461f, 0.06780404f, 0.02262423f, 0.05738341f, 0.10386927f, 
    -0.29247224f, 0.14778912f, -0.15807575f, -0.19381928f, -0.01026161f, -0.06580944f, 0.12459926f, 0.03633901f, 
    0.05265462f, 0.04392500f, 0.05233306f, -0.00834235f, 0.01042354f, -0.18267712f, 0.19678210f, 0.02353101f, 
    -0.14810550f, -0.04080519f, -0.02091455f, -0.02637140f, -0.05031217f, 0.05287191f, -0.08079159f, 0.08483778f, 
    0.07513469f, -0.05568057f, -0.04995865f, 0.21527962f, 0.07933372f, 0.10671430f, -0.11982121f, 0.09799329f, 
    0.08396538f, 0.01947206f, 0.01596869f, 0.05522836f, 0.13797179f, 0.13896129f, -0.10591771f, -0.15724221f, 
    -0.05201681f, -0.13491921f, -0.06796163f, -0.01309377f, 0.01468605f, 0.06752080f, -0.02797305f, -0.08008584f, 
    -0.21804796f, 0.00516269f, -0.02503558f, 0.07007132f, -0.05892969f, -0.10460084f, 0.13781790f, -0.00092546f, 
    0.01924688f, 0.09344626f, -0.16357468f, -0.04351442f, -0.11448612f, 0.11389269f, -0.05047530f, 0.03540886f, 
    0.09339499f, 0.09519940f, -0.05199773f, 0.08157936f, -0.13379468f, 0.01535878f, 0.09909710f, -0.00149774f, 
    0.21415837f, -0.06315590f, -0.01555563f, 0.12016080f, -0.06056777f, -0.00038933f, 0.09573859f, 0.02225763f, 
    0.03960789f, 0.02558064f, -0.03028178f, 0.02889538f, 0.18143225f, -0.08007643f, -0.05458684f, 0.14817688f, 
    -0.11648758f, 0.06734063f, -0.06173843f, 0.07244371f, 0.09147035f, -0.00806969f, -0.05772201f, 0.06345043f, 
    -0.14017475f, 0.20339330f, 0.13579740f, 0.21025731f, 0.20078333f, 0.02510010f, 0.01520353f, 0.01161250f, 
    0.03055920f, 0.03736489f, 0.01967067f, -0.12992044f, 0.16524683f, 0.19011556f, -0.13447341f, -0.10915216f, 
    0.00867222f, -0.01586599f, 0.06542500f, 0.02656107f, 0.11123278f, -0.02426809f, 0.05892225f, -0.06282858f, 
    -0.10534499f, 0.02136264f, -0.27606654f, 0.23157023f, -0.22584002f, 0.10156932f, -0.10953641f, 0.04400465f, 
    -0.03371227f, 0.06391558f, 0.06956500f, 0.11122815f, -0.20070407f, 0.17336692f, 0.17649586f, -0.00665795f, 
    0.03266358f, 0.13986272f, -0.11386316f, -0.07228210f, 0.00819426f, -0.03599523f, -0.01042171f, 0.02041567f, 
    -0.61172688f, 0.34451133f, 0.08281819f, -0.07590248f, 0.17679705f, -0.06957807f, 0.01174606f, -0.18240447f, 
    -0.01499680f, 0.00448104f, 0.02597830f, 0.05089057f, -0.40257761f, 0.17604503f, 0.18504858f, -0.12256330f, 
    0.10978798f, 0.04787545f, 0.17474638f, -0.03019655f, 0.05757093f, 0.14971222f, -0.12808941f, -0.00789269f, 
    -0.16289598f, 0.22379328f, 0.05629178f, 0.00039846f, -0.08288033f, -0.00533222f, 0.04108497f, 0.08248495f, 
    -0.06229921f, -0.16381030f, -0.09638816f, -0.16489148f, 0.17739317f, -0.17068507f, -0.13185042f, 0.09100228f, 
    0.13531122f, 0.02356847f, -0.03988539f, 0.04388274f, 0.12833701f, -0.07753617f, -0.06647272f, 0.02565605f, 
    0.15240799f, -0.09040887f, -0.21880034f, -0.12528436f, -0.05465763f, -0.05950533f, 0.04858859f, 0.09292424f, 
    0.06740810f, -0.01069675f, 0.11896875f, -0.02215030f, 0.14063025f, 0.07907442f, 0.09588131f, 0.09803244f, 
    0.09922495f, -0.08940414f, -0.01030644f, -0.06686248f, 0.02209227f, -0.01219410f, -0.00818178f, -0.02313512f, 
    0.26475585f, -0.14991686f, -0.00469698f, 0.07083367f, -0.07755251f, -0.07097887f, 0.08297042f, 0.02348585f, 
    -0.03704970f, -0.01687986f, -0.02334918f, 0.08181517f, 0.09711973f, -0.01231305f, 0.10568166f, 0.15637937f, 
    0.03999067f, 0.00692136f, 0.21901131f, 0.04087841f, -0.06723822f, -0.10169275f, 0.01524137f, -0.09864162f, 
    0.11134444f, -0.01699389f, 0.08913392f, 0.11561117f, 0.13026267f, 0.07445259f, 0.04880165f, 0.08204788f, 
    -0.02215842f, -0.00371760f, 0.06411684f, 0.08042620f, -0.21822309f, 0.01906545f, 0.06381227f, 0.01900572f, 
    0.09271177f, 0.00474167f, 0.13827178f, 0.16660456f, 0.05044002f, 0.04108338f, -0.09009930f, -0.01397581f, 
    0.12725727f, -0.02879851f, 0.05537993f, -0.00489979f, 0.09103224f, 0.02470356f, 0.03706158f, -0.06252199f, 
    -0.05825818f, -0.06849708f, 0.07403639f, 0.01616160f, 0.31197691f, -0.12791537f, 0.28318620f, 0.03167255f, 
    0.08304849f, -0.02044777f, 0.08900882f, -0.13078544f, 0.09538171f, -0.00861940f, 0.16198727f, 0.09007315f, 
    -0.17333286f, -0.20325698f, 0.38654244f, 0.32284406f, -0.02979419f, -0.03560953f, 0.00853180f, -0.03465766f, 
    0.04039308f, 0.17098980f, -0.02627733f, 0.05761316f, -0.34483966f, -0.00583953f, -0.14517309f, 0.19324622f, 
    0.05617141f, -0.00562937f, 0.03057795f, -0.14490908f, 0.07861613f, 0.01659378f, 0.04113032f, -0.07725926f, 
    -0.00681169f, -0.01392773f, 0.00587454f, 0.06773122f, -0.01254207f, -0.01045569f, 0.01421150f, -0.05936775f, 
    0.02816277f, -0.07123245f, -0.06549579f, -0.06164728f, 0.02471478f, 0.06424950f, 0.00254151f, -0.06738392f, 
    0.04185882f, -0.00743061f, 0.04683945f, 0.01058363f, -0.05175551f, -0.00899400f, -0.04306413f, -0.03064485f, 
    0.02567560f, -0.00990262f, -0.07211012f, -0.03855306f, -0.04553958f, -0.06200685f, -0.03711144f, -0.03756409f, 
    -0.06701218f, 0.05454667f, 0.03320302f, -0.04860786f, 0.06629395f, -0.05853485f, 0.02420734f, 0.06615290f, 
    0.05485893f, 0.04853498f, 0.04832187f, 0.02337682f, -0.01855608f, 0.02193336f, 0.04086607f, -0.01752982f, 
    -0.03716945f, 0.00028043f, -0.02227772f, -0.01902815f, 0.07005983f, 0.06807713f, 0.05526315f, -0.01129667f, 
    0.00466373f, 0.00833758f, -0.00918814f, 0.04218804f, -0.07026584f, 0.06780524f, -0.02429185f, -0.05570068f, 
    -0.02940851f, -0.04971933f, 0.03807365f, 0.04404240f, 0.05855088f, 0.01171902f, -0.05143559f, -0.06538081f, 
    -0.02317434f, 0.02366471f, -0.06668455f, 0.03215118f, -0.00645353f, -0.05975131f, -0.00427492f, -0.04839029f, 
    0.02390794f, 0.00028667f, -0.07113164f, -0.03951110f, 0.06033360f, -0.03471512f, 0.00468630f, -0.03544353f, 
    -0.01290838f, -0.05779653f, 0.00920039f, 0.06079223f, -0.06093490f, -0.03810375f, -0.01932315f, -0.00621065f, 
    0.05497083f, -0.05850492f, -0.04216250f, -0.07127826f, -0.06396015f, 0.00179945f, 0.06764421f, 0.06224460f, 
    -0.02034925f, 0.03289701f, 0.02351730f, 0.03225195f, -0.04774028f, 0.00464355f, 0.02295075f, -0.05744606f, 
    -0.01370845f, 0.07026473f, 0.04991687f, 0.00396479f, -0.03717824f, -0.04331940f, -0.04202963f, 0.02158881f, 
    0.06898747f, -0.04601403f, -0.02192450f, -0.05747190f, -0.03389311f, -0.06102816f, -0.02236478f, -0.04215844f, 
    -0.05919311f, -0.05581505f, 0.03775833f, 0.04544193f, 0.00057563f, -0.06239453f, 0.06094809f, 0.01211714f, 
    -0.01069047f, -0.00624727f, -0.03303546f, 0.05175435f, -0.04801184f, -0.05577981f, 0.06934115f, 0.01483660f, 
    -0.03726223f, 0.00761159f, -0.07133236f, -0.01586363f, -0.03741208f, -0.02635610f, 0.03751523f, 0.01845167f, 
    0.07070746f, -0.00768800f, 0.07051685f, 0.05038138f, -0.05250198f, 0.02149867f, -0.05714286f, -0.05166249f, 
    0.00281174f, 0.00891254f, -0.01752877f, 0.02019465f, -0.04970664f, 0.02378436f, 0.01479896f, -0.03986085f, 
    0.03466650f, -0.03599379f, -0.06345941f, -0.01322371f, -0.05046134f, -0.03949643f, -0.05812192f, -0.06149352f, 
    -0.03792013f, -0.01896579f, -0.00991530f, 0.05574368f, -0.00051634f, -0.02976321f, -0.05014816f, -0.07077035f, 
    0.05646164f, 0.03866396f, 0.00210819f, -0.01649935f, -0.04897324f, -0.04603995f, 0.01482714f, -0.02021082f, 
    0.01606534f, -0.12131105f, -0.33952236f, 0.02260595f, 0.11853320f, -0.04336489f, -0.00393569f, -0.01314891f, 
    0.08523288f, -0.05429148f, -0.06469239f, 0.05146227f, -0.05577905f, -0.04282256f, -0.01048241f, -0.09077365f, 
    -0.03972547f, 0.11489242f, -0.03372348f, 0.06917181f, 0.11237444f, 0.15368767f, -0.05390469f, 0.01884902f, 
    -0.00224157f, -0.13374031f, -0.00558923f, -0.11917584f, -0.05087400f, -0.00712587f, 0.06523683f, -0.06376410f, 
    0.08055680f, -0.09177007f, 0.03919287f, 0.11846589f, 0.03362177f, -0.00953652f, 0.01911043f, -0.08150650f, 
    -0.10023820f, -0.01581558f, -0.04273076f, 0.03360143f, 0.04970930f, 0.14196496f, 0.00926319f, 0.06806526f, 
    -0.00827275f, 0.17136855f, -0.07001880f, 0.16606826f, -0.09380747f, -0.01247696f, 0.02841221f, -0.08261733f, 
    0.01026333f, 0.02196302f, 0.02494739f, -0.10179891f, 0.09478778f, 0.02364383f, 0.06154669f, 0.12143441f, 
    -0.09062608f, -0.09883998f, 0.06246269f, 0.12662560f, 0.11330102f, -0.05361037f, 0.11069266f, 0.02380674f, 
    0.06355543f, 0.19000083f, -0.27385786f, -0.03376203f, 0.03387121f, -0.08943943f, 0.11886577f, 0.01538845f, 
    0.11363509f, -0.03948710f, 0.00622448f, 0.00410079f, 0.22608651f, 0.02204780f, 0.20220949f, -0.01585060f, 
    -0.00853363f, 0.02829403f, -0.07880671f, 0.02328028f, -0.09467246f, 0.04511861f, 0.05780638f, -0.00562510f, 
    0.07357205f, -0.15427540f, -0.16714831f, -0.02381731f, 0.08359281f, 0.00011341f, 0.10742256f, -0.08723304f, 
    0.11955098f, 0.04479476f, 0.02999371f, 0.07493109f, -0.03227728f, 0.18362615f, 0.09767183f, -0.11590366f, 
    -0.04972778f, 0.02897736f, 0.10321726f, -0.06362266f, 0.01354230f, 0.00701098f, -0.11437427f, 0.00209634f, 
    -0.13819720f, 0.05560608f, 0.04258598f, -0.01516583f, 0.06808241f, -0.09982941f, 0.13570300f, 0.01560413f, 
    -0.04222633f, -0.07495116f, -0.10954356f, 0.01207631f, -0.03627562f, -0.00905986f, -0.02062530f, -0.02855066f, 
    0.07602817f, -0.04919536f, -0.03976563f, 0.03730058f, -0.07283632f, -0.06939304f, 0.00199375f, -0.02757393f, 
    0.18175936f, -0.11556578f, 0.10095034f, 0.20284887f, -0.09578328f, -0.09871513f, -0.11941651f, -0.04431387f, 
    0.00781177f, -0.07448399f, 0.01170949f, 0.14270839f, 0.28926083f, -0.06870426f, 0.25226635f, 0.24998970f, 
    0.00805098f, 0.11913541f, -0.01704953f, -0.02266574f, 0.08319484f, 0.10910229f, 0.09936533f, 0.02118164f, 
    -0.26621357f, 0.10528313f, 0.15814315f, -0.05908396f, 0.06700409f, 0.09166990f, 0.03448990f, -0.06205369f, 
    0.04394241f, 0.15264162f, 0.00093879f, 0.05361247f, -0.11704174f, -0.05770799f, 0.10404172f, 0.08303671f, 
    -0.02770511f, -0.05050278f, -0.07744229f, -0.01694519f, -0.01408341f, -0.00789703f, 0.13596815f, -0.02620840f, 
    -0.11361167f, 0.16614929f, -0.12348717f, 0.08451754f, -0.15127090f, 0.05084741f, -0.00612746f, -0.04762078f, 
    -0.05651561f, -0.15896419f, -0.03538158f, 0.09508625f, -0.33709037f, -0.04106924f, -0.00115663f, 0.02542883f, 
    0.13153857f, 0.09300331f, -0.07069037f, 0.11985084f, 0.05685871f, -0.00165881f, -0.01036827f, -0.07600989f, 
    0.38002962f, 0.03938811f, -0.02761278f, -0.03607481f, 0.18899855f, 0.07418807f, 0.00409861f, -0.12195394f, 
    -0.04284469f, -0.01850125f, -0.00597506f, 0.03547595f, 0.08795632f, -0.03005647f, 0.10498314f, -0.12711462f, 
    -0.04839409f, 0.06426436f, -0.05677931f, 0.13460043f, 0.16902304f, 0.07970960f, 0.12493323f, 0.00051353f, 
    -0.05015946f, 0.18479533f, 0.10846250f, -0.17728056f, -0.20094760f, 0.03149994f, 0.07282763f, -0.03307913f, 
    -0.00924226f, -0.08780174f, 0.10573900f, -0.01735618f, 0.01405475f, 0.01134142f, 0.06244041f, 0.07912420f, 
    0.00078977f, 0.01481314f, 0.06145336f, 0.01328406f, -0.00094477f, -0.02817222f, 0.06809726f, 0.00749998f, 
    -0.16875850f, -0.06480870f, -0.20215727f, 0.05248227f, 0.05750131f, 0.01445748f, 0.17845319f, 0.05286536f, 
    0.10312619f, -0.08623684f, 0.11082857f, -0.06375956f, 0.16553465f, 0.16689704f, 0.19227418f, 0.09555226f, 
    -0.09011681f, -0.08441112f, 0.05654924f, -0.07847481f, -0.02198516f, -0.02626018f, 0.06892700f, 0.11871145f, 
    -0.17728941f, -0.00384808f, -0.02769325f, 0.05612358f, 0.03804179f, -0.06293062f, 0.11735181f, 0.04333618f, 
    0.00156297f, 0.00959431f, -0.02455184f, 0.03373962f, -0.17226927f, 0.16944298f, 0.09108292f, 0.13140804f, 
    0.14498705f, 0.01644406f, 0.19021016f, 0.05194001f, -0.02134394f, -0.02297128f, 0.08788217f, -0.04964380f, 
    0.02125854f, -0.12437370f, -0.00361167f, 0.26022956f, -0.00618523f, -0.04966571f, 0.07142475f, 0.09337837f, 
    0.01116381f, -0.02929980f, -0.11892242f, -0.07088892f, -0.10085719f, -0.01276630f, 0.08361987f, -0.01023333f, 
    0.02192275f, -0.00257096f, 0.13921566f, -0.14794117f, 0.03099789f, -0.05901901f, 0.00368869f, -0.07548450f, 
    0.00950475f, 0.17005877f, 0.11182174f, 0.02650271f, 0.02464795f, 0.02094509f, 0.06758275f, -0.02611964f, 
    -0.08836643f, -0.17470218f, -0.02865187f, -0.01827624f, 0.13829078f, 0.02496533f, 0.15729727f, -0.07135329f, 
    -0.03608482f, -0.03144303f, 0.03597270f, 0.00033673f, -0.03612854f, -0.11066328f, 0.08922594f, 0.05796318f, 
    -0.02204041f, -0.19064404f, 0.10183764f, 0.19850932f, 0.08752143f, 0.00468148f, 0.01534861f, -0.03839549f, 
    -0.03971813f, 0.08897737f, -0.12270286f, 0.07519038f, -0.15133174f, -0.12851214f, -0.03417154f, -0.01632973f, 
    -0.01530653f, 0.04633953f, -0.11868093f, -0.10762884f, -0.03526806f, -0.09545296f, 0.08774149f, -0.00790339f, 
    -0.10663947f, -0.00044694f, -0.51239419f, 0.14322889f, 0.06938332f, -0.00458881f, -0.10250705f, -0.00645944f, 
    0.15723678f, 0.05937820f, -0.24315304f, -0.06963023f, 0.01494513f, 0.38784033f, 0.21902283f, 0.13112292f, 
    0.04992094f, 0.14778757f, 0.16172256f, 0.06541315f, -0.10829535f, 0.09426406f, 0.09419064f, -0.06134179f, 
    0.20839420f, 0.10916808f, 0.23488246f, 0.06051020f, -0.01839832f, -0.09346730f, 0.15807930f, 0.00571109f, 
    -0.09228338f, -0.01949681f, 0.08966932f, -0.09847853f, -0.18697934f, 0.34462941f, 0.17186412f, 0.09579115f, 
    -0.06543215f, 0.01778840f, 0.07892719f, 0.08888477f, -0.12947035f, 0.06597345f, 0.15129499f, -0.08248933f, 
    -0.24892968f, -0.06997158f, -0.16883025f, -0.12752746f, -0.11982026f, 0.04043272f, -0.02227313f, 0.01064348f, 
    0.09057482f, 0.06050432f, -0.05699910f, -0.08252090f, 0.00446349f, -0.06516314f, -0.26913902f, 0.02352273f, 
    0.07832855f, -0.08705525f, -0.00742205f, -0.03117385f, 0.02936184f, -0.11787614f, -0.05798936f, -0.01055507f, 
    0.50614548f, -0.33573261f, -0.10889713f, -0.23324849f, 0.02431625f, -0.09264100f, 0.02454368f, 0.00990002f, 
    0.07272875f, -0.10871299f, -0.00625490f, 0.14812288f, 0.17766407f, -0.22913598f, -0.02129447f, -0.11678943f, 
    0.04163897f, -0.02240410f, -0.07226368f, -0.03144868f, -0.04343567f, 0.00106784f, 0.05338710f, -0.08423129f, 
    0.19760180f, -0.08754035f, 0.00212964f, -0.05563438f, 0.20916186f, -0.17317203f, 0.07592870f, 0.04164074f, 
    0.11395189f, -0.16621982f, -0.01612559f, -0.03451357f, 0.16526008f, 0.39329770f, 0.34724459f, 0.30010357f, 
    -0.00748170f, -0.02486914f, 0.06522666f, 0.01521401f, -0.11528560f, -0.10994492f, -0.03962729f, 0.01975513f, 
    0.15011452f, -0.12482605f, 0.08759792f, -0.10430441f, -0.03999808f, -0.00964464f, -0.01382101f, 0.07530133f, 
    0.12868354f, -0.04941732f, 0.09422664f, 0.11279020f, -0.31629980f, -0.01175101f, 0.12505805f, -0.22357135f, 
    0.14495979f, 0.07208616f, 0.04144823f, 0.08155929f, -0.19192766f, 0.04169002f, -0.04821574f, -0.02726338f, 
    -0.08753821f, -0.24219669f, -0.14906952f, -0.09544549f, 0.19667739f, -0.09170593f, -0.12125710f, 0.02229633f, 
    0.11449230f, 0.06582443f, 0.07358013f, 0.03076653f, 0.00305794f, -0.06631568f, 0.18088548f, 0.01085075f, 
    0.07010590f, -0.00842361f, -0.18641587f, -0.07684145f, 0.12410960f, -0.24363267f, 0.03238265f, -0.13648784f, 
    -0.09157199f, 0.06090250f, 0.34934056f, 0.15234736f, -0.11628608f, 0.01950939f, -0.06514543f, 0.08741528f, 
    -0.00193677f, 0.13684811f, -0.04200336f, 0.08446512f, -0.04282872f, 0.11186524f, 0.20067850f, 0.19270048f, 
    -0.00923566f, 0.06399653f, 0.06650393f, 0.07363266f, 0.06246621f, 0.01069051f, 0.09629234f, -0.01599207f, 
    -0.07966603f, -0.13421057f, -0.22937623f, 0.13501383f, 0.16043285f, 0.03674622f, 0.07982961f, -0.03892104f, 
    -0.01313483f, 0.06280171f, -0.00395307f, -0.03071249f, 0.28162968f, 0.20126139f, 0.18078439f, -0.08374562f, 
    -0.14225432f, -0.04789102f, 0.06989866f, 0.03622790f, -0.00518895f, -0.03804203f, -0.03185046f, -0.02442227f, 
    -0.10674782f, 0.10408394f, 0.04447389f, -0.08896542f, -0.03612533f, -0.04172995f, 0.03598617f, -0.00915478f, 
    0.03552150f, -0.02970530f, 0.05707137f, 0.01771672f, 0.36249995f, -0.10978328f, 0.06442023f, 0.00946192f, 
    -0.01784898f, 0.00620805f, -0.02447246f, -0.10004647f, 0.05209827f, 0.00327314f, -0.07692609f, 0.11868144f, 
    -0.08000299f, 0.14201652f, -0.19135576f, 0.15324764f, 0.07038920f, 0.00435482f, -0.04858597f, -0.04214472f, 
    0.04110048f, 0.06373116f, -0.10992082f, -0.10643224f, -0.10115305f, -0.10999675f, -0.14398003f, 0.20224063f, 
    -0.02368307f, 0.00775364f, -0.05766502f, -0.04555430f, 0.08238915f, -0.02390267f, 0.07927828f, 0.00155943f, 
    -0.02563882f, -0.00280206f, -0.23729776f, -0.17306109f, 0.00697320f, 0.07382838f, 0.12613709f, -0.00506653f, 
    0.05613900f, 0.05970055f, 0.07555921f, 0.19640680f, -0.13072614f, -0.21920297f, 0.05780074f, -0.00342593f, 
    -0.04240297f, 0.07927708f, 0.02180415f, -0.05634772f, -0.07964808f, -0.01872269f, -0.01979382f, -0.02479760f, 
    0.23136052f, -0.06170104f, -0.04172017f, 0.15328757f, 0.07874495f, 0.12747666f, -0.10128851f, -0.02376375f, 
    0.11441168f, -0.04820487f, 0.08628353f, 0.06539308f, 0.33211589f, 0.08839574f, -0.02241976f, -0.06380006f, 
    0.02112940f, 0.00661483f, -0.03400299f, -0.00604292f, -0.00445194f, 0.07486261f, 0.01449345f, 0.03277105f, 
    -0.16040102f, 0.07726952f, -0.03711041f, -0.15164413f, -0.00609553f, 0.02317040f, 0.10977228f, -0.07115278f, 
    -0.00731874f, 0.08164613f, -0.06326185f, -0.05398719f, -0.01992320f, 0.04964103f, -0.24566214f, -0.10662759f, 
    0.03728135f, 0.03111034f, -0.04869799f, 0.01877172f, -0.10547857f, 0.00677741f, 0.05478736f, 0.05570595f, 
    0.25787613f, -0.19346236f, 0.00860614f, 0.14334938f, -0.01424867f, -0.02983249f, 0.05218450f, -0.04697335f, 
    -0.01655049f, 0.10534125f, 0.00354298f, 0.03315182f, 0.04688924f, -0.01241690f, 0.06318550f, 0.19395711f, 
    0.08794824f, 0.01754412f, 0.00225328f, -0.03575548f, 0.09601881f, 0.02207306f, 0.02381928f, 0.09140553f, 
    -0.04219939f, 0.32073230f, 0.10435908f, 0.06333658f, 0.13324289f, 0.08991895f, -0.00967671f, -0.07862713f, 
    -0.00756524f, 0.00090775f, 0.07196305f, -0.04507839f, 0.15121138f, 0.24826328f, 0.09318850f, 0.22242045f, 
    -0.08971621f, -0.12787329f, 0.12192255f, 0.07557139f, -0.04202635f, -0.02747739f, -0.00771684f, -0.08888420f, 
    0.21987633f, -0.01824330f, -0.03112561f, 0.03037987f, 0.01049836f, 0.17160508f, 0.10560036f, 0.11942809f, 
    0.08912018f, -0.05296081f, -0.00651542f, -0.03165762f, 0.01167917f, -0.03049057f, -0.08665165f, -0.02733660f, 
    0.00081484f, -0.01505647f, -0.05527931f, 0.19197878f, 0.06445451f, 0.11352460f, -0.02785466f, 0.04197921f, 
    -0.06779691f, -0.11430123f, -0.05787950f, 0.16590154f, -0.06770675f, -0.03267340f, 0.04599796f, 0.03643029f, 
    0.01367030f, -0.09022260f, 0.06466710f, 0.20143887f, 0.01578481f, -0.03226397f, -0.00713539f, 0.14571832f, 
    -0.15044090f, 0.11503232f, -0.04247906f, 0.04241368f, 0.12549551f, 0.01722540f, -0.01323252f, 0.01458625f, 
    0.02652845f, 0.06310794f, 0.09334474f, 0.09590257f, -0.07693558f, 0.01896316f, 0.14888488f, -0.12892726f, 
    -0.05847257f, 0.04681411f, 0.04133568f, 0.11730747f, 0.03558132f, -0.06853219f, 0.02636665f, 0.23552109f, 
    -0.09815220f, 0.06508255f, 0.10425016f, -0.15443739f, -0.00080964f, 0.06573445f, 0.07138819f, 0.06159208f, 
    -0.22039470f, 0.18239579f, -0.14747031f, 0.07409017f, 0.02000905f, 0.07367412f, 0.14252445f, -0.03588621f, 
    -0.00511619f, -0.01576083f, -0.05941365f, -0.16254106f, 0.27286744f, 0.15326160f, -0.02445262f, 0.16752829f, 
    -0.03433001f, -0.04047947f, 0.02601008f, 0.07678513f, -0.04803278f, 0.07005943f, 0.00350935f, 0.09668260f, 
    -0.16177770f, -0.14805064f, -0.10568492f, -0.01368946f, 0.01459677f, 0.04288200f, -0.13154630f, 0.10928708f, 
    0.02413795f, -0.14678264f, -0.03215846f, -0.11223801f, 0.02520829f, -0.04616471f, 0.03522244f, -0.23745331f, 
    -0.03391971f, -0.08165329f, -0.06325715f, 0.08020715f, -0.09674159f, -0.13558435f, 0.03676198f, 0.17494944f, 
    0.02358362f, 0.02030749f, -0.08145291f, 0.03658143f, -0.07790335f, -0.09564841f, 0.10351231f, 0.15482660f, 
    -0.04437042f, 0.19948852f, -0.09153012f, 0.14694417f, -0.09802482f, -0.01229365f, 0.18904087f, 0.20084119f, 
    0.00513809f, -0.07035778f, 0.01794786f, 0.00297920f, -0.01073210f, 0.07367821f, 0.11715933f, -0.09312593f, 
    0.10121512f, 0.04519713f, -0.12067898f, 0.28260982f, -0.17553677f, 0.05198649f, -0.03543760f, 0.14148733f, 
    -0.07189906f, -0.14642091f, 0.00628842f, -0.06872726f, 0.43147084f, 0.09115936f, 0.08909640f, 0.12806986f, 
    -0.08591884f, 0.06896002f, -0.03030966f, -0.03212537f, 0.06970952f, 0.00393170f, -0.01780634f, -0.09532633f, 
    -0.30219644f, 0.01027398f, 0.23011018f, -0.11799825f, 0.23003390f, 0.01453984f, 0.03123341f, -0.00746658f, 
    -0.03149744f, -0.06074786f, 0.01373116f, 0.04231862f, -0.07306013f, -0.06955096f, 0.05113194f, -0.00352800f, 
    0.01895091f, -0.02732844f, 0.04143213f, 0.08811519f, -0.01558840f, 0.02338509f, 0.03155277f, 0.17611143f, 
    -0.37325549f, -0.10399500f, -0.09450514f, 0.16192874f, -0.06915147f, 0.04185419f, -0.04843159f, -0.13730243f, 
    0.04468882f, 0.06917267f, -0.05576115f, 0.02805235f, -0.04624779f, 0.09918984f, 0.12440841f, 0.13389561f, 
    0.07001267f, 0.07423655f, 0.03199422f, -0.02351285f, 0.01374818f, 0.02836357f, 0.07358220f, -0.05061055f, 
    -0.10779836f, 0.10356066f, 0.04976302f, 0.05963843f, 0.09769616f, 0.02282062f, -0.07262260f, -0.03172710f, 
    0.05250013f, 0.04761005f, 0.03877743f, -0.04337801f, -0.18282419f, 0.06422287f, -0.01947204f, -0.10408511f, 
    0.12407732f, -0.02359136f, 0.05690536f, -0.04672255f, 0.02345652f, 0.09624001f, -0.12789573f, 0.05588677f, 
    0.03689692f, -0.03341933f, -0.06935107f, -0.07769823f, 0.00565296f, -0.07598303f, 0.04054854f, 0.10105347f, 
    -0.06341423f, -0.03018542f, 0.00024329f, -0.03268899f, -0.19686843f, -0.15223783f, 0.07584361f, 0.06140833f, 
    0.10519170f, -0.05799001f, 0.00341780f, 0.06197736f, 0.12662642f, 0.01176250f, 0.05853235f, -0.01885132f, 
    -0.43315226f, -0.36997107f, 0.02080563f, -0.11601073f, 0.21334419f, 0.03886510f, 0.08913708f, -0.00948288f, 
    0.11812515f, 0.05506643f, -0.04605000f, -0.01296565f, -0.22240710f, 0.17268209f, -0.13683832f, -0.12779793f, 
    0.13059889f, -0.09850942f, 0.01195910f, 0.06844680f, -0.04780305f, -0.01306948f, 0.00495113f, 0.02403417f, 
    0.10312157f, 0.04270674f, 0.11777278f, 0.03147288f, -0.05838311f, -0.01171928f, 0.10569005f, -0.02254684f, 
    -0.02732842f, -0.01093790f, 0.03203356f, 0.03760623f, 0.16750632f, -0.13262349f, 0.01209704f, 0.29963481f, 
    0.13530508f, -0.01566020f, 0.04769573f, 0.00179444f, 0.10251088f, 0.09860338f, -0.04849198f, 0.00243270f, 
    0.18240972f, 0.01211022f, 0.05239338f, -0.15116160f, 0.17776005f, 0.12307507f, 0.03911778f, -0.03258289f, 
    -0.01367162f, -0.02575408f, 0.00934839f, 0.07915673f, 0.06055925f, 0.03452314f, 0.09280019f, -0.17092316f, 
    0.06370126f, 0.09358915f, 0.00474409f, 0.09102680f, 0.02261754f, 0.14968508f, -0.09318088f, 0.09028073f, 
    -0.18243630f, -0.02757521f, -0.03540694f, -0.13427646f, 0.08661065f, 0.02244721f, 0.08369886f, -0.04084715f, 
    0.04997377f, -0.04195881f, 0.07469250f, -0.06718619f, -0.10672533f, 0.02163421f, 0.19460641f, -0.15662886f, 
    0.06665760f, 0.00590282f, 0.02185656f, 0.05949670f, 0.08408297f, 0.12756453f, 0.14829955f, 0.09489770f, 
    0.12099157f, -0.00142443f, 0.26431772f, 0.07354919f, -0.00631753f, 0.00667024f, 0.05558715f, -0.01242546f, 
    -0.05232109f, 0.11544763f, 0.04671164f, 0.00327343f, -0.16630602f, 0.08507055f, -0.06126102f, 0.21609367f, 
    -0.08970966f, 0.03943451f, 0.08190801f, -0.00286170f, -0.05534870f, 0.02739964f, 0.09340723f, -0.08385003f, 
    0.03252921f, 0.00092115f, -0.07860360f, 0.06299012f, 0.06468964f, -0.01167244f, 0.01685668f, -0.00681231f, 
    -0.02238864f, 0.04238150f, 0.04408242f, 0.04711643f, 0.05838757f, -0.07912688f, 0.00206914f, 0.02861900f, 
    -0.04105731f, 0.02816170f, -0.00898250f, -0.06322370f, 0.02147205f, -0.01362139f, -0.01053660f, -0.07632080f, 
    -0.04730896f, -0.08141371f, 0.04260878f, -0.00311387f, -0.03540874f, 0.00910520f, -0.00327497f, -0.03285464f, 
    -0.07467444f, 0.01000762f, -0.00963321f, -0.01531944f, -0.00831332f, 0.03458808f, 0.02156651f, -0.06938552f, 
    -0.07080165f, 0.00436674f, 0.06291955f, 0.00659905f, -0.03587136f, 0.02190175f, 0.06143299f, -0.05256364f, 
    -0.06405742f, -0.05716263f, 0.01231428f, 0.06096843f, 0.01657601f, 0.03626326f, -0.05058390f, -0.03891880f, 
    -0.01594646f, 0.00260147f, 0.00932705f, -0.03340060f, 0.03449043f, -0.02730073f, 0.01676533f, 0.01747089f, 
    0.01888807f, 0.01066281f, -0.07382806f, -0.07707412f, 0.04927715f, 0.03374272f, 0.03677239f, 0.02016220f, 
    -0.05362359f, -0.03803983f, -0.05760977f, -0.02860792f, -0.03167509f, -0.04108776f, 0.04878776f, 0.04205428f, 
    0.02805980f, -0.02622461f, -0.02678601f, 0.00220421f, 0.01385548f, 0.02702028f, -0.07488648f, -0.00652583f, 
    -0.03918458f, 0.04013286f, -0.01294504f, 0.00564819f, 0.00595865f, -0.07132187f, -0.03535859f, -0.00041177f, 
    0.01740100f, 0.01649143f, -0.04804997f, 0.03713544f, -0.03402149f, 0.03125213f, 0.00202356f, -0.03488895f, 
    -0.04272857f, -0.03070852f, -0.05826404f, 0.05551945f, 0.03260605f, 0.06254790f, -0.01004856f, -0.05644541f, 
    0.00981269f, -0.06096139f, -0.00986968f, 0.01235077f, -0.04044545f, 0.04724404f, -0.04629427f, -0.01249167f, 
    -0.06678445f, -0.02594417f, -0.04644777f, -0.03118837f, 0.03596114f, 0.02369542f, 0.04808507f, -0.04680336f, 
    0.02529556f, -0.01826704f, 0.01916729f, -0.04197896f, -0.00005273f, -0.03112068f, -0.03254491f, -0.07753522f, 
    -0.03019613f, -0.05934434f, -0.04679850f, -0.04852738f, -0.04990556f, 0.00502914f, 0.02763698f, -0.04440304f, 
    0.01508054f, -0.06373584f, 0.04504317f, 0.01588175f, 0.04876599f, 0.04061568f, -0.07765384f, -0.07462982f, 
    -0.06572791f, -0.03272086f, -0.05773661f, -0.05867467f, 0.05955765f, -0.00660167f, -0.00776173f, 0.02308465f, 
    0.04283298f, 0.00043380f, 0.01779438f, -0.02058966f, -0.07589893f, 0.01311130f, 0.03714601f, 0.00037788f, 
    0.06174925f, -0.07573790f, -0.03702548f, 0.05048846f, -0.05881202f, 0.02198368f, -0.04504552f, 0.02247259f, 
    0.01733642f, 0.02357854f, 0.05881600f, -0.00928730f, -0.05012031f, -0.05640727f, 0.05606914f, -0.02980449f, 
    0.06104018f, 0.00178664f, -0.03821409f, -0.02036575f, 0.03467606f, -0.02215272f, -0.03314323f, -0.05579041f, 
    -0.02138129f, -0.21624248f, -0.10185700f, 0.00014688f, 0.22214682f, -0.05836286f, 0.03227995f, -0.10176456f, 
    -0.03938964f, -0.01415505f, -0.03012776f, -0.01196038f, 0.16607237f, 0.11402106f, -0.02093552f, -0.09336830f, 
    -0.08472037f, -0.09000876f, -0.02673035f, 0.08688361f, -0.04216051f, 0.16629012f, 0.05647239f, -0.04973154f, 
    0.41494393f, -0.15917191f, -0.09419578f, -0.14531775f, 0.04007865f, 0.03010883f, -0.09604562f, 0.05115647f, 
    0.07811911f, 0.05563203f, -0.04359275f, 0.09050575f, 0.48981261f, -0.06582499f, 0.05662208f, -0.01059883f, 
    0.03913064f, 0.00450659f, -0.09876039f, 0.07125448f, 0.08061882f, 0.07548751f, 0.07826520f, -0.00335264f, 
    -0.11474372f, -0.00950283f, -0.13892531f, 0.14458628f, 0.08477321f, 0.01788206f, -0.09425972f, -0.05683975f, 
    -0.03582438f, 0.11432394f, -0.06973548f, 0.04573584f, -0.09414854f, 0.15777242f, 0.12765415f, -0.03520031f, 
    0.03910601f, -0.03799161f, 0.13670196f, 0.01993899f, 0.01853890f, 0.02774962f, 0.14500195f, 0.02260948f, 
    -0.41881171f, 0.04277301f, -0.06883864f, 0.05926628f, 0.01483573f, 0.01655597f, 0.05217468f, 0.02501877f, 
    0.04480411f, 0.03887237f, -0.00450851f, 0.05486014f, -0.11528423f, -0.23314238f, 0.05080773f, -0.22368939f, 
    -0.14997599f, -0.08052187f, -0.15387090f, -0.07114130f, -0.08298526f, -0.02121853f, 0.02995218f, -0.04359558f, 
    -0.10178249f, 0.03292966f, -0.04380840f, -0.02063921f, -0.00883564f, 0.06982671f, -0.04361093f, -0.06474409f, 
    -0.04230917f, 0.06625037f, 0.03021620f, 0.09426752f, -0.01955683f, 0.29427415f, -0.16075960f, -0.01238284f, 
    -0.06128753f, 0.01374394f, -0.09705649f, -0.03482554f, -0.01740491f, 0.24857892f, -0.06908224f, -0.01908938f, 
    -0.33460212f, 0.19685243f, -0.05741425f, -0.06516878f, -0.10827821f, 0.03880293f, -0.00160009f, 0.09352656f, 
    -0.05384067f, -0.02825076f, -0.04491856f, -0.06917639f, 0.03632505f, 0.03306453f, -0.11238526f, -0.11686385f, 
    0.07121769f, 0.17340547f, 0.02177480f, 0.01311856f, -0.12289637f, -0.00352813f, 0.10314963f, -0.08817923f, 
    0.12353176f, -0.09720409f, 0.09722184f, 0.09640785f, -0.01296119f, -0.12045014f, 0.04726055f, 0.04313172f, 
    0.09898744f, -0.00524078f, 0.01591261f, 0.08955615f, -0.05713645f, 0.12392651f, 0.16455784f, 0.06508334f, 
    0.03853385f, 0.05646756f, -0.00535514f, 0.03339507f, 0.04819833f, 0.04212180f, 0.01866606f, -0.02186777f, 
    -0.02537559f, 0.12335217f, -0.10304094f, -0.02857879f, 0.10172851f, 0.10489409f, 0.01000313f, 0.11934243f, 
    -0.04808731f, 0.10776454f, 0.04762942f, 0.03418703f, 0.15944356f, -0.04364783f, 0.09748057f, 0.17481910f, 
    -0.16739468f, -0.11680357f, 0.09438480f, -0.00346048f, -0.02041405f, -0.06049807f, -0.04491705f, -0.07418682f, 
    -0.04851910f, -0.03069178f, -0.02956529f, -0.05116398f, 0.00549913f, 0.04680227f, -0.03338663f, 0.05390416f, 
    0.03470127f, -0.04911204f, -0.00428838f, -0.01792163f, 0.05635815f, -0.01409736f, 0.02017936f, 0.05553906f, 
    -0.05168305f, -0.05882191f, 0.00602534f, -0.04764345f, 0.02314677f, -0.04903516f, -0.03433652f, 0.02108510f, 
    -0.01147491f, -0.04032328f, 0.00447183f, -0.07790919f, 0.01257433f, 0.03044104f, 0.06505134f, 0.04900492f, 
    -0.02188273f, -0.00495398f, 0.02954811f, -0.05602160f, 0.02745351f, 0.04095694f, -0.05988239f, 0.00842483f, 
    0.04328346f, -0.03526007f, -0.03326517f, -0.00356666f, -0.02709079f, -0.02971053f, 0.01148370f, -0.03996620f, 
    0.03135660f, 0.01194297f, -0.02026011f, 0.01174881f, 0.05735921f, 0.00209766f, -0.01409051f, -0.05053557f, 
    0.01505177f, -0.07494968f, 0.05676916f, 0.02211107f, -0.03338676f, -0.06998109f, -0.07362464f, -0.02055590f, 
    -0.04243625f, -0.02246955f, 0.06337610f, 0.02029479f, -0.04305575f, -0.06800455f, 0.05881256f, 0.02535518f, 
    0.02491728f, -0.03995154f, -0.00197657f, 0.02162615f, 0.02008395f, -0.07542103f, 0.05381191f, -0.04009951f, 
    0.01561570f, -0.01386334f, -0.03148853f, 0.05069963f, 0.04213418f, -0.04014797f, -0.04565798f, 0.03084102f, 
    -0.00942967f, -0.06269053f, 0.03337634f, -0.01311415f, -0.07114538f, -0.00207024f, 0.02271529f, -0.00259750f, 
    0.04712100f, -0.04263899f, 0.03677008f, -0.01153951f, 0.03152645f, 0.03878889f, -0.04871394f, -0.00000804f, 
    -0.06053829f, -0.03510247f, -0.05422670f, 0.05724930f, -0.01494439f, -0.06103231f, -0.01547389f, 0.00736405f, 
    0.04288995f, 0.01579414f, -0.05594679f, -0.03882759f, -0.06747626f, 0.02505269f, -0.02441069f, -0.02117604f, 
    -0.05605550f, 0.03538095f, 0.06059950f, 0.00113007f, -0.05144320f, 0.00192681f, -0.00789689f, 0.05409173f, 
    0.01788007f, 0.00456532f, 0.01792154f, -0.01651108f, -0.01167938f, 0.00603623f, -0.04803906f, 0.00855187f, 
    -0.06514841f, -0.02128696f, -0.05504860f, 0.00165546f, 0.02147876f, 0.03080103f, -0.06034059f, 0.03102903f, 
    0.05850117f, -0.05896583f, 0.02191078f, 0.05266391f, 0.03336804f, 0.02100254f, -0.05302359f, 0.02809055f, 
    -0.06175441f, -0.01561167f, -0.04226522f, 0.00691506f, 0.01429836f, -0.00187090f, 0.00355245f, 0.02555207f, 
    0.04873089f, -0.03663836f, -0.00490227f, -0.03062679f, -0.00005646f, -0.00750444f, -0.02062095f, 0.03942556f, 
    0.06424449f, -0.05278473f, -0.02018560f, 0.01839073f, 0.03350619f, -0.00495050f, -0.06045864f, -0.06991930f, 
    0.06316464f, -0.05909077f, 0.01800494f, 0.02409653f, -0.06385936f, -0.03217070f, 0.03303357f, -0.03350117f, 
    -0.02231649f, -0.07142548f, -0.05750137f, -0.02224986f, 0.03944480f, -0.01514263f, -0.06555507f, -0.05246061f, 
    -0.03480237f, -0.01833420f, -0.01780198f, 0.05274885f, -0.05299188f, 0.03302954f, -0.07512875f, -0.02714707f, 
    -0.01867158f, -0.00356823f, -0.07093458f, -0.07194863f, 0.03207546f, -0.02825089f, 0.05911017f, -0.01976923f, 
    0.06161645f, 0.01251669f, -0.06160111f, 0.04492488f, -0.05063421f, -0.05658317f, -0.00404921f, -0.06909505f, 
    0.04678385f, -0.07652110f, -0.04161131f, 0.06111761f, -0.02028797f, -0.01512434f, -0.00975293f, -0.02754290f, 
    -0.01405525f, -0.06248220f, -0.00448093f, 0.04732133f, -0.00849691f, -0.05891664f, 0.00068256f, 0.03852821f, 
    -0.05575963f, -0.05797900f, -0.06298342f, -0.07314769f, 0.00638404f, 0.04379920f, -0.06352361f, 0.01750287f, 
    -0.06296142f, -0.02793800f, 0.00586167f, 0.05957016f, -0.01748354f, -0.03377869f, -0.01823274f, -0.00941773f, 
    0.00424276f, -0.06595484f, -0.02769608f, 0.00844980f, -0.06757630f, -0.05306066f, 0.04298425f, 0.04105008f, 
    0.03129079f, -0.05584165f, 0.05106585f, -0.06310125f, -0.04198068f, 0.01622231f, -0.04981039f, 0.04928100f, 
    0.04447970f, -0.01530483f, -0.07036402f, -0.04035009f, 0.03882573f, -0.05194909f, -0.05765735f, -0.03697261f, 
    0.00997233f, 0.00875016f, 0.01635342f, -0.00212119f, 0.02801050f, -0.07766947f, -0.03688452f, -0.07717725f, 
    0.05034112f, 0.00460193f, -0.01770074f, 0.01971242f, -0.00876706f, -0.07169076f, -0.07780436f, -0.00262454f, 
    -0.02280580f, -0.05468759f, -0.06058698f, 0.04653418f, 0.01164684f, -0.02261423f, -0.05071735f, -0.01032307f, 
    0.05850168f, -0.04968644f, -0.04693729f, 0.04400490f, -0.05671163f, 0.04804463f, 0.02557545f, -0.02216084f, 
    0.04664392f, -0.06530030f, 0.02986836f, -0.02654478f, -0.00438312f, -0.00678703f, -0.06725320f, 0.06301741f, 
    0.04135768f, 0.05975318f, -0.00406562f, -0.06371001f, -0.00725421f, 0.01540769f, -0.00884078f, 0.04247802f, 
    -0.03148880f, -0.02652611f, -0.01723247f, 0.05930505f, -0.05171553f, -0.02188443f, 0.01682034f, -0.02156218f, 
    -0.00108662f, -0.02113584f, 0.00141239f, -0.00164929f, 0.02064211f, -0.04006005f, -0.04968984f, -0.03629308f, 
    -0.04211786f, -0.04042409f, -0.03431524f, -0.01454422f, -0.03682815f, 0.03666682f, 0.03079477f, -0.06316595f, 
    0.00654146f, -0.01872822f, 0.02776423f, -0.04801841f, 0.02670903f, -0.00111350f, 0.00136980f, 0.01367093f, 
    -0.00194011f, -0.05516045f, -0.00795251f, 0.05738031f, -0.01171853f, -0.04038544f, 0.03141255f, 0.01245509f, 
    -0.04856464f, 0.04299646f, 0.04701365f, -0.03602575f, -0.06367505f, -0.06367891f, 0.04074642f, -0.07351187f, 
    0.03511114f, -0.05374534f, -0.03407661f, -0.01385029f, 0.03198986f, -0.07293759f, -0.06333060f, 0.02282104f, 
    0.02214730f, -0.04049608f, -0.02964162f, -0.07005519f, -0.05576013f, 0.05503568f, -0.06385753f, 0.01812743f, 
    0.11129604f, 0.20597266f, -0.11016183f, 0.01385978f, -0.08855502f, -0.03521788f, -0.02244878f, 0.07932980f, 
    -0.13861614f, 0.01392633f, 0.19052033f, -0.04654576f, -0.06435110f, 0.15485799f, 0.09312312f, 0.03594269f, 
    0.16672178f, 0.02804845f, -0.03653582f, 0.05809278f, 0.03592848f, -0.03815142f, -0.03756406f, 0.00715182f, 
    -0.11788499f, 0.15524600f, 0.25509939f, 0.10837741f, 0.00269247f, 0.05826810f, 0.07547700f, -0.04140504f, 
    -0.10932293f, -0.06779885f, 0.00003834f, -0.04451149f, -0.20675458f, -0.01938035f, 0.15621506f, -0.08756462f, 
    0.10187358f, 0.03129056f, 0.04273905f, -0.09474187f, 0.04286135f, 0.04076973f, -0.10612866f, 0.02262534f, 
    0.23433040f, 0.07852425f, 0.03738190f, 0.00075451f, 0.07799071f, -0.03885866f, -0.05085744f, -0.10728675f, 
    -0.08739915f, -0.02823084f, -0.06454315f, 0.04188355f, -0.00610072f, -0.14952436f, -0.21498317f, 0.06729994f, 
    -0.07916278f, 0.00955164f, -0.05577651f, -0.13338000f, -0.12784190f, -0.07932182f, -0.11052673f, -0.21250905f, 
    0.14387833f, 0.10781588f, -0.18745987f, 0.05381088f, 0.08432329f, 0.07622100f, -0.14237408f, -0.03395141f, 
    -0.06291787f, 0.01133117f, -0.00424688f, 0.06083407f, -0.05912255f, -0.06013289f, 0.13374014f, 0.27188131f, 
    0.06656096f, -0.01066913f, -0.04343783f, -0.04160757f, 0.12302916f, 0.02955985f, -0.00432788f, 0.06981177f, 
    0.16232617f, -0.13574079f, -0.16179158f, 0.08526623f, 0.00319145f, -0.04851023f, -0.06907502f, 0.02847857f, 
    0.03581643f, 0.13546082f, 0.00260561f, 0.08596355f, 0.12257291f, 0.05523800f, 0.16019854f, -0.04160105f, 
    0.17690974f, 0.15368199f, 0.19049950f, 0.01705500f, 0.06264020f, -0.11196975f, -0.00228880f, 0.05361609f, 
    0.21441180f, -0.11381169f, 0.02540473f, 0.05351975f, 0.07760973f, -0.02917405f, -0.03665276f, -0.11872137f, 
    0.03749231f, 0.13413593f, -0.01829815f, 0.04577317f, 0.03602656f, -0.07858652f, 0.04041590f, 0.02636226f, 
    0.10144377f, -0.12089206f, -0.03063621f, 0.00234005f, 0.09485397f, -0.21413562f, -0.02575888f, 0.11091752f, 
    -0.08551148f, -0.02328477f, -0.02363892f, 0.17558174f, 0.00475179f, -0.02027400f, -0.00106513f, -0.09254377f, 
    -0.12390595f, 0.09966058f, -0.10055015f, -0.13278978f, -0.11908624f, -0.10593788f, -0.12662444f, 0.10832967f, 
    0.11242682f, -0.07926184f, 0.04727111f, -0.13020758f, -0.05813871f, 0.07632892f, 0.03826594f, 0.02880840f, 
    0.19747795f, -0.01473358f, 0.11480618f, 0.06984472f, 0.01000623f, -0.02419036f, -0.02220491f, -0.14240840f, 
    0.16613835f, -0.02206471f, -0.02776450f, 0.07696414f, 0.08413739f, 0.23335777f, 0.08961551f, -0.17625280f, 
    -0.02063462f, 0.02967188f, -0.08249810f, -0.06563908f, -0.06396011f, -0.00713431f, -0.00828888f, -0.06657067f, 
    -0.32094920f, 0.04641521f, -0.07710072f, -0.08203670f, 0.09243388f, 0.08187380f, -0.04074746f, 0.01145918f, 
    0.03224192f, 0.10891981f, 0.09121910f, -0.15303873f, 0.12325899f, 0.08640853f, 0.18594915f, 0.14650792f, 
    0.09689504f, -0.00538477f, 0.23426211f, 0.01974787f, -0.16807340f, 0.12945218f, 0.10001999f, 0.03653409f, 
    0.27364913f, -0.39782310f, 0.17321710f, 0.05878348f, -0.00721009f, 0.07243902f, -0.00149831f, 0.16585390f, 
    0.00081863f, -0.02824107f, 0.10996847f, 0.00083073f, 0.44346690f, 0.00592350f, 0.12805846f, 0.00071498f, 
    -0.07760257f, 0.02681346f, 0.00722492f, 0.08470249f, -0.05820365f, -0.01393036f, -0.03046540f, -0.02463597f, 
    0.27151948f, -0.24493185f, -0.05220556f, -0.06602821f, 0.15059486f, -0.06376518f, 0.07364162f, -0.00709742f, 
    -0.04355766f, 0.05931394f, 0.01219407f, 0.12663633f, -0.25436246f, 0.08029092f, 0.12170674f, -0.29091999f, 
    0.00964816f, -0.02560426f, 0.04738682f, -0.16611563f, 0.01194701f, 0.07839653f, 0.03433284f, 0.06241444f, 
    -0.23780794f, -0.22331847f, 0.23742151f, 0.13804238f, 0.16760053f, 0.13088372f, -0.10267857f, 0.04024113f, 
    -0.00957941f, 0.04264212f, -0.08632103f, -0.13730516f, -0.20798367f, 0.00233170f, -0.24352781f, -0.15432641f, 
    0.09664570f, 0.02809402f, -0.02331896f, 0.11916321f, -0.00949050f, -0.06921587f, -0.05663185f, -0.03647761f, 
    -0.14565571f, 0.08728129f, 0.23434125f, 0.07978796f, -0.12508075f, -0.02336975f, 0.03839009f, -0.04273470f, 
    -0.08466368f, -0.01466667f, -0.00533633f, -0.12826642f, 0.18996093f, 0.06101665f, -0.02802593f, 0.20826447f, 
    0.04044971f, -0.00625834f, -0.18627556f, 0.06132714f, -0.10756934f, 0.01026439f, 0.06811317f, 0.05594633f, 
    0.23585641f, 0.02396865f, -0.00282530f, -0.18547009f, -0.01273031f, 0.10326521f, -0.05784449f, 0.08783831f, 
    0.05464493f, 0.15896820f, 0.05247679f, 0.13137963f, 0.17609482f, -0.05662646f, 0.16353032f, -0.20885582f, 
    -0.02606361f, 0.08769386f, -0.03477881f, -0.09461062f, 0.01627537f, -0.02406697f, 0.14917250f, -0.15185086f, 
    -0.17558530f, 0.15517999f, -0.17241231f, -0.15973711f, -0.05993646f, 0.09302478f, 0.02677359f, 0.06870986f, 
    0.01183093f, 0.00993110f, 0.00502671f, -0.08658882f, -0.11256657f, 0.23937614f, 0.00340059f, -0.12124611f, 
    0.02729362f, -0.04173739f, 0.07447587f, -0.03789622f, 0.04227621f, -0.02404306f, -0.09748571f, -0.16184920f, 
    0.22048593f, -0.23314388f, 0.03831929f, -0.07841334f, -0.09417419f, -0.02363393f, -0.02469094f, 0.00617996f, 
    -0.03972545f, -0.07450493f, 0.10964148f, -0.05668784f, -0.09199464f, 0.01501780f, 0.13820566f, 0.13956882f, 
    0.04383420f, 0.06773501f, 0.26567280f, 0.14610779f, -0.04191731f, 0.10556687f, 0.01486059f, -0.00178754f, 
    -0.24923433f, 0.22719789f, -0.03386929f, -0.13119549f, 0.10251234f, 0.05373780f, 0.12288466f, 0.01399151f, 
    -0.06525216f, 0.10451703f, 0.01707292f, -0.01238495f, 0.00625756f, -0.02738066f, 0.08924180f, -0.00114101f, 
    0.08828710f, 0.06010704f, 0.06489445f, -0.02222399f, -0.16302900f, 0.11321714f, -0.02245611f, 0.00601212f, 
    0.56801885f, -0.20124553f, 0.11209038f, 0.05292226f, 0.04239704f, 0.12134928f, -0.05033824f, 0.02642084f, 
    0.02575142f, 0.06811119f, -0.00737476f, 0.16206111f, 0.60474271f, -0.06190369f, 0.08906645f, -0.15987433f, 
    -0.11340012f, 0.07768483f, 0.03254639f, 0.03753791f, -0.05369522f, 0.01885223f, 0.01951589f, -0.08930800f, 
    0.15089774f, -0.15014070f, -0.05868262f, -0.10774090f, 0.16431443f, 0.04388019f, 0.00726446f, 0.02864747f, 
    0.02837236f, -0.02576116f, 0.07376467f, 0.09434655f, -0.10754685f, 0.28410619f, 0.07229512f, -0.31392565f, 
    0.08067431f, 0.00210664f, 0.08781009f, -0.09121094f, -0.02143292f, -0.01487504f, 0.01703689f, 0.10970102f, 
    0.10299358f, 0.01779388f, 0.09714285f, 0.23156402f, 0.00245988f, 0.02339769f, -0.02043005f, -0.06092952f, 
    -0.06934320f, -0.08025706f, 0.06324197f, -0.10110276f, -0.14752801f, -0.18296914f, 0.09517239f, -0.09431276f, 
    0.09004346f, 0.10936385f, 0.00169005f, -0.10490993f, 0.03090754f, 0.01023673f, -0.07672405f, -0.08678622f, 
    -0.04795732f, 0.15181057f, 0.10939644f, 0.00568288f, -0.05816355f, 0.03504249f, 0.09559249f, 0.05117986f, 
    -0.13855593f, 0.09081004f, -0.01535848f, -0.09716417f, -0.11568039f, 0.10729854f, 0.05538972f, 0.22092794f, 
    -0.07895968f, 0.14446400f, -0.16834322f, 0.01361274f, -0.06580483f, 0.05924905f, 0.12307480f, 0.02197209f, 
    -0.05494599f, 0.09144340f, -0.05679056f, -0.00500226f, 0.02520652f, -0.00169854f, -0.03984572f, 0.00695778f, 
    0.00609087f, 0.13844660f, 0.24348871f, 0.06073011f, 0.31231445f, -0.19692092f, -0.05206705f, -0.29126063f, 
    -0.02623088f, 0.02157572f, -0.03283547f, -0.15143196f, -0.06908824f, 0.06892105f, 0.21364892f, -0.13755773f, 
    0.08791671f, 0.14993560f, 0.07362480f, -0.22044635f, 0.09691835f, 0.04197099f, -0.01205168f, -0.04864198f, 
    0.10638455f, -0.03547332f, -0.01725540f, 0.10573078f, -0.24592966f, 0.20695049f, -0.00402353f, -0.33246884f, 
    0.14433472f, 0.05220572f, -0.05273480f, -0.01087580f, 0.04342306f, 0.05351811f, -0.02149565f, -0.04461778f, 
    0.42741022f, -0.17956810f, -0.28310031f, -0.02728942f, 0.02056632f, -0.02359279f, -0.00835146f, 0.02260105f, 
    -0.06933479f, 0.01020218f, 0.04251050f, 0.01259484f, 0.10927176f, 0.00744181f, 0.16945641f, 0.04817639f, 
    -0.07669643f, 0.06037566f, 0.04779603f, 0.10675025f, -0.02764865f, 0.09146292f, -0.05684172f, 0.02816625f, 
    -0.33088240f, 0.09491754f, -0.09816701f, -0.05323912f, 0.05176587f, 0.05979174f, 0.00837597f, -0.12537824f, 
    0.01656236f, 0.01077591f, -0.03066031f, -0.01406031f, -0.18595049f, -0.26794776f, -0.07620424f, 0.05631823f, 
    0.02059594f, -0.01731709f, 0.11367501f, -0.00194001f, 0.01534477f, 0.02427096f, 0.10971077f, 0.02052853f, 
    0.39485326f, -0.34174106f, 0.08090076f, 0.06035546f, 0.03232555f, 0.11045952f, -0.00834533f, 0.01182923f, 
    0.01708122f, -0.06235752f, -0.00012504f, 0.02355993f, 0.16685188f, -0.03075162f, -0.00561038f, -0.18063451f, 
    -0.06846339f, 0.05593307f, 0.06984743f, -0.00704419f, 0.06503369f, 0.02369780f, -0.01331605f, -0.11418078f, 
    0.56730324f, -0.21802570f, -0.05405582f, -0.00589007f, 0.15688360f, 0.01126918f, -0.09280314f, -0.09388047f, 
    0.04262692f, 0.05624257f, 0.12063640f, 0.09468505f, -0.25113857f, 0.24797338f, 0.16597378f, -0.22957107f, 
    0.10285127f, -0.01343901f, -0.08197989f, 0.17557792f, -0.00460406f, 0.04100047f, 0.08300307f, -0.04490572f, 
    0.20531799f, -0.23064026f, 0.15530089f, 0.32155442f, 0.17713907f, 0.08893984f, -0.12458005f, -0.04791625f, 
    -0.10157162f, 0.02423418f, -0.01089256f, 0.01079657f, 0.06982596f, 0.12643659f, -0.00264040f, -0.10650083f, 
    0.16573839f, 0.00329711f, -0.07915046f, -0.02523651f, -0.02331616f, -0.08525991f, 0.07834642f, -0.08331366f, 
    -0.03564314f, 0.04577138f, 0.04560418f, -0.09173641f, -0.02901898f, -0.10583592f, 0.10256458f, -0.07805185f, 
    -0.02228204f, 0.07858480f, 0.02336436f, -0.00558415f, -0.31168956f, 0.00540534f, 0.01706623f, 0.18331929f, 
    0.05613106f, 0.14234422f, -0.17796987f, -0.06033305f, -0.06834231f, 0.10430741f, 0.08741772f, 0.13654885f, 
    0.04216167f, 0.02014023f, 0.07688796f, -0.19714886f, 0.12923685f, 0.17099081f, -0.08894051f, -0.01108072f, 
    -0.07228930f, -0.04269093f, 0.21995695f, 0.03640650f, 0.29428640f, -0.15491368f, 0.11173876f, -0.13732199f, 
    0.02777821f, -0.09275901f, 0.06786244f, 0.03428219f, 0.01971774f, -0.01425403f, -0.00463963f, 0.06927472f, 
    -0.13290443f, 0.06066033f, 0.10873789f, -0.17832235f, 0.12367556f, -0.02940736f, -0.08215162f, -0.05606934f, 
    0.05392658f, -0.05615355f, -0.00153745f, 0.15394734f, -0.29139221f, 0.15900989f, 0.17547411f, -0.24857877f, 
    0.08729135f, -0.08511694f, 0.04992568f, 0.01290081f, -0.06980155f, 0.07009231f, -0.04218472f, -0.05224459f, 
    0.23274516f, -0.07758268f, -0.09166627f, -0.23596188f, -0.08369492f, 0.02261408f, 0.13276768f, 0.05739883f, 
    -0.00693622f, -0.03145221f, 0.15872130f, 0.10373533f, -0.02131711f, -0.12223515f, 0.28201056f, 0.23255575f, 
    -0.15078950f, 0.11454247f, 0.09251308f, 0.12887488f, 0.10886645f, 0.09835605f, 0.14740804f, 0.01312553f, 
    -0.03778124f, -0.02454268f, -0.01199471f, 0.02428438f, -0.05618318f, -0.03815838f, 0.00386622f, -0.04395473f, 
    -0.03205763f, 0.00554349f, -0.03562697f, 0.00849484f, -0.04584429f, 0.03632386f, -0.01404186f, 0.04353406f, 
    0.06000780f, 0.02471438f, 0.02880583f, -0.03312676f, 0.03361889f, -0.07646479f, -0.01150462f, 0.02665510f, 
    0.06598561f, -0.01926173f, -0.06142157f, 0.00041129f, -0.00691675f, -0.02701450f, 0.04822479f, -0.06645364f, 
    -0.01365493f, -0.06828484f, 0.01981941f, -0.03591519f, 0.06309187f, -0.06759953f, -0.02123835f, 0.06059412f, 
    -0.04298132f, -0.02442413f, -0.04540109f, -0.00106257f, 0.01376429f, -0.05606032f, -0.05123428f, -0.00570959f, 
    0.06060513f, -0.04854644f, 0.03704307f, -0.04940946f, 0.01937222f, -0.03649872f, -0.00383000f, 0.05935508f, 
    0.00674161f, 0.01783568f, 0.04236072f, -0.03969699f, -0.00029678f, -0.04403402f, -0.02010452f, -0.05130461f, 
    0.05443827f, -0.05141464f, -0.01647360f, -0.02577015f, -0.00052871f, -0.05854736f, -0.07423325f, 0.02779640f, 
    -0.06189172f, -0.04039377f, 0.06258412f, 0.05017448f, -0.05856043f, -0.05969900f, 0.02895544f, -0.07272858f, 
    -0.06834687f, -0.02387497f, 0.00123373f, 0.06355364f, 0.06278640f, -0.01380390f, -0.01461520f, -0.00418497f, 
    0.03546303f, -0.03918990f, 0.00688501f, -0.00013192f, -0.02565643f, 0.03733268f, -0.01028387f, 0.03103658f, 
    -0.03041060f, -0.04255189f, -0.04818192f, 0.00634174f, -0.05121059f, -0.04773276f, 0.02437426f, 0.01554885f, 
    -0.01659842f, 0.03959965f, -0.05643524f, 0.06138403f, -0.07509618f, 0.01401116f, -0.06524984f, -0.02509293f, 
    -0.06499525f, -0.03902238f, 0.00813192f, -0.05639370f, 0.06198458f, 0.05569059f, -0.06739803f, -0.04178658f, 
    -0.04420087f, -0.07256998f, -0.02656697f, -0.06039839f, -0.01826379f, -0.02194143f, -0.03800517f, -0.04308444f, 
    -0.00752976f, 0.02114174f, -0.00398630f, -0.00548278f, -0.05239376f, 0.05370468f, -0.00627366f, 0.01720134f, 
    0.02412676f, -0.05675908f, 0.04533965f, 0.03601589f, 0.00719318f, 0.01992570f, -0.00115031f, -0.02070758f, 
    0.04889842f, 0.00041787f, -0.04262503f, -0.04966465f, 0.00376480f, -0.01092976f, -0.01169540f, 0.05023662f, 
    -0.03122522f, 0.05022253f, 0.04051209f, 0.05958222f, -0.01470638f, -0.00582141f, -0.01678130f, -0.05907118f, 
    -0.06086890f, -0.04981503f, -0.02284444f, -0.01064296f, -0.06141607f, -0.05990945f, 0.04863234f, 0.02510338f, 
    0.04663786f, 0.06565490f, -0.02003272f, -0.05286485f, -0.04711629f, -0.03655043f, -0.05203304f, -0.07277322f, 
    -0.05879963f, -0.04871592f, -0.04724428f, 0.02453765f, -0.04642791f, 0.02318317f, -0.00075788f, -0.06949497f, 
    0.04379654f, 0.04954537f, -0.01086176f, -0.01624911f, 0.00006694f, 0.03770962f, -0.06018993f, 0.06347646f, 
    -0.16935438f, 0.29845735f, -0.38300776f, 0.03335474f, 0.02357918f, 0.08404121f, -0.11261427f, -0.02291873f, 
    -0.04911527f, 0.18945663f, 0.14848317f, 0.09266240f, 0.05152494f, 0.00406035f, 0.19330975f, -0.01577356f, 
    0.08423831f, 0.03795289f, 0.09099588f, -0.13821322f, -0.06861824f, 0.08637555f, -0.04099508f, -0.01613533f, 
    -0.25819990f, -0.11675378f, 0.22644718f, 0.00939903f, 0.08781191f, 0.08319326f, -0.06117930f, -0.20473947f, 
    0.11522208f, -0.00594740f, 0.10211365f, 0.10587469f, -0.10347749f, 0.07183103f, 0.06906894f, -0.26893458f, 
    -0.11587652f, -0.03607772f, 0.15378429f, -0.14294744f, 0.07397701f, 0.08609689f, -0.15805072f, -0.00635496f, 
    0.20873696f, -0.17102294f, -0.01467280f, -0.00909703f, 0.08257400f, -0.13643835f, 0.06443661f, -0.00600040f, 
    -0.09553671f, 0.00118174f, -0.11659582f, 0.03390135f, -0.02911013f, 0.06052507f, -0.06759534f, -0.13569658f, 
    0.16818985f, 0.03265643f, -0.01282276f, -0.04387828f, -0.00842624f, -0.00316814f, -0.02127020f, -0.05690652f, 
    0.44316304f, -0.12565446f, -0.12067402f, 0.00822046f, 0.06517875f, 0.14883631f, 0.00259788f, -0.02226829f, 
    0.02124769f, -0.08253361f, 0.10946756f, -0.03313714f, 0.05407692f, 0.07004098f, 0.01604482f, 0.11964281f, 
    0.02279956f, -0.06205126f, 0.05290788f, -0.12935695f, 0.01356049f, 0.04874995f, 0.00856028f, -0.07923934f, 
    0.19421543f, -0.12258918f, -0.00217103f, -0.10349137f, 0.01616483f, -0.01518143f, 0.06048993f, 0.02594974f, 
    0.03772072f, 0.07601935f, -0.00762433f, -0.05888924f, 0.09000798f, 0.06600840f, 0.03121786f, 0.14698657f, 
    -0.07750482f, 0.14868546f, 0.11713499f, -0.02805279f, 0.01543224f, -0.04543380f, 0.18116790f, 0.09150435f, 
    0.30894402f, 0.05369387f, 0.00161286f, -0.14007646f, 0.09604590f, 0.00202470f, -0.05626117f, 0.01524097f, 
    0.04688999f, 0.26183414f, 0.17577218f, 0.01036125f, 0.23719554f, -0.24235208f, 0.10333785f, -0.16566673f, 
    -0.02140752f, -0.05451781f, 0.01259467f, -0.02214983f, 0.07593854f, 0.09853197f, 0.17233168f, -0.02096609f, 
    0.06288767f, 0.08134573f, -0.00458631f, -0.05724700f, 0.13959716f, 0.01671757f, -0.12332173f, -0.09684126f, 
    -0.00456317f, 0.01351586f, 0.09290072f, -0.05801777f, -0.11433936f, 0.17588089f, 0.12182844f, 0.08994384f, 
    0.27056563f, 0.10543726f, 0.05737447f, -0.08703218f, -0.04531386f, 0.00365469f, -0.03198810f, 0.05318712f, 
    0.18710221f, -0.45579919f, 0.06403750f, -0.01493377f, -0.00898359f, 0.04336684f, 0.01106029f, 0.03733763f, 
    0.00879569f, -0.03901577f, -0.01665030f, -0.03829204f, -0.25122112f, 0.03017549f, 0.12451942f, 0.22420983f, 
    -0.11764629f, 0.01206443f, 0.06053904f, 0.09900814f, -0.02331219f, 0.15424269f, -0.01393642f, -0.03296243f, 
    0.00265099f, 0.06130580f, 0.00042095f, 0.04175988f, -0.02334670f, 0.05704557f, 0.03378075f, -0.01914896f, 
    -0.04666606f, 0.03851331f, -0.03589969f, -0.03604116f, -0.06243898f, 0.05328638f, -0.02236296f, 0.04575419f, 
    0.00007703f, -0.06422292f, 0.05962818f, -0.04660374f, -0.04006280f, 0.03176513f, 0.03078854f, 0.05982301f, 
    -0.07584905f, -0.00971244f, -0.07187940f, 0.02242213f, -0.01068607f, 0.03466418f, 0.03782010f, -0.00391133f, 
    0.00770907f, 0.05328607f, 0.01648638f, 0.06063874f, -0.02283534f, -0.03714382f, -0.07706600f, -0.01950427f, 
    -0.06294973f, -0.00594953f, -0.05224894f, -0.07247281f, -0.04733732f, 0.01862228f, -0.00931141f, 0.05783639f, 
    -0.03916547f, 0.01098437f, -0.06766855f, 0.04418502f, 0.02833756f, -0.04318890f, 0.05504295f, 0.01461114f, 
    0.05343422f, -0.03822673f, -0.02011775f, 0.01018439f, -0.03420919f, 0.03258471f, -0.04697933f, 0.02311939f, 
    0.00854322f, 0.00107704f, -0.05066000f, -0.00584005f, -0.01256137f, 0.00588636f, -0.02798667f, -0.07648093f, 
    0.06185429f, 0.01081489f, 0.04545951f, -0.05023962f, 0.01645854f, 0.05241420f, -0.00086744f, 0.03765312f, 
    -0.05712983f, -0.03028582f, -0.06495585f, -0.05453715f, 0.00536343f, -0.01542708f, 0.06371450f, 0.03679600f, 
    -0.00587738f, -0.03170935f, 0.06410559f, -0.00641552f, -0.03201605f, -0.03152996f, 0.04628601f, 0.00023399f, 
    -0.02041344f, 0.04210080f, 0.01958385f, -0.03548668f, -0.00252661f, 0.00861237f, -0.03404754f, 0.02673678f, 
    0.00652312f, 0.00016414f, -0.01378348f, -0.01991691f, 0.06326692f, 0.04524451f, -0.00058553f, 0.00831984f, 
    -0.06693873f, 0.04928789f, -0.03077540f, -0.03128095f, 0.04745981f, -0.04924158f, -0.07252959f, -0.07262719f, 
    0.00074132f, -0.07812166f, 0.02519581f, 0.01976490f, 0.01992954f, -0.03778723f, -0.06457755f, 0.01956220f, 
    -0.05553621f, -0.07440972f, 0.02760737f, -0.02532907f, 0.01743864f, -0.07815711f, 0.00040725f, -0.04403340f, 
    0.04593420f, -0.06026313f, -0.07009757f, -0.06385945f, -0.00964887f, 0.05592471f, -0.04820479f, 0.00297997f, 
    0.06091515f, -0.00534276f, -0.04283101f, 0.05715317f, 0.01998631f, -0.06875927f, 0.05806128f, -0.02007686f, 
    -0.02041373f, -0.07011465f, -0.06248465f, -0.07154372f, 0.04016893f, -0.05896638f, -0.04727682f, 0.04565325f, 
    0.00236760f, 0.02749829f, 0.06236325f, 0.02487031f, -0.06187172f, 0.06482018f, -0.01673129f, 0.03250811f, 
    -0.07402090f, -0.04249657f, -0.04753876f, -0.02810248f, -0.05851450f, 0.00984453f, -0.01959428f, -0.07282494f, 
    -0.01398362f, 0.05586065f, -0.04058371f, 0.03460649f, -0.01988560f, 0.04562328f, -0.02939621f, 0.00037181f, 
    0.05972119f, -0.01111482f, 0.00529270f, -0.04036843f, -0.05642648f, -0.00370141f, -0.03011698f, 0.00369576f, 
    0.03793066f, -0.00368603f, -0.07523094f, -0.06019920f, -0.02249065f, 0.02796003f, -0.02808421f, -0.01321485f, 
    0.03306043f, -0.04831118f, -0.10375627f, -0.06920607f, -0.05880324f, 0.02784151f, -0.07162458f, -0.03455658f, 
    0.01167805f, -0.06683042f, -0.00442845f, -0.06322019f, -0.08116199f, -0.06707072f, -0.05407291f, 0.01056234f, 
    0.01981395f, -0.05679707f, 0.01996226f, 0.00045791f, -0.06750855f, -0.03848872f, -0.08329895f, -0.08725383f, 
    -0.07364654f, -0.04585796f, -0.01497650f, -0.01427790f, 0.01694569f, 0.03549631f, 0.03883111f, 0.02825061f, 
    0.04307057f, 0.04272455f, 0.04332019f, -0.01086051f, 0.03703729f, -0.06853390f, -0.08544262f, -0.05367539f, 
    -0.05851778f, -0.04200966f, -0.05105259f, -0.07809098f, -0.00168248f, 0.03160409f, 0.00526890f, 0.04870303f, 
    -0.03576822f, 0.06343892f, -0.08139388f, -0.00277219f, -0.02446485f, 0.00764235f, -0.08346105f, 0.06905531f, 
    -0.04666750f, -0.04247212f, -0.04668927f, 0.01097367f, -0.04239928f, -0.02479737f, -0.06403100f, -0.04498279f, 
    0.01819390f, 0.07503109f, 0.00641087f, 0.00418774f, -0.04597264f, -0.07194878f, -0.06810974f, -0.04628452f, 
    -0.09489360f, -0.04224152f, 0.03880036f, -0.05718943f, -0.02841840f, -0.02464555f, 0.00604399f, 0.02498822f, 
    -0.07197212f, -0.02015372f, -0.02290148f, -0.02405359f, -0.06068645f, -0.04396758f, -0.04912971f, -0.06492025f, 
    -0.04956780f, -0.04594920f, 0.00559447f, 0.03814495f, 0.04266313f, 0.02427602f, -0.08639948f, 0.03219079f, 
    0.00499627f, -0.02106256f, 0.02245818f, 0.04173618f, 0.03861713f, 0.00634671f, -0.06580709f, 0.00369023f, 
    -0.04381719f, 0.05134790f, 0.05055064f, -0.05262059f, -0.00091108f, -0.01730947f, -0.08875526f, -0.07880235f, 
    -0.08031532f, 0.04587086f, -0.01622541f, -0.01612632f, -0.05173539f, 0.00953874f, -0.06757332f, -0.08894137f, 
    -0.00248041f, -0.08506024f, -0.00435865f, -0.05666602f, -0.05734097f, -0.05823106f, -0.08697445f, 0.06070878f, 
    0.01863965f, -0.01069152f, -0.09687126f, 0.00419689f, -0.02194251f, 0.04822260f, -0.03767424f, 0.04728434f, 
    0.03607853f, -0.10450161f, 0.00331438f, 0.00665965f, -0.00931486f, -0.10878526f, -0.10564079f, -0.00632198f, 
    -0.03696496f, -0.01905773f, -0.06679394f, 0.04810525f, 0.01025846f, -0.08918892f, -0.03818506f, -0.03446650f, 
    -0.05276046f, 0.02186519f, -0.01193127f, -0.04404894f, -0.05944200f, 0.04395211f, 0.03991760f, -0.06232996f, 
    0.01886885f, 0.10520419f, -0.04632961f, 0.07443340f, 0.02893037f, -0.04446386f, 0.03803501f, -0.08514071f, 
    -0.05288443f, -0.07928262f, 0.03552673f, -0.01791567f, -0.07454157f, -0.08582161f, 0.01482551f, -0.08414586f, 
    -0.08716343f, -0.04159983f, -0.03406730f, 0.04802406f, -0.07373574f, -0.07843444f, -0.04312257f, -0.00936590f, 
    0.15838885f, 0.10786640f, -0.03905316f, -0.05436190f, 0.00319545f, -0.10646245f, -0.16565716f, 0.07321890f, 
    0.03644146f, -0.00835989f, -0.08166656f, 0.15033343f, -0.05466582f, -0.14774887f, -0.14060001f, -0.13146295f, 
    -0.00403373f, 0.16550700f, -0.05417198f, -0.09161150f, -0.02869303f, 0.10723870f, -0.13029115f, -0.06473826f, 
    -0.34582719f, 0.04547938f, 0.01617869f, -0.08768594f, 0.16113254f, 0.00134530f, -0.05530493f, -0.08517057f, 
    0.13733597f, -0.03467983f, 0.01116575f, 0.15254954f, -0.44520327f, 0.19741753f, -0.07070069f, -0.14065936f, 
    0.01859301f, -0.02617980f, -0.01720291f, 0.05686343f, 0.00259273f, 0.00854709f, 0.05398116f, 0.05730850f, 
    -0.09826633f, 0.12440974f, 0.03789568f, 0.13973591f, -0.01066488f, 0.06612895f, -0.00119393f, 0.12278575f, 
    -0.06658725f, -0.06897584f, -0.01381747f, -0.11820031f, 0.37395555f, 0.21077180f, 0.16425730f, -0.02670614f, 
    0.01004282f, -0.05299929f, -0.07090345f, 0.21936019f, -0.00146480f, 0.00398548f, -0.02595518f, -0.00008714f, 
    0.58566725f, 0.09325908f, -0.09706697f, 0.08847918f, -0.15410741f, -0.01859765f, -0.03918183f, -0.06345825f, 
    0.05173400f, 0.02997249f, 0.02041565f, -0.01252814f, 0.35945368f, 0.27433884f, 0.04300354f, 0.02183148f, 
    0.01425228f, 0.06807806f, -0.03194641f, 0.05146805f, 0.05029428f, 0.07718223f, 0.02919105f, -0.11987215f, 
    0.15088236f, 0.06263189f, 0.01303703f, -0.00030668f, 0.05470552f, 0.01263977f, 0.14404446f, -0.11036500f, 
    -0.01054750f, 0.00855496f, -0.05999566f, -0.04799696f, -0.17078969f, -0.03494943f, 0.02015805f, 0.00120841f, 
    -0.15726186f, 0.02312367f, 0.12547882f, -0.05805377f, -0.14306368f, 0.09725619f, -0.02247759f, -0.03543686f, 
    -0.01107150f, -0.02053589f, 0.08140485f, 0.11387440f, 0.03779130f, -0.04867983f, 0.03337385f, -0.02386817f, 
    0.04260937f, -0.09723117f, 0.17277864f, -0.08960933f, 0.02052748f, -0.12789416f, -0.05287169f, 0.01793259f, 
    -0.16530773f, -0.00993967f, 0.11493263f, -0.01021097f, 0.00410733f, 0.03662186f, -0.00079587f, -0.03530811f, 
    0.20850228f, -0.08669758f, 0.21597092f, -0.00697198f, -0.02527355f, -0.03570664f, 0.00628081f, -0.01605921f, 
    0.05595243f, 0.00906604f, 0.00451748f, 0.00007589f, 0.26163343f, 0.13928264f, 0.24898683f, 0.23957840f, 
    -0.02796533f, 0.06205678f, 0.03308575f, -0.08993545f, 0.04647028f, -0.03768973f, 0.11560050f, 0.06547571f, 
    -0.05918618f, -0.20696817f, -0.09764565f, 0.11843746f, -0.04244139f, -0.04536941f, 0.11909135f, -0.00356431f, 
    0.02380197f, 0.13120405f, 0.05261613f, 0.09203459f, -0.23311037f, -0.20661521f, -0.03130588f, 0.14349629f, 
    0.16857664f, 0.14261338f, -0.08142529f, 0.03961500f, 0.11640545f, -0.04337614f, 0.09833082f, 0.09539935f, 
    0.20622344f, -0.05660899f, -0.03838591f, -0.05255193f, 0.19569159f, -0.19175370f, -0.03669654f, 0.14557120f, 
    0.05438528f, 0.04120532f, 0.00133518f, -0.05747936f, 0.08189208f, 0.11194268f, -0.07568859f, -0.08439026f, 
    -0.06913787f, 0.05223629f, 0.00244543f, 0.03857326f, -0.12729092f, 0.06244234f, 0.00720826f, -0.02238496f, 
    0.12251715f, -0.13645835f, -0.03049726f, -0.16835114f, 0.08066860f, -0.02158093f, 0.02606156f, 0.19135503f, 
    0.01678312f, -0.04185636f, -0.01486933f, 0.01637538f, 0.08009799f, 0.12670138f, -0.07270440f, -0.00884131f, 
    -0.00956224f, 0.03712730f, 0.06272978f, -0.03191620f, 0.07549070f, -0.11827484f, 0.09309930f, -0.01920776f, 
    -0.29934537f, 0.02328420f, -0.00984311f, 0.11788130f, 0.10721177f, 0.05702740f, -0.01628407f, -0.01434913f, 
    0.04230774f, -0.00038059f, -0.02328900f, 0.02928721f, 0.34698948f, 0.21454269f, 0.10180081f, -0.20089293f, 
    -0.08858038f, 0.02786993f, 0.13762695f, 0.02716629f, -0.01016857f, 0.00155115f, 0.12196813f, 0.15077339f, 
    0.24738453f, 0.19809061f, 0.08775903f, 0.05399597f, -0.14224128f, -0.19730990f, 0.01718906f, -0.06654420f, 
    0.01962940f, 0.03789612f, -0.07490314f, 0.01422989f, 0.16753235f, -0.11931909f, 0.08306417f, -0.16237840f, 
    -0.16134076f, 0.03462907f, -0.01688019f, 0.02911144f, -0.12739225f, 0.02237797f, -0.05728555f, -0.05564388f, 
    0.18584725f, 0.10435021f, -0.01608898f, 0.06240074f, -0.03126544f, -0.05292442f, 0.07755574f, -0.03010937f, 
    0.06728339f, -0.01211382f, 0.03566371f, -0.08973558f, -0.05033936f, 0.14247471f, -0.09519775f, 0.03831986f, 
    -0.19456980f, 0.19347790f, -0.06152286f, -0.08824299f, -0.17336226f, 0.11347868f, -0.12548669f, -0.00009918f, 
    -0.23452152f, 0.08069525f, 0.05003143f, -0.08793207f, -0.16926563f, -0.13141973f, 0.00762271f, -0.08255053f, 
    -0.07459585f, 0.05898073f, 0.03711055f, 0.01602009f, 0.23125325f, -0.00753855f, 0.00161508f, -0.08006462f, 
    0.03141157f, 0.15225041f, 0.00358278f, -0.04104476f, -0.19571449f, -0.03070146f, 0.16599616f, -0.01149547f, 
    0.19792202f, -0.05511023f, 0.13861805f, 0.00539278f, -0.11511011f, -0.16379127f, -0.02123731f, 0.01184079f, 
    0.13561518f, -0.01936887f, 0.01271280f, 0.10242714f, 0.08133709f, 0.15323229f, 0.04615175f, 0.15729825f, 
    -0.09338632f, 0.16905460f, -0.02475160f, -0.03843812f, 0.14397055f, 0.05719431f, -0.01699470f, -0.07022762f, 
    -0.03207269f, -0.03584753f, -0.07784556f, 0.21624917f, -0.06765151f, 0.05301807f, 0.02925443f, 0.02819297f, 
    -0.00934616f, 0.12376143f, 0.01361874f, -0.03006159f, -0.10829449f, -0.14721958f, -0.08151671f, -0.07802042f, 
    0.03905576f, -0.03108707f, -0.00826878f, 0.08671631f, 0.09804244f, -0.03035163f, 0.03241576f, 0.00856273f, 
    0.52924269f, 0.06598786f, 0.26364979f, -0.09273405f, 0.11295176f, -0.00442923f, 0.03804939f, 0.05178531f, 
    0.13012338f, -0.08199808f, 0.02672059f, -0.02329140f, 0.01034527f, -0.13201354f, -0.18089250f, -0.11294674f, 
    0.04593429f, -0.03473260f, -0.09589988f, 0.12268763f, 0.09326506f, -0.05359097f, -0.10777993f, -0.02122537f, 
    0.07910503f, 0.20749946f, -0.13328385f, 0.12725227f, -0.06070042f, 0.00190507f, 0.07521751f, 0.13088700f, 
    -0.01816430f, 0.06140854f, -0.01989571f, 0.01136931f, -0.19099292f, 0.11010135f, -0.17063528f, 0.11765595f, 
    -0.00085223f, 0.10742106f, -0.00539640f, -0.01789501f, -0.00145374f, -0.03373453f, 0.08675658f, -0.00477010f, 
    -0.17887324f, 0.10353119f, 0.06891384f, -0.01719663f, 0.04843421f, -0.01738257f, -0.06697206f, 0.06488108f, 
    0.09817179f, 0.00327918f, 0.06707342f, 0.06586659f, 0.26932520f, 0.01010757f, 0.01956877f, -0.01189644f, 
    -0.07512964f, 0.05714863f, 0.07658423f, -0.01695168f, -0.00690571f, 0.01163207f, 0.01003642f, 0.05304510f, 
    0.28094721f, 0.32533187f, 0.05644690f, 0.07853185f, -0.05148754f, -0.12828593f, -0.00269259f, 0.06858680f, 
    0.01338410f, 0.00331165f, 0.09346758f, 0.06930322f, 0.06897577f, -0.02239364f, 0.03484797f, 0.02464189f, 
    -0.18371704f, 0.07287133f, 0.07010962f, 0.01906739f, 0.03577519f, -0.02651528f, -0.05795985f, 0.03176071f, 
    -0.02674592f, 0.10251631f, -0.14045285f, 0.08048169f, 0.16342859f, 0.04514795f, 0.02894840f, 0.02852629f, 
    -0.01026644f, -0.02198943f, 0.04338253f, 0.07167158f, -0.20121697f, -0.05854227f, -0.07507824f, -0.27508220f, 
    -0.11419088f, -0.07368874f, -0.04390232f, -0.05105630f, 0.04027748f, -0.01032799f, 0.00348353f, -0.04666282f, 
    -0.08062138f, 0.07586244f, -0.06139290f, 0.10614286f, -0.04997931f, -0.11598177f, 0.01224897f, 0.00831747f, 
    0.03660382f, 0.05940522f, 0.02097200f, -0.06241150f, -0.13697571f, 0.17132473f, 0.05142857f, 0.27114192f, 
    -0.00206912f, 0.01856913f, 0.00834056f, 0.04803887f, 0.08458209f, -0.08452532f, 0.01350130f, 0.00906707f, 
    0.13554980f, -0.04405541f, 0.01401931f, 0.08577917f, -0.06672255f, 0.01254897f, 0.06157796f, 0.10248971f, 
    0.14936915f, 0.09314113f, 0.03191376f, 0.00121512f, 0.10859565f, -0.09856899f, -0.16302021f, 0.07284947f, 
    -0.14309858f, 0.02939988f, -0.04448395f, 0.04414656f, -0.05796678f, -0.11805307f, -0.15166380f, -0.02874539f, 
    -0.13242148f, 0.21638995f, -0.12630968f, 0.05096960f, 0.11348794f, 0.16697331f, 0.01167054f, 0.11139494f, 
    0.04427144f, 0.04695051f, -0.01564897f, -0.03040937f, 0.14324778f, -0.06745425f, -0.09095859f, -0.22775260f, 
    0.12859407f, -0.04493095f, -0.14841151f, 0.02213163f, 0.05919624f, -0.08771154f, 0.03442021f, 0.21959415f, 
    0.06503731f, 0.00209472f, -0.05760903f, 0.06360316f, 0.04474303f, 0.04715264f, -0.04783839f, 0.06050950f, 
    -0.07184057f, 0.05183843f, 0.02332995f, -0.00957106f, 0.04423080f, 0.00417122f, -0.02561460f, 0.00741101f, 
    0.03873124f, -0.03753938f, -0.03732322f, -0.06808005f, -0.02374174f, -0.06563443f, -0.06366839f, 0.05538430f, 
    -0.00588784f, 0.06412864f, -0.03559157f, -0.04009642f, 0.01867019f, -0.07673544f, 0.05798718f, -0.02484256f, 
    -0.00160136f, -0.04573250f, 0.06407951f, -0.00731734f, -0.06265292f, 0.00140246f, -0.02271327f, -0.00629049f, 
    -0.03132264f, -0.00425511f, 0.03393196f, 0.04780659f, -0.01185220f, -0.00538348f, -0.02641113f, -0.02545615f, 
    -0.06656712f, 0.00757819f, -0.04275028f, 0.04017767f, -0.07186738f, -0.03055858f, -0.03967936f, -0.00134576f, 
    0.04543527f, -0.04446421f, 0.03109219f, -0.00129379f, -0.07198778f, -0.00395181f, 0.01569493f, -0.04024006f, 
    -0.06526797f, -0.07645899f, 0.01570554f, -0.06455678f, 0.03570436f, 0.06304408f, 0.05527386f, 0.03597814f, 
    0.01537828f, 0.04445641f, -0.06022613f, 0.04911846f, 0.04241732f, 0.00332421f, 0.06308456f, -0.06671747f, 
    -0.05127436f, 0.02176416f, -0.06089328f, -0.06335080f, 0.00565713f, 0.00809628f, 0.01776565f, -0.04877092f, 
    0.00253538f, -0.02523122f, -0.03955098f, 0.04074948f, -0.03320646f, -0.04252382f, 0.02122941f, 0.05125807f, 
    -0.06912236f, -0.07533557f, 0.02012090f, -0.06968048f, 0.02319042f, 0.05979983f, 0.05723587f, 0.04446753f, 
    -0.04229324f, 0.04323263f, -0.00080420f, 0.03432792f, -0.03082721f, -0.05834547f, -0.01569084f, -0.03584205f, 
    -0.01685584f, -0.04291683f, -0.01331454f, -0.03729298f, 0.04186527f, -0.04829389f, -0.04887640f, -0.05347502f, 
    -0.06754147f, -0.06869513f, -0.04152305f, -0.01782853f, 0.00583426f, 0.05690574f, 0.03211303f, 0.00521813f, 
    -0.07102833f, -0.01679672f, -0.01550373f, 0.03812981f, -0.07225449f, 0.02549044f, -0.00861820f, -0.00061861f, 
    -0.05644554f, 0.03294649f, -0.04916859f, 0.00978016f, -0.00378251f, 0.00219046f, 0.01355575f, -0.00951571f, 
    -0.02523493f, -0.00110513f, 0.03135537f, 0.01693410f, 0.06295647f, -0.06458965f, -0.05790408f, -0.06901500f, 
    0.03448389f, -0.06484956f, 0.05314359f, -0.06574187f, -0.00588439f, 0.00711220f, -0.07402255f, -0.00005709f, 
    -0.04487698f, -0.02379855f, -0.05803114f, 0.02057554f, -0.03660013f, -0.04231700f, -0.03518337f, -0.02855947f, 
    0.02807290f, -0.07818665f, 0.04204359f, 0.00827364f, -0.07261930f, 0.04141143f, -0.06743433f, 0.06064150f, 
    0.03992769f, 0.00154386f, -0.01096784f, -0.04777597f, 0.01075867f, -0.00979637f, 0.03022611f, -0.04976964f, 
    -0.04529293f, -0.05302259f, -0.03853709f, -0.07769864f, -0.01567121f, -0.06432225f, 0.05952846f, -0.05429783f, 
    0.38226739f, 0.26424283f, 0.06084666f, 0.24074396f, -0.03226251f, -0.01720252f, 0.11039238f, 0.06631709f, 
    0.02101138f, -0.01914395f, 0.07514785f, 0.00563097f, -0.07686312f, -0.06400041f, -0.15375449f, -0.00228617f, 
    0.01286733f, 0.04808342f, -0.15505898f, 0.04042775f, -0.04375323f, -0.06034034f, -0.03855889f, -0.00256965f, 
    -0.04935601f, 0.20161107f, -0.16816886f, 0.11728191f, 0.07502814f, -0.07030215f, 0.04353712f, 0.05380716f, 
    -0.10106926f, 0.09169516f, 0.12542254f, 0.16495487f, 0.11104227f, 0.11364499f, -0.04741212f, -0.01929430f, 
    0.02190462f, 0.19648847f, 0.07618652f, -0.03098070f, -0.01617847f, -0.04881342f, 0.06743080f, -0.15924384f, 
    -0.42128524f, 0.02900307f, 0.13007607f, -0.08095937f, 0.02563316f, 0.01865682f, 0.08175262f, 0.06195126f, 
    -0.08545282f, 0.02029708f, 0.00042701f, 0.21845818f, 0.19882965f, 0.00527522f, -0.09710123f, -0.11169613f, 
    0.00504609f, 0.09194465f, 0.06492380f, -0.10169816f, 0.03325690f, -0.11807851f, -0.15322854f, 0.05537647f, 
    0.47233593f, 0.31395987f, 0.10987583f, 0.05800122f, -0.19724172f, 0.03587506f, 0.09266875f, 0.06426886f, 
    -0.14210761f, -0.01795149f, 0.03068670f, -0.06798446f, -0.08519483f, -0.10662639f, 0.22848548f, 0.07045624f, 
    -0.04028274f, 0.10408033f, 0.03905520f, -0.05131025f, 0.09069044f, -0.04328796f, -0.05222446f, 0.03804814f, 
    0.08259017f, 0.05139013f, -0.01778848f, -0.02204134f, 0.09178567f, 0.17399058f, 0.03663582f, 0.06581098f, 
    0.02225741f, -0.05379025f, -0.06119366f, -0.09680112f, -0.21430820f, -0.12040739f, -0.05794414f, -0.18277544f, 
    -0.26742765f, 0.00531166f, -0.17470323f, 0.10307764f, -0.01393894f, -0.16095471f, 0.13950327f, -0.02867593f, 
    0.02807906f, 0.04044279f, -0.14690614f, 0.12757532f, -0.00573921f, -0.10449863f, 0.04489365f, 0.13540779f, 
    0.07360466f, 0.32547936f, 0.14531055f, -0.06112732f, 0.03106551f, 0.15007292f, -0.03180880f, 0.01977071f, 
    -0.01614254f, -0.09039350f, 0.00250911f, -0.05465639f, 0.02337315f, 0.12259034f, 0.30727848f, -0.09237975f, 
    0.22373930f, 0.02598879f, 0.09546961f, -0.04730681f, 0.02882703f, -0.02148677f, 0.15499625f, 0.02233211f, 
    0.09303369f, 0.01434637f, 0.04405741f, 0.05451268f, -0.05824925f, 0.21013163f, -0.05122635f, -0.15505685f, 
    0.14668006f, 0.07612375f, 0.01630886f, -0.03579486f, 0.00856634f, -0.12718363f, -0.09790150f, -0.11212616f, 
    0.06037375f, 0.02987202f, -0.07492809f, 0.15242682f, -0.03227588f, -0.02259644f, -0.13543272f, 0.11814854f, 
    -0.05244458f, 0.04276858f, -0.06671984f, -0.07961918f, -0.06344046f, -0.17751233f, -0.07288292f, -0.16896927f, 
    0.07215402f, 0.02204278f, -0.04836311f, 0.16443177f, -0.07225604f, 0.03049695f, 0.00527367f, 0.11745224f, 
    -0.06486768f, 0.05699899f, -0.04062098f, -0.06276728f, -0.05211566f, -0.02797455f, 0.05374258f, -0.02629941f, 
    -0.05593643f, -0.04239408f, 0.03774879f, -0.01535671f, -0.05551958f, -0.03625083f, -0.06805471f, -0.00361803f, 
    -0.02893670f, -0.02091836f, -0.00282263f, 0.04794095f, 0.05284420f, -0.03811868f, -0.02316201f, -0.06758107f, 
    0.02334644f, -0.03857678f, -0.07676252f, 0.02937142f, 0.05745233f, 0.03362117f, 0.05856231f, 0.03699624f, 
    -0.00905398f, 0.00129181f, -0.04145803f, -0.03434981f, 0.02005074f, -0.02047791f, -0.03013280f, -0.04148839f, 
    -0.00868383f, 0.01911328f, -0.01063266f, -0.02539972f, -0.04627217f, -0.07199174f, 0.00868952f, -0.00354263f, 
    0.06422672f, -0.04022479f, -0.02912736f, -0.04184417f, 0.00331262f, -0.06378370f, -0.00638331f, 0.02565306f, 
    -0.00611643f, 0.06072894f, -0.04279556f, -0.07245134f, -0.04621369f, -0.04928026f, 0.06537097f, -0.01605159f, 
    -0.00320827f, 0.03577852f, -0.06210964f, -0.05877416f, -0.06537667f, 0.06020083f, 0.06093106f, 0.05921476f, 
    -0.03784798f, 0.04753625f, -0.03403125f, 0.01552623f, -0.07727526f, -0.04335532f, -0.00095949f, -0.03107091f, 
    0.01281682f, -0.00966617f, 0.04474492f, -0.04348584f, -0.06333155f, -0.04651586f, 0.05242019f, -0.05777179f, 
    0.01182343f, -0.07548548f, -0.00540941f, 0.01507306f, 0.00370119f, -0.01766409f, 0.05332856f, 0.03348416f, 
    -0.03280317f, 0.03904921f, 0.05809180f, 0.02395133f, 0.05113171f, -0.03104523f, 0.01037450f, 0.06441509f, 
    0.06092192f, 0.02972585f, 0.01799386f, -0.05490969f, -0.02897012f, 0.03578416f, -0.02716001f, 0.04629017f, 
    -0.01826887f, 0.00496929f, -0.07722568f, -0.07574148f, -0.05223327f, 0.03390902f, 0.04763424f, -0.05721369f, 
    -0.04971348f, -0.06187459f, -0.00042661f, 0.00196364f, 0.06552726f, -0.05662033f, 0.02278645f, 0.04307719f, 
    -0.02078982f, -0.06923648f, 0.04302859f, -0.05282770f, -0.03457828f, -0.03375139f, 0.00729538f, -0.07287799f, 
    -0.02571913f, 0.05751571f, 0.02742539f, -0.02250586f, -0.06773984f, -0.03952433f, 0.02155272f, 0.02837697f, 
    0.05939009f, 0.01690145f, -0.07536048f, -0.05785459f, -0.07344749f, 0.02589441f, -0.07540041f, -0.00914082f, 
    -0.05476878f, 0.01874491f, -0.00434635f, -0.02378673f, 0.05957974f, -0.01998959f, -0.03852219f, 0.03275355f, 
    0.04941611f, 0.05702534f, 0.03024255f, -0.06936239f, -0.00818260f, -0.01968349f, -0.05038896f, -0.02424028f, 
    -0.03866860f, -0.00212111f, -0.02481685f, -0.04391494f, 0.04257243f, 0.06498428f, -0.07232856f, -0.03367605f, 
    -0.06539135f, -0.04449867f, -0.05609648f, 0.02792357f, -0.00860232f, -0.06970954f, -0.04779078f, -0.06299843f, 
    0.05142489f, 0.03416749f, 0.03153431f, 0.01354394f, 0.06198171f, -0.00013729f, 0.01189516f, 0.02577707f, 
    -0.20088632f, -0.20545071f, -0.30403373f, -0.00435389f, -0.06642655f, -0.11910206f, -0.14766578f, 0.01659169f, 
    0.01458554f, 0.09974412f, -0.01280261f, 0.17233133f, -0.01745591f, 0.07123927f, 0.00061128f, -0.02371916f, 
    0.11038343f, 0.09227870f, 0.02948182f, -0.11568079f, 0.09333652f, 0.10019506f, -0.05796160f, 0.02697239f, 
    -0.48527563f, 0.05680468f, 0.08899596f, -0.17390634f, 0.14834988f, 0.06299740f, 0.01875068f, -0.08785933f, 
    0.11943447f, 0.02425976f, 0.04839957f, 0.07278582f, -0.37871510f, 0.25344664f, -0.00329369f, -0.15937555f, 
    0.04223147f, -0.07904837f, -0.00420482f, 0.02692299f, 0.03643571f, 0.09037165f, -0.04142870f, 0.02789471f, 
    -0.05476534f, 0.14188537f, -0.02848706f, 0.14222956f, -0.01388090f, -0.00058659f, 0.05706222f, 0.09333997f, 
    -0.01228546f, -0.15732883f, -0.00944661f, -0.19048388f, 0.10772762f, 0.03151722f, -0.03765847f, 0.07421176f, 
    -0.02220704f, -0.10300638f, -0.00366256f, 0.18222126f, 0.10851376f, -0.06953099f, 0.02247357f, -0.01969861f, 
    0.38697743f, -0.00966451f, -0.10326022f, -0.18778023f, -0.06890514f, -0.04841011f, -0.00996577f, 0.05446714f, 
    0.18532079f, -0.10937138f, 0.10707910f, 0.11596727f, 0.29453921f, 0.15521823f, 0.11291274f, -0.07031697f, 
    0.03334019f, -0.06580585f, -0.02248328f, -0.05053491f, 0.01924567f, 0.04536055f, -0.03337296f, -0.07261083f, 
    0.18368641f, -0.13966371f, -0.08900814f, -0.02136866f, 0.02830096f, -0.15565540f, 0.10418008f, -0.12387946f, 
    0.05923447f, -0.03328093f, 0.07788642f, 0.01896790f, 0.09198479f, 0.01267739f, -0.01932614f, 0.21933657f, 
    -0.01960291f, -0.02737287f, 0.25618032f, -0.03783812f, -0.06457933f, 0.02561690f, -0.09899984f, -0.00345141f, 
    0.06135863f, 0.04177615f, 0.17759192f, -0.14340784f, 0.04954771f, 0.10060039f, -0.00467930f, 0.03290141f, 
    0.09272630f, -0.15407827f, 0.01554975f, 0.05574320f, -0.00384930f, -0.00014917f, -0.02194028f, -0.00611489f, 
    -0.06878878f, 0.01048751f, 0.06525415f, 0.08107425f, -0.01852283f, 0.08493426f, -0.07363091f, 0.00093231f, 
    0.17573763f, -0.16806148f, 0.18130969f, 0.11090865f, 0.07022444f, -0.00699835f, -0.11775388f, -0.05099446f, 
    -0.04097349f, 0.02369327f, -0.04440603f, 0.04566340f, 0.29335070f, 0.03043772f, 0.26859343f, 0.24945395f, 
    -0.01036994f, 0.00243180f, 0.00143629f, 0.00116018f, 0.08566026f, 0.02392264f, 0.10133946f, 0.11402223f, 
    -0.14315592f, -0.14955278f, 0.20028119f, 0.20758456f, -0.05712050f, -0.04399362f, 0.09371651f, -0.07855842f, 
    0.11186672f, 0.10617895f, 0.07677417f, -0.01650083f, -0.23611881f, -0.17704678f, 0.01708575f, 0.26465768f, 
    0.05867051f, 0.06752273f, 0.01990442f, -0.06565388f, 0.07767160f, -0.00956830f, 0.15275575f, -0.15881127f, 
    0.02120493f, -0.01236834f, 0.00759247f, -0.04902426f, 0.06867301f, -0.01987158f, -0.00286669f, -0.01954367f, 
    0.06630655f, -0.07812849f, 0.01018582f, -0.01493449f, -0.02251726f, -0.00439134f, -0.01103494f, 0.06444705f, 
    0.05223193f, 0.04713212f, -0.04036194f, -0.01111644f, -0.03888813f, 0.02993786f, -0.06108396f, 0.02120636f, 
    -0.07598433f, -0.04638400f, 0.05568068f, -0.06456015f, -0.06174202f, -0.00504766f, 0.02651677f, -0.03535427f, 
    0.05130979f, 0.05380751f, -0.06088192f, -0.06209314f, 0.03586162f, 0.04268352f, -0.07962292f, 0.01720841f, 
    0.02578537f, -0.02175545f, -0.02426788f, 0.00662528f, -0.00884838f, 0.03755892f, 0.04241743f, -0.07468457f, 
    0.00637543f, -0.05065572f, -0.01181934f, 0.00479067f, -0.05016460f, 0.02518468f, 0.02503952f, 0.04926083f, 
    -0.03381212f, -0.01121985f, -0.01724515f, 0.00223222f, 0.03887292f, -0.01500830f, 0.06424255f, 0.07335909f, 
    -0.02728726f, 0.01263508f, 0.04506876f, -0.02337585f, 0.02165364f, -0.02026676f, -0.07450141f, 0.05380272f, 
    0.04619738f, -0.01367266f, 0.02399057f, -0.03005673f, 0.04676918f, 0.03406998f, 0.00296346f, 0.03588706f, 
    0.01716562f, -0.04382778f, -0.06668703f, 0.00896503f, -0.06366030f, 0.07726097f, 0.04885550f, -0.05120957f, 
    0.03585668f, 0.05544714f, 0.00735726f, -0.06077656f, -0.05896305f, -0.00848377f, 0.03291607f, 0.01010014f, 
    -0.06066238f, -0.07132586f, 0.01557594f, 0.04019453f, -0.02903383f, -0.04233893f, -0.02828638f, 0.02819335f, 
    0.01063293f, 0.00618717f, 0.04091074f, 0.01988568f, -0.00671128f, 0.04549390f, -0.05153878f, -0.01429101f, 
    0.04091467f, -0.03090936f, -0.04429107f, 0.00282842f, -0.03558027f, 0.00506132f, -0.06570148f, -0.05611298f, 
    -0.05106952f, -0.04457494f, 0.05678880f, 0.06735750f, 0.01548142f, 0.02874368f, -0.01163737f, 0.03425273f, 
    0.05478686f, -0.01476937f, 0.04753578f, -0.05724428f, 0.03154515f, -0.06999452f, 0.02278266f, 0.00113466f, 
    -0.00249160f, 0.02743661f, -0.02230231f, -0.02846417f, 0.00407309f, -0.05383220f, 0.04585120f, -0.01303758f, 
    -0.00729612f, -0.02857538f, 0.02383980f, -0.04152330f, -0.07854061f, -0.03752487f, -0.05901850f, -0.02932127f, 
    -0.01366164f, 0.05687026f, -0.02860605f, -0.00838491f, -0.03114565f, -0.04521925f, -0.05213490f, 0.02306814f, 
    -0.00542026f, -0.06395623f, 0.05428839f, -0.08790194f, -0.01669321f, -0.05484102f, -0.05554691f, -0.08423884f, 
    -0.00390588f, 0.03201975f, -0.06650238f, -0.03981319f, -0.04312749f, 0.01031032f, 0.00171398f, 0.00893644f, 
    -0.05496770f, 0.02432687f, -0.00234067f, -0.01273095f, -0.06583837f, -0.05312278f, 0.01754687f, -0.02066606f, 
    0.00355467f, 0.06118955f, 0.03426980f, -0.05076968f, 0.00495996f, -0.06149700f, -0.04364076f, -0.06482083f, 
    0.14024021f, 0.15260246f, -0.06423788f, 0.23618291f, 0.04243321f, 0.16038850f, 0.03113725f, 0.10135002f, 
    0.06056786f, 0.00763534f, 0.06049583f, -0.06456998f, -0.09267320f, 0.12558839f, 0.03319798f, -0.01044091f, 
    0.04549258f, 0.05226749f, -0.01372585f, -0.07034662f, -0.11072580f, -0.00402493f, 0.11049572f, 0.05994825f, 
    0.22968867f, 0.09782471f, -0.01017460f, 0.14756231f, 0.10627317f, 0.03287011f, -0.05000839f, 0.08452795f, 
    -0.10001440f, 0.07872173f, 0.08778173f, -0.01006722f, 0.26807138f, 0.04355994f, 0.17458199f, -0.02847712f, 
    0.04827781f, 0.09230377f, 0.06923580f, -0.09519713f, 0.03565764f, 0.06297258f, 0.01467270f, -0.13377409f, 
    -0.21846418f, -0.19851911f, 0.03741890f, -0.10699424f, 0.20274979f, -0.04094810f, 0.01292246f, 0.09733927f, 
    0.01735012f, -0.00482939f, -0.01200222f, 0.25465617f, -0.07693826f, 0.04376905f, -0.14945863f, -0.26930395f, 
    0.10517517f, 0.00538525f, 0.11750712f, -0.09935407f, 0.01529307f, 0.04566374f, -0.01566576f, 0.15098278f, 
    0.07167941f, -0.00238661f, 0.11282692f, 0.16452065f, -0.01214300f, -0.03037031f, 0.04599788f, 0.08471680f, 
    -0.01683219f, 0.05055253f, 0.04708793f, -0.14886568f, -0.28876290f, -0.23021270f, 0.09246254f, -0.04374394f, 
    0.00887569f, 0.10153477f, 0.10358571f, 0.03998441f, 0.08252229f, -0.06336685f, -0.05184342f, 0.06823643f, 
    0.08824951f, 0.13851884f, 0.16792364f, 0.03898671f, 0.00308571f, 0.06951860f, 0.06358167f, 0.12505069f, 
    -0.04287905f, -0.04191360f, -0.04628395f, -0.08248039f, 0.09936339f, 0.08581508f, -0.12546067f, -0.01785135f, 
    -0.06906492f, 0.06089761f, -0.05722664f, -0.04605664f, -0.02750151f, 0.00008495f, 0.12197391f, -0.04594034f, 
    0.11655606f, -0.09825484f, 0.00686995f, 0.07433022f, -0.02850006f, -0.04028761f, -0.00002819f, 0.03154809f, 
    -0.02722092f, 0.37169430f, 0.14640491f, 0.02562255f, 0.13768290f, 0.07206780f, 0.10745875f, -0.16513251f, 
    0.15247236f, -0.07245792f, -0.09854937f, 0.02148237f, -0.06403136f, 0.07744119f, 0.31855643f, -0.02155735f, 
    -0.16217956f, 0.09462069f, -0.00656917f, -0.19520923f, 0.14084920f, -0.04338445f, 0.13485862f, 0.03319141f, 
    0.14585447f, 0.03833935f, 0.08985227f, -0.01185225f, -0.33029148f, 0.12882712f, -0.10130006f, -0.31963259f, 
    0.15779050f, 0.10945020f, 0.06229608f, -0.04649936f, 0.02698522f, -0.10781321f, -0.15550983f, -0.01444095f, 
    0.19153748f, -0.03553690f, -0.03506046f, 0.11105981f, 0.06103512f, -0.05788785f, -0.04993670f, 0.12025274f, 
    -0.07213931f, -0.05739141f, 0.01649115f, -0.13135652f, -0.05002791f, -0.09442259f, -0.02036877f, -0.09859051f, 
    0.02001342f, -0.00600978f, 0.05787619f, 0.04330406f, -0.00988898f, 0.05528495f, -0.02370326f, 0.05554913f, 
    0.48980287f, -0.13624378f, 0.07034802f, 0.20924264f, 0.03062071f, 0.03603104f, 0.03994162f, 0.05516593f, 
    0.19421886f, 0.03945388f, -0.10419159f, 0.05471095f, 0.15617153f, 0.25858325f, -0.01076035f, 0.07781943f, 
    -0.04695740f, 0.00479859f, 0.09224017f, 0.02477243f, -0.06883203f, -0.06570876f, 0.03747378f, 0.03234361f, 
    0.06809267f, 0.07796682f, -0.03093057f, 0.03804485f, 0.03228327f, 0.05728810f, 0.13388230f, 0.21008886f, 
    0.02377273f, 0.01458391f, 0.04583704f, -0.02156722f, -0.19156709f, 0.09884626f, -0.05316180f, 0.27919978f, 
    0.00142104f, 0.08423007f, 0.00137328f, -0.04903346f, -0.00847453f, 0.03488526f, -0.01592596f, 0.06404930f, 
    -0.34986907f, 0.08852637f, -0.09763137f, 0.01636469f, 0.02147563f, -0.03050271f, -0.05037151f, 0.03435991f, 
    0.06834687f, 0.06030999f, -0.02412010f, 0.13973007f, 0.00408484f, -0.11946516f, -0.03669770f, 0.04649316f, 
    -0.04362961f, 0.00316955f, 0.07931556f, -0.04450234f, 0.02288065f, 0.05398163f, 0.06674171f, 0.09002333f, 
    -0.31058317f, -0.02405260f, 0.08400451f, 0.13976389f, 0.02372232f, -0.14140104f, -0.07247689f, 0.05140461f, 
    0.13832067f, -0.00226048f, -0.03357900f, 0.05957627f, -0.19531816f, -0.20617881f, -0.05802624f, -0.03800437f, 
    -0.04176658f, -0.02887820f, 0.06384768f, 0.12630393f, 0.02646886f, -0.04314008f, 0.06805193f, -0.03372931f, 
    0.18367176f, 0.03816014f, -0.04365418f, 0.25278768f, 0.11440476f, -0.02745340f, -0.03286244f, 0.09170243f, 
    0.10663949f, -0.05266910f, 0.05191918f, -0.01291776f, 0.19193219f, 0.14407991f, -0.18369901f, -0.15923460f, 
    -0.05318092f, 0.01969948f, 0.03095287f, -0.02180071f, -0.03108513f, 0.12942986f, -0.16647168f, -0.00655564f, 
    -0.15142527f, -0.01612583f, 0.20515291f, -0.04830987f, -0.00256378f, -0.04138811f, -0.06810140f, 0.04307583f, 
    0.08930476f, 0.00073891f, 0.01852230f, 0.12863785f, -0.07323255f, 0.18173532f, 0.04071621f, 0.17533681f, 
    0.12737112f, -0.04281240f, -0.04739857f, 0.21147595f, 0.00919021f, -0.10078780f, -0.01755742f, 0.02079709f, 
    -0.15759403f, -0.01084692f, -0.07450821f, -0.06287727f, -0.10629283f, -0.02988192f, 0.11683448f, 0.03443208f, 
    0.17303503f, 0.11206914f, 0.04876246f, -0.04278762f, 0.02609069f, -0.07345477f, -0.18672919f, 0.08515506f, 
    -0.12221029f, 0.07680437f, -0.01329125f, 0.02515917f, 0.09627566f, -0.09582203f, -0.12378312f, -0.02052581f, 
    -0.29088786f, 0.23506759f, 0.12361772f, 0.08700238f, 0.04459635f, 0.03341896f, -0.02170333f, 0.08398588f, 
    0.02554111f, -0.09334476f, -0.03923956f, -0.10940411f, -0.00089813f, -0.04003587f, -0.13705203f, -0.28466630f, 
    0.13476188f, -0.11914860f, 0.04368610f, 0.05489749f, 0.10674641f, 0.06146333f, 0.02599368f, 0.05945102f, 
    0.10719360f, 0.00643631f, -0.01317343f, 0.32102370f, -0.17144525f, 0.08009925f, -0.08702767f, 0.08702407f, 
    0.06507415f, 0.03399010f, 0.02001145f, 0.07935964f, -0.13585927f, 0.32188120f, 0.06891837f, 0.03878190f, 
    0.00816595f, 0.14019495f, 0.02701684f, -0.04831459f, -0.02074224f, 0.01932082f, 0.04730905f, -0.00248694f, 
    -0.23904032f, 0.21573460f, -0.00024954f, -0.05053176f, 0.16205168f, -0.07309515f, -0.02522035f, 0.00930754f, 
    -0.00052761f, 0.03339639f, 0.08457596f, -0.05730024f, -0.34308302f, 0.10354609f, 0.09572291f, -0.04648343f, 
    0.00509543f, 0.03907825f, 0.16308393f, -0.01507222f, 0.09245430f, -0.00091665f, -0.03768672f, -0.02848252f, 
    -0.42877010f, -0.02722748f, 0.05140094f, -0.13163136f, -0.00126862f, -0.04355446f, 0.09271732f, 0.00104386f, 
    -0.04258151f, -0.19347823f, -0.10542759f, -0.04153508f, 0.11154133f, -0.01200582f, -0.00302275f, -0.07334710f, 
    0.06547487f, -0.03041935f, 0.03604187f, -0.13090630f, 0.03485348f, 0.08212820f, -0.02657775f, 0.09680942f, 
    -0.06426196f, -0.00974120f, -0.03554203f, 0.07247288f, 0.08058117f, -0.08235597f, 0.08823405f, 0.01094188f, 
    0.11510151f, -0.02976790f, -0.04815545f, -0.06585415f, -0.19568601f, 0.06868681f, 0.06013355f, -0.01892243f, 
    0.02793628f, -0.11725154f, 0.02782708f, 0.04391655f, 0.03595632f, -0.01724874f, 0.01866283f, 0.00463164f, 
    0.18637416f, 0.06710213f, 0.06815402f, 0.05883021f, -0.07485890f, -0.02227083f, 0.04806210f, 0.13499433f, 
    0.09073231f, -0.01236056f, -0.04223890f, -0.02178718f, 0.20751370f, 0.01851092f, -0.16115896f, 0.07220908f, 
    -0.11374205f, 0.02950538f, 0.08884828f, 0.04488132f, -0.07773405f, 0.03608472f, 0.01059116f, 0.01605257f, 
    0.15149634f, -0.04283423f, 0.06401464f, 0.08754545f, 0.03235413f, -0.05377173f, 0.01624735f, 0.04852535f, 
    -0.03414825f, 0.21129403f, 0.13547213f, 0.17932735f, 0.10720558f, 0.17307450f, 0.18153341f, -0.14979263f, 
    0.13422111f, -0.03247425f, 0.02899634f, 0.19801684f, 0.00629598f, 0.12353060f, 0.12003769f, 0.06807863f, 
    -0.02271619f, 0.05209697f, -0.00537572f, -0.15475844f, 0.08420314f, -0.08611341f, 0.07580219f, -0.05805063f, 
    0.07088496f, -0.14053850f, 0.02257167f, 0.01807964f, 0.10746245f, 0.02576817f, 0.07800467f, -0.24567440f, 
    0.10694492f, 0.09359813f, 0.04782578f, -0.09556095f, -0.02308492f, -0.00170525f, -0.07786395f, 0.02229934f, 
    -0.03420817f, -0.13914149f, 0.30310908f, 0.25567329f, -0.00517508f, -0.10607395f, -0.01956472f, 0.05911058f, 
    -0.06100269f, 0.05265065f, -0.08156677f, -0.01881538f, -0.35688975f, -0.04743363f, -0.26638648f, -0.11502393f, 
    0.03738829f, 0.02822511f, 0.05860616f, -0.10905326f, 0.06180514f, 0.10873960f, 0.05001703f, 0.11995938f, 
    0.01936850f, 0.04495503f, -0.04194177f, -0.05311096f, -0.01468845f, -0.01972725f, 0.05916059f, -0.06216539f, 
    0.00551016f, 0.01287157f, 0.02607423f, 0.02623582f, -0.01882275f, -0.04513445f, -0.04684324f, -0.00541262f, 
    0.04967424f, 0.00567365f, -0.07755592f, 0.01687552f, -0.06219079f, 0.00073046f, 0.02368139f, 0.05060861f, 
    -0.00038926f, -0.04196288f, -0.04657104f, 0.03563713f, -0.05625100f, -0.03538290f, 0.02227824f, 0.01786159f, 
    -0.07375394f, 0.00972714f, -0.06013059f, 0.05874943f, -0.00359904f, -0.05130422f, 0.02354419f, -0.05045847f, 
    0.05979408f, 0.02565745f, -0.04275727f, -0.03925478f, 0.03371317f, -0.01902071f, -0.02285582f, 0.04870832f, 
    -0.04155233f, -0.06593647f, 0.01393716f, -0.08096237f, 0.06124398f, -0.00391226f, 0.00585791f, 0.00789660f, 
    0.04254288f, -0.01104545f, -0.04409831f, 0.00547461f, -0.01020550f, 0.04490510f, 0.05379867f, -0.05292853f, 
    -0.03249503f, -0.00105268f, -0.07028390f, -0.00982400f, -0.08442026f, 0.05945510f, -0.03389818f, -0.06336148f, 
    -0.04247889f, -0.05017420f, -0.02307985f, 0.04748280f, -0.06094887f, 0.04767961f, 0.02836948f, 0.04298947f, 
    -0.00792371f, 0.04406074f, 0.06614436f, -0.01086901f, -0.05769187f, -0.04513472f, 0.00321171f, 0.04604951f, 
    0.02986075f, -0.00344577f, -0.07410902f, -0.01578981f, 0.03475779f, -0.05819780f, -0.04659942f, 0.00415157f, 
    -0.02881094f, -0.03968019f, -0.01330546f, -0.06923459f, 0.04354048f, 0.04964875f, -0.06145648f, -0.07432479f, 
    -0.06778039f, -0.02971342f, 0.05213581f, -0.06664935f, -0.02036398f, -0.01645578f, -0.04696508f, -0.00447271f, 
    -0.02848595f, -0.06085713f, 0.02315120f, 0.06246555f, 0.00605371f, 0.00580083f, -0.02865241f, 0.02222815f, 
    0.02794871f, -0.05083434f, -0.05076798f, -0.05598482f, -0.06679162f, -0.08214257f, 0.04231087f, 0.03851124f, 
    0.05513147f, -0.02185336f, 0.01638876f, -0.04363535f, -0.02445975f, -0.06559123f, 0.02980480f, 0.00601259f, 
    0.02988160f, -0.03688418f, 0.05219531f, -0.00177524f, -0.01260222f, -0.07200238f, 0.01547969f, -0.01038179f, 
    -0.00793628f, 0.03770515f, 0.05491026f, -0.00302402f, -0.06170866f, 0.01549719f, -0.02989337f, 0.05242623f, 
    -0.04096464f, 0.05141052f, -0.04237982f, -0.01687349f, -0.04410345f, -0.00960961f, -0.05573029f, -0.05211734f, 
    -0.01111967f, -0.00614450f, -0.04788686f, 0.04133990f, 0.04622310f, -0.05365007f, -0.05835130f, -0.02873572f, 
    -0.06939912f, 0.05740936f, -0.00822752f, 0.05771708f, 0.01584601f, -0.07792877f, -0.05787558f, 0.06375731f, 
    -0.01245631f, -0.08173403f, -0.01559756f, -0.01390458f, 0.05149866f, -0.02088690f, 0.04295620f, 0.04183845f, 
    -0.00762432f, 0.04563368f, -0.04917004f, 0.00801529f, 0.05169879f, 0.00156042f, 0.02350481f, -0.02201239f, 
    0.01937020f, 0.00061192f, -0.05877286f, 0.03979960f, 0.04795091f, -0.02465592f, 0.02031995f, -0.07407572f, 
    0.01224989f, 0.06629694f, -0.00539373f, 0.05709625f, -0.00162642f, -0.03448230f, -0.04991347f, -0.01357900f, 
    -0.05338934f, -0.03147035f, 0.04845413f, -0.04753549f, -0.05793931f, 0.04423817f, -0.06277975f, -0.04402538f, 
    -0.00244236f, 0.06759740f, -0.06018630f, -0.06985998f, -0.03884020f, 0.04305416f, -0.02725114f, -0.04656011f, 
    -0.02657967f, 0.05327134f, -0.04954961f, -0.00849485f, 0.01830124f, -0.03924850f, 0.01100695f, -0.07726816f, 
    -0.04558961f, -0.03830093f, -0.02292364f, -0.00078362f, 0.00971747f, -0.05284076f, -0.05851252f, 0.04580175f, 
    -0.01926671f, -0.03426811f, -0.00427326f, -0.00927480f, 0.05420075f, -0.06798078f, 0.03831417f, 0.03511768f, 
    0.01660856f, -0.03477932f, -0.01535301f, -0.06314904f, -0.06193442f, 0.04927883f, -0.06926837f, -0.06341318f, 
    0.03570508f, -0.03485355f, 0.01110123f, 0.01644579f, 0.06549301f, 0.01156281f, -0.01397873f, -0.07057438f, 
    0.03456953f, -0.06759410f, -0.02242840f, -0.01643828f, 0.01015435f, -0.00693605f, -0.01704501f, -0.07681745f, 
    0.02179461f, 0.03775370f, -0.04688216f, 0.00714721f, -0.06409861f, -0.01059591f, 0.04965324f, -0.01641171f, 
    -0.02986545f, -0.00207119f, 0.03587735f, -0.06216935f, 0.02437716f, 0.00695979f, 0.06631300f, 0.00311526f, 
    -0.05866805f, 0.02903788f, -0.01564758f, 0.02238987f, -0.07344177f, 0.06200362f, 0.04429090f, -0.00852044f, 
    -0.01127563f, -0.03858741f, 0.04578377f, -0.06615788f, -0.04848041f, 0.05204493f, 0.06224925f, -0.04388266f, 
    -0.05211607f, 0.01261594f, -0.05380791f, 0.02282527f, 0.01603191f, 0.04162904f, -0.01943921f, 0.05933283f, 
    -0.05347764f, -0.03101408f, -0.05363164f, 0.01217548f, -0.05252011f, -0.06716310f, 0.02626066f, -0.01691350f, 
    -0.01314274f, -0.06919926f, -0.01731856f, -0.01537955f, -0.03592465f, 0.00670297f, -0.07719882f, 0.03718310f, 
    -0.06053448f, -0.03316138f, 0.04524446f, 0.01395070f, -0.04310170f, -0.02469500f, -0.00505556f, 0.04293196f, 
    0.00711860f, -0.05795106f, -0.00328865f, -0.06523309f, 0.04195561f, 0.03633458f, -0.01037048f, 0.01740365f, 
    -0.04352072f, 0.03411263f, 0.00338791f, 0.03275650f, 0.02138102f, -0.06505024f, -0.02124736f, 0.04061773f, 
    -0.07328036f, 0.04024342f, 0.01395246f, 0.01548203f, -0.03377268f, -0.05125843f, 0.00077212f, -0.05073685f, 
    0.03158480f, 0.02298898f, -0.07405430f, -0.00651838f, 0.02766088f, 0.05156969f, -0.03272385f, -0.05465735f, 
    -0.03510269f, -0.06855466f, 0.04512265f, -0.06853906f, -0.07369694f, 0.01065794f, 0.01943689f, 0.05538235f, 
    -0.03310828f, 0.03981890f, 0.05051137f, 0.01237511f, 0.03650705f, -0.05966077f, 0.03378798f, 0.04457290f, 
    0.37582853f, 0.03525031f, 0.20272453f, -0.10082404f, 0.15072075f, -0.05426147f, 0.02374019f, -0.01752958f, 
    0.06311503f, -0.04029674f, 0.00058084f, -0.00150094f, 0.05958427f, -0.12149940f, -0.26142398f, -0.10717917f, 
    -0.06658765f, 0.01986082f, -0.08541581f, 0.11139617f, 0.00011466f, -0.02114955f, -0.01551732f, -0.04796330f, 
    0.29318982f, 0.01737799f, -0.10738838f, -0.06800876f, 0.04889458f, 0.03839658f, 0.03467948f, 0.06468686f, 
    0.09390002f, -0.02899976f, 0.00792859f, 0.09678654f, 0.11510248f, 0.09646616f, -0.11485894f, 0.02108997f, 
    0.06425464f, 0.04324586f, -0.01448072f, 0.05974512f, -0.03202151f, 0.02182665f, 0.10392578f, 0.09351756f, 
    -0.16235439f, 0.11995938f, 0.06563248f, 0.03130230f, 0.05398634f, 0.08997471f, -0.06975797f, 0.00321792f, 
    0.10377795f, 0.03547474f, 0.04688716f, 0.08275467f, 0.18501894f, 0.16674875f, 0.19196868f, -0.01227833f, 
    -0.07674282f, 0.04103306f, -0.04076878f, 0.15344906f, -0.11241790f, 0.02154857f, 0.09816606f, 0.13740455f, 
    -0.09486837f, 0.24826287f, 0.04475465f, 0.10212629f, -0.10795188f, -0.06081593f, 0.03928538f, 0.01740690f, 
    -0.00892504f, 0.03323662f, 0.02671498f, 0.05493726f, 0.06032146f, -0.16629156f, 0.05909583f, -0.10805559f, 
    -0.13303243f, 0.10198267f, -0.00843745f, 0.04281869f, -0.07496627f, -0.01736685f, -0.04082611f, -0.02051346f, 
    -0.05138467f, 0.12407659f, -0.09707037f, 0.02448384f, 0.08784852f, 0.00573455f, 0.06713790f, -0.01680415f, 
    0.07406301f, -0.00720943f, 0.01441939f, 0.01544905f, -0.18252173f, -0.03675770f, -0.09193970f, -0.07978977f, 
    -0.08351449f, -0.04016314f, -0.03306823f, 0.02760548f, -0.03437410f, 0.03922917f, -0.05414536f, -0.01977090f, 
    -0.30851489f, 0.08053476f, 0.02877217f, 0.16134194f, -0.03872549f, -0.06489661f, 0.12099957f, 0.07941891f, 
    -0.07917036f, -0.05511231f, 0.00125609f, 0.01206342f, 0.03975646f, 0.06161887f, -0.12590243f, 0.10903170f, 
    -0.06267088f, 0.01947234f, 0.04951125f, -0.03211818f, 0.02811144f, -0.07411364f, 0.02982881f, -0.03457046f, 
    0.11296850f, -0.08520849f, 0.06595918f, 0.07163606f, -0.09229273f, -0.00030317f, -0.06341390f, 0.12634827f, 
    0.05800696f, 0.04936790f, -0.06388255f, 0.09092044f, 0.07866004f, -0.01857910f, -0.03027638f, 0.03625454f, 
    -0.09063601f, 0.03228378f, -0.09196730f, 0.12559032f, -0.04168395f, 0.02914307f, -0.00212415f, -0.00193976f, 
    -0.04788586f, 0.27015314f, -0.24838859f, -0.04328147f, 0.06694763f, 0.10148059f, 0.12520091f, 0.01303547f, 
    -0.01545464f, 0.05581888f, 0.06056371f, 0.14828208f, 0.23020998f, -0.07683275f, 0.02449979f, -0.22039254f, 
    0.03002874f, 0.03467579f, -0.03144213f, 0.01325971f, 0.10395489f, -0.11226112f, -0.03653449f, 0.10827728f, 
    0.00387935f, -0.26414764f, 0.24845989f, 0.03281634f, -0.03220634f, -0.06478332f, 0.05787159f, 0.02332628f, 
    -0.01400715f, -0.09578525f, -0.09735850f, -0.02658957f, -0.24143037f, -0.14666186f, -0.19391738f, 0.04839955f, 
    0.16428299f, -0.04675986f, -0.06301658f, 0.14226528f, 0.02072944f, 0.09174385f, 0.03530888f, -0.00222285f, 
    -0.09767541f, -0.10614413f, -0.14784962f, 0.07234579f, 0.02387974f, -0.01405638f, -0.03124231f, 0.00634998f, 
    -0.07289344f, -0.02427513f, -0.08488762f, 0.08993320f, -0.16615728f, -0.11443090f, -0.24179205f, 0.15241800f, 
    0.05025791f, 0.02175922f, -0.09761781f, 0.11353213f, 0.03000755f, 0.10850509f, 0.06397279f, -0.08814500f, 
    0.26041204f, -0.00064062f, 0.10358133f, -0.05165846f, -0.05575652f, 0.09796986f, 0.01357732f, -0.00976261f, 
    -0.00914482f, 0.02242227f, 0.18376261f, 0.05086722f, 0.19892776f, 0.16581054f, 0.12999754f, 0.03751634f, 
    -0.17684489f, 0.10507537f, 0.02884592f, 0.03896842f, -0.12017718f, 0.06802355f, 0.00824201f, 0.03206617f, 
    -0.04234346f, -0.05439976f, 0.26096514f, 0.00868499f, -0.12687297f, -0.08567984f, 0.01991111f, -0.02727283f, 
    0.00110134f, -0.03439018f, 0.01678524f, -0.16768464f, 0.28734916f, 0.33002639f, 0.00714568f, -0.01352159f, 
    -0.05826458f, 0.02782795f, 0.08263509f, 0.12406080f, 0.01418844f, 0.07027403f, 0.00180083f, 0.04784275f, 
    -0.25649372f, 0.10071387f, 0.11766922f, 0.02030894f, -0.04167476f, 0.01195499f, 0.03119160f, -0.03869464f, 
    -0.09563355f, -0.05010742f, -0.07411287f, 0.03418784f, -0.19501486f, -0.06537536f, -0.04315400f, 0.03997703f, 
    0.15704514f, -0.13599361f, 0.01053263f, 0.06847614f, -0.07160776f, -0.01730897f, -0.06724437f, 0.12747450f, 
    0.11836302f, 0.11298186f, 0.05337849f, -0.02901557f, -0.12431019f, -0.00595397f, 0.04920301f, 0.03192697f, 
    0.03758314f, -0.01568483f, 0.03006940f, 0.06355623f, -0.10380694f, 0.14627729f, 0.04188464f, 0.13312384f, 
    -0.17546508f, 0.06090820f, 0.08230427f, -0.01073196f, 0.12505947f, 0.02889629f, -0.06298643f, -0.00874462f, 
    -0.01117099f, 0.14757770f, 0.08002182f, 0.09032843f, -0.11909726f, 0.11371150f, -0.03859051f, 0.04640585f, 
    -0.02064123f, -0.01570305f, 0.07715669f, -0.06629227f, 0.21304002f, 0.13267377f, 0.07723564f, 0.13319471f, 
    -0.20901024f, 0.01617681f, 0.05424703f, -0.01337393f, -0.05517710f, -0.05766176f, -0.03554317f, -0.05194040f, 
    -0.15084881f, -0.07070520f, -0.00628708f, 0.06111573f, -0.09754752f, 0.02392568f, -0.01631818f, 0.06435998f, 
    -0.03011668f, -0.07511559f, 0.19333330f, 0.02756803f, 0.00177307f, -0.06201816f, -0.06160052f, -0.06007234f, 
    0.12561181f, -0.00858340f, 0.02506925f, 0.15795948f, -0.01977202f, -0.00961242f, 0.07988479f, 0.10952119f, 
    0.19779137f, -0.28604928f, 0.09281270f, 0.10581248f, -0.07441118f, 0.07409798f, 0.07318100f, -0.05111088f, 
    0.11850297f, 0.06832403f, 0.14605333f, 0.01334886f, 0.30115205f, 0.40517709f, 0.08923955f, 0.05418901f, 
    0.16713226f, 0.10167952f, 0.07114644f, 0.01852999f, -0.13274920f, 0.03634646f, -0.07602135f, -0.02099307f, 
    -0.32204831f, 0.28094369f, -0.05422131f, 0.10015927f, 0.04885354f, 0.15120959f, 0.19588801f, 0.21148778f, 
    -0.00423800f, 0.03003996f, 0.20702146f, 0.04349015f, -0.23632799f, -0.04425537f, 0.05610395f, 0.29721242f, 
    0.07227096f, -0.00023150f, -0.01434349f, -0.00437615f, -0.01250547f, 0.06323569f, -0.10776515f, 0.01755750f, 
    -0.26218718f, -0.08734652f, -0.21612498f, -0.08375854f, -0.07019188f, -0.02607322f, -0.07582515f, 0.00142068f, 
    -0.04156091f, -0.15980087f, 0.02556345f, 0.08600795f, 0.09266587f, -0.29864544f, -0.12932193f, 0.04439352f, 
    -0.04279418f, -0.03801930f, -0.01444211f, -0.30406132f, -0.15525752f, -0.00462687f, 0.11080898f, -0.02141922f, 
    -0.15468533f, -0.02924276f, 0.01385115f, -0.18732932f, -0.11928766f, -0.07430263f, -0.02807741f, -0.17214429f, 
    -0.02526266f, -0.03413859f, -0.12859693f, 0.02671720f, -0.02011479f, 0.04235129f, -0.35933122f, -0.11008485f, 
    0.04205256f, -0.25134236f, 0.03500585f, -0.01410911f, 0.03424930f, -0.03002376f, 0.04284994f, 0.04309074f, 
    0.13414738f, -0.09802479f, 0.10081270f, -0.00443842f, -0.00215571f, 0.09546582f, -0.16048327f, 0.06420341f, 
    0.05313822f, -0.17187940f, 0.03106065f, 0.05126890f, 0.48956504f, -0.00669267f, -0.11723091f, 0.04778925f, 
    0.14359652f, 0.02389798f, -0.02717888f, 0.05776696f, -0.01207328f, 0.00453762f, -0.18743846f, 0.06328738f, 
    0.20308952f, 0.07390787f, 0.07011083f, 0.04595445f, -0.00211985f, 0.03378170f, -0.00215906f, -0.07706447f, 
    0.05631099f, 0.11953213f, 0.03433222f, 0.20104623f, 0.09891567f, 0.13148218f, 0.04688065f, 0.07405457f, 
    0.03870952f, 0.02356166f, -0.10943180f, 0.25565398f, -0.09952793f, 0.07442372f, 0.09739086f, 0.07876047f, 
    0.07028497f, -0.05753896f, -0.11250877f, -0.08057211f, -0.06791341f, 0.04166617f, -0.15591778f, -0.01749066f, 
    -0.04516007f, 0.10102636f, -0.10153218f, -0.18065880f, 0.36485597f, -0.04460699f, -0.10959797f, 0.13385637f, 
    -0.04199384f, -0.03903589f, -0.05888869f, -0.14861441f, -0.07872726f, -0.05399352f, 0.00270351f, 0.02711772f, 
    -0.16674246f, 0.06281444f, 0.30919006f, 0.17896262f, 0.09876625f, 0.02306282f, -0.00819704f, -0.18851691f, 
    0.03551685f, -0.04830198f, -0.05671335f, 0.00790164f, 0.10285101f, 0.15629904f, -0.30718803f, -0.16894633f, 
    0.10987297f, 0.06028841f, 0.25125256f, -0.01173763f, 0.01726037f, 0.00914905f, 0.00941120f, 0.06192174f, 
    0.12797865f, -0.16150512f, 0.08692590f, 0.08406944f, 0.00843043f, -0.03984618f, 0.01839737f, -0.07683202f, 
    -0.05483483f, -0.16054672f, -0.06209589f, 0.06320503f, -0.05616933f, -0.15304728f, -0.15591156f, 0.08591200f, 
    0.08689923f, 0.00496649f, -0.03288050f, -0.10074192f, 0.24115409f, 0.01029635f, 0.10886582f, 0.02973564f, 
    -0.24247997f, 0.36856946f, -0.05464501f, 0.13893411f, 0.02241232f, 0.03970942f, 0.04886577f, -0.01651782f, 
    -0.00061506f, -0.02543563f, -0.04126227f, -0.13297509f, -0.46200705f, 0.06928404f, -0.14652169f, 0.05166148f, 
    0.19512303f, -0.00448978f, 0.03466289f, -0.02704606f, 0.01570252f, 0.00641718f, 0.10892966f, 0.00395332f, 
    0.02846384f, 0.03246447f, -0.06492151f, -0.01952220f, 0.03989637f, 0.06819655f, 0.01755419f, 0.01269910f, 
    -0.03472649f, 0.03960218f, 0.03585690f, -0.12216415f, 0.02146157f, -0.00035057f, -0.04559052f, 0.21956360f, 
    0.05619159f, -0.07766623f, -0.06063938f, 0.13137576f, 0.07848234f, -0.07503431f, 0.03466914f, 0.05284795f, 
    0.12429374f, -0.03371719f, 0.10791449f, -0.05705107f, 0.02596299f, -0.02847825f, 0.00293227f, 0.08312731f, 
    0.01139032f, 0.04862500f, 0.08961993f, 0.20297088f, 0.07035697f, 0.12898535f, -0.00279282f, 0.06833460f, 
    0.08727865f, 0.06091399f, -0.01662622f, 0.03786711f, 0.12818502f, -0.00412350f, 0.10212355f, 0.00021332f, 
    0.09165846f, -0.02215159f, -0.03136350f, -0.04977271f, 0.06716319f, -0.02604210f, 0.05224915f, -0.02483913f, 
    0.08444465f, 0.11418034f, 0.06595524f, 0.19259986f, -0.14524268f, -0.17475013f, 0.05649840f, 0.00024582f, 
    0.09358048f, -0.06344973f, 0.07213498f, -0.04513135f, 0.06943028f, -0.01760454f, -0.06048189f, 0.05516219f, 
    0.00415903f, 0.03795283f, 0.08919373f, 0.12118969f, 0.01892666f, 0.14167401f, -0.01865193f, -0.00841021f, 
    0.11018538f, -0.25831357f, 0.04154433f, 0.05282391f, -0.19593503f, 0.19263864f, 0.06185813f, 0.16644795f, 
    -0.03388558f, 0.03195724f, 0.09106271f, 0.12086327f, 0.12819877f, 0.01438179f, -0.33883715f, 0.16129895f, 
    -0.20013510f, -0.04561992f, 0.12011871f, 0.09581109f, 0.14660160f, -0.03784496f, 0.00904615f, -0.06218034f, 
    0.00964583f, 0.08925550f, -0.05415624f, 0.02344575f, -0.05754243f, -0.30505180f, 0.01157698f, 0.09127519f, 
    -0.10170023f, -0.08805267f, 0.06561690f, 0.02687231f, -0.06137960f, 0.05170932f, 0.03749827f, 0.00591972f, 
    -0.08903436f, 0.26775286f, -0.09035175f, 0.01547813f, -0.04329092f, -0.00606641f, 0.07678461f, 0.06204220f, 
    0.00238183f, 0.03564485f, 0.07222609f, 0.04311967f, 0.11994311f, 0.00365964f, -0.06510258f, -0.03849502f, 
    0.12075345f, 0.00482649f, -0.12804055f, -0.03424269f, 0.04878113f, -0.13406700f, -0.00890857f, 0.02563977f, 
    -0.28681993f, -0.25587094f, -0.16236708f, -0.13880512f, 0.26995990f, -0.01649920f, 0.09462282f, -0.01636409f, 
    0.06285728f, -0.04253972f, -0.04325187f, 0.06814781f, -0.03705298f, -0.19108871f, -0.03713793f, 0.00506113f, 
    -0.09446648f, -0.19277889f, -0.02379501f, -0.04308195f, 0.09091187f, -0.02975829f, 0.25885221f, -0.02730119f, 
    0.17860296f, -0.08467016f, 0.08009505f, 0.01116341f, -0.10074534f, -0.03415221f, -0.08242753f, -0.06600339f, 
    0.00434497f, -0.02244547f, -0.12593353f, -0.09062045f, 0.00528211f, -0.03582393f, -0.03990135f, 0.00683692f, 
    -0.08816112f, -0.11322881f, -0.18162394f, -0.02990484f, 0.06683456f, 0.15026744f, 0.12142846f, 0.06868595f, 
    0.50855243f, 0.16527221f, -0.12093075f, 0.10634205f, -0.01090847f, 0.10690316f, -0.07776967f, -0.01873161f, 
    0.06697829f, 0.08742836f, -0.04315316f, 0.02380496f, -0.09515126f, 0.06178221f, 0.05919941f, 0.39815131f, 
    0.10504454f, 0.11359138f, 0.08154524f, 0.12064856f, 0.00706286f, -0.06686469f, -0.03081803f, -0.01672575f, 
    -0.08769222f, -0.11942447f, -0.07726941f, -0.13174392f, 0.28598776f, 0.10420594f, 0.12246201f, 0.09448538f, 
    0.02577528f, 0.08450007f, 0.07687887f, 0.12900950f, 0.25217244f, 0.12311726f, 0.09873846f, 0.07461234f, 
    0.12983973f, 0.00687160f, -0.10570446f, -0.11333948f, -0.16083094f, 0.02696884f, -0.03731574f, 0.05477474f, 
    -0.15978670f, -0.12299712f, -0.16046159f, -0.04464499f, 0.26815796f, -0.15255845f, -0.00487315f, -0.13158156f, 
    -0.01606577f, 0.09151582f, 0.05749346f, 0.04817591f, -0.16579604f, 0.07134788f, 0.08534868f, -0.09292692f, 
    0.05847729f, -0.15733781f, 0.01496479f, -0.11413117f, 0.15201864f, -0.12858415f, -0.02864802f, 0.01460497f, 
    -0.11939008f, 0.06373344f, -0.05019985f, -0.20312825f, 0.06680267f, 0.12804556f, -0.02804503f, -0.08442222f, 
    -0.02603647f, -0.26931900f, -0.10191397f, 0.09324049f, -0.13112265f, 0.04921842f, -0.04225011f, 0.11288157f, 
    0.10927008f, 0.09346494f, 0.07346103f, -0.14109759f, -0.03523483f, -0.07787623f, -0.27719185f, 0.06854451f, 
    0.03247584f, 0.16362037f, 0.14401796f, 0.26310056f, 0.17003150f, -0.00281770f, -0.05606380f, -0.06889392f, 
    -0.10673401f, -0.04770784f, -0.01034133f, 0.00934851f, -0.08377594f, -0.02709748f, 0.15184945f, 0.39359033f, 
    0.01839260f, 0.00641350f, -0.06142996f, 0.04047034f, 0.08023484f, -0.06411462f, 0.04585961f, -0.01484943f, 
    -0.16336603f, 0.13418201f, -0.17437609f, -0.24368805f, -0.03527392f, 0.07790290f, 0.02172635f, -0.03566786f, 
    0.12282093f, 0.02063084f, 0.19802533f, 0.05366631f, 0.27846009f, 0.16242760f, 0.14721149f, 0.08688045f, 
    -0.03067790f, -0.03334805f, -0.01232537f, 0.02213122f, -0.00623315f, -0.10313727f, -0.02153164f, -0.29479936f, 
    -0.03287483f, -0.08549332f, -0.02792149f, 0.16651247f, -0.08995122f, -0.01873246f, -0.00158947f, -0.05905412f, 
    -0.04532299f, -0.02275666f, 0.03605794f, 0.01089948f, -0.18138722f, 0.01216207f, 0.00419367f, 0.10973344f, 
    0.11334119f, -0.02734263f, -0.06378854f, -0.04600069f, 0.16851689f, -0.09110110f, 0.07027270f, 0.03581737f, 
    -0.42687473f, 0.48478231f, 0.06787968f, 0.13171206f, 0.05569625f, -0.00550756f, 0.01872201f, -0.00309213f, 
    -0.05957845f, 0.08957666f, 0.02686077f, -0.14246374f, -0.50841337f, -0.01412701f, 0.07809274f, -0.04047376f, 
    0.15563504f, -0.04155253f, -0.02231804f, -0.16027208f, -0.00996025f, 0.01364015f, -0.03192713f, 0.01473668f, 
    0.12800196f, 0.11395387f, 0.04188954f, -0.04372188f, -0.06081914f, 0.02722711f, -0.00573691f, 0.08980245f, 
    -0.00807782f, -0.09733606f, -0.04895816f, -0.12655486f, 0.01583031f, -0.23274419f, -0.17255433f, 0.30109987f, 
    -0.06947736f, 0.08038118f, -0.10865953f, 0.02046233f, -0.00161567f, -0.04674802f, -0.07232223f, -0.13968511f, 
    0.28582537f, -0.09255017f, -0.01216312f, -0.16857675f, -0.03613564f, 0.02218744f, 0.00320861f, 0.05458212f, 
    0.05962725f, -0.00106756f, 0.03366133f, 0.18221778f, 0.04773506f, 0.13469662f, 0.06351868f, 0.17904958f, 
    -0.00839549f, 0.01951792f, 0.12203232f, -0.00668253f, 0.04808298f, 0.10437405f, 0.08972409f, 0.12946238f, 
    0.14806354f, -0.13597730f, -0.03747211f, 0.04004988f, 0.04282179f, -0.05031314f, -0.04710521f, -0.02009596f, 
    0.01611453f, 0.06976958f, 0.07495841f, 0.18745482f, -0.10916328f, -0.13625859f, 0.14398952f, 0.03888898f, 
    0.21554244f, 0.01088680f, 0.16898720f, 0.07657307f, 0.12933873f, -0.14207946f, 0.00505123f, 0.10697334f, 
    0.14898230f, -0.02750215f, 0.11784445f, 0.06069571f, 0.06520473f, 0.04033475f, -0.00276719f, -0.05057469f, 
    0.12362096f, -0.16583268f, -0.02794417f, -0.04055585f, -0.12335166f, 0.11536080f, -0.02265519f, 0.24373487f, 
    -0.04125963f, -0.04498154f, 0.00761798f, 0.08167662f, 0.18407229f, -0.01225665f, -0.22868215f, 0.14924401f, 
    -0.07735781f, 0.02757759f, -0.01694325f, 0.09454569f, 0.20407911f, 0.02863859f, 0.04040032f, -0.05940929f, 
    -0.02336081f, 0.00294698f, -0.01644583f, -0.04618033f, 0.07146462f, -0.17434084f, -0.04042846f, 0.25806773f, 
    0.00741041f, -0.06301558f, -0.02719402f, 0.05336477f, -0.02625325f, -0.01417244f, 0.10931116f, 0.14615084f, 
    -0.03260143f, 0.07016973f, 0.12309418f, 0.02709917f, -0.01580971f, -0.05068034f, 0.10399594f, -0.05014906f, 
    0.11229393f, -0.00982662f, 0.06815295f, 0.06936117f, 0.12144190f, 0.08622050f, -0.05126974f, -0.08366697f, 
    0.05850516f, 0.03555972f, -0.12410735f, -0.04844339f, -0.00503373f, -0.02057918f, 0.07448807f, -0.06588567f, 
    0.13626033f, -0.06492722f, 0.17419030f, -0.05729628f, 0.05486999f, -0.04859943f, 0.02665606f, 0.03185042f, 
    0.02701199f, 0.03279956f, -0.15845588f, 0.08487761f, 0.23930280f, 0.18386972f, -0.02039847f, -0.01099608f, 
    0.01008560f, -0.11496558f, 0.02393860f, 0.05387900f, -0.02061149f, 0.01771222f, 0.07670245f, -0.12612137f, 
    0.32057706f, -0.23103938f, 0.10372592f, -0.12876618f, -0.18362179f, 0.06441759f, 0.06089610f, 0.24423304f, 
    -0.00393519f, 0.02475299f, -0.01537084f, -0.16190539f, 0.15129872f, -0.02072232f, -0.01633988f, 0.20365301f, 
    -0.09283158f, -0.09843608f, -0.21792607f, 0.16529211f, -0.04680803f, -0.10841092f, 0.07411374f, 0.06629482f, 
    0.04716945f, 0.00793755f, 0.05173862f, 0.04186698f, 0.11215543f, 0.10977959f, -0.09446441f, 0.04416968f, 
    0.11044312f, 0.14130476f, 0.17989384f, -0.09110138f, 0.06747143f, 0.12671706f, 0.12557694f, -0.16879024f, 
    0.01421813f, 0.01507428f, -0.02157599f, 0.24342149f, -0.02575227f, 0.05398791f, 0.22398593f, 0.09249387f, 
    -0.28299093f, 0.06934258f, 0.02979398f, 0.02634658f, 0.08681700f, -0.01183133f, -0.14739983f, -0.09674171f, 
    0.08565485f, -0.12559089f, -0.02800683f, 0.21909294f, 0.07875497f, -0.08792054f, -0.12421103f, 0.00658625f, 
    -0.03638674f, 0.00277271f, 0.01775966f, 0.01599462f, -0.08502347f, -0.08551367f, 0.04751318f, 0.04824295f, 
    0.05016637f, 0.11271792f, 0.06900167f, -0.05022481f, 0.07928218f, 0.04026855f, -0.04643229f, 0.01002377f, 
    -0.01502029f, 0.17643529f, 0.03739472f, 0.04416912f, 0.00261696f, 0.17914428f, -0.04983237f, 0.11377711f, 
    0.01315353f, 0.12364704f, -0.06195826f, -0.22006552f, 0.03400450f, 0.19780931f, -0.10898779f, -0.05379800f, 
    -0.41319934f, -0.05274527f, -0.00714021f, -0.08825679f, 0.04727490f, 0.05022020f, 0.03073990f, -0.09044343f, 
    0.03026321f, -0.23768437f, -0.01365003f, -0.16213575f, 0.12574501f, -0.12274557f, -0.05177902f, 0.07025052f, 
    0.03491190f, -0.05132832f, -0.04031485f, -0.00393911f, -0.02144899f, -0.10312881f, -0.05854376f, -0.03103908f, 
    -0.18156525f, 0.03526031f, 0.02667396f, -0.10221457f, -0.08902460f, 0.07838341f, -0.14636703f, 0.08787971f, 
    0.00121834f, 0.12978099f, -0.01590391f, 0.12016997f, -0.24266441f, -0.06091531f, -0.21470267f, 0.03370442f, 
    -0.16198185f, -0.02284051f, -0.05851096f, 0.05962307f, -0.01487349f, 0.03749284f, 0.06662070f, 0.09347890f, 
    -0.06965155f, 0.12267470f, -0.14760518f, -0.09184861f, 0.00525594f, 0.01088742f, -0.00915681f, 0.00477526f, 
    0.06828216f, -0.02914235f, 0.11713792f, 0.00714286f, 0.20362754f, 0.28826714f, 0.00401347f, -0.04135517f, 
    0.08034246f, -0.00306953f, -0.05783821f, -0.20392194f, 0.07691647f, -0.00957068f, -0.01983136f, 0.02158106f, 
    -0.19270800f, 0.15904383f, -0.07570885f, 0.05607332f, 0.04729405f, 0.11131182f, -0.06411723f, -0.11102183f, 
    -0.01771160f, 0.03587988f, 0.09174027f, 0.03810155f, 0.01509096f, 0.10210656f, 0.16830020f, 0.09008736f, 
    0.02199746f, 0.04134013f, 0.07449146f, -0.06733048f, -0.00077057f, 0.00448499f, 0.02017017f, 0.01403686f, 
    0.32204670f, -0.09329867f, 0.01452296f, -0.08717483f, 0.03635885f, -0.03267200f, 0.08947377f, -0.05511867f, 
    0.12216175f, 0.03323745f, 0.06219305f, 0.00332148f, 0.24676745f, 0.00193686f, 0.20222802f, -0.14158772f, 
    -0.01629383f, -0.00491003f, 0.09100372f, -0.01660502f, 0.08755526f, 0.06337386f, -0.03047619f, -0.02773818f, 
    -0.21391964f, -0.11235254f, -0.01842286f, -0.05054065f, -0.01573484f, 0.06530966f, -0.03032606f, 0.11250634f, 
    -0.06180643f, -0.04683087f, -0.03112366f, -0.07125862f, -0.10354365f, 0.02143087f, 0.08046822f, -0.22212778f, 
    0.09851602f, 0.01516234f, 0.00092502f, 0.10857840f, 0.03324832f, -0.02560680f, 0.04185591f, 0.02045219f, 
    -0.53070623f, -0.18109192f, -0.08885171f, 0.15632866f, 0.14009947f, -0.02995470f, 0.01340886f, 0.03504854f, 
    0.05142384f, -0.03010924f, 0.03659592f, 0.01465719f, -0.24050508f, -0.12941942f, -0.00253145f, -0.10518207f, 
    0.01802308f, -0.02060482f, -0.04453605f, -0.00158698f, -0.05096291f, -0.03941316f, 0.07965964f, 0.00382045f, 
    0.02098512f, 0.16164726f, 0.11030746f, 0.08501324f, -0.02369155f, 0.02167124f, 0.10640529f, 0.09722228f, 
    -0.04209647f, 0.04034191f, 0.07184395f, -0.04438158f, 0.01917546f, 0.12788925f, 0.00381404f, 0.24471180f, 
    -0.04956152f, 0.12846690f, 0.06548073f, -0.07994623f, 0.03267460f, 0.08402456f, 0.07069466f, -0.06197090f, 
    -0.08579543f, -0.10883801f, -0.04319426f, 0.00354386f, 0.11250862f, 0.03199937f, -0.09663259f, -0.01689342f, 
    -0.05036424f, 0.04049604f, -0.04005142f, -0.01999181f, 0.11629599f, -0.12214586f, 0.04824150f, -0.25188169f, 
    0.18058641f, 0.01011780f, 0.02216990f, 0.04356087f, -0.08643555f, 0.09083211f, 0.05722122f, 0.00317312f, 
    -0.01512271f, 0.00803156f, 0.01151294f, -0.20127273f, 0.09201734f, -0.08756866f, -0.01940682f, -0.11308773f, 
    0.09593109f, -0.03302801f, -0.03394863f, 0.00924389f, -0.24211784f, 0.00817403f, 0.23875906f, -0.30516422f, 
    0.02093170f, 0.03955640f, 0.10356236f, -0.05047005f, 0.01954841f, 0.08081593f, 0.18675505f, 0.04261798f, 
    0.22351767f, -0.10869845f, 0.10796469f, 0.13226698f, 0.11935958f, -0.03409236f, 0.00523563f, 0.11396734f, 
    -0.02783077f, 0.14928980f, -0.01649763f, 0.06215282f, -0.06430670f, 0.02828787f, -0.08814288f, 0.10475481f, 
    -0.22809158f, 0.13036767f, 0.09226799f, -0.04543782f, 0.06721834f, -0.01033162f, -0.03584555f, -0.02130995f, 
    -0.29856685f, -0.21658254f, 0.10644827f, -0.07077418f, -0.07356370f, -0.10177270f, -0.06125113f, -0.07472406f, 
    -0.03605517f, -0.01036965f, 0.04691413f, 0.07426736f, -0.03085468f, 0.03124979f, 0.06293483f, 0.14912067f, 
    0.11383320f, 0.00446335f, 0.15718327f, -0.02759382f, 0.05345001f, 0.07543444f, 0.03146525f, -0.06040058f, 
    -0.06758286f, -0.00654260f, -0.00768043f, 0.14326097f, 0.08043367f, 0.10315649f, -0.05221881f, -0.04035034f, 
    0.03381566f, 0.11264779f, -0.10573613f, -0.12449079f, -0.31400678f, -0.10431580f, -0.05485138f, -0.06192240f, 
    0.07752362f, -0.01060250f, 0.02959106f, -0.02779465f, 0.02986953f, 0.10362390f, -0.03769187f, -0.05427544f, 
    0.16034041f, -0.04897136f, -0.01435205f, -0.02236786f, -0.08780045f, -0.03954507f, 0.02974125f, 0.06870646f, 
    -0.06673378f, -0.09005996f, -0.06350440f, -0.03804783f, -0.12243934f, -0.08431744f, -0.00785093f, 0.07440799f, 
    -0.00302868f, 0.00074229f, 0.00706932f, 0.06135803f, 0.04428713f, 0.04326819f, -0.03923803f, 0.04100864f, 
    -0.27140176f, -0.32477355f, 0.17403613f, -0.03301832f, 0.09245858f, 0.07862428f, -0.05335865f, 0.08754729f, 
    -0.08335162f, -0.03526884f, 0.01623597f, 0.02678502f, -0.08126646f, 0.25044695f, -0.32155004f, -0.12089992f, 
    0.01343932f, -0.06420595f, 0.07066280f, 0.03997985f, 0.13129809f, 0.13397884f, -0.01528982f, 0.07385898f, 
    -0.03302875f, 0.05047635f, 0.09373366f, -0.06392469f, -0.02382668f, -0.07576769f, -0.06331303f, -0.04506899f, 
    -0.00327205f, -0.01977051f, 0.03380845f, 0.06373235f, 0.14891204f, -0.10148701f, 0.02765809f, 0.23377068f, 
    0.34936768f, 0.05601789f, 0.17327364f, 0.11226933f, 0.06648924f, 0.06109033f, -0.02830926f, 0.01142576f, 
    0.27009451f, -0.03555850f, 0.11537660f, -0.03248884f, 0.01172795f, 0.12928526f, -0.08306513f, 0.05950884f, 
    -0.09072224f, -0.12752928f, 0.03305691f, 0.17872605f, -0.07743958f, 0.09956274f, 0.14498149f, 0.09811103f, 
    -0.03693356f, 0.09584992f, -0.00021878f, 0.20491028f, 0.12423278f, 0.12092691f, -0.07413578f, 0.14368254f, 
    -0.33358210f, 0.00888454f, -0.04266382f, -0.17945553f, 0.05752224f, -0.00471688f, 0.05796427f, 0.03848002f, 
    -0.03252381f, 0.03364923f, 0.06594116f, -0.08847214f, -0.02232020f, 0.01723582f, -0.00256847f, -0.07357918f, 
    -0.08632503f, -0.05619151f, 0.05759938f, 0.03630475f, 0.03975111f, 0.06773753f, 0.16893366f, 0.10607368f, 
    0.07670881f, 0.03455820f, 0.07548838f, 0.05840772f, -0.08134113f, -0.13758127f, 0.03839573f, -0.03350120f, 
    -0.05574722f, -0.02881760f, 0.10800844f, 0.03525387f, -0.12054540f, 0.01665667f, 0.04637599f, 0.13525279f, 
    0.11459584f, -0.01650628f, 0.03430802f, -0.00393605f, 0.00272542f, -0.07204448f, 0.00618119f, -0.04594995f, 
    -0.04441375f, -0.03903027f, -0.13373581f, 0.27345225f, -0.21218428f, -0.09540394f, -0.14655897f, -0.08196245f, 
    0.08183590f, 0.11922419f, -0.10389160f, 0.11950302f, -0.07145164f, 0.04394937f, 0.23015845f, -0.06882481f, 
    0.07775994f, 0.16331546f, 0.16576339f, -0.02413390f, 0.01489839f, 0.01882571f, -0.01733078f, 0.00742546f, 
    -0.00763097f, 0.14673366f, -0.02468757f, 0.00975353f, -0.00597097f, 0.13597074f, 0.17367484f, -0.01756802f, 
    0.03041905f, 0.01989706f, -0.06381223f, -0.01348959f, -0.16806982f, 0.14656693f, 0.13057174f, 0.02290468f, 
    0.18977600f, 0.12851177f, 0.11883248f, -0.03814097f, 0.03909215f, -0.06371927f, -0.00128716f, -0.04903232f, 
    -0.55754149f, -0.01405475f, -0.14753312f, -0.17854278f, 0.01688693f, 0.11496632f, 0.09129000f, 0.20996368f, 
    -0.04664072f, -0.18203743f, -0.17839591f, -0.01169956f, -0.10047921f, -0.12796217f, -0.16674115f, -0.11809928f, 
    -0.08340141f, -0.15130597f, -0.00947183f, 0.00698593f, 0.02640717f, -0.02158433f, 0.05296540f, 0.10091109f, 
    -0.05340336f, -0.11704689f, 0.00269880f, -0.22329006f, -0.02926189f, -0.12937276f, 0.05869387f, 0.12753770f, 
    0.20259680f, 0.01120532f, 0.01878863f, 0.26282129f, -0.21676521f, -0.20602570f, -0.00745286f, -0.12656233f, 
    -0.01186125f, -0.16552638f, 0.06072226f, 0.06656130f, -0.05681433f, -0.00802193f, -0.02370089f, 0.02322952f, 
    0.26791993f, 0.20809275f, 0.09221920f, 0.16250849f, 0.00475619f, -0.03273645f, 0.00615352f, 0.10218164f, 
    0.12406595f, 0.03252901f, 0.09589913f, 0.09539067f, 0.14145085f, 0.06025947f, 0.01792621f, 0.03796695f, 
    0.12237527f, 0.06027706f, 0.14847054f, 0.14320868f, 0.03898366f, 0.03028749f, 0.01725268f, -0.03378981f, 
    -0.01202023f, 0.01122618f, 0.06051657f, -0.17573132f, 0.02954874f, 0.06067371f, -0.05986632f, -0.05548192f, 
    -0.07861830f, -0.17019634f, -0.06135094f, -0.09798756f, -0.14694346f, 0.04393397f, 0.00997236f, -0.12716942f, 
    0.32657689f, 0.14553174f, 0.05519509f, 0.11664172f, -0.00894442f, 0.18613750f, 0.02304412f, 0.05557173f, 
    -0.06894986f, -0.31472886f, -0.12619813f, -0.19015980f, -0.08152705f, 0.02475417f, 0.08506367f, -0.06562155f, 
    0.07403185f, 0.00017078f, -0.12301882f, 0.09807111f, -0.09696576f, -0.33707398f, 0.09314410f, -0.12230892f, 
    -0.08670966f, -0.07350893f, 0.03303115f, 0.04926258f, 0.01521195f, 0.01015394f, -0.05056508f, 0.02915754f, 
    0.15662310f, 0.29624626f, 0.17796777f, 0.24618405f, -0.00852781f, -0.00405540f, 0.06275006f, 0.05157976f, 
    -0.09546975f, 0.16066420f, -0.04111981f, -0.16396697f, -0.05903601f, -0.09630285f, -0.22065319f, -0.00082216f, 
    0.01981917f, 0.12019731f, 0.05541981f, -0.06049175f, 0.08402823f, 0.02879185f, -0.01086444f, -0.03635352f, 
    0.12223118f, -0.31624383f, 0.22721985f, 0.03231183f, 0.00694625f, -0.00736497f, 0.12677780f, 0.00715665f, 
    0.05550057f, -0.17475957f, -0.06754477f, -0.05798710f, -0.03889138f, -0.02209920f, -0.18634947f, 0.11131038f, 
    0.03544683f, -0.04524298f, -0.06965522f, 0.00379569f, 0.16336285f, 0.02881670f, 0.03504637f, 0.01599039f, 
    0.01503417f, 0.05462357f, -0.12422376f, 0.10644365f, 0.00922382f, 0.00579679f, -0.02352460f, 0.11201537f, 
    -0.05027856f, 0.01408724f, -0.02620594f, -0.01894389f, -0.17155637f, 0.11130197f, -0.18217044f, 0.14521860f, 
    0.13449983f, -0.02115189f, -0.07551187f, 0.19794793f, 0.02676099f, 0.04778830f, 0.16465542f, 0.13002142f, 
    -0.11389477f, 0.14152469f, 0.04900113f, 0.04919379f, -0.04084510f, 0.09483088f, -0.01058553f, 0.00001223f, 
    0.11269526f, 0.04938583f, 0.04564601f, -0.07105575f, 0.09040435f, -0.04120681f, 0.24261038f, 0.21710023f, 
    -0.12100162f, 0.01374895f, -0.05532251f, 0.10680468f, 0.00537842f, -0.05076842f, 0.04279552f, 0.12023354f, 
    -0.37081894f, -0.03637728f, 0.13377622f, -0.05885882f, -0.00352979f, -0.10131726f, 0.02337714f, 0.03394340f, 
    0.08155952f, 0.09813036f, -0.05974321f, -0.05065576f, 0.11003510f, 0.12913692f, -0.13433844f, -0.04341801f, 
    -0.10623603f, 0.04831004f, -0.00656149f, 0.11449354f, -0.03989145f, 0.09856691f, 0.03675757f, 0.02981542f, 
    -0.10120644f, 0.11255617f, 0.02677254f, -0.05295274f, 0.10292146f, -0.07341760f, 0.04115130f, -0.08145181f, 
    -0.01704775f, 0.04483343f, -0.04895840f, 0.02890615f, -0.07071415f, -0.04923204f, -0.07388940f, -0.01490389f, 
    0.04686630f, -0.03261809f, 0.00191707f, 0.05224620f, 0.04799567f, -0.01253002f, -0.14067656f, -0.04333308f, 
    -0.09948662f, 0.12161684f, 0.12321584f, 0.06664275f, -0.08236030f, 0.15259604f, 0.07331414f, 0.06835106f, 
    -0.04797122f, -0.27114686f, -0.09780660f, 0.03976914f, -0.15123695f, 0.25560927f, -0.04887196f, 0.22856022f, 
    0.04702231f, 0.09786012f, 0.03023520f, 0.06398509f, 0.02741158f, -0.06813366f, -0.23984943f, 0.10926502f, 
    -0.18853007f, -0.05648648f, 0.08036866f, -0.01821583f, -0.07455132f, 0.03086370f, 0.00274273f, 0.13665959f, 
    0.07226917f, -0.05621336f, -0.07223634f, 0.09127207f, 0.19180669f, -0.04875257f, -0.07934168f, 0.13005739f, 
    -0.21207339f, 0.03472982f, -0.04569171f, 0.03053393f, 0.01013724f, 0.01246515f, -0.06106276f, 0.00784935f, 
    -0.18550467f, 0.26532549f, -0.00722679f, -0.10812161f, 0.04091869f, 0.12136868f, 0.15390942f, 0.10853863f, 
    -0.08702409f, 0.06984143f, 0.11674333f, 0.08449958f, 0.13068753f, -0.00841186f, -0.05156471f, -0.14222455f, 
    0.12168329f, 0.05191169f, -0.08901517f, 0.00751052f, 0.00897696f, -0.07364677f, 0.06952022f, 0.08743683f, 
    -0.31612217f, -0.22811069f, -0.17721795f, -0.02241655f, 0.09812641f, 0.15729684f, 0.23952626f, 0.00343685f, 
    -0.00008038f, -0.08988908f, 0.09504394f, -0.14615414f, 0.01254966f, 0.02508959f, 0.13442361f, 0.07741562f, 
    -0.15322423f, -0.15090621f, -0.06100711f, 0.03241350f, 0.00117894f, 0.04861348f, 0.09012603f, 0.10928478f, 
    0.06197562f, 0.00419424f, -0.11117228f, 0.18215154f, 0.05769935f, -0.06196943f, -0.19051392f, -0.04793993f, 
    -0.11558039f, 0.00744702f, 0.02504868f, 0.07174969f, 0.35351667f, -0.18756828f, -0.06440132f, 0.02725091f, 
    0.02733841f, -0.07610994f, -0.09953919f, 0.01197020f, 0.05706896f, 0.04950332f, 0.02109347f, -0.11614772f, 
    0.21617821f, 0.10885277f, -0.01218214f, 0.07996253f, -0.00935450f, -0.01328434f, 0.04406632f, -0.10874677f, 
    0.07013904f, -0.04066126f, -0.07031517f, -0.06856848f, -0.24554083f, -0.11637909f, -0.05492137f, 0.41400144f, 
    0.04424942f, 0.07133222f, 0.04218631f, -0.12002146f, 0.02472903f, 0.01371818f, 0.03456309f, -0.03772169f, 
    -0.45148721f, -0.14993894f, -0.23960976f, -0.12852529f, 0.05656246f, 0.15969783f, 0.15920858f, 0.05789406f, 
    0.03868454f, 0.02101695f, -0.12439443f, -0.24335201f, 0.00127317f, 0.23404914f, 0.15809378f, 0.14577088f, 
    0.06725959f, 0.07525247f, -0.09450994f, 0.04911418f, -0.02647317f, 0.02026182f, -0.09880675f, 0.05182680f, 
    -0.17980583f, -0.22017220f, -0.04697093f, 0.03313146f, -0.09679894f, 0.04023739f, 0.10152862f, 0.11189036f, 
    0.01786529f, -0.04557063f, -0.00315007f, -0.00635501f, 0.15041287f, 0.01776860f, 0.04185272f, 0.08843665f, 
    0.04868970f, -0.29922357f, -0.06782115f, 0.13109125f, 0.16154061f, -0.04088262f, 0.14663328f, 0.20331161f, 
    0.01463029f, 0.00705234f, -0.02264814f, -0.07829548f, 0.02480577f, 0.15581331f, 0.13790999f, 0.09876765f, 
    -0.02295692f, -0.03017982f, -0.07443310f, 0.03616263f, -0.13499646f, 0.10212245f, 0.01206083f, 0.05612849f, 
    0.14033303f, 0.16801801f, -0.09132868f, -0.03305731f, -0.02440522f, 0.03729676f, 0.08233313f, -0.03521724f, 
    0.08907148f, 0.15852113f, 0.06016126f, 0.21890844f, 0.12101270f, 0.02860619f, 0.12617488f, -0.03375971f, 
    -0.20932539f, -0.15830089f, 0.05907166f, -0.09714637f, 0.21514030f, 0.04147481f, 0.16063063f, 0.25558886f, 
    0.04764491f, 0.00711068f, 0.02331975f, 0.06160638f, 0.07298652f, 0.00963102f, -0.01612109f, -0.00472270f, 
    -0.11766720f, -0.03058656f, 0.11052109f, -0.08793270f, -0.05150312f, -0.01304570f, 0.01942507f, -0.06654038f, 
    -0.04519911f, -0.04307957f, -0.01019219f, -0.09329337f, 0.10293154f, 0.09133615f, 0.06834865f, 0.33702633f, 
    -0.06206889f, -0.20305279f, 0.01335041f, -0.02691798f, -0.07258436f, -0.06698415f, -0.04897388f, -0.20684262f, 
    -0.19202800f, -0.09629103f, 0.14683035f, 0.02755511f, -0.06299661f, -0.14443021f, 0.23281048f, -0.01177769f, 
    -0.02514041f, -0.06216842f, -0.01312581f, 0.04321842f, 0.23055606f, 0.18072750f, 0.16833869f, 0.01831256f, 
    0.00043233f, -0.00827704f, -0.09895194f, 0.05125251f, 0.07680294f, -0.04049009f, -0.05512503f, 0.06695012f, 
    -0.07234074f, 0.28937736f, -0.24347909f, -0.06574939f, -0.07451686f, 0.03178819f, 0.00789109f, 0.12332769f, 
    -0.02868534f, 0.06937862f, -0.09060171f, -0.04299664f, 0.34198409f, -0.25501293f, 0.10129290f, 0.14359884f, 
    0.11828565f, 0.00311835f, -0.14581463f, 0.07480536f, 0.04407890f, -0.02583276f, 0.07773123f, 0.04201976f, 
    -0.18238439f, 0.21270622f, -0.10698283f, -0.12031302f, -0.08713397f, -0.02217640f, 0.01387919f, -0.00339892f, 
    0.08140674f, -0.17436616f, 0.00113407f, -0.16227175f, 0.05444567f, -0.08173325f, 0.06497899f, 0.20312484f, 
    0.03408651f, -0.06445672f, -0.06182524f, 0.05896409f, 0.00133862f, -0.09572224f, -0.03452174f, 0.08302099f, 
    -0.24178053f, -0.03838007f, 0.01365808f, -0.30693030f, -0.03592840f, -0.11837380f, 0.14386223f, 0.03346905f, 
    0.01881366f, -0.01567673f, 0.04752701f, 0.09548172f, -0.09710643f, -0.05423398f, 0.16037038f, -0.09773111f, 
    0.05640282f, 0.08062807f, 0.08616120f, -0.01642629f, -0.10233878f, 0.05311819f, -0.09705238f, 0.06020646f, 
    -0.03189626f, -0.02474247f, 0.07521782f, 0.13206454f, -0.03905714f, 0.05095880f, 0.01067145f, 0.04607776f, 
    -0.02307028f, 0.01593492f, 0.07055463f, 0.06788076f, 0.06316549f, 0.01845639f, -0.04312182f, 0.28809544f, 
    0.19987521f, -0.06451060f, 0.07716641f, 0.02020627f, 0.07449164f, 0.10237703f, -0.04343318f, -0.08798964f, 
    -0.07798906f, 0.10434420f, 0.02856084f, 0.09275991f, -0.00437499f, 0.04502531f, 0.13409698f, -0.13249747f, 
    -0.01138199f, -0.19573957f, -0.01122374f, -0.11362691f, -0.06165663f, 0.18873222f, -0.27935925f, -0.02126148f, 
    -0.11787686f, 0.19986817f, -0.00007325f, -0.00137633f, -0.06528926f, 0.11189698f, -0.01519473f, 0.00499391f, 
    0.18147510f, -0.04798276f, 0.07776350f, 0.03395777f, 0.07077632f, 0.05148003f, 0.01736009f, 0.00908455f, 
    -0.09181003f, 0.14018069f, -0.06530110f, 0.08744425f, 0.12659714f, -0.01814348f, -0.01557972f, 0.13736024f, 
    -0.11094482f, -0.01669287f, -0.02294486f, 0.11121880f, 0.03287233f, 0.03346176f, 0.09038168f, 0.10977019f, 
    0.13494253f, 0.16630408f, 0.10657077f, 0.17188264f, -0.00075577f, 0.04592972f, -0.00579189f, -0.05273956f, 
    -0.05689201f, 0.06675448f, -0.01388112f, -0.08312938f, 0.24324036f, 0.30689844f, -0.12588002f, 0.08380695f, 
    0.06516880f, -0.02234076f, 0.04911290f, 0.01635886f, 0.05409684f, -0.04299694f, -0.02007710f, -0.13319321f, 
    -0.01852295f, 0.22235738f, -0.04672350f, 0.04992209f, 0.10829425f, 0.04330746f, -0.00968909f, 0.10082833f, 
    0.02406869f, -0.04156573f, 0.10490923f, 0.02697443f, 0.13162585f, 0.05103634f, 0.13858595f, -0.06423789f, 
    -0.07018048f, 0.11665971f, -0.06246358f, -0.14483346f, -0.04498544f, -0.08885751f, -0.05791606f, -0.07092706f, 
    -0.10336718f, 0.01696446f, -0.09225588f, -0.17952560f, -0.00279804f, -0.00969420f, -0.03911062f, -0.06735501f, 
    0.14727980f, 0.10957184f, -0.01142729f, 0.06041373f, 0.15296072f, 0.05713127f, 0.10528051f, -0.22811297f, 
    -0.03961842f, 0.02503699f, 0.03223107f, 0.06599040f, -0.00771446f, -0.03599251f, -0.05274281f, 0.01282267f, 
    -0.30263457f, 0.06345842f, 0.11344180f, -0.13997407f, 0.00129955f, 0.02408669f, 0.08247911f, 0.10822639f, 
    0.11476507f, -0.10662451f, -0.08076373f, -0.09298842f, 0.07165329f, 0.06592748f, 0.01465009f, -0.22069626f, 
    0.07328921f, -0.07623796f, 0.01707304f, 0.05046745f, 0.07951635f, 0.07284600f, 0.12443079f, -0.03470046f, 
    -0.10309257f, 0.18881442f, -0.15367427f, 0.13774355f, 0.02423716f, 0.00331283f, 0.04765802f, -0.00083360f, 
    0.04156909f, 0.02877059f, 0.02854064f, 0.00751106f, -0.21948414f, -0.17021558f, 0.20325018f, -0.00763290f, 
    0.07918692f, -0.04170410f, -0.03039348f, -0.04180386f, -0.03986520f, 0.03522054f, 0.12815638f, 0.01338305f, 
    0.22070441f, 0.14712405f, -0.07266772f, 0.08794425f, -0.04713666f, 0.03633004f, 0.09456307f, 0.10506592f, 
    0.00834740f, 0.02029817f, 0.07617122f, 0.00110032f, 0.05595780f, -0.09818932f, -0.17788185f, 0.01620272f, 
    -0.07845084f, 0.17513610f, 0.05889160f, -0.18794835f, -0.07543289f, 0.18581074f, -0.04004074f, -0.15441453f, 
    -0.20182869f, 0.02790279f, 0.04102705f, 0.06895529f, 0.10202511f, -0.05305797f, 0.04926552f, -0.08286487f, 
    -0.00333642f, 0.05962599f, 0.05937317f, -0.15784267f, 0.21758369f, -0.10461571f, -0.19766052f, -0.22686860f, 
    0.11633977f, 0.01688653f, -0.03918754f, 0.16394390f, -0.05699492f, 0.02444042f, 0.16071756f, -0.04597812f, 
    0.25155434f, -0.02670117f, 0.05754517f, -0.17166495f, -0.06015659f, -0.00218782f, 0.04617831f, 0.02453014f, 
    0.12225550f, 0.02921727f, -0.03014659f, 0.18743907f, -0.10940179f, 0.05001762f, 0.06924435f, -0.14000916f, 
    0.14997251f, 0.13161443f, -0.03737671f, -0.07907421f, -0.00958163f, 0.16987751f, 0.04340934f, 0.12425122f, 
    0.19722113f, -0.10011192f, -0.12337892f, 0.22772145f, 0.04944061f, -0.01097160f, 0.10750949f, -0.00317906f, 
    -0.07339062f, 0.08067973f, -0.10962176f, 0.14503649f, -0.12716351f, 0.15669736f, -0.00339050f, 0.06595016f, 
    -0.13689390f, 0.01024602f, -0.01982675f, -0.07898964f, 0.07776836f, -0.03777312f, 0.03541633f, -0.03331155f, 
    -0.26305884f, 0.08178359f, 0.32286698f, -0.26116925f, 0.02473314f, 0.05669671f, -0.00655126f, -0.05821216f, 
    0.01728417f, -0.00409528f, -0.01873646f, -0.01314450f, -0.14099783f, -0.25782689f, -0.05031305f, -0.10791370f, 
    -0.01731796f, 0.01876973f, 0.10665778f, 0.10806325f, -0.09293912f, -0.05544392f, 0.00760048f, -0.07720610f, 
    0.17878745f, -0.23843546f, -0.14356583f, -0.07111551f, 0.15626809f, 0.08230143f, -0.10490780f, 0.16266277f, 
    0.08093787f, -0.00284852f, -0.11248183f, 0.10750199f, 0.09568177f, -0.12363163f, -0.11921193f, -0.08997895f, 
    -0.03815681f, -0.16052961f, -0.13183810f, 0.21456636f, 0.07015888f, -0.05137757f, 0.10578381f, 0.00542631f, 
    0.59644055f, 0.01164736f, 0.05363758f, 0.02576050f, -0.03132089f, 0.05735727f, 0.01140947f, -0.14659943f, 
    0.23118150f, 0.04998881f, 0.13363002f, 0.02155416f, -0.02144770f, 0.25793552f, 0.36430264f, 0.05109085f, 
    0.02506387f, 0.07618693f, -0.05290170f, 0.06861675f, -0.04974625f, 0.12201624f, 0.05836595f, -0.08684716f, 
    -0.21401908f, 0.08977255f, 0.13612708f, 0.09824690f, 0.15784647f, 0.19967571f, -0.06731496f, -0.15644346f, 
    0.06513742f, 0.03466359f, -0.02813388f, 0.05305205f, 0.21956597f, 0.27715287f, 0.04359902f, -0.08185487f, 
    0.13405414f, 0.09031877f, -0.12191480f, -0.08165708f, 0.08539381f, 0.11599251f, 0.09798222f, 0.11853263f, 
    -0.19431260f, 0.13913153f, 0.05154790f, -0.06502305f, 0.01904058f, 0.02656315f, -0.02797212f, -0.09224685f, 
    0.03252026f, 0.02457000f, -0.06479137f, 0.03059264f, -0.09619725f, -0.12923260f, -0.04130083f, 0.03211283f, 
    0.12693982f, 0.07751095f, -0.04362165f, 0.00807211f, 0.03985470f, 0.00089475f, 0.06361266f, 0.09081345f, 
    -0.09119774f, 0.04415017f, -0.08862561f, 0.14152122f, -0.05468274f, 0.11138911f, 0.06451407f, -0.01510247f, 
    0.02511538f, -0.04810856f, 0.06536810f, 0.07267876f, 0.20356838f, -0.15937066f, -0.04557168f, 0.20405436f, 
    -0.13480869f, -0.13680172f, -0.04766623f, -0.15503547f, 0.18248568f, -0.03638275f, 0.01555454f, -0.01331233f, 
    -0.07991013f, 0.17740799f, 0.14982238f, 0.04866481f, -0.07215373f, 0.05886951f, -0.17412804f, -0.09969708f, 
    -0.04513792f, -0.07934538f, 0.03131750f, 0.10805545f, 0.05978227f, 0.04448394f, 0.21087599f, 0.14143611f, 
    -0.05134971f, -0.00618960f, -0.01777827f, 0.01669334f, 0.08419579f, 0.15471902f, 0.14181726f, -0.01738366f, 
    0.12952699f, -0.07666502f, -0.11515576f, -0.09866069f, 0.02338646f, -0.17042610f, -0.00579476f, -0.00233638f, 
    -0.04278687f, -0.01807607f, 0.04810937f, 0.17920631f, 0.01960761f, 0.04295389f, 0.00138262f, -0.03857975f, 
    0.08034449f, 0.07639372f, -0.01618687f, 0.08712546f, -0.08005047f, -0.06577457f, 0.01773926f, 0.03884280f, 
    0.18418315f, 0.09123352f, 0.24682148f, -0.09616247f, 0.09089135f, -0.00594737f, 0.02872718f, 0.00120798f, 
    0.07235678f, -0.01492395f, -0.06576879f, 0.04458626f, 0.17267196f, -0.20162794f, -0.10478521f, -0.15686068f, 
    -0.10962415f, -0.00423172f, 0.09311795f, 0.07862942f, 0.04208511f, 0.06388526f, -0.06241458f, -0.08897807f, 
    0.12784545f, -0.24985661f, -0.15269753f, -0.11883063f, 0.05320696f, -0.03674050f, -0.00656070f, 0.12325952f, 
    0.13643283f, 0.05957112f, -0.07725405f, 0.10921023f, 0.28123498f, -0.06169910f, -0.09258611f, -0.05664791f, 
    -0.04919718f, 0.06264248f, -0.11357045f, 0.18021536f, -0.00896412f, -0.06079983f, 0.05459904f, 0.12625797f, 
    -0.22576651f, 0.06899783f, -0.04267366f, -0.01764876f, 0.05907955f, -0.01896278f, -0.09033852f, -0.02081643f, 
    0.10555722f, 0.01556402f, 0.14434612f, -0.03193959f, 0.14708212f, 0.26020482f, 0.11265595f, -0.24536639f, 
    -0.03841386f, -0.03479488f, 0.05509970f, 0.04842716f, 0.06069177f, 0.12266432f, 0.11328810f, 0.16522011f, 
    -0.24927811f, 0.32989088f, 0.00271782f, 0.11516313f, -0.02775890f, -0.09877580f, 0.04546958f, -0.02736752f, 
    -0.03207159f, -0.03734674f, 0.01810166f, 0.06396448f, -0.02568756f, -0.08621764f, 0.07808560f, -0.11268429f, 
    -0.03489325f, 0.09775396f, -0.04383566f, -0.01305593f, -0.04981342f, 0.08584679f, 0.06734970f, 0.00504934f, 
    0.07656814f, 0.23294456f, 0.07021711f, 0.11853696f, -0.04263591f, 0.11660594f, -0.09599268f, 0.02519287f, 
    0.03198810f, 0.08431318f, -0.04908747f, -0.01177356f, -0.17174077f, 0.00666867f, -0.19829406f, 0.03158880f, 
    -0.19942130f, 0.10970164f, -0.11447014f, -0.14169891f, -0.02442922f, 0.19155844f, -0.07012916f, -0.07019090f, 
    -0.41207355f, 0.08791979f, -0.06560106f, -0.01924562f, -0.03565622f, -0.02168575f, 0.10715415f, -0.03651863f, 
    -0.07455859f, 0.00846575f, 0.03336361f, -0.04320839f, 0.23424716f, -0.00351976f, -0.20298271f, -0.02915656f, 
    0.03503744f, 0.09598797f, -0.13496350f, -0.04479826f, 0.01378582f, 0.04036318f, 0.23486513f, -0.07738691f, 
    0.14349124f, -0.12663436f, 0.03372560f, -0.15993512f, -0.11866400f, -0.07012305f, 0.02700936f, 0.00810068f, 
    0.06828802f, 0.11826014f, 0.04237749f, 0.21174103f, -0.08778813f, 0.10838191f, 0.00766563f, -0.08601666f, 
    -0.13492422f, 0.10888885f, -0.16061158f, 0.08586134f, 0.07853535f, 0.12130558f, 0.06993328f, 0.06881291f, 
    0.10875650f, 0.29061219f, -0.21935421f, 0.14575478f, 0.06433362f, 0.06023469f, -0.00281485f, 0.00249780f, 
    0.02907611f, 0.06669150f, 0.06859241f, 0.03440298f, -0.03247938f, 0.02560963f, -0.13579729f, -0.09883656f, 
    -0.04874661f, -0.02985672f, 0.04903293f, -0.01125660f, -0.01495671f, -0.02391061f, 0.01521618f, 0.08785871f, 
    -0.04453170f, 0.05580535f, -0.03784638f, 0.00947781f, 0.01720737f, 0.05672783f, -0.04222472f, -0.05363834f, 
    0.00656539f, 0.01040345f, -0.06433325f, 0.00740806f, 0.04539408f, -0.03888822f, 0.00763987f, -0.07887913f, 
    -0.00016642f, 0.04431587f, -0.06524067f, -0.00912431f, -0.06877098f, -0.06704634f, -0.01933393f, -0.03424202f, 
    -0.02630147f, 0.05760376f, 0.01557912f, 0.01273115f, 0.00343714f, -0.01970729f, 0.05725801f, -0.05926744f, 
    0.05910864f, 0.00326020f, -0.02869847f, -0.03226585f, -0.01813182f, -0.06069987f, 0.00854400f, -0.05646748f, 
    -0.04994211f, -0.00391394f, -0.05543000f, -0.04907480f, 0.04693961f, 0.05314955f, -0.00491424f, -0.03914610f, 
    -0.03905496f, -0.04022092f, 0.01102381f, -0.05430830f, 0.03999395f, -0.02271001f, 0.01482049f, 0.04311595f, 
    -0.02028575f, 0.02396962f, 0.01756431f, 0.04305170f, -0.00046697f, 0.04529089f, 0.05028802f, 0.03867457f, 
    -0.03629756f, -0.03429006f, 0.03789952f, -0.00983273f, -0.04345993f, -0.06879362f, -0.00455992f, 0.05142305f, 
    0.02441919f, -0.00006271f, -0.07886568f, -0.05828594f, 0.03114541f, -0.03701428f, 0.05133413f, 0.02323158f, 
    0.01183815f, -0.02322168f, -0.02075571f, 0.06480926f, -0.02526341f, 0.03188170f, 0.03154801f, 0.01747444f, 
    -0.04081324f, 0.05130077f, -0.00895188f, -0.05790292f, 0.00595944f, -0.01062536f, -0.06512725f, -0.01719860f, 
    -0.02515855f, 0.01408068f, -0.01380412f, -0.03738695f, 0.04424843f, -0.05833014f, -0.06888115f, -0.06596002f, 
    -0.00660314f, -0.00043537f, -0.07274108f, 0.05700810f, 0.00436924f, -0.00693020f, -0.02717857f, 0.02962229f, 
    -0.04200539f, -0.02830715f, -0.09025684f, -0.05630594f, 0.04823337f, -0.00233458f, -0.08187236f, -0.05136652f, 
    0.00259282f, 0.01887468f, 0.04981261f, -0.07214704f, -0.08050025f, -0.06081996f, 0.02726118f, 0.03981021f, 
    -0.05863515f, 0.05213183f, -0.03156906f, 0.00018276f, 0.03981049f, 0.03012945f, 0.04867674f, 0.05559217f, 
    0.01007646f, -0.01429839f, -0.02877846f, -0.01327258f, -0.07228341f, -0.07082900f, -0.00160200f, -0.01256429f, 
    0.02634990f, -0.02635118f, -0.01574747f, -0.00823649f, -0.06474201f, 0.03132212f, -0.06843224f, -0.07774261f, 
    0.03927160f, -0.03861665f, -0.05138900f, -0.07211875f, 0.05933104f, -0.04924945f, -0.01284513f, 0.00807398f, 
    0.04594645f, 0.05895557f, -0.06010735f, -0.09483164f, -0.08444811f, -0.03090546f, -0.01902076f, -0.03200551f, 
    -0.01094778f, -0.05214801f, -0.01230627f, 0.07225851f, 0.06565220f, -0.04115921f, -0.05332727f, 0.04060150f, 
    -0.00565753f, -0.04026822f, -0.02307955f, -0.01615921f, 0.02974299f, 0.04695698f, 0.04756303f, -0.08987921f, 
    -0.02731508f, 0.04038720f, 0.05497399f, 0.01912514f, -0.07045987f, -0.03931106f, 0.03979978f, -0.01290451f, 
    0.02347270f, 0.18244658f, 0.27870479f, 0.04937178f, 0.01496734f, -0.03404025f, 0.01510302f, 0.03703223f, 
    -0.06128527f, -0.08499900f, 0.11835174f, 0.12650229f, -0.17066358f, -0.36034623f, -0.19401640f, 0.08860140f, 
    -0.02707224f, -0.14704807f, -0.06934060f, 0.07915594f, 0.19507785f, -0.18470354f, 0.08092801f, 0.09810781f, 
    0.00100460f, -0.05342349f, -0.23403205f, 0.08193303f, -0.03722676f, -0.11022899f, -0.07158624f, 0.03715617f, 
    0.05765413f, 0.13981728f, 0.03646046f, -0.06578673f, -0.20285176f, -0.27466184f, -0.07502110f, 0.05479424f, 
    -0.07431050f, 0.04144242f, 0.04521501f, -0.03135068f, 0.05227628f, 0.03536670f, 0.13959378f, 0.05377810f, 
    0.30444342f, -0.10903578f, -0.09902581f, -0.20811114f, 0.16562565f, 0.04930636f, -0.00980859f, 0.00986794f, 
    -0.02228470f, 0.00224447f, 0.08701553f, 0.14809373f, -0.00359687f, 0.04402792f, -0.01511141f, 0.00401688f, 
    0.01964778f, 0.17667703f, -0.00607019f, 0.10993036f, -0.06469578f, 0.04748614f, -0.13624746f, -0.02814443f, 
    0.04085531f, 0.13996124f, 0.03786431f, 0.04407930f, 0.13458569f, 0.10840864f, -0.08654952f, -0.01750079f, 
    -0.11247528f, 0.03016773f, 0.02982327f, 0.09493917f, 0.07530229f, 0.28574982f, 0.13275106f, 0.05021692f, 
    0.13577239f, 0.05218102f, -0.06062610f, -0.11545437f, 0.06405021f, 0.10305797f, -0.05902892f, 0.14814627f, 
    -0.11759079f, 0.13208386f, -0.03786378f, -0.11928638f, 0.01215330f, 0.05661482f, 0.04355493f, 0.00948266f, 
    -0.05256548f, 0.21409036f, 0.00303209f, 0.08111894f, -0.49927056f, -0.21289840f, -0.04895152f, -0.02312374f, 
    0.00073687f, -0.08332426f, 0.05737590f, -0.01130010f, 0.10736772f, -0.02695862f, 0.13179635f, 0.07665964f, 
    0.10306054f, 0.00241031f, -0.02234741f, 0.14364068f, 0.11290439f, -0.05102577f, -0.04561575f, 0.04527226f, 
    0.10284047f, 0.02825255f, 0.00854394f, 0.03443053f, 0.14661528f, 0.01240974f, -0.16992107f, 0.26656359f, 
    0.04717668f, -0.08568478f, 0.04305936f, -0.00689109f, 0.14716704f, -0.02113025f, -0.00024577f, -0.00791731f, 
    -0.01260102f, 0.22512789f, -0.03599745f, -0.12919566f, -0.05464039f, 0.13394004f, -0.00252770f, -0.01747912f, 
    -0.00621729f, 0.13019447f, 0.05887168f, -0.04842630f, -0.13028404f, -0.00070517f, -0.16107754f, -0.17349377f, 
    -0.14949991f, -0.17809016f, 0.11861070f, -0.02488560f, -0.20430355f, -0.01751899f, 0.00982116f, -0.06376907f, 
    -0.04158125f, -0.12276623f, -0.19717681f, 0.02016173f, -0.04358281f, -0.12223911f, -0.01027802f, 0.19842871f, 
    0.03700421f, -0.06855916f, 0.03548582f, 0.16346858f, 0.15450296f, -0.01094652f, -0.21335071f, -0.46754318f, 
    0.10990892f, 0.02427337f, -0.07693163f, 0.10368710f, 0.08442317f, 0.05774536f, -0.09301320f, 0.08754379f, 
    -0.06578786f, 0.01273960f, -0.02810067f, 0.06919029f, -0.04725112f, 0.03679055f, -0.06766418f, 0.04650010f, 
    0.05076192f, 0.00910250f, 0.06264879f, -0.06865370f, -0.03958141f, 0.02784866f, -0.00990058f, 0.06750943f, 
    -0.03376346f, -0.02034442f, -0.01329690f, 0.05768688f, 0.01414272f, -0.01656762f, -0.02735882f, -0.04536308f, 
    -0.02539248f, 0.05123098f, -0.03175377f, 0.01490636f, -0.01035474f, -0.01542494f, 0.05287035f, -0.02809047f, 
    -0.02261233f, 0.00630840f, -0.00356844f, -0.02671591f, 0.07198642f, 0.00633953f, -0.02412822f, -0.01420576f, 
    0.01693700f, -0.02707345f, 0.06394041f, -0.05162970f, 0.04228930f, -0.02286421f, 0.01891298f, -0.05319132f, 
    -0.05513204f, -0.04696941f, -0.05372151f, -0.04529702f, -0.03454365f, -0.05611564f, -0.00522008f, 0.00678771f, 
    -0.04825483f, 0.03705597f, -0.04354890f, -0.02680863f, 0.03328147f, 0.01655266f, 0.04432260f, -0.00868732f, 
    0.03910640f, -0.07793362f, -0.00311766f, -0.02949388f, 0.04853087f, -0.04375181f, -0.00748801f, 0.04762092f, 
    -0.06635866f, 0.01742491f, -0.03594879f, -0.00451950f, 0.02381948f, 0.04873355f, -0.03049640f, 0.04305380f, 
    -0.07206064f, -0.05865689f, 0.06546608f, -0.06521517f, -0.03067192f, 0.00256304f, 0.00567206f, -0.03593207f, 
    0.03607898f, -0.02561877f, 0.02275716f, -0.00116769f, -0.06659109f, -0.05092742f, 0.04640988f, -0.04668124f, 
    -0.07815169f, 0.01560143f, -0.03853434f, -0.01432147f, -0.07275548f, -0.00435639f, 0.03811677f, 0.01726849f, 
    0.04869163f, 0.05544427f, -0.06205692f, -0.04774893f, -0.03205725f, 0.03904932f, -0.02325554f, 0.00210214f, 
    -0.01530568f, -0.05584747f, 0.01442228f, -0.01349288f, 0.02435051f, -0.03110964f, 0.01276620f, 0.02254768f, 
    -0.06304005f, -0.00396374f, 0.00629114f, -0.03814507f, -0.02874519f, -0.02176403f, 0.05666151f, -0.03149623f, 
    -0.01774294f, -0.02960283f, -0.05233403f, 0.05502059f, 0.04124929f, -0.01743218f, 0.02190246f, 0.00913465f, 
    0.02799841f, 0.05483139f, -0.03954949f, -0.00559148f, -0.05727362f, 0.02837612f, 0.00896031f, 0.05516988f, 
    -0.05412908f, -0.06915215f, 0.05630987f, -0.08516590f, -0.04880054f, -0.04132311f, -0.03973940f, -0.04635426f, 
    0.01478941f, -0.05254547f, 0.02233312f, -0.06319731f, -0.00073066f, 0.04609401f, -0.02488659f, -0.05665728f, 
    0.05832827f, -0.02914714f, -0.03085047f, -0.01143733f, 0.06326614f, 0.00555840f, -0.07573090f, 0.02985156f, 
    -0.06206907f, 0.05134917f, 0.04759639f, -0.01847675f, -0.08143141f, -0.06447391f, 0.05606030f, 0.01283888f, 
    0.03173558f, 0.00801154f, 0.03479237f, 0.03231989f, -0.07519364f, -0.01995794f, 0.00622729f, -0.03891728f, 
    -0.04060229f, 0.01846465f, 0.01464417f, -0.06220629f, -0.03536877f, 0.02359287f, -0.07699566f, -0.02832390f, 
    -0.07727377f, -0.03826823f, -0.02231876f, -0.07446993f, -0.04797868f, -0.02996173f, -0.06478717f, -0.00690161f, 
    -0.02641878f, -0.06067427f, -0.02598305f, -0.05729574f, -0.05410203f, 0.05202528f, -0.05778816f, -0.06929711f, 
    0.00625087f, 0.00101453f, 0.00139984f, -0.01443157f, -0.02939438f, 0.03111548f, -0.04249184f, 0.03582506f, 
    0.00036719f, -0.06170107f, 0.06014295f, -0.04622097f, 0.00402888f, -0.06531248f, -0.00310038f, 0.05971706f, 
    -0.01236784f, 0.05862622f, 0.00437575f, -0.05721619f, -0.00477440f, -0.04840932f, -0.05194830f, -0.00924915f, 
    -0.00783063f, -0.03425519f, 0.04616321f, -0.01199724f, -0.05503536f, 0.05236177f, 0.01953785f, -0.03505728f, 
    -0.06550170f, -0.01982317f, -0.03612716f, 0.02432900f, 0.02129898f, -0.06832816f, 0.05780014f, -0.01617745f, 
    0.02471793f, -0.01312948f, -0.04883580f, 0.06018753f, -0.02590439f, -0.07216523f, -0.07071672f, -0.07276233f, 
    -0.02692644f, -0.04368567f, 0.04565550f, 0.01404713f, 0.01780186f, -0.01936021f, -0.07561149f, 0.02753113f, 
    0.05038782f, 0.00713780f, -0.05561612f, 0.01633438f, 0.03270081f, 0.03247155f, -0.01820181f, 0.01956117f, 
    0.01746344f, 0.04139411f, 0.00291163f, -0.04811678f, -0.03049645f, 0.03060586f, -0.03068052f, -0.05709642f, 
    -0.00649270f, -0.05819485f, 0.03582333f, -0.04753711f, 0.02471177f, -0.04827808f, -0.03142746f, 0.01287467f, 
    -0.01550975f, -0.06729215f, 0.06170559f, 0.00818838f, -0.04978160f, 0.02205825f, -0.04948680f, 0.03819894f, 
    -0.02207273f, -0.00267554f, -0.03818543f, -0.01537372f, -0.03153767f, 0.04220204f, 0.03849207f, -0.03296177f, 
    -0.02135798f, -0.06740719f, 0.06590480f, -0.01296058f, -0.06578577f, 0.03820024f, -0.03787690f, 0.00636087f, 
    0.04701772f, 0.00322801f, 0.01266401f, 0.03376271f, -0.01163696f, 0.04977561f, 0.04546916f, 0.04380390f, 
    0.02686156f, -0.06491727f, 0.00898161f, -0.03983779f, 0.03594644f, -0.02901273f, 0.00050465f, 0.06104349f, 
    0.06521298f, 0.04237628f, 0.03418914f, 0.06366965f, -0.07282355f, -0.03832459f, 0.04280836f, -0.04603008f, 
    -0.04916791f, 0.01551258f, -0.06367185f, -0.07227705f, 0.01403491f, -0.01783651f, 0.03842593f, -0.01803198f, 
    -0.02429499f, -0.06329759f, -0.00772565f, -0.02295233f, -0.02918031f, -0.05855391f, -0.03825954f, 0.01411345f, 
    -0.02198282f, -0.05130515f, -0.01436378f, -0.05258493f, -0.01633475f, -0.05697456f, 0.01036721f, -0.00788393f, 
    -0.07434744f, -0.00370246f, -0.05360889f, 0.00857138f, -0.02085923f, 0.00798875f, -0.03214573f, 0.04720123f, 
    0.04065999f, 0.00893441f, -0.06906149f, 0.01696981f, -0.01739429f, 0.04614187f, -0.04264522f, -0.00502839f, 
    0.02525603f, -0.01047983f, 0.03197265f, 0.01371294f, -0.03469557f, -0.01410270f, -0.05886303f, 0.02924297f, 
    -0.02394444f, 0.05867496f, 0.04162193f, -0.18463342f, 0.09487731f, 0.00555475f, 0.00535248f, 0.07695148f, 
    0.09999512f, 0.21967731f, 0.02819441f, -0.00765875f, 0.31233937f, 0.00418687f, 0.17000322f, -0.04637657f, 
    0.00808729f, -0.00742556f, 0.01311811f, -0.02462680f, -0.11212430f, 0.08703358f, 0.07634314f, 0.08423889f, 
    -0.05594103f, -0.13553771f, 0.21378253f, 0.07544643f, -0.16062178f, 0.08141391f, 0.07768639f, 0.08631972f, 
    -0.06043529f, 0.01609868f, 0.02466350f, 0.15261059f, 0.44064730f, -0.07184263f, -0.06110136f, 0.14955601f, 
    -0.06858399f, 0.02375510f, -0.04275701f, 0.01639344f, 0.00762240f, 0.03128745f, -0.10866959f, 0.00517880f, 
    0.36733747f, -0.05328210f, -0.02319032f, 0.10850848f, 0.20228437f, 0.04096355f, 0.04071344f, -0.16273728f, 
    0.01899245f, 0.09819403f, 0.03987387f, 0.16840620f, -0.04303367f, -0.02554153f, -0.07373704f, -0.01292266f, 
    -0.02497589f, -0.02662647f, 0.03115438f, -0.22458024f, 0.00312382f, -0.03728695f, -0.00149917f, -0.03536745f, 
    0.42539614f, 0.10024433f, 0.08173237f, -0.06306593f, -0.03652063f, 0.00877646f, -0.09147543f, -0.03085145f, 
    -0.07312567f, -0.06449065f, 0.01673248f, -0.02397514f, 0.15513864f, -0.09171841f, -0.15211582f, 0.07857727f, 
    0.01884520f, 0.04736338f, 0.04886108f, 0.09682940f, -0.02224543f, -0.01248564f, -0.10536290f, -0.10126274f, 
    -0.04420047f, -0.08840065f, -0.04652684f, -0.03653912f, -0.07236608f, 0.00557523f, -0.04999528f, -0.00960450f, 
    0.05348445f, -0.08525139f, -0.01368245f, -0.12638651f, 0.21092646f, 0.03680551f, 0.09010330f, -0.06670625f, 
    0.01042430f, 0.03536002f, -0.18188469f, 0.01648605f, -0.01028114f, -0.09218261f, 0.08038004f, 0.09252425f, 
    0.13377678f, 0.04755331f, -0.11911388f, -0.11742671f, -0.20126081f, -0.03749960f, -0.03828301f, 0.04401554f, 
    0.05497503f, 0.20241950f, 0.04835488f, 0.04785976f, 0.05673343f, -0.11011846f, 0.06046513f, 0.13304760f, 
    -0.11390353f, 0.08565280f, -0.13399658f, -0.12625590f, 0.03076557f, -0.06638274f, 0.19000535f, 0.00817180f, 
    0.20288679f, 0.10473470f, -0.16974068f, 0.19006634f, -0.08854854f, 0.06799737f, -0.02609251f, 0.07310760f, 
    -0.11896452f, 0.04578017f, 0.00487528f, -0.08640524f, 0.12036642f, 0.12325181f, -0.19042860f, 0.30983174f, 
    0.12166076f, -0.00577561f, -0.01137448f, -0.04160643f, 0.00428367f, -0.03086349f, -0.09702400f, -0.17123026f, 
    0.12375608f, -0.04116121f, -0.05753351f, -0.24903259f, -0.00610245f, 0.03508485f, -0.03784762f, -0.08243448f, 
    0.08427907f, -0.20074709f, 0.16827868f, -0.08232858f, 0.06479956f, 0.08201078f, 0.17740563f, 0.04767112f, 
    0.06227313f, -0.08727033f, 0.14006680f, 0.19610141f, -0.08871356f, 0.09372402f, 0.01880294f, 0.01748370f, 
    -0.06208431f, -0.04494257f, 0.04863305f, 0.03329183f, -0.03860191f, -0.00666211f, 0.04761093f, 0.02703501f, 
    -0.00908501f, -0.02806790f, 0.02559283f, -0.03202851f, 0.00987172f, 0.02943516f, -0.01281738f, -0.02818099f, 
    0.04713513f, 0.01875321f, -0.03908765f, -0.06754477f, 0.01723001f, -0.03350123f, 0.05673903f, 0.02693575f, 
    0.01293842f, -0.05032726f, -0.04135865f, 0.03296401f, 0.00813219f, -0.02939101f, 0.03498860f, 0.01039996f, 
    -0.03798492f, -0.04321581f, -0.04025267f, 0.00589513f, -0.02928225f, -0.04376407f, -0.02829296f, -0.01922305f, 
    0.00682216f, -0.01962361f, -0.02760561f, 0.03821837f, -0.03385573f, -0.01725041f, 0.06190486f, -0.00551320f, 
    0.00027440f, 0.03690649f, 0.04403511f, -0.05940356f, 0.03144602f, -0.01431615f, -0.00490067f, -0.03898926f, 
    -0.03883698f, 0.03166591f, 0.05324059f, -0.06095668f, -0.02933188f, -0.00378805f, -0.03853978f, -0.02762049f, 
    -0.00020363f, -0.07090780f, 0.04372879f, 0.03871915f, 0.00244683f, 0.04429214f, 0.01149753f, -0.02849508f, 
    0.00679488f, 0.04174459f, -0.03853864f, 0.04697944f, 0.00649947f, 0.03419223f, -0.00575778f, 0.03564364f, 
    0.02190366f, 0.05155061f, 0.04706035f, 0.00549699f, -0.01377392f, -0.00542938f, 0.00225247f, -0.01510935f, 
    -0.05230245f, -0.07035209f, -0.06917930f, 0.02711826f, -0.05235318f, -0.05717915f, -0.02837770f, 0.01572845f, 
    -0.00847744f, -0.07722174f, 0.04977897f, 0.01116442f, -0.02718068f, -0.03597079f, -0.03753160f, -0.00547053f, 
    0.02989250f, -0.04581843f, -0.00289388f, 0.05481028f, 0.05300632f, -0.06628047f, -0.06533906f, -0.05684489f, 
    0.02302908f, -0.01909744f, -0.07429248f, -0.02433294f, -0.01940075f, -0.01993689f, 0.04729624f, -0.05263140f, 
    -0.03438137f, -0.01128026f, 0.05968478f, -0.05094144f, 0.05659759f, -0.05054334f, -0.04055244f, -0.00529351f, 
    0.05895118f, -0.00275739f, -0.00027860f, -0.04011496f, 0.06342465f, 0.00844487f, -0.00098957f, -0.05486518f, 
    -0.07542527f, 0.02417077f, -0.06689314f, 0.03908615f, -0.07209447f, -0.07481317f, -0.07539464f, -0.07017621f, 
    -0.02702992f, -0.04816496f, -0.05640875f, -0.04283713f, 0.03098018f, -0.01010222f, -0.05449414f, 0.03007895f, 
    -0.01564516f, -0.01978880f, -0.02930250f, -0.05935157f, -0.04655944f, -0.00720289f, 0.05451420f, -0.01594475f, 
    0.06352062f, 0.03509164f, -0.00708454f, 0.00219633f, 0.03287875f, 0.03191910f, 0.03030549f, -0.00595669f, 
    -0.00031681f, 0.05531418f, -0.05038983f, -0.05634983f, -0.03508611f, 0.00456963f, 0.05618408f, -0.06111084f, 
    -0.03422174f, -0.05009075f, -0.01304238f, -0.07552414f, 0.05699962f, -0.07742141f, -0.06671271f, 0.01232442f, 
    0.04877389f, 0.02097106f, -0.07373235f, -0.04760909f, 0.00550201f, -0.00652643f, -0.03880952f, 0.01678189f, 
    -0.17722929f, 0.11234843f, -0.00572480f, 0.32505468f, -0.09697402f, 0.06226817f, -0.08893827f, -0.03958203f, 
    -0.03773572f, -0.00808843f, -0.01004152f, -0.00782915f, 0.00250227f, 0.37566003f, 0.00433501f, -0.12070194f, 
    0.19036599f, 0.06563473f, 0.01094854f, -0.04775563f, 0.00700328f, 0.11321649f, 0.17812583f, 0.08339039f, 
    0.08200103f, 0.28653887f, -0.05113284f, -0.25171831f, 0.11075318f, 0.13725327f, 0.04584879f, 0.15196496f, 
    -0.00828564f, -0.05736278f, 0.07458103f, 0.08186997f, -0.09926768f, 0.20518415f, -0.03008213f, 0.00747212f, 
    -0.04324847f, 0.05554949f, 0.10675361f, 0.14497465f, 0.05494081f, -0.03579978f, 0.04312684f, 0.04695278f, 
    -0.47041714f, -0.02588588f, 0.04111845f, -0.10999223f, -0.21547116f, 0.03348320f, -0.15849422f, -0.08142830f, 
    0.02334828f, -0.11483081f, 0.08565362f, -0.31233621f, -0.20252718f, -0.14548285f, -0.00661075f, 0.18086261f, 
    0.17137519f, -0.06788932f, -0.08634949f, -0.18861842f, -0.02176619f, -0.03028340f, 0.09882309f, -0.03298239f, 
    -0.63464588f, -0.15172224f, 0.02219447f, 0.14739232f, 0.00234705f, 0.08015426f, 0.07805295f, -0.10096215f, 
    0.08921695f, -0.02691276f, -0.18257058f, -0.06206362f, -0.37839094f, -0.01440103f, 0.02815929f, 0.17480873f, 
    0.10559976f, -0.12492175f, -0.04116140f, 0.03903153f, -0.04648290f, -0.07176197f, -0.09768277f, -0.04609048f, 
    0.14653158f, 0.16155486f, 0.19297978f, -0.03750522f, -0.17594691f, -0.01369886f, 0.01662562f, -0.09217159f, 
    0.04867321f, -0.00678350f, -0.00726472f, 0.04280422f, 0.23953159f, -0.08473617f, -0.14306369f, 0.18905047f, 
    0.20987339f, 0.01794220f, 0.21326660f, -0.06945933f, -0.06522322f, 0.18079726f, 0.16859034f, 0.03628634f, 
    0.03451969f, 0.02185174f, 0.17346838f, 0.08921582f, 0.19602360f, 0.20017520f, 0.05599408f, -0.07354289f, 
    -0.11275782f, 0.02109347f, -0.10195494f, 0.08649776f, -0.22603562f, 0.10255588f, 0.12380120f, -0.05435464f, 
    0.02865740f, -0.05388234f, -0.05727862f, -0.07032473f, -0.05500083f, -0.12531780f, 0.00424498f, -0.09927337f, 
    -0.30766666f, -0.07902794f, -0.03182594f, 0.05033408f, 0.04963085f, 0.09368414f, 0.03657648f, -0.13032052f, 
    0.09149043f, -0.11928824f, -0.23968692f, -0.01384795f, -0.04492499f, -0.17678502f, 0.04333852f, -0.05026908f, 
    -0.08145343f, -0.00934905f, 0.04464356f, 0.02284061f, 0.15553494f, 0.00186251f, -0.00934171f, 0.01122681f, 
    0.16843201f, 0.34153906f, 0.47841948f, -0.00708286f, -0.05445692f, 0.07856168f, 0.01991590f, 0.11183760f, 
    0.17933035f, 0.19159217f, -0.14976838f, -0.04921416f, 0.10743896f, 0.23624146f, -0.28236595f, -0.19204745f, 
    0.04596696f, 0.03399796f, 0.05533798f, -0.12302269f, -0.08553265f, 0.15222305f, 0.05358983f, -0.15635329f, 
    0.06037794f, -0.02839532f, 0.03645756f, 0.03007168f, 0.03663622f, 0.02228095f, -0.08139941f, -0.04464966f, 
    -0.05041269f, -0.03627852f, -0.06572171f, 0.03477804f, -0.04851517f, 0.03571083f, -0.05528702f, 0.00755845f, 
    -0.06063248f, -0.05714400f, -0.06029868f, -0.00066457f, -0.06041914f, -0.05242050f, -0.00376168f, -0.03465175f, 
    -0.07763135f, -0.01837104f, 0.02277351f, -0.02826487f, 0.03927287f, 0.02170794f, 0.04585992f, -0.01888979f, 
    -0.00423079f, -0.01002659f, 0.01254283f, 0.04239849f, 0.02403852f, 0.02669035f, -0.02789751f, -0.05174538f, 
    -0.01787117f, -0.01526730f, -0.04086428f, -0.02077291f, -0.01262551f, -0.07570010f, 0.00358209f, 0.02457220f, 
    0.05813894f, -0.04914396f, -0.06933259f, 0.01400512f, -0.00226680f, -0.04513349f, -0.00666257f, 0.06196442f, 
    0.01505914f, 0.06343402f, -0.02722816f, -0.07102043f, 0.05559178f, 0.03041816f, -0.03150044f, -0.00407453f, 
    0.04715711f, -0.02330109f, 0.03830853f, -0.00186991f, -0.06308967f, -0.00113738f, 0.03553209f, -0.04690372f, 
    -0.03603875f, -0.02361069f, -0.02988663f, 0.04829644f, -0.00919836f, -0.07718972f, -0.05091634f, -0.00691324f, 
    -0.01244904f, 0.05280324f, -0.07104149f, -0.05509286f, 0.02550092f, -0.03333284f, 0.00685348f, -0.01406728f, 
    -0.03532285f, 0.00509818f, -0.03224179f, 0.04482207f, 0.05165706f, 0.03304829f, -0.06764009f, -0.01051187f, 
    -0.01057020f, -0.02165612f, -0.02472718f, 0.02370193f, 0.00947466f, -0.06993511f, -0.00860090f, 0.03627510f, 
    0.05423752f, -0.05257208f, 0.03280365f, -0.07610110f, 0.05868856f, -0.04293847f, -0.07255147f, -0.00701660f, 
    0.03813070f, 0.01383955f, -0.04336010f, -0.04476496f, 0.03958588f, -0.02352594f, -0.04456746f, 0.05583062f, 
    -0.01947296f, -0.03674456f, -0.01334522f, 0.03240609f, 0.03246085f, -0.06004618f, 0.04302365f, 0.03560005f, 
    -0.00565434f, -0.01404844f, 0.01461733f, -0.04936923f, -0.07281306f, -0.01713962f, -0.05008509f, 0.00244440f, 
    0.01123998f, -0.01533797f, -0.02465484f, 0.05121315f, 0.02594670f, -0.03561062f, 0.01689078f, 0.01054557f, 
    0.06104816f, -0.02005049f, 0.02809160f, -0.05475225f, -0.05631290f, 0.04822281f, -0.06359423f, -0.06698292f, 
    0.03634975f, 0.06074815f, -0.05521356f, 0.05671309f, -0.05026063f, -0.05262676f, 0.01174648f, -0.05127748f, 
    0.04345205f, 0.04234633f, -0.06079325f, -0.06372658f, -0.05474941f, 0.05476480f, 0.02413240f, 0.06130057f, 
    0.00178643f, -0.04895694f, -0.06886473f, -0.03363933f, 0.05038312f, 0.02682171f, -0.03315789f, -0.02143302f, 
    0.00648519f, 0.00005082f, 0.02043528f, -0.03737642f, 0.05725615f, -0.02131644f, -0.04458468f, -0.06104744f, 
    0.05284654f, 0.00403345f, -0.07801645f, 0.06080176f, -0.06615659f, -0.03973834f, -0.05058963f, -0.05865520f, 
    0.17728667f, -0.04434899f, -0.10764052f, -0.04318368f, -0.02321041f, 0.10410821f, 0.11718492f, 0.07377911f, 
    0.00086730f, 0.03663724f, 0.01550915f, -0.09897403f, -0.01033306f, -0.06743310f, 0.05398466f, -0.01334987f, 
    -0.00215776f, -0.02537356f, -0.06372599f, 0.16708258f, 0.05889883f, 0.10497383f, -0.01084780f, 0.05785081f, 
    -0.15811849f, -0.08875257f, -0.01398501f, 0.07878834f, -0.11118895f, -0.05939081f, 0.04703008f, -0.02250397f, 
    0.08023302f, -0.06214643f, 0.13492878f, 0.16579415f, 0.07564152f, -0.04793691f, -0.09745850f, 0.08474118f, 
    -0.03858266f, 0.12167011f, 0.12506053f, 0.01862590f, 0.10115734f, 0.07079431f, -0.04802969f, 0.05004496f, 
    -0.00075239f, 0.12510788f, 0.02617377f, 0.17610978f, -0.09978203f, -0.09170134f, 0.13130303f, -0.07427094f, 
    -0.07814967f, 0.04627546f, 0.04648481f, 0.08176616f, 0.18004245f, -0.05307531f, 0.13293815f, 0.24838971f, 
    -0.07560358f, 0.07492972f, -0.00077021f, -0.04204616f, 0.08911289f, -0.02119409f, 0.00311064f, 0.06695950f, 
    -0.07893704f, 0.20059337f, -0.09188866f, 0.07461441f, -0.07426015f, 0.00700980f, 0.08682568f, 0.02687443f, 
    0.05064837f, 0.05384377f, -0.01300638f, -0.17003991f, 0.29248127f, -0.00928124f, 0.05746303f, 0.04791807f, 
    -0.04367550f, -0.06153616f, 0.00326068f, 0.05353353f, 0.02750984f, -0.00596724f, 0.00884844f, 0.03513076f, 
    -0.13695465f, -0.06476858f, -0.02820627f, 0.02704373f, -0.01276312f, 0.17477511f, -0.01755006f, 0.08787636f, 
    0.04951408f, -0.12805438f, -0.07212842f, -0.05533948f, 0.07652193f, -0.08658317f, 0.01327972f, -0.27818909f, 
    -0.16085497f, -0.12681362f, -0.02417142f, 0.13358818f, -0.13441946f, -0.06682027f, -0.08590325f, 0.03706628f, 
    -0.01263597f, 0.14636840f, -0.03939066f, -0.01843773f, 0.01857952f, -0.01886925f, 0.17553656f, 0.13292806f, 
    -0.00036252f, 0.14221358f, -0.07601517f, 0.08126017f, -0.13828611f, -0.00952176f, 0.05375669f, 0.16287951f, 
    -0.01218113f, -0.05541466f, -0.02104491f, -0.00536136f, -0.01450823f, 0.05774123f, 0.07765283f, -0.01716888f, 
    0.34764364f, -0.07187701f, -0.09122814f, 0.16813378f, -0.09097316f, 0.05569095f, -0.04690886f, 0.13830520f, 
    -0.01983343f, -0.04070046f, 0.09142510f, 0.00158168f, 0.50449157f, 0.09911214f, 0.09105609f, 0.10599200f, 
    0.05115975f, 0.11774714f, -0.08543621f, 0.07600423f, 0.07469711f, -0.00270594f, -0.00818112f, 0.00231654f, 
    -0.32422465f, 0.03248260f, 0.19521889f, -0.08211129f, 0.08513114f, -0.03220132f, -0.01068307f, -0.04772903f, 
    -0.03984642f, 0.03821429f, -0.02400242f, 0.07054703f, -0.14893225f, -0.12217351f, -0.04896034f, 0.03644613f, 
    -0.05173042f, -0.07712140f, -0.00913849f, 0.05524149f, 0.01981133f, -0.00492785f, 0.05055042f, 0.17970367f, 
    -0.05425115f, -0.06275027f, 0.01772665f, -0.03843941f, -0.02041537f, 0.05645150f, 0.00182433f, 0.06170031f, 
    -0.05776454f, 0.05519750f, 0.02113024f, -0.02707769f, 0.03576522f, 0.04363947f, -0.01021864f, 0.03931451f, 
    -0.00763360f, -0.02307267f, -0.07796831f, 0.05183654f, 0.06153590f, -0.04578668f, 0.03922737f, -0.01167206f, 
    0.00093379f, -0.05277086f, -0.00830367f, -0.03992658f, -0.04060022f, -0.00800796f, 0.00236982f, -0.03037305f, 
    0.05898093f, 0.04551430f, 0.05297694f, 0.04562067f, -0.07312822f, -0.04764388f, -0.04603717f, 0.03982043f, 
    -0.04695885f, -0.06855021f, -0.05802380f, -0.07422750f, -0.03831296f, -0.05843768f, 0.03653504f, 0.01646840f, 
    0.01199739f, 0.01900432f, 0.00029848f, 0.02848346f, -0.03932969f, 0.04676184f, -0.01719306f, -0.00844813f, 
    0.06478257f, 0.02566293f, 0.00569377f, 0.04913964f, 0.00732410f, 0.03224510f, 0.04329994f, 0.04606614f, 
    0.06460732f, 0.00058173f, 0.05429919f, -0.07492264f, 0.00856991f, -0.01447046f, 0.04380787f, -0.02924357f, 
    -0.01239561f, -0.07852641f, 0.01463010f, -0.06996657f, -0.06503849f, 0.00965997f, -0.04608042f, -0.02022026f, 
    -0.03783332f, 0.01044485f, -0.02939228f, -0.04868587f, 0.03533506f, -0.07673561f, -0.06238440f, 0.00091607f, 
    -0.06098075f, -0.01505363f, -0.05077394f, -0.02882537f, -0.06430398f, 0.00565748f, 0.06868912f, -0.03095434f, 
    -0.02361136f, 0.02155224f, -0.07726697f, -0.06465602f, -0.03668017f, 0.01242698f, -0.04573613f, -0.06431580f, 
    0.04575983f, -0.01960038f, 0.01114283f, -0.02415352f, -0.04316450f, 0.04583014f, -0.00408991f, 0.01519164f, 
    -0.00025054f, -0.02662088f, -0.03971644f, 0.01017779f, -0.04323620f, -0.05591328f, 0.03839275f, -0.06668359f, 
    -0.05949235f, -0.02438385f, -0.04173271f, -0.07057907f, 0.03534820f, -0.01998192f, 0.03924556f, 0.04070320f, 
    0.01629144f, 0.04522040f, 0.00640918f, 0.01872724f, -0.00452824f, -0.04041508f, -0.06319592f, -0.02029321f, 
    -0.01183946f, -0.01325409f, -0.06473804f, -0.05048743f, -0.03154253f, -0.02877920f, -0.06975022f, 0.00447689f, 
    0.00618266f, 0.01863410f, -0.05830961f, 0.00421258f, -0.06630419f, -0.05213193f, -0.05369410f, -0.03250099f, 
    -0.04607910f, 0.06535463f, -0.06579069f, -0.05525986f, 0.00644906f, -0.01523861f, -0.03643718f, -0.07486738f, 
    -0.06896378f, -0.00741648f, -0.05649203f, -0.04292836f, -0.06421895f, 0.00265349f, -0.05723828f, 0.05366025f, 
    -0.00802411f, -0.04722091f, -0.03243921f, 0.05711509f, -0.03764906f, 0.05666397f, -0.07125463f, -0.00903936f, 
    0.05774888f, -0.00848453f, 0.00790609f, -0.00453667f, -0.02569570f, 0.00662083f, -0.04417182f, 0.05789984f, 
    -0.02681469f, -0.03649703f, -0.04237689f, 0.05905889f, 0.01105223f, -0.07751293f, -0.00663738f, 0.01439807f, 
    0.02413488f, 0.05027167f, 0.00229072f, 0.04312784f, -0.05399821f, -0.05032130f, -0.04872376f, -0.04016936f, 
    -0.01964013f, 0.06539742f, -0.07041981f, 0.02112519f, -0.01300354f, -0.06580722f, 0.05912811f, -0.01798601f, 
    0.05192471f, -0.07349771f, -0.04469401f, -0.01496302f, -0.06576458f, -0.06102226f, -0.01849791f, -0.03441663f, 
    -0.03332149f, -0.05755219f, 0.06359482f, 0.02801449f, -0.05007877f, 0.02392226f, 0.04955848f, -0.01177531f, 
    -0.02298137f, -0.03911045f, -0.06855565f, -0.01481057f, -0.01423860f, -0.04898204f, -0.01285449f, -0.04433250f, 
    -0.06300217f, -0.06504694f, 0.04769119f, -0.01290180f, 0.04647429f, -0.01205684f, -0.04615762f, -0.07497910f, 
    0.02613257f, -0.04154184f, 0.06455676f, -0.04354299f, 0.04430810f, 0.00027546f, -0.03720132f, -0.01577608f, 
    0.02766424f, 0.03304038f, 0.01681792f, -0.03358300f, -0.04116401f, -0.05357007f, -0.04340757f, 0.05230347f, 
    0.04617478f, 0.01424658f, -0.02945855f, 0.02468891f, -0.03284984f, 0.04804522f, -0.01323110f, -0.05708238f, 
    -0.02458923f, -0.03793985f, -0.07171883f, 0.00485378f, -0.06840855f, -0.03305154f, -0.06213791f, -0.05026774f, 
    -0.01834400f, 0.05704902f, -0.00941784f, -0.04752246f, -0.02982151f, 0.02418225f, -0.03274429f, -0.02470822f, 
    0.05867947f, -0.05459711f, -0.06419319f, -0.05804640f, -0.02263823f, 0.04565899f, 0.06147729f, -0.05125166f, 
    -0.01266260f, 0.01454838f, 0.01171335f, -0.00321660f, -0.04778249f, 0.00915851f, -0.00394356f, 0.05214210f, 
    0.00745485f, -0.00688277f, 0.02704426f, 0.01519943f, -0.02078895f, 0.05015834f, -0.06081823f, -0.02971342f, 
    -0.01209094f, -0.07379335f, -0.02070439f, -0.07236585f, 0.00654353f, 0.05543329f, -0.04894855f, -0.00834243f, 
    0.05476612f, -0.01804818f, -0.04322527f, -0.06836131f, -0.05696714f, -0.01625561f, -0.00181559f, -0.03108093f, 
    -0.01608395f, -0.05319151f, 0.01898419f, -0.01375736f, 0.04912887f, 0.06153065f, -0.03162333f, 0.01789828f, 
    0.06446632f, 0.01305139f, 0.03034036f, -0.04818567f, -0.03797822f, -0.07109559f, -0.00048060f, 0.04155625f, 
    -0.05944116f, 0.05653562f, 0.01583957f, -0.07468398f, 0.02456773f, 0.03077887f, 0.03199638f, 0.01220796f, 
    -0.01670200f, -0.05387495f, -0.02697411f, -0.06658202f, -0.05786503f, 0.06194710f, 0.05924873f, 0.00753572f, 
    -0.05268253f, -0.01983409f, 0.03235075f, 0.04462569f, -0.04786823f, -0.02193662f, 0.01839890f, -0.07163731f, 
    -0.02302105f, 0.01467128f, -0.03182281f, 0.02672986f, -0.06091467f, -0.01750669f, 0.06456864f, 0.02150861f, 
    0.05362057f, -0.06838731f, 0.00727021f, 0.04729986f, 0.02478790f, -0.06943846f, 0.00178581f, -0.01330243f, 
    -0.06562083f, 0.02385947f, -0.06006267f, 0.03452084f, -0.04869055f, 0.02178617f, 0.04019719f, 0.04049796f, 
    0.05615000f, 0.14684114f, 0.01727454f, -0.03580153f, -0.04179253f, 0.18707134f, -0.03262644f, 0.01737067f, 
    0.04764690f, 0.07458324f, 0.02172986f, -0.03177581f, 0.16395843f, -0.14353740f, 0.07043727f, -0.07111183f, 
    -0.12640823f, 0.03826561f, 0.04557370f, 0.00446712f, -0.07428636f, 0.04681525f, -0.10606343f, 0.10116154f, 
    -0.36681849f, -0.05505370f, 0.03944570f, 0.06810582f, -0.02867950f, -0.03120621f, 0.03250436f, 0.08466674f, 
    0.12754129f, -0.03632304f, -0.00102897f, 0.21365343f, 0.02566751f, -0.10698014f, -0.12103327f, 0.03782532f, 
    -0.12955053f, 0.06906718f, 0.07637313f, 0.04182383f, 0.05338335f, -0.05281577f, -0.06037286f, 0.01534771f, 
    0.03117270f, -0.07668901f, 0.02317160f, 0.19437054f, 0.05227198f, 0.05122097f, 0.15724452f, -0.08959979f, 
    0.01561740f, -0.00187320f, -0.09006335f, 0.00402346f, 0.15416792f, -0.09604830f, 0.08896796f, 0.07159383f, 
    -0.06317193f, 0.01254252f, 0.01664410f, -0.04915133f, -0.03097317f, 0.03369376f, 0.03036789f, -0.06233929f, 
    0.07703009f, 0.24872449f, -0.01125220f, 0.03922390f, -0.12063479f, 0.13833563f, 0.06776989f, -0.02344652f, 
    -0.03359440f, 0.07070655f, 0.01597953f, -0.01665644f, 0.13224858f, 0.01944140f, -0.08431262f, 0.15268381f, 
    0.01551121f, -0.03851739f, -0.02541622f, 0.16368158f, -0.08091436f, 0.02912622f, -0.02944939f, -0.04004556f, 
    -0.12595350f, -0.01158971f, -0.00985448f, -0.01260199f, 0.00846351f, 0.07605971f, -0.09398559f, 0.07378844f, 
    0.02035023f, -0.03014023f, -0.05746605f, 0.00783069f, 0.21638794f, -0.19225320f, 0.03757101f, -0.26081941f, 
    -0.16376795f, 0.02945369f, -0.12742276f, 0.08898625f, -0.07088754f, -0.04251337f, 0.00094152f, 0.06900997f, 
    0.10014315f, 0.07002643f, -0.08207118f, -0.06968626f, 0.00718128f, -0.11869769f, 0.08590298f, 0.09071226f, 
    -0.01324487f, 0.19587156f, -0.04408086f, 0.02301218f, 0.13203333f, -0.08826491f, 0.00980536f, 0.10809871f, 
    0.02174398f, -0.04012247f, -0.02554315f, 0.10490742f, 0.00781352f, 0.01938552f, 0.19223224f, -0.07032280f, 
    0.32481593f, -0.06728111f, -0.07976015f, 0.17345367f, -0.08529444f, 0.00684735f, 0.03331323f, 0.09330166f, 
    0.01042800f, -0.00233448f, 0.12764020f, -0.06060871f, 0.22407950f, 0.13417405f, 0.03696791f, 0.09287784f, 
    0.07644132f, 0.14937246f, 0.04120506f, 0.10263663f, 0.02003118f, 0.01247813f, 0.01397051f, -0.06644464f, 
    -0.17399581f, -0.01258882f, 0.04475972f, -0.06173905f, 0.16796409f, 0.03688717f, 0.03348073f, -0.04916244f, 
    0.02676550f, -0.01861263f, -0.04333100f, 0.01411476f, -0.15234828f, -0.04428869f, 0.02661388f, 0.13496847f, 
    -0.02452633f, -0.06638008f, 0.04186168f, 0.16468593f, -0.07115770f, 0.08320925f, -0.00164951f, 0.18815784f, 
    -0.02747894f, 0.13129044f, -0.03923680f, -0.01499862f, 0.02009850f, -0.09559464f, -0.03864912f, 0.01152436f, 
    -0.03932101f, -0.03539829f, 0.08006462f, 0.12406778f, -0.05620904f, -0.15307505f, -0.15907250f, 0.07698530f, 
    0.14228350f, 0.09535585f, -0.06270941f, -0.07242785f, 0.15686475f, -0.03740665f, -0.02443398f, 0.04442108f, 
    0.22711417f, 0.00017430f, 0.00577000f, -0.01884863f, 0.03892052f, 0.10338958f, -0.03491411f, -0.07796126f, 
    0.06891525f, -0.05904810f, -0.06628308f, -0.09786186f, 0.06634083f, 0.03182719f, 0.08249407f, -0.07267607f, 
    0.06846817f, 0.08235124f, -0.16499612f, -0.05335707f, 0.02909958f, -0.02497467f, 0.12781090f, 0.05801317f, 
    0.15552829f, 0.10969809f, 0.08165062f, -0.05915156f, -0.01763729f, 0.08893053f, -0.21037087f, 0.08862258f, 
    -0.00111656f, -0.05602983f, 0.11233795f, -0.13444613f, 0.12236074f, 0.18544532f, -0.07912156f, 0.01134217f, 
    0.11302754f, -0.01543532f, -0.08988855f, 0.20416111f, -0.05611943f, -0.09623230f, 0.02387844f, 0.02624617f, 
    0.37017626f, 0.05079143f, -0.16680397f, -0.08442660f, -0.02430781f, 0.06027993f, -0.04963606f, 0.00162944f, 
    0.02531099f, -0.04482840f, 0.15874098f, 0.14088285f, 0.20871027f, 0.05490168f, 0.26883432f, 0.03858823f, 
    -0.07772867f, 0.07764377f, -0.08153208f, -0.14358407f, 0.03248140f, 0.02412521f, -0.01618860f, 0.04640848f, 
    -0.00607909f, 0.11119709f, -0.11160223f, -0.12081457f, 0.02963155f, -0.10232832f, 0.06465550f, -0.14516050f, 
    -0.06995869f, 0.11728070f, -0.04605677f, 0.07829951f, -0.43144608f, 0.06631741f, 0.06884023f, 0.13562085f, 
    0.03931228f, 0.04230089f, 0.09730992f, 0.01566415f, 0.07116196f, 0.02682335f, 0.02746009f, -0.05285826f, 
    -0.12714989f, -0.10998087f, 0.02045691f, 0.13847856f, -0.00955498f, -0.01806833f, -0.03795645f, -0.17368661f, 
    0.02606544f, -0.30795082f, 0.03372074f, -0.26476362f, 0.02918797f, -0.06823248f, -0.09394738f, 0.03591932f, 
    -0.00693866f, 0.03883251f, 0.06996638f, -0.03174921f, 0.12001058f, -0.08234539f, -0.19937657f, 0.03544923f, 
    0.01646941f, -0.06743864f, 0.27562720f, 0.04226649f, 0.05015318f, 0.04495087f, -0.00277345f, -0.11399368f, 
    -0.04962452f, 0.10529312f, -0.00575903f, 0.13396572f, -0.11375216f, -0.12136880f, 0.06409734f, 0.04965116f, 
    -0.02045337f, -0.12076344f, -0.01550029f, -0.04744506f, -0.03904108f, 0.07292432f, 0.13090557f, 0.08537200f, 
    0.21142992f, -0.06747293f, -0.28726861f, 0.08556650f, -0.04629714f, 0.07112876f, 0.13939777f, -0.02547410f, 
    0.13602164f, 0.17874548f, -0.00116204f, 0.06412245f, 0.25316206f, -0.03298767f, 0.11643764f, 0.02574249f, 
    0.08923463f, 0.10429792f, -0.14771836f, -0.06514885f, 0.04817065f, -0.07305833f, 0.09085796f, -0.06253181f, 
    -0.03556138f, -0.03364794f, -0.03231801f, -0.06588091f, 0.01219941f, -0.01127313f, -0.06663104f, -0.02868376f, 
    0.01115839f, -0.07207563f, 0.06382625f, -0.04819780f, 0.01186020f, -0.04188692f, 0.05050481f, -0.02391317f, 
    -0.01021653f, -0.01935709f, -0.04193277f, -0.02125556f, -0.08191405f, 0.04587654f, 0.01189978f, -0.06850195f, 
    0.01247995f, -0.02815924f, 0.03576850f, 0.05697274f, -0.01713272f, 0.06108733f, -0.04336647f, 0.04735844f, 
    -0.07668753f, 0.03822529f, -0.01266756f, -0.06019048f, 0.06486206f, -0.02375054f, -0.00629012f, -0.03529640f, 
    -0.07327000f, -0.01577830f, -0.02989627f, 0.05326746f, 0.01860358f, -0.07804173f, -0.06755089f, 0.04366200f, 
    0.01994948f, -0.01597881f, 0.02043112f, -0.05221712f, 0.01143132f, -0.00437065f, 0.04426446f, -0.01434239f, 
    -0.06322557f, 0.03214980f, 0.02943010f, -0.00544174f, -0.07367384f, 0.06254520f, 0.03755667f, -0.03702874f, 
    -0.05633655f, -0.06006404f, -0.01593723f, -0.01702001f, 0.05193703f, 0.00256459f, -0.05740331f, -0.06559858f, 
    -0.00911434f, -0.00263368f, -0.06866097f, -0.05583624f, -0.06847872f, -0.05994894f, -0.02318856f, 0.00773134f, 
    0.04821971f, -0.03995346f, -0.03934731f, 0.00684403f, -0.04552622f, 0.03145792f, 0.04199612f, 0.00484150f, 
    0.03451949f, -0.06836618f, 0.04727828f, 0.00348247f, 0.06092091f, 0.03644975f, 0.04642045f, 0.03758756f, 
    -0.02197491f, -0.02134643f, 0.04346955f, 0.01088848f, -0.04524608f, 0.05785359f, 0.04810204f, -0.01527884f, 
    -0.08258858f, 0.01572930f, 0.04604032f, -0.07916687f, -0.05398900f, -0.02788664f, 0.02524706f, 0.01987757f, 
    0.01684876f, 0.01041468f, -0.03790589f, 0.00265082f, -0.03173789f, 0.01551458f, -0.04874801f, -0.00642157f, 
    -0.06629642f, -0.00720419f, 0.02084265f, 0.01999558f, 0.00860667f, 0.06026968f, -0.05689597f, 0.00994458f, 
    0.03272526f, -0.04006378f, -0.02029656f, 0.03740196f, -0.02735318f, -0.01051580f, -0.06678574f, -0.01637223f, 
    0.02037079f, -0.04214600f, -0.02549036f, -0.03122810f, 0.03126539f, 0.01720918f, 0.00786875f, -0.00377153f, 
    -0.03668137f, 0.04048508f, 0.02255312f, 0.01064814f, 0.03117263f, -0.02344374f, -0.06669743f, -0.06189412f, 
    0.02984883f, -0.03297987f, 0.04869590f, 0.03862942f, -0.07258413f, 0.01114217f, 0.03901244f, 0.01858161f, 
    0.02181240f, -0.01530971f, 0.00157714f, -0.03164894f, -0.07285020f, -0.02927376f, 0.00454964f, -0.00153287f, 
    -0.07618567f, -0.07486492f, -0.00262493f, -0.01756284f, -0.04750186f, 0.05092734f, -0.04283563f, 0.05536691f, 
    -0.01768916f, 0.06026047f, -0.00829069f, 0.00279395f, -0.05091321f, -0.02501669f, -0.01610491f, -0.03792400f, 
    0.05594954f, -0.01532600f, -0.05218646f, 0.02067181f, -0.04903543f, -0.04924517f, 0.05933968f, 0.04618670f, 
    -0.28890157f, 0.20703746f, -0.06875245f, 0.13088423f, 0.02363570f, 0.05612857f, -0.10273144f, -0.11487493f, 
    -0.00874448f, -0.10771024f, 0.07602531f, 0.12246054f, -0.08173162f, -0.06846559f, 0.08950224f, 0.16171426f, 
    0.10266358f, 0.06207228f, 0.03143871f, -0.02195473f, 0.14672618f, -0.02488415f, 0.06994920f, -0.00433326f, 
    0.23697075f, -0.03926707f, 0.11854241f, 0.12628704f, 0.09093546f, -0.00554894f, 0.09716422f, -0.12706938f, 
    0.05655023f, 0.04168589f, -0.08602655f, -0.13894437f, -0.14951396f, 0.01354401f, 0.03178957f, -0.21789235f, 
    -0.02281585f, -0.06561986f, 0.12062367f, 0.05556572f, 0.02324718f, 0.05155044f, -0.01520216f, 0.05315598f, 
    0.17262731f, -0.05253103f, -0.01352521f, -0.19106314f, -0.00775608f, -0.04197984f, -0.01400428f, 0.08312703f, 
    0.00205118f, 0.06801035f, -0.04275487f, -0.06849130f, -0.29169899f, 0.01404430f, 0.00928548f, -0.12052525f, 
    0.22436740f, 0.01885817f, -0.13561220f, 0.10517969f, 0.01906345f, -0.01094781f, 0.03237914f, 0.02691560f, 
    -0.04305457f, -0.15504099f, 0.10485616f, 0.24973296f, 0.11025877f, 0.07260533f, 0.00256429f, 0.06474487f, 
    -0.06135124f, -0.04430334f, 0.08910074f, 0.06726795f, -0.19336551f, 0.05723074f, -0.00166391f, 0.06005234f, 
    0.10353782f, 0.00616789f, -0.00879352f, -0.14415067f, 0.09636632f, -0.07280172f, 0.14395863f, 0.07696533f, 
    0.12469073f, 0.13482451f, 0.07930899f, -0.01579563f, 0.08002524f, -0.08936578f, 0.09057631f, -0.01505895f, 
    -0.02669087f, 0.15504916f, -0.07775389f, 0.06095910f, -0.19990516f, -0.07522804f, -0.02000369f, 0.25607473f, 
    0.09428395f, 0.09043819f, 0.10204396f, -0.06321802f, 0.08230120f, -0.01546410f, 0.08444355f, -0.11133134f, 
    0.12697518f, -0.09880669f, 0.04595666f, 0.00809389f, 0.17437063f, 0.16844955f, -0.06529755f, 0.00003987f, 
    0.03758543f, -0.01169230f, 0.06427466f, -0.07215942f, 0.09007123f, -0.04102859f, 0.08589018f, -0.07384892f, 
    0.05643025f, -0.12658271f, 0.04281640f, 0.00697598f, 0.11872903f, 0.09397361f, -0.09813790f, 0.05507373f, 
    -0.28246516f, 0.02691961f, 0.03615497f, -0.11939564f, 0.14302804f, 0.05969271f, 0.03805518f, -0.05829564f, 
    -0.01665644f, -0.08822790f, 0.02116620f, 0.07515888f, -0.34651786f, -0.11934421f, 0.10684734f, -0.32328597f, 
    0.08249882f, -0.08231296f, 0.12792388f, -0.10577043f, -0.08745722f, -0.02240097f, 0.02147915f, -0.02558480f, 
    0.25232711f, -0.00262414f, -0.00427815f, -0.06345165f, -0.01420410f, 0.02783282f, 0.16441166f, 0.05886951f, 
    -0.03551987f, 0.07602756f, -0.09746706f, 0.17415173f, -0.01636299f, 0.05100852f, 0.01404769f, -0.02162457f, 
    -0.13978940f, 0.06885448f, -0.04967947f, -0.01261347f, 0.04280634f, 0.02883137f, 0.07638852f, -0.05601735f, 
    0.27073458f, -0.01698114f, -0.12136612f, 0.31789503f, -0.00587470f, 0.10435049f, -0.03912520f, 0.03029871f, 
    0.06832283f, 0.00211589f, -0.01821631f, 0.14861991f, -0.00238308f, 0.17780779f, -0.09056268f, 0.06100535f, 
    0.07989153f, 0.05937252f, 0.04495517f, -0.10265520f, -0.01298295f, -0.04855610f, 0.13900080f, -0.07366137f, 
    0.16831392f, 0.00312301f, -0.12265673f, 0.02209553f, 0.14295939f, -0.05371524f, 0.02544546f, -0.00537662f, 
    0.03505259f, 0.03734406f, 0.10519406f, -0.06841946f, -0.24902825f, 0.18402357f, -0.00569055f, -0.08706182f, 
    0.00703904f, 0.01666911f, 0.13525465f, 0.00680749f, -0.02973446f, 0.08742499f, 0.05803693f, 0.00224818f, 
    -0.30093998f, -0.12240394f, -0.01257314f, -0.15217280f, 0.10615349f, -0.07621244f, 0.01872219f, 0.12428926f, 
    -0.02698492f, 0.01909043f, -0.02763892f, 0.06928583f, 0.05827379f, 0.03633616f, -0.05129373f, -0.21413770f, 
    0.12299771f, -0.02071359f, 0.07608476f, 0.04620420f, 0.12778758f, -0.03510099f, 0.00870549f, 0.12798490f, 
    0.04341468f, -0.06611700f, 0.22875968f, 0.33534262f, 0.02122781f, -0.01437835f, -0.03051555f, 0.01462820f, 
    0.09078861f, 0.08810869f, 0.00744065f, 0.03147312f, -0.35631391f, -0.13895552f, -0.01076146f, 0.02130943f, 
    0.08235525f, -0.09635782f, 0.11790542f, -0.04411627f, 0.03923170f, -0.10181037f, -0.03602832f, -0.13293423f, 
    0.31295344f, 0.14932756f, 0.05982132f, 0.11396696f, 0.08808180f, 0.00702402f, 0.15794535f, 0.11736441f, 
    0.02025270f, -0.01517060f, 0.03428881f, -0.02451306f, -0.05669597f, -0.01025464f, -0.17542253f, 0.01248776f, 
    -0.21666250f, -0.00722008f, -0.04548437f, -0.00005428f, -0.08799923f, 0.02682154f, -0.04349272f, -0.10884015f, 
    -0.02732492f, -0.01971422f, 0.17311551f, -0.01842607f, 0.15992598f, 0.01128868f, -0.13676281f, 0.04674990f, 
    -0.05321289f, 0.14387129f, 0.11749630f, 0.07919064f, 0.01139675f, 0.21691661f, 0.16494057f, -0.22947408f, 
    0.22723648f, -0.10298382f, 0.01122515f, 0.15692268f, 0.00520513f, 0.07957989f, 0.02509125f, -0.02402324f, 
    -0.24154240f, -0.02598835f, 0.06401382f, -0.31751546f, 0.11656124f, 0.02609143f, 0.07308975f, 0.01472585f, 
    0.23227645f, 0.04838948f, 0.02844484f, 0.12220208f, -0.33486414f, 0.10277521f, -0.01810206f, -0.39638323f, 
    0.09398358f, 0.00990057f, 0.15124835f, -0.03042980f, 0.06895584f, -0.02612616f, -0.03849187f, 0.04492820f, 
    0.07356518f, 0.07474035f, 0.05948277f, 0.20093651f, -0.01461235f, 0.15043715f, 0.06860454f, 0.19492564f, 
    -0.02072716f, 0.01907247f, -0.00017684f, -0.07200828f, -0.09057516f, -0.23473410f, -0.18598913f, -0.25294554f, 
    -0.01961818f, 0.03351281f, -0.03111031f, -0.09925324f, 0.00564116f, 0.03940038f, 0.03192278f, 0.03677756f, 
    0.20834197f, 0.08118925f, -0.02020355f, 0.14733224f, 0.05485983f, 0.16189785f, -0.06253514f, 0.10886983f, 
    0.00395146f, 0.01434675f, -0.01797294f, -0.08745375f, 0.16561110f, 0.22660765f, 0.08254144f, -0.14246809f, 
    0.05007537f, -0.00419117f, 0.08818122f, -0.11497844f, -0.15957801f, 0.16454470f, -0.07342926f, -0.07652020f, 
    -0.19767241f, -0.14727060f, -0.08908091f, -0.09813544f, 0.07116269f, 0.01905636f, -0.06737972f, 0.00674997f, 
    0.09586781f, 0.03490021f, 0.15725347f, 0.00961200f, -0.11554160f, 0.16464990f, 0.04139651f, -0.10645815f, 
    -0.05820579f, -0.07247583f, 0.17640963f, -0.03613310f, -0.01950832f, 0.03439130f, -0.11331739f, -0.02203966f, 
    -0.42474699f, -0.18923755f, 0.01279094f, -0.05617402f, 0.12682314f, -0.04339242f, 0.05926571f, 0.08904953f, 
    0.01295559f, -0.01398006f, -0.09675723f, 0.05847490f, 0.16144173f, 0.09672133f, 0.09672886f, -0.28345323f, 
    0.00022934f, -0.03069755f, 0.03311371f, -0.01152929f, 0.05984905f, 0.12529802f, 0.16734926f, 0.11969805f, 
    -0.17435010f, 0.14490612f, 0.08637787f, 0.29391792f, -0.03195011f, -0.10618936f, -0.07099108f, -0.02355019f, 
    0.08617700f, 0.06447042f, -0.05005016f, -0.10484004f, -0.16925369f, -0.07362299f, -0.05380489f, 0.00355347f, 
    -0.03334292f, -0.11824707f, -0.01275972f, 0.11331341f, 0.08714870f, -0.01173832f, 0.08476561f, -0.12852453f, 
    0.11451944f, 0.11679821f, 0.21250835f, 0.10174039f, -0.00642325f, -0.03220113f, 0.00890238f, 0.11824678f, 
    0.00314801f, -0.04585299f, 0.08166969f, -0.12659818f, 0.33316353f, -0.01147112f, -0.30752215f, -0.13889295f, 
    -0.15172575f, 0.09678386f, -0.12570511f, -0.09876697f, -0.06880848f, 0.10853387f, -0.09457863f, -0.05860162f, 
    -0.00931765f, 0.00439404f, 0.09640664f, -0.08693174f, 0.10235576f, -0.02626077f, -0.00591296f, 0.03020026f, 
    -0.04368887f, 0.27358022f, 0.06553696f, 0.18228377f, 0.23040527f, -0.01731387f, 0.14616349f, -0.18873261f, 
    0.18277082f, 0.00637118f, 0.07892577f, 0.21567756f, -0.08718019f, 0.13587064f, 0.25591838f, -0.08608983f, 
    0.05955075f, -0.00675794f, -0.08959351f, -0.18461280f, -0.09325711f, 0.01000595f, -0.02844325f, 0.03612773f, 
    0.22245777f, 0.01110011f, 0.05714047f, -0.03022059f, -0.00966386f, 0.23143865f, 0.05618688f, -0.27056593f, 
    0.07066240f, 0.13275030f, 0.03254583f, 0.00114201f, 0.15381221f, -0.01377163f, -0.07126021f, 0.00812738f, 
    -0.03797048f, -0.10589786f, 0.16898689f, 0.10271229f, 0.12079350f, 0.01538093f, -0.01041568f, 0.04851256f, 
    -0.09389923f, -0.05631278f, -0.08322572f, 0.00818087f, -0.26140603f, -0.05452482f, -0.09351999f, -0.06934597f, 
    -0.02148372f, -0.04312631f, 0.10192977f, 0.01139479f, 0.03876682f, 0.01440046f, -0.00910074f, 0.06232177f, 
    0.17002845f, 0.06613855f, -0.19953093f, -0.01007928f, 0.19426863f, 0.05382250f, -0.06521603f, 0.07217105f, 
    0.03799631f, -0.03561467f, -0.10736158f, 0.06725473f, -0.18120107f, 0.03850432f, -0.18894790f, -0.09389848f, 
    0.00583422f, 0.10734079f, 0.08581337f, 0.03873511f, -0.10162024f, 0.05616214f, -0.00809735f, -0.03821180f, 
    0.59361714f, -0.31764466f, 0.07037234f, -0.09001422f, 0.06268118f, 0.00124937f, 0.08168958f, 0.06635220f, 
    0.04684319f, -0.00318535f, 0.03265326f, 0.00476411f, 0.19872293f, 0.06645247f, 0.15646185f, 0.04916493f, 
    -0.06607113f, 0.04786038f, 0.06881700f, 0.02691607f, 0.03049035f, 0.03269215f, 0.10869728f, -0.05190212f, 
    -0.08327323f, 0.00461888f, 0.03829076f, 0.02925917f, 0.00730601f, 0.07819217f, -0.08132359f, 0.02691548f, 
    0.01631636f, -0.02453355f, -0.07158055f, 0.08856389f, 0.00067747f, 0.04798867f, 0.04561908f, -0.14334162f, 
    -0.12247748f, 0.10261186f, 0.11926473f, 0.02064179f, 0.02212212f, 0.04972422f, 0.09275386f, 0.07977207f, 
    0.01685213f, 0.07054494f, -0.10463956f, 0.18199092f, 0.10409636f, -0.19485691f, 0.07654759f, 0.01328659f, 
    0.03978037f, 0.01348202f, -0.09730879f, 0.07617275f, 0.14841822f, -0.11783874f, 0.08173383f, -0.10127413f, 
    -0.10721126f, -0.02574568f, -0.02522733f, 0.05677579f, -0.00454699f, -0.02652044f, 0.03012071f, -0.05978446f, 
    -0.04828965f, -0.02473370f, -0.15408556f, 0.10682979f, 0.08245295f, -0.05332645f, 0.11494073f, 0.09203490f, 
    0.05120350f, -0.00466275f, -0.05952965f, -0.00459911f, -0.12391622f, 0.31121191f, 0.00185328f, -0.02957814f, 
    -0.03933511f, -0.03188786f, 0.04561888f, 0.02945574f, -0.01370958f, 0.05375200f, -0.01711483f, -0.00982246f, 
    -0.24873321f, 0.01817665f, -0.01819853f, 0.07722222f, -0.04274683f, -0.02316210f, 0.00721249f, 0.03068047f, 
    0.09669162f, -0.06342674f, -0.03447364f, -0.10915471f, 0.04642415f, -0.15196843f, 0.07965210f, -0.01236455f, 
    0.05943418f, 0.00940099f, 0.01598420f, -0.10175025f, -0.10623772f, -0.03549212f, 0.16102459f, -0.07294212f, 
    -0.11232747f, 0.07516077f, 0.02080149f, 0.03229074f, -0.02150258f, -0.02188516f, 0.00355002f, 0.09103942f, 
    0.13361073f, -0.01269684f, -0.09027559f, 0.09883895f, -0.04027819f, 0.05096772f, -0.04079055f, -0.10926535f, 
    -0.01141238f, 0.09956320f, 0.05451172f, -0.01498153f, 0.12360266f, -0.11640032f, -0.09242203f, -0.12639280f, 
    -0.14496976f, -0.10278405f, -0.09020105f, -0.05849317f, 0.01331476f, 0.04436043f, -0.03077534f, 0.07455143f, 
    0.01864938f, -0.03730610f, 0.00683834f, 0.02638364f, 0.00742304f, -0.20407921f, -0.06936628f, -0.15328377f, 
    0.02726659f, 0.13601165f, 0.00942759f, -0.06057154f, 0.12582840f, 0.06019538f, -0.04243744f, -0.03212846f, 
    0.01665541f, 0.01814693f, -0.03709973f, -0.02174599f, 0.04540236f, -0.01666645f, -0.04470615f, -0.00836913f, 
    0.04616767f, 0.03410799f, -0.01599100f, -0.06231185f, 0.04936953f, -0.01581024f, -0.02396023f, 0.00194834f, 
    -0.05490701f, 0.00192394f, 0.00495133f, 0.00275542f, -0.05669649f, -0.06850726f, -0.02526703f, -0.00599208f, 
    -0.04173538f, -0.01703739f, 0.05782438f, -0.05712890f, -0.01490364f, -0.03462135f, 0.03311373f, -0.04819170f, 
    -0.06481596f, -0.06891777f, -0.02295865f, -0.05151245f, -0.03848298f, -0.08027586f, 0.02283921f, 0.05660895f, 
    0.00428032f, 0.05988646f, -0.02319927f, -0.04668606f, -0.02119933f, -0.02947310f, -0.05859265f, 0.04958344f, 
    -0.06220729f, -0.04761795f, -0.06858554f, 0.05524190f, -0.07908428f, 0.04756074f, 0.01491635f, -0.06512105f, 
    -0.05064398f, 0.04821936f, 0.01225664f, 0.03044088f, -0.03815704f, -0.01435237f, -0.05128682f, -0.02118270f, 
    -0.00544509f, 0.00571851f, -0.05235572f, 0.00420389f, -0.00192379f, -0.03916299f, -0.06552620f, -0.05180861f, 
    0.02874114f, 0.02327087f, 0.01717640f, 0.05498333f, -0.04527445f, -0.02641385f, -0.00762967f, -0.05991043f, 
    -0.06329893f, 0.05038493f, -0.00312543f, 0.02815333f, -0.02376462f, -0.00378715f, -0.06236011f, 0.03037348f, 
    -0.05627852f, 0.06310432f, 0.03712824f, -0.01109004f, 0.00867174f, 0.04296354f, -0.02177686f, 0.02358776f, 
    -0.03869202f, 0.03556010f, -0.03235180f, 0.02292123f, -0.05070576f, -0.04758213f, -0.04524645f, 0.03588781f, 
    -0.03466729f, 0.02041824f, 0.05299501f, 0.02616457f, -0.05764176f, -0.03301213f, -0.03094861f, 0.02184963f, 
    0.00973493f, 0.06442702f, -0.07242096f, -0.03241762f, 0.03169689f, 0.01676951f, -0.03948349f, -0.06029418f, 
    0.05901660f, -0.02848598f, 0.02329809f, -0.06632924f, -0.02076728f, -0.03265939f, -0.01741792f, 0.00403877f, 
    -0.06712358f, 0.01943706f, -0.04214727f, -0.01174211f, 0.04395715f, 0.03505600f, -0.07082266f, -0.03579222f, 
    0.05604705f, -0.07418304f, 0.02994205f, -0.03485599f, -0.01591206f, -0.05171629f, 0.06181347f, 0.03577124f, 
    0.04511835f, 0.04971495f, 0.03190466f, -0.00364872f, -0.04620584f, -0.05941781f, 0.06157730f, -0.07387286f, 
    -0.07668342f, 0.01092265f, 0.03624103f, 0.04388468f, -0.06530327f, 0.03439632f, -0.06979277f, -0.02930860f, 
    -0.02610936f, -0.03112217f, -0.06334472f, 0.03641884f, 0.01863045f, 0.00599641f, -0.04328847f, 0.00819797f, 
    -0.04390404f, 0.02768694f, -0.00651995f, 0.05667265f, -0.02744681f, 0.03490752f, 0.04924027f, 0.01741678f, 
    -0.03373560f, -0.04720659f, 0.02828198f, -0.00537580f, 0.01815899f, -0.07138570f, -0.02638515f, 0.00417199f, 
    -0.05533279f, -0.04284480f, -0.02904143f, 0.02983340f, -0.06622105f, 0.01536062f, 0.02251994f, 0.06412336f, 
    0.00589917f, 0.22985446f, 0.23675551f, 0.02244132f, -0.13960455f, -0.07015036f, 0.04098754f, 0.06199207f, 
    -0.17842320f, -0.05868959f, 0.14688621f, -0.02625834f, 0.00139743f, 0.11237387f, 0.00537366f, -0.01211793f, 
    0.13609245f, 0.05868583f, -0.13971648f, 0.00563294f, 0.13396066f, -0.14390258f, -0.03551215f, 0.06497257f, 
    -0.05279045f, 0.21860750f, -0.13581245f, -0.05073397f, 0.01065754f, 0.02771470f, -0.06483004f, -0.03301319f, 
    0.02965326f, 0.13371167f, -0.09501529f, -0.10122351f, -0.00627761f, -0.13608836f, 0.08504562f, -0.03845873f, 
    0.09702142f, -0.03591648f, -0.16777721f, -0.02606321f, -0.01672553f, -0.15522005f, 0.11554207f, 0.09664880f, 
    -0.14304353f, 0.13263604f, 0.15526226f, -0.24555336f, -0.00613778f, 0.06950331f, 0.04216136f, 0.15675774f, 
    0.12597230f, -0.13809553f, 0.04102761f, -0.10593030f, 0.16666649f, 0.00970399f, -0.10760453f, -0.13409548f, 
    0.12010900f, -0.00019180f, -0.02725837f, 0.00821535f, -0.11466172f, -0.02549692f, -0.02014130f, -0.07090742f, 
    0.10248102f, 0.15519698f, 0.06555721f, -0.11930837f, -0.12637952f, 0.00648405f, 0.00472433f, 0.06553003f, 
    -0.03037361f, 0.00066741f, 0.04370619f, 0.02775336f, -0.04498130f, 0.00982193f, 0.19503605f, 0.08961736f, 
    -0.00472537f, 0.10204503f, 0.17224653f, -0.09171503f, 0.12098774f, 0.06558315f, -0.00795217f, 0.11159048f, 
    0.14629513f, 0.13748772f, 0.03048157f, -0.01679211f, -0.07944690f, 0.02681724f, -0.01900166f, -0.02489392f, 
    -0.07005917f, 0.11469101f, 0.02011165f, 0.02671382f, -0.12996738f, -0.08068566f, -0.05581592f, 0.23872297f, 
    0.13585097f, 0.14416045f, 0.09961229f, -0.03089182f, -0.00837935f, 0.05799411f, 0.10063937f, -0.11126212f, 
    -0.05558576f, -0.15301698f, 0.00501537f, 0.26254955f, 0.11774718f, -0.01522620f, 0.05225197f, -0.12088205f, 
    -0.05721631f, -0.06502211f, -0.03787253f, -0.14864330f, 0.08358999f, 0.01611426f, -0.20431355f, -0.07951126f, 
    -0.14196114f, -0.00984063f, -0.01831354f, 0.02680266f, -0.00463715f, -0.09262542f, -0.08555759f, 0.04921832f, 
    0.12294571f, 0.15012264f, 0.13109306f, -0.10564095f, 0.04352677f, 0.00926710f, 0.05676974f, -0.04235333f, 
    -0.08966762f, 0.12267060f, -0.01347852f, 0.02772588f, -0.01778439f, 0.02292557f, -0.02507209f, -0.03411890f, 
    -0.03388727f, -0.08410385f, -0.04728606f, 0.08049139f, -0.14177594f, 0.07062011f, 0.09720955f, 0.10179795f, 
    0.19965938f, -0.21230632f, -0.09030893f, 0.29035661f, -0.00608144f, -0.05538385f, -0.01845608f, 0.02810294f, 
    0.04751880f, -0.12574603f, -0.06045513f, 0.00272522f, 0.04741027f, 0.27041787f, -0.07800584f, -0.12029769f, 
    0.17479599f, 0.04142033f, -0.14686227f, -0.09434079f, 0.01308970f, -0.09795874f, -0.05227905f, -0.01460015f, 
    0.17688012f, 0.12937547f, -0.30158237f, 0.21319325f, 0.10307214f, 0.15055260f, -0.17370372f, -0.03544712f, 
    0.00813946f, 0.04647140f, -0.07293940f, 0.13917162f, -0.18913539f, 0.05453854f, -0.07322554f, -0.07206626f, 
    -0.03451057f, 0.05477222f, -0.00833412f, 0.00740278f, -0.00926479f, 0.13556941f, -0.03322011f, 0.06437922f, 
    0.13371749f, -0.01930174f, 0.07116809f, -0.01029557f, -0.01505346f, -0.12593295f, 0.02198606f, -0.09215978f, 
    0.00357437f, -0.08896248f, 0.13233179f, -0.04657661f, -0.22643191f, 0.15085818f, 0.08231814f, -0.18517683f, 
    -0.10864691f, 0.00213013f, 0.06336644f, 0.08062623f, -0.01921092f, 0.10124673f, -0.02293827f, 0.00460281f, 
    -0.14138258f, 0.06747269f, -0.04348994f, 0.06567628f, 0.05185825f, -0.01162839f, -0.05263724f, 0.07611024f, 
    -0.08535405f, 0.14572300f, -0.05722710f, -0.02908408f, -0.12613596f, -0.08012716f, 0.01046184f, -0.00629226f, 
    0.01202203f, 0.01806748f, 0.11615021f, 0.04399153f, 0.09154458f, 0.11177736f, 0.13955140f, 0.02642293f, 
    -0.00546510f, 0.08569188f, -0.17829192f, 0.29564363f, 0.11636377f, 0.00669480f, -0.05818070f, 0.07914399f, 
    0.06908671f, 0.00021327f, 0.01562602f, 0.12943579f, -0.00636218f, -0.06235042f, 0.05796718f, 0.10926254f, 
    0.04212186f, -0.06759569f, -0.10856506f, -0.04228911f, -0.01390887f, -0.09211952f, 0.12597649f, -0.03120716f, 
    0.13452359f, -0.12174026f, -0.01207304f, 0.13496651f, 0.17089745f, -0.06089321f, 0.13019714f, -0.01433129f, 
    0.14242363f, 0.13378558f, 0.06662034f, -0.05404850f, -0.14560227f, 0.07730829f, -0.06715789f, -0.16230711f, 
    -0.11079150f, 0.01260316f, 0.08638281f, -0.10402416f, -0.05840247f, -0.00657768f, -0.04989743f, -0.04614823f, 
    -0.06137120f, 0.01227051f, 0.06537332f, -0.09883162f, 0.12413095f, -0.02970492f, 0.03051597f, 0.05894281f, 
    0.04160886f, 0.01497934f, 0.03101858f, 0.05519703f, -0.04476607f, -0.07268629f, 0.04937100f, 0.01604039f, 
    0.24119432f, -0.09855897f, 0.07137122f, -0.06060760f, 0.07139853f, 0.05856394f, -0.02298536f, 0.05732374f, 
    -0.03930320f, -0.07481024f, -0.04273865f, 0.02976261f, 0.08032285f, -0.02732998f, -0.05491843f, -0.08100481f, 
    0.11476438f, -0.07556349f, -0.04950143f, 0.05080840f, -0.06760566f, -0.12753013f, 0.15805036f, -0.23105323f, 
    0.12670910f, 0.10798649f, 0.04397978f, -0.03807512f, 0.09159128f, 0.06231710f, 0.05761496f, 0.00949845f, 
    -0.20372234f, 0.15087338f, 0.19819964f, -0.08099815f, 0.04326229f, 0.13673827f, 0.09916504f, 0.15773857f, 
    0.10176722f, 0.05153532f, -0.04050017f, 0.14575355f, -0.13060071f, -0.09335709f, -0.04776309f, -0.18634519f, 
    -0.17410265f, 0.03867995f, -0.04138489f, -0.02987728f, 0.02251199f, -0.04995739f, 0.05532008f, 0.02339321f, 
    0.29723841f, -0.11100386f, 0.28290758f, -0.10789246f, 0.07670405f, -0.06210057f, -0.00882659f, 0.06807300f, 
    0.04995112f, -0.11803102f, -0.09586526f, 0.06877618f, 0.02685634f, -0.15199426f, -0.21118994f, 0.02071062f, 
    0.06117132f, -0.00405774f, 0.00794252f, 0.05783524f, 0.09000987f, -0.04994475f, 0.02147117f, -0.04107396f, 
    0.09151639f, 0.17219043f, 0.03756540f, -0.00088942f, 0.07750182f, 0.00677915f, 0.07483128f, 0.03244588f, 
    0.07852600f, -0.01005903f, -0.01933515f, -0.04066356f, -0.31397927f, 0.10425367f, -0.16893174f, 0.08853143f, 
    0.09063590f, -0.05486942f, -0.16367894f, 0.06645365f, -0.04156690f, -0.04811873f, 0.12670764f, 0.03959960f, 
    0.18202408f, 0.08837672f, -0.00521348f, -0.05963477f, 0.01484934f, 0.06054160f, -0.01408790f, -0.02164410f, 
    0.07561895f, 0.05896256f, 0.11090412f, 0.04167873f, 0.04238909f, 0.04466714f, -0.01154898f, 0.09373789f, 
    -0.11323419f, -0.01803884f, -0.06236880f, 0.09785513f, -0.12260095f, -0.09791657f, 0.04115501f, -0.00575813f, 
    0.16654897f, 0.12122072f, 0.15665050f, -0.09258652f, -0.00731826f, 0.02386912f, -0.07279324f, 0.02371437f, 
    0.01172936f, 0.04330391f, 0.08125842f, 0.08586229f, 0.10246272f, 0.09146912f, 0.01722143f, 0.07585559f, 
    -0.05378060f, 0.06261922f, -0.05874841f, 0.03712459f, 0.10092235f, 0.03980483f, 0.01791750f, 0.09720176f, 
    -0.04383574f, 0.11731188f, -0.12790243f, -0.05517738f, 0.15567875f, -0.00756174f, 0.00301196f, -0.03539158f, 
    -0.04345095f, 0.15306407f, -0.01145817f, 0.10052072f, -0.22163349f, -0.04741048f, -0.00878545f, -0.09537972f, 
    0.09604275f, 0.04004977f, 0.03984329f, -0.06012418f, 0.05466609f, 0.00815037f, -0.05741500f, 0.02672164f, 
    -0.08516541f, -0.06689683f, 0.10631935f, 0.09995934f, -0.00511814f, 0.05313572f, 0.04322011f, -0.04112014f, 
    0.06630724f, -0.21293254f, -0.07063668f, -0.11181276f, 0.00222812f, 0.01454373f, -0.05437808f, 0.20318763f, 
    -0.04587685f, -0.05387002f, 0.05308619f, 0.06326880f, 0.07456827f, -0.16455376f, -0.14242637f, 0.13328406f, 
    -0.11336854f, 0.00255388f, 0.07276459f, 0.09651425f, -0.00185934f, 0.07303688f, -0.03206054f, 0.02023191f, 
    0.03562135f, 0.08341727f, -0.02510669f, 0.03793418f, -0.08939556f, -0.13041481f, -0.10848194f, 0.10418297f, 
    -0.20707421f, -0.08154099f, -0.09617442f, 0.07780468f, -0.02437934f, 0.03316551f, -0.06676249f, -0.01152424f, 
    -0.05644810f, 0.27782208f, -0.18596947f, -0.06055271f, -0.07414552f, 0.05680274f, 0.10866152f, 0.13375986f, 
    -0.02139764f, -0.02210220f, 0.06308399f, 0.08490805f, 0.34003079f, 0.04786655f, -0.02268554f, -0.14814258f, 
    0.12252054f, 0.15130174f, -0.20387930f, -0.04273105f, 0.04472453f, -0.09800866f, 0.06257688f, 0.03431429f, 
    0.10631198f, 0.11551911f, 0.18712685f, -0.30205983f, 0.13040057f, 0.09364630f, -0.05703417f, 0.08259928f, 
    0.14457524f, 0.07332839f, -0.07618157f, 0.00834638f, 0.17135036f, -0.22670904f, 0.00809678f, -0.02617712f, 
    0.02240510f, -0.05893011f, 0.04146929f, 0.07990932f, -0.11623930f, 0.07314690f, -0.03335294f, 0.08753965f, 
    -0.13020059f, -0.33067888f, 0.15168661f, -0.04659212f, -0.05144627f, 0.13312617f, 0.03397116f, 0.14826572f, 
    0.13724898f, -0.10558687f, 0.07732264f, 0.04261991f, -0.07413436f, -0.07165764f, -0.09663483f, 0.04403739f, 
    -0.09916245f, -0.11293917f, 0.05495085f, 0.04285460f, 0.05300691f, 0.05395523f, -0.14372838f, 0.08527528f, 
    0.34758297f, -0.13918734f, -0.02127607f, 0.20497712f, 0.09816372f, -0.03469957f, 0.05796101f, -0.07596804f, 
    0.04196039f, 0.07227272f, -0.00604804f, 0.10726091f, -0.00578724f, 0.07855168f, 0.17898767f, 0.01487968f, 
    -0.05629990f, 0.02651514f, -0.03104056f, 0.07687628f, -0.03269351f, 0.17177656f, 0.13338116f, 0.00305639f, 
    -0.13542041f, 0.22346801f, 0.08614580f, 0.19896001f, 0.03099964f, 0.12837343f, -0.05966119f, -0.10872482f, 
    0.05484821f, 0.08197546f, -0.02742624f, -0.00280773f, 0.07399905f, 0.01087994f, -0.16562042f, 0.09482778f, 
    0.01408974f, -0.00490629f, -0.02529752f, 0.16032474f, -0.02443805f, 0.01787001f, 0.09153607f, -0.08441775f, 
    -0.15600064f, 0.03346594f, 0.00414624f, -0.04650262f, -0.05455392f, 0.02721202f, -0.09648878f, -0.04406152f, 
    0.01473747f, -0.00567557f, -0.02115036f, 0.05044205f, 0.18456468f, -0.06812400f, -0.00246024f, -0.28555819f, 
    -0.10495086f, 0.05090319f, -0.10221239f, 0.00346284f, -0.07598424f, -0.00334277f, 0.00092772f, 0.13719133f, 
    0.05162915f, -0.00125378f, -0.05041467f, -0.00241647f, -0.04419747f, -0.08917111f, -0.03976563f, -0.08065227f, 
    0.08904572f, 0.17799032f, 0.00123711f, 0.10962868f, 0.15382041f, -0.14874689f, 0.12498412f, 0.21797590f, 
    0.04253326f, -0.02697743f, -0.03732980f, 0.02239748f, 0.05655240f, -0.08670791f, 0.04634183f, -0.01119289f, 
    0.02021738f, 0.02021728f, -0.07898787f, 0.15971784f, -0.16966282f, 0.02940453f, -0.07846715f, 0.09486112f, 
    0.06192341f, 0.00306618f, 0.01570195f, -0.05712580f, -0.01249508f, -0.00338846f, -0.07361686f, 0.05114426f, 
    -0.01867599f, 0.08833254f, -0.05040120f, 0.09842845f, 0.08830083f, 0.07488995f, 0.08339169f, -0.04879765f, 
    0.01680348f, -0.01764548f, -0.07112478f, -0.23908217f, 0.16099447f, 0.09697840f, 0.08148909f, -0.03833525f, 
    -0.05820294f, -0.13300034f, -0.01889891f, 0.09284899f, 0.03986939f, 0.01137566f, 0.10850974f, -0.00563940f, 
    -0.03736563f, 0.03139104f, 0.07542511f, 0.05051159f, 0.02532296f, -0.00401842f, -0.00837225f, 0.19646363f, 
    -0.05386189f, -0.16757002f, -0.04639207f, -0.10570722f, 0.11108420f, -0.08877321f, 0.06461227f, 0.02999845f, 
    0.02801646f, 0.14525478f, 0.00630661f, 0.02404987f, 0.24800801f, -0.15925744f, 0.06452467f, -0.04234730f, 
    -0.15482306f, 0.03272976f, 0.05226390f, 0.01763666f, -0.00576399f, 0.07806768f, -0.11458920f, 0.05147919f, 
    -0.23963065f, -0.06349472f, -0.06854453f, -0.11427201f, -0.01715831f, 0.06254698f, -0.11243168f, -0.03383360f, 
    0.08794317f, -0.01601549f, 0.08016407f, 0.14565116f, 0.09443820f, -0.05084801f, -0.09112742f, -0.02726494f, 
    -0.01209702f, -0.02639995f, -0.10125148f, 0.02821259f, -0.00534546f, -0.05981040f, -0.02240810f, -0.00088225f, 
    0.15220852f, 0.08719998f, -0.08993399f, 0.26582542f, 0.12414851f, 0.03745484f, 0.07885928f, -0.04255226f, 
    -0.00342661f, -0.07267004f, -0.01575154f, -0.04743215f, 0.24977133f, 0.20851287f, 0.26034278f, 0.09332198f, 
    0.02655752f, -0.11426020f, 0.01838374f, 0.17878777f, 0.04359594f, 0.01393571f, 0.07547613f, 0.00890316f, 
    0.50212431f, 0.08819187f, -0.02321633f, -0.13398156f, -0.08624408f, 0.04589429f, -0.03441267f, -0.14979750f, 
    0.00675031f, -0.07885531f, -0.00927588f, 0.02005714f, 0.19561569f, 0.09126373f, 0.06198313f, -0.10476082f, 
    -0.01905701f, 0.02328303f, -0.09200512f, 0.07986402f, -0.04457951f, 0.10768075f, -0.07125174f, -0.13074405f, 
    -0.12433971f, 0.04902548f, 0.07104130f, -0.10237297f, -0.00675485f, 0.04652696f, -0.00362052f, -0.05371230f, 
    0.06442127f, -0.08381981f, -0.06524171f, 0.00784781f, 0.01998445f, -0.12151851f, 0.03838166f, -0.06331494f, 
    -0.08387335f, 0.02111181f, -0.06362283f, -0.05112579f, -0.06946176f, 0.03854274f, -0.04742254f, 0.03737109f, 
    0.05248616f, 0.21213500f, 0.00050437f, -0.15211517f, -0.03321303f, -0.01632080f, 0.03663765f, -0.02128115f, 
    0.11187805f, -0.04039377f, 0.16652250f, 0.00529027f, 0.14704709f, -0.15374513f, -0.08289560f, -0.03909526f, 
    -0.18909034f, 0.15143943f, -0.00512306f, -0.03963253f, -0.00085145f, 0.00933592f, 0.08838837f, -0.07770146f, 
    0.30310151f, -0.13352534f, 0.07036735f, 0.11960260f, -0.05222558f, -0.02211303f, -0.04633535f, -0.03206638f, 
    0.04185661f, 0.00768185f, 0.01343782f, -0.01083852f, 0.25006798f, 0.17641142f, 0.15997615f, 0.36709544f, 
    0.04725367f, 0.01065857f, 0.00942057f, 0.01419752f, -0.04643471f, 0.04104476f, -0.10559951f, -0.00430110f, 
    -0.04599366f, -0.00902653f, -0.19532497f, 0.00188868f, -0.10313507f, 0.02582938f, 0.00542890f, -0.04045667f, 
    0.08263686f, 0.06252681f, 0.15652634f, 0.02032795f, 0.05004450f, -0.05651794f, 0.23628153f, 0.31094766f, 
    0.10769743f, -0.08194053f, -0.02187037f, 0.08726736f, 0.09400878f, 0.05939851f, 0.04592140f, 0.08087347f, 
    -0.01295850f, 0.06180489f, -0.08161358f, 0.02058679f, 0.13559394f, -0.04426350f, 0.05750381f, -0.03472771f, 
    0.08046139f, 0.08212145f, -0.04343462f, -0.01874687f, -0.07184451f, -0.20907927f, -0.01612137f, 0.08156078f, 
    0.00412336f, -0.15313983f, 0.12777187f, -0.11609527f, 0.13178281f, -0.02224739f, 0.13205130f, 0.05992754f, 
    0.24587189f, 0.06622765f, 0.15146013f, 0.10951491f, -0.09784662f, -0.11979013f, 0.05148695f, 0.02453208f, 
    -0.01303805f, 0.00255466f, -0.05827794f, -0.08570226f, 0.18472916f, -0.02536389f, 0.06414403f, 0.08293086f, 
    -0.05398827f, 0.08162992f, 0.04758283f, -0.01256727f, -0.05140024f, 0.05534677f, 0.08509862f, -0.11172273f, 
    0.37659892f, -0.01338076f, -0.13918447f, 0.03031876f, 0.25540975f, 0.01406414f, -0.04955659f, -0.03512501f, 
    -0.08863541f, 0.18265556f, -0.06850076f, 0.12012483f, -0.14876112f, -0.00888336f, -0.14870688f, 0.07924758f, 
    0.02257738f, 0.04750450f, -0.00809417f, 0.01950510f, -0.01632970f, -0.08168943f, -0.00536915f, 0.03696533f, 
    0.51458555f, -0.08440471f, 0.13432185f, 0.05918748f, -0.05717516f, 0.14905664f, -0.04664069f, -0.05074370f, 
    -0.05890831f, 0.06371567f, 0.17696780f, 0.24226858f, -0.02482593f, -0.09042107f, 0.04896865f, -0.01666823f, 
    0.11387660f, 0.19988139f, -0.00050023f, -0.11824135f, -0.08867086f, -0.08717085f, -0.00103100f, 0.02716096f, 
    0.09732036f, -0.05564518f, -0.08870809f, -0.03606788f, 0.19557044f, -0.04079402f, 0.08062384f, -0.05106149f, 
    0.06056574f, 0.00764525f, 0.03604998f, 0.01520284f, -0.32425532f, -0.04678007f, 0.18621112f, -0.12732416f, 
    -0.05916408f, -0.06119777f, -0.08889353f, 0.03135419f, 0.06596097f, -0.11487005f, 0.15859263f, 0.05602491f, 
    -0.03971871f, 0.11962671f, -0.02299601f, -0.23157042f, 0.06482478f, -0.00288011f, -0.11275255f, -0.00287629f, 
    0.11967359f, -0.08649001f, 0.06859262f, 0.04430415f, -0.06777677f, 0.08023361f, -0.00922731f, 0.02201284f, 
    -0.00249526f, 0.02379177f, -0.10580962f, -0.07929220f, 0.03074726f, -0.05115040f, 0.01866467f, 0.10210871f, 
    -0.12764534f, -0.10365292f, 0.10321340f, 0.02001794f, 0.26410031f, -0.01110155f, -0.00672789f, -0.01946684f, 
    0.06865378f, 0.15967518f, -0.01841740f, -0.02972773f, -0.35325542f, -0.05983264f, -0.14953306f, 0.16613370f, 
    0.07302287f, -0.09329209f, -0.02227273f, -0.08522967f, -0.02174865f, -0.10229215f, -0.12652503f, -0.04045489f, 
    0.20620641f, 0.24194115f, -0.16382293f, -0.10784428f, -0.14631416f, 0.15547304f, -0.05472610f, 0.12432861f, 
    0.07690813f, 0.01812564f, 0.08980285f, -0.07071971f, 0.22645508f, -0.06716722f, 0.17219357f, 0.03653412f, 
    -0.11235350f, 0.05285285f, -0.06849951f, 0.05817234f, -0.05131935f, -0.02072891f, -0.04922740f, -0.01747632f, 
    -0.23110640f, 0.04967106f, 0.00650211f, 0.08235358f, -0.26360494f, 0.19176100f, 0.02083158f, -0.06095944f, 
    -0.06427532f, -0.12704058f, 0.04155130f, 0.05855662f, -0.07166027f, -0.11035614f, 0.11507098f, 0.09055234f, 
    0.07114992f, -0.02546931f, -0.03254704f, 0.07147654f, 0.01318189f, 0.02000388f, -0.04821969f, 0.10051071f, 
    -0.40847877f, 0.10097697f, -0.06559224f, 0.13865723f, 0.16245367f, 0.04075405f, -0.00317446f, -0.05531355f, 
    0.02414279f, 0.03135330f, -0.11775280f, 0.01665732f, -0.28143772f, -0.12184134f, -0.06134235f, -0.07647216f, 
    0.02998351f, -0.00449300f, -0.00183932f, 0.01380159f, 0.13845590f, 0.05168658f, -0.00928719f, 0.04339881f, 
    0.17691673f, 0.14552987f, 0.21211390f, -0.10721058f, -0.15465337f, 0.12076864f, 0.09186926f, -0.05543202f, 
    0.05361979f, -0.06296514f, -0.00830529f, -0.08044329f, -0.06054699f, -0.10911620f, 0.13404827f, 0.14635745f, 
    0.06493274f, 0.05225486f, -0.02658499f, -0.03771069f, 0.10320700f, -0.05088781f, -0.03802843f, -0.08237706f, 
    -0.15093258f, -0.09422138f, 0.01513671f, -0.17189518f, -0.07223099f, 0.11248004f, 0.13032793f, -0.05684918f, 
    -0.04970685f, -0.01588846f, 0.03893995f, -0.09132054f, 0.12117831f, 0.32964218f, -0.00546753f, 0.07581052f, 
    0.08658358f, -0.06894825f, 0.05756452f, 0.08763768f, 0.09199348f, -0.00208840f, 0.09331045f, 0.13604189f, 
    -0.08206648f, -0.04947023f, 0.04584957f, -0.07494698f, -0.11761077f, 0.07438218f, 0.03509902f, 0.05943466f, 
    -0.10090304f, -0.04991379f, 0.00174396f, -0.03352462f, 0.03674962f, -0.17623109f, 0.16254760f, 0.03035391f, 
    0.16938677f, -0.00594398f, 0.13703914f, 0.13389049f, 0.03682442f, -0.05662898f, 0.00600855f, 0.07871749f, 
    0.16965434f, 0.01435059f, 0.04600239f, 0.11800802f, 0.11006678f, 0.05246421f, 0.14722516f, 0.07365078f, 
    -0.02716326f, 0.05055228f, -0.09772703f, 0.06627118f, 0.03186299f, -0.02857056f, 0.00151807f, 0.12301838f, 
    -0.01845755f, 0.03912952f, 0.13680117f, 0.09100184f, 0.11292453f, 0.13280475f, -0.09116758f, -0.00265201f, 
    0.14644283f, 0.15369391f, -0.09116364f, -0.00916534f, -0.00138698f, 0.10494938f, 0.05077529f, -0.08845971f, 
    -0.10142514f, -0.15915211f, 0.15093423f, -0.06030922f, 0.25487271f, -0.06258839f, 0.11811303f, -0.09192945f, 
    0.06194231f, 0.01991929f, 0.05325781f, 0.06879189f, -0.04376890f, -0.01042751f, 0.14867085f, 0.05953859f, 
    -0.08163823f, -0.15490803f, 0.19032659f, -0.01414333f, 0.02076174f, -0.14588979f, 0.06036572f, -0.11275989f, 
    -0.05549837f, -0.03014731f, -0.05921856f, 0.14818162f, -0.20810625f, 0.08331768f, 0.01034128f, 0.16502221f, 
    0.03252771f, 0.08412856f, -0.02053691f, -0.06432813f, -0.11153633f, -0.10825276f, 0.04610619f, 0.01313765f, 
    0.30844459f, 0.12047107f, 0.29779473f, -0.11081144f, -0.12057399f, -0.01400005f, -0.06318358f, 0.10925265f, 
    -0.05321397f, -0.08180843f, 0.12608178f, 0.04716002f, 0.17614113f, 0.13903472f, 0.10183588f, -0.10140673f, 
    0.07961197f, 0.09300054f, -0.06794113f, 0.00739839f, 0.06705749f, -0.04981623f, -0.15376709f, 0.09053024f, 
    -0.26316294f, 0.04475947f, -0.08589610f, -0.21353486f, 0.06833077f, 0.09137467f, 0.03215205f, 0.02941938f, 
    0.08984846f, 0.06982879f, -0.07025706f, 0.08183255f, -0.25675002f, 0.00097096f, 0.01525178f, 0.08803631f, 
    -0.00315737f, 0.00710007f, -0.10214058f, 0.01188141f, -0.03051536f, -0.09027038f, -0.08341147f, 0.18137611f, 
    -0.22801824f, 0.02304367f, 0.26807156f, -0.05412376f, -0.14452706f, 0.07468883f, 0.03242451f, -0.03266595f, 
    0.03363127f, -0.13041544f, 0.05731541f, -0.12625921f, 0.23212110f, 0.06558753f, 0.02363580f, -0.12718157f, 
    -0.02277079f, 0.00998492f, -0.03563331f, 0.10658870f, -0.07722832f, 0.03800640f, -0.03819714f, -0.15501900f, 
    -0.14046374f, 0.27409273f, -0.15844151f, -0.12601475f, 0.01818644f, -0.08886915f, -0.03293771f, 0.02495078f, 
    -0.06390348f, -0.09529145f, -0.10315020f, 0.01127699f, 0.19650026f, 0.01817544f, 0.11944930f, 0.14821830f, 
    -0.02156846f, -0.06444375f, 0.02090996f, 0.07313178f, 0.04338130f, 0.05285382f, 0.07261160f, 0.09816925f, 
    -0.04813198f, 0.06913295f, -0.11758775f, -0.01316658f, -0.01553684f, -0.02998937f, -0.09533816f, 0.05746708f, 
    -0.13702452f, 0.05185876f, 0.02698160f, -0.04568598f, 0.12874636f, 0.02786891f, -0.00513244f, -0.04007402f, 
    -0.01821280f, 0.19600515f, 0.07606681f, -0.07208289f, 0.06609574f, 0.18739924f, -0.13214663f, -0.05872075f, 
    -0.19524857f, -0.02455676f, -0.07584024f, 0.32576716f, 0.01662177f, -0.05326521f, 0.10510334f, -0.10552088f, 
    0.02988009f, 0.01728065f, -0.06980109f, 0.00058465f, 0.17532520f, -0.17943253f, -0.14306636f, 0.18533292f, 
    -0.02920577f, -0.03122601f, -0.01649023f, 0.07946259f, 0.09307696f, -0.08849327f, 0.03000147f, 0.05445370f, 
    0.31166938f, 0.09504269f, 0.08417385f, 0.05568417f, -0.21507791f, 0.05571905f, -0.01618311f, 0.03958127f, 
    -0.07438183f, -0.00109873f, 0.05162474f, -0.09205939f, 0.21601197f, 0.04871203f, 0.09562204f, 0.08227697f, 
    -0.07488428f, 0.07908037f, -0.10945779f, 0.11376069f, -0.01784588f, 0.14190060f, 0.10444354f, 0.11348969f, 
    -0.06039324f, -0.24991499f, -0.04624465f, 0.15792328f, 0.22025891f, -0.00275223f, 0.09167138f, -0.01629434f, 
    -0.11980619f, -0.01825574f, -0.19654495f, 0.14967518f, 0.04625197f, 0.31323114f, -0.10170554f, -0.11705906f, 
    0.09954250f, 0.09329122f, -0.07044721f, -0.13914025f, 0.08872353f, -0.07242280f, -0.04452080f, 0.08795994f, 
    0.06314775f, -0.01966201f, 0.01295199f, -0.00094482f, 0.01220710f, -0.06631321f, -0.07462572f, -0.00750562f, 
    -0.03066512f, -0.02821990f, 0.03815963f, -0.05555356f, -0.08462023f, 0.02354252f, -0.06268576f, -0.02721016f, 
    -0.01457475f, -0.01880366f, -0.04841064f, 0.05746656f, -0.03191549f, -0.03256167f, 0.01171755f, 0.00723494f, 
    0.01784961f, -0.03052817f, 0.01845254f, 0.02878843f, -0.02025533f, -0.01818601f, 0.01610271f, -0.03703370f, 
    -0.02567968f, -0.08179466f, 0.03576292f, -0.00654371f, 0.03391836f, -0.00708091f, -0.06634638f, -0.04194753f, 
    0.00404583f, 0.01979468f, -0.05452063f, -0.07321346f, -0.01397381f, -0.01778474f, 0.06513061f, -0.07558886f, 
    0.04500233f, -0.01309077f, 0.05246811f, -0.04203994f, -0.03721977f, -0.03483457f, -0.02805963f, -0.00624980f, 
    0.05996728f, -0.02371944f, -0.02998615f, 0.04153411f, 0.01006495f, 0.03450502f, -0.00989604f, 0.00273005f, 
    0.01861331f, 0.00660457f, 0.01130332f, -0.07557879f, -0.06108002f, -0.06613983f, 0.00885692f, 0.00405817f, 
    0.03332962f, -0.05508025f, 0.03495720f, -0.04384892f, 0.03915858f, 0.00592658f, -0.05863413f, 0.01464085f, 
    0.03656734f, 0.04272963f, 0.05573082f, -0.00426736f, -0.02050043f, -0.06681325f, -0.07272194f, 0.06710524f, 
    0.00396551f, 0.02229276f, 0.05769959f, 0.00810215f, -0.03347226f, 0.04563626f, -0.03069415f, -0.04954204f, 
    0.02693772f, -0.04205187f, -0.02684610f, -0.02473571f, 0.06422647f, 0.00072830f, 0.00733683f, 0.00588918f, 
    -0.03478356f, -0.03176844f, -0.02237242f, 0.06231753f, -0.01497706f, 0.03339390f, -0.01662652f, -0.02457838f, 
    -0.04987872f, 0.03621591f, -0.05269662f, 0.06735018f, -0.05694147f, -0.06419962f, -0.03741169f, 0.04629615f, 
    0.06311417f, 0.02855830f, 0.06117074f, -0.01372239f, -0.07199348f, -0.05009880f, -0.01303157f, -0.08467643f, 
    0.00807512f, -0.04078991f, -0.06102942f, -0.08434953f, -0.00619326f, -0.06273735f, 0.05541177f, -0.01347826f, 
    0.03095893f, 0.05982034f, -0.04373172f, -0.03770279f, -0.00006362f, -0.05669572f, 0.04387384f, -0.04470589f, 
    0.01299766f, -0.00047007f, 0.05148846f, -0.05434654f, -0.01093718f, 0.02801448f, 0.05761361f, 0.03734180f, 
    -0.08349515f, -0.02146407f, -0.07270547f, -0.02421766f, -0.01251588f, 0.01303737f, -0.05717429f, 0.03089713f, 
    -0.01767745f, -0.06285565f, 0.00581106f, -0.00036762f, 0.02445360f, -0.02369759f, -0.04058453f, 0.04309697f, 
    0.03219207f, 0.03601883f, -0.00316689f, -0.00535926f, -0.01591711f, -0.02552991f, 0.01002495f, -0.00050257f, 
    -0.00048216f, -0.04210785f, -0.06088984f, 0.00132648f, -0.07255832f, 0.04236275f, 0.02191341f, -0.06115987f, 
    -0.04585069f, -0.06118625f, -0.07068557f, -0.02218382f, 0.03805541f, -0.02614963f, 0.00933560f, 0.03048199f, 
    0.01777841f, -0.08047504f, 0.04734381f, 0.01056745f, 0.03273715f, 0.08772305f, 0.07435270f, 0.09243979f, 
    0.09245397f, 0.02229654f, 0.12696077f, -0.35320225f, -0.02335566f, 0.29214311f, -0.04527091f, -0.00534577f, 
    -0.14504758f, 0.07197580f, -0.09170114f, -0.21166399f, -0.04363461f, 0.18930282f, 0.15748377f, -0.00187631f, 
    -0.23906599f, 0.02026230f, -0.02924410f, -0.04490998f, -0.13266979f, -0.16973852f, 0.08590373f, -0.05193603f, 
    0.00060476f, 0.10422016f, 0.22719675f, 0.20135231f, 0.20177233f, -0.10686953f, 0.03230013f, -0.07753792f, 
    -0.10747202f, 0.03440540f, 0.06797895f, -0.02871413f, 0.05941295f, -0.04021176f, 0.14994438f, 0.06954244f, 
    -0.23691955f, -0.07107466f, 0.03959500f, 0.03823854f, -0.09641881f, -0.23817757f, 0.07759134f, -0.16173112f, 
    -0.10276961f, 0.02074091f, 0.03765175f, 0.20352995f, -0.09252001f, -0.19937722f, 0.06450649f, -0.05248161f, 
    0.01329683f, 0.01562196f, -0.03531243f, 0.03330250f, -0.09276580f, -0.03679666f, 0.05114401f, -0.11106138f, 
    -0.14936310f, -0.05258624f, -0.00427076f, -0.19038330f, 0.18144968f, 0.04992428f, 0.13466719f, 0.10769334f, 
    -0.04641726f, 0.11231149f, -0.24282281f, -0.32896879f, -0.13920428f, -0.06509206f, -0.02133175f, 0.00016581f, 
    0.05450212f, -0.06912977f, -0.02190452f, 0.12164805f, 0.04947667f, 0.06317522f, -0.03144481f, -0.03839576f, 
    -0.13587143f, -0.06233451f, -0.07074685f, 0.08140689f, -0.01134564f, 0.04466818f, -0.08397621f, -0.04248229f, 
    0.21323924f, 0.04116070f, 0.01076571f, 0.00680519f, 0.12700507f, 0.04545736f, -0.00392976f, 0.11644881f, 
    -0.14411452f, -0.00513477f, 0.07445484f, -0.06173123f, -0.08042849f, 0.11766749f, -0.02623355f, 0.09457709f, 
    0.06730419f, 0.15538946f, -0.09376018f, -0.05113320f, 0.13566278f, 0.03299971f, 0.08083370f, 0.01432840f, 
    -0.01443257f, 0.24332328f, -0.17332649f, 0.17073521f, 0.06589996f, 0.10154422f, -0.03983901f, 0.09738397f, 
    -0.03384442f, 0.06450842f, 0.12140166f, 0.05141066f, -0.03145295f, -0.14108457f, 0.01756191f, 0.02079395f, 
    0.04629403f, -0.06586442f, 0.00253676f, 0.12501678f, 0.04747884f, 0.07498176f, -0.19008675f, 0.01140338f, 
    -0.06059544f, -0.23449293f, -0.04203765f, 0.05372413f, 0.06950983f, 0.02432915f, 0.01007921f, 0.15802982f, 
    0.06678645f, 0.14453974f, 0.03657619f, 0.09302609f, 0.06636962f, -0.08422428f, -0.05648753f, -0.22240750f, 
    -0.13576393f, 0.10056479f, 0.04907672f, 0.03647708f, 0.03081691f, 0.06302926f, 0.14690676f, -0.07561707f, 
    -0.03973525f, -0.13325851f, 0.05050184f, 0.03418452f, 0.02640146f, -0.06184358f, -0.05432911f, 0.16054860f, 
    -0.10792655f, -0.18906693f, -0.08994535f, -0.12586291f, 0.14986946f, 0.12003848f, 0.27589595f, 0.09506350f, 
    0.07937293f, -0.01748881f, 0.10435700f, 0.05842382f, 0.02527640f, 0.07064532f, -0.17808957f, -0.04366653f, 
    0.05596442f, -0.03985700f, 0.02917349f, 0.11102893f, 0.03041529f, 0.09145040f, -0.11401666f, -0.03821081f, 
    0.02400800f, 0.12954126f, 0.15972577f, -0.10283253f, -0.02111536f, 0.11438927f, 0.05192634f, -0.09016444f, 
    -0.22982360f, 0.02865317f, -0.09187930f, -0.10871089f, 0.11114127f, 0.01263326f, 0.02379562f, 0.04772162f, 
    0.14151314f, 0.05500780f, 0.05252056f, -0.06234208f, -0.60717750f, 0.28332707f, -0.13691908f, -0.11373885f, 
    0.02804931f, -0.08927738f, 0.09785721f, 0.04539511f, -0.04384395f, 0.01558356f, -0.00693033f, 0.11252363f, 
    -0.12639855f, -0.04036110f, 0.06981029f, 0.01966950f, 0.02267591f, 0.05403260f, -0.00780085f, 0.12168008f, 
    -0.00109403f, -0.07397964f, 0.05228037f, -0.08828402f, 0.07595558f, 0.12744917f, 0.08963615f, -0.17609352f, 
    0.02310720f, -0.05059496f, 0.03260260f, 0.16982219f, 0.07341749f, 0.08362854f, 0.00256823f, -0.05114999f, 
    -0.18699038f, -0.08425821f, 0.25965133f, 0.24163222f, 0.09411137f, 0.05347580f, -0.00179429f, 0.09324325f, 
    0.07570070f, 0.05278624f, -0.06070233f, -0.00385843f, -0.17940390f, 0.19549942f, -0.16625357f, 0.04603621f, 
    0.09327175f, -0.08174864f, 0.01499672f, 0.00326995f, 0.08312719f, 0.02800176f, 0.11363631f, 0.00229548f, 
    0.14566745f, 0.19911407f, 0.17531869f, -0.00466004f, -0.05170118f, -0.10612062f, -0.00345277f, -0.02984627f, 
    -0.02379442f, 0.06080177f, -0.01288584f, 0.03894427f, -0.02932627f, -0.19260229f, -0.25803089f, 0.19567433f, 
    -0.00564369f, 0.06197910f, 0.17318775f, -0.01325533f, -0.05888486f, 0.24587204f, -0.06461933f, -0.03936189f, 
    0.05722082f, -0.03161887f, 0.21587330f, -0.00895540f, 0.07641769f, 0.09307334f, -0.02242197f, -0.04301573f, 
    -0.04226179f, -0.02692175f, 0.07709512f, 0.07775530f, 0.17121285f, 0.00167998f, 0.12723584f, -0.07407068f, 
    0.11050712f, -0.09412530f, 0.17320776f, 0.17959970f, 0.07838333f, 0.10153949f, -0.16806126f, 0.05252464f, 
    -0.15021233f, -0.04546886f, 0.10601051f, -0.15791972f, 0.10093080f, -0.03599025f, 0.03622305f, 0.05547336f, 
    0.05236217f, 0.02466742f, 0.02244510f, -0.01230437f, -0.15919252f, 0.05136937f, 0.08113637f, -0.22691688f, 
    0.00887836f, -0.03922961f, 0.11170935f, 0.04291175f, 0.02648518f, 0.14101100f, 0.09670309f, 0.03456885f, 
    0.02097768f, -0.12552369f, 0.07219525f, 0.14463381f, -0.01313154f, -0.02455882f, 0.04690626f, 0.08081104f, 
    -0.05271827f, -0.00896897f, -0.01588302f, 0.18994708f, -0.20677802f, -0.14246915f, -0.08445257f, -0.05983343f, 
    -0.00120503f, 0.06208014f, 0.02325712f, -0.03298139f, 0.09131887f, 0.00326904f, 0.04971339f, 0.06743683f, 
    -0.00647336f, 0.05332587f, -0.03531453f, 0.05982668f, 0.01821407f, 0.01490051f, -0.06571407f, -0.02254423f, 
    0.04374398f, 0.02526424f, -0.00943155f, 0.05206437f, 0.05396230f, 0.04286968f, 0.05732676f, -0.01324615f, 
    -0.06260072f, -0.03192144f, -0.00130767f, -0.00793249f, -0.02823712f, 0.03689849f, 0.06427674f, -0.07455377f, 
    -0.00237936f, -0.06519911f, -0.04223885f, 0.06476283f, 0.04477905f, 0.06413580f, -0.02491308f, 0.02565365f, 
    -0.06949296f, 0.02045410f, -0.07123959f, 0.00831481f, 0.05200746f, -0.02535626f, 0.05276765f, 0.01277822f, 
    -0.01178437f, -0.02611537f, -0.01935543f, -0.07171795f, 0.00192132f, -0.08205768f, -0.06971131f, 0.02565439f, 
    0.03903476f, -0.04761725f, -0.04194162f, -0.00882165f, 0.06178025f, -0.01658035f, -0.04579205f, 0.00235630f, 
    0.02809451f, -0.05391634f, -0.05677444f, -0.02541235f, -0.02304941f, -0.00715738f, -0.02924655f, 0.05509020f, 
    -0.05417210f, -0.06901258f, 0.01320248f, 0.01044335f, -0.02743907f, 0.03033336f, -0.00744890f, -0.07215133f, 
    -0.00199133f, -0.01792862f, -0.03195351f, -0.04293672f, -0.01915483f, 0.00115214f, -0.05730401f, 0.06147825f, 
    -0.05934596f, -0.03123723f, -0.05992952f, 0.01229380f, 0.00114640f, 0.02152924f, -0.07779218f, 0.02572211f, 
    0.06192412f, -0.04851029f, -0.07483494f, -0.08193714f, -0.00204864f, -0.04650474f, -0.04454140f, 0.04778887f, 
    -0.00338164f, 0.01781203f, 0.01960504f, -0.04817754f, -0.03593583f, -0.07511694f, 0.03770111f, -0.04869233f, 
    -0.02048360f, -0.06387165f, -0.02735914f, 0.04918843f, 0.00242285f, -0.01437289f, -0.00261951f, 0.03106793f, 
    0.05341392f, -0.01825108f, 0.06147727f, -0.03518028f, 0.04536748f, -0.05750898f, -0.04753278f, -0.03420018f, 
    0.04087831f, -0.06598280f, 0.03018661f, 0.02965222f, 0.04893638f, -0.00739161f, 0.02805148f, -0.04916424f, 
    -0.01442462f, -0.03777530f, 0.02654253f, 0.01416715f, 0.05118367f, 0.06105617f, 0.04880340f, -0.02740741f, 
    -0.03003096f, 0.04485383f, -0.06271464f, 0.01844937f, -0.05416815f, 0.04116021f, 0.05285269f, 0.01697770f, 
    0.03030331f, 0.02014255f, -0.07021251f, -0.02329228f, 0.05215619f, -0.04376486f, -0.02319431f, 0.02362435f, 
    -0.02003826f, 0.00022532f, -0.03254188f, 0.02689914f, -0.05296635f, 0.06085182f, -0.07908872f, 0.03840441f, 
    0.03961595f, -0.01795755f, -0.06298112f, -0.06192305f, 0.00242331f, -0.01727089f, -0.07954997f, 0.01030359f, 
    -0.04874801f, 0.01543050f, -0.02657633f, -0.04605354f, -0.05516053f, 0.02934379f, -0.00772241f, -0.02984281f, 
    0.04842163f, 0.01371840f, -0.04666795f, -0.07268651f, -0.06260265f, -0.07120188f, 0.00155864f, 0.04246760f, 
    -0.05401749f, 0.01957012f, 0.04497328f, -0.00891581f, -0.07161589f, -0.03767349f, -0.06503689f, -0.02303971f, 
    0.02189574f, -0.02385077f, 0.03882084f, 0.03537399f, 0.00252214f, -0.08052917f, -0.02922508f, 0.04164980f, 
    -0.06228571f, 0.05160965f, -0.00030432f, 0.03119673f, -0.00215357f, -0.04197361f, 0.00088765f, 0.04007433f, 
    0.02939134f, -0.01755400f, -0.05419620f, 0.06195882f, 0.02252048f, 0.03706433f, -0.01769225f, -0.05671551f, 
    -0.07014794f, -0.01320919f, -0.02586118f, -0.05973811f, -0.02313413f, -0.05337532f, 0.03606297f, -0.03148661f, 
    -0.07609832f, -0.04242697f, -0.02700537f, -0.01499446f, -0.04151479f, -0.01361870f, 0.00941583f, -0.05156773f, 
    0.01989324f, 0.05318501f, -0.07602784f, 0.00652861f, 0.04135880f, -0.01356504f, 0.05979630f, -0.03157633f, 
    -0.02061359f, 0.05279731f, -0.02486571f, -0.00237313f, -0.05328397f, 0.02511986f, -0.00666119f, 0.06733576f, 
    -0.00155274f, -0.06247136f, -0.01114108f, -0.02436077f, -0.07528856f, 0.04819599f, 0.05034602f, -0.00116384f, 
    -0.03764984f, 0.04389531f, 0.02958519f, 0.04862699f, 0.04535074f, -0.06590654f, -0.07041664f, 0.02586725f, 
    -0.00844837f, 0.04252921f, -0.03639226f, -0.04487395f, 0.05113707f, -0.04355898f, -0.03744043f, 0.03177128f, 
    -0.06043692f, -0.04421726f, 0.04452615f, -0.05270809f, -0.06730685f, 0.05517001f, -0.07030129f, 0.01108197f, 
    0.04493954f, -0.04428714f, -0.04442276f, 0.06159930f, -0.03069229f, 0.02882617f, -0.02921345f, -0.07318634f, 
    -0.06668609f, -0.03618242f, 0.04203333f, 0.03745874f, -0.03430935f, 0.03201235f, -0.05211100f, -0.05817164f, 
    -0.04630763f, 0.01887953f, 0.00682152f, -0.06379850f, -0.01840203f, -0.04153438f, -0.03316387f, 0.00481777f, 
    -0.01597189f, 0.02858752f, -0.06565166f, 0.04724630f, -0.01667105f, -0.01668813f, -0.06149982f, -0.05522328f, 
    0.01582427f, -0.00057917f, -0.02793649f, -0.07210165f, -0.05324051f, -0.05218155f, 0.06070695f, 0.01443921f, 
    -0.00770903f, -0.06074189f, -0.05667611f, -0.00607790f, -0.04555298f, -0.03859867f, -0.05154568f, -0.03928468f, 
    -0.01433027f, 0.01585110f, 0.00730712f, 0.04389755f, -0.00679562f, 0.00940182f, -0.01145865f, -0.02805482f, 
    -0.06598762f, 0.02278051f, 0.03079001f, 0.01237980f, 0.05204540f, -0.01687737f, -0.04774612f, -0.05173776f, 
    -0.00270570f, -0.03613725f, -0.07455669f, -0.05234283f, 0.00349385f, 0.05473945f, 0.00533677f, -0.04339143f, 
    -0.03188865f, 0.03225558f, -0.05377026f, -0.07098164f, -0.02417705f, -0.01722160f, -0.00948662f, -0.00873722f, 
    0.00490377f, -0.04145363f, -0.07228248f, 0.01707550f, 0.01031976f, -0.01868519f, -0.04149907f, -0.03325005f, 
    -0.04444725f, 0.05468351f, -0.02647762f, -0.02876125f, -0.07927519f, -0.03549359f, 0.05115464f, -0.02254353f, 
    -0.02805979f, 0.03666842f, -0.03867335f, -0.03292606f, -0.00455995f, 0.02768921f, -0.03328253f, -0.02902523f, 
    -0.05835507f, -0.06500451f, 0.06605703f, -0.01101231f, 0.02399412f, 0.04344395f, -0.00122150f, 0.04976535f, 
    -0.00757106f, -0.09273823f, 0.00766898f, -0.06126397f, 0.02352524f, -0.05444148f, 0.01113553f, -0.03983597f, 
    -0.05401348f, -0.04252307f, -0.02304687f, -0.07905687f, -0.08138365f, -0.02353975f, -0.03586396f, -0.07956414f, 
    -0.03875720f, 0.03553269f, 0.06019332f, 0.02601349f, 0.02070526f, 0.00407015f, -0.05283957f, -0.01962646f, 
    0.05018931f, -0.05731156f, -0.06319943f, 0.00925253f, -0.03278642f, 0.01124193f, -0.02192698f, -0.05988872f, 
    -0.00071153f, 0.03584016f, 0.03467902f, 0.01628463f, -0.05775415f, -0.04283965f, -0.09415823f, -0.03376913f, 
    0.02458085f, 0.02479379f, -0.00040092f, -0.03195660f, -0.01184343f, -0.00956398f, -0.06314947f, 0.01973949f, 
    0.01915164f, 0.01075274f, -0.07924196f, -0.02682721f, -0.02313766f, -0.00518240f, -0.01454397f, -0.05910101f, 
    0.04595832f, 0.00541198f, -0.07892399f, -0.04128760f, 0.03391965f, -0.08473343f, -0.03803225f, -0.05059888f, 
    -0.04264402f, -0.04506387f, -0.00138363f, -0.07392769f, -0.06795321f, 0.05119573f, -0.02717679f, -0.02886415f, 
    -0.04551469f, -0.06547678f, -0.04444050f, 0.01089141f, -0.04142915f, -0.06673039f, -0.04876657f, 0.01189736f, 
    -0.07404418f, 0.00467728f, -0.04333336f, -0.03991722f, 0.07339982f, 0.02863835f, 0.01340525f, -0.04835225f, 
    -0.06681904f, -0.02768072f, -0.00313405f, 0.00392139f, -0.00022711f, -0.03640122f, -0.00386869f, 0.02191715f, 
    -0.06409256f, -0.03382854f, -0.05088429f, 0.03080209f, -0.05818380f, -0.00153169f, -0.00979408f, 0.04151438f, 
    -0.00276998f, -0.08159091f, 0.03911157f, -0.04668987f, -0.05516746f, -0.01085846f, 0.02292718f, -0.06101608f, 
    -0.03972632f, -0.01760905f, 0.06064440f, -0.08627790f, -0.04808804f, 0.06700660f, -0.04964883f, -0.02774383f, 
    -0.04611767f, 0.04535839f, -0.05337608f, -0.01287548f, 0.05236785f, 0.00039413f, -0.01608490f, -0.02024115f, 
    0.00894115f, 0.03067761f, 0.03549194f, -0.02269451f, -0.08709448f, 0.04148705f, 0.08690124f, 0.05349079f, 
    -0.03887862f, 0.00838032f, -0.07851346f, 0.02742971f, -0.09880867f, -0.03516979f, -0.08541714f, -0.03072957f, 
    -0.01458889f, -0.07693537f, -0.04438176f, -0.04818406f, 0.02181205f, -0.01580538f, -0.06070514f, 0.05091461f, 
    0.02483040f, -0.05540526f, -0.02084346f, 0.05138990f, -0.03188536f, -0.07543906f, -0.07083776f, -0.08146885f, 
    0.05196991f, 0.00302028f, -0.06819192f, 0.03138866f, -0.01150076f, -0.04372843f, -0.00271484f, -0.04545340f, 
    0.03339762f, 0.10104116f, 0.07095186f, -0.02484057f, 0.05479268f, 0.04597451f, -0.06973901f, -0.00148804f, 
    -0.06004693f, -0.03451122f, 0.02232332f, 0.01728833f, 0.01285780f, 0.02915691f, 0.01138693f, -0.07757502f, 
    0.31364429f, -0.08578470f, 0.16500589f, 0.11634197f, 0.03818042f, -0.01834771f, 0.06806253f, -0.03106385f, 
    -0.02450676f, -0.06830389f, 0.01173977f, 0.00575038f, 0.01556867f, 0.13774179f, -0.07852843f, -0.12309543f, 
    0.06997620f, 0.06432644f, -0.04380601f, 0.14493887f, 0.11056115f, -0.09395291f, -0.07542479f, -0.10348490f, 
    -0.39727941f, 0.31632319f, -0.17832090f, -0.05941975f, 0.04606339f, -0.09780196f, 0.16843681f, 0.12867719f, 
    0.05051306f, 0.13660589f, -0.01008018f, -0.01831174f, -0.28687075f, 0.02723505f, -0.11040974f, 0.15251848f, 
    0.19151704f, 0.02058458f, -0.06680202f, 0.06172866f, 0.04298614f, -0.10323139f, 0.10624041f, 0.05438396f, 
    -0.51766282f, 0.27842978f, -0.03800554f, -0.05718435f, -0.15575299f, 0.10443690f, 0.06507877f, -0.03073691f, 
    0.00437901f, -0.05669389f, 0.05496060f, 0.08245528f, 0.26063836f, -0.14865232f, 0.03712697f, 0.14241083f, 
    -0.00638076f, 0.09278063f, -0.04895832f, -0.18682531f, -0.04580677f, -0.00937693f, 0.13773961f, 0.21157695f, 
    -0.28953886f, 0.18327665f, -0.00326407f, 0.00595299f, -0.16442537f, -0.07142522f, 0.08186442f, -0.04627472f, 
    -0.03960235f, -0.11031415f, 0.01594292f, -0.04329031f, 0.13528758f, -0.04638493f, 0.13368809f, 0.14154765f, 
    -0.04481121f, -0.09596387f, -0.04875413f, -0.05403401f, -0.08932650f, -0.01095944f, 0.01774669f, 0.15876904f, 
    0.10311756f, -0.09181362f, -0.03875637f, 0.16262174f, -0.05177466f, 0.09357142f, -0.14582497f, 0.00450811f, 
    -0.00090734f, -0.03124252f, 0.01153630f, -0.05671604f, 0.01990864f, 0.02447911f, -0.20278595f, -0.19723289f, 
    -0.08608577f, -0.02435028f, 0.04450084f, 0.04064525f, -0.05812609f, 0.06542224f, -0.09845465f, -0.03018225f, 
    -0.13670667f, 0.15315631f, -0.00080645f, 0.15587476f, -0.13378489f, 0.02376144f, 0.06648422f, -0.00972753f, 
    0.01886459f, 0.06550813f, -0.07756620f, 0.12001087f, -0.16459404f, 0.15451464f, -0.00475044f, 0.20848542f, 
    0.11161884f, 0.03585472f, -0.04414691f, 0.07586629f, 0.05443301f, -0.02224007f, 0.08408877f, 0.18429673f, 
    0.17253900f, -0.15255786f, 0.08748103f, -0.04312041f, -0.27978545f, 0.00397233f, 0.14924739f, -0.16443004f, 
    0.07476776f, 0.03859275f, -0.00715906f, 0.07362372f, 0.32601801f, -0.12508909f, 0.01823978f, 0.06459935f, 
    -0.17416967f, -0.04823206f, -0.00550646f, -0.14949833f, 0.02343975f, -0.06078228f, -0.03892044f, 0.25303870f, 
    -0.29761133f, 0.22345647f, 0.23652379f, 0.11740844f, 0.27698779f, 0.13937637f, -0.08349977f, -0.03113289f, 
    -0.01301862f, -0.02671329f, 0.01459830f, 0.11088553f, 0.06202135f, 0.12986571f, -0.38338819f, -0.46417487f, 
    0.03448380f, 0.02756101f, 0.13511054f, -0.03096229f, 0.18329911f, 0.13542283f, -0.10984571f, 0.05758775f, 
    0.13382500f, 0.17655179f, 0.17447673f, -0.15011309f, -0.03174760f, -0.13014171f, 0.06140379f, 0.09302178f, 
    -0.12922227f, -0.06744976f, 0.11033915f, -0.01380586f, -0.08682877f, 0.05455545f, 0.03782326f, -0.03530145f, 
    0.16856623f, -0.02864010f, -0.03275023f, 0.07968447f, 0.12074518f, -0.16625619f, -0.04488893f, 0.05476438f, 
    0.22994554f, -0.10039618f, 0.13463958f, -0.00423246f, 0.01499078f, 0.08545912f, -0.03554824f, 0.10289063f, 
    -0.07829920f, 0.05888138f, -0.09013055f, 0.02700925f, 0.14058104f, -0.09048764f, 0.03154745f, 0.05919835f, 
    -0.03879951f, 0.06100431f, -0.11913025f, 0.04823702f, -0.07132965f, -0.05165179f, 0.10692295f, 0.05561660f, 
    0.36229438f, 0.11673731f, 0.14613038f, 0.01875203f, -0.06537580f, 0.12394691f, -0.08066645f, -0.06196569f, 
    0.15679984f, 0.02178911f, 0.16613352f, -0.10841720f, 0.11447165f, 0.00345285f, -0.03086972f, -0.00213313f, 
    -0.13108733f, 0.02418370f, -0.04728211f, 0.02995528f, -0.16455840f, -0.07166292f, -0.15571219f, -0.10100848f, 
    0.12095502f, 0.20475109f, -0.18083504f, -0.06071205f, 0.02575342f, 0.01714665f, -0.04121148f, -0.06868185f, 
    -0.07104916f, 0.06729677f, 0.04533191f, 0.01042187f, 0.36192095f, 0.13780911f, 0.14808877f, 0.19773698f, 
    -0.09339789f, 0.07733968f, 0.04629909f, -0.10377086f, 0.11581576f, 0.05795997f, 0.09550387f, 0.19402629f, 
    -0.12549302f, 0.04874544f, -0.22372831f, -0.00358590f, 0.04073970f, -0.14225882f, -0.05727814f, 0.01764526f, 
    -0.03339278f, 0.18154307f, -0.13397586f, -0.03355149f, -0.06442588f, 0.15381590f, 0.15533507f, 0.10255427f, 
    0.25176927f, 0.02651147f, 0.20479308f, 0.05743879f, 0.12069535f, -0.12100796f, 0.09344362f, 0.03412654f, 
    0.03922410f, -0.06647043f, -0.03021510f, 0.24084470f, -0.14416595f, -0.14854193f, 0.04718859f, -0.12426028f, 
    0.08172950f, -0.10290445f, -0.07528514f, -0.12760693f, -0.01663898f, -0.09686177f, -0.03422001f, 0.20419589f, 
    -0.09252101f, -0.07624580f, 0.04108501f, -0.19991288f, 0.07932027f, -0.14201757f, -0.14435716f, 0.03746392f, 
    0.02446360f, 0.18594845f, 0.03895981f, 0.13139167f, -0.13508448f, -0.01292331f, -0.02088325f, -0.00904790f, 
    -0.08056779f, -0.01276112f, -0.00166526f, -0.04146176f, 0.19267096f, -0.05445984f, -0.08453794f, 0.16230015f, 
    -0.18914285f, -0.04631586f, -0.04356290f, 0.06472625f, -0.09182846f, 0.07217170f, 0.03582543f, -0.00901648f, 
    0.01883875f, -0.24948074f, -0.14264986f, -0.05349383f, 0.16452079f, -0.00535388f, -0.03206857f, 0.02795774f, 
    0.01576007f, -0.15512164f, 0.00038517f, 0.13742690f, 0.25120220f, 0.21652798f, -0.03055021f, -0.13493128f, 
    0.24568042f, 0.09596516f, -0.05917178f, -0.01708361f, 0.01130676f, -0.09355453f, 0.04518692f, 0.06674069f, 
    0.05113686f, 0.01396754f, -0.01530504f, -0.07751654f, -0.04570312f, 0.00199996f, -0.07033600f, -0.02489965f, 
    0.02740360f, 0.06134836f, -0.07344209f, -0.06950259f, 0.00385232f, -0.00713728f, 0.00491188f, -0.00551784f, 
    -0.04510859f, 0.05219611f, -0.01226213f, 0.02435239f, 0.02358709f, -0.03540210f, -0.03016681f, -0.01295948f, 
    0.01388527f, -0.03615776f, 0.06336527f, -0.02484455f, -0.05712095f, 0.03787643f, -0.05650787f, -0.05215798f, 
    0.01205784f, 0.01801306f, -0.03327785f, -0.00857227f, 0.00814573f, -0.06414712f, 0.05582479f, -0.00121836f, 
    0.01341352f, 0.02896486f, -0.07348323f, -0.01810623f, -0.04746981f, 0.01625340f, -0.02675145f, -0.00174479f, 
    0.01714435f, -0.00927397f, -0.00002286f, -0.02141003f, 0.06777523f, -0.02192190f, 0.04295108f, -0.00857512f, 
    -0.00441081f, -0.06896180f, -0.02170203f, 0.06867018f, 0.04800767f, 0.04242557f, -0.05555779f, -0.01518249f, 
    -0.03380662f, 0.07297532f, -0.02137023f, -0.06503318f, -0.05760967f, -0.01856826f, -0.01617982f, 0.01177051f, 
    0.01626607f, 0.00603720f, -0.04249839f, -0.04295067f, 0.01393860f, 0.05034031f, -0.01539619f, -0.01602892f, 
    0.02827451f, 0.02734771f, -0.01241585f, -0.03309083f, -0.00918522f, -0.00193416f, -0.01597852f, -0.03788263f, 
    -0.06781903f, -0.01471719f, -0.00513016f, 0.05316209f, -0.01527825f, -0.01611170f, 0.05613717f, -0.03726878f, 
    0.04649482f, 0.05385647f, -0.05492473f, -0.04520975f, 0.04406993f, -0.03100894f, -0.05289212f, -0.06728711f, 
    -0.00508960f, -0.04694306f, 0.02217580f, 0.06109222f, 0.02345303f, -0.03548864f, -0.01518333f, 0.05342026f, 
    0.01414550f, 0.06263923f, -0.04713070f, -0.06395004f, 0.03574470f, 0.03416127f, 0.01841809f, 0.06359950f, 
    -0.00322186f, -0.06611778f, -0.00603912f, -0.06271920f, -0.05152461f, -0.01365398f, -0.00797579f, 0.05229613f, 
    0.01375290f, 0.00167188f, -0.02349773f, 0.03020463f, 0.03951545f, -0.01287834f, -0.08082750f, 0.02036165f, 
    0.06090150f, 0.06841487f, -0.02023474f, -0.07089436f, 0.04213094f, -0.04867959f, -0.03480598f, -0.02716513f, 
    -0.04466495f, 0.02335143f, -0.06530703f, 0.03829249f, 0.01378578f, -0.05156249f, -0.02147120f, -0.06935827f, 
    0.02464099f, -0.06785075f, -0.00652211f, 0.02269939f, 0.02830680f, -0.03698051f, 0.02159792f, -0.00506252f, 
    -0.05317848f, -0.06420467f, -0.02424816f, -0.02511956f, -0.04111755f, 0.05338713f, 0.02252918f, -0.04715589f, 
    -0.07464789f, -0.05272983f, -0.01343113f, -0.07196614f, 0.03041997f, 0.06842750f, 0.01648840f, -0.01070771f, 
    0.03527474f, 0.06939886f, -0.01960932f, -0.02451744f, 0.02741138f, -0.03878272f, -0.06219905f, -0.02348454f, 
    -0.04451752f, 0.03666548f, -0.02937330f, -0.00097415f, -0.04159842f, -0.03670756f, 0.00638819f, -0.06363412f, 
    -0.02467395f, 0.02512049f, -0.01823900f, 0.06124433f, -0.00497069f, -0.08062014f, 0.04713153f, 0.01700649f, 
    -0.00317488f, -0.03766264f, -0.02325271f, -0.07470990f, 0.02441857f, 0.03088412f, 0.04518918f, 0.02780546f, 
    -0.02885616f, -0.00111351f, 0.03662031f, -0.07241486f, 0.01620855f, -0.07205880f, -0.08016595f, -0.00988110f, 
    -0.03217702f, -0.03392530f, 0.00259706f, -0.05600874f, -0.00775212f, 0.02986534f, -0.07312871f, 0.05314092f, 
    0.02149338f, 0.00795320f, 0.00119000f, -0.06174441f, 0.00302897f, -0.05515167f, -0.03565891f, 0.03935518f, 
    0.05718248f, -0.02854040f, 0.06161226f, 0.01126231f, -0.05753706f, -0.04481549f, -0.02389253f, -0.03507650f, 
    0.02194062f, -0.07360476f, -0.06046300f, -0.01787083f, -0.04831282f, 0.00582117f, 0.05463390f, 0.05547153f, 
    -0.05180905f, -0.05366437f, -0.07759418f, 0.01910255f, 0.01215196f, 0.04845890f, -0.04709782f, -0.05734032f, 
    -0.01433223f, -0.07475039f, 0.01750065f, 0.04660639f, -0.05085372f, -0.07235675f, 0.04781508f, -0.04141317f, 
    -0.03242211f, -0.06556133f, 0.02954724f, 0.03684698f, -0.07025775f, 0.03622537f, 0.02650507f, -0.01269218f, 
    -0.01369517f, 0.05809819f, 0.03804202f, -0.01315130f, -0.00991124f, 0.00740092f, 0.02719271f, 0.00107080f, 
    -0.05235328f, -0.07681050f, -0.04612077f, -0.00017435f, -0.03740257f, -0.04142095f, 0.01453254f, -0.06299824f, 
    0.01917227f, 0.05261109f, -0.07656550f, -0.05172504f, -0.02850237f, -0.01424452f, -0.04498019f, 0.02500626f, 
    -0.05757662f, -0.04141998f, -0.05565347f, 0.05173091f, -0.03231072f, 0.01435264f, 0.00526078f, -0.03339104f, 
    -0.04395707f, 0.04497125f, 0.05128868f, 0.03688795f, 0.05060483f, 0.03649920f, 0.05080877f, 0.00094061f, 
    -0.06296705f, -0.05242882f, 0.00927404f, -0.01072120f, -0.03492222f, -0.02180822f, 0.03284361f, 0.00299927f, 
    0.04632881f, 0.02445174f, 0.05581032f, 0.01516331f, -0.04285312f, 0.05568146f, 0.05956689f, -0.03828763f, 
    -0.01767880f, -0.04927490f, 0.01616970f, 0.03414077f, 0.03765941f, -0.04650625f, -0.06122597f, -0.06468958f, 
    -0.04132916f, -0.05185029f, 0.03522518f, 0.00790868f, -0.00361551f, -0.05781663f, 0.01128011f, -0.06750233f, 
    -0.04747747f, -0.08025701f, 0.01907653f, -0.07392310f, 0.04637819f, 0.05416654f, 0.00376645f, -0.03951455f, 
    0.05209149f, 0.06110123f, 0.02474058f, 0.03578955f, 0.02724128f, -0.01174398f, -0.03763730f, -0.00076120f, 
    0.03548531f, -0.00291463f, 0.05452346f, -0.05649437f, -0.04652952f, 0.01160705f, -0.00095132f, 0.01331835f, 
    0.06336229f, 0.05036470f, -0.03906199f, 0.05653442f, -0.01222966f, -0.02848451f, -0.03967296f, 0.03620625f, 
    -0.02689400f, -0.05449921f, -0.01283690f, -0.03184690f, -0.06283262f, -0.00712259f, -0.04577851f, -0.03761419f, 
    0.02544991f, 0.01693277f, 0.02354323f, 0.02673507f, 0.03986171f, -0.05577228f, 0.03648891f, -0.01296995f, 
    0.00588097f, -0.05646101f, -0.07043602f, -0.04636388f, 0.05838405f, -0.06355018f, -0.03036896f, 0.03869347f, 
    -0.04983533f, 0.02335645f, 0.00329052f, 0.05641990f, -0.06105970f, -0.00781469f, -0.06469585f, 0.00237456f, 
    -0.01296975f, 0.02767713f, -0.00625902f, -0.02547819f, 0.04521722f, -0.07372785f, -0.07109728f, -0.01035669f, 
    -0.04257094f, 0.05064315f, -0.00170929f, 0.06304410f, 0.03684208f, -0.03839177f, -0.02382076f, -0.01707092f, 
    -0.02299171f, -0.07628368f, -0.05308641f, -0.06701206f, 0.03463084f, -0.01919021f, 0.01847268f, 0.00844511f, 
    0.05237446f, -0.04215253f, 0.05551600f, -0.06783149f, -0.03401264f, -0.05083606f, -0.03046717f, -0.03271858f, 
    0.04171690f, -0.06007199f, 0.01808309f, 0.00783627f, -0.05777473f, -0.01477078f, 0.04345280f, -0.04964886f, 
    -0.07288609f, -0.02962089f, 0.04010201f, -0.05530236f, 0.04447182f, -0.05651139f, 0.03760883f, 0.05195975f, 
    -0.06129171f, 0.03948071f, -0.02046833f, -0.04666920f, -0.06875697f, -0.06161552f, -0.04736739f, -0.04497529f, 
    -0.02201109f, -0.03693409f, 0.04907615f, -0.07185362f, -0.00829419f, -0.01492664f, -0.05354650f, -0.03405040f, 
    -0.02073417f, 0.05408732f, 0.00169880f, 0.03079478f, 0.00363714f, -0.04857184f, -0.02198715f, 0.06309017f, 
    0.04820531f, 0.03068744f, 0.02861880f, -0.06611000f, 0.05468744f, -0.00919159f, -0.05005730f, -0.03016500f, 
    -0.06084788f, 0.04493525f, 0.04880840f, -0.07109874f, 0.04901206f, 0.00885581f, 0.00996765f, -0.00946865f, 
    -0.01447042f, -0.01439257f, 0.06417830f, 0.04952604f, -0.04645728f, 0.02267192f, -0.02660315f, 0.04532473f, 
    0.00156788f, -0.04987287f, 0.02625118f, -0.01494380f, -0.03042279f, -0.05254582f, -0.06169428f, 0.00344259f, 
    -0.03239501f, -0.03637493f, -0.06190107f, 0.02195836f, -0.00188418f, -0.00225382f, -0.05854798f, 0.01208596f, 
    0.03087003f, -0.01198610f, -0.05212314f, -0.05455990f, 0.05155204f, -0.02539116f, -0.01991191f, -0.00938585f, 
    -0.04273858f, -0.01876130f, -0.02104220f, -0.04308637f, -0.03818249f, -0.05567983f, -0.01587134f, 0.04494824f, 
    0.00151792f, 0.06493182f, 0.03900907f, -0.04417523f, -0.01187980f, 0.02697931f, 0.03982655f, 0.03345551f, 
    -0.04021666f, -0.00663318f, 0.02189729f, -0.06208933f, 0.04535875f, -0.06873327f, 0.03883787f, 0.01380802f, 
    -0.02460380f, 0.03107508f, -0.02186981f, -0.04483831f, 0.00063517f, 0.03431816f, -0.04915315f, -0.03241016f, 
    0.04026927f, -0.03024697f, -0.00062877f, 0.03940313f, 0.04787778f, -0.01408636f, 0.01184116f, -0.07073732f, 
    0.05422748f, -0.00782718f, 0.01959080f, 0.00443839f, -0.06674092f, 0.01978417f, -0.05370191f, -0.03467705f, 
    -0.02928151f, -0.02821101f, -0.15119128f, 0.06391130f, -0.12205870f, 0.06248021f, -0.08645613f, -0.04315938f, 
    0.06384274f, 0.11137825f, 0.05784084f, -0.06077689f, -0.04370794f, 0.01095356f, 0.09089811f, 0.13133833f, 
    0.04765519f, 0.05617311f, 0.00509650f, -0.06995498f, -0.18056664f, 0.06194630f, -0.00940211f, -0.01410005f, 
    -0.25884634f, 0.03330205f, 0.09851032f, 0.09961347f, 0.05882833f, -0.04407583f, -0.03677374f, -0.02789517f, 
    -0.02256382f, -0.01994064f, 0.02843825f, 0.16315968f, -0.10224377f, 0.16677646f, 0.03253371f, -0.01254290f, 
    -0.02424593f, 0.05717588f, 0.16271225f, -0.05814691f, 0.09091116f, -0.00237542f, -0.14349563f, -0.09659105f, 
    0.09632655f, -0.14044297f, 0.00024112f, 0.04413863f, 0.08143712f, -0.08433123f, 0.12171337f, 0.04137617f, 
    -0.05114377f, -0.06458846f, -0.00259071f, 0.07107624f, 0.00570069f, -0.02471159f, -0.08745195f, -0.07412094f, 
    0.01232429f, 0.00256119f, 0.04423915f, -0.10072604f, 0.12872912f, 0.00584759f, -0.10030486f, 0.03985221f, 
    0.52861869f, -0.04896868f, 0.17434263f, -0.02425906f, -0.06236110f, 0.04246501f, -0.02347522f, -0.01645031f, 
    0.02003542f, 0.05147630f, -0.01544568f, -0.13763316f, -0.06127148f, 0.22263594f, -0.14975454f, -0.09781095f, 
    0.14046498f, 0.02717023f, 0.07164948f, 0.06052652f, 0.06282353f, 0.07758634f, -0.06682161f, -0.10139638f, 
    0.08471839f, -0.01522152f, 0.18039551f, 0.01332661f, -0.03897512f, 0.01517217f, 0.08402507f, -0.01123870f, 
    0.06681687f, -0.20558783f, -0.02172956f, -0.14923120f, 0.19160476f, -0.17128427f, 0.06399400f, 0.06555492f, 
    -0.10470374f, -0.05621261f, 0.00312584f, 0.16979319f, 0.01134060f, -0.11133617f, 0.03603105f, 0.11803360f, 
    0.42397445f, 0.12997295f, 0.04708060f, -0.21607655f, 0.07200142f, 0.00405234f, -0.06684738f, 0.15065250f, 
    0.04881734f, 0.26564601f, 0.10323414f, 0.15982234f, 0.14712521f, 0.07850265f, 0.21432865f, -0.10062490f, 
    -0.11931112f, 0.02070590f, -0.04362051f, 0.04983253f, -0.00280019f, 0.14505041f, 0.15696388f, -0.08562241f, 
    0.03418845f, 0.05487339f, 0.00073847f, 0.00655763f, 0.00031514f, 0.01011544f, 0.06319673f, -0.04803288f, 
    0.02158700f, -0.06872802f, 0.14067872f, -0.06506605f, 0.11345746f, 0.25105649f, -0.04307681f, -0.01199537f, 
    0.18761215f, 0.11201528f, 0.08799306f, -0.09607960f, -0.08263322f, -0.13086760f, -0.17122370f, -0.11892086f, 
    0.00018077f, -0.25847933f, 0.09338612f, -0.03612220f, -0.09142923f, -0.02622407f, -0.11779544f, -0.04194003f, 
    0.03156430f, -0.00725282f, 0.11223176f, -0.15884587f, -0.26354364f, -0.21298331f, 0.13360810f, 0.27626532f, 
    0.05834187f, -0.11065755f, 0.15723948f, 0.16390443f, -0.02861645f, 0.18341367f, -0.02467900f, 0.06183654f, 
    0.02894177f, 0.11614887f, -0.18400116f, 0.14632690f, 0.07233467f, 0.15571161f, 0.05081248f, -0.05305003f, 
    0.05015055f, 0.04545617f, 0.15649293f, -0.05358947f, -0.12664580f, 0.20664650f, 0.18370764f, 0.07372744f, 
    0.00811948f, -0.00530596f, 0.10709790f, 0.01996284f, 0.11003761f, 0.02203604f, 0.02326537f, 0.02430324f, 
    0.18675548f, 0.03499291f, 0.11782736f, 0.08906883f, -0.02009892f, 0.14646296f, 0.00997062f, -0.05139126f, 
    -0.00403574f, -0.02403917f, 0.06765178f, -0.13883580f, 0.12352076f, 0.00427089f, 0.22066024f, -0.06650420f, 
    0.00164589f, 0.02337819f, 0.12654810f, -0.05193650f, 0.00176646f, 0.05072130f, -0.08651966f, 0.01919954f, 
    0.12522620f, -0.08322975f, 0.01054552f, -0.12310467f, 0.05322128f, 0.05017751f, -0.06786676f, 0.00467639f, 
    -0.00344319f, 0.14353135f, -0.02461579f, 0.09938510f, -0.38740635f, -0.18757914f, -0.22509938f, 0.05422108f, 
    0.04429110f, 0.01547772f, -0.01498312f, -0.19950585f, 0.03916540f, 0.00871956f, 0.02908874f, -0.01698327f, 
    -0.40751147f, -0.06509514f, -0.19045599f, 0.18372816f, 0.20201704f, 0.00507193f, 0.03756649f, 0.02039570f, 
    0.03416330f, 0.10686852f, 0.09174217f, 0.01886391f, -0.36745253f, -0.28103444f, -0.03820163f, 0.17236754f, 
    -0.02394624f, -0.01089432f, 0.07190584f, -0.04754737f, 0.00315692f, -0.01115402f, 0.19240017f, 0.05419445f, 
    0.22607106f, -0.02137077f, 0.04830319f, 0.17206481f, 0.09028170f, -0.06300413f, 0.03525475f, 0.04762238f, 
    0.10820240f, 0.09714086f, 0.05708817f, -0.05063467f, 0.11626588f, 0.13756944f, 0.04655224f, -0.03150659f, 
    0.12639797f, 0.09722202f, 0.09398016f, 0.08891280f, 0.03261119f, -0.06485476f, 0.13992894f, -0.06783152f, 
    0.12440674f, -0.07160688f, 0.03349051f, -0.06386743f, 0.06347127f, 0.09829433f, -0.07914907f, 0.02176791f, 
    0.01640013f, 0.09788626f, -0.05093528f, 0.02900080f, -0.10243977f, 0.02222946f, 0.00223994f, -0.00066895f, 
    0.20038678f, -0.02647646f, -0.03992371f, -0.00706685f, 0.04220873f, -0.08688615f, -0.05058660f, 0.12881261f, 
    -0.48905936f, 0.09860384f, -0.05742743f, -0.02708741f, 0.03828076f, 0.01599470f, 0.01143055f, -0.07064078f, 
    0.06022112f, 0.12239268f, -0.11059566f, -0.04993910f, -0.36015186f, -0.18521750f, -0.06435335f, -0.10997139f, 
    -0.03379796f, -0.06641194f, 0.03926843f, -0.08896926f, 0.05033267f, 0.05261739f, -0.03736288f, 0.12017765f, 
    0.11444220f, 0.17559019f, 0.12995702f, -0.09140426f, 0.11111283f, 0.05061293f, 0.03026188f, 0.08049182f, 
    0.08655746f, -0.10137364f, -0.10416290f, -0.01609746f, 0.12285220f, 0.19939248f, -0.04758819f, -0.15661214f, 
    -0.10018855f, -0.00605392f, -0.04047256f, -0.16118252f, 0.01567288f, 0.07233749f, -0.01670724f, -0.05185747f, 
    -0.08206185f, 0.10804970f, -0.08024351f, 0.12646349f, -0.05936969f, 0.01233017f, -0.05667574f, -0.06920519f, 
    -0.12417678f, -0.00342878f, 0.04464413f, 0.17356211f, 0.06696175f, -0.04783269f, 0.12752502f, -0.03930739f, 
    -0.08090593f, 0.12265701f, -0.09939720f, -0.00891956f, 0.18834859f, -0.03401351f, -0.11590073f, 0.08699502f, 
    -0.24004042f, 0.21213123f, -0.01126331f, -0.05127777f, -0.04478167f, -0.15653695f, 0.14861423f, -0.04284164f, 
    -0.07906947f, 0.02840370f, 0.02208831f, -0.19344926f, -0.37938765f, -0.04484326f, 0.19422927f, -0.15629806f, 
    0.14064075f, 0.01125538f, 0.10198347f, -0.11146986f, -0.01255062f, 0.02988978f, 0.01018069f, 0.06457870f, 
    -0.17721899f, 0.03751041f, -0.01592315f, 0.00022298f, -0.08593360f, 0.01823692f, -0.01342263f, 0.16366477f, 
    0.04244046f, -0.11094891f, -0.03181503f, -0.20834285f, -0.08004098f, -0.08766223f, -0.16176522f, 0.26858547f, 
    0.11417326f, -0.00000054f, 0.01798217f, 0.14075698f, 0.03461164f, 0.00574269f, 0.01504116f, -0.00020725f, 
    0.17276864f, -0.00262264f, -0.20350449f, -0.20626920f, 0.10332073f, 0.07342864f, -0.01060402f, 0.11994443f, 
    0.09820720f, 0.07201352f, 0.13185553f, 0.17608762f, -0.08148362f, -0.13907516f, 0.12147430f, 0.09141660f, 
    0.02955588f, -0.08257974f, -0.01569231f, -0.14886959f, 0.02591829f, 0.05331816f, 0.14640065f, 0.11720321f, 
    0.34528062f, -0.03338234f, -0.09463654f, 0.05169791f, 0.07374024f, 0.06473279f, 0.05012592f, -0.08320455f, 
    -0.01165043f, 0.07681931f, 0.10722192f, 0.14704543f, -0.08822854f, -0.12357502f, 0.02673286f, -0.04747676f, 
    -0.20258433f, 0.14170505f, 0.06068317f, -0.06105529f, -0.03897596f, 0.02488524f, -0.02025870f, -0.07284224f, 
    -0.16095394f, -0.07277031f, -0.03734817f, 0.03821762f, 0.17429817f, 0.03944953f, 0.13128698f, -0.09137217f, 
    -0.07471550f, -0.03694022f, -0.07564570f, -0.16861968f, -0.02006335f, 0.03542445f, -0.18162984f, -0.01270785f, 
    0.15646406f, -0.04687083f, 0.12523918f, 0.06234814f, 0.05341772f, -0.02044093f, -0.18882570f, 0.08705115f, 
    0.09327489f, -0.19870695f, 0.04280576f, 0.10056919f, 0.11720122f, 0.03151840f, 0.01193072f, -0.04057548f, 
    0.02760983f, -0.03827396f, -0.01915725f, 0.01663216f, -0.17072423f, -0.35649002f, 0.01426332f, 0.06901880f, 
    0.04987419f, 0.01084963f, 0.05704434f, -0.10216158f, 0.02757579f, 0.13792239f, 0.02360503f, 0.35395333f, 
    0.00635789f, 0.23938459f, 0.02323691f, 0.21476191f, 0.01715035f, 0.01976971f, 0.10159069f, -0.09334406f, 
    0.08572803f, 0.03751549f, -0.07223289f, 0.12763955f, -0.04199304f, 0.29779172f, 0.11178458f, 0.02596082f, 
    -0.12999958f, 0.01916854f, 0.02157991f, -0.00537894f, 0.03520685f, -0.02343426f, 0.08103952f, -0.07420149f, 
    -0.07718500f, -0.02454787f, -0.07731792f, -0.06840756f, 0.02286908f, -0.03496117f, 0.00410106f, -0.00415159f, 
    0.05297662f, -0.02698876f, 0.00498796f, -0.04228229f, -0.07897191f, 0.04300781f, -0.05263308f, 0.01465882f, 
    -0.01308275f, 0.03885836f, -0.08135048f, -0.00543568f, -0.01839864f, 0.00019097f, -0.00416335f, -0.05648672f, 
    0.04863872f, 0.04011982f, -0.08551770f, -0.03089425f, 0.03920646f, 0.01567772f, -0.04916758f, 0.06381036f, 
    0.01980442f, -0.05965929f, 0.03937216f, -0.01371981f, 0.03006922f, -0.07817299f, -0.04810773f, 0.01118695f, 
    -0.06082327f, -0.05070871f, -0.07055144f, -0.04048988f, 0.04512595f, -0.03234679f, 0.01772675f, -0.01812445f, 
    -0.06938010f, -0.00709157f, -0.08861037f, 0.01790892f, 0.03779291f, 0.02257975f, -0.07186485f, 0.02095338f, 
    -0.02291240f, -0.03739406f, -0.04883036f, -0.01469509f, 0.02498800f, 0.00175067f, 0.03635460f, -0.00664428f, 
    -0.04117643f, 0.02456124f, -0.00555847f, 0.03685750f, -0.08050949f, -0.07472204f, -0.05547291f, 0.03014358f, 
    -0.00712184f, 0.06112811f, -0.07656687f, 0.01003458f, 0.06358709f, 0.04401704f, -0.07380024f, 0.02181679f, 
    -0.04234130f, 0.02220952f, 0.00187252f, 0.02328331f, -0.08784110f, -0.02644719f, -0.04026163f, -0.05714852f, 
    -0.04396822f, 0.03462203f, -0.01592206f, -0.04138243f, -0.05803851f, -0.05306599f, 0.02848038f, -0.03110345f, 
    0.01040893f, -0.06284991f, -0.05983244f, 0.06459490f, -0.02499910f, -0.02109967f, -0.04144202f, 0.04094147f, 
    -0.07020096f, -0.07658788f, -0.04174029f, 0.00460460f, 0.05436974f, -0.04077929f, 0.03456892f, 0.02504263f, 
    0.04431162f, 0.02534871f, -0.02921788f, 0.04419199f, -0.01767363f, -0.04122382f, 0.02846559f, -0.05208166f, 
    -0.03660455f, -0.01214153f, -0.00222521f, 0.00284218f, 0.05356958f, 0.02481568f, 0.00341837f, -0.05789429f, 
    -0.00370446f, 0.03300485f, 0.02121080f, -0.00062983f, 0.02592049f, 0.05094908f, -0.03081110f, 0.01955499f, 
    0.06611311f, 0.04280106f, 0.03819989f, 0.05572096f, 0.02572412f, 0.06142207f, -0.07105557f, -0.07726794f, 
    0.00560775f, 0.02493559f, 0.00003441f, -0.07004759f, 0.07456231f, 0.00227404f, -0.01790060f, -0.06587073f, 
    -0.01540551f, -0.06087463f, -0.06116373f, -0.05420472f, -0.05549083f, -0.03136233f, -0.06127495f, 0.03269447f, 
    0.07152099f, 0.00940336f, 0.01965064f, 0.00962713f, -0.02190193f, 0.04427137f, -0.03374589f, -0.01467706f, 
    0.05227422f, 0.00151049f, -0.00705144f, 0.03618535f, 0.07008485f, 0.01689965f, 0.00750943f, -0.05189846f, 
    0.04232896f, 0.04541630f, -0.01521233f, 0.05158528f, -0.03819443f, 0.05199815f, 0.02948464f, -0.08433922f, 
    0.03263460f, -0.05955506f, -0.01144696f, -0.09003511f, -0.00639965f, -0.05125451f, -0.06253881f, 0.03288430f, 
    0.27029574f, 0.21453474f, -0.06696815f, 0.31256148f, -0.02809728f, 0.11804510f, -0.07278295f, 0.12945755f, 
    -0.08702459f, -0.02427596f, 0.03872747f, 0.05697595f, -0.22096902f, 0.21831954f, -0.05148925f, -0.11091667f, 
    0.05399343f, 0.08954541f, -0.06166937f, -0.03877651f, -0.12523139f, 0.01098323f, -0.03515115f, 0.01335359f, 
    0.02544533f, 0.08812597f, -0.11205253f, 0.02262889f, 0.12972791f, -0.05254805f, 0.06433589f, -0.07507392f, 
    -0.07195724f, 0.00706901f, 0.15397999f, 0.05954432f, -0.10163387f, 0.21288890f, 0.00808528f, -0.07523260f, 
    -0.04168841f, 0.13775165f, 0.15403104f, -0.11077694f, 0.11322411f, 0.00071986f, -0.00804835f, -0.05899894f, 
    -0.56683749f, -0.09251310f, 0.07999223f, -0.11062288f, 0.02681527f, -0.03801267f, 0.10725829f, 0.11953085f, 
    -0.02722367f, -0.08247679f, -0.03349848f, 0.13615428f, 0.10798006f, 0.10928228f, -0.09108963f, -0.15547426f, 
    0.08167785f, 0.10527331f, 0.05973904f, -0.07195497f, 0.05309755f, 0.04649412f, 0.02069337f, 0.09218758f, 
    0.16057874f, 0.01890871f, -0.03820498f, 0.26624230f, -0.01938998f, -0.04264468f, 0.06389694f, 0.02555508f, 
    0.09037431f, -0.03230795f, -0.00771259f, -0.21662717f, -0.11869357f, 0.01393670f, 0.08668793f, 0.09539700f, 
    0.01386712f, 0.03623805f, 0.03611264f, 0.01616345f, 0.04161834f, 0.03519480f, -0.03978666f, 0.02653184f, 
    0.14729112f, 0.02577623f, 0.00295191f, 0.16744003f, 0.01139983f, 0.10232193f, 0.09297918f, 0.17488769f, 
    -0.03765874f, -0.08472577f, -0.04356467f, -0.12614568f, 0.02484363f, -0.03158471f, -0.08997098f, -0.02383050f, 
    -0.19781931f, -0.01335533f, 0.01849120f, 0.08036157f, -0.08704471f, -0.02731209f, 0.02154083f, -0.09320699f, 
    0.07225695f, -0.09971997f, 0.05861169f, 0.18535809f, 0.11915047f, 0.02134284f, 0.06056752f, 0.15455784f, 
    -0.01833429f, 0.32002747f, 0.07245702f, 0.08524842f, 0.02678695f, 0.00047122f, 0.20318688f, -0.12652920f, 
    0.17040713f, -0.05251333f, 0.04081582f, 0.08634924f, -0.05145710f, 0.12029897f, 0.24116969f, -0.05010572f, 
    0.04024282f, 0.15106055f, -0.00758527f, -0.17164649f, 0.03045803f, -0.00970479f, 0.07725676f, -0.02901875f, 
    0.07902631f, -0.05405631f, 0.06433716f, 0.06526278f, 0.06194031f, 0.17583789f, 0.09935942f, -0.27673170f, 
    0.07060266f, 0.07764205f, 0.11927875f, -0.01720505f, -0.00663012f, -0.05377921f, -0.06987723f, -0.04395456f, 
    -0.07591141f, -0.13648774f, 0.16949178f, 0.29336154f, 0.01222706f, -0.08977578f, -0.12103149f, 0.14608167f, 
    -0.10575595f, 0.01238526f, -0.13114990f, -0.00557059f, -0.34577578f, -0.23805383f, -0.21555044f, -0.14068054f, 
    -0.05167512f, -0.05169854f, 0.05304922f, 0.00993517f, -0.06524572f, 0.14012796f, 0.06183489f, 0.05796656f, 
    -0.51816374f, 0.10157939f, -0.04814609f, 0.05104564f, -0.04342720f, 0.01756802f, 0.08811505f, -0.04468431f, 
    -0.05263109f, 0.04043951f, 0.12987600f, -0.02863983f, -0.10875772f, -0.13328481f, 0.27592918f, 0.17227757f, 
    0.05893748f, 0.01058926f, -0.01227846f, -0.04810876f, 0.01696532f, -0.21722554f, 0.01559439f, 0.11846373f, 
    -0.03281287f, 0.00410199f, 0.01978456f, 0.22457106f, 0.10976758f, -0.05843428f, 0.04825012f, -0.08567745f, 
    -0.05726052f, 0.04885511f, -0.07303277f, -0.06568818f, 0.24381076f, -0.22165522f, 0.13951609f, -0.11114083f, 
    0.10174927f, -0.04651337f, -0.06000340f, 0.02676507f, 0.11348575f, 0.08693366f, 0.02230552f, -0.01725059f, 
    0.41960594f, -0.01009344f, -0.02941673f, -0.01651056f, 0.06562714f, -0.06117722f, 0.11935287f, -0.02381836f, 
    -0.00875159f, -0.06266892f, -0.01032571f, 0.04363910f, -0.18251301f, -0.02301611f, -0.19184114f, 0.08178889f, 
    0.14023168f, 0.08615118f, 0.01657602f, -0.09451109f, 0.01264801f, -0.14599940f, -0.09878708f, -0.15027232f, 
    0.14494731f, -0.19410309f, -0.02980443f, -0.16165695f, 0.05418000f, 0.16584101f, 0.06412049f, -0.00367967f, 
    -0.12131816f, -0.07564948f, 0.01929474f, -0.01155390f, -0.03673697f, 0.17687508f, 0.00411430f, -0.07509303f, 
    0.27158540f, 0.07106226f, 0.05267492f, 0.01249853f, 0.02582915f, -0.00547890f, -0.02106445f, 0.06442976f, 
    -0.07740474f, -0.10378500f, 0.04156511f, -0.04841240f, -0.09834444f, 0.00934533f, 0.05910308f, 0.05856088f, 
    -0.09909400f, -0.11306013f, 0.03733190f, -0.04090724f, -0.07461971f, -0.16200033f, 0.22038198f, 0.26610020f, 
    0.12438340f, -0.02515291f, -0.10164167f, 0.02519147f, 0.08942944f, -0.04864601f, 0.17004007f, 0.04921639f, 
    0.29434308f, -0.01273119f, -0.04956681f, -0.13029404f, 0.13336533f, 0.04308167f, 0.01796446f, -0.10287791f, 
    0.03939271f, 0.13010184f, 0.01119589f, 0.12388022f, 0.10519618f, -0.04328499f, -0.05850626f, -0.19606943f, 
    -0.05777987f, -0.02685817f, 0.04244232f, -0.11223742f, 0.12802571f, 0.01525511f, 0.00725454f, 0.03736322f, 
    0.10266629f, 0.23478003f, -0.01111951f, -0.07391033f, 0.16141239f, 0.07176320f, 0.00139765f, -0.12430198f, 
    -0.08650277f, 0.05256449f, 0.14991707f, -0.01076251f, -0.12031733f, 0.13500358f, 0.00517013f, -0.13895716f, 
    0.18140517f, -0.03496157f, -0.00213917f, -0.10407592f, -0.12943326f, -0.07415441f, 0.14076558f, -0.03356172f, 
    0.28845713f, -0.44974139f, -0.01454434f, 0.05331567f, -0.00687200f, -0.10967867f, -0.10926040f, -0.13993026f, 
    0.05861729f, -0.08073079f, -0.00282549f, 0.00871772f, 0.02688806f, 0.05946932f, 0.13721153f, 0.29883337f, 
    -0.00107759f, -0.01886163f, 0.07043520f, 0.14041974f, -0.01415323f, 0.08472554f, 0.04360398f, -0.07773253f, 
    0.04098930f, -0.02947222f, -0.00528225f, -0.06389079f, -0.03697145f, 0.04423277f, -0.04264790f, 0.01902827f, 
    0.03002034f, -0.04260259f, 0.00010476f, 0.00259929f, 0.01219953f, -0.03781717f, -0.07351939f, 0.00567959f, 
    0.02219853f, -0.03067092f, -0.02193211f, -0.00559405f, -0.05016343f, 0.00464692f, -0.04233283f, -0.01756464f, 
    -0.00668200f, -0.04239906f, 0.00385877f, 0.06348192f, 0.06470601f, -0.00411532f, 0.01212847f, -0.01542374f, 
    0.01735017f, 0.00047320f, -0.02660302f, 0.04411564f, -0.07584532f, -0.02459717f, 0.00615362f, 0.00887446f, 
    -0.06365287f, 0.06483977f, 0.05757868f, 0.02374291f, -0.05531871f, 0.00832048f, -0.00620379f, -0.04497004f, 
    -0.04424561f, 0.00004941f, 0.02808466f, -0.03150084f, 0.05996126f, 0.05530614f, 0.02005263f, 0.01793499f, 
    0.05752316f, 0.03765301f, -0.04221560f, 0.01800032f, -0.03109057f, -0.04465601f, -0.00641802f, -0.02602735f, 
    -0.02412973f, 0.00098569f, -0.05496044f, 0.02538095f, 0.03816561f, -0.04534962f, 0.00799554f, -0.00257233f, 
    -0.03435807f, 0.03444009f, -0.03838856f, 0.04237450f, -0.04116498f, 0.03480228f, -0.07478745f, 0.00370944f, 
    -0.07692497f, -0.05590238f, -0.02872928f, 0.05101913f, -0.07441340f, -0.04904795f, 0.02098832f, 0.03573270f, 
    0.03674940f, 0.05198977f, -0.00876245f, 0.02545761f, 0.04617043f, -0.04788069f, -0.06587856f, 0.00702352f, 
    -0.02140297f, 0.03006282f, -0.07198067f, 0.03939887f, 0.00241140f, 0.01884708f, -0.03809071f, 0.04288936f, 
    -0.01792184f, -0.05241197f, -0.04851498f, -0.04496410f, -0.03439435f, -0.04887669f, -0.03678202f, -0.06820820f, 
    -0.01661018f, -0.00969276f, 0.02842537f, -0.07171234f, -0.02092248f, 0.06461786f, 0.05901127f, 0.01712655f, 
    0.06602005f, -0.01626113f, -0.00632827f, -0.06435554f, -0.04239161f, -0.05143721f, 0.02602600f, -0.00649345f, 
    0.04079587f, 0.02931464f, -0.00608808f, -0.05247116f, -0.02420517f, -0.01793364f, 0.02073903f, -0.00207484f, 
    -0.05631704f, -0.01748904f, 0.00921736f, -0.06295267f, 0.00425378f, 0.04720029f, 0.04659226f, -0.05628718f, 
    -0.05505679f, -0.01450945f, -0.05704832f, -0.05570233f, 0.05192359f, 0.03230337f, 0.06424485f, 0.05130823f, 
    -0.02642918f, -0.07164612f, 0.02463697f, -0.06880817f, 0.02998663f, -0.00226094f, 0.02621496f, 0.03825468f, 
    -0.06695995f, 0.04105335f, -0.01979195f, 0.02822720f, -0.01371914f, -0.06116167f, -0.06374560f, -0.06396767f, 
    -0.04099572f, -0.01318152f, -0.06783690f, -0.03386934f, 0.00003682f, -0.06925894f, 0.00097163f, 0.05795585f, 
    0.03024959f, 0.06008341f, -0.05660224f, 0.02987738f, -0.07646179f, -0.06176373f, 0.02706885f, -0.01182695f, 
    0.05912555f, 0.05157517f, -0.07748215f, -0.01186350f, -0.07148767f, -0.04656203f, 0.02075206f, -0.03277063f, 
    -0.00649905f, -0.38757822f, 0.03651889f, 0.05826266f, 0.17213802f, -0.03841655f, 0.21997300f, -0.10533786f, 
    0.13671482f, -0.01818428f, -0.05998746f, -0.08018429f, 0.10786098f, 0.03037276f, -0.00164854f, -0.01794958f, 
    -0.13524885f, -0.18909532f, 0.00223993f, 0.06827250f, 0.05910244f, 0.07807524f, 0.03489991f, -0.06207358f, 
    0.16382606f, 0.09281700f, -0.23052488f, 0.02331425f, -0.15111791f, -0.08341022f, 0.05850780f, 0.13828920f, 
    -0.02220032f, -0.05549333f, -0.06887884f, 0.01771823f, 0.23680615f, -0.14323744f, -0.06408045f, 0.20942213f, 
    0.09377857f, -0.08725455f, -0.06865435f, 0.09507118f, -0.02262291f, -0.05652637f, 0.04598013f, 0.00675011f, 
    -0.04249229f, 0.17993848f, -0.22747312f, 0.05658861f, 0.08758071f, 0.02439190f, 0.00553061f, 0.06599198f, 
    0.06103126f, 0.11193790f, 0.03388100f, 0.01413086f, -0.17283110f, -0.13403979f, 0.04600780f, 0.27185753f, 
    -0.04507490f, 0.05908797f, -0.03187328f, 0.02982042f, 0.07492287f, 0.09500241f, 0.11486266f, 0.11945777f, 
    -0.45475414f, -0.03174534f, 0.05757816f, -0.11187136f, -0.01211334f, 0.04620687f, 0.07348283f, 0.01066538f, 
    0.09741293f, 0.03942801f, -0.04888832f, 0.07282972f, -0.09376644f, -0.15405869f, 0.08708977f, -0.00179510f, 
    0.07894247f, -0.00442055f, -0.12507743f, 0.04321127f, -0.09586427f, 0.02420815f, 0.00623872f, 0.02219513f, 
    0.00093618f, 0.04601470f, 0.03345991f, 0.07844316f, 0.05151686f, 0.12718740f, -0.02331487f, 0.01629866f, 
    0.13613914f, 0.02775404f, -0.01066861f, 0.03310801f, -0.01012073f, -0.02752792f, -0.04168652f, -0.02370939f, 
    0.04678745f, -0.22260764f, -0.18973202f, 0.00970851f, 0.08863348f, 0.03768789f, -0.07447270f, 0.00393922f, 
    -0.26841772f, 0.08276383f, 0.07872554f, -0.11871313f, -0.02125157f, 0.20640138f, 0.10838993f, 0.02201783f, 
    0.03444989f, -0.11985433f, -0.03321941f, 0.03092667f, -0.13284424f, 0.25699234f, -0.16615658f, 0.13827986f, 
    0.14243715f, 0.17728411f, -0.12890179f, 0.07891366f, -0.15992162f, -0.07286393f, -0.02032026f, 0.00043834f, 
    0.02487551f, -0.11766496f, -0.03258404f, 0.18787065f, -0.03793054f, -0.00278108f, 0.04284600f, 0.08928609f, 
    -0.05070367f, 0.04510109f, 0.02475449f, 0.05033685f, 0.06667010f, -0.14602084f, -0.01323381f, 0.24703225f, 
    -0.01457941f, 0.01968589f, -0.02907637f, 0.02241945f, 0.01687218f, 0.07955637f, -0.06220395f, 0.07439486f, 
    -0.09507422f, 0.45572588f, 0.07928711f, -0.10424536f, 0.02201282f, 0.12936014f, -0.07613585f, -0.00918035f, 
    -0.00287413f, 0.08700388f, 0.12014120f, -0.05611413f, 0.26999545f, 0.07425670f, -0.09077232f, 0.06840809f, 
    0.00213226f, -0.12028202f, 0.09236176f, 0.06711520f, -0.01992805f, -0.04869109f, -0.12922442f, -0.07059488f, 
    -0.00839498f, 0.01792058f, 0.02952356f, 0.01070127f, 0.04914028f, 0.02804420f, -0.07141554f, -0.06590290f, 
    -0.02378087f, -0.03010022f, 0.03585769f, -0.03325014f, -0.02481631f, 0.01568920f, 0.00709975f, 0.00927733f, 
    -0.06579810f, 0.06291069f, -0.08399047f, -0.03838782f, 0.03214775f, -0.02252547f, 0.04788795f, 0.02041474f, 
    -0.00605242f, 0.03572749f, 0.05512256f, 0.00717774f, -0.03147045f, 0.01496411f, 0.04672804f, -0.07207979f, 
    -0.04969448f, -0.04579397f, -0.03854160f, 0.05962610f, -0.07685266f, -0.02328135f, -0.05560549f, -0.05516024f, 
    -0.03801561f, -0.04006594f, 0.00178733f, -0.00203949f, -0.07160727f, -0.06467334f, 0.04795612f, 0.05832777f, 
    -0.05497693f, -0.07598235f, 0.03327507f, 0.03027327f, -0.07110288f, -0.04751895f, -0.04228538f, -0.03555263f, 
    -0.04954365f, -0.04525609f, -0.07169947f, -0.01932692f, 0.01295214f, -0.09076922f, -0.06800092f, 0.05182575f, 
    0.05564060f, -0.03579349f, -0.03928739f, 0.05541111f, 0.01517162f, -0.00521362f, 0.01886547f, -0.07694656f, 
    -0.01487851f, 0.03127733f, 0.03916775f, -0.01474842f, -0.05052531f, -0.06584306f, -0.02508300f, -0.00332026f, 
    0.04564896f, 0.01507380f, -0.06858958f, 0.05239239f, -0.07000327f, 0.06567829f, -0.05356156f, -0.06751853f, 
    -0.01251502f, -0.07251866f, -0.04767321f, 0.01754243f, -0.04381858f, -0.02624225f, -0.00151369f, -0.04845805f, 
    -0.06373091f, 0.04880716f, -0.04751747f, -0.04025634f, -0.05542324f, -0.06939840f, 0.05410585f, 0.05862898f, 
    0.00130232f, -0.06736029f, 0.01537584f, -0.00809236f, 0.00497270f, -0.05279462f, -0.05768901f, -0.01473346f, 
    -0.05151605f, -0.05474170f, -0.05100552f, -0.05384336f, 0.02498314f, -0.01227385f, 0.03916271f, -0.07029476f, 
    -0.01649636f, 0.02568540f, 0.06626163f, -0.02399888f, -0.00587293f, 0.04698239f, 0.00680618f, 0.00704338f, 
    -0.06837785f, -0.01360729f, -0.06872903f, 0.04291511f, -0.06234334f, -0.07945689f, -0.01567466f, 0.02574014f, 
    -0.00494314f, 0.01821005f, -0.04644249f, 0.01230066f, -0.02574316f, 0.04556533f, -0.04203102f, 0.06369255f, 
    -0.03588751f, 0.01431475f, 0.03279304f, 0.02153808f, -0.02296294f, -0.05157420f, -0.04644047f, 0.05366794f, 
    -0.01853335f, 0.04339770f, 0.06342486f, -0.03352851f, 0.02241324f, 0.00621474f, 0.00190353f, -0.05453419f, 
    -0.01813205f, 0.01832175f, 0.04670720f, 0.04440982f, -0.05919079f, -0.02588378f, -0.06817216f, 0.03273433f, 
    0.02177407f, -0.07010320f, -0.02821393f, -0.05109701f, 0.02606784f, 0.01885740f, -0.04070602f, 0.04827417f, 
    0.00470011f, 0.05950574f, -0.02928794f, -0.02036238f, -0.05243649f, -0.01890792f, -0.06021241f, 0.00454862f, 
    -0.03779210f, 0.03450415f, -0.07623891f, 0.00462367f, -0.04823830f, -0.00192360f, 0.00134477f, -0.01608318f, 
    0.20297037f, 0.14150850f, 0.01525495f, 0.07664322f, 0.14389795f, 0.11506062f, 0.06863340f, 0.10810810f, 
    0.04950450f, 0.13256162f, 0.08520956f, -0.08431646f, 0.10001872f, 0.12983611f, 0.14886430f, 0.02418227f, 
    -0.07017902f, -0.10104340f, 0.12495471f, -0.03725976f, -0.23524070f, 0.07285449f, -0.04678446f, -0.07477353f, 
    0.15004262f, -0.12407735f, -0.01233688f, 0.14213544f, -0.07271269f, -0.01158549f, -0.06556889f, 0.09773392f, 
    -0.02819248f, 0.10427115f, 0.14383219f, 0.13855194f, 0.49614114f, -0.01859026f, 0.09766411f, 0.03932283f, 
    -0.13432068f, 0.09613616f, 0.04987792f, -0.06567831f, 0.01143994f, -0.07237656f, -0.05962102f, -0.07617532f, 
    -0.12904710f, -0.28454709f, 0.03071471f, -0.06089355f, 0.19431891f, -0.01595788f, 0.04284270f, 0.03422211f, 
    0.04246774f, 0.01439761f, -0.00368482f, 0.24699609f, -0.02572254f, 0.09612364f, 0.00389726f, -0.26620033f, 
    0.05036132f, 0.08503036f, 0.13653173f, -0.19126612f, 0.03472978f, 0.05085212f, -0.05119619f, 0.10657541f, 
    0.16093606f, 0.09326880f, 0.17091343f, 0.09180412f, -0.00146068f, 0.04937680f, -0.06525608f, -0.00919002f, 
    -0.01651099f, -0.01782479f, -0.11918259f, -0.10799459f, -0.19421703f, -0.09384909f, -0.11767622f, -0.09864922f, 
    0.00145214f, 0.00958352f, 0.05843188f, 0.07834829f, 0.00291318f, -0.11254620f, -0.01090534f, -0.11206444f, 
    -0.04637663f, 0.09827916f, 0.11673383f, 0.11122985f, 0.02925567f, 0.14369024f, -0.00822438f, 0.07872951f, 
    0.07874672f, -0.06563196f, -0.01571804f, -0.15892595f, 0.15815245f, 0.05429917f, -0.12624550f, -0.07243605f, 
    -0.11568840f, -0.01914508f, -0.26910514f, -0.06593737f, -0.02532718f, -0.01580418f, 0.03332566f, 0.00605580f, 
    0.10301343f, -0.02102707f, -0.12378067f, -0.15855867f, -0.11116227f, 0.00235387f, -0.01791911f, 0.12026349f, 
    0.02341754f, 0.37287316f, 0.17471239f, 0.12292260f, 0.21731251f, -0.06596693f, 0.10325421f, -0.19979405f, 
    0.07267944f, 0.08657966f, -0.06530651f, -0.01529456f, -0.15859123f, 0.04246106f, 0.34620416f, -0.13540803f, 
    -0.01589336f, 0.10563441f, -0.14217041f, -0.03841602f, 0.04609128f, -0.00313772f, 0.05249528f, 0.10103239f, 
    0.13352931f, 0.10702130f, 0.07876921f, 0.06050399f, -0.04182020f, 0.25585249f, -0.09159251f, -0.18149877f, 
    0.15556580f, 0.12726586f, 0.07622270f, 0.02459482f, 0.01435278f, -0.09142607f, -0.08797779f, -0.14044219f, 
    0.04416599f, -0.01538663f, 0.00105913f, -0.03697391f, 0.03880585f, -0.04468687f, -0.15861897f, 0.05359798f, 
    -0.03958791f, -0.07329413f, 0.03239978f, -0.09786858f, -0.04894800f, -0.11685506f, -0.00140078f, -0.05132480f, 
    0.00659116f, -0.14263645f, 0.19317336f, 0.11346573f, 0.00309427f, 0.15147936f, -0.02950360f, 0.08804329f, 
    0.03515588f, 0.21614148f, 0.22624640f, -0.05879628f, -0.04950948f, 0.10360947f, -0.06295586f, 0.02652648f, 
    -0.04745994f, 0.02915135f, -0.09089294f, -0.03308681f, -0.29291716f, -0.36861196f, -0.22229314f, 0.00046291f, 
    0.01660656f, -0.05779165f, 0.01142708f, 0.03467501f, 0.00669369f, 0.02718220f, 0.01819573f, 0.02562459f, 
    0.11483845f, -0.10860194f, -0.15154712f, 0.09169985f, 0.04740068f, -0.00822292f, -0.10982025f, 0.02277219f, 
    -0.02480759f, 0.03917247f, -0.13462068f, 0.10492252f, -0.04476416f, -0.09189632f, -0.16093028f, -0.07025762f, 
    0.06599869f, -0.05134583f, 0.02014019f, 0.11178930f, 0.00973937f, 0.08472200f, 0.08306768f, -0.05741914f, 
    0.33453751f, -0.00078160f, 0.03157958f, -0.03380197f, 0.05502264f, -0.03351825f, -0.06658586f, -0.09956338f, 
    0.13903050f, 0.23115520f, 0.04523923f, 0.17600389f, 0.06928290f, 0.19483040f, 0.26307207f, 0.01478618f, 
    -0.06511627f, 0.13748972f, -0.05951132f, 0.01075642f, 0.04522363f, 0.10662691f, 0.05927880f, 0.00717767f, 
    0.03303672f, 0.21503527f, 0.03047735f, 0.37912673f, -0.04839347f, 0.15200576f, -0.02431205f, -0.02331748f, 
    -0.12678188f, 0.06513796f, 0.05667374f, 0.00527316f, 0.17147259f, 0.16141377f, 0.07274105f, 0.10252957f, 
    0.02350922f, 0.13637288f, -0.14289770f, -0.12244753f, -0.04227323f, 0.05145635f, 0.07901372f, 0.03601354f, 
    -0.12396083f, 0.12299185f, 0.04979869f, 0.00713058f, -0.03570833f, 0.07266055f, 0.04419891f, 0.07730996f, 
    0.01624765f, -0.01525168f, -0.02877454f, 0.06636181f, -0.48398528f, -0.21255124f, 0.03673509f, -0.05606105f, 
    -0.00767202f, 0.13837215f, -0.05788045f, -0.06788486f, 0.00599021f, -0.16311404f, 0.04928058f, 0.09150399f, 
    0.03469352f, 0.08670653f, 0.02123548f, 0.21989593f, 0.06363197f, -0.05157141f, -0.02249608f, -0.05856968f, 
    0.12202498f, -0.00817398f, 0.12415815f, -0.02463397f, 0.10432711f, -0.03496756f, 0.08037917f, 0.12444484f, 
    -0.01566253f, -0.17740457f, -0.12918460f, -0.20645072f, 0.17381348f, -0.02168233f, 0.03189711f, 0.01431983f, 
    -0.07866690f, 0.12121253f, 0.18595874f, 0.03310132f, -0.05848513f, -0.02488710f, -0.11563130f, -0.06695727f, 
    0.06851675f, 0.02629514f, 0.07585262f, 0.09150627f, -0.11836512f, -0.01656003f, -0.00296108f, 0.00396917f, 
    -0.02278453f, -0.11273902f, -0.04547676f, 0.00563813f, -0.01344273f, 0.01192668f, -0.00506660f, -0.05423166f, 
    0.03333323f, -0.01827545f, -0.10284021f, -0.16785802f, 0.01110917f, 0.01462428f, -0.03275952f, 0.10238571f, 
    0.09198626f, -0.00322606f, -0.04989894f, 0.21561785f, -0.04972769f, -0.07074068f, 0.06919896f, -0.18985297f, 
    0.01319756f, -0.01777871f, -0.08282974f, 0.10199856f, -0.08849692f, 0.07119375f, 0.06076135f, 0.14239535f, 
    0.09137700f, -0.05159722f, 0.10895745f, 0.10097346f, -0.20858379f, 0.08776135f, -0.11249801f, 0.04801136f, 
    -0.10470989f, -0.00372861f, 0.04513095f, -0.16035503f, 0.30120340f, 0.23941126f, 0.14088187f, 0.03685123f, 
    0.17435539f, 0.10602816f, 0.03743434f, -0.04978524f, 0.01990569f, 0.08988225f, -0.06474943f, -0.02116420f, 
    -0.17814645f, 0.16149974f, -0.03862360f, -0.15229492f, 0.27830812f, 0.10674176f, 0.12655160f, 0.02514672f, 
    -0.10326290f, 0.05358725f, 0.09266273f, 0.10053447f, -0.28049609f, 0.14382499f, -0.00475233f, 0.07364196f, 
    0.02285318f, -0.08652921f, 0.10911731f, 0.00811984f, 0.04402550f, -0.01133077f, -0.12725045f, -0.01765541f, 
    -0.27546889f, 0.03934472f, 0.12566790f, -0.18494563f, 0.00654860f, 0.05232767f, -0.04390977f, -0.12835120f, 
    -0.04141504f, -0.09261550f, 0.06409712f, -0.13931657f, 0.14850293f, -0.03396951f, 0.05538413f, -0.02815672f, 
    0.00675010f, 0.00518133f, -0.16441204f, -0.14100204f, -0.09379667f, 0.01560202f, 0.05380553f, -0.04226918f, 
    -0.24411388f, 0.06819469f, 0.21385385f, 0.12307974f, -0.10158797f, -0.05094296f, -0.06485443f, -0.13148098f, 
    -0.08426302f, -0.02931491f, -0.18066907f, 0.06246485f, 0.05436575f, 0.21301223f, -0.06402193f, -0.07745637f, 
    -0.03287892f, -0.21218748f, 0.17910576f, -0.02033345f, 0.01555024f, -0.05593910f, -0.00574401f, -0.00659572f, 
    -0.00848583f, 0.15997231f, 0.10884642f, 0.11143878f, -0.11728591f, -0.03827336f, -0.16976838f, -0.05087953f, 
    -0.04610667f, 0.02666557f, -0.15085137f, -0.10510275f, 0.45621285f, 0.06925475f, -0.05385724f, 0.11544674f, 
    0.18206555f, 0.03997221f, 0.06516238f, -0.15187491f, 0.01426460f, 0.14792719f, -0.24857093f, 0.12881157f, 
    0.17324996f, -0.11164975f, 0.06596153f, 0.11671899f, -0.00640640f, 0.04280851f, 0.01615812f, 0.01943535f, 
    -0.02090732f, 0.11610318f, 0.07745536f, 0.21607463f, 0.04072978f, -0.16682124f, 0.02039040f, 0.09583139f, 
    0.04863986f, -0.10999595f, -0.05403040f, -0.00192589f, 0.00713536f, -0.01800123f, 0.08458238f, -0.02501113f, 
    -0.05939311f, 0.03838682f, 0.01655213f, -0.15075085f, -0.21001413f, -0.07727205f, -0.07221462f, -0.11938018f, 
    -0.03040854f, -0.13029435f, 0.03165759f, -0.03651429f, 0.26688004f, 0.22531733f, 0.16988541f, 0.00540886f, 
    -0.02200709f, -0.08556104f, 0.01429658f, -0.12523484f, -0.06371748f, -0.04520150f, -0.05559468f, -0.00140350f, 
    -0.12561858f, -0.13025784f, 0.32145682f, 0.09019406f, 0.10750785f, -0.01428071f, 0.01028952f, -0.19457440f, 
    0.02117047f, -0.10135689f, -0.05873429f, 0.10969504f, -0.00257763f, 0.13755226f, -0.33628041f, -0.17637965f, 
    0.12790921f, 0.04668909f, 0.14220481f, -0.02117607f, 0.05800430f, 0.03588006f, -0.03370813f, 0.01666239f, 
    0.04308878f, -0.22323766f, -0.00682553f, 0.03288791f, -0.01542877f, -0.22412154f, -0.06950273f, 0.05064449f, 
    -0.02880047f, 0.01276881f, -0.02506667f, 0.09432682f, 0.12668131f, 0.36775449f, 0.04786563f, -0.03010132f, 
    -0.01786938f, -0.00021986f, -0.03209697f, 0.07773901f, 0.01402427f, -0.07968780f, -0.02176919f, 0.03228492f, 
    -0.37126210f, 0.27576694f, 0.07621035f, -0.11249404f, 0.01632436f, -0.02239514f, 0.07458652f, 0.05369712f, 
    0.05646297f, 0.01046751f, 0.07733531f, -0.00679522f, -0.26559654f, 0.05470358f, 0.14017600f, 0.10127363f, 
    0.14721341f, 0.02578253f, -0.01485456f, -0.12499775f, -0.00021877f, -0.04343138f, -0.09175707f, 0.01112714f, 
    -0.12177891f, 0.27077925f, -0.12278780f, 0.09089242f, -0.10678846f, 0.10747511f, 0.00816971f, 0.08905660f, 
    0.02891330f, -0.16613615f, -0.00024444f, -0.13166545f, 0.17293532f, -0.09142961f, -0.06563964f, 0.20752741f, 
    -0.06404106f, 0.05093202f, -0.05712689f, 0.04755464f, 0.03178685f, -0.03251612f, 0.04038324f, -0.10242467f, 
    0.19890818f, 0.04268854f, -0.11078530f, -0.38213781f, -0.00588385f, -0.14746033f, 0.02377525f, 0.02369322f, 
    0.12536317f, -0.07740702f, 0.07314845f, 0.02626112f, 0.26694590f, 0.01799189f, -0.02056570f, 0.07388958f, 
    -0.08161062f, -0.05583757f, 0.12691844f, 0.03586040f, 0.02217746f, 0.10987861f, -0.08624472f, 0.01669783f, 
    0.10796268f, -0.17558523f, -0.06617486f, 0.11173218f, 0.03345600f, -0.14136364f, -0.00280040f, -0.10916870f, 
    -0.04387662f, -0.03256717f, 0.12094543f, 0.08460326f, 0.19623290f, 0.28430966f, 0.04540490f, 0.17743774f, 
    0.16090411f, 0.00095794f, 0.25987667f, 0.09292491f, 0.01722196f, -0.05817063f, -0.09397779f, 0.07044715f, 
    -0.00679723f, 0.05303923f, 0.09334628f, 0.03853585f, -0.08092435f, -0.00720493f, -0.01457732f, -0.11879470f, 
    0.02704898f, -0.12357803f, -0.05841708f, -0.08820321f, -0.16720550f, 0.16023605f, -0.14794767f, 0.09005287f, 
    -0.05517089f, 0.07080800f, 0.06942258f, 0.01179977f, -0.07185259f, -0.08791308f, -0.02844254f, 0.00541969f, 
    0.17367023f, -0.04783191f, 0.10539354f, 0.12142773f, 0.00684992f, -0.09404967f, 0.00388816f, -0.01984061f, 
    -0.15232374f, 0.06894819f, 0.00725694f, -0.02570047f, 0.36791182f, -0.03777694f, -0.00931791f, 0.44964015f, 
    -0.13355593f, 0.06513643f, -0.01893065f, 0.01192987f, 0.00397507f, -0.01818861f, -0.04638131f, 0.15104668f, 
    -0.20821987f, -0.16352347f, 0.21330301f, 0.25645998f, 0.06393784f, -0.04499604f, -0.01617144f, -0.07504290f, 
    0.03350482f, -0.01550788f, 0.08383358f, -0.12341847f, 0.11584342f, 0.08494608f, -0.05072065f, 0.04878334f, 
    0.21477866f, 0.07241804f, -0.03874083f, 0.01365959f, 0.11760135f, 0.00956889f, 0.12612560f, -0.05605223f, 
    0.07810751f, -0.13560705f, -0.06799865f, -0.16481234f, 0.16764097f, -0.21875046f, -0.02161210f, 0.11645200f, 
    0.01899022f, 0.07934161f, 0.01953797f, -0.00708393f, 0.08181092f, -0.00425755f, -0.11356724f, -0.08953096f, 
    -0.10677771f, -0.08873300f, 0.03410004f, 0.00332923f, 0.12171675f, -0.02981307f, 0.04537220f, 0.03033126f, 
    -0.04378778f, 0.06095219f, 0.08727051f, -0.06388790f, -0.18054056f, 0.00750655f, 0.05986916f, 0.03403477f, 
    -0.08703405f, -0.00702953f, 0.07567331f, 0.01770579f, -0.03423027f, -0.02296574f, -0.13422461f, 0.18055817f, 
    0.00895985f, 0.04326662f, -0.18510753f, -0.11273640f, -0.03226091f, -0.05299688f, 0.14229307f, -0.03259095f, 
    0.31260547f, 0.15969975f, -0.06598087f, 0.19008122f, 0.07226949f, 0.08289167f, -0.07008751f, -0.11745428f, 
    -0.07809099f, 0.01712990f, 0.04097813f, 0.13593099f, 0.05733551f, 0.09732894f, -0.01602913f, 0.12406526f, 
    -0.01115354f, 0.01707375f, -0.01600659f, -0.00733124f, -0.11217363f, 0.00227580f, 0.05366675f, -0.09715152f, 
    0.65077621f, 0.01370210f, -0.02443231f, -0.26643077f, -0.04760500f, 0.03439341f, -0.04986948f, -0.00449968f, 
    -0.03547648f, -0.04093416f, 0.08468341f, 0.21478271f, 0.35079178f, 0.04738095f, 0.05751095f, 0.03733670f, 
    -0.11512572f, 0.11832416f, -0.02966603f, 0.00418620f, -0.11924464f, -0.05093304f, 0.01860085f, -0.00307617f, 
    0.02628949f, -0.14405416f, -0.26342785f, -0.02456721f, -0.01982608f, 0.04104113f, -0.01705428f, -0.08508562f, 
    0.12351191f, 0.10302237f, 0.00354998f, 0.02837422f, -0.00875875f, 0.21883798f, 0.25175098f, -0.12983032f, 
    0.03976959f, -0.08973571f, -0.03414904f, 0.07790047f, 0.04552077f, -0.10435715f, -0.05089059f, -0.03651186f, 
    0.00682403f, -0.00339441f, -0.02450455f, -0.10115769f, -0.10828840f, -0.00101016f, -0.01064433f, -0.06324159f, 
    0.09498634f, -0.14132524f, -0.08915526f, -0.02105284f, -0.21032405f, 0.07226761f, -0.03577846f, 0.08676436f, 
    -0.18203947f, 0.10808167f, 0.04177566f, -0.11011255f, 0.02912565f, -0.11528848f, -0.00724775f, -0.01936452f, 
    0.20358384f, 0.03038588f, 0.17086501f, 0.22436795f, -0.00138261f, 0.08867051f, -0.03493050f, -0.01696764f, 
    -0.08356721f, 0.04113203f, -0.00538319f, -0.07105860f, 0.13619569f, -0.04782334f, -0.11598399f, 0.49885565f, 
    0.03959317f, 0.05891009f, -0.09848956f, 0.02090039f, -0.09728187f, -0.15918677f, 0.04591252f, -0.03792592f, 
    -0.09882470f, 0.00307030f, -0.09473994f, -0.14329213f, -0.06574960f, 0.09129868f, 0.03525591f, -0.01636231f, 
    0.15516734f, 0.04387872f, 0.08421008f, -0.07766802f, 0.27694812f, 0.05324132f, 0.14809772f, -0.06215237f, 
    0.05224270f, 0.02810713f, -0.09371858f, 0.16993135f, 0.03442724f, -0.11125816f, 0.03257335f, -0.08587296f, 
    0.02882232f, -0.00212616f, 0.02541340f, 0.01591965f, -0.07465598f, -0.07864265f, 0.03912906f, -0.06572565f, 
    0.01676115f, -0.06514153f, 0.05031469f, -0.05813030f, 0.02385510f, -0.09049411f, 0.02506679f, 0.04681667f, 
    0.02674347f, -0.02637230f, 0.06326506f, -0.00573189f, -0.07826266f, 0.04705056f, -0.05746331f, -0.05872612f, 
    -0.04297403f, 0.00325943f, -0.01983435f, 0.00073133f, 0.03354306f, -0.01647793f, -0.01527768f, 0.02424367f, 
    -0.04739235f, 0.04433231f, -0.06530304f, 0.05721196f, -0.03820967f, -0.04476887f, 0.04298638f, -0.08033682f, 
    -0.07451309f, -0.07557573f, -0.07234827f, -0.00521964f, -0.04346813f, -0.04025025f, -0.03361259f, 0.04410788f, 
    -0.06342248f, 0.04234455f, -0.05616470f, -0.03708778f, -0.04911789f, -0.01767713f, -0.04670786f, 0.00448870f, 
    -0.04289928f, -0.03387073f, -0.05455103f, -0.06679112f, 0.02179727f, 0.00000438f, 0.07160908f, -0.08596746f, 
    -0.04919424f, 0.02835265f, 0.00453899f, 0.07148691f, 0.03447242f, 0.05249429f, 0.02781715f, 0.01421642f, 
    0.02558056f, 0.07334907f, -0.05782732f, -0.00230830f, 0.07694963f, -0.03795512f, -0.00636007f, -0.06471115f, 
    -0.01124187f, -0.01162914f, -0.03615219f, 0.00331796f, -0.01949203f, 0.03216596f, -0.00626039f, 0.02436123f, 
    0.01028441f, -0.03029132f, -0.02264951f, -0.03607018f, -0.06992070f, 0.05808598f, -0.03777120f, 0.06003100f, 
    0.02159538f, 0.00392007f, -0.00555107f, 0.07181961f, -0.06913971f, 0.01763842f, 0.01364098f, -0.06267709f, 
    0.01107981f, -0.08990192f, -0.06617121f, -0.04226850f, -0.02462277f, -0.04078192f, -0.00973745f, 0.00034382f, 
    -0.00724570f, -0.06853808f, 0.05027882f, 0.02250794f, 0.02461340f, -0.01927152f, -0.03222141f, 0.03862061f, 
    -0.02833869f, -0.01204603f, -0.07908711f, 0.00996892f, -0.01816157f, -0.04922827f, 0.05000956f, -0.02934386f, 
    0.02841264f, -0.03518741f, 0.06129860f, -0.04335204f, -0.01116859f, 0.00468454f, 0.01922661f, -0.02765357f, 
    0.03633699f, -0.04333060f, -0.07283638f, -0.08965320f, 0.03099563f, 0.02772260f, -0.00499166f, -0.03853121f, 
    -0.02132836f, 0.05188414f, -0.00510085f, -0.06982221f, 0.05433561f, -0.03571558f, -0.05495418f, -0.00182518f, 
    0.06045530f, -0.03418737f, -0.00838337f, 0.03065564f, 0.01598576f, 0.07625134f, 0.03422585f, 0.02817331f, 
    0.00951598f, -0.05388672f, 0.02424320f, -0.03235308f, -0.02390950f, 0.06694841f, -0.00832278f, -0.02012556f, 
    0.01526106f, 0.07655875f, -0.08225211f, -0.02358997f, -0.06039994f, -0.06286568f, -0.00054716f, 0.00515444f, 
    0.00495719f, 0.03426675f, 0.00572768f, -0.06022956f, 0.03959172f, 0.01535935f, -0.03023133f, 0.04873009f, 
    0.00399013f, 0.03741715f, -0.05703155f, -0.04289436f, 0.04676481f, -0.01811367f, 0.03011649f, -0.00632993f, 
    0.01697798f, 0.22390091f, 0.35941419f, -0.17984331f, 0.02450681f, -0.15674022f, 0.04205125f, 0.05272589f, 
    -0.01997663f, -0.07979011f, 0.17132503f, 0.02674248f, 0.21852621f, -0.03502363f, 0.11631554f, 0.08261848f, 
    0.05843383f, 0.01091427f, 0.04600947f, -0.05679048f, -0.14459899f, -0.15028906f, -0.04036267f, -0.03528050f, 
    0.01349640f, 0.11905123f, -0.06470867f, -0.06202606f, 0.05910762f, 0.15305705f, -0.05143268f, 0.05333915f, 
    0.02739157f, 0.17402600f, -0.11909444f, -0.07819062f, 0.16120508f, -0.02310305f, 0.04358552f, -0.04766072f, 
    0.12806635f, -0.00512451f, -0.00742146f, -0.01545149f, -0.01298627f, -0.12355687f, 0.06284031f, -0.00175808f, 
    0.01130846f, -0.12735943f, 0.11571504f, -0.15045637f, 0.14274406f, 0.10134488f, -0.07992495f, 0.14440912f, 
    0.08626597f, -0.11867215f, 0.12004642f, 0.02635657f, 0.12011737f, 0.22356299f, 0.02378992f, -0.21837156f, 
    0.08030565f, 0.05761825f, -0.11938635f, 0.08269956f, -0.04720368f, 0.02669981f, -0.07805553f, -0.01783422f, 
    0.23393853f, 0.05225034f, 0.18403302f, -0.16248377f, -0.01742743f, -0.04080509f, -0.03440035f, 0.02321329f, 
    -0.08869013f, 0.03553503f, -0.00745859f, 0.03542493f, -0.09992588f, -0.01672133f, -0.03731938f, -0.04012214f, 
    0.02301035f, 0.01369625f, 0.15940955f, -0.10428555f, 0.10459953f, 0.00631613f, -0.11921579f, 0.05202526f, 
    0.10564160f, 0.23229496f, 0.04369464f, -0.07639577f, -0.04633689f, -0.03086420f, 0.00044432f, -0.03843427f, 
    -0.18111406f, 0.08528548f, -0.04300909f, 0.01649052f, 0.02904007f, -0.08342332f, -0.02511067f, 0.15408708f, 
    0.02218940f, 0.17704459f, 0.04887252f, -0.07138859f, -0.03486064f, 0.10277798f, 0.01228628f, -0.01250662f, 
    -0.06970125f, -0.04590781f, -0.01926934f, 0.16277757f, -0.04143779f, 0.05819551f, -0.05634831f, -0.15299390f, 
    -0.02845541f, 0.09703030f, 0.09761962f, -0.10759735f, 0.19471811f, -0.05162565f, -0.12427136f, -0.06006763f, 
    -0.11765740f, 0.06918880f, -0.01387245f, 0.05853264f, 0.03224551f, -0.05520623f, 0.08328656f, -0.02913383f, 
    0.04609897f, 0.05794506f, 0.09070911f, -0.14972101f, 0.04025339f, 0.07268329f, -0.03797428f, 0.01717180f, 
    -0.09874924f, 0.04440870f, -0.04584822f, 0.08352089f, -0.17733149f, 0.11197942f, -0.06962044f, -0.08779196f, 
    0.00262782f, -0.03426500f, 0.03806975f, 0.06430811f, -0.13160905f, -0.00264054f, 0.00489117f, -0.00468519f, 
    0.37915438f, -0.12927316f, -0.29947779f, 0.19708566f, -0.07014023f, -0.01967509f, -0.02180284f, -0.04738295f, 
    -0.09252590f, -0.12843764f, 0.04015065f, -0.00779748f, 0.12135985f, 0.18674017f, 0.03510684f, -0.07914607f, 
    0.16221878f, 0.06459644f, 0.00379174f, 0.03593498f, 0.00231806f, 0.00692198f, 0.01947687f, -0.03293437f, 
    -0.33407030f, 0.00157013f, 0.11036825f, 0.19978216f, -0.23594856f, 0.01961543f, 0.15158956f, 0.01805863f, 
    0.03438186f, -0.01241326f, 0.02835076f, -0.03274576f, -0.58142054f, -0.22501406f, -0.21095639f, 0.02236156f, 
    0.11974569f, -0.05990406f, -0.07208379f, 0.15499789f, 0.11097607f, 0.08487581f, 0.07975492f, -0.02899159f, 
    -0.00428570f, 0.10069884f, -0.40867159f, 0.09560870f, 0.10051544f, -0.03476894f, -0.07822151f, -0.07493743f, 
    0.04661107f, -0.00936866f, -0.04003144f, 0.04254821f, -0.27215514f, -0.26663962f, -0.20194557f, -0.09507338f, 
    0.13648058f, 0.07478252f, 0.07016560f, 0.14951317f, 0.15606435f, 0.14525141f, 0.01352675f, -0.09668883f, 
    0.20630482f, 0.12498483f, 0.13765147f, -0.27194217f, -0.03521426f, -0.02334593f, 0.00483954f, 0.03870986f, 
    -0.15131533f, -0.06575931f, 0.10599260f, 0.00333641f, 0.06160172f, 0.07360283f, 0.02323569f, 0.25108477f, 
    0.09187751f, 0.15699102f, -0.10178143f, -0.07804756f, -0.00861261f, 0.07086925f, -0.00313988f, 0.17892750f, 
    -0.31962189f, -0.30294454f, 0.23972936f, 0.06172420f, -0.02810660f, 0.07664169f, 0.07811251f, -0.02782682f, 
    0.07734364f, -0.01063577f, 0.10162691f, -0.10447355f, 0.24272031f, 0.36622193f, 0.26756984f, -0.09026530f, 
    0.07441432f, 0.07480503f, 0.05311388f, -0.18153718f, 0.08992724f, 0.03052421f, -0.06741914f, 0.04038066f, 
    -0.16107726f, 0.04377501f, 0.25992239f, -0.04472583f, -0.21219963f, -0.00632190f, 0.15412658f, 0.03942347f, 
    -0.08410732f, -0.02292171f, -0.04301393f, -0.02825201f, -0.33922589f, -0.23993945f, -0.00902160f, 0.21431266f, 
    0.11867081f, -0.14702062f, -0.01358975f, 0.06445508f, -0.04862957f, -0.03670072f, 0.12637031f, 0.07648095f, 
    0.13507809f, 0.05936013f, 0.09398967f, 0.16987631f, 0.18224502f, 0.09467024f, 0.08431499f, 0.04572544f, 
    0.03533911f, 0.06818692f, 0.09837892f, 0.03954281f, -0.16600704f, 0.16250101f, 0.04604094f, 0.01137166f, 
    -0.01853394f, -0.01257909f, -0.00777982f, -0.11369808f, 0.10087196f, 0.15620172f, -0.05578863f, 0.05685519f, 
    -0.08171107f, 0.28360656f, 0.15844843f, 0.03741249f, 0.02107603f, 0.15533502f, 0.11398812f, -0.06141305f, 
    0.00561569f, -0.08162718f, 0.00705948f, 0.02914557f, 0.11212220f, 0.11134021f, 0.11647917f, 0.06498787f, 
    -0.09106946f, -0.11399897f, -0.02172678f, -0.06635359f, 0.01602459f, -0.00147266f, 0.04203720f, 0.06352677f, 
    0.03485936f, -0.15285170f, 0.21084602f, 0.12692307f, -0.16083305f, -0.14934842f, -0.07504699f, -0.05980821f, 
    0.07291495f, 0.20262112f, 0.21555780f, 0.01732932f, -0.09806461f, -0.13867310f, -0.20489693f, -0.13644189f, 
    -0.00527658f, -0.07564142f, 0.08155885f, 0.07643562f, -0.02727546f, 0.06778763f, 0.07406981f, -0.03740030f, 
    0.03189209f, -0.21418971f, -0.01685540f, 0.08362685f, -0.07667182f, 0.12437659f, 0.15021205f, -0.15449274f, 
    0.04540455f, 0.13615130f, 0.04619411f, -0.01455371f, 0.15121630f, -0.04032307f, 0.00726148f, 0.08199488f, 
    0.02096800f, 0.04247033f, -0.03180950f, 0.15132928f, -0.10945298f, 0.01226090f, -0.04112111f, 0.03600851f, 
    -0.36157915f, 0.16146667f, -0.13869415f, 0.11176360f, 0.09257690f, 0.06364075f, 0.09998344f, 0.14166018f, 
    -0.07189845f, -0.01209496f, 0.21199231f, 0.12948452f, -0.13054541f, 0.03911565f, -0.01308485f, 0.18677117f, 
    0.14231317f, 0.00313686f, 0.01643698f, 0.00637636f, -0.00804429f, 0.05674649f, -0.05141697f, -0.13414325f, 
    -0.02954618f, -0.20253564f, -0.25200376f, -0.12350605f, -0.02157757f, -0.01166070f, 0.03614185f, -0.10378852f, 
    -0.09865864f, -0.04498433f, 0.08720440f, 0.19812793f, -0.03233450f, -0.23536947f, 0.00684044f, 0.06490387f, 
    0.04982775f, -0.03430663f, -0.09185156f, -0.21641725f, -0.05056041f, 0.01954854f, -0.06268746f, 0.16230312f, 
    0.15080728f, -0.19753064f, 0.22755142f, -0.00744576f, -0.06306542f, 0.16787048f, -0.07865526f, -0.18165195f, 
    0.00116226f, -0.02653515f, -0.00829810f, -0.06396895f, -0.03425597f, 0.17023751f, -0.24928907f, -0.16759858f, 
    0.20902266f, 0.00943958f, 0.03488109f, 0.10920203f, 0.01861722f, -0.13881359f, -0.02419548f, 0.18547595f, 
    -0.06493074f, -0.06383020f, 0.08497415f, 0.01390966f, -0.07211019f, 0.17100856f, -0.21150064f, 0.07593311f, 
    0.14041045f, -0.25444597f, -0.14267109f, -0.12408710f, 0.33624521f, -0.22351871f, 0.00217895f, 0.03059949f, 
    0.07119106f, -0.19437151f, -0.19313002f, 0.16578011f, -0.01520200f, -0.18219350f, -0.16304682f, 0.08337943f, 
    0.19693454f, 0.07121927f, -0.02822710f, 0.02386904f, -0.01017312f, 0.18485674f, -0.03397986f, 0.07664183f, 
    0.12631930f, 0.25095347f, 0.17069709f, 0.16195653f, 0.04719669f, 0.19593643f, 0.16768634f, 0.04661091f, 
    -0.03720954f, 0.05704500f, -0.22649418f, 0.08394622f, 0.06026667f, 0.07332045f, 0.21702662f, 0.11217233f, 
    -0.16653924f, -0.00493808f, -0.03185783f, -0.20411302f, -0.05678278f, 0.12773909f, -0.10187351f, 0.03347179f, 
    -0.02962729f, -0.12614675f, 0.02852148f, -0.06245571f, 0.20513421f, 0.02288397f, 0.00004096f, 0.08786386f, 
    0.13473779f, -0.06025696f, 0.01907776f, -0.06199737f, -0.00088774f, -0.17453888f, -0.09207323f, -0.02597417f, 
    -0.14064942f, 0.04108734f, 0.30694181f, 0.01324806f, 0.05805708f, -0.00779930f, -0.20622340f, -0.17788237f, 
    -0.02054735f, -0.06880518f, 0.07197874f, -0.09822652f, -0.12599660f, -0.05859519f, -0.21598287f, 0.00976242f, 
    0.06899047f, -0.01480221f, 0.18454003f, 0.24403255f, -0.00866169f, 0.10397810f, 0.06258082f, 0.12255974f, 
    -0.25049382f, 0.11359791f, -0.02469503f, 0.13723721f, 0.06641444f, 0.12775673f, 0.00970488f, -0.08437655f, 
    -0.00032135f, -0.02346705f, 0.09684406f, 0.02505798f, 0.22319168f, -0.12397310f, 0.11914603f, 0.04743689f, 
    0.02450248f, -0.04093342f, 0.12744120f, -0.14582737f, -0.12653698f, 0.02907331f, 0.04954718f, 0.05525666f, 
    -0.20142786f, 0.11130156f, -0.18093957f, 0.08104874f, 0.00852684f, -0.05083104f, -0.10662622f, -0.00915487f, 
    0.09357332f, 0.04947955f, 0.09930377f, -0.06557192f, 0.05346230f, 0.05172367f, -0.07638653f, -0.18805172f, 
    0.16751830f, 0.01099148f, 0.09337036f, -0.04971582f, -0.04132565f, 0.01249880f, 0.04273504f, -0.02452598f, 
    -0.04202975f, -0.25533769f, -0.14592852f, -0.04094231f, 0.15801316f, -0.13104771f, 0.13257197f, 0.14456949f, 
    -0.01905690f, -0.11725716f, -0.03697643f, 0.05783832f, -0.07810361f, 0.12699938f, 0.09467981f, -0.19744523f, 
    0.28084317f, -0.03037722f, -0.08727572f, 0.00627108f, 0.13720915f, -0.09188909f, 0.05954172f, 0.06859774f, 
    0.19460219f, -0.12050990f, 0.33796051f, 0.08427516f, 0.00239605f, 0.06547644f, -0.06659701f, -0.01957898f, 
    0.02995259f, 0.04659352f, -0.04017933f, 0.04881667f, -0.44700667f, -0.06125565f, -0.08911131f, -0.18296127f, 
    0.19108103f, -0.03612303f, 0.02666760f, -0.00551000f, 0.08674577f, -0.01294407f, -0.02843714f, -0.12521762f, 
    0.08854499f, 0.20983814f, 0.17846268f, -0.11856606f, -0.01793465f, 0.10163526f, 0.02896460f, -0.06464226f, 
    0.07222477f, -0.10079899f, 0.04921358f, -0.03886433f, 0.11557859f, -0.24210845f, -0.15064444f, 0.05656758f, 
    -0.11286205f, -0.00898884f, -0.25564918f, -0.08611218f, -0.04579455f, 0.02897860f, 0.07228328f, 0.03555109f, 
    0.23516051f, 0.09718138f, 0.05517312f, -0.09615334f, 0.01057668f, 0.12792432f, -0.09265017f, 0.00242355f, 
    -0.00711622f, 0.17684431f, 0.14724374f, 0.14161561f, 0.35553691f, -0.02735465f, 0.04792409f, -0.25244558f, 
    0.02549658f, 0.00149661f, -0.02347606f, 0.13342641f, -0.02361481f, 0.11213400f, 0.04771901f, 0.12941615f, 
    0.06383250f, -0.07925590f, -0.02176645f, -0.27521685f, 0.11749754f, 0.08723090f, 0.00320573f, -0.00551925f, 
    0.08660590f, 0.10782965f, 0.08691328f, 0.12442745f, -0.39087716f, 0.19710080f, -0.08125958f, -0.19968159f, 
    0.25339398f, -0.01181275f, 0.00173104f, 0.02033832f, 0.00222566f, 0.02178169f, -0.05014141f, -0.07210020f, 
    0.37212896f, -0.07605641f, -0.07837769f, 0.11225139f, -0.13074338f, -0.03520314f, 0.01836025f, 0.07257066f, 
    0.00082289f, 0.01643623f, 0.01537127f, -0.07086586f, -0.08883700f, -0.10864366f, -0.01910531f, 0.20050114f, 
    -0.07595807f, -0.00657240f, 0.14228910f, 0.18355256f, 0.03733185f, 0.13779178f, -0.00448010f, 0.06375986f, 
    -0.13641688f, -0.13402568f, 0.11118680f, 0.10874852f, -0.11530399f, -0.05902443f, 0.02271037f, -0.02158843f, 
    0.09191822f, -0.04345068f, 0.00381850f, 0.02928336f, -0.15290889f, -0.11530963f, -0.07462806f, 0.11651701f, 
    0.05827723f, 0.01181611f, 0.05207381f, -0.10097820f, 0.03522479f, 0.11849176f, 0.01749888f, 0.00162499f, 
    -0.24349208f, 0.22206122f, -0.13160644f, 0.19767064f, 0.13352673f, 0.00276966f, -0.10582428f, -0.04415159f, 
    -0.02639528f, 0.08697015f, 0.01263718f, 0.02984799f, -0.48464820f, 0.22684799f, -0.18010934f, -0.07090793f, 
    0.15869208f, -0.01306655f, 0.17514941f, -0.04063070f, -0.01746020f, 0.09724341f, 0.05223086f, -0.01678464f, 
    0.00276741f, -0.12602238f, 0.04367528f, -0.05240006f, 0.03370845f, -0.09533218f, 0.05448825f, 0.15658028f, 
    -0.11393263f, -0.10545619f, 0.01780603f, -0.03991579f, -0.02694976f, 0.10739836f, 0.16794463f, -0.10472941f, 
    0.13347679f, 0.00611435f, 0.04646256f, 0.14572297f, 0.08894114f, -0.05272709f, 0.05723013f, 0.10377103f, 
    0.14589949f, -0.11310060f, 0.42339405f, 0.15229778f, -0.01962373f, -0.01753854f, 0.01225775f, -0.02025365f, 
    0.04879123f, 0.06818414f, 0.00723597f, -0.09065066f, -0.12917000f, 0.21441847f, -0.20290996f, -0.14314614f, 
    0.14523730f, -0.01932169f, 0.07416376f, 0.11909091f, 0.11243186f, 0.05503935f, -0.07184216f, -0.00629040f, 
    -0.04987977f, 0.19382972f, 0.25508657f, -0.02911075f, -0.00542654f, 0.03047316f, 0.02443541f, -0.00970344f, 
    0.02589624f, -0.16917297f, 0.08889164f, 0.07162435f, -0.15046988f, -0.32007778f, -0.13772169f, 0.03840310f, 
    0.01616178f, -0.00293862f, 0.06904905f, -0.02163610f, -0.01332693f, 0.04247324f, 0.03620752f, 0.06847540f, 
    0.16214029f, 0.02314394f, 0.18732713f, -0.09985048f, 0.15297861f, 0.24710710f, -0.04198483f, 0.04768270f, 
    0.05988104f, 0.02286569f, 0.10887854f, 0.11230069f, 0.09006527f, 0.22600751f, 0.16600843f, -0.09897601f, 
    -0.05942374f, 0.00727653f, 0.08880406f, 0.12421055f, 0.09645800f, 0.20162931f, -0.05115907f, 0.00346873f, 
    -0.17340519f, 0.07114735f, 0.03616329f, -0.22220074f, 0.12631090f, 0.03534327f, 0.07017042f, -0.01694852f, 
    0.03757384f, 0.01377161f, 0.05539886f, 0.08523832f, -0.14729498f, 0.06001639f, 0.04821324f, -0.14953201f, 
    0.03545129f, -0.07880670f, 0.03182764f, -0.02705014f, -0.03953142f, -0.01188578f, -0.02768974f, 0.00692041f, 
    0.04854409f, 0.00805941f, 0.04997310f, 0.08002054f, -0.28285852f, -0.04442983f, 0.03273105f, 0.09230214f, 
    -0.05338101f, 0.10141047f, 0.08178739f, 0.02880056f, -0.20843412f, -0.27112541f, -0.04916176f, 0.15611272f, 
    0.11428346f, 0.05786026f, 0.04163832f, 0.02401983f, -0.02778271f, 0.09427755f, -0.03350063f, -0.03197739f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03272560f, 0.04773334f, -0.06706085f, -0.06396968f, 0.00066564f, -0.00889300f, 0.03548902f, 0.02234451f, 
    0.01169140f, 0.11262033f, -0.09218354f, 0.03829176f, 0.02259129f, 0.02689913f, 0.11840525f, -0.07148864f, 
    -0.01950202f, -0.00589570f, -0.04938588f, -0.04498224f, -0.01812038f, 0.05537450f, -0.05560570f, -0.02549897f, 
    -0.03722788f, 0.10390372f, -0.03308745f, -0.05091880f, 0.06122417f, -0.06959017f, 0.01027352f, 0.05567212f, 
    -0.07307058f, -0.11336324f, 0.01860639f, -0.03331909f, 0.04515360f, -0.04186002f, -0.05186685f, -0.07670186f, 
    -0.04525494f, 0.03393774f, 0.04997542f, 0.00351145f, -0.06457122f, -0.06620076f, 0.05683733f, -0.02627192f, 
    -0.05176018f, 0.00837919f, 0.13070579f, 0.04042645f, 0.01979333f, -0.05729108f, 0.02041020f, 0.02893169f, 
    -0.04107595f, 0.04897992f, 0.06804344f, 0.01598334f, -0.03181522f, 0.12084164f, -0.01881275f, 0.11945245f, 
    0.13063724f, -0.03759023f, -0.01466227f, 0.08039994f, -0.06833152f, 0.09201121f, 0.05886167f, 0.03782232f, 
    -0.01068201f, 0.03378246f, -0.10189302f, 0.02563197f, 0.08334407f, -0.03039628f, 0.02072487f, -0.02052958f, 
    -0.04142235f, 0.00526490f, 0.05479267f, -0.04838949f, 0.10422682f, 0.19272393f, -0.01990087f, 0.07028882f, 
    -0.06272108f, -0.10319386f, 0.09958161f, 0.00441993f, -0.00102620f, 0.00660500f, 0.09111009f, -0.09065636f, 
    -0.13794219f, -0.08406565f, -0.09842534f, 0.06683405f, -0.03597706f, -0.07806801f, -0.00535212f, 0.09020915f, 
    -0.12797025f, -0.01423492f, -0.01791035f, -0.04831136f, 0.03010466f, 0.05013712f, 0.12664944f, 0.00748320f, 
    0.04241263f, 0.02696585f, -0.03963215f, 0.09943926f, -0.06846968f, -0.06045906f, -0.03917095f, -0.07767146f, 
    -0.06850386f, -0.11357605f, -0.04331506f, -0.02141675f, 0.04956672f, 0.03696194f, 0.10866231f, 0.08761847f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.06488566f, 0.21331726f, 0.05251484f, -0.09580363f, 0.09785468f, 0.03102018f, -0.15655868f, -0.19506378f, 
    -0.49149346f, -0.47298130f, 0.21673697f, 0.07123454f, 0.08395099f, 0.21928915f, 0.11167750f, -0.03655517f, 
    0.51799154f, -0.10196564f, 0.01894115f, -0.02292233f, 0.15159450f, -0.11670032f, 0.06773430f, -0.04105401f, 
    -0.15639751f, -0.59000051f, 0.00564136f, 0.12530458f, -0.23324673f, -0.04421489f, -0.12332647f, -0.05966497f, 
    0.05681673f, 0.13692439f, -0.16072750f, -0.41935158f, -0.47557142f, -0.08405691f, -0.17214015f, -0.08211524f, 
    -0.06887896f, -0.00289378f, 0.02038021f, 0.15421537f, -0.05532129f, -0.05257213f, 0.07252545f, -0.07198015f, 
    0.07571729f, -0.15867381f, 0.16732286f, -0.04727734f, -0.05463563f, 0.00021359f, 0.10007568f, 0.07001077f, 
    0.33861923f, 0.05072368f, -0.16373773f, 0.12763001f, 0.22956386f, -0.34819028f, 0.03747685f, -0.44078353f, 
    0.15495083f, -0.13464662f, 0.09852898f, -0.05568900f, 0.03219874f, 0.04366799f, 0.07296414f, 0.11863539f, 
    -0.04875259f, 0.05269049f, 0.13797751f, -0.04570795f, -0.15856101f, 0.00854430f, 0.08615543f, 0.01922037f, 
    -0.00895842f, 0.11080429f, -0.12717535f, 0.01410590f, -0.39529082f, -0.18746610f, 0.00938632f, -0.15502457f, 
    -0.07119990f, 0.16098580f, -0.17094113f, 0.16579875f, 0.16502617f, 0.03462689f, -0.30244106f, 0.01478618f, 
    0.29929924f, -0.00411334f, 0.11819102f, -0.00004906f, 0.00619120f, 0.02582142f, -0.00261006f, 0.24132738f, 
    0.22070274f, -0.04938476f, 0.04702387f, 0.02129963f, -0.17551094f, -0.08070240f, -0.05748267f, -0.06124667f, 
    -0.17421864f, -0.38608980f, 0.03493862f, -0.00082394f, 0.01076900f, -0.06843638f, -0.02327614f, 0.29993904f, 
    0.24352528f, 0.11285026f, -0.01373716f, 0.12535751f, -0.24281265f, 0.21527801f, -0.24128026f, -0.15729271f, 
    0.22213858f, 0.01608603f, 0.06327104f, -0.02792424f, 0.19637170f, 0.08993514f, 0.03524040f, -0.08521887f, 
    0.23725602f, 0.16319561f, -0.26295817f, 0.09896575f, -0.10864086f, 0.22032981f, -0.71128708f, -0.01596629f, 
    -0.24117258f, 0.09824111f, -0.01169407f, 0.05255158f, 0.05967975f, -0.16172352f, 0.08529143f, 0.13476476f, 
    0.15608920f, 0.39075637f, -0.06390084f, 0.11403976f, -0.35657632f, 0.01105850f, 0.13458832f, -0.02148821f, 
    -0.03658657f, -0.14014535f, -0.20127302f, -0.11300673f, -0.02810444f, -0.08573091f, -0.23812304f, 0.01516274f, 
    -0.05052608f, 0.08383952f, 0.08999379f, 0.14682548f, -0.00303446f, 0.01291125f, 0.06401539f, 0.03327901f, 
    -0.03976795f, -0.17953642f, -0.01929829f, -0.25365591f, 0.06389174f, -0.00839541f, 0.21428558f, 0.19077164f, 
    -0.37938735f, 0.07296838f, 0.14341705f, -0.00464598f, 0.06954793f, -0.24408194f, -0.17658843f, -0.16842747f, 
    0.21547791f, 0.06851747f, 0.06461402f, -0.21618311f, 0.13345794f, 0.13131770f, -0.03549153f, 0.09913061f, 
    -0.00402398f, 0.02443928f, 0.01267315f, -0.04220229f, -0.34970009f, -0.06610185f, 0.08859824f, -0.00301535f, 
    0.08186275f, -0.06875934f, 0.17356861f, 0.01330785f, -0.17935789f, -0.18874417f, -0.48606703f, 0.18620543f, 
    -0.04284110f, -0.03106475f, -0.05239708f, 0.17900223f, -0.07182653f, 0.11681554f, 0.10132411f, -0.08759562f, 
    -0.04473104f, 0.02128062f, 0.00744039f, -0.23425817f, -0.02246520f, 0.01798410f, -0.03593811f, 0.10993560f, 
    0.19109447f, 0.07125106f, 0.07988343f, 0.07935903f, -0.20498821f, -0.19386235f, -0.11084720f, -0.04723566f, 
    -0.19249128f, -0.28965324f, -0.07097773f, 0.12036445f, -0.07684372f, -0.19336452f, 0.14389245f, -0.47300768f, 
    0.12317911f, 0.23510808f, 0.05263304f, -0.07583170f, 0.22888340f, -0.32380849f, -0.55568850f, -0.11963519f, 
    0.10824012f, 0.03511224f, 0.02122950f, -0.03006260f, 0.16071686f, 0.00698900f, 0.16346397f, -0.40203670f, 
    0.07954513f, -0.15152848f, -0.02699823f, 0.08309758f, 0.08121826f, 0.21117160f, 0.31872582f, -0.01653104f, 
    0.08370495f, 0.04814721f, -0.09152673f, 0.01354966f, 0.07395431f, -0.46446213f, 0.07583785f, -0.01695768f, 
    -0.03152030f, -0.50593054f, 0.26165232f, 0.04965836f, -0.09807630f, 0.00376808f, 0.23214610f, 0.03638002f, 
    0.01301928f, -0.17288503f, 0.19407043f, 0.39695373f, 0.08125553f, 0.02652931f, 0.01730256f, 0.00683922f, 
    0.06594181f, -0.24144165f, -0.12462249f, -0.15047254f, 0.00805886f, 0.04210343f, 0.05556716f, -0.31013459f, 
    0.00182459f, -0.02518190f, -0.42213297f, -0.43796840f, -0.06824908f, 0.01593679f, 0.02769995f, -0.12453799f, 
    -0.26351467f, -0.28990027f, -0.01678948f, -0.34514645f, -0.01070272f, 0.03630777f, -0.21241428f, -0.13071820f, 
    -0.20983554f, 0.26374248f, 0.29705960f, 0.19060448f, 0.17676997f, 0.22582260f, 0.01331331f, -0.12664680f, 
    -0.06393818f, -0.06640468f, 0.27362472f, 0.01048484f, -0.08980095f, -0.00969218f, 0.08734161f, 0.06782877f, 
    -0.06612170f, 0.14967865f, 0.00436067f, -0.00818889f, -0.09784734f, -0.48213205f, -0.23236783f, -0.26387489f, 
    -0.09157545f, 0.11496004f, -0.33081084f, -0.24371174f, 0.05992860f, 0.21424936f, 0.07609943f, 0.04872685f, 
    -0.01651050f, -0.04518920f, 0.11316714f, -0.56106371f, -0.09622568f, -0.00991237f, 0.02222927f, -0.29248601f, 
    0.03847589f, 0.05165470f, -0.09648491f, -0.09337977f, -0.09574826f, -0.10644107f, -0.00362074f, 0.00339244f, 
    -0.33992469f, 0.34594578f, -0.00736858f, 0.14125530f, 0.07146624f, 0.16705927f, 0.01365437f, -0.37780282f, 
    -0.28899053f, -0.01673530f, 0.02912575f, 0.21652439f, -0.16044758f, -0.09781635f, 0.17497459f, -0.27962044f, 
    0.07786216f, -0.31928948f, 0.02841446f, 0.11200462f, -0.16892225f, -0.03607232f, 0.07772453f, -0.32543287f, 
    -0.06039274f, 0.24781096f, 0.19150487f, 0.21620853f, 0.14251475f, -0.17373523f, -0.07087928f, 0.03042680f, 
    0.20970181f, -0.42966816f, 0.05473320f, 0.00541645f, 0.25006074f, 0.13486212f, -0.00743793f, 0.05343844f, 
    0.13122472f, 0.11699773f, 0.13699579f, 0.25716746f, -0.00909660f, -0.07917923f, -0.01756088f, -0.05490952f, 
    -0.04408910f, 0.18050866f, -0.13368420f, -0.25222090f, -0.46574631f, -0.05601461f, -0.09046409f, 0.00335552f, 
    0.08137147f, -0.46740896f, -0.27667806f, 0.05444639f, -0.03523855f, 0.18434732f, 0.05288732f, -0.28216365f, 
    -0.04588389f, 0.14845893f, 0.18872376f, 0.18869913f, 0.07269727f, 0.06925265f, -0.09236015f, -0.27824339f, 
    0.16846119f, -0.05023340f, -0.11388340f, 0.09546233f, -0.26262102f, 0.00005455f, -0.12354553f, 0.11893738f, 
    -0.03746909f, 0.21908130f, -0.02223887f, -0.02966656f, -0.68701005f, -0.21935943f, 0.04777008f, -0.20119031f, 
    -0.04670169f, -0.00825025f, -0.10408712f, -0.05112640f, 0.20741139f, -0.07078855f, 0.19494650f, 0.05553010f, 
    -0.03225069f, 0.00905856f, -0.41432264f, -0.05772999f, -0.02070638f, 0.16887559f, 0.10186310f, 0.05512656f, 
    -0.03761353f, -0.20659621f, 0.22707473f, -0.22314011f, -0.20150949f, -0.58373803f, -0.03119584f, 0.02985162f, 
    -0.16220157f, 0.04951611f, 0.10507400f, -0.19449249f, 0.04521584f, 0.02268440f, 0.00331424f, 0.29408345f, 
    -0.14063050f, 0.04992508f, -0.06729410f, -0.07469233f, -0.08529978f, 0.24748178f, 0.14009406f, 0.03274224f, 
    0.25325122f, -0.12627378f, 0.03933523f, 0.13199125f, -0.02659044f, 0.07154805f, -0.25743994f, -0.07876991f, 
    -0.05171449f, -0.29797900f, -0.00027640f, -0.49003133f, -0.10841233f, 0.11059061f, -0.23437200f, -0.21969475f, 
    -0.39297742f, 0.16082869f, -0.01677514f, 0.16593303f, 0.02499158f, -0.04426351f, 0.24759397f, -0.35715151f, 
    -0.13270111f, -0.18476500f, 0.09677356f, -0.05659284f, 0.20711680f, -0.21537815f, 0.11054271f, -0.08099632f, 
    -0.62031573f, -0.25253969f, 0.00588286f, 0.06159259f, -0.08688357f, 0.22398207f, 0.01848283f, 0.05942318f, 
    0.01456280f, 0.08658945f, -0.03461721f, 0.11989329f, 0.28322220f, -0.05246664f, -0.03884009f, -0.02891529f, 
    0.04998578f, -0.31301072f, 0.04465194f, -0.32781318f, -0.05108727f, -0.08911360f, 0.01273276f, -0.03742766f, 
    0.05188439f, 0.06904692f, -0.08749229f, -0.14066683f, -0.07097155f, -0.14350647f, 0.07892171f, 0.25850156f, 
    -0.04301070f, -0.16202888f, -0.00089753f, 0.12400845f, 0.03949755f, 0.04538632f, -0.14840366f, 0.14512786f, 
    0.25109708f, 0.05004207f, 0.08976164f, 0.03401946f, -0.33060214f, -0.07657169f, 0.32946819f, 0.17621851f, 
    0.13080445f, 0.30205083f, 0.05468149f, -0.15603623f, -0.00150014f, -0.15390553f, -0.00501333f, -0.37237582f, 
    0.02291753f, 0.05005447f, -0.07304015f, 0.05957406f, 0.15864928f, -0.01347674f, 0.12869178f, -0.00937672f, 
    0.00544515f, 0.06337818f, -0.34557045f, -0.05243769f, -0.10637861f, -0.05585747f, 0.08003325f, -0.25807536f, 
    0.05565522f, -0.28049278f, -0.08704552f, -0.19051848f, -0.05951318f, 0.13441440f, -0.29671201f, 0.19350393f, 
    -0.11908084f, -0.06006007f, 0.29853275f, 0.10571583f, -0.05728398f, -0.01597238f, -0.05421266f, 0.11760206f, 
    -0.25226942f, -0.03602270f, -0.02814563f, -0.01056482f, 0.23826277f, -0.19672816f, -0.14646909f, -0.03752017f, 
    -0.01399879f, 0.06912585f, 0.08032798f, 0.06049129f, 0.06440201f, -0.10303152f, -0.14345194f, 0.21775195f, 
    0.13343863f, -0.12978995f, -0.03682910f, -0.21578275f, 0.22572604f, 0.36065528f, 0.10351962f, 0.26356241f, 
    0.11868488f, -0.11775527f, -0.08672389f, -0.28912616f, 0.01473061f, 0.04795726f, -0.19869834f, 0.47419441f, 
    -0.38558397f, -0.51263970f, 0.21629815f, -0.25040326f, -0.29497832f, -0.32933778f, -0.12891489f, -0.07805701f, 
    0.00822460f, -0.08726866f, 0.00287169f, -0.07065637f, -0.08796979f, 0.19425759f, -0.04218060f, -0.05056161f, 
    0.20936890f, -0.22477789f, -0.23431361f, -0.10600976f, 0.00352381f, -0.02752949f, -0.24659623f, -0.05343775f, 
    -0.06783403f, 0.07579565f, -0.38343522f, -0.09669986f, -0.05471576f, -0.07570048f, -0.02201076f, -0.03069218f, 
    0.00588120f, 0.14824422f, -0.07239885f, 0.04947519f, -0.08933496f, 0.09999617f, 0.03961562f, 0.05970365f, 
    0.01125538f, -0.05340721f, -0.10046960f, 0.11915200f, -0.08193245f, -0.01417283f, 0.06743719f, 0.03520034f, 
    -0.18862236f, 0.15045020f, -0.13408610f, 0.17018597f, -0.05923099f, 0.01425303f, 0.08059259f, 0.13830912f, 
    0.06825326f, -0.24433729f, 0.07887004f, 0.18369749f, 0.07557943f, 0.03375177f, -0.05597413f, 0.24539950f, 
    0.06998510f, -0.08750112f, -0.40798000f, 0.03183641f, 0.49796864f, 0.01078583f, -0.07424552f, -0.00790871f, 
    -0.01969145f, -0.10337161f, 0.20719500f, -0.07624659f, 0.16285133f, 0.04606907f, -0.09725792f, -0.15914370f, 
    -0.01123333f, 0.35181004f, -0.03855764f, 0.09452297f, -0.17966089f, -0.07070329f, -0.21287273f, 0.15731482f, 
    0.19285893f, 0.01879203f, -0.45999244f, 0.17150933f, 0.02392432f, -0.09143633f, -0.01738284f, 0.11417788f, 
    0.10030310f, -0.02129278f, 0.07840569f, -0.06368686f, -0.17912915f, -0.04805028f, 0.26655781f, -0.06916070f, 
    0.09448343f, 0.17158015f, -0.02470764f, -0.28992286f, 0.05674287f, -0.31008154f, 0.08825026f, 0.14151615f, 
    0.01939621f, -0.26080590f, 0.00430408f, 0.19627601f, 0.20530853f, -0.37669635f, -0.00123777f, 0.15287308f, 
    -0.21171986f, -0.15587369f, 0.07255325f, 0.18265468f, -0.09548058f, 0.04898774f, -0.02538335f, -0.52978247f, 
    -0.13568836f, 0.15603915f, -0.53378814f, -0.27184901f, -0.07412945f, -0.18484674f, -0.20819041f, 0.05631245f, 
    -0.00087242f, 0.21503800f, -0.04916853f, -0.01468563f, -0.11364694f, -0.21047035f, 0.03877321f, 0.05352575f, 
    0.10297532f, -0.25656757f, -0.25772706f, 0.15764670f, -0.17361535f, -0.02861371f, 0.21195361f, -0.00869200f, 
    -0.02029544f, -0.35942200f, 0.14735335f, 0.27056983f, 0.16861901f, 0.04974903f, 0.07437763f, 0.04176377f, 
    -0.00124017f, 0.12511285f, 0.27978253f, 0.05078869f, 0.07451407f, 0.09964267f, 0.02516459f, -0.11589560f, 
    -0.06558283f, 0.09165706f, 0.01878398f, 0.08184921f, -0.04354989f, -0.01401147f, 0.16420875f, 0.02369426f, 
    -0.43835840f, -0.23251261f, -0.59987086f, -0.54160327f, 0.15348199f, 0.13693456f, -0.22355652f, -0.50817996f, 
    -0.01710951f, -0.38683853f, -0.34695312f, 0.20299549f, 0.16863488f, 0.27485448f, -0.00724808f, -0.10796870f, 
    0.04392309f, 0.01208595f, -0.02222331f, 0.05601528f, -0.15048778f, -0.04964248f, 0.12904891f, -0.01808496f, 
    -0.05984842f, 0.10412713f, -0.15391810f, -0.07520511f, 0.01211363f, 0.13803048f, 0.36275649f, 0.29701081f, 
    -0.06022446f, -0.15618663f, 0.14007844f, -0.11921823f, 0.18953180f, 0.03809888f, -0.28495356f, -0.05446258f, 
    0.10238852f, -0.03288012f, 0.11027502f, 0.13193585f, -0.06102838f, -0.07132640f, -0.11107259f, -0.07644541f, 
    -0.03097457f, -0.06551160f, 0.05020912f, -0.03964356f, 0.01959005f, -0.08643838f, -0.29189542f, 0.06954736f, 
    0.21391694f, -0.30890861f, -0.08394290f, -0.32923853f, 0.03592940f, 0.25012434f, 0.14828703f, 0.09219798f, 
    -0.39389899f, -0.42761338f, 0.04793317f, -0.00256175f, -0.06976631f, -0.21530524f, 0.02378377f, 0.02235089f, 
    -0.23930036f, 0.12462538f, -0.08545084f, 0.14557260f, -0.26297045f, 0.11842483f, -0.15043536f, -0.16463044f, 
    0.03058948f, 0.15818775f, 0.00007883f, -0.21117897f, 0.19585201f, -0.10563739f, 0.01546044f, 0.03248490f, 
    -0.28614122f, -0.09298024f, 0.05920689f, -0.00638464f, 0.00237972f, 0.06450749f, 0.08595237f, -0.09998113f, 
    0.20397678f, 0.20462772f, 0.04066278f, -0.20229009f, 0.14960568f, 0.07922682f, 0.06755906f, -0.03808773f, 
    -0.03326640f, 0.16388951f, 0.30180678f, 0.34408566f, 0.09151434f, 0.07791030f, 0.24460799f, -0.05553646f, 
    -0.07643902f, -0.15544073f, -0.07691208f, -0.41795066f, -0.01637010f, -0.25363392f, 0.03771598f, 0.01519141f, 
    -0.02406823f, 0.14179856f, -0.05337916f, 0.09989299f, 0.02515798f, -0.00387565f, -0.36332408f, -0.18467775f, 
    0.17930287f, -0.41571996f, 0.05681768f, -0.08133930f, 0.05292797f, 0.22464702f, 0.10462406f, 0.05346477f, 
    -0.37426814f, 0.13943301f, 0.09864800f, 0.01607892f, -0.04119552f, -0.54203373f, -0.01864677f, -0.22897263f, 
    0.07859758f, -0.06749636f, 0.09036885f, -0.03560479f, 0.13188213f, -0.01389944f, -0.29424125f, -0.05124458f, 
    0.07900255f, -0.27776992f, 0.03427988f, 0.01739201f, 0.10529721f, -0.04329341f, -0.08413940f, 0.15545367f, 
    -0.00082537f, 0.19723018f, -0.11808330f, -0.41206834f, -0.28785393f, -0.15141693f, -0.12436576f, -0.06974547f, 
    -0.01607643f, 0.01860570f, 0.01160112f, -0.18050826f, -0.03140595f, -0.03519930f, 0.00296068f, -0.42867056f, 
    0.21852788f, 0.06162757f, 0.02013477f, -0.03399323f, 0.03000215f, 0.16095144f, -0.18378723f, 0.01413339f, 
    0.02389592f, 0.35209584f, -0.06410708f, -0.30408329f, 0.01250396f, 0.07947868f, -0.33072835f, 0.25423199f, 
    0.17503826f, 0.02769444f, -0.07591020f, 0.13648871f, 0.09332494f, 0.03136341f, -0.10326076f, -0.37202305f, 
    0.10779976f, -0.41736239f, 0.06092340f, -0.24570139f, 0.04298229f, 0.19904085f, 0.07636634f, -0.22870578f, 
    -0.05298012f, -0.24115779f, -0.38224536f, 0.15841739f, -0.07319248f, 0.05074540f, -0.11201133f, -0.09707755f, 
    -0.06544676f, 0.13576464f, 0.02747554f, -0.04329345f, -0.30419785f, 0.24996543f, 0.06204750f, 0.23048733f, 
    -0.02115327f, 0.14832935f, 0.12716100f, 0.01710437f, 0.02252783f, 0.02835375f, -0.13775072f, -0.05657434f, 
    -0.04242892f, 0.33137256f, -0.23640779f, -0.30974805f, 0.13901997f, 0.06161378f, 0.36581537f, -0.04471050f, 
    -0.08687837f, 0.22578423f, -0.26942980f, -0.12633535f, 0.01583636f, -0.30951837f, 0.06142847f, 0.34145465f, 
    -0.07220983f, -0.38876906f, -0.28768438f, -0.17141908f, -0.05546003f, -0.01632997f, -0.16728045f, -0.23019303f, 
    -0.35329989f, 0.14346282f, 0.20588921f, 0.27281275f, -0.01049855f, -0.10185122f, 0.01061317f, -0.05696830f, 
    -0.19151375f, 0.01898158f, -0.28955513f, 0.02037669f, 0.09880528f, -0.42339981f, -0.00731079f, -0.06694443f, 
    0.05923944f, -0.06882650f, 0.10787628f, 0.02190763f, -0.31293392f, -0.02143130f, 0.05504464f, 0.06104555f, 
    0.04846560f, 0.11898283f, 0.16606663f, -0.06879842f, 0.16099399f, -0.29656655f, -0.27886686f, -0.15028882f, 
    0.03770485f, -0.22495577f, 0.23184736f, 0.02238363f, 0.18290769f, 0.18385901f, 0.18541779f, 0.11074138f, 
    0.00009483f, -0.02240421f, -0.25003952f, -0.00675301f, 0.00556660f, -0.03442538f, -0.01833701f, -0.62160873f, 
    0.09007008f, 0.02389229f, 0.00195432f, 0.04165844f, 0.03408832f, 0.04976091f, 0.31496128f, 0.00012835f, 
    -0.36990863f, 0.12045568f, -0.04991672f, -0.23884483f, 0.04015005f, -0.49619499f, 0.07779582f, -0.22303438f, 
    0.09640422f, 0.20379794f, -0.08922309f, -0.29659981f, -0.27126062f, -0.30674112f, -0.17552184f, -0.16799161f, 
    -0.34915844f, 0.00167567f, 0.03581136f, 0.16250239f, -0.01223734f, 0.10644527f, 0.03029573f, 0.59531158f, 
    0.35395676f, -0.01682053f, -0.14921866f, -0.12666900f, -0.23261796f, 0.11149406f, 0.37836206f, 0.05026338f, 
    0.15443075f, 0.03350058f, 0.00947860f, -0.02174611f, -0.40844521f, -0.34332365f, 0.06786248f, -0.35162547f, 
    -0.09973158f, -0.27196801f, -0.40218055f, -0.02620529f, -0.05612424f, 0.01035079f, -0.41663015f, -0.02694270f, 
    -0.04973654f, 0.15404841f, 0.23334895f, 0.13732608f, 0.25519156f, 0.08027609f, 0.09805731f, -0.06601118f, 
    0.04531366f, -0.09016271f, -0.26616380f, 0.03451286f, -0.07123180f, 0.11701182f, -0.05551165f, -0.28135058f, 
    0.03701385f, 0.12074740f, -0.07552079f, -0.08696146f, -0.07754029f, -0.03169994f, -0.08777903f, 0.13365526f, 
    -0.14982708f, 0.09606276f, -0.11311986f, 0.06987562f, -0.15238346f, -0.14938669f, 0.24450423f, -0.31545529f, 
    -0.00413525f, -0.09823126f, -0.28144890f, -0.40061104f, 0.08896986f, -0.21004403f, -0.02242570f, 0.35861987f, 
    -0.05662051f, -0.03404159f, 0.16519631f, 0.05430762f, -0.15814473f, -0.07859512f, -0.10938276f, 0.01470689f, 
    0.03254656f, -0.05207227f, -0.06141851f, -0.04085759f, 0.20438035f, 0.08213335f, -0.17223255f, -0.11192145f, 
    -0.08836517f, -0.08814415f, -0.12029338f, 0.09452875f, 0.06480141f, -0.05361494f, 0.32111695f, -0.02309219f, 
    -0.38615242f, 0.05885251f, -0.40098140f, 0.00371915f, 0.02540063f, -0.00098981f, -0.04706932f, -0.40015414f, 
    0.03526559f, 0.00143780f, 0.05452147f, 0.04533479f, 0.23265842f, 0.08907943f, -0.54251087f, -0.02561399f, 
    -0.03990563f, 0.23705326f, 0.02287761f, -0.27038983f, -0.02534262f, 0.14400405f, 0.19720113f, -0.16639706f, 
    -0.37447828f, 0.09770350f, 0.02363814f, 0.12504008f, 0.16556174f, 0.22366312f, 0.20870240f, 0.26537973f, 
    0.09245598f, 0.23333322f, -0.02490658f, -0.23743358f, -0.45476583f, 0.12049893f, 0.25879076f, -0.03554258f, 
    0.04149740f, 0.16926980f, -0.04762642f, -0.05330825f, 0.14832300f, 0.21556579f, 0.21922980f, -0.03585840f, 
    0.07856324f, 0.15821688f, 0.00265423f, 0.01437322f, -0.01472053f, -0.36248896f, -0.04819217f, -0.10576257f, 
    -0.17838097f, 0.06328055f, 0.06756738f, -0.35079029f, 0.22689067f, 0.03834466f, 0.27345622f, 0.07373885f, 
    -0.07775161f, -0.15883711f, 0.08696155f, 0.03769871f, 0.21745937f, -0.01442751f, -0.36419791f, -0.03971738f, 
    -0.09474541f, -0.24023268f, -0.15687253f, -0.12264414f, 0.02806420f, -0.40746555f, 0.02479704f, -0.13634197f, 
    0.06891908f, -0.03496179f, 0.13715315f, -0.10231796f, 0.06223068f, -0.04723889f, 0.08777513f, -0.23304948f, 
    -0.01843294f, 0.14286612f, 0.16756700f, -0.10481911f, 0.37919903f, 0.18579334f, 0.23229524f, 0.22417492f, 
    0.22713764f, -0.08067837f, 0.13206033f, 0.07042797f, 0.03320963f, 0.13244297f, -0.06293526f, -0.10580060f, 
    -0.06520364f, -0.00528596f, -0.27696735f, -0.04901974f, 0.27803284f, -0.08012091f, -0.31397608f, -0.07876264f, 
    -0.03422922f, -0.30607697f, 0.04544754f, -0.08713058f, 0.25632459f, 0.17910163f, -0.03018604f, 0.00628379f, 
    -0.01429364f, -0.15831822f, 0.07909273f, 0.12577350f, -0.03461266f, -0.16381867f, 0.11402538f, -0.29075375f, 
    -0.32074201f, -0.09749184f, -0.24243373f, 0.19042404f, -0.08950474f, -0.00894101f, -0.00575583f, -0.16073856f, 
    -0.26105383f, 0.05671342f, -0.03231275f, -0.03748172f, -0.56361765f, 0.16134825f, 0.11848982f, 0.05464327f, 
    -0.29372880f, -0.21018000f, 0.08102699f, 0.26882058f, 0.07469020f, -0.12744287f, -0.05337895f, -0.15504025f, 
    -0.22915450f, -0.26224846f, 0.02907419f, -0.00676643f, -0.44841829f, -0.33244959f, 0.13830213f, 0.06425535f, 
    0.11609505f, 0.00383059f, 0.00403073f, -0.30494219f, 0.15582855f, -0.50343573f, -0.40598390f, 0.13532034f, 
    0.15558298f, -0.08513463f, 0.10970737f, 0.22914284f, -0.20976940f, -0.17863418f, -0.00126577f, -0.06345842f, 
    -0.22053839f, -0.09695088f, -0.09353007f, -0.01594082f, 0.06391007f, 0.06285711f, -0.07810391f, -0.02323421f, 
    -0.31154555f, 0.15101036f, 0.14208005f, -0.28566247f, -0.15378338f, -0.08149698f, 0.01708562f, 0.06152844f, 
    -0.02873095f, -0.08935792f, -0.16031949f, 0.04973867f, -0.12187833f, -0.03666394f, 0.13533780f, -0.01850280f, 
    -0.06391288f, 0.16527598f, 0.35744464f, 0.11110251f, 0.05220054f, 0.28858614f, 0.07176747f, 0.16912942f, 
    -0.07359058f, 0.13437343f, 0.08291530f, 0.10594504f, 0.00413090f, 0.01340842f, 0.05086404f, -0.33436000f, 
    0.00330075f, -0.01541601f, -0.25229824f, -0.03862491f, -0.10593835f, -0.09357231f, -0.29378682f, 0.15452924f, 
    -0.18757202f, -0.45172101f, 0.03161430f, 0.21498857f, -0.44252685f, 0.12313767f, 0.05599847f, -0.57268167f, 
    0.06536455f, 0.04576010f, 0.05288441f, 0.03260118f, -0.23833610f, -0.04830095f, -0.09163892f, 0.05034101f, 
    -0.00085866f, -0.02048504f, 0.00576276f, -0.05147153f, -0.14728549f, 0.22154960f, 0.20195845f, -0.04714079f, 
    0.00680175f, 0.08715200f, -0.02304920f, -0.06801032f, -0.23511152f, 0.18629278f, 0.19100994f, -0.38973543f, 
    -0.10433055f, -0.01716402f, -0.03479334f, 0.01681636f, 0.03677680f, 0.03778156f, -0.14947248f, -0.03376935f, 
    -0.35471290f, 0.03901402f, 0.04935671f, 0.03560846f, 0.20290411f, -0.11655688f, 0.14732274f, 0.01764601f, 
    0.16553816f, -0.13155867f, -0.07989096f, -0.07606509f, 0.04625486f, 0.17172183f, -0.22775094f, -0.24367738f, 
    0.14087725f, 0.10125683f, 0.01833929f, 0.18014900f, -0.57898086f, -0.01143642f, 0.30861452f, 0.13050301f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.11898415f, 0.00641354f, -0.05735634f, -0.04071877f, -0.07660392f, -0.05834745f, -0.02449644f, 0.00216823f, 
    -0.07484838f, 0.00530955f, 0.00796096f, 0.03579115f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
