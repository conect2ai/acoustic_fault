#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.38868669f, 0.01455484f, 0.11874378f, -0.34098348f, 0.18295136f, 0.78040582f, -0.72562724f, -0.27238232f, 
    -0.08781001f, 0.04006331f, -0.08665984f, -0.53095567f, 0.01643702f, 0.28438190f, 0.09839214f, 0.10415969f, 
    0.13076316f, -0.24246892f, -0.00279053f, 0.08499574f, 0.10101752f, 0.07977203f, 0.27213755f, 0.07290251f, 
    -0.25265604f, -0.35775903f, 0.43669972f, 0.50108367f, 0.46078417f, 0.16735998f, 0.46904349f, -0.11623681f, 
    0.51380086f, 0.17520292f, -0.14866969f, -0.40105048f, -0.21729447f, -0.33903760f, -0.10756253f, -0.02342654f, 
    -0.09308030f, 0.23540603f, 0.15367876f, 0.03421010f, -0.19553818f, 0.14043340f, 0.01620320f, 0.01557737f, 
    0.02033078f, -0.22880091f, 0.49336809f, 0.32744202f, 0.64776516f, 0.44925800f, 0.12617929f, 0.11550606f, 
    -0.39707097f, -0.22639519f, -0.36602426f, 0.12082633f, 0.02528280f, 0.15727387f, 0.07084136f, 0.21406694f, 
    0.19131550f, 0.23658907f, 0.16281632f, 0.21310818f, -0.15976995f, -0.12873481f, 0.13693155f, 0.03880119f, 
    0.18480605f, -0.01475243f, -0.05605774f, 0.20399947f, 0.42819491f, -0.63551354f, -0.53929538f, -0.42956114f, 
    0.33743680f, -0.40037549f, -0.04916186f, 0.37962446f, -0.06205254f, -0.31849256f, -0.14633732f, -0.25149429f, 
    0.28999677f, -0.08001620f, -0.09668684f, 0.18390445f, 0.01345205f, 0.06791539f, 0.15826714f, -0.00746088f, 
    0.02129192f, -0.07928164f, 0.05778781f, -0.22158059f, -0.07611889f, 0.41758984f, -0.21778630f, -0.12634534f, 
    0.28153187f, -0.33547488f, -0.76799011f, -0.71175575f, -0.39755228f, -0.24872728f, -0.18543859f, 0.33013415f, 
    -0.02785806f, -0.27398074f, -0.00485176f, -0.13393822f, -0.05404807f, 0.28233725f, -0.49262726f, -0.00782478f, 
    -0.06367515f, 0.28466144f, 0.03135576f, 0.04952564f, 0.05312752f, -0.19476357f, -0.49230930f, 0.33809051f, 
    0.23563141f, -0.18387951f, -0.24718814f, -0.16434231f, 0.02145667f, -0.29171425f, -0.40934461f, -0.01990258f, 
    -0.17674586f, -0.18945190f, 0.32192880f, -0.22205342f, 0.01780442f, 0.32812852f, 0.33250943f, -0.33293596f, 
    0.10962193f, 0.28218254f, -0.01353873f, 0.07043371f, 0.23131470f, -0.02349850f, -0.09034149f, -0.21333565f, 
    -0.26859781f, -0.35232273f, -0.11566056f, -0.33334628f, -0.35106501f, 0.05347913f, 0.45365870f, -0.17180949f, 
    -0.14579400f, -0.24431849f, -0.09509422f, -0.30243450f, -0.24410568f, 0.25833189f, -0.14001088f, -0.07637859f, 
    -0.20327945f, -0.34620792f, -0.02580433f, 0.11163213f, 0.31558427f, 0.27715951f, -0.13776325f, 0.62931007f, 
    -0.22082415f, -0.23779091f, 0.16507173f, 0.30775777f, 0.05498290f, 0.15378638f, 0.17970349f, 0.12490650f, 
    0.34117189f, 0.42989936f, 0.13023032f, -0.38565344f, 0.18065576f, 0.13815504f, -0.18775298f, -0.11173678f, 
    0.19565557f, 0.07718320f, 0.15519564f, -0.22422221f, -0.04978141f, 0.35973561f, -0.13762657f, -0.25604779f, 
    -0.00906352f, 0.66763341f, 0.57047379f, -0.70517606f, -0.41653219f, -0.03141849f, 0.20516819f, -0.72234792f, 
    -0.59679765f, -0.08532341f, 0.10236273f, 0.54647803f, 0.15530331f, -0.10241746f, 0.12729055f, -0.08573762f, 
    -0.07759109f, 0.16232716f, 0.02136619f, 0.14140059f, 0.11519472f, 0.11902533f, 0.02960226f, -0.17094223f, 
    0.21654363f, -0.45426613f, 0.34804422f, 0.26565459f, -0.23826350f, 0.17533383f, -0.75967330f, -0.15463477f, 
    -0.20463942f, -0.36576387f, 0.04028275f, 0.16946679f, 0.28255376f, 0.05031980f, 0.31906086f, 0.04622282f, 
    -0.12348388f, -0.37647989f, -0.04227778f, -0.14925310f, -0.13078034f, 0.05598397f, 0.04645782f, 0.14069387f, 
    0.42159778f, -0.22545743f, -0.69666636f, 0.55359322f, -0.19666468f, -0.19137748f, -0.16891535f, 0.11990261f, 
    0.02744927f, 0.05054072f, 0.24026020f, 0.24990104f, -0.36941016f, -0.18790159f, 0.28008449f, -0.31474715f, 
    0.29304901f, 0.21887212f, 0.11975291f, -0.25506353f, -0.17302595f, -0.16452433f, -0.26918456f, -0.25970286f, 
    -0.27688485f, -0.26725695f, -0.00475261f, -0.17892891f, -0.73559064f, -0.01052776f, 0.55797285f, -0.33814636f, 
    -0.12449331f, -0.26938841f, 0.23352534f, 0.27383116f, -0.10915285f, 0.05567182f, -0.26923513f, -0.34077609f, 
    0.21346976f, 0.18757208f, 0.22694628f, 0.37076446f, -0.26067644f, 0.01248374f, -0.40569869f, -0.35828945f, 
    0.00275311f, 0.26398310f, 0.39512640f, -0.11300135f, -0.73503208f, 0.09956894f, 0.45196724f, -0.39871007f, 
    -0.32752082f, 0.36923912f, 0.44987053f, 0.20025767f, -0.13246502f, -0.22968987f, -0.22787978f, 0.27386180f, 
    -0.38187698f, 0.28844482f, 0.14267528f, -0.34044030f, -0.21642560f, -0.16397272f, -0.00573133f, -0.12945959f, 
    0.05902368f, 0.09301309f, -0.02561339f, 0.06694444f, -0.23077065f, 0.64177573f, 0.06579697f, -0.25135541f, 
    0.40104708f, 0.34982741f, -0.12167263f, -0.35391217f, -0.04738080f, -0.37735993f, -0.26040128f, -0.40669015f, 
    -0.09796076f, -0.22926718f, -0.18937403f, -0.30733591f, 0.13653842f, 0.00174367f, -0.44894961f, -0.31552261f, 
    -0.05528484f, -0.01008731f, 0.04388654f, -0.11158103f, -0.02325249f, -0.09369075f, -0.11557619f, -0.51892054f, 
    -0.33215860f, -0.48656824f, 0.10078497f, 0.55659270f, -0.06559400f, 0.61437416f, 0.41681042f, 0.41856176f, 
    0.42773774f, -0.01878568f, 0.01350007f, 0.02466311f, 0.10195051f, 0.07942015f, 0.11784968f, 0.18006733f, 
    0.12217917f, -0.01937468f, -0.34789279f, -0.21518007f, -0.15101252f, -0.17137752f, -0.01539603f, 0.44945636f, 
    0.60083556f, -0.05969169f, 0.37418845f, 0.35647622f, -0.03652117f, 0.30494580f, 0.19799136f, 0.37017149f, 
    0.33993724f, -0.23468366f, 0.10460731f, 0.13199128f, -0.22509409f, -0.05437176f, 0.20657380f, -0.06165370f, 
    -0.11699665f, -0.15995498f, 0.25612342f, -0.09465101f, 0.05919546f, 0.34879714f, -0.13591267f, 0.04120838f, 
    0.69856989f, 0.25469393f, 0.62255102f, -0.39030582f, 0.38325486f, -0.26728851f, -0.49428877f, 0.35911179f, 
    0.10149603f, -0.12325542f, -0.23159137f, -0.07447492f, -0.21395186f, -0.14140733f, 0.11854094f, 0.08131137f, 
    -0.13364732f, -0.18901919f, -0.00742181f, 0.16692506f, 0.15951034f, 0.22868651f, -0.15720235f, -0.11056105f, 
    0.08165643f, 0.66045099f, 0.41079876f, 0.10713208f, 0.42973951f, 0.61791980f, 0.09942345f, 0.17906883f, 
    -0.42293578f, 0.40876898f, 0.11212242f, -0.22696823f, -0.07213379f, -0.11381080f, -0.01167501f, 0.04978944f, 
    -0.05042442f, -0.18136193f, -0.01234221f, -0.04086372f, -0.19515595f, 0.06798865f, 0.27344930f, 0.19464225f, 
    0.20658983f, 0.03004776f, 0.42056879f, 0.16098082f, 0.33871186f, -0.59691799f, -0.41954076f, 0.13464783f, 
    0.01753903f, 0.02386003f, 0.20442756f, 0.42415762f, 0.06250184f, -0.12201101f, -0.06947061f, -0.03003900f, 
    -0.05098046f, -0.14981082f, -0.05724372f, -0.06676846f, -0.19212298f, -0.57894206f, -0.16762020f, 0.16539471f, 
    0.20569777f, 0.09623762f, 0.15351698f, 0.74153733f, 0.23794451f, 0.10755742f, 0.59424585f, 0.51067913f, 
    -0.25732598f, 0.21539453f, -0.10116223f, 0.59541857f, -0.08004455f, -0.09446281f, -0.26882988f, -0.18910442f, 
    -0.09318768f, -0.16003384f, -0.06053813f, -0.19559062f, -0.00508931f, 0.07693846f, 0.26887619f, -0.05426731f, 
    0.04613785f, 0.06979415f, 0.01592775f, -0.12426609f, 0.49929088f, 0.52544802f, -0.07597129f, -0.33048692f, 
    -0.31943351f, -0.42974985f, -0.64895886f, -0.06843513f, -0.19114748f, 0.14949828f, 0.24482447f, -0.20335813f, 
    0.12910123f, -0.15611273f, -0.00078888f, 0.13662748f, -0.40374470f, -0.24970625f, 0.19111636f, -0.22123995f, 
    0.29208186f, 0.05590403f, 0.15825537f, -0.03210313f, 0.12518457f, -0.63693565f, 0.70678174f, 0.38879961f, 
    -0.45587814f, 0.34653103f, 0.25771222f, -0.38243386f, 0.01229372f, 0.38125309f, -0.22806744f, -0.37497860f, 
    0.11798260f, -0.32244703f, 0.14407812f, 0.11319980f, -0.34463227f, 0.30343729f, 0.06964207f, 0.26456571f, 
    0.15324433f, 0.14199123f, -0.18775351f, -0.07847624f, -0.02041701f, -0.01661804f, 0.20912869f, -0.26814076f, 
    0.63091797f, 0.45988926f, -0.36478990f, -0.12402024f, -0.35193336f, 0.42183927f, -0.21239494f, 0.13177612f, 
    0.30513349f, -0.31861308f, -0.13641971f, 0.25762254f, -0.19982390f, -0.05597265f, -0.01370214f, 0.05243113f, 
    -0.10306735f, 0.01470365f, 0.29272160f, 0.47212169f, 0.36270544f, 0.11879145f, -0.14845702f, 0.34147191f, 
    -0.23874140f, 0.37751463f, 0.37702626f, 0.11223207f, 0.37279326f, -0.07950077f, 0.04948746f, -0.07939132f, 
    -0.09176262f, 0.25363538f, 0.06405910f, 0.08475079f, -0.15800364f, -0.19684733f, 0.28804222f, 0.19058935f, 
    -0.15192455f, 0.05430354f, -0.35567868f, 0.21128227f, 0.17899223f, 0.31928477f, 0.14111747f, 0.51665384f, 
    0.24829419f, 0.44460404f, -0.33043686f, -0.20847756f, 0.46293107f, -0.33318689f, -0.44337893f, 0.40838090f, 
    -0.32455999f, 0.09229738f, -0.00003218f, -0.11371754f, 0.31400526f, 0.15079753f, -0.04649784f, 0.13725558f, 
    -0.12985648f, -0.09705302f, 0.20701493f, 0.45300141f, 0.00513197f, 0.07936700f, -0.06476492f, -0.03523584f, 
    -0.37324405f, -0.34464121f, -0.24559338f, -0.45756298f, -0.40313497f, -0.23971915f, -0.30316427f, -0.14750010f, 
    0.12443835f, 0.27545103f, -0.00816999f, -0.09122235f, 0.13903977f, 0.14629106f, -0.27329168f, -0.32259539f, 
    -0.11481951f, 0.19258462f, 0.07789660f, 0.13957340f, -0.43691587f, -0.14381166f, -0.04645277f, 0.02345993f, 
    0.04250997f, 0.05901034f, 0.48846519f, -0.05331286f, 0.51850760f, 0.34566015f, 0.39447349f, 0.05371674f, 
    0.31835529f, -0.62446928f, -0.56188416f, -0.23179774f, 0.14669442f, 0.25505573f, 0.15553164f, 0.12562120f, 
    0.32508904f, -0.24282181f, 0.15681715f, -0.24271901f, 0.23351209f, 0.04343322f, 0.32711864f, 0.21519490f, 
    0.38811773f, -0.00687761f, 0.30531141f, -0.47872165f, 0.12131220f, -0.33999100f, -0.32106417f, 0.14437328f, 
    0.21492249f, -0.34237072f, 0.10487100f, 0.28381646f, -0.44208109f, -0.39030489f, -0.15791842f, 0.12108773f, 
    0.21532094f, 0.00587248f, -0.19534974f, 0.12383964f, -0.15960719f, -0.28145310f, -0.16921957f, -0.15833546f, 
    0.14274789f, 0.32003337f, 0.35262883f, -0.18773063f, 0.09576360f, 0.00170092f, 0.54161829f, 0.38803443f, 
    0.37120989f, -0.42477748f, -0.63865983f, 0.00659774f, -0.02961137f, -0.23787573f, 0.46511242f, 0.13996135f, 
    -0.38022265f, -0.05899173f, -0.22302623f, 0.23709363f, 0.23339863f, 0.32525706f, -0.03356828f, 0.04473450f, 
    0.11264807f, -0.12120390f, -0.02789173f, -0.21716836f, -0.42914155f, 0.48771083f, -0.18421434f, -0.69675893f, 
    -0.64743239f, -0.33325750f, 0.45497653f, -0.25206786f, 0.31394821f, 0.20470580f, 0.38063639f, -0.18092030f, 
    -0.10704697f, -0.16906451f, 0.17642561f, -0.01357687f, -0.16576685f, 0.04183103f, -0.32542402f, 0.16152132f, 
    0.12501769f, -0.05756425f, 0.17683187f, -0.24816471f, -0.15586694f, 0.18848716f, -0.38050246f, -0.15982828f, 
    0.57412207f, 0.63192338f, -0.28025284f, -0.33320963f, 0.22055495f, -0.21321054f, -0.19554809f, -0.36777121f, 
    0.46821085f, -0.00686915f, -0.06829249f, 0.33404168f, 0.17349018f, -0.27376378f, 0.21173270f, -0.00080202f, 
    -0.04942344f, 0.39401993f, -0.24084747f, -0.11955001f, 0.16638836f, -0.00585519f, 0.12449229f, -0.03752969f, 
    -0.40383157f, 0.53822213f, 0.13528356f, -0.36018577f, -0.17556949f, -0.11505782f, 0.39009166f, 0.22136293f, 
    -0.57387513f, 0.14137994f, -0.23911703f, -0.03876644f, -0.28029168f, -0.28097153f, 0.01395968f, -0.21996883f, 
    -0.33677521f, 0.08865933f, 0.02367246f, -0.06039861f, -0.10673049f, -0.22913840f, -0.07936168f, -0.35147822f, 
    -0.17517616f, -0.63912284f, -0.37704948f, -0.09094086f, -0.13691258f, -0.07897095f, -0.42317626f, -0.30640203f, 
    -0.10795567f, -0.33021650f, 0.02668583f, 0.50041258f, -0.06387328f, 0.13507988f, 0.35808247f, 0.19772850f, 
    -0.18483533f, 0.25909340f, 0.15548478f, 0.27605209f, 0.07467841f, -0.07879210f, -0.08101738f, 0.23457409f, 
    -0.03325838f, -1.09194088f, 0.73435360f, 0.36161748f, -0.10098673f, 0.20271879f, -0.27384582f, 0.25818393f, 
    0.41873202f, -0.14217116f, -0.01149374f, 0.03783306f, -0.15466206f, 0.10874281f, 0.09345695f, -0.11961342f, 
    -0.05473627f, 0.05451303f, -0.02057512f, -0.09637506f, 0.04265833f, 0.03705668f, 0.12809947f, -0.05979789f, 
    0.10311593f, -0.06518903f, -0.63308185f, -0.36802357f, -0.52378315f, -0.32951543f, -0.16376586f, 0.21235029f, 
    0.57602572f, 0.11284368f, 0.31219998f, 0.54279184f, -0.08915574f, 0.11544982f, 0.30724931f, -0.01700314f, 
    0.04714506f, -0.15345950f, -0.16733758f, -0.06852206f, 0.34769821f, -0.41148320f, 0.08821665f, -0.23987299f, 
    -0.08798368f, 0.03351422f, 0.16277979f, -0.51467353f, 0.02534563f, -0.25778732f, -0.00052435f, -0.05263302f, 
    -0.24978055f, -0.44394699f, -0.12018130f, 0.14061871f, -0.01041111f, -0.00092799f, 0.15058851f, -0.37855512f, 
    0.05725985f, -0.55417567f, -0.21030073f, 0.36122778f, -0.02625877f, 0.04267545f, 0.07941583f, 0.08433337f, 
    -0.05535257f, 0.16643907f, 0.14040385f, 0.15767442f, 0.16492261f, -0.35081545f, -0.51280022f, -0.23467343f, 
    0.11222847f, -0.25259611f, 0.47456142f, 0.51526827f, 0.18232532f, -0.01295627f, -0.22269839f, 0.09016642f, 
    -0.29127514f, -0.18981436f, 0.12182178f, -0.09920945f, -0.14624667f, -0.08315930f, 0.27763087f, 0.07436702f, 
    0.45715261f, -0.13487935f, 0.45394397f, -0.33714762f, -0.29590723f, 0.07173309f, -0.73828292f, -0.61358219f, 
    0.42424914f, -0.02162852f, -0.65421128f, 0.56144905f, 0.45706946f, -0.10657220f, 0.34965399f, 0.09632982f, 
    -0.08005195f, 0.09221978f, -0.11541976f, 0.17691943f, 0.14655703f, -0.09367444f, -0.15327430f, -0.13609241f, 
    0.07705577f, 0.16999616f, 0.22623079f, -0.13038029f, 0.23054497f, 0.10027316f, 0.46346530f, 0.12488893f, 
    -0.73690456f, 0.46891224f, 0.13400725f, -0.20490882f, -0.04080270f, -0.42544061f, -0.32195228f, -0.08245854f, 
    0.42177570f, 0.48733214f, -0.13484046f, 0.16491383f, -0.05312034f, 0.04509985f, -0.31073198f, -0.27616003f, 
    -0.10228144f, -0.15089981f, -0.15257898f, 0.14321111f, -0.14779295f, 0.16737646f, -0.00433326f, 0.10662922f, 
    0.09766051f, -0.37702957f, 0.82665032f, -0.23581827f, 0.16722918f, -0.43262750f, -0.15009804f, 0.24320079f, 
    0.01114638f, -0.12260266f, 0.09413101f, 0.38230035f, -0.00658194f, -0.49902302f, 0.10400181f, -0.27846858f, 
    0.09462313f, 0.18490362f, 0.06162120f, 0.13093667f, 0.27656177f, -0.11656389f, -0.05665936f, -0.09060594f, 
    -0.17717814f, -0.24212836f, -0.63339382f, -0.33872229f, -0.19994985f, 0.06980484f, -0.45327237f, 0.06427939f, 
    -0.41679811f, 0.16140781f, 0.25338581f, 0.14692320f, 0.14904754f, -0.11835234f, 0.11942572f, 0.04141064f, 
    0.02832538f, -0.11651232f, 0.12955457f, 0.30615327f, -0.01917696f, 0.10344171f, -0.24663366f, -0.18761225f, 
    -0.27311823f, 0.18383105f, -0.25400054f, -0.33107248f, -0.27592871f, 0.08460596f, 0.57398063f, 0.41206080f, 
    -0.57537919f, -0.35049090f, -0.16928600f, 0.32030010f, 0.32895124f, 0.11446780f, -0.08249559f, -0.01296418f, 
    -0.18693940f, 0.11879312f, 0.04168229f, -0.27145308f, 0.08096688f, 0.14050809f, -0.25511068f, 0.01222922f, 
    0.29344544f, -0.21705744f, -0.21869639f, -0.49238786f, -0.42891410f, -0.43083227f, -0.33384886f, 0.11899569f, 
    -0.58289957f, 0.06486933f, 0.24171738f, -0.47456577f, 0.31120685f, 0.16817768f, -0.02732685f, 0.15819599f, 
    -0.17959040f, 0.20988077f, 0.18479781f, -0.18063937f, -0.02979077f, 0.29494643f, 0.24233884f, -0.17033218f, 
    0.13731125f, -0.11556409f, 0.03289730f, -0.64325756f, -0.38720998f, 0.39619088f, -0.13024764f, 0.73222917f, 
    0.34288588f, 0.06533023f, -0.28381968f, -0.02285012f, -0.05538954f, -0.11751179f, -0.32650289f, -0.06619918f, 
    0.26553774f, 0.03822962f, 0.02418896f, 0.00253140f, -0.41743892f, 0.02815249f, 0.22461857f, -0.02069287f, 
    0.36484852f, 0.10770837f, 0.38238859f, -0.31509134f, 0.36268008f, 0.27452222f, -0.62178618f, -0.00305112f, 
    -0.03933990f, -0.54369098f, -0.50600785f, 0.16855381f, 0.30627471f, -0.29156822f, -0.35292235f, -0.27471626f, 
    0.35156465f, -0.04239544f, -0.12416844f, 0.16215609f, -0.18260306f, -0.03640714f, 0.30103680f, 0.30664042f, 
    0.27557951f, -0.12560774f, 0.03179003f, -0.30005220f, -0.05412465f, 0.83401328f, 0.58455616f, 0.77313733f, 
    -0.27067629f, -0.39639732f, -0.14512162f, -0.49320382f, -0.10775109f, 0.27308640f, 0.15306246f, 0.27399507f, 
    0.12139852f, -0.14558502f, 0.01046599f, 0.17448276f, -0.15140618f, 0.09134077f, -0.26935530f, -0.05370814f, 
    0.20530599f, -0.31250030f, -0.19287030f, 0.01281492f, 0.03707010f, 0.08080494f, 0.33615595f, 0.27276030f, 
    0.53058553f, -0.40818122f, 0.32770321f, -0.45508608f, 0.04525692f, 0.20735332f, 0.22839004f, 0.45601240f, 
    0.09619616f, -0.36731163f, -0.14102827f, -0.08492697f, 0.21554337f, 0.00643057f, 0.21744581f, 0.13228074f, 
    0.10038067f, 0.34426883f, 0.23600918f, 0.04117470f, -0.17495511f, 0.27452621f, -0.25926420f, 0.09457042f, 
    -0.49916223f, -0.68789732f, -0.36793068f, -0.39470449f, 0.20230471f, -0.10803925f, 0.32548845f, 0.42914218f, 
    0.28458756f, -0.13171495f, 0.00159280f, -0.21711080f, 0.11280878f, -0.22331661f, 0.27953726f, 0.20592739f, 
    0.33595410f, -0.20083593f, 0.02533971f, 0.17666052f, 0.34041274f, -0.09378975f, 0.20975775f, -0.07588597f, 
    0.50415492f, 0.25883949f, 0.51158035f, 0.43583879f, 0.14097624f, 0.45617720f, 0.32581791f, 0.21279114f, 
    0.26417911f, 0.19982758f, -0.17357560f, 0.16336025f, 0.00579751f, 0.10659364f, -0.04562058f, -0.18102749f, 
    0.30774465f, 0.15477811f, -0.08675374f, 0.15450440f, -0.10213373f, 0.19166754f, -0.27152070f, 0.03599980f, 
    0.34972894f, -0.80087692f, 0.47942427f, 0.38690946f, -0.28121325f, -0.35317922f, 0.23293546f, 0.75805938f, 
    -0.39442211f, -0.21655209f, 0.10948596f, 0.09656385f, 0.12071074f, 0.11733511f, -0.18285079f, -0.00827566f, 
    0.14663078f, -0.20331138f, -0.14205144f, -0.05755110f, -0.18462385f, 0.13402717f, 0.04563553f, 0.18959667f, 
    -0.02296455f, -0.00423088f, -0.08299609f, -0.88964927f, -0.42598000f, 0.20420285f, -0.11451079f, -0.59420210f, 
    -0.17579030f, 0.22414936f, -0.13789612f, 0.11023279f, 0.05451426f, 0.25122130f, 0.25873727f, 0.18818864f, 
    0.20558707f, -0.11402886f, 0.13996410f, 0.10549508f, -0.01788155f, 0.00356095f, 0.09063840f, -0.04049124f, 
    -0.19228463f, -0.06333959f, 0.18627213f, 0.42730623f, -0.10407693f, 0.15824069f, -0.23013037f, -0.23083055f, 
    0.37157887f, -0.63988996f, -0.04616979f, 0.63999033f, 0.42644370f, 0.09749763f, -0.27931061f, -0.14569637f, 
    0.31643280f, -0.20408131f, 0.14261335f, 0.06584156f, 0.02234582f, -0.08836205f, 0.31552511f, 0.04969368f, 
    0.06215956f, 0.19566242f, -0.04504338f, -0.04652780f, 0.28696787f, 0.62269431f, 0.36473110f, 0.47614259f, 
    0.36917970f, -0.10757879f, -0.38823134f, -0.00720810f, -0.65476066f, -0.07830088f, 0.36320391f, -0.06433241f, 
    0.10273554f, 0.18903793f, -0.03458369f, 0.24870121f, -0.20557785f, -0.16877933f, 0.12307718f, -0.04219220f, 
    -0.02116084f, -0.10943362f, 0.11135608f, 0.17861466f, 0.24738149f, 0.73359549f, 0.56074667f, -0.35461888f, 
    -0.61152434f, -0.41486320f, -0.05500992f, 0.01877397f, -0.39733368f, -0.09222276f, -0.19324906f, 0.13056362f, 
    -0.02320167f, 0.28863955f, 0.20573850f, -0.10898654f, 0.17020094f, 0.06978830f, 0.09505320f, 0.03735018f, 
    0.05704250f, 0.06955006f, -0.21847665f, -0.11574470f, -0.00879634f, 0.26972157f, 0.21957599f, 0.55631387f, 
    0.59020805f, 0.31562293f, 0.26665384f, 0.37205875f, -0.22688304f, 0.16680914f, -0.12890400f, 0.11731339f, 
    -0.35043928f, -0.13515155f, 0.14022411f, 0.19796526f, -0.27055565f, -0.14650084f, 0.00278152f, -0.00325865f, 
    -0.15537691f, -0.13789114f, -0.25929818f, -0.13677554f, -0.01909130f, -0.26601639f, -0.21443667f, 0.70063442f, 
    -0.00126538f, 0.41583320f, 0.44637462f, -0.25541034f, -0.70260084f, 0.35301772f, -0.16769023f, 0.00072445f, 
    -0.34214777f, 0.32007062f, -0.08618336f, 0.04639010f, -0.19957620f, -0.00266770f, 0.27462661f, -0.25377536f, 
    -0.03759748f, 0.18286146f, 0.09890607f, 0.01260770f, -0.16873504f, 0.05612306f, -0.08581352f, 0.20259418f, 
    -0.33366796f, -0.67743111f, -0.45870286f, 0.11166732f, 0.02797428f, -0.64043617f, 0.61183196f, 0.57902992f, 
    -0.47951356f, 0.01549395f, 0.06839569f, -0.14900240f, 0.03346926f, -0.12606980f, 0.27148131f, -0.23147750f, 
    -0.05901662f, 0.04389900f, -0.14816922f, -0.21604483f, 0.06269037f, -0.13369022f, 0.12879728f, 0.11876189f, 
    0.01159569f, 0.57352394f, 0.47034585f, 0.45504457f, 0.35454291f, 0.21845992f, 0.23757586f, 0.01181516f, 
    -0.19982028f, -0.35326084f, -0.20096329f, -0.05412901f, 0.14498830f, 0.12967247f, -0.20165288f, 0.20154403f, 
    0.09628811f, -0.17579977f, 0.37464410f, 0.04464563f, 0.04041716f, -0.05315750f, 0.11909546f, -0.09817348f, 
    -0.16994126f, 0.04356331f, -0.14712197f, -0.14914227f, -0.39516076f, -0.26368842f, -0.42122063f, 0.27548817f, 
    0.61638069f, -0.39390242f, -0.17459922f, 0.25426176f, 0.03713638f, -0.36359096f, -0.16206776f, 0.06176613f, 
    0.25853768f, -0.23041840f, -0.11899430f, -0.02848124f, -0.06226812f, -0.09169173f, 0.01728218f, -0.12437379f, 
    0.04315827f, 0.15022190f, -0.05083735f, 0.40689486f, -0.26386186f, -0.37212858f, -0.50803524f, -0.24008428f, 
    0.27703232f, 0.59492415f, -0.00719321f, -0.04619649f, 0.27676129f, -0.46829882f, 0.07454991f, -0.11276499f, 
    0.30173340f, 0.23467523f, -0.23834431f, -0.06080285f, -0.07539680f, -0.03761214f, -0.08732731f, -0.13693729f, 
    -0.10391591f, 0.24895543f, -0.04496593f, -0.04050506f, -1.07658422f, 0.39048448f, 0.24983522f, 0.15125374f, 
    -0.11627407f, 0.05513535f, 0.91341931f, -0.18902315f, 0.14614326f, 0.44790304f, -0.30492461f, -0.03833646f, 
    0.50688761f, -0.25619495f, 0.08915000f, 0.05715214f, -0.10022504f, 0.11447193f, 0.03830810f, 0.00571356f, 
    0.02922313f, 0.07323224f, 0.00157771f, 0.23462071f, -0.02252434f, 0.02242627f, 0.13986601f, 0.46729502f, 
    0.65202338f, -0.03897268f, 0.50405902f, 0.40022075f, 0.10842430f, 0.33112773f, 0.15728270f, -0.44169569f, 
    -0.10575004f, -0.20447610f, -0.08867867f, 0.16520530f, -0.03072487f, -0.07144529f, -0.30567303f, -0.25751060f, 
    -0.07688168f, -0.12545852f, 0.20397317f, -0.14881858f, 0.29282853f, -0.21945587f, 0.62250561f, -0.29646727f, 
    -0.45049593f, -0.49948817f, 0.19710170f, 0.17887254f, -0.29361355f, 0.25903639f, 0.30897471f, -0.09134877f, 
    -0.48860037f, 0.23963657f, 0.38730714f, -0.11204897f, -0.22569825f, -0.13171059f, -0.07274648f, 0.08450706f, 
    -0.10224535f, 0.16944264f, 0.09245308f, 0.03160969f, 0.25103590f, 0.09518606f, 0.06024825f, 0.09778616f, 
    -0.52948332f, 0.28402933f, 0.47941443f, -0.31404978f, -0.41804779f, -0.12451426f, -0.34511697f, -0.22809216f, 
    -0.11188735f, -0.20026368f, 0.20745541f, 0.07844456f, -0.38549334f, -0.04537139f, -0.40193170f, -0.23370606f, 
    -0.07424588f, 0.32785106f, -0.20372523f, 0.08300511f, 0.15623088f, -0.38740200f, -0.18458493f, -0.20481059f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16666171f, 0.20096679f, 0.16448237f, -0.08221066f, 0.25857469f, 0.05171972f, -0.11559646f, -0.06687535f, 
    0.26327038f, 0.06662521f, -0.00534644f, -0.01618429f, 0.11065091f, -0.04775315f, 0.14683062f, 0.15212712f, 
    0.13078265f, 0.18427087f, 0.07149091f, 0.23996198f, 0.35067469f, 0.02804183f, 0.02959200f, 0.19160683f, 
    0.29804003f, 0.07432132f, -0.06384046f, 0.07721939f, 0.10446347f, -0.00094703f, 0.14469397f, -0.03884033f, 
    0.25517023f, 0.12400091f, -0.08837879f, 0.09982366f, -0.06719196f, 0.00321602f, 0.23688602f, 0.21144152f, 
    0.18325485f, 0.27615398f, 0.17636159f, 0.21493566f, 0.02486542f, 0.17791742f, 0.07406302f, -0.12030794f, 
    0.22604606f, 0.14840566f, 0.29835492f, -0.01238430f, 0.17115785f, 0.10308243f, -0.00413111f, 0.02512424f, 
    0.10915788f, -0.04400423f, 0.08955368f, 0.07359584f, 0.06100107f, 0.14434977f, -0.02181812f, 0.20189041f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01541509f, -0.00914732f, -0.01395439f, 0.02521860f, -0.01248694f, 0.01794563f, 0.01687914f, -0.03386506f, 
    0.00072322f, -0.02700818f, -0.01129842f, 0.00545495f, 0.00081058f, -0.02754172f, 0.00416721f, 0.00453657f, 
    0.02106720f, -0.02805441f, -0.00379949f, -0.01675983f, 0.00226868f, -0.00840213f, -0.00666009f, 0.00648335f, 
    -0.01469082f, -0.01779727f, -0.02436059f, 0.02283371f, -0.03581416f, 0.00755742f, -0.04263815f, -0.02042839f, 
    0.01341252f, 0.02675908f, 0.02556244f, 0.01410801f, 0.00890630f, 0.00008865f, -0.01329367f, -0.00310612f, 
    0.00467378f, -0.00150505f, -0.01410425f, 0.01839931f, 0.00339717f, 0.02055749f, 0.01341958f, -0.01680842f, 
    -0.00009185f, -0.02253140f, -0.02073842f, 0.00250058f, 0.01004890f, 0.00028665f, -0.02071785f, -0.01506241f, 
    0.01920066f, 0.01316490f, -0.00798693f, -0.00588921f, 0.02166286f, -0.03663088f, -0.03653995f, -0.00822196f, 
    -0.04077625f, 0.01638774f, -0.04358831f, -0.04156182f, 0.02896350f, -0.00889633f, -0.00190443f, 0.00438852f, 
    -0.00774278f, -0.03523226f, -0.01586585f, 0.01422973f, -0.01332616f, 0.02246461f, 0.02537251f, -0.01215204f, 
    0.01432550f, -0.00614058f, -0.02106805f, -0.01484037f, 0.02754215f, -0.00864533f, 0.00986544f, -0.03082317f, 
    -0.04261443f, -0.02242531f, 0.02041521f, 0.02274246f, -0.00578180f, 0.01660635f, -0.02208469f, 0.02655960f, 
    0.00249141f, -0.01777849f, 0.01602100f, 0.02521344f, 0.00665263f, -0.04098030f, -0.01142153f, 0.02254316f, 
    0.00135591f, 0.01992903f, 0.01711788f, -0.03047120f, -0.02358991f, -0.01322330f, 0.02663698f, 0.01793757f, 
    0.01308543f, -0.02293056f, -0.03790454f, -0.01549674f, -0.00841899f, 0.01551350f, 0.00424784f, 0.02102057f, 
    -0.00148037f, 0.00718777f, -0.02079488f, 0.01370121f, -0.03745133f, 0.00850910f, -0.04220216f, -0.01909837f, 
    -0.03594856f, 0.02489482f, -0.00888029f, -0.04178170f, 0.00862927f, 0.00873183f, 0.01550828f, -0.00574830f, 
    -0.01746168f, -0.01228626f, -0.02979752f, -0.02427892f, -0.02825743f, -0.01217871f, -0.00631458f, -0.00683172f, 
    0.00186954f, -0.02061271f, -0.03539415f, -0.00508543f, -0.03218588f, -0.03123892f, 0.01269364f, 0.00223295f, 
    0.00399597f, 0.01847736f, -0.01125468f, -0.01373762f, -0.00439319f, -0.03710344f, -0.03725531f, -0.02850360f, 
    -0.01185093f, -0.03376323f, 0.01172173f, 0.01607734f, -0.02276530f, -0.00958179f, -0.00769992f, 0.00456559f, 
    0.02097539f, -0.01385050f, -0.03215429f, -0.01377875f, -0.02413223f, -0.02322463f, -0.01331533f, -0.00122503f, 
    -0.00322267f, -0.01241624f, -0.02944147f, -0.00121393f, 0.00411947f, 0.01041084f, 0.02587788f, -0.02728860f, 
    0.01194847f, 0.01431823f, -0.01079801f, 0.00522726f, 0.01750364f, -0.04133060f, -0.03529023f, -0.03157205f, 
    -0.03585605f, -0.03174562f, -0.00261117f, -0.01121897f, 0.02603589f, 0.00489739f, 0.01167435f, 0.00744369f, 
    -0.01301622f, 0.00096575f, 0.01126285f, 0.00720080f, 0.01252879f, 0.00132466f, -0.01539167f, 0.02228331f, 
    0.01705250f, -0.00752730f, -0.03870085f, 0.00136708f, -0.02778090f, -0.03392170f, -0.04167007f, -0.03878376f, 
    -0.03285290f, -0.03028619f, -0.01591538f, 0.01651422f, -0.02923799f, 0.00521123f, -0.01291906f, -0.01917159f, 
    -0.04337914f, -0.00045282f, -0.02001787f, -0.03558875f, -0.03449935f, -0.02745899f, -0.04076048f, -0.02039393f, 
    -0.00416341f, -0.01286713f, -0.02822891f, -0.00551322f, 0.02795147f, -0.00893362f, 0.01615411f, -0.00517289f, 
    -0.03726134f, -0.03197758f, -0.01022495f, -0.03825705f, 0.02749494f, -0.02696288f, -0.03759348f, -0.02344801f, 
    0.02681216f, 0.02798697f, 0.02534723f, -0.00282554f, -0.00751022f, -0.03659473f, -0.00456170f, -0.01301822f, 
    0.02338150f, -0.03045697f, 0.02691287f, -0.03842307f, -0.00420960f, 0.01004295f, -0.01009444f, -0.04330419f, 
    0.02054487f, -0.03402420f, -0.02545742f, -0.03698819f, 0.01855596f, -0.02903171f, -0.03128344f, -0.02072840f, 
    0.01432444f, 0.01050011f, -0.00891465f, 0.00251397f, -0.03517145f, 0.00725372f, -0.00366315f, -0.00975296f, 
    -0.02566222f, -0.03868292f, 0.01940897f, -0.03575915f, -0.01540463f, -0.01323977f, -0.01764211f, -0.03894918f, 
    -0.03841646f, 0.02053267f, -0.01728833f, 0.01620787f, 0.02504885f, -0.01489889f, -0.00423582f, -0.01730602f, 
    0.00691851f, -0.00524205f, -0.00298669f, 0.00374093f, -0.02417842f, -0.00128170f, -0.02078331f, 0.01692409f, 
    -0.03624640f, -0.00661634f, -0.00000694f, -0.00166891f, 0.01069023f, -0.00221773f, -0.00117970f, 0.02552486f, 
    -0.03346048f, -0.02883420f, -0.00506985f, -0.01360024f, 0.02163345f, -0.00245045f, 0.02160502f, -0.01710396f, 
    -0.03445045f, 0.02636644f, -0.01228992f, -0.00880366f, 0.00207224f, -0.02730629f, -0.04207074f, -0.03477105f, 
    -0.01273556f, -0.00619752f, -0.00598790f, -0.01372916f, 0.00146168f, 0.02240097f, -0.01032869f, -0.02538086f, 
    -0.00374329f, -0.00127739f, -0.00345371f, -0.01580298f, -0.02931660f, 0.02180377f, 0.02251831f, -0.02009442f, 
    -0.02295639f, 0.01482580f, 0.01555823f, 0.01284508f, -0.03484143f, -0.02743176f, -0.03193648f, -0.02597337f, 
    -0.02075521f, 0.02065441f, -0.00601252f, -0.01024761f, -0.00705690f, 0.01531788f, 0.01098136f, 0.00165527f, 
    0.01073931f, 0.03096505f, -0.03793120f, -0.02889693f, 0.00254311f, -0.02796965f, 0.00855743f, 0.01500865f, 
    0.00515962f, -0.03998859f, -0.00401424f, -0.01311530f, -0.00251995f, -0.02937467f, 0.00864138f, -0.01959701f, 
    -0.01389438f, -0.00258899f, 0.00720769f, 0.00520798f, 0.02729645f, -0.01363122f, -0.01170332f, 0.00599140f, 
    0.02134787f, -0.04267410f, 0.00910617f, -0.04212147f, -0.00128911f, 0.01055954f, 0.02011536f, -0.00860077f, 
    -0.02250367f, -0.01471362f, -0.01400794f, -0.02620308f, -0.04109050f, 0.00702598f, -0.01516340f, -0.00910353f, 
    -0.02543443f, 0.02477066f, -0.01325395f, 0.02331339f, -0.00726610f, 0.01033987f, -0.00089724f, -0.00161255f, 
    -0.00534248f, -0.00169962f, 0.00547790f, -0.03219940f, 0.02301828f, 0.02114283f, 0.00090680f, 0.00298224f, 
    0.00940649f, 0.01819764f, -0.00725087f, -0.01808883f, 0.02748987f, 0.00310098f, -0.01223544f, -0.01533874f, 
    -0.02075152f, -0.04366913f, -0.01014777f, -0.01587583f, 0.01725327f, -0.00012197f, -0.01819402f, 0.00160898f, 
    -0.01696482f, 0.02427938f, 0.00921165f, -0.02835700f, 0.02687023f, -0.02402797f, -0.03312773f, 0.01907838f, 
    -0.01791335f, -0.00362911f, -0.02447450f, -0.01306470f, -0.01021106f, 0.02409574f, -0.03749905f, -0.01566007f, 
    0.00947081f, -0.03885969f, 0.02103579f, 0.00757126f, -0.02095682f, 0.00581627f, -0.02862750f, 0.01429111f, 
    0.00737178f, -0.01171010f, 0.02749387f, 0.02117234f, -0.01563944f, -0.01458998f, 0.02123481f, 0.00943477f, 
    0.01518496f, -0.02033675f, 0.01439652f, -0.02826211f, -0.01573440f, -0.01410136f, 0.02148290f, 0.00846912f, 
    -0.02497325f, -0.02053080f, 0.01966147f, -0.00675011f, 0.00322116f, -0.03096854f, -0.04085356f, -0.03620142f, 
    0.00895243f, 0.01769330f, -0.04280121f, -0.01240853f, 0.00918015f, -0.01243777f, 0.00924056f, 0.02616304f, 
    -0.02470539f, -0.03198826f, -0.00643808f, -0.03083083f, -0.03052560f, 0.00623454f, -0.03425347f, -0.03380042f, 
    0.02420483f, -0.04098089f, -0.01810062f, 0.01520647f, 0.01046714f, -0.03741653f, -0.04337705f, -0.02996201f, 
    0.01475754f, 0.02069585f, -0.02571886f, 0.01845769f, -0.00385110f, -0.00257671f, -0.03049621f, 0.02367819f, 
    0.00439546f, -0.04145527f, -0.04303836f, -0.01058842f, -0.00162316f, 0.02226147f, -0.01513407f, -0.03391365f, 
    0.02336348f, 0.00157013f, -0.01945410f, -0.00494254f, -0.00031364f, 0.00900529f, -0.02011295f, -0.02082264f, 
    -0.01188037f, 0.01898549f, 0.02194059f, -0.01873827f, -0.01078188f, -0.02393977f, -0.00268904f, -0.04028364f, 
    0.00383703f, 0.00478787f, -0.00863181f, -0.01074305f, -0.02508034f, -0.02865533f, 0.01984440f, -0.01629976f, 
    -0.00981972f, -0.01361069f, 0.01714822f, -0.00364652f, -0.02506270f, -0.02800487f, 0.01228314f, -0.02595369f, 
    -0.04224711f, -0.03154856f, -0.02012068f, 0.00450394f, -0.04066877f, -0.03025272f, -0.03780857f, -0.01277468f, 
    0.02037940f, 0.01848094f, -0.00415464f, 0.00252289f, -0.02454911f, -0.02324085f, -0.00910436f, 0.01964375f, 
    -0.01214790f, 0.00626904f, -0.03139526f, -0.04108639f, -0.03838063f, 0.00323438f, -0.03025209f, 0.02431188f, 
    0.02565616f, 0.01726091f, -0.01927261f, -0.04192319f, -0.00270124f, -0.03032432f, -0.01238366f, 0.01952220f, 
    0.01657011f, -0.00579722f, -0.03390580f, 0.02558991f, 0.00296697f, 0.01431028f, -0.00481659f, -0.03802133f, 
    -0.03254324f, -0.01016855f, 0.01914242f, 0.02096527f, -0.00471620f, 0.00978453f, -0.04096164f, -0.00685570f, 
    0.02751330f, -0.03027414f, 0.01209660f, -0.03773054f, -0.00620556f, -0.00774307f, 0.01895264f, -0.01510779f, 
    -0.00273602f, -0.03795297f, -0.00260653f, -0.02980818f, -0.02105534f, 0.02420129f, -0.02832521f, 0.02591439f, 
    -0.01200267f, -0.02826224f, 0.02309176f, 0.02367649f, 0.02350562f, -0.01901266f, 0.00135097f, 0.00706096f, 
    -0.03937595f, 0.01391426f, -0.03744979f, -0.01629453f, -0.01237377f, -0.00102128f, 0.02063718f, -0.00752644f, 
    0.00119643f, -0.03556912f, -0.02336465f, 0.00851619f, -0.01146132f, -0.03053010f, -0.01981616f, 0.01104322f, 
    -0.01230991f, -0.00485023f, -0.00151477f, -0.02892441f, 0.01376028f, -0.01270510f, -0.02627890f, 0.02351825f, 
    -0.03852562f, 0.01693735f, -0.04212721f, 0.01065787f, 0.00247373f, -0.04076749f, -0.03312737f, -0.01756882f, 
    -0.03748813f, -0.02285614f, -0.02103326f, 0.02164607f, 0.01137322f, 0.01188107f, -0.03714298f, 0.01039083f, 
    0.02171249f, -0.01401739f, 0.00669870f, -0.01536664f, -0.00172392f, -0.00954208f, -0.01472662f, 0.00468187f, 
    0.02010389f, -0.00610542f, -0.03755336f, -0.00718131f, -0.00026807f, -0.00666962f, 0.00063294f, -0.01629405f, 
    0.01973511f, -0.01833647f, -0.03605244f, 0.00464634f, -0.03739419f, -0.00097953f, -0.03594087f, 0.00399038f, 
    -0.01466522f, 0.00225600f, 0.02015541f, -0.01313062f, -0.02506417f, -0.00134181f, 0.00886694f, -0.03277287f, 
    -0.01199707f, 0.01936826f, -0.01154517f, 0.00984927f, -0.00229262f, -0.03210135f, 0.00454301f, 0.01452849f, 
    -0.02016207f, -0.00896437f, -0.03785154f, -0.00952334f, 0.00845257f, -0.04188178f, -0.02213199f, -0.02252684f, 
    0.03204239f, -0.00501195f, -0.03250662f, -0.03402112f, 0.00174776f, 0.01155575f, 0.01928967f, -0.04088331f, 
    -0.03125876f, -0.01280897f, 0.00945714f, -0.01167134f, 0.01696297f, -0.02701413f, -0.00395535f, 0.01542026f, 
    0.00289968f, 0.02091906f, -0.00830986f, -0.02140660f, -0.00299042f, 0.01011636f, 0.02053684f, 0.00085599f, 
    -0.00527655f, -0.01272754f, 0.01172808f, -0.00982055f, -0.01907404f, 0.01001217f, 0.02604212f, -0.00237484f, 
    -0.03741490f, 0.01345926f, 0.02462586f, 0.00221540f, 0.00631657f, 0.00949006f, 0.00649729f, 0.02207303f, 
    -0.03309701f, -0.00045431f, -0.00400644f, -0.03628377f, 0.02699373f, -0.00256980f, 0.00312780f, -0.00120584f, 
    -0.00291531f, -0.02489873f, 0.00954663f, 0.02545518f, -0.02526160f, 0.03259915f, 0.00721476f, 0.01333186f, 
    0.00702102f, 0.01390629f, -0.00303432f, -0.00689802f, -0.00167799f, -0.01048493f, -0.02771975f, 0.01085954f, 
    0.02313893f, -0.03476741f, -0.01336589f, 0.01583177f, 0.02601357f, -0.00070178f, 0.02028639f, -0.01526705f, 
    -0.00257806f, -0.03398819f, -0.02823056f, -0.01441785f, -0.02730405f, 0.01508353f, -0.03918444f, -0.01586258f, 
    -0.03804822f, -0.01024485f, -0.02506753f, -0.00401698f, -0.01339478f, -0.00922988f, 0.02727825f, 0.00055638f, 
    0.02736037f, -0.02373863f, 0.01256610f, 0.01648703f, 0.00615975f, -0.01457781f, 0.01129360f, -0.01363940f, 
    -0.01351648f, 0.01422812f, -0.03027262f, -0.03158295f, -0.02876673f, -0.03959347f, -0.02319281f, -0.03077627f, 
    -0.03586582f, -0.00288814f, 0.00331614f, -0.02104714f, 0.00830743f, -0.03436210f, 0.02406233f, -0.00031453f, 
    0.00269913f, 0.00351606f, -0.03992169f, 0.01667686f, -0.03829790f, 0.02426966f, -0.02666840f, 0.00898719f, 
    -0.01785534f, 0.02536344f, -0.02810244f, -0.02686244f, -0.01969858f, -0.03219071f, 0.00704713f, -0.02739823f, 
    -0.01213636f, 0.01133023f, -0.00379112f, -0.00273086f, 0.02774717f, -0.01166079f, 0.00110889f, 0.02594582f, 
    -0.00424915f, -0.03502332f, -0.02335967f, 0.00145569f, -0.02110430f, -0.02906681f, -0.02746584f, 0.02079253f, 
    0.00362658f, 0.00516970f, 0.01824844f, -0.00930980f, -0.03374730f, 0.02992227f, 0.02837260f, -0.02416198f, 
    0.02929332f, 0.00544256f, -0.00351689f, 0.02908313f, -0.01856694f, -0.04157660f, 0.01089367f, -0.01852174f, 
    -0.00543817f, -0.03822157f, 0.00302582f, -0.00111764f, -0.01876932f, 0.01189233f, 0.02887546f, -0.02295971f, 
    0.02992104f, 0.02830878f, -0.03148583f, 0.00676405f, 0.03191699f, 0.01841060f, 0.04109672f, -0.03481393f, 
    0.00285948f, -0.00669767f, 0.00871613f, 0.00679916f, -0.00566398f, -0.03470144f, 0.01159523f, -0.00089757f, 
    0.02867958f, -0.02623196f, 0.01134166f, -0.04155879f, 0.00968348f, -0.03249856f, 0.00422843f, -0.02116469f, 
    -0.04107213f, -0.01316638f, 0.00671532f, 0.01836371f, -0.03129872f, 0.00166433f, 0.00884302f, 0.01267124f, 
    -0.01568326f, -0.03288464f, -0.01873670f, 0.02212014f, -0.00635075f, 0.00531207f, 0.02395252f, -0.02206179f, 
    -0.03949874f, 0.00717470f, -0.01644498f, 0.01878614f, -0.02891493f, 0.00745349f, -0.03476790f, 0.02162604f, 
    -0.03156339f, -0.03785792f, -0.04027697f, -0.02816222f, -0.02546688f, -0.00742446f, -0.01666767f, -0.02636500f, 
    0.01260831f, -0.00954110f, 0.03120886f, -0.01246150f, 0.02971201f, 0.00857445f, -0.03290212f, -0.04105958f, 
    -0.01036212f, -0.00626459f, -0.01740802f, 0.00818710f, -0.02682866f, 0.02038434f, -0.00698772f, 0.01710527f, 
    0.00700874f, -0.02361742f, -0.01176700f, 0.02645430f, -0.00178771f, -0.02327040f, 0.00857884f, 0.01377597f, 
    0.01207182f, -0.00869248f, -0.02221002f, -0.00228675f, -0.01214512f, 0.00465843f, -0.01201516f, -0.00038473f, 
    -0.03239409f, 0.01541416f, 0.01736040f, 0.01859053f, -0.01775069f, 0.00100021f, -0.03077667f, -0.03101361f, 
    -0.03552897f, 0.01549620f, 0.03736663f, 0.00079176f, 0.01979152f, -0.00660629f, -0.02087876f, 0.02036161f, 
    0.01053296f, 0.00758881f, -0.00341146f, 0.02882966f, 0.02015444f, 0.00435662f, 0.02456857f, -0.02442631f, 
    -0.03600691f, -0.03987291f, 0.01324876f, -0.03521029f, -0.03454800f, -0.04148378f, -0.00628057f, -0.03432663f, 
    -0.01064388f, -0.02981584f, -0.00018085f, -0.02850405f, -0.02508600f, -0.01459754f, -0.03548140f, 0.00812850f, 
    0.00555425f, 0.00729691f, 0.01395239f, 0.01367929f, 0.00066301f, -0.00398353f, -0.02084960f, -0.00044411f, 
    -0.00218239f, 0.02297686f, 0.01918756f, -0.02422404f, -0.02646241f, 0.01960655f, 0.00749069f, 0.02311120f, 
    0.00379357f, 0.01397642f, 0.00545511f, -0.01928910f, 0.02151548f, 0.00007388f, -0.04192845f, 0.00988104f, 
    -0.02209243f, 0.00968419f, -0.02374800f, -0.03398531f, -0.03989182f, -0.01884479f, 0.02839086f, 0.03775689f, 
    0.02861459f, 0.00266640f, -0.04036486f, -0.00079381f, 0.00892923f, -0.02400007f, 0.01349640f, -0.00861232f, 
    -0.03411962f, 0.01424060f, 0.00346468f, -0.01598015f, 0.02612061f, 0.01870813f, -0.01886351f, 0.02065645f, 
    0.01732466f, -0.03034893f, 0.02117774f, 0.00300316f, 0.00745761f, 0.00439695f, -0.04202741f, -0.02873305f, 
    0.02074105f, -0.02051453f, -0.00722211f, 0.03953150f, 0.01231944f, -0.02162832f, -0.02872070f, -0.04076552f, 
    -0.00640759f, 0.00975535f, 0.01757049f, 0.02287721f, -0.02691353f, -0.03889098f, -0.03714969f, -0.02673724f, 
    0.01587317f, -0.02002579f, 0.02234710f, -0.04050750f, 0.01937342f, 0.02744942f, -0.01175158f, 0.01811623f, 
    0.02700820f, -0.00917463f, -0.01642601f, 0.02041650f, 0.02252476f, -0.02926475f, -0.03594666f, -0.00159282f, 
    -0.03135345f, 0.02993081f, -0.01696713f, -0.03458917f, -0.01924299f, -0.00360625f, 0.02826342f, -0.01760244f, 
    -0.00619194f, 0.00031752f, -0.02881168f, -0.03045714f, -0.02317253f, 0.02175813f, -0.00082247f, -0.03268898f, 
    0.01006558f, 0.00597610f, 0.02294416f, -0.01858404f, -0.01548925f, 0.00108423f, -0.01244125f, -0.01007085f, 
    0.02464721f, 0.02165693f, -0.01133365f, 0.00249347f, 0.00188435f, 0.01689343f, 0.00923157f, -0.03243842f, 
    -0.02706506f, 0.01704733f, 0.03698606f, -0.01291116f, 0.02235062f, -0.02726669f, -0.01700237f, -0.01667784f, 
    0.02059668f, -0.01896050f, -0.00720825f, -0.01358786f, -0.02283074f, -0.01652557f, -0.00285217f, 0.02538045f, 
    0.00824633f, 0.01917077f, -0.02891316f, 0.00660376f, -0.00043984f, -0.04175121f, 0.02304679f, 0.00584771f, 
    -0.03724764f, -0.03395139f, 0.01150719f, 0.01998941f, 0.02753646f, -0.01144991f, 0.00533093f, -0.00026726f, 
    -0.01975894f, -0.01460858f, 0.02768388f, -0.01716575f, -0.02941724f, -0.00178188f, -0.00196870f, -0.03990071f, 
    -0.03721762f, -0.00744404f, 0.02713908f, -0.00899159f, 0.02519965f, -0.01708212f, -0.02885353f, -0.04121983f, 
    -0.01229242f, -0.03411944f, -0.01294055f, 0.02904974f, -0.01811520f, 0.02962177f, -0.00601120f, -0.03732499f, 
    0.02145342f, -0.01138885f, -0.02650261f, -0.02309603f, -0.02872682f, 0.02573038f, -0.00350700f, -0.00242201f, 
    -0.02031006f, 0.02433867f, 0.00976547f, 0.01788454f, -0.03943320f, 0.00304004f, -0.03123691f, 0.00354571f, 
    0.03007114f, -0.00223265f, 0.02346264f, -0.00512110f, 0.00377451f, -0.01301965f, -0.01871950f, -0.00202655f, 
    0.04030457f, -0.01143989f, 0.01678066f, 0.00043915f, -0.02852305f, -0.03635886f, 0.02411027f, -0.00578960f, 
    -0.01000969f, 0.01726844f, 0.03524486f, -0.00080234f, -0.02550671f, -0.04095249f, -0.03814453f, -0.02798514f, 
    -0.03626137f, -0.00039554f, -0.02611073f, -0.02628147f, -0.02513208f, -0.02987988f, 0.02602038f, -0.03345570f, 
    -0.02827756f, 0.02660672f, -0.01013807f, -0.01352364f, 0.02441394f, 0.02991948f, -0.01513961f, 0.02170255f, 
    -0.04162071f, -0.01509128f, -0.03375242f, 0.00637967f, -0.03227885f, -0.03823869f, 0.00558597f, -0.01824916f, 
    -0.04114590f, -0.02775884f, 0.01363392f, 0.00535188f, 0.01526202f, -0.01427667f, -0.03440316f, -0.00940738f, 
    -0.03936774f, -0.03457236f, -0.00958312f, -0.03998910f, 0.01681204f, 0.00557472f, 0.01667901f, -0.00526937f, 
    -0.01462315f, -0.00257936f, -0.00255655f, 0.00304921f, 0.00145880f, -0.00874496f, -0.02364101f, 0.02103315f, 
    -0.03785089f, 0.02376607f, 0.00070959f, -0.03225014f, 0.02778533f, 0.00666386f, -0.02235786f, -0.03561748f, 
    0.00057103f, 0.02829633f, 0.02060498f, -0.00654232f, -0.00510893f, -0.03949108f, -0.00585163f, -0.01147794f, 
    0.00027346f, 0.01803085f, -0.02683530f, -0.00674752f, -0.00535662f, -0.00728370f, 0.02769808f, 0.02808188f, 
    0.02823701f, -0.03902900f, 0.00674414f, -0.00990214f, -0.03211708f, -0.02937582f, 0.00568870f, -0.02508228f, 
    0.01523220f, -0.03460943f, -0.03212100f, 0.00175846f, 0.00980155f, -0.00124775f, 0.02260170f, 0.00347563f, 
    -0.00020899f, -0.00960519f, -0.01321405f, -0.01489551f, -0.03032178f, -0.00022061f, 0.02637924f, -0.00175931f, 
    -0.03993550f, -0.03331294f, -0.02014577f, 0.02842423f, 0.01092571f, -0.03553212f, -0.03861809f, 0.02259727f, 
    -0.02221304f, 0.00845246f, 0.00888669f, -0.01365064f, -0.01256417f, 0.02481283f, -0.02452065f, -0.00295793f, 
    -0.01831695f, 0.00227496f, 0.02508001f, -0.03186149f, -0.01784780f, -0.03886062f, -0.00839246f, 0.00232131f, 
    0.03165499f, -0.01926341f, -0.01172952f, -0.04149383f, 0.02925834f, -0.03419348f, 0.00540194f, 0.02205748f, 
    -0.03487575f, 0.02218022f, -0.02541389f, -0.01594485f, 0.00664452f, 0.01203114f, -0.01049550f, -0.02075298f, 
    0.02676230f, 0.02388447f, 0.02791259f, -0.03574493f, 0.02074041f, -0.01927063f, -0.04151818f, -0.03974811f, 
    0.02342478f, -0.01708283f, -0.00179658f, -0.03412835f, 0.00592939f, -0.01736216f, 0.00772163f, -0.03236691f, 
    -0.02410008f, 0.01994667f, 0.00424933f, -0.02852622f, -0.02456179f, 0.00246128f, -0.02618324f, 0.02373202f, 
    -0.00882370f, 0.03326963f, 0.01996100f, -0.02641537f, -0.00416596f, -0.03623503f, -0.04079384f, 0.01909456f, 
    0.00993591f, -0.00250651f, 0.02330673f, -0.03873454f, -0.00397226f, 0.00802365f, 0.00515214f, -0.02847261f, 
    0.02870625f, 0.00596616f, -0.00629736f, -0.01909884f, 0.00518238f, 0.02428816f, -0.03483224f, -0.01377978f, 
    -0.03247372f, 0.01421856f, -0.03871168f, -0.02160409f, -0.04160153f, 0.01758542f, 0.02112667f, -0.00138302f, 
    0.03000831f, 0.00415291f, 0.01386340f, -0.02583284f, -0.02227729f, -0.03118146f, 0.01880858f, -0.02886445f, 
    -0.03766345f, 0.00412678f, -0.00601007f, -0.03255083f, -0.00042859f, -0.01017682f, 0.01956240f, 0.01950832f, 
    0.00449105f, -0.02292569f, -0.02923900f, 0.01030049f, 0.01538783f, 0.02580192f, 0.02184452f, -0.00101546f, 
    -0.01428122f, 0.01420594f, 0.00886938f, 0.00443536f, 0.01807110f, -0.02607206f, -0.01440162f, -0.01940675f, 
    -0.03890550f, 0.00323283f, -0.02576317f, -0.02439246f, 0.00071458f, -0.00760411f, -0.03866728f, 0.01905361f, 
    0.01275082f, -0.03579906f, -0.00165269f, 0.00425794f, 0.00969422f, -0.02401349f, -0.03377098f, -0.03131007f, 
    -0.03198526f, 0.02222233f, -0.00871113f, -0.02738352f, -0.02412378f, -0.01720250f, -0.03092535f, -0.00857837f, 
    0.01791324f, 0.00486004f, 0.01774265f, -0.01094471f, -0.02892203f, -0.00604594f, -0.00172179f, -0.03306630f, 
    -0.03176679f, 0.00402958f, 0.01255567f, -0.00717168f, 0.02043008f, -0.01064051f, 0.02528944f, 0.02838467f, 
    -0.01070863f, -0.03941694f, 0.02425591f, -0.00943113f, -0.00064379f, 0.00109498f, -0.01312008f, -0.03738092f, 
    -0.01560060f, 0.01515263f, 0.00788590f, -0.02645457f, 0.00042743f, -0.02221197f, -0.02872947f, -0.03691910f, 
    0.01073482f, 0.01858916f, 0.02128313f, 0.02886320f, 0.00456520f, -0.00363997f, -0.01630337f, 0.00493273f, 
    -0.02693621f, 0.02187797f, -0.00719426f, -0.01949559f, 0.00287206f, -0.03239979f, -0.02435748f, 0.00629244f, 
    -0.04085583f, -0.03207712f, 0.02208244f, -0.00016158f, -0.03344302f, -0.00899113f, 0.00576703f, -0.00842599f, 
    -0.03729532f, 0.02276922f, 0.02405411f, -0.02765100f, -0.03702017f, 0.02791870f, -0.03219139f, 0.01790030f, 
    -0.03018397f, 0.01405217f, 0.02705392f, -0.03528002f, 0.01456491f, -0.01492390f, -0.03849893f, 0.02687895f, 
    -0.02222150f, -0.00613379f, 0.01872752f, 0.02710926f, -0.00155240f, 0.00774550f, 0.00194175f, -0.03095757f, 
    0.00507461f, -0.01066343f, -0.02318973f, -0.03974929f, -0.00777595f, -0.03436296f, -0.03255284f, -0.02311426f, 
    0.00558103f, 0.01367101f, -0.03255542f, -0.03102425f, -0.01169321f, -0.00509572f, 0.00945113f, -0.01277824f, 
    0.01399445f, -0.03792525f, 0.01966985f, -0.01344288f, -0.03761795f, -0.01893768f, 0.00634733f, 0.02185596f, 
    -0.00981553f, 0.01951677f, -0.02138293f, -0.01662908f, 0.01511012f, -0.02765502f, 0.02061152f, -0.03899202f, 
    -0.00342723f, -0.03117493f, -0.02045377f, -0.02906282f, -0.00568692f, 0.00662277f, -0.00510906f, 0.01245431f, 
    0.02149276f, -0.03843026f, -0.03866750f, 0.00626302f, 0.01176107f, 0.02333869f, 0.00270472f, -0.02097863f, 
    -0.00895958f, 0.00180925f, -0.02915589f, -0.01715185f, -0.01725614f, 0.02385961f, -0.02009184f, 0.01837527f, 
    0.00881497f, 0.01453992f, -0.04058027f, -0.00254850f, -0.03778467f, -0.01318300f, -0.02040395f, 0.01890658f, 
    -0.00043539f, -0.01194204f, -0.00681214f, -0.03492882f, 0.03215317f, 0.00812939f, 0.02105919f, -0.02493767f, 
    -0.00689208f, 0.02641446f, -0.00264803f, 0.00179399f, -0.00430235f, 0.02287242f, -0.02384637f, 0.03732249f, 
    0.02830643f, -0.03758568f, 0.00374478f, 0.00118356f, -0.03766296f, 0.01347755f, 0.01535211f, 0.02850294f, 
    -0.02760902f, 0.01272474f, 0.01556603f, 0.01116688f, 0.01978496f, -0.01127229f, 0.01694225f, -0.03477873f, 
    -0.02125891f, -0.03912219f, -0.03088482f, -0.01478329f, -0.00682134f, 0.00902696f, -0.01821844f, 0.00414816f, 
    0.00722799f, 0.00679318f, 0.01303170f, 0.02931496f, -0.00032002f, 0.00873460f, -0.03916363f, -0.00574379f, 
    0.00099225f, 0.02901304f, 0.02094386f, -0.01651965f, -0.01914337f, -0.01184523f, 0.02511559f, 0.00778474f, 
    -0.03962319f, 0.01323425f, -0.02857947f, 0.00738438f, -0.00867712f, -0.00634479f, 0.01829931f, -0.02515596f, 
    -0.00155855f, 0.02718453f, -0.03991819f, 0.02584432f, 0.01114574f, 0.01252054f, -0.02528024f, -0.03105840f, 
    0.01432424f, -0.00298748f, -0.00487228f, 0.01022780f, -0.00624103f, -0.03922307f, -0.02783110f, -0.01954450f, 
    -0.02134285f, -0.00461326f, 0.00590306f, 0.01706909f, -0.02581822f, 0.01434455f, 0.00835265f, 0.00192183f, 
    -0.00854170f, -0.03951560f, 0.00848568f, 0.00255483f, -0.01689243f, -0.00382720f, 0.02257104f, 0.01361164f, 
    -0.01875114f, 0.00225465f, 0.01177046f, 0.00265409f, 0.01512501f, 0.02082372f, -0.02903469f, -0.01598889f, 
    0.01164346f, 0.00676676f, 0.01420076f, 0.04022004f, -0.01159051f, 0.02330675f, 0.00740871f, -0.00435630f, 
    0.01083124f, -0.02539651f, -0.01070936f, -0.02014101f, -0.01870588f, 0.00586347f, -0.01656636f, -0.02297395f, 
    0.02237463f, -0.02406849f, 0.01845375f, -0.00876036f, -0.00490698f, 0.00344401f, -0.02533734f, -0.00287850f, 
    0.00478722f, -0.02125265f, 0.03509156f, 0.01402715f, -0.02577144f, -0.00871746f, -0.02046856f, -0.01832360f, 
    -0.01056843f, -0.03951122f, 0.01922419f, -0.02517494f, -0.00833291f, -0.03114277f, 0.02693301f, -0.03541758f, 
    0.00660483f, 0.02812657f, -0.00591798f, -0.00838617f, 0.01826616f, -0.02833054f, -0.03786692f, -0.02166400f, 
    -0.01257738f, -0.00537016f, -0.01513147f, -0.00899457f, 0.02313206f, -0.02690433f, -0.02032077f, 0.03060984f, 
    -0.01649806f, -0.00458258f, -0.02828647f, 0.02339035f, 0.02471255f, -0.03490067f, -0.03030778f, -0.02284401f, 
    0.00273043f, 0.00268334f, -0.01464899f, 0.01896736f, 0.02328348f, 0.02457519f, 0.00378570f, 0.01180227f, 
    0.01420989f, 0.00456576f, -0.00782453f, -0.00943113f, -0.01784977f, -0.00257661f, -0.00393275f, 0.01540475f, 
    0.02810251f, -0.01646495f, 0.00091174f, -0.03010526f, 0.00705293f, -0.04655301f, -0.00772596f, -0.02722079f, 
    -0.03860942f, -0.04489044f, 0.02036728f, 0.03934322f, -0.02419570f, -0.04218961f, 0.00817472f, 0.02178157f, 
    0.02920715f, 0.00697343f, 0.02344910f, -0.01540073f, -0.03373094f, -0.02733569f, 0.00436373f, -0.01542442f, 
    -0.00158481f, -0.00593135f, -0.03679512f, -0.00108738f, -0.03537738f, 0.02563391f, -0.02265695f, 0.03126895f, 
    0.02231514f, -0.02515303f, 0.03312932f, -0.01652263f, 0.03105221f, -0.01024072f, -0.03638734f, 0.01405474f, 
    0.02454117f, 0.00123257f, -0.03399847f, -0.00231164f, -0.00550825f, 0.02772233f, -0.00554122f, -0.04106999f, 
    -0.00842536f, 0.02686810f, -0.01227976f, 0.01270303f, 0.00514182f, -0.00985919f, 0.02486044f, -0.02151692f, 
    0.00637842f, 0.02927759f, -0.02500064f, -0.02623334f, -0.03211479f, 0.00835771f, -0.03808513f, -0.01897503f, 
    0.00207473f, 0.02482546f, -0.03075119f, 0.02178321f, -0.00943767f, -0.01513525f, 0.00009018f, 0.01271471f, 
    -0.01690316f, 0.00842728f, 0.02570068f, 0.01236327f, -0.02092717f, 0.00138554f, 0.00029434f, 0.00284024f, 
    -0.03114269f, -0.03220438f, -0.02008135f, -0.01301495f, 0.01500318f, -0.01244330f, -0.01360956f, -0.03482531f, 
    -0.00540161f, -0.03124505f, -0.00255925f, -0.02446447f, -0.01904009f, 0.01043702f, 0.01155455f, 0.01534134f, 
    0.02420493f, 0.00675828f, -0.02670795f, -0.03430451f, -0.02828602f, -0.01092114f, -0.01914490f, 0.00496979f, 
    0.00605378f, -0.01237169f, 0.02933396f, 0.01911371f, -0.03038783f, -0.01204693f, -0.03724742f, 0.00306953f, 
    -0.02379189f, 0.00935246f, -0.01769186f, 0.01635973f, 0.01616357f, -0.04331192f, 0.03037788f, -0.01919418f, 
    0.01465746f, 0.00636974f, -0.02407398f, 0.00375640f, -0.03401559f, 0.03102754f, -0.02878786f, 0.01631294f, 
    0.03054165f, -0.02366094f, 0.01057867f, 0.03126866f, 0.02856502f, -0.00085367f, 0.02749639f, -0.01379904f, 
    -0.01793648f, -0.00308956f, 0.01803204f, -0.02475636f, 0.00907609f, 0.00372158f, -0.04515894f, 0.01474595f, 
    0.02361203f, -0.01733839f, 0.02197865f, 0.00149600f, 0.02545052f, -0.03455869f, 0.01044831f, -0.02166868f, 
    0.01105782f, -0.02893149f, -0.02298292f, 0.00940099f, -0.03410452f, -0.04040097f, -0.01983836f, -0.02168754f, 
    -0.02810662f, -0.02312172f, 0.01484309f, 0.01477194f, 0.00411576f, 0.00869219f, -0.01817019f, -0.01637837f, 
    -0.01100269f, -0.01123055f, -0.02570793f, 0.01506563f, -0.01629343f, -0.03303980f, 0.01642893f, 0.00784750f, 
    0.01868315f, 0.00413600f, -0.01579841f, 0.00123460f, -0.01345759f, 0.02727572f, -0.00208727f, 0.00557642f, 
    -0.02159863f, -0.02382676f, 0.03850856f, -0.00329251f, -0.00022364f, -0.00842652f, 0.00789193f, 0.01239284f, 
    -0.03327230f, -0.00127205f, 0.00510826f, -0.02104645f, -0.03598830f, 0.01292268f, -0.03538884f, 0.00937168f, 
    -0.03534601f, 0.00001904f, -0.00054449f, -0.00186585f, -0.00496229f, -0.00059157f, 0.02478386f, 0.02708582f, 
    0.00858864f, 0.00509177f, -0.01794178f, -0.03984428f, -0.00132956f, 0.02366969f, 0.00994918f, 0.02268808f, 
    0.00860508f, -0.00490973f, -0.00173565f, 0.00288658f, 0.02679895f, -0.01307079f, -0.04469973f, -0.03198224f, 
    -0.02546843f, 0.00399059f, 0.02306420f, 0.02209928f, -0.02505229f, -0.02825101f, 0.00698942f, -0.00296215f, 
    -0.03179713f, -0.02059467f, -0.02491650f, 0.01260129f, 0.01393637f, 0.02219745f, 0.00460126f, 0.02986858f, 
    -0.03208809f, 0.02309808f, 0.00050282f, 0.02791546f, 0.01443083f, 0.02639794f, -0.03153796f, 0.00810724f, 
    0.01370512f, 0.03331007f, -0.00209749f, -0.00859574f, 0.00398026f, 0.02528498f, -0.02724161f, -0.02846409f, 
    0.00707319f, -0.00322293f, -0.00805241f, -0.00251878f, -0.01560254f, -0.02026938f, 0.01359155f, -0.02281259f, 
    0.00567427f, -0.00116953f, 0.02880719f, 0.02547484f, 0.00665678f, -0.02546246f, -0.04130216f, -0.01020176f, 
    -0.03331906f, -0.03903625f, 0.00511961f, 0.00696633f, -0.03042840f, 0.02010144f, -0.01583225f, -0.03469406f, 
    -0.01958053f, -0.00753413f, -0.00081184f, 0.00033082f, 0.00944678f, -0.03298176f, -0.01310737f, 0.02037659f, 
    0.02872794f, 0.03125462f, -0.01432197f, -0.04127168f, -0.03358879f, 0.01603303f, 0.02911981f, -0.00555909f, 
    -0.03239946f, -0.01720578f, -0.02226643f, 0.00206933f, 0.00542181f, -0.03080865f, 0.02630383f, 0.02122498f, 
    -0.00990772f, -0.03209113f, 0.00903717f, -0.00618715f, 0.01995863f, -0.01215873f, 0.00606538f, -0.02050870f, 
    0.02893070f, -0.01706280f, 0.02565582f, -0.01936644f, 0.03835390f, -0.00616586f, -0.01251520f, 0.03412542f, 
    0.01745882f, -0.01107278f, 0.03755480f, -0.02513975f, 0.01943626f, -0.03015963f, -0.01516238f, -0.01738325f, 
    0.01705728f, -0.03325785f, 0.01003199f, -0.01910985f, -0.00506854f, -0.01264299f, -0.01698602f, 0.02291805f, 
    -0.00935967f, 0.02254340f, -0.02228043f, 0.00269080f, -0.00468720f, 0.01412030f, 0.01993879f, -0.01754570f, 
    -0.02605467f, -0.02878773f, 0.03476880f, -0.01039109f, 0.02264367f, -0.01599682f, 0.01905257f, -0.02777122f, 
    -0.03942570f, 0.00257882f, -0.02986792f, 0.00872949f, 0.00907483f, -0.00958723f, 0.01383855f, -0.00850434f, 
    0.01659472f, 0.01693558f, 0.02542354f, -0.01123872f, 0.03627111f, -0.02166346f, 0.02313098f, 0.00138843f, 
    -0.00350778f, -0.01414775f, 0.03027854f, -0.02995073f, 0.01798770f, -0.01834976f, 0.02363948f, 0.00592650f, 
    0.01058213f, -0.00760838f, -0.00383892f, 0.01486534f, -0.02649490f, 0.02773486f, 0.01314396f, 0.02190664f, 
    -0.02277624f, -0.03884919f, -0.02023250f, -0.00473936f, -0.02661205f, 0.00777919f, 0.02213513f, -0.01817136f, 
    -0.03355253f, -0.04076685f, -0.01961693f, -0.03528008f, 0.00789847f, -0.02721693f, 0.01105884f, -0.02538643f, 
    0.02045123f, -0.01307835f, -0.02317875f, -0.03641475f, 0.02276230f, -0.02908208f, -0.00556800f, 0.02228293f, 
    -0.00864477f, 0.01415711f, -0.00346914f, -0.03171210f, 0.00949194f, -0.01632588f, -0.01262992f, -0.02799615f, 
    -0.03411539f, 0.01211840f, -0.02363442f, -0.00712455f, -0.01223803f, -0.01260066f, 0.01329494f, -0.02832022f, 
    -0.02794191f, 0.01833360f, -0.02613945f, -0.03400144f, -0.04180370f, -0.01064594f, -0.01361746f, -0.03392939f, 
    -0.00238213f, -0.00913560f, -0.01721379f, 0.01241562f, -0.03864068f, 0.03060910f, -0.02862094f, 0.00374737f, 
    0.00963618f, 0.01304374f, 0.01712457f, -0.01664032f, 0.00542140f, 0.01290871f, -0.03413999f, 0.00153143f, 
    -0.01284119f, 0.00221651f, 0.00236665f, 0.01505131f, -0.01060781f, -0.02083312f, 0.02372792f, -0.02265595f, 
    0.01029457f, -0.02099549f, 0.03305189f, 0.02025236f, -0.03168215f, 0.02349690f, -0.00315786f, 0.03005269f, 
    -0.00496271f, -0.00725191f, 0.02967379f, -0.00378893f, 0.02958591f, 0.01492518f, 0.00695974f, -0.01241749f, 
    0.00952540f, -0.02780175f, -0.01739931f, -0.01061157f, 0.02059634f, -0.01296117f, -0.03849594f, -0.03098835f, 
    -0.03494737f, 0.01352697f, -0.00857162f, -0.00791107f, 0.04568376f, -0.00313633f, 0.01810155f, -0.01384502f, 
    0.01609899f, -0.01656237f, 0.01521916f, 0.01883998f, -0.01018810f, 0.01169773f, 0.01268546f, -0.01014007f, 
    -0.02191507f, 0.00337107f, 0.01030592f, -0.01156255f, -0.03627393f, -0.00291612f, -0.01598225f, 0.01874867f, 
    0.01226962f, 0.17451173f, 0.18125811f, 0.08464561f, 0.07863110f, 0.07460123f, 0.05109306f, -0.11939580f, 
    -0.04082139f, -0.00382907f, -0.07635238f, 0.01301004f, -0.13027348f, -0.05803988f, 0.07326781f, 0.26148853f, 
    -0.08152784f, 0.01357982f, 0.03371507f, 0.05539297f, 0.04422081f, 0.00195256f, -0.02970470f, -0.06964924f, 
    0.00087837f, -0.04290392f, 0.02329521f, 0.25862214f, -0.06785282f, -0.06088034f, 0.10013785f, 0.00347890f, 
    0.04508915f, 0.00127520f, 0.01190009f, 0.06780829f, -0.05050747f, -0.24296534f, -0.11610705f, -0.28604424f, 
    -0.02902436f, 0.04644632f, 0.14192544f, 0.11309100f, 0.01286116f, 0.02726003f, 0.01806035f, -0.06654269f, 
    0.21537851f, 0.05523318f, 0.08908181f, -0.04495728f, 0.04734308f, 0.04431544f, 0.03640028f, 0.00555285f, 
    -0.06532945f, 0.01365614f, 0.09311467f, 0.08462681f, -0.13719819f, 0.01251560f, 0.04894494f, 0.01641914f, 
    0.08792901f, 0.01062041f, -0.04881190f, -0.00979380f, 0.00951382f, -0.07139154f, 0.05271215f, 0.06185138f, 
    -0.01862283f, -0.16430065f, 0.08605812f, -0.11129230f, -0.01704237f, -0.03521446f, 0.08690538f, -0.11040197f, 
    0.09115633f, 0.03151766f, -0.09493949f, 0.06316207f, 0.26917997f, -0.19363087f, 0.00132939f, -0.05666990f, 
    -0.09750613f, -0.01777644f, -0.06575747f, 0.01708244f, -0.07915453f, 0.00548670f, -0.00758379f, -0.01480643f, 
    -0.33435550f, 0.30270296f, 0.03243379f, -0.25375831f, 0.05340926f, 0.09050655f, 0.07213179f, 0.03858383f, 
    0.09721176f, 0.06713478f, 0.02097957f, 0.00072240f, -0.17719936f, 0.28564736f, 0.01503446f, 0.05297221f, 
    0.04379778f, -0.00591348f, 0.02792059f, 0.06889164f, 0.00829574f, 0.04501987f, -0.04980223f, -0.00147086f, 
    -0.02540074f, 0.17233799f, 0.06896145f, -0.13931218f, 0.05569958f, 0.07038625f, -0.02021544f, -0.07802912f, 
    0.09098319f, -0.07776906f, 0.05028456f, -0.00526929f, -0.16065462f, -0.10518856f, -0.09545401f, 0.29289144f, 
    -0.01304373f, -0.02728833f, -0.03544734f, 0.00502368f, 0.07229082f, 0.03852502f, -0.02506539f, 0.10065121f, 
    0.04033871f, 0.27477643f, 0.03763092f, -0.08693535f, -0.01522623f, -0.05916193f, 0.02478630f, 0.01376609f, 
    -0.05547061f, 0.08174494f, -0.02288776f, -0.05622985f, 0.26761684f, -0.12432566f, 0.13250779f, 0.05753025f, 
    0.00458727f, 0.18154435f, 0.01790886f, 0.08118305f, -0.02082062f, -0.03056875f, -0.11794668f, -0.05957915f, 
    0.16370961f, 0.08854735f, 0.03134884f, -0.19580069f, 0.05316806f, 0.05153910f, -0.09739685f, -0.05218080f, 
    0.01315735f, 0.10212953f, -0.00649600f, 0.05328650f, 0.22080120f, -0.06344882f, -0.00480340f, 0.10433886f, 
    -0.07645552f, -0.11139104f, 0.09767147f, -0.00003081f, -0.04903491f, 0.04652549f, -0.04144535f, 0.09588068f, 
    -0.00315871f, 0.06364313f, 0.09422330f, -0.04165568f, 0.08520378f, -0.08152267f, 0.05031684f, 0.02220749f, 
    0.05996033f, -0.04148817f, -0.02178027f, 0.06057695f, 0.33174208f, -0.22397202f, 0.13601260f, 0.17056718f, 
    -0.07130827f, -0.06354478f, 0.06928752f, 0.00346173f, 0.01401009f, 0.02546371f, 0.03911430f, 0.00653822f, 
    0.00469820f, -0.07526411f, 0.00847249f, -0.13262020f, 0.05180467f, 0.08759163f, -0.04627208f, 0.02457306f, 
    -0.03290953f, -0.07833337f, -0.06313252f, -0.04663558f, 0.28780407f, -0.09173709f, 0.05521327f, 0.30634049f, 
    -0.02063847f, -0.03148905f, 0.08677704f, 0.07711187f, 0.08457998f, 0.05278165f, 0.01077875f, -0.00888096f, 
    -0.00579873f, -0.02137724f, 0.05187691f, -0.14975818f, 0.10485802f, 0.02897278f, 0.08572364f, 0.09080921f, 
    -0.03308916f, 0.01858693f, 0.00740693f, 0.01168893f, 0.18226665f, 0.05168895f, 0.05027297f, 0.03267977f, 
    0.02579916f, 0.01070425f, 0.08190064f, -0.00835752f, 0.01933126f, -0.03034406f, -0.04699971f, -0.05605807f, 
    -0.44483668f, -0.03770239f, -0.03329883f, 0.31114724f, -0.02089989f, 0.05582898f, 0.00536785f, -0.03809405f, 
    0.07520860f, 0.09115607f, 0.12812699f, -0.00292081f, -0.13883711f, -0.05928246f, 0.05578586f, 0.32210097f, 
    -0.09237194f, 0.07326397f, -0.04940141f, 0.03428343f, 0.05437595f, -0.04663703f, -0.04135176f, -0.08745395f, 
    0.15461329f, 0.11222354f, 0.08453001f, -0.11232954f, 0.09621026f, -0.01339966f, 0.05747291f, -0.00763442f, 
    0.04930952f, 0.00165696f, 0.03714980f, 0.07049274f, -0.00282242f, -0.09621374f, 0.05186926f, -0.05001871f, 
    -0.01025274f, -0.04159934f, 0.04005126f, 0.06914035f, 0.06390961f, -0.04256149f, 0.02130584f, 0.05753436f, 
    -0.06792039f, 0.03562223f, 0.31036890f, 0.10319124f, -0.06750213f, 0.07086725f, -0.01936307f, -0.00462166f, 
    0.05466703f, 0.07122695f, -0.00263781f, -0.05066485f, -0.13973294f, 0.07654171f, 0.00160401f, -0.15840743f, 
    -0.02134860f, 0.01294129f, 0.01804222f, -0.10812871f, 0.02050855f, -0.03898396f, -0.05584698f, -0.04763945f, 
    -0.05961690f, -0.02968368f, -0.04462373f, 0.25393966f, 0.03377644f, 0.00568656f, -0.03225685f, -0.02480240f, 
    0.00584175f, -0.08637839f, -0.04798602f, -0.03471999f, 0.22894040f, -0.15105145f, -0.04699138f, -0.20894241f, 
    0.00334228f, -0.08507876f, 0.02867992f, 0.06675220f, -0.10738733f, -0.02393020f, 0.07714059f, 0.01066329f, 
    -0.30536878f, 0.17039968f, -0.10934052f, 0.02533446f, 0.02951783f, 0.15780675f, 0.03789927f, 0.02184860f, 
    -0.02485496f, -0.00872398f, 0.10765251f, -0.00123805f, -0.22192685f, 0.12516570f, -0.08402798f, 0.08661555f, 
    0.02821013f, 0.04210908f, -0.02140643f, -0.04512944f, -0.02772166f, 0.02284391f, -0.07699656f, -0.05146256f, 
    0.01583106f, -0.12203240f, 0.10920692f, 0.01693773f, 0.08753078f, 0.05408037f, 0.02883271f, 0.07573084f, 
    -0.08310200f, 0.03242771f, 0.04756434f, 0.14389154f, -0.22755682f, 0.30120340f, -0.02320945f, -0.01471623f, 
    0.04494599f, 0.08821615f, 0.08983812f, -0.02667527f, -0.04205169f, -0.07719968f, 0.03379176f, -0.00141351f, 
    0.25608560f, 0.18426323f, -0.03904972f, -0.14748280f, -0.02482996f, -0.11403023f, 0.07545939f, 0.06418737f, 
    0.06830920f, -0.03355714f, 0.02797973f, 0.00776686f, -0.06125828f, -0.04159346f, -0.02528281f, 0.01978890f, 
    0.00851420f, -0.03438548f, 0.06569823f, 0.12656890f, 0.02261991f, -0.06203880f, -0.01128238f, 0.01779960f, 
    0.20555006f, 0.00662974f, 0.06220720f, -0.23131922f, -0.00476669f, 0.03052787f, 0.02203831f, -0.04120968f, 
    0.00052839f, 0.05133872f, -0.05623393f, -0.02483811f, 0.35418400f, -0.11480447f, -0.08232673f, 0.18176909f, 
    -0.05300677f, 0.06753983f, 0.02022118f, 0.01032583f, 0.03221381f, -0.00605514f, 0.05460735f, 0.11766587f, 
    0.34283835f, -0.19821402f, 0.07989526f, 0.04904983f, 0.05610326f, 0.00056556f, -0.01035808f, 0.09770393f, 
    0.18249278f, 0.08820365f, -0.08781705f, -0.04398459f, 0.04269113f, -0.00714428f, -0.12819959f, 0.17359722f, 
    0.01657620f, 0.04444661f, 0.00472164f, 0.02617162f, 0.05206606f, -0.02115556f, 0.09206989f, 0.02282594f, 
    0.15690552f, 0.01639973f, 0.06464371f, 0.03131613f, -0.05702485f, -0.02805405f, 0.04938466f, 0.04708834f, 
    -0.04098641f, -0.01201676f, 0.08777301f, -0.04976485f, 0.12687589f, -0.08929491f, 0.14913605f, -0.11987770f, 
    -0.02399355f, -0.00474949f, 0.04562328f, 0.01266694f, -0.03059359f, -0.00486212f, 0.04865890f, -0.02796420f, 
    -0.02771280f, -0.09271275f, 0.05610710f, -0.14915302f, -0.08740126f, 0.03784274f, 0.14891532f, -0.00777618f, 
    0.04720156f, 0.02703265f, 0.05231316f, 0.01898705f, 0.05092004f, 0.09271222f, 0.03366642f, -0.04676183f, 
    0.02343108f, 0.04338548f, 0.05796674f, -0.13292052f, 0.03462682f, 0.03316775f, -0.04152854f, -0.03010439f, 
    0.09957373f, -0.09782062f, 0.10637169f, -0.13365166f, 0.04138268f, -0.04474337f, 0.02490349f, 0.03350344f, 
    -0.06225985f, 0.00416306f, -0.03907783f, 0.11917970f, -0.19930217f, 0.08679190f, -0.14607389f, 0.03703137f, 
    -0.01010448f, -0.07343601f, 0.05530423f, 0.09561524f, -0.05024933f, 0.04112476f, 0.05113061f, -0.01085847f, 
    -0.10600706f, 0.07303428f, -0.03948756f, -0.00602783f, -0.00992073f, -0.08380675f, -0.00137653f, 0.02716469f, 
    0.13633211f, 0.04237515f, -0.02759103f, 0.02192582f, 0.15782447f, -0.09039672f, -0.11326410f, -0.09134236f, 
    -0.00499056f, 0.02282722f, 0.01587458f, -0.05515721f, 0.11603873f, -0.04244730f, 0.01524159f, -0.01175554f, 
    0.10342047f, -0.05373244f, 0.06023173f, 0.11212809f, -0.12559059f, 0.02518216f, 0.01583646f, 0.01231956f, 
    -0.01237334f, -0.00199611f, 0.05587735f, 0.04911070f, -0.18276845f, 0.13313039f, 0.00395787f, -0.10578800f, 
    -0.04917073f, -0.01515860f, -0.03367503f, 0.09333265f, -0.01401282f, -0.02587812f, 0.03161119f, -0.00544595f, 
    0.05643305f, -0.11906914f, -0.03404533f, 0.11446065f, 0.00471450f, -0.01066816f, -0.01148327f, 0.11511799f, 
    0.01252147f, 0.01195167f, 0.05024160f, 0.05476056f, -0.05111250f, 0.02962421f, -0.00897200f, 0.06502316f, 
    0.03584294f, 0.01076643f, 0.03295732f, -0.09986390f, 0.04626987f, 0.04940491f, 0.05190466f, 0.00119429f, 
    0.13854466f, 0.06921815f, 0.12463212f, 0.25677806f, 0.02637290f, 0.06622376f, 0.03171830f, 0.01699088f, 
    -0.02201313f, 0.05578766f, -0.02234567f, -0.03809798f, 0.13415569f, -0.16240133f, 0.09732840f, -0.15487340f, 
    -0.07396160f, 0.00971013f, 0.18370137f, 0.04110042f, -0.10919143f, 0.08084622f, 0.00828288f, 0.03213109f, 
    0.08817200f, -0.07034621f, 0.09228493f, 0.25024092f, -0.00696636f, -0.04760376f, 0.12761304f, -0.02498904f, 
    0.00971077f, -0.08368240f, -0.02478077f, -0.00596208f, 0.11460372f, 0.09336136f, -0.13072182f, 0.12567513f, 
    -0.00454789f, 0.11316048f, -0.03140258f, 0.07236550f, -0.05488754f, -0.00599665f, 0.00410782f, 0.00920590f, 
    0.14376909f, -0.01065799f, -0.04969519f, 0.16766679f, -0.04188752f, -0.04306325f, -0.02956852f, 0.06354814f, 
    0.10282484f, 0.02906932f, 0.06369518f, 0.02842754f, 0.10594638f, -0.16215718f, 0.17920354f, 0.07090355f, 
    -0.00840848f, 0.00336843f, 0.02877290f, 0.04340675f, -0.02782937f, -0.01311535f, 0.01802262f, 0.06680887f, 
    0.15421125f, -0.02201480f, -0.01810235f, -0.15310585f, 0.02490924f, -0.04430223f, -0.04222689f, 0.11226824f, 
    0.00804494f, 0.01747782f, -0.00325823f, -0.06030595f, 0.27631116f, -0.00228500f, 0.18205069f, -0.21560283f, 
    -0.02056846f, -0.07281813f, 0.07699508f, 0.03253827f, -0.13513851f, -0.00284860f, 0.02587176f, 0.03918821f, 
    -0.22585201f, 0.23776202f, -0.04843705f, -0.01285733f, -0.06722071f, -0.01928389f, 0.01862430f, -0.01744561f, 
    0.02117111f, -0.00860502f, 0.08888597f, -0.03783164f, -0.03994855f, 0.12890080f, 0.04323471f, 0.21350224f, 
    -0.12486316f, 0.12627886f, 0.07529840f, 0.00370327f, -0.04753223f, 0.00325012f, 0.07119352f, 0.02050391f, 
    0.01865135f, -0.15367059f, 0.18588385f, -0.18002942f, 0.02538797f, -0.01822604f, 0.15292661f, -0.07117795f, 
    -0.06351651f, -0.08025824f, -0.02135628f, 0.02982676f, -0.07648499f, -0.03295683f, 0.00609501f, 0.27585500f, 
    -0.04146599f, 0.03240101f, -0.05321741f, 0.00203861f, 0.02150055f, 0.04648318f, 0.07019353f, -0.04818012f, 
    0.04902835f, -0.10441445f, -0.04215689f, -0.02685230f, -0.04540806f, 0.10289857f, 0.02057229f, 0.11601660f, 
    0.04292329f, 0.00307103f, 0.10096148f, 0.00248963f, 0.09392840f, 0.06127949f, 0.11302958f, 0.17193431f, 
    0.06778692f, 0.04820837f, 0.09032531f, -0.14674620f, 0.03297238f, -0.04532313f, 0.00236662f, 0.18353818f, 
    0.19076973f, 0.11950585f, -0.06618360f, -0.13545603f, 0.03022550f, 0.10952278f, 0.02857593f, 0.05852106f, 
    -0.06469423f, -0.01734436f, -0.04084372f, -0.02426960f, 0.26322490f, 0.27322230f, 0.11582489f, 0.13972712f, 
    -0.01680760f, -0.02756912f, -0.00573385f, 0.02227358f, 0.04187802f, 0.02435035f, 0.05887632f, 0.15522030f, 
    -0.14652131f, -0.08214883f, -0.07065780f, 0.07935521f, -0.03571014f, -0.07960381f, 0.01711135f, 0.02319751f, 
    -0.00598116f, 0.03496204f, -0.08971594f, 0.00904792f, 0.11538811f, -0.00573799f, -0.09274398f, 0.12241356f, 
    0.05756165f, -0.00901420f, 0.15696833f, 0.04977159f, 0.01224392f, 0.07270668f, 0.00555910f, 0.02719699f, 
    0.12216989f, 0.16991040f, -0.08639974f, 0.12105643f, 0.14200562f, 0.06545935f, -0.12528585f, 0.12785877f, 
    0.03555077f, -0.03077867f, 0.07691888f, -0.03753715f, 0.05194263f, 0.25182277f, 0.05598816f, -0.03500168f, 
    -0.08634891f, 0.10920037f, -0.01962448f, -0.01158706f, 0.05431875f, 0.02616139f, 0.04059225f, 0.03328510f, 
    0.23417097f, -0.02514671f, 0.04612052f, 0.21544023f, 0.00106013f, -0.03674228f, -0.01077716f, 0.01407186f, 
    -0.16249625f, -0.06438107f, -0.02016997f, 0.01549066f, -0.03473222f, -0.19702472f, 0.04950483f, 0.02152888f, 
    -0.03244115f, 0.01935806f, -0.06673155f, -0.01734386f, -0.13074552f, -0.01264836f, 0.02852538f, 0.04480441f, 
    0.16298735f, -0.07514909f, 0.03867014f, 0.03235816f, 0.11223600f, -0.03586341f, 0.03438019f, 0.13209519f, 
    -0.00353379f, 0.13455065f, 0.00093933f, 0.07043120f, 0.18230125f, 0.03303973f, -0.01900647f, -0.16620004f, 
    0.02876632f, 0.09723179f, 0.08923061f, -0.04714619f, 0.06403729f, 0.00206550f, 0.02246623f, -0.14039636f, 
    0.01883140f, -0.04185980f, 0.07828689f, 0.15887372f, 0.14792207f, 0.05768258f, 0.01638314f, -0.01091269f, 
    0.06634415f, 0.02290736f, 0.06920587f, 0.09525216f, 0.01633799f, 0.08871225f, -0.04091423f, 0.08736353f, 
    -0.00041658f, -0.01532791f, -0.02897014f, -0.03651850f, -0.02406456f, 0.01582634f, 0.14099164f, -0.03106688f, 
    -0.04661936f, -0.15847270f, -0.07462312f, -0.00501566f, 0.03367331f, 0.07785450f, 0.02515568f, -0.13643382f, 
    0.12640882f, 0.00229545f, 0.03211625f, -0.02986521f, -0.12889397f, 0.16204903f, 0.10807438f, -0.04469960f, 
    -0.00558015f, 0.11630940f, -0.02307900f, 0.00706091f, 0.01222310f, 0.00596017f, -0.02927491f, -0.15812838f, 
    0.20433891f, 0.01163864f, -0.04241306f, 0.15184157f, -0.04549472f, 0.07126000f, 0.06156284f, -0.01737530f, 
    -0.18253499f, 0.03950641f, 0.00422823f, -0.07090796f, -0.18856570f, 0.22592990f, -0.02758017f, -0.20098002f, 
    0.08759961f, 0.09019405f, -0.05416977f, -0.06806590f, -0.10852644f, -0.09296893f, -0.01488005f, -0.05283793f, 
    0.12568949f, 0.05628433f, -0.10664722f, 0.02378083f, 0.01853875f, -0.04812606f, 0.04498751f, -0.04377931f, 
    -0.02612337f, 0.12589663f, 0.00003252f, 0.00454772f, -0.10608847f, 0.22666892f, 0.06197151f, -0.19945593f, 
    0.01569560f, 0.07545573f, -0.05878904f, -0.11902484f, -0.05840803f, -0.04633481f, 0.02234275f, 0.00585385f, 
    -0.06882803f, -0.08161777f, -0.06632280f, 0.04986889f, -0.03246824f, -0.00709923f, -0.06765575f, -0.03037640f, 
    0.03011057f, -0.06026100f, 0.09177689f, -0.06383274f, -0.07044763f, -0.08917671f, 0.08465389f, 0.00040822f, 
    -0.14624289f, -0.00339465f, -0.03853077f, -0.10609464f, -0.02796476f, -0.02207354f, 0.07867640f, 0.10906574f, 
    0.36726055f, 0.01508845f, -0.10789337f, -0.08875925f, 0.01125459f, -0.00145088f, 0.03872690f, -0.02276550f, 
    0.01355734f, -0.00405018f, -0.13833699f, 0.08269665f, 0.20467170f, 0.02955390f, -0.09217258f, -0.09511132f, 
    0.07080284f, 0.03639686f, 0.06058308f, -0.04444226f, -0.08482188f, -0.03724784f, -0.01184554f, 0.00328140f, 
    -0.11504266f, -0.06252950f, 0.05902491f, -0.16090937f, -0.10355721f, 0.05058407f, -0.03366755f, -0.00285074f, 
    -0.06456292f, -0.08025277f, 0.02324947f, -0.00642953f, -0.05007794f, 0.00684866f, -0.02227445f, 0.09099426f, 
    0.14727886f, 0.08159811f, -0.09395633f, 0.01319763f, 0.03324825f, 0.16446483f, 0.00053158f, 0.06686267f, 
    0.12103035f, -0.12724961f, -0.13445002f, -0.08883295f, 0.09606059f, -0.01862766f, -0.00034975f, 0.03103898f, 
    -0.09138994f, -0.05922078f, -0.02089021f, 0.10417226f, 0.10903955f, 0.07618342f, 0.03370434f, 0.22855185f, 
    0.00751101f, -0.03618280f, 0.04257192f, 0.07363859f, 0.01142366f, 0.00536408f, -0.01209074f, 0.09793431f, 
    0.17444646f, 0.07313389f, 0.03759641f, 0.09121362f, -0.04374534f, 0.19765095f, 0.07407985f, -0.07868492f, 
    0.11585031f, 0.10560988f, -0.02204068f, -0.02321636f, 0.01928823f, 0.16150324f, 0.00739249f, -0.05093735f, 
    0.05873186f, -0.03239354f, 0.04345280f, -0.06927557f, 0.06133601f, 0.01632657f, 0.05745653f, 0.03091807f, 
    0.27269903f, -0.12074281f, 0.06357138f, -0.01673575f, 0.00228478f, -0.03541212f, 0.09306195f, 0.02466426f, 
    0.04217258f, -0.03933484f, 0.00083280f, -0.01867267f, 0.28697771f, -0.13032359f, 0.10054652f, 0.30202281f, 
    -0.04812666f, -0.02131136f, 0.17933170f, 0.03281634f, 0.11402765f, -0.02928404f, 0.13562995f, 0.02541011f, 
    -0.23019160f, 0.01443710f, -0.00170903f, -0.02088272f, -0.08172294f, -0.06191635f, -0.06641113f, 0.01624421f, 
    0.09930009f, -0.07493283f, -0.00795471f, -0.15970773f, 0.31398159f, -0.35343423f, 0.17597172f, 0.15561986f, 
    0.03217358f, -0.19422415f, 0.02283562f, -0.03671007f, 0.00693283f, 0.02662735f, 0.00651187f, 0.01732889f, 
    -0.16272515f, -0.12909429f, 0.04864571f, -0.07092727f, 0.11735912f, 0.05521034f, -0.05274611f, -0.09232244f, 
    -0.03402773f, 0.01488550f, -0.00327230f, 0.11138759f, -0.09773878f, -0.03183996f, 0.00393674f, 0.16959098f, 
    0.14190830f, -0.00612342f, 0.01396444f, -0.06132202f, 0.04304868f, 0.02823355f, 0.07121853f, -0.08163365f, 
    -0.15014666f, 0.11173329f, -0.10317238f, 0.05070662f, 0.07536543f, 0.01170454f, 0.00194369f, -0.00770941f, 
    -0.02962791f, -0.03814034f, 0.06380511f, -0.00598466f, -0.27356845f, 0.11869109f, 0.11729012f, -0.18781078f, 
    -0.04811982f, -0.03343358f, 0.00163152f, -0.12013965f, -0.03418184f, -0.03321882f, 0.02516990f, -0.07945535f, 
    -0.18036683f, 0.25737849f, 0.02711588f, -0.00640694f, -0.13820541f, 0.05279363f, 0.03804258f, -0.04653564f, 
    -0.13959050f, -0.08778821f, 0.14594893f, 0.01889916f, -0.02828249f, 0.19866040f, 0.11230602f, -0.03406102f, 
    0.03863205f, -0.01199708f, -0.03027799f, -0.08681073f, -0.11299393f, 0.02125814f, -0.10064327f, 0.00685200f, 
    -0.17783524f, -0.02241794f, -0.03612509f, -0.00781849f, 0.11065601f, -0.00735372f, -0.04557456f, 0.05963666f, 
    0.02954826f, 0.03055568f, -0.00189968f, -0.00340525f, -0.16185206f, 0.03350477f, -0.02274838f, 0.11918457f, 
    -0.08056112f, 0.08183646f, -0.07475509f, 0.10394817f, 0.04736964f, 0.07425368f, -0.01378746f, 0.02760797f, 
    -0.11753879f, -0.01655139f, -0.14795938f, 0.24300654f, 0.04193377f, -0.06408498f, -0.06806938f, -0.01594755f, 
    -0.01378172f, -0.00082175f, 0.00603383f, -0.02729494f, -0.06727631f, -0.18996046f, 0.09165172f, 0.12045407f, 
    -0.02052128f, 0.09461773f, 0.00003684f, -0.00463002f, -0.11158957f, 0.03530080f, 0.09687521f, 0.00282909f, 
    0.07222024f, 0.09741801f, 0.00754493f, 0.05115105f, -0.00276517f, 0.02843124f, 0.05135722f, 0.03204008f, 
    -0.00166348f, -0.02052468f, 0.03878602f, -0.01054003f, 0.22589083f, 0.11056253f, -0.12129347f, 0.11467469f, 
    -0.00831514f, 0.02338117f, 0.11032007f, 0.03587905f, 0.00015980f, -0.01101589f, -0.05780700f, -0.10732586f, 
    0.00540029f, -0.07543310f, 0.03632120f, 0.03146728f, 0.04557217f, 0.12570950f, 0.02559168f, -0.02546988f, 
    -0.13062502f, -0.05365923f, 0.03970250f, -0.00502294f, -0.08600898f, -0.04727139f, 0.04699392f, -0.07486857f, 
    0.04545367f, 0.01223356f, 0.01179785f, 0.02742800f, -0.02380929f, -0.00137746f, -0.04048328f, 0.04306412f, 
    0.04547442f, 0.09576033f, 0.07253399f, 0.05506534f, 0.01667836f, -0.09866836f, 0.09058044f, -0.05164835f, 
    0.00050670f, -0.02745774f, -0.06487855f, 0.00706299f, 0.35857648f, -0.07590836f, 0.22002035f, 0.13125280f, 
    0.06673848f, -0.01759418f, 0.05829465f, 0.10306931f, 0.04459450f, 0.03176875f, -0.03443000f, 0.03971743f, 
    0.00248505f, -0.02807654f, 0.04892449f, -0.06128450f, -0.01159032f, -0.09266423f, -0.01000538f, -0.05663090f, 
    -0.01565635f, -0.04742211f, -0.07415236f, 0.04578660f, 0.12571323f, 0.13886011f, -0.15196155f, -0.15573019f, 
    -0.04724944f, 0.04456470f, 0.03528203f, 0.00540145f, 0.04637673f, 0.06388687f, 0.06649489f, 0.08969143f, 
    -0.03938979f, -0.05944173f, -0.01002500f, -0.06674024f, 0.02543894f, -0.01349136f, 0.07069956f, -0.04881849f, 
    -0.08661818f, -0.14798579f, 0.04179205f, -0.00237342f, -0.07653768f, 0.26707271f, -0.05815801f, 0.14302880f, 
    0.07703991f, -0.02501605f, -0.06068069f, 0.05809734f, 0.02310180f, -0.02476903f, 0.00512433f, -0.02639210f, 
    0.07416705f, 0.11399004f, 0.04175037f, 0.12817757f, -0.05631723f, 0.09130332f, 0.03309423f, 0.03305569f, 
    0.04455213f, 0.16268994f, -0.06142898f, 0.07189082f, 0.20735466f, 0.05671787f, 0.06679212f, 0.12890583f, 
    -0.00953991f, -0.09383144f, 0.05508724f, -0.02379299f, 0.04744442f, -0.02505878f, 0.08453717f, -0.05506466f, 
    -0.09555200f, 0.08660108f, -0.01113999f, -0.10942967f, 0.12822290f, 0.02090871f, 0.07802097f, -0.00908269f, 
    -0.00198099f, 0.05735175f, 0.00252001f, 0.02005993f, 0.02218509f, 0.19587718f, -0.03046914f, 0.06279594f, 
    0.02656069f, 0.05122846f, 0.06649713f, 0.01061778f, -0.04732356f, 0.08433694f, -0.05341665f, -0.08361360f, 
    -0.13409024f, 0.08566239f, 0.12199695f, 0.00259900f, 0.02828459f, 0.11151688f, 0.01737007f, -0.04037694f, 
    0.05134151f, 0.02129453f, 0.03780883f, 0.03712170f, -0.13551857f, 0.00890604f, -0.06152797f, 0.01239507f, 
    -0.02738509f, 0.06372181f, -0.06969997f, -0.03371484f, 0.05957971f, 0.07180659f, 0.04065042f, 0.00680003f, 
    0.40723076f, -0.21317126f, 0.21698561f, 0.07050801f, 0.05973480f, 0.03758815f, 0.09329688f, -0.00546900f, 
    0.07408928f, -0.03409882f, -0.05422935f, 0.07372255f, 0.11289270f, 0.03435404f, 0.08847807f, 0.07396423f, 
    0.03650027f, -0.02798737f, -0.01123295f, -0.06856497f, 0.06379911f, 0.02054600f, 0.01497525f, -0.08315852f, 
    0.22126003f, 0.21830048f, -0.07448462f, 0.07142832f, -0.03621940f, 0.02886049f, 0.01740443f, 0.14823167f, 
    0.01375218f, 0.07617304f, 0.02868778f, -0.01670563f, 0.19232872f, 0.04214910f, -0.00427433f, -0.03502259f, 
    0.00949146f, 0.04151936f, 0.14461519f, 0.06519585f, 0.02187049f, -0.00539729f, -0.10649030f, -0.00370611f, 
    -0.08710246f, 0.10920002f, -0.05721914f, 0.05191923f, 0.10249560f, 0.05191687f, 0.10358224f, 0.01675706f, 
    0.14733990f, 0.03697499f, -0.03281607f, 0.03342796f, -0.09980657f, -0.08284045f, 0.02526574f, -0.02308814f, 
    0.05313421f, -0.05062551f, -0.00040434f, 0.05576782f, 0.01966824f, 0.03300758f, -0.00773535f, -0.06417144f, 
    -0.13926582f, -0.13139056f, 0.00952372f, 0.16573964f, 0.06286186f, -0.03855010f, -0.06215104f, -0.07200831f, 
    -0.03040917f, 0.02593400f, 0.15637228f, 0.13702691f, -0.20545729f, -0.09141941f, 0.17781436f, -0.11349685f, 
    0.03517051f, 0.04688274f, 0.09333093f, 0.10686351f, 0.06621944f, 0.06640076f, -0.08170915f, -0.04684798f, 
    0.25912490f, 0.08281318f, 0.26730692f, 0.07328244f, 0.03200103f, 0.11621595f, -0.05753752f, 0.09315719f, 
    -0.03784299f, -0.04384579f, 0.04522897f, 0.00699359f, 0.17827235f, -0.00079173f, 0.16108148f, -0.08716954f, 
    -0.02680576f, -0.05489518f, -0.02232033f, 0.00333890f, 0.04131502f, 0.10734331f, 0.00462873f, 0.05339666f, 
    0.06436212f, -0.19414283f, 0.07090879f, 0.07716832f, -0.02931382f, 0.02302100f, 0.20864004f, 0.07117375f, 
    0.00357514f, -0.08374070f, -0.06544885f, -0.08769102f, -0.28130895f, -0.01447369f, -0.13772032f, -0.15474740f, 
    0.13284183f, -0.14017850f, 0.05302050f, -0.15795521f, -0.02295117f, -0.00283475f, 0.02715567f, 0.05314733f, 
    -0.16890097f, 0.06317610f, 0.09213501f, -0.08303603f, -0.02837189f, -0.03828948f, 0.00353243f, 0.01399592f, 
    0.02416153f, 0.16248323f, -0.00114712f, 0.06581770f, 0.08645231f, 0.08405054f, 0.08986116f, 0.07305910f, 
    0.05682968f, -0.10789323f, 0.05770381f, 0.06672850f, -0.01543045f, -0.08261655f, 0.00275456f, 0.06452742f, 
    -0.09410431f, -0.08259393f, 0.15818959f, -0.08036925f, 0.03606549f, 0.02960786f, -0.00566176f, -0.17303565f, 
    -0.01612712f, -0.04494527f, 0.02675094f, 0.05727534f, -0.09762774f, -0.00733961f, -0.02525498f, 0.12320369f, 
    0.07265645f, 0.06305163f, 0.05554963f, 0.00532872f, 0.05459271f, 0.03464103f, 0.00517500f, -0.03198187f, 
    0.08254021f, 0.07673009f, 0.09258339f, -0.11515286f, -0.02237199f, -0.08190799f, -0.01122813f, 0.11301364f, 
    0.00997454f, -0.05168752f, -0.06267118f, -0.06515736f, 0.01376646f, 0.03365871f, 0.08146710f, 0.05598432f, 
    -0.02907930f, 0.02558757f, 0.08801816f, 0.04852926f, 0.01651637f, -0.02133856f, -0.19583134f, 0.11993355f, 
    0.05338676f, 0.11663327f, -0.06108465f, -0.12490714f, 0.01204181f, -0.02599382f, -0.05612175f, -0.06372140f, 
    0.09187957f, -0.07769363f, -0.00375888f, 0.11178047f, 0.06724634f, -0.20347261f, -0.06888486f, -0.14429562f, 
    -0.00495811f, -0.10036490f, 0.02926823f, -0.05854196f, 0.09286854f, 0.02755804f, -0.01466379f, 0.07289581f, 
    -0.06116069f, -0.16622265f, 0.18786296f, 0.05404251f, 0.06837603f, 0.04987781f, 0.07131363f, -0.12346368f, 
    0.10356928f, 0.04834696f, 0.00844580f, 0.03511275f, -0.03633938f, -0.12665193f, -0.13206038f, -0.11635794f, 
    0.00983459f, -0.02231064f, 0.02797689f, -0.02484600f, 0.14106286f, 0.06599093f, 0.06411828f, 0.01958561f, 
    0.04429790f, -0.17948548f, -0.08737086f, 0.06119954f, 0.04887704f, 0.06278896f, 0.08285825f, 0.06287457f, 
    0.09021010f, -0.08763137f, -0.03067446f, 0.03581325f, -0.06708739f, -0.11694627f, 0.06331465f, 0.00586606f, 
    0.01843920f, -0.12596671f, 0.04694993f, -0.13292469f, 0.10908222f, 0.03194002f, 0.00809425f, 0.04081844f, 
    0.07553750f, -0.01167787f, 0.17373967f, 0.15276986f, 0.09605268f, 0.04421864f, 0.05949720f, 0.04434491f, 
    -0.05265547f, 0.02969365f, -0.05025540f, 0.05447663f, 0.22645843f, -0.12498207f, 0.01308191f, -0.08577036f, 
    0.12656052f, -0.19355175f, -0.01003598f, 0.01510067f, 0.05131968f, 0.04976505f, 0.08318491f, -0.04735996f, 
    -0.06503603f, 0.03634513f, 0.14377585f, 0.05340501f, 0.04419733f, 0.02642118f, -0.06215455f, 0.06237749f, 
    0.02666715f, 0.07322362f, 0.06157619f, 0.03667761f, -0.05918139f, 0.05958910f, 0.07069245f, 0.09864658f, 
    0.00152516f, -0.00704549f, 0.08685348f, 0.05235416f, 0.11690105f, 0.06501594f, 0.01078007f, 0.13149330f, 
    0.19486843f, -0.17806011f, 0.04589998f, 0.07701577f, 0.05044674f, -0.03141252f, 0.02864735f, -0.05211471f, 
    0.05928605f, 0.12134172f, 0.04403099f, 0.08858128f, 0.01884537f, -0.17154227f, 0.02913550f, 0.05165661f, 
    0.03923130f, 0.05702863f, 0.06154459f, 0.16022971f, -0.06380143f, -0.02403972f, 0.11805671f, 0.08192164f, 
    -0.32802072f, 0.14251234f, 0.08412890f, 0.02908538f, 0.08169104f, 0.05615878f, -0.01211331f, 0.09179291f, 
    0.01599452f, 0.00919214f, 0.10904927f, -0.03402329f, -0.05758345f, -0.24948803f, -0.04582598f, 0.02732495f, 
    -0.01126934f, 0.09932282f, 0.02482138f, 0.09297094f, 0.03734837f, 0.00866867f, 0.02509729f, -0.03516370f, 
    -0.03846280f, 0.00485991f, 0.08847202f, 0.00243571f, 0.09593107f, -0.07072035f, -0.04710709f, -0.00067059f, 
    0.05087792f, 0.06594986f, 0.09399816f, 0.01269727f, -0.13741040f, 0.08022372f, 0.07601609f, 0.03097241f, 
    -0.03267262f, 0.08989816f, -0.06311437f, 0.03200597f, 0.02752757f, 0.01394419f, -0.07916159f, 0.02702495f, 
    -0.33609927f, 0.10207246f, 0.17447470f, -0.10097135f, -0.00610822f, 0.12090824f, 0.02987418f, 0.07363350f, 
    0.01577016f, 0.01262873f, 0.05095788f, 0.06097766f, 0.22132412f, 0.09717003f, 0.07363470f, -0.09267653f, 
    0.02880760f, 0.03157924f, -0.08945299f, 0.05861852f, -0.09298880f, 0.06065746f, -0.04835986f, 0.01599937f, 
    0.09388430f, -0.08816659f, -0.11023917f, 0.03410164f, 0.03416165f, -0.00778139f, -0.00484152f, 0.01044246f, 
    0.03499187f, 0.10515114f, 0.05856057f, 0.10495935f, -0.10102562f, 0.08055629f, -0.03415856f, 0.00584161f, 
    0.00500687f, 0.02404401f, 0.03386284f, 0.07538525f, 0.19314562f, 0.07803503f, 0.04758736f, 0.06868676f, 
    -0.14835605f, 0.04841576f, -0.13812795f, -0.10849490f, -0.05474340f, -0.05600489f, 0.07048701f, -0.00104546f, 
    0.07736789f, 0.01627779f, 0.11090650f, -0.03213304f, 0.16206588f, 0.06053667f, 0.18886937f, 0.07983790f, 
    0.02663077f, 0.02682855f, 0.01970488f, 0.10110927f, 0.08853600f, 0.00859260f, -0.06796843f, 0.18752266f, 
    0.15853189f, -0.05116390f, 0.00743139f, 0.05169578f, 0.06249674f, -0.05194483f, -0.07126194f, -0.09456842f, 
    0.04612953f, 0.00910128f, -0.01364082f, -0.00932364f, -0.14348827f, -0.16160241f, -0.15628093f, -0.08222108f, 
    -0.02795082f, -0.01046091f, -0.02923414f, 0.08203550f, -0.04650920f, 0.00567365f, -0.03663958f, 0.04024407f, 
    -0.07467525f, -0.01612034f, 0.15903695f, -0.05691696f, 0.02951719f, -0.00932191f, 0.02851404f, 0.01695165f, 
    0.01100711f, -0.10862157f, -0.02636034f, 0.06551004f, 0.06255066f, -0.07575861f, 0.03741499f, 0.09907928f, 
    -0.05649812f, -0.08933339f, 0.10453597f, 0.00806344f, 0.04159182f, -0.00962745f, 0.03787009f, -0.02285168f, 
    0.09916965f, 0.01110215f, -0.03486468f, 0.03542466f, -0.02255217f, 0.08901740f, -0.06177047f, -0.02342831f, 
    0.00043779f, 0.06717843f, 0.03518855f, 0.04461506f, -0.04181267f, 0.23114525f, 0.01100601f, 0.01308871f, 
    0.07643828f, -0.00796298f, 0.05605062f, 0.02881822f, 0.11183248f, 0.08495028f, 0.05895369f, 0.00987226f, 
    0.00271830f, -0.13982341f, -0.08130172f, -0.10456087f, -0.01201662f, -0.03385406f, 0.04242067f, 0.00338584f, 
    0.00199130f, 0.07526670f, 0.04741030f, 0.11448723f, 0.09887131f, 0.24280143f, -0.08327137f, -0.01633138f, 
    0.05683559f, -0.08572134f, 0.10343261f, 0.14345522f, 0.09576039f, 0.05202244f, 0.02552178f, 0.13871554f, 
    0.19410239f, -0.11955004f, 0.23733871f, -0.00047147f, 0.07095735f, -0.04540751f, 0.06320097f, -0.05414499f, 
    -0.01913082f, 0.03756237f, -0.00811997f, -0.00274437f, -0.08506650f, -0.12819739f, 0.13604890f, -0.01669693f, 
    0.14767431f, 0.10434228f, 0.01862809f, -0.05127713f, -0.01394455f, 0.01426206f, -0.02284856f, 0.04029116f, 
    0.05948350f, -0.05215082f, -0.09762987f, -0.00439154f, 0.00502590f, -0.00946153f, 0.00316125f, -0.02302523f, 
    0.04380910f, 0.15617357f, 0.03644309f, 0.08127394f, -0.07639892f, -0.06595764f, -0.13347161f, -0.03321411f, 
    -0.03092429f, 0.05137986f, -0.03081223f, 0.02963936f, 0.05010198f, 0.04341419f, 0.03277511f, -0.03904588f, 
    -0.11554432f, -0.06081418f, -0.04297334f, -0.08552872f, -0.06669261f, 0.11399103f, -0.03843240f, -0.02376732f, 
    0.00816278f, -0.03408435f, 0.06157631f, 0.10441352f, -0.35253695f, 0.06165391f, -0.02689110f, -0.04108236f, 
    -0.00044052f, -0.07813711f, -0.04113837f, 0.00569631f, 0.08954801f, 0.07083346f, -0.10269342f, 0.07864006f, 
    -0.22196239f, -0.03403720f, -0.07764360f, -0.03329442f, 0.02763674f, 0.03905288f, 0.01952863f, 0.01911456f, 
    0.08239855f, 0.13564029f, 0.06611083f, -0.00204523f, -0.21470508f, 0.01939644f, -0.02600786f, -0.02772648f, 
    0.04750566f, -0.08339491f, 0.07208493f, -0.16393489f, 0.18406233f, -0.06783124f, -0.02224238f, 0.04907913f, 
    -0.07959836f, -0.14093414f, -0.00293863f, 0.04106084f, -0.01303162f, 0.06719279f, 0.00629075f, 0.02074285f, 
    0.07980199f, -0.06968135f, -0.08584439f, 0.10131402f, -0.12193742f, -0.14686657f, 0.20740746f, -0.05617885f, 
    -0.07310457f, 0.04941581f, 0.05804051f, -0.00217183f, -0.04266447f, -0.03008586f, 0.03589591f, -0.00246466f, 
    -0.18602225f, -0.18908781f, -0.01129603f, 0.05392448f, 0.10097428f, -0.07976738f, -0.04214963f, -0.03459113f, 
    -0.07806219f, -0.16992210f, -0.03511120f, -0.02576386f, -0.39960399f, -0.05104544f, 0.09883547f, -0.02578459f, 
    0.02070028f, 0.12228934f, -0.02440246f, -0.03686398f, 0.07320657f, -0.00658804f, -0.01618154f, 0.16682862f, 
    -0.08424322f, -0.10634536f, -0.01629201f, 0.02003381f, -0.00839488f, 0.06637609f, 0.08265078f, 0.08887593f, 
    0.03344550f, -0.02571982f, -0.03227851f, -0.04711783f, -0.13920444f, -0.20120296f, -0.00504069f, -0.03325181f, 
    0.04740334f, 0.01772264f, -0.06877662f, 0.00654075f, -0.04974632f, 0.03308641f, 0.09492178f, 0.03651027f, 
    -0.25269061f, 0.01862350f, -0.12163803f, 0.04447315f, 0.09048424f, -0.01762808f, 0.02523938f, 0.10536233f, 
    0.10024586f, -0.01025874f, -0.07321632f, -0.04892689f, -0.05467725f, 0.07157185f, -0.09197599f, 0.11524227f, 
    0.00045707f, 0.02451747f, 0.02630845f, 0.15694366f, 0.04919188f, -0.10249214f, 0.07486054f, -0.11009316f, 
    -0.42711076f, 0.10217035f, -0.05122837f, -0.00833410f, -0.03688054f, -0.07010470f, -0.02993055f, -0.03601172f, 
    0.04270834f, -0.00136255f, 0.06328378f, 0.03923034f, -0.22100043f, 0.06139688f, -0.09758365f, -0.08519661f, 
    0.09262113f, -0.00645017f, -0.08051331f, 0.03519636f, 0.03986349f, -0.01935503f, -0.02383856f, 0.03727162f, 
    -0.19387831f, -0.09762638f, 0.04507122f, 0.03574048f, -0.00790865f, 0.00953134f, -0.19742596f, -0.00191124f, 
    0.03507765f, -0.10612484f, 0.09256881f, 0.01063370f, -0.14357412f, 0.15346715f, 0.16390055f, 0.05572253f, 
    -0.02309689f, 0.02184163f, -0.07603801f, 0.09714825f, 0.03095867f, 0.00410925f, 0.16656272f, 0.02333359f, 
    -0.03394198f, -0.00556881f, 0.03553467f, -0.02221731f, -0.02146838f, 0.00975589f, -0.03825859f, -0.02236240f, 
    -0.00830691f, -0.01476718f, -0.03651334f, -0.02903693f, -0.01833065f, 0.02634973f, 0.02013174f, 0.03643942f, 
    -0.00227445f, -0.01335580f, -0.02915495f, 0.01990032f, -0.00669508f, 0.01329044f, 0.02446206f, 0.00993981f, 
    0.00240623f, -0.02143132f, 0.02492396f, -0.02329796f, -0.04315355f, -0.02844733f, -0.02403839f, -0.01931951f, 
    0.00579369f, -0.01780129f, 0.02874159f, 0.00894875f, 0.03939031f, 0.00256436f, -0.00421116f, -0.05781503f, 
    0.01158190f, -0.01491797f, -0.01428549f, -0.01582976f, 0.01349859f, -0.01656533f, -0.03563333f, 0.02490715f, 
    -0.00897648f, -0.02357085f, -0.01270485f, -0.00409925f, 0.03679271f, 0.00146797f, 0.01339834f, -0.01051644f, 
    0.02043889f, 0.00996542f, -0.01591440f, -0.04145316f, -0.03920669f, 0.02680871f, -0.00627695f, 0.02179183f, 
    -0.01957768f, -0.01392254f, -0.00503368f, 0.00227944f, -0.03921958f, 0.01683245f, -0.01557834f, -0.00797630f, 
    -0.00846566f, -0.02292464f, 0.00540843f, 0.01678029f, -0.02767721f, 0.01476599f, -0.00172623f, -0.00433842f, 
    -0.00659107f, -0.02466102f, -0.03757706f, -0.01245568f, 0.03678574f, 0.01903420f, 0.01317866f, 0.01546388f, 
    0.02174238f, 0.00755767f, 0.02193496f, -0.00466049f, -0.00986773f, -0.02913657f, 0.00438399f, 0.00067686f, 
    -0.03315150f, -0.02727622f, -0.01025103f, 0.01364832f, 0.00603491f, -0.00655848f, 0.02282057f, -0.03656248f, 
    0.01931845f, -0.03382988f, 0.02525326f, 0.02264524f, -0.05153118f, -0.03278056f, 0.00588828f, 0.00543427f, 
    0.02521231f, 0.02960073f, -0.02464889f, -0.00757320f, 0.01869881f, -0.03029109f, -0.01958980f, -0.03866153f, 
    0.02571159f, -0.00188457f, -0.03009337f, -0.00131816f, 0.00249175f, -0.03008219f, 0.02928192f, 0.00363137f, 
    0.00936677f, 0.00913063f, 0.02532677f, 0.01597857f, -0.00014690f, 0.02701279f, -0.00657179f, -0.01953670f, 
    -0.03756277f, 0.01710043f, -0.02294376f, 0.02668128f, 0.02163225f, -0.03044803f, -0.03186326f, -0.01784991f, 
    0.00259575f, -0.02915317f, 0.00840320f, -0.00622601f, -0.02309124f, -0.03102230f, -0.00530377f, 0.02789049f, 
    -0.00278007f, 0.02937754f, -0.01218307f, 0.01477897f, -0.02933699f, -0.01603184f, 0.01222346f, 0.03999781f, 
    0.00740641f, -0.00839033f, 0.01036084f, 0.00882559f, 0.01933116f, 0.02384954f, 0.00574880f, -0.03613406f, 
    -0.00063559f, -0.02458012f, -0.00514006f, -0.03002751f, 0.01949202f, 0.01213738f, 0.03094523f, 0.01961909f, 
    -0.03709544f, -0.02368840f, 0.01223234f, -0.02885705f, -0.03106991f, -0.00972375f, 0.02311138f, -0.02904711f, 
    0.00586597f, 0.02543722f, -0.03138812f, -0.03871540f, 0.00895247f, 0.00387513f, -0.02391474f, 0.02610051f, 
    0.01762306f, -0.03165525f, -0.00811677f, 0.03712497f, 0.02900073f, -0.01023276f, -0.01377408f, 0.00415635f, 
    -0.02504637f, 0.00441249f, 0.02810659f, -0.03053988f, -0.01924402f, 0.02523782f, 0.03013144f, 0.01774438f, 
    -0.02285174f, -0.00733022f, -0.00374516f, -0.01088172f, -0.02762239f, 0.02577093f, -0.01692229f, -0.02724004f, 
    -0.02856014f, -0.00381769f, 0.00074911f, 0.01462234f, 0.01341179f, 0.00246129f, 0.00987388f, 0.00274919f, 
    0.01402066f, -0.03228968f, 0.00502698f, -0.03492310f, 0.00239494f, -0.00522486f, -0.02218433f, 0.03853020f, 
    0.00047436f, 0.01698686f, -0.03935146f, -0.03060216f, -0.02605972f, -0.03206276f, -0.01127506f, -0.03053183f, 
    -0.01356347f, -0.01656850f, 0.02585410f, -0.02430891f, 0.01202457f, -0.02988129f, 0.00735364f, 0.02861429f, 
    -0.00628188f, -0.01735151f, 0.01360353f, 0.02756739f, 0.01111482f, -0.03443863f, 0.03224289f, 0.01463385f, 
    -0.02868934f, 0.03341563f, 0.02321670f, 0.01490272f, 0.02768999f, -0.01284587f, -0.01247113f, -0.02835475f, 
    -0.03801590f, -0.00653251f, 0.00822820f, 0.01438040f, 0.00889429f, -0.00392383f, 0.00261627f, -0.03330550f, 
    -0.03615330f, -0.02186115f, 0.00283172f, 0.01949234f, -0.00999642f, 0.02305996f, 0.02539708f, 0.02035794f, 
    0.01939098f, 0.00158171f, 0.02454335f, -0.04063994f, 0.00342960f, 0.00695870f, 0.02553228f, -0.00011247f, 
    -0.03541148f, 0.03037180f, 0.00549270f, -0.02755543f, -0.03130024f, -0.03070347f, 0.02325727f, -0.00908462f, 
    -0.00568919f, 0.02090318f, -0.01385785f, 0.03118640f, -0.02989854f, -0.02134121f, 0.00328810f, -0.02237867f, 
    -0.00606548f, -0.00170259f, -0.01576663f, 0.02283648f, -0.01643252f, -0.00438289f, 0.02757169f, -0.00710484f, 
    0.01631831f, 0.00744184f, 0.00391804f, -0.00132852f, 0.01206767f, -0.00709072f, 0.00366207f, -0.02377226f, 
    0.02775165f, 0.02728720f, 0.02143229f, -0.03987926f, -0.00991959f, -0.00605163f, -0.01150975f, 0.02847963f, 
    -0.02738942f, -0.03467052f, -0.02399760f, -0.03307039f, 0.02531506f, -0.01336980f, -0.01335086f, 0.01908950f, 
    0.00329279f, -0.00723432f, -0.01779132f, -0.00211926f, -0.02255678f, -0.01412271f, 0.02492855f, 0.00012826f, 
    -0.01503495f, -0.03960114f, -0.02993005f, -0.03615938f, -0.01235041f, 0.02181251f, -0.00513813f, -0.03448017f, 
    0.00624400f, 0.02971911f, 0.01530389f, 0.01934622f, 0.02598332f, -0.02316227f, -0.01129081f, -0.01540756f, 
    -0.00577525f, 0.01112371f, -0.03874376f, -0.03068445f, -0.02474155f, -0.02095427f, 0.02371620f, 0.00728460f, 
    0.01977248f, 0.01464937f, -0.03820851f, -0.03947252f, -0.02581858f, -0.00870825f, 0.01974289f, 0.00028486f, 
    0.00221766f, -0.01675192f, 0.01760611f, -0.03065570f, -0.02929395f, 0.01925380f, 0.02777966f, -0.01188945f, 
    -0.01770629f, 0.00298041f, -0.01342990f, -0.00584098f, -0.02938161f, 0.01618500f, -0.02103097f, -0.00784649f, 
    -0.00432938f, 0.01293767f, 0.00061634f, -0.03317892f, 0.02332213f, -0.02818752f, -0.00387388f, -0.02774254f, 
    0.02926936f, 0.02553505f, -0.02397184f, 0.00759876f, -0.03090976f, 0.03311926f, -0.00841375f, 0.02339601f, 
    -0.00108528f, -0.02890810f, -0.01164772f, -0.02752143f, 0.01846373f, 0.01538180f, 0.00303471f, -0.00702030f, 
    0.00353194f, 0.01978122f, 0.02480150f, -0.00369504f, -0.00390167f, -0.02609591f, -0.02248824f, -0.00908272f, 
    -0.01814445f, -0.00385817f, 0.02478419f, -0.01695476f, -0.03852758f, -0.01664330f, 0.01147106f, -0.03474476f, 
    -0.02182495f, -0.02964761f, 0.00852073f, -0.02014416f, 0.01440558f, 0.03417619f, 0.00819648f, 0.01023423f, 
    0.02538751f, -0.01748478f, -0.01882638f, -0.01923849f, -0.02402616f, -0.00996124f, 0.00827033f, 0.03365576f, 
    -0.00730774f, 0.00839491f, 0.01689429f, -0.02001013f, 0.01846853f, 0.00003156f, -0.03078097f, 0.00500901f, 
    -0.01313225f, 0.02023595f, 0.01684360f, -0.02218723f, 0.03078728f, -0.00281894f, -0.00331782f, 0.03022353f, 
    0.00393353f, 0.02495756f, -0.03897676f, 0.01014007f, 0.02569108f, 0.02553206f, 0.01844934f, 0.03436091f, 
    -0.02556147f, -0.02810274f, -0.02521368f, 0.02241793f, 0.00218171f, 0.00129607f, -0.02218612f, 0.00995214f, 
    0.03630038f, -0.01739702f, 0.00009228f, -0.00345950f, -0.04209588f, 0.02541522f, -0.03227637f, 0.00719650f, 
    -0.01505667f, 0.02473577f, -0.00175387f, -0.02943892f, -0.00968672f, -0.04511221f, -0.00765426f, 0.02315442f, 
    -0.01263501f, -0.04119354f, 0.01312571f, -0.00068951f, 0.00526734f, -0.01803936f, -0.00130490f, 0.02359266f, 
    0.02920781f, -0.01827421f, 0.01996421f, -0.00879207f, -0.01651780f, -0.02641051f, -0.02508944f, 0.01060499f, 
    0.01641127f, 0.01237075f, -0.04098752f, 0.01878968f, 0.01696382f, -0.00582292f, 0.02715790f, 0.00511114f, 
    0.00549198f, -0.00859114f, 0.01055839f, -0.01624447f, -0.03275681f, -0.00567842f, 0.01705695f, -0.00448047f, 
    -0.00662279f, -0.03941650f, 0.02011776f, -0.01131915f, -0.00204577f, -0.02796639f, -0.04589761f, 0.01443545f, 
    0.01961405f, -0.02726961f, -0.03201414f, -0.01730284f, -0.02453746f, -0.00325129f, 0.01568606f, -0.03275027f, 
    0.03945200f, -0.02543168f, -0.02382652f, -0.01885114f, -0.04246856f, 0.01473771f, -0.03389407f, -0.00468950f, 
    0.00926834f, 0.01178822f, -0.01159398f, 0.01257392f, 0.00473276f, -0.02052974f, 0.02870006f, -0.01270559f, 
    -0.01732278f, -0.02990533f, -0.03757232f, 0.01351013f, -0.00962034f, -0.02853346f, -0.00322790f, 0.02070875f, 
    -0.00599965f, 0.00814450f, -0.03407183f, -0.02284555f, -0.02123474f, -0.02197458f, -0.00663034f, -0.04026835f, 
    -0.01431996f, 0.02903447f, 0.01227694f, -0.00144852f, 0.00276293f, -0.01695554f, -0.02054605f, -0.02904505f, 
    0.00602856f, -0.00741540f, 0.02044572f, -0.03227634f, 0.01678137f, 0.03533687f, -0.02179018f, 0.01204529f, 
    0.00287497f, 0.00785360f, 0.00840167f, 0.01245731f, 0.01394310f, 0.00694416f, -0.01897169f, -0.01585779f, 
    0.01111590f, -0.02341775f, 0.00364929f, 0.00125452f, -0.01895589f, 0.03151328f, 0.00784125f, 0.02775986f, 
    0.00555233f, -0.01050166f, 0.00217149f, -0.03224399f, -0.01268025f, -0.00478947f, 0.00445070f, 0.02076527f, 
    -0.02541393f, -0.03259331f, 0.01713684f, 0.02055931f, -0.00856605f, 0.01749982f, -0.00899330f, -0.02725944f, 
    0.03942142f, 0.01421057f, -0.02080054f, 0.03280322f, -0.03186017f, -0.00728640f, -0.00275819f, 0.00997595f, 
    -0.03722236f, 0.01101084f, 0.02432264f, -0.03673291f, 0.02229842f, -0.00277190f, 0.01728371f, -0.04299348f, 
    0.00387682f, -0.02280943f, -0.02650327f, 0.03130382f, 0.00297368f, -0.00988821f, -0.03010106f, 0.02524723f, 
    0.03926622f, -0.02039230f, -0.00135397f, -0.01021318f, -0.01313390f, -0.04091509f, -0.02624941f, 0.00958159f, 
    -0.02869715f, 0.01899045f, 0.02565683f, 0.00812438f, 0.03148068f, -0.01005114f, -0.03134164f, 0.02446905f, 
    -0.01065353f, 0.00629395f, 0.01778956f, -0.02346573f, 0.00232484f, 0.02578634f, -0.04658867f, -0.02369528f, 
    -0.03141165f, 0.02170374f, -0.01880164f, -0.04521192f, -0.00557024f, 0.01492671f, -0.01973933f, 0.00818792f, 
    0.02175644f, 0.00956756f, 0.02331718f, 0.01254694f, 0.01064687f, -0.03190205f, -0.02674191f, 0.02157256f, 
    0.01859825f, -0.04017438f, -0.00835107f, -0.02062933f, 0.01195909f, 0.02100204f, -0.03557244f, -0.02627430f, 
    -0.00654010f, 0.02533267f, 0.01293590f, -0.03996222f, 0.00056342f, -0.00057859f, -0.01030358f, 0.01350121f, 
    -0.00200398f, -0.00669804f, -0.01964590f, -0.00279658f, 0.02523607f, -0.00449550f, 0.00812935f, -0.04069530f, 
    -0.02571997f, 0.01409425f, -0.00997144f, 0.00899155f, 0.03281699f, 0.01795451f, -0.00803819f, 0.00604845f, 
    0.00378151f, 0.00360470f, -0.01427624f, 0.00734868f, -0.01647714f, 0.00573402f, 0.03227129f, -0.02342877f, 
    0.02301244f, 0.02455653f, -0.01133583f, 0.02628834f, -0.01647935f, 0.02173555f, 0.00284210f, 0.04677995f, 
    0.00354643f, -0.02031573f, 0.01276153f, -0.03915535f, -0.04367900f, 0.02714525f, 0.00922688f, 0.01339839f, 
    0.02093850f, -0.00149096f, 0.01115783f, -0.03208205f, 0.01548213f, 0.02426806f, -0.01099651f, -0.03433659f, 
    -0.02327728f, -0.03519239f, 0.03115257f, 0.01561993f, -0.01356350f, -0.02611170f, -0.04788137f, 0.02492915f, 
    -0.03087099f, 0.01744960f, -0.02190325f, -0.02593564f, -0.03565026f, 0.02188010f, 0.00236004f, -0.04222604f, 
    -0.00057607f, 0.00682884f, 0.00889255f, 0.00501856f, 0.02485659f, -0.00272493f, 0.01568945f, -0.01112353f, 
    -0.03999805f, -0.03963269f, -0.00100684f, 0.01504522f, -0.02602734f, -0.01766120f, -0.00758241f, 0.00317775f, 
    -0.02175967f, -0.02315905f, 0.01549271f, -0.01611025f, -0.02661759f, -0.02775360f, 0.00142641f, -0.03674284f, 
    0.00036021f, -0.02351040f, -0.02661561f, -0.00287135f, -0.04228688f, 0.00636757f, -0.01165487f, -0.04294678f, 
    -0.01456808f, -0.01681464f, 0.02176182f, -0.03388394f, -0.03868603f, -0.02965965f, 0.00663636f, 0.01938208f, 
    0.02707077f, 0.01644319f, 0.00815315f, 0.00932605f, -0.02572147f, -0.01363631f, -0.01155633f, -0.02973982f, 
    0.01543394f, -0.02037109f, 0.02189871f, -0.03683720f, 0.01914127f, -0.02208970f, -0.03617282f, -0.02897083f, 
    -0.00585270f, -0.02386077f, 0.02871850f, -0.03095616f, 0.01972446f, -0.02978985f, 0.00097993f, -0.02140180f, 
    -0.00524162f, 0.00219827f, -0.01417845f, 0.02182714f, -0.01553713f, -0.02199198f, 0.01936879f, 0.02610373f, 
    -0.02553869f, -0.02202635f, 0.00466366f, -0.02907795f, -0.01894805f, 0.01565507f, 0.03099725f, 0.00524112f, 
    -0.00590931f, -0.03578028f, 0.01529755f, -0.02978402f, 0.01774488f, -0.00968759f, -0.01156775f, -0.03400648f, 
    -0.01866113f, 0.00117696f, -0.03352269f, -0.01122989f, -0.02421858f, -0.01053310f, -0.03111241f, -0.03651912f, 
    0.00269492f, -0.01311409f, -0.01443311f, 0.00650320f, -0.01289696f, -0.02547286f, -0.03941956f, -0.03771995f, 
    0.01012122f, 0.02599057f, 0.02080150f, -0.02375599f, -0.02596460f, -0.01892646f, -0.00832477f, -0.00152277f, 
    0.00441182f, 0.00975524f, -0.01763207f, 0.02285547f, -0.03775408f, -0.00973128f, -0.01800129f, 0.00508937f, 
    0.02739717f, 0.00634641f, -0.03977459f, -0.03955723f, 0.01969975f, -0.00032076f, -0.00531934f, 0.02474155f, 
    -0.03784005f, -0.03596942f, -0.02194541f, -0.03758828f, -0.01321283f, -0.03723652f, -0.03226985f, -0.00849750f, 
    -0.01461240f, -0.03125734f, 0.00169325f, -0.00840645f, -0.02023812f, -0.04374976f, -0.00016277f, -0.01805630f, 
    -0.03944411f, 0.02015078f, 0.01693920f, -0.03885133f, -0.01603374f, -0.02470765f, 0.01313200f, -0.03333139f, 
    -0.03186180f, 0.01614644f, -0.00148917f, -0.02827226f, 0.00441559f, -0.01444167f, -0.03276315f, 0.01227448f, 
    0.02118974f, -0.02980544f, 0.02947998f, -0.04064938f, 0.01101812f, 0.00888355f, -0.03580508f, -0.02115512f, 
    0.02707176f, 0.00149959f, -0.03711613f, -0.01592326f, 0.00586455f, -0.03356905f, -0.01387207f, -0.01896544f, 
    0.01306532f, 0.01131108f, 0.00621341f, 0.01886343f, 0.01435443f, 0.01653587f, -0.03311712f, -0.00208634f, 
    0.02824972f, 0.00432631f, 0.01185004f, -0.03146308f, 0.02055690f, -0.03777684f, -0.00066672f, -0.03420306f, 
    -0.03630211f, -0.00846848f, -0.02912013f, 0.02865801f, -0.01341753f, -0.00372721f, -0.01105007f, 0.01001003f, 
    -0.02518946f, -0.03990414f, -0.01669467f, 0.01757402f, 0.01524848f, 0.00476532f, 0.00616970f, 0.01958181f, 
    -0.04030829f, -0.02375222f, 0.01457311f, 0.01120842f, 0.01638726f, -0.02125498f, 0.02356233f, -0.04414350f, 
    -0.02817580f, -0.01716264f, -0.01592394f, 0.01485720f, -0.03038997f, -0.00177481f, -0.02122973f, -0.04325528f, 
    -0.02640676f, 0.00789925f, -0.00769689f, 0.00463623f, -0.02197510f, 0.02379151f, -0.02202948f, -0.04080859f, 
    0.00911812f, 0.01372353f, -0.01115370f, -0.04071151f, -0.03576474f, -0.00394165f, 0.00424952f, -0.02520222f, 
    0.01606084f, 0.00424594f, -0.03265247f, -0.01514073f, -0.01479687f, 0.01667112f, 0.00901485f, -0.03298454f, 
    -0.00454686f, -0.04208767f, -0.03966537f, 0.00238478f, -0.03822147f, -0.01660184f, 0.02012890f, 0.00550312f, 
    -0.03894547f, -0.03177800f, -0.00737827f, -0.01116070f, 0.01559932f, -0.02397021f, 0.00515067f, 0.00224473f, 
    0.01493976f, 0.00266422f, -0.01701646f, -0.00444652f, 0.00728995f, 0.02663761f, -0.03351227f, -0.03529043f, 
    -0.01807678f, 0.01113691f, 0.00661639f, 0.00158767f, 0.00621794f, -0.01532964f, 0.02711104f, 0.00066438f, 
    -0.03931170f, 0.02932987f, -0.03448755f, -0.00673232f, 0.01634176f, -0.02918538f, -0.03974568f, 0.00435211f, 
    -0.02085530f, 0.02303411f, -0.02023053f, 0.02525513f, 0.03682700f, -0.04281339f, 0.00848783f, 0.01811191f, 
    -0.00663647f, -0.01001222f, -0.00630199f, 0.00513172f, -0.01629569f, -0.00123674f, -0.03374612f, 0.03302497f, 
    -0.01933589f, 0.02740370f, 0.02529647f, -0.00810385f, -0.00858559f, 0.02342024f, 0.02424861f, -0.04377582f, 
    -0.01761776f, 0.00524338f, -0.02962403f, -0.02281099f, -0.02943367f, -0.02397594f, -0.02499842f, 0.01766156f, 
    -0.03528984f, -0.00973133f, 0.01000424f, -0.02187573f, -0.01888531f, 0.02048972f, -0.02910293f, 0.02591887f, 
    -0.02336152f, -0.00787998f, 0.02675102f, -0.00097014f, -0.02184560f, -0.02977013f, 0.01961440f, -0.04326226f, 
    -0.03585606f, 0.02338556f, 0.01574696f, -0.03502429f, -0.03215178f, 0.00309222f, -0.03694161f, 0.02086982f, 
    0.01360970f, -0.02659738f, -0.03389322f, -0.00527489f, 0.01654857f, -0.03003385f, 0.00197069f, 0.01958623f, 
    -0.00513623f, 0.00564833f, -0.02849900f, -0.01217926f, -0.01941687f, 0.00922376f, -0.00868801f, 0.02043693f, 
    0.01570974f, 0.00321484f, -0.02901274f, 0.00382832f, 0.01704319f, -0.00880413f, 0.00596225f, -0.02053389f, 
    -0.00553325f, -0.02210453f, 0.01231743f, -0.01800154f, -0.01960695f, 0.01606041f, -0.03687913f, -0.02261270f, 
    0.00344374f, 0.02027107f, 0.02775196f, -0.00332175f, 0.02027481f, 0.02556347f, -0.01305895f, 0.00597748f, 
    0.02240966f, 0.02686874f, -0.01579469f, 0.02677898f, -0.01385353f, -0.00979810f, -0.04335433f, -0.00358629f, 
    -0.02116544f, 0.00807009f, -0.02807031f, -0.00807969f, -0.00414097f, 0.01207302f, -0.03454132f, -0.02915295f, 
    -0.03083265f, -0.02380260f, -0.00991596f, -0.03037069f, 0.01162850f, 0.02533796f, 0.01749962f, -0.02347989f, 
    -0.00773348f, -0.03343305f, -0.02980215f, 0.00179787f, 0.02633666f, -0.00431718f, -0.01428941f, -0.04243980f, 
    0.02764102f, -0.04117938f, 0.01686259f, -0.02281107f, -0.03310405f, 0.02426392f, -0.02529578f, -0.02685933f, 
    0.00788855f, 0.02694654f, -0.00030678f, -0.03408342f, -0.03151782f, 0.02012124f, -0.03402656f, 0.02117504f, 
    -0.00450175f, -0.03746127f, 0.02092505f, -0.02143477f, -0.01316924f, 0.02765060f, -0.03620148f, -0.00130880f, 
    -0.00834916f, -0.02626828f, -0.01658043f, 0.00893670f, 0.00154879f, -0.01939477f, -0.00954931f, -0.03704082f, 
    0.02537791f, -0.03371921f, 0.02504818f, 0.00871450f, -0.03665816f, -0.01656923f, 0.00680047f, -0.00047872f, 
    0.03227406f, -0.01328422f, -0.00094283f, -0.01504921f, -0.00367655f, -0.01744537f, 0.01971757f, -0.02826572f, 
    -0.02488029f, -0.00487231f, 0.00452226f, 0.02549688f, 0.01426732f, -0.00123105f, -0.00385232f, -0.01269102f, 
    0.02167460f, -0.01117058f, -0.04358864f, -0.03541064f, 0.02399345f, -0.00112091f, -0.01584266f, -0.01828786f, 
    0.02222108f, -0.03658770f, 0.01634326f, 0.01500920f, 0.01567574f, 0.02494701f, 0.01089030f, -0.04051471f, 
    0.00749028f, -0.02855803f, -0.01699592f, -0.01980675f, 0.01148424f, -0.01165498f, 0.03121237f, -0.03087804f, 
    -0.00951070f, -0.01988330f, 0.02087474f, -0.02114079f, 0.00178886f, 0.01415124f, 0.00786142f, -0.03391794f, 
    -0.02920084f, -0.01963860f, -0.00554507f, -0.03570159f, 0.00095305f, -0.02050872f, -0.02275367f, 0.02676658f, 
    0.02383151f, -0.00274169f, -0.02340699f, 0.02614637f, 0.00861664f, 0.00761463f, 0.01075725f, -0.00741300f, 
    -0.02307578f, -0.03871448f, 0.00670512f, -0.01362516f, 0.01468037f, 0.00886468f, -0.03056556f, 0.00639452f, 
    -0.01998978f, -0.04206281f, -0.00548974f, -0.02876704f, -0.03107232f, 0.01095751f, 0.01949685f, 0.01492658f, 
    -0.00378598f, -0.00956586f, -0.00660262f, -0.03734528f, -0.01875227f, -0.01427354f, -0.01824944f, -0.04149129f, 
    -0.02188567f, -0.03246625f, -0.02186706f, -0.00391660f, 0.01838412f, -0.03578785f, 0.01632288f, 0.01321806f, 
    -0.02682550f, -0.01774009f, -0.03940057f, -0.03795938f, 0.01064924f, -0.00597736f, -0.00295835f, 0.01731317f, 
    0.00491105f, 0.02147245f, 0.02464418f, -0.01186782f, -0.00352136f, -0.02625688f, -0.01647289f, -0.02908962f, 
    0.01123965f, -0.01775788f, -0.01237880f, -0.03175375f, 0.01668155f, 0.02446760f, 0.02867490f, -0.00920587f, 
    -0.04218972f, 0.02287772f, 0.01291653f, -0.04049709f, 0.01023792f, -0.02907781f, -0.02466975f, -0.00263707f, 
    -0.00204884f, -0.00984678f, -0.00061971f, 0.01355687f, -0.01430238f, 0.00113787f, 0.00442666f, -0.00245686f, 
    0.00054400f, 0.01737744f, -0.01607004f, -0.00650153f, -0.00100138f, -0.03664466f, 0.01734556f, 0.01770355f, 
    -0.01527081f, 0.01351303f, 0.00565007f, -0.00668116f, -0.02523282f, -0.03690166f, 0.01210484f, 0.01369354f, 
    0.01880479f, 0.00539037f, -0.01675432f, -0.01193483f, -0.02899078f, -0.01528267f, 0.02039844f, -0.01902535f, 
    0.00511984f, 0.01157085f, 0.02152999f, -0.01751469f, 0.01324373f, 0.02134206f, 0.03088837f, -0.02577516f, 
    0.00845471f, -0.03213309f, -0.00146773f, 0.00821705f, 0.00516141f, -0.00721578f, -0.00948394f, 0.02666950f, 
    -0.00115459f, -0.01944267f, -0.02513835f, -0.00978509f, 0.02733500f, -0.00248471f, 0.00912776f, -0.03055309f, 
    0.02659565f, -0.02515273f, 0.01146386f, -0.02601004f, 0.01879296f, 0.00599219f, -0.03491668f, 0.03434963f, 
    0.02056035f, 0.02401639f, -0.01565224f, 0.02624883f, -0.00155324f, 0.02125842f, 0.01612781f, 0.02767773f, 
    -0.03043703f, -0.04346885f, -0.00972807f, -0.01155585f, 0.02231822f, -0.03581810f, -0.01615815f, 0.02342056f, 
    -0.01541017f, 0.00675834f, -0.01726723f, -0.01924598f, -0.01180838f, 0.02277420f, -0.03626438f, -0.01320571f, 
    -0.03865520f, -0.03639387f, -0.00003191f, 0.00894401f, 0.00870789f, -0.03330050f, -0.00133115f, -0.03955040f, 
    0.00776357f, -0.01480963f, -0.00740908f, 0.02265774f, -0.01520142f, -0.00287066f, 0.01592274f, 0.02212035f, 
    -0.00189774f, 0.02362521f, 0.01679043f, 0.02805571f, 0.01410098f, -0.00926202f, 0.01408725f, 0.01613051f, 
    0.01264973f, 0.01787303f, 0.00922386f, -0.02230204f, 0.02419785f, -0.01172913f, -0.03506117f, 0.00769220f, 
    0.01732654f, 0.02255175f, -0.00154523f, -0.00957939f, -0.02209223f, -0.02538602f, -0.02606170f, 0.00058530f, 
    0.01968899f, -0.01257452f, -0.03509259f, 0.00778389f, 0.01730760f, -0.03665260f, -0.04014287f, -0.00558290f, 
    0.02494317f, -0.01641065f, -0.02827455f, 0.01233223f, -0.02185211f, 0.00843363f, -0.03711123f, -0.03322712f, 
    0.00938215f, -0.01598821f, 0.01121215f, 0.02350314f, -0.02447065f, -0.03012283f, -0.03047464f, -0.03670074f, 
    0.00948368f, -0.03774288f, 0.00071249f, -0.01822508f, -0.01984372f, -0.02989499f, 0.00313124f, -0.01001120f, 
    -0.02915658f, -0.02644472f, 0.02269882f, 0.00481034f, -0.03282402f, -0.01544948f, 0.00095616f, -0.04025975f, 
    -0.00753655f, -0.01497384f, -0.00881116f, -0.02294715f, -0.01356502f, -0.00163505f, -0.00341555f, -0.02932448f, 
    0.01415480f, 0.01964122f, -0.00364254f, -0.04057323f, 0.02519025f, 0.02642983f, -0.03451686f, -0.02078059f, 
    -0.05037192f, -0.05493787f, -0.04433360f, -0.21456978f, 0.01089012f, 0.12992378f, -0.06056029f, 0.06312648f, 
    0.00603027f, 0.00353624f, 0.04412400f, 0.08241015f, 0.18347906f, 0.18860133f, 0.04893946f, -0.07768303f, 
    0.13335939f, 0.12220448f, 0.03876073f, -0.00306841f, -0.00471851f, 0.06544301f, 0.03726580f, 0.12350042f, 
    0.02195488f, 0.22731413f, 0.19673529f, -0.16735929f, -0.04284258f, 0.09695102f, -0.10951452f, 0.04875380f, 
    -0.01179776f, 0.01616083f, -0.02778235f, -0.04919641f, -0.06888209f, -0.04945031f, 0.14531524f, 0.22305076f, 
    0.04517283f, -0.03874864f, 0.11844813f, -0.00110259f, 0.00372058f, -0.01588362f, -0.03789185f, 0.10240617f, 
    -0.19659467f, -0.03997952f, 0.20562147f, 0.04208557f, -0.09015203f, -0.06336165f, 0.06312399f, -0.03102077f, 
    0.00806697f, -0.05581228f, 0.03749014f, 0.04727230f, 0.23031364f, 0.03686241f, -0.13232888f, -0.07350682f, 
    -0.04588519f, 0.04822516f, 0.00279226f, 0.02623475f, 0.03580705f, 0.08792890f, -0.01709560f, -0.04952891f, 
    -0.01334133f, -0.12204375f, -0.19908546f, 0.16009930f, 0.05931571f, 0.05810395f, 0.01831814f, 0.10817307f, 
    -0.03714046f, 0.03090134f, 0.16119693f, 0.03890743f, 0.00603961f, 0.15675592f, 0.04284962f, 0.02102241f, 
    0.04857022f, 0.13489385f, 0.11915712f, 0.03377821f, 0.06646873f, -0.03805467f, -0.00023389f, 0.07862386f, 
    -0.21030918f, -0.08702821f, 0.22221628f, -0.09851974f, 0.00667124f, 0.01305785f, 0.02473841f, -0.05027413f, 
    0.01174253f, -0.03169331f, -0.02433461f, 0.01666929f, -0.04246384f, -0.32969296f, -0.01530596f, 0.01010207f, 
    0.02452417f, 0.07829044f, -0.06615264f, -0.00789549f, -0.11193462f, -0.08664906f, -0.00709037f, 0.04224905f, 
    0.33191669f, -0.15544656f, 0.03673245f, 0.08582951f, -0.00433721f, -0.00670925f, 0.17188488f, 0.19616024f, 
    0.04009242f, 0.11264069f, 0.03926727f, 0.01844016f, 0.06967008f, 0.02489932f, -0.18778615f, 0.06364929f, 
    0.03820831f, 0.24435784f, -0.09406408f, 0.05695853f, -0.05707887f, -0.00923996f, 0.11441929f, -0.00323635f, 
    0.03593795f, -0.10799018f, 0.02844622f, -0.00756849f, 0.09478021f, 0.03202100f, 0.03365432f, 0.04573423f, 
    0.00643699f, -0.02747742f, 0.06934357f, 0.11284417f, -0.01644885f, 0.21039106f, -0.09418172f, -0.03493020f, 
    0.02214984f, -0.02432933f, -0.03324966f, -0.01162622f, -0.01547552f, 0.10206825f, 0.12101456f, 0.11449316f, 
    0.13992122f, -0.06320792f, -0.03582863f, 0.11308543f, 0.06900988f, 0.02203116f, 0.14707999f, 0.17072067f, 
    0.08641055f, -0.01937487f, 0.05915895f, -0.05469657f, -0.04504356f, 0.05148195f, 0.10310235f, 0.04235241f, 
    0.03223594f, 0.14622957f, 0.05448323f, 0.02620434f, 0.05557542f, 0.05028669f, 0.08542995f, -0.04091363f, 
    0.15274064f, -0.01903347f, 0.09982649f, 0.04448586f, -0.01172761f, -0.00983257f, 0.08486848f, -0.03808857f, 
    0.00458903f, -0.00222811f, 0.07501432f, 0.00433254f, -0.12215465f, 0.27116278f, 0.04484959f, -0.08283936f, 
    0.00851959f, 0.03850208f, 0.01390235f, 0.07429199f, -0.05100003f, 0.07721473f, -0.02464176f, 0.07253948f, 
    -0.01031607f, -0.07364350f, 0.05971991f, 0.07018129f, -0.05930218f, -0.04663999f, 0.04872929f, 0.03908897f, 
    0.09235404f, 0.10041503f, 0.04087220f, 0.07920554f, -0.00898927f, 0.19834772f, 0.05226825f, -0.07001930f, 
    0.03004914f, 0.06403217f, 0.05418039f, -0.03310410f, 0.03048337f, -0.00581474f, 0.03801188f, 0.17931223f, 
    -0.16344111f, -0.15214427f, 0.15110371f, 0.11791876f, -0.08629306f, -0.05941219f, 0.05530809f, -0.02328791f, 
    0.03307141f, 0.00193814f, 0.09521047f, 0.00498649f, -0.02071414f, 0.05204897f, -0.07376166f, -0.04142998f, 
    -0.11160874f, 0.07447752f, 0.01417642f, 0.01168712f, -0.03587216f, 0.01596954f, 0.10975580f, 0.08359464f, 
    0.18995091f, 0.19421852f, 0.08502266f, -0.17344697f, -0.02946698f, -0.00071694f, -0.08503012f, -0.07845800f, 
    -0.01373726f, 0.02691396f, -0.07499303f, 0.08700825f, 0.18983309f, 0.21197183f, 0.09649551f, -0.19378187f, 
    0.08201866f, 0.02290166f, -0.02598722f, -0.00276671f, -0.03117365f, 0.09668171f, 0.11587229f, -0.09826849f, 
    0.05781072f, -0.21448883f, -0.00304558f, 0.06092382f, -0.05279222f, 0.04988034f, 0.10985231f, -0.07268082f, 
    -0.03950667f, 0.01757209f, 0.04608648f, 0.04857056f, -0.09626107f, -0.20161292f, -0.11154964f, 0.05252219f, 
    0.18269257f, 0.06756278f, 0.04712449f, 0.12017762f, 0.00461243f, 0.16005120f, 0.03172910f, -0.00941047f, 
    -0.03300039f, 0.24789600f, 0.00272676f, -0.18656226f, 0.12260358f, -0.02740957f, -0.07441489f, -0.01774022f, 
    -0.05394754f, -0.07623832f, 0.07666974f, 0.08928290f, 0.12484185f, -0.10792369f, -0.17190415f, 0.07582329f, 
    -0.10493936f, 0.00943668f, -0.00047756f, 0.11474200f, -0.00435720f, 0.00468690f, 0.01940995f, 0.04229453f, 
    0.17770450f, 0.19730972f, 0.09624449f, -0.12143461f, -0.07102811f, 0.03828973f, 0.07197629f, -0.07692691f, 
    0.22539508f, -0.01042045f, -0.02014934f, -0.02585894f, -0.07438923f, 0.06715018f, 0.09437541f, 0.12527627f, 
    0.13971172f, -0.06687050f, 0.19810192f, 0.01210905f, 0.01798447f, -0.10116132f, 0.03329448f, 0.07699798f, 
    0.06771996f, 0.16105558f, 0.02586626f, -0.01675829f, -0.06144157f, 0.02787668f, 0.02571429f, -0.01814310f, 
    0.05004152f, -0.05503858f, -0.08347283f, -0.06896247f, 0.22557597f, -0.04080866f, -0.02997070f, 0.02183771f, 
    -0.10154861f, 0.02862135f, 0.09974584f, 0.08456982f, 0.11820406f, 0.08930738f, 0.09585946f, 0.07183539f, 
    -0.19542189f, -0.02451386f, 0.00570139f, 0.06639057f, 0.06385621f, 0.05811911f, 0.03760060f, 0.09136692f, 
    0.16359715f, -0.12297989f, -0.02889143f, -0.07583793f, 0.44740048f, -0.11092641f, -0.20261595f, 0.05977540f, 
    -0.07698563f, -0.03365107f, 0.05498371f, 0.00023793f, -0.00835760f, 0.06443037f, -0.01806977f, 0.08871375f, 
    -0.00817120f, -0.22124884f, 0.01965903f, -0.03005739f, 0.17871456f, -0.05591337f, -0.00267753f, 0.07671560f, 
    0.01992494f, 0.16652706f, -0.06281658f, 0.02226621f, 0.06441743f, -0.15714981f, -0.02856913f, -0.03188893f, 
    -0.02577392f, -0.06249600f, -0.00882103f, -0.01533663f, 0.01802192f, 0.12939145f, 0.09137838f, 0.02859193f, 
    -0.09307598f, 0.05309433f, -0.11045840f, 0.12971030f, 0.09329562f, -0.00998063f, 0.00173177f, -0.05552902f, 
    -0.00076559f, -0.10896401f, 0.10908827f, 0.09512204f, -0.18086475f, 0.04148796f, -0.13977492f, -0.04273129f, 
    0.07213581f, -0.01990571f, -0.03534821f, -0.01441898f, -0.05845428f, 0.04524298f, 0.02022492f, 0.02179415f, 
    -0.22710155f, 0.19275568f, 0.12791684f, -0.04718129f, -0.05232558f, 0.00656631f, 0.11711881f, -0.00550927f, 
    0.03006068f, 0.07896534f, 0.13471392f, 0.09894706f, -0.16381927f, 0.06751222f, 0.01630300f, -0.07480804f, 
    0.01411423f, 0.13962188f, 0.03980197f, -0.03890998f, 0.02113525f, 0.01616392f, -0.10984889f, 0.07391794f, 
    -0.13831532f, -0.25428435f, 0.01444644f, 0.02330819f, 0.17041804f, 0.07776824f, 0.07383044f, -0.04847646f, 
    0.08838066f, -0.10713119f, 0.03796602f, -0.04954703f, -0.29085308f, -0.01693061f, 0.02990159f, -0.00615333f, 
    0.11096157f, 0.08139934f, -0.03589669f, 0.04287351f, 0.11364045f, 0.06879567f, 0.04241139f, -0.00318234f, 
    -0.10219277f, -0.07382118f, -0.12858826f, 0.13955826f, 0.12799041f, -0.03924593f, -0.04014146f, 0.07661143f, 
    0.04501558f, -0.06538361f, 0.07458798f, -0.02713387f, 0.06515218f, 0.02127902f, -0.19903663f, -0.12386288f, 
    0.07853197f, 0.06137105f, -0.02319171f, 0.13646957f, -0.03011354f, 0.02552259f, 0.05800017f, 0.12552606f, 
    -0.05194306f, -0.11277793f, 0.04879146f, 0.15112107f, -0.03805437f, 0.07912569f, 0.04264747f, -0.03366189f, 
    0.14336406f, -0.00793719f, 0.02506092f, 0.01638480f, 0.04081675f, 0.01347735f, 0.37798089f, 0.08734918f, 
    -0.04891723f, 0.05228782f, 0.04180897f, -0.00599672f, 0.02748081f, -0.00161193f, 0.10516497f, -0.01350856f, 
    0.07565535f, -0.05192479f, 0.09357076f, 0.09254830f, 0.02846494f, 0.05744901f, 0.02551987f, -0.05414424f, 
    0.02379072f, -0.03688299f, 0.05322159f, 0.05048300f, -0.11915889f, -0.07504866f, 0.01165362f, 0.15235928f, 
    0.12974699f, 0.03730613f, 0.02784083f, 0.08526780f, -0.04475737f, -0.04166233f, 0.05169321f, 0.08275759f, 
    -0.08897769f, 0.21194315f, 0.06354311f, 0.00094970f, 0.06259223f, 0.03404200f, 0.03270885f, 0.00166225f, 
    0.03977920f, 0.09232316f, -0.03786822f, 0.02027549f, 0.14364700f, -0.18782745f, 0.11418504f, -0.13929765f, 
    0.03362841f, 0.00811368f, 0.09568029f, -0.07610616f, 0.05962554f, 0.11167546f, -0.06535947f, -0.02512494f, 
    -0.09952115f, -0.00071731f, -0.26102731f, -0.02682976f, 0.04666061f, 0.01440226f, 0.03377591f, 0.05294975f, 
    -0.02477954f, -0.00300874f, -0.09184837f, 0.01894509f, 0.15614110f, -0.02959410f, 0.04956803f, -0.01249667f, 
    0.09524629f, 0.06669457f, 0.00619549f, 0.11680056f, 0.09295359f, -0.02425309f, 0.00682296f, 0.05453202f, 
    -0.01491390f, 0.28424582f, 0.11220729f, -0.11988019f, -0.12511919f, -0.06791174f, -0.01182367f, 0.02800828f, 
    -0.00443785f, 0.00636279f, 0.08761734f, 0.01819990f, -0.19079520f, 0.10865558f, 0.14177553f, 0.05342943f, 
    0.03545157f, 0.06407597f, 0.00510633f, -0.07273913f, 0.08904418f, -0.06608392f, 0.02639933f, -0.19531523f, 
    -0.11729811f, 0.21987194f, 0.02065984f, -0.15855706f, 0.03350754f, 0.09265195f, 0.03908503f, 0.06471163f, 
    -0.05487307f, 0.09671943f, 0.00518898f, 0.12091731f, -0.08592565f, 0.14645407f, 0.24478588f, -0.01390108f, 
    -0.04077355f, -0.07768269f, 0.05351472f, -0.10452322f, 0.17775829f, 0.06908236f, -0.01456168f, 0.02105328f, 
    -0.17924817f, 0.07881931f, -0.18661456f, -0.03988261f, 0.08668678f, 0.06078978f, -0.06634434f, 0.07082591f, 
    -0.01792511f, -0.01034316f, 0.06733789f, 0.09525383f, 0.04391265f, 0.31238669f, 0.06655490f, -0.14987032f, 
    0.00599383f, 0.00227872f, 0.03595075f, 0.07402726f, -0.03163429f, 0.05782725f, -0.03773303f, 0.04040817f, 
    -0.20040174f, -0.11672298f, 0.11361735f, 0.03035935f, 0.03719168f, 0.05690442f, 0.04933560f, 0.11047963f, 
    0.14272344f, 0.00219433f, 0.06469832f, 0.03590883f, -0.26183125f, 0.07179186f, 0.03167047f, 0.20218726f, 
    0.10155975f, 0.05458617f, -0.02027655f, 0.14588270f, 0.16928278f, 0.00567973f, -0.05333185f, 0.07644174f, 
    0.42206413f, -0.06894752f, 0.08482236f, 0.03832704f, 0.00429756f, 0.17307761f, 0.07879858f, 0.06969365f, 
    0.05965224f, 0.08737220f, -0.06707407f, 0.07868934f, 0.00483610f, 0.15345868f, 0.04824550f, 0.00097856f, 
    0.12671992f, 0.12780246f, -0.00789702f, 0.10471946f, 0.00861537f, 0.02678754f, 0.06186525f, 0.14053677f, 
    -0.00786204f, 0.06367667f, -0.13388358f, 0.08551265f, 0.07708357f, 0.04968026f, 0.05444014f, 0.04586994f, 
    -0.00066441f, -0.01622386f, -0.06235354f, -0.08819716f, -0.04329817f, -0.03920667f, -0.07695565f, -0.10548712f, 
    -0.08471452f, 0.08527377f, 0.09489089f, -0.04827258f, 0.04056066f, 0.07641850f, -0.00076522f, 0.03173311f, 
    -0.00620418f, -0.13705212f, 0.02848407f, 0.08919547f, -0.01348512f, 0.07501893f, 0.18511921f, 0.08142556f, 
    0.12336014f, 0.08264419f, 0.06742782f, -0.01345579f, 0.15525894f, -0.01968108f, 0.14468932f, -0.04867024f, 
    0.10876741f, 0.00293138f, 0.04448562f, 0.06915170f, 0.09964681f, 0.00413213f, -0.02638243f, 0.13544816f, 
    0.20486115f, 0.07107842f, 0.05847449f, 0.16902508f, 0.06099290f, 0.01815135f, 0.04715104f, 0.03774671f, 
    0.06236649f, 0.05978617f, 0.06065660f, 0.16465761f, 0.28760457f, 0.04916351f, 0.02616645f, 0.24930115f, 
    -0.00724378f, -0.02693498f, -0.00847182f, -0.04324821f, 0.10535699f, 0.01815571f, -0.00387460f, -0.01388013f, 
    -0.10915006f, -0.01032681f, 0.06375569f, 0.22840475f, -0.03767989f, -0.04157313f, -0.02893007f, 0.02147514f, 
    -0.10083032f, -0.04777182f, 0.00586302f, 0.07373311f, 0.06708501f, -0.13006927f, -0.00293015f, -0.06768864f, 
    0.10558362f, -0.05282553f, 0.11058843f, -0.03104180f, 0.02258018f, 0.10605977f, -0.02927120f, 0.05787729f, 
    0.03453565f, -0.03829132f, -0.16480556f, 0.12405551f, 0.11351591f, 0.07406674f, 0.04363364f, 0.05201438f, 
    -0.03044969f, -0.03996751f, -0.02962173f, -0.09207248f, -0.13065147f, 0.14511572f, -0.04105669f, -0.11462484f, 
    0.06791020f, -0.03736981f, -0.02665135f, -0.09762947f, -0.01448091f, 0.03541230f, 0.02103578f, 0.04565458f, 
    0.08937223f, -0.06644027f, -0.02416449f, 0.29186311f, -0.00423910f, -0.08166438f, 0.02963624f, -0.09427163f, 
    -0.13191454f, 0.03074624f, 0.04416572f, 0.05572816f, -0.06030491f, -0.00830357f, 0.11417325f, 0.25560361f, 
    -0.13024801f, -0.18934788f, -0.01262037f, 0.06809622f, -0.10990524f, 0.03328532f, -0.05925332f, 0.17594585f, 
    -0.16806506f, -0.14431185f, 0.04524788f, 0.08245128f, 0.09685168f, -0.06529064f, -0.06495219f, -0.08444127f, 
    -0.06458104f, 0.16505635f, 0.03945317f, 0.01734344f, -0.03438706f, 0.05679629f, -0.02889344f, -0.16530053f, 
    0.08791046f, 0.00652407f, 0.18350275f, 0.02184477f, 0.00580003f, 0.05344215f, -0.09983997f, -0.06461699f, 
    -0.10787507f, -0.11922576f, -0.08251663f, 0.04429101f, 0.06489984f, 0.04492580f, -0.03663942f, 0.01609218f, 
    -0.03080352f, -0.01054904f, 0.03381023f, 0.04451914f, 0.15410709f, 0.03594109f, 0.09396362f, 0.14220016f, 
    0.00279069f, -0.03632988f, 0.04020450f, -0.07138958f, 0.08710676f, -0.01905264f, -0.04723139f, 0.06367119f, 
    -0.30331028f, -0.15713051f, -0.06478719f, 0.05218002f, -0.00570415f, 0.00210520f, -0.11978880f, -0.18498510f, 
    0.07380812f, -0.09146477f, 0.02729926f, 0.06654050f, 0.00086228f, 0.09024350f, 0.14298561f, -0.09035727f, 
    0.03435220f, 0.02323229f, 0.07650330f, 0.05218043f, 0.01642754f, -0.00304797f, -0.05745867f, -0.03260223f, 
    0.13929890f, 0.05903510f, 0.15798491f, 0.20307209f, -0.07755010f, 0.08502673f, 0.06556021f, -0.04550459f, 
    0.02866130f, 0.09679308f, 0.04232518f, 0.02833633f, 0.03418539f, 0.07523840f, -0.02103459f, -0.10604433f, 
    0.02855639f, 0.03662778f, -0.02635751f, 0.07331014f, 0.02756163f, 0.05613136f, 0.06679932f, -0.02202230f, 
    0.11475991f, -0.04385579f, -0.25043792f, 0.06622339f, -0.00858477f, 0.02419224f, 0.08974370f, -0.02415664f, 
    -0.02435378f, -0.11674444f, 0.06860953f, -0.00996029f, 0.01178348f, 0.14942764f, 0.05312408f, -0.19475849f, 
    0.06634638f, -0.04995249f, 0.05339587f, -0.10057122f, 0.01131635f, 0.04117950f, 0.05326505f, -0.03534598f, 
    -0.04339459f, -0.04945331f, -0.02647689f, 0.15971868f, 0.05113772f, 0.02715740f, 0.04484938f, 0.05542175f, 
    0.05095245f, -0.08564579f, -0.03526384f, -0.03050680f, 0.14478168f, -0.09491923f, 0.12926321f, 0.06918170f, 
    0.06016641f, -0.13911863f, -0.12678009f, -0.04264412f, 0.02526907f, 0.05639238f, 0.03122342f, 0.03328323f, 
    0.12973142f, -0.16995519f, 0.03218158f, -0.06025447f, 0.11315354f, -0.09166548f, 0.01931103f, 0.09287680f, 
    0.07313742f, -0.05522886f, -0.07410166f, 0.02487646f, 0.05983186f, 0.18195491f, 0.15030363f, 0.05893695f, 
    -0.09065057f, 0.02265279f, 0.08521407f, -0.02040678f, 0.01830480f, -0.03183110f, -0.12035521f, 0.05740650f, 
    -0.00601481f, -0.03004631f, 0.03358986f, 0.07397514f, -0.06946988f, -0.10222920f, -0.04442327f, -0.03562090f, 
    -0.04576772f, 0.04058152f, 0.01351493f, -0.01196951f, -0.15392621f, -0.08174259f, -0.06566304f, 0.08624689f, 
    0.09196839f, 0.16683955f, -0.06981151f, -0.02210837f, 0.06396349f, 0.10460656f, 0.06084604f, 0.11227574f, 
    0.01555036f, 0.00030272f, 0.20357467f, 0.17549153f, -0.00352838f, 0.03357463f, 0.00702568f, 0.09619105f, 
    -0.09549902f, 0.01608007f, 0.05836662f, 0.00031085f, 0.15520352f, -0.06824211f, 0.08598446f, 0.04762129f, 
    -0.02265883f, 0.04032141f, 0.03622288f, 0.06775627f, -0.04064205f, 0.02470801f, 0.04080359f, 0.02184211f, 
    0.15878412f, 0.02329473f, -0.07546129f, -0.01254546f, 0.04878252f, 0.12985864f, 0.07193774f, 0.00599182f, 
    0.07338920f, 0.05456451f, 0.02629108f, 0.15919186f, -0.09161544f, -0.00011725f, -0.12341918f, 0.12515444f, 
    0.04794867f, 0.07981202f, -0.13692221f, -0.05138411f, 0.08173124f, -0.00446583f, -0.00540238f, -0.01716936f, 
    0.07442712f, -0.14148778f, 0.20963725f, -0.13122603f, 0.01736413f, 0.02859787f, 0.07531080f, 0.03887814f, 
    -0.01428861f, -0.02604798f, 0.03101506f, 0.01776094f, 0.21169890f, -0.15272629f, 0.03983352f, 0.10193620f, 
    0.01412130f, -0.03445091f, -0.01058666f, 0.02491605f, -0.09256347f, 0.04058265f, 0.09493326f, 0.03651382f, 
    -0.27151424f, 0.01718813f, -0.03299132f, 0.00953391f, -0.01946725f, -0.04583204f, -0.04676278f, 0.03012625f, 
    0.03280209f, -0.03025031f, 0.08175955f, -0.01670259f, 0.01958519f, -0.16617878f, 0.21803267f, 0.24261518f, 
    0.01928877f, -0.11443100f, 0.01249162f, -0.06090831f, 0.00667436f, 0.10560580f, 0.02048000f, -0.00344835f, 
    -0.41143948f, -0.13760161f, -0.20294929f, -0.01489536f, 0.02187418f, 0.13023259f, 0.04367687f, -0.13089062f, 
    -0.00342796f, -0.01062499f, 0.07981411f, 0.01131419f, 0.15497318f, 0.05851822f, 0.02303655f, 0.20676331f, 
    0.12688819f, 0.14238888f, -0.00055453f, -0.05759554f, 0.08506191f, -0.00875875f, -0.06454929f, 0.00066684f, 
    -0.13624027f, 0.03181753f, -0.14271878f, -0.08594976f, 0.16714896f, -0.02723496f, -0.08243667f, -0.04919428f, 
    0.05047130f, -0.01239481f, -0.03257866f, -0.03888976f, -0.46941194f, 0.06615233f, 0.07689861f, -0.22970480f, 
    0.01282009f, -0.02114448f, 0.00935750f, 0.02649538f, 0.01389362f, -0.04141227f, -0.00879024f, -0.07227480f, 
    -0.12160172f, 0.13401343f, 0.13583995f, 0.00355646f, -0.03301399f, 0.03167712f, 0.02184321f, -0.11587221f, 
    -0.17222078f, -0.21096750f, 0.03993419f, 0.09071230f, 0.15651681f, 0.02782589f, 0.11948260f, -0.10606776f, 
    -0.05119591f, -0.03240338f, -0.02701086f, 0.02903663f, -0.01479348f, -0.03345577f, 0.02942986f, -0.04547836f, 
    -0.13893598f, 0.01051506f, -0.11729303f, 0.21264420f, 0.08561935f, -0.05674069f, -0.14226349f, 0.12083844f, 
    0.14581107f, 0.01677551f, -0.04026221f, -0.06586754f, -0.19006495f, 0.09737939f, 0.06940840f, 0.12430777f, 
    -0.00703872f, 0.06394196f, 0.06372986f, 0.04287829f, 0.04294633f, 0.02338846f, -0.02156397f, 0.04137578f, 
    -0.14816052f, -0.06860723f, -0.17340401f, 0.14814501f, 0.05721866f, -0.11533251f, -0.11418151f, -0.18766522f, 
    0.00173100f, 0.08712864f, -0.05887896f, 0.10658044f, -0.12319095f, 0.03294849f, 0.07356184f, 0.08263258f, 
    0.02570285f, 0.00085465f, 0.07479561f, 0.18177801f, -0.13724449f, 0.14509825f, 0.05984130f, 0.00809255f, 
    0.18969716f, 0.07324127f, 0.02898433f, 0.05058042f, 0.08030106f, -0.00541970f, 0.01859000f, -0.12379635f, 
    -0.05807177f, 0.05041996f, 0.10204974f, -0.04244277f, 0.00980389f, 0.06387565f, -0.08696099f, 0.13483249f, 
    0.04122610f, 0.09403882f, 0.07592822f, -0.01702114f, -0.02346415f, 0.08973011f, -0.02045307f, -0.06749354f, 
    0.09408575f, 0.04454583f, 0.04077409f, -0.03253164f, 0.09076504f, -0.00470191f, -0.00115542f, 0.01200411f, 
    -0.02699201f, 0.10025754f, 0.07992377f, -0.03685303f, -0.25964519f, -0.08481569f, -0.07222376f, -0.00170878f, 
    0.05350428f, 0.06147694f, 0.02233907f, -0.01269444f, 0.08223705f, 0.01530079f, -0.02900375f, -0.04769319f, 
    0.05341800f, 0.11885914f, 0.08020408f, 0.04651494f, -0.00319658f, 0.07200916f, 0.00191479f, 0.00973570f, 
    -0.00983482f, -0.06780471f, 0.10376564f, 0.01726220f, -0.26347926f, 0.01247284f, 0.06873999f, 0.15883137f, 
    0.04073874f, -0.02561598f, 0.08006012f, 0.02793802f, 0.06328864f, 0.03226294f, -0.10989162f, -0.00354642f, 
    -0.41308314f, 0.09284115f, 0.02342597f, -0.02824916f, 0.03854363f, -0.04213708f, -0.00598861f, 0.06397128f, 
    0.06452866f, 0.02584115f, 0.07830756f, -0.01068733f, -0.06169272f, 0.10372386f, -0.10393034f, 0.08270316f, 
    -0.08228378f, -0.05009871f, -0.00240999f, -0.07442680f, 0.10070875f, -0.08180222f, -0.02273342f, 0.11833738f, 
    -0.03778662f, -0.01573817f, 0.13459502f, 0.11138625f, -0.07402822f, -0.00745512f, 0.09848533f, 0.01711616f, 
    -0.04123724f, -0.08935323f, 0.02373574f, 0.12281179f, 0.09347384f, 0.13632664f, -0.14994739f, 0.23499577f, 
    0.00974434f, 0.03441173f, 0.01300423f, -0.02891438f, 0.08083623f, -0.04091446f, 0.00544945f, 0.01815715f, 
    0.04034259f, 0.11429875f, 0.18816367f, 0.20550191f, 0.08788686f, 0.03154977f, 0.03408386f, 0.04160991f, 
    -0.07995268f, 0.02037877f, 0.07082195f, -0.00337699f, 0.10731537f, 0.06351312f, 0.22839291f, 0.10499530f, 
    0.01076632f, -0.01876882f, 0.04529996f, -0.03495190f, -0.00396733f, -0.00610616f, 0.09261080f, -0.01162463f, 
    -0.49886599f, 0.00670254f, -0.01995199f, -0.22076398f, 0.10964295f, -0.00476220f, 0.14030938f, 0.05170279f, 
    -0.00775006f, -0.02492904f, -0.06188374f, -0.01174353f, 0.13951275f, 0.06861321f, 0.03346144f, 0.18043315f, 
    -0.02473151f, 0.12255031f, 0.01115225f, 0.06423512f, -0.02145770f, 0.05593308f, 0.11860020f, 0.01222738f, 
    -0.28971371f, -0.03317029f, -0.10330337f, 0.04937117f, 0.05094618f, 0.10548441f, 0.11004905f, -0.00225352f, 
    0.02350270f, 0.05685823f, 0.00198760f, -0.03715310f, -0.17081277f, -0.07187857f, -0.16402012f, 0.04694869f, 
    0.00684680f, 0.05226665f, 0.05626257f, -0.04116777f, 0.09180808f, -0.02416555f, 0.00382748f, -0.02470556f, 
    -0.28481016f, -0.06474985f, 0.11128024f, 0.03706796f, -0.00447750f, -0.00504282f, 0.10827915f, -0.05612573f, 
    0.06733134f, -0.08279789f, 0.04395766f, 0.07110465f, 0.09903190f, 0.09738458f, 0.06629535f, -0.00618549f, 
    0.03208883f, -0.03720582f, 0.08694249f, 0.11963913f, -0.06422685f, 0.02144606f, -0.07680143f, -0.06256666f, 
    0.02457655f, -0.01815333f, -0.09957114f, 0.02668589f, -0.06940209f, -0.02502077f, -0.08394012f, 0.00315156f, 
    0.04142240f, -0.01110162f, 0.01446593f, -0.02692364f, 0.11092027f, 0.03649381f, 0.05687928f, -0.05405588f, 
    0.04425572f, 0.04182795f, -0.00389538f, 0.15305731f, -0.00327087f, 0.01392576f, 0.14197786f, -0.04940198f, 
    -0.01448222f, 0.00182374f, -0.02236356f, -0.03358557f, 0.01528888f, 0.00637989f, -0.03632194f, -0.02564210f, 
    -0.01376026f, -0.00347857f, -0.02800677f, -0.00369815f, 0.01366650f, -0.04344265f, -0.04390299f, -0.00828196f, 
    -0.03687652f, -0.03181785f, -0.01097213f, -0.02058174f, 0.00936120f, 0.01103517f, 0.02754310f, 0.00653983f, 
    -0.01860559f, 0.02125113f, 0.02394552f, -0.00027385f, 0.01074980f, -0.04167194f, -0.01091316f, -0.02370991f, 
    -0.04487074f, -0.04166101f, 0.02116373f, 0.00349749f, -0.02213676f, 0.00098508f, 0.02303973f, 0.01698646f, 
    -0.03316943f, 0.01600114f, 0.00217010f, -0.01023935f, -0.03395703f, 0.01351998f, 0.00301185f, -0.01494892f, 
    0.02672015f, -0.02245465f, -0.01508641f, -0.03625900f, 0.01293244f, 0.01445404f, 0.00219994f, 0.01303533f, 
    -0.01498330f, -0.02719519f, -0.02489604f, 0.01491853f, -0.02626589f, 0.02004465f, 0.00580675f, 0.03823065f, 
    0.01587225f, -0.03790008f, -0.02715792f, 0.01347299f, -0.01033718f, -0.00969955f, -0.03623260f, -0.02715525f, 
    -0.03055954f, -0.02938221f, 0.00400139f, 0.02697943f, -0.02871997f, -0.00428266f, -0.01314913f, -0.02322426f, 
    -0.02529899f, 0.00654905f, 0.01309533f, 0.01294888f, -0.04403606f, -0.04364995f, 0.00238816f, -0.00737818f, 
    -0.01244208f, -0.02604125f, -0.01024263f, -0.01556262f, 0.00910679f, -0.01706953f, -0.00179867f, 0.00093714f, 
    -0.02199262f, -0.03261293f, -0.00942627f, -0.02384376f, -0.00934769f, -0.02449862f, -0.04555739f, -0.03672597f, 
    -0.00805959f, -0.04124365f, -0.01900128f, -0.03465701f, -0.00270545f, -0.00229189f, 0.01050768f, 0.00624620f, 
    -0.03551394f, -0.03253163f, 0.01927806f, 0.04065619f, 0.00531034f, 0.01468026f, -0.01839616f, -0.03867348f, 
    -0.00677730f, 0.02850891f, 0.00358577f, -0.01682499f, 0.02373328f, -0.03707229f, 0.00797875f, -0.01545349f, 
    0.01196069f, -0.01123673f, 0.02279836f, -0.02009051f, -0.03150831f, -0.00147028f, -0.02097921f, -0.01005888f, 
    0.00164481f, 0.01796776f, -0.01020976f, -0.00577891f, 0.00121475f, -0.03151913f, -0.01898618f, -0.02355945f, 
    0.01656137f, -0.01337911f, 0.00640306f, 0.00241594f, 0.02078654f, -0.00349305f, -0.03524653f, -0.00826728f, 
    -0.03623053f, -0.00705109f, -0.02151417f, -0.01835298f, 0.03311337f, 0.01079275f, 0.02189386f, 0.00056283f, 
    -0.00977831f, -0.03199545f, -0.03817863f, 0.00915962f, -0.00162002f, 0.02150162f, -0.00496836f, 0.02770786f, 
    -0.01594601f, -0.01411125f, -0.00006637f, -0.01059856f, 0.01420223f, 0.02805806f, 0.02416094f, 0.02702207f, 
    0.00491422f, 0.02072115f, 0.02750403f, -0.01260672f, -0.03655148f, 0.00179355f, -0.02297641f, -0.00423766f, 
    0.01558252f, -0.02001292f, 0.01596970f, -0.00633364f, -0.01904825f, -0.02815668f, -0.00312551f, -0.02309840f, 
    0.02986922f, -0.03395874f, -0.02391123f, 0.00347374f, 0.01404859f, 0.02988738f, 0.00496762f, -0.04033865f, 
    -0.03857963f, -0.00197529f, 0.02495371f, 0.00511992f, 0.01228013f, 0.01069209f, -0.01254598f, -0.00562820f, 
    0.02157686f, -0.02236175f, 0.01107654f, -0.00535425f, -0.02650646f, 0.00299791f, 0.02438140f, -0.02936148f, 
    0.00536711f, 0.00063323f, -0.00879456f, 0.02212016f, -0.02603926f, 0.01524846f, -0.02798616f, 0.01029244f, 
    -0.03495495f, -0.02664252f, -0.01182735f, -0.00194395f, -0.03787415f, -0.00523219f, 0.00770427f, -0.01868329f, 
    -0.04009042f, -0.01049313f, 0.01024376f, -0.03494012f, -0.03108912f, -0.04108745f, 0.02227468f, -0.02120708f, 
    -0.00310079f, -0.00074055f, -0.02607273f, 0.01838431f, -0.03486063f, 0.02722253f, 0.01122847f, 0.01650805f, 
    -0.00371924f, -0.02575491f, 0.02242423f, 0.00414348f, -0.01791338f, 0.01958510f, -0.02726210f, 0.01440583f, 
    -0.01432352f, -0.00842777f, -0.02760460f, -0.04268933f, 0.01692498f, 0.00530583f, -0.02406383f, -0.02060218f, 
    0.01679260f, 0.01817276f, -0.01039523f, -0.01768026f, 0.00078847f, -0.03658816f, -0.03909610f, 0.02694540f, 
    -0.03332806f, 0.01939348f, -0.04445417f, -0.02572371f, -0.04195206f, -0.02764845f, 0.00881827f, -0.01453414f, 
    -0.02958730f, 0.01304679f, 0.01109230f, -0.02101170f, -0.01192730f, 0.01584854f, 0.02246241f, -0.02113250f, 
    0.01849610f, 0.02669728f, -0.00324389f, 0.03026514f, -0.00784249f, -0.01175113f, 0.00302796f, 0.02028281f, 
    0.01414673f, -0.00853392f, -0.00866838f, 0.02600395f, 0.00121354f, -0.00643284f, -0.00862597f, 0.01225527f, 
    0.02349807f, 0.01215038f, -0.01914987f, 0.01130495f, 0.02123125f, -0.02167271f, -0.00892225f, 0.02619069f, 
    -0.03000343f, 0.00671815f, -0.01446325f, 0.00124893f, -0.03937989f, -0.03960080f, 0.01094119f, -0.02984912f, 
    -0.02504338f, -0.02167721f, -0.02690710f, -0.03585704f, -0.03560449f, -0.01110041f, 0.02846930f, 0.00770973f, 
    -0.01122482f, -0.01224397f, -0.00599769f, 0.00442442f, 0.01563066f, 0.00048435f, -0.00973898f, 0.02162613f, 
    -0.00874990f, 0.01943942f, 0.01294722f, 0.01485458f, 0.02339911f, -0.02461653f, -0.01503307f, 0.02627268f, 
    -0.03178094f, -0.00152712f, 0.01750408f, -0.03632765f, 0.01332106f, -0.02343091f, -0.03691715f, 0.02180183f, 
    0.02441470f, 0.00586490f, 0.03488132f, 0.01090408f, -0.02851334f, -0.02858798f, 0.00211332f, -0.00843202f, 
    -0.01737546f, -0.03432387f, 0.01395047f, 0.02479034f, -0.00908452f, -0.00979808f, -0.02141438f, 0.02268623f, 
    -0.00161002f, 0.02453958f, 0.03313395f, -0.01107003f, 0.02162435f, -0.02909242f, -0.00059104f, -0.00925576f, 
    0.01780596f, -0.02246998f, -0.00942203f, -0.00121267f, -0.00652404f, 0.02979719f, -0.01895794f, 0.00221865f, 
    -0.02884892f, 0.02076701f, -0.03250230f, 0.01116031f, -0.02023677f, 0.00056167f, -0.01706393f, 0.00541641f, 
    -0.00984013f, 0.00447239f, -0.02335707f, -0.03692181f, 0.01355720f, -0.01512902f, -0.02914739f, 0.01625111f, 
    -0.03309339f, -0.00795761f, 0.02731946f, -0.01181449f, -0.01737383f, -0.01984826f, 0.00583677f, 0.03108770f, 
    -0.04582076f, 0.00525818f, 0.03212683f, -0.02380825f, -0.01629382f, 0.00038552f, 0.02509591f, -0.02326527f, 
    0.00529265f, 0.01481038f, -0.04123770f, -0.01754451f, -0.04080757f, 0.02449075f, 0.02678429f, -0.01065857f, 
    -0.00885635f, 0.00901795f, -0.03515068f, 0.02419595f, 0.02060173f, 0.01992911f, 0.03343711f, 0.03360568f, 
    0.00573971f, 0.01387886f, -0.00125540f, 0.02245193f, -0.03297615f, 0.02422635f, -0.02678988f, -0.04438306f, 
    0.02989750f, -0.00799235f, -0.02258037f, 0.01582726f, -0.02734951f, -0.01170817f, -0.00752127f, -0.01142674f, 
    -0.03914966f, -0.00923847f, 0.02567212f, -0.03887250f, 0.01834788f, -0.02181241f, 0.00633201f, 0.00958372f, 
    0.02712517f, 0.01002720f, -0.02723368f, 0.01401884f, -0.04495111f, -0.00090483f, -0.03285792f, 0.01520704f, 
    0.00140177f, -0.03128494f, 0.01026094f, 0.02567182f, -0.03916423f, -0.03570729f, -0.02607808f, -0.01665484f, 
    -0.00567858f, -0.04503274f, -0.02635426f, -0.03078530f, 0.00893471f, -0.01474054f, -0.02029865f, -0.03563606f, 
    -0.01736246f, 0.01861885f, -0.00225233f, 0.00904844f, 0.03161516f, 0.00667096f, -0.00061197f, -0.02742200f, 
    0.02383324f, 0.02446777f, 0.02328677f, -0.02871620f, -0.01409074f, 0.01221856f, -0.02841327f, 0.00134131f, 
    -0.03469505f, 0.02754189f, -0.00891032f, -0.00960272f, -0.02862923f, -0.03601693f, 0.01968353f, 0.02501880f, 
    -0.03256052f, 0.03721225f, -0.00576337f, 0.00236083f, -0.00214987f, 0.02963975f, 0.00845131f, -0.01902204f, 
    0.02486718f, -0.03768403f, 0.01074465f, 0.02399726f, -0.02671599f, 0.02384854f, -0.00642957f, 0.00991474f, 
    0.01861014f, -0.02722598f, 0.01308380f, 0.01199767f, -0.00411500f, -0.00529571f, 0.00295058f, -0.02378947f, 
    -0.01212564f, -0.02434900f, 0.00664816f, 0.01189908f, -0.02303845f, -0.02161334f, 0.01095968f, -0.00864952f, 
    0.00850553f, -0.01005630f, -0.00873091f, -0.00558939f, -0.01746612f, -0.03938252f, 0.00938896f, -0.04269783f, 
    0.02441607f, -0.01701546f, 0.01145905f, 0.00226326f, 0.03048543f, -0.01893533f, -0.01160778f, -0.01701483f, 
    -0.01062064f, -0.02777489f, 0.02362817f, -0.04007898f, -0.02847545f, 0.01189887f, -0.01473630f, -0.03581033f, 
    -0.01289932f, -0.03516885f, -0.00626343f, -0.03595801f, 0.02490176f, -0.00425590f, -0.02251013f, -0.00947980f, 
    -0.00729658f, -0.03388754f, -0.04140827f, -0.03663103f, -0.02591690f, -0.03276728f, -0.01635693f, 0.02593556f, 
    -0.04425352f, 0.02129820f, 0.02456260f, 0.00159735f, -0.01912790f, -0.02295485f, -0.00059971f, -0.01952076f, 
    -0.00972158f, -0.04079407f, -0.02019007f, 0.00252926f, -0.00900623f, -0.01309865f, -0.01130322f, 0.01321825f, 
    0.00136851f, -0.03706253f, -0.00674221f, -0.02596917f, -0.01015617f, -0.01657114f, 0.02511568f, -0.02838315f, 
    -0.02898009f, 0.00098547f, -0.00263030f, 0.00944472f, 0.00134771f, -0.02584670f, -0.01115428f, -0.03303352f, 
    0.00746021f, -0.00298686f, -0.00080359f, -0.00951235f, -0.00900063f, 0.02729335f, 0.01506684f, -0.02256000f, 
    -0.03614509f, -0.04022785f, -0.02372708f, -0.00919233f, -0.03680696f, -0.03166645f, 0.01312418f, 0.00469030f, 
    0.02058304f, 0.00914034f, -0.03807384f, 0.01581254f, 0.02516224f, 0.00404946f, -0.01778140f, 0.02933834f, 
    0.00006652f, -0.00284128f, -0.01121473f, -0.00488490f, 0.01387739f, -0.01874333f, -0.01459178f, 0.02332666f, 
    0.00930200f, 0.01255261f, 0.01190720f, 0.00601067f, 0.00625114f, 0.01808209f, 0.00180250f, 0.02670123f, 
    0.00888918f, -0.02331169f, -0.01333377f, -0.00852404f, -0.03413645f, -0.03889130f, 0.01167223f, -0.01272304f, 
    0.01255122f, -0.00254553f, -0.02862628f, -0.02303509f, 0.02655333f, 0.00341889f, 0.02269478f, -0.02345708f, 
    -0.03155847f, -0.02017581f, 0.00384499f, -0.02787271f, -0.03661477f, -0.02911450f, 0.02542760f, 0.00255000f, 
    0.00551366f, 0.01473989f, -0.00955403f, -0.03817680f, -0.03398759f, -0.02201080f, 0.01429220f, 0.01026607f, 
    0.00214492f, -0.02440239f, -0.03236418f, -0.01578861f, -0.04537414f, -0.00737514f, 0.01157175f, 0.01120337f, 
    -0.02936136f, -0.03423523f, -0.03536714f, -0.01233804f, -0.01325557f, -0.02698212f, -0.03495287f, -0.02337527f, 
    -0.02653220f, 0.00862005f, -0.02381545f, 0.01769607f, -0.00280272f, 0.01179227f, -0.02610009f, 0.01776611f, 
    0.01907237f, -0.03337222f, -0.02542762f, 0.00793967f, -0.03316953f, -0.00958496f, 0.02022848f, -0.03779590f, 
    -0.01837155f, -0.02597728f, 0.02958092f, -0.02739006f, -0.01941294f, 0.00455498f, -0.00850994f, 0.01655617f, 
    -0.03827701f, 0.00016379f, -0.01745457f, -0.03957780f, -0.01198591f, 0.01480654f, -0.02190364f, 0.01552053f, 
    -0.01539495f, 0.01598925f, 0.01553681f, -0.01713802f, 0.02449918f, 0.01228877f, 0.00180501f, -0.00173159f, 
    -0.02577469f, -0.01701676f, -0.02320229f, 0.01304397f, -0.02504995f, 0.01790439f, 0.02738767f, -0.02820476f, 
    -0.02829914f, -0.03922410f, 0.02456699f, -0.00900850f, 0.02613132f, -0.02462548f, -0.03753015f, -0.04177864f, 
    -0.03131771f, -0.01426044f, -0.03607748f, 0.01633639f, 0.00634584f, -0.02908447f, 0.03172720f, -0.00605438f, 
    -0.00154114f, 0.00181398f, -0.00972811f, 0.01805551f, 0.02484899f, -0.00549401f, 0.01005812f, 0.02348755f, 
    0.02858474f, 0.03285313f, 0.00225232f, -0.03504855f, 0.00291859f, 0.01076879f, 0.00324247f, -0.03556253f, 
    -0.03337261f, -0.01650588f, 0.02227652f, -0.02684990f, -0.03218900f, -0.01302870f, -0.01286462f, -0.00156363f, 
    -0.00575658f, 0.00649572f, 0.02201436f, -0.02406272f, 0.00718368f, -0.01663258f, -0.00014069f, -0.02974239f, 
    0.03140523f, -0.00299763f, -0.01120047f, -0.00553275f, -0.02811916f, 0.02542352f, -0.03102249f, 0.01812183f, 
    -0.01392468f, 0.00878087f, -0.00853981f, -0.02390081f, -0.00499943f, -0.02683522f, -0.00423425f, -0.01904510f, 
    0.00572327f, -0.00935527f, 0.00335804f, -0.01771957f, -0.02597454f, 0.01483941f, 0.00692307f, -0.03102766f, 
    0.03466301f, -0.02911853f, -0.00044314f, -0.01211097f, 0.02216166f, -0.01547205f, 0.01813555f, -0.01214582f, 
    0.00751581f, -0.02572743f, -0.01085701f, 0.01450828f, 0.00150795f, -0.00100549f, -0.02067029f, -0.03491760f, 
    0.02321342f, 0.00800687f, -0.00262344f, 0.00933694f, -0.02034208f, 0.00968664f, -0.00550424f, -0.02467383f, 
    -0.01213281f, -0.02638360f, -0.03670784f, -0.00345523f, -0.03544235f, -0.01815048f, -0.01426709f, 0.01295804f, 
    -0.02320264f, -0.03016750f, 0.02817148f, -0.02716053f, -0.02327213f, -0.02669083f, -0.00347176f, 0.02877220f, 
    -0.01409287f, -0.00993416f, -0.00479155f, -0.00616393f, -0.01138338f, 0.02345559f, 0.01293460f, -0.01666537f, 
    -0.02806664f, -0.00153210f, -0.00755098f, 0.01708176f, -0.01072819f, -0.01568586f, 0.02198276f, 0.03042694f, 
    0.01127329f, -0.03087338f, 0.00133122f, -0.03580979f, -0.01386101f, -0.01457097f, -0.01546328f, 0.00730581f, 
    -0.02621203f, 0.02206297f, 0.01038496f, 0.03637794f, 0.02101639f, 0.00410244f, 0.00888783f, -0.01909654f, 
    -0.00264867f, -0.03559061f, 0.00482208f, -0.01303668f, -0.00568555f, -0.01939582f, 0.01336472f, 0.03335379f, 
    0.00420692f, 0.01613590f, 0.01536271f, -0.00266771f, 0.03097448f, 0.02940275f, -0.00632021f, -0.03284527f, 
    -0.00374962f, 0.01413250f, -0.02328460f, -0.00454212f, 0.00557060f, 0.00074727f, -0.02290961f, -0.02260361f, 
    -0.02688580f, -0.03587571f, 0.02771598f, 0.01447270f, 0.03485428f, -0.02036070f, 0.01607862f, -0.01312165f, 
    -0.03067642f, -0.02006472f, -0.01638860f, -0.03683165f, -0.00009680f, -0.02093327f, 0.01328078f, 0.02557394f, 
    -0.03233908f, -0.02336702f, -0.01168008f, -0.00466095f, 0.00515538f, 0.00413560f, 0.02424742f, 0.03232641f, 
    0.02293058f, 0.00419115f, -0.00208278f, -0.00988020f, -0.01313689f, -0.00563797f, 0.01907605f, -0.02413492f, 
    0.01503209f, -0.03215170f, 0.00904270f, -0.02155033f, 0.03618047f, 0.01305988f, 0.02786130f, 0.02036206f, 
    0.03724603f, -0.01402257f, -0.03657741f, 0.03183101f, 0.00314046f, 0.00539021f, -0.01903089f, -0.03815809f, 
    0.01820548f, -0.03080635f, -0.03279311f, -0.01964649f, -0.03869039f, 0.00968194f, -0.02401798f, 0.00773651f, 
    0.02101400f, -0.03024805f, -0.00117520f, 0.02873652f, 0.01387613f, -0.03452577f, -0.03088171f, 0.01254785f, 
    -0.00338751f, 0.01615927f, -0.02051436f, -0.01626923f, 0.01348381f, 0.00610242f, -0.01373986f, 0.02630611f, 
    -0.01726012f, -0.01832678f, 0.00807145f, 0.03262227f, 0.00955729f, 0.02948831f, -0.02895510f, -0.03120230f, 
    -0.00833979f, 0.02014302f, -0.02553879f, -0.00611077f, -0.03215593f, 0.03330564f, 0.03028304f, 0.01941900f, 
    -0.03557658f, -0.01828293f, 0.01904579f, 0.01278460f, -0.02245984f, -0.02621092f, 0.03475219f, -0.02372275f, 
    -0.01922483f, 0.02896188f, 0.03596235f, -0.01228655f, -0.01010472f, 0.02430108f, -0.01224132f, -0.02277312f, 
    0.01159719f, 0.02375161f, -0.00741277f, 0.02839983f, 0.00558324f, 0.00247902f, 0.00726866f, -0.03062194f, 
    -0.02361031f, 0.03208488f, -0.01237884f, -0.03316586f, -0.00913610f, -0.02657324f, 0.01704104f, -0.02151106f, 
    -0.01574705f, -0.01621634f, -0.00546237f, -0.02839064f, 0.01077190f, 0.02507180f, -0.01292172f, -0.00036383f, 
    -0.00444580f, -0.00138348f, -0.03380930f, -0.03317617f, 0.03395389f, 0.00644949f, 0.00736945f, -0.02153799f, 
    0.00682509f, 0.01283433f, 0.02571990f, 0.01254779f, 0.00625060f, 0.00789195f, -0.03208381f, 0.01322911f, 
    0.01802024f, -0.01545720f, -0.01477435f, -0.01973690f, -0.01101294f, -0.02612461f, -0.00620473f, 0.02351547f, 
    -0.02525738f, 0.01884625f, -0.00512475f, -0.01656657f, 0.02111805f, 0.02458342f, 0.02330192f, 0.03315211f, 
    -0.01379501f, -0.00981879f, 0.00857001f, 0.02808757f, 0.01895227f, -0.03859890f, -0.01147644f, 0.02879640f, 
    0.02463340f, -0.00809869f, -0.03851133f, -0.03779999f, 0.01932754f, -0.01585060f, -0.01872340f, -0.00180651f, 
    -0.04255442f, -0.00881017f, -0.02981342f, -0.01298509f, -0.00036240f, 0.01595600f, 0.01217625f, -0.00329992f, 
    -0.03078902f, -0.02049466f, -0.00505077f, -0.03019501f, -0.01458659f, 0.00144678f, -0.00503594f, -0.02247504f, 
    -0.00707915f, -0.02792988f, -0.00113752f, -0.00652561f, -0.02780806f, 0.00019824f, -0.03041052f, 0.00859783f, 
    0.02606973f, -0.02951470f, 0.02188609f, 0.03923359f, -0.02390183f, -0.01284358f, -0.02747659f, 0.01003732f, 
    0.01629308f, 0.03736982f, 0.01786457f, -0.00392797f, -0.01308369f, -0.02516515f, -0.03004771f, 0.02555004f, 
    -0.01332956f, -0.01962944f, -0.00645872f, 0.02734591f, 0.03205477f, 0.01808301f, 0.01741968f, -0.00528086f, 
    -0.02540509f, 0.00970928f, -0.02917141f, 0.01422197f, -0.02101596f, 0.02404489f, -0.02671140f, -0.00254529f, 
    -0.03660038f, -0.01915458f, 0.01012984f, -0.02033379f, -0.01905690f, -0.01377382f, -0.00710464f, 0.03908287f, 
    0.01776572f, 0.00312294f, -0.00947841f, -0.01602592f, -0.00488425f, 0.01887334f, 0.01367138f, -0.01197499f, 
    -0.01559710f, -0.01111088f, -0.02911806f, 0.01486361f, 0.02535302f, 0.00539684f, -0.01052280f, -0.00195812f, 
    -0.02235680f, -0.01748184f, 0.01027265f, 0.03098798f, -0.03585790f, -0.01951751f, 0.01574699f, 0.03668347f, 
    0.03037363f, -0.01998435f, 0.01902223f, -0.03583469f, -0.03438377f, -0.03718211f, 0.02598688f, -0.01021181f, 
    0.01655909f, -0.02933637f, -0.02156993f, -0.01967960f, -0.01347680f, -0.03195771f, -0.02455789f, 0.02396851f, 
    -0.03033679f, -0.02989011f, 0.01227012f, 0.02479659f, -0.00577268f, 0.01640781f, 0.01850688f, 0.01191767f, 
    0.00198694f, 0.03332644f, 0.02986424f, -0.01056337f, 0.03363494f, -0.02858766f, -0.01385161f, 0.01412083f, 
    -0.03816511f, 0.00978379f, -0.00042937f, -0.01750700f, -0.00684073f, -0.00169705f, -0.01277112f, 0.01913554f, 
    -0.02023235f, 0.00892646f, -0.02469661f, -0.00970355f, -0.01619705f, -0.01884574f, -0.02881954f, -0.02163546f, 
    0.01775265f, -0.03464698f, 0.01120111f, -0.00030490f, -0.00546960f, -0.00750636f, -0.02387392f, -0.02408320f, 
    0.02327116f, -0.03124763f, 0.02161122f, 0.02744149f, 0.02599737f, 0.01992241f, 0.02644204f, -0.02911309f, 
    0.01632315f, 0.03305963f, 0.02107598f, -0.01652393f, 0.01065102f, 0.00333945f, -0.01694327f, -0.02591305f, 
    -0.01050430f, 0.00981724f, -0.02866920f, -0.02027257f, 0.00355455f, 0.02718044f, 0.01238798f, 0.02407171f, 
    0.00902337f, 0.03155165f, 0.01050179f, 0.01233648f, -0.00406957f, 0.00546716f, -0.01073283f, -0.00389041f, 
    -0.02980309f, 0.00357088f, -0.00524998f, -0.01097793f, -0.03157559f, 0.03304432f, -0.03055936f, 0.00559279f, 
    -0.03765132f, 0.00026048f, -0.00693372f, -0.01637135f, 0.02248584f, 0.01738366f, -0.02611037f, -0.03045755f, 
    -0.00590875f, -0.02620559f, -0.03380373f, -0.00110501f, -0.01640769f, 0.00267791f, -0.03345930f, 0.01483111f, 
    -0.02906706f, 0.00979367f, 0.02879122f, -0.00307424f, -0.00331325f, 0.02214908f, 0.01424321f, 0.00600312f, 
    -0.03704334f, 0.01219246f, -0.00506582f, -0.03172813f, -0.00430060f, -0.03159951f, -0.02393949f, 0.00239338f, 
    -0.03863053f, -0.03095277f, -0.02045405f, 0.01066310f, -0.03022369f, 0.01576566f, 0.00140630f, 0.00139147f, 
    0.01828835f, 0.01503880f, 0.01172943f, 0.02819095f, -0.03129680f, 0.00495134f, 0.01495886f, -0.03193342f, 
    0.01664004f, 0.00425206f, 0.00857366f, 0.00929637f, -0.02637569f, 0.00394955f, -0.02973853f, 0.03697251f, 
    0.03523908f, 0.02786842f, 0.02930240f, 0.02743000f, 0.00780021f, 0.03325830f, -0.00344395f, -0.02790433f, 
    -0.02769702f, 0.02367752f, -0.03442318f, 0.01130289f, 0.00572213f, -0.03543663f, -0.02615288f, 0.02030677f, 
    0.00334634f, -0.00210366f, 0.02562249f, 0.02197162f, 0.03448049f, 0.00042667f, -0.03085005f, -0.03217561f, 
    0.01476337f, -0.03171886f, -0.01008923f, -0.02755352f, -0.01537590f, 0.00117136f, 0.03172168f, 0.03141318f, 
    -0.01198285f, 0.02519764f, -0.02118335f, -0.02955523f, 0.01502213f, 0.01091649f, -0.01725065f, -0.02602269f, 
    -0.01726136f, 0.00471706f, -0.04178908f, -0.01108010f, -0.02605819f, 0.00447379f, 0.01868915f, 0.02404984f, 
    0.02597832f, -0.02509801f, -0.00294427f, -0.03235919f, 0.01884288f, 0.01624556f, -0.00863498f, 0.02108032f, 
    0.01880625f, -0.01634217f, 0.01458746f, -0.00964921f, -0.00318877f, -0.04009834f, -0.03024655f, -0.01915354f, 
    -0.03010982f, -0.03350922f, -0.00617473f, 0.02640186f, 0.02733896f, -0.01352902f, -0.01672442f, 0.02357214f, 
    0.00845345f, 0.03439552f, -0.01770624f, 0.02911162f, -0.01797869f, 0.01686618f, -0.00393642f, 0.01163558f, 
    0.00240592f, -0.02957919f, 0.00207769f, -0.02920923f, 0.01037044f, -0.00977903f, 0.02233335f, -0.03675339f, 
    0.01454164f, 0.02619153f, -0.02223598f, 0.00442097f, 0.02048776f, -0.02565730f, -0.01476375f, 0.01021573f, 
    -0.02260236f, 0.03991415f, 0.03006756f, -0.00323340f, 0.00403950f, 0.00512493f, 0.03441363f, -0.02062611f, 
    0.02547292f, -0.02868283f, 0.01405856f, -0.03506558f, -0.03217036f, -0.01654583f, 0.02945508f, 0.00221939f, 
    -0.03155059f, 0.02355259f, -0.01438617f, -0.00766788f, 0.01349717f, -0.03459081f, 0.00091269f, -0.01460075f, 
    0.01025351f, 0.01182383f, -0.03499068f, -0.03375144f, -0.03883548f, 0.02125899f, -0.03368329f, -0.02762290f, 
    -0.02988543f, -0.00425022f, 0.03063243f, -0.02643825f, 0.01824416f, 0.02621342f, 0.01032788f, 0.00527188f, 
    0.00444698f, -0.01831086f, -0.02971416f, 0.01490444f, 0.00352984f, 0.02447791f, 0.00782686f, -0.02757466f, 
    0.01909333f, -0.02240553f, 0.00893595f, -0.00004787f, -0.02227946f, -0.01664575f, -0.01390976f, 0.02874158f, 
    0.00752576f, 0.00111082f, 0.04073377f, -0.00056247f, -0.04014014f, 0.01543047f, 0.03258263f, -0.00092583f, 
    -0.02553884f, -0.02840431f, 0.01782379f, 0.01600723f, 0.01147996f, -0.02404300f, -0.00412173f, 0.01160350f, 
    -0.02856276f, -0.01740874f, 0.03077176f, 0.00188565f, 0.03478056f, 0.02714294f, -0.03190431f, -0.03391426f, 
    -0.01970951f, -0.00979671f, -0.00595029f, 0.01695666f, 0.03129783f, -0.00829939f, 0.01532848f, -0.01647143f, 
    -0.03529566f, 0.02185235f, -0.00687259f, 0.01761618f, -0.02683649f, 0.03718298f, -0.00494151f, 0.00425955f, 
    -0.02093033f, -0.02688063f, 0.02132649f, 0.03392429f, 0.00316555f, 0.00846997f, -0.01349021f, 0.02092810f, 
    0.00423434f, 0.01119978f, 0.03009620f, -0.02546926f, -0.00710329f, 0.00263009f, -0.03687248f, 0.03173093f, 
    -0.02617443f, 0.02317583f, -0.03756482f, 0.00889372f, 0.00207905f, 0.00331870f, -0.02312963f, -0.00182760f, 
    -0.00420232f, 0.02591235f, 0.01001971f, -0.03572568f, 0.00934780f, -0.00804041f, -0.02127157f, -0.01559786f, 
    -0.00511010f, -0.02290797f, 0.02518327f, -0.01829395f, -0.00167131f, -0.00211623f, 0.00944029f, 0.00632740f, 
    0.00906295f, 0.01300434f, 0.01752541f, 0.01659865f, 0.01731897f, 0.00098806f, -0.02812297f, 0.00467934f, 
    0.03066360f, -0.02359783f, 0.00204035f, -0.01975522f, -0.02139915f, -0.04020405f, -0.00679144f, -0.01744514f, 
    -0.01529581f, -0.01864988f, -0.03314042f, -0.02329057f, 0.00371202f, -0.03654270f, -0.01153870f, 0.01915925f, 
    0.00190262f, -0.02216301f, -0.02504688f, -0.03923151f, -0.02568029f, 0.02231578f, -0.01750977f, -0.00028920f, 
    0.01852036f, 0.00233979f, -0.01665446f, 0.00741232f, -0.00133743f, -0.00150074f, -0.01832831f, -0.03403563f, 
    -0.01989202f, -0.00230927f, 0.02708845f, -0.02706804f, 0.02743416f, 0.01217674f, 0.00739627f, 0.01990904f, 
    0.00169123f, 0.00146190f, 0.00460184f, 0.01624073f, -0.00286323f, 0.01707643f, 0.02638431f, -0.04454335f, 
    -0.00992708f, 0.01572025f, 0.03094661f, 0.02243362f, -0.03790712f, 0.01107623f, 0.00369372f, -0.02876578f, 
    0.00072360f, -0.02896983f, 0.02429094f, 0.03100464f, -0.01962791f, 0.01271459f, -0.02832261f, 0.02002012f, 
    -0.03896293f, 0.02027901f, 0.02450794f, 0.02209911f, -0.01281884f, 0.00686105f, -0.01815052f, -0.00418505f, 
    -0.02010801f, -0.03736272f, -0.00283449f, 0.00303984f, -0.01075599f, -0.01655926f, -0.03616696f, -0.00189937f, 
    -0.03856710f, 0.00176201f, 0.01614374f, -0.00886624f, 0.01247322f, -0.02163720f, 0.00695665f, -0.00182663f, 
    -0.03258983f, -0.02070019f, -0.00613542f, 0.00904842f, -0.01438538f, -0.03116876f, -0.02617393f, -0.03428347f, 
    0.02500090f, -0.04210388f, 0.01287805f, 0.02841182f, -0.01023060f, -0.01853141f, -0.00495855f, -0.03062500f, 
    -0.00510483f, 0.01599249f, -0.02533153f, -0.02833166f, 0.00534034f, 0.02539927f, -0.00832160f, 0.02752654f, 
    -0.01482146f, 0.01048806f, 0.02390687f, -0.01564958f, 0.01369231f, 0.03144526f, 0.00127040f, 0.01862457f, 
    -0.00039564f, -0.03827294f, -0.00766289f, 0.01541139f, 0.02164012f, -0.03374337f, -0.00945720f, -0.00751273f, 
    -0.01794734f, -0.03089300f, 0.00033013f, -0.03659226f, -0.02712352f, 0.01256701f, 0.02184340f, 0.00559099f, 
    -0.02448864f, 0.00308457f, -0.02201062f, -0.00582091f, -0.01513340f, 0.01174265f, 0.03226626f, 0.01077302f, 
    -0.03231896f, 0.01506695f, -0.01235473f, -0.02791748f, -0.00789712f, -0.04062347f, -0.01867327f, -0.00018749f, 
    -0.02133252f, -0.01861468f, 0.01215700f, 0.00165392f, 0.01726955f, 0.00049309f, 0.00395193f, -0.02543703f, 
    0.01196449f, -0.02651312f, -0.00135209f, 0.03112145f, -0.00884412f, 0.01723865f, 0.02023139f, -0.03617711f, 
    0.01167051f, -0.00128344f, -0.03443341f, -0.04338067f, -0.00239941f, -0.01024704f, 0.00738672f, 0.01055829f, 
    0.02152412f, -0.00429850f, -0.03740076f, -0.00229120f, -0.00065411f, -0.03324350f, -0.02837097f, 0.01468779f, 
    -0.01137730f, -0.00825697f, 0.02043239f, -0.02699718f, -0.02733726f, -0.01958554f, 0.01223133f, 0.02473635f, 
    0.01427089f, -0.02365312f, 0.01984418f, -0.01715526f, -0.03342183f, -0.02890126f, 0.00257007f, 0.00301744f, 
    0.03103248f, 0.02719176f, -0.01630552f, -0.03360730f, 0.02858836f, 0.00148597f, 0.01752621f, -0.01469772f, 
    0.01718375f, 0.01810879f, -0.03794419f, -0.01563939f, -0.02989751f, -0.00775474f, -0.02791588f, 0.02308962f, 
    0.01101518f, 0.00529122f, -0.03610599f, -0.02104343f, -0.02603536f, 0.02211823f, 0.00255014f, -0.03578404f, 
    0.00967299f, 0.01437701f, 0.01412774f, -0.00235683f, -0.03313254f, -0.03035878f, 0.03062024f, 0.03091445f, 
    -0.04062238f, 0.02870980f, 0.02348222f, -0.00935442f, 0.00794804f, -0.00360191f, -0.00449233f, 0.00786506f, 
    0.01656809f, 0.00295187f, 0.01130133f, -0.01202340f, -0.00557789f, -0.01289564f, -0.00127834f, 0.00490187f, 
    0.01699202f, 0.00199438f, -0.03157045f, -0.02150110f, -0.00102881f, 0.00300096f, -0.01939952f, 0.03137463f, 
    0.00877257f, -0.03236291f, 0.01600878f, 0.00420667f, -0.02912526f, -0.03780190f, 0.03292152f, 0.01833337f, 
    0.00398063f, -0.01926341f, 0.02615920f, 0.00512028f, 0.02257218f, 0.02526616f, -0.00933979f, -0.01339459f, 
    -0.01391367f, -0.01179049f, 0.02476133f, 0.02110512f, 0.01139492f, 0.02439058f, 0.02838686f, -0.03680049f, 
    -0.00608849f, 0.02652613f, 0.02025419f, -0.01788487f, 0.01365387f, -0.04215854f, 0.02108642f, -0.02107633f, 
    -0.02694202f, 0.02182138f, 0.00636686f, -0.03813905f, 0.02799851f, -0.03566404f, 0.02766512f, -0.04299772f, 
    0.02559472f, 0.00235511f, -0.02241373f, -0.01993967f, -0.02581633f, -0.02206204f, 0.00112969f, -0.02823929f, 
    0.02993571f, 0.02626331f, 0.02042453f, -0.01371995f, -0.01008661f, 0.00140716f, 0.00051212f, 0.01511756f, 
    -0.03311216f, -0.00965702f, -0.02254898f, 0.01961353f, 0.01735678f, 0.01757643f, -0.02540145f, -0.01785315f, 
    -0.04154347f, 0.02624544f, -0.01649076f, 0.00212257f, 0.01369822f, -0.03453009f, -0.03713613f, -0.02945043f, 
    -0.04081155f, -0.00369651f, -0.04066956f, 0.01071641f, -0.04529096f, 0.00804896f, -0.02839404f, 0.02886669f, 
    -0.01975176f, 0.00714293f, -0.03083863f, -0.03226994f, -0.00824315f, 0.01029465f, -0.01751375f, -0.01246749f, 
    -0.03735597f, -0.01443621f, 0.02670068f, -0.04599810f, -0.03407399f, -0.02230532f, -0.01489636f, 0.01168822f, 
    0.01977654f, -0.03552122f, -0.02471300f, 0.00500247f, -0.00587838f, -0.01417782f, -0.00282257f, -0.01362344f, 
    0.01055543f, 0.03025682f, 0.02914609f, -0.03696756f, -0.00293825f, 0.03218413f, -0.03997257f, -0.00113512f, 
    -0.03520820f, -0.03058929f, -0.03899635f, -0.03918550f, -0.02039894f, -0.00624445f, -0.01572867f, 0.00512389f, 
    -0.01177781f, -0.02116740f, 0.00811090f, -0.01152732f, -0.02018033f, -0.02248711f, 0.01873025f, -0.02894005f, 
    0.01678337f, -0.02445174f, 0.00362093f, -0.01956540f, -0.03371719f, -0.03213489f, -0.01265064f, -0.03196859f, 
    0.01031676f, -0.04326960f, 0.02920578f, 0.01954047f, 0.02709230f, -0.03260068f, -0.03498134f, -0.02607243f, 
    0.02901766f, -0.00581569f, 0.02340651f, -0.02789599f, 0.00551572f, -0.03621260f, 0.02646844f, -0.02173988f, 
    0.00991739f, -0.01985927f, -0.03719259f, 0.01568571f, -0.01768271f, 0.02186470f, -0.00186416f, 0.00763473f, 
    -0.01290253f, -0.03481721f, 0.03061972f, -0.01065391f, 0.00942514f, -0.03170107f, -0.03410382f, -0.01777523f, 
    -0.00168001f, 0.02907475f, -0.03580026f, -0.00718340f, -0.03516778f, -0.03258014f, -0.03358270f, -0.00271401f, 
    -0.02749523f, -0.02494275f, -0.04338824f, -0.01593911f, -0.01401274f, 0.03246303f, -0.03324388f, 0.02578003f, 
    -0.00605644f, 0.02453805f, -0.01278334f, 0.01773605f, 0.01363103f, 0.01365856f, -0.02954623f, -0.00554857f, 
    0.00804379f, -0.02948654f, 0.00263527f, -0.01828048f, -0.00717195f, -0.04053292f, -0.03595945f, -0.01832715f, 
    0.00149660f, 0.00171747f, -0.03294821f, -0.00942144f, 0.02057615f, 0.01246750f, -0.00891692f, -0.02762946f, 
    -0.01889340f, 0.02950979f, -0.02799875f, -0.01304470f, 0.02219528f, -0.01825697f, -0.02770622f, 0.02935746f, 
    -0.03750496f, -0.04425167f, 0.00538449f, 0.00529215f, -0.02293794f, -0.01363439f, 0.02480299f, 0.02117593f, 
    0.00824916f, 0.00660489f, -0.03863465f, -0.02872305f, -0.01262798f, -0.03682374f, 0.00195302f, 0.00332532f, 
    -0.00983585f, -0.02700223f, -0.02421044f, -0.01701811f, 0.01766251f, -0.02942415f, 0.02830849f, -0.00983654f, 
    -0.03400187f, 0.01218930f, 0.02589159f, 0.02723195f, 0.01932716f, 0.00553347f, -0.01602886f, -0.01377770f, 
    -0.02644270f, 0.00499858f, -0.02594799f, -0.00582328f, -0.01994445f, 0.01145589f, 0.02765491f, -0.02289929f, 
    -0.02669461f, -0.02250678f, 0.00854954f, -0.01719819f, -0.01499839f, -0.02159577f, -0.01422647f, -0.01495776f, 
    -0.00655418f, -0.03912384f, 0.02856167f, -0.01066198f, -0.03814763f, -0.02843682f, -0.03350000f, -0.02812953f, 
    0.00321767f, -0.01974577f, -0.00811159f, 0.00323368f, 0.00440375f, -0.03136403f, 0.02625467f, 0.00973526f, 
    -0.00675187f, 0.02088902f, -0.01763408f, 0.01893302f, -0.00348095f, -0.01476625f, -0.03699004f, -0.01146578f, 
    0.01301783f, 0.01987764f, 0.02561216f, -0.01108734f, -0.00904017f, -0.01098074f, 0.03283268f, 0.00848522f, 
    0.00667882f, 0.00735796f, 0.00457219f, 0.02603612f, 0.01233558f, 0.02524020f, 0.02005410f, 0.02529490f, 
    0.02632932f, 0.01984557f, -0.03582608f, -0.02318762f, 0.01253378f, -0.03929563f, 0.01241880f, -0.00306758f, 
    -0.03238463f, 0.02837798f, -0.02792989f, -0.02993717f, -0.02239187f, -0.02706801f, 0.00293150f, 0.00341344f, 
    -0.03344624f, 0.02657701f, 0.02889936f, 0.02508118f, -0.00806241f, 0.02291778f, -0.00753804f, 0.02876694f, 
    0.01037018f, -0.00272089f, -0.00018786f, 0.01137846f, 0.01465045f, -0.00108746f, 0.01275743f, -0.00996996f, 
    -0.01632923f, 0.00443379f, 0.02119903f, -0.01728444f, -0.00643569f, 0.01180416f, -0.01152668f, 0.01071352f, 
    -0.02094461f, 0.01226947f, -0.02866253f, 0.00634170f, 0.00706685f, -0.01001776f, 0.02497319f, 0.01508367f, 
    0.02434755f, 0.01842418f, 0.00883578f, -0.03840272f, 0.02459607f, -0.02107226f, -0.03826915f, 0.01202938f, 
    0.03065264f, -0.03913679f, 0.02213249f, 0.02310173f, -0.02914239f, 0.00643364f, -0.00440249f, -0.02898872f, 
    -0.00137929f, -0.00407582f, -0.00978407f, -0.02583391f, -0.00789553f, -0.02835426f, -0.00784201f, 0.02344819f, 
    0.01744765f, -0.03171567f, -0.02459499f, -0.02733890f, -0.03660592f, -0.02560542f, 0.00478482f, 0.00192123f, 
    -0.00455932f, -0.02474434f, 0.01526175f, -0.02442967f, 0.00148966f, -0.00059400f, -0.03891900f, -0.01340689f, 
    0.02079674f, 0.00641019f, -0.03195868f, -0.01999894f, 0.02532679f, -0.01816241f, 0.01134029f, -0.02558664f, 
    -0.00554680f, 0.02793475f, 0.00396626f, 0.00195981f, 0.00737546f, 0.02184059f, 0.01001257f, -0.01508659f, 
    -0.02396234f, -0.02351131f, 0.00818188f, 0.00388551f, 0.01866823f, -0.01865986f, 0.01621558f, -0.01164986f, 
    -0.04049227f, -0.02043227f, 0.00002072f, -0.01431780f, -0.03058729f, 0.01088212f, -0.01260513f, 0.02599706f, 
    -0.02339189f, -0.00603320f, 0.00674811f, -0.03344625f, 0.01981663f, -0.03442556f, -0.03695647f, -0.03132685f, 
    -0.02083275f, -0.01393311f, -0.03010958f, 0.01808725f, 0.00401716f, -0.00737254f, -0.01520939f, -0.03329468f, 
    0.01332461f, 0.00507819f, -0.01288008f, -0.03744787f, -0.02822272f, -0.01706808f, 0.01172250f, -0.03937074f, 
    -0.01992055f, 0.03233847f, 0.02360620f, -0.00499281f, -0.00935811f, -0.01570723f, -0.03072190f, -0.03356754f, 
    0.00421964f, -0.03908136f, -0.01445194f, 0.01709765f, -0.01120833f, -0.03727414f, -0.03366207f, -0.02536269f, 
    0.00913937f, 0.02354626f, 0.01205593f, 0.01796512f, 0.00159406f, 0.03603779f, 0.00833670f, 0.02225078f, 
    -0.00685687f, -0.03780414f, -0.00570574f, -0.03766187f, -0.03421176f, 0.02055159f, -0.00256039f, 0.02454752f, 
    -0.10429206f, 0.03769382f, 0.02660694f, 0.02650625f, -0.01051262f, -0.14142287f, 0.00304333f, -0.00777187f, 
    0.11880763f, -0.00547643f, -0.03962209f, 0.04116384f, 0.09146767f, -0.03359253f, -0.06883522f, -0.06779235f, 
    0.07268509f, -0.06473187f, -0.10710356f, 0.04482412f, 0.01880313f, 0.03992727f, -0.02413031f, -0.04452331f, 
    0.12593471f, -0.11372257f, -0.03561191f, 0.04941411f, 0.01912749f, 0.08908310f, -0.03212221f, -0.11577355f, 
    0.08408593f, 0.01373299f, 0.08205644f, 0.02585323f, -0.02935307f, 0.17942983f, 0.02820130f, -0.24830201f, 
    0.00160530f, 0.03755252f, -0.03790236f, 0.11277668f, -0.01721269f, 0.03374333f, 0.01606883f, 0.10023911f, 
    -0.15785462f, -0.04532985f, -0.15244608f, -0.00521994f, 0.10933926f, 0.09362545f, 0.04890238f, 0.07955633f, 
    0.18785079f, 0.15973040f, 0.08717023f, -0.13772108f, -0.19189730f, -0.02896188f, 0.08012624f, 0.10272779f, 
    -0.06001452f, 0.02536593f, -0.02159734f, 0.08916657f, 0.04494163f, -0.00825884f, 0.00014607f, 0.05241716f, 
    0.03690262f, 0.11369460f, 0.15611014f, 0.13845947f, -0.00287435f, 0.07952999f, 0.11197013f, 0.03273484f, 
    -0.05466573f, 0.01084513f, 0.01384579f, 0.16887771f, -0.00812186f, 0.05370539f, 0.01555152f, 0.23149057f, 
    0.06845204f, 0.04874755f, 0.12770334f, -0.09048244f, 0.09131996f, 0.00738676f, 0.13111955f, -0.02710036f, 
    0.31198582f, 0.02282884f, -0.09311657f, -0.12231006f, -0.03562849f, 0.06738854f, 0.06746030f, -0.02362224f, 
    0.14297423f, 0.07094694f, 0.09963427f, 0.04225033f, 0.09085990f, -0.15567212f, -0.10181212f, -0.06238268f, 
    0.00343101f, -0.06450731f, 0.13570654f, 0.00539633f, 0.13792585f, 0.04694076f, 0.12944935f, -0.06208808f, 
    0.01082781f, 0.01737603f, 0.02734112f, -0.06481043f, 0.03819887f, 0.05234206f, 0.00559612f, -0.00221431f, 
    0.10108178f, 0.03758058f, -0.01952610f, 0.03655845f, -0.09643585f, 0.03040892f, 0.19841972f, 0.10990271f, 
    -0.01209253f, -0.08410399f, -0.06744988f, 0.04859578f, -0.11949853f, 0.07552066f, -0.02180777f, 0.18464470f, 
    -0.11804479f, 0.01007113f, 0.03367968f, -0.11575532f, -0.03591861f, 0.01968371f, 0.05689479f, 0.12527674f, 
    0.01974397f, 0.05505510f, -0.02038470f, -0.07481477f, -0.21757264f, 0.04749061f, 0.00645613f, 0.18178627f, 
    0.04716486f, -0.01859813f, 0.08614171f, 0.06087860f, 0.15734845f, 0.05694806f, -0.01114395f, 0.05990524f, 
    0.21722868f, 0.24447304f, 0.29011273f, 0.28474429f, -0.02885884f, -0.00961455f, 0.07805415f, 0.22357060f, 
    -0.08161485f, 0.00080836f, 0.05823333f, -0.06091372f, 0.46650195f, -0.13899934f, -0.08948524f, 0.19196856f, 
    0.17913295f, -0.04476483f, -0.05723824f, -0.07005736f, 0.05910023f, 0.01254481f, 0.02702359f, 0.03697522f, 
    0.18931910f, -0.17380705f, -0.17828296f, -0.10808098f, 0.07228394f, 0.00623884f, -0.04429891f, -0.07923941f, 
    0.16810600f, 0.06702314f, -0.00382609f, -0.06113208f, 0.28532097f, -0.06402499f, -0.03102392f, 0.43541130f, 
    0.08330735f, 0.00061364f, 0.01420818f, -0.03019763f, 0.13579363f, -0.04858297f, -0.06287098f, 0.01131108f, 
    0.21105011f, 0.04145278f, 0.19024599f, -0.12730941f, 0.11839198f, -0.03085436f, 0.04874120f, 0.12858610f, 
    0.11223221f, -0.03155300f, -0.01950133f, 0.08627912f, 0.13928942f, -0.15355352f, -0.11448290f, 0.41773161f, 
    0.03648541f, -0.01495540f, -0.01993238f, -0.00711551f, 0.08647633f, 0.09002216f, -0.02618293f, -0.01661199f, 
    0.27616280f, 0.18214889f, -0.07407091f, -0.17562875f, -0.02203993f, -0.08405601f, 0.11387512f, 0.03968585f, 
    0.07981430f, 0.15859054f, -0.11770527f, 0.06223055f, 0.10789620f, -0.05212174f, -0.06805641f, -0.06362550f, 
    -0.00876370f, 0.12724659f, 0.03010320f, 0.11695021f, 0.02624830f, -0.05367075f, 0.02901488f, -0.00471220f, 
    0.09500635f, 0.15810162f, 0.06864646f, -0.04974566f, -0.00543031f, 0.02577365f, 0.01494096f, 0.04496946f, 
    0.06315061f, 0.01831547f, 0.10492112f, -0.01159220f, 0.05594095f, 0.00571050f, 0.02445504f, 0.11620855f, 
    0.18168043f, -0.00658281f, -0.09276144f, 0.00577854f, 0.02558604f, -0.00707289f, 0.06019210f, 0.09050368f, 
    0.08806437f, 0.17791939f, -0.24498540f, 0.21982868f, 0.12854218f, -0.04070631f, 0.05127307f, 0.07601046f, 
    0.04050735f, 0.13178547f, -0.03187601f, 0.02473119f, 0.02260866f, 0.13232204f, 0.16998161f, 0.11037254f, 
    -0.14440787f, 0.03273757f, 0.06514227f, 0.14475168f, -0.04460358f, -0.06533643f, 0.12305760f, 0.04023525f, 
    0.00580813f, 0.03465674f, -0.08470762f, 0.26023000f, 0.07991491f, 0.07078432f, 0.02195850f, -0.04688675f, 
    0.15813957f, 0.02373688f, -0.01355841f, 0.07434145f, -0.12931341f, 0.01726211f, 0.01060581f, 0.03895743f, 
    0.11756216f, 0.07448052f, -0.00795242f, 0.06898195f, 0.01582251f, 0.00465683f, 0.09074365f, 0.00596641f, 
    -0.11186207f, -0.26910549f, -0.01780125f, 0.19585755f, 0.10719097f, -0.14606167f, -0.15353991f, 0.04470275f, 
    0.03441184f, 0.06020109f, 0.05419698f, 0.06043194f, 0.08125331f, 0.15311350f, 0.20463069f, 0.16525511f, 
    -0.10349912f, 0.04645173f, -0.16038786f, 0.13447006f, 0.06955533f, 0.08549500f, -0.01473653f, 0.09010960f, 
    0.01420162f, -0.22492459f, -0.13797663f, -0.03874522f, 0.14698492f, -0.06013861f, -0.08981099f, -0.01974029f, 
    -0.11973114f, 0.16727902f, -0.00705726f, 0.17266542f, -0.12710457f, 0.09821939f, 0.06898171f, -0.16445121f, 
    0.10790835f, 0.01257292f, -0.14681700f, -0.00693937f, -0.03407988f, 0.10203488f, 0.03496237f, 0.01614137f, 
    0.10814261f, 0.07067084f, -0.01666282f, -0.06984977f, 0.02303775f, -0.01912385f, 0.08220825f, 0.08267456f, 
    -0.00602111f, 0.21972506f, 0.00232119f, 0.07632044f, -0.07492772f, 0.17607230f, 0.06564009f, -0.18295456f, 
    0.03675680f, 0.11813553f, -0.09122457f, 0.05910511f, -0.10629215f, -0.08576056f, 0.06449904f, 0.10661722f, 
    0.24803996f, 0.14759348f, 0.33913481f, 0.32855535f, 0.06132765f, 0.06558125f, 0.03340733f, 0.30939370f, 
    -0.00582792f, -0.10342085f, 0.15731597f, -0.04941369f, 0.00872353f, -0.08448038f, 0.00714657f, -0.13056447f, 
    -0.10565060f, 0.12064158f, -0.01148361f, 0.03947211f, -0.04392883f, 0.02544129f, 0.00188603f, 0.16523889f, 
    -0.01295622f, 0.17877629f, 0.10273632f, 0.28240764f, -0.05527027f, 0.04979099f, 0.06586339f, 0.12735404f, 
    0.01512915f, 0.09295974f, -0.02774670f, 0.03244966f, 0.07700711f, 0.28667447f, 0.03888572f, 0.32994363f, 
    0.03892329f, 0.08018212f, -0.05084832f, 0.12888390f, 0.02411509f, 0.06006934f, 0.02088839f, 0.02933407f, 
    -0.10697130f, 0.11292434f, -0.12208673f, -0.13080697f, 0.14302637f, -0.06105040f, 0.04650980f, -0.05644068f, 
    0.08797284f, 0.15117683f, -0.01609438f, 0.02105657f, -0.08728320f, -0.15690660f, -0.12630828f, 0.03698540f, 
    0.10803717f, -0.15230611f, 0.01432235f, 0.16962308f, 0.17112069f, -0.01486322f, 0.17656457f, -0.06010944f, 
    -0.01042422f, 0.24554056f, 0.09211913f, -0.07936845f, -0.03947371f, 0.00151809f, 0.10354941f, 0.03754550f, 
    0.03525156f, 0.17468402f, 0.00287586f, 0.11279781f, 0.14880690f, 0.19220209f, -0.04085622f, 0.00609467f, 
    0.11736907f, -0.00319849f, 0.00642622f, -0.05870974f, 0.02432202f, 0.02473271f, 0.06209771f, -0.00130023f, 
    0.20245261f, 0.20985660f, 0.35337460f, -0.04790977f, 0.06509412f, 0.13273050f, 0.04373449f, 0.13239919f, 
    0.03328602f, -0.02869781f, -0.01009997f, 0.07159772f, -0.22588471f, 0.10039629f, 0.10208943f, 0.08787045f, 
    -0.02256567f, -0.10992603f, -0.06337789f, 0.01189158f, 0.12991476f, -0.05347504f, -0.06584481f, 0.04803605f, 
    -0.24103238f, 0.11645988f, -0.23268399f, -0.03456344f, 0.00958478f, -0.00180787f, -0.08737696f, 0.06979821f, 
    0.06480151f, 0.14128332f, -0.10715459f, -0.11661365f, 0.48943087f, -0.13466106f, 0.00000676f, -0.27047834f, 
    0.09501266f, 0.08982216f, -0.16630708f, -0.09690317f, 0.03382096f, -0.01968197f, 0.12585124f, 0.24292165f, 
    0.31396297f, -0.08587331f, -0.14090720f, -0.06934684f, 0.02233195f, 0.02576551f, -0.03874800f, -0.03276896f, 
    0.14916077f, -0.03383073f, -0.09013153f, -0.06241976f, 0.19587393f, 0.11138906f, 0.26188377f, 0.32668483f, 
    -0.03151939f, -0.03920780f, -0.04817874f, 0.14343905f, 0.02882433f, 0.02062279f, 0.01728330f, 0.09734887f, 
    0.32132155f, -0.10129005f, -0.09399717f, 0.01485994f, 0.17451030f, 0.13898048f, -0.01628428f, -0.06878596f, 
    0.00101015f, -0.01831434f, 0.09320832f, 0.02350428f, -0.01763263f, 0.12481992f, -0.08600481f, -0.13658498f, 
    0.07550230f, 0.08744942f, -0.03987212f, -0.07413215f, -0.01466084f, 0.03995861f, 0.12087256f, 0.06590302f, 
    0.01677483f, 0.02906967f, 0.09808576f, 0.03644287f, 0.04260946f, 0.06147821f, -0.03753335f, 0.04422070f, 
    0.04304246f, 0.03785999f, 0.07577121f, 0.06243613f, 0.36511719f, -0.16596095f, 0.24489588f, -0.08872352f, 
    -0.00709034f, -0.02885799f, -0.07151476f, 0.04703548f, -0.00912065f, -0.02759347f, 0.01481282f, 0.03807951f, 
    0.03355037f, -0.06764784f, -0.00562269f, 0.34505573f, 0.15000956f, 0.03804361f, -0.11684497f, -0.10508090f, 
    0.05574399f, 0.14596538f, 0.04151991f, 0.09572395f, 0.18139486f, 0.17702703f, -0.17659530f, -0.17952704f, 
    -0.03291951f, 0.02593809f, 0.00431811f, -0.04411428f, 0.04604497f, 0.07018550f, 0.04633211f, 0.07384653f, 
    0.26719743f, -0.06282501f, -0.02760902f, 0.00599466f, 0.10528914f, 0.06025199f, -0.19985023f, -0.10458214f, 
    0.09845833f, -0.08134807f, 0.14235640f, -0.04153526f, 0.08102956f, -0.23312515f, -0.25713658f, 0.11484080f, 
    0.11775111f, 0.00597395f, -0.05629097f, -0.02859143f, -0.03951937f, -0.02576301f, -0.05067968f, 0.08935727f, 
    0.05363478f, 0.03054557f, 0.12966737f, 0.13301608f, -0.12340060f, 0.05960782f, 0.02878047f, -0.02192619f, 
    -0.03276936f, 0.04228515f, 0.01401727f, 0.02557519f, 0.12716778f, -0.07979243f, 0.01447996f, 0.25044817f, 
    0.24400179f, 0.03394247f, -0.02492311f, -0.14678988f, 0.10769026f, -0.04382558f, 0.03681273f, -0.01344458f, 
    0.07453179f, 0.06596060f, 0.13116679f, 0.16495006f, 0.08332916f, -0.03598960f, -0.05131082f, 0.01087735f, 
    -0.03083943f, 0.00168757f, -0.00176103f, 0.03264444f, 0.15624741f, 0.22499892f, 0.06449628f, 0.10905053f, 
    0.02673458f, -0.00515474f, 0.07102507f, 0.12934047f, 0.00103119f, 0.05078045f, 0.02826228f, -0.06052100f, 
    -0.18190867f, 0.06252822f, -0.07241866f, -0.03913400f, 0.08278314f, 0.00568329f, -0.03945713f, 0.05108181f, 
    -0.08573268f, -0.02502086f, 0.07936601f, -0.09100569f, 0.05956513f, -0.05410368f, -0.06616712f, 0.03361702f, 
    0.12196390f, -0.08618432f, -0.08977025f, -0.04288691f, 0.05524950f, 0.02121828f, -0.01066653f, 0.07082267f, 
    0.05969154f, 0.09654307f, -0.06540287f, 0.02024421f, 0.00567072f, 0.08410723f, -0.06992270f, 0.01493429f, 
    0.05661615f, 0.05674569f, 0.09360952f, 0.14741513f, -0.24645135f, -0.13500647f, -0.06218566f, 0.03156968f, 
    0.07505853f, -0.05310074f, -0.07827357f, 0.02408824f, 0.06337023f, -0.01826198f, 0.18804692f, 0.06767226f, 
    0.02259016f, 0.00799857f, -0.02243087f, -0.01769423f, -0.02829225f, -0.00686801f, -0.03910453f, 0.00012172f, 
    0.01358386f, -0.03415858f, 0.01356633f, -0.01567562f, -0.00352513f, -0.02123938f, 0.01612210f, -0.00890661f, 
    0.00573823f, 0.02150741f, -0.02941108f, 0.02479805f, -0.01265357f, 0.02130173f, -0.03367014f, -0.02273672f, 
    -0.00350461f, -0.01529314f, 0.02772009f, -0.01267733f, 0.02079153f, 0.01028713f, -0.00866863f, -0.01825413f, 
    0.01441472f, 0.00268112f, -0.03603180f, -0.02044038f, -0.01349071f, 0.02429569f, -0.03628942f, -0.03886386f, 
    -0.00532522f, -0.02567723f, -0.02708327f, -0.01895197f, -0.02635075f, -0.00136719f, 0.00334570f, -0.02015525f, 
    -0.03236894f, 0.02282816f, -0.03581949f, -0.04118704f, -0.00428849f, -0.01559774f, -0.02121536f, 0.00326129f, 
    0.00780838f, -0.02486279f, -0.02435150f, -0.03768898f, -0.02292505f, 0.00657222f, -0.01886901f, 0.03292546f, 
    0.01536190f, 0.02411714f, -0.01999791f, -0.01874667f, -0.02434869f, 0.01162078f, -0.02380587f, -0.01895539f, 
    0.03041676f, 0.02591987f, 0.03045199f, -0.00450892f, 0.00749881f, 0.00131454f, -0.01479140f, -0.03303311f, 
    -0.03647972f, -0.02525256f, 0.03310502f, -0.00842109f, 0.02984175f, 0.02125208f, 0.00365871f, 0.00228090f, 
    0.03223775f, -0.00664734f, 0.00418395f, 0.01602085f, 0.02495763f, -0.04141237f, 0.00850709f, 0.02936177f, 
    0.02691594f, 0.00532351f, -0.00216116f, -0.02035859f, -0.00354198f, 0.01523737f, -0.03631671f, 0.02107359f, 
    0.01894588f, -0.03320750f, -0.01314277f, -0.04125088f, 0.00773835f, -0.00270935f, -0.02306262f, -0.00684700f, 
    0.02053672f, -0.03497718f, -0.00025621f, -0.00106525f, 0.01339620f, -0.00347854f, -0.03434690f, 0.02857516f, 
    -0.02039671f, -0.02361104f, 0.01175102f, 0.02516612f, -0.01135953f, -0.00465852f, 0.02293155f, -0.01944591f, 
    0.00271884f, -0.02453734f, 0.02540927f, -0.01183378f, -0.03968382f, 0.00142410f, -0.02055255f, -0.02473819f, 
    0.01592078f, -0.02017794f, -0.03218532f, -0.03698728f, 0.00817119f, 0.00444793f, -0.01734098f, 0.00883850f, 
    -0.00485270f, -0.00933338f, 0.01575713f, 0.00237117f, 0.00773116f, -0.01394229f, -0.02995711f, -0.03172560f, 
    0.02067997f, -0.01506991f, -0.04049043f, 0.00564856f, -0.03547591f, -0.02707390f, -0.00938365f, 0.00874430f, 
    -0.01377381f, -0.03448428f, -0.02900684f, 0.02819338f, -0.02724301f, -0.01789322f, 0.00158413f, 0.00880304f, 
    -0.04066844f, 0.01798815f, -0.00695872f, 0.01212116f, -0.00745559f, -0.01584235f, -0.03891280f, 0.01053577f, 
    0.00485546f, -0.03630403f, -0.01195586f, -0.03813124f, -0.03069582f, -0.01697502f, 0.02099317f, -0.01734661f, 
    -0.02997032f, 0.02727034f, -0.02489818f, -0.03128261f, 0.00782707f, -0.00946930f, -0.02370278f, -0.01608229f, 
    0.00948145f, -0.03583376f, 0.03027194f, -0.03639981f, -0.00741688f, -0.01482891f, 0.03047068f, -0.04020429f, 
    -0.03156888f, 0.01039947f, 0.00674870f, 0.02822176f, -0.01208869f, -0.03266783f, 0.00806307f, -0.04142784f, 
    -0.00021815f, -0.02929773f, -0.00686938f, 0.02047694f, -0.02057486f, -0.02650409f, -0.02587736f, -0.00105489f, 
    -0.03283886f, -0.04087983f, -0.04096322f, 0.00160656f, 0.00065453f, 0.02693451f, -0.03407895f, 0.02723381f, 
    0.01319503f, -0.02298390f, 0.01588259f, -0.01737847f, -0.02240193f, 0.02650489f, 0.02605494f, 0.02390617f, 
    0.02997990f, -0.01452855f, -0.01705431f, 0.00804200f, -0.01228087f, 0.01014940f, -0.03068279f, -0.03631618f, 
    0.01927071f, 0.01166945f, 0.01884849f, 0.02609286f, -0.02849477f, -0.03793250f, 0.00850242f, 0.00525603f, 
    -0.02052996f, 0.00824305f, -0.02301660f, -0.03608953f, -0.00487693f, 0.01321063f, -0.03573459f, 0.00427517f, 
    -0.01794067f, -0.02816557f, 0.02499128f, -0.00529711f, -0.00810437f, 0.00661775f, -0.02370227f, -0.01709708f, 
    0.01677171f, -0.01509371f, -0.03242736f, -0.03296731f, 0.01842852f, -0.02391511f, -0.02911079f, 0.00568697f, 
    0.02566321f, -0.04038078f, -0.02150611f, -0.02852162f, 0.00564964f, -0.02790895f, -0.01465418f, -0.03039377f, 
    0.01550781f, -0.03249569f, -0.01489067f, 0.02613869f, 0.00169323f, -0.03180027f, 0.02845096f, -0.01997923f, 
    -0.01626821f, 0.00188467f, -0.03133903f, 0.00248403f, -0.02654972f, 0.01343490f, 0.01550903f, -0.01273236f, 
    0.01291905f, -0.00870354f, 0.01633594f, -0.01069736f, -0.01834373f, -0.02401370f, -0.03706220f, 0.02592618f, 
    -0.01218945f, 0.02533745f, -0.00680390f, 0.00058223f, 0.00114632f, 0.02879959f, -0.01983039f, 0.02610733f, 
    0.01766078f, -0.00960373f, -0.00963845f, -0.01884997f, 0.02264682f, 0.02964119f, 0.01135722f, -0.00964303f, 
    0.01095446f, -0.00003874f, -0.02243017f, -0.03634853f, -0.02810654f, 0.00397094f, 0.02666528f, 0.00991577f, 
    -0.00236014f, 0.01701878f, 0.02066223f, -0.03244227f, 0.00164459f, 0.00239132f, 0.01092695f, 0.01082857f, 
    -0.00524476f, 0.02213512f, 0.00808970f, 0.02850185f, -0.04094200f, -0.01823307f, 0.00024685f, -0.03481445f, 
    0.00923982f, -0.01224907f, -0.00440332f, 0.00079468f, -0.03605687f, 0.01118149f, 0.00575104f, -0.00477805f, 
    -0.02903689f, -0.04109153f, -0.02222911f, -0.01988633f, 0.00604310f, -0.01362831f, 0.00761383f, -0.01475742f, 
    -0.02216362f, -0.01770852f, -0.02467001f, 0.01715490f, 0.00871043f, -0.04052559f, -0.03373850f, 0.03020636f, 
    -0.03636562f, 0.01075179f, -0.03772201f, -0.03045199f, -0.02615145f, 0.02565898f, -0.01734722f, 0.01389457f, 
    -0.00097042f, -0.01135596f, -0.02969231f, -0.00337588f, -0.01560257f, -0.01504737f, -0.01094862f, 0.02291603f, 
    -0.01007539f, -0.03055038f, 0.01678342f, -0.00220717f, -0.00520670f, -0.02993851f, -0.03578149f, -0.03785893f, 
    -0.01817896f, -0.00304613f, -0.03483728f, -0.01289078f, 0.00236028f, 0.02755353f, -0.02186701f, 0.01665520f, 
    -0.01279100f, 0.01022383f, 0.01994686f, -0.00099727f, 0.00366434f, -0.00179547f, 0.02653394f, 0.00748705f, 
    -0.01526268f, -0.00318356f, 0.02238230f, 0.01602265f, -0.00835488f, -0.00126224f, -0.03810987f, 0.00647302f, 
    -0.00263327f, -0.01220019f, -0.03186898f, 0.00958439f, -0.01338835f, -0.03349066f, -0.00995632f, 0.01034235f, 
    0.00981933f, -0.01363497f, -0.02205110f, -0.01478256f, 0.01417124f, 0.02561231f, 0.00799050f, 0.02000330f, 
    -0.01873926f, -0.00315850f, -0.04035470f, -0.03984367f, -0.02354454f, 0.00411932f, -0.03582510f, -0.02635994f, 
    0.00817449f, -0.03130474f, 0.00463123f, -0.03056063f, -0.01228895f, 0.00687647f, -0.02155978f, -0.01454543f, 
    -0.03844554f, -0.01223187f, -0.02974056f, -0.01791469f, -0.01530593f, -0.03730860f, 0.00024168f, -0.00895478f, 
    -0.02700971f, 0.01886357f, 0.02944648f, -0.02879117f, -0.02743100f, 0.02018052f, -0.03638879f, -0.01882950f, 
    0.03043445f, 0.03469128f, 0.00056149f, -0.00521968f, -0.02674344f, -0.00191589f, 0.00953361f, 0.02455682f, 
    -0.03505587f, -0.03294938f, -0.03017982f, 0.02021748f, 0.00620165f, -0.02550422f, -0.00469525f, -0.04006756f, 
    -0.00818415f, -0.03182063f, -0.02191877f, -0.03466576f, -0.00798588f, -0.01371178f, 0.00656490f, 0.01595702f, 
    0.01958368f, -0.03337429f, 0.01435232f, 0.01268209f, 0.01410841f, -0.03151140f, 0.02356527f, -0.00204895f, 
    -0.04023948f, -0.01561594f, 0.01166817f, 0.00582398f, 0.01730276f, 0.03013150f, 0.01506589f, 0.00768624f, 
    -0.01845455f, -0.03903250f, -0.00528532f, -0.02410908f, 0.03527102f, -0.02784822f, 0.02476707f, 0.01305401f, 
    0.02762963f, -0.03938855f, 0.02951946f, -0.03632885f, -0.00942936f, -0.02577414f, 0.00520301f, 0.01920664f, 
    0.01455791f, 0.00617276f, 0.01503952f, -0.00491357f, 0.01873842f, -0.00272617f, -0.01808886f, 0.00453481f, 
    -0.01041217f, -0.03313741f, 0.01830624f, 0.01291655f, 0.00268994f, -0.00583863f, 0.02829135f, -0.00640889f, 
    -0.04007468f, -0.02309332f, 0.02243605f, -0.01045852f, 0.01965709f, -0.03126492f, -0.03458674f, 0.01936754f, 
    0.01792516f, 0.02971657f, -0.04031775f, -0.02395976f, -0.02669540f, -0.02812313f, 0.01381833f, -0.01926140f, 
    -0.01737554f, -0.01019284f, -0.00341127f, -0.02123996f, -0.00873481f, -0.02415162f, 0.01590448f, -0.02297426f, 
    -0.00526537f, -0.01243460f, -0.03687561f, 0.01925565f, 0.00154073f, 0.02420492f, -0.01816345f, 0.00381797f, 
    -0.02892334f, -0.02310141f, -0.02989158f, 0.01125052f, -0.00002403f, -0.01247493f, -0.01905769f, -0.00072989f, 
    0.02391680f, 0.00625455f, 0.02141947f, -0.03389372f, -0.00365375f, -0.01016975f, -0.01787411f, -0.00809559f, 
    0.01980515f, -0.01314029f, -0.00269344f, 0.01708873f, -0.03352955f, -0.00419453f, -0.03717794f, 0.01747487f, 
    -0.02855512f, 0.02497871f, -0.01128452f, -0.02768482f, -0.02370858f, -0.03057325f, 0.01096408f, 0.00045985f, 
    -0.03705197f, 0.02610055f, 0.00009539f, 0.01038150f, -0.01548324f, -0.00793592f, -0.01461375f, -0.04089079f, 
    0.01807818f, 0.02709553f, -0.03957360f, -0.03978188f, -0.01191937f, -0.00647342f, 0.00292919f, -0.03499526f, 
    -0.03884013f, -0.00015359f, -0.00135629f, 0.01922958f, -0.03851838f, -0.02922182f, 0.00684884f, -0.02125519f, 
    0.01712684f, -0.03268376f, -0.03775546f, 0.03016537f, -0.00000755f, 0.01377480f, 0.02660870f, -0.03226467f, 
    -0.02975247f, 0.00468795f, 0.00634432f, 0.01497737f, -0.00673799f, -0.02376570f, -0.00393675f, 0.01355778f, 
    -0.02577274f, -0.01723644f, -0.01085234f, 0.00678135f, 0.01064260f, 0.02762090f, -0.02466526f, -0.00642963f, 
    0.00420516f, -0.03456672f, -0.00268911f, -0.01396293f, 0.02553081f, -0.02974660f, -0.03502023f, -0.01433042f, 
    0.03241684f, 0.02202712f, -0.01615062f, -0.02031252f, -0.03236026f, 0.01603980f, -0.00175426f, -0.01869729f, 
    0.00279863f, -0.02921566f, 0.02717038f, -0.03674574f, 0.02232045f, 0.02023834f, 0.00733706f, -0.00959048f, 
    -0.01448718f, 0.01446071f, -0.01482271f, -0.02012648f, -0.01858145f, 0.02240616f, 0.00005296f, -0.02599186f, 
    -0.03480713f, -0.04076837f, -0.03098321f, -0.03322402f, -0.02312328f, -0.02385469f, -0.01265278f, 0.01935409f, 
    -0.02255120f, 0.02050205f, 0.02706647f, 0.00677256f, -0.03711824f, 0.00604710f, 0.03519074f, 0.01624795f, 
    -0.02228498f, -0.01297054f, 0.01982791f, -0.01011075f, -0.00295344f, -0.02874951f, 0.00964952f, -0.02675359f, 
    0.01713373f, -0.00446606f, -0.02365317f, 0.01748472f, 0.02519347f, -0.00777957f, -0.03608029f, 0.00120343f, 
    0.01448002f, -0.02747202f, 0.01649674f, -0.02996982f, 0.00200986f, 0.01180581f, -0.03951006f, -0.04101085f, 
    0.01423777f, 0.00926961f, 0.02607852f, -0.01385631f, -0.03022677f, 0.02166908f, 0.02166437f, 0.00426432f, 
    -0.00938770f, 0.01946082f, -0.03196279f, 0.00598843f, 0.00650395f, 0.02474252f, 0.00676619f, -0.00670246f, 
    0.01212173f, 0.02332817f, -0.00418058f, -0.00966868f, 0.01484797f, -0.03919178f, 0.00301804f, -0.01185853f, 
    0.02899286f, 0.01374309f, 0.01123140f, 0.02351792f, -0.02073190f, -0.03580092f, 0.00040369f, -0.03923739f, 
    -0.01223783f, 0.02572770f, -0.01628968f, -0.01186081f, -0.02452698f, -0.00676488f, -0.03351891f, -0.00660411f, 
    0.03037683f, -0.02118079f, -0.00602608f, -0.03299813f, -0.01758381f, 0.00266167f, -0.00297366f, 0.03027771f, 
    0.02385288f, 0.01029060f, -0.03097230f, -0.00836165f, -0.00863478f, -0.02776165f, -0.01070157f, -0.03452719f, 
    -0.02100052f, -0.02398859f, 0.02862952f, -0.03298755f, -0.01454637f, -0.01051768f, -0.01750633f, 0.02649602f, 
    0.01822211f, 0.01018749f, -0.01399780f, -0.01256144f, 0.02281218f, -0.01573798f, -0.03714968f, 0.01233964f, 
    -0.00697347f, 0.03214091f, -0.00980022f, -0.01990490f, -0.03968062f, -0.02643052f, -0.01646542f, -0.02626272f, 
    -0.01628584f, 0.00698370f, 0.01279984f, -0.03019422f, 0.01763373f, -0.01100550f, -0.03687521f, -0.00877767f, 
    0.02953156f, -0.03169205f, 0.03365901f, 0.01141264f, -0.01421447f, -0.01145821f, -0.04150064f, -0.00614782f, 
    -0.00983959f, 0.00227523f, -0.03552159f, -0.02888336f, 0.00737117f, 0.01044939f, -0.02216139f, -0.02769623f, 
    -0.02933875f, -0.03390688f, 0.02622152f, 0.01651021f, 0.02060027f, 0.02623476f, -0.02705635f, -0.04332787f, 
    -0.02860138f, -0.02846253f, -0.00001961f, -0.03855760f, -0.00813903f, -0.00622798f, -0.00069624f, -0.03825706f, 
    -0.00523657f, 0.01433404f, -0.01206051f, -0.04026898f, 0.01185169f, -0.02590100f, -0.01265961f, -0.00269538f, 
    0.01645993f, -0.03494436f, -0.03578123f, -0.02599882f, -0.00669571f, 0.00387163f, 0.02667360f, -0.01720038f, 
    -0.00035240f, -0.03269386f, -0.03319021f, -0.04298299f, -0.00702589f, 0.00135802f, -0.03651097f, 0.01359340f, 
    -0.02716359f, 0.01939500f, -0.00800986f, -0.01991732f, -0.00264383f, -0.00055267f, -0.02126641f, 0.01691466f, 
    -0.01365004f, -0.04445187f, 0.00494522f, 0.01594453f, 0.01719654f, 0.01711121f, -0.01819678f, 0.02573952f, 
    0.00748378f, 0.02294698f, 0.00734073f, 0.02301443f, -0.02043196f, -0.02978024f, -0.03023986f, -0.02673300f, 
    0.01012933f, -0.03032929f, -0.01147928f, 0.01214534f, 0.00143538f, 0.01636215f, -0.03000052f, -0.00942090f, 
    -0.03433315f, -0.00670077f, 0.02451224f, -0.03730200f, -0.03461485f, -0.02459860f, -0.02327713f, -0.01859685f, 
    0.03489379f, 0.02749417f, -0.02883685f, -0.01101456f, -0.01389544f, 0.01812364f, -0.02215464f, 0.00368729f, 
    0.01612082f, 0.01025122f, -0.02183630f, 0.00007551f, -0.02575755f, -0.02111494f, 0.00249310f, -0.02045841f, 
    -0.01527465f, -0.02056695f, 0.01653527f, -0.00426328f, 0.00357328f, -0.04053852f, -0.03296061f, -0.02211897f, 
    0.01881408f, -0.02987585f, -0.03645605f, 0.00997475f, -0.03204353f, 0.00496774f, -0.00490224f, 0.01701897f, 
    -0.02432400f, -0.03415680f, -0.00801160f, 0.01959878f, -0.04211857f, -0.04208737f, -0.01928105f, -0.03198764f, 
    -0.01397913f, 0.01157116f, -0.03048957f, 0.00358106f, -0.00667240f, 0.01153910f, -0.01345535f, -0.01102240f, 
    0.01278342f, 0.02717808f, -0.03354116f, 0.02772441f, 0.02682489f, -0.04140820f, 0.00434525f, -0.00840109f, 
    -0.02054848f, -0.04222753f, 0.01511409f, 0.02481165f, -0.00064397f, 0.01120462f, 0.01893172f, -0.03477064f, 
    0.02194971f, -0.01560680f, -0.00705232f, -0.03587625f, 0.01884035f, -0.01999858f, -0.03351176f, -0.01671568f, 
    -0.03417859f, -0.03867924f, 0.02883461f, 0.01592026f, -0.00134467f, -0.01267340f, 0.00963828f, 0.00433818f, 
    -0.02377590f, -0.00621096f, -0.00359100f, -0.02357460f, -0.02283862f, 0.01643120f, -0.00198535f, 0.02792737f, 
    -0.00852535f, 0.02277180f, -0.04386235f, 0.00093109f, -0.04096798f, -0.03230303f, 0.02526937f, -0.02293563f, 
    -0.03121939f, -0.02160866f, 0.02126637f, -0.00037164f, -0.04108236f, -0.02383567f, -0.03190202f, 0.02424465f, 
    -0.01530662f, -0.00550137f, -0.01466319f, -0.00694533f, -0.00429249f, 0.01064947f, -0.03052459f, -0.00912611f, 
    0.02695680f, -0.00065938f, 0.02246488f, -0.00767021f, -0.01342011f, -0.03861931f, -0.00755765f, -0.01564298f, 
    0.00155080f, -0.02883843f, -0.03783828f, -0.00993565f, 0.01209716f, -0.01539065f, -0.03245491f, 0.00998216f, 
    -0.03307390f, -0.02237855f, -0.01732571f, -0.00466907f, 0.02282187f, 0.02143673f, 0.01409435f, 0.02553560f, 
    0.01729882f, -0.03607679f, -0.02002157f, -0.01884041f, -0.02625434f, 0.01534223f, -0.02124281f, -0.01903544f, 
    0.02603265f, -0.00286953f, -0.02127528f, 0.01922948f, 0.00410309f, 0.03463805f, -0.01632407f, -0.01290689f, 
    -0.02123373f, -0.02432058f, -0.01318643f, -0.01726843f, -0.04412492f, -0.02977154f, 0.01236743f, -0.00839920f, 
    0.00745635f, 0.00251659f, 0.02386320f, -0.00522927f, -0.02658906f, -0.01145015f, -0.00234026f, 0.02303955f, 
    -0.03819822f, -0.00951488f, -0.01714375f, -0.01816763f, 0.01405820f, -0.02193040f, 0.02119919f, 0.01440404f, 
    0.00757051f, -0.01339210f, -0.01629920f, -0.02966866f, 0.02282898f, -0.02147561f, 0.00364231f, -0.00948757f, 
    -0.02764519f, -0.02273982f, -0.02100274f, 0.00112144f, 0.03016438f, -0.00840326f, 0.00968721f, -0.02205608f, 
    -0.01802855f, 0.01842166f, -0.02554189f, 0.01511196f, 0.02174273f, -0.02955295f, -0.02745929f, -0.02921631f, 
    0.02104884f, 0.02527980f, -0.00899705f, -0.03030861f, -0.04396225f, 0.00220458f, -0.01183768f, -0.01991528f, 
    -0.04265856f, 0.01565012f, 0.01328519f, 0.01299103f, -0.02390909f, 0.02301253f, 0.00080357f, -0.02026360f, 
    0.00252247f, 0.02292546f, -0.00805591f, -0.00822405f, 0.01289793f, -0.02939400f, -0.03108963f, -0.01978315f, 
    0.03101315f, 0.01475696f, -0.01834042f, 0.00906528f, 0.03029573f, 0.02186889f, 0.02975836f, 0.00429285f, 
    -0.00707103f, 0.01774269f, -0.02379635f, -0.01542003f, 0.01759105f, -0.02962008f, 0.02764258f, 0.01567122f, 
    -0.00711847f, 0.00643991f, 0.01138615f, -0.01596538f, 0.02235286f, -0.04331129f, -0.03081588f, 0.00138546f, 
    -0.03561867f, -0.03709697f, -0.00558613f, -0.03688180f, -0.00623396f, -0.01374228f, -0.01076184f, -0.00974532f, 
    -0.02685555f, 0.01835958f, 0.01753333f, 0.03213551f, 0.01949904f, 0.01098432f, -0.02972238f, -0.01513652f, 
    0.00955774f, 0.01848341f, 0.01009953f, 0.02350002f, 0.02620164f, 0.01761056f, -0.00262170f, 0.02407759f, 
    -0.02090824f, -0.01913308f, -0.00586095f, 0.00819202f, -0.00784209f, -0.02286243f, 0.01590089f, 0.01204408f, 
    0.01623418f, -0.01930296f, 0.00384944f, -0.00813195f, 0.01742164f, 0.01004729f, -0.01792071f, -0.02497101f, 
    -0.03587298f, -0.03791564f, 0.02414131f, -0.00629155f, -0.02303436f, -0.03736582f, 0.02505696f, 0.00647561f, 
    0.00998316f, -0.03479977f, -0.01309187f, -0.00965257f, -0.04289878f, 0.01231054f, 0.01530044f, -0.01054490f, 
    -0.03866814f, -0.02330799f, 0.02140654f, 0.01541666f, 0.00083319f, 0.02994561f, -0.01083566f, -0.03698980f, 
    -0.01901780f, 0.00547365f, -0.02530175f, -0.02284930f, 0.01341080f, -0.02075883f, 0.02143913f, 0.02873013f, 
    -0.03614900f, 0.01433381f, 0.01749084f, -0.02223426f, -0.00470224f, -0.02712981f, 0.01545192f, -0.04206801f, 
    0.02316311f, 0.01682623f, -0.00333194f, -0.01252184f, 0.00144398f, 0.00948459f, 0.03212791f, -0.03060959f, 
    -0.03146083f, 0.02104446f, -0.01987958f, 0.00512098f, 0.01068223f, -0.02947680f, 0.02607358f, -0.04124055f, 
    -0.02643777f, -0.03951323f, 0.02293234f, -0.00305163f, 0.02433871f, -0.00094841f, -0.03707257f, -0.01807309f, 
    -0.01329988f, -0.03736502f, 0.02654664f, 0.00385030f, -0.01301653f, 0.01089150f, 0.00837030f, 0.00302766f, 
    0.02302140f, 0.01559435f, -0.00059095f, 0.01060378f, -0.02420769f, -0.00215370f, -0.03137023f, 0.02626039f, 
    -0.00271705f, -0.01451862f, -0.02725100f, -0.01576696f, -0.00139661f, 0.02538443f, -0.02858175f, -0.00941253f, 
    0.01525378f, -0.03182694f, 0.01167796f, 0.00713065f, -0.03803350f, 0.01013129f, -0.00034773f, -0.01940086f, 
    -0.02166519f, 0.01693895f, 0.03520556f, -0.01513098f, -0.01494066f, -0.00925186f, 0.02286661f, -0.01357080f, 
    -0.02091724f, -0.02741573f, 0.02987586f, 0.00914250f, 0.02480408f, 0.01875680f, 0.00176215f, 0.02377455f, 
    0.02046996f, 0.02310093f, -0.02194946f, 0.00504374f, -0.01178542f, -0.01059090f, -0.00146842f, 0.00653564f, 
    0.03101720f, 0.01031827f, 0.01084859f, -0.00363722f, -0.03969966f, 0.01219008f, -0.00924895f, -0.01702016f, 
    -0.01808641f, 0.00252919f, 0.00244867f, -0.01870838f, -0.04013205f, -0.02403577f, 0.01754253f, 0.02048932f, 
    -0.01977609f, -0.00701558f, -0.04289337f, -0.00978293f, 0.01222148f, 0.00551229f, 0.01694177f, 0.01121687f, 
    -0.00468590f, 0.01883887f, -0.03068697f, 0.01808175f, 0.00183428f, -0.00663200f, 0.02815532f, -0.02926242f, 
    -0.02390790f, -0.00316025f, -0.02661527f, 0.00935060f, -0.02781207f, -0.02137358f, -0.02570033f, 0.00679853f, 
    -0.04036217f, 0.02017447f, 0.01849878f, 0.02379318f, -0.00942631f, 0.02686373f, -0.01710169f, -0.01130386f, 
    -0.04007179f, -0.03862744f, 0.01040699f, -0.01709046f, -0.01639397f, 0.02383015f, -0.01322958f, -0.02533843f, 
    0.01582356f, -0.01236624f, -0.02131590f, 0.03015297f, 0.01000839f, 0.01645568f, -0.02021496f, 0.02346179f, 
    0.01820249f, 0.02213155f, -0.00541681f, 0.00366767f, -0.03668099f, 0.00412134f, -0.01191108f, -0.01187090f, 
    -0.02098695f, -0.01572198f, 0.02229051f, -0.01858264f, -0.02164886f, -0.02268081f, -0.00234712f, -0.03347013f, 
    -0.00310277f, 0.00512476f, -0.03460454f, -0.03588896f, -0.00502034f, -0.03576998f, -0.02811211f, -0.02035387f, 
    -0.01187757f, -0.00212935f, 0.00975354f, -0.03323974f, 0.00784159f, 0.00958356f, 0.03076983f, -0.03231036f, 
    -0.03155627f, 0.01839622f, 0.00949160f, -0.01051450f, 0.00069614f, -0.00328144f, -0.03389305f, -0.02777801f, 
    -0.02323593f, -0.01683216f, -0.02137162f, 0.03157420f, 0.01070002f, 0.01695247f, -0.03487605f, -0.03922051f, 
    -0.02434670f, -0.00857893f, -0.01550530f, 0.00612785f, 0.00429641f, 0.02211172f, -0.01867350f, 0.01515671f, 
    -0.04135616f, -0.01737996f, -0.02320778f, -0.00798041f, 0.00399012f, 0.01467237f, -0.00219963f, -0.01604569f, 
    -0.00494251f, -0.02491491f, -0.04043705f, -0.03467405f, -0.04153884f, -0.02419600f, 0.02732177f, -0.02484958f, 
    0.01083417f, -0.00103971f, 0.01107364f, 0.01215850f, 0.02971945f, -0.03852154f, -0.02490007f, 0.02567666f, 
    -0.00767066f, -0.02045816f, 0.00447693f, -0.03611366f, 0.01008784f, 0.01101303f, -0.00972650f, 0.02817121f, 
    0.02633851f, -0.00214973f, -0.02088568f, -0.03423971f, 0.01520802f, 0.01865220f, 0.01985743f, -0.00251890f, 
    -0.02563962f, 0.01531226f, 0.01736518f, -0.00817547f, 0.01591699f, -0.00220623f, -0.03542006f, -0.01968019f, 
    -0.03805694f, -0.02893740f, 0.00400124f, -0.00631306f, -0.01256151f, -0.03847586f, 0.00965987f, 0.02414110f, 
    0.03045402f, -0.02784645f, 0.00990426f, 0.02932352f, -0.03471901f, 0.02867774f, 0.02397522f, -0.04216575f, 
    -0.01564370f, -0.01028925f, -0.00538765f, -0.01213769f, -0.02029692f, 0.02511186f, -0.03617491f, 0.00638151f, 
    -0.03782734f, -0.03055884f, -0.02233976f, -0.02679815f, 0.01368960f, 0.01231373f, 0.01212409f, 0.02168464f, 
    -0.02772662f, 0.02140353f, 0.02044604f, -0.00619233f, -0.01100479f, -0.02951367f, 0.00864838f, -0.02299655f, 
    -0.03678866f, 0.00060645f, 0.00960270f, -0.03035946f, -0.01273154f, -0.02350801f, -0.03122498f, -0.02877721f, 
    -0.01360392f, -0.03206033f, 0.01699407f, -0.02785828f, -0.00179673f, -0.02338891f, -0.01592109f, 0.01065846f, 
    0.04973397f, 0.01898346f, 0.05257836f, 0.08220865f, -0.02118778f, 0.13772142f, 0.05532014f, 0.02231676f, 
    -0.05401454f, -0.02134025f, -0.01073448f, 0.07072948f, 0.14168046f, 0.02228344f, 0.11022143f, 0.04751968f, 
    -0.02439081f, 0.12295774f, 0.09763533f, 0.12386888f, 0.07436497f, 0.04602459f, -0.02864982f, -0.06462997f, 
    0.12362196f, 0.04883158f, 0.13977753f, 0.16974756f, -0.11691014f, -0.09828921f, -0.00070381f, 0.09743341f, 
    0.06836638f, 0.06162401f, 0.03641078f, 0.09638675f, 0.26300651f, -0.22519018f, -0.03908109f, -0.00271604f, 
    -0.02043070f, 0.00997813f, 0.06065831f, 0.01433627f, 0.07294286f, 0.05693038f, 0.06802861f, -0.00860280f, 
    0.02463228f, 0.03967230f, 0.27441996f, 0.27201951f, -0.04752364f, -0.04616366f, 0.03443727f, 0.04824336f, 
    -0.04079621f, -0.03616109f, 0.03935846f, 0.11173178f, -0.03393092f, -0.00554269f, 0.06701041f, 0.05287724f, 
    0.03807710f, 0.05566888f, -0.06385113f, -0.06166273f, -0.04788010f, 0.00166573f, 0.04965530f, 0.01542246f, 
    0.12251350f, -0.05933536f, 0.06455664f, 0.07418016f, 0.09281305f, 0.03636843f, 0.20396748f, -0.05515691f, 
    -0.01431255f, 0.00861560f, -0.03911419f, 0.03453893f, 0.03454073f, -0.12950990f, -0.11006706f, -0.01069046f, 
    -0.05797971f, 0.04926498f, -0.07193339f, -0.10534663f, -0.08449280f, 0.01210910f, -0.06076893f, 0.09192584f, 
    -0.28251842f, 0.10327236f, 0.17751740f, -0.05159617f, -0.02984125f, 0.06982677f, -0.02484297f, -0.10293754f, 
    0.09690184f, 0.09742077f, 0.03097833f, 0.08477508f, -0.30029756f, -0.11592478f, 0.08972096f, 0.29778185f, 
    -0.06334649f, -0.14498724f, 0.05547282f, 0.07855503f, 0.00753492f, 0.08581410f, -0.07416135f, 0.07260921f, 
    0.04211942f, 0.03512725f, 0.13257253f, 0.07017893f, 0.03376252f, -0.01052081f, 0.08945093f, -0.04322099f, 
    0.04109461f, 0.03832748f, 0.04528644f, 0.04629359f, -0.22781563f, 0.07815748f, -0.06670357f, 0.24188285f, 
    0.12684235f, 0.07554249f, -0.05233464f, 0.08417889f, -0.08722224f, 0.04522612f, -0.10293213f, 0.01025549f, 
    -0.18886225f, 0.09571701f, 0.05291137f, 0.04780171f, 0.06472834f, 0.06654519f, -0.05475381f, 0.02879820f, 
    -0.04340107f, 0.07318120f, 0.00696069f, 0.05114074f, 0.41675097f, 0.10429272f, 0.13499460f, 0.17011927f, 
    -0.08394168f, 0.14547698f, 0.02979684f, 0.05861358f, -0.03484878f, -0.03823339f, -0.08415178f, 0.06930002f, 
    0.03987745f, -0.13924274f, -0.06019085f, -0.09167719f, 0.18047908f, 0.02472928f, -0.08253446f, -0.09513673f, 
    0.03273295f, 0.06203812f, 0.06903520f, 0.08383344f, 0.12441275f, 0.03163677f, 0.07452179f, 0.03534916f, 
    -0.11476675f, -0.06066602f, 0.04979292f, 0.10156424f, -0.04766726f, 0.09911157f, -0.04716971f, -0.03643191f, 
    0.34636706f, -0.08924641f, 0.14125611f, 0.07211450f, -0.11190375f, -0.01188841f, 0.04423086f, -0.01913169f, 
    0.13025506f, -0.03811135f, 0.01585646f, -0.01806841f, 0.29621279f, 0.03396227f, 0.12297273f, 0.19602144f, 
    -0.18764196f, -0.03196798f, 0.02936672f, 0.10188913f, 0.04480666f, 0.05527344f, -0.06675425f, 0.05205556f, 
    0.03927949f, -0.06870613f, -0.11798373f, -0.13413224f, 0.15246494f, 0.10113684f, 0.01949205f, -0.02054357f, 
    -0.03115944f, -0.09129205f, -0.00498341f, -0.04610407f, 0.27766046f, 0.11088906f, 0.07824777f, 0.18659036f, 
    -0.14197180f, 0.03174919f, 0.07276341f, 0.04419747f, 0.13616504f, -0.08155130f, 0.06583004f, -0.02587929f, 
    0.13133273f, -0.13493977f, 0.02374125f, -0.01559981f, -0.03000550f, -0.07329570f, 0.08211599f, 0.11059083f, 
    -0.00017328f, 0.00175390f, -0.03191740f, -0.04654348f, 0.19594020f, 0.03905557f, 0.03448869f, -0.01332050f, 
    -0.03787918f, -0.09703010f, 0.06948940f, -0.00822928f, -0.02283959f, 0.03349606f, -0.02264887f, -0.03588382f, 
    -0.13452506f, -0.11752620f, 0.10947077f, 0.11102548f, 0.05339698f, -0.06370245f, -0.10287480f, 0.00136421f, 
    0.06593248f, 0.02046302f, -0.00922070f, -0.01422708f, -0.02829990f, 0.13716137f, 0.18194632f, 0.16221268f, 
    -0.09170200f, 0.01140457f, -0.00327183f, 0.06970480f, 0.02037050f, -0.01124687f, -0.07720036f, -0.10597250f, 
    0.20886621f, -0.14256787f, 0.01303193f, 0.10207387f, -0.03057192f, -0.07569451f, -0.00584992f, -0.07160883f, 
    0.03541647f, 0.02098423f, -0.00068527f, 0.00699431f, 0.12074284f, -0.02477344f, 0.06546094f, 0.08260184f, 
    0.17223470f, 0.08927686f, 0.14908645f, 0.08901388f, 0.05091592f, 0.02920039f, 0.10536641f, 0.07186661f, 
    -0.10752340f, 0.07054976f, 0.33175728f, 0.14978100f, -0.11730155f, -0.00554794f, -0.07226162f, 0.07237426f, 
    -0.01582370f, 0.08974703f, -0.00355873f, -0.02809839f, 0.15678324f, -0.06555796f, -0.02171231f, -0.11238184f, 
    -0.00042237f, 0.11030770f, 0.09564436f, -0.02738541f, 0.04602466f, 0.00008197f, -0.07589546f, 0.00478876f, 
    0.00788523f, -0.03252668f, -0.09956746f, 0.04175076f, -0.02976085f, 0.02096208f, 0.07365387f, -0.00352246f, 
    0.05508413f, -0.02867365f, -0.06763173f, 0.06492075f, 0.24920012f, -0.30173239f, -0.08146589f, 0.00708928f, 
    0.08316626f, -0.01786407f, -0.00849391f, -0.06259812f, -0.02235093f, 0.05325669f, 0.04481330f, 0.05883671f, 
    -0.33991659f, -0.01392789f, 0.03074048f, 0.01446132f, 0.04096463f, 0.04877314f, 0.04252056f, 0.02078408f, 
    -0.04838202f, -0.09624103f, 0.04073617f, 0.00506050f, -0.01336365f, -0.03558024f, 0.03162962f, 0.11995830f, 
    -0.00496503f, 0.04231539f, 0.04298733f, -0.00423290f, -0.06702583f, 0.06916506f, 0.08509070f, 0.00669626f, 
    -0.05569673f, 0.02183967f, 0.07264844f, 0.20839027f, 0.12115733f, 0.07419074f, 0.03649350f, 0.11755677f, 
    -0.01600963f, -0.03639274f, 0.00144375f, -0.01319252f, -0.17617078f, 0.05365433f, 0.08486124f, 0.04414548f, 
    0.00574369f, 0.01528685f, 0.07707035f, -0.00108323f, 0.00505701f, -0.06358296f, 0.00176663f, 0.00202535f, 
    -0.16917470f, 0.01559024f, -0.15040325f, -0.04503613f, 0.19605586f, 0.02008183f, 0.04304164f, 0.05018742f, 
    0.07435472f, -0.03271873f, 0.03096594f, 0.01803011f, 0.28631678f, 0.13925265f, -0.10077810f, 0.04361752f, 
    0.01488220f, 0.03744696f, 0.02283598f, 0.15349658f, 0.01450170f, 0.00297448f, -0.05865686f, -0.01467506f, 
    0.03833678f, -0.04551751f, 0.09891353f, -0.17818491f, 0.19638959f, 0.05749821f, -0.07302929f, -0.14357820f, 
    0.07999845f, 0.01935944f, 0.01714808f, 0.00809975f, -0.28887790f, 0.04946072f, -0.08001676f, 0.00381274f, 
    0.02922080f, 0.03374325f, -0.05270189f, 0.01721058f, 0.01719016f, -0.10172424f, 0.00262622f, 0.02935294f, 
    0.03198142f, -0.04092982f, 0.05497477f, 0.10620464f, -0.09253839f, -0.03571089f, -0.09492169f, 0.01809886f, 
    0.00900355f, -0.01782082f, -0.07158255f, 0.09142103f, 0.02708422f, 0.02764443f, -0.12282155f, -0.00020666f, 
    0.03665148f, 0.09736802f, 0.00608942f, 0.02016297f, 0.06523877f, -0.06827462f, 0.05978569f, 0.04950519f, 
    0.15655899f, -0.01098509f, 0.03429502f, 0.28292072f, 0.07033824f, 0.01049676f, 0.09403844f, -0.00838242f, 
    0.11006097f, 0.00489707f, 0.13354512f, -0.04153229f, -0.19001558f, -0.06267623f, 0.08915407f, 0.04558135f, 
    0.02331316f, 0.01527210f, 0.08182243f, -0.03572570f, -0.00697791f, 0.04571754f, -0.03146456f, 0.03275456f, 
    0.09372014f, 0.00451805f, -0.02853878f, 0.07729363f, 0.01815858f, 0.02122622f, 0.06795403f, -0.03700651f, 
    0.10242564f, 0.01545220f, 0.02235559f, -0.01590362f, -0.09651940f, 0.25168416f, -0.06733032f, -0.17423846f, 
    0.00570589f, 0.12554847f, 0.00825965f, 0.12302794f, -0.09974457f, 0.05387231f, -0.00260504f, 0.03597831f, 
    0.28836840f, 0.07099164f, 0.09959099f, 0.00332581f, 0.02691665f, -0.05097960f, 0.04414420f, -0.04403363f, 
    -0.06549733f, -0.03728040f, 0.00476686f, 0.05160787f, 0.03556721f, -0.04080738f, 0.03488689f, 0.06798354f, 
    -0.01908297f, -0.04657652f, 0.00791636f, -0.02660213f, 0.04121462f, 0.05521037f, 0.05640940f, 0.05227084f, 
    0.05209765f, 0.03805939f, -0.09576478f, -0.06011790f, -0.05829026f, -0.07494921f, -0.01250825f, 0.03840332f, 
    0.12990767f, 0.01756145f, 0.01568072f, -0.05219879f, 0.18536584f, -0.11571547f, -0.14751947f, -0.09889112f, 
    0.18150787f, 0.15166919f, 0.03109346f, -0.05210650f, 0.05006367f, 0.14831327f, 0.10570523f, -0.03101481f, 
    0.16060381f, 0.05536148f, 0.00974411f, 0.03172747f, -0.10492947f, -0.08057391f, -0.00410390f, 0.11981749f, 
    -0.00186848f, -0.03746250f, 0.02015884f, -0.04691702f, -0.26929343f, 0.03304005f, 0.07303085f, -0.08029234f, 
    0.00560378f, 0.01096115f, -0.02378564f, -0.02130832f, 0.05545458f, 0.09231689f, -0.04989096f, -0.02480173f, 
    -0.36222264f, 0.10098164f, -0.04998309f, 0.21246134f, 0.05742666f, 0.00318998f, -0.02105027f, 0.17342237f, 
    0.06072036f, 0.03933881f, 0.05125895f, 0.02701205f, 0.09888826f, -0.01610885f, -0.05202693f, -0.03302349f, 
    0.10716671f, -0.07589675f, -0.02731108f, -0.10995278f, 0.07130892f, -0.01769862f, -0.03251695f, 0.08353170f, 
    0.06216517f, -0.00076379f, 0.22924112f, 0.24019113f, -0.19197376f, -0.08118812f, -0.00390641f, 0.17626813f, 
    0.02332369f, 0.05098702f, -0.00754567f, 0.04251060f, 0.26336771f, -0.04735710f, 0.05683140f, -0.06604110f, 
    -0.13265891f, 0.06842469f, 0.16271670f, 0.05492428f, -0.01063153f, 0.02155133f, 0.03764715f, -0.04888913f, 
    0.17257963f, 0.06416079f, 0.12608752f, 0.08245200f, -0.12496146f, -0.01960880f, 0.15985417f, 0.14379980f, 
    -0.03011581f, -0.02491942f, 0.00867492f, 0.06884070f, 0.21381465f, 0.08807395f, 0.11047129f, 0.12078023f, 
    -0.10967395f, -0.06735925f, -0.00693434f, 0.03367450f, 0.01339712f, -0.00764539f, -0.03980711f, -0.13115746f, 
    -0.42113930f, 0.09705210f, -0.04638708f, -0.01159332f, 0.11732632f, 0.02349055f, -0.01868967f, 0.09105770f, 
    -0.02324909f, -0.08596227f, -0.00255120f, 0.06282317f, 0.31428647f, 0.07355498f, 0.10800690f, 0.05310052f, 
    -0.11293750f, 0.00670378f, 0.06679811f, 0.10293976f, 0.02691048f, -0.03168681f, 0.04852877f, 0.03470423f, 
    -0.12810247f, -0.07339999f, -0.02526728f, 0.06772470f, 0.01656760f, 0.08365297f, 0.03403440f, 0.09572442f, 
    0.12370692f, -0.02067757f, 0.00985152f, -0.00116632f, 0.05403003f, -0.10848156f, 0.11402869f, 0.03527595f, 
    0.09522391f, 0.02951631f, 0.00431951f, 0.00847376f, -0.00450140f, 0.00167798f, -0.03253763f, 0.11539310f, 
    -0.46995670f, 0.19376257f, 0.01733618f, 0.01478165f, 0.03926417f, -0.00777815f, 0.02125539f, -0.04357627f, 
    0.04173243f, -0.05906193f, 0.00344470f, 0.01901231f, -0.00980355f, 0.16943216f, 0.08796465f, 0.13545734f, 
    -0.09158204f, 0.10142412f, 0.09619445f, 0.19163105f, -0.03832325f, 0.07635657f, -0.02718286f, 0.05919075f, 
    0.29406565f, -0.21951050f, -0.07399429f, -0.20046188f, 0.07875752f, 0.00455247f, 0.00757850f, -0.11687312f, 
    -0.09189375f, 0.01354038f, 0.00164219f, -0.09465609f, -0.20928670f, -0.09331645f, -0.00484187f, 0.21963659f, 
    -0.02739331f, -0.01755318f, -0.03874758f, -0.00311005f, 0.02262590f, -0.03011343f, 0.15306465f, -0.01330679f, 
    0.24747555f, -0.07337013f, -0.04843863f, 0.27452520f, 0.00161609f, -0.06196223f, 0.14324354f, 0.05651180f, 
    0.10146293f, 0.04035030f, 0.08494227f, 0.00930305f, 0.07722740f, -0.06018166f, 0.01691531f, -0.22570880f, 
    -0.07637808f, -0.01386441f, 0.02347711f, 0.10477868f, 0.10543645f, 0.00929688f, 0.04014565f, -0.01470939f, 
    0.14383893f, -0.14742316f, 0.02133235f, 0.22516607f, 0.10087157f, -0.06023097f, 0.07469640f, -0.01434859f, 
    0.15573223f, -0.04079297f, 0.09469941f, 0.15350439f, 0.14489160f, -0.03915194f, -0.26123336f, 0.24220149f, 
    -0.01334355f, 0.03154385f, -0.01493116f, -0.00914523f, 0.15119135f, 0.12142424f, 0.08916103f, -0.04363827f, 
    0.13254486f, 0.13265193f, -0.17116669f, 0.22314724f, 0.08797723f, 0.04117887f, -0.03705298f, 0.02968747f, 
    0.03892159f, 0.07306050f, 0.01458153f, 0.13973677f, -0.22490169f, -0.01635079f, 0.27330518f, -0.00481164f, 
    0.10193146f, -0.06449142f, -0.03734792f, -0.06249328f, -0.03841317f, -0.11745533f, 0.00015899f, 0.10233927f, 
    0.02892434f, 0.07876250f, 0.02248391f, -0.00283336f, 0.00517030f, -0.02850799f, -0.00055017f, -0.09395929f, 
    -0.07123075f, 0.04895081f, -0.04260973f, 0.02433264f, -0.06088752f, -0.11049193f, -0.09560862f, -0.12580617f, 
    0.14581652f, -0.01562581f, -0.03175666f, -0.01392172f, -0.04812211f, 0.03724698f, 0.01396214f, -0.04458309f, 
    0.32084128f, -0.08796791f, -0.21376491f, 0.41435203f, 0.00209210f, -0.05452847f, 0.00211851f, -0.01186900f, 
    -0.00030254f, 0.02407736f, -0.01480658f, -0.04866018f, 0.07412229f, 0.26696619f, 0.05789932f, 0.20196420f, 
    -0.12925215f, -0.12352368f, -0.03301170f, 0.04551909f, 0.07136250f, 0.03009579f, -0.06658417f, 0.08656043f, 
    -0.47292465f, 0.13661820f, -0.11012887f, 0.10570946f, -0.00673064f, 0.06211153f, -0.11057949f, -0.04423461f, 
    -0.05034565f, -0.03767282f, -0.04922386f, 0.03214466f, -0.02976601f, 0.02613863f, 0.15728603f, -0.26944467f, 
    0.02566485f, -0.18165831f, 0.08078772f, -0.02140825f, -0.03245381f, -0.00578371f, -0.07132275f, -0.02848089f, 
    -0.05593478f, -0.07973213f, -0.03321289f, 0.01117875f, -0.08468968f, 0.08835939f, -0.00655257f, -0.02151784f, 
    -0.05242338f, 0.06844557f, 0.02036416f, -0.01356811f, 0.13831399f, -0.13189787f, 0.06404498f, -0.02784430f, 
    -0.04701445f, -0.04446089f, 0.11952753f, -0.07233314f, 0.10125767f, 0.06061605f, 0.01227151f, 0.14453669f, 
    -0.31467706f, -0.03314317f, -0.03397102f, 0.00592817f, -0.02939703f, -0.01968372f, -0.03556120f, -0.04802816f, 
    -0.05003210f, -0.01437700f, 0.03665193f, 0.05209489f, -0.06078202f, 0.07759904f, 0.02069197f, -0.08641318f, 
    0.08817003f, -0.00597694f, 0.00577090f, 0.08141237f, -0.00574770f, -0.03539374f, -0.08179086f, 0.01814954f, 
    -0.16965263f, 0.12491376f, 0.04561654f, 0.13502498f, -0.10971487f, 0.03951615f, 0.02411075f, -0.04786397f, 
    0.14200771f, 0.07101823f, 0.09272520f, 0.06038164f, 0.16211657f, -0.08711074f, -0.09727775f, -0.06689689f, 
    -0.02914025f, -0.00589860f, 0.04203074f, 0.05425812f, 0.07456822f, 0.01605575f, 0.09373726f, 0.07918339f, 
    -0.07809569f, 0.01633151f, -0.14785312f, 0.01393262f, 0.02198259f, -0.01126003f, -0.00382925f, 0.03656681f, 
    -0.05392887f, -0.08000410f, 0.08256809f, -0.02644766f, 0.11227729f, -0.00842240f, -0.00574403f, -0.19404094f, 
    0.09074023f, 0.02556591f, 0.08221873f, 0.00516092f, 0.11417244f, 0.02290326f, 0.10685030f, 0.00099289f, 
    0.18239601f, 0.08080344f, -0.18437995f, 0.13313691f, 0.14440484f, 0.03671509f, -0.06461854f, 0.03929447f, 
    0.07046314f, 0.02891680f, -0.01625261f, 0.05010335f, 0.20188080f, 0.00915679f, 0.03914257f, 0.11487095f, 
    0.10823905f, -0.11400952f, -0.07522009f, 0.00401848f, 0.07126275f, -0.01004014f, -0.13760895f, 0.00740022f, 
    -0.10898373f, -0.29422167f, 0.00087840f, -0.01979114f, 0.11596180f, -0.00523807f, -0.04006932f, 0.14229462f, 
    -0.01681850f, -0.14093135f, 0.01857080f, 0.05367519f, -0.07900927f, -0.06639159f, 0.07002880f, 0.08522175f, 
    -0.05843168f, 0.00436591f, 0.04992513f, 0.01000637f, 0.07241420f, -0.00513078f, -0.09513882f, 0.09277102f, 
    0.07322676f, 0.25499839f, -0.08451979f, 0.19808435f, 0.07779848f, -0.03211057f, -0.05602368f, 0.11018591f, 
    0.05116982f, 0.00855969f, -0.02365991f, -0.05810322f, 0.10926758f, 0.19753559f, 0.00301321f, -0.03969802f, 
    -0.16710278f, 0.10570623f, -0.01373800f, -0.13664283f, 0.04270949f, 0.04833062f, 0.05916282f, 0.03062775f, 
    0.21759516f, -0.21301728f, 0.13043727f, 0.27556565f, -0.05947534f, -0.01802163f, 0.03685134f, -0.02364267f, 
    0.04361708f, 0.08518723f, -0.04011875f, -0.10904786f, 0.11376423f, 0.16376460f, 0.03435122f, -0.07451586f, 
    0.03561893f, -0.00547743f, 0.04791480f, -0.01977350f, -0.01845300f, 0.07273991f, -0.03227724f, 0.05589737f, 
    -0.02292661f, -0.02420119f, -0.10062287f, -0.00905625f, 0.17085516f, 0.04395662f, -0.02469962f, 0.07716548f, 
    -0.22359502f, 0.01340655f, 0.04177052f, 0.15369934f, -0.08143793f, -0.18958403f, -0.23364006f, 0.14683755f, 
    -0.09449201f, 0.17508475f, -0.12883660f, -0.03868687f, 0.03957342f, 0.08465517f, -0.02883659f, -0.11068484f, 
    0.10045599f, -0.18566872f, 0.20189086f, -0.12300784f, 0.07793754f, -0.04256740f, -0.05300518f, 0.08743584f, 
    -0.03393045f, 0.04448929f, 0.05921794f, 0.04830920f, -0.23392400f, -0.02255028f, 0.14122157f, -0.21515465f, 
    0.08167271f, 0.07006403f, -0.12303394f, 0.01024228f, -0.09328099f, -0.00208369f, 0.02017183f, 0.02228528f, 
    0.23781207f, 0.17401524f, -0.03561505f, 0.04657528f, -0.03612963f, -0.05551577f, -0.14621025f, -0.07310383f, 
    -0.10781405f, 0.03471487f, -0.03299153f, 0.03496506f, -0.37499857f, 0.15251406f, 0.19135758f, 0.00373473f, 
    0.02946312f, 0.12515779f, -0.04772286f, -0.03184181f, -0.03724052f, 0.10984857f, -0.07836990f, -0.01495073f, 
    -0.26601073f, 0.16563500f, -0.09272992f, 0.07977151f, -0.14575638f, 0.02727434f, 0.07094901f, -0.00426118f, 
    -0.01446952f, -0.09158631f, 0.07430881f, -0.00998439f, 0.20564835f, 0.35381457f, -0.04224741f, 0.04142355f, 
    0.03151534f, 0.12790485f, -0.05922693f, -0.12168232f, 0.03143865f, -0.00193433f, -0.10361980f, -0.04418786f, 
    -0.00878598f, -0.08684095f, 0.07366659f, -0.10382564f, 0.06078310f, 0.03458400f, 0.04543593f, 0.08019394f, 
    0.05706143f, 0.07058377f, -0.06114839f, -0.02057316f, 0.04286269f, -0.08167583f, 0.09845868f, -0.13928115f, 
    0.02233387f, -0.02687830f, 0.03955985f, 0.04008957f, 0.06364403f, -0.05934058f, 0.03961643f, -0.07670619f, 
    0.22974865f, -0.15068747f, -0.06305381f, 0.06156568f, 0.15656322f, 0.04002675f, -0.00188682f, -0.00838467f, 
    -0.06478769f, -0.01198736f, -0.00723521f, -0.01335477f, 0.33191425f, -0.01324195f, 0.06577925f, -0.02748999f, 
    0.00275033f, -0.03932752f, -0.00583438f, 0.13735279f, 0.06217904f, 0.04686631f, 0.09005530f, 0.02316644f, 
    0.16678444f, 0.25563097f, -0.13079204f, 0.18041357f, -0.06392468f, -0.04270417f, -0.01405177f, 0.10286307f, 
    0.08864148f, 0.10024421f, -0.04660193f, -0.01153615f, 0.34996617f, -0.00569867f, -0.05795881f, 0.14485851f, 
    -0.05088959f, -0.02921701f, 0.11112153f, -0.02157989f, -0.10036241f, -0.03885504f, -0.05771488f, 0.05470737f, 
    0.20575804f, 0.12721455f, -0.01220885f, 0.01206100f, -0.01155978f, -0.01110743f, -0.01660833f, -0.17540325f, 
    0.04155065f, 0.09121275f, -0.04763371f, 0.04560320f, 0.10934540f, 0.07893982f, 0.11986788f, 0.11805645f, 
    -0.01564821f, -0.09552003f, -0.00063600f, 0.04015541f, 0.00080558f, 0.06990360f, -0.03024893f, 0.02672800f, 
    0.15235849f, 0.22710638f, -0.11826361f, 0.10915432f, 0.13179284f, -0.01786332f, 0.01140399f, -0.09973957f, 
    0.00524880f, 0.04543702f, 0.04966271f, 0.06834476f, -0.10965395f, -0.00243510f, -0.19623461f, 0.08681270f, 
    0.04776553f, -0.03489438f, -0.00158459f, 0.03824182f, 0.02728354f, 0.13787770f, -0.01355715f, 0.00161416f, 
    -0.04719197f, 0.21070035f, 0.00217238f, 0.01351489f, 0.07354734f, -0.07540638f, 0.02885193f, 0.13874979f, 
    -0.02500595f, 0.01674236f, -0.08618423f, 0.02894172f, -0.12298737f, 0.04694899f, -0.05602235f, -0.00510718f, 
    -0.09517931f, 0.00698463f, -0.06916799f, -0.06770442f, -0.02833154f, 0.10974704f, 0.02416418f, -0.21267481f, 
    -0.00309577f, -0.06264900f, 0.09402892f, -0.04313914f, -0.03664263f, -0.02389099f, -0.05224868f, 0.07829354f, 
    0.03501439f, -0.07836592f, 0.10443531f, -0.07001156f, -0.28246275f, 0.18513678f, -0.14727522f, 0.26070932f, 
    -0.02057026f, 0.07084426f, 0.00819995f, 0.09759431f, -0.08972963f, 0.01006395f, 0.03646677f, 0.00869093f, 
    -0.07713170f, 0.29191741f, 0.16990061f, 0.02198141f, 0.01828179f, -0.00594060f, -0.05291121f, -0.01168479f, 
    0.03106651f, -0.00642466f, 0.10708020f, -0.04024485f, -0.21234460f, 0.06873579f, -0.03026373f, 0.14413282f, 
    0.00440968f, -0.00526536f, 0.06703064f, -0.01263037f, -0.00277682f, -0.05185295f, -0.04844939f, 0.01270308f, 
    0.10242882f, -0.19949019f, 0.05316453f, 0.07412409f, 0.08675159f, -0.02268443f, 0.05781278f, -0.02420124f, 
    0.04069822f, 0.06792034f, 0.00086278f, 0.04232917f, 0.22308525f, -0.19071022f, -0.25005463f, 0.29607633f, 
    0.08863371f, -0.00351760f, 0.00976585f, -0.02281024f, 0.05983523f, 0.11370530f, -0.05204806f, 0.02862806f, 
    0.12623550f, 0.00610776f, 0.04915460f, 0.06855547f, -0.03378965f, 0.00317815f, 0.02343325f, -0.00604698f, 
    0.05154345f, -0.05172561f, 0.11086632f, -0.03705254f, 0.15421291f, -0.00266984f, 0.07140044f, -0.13097449f, 
    0.13674188f, 0.05074799f, 0.03177881f, 0.01418531f, -0.11275215f, 0.06468509f, 0.06090460f, 0.04032130f, 
    -0.13101873f, -0.06793030f, 0.13329129f, -0.09313032f, 0.02968045f, -0.01596907f, 0.14875314f, -0.02280498f, 
    -0.03051219f, 0.04725100f, -0.00935172f, 0.02359665f, 0.05835247f, -0.13843295f, 0.08078379f, 0.22097114f, 
    -0.03238224f, 0.05754449f, -0.04275149f, -0.03824275f, 0.04609253f, -0.13431975f, 0.19117099f, -0.00530543f, 
    0.12245164f, -0.00470285f, -0.16924146f, 0.19942032f, -0.00826966f, 0.00937631f, 0.04231233f, -0.03316729f, 
    -0.12120245f, 0.04131852f, -0.04260391f, -0.03604085f, 0.10851969f, -0.15266421f, -0.16933835f, 0.02228171f, 
    0.00587579f, -0.03141757f, 0.04824745f, -0.09426575f, -0.08794716f, 0.01311848f, -0.00811204f, -0.03254361f, 
    -0.61743742f, 0.18363149f, -0.08945037f, 0.05216561f, 0.02503606f, -0.07642373f, -0.01407265f, -0.00571514f, 
    -0.06919100f, 0.01270667f, -0.02275741f, 0.00727706f, 0.01399820f, -0.07840526f, 0.03269594f, -0.18769918f, 
    -0.08998926f, -0.09440120f, 0.12658685f, 0.07288331f, -0.05114231f, -0.03589531f, -0.03274912f, -0.01287818f, 
    -0.09060451f, -0.10706159f, -0.05598903f, 0.06947667f, -0.02452333f, -0.06181255f, -0.03357794f, -0.02413217f, 
    0.03169875f, -0.00454887f, 0.03530290f, 0.06774168f, 0.18081239f, 0.08207816f, 0.13076596f, -0.03746938f, 
    0.20615913f, -0.03013242f, -0.11470862f, 0.08022729f, 0.08263721f, -0.02594935f, 0.15609497f, 0.09584892f, 
    0.01578248f, -0.29186046f, 0.02573231f, 0.12862889f, -0.02350731f, 0.02208417f, 0.05968316f, 0.06496728f, 
    0.03979485f, -0.13027906f, 0.04992045f, 0.15489861f, -0.41745070f, -0.17802002f, 0.10662720f, 0.09341310f, 
    -0.06365930f, 0.03093172f, -0.01107406f, -0.03269901f, -0.03823394f, 0.04869625f, 0.02166111f, 0.07605243f, 
    0.31113002f, -0.04408675f, -0.14765048f, -0.08872055f, -0.04616821f, -0.02204030f, 0.02071309f, 0.04985002f, 
    -0.03539033f, 0.02630531f, -0.04187603f, -0.05274687f, 0.11294234f, 0.00228877f, 0.11467399f, -0.20370248f, 
    -0.03156210f, 0.09044486f, -0.07292859f, -0.19313702f, -0.06977629f, 0.06435275f, -0.00747629f, 0.12509775f, 
    0.26713938f, 0.16778336f, 0.05528235f, 0.23445503f, 0.04148920f, -0.06058379f, 0.05115781f, 0.07468154f, 
    -0.05169537f, 0.08574575f, -0.05931305f, -0.13992965f, 0.07697964f, 0.09777673f, -0.02787182f, 0.28205639f, 
    -0.00675509f, -0.06134325f, -0.06066932f, 0.00287909f, -0.02844253f, -0.01444008f, -0.07039771f, -0.04728874f, 
    0.07929038f, 0.03204590f, -0.03353467f, -0.15367824f, 0.02672903f, -0.01606366f, -0.03407627f, -0.00826647f, 
    0.16520549f, 0.03378148f, 0.08632716f, -0.01951836f, -0.09553812f, 0.04654524f, -0.09689891f, 0.11968004f, 
    0.03061410f, 0.07113186f, 0.14809269f, 0.08019483f, 0.04876482f, -0.04903421f, 0.03913355f, -0.04162296f, 
    0.13004978f, 0.25469396f, 0.17946242f, 0.15026309f, 0.00319172f, 0.06510008f, -0.01566932f, 0.07832111f, 
    -0.08674647f, 0.02868010f, 0.05121225f, -0.00652409f, 0.09595542f, -0.00457005f, -0.05137314f, 0.02935143f, 
    0.10779934f, 0.12835491f, -0.01726688f, 0.06237435f, 0.01299526f, 0.01815630f, 0.05782414f, 0.03777058f, 
    0.21318302f, 0.04211832f, 0.00594259f, -0.06182785f, -0.06955409f, 0.07512042f, 0.07051358f, 0.00817398f, 
    0.12209077f, 0.00665988f, -0.05897057f, -0.08521062f, 0.17480360f, 0.12939967f, -0.03013538f, -0.00222500f, 
    0.09198865f, 0.06133434f, 0.03695844f, 0.06896003f, -0.02081876f, 0.00978990f, 0.09803911f, -0.09009030f, 
    -0.44339457f, -0.06305859f, 0.26518387f, 0.17944068f, -0.03826063f, 0.07987289f, -0.02766293f, 0.10505912f, 
    0.09746139f, 0.03344969f, 0.15351239f, 0.05428797f, 0.02040724f, 0.09725508f, -0.00652867f, -0.03539601f, 
    0.11562181f, -0.03930776f, -0.10216559f, 0.00576544f, -0.03347987f, -0.09954333f, 0.14062993f, -0.05478228f, 
    0.26302806f, -0.14130722f, -0.04422489f, -0.26757935f, 0.02887923f, 0.05523924f, 0.16490336f, -0.07087527f, 
    0.08629362f, 0.01478955f, -0.03753190f, -0.00967389f, -0.15220402f, -0.07997137f, -0.12127064f, -0.06731390f, 
    -0.01054439f, 0.01673148f, -0.04025022f, 0.02494020f, -0.04928277f, 0.03405133f, 0.03646528f, -0.05125995f, 
    0.25726536f, 0.15198532f, -0.05318876f, 0.00226906f, -0.01580236f, 0.02407243f, -0.03568354f, 0.08836920f, 
    -0.02922429f, -0.09971182f, 0.01357768f, -0.03347425f, 0.05051126f, -0.02572815f, -0.05196940f, 0.04497211f, 
    0.07225972f, 0.00361864f, 0.02129919f, -0.01849168f, 0.05852522f, -0.00709942f, 0.04811665f, -0.04542852f, 
    0.08846188f, -0.10697442f, 0.01431997f, -0.15750457f, 0.01767561f, 0.03617011f, -0.00659495f, -0.08966105f, 
    0.04113161f, 0.08846539f, 0.01332775f, 0.03607501f, -0.06915598f, -0.04367666f, -0.07123364f, -0.02442512f, 
    -0.08208845f, 0.04150164f, -0.10897592f, -0.02514203f, 0.05624212f, 0.05767944f, -0.01606406f, 0.05529457f, 
    0.19736235f, 0.07205362f, 0.13356386f, 0.05105957f, 0.08719343f, -0.07186983f, -0.06233494f, -0.00965948f, 
    0.04843872f, -0.00455560f, 0.05815452f, 0.05356471f, -0.28851178f, -0.19854705f, 0.18126503f, 0.20193072f, 
    0.01439343f, 0.18432531f, -0.01785294f, 0.01247053f, -0.06073817f, 0.04212612f, 0.11550485f, 0.00366641f, 
    0.33796167f, 0.03352631f, -0.03650231f, 0.17023528f, 0.05076236f, 0.00956960f, 0.03814235f, -0.06582185f, 
    0.00836890f, 0.06895230f, 0.07023644f, -0.08471394f, 0.10059239f, -0.15019344f, -0.04810642f, 0.03269231f, 
    0.05545558f, 0.02111785f, 0.08951896f, 0.00270819f, -0.05151744f, -0.02532002f, 0.03348330f, 0.01200543f, 
    0.08311640f, 0.06164088f, 0.12158419f, -0.05453277f, 0.06129128f, 0.09940814f, 0.01809500f, 0.06407646f, 
    0.06415483f, -0.00701080f, 0.00018013f, 0.08371696f, -0.13737002f, 0.10424465f, -0.15723479f, -0.09861329f, 
    -0.07021455f, -0.10162824f, 0.00768637f, -0.08369149f, 0.06862251f, 0.08455478f, -0.06124619f, 0.00020749f, 
    0.26643440f, -0.13886559f, -0.06834407f, 0.14856389f, -0.03440946f, 0.05739274f, 0.06549247f, 0.05394360f, 
    -0.00626878f, 0.07052171f, -0.01971235f, 0.13173550f, 0.03633223f, -0.00381789f, 0.09461965f, 0.15991005f, 
    0.03024206f, 0.02940458f, -0.05219384f, 0.05821520f, 0.08570353f, -0.03080084f, 0.05732373f, -0.00075331f, 
    0.17461240f, 0.01657984f, 0.09638149f, 0.06189720f, -0.07163406f, 0.14261523f, 0.07359347f, 0.04255667f, 
    0.17849897f, 0.04681166f, 0.15843032f, -0.07905263f, 0.16833484f, -0.16024058f, -0.09022285f, -0.17034136f, 
    0.03996901f, -0.12778334f, 0.13320008f, -0.07403126f, -0.01042129f, 0.04706667f, 0.04968445f, 0.05633663f, 
    0.09468705f, 0.23039529f, -0.05849852f, 0.17175740f, 0.13210891f, 0.06525265f, 0.08172766f, 0.12239790f, 
    0.08271005f, 0.04359017f, 0.05619640f, 0.01846417f, 0.00178058f, 0.02288698f, 0.05034940f, 0.28105113f, 
    0.04809485f, 0.01124851f, 0.07242862f, 0.02170271f, 0.21180825f, 0.10559333f, 0.07407246f, 0.00282309f, 
    0.03170138f, -0.19351448f, -0.00001216f, 0.07690105f, -0.03782186f, -0.02056382f, -0.02436484f, -0.05553485f, 
    0.04147303f, -0.10297113f, 0.04453814f, -0.03256773f, -0.44565341f, 0.09509865f, 0.06110531f, 0.04398833f, 
    0.07935461f, -0.06208889f, -0.06464756f, 0.12926167f, 0.07341036f, 0.02073038f, 0.08533200f, 0.11484101f, 
    0.09371148f, -0.07337468f, -0.09471153f, -0.29847541f, 0.05310246f, -0.00486580f, -0.01897843f, 0.04286865f, 
    0.07684653f, -0.01295729f, -0.12486275f, 0.01980887f, -0.06789514f, -0.00647371f, 0.03434377f, 0.23516013f, 
    -0.00048222f, -0.09435710f, 0.03667106f, 0.00614657f, 0.03104959f, 0.06715401f, -0.03568360f, -0.13697578f, 
    -0.33523381f, 0.19012378f, -0.09564608f, -0.07445768f, 0.01856967f, -0.00538528f, 0.03702667f, -0.05549374f, 
    -0.00075005f, -0.02245784f, 0.00069050f, 0.00872578f, -0.44521087f, 0.23638518f, -0.16600572f, 0.03299175f, 
    0.09331502f, -0.01217534f, 0.02862667f, 0.02279017f, -0.02432267f, 0.06723576f, 0.00105457f, 0.01662895f, 
    0.12201910f, -0.01371791f, 0.09502295f, 0.05116229f, 0.00296793f, -0.00298573f, 0.06985234f, 0.03874655f, 
    0.02478961f, 0.04190090f, 0.11437847f, -0.03406647f, 0.13813426f, 0.20561032f, -0.07829645f, -0.00657762f, 
    0.05198672f, 0.07315787f, 0.06505140f, -0.09758902f, -0.00273996f, -0.01147190f, -0.11326296f, 0.06273122f, 
    0.03230793f, -0.24715322f, 0.01364629f, -0.10184706f, 0.04272155f, 0.03126739f, 0.01891329f, -0.11064057f, 
    -0.02449145f, -0.03009110f, 0.04040722f, 0.02684254f, 0.03408568f, -0.08970443f, 0.04995202f, 0.09502088f, 
    0.02314511f, 0.03903508f, -0.02740140f, 0.08713593f, 0.12594217f, 0.02069625f, 0.05019494f, 0.11656853f, 
    0.07555866f, -0.32930726f, -0.18817191f, -0.06877833f, -0.07470877f, 0.04634203f, -0.04515744f, 0.04757805f, 
    -0.04107994f, -0.03431943f, -0.01958311f, -0.03998085f, -0.21429734f, -0.03253400f, 0.18788855f, 0.22902948f, 
    0.05665434f, 0.08045122f, -0.01643552f, 0.03936083f, -0.10376760f, -0.10694809f, 0.13720709f, 0.00597584f, 
    -0.03621640f, 0.30171522f, 0.13496830f, -0.00525684f, -0.05555857f, 0.02664727f, 0.00923417f, 0.07879329f, 
    0.02799859f, -0.03328966f, 0.06710105f, -0.00473760f, 0.39333355f, 0.10908616f, 0.01708050f, 0.04550047f, 
    0.02082856f, -0.03486998f, 0.03019951f, 0.09593689f, 0.08139536f, -0.04580967f, 0.02451319f, 0.01851513f, 
    0.09822328f, 0.05843813f, -0.14618658f, -0.06426869f, 0.01350547f, 0.16516313f, -0.03291795f, 0.02114680f, 
    -0.13310461f, -0.00482709f, -0.01827346f, 0.13422076f, 0.31517622f, -0.14196461f, -0.27649733f, -0.36368462f, 
    0.07358921f, -0.00845912f, 0.06131903f, -0.12522851f, -0.12981004f, 0.07408733f, -0.09307222f, 0.04306452f, 
    -0.09359659f, -0.27722359f, -0.15682058f, -0.03571672f, 0.05691360f, -0.04955653f, 0.06209837f, 0.01809478f, 
    0.02831834f, 0.06191842f, -0.11625154f, 0.06916783f, 0.27346531f, 0.02805541f, 0.25208870f, 0.09957509f, 
    -0.05024029f, 0.08849906f, -0.09918948f, -0.04364838f, 0.08568534f, 0.06051698f, 0.06951042f, 0.06663387f, 
    -0.11509968f, -0.03139050f, -0.19438499f, -0.02546095f, 0.03539320f, -0.01931097f, 0.01000100f, -0.13347308f, 
    -0.00301042f, 0.00948884f, -0.04909642f, -0.00128170f, 0.28659990f, -0.17025736f, -0.09924219f, -0.13713872f, 
    0.03739822f, -0.00739757f, -0.02327702f, 0.02433073f, -0.02104171f, -0.00669361f, 0.00598980f, 0.10072292f, 
    0.23698646f, -0.13034518f, -0.10033090f, -0.11223549f, 0.02994017f, 0.02743505f, 0.01845438f, 0.08271816f, 
    0.03604709f, -0.04493305f, 0.08451287f, 0.04635770f, -0.05967413f, 0.19449310f, 0.22629733f, -0.04502586f, 
    -0.08951984f, -0.07388698f, 0.05831576f, 0.01983389f, 0.02009608f, -0.02610913f, -0.02050626f, 0.13753372f, 
    -0.05035916f, -0.24408406f, -0.07904623f, -0.08023888f, -0.07298708f, -0.02616199f, 0.04117028f, -0.00091386f, 
    0.06919137f, 0.03669767f, -0.12499559f, 0.03582234f, 0.14853689f, 0.16040674f, -0.05051193f, 0.19772303f, 
    -0.06085601f, -0.04217361f, -0.11476374f, 0.08210541f, 0.10830612f, 0.04873532f, 0.01477773f, 0.02604205f, 
    -0.34050217f, 0.21286662f, -0.02636980f, 0.06252205f, 0.08395953f, -0.06300375f, -0.00048059f, 0.04242131f, 
    0.04114408f, 0.00260887f, 0.02971951f, -0.02937587f, 0.23222488f, 0.00374241f, -0.17785333f, -0.11081266f, 
    -0.11721180f, -0.04369573f, 0.03513948f, -0.05430777f, -0.02826681f, 0.04562109f, -0.06872858f, -0.01569125f, 
    0.24863610f, -0.22353873f, -0.04601909f, -0.02061719f, -0.02133303f, 0.12255154f, 0.03598342f, 0.03407842f, 
    0.20449075f, -0.02209027f, 0.11969960f, 0.07059978f, -0.07070434f, -0.16807161f, -0.09704800f, -0.01419304f, 
    -0.05244468f, 0.14861624f, 0.06787009f, 0.02011412f, 0.04635945f, -0.05192653f, 0.07170320f, 0.06652789f, 
    0.29886070f, 0.03386761f, 0.13390957f, 0.03843817f, -0.07185236f, 0.06692035f, -0.01160569f, 0.11257217f, 
    0.00282532f, -0.01943653f, -0.02962569f, 0.10064236f, -0.28364307f, -0.12980039f, 0.00963882f, 0.02903262f, 
    -0.05962893f, -0.04237129f, 0.03157731f, 0.02487818f, 0.00440514f, 0.09818137f, -0.04818879f, -0.00963552f, 
    -0.01826768f, 0.15189466f, -0.05976333f, -0.05847817f, 0.04303839f, 0.09236997f, 0.04563439f, 0.02268979f, 
    -0.06608175f, 0.07800305f, 0.00342304f, 0.02716984f, 0.01690879f, 0.16751769f, -0.02153740f, 0.09881973f, 
    0.06326675f, -0.01285193f, 0.12077851f, 0.00496415f, 0.08746992f, 0.10932820f, -0.08052549f, -0.00217666f, 
    -0.03079530f, 0.01754748f, 0.01437355f, -0.01728232f, -0.01577231f, 0.02815574f, 0.02607395f, -0.02346013f, 
    -0.02471616f, 0.00013174f, -0.01114815f, -0.02733718f, 0.00807385f, -0.03448002f, 0.01717329f, 0.02462883f, 
    -0.01786879f, 0.02809077f, 0.01419100f, -0.03356227f, 0.00761639f, -0.01919152f, -0.04092390f, -0.00698292f, 
    -0.03208695f, -0.02635378f, 0.02914996f, -0.01107259f, -0.02668665f, -0.00489219f, -0.04024596f, -0.03467403f, 
    0.00565573f, -0.03514514f, 0.02650659f, -0.00439045f, 0.02387248f, -0.04120597f, 0.03675051f, -0.02622482f, 
    0.00987024f, -0.03871088f, -0.00321368f, -0.00830249f, -0.03561358f, -0.02471806f, -0.00880483f, -0.00070545f, 
    -0.02866574f, 0.02919307f, 0.02139205f, 0.01245525f, -0.02795999f, -0.03421089f, 0.01492722f, 0.00799184f, 
    0.02510751f, 0.01700051f, -0.02852439f, 0.01412203f, -0.03005194f, -0.00034088f, 0.00759658f, -0.02973172f, 
    -0.02013385f, -0.02177445f, -0.00807143f, -0.02655123f, -0.00415222f, 0.02157126f, -0.02440419f, -0.00233971f, 
    -0.02529980f, -0.02746515f, -0.00214834f, 0.00242320f, 0.01446366f, 0.02751306f, -0.04049452f, -0.01626612f, 
    -0.02877458f, -0.02212842f, -0.01782390f, -0.01113602f, -0.02682524f, 0.02570586f, 0.02039954f, -0.03663515f, 
    -0.00310741f, -0.01227039f, -0.03564117f, -0.00099965f, -0.03693715f, -0.03660166f, 0.02653239f, 0.03945905f, 
    -0.03821952f, -0.03460580f, 0.00324686f, 0.00609546f, -0.04078581f, -0.01577256f, 0.01917120f, -0.04087479f, 
    -0.03543831f, -0.03008026f, 0.01191519f, 0.01754387f, -0.03791276f, -0.02049750f, -0.03542895f, 0.02764593f, 
    0.03973843f, -0.02189715f, -0.02572201f, -0.00516003f, 0.00217622f, -0.02381227f, -0.02350587f, -0.02887325f, 
    -0.03203905f, -0.03415145f, -0.01174634f, -0.00610833f, 0.00909774f, 0.01911169f, -0.04019394f, 0.02954840f, 
    0.00585907f, -0.01913870f, -0.01876822f, 0.00622069f, -0.01677658f, -0.03748558f, 0.02009526f, 0.03929669f, 
    0.02172655f, 0.00229925f, -0.01446054f, 0.00504761f, -0.00807535f, -0.00098867f, 0.01436790f, -0.01200718f, 
    0.02486593f, -0.00418361f, -0.03814050f, -0.02679440f, 0.02933265f, 0.02270109f, 0.02854277f, 0.02816527f, 
    -0.01855387f, -0.01697187f, 0.02166959f, 0.01491525f, -0.00524591f, 0.01783124f, 0.03243919f, -0.02974896f, 
    0.01077776f, 0.00076651f, -0.00646430f, 0.02570290f, 0.01513223f, -0.00834251f, 0.00733980f, 0.00237790f, 
    -0.02630007f, -0.02574367f, -0.01533229f, 0.01635806f, 0.01322364f, -0.03488344f, 0.03910767f, -0.03948255f, 
    -0.02491406f, 0.01005980f, 0.01969461f, 0.02403110f, -0.03131576f, -0.01612616f, -0.02080316f, 0.01184950f, 
    -0.03527400f, -0.03369129f, -0.02404409f, 0.01989652f, 0.02399028f, -0.00458539f, 0.02073852f, -0.03192408f, 
    0.01891079f, 0.03647429f, -0.00525851f, -0.00606743f, 0.02694104f, -0.01401901f, 0.02500203f, -0.01499499f, 
    -0.01193983f, -0.03332027f, -0.00667370f, -0.02198857f, 0.00271694f, 0.02638225f, -0.02853527f, -0.04021289f, 
    -0.00310263f, -0.00184805f, 0.01072501f, -0.01830379f, -0.02951891f, 0.01384656f, -0.02530028f, 0.00865170f, 
    -0.01305325f, 0.02124056f, -0.04051329f, 0.01384411f, -0.01702193f, -0.00736906f, 0.01924976f, 0.00404543f, 
    0.01672936f, -0.03946486f, 0.04044421f, -0.02507641f, -0.02494503f, 0.01088818f, -0.03755561f, -0.03368586f, 
    0.01730974f, -0.00679476f, 0.00269686f, -0.00445684f, -0.01910659f, 0.01636050f, -0.01214460f, -0.00833792f, 
    0.00757967f, 0.02296064f, -0.02170682f, -0.03530221f, -0.03012557f, -0.00480081f, -0.00948022f, -0.02387297f, 
    -0.01877444f, -0.02055895f, -0.02077893f, 0.02807725f, -0.02940004f, -0.00706056f, 0.01924950f, 0.00285505f, 
    0.02243424f, 0.02882119f, -0.01805737f, -0.02177431f, -0.00498282f, -0.04008296f, -0.01951367f, 0.01096563f, 
    -0.00007439f, -0.04044235f, -0.02789111f, -0.02839047f, 0.00299272f, -0.03168306f, -0.02169576f, -0.00933998f, 
    -0.03603854f, 0.01265424f, 0.02530094f, 0.02233864f, -0.01198965f, 0.00935569f, 0.01291657f, 0.00282480f, 
    -0.01615372f, 0.02363496f, -0.03948907f, 0.02805421f, 0.01131811f, 0.02019027f, 0.01314587f, 0.02510262f, 
    0.00050056f, -0.03415458f, -0.02028263f, -0.02767081f, 0.02142945f, 0.02047405f, 0.01988247f, -0.01428984f, 
    -0.01907578f, -0.02836871f, -0.01581979f, -0.01132869f, -0.01053402f, 0.00656334f, -0.00862471f, -0.01904067f, 
    -0.02021457f, 0.01054152f, 0.01837803f, 0.00210325f, -0.02088098f, -0.02544049f, -0.00896908f, -0.01229862f, 
    0.01631257f, 0.02611443f, 0.02303006f, -0.01892698f, 0.00677506f, 0.02749565f, -0.04123491f, 0.01726134f, 
    -0.03093979f, -0.02795917f, -0.03377673f, -0.01480530f, 0.02802415f, -0.02179323f, 0.00920523f, -0.00048006f, 
    0.01589451f, -0.03025907f, 0.02983615f, -0.02175288f, -0.01580209f, 0.00532205f, -0.00010432f, -0.01313046f, 
    0.01080060f, -0.03140318f, -0.01741982f, 0.01908752f, 0.00455601f, 0.01489568f, 0.02153815f, -0.03899541f, 
    0.00526957f, -0.01676185f, -0.02846097f, -0.03589557f, -0.02719699f, -0.03306025f, -0.03119964f, -0.00481266f, 
    -0.03328700f, -0.03009437f, -0.03108314f, -0.03005215f, -0.00661112f, 0.01195733f, 0.03016738f, 0.00845760f, 
    -0.00909993f, -0.02150675f, -0.00886811f, -0.00280829f, 0.01604465f, -0.03068802f, 0.00616445f, 0.02805242f, 
    -0.02789072f, -0.02127456f, 0.00309747f, -0.01125360f, 0.00342557f, -0.03287273f, 0.01834514f, -0.00092197f, 
    0.01510479f, -0.01617682f, -0.01865304f, -0.02189141f, 0.02102141f, 0.00715333f, 0.01907982f, 0.03658468f, 
    -0.02847496f, 0.01780063f, -0.03419877f, -0.02307658f, -0.03778705f, 0.00542702f, -0.02667442f, 0.02523222f, 
    0.01010504f, -0.04158133f, -0.00447367f, -0.03239863f, -0.02746270f, -0.00120876f, 0.00735284f, 0.00758660f, 
    0.02225441f, -0.01506029f, -0.03139980f, -0.02803576f, -0.03960962f, -0.00007293f, -0.01693861f, -0.03351712f, 
    -0.02670486f, 0.02412046f, -0.00837473f, 0.01166893f, -0.03709194f, -0.04045428f, 0.03267904f, 0.00301814f, 
    0.02630781f, -0.02773909f, 0.02109792f, 0.02715945f, 0.01836696f, 0.00260789f, 0.02602430f, -0.01775155f, 
    -0.03887257f, -0.02035870f, -0.02923712f, -0.01520044f, -0.00145031f, -0.01755504f, 0.01231382f, -0.01467463f, 
    -0.03383164f, -0.01376848f, -0.01861992f, -0.01487871f, 0.00345533f, 0.02225053f, -0.00182727f, -0.02261612f, 
    -0.02595534f, -0.00888527f, 0.02241017f, -0.00824255f, -0.03195011f, -0.03748580f, 0.00246208f, -0.00747697f, 
    -0.00506309f, 0.01064216f, 0.01397907f, 0.01841346f, -0.00992667f, 0.02095274f, -0.00109067f, 0.00534309f, 
    0.00834576f, 0.00910228f, -0.03029209f, 0.01095126f, -0.03090106f, -0.00215196f, -0.03891115f, 0.02953836f, 
    0.00737290f, -0.03995833f, -0.00033291f, -0.03937206f, -0.02806799f, 0.02252729f, 0.01305100f, -0.01076930f, 
    0.01114303f, 0.01161012f, -0.03153467f, -0.01131093f, -0.01936665f, 0.02428621f, -0.00911900f, 0.01344958f, 
    0.00566869f, 0.01299749f, -0.01841613f, -0.02633964f, -0.02903444f, -0.00156065f, -0.01735989f, -0.04092856f, 
    0.01812015f, 0.02713882f, 0.02456710f, -0.00628518f, 0.02406170f, 0.02005548f, -0.00980482f, 0.00146503f, 
    -0.01332390f, -0.03236517f, 0.01459367f, -0.00530594f, -0.02042913f, -0.02495021f, 0.01692996f, -0.02242134f, 
    -0.02496497f, -0.00086932f, -0.03360622f, 0.03403918f, -0.02860951f, -0.02242526f, 0.00671211f, -0.01504467f, 
    -0.01432241f, -0.02519736f, -0.02534782f, 0.00547181f, -0.01731596f, -0.02874645f, 0.02342420f, 0.00485632f, 
    0.00916340f, 0.00882808f, 0.00851099f, -0.00433556f, -0.03792854f, -0.01019034f, -0.02098379f, -0.01481996f, 
    -0.01688441f, -0.00207756f, -0.01666187f, 0.03013555f, 0.02079932f, -0.03091385f, 0.02874983f, 0.02931527f, 
    0.00978623f, 0.02187789f, 0.00578848f, 0.01549264f, -0.03473842f, 0.00357256f, -0.00805971f, -0.03946404f, 
    -0.02774609f, -0.03658192f, -0.01004862f, -0.03481762f, -0.03040371f, 0.00425520f, 0.02215043f, 0.02867980f, 
    0.01003050f, -0.03131889f, 0.02082247f, -0.01980646f, -0.01151199f, -0.01915220f, -0.03698406f, 0.02690672f, 
    0.00275738f, -0.00736361f, -0.01544120f, 0.01812397f, 0.02516231f, -0.00322739f, -0.00625713f, -0.02111105f, 
    0.02544828f, 0.00614539f, 0.02259062f, -0.03097146f, -0.02047714f, 0.01816051f, -0.01046069f, -0.01130810f, 
    -0.01815538f, -0.01082920f, -0.00935973f, -0.00353729f, 0.01471017f, 0.01062110f, -0.03456254f, 0.00238512f, 
    0.02319391f, 0.02617602f, 0.00226121f, 0.02184422f, -0.03287086f, -0.03325791f, -0.03138101f, 0.00400507f, 
    0.01086309f, -0.04100247f, 0.00842230f, -0.00982121f, -0.03169649f, -0.04082314f, -0.01087472f, 0.00217504f, 
    -0.00262671f, 0.00212106f, -0.01032275f, 0.01464915f, -0.00987485f, -0.01049145f, 0.01903142f, 0.01608145f, 
    0.00985950f, -0.03209373f, -0.00245803f, -0.01795075f, 0.00846375f, -0.02378958f, 0.02579385f, -0.03189079f, 
    0.02225684f, 0.01975422f, -0.00167245f, -0.03577291f, 0.00723851f, 0.02243062f, 0.00910941f, 0.01851479f, 
    -0.00227765f, -0.00388671f, 0.02512996f, 0.02716271f, 0.00447121f, -0.00825495f, 0.00629493f, -0.03209896f, 
    -0.03291042f, -0.01910725f, -0.02642719f, -0.00766770f, 0.03005289f, -0.01685566f, -0.03825973f, -0.02063262f, 
    -0.01104632f, -0.01348769f, 0.00732881f, -0.02064584f, -0.02793491f, 0.00443286f, 0.00147701f, 0.02798567f, 
    0.00543475f, -0.03554440f, 0.00538797f, 0.01786529f, -0.00584583f, -0.01817249f, 0.01685790f, -0.01704499f, 
    0.02467840f, -0.02430719f, -0.00799804f, -0.01223334f, 0.01418751f, -0.00584727f, 0.01639874f, 0.00204966f, 
    0.01649240f, -0.01284099f, 0.00294727f, 0.00673483f, -0.03380667f, 0.01321842f, -0.01832955f, -0.03303610f, 
    0.00631330f, -0.02576658f, 0.00368074f, -0.00526970f, -0.00447945f, -0.02878661f, 0.00947397f, -0.03440496f, 
    -0.03270463f, -0.02822229f, -0.03540239f, -0.01442068f, 0.00261140f, 0.00825724f, 0.02405616f, 0.01372663f, 
    0.01264833f, 0.00363050f, -0.01224511f, 0.02283775f, -0.03016572f, -0.02250732f, -0.00246309f, 0.01310392f, 
    0.02400508f, 0.02302123f, -0.03177384f, 0.02521930f, -0.03063712f, -0.02115271f, 0.00010651f, -0.02102705f, 
    0.03807518f, -0.03066588f, 0.01363632f, 0.03705966f, 0.01009281f, -0.02713764f, 0.00884363f, -0.01874771f, 
    -0.00595178f, -0.02046177f, -0.00370886f, -0.01722347f, -0.03586712f, 0.02526115f, 0.02768439f, -0.02998267f, 
    0.00653386f, 0.01155088f, -0.03412194f, -0.00101470f, 0.00856120f, 0.02549943f, 0.00938545f, 0.00846871f, 
    0.02697156f, -0.02674988f, -0.00792698f, 0.01557535f, -0.03826847f, 0.00366180f, -0.00423908f, -0.01682783f, 
    -0.03101246f, -0.00572714f, 0.02548055f, 0.00992149f, -0.00211405f, -0.00629015f, 0.02172938f, -0.01689064f, 
    -0.00898579f, 0.01042319f, -0.00551826f, 0.01592341f, 0.00917836f, -0.02125236f, 0.01890199f, 0.02443718f, 
    0.02645150f, -0.01083614f, 0.00225409f, 0.00327204f, 0.01773174f, -0.03201282f, 0.03017385f, -0.00363905f, 
    0.00911817f, 0.03016989f, -0.01507540f, -0.02033607f, -0.00326247f, 0.02878627f, 0.00071369f, 0.00182346f, 
    -0.02831888f, 0.01067944f, -0.03330142f, -0.03369776f, -0.01717751f, -0.03116341f, 0.03200278f, -0.03928469f, 
    -0.00881711f, 0.02206129f, -0.02459495f, -0.02501835f, -0.04171239f, -0.03421215f, -0.03221826f, 0.00553010f, 
    -0.03754922f, -0.02000967f, 0.01387231f, 0.02254366f, 0.02058280f, -0.03152095f, -0.03272858f, 0.01229789f, 
    0.03263329f, 0.00790211f, -0.02394658f, 0.00368648f, 0.01837794f, 0.02172507f, -0.02635315f, 0.02992358f, 
    0.00347334f, -0.02011373f, -0.03763786f, 0.00478242f, 0.00255812f, 0.00003419f, -0.01875770f, 0.00517987f, 
    -0.01865469f, 0.01896607f, 0.02304133f, -0.01595303f, 0.01258955f, 0.01553447f, 0.00067471f, -0.02067075f, 
    -0.03656014f, 0.02616036f, -0.02666226f, -0.03313044f, -0.02380802f, 0.01375445f, 0.01655142f, -0.02237050f, 
    -0.00763768f, -0.02777502f, 0.02143898f, -0.01818980f, -0.03329305f, 0.03114083f, -0.03926819f, 0.02805949f, 
    0.02618862f, -0.00911545f, 0.02346482f, 0.00007614f, -0.02404290f, -0.01913989f, -0.03851055f, -0.01909520f, 
    0.00744523f, -0.00507875f, -0.03072250f, 0.00344206f, 0.02829031f, 0.01173043f, -0.03382124f, -0.00575633f, 
    0.00754828f, -0.03417889f, 0.01047101f, 0.01693675f, -0.01153848f, -0.02724866f, 0.03449620f, -0.02675582f, 
    0.02675754f, -0.02525301f, -0.03697842f, -0.00650731f, -0.01446683f, -0.02520177f, -0.02494912f, -0.02105945f, 
    -0.01310579f, -0.01244580f, -0.01861920f, -0.02294930f, 0.01585569f, -0.02829178f, -0.03469922f, 0.00194794f, 
    0.02555352f, -0.01768679f, 0.01083686f, -0.03657271f, -0.02507054f, -0.02303430f, 0.00779105f, 0.00718818f, 
    -0.01383726f, -0.04704606f, -0.00709243f, -0.01069992f, 0.02233733f, 0.02881033f, 0.01682383f, 0.03267016f, 
    -0.02148431f, 0.01696015f, -0.03567750f, -0.03122309f, 0.01824029f, -0.03197948f, -0.01915078f, 0.01912712f, 
    0.00634164f, -0.00601745f, -0.00026901f, -0.03852032f, 0.00318244f, -0.02670358f, 0.01653293f, -0.01110611f, 
    -0.00798862f, -0.03603287f, 0.03297624f, -0.01854926f, 0.00171604f, -0.03013352f, -0.03386083f, 0.02172522f, 
    0.01557172f, -0.03224555f, 0.00812475f, 0.00705996f, -0.03479310f, 0.03008883f, 0.01171078f, -0.01490732f, 
    -0.00299847f, 0.00812517f, -0.02141211f, -0.01450088f, 0.02060440f, -0.01789733f, -0.02677705f, 0.02451446f, 
    -0.00113841f, 0.00816324f, -0.03278099f, -0.03677761f, -0.01866816f, 0.01849113f, -0.01596877f, -0.00439080f, 
    -0.00775491f, -0.02977916f, 0.01554521f, 0.01805787f, -0.00358906f, -0.02101836f, 0.01810978f, 0.01658978f, 
    0.02960814f, 0.02307328f, 0.02546761f, 0.00371248f, -0.03224107f, -0.01588017f, -0.01144357f, -0.01349251f, 
    -0.00421859f, 0.00602415f, 0.01284518f, -0.02514765f, -0.00094582f, 0.02624926f, 0.01906096f, 0.00984844f, 
    -0.02014506f, -0.03387531f, 0.01359516f, -0.02073854f, 0.02550756f, 0.03159226f, 0.02192378f, 0.02907422f, 
    -0.00593209f, -0.02929813f, -0.03162040f, -0.00163330f, -0.00571015f, -0.02246561f, -0.00579948f, -0.02073549f, 
    -0.00002501f, 0.01563801f, 0.00699650f, -0.02328906f, -0.01426136f, -0.02419802f, -0.00138565f, -0.00131245f, 
    0.01746720f, -0.00831208f, 0.01592427f, 0.00132213f, 0.00210230f, 0.02032102f, 0.00606446f, 0.02096828f, 
    -0.00318921f, 0.01088551f, -0.00290553f, 0.01055257f, -0.02604422f, -0.01188857f, 0.01475368f, 0.02624419f, 
    -0.01063081f, -0.00591870f, 0.00875166f, -0.04258969f, 0.02134386f, -0.02124296f, 0.01871772f, -0.03522420f, 
    -0.00572295f, -0.02527795f, -0.02411857f, -0.02664380f, -0.02565425f, -0.01616859f, 0.03160449f, 0.01977558f, 
    -0.02902360f, -0.02263268f, -0.03464834f, -0.01598031f, -0.02338844f, 0.01069015f, 0.00572524f, 0.01020702f, 
    0.00655508f, -0.03483578f, 0.02210399f, 0.00174116f, 0.02084182f, -0.00009233f, 0.02139836f, 0.02177311f, 
    -0.04372429f, 0.02936567f, -0.02983006f, 0.03100591f, 0.00093128f, -0.02400045f, -0.01648017f, -0.03484883f, 
    -0.03931671f, -0.03105099f, -0.00703053f, -0.01854814f, -0.00722020f, 0.01165604f, -0.01761247f, 0.02918010f, 
    0.01505687f, 0.00186964f, 0.01428055f, -0.03629956f, -0.00852701f, -0.00199285f, -0.02257038f, -0.01482613f, 
    0.00182654f, -0.03072258f, 0.01699475f, 0.00813405f, -0.02655219f, 0.00652671f, 0.02743943f, -0.02117852f, 
    0.00928168f, -0.01251391f, 0.00022225f, 0.01487650f, 0.01215842f, 0.03044318f, 0.02103363f, 0.01757196f, 
    -0.00871423f, -0.00123120f, 0.02056877f, 0.01101165f, 0.02960427f, 0.01411304f, 0.02074140f, -0.02394468f, 
    0.02044135f, -0.03812480f, -0.02364303f, 0.02167807f, -0.01718262f, -0.03836194f, -0.00842151f, -0.02725991f, 
    0.00141821f, -0.00611564f, -0.00907945f, 0.01675663f, 0.01153480f, -0.00496894f, 0.01825302f, -0.02717122f, 
    0.01395984f, -0.03799701f, 0.02179935f, -0.02577886f, -0.03497118f, -0.00556001f, -0.01578248f, 0.02720610f, 
    -0.03373886f, 0.00305086f, 0.01325478f, -0.03432184f, -0.02020326f, -0.03635028f, -0.02091605f, -0.01731252f, 
    0.01508118f, 0.01619380f, -0.03635249f, -0.01328341f, -0.01894747f, -0.03505516f, -0.02084453f, -0.04294124f, 
    -0.03988033f, -0.03302408f, -0.00633136f, -0.01324889f, -0.03043729f, -0.01030832f, -0.02189574f, -0.03337990f, 
    -0.01777620f, -0.00913416f, -0.00495991f, -0.00053209f, -0.00064247f, 0.00837974f, 0.02831245f, 0.00846394f, 
    -0.03618723f, 0.01802490f, -0.03158468f, -0.00191777f, 0.00198329f, -0.01903590f, 0.00941378f, -0.03647184f, 
    0.00354100f, 0.01530677f, -0.00590112f, 0.02059872f, -0.03921496f, -0.00701882f, -0.00266413f, -0.01989319f, 
    0.01398325f, 0.02051781f, 0.00012746f, -0.03009711f, -0.04205056f, 0.01890770f, -0.04069928f, -0.00640599f, 
    0.00849523f, -0.03645859f, 0.01209569f, 0.00445956f, 0.00525369f, 0.03106870f, 0.00959088f, 0.03059755f, 
    0.03013088f, 0.02182941f, 0.00015433f, -0.03575692f, 0.00816987f, -0.04307678f, -0.00032100f, -0.02878720f, 
    -0.03444741f, 0.00252667f, -0.00659060f, -0.01343489f, -0.01205271f, -0.02983820f, 0.01117068f, -0.01903445f, 
    0.00604303f, 0.01999292f, 0.00738202f, -0.00838618f, -0.02160427f, 0.01690830f, -0.03440788f, 0.00409751f, 
    0.00462663f, -0.00789805f, -0.01386162f, -0.02408581f, -0.01402224f, 0.00655831f, 0.02296219f, -0.01369954f, 
    0.00238298f, 0.00914648f, 0.00015378f, 0.03089323f, -0.03298425f, -0.00314900f, -0.00269355f, 0.01629538f, 
    -0.02282757f, -0.01758386f, -0.03096024f, 0.01081184f, 0.02547310f, 0.00359747f, -0.04123512f, -0.01342000f, 
    0.00648420f, -0.03272308f, -0.03930466f, 0.01238542f, -0.01106890f, 0.01772548f, 0.02917599f, 0.00279509f, 
    -0.01612917f, 0.02189554f, -0.01931984f, 0.01097548f, -0.01621441f, -0.03990785f, -0.00863006f, -0.01564927f, 
    0.03422932f, -0.03794364f, 0.01664569f, -0.00990006f, -0.02701123f, 0.03140533f, -0.02336840f, -0.01206960f, 
    0.00454094f, -0.03448139f, 0.00037410f, -0.02317331f, -0.01275974f, -0.00212349f, -0.02630019f, -0.03349253f, 
    0.00161282f, -0.01278063f, -0.03247455f, -0.03365075f, 0.00106956f, -0.03738016f, 0.02922648f, 0.00826014f, 
    -0.02407959f, 0.01660885f, -0.00134207f, -0.02488711f, -0.00991510f, -0.03356218f, 0.00068129f, -0.03203339f, 
    0.01016248f, -0.02393212f, -0.02470275f, 0.02264213f, -0.01214212f, 0.02163300f, 0.01762821f, 0.00673823f, 
    -0.00506831f, -0.02401855f, -0.01315771f, 0.01581344f, -0.02818806f, -0.00126228f, -0.02784277f, 0.02996562f, 
    -0.03165203f, 0.02667409f, -0.01942421f, 0.00821474f, -0.02145407f, 0.00879252f, 0.02309708f, -0.01678467f, 
    -0.01089446f, -0.02174276f, 0.02886587f, -0.01094144f, 0.02465166f, -0.00432189f, 0.01494440f, 0.00593330f, 
    0.01028680f, 0.01727722f, 0.01190554f, -0.03988365f, -0.01345112f, -0.00974231f, 0.03036113f, -0.00679823f, 
    -0.03190273f, -0.01466805f, -0.01877712f, -0.03020834f, 0.02674891f, 0.01708381f, 0.00557032f, -0.02270412f, 
    0.01329954f, -0.01603683f, -0.02463223f, 0.01714954f, -0.01022147f, -0.01338661f, -0.03401493f, 0.02115704f, 
    0.00051990f, -0.03909837f, -0.00795999f, -0.00476786f, 0.01508234f, -0.02696477f, 0.01424342f, 0.02342238f, 
    0.02371816f, -0.01642083f, -0.00247074f, 0.00895569f, -0.03411855f, 0.01736814f, 0.02752856f, -0.03466188f, 
    0.03162070f, 0.00700013f, 0.02423653f, -0.01371047f, -0.03279957f, 0.01820596f, -0.03338189f, 0.02242002f, 
    0.02880190f, -0.00301399f, -0.03785656f, -0.03606050f, -0.01282543f, -0.02691652f, 0.01968595f, 0.02223778f, 
    -0.00800168f, 0.02666620f, 0.00486026f, 0.00499398f, 0.01836318f, -0.03105796f, -0.02788910f, 0.02924687f, 
    -0.01482724f, -0.02943365f, 0.02541422f, 0.03102314f, -0.00602127f, -0.00403458f, -0.01666864f, 0.01614193f, 
    -0.00769206f, -0.04045182f, 0.02693366f, -0.00311118f, -0.03764285f, -0.00158892f, -0.01759815f, 0.02557585f, 
    -0.03355217f, -0.03407809f, -0.02287284f, 0.02235400f, -0.01098516f, 0.01451079f, -0.00936917f, 0.00195719f, 
    0.02995860f, -0.03672872f, 0.01344080f, -0.04387161f, -0.03411179f, 0.01103143f, 0.00723601f, -0.03887095f, 
    0.01021261f, -0.02551849f, -0.00458192f, 0.01393591f, -0.00572739f, 0.01736105f, 0.02297918f, 0.00773804f, 
    0.01004431f, -0.03575255f, 0.02339427f, 0.02289331f, 0.00555247f, -0.03289177f, -0.00123981f, 0.00102476f, 
    -0.00437372f, -0.00476542f, 0.00308235f, -0.04073371f, -0.01809038f, -0.00840099f, -0.02677519f, -0.02008943f, 
    -0.03839865f, 0.03330532f, 0.00391962f, 0.03105559f, -0.01959307f, -0.03077673f, -0.03741915f, -0.03502917f, 
    0.02498698f, -0.00461228f, 0.01235646f, -0.01712531f, -0.02795427f, -0.00726898f, -0.02229794f, 0.02359118f, 
    -0.02991222f, 0.02448067f, -0.00145435f, -0.00213950f, -0.03225504f, 0.00746373f, -0.00833273f, 0.00430422f, 
    -0.00191707f, -0.03837686f, -0.00977613f, -0.00291371f, 0.00575302f, 0.02582732f, -0.02253223f, -0.03137524f, 
    0.00603254f, 0.03091709f, -0.04252212f, -0.01781522f, -0.03145194f, 0.01092705f, -0.01358566f, -0.01711828f, 
    -0.03747578f, 0.02010875f, 0.02224193f, -0.00378228f, 0.00136872f, 0.02719592f, 0.01574468f, 0.00832260f, 
    0.03253106f, -0.00150225f, 0.00344746f, -0.01448132f, 0.01751318f, 0.01717661f, 0.01111838f, -0.04373320f, 
    -0.00511859f, 0.02159755f, 0.02155446f, -0.01653532f, 0.00833212f, 0.00823899f, -0.02903944f, -0.01230578f, 
    0.02378328f, 0.00372324f, 0.01579951f, -0.00159893f, -0.02278049f, 0.01458436f, 0.03169980f, 0.01521545f, 
    -0.00335617f, -0.03456400f, 0.02481616f, -0.01086892f, -0.00889321f, -0.02942743f, -0.04321384f, 0.02069597f, 
    -0.03011891f, 0.02782932f, 0.01261126f, -0.02708711f, -0.00190692f, 0.02197362f, -0.03536130f, 0.02571989f, 
    -0.04330865f, 0.01029566f, -0.03049684f, -0.01490533f, 0.00740480f, -0.03898213f, -0.01599445f, 0.00427233f, 
    -0.00822239f, -0.02575637f, 0.02516076f, -0.00808362f, -0.02640141f, -0.02557014f, 0.00902529f, 0.00551130f, 
    -0.00802832f, -0.01362048f, -0.03554837f, -0.03143615f, 0.02929141f, -0.00719553f, -0.00719164f, -0.01455787f, 
    -0.02410824f, 0.00880280f, 0.02122261f, -0.00269137f, 0.01155649f, 0.00495370f, 0.03083251f, 0.00562680f, 
    0.25984305f, 0.20608293f, -0.01810427f, -0.02342699f, 0.02195717f, 0.12919368f, -0.14474310f, 0.07824088f, 
    -0.05019208f, 0.00070166f, 0.04895001f, 0.00143063f, 0.17763171f, 0.10722212f, -0.06658613f, 0.19566369f, 
    -0.00108235f, 0.03475327f, 0.15622307f, 0.01620775f, -0.01005253f, 0.06016595f, 0.09239098f, 0.11509472f, 
    -0.17203882f, -0.03898034f, 0.09775752f, 0.09039748f, -0.04982750f, 0.17376412f, -0.05953486f, 0.00854484f, 
    -0.02502398f, -0.01082822f, -0.09533928f, -0.05088766f, 0.10542828f, 0.09691127f, -0.10007195f, 0.18610473f, 
    -0.08073745f, 0.01046112f, 0.17565452f, 0.07828815f, -0.00325157f, -0.01983675f, 0.05344505f, 0.13151230f, 
    -0.14142475f, -0.04898408f, 0.15209313f, 0.02787007f, -0.01759723f, -0.05516678f, -0.03071222f, -0.01758000f, 
    0.09687299f, 0.01500467f, -0.11624769f, 0.13933969f, 0.08057699f, -0.02155571f, 0.15012378f, 0.00767190f, 
    0.06519727f, 0.04348065f, -0.02137291f, 0.07607143f, -0.04926964f, 0.01656037f, -0.01413945f, 0.10806512f, 
    0.03463482f, 0.08094656f, 0.02924486f, 0.16616766f, -0.02246980f, -0.01060048f, -0.01727488f, 0.05029018f, 
    -0.02573601f, 0.15955539f, 0.07710637f, 0.03135007f, 0.04234188f, 0.04630276f, 0.06933028f, -0.07799184f, 
    -0.01858198f, 0.23915197f, -0.01512676f, 0.05051892f, 0.06866465f, -0.01273387f, -0.05147239f, 0.10525198f, 
    -0.12211692f, 0.01699857f, 0.11827217f, -0.04720219f, 0.04859754f, 0.09556901f, 0.00330918f, 0.00135464f, 
    0.02620005f, 0.03408328f, -0.13851008f, -0.00996925f, -0.22906558f, 0.01557093f, 0.16730492f, -0.00401844f, 
    -0.03886913f, 0.01652362f, -0.02999581f, -0.11399699f, 0.04294186f, 0.07953926f, 0.01554262f, -0.00249646f, 
    0.17658429f, 0.05270196f, -0.08225948f, 0.11888883f, 0.02912934f, -0.03046297f, 0.10930465f, 0.31084692f, 
    0.03981347f, 0.17619136f, 0.13700211f, 0.17835195f, 0.10801429f, -0.21306470f, 0.03098600f, 0.05469595f, 
    -0.04419070f, 0.11673696f, -0.08341105f, 0.04967411f, 0.14218134f, -0.02257964f, 0.07211892f, -0.04846989f, 
    0.45781055f, 0.12467491f, 0.00292738f, -0.12944302f, 0.07431861f, 0.00395404f, 0.02298426f, -0.06488690f, 
    -0.04953144f, -0.06019964f, 0.09911064f, 0.18823135f, 0.26052663f, -0.01094040f, 0.07650836f, 0.15217970f, 
    -0.15155025f, -0.01809236f, -0.06553089f, 0.03727260f, -0.04586599f, 0.05951606f, 0.15599963f, 0.02175138f, 
    -0.01469239f, -0.00704954f, -0.11775551f, 0.03940485f, 0.03045517f, 0.04427016f, 0.03783217f, 0.09444918f, 
    0.11063962f, 0.05967729f, 0.06218410f, 0.10769504f, -0.19888347f, 0.08730049f, 0.00621094f, 0.12663749f, 
    -0.12087652f, 0.09934258f, -0.08342172f, 0.12466514f, 0.03158349f, 0.04762725f, 0.02312740f, -0.05067345f, 
    -0.07936351f, -0.13890214f, -0.05011763f, 0.06447003f, -0.00113176f, 0.01830508f, 0.00201214f, -0.06435495f, 
    -0.01661088f, 0.06042090f, 0.11216962f, -0.04341181f, -0.07687105f, 0.13829029f, 0.07424535f, 0.08226752f, 
    -0.04148215f, 0.05422997f, -0.12609600f, 0.01570571f, -0.13104106f, -0.01061270f, -0.01875381f, 0.07601839f, 
    -0.15766183f, 0.00413894f, -0.06274873f, -0.05422246f, 0.03895094f, 0.06899302f, -0.05025726f, -0.00201509f, 
    -0.03075507f, 0.22709219f, 0.08114280f, -0.01687738f, 0.09106454f, 0.15698032f, 0.07827699f, 0.15021658f, 
    0.03772123f, 0.07804881f, 0.00392460f, 0.05505321f, 0.00985170f, -0.09460124f, 0.09736983f, 0.06268495f, 
    -0.24792252f, -0.17877214f, -0.03591318f, -0.02963123f, -0.04788839f, 0.04116352f, 0.04188154f, -0.09857849f, 
    0.07246202f, 0.01890130f, 0.13397588f, -0.12626670f, 0.29171476f, 0.28688312f, -0.14136763f, -0.09405926f, 
    -0.12890041f, 0.05482010f, 0.14020126f, -0.01974851f, 0.06508488f, -0.09044072f, -0.04851000f, 0.19523564f, 
    -0.07093239f, -0.17280386f, -0.02850807f, 0.00827293f, -0.12363368f, 0.17611952f, -0.09073384f, -0.10997003f, 
    -0.06178334f, 0.01199260f, -0.13790153f, 0.07555426f, -0.00068312f, 0.06640455f, -0.06043513f, -0.00172874f, 
    -0.07525702f, -0.03634449f, -0.02230596f, -0.04658020f, -0.08865088f, 0.05107259f, 0.06615922f, -0.14029188f, 
    0.02672254f, -0.05567850f, -0.05910933f, -0.07782197f, -0.10735363f, 0.15447527f, 0.01237227f, -0.05326765f, 
    0.02542813f, -0.10686036f, 0.02158013f, -0.11333487f, 0.09020359f, 0.12779438f, 0.03532075f, 0.07297469f, 
    0.00724556f, -0.06217644f, 0.14183716f, 0.13038646f, 0.07636730f, 0.18066677f, -0.01576233f, 0.05301608f, 
    -0.28699049f, 0.09364723f, 0.03646575f, -0.11954278f, -0.00170097f, -0.07037418f, -0.12894519f, -0.07940155f, 
    -0.03870170f, -0.12038856f, -0.04834345f, 0.01583159f, 0.24433158f, 0.13218106f, -0.09528793f, -0.07764276f, 
    0.03615643f, -0.00541554f, 0.02050762f, 0.02778325f, -0.03792298f, 0.06266247f, -0.03713356f, 0.10870726f, 
    0.02776280f, 0.05080763f, 0.03026511f, 0.19434236f, -0.07048503f, 0.10079410f, 0.16142713f, -0.02293113f, 
    0.05065632f, 0.04116296f, -0.08310641f, -0.16066211f, -0.06751071f, 0.07032841f, -0.12161944f, 0.06349382f, 
    0.04802009f, 0.10877256f, 0.21980327f, 0.01079852f, -0.01073460f, -0.06269725f, 0.06571001f, 0.09378969f, 
    -0.04047098f, -0.04653016f, 0.02164734f, 0.06352856f, -0.09420174f, -0.04100348f, -0.01969629f, -0.09483545f, 
    0.04824061f, -0.16146195f, -0.04410433f, -0.12247792f, 0.18273488f, 0.00636952f, 0.12065855f, 0.04509979f, 
    -0.01810488f, 0.08432133f, 0.14548737f, 0.04306133f, 0.08881374f, 0.03932097f, 0.13783821f, 0.08383901f, 
    -0.05609769f, 0.09888902f, 0.11498640f, -0.04770831f, 0.05247763f, 0.05246583f, 0.04545143f, 0.02720546f, 
    0.12205855f, -0.23533514f, -0.08230001f, -0.15407690f, 0.39416862f, 0.02344409f, 0.04467462f, 0.01059729f, 
    0.00273995f, -0.04647776f, 0.12337579f, -0.02948534f, 0.00663270f, 0.08017946f, -0.15026887f, -0.03274010f, 
    0.05602786f, 0.13873571f, 0.10711653f, -0.00386771f, 0.07449307f, -0.06993999f, 0.08237150f, -0.02401365f, 
    -0.04542148f, 0.13633975f, -0.06020215f, 0.07660670f, 0.06705067f, 0.08368307f, 0.03196786f, 0.02530540f, 
    0.01769679f, -0.03737154f, 0.00649349f, 0.05861089f, -0.03150957f, 0.07667036f, 0.05178002f, -0.04720495f, 
    0.03822574f, -0.03934965f, 0.11915546f, 0.00309041f, -0.02317064f, 0.06913307f, 0.10751420f, 0.05067710f, 
    -0.04675655f, -0.06439495f, 0.16885146f, 0.10458469f, 0.21469478f, -0.01617432f, 0.08455679f, -0.06093200f, 
    -0.02474151f, -0.03298543f, 0.00127710f, -0.08441831f, 0.01733659f, -0.00809350f, 0.01425536f, -0.03583671f, 
    0.01289025f, 0.18984054f, 0.00850166f, 0.14584051f, -0.06885824f, -0.05250929f, 0.06127037f, 0.06886113f, 
    0.07695211f, 0.02863254f, 0.08402947f, 0.04833241f, 0.04153785f, 0.12962905f, -0.01558258f, 0.13459192f, 
    -0.00675678f, 0.08586299f, -0.02976772f, -0.07194234f, 0.03071343f, -0.02246207f, -0.01325917f, 0.00457558f, 
    0.07409977f, 0.01861840f, -0.01454287f, -0.03362566f, 0.00219384f, 0.07620879f, 0.09342750f, 0.02261355f, 
    -0.00959378f, -0.15889874f, 0.08299296f, 0.00156711f, -0.08119091f, 0.00295457f, -0.04667066f, -0.13002254f, 
    -0.13694426f, 0.05952741f, -0.01076946f, 0.02257943f, -0.10451405f, 0.01264683f, 0.02223857f, -0.01605713f, 
    -0.04932124f, 0.21725574f, -0.07186630f, 0.06022400f, -0.00227991f, 0.00667439f, 0.03994564f, 0.06723712f, 
    0.04761063f, -0.09647973f, 0.14769426f, -0.12155977f, 0.13549218f, -0.00556390f, 0.02294738f, -0.06356074f, 
    -0.02386211f, 0.03836095f, -0.06132257f, 0.08388450f, 0.09035348f, -0.10299230f, 0.03073663f, -0.00277316f, 
    0.21556194f, -0.03179540f, -0.03277440f, -0.02782519f, 0.03210287f, 0.08829581f, 0.12954785f, -0.09427578f, 
    0.07327400f, 0.02504368f, 0.01743326f, 0.06503532f, -0.36432037f, -0.16483314f, -0.06977513f, 0.09067032f, 
    -0.05733079f, 0.11156233f, 0.03332178f, 0.14019795f, 0.07181851f, 0.08281104f, -0.00613375f, -0.07764275f, 
    -0.19788438f, -0.03653716f, 0.10737625f, 0.14511929f, 0.05537843f, 0.03173753f, 0.08024301f, -0.04579984f, 
    0.02626715f, -0.07009484f, 0.08441706f, -0.02927729f, -0.18889137f, 0.08008786f, 0.09968228f, 0.16284816f, 
    -0.07254240f, 0.07958967f, 0.15518226f, 0.17114356f, -0.04256386f, 0.05996649f, 0.05940083f, 0.07761765f, 
    -0.13996217f, 0.06590611f, -0.01432959f, 0.12665473f, -0.05591472f, -0.12927024f, 0.04725672f, 0.05737782f, 
    -0.01581194f, 0.04963914f, -0.03289062f, 0.07151771f, 0.37825197f, 0.19847944f, 0.11139842f, -0.07562053f, 
    0.06901582f, -0.01416235f, 0.11227043f, 0.07238390f, -0.04112209f, 0.02829746f, -0.05252664f, -0.07891615f, 
    0.21605997f, 0.02127249f, 0.03509551f, 0.02127625f, -0.08723322f, -0.02866778f, 0.08493716f, -0.01049217f, 
    0.08526124f, -0.02505030f, -0.17562632f, 0.04827233f, -0.15922959f, 0.18574248f, -0.04426429f, -0.04504165f, 
    0.04174966f, 0.14686978f, 0.08161666f, 0.09261815f, 0.10764784f, 0.13708456f, 0.06089466f, -0.01320022f, 
    -0.17381342f, 0.14786145f, 0.17924738f, 0.05942054f, -0.05369083f, -0.07605664f, 0.00810579f, 0.03015341f, 
    -0.00227910f, 0.05504176f, 0.10689947f, -0.14157672f, -0.17292592f, -0.08433058f, -0.01512410f, -0.08846632f, 
    0.00832332f, 0.08443277f, 0.01413152f, 0.07196866f, -0.02465777f, 0.05009278f, -0.01770579f, -0.13255678f, 
    0.04259720f, 0.16219686f, -0.11131517f, 0.13808168f, -0.02256921f, 0.04138948f, 0.03251367f, 0.08675021f, 
    0.05011300f, 0.10722493f, 0.01884422f, 0.17727847f, -0.00472359f, 0.18614590f, 0.10691738f, -0.04475695f, 
    -0.03226429f, 0.02883651f, 0.04067800f, -0.02814472f, -0.00412307f, -0.02835858f, 0.01434228f, -0.16600895f, 
    0.10359516f, -0.11371374f, -0.00892083f, -0.02957522f, 0.00443545f, -0.02337235f, 0.06063129f, 0.04160985f, 
    0.05054147f, 0.04979806f, -0.02557662f, 0.17261560f, -0.12420883f, 0.17803223f, 0.17065890f, 0.00353026f, 
    0.01874745f, -0.03696265f, -0.11595614f, 0.10645162f, 0.03597989f, -0.12516052f, -0.04230148f, -0.06463234f, 
    0.00111076f, 0.10826103f, 0.15940052f, -0.03749644f, -0.00449301f, 0.01171112f, -0.02203785f, 0.07992008f, 
    -0.02917596f, 0.00543203f, 0.13464577f, 0.11757508f, -0.20988512f, -0.01015557f, 0.03294399f, 0.00342691f, 
    0.10280974f, 0.04178189f, -0.13506509f, 0.04740458f, -0.02443277f, 0.11553845f, -0.05857695f, 0.18034369f, 
    0.25124869f, 0.07972832f, 0.05006559f, 0.00409414f, 0.06009537f, 0.02286082f, 0.09452202f, 0.12238902f, 
    0.05266814f, 0.07296467f, -0.13269010f, 0.08984492f, -0.01662879f, 0.02836304f, -0.01723070f, 0.06499642f, 
    0.06901362f, 0.01102699f, 0.04667027f, 0.14858861f, 0.07959618f, -0.00390530f, 0.20656216f, 0.09127637f, 
    0.19194992f, -0.02198309f, -0.15767467f, -0.08230337f, 0.02300322f, 0.07853516f, 0.11020152f, -0.03432908f, 
    -0.02368767f, 0.11030652f, -0.00341830f, -0.00638149f, 0.14026727f, -0.04623774f, 0.09237961f, 0.01461689f, 
    0.02705172f, 0.11504599f, 0.10211325f, -0.04287373f, 0.03899394f, -0.02318775f, -0.07016022f, 0.07505792f, 
    -0.01676395f, -0.00281938f, 0.02290477f, 0.02511258f, 0.01867482f, 0.00003859f, -0.03760757f, 0.03046023f, 
    -0.01868512f, 0.01621532f, 0.00916692f, 0.01780688f, 0.00405962f, -0.00014613f, -0.03937639f, 0.00903187f, 
    -0.00092484f, -0.03270571f, -0.00143501f, 0.01718679f, -0.03213114f, -0.01969874f, 0.00671778f, -0.02779564f, 
    -0.00468783f, -0.01916274f, -0.03351068f, 0.01561702f, -0.03384125f, -0.00656450f, -0.00406099f, 0.01093133f, 
    -0.03314242f, 0.02468481f, -0.02492641f, -0.01790125f, 0.02068619f, 0.02117538f, -0.03422992f, 0.01558034f, 
    0.00531989f, 0.00806567f, -0.03121079f, -0.03411605f, -0.03359119f, 0.02149169f, 0.02066767f, -0.02379835f, 
    -0.02822336f, -0.02655523f, -0.03600395f, -0.00947660f, -0.00469265f, -0.03123873f, -0.01534353f, -0.01237032f, 
    -0.00010725f, 0.01484443f, 0.01298650f, 0.01293810f, 0.01828773f, 0.02287777f, -0.04304868f, -0.03229426f, 
    0.00392460f, 0.00620767f, 0.03312096f, 0.01480802f, -0.03601389f, -0.03941747f, 0.01295936f, 0.03263964f, 
    -0.01625635f, -0.02488605f, -0.03197777f, -0.03214868f, -0.01469901f, -0.00188445f, -0.03686107f, 0.01412670f, 
    0.00435646f, 0.02384445f, -0.03023676f, 0.02954690f, -0.02244971f, 0.00695276f, 0.02766136f, -0.01680407f, 
    0.00688999f, -0.02597689f, -0.01009375f, -0.00927038f, 0.00580275f, 0.00385431f, 0.02723176f, -0.03935482f, 
    -0.03453036f, 0.01227479f, -0.03465062f, -0.02693908f, -0.00357240f, 0.01659853f, 0.02671974f, -0.01940993f, 
    -0.00374958f, -0.00383860f, -0.00918377f, -0.01379625f, 0.02422615f, 0.03132417f, 0.01543362f, 0.01067060f, 
    -0.03535138f, -0.00027884f, -0.03314343f, -0.01525745f, 0.00616866f, -0.00693292f, 0.02147666f, -0.01490449f, 
    0.01238579f, -0.01912725f, 0.03014660f, -0.02790237f, 0.00523909f, -0.02766778f, -0.00065865f, 0.01543214f, 
    -0.00002735f, -0.03574092f, -0.00434700f, 0.01926611f, -0.01200958f, -0.04082231f, 0.00462658f, 0.00305399f, 
    -0.01454746f, -0.02915655f, -0.02785089f, -0.03277164f, -0.02781466f, -0.03478088f, 0.01850317f, 0.01374936f, 
    -0.03076077f, -0.00158108f, -0.02417662f, -0.01829442f, -0.03088859f, -0.00341288f, 0.02378601f, 0.01437883f, 
    -0.01793584f, 0.01009541f, -0.02225989f, 0.01426046f, -0.01962991f, 0.01084533f, 0.03015734f, -0.02315209f, 
    -0.03384558f, -0.00282488f, -0.02638431f, -0.00655774f, -0.02733745f, -0.04276086f, -0.01208462f, 0.01199161f, 
    -0.01129836f, 0.01288666f, 0.01796732f, -0.03353127f, 0.01003001f, 0.01637475f, 0.00561540f, 0.00667065f, 
    -0.00119395f, -0.01630842f, -0.00420996f, -0.01772678f, -0.02988613f, -0.01017210f, -0.01941441f, -0.03133576f, 
    0.00601420f, -0.01778192f, 0.02556111f, -0.01046201f, 0.00058584f, -0.03637291f, 0.01883629f, 0.00245110f, 
    -0.02033322f, 0.01739570f, 0.02565454f, -0.00819625f, -0.00604171f, 0.02418149f, -0.03174972f, 0.02568901f, 
    0.01682100f, -0.01179890f, 0.02532455f, -0.02407464f, 0.02724819f, -0.02263912f, -0.02834460f, 0.00333007f, 
    0.02545185f, 0.01825073f, -0.01755580f, -0.01197167f, 0.01281821f, 0.02410494f, -0.00848671f, -0.01494809f, 
    -0.01393909f, -0.01407845f, 0.02294796f, 0.01444129f, -0.00366466f, -0.02852601f, 0.00129909f, 0.02711124f, 
    0.01308509f, 0.02910346f, 0.02128347f, 0.01193129f, 0.02630911f, 0.00778980f, -0.02314901f, -0.02881603f, 
    -0.02819782f, -0.01673162f, 0.03206406f, -0.03943790f, 0.00517114f, -0.00813160f, 0.00886701f, -0.03356149f, 
    -0.01363752f, 0.01704935f, 0.02324879f, 0.02087544f, -0.01832042f, -0.03676278f, -0.01261436f, -0.03507852f, 
    0.03068933f, 0.01853714f, -0.00933292f, -0.00541083f, 0.00668506f, 0.01157331f, 0.02993399f, -0.02179105f, 
    -0.01238735f, -0.01854053f, 0.01615443f, -0.00846442f, -0.00520918f, -0.01039270f, 0.00616132f, -0.03904390f, 
    -0.01322151f, 0.02880397f, -0.02951286f, -0.00125664f, -0.00081818f, -0.00266200f, -0.01949435f, 0.02587326f, 
    0.00743338f, 0.02668212f, -0.03858247f, -0.00439667f, -0.02295684f, -0.03064971f, -0.03176815f, 0.02751639f, 
    -0.03693096f, -0.00269180f, 0.01695790f, -0.00597191f, 0.00658182f, 0.01511958f, 0.02255977f, -0.00578581f, 
    0.00719028f, 0.01598603f, -0.03234468f, -0.02052253f, -0.00748301f, -0.01297272f, 0.00772156f, 0.02740737f, 
    -0.01062498f, 0.00888337f, 0.00260977f, 0.02806057f, 0.00729868f, 0.02592687f, 0.00402733f, -0.02033823f, 
    -0.00302613f, -0.01792753f, -0.02078756f, 0.01545963f, -0.03144981f, -0.01028460f, -0.01656417f, 0.01601825f, 
    -0.02283048f, 0.02227713f, -0.03124048f, 0.02164097f, 0.00871339f, -0.03708028f, -0.02588908f, -0.03240823f, 
    -0.01779595f, -0.01611233f, -0.03449487f, -0.00691798f, -0.04209873f, -0.03174944f, -0.03926520f, -0.01123108f, 
    -0.00394547f, -0.03442860f, -0.03568549f, -0.03297446f, 0.00824448f, 0.01033418f, 0.02332989f, -0.03614997f, 
    -0.04140382f, -0.01586931f, -0.00445652f, -0.01465611f, -0.01051035f, 0.01283744f, -0.00169016f, -0.04033820f, 
    -0.01054303f, -0.02323348f, 0.00599145f, -0.01333999f, -0.03564926f, 0.00200016f, -0.03558708f, -0.01428134f, 
    -0.03435637f, -0.01048710f, -0.02418264f, -0.03535108f, -0.00620357f, 0.00565737f, -0.01203900f, -0.02454903f, 
    0.01358895f, -0.02678623f, 0.00437233f, -0.00453982f, -0.00985445f, -0.03077332f, 0.02159387f, -0.04331078f, 
    0.01542108f, -0.03146579f, -0.04095088f, 0.01624718f, 0.00607236f, -0.00645568f, -0.02718466f, 0.01195673f, 
    -0.01844974f, -0.02112473f, 0.00780286f, 0.02228060f, -0.02147847f, -0.01258567f, 0.02528078f, 0.03144681f, 
    0.03429646f, 0.02895171f, 0.01094932f, -0.02008552f, -0.01859961f, 0.02844162f, 0.00083650f, -0.01127760f, 
    -0.00043290f, 0.01947125f, 0.02237642f, 0.02763714f, -0.02340995f, -0.02931155f, -0.01506084f, -0.03342920f, 
    -0.01570198f, 0.00990760f, 0.01198958f, -0.00805092f, 0.01742664f, 0.02218167f, -0.00832095f, -0.01203410f, 
    -0.02179494f, 0.01522547f, 0.03527424f, 0.00018548f, -0.01694353f, -0.02056960f, -0.01667300f, -0.01566540f, 
    0.03257018f, 0.02313254f, 0.00760426f, -0.01628414f, 0.02455397f, -0.00713014f, -0.02789691f, 0.02437492f, 
    -0.00012843f, -0.03804613f, 0.00046115f, 0.00992257f, -0.03651014f, -0.01521116f, -0.00661196f, 0.01019057f, 
    -0.01330569f, -0.02518628f, -0.00925805f, 0.02329326f, 0.02105021f, -0.03219975f, -0.03267669f, -0.00397251f, 
    0.00132355f, 0.01398110f, 0.02717800f, -0.02228026f, 0.00938079f, -0.00461456f, -0.03119651f, -0.00460894f, 
    -0.01891510f, 0.00892931f, 0.02702869f, 0.02185709f, 0.01914396f, 0.01722758f, -0.03603350f, 0.02414922f, 
    0.01492173f, -0.02053570f, -0.02723802f, 0.00927893f, 0.00725130f, -0.01650577f, 0.01706968f, 0.00983698f, 
    0.00603135f, -0.00897457f, -0.00271316f, -0.00447514f, -0.03935268f, 0.02509835f, -0.02609568f, -0.00624098f, 
    -0.00221516f, 0.01463361f, 0.01676093f, 0.00497484f, 0.00098353f, -0.00412154f, -0.03865342f, -0.02485539f, 
    -0.00421186f, 0.00213332f, -0.01241056f, 0.00575919f, 0.01166931f, -0.03990836f, 0.00333856f, 0.00809509f, 
    -0.02572905f, 0.00955669f, -0.02283547f, -0.03914473f, -0.00174396f, -0.02138880f, -0.00626056f, -0.02587966f, 
    0.01043548f, -0.03695647f, -0.00348783f, -0.00394911f, -0.01855911f, 0.03416732f, -0.03195335f, -0.00201881f, 
    -0.02569550f, -0.02078542f, 0.00521204f, -0.02362068f, -0.03039513f, -0.01742531f, -0.03195959f, 0.02429086f, 
    0.01359598f, -0.02124127f, -0.02406251f, 0.02975392f, -0.02845567f, -0.00018673f, 0.00044298f, 0.01858825f, 
    0.01976733f, -0.03232000f, -0.03206496f, -0.00275798f, 0.02588484f, -0.01574502f, 0.02585442f, -0.00121502f, 
    0.02803325f, -0.00691574f, -0.00964498f, -0.01898684f, -0.02424399f, -0.03794448f, -0.01879511f, -0.01308830f, 
    -0.02980667f, -0.03206843f, 0.01534828f, 0.00547984f, -0.02663934f, 0.00064345f, -0.03667364f, 0.02035923f, 
    -0.03500246f, 0.02100731f, -0.01936319f, -0.02392959f, -0.00360321f, -0.02337195f, 0.01474888f, -0.02163739f, 
    0.02105610f, -0.03907344f, -0.00786383f, -0.03600638f, -0.02974046f, -0.01135221f, -0.04294294f, -0.01111425f, 
    -0.02462454f, 0.02570641f, -0.03479633f, 0.00982052f, -0.03395708f, 0.01209526f, -0.03737573f, 0.00438619f, 
    0.00401318f, -0.03692868f, -0.01008549f, 0.01144395f, -0.03736421f, 0.00718492f, 0.02449762f, 0.01248195f, 
    -0.01079649f, -0.03793966f, 0.02279059f, 0.01400594f, -0.04124369f, 0.02115582f, -0.00091527f, -0.00229821f, 
    0.00097007f, -0.02837460f, 0.00351843f, 0.03151952f, 0.01174705f, 0.00929223f, -0.00104288f, -0.02893421f, 
    -0.02651561f, -0.01720297f, 0.00480710f, -0.00390574f, -0.02434148f, 0.02419985f, -0.03296305f, 0.00038798f, 
    0.01798950f, 0.03326488f, -0.02940811f, 0.01149151f, -0.03779176f, -0.02709347f, -0.00204825f, -0.00804946f, 
    -0.04222680f, -0.04153299f, -0.02275135f, -0.02861579f, -0.02311333f, 0.01982740f, -0.00448925f, -0.01850221f, 
    -0.00353154f, -0.01458064f, -0.03733133f, -0.00088538f, -0.03887342f, -0.01974211f, 0.01158989f, -0.00870953f, 
    0.01811201f, -0.01600515f, 0.00746696f, -0.03820070f, -0.00501062f, -0.02659017f, -0.00413724f, -0.03950816f, 
    0.01302407f, -0.02534304f, 0.01042341f, -0.02510910f, -0.00227632f, 0.02721699f, -0.04155771f, 0.02937208f, 
    0.01442389f, 0.01186268f, -0.03078189f, 0.01102261f, 0.03225926f, -0.01519246f, -0.01639847f, 0.01100109f, 
    -0.00923918f, -0.02182083f, -0.03875107f, -0.00547253f, -0.03024654f, -0.01735356f, 0.00074306f, -0.02037706f, 
    0.02341470f, 0.02991307f, 0.00054565f, -0.03622181f, 0.00488048f, 0.00717536f, 0.01466015f, 0.00553390f, 
    -0.02066306f, -0.03114119f, -0.00570917f, -0.03670712f, -0.01966816f, -0.02421239f, 0.02073435f, 0.01295856f, 
    -0.01307384f, 0.00209145f, -0.02732873f, -0.03475145f, -0.02555700f, -0.01130625f, 0.02425232f, 0.02524029f, 
    -0.00245591f, 0.02218224f, 0.01368590f, -0.01772897f, 0.02318260f, -0.03414008f, -0.01688426f, -0.02942562f, 
    -0.02627889f, 0.01376676f, 0.02893394f, 0.01834621f, 0.02937108f, 0.00368675f, 0.01886005f, -0.01576688f, 
    0.01280759f, -0.01971191f, -0.02411471f, 0.02733753f, -0.00925659f, -0.03875514f, 0.02616284f, -0.01551396f, 
    -0.02770839f, -0.01167390f, -0.02045703f, 0.00505095f, -0.01928840f, -0.01881787f, 0.00752754f, 0.01188430f, 
    0.02111457f, -0.03516104f, -0.03222749f, 0.00422643f, 0.01875223f, -0.03254123f, -0.03430834f, 0.02378816f, 
    -0.01004461f, -0.01369000f, 0.01660993f, 0.02950488f, 0.01748230f, -0.03047009f, 0.01311344f, 0.01080098f, 
    -0.00182060f, -0.02292865f, -0.00461062f, 0.01374319f, -0.00679226f, -0.00172997f, 0.02768071f, -0.00054311f, 
    -0.00979506f, 0.00601232f, 0.01055540f, -0.01651282f, 0.00149282f, -0.04014277f, -0.00780727f, 0.02700557f, 
    -0.03561181f, -0.01800044f, -0.03497504f, 0.02799529f, 0.02542338f, 0.01980658f, 0.00233946f, 0.01709244f, 
    0.02406487f, 0.01638861f, -0.00975359f, 0.03018636f, -0.02117250f, -0.04112608f, -0.03435653f, -0.00317885f, 
    -0.00122585f, 0.02789663f, 0.01528990f, -0.03960730f, -0.01198577f, -0.03616193f, -0.01138174f, -0.01196626f, 
    -0.02796775f, 0.02804746f, -0.02692700f, -0.01392215f, -0.01991722f, 0.02408964f, 0.00965986f, -0.00212490f, 
    -0.02956598f, -0.03455785f, 0.02119297f, 0.02904611f, 0.02577793f, 0.00033019f, 0.00052890f, -0.03280741f, 
    0.00641871f, 0.00992279f, -0.03668963f, 0.00580546f, 0.01609366f, 0.00362271f, 0.00724547f, -0.01098402f, 
    -0.04034454f, 0.00247518f, -0.01422841f, 0.02255872f, -0.03394597f, -0.01709025f, -0.01081477f, 0.01136210f, 
    0.02215577f, 0.01002808f, 0.03000998f, -0.01286841f, -0.01284352f, 0.01800926f, -0.02083054f, -0.02499202f, 
    -0.03472432f, -0.00807833f, -0.00981452f, 0.01072344f, 0.01958708f, -0.03606217f, 0.00944270f, -0.03565863f, 
    0.00505606f, -0.00101462f, -0.03828243f, -0.02517890f, 0.00139702f, -0.00143991f, -0.00252005f, -0.03906645f, 
    0.02661371f, -0.04123430f, 0.02484319f, 0.02163002f, -0.00707177f, 0.00279225f, -0.01380970f, -0.00302276f, 
    -0.00852569f, 0.00889922f, -0.03511153f, 0.02180440f, 0.00267980f, 0.00064620f, 0.00156948f, 0.01494771f, 
    0.02585408f, -0.01516720f, -0.03150556f, -0.00688175f, -0.00363718f, -0.00176699f, -0.00345238f, -0.02581696f, 
    -0.02134398f, -0.03844742f, -0.02997922f, -0.02987095f, -0.01993553f, 0.00744059f, 0.01790495f, -0.00843655f, 
    0.01416198f, 0.01593503f, 0.01270188f, -0.03502204f, -0.02405732f, -0.02510891f, 0.01700714f, 0.01373320f, 
    0.02155499f, -0.03199222f, -0.01133998f, 0.00143704f, -0.02308374f, -0.02598785f, 0.01247710f, 0.02015384f, 
    -0.01112039f, -0.03474125f, -0.00503958f, -0.01380059f, -0.00746779f, -0.03106638f, -0.01570307f, -0.00084368f, 
    0.02487794f, -0.03439353f, -0.00632671f, 0.02501479f, 0.01819541f, -0.03393164f, -0.01940623f, -0.01448099f, 
    0.00697188f, 0.00474042f, 0.00668512f, -0.00209263f, 0.00533411f, -0.03722537f, -0.02717901f, -0.00205236f, 
    -0.02983895f, -0.03642352f, 0.00038577f, 0.02772065f, -0.03492725f, -0.01794669f, -0.02893908f, 0.02894003f, 
    0.01181210f, 0.00100463f, -0.03499151f, 0.02697006f, -0.03121202f, -0.00761539f, 0.02720963f, -0.03561284f, 
    -0.01203786f, -0.01645850f, 0.02554578f, -0.00306029f, 0.02565734f, -0.02313199f, -0.04133730f, -0.02852295f, 
    0.00751689f, -0.00485613f, -0.01228579f, -0.02871087f, -0.01554406f, -0.00205890f, 0.00270647f, -0.01128604f, 
    0.02051773f, -0.03013213f, 0.00197750f, -0.01905990f, -0.00459442f, 0.01008021f, -0.01897658f, 0.01750014f, 
    0.02376817f, -0.03376583f, 0.02184028f, 0.01739757f, -0.00904567f, -0.02612096f, 0.02544065f, -0.03472691f, 
    0.01163732f, -0.00690609f, -0.04092941f, 0.02924648f, -0.03233385f, -0.00597626f, -0.02134957f, -0.01681160f, 
    0.02998400f, -0.03800634f, -0.00077913f, -0.04126148f, -0.01002381f, -0.01758932f, 0.02171282f, -0.01278501f, 
    -0.00388941f, 0.01395771f, -0.00762373f, -0.02219196f, 0.02425215f, -0.00481757f, 0.00928706f, 0.00742636f, 
    -0.04116859f, -0.01813413f, 0.02519375f, 0.02478960f, -0.02558273f, -0.02793759f, 0.00424311f, -0.03270540f, 
    -0.01722268f, 0.01583043f, -0.00466817f, -0.01661336f, -0.03748081f, 0.01902186f, -0.02598627f, 0.00070264f, 
    -0.01905696f, 0.00463404f, -0.03270117f, 0.02863840f, 0.00249369f, 0.00578612f, 0.01432275f, -0.02342404f, 
    -0.02185713f, -0.00339629f, -0.03809793f, -0.00079629f, 0.02478472f, 0.00901252f, -0.00232966f, 0.01477067f, 
    0.02833338f, 0.02580302f, 0.00777989f, -0.01549068f, -0.01057877f, 0.02177544f, 0.00535159f, -0.03293221f, 
    0.00883666f, 0.02620925f, -0.01539470f, 0.01398030f, 0.00983911f, -0.02671835f, -0.01863010f, -0.02817583f, 
    -0.00971435f, 0.00018811f, -0.01884085f, 0.00553055f, -0.02152924f, -0.02768416f, 0.01310578f, -0.01676782f, 
    0.00290739f, -0.02336102f, 0.02131904f, 0.01884792f, -0.02024141f, 0.02524889f, -0.02790916f, -0.03053458f, 
    0.01484265f, -0.02587063f, 0.00846535f, -0.00285025f, -0.00403191f, -0.02953339f, -0.03139259f, -0.04142982f, 
    -0.01671362f, -0.03940531f, 0.01886013f, -0.02609296f, -0.02154892f, 0.01247231f, -0.01129670f, -0.03423672f, 
    -0.02781946f, 0.01015984f, 0.00497396f, -0.01494961f, -0.02483070f, -0.00145994f, -0.03617526f, 0.00514319f, 
    -0.00086015f, 0.00406423f, -0.01288110f, 0.01786108f, -0.02822968f, -0.03077571f, -0.03504827f, -0.00724567f, 
    0.02539581f, -0.03151141f, -0.01783135f, -0.03904681f, -0.01862295f, -0.02437933f, 0.01170484f, -0.00338382f, 
    -0.03736273f, -0.02556111f, 0.00940702f, -0.00992942f, -0.00600351f, 0.02229596f, -0.01895613f, 0.00116192f, 
    0.02924930f, 0.00754344f, -0.01391574f, -0.01453172f, 0.00765956f, -0.02209696f, 0.01197156f, 0.01768118f, 
    -0.01978843f, -0.00090025f, 0.02268193f, -0.01027851f, -0.04146946f, 0.00324677f, -0.00396309f, -0.03532884f, 
    -0.02501399f, 0.00964233f, 0.01463323f, -0.00802740f, 0.01413405f, 0.02944518f, 0.02569799f, -0.00393202f, 
    -0.01207027f, -0.00394587f, 0.01926070f, -0.03417580f, -0.02850723f, -0.01599187f, -0.02611720f, -0.00540661f, 
    0.00372308f, -0.00264337f, 0.01965876f, -0.03581628f, 0.00867497f, 0.00809331f, 0.00826704f, -0.00710511f, 
    0.02055282f, -0.02651497f, -0.04035047f, 0.00696619f, -0.01158864f, -0.01626593f, 0.01150797f, -0.01035963f, 
    -0.00121619f, -0.02384137f, 0.01855526f, -0.00208018f, 0.01248820f, 0.01884982f, -0.03882698f, 0.02097667f, 
    -0.01557659f, -0.04058107f, -0.02349987f, -0.02389746f, -0.00095404f, -0.04179361f, -0.00152422f, -0.04041023f, 
    0.01094973f, 0.01445036f, -0.01029702f, -0.03016227f, -0.01569043f, 0.02122893f, -0.01359534f, -0.01255554f, 
    -0.04180525f, -0.03087720f, 0.00806849f, -0.03883488f, -0.00520098f, -0.02813079f, -0.03731083f, 0.01301606f, 
    0.01791007f, 0.01287996f, -0.02347929f, 0.00619528f, -0.03779366f, 0.02643773f, 0.02868063f, -0.03670961f, 
    0.00730772f, 0.02852080f, 0.01918073f, -0.00210836f, -0.00738559f, -0.03734731f, -0.03995654f, -0.00488159f, 
    0.02499439f, -0.04077323f, 0.00975302f, 0.00073606f, -0.01726675f, 0.02864548f, -0.01578120f, -0.01080695f, 
    -0.03125021f, -0.02136960f, -0.03531559f, -0.01732596f, -0.00937009f, 0.01916335f, -0.00980014f, 0.02908649f, 
    -0.01929916f, -0.02012078f, 0.01833323f, -0.02727884f, -0.03980705f, 0.00907594f, -0.01003524f, -0.03297244f, 
    0.02722101f, -0.01895282f, -0.04006269f, 0.02486622f, -0.01479097f, -0.02467507f, -0.03571201f, -0.02030984f, 
    0.00401161f, -0.01200202f, 0.02727734f, 0.01559319f, 0.00214405f, -0.04071544f, -0.01792361f, -0.01664948f, 
    -0.02873924f, 0.01783281f, 0.00660052f, -0.02574111f, -0.00193402f, -0.01883770f, -0.00330170f, 0.01436810f, 
    -0.01602163f, -0.01033035f, 0.00543892f, 0.00268761f, 0.01977451f, 0.00841643f, -0.02952074f, -0.03991965f, 
    0.02757077f, -0.03972398f, 0.00837032f, 0.02218940f, 0.00579681f, 0.02456756f, 0.01971123f, -0.01287506f, 
    -0.00275170f, -0.01962167f, 0.00763306f, -0.01502603f, -0.02826895f, -0.03453837f, -0.04040612f, 0.02780201f, 
    -0.02624380f, -0.01663888f, -0.02341392f, -0.03133156f, -0.03565210f, -0.03115529f, 0.00958462f, 0.02158216f, 
    0.01482075f, -0.00475261f, -0.00907969f, 0.02315350f, -0.01120887f, -0.02800171f, 0.00606395f, 0.02334784f, 
    -0.02922321f, -0.00655492f, 0.01739658f, -0.03273514f, -0.00103391f, 0.01636803f, 0.00385247f, -0.01772966f, 
    0.02469021f, -0.03745314f, -0.02216041f, 0.01452546f, 0.02363352f, 0.01309693f, -0.00641942f, 0.00065920f, 
    -0.01945823f, 0.02270467f, -0.00990636f, -0.02999723f, -0.03293215f, -0.00502154f, -0.00931474f, -0.03952477f, 
    0.00442234f, -0.03128021f, -0.01554648f, -0.00652567f, 0.02311305f, -0.02611339f, -0.03014675f, 0.01535921f, 
    0.02904372f, -0.01800138f, -0.00623635f, 0.03003109f, -0.00508581f, -0.00807381f, -0.04176048f, 0.01987735f, 
    -0.00432740f, -0.01829343f, 0.02212366f, -0.02777769f, 0.00913311f, 0.01901945f, -0.01399775f, 0.01031701f, 
    -0.03769660f, 0.01750112f, -0.03979775f, -0.01832961f, -0.02235158f, -0.00081113f, 0.01886096f, 0.00559315f, 
    -0.00531987f, -0.00533955f, 0.01859527f, -0.00357312f, -0.00593626f, -0.02396736f, -0.03032902f, -0.01258483f, 
    -0.02809300f, -0.00498825f, -0.03362469f, 0.01901545f, -0.01265459f, -0.01500180f, -0.00053580f, -0.01889422f, 
    -0.00796633f, -0.02387219f, 0.02309021f, -0.03697758f, -0.02343193f, 0.00728784f, 0.02269119f, -0.04172171f, 
    -0.01201585f, -0.02308636f, 0.02738057f, -0.00321139f, -0.02957546f, 0.00000977f, -0.00557265f, -0.02393689f, 
    -0.02641843f, 0.02684562f, -0.03655789f, -0.02107934f, -0.04192001f, -0.03929691f, -0.02556945f, -0.00497747f, 
    0.00669761f, 0.01772620f, -0.00239048f, 0.02570105f, -0.03842698f, -0.02463302f, 0.02003360f, -0.04029605f, 
    0.01460841f, 0.01842421f, -0.00907317f, -0.03683732f, -0.02256254f, 0.01772109f, 0.00023711f, -0.02617785f, 
    -0.00142375f, 0.02365137f, 0.02737565f, -0.02855053f, -0.02064690f, 0.01014414f, -0.02101717f, -0.01927359f, 
    -0.02346873f, -0.00719569f, -0.04044365f, 0.00756616f, -0.03217466f, -0.01749044f, -0.01729194f, -0.03902091f, 
    -0.00556863f, -0.02937016f, 0.02719287f, -0.01997806f, -0.03413839f, -0.03869754f, 0.02835475f, -0.03066104f, 
    0.01622822f, -0.04110825f, 0.02116990f, 0.00069234f, 0.00361363f, -0.01476643f, -0.03613231f, -0.03149455f, 
    0.00817795f, -0.03874403f, -0.03378646f, 0.01236413f, 0.00432023f, -0.01795450f, -0.03963071f, -0.00085955f, 
    -0.00260499f, -0.01193427f, -0.00690684f, 0.02611207f, -0.01637950f, 0.01702739f, -0.02020106f, -0.03079383f, 
    -0.02745941f, 0.01376695f, -0.02321142f, 0.02049738f, -0.01810504f, 0.01065566f, 0.00571248f, -0.02852694f, 
    0.02959812f, -0.00591122f, -0.03773950f, -0.03332806f, 0.00834724f, 0.02569178f, 0.00682617f, 0.02592735f, 
    0.00173840f, 0.02478971f, 0.01407765f, -0.01385331f, -0.00920953f, -0.03615202f, -0.02075531f, -0.01988452f, 
    -0.03149197f, -0.02960337f, -0.00913725f, -0.00916853f, 0.01111862f, 0.02066602f, -0.01537888f, 0.02799221f, 
    -0.03802888f, -0.02455839f, 0.01138536f, -0.01390458f, 0.00283530f, 0.00735192f, -0.02167473f, -0.02580620f, 
    0.02960508f, 0.02590469f, 0.02204776f, 0.01956350f, -0.03268615f, 0.00962481f, -0.03299900f, -0.03252545f, 
    -0.01362436f, 0.00546980f, -0.01988380f, -0.03144155f, -0.03567529f, -0.02463565f, -0.04152841f, -0.04132184f, 
    -0.04102112f, -0.01386641f, 0.01154816f, -0.03125659f, 0.01715349f, 0.01498833f, 0.01608390f, -0.01045562f, 
    0.02704792f, 0.02824919f, 0.00966335f, -0.03559529f, 0.02717669f, 0.00673853f, -0.00197364f, -0.03755023f, 
    -0.03821702f, -0.01024213f, 0.02720872f, -0.01956706f, 0.00811286f, -0.00702556f, -0.00883873f, -0.03758298f, 
    -0.01901514f, 0.00616020f, -0.04106335f, 0.01696952f, -0.03561710f, -0.02102734f, -0.02964184f, 0.00497275f, 
    0.01889202f, -0.01522385f, 0.01916563f, -0.00054906f, -0.00933354f, -0.01806420f, -0.02911949f, 0.02760043f, 
    0.00392287f, 0.02401908f, -0.00774201f, 0.00658013f, 0.00528080f, -0.01305673f, -0.03028399f, -0.01393892f, 
    -0.01333738f, 0.01526894f, 0.00541656f, 0.01263182f, -0.01286001f, -0.03651513f, 0.01197407f, 0.00284815f, 
    -0.30702984f, -0.09446456f, 0.20004393f, -0.10866632f, 0.04221858f, -0.09357533f, 0.14842893f, -0.14123993f, 
    -0.01033028f, 0.05810275f, -0.02012208f, 0.03385880f, -0.04581352f, 0.07400657f, 0.02494300f, -0.14434728f, 
    0.01871866f, -0.03113109f, -0.16645563f, 0.01366435f, -0.00544759f, 0.07173982f, -0.04993918f, -0.07885790f, 
    0.05081512f, 0.32116073f, 0.11195675f, -0.03372790f, 0.03890439f, -0.04977622f, 0.03998034f, -0.01564194f, 
    0.02247005f, 0.05793047f, 0.02675742f, 0.02885533f, -0.27246830f, -0.16143058f, 0.03941662f, -0.16497374f, 
    0.09562198f, 0.01564950f, -0.01332530f, -0.00194446f, 0.01356820f, -0.08113793f, -0.02495818f, -0.11110231f, 
    0.05838858f, 0.10887066f, -0.05324151f, -0.17786613f, 0.09123265f, 0.11096067f, 0.09346943f, 0.04588825f, 
    -0.00549654f, -0.03360773f, 0.19642061f, 0.01660319f, -0.13504723f, 0.07762159f, -0.13673651f, -0.09667322f, 
    0.04678781f, 0.05045778f, 0.09307056f, -0.00898230f, 0.11738590f, -0.00979328f, 0.06975543f, 0.02008004f, 
    -0.14397509f, -0.14997374f, -0.02646490f, -0.21684024f, 0.03095970f, -0.02775475f, -0.00370822f, -0.03062133f, 
    0.00839329f, -0.06418221f, 0.02598087f, 0.09003401f, 0.24945477f, -0.04983006f, 0.11849017f, 0.16780533f, 
    0.05180423f, -0.21138780f, -0.00325625f, 0.07880106f, 0.04623239f, 0.09162623f, 0.08837110f, -0.00049795f, 
    -0.13639237f, 0.00508563f, -0.15345375f, -0.08392754f, 0.02965241f, -0.00100017f, 0.07287683f, 0.03578552f, 
    0.08903575f, 0.01719507f, 0.10756490f, 0.02229609f, 0.18552966f, 0.02328731f, -0.15322179f, -0.16076680f, 
    0.08796404f, 0.11163430f, 0.08219611f, 0.07608225f, 0.00709495f, -0.00528109f, 0.02928104f, -0.05990659f, 
    -0.00032388f, -0.05243137f, 0.04276545f, -0.08683172f, -0.07019071f, 0.14392567f, -0.04126871f, -0.16979165f, 
    0.05828812f, -0.08674406f, -0.05136079f, -0.11773604f, -0.14295919f, 0.00630072f, -0.00207138f, 0.08420989f, 
    0.02498659f, -0.08112407f, 0.07103541f, 0.00601640f, -0.01757936f, 0.07012796f, 0.02392751f, 0.13677125f, 
    -0.18869527f, -0.09265494f, -0.13958399f, 0.07184348f, -0.03044872f, 0.07625628f, 0.03419816f, -0.03108598f, 
    0.05733920f, 0.07072644f, -0.04245554f, -0.11623739f, -0.24137676f, 0.03471014f, -0.04662379f, -0.23464508f, 
    0.14111505f, 0.05602774f, 0.05978369f, 0.04607017f, 0.07650941f, 0.07571327f, -0.07602446f, 0.02598940f, 
    0.03540289f, 0.01835551f, 0.07022404f, 0.01392358f, 0.04677086f, 0.03147258f, 0.09812699f, 0.17042889f, 
    -0.09940565f, 0.06188365f, -0.02059579f, -0.08012427f, 0.21217372f, 0.04037785f, 0.09042910f, 0.03061910f, 
    0.09115452f, -0.04215517f, 0.08419710f, -0.04103182f, 0.07886860f, 0.02177292f, 0.12027078f, 0.19258252f, 
    -0.06015053f, 0.31733644f, 0.20229933f, -0.07223825f, 0.10540552f, 0.00131715f, 0.02422862f, 0.07442731f, 
    0.04391748f, -0.01945281f, -0.04528506f, 0.11458988f, 0.11594418f, -0.05465162f, 0.23235063f, 0.02358767f, 
    0.03503558f, 0.01696640f, 0.17238164f, 0.06546563f, 0.09895061f, 0.09448039f, 0.07407634f, 0.06354251f, 
    0.07319953f, 0.03690144f, 0.14888190f, 0.19950043f, -0.03017621f, -0.01817446f, 0.06095055f, -0.02094612f, 
    0.04312621f, -0.13966943f, 0.05577870f, 0.09237867f, 0.05582139f, -0.06912322f, 0.07829005f, 0.07577925f, 
    0.00007935f, -0.01726913f, 0.03143643f, 0.03307059f, 0.02098312f, 0.14390400f, -0.05009907f, 0.10816355f, 
    0.04533927f, 0.20191166f, 0.09989750f, -0.02605818f, 0.05654984f, 0.05174998f, 0.06354310f, 0.08392690f, 
    -0.03674345f, -0.00401277f, -0.04182329f, 0.15530466f, -0.27707273f, -0.04716079f, 0.09549171f, 0.14487435f, 
    0.08992261f, 0.05740365f, -0.04039440f, 0.12614873f, -0.01169405f, 0.09211705f, 0.02226964f, -0.11960205f, 
    -0.11174974f, 0.26701540f, 0.03331988f, 0.10117947f, 0.11687785f, -0.15187494f, 0.04345408f, 0.02287223f, 
    0.02433699f, -0.00336304f, 0.14440380f, -0.00032163f, 0.05413448f, 0.07180302f, 0.12100238f, 0.03188283f, 
    0.08048001f, 0.04912595f, 0.04047382f, -0.00337676f, 0.14524114f, 0.02899116f, 0.10182840f, 0.08081829f, 
    -0.03788477f, 0.09974650f, 0.05055238f, -0.02935605f, 0.09058768f, -0.00129937f, 0.13041750f, 0.10634436f, 
    0.07219214f, 0.13032076f, 0.07641442f, 0.16182788f, -0.06816078f, -0.13646328f, -0.04491005f, -0.06946670f, 
    0.04481361f, 0.00507193f, -0.03832977f, -0.00074678f, -0.02305800f, -0.12023043f, 0.03652564f, -0.03531669f, 
    0.35145685f, 0.16330422f, -0.07627005f, -0.01830561f, 0.04566566f, 0.07971430f, 0.09083269f, 0.00135217f, 
    0.06462371f, 0.15168418f, 0.01365032f, 0.02425469f, -0.27866033f, -0.13397680f, 0.03859973f, -0.08532485f, 
    -0.02982731f, 0.02623312f, 0.01481475f, 0.00823806f, 0.08777346f, 0.03818773f, 0.02024121f, -0.04016665f, 
    0.02600855f, 0.18500321f, 0.04529546f, -0.24980602f, 0.09035136f, -0.15206438f, -0.07822046f, 0.07293972f, 
    -0.00566755f, -0.03608579f, 0.09246251f, 0.15474181f, 0.00867551f, -0.04387097f, 0.06396517f, -0.09969264f, 
    0.03538875f, -0.08245047f, -0.02358511f, 0.10242222f, -0.00733182f, -0.01931641f, 0.00949158f, -0.03561915f, 
    0.13354379f, 0.12944572f, -0.12788418f, 0.03264147f, 0.05410319f, 0.07837843f, 0.00293948f, 0.03582475f, 
    0.03578841f, 0.17211857f, 0.10901080f, 0.10195325f, -0.29770380f, 0.05660056f, -0.17808312f, -0.11759679f, 
    -0.01789984f, -0.02029157f, -0.00526404f, -0.01630838f, 0.03212347f, 0.00762616f, -0.15038554f, 0.05043595f, 
    0.06739601f, -0.04578960f, -0.01384076f, -0.09106088f, 0.02809971f, 0.03772950f, 0.08780643f, 0.06620115f, 
    -0.00743560f, 0.12545195f, 0.10893681f, 0.15228005f, -0.06960641f, 0.05888390f, -0.16775636f, -0.05063147f, 
    -0.02016044f, 0.07196457f, 0.02509139f, 0.04517293f, -0.05302674f, -0.03644809f, 0.12541498f, 0.02134772f, 
    0.19111644f, -0.14187279f, -0.07536231f, 0.03348796f, -0.02103554f, 0.02125282f, -0.02908740f, 0.09845444f, 
    0.02575105f, 0.04184476f, 0.07080273f, -0.02453176f, -0.15285939f, -0.13151203f, 0.03438191f, -0.15740821f, 
    0.03478658f, 0.03058475f, 0.05916827f, -0.03214327f, 0.05502614f, -0.07903198f, 0.02762980f, 0.06750038f, 
    0.05185795f, 0.01396445f, -0.08381984f, -0.03718555f, -0.06535842f, -0.03164776f, -0.00735638f, 0.15470999f, 
    0.12213039f, 0.04841555f, -0.08750349f, -0.00960029f, 0.17227612f, -0.06950880f, -0.07928473f, 0.12444070f, 
    0.02119405f, 0.06078128f, 0.06869724f, 0.11091725f, 0.05944355f, 0.05407687f, 0.07141414f, 0.13409637f, 
    0.19578010f, -0.12079114f, -0.06642496f, -0.05168599f, 0.12910584f, 0.07617645f, -0.00070381f, 0.04042906f, 
    0.11882887f, 0.09125830f, -0.12570098f, 0.01502152f, -0.16850311f, -0.18694228f, 0.14097220f, -0.08148487f, 
    0.05442761f, -0.03335279f, 0.03020385f, 0.09776322f, 0.06623399f, 0.08872151f, 0.07475854f, 0.09456678f, 
    -0.08006112f, -0.01160606f, 0.01289430f, -0.09841590f, 0.03823315f, 0.03741791f, 0.02479160f, 0.06995190f, 
    0.00642851f, 0.08888187f, 0.00938253f, 0.07888673f, 0.15492748f, -0.04696952f, -0.02513931f, -0.01137617f, 
    0.17584004f, -0.02017113f, 0.03548696f, 0.00463645f, 0.15506111f, 0.02627346f, 0.02469570f, 0.00404817f, 
    -0.03396773f, -0.08603401f, 0.17757908f, -0.21235868f, 0.11624214f, 0.11704648f, 0.07592354f, 0.03844289f, 
    0.00315684f, 0.05775611f, -0.02531273f, 0.15435223f, 0.05600803f, -0.03092431f, -0.03313330f, -0.07304219f, 
    0.08769715f, -0.02854296f, 0.03869684f, -0.08038224f, 0.00154311f, 0.12168381f, -0.00569802f, 0.06085812f, 
    -0.28053594f, -0.19720365f, 0.03521248f, 0.06141686f, -0.01853366f, -0.00175980f, -0.03904162f, 0.15906379f, 
    -0.01235869f, -0.00948339f, -0.00077040f, 0.01485902f, 0.16728258f, 0.33796284f, 0.25716892f, 0.02975621f, 
    0.03629994f, -0.09391386f, -0.00857079f, -0.11789180f, 0.01625497f, 0.02279446f, 0.05685432f, 0.07767279f, 
    0.14801002f, 0.09851725f, 0.10007095f, 0.09029782f, 0.03476316f, -0.10208130f, -0.01388734f, 0.07503808f, 
    0.06299393f, 0.09189536f, -0.04060589f, 0.04090394f, 0.04872818f, -0.04484629f, -0.04454156f, -0.09062637f, 
    0.05126665f, -0.11294152f, -0.06147345f, -0.08046135f, 0.13548496f, -0.09044284f, 0.03057429f, -0.01856361f, 
    0.25701290f, 0.16837738f, 0.21264750f, 0.06680007f, 0.08044605f, 0.10357202f, -0.00413376f, -0.03192468f, 
    0.07374293f, 0.07955363f, 0.10163608f, -0.03780011f, -0.17389849f, -0.17504787f, -0.15081969f, -0.02765546f, 
    -0.07101748f, 0.07912321f, 0.03242484f, -0.10657408f, 0.02762105f, 0.00983561f, 0.11072823f, 0.04648368f, 
    0.01422002f, -0.09664419f, -0.05892225f, -0.04137963f, 0.12335710f, 0.09420977f, 0.02003673f, 0.09924656f, 
    0.00384088f, 0.04664765f, 0.09286588f, 0.02110905f, 0.06054172f, -0.15978967f, 0.17510031f, 0.21233666f, 
    0.00728205f, -0.03536760f, 0.04468221f, 0.02768069f, -0.05502289f, -0.04910953f, 0.04078536f, -0.09979352f, 
    0.24674951f, 0.28252527f, 0.00849123f, -0.05114800f, 0.14123163f, 0.01053826f, 0.00907574f, -0.02441471f, 
    0.01112592f, 0.08035920f, -0.03766866f, 0.14109641f, 0.10438541f, 0.00681802f, 0.07959852f, 0.12536724f, 
    0.08424818f, -0.01360929f, 0.03313159f, -0.03465496f, 0.05286325f, 0.01671778f, 0.04973603f, 0.08049449f, 
    0.02340386f, 0.11904540f, 0.19739254f, -0.11671019f, 0.05381201f, 0.02386497f, -0.06506136f, -0.11323228f, 
    -0.03319853f, 0.01235069f, 0.02431409f, -0.12596527f, 0.09407735f, -0.03445240f, 0.05975022f, -0.01924728f, 
    0.09595223f, 0.02783432f, 0.05088196f, 0.08211267f, 0.04904250f, 0.10645123f, 0.04988050f, 0.18720113f, 
    0.09732123f, 0.03077376f, -0.05160210f, 0.01133572f, -0.04445378f, 0.03163772f, -0.03785190f, 0.04009839f, 
    0.01479714f, 0.03135470f, 0.14787497f, -0.07612702f, 0.13818577f, 0.03938280f, -0.01389304f, -0.05949594f, 
    -0.02005722f, 0.04205377f, 0.05204047f, -0.01643253f, 0.06034730f, 0.12943113f, 0.03480798f, 0.13644296f, 
    0.15616825f, -0.11192719f, -0.14439215f, -0.12353757f, 0.06017479f, 0.02423790f, 0.07010023f, -0.02313082f, 
    0.04973188f, 0.03958816f, -0.00091443f, -0.02174731f, 0.19168600f, 0.02600806f, 0.08822487f, -0.12142045f, 
    -0.04401530f, 0.02280037f, 0.23091365f, -0.01221337f, 0.05061141f, -0.01773135f, 0.02426995f, -0.00022053f, 
    0.29209554f, -0.14113040f, -0.13311492f, 0.01490645f, -0.07154845f, 0.08746540f, 0.01247765f, -0.04665819f, 
    -0.01806647f, 0.05383391f, 0.09624908f, -0.05443250f, 0.33449617f, 0.06799872f, 0.09843516f, 0.02439825f, 
    0.05477304f, 0.05765136f, -0.00991057f, -0.07981524f, -0.00861154f, 0.03225667f, -0.00836812f, 0.05617112f, 
    -0.24355562f, -0.09158763f, 0.18770942f, 0.01934603f, 0.04041114f, -0.07391970f, 0.10703479f, 0.07577565f, 
    0.08176710f, -0.09653830f, 0.02591674f, 0.08703361f, -0.04717265f, -0.03069482f, -0.06425980f, -0.03981876f, 
    -0.03213337f, -0.01633305f, -0.01799540f, 0.01693505f, 0.05163362f, 0.07620586f, 0.05952300f, -0.00335534f, 
    -0.15394709f, 0.09666130f, 0.15942496f, -0.07941725f, 0.06399679f, -0.10869383f, 0.10949187f, -0.06515241f, 
    -0.03806797f, 0.15998296f, -0.01053921f, -0.10557579f, 0.05653599f, 0.12541589f, 0.00277553f, 0.00858826f, 
    0.05128352f, -0.08497091f, -0.08522693f, -0.02310861f, 0.04276075f, 0.03123837f, -0.02198617f, 0.01099752f, 
    -0.18403095f, 0.18105389f, 0.08749814f, 0.02762919f, 0.05995119f, -0.01448952f, 0.01772245f, -0.02088679f, 
    0.06419037f, 0.03014206f, 0.03824327f, -0.04148579f, -0.26458356f, -0.04029553f, -0.11761005f, 0.01980166f, 
    0.01293942f, 0.02482037f, -0.02285086f, 0.13028774f, 0.03816926f, -0.03147908f, 0.03979917f, -0.09807372f, 
    0.10759221f, 0.11637402f, -0.15135998f, -0.36588919f, 0.12601389f, 0.14169770f, -0.00501561f, 0.09094851f, 
    -0.01573468f, -0.02835435f, 0.06703363f, 0.09032924f, -0.12277924f, 0.02826362f, -0.03001666f, -0.16695490f, 
    0.11212138f, 0.06201138f, 0.18777002f, 0.02620527f, 0.08212407f, -0.01759873f, 0.08203055f, 0.01027320f, 
    -0.25670958f, -0.08565024f, 0.02120537f, -0.25474948f, -0.02944342f, -0.00900534f, -0.08799831f, 0.02283593f, 
    0.02479378f, -0.01989811f, 0.00257033f, 0.03709407f, 0.26582220f, -0.06491667f, 0.12501577f, -0.02933441f, 
    -0.02819956f, -0.17159125f, -0.15542588f, 0.06168312f, 0.08172876f, 0.12019344f, 0.05210049f, 0.00390776f, 
    -0.06395692f, 0.00545277f, -0.22449178f, 0.07847095f, 0.10026471f, 0.05744457f, 0.04277225f, 0.09921907f, 
    0.09513750f, -0.06719059f, -0.00733238f, -0.01397616f, 0.11491981f, 0.20967256f, -0.06920864f, -0.23882836f, 
    0.07764091f, 0.06064450f, 0.04830758f, -0.01469665f, -0.01070110f, 0.03042262f, 0.01367207f, 0.03960267f, 
    -0.14612773f, 0.07273289f, -0.03484382f, 0.02365047f, 0.02344961f, 0.02175108f, -0.18078324f, -0.04781840f, 
    -0.03641764f, -0.08085702f, 0.02932102f, 0.01280347f, -0.01730378f, -0.18386994f, 0.12030502f, 0.00285648f, 
    -0.08005000f, -0.12179190f, 0.14128877f, -0.04731511f, 0.17665833f, -0.03342601f, 0.01775838f, 0.08288739f, 
    0.27549827f, -0.01177184f, -0.25942335f, 0.03642334f, -0.00949555f, 0.02081792f, 0.03574750f, -0.09980764f, 
    0.03746352f, 0.07401767f, -0.06009198f, -0.05761760f, -0.14178120f, -0.14232185f, 0.01512913f, -0.20996571f, 
    -0.07403957f, 0.03622959f, 0.05613091f, 0.01725678f, 0.02714802f, 0.09609320f, -0.08480054f, -0.01098339f, 
    -0.23123758f, -0.00931535f, 0.00189308f, -0.00920449f, -0.03120292f, 0.02999681f, 0.00328109f, 0.07586672f, 
    -0.03344958f, 0.04980901f, 0.07329917f, 0.06862289f, -0.04975079f, 0.04030389f, 0.05875382f, 0.02684546f, 
    0.01796153f, -0.08483102f, 0.00746768f, -0.05339486f, 0.01901223f, 0.00196790f, 0.04581490f, 0.13371609f, 
    -0.38075694f, 0.19846603f, 0.16962242f, 0.07506248f, 0.01829164f, -0.02286480f, -0.00050199f, 0.09652916f, 
    -0.03761080f, 0.06382315f, -0.05298378f, 0.12480312f, -0.14669149f, -0.04797681f, 0.17813107f, -0.11941712f, 
    0.03796412f, -0.01494950f, 0.10331152f, -0.00307118f, 0.03405802f, 0.02299186f, 0.12664613f, 0.01656207f, 
    -0.07663153f, 0.19034366f, -0.02059227f, 0.25152448f, -0.03830240f, 0.03281135f, 0.02242234f, -0.06307072f, 
    0.02760208f, -0.03104708f, 0.02951674f, -0.00652204f, -0.02548798f, 0.01887575f, 0.20398334f, 0.01819209f, 
    0.06047019f, 0.01656031f, 0.00405107f, 0.02816694f, -0.11184601f, 0.09133767f, -0.04288412f, 0.00845523f, 
    -0.22803539f, 0.12422891f, -0.08710253f, 0.03007889f, 0.04830978f, 0.15909226f, -0.07677994f, 0.08192722f, 
    -0.00204496f, -0.02509887f, 0.07279692f, 0.05844554f, -0.19787756f, 0.04040015f, 0.01605889f, 0.10636675f, 
    0.11985487f, -0.02605259f, -0.05101921f, 0.02131014f, 0.13214210f, 0.07836431f, -0.08366279f, -0.03420484f, 
    -0.24373993f, -0.02864832f, 0.01169249f, 0.12655877f, 0.07107893f, -0.02759686f, 0.08244485f, 0.07088575f, 
    0.03173055f, -0.02011666f, 0.02219677f, 0.03923906f, -0.03956570f, -0.03453780f, 0.06082227f, -0.01960618f, 
    -0.00473612f, 0.02699059f, 0.02539098f, 0.02492665f, 0.08501927f, 0.02754871f, 0.06355124f, 0.08238285f, 
    -0.15284376f, 0.14914773f, 0.08679254f, -0.17663039f, 0.02651913f, 0.03321534f, 0.04627048f, 0.12474704f, 
    0.05905971f, 0.04611807f, 0.11404716f, 0.05096743f, -0.06506752f, -0.05670976f, 0.04767953f, -0.16970798f, 
    0.05140753f, 0.01304463f, -0.09257412f, -0.10711171f, 0.04086248f, -0.08937933f, -0.05750185f, 0.00687420f, 
    0.07200008f, -0.00847963f, -0.17509775f, -0.23485810f, -0.01286867f, 0.04556063f, 0.02457421f, 0.00716160f, 
    0.02255153f, 0.10313457f, 0.02246137f, -0.00247372f, -0.14320393f, 0.11152258f, 0.09410310f, -0.14845701f, 
    0.02920740f, -0.06904847f, 0.06549793f, -0.07445714f, 0.09653558f, 0.08130836f, 0.01209885f, 0.01574791f, 
    -0.00550707f, 0.22777285f, 0.05663804f, -0.20960370f, 0.07655865f, -0.08077680f, 0.02385980f, 0.01510511f, 
    -0.16649732f, -0.01501252f, -0.01750984f, 0.08853605f, -0.19941022f, 0.08870438f, -0.11133409f, -0.17739040f, 
    -0.02814905f, 0.06199758f, -0.04045138f, 0.07174271f, 0.04782515f, 0.00231730f, 0.05314019f, -0.04462408f, 
    0.22155561f, -0.05663610f, -0.02091008f, 0.00583970f, -0.00512829f, -0.01960984f, 0.09385221f, 0.06083746f, 
    0.05098601f, 0.05915057f, 0.08172149f, 0.00138803f, -0.14350469f, 0.01443861f, -0.09785150f, -0.07103612f, 
    0.04683298f, -0.07648053f, 0.04009196f, -0.02159161f, -0.08907468f, -0.10549904f, -0.06404088f, 0.08989459f, 
    0.04907281f, 0.10436864f, -0.00831434f, -0.23383668f, 0.01947322f, 0.04631236f, 0.13078953f, 0.00480137f, 
    -0.02994362f, 0.09452846f, 0.06104686f, 0.13683522f, 0.17398314f, -0.05451579f, -0.06139876f, -0.04811386f, 
    0.07689030f, -0.03246685f, 0.06524443f, -0.05047955f, 0.01186537f, 0.08021989f, 0.04088562f, -0.08179101f, 
    0.05188497f, -0.08175439f, -0.07241119f, 0.04860993f, -0.12830396f, 0.04899120f, 0.01983627f, -0.05091979f, 
    -0.07140085f, 0.03280671f, 0.12610210f, 0.09281827f, -0.25244582f, 0.03348106f, 0.11983401f, -0.09395270f, 
    0.10630695f, 0.06506250f, 0.08247852f, -0.03586786f, 0.05645973f, -0.14221440f, 0.03523570f, 0.02352906f, 
    0.27242368f, -0.13818146f, -0.01683109f, -0.13670026f, -0.06316336f, 0.01062941f, 0.04107955f, 0.23742542f, 
    0.09287728f, 0.07823950f, -0.02748108f, 0.02430911f, 0.44321662f, -0.28871927f, 0.13006237f, -0.03425262f, 
    -0.07114764f, -0.01647086f, 0.15706439f, -0.03807567f, 0.10558408f, 0.05449108f, 0.07269090f, 0.04490157f, 
    0.26340416f, -0.08405352f, -0.07039851f, 0.03483923f, 0.06176596f, 0.13622449f, -0.05414153f, 0.10677021f, 
    0.02970920f, -0.02186616f, -0.07587978f, 0.00854925f, 0.01719955f, -0.15056196f, 0.22470208f, 0.04307562f, 
    -0.00843050f, -0.04930514f, 0.02820060f, 0.10181906f, 0.00335764f, 0.12533419f, 0.09819723f, 0.03326720f, 
    -0.08814576f, 0.18209444f, -0.04214757f, -0.10046607f, -0.06430985f, 0.00605896f, -0.01095738f, 0.12022724f, 
    -0.05394784f, -0.00174471f, 0.02595519f, 0.07693521f, 0.22530548f, 0.00062165f, -0.16261639f, -0.03865050f, 
    -0.07545221f, 0.00415776f, 0.06751544f, 0.08004817f, -0.02617586f, 0.00450618f, 0.01567786f, -0.03153890f, 
    -0.04647248f, 0.15355812f, 0.13558476f, -0.19066362f, 0.06354015f, 0.05130232f, 0.07291920f, -0.01007535f, 
    0.01141375f, 0.09673329f, -0.00054095f, 0.10053532f, 0.21289216f, -0.17953676f, -0.00855533f, -0.01655029f, 
    0.03808738f, -0.07719317f, 0.09499701f, -0.16577943f, 0.09039838f, 0.14362785f, -0.01021217f, -0.02324025f, 
    -0.20873743f, -0.30874225f, -0.00266504f, -0.01277867f, 0.07230195f, 0.05639375f, 0.02942122f, 0.12998700f, 
    -0.01305071f, -0.03731336f, 0.09115575f, 0.07254029f, -0.36937749f, 0.29878008f, -0.06379899f, 0.15230358f, 
    0.05679492f, -0.08743217f, 0.01059152f, -0.05037878f, 0.00070180f, 0.04978161f, -0.05757101f, -0.04009786f, 
    -0.20149916f, 0.05141418f, 0.22601633f, 0.14086978f, 0.08096192f, -0.08409085f, -0.00769890f, 0.02765993f, 
    0.00487469f, 0.10400494f, -0.03143700f, -0.05923706f, -0.20553873f, 0.02042523f, 0.02811918f, -0.16316128f, 
    -0.11598977f, -0.00828540f, -0.05684712f, -0.01462490f, 0.17087467f, -0.13312586f, 0.05297050f, -0.01719168f, 
    0.05193673f, 0.20094199f, 0.21275096f, 0.12297872f, -0.01480246f, 0.01306993f, -0.04882813f, -0.07030868f, 
    0.08086770f, 0.05829744f, 0.14749454f, -0.01358825f, 0.00571574f, -0.06632046f, -0.22150277f, 0.10537643f, 
    0.02569957f, -0.00531354f, 0.12539594f, 0.08760158f, -0.01344249f, -0.07798639f, 0.03543008f, 0.03657322f, 
    0.24817464f, -0.09755167f, 0.18771119f, -0.09169122f, 0.11245567f, 0.07419516f, 0.07301906f, 0.06435224f, 
    0.02272204f, 0.01462763f, 0.03542428f, 0.03049338f, -0.33967742f, 0.04018529f, 0.03036832f, 0.25404885f, 
    -0.03511296f, 0.04898782f, 0.11535199f, 0.06748757f, -0.05031209f, 0.02544837f, 0.11673842f, -0.15060808f, 
    -0.02272515f, 0.16893740f, 0.07698151f, -0.11795560f, 0.13571171f, 0.06405519f, 0.09656352f, -0.10154021f, 
    -0.01007330f, 0.08814826f, -0.04764120f, 0.00492276f, 0.00463506f, -0.13789006f, -0.10538373f, 0.17891294f, 
    0.18128109f, -0.03829521f, -0.10375872f, -0.01980234f, 0.05018099f, 0.01790742f, 0.04178020f, 0.05187003f, 
    -0.04598617f, 0.14877100f, 0.18934205f, 0.11114638f, 0.02105597f, -0.06428071f, -0.06746385f, -0.14401725f, 
    -0.01305935f, -0.01022924f, 0.05985172f, -0.08427101f, 0.00546419f, 0.01215607f, 0.10737905f, -0.11717980f, 
    0.10740458f, 0.08164394f, 0.13135730f, 0.02862591f, -0.02753798f, 0.04783203f, 0.06594647f, 0.14808163f, 
    0.46752605f, -0.15133053f, 0.00677139f, -0.11481590f, -0.00192176f, 0.03768391f, -0.01596848f, -0.02482015f, 
    0.07490569f, 0.02370546f, 0.08567708f, -0.00806349f, -0.19555172f, 0.01667214f, 0.07829017f, 0.01822304f, 
    -0.04080886f, 0.01354707f, -0.02200971f, 0.00294901f, 0.05579443f, 0.07727871f, 0.00238150f, 0.10642213f, 
    0.19208419f, 0.18952522f, -0.11794551f, -0.23777768f, -0.02782839f, 0.03599741f, 0.02498115f, -0.07528511f, 
    -0.13252293f, 0.09193268f, -0.02980847f, 0.01056412f, 0.20264092f, 0.01500409f, 0.05180349f, -0.21878941f, 
    -0.10318012f, -0.04714200f, 0.04762038f, -0.09818570f, -0.00440542f, -0.03365352f, -0.01520613f, 0.02115257f, 
    0.27257222f, -0.19282848f, -0.04916917f, 0.07912587f, -0.02448671f, -0.02845656f, 0.02236433f, -0.06916306f, 
    0.05173028f, 0.12868266f, 0.08830358f, -0.03695780f, 0.31115109f, 0.09992789f, 0.08343869f, 0.00443990f, 
    0.02742810f, 0.01598266f, -0.05503219f, -0.11907199f, 0.04368304f, -0.07288796f, 0.06237358f, 0.00749924f, 
    -0.23552720f, -0.17597151f, 0.19363886f, 0.07477320f, -0.02307105f, -0.02131159f, 0.12747633f, 0.09475215f, 
    0.08540633f, -0.04810804f, -0.03830259f, 0.13869224f, 0.32272476f, -0.03177712f, 0.10936603f, -0.06225864f, 
    -0.00141078f, 0.01419595f, 0.04699943f, 0.09195506f, 0.03479038f, 0.05356370f, -0.00100391f, 0.02687792f, 
    -0.03705017f, 0.02022908f, 0.01886223f, -0.00619046f, -0.00557135f, 0.01224737f, 0.02673568f, -0.00342355f, 
    0.00072751f, -0.02827336f, -0.01189857f, 0.02435737f, -0.02639498f, -0.02398095f, 0.01114144f, 0.02625485f, 
    -0.02895431f, 0.01626062f, -0.03162824f, 0.01251450f, -0.03513325f, -0.00106627f, 0.00838146f, 0.00190980f, 
    -0.03689516f, 0.02585213f, -0.01017731f, 0.01805518f, -0.03253609f, -0.00172318f, -0.01990430f, 0.00950306f, 
    -0.00052881f, -0.00150502f, -0.01463717f, -0.01664369f, -0.00754087f, 0.01796661f, 0.02601622f, -0.00665792f, 
    0.03356719f, -0.02746505f, -0.03627943f, -0.02850746f, 0.02451678f, -0.01612681f, -0.02445238f, -0.02815236f, 
    0.02286343f, 0.02482413f, 0.00035195f, -0.03597196f, -0.01385773f, -0.02029112f, 0.01115253f, 0.00931483f, 
    0.01311277f, 0.02700321f, -0.02428166f, -0.04012467f, 0.02687599f, 0.01403426f, 0.02904965f, 0.00688725f, 
    -0.03059544f, 0.01787203f, -0.03566103f, -0.01331941f, 0.01753375f, -0.02372819f, -0.04089262f, -0.04068265f, 
    0.02725521f, 0.01718497f, -0.01777410f, 0.00188662f, -0.03088619f, -0.04082040f, -0.01416371f, -0.04142697f, 
    0.00718436f, -0.03616567f, -0.01290020f, 0.00543184f, -0.02692407f, -0.03080793f, -0.03566313f, 0.00254237f, 
    0.00929092f, 0.01482125f, -0.03473858f, 0.01015943f, 0.02155373f, -0.00830160f, -0.02226627f, -0.01620865f, 
    -0.02855609f, 0.02589152f, -0.03331893f, -0.02106533f, -0.01648509f, -0.00586760f, -0.00794915f, 0.00208614f, 
    0.01420514f, 0.02610388f, 0.02251068f, -0.00688510f, -0.00519386f, 0.00793752f, -0.02348010f, -0.00445391f, 
    0.02289363f, -0.00388051f, -0.00365807f, 0.02314146f, -0.01461914f, 0.02962979f, -0.01326042f, -0.03309807f, 
    0.02831952f, 0.00107829f, 0.01487687f, -0.01470374f, -0.00338474f, -0.02608770f, -0.01524003f, -0.01966757f, 
    0.01289810f, -0.00935666f, 0.00693674f, -0.00544337f, -0.02485173f, -0.01241507f, -0.02181310f, -0.00257507f, 
    -0.02995894f, -0.03544489f, -0.01231197f, 0.01766595f, -0.01428555f, 0.00978445f, 0.01606033f, 0.00302685f, 
    0.01233946f, -0.04189166f, -0.03220074f, 0.00479544f, 0.00440976f, 0.02949642f, -0.03221661f, -0.02047912f, 
    0.00046649f, 0.00112540f, -0.01338721f, 0.01149630f, 0.01181429f, -0.01688856f, 0.00012567f, 0.01377668f, 
    -0.03023124f, -0.00538460f, -0.03867246f, 0.02019736f, -0.01668775f, 0.01558558f, -0.03009578f, -0.02704128f, 
    -0.03079715f, -0.01225508f, -0.02154931f, -0.02345476f, 0.00323633f, -0.02311810f, -0.02982931f, -0.00051939f, 
    -0.01213267f, -0.02447262f, -0.01701112f, -0.03358738f, -0.01376087f, -0.02664006f, -0.03915549f, 0.01620842f, 
    -0.00401844f, 0.01959744f, -0.01616706f, -0.02575528f, -0.00475690f, 0.02901927f, -0.00613883f, 0.01182778f, 
    -0.01633001f, -0.03367304f, -0.02323190f, -0.00658455f, -0.01548511f, -0.00930787f, 0.01357872f, 0.02460754f, 
    0.01937000f, -0.00004438f, -0.03504809f, 0.02936232f, -0.02201904f, -0.01010557f, 0.02564021f, -0.03389237f, 
    -0.00344988f, -0.03936458f, 0.02211154f, -0.03272789f, -0.01351077f, -0.02621571f, -0.02511563f, -0.01209035f, 
    -0.03667148f, -0.01901943f, -0.02501021f, -0.00382512f, 0.01361035f, -0.01307307f, -0.01649241f, -0.02054574f, 
    -0.02465056f, -0.03805827f, -0.00861205f, -0.02450087f, -0.02348949f, -0.00548704f, 0.00055701f, -0.00655405f, 
    0.00714412f, -0.01149189f, 0.00987471f, 0.02419834f, -0.02557808f, 0.02603722f, -0.01251616f, -0.01398889f, 
    -0.02044406f, -0.04070936f, 0.00717900f, 0.00547639f, -0.02412432f, -0.01109045f, 0.00190659f, 0.02312683f, 
    0.02131812f, 0.00590707f, 0.00005553f, 0.02644813f, 0.01126351f, -0.02398498f, -0.01543136f, 0.02190974f, 
    -0.02050983f, -0.02903746f, 0.00498225f, 0.01079834f, 0.00153664f, -0.00943124f, -0.00306784f, -0.03462574f, 
    -0.00768645f, 0.02382343f, -0.02886325f, -0.02389122f, -0.01185888f, 0.02337226f, -0.02966901f, 0.02796727f, 
    -0.02408053f, -0.00831311f, -0.03247574f, -0.03620155f, -0.01235961f, -0.03504764f, -0.00525092f, -0.02525890f, 
    0.00458193f, 0.00663464f, 0.00519319f, -0.03582865f, 0.02351881f, -0.01802904f, -0.00907167f, -0.00949211f, 
    -0.03488647f, 0.00506586f, 0.02806547f, -0.04191323f, -0.03080750f, 0.02477909f, 0.00796789f, 0.01509451f, 
    -0.03967526f, -0.03881424f, 0.02520164f, 0.00274789f, -0.01143922f, 0.00571202f, -0.03879893f, 0.02128176f, 
    -0.03112289f, -0.01351925f, -0.01130529f, 0.02505052f, -0.03956696f, -0.03395608f, -0.02804450f, -0.03936829f, 
    0.01035236f, -0.02341059f, 0.01735678f, -0.01900386f, 0.00176224f, -0.02915908f, 0.00168428f, -0.03072638f, 
    -0.03953511f, 0.02058761f, -0.03651579f, -0.03027270f, -0.03755768f, -0.03801369f, 0.00911506f, 0.00728304f, 
    0.01270622f, -0.03411588f, 0.02224323f, -0.04050545f, -0.01012166f, -0.01099664f, 0.00277779f, 0.01193128f, 
    0.01703464f, -0.02254988f, -0.02768001f, -0.01473287f, -0.00919537f, -0.03223413f, 0.02631668f, -0.01967262f, 
    0.02051070f, -0.02766132f, -0.02236352f, -0.03488386f, -0.03143713f, -0.00271732f, -0.02170583f, -0.02208645f, 
    0.00567874f, -0.01131780f, -0.00409142f, 0.02260877f, 0.01827850f, 0.02663529f, -0.00682309f, -0.02030003f, 
    -0.02367122f, 0.00732731f, 0.01587669f, -0.02995441f, -0.00318199f, -0.00568338f, 0.02276442f, 0.02025798f, 
    -0.00193216f, 0.02501807f, 0.02605439f, -0.01309648f, -0.00176218f, 0.02882798f, -0.03085143f, -0.03256074f, 
    -0.03161995f, -0.03311531f, -0.01582167f, 0.02774503f, -0.00034569f, -0.03193780f, 0.01380609f, 0.01559360f, 
    0.01263438f, -0.04016000f, 0.00058224f, -0.01344726f, 0.00238136f, 0.00127837f, 0.00124009f, -0.03097045f, 
    0.02380011f, -0.02928452f, 0.02084114f, -0.00652320f, 0.00000077f, -0.03710599f, 0.02494409f, -0.03959361f, 
    -0.03067523f, -0.02799212f, 0.02428135f, -0.03839055f, 0.02363173f, 0.00441649f, -0.00908096f, -0.00527438f, 
    -0.01588286f, 0.00029509f, -0.00995837f, -0.01010550f, 0.02914549f, -0.00342618f, -0.02863333f, -0.03740131f, 
    0.00938673f, -0.03532570f, -0.03937647f, -0.01789304f, 0.02586124f, -0.01576254f, -0.03637195f, -0.01701321f, 
    -0.00212916f, 0.00885558f, -0.01181188f, -0.00782227f, -0.00225978f, -0.03897201f, 0.00912139f, -0.01764097f, 
    0.01074434f, 0.02577394f, -0.03926216f, 0.02736685f, -0.00193953f, 0.02560549f, -0.01780794f, -0.01137225f, 
    -0.03494547f, -0.02083638f, -0.03832261f, -0.01715836f, 0.00517029f, 0.00576231f, -0.03558667f, -0.00507813f, 
    -0.02924206f, 0.03479405f, -0.00509077f, -0.03588970f, 0.02069333f, -0.00416784f, 0.00258109f, -0.01199056f, 
    0.02603707f, -0.03784600f, 0.01401589f, -0.00578046f, -0.01915468f, -0.02718499f, -0.03107380f, -0.02703748f, 
    -0.03323503f, 0.01185622f, -0.02883240f, 0.02648837f, -0.02859871f, 0.00045466f, -0.03248372f, -0.02640804f, 
    0.01410181f, -0.00847043f, -0.01583312f, -0.00659576f, 0.02142634f, -0.00100302f, -0.01231874f, 0.02658948f, 
    -0.00613544f, -0.03030788f, -0.02322243f, -0.01142751f, -0.02374738f, 0.01131747f, -0.01115554f, 0.02413331f, 
    -0.03282598f, 0.00881157f, -0.03810777f, 0.02084440f, -0.00345460f, 0.00174275f, 0.02047222f, 0.01116776f, 
    0.01730544f, -0.01926931f, 0.02613655f, 0.01989005f, 0.00847145f, 0.00976004f, -0.00576139f, 0.02486110f, 
    0.01122369f, -0.03604600f, 0.00594017f, 0.03003958f, 0.00742861f, -0.00694416f, -0.00905364f, 0.02569687f, 
    0.01416380f, -0.00448198f, 0.02943841f, 0.02394942f, -0.03694409f, 0.01443283f, -0.02980736f, -0.03550169f, 
    -0.02490955f, 0.01501694f, 0.02733809f, 0.00730723f, -0.02855687f, 0.02559402f, 0.01533285f, 0.01592539f, 
    -0.04023366f, -0.01745831f, -0.03726254f, -0.03567608f, 0.01164996f, 0.02447212f, -0.00971258f, 0.02488962f, 
    0.00745161f, -0.04192951f, 0.01404501f, -0.03027969f, -0.02359363f, -0.00715829f, -0.01246010f, -0.04048208f, 
    0.00759617f, -0.03978388f, -0.00702803f, -0.01084964f, 0.02479886f, 0.00640386f, -0.01750397f, -0.03761444f, 
    0.01421241f, -0.01819625f, -0.04090834f, 0.02536201f, -0.04175870f, -0.02346489f, -0.02228526f, -0.03885140f, 
    0.02039199f, 0.00454984f, 0.00221255f, -0.00335973f, -0.00802490f, 0.00382591f, 0.00040253f, 0.02431867f, 
    -0.01014623f, 0.01991242f, 0.02849412f, -0.02715671f, -0.01074528f, 0.00574060f, 0.00634437f, 0.00947699f, 
    -0.01226781f, 0.01403499f, -0.01406138f, 0.01534556f, 0.00833953f, -0.00778433f, -0.01421285f, -0.01354881f, 
    -0.02198125f, -0.00032090f, 0.02583143f, -0.02007449f, -0.03117304f, -0.02208310f, -0.03722537f, 0.01773515f, 
    0.00077233f, 0.02543212f, -0.03508061f, 0.02780615f, 0.02276123f, -0.00537595f, -0.01060241f, -0.00325187f, 
    -0.01953948f, 0.00329776f, -0.00725729f, -0.02611618f, -0.04179524f, -0.01426884f, 0.00356400f, -0.03790271f, 
    0.01796519f, -0.03129078f, 0.02372273f, 0.00952458f, -0.03496690f, -0.03973289f, -0.00269200f, -0.03605972f, 
    -0.00946275f, -0.01265440f, -0.01310854f, -0.03267932f, 0.01934220f, -0.02615760f, -0.00912620f, 0.02243966f, 
    0.00785624f, 0.01118947f, 0.01861594f, 0.02130270f, 0.00659385f, -0.01675703f, -0.03406426f, 0.01195587f, 
    -0.01997682f, -0.00645296f, 0.01767653f, 0.00190142f, 0.02754178f, 0.02972204f, -0.03152370f, -0.02450737f, 
    -0.04046340f, -0.00396921f, 0.01160839f, -0.00238413f, -0.03295020f, -0.03073804f, -0.03641081f, 0.00648404f, 
    0.01047825f, 0.02620577f, -0.01071512f, 0.02821068f, 0.02960338f, -0.02342639f, 0.01067609f, -0.02716630f, 
    -0.04013724f, -0.01134806f, -0.02990957f, -0.03128107f, -0.02445448f, -0.03110893f, 0.02298517f, -0.00120407f, 
    0.02654233f, -0.03378869f, -0.03713185f, -0.02779198f, 0.02377082f, -0.00636292f, 0.01244139f, -0.01392612f, 
    0.02324443f, -0.00631048f, 0.01086909f, -0.02421037f, 0.02516606f, 0.02229844f, -0.00896257f, 0.01163069f, 
    0.02329274f, -0.03254698f, -0.01381573f, -0.00357215f, -0.03859232f, -0.01602339f, -0.00089173f, -0.02000965f, 
    -0.00492983f, -0.00031303f, 0.01348645f, -0.00463830f, 0.02800841f, -0.02866388f, 0.00405861f, -0.01548958f, 
    0.01221881f, -0.01492410f, -0.01944760f, 0.00848482f, -0.01508070f, 0.01923712f, -0.03928156f, 0.02197103f, 
    0.00130834f, 0.00974707f, 0.00142739f, 0.00948638f, -0.03957755f, -0.01069562f, 0.01289376f, -0.02751220f, 
    -0.04171747f, -0.03264400f, 0.00116302f, -0.01376132f, -0.01656825f, -0.01085793f, 0.02935663f, 0.00594269f, 
    -0.00138792f, -0.03516325f, -0.02017408f, -0.01364558f, -0.03541392f, -0.02642278f, -0.00963406f, -0.02852100f, 
    -0.02236935f, 0.00683985f, 0.02720721f, -0.01607226f, 0.00054119f, 0.01708073f, -0.02011650f, -0.01831674f, 
    0.00166211f, -0.03293301f, -0.00886849f, -0.02150887f, 0.01389610f, -0.03092075f, -0.02865478f, -0.00381768f, 
    -0.03307911f, 0.00706103f, 0.02081232f, -0.01773802f, -0.00497124f, -0.03806435f, 0.01811060f, 0.02746350f, 
    -0.02362706f, -0.00737402f, -0.01220191f, 0.02268052f, -0.02614615f, 0.02748213f, 0.02483256f, -0.02590573f, 
    -0.02648072f, -0.03082867f, 0.02295230f, 0.02186279f, 0.00165400f, -0.03621147f, 0.01398617f, -0.02811866f, 
    -0.03993188f, -0.03860712f, -0.01673979f, -0.02311236f, -0.03602926f, -0.02491186f, 0.01089531f, 0.01684879f, 
    0.03368066f, -0.00825514f, -0.04324843f, 0.02250575f, 0.01427691f, -0.02032776f, 0.02037580f, -0.01213094f, 
    0.01706473f, -0.04070562f, 0.00181321f, 0.02277432f, -0.01920982f, 0.02505355f, 0.01189355f, 0.02479577f, 
    -0.00203956f, 0.00946525f, -0.01939791f, 0.00902010f, -0.00001379f, -0.03545010f, 0.01500515f, -0.03917626f, 
    -0.02015691f, -0.02980657f, -0.02586384f, -0.01587890f, -0.00981091f, 0.00918033f, 0.00261769f, -0.01546639f, 
    -0.00314470f, 0.00446112f, 0.02331699f, -0.00726570f, -0.02405963f, -0.01117586f, -0.00828716f, 0.02965936f, 
    0.02276151f, 0.02343291f, -0.00513059f, -0.02238847f, 0.01544591f, 0.02020003f, 0.02667216f, 0.02554768f, 
    -0.04032583f, 0.01810080f, 0.01714471f, -0.03721765f, 0.02036709f, -0.01242629f, -0.02491812f, -0.03537715f, 
    0.00230005f, -0.00048960f, -0.00776520f, 0.00344323f, -0.00078192f, -0.03213256f, 0.01567966f, -0.02177457f, 
    0.02385273f, -0.01444137f, 0.02065445f, 0.02806975f, 0.00937319f, -0.01935337f, -0.02497574f, -0.04249482f, 
    -0.03535260f, -0.04181434f, -0.00889766f, 0.00100742f, -0.03458788f, 0.02632939f, -0.00539792f, 0.01052371f, 
    -0.00623614f, -0.01975780f, -0.01648286f, 0.01231119f, -0.02731861f, 0.02349965f, 0.00682138f, 0.00637017f, 
    -0.00449405f, -0.03085442f, -0.00382660f, 0.03307503f, -0.00085303f, -0.03507632f, -0.03741412f, -0.01118039f, 
    0.00928103f, -0.01232158f, 0.02441498f, 0.03404817f, -0.00655551f, 0.02062577f, 0.00932258f, 0.01847353f, 
    0.01771960f, -0.00253689f, 0.01072543f, 0.01389720f, 0.00965020f, 0.00335764f, 0.00305436f, -0.01950290f, 
    0.01497664f, -0.04147784f, -0.00129562f, 0.01861787f, -0.01250928f, 0.02523822f, 0.01191732f, 0.00355320f, 
    -0.01096981f, -0.01317929f, -0.01828935f, -0.02818554f, -0.00138997f, 0.00062018f, 0.02060191f, 0.02575174f, 
    -0.01235845f, 0.01099971f, -0.02978548f, -0.04100318f, 0.01453622f, 0.01708014f, -0.02395762f, -0.01500701f, 
    0.00448698f, 0.02832182f, 0.00682738f, 0.01011913f, -0.03133733f, -0.03687179f, -0.01714317f, -0.00575266f, 
    -0.02112025f, -0.03363080f, 0.00949824f, 0.01577129f, -0.03092670f, -0.02995995f, 0.02908940f, 0.02935964f, 
    -0.04127531f, -0.01745733f, -0.02280662f, -0.03380599f, 0.01162410f, -0.01359092f, 0.00392709f, -0.03223960f, 
    -0.01359891f, -0.02229617f, -0.02939739f, 0.01011584f, 0.00475649f, -0.01137042f, 0.02775685f, -0.03811758f, 
    -0.03613591f, -0.00335901f, -0.03452838f, 0.02432511f, 0.02733421f, -0.03870264f, -0.03806118f, -0.01832546f, 
    -0.03205299f, 0.02456902f, 0.02725257f, 0.02216529f, -0.00891117f, -0.02962593f, -0.00651575f, 0.00802111f, 
    0.01968003f, 0.01813064f, -0.02635917f, 0.01184102f, -0.02551257f, -0.03465500f, 0.02960392f, -0.03135999f, 
    -0.02731872f, -0.00803082f, 0.01802633f, -0.00108793f, -0.02309356f, -0.03826348f, -0.02144796f, 0.01724356f, 
    -0.01698725f, 0.01007392f, -0.01856771f, -0.03316429f, 0.02310253f, 0.02934216f, -0.02268171f, 0.00260261f, 
    0.01482714f, -0.00742287f, 0.00295157f, -0.00449542f, -0.00626981f, -0.01541995f, 0.02190882f, -0.03246623f, 
    0.01777047f, -0.02582479f, -0.03292200f, -0.00349215f, -0.02303795f, 0.01529742f, -0.00515628f, -0.02036396f, 
    -0.00323997f, -0.00580565f, -0.00067119f, 0.00320761f, 0.02043611f, -0.02872451f, 0.02041549f, 0.02057600f, 
    0.00203427f, -0.00970355f, 0.02058054f, -0.03999570f, 0.01641461f, -0.02673863f, 0.01077883f, -0.00890711f, 
    -0.00104414f, 0.00132937f, 0.00955945f, -0.00448934f, -0.03902652f, 0.02047984f, -0.00498980f, -0.01662226f, 
    0.01981479f, 0.02389990f, -0.01581742f, 0.02368349f, -0.00561079f, -0.00021140f, 0.02896920f, -0.00350450f, 
    -0.01192373f, 0.02306691f, 0.02667784f, -0.03902328f, 0.02612490f, -0.03487558f, -0.03667488f, -0.00072416f, 
    0.01445993f, -0.00079971f, 0.03101449f, 0.00239087f, -0.02649181f, 0.01750091f, -0.01358038f, 0.02472825f, 
    -0.00761390f, 0.01908120f, 0.00959993f, 0.02419919f, 0.02850999f, -0.00895959f, 0.01123297f, 0.00925544f, 
    -0.01552332f, 0.03045248f, -0.02162871f, 0.03073389f, 0.03243708f, 0.01805157f, 0.02784842f, -0.01727921f, 
    0.02560271f, -0.03058121f, -0.01083580f, -0.02924593f, 0.00705748f, 0.00030014f, -0.03320317f, 0.01598806f, 
    0.01201125f, -0.01885293f, -0.01034338f, 0.01640233f, 0.01298605f, -0.00655295f, 0.02840408f, -0.01779812f, 
    -0.01486779f, -0.01697185f, 0.02819833f, 0.03266478f, 0.01219705f, 0.00397988f, -0.02768606f, 0.03599445f, 
    -0.01577515f, 0.02862852f, -0.00985567f, 0.00091888f, -0.01960052f, -0.03651753f, -0.00263704f, 0.03289973f, 
    -0.00558682f, -0.01127653f, -0.03823742f, -0.02511706f, -0.00611376f, 0.01177419f, -0.04042401f, 0.00435812f, 
    -0.02870994f, -0.01240203f, 0.01230765f, -0.01189095f, -0.01971249f, -0.02243694f, -0.03157995f, 0.02077460f, 
    -0.00854559f, -0.03940225f, 0.01749025f, -0.01330380f, 0.02530215f, -0.03267100f, -0.02810816f, -0.02751810f, 
    -0.01468095f, -0.03385762f, -0.03587018f, -0.02809664f, 0.00986391f, 0.01823664f, -0.00280871f, 0.01175988f, 
    -0.01568376f, -0.02809976f, 0.00048986f, 0.02491012f, 0.01097971f, 0.02383586f, -0.04262593f, 0.00222357f, 
    0.01165411f, -0.00113871f, 0.00062218f, -0.02452105f, -0.02858242f, -0.01055332f, -0.04131985f, 0.01766858f, 
    0.02768921f, 0.01394092f, -0.03005623f, -0.00540606f, -0.00257224f, -0.02853836f, 0.01659627f, 0.01832869f, 
    -0.00187803f, -0.03741821f, 0.00265743f, 0.01846823f, -0.03490548f, 0.01948064f, 0.00639795f, 0.01531371f, 
    -0.01327843f, 0.02326130f, -0.00287769f, -0.01160732f, -0.02182366f, 0.01181480f, -0.02329475f, -0.02647778f, 
    0.01622107f, -0.02174890f, -0.00964835f, 0.00548553f, -0.00046146f, 0.00140785f, -0.01752658f, -0.01120020f, 
    -0.01632653f, 0.02349112f, 0.00815866f, -0.00469179f, -0.01998171f, 0.00025727f, -0.00098098f, -0.00497885f, 
    -0.03967845f, -0.03208025f, 0.01733665f, -0.00867023f, -0.02188195f, 0.01044121f, 0.01638916f, -0.02773198f, 
    0.01571461f, -0.01488822f, -0.01322108f, -0.02537679f, 0.03385836f, -0.01897993f, -0.03711373f, -0.02362646f, 
    0.01031641f, -0.03601732f, 0.01882934f, 0.02388541f, -0.03460496f, -0.03884423f, 0.01311700f, -0.01904255f, 
    0.02215011f, 0.02817417f, 0.00868411f, -0.01666757f, -0.03669683f, -0.02178064f, 0.03372593f, 0.00260417f, 
    -0.01293692f, 0.00627275f, -0.01513108f, -0.03591047f, 0.01460182f, -0.03538597f, 0.01523744f, -0.02603641f, 
    0.02716271f, 0.02501172f, 0.02522261f, 0.00742752f, -0.03914635f, -0.00062719f, 0.02814073f, -0.02240465f, 
    -0.00174255f, -0.01349746f, -0.01104598f, -0.03160538f, 0.02272754f, -0.01382007f, 0.01618298f, -0.01280183f, 
    0.02820679f, -0.00268091f, -0.01984784f, 0.02896564f, 0.02150059f, -0.03660893f, -0.02007227f, -0.00507022f, 
    -0.02595638f, 0.02789641f, -0.01384171f, -0.03552087f, -0.01461517f, 0.01859516f, 0.01125809f, 0.02127880f, 
    -0.00435146f, -0.02826633f, -0.01646311f, 0.02662192f, -0.03947669f, 0.01456808f, -0.03645042f, 0.02401417f, 
    -0.03240044f, -0.01640240f, 0.00454553f, -0.00106867f, -0.04000016f, 0.02058640f, -0.01811708f, -0.03453643f, 
    -0.02488481f, -0.02064351f, 0.02225720f, 0.01786111f, -0.00954365f, -0.03979427f, 0.01046658f, 0.01453543f, 
    -0.01786719f, 0.02007158f, 0.00872961f, 0.02172580f, 0.01493697f, 0.00003099f, -0.00749668f, -0.00998819f, 
    -0.02968274f, 0.01329696f, 0.00543640f, -0.00656541f, -0.04264680f, -0.03279642f, 0.00536933f, 0.00268180f, 
    0.00317186f, 0.02708899f, 0.01319555f, -0.00044980f, 0.01957829f, -0.01175095f, -0.03909321f, 0.00476116f, 
    -0.04099525f, -0.02551113f, -0.00908795f, -0.00351745f, -0.01360232f, -0.00138198f, -0.03398312f, -0.03081256f, 
    0.00951152f, 0.03128642f, 0.02184251f, 0.00963473f, 0.00293012f, 0.02622033f, -0.00329011f, -0.01272563f, 
    -0.01283725f, -0.01028261f, -0.02283617f, 0.02382795f, 0.00586085f, -0.02767469f, 0.01472813f, -0.02594162f, 
    -0.03879418f, 0.01270993f, 0.01933459f, 0.02541782f, -0.03165368f, -0.01921843f, -0.01109726f, 0.01279889f, 
    -0.03722912f, -0.01356883f, -0.02142916f, -0.00979940f, 0.01328637f, -0.01238486f, -0.02905401f, -0.04004044f, 
    0.01699077f, -0.04108814f, -0.00699807f, -0.01182143f, -0.00405811f, -0.01904422f, -0.00371999f, 0.03084055f, 
    0.02690595f, 0.02435009f, -0.02323830f, -0.01043833f, -0.03921638f, -0.01731450f, 0.02172017f, -0.02354172f, 
    -0.01091996f, -0.02224324f, -0.01020673f, -0.00394033f, -0.02582810f, 0.00582458f, -0.04080782f, -0.03890238f, 
    0.02753697f, 0.02296774f, -0.02687914f, 0.00075902f, -0.02711437f, 0.00900849f, -0.01589873f, -0.03435735f, 
    -0.01871435f, -0.02477857f, 0.03360309f, -0.01105016f, -0.04117698f, -0.00338298f, 0.02084659f, 0.02781476f, 
    0.01208934f, -0.01188714f, -0.02532104f, -0.03676965f, -0.02638393f, -0.00645113f, 0.00757191f, -0.01775432f, 
    0.00075035f, 0.01791424f, -0.03689042f, 0.01525695f, -0.03338542f, 0.01765279f, 0.00147845f, -0.01865539f, 
    -0.02619657f, -0.02712634f, 0.00218442f, -0.00446185f, 0.01558388f, -0.01500422f, 0.00965705f, 0.01094877f, 
    -0.00765057f, -0.03802979f, -0.04017158f, -0.04243751f, 0.00913756f, -0.00831656f, 0.02186249f, -0.00988427f, 
    -0.00859712f, -0.01313551f, -0.02688304f, -0.01058383f, -0.01517407f, -0.00600900f, 0.02543903f, 0.00925920f, 
    0.00749397f, -0.01898792f, -0.03754478f, -0.03133024f, 0.01178481f, 0.02896093f, 0.01882994f, 0.02128046f, 
    -0.00730244f, -0.01608746f, -0.03910579f, 0.00183473f, 0.01138445f, 0.03204561f, -0.03507808f, 0.01989423f, 
    -0.02056703f, -0.01333701f, 0.02419347f, 0.02733869f, 0.02018081f, 0.00874276f, 0.00764113f, -0.04145525f, 
    -0.02322069f, -0.01410854f, 0.02226010f, -0.00623946f, 0.02342391f, -0.00207336f, -0.04290881f, 0.01692383f, 
    0.02365719f, -0.00505662f, -0.00226783f, -0.01212076f, -0.01695693f, -0.00644184f, -0.01590380f, 0.02625148f, 
    -0.00431052f, -0.00925553f, 0.00846382f, -0.03592178f, -0.01174549f, -0.01748013f, 0.02133399f, -0.03308702f, 
    -0.00034047f, -0.01449452f, 0.01224816f, 0.00290834f, 0.01565138f, -0.00466853f, 0.02752610f, 0.00543966f, 
    -0.01811312f, 0.00463389f, -0.02878571f, -0.01489305f, -0.02857685f, 0.02282441f, 0.02073286f, -0.00764594f, 
    -0.02467144f, 0.00824650f, 0.01282120f, -0.01389866f, 0.02628977f, -0.03815135f, -0.02698869f, -0.03451650f, 
    -0.03123662f, 0.01591151f, 0.01941213f, 0.02986911f, -0.01412957f, 0.00413991f, -0.01139484f, -0.00774240f, 
    -0.01105585f, -0.01589157f, -0.04136355f, 0.02078681f, 0.01669327f, 0.00791771f, -0.01229906f, -0.01678832f, 
    0.02341608f, -0.03243038f, -0.01421439f, -0.01041308f, 0.03762305f, 0.01690953f, -0.03509844f, -0.01833388f, 
    -0.02176181f, 0.02004083f, -0.03405123f, 0.02418937f, 0.01848072f, 0.01780541f, 0.01685376f, 0.00306349f, 
    0.00162107f, -0.03800736f, -0.02925496f, -0.00564517f, -0.00302124f, -0.00424470f, 0.01332014f, 0.01447944f, 
    -0.01592899f, 0.02116529f, 0.02477210f, 0.02518543f, 0.02185774f, -0.00973763f, -0.03248120f, -0.00817143f, 
    -0.02267458f, -0.02070834f, -0.02754345f, 0.01740392f, 0.03760704f, 0.02715440f, -0.00259355f, 0.01378552f, 
    0.00270317f, 0.02008547f, -0.00905351f, -0.00716696f, -0.03378788f, -0.03336239f, 0.01147191f, -0.00345279f, 
    -0.03742815f, 0.00378501f, -0.01846193f, 0.01821412f, -0.01150216f, 0.00704084f, 0.00282499f, -0.04013393f, 
    0.03017798f, -0.00319535f, -0.02315000f, 0.00469154f, 0.01878402f, -0.01069341f, 0.02586021f, -0.02238079f, 
    -0.00464136f, -0.03807721f, -0.02004969f, -0.02734263f, -0.02316586f, -0.02145143f, -0.01950075f, 0.00834780f, 
    -0.01435288f, 0.03639813f, -0.00120042f, -0.01640501f, -0.01960937f, -0.00526766f, -0.00228897f, -0.02608944f, 
    0.00095620f, 0.03445782f, 0.02117037f, 0.03396615f, -0.00781611f, -0.03114100f, -0.00630758f, -0.00029522f, 
    0.02567366f, -0.03087060f, -0.02482159f, -0.02583347f, 0.02401246f, -0.01524537f, -0.02810618f, 0.01481263f, 
    0.00343033f, -0.00745909f, -0.01505220f, 0.00142425f, 0.00112779f, 0.01920185f, -0.03029181f, -0.02979314f, 
    0.00040673f, -0.03463890f, -0.04223829f, -0.03771696f, -0.03302602f, 0.02366822f, -0.03716886f, -0.01774503f, 
    -0.01971215f, -0.01390878f, -0.01274490f, -0.03235888f, -0.02141173f, 0.02715848f, -0.01264503f, 0.01432372f, 
    -0.02892805f, 0.00822025f, -0.02599132f, -0.00443985f, 0.00762621f, -0.00175613f, -0.02854632f, 0.00379003f, 
    -0.01755934f, 0.01812639f, -0.00352214f, 0.02457910f, -0.00191423f, 0.03571359f, -0.00796961f, 0.00168713f, 
    0.02743204f, 0.00601230f, 0.01364028f, -0.04204540f, -0.03317539f, 0.03570653f, -0.00765994f, -0.03674859f, 
    -0.03806496f, 0.00544322f, -0.01980402f, 0.01719452f, -0.01373884f, -0.02944529f, -0.01162055f, 0.00773365f, 
    -0.03480406f, -0.00398690f, -0.02223436f, -0.01916822f, 0.02101207f, 0.01276502f, -0.02358940f, -0.02086689f, 
    -0.03682479f, 0.02759773f, 0.02366093f, -0.01859459f, -0.00371859f, -0.03687374f, -0.01607633f, -0.00476465f, 
    0.01734840f, -0.01237270f, -0.02541531f, -0.02700620f, -0.03711026f, 0.02604995f, -0.03107575f, -0.00283200f, 
    -0.00990009f, -0.03352499f, 0.01554597f, -0.03379647f, -0.01349739f, -0.00516418f, -0.03481637f, 0.00725272f, 
    -0.03450372f, -0.00173928f, -0.02976364f, 0.02908194f, -0.00897037f, -0.00355722f, -0.00643844f, 0.01858678f, 
    0.01969563f, 0.01974251f, -0.01495179f, -0.03356583f, -0.00435449f, -0.00794633f, -0.04040854f, 0.00019700f, 
    -0.01180332f, -0.03626058f, 0.01294663f, -0.02604000f, 0.01621580f, 0.00597469f, 0.00546225f, -0.03100104f, 
    -0.01832327f, -0.00255658f, 0.01358857f, -0.02713383f, -0.03811594f, -0.03194216f, 0.00313983f, -0.02350501f, 
    0.00733302f, -0.01955979f, 0.02434693f, -0.01425984f, -0.01857398f, -0.00739971f, 0.01533389f, 0.00060456f, 
    -0.00199245f, 0.01801352f, 0.01612991f, -0.03400415f, -0.02914053f, 0.03218750f, 0.03094190f, 0.01176976f, 
    0.02808399f, 0.01475540f, 0.00185479f, 0.01535505f, 0.02758116f, -0.01566650f, 0.02536620f, 0.02313605f, 
    -0.02070225f, 0.02793765f, -0.02838016f, -0.04088095f, 0.02566166f, -0.03857699f, -0.03338410f, -0.03855821f, 
    -0.02782727f, 0.00755046f, 0.02412236f, -0.00624215f, 0.02848507f, -0.00030825f, -0.01594546f, -0.03067794f, 
    -0.00117501f, 0.01692927f, -0.01279333f, 0.02843892f, -0.02786676f, -0.03926130f, 0.01372496f, -0.02563647f, 
    0.02326731f, -0.00762582f, 0.01536996f, 0.02432870f, 0.00343766f, 0.02319783f, -0.04066259f, 0.01653635f, 
    0.00837221f, -0.03391403f, 0.01987494f, -0.00275350f, -0.02796216f, 0.00043860f, 0.01650994f, 0.00396626f, 
    0.01533998f, -0.03758294f, -0.01060268f, 0.02776732f, 0.00318981f, -0.00615952f, -0.01992998f, -0.01502765f, 
    0.02155323f, 0.02584053f, 0.00565146f, -0.02875548f, -0.03385457f, -0.02779507f, 0.01099975f, 0.01102068f, 
    0.03078120f, -0.00229866f, -0.02517432f, -0.02030359f, 0.01526919f, -0.03237173f, -0.01330670f, -0.02618850f, 
    -0.00646469f, -0.01039791f, -0.00071154f, -0.02944589f, -0.01681223f, -0.02737421f, -0.01294341f, -0.00173217f, 
    -0.00592807f, 0.02360583f, -0.02435330f, 0.02184556f, -0.02227832f, -0.00064969f, 0.03153789f, 0.01026128f, 
    0.00031115f, 0.00710313f, 0.00085113f, 0.01155093f, -0.01300449f, -0.04235712f, 0.01185314f, 0.03507134f, 
    -0.03997340f, -0.02248083f, -0.01771051f, 0.00872920f, 0.00744043f, -0.04281067f, 0.02404671f, -0.00053437f, 
    0.01407909f, -0.01857599f, -0.00756721f, 0.01881843f, -0.00372458f, 0.00271382f, -0.02041847f, -0.00146831f, 
    -0.02527663f, 0.00336097f, -0.03287131f, 0.01611501f, -0.00651759f, -0.01063680f, -0.00620541f, -0.01234031f, 
    -0.04038889f, 0.03044925f, -0.02666420f, -0.01077625f, -0.04015632f, 0.02457247f, -0.03518181f, -0.00445616f, 
    0.03236493f, 0.01854220f, -0.01815373f, 0.01595546f, -0.02625282f, 0.02843376f, 0.02319189f, -0.01562302f, 
    0.02680552f, 0.01926258f, 0.02231774f, 0.02587559f, -0.01696738f, -0.01360676f, -0.03066340f, -0.01166989f, 
    -0.00586895f, -0.01581982f, 0.02339151f, -0.03168629f, -0.02403391f, -0.01293620f, -0.01953943f, 0.01836082f, 
    -0.03674058f, 0.00568313f, -0.03582298f, -0.02370816f, -0.02196037f, 0.00315300f, -0.02608183f, 0.01177828f, 
    -0.03321045f, 0.01861511f, -0.03454693f, 0.03203784f, 0.00139343f, 0.02502818f, 0.02032394f, -0.01830002f, 
    0.02237352f, -0.02855150f, -0.00509273f, -0.01225859f, -0.02061519f, -0.03190315f, -0.03108201f, -0.00883114f, 
    -0.01931724f, -0.02995116f, -0.02816697f, -0.01570258f, 0.01317830f, -0.00625302f, 0.00058618f, -0.02987402f, 
    -0.00063558f, 0.00833484f, -0.03444258f, -0.00866666f, 0.00841521f, 0.01050729f, -0.02444305f, -0.00347881f, 
    -0.03818182f, -0.00616868f, -0.02141037f, -0.03119882f, -0.01623778f, -0.02991576f, 0.02851615f, 0.02785874f, 
    0.01699787f, -0.03712422f, -0.02811747f, 0.02786120f, -0.01715173f, -0.00022905f, 0.00515704f, -0.02958233f, 
    -0.03119597f, -0.01938033f, 0.03201649f, -0.00939153f, 0.02372627f, 0.02630988f, -0.00133669f, -0.00895609f, 
    0.00973089f, 0.00698298f, 0.01252997f, 0.02028853f, -0.01268312f, 0.00950803f, 0.03649834f, -0.01036738f, 
    0.01879376f, -0.02578810f, -0.01897240f, 0.01425499f, 0.00681995f, -0.02393389f, 0.03133979f, -0.03210592f, 
    -0.02700077f, -0.03198998f, 0.02273410f, -0.02294132f, 0.01920349f, -0.02773581f, -0.03982108f, 0.02072280f, 
    -0.02529159f, -0.02615347f, -0.02819961f, -0.03514997f, 0.02010214f, -0.00138289f, -0.02307437f, 0.00047569f, 
    0.03296380f, 0.00141666f, 0.02125883f, -0.02588527f, -0.03159828f, 0.00007725f, -0.00573374f, 0.00651041f, 
    -0.03413843f, -0.03753034f, -0.01423756f, 0.01791487f, 0.02296841f, -0.01699009f, -0.01668042f, 0.00500703f, 
    0.00103374f, 0.00093917f, 0.00145298f, -0.00469713f, 0.00893724f, -0.03152367f, -0.00828673f, -0.02152240f, 
    -0.02979856f, -0.01415503f, -0.04269523f, -0.03634512f, 0.00490234f, -0.00668172f, 0.02266001f, -0.01029104f, 
    0.01606950f, -0.01432252f, 0.01208906f, 0.02249652f, -0.04447339f, -0.03951480f, 0.02907930f, 0.00055482f, 
    0.02322553f, -0.03366020f, 0.01330818f, -0.02977783f, 0.02400280f, -0.03125642f, -0.03128889f, 0.02918942f, 
    0.01992179f, -0.01331317f, -0.02853494f, -0.02761646f, -0.01740839f, -0.00596413f, -0.03289214f, 0.00561590f, 
    -0.03687621f, 0.00726691f, -0.00118387f, 0.01384354f, 0.00858955f, -0.04225099f, -0.00810410f, -0.03214893f, 
    -0.00967770f, 0.01133621f, -0.00043254f, 0.02197307f, -0.00839886f, -0.00113095f, 0.02730304f, -0.02162318f, 
    0.00925452f, 0.00574092f, -0.01684226f, -0.00299520f, -0.02768108f, -0.02223681f, 0.01383766f, 0.01353153f, 
    -0.03736173f, 0.03071676f, -0.02267898f, -0.01502903f, -0.00655508f, 0.00057527f, -0.03432641f, -0.03952870f, 
    -0.02319483f, -0.00291747f, -0.02823374f, 0.01712820f, -0.03939866f, 0.01589894f, 0.00051012f, 0.02206025f, 
    0.01428637f, -0.03486707f, 0.00424885f, -0.01329254f, -0.02837865f, -0.00231842f, -0.01503896f, 0.02855458f, 
    -0.00702147f, -0.03962891f, 0.01702973f, -0.00849438f, 0.01873137f, -0.03095614f, 0.02758407f, -0.00834694f, 
    0.02031754f, -0.03383824f, -0.02869175f, -0.03694373f, 0.01265348f, 0.02616148f, 0.02130648f, -0.01189014f, 
    0.01994037f, -0.02836205f, -0.00415726f, -0.01280990f, 0.00436263f, 0.00870924f, 0.01820067f, 0.01731333f, 
    0.02300063f, -0.02779558f, 0.02462918f, 0.01445158f, -0.03196386f, -0.02749223f, 0.02171590f, 0.02658714f, 
    0.03147093f, 0.00343571f, -0.00834563f, -0.03240774f, 0.00280433f, 0.00899214f, -0.01562128f, -0.03052178f, 
    -0.01402063f, -0.02054730f, -0.03487962f, 0.00925181f, -0.01342029f, 0.00064512f, 0.02080110f, -0.01515842f, 
    -0.03907102f, 0.01421928f, 0.00321550f, 0.00799725f, -0.02412109f, -0.00200989f, -0.02427878f, 0.00072207f, 
    -0.03089227f, -0.01809981f, -0.01412299f, -0.02855309f, -0.03758474f, -0.00595172f, 0.00628337f, 0.00800111f, 
    0.03539072f, 0.02095727f, -0.03822651f, -0.02694907f, -0.02555370f, 0.00368286f, 0.00318370f, 0.02054796f, 
    0.00329655f, -0.01360496f, -0.03004876f, 0.02065448f, 0.02217740f, 0.00135431f, -0.00262456f, 0.01323836f, 
    0.02184894f, 0.01603730f, -0.00068930f, 0.01247849f, -0.04147637f, 0.00851549f, -0.01754346f, 0.00266597f, 
    -0.02563523f, -0.01050260f, 0.00704000f, -0.00382784f, -0.01422082f, -0.00119747f, -0.02489194f, -0.00938319f, 
    -0.01964308f, 0.02534319f, -0.01433232f, -0.00949434f, 0.00142565f, -0.00490707f, -0.00022422f, -0.01202973f, 
    0.01702722f, -0.01473467f, 0.02918542f, 0.02109374f, -0.02589716f, -0.01634867f, 0.01672635f, 0.00187432f, 
    0.00711936f, 0.01919984f, 0.01820292f, -0.02482422f, -0.01693608f, 0.02164236f, -0.00960493f, -0.03037952f, 
    0.01735139f, -0.00741090f, 0.01809873f, 0.01157129f, -0.01098007f, -0.01016115f, 0.00127263f, 0.01850833f, 
    0.01443558f, -0.02816348f, 0.02487236f, -0.03822837f, 0.02080482f, -0.00213334f, -0.03001468f, -0.01672398f, 
    -0.03218531f, -0.03258041f, -0.03308765f, -0.00986922f, 0.02920813f, -0.00404082f, 0.01474782f, 0.01487057f, 
    0.01530828f, -0.01763690f, 0.02098059f, 0.00589262f, -0.01291412f, -0.02557420f, -0.03081832f, -0.00149283f, 
    -0.01010359f, 0.00108198f, -0.03428071f, 0.02749314f, -0.02724183f, 0.02437271f, -0.00630408f, 0.01827634f, 
    0.02525816f, 0.01814617f, -0.00745027f, -0.00070413f, -0.01179867f, -0.02415388f, 0.03319278f, 0.02609084f, 
    -0.02173424f, 0.00773955f, -0.02770253f, 0.01617280f, 0.02617988f, -0.01650782f, -0.00188703f, -0.02457192f, 
    0.00576745f, -0.03219908f, 0.02597580f, 0.00732091f, 0.02246103f, 0.01036845f, 0.00088576f, 0.01239695f, 
    -0.03593064f, -0.03024536f, -0.02351596f, -0.00980151f, -0.01564019f, -0.02107775f, 0.00475921f, -0.00492192f, 
    -0.03029129f, 0.01177772f, 0.00403501f, -0.02432959f, 0.00805052f, 0.00054874f, 0.01141841f, -0.00401632f, 
    0.02486270f, -0.00791640f, 0.02275071f, -0.02964203f, 0.03130793f, 0.00894130f, -0.03162954f, -0.00080075f, 
    0.02156622f, 0.00227390f, 0.00614568f, 0.02768376f, 0.02846031f, 0.02695806f, -0.00609939f, -0.01819715f, 
    0.02469118f, -0.00491443f, 0.00586119f, 0.01131568f, -0.02834054f, -0.03415011f, 0.00127508f, -0.01840405f, 
    -0.02326115f, -0.02261350f, 0.01547283f, 0.01531429f, -0.00727824f, -0.00761701f, -0.02449059f, -0.01517987f, 
    -0.02521277f, -0.00729818f, -0.00260854f, -0.02317710f, 0.01436554f, -0.01546674f, 0.02914730f, 0.00043789f, 
    -0.00944332f, -0.01051941f, -0.03888454f, 0.00992291f, -0.03824032f, 0.01764536f, -0.00126935f, -0.01387512f, 
    0.01072968f, 0.02795170f, 0.02033667f, 0.02659170f, -0.02403472f, 0.02545279f, 0.00914715f, 0.01743053f, 
    -0.00638356f, 0.00527277f, -0.01400585f, -0.02091024f, -0.02338211f, -0.00911482f, -0.02724537f, 0.01963738f, 
    0.01483872f, -0.03554062f, 0.01603611f, 0.01616225f, 0.01371013f, 0.02588319f, -0.02946356f, 0.01385067f, 
    -0.01745624f, -0.03864384f, -0.03482095f, 0.00286806f, 0.02001938f, 0.00736503f, 0.02204690f, 0.02590535f, 
    0.02278029f, -0.01231494f, -0.03976116f, -0.00311404f, 0.01078733f, -0.02659787f, -0.02413097f, -0.02333342f, 
    -0.01068013f, 0.01120918f, 0.02107067f, 0.00558674f, 0.01366887f, -0.01042917f, -0.00999117f, -0.01047605f, 
    -0.02022677f, 0.00233161f, -0.01760450f, -0.03244554f, -0.01748335f, 0.01385075f, -0.01550499f, -0.00799476f, 
    -0.01732566f, 0.01732603f, -0.00442552f, -0.02320775f, -0.03427631f, -0.02490938f, -0.00282171f, -0.02731334f, 
    -0.00669599f, -0.01760210f, -0.02228068f, 0.02413670f, 0.02485039f, 0.01577421f, 0.02906813f, -0.03757986f, 
    0.01106790f, -0.01742898f, -0.01245276f, 0.00314720f, -0.01031869f, 0.01736423f, -0.02230382f, 0.02226927f, 
    -0.02871782f, -0.03134684f, -0.02585898f, -0.00044486f, -0.02888856f, 0.00467041f, 0.02988731f, -0.04035462f, 
    -0.02260481f, 0.02783014f, -0.00183352f, -0.03714304f, 0.02696686f, 0.01629096f, 0.02403204f, 0.01674129f, 
    -0.01648069f, -0.03489339f, 0.02666621f, -0.00414572f, -0.00339529f, 0.01731949f, -0.02367170f, -0.00231654f, 
    0.00781646f, -0.01052960f, -0.00629128f, 0.01429179f, 0.00730395f, -0.03008041f, 0.02387640f, 0.04114250f, 
    -0.02149880f, 0.02902632f, -0.02514296f, -0.01599699f, 0.02529915f, -0.04056123f, 0.02810465f, 0.02661066f, 
    0.01236057f, 0.00193695f, -0.02569641f, 0.01474807f, -0.00625044f, 0.01073446f, 0.02631661f, -0.01318327f, 
    0.02622370f, -0.02256034f, -0.00061828f, 0.01479715f, -0.02484883f, 0.02515916f, -0.02627080f, 0.01555938f, 
    -0.04006028f, -0.03331640f, 0.00356791f, 0.02754355f, -0.00380969f, -0.03184313f, 0.01308860f, -0.01053376f, 
    -0.03539168f, 0.02944392f, -0.00045103f, -0.02217349f, -0.00794458f, -0.03591583f, 0.00537014f, -0.01627852f, 
    0.01331723f, 0.01282626f, -0.01758582f, -0.00640038f, 0.02723321f, -0.02003372f, -0.03941813f, -0.00842630f, 
    -0.03639668f, -0.02774968f, 0.00837073f, 0.00840071f, 0.01818182f, -0.02014052f, -0.01126929f, 0.01693598f, 
    0.00073110f, -0.03148017f, -0.03520989f, -0.00879013f, -0.03410382f, 0.00349875f, 0.02351020f, -0.01573929f, 
    0.00604958f, -0.03542092f, -0.03063343f, 0.02445059f, -0.01153680f, -0.02581692f, -0.02423402f, 0.02601724f, 
    0.00650060f, -0.03439540f, -0.01445737f, 0.02736047f, 0.02218560f, 0.02689140f, -0.03185839f, -0.02795972f, 
    -0.03816308f, -0.02259560f, -0.00417671f, -0.03632696f, -0.03923151f, 0.02322921f, -0.01730059f, 0.01065259f, 
    -0.01747609f, -0.03238042f, -0.03969949f, 0.02348576f, -0.02183225f, -0.01960181f, -0.03516352f, -0.00074120f, 
    0.02228766f, -0.00153737f, -0.03072328f, -0.00521621f, 0.00213742f, -0.02910746f, -0.01943671f, -0.01662777f, 
    -0.02807226f, -0.00671849f, -0.03219242f, -0.04148572f, -0.02673701f, 0.01559316f, -0.00600273f, 0.01317322f, 
    -0.01969858f, 0.01444456f, -0.03930943f, 0.00547585f, 0.02146536f, -0.02461674f, -0.02919879f, 0.02254227f, 
    0.01810397f, -0.02479012f, 0.02220319f, -0.01372533f, -0.01779035f, -0.02517403f, -0.02979806f, -0.03012636f, 
    0.02499134f, -0.00779233f, 0.02471513f, 0.00299959f, 0.00395196f, -0.00390650f, -0.00180721f, -0.00958401f, 
    -0.01666096f, 0.02605643f, 0.01797433f, -0.00752725f, -0.04064042f, -0.02470340f, 0.00214964f, 0.00790650f, 
    0.00937573f, 0.00132439f, -0.00261437f, 0.00999726f, -0.02589131f, -0.01040931f, -0.03814944f, 0.01862486f, 
    0.01773887f, -0.00121181f, -0.01654592f, -0.00665008f, -0.02886230f, -0.02701652f, -0.02155675f, -0.00041325f, 
    -0.03055389f, 0.02768595f, 0.00076949f, 0.01592220f, -0.02955978f, -0.02121115f, 0.01211120f, -0.02158111f, 
    -0.00367196f, 0.02335189f, 0.00879544f, -0.00187479f, -0.04151857f, 0.03996872f, -0.02053685f, -0.03977799f, 
    -0.02798180f, 0.01029637f, -0.03749239f, 0.02927843f, -0.02384027f, 0.00162959f, 0.02958791f, -0.03371936f, 
    0.00558794f, 0.01242224f, 0.00377446f, -0.03597855f, -0.01662721f, -0.01752402f, -0.03936740f, -0.01593156f, 
    -0.03418754f, -0.02782678f, -0.00623024f, 0.01879208f, 0.00614925f, -0.00778646f, -0.00095218f, -0.04194068f, 
    -0.01753378f, 0.00733406f, 0.01317049f, 0.02779362f, -0.03331859f, 0.00705715f, 0.01456427f, -0.01431789f, 
    -0.02562738f, -0.01371796f, -0.00299142f, -0.02787349f, -0.03787723f, 0.00973988f, 0.00378872f, -0.01252734f, 
    -0.03355011f, 0.01618716f, 0.02700040f, -0.01191474f, -0.02388060f, -0.00426276f, 0.02090457f, 0.02134851f, 
    0.01469254f, -0.03266530f, 0.01120800f, -0.02360664f, 0.00368413f, 0.00618689f, -0.00366487f, -0.02403343f, 
    0.02287140f, -0.01806693f, 0.00653089f, 0.00981537f, 0.01405093f, -0.03627522f, -0.00108194f, 0.02847696f, 
    0.01086124f, 0.00544021f, -0.01449380f, 0.00869102f, 0.01701892f, 0.01512574f, -0.03878343f, 0.00653064f, 
    0.00981692f, -0.01758491f, 0.00576324f, 0.01113223f, -0.03210257f, 0.00362983f, 0.00484372f, 0.00352128f, 
    -0.01243803f, 0.02043486f, 0.00841023f, 0.02711755f, 0.02988068f, -0.00757474f, -0.02147976f, -0.00955584f, 
    0.02721750f, 0.02945672f, -0.03178154f, -0.01087559f, 0.01703982f, 0.02551993f, 0.00046701f, 0.00410926f, 
    -0.00035526f, -0.01094410f, -0.00863211f, -0.04085778f, -0.03996491f, -0.01061584f, 0.01228816f, -0.03829530f, 
    -0.03616248f, -0.00353463f, 0.00452231f, -0.03406280f, -0.00381364f, 0.00653482f, -0.00414970f, -0.03375128f, 
    0.01252464f, 0.00637011f, -0.00816303f, 0.00535822f, -0.02937639f, -0.01957961f, 0.00995260f, -0.00614893f, 
    -0.00454701f, -0.01636817f, -0.02069294f, -0.00239493f, -0.03202756f, -0.01981364f, 0.02681991f, -0.01227736f, 
    -0.01647238f, 0.02287558f, -0.02140527f, 0.00384432f, -0.03988623f, -0.02849453f, 0.00385833f, 0.02604830f, 
    -0.02750959f, -0.01386732f, -0.02637610f, 0.02625615f, -0.00371759f, 0.02751985f, 0.00417516f, -0.00921908f, 
    -0.04163128f, -0.00277574f, -0.03572698f, -0.02876564f, -0.00742162f, -0.01760265f, -0.03198912f, 0.02955004f, 
    0.01315993f, -0.00693420f, 0.02179853f, -0.01168130f, -0.02148626f, -0.02925524f, 0.00124482f, -0.00895173f, 
    0.01771660f, 0.02941024f, -0.03549531f, -0.04122280f, -0.02096897f, 0.00841796f, 0.03381474f, 0.00246216f, 
    -0.00332001f, 0.01767995f, -0.00480040f, 0.00153116f, -0.01943580f, -0.01057449f, -0.04028122f, -0.02990305f, 
    -0.03523996f, 0.02642840f, 0.01039580f, 0.01400703f, -0.03378163f, 0.01799232f, 0.01983108f, 0.02599488f, 
    -0.01221890f, -0.00942615f, -0.00915939f, -0.02242446f, 0.02629993f, -0.01160613f, 0.00078877f, 0.00755120f, 
    0.00617137f, 0.02599818f, -0.00906822f, -0.02569564f, -0.01784996f, -0.03794551f, -0.04177962f, 0.02474704f, 
    0.01964629f, -0.01095230f, -0.03954394f, 0.01455339f, 0.00348729f, -0.03035211f, -0.01217994f, -0.01419799f, 
    -0.02964107f, -0.01603643f, -0.03546418f, -0.01585739f, 0.02646647f, -0.02166282f, -0.04162972f, -0.00492519f, 
    -0.03951413f, 0.02572414f, 0.00515064f, 0.00262369f, -0.03250113f, -0.03878097f, -0.00401211f, 0.00494886f, 
    -0.02134490f, 0.01051701f, -0.01015433f, -0.01767745f, 0.00848028f, -0.03327270f, 0.00102640f, 0.01107157f, 
    0.00396446f, 0.02882481f, -0.03801832f, -0.01290474f, 0.02958710f, 0.01991747f, -0.03307289f, -0.02976115f, 
    -0.03220275f, -0.01265450f, -0.02042239f, -0.00130982f, -0.02766816f, -0.01517854f, -0.00353267f, -0.00025230f, 
    -0.02162719f, 0.00921488f, -0.00372963f, 0.01797759f, 0.01644965f, -0.03784148f, 0.00145725f, 0.02733650f, 
    0.00039359f, -0.03591185f, 0.00950308f, 0.00539128f, 0.01604019f, -0.03217510f, 0.02842955f, 0.02194417f, 
    0.02501032f, 0.02703836f, 0.00077727f, -0.03883072f, 0.02441134f, -0.03663348f, -0.03466355f, -0.00543325f, 
    -0.00728005f, 0.01445001f, 0.01246625f, 0.00264319f, -0.00584878f, 0.02729107f, 0.02299226f, 0.02039464f, 
    -0.02819184f, -0.03202020f, -0.01579879f, 0.00016914f, 0.01712345f, -0.03922635f, 0.01382379f, -0.02024056f, 
    -0.01558161f, -0.00031036f, -0.00418715f, -0.02527827f, -0.00390008f, 0.00816583f, 0.02369058f, 0.02693346f, 
    -0.03319531f, -0.01781300f, -0.00401772f, -0.02327713f, -0.00974788f, -0.02821209f, -0.02356153f, 0.00116217f, 
    0.00357092f, 0.01641166f, 0.00089079f, -0.02992504f, -0.01951029f, -0.02327112f, 0.01563600f, -0.03769682f, 
    0.00191957f, -0.00217752f, 0.01507046f, 0.02754624f, 0.01332338f, -0.02532860f, 0.02115698f, 0.00386222f, 
    -0.00094852f, 0.03120676f, -0.03510160f, 0.02343901f, -0.01286386f, -0.03040017f, 0.02085796f, 0.00752458f, 
    -0.03654794f, 0.01172585f, 0.02902604f, 0.01361098f, -0.02104423f, -0.02133292f, 0.02070355f, -0.02279101f, 
    -0.02548856f, -0.01567784f, -0.00507405f, -0.00772903f, -0.02450537f, -0.01795844f, -0.01499848f, 0.00334137f, 
    -0.04141963f, -0.00349290f, 0.00676567f, 0.02451201f, -0.03506298f, 0.01287264f, -0.03651760f, 0.00188565f, 
    0.02240185f, 0.02386093f, -0.02438276f, 0.00062125f, -0.03793924f, 0.00296962f, -0.02801116f, 0.02944543f, 
    -0.01782545f, -0.01671574f, -0.04113641f, 0.00537615f, -0.03581324f, 0.02310578f, -0.02595377f, -0.02477502f, 
    -0.04055420f, 0.00591657f, 0.02864090f, 0.02243214f, 0.01347545f, 0.02694607f, -0.02209949f, -0.01522442f, 
    -0.02650817f, -0.00472024f, 0.00678065f, 0.00342349f, 0.01664586f, -0.00222093f, -0.00669777f, -0.04011230f, 
    -0.04075301f, -0.03933922f, 0.00596459f, 0.01559291f, 0.01126137f, -0.03846262f, -0.00737947f, -0.02391810f, 
    -0.00455772f, -0.02670421f, -0.02065669f, 0.00792078f, -0.01314694f, 0.02514582f, 0.00864716f, -0.04194103f, 
    -0.01186762f, -0.03320966f, -0.02098092f, -0.03372674f, 0.02086766f, -0.01708744f, 0.02706946f, -0.02355459f, 
    -0.01454016f, 0.00103695f, 0.02950118f, 0.01904362f, 0.00317992f, -0.03000412f, -0.01071633f, -0.02194490f, 
    -0.03983214f, -0.00573484f, 0.00839497f, -0.03954061f, -0.03624950f, 0.02143755f, -0.00171918f, 0.02268985f, 
    -0.02955534f, 0.01243703f, 0.02597355f, -0.03611225f, -0.03839011f, 0.00955542f, -0.02724878f, -0.00701623f, 
    0.02527251f, -0.03450475f, -0.02350415f, -0.02063676f, -0.01164539f, 0.01457578f, 0.00392967f, -0.03758338f, 
    0.35805875f, 0.01487372f, -0.11236256f, 0.06224070f, -0.02966015f, -0.01743627f, -0.15464796f, 0.16122292f, 
    0.00574006f, -0.04754746f, 0.09492745f, 0.06486021f, 0.03521883f, 0.04570403f, -0.09632032f, -0.01589685f, 
    0.00805899f, -0.01257933f, 0.07705165f, 0.01131842f, -0.02620341f, 0.05007946f, 0.07323431f, 0.13940734f, 
    -0.15262669f, -0.15795062f, -0.02805492f, -0.06698863f, -0.00100567f, 0.03609764f, -0.03029905f, -0.00445188f, 
    -0.00024360f, 0.00818680f, -0.06878389f, -0.07641065f, 0.10868905f, 0.20081371f, -0.04115111f, 0.16573425f, 
    -0.01124041f, 0.06824775f, -0.02569875f, -0.04039875f, 0.01593436f, 0.05653620f, 0.03428741f, 0.20442306f, 
    0.00386403f, -0.02271128f, -0.06852954f, 0.09278497f, 0.08812529f, -0.01258832f, 0.00654278f, -0.00730951f, 
    0.17542486f, 0.09060640f, -0.10388180f, -0.00741298f, 0.03435925f, 0.05313766f, 0.21153569f, 0.06884984f, 
    0.02739969f, 0.03014164f, -0.00626310f, 0.07897203f, -0.05788245f, -0.00811930f, -0.05899301f, 0.04465248f, 
    0.04746253f, 0.21690729f, 0.07762166f, 0.09600093f, -0.08868919f, 0.01733376f, -0.05606643f, 0.04326905f, 
    -0.08246717f, 0.12300071f, 0.10583260f, 0.05211175f, -0.12477589f, 0.04927608f, 0.00507943f, -0.01067141f, 
    0.02923965f, 0.20802207f, 0.10058450f, 0.10853743f, 0.07840037f, -0.00501613f, -0.02567497f, 0.05942516f, 
    0.22795980f, -0.06976467f, 0.00698377f, 0.13895486f, -0.00194427f, 0.00237534f, -0.01077425f, 0.01842103f, 
    -0.01016598f, -0.00592583f, -0.08677807f, -0.05793003f, -0.00961179f, 0.05013104f, 0.05144765f, -0.04078040f, 
    0.01381454f, 0.02693151f, -0.04102791f, -0.11410551f, 0.13893907f, 0.04387908f, 0.01416905f, 0.02760635f, 
    0.05906809f, 0.07216016f, -0.13394639f, 0.12224056f, -0.02857451f, -0.08747529f, 0.06431083f, 0.28946045f, 
    0.01000364f, 0.03241837f, 0.03735266f, 0.08571762f, 0.23590799f, -0.02352594f, 0.15928249f, -0.11337332f, 
    -0.04036837f, 0.01817572f, -0.04351414f, 0.00646778f, 0.04198789f, -0.02876448f, 0.10089738f, -0.06618471f, 
    0.24690354f, -0.01032300f, 0.04452172f, -0.02267044f, -0.00731379f, 0.02424973f, 0.01752678f, 0.03643024f, 
    -0.01174965f, -0.06586178f, 0.08939942f, 0.15545531f, 0.04015204f, 0.03040394f, 0.03585158f, 0.10364822f, 
    -0.05341217f, -0.12524521f, -0.09595183f, 0.01626498f, -0.01984072f, 0.01586848f, 0.23108938f, 0.03584758f, 
    -0.02128846f, 0.02500682f, -0.05435913f, 0.05863406f, 0.00777146f, 0.00830786f, 0.18246686f, 0.08133481f, 
    0.02468582f, 0.03291810f, 0.05949274f, 0.02297855f, -0.28653768f, -0.03203588f, -0.10110928f, 0.04115926f, 
    0.03321458f, 0.04686917f, -0.14765972f, 0.05735387f, 0.01384179f, -0.03294380f, -0.01163541f, -0.04354760f, 
    -0.09068582f, -0.11605744f, -0.13833377f, 0.05000205f, -0.00265808f, 0.03914607f, -0.05446631f, 0.00176173f, 
    -0.03025180f, 0.02847921f, 0.10966800f, 0.00746506f, -0.16850507f, 0.07311211f, -0.07356138f, 0.03796584f, 
    0.08373465f, 0.01808256f, -0.11655786f, -0.09326523f, -0.04264471f, -0.04781662f, -0.01829834f, 0.09663570f, 
    -0.10264377f, 0.02982777f, 0.04578221f, -0.01767613f, -0.03056755f, -0.02754069f, 0.01015580f, 0.04913766f, 
    0.04184576f, 0.26292849f, 0.09065038f, 0.01185941f, -0.13639119f, 0.03180378f, -0.02857358f, -0.09254485f, 
    0.07274257f, 0.11493824f, -0.04655802f, 0.01889743f, -0.00400338f, -0.02948300f, 0.03472370f, 0.01623143f, 
    0.01724688f, -0.06477621f, -0.06463493f, 0.07109202f, -0.04284522f, 0.04800404f, -0.10779764f, -0.11154255f, 
    0.09421204f, 0.08521132f, 0.13021389f, 0.00824747f, 0.06885798f, 0.11176668f, -0.10706452f, -0.00944750f, 
    -0.04350710f, 0.14106046f, -0.03081916f, 0.01367828f, 0.04300146f, -0.07511643f, -0.01148570f, 0.15034494f, 
    0.18164964f, -0.08488712f, -0.03204362f, -0.10204212f, -0.11399037f, 0.18489039f, -0.02661705f, 0.00033127f, 
    -0.08386517f, 0.01416134f, -0.07266036f, 0.02387585f, 0.03405561f, -0.06777926f, -0.12344246f, -0.11880790f, 
    0.00433335f, -0.05699848f, 0.01587167f, -0.04142363f, -0.11526937f, 0.02386162f, 0.09073716f, -0.06295381f, 
    -0.03311780f, 0.04158175f, -0.05805901f, 0.07462355f, 0.00826902f, 0.13180439f, -0.04018322f, 0.03199184f, 
    0.02749399f, -0.08093543f, -0.01929678f, -0.10007572f, 0.12115417f, 0.18638334f, 0.01346111f, 0.01237390f, 
    -0.13256288f, -0.03232656f, 0.10828560f, 0.00572045f, -0.01117601f, 0.11921421f, -0.02535702f, -0.02637574f, 
    -0.10826950f, -0.05558497f, -0.15550502f, -0.08448901f, 0.02286826f, -0.12222666f, -0.03139219f, -0.05069957f, 
    0.04589369f, -0.07374365f, -0.00833065f, -0.00830404f, 0.22494645f, 0.14216004f, -0.02884134f, 0.06444257f, 
    0.04314671f, -0.01864519f, -0.05051608f, 0.06398598f, 0.02548558f, 0.07153361f, 0.01539039f, 0.07592901f, 
    0.02727009f, 0.00307005f, 0.04238206f, 0.09689163f, -0.05519323f, 0.07745614f, 0.04091449f, 0.03284592f, 
    -0.03225046f, 0.08883429f, 0.01631225f, -0.10994609f, -0.05401138f, 0.07448521f, -0.04128714f, 0.17486325f, 
    0.00795467f, 0.08523811f, 0.11385567f, -0.00663168f, 0.02941282f, 0.03361065f, 0.08485946f, 0.00855457f, 
    0.11263930f, -0.04727893f, 0.06300696f, 0.05501126f, -0.00326331f, -0.17277861f, -0.04826409f, -0.03853808f, 
    0.08852609f, -0.03267524f, -0.05221967f, -0.08629016f, 0.08092670f, -0.01706218f, 0.22148706f, -0.09189004f, 
    0.06561631f, 0.03049360f, 0.03665089f, 0.07519322f, 0.08912452f, -0.03411360f, 0.14867394f, 0.06026910f, 
    0.14977929f, 0.14970663f, 0.04496528f, 0.02018324f, -0.01385014f, 0.00520013f, -0.06091104f, -0.04658512f, 
    0.09749017f, -0.10491861f, -0.14046481f, -0.14589795f, 0.08364798f, 0.06287415f, 0.04525184f, -0.07183626f, 
    0.03884718f, -0.01011933f, -0.07094876f, 0.06480089f, -0.00765760f, 0.05081443f, -0.07638052f, 0.03413951f, 
    0.05171051f, 0.10188334f, 0.13062166f, 0.09802733f, 0.01120073f, -0.00277766f, 0.03517494f, 0.05110006f, 
    -0.00405415f, 0.04978549f, -0.07881425f, 0.04840166f, 0.10318179f, 0.18126771f, 0.04404143f, 0.05092953f, 
    -0.02686924f, -0.06059910f, -0.03324649f, -0.02212217f, -0.03811803f, 0.08372343f, 0.01904740f, -0.02914476f, 
    -0.07238993f, 0.01761072f, 0.10303172f, 0.10601304f, -0.02032854f, 0.04332478f, 0.15254244f, 0.12276141f, 
    -0.02231942f, -0.03029782f, 0.16639842f, 0.09196299f, 0.13253602f, 0.10802271f, 0.07693225f, -0.02113816f, 
    0.02040020f, -0.02696549f, 0.03460252f, -0.02936314f, -0.02700553f, 0.01985655f, -0.01747135f, -0.04650955f, 
    -0.04497134f, 0.12697364f, -0.03283049f, 0.03997174f, -0.01249809f, -0.07367693f, 0.11148892f, 0.04366546f, 
    0.01074723f, 0.01580394f, 0.10685819f, -0.02822166f, 0.08712779f, 0.12793724f, 0.01094758f, 0.06308887f, 
    0.02574249f, 0.01181360f, 0.00250954f, 0.00026160f, 0.00005080f, -0.02104620f, -0.07464840f, 0.03229216f, 
    0.11574566f, -0.00042192f, -0.03728012f, -0.06003735f, -0.05469605f, 0.07873469f, 0.06936312f, -0.00472912f, 
    0.00139250f, -0.06894970f, -0.06094427f, 0.04952207f, 0.15001154f, 0.02483869f, -0.13328651f, -0.00681169f, 
    -0.08958448f, -0.01085449f, -0.02983871f, 0.01892214f, -0.06695509f, 0.03821143f, 0.00476444f, 0.04378649f, 
    0.15264674f, 0.15863433f, -0.02351982f, 0.05503865f, -0.03969130f, -0.00389612f, -0.03041996f, 0.03210270f, 
    -0.02368449f, -0.02640278f, 0.06552674f, -0.05652121f, 0.07539501f, -0.01655862f, 0.04175549f, 0.10268938f, 
    0.01417797f, -0.06684128f, -0.06981984f, 0.07989608f, 0.07632454f, -0.10964331f, 0.02160449f, 0.02049787f, 
    0.07708905f, 0.16246256f, -0.10329539f, 0.07032415f, 0.03723431f, 0.08526444f, -0.00166289f, -0.03185504f, 
    0.15777312f, -0.00774125f, -0.01291326f, -0.01295501f, -0.14130318f, -0.14156799f, -0.03426860f, -0.03141708f, 
    -0.06423716f, 0.05562223f, -0.01936220f, 0.05856725f, 0.09489869f, 0.04096712f, -0.01303736f, 0.05157508f, 
    -0.18314539f, -0.05353256f, 0.03183036f, 0.08220726f, 0.05159294f, 0.12829520f, -0.00176284f, 0.00321588f, 
    -0.04531490f, -0.08676271f, -0.00162789f, 0.06452058f, -0.02499338f, 0.11573560f, 0.11077387f, 0.07580536f, 
    -0.12798619f, 0.04440041f, 0.02981542f, 0.07869408f, -0.12743860f, 0.06399179f, 0.04776874f, -0.02292732f, 
    -0.24815404f, -0.13743809f, -0.15357219f, -0.04912385f, -0.00966656f, -0.13809067f, 0.01748488f, -0.01040457f, 
    0.03506178f, 0.07811292f, -0.11259912f, -0.02313344f, 0.32832900f, 0.18236023f, -0.00716887f, 0.05568003f, 
    0.03212766f, 0.07208459f, -0.01513836f, 0.09185029f, -0.02778251f, 0.03511514f, 0.09171776f, 0.00479400f, 
    0.21394865f, 0.19760577f, 0.11832949f, -0.00562750f, -0.03632957f, -0.03140105f, 0.08129475f, -0.10542384f, 
    0.00506062f, -0.05780770f, -0.07120622f, 0.03696164f, -0.05956084f, 0.01039917f, 0.01595718f, -0.05352200f, 
    -0.00877851f, 0.07102279f, -0.00344644f, 0.13870342f, -0.02733599f, 0.11764813f, 0.01799074f, 0.03408850f, 
    -0.13375467f, -0.10469841f, -0.05455900f, -0.04821907f, 0.03276554f, -0.08016457f, -0.10334874f, -0.03060646f, 
    0.10100046f, 0.04566485f, 0.07777958f, -0.10220501f, -0.19106176f, -0.08408042f, -0.07524158f, 0.04927991f, 
    0.06414599f, 0.02847313f, -0.11589628f, 0.04028539f, 0.07448936f, 0.07011827f, -0.05466684f, -0.03701844f, 
    -0.05521640f, -0.06281888f, -0.16363221f, -0.11565054f, -0.04732451f, -0.03113760f, -0.07546627f, 0.06340113f, 
    0.06308447f, 0.11471242f, 0.08993210f, 0.07964644f, -0.06256277f, 0.01875669f, 0.06413529f, -0.14214131f, 
    0.05764546f, -0.09509748f, 0.00864284f, -0.02250751f, -0.04247642f, 0.04046554f, -0.01221056f, -0.08795580f, 
    0.08298998f, -0.02347275f, 0.09843353f, -0.03831827f, 0.01589442f, 0.06298254f, 0.03247610f, -0.07036173f, 
    0.01866164f, 0.06340085f, -0.07919099f, 0.14666630f, -0.20918961f, 0.04767641f, -0.01621786f, -0.08537799f, 
    0.03854071f, -0.06852554f, -0.08062029f, -0.03130449f, 0.05907589f, -0.08964148f, -0.02700245f, -0.10126012f, 
    0.13474199f, 0.10275133f, 0.14174210f, 0.11369885f, -0.04541751f, 0.06597424f, -0.02997117f, -0.04906588f, 
    -0.06722381f, -0.01385976f, 0.10207859f, 0.15306962f, -0.14857462f, -0.01221415f, -0.07567362f, 0.12636709f, 
    0.06910022f, 0.01985516f, -0.15954301f, 0.00307605f, 0.05202447f, 0.05390084f, 0.04222525f, 0.04774395f, 
    0.14766191f, 0.06165240f, -0.03189544f, -0.01016180f, 0.00497910f, 0.03060499f, -0.03587740f, 0.13006842f, 
    0.01857196f, 0.10468446f, -0.13275412f, 0.01068199f, -0.17985739f, -0.18378100f, -0.07549179f, -0.13351598f, 
    0.03917830f, -0.12647051f, -0.01374384f, 0.02959837f, 0.09211240f, -0.03867837f, 0.09476691f, 0.04513222f, 
    0.11317354f, 0.12434148f, -0.17540279f, 0.09530780f, 0.03448667f, 0.02293838f, 0.04705560f, 0.02483092f, 
    0.04920449f, 0.17204715f, 0.04579299f, 0.03320320f, 0.19762141f, 0.05838333f, 0.10946584f, -0.07585485f, 
    0.10988147f, 0.05363025f, 0.07410055f, -0.01416576f, 0.08176407f, -0.04333485f, -0.06760748f, 0.11962029f, 
    0.18788730f, 0.10784826f, -0.20138355f, 0.00374133f, 0.09458060f, 0.07097253f, -0.10975818f, 0.04332951f, 
    0.01859317f, -0.07507146f, -0.03178138f, 0.07981359f, -0.06101422f, 0.02977338f, -0.12338056f, -0.13394603f, 
    0.04025660f, 0.07251267f, 0.05758767f, 0.04387660f, -0.08282876f, -0.02144682f, 0.07846572f, 0.01367596f, 
    -0.20624173f, -0.16650949f, -0.02587392f, -0.12063500f, 0.10342328f, 0.14550857f, -0.04105787f, -0.01831947f, 
    -0.09852618f, -0.07175354f, 0.04582117f, -0.10147157f, -0.11514760f, 0.05969320f, 0.04830112f, 0.18776013f, 
    0.10684124f, 0.08393071f, 0.10950767f, 0.08556446f, -0.01686811f, 0.08768589f, 0.03846550f, 0.08770345f, 
    0.16724472f, 0.02951260f, 0.01242094f, 0.10527734f, 0.07914045f, 0.04694175f, -0.02961580f, -0.00282819f, 
    0.06507616f, 0.01962830f, -0.06657702f, -0.06940076f, 0.19126406f, 0.02972150f, 0.14671879f, -0.01346645f, 
    -0.03155794f, 0.03210144f, -0.14245097f, 0.06018495f, -0.03245103f, 0.00484969f, -0.03133237f, 0.01903220f, 
    0.07995555f, 0.05270739f, 0.05440775f, 0.23503192f, -0.11076498f, 0.02741826f, 0.00006545f, -0.01385293f, 
    -0.01339864f, 0.06399796f, 0.02192554f, -0.04336487f, -0.18793495f, 0.01531818f, -0.00931066f, -0.16156921f, 
    0.10821981f, 0.04128113f, 0.10851498f, 0.03374249f, 0.01861290f, -0.07287887f, 0.01129640f, 0.01127631f, 
    0.07355131f, -0.13591079f, 0.11737597f, 0.00731282f, 0.00546909f, 0.01084013f, -0.04305148f, 0.09151509f, 
    -0.00024750f, 0.03217914f, -0.04026387f, -0.04936099f, 0.23730081f, 0.14877233f, 0.11508425f, -0.00762269f, 
    0.03579241f, 0.11248881f, -0.07465198f, -0.04514430f, 0.00323505f, -0.07400664f, 0.01306894f, -0.02673182f, 
    0.01695229f, 0.02261472f, -0.03829186f, 0.07358085f, -0.01717073f, 0.03522970f, 0.07934751f, 0.17760427f, 
    0.00399267f, -0.02460830f, 0.05608363f, 0.05224507f, 0.17208055f, 0.03611760f, -0.00990767f, -0.04249579f, 
    -0.12669308f, 0.09095457f, -0.07425458f, 0.03105058f, 0.04122370f, -0.00485874f, 0.14068544f, -0.03516373f, 
    0.28412125f, 0.07247819f, 0.11775551f, -0.08844277f, -0.04464394f, -0.05943004f, 0.01745796f, 0.08759470f, 
    0.00625162f, -0.12409215f, -0.04093282f, 0.06902803f, -0.10774706f, 0.00099411f, -0.03503525f, -0.03180361f, 
    0.03089459f, -0.09246790f, 0.03349328f, -0.00839511f, -0.03193367f, -0.03257154f, 0.08743478f, 0.10102618f, 
    0.03901277f, 0.16160981f, -0.07492974f, 0.10695825f, -0.07858965f, -0.07190812f, 0.12304853f, 0.13263138f, 
    0.02728566f, -0.04099466f, -0.02501369f, 0.02508446f, -0.16656855f, -0.03615682f, -0.04039555f, -0.13609606f, 
    0.05704452f, 0.05363647f, -0.03614489f, 0.02834466f, -0.00227173f, -0.05339041f, 0.03941117f, 0.05589239f, 
    -0.21406494f, -0.10300797f, -0.10329166f, -0.01505108f, 0.05976757f, -0.03273321f, 0.09473672f, -0.01189688f, 
    0.04575674f, -0.01799244f, 0.07561680f, -0.02722966f, -0.11060227f, 0.01719104f, -0.12500535f, -0.19922087f, 
    0.08133392f, 0.00309674f, -0.02176594f, -0.02291882f, 0.03603178f, 0.02172501f, 0.04648363f, 0.06686942f, 
    -0.11869103f, -0.02887558f, 0.12419761f, 0.04137881f, -0.08974617f, -0.04334204f, 0.00724219f, 0.10293349f, 
    0.04533923f, 0.13587271f, 0.07931578f, 0.07404314f, -0.12352631f, -0.02119686f, -0.06016578f, -0.22407906f, 
    0.09229044f, 0.03350836f, -0.00365478f, 0.03411993f, -0.01247888f, -0.02652464f, 0.04620692f, 0.03408094f, 
    0.02762947f, -0.07152931f, 0.10670950f, 0.23113392f, 0.02001729f, 0.02337184f, 0.05915855f, -0.09531920f, 
    0.04439509f, 0.07117938f, 0.05084848f, 0.03245533f, 0.14838499f, 0.15627640f, -0.15651530f, -0.16168307f, 
    -0.03616609f, 0.04707603f, 0.06319845f, 0.05905661f, 0.00457458f, -0.01869049f, -0.01254506f, 0.09234274f, 
    0.10399778f, 0.03703283f, 0.05053296f, -0.12761904f, -0.06047500f, 0.18339357f, 0.01577017f, -0.01691289f, 
    -0.03422568f, 0.02623353f, -0.02746923f, 0.05897539f, -0.02791614f, -0.11142077f, -0.14003798f, -0.14991152f, 
    0.05063332f, -0.04010301f, 0.02645188f, 0.02290041f, -0.02833727f, 0.03343154f, 0.05117650f, -0.02687494f, 
    0.04520758f, -0.01193385f, -0.03706466f, 0.16452152f, 0.03659762f, 0.02390050f, 0.05339297f, 0.01035353f, 
    0.05206737f, -0.02670985f, 0.03212754f, -0.03613758f, 0.18210100f, 0.03580149f, -0.00668022f, 0.12073426f, 
    -0.06016742f, -0.02312258f, 0.07360312f, 0.07702141f, -0.10157774f, 0.10608451f, 0.02835013f, 0.00190441f, 
    -0.16108429f, -0.01499647f, -0.05600784f, -0.13073173f, 0.12174683f, 0.01472566f, 0.01464396f, 0.02800741f, 
    -0.01341846f, -0.09470435f, 0.03391079f, -0.01389936f, 0.06337362f, 0.02214011f, -0.11697062f, 0.14878936f, 
    -0.03617159f, -0.01783942f, -0.04927254f, 0.07177276f, -0.05125596f, -0.02686857f, 0.03369353f, 0.06430066f, 
    -0.00342223f, 0.05058663f, 0.08098544f, 0.09991647f, 0.04311907f, 0.03336516f, -0.01159055f, 0.03349524f, 
    -0.05839750f, 0.00193584f, 0.01433225f, -0.14936301f, -0.15618622f, 0.12924534f, 0.06191017f, 0.26431808f, 
    -0.01056125f, 0.11693522f, 0.06284035f, 0.02466640f, 0.00951211f, 0.03131045f, -0.05634829f, 0.05248911f, 
    0.01872896f, 0.24960576f, 0.07175135f, 0.00403304f, -0.04196252f, -0.03078405f, -0.02833378f, 0.05074191f, 
    0.00929267f, -0.00461414f, -0.06143514f, -0.04298259f, 0.11512924f, 0.06910724f, 0.14482500f, -0.17163970f, 
    0.03670346f, 0.10822550f, -0.02704830f, 0.12588373f, 0.03924512f, 0.07411554f, 0.00758552f, 0.04771730f, 
    0.22015300f, -0.00320324f, -0.05363510f, 0.11466634f, 0.00761231f, -0.05035705f, -0.10812617f, -0.00079736f, 
    0.04135448f, -0.03765515f, -0.02798739f, 0.00722047f, 0.16978081f, 0.11597401f, -0.12523761f, -0.04843689f, 
    -0.04278852f, 0.13275199f, -0.00833615f, 0.10595466f, 0.03581402f, 0.04378133f, -0.14088432f, 0.10639546f, 
    0.12699521f, 0.11109455f, 0.14144063f, 0.02799313f, -0.10279945f, -0.06019383f, 0.00661782f, 0.06153959f, 
    -0.01876046f, 0.09265369f, -0.06223245f, 0.03931578f, 0.11796293f, 0.17256556f, 0.06629219f, -0.05567845f, 
    -0.07488188f, -0.04381023f, -0.08696473f, 0.02324332f, -0.09546489f, 0.10841273f, 0.08974543f, 0.13376215f, 
    0.05341590f, -0.05744046f, 0.08196981f, 0.21111012f, -0.05822946f, -0.03237925f, -0.04290333f, -0.00760047f, 
    -0.02998842f, 0.00594055f, 0.11622740f, 0.05734468f, 0.28110129f, -0.12552418f, -0.01416412f, -0.01829745f, 
    -0.01102993f, -0.05700588f, -0.00833828f, 0.04997854f, -0.05307596f, 0.00991693f, -0.05233243f, 0.03039009f, 
    -0.03335979f, 0.00144218f, 0.02149476f, -0.06336641f, 0.08018276f, -0.05064305f, 0.07635404f, 0.05276168f, 
    0.00225386f, 0.05949565f, 0.09100137f, -0.03960952f, 0.03137838f, 0.03979435f, -0.07533643f, 0.12592836f, 
    -0.03766339f, 0.01166723f, 0.08255877f, -0.05939212f, 0.05741537f, 0.05313451f, -0.06483673f, 0.05280232f, 
    0.12624152f, -0.00802744f, 0.00791916f, -0.00920475f, -0.00053422f, 0.09122557f, 0.01793688f, -0.07374008f, 
    0.01304248f, -0.04311963f, -0.04249184f, 0.00736133f, 0.06789509f, 0.05305729f, -0.00682205f, 0.10408419f, 
    0.03926707f, -0.01401560f, -0.07271449f, 0.05441533f, 0.05409453f, 0.00640356f, 0.02086881f, -0.06274755f, 
    0.10338605f, 0.00972355f, -0.02767905f, 0.13468733f, -0.00212379f, -0.01325681f, -0.05579949f, 0.05520117f, 
    0.03441250f, 0.03223110f, 0.03543982f, -0.11243442f, 0.29660466f, 0.07138947f, -0.10238209f, -0.00469200f, 
    -0.00614330f, 0.00037609f, 0.04426290f, 0.01883487f, 0.10838502f, -0.12550455f, -0.00729729f, 0.10875989f, 
    0.06508120f, 0.07104269f, 0.00744580f, 0.10257258f, -0.00016931f, 0.07950582f, 0.07856693f, -0.11139006f, 
    0.05487747f, 0.06078815f, -0.05641158f, 0.00786731f, -0.10717271f, -0.18758747f, 0.20233710f, -0.09018959f, 
    0.00354966f, 0.09768748f, 0.01477418f, 0.14707504f, -0.03347499f, 0.03720933f, 0.01483211f, -0.01034939f, 
    -0.12847352f, 0.05138317f, 0.03574992f, 0.00999830f, -0.05534281f, 0.12982905f, 0.10538383f, 0.02235360f, 
    -0.02631374f, -0.03539765f, 0.01997182f, 0.07815684f, -0.04665930f, 0.07838640f, 0.03477843f, 0.20730057f, 
    -0.05671801f, 0.01026276f, -0.02754796f, 0.03319680f, -0.12437752f, 0.01260148f, 0.00048670f, -0.01570443f, 
    -0.30218914f, -0.07895458f, -0.03040267f, -0.14095497f, 0.00449588f, 0.05712150f, 0.04150080f, 0.07214793f, 
    0.02863626f, 0.02534943f, -0.07120527f, 0.01039034f, 0.05049759f, 0.08722804f, -0.02250165f, 0.07324751f, 
    0.01932273f, -0.00510489f, -0.03183307f, 0.06031940f, 0.03408580f, 0.05698104f, 0.02931885f, 0.00119283f, 
    0.33695853f, 0.11143176f, -0.02908861f, 0.00757133f, -0.06628657f, 0.02769572f, 0.07179800f, -0.10023389f, 
    0.02148411f, 0.00682513f, -0.07426643f, -0.00343520f, -0.14195900f, 0.06059843f, -0.02138945f, -0.02444090f, 
    0.06642916f, 0.01271515f, 0.02798632f, 0.11056826f, 0.01571892f, 0.04934409f, -0.04129153f, -0.03088811f, 
    -0.06420559f, -0.06906648f, -0.17273511f, -0.14706178f, 0.01449806f, 0.04283835f, -0.02885765f, -0.01822903f, 
    0.09137012f, -0.00305048f, 0.00947945f, -0.09862125f, -0.18308894f, -0.23787481f, 0.15790486f, 0.00815873f, 
    0.02101550f, 0.04261668f, 0.03995740f, 0.01410404f, -0.10087030f, 0.07010034f, -0.04136636f, -0.07976971f, 
    -0.11998956f, -0.10863008f, -0.19681104f, -0.19327682f, 0.02721557f, 0.07430718f, 0.04291951f, 0.04527939f, 
    -0.01764495f, -0.01843352f, -0.00217721f, 0.08482312f, -0.30839777f, 0.04765666f, 0.05174943f, -0.26115996f, 
    0.07775889f, 0.08052981f, 0.01570654f, -0.01170250f, -0.01359175f, 0.02134891f, -0.08656498f, -0.02187336f, 
    0.29114598f, -0.09962466f, 0.10015786f, 0.14595205f, -0.03774521f, 0.05281883f, 0.01956181f, -0.00361263f, 
    0.01645768f, 0.03972824f, -0.03375949f, 0.05611629f, -0.28345937f, -0.11527205f, -0.05044596f, -0.14786810f, 
    0.10984474f, -0.05545678f, -0.08099420f, -0.02015977f, -0.03460324f, -0.08703752f, -0.00008842f, -0.04803541f, 
    -0.06728983f, 0.00084379f, 0.06403497f, 0.18409014f, 0.04760107f, -0.06318872f, -0.11520449f, 0.02175445f, 
    -0.00455797f, 0.02269983f, 0.04886124f, 0.05009402f, -0.14957562f, 0.11110868f, 0.04766717f, 0.20798363f, 
    0.03563909f, 0.00456995f, -0.08555423f, 0.14993498f, 0.03619963f, 0.04984110f, 0.04516328f, -0.02876669f, 
    0.00296297f, 0.12163430f, -0.07636790f, -0.07443773f, 0.02884279f, 0.01203141f, 0.00300967f, 0.15276831f, 
    0.00477043f, 0.04349661f, -0.02099096f, -0.02959734f, -0.27912197f, -0.02636519f, -0.13279139f, -0.23482566f, 
    0.11912802f, 0.00446093f, -0.02961493f, 0.06900333f, 0.10337948f, 0.00154953f, 0.07609055f, 0.08864778f, 
    -0.08523714f, 0.07905246f, -0.04891130f, 0.25133112f, -0.00324485f, -0.00260860f, -0.08797996f, 0.03462536f, 
    0.04508985f, 0.04819828f, 0.00794046f, 0.00514265f, 0.11999877f, 0.13242766f, 0.15463495f, -0.03530646f, 
    0.00270738f, 0.02663444f, -0.03950670f, -0.01706186f, 0.05660486f, -0.01640956f, 0.01856609f, 0.09342368f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03897252f, 0.02206069f, -0.00773542f, 0.04898806f, -0.06313837f, 0.10225230f, -0.00176616f, 0.02356839f, 
    0.02910761f, 0.04244280f, 0.01570284f, 0.00442189f, -0.00492424f, 0.06585801f, -0.04004601f, 0.00188480f, 
    0.01818504f, 0.04964389f, -0.02410156f, 0.01234508f, 0.00635341f, -0.00850152f, 0.02230006f, -0.02472149f, 
    0.08375045f, 0.04193376f, 0.00093813f, 0.01009178f, 0.02896138f, -0.00502253f, -0.02903526f, 0.05683836f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.00076608f, 0.12594755f, 0.12016293f, -0.18912241f, 0.25874814f, -0.49419206f, 0.10574797f, -0.16806689f, 
    0.08484641f, -0.29481307f, 0.06538343f, -0.10945200f, 0.14025597f, 0.11628859f, 0.01832444f, -0.02613783f, 
    -0.12204329f, -0.21005985f, 0.33235371f, -0.16868913f, 0.08595351f, 0.13070802f, -0.08323100f, -0.03420201f, 
    0.01264712f, 0.12706715f, 0.01635761f, -0.07695851f, 0.04346818f, -0.10745840f, 0.27938172f, 0.10099716f, 
    -0.06613763f, 0.12842314f, -0.03047602f, 0.38565227f, -0.00311318f, 0.34333238f, 0.11067193f, -0.03146287f, 
    -0.21645819f, 0.38422778f, -0.10527164f, -0.07526883f, -0.15483716f, 0.01988411f, -0.15058537f, 0.13936003f, 
    0.10544365f, 0.42164484f, -0.16612737f, -0.09667249f, 0.18734527f, 0.10798410f, 0.16751511f, 0.09590227f, 
    -0.01952410f, 0.16729107f, -0.11020386f, 0.09329958f, 0.09053286f, 0.01394375f, 0.01008706f, -0.29526222f, 
    0.03574723f, 0.15856184f, 0.09874246f, 0.32991534f, -0.18092419f, -0.53552639f, -0.15145138f, 0.15578669f, 
    0.00350139f, -0.28731054f, -0.00797262f, 0.13037963f, -0.07550211f, 0.10132556f, -0.13927674f, -0.02935781f, 
    0.07581029f, 0.13942827f, -0.36128429f, -0.09178621f, 0.01612257f, 0.18893610f, -0.14722706f, 0.14745846f, 
    0.18693027f, 0.43620440f, 0.09963100f, 0.13609539f, -0.03839287f, 0.02592000f, -0.07012053f, -0.04409114f, 
    0.09348363f, 0.08789007f, 0.08727065f, -0.23524623f, 0.30180970f, -0.36378351f, 0.07932139f, -0.17150420f, 
    0.04617805f, -0.19078465f, 0.05534182f, -0.00256265f, 0.01895538f, 0.23621611f, 0.02881418f, 0.03298282f, 
    -0.11893301f, -0.02876148f, -0.24211308f, -0.01019933f, -0.17148525f, -0.00982106f, 0.03090220f, 0.01535151f, 
    -0.07233666f, 0.30167481f, 0.15038989f, -0.06237751f, 0.03196895f, 0.00822060f, 0.31286585f, 0.22037543f, 
    0.08501672f, 0.08688650f, -0.11533775f, 0.37878150f, -0.23644245f, 0.48234594f, 0.01209651f, 0.13689999f, 
    0.05692155f, -0.22777553f, 0.05990393f, 0.10747761f, 0.16780676f, -0.00287150f, -0.13657343f, -0.13936657f, 
    0.27485657f, -0.10267317f, 0.35780907f, 0.11168429f, 0.04824682f, 0.02554005f, 0.11291980f, -0.01164937f, 
    0.01844342f, -0.20543565f, -0.15002970f, 0.02371562f, 0.08230452f, 0.13565271f, -0.07877015f, 0.14622903f, 
    -0.13521412f, 0.03962436f, -0.17118026f, 0.13639437f, 0.28308812f, 0.00178655f, 0.15220989f, 0.12731788f, 
    -0.31955761f, -0.21280244f, 0.03247809f, -0.09321089f, 0.09279714f, 0.06096466f, 0.05229256f, -0.05342587f, 
    0.15356785f, 0.03489204f, 0.02338275f, 0.11815014f, -0.04943973f, 0.14706153f, 0.15350100f, -0.07145406f, 
    -0.44704810f, -0.16086580f, 0.08546823f, -0.07227787f, -0.06633506f, 0.11231118f, 0.27936795f, 0.16255423f, 
    0.01043526f, -0.16080293f, -0.07886606f, -0.09584365f, 0.25861079f, -0.23736322f, -0.10917655f, 0.03565053f, 
    0.35173106f, 0.09643912f, 0.00084521f, -0.10199562f, -0.05592821f, -0.00916402f, 0.07880354f, 0.17513235f, 
    0.00370603f, -0.14877114f, 0.09325724f, -0.10499088f, 0.08338522f, -0.02290218f, 0.01547255f, 0.03731183f, 
    0.27297720f, -0.20968699f, 0.05285392f, -0.13440250f, -0.17472005f, -0.05822577f, -0.13029005f, 0.00238881f, 
    0.03527413f, -0.11090557f, -0.05196945f, -0.28670570f, 0.13325742f, -0.38330209f, 0.10933381f, 0.07537401f, 
    0.03100111f, 0.39645779f, 0.16274600f, -0.13866791f, -0.13591209f, 0.08194659f, 0.09536811f, 0.09005689f, 
    0.17977035f, 0.13939677f, 0.29591700f, 0.01517080f, 0.15411082f, 0.11159772f, -0.15474355f, -0.11719043f, 
    -0.20181143f, -0.07922821f, 0.04712585f, -0.10351825f, -0.13521010f, -0.00491108f, 0.18230051f, -0.21571243f, 
    -0.06690672f, -0.03283098f, -0.11351556f, 0.29437646f, -0.40053502f, 0.01390156f, 0.09056687f, -0.05220085f, 
    -0.10560580f, -0.40773520f, -0.14142095f, -0.01602173f, 0.13758887f, 0.41345981f, 0.16792901f, 0.01320828f, 
    -0.17097145f, -0.12197699f, 0.08100875f, -0.01244520f, 0.09690107f, 0.15289897f, 0.06224073f, -0.03794435f, 
    0.21846466f, 0.30476886f, 0.11217143f, -0.05772641f, -0.01741593f, 0.15056275f, 0.07210024f, 0.05470949f, 
    -0.09365118f, -0.05483741f, 0.17062832f, -0.11385818f, -0.12412393f, -0.14505824f, 0.08449946f, -0.15316403f, 
    -0.14947522f, -0.01845167f, 0.05576479f, -0.13303421f, 0.00430475f, -0.02673084f, 0.10152375f, -0.16514146f, 
    -0.09858006f, -0.12143746f, -0.01769889f, -0.16903910f, -0.12738979f, -0.11330695f, 0.16474813f, -0.05932976f, 
    0.15295529f, -0.03312098f, -0.07679434f, -0.03655678f, -0.14783041f, -0.10605247f, -0.04384183f, 0.01848231f, 
    -0.06271895f, -0.05439502f, -0.10563283f, 0.18872531f, 0.37782297f, -0.40057352f, 0.06193328f, -0.01952773f, 
    0.20916128f, 0.03316353f, 0.06810699f, 0.12220628f, -0.07760286f, -0.12427546f, 0.06676944f, 0.11313981f, 
    0.23756881f, -0.20205916f, 0.18374407f, 0.15838674f, 0.04183469f, 0.09010519f, 0.00656262f, -0.15997295f, 
    0.29006407f, 0.26694384f, 0.13761224f, 0.00808352f, 0.18140365f, 0.09513469f, -0.24988742f, -0.41844895f, 
    0.09970375f, 0.11827753f, -0.10905161f, 0.07936063f, 0.20078969f, -0.39842060f, 0.13729429f, -0.12184098f, 
    0.27583089f, -0.10301567f, 0.09546568f, -0.09898464f, 0.13884281f, 0.06522056f, -0.07186357f, -0.05559118f, 
    0.07804567f, -0.26950905f, -0.10315350f, 0.12792085f, 0.15880053f, 0.33020315f, 0.08916272f, -0.14943379f, 
    -0.17174487f, -0.16017015f, 0.02617665f, -0.14855587f, -0.04188462f, 0.06829114f, 0.32058853f, -0.14873832f, 
    -0.07506680f, -0.07326574f, -0.02539808f, -0.16072647f, 0.14720403f, -0.00855035f, 0.05204356f, 0.06541391f, 
    -0.14697750f, -0.00510882f, -0.04236597f, -0.12952013f, 0.16851331f, 0.06906262f, -0.04416773f, -0.00464165f, 
    0.01390205f, -0.06778129f, -0.11505361f, 0.05800492f, 0.09695562f, -0.01472508f, 0.13410282f, 0.05612038f, 
    -0.00500651f, -0.12189160f, -0.03996145f, 0.12124721f, 0.12437610f, -0.08082189f, 0.03273689f, -0.18182358f, 
    -0.10641892f, -0.03928419f, 0.08023879f, -0.05493295f, 0.27447873f, -0.11077239f, 0.08092672f, 0.08560371f, 
    -0.18280366f, 0.19971840f, 0.11605852f, 0.11216550f, 0.08761492f, 0.32850319f, -0.13997360f, -0.07740232f, 
    -0.00235779f, 0.24659944f, 0.29487586f, 0.11790127f, 0.09050792f, -0.27948993f, -0.00616474f, 0.05990131f, 
    0.16136619f, -0.10099781f, -0.05851588f, 0.02023569f, -0.12080970f, -0.11842310f, -0.14162172f, -0.29235083f, 
    -0.08125944f, -0.15254636f, 0.13668305f, -0.03649739f, -0.17206907f, 0.08122128f, -0.12486798f, 0.13084875f, 
    -0.09063064f, 0.15570819f, 0.07809667f, -0.03287620f, 0.08514761f, 0.09726085f, -0.02867870f, 0.05467228f, 
    0.06449319f, -0.07895252f, 0.07074791f, -0.05489505f, 0.15105858f, -0.10561147f, -0.14502712f, -0.12698480f, 
    -0.14016770f, -0.16291417f, -0.02581071f, -0.08979635f, -0.09168996f, -0.02946636f, -0.03096675f, -0.09833410f, 
    0.00031382f, 0.12993662f, -0.01083521f, -0.23120210f, 0.45222872f, -0.22128820f, -0.02432590f, -0.16584557f, 
    0.28297392f, 0.33982691f, -0.09226314f, 0.03298142f, 0.00198527f, -0.21869104f, 0.08809339f, -0.15565710f, 
    0.03235086f, 0.19860758f, 0.35574555f, 0.05184706f, -0.16943963f, 0.26368603f, -0.14828192f, -0.01704204f, 
    -0.25232941f, -0.31938538f, 0.04225479f, 0.06837300f, 0.03999705f, -0.07270706f, 0.25042674f, 0.01498605f, 
    0.10931097f, 0.13173145f, -0.11375476f, 0.03846956f, 0.09992021f, -0.06978544f, -0.14117476f, 0.17616969f, 
    0.13842912f, -0.14009209f, -0.09117916f, -0.14328335f, -0.11827981f, -0.06684893f, 0.13778311f, -0.01914032f, 
    -0.10846447f, -0.19421425f, 0.03517220f, -0.03764183f, -0.08057055f, -0.17109205f, -0.14965758f, -0.01974569f, 
    -0.16149904f, -0.16117905f, 0.16242433f, 0.11311831f, -0.15663627f, 0.08103146f, -0.06461669f, -0.01629903f, 
    0.08430798f, -0.01991782f, 0.13919304f, 0.17978755f, -0.09815056f, -0.02562642f, 0.10483062f, 0.17492646f, 
    -0.08735884f, 0.02784239f, -0.03274776f, 0.05028091f, -0.15173884f, 0.10167477f, -0.06995751f, -0.07665854f, 
    0.20096631f, 0.19394374f, -0.19564188f, 0.12341537f, 0.03095819f, 0.31803709f, -0.16823182f, -0.16827707f, 
    -0.33612102f, -0.37469622f, 0.00518377f, -0.16102639f, -0.15544282f, -0.06193228f, 0.13834879f, 0.32258746f, 
    -0.01202774f, 0.03766502f, -0.14188972f, -0.23142852f, 0.08737914f, 0.29718673f, 0.04820557f, 0.02969481f, 
    0.36493370f, 0.26562747f, -0.15402412f, 0.16031250f, -0.11358915f, 0.07829677f, 0.15380472f, -0.04094817f, 
    0.21259066f, -0.15279540f, -0.15324974f, 0.02959474f, -0.16683434f, -0.02665586f, -0.07432028f, -0.16221391f, 
    0.09729193f, -0.06473794f, 0.14784452f, 0.12932329f, 0.06941251f, -0.12733757f, -0.17876144f, 0.02737522f, 
    0.00213497f, -0.08019036f, 0.17101008f, 0.15454794f, -0.14685488f, -0.04881612f, -0.03232443f, -0.03598494f, 
    0.05039334f, 0.31844676f, 0.14211316f, -0.14216471f, -0.10377810f, 0.09144612f, -0.10223472f, -0.00252243f, 
    0.20954354f, 0.38532755f, -0.35136104f, -0.02175610f, 0.04917601f, -0.05102988f, -0.11182766f, 0.07280950f, 
    0.17759904f, 0.20642737f, -0.02469262f, 0.14871502f, -0.14003509f, 0.00880540f, -0.25974503f, -0.27782604f, 
    0.05930224f, -0.08113296f, -0.04867044f, -0.36198717f, -0.26111385f, 0.27271354f, 0.10830041f, -0.01947973f, 
    0.14526756f, -0.22892003f, 0.11611982f, -0.04910183f, -0.14375609f, 0.28295207f, -0.03463649f, -0.15942670f, 
    0.04682796f, 0.12530884f, -0.11802652f, 0.04375443f, 0.00092222f, -0.07853833f, -0.09136959f, -0.03392641f, 
    0.23937602f, -0.26150060f, 0.08745864f, 0.03962214f, -0.00640407f, -0.00212014f, 0.29528895f, 0.16387281f, 
    -0.04923774f, -0.02022393f, 0.10118771f, -0.12076574f, 0.05377303f, -0.14090692f, -0.07171753f, 0.14549239f, 
    0.04832176f, -0.21911541f, 0.13554505f, -0.07330359f, -0.13241732f, 0.01033398f, -0.11296137f, -0.05430021f, 
    -0.12675819f, 0.39416665f, -0.06741127f, -0.10483723f, 0.00517167f, 0.09180728f, 0.15752934f, 0.12964818f, 
    -0.11219930f, -0.02532148f, -0.12903468f, -0.07252495f, -0.11788037f, -0.00471200f, 0.44818595f, 0.50059980f, 
    0.16006193f, 0.15024972f, -0.04361373f, 0.09547401f, -0.15240525f, 0.13285710f, 0.11698976f, -0.09753796f, 
    -0.10497796f, -0.17142214f, 0.09579244f, 0.04227145f, 0.03897419f, -0.09060900f, 0.06783019f, 0.07526189f, 
    -0.03946523f, -0.02539347f, -0.01727046f, -0.17502320f, -0.01434078f, 0.04523248f, 0.00633040f, -0.07753517f, 
    -0.02446923f, 0.10951704f, 0.14764492f, 0.06868034f, 0.02791852f, 0.06314150f, -0.18321179f, 0.03355400f, 
    0.04399479f, -0.09378838f, 0.10076378f, -0.07565318f, 0.02432265f, -0.13233744f, 0.05802902f, 0.15576389f, 
    -0.13811396f, -0.10360209f, 0.14924829f, 0.09952936f, 0.16487183f, -0.07153197f, 0.08104405f, -0.07278126f, 
    0.03963080f, -0.15723042f, -0.06763236f, 0.09136833f, -0.16485307f, -0.05572262f, -0.09541367f, 0.13292024f, 
    0.07427189f, 0.03410152f, -0.16447484f, 0.03010409f, 0.08981011f, -0.16405256f, 0.16076994f, 0.00258030f, 
    0.01057581f, 0.00118692f, -0.01588958f, -0.41494438f, 0.18397573f, 0.58176243f, -0.17912912f, -0.16044034f, 
    0.16778025f, 0.18857643f, 0.12998009f, 0.05470650f, -0.03408607f, -0.06001773f, 0.14393134f, -0.06834006f, 
    0.06761456f, 0.06707884f, -0.24673791f, 0.06504346f, -0.01643433f, 0.26679304f, -0.13843456f, -0.00223784f, 
    -0.25875351f, 0.18694510f, 0.04074064f, 0.06389985f, 0.01757558f, 0.12198259f, 0.23817265f, 0.37517750f, 
    -0.13185604f, -0.14189285f, 0.03453131f, 0.22405690f, 0.05210833f, 0.31474337f, -0.08826986f, 0.05934441f, 
    0.12629300f, 0.06763414f, 0.10221172f, -0.04538889f, 0.16644357f, 0.18144965f, -0.10718500f, 0.01184562f, 
    0.33407778f, -0.16753395f, 0.27449188f, -0.02966135f, -0.13809113f, -0.04574157f, -0.12639718f, 0.09928799f, 
    -0.12136271f, -0.41347945f, 0.03851992f, -0.04950340f, 0.05452874f, -0.13970289f, -0.17794882f, -0.21221375f, 
    0.12573478f, -0.12720877f, 0.12826608f, 0.43004584f, -0.24155419f, 0.18051365f, 0.10611317f, -0.03382074f, 
    -0.03082256f, 0.02884533f, 0.02031377f, 0.05421853f, 0.15587607f, -0.14749986f, -0.14540023f, -0.14837955f, 
    0.15880251f, 0.19652565f, 0.31712687f, -0.01977273f, -0.05057435f, 0.01162482f, -0.03284187f, -0.11310267f, 
    -0.02265914f, -0.00741974f, -0.06204701f, -0.01382777f, 0.10942848f, 0.18128410f, -0.04242247f, 0.28720465f, 
    -0.02209246f, -0.04964151f, 0.14896962f, 0.05322358f, 0.11178759f, 0.11103687f, -0.11924770f, 0.01888311f, 
    -0.05990587f, 0.06165428f, 0.12030873f, 0.12850787f, -0.16858032f, 0.07099961f, -0.01049284f, -0.05757969f, 
    -0.01143213f, 0.04464736f, -0.00285745f, -0.08600353f, 0.05233471f, -0.16498591f, -0.16092971f, 0.01613360f, 
    -0.18864785f, -0.01377461f, 0.02619732f, -0.08796953f, 0.12053072f, 0.16874008f, -0.11349181f, -0.09314820f, 
    -0.07945728f, -0.01643355f, 0.01104342f, 0.07359352f, -0.16445370f, 0.15461832f, 0.09029745f, 0.11816324f, 
    0.10640863f, 0.07458876f, -0.08991711f, -0.00685053f, 0.03919208f, -0.07236812f, -0.09646451f, -0.16002636f, 
    0.08742210f, -0.19281213f, -0.01960451f, 0.13431065f, -0.06595191f, -0.13574912f, -0.00642272f, -0.14312768f, 
    -0.10677309f, -0.14850110f, 0.10515103f, 0.06287865f, -0.11552544f, 0.08471110f, -0.10972072f, -0.12982929f, 
    -0.07799860f, -0.00926133f, -0.02565134f, -0.22464429f, 0.03506205f, 0.06820014f, -0.08213717f, -0.10376284f, 
    -0.05192341f, 0.17728671f, 0.13134585f, -0.15056431f, 0.12131891f, -0.08413594f, 0.05666479f, -0.08699362f, 
    -0.21805048f, 0.30899847f, 0.42381433f, 0.04378529f, 0.07763557f, -0.16254033f, 0.16336393f, -0.03357951f, 
    0.12815621f, 0.25957769f, -0.02484632f, -0.16231483f, -0.04579817f, -0.04804302f, 0.28284836f, 0.22012240f, 
    0.11107630f, 0.16947821f, -0.15284881f, 0.29244637f, -0.03597239f, 0.29085299f, -0.07694018f, -0.01155577f, 
    0.12813024f, -0.11321773f, -0.14272423f, -0.05091535f, -0.07521521f, -0.25544497f, 0.13770682f, -0.05373234f, 
    0.02655973f, -0.02622253f, 0.01741065f, 0.12160824f, -0.16190676f, 0.19802397f, 0.01887536f, -0.16192560f, 
    0.17644586f, 0.40560162f, -0.00437509f, -0.09697974f, 0.03903103f, 0.04423461f, -0.00223644f, 0.04684833f, 
    0.16375740f, -0.07512157f, -0.00402751f, -0.06832341f, 0.27860948f, 0.15198873f, 0.11984698f, 0.12091000f, 
    0.27454633f, 0.17901199f, -0.02259926f, -0.12532671f, 0.14286895f, 0.06980097f, 0.09878737f, -0.03540501f, 
    -0.28476095f, -0.38312212f, -0.06960660f, -0.04239433f, 0.01290635f, 0.19493036f, 0.16580540f, 0.15659954f, 
    -0.16649543f, 0.09590180f, 0.07731422f, 0.01510600f, 0.16039208f, 0.11515553f, 0.04429336f, 0.23794003f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.10108497f, -0.02019184f, -0.11873998f, -0.10126173f, 0.15200312f, -0.05366033f, -0.11387173f, -0.03212997f, 
    0.27330175f, -0.18040033f, -0.17759228f, 0.10943911f, -0.06305337f, -0.01311129f, -0.07613275f, 0.15016744f, 
    -0.19512907f, -0.14741077f, -0.09322036f, -0.05389565f, 0.17173250f, 0.29404226f, 0.08864453f, 0.03015091f, 
    -0.00776257f, 0.09422224f, 0.01939041f, 0.15711451f, 0.14759988f, 0.00497893f, -0.09781916f, -0.14074126f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.23328255f, -0.19239491f, -0.11737695f, -0.89463812f, 0.34154221f, -0.20260182f, -0.04477386f, 0.26942521f, 
    -0.01202159f, -0.11815276f, 0.25231078f, 0.33904997f, 0.07288689f, -0.05718782f, -0.19611368f, 0.17799699f, 
    0.12878817f, -0.17260863f, -0.23360409f, -0.29393408f, -0.20869462f, -0.68474787f, -0.10918170f, -0.15994312f, 
    -0.39863917f, 0.34450078f, 0.17211664f, -0.06882151f, 0.00987701f, -0.33854657f, -0.05359734f, -0.23325257f, 
    -0.23741025f, 0.03815442f, 0.21429561f, -0.47948939f, 0.15087482f, 0.36668071f, -0.04626091f, -0.32025748f, 
    0.10461393f, 0.12691152f, 0.08029272f, -0.08876997f, 0.15018351f, 0.01545515f, 0.09946997f, -0.56264526f, 
    0.12303654f, 0.15137422f, 0.03119755f, 0.27181372f, -0.09668472f, -0.02634808f, -0.04342570f, -0.11363971f, 
    -0.28078771f, 0.25850186f, 0.14376783f, 0.08934122f, 0.11198736f, -0.40434793f, 0.13786305f, -0.51658112f, 
    0.24344368f, -0.37178433f, 0.39593032f, 0.19541587f, -0.00705209f, -0.45646790f, 0.24736585f, -0.64406401f, 
    0.30230829f, -0.01890315f, 0.02818010f, 0.20915082f, -0.08594364f, -0.32399246f, -0.09366964f, -0.26663288f, 
    0.02170789f, -0.07497972f, -0.11246586f, -0.19936639f, -0.02017485f, 0.12718479f, -0.05025910f, 0.08134702f, 
    -0.19295439f, -0.46428281f, 0.08890749f, -0.16362879f, 0.12641804f, -0.16309646f, -0.09277701f, 0.31015748f, 
    -0.13386647f, 0.20595391f, -0.14333621f, -0.41666833f, 0.25595897f, 0.32258311f, -0.64890218f, -0.10584006f, 
    -0.02831277f, -0.02712623f, -0.57073855f, -0.16607031f, -0.09159794f, -0.05548275f, -0.14351916f, 0.15504895f, 
    0.14602508f, 0.25408396f, -0.39224130f, -0.33918789f, -0.16274835f, 0.19594869f, 0.07773083f, -0.16935702f, 
    0.21570110f, 0.05064201f, 0.25256777f, 0.09587532f, -0.15693380f, 0.10485953f, -0.01775458f, 0.07696209f, 
    -0.27493680f, -0.02972935f, -0.11288366f, -0.49503398f, 0.18384340f, -0.25433913f, -0.01324637f, 0.13067883f, 
    -0.16958770f, 0.08635060f, -0.24552962f, 0.27650043f, 0.07078646f, -0.36999384f, 0.06531329f, 0.08945858f, 
    0.13501735f, 0.30577317f, 0.25218666f, 0.11649604f, 0.16247560f, -0.06628545f, -0.13923894f, 0.12928084f, 
    0.27143279f, 0.19221364f, -0.03246104f, 0.07018039f, -0.01944159f, -0.35853371f, -0.17102118f, 0.04729814f, 
    -0.43957371f, 0.21368606f, -0.41408342f, -1.41221690f, 0.10401364f, -0.10704859f, 0.10112537f, 0.03986929f, 
    -0.37416556f, -0.16896206f, 0.05436273f, -0.44513360f, 0.14110492f, 0.22006524f, -0.12428453f, 0.13501139f, 
    0.05814566f, -0.32477149f, 0.20091458f, 0.17077017f, -0.18417218f, -0.66492355f, 0.01180020f, 0.01936079f, 
    0.13915929f, 0.23033936f, 0.14234363f, 0.05230168f, -0.04679465f, 0.10163828f, -0.16064741f, 0.06036457f, 
    0.09121990f, -0.07629336f, 0.15847810f, -0.04352814f, -0.44321489f, -0.21661121f, -0.02400661f, 0.24383438f, 
    -0.30040479f, 0.07410337f, 0.15113139f, 0.09368758f, 0.11446209f, -0.25171077f, -0.16385657f, 0.22635148f, 
    -0.01035648f, -0.58349138f, -0.01782220f, 0.06583760f, -0.18483859f, 0.00117945f, 0.09138979f, -0.11955222f, 
    0.21669209f, -0.47017488f, 0.01549978f, -0.07998239f, 0.08884142f, 0.21429548f, 0.23396057f, -0.04506662f, 
    0.22018319f, -0.14967139f, 0.10630583f, 0.51749241f, -0.39831045f, 0.35382539f, -0.31358814f, 0.22447330f, 
    -0.32161519f, 0.16463128f, -0.34151813f, 0.15889859f, 0.01873632f, -0.15575454f, -0.13140675f, 0.24456561f, 
    -0.17465939f, 0.27072990f, -0.28525034f, -0.00183452f, -0.04123616f, 0.22630644f, -0.11672387f, -0.09181409f, 
    0.27961236f, -0.23415822f, -0.06890047f, -0.04570175f, -0.13611403f, -0.18224624f, -0.33558497f, 0.05599324f, 
    0.07802141f, 0.24534154f, 0.17058147f, 0.40831518f, -0.53963006f, -0.16991250f, -0.26645765f, 0.14551345f, 
    0.25462142f, -0.10096104f, -0.00124604f, -0.27575076f, -0.10081811f, 0.41844901f, -0.04516475f, -0.39814478f, 
    0.14532050f, -0.29574302f, -0.10294133f, 0.25651109f, 0.16823800f, -0.06152035f, 0.08036409f, -0.03675887f, 
    -0.01935202f, -0.29996186f, -0.45203969f, 0.15706974f, 0.07605914f, -0.07128295f, -0.17250858f, -0.05619971f, 
    0.25759494f, -0.59748864f, -0.47880709f, -0.00376494f, 0.09717412f, -0.22000206f, 0.27387699f, -0.07258905f, 
    -0.04107395f, 0.16040735f, -0.06192379f, 0.09313915f, 0.04131355f, -0.09514409f, -0.13423859f, 0.08495328f, 
    0.12993886f, -0.52536768f, 0.28419644f, -0.55040693f, 0.10683151f, -0.17055137f, 0.12540700f, -0.13796113f, 
    0.23759985f, 0.11117274f, -0.31033969f, 0.01289244f, 0.05824425f, 0.00915361f, -0.01458329f, 0.37523824f, 
    -0.05188869f, -0.00127143f, 0.02152860f, -0.22309792f, 0.36542428f, -0.32580003f, -0.49698281f, -0.58592898f, 
    0.27979785f, -0.07788906f, -0.54721594f, -0.73534864f, -0.13797754f, -0.26112458f, -0.10418162f, -0.40181425f, 
    -0.04669159f, -0.16856730f, -0.10188202f, -0.09378301f, 0.25638857f, 0.16628218f, 0.03183756f, 0.06353887f, 
    0.23909724f, -0.15552381f, 0.29573479f, -0.13316213f, 0.04797766f, 0.25747901f, 0.23100533f, -0.17783266f, 
    0.22841635f, -0.26600981f, -0.25297073f, -0.27918884f, 0.05305193f, -0.40604004f, 0.02765088f, 0.34473231f, 
    -0.07289575f, -0.07977330f, -0.27276009f, -0.31893307f, 0.04971756f, 0.32271141f, 0.00544409f, 0.22451465f, 
    0.00532793f, -0.09848648f, -0.08367243f, -0.05561117f, 0.21861044f, 0.21572901f, 0.09792565f, -0.15015317f, 
    -0.18256584f, 0.13733529f, 0.18630674f, 0.05359251f, 0.07769589f, 0.30857596f, -0.29604560f, -0.55470377f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.14596784f, 0.09891833f, 0.02292045f, -0.15261769f, -0.11209441f, 0.07325988f, -0.09337727f, -0.27012363f, 
    0.09696484f, 0.12361176f, 0.00377925f, 0.08594257f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
