#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.08819705f, 0.59981155f, 0.53148431f, -0.61493677f, -0.52534544f, 0.12104976f, 0.41398770f, 0.22853526f, 
    0.01920998f, 0.82961929f, -0.74254584f, 0.51772392f, -0.31738228f, -0.10142021f, -0.14439471f, -0.19921966f, 
    -0.49274462f, -0.14001969f, -0.46443996f, -0.59426594f, -0.20018254f, -0.47816804f, -0.45028061f, -0.30327508f, 
    0.53679717f, 0.21984971f, -0.60570592f, -0.71951544f, -0.46902648f, 0.38964781f, -0.27432123f, -0.63124627f, 
    -0.57158089f, 0.17704211f, 0.27584034f, 0.33995536f, -0.61228979f, 0.59985411f, -0.58671898f, -0.74142659f, 
    -0.00854676f, 0.24890645f, -0.13503087f, 0.21690126f, 0.12731314f, -0.59842491f, 0.29965848f, 0.51378053f, 
    -0.62086666f, 0.37791172f, -0.50851941f, -0.53434241f, 0.19065440f, -0.11492517f, 0.73475355f, 0.44459042f, 
    0.30917454f, 0.13732786f, 0.19888838f, 0.10017762f, -0.13360997f, 0.12721436f, 0.33184633f, 0.83648515f, 
    0.62306124f, 0.41857639f, -0.18681242f, -0.36201456f, 0.16909799f, -0.15989554f, -0.27336290f, -0.05478530f, 
    0.30116373f, -0.48013151f, -0.57708156f, 0.01103675f, -0.63799083f, 0.22744603f, -0.28002807f, 0.17361157f, 
    0.33900985f, 0.78876644f, -0.59152818f, 0.67046565f, -0.08703530f, -0.96030748f, 0.12235388f, 0.31486517f, 
    0.23841940f, -0.01855177f, -0.45711100f, -0.10242523f, 0.07499399f, 0.78841835f, 0.24088112f, 0.40153879f, 
    -0.35912517f, -0.58898532f, 0.16264887f, -0.09442190f, 0.98943001f, 0.44904676f, 0.70277697f, -0.43063807f, 
    -0.74913335f, -0.18575136f, 0.01666119f, -0.10987783f, 0.39768714f, 0.52008957f, 0.46222278f, 0.07777735f, 
    0.28799626f, -0.10156090f, 0.38597861f, -0.47344166f, 0.21413642f, -0.73370236f, 0.86337960f, 0.52167594f, 
    0.24963960f, 0.72270018f, 0.31332383f, -0.19012249f, -0.07838512f, 0.20498119f, -0.18299617f, -0.63053119f, 
    -0.49026594f, -0.17991447f, -0.46796650f, -0.35012576f, -0.22305882f, -0.24437860f, 0.30925578f, -0.03671423f, 
    -0.60127676f, 0.80304277f, -0.44665876f, 0.51787651f, -0.28762177f, 0.45046860f, -0.26203430f, 0.07623974f, 
    0.69373530f, 0.51747346f, 0.81971067f, -0.75747842f, 0.12526457f, -0.36141843f, 0.09620867f, 0.04592245f, 
    -0.17033979f, -1.06323874f, -0.20319033f, -0.17734410f, 0.83831418f, -0.47912827f, -0.01787613f, 0.07301594f, 
    0.10838719f, 0.22852291f, -0.13393587f, -0.73315495f, -0.66744274f, 0.32083872f, 1.03400183f, -0.10235193f, 
    0.34756920f, 0.13690002f, -0.23307823f, -0.31111550f, -0.29337165f, 0.46615705f, -0.80303460f, 0.56585819f, 
    0.08858000f, -0.06332214f, 0.05849432f, -0.13472189f, -0.58097303f, 0.39931324f, 0.25365108f, 0.53496420f, 
    0.68936169f, 0.41169932f, 0.30834082f, 0.36948410f, 0.09325129f, -0.95718426f, 0.63236332f, 0.53859842f, 
    -0.23376049f, 0.52315080f, -0.01898698f, 0.04188019f, 0.29602599f, -0.15697704f, -0.56184471f, -1.00745606f, 
    -0.48137617f, -0.36665428f, 0.75508940f, 0.68813270f, -0.14504263f, -0.37125382f, 0.06139506f, -0.61438996f, 
    0.57149041f, 0.42006406f, -0.57281095f, 0.22660498f, 0.56061792f, 0.22124851f, -0.43077329f, 0.57626629f, 
    0.38214284f, 0.79308134f, 0.73561186f, -0.73037577f, 0.42094654f, -0.50437438f, 0.39423871f, -0.02231417f, 
    0.01586306f, 0.15123597f, 0.11890201f, -0.28383327f, -0.16378254f, -1.00044179f, -0.44017774f, -0.39085165f, 
    0.85166973f, 0.12189364f, -0.64683849f, -0.94589132f, -0.50252545f, -0.05264951f, 0.40242839f, 0.67934668f, 
    -0.24399163f, 0.02696939f, -0.12690359f, 0.81156582f, -0.07145584f, 0.11424167f, 0.63458955f, 0.76600683f, 
    -0.51403427f, -0.38993505f, -0.04033606f, 0.01769539f, 0.70346648f, 0.44070408f, -0.88533127f, 0.43260682f, 
    -0.08124784f, 0.48357433f, -0.39475685f, -0.36192730f, -0.23605314f, -0.61874497f, 0.19198477f, -0.01050435f, 
    -0.54625034f, -0.52170706f, -0.60418481f, -0.05399210f, -0.24434157f, -0.48621908f, 0.32606155f, 0.94760621f, 
    -0.11380944f, -0.05671607f, 0.37032074f, 0.46770534f, 0.21770371f, -0.02202778f, -0.44424748f, 0.75696981f, 
    -0.12766771f, -0.27057159f, 0.81471431f, -0.08035871f, -0.60413241f, -0.11433850f, 0.42191863f, -0.06260706f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.13516118f, -0.02281474f, -0.09784201f, 0.05998859f, 0.16712317f, 0.23928156f, 0.27752498f, 0.24122135f, 
    -0.16019230f, 0.13453853f, -0.16985977f, -0.14135855f, -0.04825962f, -0.06615622f, -0.11323159f, -0.18456981f, 
    0.14662683f, -0.09911522f, 0.34176412f, 0.13802597f, -0.04809259f, -0.00914443f, 0.19506551f, 0.01432938f, 
    -0.06672592f, 0.06515562f, -0.03231985f, -0.03748179f, -0.00926574f, 0.13089162f, 0.35032207f, -0.02999311f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.16331080f, 0.12477936f, 0.00263170f, 0.14784329f, -0.01270914f, -0.12069755f, -0.21753898f, -0.02749698f, 
    -0.03346928f, 0.09456715f, -0.05235732f, -0.01477474f, 0.04925786f, 0.03355052f, -0.01780944f, -0.01783264f, 
    0.08765844f, 0.03882851f, -0.01826746f, 0.02311196f, 0.39541668f, -0.11690947f, 0.07302249f, 0.25698510f, 
    -0.04148194f, -0.11117937f, 0.00026608f, -0.03363891f, 0.00581836f, -0.00948267f, -0.02833564f, 0.01492745f, 
    0.08243640f, 0.08911666f, 0.12116006f, 0.03016820f, -0.11593986f, -0.07921535f, -0.05485486f, 0.09858248f, 
    0.08182163f, 0.00055150f, -0.02966097f, 0.21280199f, 0.14312868f, 0.00640875f, -0.06460121f, -0.02103154f, 
    0.02377892f, 0.05990201f, 0.11003064f, 0.05234147f, -0.01232863f, -0.10921731f, 0.00657145f, -0.01202191f, 
    0.02334129f, -0.03041980f, 0.00964128f, 0.15119052f, -0.01409440f, -0.06129057f, -0.07855822f, 0.10897800f, 
    0.11993893f, 0.10854940f, -0.01917030f, -0.01226308f, -0.07063951f, -0.00910121f, -0.00796523f, 0.03099626f, 
    0.07822414f, 0.00812711f, 0.01935086f, 0.06209924f, 0.08691288f, 0.09334026f, -0.06038549f, 0.03424131f, 
    0.12456675f, -0.24399239f, 0.10639554f, 0.12162116f, 0.20743729f, 0.05584154f, 0.05332041f, -0.02386429f, 
    0.02878753f, 0.14881691f, 0.06133441f, 0.01704724f, -0.00915729f, 0.01397378f, -0.00908467f, -0.02486810f, 
    -0.04689708f, 0.05312956f, 0.02442285f, 0.02832817f, 0.06322324f, -0.10452747f, 0.13652554f, 0.02992834f, 
    0.01511720f, 0.10513303f, 0.11280362f, 0.01691647f, 0.06523294f, -0.02091319f, -0.02114177f, 0.02962311f, 
    -0.07999111f, 0.04605573f, 0.02683256f, -0.02966635f, -0.02330293f, 0.05070378f, -0.00488852f, 0.00004319f, 
    -0.12083730f, 0.01704760f, 0.04883768f, -0.05550089f, 0.06606180f, -0.05433622f, 0.01343228f, 0.05609743f, 
    0.02552234f, -0.04553995f, -0.01246407f, -0.03111863f, -0.00853565f, -0.00049737f, -0.08476618f, 0.00595743f, 
    0.05523711f, -0.03798996f, -0.05266081f, 0.04006331f, -0.03737913f, -0.12879434f, 0.11656369f, 0.09877603f, 
    0.08129326f, -0.09248128f, -0.03581345f, -0.06067639f, -0.03209540f, -0.01271617f, -0.05886151f, -0.01726474f, 
    -0.05208584f, 0.03988177f, 0.05661684f, 0.06699157f, 0.00733056f, -0.06046186f, 0.02503839f, -0.02385381f, 
    0.08179404f, -0.15061390f, 0.09053005f, 0.12938294f, 0.11724935f, 0.05352430f, 0.16549635f, -0.04336471f, 
    0.02805356f, 0.03538029f, -0.11767092f, -0.03352869f, 0.02190129f, -0.02619176f, -0.00442606f, 0.04683612f, 
    0.03158761f, 0.04039383f, 0.01767479f, 0.16917767f, 0.38410103f, -0.07057962f, -0.05388178f, 0.19985241f, 
    -0.01698553f, -0.16591418f, 0.00404274f, 0.03783918f, 0.01391682f, 0.02260667f, -0.11937053f, -0.03407237f, 
    -0.03148294f, 0.03318722f, -0.00568952f, -0.03199318f, -0.00460007f, -0.05300868f, 0.01168647f, -0.00665939f, 
    0.05547404f, 0.20457688f, -0.05164890f, -0.04818254f, -0.32483986f, 0.06509063f, 0.02285652f, 0.09192603f, 
    -0.08267322f, -0.05889297f, 0.04746754f, 0.08137866f, -0.07980262f, -0.08186985f, 0.02499270f, 0.26150948f, 
    0.03856143f, 0.02232056f, 0.05601839f, 0.00356880f, -0.25954786f, 0.23571937f, 0.16506726f, 0.04847812f, 
    0.04477395f, -0.14211385f, -0.14099745f, 0.05834294f, 0.01802640f, 0.04184863f, -0.20117123f, 0.04124380f, 
    0.01054034f, 0.02944847f, 0.01442745f, 0.04911147f, -0.09316268f, 0.02686667f, -0.02111561f, -0.08775711f, 
    -0.02944706f, -0.00678620f, 0.13087568f, -0.05203015f, -0.09568550f, -0.07969940f, -0.07079243f, -0.00722052f, 
    -0.02445309f, 0.01525119f, -0.00400597f, -0.04880235f, -0.00706849f, -0.01514671f, 0.00281056f, -0.01425425f, 
    0.06302047f, 0.05342685f, -0.02543835f, 0.07457180f, 0.01305289f, -0.11958490f, 0.24538092f, 0.16524875f, 
    0.01870827f, -0.03912136f, -0.04698055f, -0.00638025f, -0.14652872f, -0.03053995f, 0.07845684f, -0.01967425f, 
    -0.05546489f, 0.02508498f, -0.01665156f, 0.08337855f, 0.05167437f, 0.02524971f, 0.00463641f, 0.02703423f, 
    -0.14147958f, -0.00623348f, 0.00827927f, 0.17730875f, 0.12423997f, 0.14008102f, 0.14797612f, 0.03933925f, 
    0.04400591f, -0.01679735f, -0.08976705f, 0.03774551f, -0.03198410f, 0.00198724f, 0.05682481f, 0.10512425f, 
    -0.03317950f, 0.01337475f, 0.00756670f, 0.06226780f, 0.04481532f, 0.03216926f, 0.11425900f, 0.03203273f, 
    -0.22790752f, -0.14854187f, -0.03267449f, -0.09772240f, 0.03643166f, 0.11122027f, -0.00924226f, 0.12101924f, 
    -0.06355504f, -0.01388783f, -0.03606536f, -0.01591878f, -0.00364128f, 0.01319675f, -0.14148299f, 0.03458834f, 
    -0.12748344f, -0.10291779f, 0.16239513f, 0.05902060f, -0.10977276f, -0.13262989f, 0.02944780f, -0.08088373f, 
    0.00497354f, 0.05744225f, -0.10041076f, -0.02799537f, 0.00936078f, 0.06048543f, 0.04006810f, -0.08124816f, 
    0.03371444f, -0.00144175f, 0.05089359f, 0.01021000f, -0.21166943f, -0.06955262f, -0.14048488f, 0.06539690f, 
    -0.20736963f, 0.09882138f, 0.03142065f, 0.00448134f, -0.11438043f, 0.17680939f, 0.00262123f, 0.09403217f, 
    0.05837539f, -0.04140843f, 0.06315016f, 0.14656471f, 0.06746149f, 0.07994959f, -0.08180769f, -0.03976917f, 
    -0.19502565f, 0.16795772f, -0.09585843f, -0.12165417f, 0.03145336f, 0.11858519f, 0.02371119f, -0.01066161f, 
    -0.01661780f, -0.05796229f, 0.01328103f, 0.19990708f, -0.00938463f, -0.03699169f, 0.03400577f, -0.03805473f, 
    0.10238511f, 0.00522366f, -0.03823659f, -0.02943988f, 0.05361400f, -0.22957079f, 0.04787352f, -0.01641298f, 
    -0.08940441f, 0.05403484f, 0.12193089f, 0.06718510f, 0.03519864f, -0.05298091f, 0.03092561f, 0.01264236f, 
    -0.02328552f, 0.03547834f, -0.00580197f, -0.02005249f, -0.04554649f, 0.05080222f, 0.00097503f, 0.08363240f, 
    -0.11438927f, -0.02505561f, 0.08269538f, -0.03022254f, -0.10632391f, 0.06281332f, -0.03823984f, 0.04345165f, 
    -0.01008679f, -0.07573823f, 0.04623742f, 0.00398102f, -0.01181409f, 0.05498760f, -0.01577057f, 0.02300010f, 
    0.12106257f, 0.03780113f, -0.03624408f, -0.01768832f, -0.20970137f, -0.15201801f, 0.12451144f, 0.04693320f, 
    0.09582643f, 0.10998020f, -0.04098953f, -0.01829343f, -0.08349503f, -0.02911110f, -0.03825315f, 0.02526847f, 
    -0.04884112f, 0.04968398f, -0.02681136f, 0.00323017f, 0.07566237f, 0.03255430f, -0.06442387f, -0.01940669f, 
    0.05342900f, 0.03366704f, -0.18884654f, -0.17736930f, -0.11729901f, 0.10374624f, 0.09392972f, 0.06153155f, 
    0.01772606f, -0.05878173f, -0.03235272f, 0.09628901f, -0.04863144f, -0.04841571f, 0.00476869f, 0.05296093f, 
    0.03139846f, -0.01331413f, 0.01808051f, -0.02104650f, 0.17144963f, -0.15803920f, 0.03624811f, 0.13471022f, 
    -0.11207593f, 0.07366230f, -0.15402092f, -0.07584479f, -0.06851246f, 0.05990886f, 0.09202047f, -0.01042818f, 
    0.08665856f, 0.05177082f, 0.03341051f, 0.04917750f, 0.04137703f, 0.05425755f, -0.09105795f, 0.07702652f, 
    -0.20341605f, 0.09684390f, 0.14824933f, -0.00126274f, -0.06288467f, -0.08598570f, -0.05346116f, -0.05553062f, 
    0.06959848f, 0.05534844f, -0.05519460f, -0.01950858f, 0.02419835f, 0.03093852f, 0.06979629f, 0.00577297f, 
    0.00828408f, 0.05464851f, -0.03230508f, 0.05879891f, 0.24742153f, 0.00178226f, 0.07076414f, 0.08927975f, 
    0.02130794f, -0.14612088f, -0.02070456f, 0.01123696f, -0.06933112f, 0.05330738f, -0.04947101f, -0.11323769f, 
    -0.04549555f, 0.04603854f, -0.01669966f, -0.05535687f, 0.04498509f, -0.01514518f, 0.09481569f, 0.00167487f, 
    0.04744504f, -0.02442029f, -0.15272686f, -0.13145423f, -0.05844270f, 0.10677543f, 0.15636799f, 0.03782473f, 
    0.03071408f, 0.01334795f, -0.01252248f, 0.03373513f, -0.04057278f, -0.00460250f, -0.08035082f, 0.04543794f, 
    -0.01587287f, 0.05224891f, -0.01268017f, 0.07880243f, -0.27147415f, 0.20098974f, -0.08550514f, 0.09691812f, 
    0.14517751f, -0.03419901f, -0.07901491f, 0.03662999f, 0.00460986f, -0.09422625f, 0.05649422f, -0.02479357f, 
    -0.01454828f, 0.09210923f, 0.02461020f, -0.00090222f, 0.04139582f, 0.04335247f, -0.06154107f, 0.04121367f, 
    0.15272039f, 0.18270062f, 0.22322047f, -0.20363389f, 0.30789351f, -0.11297737f, 0.06448925f, -0.04184427f, 
    -0.09762554f, -0.02751709f, 0.05235946f, 0.09258442f, 0.01162180f, 0.02543336f, 0.03337434f, 0.07493861f, 
    0.00609212f, 0.06014942f, -0.03400117f, 0.03163236f, 0.03971458f, 0.18823053f, 0.18785600f, 0.18627220f, 
    0.22423609f, -0.01049546f, 0.01743370f, 0.01736249f, -0.00024496f, 0.16875459f, -0.00227574f, 0.04893471f, 
    0.04321662f, -0.04535485f, 0.01130129f, 0.00719896f, -0.04528761f, 0.00970330f, 0.01784126f, 0.04539433f, 
    -0.04154775f, 0.00091828f, 0.11529786f, 0.00006150f, 0.15426140f, -0.11347433f, 0.01349682f, -0.10212881f, 
    -0.04763195f, -0.04025178f, 0.00357180f, 0.07578927f, 0.01847629f, -0.00222915f, 0.02675817f, 0.06029829f, 
    -0.02632288f, 0.02698551f, 0.03529349f, 0.03515645f, 0.03371005f, 0.36952510f, -0.04958219f, -0.05271599f, 
    0.23667625f, -0.03419332f, -0.00621420f, 0.04719798f, 0.01460631f, 0.05806131f, -0.03584043f, 0.03704938f, 
    0.04202630f, -0.05573367f, 0.00415561f, -0.05524391f, 0.08779719f, 0.00689362f, 0.01647875f, -0.01134579f, 
    0.19799010f, 0.15917681f, -0.06627844f, -0.18502745f, -0.02333217f, 0.11595735f, 0.16888613f, -0.01266994f, 
    -0.02352555f, -0.03427552f, 0.06599002f, -0.02756255f, -0.00699688f, 0.02378465f, -0.09701018f, 0.04572488f, 
    0.05936559f, 0.04624405f, 0.03335923f, -0.03425687f, -0.20470306f, 0.21314280f, 0.02380048f, -0.20180611f, 
    0.33411995f, 0.00352125f, -0.08218510f, 0.02496169f, 0.01940384f, 0.00843148f, 0.01449043f, -0.05989855f, 
    -0.04236571f, 0.03138763f, 0.07914879f, 0.02699925f, 0.08494560f, -0.07744989f, 0.03825676f, 0.03923478f, 
    0.08605690f, 0.31380686f, 0.02473513f, -0.44835195f, -0.19231275f, 0.17790003f, 0.03457974f, 0.00691888f, 
    0.00813866f, -0.11051811f, -0.12205792f, -0.02644828f, 0.03270284f, -0.07059950f, 0.03997459f, -0.06818447f, 
    0.01182201f, 0.10966070f, 0.11605552f, 0.11105687f, 0.18220851f, 0.23944618f, -0.16936520f, -0.16227412f, 
    -0.03877005f, 0.03376343f, 0.08014993f, 0.05158005f, -0.01842726f, -0.05433222f, 0.08885483f, -0.10384428f, 
    -0.00504581f, -0.00953429f, -0.17139761f, 0.03174845f, -0.10016996f, -0.02247400f, 0.04588050f, 0.05122603f, 
    -0.30543274f, 0.27137291f, 0.02252867f, -0.03243160f, 0.10309779f, 0.02049572f, -0.00640471f, 0.02391501f, 
    -0.02293118f, -0.04061463f, -0.07800712f, 0.02051932f, 0.11360054f, -0.03145673f, 0.01639178f, 0.15529557f, 
    0.10843231f, -0.04967438f, 0.04635619f, 0.03111777f, 0.16107242f, 0.03613234f, -0.13416487f, -0.05922995f, 
    0.20971642f, -0.02454352f, 0.00013981f, 0.11039304f, -0.02938637f, 0.05972913f, 0.03426316f, 0.03534934f, 
    0.03684758f, -0.04349224f, -0.05435645f, 0.11581966f, 0.09115458f, -0.06854423f, 0.17584230f, 0.08257320f, 
    -0.43609366f, 0.10291356f, 0.02662840f, 0.15151471f, -0.12816203f, 0.00072529f, 0.01122441f, -0.01819513f, 
    -0.09474899f, 0.12927996f, 0.01212079f, 0.10350775f, 0.05407469f, -0.03998467f, 0.09656873f, -0.00646008f, 
    -0.03308022f, 0.00214555f, -0.05860143f, -0.15250319f, -0.39382261f, 0.36029273f, 0.04024709f, 0.03353506f, 
    -0.22264177f, 0.10078978f, 0.03114535f, 0.09424330f, 0.07127628f, 0.13273418f, 0.06869576f, 0.02765160f, 
    0.04379982f, -0.01776046f, 0.00285468f, -0.05926283f, 0.02596697f, -0.00981006f, -0.08046857f, 0.01482932f, 
    -0.09825509f, 0.05805534f, 0.03561555f, -0.39823121f, 0.28931859f, 0.06559717f, -0.18569210f, 0.14163329f, 
    0.08902031f, -0.04061502f, 0.08457459f, -0.13313557f, -0.04364562f, -0.03952698f, -0.07045293f, -0.00423262f, 
    0.01526801f, 0.01481511f, 0.05023441f, -0.07056070f, -0.21535534f, 0.13802129f, 0.09809639f, -0.10835174f, 
    0.21964110f, 0.14983881f, -0.05874706f, 0.04630366f, 0.06089926f, 0.00315617f, 0.06182704f, 0.19117603f, 
    0.03546622f, -0.13534938f, 0.06832664f, 0.01151775f, 0.03219058f, 0.11584186f, 0.08829369f, 0.02050676f, 
    0.25665256f, -0.41135925f, -0.28159723f, 0.03674185f, 0.09639524f, -0.14249966f, 0.07318871f, -0.03204704f, 
    -0.07406343f, 0.11297436f, -0.11656962f, 0.00650764f, 0.13895120f, 0.05190756f, 0.13627446f, -0.02676727f, 
    -0.18824352f, -0.09586813f, -0.20604040f, -0.09526709f, 0.17108421f, 0.06839677f, -0.14077257f, 0.01743723f, 
    -0.17322917f, 0.02406395f, 0.16930684f, 0.05233556f, 0.09741481f, -0.04486522f, 0.15688670f, 0.02173951f, 
    0.07052517f, -0.01242098f, -0.08276387f, -0.07749787f, 0.04652796f, -0.05393043f, -0.13723575f, 0.12634867f, 
    0.02811466f, 0.05007949f, 0.03947804f, 0.08920484f, -0.11723641f, 0.05178307f, 0.01906345f, -0.11391829f, 
    -0.04715648f, 0.10744254f, 0.14100996f, 0.03880996f, 0.03544876f, -0.04211624f, -0.02848813f, 0.02813144f, 
    -0.02955534f, -0.02073769f, -0.02772101f, -0.11108958f, 0.07044947f, -0.06670608f, -0.35272905f, -0.02728437f, 
    -0.14193332f, -0.00610587f, 0.05798619f, -0.05127200f, 0.03427890f, 0.21375960f, -0.09599280f, 0.08451565f, 
    0.01287136f, 0.01672081f, 0.08964112f, -0.00736465f, -0.08110067f, -0.03095546f, -0.15113932f, -0.12182865f, 
    0.12023192f, 0.13149589f, -0.09152609f, -0.41792169f, 0.09175729f, -0.06086265f, -0.05767656f, 0.14280215f, 
    -0.07084294f, 0.13656554f, 0.08044478f, -0.07979234f, 0.01828115f, -0.02606234f, -0.00052346f, -0.03551781f, 
    -0.06371129f, 0.01780947f, 0.15005241f, -0.00598729f, 0.31536624f, 0.06462392f, 0.05437458f, 0.05345711f, 
    0.25548908f, -0.08541504f, 0.03851981f, 0.00253423f, 0.10540409f, -0.00969266f, -0.03198929f, -0.08120629f, 
    0.02795554f, -0.16547559f, 0.06802546f, 0.04400899f, 0.10553341f, -0.00356721f, 0.01046939f, 0.04398037f, 
    -0.00300953f, 0.23402303f, 0.17602153f, -0.00416160f, -0.16134229f, 0.15539894f, -0.02844841f, 0.05264730f, 
    -0.00323344f, -0.01511633f, 0.05259757f, 0.08958422f, -0.01800612f, 0.09560061f, -0.01065388f, 0.15332831f, 
    -0.03459487f, -0.13675858f, -0.07933930f, 0.05856739f, 0.40057305f, 0.09760214f, -0.03142210f, -0.11354648f, 
    0.10394679f, -0.20538187f, 0.05725764f, -0.01749349f, -0.03732036f, -0.17437109f, -0.09253280f, -0.03769415f, 
    -0.13356352f, 0.14930648f, 0.00660603f, -0.03453256f, -0.03371847f, 0.02321041f, -0.12308583f, 0.18619403f, 
    0.54628307f, -0.29872054f, 0.09706238f, 0.08030689f, -0.01368190f, 0.01426457f, 0.03718368f, 0.04873116f, 
    0.08969577f, 0.00276647f, 0.02398390f, -0.04025688f, 0.07986981f, 0.01463589f, -0.00752094f, -0.02258117f, 
    0.02009988f, 0.01979642f, -0.04806975f, 0.15561388f, 0.23408335f, 0.11816457f, -0.04093479f, -0.01741563f, 
    0.10386058f, 0.03060266f, 0.03438064f, 0.03299007f, -0.06542186f, 0.00227881f, -0.15084474f, 0.01436174f, 
    0.07661468f, 0.04874225f, 0.08071402f, 0.13762282f, 0.13669062f, -0.02988166f, -0.04828367f, 0.00902476f, 
    0.11406309f, -0.25465524f, -0.21025893f, 0.24014837f, -0.01091643f, -0.08758882f, 0.08708496f, 0.03336248f, 
    0.13633211f, 0.11839856f, -0.07549219f, 0.05560122f, -0.04087477f, -0.01757023f, -0.00985177f, -0.03665162f, 
    0.00868520f, 0.01837227f, -0.14878106f, -0.09103985f, 0.18842690f, -0.10333583f, -0.23699142f, 0.04604857f, 
    0.10730854f, -0.04403774f, 0.03143386f, -0.01173144f, -0.01285994f, 0.07894705f, 0.03154078f, 0.02291912f, 
    0.04175230f, -0.08188882f, 0.03600889f, 0.02571942f, 0.06533545f, 0.06536405f, -0.04190748f, -0.00028235f, 
    0.17744431f, -0.26984057f, 0.07838920f, -0.20036849f, 0.13994341f, -0.03023137f, -0.03584137f, -0.01458872f, 
    -0.10145937f, -0.01453704f, 0.00431142f, -0.06320696f, 0.11506376f, 0.08293401f, -0.01205018f, 0.02379980f, 
    -0.00831911f, -0.17866333f, -0.04566476f, 0.11747484f, -0.14324722f, 0.06989869f, 0.02231165f, -0.11418310f, 
    0.10413872f, -0.10554194f, 0.09671751f, 0.18529695f, -0.02085920f, 0.04450310f, 0.05398482f, -0.04581895f, 
    -0.09835211f, -0.07057057f, 0.03572407f, 0.00728419f, 0.03303667f, 0.03395543f, 0.13652638f, -0.07923446f, 
    0.29140687f, 0.05106268f, 0.09653703f, -0.03222712f, -0.07580418f, 0.11349230f, -0.00546265f, -0.02606736f, 
    0.00658686f, -0.04805767f, 0.13911948f, 0.00559689f, -0.06510139f, 0.03616799f, -0.09914850f, 0.10633662f, 
    -0.05031170f, -0.02480528f, -0.00580617f, -0.04027536f, -0.00078699f, 0.14131887f, -0.07533316f, -0.15063560f, 
    0.01099878f, 0.17978729f, -0.00846091f, 0.05748300f, 0.12166056f, -0.10730375f, 0.12230651f, 0.09919355f, 
    0.06122515f, -0.10597988f, -0.00840576f, 0.06995472f, 0.00097303f, 0.16295634f, -0.00578184f, 0.13973297f, 
    0.17300396f, -0.21232724f, 0.12018361f, -0.29783842f, 0.10273767f, -0.10547306f, -0.10034961f, -0.06490052f, 
    -0.08933387f, -0.07276326f, -0.04987505f, -0.06735371f, 0.04134199f, 0.01808649f, 0.02956540f, -0.11227472f, 
    0.05378380f, -0.15593053f, 0.03937049f, 0.09482498f, -0.02494562f, -0.41489395f, 0.06830214f, -0.06442218f, 
    -0.09805281f, -0.07569540f, 0.10670970f, -0.06328364f, -0.06819391f, 0.12589970f, -0.07169537f, -0.07812664f, 
    0.07943639f, 0.00275950f, -0.06162017f, 0.01650730f, 0.06252161f, -0.07978233f, -0.14816643f, -0.00365460f, 
    -0.35862967f, -0.13773927f, -0.24161299f, 0.19900680f, -0.03937824f, 0.06218553f, -0.01856687f, 0.04519225f, 
    -0.03605162f, 0.01281599f, 0.03161585f, -0.12225330f, -0.00550298f, 0.02347151f, -0.01065248f, 0.00192888f, 
    -0.04926087f, -0.14190990f, -0.02580774f, -0.02262777f, 0.12520409f, 0.04224054f, -0.04157246f, -0.15625244f, 
    0.11657954f, -0.07130312f, 0.03900504f, 0.08776392f, -0.01315294f, -0.08431918f, -0.05330240f, -0.08655448f, 
    -0.06212911f, -0.01034427f, 0.01102362f, 0.08624166f, 0.00296424f, 0.00052320f, 0.13483132f, 0.11900566f, 
    -0.25505283f, 0.12890229f, -0.15023501f, 0.22910556f, -0.24424358f, 0.20836407f, -0.01061387f, 0.01025338f, 
    0.06921683f, 0.05733006f, 0.10366560f, -0.03545159f, 0.06163672f, 0.11664704f, 0.03476366f, -0.03913180f, 
    0.09699847f, -0.09705714f, -0.08223365f, -0.03129908f, 0.04985755f, -0.41571596f, -0.06409477f, -0.09429612f, 
    0.04227412f, -0.02467214f, 0.07299607f, 0.06220412f, 0.04094059f, -0.07846618f, -0.01549124f, 0.02129525f, 
    -0.07449362f, -0.05327406f, 0.01003508f, -0.05109240f, -0.00820476f, 0.15503263f, -0.21477875f, 0.02604423f, 
    -0.08409210f, -0.07964269f, 0.24809137f, -0.05140720f, 0.13430092f, -0.06050438f, 0.05576749f, -0.04719792f, 
    -0.09327691f, -0.01646081f, 0.02981120f, 0.01026540f, 0.11068016f, -0.15885909f, 0.04962318f, 0.04235611f, 
    -0.01473686f, -0.01493791f, 0.08665914f, 0.04827150f, 0.24207261f, 0.00876391f, 0.00716652f, 0.07312740f, 
    -0.26745963f, -0.05093656f, 0.01460188f, -0.05093128f, -0.06451127f, -0.10442405f, -0.04011820f, 0.05871620f, 
    0.03612595f, 0.05178665f, -0.01218969f, 0.08246607f, 0.13118488f, 0.07677942f, -0.05496158f, 0.08967065f, 
    -0.03012218f, -0.18652822f, -0.05807609f, 0.14022098f, -0.01538859f, -0.16894537f, 0.02114978f, 0.03584331f, 
    -0.07635636f, -0.00820559f, 0.11782621f, 0.12240966f, 0.04563637f, -0.12916842f, -0.01318297f, -0.05844655f, 
    -0.10539193f, -0.06905854f, 0.25997233f, 0.04978738f, -0.21767786f, -0.08212274f, -0.19880208f, -0.02521895f, 
    0.05203523f, -0.04603246f, -0.04993701f, -0.05315561f, -0.03958770f, -0.03610652f, 0.01859100f, 0.03720436f, 
    -0.05611712f, -0.13478501f, 0.04026313f, -0.03152577f, 0.02397721f, 0.05810972f, 0.16293783f, 0.05358808f, 
    0.27026772f, -0.10045811f, -0.06103976f, 0.03086434f, -0.17057465f, -0.02367898f, -0.00000415f, 0.03722150f, 
    -0.00128305f, -0.03155728f, -0.04731130f, 0.03641757f, 0.07654384f, -0.11275454f, 0.10971592f, -0.02716209f, 
    -0.04662314f, 0.00679937f, 0.11497955f, -0.00742507f, 0.01323801f, -0.13697049f, 0.22692825f, 0.05362611f, 
    0.10993294f, -0.03819888f, 0.03402268f, -0.10807406f, 0.03051153f, -0.07001753f, 0.07156177f, -0.00083419f, 
    -0.03954578f, 0.00663716f, 0.00327382f, 0.00885838f, 0.04934331f, -0.01983284f, 0.01564157f, -0.04871998f, 
    0.14950098f, -0.02905123f, -0.09571275f, -0.22164874f, 0.03219658f, 0.04734055f, -0.02277291f, -0.10491311f, 
    -0.07221810f, -0.07708789f, 0.00088679f, 0.02285008f, -0.07421006f, -0.00852016f, -0.11880079f, -0.07944515f, 
    0.00964403f, -0.15854731f, -0.21828587f, 0.00608507f, 0.32911047f, -0.07700662f, 0.07192378f, -0.19049017f, 
    0.07587510f, -0.08977873f, -0.00358483f, -0.13541001f, -0.05049444f, -0.04654184f, 0.05379948f, 0.04246306f, 
    -0.01880665f, -0.15977751f, 0.03706004f, 0.01722078f, 0.08523236f, -0.13431938f, 0.00949630f, 0.05843420f, 
    0.30774209f, 0.17257939f, -0.25099298f, 0.22475561f, -0.15120102f, -0.03831862f, 0.10526825f, -0.08137397f, 
    -0.04218140f, -0.10218230f, 0.00468382f, 0.18191953f, -0.11729057f, 0.05310518f, 0.19030091f, 0.05635502f, 
    0.17343117f, 0.12146303f, -0.08512841f, 0.06718027f, 0.32682127f, -0.11593719f, -0.16318820f, -0.24862987f, 
    -0.16416411f, -0.00378675f, 0.00833866f, -0.06141075f, -0.09882181f, -0.00440329f, -0.07245569f, -0.00616761f, 
    -0.03343925f, -0.01155761f, -0.02535186f, 0.03534776f, 0.03442248f, -0.02291843f, -0.00876160f, 0.10953400f, 
    0.23163939f, 0.06993467f, 0.02238471f, -0.17756541f, 0.09775746f, 0.15682809f, -0.07570283f, -0.00988941f, 
    0.26940680f, 0.13327515f, -0.04589039f, 0.02018367f, -0.08748915f, 0.24674881f, 0.01387858f, -0.04318285f, 
    0.13492805f, -0.05394607f, -0.07613854f, -0.04170447f, 0.01246890f, 0.20303257f, 0.20484059f, -0.34592706f, 
    0.13520631f, -0.07697757f, -0.05461486f, -0.21155253f, -0.02296229f, -0.01661344f, 0.02593515f, -0.10374568f, 
    -0.07033507f, 0.15735482f, -0.02194847f, 0.12616615f, 0.10499652f, -0.01617293f, -0.13956451f, -0.05943009f, 
    0.12265927f, -0.01491741f, -0.03291424f, -0.10120653f, 0.11164559f, 0.02698390f, 0.06124488f, -0.14812134f, 
    -0.04261265f, -0.08182815f, 0.01097372f, -0.01586372f, -0.14795975f, -0.08236647f, 0.02136500f, 0.00122917f, 
    -0.08745373f, -0.08408976f, -0.08357004f, -0.06966992f, 0.37901446f, -0.01770585f, 0.04231679f, -0.05934028f, 
    0.18815914f, 0.11264604f, 0.11055747f, 0.00071539f, 0.05912011f, -0.01457497f, 0.08056223f, 0.01215583f, 
    -0.00671719f, 0.14639316f, 0.02537336f, 0.04914148f, 0.12698366f, -0.31095272f, -0.13741709f, 0.05912899f, 
    0.18129696f, -0.04752120f, -0.09516038f, 0.15708834f, -0.05748747f, 0.02071766f, 0.00641158f, -0.07561752f, 
    0.14265798f, -0.21473531f, -0.02050613f, 0.06630975f, -0.17651629f, -0.05033704f, 0.12518655f, 0.01004684f, 
    -0.07709225f, 0.09131788f, 0.03029246f, 0.16756831f, 0.00824600f, -0.01328010f, -0.09623376f, 0.05234890f, 
    -0.03537154f, 0.01457420f, -0.01471958f, 0.03141585f, -0.08907655f, 0.03279838f, -0.05279414f, 0.17153186f, 
    0.00449512f, 0.14110908f, -0.05317999f, 0.00923133f, -0.16209251f, -0.12934701f, 0.12502317f, 0.06528433f, 
    0.15360831f, -0.08929351f, -0.00671217f, -0.07436898f, 0.01484065f, -0.06833918f, -0.05970341f, -0.24106365f, 
    -0.09714662f, -0.01290521f, 0.06648743f, 0.07292042f, -0.09103928f, -0.11491383f, -0.00213092f, 0.02763427f, 
    0.05546235f, -0.02606432f, 0.06657854f, -0.10243536f, 0.29272008f, -0.07772184f, -0.09164716f, -0.04629005f, 
    0.10823989f, 0.14409310f, 0.05003119f, 0.03684568f, 0.21666752f, 0.12387882f, -0.20901582f, -0.01806259f, 
    0.03366101f, -0.00339566f, 0.09179116f, 0.09692985f, -0.11058734f, 0.08023494f, -0.06599351f, -0.09990690f, 
    -0.33113888f, 0.23001002f, 0.23008743f, 0.01971718f, -0.01359564f, 0.08063556f, 0.06100947f, 0.02628378f, 
    -0.02929603f, 0.05241487f, 0.06461270f, 0.03116545f, 0.06973173f, 0.05296918f, -0.04594425f, -0.13987321f, 
    -0.10797296f, 0.03474906f, 0.00840087f, -0.11568244f, -0.23884447f, -0.04313505f, 0.03770851f, 0.09182669f, 
    0.11235423f, -0.08045048f, 0.07981308f, 0.00170146f, 0.01920417f, 0.06788861f, 0.03890798f, 0.01818974f, 
    0.05367966f, 0.04109213f, 0.04142433f, 0.02915225f, 0.01327401f, -0.05438634f, 0.18184532f, 0.01716590f, 
    0.24129078f, 0.16361555f, 0.08071000f, -0.25332895f, 0.00861407f, 0.18597569f, 0.11840734f, 0.09169640f, 
    -0.01319491f, -0.02975734f, -0.03569852f, -0.02577831f, 0.17574224f, 0.08131734f, -0.12393613f, 0.06294698f, 
    0.01476689f, -0.25515476f, -0.00328120f, -0.04188232f, 0.30331597f, 0.18549588f, 0.32783589f, 0.06997801f, 
    0.09515048f, 0.06149316f, 0.08744019f, 0.05282919f, -0.00079190f, 0.03561867f, -0.10677873f, -0.04191007f, 
    0.04687385f, 0.03409188f, -0.00913200f, 0.12552834f, -0.04758820f, -0.24710348f, 0.06736984f, -0.01585486f, 
    -0.17535149f, 0.29764557f, 0.03911044f, 0.21722434f, -0.02489094f, 0.03461997f, -0.00609271f, 0.06642745f, 
    0.14961068f, 0.15992518f, -0.05889726f, -0.06771361f, 0.04179411f, 0.08567760f, 0.04990705f, 0.00878424f, 
    0.15485647f, 0.00454243f, 0.13698898f, -0.06482697f, 0.16958992f, 0.07104666f, -0.04824577f, 0.09296972f, 
    0.14454468f, -0.09029982f, 0.03568532f, -0.08865874f, 0.01925803f, -0.03377356f, -0.03788071f, 0.02722245f, 
    -0.02137876f, -0.00429649f, 0.02185243f, -0.01218505f, 0.11162689f, -0.15316918f, 0.07083444f, -0.02449848f, 
    -0.00718876f, -0.07667327f, -0.04645266f, -0.02341579f, 0.17970084f, -0.03953057f, -0.00153377f, -0.18079647f, 
    0.04747904f, 0.01449865f, 0.01541172f, 0.06355874f, -0.06519490f, -0.14311166f, -0.03116831f, -0.04182530f, 
    -0.04979870f, 0.02867531f, 0.11497939f, -0.09955996f, 0.02583988f, 0.01224803f, -0.03162405f, 0.14028947f, 
    -0.10979982f, -0.13428171f, 0.00080667f, -0.10757171f, -0.05686037f, 0.08812942f, 0.03216504f, 0.06632295f, 
    -0.08841125f, 0.03716784f, 0.10754284f, -0.01844353f, 0.03227541f, 0.11086720f, 0.16900313f, 0.04908237f, 
    -0.12643795f, 0.14048187f, -0.04322620f, 0.21780400f, 0.04255802f, 0.06694967f, 0.06264676f, -0.00816371f, 
    0.14225076f, 0.19520023f, -0.00464753f, -0.01954711f, 0.14356312f, 0.02613710f, 0.02786355f, 0.12122554f, 
    0.05929578f, 0.06172236f, 0.02603157f, 0.01197818f, -0.27967170f, 0.23942536f, -0.13494129f, -0.09826948f, 
    -0.07063090f, 0.18506357f, -0.02398055f, -0.00549682f, -0.13780847f, -0.00273314f, 0.08893064f, 0.16032043f, 
    -0.03382441f, 0.15730622f, 0.04130939f, -0.00302947f, -0.05118480f, 0.00017343f, -0.38401404f, -0.03645387f, 
    0.08745017f, 0.14922111f, 0.02727107f, 0.05082607f, -0.03294012f, 0.19815181f, 0.03625837f, 0.08355070f, 
    -0.04054742f, -0.17003655f, 0.04984591f, 0.06015312f, 0.12319448f, 0.10326378f, 0.19919401f, 0.07513893f, 
    0.09513208f, 0.06272149f, -0.22578661f, 0.00172753f, -0.09141169f, -0.11017549f, 0.00010169f, 0.08531114f, 
    0.00514648f, -0.08870976f, 0.02121550f, -0.11238066f, 0.04598357f, -0.00216073f, -0.03118257f, 0.13414857f, 
    -0.03084368f, 0.06870292f, -0.00728680f, 0.14795503f, 0.06920393f, 0.05595472f, 0.03219222f, 0.01802349f, 
    0.13738905f, -0.19054021f, 0.12872192f, -0.23030041f, 0.08789662f, -0.05433474f, 0.15697543f, 0.05094612f, 
    -0.02405411f, -0.04018651f, -0.06614865f, 0.01531465f, 0.07221780f, -0.03831405f, -0.05785560f, 0.00910855f, 
    -0.00218281f, -0.27676508f, -0.09758317f, -0.06003024f, 0.08878620f, 0.33647531f, 0.02968137f, 0.00052099f, 
    -0.12548620f, 0.10340378f, -0.03603945f, 0.06746677f, 0.02505991f, -0.03488441f, 0.04098699f, 0.05785784f, 
    0.02422365f, 0.13972320f, 0.18214811f, 0.01603363f, 0.04627443f, 0.13499181f, -0.27807295f, -0.03128774f, 
    -0.40415215f, 0.00986780f, -0.07517250f, 0.19575776f, 0.22971986f, 0.09125564f, 0.11975033f, 0.12987739f, 
    -0.04782714f, 0.06984998f, -0.03805362f, 0.10175735f, 0.00930094f, -0.16016586f, 0.00655307f, 0.06294877f, 
    0.04489757f, 0.00927229f, -0.00149182f, 0.03279085f, -0.11234400f, 0.06775501f, 0.06893262f, 0.13443111f, 
    -0.06759660f, 0.07639211f, 0.04177135f, 0.11895658f, -0.03652584f, 0.11442977f, 0.04093931f, 0.11583652f, 
    -0.13901863f, -0.03280458f, 0.01108301f, 0.03419199f, 0.00756606f, 0.07814736f, 0.10956608f, 0.05014570f, 
    0.14458781f, 0.11732228f, 0.02356524f, 0.33523476f, -0.00872024f, -0.04278946f, 0.00418128f, 0.08857862f, 
    -0.04281944f, 0.09298374f, 0.02454886f, -0.04764544f, 0.13529044f, -0.02560883f, -0.05652227f, -0.10200944f, 
    0.05243445f, 0.03574646f, 0.30682075f, -0.10367959f, 0.05393875f, 0.39803270f, 0.02995265f, 0.21040311f, 
    -0.02643616f, 0.04020877f, 0.03839747f, 0.04627522f, 0.11383545f, 0.06062956f, 0.06110529f, 0.01754508f, 
    -0.00666597f, -0.09278604f, -0.05362054f, -0.07029548f, 0.19105129f, 0.05893382f, 0.18329363f, 0.04451110f, 
    0.16916798f, 0.18102488f, -0.04268090f, -0.09806217f, 0.04908181f, 0.07351663f, 0.11942952f, 0.06204900f, 
    0.09133191f, 0.00078989f, -0.03164960f, 0.10503875f, 0.05695394f, -0.08347414f, 0.12245419f, -0.02550798f, 
    0.09146609f, 0.08480295f, 0.15486464f, -0.04428104f, -0.03528138f, 0.41742757f, 0.10304959f, 0.21673769f, 
    0.06985422f, 0.08609891f, 0.02079877f, 0.03174023f, 0.07238963f, 0.08884428f, 0.04094055f, -0.06469055f, 
    0.00228935f, 0.00845669f, -0.06793090f, 0.06202610f, 0.04113031f, -0.00633807f, -0.04862333f, 0.09560519f, 
    -0.29911193f, -0.33041888f, -0.11334199f, -0.21647407f, -0.10117970f, -0.06396928f, -0.14144531f, -0.02368504f, 
    0.12489092f, 0.04412767f, 0.02758329f, 0.02325742f, -0.00367588f, 0.04425088f, 0.04039879f, 0.05447832f, 
    0.01659820f, -0.01513529f, -0.11736620f, 0.02754157f, -0.02005899f, -0.36981952f, -0.16389814f, -0.18195789f, 
    -0.02591195f, -0.06120738f, -0.04251268f, 0.09045143f, -0.04173329f, 0.08098928f, 0.03060739f, 0.06506132f, 
    0.00584046f, 0.07342274f, -0.01057185f, 0.07048087f, 0.06476393f, -0.07229052f, -0.03891740f, 0.06088349f, 
    0.40184590f, 0.16934197f, -0.06879117f, 0.17996441f, 0.00059329f, 0.04868668f, 0.01659161f, 0.00506133f, 
    -0.14715949f, 0.04335208f, -0.02345253f, -0.00820880f, -0.06815291f, -0.01844237f, 0.12538412f, 0.10478623f, 
    -0.01756349f, 0.18497130f, 0.01845314f, -0.04951475f, -0.09339785f, -0.12316447f, -0.00343335f, 0.16452025f, 
    0.03570575f, 0.08778283f, 0.13940589f, 0.06254344f, 0.03597314f, 0.07459404f, -0.03705261f, 0.12525132f, 
    -0.01389142f, 0.04678544f, 0.00188049f, 0.02536859f, -0.12885498f, 0.08006877f, 0.09202493f, 0.02854231f, 
    -0.14479193f, 0.04021618f, -0.25327453f, 0.11132862f, -0.08728164f, -0.03812872f, -0.04709288f, 0.12249278f, 
    0.23825003f, 0.09147356f, -0.14140184f, 0.11012788f, 0.03613076f, 0.29127404f, 0.17096402f, -0.04831453f, 
    0.00002142f, 0.04507897f, -0.02384826f, 0.05401390f, 0.38925493f, 0.17770691f, -0.11629544f, -0.11151372f, 
    0.10412175f, 0.05377541f, -0.00099341f, 0.04825859f, 0.02937537f, -0.01113747f, -0.00968235f, 0.06937899f, 
    -0.07409997f, 0.11898878f, -0.16247331f, 0.01949938f, 0.01727140f, 0.02383098f, -0.01904975f, 0.06015450f, 
    -0.36883590f, -0.21228744f, 0.05503319f, -0.21602236f, 0.03253594f, -0.11938674f, 0.01084434f, 0.02541381f, 
    0.01576331f, 0.01092837f, -0.02199416f, 0.00853542f, 0.03378075f, 0.05898801f, 0.11283195f, 0.02588426f, 
    0.04652639f, -0.00524623f, -0.11608768f, 0.00714976f, -0.30411446f, 0.00223941f, -0.16110842f, -0.21591625f, 
    -0.11781465f, 0.04110884f, 0.09866295f, 0.05198729f, 0.07856862f, 0.03338105f, 0.04055525f, 0.03338020f, 
    0.03381900f, 0.01829994f, 0.03861974f, -0.01315022f, 0.02202694f, -0.07357266f, -0.06350054f, 0.13998227f, 
    0.34177437f, 0.05714241f, -0.05601838f, 0.22693710f, -0.08567069f, -0.14430535f, -0.08084796f, 0.04506929f, 
    -0.01320514f, -0.07172454f, -0.01494563f, 0.05537102f, -0.05881596f, -0.06295118f, 0.01821707f, 0.02424241f, 
    -0.02596938f, 0.06362685f, 0.05436750f, 0.11604309f, -0.17032370f, 0.41465342f, 0.20873451f, 0.32528150f, 
    0.06873599f, -0.02853084f, 0.12574424f, 0.07782441f, 0.15861246f, 0.01051294f, 0.07806155f, 0.07986671f, 
    0.14651312f, 0.00012878f, 0.00898499f, 0.06223857f, -0.06964761f, 0.02039761f, 0.10395650f, -0.07639041f, 
    -0.21660420f, 0.15545516f, -0.15141574f, -0.10191561f, -0.00723224f, -0.03727921f, -0.07430530f, -0.00825704f, 
    0.07464454f, 0.03621964f, 0.12581010f, 0.08652736f, -0.08075902f, 0.02528060f, -0.07113023f, 0.03193125f, 
    0.09810877f, -0.06390980f, -0.04969592f, 0.09800656f, 0.53944260f, 0.47305480f, -0.25331959f, 0.12593932f, 
    0.22886337f, 0.09149560f, -0.05570241f, 0.01410812f, 0.17853501f, 0.03398542f, -0.10934777f, -0.06825824f, 
    -0.06296217f, 0.01180317f, 0.00591731f, -0.05755384f, -0.01419352f, 0.08092348f, 0.02354167f, 0.15005141f, 
    0.25477093f, 0.04148029f, 0.02685213f, -0.03320387f, -0.09603842f, -0.06967378f, 0.00543602f, 0.08169500f, 
    -0.00067072f, 0.10130981f, -0.05293952f, -0.00130499f, 0.01813289f, 0.09640189f, -0.03675563f, -0.02512067f, 
    0.00809604f, 0.14130677f, 0.11461514f, 0.00186219f, -0.14463525f, 0.48457682f, 0.08520855f, 0.25090653f, 
    0.09685872f, -0.01165220f, -0.01818601f, 0.05633532f, 0.07810595f, 0.02461794f, 0.02221977f, -0.00092815f, 
    -0.00731058f, -0.01016080f, 0.05001185f, 0.08914620f, 0.03354231f, 0.02110908f, 0.04123107f, 0.03220593f, 
    -0.07501233f, 0.13665076f, 0.09820899f, -0.26906040f, -0.17395027f, 0.01792102f, 0.09633593f, 0.06569885f, 
    -0.04182676f, 0.06026653f, -0.08395764f, 0.05532309f, 0.07886799f, -0.02094513f, 0.04670884f, -0.04897601f, 
    0.01162366f, -0.04944844f, 0.06926803f, 0.03475975f, -0.04900963f, 0.56268376f, 0.09992772f, -0.15496877f, 
    -0.06776489f, 0.04140280f, 0.07580207f, 0.04936401f, 0.00211442f, 0.18135677f, -0.10526945f, 0.08155651f, 
    0.04670750f, -0.02836480f, -0.04941858f, 0.02480223f, -0.02948840f, 0.01420326f, 0.02713672f, 0.12303786f, 
    0.23376785f, 0.10271310f, 0.00539229f, 0.20105261f, -0.08051598f, -0.05373510f, -0.10114354f, -0.03255455f, 
    0.14018340f, 0.06869141f, -0.00916961f, 0.04703255f, 0.02782280f, 0.08805104f, 0.01661371f, 0.02978113f, 
    0.04791586f, 0.10304981f, 0.06749409f, -0.00292604f, -0.39569050f, 0.38190952f, -0.08552666f, 0.04755992f, 
    -0.02107133f, 0.11882575f, 0.16192748f, -0.07210724f, 0.14443490f, 0.02487431f, -0.05690802f, -0.07717897f, 
    -0.05015543f, 0.06838578f, 0.09603777f, 0.11278565f, 0.06016280f, -0.03238714f, 0.11273655f, 0.06724522f, 
    -0.39811450f, 0.07354046f, 0.02831417f, -0.05922503f, 0.13098325f, -0.07786627f, 0.04683717f, -0.00154723f, 
    0.03313443f, 0.07295277f, 0.04442093f, 0.03692146f, -0.08610401f, -0.06083499f, 0.07700104f, -0.03631453f, 
    0.05655777f, -0.01001254f, -0.04724002f, 0.07493930f, 0.11608995f, 0.02126316f, 0.11874321f, 0.27253732f, 
    0.16606443f, 0.09526356f, 0.20082738f, -0.02684331f, -0.04274359f, 0.03780253f, 0.05662978f, 0.06752107f, 
    0.01886734f, -0.09673375f, 0.09861459f, 0.05915241f, 0.10254912f, 0.08712652f, 0.05339712f, -0.05381430f, 
    0.34034416f, 0.10264992f, 0.03677984f, 0.12054747f, -0.11871027f, -0.02998311f, -0.09194538f, -0.04338223f, 
    0.16571379f, 0.09295659f, -0.05386472f, -0.01130257f, 0.17646076f, -0.01501271f, 0.01055641f, -0.01715671f, 
    0.07880944f, -0.00611998f, 0.15764470f, -0.04064969f, -0.52169716f, -0.14520900f, -0.20543759f, -0.07487908f, 
    -0.18218754f, 0.05150994f, -0.07118024f, -0.02728512f, 0.08455924f, -0.05309001f, 0.06123050f, 0.05289569f, 
    0.10561738f, 0.11969123f, 0.00052552f, 0.00378609f, -0.01863131f, 0.12018037f, -0.08020921f, 0.07626884f, 
    -0.00004173f, -0.43573990f, -0.09914823f, 0.13113926f, 0.13383628f, 0.02309641f, -0.11427031f, 0.07131664f, 
    0.05541489f, 0.06558937f, -0.07399598f, -0.01058513f, 0.10109735f, 0.16480029f, 0.06486375f, 0.01881347f, 
    0.09048653f, -0.03590355f, -0.12019154f, 0.06065679f, 0.19036961f, 0.29425451f, 0.17479318f, 0.27247700f, 
    -0.02663207f, 0.13088420f, -0.00825407f, 0.03687901f, 0.03190896f, 0.04855590f, -0.04018791f, -0.04140982f, 
    -0.03223785f, 0.01575132f, -0.06658056f, 0.09969345f, -0.09240595f, 0.05452925f, 0.05471997f, 0.06532382f, 
    -0.28085333f, -0.42939138f, 0.01696008f, -0.29781544f, 0.09593657f, -0.09154519f, 0.02813203f, 0.11650696f, 
    0.02873311f, 0.04127147f, -0.05561563f, 0.04648053f, 0.01487627f, 0.09482910f, 0.03604560f, -0.10214957f, 
    0.07923082f, -0.08217710f, -0.05686368f, 0.11798936f, -0.27308443f, -0.24787809f, 0.01020640f, 0.10586744f, 
    -0.02708064f, 0.10386383f, -0.11722266f, 0.00677748f, 0.15208453f, -0.04521482f, -0.10963145f, -0.11754656f, 
    0.04044975f, 0.05586723f, 0.10863266f, 0.12587655f, -0.00217019f, 0.05225414f, -0.17284349f, 0.12210774f, 
    -0.03439669f, -0.00931470f, -0.00960860f, -0.00228938f, -0.01257468f, 0.01564713f, -0.02387935f, 0.03189571f, 
    -0.01692920f, -0.02967946f, -0.01823042f, -0.00824840f, 0.03035225f, 0.00404493f, -0.03363398f, -0.02722818f, 
    -0.02564760f, 0.03224563f, 0.03400937f, -0.02871846f, -0.00640501f, -0.01723388f, -0.02181531f, -0.02623559f, 
    -0.03465106f, 0.01512549f, -0.02640839f, -0.03408379f, 0.00222735f, 0.01130451f, 0.00184682f, -0.01284858f, 
    -0.01000374f, 0.01979129f, 0.00417146f, 0.03388863f, 0.00021361f, -0.04067695f, 0.01544208f, 0.02669369f, 
    0.01963569f, -0.01181141f, -0.03556606f, 0.01855623f, 0.02290321f, 0.01915584f, -0.01649509f, -0.04421623f, 
    0.02610709f, 0.02440699f, -0.03052099f, -0.04350632f, 0.01219323f, 0.02874927f, -0.03787727f, 0.01831729f, 
    0.00713760f, 0.02663044f, -0.02443931f, 0.02224596f, 0.00205857f, -0.00099975f, -0.01973705f, -0.04852446f, 
    0.01770145f, -0.02270813f, -0.04214588f, 0.01829499f, 0.03413348f, -0.04039248f, -0.03784281f, 0.01667220f, 
    -0.00805761f, 0.01975746f, -0.00628601f, -0.02331097f, -0.01959768f, 0.01045837f, 0.01904916f, -0.02395439f, 
    -0.01134839f, -0.01410580f, -0.01820050f, -0.03085937f, 0.01245114f, 0.02598137f, 0.01511524f, 0.00067010f, 
    0.01599657f, 0.00490237f, 0.01483647f, -0.03746761f, 0.01965631f, -0.02235613f, 0.02419471f, 0.00694711f, 
    0.03082647f, -0.02974844f, -0.03731612f, 0.00345554f, -0.04514200f, 0.01880780f, -0.00003424f, 0.01993925f, 
    -0.03020450f, 0.02372868f, -0.03885109f, 0.03367991f, -0.01547811f, -0.00930641f, 0.02975679f, -0.01585012f, 
    -0.03338633f, 0.02774764f, -0.00159645f, 0.01457079f, -0.03132145f, 0.00199949f, -0.01978628f, 0.00942852f, 
    0.00238153f, 0.00689302f, 0.00381200f, 0.00366504f, 0.03348116f, -0.03185702f, -0.03929730f, 0.02187960f, 
    0.02636252f, 0.00733762f, -0.03312802f, 0.01598223f, 0.01830896f, -0.02532220f, -0.04408330f, -0.01560509f, 
    0.03354615f, -0.02282986f, -0.01024822f, 0.02888695f, 0.02109479f, 0.01176930f, -0.01526886f, 0.03045528f, 
    -0.00123636f, 0.02909860f, -0.02481870f, 0.03089759f, -0.03328598f, 0.01633469f, -0.04653543f, 0.02584314f, 
    -0.04243971f, 0.01361357f, -0.02599790f, 0.00055787f, 0.00061310f, -0.03236115f, 0.00386439f, -0.00573832f, 
    0.02073349f, -0.05226653f, 0.00883664f, -0.04684287f, 0.02358278f, 0.02778466f, 0.01514996f, 0.00131632f, 
    -0.03506504f, -0.01492208f, -0.02014765f, 0.02138455f, 0.01587425f, 0.02094603f, 0.02594971f, -0.02856576f, 
    0.00959856f, -0.01007011f, 0.02637798f, 0.00982993f, 0.01335148f, 0.02566652f, -0.00980811f, 0.02630505f, 
    -0.03245679f, -0.03435356f, -0.01922427f, -0.00933874f, -0.04449339f, 0.01342599f, 0.01150865f, 0.00446920f, 
    0.03350039f, -0.02716746f, 0.00249133f, 0.01355402f, -0.00835805f, 0.03704428f, 0.03336279f, -0.03584602f, 
    -0.02796382f, 0.01555013f, -0.04356842f, -0.01958369f, -0.00541362f, 0.01738467f, 0.02454621f, -0.02813210f, 
    -0.02434000f, 0.00777226f, -0.01876449f, 0.02396319f, -0.01101391f, -0.03149273f, -0.02561945f, -0.02506909f, 
    -0.02413004f, 0.02436327f, -0.01868533f, 0.00706257f, 0.00853660f, -0.02465112f, 0.02251956f, -0.01715963f, 
    -0.03994545f, 0.02637849f, -0.03203814f, -0.03624186f, 0.03344765f, -0.01936436f, -0.02542906f, 0.00016173f, 
    0.01525687f, -0.02725473f, -0.02868034f, 0.00359531f, -0.02607095f, 0.03046521f, 0.01617071f, 0.00149300f, 
    -0.03494202f, -0.00087394f, -0.02360664f, 0.02469300f, -0.01204009f, 0.02667033f, 0.02736052f, 0.01547354f, 
    -0.02265007f, -0.00401986f, 0.01138893f, -0.00311834f, -0.00492612f, -0.03461292f, 0.00853846f, -0.03398594f, 
    0.02637294f, 0.02703083f, 0.02978860f, 0.00329538f, 0.00136178f, -0.02189294f, -0.03666927f, 0.03505174f, 
    -0.01694460f, 0.00724474f, 0.02118609f, -0.02525589f, 0.00136603f, -0.02460723f, 0.00087556f, -0.02773273f, 
    -0.00999569f, 0.01960181f, 0.00343988f, 0.00968969f, 0.00755787f, 0.01297312f, -0.03341988f, -0.01967856f, 
    -0.02993059f, -0.03991146f, -0.01361304f, -0.02300324f, 0.01640886f, 0.01835702f, 0.01267768f, 0.01937311f, 
    -0.00046130f, 0.01442290f, 0.00285442f, -0.03922099f, 0.01833420f, 0.00710359f, 0.02362144f, -0.00921795f, 
    0.01583062f, -0.01537650f, -0.00409717f, 0.01296925f, 0.02398469f, -0.04820580f, 0.01484937f, -0.03969820f, 
    -0.01643823f, -0.00451489f, 0.00478900f, 0.01380531f, 0.00190597f, -0.00255501f, -0.02920976f, -0.02915150f, 
    -0.02584961f, 0.00765214f, 0.00089163f, -0.01732136f, -0.00069857f, 0.00779346f, -0.01743392f, -0.04498357f, 
    0.01688845f, 0.01622110f, 0.02870932f, 0.03465141f, 0.02095808f, 0.01736153f, -0.03158582f, -0.00149948f, 
    -0.00459633f, -0.02175272f, -0.01467321f, -0.02428468f, -0.01768055f, -0.03668285f, -0.02800845f, -0.02796266f, 
    0.01430806f, 0.01025712f, 0.00622066f, 0.01980029f, -0.04265433f, -0.04006866f, 0.01690077f, 0.02643202f, 
    -0.02644781f, -0.01882404f, 0.00655124f, -0.04003978f, -0.00492510f, 0.02977901f, -0.01417218f, -0.03896861f, 
    0.01426119f, 0.03631879f, 0.00501950f, 0.00499750f, -0.02837145f, 0.01811849f, 0.01590357f, 0.00069270f, 
    -0.00710157f, -0.01133805f, -0.00576650f, 0.02837235f, -0.02900891f, 0.01359588f, 0.00849908f, -0.01844362f, 
    -0.04058749f, -0.00610185f, -0.01159254f, 0.03367478f, -0.02568169f, -0.00344994f, -0.02437847f, -0.03791277f, 
    -0.00063615f, 0.02581551f, -0.04275601f, -0.02170194f, 0.01635847f, -0.03240968f, 0.02778589f, -0.03508655f, 
    0.00673140f, -0.00122396f, 0.02183813f, 0.01161507f, 0.02944928f, 0.01636407f, -0.01912765f, -0.03376162f, 
    0.03040259f, 0.02693125f, -0.02732097f, -0.03108753f, -0.02075696f, -0.03505114f, -0.03637482f, 0.00337652f, 
    0.02707969f, 0.01948709f, -0.01442565f, -0.04047222f, 0.02094303f, -0.04413665f, -0.03098158f, -0.03823890f, 
    0.01528841f, -0.03900968f, 0.00168924f, 0.02199341f, -0.02709519f, 0.00006119f, -0.04570024f, -0.01444621f, 
    0.00242673f, -0.00197401f, 0.00413182f, -0.00157416f, 0.02528533f, -0.00452723f, -0.02542820f, 0.01151461f, 
    -0.03182353f, -0.04554782f, -0.01511210f, 0.03121303f, -0.03445877f, -0.03679600f, 0.01828919f, -0.03632580f, 
    -0.02536041f, 0.01754696f, -0.03997680f, -0.03504938f, -0.03321540f, 0.01368766f, -0.01249903f, -0.03518907f, 
    -0.01028583f, 0.01009012f, -0.03414328f, 0.00244268f, 0.00288392f, 0.01308464f, -0.01723210f, 0.01397139f, 
    -0.01908444f, -0.00031650f, -0.00154357f, -0.01433138f, -0.00836502f, -0.02071801f, -0.03586784f, -0.01315272f, 
    -0.00923794f, 0.02114943f, 0.01327817f, -0.02840720f, 0.03374543f, 0.00496644f, -0.02292113f, 0.00709611f, 
    -0.01825265f, -0.02719427f, -0.01961520f, 0.02366859f, 0.03499543f, 0.03171790f, -0.02542185f, 0.01662207f, 
    0.02814496f, 0.00424883f, -0.01618005f, 0.01272522f, -0.02016513f, -0.03362618f, -0.02790004f, -0.03383965f, 
    0.00725943f, -0.01060501f, -0.01566211f, 0.01859176f, -0.04078041f, -0.01690908f, -0.01815219f, -0.01519453f, 
    0.02469959f, 0.03294522f, -0.00604466f, 0.00561367f, 0.02976278f, -0.01236263f, -0.02119802f, 0.01146069f, 
    0.01428653f, -0.02152823f, -0.01195476f, -0.04558207f, 0.01993277f, 0.02230659f, 0.02826994f, -0.03923730f, 
    -0.01198661f, 0.02902642f, 0.02351039f, 0.02828844f, -0.03313930f, 0.03160207f, 0.02516397f, -0.00565424f, 
    0.02913435f, -0.01066441f, -0.00691748f, 0.00477858f, 0.00466411f, -0.02741922f, 0.02150746f, 0.01503409f, 
    -0.01103854f, 0.00708123f, 0.02333345f, -0.05012360f, -0.04006591f, 0.00848565f, -0.00719071f, 0.00742150f, 
    -0.01099021f, 0.00820688f, 0.01719728f, -0.02875210f, -0.04334855f, -0.04000979f, -0.02629374f, -0.03036094f, 
    0.03198444f, -0.03809874f, -0.04225650f, -0.00122587f, 0.02362471f, -0.00495176f, -0.02294912f, 0.01592925f, 
    0.01784204f, -0.01466683f, -0.01849155f, 0.00921536f, -0.00729978f, 0.01251535f, -0.00325703f, 0.01369489f, 
    -0.03279888f, -0.03980517f, 0.01559966f, -0.02202967f, 0.03578312f, -0.02600044f, 0.02907896f, 0.02986277f, 
    -0.00376531f, -0.00822960f, -0.00425158f, -0.03753109f, -0.03008842f, -0.03701943f, 0.01337202f, 0.00415175f, 
    -0.02536152f, 0.01288451f, 0.02964468f, -0.02009737f, -0.01931319f, -0.00663299f, -0.02310587f, -0.02866047f, 
    -0.01295776f, 0.01524692f, 0.00426251f, -0.03657178f, -0.01601818f, 0.02923829f, -0.04705707f, -0.04016725f, 
    0.01766152f, -0.01084014f, -0.00850371f, 0.02886169f, 0.00210961f, 0.01950065f, -0.00437995f, -0.02130026f, 
    0.01177251f, -0.03081852f, 0.02090580f, -0.04068419f, 0.02009083f, -0.00367080f, -0.02596105f, 0.01727828f, 
    0.03236768f, 0.03397857f, -0.01092579f, 0.03046133f, -0.01657028f, 0.01491513f, 0.02428104f, 0.02047472f, 
    -0.03611087f, 0.02716596f, 0.02189235f, -0.02114468f, -0.03933028f, -0.02794060f, -0.03986086f, 0.00038223f, 
    0.00361135f, 0.01676655f, 0.00272480f, -0.02521555f, -0.01345523f, -0.00023008f, 0.02871182f, -0.01503819f, 
    0.02559762f, -0.02389956f, -0.01024359f, 0.00133140f, -0.03903504f, 0.02110455f, 0.00389590f, -0.03177364f, 
    0.03355253f, -0.00302039f, 0.01134701f, -0.00438590f, -0.03816308f, -0.01596421f, -0.02688923f, -0.04221972f, 
    0.01363928f, 0.01763023f, 0.00500863f, -0.04382632f, -0.02950714f, -0.03325865f, -0.01481201f, 0.02890966f, 
    -0.00549904f, -0.02899498f, -0.00445407f, 0.03387696f, 0.01337530f, -0.02064614f, 0.00583712f, -0.01537231f, 
    -0.02187698f, -0.03560689f, 0.02725889f, -0.02276913f, 0.02843221f, -0.01695180f, 0.01006571f, -0.03641801f, 
    -0.03749631f, -0.04264773f, 0.03224412f, -0.01070477f, 0.02450118f, -0.01582374f, 0.03258650f, 0.02622188f, 
    -0.04037150f, -0.01406578f, 0.01844095f, 0.00137437f, 0.00107024f, -0.03659070f, 0.01511045f, -0.00473248f, 
    -0.01925469f, 0.00391513f, -0.00161461f, -0.01632253f, -0.01247233f, -0.03628131f, 0.02392806f, 0.03819548f, 
    0.01108168f, 0.01691465f, -0.00887016f, 0.02298045f, -0.03953492f, -0.00177059f, -0.02095595f, -0.01636585f, 
    0.00218953f, 0.00201993f, -0.04678980f, -0.02314846f, -0.01372199f, 0.00492704f, -0.01653501f, 0.01267440f, 
    -0.02269218f, -0.00850412f, -0.01870058f, -0.00459338f, -0.02580098f, 0.01589176f, 0.00565153f, 0.02678745f, 
    0.01419855f, 0.02893768f, -0.03260128f, -0.02504072f, -0.04424360f, -0.03497762f, -0.01069588f, -0.01282688f, 
    -0.02654181f, 0.02339885f, -0.03030527f, 0.00493244f, -0.03641945f, 0.03262491f, -0.00730776f, -0.02382239f, 
    -0.02202723f, 0.02253856f, 0.02429174f, -0.03355260f, -0.03173642f, 0.02549354f, 0.00544831f, 0.02937791f, 
    0.02448503f, -0.04393917f, -0.00843014f, -0.00594113f, -0.00795539f, 0.00134490f, -0.03217582f, 0.02575275f, 
    -0.01320794f, -0.01810584f, -0.01616489f, -0.04343871f, 0.01705977f, 0.00901066f, 0.02856542f, 0.03080559f, 
    -0.03138606f, -0.01037855f, 0.02163835f, -0.01494551f, 0.02245577f, 0.00593865f, -0.02434609f, -0.03252338f, 
    -0.03750497f, -0.00257265f, 0.02762629f, -0.00516193f, -0.02720102f, -0.03249802f, -0.01861218f, 0.01180923f, 
    -0.02109738f, -0.02934317f, -0.02637081f, -0.00001159f, 0.01579510f, -0.00091237f, 0.01520965f, -0.00296206f, 
    0.02436469f, -0.03585209f, 0.03000863f, 0.00359718f, 0.00261362f, -0.01008758f, -0.02129398f, 0.00808913f, 
    0.00279802f, 0.01486278f, 0.01805745f, -0.01437271f, 0.01043432f, -0.04324466f, -0.02663139f, -0.00999510f, 
    -0.02303599f, 0.04072026f, 0.02401730f, 0.01021656f, 0.02497663f, 0.01815748f, -0.04388432f, 0.01318749f, 
    -0.01459258f, 0.00253755f, 0.01497300f, -0.04358608f, -0.00882655f, 0.00425166f, -0.01254794f, -0.03164691f, 
    0.01815290f, 0.00029026f, -0.03749676f, -0.01266969f, -0.00823511f, 0.01781994f, -0.00748499f, -0.00722212f, 
    0.00239291f, 0.00457361f, -0.01111952f, -0.03580678f, -0.01037471f, 0.02651048f, 0.00711757f, 0.02874920f, 
    0.01613639f, 0.01021734f, 0.00410469f, -0.01013217f, -0.00532033f, 0.02715410f, -0.00286348f, -0.02089748f, 
    0.02768654f, -0.00952451f, -0.04022101f, 0.02002210f, 0.02500393f, -0.00000983f, -0.01134006f, -0.00811181f, 
    -0.04125777f, -0.01810305f, 0.02900348f, 0.02746210f, 0.01280979f, -0.01236595f, -0.00205401f, 0.00167758f, 
    -0.02117535f, -0.00506525f, -0.01949590f, 0.02269338f, 0.01638507f, -0.03173961f, 0.01342619f, 0.02649453f, 
    -0.02375585f, 0.03379750f, 0.01039481f, -0.00042405f, -0.01861180f, -0.02245729f, 0.04317653f, -0.01748812f, 
    -0.02114307f, 0.01101344f, 0.01362062f, -0.00867687f, -0.03451503f, 0.02791003f, 0.02810609f, 0.01023094f, 
    -0.02370066f, -0.00277143f, 0.01320588f, 0.01341775f, -0.03961824f, -0.00411762f, -0.00206009f, -0.02174283f, 
    0.00167613f, 0.02331456f, -0.03487860f, -0.00218615f, -0.01293494f, 0.00586660f, 0.02322176f, -0.01954363f, 
    -0.02838338f, 0.01184361f, 0.03220246f, -0.00252462f, -0.02639884f, 0.01215644f, -0.02181704f, -0.00444593f, 
    0.00680961f, 0.02264307f, 0.00197256f, -0.04172702f, -0.01709131f, -0.00369604f, 0.02196931f, 0.01056731f, 
    -0.00743203f, -0.01982359f, 0.02755485f, 0.02909049f, 0.04141096f, -0.01960657f, -0.00816259f, -0.02160848f, 
    0.00558065f, 0.01572886f, -0.00232402f, -0.02463450f, 0.01131215f, 0.02583297f, -0.01752111f, -0.01326939f, 
    0.02453968f, 0.01218389f, -0.01017805f, -0.04258095f, -0.00419655f, -0.00078566f, 0.02078630f, 0.01317218f, 
    0.00824128f, 0.02005433f, 0.00158532f, 0.00932573f, 0.02093632f, -0.02010353f, -0.00088089f, -0.03523783f, 
    0.02255394f, -0.04306512f, -0.03236175f, 0.01989740f, -0.04017143f, -0.03787152f, 0.00905852f, -0.01143402f, 
    0.00804659f, -0.01042127f, 0.01881119f, 0.01566895f, 0.01580125f, 0.02543778f, 0.00411309f, -0.02698782f, 
    -0.02445245f, -0.00559636f, -0.00692109f, 0.00721893f, -0.01814729f, 0.02771607f, -0.00981370f, -0.00075659f, 
    -0.04574345f, 0.00583424f, -0.03644511f, -0.01126770f, 0.01459691f, 0.01103920f, 0.01438989f, 0.00095045f, 
    0.00759782f, 0.02001818f, 0.01282244f, 0.00014711f, -0.03957906f, -0.03354032f, 0.03027161f, 0.00756278f, 
    -0.01612120f, -0.01949524f, -0.02315407f, -0.02664613f, 0.01285588f, -0.01755254f, 0.02528905f, -0.04242072f, 
    -0.02962288f, -0.00699652f, 0.01362246f, -0.02633100f, 0.03899375f, 0.01245442f, 0.01585323f, 0.00107728f, 
    -0.00985349f, -0.04146480f, -0.02124348f, -0.02741282f, 0.01208531f, 0.01358562f, -0.03720811f, 0.02567156f, 
    -0.03784458f, 0.02895521f, 0.00599557f, -0.01868234f, 0.01147782f, -0.01750378f, -0.01939679f, 0.00708436f, 
    0.02370689f, -0.00178119f, 0.01052004f, -0.02565776f, 0.00279999f, -0.03827297f, 0.01660476f, -0.04001442f, 
    0.01698854f, -0.00056018f, 0.01740095f, 0.02455453f, -0.00939773f, -0.04087903f, 0.00102268f, -0.01554339f, 
    0.02583071f, 0.01143646f, 0.03254578f, 0.03171543f, 0.03385672f, -0.03122251f, -0.02764992f, -0.01447264f, 
    0.02644104f, -0.03636105f, -0.00744691f, 0.00217961f, 0.03496909f, -0.02265113f, -0.02043041f, -0.00682807f, 
    -0.02411084f, 0.02445129f, -0.04035260f, 0.03519031f, -0.00022188f, -0.02199879f, 0.02183480f, 0.03158126f, 
    -0.02942275f, -0.02237140f, 0.02904304f, 0.03017958f, 0.00366358f, 0.01969240f, 0.01143865f, 0.01673740f, 
    -0.04533830f, -0.01337140f, 0.00928228f, 0.00426787f, -0.03809570f, -0.03296887f, -0.00637227f, -0.02767644f, 
    0.00486914f, -0.04240261f, -0.03387292f, -0.02148820f, -0.00660075f, 0.01266652f, -0.03046860f, 0.01436994f, 
    0.02646270f, 0.01134611f, -0.02238316f, -0.02421887f, -0.02907700f, -0.03940856f, -0.00797550f, -0.00136856f, 
    -0.01220726f, 0.01472351f, -0.01080160f, -0.00282305f, -0.01455363f, -0.01832896f, 0.02466425f, -0.01907974f, 
    -0.03885874f, -0.00709339f, 0.00542727f, 0.00570432f, -0.03394514f, 0.01766835f, 0.03157732f, -0.00238557f, 
    0.02931214f, 0.02937399f, 0.02416647f, -0.01365766f, 0.03556062f, -0.00013936f, 0.02476040f, 0.03726127f, 
    0.02720871f, -0.04262576f, -0.04176062f, 0.02334862f, 0.03535074f, -0.00451864f, 0.03491326f, -0.01630647f, 
    -0.04068492f, 0.01867180f, -0.02510871f, -0.02910315f, 0.01946550f, -0.01655261f, -0.01860391f, -0.03092365f, 
    -0.04115400f, -0.04454577f, 0.00631462f, -0.01039970f, -0.01531934f, -0.01133808f, 0.01730612f, 0.02674562f, 
    0.00240932f, 0.02874817f, 0.01521264f, 0.00218192f, -0.00551826f, 0.03785101f, 0.01771189f, -0.02279519f, 
    0.02574376f, -0.02951950f, -0.02237993f, 0.01502853f, 0.00474317f, 0.03099528f, -0.01428050f, -0.03758427f, 
    0.00139493f, -0.02409976f, -0.01294227f, 0.03264287f, 0.00540808f, -0.02376691f, 0.01769549f, -0.02676958f, 
    -0.03620964f, -0.00385101f, -0.00824922f, -0.01967072f, -0.01809025f, -0.04311204f, -0.03531875f, -0.02495626f, 
    0.03023582f, -0.04276670f, 0.04223488f, -0.03413580f, -0.00438981f, -0.02895529f, -0.03054257f, 0.02965198f, 
    -0.02034802f, -0.02527015f, 0.01714695f, 0.03340264f, -0.02812315f, -0.02433776f, 0.00686181f, 0.03490417f, 
    0.02495462f, -0.01543085f, 0.01692175f, -0.01812515f, 0.02937248f, -0.00763437f, 0.00810062f, 0.02861040f, 
    0.02181172f, -0.00455273f, 0.03980325f, -0.03794556f, 0.04626760f, -0.02755484f, -0.00718305f, 0.02284932f, 
    0.01016599f, 0.03336284f, 0.01825832f, -0.02072695f, 0.00745320f, -0.01131298f, 0.00575395f, -0.03940802f, 
    0.01037745f, 0.00361491f, 0.02123613f, 0.02203695f, 0.03585288f, 0.01212094f, -0.03393174f, -0.03973060f, 
    -0.00009160f, -0.03938162f, -0.01666244f, 0.00088889f, 0.00124257f, 0.01616607f, 0.02700022f, 0.00059239f, 
    -0.00372126f, 0.00682865f, -0.02593367f, 0.00399482f, 0.00573831f, -0.01800282f, -0.00269331f, -0.02608525f, 
    0.00548412f, -0.02099324f, -0.01405607f, -0.01837081f, 0.01598449f, -0.02422388f, 0.02788056f, -0.02066372f, 
    0.00622937f, 0.00082437f, 0.02805701f, -0.03389378f, 0.02455921f, -0.03269153f, -0.03232657f, -0.02154771f, 
    -0.03491241f, -0.02799923f, -0.02957920f, -0.01432821f, -0.03884518f, -0.01285175f, -0.02664953f, 0.01127508f, 
    0.01493505f, -0.02466976f, -0.02600505f, 0.01805045f, 0.00783726f, 0.02402515f, 0.00856416f, -0.00117316f, 
    -0.03433760f, -0.01195345f, -0.03288853f, -0.03155865f, 0.03370539f, -0.02154952f, 0.02904702f, 0.00143316f, 
    -0.02565519f, -0.01067306f, 0.01343549f, -0.01212564f, 0.03300117f, -0.02509308f, -0.01236522f, 0.01898204f, 
    0.00261431f, -0.03372118f, -0.04143368f, 0.00966104f, 0.00495481f, -0.02491820f, -0.03135083f, 0.00074227f, 
    0.02985440f, 0.01617507f, -0.03968155f, -0.02729849f, -0.00882310f, 0.02678735f, -0.02322083f, -0.01287324f, 
    0.00308948f, 0.01251688f, -0.00062270f, -0.03251054f, 0.00636113f, -0.00274947f, 0.00791569f, -0.01391136f, 
    0.01412807f, -0.00807473f, 0.02870153f, -0.00782906f, 0.02209723f, -0.00886464f, -0.04757098f, 0.02927349f, 
    -0.00227627f, -0.03214215f, 0.02369107f, 0.02227890f, 0.00278078f, -0.03604267f, 0.02761569f, 0.01196107f, 
    -0.04272871f, 0.00994745f, -0.03400332f, -0.03664049f, -0.02104175f, -0.04817220f, -0.00680316f, -0.03264826f, 
    -0.01239384f, -0.03120178f, 0.02701597f, 0.01156202f, -0.00401640f, 0.01133948f, -0.02588556f, 0.02383975f, 
    -0.00077217f, -0.04597012f, 0.01923770f, -0.01807624f, -0.02759602f, 0.00202176f, -0.01895166f, 0.02633978f, 
    -0.01433479f, -0.01093285f, 0.01939933f, -0.01231242f, 0.01795386f, 0.02538213f, 0.00172660f, 0.00701341f, 
    0.00512461f, -0.03279809f, 0.00587785f, -0.02818589f, -0.00808366f, -0.02788180f, 0.01881200f, 0.01035625f, 
    0.00407779f, -0.03831918f, -0.04257260f, 0.02138513f, -0.02893601f, 0.02394154f, 0.02422062f, 0.01969289f, 
    -0.01737572f, -0.02019712f, -0.02596314f, -0.02101880f, 0.02290363f, 0.02905552f, -0.02819439f, -0.01851471f, 
    0.00176097f, -0.03100669f, -0.04265535f, 0.02802096f, 0.02458954f, -0.04631538f, -0.01032074f, -0.00125145f, 
    -0.00231780f, -0.00307402f, 0.00608763f, 0.00073147f, -0.01170549f, -0.03163773f, 0.01118059f, -0.00032230f, 
    -0.01270312f, 0.02477921f, -0.04257191f, -0.03931516f, -0.03401513f, -0.00103914f, 0.00864376f, -0.04008673f, 
    -0.00556980f, -0.00016516f, 0.02316466f, -0.02935203f, -0.01606005f, 0.01888834f, -0.03680691f, -0.02214556f, 
    -0.00180129f, 0.02771445f, 0.00598474f, 0.03177729f, -0.03560212f, 0.01196268f, -0.03554897f, 0.02029543f, 
    0.02234913f, 0.03985965f, -0.04514225f, -0.04047354f, -0.02244233f, -0.00670555f, 0.00201377f, 0.00697041f, 
    0.02909549f, 0.02528465f, -0.00982342f, -0.03316939f, -0.02723110f, -0.02631615f, -0.02363082f, -0.03584687f, 
    0.00282168f, -0.01188863f, -0.02159772f, -0.02992008f, -0.01241830f, 0.02762848f, 0.02125542f, 0.01880934f, 
    0.02843048f, -0.02072422f, 0.02639218f, 0.01145594f, 0.01024032f, 0.01744528f, 0.03433727f, 0.00176478f, 
    -0.03015945f, -0.00034031f, -0.00128666f, 0.01943327f, -0.02989751f, 0.00102772f, -0.00022871f, -0.01006139f, 
    -0.00769611f, 0.00196159f, -0.00322443f, 0.02035003f, 0.02679887f, -0.03083481f, -0.03604675f, 0.00717633f, 
    0.01073249f, -0.03539789f, 0.00037576f, -0.01861359f, -0.04392868f, 0.00034376f, -0.01750647f, -0.03327433f, 
    -0.00900278f, 0.01799458f, 0.02768295f, -0.01984046f, -0.02705759f, -0.01646937f, -0.04143569f, -0.04605496f, 
    0.00203811f, -0.00372153f, -0.01591892f, -0.05035769f, -0.02539866f, 0.02299606f, -0.01473950f, 0.00469147f, 
    0.01397399f, -0.04231405f, 0.00980105f, 0.02255274f, -0.02018943f, -0.04775450f, 0.02699743f, -0.03362430f, 
    0.01087994f, -0.02909104f, -0.00353095f, -0.00317806f, 0.01692105f, 0.01067296f, 0.03558201f, -0.04589247f, 
    0.01475566f, -0.00969630f, -0.00038644f, -0.02902848f, -0.01149783f, -0.04074680f, 0.00559064f, -0.02080886f, 
    0.03293345f, -0.02526663f, -0.00321191f, 0.00203951f, -0.01512309f, -0.00813139f, 0.02863725f, -0.02375627f, 
    0.02774091f, -0.03074997f, -0.02652389f, -0.01629409f, 0.01091589f, -0.00603189f, -0.02602810f, -0.00966402f, 
    0.01329911f, 0.01371211f, -0.00643193f, 0.01314889f, -0.02133102f, 0.00221729f, -0.03034506f, 0.02609016f, 
    0.02101886f, -0.02057291f, 0.00702861f, 0.01177723f, -0.00043022f, -0.04170895f, -0.02612121f, -0.00585811f, 
    -0.01238156f, -0.03198074f, 0.03305807f, -0.04241201f, 0.02147198f, 0.00594238f, 0.01985354f, 0.02390070f, 
    0.00720559f, 0.02771772f, 0.02199138f, -0.03163100f, 0.01760316f, 0.01753583f, -0.03433244f, 0.00033368f, 
    -0.01440258f, 0.03463606f, 0.03210809f, 0.01089338f, 0.01394966f, 0.03102027f, 0.03721431f, 0.03224728f, 
    -0.00148711f, -0.00375742f, -0.02262952f, -0.04331983f, -0.00143314f, 0.00445400f, -0.03259332f, 0.01319835f, 
    -0.01020172f, -0.02043204f, -0.01004309f, 0.03306317f, -0.01936037f, 0.02508132f, -0.03627073f, 0.01082034f, 
    -0.04677306f, -0.00320808f, -0.01030361f, 0.00057055f, 0.01038249f, 0.02521197f, 0.02805020f, -0.02129894f, 
    -0.04002566f, 0.00628923f, 0.00885944f, -0.01349662f, -0.00355964f, 0.02371353f, -0.00334645f, -0.01627169f, 
    0.00214070f, 0.00164259f, 0.03242346f, -0.00352473f, -0.02611353f, 0.00833763f, -0.03124614f, -0.04945114f, 
    -0.04405667f, 0.00819223f, -0.01565715f, -0.00100172f, -0.04812857f, -0.00712413f, -0.01753291f, -0.00458442f, 
    0.00340824f, 0.00063750f, -0.02353733f, -0.01458545f, -0.01654360f, -0.02111449f, -0.02703959f, -0.02887624f, 
    0.01979875f, -0.00285481f, 0.00230217f, -0.02526812f, -0.00051588f, -0.03220225f, -0.01656249f, -0.02002159f, 
    -0.02766635f, -0.00178592f, 0.01552093f, -0.01141853f, -0.00873349f, -0.04419071f, -0.02781009f, 0.00780101f, 
    0.01270976f, -0.02802748f, -0.02088793f, 0.00707820f, 0.02091924f, 0.01231139f, 0.00347112f, -0.02705033f, 
    -0.04889795f, 0.02197020f, 0.00120925f, 0.01875164f, -0.02857301f, -0.02696862f, -0.03315638f, 0.02665521f, 
    0.01153929f, -0.00388243f, -0.01089379f, -0.00666226f, -0.01735358f, -0.00285860f, 0.02551797f, 0.00131486f, 
    0.02296661f, 0.02760346f, 0.02900446f, -0.01760879f, -0.03000567f, -0.04383706f, 0.02216089f, 0.00199197f, 
    -0.01184620f, 0.01382250f, 0.00385356f, 0.00516146f, -0.01337030f, -0.04909750f, 0.01742457f, -0.04680941f, 
    -0.00694935f, 0.01748673f, -0.00787811f, -0.03497622f, 0.01982611f, -0.02775107f, 0.02597488f, 0.00757027f, 
    0.00029733f, -0.01887943f, 0.00533402f, -0.03242089f, 0.04432190f, -0.04811253f, 0.01993772f, -0.02225467f, 
    -0.03098421f, 0.00618817f, -0.01707999f, 0.00796157f, -0.02464804f, -0.00492312f, -0.03350338f, 0.00687894f, 
    0.01236043f, -0.02298512f, -0.02671511f, 0.02650443f, 0.01111118f, 0.02690971f, -0.02089177f, -0.02717741f, 
    0.01296978f, 0.00049738f, -0.03880354f, 0.01610953f, 0.01173997f, -0.04459743f, -0.02424334f, -0.04367804f, 
    -0.02944973f, -0.00572145f, -0.04212451f, 0.01445362f, -0.00580123f, -0.00947040f, -0.03570886f, 0.01168605f, 
    -0.04478423f, 0.00809555f, -0.01786911f, 0.02024877f, 0.00096910f, 0.00502834f, -0.03677727f, 0.01978321f, 
    0.02421879f, -0.00530475f, 0.02418604f, 0.01010025f, 0.01598965f, -0.00802850f, -0.00677094f, -0.01381701f, 
    0.01231253f, 0.03330217f, -0.03946896f, -0.00333250f, 0.01932324f, 0.01202512f, -0.02322684f, -0.02681528f, 
    0.01855673f, -0.00454283f, 0.02333778f, -0.02214828f, 0.00694712f, 0.01482821f, -0.00383262f, 0.01403776f, 
    0.01692528f, -0.03960018f, 0.00562016f, -0.04189939f, -0.03676185f, -0.02432433f, 0.01204533f, -0.04548673f, 
    0.03017412f, -0.01815202f, -0.02290189f, -0.04261549f, -0.04509547f, 0.00063997f, 0.02801110f, 0.01408626f, 
    0.03033237f, -0.03178229f, 0.00364676f, 0.02886457f, -0.04831945f, 0.00047034f, -0.02359728f, 0.01324503f, 
    -0.04199019f, 0.01659928f, -0.00507143f, -0.04685856f, 0.01540143f, 0.00701907f, -0.01469620f, 0.00904423f, 
    -0.03244369f, 0.02441534f, -0.01034614f, -0.03794795f, 0.00579563f, -0.03597134f, -0.03062292f, 0.01062033f, 
    -0.04674570f, 0.02631563f, -0.02789399f, -0.02270012f, -0.02049970f, -0.00639248f, -0.03083635f, 0.01716020f, 
    0.00410634f, -0.00242999f, -0.04096190f, 0.02519051f, 0.01225031f, 0.03129315f, -0.02791777f, -0.03711528f, 
    -0.04822912f, -0.04610682f, -0.04443017f, -0.03277499f, -0.00202191f, 0.02365049f, 0.02506298f, 0.01866418f, 
    -0.03107453f, 0.02886736f, -0.02040360f, -0.00740663f, 0.03535227f, 0.01176370f, 0.00324047f, 0.02946550f, 
    -0.01253747f, 0.01604975f, -0.03501204f, -0.02001114f, -0.03433491f, -0.00978146f, -0.04019600f, -0.03750891f, 
    -0.00552833f, -0.03655475f, -0.02617695f, 0.02922312f, -0.04122823f, -0.02564004f, 0.02661270f, -0.03364797f, 
    -0.02252585f, 0.00463722f, 0.02438273f, -0.03615147f, 0.02708481f, 0.00812284f, 0.01737848f, 0.00050677f, 
    0.00346056f, 0.02748664f, -0.00949009f, -0.03924376f, -0.00890395f, -0.00962268f, 0.00077094f, 0.01821761f, 
    0.00774278f, 0.01177363f, -0.00325206f, 0.00358391f, 0.00758008f, -0.00916559f, -0.02673043f, 0.01537282f, 
    -0.00343156f, 0.01552829f, -0.02589843f, 0.00948131f, 0.00225498f, -0.04810448f, -0.04003129f, -0.01055671f, 
    0.00124815f, -0.03424961f, -0.00043828f, -0.01163333f, 0.02893352f, -0.02913428f, 0.01425227f, -0.00700126f, 
    -0.04519466f, -0.02492869f, 0.01094269f, 0.00035729f, 0.01606215f, -0.01807591f, -0.00107763f, -0.02399361f, 
    0.01663487f, -0.02541983f, -0.03628842f, -0.04143056f, 0.00196713f, -0.00058966f, -0.03467122f, -0.04786650f, 
    0.01377603f, 0.02891815f, 0.00027327f, -0.01070761f, -0.03595080f, -0.00008621f, -0.00644735f, 0.00056208f, 
    -0.00180959f, 0.01607243f, 0.00061828f, 0.02163664f, 0.02684524f, 0.00268296f, 0.00944820f, -0.05010198f, 
    -0.00180703f, 0.03524404f, -0.01883455f, -0.04164603f, -0.02734205f, 0.00234634f, -0.03112422f, 0.01660018f, 
    0.02960665f, -0.04553802f, -0.01304574f, 0.01919884f, 0.02827133f, -0.03254656f, -0.01964952f, 0.03180093f, 
    -0.00675261f, 0.01471312f, -0.02580188f, -0.04111453f, -0.02513617f, -0.02616843f, -0.03345222f, 0.01925894f, 
    -0.02509659f, -0.02803015f, 0.02669123f, 0.01609334f, 0.03130981f, -0.03921530f, -0.03051012f, -0.00631632f, 
    -0.03690721f, 0.02038037f, 0.00104982f, 0.01687002f, -0.03474558f, -0.03552788f, -0.04058928f, -0.01905643f, 
    0.02746506f, -0.03374226f, 0.02187327f, -0.00340149f, -0.01800811f, -0.00978428f, -0.03109322f, -0.01250327f, 
    0.00597122f, -0.04404241f, -0.01242100f, -0.04285271f, -0.02827349f, -0.01124577f, -0.01356638f, -0.03028155f, 
    -0.04061991f, 0.02111275f, -0.02566584f, -0.02090885f, 0.02159614f, 0.02319580f, -0.00028972f, -0.04621779f, 
    0.03593559f, 0.02828091f, 0.01628808f, -0.02352227f, -0.03175068f, 0.01003955f, 0.03469693f, 0.00903451f, 
    -0.03733947f, 0.01384106f, -0.04261292f, 0.02045438f, 0.01969117f, -0.02904147f, 0.00923278f, -0.01724966f, 
    0.00808959f, 0.00369235f, -0.00700950f, 0.02889844f, -0.02206142f, -0.03438181f, -0.04493561f, -0.02325017f, 
    0.02389976f, -0.01397846f, 0.03354872f, 0.01843270f, -0.01910719f, -0.04494524f, -0.00564001f, 0.01582679f, 
    -0.00843143f, 0.02637863f, 0.03465931f, 0.01561278f, 0.00370994f, 0.00551369f, -0.00391596f, 0.00935064f, 
    -0.01825495f, -0.02125130f, 0.03255698f, 0.02875185f, 0.03326816f, 0.00390727f, -0.02508161f, -0.02215470f, 
    0.01923087f, -0.02657892f, -0.03080432f, 0.01660630f, -0.02558110f, -0.03995965f, -0.00809023f, -0.00320493f, 
    0.01450190f, -0.03016127f, 0.01953257f, 0.02221834f, -0.01994803f, -0.00146370f, 0.02642619f, 0.01198933f, 
    0.02084762f, -0.03791614f, 0.00950270f, -0.01408076f, 0.02550581f, -0.00968624f, -0.04087269f, 0.01130553f, 
    -0.01799476f, 0.01940811f, -0.02045382f, 0.00526568f, -0.01241390f, -0.03517611f, 0.00468280f, -0.02109339f, 
    -0.00087992f, -0.04319263f, -0.02503871f, 0.00894739f, -0.01353156f, -0.01796210f, -0.01192426f, 0.02635815f, 
    -0.00827243f, 0.00586829f, 0.01558850f, 0.00635160f, -0.02882818f, -0.00420121f, 0.00645385f, -0.01984962f, 
    0.02140947f, 0.01850318f, -0.04003737f, -0.03834004f, -0.00111597f, 0.00737188f, -0.02553458f, -0.01886472f, 
    0.02333026f, 0.01732640f, -0.01094905f, -0.02394186f, 0.03718976f, 0.03019548f, -0.01951787f, -0.04094149f, 
    0.00833350f, -0.02484974f, -0.02060845f, -0.02539013f, 0.00210892f, -0.00747190f, -0.04832289f, -0.02556388f, 
    -0.00060672f, -0.03658427f, 0.00189710f, -0.04153921f, -0.04582769f, 0.01804117f, 0.02143939f, 0.00269232f, 
    -0.00518825f, 0.00287348f, 0.00312760f, -0.02600336f, -0.02918203f, 0.00856818f, -0.02338406f, -0.03794196f, 
    -0.03605403f, -0.00504720f, -0.02398734f, 0.00242215f, -0.00502581f, -0.00393169f, -0.01749832f, -0.00135380f, 
    -0.01119018f, 0.03042269f, 0.01857699f, 0.00111215f, -0.02790223f, 0.03815607f, -0.04501656f, 0.00848015f, 
    -0.01999464f, -0.01915214f, -0.04335061f, 0.03087139f, -0.00330785f, -0.02404873f, 0.00991148f, -0.04150074f, 
    0.00414865f, 0.02357600f, 0.01015525f, 0.00168625f, 0.00544555f, 0.00754023f, 0.02021754f, -0.01263836f, 
    -0.00114646f, 0.02710937f, 0.01222581f, -0.03455875f, -0.01825328f, 0.00881267f, 0.01045895f, 0.03490487f, 
    0.00725256f, 0.02536313f, 0.02550310f, -0.03823683f, -0.02966964f, 0.01563888f, -0.04099503f, -0.03809860f, 
    0.02366347f, -0.00188094f, 0.00304063f, -0.01628055f, -0.01274904f, -0.00044881f, 0.02186934f, -0.02531749f, 
    -0.00313273f, -0.04143855f, -0.02301945f, 0.02580397f, -0.01058169f, 0.01708067f, -0.02143547f, -0.00226777f, 
    -0.03595750f, 0.01032611f, 0.01724011f, -0.00705337f, -0.04870353f, 0.03444551f, 0.03758689f, -0.03569056f, 
    0.00160594f, 0.03464357f, -0.02016069f, 0.00631660f, 0.01153089f, 0.01529697f, -0.02007142f, -0.00134093f, 
    -0.00591153f, -0.02641003f, 0.02298041f, 0.01208798f, -0.02656271f, -0.03030912f, 0.02434273f, -0.00587212f, 
    0.01632237f, 0.00966029f, 0.00792059f, 0.01123585f, 0.00913442f, 0.01110058f, -0.02277752f, -0.03833718f, 
    0.01371624f, -0.02371000f, -0.03043764f, 0.01367029f, 0.00190899f, -0.01479305f, -0.00035407f, -0.01936497f, 
    -0.00265651f, -0.02492375f, 0.00133020f, -0.02238673f, 0.01175249f, 0.00229748f, 0.03065447f, 0.03952269f, 
    -0.00167592f, 0.03228452f, -0.01862434f, 0.02754888f, -0.01218678f, -0.02086779f, 0.00735820f, 0.02968262f, 
    -0.02712997f, -0.03608568f, 0.00453765f, -0.02409189f, 0.00978404f, 0.01974420f, -0.01904966f, -0.02861803f, 
    -0.00667213f, -0.03003249f, 0.01293098f, -0.01460054f, 0.01072218f, -0.01454439f, -0.02738695f, -0.03834873f, 
    0.03415609f, -0.03603166f, -0.02089532f, -0.01537480f, 0.02301234f, -0.04221732f, 0.00859392f, -0.00971592f, 
    0.00434544f, -0.03554727f, 0.01947320f, -0.02231546f, 0.02981788f, 0.02628303f, 0.00383550f, -0.01878521f, 
    -0.01680280f, -0.01003804f, 0.00722285f, 0.01927070f, 0.00977825f, 0.03092121f, -0.00219708f, -0.00655722f, 
    0.01961740f, -0.03830856f, 0.03060863f, -0.02354027f, 0.03289208f, -0.00341368f, 0.00622466f, -0.01378812f, 
    0.02574208f, -0.02308403f, 0.03234331f, -0.02471047f, -0.03867031f, -0.01606619f, -0.02640050f, -0.04080351f, 
    0.01664523f, -0.03172967f, 0.03138378f, 0.01297035f, 0.01181542f, -0.00263263f, -0.02558661f, -0.04469208f, 
    -0.04038169f, 0.00017989f, 0.00939447f, -0.01038497f, -0.02627168f, 0.03126292f, -0.00254789f, 0.02761305f, 
    0.01171119f, 0.02800467f, -0.03709330f, -0.02807350f, -0.01311489f, -0.00765784f, 0.00909800f, 0.01748964f, 
    0.00397329f, -0.01774443f, 0.02229213f, -0.02703616f, -0.00549229f, 0.02045768f, 0.01958398f, -0.00025273f, 
    -0.02307926f, -0.03682611f, -0.03413491f, -0.01890338f, 0.02765302f, -0.03507737f, 0.01732390f, 0.01676513f, 
    0.01301843f, -0.01132121f, 0.01988869f, 0.01582084f, 0.00662150f, -0.00625058f, -0.01817240f, -0.01151309f, 
    -0.00241013f, 0.02739505f, 0.02368903f, 0.02011098f, 0.02752345f, 0.00382102f, -0.02303825f, -0.00719686f, 
    0.03174643f, 0.00893289f, -0.03697819f, -0.02831969f, -0.00038133f, -0.03911299f, -0.02488162f, 0.02565595f, 
    0.03224577f, -0.00839684f, -0.01932166f, -0.03504666f, -0.01294849f, -0.00465751f, -0.01071824f, 0.01731166f, 
    -0.02228484f, -0.01394156f, -0.03858181f, -0.01204632f, 0.00342368f, -0.00408293f, -0.00072537f, 0.02655735f, 
    0.02499705f, 0.03242518f, -0.00879080f, -0.01001060f, 0.02538993f, -0.02083177f, -0.02726684f, 0.00146105f, 
    -0.02937134f, -0.02967978f, 0.02555263f, 0.01937673f, -0.00063078f, 0.00794797f, 0.00405340f, 0.03642310f, 
    0.00813284f, 0.01442263f, 0.00953783f, -0.00192477f, -0.00289873f, -0.01153987f, 0.01728586f, -0.03913012f, 
    -0.03645280f, 0.02210251f, 0.00909448f, 0.01405107f, -0.04031494f, -0.03238439f, -0.00975851f, -0.03274678f, 
    -0.00790536f, 0.00393873f, 0.00358827f, -0.03355128f, -0.02343598f, -0.03996891f, -0.04781901f, 0.04082244f, 
    -0.02921529f, -0.04389453f, -0.02990042f, -0.01749847f, -0.02392053f, -0.01095470f, -0.03692243f, -0.00280432f, 
    0.02910415f, -0.02548198f, -0.02049441f, 0.01613805f, 0.01613807f, 0.00568133f, 0.02023957f, -0.03485592f, 
    -0.03578092f, -0.01084301f, -0.04003450f, 0.00522459f, -0.04121289f, 0.01621795f, -0.02239802f, -0.03914270f, 
    0.01181231f, -0.03683389f, -0.02737325f, -0.04501264f, 0.02079946f, 0.00202435f, 0.01834769f, 0.00237416f, 
    0.00686040f, -0.01400810f, -0.02454231f, 0.00075234f, 0.00792506f, -0.03301457f, 0.00415312f, -0.02840708f, 
    0.00672666f, 0.03339968f, 0.01278365f, -0.04266403f, -0.01153889f, -0.00123798f, 0.01921069f, -0.04229644f, 
    0.03154682f, 0.03755190f, -0.00933953f, 0.03790452f, 0.00307798f, -0.00883809f, -0.00318350f, 0.00649467f, 
    -0.02366078f, -0.01667304f, 0.03680050f, 0.01229384f, 0.01014348f, -0.00418010f, -0.04068018f, 0.01427043f, 
    0.02586254f, -0.02264070f, -0.03377869f, 0.03371382f, -0.00327355f, 0.02887584f, 0.01994661f, -0.03046284f, 
    -0.00582131f, 0.00878208f, -0.00650106f, -0.02938879f, -0.02591728f, -0.04151195f, -0.00475665f, -0.03979142f, 
    0.01152823f, 0.00889383f, -0.02732552f, 0.00200899f, 0.01561429f, -0.01953633f, -0.04437045f, 0.02239456f, 
    0.02426803f, 0.00279802f, 0.00165209f, 0.02005718f, 0.03022444f, 0.01248583f, -0.00950366f, -0.01639169f, 
    -0.00135626f, -0.03664597f, -0.03290084f, -0.00645492f, 0.02714827f, 0.02668083f, 0.01517197f, 0.03348522f, 
    -0.02437655f, -0.03319988f, -0.00782067f, -0.01007835f, -0.02455166f, -0.01940395f, -0.01375501f, -0.00301233f, 
    -0.04303025f, 0.00982123f, 0.01328914f, -0.03611201f, -0.00625525f, -0.00868496f, 0.01445256f, -0.02715400f, 
    0.01772140f, -0.02984798f, -0.01909548f, -0.01698135f, -0.00656850f, 0.02037892f, 0.01780816f, 0.02035469f, 
    -0.00185181f, -0.01084804f, -0.00898425f, 0.00851875f, -0.03671690f, 0.01209969f, 0.03463718f, 0.00013922f, 
    -0.00265057f, -0.03987629f, 0.00158844f, -0.01380832f, 0.02612710f, -0.02041840f, 0.02658357f, -0.00980046f, 
    0.00612313f, -0.01292899f, 0.02975358f, 0.00174121f, -0.02650130f, -0.02978949f, -0.01378110f, -0.02620023f, 
    0.02378296f, -0.13168730f, -0.09895522f, 0.21480604f, 0.00733199f, -0.23718698f, 0.11991606f, 0.11255229f, 
    0.06453459f, -0.02954730f, -0.06870119f, -0.03408085f, -0.07915175f, 0.02763698f, 0.09378850f, -0.00112928f, 
    -0.11317306f, -0.04619588f, -0.03687835f, -0.00342756f, 0.15506969f, 0.08706248f, 0.06983700f, 0.04689102f, 
    0.13853285f, 0.06306416f, 0.08484441f, 0.04567968f, -0.01876823f, 0.10511823f, 0.11181042f, 0.01386345f, 
    -0.00998135f, 0.04339199f, -0.00269451f, -0.02263401f, 0.02453829f, 0.03623095f, 0.04023428f, 0.03139902f, 
    -0.18025270f, 0.03875570f, -0.25816101f, 0.02910351f, 0.20974794f, 0.01156766f, -0.09318741f, -0.03281010f, 
    0.09137734f, 0.03812460f, -0.08856674f, 0.11175501f, 0.07844763f, -0.01809726f, 0.13134100f, 0.10919812f, 
    0.08594546f, 0.19403993f, -0.05512546f, 0.01525743f, -0.27787486f, -0.16132444f, 0.05775190f, 0.04401374f, 
    0.08091896f, 0.09068679f, 0.07553458f, -0.10735422f, 0.00594170f, -0.01391996f, 0.08426108f, 0.08605769f, 
    -0.05129005f, 0.09110039f, 0.08999380f, 0.00797602f, -0.00624262f, -0.08055563f, 0.01651432f, -0.05830503f, 
    -0.15884385f, 0.08894316f, -0.12036893f, -0.04722883f, 0.05215287f, -0.10315589f, 0.05379723f, 0.16875896f, 
    -0.04578810f, 0.11727842f, 0.07809780f, -0.04051846f, -0.08476856f, 0.03119931f, -0.01240348f, 0.04539488f, 
    -0.08028820f, 0.06723298f, 0.09039278f, -0.03418072f, -0.11217581f, 0.19789959f, -0.04631300f, -0.01272386f, 
    -0.14164789f, -0.04069902f, 0.07470581f, -0.04990674f, -0.03043077f, -0.01762179f, -0.08063766f, 0.04995359f, 
    0.03628390f, 0.11668067f, 0.02986287f, -0.03101744f, 0.02720294f, 0.03954641f, 0.09928004f, 0.03443129f, 
    0.48728621f, 0.23221536f, 0.25641492f, 0.11855336f, 0.04179979f, 0.02997110f, 0.01052877f, 0.09681944f, 
    0.07961313f, 0.11566088f, 0.06471293f, -0.01313556f, -0.01291755f, 0.11954638f, 0.03954597f, -0.01684472f, 
    0.09044669f, -0.05595395f, -0.06225170f, 0.02466147f, 0.56769431f, 0.19908726f, 0.19588268f, 0.25259545f, 
    0.09746585f, -0.12033498f, 0.03920335f, 0.06002731f, 0.01944905f, 0.09517223f, 0.07339551f, -0.00412533f, 
    0.02989884f, 0.04750282f, 0.04547219f, 0.07773578f, 0.06477157f, -0.01906594f, 0.04673762f, 0.05540387f, 
    0.02666306f, -0.15932840f, -0.26509604f, -0.07121941f, -0.00721374f, -0.02953905f, -0.16340135f, -0.03270389f, 
    0.00011543f, 0.18147613f, 0.07227916f, 0.08013664f, 0.09606613f, 0.01726100f, -0.01528403f, -0.04205706f, 
    -0.00659827f, -0.00630814f, 0.08905480f, 0.09197896f, 0.18392454f, -0.18011543f, 0.22476780f, 0.22752067f, 
    -0.00709822f, -0.04199808f, 0.03758686f, 0.04866232f, 0.00269211f, 0.09229770f, 0.17216080f, -0.09830322f, 
    -0.04970457f, 0.01245034f, 0.09191670f, 0.07318269f, 0.08632217f, -0.02664341f, -0.04709762f, -0.08511984f, 
    -0.29851970f, -0.06714516f, -0.03543305f, -0.06981114f, -0.15031539f, 0.08567446f, 0.15537074f, 0.10930210f, 
    0.11511979f, -0.00799159f, 0.06662207f, 0.12117708f, -0.09520134f, 0.04201139f, -0.07600553f, 0.09968039f, 
    0.08740748f, -0.00198737f, -0.05484612f, -0.04965462f, 0.51940107f, -0.04290008f, 0.31735498f, 0.38052207f, 
    -0.19996217f, -0.05583961f, 0.14731172f, 0.08375121f, -0.00264782f, -0.01221338f, -0.00074942f, 0.04593893f, 
    -0.01033202f, 0.05099018f, 0.08996666f, 0.03692147f, 0.08417241f, -0.00593463f, -0.00180980f, 0.12264790f, 
    0.21118811f, 0.29108664f, 0.09239116f, 0.14388159f, -0.05322368f, 0.00574673f, -0.04507205f, 0.12278799f, 
    0.05312880f, 0.14529942f, 0.04950242f, 0.05144692f, 0.01698432f, -0.00915979f, 0.10710751f, 0.02612776f, 
    0.06827832f, -0.08483403f, -0.00556928f, -0.01353747f, -0.19009466f, 0.31130889f, 0.08976188f, 0.06254048f, 
    -0.11675139f, 0.04594460f, 0.07334685f, 0.16587295f, 0.05451223f, 0.06405013f, 0.01899132f, -0.06372800f, 
    -0.03565980f, 0.03861011f, -0.00275644f, 0.01103164f, 0.00049528f, -0.06167836f, 0.00398852f, -0.07088266f, 
    -0.04058454f, -0.18988128f, -0.20655382f, 0.06295422f, 0.23114721f, -0.07127568f, -0.10637660f, -0.08512928f, 
    0.08604059f, 0.07255330f, 0.06586297f, 0.06602865f, 0.11430289f, 0.14660914f, 0.08929554f, -0.00633190f, 
    0.00099914f, 0.01041860f, 0.12527186f, 0.11051052f, -0.23648904f, 0.01037327f, -0.08157474f, -0.02932344f, 
    -0.04139137f, 0.03787560f, -0.03108684f, 0.03715649f, 0.12422611f, -0.01488146f, 0.07863756f, -0.06385564f, 
    0.12645270f, -0.05959309f, 0.03526149f, -0.06040547f, -0.00811254f, -0.01424979f, 0.07155733f, -0.02747332f, 
    0.32707244f, 0.42151642f, 0.07666765f, 0.29046148f, 0.19374266f, -0.10833301f, -0.00277274f, 0.09699615f, 
    -0.01264787f, 0.07500857f, 0.14066723f, -0.02789255f, 0.16986549f, -0.00650604f, 0.06026136f, 0.02161112f, 
    -0.07462161f, -0.07032660f, 0.02399541f, 0.03495463f, -0.08668238f, -0.19974516f, -0.11224969f, -0.38587096f, 
    -0.00359935f, 0.00659193f, 0.20567854f, -0.12242234f, -0.03216828f, -0.01378941f, 0.14340746f, 0.05889298f, 
    -0.03365519f, 0.07621745f, -0.02397924f, 0.06684994f, 0.08253755f, -0.06864414f, 0.00516809f, -0.00279966f, 
    -0.33909321f, -0.07034676f, -0.28023517f, -0.08667745f, -0.01913514f, 0.20395996f, 0.04395573f, 0.06195239f, 
    0.01129931f, -0.03016830f, -0.00346213f, -0.01138924f, 0.06152265f, -0.01866871f, 0.02243035f, 0.08982261f, 
    0.10034145f, -0.07389443f, -0.03160645f, 0.04864664f, -0.17089176f, 0.22071664f, -0.11221782f, 0.00015585f, 
    -0.13581321f, 0.00197985f, -0.05552248f, 0.01345897f, 0.05129863f, 0.03520346f, 0.04772585f, 0.00688050f, 
    0.10639766f, -0.01618840f, 0.00359805f, -0.01821738f, 0.03470437f, 0.05178701f, 0.09275946f, -0.03940156f, 
    -0.38155055f, -0.00717409f, 0.07366075f, -0.04663296f, 0.03490274f, 0.09233099f, 0.08771469f, 0.06880043f, 
    0.11870145f, 0.03590462f, 0.06615599f, -0.01990085f, -0.01250788f, 0.00392617f, 0.01792689f, 0.00794172f, 
    -0.00277346f, -0.06089119f, -0.07231668f, -0.12478738f, -0.11870335f, 0.16727366f, -0.02883048f, -0.12156051f, 
    -0.15015644f, -0.06024532f, 0.06172070f, 0.07663706f, 0.09439714f, -0.10663010f, -0.01710774f, 0.02214362f, 
    0.02123005f, 0.03446123f, -0.00253875f, 0.01805259f, 0.00061691f, 0.00038648f, 0.05795866f, -0.09428933f, 
    -0.40255508f, 0.03278058f, -0.35559228f, -0.09245449f, 0.00561026f, 0.14251108f, 0.02218450f, 0.02834174f, 
    0.09702349f, 0.00687157f, -0.00226490f, -0.05323968f, 0.12292906f, 0.10139595f, 0.13413924f, 0.11006264f, 
    -0.01138351f, 0.08007036f, 0.10986600f, -0.03491879f, -0.16975759f, 0.13062252f, -0.08656605f, 0.04083651f, 
    -0.02084038f, -0.00783981f, -0.04786414f, 0.03040162f, -0.12194216f, -0.02370315f, 0.03232848f, 0.07862552f, 
    -0.08274167f, 0.02050890f, 0.01159625f, -0.07819831f, -0.05260692f, -0.03151983f, 0.01622923f, -0.10276317f, 
    0.11638734f, 0.39645261f, 0.14801085f, 0.19802521f, -0.01519165f, -0.09859474f, -0.03129192f, 0.10603399f, 
    -0.04243892f, 0.06161842f, 0.05445297f, -0.00484956f, 0.07961342f, -0.02046786f, 0.10730095f, -0.02335940f, 
    0.04607525f, -0.11179544f, -0.07636670f, 0.04209946f, -0.00649983f, -0.05345086f, 0.09672306f, 0.20523778f, 
    0.04738912f, -0.06964006f, -0.01482819f, 0.04624638f, 0.09675348f, -0.02281254f, 0.07378969f, 0.00747708f, 
    -0.05993942f, 0.15557216f, 0.05867586f, -0.06585506f, -0.06279063f, -0.01593236f, 0.01142387f, -0.01322714f, 
    -0.47932586f, 0.13831106f, -0.39719114f, -0.15203351f, -0.02797867f, 0.07823848f, -0.03101568f, 0.04925138f, 
    0.07722045f, 0.08193319f, -0.03123917f, -0.02528283f, 0.16347148f, 0.02796379f, 0.01830728f, 0.14112952f, 
    0.01613344f, 0.02359148f, 0.03723730f, -0.05319116f, 0.18662211f, -0.01344559f, 0.31014776f, 0.09475856f, 
    0.03897428f, 0.05477104f, 0.01867766f, 0.00269572f, 0.04718161f, 0.12167527f, 0.08713023f, -0.00065991f, 
    -0.03327608f, 0.11644734f, 0.11435256f, 0.12991332f, 0.10482708f, -0.08238334f, -0.00863920f, 0.01750558f, 
    0.21839574f, -0.03986232f, -0.04404896f, 0.17575164f, -0.03183738f, 0.09592491f, -0.04281971f, 0.11385898f, 
    0.06914298f, 0.21623248f, 0.03366630f, 0.01343700f, 0.07199519f, 0.01673137f, -0.03366148f, -0.02708234f, 
    0.08854511f, 0.06163085f, -0.05926117f, -0.03806029f, 0.06878976f, -0.03434110f, -0.08458813f, -0.04855531f, 
    -0.02002097f, -0.13587555f, 0.03283380f, 0.00365934f, 0.03731482f, 0.07070018f, 0.03638229f, 0.04461826f, 
    0.09965178f, 0.06714865f, 0.23299927f, -0.03484239f, 0.23945321f, 0.20145676f, 0.07741104f, 0.12643461f, 
    0.17712824f, 0.15402399f, 0.14678474f, 0.09329443f, 0.07327844f, -0.02682580f, 0.05930573f, 0.02282863f, 
    0.08395454f, 0.09746257f, 0.10544928f, 0.04016631f, 0.08864544f, 0.02601705f, 0.06727517f, 0.03942617f, 
    -0.06174247f, -0.02151274f, 0.03409693f, 0.04717386f, 0.13126804f, -0.16295207f, 0.09987531f, 0.16415934f, 
    -0.04318068f, 0.15924336f, 0.04258111f, 0.05245513f, 0.05452203f, 0.02060092f, 0.10683160f, -0.05482164f, 
    -0.03464564f, 0.07934400f, 0.01788910f, 0.04949223f, 0.09700861f, -0.03828742f, -0.06511206f, -0.03934203f, 
    0.00740403f, 0.02048463f, 0.01132250f, -0.01803307f, -0.00046620f, 0.00757802f, -0.03415182f, -0.04210529f, 
    -0.03657837f, -0.02780114f, 0.00416910f, 0.03193183f, -0.00601629f, -0.02558143f, -0.04349079f, 0.03073166f, 
    -0.04122251f, -0.04045169f, -0.02298016f, -0.01805874f, -0.01970974f, -0.01476142f, 0.00705607f, 0.01204275f, 
    -0.00418552f, -0.01756213f, -0.02769248f, 0.02841724f, -0.03855280f, -0.02748237f, 0.02281588f, -0.02189695f, 
    0.02293678f, -0.01212192f, -0.01672130f, 0.00570272f, -0.04610282f, -0.00832918f, 0.01897948f, 0.03230479f, 
    0.02999187f, 0.03035356f, -0.02179034f, -0.03701164f, -0.03721092f, 0.03039441f, -0.01606709f, -0.02598359f, 
    -0.01719530f, -0.03595498f, 0.00120342f, -0.04407314f, -0.02470989f, 0.02436170f, -0.03683168f, -0.04574171f, 
    0.02413788f, -0.02611214f, -0.02382904f, 0.01277564f, 0.03127236f, 0.00278057f, -0.01917206f, -0.02590289f, 
    -0.03827093f, -0.00888340f, 0.01951802f, 0.02747460f, 0.02359318f, -0.01077387f, -0.04541422f, 0.02083832f, 
    0.02870349f, -0.01911051f, 0.02393270f, 0.00323545f, -0.03030852f, -0.00997622f, -0.01457043f, -0.01553939f, 
    -0.00418558f, 0.01431825f, -0.02857167f, 0.00639141f, -0.02428147f, 0.01712688f, -0.02156001f, 0.00759446f, 
    0.00765071f, 0.01317507f, -0.01055626f, -0.00496275f, 0.01640855f, 0.00753491f, -0.01277757f, -0.04524640f, 
    -0.03985756f, -0.01455472f, -0.01190835f, 0.02161848f, 0.00161619f, -0.01595688f, -0.04023498f, -0.02763058f, 
    -0.03697336f, 0.01620035f, -0.03212230f, -0.00702422f, -0.01767934f, 0.01888948f, -0.01429975f, -0.01163336f, 
    0.01754300f, 0.00426075f, -0.04032961f, 0.02583202f, -0.01595828f, 0.02049446f, -0.01178106f, -0.03187570f, 
    -0.03090754f, 0.01611823f, -0.01734370f, -0.03704884f, 0.02496924f, -0.02993991f, -0.02337478f, -0.02771707f, 
    0.00593486f, -0.00315778f, -0.03731466f, 0.01824968f, 0.03117767f, -0.01751748f, 0.01143672f, -0.01626231f, 
    -0.04193109f, -0.04151126f, -0.01985533f, -0.02943013f, -0.00887224f, -0.01417485f, 0.02561595f, -0.03685981f, 
    -0.01328052f, -0.00835664f, -0.02823558f, -0.01003197f, 0.02716227f, -0.00348396f, 0.01580522f, -0.00540947f, 
    -0.00986019f, -0.03740815f, -0.01635429f, -0.00980606f, 0.01945348f, -0.01617965f, 0.01397678f, 0.01689481f, 
    -0.00054510f, -0.01261385f, 0.04277457f, -0.01449325f, 0.01507269f, -0.02583797f, 0.01929689f, -0.00091678f, 
    0.02155289f, 0.01270694f, -0.04119546f, -0.00950294f, -0.02221558f, 0.01293791f, -0.03140480f, 0.01495361f, 
    -0.03655491f, 0.01366404f, -0.03495840f, -0.01651098f, 0.00324380f, -0.04181895f, 0.00137367f, -0.00790921f, 
    -0.00296797f, 0.01803548f, -0.02029284f, 0.00257270f, -0.04493999f, -0.02714508f, -0.01339647f, 0.00987535f, 
    0.02704300f, 0.01657945f, 0.01868076f, -0.00185206f, 0.03279848f, 0.01612397f, 0.01198286f, -0.01807970f, 
    0.02971833f, -0.02052881f, -0.00202376f, -0.01471240f, 0.00830117f, -0.03602586f, -0.00857792f, -0.01218732f, 
    -0.01445683f, 0.02231477f, 0.01386799f, 0.01291735f, 0.00632710f, -0.03132978f, -0.00155646f, 0.00589533f, 
    -0.00917605f, -0.00692187f, 0.01234182f, -0.00016859f, 0.02355073f, -0.02408681f, -0.02950422f, 0.02742828f, 
    0.00453089f, -0.01725187f, 0.02747632f, 0.00312499f, -0.02239256f, 0.01026021f, -0.03886962f, 0.02285968f, 
    -0.02480825f, -0.03517577f, 0.01841465f, -0.03873159f, -0.00799574f, 0.00211675f, 0.02379899f, 0.03403867f, 
    -0.02147520f, -0.02025223f, 0.03024734f, -0.01986571f, -0.04266750f, -0.02362055f, 0.00113418f, -0.00544871f, 
    -0.01357090f, 0.01389017f, -0.00632576f, -0.04020015f, -0.01668135f, 0.01700901f, -0.00803656f, -0.03152901f, 
    0.01515708f, -0.00130597f, -0.03488400f, -0.00520192f, 0.01095371f, -0.03612414f, 0.02500646f, 0.00518503f, 
    0.02102109f, 0.02773414f, -0.03036487f, 0.00230535f, -0.01663417f, -0.03199520f, 0.02991643f, -0.03028889f, 
    0.03305667f, -0.04540096f, -0.02851636f, -0.02866121f, 0.01748333f, 0.02707416f, -0.03955942f, 0.02824455f, 
    0.02555009f, 0.01303191f, -0.01397301f, -0.01488347f, -0.00965884f, 0.02688100f, -0.00068081f, -0.01998651f, 
    -0.03380373f, 0.02884228f, 0.01161848f, -0.01527793f, -0.03685141f, 0.02009479f, -0.00777242f, 0.03452387f, 
    0.00881266f, 0.00996934f, 0.01779205f, -0.01756299f, -0.00957347f, 0.01750439f, 0.00581350f, -0.01322561f, 
    -0.03066956f, 0.00775024f, -0.03330006f, -0.03483983f, -0.00549676f, 0.00721046f, -0.01269501f, 0.01847464f, 
    -0.03669350f, 0.01583135f, -0.03794817f, -0.04282332f, -0.00472141f, -0.00627650f, 0.00328382f, 0.03054762f, 
    0.01119250f, -0.03616583f, -0.02298917f, 0.00167139f, 0.00751222f, -0.02701431f, -0.00840367f, -0.00457239f, 
    -0.04108964f, 0.02562241f, -0.03070751f, 0.01861046f, -0.02017034f, -0.03007828f, 0.00410141f, -0.01267519f, 
    0.00466125f, -0.01004185f, 0.03027619f, -0.02580417f, 0.03338965f, 0.02755619f, -0.02574684f, -0.01915842f, 
    -0.03931939f, 0.02818948f, -0.04210621f, 0.00881451f, 0.00683445f, -0.02765216f, 0.01096346f, -0.04373339f, 
    0.00790944f, 0.01272694f, 0.00349023f, 0.01449655f, 0.00199167f, -0.01897112f, 0.01372543f, -0.02539519f, 
    0.02556594f, 0.03526228f, -0.00116296f, -0.00632396f, 0.01018511f, -0.01865250f, -0.00025061f, 0.01528730f, 
    0.00439331f, -0.01935837f, 0.01496504f, -0.01951071f, -0.03431482f, -0.03579461f, 0.00374533f, -0.03729160f, 
    0.02882566f, 0.00676456f, -0.01702127f, -0.01973421f, -0.00177316f, -0.00491784f, 0.02789977f, 0.04448136f, 
    0.01085862f, -0.01720288f, -0.01028354f, -0.03036931f, 0.01811135f, -0.03031152f, 0.02463819f, -0.04699710f, 
    -0.03377458f, -0.01153866f, -0.00294302f, 0.03157812f, -0.02018575f, -0.00493037f, -0.03993591f, -0.03573502f, 
    -0.00648288f, 0.02326410f, -0.01551006f, -0.01036392f, -0.03456527f, 0.00060975f, -0.00610044f, 0.02873335f, 
    -0.00255613f, 0.02372854f, -0.02627713f, -0.04356494f, -0.02415227f, -0.03564608f, 0.01365064f, -0.01330334f, 
    -0.00898353f, 0.01723540f, -0.03237513f, -0.03446657f, 0.00864112f, 0.02826156f, 0.02368710f, -0.01661488f, 
    -0.00700503f, 0.01171053f, 0.02637714f, 0.01161078f, 0.02006057f, -0.04508090f, -0.01522341f, -0.00969416f, 
    -0.01222807f, 0.00677211f, -0.02901353f, 0.01415860f, -0.00824402f, 0.00679516f, 0.03183129f, 0.01592445f, 
    -0.03870490f, -0.01793493f, -0.03047580f, -0.02924719f, 0.02552159f, -0.02681646f, 0.01315454f, 0.00440235f, 
    0.02494870f, -0.00044075f, -0.03246047f, 0.00284027f, 0.02725488f, -0.01958679f, -0.01484301f, 0.01823586f, 
    0.02169164f, 0.03279584f, 0.01046154f, -0.00888905f, 0.02915333f, -0.04152949f, 0.02005861f, 0.02196966f, 
    -0.01495860f, 0.02128725f, 0.01229314f, -0.00072358f, -0.04129159f, -0.03677089f, 0.02822340f, -0.02574275f, 
    -0.01446343f, 0.02747750f, 0.01219985f, -0.02872582f, -0.01717895f, 0.00372282f, -0.00863481f, 0.01014561f, 
    0.00864094f, 0.01868044f, -0.04450101f, 0.00880556f, -0.01860216f, 0.02236632f, 0.01807234f, -0.02993901f, 
    0.03166059f, 0.01021381f, -0.00208146f, -0.04566733f, -0.00343466f, -0.04343994f, -0.00977270f, -0.01081826f, 
    0.04161083f, -0.00756364f, -0.00873902f, 0.02228524f, -0.01018197f, -0.00893364f, 0.03064500f, 0.00656119f, 
    0.02367269f, -0.00569731f, -0.00214456f, -0.00615394f, 0.01173805f, 0.00987097f, 0.02503865f, 0.01651190f, 
    -0.04223378f, 0.00093942f, 0.02901377f, -0.04561251f, -0.02428978f, 0.00841456f, 0.01909856f, 0.00242435f, 
    0.01032333f, -0.03512482f, 0.00844089f, 0.04393005f, -0.00671854f, -0.01036465f, 0.00476763f, -0.00339126f, 
    -0.04443279f, -0.03115063f, -0.01390057f, -0.01453326f, -0.01456780f, 0.02233750f, 0.02222853f, 0.00155689f, 
    -0.01040970f, -0.00652356f, 0.00142046f, -0.01759005f, -0.03518189f, -0.02683608f, -0.00328766f, -0.03780113f, 
    -0.04150116f, 0.03004644f, 0.02493743f, -0.02143080f, -0.04011449f, -0.01738690f, -0.02172600f, -0.03107738f, 
    -0.02518677f, 0.02226074f, 0.01835031f, -0.04687686f, 0.03288616f, -0.00733516f, -0.00239498f, -0.03306740f, 
    -0.01463930f, 0.02278429f, 0.01064494f, -0.04512656f, -0.00213460f, 0.01094688f, -0.00980576f, 0.02020621f, 
    0.02559420f, -0.02322183f, 0.01868088f, -0.01390411f, -0.01884090f, 0.02573048f, -0.04033632f, -0.00097489f, 
    -0.01221859f, -0.03786629f, 0.02021650f, -0.01254774f, 0.02586374f, -0.03272687f, -0.02655304f, 0.00624955f, 
    -0.02310117f, -0.00561533f, -0.04146440f, 0.02663224f, 0.01689669f, -0.04146212f, -0.03137477f, -0.04210169f, 
    -0.02844885f, 0.02761497f, -0.01038287f, -0.00969242f, 0.03103142f, -0.04666368f, 0.03443412f, -0.01840598f, 
    0.00051489f, -0.01401049f, -0.01692831f, 0.02312180f, -0.02428304f, 0.02601910f, -0.01182638f, 0.03034556f, 
    -0.01561206f, -0.01441166f, -0.02612210f, -0.03572770f, 0.02196476f, 0.00065885f, 0.01518067f, -0.02750595f, 
    0.02754978f, 0.02192479f, 0.04011728f, 0.01487214f, -0.01759489f, -0.00818099f, -0.01827474f, 0.02550013f, 
    0.02541114f, -0.04362382f, -0.04241091f, 0.00735224f, -0.03863530f, -0.03456744f, 0.01359431f, -0.01382448f, 
    -0.03055498f, 0.01671124f, -0.01795281f, 0.00241846f, 0.00971597f, -0.00637037f, -0.03190080f, 0.00690331f, 
    0.02703763f, 0.21435721f, -0.02172399f, -0.15963295f, -0.10311554f, 0.04586734f, -0.00235080f, -0.07662311f, 
    0.01423367f, -0.12075163f, 0.02380123f, 0.07451557f, 0.09560596f, 0.08802203f, -0.03071639f, 0.02094303f, 
    -0.01928888f, -0.06260393f, 0.01824811f, -0.07145955f, 0.10770506f, -0.08540233f, -0.00014693f, 0.01365745f, 
    0.05809737f, 0.09056386f, 0.10673837f, -0.02924260f, -0.06791387f, 0.00759162f, -0.01774808f, 0.09275872f, 
    0.06191025f, -0.02146176f, 0.06114559f, -0.01002964f, 0.02863059f, -0.02532485f, 0.01705701f, -0.00079477f, 
    -0.09917486f, -0.20220678f, 0.01651757f, -0.07697606f, -0.17565052f, 0.03095266f, 0.00858909f, -0.07000994f, 
    0.08126678f, -0.02876464f, -0.01264748f, -0.03344358f, -0.05106299f, 0.07078423f, -0.03445640f, 0.13704933f, 
    0.02794698f, -0.01407545f, -0.17583962f, 0.03644848f, 0.08418600f, -0.19941898f, -0.02539497f, -0.10431029f, 
    -0.17673951f, -0.03745616f, -0.03829695f, -0.01393132f, 0.06573030f, -0.03524276f, -0.03171137f, 0.08462298f, 
    0.09656896f, 0.01346060f, 0.00891437f, 0.06202389f, 0.05504626f, 0.03754945f, 0.00380486f, 0.01978926f, 
    -0.06287058f, 0.06157428f, -0.07308556f, 0.00352909f, 0.00357513f, 0.07178486f, 0.03254089f, -0.05890425f, 
    0.02261304f, 0.03461591f, -0.02542995f, 0.00074852f, 0.04009504f, 0.08650701f, -0.06208900f, 0.03286408f, 
    -0.00122373f, -0.02633410f, -0.03973803f, 0.00476775f, 0.11154322f, -0.19276467f, -0.23477174f, -0.02978778f, 
    -0.03401364f, -0.04356158f, 0.07548409f, -0.01844986f, -0.03232187f, 0.05968832f, -0.05218517f, -0.02249600f, 
    0.08585168f, -0.05812414f, -0.00620460f, 0.02060584f, 0.01407739f, 0.09192208f, 0.04518805f, 0.06337783f, 
    0.29876986f, 0.29945627f, 0.09138917f, 0.16533846f, 0.20322697f, 0.00356347f, 0.05540104f, 0.05249028f, 
    -0.07396260f, -0.01679425f, -0.05152738f, 0.06771617f, 0.07004873f, 0.01777058f, 0.03930948f, 0.05281704f, 
    0.03766954f, 0.06012094f, 0.05663915f, 0.01032693f, 0.04365982f, 0.30788237f, 0.09098290f, 0.13712706f, 
    0.20419215f, 0.08507854f, -0.00192003f, 0.01407689f, 0.03604544f, -0.00802647f, -0.06336278f, 0.00497480f, 
    0.06127305f, 0.05015499f, 0.04155416f, 0.10173662f, -0.03331317f, 0.00926114f, 0.02840968f, -0.01713457f, 
    -0.23827198f, -0.29077992f, 0.11249933f, -0.12984197f, -0.07469576f, 0.02671751f, 0.02097341f, 0.12303609f, 
    0.06752242f, 0.04845288f, 0.04132493f, -0.07275411f, -0.05733040f, 0.01397743f, 0.10814820f, 0.04265397f, 
    0.05159538f, 0.02071015f, 0.04938709f, -0.05356754f, -0.14141363f, 0.18277082f, 0.26608536f, -0.09720860f, 
    -0.15694198f, 0.00237140f, 0.04777662f, -0.00002967f, -0.01128651f, -0.06669215f, 0.07587104f, 0.02177660f, 
    0.08715511f, 0.06530206f, 0.08606587f, 0.01681961f, 0.08783808f, 0.00906646f, 0.07090477f, 0.05396857f, 
    0.16626181f, 0.09808058f, 0.25997311f, -0.00501676f, 0.13800666f, -0.01728548f, 0.07559721f, -0.08754174f, 
    -0.02337134f, 0.04356575f, 0.10594160f, 0.04820906f, 0.00526980f, -0.05502635f, 0.06048008f, 0.04194777f, 
    0.07804333f, -0.09015775f, -0.01557692f, -0.01344585f, -0.23231830f, -0.15465726f, 0.13738179f, 0.04624000f, 
    0.12414558f, 0.08527188f, 0.04854724f, 0.01827917f, -0.15261601f, 0.00734201f, 0.10535099f, 0.08920077f, 
    0.13582413f, 0.05383489f, 0.12994504f, 0.00023959f, -0.07103296f, 0.01045263f, -0.05397793f, 0.04627746f, 
    0.28230125f, 0.25229624f, -0.04094207f, 0.20998956f, 0.28981772f, 0.14598571f, 0.06195276f, 0.05114758f, 
    -0.04170548f, -0.06153645f, 0.00027081f, 0.02779896f, 0.01929644f, -0.00833116f, -0.00852684f, -0.01746031f, 
    0.04634267f, 0.02349580f, -0.06190448f, -0.03285341f, 0.32183671f, 0.14856130f, 0.03942612f, 0.07346549f, 
    0.27285111f, -0.01407129f, -0.00801241f, 0.00818544f, 0.03700821f, -0.03636005f, -0.03428224f, -0.01455337f, 
    0.16734910f, 0.04286836f, 0.02120883f, 0.07175594f, -0.08542052f, 0.00393452f, 0.02086852f, -0.06331325f, 
    -0.29280075f, -0.19027215f, 0.10064804f, -0.07463939f, -0.14248718f, 0.03105780f, 0.01881103f, -0.00682293f, 
    0.03129856f, 0.11148816f, -0.02821840f, -0.04342230f, 0.00781127f, 0.05527045f, -0.01441608f, -0.11405459f, 
    0.11537018f, 0.01904468f, -0.03148253f, -0.07544287f, 0.21355553f, -0.35390481f, -0.06171683f, -0.10960995f, 
    -0.21673931f, 0.16899307f, 0.06151284f, -0.01210948f, -0.09891911f, -0.05318983f, 0.03742531f, 0.03137974f, 
    0.02554153f, 0.02664925f, 0.01939012f, 0.03911091f, 0.01479041f, 0.01635814f, 0.03773916f, 0.00119534f, 
    0.23042335f, 0.15523286f, 0.01655914f, 0.09416682f, 0.15331246f, 0.13798085f, 0.05376465f, -0.02009363f, 
    -0.02554565f, -0.07065783f, 0.05572131f, 0.02446762f, 0.00438912f, 0.12803407f, 0.06876753f, 0.01804840f, 
    0.03429485f, 0.02915705f, 0.02638667f, -0.02044469f, -0.06950727f, -0.11794507f, 0.24582444f, -0.04566034f, 
    -0.03326358f, -0.05705172f, -0.03364740f, 0.01931681f, -0.02748057f, 0.00473931f, 0.07298226f, -0.00283319f, 
    -0.05421045f, -0.02437542f, -0.00932511f, -0.02449060f, 0.12463854f, 0.00010507f, 0.07200260f, 0.03046113f, 
    0.16858213f, -0.05014213f, -0.01358609f, 0.01236626f, 0.00685362f, -0.07355838f, 0.02239157f, 0.03852769f, 
    0.07874280f, 0.06093325f, 0.11142953f, -0.01772209f, -0.06136869f, 0.04332253f, 0.06439365f, 0.14266448f, 
    0.03228202f, -0.03784895f, 0.00270558f, 0.08151419f, 0.29360566f, -0.18326727f, -0.05250905f, 0.01192679f, 
    -0.06664778f, -0.00202180f, 0.03599781f, 0.01447248f, -0.03744456f, 0.02480582f, 0.04855062f, 0.10751448f, 
    0.05958122f, 0.00520501f, -0.01729429f, 0.01875751f, -0.09423815f, -0.01929035f, 0.01094503f, 0.04835158f, 
    0.23766388f, 0.07527506f, 0.04299359f, 0.10947075f, 0.12092453f, 0.01602159f, -0.04907630f, -0.02282293f, 
    0.02076178f, 0.03866033f, -0.03998514f, -0.04460789f, -0.02393693f, 0.01946384f, 0.09666427f, 0.07922980f, 
    -0.06355252f, 0.05852937f, -0.02728290f, 0.06201377f, 0.05708268f, -0.16700055f, -0.10754336f, 0.00936671f, 
    0.03668266f, 0.01602397f, -0.04056330f, 0.04612229f, 0.12021416f, -0.02547921f, 0.00486705f, -0.02747042f, 
    0.07656728f, -0.09796989f, 0.02889081f, 0.03596701f, 0.00143336f, 0.05894849f, 0.03108494f, 0.02272130f, 
    0.06747880f, 0.07393278f, -0.00847764f, 0.02315077f, -0.02024192f, -0.09174498f, 0.11916173f, -0.01370603f, 
    0.04853131f, 0.03029561f, 0.08621208f, -0.02129068f, -0.04209638f, 0.03904321f, 0.01568664f, 0.02757920f, 
    -0.02886738f, -0.01396176f, -0.02128944f, 0.12885460f, 0.26193422f, 0.06185884f, 0.00443043f, -0.10787474f, 
    0.05862805f, -0.02771743f, 0.04972231f, 0.06737852f, 0.02260900f, -0.04133034f, -0.07598008f, 0.03929160f, 
    0.16092281f, 0.02530633f, -0.00853859f, 0.00056725f, -0.01935086f, -0.01616601f, 0.08157319f, 0.02023846f, 
    0.36868560f, 0.14533311f, -0.07258355f, 0.06489506f, 0.11956784f, 0.12356865f, 0.03791776f, 0.00487133f, 
    -0.02768594f, -0.05199088f, 0.05375023f, 0.02039819f, 0.06598139f, 0.08100899f, -0.00417923f, -0.01410602f, 
    0.03162090f, 0.04548988f, -0.00451489f, -0.05546349f, -0.34549141f, -0.07623655f, 0.07201655f, -0.25318381f, 
    -0.01970236f, 0.07829809f, -0.11064996f, 0.12879479f, 0.03622272f, -0.00601843f, 0.03258100f, 0.05656192f, 
    0.04826287f, 0.03471773f, 0.04387799f, 0.03726595f, -0.00237104f, 0.04764440f, 0.02179212f, -0.00594455f, 
    0.06383964f, 0.04269366f, -0.03895920f, 0.01131248f, -0.11269134f, -0.02109389f, 0.04500229f, 0.10186444f, 
    0.03552510f, -0.00090109f, 0.12863633f, -0.04784541f, -0.12755023f, 0.08817178f, 0.04131436f, 0.05050607f, 
    0.05193910f, -0.00553199f, -0.05995428f, 0.13425013f, 0.49000704f, 0.07291880f, 0.33338320f, -0.06399468f, 
    0.31757668f, -0.02866562f, 0.05219103f, 0.09372510f, 0.00905321f, 0.05551626f, -0.01930578f, 0.03745997f, 
    0.04080717f, -0.03029879f, 0.09339232f, -0.02180981f, 0.02808167f, -0.03683842f, 0.06085346f, -0.05965140f, 
    0.06865540f, -0.06769965f, 0.16891801f, -0.04721171f, 0.14940947f, -0.02530938f, -0.01573419f, -0.01326049f, 
    0.05743750f, -0.00766762f, 0.01096292f, -0.05009254f, -0.04560168f, -0.01066459f, -0.08967223f, 0.02596187f, 
    0.03171324f, 0.00882520f, 0.03451301f, -0.01614205f, -0.17017794f, -0.18851808f, -0.04222846f, -0.15693939f, 
    -0.16338976f, 0.03394613f, -0.00771573f, -0.01226928f, 0.03802282f, -0.04622749f, -0.05942433f, 0.05818968f, 
    0.10537955f, 0.05377131f, 0.00054334f, -0.06099242f, 0.01499106f, -0.02080711f, -0.10345408f, -0.04653542f, 
    0.25424185f, 0.31483710f, 0.01724691f, 0.09271125f, 0.28372911f, 0.10095496f, -0.02412863f, -0.03645253f, 
    0.06396945f, 0.01899429f, 0.01064938f, -0.01296267f, 0.07898537f, 0.07012149f, 0.04406599f, 0.01277526f, 
    0.00714761f, 0.07648361f, 0.04877707f, -0.08176591f, 0.21004415f, -0.17395246f, 0.20662363f, -0.20354921f, 
    0.07820769f, -0.10433694f, 0.02278413f, 0.03905572f, -0.10641561f, 0.05093268f, 0.01032961f, 0.14403042f, 
    0.01430383f, -0.05012691f, 0.01294988f, -0.01227063f, 0.01166454f, -0.00184211f, 0.15079932f, 0.08703960f, 
    -0.00147778f, -0.02275350f, -0.03290304f, -0.00204264f, 0.02168801f, -0.00520985f, -0.04320214f, -0.01741037f, 
    -0.00247777f, -0.03913151f, -0.01501433f, 0.01572616f, -0.04651456f, -0.03511788f, 0.01627702f, 0.01131624f, 
    -0.00884706f, -0.03477200f, -0.02393858f, 0.01137688f, -0.03142926f, 0.00274890f, 0.02436426f, -0.01118349f, 
    -0.04097533f, -0.02646075f, -0.00372857f, -0.02066335f, -0.00447512f, -0.02669510f, 0.03240477f, -0.03796226f, 
    -0.02292950f, 0.02765729f, 0.00064204f, 0.02761754f, 0.01445939f, -0.03368241f, -0.01881636f, -0.01803086f, 
    -0.01076139f, 0.00713975f, -0.00361595f, -0.02559795f, -0.00167405f, -0.02869596f, 0.01478424f, -0.02665680f, 
    -0.03762305f, 0.00952855f, 0.01656353f, -0.00029260f, -0.00998200f, -0.02811140f, 0.01733849f, 0.00572696f, 
    0.02606054f, -0.02062534f, -0.04162376f, 0.01013077f, 0.00402323f, 0.01006246f, 0.02047742f, 0.00137384f, 
    -0.00338594f, -0.01561715f, -0.01013720f, -0.02842648f, -0.01554875f, -0.01544003f, -0.03106067f, 0.02086481f, 
    0.00615193f, -0.02858537f, 0.02087222f, 0.00898410f, -0.02173732f, 0.02695779f, -0.01226937f, -0.00749014f, 
    -0.04622925f, -0.04091350f, 0.01967057f, -0.01924557f, 0.00508658f, -0.03139767f, 0.01043392f, 0.00314320f, 
    0.02491084f, 0.02754670f, -0.02897384f, -0.01662974f, 0.02378185f, 0.00407214f, -0.02336252f, -0.03639983f, 
    -0.00590344f, 0.02613501f, -0.00336838f, 0.00027354f, 0.00856908f, 0.01951746f, -0.00035456f, 0.03179302f, 
    -0.01775535f, -0.02921426f, -0.01159415f, 0.01039736f, 0.01387719f, 0.01563314f, 0.02891213f, 0.01562568f, 
    0.00244216f, -0.01727271f, -0.03525810f, -0.04236016f, 0.00421950f, -0.04166240f, 0.03263606f, -0.04607444f, 
    -0.01098895f, -0.02767143f, -0.02749834f, 0.01880416f, 0.01278491f, -0.00724963f, -0.02468077f, -0.00518384f, 
    -0.03163742f, -0.02746099f, 0.03131426f, -0.04011341f, 0.00807794f, 0.01370558f, -0.00635588f, 0.01413794f, 
    -0.03994042f, -0.00933492f, -0.01084725f, -0.03098130f, 0.04473140f, -0.02079074f, 0.00961812f, 0.01458084f, 
    -0.01834428f, -0.00937939f, 0.01448122f, 0.00953399f, -0.04025335f, 0.00540564f, 0.04428142f, -0.01522021f, 
    -0.04321059f, -0.03509495f, -0.01708559f, 0.01399336f, -0.04482495f, -0.01690369f, 0.00032293f, 0.03151024f, 
    -0.03011153f, 0.02758308f, 0.03269019f, 0.02325502f, -0.01097829f, 0.02477392f, 0.02522307f, 0.03478917f, 
    0.02466843f, -0.02163341f, -0.03638189f, -0.00213901f, 0.01554662f, 0.01147282f, 0.01981437f, -0.00400146f, 
    -0.02490694f, -0.01587913f, -0.01827540f, 0.01527594f, 0.01623939f, 0.03408389f, -0.03336247f, -0.01380190f, 
    -0.01090466f, 0.00817125f, 0.00176385f, 0.00555651f, 0.01720040f, -0.00802077f, -0.02738211f, 0.01132734f, 
    0.02184520f, 0.03349688f, -0.01454650f, -0.03954354f, -0.03666415f, -0.01092707f, 0.01808422f, -0.02083109f, 
    0.01148702f, -0.02961679f, 0.01144068f, 0.01591601f, 0.01250911f, 0.02537558f, -0.02428328f, -0.01050602f, 
    0.02607413f, -0.03275605f, 0.02129914f, -0.03632388f, 0.03096381f, -0.02813851f, 0.01365115f, -0.01191157f, 
    -0.00836022f, -0.00142679f, -0.01826456f, 0.02711106f, -0.02381040f, 0.01071659f, -0.02418802f, -0.00061556f, 
    0.01145603f, -0.02867757f, 0.03017934f, 0.04061983f, -0.00304466f, -0.03808184f, -0.03414432f, -0.00816381f, 
    -0.04324603f, -0.01851550f, 0.01510398f, -0.02528036f, 0.02532362f, -0.00331008f, 0.02495615f, -0.02391964f, 
    0.03575202f, 0.00361452f, -0.00688066f, -0.03001912f, -0.01650735f, -0.00243324f, 0.02444181f, -0.03804552f, 
    0.00380427f, -0.01995143f, -0.03079521f, -0.03165244f, 0.03574334f, -0.03790367f, 0.00053267f, -0.03258716f, 
    -0.00850695f, -0.01874173f, 0.00480144f, -0.02763506f, 0.02724313f, -0.00677620f, -0.02132305f, -0.00484406f, 
    -0.03417264f, -0.01801519f, -0.01085005f, -0.02316889f, 0.02036028f, -0.04551095f, -0.01478173f, 0.03183847f, 
    0.01233936f, 0.02297740f, -0.03349223f, 0.01153066f, 0.01204208f, 0.02488262f, -0.00938997f, 0.02769207f, 
    0.00397412f, -0.02155762f, -0.00566686f, -0.01512555f, 0.00478915f, -0.02953561f, -0.03750653f, 0.01092921f, 
    -0.04017637f, 0.01532385f, 0.00344164f, -0.00384831f, 0.02610582f, -0.01246865f, -0.02128630f, -0.00698589f, 
    -0.01541745f, -0.02562865f, -0.02297011f, -0.01358794f, 0.00421744f, 0.01966061f, 0.02377215f, -0.03419359f, 
    -0.00836769f, 0.00564146f, -0.04221509f, -0.02176818f, -0.00138015f, -0.03552225f, -0.00016028f, -0.03847304f, 
    -0.00784330f, -0.02097147f, -0.01982813f, 0.02781892f, -0.01804498f, -0.00213380f, -0.03298221f, 0.00185888f, 
    -0.04080788f, 0.01901418f, -0.02753220f, -0.04081877f, -0.01565249f, -0.02526063f, -0.00625060f, 0.01694138f, 
    -0.02811144f, -0.02462670f, -0.00031293f, 0.03180405f, 0.01077968f, -0.01661517f, -0.00202035f, -0.03786507f, 
    -0.02953934f, 0.01325801f, 0.01300230f, -0.02812009f, -0.01645662f, -0.01675636f, 0.02306118f, 0.01409532f, 
    -0.03020536f, -0.03080088f, 0.02864824f, -0.02514265f, -0.01928008f, 0.00724637f, -0.02840831f, -0.03828437f, 
    0.00170704f, -0.01222049f, -0.01093698f, 0.02996062f, 0.02146727f, -0.02476137f, -0.02465286f, 0.03935045f, 
    -0.03285759f, -0.01026926f, -0.02705185f, -0.02083911f, 0.00758048f, 0.00226628f, -0.00790705f, 0.03005720f, 
    -0.01104077f, -0.04284233f, 0.01608617f, -0.00059858f, 0.00104915f, -0.00529765f, -0.00776454f, -0.04109443f, 
    0.01844142f, 0.00004004f, 0.03048114f, -0.00874840f, -0.01699954f, 0.01751754f, -0.02516302f, -0.00529866f, 
    0.02110910f, -0.03687466f, -0.01749287f, -0.00755443f, 0.02331175f, -0.02556863f, 0.00845473f, -0.00742656f, 
    0.01206252f, -0.01252768f, -0.02909540f, 0.02311441f, 0.00922066f, 0.00362872f, -0.00712435f, -0.00402706f, 
    -0.03366819f, -0.00654060f, -0.03468327f, 0.01966356f, -0.00870450f, 0.02143387f, -0.03818756f, 0.00837949f, 
    0.01140344f, -0.00663290f, -0.00151378f, 0.01824653f, -0.00584735f, -0.04110528f, 0.00963235f, 0.02340912f, 
    0.02141649f, 0.03160157f, -0.00964683f, -0.04514565f, -0.00278277f, 0.00576202f, -0.02349251f, -0.03311227f, 
    0.00036104f, 0.03684719f, 0.00380316f, 0.00805587f, -0.02230954f, -0.04281338f, 0.01704123f, -0.01987766f, 
    -0.03690264f, -0.00341838f, -0.00406373f, 0.01729024f, -0.02976009f, 0.01979793f, -0.00389635f, -0.04219732f, 
    -0.03650275f, -0.04076337f, 0.01848011f, -0.00095257f, 0.00140781f, 0.03021888f, -0.00587211f, -0.00601594f, 
    -0.01246797f, -0.00024979f, -0.02984498f, 0.02880871f, -0.04494676f, -0.00590691f, -0.03143997f, -0.03168078f, 
    -0.04251334f, 0.00552590f, -0.00606482f, 0.00809527f, 0.02686916f, -0.00815955f, 0.00132597f, -0.00866250f, 
    -0.03519422f, 0.02496680f, 0.00753687f, 0.01264666f, -0.02256866f, 0.01433551f, 0.00327816f, -0.00742698f, 
    0.01777366f, -0.02124908f, 0.01411724f, 0.01784265f, -0.01982041f, 0.03095149f, 0.03263922f, -0.02096265f, 
    0.02306516f, 0.02181190f, -0.03026797f, 0.00736166f, 0.01230342f, 0.01289389f, -0.03428749f, 0.02382427f, 
    -0.01468423f, -0.02076230f, -0.01616934f, -0.02560787f, -0.03320057f, -0.04021389f, -0.00644012f, -0.04218484f, 
    0.02999943f, 0.01660842f, 0.01325500f, -0.01317068f, 0.02551420f, -0.00759629f, 0.02596179f, 0.00935506f, 
    -0.02055700f, 0.00500609f, 0.00268692f, -0.03850527f, -0.01243762f, -0.02434659f, 0.01458486f, -0.03795186f, 
    -0.02920757f, -0.00524959f, -0.01737085f, 0.02125037f, 0.03305887f, -0.01088890f, 0.01946431f, 0.00188275f, 
    -0.03726583f, -0.04464757f, 0.02535339f, 0.02561383f, -0.00567543f, 0.00594846f, 0.02806628f, 0.00568712f, 
    0.02832003f, 0.01192999f, -0.01765767f, -0.01766618f, -0.03415795f, -0.02523261f, -0.00014847f, 0.03295701f, 
    -0.04412996f, -0.03012146f, -0.00406250f, 0.01752091f, -0.04143853f, -0.02895702f, -0.00680350f, 0.01217480f, 
    -0.02102864f, 0.02701415f, -0.01132741f, 0.00844472f, -0.03743522f, -0.01406211f, -0.00338428f, 0.01849376f, 
    0.01547061f, -0.00022446f, 0.02303109f, 0.01834919f, -0.01693424f, 0.02325019f, 0.00136523f, 0.01783387f, 
    -0.03952719f, 0.02335904f, -0.03518663f, -0.01190112f, 0.00697627f, 0.01015282f, -0.04282510f, 0.03243204f, 
    -0.01478740f, -0.04488896f, -0.00561086f, -0.04587642f, -0.02498064f, -0.02848087f, 0.01290103f, -0.02022181f, 
    -0.01700467f, -0.03855535f, 0.00581166f, 0.00493317f, -0.00434945f, 0.01449726f, 0.02125528f, -0.02727594f, 
    0.02284784f, -0.03444061f, -0.02604774f, -0.00620207f, -0.04493108f, 0.01521664f, -0.01941697f, -0.03318437f, 
    -0.03224850f, 0.01166840f, 0.01148160f, -0.00492960f, 0.01950476f, -0.01933958f, -0.02777293f, 0.01420344f, 
    0.00756395f, -0.01786976f, 0.02803736f, -0.03574521f, -0.00999752f, 0.02932005f, -0.02006976f, -0.01034229f, 
    -0.00903452f, -0.00076239f, 0.00377027f, -0.03933834f, -0.02541770f, 0.00692369f, -0.03157810f, 0.02357144f, 
    -0.01767747f, 0.00493266f, -0.01159861f, 0.01734986f, -0.03038151f, -0.02045465f, 0.02770910f, -0.00626165f, 
    0.01316782f, -0.00989482f, -0.01458101f, 0.02223798f, -0.00509936f, 0.00825404f, 0.02361808f, -0.01197749f, 
    -0.02471752f, 0.00214609f, -0.03947087f, -0.04483116f, 0.03459340f, -0.00020553f, -0.00028353f, -0.00525146f, 
    0.28004915f, 0.20845746f, 0.09867207f, -0.13556170f, -0.23691680f, 0.02697174f, 0.02609294f, -0.05548961f, 
    0.08108214f, -0.02307147f, 0.06820941f, -0.02193102f, 0.06740208f, 0.08739105f, 0.11446966f, -0.00399041f, 
    0.12274209f, -0.03403775f, 0.03490806f, -0.02097652f, 0.01805134f, -0.05197268f, -0.23457241f, -0.14925547f, 
    0.05193791f, -0.03401197f, -0.17303130f, -0.00864835f, 0.03206249f, -0.00139211f, -0.08018751f, 0.01580049f, 
    0.08245213f, 0.16696334f, 0.08378661f, 0.01529583f, -0.00156583f, -0.03256704f, -0.19354968f, -0.04514879f, 
    0.11676938f, -0.10498643f, -0.02442102f, -0.05304496f, 0.04876177f, -0.14058147f, -0.02171987f, 0.02829541f, 
    -0.05667683f, -0.09996952f, 0.02223678f, -0.04031953f, 0.05301805f, 0.08603448f, -0.05711587f, 0.12790945f, 
    -0.11095996f, -0.23100449f, 0.09286842f, -0.07458063f, 0.23926072f, 0.16017732f, -0.21530515f, 0.07131031f, 
    0.10162092f, -0.10923239f, 0.04314223f, 0.04075360f, 0.06966182f, 0.00729663f, -0.08292922f, 0.00052652f, 
    0.08442350f, 0.05837752f, 0.11686263f, 0.11365627f, 0.05603537f, 0.14649881f, 0.11878972f, 0.03024943f, 
    0.14403655f, -0.12762208f, -0.03222011f, 0.04817391f, 0.03820440f, -0.00945486f, 0.01926746f, -0.13442694f, 
    0.06895231f, -0.01886727f, -0.02123355f, 0.06168358f, 0.06874316f, -0.02235625f, -0.03247200f, 0.00493198f, 
    0.08802533f, -0.02321699f, -0.15738587f, -0.02419885f, 0.32968566f, -0.20012346f, -0.17356792f, -0.06762966f, 
    0.12834486f, -0.10033477f, -0.05035909f, -0.00514996f, 0.05787730f, 0.02877419f, 0.03310552f, 0.01025885f, 
    0.01573546f, -0.00008275f, -0.06956573f, 0.00219545f, 0.05204031f, -0.03201258f, -0.04699384f, -0.06426722f, 
    -0.03587443f, -0.01842200f, -0.04770704f, -0.15843727f, -0.15617912f, 0.14774911f, 0.10523660f, 0.05894273f, 
    -0.07384244f, -0.02290091f, -0.01463278f, 0.00530881f, -0.03672512f, 0.05895520f, 0.02838808f, 0.14332753f, 
    -0.11373073f, 0.02295249f, -0.01100660f, 0.01009098f, -0.01431265f, 0.25588763f, -0.04215836f, -0.21147771f, 
    -0.09635671f, 0.10176405f, -0.04707300f, 0.03949839f, 0.04084947f, -0.01129804f, 0.01055602f, -0.01924727f, 
    0.01374553f, 0.10374796f, 0.11848640f, 0.00174798f, -0.08590070f, 0.06608787f, -0.13778417f, 0.02671215f, 
    -0.04582386f, -0.03787009f, -0.02289088f, 0.05497154f, 0.20744197f, 0.06964422f, -0.03705865f, 0.03859772f, 
    -0.06968354f, 0.04808792f, 0.05682678f, -0.05982948f, 0.03730586f, 0.04037165f, -0.04105097f, 0.14387302f, 
    0.08970720f, 0.06791374f, -0.14883967f, -0.02936262f, -0.02684284f, 0.18175659f, -0.05324043f, -0.22238158f, 
    -0.02975665f, 0.08507150f, -0.12601602f, 0.01975765f, 0.14400850f, 0.03769140f, -0.06490703f, -0.05667337f, 
    0.14433387f, 0.04094088f, 0.15272214f, 0.13291971f, 0.10783139f, -0.06283654f, -0.08195708f, 0.09142280f, 
    -0.04977370f, 0.07513645f, 0.41005689f, -0.10877921f, 0.07057621f, 0.06851084f, 0.09136728f, 0.08255539f, 
    0.05650150f, 0.16427343f, 0.11799762f, -0.08406186f, 0.07265725f, -0.12393726f, -0.05971765f, 0.01769859f, 
    -0.06877372f, -0.00345794f, -0.08461153f, -0.00088279f, -0.27342340f, -0.27468592f, -0.07458654f, -0.19578260f, 
    -0.18888849f, 0.03478992f, 0.07129698f, -0.02770580f, -0.07901377f, 0.00500060f, -0.00712999f, 0.05005228f, 
    -0.00988522f, 0.02010605f, 0.05251382f, 0.09264930f, -0.06304049f, -0.13568883f, -0.04563041f, -0.09549416f, 
    0.21807724f, -0.15535812f, 0.07584934f, -0.13445680f, -0.14649509f, -0.01682807f, 0.10599553f, 0.05595877f, 
    -0.03887603f, -0.02365510f, 0.01794099f, 0.03126537f, -0.04546904f, -0.02478375f, 0.01751779f, 0.02032630f, 
    -0.05155117f, 0.08790549f, -0.06184586f, 0.06990127f, -0.00561364f, -0.38989827f, 0.07544965f, -0.21213761f, 
    -0.14216250f, -0.00177637f, 0.14032795f, -0.06529840f, 0.00643321f, 0.00804936f, 0.07039063f, 0.02478115f, 
    0.11302453f, 0.16325893f, 0.09007589f, 0.05491759f, -0.07320786f, 0.01324468f, -0.05675789f, -0.04436927f, 
    0.00747827f, 0.04262137f, -0.07334705f, -0.02979295f, 0.01237249f, 0.04977482f, -0.02146523f, -0.05947805f, 
    -0.08018566f, -0.02477532f, 0.02700723f, -0.11250785f, -0.01927892f, 0.11386772f, -0.05404287f, 0.02115684f, 
    0.18621029f, -0.03036415f, -0.08209044f, 0.04909667f, 0.34453800f, 0.08204555f, -0.02218514f, 0.03879732f, 
    0.18673694f, -0.00296644f, 0.17917919f, -0.05838932f, 0.00637635f, 0.07981763f, 0.02594509f, 0.02490644f, 
    -0.03746694f, 0.05405634f, -0.08266632f, 0.09912550f, -0.00980834f, 0.15340711f, 0.04302357f, -0.02637909f, 
    0.41198841f, 0.01364534f, -0.02568789f, -0.40637371f, -0.13501945f, 0.09287274f, 0.03649635f, -0.02542687f, 
    0.01575217f, -0.02315918f, -0.07018119f, 0.00875274f, -0.07105543f, 0.09174001f, 0.05650155f, -0.00593995f, 
    0.04646992f, 0.02893298f, -0.06172815f, -0.00396727f, -0.16063488f, 0.02914583f, 0.13430926f, 0.43984234f, 
    0.10846192f, 0.00674145f, 0.04357708f, 0.11470307f, 0.01253336f, 0.04742688f, -0.09483473f, 0.01514864f, 
    0.04768007f, -0.08490441f, 0.02976733f, -0.06179168f, 0.05960897f, 0.20072672f, -0.06136351f, -0.12468230f, 
    0.29879484f, -0.11495034f, 0.17705587f, 0.11897752f, 0.06299336f, 0.07838643f, -0.02672882f, -0.05444900f, 
    -0.00206702f, 0.05922556f, 0.04517288f, -0.02136354f, -0.10350782f, -0.07966702f, -0.04979606f, 0.01303098f, 
    -0.06193003f, -0.05931442f, 0.01254815f, -0.02474537f, 0.26546398f, -0.10915661f, -0.11726569f, -0.02138577f, 
    0.17741156f, 0.02645919f, 0.02768551f, -0.01127597f, 0.06262963f, 0.03810508f, 0.02529956f, 0.06873991f, 
    -0.01446100f, -0.02073474f, 0.00814840f, 0.07231489f, -0.03793392f, 0.06834181f, -0.09138848f, 0.08396491f, 
    0.11857287f, -0.17043306f, 0.14425008f, -0.15354452f, -0.10716288f, 0.16309048f, 0.07439120f, -0.00946001f, 
    0.06192883f, -0.00085547f, -0.08080594f, -0.00000988f, -0.04053048f, 0.01099014f, 0.03732859f, -0.02239615f, 
    -0.07843398f, 0.06402641f, -0.06431641f, 0.08763807f, 0.02299376f, -0.33672908f, -0.00388269f, 0.14144517f, 
    0.06878269f, 0.01144891f, -0.03333089f, -0.01918093f, 0.06458586f, -0.06521535f, 0.02058619f, 0.01045338f, 
    0.14955269f, -0.02027170f, 0.08624928f, 0.02101582f, 0.01732658f, 0.01874851f, -0.00307845f, 0.02879598f, 
    0.41570765f, 0.30789742f, -0.04343716f, 0.23627207f, -0.07773598f, 0.05645355f, 0.06003839f, -0.01292734f, 
    0.04215662f, 0.01268153f, 0.02521017f, 0.17011470f, -0.07283180f, -0.10048825f, -0.05503305f, 0.01111937f, 
    -0.00562622f, -0.09256407f, -0.08575728f, 0.04192494f, 0.09365728f, 0.00410724f, -0.07639310f, 0.11154319f, 
    -0.04160754f, -0.21019505f, 0.14409240f, 0.01933372f, 0.05842736f, -0.01537575f, 0.06159031f, 0.03480034f, 
    0.15331313f, 0.03743112f, 0.07111825f, 0.03954856f, 0.07013066f, 0.13704923f, 0.02103910f, 0.15592314f, 
    0.65662324f, -0.07890625f, -0.11145244f, -0.25977501f, -0.19971159f, -0.02223704f, 0.10932261f, -0.11332645f, 
    0.01663485f, -0.02031425f, -0.02284185f, 0.02527886f, -0.04892659f, 0.11838751f, 0.01226540f, -0.01675024f, 
    0.02832958f, 0.09392444f, 0.00804514f, 0.01199191f, -0.11245574f, 0.23204501f, -0.11548725f, -0.21725878f, 
    0.05330361f, 0.05308278f, -0.12133972f, 0.07102223f, 0.04671106f, 0.04194115f, -0.04010401f, 0.09895910f, 
    0.06956311f, -0.09109338f, -0.08731523f, 0.03859976f, 0.03292110f, 0.08154911f, 0.04217390f, 0.02035966f, 
    0.55516893f, 0.19673842f, -0.11568663f, 0.16289327f, -0.11953136f, 0.00968036f, 0.10986283f, 0.02619063f, 
    -0.06339177f, -0.03009146f, 0.00975850f, 0.05564361f, -0.07988876f, -0.00461199f, -0.03322811f, -0.06491440f, 
    -0.04541514f, -0.02286507f, -0.10054708f, 0.04740180f, 0.00338746f, -0.17075436f, -0.06302581f, -0.13130419f, 
    -0.10040251f, 0.12117228f, 0.13704327f, 0.30006731f, 0.00000256f, 0.11204104f, 0.05562582f, 0.04612907f, 
    -0.10954233f, -0.10241887f, -0.04103878f, -0.03956218f, -0.00952682f, 0.01839021f, -0.00513622f, -0.14802887f, 
    -0.12030008f, 0.19476493f, 0.31152087f, -0.20994692f, 0.01215196f, 0.11064815f, 0.06114468f, 0.00679733f, 
    0.00994009f, -0.05089622f, 0.01931157f, -0.01120869f, 0.01761506f, 0.01464593f, 0.00169250f, 0.07679630f, 
    0.04546950f, 0.05737377f, -0.00839941f, 0.15323320f, -0.15695754f, -0.17216906f, -0.06334569f, 0.09728809f, 
    0.09246587f, -0.10769799f, -0.10409905f, -0.03255436f, 0.08823982f, -0.13791361f, -0.02595951f, -0.00953906f, 
    0.07437263f, 0.05896630f, -0.01030162f, 0.09313645f, -0.09730658f, -0.11122015f, -0.10815798f, -0.07261916f, 
    0.21284874f, -0.02172414f, -0.07497742f, -0.10549900f, -0.23449352f, 0.08855907f, 0.10095465f, 0.03593247f, 
    0.01836321f, 0.01415069f, 0.05006520f, 0.09399721f, -0.00353775f, -0.01244521f, 0.10251497f, -0.01708862f, 
    0.01805053f, 0.06770142f, -0.05845244f, 0.04993320f, -0.02160446f, -0.03888636f, 0.17373827f, -0.16428480f, 
    0.04460545f, 0.23121384f, 0.03494018f, -0.06486944f, -0.05416801f, 0.16311024f, 0.03981361f, 0.20328228f, 
    0.11142205f, -0.06494935f, -0.06125269f, 0.05248209f, 0.01658785f, 0.06996942f, 0.15278146f, -0.08787243f, 
    -0.02341469f, 0.00310297f, 0.02900154f, -0.02250069f, -0.00810593f, -0.03202997f, -0.01776549f, 0.02282484f, 
    -0.03593265f, 0.01315924f, -0.01693903f, 0.02404649f, -0.01997115f, -0.02540942f, -0.00223154f, -0.02643421f, 
    0.01174024f, 0.03124139f, 0.02867300f, 0.03262875f, -0.04285673f, -0.03145181f, 0.03093445f, 0.01308334f, 
    -0.00767418f, -0.03099258f, 0.01860360f, -0.02745771f, 0.03124525f, -0.03450773f, 0.00789081f, -0.03197445f, 
    -0.01336459f, -0.03776047f, 0.03453993f, -0.02331693f, -0.03294863f, 0.00852693f, -0.04452807f, 0.00858805f, 
    0.03026977f, -0.02795239f, 0.01644409f, 0.02639779f, 0.00627318f, -0.00209929f, -0.03638218f, -0.02365854f, 
    -0.00848804f, -0.02393818f, 0.02070285f, -0.00241284f, -0.01610626f, 0.03033563f, -0.03375475f, 0.01953118f, 
    0.03325188f, -0.02614347f, 0.01225336f, 0.00635236f, -0.03434930f, -0.01560183f, 0.00693844f, -0.01309621f, 
    -0.02211542f, -0.03829621f, -0.03625023f, -0.03946041f, 0.00393437f, -0.02180727f, -0.04206153f, -0.01689343f, 
    0.02941342f, -0.02980314f, -0.03914890f, 0.00855802f, 0.03228593f, 0.02593062f, 0.02620015f, 0.00907428f, 
    0.01033151f, -0.02567081f, 0.01357231f, -0.02101604f, -0.00520193f, 0.03279206f, -0.02053984f, -0.00481645f, 
    -0.02416919f, -0.01704164f, -0.00711586f, -0.01260567f, -0.02191040f, -0.02165718f, -0.00895536f, -0.01917225f, 
    0.02887456f, 0.02373119f, -0.00294085f, -0.02460829f, -0.03470413f, -0.03729253f, -0.04433972f, 0.00307799f, 
    0.02894557f, -0.00944655f, -0.00345486f, -0.02837560f, 0.01705157f, 0.00451309f, -0.01835531f, -0.00015124f, 
    -0.01272011f, -0.00280929f, 0.00453897f, -0.02543946f, -0.03727841f, -0.02096004f, 0.02767958f, -0.00505486f, 
    0.00730751f, -0.03842796f, -0.02009276f, 0.01814150f, -0.00869076f, -0.01246932f, -0.02798860f, -0.02444221f, 
    -0.01174488f, 0.03719415f, -0.04321297f, -0.01682478f, 0.02037376f, -0.00190258f, 0.03502098f, -0.02413920f, 
    0.01003483f, -0.01671133f, 0.01690696f, 0.01284552f, -0.03341444f, 0.00196097f, -0.00450341f, -0.02774628f, 
    0.02301385f, 0.02013655f, 0.02266364f, -0.00244790f, 0.03174146f, -0.00881525f, -0.04262973f, -0.04319146f, 
    0.02458903f, 0.00906366f, -0.03109161f, 0.00471066f, -0.03490282f, 0.02519935f, 0.03266613f, -0.00493371f, 
    -0.02069531f, -0.03943526f, -0.01308045f, -0.02762638f, -0.02846109f, -0.01663683f, -0.00251868f, -0.02598267f, 
    -0.00611663f, 0.02056117f, -0.03002995f, -0.02030330f, -0.02096345f, -0.01857734f, 0.01055361f, -0.01327423f, 
    -0.00350865f, -0.03388183f, 0.02984807f, 0.00527820f, 0.01086246f, 0.01364656f, 0.02833967f, -0.01463187f, 
    0.00368797f, 0.00095744f, -0.03832589f, 0.02482911f, 0.00284144f, 0.02593790f, 0.02243275f, 0.01664197f, 
    -0.02911470f, 0.03376315f, -0.02360964f, -0.01218360f, -0.02670566f, -0.03159046f, -0.01948006f, -0.02610255f, 
    -0.01397345f, 0.00434183f, -0.00818619f, 0.01349941f, -0.03593662f, -0.04371715f, 0.02466380f, -0.00834889f, 
    0.03696935f, -0.02940490f, 0.01996900f, 0.01492706f, 0.00112090f, -0.02824189f, -0.00338954f, -0.03148904f, 
    0.03371517f, 0.01310627f, 0.00472311f, -0.04175350f, 0.01537545f, 0.02654839f, 0.03190816f, -0.02766113f, 
    -0.02681581f, -0.02659744f, -0.02092081f, -0.00789629f, -0.01573457f, -0.01797038f, 0.00070347f, 0.02676513f, 
    -0.02525952f, 0.00215089f, -0.00991831f, 0.03223226f, 0.03000497f, 0.00257809f, -0.00050031f, -0.02947501f, 
    0.01916051f, -0.03320562f, -0.01243310f, -0.02927170f, -0.02377482f, -0.00130778f, -0.04025281f, 0.00368098f, 
    0.00690469f, -0.02710937f, 0.01713066f, 0.00186277f, 0.00677329f, -0.00429500f, -0.03447969f, 0.00189125f, 
    0.01293488f, 0.01182353f, 0.02982284f, 0.00812513f, 0.03340305f, -0.03600799f, -0.02377307f, -0.03822709f, 
    -0.03118476f, 0.02077318f, 0.00902672f, -0.02105432f, 0.00003458f, 0.01567433f, 0.00652479f, 0.02444847f, 
    0.00286257f, -0.03174352f, -0.03793102f, -0.02871448f, -0.03814911f, -0.04441236f, 0.02667334f, -0.03236568f, 
    0.00384836f, 0.00886985f, -0.01484643f, -0.01458895f, 0.01799362f, 0.00251791f, -0.02161236f, -0.03695210f, 
    -0.00014652f, 0.00234807f, -0.03792025f, 0.02179277f, -0.02393338f, -0.01607930f, -0.02993485f, -0.02382096f, 
    0.02598586f, 0.02172581f, -0.04082974f, 0.01425375f, 0.02859777f, 0.01941332f, 0.00682384f, -0.00169260f, 
    -0.03902084f, -0.01259098f, -0.00367953f, -0.03419440f, 0.02062285f, 0.04476946f, -0.01566186f, 0.03082148f, 
    -0.04174474f, 0.01515097f, 0.01563610f, 0.01148826f, -0.02960726f, -0.01614798f, 0.00842280f, -0.03485525f, 
    -0.00570954f, -0.00580660f, -0.00746649f, -0.02100536f, -0.04480970f, -0.03958026f, 0.02838876f, 0.00042999f, 
    0.03348218f, 0.02760286f, 0.03076013f, 0.01549923f, 0.02474719f, 0.03177825f, 0.03702180f, 0.01204354f, 
    0.01785151f, 0.01705637f, -0.03213236f, -0.04327706f, 0.03546130f, 0.01156520f, -0.01951515f, -0.03862468f, 
    -0.00384363f, -0.04232658f, -0.03053984f, 0.03190842f, -0.01839587f, -0.00189911f, 0.02631351f, -0.02262622f, 
    -0.02912116f, 0.00703412f, 0.01755807f, 0.01530288f, -0.00822253f, -0.00118645f, 0.01080414f, -0.02886566f, 
    -0.00107404f, 0.01577517f, -0.00070143f, -0.02904262f, 0.02306428f, -0.01203024f, -0.01596072f, 0.02078958f, 
    -0.02892979f, -0.00356107f, 0.00742278f, -0.02502698f, 0.02270923f, 0.02967511f, -0.02893472f, 0.00871724f, 
    0.02226262f, 0.03134468f, -0.00879939f, 0.02287354f, -0.00003519f, -0.02628761f, -0.03159931f, 0.03349684f, 
    -0.00540938f, -0.02561051f, 0.01760225f, 0.02289162f, -0.00170304f, 0.02414548f, 0.00696041f, 0.00836598f, 
    0.03165588f, -0.02212709f, 0.01792317f, 0.03075262f, -0.01851113f, -0.01348273f, -0.00880801f, 0.02617567f, 
    -0.02626972f, 0.02690832f, 0.02476491f, -0.02930127f, -0.02021639f, 0.00969742f, -0.00160364f, -0.02328419f, 
    -0.02527919f, 0.02973692f, 0.00149234f, 0.03245750f, 0.01723636f, -0.00346218f, -0.02536566f, -0.01905218f, 
    -0.03499214f, -0.00510552f, 0.03639993f, 0.00001039f, -0.02133545f, 0.02762044f, -0.01144279f, -0.00902190f, 
    0.01069785f, -0.00283130f, -0.01311683f, 0.02186058f, 0.00924371f, -0.04063334f, -0.02002939f, 0.00386723f, 
    0.02210896f, -0.00812932f, -0.02964940f, -0.01511747f, -0.00668160f, 0.01639768f, 0.00512120f, -0.02815923f, 
    -0.02911687f, -0.04421219f, -0.00636664f, -0.03442267f, 0.00705201f, -0.02848275f, 0.01126547f, -0.03285443f, 
    0.03882303f, -0.01113789f, 0.01638840f, -0.00691387f, -0.04295504f, 0.02074849f, -0.02799083f, 0.00286851f, 
    -0.02949657f, -0.00286164f, 0.03351185f, 0.00324559f, -0.02050667f, 0.00974063f, -0.03860883f, -0.04386825f, 
    -0.03551750f, -0.03415340f, 0.00779729f, 0.02781446f, 0.03541367f, 0.01639736f, -0.03112280f, -0.02925896f, 
    -0.03544516f, -0.00606172f, 0.00396033f, -0.03541821f, 0.02881994f, 0.02320917f, 0.01038128f, -0.04039557f, 
    -0.01835118f, -0.03014873f, 0.00691496f, -0.03614192f, -0.00494535f, 0.02779942f, -0.00634910f, 0.00508832f, 
    0.00519746f, 0.03280263f, -0.02176281f, -0.03500767f, 0.00178810f, -0.02394604f, 0.02601059f, -0.00036309f, 
    -0.00461395f, -0.01573302f, -0.01869886f, 0.02365606f, -0.03274584f, -0.02976258f, 0.01240925f, -0.00562584f, 
    -0.00847215f, 0.01655741f, -0.04376625f, 0.02257126f, -0.00559851f, -0.03753918f, -0.00236337f, -0.01163698f, 
    -0.00046464f, -0.02800124f, 0.01452526f, -0.03226604f, 0.02386075f, -0.01997176f, -0.03076739f, 0.02531359f, 
    -0.00202868f, 0.00760890f, -0.04242820f, 0.02647927f, 0.00622752f, -0.04376362f, -0.03949318f, -0.01495638f, 
    -0.03499520f, 0.01176686f, -0.00257515f, 0.03133069f, -0.02418744f, 0.00670565f, -0.01367765f, 0.03217258f, 
    -0.01726261f, -0.00925490f, -0.00332935f, 0.00877400f, -0.02741106f, -0.00109044f, -0.01564210f, -0.02659900f, 
    -0.04290571f, -0.01493485f, -0.00871122f, -0.01968271f, 0.03100988f, 0.03637066f, -0.01997409f, -0.00040898f, 
    -0.02389190f, -0.01376133f, -0.03934754f, -0.00851382f, -0.00510899f, 0.01248785f, 0.01421890f, -0.00542921f, 
    0.00660488f, 0.02988913f, -0.04066268f, 0.00480743f, -0.01945827f, -0.00794233f, -0.02623020f, -0.02503907f, 
    0.01307695f, -0.00685722f, -0.00915544f, -0.01098083f, 0.00224286f, -0.01860152f, 0.02039096f, -0.01067466f, 
    0.01060478f, -0.02398845f, 0.03538166f, -0.00121635f, -0.04240475f, -0.00634022f, -0.01059600f, 0.01506637f, 
    0.03300410f, -0.00207648f, -0.04544107f, -0.04146414f, -0.03557364f, 0.03013122f, -0.00817748f, -0.02235571f, 
    0.03608924f, -0.03174527f, 0.00061806f, -0.01118396f, -0.01259086f, -0.00501308f, 0.01504901f, -0.01380987f, 
    -0.02858771f, -0.02738475f, -0.00401280f, -0.00622169f, -0.02857102f, 0.01042410f, -0.02298031f, -0.01769420f, 
    0.01240049f, 0.00350496f, -0.01724143f, -0.03578329f, -0.01154746f, 0.01315104f, 0.00879425f, -0.03136115f, 
    -0.01974300f, 0.02978401f, -0.02137512f, -0.00731292f, -0.03089551f, -0.03505747f, 0.03463418f, -0.02422814f, 
    0.03106225f, 0.02897018f, -0.00678020f, 0.03192543f, 0.02774626f, 0.03722904f, -0.01654389f, 0.01055687f, 
    -0.02705240f, 0.01215278f, -0.00331642f, -0.03591536f, 0.02549322f, -0.03690211f, -0.04176024f, -0.02938860f, 
    -0.03203611f, -0.00452876f, 0.03197248f, -0.01631750f, -0.02675438f, 0.02532820f, 0.00511138f, 0.03070055f, 
    -0.04127263f, -0.03556964f, -0.02332948f, 0.01242304f, 0.01401280f, -0.00279335f, 0.01157124f, 0.00176458f, 
    0.01316952f, -0.00090788f, 0.02398322f, 0.01212405f, 0.02291806f, -0.03956709f, 0.03795643f, -0.02139013f, 
    0.02633873f, 0.00431069f, -0.03676280f, 0.00355359f, -0.00475755f, -0.02505064f, 0.01143264f, -0.01166225f, 
    -0.02075815f, -0.02925088f, 0.02103302f, 0.02193541f, 0.00443395f, -0.02682410f, -0.00016370f, -0.02972803f, 
    0.02842410f, 0.03686157f, 0.04306071f, -0.00581864f, 0.02804853f, -0.03717038f, 0.00022177f, -0.04191938f, 
    -0.02267537f, -0.00701586f, -0.02667172f, -0.00374646f, -0.03501163f, 0.01008892f, -0.02477444f, 0.01088686f, 
    0.00106958f, -0.01667773f, -0.02249330f, 0.00959986f, -0.01104830f, -0.01424735f, -0.00731345f, -0.01868200f, 
    -0.00087633f, -0.03579052f, -0.01995726f, -0.03915219f, 0.03046462f, 0.00166088f, -0.04219473f, 0.00487185f, 
    -0.00928819f, 0.00609372f, -0.01875999f, 0.02651530f, 0.02648765f, 0.02964486f, 0.01062919f, 0.03191301f, 
    -0.02439921f, -0.01245325f, -0.00034896f, 0.00247501f, 0.02927655f, -0.02369305f, 0.02840988f, 0.02222754f, 
    0.02104629f, 0.01249090f, 0.00464071f, 0.02634661f, -0.02961485f, 0.01784884f, -0.01910446f, 0.01799187f, 
    0.01392242f, 0.00063973f, -0.00662667f, -0.02080263f, -0.02288906f, -0.01001957f, -0.03164850f, 0.00490141f, 
    -0.04429880f, 0.01657091f, 0.01023432f, -0.02263420f, 0.00803870f, -0.01826319f, -0.03352380f, 0.02659355f, 
    0.02164246f, -0.00202528f, 0.03026491f, 0.01306110f, -0.00230133f, 0.02171320f, 0.02754463f, 0.00690294f, 
    -0.04546060f, -0.02348724f, 0.00604915f, -0.01685988f, 0.01451582f, 0.01542054f, -0.03090073f, -0.03631441f, 
    -0.02561780f, 0.02326178f, 0.02496138f, 0.01336415f, 0.03116133f, 0.01231354f, 0.00640676f, 0.01073889f, 
    -0.01372156f, -0.03780424f, -0.02744035f, -0.01142252f, -0.00416877f, -0.01272658f, -0.00271239f, -0.03631099f, 
    -0.03405584f, -0.03275231f, 0.01664287f, 0.00174459f, -0.03547168f, -0.02160258f, 0.00455320f, -0.02238183f, 
    -0.00781667f, 0.01492226f, 0.02013127f, -0.01138392f, 0.01692219f, -0.01648041f, 0.02834766f, 0.00641695f, 
    -0.01215331f, 0.02349499f, -0.00872685f, 0.02813786f, 0.03201484f, -0.04154741f, 0.02162669f, -0.00139594f, 
    0.01032923f, -0.02922980f, -0.04481646f, 0.02244721f, -0.03116953f, 0.03118055f, 0.00459517f, 0.02152682f, 
    -0.03095801f, 0.00899878f, 0.01322929f, 0.02246794f, -0.02980800f, 0.01467905f, 0.00637361f, 0.01852854f, 
    -0.02482687f, -0.03306364f, -0.02765814f, -0.02740459f, 0.01867009f, -0.02082193f, -0.04243255f, -0.00317284f, 
    0.02785529f, -0.04012960f, 0.03563466f, 0.00239617f, -0.04225535f, 0.01699517f, -0.01684328f, 0.00140240f, 
    -0.00147947f, 0.00321134f, -0.01895141f, -0.02820986f, 0.00358899f, 0.02192850f, 0.03589902f, 0.00117636f, 
    -0.04410491f, -0.01623469f, -0.02002157f, 0.01242382f, -0.02187921f, 0.00546849f, 0.02126071f, 0.02217962f, 
    -0.00605402f, 0.02537027f, -0.04478575f, 0.02467831f, 0.02673717f, -0.02934960f, -0.01910577f, -0.01841753f, 
    0.01109953f, -0.01425415f, -0.00989096f, 0.03122525f, -0.03384145f, 0.02337727f, 0.02085045f, -0.00469560f, 
    -0.01067694f, 0.00111068f, 0.03032216f, -0.03184828f, -0.00063695f, -0.00981652f, -0.01628753f, 0.00478571f, 
    -0.02259680f, -0.01795322f, 0.02839354f, 0.00403827f, -0.00172420f, 0.02531569f, -0.00470031f, -0.00328239f, 
    -0.01426629f, 0.00299947f, 0.00312854f, -0.03465558f, -0.01325520f, 0.02120256f, 0.03070099f, -0.00358792f, 
    -0.01555354f, -0.03438069f, -0.04003169f, -0.01868574f, 0.01388683f, 0.01010000f, 0.00866592f, -0.02894810f, 
    -0.03788598f, -0.03159033f, -0.02673941f, 0.01158857f, -0.02007367f, -0.01686461f, -0.01025119f, 0.03239142f, 
    0.00160956f, 0.02945388f, -0.02397853f, -0.01726124f, -0.02495217f, -0.03002989f, -0.01744231f, 0.01321337f, 
    -0.00257287f, 0.01607757f, 0.01984322f, -0.00278772f, -0.00823155f, -0.00184523f, -0.04023240f, -0.00816136f, 
    -0.04431469f, -0.00856899f, -0.03361434f, 0.00749467f, -0.02147809f, 0.02308808f, -0.03164431f, 0.01534752f, 
    -0.02488223f, 0.01385492f, -0.01151573f, 0.02843303f, 0.01158991f, -0.03351367f, -0.04277971f, 0.02900883f, 
    -0.03092985f, 0.04286121f, -0.00772914f, -0.01434291f, -0.03178179f, -0.01021574f, -0.04332616f, 0.01539267f, 
    -0.01139820f, -0.02611145f, -0.02316575f, -0.01635881f, -0.00039489f, -0.04436103f, -0.03605529f, -0.02098036f, 
    -0.00041014f, 0.01224303f, -0.00830253f, -0.03498244f, -0.03352564f, -0.01672535f, -0.04476302f, -0.02796816f, 
    0.03008681f, -0.02563124f, -0.01699380f, -0.00153062f, 0.02140267f, -0.01266115f, -0.04416389f, 0.01532933f, 
    0.02434039f, -0.03564370f, 0.00719919f, -0.01902542f, 0.01093319f, 0.01352079f, -0.02818618f, -0.02456155f, 
    0.00766282f, 0.03054364f, 0.00741209f, -0.01810168f, -0.03593442f, 0.02056682f, -0.04384685f, -0.04298127f, 
    -0.03624516f, 0.02192386f, 0.01303920f, 0.00384657f, 0.02527184f, 0.01699110f, 0.00170518f, 0.03332269f, 
    0.02812886f, 0.03632686f, 0.00023580f, 0.00108301f, -0.01389913f, 0.01854565f, -0.02927605f, 0.01935334f, 
    0.02214894f, 0.02216326f, 0.01714048f, -0.00722953f, 0.02822819f, -0.03799408f, -0.00646622f, 0.03310709f, 
    0.03339634f, -0.04244618f, 0.01239537f, 0.01592932f, -0.03839783f, -0.04069416f, 0.03216229f, 0.02054823f, 
    0.03228361f, -0.02110089f, -0.03520982f, 0.00735271f, -0.01944707f, -0.01205259f, -0.04012730f, -0.02636904f, 
    -0.01522048f, 0.02010007f, 0.00829038f, 0.01700212f, 0.01851633f, -0.03557368f, 0.02593040f, 0.00726834f, 
    -0.01372163f, 0.00858351f, 0.03096269f, -0.02607387f, -0.01635179f, -0.00818321f, -0.04523303f, -0.01966397f, 
    0.02569824f, -0.00035116f, 0.03473460f, -0.00855132f, -0.04538856f, 0.02241916f, 0.03183013f, -0.01662572f, 
    -0.03910548f, -0.02738714f, 0.03239494f, -0.01443200f, -0.02224218f, 0.00719851f, -0.02189326f, -0.02561008f, 
    0.00146708f, -0.01828367f, -0.00978907f, -0.00557541f, 0.03279075f, -0.01571328f, -0.01124699f, 0.00479154f, 
    0.03227798f, 0.02464143f, -0.01085920f, 0.01159084f, -0.03277589f, -0.02920940f, 0.01494891f, 0.02799716f, 
    -0.03314583f, 0.00798188f, -0.01537976f, -0.02988773f, 0.00784061f, -0.02068888f, -0.01153589f, 0.02457136f, 
    -0.03720371f, -0.01308905f, 0.02410067f, 0.01771014f, -0.02635613f, -0.00969598f, 0.00405730f, -0.00321413f, 
    -0.02528149f, -0.01172896f, -0.03540285f, -0.01885340f, -0.03782842f, -0.01353923f, 0.00631831f, 0.02577298f, 
    0.02869728f, 0.02926863f, 0.00939354f, 0.00514198f, -0.03191352f, -0.03158883f, -0.00369668f, -0.01127976f, 
    -0.02607161f, -0.03628542f, -0.01533992f, -0.03847304f, -0.02728677f, -0.01101784f, -0.03869608f, 0.01876887f, 
    -0.00082696f, 0.00074464f, -0.01384890f, -0.03908917f, -0.02546865f, -0.00733738f, 0.01852701f, -0.01660256f, 
    0.00893442f, -0.03419606f, -0.03580976f, -0.03240627f, -0.04448805f, 0.02554499f, -0.00790025f, 0.01813934f, 
    -0.00971104f, -0.02357275f, 0.02133681f, -0.03986543f, 0.00086478f, -0.03769652f, -0.02159191f, -0.02685302f, 
    0.00300572f, -0.02025096f, 0.03055315f, -0.00297938f, 0.00045687f, -0.04205723f, -0.02029550f, -0.00917771f, 
    -0.01612576f, -0.02750893f, 0.00732971f, -0.03752606f, -0.01735651f, 0.01815190f, -0.00780241f, 0.01771737f, 
    0.03706179f, 0.03037424f, -0.01486547f, 0.00983092f, 0.01790479f, -0.04033448f, -0.02990587f, 0.01256520f, 
    -0.02189375f, 0.00284479f, 0.02705207f, -0.04428997f, 0.03765292f, -0.00800581f, 0.03811555f, 0.00146408f, 
    0.02058497f, 0.02657102f, 0.00846959f, -0.00851630f, 0.01610957f, 0.00626650f, 0.02447748f, 0.02334909f, 
    -0.04515196f, -0.00986436f, -0.00547677f, 0.00521005f, -0.03482414f, 0.00009032f, -0.00844967f, 0.01318666f, 
    -0.03500133f, -0.04253214f, 0.01683722f, -0.03433750f, -0.01359948f, -0.04324653f, 0.01050808f, 0.02770600f, 
    0.01373569f, -0.01583410f, -0.02861783f, -0.02466645f, 0.02816537f, -0.03433404f, 0.00956670f, -0.00979337f, 
    -0.03875633f, 0.00477466f, -0.03816861f, -0.01847721f, 0.01222466f, 0.02020348f, -0.00376825f, -0.03071403f, 
    -0.00733856f, 0.01259417f, -0.01072729f, -0.02427788f, -0.03484612f, -0.04141757f, -0.00132902f, 0.02194158f, 
    -0.03648484f, -0.03921413f, -0.04215881f, -0.02226505f, 0.02382618f, 0.01127234f, 0.00758474f, 0.01371584f, 
    -0.03997863f, -0.02221534f, 0.00903732f, 0.01706926f, -0.03835486f, -0.00659959f, 0.01634247f, -0.02530858f, 
    0.03232352f, -0.02065544f, 0.01836052f, -0.00523480f, -0.01643994f, -0.03254733f, -0.02419570f, -0.00411757f, 
    -0.02731529f, -0.03138102f, -0.00648377f, -0.02229089f, 0.01699885f, 0.01416760f, 0.01826705f, -0.03287236f, 
    -0.04501952f, -0.00305771f, 0.00537493f, -0.00682806f, -0.03495525f, 0.01469173f, -0.04405060f, -0.01756612f, 
    0.00771560f, 0.02304622f, -0.03539737f, -0.00594386f, 0.01078347f, -0.00789502f, 0.00925007f, -0.01754522f, 
    0.02961044f, -0.03221896f, 0.02437991f, 0.01459193f, -0.03929780f, 0.02512651f, 0.03010684f, 0.01664305f, 
    -0.02132468f, 0.02308874f, 0.00620067f, -0.04032214f, 0.02955429f, -0.03197559f, -0.00229436f, -0.01483192f, 
    0.02412156f, 0.00661689f, -0.03111037f, -0.04055086f, 0.00495687f, 0.01018914f, 0.00217045f, 0.00696131f, 
    -0.00979772f, -0.02117566f, 0.02187371f, -0.03548188f, 0.02771461f, -0.02706086f, -0.00619744f, -0.04658209f, 
    0.02056164f, -0.01360442f, 0.03387278f, 0.00004762f, -0.00496759f, 0.00649505f, -0.03298576f, -0.01128442f, 
    0.02691045f, 0.02372761f, -0.04586375f, -0.04120736f, -0.00622011f, 0.03266716f, -0.02058197f, 0.01424323f, 
    0.00773073f, -0.00235159f, -0.01511632f, 0.00458155f, 0.00371037f, -0.04482692f, -0.03813468f, 0.01220554f, 
    0.00442026f, -0.02777742f, -0.00833054f, 0.00365052f, -0.02122929f, -0.02861782f, -0.04009457f, -0.04024179f, 
    -0.01777328f, -0.03188995f, -0.02014088f, 0.00486272f, -0.02044827f, -0.03575590f, 0.02886835f, 0.00149397f, 
    0.02873517f, -0.03760643f, -0.01971145f, 0.02839854f, -0.03896198f, -0.04299674f, 0.02566589f, 0.01120034f, 
    -0.00244616f, -0.04380624f, -0.04694313f, -0.01466998f, -0.00821903f, 0.03403453f, 0.00207479f, -0.01428243f, 
    -0.02676109f, 0.01035890f, -0.00217240f, -0.01390575f, 0.02728201f, 0.00841880f, 0.00785508f, 0.00657062f, 
    -0.01894987f, -0.00728188f, -0.00880954f, 0.01483697f, 0.02811611f, 0.00452303f, 0.01140595f, -0.03126611f, 
    -0.03069374f, 0.02611031f, -0.00130351f, 0.01758873f, -0.00645148f, -0.01369558f, 0.01877617f, -0.02955265f, 
    0.02332055f, -0.01217632f, -0.02496468f, -0.04456218f, 0.00960513f, -0.00843416f, 0.00109920f, -0.01375850f, 
    0.01007773f, -0.00341853f, -0.03462680f, -0.04190151f, -0.02027680f, -0.03303347f, -0.00105393f, 0.01916058f, 
    0.00687688f, 0.02990761f, -0.03811680f, -0.03836552f, -0.04013673f, -0.00935624f, 0.03252862f, -0.01142723f, 
    0.01719890f, -0.00001372f, -0.00901894f, -0.01383828f, 0.03194386f, 0.01554579f, -0.03498460f, -0.01859197f, 
    0.00647380f, 0.03151062f, 0.02494515f, -0.04553057f, 0.01212491f, 0.00593074f, -0.00907938f, -0.02764519f, 
    0.01797166f, -0.00901518f, 0.02124018f, 0.02852060f, 0.02562036f, 0.00689248f, 0.03414861f, 0.00254796f, 
    -0.02473543f, -0.04059107f, -0.00902440f, -0.02615696f, -0.04386266f, 0.01411888f, -0.03935277f, 0.02237843f, 
    0.02990683f, 0.02610259f, 0.00564257f, 0.00261241f, -0.03344450f, 0.02080314f, -0.02624124f, -0.03912531f, 
    -0.01759277f, 0.01790256f, 0.02492521f, -0.01072272f, -0.01925651f, 0.00042318f, -0.00332206f, -0.01484267f, 
    -0.03359916f, 0.02442772f, 0.00747418f, 0.00259407f, 0.01790909f, -0.00883334f, -0.02499172f, 0.00207471f, 
    0.03371537f, 0.01201971f, 0.03240828f, 0.02005676f, 0.01524643f, 0.00779281f, 0.03050710f, 0.01028096f, 
    -0.04517481f, -0.02885208f, 0.03504698f, 0.01540637f, -0.00249112f, 0.02958879f, 0.00112358f, 0.00034115f, 
    -0.01618470f, -0.01668024f, 0.02120552f, -0.02135941f, -0.04537905f, -0.03220361f, -0.01268339f, -0.01979212f, 
    0.03099550f, 0.00551252f, 0.01137951f, 0.00965599f, -0.02002799f, 0.02701658f, -0.00960924f, 0.01136222f, 
    0.01042585f, 0.00770118f, -0.01567814f, -0.04097004f, -0.02003963f, -0.01431699f, -0.01983635f, 0.00536264f, 
    0.02161050f, 0.02551422f, 0.02788957f, -0.04642032f, 0.01851102f, 0.00058850f, -0.01285898f, -0.01350845f, 
    0.00001453f, 0.02983358f, -0.03567756f, 0.01384145f, 0.02829041f, 0.03387457f, 0.02931416f, 0.00937935f, 
    -0.02068962f, -0.03109221f, -0.00090429f, 0.02037366f, -0.00208231f, 0.00489695f, -0.03135912f, -0.03731975f, 
    0.00049404f, -0.01381871f, 0.01993051f, 0.00035313f, -0.03879216f, -0.02153556f, -0.02807137f, 0.02069248f, 
    0.03164114f, 0.01284181f, 0.00944621f, -0.02281159f, 0.01224979f, -0.00229057f, -0.01587486f, -0.01582538f, 
    0.02397973f, -0.02713288f, 0.00862562f, -0.03002266f, 0.03252606f, 0.01709612f, -0.01784608f, -0.03748772f, 
    -0.02576862f, 0.02843848f, 0.01487470f, 0.01752016f, 0.02942737f, -0.02138429f, 0.02039481f, -0.00616921f, 
    -0.02009409f, -0.01241602f, -0.02920138f, -0.04426205f, -0.02283381f, 0.02626897f, -0.01940059f, -0.04065276f, 
    0.02652866f, -0.01368295f, 0.01811746f, -0.03163247f, -0.02091617f, -0.03300739f, -0.03688204f, -0.00093934f, 
    0.01455387f, -0.02387684f, -0.01491045f, -0.01978799f, -0.03426072f, 0.00015215f, -0.02903777f, -0.01768303f, 
    -0.03735644f, 0.01108516f, -0.02730114f, 0.03267355f, 0.02535189f, 0.03053263f, 0.01965586f, -0.03091275f, 
    0.01013219f, 0.01846410f, -0.01265186f, 0.02247706f, -0.03426534f, -0.04277781f, 0.00215021f, 0.01345457f, 
    -0.03844849f, -0.02254955f, -0.00009794f, 0.00105163f, -0.03545340f, -0.01525374f, 0.02139718f, -0.03231406f, 
    -0.02861411f, 0.02155042f, 0.01604493f, -0.01148440f, 0.01813034f, 0.02514429f, 0.02861563f, -0.01333170f, 
    -0.00625309f, 0.03470501f, -0.02419800f, 0.03523096f, 0.02147369f, -0.02153417f, 0.01017786f, -0.00969564f, 
    0.01728004f, 0.02398075f, -0.02444500f, 0.01275218f, 0.01394686f, 0.02441102f, -0.04310638f, -0.00367955f, 
    0.02055621f, -0.04225033f, -0.00702004f, 0.00306598f, 0.02888520f, -0.02961885f, -0.03125511f, -0.03570845f, 
    -0.00856234f, 0.02670382f, -0.02456152f, 0.01883049f, 0.02172979f, 0.00847384f, -0.01198567f, 0.01382937f, 
    -0.03601302f, -0.01167120f, -0.00651368f, 0.00280840f, 0.00185928f, 0.00945088f, -0.04462068f, -0.02427623f, 
    -0.01580742f, -0.01424027f, 0.02029862f, -0.02132574f, -0.01156558f, 0.03290580f, -0.00012355f, -0.00881614f, 
    0.01110592f, -0.00570802f, 0.00125694f, -0.02315642f, -0.00918738f, 0.01202561f, 0.02339122f, -0.04303526f, 
    0.03402116f, -0.04526209f, 0.02722918f, 0.00178612f, 0.02587539f, -0.03718916f, -0.00919069f, 0.03205014f, 
    -0.02855778f, -0.03097352f, -0.02646100f, -0.03932278f, -0.02911161f, -0.01648270f, 0.01265554f, 0.00705899f, 
    -0.01764831f, 0.04281711f, 0.01899997f, 0.00128455f, 0.00583718f, -0.00715739f, 0.01287267f, 0.01378895f, 
    0.00504477f, 0.02529684f, 0.00389070f, -0.00624955f, -0.00090393f, -0.01848289f, 0.02946886f, -0.00406501f, 
    0.00446804f, 0.03243292f, 0.01484561f, -0.03314433f, -0.03925047f, 0.02180557f, 0.00742164f, 0.01806717f, 
    0.00418811f, -0.04399092f, 0.01050455f, 0.02987559f, -0.03427142f, -0.02506138f, 0.02129143f, 0.01543926f, 
    -0.01698487f, -0.02955018f, -0.01010490f, 0.03408568f, -0.04361981f, -0.01556899f, 0.00079185f, 0.02127807f, 
    -0.01521030f, 0.01588049f, -0.02122774f, -0.02961949f, 0.01096632f, 0.00849869f, -0.00134494f, -0.03343154f, 
    0.02150697f, -0.04025002f, -0.02684903f, -0.04324760f, 0.01001715f, -0.02707564f, -0.02692963f, -0.04403286f, 
    0.01036734f, 0.00362143f, -0.02259903f, 0.02377563f, -0.00686096f, -0.02007826f, 0.02106464f, 0.01751020f, 
    -0.02374251f, -0.03803480f, -0.03166292f, -0.01150201f, -0.02072950f, -0.02298439f, -0.03331558f, 0.01575176f, 
    -0.02513806f, 0.00372368f, -0.01629784f, -0.04014818f, 0.02304048f, 0.02749786f, -0.03071370f, 0.01774698f, 
    -0.03659488f, -0.00851473f, -0.03087071f, -0.02956771f, -0.02046311f, -0.00577414f, -0.02287618f, 0.00840076f, 
    -0.04138788f, -0.03813130f, -0.01242101f, 0.00354997f, 0.02833099f, -0.02529840f, 0.01545259f, -0.03923430f, 
    -0.01759994f, 0.00274765f, -0.01306057f, -0.04113815f, 0.01039371f, -0.01108084f, 0.02322496f, -0.02816169f, 
    -0.02301689f, -0.01755170f, 0.02822022f, -0.01919975f, 0.01311185f, -0.03755898f, -0.03999672f, -0.02106381f, 
    -0.00863353f, 0.03437134f, -0.03893367f, -0.02484367f, -0.00691630f, 0.01568809f, 0.00952546f, -0.01463674f, 
    -0.04234210f, 0.00394914f, -0.00151758f, -0.02571927f, 0.01136401f, -0.02619831f, 0.02576627f, 0.02911670f, 
    0.01610979f, -0.01478688f, 0.01398034f, 0.02210481f, 0.00315256f, -0.02663673f, 0.02953287f, -0.00873506f, 
    -0.00848950f, -0.03887361f, -0.02480443f, -0.01764705f, 0.01116264f, 0.03319051f, 0.01258815f, -0.00870148f, 
    -0.04549166f, -0.03327630f, -0.01809398f, 0.00199681f, -0.03852444f, 0.00167635f, -0.00659615f, -0.00043474f, 
    0.01734974f, -0.03918745f, -0.00599235f, 0.00058229f, 0.01511861f, 0.02194117f, 0.01797510f, 0.01001189f, 
    0.02898856f, 0.00565320f, -0.02838482f, 0.00614336f, 0.02901275f, -0.03830566f, 0.01703102f, 0.02318859f, 
    0.00945502f, -0.01971736f, 0.03309071f, -0.02027189f, 0.01397458f, -0.01340656f, 0.00080843f, -0.00809746f, 
    -0.00851660f, -0.00604423f, -0.01654586f, -0.03328750f, -0.04440595f, -0.04564154f, 0.01046079f, 0.00769673f, 
    0.01068744f, -0.02611812f, -0.04247818f, -0.00135580f, -0.03924354f, -0.03836700f, -0.03317313f, -0.01554471f, 
    0.02995063f, -0.00436643f, -0.02586459f, 0.02002527f, -0.02571537f, -0.00606598f, 0.00783967f, 0.01418285f, 
    -0.01459787f, 0.00495346f, 0.01137367f, -0.00737432f, -0.01479822f, 0.02159380f, -0.01641019f, -0.01105382f, 
    0.00224183f, -0.01717384f, -0.02873623f, -0.02388115f, -0.00028956f, -0.02279135f, -0.03253336f, -0.00980951f, 
    0.00962827f, -0.01882604f, 0.01381508f, -0.03867334f, 0.02823604f, 0.01803556f, 0.02894784f, 0.00061324f, 
    0.00748920f, -0.03510424f, -0.03869056f, 0.03105200f, -0.03776592f, -0.00360064f, -0.00447552f, 0.01878400f, 
    -0.02838821f, 0.01009849f, -0.01582514f, 0.02488748f, 0.02017872f, -0.03976288f, 0.01416788f, -0.03583791f, 
    0.01193666f, -0.01409174f, 0.02087536f, 0.02312273f, -0.00566467f, -0.03487595f, -0.00287656f, -0.03018843f, 
    -0.00447517f, -0.01969231f, 0.02963125f, 0.03350107f, 0.03035523f, -0.02490026f, -0.02836262f, -0.01448280f, 
    -0.01824805f, -0.04153308f, -0.00862381f, -0.03651445f, 0.03044834f, -0.04908381f, 0.01129872f, 0.00631888f, 
    -0.04612849f, 0.00271242f, 0.00574505f, -0.03350852f, 0.02721198f, -0.01894347f, -0.04772643f, 0.00293971f, 
    -0.04579887f, -0.00058211f, -0.01020659f, -0.05029870f, -0.02776483f, -0.00629081f, -0.04539566f, -0.01726800f, 
    0.01196582f, -0.03369002f, 0.01981398f, 0.01590181f, -0.03027310f, -0.01465013f, 0.02369136f, -0.03181203f, 
    -0.03696915f, 0.01728757f, -0.02115078f, -0.01737832f, -0.02167788f, 0.01514293f, 0.01419376f, 0.00720768f, 
    0.00070213f, -0.01123913f, -0.04608303f, -0.00209314f, 0.00711654f, -0.00779252f, 0.00758380f, -0.01788680f, 
    0.02110844f, 0.01161739f, -0.03408764f, 0.02389445f, -0.02097947f, 0.00364361f, -0.00650489f, 0.01411929f, 
    -0.01146611f, 0.02540271f, -0.02634749f, -0.03336850f, -0.00090567f, -0.00993983f, 0.00449378f, 0.00885924f, 
    -0.02350821f, 0.00699118f, -0.00188954f, 0.02039019f, 0.01246348f, -0.01113217f, -0.04562181f, 0.02426491f, 
    -0.04205575f, -0.01189322f, -0.00124237f, 0.00784522f, -0.04146164f, -0.03065039f, 0.00695006f, 0.02007276f, 
    0.00635949f, -0.02694575f, -0.01189575f, 0.00308895f, -0.01135230f, -0.04201942f, -0.03561034f, 0.00518908f, 
    -0.00200561f, 0.01688622f, -0.02870863f, -0.04091133f, 0.01631778f, 0.01069789f, -0.03520643f, -0.00586850f, 
    0.01379032f, -0.02544861f, 0.02800084f, 0.00332970f, 0.00221220f, -0.03595727f, -0.04311643f, -0.00505243f, 
    0.00486020f, -0.03365501f, -0.03993740f, 0.01930439f, 0.02337146f, 0.00340629f, -0.02255215f, -0.03352486f, 
    -0.00724083f, -0.00447120f, 0.00413816f, 0.02635753f, 0.02162780f, -0.01635467f, -0.00324774f, -0.00890328f, 
    0.01067851f, -0.01793496f, -0.00070040f, 0.02335774f, 0.00418348f, 0.02625118f, -0.02451984f, 0.02304488f, 
    -0.03669319f, 0.00136031f, -0.04336100f, -0.00583514f, 0.00659594f, -0.02684545f, 0.02246131f, -0.01933944f, 
    0.00711087f, -0.00316752f, 0.02015878f, -0.00430660f, -0.03791969f, -0.00963682f, 0.02175613f, -0.01565947f, 
    0.03120218f, -0.01260785f, 0.00597864f, 0.02843450f, 0.00245095f, 0.02534197f, -0.03233763f, 0.01774614f, 
    -0.03608361f, -0.00968249f, 0.02219417f, 0.03112655f, -0.04225007f, -0.03290928f, 0.00019765f, -0.03398281f, 
    0.01386754f, -0.00144285f, 0.02349113f, -0.01608813f, 0.01291596f, -0.04569208f, 0.02790396f, -0.01349896f, 
    -0.00498713f, -0.00994679f, -0.04149817f, -0.01888688f, 0.01723262f, -0.01889406f, -0.01476547f, -0.01289095f, 
    -0.03220570f, 0.00303832f, 0.03279286f, -0.00011432f, -0.02641111f, 0.02409534f, -0.02337441f, -0.00421208f, 
    0.02272272f, -0.03428482f, 0.02211620f, -0.01937992f, 0.00668354f, -0.00708742f, -0.03479201f, 0.01752464f, 
    -0.03475763f, 0.00226150f, -0.01349432f, -0.02968084f, 0.00923897f, -0.00884764f, -0.00775446f, 0.02983048f, 
    -0.02815495f, -0.00742994f, -0.00226315f, -0.00324665f, -0.01438098f, 0.02092393f, -0.01496827f, -0.01688205f, 
    0.01407001f, -0.01597338f, 0.02032716f, 0.02372176f, -0.02205141f, 0.00701900f, 0.02736846f, -0.04350711f, 
    0.03513362f, 0.03207310f, -0.01193580f, 0.00784681f, -0.03097819f, -0.02647313f, 0.00542439f, -0.00781499f, 
    0.00394465f, -0.01906159f, -0.03930046f, 0.02771648f, 0.00117128f, 0.00192257f, -0.01407243f, 0.01757220f, 
    -0.00895622f, 0.02013558f, 0.03593349f, -0.00617722f, 0.01512865f, -0.02457199f, 0.02216606f, -0.03837477f, 
    0.01866469f, 0.01204934f, -0.00099217f, 0.02341667f, 0.02203880f, 0.01574165f, -0.02704407f, 0.02210498f, 
    0.00172125f, 0.01782603f, -0.00369125f, -0.02366355f, 0.00827086f, 0.01226439f, 0.00839788f, -0.01375184f, 
    0.01775146f, -0.02304862f, 0.01465026f, -0.01901723f, 0.02151302f, -0.03894649f, -0.03696526f, -0.03825168f, 
    0.00630153f, -0.00051831f, -0.02970980f, 0.01623722f, -0.01236619f, -0.00025399f, -0.01339192f, -0.01903625f, 
    -0.03057280f, -0.00679390f, -0.04044080f, -0.01118348f, 0.03107431f, 0.00604156f, -0.00427309f, -0.02182101f, 
    0.00466684f, -0.04122759f, 0.02771930f, 0.02884080f, 0.00319661f, -0.03902452f, 0.01029150f, 0.02524046f, 
    0.01786794f, 0.00170571f, 0.02442697f, -0.04623229f, -0.00815253f, -0.03374122f, -0.02603180f, 0.01406650f, 
    -0.04339420f, 0.00101116f, -0.01335027f, 0.00144407f, -0.02693654f, -0.00781611f, -0.04730931f, 0.01341986f, 
    0.00620510f, -0.00861647f, -0.02326915f, 0.00601026f, 0.00461196f, -0.03569736f, 0.02301374f, -0.01459200f, 
    -0.02921641f, -0.03535045f, -0.02578181f, 0.02227473f, -0.01574213f, -0.00338195f, -0.04265824f, 0.00741831f, 
    -0.02335201f, -0.04597533f, -0.03714008f, -0.01594421f, -0.01998626f, -0.02759560f, -0.01386899f, -0.02881843f, 
    0.01181419f, 0.01010124f, -0.00843776f, -0.02600387f, -0.00021266f, -0.04608937f, -0.04027642f, 0.03983658f, 
    0.02717342f, -0.01756944f, 0.01434686f, -0.03177393f, 0.00745777f, -0.00457268f, -0.02115257f, 0.01680905f, 
    -0.02230365f, 0.02252982f, 0.02789050f, -0.01364298f, 0.02422802f, -0.02598543f, -0.01271688f, -0.03548491f, 
    0.00888000f, -0.03319927f, 0.00481605f, -0.01517193f, 0.00113594f, -0.03152358f, -0.04887715f, 0.00377713f, 
    0.01918987f, 0.02577957f, -0.04066377f, 0.01355317f, 0.01322399f, 0.02026248f, 0.01208479f, 0.02820267f, 
    -0.04290919f, 0.02837725f, -0.02382790f, -0.02669320f, 0.02375433f, -0.01502206f, 0.00664313f, 0.00181684f, 
    -0.04368908f, -0.02482121f, 0.02685682f, 0.01618840f, -0.03532114f, 0.02426673f, -0.04023428f, -0.03369550f, 
    -0.00730578f, 0.00006662f, -0.04518813f, -0.01852232f, -0.02326459f, -0.01288112f, -0.00630290f, -0.03058135f, 
    -0.03474616f, 0.01644148f, 0.02714161f, 0.01395790f, -0.03215637f, -0.00355014f, 0.01651995f, 0.01684985f, 
    0.02688308f, -0.00642302f, -0.01256842f, -0.01388783f, 0.01725211f, -0.00512290f, -0.00576740f, -0.02596991f, 
    -0.03307891f, -0.04212996f, 0.00723196f, -0.01911470f, 0.00962206f, 0.01984149f, -0.00573696f, -0.02721440f, 
    -0.02065504f, 0.00632511f, -0.01860879f, 0.02905183f, -0.04357972f, 0.03192093f, 0.01992815f, -0.03527287f, 
    0.02170165f, 0.01662366f, 0.02144397f, -0.00409390f, -0.03010232f, -0.00352379f, -0.02455169f, 0.00239904f, 
    0.02139661f, 0.02546444f, -0.01048097f, -0.04532518f, -0.02195372f, 0.00107285f, -0.00559109f, 0.01133799f, 
    -0.05004507f, 0.00929878f, -0.00630328f, 0.01903027f, -0.04492441f, -0.01136833f, 0.02084783f, -0.04208313f, 
    -0.03782106f, -0.03281995f, -0.02764816f, -0.02256952f, 0.02430281f, 0.00787003f, -0.03412460f, 0.01874202f, 
    0.00962340f, -0.02312625f, -0.02705512f, -0.02419257f, 0.01752727f, -0.01893995f, -0.02773525f, 0.02778669f, 
    0.00964702f, 0.00204524f, 0.01719756f, 0.02225653f, -0.01268268f, 0.00830353f, -0.02671669f, -0.03951372f, 
    -0.01712507f, -0.01536457f, -0.03225726f, -0.03319009f, 0.00191161f, -0.01107395f, 0.01031964f, -0.00709413f, 
    -0.02387335f, 0.00723727f, -0.04923332f, -0.01277118f, 0.00143481f, -0.01534154f, 0.00548245f, -0.04503335f, 
    0.00646757f, -0.02232623f, 0.00185412f, -0.00094664f, 0.01325762f, 0.01295050f, -0.03816005f, 0.01504701f, 
    -0.03478596f, 0.01711980f, 0.00746941f, 0.00553422f, -0.02688660f, -0.01735715f, 0.01571455f, -0.01054014f, 
    0.02757527f, -0.04364124f, 0.02341110f, 0.02371759f, 0.02018578f, -0.03785041f, -0.00670773f, -0.01661602f, 
    -0.03425620f, -0.03020130f, 0.01669557f, -0.00512953f, 0.02122840f, -0.00266599f, 0.03414094f, -0.03815578f, 
    -0.04075972f, -0.04413054f, 0.00424523f, -0.03409418f, -0.00910310f, -0.01599783f, 0.02754574f, 0.00785656f, 
    -0.03524430f, -0.01331444f, -0.03332833f, -0.01711632f, -0.03875776f, -0.02405483f, -0.02656747f, 0.01295548f, 
    0.00305653f, 0.01372489f, -0.00550311f, -0.01306705f, -0.01439553f, 0.01998514f, -0.04918422f, 0.02509215f, 
    0.00772132f, 0.01397448f, 0.02875524f, 0.00990455f, -0.02807935f, 0.01393427f, -0.03228284f, 0.01822219f, 
    0.01962348f, 0.00147018f, -0.00772466f, 0.01536338f, 0.02102039f, -0.00276543f, -0.02483259f, 0.02677523f, 
    0.00117925f, -0.01704941f, 0.00857665f, 0.02847329f, 0.00388675f, 0.02852267f, -0.01153247f, -0.02817983f, 
    0.02685876f, -0.00591067f, 0.02990766f, -0.01484090f, -0.01750148f, -0.00103354f, 0.02486749f, -0.01834183f, 
    -0.00927106f, -0.03151481f, -0.00923830f, -0.01072242f, 0.00033317f, -0.02786989f, -0.03207602f, 0.01679545f, 
    0.02644889f, -0.04164322f, 0.00183217f, -0.01040012f, -0.04841929f, -0.03508313f, -0.01029450f, 0.00678324f, 
    -0.01371037f, -0.00087502f, 0.02443116f, 0.02911576f, -0.04541432f, 0.01390079f, -0.04244835f, 0.00271209f, 
    -0.01908801f, -0.03413971f, -0.01023180f, -0.01346590f, -0.01665957f, 0.01439669f, 0.01047719f, 0.02505207f, 
    -0.02045218f, -0.01559602f, -0.00141594f, 0.02574873f, -0.01654714f, -0.00327782f, 0.00691028f, -0.03154099f, 
    -0.01661603f, -0.04351620f, -0.00596563f, -0.00081013f, -0.00433277f, -0.00696575f, -0.00076709f, -0.01387636f, 
    -0.04453802f, 0.00496599f, 0.00322175f, 0.01113165f, -0.00312704f, -0.03409007f, 0.00026001f, 0.00961478f, 
    0.01729068f, -0.01014295f, 0.00089353f, -0.02322347f, 0.03532462f, -0.04232548f, 0.02121832f, 0.01981742f, 
    0.03297165f, 0.01524894f, 0.00281454f, 0.02522485f, 0.01761235f, 0.02607837f, 0.03299535f, -0.04778798f, 
    0.02929211f, 0.00874124f, 0.00749078f, -0.01535550f, -0.02011678f, 0.03517971f, 0.03132996f, 0.02155662f, 
    -0.01031868f, -0.01073476f, 0.02068634f, 0.00550083f, -0.00154076f, 0.03449664f, 0.03744004f, -0.02010787f, 
    -0.01345860f, -0.00752005f, 0.02081859f, -0.02337644f, -0.03712864f, -0.02336576f, 0.00587998f, 0.01766394f, 
    -0.00323086f, -0.01625122f, -0.02362279f, -0.03066320f, -0.03690443f, -0.03326387f, -0.01450030f, -0.02301845f, 
    -0.00761192f, -0.03307164f, -0.01343646f, -0.03649328f, -0.00896265f, 0.03056174f, 0.01746722f, -0.00713933f, 
    0.01156827f, 0.02779515f, -0.02514466f, 0.02976221f, -0.01167950f, -0.01152708f, -0.00949393f, -0.00282255f, 
    0.02309889f, 0.03302129f, 0.01927607f, -0.00540784f, -0.03871607f, 0.00980050f, -0.01242798f, -0.01396595f, 
    0.02815056f, -0.01948230f, -0.01543967f, -0.00411655f, -0.04031833f, -0.03104222f, -0.04141027f, -0.01272178f, 
    -0.00110544f, -0.03085208f, 0.00139044f, 0.00589518f, -0.00373203f, 0.03254955f, 0.01172194f, 0.02068187f, 
    -0.02786349f, 0.01114484f, 0.00348093f, -0.03516915f, -0.02646638f, 0.00752058f, -0.04785215f, 0.01395483f, 
    -0.01454540f, 0.00198709f, 0.00509275f, -0.00682452f, -0.01877766f, 0.02332466f, 0.00633793f, -0.00050736f, 
    -0.04148721f, 0.00621792f, -0.02581104f, 0.01181543f, -0.02087156f, 0.02761369f, -0.02949700f, 0.00033428f, 
    -0.03722396f, -0.00889619f, -0.00320799f, 0.02262595f, 0.00943747f, -0.04269397f, -0.00903287f, -0.00558490f, 
    0.00497188f, -0.02522901f, -0.04189704f, -0.01898918f, 0.02155893f, 0.01888242f, -0.01655531f, -0.03788468f, 
    0.02649812f, -0.02443814f, -0.03014148f, -0.02502688f, -0.01489351f, 0.01807376f, -0.03318068f, 0.00544559f, 
    0.03517567f, -0.00138858f, 0.02897270f, 0.00381465f, -0.01365062f, -0.03662302f, -0.00858935f, 0.03696581f, 
    -0.01090955f, -0.02508821f, -0.01650255f, 0.02481773f, 0.03047365f, -0.00804000f, 0.03886466f, -0.03790046f, 
    -0.03072467f, -0.00625750f, 0.02324248f, 0.01348899f, 0.01715287f, 0.00369851f, 0.00390894f, -0.02986481f, 
    0.00947881f, -0.03708035f, 0.02440254f, -0.00851112f, -0.03374410f, -0.02642798f, 0.00089828f, -0.00312204f, 
    0.02895614f, 0.00626182f, 0.02210468f, 0.02690993f, -0.02529465f, 0.03822255f, 0.00274005f, -0.02486107f, 
    -0.02898084f, 0.00815187f, -0.03199396f, 0.02041599f, 0.01170359f, 0.02884355f, -0.03543285f, 0.01649844f, 
    0.01661927f, 0.00584847f, -0.04133439f, 0.01478124f, 0.03119356f, 0.02383854f, 0.02045701f, 0.01262265f, 
    -0.00239220f, -0.02951130f, 0.00319865f, 0.03524665f, -0.00183947f, -0.00365689f, -0.00967566f, -0.01858083f, 
    0.03237684f, -0.01767713f, 0.00818509f, 0.00750544f, -0.03230634f, -0.01716924f, -0.01438322f, -0.01643757f, 
    -0.00080624f, -0.01578283f, 0.00415906f, -0.02662131f, 0.01796710f, -0.01946077f, 0.01621936f, -0.00977707f, 
    -0.00954523f, -0.01099933f, -0.01124023f, -0.01169461f, -0.01336202f, 0.00653946f, -0.04014361f, 0.03168323f, 
    0.00183048f, 0.02711814f, 0.00100801f, -0.03618111f, -0.00124235f, -0.00457773f, -0.02016849f, -0.03085438f, 
    0.00674250f, -0.04252040f, 0.00809153f, 0.02940501f, -0.01279221f, 0.02168329f, 0.04432303f, -0.00806880f, 
    -0.00497568f, -0.00237854f, -0.03339905f, -0.01780327f, 0.01564300f, -0.00220508f, -0.02450757f, 0.01656775f, 
    -0.01701669f, 0.01031051f, -0.03388805f, -0.00233196f, -0.00932702f, -0.04201888f, -0.02785250f, 0.00669879f, 
    -0.02970084f, 0.02910082f, -0.01797737f, -0.00688241f, -0.04633934f, -0.04923097f, 0.01343444f, 0.02490826f, 
    -0.01385163f, -0.02117603f, 0.04131726f, -0.01198768f, -0.00122197f, 0.01699677f, 0.02715990f, -0.01322308f, 
    -0.01216178f, 0.00238205f, -0.02024985f, 0.02107217f, 0.00599110f, 0.00281255f, -0.01913021f, 0.00240473f, 
    -0.01533369f, 0.03041603f, 0.01281468f, 0.01269974f, -0.00068143f, -0.00426763f, 0.00227444f, -0.04817387f, 
    0.01659541f, -0.03158642f, -0.03771513f, 0.03792381f, -0.01802786f, -0.01774517f, 0.03141713f, 0.01806029f, 
    0.00077656f, -0.01478506f, -0.00285952f, 0.03375483f, 0.03847772f, 0.04052516f, -0.01522123f, -0.00043550f, 
    0.01029473f, -0.00634992f, -0.01891831f, -0.00566392f, -0.03500485f, -0.02841809f, 0.00909227f, -0.01379678f, 
    -0.03700388f, 0.02595856f, 0.02749010f, 0.03932435f, -0.02439089f, 0.01682451f, -0.00212251f, -0.01945022f, 
    -0.02559824f, -0.03731286f, 0.03055660f, 0.04240654f, -0.02421911f, -0.03526587f, -0.01033728f, -0.03101754f, 
    -0.01359813f, 0.02201913f, 0.00018519f, -0.02478547f, -0.02866246f, -0.01164002f, -0.02762460f, -0.02042874f, 
    -0.02558135f, -0.00038239f, 0.02557566f, -0.00297768f, 0.03770700f, -0.02422048f, 0.00498629f, -0.02269286f, 
    -0.00382040f, -0.01486477f, 0.00358251f, -0.03213936f, 0.03041027f, -0.03027225f, -0.02005113f, 0.03320005f, 
    -0.02336055f, 0.01637896f, 0.03105250f, 0.02618448f, 0.02635127f, -0.03027469f, -0.00307143f, 0.02989762f, 
    -0.00078008f, 0.02667723f, 0.01393285f, -0.03228946f, 0.02156318f, -0.02645860f, 0.01632514f, -0.03750642f, 
    0.02425892f, 0.01437076f, 0.00725206f, -0.02030343f, -0.03202173f, -0.00630085f, -0.03682749f, 0.01389351f, 
    0.01824686f, -0.00562475f, -0.04638977f, -0.01540279f, 0.00981176f, 0.00527592f, -0.00568606f, -0.00133530f, 
    0.02075053f, -0.03989194f, 0.01474575f, -0.04495268f, -0.02606457f, 0.03082210f, 0.01283447f, 0.03871644f, 
    -0.02356148f, 0.02332458f, -0.01261008f, 0.01585283f, -0.02986691f, -0.00450853f, -0.00636636f, -0.04414672f, 
    0.01120711f, -0.04068889f, -0.02581215f, 0.04341768f, -0.00630605f, -0.03059185f, -0.03871119f, -0.01836775f, 
    -0.00125873f, 0.00825734f, -0.02241021f, -0.02379345f, 0.00822244f, 0.01829020f, -0.00782551f, -0.02567099f, 
    0.02792715f, 0.00505574f, -0.02574059f, -0.03251905f, 0.00562001f, -0.03462635f, -0.01471563f, -0.01963559f, 
    -0.00079420f, -0.00283619f, -0.00414461f, -0.04074129f, 0.03261798f, -0.01373036f, -0.00845554f, 0.02971411f, 
    0.02356632f, -0.00630127f, 0.02036511f, 0.02865685f, -0.02451265f, -0.03467483f, -0.02760997f, -0.03363915f, 
    -0.03012765f, 0.01103233f, -0.02604876f, -0.04245452f, -0.00574475f, 0.00615702f, -0.01287951f, -0.00978610f, 
    -0.00891171f, -0.00843420f, -0.00256964f, -0.01816422f, -0.04360285f, -0.00618360f, 0.01685462f, -0.01665835f, 
    -0.01473076f, 0.00471082f, -0.00757999f, -0.01789744f, 0.03379324f, -0.04720922f, 0.00458816f, -0.01782477f, 
    0.00810695f, 0.02748775f, -0.02601876f, 0.00575317f, -0.02809768f, -0.04446106f, 0.01495087f, -0.02484086f, 
    -0.03591253f, -0.00085504f, -0.02700505f, -0.00928335f, -0.01089845f, 0.01424260f, 0.00815226f, 0.03006977f, 
    0.00619466f, 0.00865487f, 0.03743997f, -0.01215905f, -0.01001219f, 0.01618416f, -0.03713604f, 0.02991196f, 
    -0.01620420f, -0.03684254f, -0.00575440f, -0.01435789f, 0.02100763f, -0.00164841f, 0.02381731f, 0.00076031f, 
    0.02688000f, -0.01957373f, 0.02193610f, 0.00910890f, 0.02475207f, -0.02170509f, -0.02560688f, 0.00458002f, 
    -0.01983508f, 0.03266086f, -0.00745758f, -0.03600368f, -0.00058638f, 0.00456549f, -0.00202630f, -0.01657129f, 
    0.02200472f, -0.01048396f, -0.01568699f, 0.01539618f, -0.04517641f, -0.02975840f, -0.02839268f, -0.00815984f, 
    0.02799495f, 0.00164125f, 0.01535527f, 0.04163174f, -0.00584141f, 0.02766975f, -0.03340597f, 0.02072222f, 
    -0.00260427f, -0.00042160f, 0.01335899f, -0.02197732f, -0.02328730f, 0.01808424f, 0.00982904f, 0.01833040f, 
    -0.01667647f, -0.01034211f, -0.02667799f, -0.03276026f, -0.00318847f, -0.03832134f, -0.01397680f, 0.00345376f, 
    0.03486816f, -0.03042006f, -0.03218752f, -0.02289159f, -0.01378838f, -0.01278224f, 0.01649620f, 0.00738493f, 
    0.03025889f, 0.01458034f, -0.03303760f, 0.03433583f, 0.02453680f, -0.00214304f, -0.00819064f, -0.03733769f, 
    0.01055020f, 0.00050266f, -0.02563205f, -0.00782296f, 0.00825162f, 0.03183228f, 0.02613972f, -0.03715701f, 
    -0.01851298f, 0.03212103f, 0.03674519f, 0.01981182f, 0.00851776f, -0.01982612f, -0.04166053f, 0.03382445f, 
    -0.01914686f, 0.01450876f, 0.01173281f, -0.02896254f, -0.01513647f, -0.01227833f, -0.01867025f, -0.02536862f, 
    0.00018537f, 0.00847266f, -0.01213067f, -0.04340078f, -0.03842257f, -0.02289026f, 0.01586927f, -0.02391636f, 
    0.01637732f, -0.00430597f, -0.02134884f, -0.00174423f, 0.01685712f, -0.02597723f, 0.03615850f, -0.01841152f, 
    -0.00582309f, -0.04758561f, -0.00951058f, -0.03425872f, -0.03223711f, 0.02461442f, -0.03987438f, -0.02957834f, 
    0.00262472f, -0.02891232f, 0.02119627f, 0.02196575f, 0.00267078f, -0.02723965f, -0.01689263f, -0.00228868f, 
    0.02539163f, -0.01890459f, -0.01067773f, -0.03186684f, -0.04318313f, -0.00829601f, 0.03694713f, -0.00600052f, 
    0.08152518f, 0.06462236f, 0.11750742f, 0.04750449f, -0.08068710f, -0.01987985f, -0.08320770f, -0.02389311f, 
    0.05319114f, 0.10249481f, 0.02961782f, -0.06853285f, 0.09403629f, -0.03145713f, 0.00811297f, -0.01052190f, 
    0.06338354f, 0.13477197f, 0.01084866f, 0.12321682f, 0.07283096f, 0.01329653f, 0.04167122f, 0.00609979f, 
    0.05087872f, -0.09433216f, -0.10694797f, -0.06940841f, 0.09936964f, -0.12285315f, -0.06489800f, -0.05799444f, 
    0.08627198f, 0.12061478f, 0.14667283f, 0.05616596f, -0.06280626f, -0.00822155f, 0.01304104f, -0.02000677f, 
    0.01796811f, -0.02885237f, -0.10147516f, -0.04841390f, 0.13321437f, -0.01353206f, 0.02864709f, 0.01532670f, 
    -0.14658011f, -0.03903408f, 0.12916005f, 0.08117631f, -0.03777187f, -0.08477981f, -0.01191404f, -0.01489447f, 
    -0.05172870f, -0.12894762f, 0.12294773f, 0.08729167f, 0.09792607f, -0.09470857f, -0.23338565f, -0.03518021f, 
    0.18098457f, 0.03620146f, -0.02559756f, -0.01257907f, -0.13571948f, 0.00386837f, 0.06012469f, -0.01898438f, 
    0.01177888f, 0.01666037f, -0.02727594f, 0.01699817f, -0.09851138f, 0.09804998f, 0.05154542f, -0.05619647f, 
    -0.05460631f, -0.25907391f, 0.09752151f, 0.17870601f, 0.00137693f, -0.01092057f, -0.06802756f, 0.00412547f, 
    -0.06099002f, -0.01957617f, -0.04488402f, 0.03622349f, 0.02849496f, -0.04530912f, -0.02788506f, 0.02367436f, 
    -0.00906352f, -0.02123560f, 0.00620601f, 0.03794941f, 0.23900862f, -0.33003023f, 0.12418694f, 0.00135270f, 
    0.08492212f, 0.06465493f, -0.00983522f, 0.04165927f, 0.05639495f, -0.05426230f, -0.01839750f, 0.11881348f, 
    -0.04214851f, -0.00700861f, 0.08561208f, 0.03088876f, 0.02234069f, 0.00533539f, 0.03391572f, -0.10459823f, 
    -0.30615461f, 0.05006903f, 0.05539474f, 0.00077184f, -0.09773576f, -0.01604281f, 0.14335668f, 0.03741575f, 
    0.00144194f, 0.01238555f, -0.06136608f, -0.01462655f, 0.01315773f, 0.00868001f, 0.00065243f, 0.01847839f, 
    -0.06160799f, 0.02525674f, 0.02880589f, 0.06053576f, -0.27667949f, 0.11261933f, 0.11172742f, -0.03936267f, 
    -0.10294448f, -0.04217736f, 0.01273134f, -0.03723875f, -0.01486447f, -0.04095119f, -0.02530617f, 0.06773516f, 
    0.01680460f, -0.12115342f, 0.04705291f, -0.05392408f, 0.01892629f, -0.00462722f, -0.00087543f, 0.02117485f, 
    -0.02499905f, 0.02320712f, 0.02273046f, -0.02303869f, 0.13170339f, 0.05218352f, 0.09208579f, -0.01241348f, 
    0.02134134f, -0.05041560f, 0.00697041f, -0.00614198f, 0.00021280f, 0.00461026f, -0.03953397f, 0.04818938f, 
    0.06483569f, 0.01347456f, -0.02381716f, 0.03955799f, 0.21638873f, 0.11302370f, -0.23692119f, -0.00684508f, 
    0.08944354f, -0.07918834f, -0.08720819f, 0.01987501f, 0.07353254f, 0.03977105f, -0.09676906f, -0.05211568f, 
    -0.00516928f, -0.01542433f, 0.02439834f, -0.02628640f, -0.00199081f, 0.04356536f, 0.05774255f, 0.01689308f, 
    0.28656051f, -0.05595529f, 0.13235806f, -0.06224182f, -0.08179476f, 0.04272584f, 0.00684365f, 0.01965548f, 
    0.07344422f, 0.07307997f, 0.00076486f, -0.03573835f, -0.00344482f, -0.01214652f, 0.01474098f, 0.03370563f, 
    -0.00770910f, -0.00640502f, -0.06836443f, -0.03335895f, -0.31222051f, 0.24734510f, 0.07161298f, -0.02802714f, 
    -0.16323954f, -0.06272250f, -0.01834617f, -0.00601024f, 0.08066469f, 0.03166439f, -0.08684856f, 0.02263108f, 
    -0.00020437f, -0.05222546f, 0.00323342f, 0.05623341f, 0.05150765f, 0.03064191f, -0.04785485f, -0.01790188f, 
    0.02093934f, -0.03811736f, 0.12194524f, -0.10048442f, -0.23828785f, -0.07258189f, 0.01204070f, -0.03610325f, 
    0.01378230f, -0.01068016f, 0.06768937f, 0.00423702f, 0.04051345f, 0.03708785f, -0.03809846f, 0.02943253f, 
    -0.04061908f, 0.07168483f, 0.02072738f, 0.00528067f, 0.21240641f, -0.33633295f, 0.11984179f, 0.14936522f, 
    -0.05829289f, 0.02716155f, 0.01509293f, 0.03071441f, -0.00665123f, 0.07032178f, 0.01076487f, 0.06426539f, 
    -0.12877765f, 0.08508771f, -0.03041131f, -0.02711574f, 0.01185442f, 0.04433518f, -0.05255728f, 0.03166263f, 
    -0.08597331f, 0.07775409f, -0.01107378f, -0.09808607f, 0.13957253f, 0.12579961f, 0.09939303f, -0.00064609f, 
    -0.01071372f, -0.03300334f, 0.02995635f, 0.05025046f, -0.07599294f, -0.02259096f, 0.00798654f, 0.09052514f, 
    -0.04836621f, 0.04114361f, 0.03390241f, 0.08144291f, 0.39497715f, 0.01057106f, 0.07730401f, 0.07141615f, 
    0.00458155f, -0.19435623f, -0.03323504f, -0.01990911f, 0.02760925f, 0.15569778f, -0.10163659f, 0.02173037f, 
    -0.08784971f, 0.07640494f, -0.01451567f, -0.00682868f, 0.04961543f, 0.16429560f, -0.00140553f, 0.14524586f, 
    -0.00289055f, -0.16825348f, 0.24581178f, -0.13139248f, -0.24912038f, -0.09841408f, -0.02565604f, -0.08090550f, 
    -0.00859472f, 0.00526218f, -0.12744220f, 0.06667326f, 0.01207821f, 0.04478582f, 0.04923124f, -0.02682877f, 
    -0.06238460f, 0.03270106f, 0.06421735f, 0.00947929f, -0.16444133f, -0.20315786f, -0.05969220f, 0.08987417f, 
    -0.10914508f, -0.00488875f, 0.11314648f, 0.07405744f, -0.04293456f, 0.09626434f, -0.00114425f, 0.03041010f, 
    0.11239922f, 0.01030406f, 0.05609231f, 0.03316061f, -0.00436048f, 0.02232133f, -0.07732622f, -0.08990880f, 
    -0.24112862f, 0.08726735f, 0.14179039f, -0.05794758f, 0.14499763f, 0.09800385f, 0.07775404f, 0.00565117f, 
    -0.04941997f, -0.18185386f, 0.01996292f, 0.10536362f, 0.10700653f, -0.02139210f, -0.02155485f, -0.09954944f, 
    -0.01551246f, 0.04638110f, 0.01323085f, 0.03972013f, 0.10401828f, -0.29536521f, 0.06177953f, -0.02187219f, 
    -0.07045472f, 0.07349966f, 0.08786386f, 0.06568550f, 0.01936426f, 0.06568107f, 0.01103117f, -0.04018521f, 
    0.02372368f, 0.03868196f, 0.08318032f, -0.02659813f, 0.09779305f, 0.00632721f, 0.01117310f, 0.05997298f, 
    0.20406994f, -0.20410690f, -0.02577759f, 0.07275801f, -0.04605020f, 0.03805510f, 0.02029477f, 0.02669405f, 
    0.04590712f, -0.06128121f, 0.07784106f, 0.03631109f, 0.05498423f, 0.04327881f, -0.03808743f, -0.06095313f, 
    -0.00546988f, 0.02594977f, -0.03994714f, -0.05405501f, 0.24675371f, -0.33325827f, 0.15552264f, 0.28739485f, 
    0.00412772f, 0.10085429f, -0.03694004f, -0.01017623f, 0.00544683f, -0.03234969f, 0.03083767f, -0.02064252f, 
    0.04150555f, 0.08512731f, 0.10005167f, 0.03542900f, 0.06207691f, 0.00659383f, 0.00646014f, -0.06572982f, 
    -0.08046769f, 0.01821047f, -0.05259154f, -0.11210807f, 0.06291209f, 0.15123017f, 0.06501909f, 0.03066043f, 
    -0.00204194f, 0.00537967f, 0.01724199f, 0.02772397f, 0.05706292f, -0.00031643f, -0.09127118f, 0.03091392f, 
    0.04249537f, -0.03173172f, -0.00369296f, 0.01819130f, 0.18890785f, -0.27504930f, 0.05638814f, 0.25342524f, 
    0.02236128f, -0.04709657f, -0.10140873f, 0.06630471f, -0.02922704f, 0.08694019f, 0.10755640f, 0.07619926f, 
    0.04847724f, -0.01313739f, -0.00303683f, -0.00998880f, 0.11457391f, -0.01160948f, -0.02980849f, 0.03690558f, 
    0.08799697f, -0.05738492f, 0.22485992f, -0.10720275f, -0.25904462f, -0.03482081f, -0.04244671f, -0.01652698f, 
    0.03062327f, -0.01683607f, -0.08547334f, -0.00916225f, -0.01967395f, 0.01214397f, 0.04723131f, 0.02783833f, 
    -0.09021067f, 0.07111201f, 0.05349120f, 0.03421067f, 0.17387901f, 0.18085986f, -0.12360174f, 0.02055596f, 
    -0.05396629f, -0.07151725f, -0.07925189f, -0.05855775f, 0.03908284f, 0.04677904f, -0.00768674f, 0.00466869f, 
    0.03819555f, -0.00589362f, -0.04775319f, 0.03157240f, 0.04981785f, 0.03836291f, 0.03174734f, 0.00687936f, 
    -0.01042177f, -0.07870696f, -0.01148796f, -0.08494227f, 0.14955318f, 0.12898548f, 0.08522615f, 0.03313383f, 
    0.01561942f, 0.00440613f, -0.00409569f, -0.04620232f, -0.05323188f, -0.04409791f, 0.03682875f, -0.04066310f, 
    -0.04845334f, 0.08096034f, 0.00342556f, 0.02524053f, -0.33091971f, 0.00590395f, -0.06603231f, 0.03058919f, 
    0.05451871f, 0.04974972f, 0.05827269f, 0.04608501f, -0.02004489f, 0.05469101f, -0.01254369f, 0.01770487f, 
    0.00461248f, 0.05219105f, -0.04272140f, 0.08449209f, 0.02549633f, 0.00309813f, -0.05138739f, 0.02695890f, 
    -0.07280457f, 0.32736573f, 0.12271369f, -0.09958547f, 0.05603360f, 0.02686626f, 0.05567342f, 0.07961341f, 
    -0.01031229f, -0.05293979f, -0.03344725f, 0.04509891f, 0.02883243f, 0.04322669f, 0.08094842f, 0.16494706f, 
    -0.00556242f, 0.07513814f, -0.01764931f, 0.11715074f, -0.10300581f, -0.07884834f, -0.01102204f, 0.09038994f, 
    0.28919160f, -0.10923865f, -0.04650752f, -0.06402744f, 0.01971437f, 0.03580885f, 0.01426324f, 0.04686713f, 
    -0.02943401f, -0.00864749f, 0.03559843f, 0.06476858f, -0.01314004f, -0.09843816f, 0.03767830f, 0.05768371f, 
    -0.03995896f, -0.02627921f, -0.01435260f, 0.03247262f, -0.23471183f, 0.04817073f, -0.05962002f, -0.03523975f, 
    -0.00330764f, -0.02373005f, 0.01390429f, 0.00230640f, 0.05738917f, -0.08456185f, -0.02931974f, 0.08856976f, 
    -0.07669473f, 0.02906185f, -0.01494436f, 0.04267389f, -0.08449468f, 0.23695707f, -0.08731660f, 0.04826314f, 
    0.18010612f, -0.06844844f, 0.05743801f, 0.09791119f, -0.01209354f, 0.05790957f, 0.02077800f, 0.11365617f, 
    0.09039688f, -0.02420363f, 0.02444739f, 0.01158000f, 0.04681187f, 0.16035956f, -0.02238203f, -0.06202181f, 
    0.35016945f, -0.02278173f, -0.04477445f, 0.05592769f, 0.07773665f, 0.20452426f, 0.00439246f, -0.07307579f, 
    0.25967920f, 0.09760329f, -0.01315438f, -0.04236421f, -0.05195560f, 0.00699569f, 0.02410370f, 0.02298051f, 
    0.09587293f, 0.02598315f, 0.07475780f, -0.01535972f, -0.17686097f, -0.02791356f, -0.08971036f, 0.10673992f, 
    0.29983652f, -0.10809638f, -0.01008786f, -0.04387223f, -0.05334273f, 0.07336129f, 0.02387161f, 0.03071764f, 
    0.02810575f, 0.15106115f, -0.01771513f, 0.05606136f, 0.02266315f, -0.16343667f, -0.07646376f, -0.06954010f, 
    0.00884896f, 0.19086105f, 0.15127426f, -0.22425446f, 0.19233821f, 0.02534747f, -0.03905081f, -0.15897359f, 
    0.00567372f, 0.08041735f, -0.11473329f, -0.07489470f, -0.11141084f, 0.07209309f, 0.13640158f, 0.10847624f, 
    0.08303622f, 0.14731154f, -0.08411589f, -0.02737387f, -0.07432001f, 0.02864076f, 0.19777584f, 0.01150139f, 
    0.00732690f, 0.04318956f, 0.11748429f, 0.14528923f, 0.02336756f, 0.05261922f, -0.03778422f, 0.00432548f, 
    0.06653865f, 0.08345601f, 0.06279912f, 0.12410215f, 0.03622931f, 0.01088769f, 0.00132991f, 0.09989041f, 
    -0.21410245f, 0.18200637f, 0.16724950f, 0.01057071f, 0.20239463f, -0.13044503f, 0.02252703f, -0.08344436f, 
    -0.06229674f, 0.02139928f, 0.03755920f, 0.07174993f, -0.07399822f, 0.18728247f, -0.07950898f, 0.01610038f, 
    0.07119459f, -0.03235431f, -0.06538177f, 0.07782573f, 0.00643618f, 0.15229970f, 0.02972038f, 0.06155626f, 
    0.17029464f, 0.07715108f, -0.03601088f, 0.02489299f, 0.11003208f, 0.02730088f, -0.01030180f, 0.00502687f, 
    0.03845851f, 0.05578180f, 0.00084773f, 0.02119505f, -0.01567434f, 0.01624631f, 0.11782844f, 0.05471164f, 
    0.04377824f, -0.08043294f, -0.14316824f, 0.02873846f, -0.07050304f, 0.20013049f, 0.01463368f, 0.03122679f, 
    -0.01403464f, -0.02101059f, 0.04144195f, -0.08963062f, -0.03613328f, 0.05320992f, 0.03692891f, 0.07120781f, 
    0.02967658f, 0.09638598f, 0.00466661f, 0.04137972f, 0.04215914f, -0.11926129f, -0.31277984f, 0.09244178f, 
    0.05774686f, 0.17575201f, 0.03361202f, -0.10332818f, -0.07382242f, -0.02964570f, 0.02775477f, -0.11172574f, 
    0.03053588f, 0.22039005f, 0.07653399f, 0.06795204f, -0.03750995f, 0.05054706f, 0.02025299f, -0.09242042f, 
    0.21305728f, 0.29373363f, 0.08210672f, -0.08692759f, 0.03318881f, -0.10319953f, -0.03963891f, 0.05170758f, 
    -0.01130353f, 0.02621552f, -0.04621003f, 0.08935335f, 0.07910444f, 0.14296806f, -0.04597824f, -0.06974494f, 
    -0.06365672f, -0.15085851f, -0.05430380f, 0.17523609f, 0.17325850f, 0.24089573f, -0.20352297f, 0.15565179f, 
    0.34486857f, 0.08505794f, -0.01950862f, 0.00117405f, 0.09334092f, 0.05890775f, 0.06129718f, 0.02805294f, 
    0.02338644f, 0.06670422f, -0.01750724f, 0.04659880f, 0.02814107f, -0.01178586f, -0.08277250f, 0.00660788f, 
    -0.11874460f, 0.06673358f, -0.01470210f, -0.16750488f, -0.30719146f, -0.09919901f, -0.00322712f, 0.13657074f, 
    -0.07776001f, -0.18188670f, 0.01112758f, -0.10357213f, 0.02429445f, -0.19796975f, -0.06135381f, 0.14792903f, 
    -0.01641862f, 0.11230131f, -0.00975380f, 0.02763480f, 0.31775063f, -0.21108396f, -0.31555218f, 0.28660884f, 
    0.07882081f, 0.11805905f, -0.23555613f, -0.05854559f, -0.00310014f, -0.04227510f, 0.06276697f, -0.03051109f, 
    0.03117460f, 0.05768942f, 0.13046037f, 0.04889474f, -0.00089810f, -0.08969571f, 0.15131685f, -0.03484605f, 
    -0.03988449f, -0.23035714f, 0.03166849f, 0.07888599f, -0.12569615f, 0.06524965f, 0.06874389f, -0.01288732f, 
    -0.02557043f, -0.10038696f, -0.05906421f, 0.05715789f, -0.05287816f, 0.05076689f, 0.00407034f, 0.07001065f, 
    0.01019569f, 0.04685993f, 0.10493782f, 0.06859472f, -0.50530225f, -0.12418077f, 0.10579634f, -0.08923680f, 
    -0.17210424f, -0.03427118f, -0.08506151f, -0.22836214f, -0.03508885f, -0.14114030f, 0.09015040f, -0.05378040f, 
    0.06617597f, 0.03775100f, -0.00572084f, 0.04032684f, 0.09314504f, 0.00232266f, 0.09167968f, 0.04247557f, 
    0.15312909f, 0.28879523f, -0.01918588f, -0.14418602f, 0.03282106f, -0.11523403f, 0.00973259f, 0.00597264f, 
    -0.10787766f, 0.02271735f, -0.10629063f, -0.05923642f, 0.12695467f, 0.08219121f, -0.02570970f, 0.07823385f, 
    0.16366304f, 0.07247484f, -0.10047860f, -0.00649601f, -0.11942323f, 0.33427051f, 0.11279745f, 0.10955431f, 
    0.32681552f, 0.10601232f, -0.00483447f, -0.12262106f, -0.06242351f, -0.03922193f, -0.04492536f, -0.03551273f, 
    0.10421488f, 0.06254245f, 0.02604078f, 0.02086914f, 0.11065748f, -0.02720152f, 0.01057714f, -0.03151108f, 
    0.10259971f, -0.10845678f, -0.34286639f, 0.03846651f, 0.22800477f, 0.11257426f, 0.06494117f, 0.03959336f, 
    0.00847874f, 0.00703039f, -0.07119013f, -0.03025744f, 0.07917997f, 0.14788485f, 0.06704071f, 0.02861113f, 
    0.03270029f, 0.06641696f, -0.04175148f, -0.00035093f, -0.19723912f, 0.04352516f, -0.03047125f, 0.14441139f, 
    -0.20226428f, -0.07706336f, 0.02084290f, 0.15760717f, 0.05732257f, -0.07322554f, -0.07844662f, 0.02523076f, 
    0.07934882f, -0.06289411f, 0.03519421f, -0.03175516f, 0.06707922f, 0.14243580f, -0.07618960f, -0.15379663f, 
    0.18055937f, 0.09761005f, -0.23349252f, -0.07643351f, -0.08470819f, -0.01279834f, -0.13585043f, 0.01271719f, 
    -0.00335091f, 0.01700655f, -0.03454487f, 0.06164958f, -0.05490168f, 0.03446294f, 0.08774319f, 0.05588458f, 
    0.11311030f, -0.10259008f, 0.05312365f, -0.01499887f, -0.01091031f, 0.20563769f, 0.15214896f, 0.02724903f, 
    0.12586719f, 0.12001117f, -0.02818663f, -0.08686024f, 0.05179860f, -0.11100847f, -0.03291229f, -0.01907911f, 
    -0.08649525f, 0.04063619f, 0.07055242f, 0.01978799f, -0.06188385f, -0.02732323f, -0.03862446f, 0.09327731f, 
    -0.32173193f, 0.04558717f, 0.00551357f, -0.03505712f, -0.10724934f, -0.01915662f, -0.09005302f, -0.08740200f, 
    -0.04249793f, -0.06073844f, 0.12473729f, -0.03879942f, -0.09427658f, -0.02360906f, 0.02137315f, 0.06197481f, 
    0.07375154f, 0.01777935f, -0.02275551f, 0.04037917f, -0.31875235f, 0.13096528f, 0.06750372f, 0.16955550f, 
    -0.03435950f, 0.09145755f, -0.02953865f, -0.10206568f, 0.02280369f, -0.09825394f, 0.11798594f, 0.01344040f, 
    -0.00429387f, 0.17297871f, -0.01005928f, -0.03804252f, 0.07011415f, -0.04569763f, 0.04378986f, 0.05644749f, 
    0.15261927f, -0.12037344f, 0.18036164f, -0.15367869f, -0.19730693f, -0.03262362f, 0.01514159f, 0.10885041f, 
    -0.06085134f, -0.14389440f, -0.08515298f, 0.16670166f, -0.07935650f, -0.12214069f, 0.01096877f, 0.01765585f, 
    -0.01135831f, 0.08656786f, 0.00777545f, 0.16026504f, -0.17946449f, -0.12582265f, 0.23212402f, -0.07520533f, 
    -0.03201570f, -0.02018124f, -0.01081620f, -0.09203995f, 0.00154873f, 0.06202720f, 0.05831713f, 0.01198973f, 
    -0.03822092f, -0.01374879f, -0.07229494f, 0.11787679f, 0.03041524f, 0.12422319f, -0.11605299f, 0.01281139f, 
    0.21278308f, -0.13901280f, -0.17308296f, 0.03802202f, 0.06819932f, 0.11705521f, 0.09796777f, -0.06869387f, 
    0.09250611f, -0.00166285f, -0.12140445f, 0.01404499f, 0.12818189f, 0.14637507f, 0.03619236f, 0.06402808f, 
    0.04943000f, -0.00295727f, 0.05574126f, 0.02865134f, 0.31044459f, 0.07411405f, -0.23856241f, 0.09063780f, 
    0.13462216f, 0.09406766f, 0.06150783f, 0.00540337f, -0.00411871f, 0.01672513f, -0.01853626f, 0.07525715f, 
    -0.15098995f, 0.11000340f, 0.00066230f, 0.12648201f, 0.05725753f, 0.14966647f, -0.02481700f, 0.15831055f, 
    0.25249976f, -0.09467611f, 0.12885728f, -0.09828675f, -0.24285911f, -0.05000899f, -0.01785272f, 0.11793452f, 
    -0.12983558f, -0.17728065f, -0.03737136f, 0.08955897f, -0.05269875f, 0.00133474f, -0.00310423f, 0.02262974f, 
    -0.03936170f, 0.08643445f, -0.02054367f, 0.05033307f, 0.18348794f, -0.05042331f, -0.32836071f, 0.16356178f, 
    -0.10417140f, 0.00341246f, 0.07476929f, 0.06065179f, -0.11367246f, -0.00415804f, -0.00973202f, -0.00623958f, 
    -0.03197943f, -0.07998753f, -0.09670093f, 0.09854783f, 0.10894533f, -0.07661808f, 0.04966913f, -0.00788628f, 
    -0.11995855f, 0.29054409f, 0.09386031f, -0.25612202f, 0.04843002f, -0.16355127f, 0.17431688f, -0.09888846f, 
    -0.11229241f, 0.04592808f, 0.08073669f, 0.05908082f, 0.01961885f, 0.00680173f, 0.01867626f, -0.01042038f, 
    -0.05475144f, -0.10072195f, 0.07930577f, 0.12016752f, 0.07349795f, 0.24450834f, 0.12347548f, 0.05559780f, 
    0.22019368f, 0.16569041f, -0.10625641f, 0.06952807f, 0.04903162f, 0.06916748f, 0.08111294f, -0.10621749f, 
    0.07485797f, -0.04666117f, 0.05971429f, -0.02603354f, 0.05518205f, -0.01234605f, 0.05685343f, 0.00395717f, 
    -0.05759374f, 0.08580617f, -0.13314065f, -0.00598139f, -0.08150897f, 0.05297717f, 0.12048060f, -0.13862687f, 
    -0.02619364f, -0.01091231f, 0.08862016f, 0.03895589f, 0.05538421f, 0.03517665f, 0.06569368f, -0.03232093f, 
    0.05079284f, 0.03282487f, 0.12858376f, 0.05880025f, 0.04784928f, 0.21261211f, -0.19640628f, 0.20712164f, 
    0.16514829f, 0.12821868f, 0.06676412f, -0.11019327f, 0.00512597f, 0.06378954f, 0.00252531f, 0.05113517f, 
    -0.09477720f, 0.08875120f, -0.06378221f, 0.02763837f, 0.09330732f, 0.04153667f, 0.17517263f, 0.00927549f, 
    0.02643500f, -0.02772645f, -0.02355679f, 0.01206684f, 0.01768591f, -0.01300746f, 0.03051081f, -0.03648676f, 
    -0.02158298f, 0.01361110f, -0.03190373f, -0.03406387f, 0.00175258f, 0.02490855f, -0.00826256f, 0.01436810f, 
    -0.03128210f, -0.00791712f, -0.03984658f, 0.00290865f, 0.02022725f, -0.03361735f, -0.01372408f, 0.01410219f, 
    -0.04550707f, 0.02749673f, 0.02851951f, -0.00726677f, -0.00773510f, -0.00144048f, 0.01445506f, -0.00500973f, 
    0.01615592f, 0.00668933f, -0.04456257f, -0.00485447f, -0.00379077f, -0.02354698f, -0.04095424f, -0.01503207f, 
    0.01041552f, -0.01685804f, -0.03538531f, -0.04472993f, 0.02318867f, 0.00154956f, 0.00347715f, 0.02572200f, 
    0.00003504f, -0.01437793f, -0.00288829f, 0.03270511f, -0.00857051f, -0.03697089f, -0.01311333f, 0.00335092f, 
    -0.00042389f, 0.02655343f, -0.02793951f, -0.03814710f, -0.02344071f, 0.00753586f, 0.02945989f, 0.02049706f, 
    -0.01639572f, -0.00971031f, 0.00324303f, 0.03173291f, -0.04513056f, 0.03100135f, -0.03154005f, 0.00451104f, 
    0.02518272f, -0.00266328f, -0.02757512f, -0.02549695f, -0.03275439f, -0.04341437f, -0.02219294f, 0.00308000f, 
    -0.03567821f, -0.01662778f, -0.02756071f, 0.01645138f, 0.03322970f, -0.00434036f, 0.02633189f, -0.03057357f, 
    0.00209613f, -0.00328919f, 0.01663158f, 0.03026027f, 0.03096455f, -0.02942685f, -0.02317610f, 0.00806321f, 
    0.03329205f, 0.00458171f, 0.02061069f, 0.01779665f, -0.00632431f, -0.03915343f, -0.01264942f, -0.01538093f, 
    0.01518912f, 0.00327764f, -0.04416350f, -0.03460536f, -0.00733275f, -0.02119703f, -0.00472201f, 0.01137233f, 
    -0.03943748f, -0.00111810f, -0.03016833f, -0.03767269f, 0.00691656f, 0.02294559f, -0.02051027f, -0.04358659f, 
    0.01940607f, 0.00033746f, -0.03080804f, -0.00417389f, 0.02749523f, -0.00796041f, -0.00813468f, 0.00623157f, 
    0.00541100f, 0.01864351f, 0.00429942f, -0.00046377f, -0.01389321f, 0.00583408f, -0.03651306f, 0.00722345f, 
    -0.01509401f, -0.02282589f, -0.00832778f, 0.00960557f, -0.02356467f, -0.00208374f, -0.03129683f, 0.00185312f, 
    -0.02238562f, 0.00467804f, -0.01536224f, -0.01222022f, 0.00215518f, 0.02998562f, 0.00159333f, -0.04244091f, 
    -0.00997536f, -0.01149231f, -0.03204582f, -0.03362473f, -0.00706301f, -0.04116541f, 0.00311942f, 0.00991870f, 
    0.01641718f, -0.00172740f, -0.03069626f, -0.04280896f, -0.04420722f, 0.02808684f, -0.03815324f, -0.01857468f, 
    0.00156366f, 0.01638187f, -0.02228873f, -0.04460393f, 0.03170983f, 0.00222638f, -0.03012539f, -0.03424172f, 
    0.02179182f, 0.03735381f, 0.02927527f, -0.02821792f, -0.03523334f, 0.00551761f, -0.02212546f, 0.02615097f, 
    -0.01759343f, 0.00683303f, 0.01196085f, -0.00682915f, -0.00863293f, -0.02969229f, -0.01593324f, 0.02219599f, 
    0.02430103f, -0.01889878f, -0.00090642f, -0.01689739f, 0.02877408f, -0.01007136f, -0.02626440f, -0.01480426f, 
    -0.02158140f, 0.02703895f, -0.01316908f, 0.02149614f, -0.01871114f, 0.02696629f, -0.03108806f, -0.02193275f, 
    0.02666157f, -0.03663781f, 0.03169446f, -0.04318323f, -0.01486215f, 0.01398939f, -0.01891219f, 0.01090709f, 
    0.02274072f, 0.02870099f, 0.01597227f, -0.02615833f, -0.01666155f, 0.01784679f, -0.00354787f, 0.00947432f, 
    -0.03410836f, -0.01621114f, 0.02216516f, -0.04487808f, -0.03253109f, -0.01130234f, 0.01537646f, 0.01507528f, 
    -0.04525019f, 0.02507010f, 0.02389917f, -0.00520068f, -0.02985417f, -0.01325328f, -0.00849200f, -0.01939277f, 
    -0.02161826f, -0.03588198f, -0.03877892f, 0.00584676f, -0.03488770f, 0.01554375f, 0.01283971f, -0.01013891f, 
    -0.03397018f, -0.04324563f, -0.01952683f, -0.00195817f, -0.01491418f, 0.02082201f, -0.03475913f, -0.04455527f, 
    -0.00906445f, -0.00721133f, -0.03123378f, 0.00505131f, -0.03577951f, -0.04151260f, -0.01152158f, -0.01675197f, 
    -0.03143844f, -0.04128259f, -0.01137136f, 0.02546444f, -0.00994913f, -0.02396454f, -0.01688722f, 0.00880510f, 
    -0.04436968f, -0.01205084f, -0.01636427f, -0.00838408f, -0.02538389f, -0.00247452f, 0.02659509f, 0.01198599f, 
    0.00065441f, 0.01487517f, 0.02134624f, 0.02551289f, -0.02544273f, -0.01471653f, 0.03092206f, -0.00440144f, 
    0.01178341f, -0.00022854f, -0.02864522f, -0.02032794f, 0.01216055f, 0.01856371f, -0.03453732f, -0.01576006f, 
    -0.00215312f, -0.01635120f, -0.00826131f, -0.04306474f, -0.00142920f, 0.02132813f, -0.04471751f, 0.00080815f, 
    -0.01565786f, 0.03302300f, -0.01867270f, -0.04465146f, 0.03108867f, 0.02971699f, -0.03869393f, 0.01110283f, 
    0.00784802f, -0.04185285f, -0.01895303f, -0.03339711f, -0.04414712f, 0.00904420f, -0.01856554f, -0.02787479f, 
    0.02440534f, 0.02172816f, -0.00462785f, 0.00280506f, 0.00792343f, -0.02482701f, 0.00097392f, 0.01150274f, 
    -0.02524971f, -0.02767844f, 0.03039716f, -0.03768715f, -0.01695834f, -0.03442777f, -0.03048164f, -0.03040684f, 
    -0.04492065f, -0.01554990f, 0.01794005f, -0.02185847f, 0.02878727f, -0.04088226f, 0.00904222f, -0.00001862f, 
    0.02028030f, 0.01034734f, 0.00956264f, 0.02038404f, 0.01013891f, -0.03074716f, 0.01150137f, 0.01729162f, 
    -0.00190638f, -0.02051616f, 0.03282004f, 0.02607497f, 0.02518610f, 0.01066558f, 0.00201475f, 0.00820086f, 
    -0.03876735f, 0.00172910f, -0.02812656f, 0.02740900f, 0.03291719f, 0.00631122f, -0.02508444f, -0.02575674f, 
    0.00084273f, 0.02891850f, -0.04302646f, 0.02468370f, -0.00119821f, -0.01104094f, 0.00926209f, 0.02301388f, 
    -0.02871354f, -0.00016369f, 0.00628644f, -0.02885378f, 0.00558078f, 0.02457875f, 0.00487291f, 0.01909504f, 
    -0.00909069f, -0.03138757f, -0.03637666f, -0.03404960f, -0.02723297f, -0.01411793f, 0.02985187f, 0.01392647f, 
    -0.03112646f, -0.02445076f, -0.03266419f, 0.02999883f, -0.01037993f, 0.00212536f, -0.02998107f, -0.01364052f, 
    0.02295196f, -0.03128618f, -0.02164801f, 0.01383838f, -0.00396508f, 0.02985414f, -0.02257016f, -0.04404905f, 
    -0.02054867f, 0.00272230f, 0.00882712f, -0.00305962f, -0.01308946f, 0.03323303f, 0.03224673f, -0.04489249f, 
    -0.01567554f, 0.00512999f, -0.02361307f, -0.04066448f, 0.00030813f, 0.00730010f, -0.00255087f, -0.00169006f, 
    -0.03216132f, 0.03288607f, -0.02443969f, -0.02545683f, -0.01285036f, -0.01085070f, -0.04076135f, -0.00709297f, 
    -0.01597313f, 0.00191365f, 0.01702501f, 0.01368264f, 0.01030791f, -0.03079814f, -0.02574910f, -0.01836014f, 
    -0.00368177f, -0.01569410f, 0.01976010f, 0.01205959f, -0.04535953f, 0.03080713f, 0.02031171f, 0.00443407f, 
    0.02047646f, -0.01731203f, 0.02511116f, -0.01936757f, -0.01717995f, 0.01814560f, -0.02111357f, -0.00793859f, 
    -0.02576752f, -0.00918713f, -0.02257202f, 0.02555214f, -0.03926568f, -0.02910589f, 0.02839350f, 0.01804071f, 
    -0.03428394f, -0.03855156f, 0.01496162f, 0.02634755f, -0.00672201f, -0.01822742f, -0.03428889f, -0.00996585f, 
    -0.01568792f, 0.01974893f, -0.02200991f, 0.00171427f, 0.01239502f, -0.00420809f, -0.02958501f, 0.02735394f, 
    -0.02242515f, 0.01236265f, -0.02635013f, -0.02259993f, 0.02075138f, 0.02044487f, 0.01617771f, -0.00473963f, 
    -0.02513687f, 0.03115041f, -0.01977534f, -0.00018688f, 0.02142513f, 0.03272705f, -0.00370658f, 0.00151291f, 
    0.00129737f, -0.01492216f, -0.01596818f, 0.02807374f, -0.00703437f, -0.00608975f, -0.04315867f, -0.01118474f, 
    0.01912810f, -0.02090634f, -0.00574247f, -0.00479821f, -0.01754989f, 0.02761952f, 0.00856872f, -0.03601358f, 
    -0.01604889f, 0.01272302f, 0.00853048f, 0.01374026f, 0.02928314f, -0.01979434f, 0.02001346f, -0.03315348f, 
    -0.02561085f, 0.00411011f, -0.04495412f, 0.01748799f, 0.01780943f, 0.01496374f, 0.02697163f, -0.04174297f, 
    -0.03463540f, -0.03165568f, 0.01236858f, -0.02874191f, -0.01379490f, 0.01492491f, -0.00044856f, 0.01607647f, 
    0.03033574f, -0.02648273f, -0.01933528f, -0.02729269f, -0.01061726f, 0.02013827f, 0.01337666f, 0.02156970f, 
    -0.02821779f, 0.01717006f, -0.03945204f, -0.00631562f, -0.01394081f, -0.04198663f, 0.01785805f, 0.02352600f, 
    -0.01713595f, 0.00371286f, -0.01955962f, 0.00448203f, 0.03135452f, -0.01307916f, -0.00450347f, 0.02045034f, 
    0.01189403f, -0.03184582f, -0.00335483f, 0.00777054f, -0.02419860f, -0.01532269f, -0.03944348f, 0.00829203f, 
    -0.04364869f, 0.02488648f, 0.01799503f, 0.03288513f, 0.00235978f, -0.02959806f, 0.01388982f, 0.00240528f, 
    0.01591334f, 0.00310509f, -0.04360145f, -0.03442421f, 0.02835411f, -0.03995429f, 0.01582769f, 0.01340919f, 
    0.01362065f, 0.01455052f, -0.01112034f, -0.02874903f, -0.00345608f, -0.03040024f, 0.02031353f, 0.00518273f, 
    -0.00473849f, 0.00462610f, -0.00351626f, -0.03551128f, 0.01643485f, 0.00885177f, -0.03421059f, -0.00829076f, 
    0.01407707f, -0.00878199f, -0.00527288f, -0.02600336f, -0.00629206f, 0.01290007f, 0.01694413f, -0.03058375f, 
    -0.02256793f, -0.03335594f, 0.02475971f, 0.02653884f, -0.04501422f, -0.03245371f, -0.03743064f, -0.00064551f, 
    0.01167268f, 0.00251990f, -0.04349395f, -0.02622439f, -0.01420518f, 0.00541057f, -0.03530558f, -0.02405899f, 
    0.02848013f, 0.01341867f, -0.01346389f, -0.02127612f, -0.00288282f, 0.03232130f, -0.02136177f, -0.03727787f, 
    -0.02880567f, -0.02698344f, 0.00038642f, -0.02394558f, 0.02307840f, -0.02826196f, 0.01892659f, -0.03002243f, 
    -0.07765813f, 0.17793064f, 0.06677515f, -0.07340368f, -0.18615149f, -0.11765078f, -0.16899766f, 0.01473887f, 
    -0.02665048f, 0.08893714f, -0.03159095f, -0.01100968f, 0.10505456f, -0.00596253f, -0.01802857f, 0.05261089f, 
    -0.01698778f, 0.02309326f, -0.03149830f, -0.01009961f, 0.22943950f, -0.15421109f, 0.03163871f, 0.05337694f, 
    -0.29579425f, -0.01251517f, 0.05112952f, -0.10654827f, -0.01286936f, -0.00507959f, 0.01008474f, -0.07627692f, 
    0.07635426f, 0.10935193f, 0.09497708f, 0.01915587f, -0.05048856f, -0.06301452f, -0.09220900f, 0.09534828f, 
    0.17693439f, -0.08429336f, -0.07218330f, 0.07410578f, -0.00703481f, 0.01190810f, 0.01795069f, 0.09583613f, 
    -0.02149112f, -0.00262749f, 0.08766300f, 0.12433936f, 0.04221179f, -0.06464475f, 0.02992629f, -0.03314422f, 
    0.03399610f, -0.11660088f, 0.06767280f, 0.03780972f, 0.16747957f, 0.18121310f, -0.27483347f, 0.07181880f, 
    0.09072702f, 0.02733348f, -0.05590689f, -0.00510835f, -0.04486215f, 0.01822083f, -0.07287168f, 0.06695487f, 
    -0.00715451f, -0.00685523f, -0.03027791f, 0.09548644f, 0.03641773f, 0.12300783f, -0.07664121f, -0.02627422f, 
    0.15098524f, -0.48375177f, -0.02863706f, 0.20588189f, 0.01178539f, -0.03698304f, 0.03691916f, -0.00256112f, 
    0.10684213f, 0.08600370f, 0.00089207f, 0.00697462f, 0.06667642f, -0.08767277f, 0.06950502f, 0.00500022f, 
    -0.00114971f, 0.08486173f, 0.01866493f, 0.12155177f, 0.05004401f, -0.15412334f, 0.09595373f, -0.04455072f, 
    0.15074874f, 0.01889631f, 0.08473268f, 0.04660077f, 0.08459909f, -0.01793101f, 0.02267925f, 0.02742077f, 
    0.06858915f, -0.01017004f, 0.02353822f, -0.01717324f, 0.10859027f, 0.09453773f, -0.02590400f, 0.04605839f, 
    -0.13961555f, 0.08550599f, 0.12543170f, 0.09799870f, 0.08480378f, -0.04539990f, 0.14112923f, 0.09695090f, 
    0.04667239f, -0.01368937f, -0.02442894f, -0.05146179f, -0.02653731f, 0.00298570f, -0.03932878f, 0.02882949f, 
    -0.03994099f, -0.00740503f, 0.04614132f, -0.03496637f, -0.20976599f, -0.05760140f, 0.28931886f, 0.12659951f, 
    -0.00618006f, 0.02586990f, -0.01516038f, 0.06936736f, -0.02182277f, 0.00104560f, -0.04039696f, -0.02990873f, 
    -0.08293407f, 0.00929069f, 0.01633667f, -0.02309638f, 0.01302681f, -0.06098830f, -0.07704216f, -0.01662498f, 
    -0.32786101f, -0.31177741f, -0.12046935f, 0.03106851f, 0.10186874f, 0.02368026f, 0.07149813f, -0.09732336f, 
    -0.03756725f, -0.00143561f, -0.09700764f, -0.12826866f, -0.08895779f, -0.02234390f, -0.02207323f, 0.06365939f, 
    0.00549025f, 0.05540662f, 0.04537912f, 0.12774022f, 0.18318789f, -0.03590305f, 0.06212951f, 0.05216441f, 
    -0.16325086f, -0.09298896f, -0.03246305f, 0.13414080f, -0.02355537f, 0.04690004f, -0.00313680f, -0.05151340f, 
    -0.08795148f, -0.07202649f, 0.03481737f, -0.02463545f, 0.06435283f, -0.08566228f, 0.06023389f, 0.03420085f, 
    0.05708323f, 0.04951807f, -0.03991014f, -0.02285361f, -0.01811750f, 0.11705827f, -0.01047367f, -0.00721246f, 
    -0.03571926f, 0.13018519f, 0.12573385f, 0.02473700f, -0.00812692f, -0.00714919f, 0.03497964f, 0.17130490f, 
    -0.03261064f, 0.00245186f, 0.05848416f, -0.03416150f, -0.42788830f, 0.11816058f, 0.26474401f, -0.18656585f, 
    -0.06234735f, -0.08174612f, 0.11133090f, -0.06937676f, 0.11132470f, 0.12695202f, -0.10455475f, -0.05415755f, 
    0.04307603f, -0.00681635f, 0.02280293f, -0.01884354f, -0.00009193f, -0.04988056f, -0.04169027f, 0.02308537f, 
    -0.03886108f, 0.05696755f, 0.15295966f, 0.03250396f, -0.13532789f, -0.01108633f, 0.02030266f, 0.02043598f, 
    -0.01737115f, 0.01243282f, 0.08592425f, -0.04565625f, -0.01353870f, 0.02977628f, -0.03433931f, 0.07362473f, 
    -0.01827684f, 0.02478580f, -0.04620458f, -0.01829216f, 0.28754148f, -0.09714518f, 0.05824345f, 0.03999032f, 
    0.02114791f, -0.01073815f, 0.06953843f, 0.01271354f, -0.05081581f, -0.02227655f, 0.05844202f, 0.03506358f, 
    -0.01872876f, 0.02315506f, -0.01613861f, 0.01754740f, -0.01899336f, 0.05615979f, -0.02087802f, 0.00629134f, 
    -0.21048462f, -0.15043180f, -0.16506904f, 0.05200333f, -0.05045639f, 0.11605062f, 0.11549717f, 0.04703493f, 
    0.00395264f, 0.01773688f, -0.07575274f, -0.01154861f, -0.07990585f, 0.12882532f, 0.10701080f, 0.11148017f, 
    -0.01035121f, 0.05892388f, -0.04317932f, 0.09479172f, 0.07286881f, -0.13521324f, -0.00045841f, -0.09971268f, 
    -0.26731274f, -0.00059780f, 0.02815221f, -0.06225624f, 0.01122587f, 0.05303060f, 0.06858545f, 0.07627521f, 
    -0.11568840f, 0.04627573f, -0.01266692f, 0.02689958f, 0.09061048f, 0.06252975f, 0.00465054f, 0.03212720f, 
    -0.28562886f, -0.08138511f, 0.32756242f, -0.07281587f, -0.24568376f, -0.03255881f, 0.08664691f, -0.06659440f, 
    0.06131990f, 0.04140100f, -0.10828698f, -0.04591103f, -0.02669598f, 0.06047997f, 0.02451211f, -0.03341271f, 
    -0.06336932f, 0.00096768f, 0.09594526f, 0.05583419f, -0.19325730f, -0.13030478f, -0.18618828f, -0.02626766f, 
    -0.04645756f, 0.06585549f, -0.08991708f, -0.03656028f, -0.13720948f, 0.18585384f, 0.03006755f, 0.08464246f, 
    0.02814022f, 0.03129076f, 0.10409920f, 0.07262721f, 0.07931887f, -0.00773986f, -0.05152099f, -0.01040351f, 
    -0.08562939f, -0.17265262f, -0.08153149f, 0.12989423f, 0.12513892f, 0.15662169f, 0.04300648f, -0.10199570f, 
    0.01841717f, -0.01468933f, 0.12074952f, 0.14504537f, 0.02700423f, -0.01044775f, 0.10185306f, 0.02632920f, 
    0.03039228f, -0.03948542f, -0.03328169f, 0.05670154f, 0.11790652f, -0.28839672f, -0.07673509f, -0.04405230f, 
    -0.06414100f, 0.00511665f, 0.10906374f, 0.05892117f, 0.03487096f, 0.04058691f, 0.00529748f, 0.00094549f, 
    0.03082312f, 0.02200382f, -0.05712358f, -0.01388092f, 0.05659924f, 0.07009109f, 0.06845628f, 0.07767245f, 
    0.12533587f, -0.11607398f, -0.09219239f, 0.01525998f, -0.00182959f, 0.07623877f, 0.01073461f, -0.09905750f, 
    -0.00019792f, -0.01045126f, 0.00223744f, 0.04558675f, -0.04624448f, -0.01516622f, 0.02080027f, -0.02865586f, 
    0.02879614f, -0.03040792f, 0.04484727f, -0.00353995f, -0.05470762f, -0.40039468f, -0.09445655f, -0.04192220f, 
    0.34180534f, -0.04923017f, -0.06990492f, -0.03974733f, -0.01160759f, 0.00162273f, -0.03893793f, 0.01826576f, 
    0.03471441f, -0.01030537f, 0.07025562f, -0.01310346f, -0.00209566f, 0.05072685f, 0.01701582f, 0.03464597f, 
    0.19112453f, -0.10787189f, -0.40377575f, 0.05742993f, -0.02731227f, 0.05353891f, 0.00139959f, -0.04701852f, 
    0.02867497f, 0.02384983f, -0.03079039f, 0.10413754f, -0.03914526f, 0.07211691f, 0.00919918f, 0.11026379f, 
    0.04126046f, -0.00116225f, 0.03679258f, 0.01642144f, 0.31661314f, -0.03058170f, -0.24202430f, 0.08634339f, 
    -0.11812483f, 0.00900856f, -0.02772841f, 0.11592089f, 0.07280150f, -0.03403011f, 0.09220358f, -0.01732727f, 
    0.08047591f, 0.09288140f, 0.02463037f, 0.09466104f, 0.01401472f, 0.05408378f, 0.11620291f, 0.02132916f, 
    -0.31201974f, 0.10096943f, 0.29645982f, -0.11018240f, -0.18872660f, 0.02792180f, 0.01170794f, -0.02115582f, 
    0.10087328f, 0.02652517f, -0.03666337f, -0.07710540f, 0.00690347f, 0.00951624f, -0.02494152f, -0.02168779f, 
    -0.06907805f, 0.04241292f, 0.04447059f, -0.00141480f, 0.04436853f, -0.00248166f, 0.11745065f, -0.02745390f, 
    -0.08006477f, -0.10287580f, -0.00449539f, 0.08785786f, 0.00524211f, 0.09768728f, -0.03404789f, -0.06570296f, 
    -0.00896881f, -0.01717049f, -0.02096078f, 0.04968210f, 0.06630688f, -0.12570345f, 0.13901600f, 0.00105282f, 
    0.06130792f, -0.15268442f, -0.43183175f, 0.02239664f, -0.00614108f, 0.00512421f, 0.02341780f, -0.00953334f, 
    -0.01447363f, 0.08484076f, -0.04114889f, -0.07017530f, -0.00434974f, -0.00141839f, 0.02408828f, -0.03549364f, 
    -0.01501191f, 0.02208417f, 0.07069176f, 0.07345451f, -0.31799451f, 0.18004899f, 0.05299114f, -0.02540234f, 
    0.14871991f, 0.07306765f, 0.02924736f, 0.00252647f, 0.05247692f, -0.01826873f, 0.03789132f, -0.05934115f, 
    0.00828440f, -0.02442734f, 0.03450092f, 0.12626706f, 0.09683008f, 0.06114809f, -0.07578936f, 0.04034423f, 
    -0.12037826f, 0.16657709f, 0.17487107f, 0.01005113f, 0.26447785f, -0.01175883f, -0.06605466f, -0.05324345f, 
    -0.02470913f, 0.01524945f, 0.05663641f, -0.00431220f, -0.00665136f, 0.05859874f, 0.00803303f, 0.07452529f, 
    0.12739219f, 0.09885871f, 0.00925635f, 0.08080468f, -0.00563051f, -0.00652056f, 0.08096391f, 0.05615218f, 
    0.09250915f, -0.16990909f, 0.04087412f, 0.01178842f, 0.05792935f, 0.16459173f, -0.06611739f, 0.00936898f, 
    0.04985935f, 0.04002441f, 0.04727193f, 0.06207333f, -0.00337052f, 0.07847965f, 0.04610529f, -0.00623963f, 
    0.00765715f, 0.03616110f, 0.10207934f, 0.17930536f, 0.05352558f, -0.00306230f, -0.05902506f, -0.00416887f, 
    -0.00233516f, -0.01044841f, 0.08394931f, 0.05804189f, 0.06205960f, -0.03022262f, 0.00578489f, 0.10142481f, 
    0.06542720f, 0.01060196f, 0.01295660f, 0.05073893f, -0.03188410f, 0.34090185f, 0.06536473f, -0.16855374f, 
    0.07903264f, -0.05981861f, 0.08609404f, 0.07514963f, 0.02197435f, 0.10594890f, -0.00680337f, 0.04198095f, 
    0.08905104f, -0.06852943f, 0.04677894f, -0.03065663f, 0.08898154f, 0.08215090f, -0.03188452f, -0.02678594f, 
    -0.00635657f, -0.00852523f, 0.02822718f, -0.00108093f, 0.02425069f, 0.03143720f, 0.01094373f, 0.00275405f, 
    -0.02472388f, -0.01347670f, -0.02449550f, -0.02647018f, 0.02731354f, -0.00780026f, 0.00677029f, -0.02363041f, 
    0.01700529f, 0.01101424f, -0.01069849f, -0.00841820f, 0.00405110f, -0.01477950f, -0.04123536f, -0.04169272f, 
    -0.04021247f, -0.01603191f, 0.01928089f, -0.03351894f, 0.01957186f, -0.03310674f, -0.02659426f, -0.02240139f, 
    -0.01219257f, -0.01636853f, -0.03086570f, -0.01190643f, 0.02853079f, -0.00067986f, 0.01717452f, -0.00989791f, 
    0.00591205f, -0.01643221f, -0.00624128f, -0.01651973f, -0.00791375f, 0.01922840f, 0.04431655f, -0.00075047f, 
    -0.03113151f, 0.02345938f, 0.00542221f, -0.03634893f, -0.00687131f, 0.01406876f, -0.02059526f, -0.03865153f, 
    0.00949059f, -0.02962013f, -0.04274467f, 0.02208362f, -0.02897699f, -0.00708043f, -0.03230260f, -0.02283779f, 
    -0.04453869f, -0.01503756f, -0.02632271f, -0.01084016f, 0.00853557f, -0.03076702f, -0.00638379f, -0.02071354f, 
    -0.02509794f, -0.01707865f, -0.04076572f, -0.00687995f, -0.01344738f, 0.01179054f, -0.04199039f, 0.02748893f, 
    0.00413264f, -0.03753191f, 0.03284785f, -0.04187055f, 0.02221119f, -0.03202526f, 0.02126674f, -0.01926418f, 
    -0.00910929f, 0.00212006f, -0.02937107f, -0.04548560f, -0.04327929f, 0.01856217f, -0.00951713f, -0.01268705f, 
    0.00906299f, 0.02282099f, 0.01680063f, -0.02209725f, -0.03885716f, -0.00975965f, -0.02266144f, 0.00033934f, 
    -0.00071184f, 0.02598286f, -0.01892412f, -0.03202559f, 0.03006083f, 0.01207138f, -0.04381362f, 0.02127930f, 
    0.03404408f, 0.03001006f, 0.01595319f, -0.03422635f, -0.01000679f, 0.01053993f, 0.02240799f, 0.00581012f, 
    0.01303608f, 0.03174113f, -0.02521500f, -0.03284844f, 0.02408131f, 0.01284659f, -0.01986277f, -0.00695835f, 
    0.00820757f, -0.03476383f, 0.02928662f, -0.02550050f, -0.04329173f, -0.04270706f, -0.01754879f, 0.00641741f, 
    0.03206653f, 0.02216401f, -0.04208672f, 0.02472521f, 0.01680447f, 0.02211581f, 0.00605525f, 0.00270410f, 
    0.02861755f, -0.03798639f, -0.03599188f, -0.00673900f, 0.01977744f, -0.03114147f, -0.03992797f, -0.03914059f, 
    -0.00347831f, -0.00939607f, -0.03119414f, -0.01892724f, 0.02426755f, -0.01591989f, -0.04193335f, -0.00749558f, 
    0.00010152f, -0.02536351f, 0.02854512f, -0.03958353f, -0.00791209f, -0.03124454f, 0.01827485f, 0.03644518f, 
    0.02560719f, 0.00524461f, 0.02356612f, 0.01651827f, -0.00244685f, -0.00833157f, 0.03269113f, -0.03876477f, 
    -0.01047566f, 0.00797778f, 0.01291599f, 0.02961745f, -0.02069919f, -0.03088672f, -0.00326211f, 0.01799872f, 
    -0.02912118f, -0.03829795f, 0.02485370f, -0.01371654f, 0.01401803f, -0.02278942f, 0.03000665f, 0.00405568f, 
    -0.03160259f, -0.02734980f, 0.01675520f, -0.01646569f, -0.04124658f, 0.01994669f, 0.02751554f, -0.01897218f, 
    -0.02751004f, -0.02621272f, 0.01752312f, -0.03930035f, -0.00803007f, -0.03746506f, 0.01940531f, -0.00878455f, 
    0.02065369f, -0.04531703f, -0.02464903f, -0.00429869f, 0.01930171f, -0.00055678f, 0.01272268f, 0.03178816f, 
    -0.02468449f, -0.03537318f, 0.01852443f, -0.01553652f, -0.00846579f, 0.01834679f, -0.00003563f, 0.02292229f, 
    0.03265403f, -0.01628764f, 0.01365182f, -0.00538898f, -0.02131173f, -0.02161637f, -0.00470386f, 0.02092530f, 
    -0.02702282f, -0.04206752f, -0.01634968f, 0.02382139f, -0.00787785f, -0.03302250f, 0.01674875f, 0.02071359f, 
    0.00059121f, 0.01226615f, -0.02955518f, -0.03106179f, -0.02712895f, -0.04291811f, 0.01857516f, 0.02548122f, 
    0.01441741f, -0.02390973f, 0.01738957f, -0.01870110f, -0.04347275f, -0.00838353f, -0.00928540f, -0.02338587f, 
    -0.00080859f, 0.00769232f, 0.00436147f, -0.01487976f, -0.01897849f, -0.03286908f, 0.02050578f, 0.03225274f, 
    -0.02440587f, -0.00401303f, 0.01649373f, -0.03570045f, -0.02718143f, -0.02730551f, 0.01098063f, 0.02936544f, 
    0.00025165f, -0.02630619f, 0.04341540f, 0.01948570f, 0.00254228f, 0.02896590f, -0.00972919f, 0.02588143f, 
    -0.01603506f, -0.04006599f, -0.02718935f, -0.03616957f, -0.00981604f, -0.00666950f, -0.03548966f, -0.01588528f, 
    -0.00702863f, 0.00558932f, 0.01989469f, 0.04485611f, 0.02615898f, 0.02265084f, 0.02627973f, 0.01333582f, 
    -0.03098430f, -0.03653676f, -0.01889485f, -0.01159654f, 0.00847343f, -0.03786569f, 0.00140525f, 0.00949751f, 
    -0.03366634f, -0.01640236f, 0.01181533f, 0.01158841f, -0.02543317f, -0.00716616f, 0.03173620f, 0.01148244f, 
    0.01694530f, -0.00223558f, -0.01318419f, -0.03629736f, -0.01889866f, -0.02494746f, 0.01219797f, -0.01102093f, 
    -0.02255626f, -0.02255821f, 0.03856654f, 0.01117991f, -0.00653668f, -0.00301853f, -0.00559781f, -0.01524672f, 
    -0.03527373f, -0.00572542f, 0.02223493f, 0.02036871f, 0.04186505f, 0.00488084f, -0.00655674f, 0.00767907f, 
    -0.03812011f, -0.01054302f, -0.01124158f, -0.02298658f, -0.00903518f, 0.02772005f, 0.02047243f, 0.02104359f, 
    0.02694738f, 0.03273474f, -0.00899229f, 0.01248944f, -0.00857815f, 0.03074553f, 0.00280797f, -0.02518554f, 
    -0.01941448f, -0.00777165f, 0.01677635f, 0.02427197f, 0.01999474f, 0.02778177f, -0.02907487f, -0.03541928f, 
    -0.03271752f, -0.04196816f, 0.01383325f, 0.00969497f, 0.01795694f, -0.02876669f, -0.03466563f, 0.03258359f, 
    0.02226862f, -0.03108290f, 0.03394583f, -0.00750519f, 0.00172016f, 0.03229285f, -0.01367700f, 0.00325127f, 
    0.02071354f, 0.01498543f, -0.02780637f, -0.02231002f, 0.04229918f, -0.04251929f, 0.00580026f, -0.03090994f, 
    0.00121275f, -0.02862771f, -0.04333234f, 0.00626574f, 0.02484743f, -0.00193899f, -0.01517676f, 0.01358303f, 
    0.01522429f, 0.02210568f, -0.01566807f, 0.01174407f, -0.03227201f, -0.03606251f, 0.00057694f, -0.03187757f, 
    -0.03045993f, 0.00453009f, -0.00986743f, 0.00132287f, 0.01830176f, -0.03127151f, -0.00146105f, -0.01182389f, 
    -0.02928144f, -0.03351298f, -0.03195900f, -0.01642765f, -0.01938163f, 0.03319779f, -0.02811444f, -0.03753147f, 
    -0.02854287f, 0.02317227f, -0.01389323f, -0.01694817f, 0.02179907f, -0.00268269f, 0.01623048f, 0.00890173f, 
    -0.01039534f, -0.04248750f, 0.00811975f, -0.03905697f, -0.03338444f, 0.03724683f, -0.00370706f, -0.03344353f, 
    -0.01204662f, 0.02541758f, -0.03706278f, -0.01104103f, 0.00528361f, 0.03161007f, -0.00718201f, 0.02325840f, 
    -0.04458512f, -0.00881904f, -0.04204415f, -0.01893091f, -0.02628733f, 0.02372185f, -0.00975117f, 0.03093028f, 
    0.02369286f, -0.02245523f, 0.01378906f, 0.01915837f, -0.02707755f, -0.00076244f, -0.00644971f, 0.00748606f, 
    -0.01635520f, -0.01825473f, 0.01306870f, -0.00356070f, 0.03703947f, 0.02968538f, 0.00640826f, -0.04416729f, 
    0.00739160f, 0.01845388f, 0.03197249f, 0.02451010f, -0.00862766f, -0.03190683f, 0.00022758f, -0.01944826f, 
    0.00294221f, -0.00998450f, 0.01628930f, 0.01498140f, -0.04457300f, -0.00995498f, 0.02589695f, 0.02101957f, 
    -0.00012616f, -0.03700203f, -0.00181101f, -0.03998692f, -0.00440560f, -0.03008212f, -0.04194265f, -0.02294849f, 
    -0.03852052f, -0.00472710f, -0.01575610f, -0.01260673f, 0.01263668f, 0.02400986f, 0.00217640f, 0.00038334f, 
    -0.01060650f, 0.02677649f, -0.04550960f, -0.04099167f, 0.00156678f, -0.02040526f, -0.01677381f, -0.02322101f, 
    -0.01691786f, -0.00046547f, 0.03202858f, 0.00143800f, 0.02032340f, -0.00188457f, -0.01702362f, 0.01325582f, 
    -0.00021051f, 0.02202237f, 0.03181389f, 0.03253179f, 0.01125356f, 0.02500093f, -0.03081121f, -0.03601677f, 
    0.01614678f, 0.03109167f, -0.03412894f, -0.04513354f, -0.00143181f, 0.01794697f, 0.02194218f, 0.01879603f, 
    -0.01072854f, -0.03133655f, -0.04334103f, 0.01519669f, 0.02999881f, -0.02207268f, -0.01412734f, 0.03114353f, 
    -0.02069227f, -0.04313166f, -0.03110100f, -0.02993532f, -0.02045022f, -0.01663237f, -0.01579506f, -0.00600604f, 
    0.02997920f, 0.04355293f, -0.03172052f, 0.01930360f, 0.02202563f, -0.02886974f, 0.00038527f, -0.04392711f, 
    0.01031843f, -0.02950498f, -0.01706076f, 0.02715355f, -0.01453887f, -0.00134988f, 0.02149784f, -0.02975824f, 
    0.03316464f, 0.02484372f, 0.02560739f, -0.04075324f, 0.00293361f, -0.02228197f, 0.02703024f, -0.04250715f, 
    -0.00074703f, 0.03292529f, 0.00531093f, 0.00059083f, 0.02672614f, 0.01937679f, -0.03023525f, 0.00499059f, 
    -0.00671611f, 0.02870392f, -0.01008725f, -0.02121808f, 0.00865567f, 0.01638022f, 0.00541049f, -0.02068526f, 
    -0.04526591f, 0.02917107f, -0.00280867f, -0.04429716f, 0.00082879f, -0.02056255f, -0.00901324f, 0.01287599f, 
    -0.04272090f, -0.02516755f, -0.03603129f, 0.00730652f, -0.00621160f, -0.03491851f, -0.03755801f, -0.01943546f, 
    0.00062739f, -0.04350604f, -0.01042907f, 0.01032634f, -0.01288861f, -0.04043919f, -0.03267483f, -0.00968043f, 
    0.03001027f, 0.03023270f, -0.03117783f, -0.02448624f, 0.01517752f, -0.00454272f, -0.01824587f, -0.03975841f, 
    -0.01375935f, 0.02962929f, 0.01431562f, -0.00523549f, 0.02787752f, 0.02143132f, -0.00503833f, -0.02854729f, 
    0.00164137f, 0.01135127f, 0.02026566f, -0.04391110f, -0.02679765f, -0.04325959f, -0.03164240f, -0.04121423f, 
    0.01468641f, -0.04521339f, 0.01133675f, 0.01196618f, -0.03632587f, 0.01255390f, -0.04023027f, -0.03538379f, 
    -0.02461114f, -0.01024908f, 0.01126265f, 0.00658860f, 0.03196570f, -0.00641354f, 0.00037866f, 0.02913787f, 
    0.02928741f, -0.01178164f, -0.02634545f, -0.01450986f, -0.04288758f, 0.00916099f, -0.02669559f, 0.01726999f, 
    -0.04041674f, 0.02100507f, -0.02516697f, 0.02387917f, -0.00871622f, 0.03307343f, 0.00825084f, -0.03796480f, 
    -0.04295077f, -0.00150273f, -0.02261737f, -0.01823094f, -0.04352984f, -0.00129606f, -0.00033236f, 0.03186585f, 
    -0.00708293f, -0.02539097f, 0.02269856f, 0.01091955f, 0.01137221f, 0.01827979f, -0.03414001f, 0.02110554f, 
    0.02172222f, -0.03492207f, -0.03690542f, -0.03751944f, 0.00250490f, -0.00643082f, -0.00488842f, 0.03027070f, 
    0.02379342f, -0.01587547f, 0.00628753f, -0.00974848f, 0.01522888f, -0.04070711f, 0.02839544f, 0.02918113f, 
    -0.02081417f, 0.01476192f, -0.02285152f, -0.01986104f, -0.02443329f, -0.00208385f, -0.02955493f, 0.00296663f, 
    -0.02128022f, -0.01616795f, 0.01543065f, 0.00159636f, 0.01060237f, 0.01474012f, 0.01638598f, 0.00443942f, 
    -0.04332139f, 0.00498650f, -0.00044478f, 0.00902460f, -0.03222348f, -0.01511541f, 0.02675393f, -0.02110034f, 
    0.00068114f, -0.01056176f, 0.00214106f, -0.00902076f, -0.01845830f, -0.00222056f, -0.00272345f, -0.02532398f, 
    -0.01704329f, 0.03170313f, -0.04225869f, 0.00290223f, -0.04339783f, 0.00136203f, -0.00269924f, 0.01218103f, 
    -0.01440316f, 0.01672942f, -0.04328484f, -0.02193881f, -0.00500265f, 0.00395586f, -0.00999587f, -0.01640767f, 
    -0.02643638f, -0.02100923f, 0.00877843f, -0.02973831f, -0.00043756f, -0.03645901f, 0.02451988f, -0.02877093f, 
    -0.00699809f, -0.03835971f, -0.01645987f, 0.01280860f, 0.02872222f, -0.03383069f, -0.01144738f, -0.02301087f, 
    0.02591267f, 0.00522049f, 0.01481216f, -0.01919767f, 0.04690087f, 0.01573007f, -0.00791908f, -0.02824148f, 
    -0.01363594f, 0.02016133f, -0.00754899f, 0.02467618f, 0.00019240f, 0.02109316f, 0.01438399f, -0.04757257f, 
    0.01364036f, -0.02197075f, -0.00205707f, 0.00641716f, 0.01434692f, 0.02681825f, 0.01327094f, -0.01185271f, 
    -0.00233971f, 0.00106908f, -0.01517251f, 0.01578251f, -0.00482657f, -0.02388996f, -0.03608793f, -0.01283067f, 
    0.01461271f, -0.03567236f, -0.02504590f, -0.04047176f, -0.03504945f, 0.02281054f, -0.01861624f, 0.03842250f, 
    -0.04656386f, 0.02836209f, -0.02779850f, 0.02813482f, -0.03794138f, 0.00095035f, 0.03795062f, -0.02804926f, 
    0.03244406f, -0.03486638f, 0.02433763f, -0.04001105f, 0.02583055f, 0.01395948f, 0.00408198f, -0.01109117f, 
    -0.02199083f, 0.00805919f, -0.01654908f, -0.02989319f, -0.01347761f, -0.03178716f, 0.02268962f, -0.00956365f, 
    -0.00263826f, -0.01709304f, 0.00576205f, 0.01188239f, -0.00408885f, 0.00807041f, -0.03454046f, 0.02204351f, 
    -0.01894427f, -0.01830759f, 0.02265934f, -0.00049162f, 0.00782340f, 0.02713768f, -0.01209730f, -0.01253859f, 
    -0.02832020f, 0.02088206f, 0.00973889f, 0.00227478f, -0.03300263f, 0.01331416f, -0.03333632f, -0.02331089f, 
    0.02235826f, 0.02058938f, -0.00991795f, 0.02561139f, -0.04005460f, 0.00275141f, 0.01782619f, 0.03082066f, 
    0.02275526f, -0.00669471f, -0.01017684f, 0.01361966f, 0.02899719f, -0.02023161f, 0.03020120f, -0.01393506f, 
    0.00749354f, -0.03135991f, -0.00388680f, 0.00115511f, 0.02198331f, 0.00364390f, -0.01236436f, -0.01545892f, 
    -0.00319039f, 0.00421228f, -0.02473718f, 0.02406727f, -0.01799650f, 0.02326137f, 0.02336802f, -0.01717491f, 
    -0.02609412f, 0.01369744f, 0.00138506f, 0.00863894f, 0.02558563f, -0.02890522f, 0.02299463f, -0.01874518f, 
    -0.02815741f, -0.03161057f, 0.02765402f, -0.00592381f, -0.00863297f, 0.02014861f, -0.04124165f, 0.01891971f, 
    -0.00135289f, 0.01957395f, -0.01716296f, 0.02919860f, -0.00641500f, 0.02967617f, 0.01519274f, -0.02499875f, 
    -0.00525204f, 0.01377073f, 0.01910554f, 0.00488488f, 0.02454055f, 0.03737849f, -0.01244355f, -0.01529023f, 
    -0.01769152f, 0.01209760f, -0.01989117f, -0.02678037f, 0.03998486f, -0.02359605f, 0.00710292f, -0.02439256f, 
    0.04316850f, -0.00002529f, -0.00526407f, -0.04135375f, -0.00466560f, 0.02739815f, -0.01921398f, 0.01532573f, 
    0.02364062f, 0.00076591f, -0.01121926f, -0.02962244f, -0.02067776f, -0.02535314f, 0.01556488f, 0.02340779f, 
    -0.03675795f, -0.03357142f, -0.00305737f, -0.02850226f, 0.01041597f, -0.03530600f, 0.02949258f, 0.01377140f, 
    0.02147532f, -0.02385662f, -0.00602910f, -0.04383516f, 0.02224705f, -0.03243278f, 0.02525760f, -0.02649818f, 
    -0.02239605f, -0.01901516f, -0.03930395f, -0.02903384f, -0.01958425f, 0.01975292f, 0.00729882f, -0.00022162f, 
    0.02025696f, 0.00163392f, 0.02123512f, 0.02765696f, 0.02553632f, 0.02852137f, -0.01459002f, -0.00356215f, 
    -0.04065404f, 0.01534226f, -0.01636900f, 0.02047516f, 0.01020321f, 0.00133786f, -0.01649269f, 0.01242064f, 
    -0.02078802f, -0.00619025f, -0.00002096f, -0.01140495f, -0.03404864f, -0.02424687f, -0.02911283f, 0.01316206f, 
    -0.03742705f, -0.03107356f, 0.01186135f, 0.02635756f, -0.02188019f, -0.01785025f, -0.03686570f, 0.02698109f, 
    0.00810531f, 0.01170169f, -0.02778939f, 0.02978128f, -0.01363407f, -0.03545321f, -0.01472891f, -0.00060982f, 
    0.01606367f, -0.03657377f, -0.01590477f, 0.01027644f, -0.03774576f, -0.00403504f, 0.01879068f, 0.00866035f, 
    -0.03194250f, 0.00173584f, -0.02134793f, -0.02723804f, 0.00559681f, -0.00028778f, -0.00689595f, 0.01657644f, 
    0.00075517f, -0.03332062f, 0.01255326f, 0.01497263f, 0.00290698f, 0.04277025f, -0.00984097f, -0.01392200f, 
    -0.02461425f, -0.02814465f, -0.04245028f, -0.03558522f, -0.01375753f, 0.02416574f, 0.02539190f, 0.02476307f, 
    -0.03162258f, -0.00584885f, 0.00101205f, 0.02772150f, -0.04019611f, -0.00472880f, 0.00109449f, -0.00541866f, 
    0.02568003f, -0.03534903f, 0.01479382f, -0.02838541f, 0.04469468f, -0.02764112f, 0.02335076f, 0.00054779f, 
    -0.03128808f, 0.00694060f, 0.02673867f, -0.01467949f, -0.01305812f, 0.00674348f, -0.03341919f, -0.03590800f, 
    -0.01901488f, 0.01715083f, -0.00359242f, 0.01958479f, 0.00338370f, 0.03637187f, 0.01860813f, 0.03142294f, 
    0.00544801f, -0.00326696f, -0.03913425f, 0.02335769f, 0.02362156f, 0.01841993f, 0.00588876f, -0.02892529f, 
    0.00364238f, 0.02723704f, -0.00242048f, 0.00161058f, -0.00018141f, 0.02958812f, -0.00687801f, -0.01276106f, 
    -0.00472688f, 0.01923500f, -0.03377149f, -0.03123348f, -0.00955412f, 0.00572887f, -0.00683624f, 0.02023895f, 
    -0.04581699f, 0.02199972f, -0.01488307f, 0.01908962f, 0.01086453f, -0.00405572f, -0.04213741f, -0.00326350f, 
    -0.02098627f, -0.03084295f, 0.00473242f, -0.02121013f, 0.02417830f, 0.02659850f, -0.00290998f, 0.03397718f, 
    -0.02532035f, 0.00855289f, -0.03507884f, -0.04202233f, -0.00342443f, 0.04222584f, 0.02415755f, -0.02375316f, 
    -0.02612665f, -0.04165772f, 0.03364307f, 0.02730752f, 0.02972706f, 0.02355943f, 0.03002646f, -0.04268857f, 
    0.00054339f, -0.00243907f, -0.01924238f, -0.04464669f, -0.03234386f, 0.00696200f, -0.00577785f, -0.04534915f, 
    0.01077208f, 0.01678897f, 0.01363132f, -0.03273416f, -0.03889764f, -0.02282419f, -0.00899117f, 0.01419380f, 
    -0.03049950f, -0.01980769f, 0.02264117f, -0.00263144f, -0.01453114f, 0.02849792f, -0.03789501f, -0.02412896f, 
    0.01202174f, -0.00294685f, 0.00416390f, 0.00268891f, 0.03080986f, 0.02904893f, -0.02850710f, -0.00307369f, 
    -0.00670817f, 0.00263254f, 0.00650368f, 0.03189368f, 0.01758599f, -0.02323755f, 0.02663557f, 0.02002152f, 
    -0.01467366f, -0.00234675f, -0.03509976f, 0.03571621f, 0.01670497f, -0.00113234f, 0.01829985f, 0.00382137f, 
    -0.01071861f, 0.01853517f, 0.00296949f, -0.00907194f, 0.02063011f, -0.04036819f, -0.02000070f, 0.01010019f, 
    -0.00113382f, 0.02083195f, 0.00584311f, 0.01704706f, -0.00417419f, 0.00545265f, -0.04363704f, 0.01642121f, 
    -0.00586533f, -0.00997144f, -0.01419807f, -0.00129518f, -0.00103057f, -0.02123773f, -0.02930879f, 0.00898191f, 
    -0.01699692f, 0.01589297f, -0.01726179f, -0.04082175f, 0.00654474f, 0.00399226f, -0.01295693f, 0.02683604f, 
    -0.04045886f, -0.03341194f, 0.01580015f, 0.00030734f, -0.04570806f, 0.02212242f, -0.01971679f, -0.01296463f, 
    -0.02144530f, 0.00199507f, -0.01647382f, -0.03611074f, -0.04199396f, -0.00194728f, 0.01770824f, 0.00174834f, 
    -0.01945260f, -0.00857508f, -0.03251145f, -0.01624602f, -0.02135504f, 0.02668412f, -0.01254241f, -0.02698092f, 
    -0.03099613f, -0.00267341f, -0.03377114f, -0.01671697f, -0.01586257f, -0.03696620f, -0.03553872f, -0.04639362f, 
    0.03256473f, -0.04570829f, -0.01020971f, 0.01194355f, 0.00881421f, -0.02254764f, -0.00212114f, 0.00991587f, 
    0.00104506f, -0.00206740f, -0.01093055f, -0.02749521f, -0.00071451f, 0.02130281f, 0.03351980f, -0.01906730f, 
    0.02799949f, -0.00278821f, 0.01302169f, -0.03453342f, 0.02613151f, -0.01470023f, 0.00000443f, -0.04320995f, 
    -0.04352616f, -0.00768787f, -0.02431826f, -0.03677565f, 0.04060028f, 0.01549787f, -0.03714975f, -0.00642163f, 
    -0.02631811f, -0.00241790f, -0.04119658f, 0.00979928f, -0.03537231f, -0.02388748f, 0.01462182f, 0.03177729f, 
    -0.01557272f, 0.00501186f, -0.00444711f, -0.02815591f, 0.00243726f, 0.02276312f, -0.03920873f, 0.02473633f, 
    0.07345583f, -0.30533648f, 0.10542266f, -0.06335162f, 0.01685838f, 0.03018044f, -0.06909627f, 0.05852282f, 
    -0.08694419f, -0.00304241f, 0.09060123f, 0.00254462f, 0.01450581f, -0.09882643f, -0.05016831f, 0.10166549f, 
    0.02316107f, 0.10885747f, 0.05593928f, 0.09795742f, 0.14311884f, 0.20358163f, 0.00266517f, -0.03675022f, 
    0.06308996f, -0.08124119f, 0.06673158f, 0.03874095f, 0.08062766f, -0.14175387f, 0.01435457f, -0.09652817f, 
    0.05243374f, 0.11046086f, -0.03373062f, 0.06221357f, 0.12083451f, 0.17594023f, 0.15397395f, 0.06383074f, 
    -0.09311029f, 0.08744115f, -0.02039725f, 0.03138510f, 0.05449888f, -0.00436270f, 0.09144618f, 0.05844792f, 
    -0.07670593f, 0.05929970f, 0.07834646f, 0.10759672f, 0.11637970f, -0.09214754f, -0.08712122f, -0.15799515f, 
    0.05156028f, 0.07768746f, 0.28566864f, 0.05390520f, -0.18256810f, -0.29206812f, 0.09052135f, -0.01780771f, 
    0.11164136f, 0.03450665f, -0.03200217f, 0.05250632f, -0.09458586f, 0.01740291f, 0.08619526f, -0.02822247f, 
    -0.06396857f, -0.06488797f, -0.10698773f, -0.00665362f, -0.21516745f, -0.00881993f, 0.19451039f, 0.03698018f, 
    0.04373923f, -0.01633908f, 0.07201866f, 0.06018136f, -0.05896461f, 0.03855697f, -0.05860455f, 0.07535788f, 
    -0.04134333f, -0.06361947f, 0.01815136f, -0.04777288f, 0.14447336f, -0.07152461f, 0.00014376f, 0.08821470f, 
    -0.04106734f, -0.02324287f, 0.19642481f, 0.03071237f, 0.02201969f, -0.22534509f, 0.26619783f, -0.02693617f, 
    0.08717611f, 0.14515503f, -0.01597579f, 0.11550982f, -0.02069677f, -0.09700832f, 0.11006542f, 0.00765376f, 
    -0.02010689f, 0.04502713f, 0.11917108f, 0.03376376f, 0.03649103f, -0.03042117f, 0.08406576f, 0.05529243f, 
    -0.04448181f, 0.11064527f, -0.07791741f, -0.00678520f, -0.16102479f, -0.01040266f, 0.03278872f, -0.08866680f, 
    0.04262968f, 0.05189215f, 0.02310487f, 0.02928430f, 0.05525314f, -0.13969992f, -0.00537243f, -0.12436457f, 
    0.00766231f, -0.03455249f, -0.03685108f, -0.03623957f, 0.04800269f, 0.05042312f, -0.04879948f, -0.04017127f, 
    -0.14992990f, -0.06609108f, 0.16915405f, 0.01459945f, 0.03845945f, 0.04890647f, 0.05120341f, 0.08598032f, 
    -0.02259854f, -0.20340241f, -0.05083672f, -0.10956976f, 0.13301024f, -0.02634485f, 0.07119296f, 0.02117004f, 
    0.23089100f, 0.39064449f, 0.11310835f, 0.03653973f, 0.07502479f, -0.03917704f, 0.13929556f, -0.01069848f, 
    -0.01176666f, -0.05519227f, 0.11244085f, 0.03799401f, 0.03703206f, 0.09663185f, -0.01733733f, -0.01263407f, 
    0.08910843f, 0.09116624f, 0.04826103f, -0.07512038f, 0.16684729f, 0.07179537f, -0.25788921f, -0.07137737f, 
    0.15162507f, -0.03755426f, 0.01297402f, 0.08010259f, -0.02804671f, -0.06063504f, -0.00723519f, -0.00422422f, 
    -0.03760556f, -0.04401642f, -0.08428266f, -0.08448756f, -0.01899361f, 0.07618406f, 0.06088438f, -0.02963699f, 
    0.29187554f, -0.14832248f, -0.14082731f, 0.05082749f, 0.17229158f, 0.06982761f, -0.13046655f, -0.02319921f, 
    0.01309039f, 0.10218502f, -0.03683052f, 0.04928993f, 0.09954878f, 0.34455261f, 0.03892633f, -0.07827246f, 
    0.03297986f, 0.02839798f, -0.01983144f, -0.03558338f, 0.15381137f, 0.42462119f, -0.09964003f, -0.12954095f, 
    0.00489054f, -0.02294011f, 0.06734210f, -0.05315574f, 0.18705574f, -0.00322521f, 0.08039025f, -0.03861256f, 
    0.02713729f, -0.01986346f, -0.08256119f, 0.00047091f, 0.21226764f, 0.08645987f, 0.04360693f, 0.13088074f, 
    0.04164140f, 0.04480962f, 0.00381408f, -0.03366852f, -0.02506362f, 0.06880707f, 0.08447079f, 0.00940217f, 
    0.02368055f, 0.02897922f, 0.10640863f, 0.00422911f, -0.01359773f, 0.00921416f, -0.05102456f, -0.03072268f, 
    -0.04291873f, -0.09634297f, 0.02181728f, -0.10554226f, 0.38874987f, -0.09218337f, -0.01208060f, 0.15316041f, 
    0.04248794f, 0.07376984f, -0.06533070f, 0.11310681f, -0.00204066f, 0.10653006f, 0.00439181f, 0.05543974f, 
    -0.09273947f, 0.06074131f, -0.02327450f, -0.00395769f, 0.09419373f, -0.09321930f, -0.12280773f, 0.06101166f, 
    0.10413099f, 0.22790393f, 0.18149479f, 0.02153082f, 0.21805520f, -0.04922754f, 0.06759043f, 0.05892769f, 
    0.04650754f, -0.05307854f, 0.06648482f, 0.04989814f, -0.01680785f, -0.00567587f, 0.03073330f, 0.03134113f, 
    -0.12585714f, 0.18410137f, 0.14764579f, 0.03193875f, 0.16823587f, -0.04219249f, 0.04386142f, 0.05721297f, 
    0.27977309f, 0.01673337f, -0.03102374f, 0.08196908f, -0.09608576f, -0.01445955f, -0.02803083f, 0.02221783f, 
    0.02087582f, 0.12665284f, 0.02485686f, -0.01136799f, -0.01340198f, 0.00424562f, 0.06484494f, 0.08507314f, 
    -0.01917056f, -0.19379488f, 0.07178384f, 0.06476547f, -0.07879869f, 0.05362464f, -0.06403366f, 0.04175683f, 
    0.03888865f, -0.00327811f, 0.07662170f, 0.06807966f, -0.04679191f, -0.08710504f, -0.01960573f, 0.04168620f, 
    0.03880896f, 0.01870612f, 0.10686196f, -0.01639584f, 0.26705480f, 0.10657801f, -0.01025288f, 0.07652367f, 
    0.07923343f, 0.06435011f, 0.04118517f, 0.07780613f, 0.08673663f, -0.11954375f, -0.00769943f, 0.06495439f, 
    0.04886667f, 0.09915349f, 0.09544466f, 0.05346941f, -0.13281731f, -0.01892121f, 0.01513336f, -0.03992756f, 
    -0.12053399f, 0.18355715f, 0.28863758f, 0.20371024f, 0.13629012f, -0.02621281f, 0.13421065f, 0.00869237f, 
    -0.02544750f, 0.01702377f, -0.08093606f, 0.01791859f, 0.18240632f, 0.09600512f, 0.02171796f, -0.12162350f, 
    -0.08338221f, 0.08541773f, 0.04071601f, -0.02918974f, -0.02250889f, -0.18279424f, 0.16347857f, -0.01343940f, 
    0.06324258f, 0.06899937f, 0.00260415f, 0.12105872f, -0.13544452f, 0.01778138f, 0.00554026f, -0.06571022f, 
    0.00520469f, 0.11435771f, 0.11639563f, -0.02639455f, 0.03145251f, 0.03285844f, 0.08522433f, 0.02514077f, 
    0.30974513f, 0.00438533f, -0.08201443f, 0.19718146f, 0.06794187f, -0.00867344f, 0.03091079f, 0.05787419f, 
    -0.01702305f, 0.00230881f, 0.02127194f, 0.02922534f, 0.10012991f, 0.02999560f, -0.04386640f, 0.02175022f, 
    -0.04800369f, -0.06889700f, -0.02649376f, -0.08573878f, 0.49895689f, 0.02160846f, 0.24758938f, 0.11138752f, 
    -0.02286448f, 0.12443325f, -0.02457388f, 0.08175581f, -0.10518976f, 0.01403192f, 0.02925225f, -0.08878940f, 
    -0.04617425f, 0.04816705f, 0.02164449f, 0.06532390f, 0.06010719f, -0.12295296f, -0.01499097f, -0.06866604f, 
    -0.15103294f, -0.06870290f, 0.28672513f, 0.03509714f, 0.30118433f, 0.04919703f, -0.05642776f, 0.08509781f, 
    -0.02630498f, 0.18438585f, 0.02994006f, -0.12887315f, 0.10115758f, 0.15111786f, -0.00012440f, 0.08638608f, 
    0.00941841f, 0.03132712f, 0.11409614f, -0.06883039f, 0.22739154f, -0.23009631f, 0.21653302f, 0.08966864f, 
    0.08677080f, 0.02410328f, -0.00327491f, 0.13431512f, -0.02975032f, 0.04538639f, 0.00796007f, -0.04178346f, 
    -0.09237943f, -0.03255179f, -0.05303813f, -0.00613494f, 0.00256329f, -0.10383096f, 0.04955038f, -0.04864146f, 
    0.00878939f, -0.21933360f, 0.06631678f, 0.06917671f, 0.02382301f, 0.10922282f, -0.05822048f, 0.02812165f, 
    0.05396022f, -0.01579221f, 0.03558398f, 0.03386515f, -0.06628598f, -0.09356802f, -0.05202664f, 0.04227305f, 
    0.00032557f, -0.03481483f, 0.11985131f, -0.04555000f, 0.06646676f, 0.04026518f, -0.07854021f, 0.14272957f, 
    -0.11212546f, -0.11624572f, 0.05762753f, -0.11681055f, 0.04549163f, 0.00331236f, 0.12223602f, -0.00411630f, 
    0.09104141f, -0.05509612f, -0.02913452f, 0.07274033f, -0.04725701f, 0.08987384f, -0.00001714f, 0.06751464f, 
    -0.09761922f, -0.11886553f, 0.28504956f, 0.18969253f, 0.35070458f, 0.04686302f, -0.03527838f, -0.02881993f, 
    -0.05929652f, 0.13270399f, -0.01374479f, -0.07319692f, 0.12194240f, 0.10017293f, 0.14665429f, 0.05398757f, 
    0.03619118f, 0.08639650f, 0.10910855f, -0.05740536f, -0.04959692f, 0.22161494f, -0.20386526f, 0.06003417f, 
    -0.09715987f, 0.00010803f, 0.02423460f, -0.18353277f, -0.02882976f, 0.08194289f, -0.09655294f, 0.07079960f, 
    0.04293729f, 0.08611743f, -0.02305019f, 0.01246835f, 0.01557131f, 0.03366680f, -0.06395798f, -0.01177981f, 
    0.09754154f, 0.23115003f, -0.11884139f, 0.16595806f, -0.13899355f, 0.03442884f, 0.05627077f, 0.09014909f, 
    0.07276726f, 0.02390445f, -0.01980738f, 0.02665047f, 0.05287074f, 0.04297445f, 0.07038903f, 0.04111892f, 
    0.00155661f, 0.02822825f, -0.04185537f, 0.00641792f, -0.09543196f, -0.07921678f, -0.06000202f, -0.09558381f, 
    0.12613420f, 0.01587235f, 0.17920494f, 0.01193682f, 0.05262972f, 0.01174972f, 0.08759771f, 0.01090882f, 
    0.01177128f, 0.01075074f, -0.08173709f, 0.11857545f, 0.07218615f, 0.07118826f, 0.16975288f, 0.18762289f, 
    -0.01123662f, -0.08243241f, 0.02254258f, 0.07677983f, -0.18207452f, 0.06912280f, -0.01019172f, 0.08134610f, 
    0.07978880f, -0.00641565f, 0.05163699f, 0.03362344f, -0.00224491f, -0.03397187f, -0.04053761f, 0.07266726f, 
    0.00971136f, -0.12607050f, 0.01311624f, -0.04828792f, 0.06928515f, 0.34333366f, -0.19388956f, 0.14156495f, 
    -0.08250789f, -0.15568614f, 0.11106139f, 0.06570315f, 0.05192500f, -0.12425149f, -0.08352099f, 0.04199634f, 
    -0.04192429f, -0.01738465f, 0.11312307f, -0.03803595f, -0.03302998f, 0.07186227f, -0.13101190f, -0.01641969f, 
    0.03315584f, 0.01270749f, -0.00352011f, -0.01763754f, -0.01397508f, -0.01864292f, 0.01078566f, 0.02661952f, 
    -0.03315110f, 0.00018604f, -0.02733827f, 0.00275720f, 0.00472985f, -0.02136463f, -0.00069767f, 0.02241447f, 
    -0.02737669f, 0.01798945f, 0.00424153f, -0.01681194f, 0.02533972f, 0.01399416f, 0.01332306f, -0.03900247f, 
    -0.00554394f, 0.00073940f, 0.01657253f, 0.01787792f, 0.01561236f, -0.02896583f, 0.02844482f, 0.03233370f, 
    0.02686810f, -0.02189372f, 0.01687090f, 0.00396924f, 0.01800681f, -0.02168928f, -0.01091758f, -0.00230189f, 
    0.02109165f, -0.02520838f, -0.03648779f, 0.00407617f, -0.03778947f, -0.00809817f, -0.02005691f, -0.01171471f, 
    0.00624523f, -0.02516068f, -0.04116509f, 0.00718587f, 0.00128860f, -0.01326518f, -0.00039114f, 0.02946154f, 
    0.03080193f, 0.02122444f, 0.01043722f, -0.02288814f, -0.03397609f, 0.00670446f, 0.01434146f, 0.02735633f, 
    0.01597921f, 0.01572337f, -0.04913069f, -0.02681516f, 0.00105253f, -0.01887180f, -0.03043098f, -0.02073700f, 
    -0.03381904f, -0.02233006f, 0.03025600f, 0.00854471f, -0.03187181f, 0.01504311f, 0.01556756f, -0.03800904f, 
    0.02096999f, 0.02925467f, -0.03541099f, -0.03406320f, -0.03275809f, -0.01115293f, 0.00112104f, 0.02255462f, 
    -0.02057268f, -0.03196252f, -0.00003749f, 0.02184908f, -0.04461330f, 0.02095621f, -0.03671224f, -0.03928671f, 
    -0.04089625f, -0.04381695f, 0.01500277f, -0.01676778f, -0.00303576f, -0.00143172f, -0.02881425f, -0.02139770f, 
    0.01876066f, 0.02625050f, 0.01046273f, 0.01291800f, 0.01868628f, -0.00171678f, 0.01464691f, -0.01272477f, 
    -0.00561365f, -0.01942579f, 0.01006035f, -0.02863784f, -0.01059388f, -0.03513171f, 0.01418920f, -0.01880311f, 
    0.03370403f, 0.00534074f, 0.01671608f, -0.00215677f, 0.02700183f, 0.03493537f, 0.00437358f, -0.03055204f, 
    0.01413019f, -0.01444351f, 0.00216383f, -0.00772665f, -0.04450783f, -0.04289050f, 0.00255687f, 0.03310158f, 
    -0.00050709f, -0.03740415f, -0.02971463f, 0.01455322f, 0.00945966f, 0.01152435f, 0.00112485f, -0.00757683f, 
    -0.01792160f, -0.00932328f, 0.01688875f, -0.04168690f, -0.01179219f, 0.00665754f, 0.00477844f, -0.00338827f, 
    -0.00386071f, -0.02760636f, 0.02039289f, -0.02353717f, -0.01499475f, -0.03531625f, -0.02576747f, -0.03469892f, 
    -0.04245313f, 0.03305931f, -0.02733193f, -0.04436141f, 0.01163002f, 0.01930000f, 0.01527057f, -0.04082818f, 
    0.01322129f, 0.01405294f, -0.00599448f, -0.00015491f, 0.01775461f, 0.00697642f, -0.01389459f, 0.01375520f, 
    -0.02993991f, 0.00104062f, -0.01802109f, 0.00869861f, 0.01523540f, -0.01906641f, -0.00387981f, 0.02848274f, 
    -0.01841827f, -0.02451991f, -0.02553332f, 0.02357396f, -0.01090828f, 0.01566641f, 0.03412606f, -0.02104128f, 
    -0.00413747f, 0.02583600f, 0.01024147f, -0.03022416f, -0.04482786f, 0.00124843f, -0.02170989f, -0.04044383f, 
    0.00737767f, 0.00953045f, 0.01012777f, -0.01448209f, -0.03014361f, 0.01474164f, -0.03780688f, -0.01874325f, 
    0.02421917f, 0.00782605f, 0.02298245f, -0.02146248f, 0.00873119f, 0.01417615f, -0.01335549f, 0.01651078f, 
    -0.02213268f, -0.01459594f, -0.04049408f, -0.00433143f, -0.02638622f, -0.02884430f, 0.01192597f, 0.01010197f, 
    0.00781147f, 0.03504246f, 0.02482305f, -0.01000853f, -0.01187900f, -0.02446133f, -0.03706097f, 0.00132994f, 
    0.02268063f, 0.00013874f, 0.02734518f, 0.02315941f, -0.01838492f, -0.02993020f, -0.02942947f, -0.01128140f, 
    0.00418026f, -0.02672892f, -0.02289227f, -0.02066919f, -0.00490850f, -0.00619567f, -0.02826148f, 0.02579493f, 
    -0.02389012f, 0.02239041f, -0.02968912f, -0.01616103f, -0.01449675f, -0.01930979f, 0.02392713f, -0.01534782f, 
    0.00018186f, -0.01488843f, 0.00113266f, -0.01023488f, -0.03105338f, 0.03244905f, -0.02116596f, -0.02680541f, 
    0.01291725f, 0.01169852f, 0.01790633f, 0.02541988f, -0.01466908f, 0.01866952f, 0.00023469f, -0.03816440f, 
    0.01319323f, -0.01694431f, -0.02754153f, 0.03700962f, -0.04504388f, 0.03079534f, 0.02983635f, 0.01058058f, 
    -0.03726670f, 0.01111836f, 0.01377453f, -0.01859645f, -0.00678530f, 0.00286617f, 0.01850210f, -0.02547606f, 
    -0.04513320f, 0.01758935f, -0.02794771f, 0.02999996f, 0.00884744f, 0.01358403f, 0.02853956f, 0.00847134f, 
    -0.00134829f, 0.01696787f, -0.00475020f, 0.00429733f, -0.01868469f, 0.00050847f, 0.00213475f, -0.01469293f, 
    0.03518828f, -0.00288870f, -0.01915323f, -0.00839009f, -0.01255766f, 0.00998468f, -0.02245276f, -0.02541115f, 
    -0.03725793f, -0.02054365f, 0.00612651f, -0.04206216f, 0.02652596f, 0.00243434f, 0.02663858f, 0.00502221f, 
    -0.03636512f, -0.03065963f, -0.03297013f, 0.02195553f, 0.01336639f, -0.00325729f, -0.02861905f, -0.03102680f, 
    -0.00235320f, 0.02417733f, 0.00601633f, -0.02964237f, 0.01630739f, -0.04093346f, 0.02011794f, -0.04369874f, 
    -0.03255756f, -0.03812972f, -0.00371555f, -0.01718220f, -0.00032673f, -0.03425716f, 0.02693399f, -0.00192674f, 
    -0.04917917f, -0.01761390f, -0.00622419f, -0.02778100f, 0.01113258f, -0.03850325f, -0.02338424f, -0.01820480f, 
    0.01088539f, 0.00776854f, -0.00992655f, -0.00533662f, -0.04267314f, -0.01026251f, -0.04007410f, -0.04257058f, 
    -0.01734961f, 0.03133775f, -0.00249121f, -0.03578442f, -0.03301648f, 0.03091021f, -0.01583789f, -0.00804319f, 
    0.01331225f, -0.00034349f, 0.01074491f, 0.02382941f, 0.00758541f, 0.01514643f, -0.01383023f, 0.02401649f, 
    0.03076608f, -0.00853115f, -0.03298584f, 0.00132195f, -0.02787736f, 0.01709369f, -0.00407172f, -0.03138524f, 
    0.01540630f, -0.00231598f, 0.01251827f, -0.01452689f, -0.01444465f, 0.01517543f, -0.00180330f, -0.00849700f, 
    -0.00228670f, 0.02936588f, -0.02344414f, 0.00286538f, -0.04243434f, 0.02445311f, -0.02595439f, -0.03056658f, 
    0.03719126f, -0.00616989f, -0.00848525f, 0.02813674f, -0.00973214f, -0.00946933f, 0.02012986f, 0.02758228f, 
    -0.00949243f, -0.02128800f, 0.01880552f, -0.02069448f, 0.00126685f, 0.00187086f, -0.02658110f, 0.00017598f, 
    0.00323965f, -0.01574302f, -0.01681446f, 0.02261310f, -0.03372181f, -0.01670349f, 0.04172315f, -0.02728997f, 
    0.03022572f, 0.01422583f, -0.01569962f, 0.02442354f, -0.02079513f, 0.02958795f, -0.04386563f, 0.00976007f, 
    -0.01213518f, 0.02908667f, 0.00568416f, 0.02789803f, -0.03889244f, -0.04037703f, -0.03057462f, 0.01250902f, 
    0.02702314f, -0.04444418f, 0.03107704f, -0.03446258f, -0.00139324f, -0.03270709f, 0.00009167f, -0.00944214f, 
    -0.01974063f, 0.00181677f, -0.02922438f, -0.03586007f, 0.01926649f, 0.02169414f, 0.00287038f, 0.01551813f, 
    -0.00113948f, -0.04230892f, -0.02300030f, 0.01501857f, 0.01410251f, -0.00565102f, -0.01918436f, 0.03041155f, 
    -0.02250845f, -0.01036925f, -0.02651725f, -0.00256081f, -0.04102188f, -0.02995857f, 0.00837219f, 0.02428086f, 
    0.01215118f, 0.00388071f, 0.01641903f, -0.01501729f, -0.04610946f, 0.00945638f, 0.02495797f, 0.02699874f, 
    0.00054535f, -0.03683693f, 0.01352760f, 0.00900566f, -0.02216294f, 0.01351842f, -0.03316513f, -0.04000537f, 
    -0.03332348f, 0.00728831f, -0.02058822f, -0.01919361f, -0.04400267f, 0.01728138f, -0.03827725f, -0.03251094f, 
    0.02616789f, -0.04302140f, 0.03046165f, -0.03329589f, -0.02862097f, -0.01055246f, 0.00497097f, -0.01577635f, 
    0.00039152f, 0.02365812f, 0.01584574f, -0.01197539f, -0.00513498f, -0.01752400f, -0.02131567f, -0.03803356f, 
    0.01048274f, -0.03843814f, -0.01049788f, 0.01536358f, -0.03473170f, -0.00629618f, -0.03604961f, 0.02331946f, 
    -0.02929271f, -0.01324874f, -0.00749193f, 0.02552503f, -0.02678882f, -0.00054116f, 0.01395051f, 0.01372088f, 
    -0.00464214f, -0.02179076f, -0.01143785f, 0.02627399f, -0.03194261f, -0.00853310f, 0.02388293f, -0.04440086f, 
    -0.01106153f, -0.01952637f, -0.01472163f, -0.01371306f, 0.02146207f, 0.03216740f, -0.02194602f, -0.00300163f, 
    0.02746799f, -0.04046308f, 0.02319871f, -0.03598440f, -0.02848320f, -0.00545353f, -0.01692733f, 0.00793003f, 
    0.02010322f, -0.02790489f, 0.01116815f, 0.01019895f, -0.02363738f, 0.01298039f, -0.00264446f, -0.01858198f, 
    -0.01865937f, -0.03120327f, -0.01217947f, -0.03677309f, -0.02120303f, -0.00124054f, 0.01889544f, -0.04443527f, 
    0.02899473f, -0.02525805f, -0.00211074f, -0.00273426f, -0.01982990f, 0.02732585f, 0.00068870f, -0.03922610f, 
    0.01968754f, -0.00675890f, -0.00536382f, 0.00491134f, 0.02538463f, -0.04593693f, 0.00007311f, -0.01089209f, 
    -0.02176070f, 0.02553965f, -0.03857231f, 0.01488140f, -0.00673932f, 0.02565863f, 0.00871096f, 0.03200620f, 
    -0.02999933f, 0.00627382f, 0.00042739f, 0.03069886f, 0.02246456f, -0.02259813f, -0.02707762f, -0.01655872f, 
    0.02070041f, 0.01215443f, 0.01014316f, 0.00615648f, -0.02609315f, 0.03157622f, 0.00429906f, 0.01732919f, 
    -0.03482474f, -0.02691664f, 0.03347598f, 0.01124457f, -0.00567366f, -0.01047573f, -0.01389163f, 0.01059152f, 
    -0.01726471f, -0.01737842f, -0.00564536f, -0.01009590f, 0.01742274f, -0.00106946f, 0.01070151f, -0.02744438f, 
    -0.00008847f, 0.02757830f, -0.00636131f, 0.00062240f, 0.02002185f, -0.01092463f, 0.01059499f, 0.01553325f, 
    -0.01987869f, 0.01246785f, 0.00183268f, 0.02428872f, 0.00098962f, -0.01579226f, 0.04238174f, -0.04930954f, 
    -0.14431904f, 0.18513133f, -0.07726030f, -0.14883798f, 0.06858218f, 0.06682042f, 0.02014090f, -0.03811007f, 
    -0.05513654f, -0.05857541f, -0.00868563f, 0.12930700f, -0.00758108f, 0.02550957f, -0.06463433f, 0.03827519f, 
    -0.03591021f, -0.07279574f, -0.05191002f, -0.05259100f, 0.17325290f, -0.04983698f, 0.10119366f, 0.05403367f, 
    -0.06041351f, 0.12969701f, -0.01096231f, -0.00984125f, -0.02527929f, 0.06982431f, 0.06524043f, 0.10066258f, 
    -0.00509403f, -0.07206823f, 0.06047470f, 0.00810418f, -0.02897560f, -0.03608784f, 0.03974606f, 0.00062257f, 
    0.03592877f, -0.01730213f, -0.00359024f, 0.06677569f, -0.16380668f, 0.13339768f, -0.00390433f, 0.01439684f, 
    0.10814784f, -0.04192772f, -0.10181081f, -0.14313394f, -0.01432990f, 0.15053451f, -0.00117497f, 0.06883453f, 
    0.02665862f, 0.07272790f, -0.10506368f, -0.02447312f, -0.00311117f, 0.05042977f, 0.06499833f, 0.00568624f, 
    -0.21671070f, -0.00452297f, -0.00298187f, 0.05657124f, 0.15869944f, -0.00806896f, -0.01299588f, 0.13452406f, 
    0.05449007f, 0.02874247f, 0.05091663f, 0.02651087f, 0.08657271f, -0.10512115f, -0.07167177f, 0.02299672f, 
    0.00387470f, 0.26844382f, -0.09374970f, -0.13995430f, 0.07155810f, 0.17362256f, 0.03743600f, -0.03235094f, 
    0.06003093f, 0.04741811f, 0.00207147f, -0.00834813f, -0.02402193f, 0.06957334f, -0.02281201f, -0.01591809f, 
    0.05956579f, 0.05111159f, -0.04714737f, 0.02996982f, -0.09517458f, 0.15443349f, -0.18766943f, 0.03876500f, 
    -0.12078299f, 0.03187767f, 0.06530889f, 0.00259832f, -0.05052089f, 0.14663188f, 0.02555308f, 0.01673048f, 
    0.04966328f, -0.09076073f, -0.06799980f, 0.04655367f, -0.03269083f, 0.04085987f, -0.04377951f, 0.14839397f, 
    0.21720083f, 0.10683686f, 0.01537308f, 0.03361653f, 0.16914847f, 0.01393177f, -0.07548170f, -0.02642873f, 
    0.02963116f, 0.08603507f, 0.05179618f, 0.04499849f, 0.02401357f, -0.00126061f, 0.07103928f, 0.09258580f, 
    0.08559541f, 0.07331962f, 0.00526250f, -0.01154506f, 0.18388964f, 0.14803734f, 0.09573945f, 0.12423687f, 
    0.14502867f, -0.00090573f, -0.15955524f, -0.03332615f, 0.05536228f, 0.05205195f, -0.05921472f, -0.04031273f, 
    0.03961936f, 0.09930529f, -0.01810002f, 0.09686477f, 0.00476478f, 0.06472281f, 0.02576471f, -0.01436563f, 
    -0.01414753f, -0.26208508f, 0.10081667f, -0.00351751f, 0.00844625f, 0.11480238f, -0.01966556f, 0.22794862f, 
    -0.00835958f, 0.05210982f, -0.02343347f, 0.01983146f, 0.01476176f, -0.02951027f, 0.13881506f, 0.02119899f, 
    -0.03273205f, -0.02784422f, 0.02370404f, -0.09737609f, -0.13452275f, -0.03026866f, 0.35979488f, -0.02534982f, 
    -0.16768758f, 0.06718436f, 0.03977136f, -0.02537356f, -0.02462088f, -0.03824905f, 0.10060182f, 0.12304663f, 
    0.12578687f, 0.07617257f, 0.05381632f, 0.07294606f, 0.01431554f, 0.01285965f, 0.03178737f, 0.06493775f, 
    -0.05612333f, 0.06378835f, 0.05178863f, 0.11642574f, 0.06972697f, -0.04964315f, 0.11057308f, -0.04054645f, 
    -0.07573226f, -0.00747430f, 0.02934040f, 0.12746508f, 0.02232458f, -0.00677516f, 0.06057516f, 0.03740179f, 
    0.09578771f, -0.01249418f, 0.03503255f, 0.06048217f, -0.01303029f, -0.12531681f, 0.04708903f, 0.10986125f, 
    0.14849396f, -0.03140010f, -0.06287353f, 0.04486760f, -0.10964371f, 0.02908927f, 0.03838954f, 0.06972007f, 
    0.08716114f, 0.03118410f, 0.04758337f, 0.00524459f, -0.14809455f, -0.01210284f, -0.05882039f, 0.02691797f, 
    0.08273717f, 0.13276817f, -0.02213732f, 0.11964969f, 0.31342560f, -0.00003925f, -0.11367039f, 0.02915078f, 
    -0.02221052f, 0.04913468f, -0.03375566f, 0.06516124f, 0.01335939f, -0.01312447f, 0.05648655f, -0.02760266f, 
    0.07898056f, 0.02684790f, -0.00892696f, -0.00562367f, -0.09658016f, 0.22804011f, -0.04943471f, 0.02015006f, 
    0.22365108f, -0.02598134f, 0.09085750f, 0.03635632f, 0.00461607f, 0.07571622f, -0.03882144f, 0.02030775f, 
    0.18535820f, -0.07001507f, 0.08463550f, 0.02157461f, -0.06749778f, 0.08854807f, 0.09215434f, -0.00515501f, 
    -0.07361715f, -0.12695245f, 0.02651252f, 0.04102177f, -0.08539832f, 0.04880881f, -0.02952326f, 0.08710025f, 
    0.08035032f, 0.11600959f, -0.08945367f, -0.03563762f, 0.08678912f, -0.00615068f, 0.03550921f, -0.06616332f, 
    0.10212906f, -0.03417198f, 0.00590845f, -0.15844049f, -0.05021784f, -0.18536489f, -0.04709305f, -0.02332272f, 
    -0.15809725f, 0.10109345f, 0.02759865f, 0.03982784f, 0.02333312f, -0.00562794f, 0.12014540f, 0.01292735f, 
    0.06537836f, -0.04206440f, 0.01450997f, 0.01252120f, -0.04817326f, -0.00865239f, -0.02625589f, -0.01198972f, 
    0.20788915f, 0.25247118f, -0.02549529f, 0.15611462f, 0.14658578f, 0.02647357f, -0.08534428f, -0.06200015f, 
    0.04268634f, 0.05118298f, 0.10624389f, 0.01328268f, 0.04422246f, 0.07340835f, -0.01601652f, 0.11423618f, 
    0.10259220f, -0.00055126f, -0.06734917f, 0.07587288f, 0.14457083f, 0.04741008f, 0.08391077f, -0.07167780f, 
    -0.01068218f, 0.05421083f, -0.00449955f, -0.03439638f, -0.04042165f, -0.01873324f, 0.05468585f, -0.03810754f, 
    -0.06593800f, 0.05754649f, -0.06321356f, 0.04208021f, 0.09524590f, 0.02107114f, 0.00688707f, 0.12833247f, 
    0.30227295f, -0.07568481f, -0.15069216f, -0.05978979f, -0.12187259f, -0.10161649f, 0.03627495f, 0.04749084f, 
    0.10413444f, 0.13703243f, 0.08125415f, -0.07420472f, -0.05866024f, 0.09638721f, -0.02074134f, 0.15733425f, 
    0.08344487f, 0.03722426f, 0.00823909f, 0.04031760f, 0.03297160f, 0.11229025f, -0.11017108f, 0.11561885f, 
    -0.02414801f, -0.03002496f, 0.00634341f, -0.03590945f, 0.07304753f, 0.05431694f, 0.04915141f, 0.08903079f, 
    -0.02101700f, -0.03957298f, -0.01544248f, 0.10518760f, -0.09476919f, -0.04180280f, -0.09100737f, 0.04791936f, 
    -0.05028664f, 0.08421995f, 0.05767937f, -0.05005897f, 0.08996300f, -0.08621167f, 0.01821188f, 0.01786407f, 
    -0.02183447f, 0.12289611f, 0.01175523f, -0.03413321f, -0.01700213f, 0.02091204f, 0.12464356f, 0.03111135f, 
    0.03083258f, 0.09857977f, 0.06771702f, 0.02411009f, -0.31621984f, 0.10706967f, -0.16709572f, -0.16967100f, 
    0.05355469f, -0.02603139f, 0.04821634f, 0.05305194f, 0.07094307f, 0.09474842f, -0.01176619f, 0.08504190f, 
    0.05853805f, -0.10755022f, -0.07256451f, 0.09051774f, 0.02794253f, 0.10965852f, -0.00207530f, 0.05705919f, 
    0.17828573f, 0.12593208f, -0.05618204f, -0.01944939f, -0.08101279f, -0.03726346f, 0.04934455f, -0.01780714f, 
    0.04238371f, -0.05441412f, 0.04148129f, -0.02608394f, -0.04195815f, -0.01000255f, 0.10775708f, -0.01533003f, 
    0.02322855f, 0.02430589f, -0.06850466f, 0.08084749f, -0.10212454f, 0.18862596f, -0.07722385f, -0.22352944f, 
    0.13182364f, 0.06783743f, 0.13774130f, -0.02869428f, 0.07362047f, -0.03598778f, -0.09945235f, 0.00228402f, 
    0.00011706f, 0.02159551f, 0.01831187f, 0.04697691f, -0.06364143f, 0.09642445f, 0.05676759f, 0.08147277f, 
    0.14937882f, 0.24927567f, -0.08489314f, 0.03158275f, 0.13061738f, 0.06082994f, -0.03922106f, -0.03724087f, 
    -0.10293274f, -0.02875346f, 0.09808190f, 0.05863787f, 0.04778119f, 0.02925493f, -0.03112487f, -0.01304186f, 
    0.07885579f, 0.01003693f, -0.05227251f, 0.01857551f, -0.12135601f, -0.08879340f, 0.19767104f, -0.08803276f, 
    0.12207954f, 0.10707022f, 0.00114475f, 0.09624819f, 0.01356838f, -0.03189034f, -0.03446316f, 0.02619174f, 
    0.06940354f, -0.00909901f, 0.06214168f, -0.02581578f, 0.02629739f, -0.00328574f, 0.02337185f, 0.02931827f, 
    0.07759237f, 0.10854166f, -0.04294135f, -0.08868363f, -0.17689113f, 0.05519447f, 0.07244992f, 0.06222946f, 
    0.05095282f, -0.03498977f, 0.13903295f, -0.05073904f, 0.02983991f, 0.06708112f, -0.00888423f, 0.02346863f, 
    0.08074209f, -0.11112191f, -0.05135833f, 0.04629906f, 0.39183298f, -0.04489418f, 0.20189561f, -0.02721929f, 
    0.17508344f, -0.12379947f, -0.00661694f, -0.03751594f, 0.07008649f, 0.01364506f, 0.04828925f, 0.06198761f, 
    0.10543615f, 0.03299505f, 0.09365114f, -0.08952627f, 0.05764132f, 0.03984716f, 0.14282291f, 0.01782283f, 
    0.12279462f, -0.34261167f, 0.05066360f, 0.01206689f, 0.14303854f, -0.05152410f, -0.06330746f, -0.10310486f, 
    0.04569201f, -0.01497950f, 0.01460939f, 0.00743752f, -0.06094246f, -0.05927606f, -0.02697121f, -0.03830896f, 
    0.03598607f, -0.00940171f, 0.05140559f, -0.10072538f, 0.06239703f, 0.02005495f, 0.00846484f, -0.05075150f, 
    -0.24172257f, 0.15808156f, -0.00579641f, 0.06118292f, 0.00950210f, -0.05898262f, -0.07280088f, 0.03701549f, 
    0.07016701f, -0.00448990f, -0.06654143f, 0.02610683f, -0.07464213f, -0.00751331f, -0.08764323f, -0.10450321f, 
    0.01880715f, 0.19765055f, 0.05828950f, 0.03534402f, 0.34439602f, -0.03333764f, -0.00452154f, 0.03140992f, 
    0.05399647f, -0.03541263f, 0.01146837f, 0.00586184f, -0.00432884f, 0.09062893f, 0.08190952f, -0.02315946f, 
    0.08178432f, 0.07383066f, 0.01633994f, 0.01457258f, 0.21174783f, -0.40838075f, 0.13282707f, -0.19418995f, 
    0.08640969f, -0.08003389f, -0.02325430f, -0.03520037f, -0.05457453f, -0.00872095f, 0.01201552f, -0.00258330f, 
    0.03624186f, 0.01607566f, -0.04797479f, 0.01228403f, 0.00457832f, -0.01607003f, 0.12771668f, 0.13526076f, 
    0.18138525f, -0.16938870f, -0.11418797f, 0.26905474f, 0.14989668f, -0.19586089f, -0.02047369f, -0.08202554f, 
    0.09217174f, -0.01704117f, -0.03000257f, -0.06373411f, -0.03514834f, 0.07480105f, 0.16863747f, 0.00152733f, 
    0.00407851f, 0.08436183f, -0.00750475f, 0.12573507f, -0.09592829f, 0.06522674f, 0.22545297f, 0.10025470f, 
    0.20502441f, -0.07021672f, -0.06581733f, -0.08097170f, 0.01356389f, -0.01246006f, 0.05191794f, 0.02079566f, 
    0.00568111f, -0.07919019f, 0.05388234f, -0.00026792f, -0.00603047f, 0.03395025f, -0.07947689f, -0.06264104f, 
    -0.12092263f, 0.04894645f, 0.04340382f, -0.19286160f, 0.34352493f, 0.06264868f, -0.12871537f, -0.02706410f, 
    0.14016016f, -0.08410808f, -0.07376472f, 0.10375205f, -0.06622659f, -0.04024973f, 0.01873503f, 0.03227639f, 
    -0.01530647f, 0.22055829f, -0.14512202f, 0.04326361f, -0.13198407f, -0.23574962f, 0.02894882f, -0.05348109f, 
    0.28923079f, 0.06144044f, 0.06664699f, -0.10874782f, -0.00878635f, 0.04225678f, 0.05096174f, 0.00402607f, 
    0.03854581f, 0.15673953f, 0.21029203f, -0.03357765f, -0.02047151f, -0.05043905f, -0.08759538f, -0.04299296f, 
    -0.13715102f, 0.19275466f, 0.05589873f, 0.06320857f, 0.17510124f, -0.00828377f, -0.02226509f, 0.01095281f, 
    -0.10858528f, -0.01244773f, 0.11306552f, -0.03344906f, -0.16592045f, 0.11489331f, 0.01416386f, -0.00763486f, 
    -0.12267246f, -0.06251815f, -0.10572892f, -0.00029157f, -0.05285913f, 0.05721987f, 0.06483174f, 0.08519612f, 
    -0.18960868f, -0.01211399f, -0.07276735f, -0.12065626f, 0.00113438f, -0.03657266f, -0.00143447f, 0.10913864f, 
    -0.02610716f, 0.14628707f, 0.13768600f, 0.02296879f, -0.01854446f, -0.01353235f, -0.01729818f, -0.14377588f, 
    0.17225029f, 0.01220323f, -0.02091652f, 0.01828673f, 0.01469392f, 0.01494593f, 0.07515438f, -0.03987316f, 
    0.01751497f, 0.06392422f, 0.08088715f, -0.04987348f, 0.05982056f, 0.11055251f, -0.01363990f, -0.01723648f, 
    0.11336401f, 0.06915383f, 0.11012597f, 0.16989885f, 0.26866084f, 0.18935712f, 0.10908792f, 0.11125825f, 
    -0.01213509f, -0.12001771f, 0.02772906f, -0.14723659f, -0.05228498f, 0.09735782f, 0.12781118f, 0.03096722f, 
    0.11299473f, 0.02921082f, 0.05764290f, 0.09433704f, 0.05106789f, 0.02186341f, 0.13213107f, 0.03845598f, 
    0.18146235f, 0.13068782f, -0.14834148f, 0.01345918f, 0.08351224f, 0.06488940f, -0.15172881f, 0.05187334f, 
    0.10750574f, 0.01609785f, 0.06603652f, 0.21913628f, 0.15865642f, -0.03869428f, -0.03249668f, -0.15315050f, 
    0.02342124f, -0.19036593f, -0.01445399f, 0.12489904f, 0.06685619f, -0.08939923f, -0.05777861f, 0.19876498f, 
    0.23574096f, 0.01856596f, -0.12430465f, -0.11264504f, 0.05368366f, 0.06718829f, 0.14828978f, -0.10528328f, 
    0.00387797f, 0.08357214f, -0.05455605f, 0.04366219f, 0.01071256f, -0.02156691f, -0.14822488f, -0.10834508f, 
    -0.10771590f, -0.01940512f, 0.03021028f, -0.12080719f, -0.17146508f, 0.05131885f, 0.04952691f, 0.08840726f, 
    0.00086830f, -0.14952753f, -0.00338523f, -0.05415076f, -0.06659632f, -0.19029334f, -0.10493509f, 0.04395077f, 
    -0.01055406f, 0.08191373f, 0.05125793f, 0.07731067f, 0.04826161f, 0.14958568f, 0.15217039f, 0.34409907f, 
    -0.20736887f, -0.02213954f, -0.16514483f, 0.01004106f, 0.02229457f, -0.09330630f, 0.02206163f, 0.11671491f, 
    0.01907404f, 0.03177565f, 0.10900716f, 0.00999906f, -0.00152821f, -0.00972692f, 0.14522938f, -0.05869714f, 
    0.14910185f, 0.07224281f, -0.15002824f, -0.09353761f, -0.14168400f, -0.06190233f, 0.03068711f, -0.03077609f, 
    -0.06424168f, 0.16103029f, 0.02204868f, 0.03298078f, 0.04480023f, -0.02554995f, 0.05164237f, 0.01489077f, 
    0.11164456f, -0.04690038f, 0.15337811f, 0.17092316f, -0.38059896f, 0.08754192f, 0.09089673f, 0.06607873f, 
    -0.03198544f, 0.07519920f, 0.01182526f, -0.09184804f, -0.01876459f, 0.07820715f, 0.02403180f, -0.01668895f, 
    -0.07798722f, -0.06687410f, -0.02280537f, -0.00072778f, 0.16499452f, 0.05390875f, 0.02039058f, 0.12823384f, 
    0.06629478f, 0.06105750f, -0.04689794f, 0.12974642f, 0.35095921f, 0.10084036f, 0.04811274f, -0.05954243f, 
    0.16354950f, -0.07529606f, 0.12711982f, 0.13727091f, 0.13629761f, -0.06762387f, -0.00702457f, 0.04838111f, 
    0.01260374f, -0.11111211f, 0.02422135f, 0.04618060f, -0.12091039f, 0.10350419f, 0.04150390f, -0.15320726f, 
    0.15418574f, -0.05272162f, -0.07308652f, 0.00508909f, 0.02699352f, 0.16285887f, -0.14524078f, -0.02487748f, 
    0.08257598f, -0.00227203f, -0.01088195f, -0.07467382f, 0.02068734f, 0.01885925f, -0.00731109f, 0.12760389f, 
    0.27376199f, -0.00364099f, 0.09663741f, 0.22428933f, 0.14739960f, -0.14738856f, -0.02912594f, -0.01716568f, 
    -0.09003134f, 0.11715561f, -0.00219174f, -0.04028506f, 0.14660031f, 0.01171625f, 0.11275873f, 0.07863453f, 
    -0.08730116f, 0.03693447f, 0.08498192f, 0.03548323f, -0.25360996f, -0.44852492f, 0.09603067f, -0.26251510f, 
    -0.11889359f, 0.05052964f, 0.27371815f, 0.07543389f, -0.02107486f, -0.05950036f, 0.13356422f, 0.01230457f, 
    0.06989596f, -0.13308203f, -0.00950278f, 0.01430422f, -0.06600695f, -0.00386443f, -0.03030223f, -0.08374029f, 
    -0.63238299f, 0.23714681f, -0.05811383f, -0.17941430f, 0.07625552f, 0.05326759f, 0.01482098f, 0.13134544f, 
    0.00806106f, -0.14394502f, 0.00956260f, -0.01139519f, -0.00071737f, -0.05856367f, -0.00523907f, -0.09088640f, 
    0.10526168f, 0.02947220f, 0.03982706f, -0.00694245f, -0.18452179f, -0.00117871f, -0.03296993f, -0.00469156f, 
    -0.07543086f, 0.05654242f, -0.02023370f, -0.03644389f, 0.07164537f, 0.07840771f, 0.06449366f, 0.03751139f, 
    0.03852250f, -0.01095448f, 0.06994682f, -0.07463065f, 0.00888912f, 0.02893376f, -0.04274261f, 0.00194409f, 
    -0.31366205f, 0.05839333f, -0.03471447f, 0.00116889f, 0.04799112f, 0.05238551f, 0.02550033f, 0.10981640f, 
    0.08560786f, 0.00740303f, 0.11741733f, -0.04155194f, 0.04434338f, 0.05212115f, 0.00268033f, 0.02550668f, 
    0.02149345f, 0.06442244f, -0.04879957f, 0.01348800f, -0.09390670f, 0.12673686f, 0.05771811f, 0.05689989f, 
    -0.18588041f, -0.00951792f, 0.04413479f, 0.01951733f, 0.08473916f, -0.07109011f, 0.05429244f, 0.07261492f, 
    -0.05932065f, 0.10800021f, 0.04644596f, 0.07721893f, 0.03979890f, 0.05356744f, -0.02635632f, -0.04134844f, 
    -0.59899586f, 0.12766349f, 0.04229635f, -0.16503666f, 0.16512194f, 0.19935128f, 0.14481601f, 0.09829080f, 
    0.00864305f, -0.18251829f, 0.04029565f, -0.04479956f, 0.04430262f, -0.06340694f, 0.01628949f, -0.07955871f, 
    0.06144840f, 0.04057701f, 0.11023660f, -0.03827555f, -0.22132303f, -0.10656586f, 0.08434303f, 0.14111625f, 
    0.08714793f, -0.00211805f, -0.13127691f, -0.15916823f, -0.11310597f, 0.11043651f, 0.08861248f, 0.13701096f, 
    0.02748953f, -0.00567203f, -0.03390969f, -0.15499710f, 0.06220913f, 0.03424085f, -0.19892658f, 0.05172059f, 
    0.06042643f, 0.00349144f, -0.03910214f, 0.06854713f, -0.03044464f, -0.12396280f, -0.03574575f, 0.01386758f, 
    -0.02614984f, 0.15606339f, -0.06579619f, 0.08123735f, 0.06482407f, 0.04873268f, 0.19012712f, 0.07193032f, 
    0.07184076f, -0.02796084f, 0.06514839f, 0.09232696f, 0.21186890f, 0.05877551f, -0.08301587f, 0.22064240f, 
    0.02953501f, -0.02258321f, -0.05401028f, -0.02163340f, -0.01255245f, 0.03379883f, 0.00510620f, 0.01902543f, 
    0.00911200f, 0.18220188f, 0.03846992f, -0.06697628f, 0.02934166f, -0.04203078f, -0.01623795f, -0.04520346f, 
    -0.74567455f, 0.21561842f, -0.00020732f, -0.11389729f, 0.30266365f, 0.17668529f, 0.19814655f, 0.11795125f, 
    0.07241710f, -0.15303022f, -0.00963241f, 0.05305656f, -0.05799402f, 0.00178285f, -0.05594432f, 0.03578421f, 
    0.01547475f, -0.01064218f, 0.04445404f, -0.05001557f, 0.07530402f, 0.05080285f, -0.01588004f, 0.01785255f, 
    -0.05155542f, -0.03497883f, 0.09880544f, 0.04243520f, -0.09962317f, 0.03129180f, 0.07634050f, 0.03550890f, 
    -0.04881680f, -0.00815422f, 0.05971404f, 0.02977659f, 0.04257501f, -0.01187915f, 0.11586597f, 0.05025829f, 
    0.24053454f, 0.16066597f, -0.06401358f, -0.03257310f, -0.28819108f, 0.06687029f, 0.13610388f, 0.03535597f, 
    -0.18636137f, 0.04360863f, 0.03385336f, 0.07725903f, 0.05586198f, -0.05141116f, -0.00785343f, -0.01943930f, 
    -0.00356448f, -0.03809314f, 0.04729848f, -0.08087224f, 0.12571818f, 0.08059279f, 0.02421467f, 0.10152894f, 
    0.09876829f, -0.00525952f, -0.10442457f, -0.04685771f, 0.01139217f, -0.00603657f, 0.18228748f, 0.01764845f, 
    -0.00954449f, 0.02987044f, 0.16981973f, -0.11257131f, 0.03608518f, -0.02598904f, 0.04127960f, 0.03635367f, 
    0.09820183f, 0.13451093f, -0.02861224f, 0.00425047f, -0.16874029f, 0.02671893f, 0.12316723f, -0.13081574f, 
    -0.15222728f, 0.06437267f, 0.06980991f, 0.00632204f, 0.01492997f, -0.03818147f, 0.08581707f, 0.05598379f, 
    -0.09202454f, 0.03775076f, 0.13782422f, 0.06539239f, -0.10324371f, -0.03205964f, -0.08349199f, 0.21069348f, 
    -0.08674315f, 0.06874579f, 0.04899199f, 0.06995673f, -0.06734352f, -0.04716639f, 0.20305334f, -0.05345505f, 
    -0.03990488f, 0.15434954f, -0.06155143f, -0.03592122f, 0.03493266f, 0.02262315f, 0.04878954f, -0.05313006f, 
    -0.03844919f, -0.01618521f, 0.00862899f, 0.01453966f, -0.03173142f, 0.02647833f, -0.02912407f, 0.00858863f, 
    -0.04362163f, 0.00967002f, 0.01108168f, -0.03134838f, -0.02494295f, -0.01323566f, 0.01417531f, 0.03229900f, 
    0.01930428f, 0.02320935f, 0.00114511f, 0.01228399f, 0.00316932f, -0.01156498f, -0.03899897f, -0.01353144f, 
    -0.02467853f, 0.00298161f, -0.02135805f, 0.02665131f, -0.01281801f, 0.01408600f, -0.03957821f, 0.02941427f, 
    0.00631770f, -0.04068377f, -0.03603110f, 0.03189065f, 0.02648042f, 0.00147485f, -0.01513208f, 0.01815459f, 
    -0.01180906f, -0.00329810f, 0.02586068f, -0.03796189f, -0.02833980f, -0.04492680f, -0.00596530f, -0.02059971f, 
    -0.02392724f, 0.02758047f, -0.01020012f, -0.03605172f, 0.00908693f, 0.01082643f, 0.02633015f, 0.03746969f, 
    -0.00735771f, 0.01327031f, -0.00456132f, 0.02335607f, 0.00834521f, -0.03004693f, -0.01118153f, -0.02120418f, 
    0.01672956f, 0.01999781f, 0.01995527f, 0.00733940f, -0.01101907f, -0.00289975f, -0.03884456f, -0.04199040f, 
    0.02005097f, -0.00541457f, -0.01493908f, -0.01434382f, 0.01178247f, 0.01084234f, -0.03761055f, -0.03979364f, 
    -0.02684263f, -0.00648557f, -0.02397292f, 0.00590799f, -0.02436061f, 0.00428090f, -0.02500211f, -0.00039767f, 
    0.00565454f, 0.03212393f, 0.01447156f, -0.02265513f, 0.02138248f, -0.03072614f, 0.02458264f, 0.02183681f, 
    0.03078032f, -0.04488488f, 0.03086264f, 0.02531400f, -0.03494587f, -0.03356211f, -0.01274806f, -0.02776640f, 
    0.01347513f, 0.02495136f, 0.02483135f, -0.04064652f, -0.02723285f, -0.04065349f, -0.02879885f, -0.00102548f, 
    0.03175069f, -0.02275416f, 0.01169170f, 0.01919004f, -0.02318176f, -0.02490568f, -0.00986259f, -0.00105998f, 
    -0.00627547f, -0.04145879f, -0.03426764f, -0.03882203f, 0.03470588f, -0.00915943f, -0.04276035f, 0.00382973f, 
    0.03216046f, 0.03613383f, -0.00959142f, -0.00700138f, 0.00781398f, -0.03249061f, -0.02942450f, 0.00672178f, 
    -0.00090779f, -0.02051550f, -0.02613205f, -0.01626559f, -0.00936721f, -0.02002544f, 0.02908137f, 0.00438569f, 
    -0.02948871f, 0.03413995f, 0.01154016f, 0.03199793f, -0.03489902f, -0.02969600f, 0.00371424f, -0.01783566f, 
    0.01373488f, 0.00797444f, -0.04016085f, -0.00525729f, -0.03085941f, 0.03458389f, -0.00544035f, 0.03481256f, 
    -0.02307972f, 0.00841115f, 0.02960513f, -0.04453641f, 0.02610452f, 0.02005570f, -0.04283620f, 0.02744801f, 
    -0.04624163f, 0.03231245f, 0.02080527f, 0.01689461f, -0.01518438f, -0.01799505f, 0.00425948f, -0.03080644f, 
    0.01727324f, -0.04268792f, 0.02306767f, 0.02830862f, 0.02581539f, 0.01335539f, -0.03518162f, -0.02306577f, 
    0.01324935f, 0.01015554f, 0.00415409f, 0.01056056f, 0.03121451f, 0.00470450f, -0.00265509f, 0.02165916f, 
    0.00064305f, 0.02500013f, -0.03623068f, 0.00682406f, -0.02858659f, -0.04443458f, -0.03503520f, 0.01188345f, 
    0.02868945f, -0.01013854f, 0.01447667f, -0.02271232f, -0.01849039f, -0.00345548f, -0.00016284f, -0.01970997f, 
    0.00508222f, 0.01576541f, 0.00052121f, 0.00750081f, -0.03301163f, -0.00272448f, 0.01072597f, 0.02229592f, 
    0.00193830f, 0.01516685f, 0.02735992f, -0.00330729f, -0.01086451f, -0.04644777f, -0.00630151f, 0.01650962f, 
    0.01218266f, 0.00515269f, -0.01433519f, -0.03565453f, -0.00127612f, 0.00484244f, -0.00326651f, -0.01110726f, 
    0.03161791f, -0.02585224f, 0.00436176f, 0.01145946f, -0.03859726f, -0.01615224f, 0.01756508f, -0.02683927f, 
    -0.00894404f, -0.01448441f, -0.00557052f, -0.01828594f, -0.03864546f, 0.03106263f, 0.02752951f, -0.03911722f, 
    -0.01535872f, -0.00472327f, -0.01015282f, 0.03427184f, 0.01924512f, 0.02189450f, -0.00276906f, 0.00217592f, 
    0.03433157f, 0.03439528f, -0.00811644f, -0.02692102f, -0.00304516f, -0.03600472f, -0.02605365f, -0.00675823f, 
    0.03722392f, -0.01476128f, -0.00194765f, 0.00820021f, -0.00279008f, 0.02191025f, 0.01425556f, 0.03022466f, 
    0.00505991f, -0.00516626f, 0.01933304f, 0.00683368f, 0.01024842f, 0.01591648f, -0.02157466f, -0.02191729f, 
    0.01738125f, -0.02081769f, -0.02775657f, -0.04562193f, 0.01999231f, -0.02723656f, -0.00808292f, -0.02111124f, 
    -0.03611263f, 0.03373197f, 0.03038176f, 0.00743995f, -0.00956970f, 0.01811022f, -0.01171253f, 0.01213099f, 
    -0.00556460f, -0.03173381f, -0.04588835f, 0.02967423f, 0.03446737f, 0.00802338f, 0.01624408f, -0.00676346f, 
    -0.02778520f, -0.02801725f, -0.03247452f, 0.02373217f, -0.01403773f, 0.00590947f, 0.02665955f, -0.00723525f, 
    -0.04380297f, -0.00736016f, -0.03668141f, 0.02833010f, -0.02314985f, 0.02793779f, 0.02737072f, 0.03516530f, 
    -0.01557615f, -0.00974533f, 0.00330565f, -0.01204485f, 0.03288273f, 0.01932730f, 0.00077585f, -0.02717392f, 
    -0.04272451f, -0.00371202f, 0.03672240f, -0.01694550f, 0.02294400f, 0.00233567f, -0.04169534f, 0.00853894f, 
    0.02816942f, 0.01874094f, -0.01556140f, -0.03478334f, 0.00939760f, 0.02131732f, -0.00884833f, 0.01976066f, 
    0.00086979f, -0.00404153f, -0.00029084f, -0.04737034f, 0.02130250f, -0.00365356f, -0.03120810f, -0.02769609f, 
    -0.02997735f, 0.00395692f, -0.02457904f, 0.01679428f, 0.00597137f, 0.02985410f, 0.02515684f, -0.01179194f, 
    -0.03801907f, -0.00132528f, -0.02611206f, 0.00301613f, -0.01925951f, -0.01219993f, 0.01373456f, -0.02446555f, 
    0.01283836f, -0.00311674f, -0.02713497f, -0.02553497f, -0.01319294f, -0.00228669f, -0.01122531f, -0.03558521f, 
    0.01144798f, -0.02246504f, 0.00334848f, -0.03720083f, 0.01790913f, 0.01836457f, 0.00332482f, -0.03367830f, 
    0.00386553f, -0.02011977f, -0.02826504f, 0.02531234f, -0.01311488f, 0.01330815f, 0.00579654f, -0.00976486f, 
    -0.00693481f, -0.03447660f, -0.01263965f, -0.02199403f, 0.02935647f, 0.01444073f, -0.02189208f, -0.03377984f, 
    0.03170820f, -0.01717765f, 0.01679843f, 0.02868508f, -0.03762529f, -0.04420697f, -0.03695131f, 0.02840080f, 
    0.00468274f, 0.01597867f, 0.02989072f, 0.00163056f, -0.03597709f, -0.02554944f, 0.01482409f, -0.03149121f, 
    -0.00638661f, -0.00158381f, -0.01676983f, -0.01943237f, -0.03668030f, -0.00886747f, -0.01604666f, 0.03728945f, 
    -0.02254493f, 0.00860471f, 0.01412406f, 0.03006582f, 0.03350338f, 0.03829128f, 0.00767168f, -0.02824907f, 
    0.03071999f, 0.00597909f, 0.00700327f, 0.01467485f, -0.00807613f, 0.00087072f, -0.02179421f, -0.00103206f, 
    -0.03986585f, -0.00250398f, -0.01192476f, 0.03222791f, 0.02531627f, -0.04406535f, 0.01546493f, -0.02720380f, 
    0.02198775f, -0.03596445f, 0.03522979f, -0.00195716f, -0.01956975f, -0.01417655f, 0.00890115f, -0.02422612f, 
    0.02154101f, 0.02700067f, -0.02388030f, -0.03985217f, 0.02547432f, -0.00457288f, 0.00874077f, -0.00798812f, 
    -0.01287137f, -0.00747473f, -0.00703405f, 0.00739416f, -0.01267505f, 0.03299366f, 0.03490209f, 0.01045298f, 
    0.02582352f, 0.00035201f, 0.01006555f, -0.02727273f, 0.03046911f, -0.03258494f, -0.03358790f, -0.03936657f, 
    -0.01754298f, -0.00469366f, 0.00116515f, -0.01517192f, -0.00342984f, -0.03451292f, 0.01133154f, -0.00344226f, 
    0.00951968f, 0.03243484f, 0.00370573f, 0.02143528f, 0.00242409f, -0.02948532f, 0.01707400f, -0.00196701f, 
    -0.00168629f, 0.01952946f, 0.00193435f, 0.00232146f, 0.01454718f, -0.02749619f, 0.01339616f, 0.00630379f, 
    -0.01596353f, 0.00259401f, -0.03310905f, -0.04031065f, -0.01390008f, -0.02714874f, -0.01547842f, -0.01031300f, 
    -0.02701476f, -0.02318793f, 0.02797153f, 0.01564412f, -0.03455835f, -0.00305217f, -0.01226174f, 0.02269956f, 
    0.03166510f, -0.00786597f, -0.03458968f, 0.03202355f, -0.04221184f, 0.01988008f, 0.01682044f, -0.03948802f, 
    -0.04113204f, 0.02541032f, -0.00845620f, -0.02076738f, -0.01937491f, -0.00518178f, -0.01277890f, -0.01256688f, 
    0.01060566f, 0.03176414f, -0.00620183f, 0.03048890f, 0.01373127f, -0.04219406f, 0.03622490f, 0.02903780f, 
    -0.00009568f, 0.02617212f, -0.03470111f, -0.02994056f, 0.01581712f, 0.00743673f, 0.00889884f, 0.00579090f, 
    0.00965627f, 0.03491420f, 0.00398368f, 0.01871280f, 0.01641174f, 0.00235043f, -0.02729970f, 0.01084026f, 
    -0.03704058f, -0.01303893f, -0.02622435f, 0.00261962f, -0.00749074f, -0.03255745f, 0.03160728f, -0.03899473f, 
    0.01207910f, -0.01837960f, 0.03403106f, 0.01154809f, 0.02670025f, -0.00900033f, 0.03397398f, -0.04025323f, 
    0.00627920f, 0.01221516f, 0.02944030f, -0.00794838f, 0.00056803f, -0.03745486f, 0.01090154f, 0.02547260f, 
    -0.01761430f, -0.04452585f, -0.02639472f, -0.01274734f, -0.00813309f, -0.00077449f, -0.01600280f, 0.01141112f, 
    -0.01409156f, -0.03330242f, 0.01575868f, -0.02049578f, -0.01706039f, -0.03413653f, 0.01273103f, 0.00047375f, 
    -0.00127619f, -0.03213589f, -0.01798435f, -0.04122071f, -0.01717461f, 0.01862727f, -0.02068376f, -0.03481119f, 
    -0.00941530f, -0.04094300f, -0.03062399f, -0.03820573f, -0.00800966f, 0.00207619f, -0.03618506f, -0.02414816f, 
    -0.03429446f, -0.03611890f, -0.00771268f, -0.00442534f, 0.02708525f, -0.03268726f, 0.02075298f, 0.00068026f, 
    0.00125384f, 0.02929143f, -0.02882980f, 0.03014496f, 0.02461383f, -0.02443370f, -0.02043166f, -0.02657180f, 
    -0.01350724f, 0.01804532f, -0.02324881f, -0.01031940f, -0.03845142f, -0.01695794f, -0.02831592f, 0.03739738f, 
    -0.02907058f, -0.01311532f, 0.01778150f, -0.02344094f, -0.04927713f, 0.00435476f, 0.02194153f, -0.02743261f, 
    0.01922142f, 0.00462372f, -0.02586189f, -0.01263768f, 0.00235291f, 0.00053403f, 0.01069136f, -0.02804550f, 
    0.02667503f, -0.00302738f, -0.02756087f, 0.02775064f, -0.00867300f, -0.04098407f, -0.01542875f, 0.01657412f, 
    0.01950699f, 0.02571236f, -0.00961012f, 0.00265944f, 0.00394394f, -0.03841258f, 0.02183704f, 0.01704182f, 
    -0.04091943f, -0.04493671f, -0.03823172f, -0.00107779f, 0.02831233f, -0.03406769f, -0.03729641f, -0.04575938f, 
    -0.00142040f, 0.02260499f, 0.00922625f, -0.03564741f, 0.01035415f, -0.02343162f, 0.02316224f, 0.01389924f, 
    0.01223821f, 0.01386352f, 0.00298176f, 0.00147682f, -0.02539190f, 0.00140595f, -0.03078193f, -0.02791582f, 
    -0.02938838f, -0.04604166f, -0.00071894f, 0.01856067f, -0.04215848f, -0.03002225f, -0.02657924f, 0.02992163f, 
    0.01389415f, -0.03115212f, -0.04556612f, 0.02418067f, 0.00929253f, -0.00554035f, 0.01665897f, 0.02210263f, 
    -0.02374879f, -0.00729110f, -0.00259451f, 0.02761469f, -0.00643550f, -0.02871836f, -0.03999653f, 0.01705922f, 
    -0.02787647f, 0.01670670f, -0.04127907f, 0.00008127f, 0.01610252f, -0.03431948f, 0.02790369f, 0.02858934f, 
    0.02544147f, -0.00121908f, -0.03506196f, 0.02932818f, 0.01828764f, -0.04318849f, -0.04107131f, 0.02606263f, 
    -0.00617837f, -0.03759494f, -0.03433615f, -0.04507758f, 0.03159511f, -0.03255135f, -0.03184338f, -0.03727990f, 
    -0.02026165f, -0.02337914f, -0.02267515f, 0.02949769f, 0.01098682f, -0.01639966f, 0.01277925f, -0.03145557f, 
    -0.02701735f, 0.02494924f, -0.03902624f, 0.01369393f, -0.01594115f, 0.00269720f, -0.00672173f, -0.02607549f, 
    -0.03657720f, 0.00719069f, 0.00963556f, -0.03557002f, 0.03060315f, -0.02812380f, -0.00753001f, 0.01525539f, 
    0.00424203f, 0.01370389f, 0.02838321f, 0.00582304f, -0.04012687f, 0.00791661f, -0.01244274f, -0.03382285f, 
    -0.00548842f, 0.01885569f, 0.01051934f, -0.01505417f, 0.02886112f, -0.04729300f, -0.01614864f, -0.02790038f, 
    0.02892264f, -0.00484181f, 0.01958908f, 0.01751768f, -0.04779124f, -0.01075836f, 0.00525795f, 0.00596152f, 
    -0.02809591f, -0.02886255f, -0.03753908f, -0.02890885f, -0.00314317f, -0.04701814f, -0.03427630f, 0.00922687f, 
    0.00822283f, 0.02801281f, 0.00221889f, -0.00084621f, 0.02030485f, 0.03257117f, 0.02134323f, -0.03263012f, 
    0.00415344f, 0.00889998f, -0.03154728f, -0.02443866f, 0.00493264f, 0.02043899f, -0.01284318f, 0.01458685f, 
    0.00082104f, -0.00555071f, 0.00780818f, -0.03657911f, -0.04188735f, -0.03449230f, -0.00189052f, -0.04428231f, 
    0.00967702f, -0.00011863f, 0.00362116f, -0.02059438f, -0.02350969f, 0.00677150f, 0.00374311f, 0.01080717f, 
    -0.00491586f, 0.01719105f, 0.01497953f, 0.02637177f, -0.00539404f, 0.00061701f, 0.01096757f, 0.01662674f, 
    0.00297961f, -0.00867996f, -0.01600870f, 0.01912018f, 0.01393139f, -0.02272557f, -0.03654220f, 0.02904461f, 
    0.01939478f, -0.03926778f, 0.01571779f, 0.00031288f, -0.01625000f, -0.04158520f, -0.02976434f, -0.04406282f, 
    0.01315534f, -0.02186545f, 0.00272861f, -0.02057436f, -0.00523527f, 0.01091447f, -0.02088606f, -0.00762810f, 
    0.02133531f, -0.02602537f, 0.02313870f, -0.00195035f, -0.03673667f, 0.01543592f, -0.01854511f, -0.00188265f, 
    0.00414387f, 0.03386635f, 0.02966547f, 0.02508541f, 0.02962477f, 0.01124717f, -0.02124324f, -0.02145429f, 
    -0.00108928f, 0.02099635f, 0.00816667f, 0.00586172f, 0.01092644f, 0.01997412f, -0.02455660f, 0.02559146f, 
    -0.04351175f, 0.01068607f, 0.02258703f, -0.04136197f, -0.03550729f, -0.01257523f, 0.01505127f, -0.00394956f, 
    -0.03794319f, -0.00235427f, 0.02754364f, 0.00231654f, -0.00244455f, -0.02845797f, 0.00769558f, 0.03057898f, 
    -0.02856779f, -0.03352380f, -0.01474466f, 0.02357928f, -0.03679405f, 0.00464716f, -0.00297634f, 0.00024114f, 
    -0.01542393f, -0.01465137f, -0.01909265f, 0.00270566f, -0.00414118f, 0.01482525f, 0.02310737f, 0.03308094f, 
    0.02155065f, 0.00676786f, 0.02097430f, -0.02123111f, -0.01716138f, -0.01697656f, 0.01070271f, 0.02116168f, 
    0.00501424f, -0.02032114f, -0.03903412f, -0.04400621f, -0.02582337f, 0.00243548f, 0.01205140f, 0.00791443f, 
    -0.01438996f, 0.00500958f, -0.02642939f, -0.00955980f, 0.03039287f, -0.00282057f, -0.03796706f, -0.04020384f, 
    0.00457645f, -0.01026584f, 0.02526874f, -0.04179550f, 0.03077864f, -0.03449798f, 0.02757775f, -0.02456568f, 
    -0.00765189f, 0.00929570f, -0.00211154f, -0.03173978f, -0.04301378f, -0.02748253f, 0.02538860f, 0.01907164f, 
    -0.01346665f, 0.01249287f, -0.01270513f, -0.04127774f, 0.02993494f, 0.00255016f, -0.03894630f, -0.00557359f, 
    -0.00096630f, -0.01044795f, -0.02177730f, -0.01404431f, -0.01754765f, 0.00083261f, -0.04202144f, 0.00726889f, 
    -0.01107131f, -0.00656752f, -0.00812518f, -0.02537923f, -0.02866200f, -0.03221057f, 0.01932620f, -0.03193441f, 
    -0.02886018f, -0.02222781f, 0.02533955f, -0.02720868f, 0.00838391f, 0.01364051f, 0.02045295f, -0.01338768f, 
    0.00265652f, -0.04990963f, -0.03858314f, 0.02575677f, -0.03138767f, -0.01727180f, -0.01227064f, -0.01373469f, 
    0.01628505f, -0.02817471f, -0.04220726f, 0.01931261f, -0.03560719f, -0.02360968f, 0.01072652f, -0.04268530f, 
    -0.01012411f, -0.04360416f, 0.01419486f, -0.03668298f, -0.04734797f, 0.00621351f, 0.00122571f, -0.01740821f, 
    0.00799753f, -0.01956648f, 0.01835524f, -0.01874648f, -0.03930474f, -0.00248496f, 0.01879258f, 0.01271341f, 
    0.01683680f, 0.02688348f, 0.00396821f, 0.00463231f, -0.00241588f, -0.02912772f, -0.02847787f, 0.00318506f, 
    -0.03418967f, -0.01595548f, -0.00540994f, -0.00947628f, -0.04738209f, 0.01418640f, -0.03388799f, -0.03870349f, 
    -0.02811730f, -0.01874116f, 0.00045065f, -0.04011501f, -0.00535143f, -0.00430450f, -0.01303043f, 0.00436845f, 
    -0.04091047f, 0.00020196f, 0.03425708f, -0.03931149f, -0.03713523f, -0.03907986f, 0.01341687f, 0.02696446f, 
    -0.03399859f, -0.00833870f, 0.02738972f, 0.02431378f, 0.02530630f, -0.04789358f, 0.00465043f, -0.03799668f, 
    0.01828230f, 0.01806957f, 0.01319286f, -0.04378528f, 0.02424049f, 0.02578917f, -0.01136792f, 0.00722975f, 
    0.01240326f, -0.02721804f, 0.02854045f, 0.02866296f, -0.01975105f, 0.01373725f, 0.00053964f, -0.02202083f, 
    -0.00553600f, -0.03520124f, -0.02118148f, 0.00975650f, 0.01345387f, 0.01340341f, 0.02870866f, -0.01947843f, 
    -0.02900492f, -0.00292528f, -0.02291906f, -0.01336636f, 0.02787869f, -0.00154525f, -0.04251289f, -0.02549119f, 
    -0.00596635f, 0.02329061f, 0.02087087f, 0.02920844f, -0.03904056f, 0.02086894f, -0.03173633f, -0.04672587f, 
    0.02402990f, -0.01171201f, 0.03521213f, -0.02406471f, -0.01295404f, -0.04152469f, -0.00092141f, -0.02201343f, 
    -0.04073025f, -0.03267976f, -0.03242412f, -0.01137149f, -0.03819470f, -0.01752664f, -0.02459587f, -0.01703465f, 
    -0.03553721f, 0.01049145f, -0.03300504f, 0.01520914f, 0.02679252f, 0.01625661f, 0.02672585f, -0.02633299f, 
    0.02859706f, -0.02608844f, -0.03943860f, -0.01740489f, 0.00047190f, -0.04200068f, 0.01321719f, -0.02022786f, 
    -0.03633757f, 0.02003869f, 0.02370273f, 0.00867805f, -0.01992546f, -0.04406190f, 0.01560243f, -0.04393763f, 
    0.01660599f, -0.02137295f, 0.01763762f, -0.01119197f, -0.00113310f, -0.00758687f, -0.02741863f, -0.00720863f, 
    0.02224565f, 0.01614429f, 0.02222073f, 0.02118358f, -0.03477018f, -0.04720524f, -0.04671508f, 0.00128616f, 
    -0.02873104f, 0.02165686f, 0.01061969f, 0.02555590f, 0.03929440f, -0.00808594f, -0.02260424f, -0.01906560f, 
    -0.04753405f, 0.03408239f, -0.01221915f, -0.03191816f, -0.00725795f, 0.01571954f, 0.00035429f, 0.00212754f, 
    0.03172444f, 0.01666322f, 0.01094790f, 0.00485395f, -0.04739728f, -0.01076847f, -0.02333617f, 0.01590820f, 
    -0.01237572f, -0.01248482f, 0.02836148f, -0.02364672f, 0.02465175f, -0.01740989f, 0.02117609f, 0.00878030f, 
    -0.02220087f, -0.02597604f, 0.01008493f, -0.04311812f, -0.01045093f, -0.03434866f, -0.02448877f, -0.01622689f, 
    -0.03642679f, 0.01899946f, 0.01791527f, 0.00104091f, -0.00332639f, -0.02958036f, -0.00622923f, -0.03798561f, 
    -0.00297378f, -0.01456326f, 0.00464087f, 0.02148037f, 0.00574855f, -0.03374531f, -0.01157747f, 0.02356565f, 
    0.01294592f, -0.01372260f, 0.00093097f, 0.00616531f, -0.01115794f, -0.04628981f, 0.02318680f, -0.01443219f, 
    -0.02860951f, -0.02042671f, -0.04528058f, 0.02786574f, -0.01650022f, -0.00866475f, 0.02970600f, -0.04037344f, 
    -0.00482164f, -0.01058628f, 0.01314473f, -0.00551695f, -0.00447156f, -0.04165155f, 0.00337803f, 0.02016762f, 
    -0.01718305f, -0.03478823f, 0.00862516f, 0.02354892f, -0.01856478f, 0.02443443f, -0.02239072f, -0.00138858f, 
    0.00153383f, 0.02293695f, 0.00189714f, 0.00049504f, -0.04715104f, -0.02947461f, -0.03291652f, 0.01914873f, 
    0.01475615f, -0.03485156f, 0.01590619f, -0.02594615f, -0.00186293f, -0.00356860f, -0.02260020f, 0.00692799f, 
    -0.00578599f, -0.00619947f, 0.02518300f, -0.00301206f, -0.01620493f, -0.01708006f, -0.04499158f, -0.02649296f, 
    0.02639023f, -0.01868488f, -0.01657769f, -0.00971926f, -0.01312743f, -0.04486183f, -0.01864755f, -0.00906923f, 
    0.05998982f, -0.04470718f, -0.09086199f, 0.12935318f, -0.01102003f, 0.07240099f, 0.09417240f, 0.04954825f, 
    0.05030494f, 0.01499165f, 0.01082735f, -0.02314579f, -0.04834048f, 0.00973514f, -0.00591514f, 0.07153560f, 
    0.07970782f, 0.08249448f, 0.07433776f, 0.05113228f, -0.47882944f, 0.32423210f, 0.07153510f, -0.05400882f, 
    0.22458279f, -0.05282511f, 0.05553744f, -0.00652919f, -0.05186787f, -0.04304156f, 0.01430269f, -0.01379638f, 
    -0.01603389f, 0.05487034f, 0.02292612f, -0.03235849f, 0.11351271f, -0.10060206f, 0.00837354f, -0.06358896f, 
    0.07153992f, 0.18069012f, 0.32319027f, -0.19953255f, 0.02810209f, 0.10270203f, 0.06823041f, -0.04401075f, 
    -0.12032191f, -0.00999209f, -0.00164740f, 0.11395205f, 0.06979343f, 0.00004863f, 0.09183288f, -0.12151735f, 
    0.02808667f, 0.14183925f, 0.02017316f, 0.11218603f, 0.29927757f, 0.13444711f, -0.00768468f, -0.06577133f, 
    -0.04665361f, 0.09688408f, -0.04467725f, -0.03376819f, -0.05707650f, 0.01109963f, 0.06621710f, -0.09248824f, 
    -0.06841018f, -0.01281746f, -0.06337962f, -0.04346796f, -0.00067439f, 0.10181218f, 0.00013373f, 0.05719906f, 
    0.02864327f, 0.02150089f, 0.00612819f, 0.16550297f, -0.13118470f, 0.05715863f, 0.07835580f, 0.03626389f, 
    -0.11609388f, -0.05578799f, 0.01991562f, -0.02661733f, 0.03791917f, 0.07829489f, 0.04601741f, 0.08682495f, 
    0.04454104f, 0.01806141f, 0.14088573f, 0.01654164f, 0.06446480f, 0.14669560f, 0.09961276f, 0.06782136f, 
    0.10319191f, 0.06843802f, 0.02507646f, 0.02683811f, -0.02538860f, -0.14565426f, 0.07120705f, 0.05053975f, 
    0.10163952f, 0.12853245f, 0.19404158f, 0.05921632f, -0.01195935f, 0.01195807f, 0.08241892f, -0.02334893f, 
    -0.43435490f, -0.05097212f, -0.05786358f, 0.02437056f, -0.11848705f, -0.05088762f, 0.15362135f, 0.01496865f, 
    -0.07915156f, 0.01143705f, 0.03299604f, -0.04009724f, 0.09523822f, -0.02752839f, 0.04376554f, -0.01420245f, 
    -0.08019654f, -0.00880638f, 0.09387337f, 0.03128586f, -0.44635308f, -0.06442287f, -0.06171356f, 0.07598119f, 
    -0.11160186f, 0.10430246f, 0.30368525f, 0.04227487f, -0.13203153f, -0.03670010f, 0.07321069f, 0.12920593f, 
    0.12215349f, 0.04511810f, 0.03526288f, -0.21450876f, -0.01932328f, -0.00271703f, 0.00017643f, -0.04041835f, 
    0.00380080f, 0.33424920f, -0.06928875f, -0.12696198f, -0.17805214f, -0.00749697f, -0.03290211f, -0.06978213f, 
    0.03334926f, 0.05088045f, 0.09774516f, 0.02523278f, 0.02114304f, -0.01805010f, -0.13981803f, -0.10397720f, 
    0.03931144f, -0.02219124f, 0.11169370f, 0.04218594f, -0.30474931f, 0.13210717f, -0.12456603f, 0.08020256f, 
    0.39040786f, 0.03540654f, 0.00697645f, -0.03215971f, 0.00022946f, 0.02218037f, 0.03449168f, 0.05958134f, 
    -0.00439129f, -0.04194665f, -0.02981141f, -0.05075300f, 0.01917954f, 0.03647142f, 0.04647667f, -0.08138991f, 
    0.16492940f, 0.02024908f, -0.20803982f, 0.03484279f, 0.16324328f, -0.13529985f, -0.17592433f, -0.03876809f, 
    0.17884198f, 0.11291112f, -0.07226114f, -0.09796063f, 0.10220290f, -0.02017465f, 0.06855287f, -0.02304464f, 
    -0.07363276f, -0.02698502f, 0.01194700f, -0.07850465f, 0.10807727f, 0.16209112f, -0.12410092f, 0.06193046f, 
    -0.12341253f, 0.19815657f, 0.18148080f, -0.08767553f, 0.06567599f, 0.01813125f, 0.06839421f, -0.00845581f, 
    0.07130291f, -0.03784070f, -0.09662674f, -0.10138699f, 0.12962911f, 0.01345626f, -0.00632621f, 0.08250941f, 
    -0.28260311f, -0.03125028f, -0.03227099f, -0.03228293f, -0.16511074f, 0.10023261f, 0.14740700f, -0.05981071f, 
    -0.03021636f, 0.01149683f, 0.12829047f, 0.01250346f, -0.01451389f, 0.07664044f, -0.09572975f, 0.10923849f, 
    0.00717830f, -0.07490688f, 0.11655515f, 0.05619900f, 0.13875426f, 0.08251721f, -0.23596027f, -0.09101563f, 
    -0.21482338f, -0.02516551f, -0.05990224f, -0.06331571f, 0.14336294f, 0.04867932f, 0.02591859f, -0.01749945f, 
    -0.09072731f, -0.03723494f, 0.01195102f, -0.03547977f, -0.01225346f, 0.02427959f, -0.04424680f, 0.04263199f, 
    0.14017242f, 0.14855199f, -0.06130915f, -0.06500977f, -0.07585273f, 0.06390955f, 0.04897593f, -0.08199018f, 
    -0.12785637f, 0.02415798f, 0.14667304f, 0.10166740f, 0.06294505f, -0.10423008f, -0.00964476f, -0.01996253f, 
    -0.06409236f, 0.10313047f, 0.03592140f, 0.08983249f, 0.03563217f, 0.29121813f, 0.10235051f, -0.09304302f, 
    0.16815673f, -0.06182552f, 0.02960687f, 0.02670853f, -0.04485423f, 0.00986636f, -0.06251153f, -0.01860721f, 
    -0.04013174f, 0.03237033f, 0.08759235f, 0.13600223f, 0.17993575f, -0.00062743f, 0.06337169f, 0.06389846f, 
    -0.51947463f, -0.12160832f, 0.18007217f, 0.05666570f, -0.03637937f, 0.08691313f, 0.15618430f, 0.14917995f, 
    -0.10732630f, -0.09953529f, -0.04882386f, 0.01148031f, 0.05406620f, -0.01751039f, 0.06239524f, 0.04890656f, 
    -0.04912725f, -0.01645631f, -0.06049387f, -0.06567374f, 0.06274492f, 0.25552225f, 0.04777448f, -0.05877227f, 
    0.12556025f, -0.14570862f, -0.04039619f, 0.05310776f, 0.06552077f, -0.08005966f, -0.01254942f, -0.05678821f, 
    -0.04696935f, 0.03237812f, 0.05472348f, -0.10747179f, -0.00958374f, -0.02885964f, -0.01114068f, 0.20147017f, 
    0.02921732f, 0.11136999f, 0.25646031f, 0.05301174f, 0.24486348f, -0.13675156f, -0.04388177f, 0.13782746f, 
    0.05464720f, -0.01047126f, 0.01297692f, -0.03678134f, 0.02616202f, 0.02954383f, 0.04081785f, -0.11693565f, 
    0.01232615f, 0.04752135f, 0.04849184f, 0.07418077f, 0.09835525f, 0.08721104f, 0.04084807f, -0.05416324f, 
    0.04318172f, 0.06432066f, 0.00350510f, 0.06419466f, -0.06752668f, 0.01671044f, -0.02295210f, -0.02986475f, 
    0.08618767f, 0.01659127f, 0.01453116f, 0.02750601f, 0.19780931f, -0.02702145f, 0.05512506f, -0.01640234f, 
    0.22771417f, 0.10221802f, -0.12615164f, 0.06124792f, 0.09078493f, -0.11020622f, -0.08176597f, 0.02428013f, 
    0.15868039f, 0.00470134f, 0.03829160f, 0.06875600f, 0.01328456f, -0.09426076f, -0.06781604f, -0.00374288f, 
    0.05467082f, 0.05012374f, 0.03869256f, 0.04013539f, 0.47393918f, 0.08387774f, -0.06736475f, 0.12145370f, 
    -0.11993284f, -0.02375787f, 0.03918829f, -0.04187049f, -0.02955881f, -0.05769775f, 0.06170315f, 0.00709215f, 
    -0.06787359f, 0.11632160f, 0.09552462f, -0.04550166f, -0.05495081f, -0.01218446f, 0.01976240f, 0.09008994f, 
    -0.00496810f, -0.26352674f, 0.20564416f, 0.10307294f, 0.37783042f, -0.12729499f, -0.07204996f, 0.09815403f, 
    -0.00235532f, 0.07678499f, 0.01698327f, -0.02603645f, 0.01326494f, -0.00871694f, -0.04864446f, -0.01657078f, 
    0.08616169f, 0.04516320f, 0.08189268f, 0.01054177f, 0.02098760f, 0.00522555f, 0.02430407f, 0.16430642f, 
    -0.08800486f, 0.08523858f, 0.02834761f, 0.02006457f, 0.00768945f, 0.04192546f, 0.10176604f, 0.01828040f, 
    -0.03744458f, -0.08426338f, -0.03695544f, 0.05168295f, 0.08571387f, -0.08301135f, 0.01147145f, -0.05147226f, 
    -0.39641544f, -0.12075363f, 0.13034803f, 0.06800035f, -0.02495866f, 0.15990791f, 0.14602576f, 0.00564624f, 
    -0.07894795f, -0.06086531f, -0.02022141f, 0.00668218f, -0.01708613f, 0.00219120f, 0.03691388f, 0.13727090f, 
    0.02740324f, -0.05235917f, 0.04443809f, 0.02492362f, 0.07711862f, 0.08648136f, -0.22597834f, 0.12454244f, 
    -0.16127431f, 0.05777320f, 0.12039620f, -0.06288359f, 0.10655737f, -0.03640972f, 0.11009298f, 0.04063377f, 
    0.06955901f, -0.06958192f, 0.00382129f, 0.11314197f, 0.12384390f, 0.07578515f, -0.11757651f, 0.04206131f, 
    -0.03781372f, -0.09385696f, 0.29290837f, 0.05025325f, 0.36011842f, -0.11379028f, -0.01090833f, 0.11257742f, 
    -0.03257330f, 0.05362882f, -0.12135364f, -0.00894933f, -0.05118045f, -0.07240533f, 0.06563300f, -0.10590597f, 
    0.02524366f, 0.09317867f, 0.12372151f, -0.06605598f, -0.35130963f, -0.05905332f, -0.14324626f, -0.03004004f, 
    -0.25201118f, 0.00823845f, 0.01717035f, -0.01264975f, -0.10255405f, -0.03223791f, -0.02912143f, -0.06030625f, 
    0.05227621f, -0.02632379f, 0.03724030f, 0.19406079f, -0.07116225f, -0.03001040f, -0.02960270f, 0.05055984f, 
    -0.19751824f, 0.19409356f, -0.27099231f, 0.02857030f, -0.24921565f, 0.02314975f, -0.01935241f, 0.18756597f, 
    -0.06090393f, 0.06841972f, -0.01702338f, 0.06433781f, 0.08493572f, 0.08676505f, 0.06714246f, 0.04466121f, 
    -0.07449486f, -0.12367131f, 0.06524638f, 0.00608971f, 0.16741835f, 0.10845148f, 0.08955856f, 0.08784060f, 
    0.08406141f, 0.04878247f, 0.10040882f, -0.10490596f, -0.06217644f, -0.02195643f, 0.00037036f, -0.00828090f, 
    -0.08681467f, -0.03421793f, 0.15181823f, -0.07287354f, 0.05724510f, -0.03976405f, 0.06874175f, 0.15141964f, 
    -0.09834656f, -0.05453876f, -0.18738475f, 0.07519082f, -0.28341013f, 0.10669877f, -0.03838909f, 0.04072349f, 
    -0.06061277f, 0.05182441f, 0.04562091f, -0.06124460f, 0.10065138f, 0.08766608f, -0.02389077f, 0.10221583f, 
    0.01527081f, -0.02632020f, 0.09800190f, 0.00326329f, -0.34450698f, 0.16412987f, -0.12597850f, 0.09613919f, 
    -0.15337960f, -0.03238293f, -0.02950211f, 0.10992569f, 0.01002176f, 0.03792493f, 0.11835735f, -0.06387673f, 
    -0.09438770f, -0.04726892f, 0.06465452f, 0.08020300f, -0.08698294f, 0.02255250f, -0.04711855f, 0.03104723f, 
    0.24328303f, -0.08065493f, 0.06345279f, -0.31176007f, -0.07706401f, 0.10431578f, -0.07821126f, -0.09572151f, 
    -0.03891658f, 0.05499952f, 0.07775509f, 0.16633344f, -0.04472725f, 0.17579077f, 0.10180397f, 0.07830010f, 
    -0.02228932f, 0.03244523f, -0.01993273f, 0.04952736f, -0.39482975f, -0.11179394f, 0.03409419f, -0.09437320f, 
    -0.24298593f, 0.05039074f, -0.02195628f, 0.02217102f, 0.00828348f, 0.03796245f, 0.11253384f, 0.01313768f, 
    -0.00750321f, 0.01480986f, -0.07083681f, -0.16151208f, 0.19854534f, -0.08524526f, -0.14275065f, -0.08004543f, 
    0.32198504f, 0.01813376f, 0.21615510f, -0.19246410f, -0.08484103f, 0.12868650f, 0.13828580f, 0.14473763f, 
    0.14866972f, 0.04970354f, -0.02892070f, 0.03121685f, 0.00368286f, 0.22591880f, -0.04201442f, 0.08904961f, 
    -0.09733340f, -0.07090516f, -0.18571728f, -0.02544947f, 0.25099275f, 0.26017758f, 0.03887828f, -0.18441831f, 
    0.02357164f, -0.06171328f, -0.10696489f, 0.18175039f, 0.12067907f, 0.07298047f, -0.00028104f, -0.03518991f, 
    0.07101625f, 0.10807638f, 0.09937267f, 0.06874438f, 0.08047267f, -0.01324117f, -0.09223844f, 0.13177371f, 
    0.20390064f, -0.08545229f, -0.01878861f, -0.04331075f, 0.03027391f, -0.03369234f, 0.12581986f, -0.04103452f, 
    0.14472921f, -0.05863545f, 0.04477967f, 0.09885141f, 0.01136623f, 0.07332120f, 0.07592770f, 0.06790657f, 
    0.08658931f, -0.01865358f, -0.18829118f, 0.11067460f, -0.16279671f, 0.09243448f, -0.06337176f, -0.17951615f, 
    0.25714225f, -0.07475945f, -0.06544041f, -0.00082655f, -0.00734025f, 0.08087936f, 0.19187459f, -0.02245897f, 
    0.08911262f, 0.06753168f, 0.05436170f, 0.08828079f, 0.06153056f, -0.04553742f, -0.15867582f, 0.08368433f, 
    0.15351787f, -0.01023116f, 0.07322337f, 0.06120905f, -0.06137865f, 0.18040498f, -0.00342173f, -0.06069600f, 
    -0.08792680f, -0.05044416f, 0.21494794f, -0.06248218f, 0.01532597f, 0.06266022f, 0.05477248f, 0.00795147f, 
    0.04910077f, 0.05671712f, 0.09963748f, 0.02710157f, -0.08490361f, -0.12297863f, 0.26729530f, 0.13793786f, 
    -0.06997453f, 0.13420574f, 0.05391875f, 0.01426200f, -0.05904474f, 0.02639892f, 0.12343594f, 0.01726504f, 
    0.00252675f, 0.22179870f, 0.08345395f, -0.05195826f, -0.06838450f, 0.06571440f, -0.00705012f, -0.09218860f, 
    -0.28229403f, 0.05571706f, -0.08735815f, 0.07581564f, 0.06506306f, -0.13653295f, -0.00922289f, 0.02553467f, 
    0.07793486f, -0.08103702f, 0.06231896f, -0.01906083f, 0.05554819f, -0.02673747f, 0.01772321f, -0.03206135f, 
    0.03524692f, -0.22226517f, 0.02719131f, 0.11351621f, -0.33687383f, 0.03963350f, 0.14198995f, -0.11095819f, 
    -0.15734363f, 0.13513008f, -0.08655664f, -0.06312894f, -0.06362574f, -0.01968479f, 0.27450234f, 0.18254821f, 
    0.16383989f, 0.15861696f, 0.00844257f, 0.03594965f, 0.10834868f, -0.06414298f, -0.09160645f, 0.09311399f, 
    -0.18035819f, 0.15273151f, -0.19406612f, -0.07192968f, 0.35081291f, 0.09137119f, -0.17353053f, -0.03378301f, 
    -0.00150337f, 0.03158680f, 0.08344062f, -0.01043736f, 0.02259130f, -0.20261008f, -0.01835683f, -0.10960950f, 
    -0.10042875f, 0.05004860f, 0.12075375f, -0.02819667f, -0.44716102f, -0.16641721f, 0.00408437f, -0.45262310f, 
    0.10265031f, 0.03667144f, 0.03326047f, -0.20565005f, -0.04444053f, 0.11211471f, 0.09341414f, -0.05462699f, 
    0.26992810f, -0.07817937f, 0.15374683f, -0.18927546f, -0.07079540f, -0.14396659f, 0.07430421f, -0.05431674f, 
    -0.07228244f, -0.12148632f, -0.13891301f, 0.05804478f, -0.03699892f, 0.18665165f, 0.15170164f, -0.06363622f, 
    -0.02374972f, 0.05817547f, -0.01736170f, 0.06217789f, -0.13543053f, 0.04011552f, -0.02911528f, 0.03398045f, 
    0.07068436f, 0.04184746f, 0.07626727f, 0.03059413f, -0.05018176f, 0.22121258f, -0.19090055f, -0.27733988f, 
    0.01685035f, 0.04967321f, 0.16050407f, -0.17541166f, -0.01032039f, -0.07529734f, -0.05129010f, 0.02464958f, 
    0.14638209f, -0.03447037f, 0.07115289f, -0.02489957f, 0.07858736f, 0.11739583f, -0.00969513f, 0.02612908f, 
    0.10670622f, 0.17037497f, 0.01698545f, 0.14905371f, 0.03747238f, -0.03218463f, 0.18820773f, 0.04672034f, 
    0.02271368f, 0.00535354f, -0.00418090f, -0.00000980f, 0.04049453f, 0.09544656f, 0.05223874f, 0.04631436f, 
    0.10995542f, -0.11058322f, -0.01003770f, -0.07817665f, -0.56436962f, -0.17395717f, -0.25441077f, -0.46587259f, 
    0.07291955f, 0.26028535f, 0.09570112f, -0.07329289f, -0.09299356f, 0.06848929f, 0.00594687f, -0.04119907f, 
    -0.10567838f, 0.00266048f, 0.05103102f, 0.09649575f, 0.10507362f, -0.13292480f, 0.00193754f, 0.01967316f, 
    -0.13539200f, -0.33354422f, 0.17316495f, -0.02932543f, -0.06003514f, 0.14057760f, 0.02574337f, 0.02529939f, 
    -0.04601283f, 0.03110149f, 0.11465291f, 0.02074825f, 0.08766119f, 0.02949445f, 0.01457831f, 0.05744604f, 
    0.09676822f, 0.06587785f, -0.04935743f, 0.06026347f, -0.29014054f, 0.09749973f, -0.05566746f, 0.04677394f, 
    0.19702572f, 0.19821440f, -0.22146980f, 0.07508785f, -0.06529873f, 0.04000122f, 0.04032053f, 0.02213374f, 
    0.04648745f, -0.03207858f, -0.00147451f, -0.05065568f, -0.01414101f, 0.03304136f, 0.08080264f, 0.03981370f, 
    0.16354518f, -0.06018699f, -0.02553095f, 0.34429747f, -0.00150345f, -0.00120917f, -0.10682527f, 0.01519847f, 
    0.04318842f, 0.29947627f, 0.07757813f, -0.13076271f, -0.05297189f, -0.02200519f, 0.06640116f, 0.06941111f, 
    0.05515956f, -0.04531260f, 0.08158001f, -0.04689592f, -0.29488212f, -0.00026192f, -0.05060622f, -0.10135888f, 
    0.30135256f, 0.00793931f, -0.00733092f, -0.02071486f, 0.04597022f, 0.10418327f, 0.06703437f, 0.06870323f, 
    -0.03978180f, 0.01975302f, -0.01474075f, 0.02062779f, 0.00490419f, -0.00295730f, -0.14174722f, 0.07623193f, 
    -0.11220721f, 0.26935142f, -0.07276142f, -0.03067730f, 0.08295602f, 0.05407969f, 0.05486148f, -0.07274258f, 
    0.03767374f, 0.17392808f, -0.09364010f, 0.02365596f, -0.11871886f, -0.05475930f, -0.02258918f, 0.07352806f, 
    0.05840849f, 0.09752810f, 0.08880819f, 0.19567990f, -0.26210341f, 0.04143688f, -0.28047287f, -0.27962068f, 
    0.22397560f, -0.13325582f, 0.08756793f, -0.11236838f, 0.01745736f, 0.13017094f, 0.01648139f, 0.04842554f, 
    -0.03578251f, -0.01456416f, 0.10329066f, 0.09413104f, 0.01485880f, 0.04840981f, -0.18539177f, 0.18247010f, 
    0.25157115f, -0.18448202f, 0.12227964f, 0.29773802f, 0.20947638f, -0.09917578f, -0.01071211f, -0.09706455f, 
    0.05445806f, 0.06852286f, -0.00893985f, 0.10074877f, -0.02961796f, -0.10872259f, 0.06763804f, -0.06103992f, 
    0.07876372f, 0.02445941f, -0.06075539f, 0.03441662f, 0.14747497f, 0.13744405f, -0.06496955f, -0.25447997f, 
    0.06392330f, 0.05659074f, 0.21793522f, -0.01348439f, 0.13287008f, -0.00230065f, -0.03521848f, -0.03133059f, 
    0.04026010f, 0.10707559f, 0.02384293f, 0.10066176f, -0.00363887f, 0.06234665f, -0.08252906f, 0.05387925f, 
    -0.26376957f, -0.26713881f, -0.08816890f, -0.11412532f, 0.11407343f, 0.12625885f, 0.06209872f, -0.08755849f, 
    -0.10540395f, 0.08186994f, 0.09959301f, 0.03735832f, 0.05410996f, 0.11074527f, 0.02224432f, 0.10922378f, 
    0.07368678f, -0.03959816f, 0.08827655f, 0.05394869f, -0.04219814f, -0.11023851f, -0.11294884f, -0.16104455f, 
    0.03723562f, 0.06694048f, 0.11396111f, 0.16868088f, -0.00862678f, 0.05457034f, 0.05629554f, -0.00882705f, 
    0.05662472f, -0.02418394f, 0.07369093f, -0.03349582f, 0.14040326f, -0.20659736f, 0.13890366f, 0.09417715f, 
    0.08176155f, -0.11348665f, 0.07688429f, 0.27634245f, 0.16026980f, -0.01404291f, -0.04986252f, 0.00849313f, 
    0.04437120f, 0.09608559f, 0.03140564f, 0.08445908f, -0.12903842f, 0.02465958f, -0.01298068f, -0.06277925f, 
    0.04445940f, -0.05710287f, -0.02663824f, -0.01234743f, 0.17784034f, 0.32995507f, -0.18396153f, -0.06894863f, 
    -0.21832766f, 0.16848455f, 0.13464433f, -0.02899582f, -0.01971041f, -0.10158237f, 0.11995712f, -0.08545317f, 
    0.00495652f, -0.18923844f, -0.03888470f, -0.10133585f, 0.03705012f, 0.02953795f, 0.15621850f, -0.05353164f, 
    -0.22779478f, -0.11015380f, -0.01003536f, -0.05074949f, -0.09019675f, 0.01597605f, 0.00104312f, -0.10028725f, 
    0.02238051f, -0.05927002f, 0.15876567f, 0.02645336f, 0.01263848f, -0.01126431f, 0.16602121f, -0.11914460f, 
    0.04060525f, -0.03679327f, 0.14594443f, -0.01803293f, 0.14040391f, 0.06010458f, 0.11834674f, -0.02627361f, 
    -0.12970150f, 0.00113568f, 0.06156885f, 0.04337951f, 0.07016058f, 0.06364942f, 0.08259511f, -0.06906886f, 
    0.07882641f, 0.11120614f, 0.15068161f, -0.03284770f, -0.01483703f, -0.04777317f, -0.08485230f, -0.04391229f, 
    0.24266121f, 0.13789797f, -0.12199300f, 0.14791176f, -0.13011739f, 0.07533554f, 0.06350436f, -0.02351973f, 
    -0.06635881f, 0.07579335f, 0.03212392f, 0.01598735f, 0.01388907f, 0.12722155f, 0.09154336f, 0.04978404f, 
    0.07505317f, 0.17786048f, 0.01476568f, 0.04717904f, -0.13135391f, 0.27570605f, 0.00412970f, -0.11815096f, 
    -0.29530734f, 0.16844301f, 0.03088517f, -0.07433880f, -0.07000177f, -0.00367793f, 0.12486396f, 0.03111503f, 
    -0.01218039f, 0.09210593f, 0.01247748f, -0.07219764f, -0.04536355f, -0.07545485f, 0.17516385f, -0.02059263f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00175817f, 0.08766326f, -0.06451108f, 0.00070787f, -0.00819994f, 0.00181051f, 0.02190300f, 0.00701010f, 
    0.06808960f, -0.00505913f, 0.02286112f, 0.01144238f, 0.01640208f, -0.03495004f, 0.01787628f, -0.02928024f, 
    0.00145695f, -0.02160663f, -0.00539919f, 0.02315773f, -0.03472965f, 0.06807202f, 0.02777592f, -0.03143188f, 
    0.00388994f, -0.00461380f, 0.04536521f, 0.02673693f, 0.01669742f, 0.00813950f, 0.08735061f, 0.09199400f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.28166470f, 0.51158357f, -0.50632197f, -0.28746384f, 0.15343821f, -0.07646508f, 0.12023520f, 0.06644145f, 
    0.15789327f, 0.00433547f, 0.32751116f, 0.09275006f, 0.16476202f, 0.16416752f, -0.16177379f, -0.08986753f, 
    0.17414638f, -0.18347020f, 0.32114843f, -0.11619107f, -0.11490881f, 0.25983191f, -0.00364698f, -0.16252510f, 
    0.03528300f, 0.03554388f, 0.22055338f, 0.08419318f, 0.10542202f, -0.08266483f, -0.02310002f, 0.03344866f, 
    -0.25505462f, 0.41011557f, -0.38748828f, 0.06368439f, -0.07241473f, -0.04377482f, 0.13514856f, -0.00148127f, 
    0.20069826f, 0.08033219f, 0.23451568f, 0.15169872f, -0.07412704f, -0.17210272f, -0.14264411f, -0.00895398f, 
    0.09872907f, -0.02366741f, -0.27975717f, 0.03032561f, 0.04887608f, 0.01906860f, 0.07694823f, 0.03683997f, 
    0.11399323f, -0.10449486f, 0.19344549f, -0.16287117f, 0.00451495f, -0.15343091f, 0.11433743f, 0.32448941f, 
    0.29777813f, -0.30831650f, 0.47065303f, 0.15038018f, 0.05210339f, -0.07083168f, 0.03439477f, -0.13897324f, 
    0.11169793f, -0.06304785f, -0.07589656f, 0.07285118f, -0.39251879f, 0.05680976f, 0.15366079f, -0.10447385f, 
    0.10390266f, 0.09198033f, 0.16534801f, -0.12890333f, 0.06295713f, 0.07445458f, -0.11725376f, -0.15410151f, 
    0.28080845f, -0.14665207f, -0.18583706f, 0.10499871f, -0.06875440f, -0.11123709f, 0.33789647f, -0.15925962f, 
    0.08740140f, -0.11900158f, 0.15411364f, -0.11692443f, 0.09926650f, -0.04645700f, 0.09067998f, -0.14909749f, 
    -0.12442695f, -0.14665630f, -0.05716857f, -0.16886909f, -0.16340096f, 0.12495065f, -0.01641222f, 0.00769957f, 
    0.00681293f, -0.06132270f, -0.12974715f, 0.00069074f, -0.07280266f, 0.14984019f, -0.09396827f, 0.15253325f, 
    -0.17367938f, -0.00145780f, -0.08015750f, -0.08737782f, 0.16803174f, -0.09501235f, 0.13819353f, -0.01614899f, 
    0.54162061f, -0.21675210f, -0.16989788f, 0.04759347f, 0.11545585f, -0.05543927f, -0.00681247f, 0.08966307f, 
    0.09394784f, 0.12149885f, 0.09389088f, 0.05716562f, -0.01031532f, 0.00209759f, -0.05878402f, -0.09703776f, 
    0.07905039f, -0.16836020f, 0.14705457f, 0.26843598f, 0.09166055f, 0.37533808f, -0.09318352f, -0.02151475f, 
    0.11394449f, 0.06859874f, 0.04835852f, -0.15346053f, 0.12228926f, -0.12224547f, -0.30241400f, -0.24412999f, 
    -0.12952934f, -0.12751393f, -0.09636746f, 0.10374366f, -0.11454953f, -0.13672084f, 0.03106659f, -0.04728366f, 
    -0.17815109f, -0.17668393f, 0.09881105f, -0.15579526f, -0.15209484f, -0.01818980f, 0.11689325f, 0.01181222f, 
    0.16180934f, 0.00443570f, -0.04404541f, -0.03953727f, -0.16728655f, 0.01538072f, 0.07455657f, -0.04811355f, 
    -0.19227880f, -0.02527886f, -0.18659133f, -0.01577569f, 0.09115248f, 0.07744614f, 0.04789432f, 0.11465294f, 
    0.02172674f, 0.07911538f, -0.07030803f, 0.26823822f, -0.11577726f, -0.15648633f, -0.05474228f, -0.15819950f, 
    -0.16902919f, 0.01357402f, -0.33276516f, -0.07600889f, 0.18294851f, 0.16384189f, 0.04433232f, 0.08138712f, 
    0.15651836f, 0.14307795f, 0.06441273f, 0.11033770f, 0.11439203f, -0.05297134f, -0.07336190f, -0.08506032f, 
    0.13163306f, -0.13895012f, -0.17432852f, 0.14022125f, -0.05963677f, 0.13761367f, 0.31221443f, 0.35787550f, 
    0.12161981f, -0.48666471f, 0.41153893f, -0.11899917f, -0.01103955f, -0.12036391f, 0.15165214f, -0.12803291f, 
    0.08875496f, -0.15182781f, 0.21106923f, 0.11109286f, -0.24247181f, 0.04875833f, 0.05898125f, -0.05869506f, 
    0.03587450f, 0.09680992f, -0.07504349f, -0.31058189f, -0.15839283f, -0.22270590f, -0.05363114f, -0.15199675f, 
    0.26036915f, 0.14733478f, 0.28852597f, 0.32616943f, -0.11792884f, 0.04748873f, -0.30692545f, 0.27248827f, 
    -0.11854929f, 0.06196907f, -0.09773339f, -0.07573625f, 0.03953421f, -0.13156711f, 0.02705719f, -0.00412802f, 
    -0.01737376f, 0.03161795f, -0.17572650f, -0.15707658f, 0.03983340f, -0.03076106f, 0.03413264f, 0.02185641f, 
    0.01010069f, 0.01654706f, -0.21063043f, -0.17048888f, -0.12111267f, -0.18276761f, 0.00077759f, -0.09339244f, 
    -0.05152648f, -0.11149040f, 0.10829251f, 0.05188233f, -0.11826321f, 0.04825154f, 0.13140188f, -0.17054766f, 
    0.26602632f, -0.08685436f, 0.13710408f, -0.05531015f, -0.09391053f, 0.02779027f, -0.00304558f, -0.13251945f, 
    0.11547667f, 0.04744969f, -0.16814177f, 0.08531158f, -0.02347059f, -0.17037199f, 0.08998674f, -0.05237776f, 
    -0.07848404f, 0.14221004f, 0.10750446f, 0.28007647f, 0.12839091f, -0.07271684f, 0.14285231f, 0.15552649f, 
    0.27439740f, -0.01761113f, -0.10457271f, 0.12535627f, -0.16785292f, -0.17111088f, -0.24688506f, 0.17071147f, 
    0.01802932f, -0.13251194f, 0.27909115f, 0.22534232f, -0.08074737f, -0.17571686f, -0.01791199f, -0.16490419f, 
    -0.03990672f, 0.15255471f, -0.36659336f, -0.04915650f, 0.18983543f, 0.09985617f, -0.13179196f, 0.12631923f, 
    -0.11956564f, 0.03061471f, -0.05181625f, 0.35769001f, 0.16967803f, -0.28369713f, -0.16831355f, 0.14763857f, 
    0.15212131f, 0.10720211f, -0.10151680f, 0.03907131f, -0.13614631f, 0.07161595f, -0.02723500f, 0.09066851f, 
    -0.08941173f, -0.17420143f, 0.27691689f, 0.29473609f, 0.16021657f, 0.01406406f, 0.15901265f, -0.17082392f, 
    -0.02649898f, 0.02999467f, 0.18475333f, 0.06487495f, 0.04379495f, 0.09264287f, -0.13773812f, 0.15194371f, 
    0.13490467f, 0.09432866f, -0.44673452f, 0.28513262f, 0.12076280f, -0.34822780f, 0.13916983f, -0.02364105f, 
    -0.14055905f, -0.14944072f, 0.26424140f, -0.05048048f, 0.05714417f, -0.06543452f, -0.07756099f, 0.15045293f, 
    0.02342233f, -0.30109760f, 0.22291166f, 0.06229959f, -0.11708815f, -0.03373220f, 0.07509127f, -0.13555123f, 
    0.34663853f, 0.01792784f, -0.04282537f, -0.14913446f, 0.38672602f, 0.10811525f, -0.06751011f, -0.02120539f, 
    0.10582630f, 0.16317010f, -0.10947362f, 0.08605006f, -0.17725281f, 0.15503857f, -0.08203827f, -0.11022516f, 
    -0.12543236f, -0.14062455f, -0.06828404f, -0.13760328f, 0.15743047f, -0.09569374f, -0.39525157f, 0.07556808f, 
    0.33201462f, -0.25530323f, 0.20754831f, 0.08094519f, 0.12496518f, 0.12269336f, -0.02550266f, 0.04943990f, 
    0.32281807f, -0.16660725f, 0.10101055f, 0.02031838f, -0.18162647f, 0.02425198f, 0.16115364f, 0.14140394f, 
    0.16071126f, -0.08617016f, 0.10073470f, 0.20711528f, 0.15373439f, -0.16356258f, 0.05693447f, -0.03309982f, 
    -0.05655846f, -0.15033278f, 0.08758478f, 0.39658991f, 0.03993272f, -0.08529150f, -0.13858868f, -0.44609845f, 
    -0.03993822f, -0.29061541f, 0.29966077f, 0.27651811f, -0.06392705f, -0.16489418f, 0.17061919f, -0.17008691f, 
    0.17575648f, 0.17006055f, -0.16259122f, 0.16640261f, 0.22989741f, -0.14767027f, -0.00289153f, 0.06035724f, 
    -0.02890175f, -0.14554867f, 0.12331372f, -0.00924375f, -0.07174371f, -0.30412230f, -0.05215056f, -0.01333031f, 
    0.04905842f, -0.03214727f, -0.15708102f, 0.31231734f, 0.12582113f, 0.05022909f, 0.03950833f, -0.19578300f, 
    -0.19157043f, 0.39438719f, 0.45016497f, 0.05305760f, -0.16388483f, -0.03557831f, -0.00014719f, 0.09296687f, 
    -0.02405824f, 0.00237646f, 0.26284719f, 0.06529742f, 0.26232100f, 0.11127319f, 0.04867092f, 0.11327203f, 
    0.10037238f, 0.06884382f, 0.24151085f, -0.33184129f, 0.15417162f, -0.15313706f, -0.04170139f, -0.03465042f, 
    0.27667999f, -0.11055173f, 0.16923055f, -0.31556019f, 0.10113758f, -0.02168675f, -0.13870208f, -0.25928846f, 
    -0.35295057f, 0.13130987f, 0.36186343f, 0.23351300f, 0.03656434f, -0.03535676f, -0.14955960f, 0.09739193f, 
    0.21840024f, -0.05819092f, 0.00520876f, -0.10319141f, -0.41606528f, 0.02025149f, 0.08015857f, -0.01713434f, 
    0.06564192f, 0.13090502f, -0.49637297f, -0.31339863f, -0.01450726f, 0.06526117f, 0.11487958f, -0.00589240f, 
    0.26238251f, -0.04052910f, 0.19426048f, -0.29266712f, -0.02969408f, -0.08364673f, 0.26404619f, 0.16025367f, 
    0.22124238f, -0.11195250f, -0.34910959f, 0.27154973f, 0.12029871f, 0.13612823f, 0.08505397f, 0.13985503f, 
    -0.22188926f, -0.17141372f, -0.01760194f, 0.09417032f, 0.36406037f, 0.12664135f, -0.14064826f, 0.15395564f, 
    0.10497908f, 0.10110717f, -0.19569467f, 0.05575806f, -0.14073256f, 0.09975642f, -0.12543614f, -0.15496255f, 
    0.04106371f, 0.00523358f, 0.02601923f, -0.22493091f, 0.07876346f, 0.06543527f, 0.12941200f, 0.07000561f, 
    -0.01603325f, -0.15837961f, -0.02053127f, -0.13123180f, 0.03266805f, -0.13576774f, -0.16263294f, 0.09784221f, 
    0.00360738f, 0.14860545f, 0.10638088f, 0.06175012f, 0.00374269f, 0.06875510f, -0.16043521f, 0.08018439f, 
    0.04284636f, -0.04736945f, 0.11174755f, -0.18074979f, -0.11072162f, -0.06839169f, -0.04186874f, 0.04896845f, 
    -0.18110327f, 0.11959852f, -0.14629883f, -0.09482338f, -0.15353800f, 0.09270001f, -0.15895838f, -0.04226359f, 
    -0.27324322f, 0.00570044f, -0.30477411f, -0.20066150f, -0.12915160f, -0.02841070f, -0.09913331f, -0.14215845f, 
    0.25873354f, 0.10207389f, 0.15160899f, 0.15306935f, 0.24125780f, 0.03079727f, 0.16458936f, 0.00367048f, 
    -0.10765692f, 0.01307111f, -0.14065184f, 0.05820720f, 0.02596796f, -0.18541200f, -0.07624036f, -0.02384045f, 
    -0.17296949f, -0.17113253f, 0.22032598f, 0.55395365f, -0.14313118f, 0.12851255f, 0.12515327f, 0.20865388f, 
    0.27809158f, 0.35761201f, -0.12715171f, 0.26991493f, 0.08472323f, 0.03174995f, -0.12310573f, 0.06390283f, 
    -0.20550969f, 0.10122511f, -0.34192345f, 0.01274852f, 0.04169991f, -0.01536761f, -0.14500977f, -0.10577911f, 
    0.08897847f, -0.00485802f, 0.35808891f, 0.35407159f, 0.03337038f, 0.20530766f, 0.10756330f, -0.02092212f, 
    -0.03025038f, 0.08755025f, -0.05547469f, -0.05559291f, 0.08942061f, 0.06272800f, 0.35928121f, 0.05389928f, 
    -0.02358641f, -0.07055897f, 0.35631040f, -0.26024872f, 0.09788013f, -0.00612433f, 0.03211861f, 0.13786510f, 
    0.01373337f, -0.11569440f, -0.06287655f, -0.11625239f, -0.11579567f, -0.12502560f, -0.11532041f, 0.06423067f, 
    0.12027687f, -0.05844263f, 0.52503502f, 0.01359582f, 0.04811998f, 0.30218932f, 0.02139288f, -0.04716759f, 
    0.24367884f, 0.04656041f, -0.30594113f, 0.26261955f, -0.09157068f, -0.04747982f, 0.29036504f, 0.27652365f, 
    -0.16258816f, 0.52722079f, 0.38903204f, 0.19814081f, 0.10663922f, -0.12190009f, -0.05000395f, -0.03568984f, 
    -0.20718940f, -0.15679272f, 0.06980713f, 0.17124358f, 0.43894857f, 0.06321682f, 0.03636231f, 0.07295459f, 
    0.02285443f, -0.06727469f, 0.41815051f, -0.21167205f, 0.16294281f, 0.25014195f, -0.03218536f, -0.14812522f, 
    0.17061016f, 0.12469671f, 0.09018319f, -0.31492999f, -0.05331054f, -0.08663575f, -0.21113221f, -0.09510299f, 
    0.09463222f, -0.17661595f, 0.25737095f, -0.07966127f, 0.13154258f, 0.13839953f, 0.07789590f, -0.05310898f, 
    -0.32988089f, 0.02266861f, 0.20637311f, 0.16066419f, 0.09833590f, -0.04818091f, 0.08875351f, -0.15151921f, 
    0.05741415f, -0.00910416f, 0.05052261f, 0.25910980f, 0.03738876f, 0.05212552f, -0.15424028f, 0.13232169f, 
    0.11988766f, -0.11307105f, 0.01473814f, -0.23381357f, 0.11538923f, -0.02401155f, 0.19967735f, 0.30242470f, 
    -0.08632691f, 0.18376726f, 0.27690777f, -0.17306623f, -0.00604320f, 0.14328459f, -0.15127793f, 0.03624160f, 
    0.16045317f, 0.10000419f, -0.00707046f, 0.14777642f, 0.35279617f, -0.00846926f, 0.06423548f, 0.01814288f, 
    0.15466291f, 0.01753752f, 0.22458686f, -0.03637883f, -0.14453818f, 0.12527956f, -0.08678290f, 0.04700014f, 
    0.14751816f, -0.00284387f, -0.30128863f, 0.04504441f, -0.08581762f, -0.03414469f, 0.19206767f, -0.17370579f, 
    0.33521694f, -0.38399667f, -0.02736496f, 0.17376992f, 0.16355033f, -0.06721606f, -0.04107399f, -0.12265525f, 
    0.31673643f, -0.11127593f, 0.10349395f, -0.00210513f, -0.02765410f, -0.03333991f, 0.00348362f, -0.09375491f, 
    -0.00157462f, 0.09662406f, -0.20990039f, -0.18381102f, 0.12552273f, 0.49761647f, 0.06873066f, -0.14026196f, 
    -0.16865848f, -0.12132342f, 0.28062016f, 0.24725516f, -0.13407956f, -0.04823814f, -0.37743968f, 0.32072222f, 
    -0.10741446f, -0.15591773f, 0.11665619f, -0.08150219f, 0.17211090f, 0.10882298f, 0.15487830f, -0.07324685f, 
    -0.12719275f, -0.01620695f, -0.07962202f, -0.08800894f, 0.02699400f, 0.02698572f, -0.11078897f, 0.03965735f, 
    0.12647165f, 0.15613014f, -0.14969927f, 0.02815278f, -0.08671641f, 0.15217765f, -0.07776951f, -0.08725487f, 
    -0.06125503f, -0.05712468f, -0.00912977f, -0.11716560f, 0.17936896f, 0.09651580f, -0.06302603f, 0.00871506f, 
    -0.22286345f, 0.30202234f, -0.33046526f, 0.01145463f, 0.01481515f, 0.06597949f, -0.07161377f, 0.16826068f, 
    0.30890641f, 0.08323713f, -0.05619992f, 0.15317774f, -0.12987809f, -0.13823603f, 0.01416527f, 0.12459502f, 
    -0.03187569f, 0.06018717f, -0.30055451f, 0.55210656f, -0.01410676f, -0.35269734f, 0.01329332f, -0.02346834f, 
    0.15211219f, 0.12710249f, 0.24838677f, 0.18275988f, -0.13602127f, -0.10164758f, -0.11083992f, 0.02345599f, 
    -0.20904429f, -0.11624483f, 0.01625885f, -0.13036463f, -0.01272754f, -0.06332231f, -0.00612620f, 0.15928864f, 
    -0.10420176f, -0.00707629f, 0.25000951f, -0.13881025f, 0.38601053f, -0.04755901f, -0.02800936f, -0.13128507f, 
    -0.09739745f, 0.03709489f, -0.01258000f, 0.35141885f, 0.16006508f, -0.26338282f, -0.09663343f, -0.06031526f, 
    0.11201046f, 0.12761781f, -0.02460642f, 0.26942608f, -0.08143257f, 0.13429435f, -0.26335341f, 0.05910391f, 
    0.16827722f, -0.30124044f, 0.23396093f, 0.05826081f, -0.15963914f, 0.02625877f, -0.11898426f, -0.14901353f, 
    0.00893014f, -0.15335862f, 0.15609634f, -0.11607625f, 0.45514235f, 0.13391149f, -0.07108108f, 0.08070616f, 
    0.17548797f, -0.11226757f, 0.13632619f, -0.19253901f, -0.07649345f, 0.32932398f, 0.01910860f, -0.16895175f, 
    -0.17616221f, 0.06449860f, 0.11974274f, -0.32046187f, -0.07296768f, 0.15579604f, -0.18137102f, 0.24860790f, 
    -0.26258025f, -0.20187891f, -0.28530270f, -0.00785584f, -0.03146165f, -0.09683970f, -0.07507905f, -0.08392858f, 
    -0.06891476f, 0.04727675f, 0.32279396f, -0.09468625f, 0.32204032f, -0.04064562f, -0.11128791f, -0.01833304f, 
    -0.13778540f, 0.08368168f, -0.09812988f, 0.05132040f, -0.02007857f, -0.03468129f, -0.11687040f, -0.14546327f, 
    0.03467768f, -0.06712370f, -0.00798883f, -0.25026366f, 0.08999509f, -0.09943897f, 0.36561060f, 0.14195628f, 
    -0.08195453f, 0.79098576f, -0.21930088f, 0.19188483f, 0.14736846f, 0.14393988f, 0.14499742f, 0.04489852f, 
    0.10341707f, 0.06409029f, -0.04789867f, -0.08307131f, 0.03912779f, 0.06404632f, 0.09833413f, -0.07021337f, 
    0.01940160f, -0.17067118f, 0.25342369f, 0.11696956f, 0.07832803f, -0.10222271f, 0.13586311f, -0.05549727f, 
    0.11124764f, 0.14640883f, -0.26313284f, 0.06282661f, -0.01358484f, -0.05213254f, 0.60040039f, 0.07559235f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.17449264f, 0.06339633f, 0.07999612f, 0.07095205f, 0.13750118f, -0.17800137f, 0.15813474f, -0.18403707f, 
    -0.10430917f, -0.14480963f, -0.15039356f, 0.23045780f, 0.20233163f, -0.09304634f, -0.04341100f, 0.03112680f, 
    0.11799161f, -0.05444198f, 0.08271796f, -0.08823425f, -0.01603922f, -0.03726651f, 0.10659181f, -0.17031896f, 
    0.09999343f, 0.28043479f, -0.14405586f, 0.24106680f, -0.12463449f, -0.15222177f, 0.02979589f, 0.22544777f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.10702429f, -0.21260120f, 0.12302614f, -0.03594904f, 0.29870477f, 0.00003206f, -0.69944257f, 0.21053717f, 
    0.15763827f, -0.07864244f, -0.11271931f, 0.22940017f, 0.12810791f, 0.32829821f, 0.17283805f, 0.13403073f, 
    -0.13534936f, -0.62801427f, 0.15280823f, -0.18176317f, -0.20646808f, -0.43564939f, 0.10645279f, -0.17299227f, 
    -0.29002538f, 0.23798737f, -0.03984094f, -0.15687646f, -0.05333454f, 0.29353607f, -0.52372444f, -0.69660991f, 
    0.19573276f, 0.26652342f, -0.45413312f, -0.14400567f, 0.24612449f, -0.15506080f, -0.19194704f, 0.01641761f, 
    -0.05323300f, -0.06210146f, 0.09544922f, 0.18494074f, 0.15101580f, -0.12958032f, -0.43211612f, -0.05539638f, 
    0.10679799f, 0.14722463f, -0.10138424f, 0.01580945f, -0.29745319f, -0.59342146f, -0.22101791f, -0.19017053f, 
    -0.60370296f, 0.28228164f, 0.01340675f, 0.22517084f, -0.06988011f, 0.09588104f, 0.06637189f, -0.30520311f, 
    0.04829704f, 0.18418558f, -0.10934641f, 0.15015644f, -0.19008030f, 0.02112696f, -0.22210069f, -0.19359924f, 
    -0.01529034f, -0.66554815f, -0.45218715f, 0.02200325f, -0.09076048f, -0.28235060f, -0.03868278f, 0.48399103f, 
    0.21560821f, 0.11200898f, -0.06207011f, -0.05696110f, -0.18634076f, -0.39627337f, 0.22488178f, 0.02490443f, 
    0.05928446f, -0.14226262f, 0.05055554f, -0.34788707f, -0.36944014f, 0.25862628f, 0.44204679f, 0.00952206f, 
    -0.60942382f, 0.06209210f, 0.30021650f, 0.15846361f, 0.16262700f, -0.15830402f, 0.04576716f, -0.45643517f, 
    -0.02314897f, -0.05934610f, 0.24757509f, 0.34393069f, 0.08313216f, 0.08121126f, 0.08021975f, -0.45033777f, 
    0.22802420f, -0.11814913f, -0.09815969f, -0.36564147f, 0.22179060f, -0.23483877f, -0.31554800f, -0.03421344f, 
    -0.31823343f, -0.15004508f, -0.05713993f, 0.35286167f, -0.28239909f, -0.54086399f, 0.04662682f, 0.13614689f, 
    -0.20707257f, 0.07166184f, 0.36818326f, 0.09437249f, -0.19155137f, -0.07475996f, 0.18998770f, 0.22038777f, 
    0.03051895f, -0.06575945f, -0.00120579f, -0.13288908f, -0.16118333f, 0.02648410f, 0.15145250f, -0.05994184f, 
    0.36152691f, -0.59566075f, 0.10264965f, -0.01276156f, -0.12345343f, 0.27992955f, -0.27646309f, -0.33451223f, 
    0.00509067f, 0.18751235f, -0.01741362f, -0.19477357f, -0.53143829f, -0.28574166f, -0.28048930f, 0.04647785f, 
    0.23251660f, -0.00604276f, 0.02825716f, -0.00243099f, 0.27251673f, -0.10559512f, -0.26227242f, -0.15382868f, 
    0.13006823f, -0.07638790f, -0.18855301f, -0.40047801f, 0.16181929f, 0.23862004f, 0.10411763f, -0.47527200f, 
    -0.51794201f, 0.00761782f, 0.11488871f, 0.27400666f, -0.03442512f, 0.08327401f, -0.50650114f, -0.40640080f, 
    0.10893878f, 0.22019535f, 0.12744819f, 0.04553819f, 0.04782537f, 0.00841721f, 0.20951997f, -0.05730598f, 
    0.34234163f, 0.16391967f, 0.06266557f, 0.01509861f, 0.19682887f, 0.16886719f, -0.21396631f, -0.29906490f, 
    0.06650537f, -0.13535914f, -0.58013803f, -0.59558845f, -0.35975245f, 0.04364030f, -0.29439086f, 0.27965811f, 
    -0.06379774f, -0.20353286f, -0.04529844f, -0.21172942f, 0.15222235f, 0.05704909f, 0.14783880f, -0.40720910f, 
    0.15563217f, -0.08480722f, 0.00190731f, 0.05683648f, -0.34467876f, -0.41522032f, -0.29130492f, 0.33131319f, 
    -0.22852765f, -0.32263738f, 0.20859231f, -0.17661324f, 0.09128764f, 0.15594454f, 0.28159946f, -0.08235221f, 
    -0.02511945f, 0.15909423f, 0.24220826f, -0.19900052f, -0.42745644f, -0.08132244f, 0.17742223f, 0.02150898f, 
    -0.48902464f, 0.04081696f, 0.11618376f, -0.36686599f, 0.24121109f, 0.10312423f, 0.00442578f, 0.27250838f, 
    0.20084755f, -0.49731848f, -0.07943719f, -0.20253550f, 0.08342120f, -0.15829624f, 0.11460651f, 0.07088987f, 
    0.12760229f, 0.16491573f, -0.16394208f, -0.11801295f, -0.25559583f, 0.00291247f, -0.26431552f, 0.22884819f, 
    0.11148156f, -0.11525289f, -0.20351678f, 0.17259659f, -0.68956238f, -0.17085126f, -0.42090073f, -0.17143156f, 
    -0.10507273f, -0.30816936f, 0.15963680f, 0.17403673f, -0.32872298f, 0.25185120f, -0.35316274f, 0.43621436f, 
    -0.28890532f, -0.18465437f, 0.16197133f, 0.21730320f, 0.49976319f, -0.33806852f, 0.33541027f, -0.07467700f, 
    -0.07774240f, -0.10496306f, 0.12394293f, -0.15220211f, 0.17000359f, 0.08931884f, 0.02811838f, -0.14912193f, 
    0.12617280f, 0.06618696f, -0.05308063f, -0.32351708f, 0.29681811f, -0.27024528f, -0.27293926f, 0.05052174f, 
    -0.08897796f, -0.29098454f, 0.04313169f, -0.44490704f, -0.02965181f, 0.37044436f, 0.17570569f, 0.14150345f, 
    0.31050694f, 0.06395338f, 0.12719008f, -0.58298916f, -0.08604676f, 0.42425701f, -0.13457261f, -0.06050753f, 
    0.04230647f, 0.14255258f, -0.28459424f, 0.10095241f, -0.25030947f, -0.06548686f, 0.38100952f, -0.43374160f, 
    -0.10793979f, -0.19197829f, 0.00671302f, 0.12532522f, -0.31458682f, -0.37029764f, -0.19047888f, -0.62567472f, 
    -0.14928173f, 0.20297918f, -0.06846215f, 0.09189820f, 0.39518741f, -0.08893614f, 0.10446912f, 0.17419301f, 
    -0.60192692f, 0.10015831f, 0.10654256f, -0.05123048f, -0.26228583f, 0.16350271f, 0.00511438f, 0.20735011f, 
    -0.16000618f, 0.02040765f, -0.35265601f, 0.17246783f, -0.43444026f, 0.01685642f, 0.05937444f, -0.20990376f, 
    0.05920919f, -0.02014105f, 0.23510335f, 0.21728732f, 0.15664335f, -0.03536094f, 0.31318542f, 0.10243575f, 
    -0.02532540f, -0.54098362f, 0.08200838f, 0.25460240f, -0.14942364f, -0.13759749f, 0.05804959f, -0.44266444f, 
    0.17783643f, -0.18258932f, -0.00482923f, 0.33857766f, 0.38223761f, -0.42636091f, -0.16658922f, 0.16970582f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.13802794f, 0.15179101f, -0.04123213f, 0.08624975f, -0.00057120f, 0.02533037f, 0.05119883f, -0.15687551f, 
    0.08710925f, 0.14748527f, -0.09548590f, -0.06981901f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
