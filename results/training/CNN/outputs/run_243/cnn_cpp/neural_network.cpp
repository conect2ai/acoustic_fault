#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.56374538f, -0.67768735f, -0.93221086f, -0.68890715f, -0.19323404f, 0.07396810f, 0.75475097f, 0.16701870f, 
    0.38882485f, 0.53747988f, -0.19214410f, -0.38897800f, 0.00503986f, -0.50564754f, -0.34149051f, -0.08150982f, 
    0.08180615f, 0.21910653f, 0.09587050f, -0.19595332f, -0.28597108f, -0.30807063f, -0.33750448f, -0.17106701f, 
    -0.07359576f, 0.71582121f, 0.75054216f, 0.76571935f, 0.91872668f, 0.78299022f, -0.31452966f, -0.07107570f, 
    -0.15082760f, 0.31779662f, -0.18762086f, 0.13501385f, -0.06004860f, 0.16304022f, -0.13294643f, 0.02262821f, 
    0.06093789f, 0.20073089f, 0.15398605f, -0.05956483f, 0.07288601f, 0.17138734f, -0.14483839f, 0.14545244f, 
    0.00900454f, 0.18462026f, 0.43311873f, -0.08655084f, -0.21313848f, 0.61739361f, 0.44756564f, 0.24077196f, 
    -0.83803403f, -0.28400445f, -0.61526859f, -0.24961114f, -0.10515967f, 0.13803639f, 0.16524270f, 0.24818090f, 
    0.17344569f, 0.08259757f, 0.03253919f, 0.05584186f, 0.33285880f, 0.47118405f, -0.30578065f, 0.16378823f, 
    0.06156576f, -0.05539198f, -0.37296468f, 0.00207493f, -1.45724523f, 0.34776184f, 1.01854527f, -0.36258477f, 
    -0.43301705f, 0.50122541f, 0.65552020f, -0.51796228f, -0.18374129f, 0.06283262f, 0.02612702f, -0.06797891f, 
    0.08241510f, -0.08312750f, -0.16078155f, 0.14382952f, 0.12132217f, -0.04800722f, -0.19407405f, 0.03916664f, 
    -0.10233320f, 0.10143881f, -0.02341361f, 0.03716448f, -1.20543206f, 0.30110580f, 0.08254878f, -0.86214662f, 
    -0.48953336f, 0.68568212f, -0.20713654f, -0.46327305f, 0.05800039f, -0.27894646f, 0.06403695f, -0.39694205f, 
    0.09110204f, 0.11306182f, -0.06455556f, -0.00100744f, -0.08576906f, -0.13861191f, -0.19116142f, -0.23812851f, 
    0.02067486f, 0.03065687f, 0.15675408f, 0.26528659f, 0.06195781f, 1.28620446f, 0.08773018f, 0.75896406f, 
    0.74310583f, -0.23134603f, 0.07211191f, -0.03110564f, -0.38650993f, 0.53375441f, 0.10532941f, 0.02280511f, 
    -0.12789968f, 0.00278777f, 0.23331501f, -0.25200692f, -0.11754893f, -0.09722647f, -0.04279792f, -0.13355018f, 
    -0.05091856f, -0.44364962f, 0.14538650f, -0.25259772f, -0.12248848f, -0.04747681f, 0.91248316f, 0.38823351f, 
    0.32239762f, 0.04250960f, 0.89888698f, 0.49267715f, 0.12691922f, 0.42715773f, 0.42667890f, 0.10587772f, 
    -0.27264684f, 0.48831350f, 0.04369873f, 0.19550298f, 0.13771725f, 0.09926441f, -0.02018206f, 0.03579859f, 
    0.30827174f, 0.24311095f, 0.10533122f, 0.09720239f, -0.02644737f, -0.39417076f, 0.07968830f, -0.02597123f, 
    0.23448487f, 0.97824645f, -0.81385458f, -0.74238980f, -0.19980709f, 0.53711510f, -0.19765574f, -0.37935624f, 
    0.26722303f, 0.18149866f, 0.34435746f, -0.34795457f, 0.01226801f, 0.31060496f, -0.04042877f, 0.01752302f, 
    0.04343951f, -0.12438817f, 0.05475283f, -0.11405993f, 0.04547535f, 0.07091264f, 0.00429074f, -0.05108362f, 
    -0.97296447f, 0.46318027f, 0.24085417f, 0.29786175f, 0.74215627f, -0.60392940f, 0.71495873f, 0.54436260f, 
    -0.44742277f, 0.33234289f, -0.49699932f, -0.15055630f, 0.40567729f, -0.20942536f, -0.04350083f, -0.01164846f, 
    -0.30753303f, 0.04570961f, 0.13439283f, -0.07074036f, -0.13510001f, -0.22236055f, -0.18621743f, -0.09866114f, 
    -0.09777378f, -1.04555202f, -0.92248362f, -0.80229950f, 0.46329170f, 0.11885539f, -0.01513606f, 0.05100242f, 
    -0.30449596f, 0.22197266f, -0.13937807f, 0.32783255f, 0.27047712f, -0.18257758f, 0.37048361f, 0.14432074f, 
    -0.01304268f, 0.22110379f, 0.04652566f, -0.10316109f, 0.05768684f, -0.06956527f, 0.05042420f, -0.09484959f, 
    -0.15207289f, -0.13625425f, -0.37199879f, 0.82173198f, 0.65199500f, 0.11324967f, -0.38053969f, -0.74640304f, 
    0.38026488f, -0.43247482f, -0.73025739f, -0.55836838f, 0.12488691f, 0.36399677f, 0.02215911f, 0.20526433f, 
    0.22172669f, 0.23106900f, 0.18343662f, 0.12521410f, 0.17572924f, 0.03613862f, 0.13870040f, 0.15972020f, 
    0.16521552f, 0.15933664f, 0.30851120f, 0.80624360f, -0.25680685f, -0.89304370f, 0.16486129f, 0.46515450f, 
    0.42836463f, 0.56920034f, -0.25892830f, 0.31649500f, 0.00637599f, -0.00063436f, 0.42393422f, -0.27427098f, 
    0.18101400f, -0.01107697f, -0.05837910f, -0.27783364f, -0.13434087f, -0.21116684f, -0.40232635f, -0.09248132f, 
    -0.11665882f, 0.07160618f, 0.21779118f, 0.30000928f, 0.60220456f, 0.89100617f, 0.42166078f, 0.35759366f, 
    -0.51497704f, -0.45598528f, -0.70955616f, -0.48006001f, -0.62946469f, -0.02116245f, 0.16874368f, 0.22460666f, 
    0.10839114f, -0.25531733f, -0.03472897f, -0.30299711f, -0.39162278f, 0.22156879f, -0.21118264f, -0.26642150f, 
    0.19863828f, 0.34697059f, -0.06341770f, 0.01180108f, 0.10339930f, -0.71820438f, -0.48658824f, 0.08821783f, 
    -0.22334599f, -0.41535738f, -0.68636876f, -0.41733569f, -0.03224000f, 0.09452355f, -0.20028962f, 0.23252180f, 
    0.17432038f, -0.47968224f, -0.22072835f, -0.09481072f, 0.51983625f, 0.06412021f, 0.19381911f, -0.41013288f, 
    -0.13949054f, 0.11279606f, 0.17811410f, 0.42499444f, 0.21941830f, 0.18570702f, -0.69504786f, -0.43772727f, 
    -0.34959799f, -0.36467791f, -0.24133365f, 0.06661076f, 0.91333687f, 0.64685977f, -0.27811432f, 0.40910426f, 
    -0.15773058f, 0.08316744f, 0.21465750f, -0.05613923f, 0.10187072f, 0.01721374f, -0.25825599f, -0.27812392f, 
    0.07244556f, 0.01621901f, 0.10999608f, 0.07212833f, 0.24530043f, 0.25741920f, 0.31803960f, -0.10257728f, 
    0.35368681f, -0.72602266f, 0.72478300f, -0.34019199f, -0.05403526f, -0.30323589f, -0.60475981f, 0.31166884f, 
    -0.47065553f, -0.40933713f, -0.18474090f, -0.19695731f, 0.25693300f, 0.11444220f, -0.35932299f, 0.13439281f, 
    -0.10735449f, -0.14784914f, -0.34839517f, 0.10820998f, 0.03274673f, 0.29496914f, 0.04398651f, -0.22154415f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00349082f, 0.08653788f, 0.07788885f, 0.12223969f, 0.23016444f, 0.24487852f, 0.16497013f, -0.03893400f, 
    0.17052804f, 0.15908790f, 0.15169327f, -0.15374704f, 0.27182785f, 0.24494876f, -0.07159712f, 0.04321273f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21104698f, 0.19312260f, -0.06250814f, -0.11577126f, 0.03182199f, 0.08771738f, 0.17660241f, 0.13400991f, 
    -0.07076668f, 0.08573149f, 0.04213845f, 0.09861424f, -0.22215991f, 0.29549757f, -0.14950655f, -0.29031271f, 
    -0.07306929f, -0.17811593f, -0.01194164f, -0.02772019f, 0.01166215f, -0.07272091f, 0.04039598f, 0.09312972f, 
    0.24151459f, -0.09361773f, 0.19259527f, 0.20477119f, 0.12103585f, 0.07643885f, -0.04895066f, -0.07243549f, 
    -0.04368441f, -0.07169339f, -0.12248649f, -0.22201163f, 0.78782356f, -0.17781843f, 0.18163130f, -0.17072837f, 
    -0.03368957f, 0.23732224f, 0.05760478f, 0.05956875f, 0.03884167f, 0.18558931f, -0.02185420f, -0.07837987f, 
    0.17994535f, 0.04616895f, -0.10460275f, 0.27045882f, 0.04589925f, 0.11514087f, -0.10950828f, 0.01652617f, 
    -0.12632366f, 0.08264664f, 0.06023872f, 0.05076279f, -0.49435079f, 0.07146724f, -0.12644307f, -0.14946163f, 
    -0.09149612f, 0.00912851f, 0.12793015f, 0.13818221f, -0.18374059f, 0.11384290f, 0.06678841f, 0.06202721f, 
    -0.49846986f, 0.04296774f, 0.22409134f, -0.20532304f, -0.00788838f, 0.17564397f, 0.01074427f, -0.10720569f, 
    -0.13996461f, -0.13682312f, 0.06310475f, 0.05548571f, 0.25661802f, 0.15355189f, -0.03029985f, 0.12309150f, 
    0.08436280f, 0.16504183f, 0.03900487f, 0.22011343f, -0.04538173f, -0.01224432f, 0.03806335f, -0.22349046f, 
    -0.12909350f, -0.21961264f, 0.10707698f, -0.11865504f, -0.05226934f, -0.00487650f, 0.04020653f, 0.01392710f, 
    -0.06142195f, 0.11316569f, -0.04790783f, 0.02694714f, 0.30520689f, 0.06715610f, 0.01783402f, -0.20345540f, 
    0.10749289f, -0.03592480f, -0.02209828f, -0.05894801f, -0.12650153f, 0.12581220f, 0.23466694f, -0.23275125f, 
    0.22876376f, 0.04318108f, -0.03657384f, 0.16191709f, 0.10378376f, -0.09210952f, -0.03635909f, 0.04768388f, 
    -0.14958428f, 0.01548788f, -0.10205247f, -0.05229663f, -0.12376107f, -0.28631771f, 0.13032110f, 0.03286244f, 
    0.01393847f, 0.00734164f, 0.08091425f, 0.20134619f, 0.03995470f, -0.07213024f, 0.00457354f, 0.17224133f, 
    0.07298318f, 0.07627076f, -0.22563538f, 0.23609231f, 0.05258456f, -0.04688280f, -0.02098336f, -0.04778484f, 
    -0.15225747f, 0.11002588f, -0.06841080f, 0.11353332f, 0.08804371f, 0.05858900f, 0.07738731f, -0.02339270f, 
    0.04727884f, -0.07342333f, -0.18956107f, 0.03055738f, -0.11120984f, 0.03568742f, 0.13801029f, -0.11759496f, 
    0.36592409f, -0.09206711f, 0.02545422f, 0.12812530f, -0.03359867f, 0.00749483f, 0.07533504f, -0.00068834f, 
    0.09163409f, -0.00630538f, 0.02525556f, -0.03004255f, 0.26182449f, 0.32343367f, -0.05717788f, 0.10194881f, 
    0.03498313f, 0.09308729f, 0.05322931f, -0.13203271f, 0.00577562f, 0.24652719f, 0.17374055f, 0.07315964f, 
    -0.04093913f, 0.01288220f, -0.03601490f, 0.01486073f, -0.05996425f, 0.04913292f, 0.05882074f, -0.02132636f, 
    0.01929698f, 0.00398076f, 0.05030634f, -0.06537537f, -0.04930045f, 0.01105959f, -0.01243261f, -0.05964266f, 
    0.01687367f, -0.08628600f, -0.01580072f, 0.03510864f, -0.04958239f, -0.06472261f, -0.03404038f, 0.05991413f, 
    -0.01148207f, 0.04212657f, 0.05398849f, -0.01009365f, -0.07618593f, -0.03438342f, -0.07122684f, 0.06306871f, 
    0.06216823f, -0.03804297f, 0.03975483f, 0.04250849f, 0.04250158f, 0.01242944f, -0.02019014f, -0.05394829f, 
    -0.02330484f, 0.00836357f, -0.03816064f, -0.04497148f, -0.04574309f, 0.00865868f, 0.05689942f, 0.00467785f, 
    -0.04581894f, -0.01622522f, -0.08261350f, -0.06177060f, 0.02074537f, -0.01146861f, 0.01009340f, -0.00673788f, 
    -0.07950307f, 0.01605642f, -0.00930185f, 0.02821217f, 0.04979942f, 0.05960461f, -0.03911725f, -0.06626330f, 
    -0.02258241f, -0.07609107f, -0.02233203f, 0.05745187f, 0.04329748f, -0.03264213f, -0.02946579f, 0.01230385f, 
    0.03107719f, -0.06441800f, 0.00290574f, -0.02574527f, 0.00400469f, 0.03406978f, -0.04785777f, -0.05160234f, 
    -0.06375811f, 0.05301574f, -0.04452350f, 0.03852955f, -0.00787343f, -0.00490887f, -0.01692014f, 0.03244461f, 
    -0.02915115f, -0.04975618f, -0.06935102f, -0.07188684f, 0.05768637f, -0.02589293f, -0.05993682f, -0.05550504f, 
    0.05647521f, 0.00582052f, -0.03650589f, 0.03177895f, 0.06329714f, -0.02972152f, -0.04980709f, 0.00890506f, 
    0.04518546f, 0.05384257f, -0.01491554f, -0.06656809f, -0.00132825f, 0.02623169f, -0.06242994f, 0.05232394f, 
    0.04617903f, -0.01127141f, 0.04063980f, -0.04538787f, -0.07530411f, -0.00963493f, -0.04039136f, -0.06412740f, 
    0.03391008f, -0.03917992f, -0.00572807f, -0.05071067f, -0.00112557f, -0.02032624f, -0.06730330f, 0.00160072f, 
    0.03436321f, -0.03219304f, 0.03767227f, -0.06942196f, -0.00883217f, 0.03334990f, 0.02196470f, 0.03257180f, 
    -0.02697306f, -0.01642451f, -0.05708451f, 0.05757301f, -0.07890660f, 0.03146774f, 0.01857217f, 0.05533569f, 
    0.00801423f, 0.05169129f, -0.01537709f, -0.02253968f, 0.02248573f, -0.01491107f, -0.00913432f, -0.00163700f, 
    0.02694295f, -0.02865460f, 0.03167651f, -0.03576827f, -0.07600429f, -0.01332419f, 0.05568241f, 0.02871045f, 
    -0.07963285f, -0.07364912f, -0.03037943f, 0.01403967f, -0.01403086f, 0.01402589f, 0.01841271f, -0.02830374f, 
    0.05293076f, -0.02020041f, -0.06296040f, -0.07717141f, -0.01413026f, 0.01693230f, 0.03182317f, -0.03664096f, 
    0.03859447f, -0.01323288f, 0.04451733f, -0.06552663f, 0.06336089f, 0.00555171f, -0.05254437f, 0.07059387f, 
    -0.01351727f, -0.00070476f, -0.02495375f, 0.04374007f, -0.01788767f, -0.07274330f, -0.04821140f, -0.00786659f, 
    -0.01073999f, -0.02704477f, 0.01853656f, 0.03751251f, -0.04566028f, -0.02788584f, -0.07021392f, 0.06274536f, 
    -0.06125270f, 0.04012729f, 0.03228532f, -0.00630010f, 0.02415956f, -0.03037663f, -0.01391782f, -0.06117191f, 
    -0.06880437f, -0.00075274f, 0.03203951f, 0.00643584f, 0.00018889f, 0.06306669f, 0.02003819f, -0.02259797f, 
    0.05950687f, -0.06491603f, -0.06168491f, 0.04367119f, -0.06297958f, 0.04891612f, 0.05598299f, 0.04369944f, 
    -0.02195226f, -0.06158449f, 0.02591370f, -0.01496082f, -0.00727133f, -0.06446361f, 0.00159808f, 0.06463174f, 
    -0.07699788f, 0.04034702f, -0.06861496f, 0.00286150f, -0.02261919f, -0.04565561f, 0.06578739f, -0.01404351f, 
    0.00374658f, 0.03389182f, -0.05856008f, 0.01447333f, 0.03047504f, -0.02174269f, 0.02127708f, 0.01142561f, 
    -0.05747057f, 0.00784747f, -0.05815421f, 0.02400259f, 0.05178846f, -0.02914624f, 0.05481711f, -0.01954501f, 
    0.01214035f, -0.07778650f, 0.05236058f, 0.03919324f, -0.04716370f, 0.03141465f, -0.04275596f, 0.02794337f, 
    0.05397778f, 0.03172139f, 0.04933142f, 0.03410232f, 0.04540228f, -0.00330632f, -0.02969518f, -0.01944120f, 
    -0.01166038f, -0.01415497f, 0.06558353f, -0.07421192f, -0.01054288f, 0.05202794f, 0.01406216f, -0.04818152f, 
    0.01731014f, -0.06232341f, 0.05258846f, -0.00323632f, -0.06416250f, -0.04584768f, -0.02809627f, -0.05135535f, 
    -0.05082228f, -0.00602782f, 0.00236741f, -0.02157556f, -0.02012964f, -0.07271878f, -0.07622524f, 0.05675119f, 
    0.06327344f, -0.04544841f, -0.02714437f, -0.03277308f, -0.04697650f, 0.05235899f, 0.00221961f, -0.05336528f, 
    -0.06665429f, -0.03712796f, 0.06424063f, -0.06680861f, 0.04447970f, 0.05588448f, -0.05475131f, -0.00490135f, 
    -0.05414736f, -0.02628015f, 0.02738814f, -0.04035701f, -0.06065296f, -0.02004897f, 0.01218271f, -0.02167027f, 
    0.06583332f, 0.02115638f, -0.03588527f, -0.00942527f, -0.03692493f, -0.05009679f, -0.04386943f, 0.00302965f, 
    0.06147790f, 0.02265345f, -0.04810033f, -0.00035064f, -0.01599942f, 0.03207008f, 0.01257982f, -0.01837042f, 
    -0.03550324f, 0.03463839f, -0.04083668f, -0.02547062f, -0.05071643f, -0.07704119f, -0.05872801f, -0.02240124f, 
    -0.03164212f, -0.05980613f, -0.03408171f, 0.02400747f, -0.03790523f, 0.02868876f, 0.06047709f, -0.05760786f, 
    -0.06606510f, 0.01032032f, -0.06577101f, 0.02153522f, -0.03288937f, -0.02791423f, -0.02653540f, 0.02906387f, 
    -0.00405648f, 0.03578153f, -0.02849944f, 0.00422970f, 0.02470056f, 0.03466913f, -0.04613123f, -0.06668586f, 
    -0.00586077f, 0.03925722f, 0.06144192f, -0.05997597f, -0.07715431f, 0.03236702f, -0.06451019f, 0.01296354f, 
    -0.00337050f, 0.00056947f, 0.03386702f, -0.07147003f, -0.03778119f, 0.01400207f, -0.06506262f, -0.05328734f, 
    -0.20540072f, -0.17036520f, 0.03707432f, 0.33090428f, -0.06212360f, 0.06792455f, 0.19548939f, 0.14370719f, 
    -0.04472772f, 0.29260206f, -0.03799035f, 0.01602723f, -0.34827906f, 0.02183010f, 0.06325391f, -0.26862884f, 
    0.24019456f, -0.02920096f, -0.08058648f, -0.05647178f, -0.00696603f, 0.00945731f, 0.03256641f, -0.02277231f, 
    -0.21109402f, 0.12091461f, -0.03349661f, -0.04561220f, 0.03092794f, 0.07593796f, 0.10635591f, 0.08644849f, 
    0.16014460f, -0.02176709f, -0.02095515f, -0.15678628f, 0.53913867f, -0.14545485f, 0.16675094f, -0.46155030f, 
    0.15346771f, -0.10781377f, 0.06269187f, 0.07929116f, -0.03991525f, 0.18149966f, -0.02678495f, 0.00653077f, 
    0.07052109f, 0.11690329f, -0.14839195f, 0.03291920f, 0.04086922f, -0.03128650f, -0.06986433f, 0.02346358f, 
    -0.00664835f, 0.03997160f, 0.16143045f, 0.03750354f, -0.38292778f, 0.11155301f, 0.24440710f, -0.33790573f, 
    0.17248397f, 0.15122919f, 0.04812570f, -0.01332886f, -0.03251222f, 0.01363366f, 0.03916550f, 0.15691260f, 
    -0.46821037f, 0.25019413f, -0.13248970f, 0.02854450f, -0.07622778f, 0.03458275f, 0.02264050f, -0.12155782f, 
    -0.17999814f, 0.03601321f, 0.03140336f, -0.01446425f, 0.55846035f, -0.21416566f, 0.03647897f, -0.19815680f, 
    -0.10691113f, -0.00615670f, 0.01265150f, 0.16058347f, 0.08206599f, 0.10167051f, 0.03274404f, -0.06663819f, 
    0.35857025f, -0.13949926f, -0.12853976f, -0.01386013f, 0.11335725f, -0.10205950f, 0.04336933f, 0.00601703f, 
    0.08388455f, 0.08658756f, -0.03373579f, 0.14623675f, 0.08038725f, -0.16496015f, 0.26834816f, -0.09499390f, 
    -0.05631224f, 0.04960321f, 0.02508333f, -0.05797790f, 0.14029005f, 0.08991482f, -0.05647260f, -0.23340800f, 
    0.37086159f, -0.27925560f, 0.13010646f, 0.04061197f, 0.16789728f, -0.00453102f, 0.00969341f, 0.01132018f, 
    -0.02876164f, -0.08235803f, -0.06194770f, -0.06648533f, -0.26104072f, 0.18665342f, -0.13888121f, 0.09209637f, 
    -0.10921762f, 0.01338450f, 0.03272608f, 0.13309985f, 0.19343466f, -0.02708608f, 0.05485210f, 0.15514082f, 
    -0.21089277f, -0.03838411f, 0.19116962f, -0.09100451f, 0.11025196f, 0.08835692f, -0.02802044f, -0.14952512f, 
    0.06635156f, 0.01485211f, -0.01347192f, 0.04304058f, 0.16488874f, -0.11024230f, 0.11338653f, -0.03030497f, 
    -0.07625560f, 0.16303614f, 0.02739907f, -0.09724108f, -0.20128195f, 0.12748699f, 0.12715045f, -0.06957572f, 
    0.24092612f, -0.24789555f, 0.06526000f, 0.31182873f, -0.04844951f, -0.09227473f, 0.06232148f, 0.00689061f, 
    0.02771287f, -0.04577298f, 0.16403900f, -0.03795319f, -0.07904398f, -0.08296433f, 0.20027602f, 0.18412267f, 
    0.06095204f, -0.06254666f, 0.06599727f, -0.00100977f, -0.04841951f, 0.20843889f, 0.19562593f, 0.11783066f, 
    0.26058859f, 0.11076540f, 0.07743325f, -0.09540748f, -0.16155280f, -0.09108111f, -0.02354822f, -0.08443156f, 
    0.16537429f, -0.20220280f, 0.00660694f, -0.28195822f, 0.18199445f, -0.31184655f, -0.21556672f, 0.40414336f, 
    0.08115438f, 0.13209750f, -0.08569690f, -0.00773649f, -0.06836811f, 0.07224397f, 0.09697028f, 0.14449684f, 
    -0.01361239f, -0.20433408f, -0.02433399f, 0.18012588f, 0.05166545f, -0.08290419f, 0.01952870f, 0.04547057f, 
    -0.00704620f, 0.22907495f, 0.04096262f, 0.12807791f, -0.47719282f, 0.07272741f, -0.09143541f, 0.30793479f, 
    -0.12465879f, 0.03792036f, 0.03212425f, -0.06162588f, 0.06474671f, -0.04959500f, 0.04637104f, 0.02955937f, 
    -0.27694258f, -0.11148594f, 0.02994562f, -0.30198672f, -0.01808414f, 0.12404693f, 0.08071331f, 0.01026116f, 
    0.08553330f, -0.09589088f, 0.04117795f, 0.04023691f, 0.21443476f, -0.34269708f, -0.06500146f, 0.27445060f, 
    0.21795484f, 0.00926199f, -0.15075612f, -0.02008029f, 0.16367751f, 0.07096394f, -0.05577435f, -0.09397878f, 
    0.33103919f, -0.22850586f, -0.01277278f, 0.05208758f, 0.20906091f, -0.04517530f, -0.17351508f, -0.00980931f, 
    0.06940870f, 0.03212936f, 0.03063431f, 0.14735001f, -0.07893736f, 0.01606691f, -0.08023966f, -0.10684958f, 
    0.07172181f, -0.11098210f, 0.10286538f, 0.02280306f, 0.17310269f, -0.00737049f, 0.05666066f, 0.04611314f, 
    -0.17479889f, 0.27906850f, 0.01666084f, 0.01954456f, 0.23839036f, 0.06492138f, -0.09385619f, 0.05275990f, 
    0.01155325f, 0.09712011f, 0.13114181f, 0.00460719f, 0.24537878f, -0.00700658f, 0.06696261f, 0.06849154f, 
    0.06107948f, -0.06875453f, 0.01231570f, 0.11687315f, -0.03983635f, -0.04516808f, -0.05041929f, 0.20598680f, 
    -0.11306528f, 0.29084629f, -0.26593664f, -0.07922551f, -0.01817631f, 0.05052949f, 0.06820015f, -0.05554966f, 
    0.12156647f, 0.05729411f, 0.13026838f, 0.20187360f, 0.18467590f, -0.02024122f, 0.12827669f, 0.12247439f, 
    0.08003441f, 0.05112981f, -0.15333402f, -0.04832888f, 0.03732916f, -0.08560731f, 0.04058674f, 0.06914913f, 
    0.40032256f, 0.07190923f, -0.05430833f, -0.08035759f, 0.18111899f, 0.15952682f, 0.10147434f, -0.00142111f, 
    0.09064916f, 0.10285941f, 0.17175207f, -0.04274159f, -0.23343836f, 0.09357933f, 0.13448094f, -0.08313934f, 
    0.08978185f, 0.04790305f, 0.01814372f, 0.09003954f, 0.10004576f, -0.03128858f, 0.00067440f, 0.13395903f, 
    0.21566398f, 0.12010957f, 0.07185308f, -0.17619066f, 0.00901369f, -0.02877799f, 0.11173025f, 0.18431543f, 
    -0.05121472f, 0.12942445f, -0.01135086f, -0.10110032f, -0.19642889f, -0.26040214f, -0.08097713f, -0.09401537f, 
    -0.07466213f, -0.07783232f, 0.02169006f, 0.12513734f, 0.11338465f, -0.06581582f, -0.03354416f, -0.06811488f, 
    0.34525666f, 0.10509247f, -0.07479766f, -0.25715756f, 0.13211790f, -0.09751592f, 0.03235826f, 0.02973086f, 
    0.11001892f, -0.02038968f, 0.08876722f, -0.04855637f, -0.16591316f, 0.06782098f, -0.01760923f, -0.10362305f, 
    -0.22213803f, -0.05017996f, -0.03834852f, 0.07212077f, -0.04134063f, -0.00814935f, -0.09124175f, -0.00968120f, 
    0.31986338f, 0.09367803f, -0.12007505f, -0.05613900f, 0.06340954f, 0.04491151f, 0.04641539f, 0.08276917f, 
    -0.07460514f, 0.01835453f, -0.06595120f, -0.01538365f, 0.02709365f, -0.02194025f, -0.06229315f, 0.41366664f, 
    -0.09130085f, 0.07184440f, 0.09139791f, 0.07077097f, -0.01808617f, -0.03467612f, 0.11411572f, 0.09588858f, 
    -0.25883913f, 0.02757783f, -0.10606342f, 0.11173935f, -0.02370569f, -0.07092523f, -0.01990981f, 0.01821102f, 
    0.00584935f, -0.03547388f, 0.04149381f, 0.02510245f, -0.04049587f, -0.13722232f, -0.02273795f, -0.01693224f, 
    -0.07490817f, -0.04069832f, -0.03945133f, -0.03634630f, 0.17776968f, 0.08221968f, -0.11624192f, 0.10797472f, 
    -0.07301642f, -0.11019994f, -0.18293944f, 0.00546882f, -0.10518339f, -0.10331376f, -0.08584897f, 0.01788778f, 
    0.08255477f, -0.00644464f, 0.04861897f, 0.06282817f, -0.66751039f, 0.09153778f, 0.17806928f, 0.36168444f, 
    0.10466295f, 0.05179397f, -0.02564576f, -0.10059069f, 0.03769689f, -0.01449495f, 0.00896708f, 0.05599764f, 
    0.12145701f, -0.07739194f, 0.10616922f, -0.00898663f, 0.17633165f, 0.22907251f, -0.10658973f, 0.05133397f, 
    0.04152813f, 0.08472725f, 0.00753969f, 0.05633631f, 0.49993384f, 0.37622941f, -0.31812555f, 0.33629176f, 
    0.18265875f, 0.01204101f, -0.02710606f, 0.28684840f, -0.14897326f, -0.08846612f, 0.14646241f, 0.06111269f, 
    -0.35097274f, -0.03169174f, 0.16719088f, -0.01224902f, -0.00063878f, 0.06214983f, 0.09180665f, 0.17332996f, 
    0.07938006f, -0.00711151f, 0.00451146f, -0.06097873f, 0.02751346f, 0.06409980f, 0.03703986f, 0.17778176f, 
    -0.05478193f, 0.05990582f, -0.28309083f, 0.06989743f, -0.18082403f, 0.09422517f, -0.04276768f, 0.02538999f, 
    0.01435333f, -0.01587687f, -0.12585796f, 0.13270350f, -0.01355946f, 0.01349929f, 0.06711332f, 0.00173103f, 
    -0.04105767f, 0.05317874f, 0.04199858f, 0.20217808f, 0.13728385f, 0.28695074f, 0.36314869f, 0.06231465f, 
    0.14498261f, 0.18582159f, -0.01870018f, -0.00838675f, -0.03360234f, -0.07286732f, 0.18673928f, -0.18428141f, 
    0.37402016f, -0.10285456f, -0.07669371f, -0.13880444f, 0.06832435f, 0.01858885f, -0.12930210f, -0.06221996f, 
    -0.03590648f, 0.21191449f, -0.07787837f, -0.01630828f, -0.20940617f, 0.03259185f, -0.00836592f, 0.29743138f, 
    -0.14534584f, 0.09981452f, 0.05437935f, 0.15486979f, -0.04049235f, -0.09129700f, 0.03332330f, 0.05296088f, 
    -0.18457703f, 0.04312833f, 0.17899194f, 0.09836421f, 0.08371808f, -0.03908711f, 0.15546007f, 0.13917334f, 
    -0.04192419f, 0.13036846f, 0.12200334f, 0.10198031f, 0.07213241f, 0.06573562f, 0.00403226f, 0.00163892f, 
    -0.19296622f, 0.07096066f, 0.01783824f, 0.02868783f, 0.13345565f, 0.06733497f, -0.06256316f, -0.19472390f, 
    0.06559985f, 0.22546786f, -0.06483374f, 0.02788485f, 0.03752829f, 0.01572259f, 0.04855282f, 0.12754746f, 
    0.03691840f, -0.09322491f, 0.00854586f, 0.02327850f, -0.17560250f, 0.11374394f, -0.05245590f, 0.12237793f, 
    0.03863248f, 0.02773729f, -0.01150861f, 0.00675121f, -0.15185528f, 0.12987185f, -0.09237035f, 0.10827739f, 
    0.44600829f, 0.11383682f, -0.03828612f, -0.09949574f, 0.00301829f, 0.02257027f, 0.00099530f, 0.05715796f, 
    -0.03664026f, -0.13167515f, 0.00712735f, 0.03304548f, 0.32505602f, 0.23101571f, -0.13655712f, 0.04488905f, 
    0.00570252f, -0.01016600f, 0.02438814f, 0.06812693f, 0.11718354f, 0.03745951f, -0.11265817f, -0.01925229f, 
    0.17424569f, -0.04534313f, -0.45550629f, 0.05113653f, -0.11824980f, 0.04473432f, 0.08292935f, 0.02302380f, 
    0.20425345f, 0.04488797f, -0.01440683f, -0.09060537f, -0.13319172f, -0.03581058f, 0.35747230f, -0.04932301f, 
    0.00587598f, 0.02937504f, -0.13089110f, -0.10279039f, 0.08257970f, -0.03303093f, 0.08545171f, 0.13811134f, 
    0.00795915f, -0.05383874f, 0.00162705f, 0.13632502f, 0.02521963f, -0.11247723f, 0.12484638f, -0.02034582f, 
    0.12930556f, -0.04546432f, -0.03879652f, -0.00715098f, -0.20215872f, -0.08687057f, -0.20694166f, 0.25461200f, 
    -0.05290023f, -0.01763039f, -0.05311043f, 0.15021034f, 0.11754903f, -0.18777452f, -0.02055282f, -0.09033376f, 
    -0.35150191f, -0.03468373f, 0.30072623f, -0.02875114f, 0.09336177f, 0.04939464f, 0.09828664f, -0.02164028f, 
    -0.02108516f, -0.13492161f, -0.13245878f, -0.23582116f, 0.00139931f, 0.41090152f, -0.03359346f, 0.11988341f, 
    -0.13016041f, -0.14421213f, -0.00793135f, 0.11580928f, -0.12544394f, 0.29511854f, 0.13880537f, -0.09282768f, 
    -0.06569037f, -0.08331034f, -0.01378716f, -0.15132956f, -0.15424946f, -0.14251639f, -0.12452620f, -0.20862305f, 
    0.06599086f, 0.06869347f, -0.04545169f, 0.07611202f, 0.18779150f, -0.10523048f, 0.03193637f, 0.17144579f, 
    -0.12755021f, -0.06143752f, -0.07463160f, 0.10686778f, -0.04960113f, 0.09372908f, 0.07042323f, -0.13513502f, 
    -0.15397552f, 0.05992526f, 0.14936708f, -0.08145496f, 0.21824825f, 0.07374460f, -0.09928343f, -0.08658259f, 
    -0.05373191f, -0.14598560f, -0.14646149f, -0.02971655f, 0.03160169f, 0.05899996f, 0.03763046f, -0.06431977f, 
    0.03750994f, 0.07972893f, 0.10017543f, -0.00165696f, -0.01878213f, -0.05493438f, 0.02906322f, 0.18709151f, 
    -0.07711595f, 0.04752524f, -0.07423617f, -0.06411775f, -0.07671992f, 0.02277226f, -0.03777990f, -0.03792836f, 
    -0.03131607f, -0.06064154f, -0.06209850f, -0.06197429f, -0.06438374f, 0.05857610f, -0.04832272f, 0.03831031f, 
    0.05538020f, -0.05088042f, -0.02542314f, 0.04540935f, -0.02654423f, 0.00719217f, -0.02791605f, 0.03986219f, 
    -0.02893544f, -0.05929242f, 0.02377105f, 0.00458045f, -0.04948217f, -0.05812927f, 0.07060573f, -0.06596111f, 
    -0.02673442f, -0.06936546f, 0.06372882f, 0.01862003f, 0.04273078f, -0.04069037f, -0.07313534f, 0.01074288f, 
    0.00185378f, 0.05990908f, -0.02725802f, 0.03269818f, -0.03141570f, -0.05691896f, -0.06253634f, 0.03860223f, 
    -0.03470591f, 0.02258190f, 0.05762425f, 0.02644262f, 0.02826793f, 0.01761732f, -0.03835766f, 0.02507403f, 
    -0.03913826f, -0.04310815f, -0.02265762f, -0.04565696f, 0.01970762f, 0.00502878f, -0.02909973f, 0.05213673f, 
    -0.04549868f, -0.01997139f, 0.05786868f, -0.01327202f, -0.06923515f, 0.06404365f, 0.01340842f, 0.00221232f, 
    -0.04197361f, -0.02579734f, -0.06958944f, 0.02300967f, 0.05325024f, 0.04616015f, -0.05747281f, 0.03836149f, 
    0.04826359f, 0.04424395f, -0.03688424f, 0.02588975f, -0.03760464f, 0.06472459f, -0.03881827f, -0.06197239f, 
    -0.01596318f, 0.00192315f, 0.04347083f, -0.06135011f, -0.00577275f, 0.02196708f, 0.02049497f, -0.05693805f, 
    -0.05599269f, 0.01121464f, -0.00038837f, 0.04784480f, -0.01714831f, -0.06552780f, -0.02508398f, 0.00023061f, 
    0.05148428f, -0.00901881f, -0.01156646f, -0.07144469f, 0.00075946f, 0.00394305f, -0.01445512f, 0.01710673f, 
    0.02570005f, -0.01052831f, -0.00882313f, 0.01153724f, 0.04190318f, -0.05285697f, 0.02084474f, -0.04620874f, 
    0.00063457f, -0.04263281f, 0.01504320f, 0.01824115f, -0.02595211f, -0.03548652f, -0.00273795f, -0.02174293f, 
    -0.01022782f, 0.05238439f, -0.07449110f, -0.00114074f, -0.04340256f, -0.04726233f, -0.06048516f, -0.00002164f, 
    -0.00476081f, 0.04569507f, -0.01521172f, 0.04013719f, -0.07178114f, -0.06663541f, -0.04596242f, -0.02119501f, 
    -0.04745227f, -0.00619642f, 0.05026393f, 0.04995726f, -0.04653538f, -0.04686034f, 0.02806730f, 0.03718876f, 
    0.02582845f, 0.02217639f, 0.01049841f, -0.00064127f, -0.02867618f, -0.04320676f, -0.04618755f, 0.06146957f, 
    0.04143118f, 0.01029937f, -0.00524733f, 0.05468716f, 0.02539708f, 0.02706591f, 0.02608389f, -0.06406201f, 
    0.06163763f, -0.07130456f, -0.03449341f, 0.00334820f, -0.02275428f, -0.04761787f, 0.04488710f, 0.04707655f, 
    0.06063366f, -0.05759113f, -0.00293591f, -0.03074665f, -0.05348356f, 0.02082752f, 0.02040965f, -0.04898217f, 
    0.01448312f, -0.07414787f, 0.06803553f, 0.04100155f, 0.02621583f, -0.03981857f, -0.05141257f, 0.01883644f, 
    0.29037204f, -0.06661641f, -0.09053936f, -0.43059447f, -0.04063074f, -0.09971520f, -0.14207180f, -0.17531407f, 
    0.18626763f, -0.11294591f, -0.07001632f, 0.07496202f, 0.12585874f, 0.11966877f, 0.00856267f, 0.09006068f, 
    -0.08268069f, -0.06290137f, 0.07271305f, 0.08212476f, -0.07013128f, 0.04006952f, 0.03270777f, 0.06039360f, 
    0.32483494f, -0.03242436f, -0.03558909f, -0.15088823f, 0.09751929f, 0.09576830f, -0.00216220f, 0.02768843f, 
    0.03811673f, 0.09769990f, -0.05979314f, -0.03806384f, 0.06551256f, -0.27464536f, 0.14602292f, 0.43684554f, 
    -0.05858823f, 0.06781066f, 0.15486194f, -0.05759704f, 0.15536620f, -0.03218900f, 0.06433660f, -0.07742120f, 
    -0.11950149f, -0.07349337f, -0.05522682f, -0.31628013f, 0.06809534f, 0.10899465f, -0.03894396f, -0.02844293f, 
    0.01676243f, 0.12861629f, -0.03808108f, 0.00138150f, -0.23431107f, -0.24908277f, 0.02769453f, 0.28766420f, 
    -0.00460614f, -0.16693474f, 0.00039704f, 0.00978422f, 0.01830674f, 0.10120030f, -0.05279488f, -0.01537723f, 
    0.02410383f, -0.27951249f, 0.05446263f, -0.04010319f, -0.04767743f, -0.13550843f, -0.11963089f, 0.08386145f, 
    0.02975068f, 0.06683114f, 0.01876897f, 0.18642810f, -0.66119748f, 0.06160304f, -0.21056649f, 0.20401376f, 
    0.04212100f, 0.06377082f, 0.08290654f, -0.10487956f, -0.01213339f, -0.00354143f, 0.02184416f, 0.03731541f, 
    -0.09519526f, 0.03301638f, 0.02289477f, 0.05814728f, 0.06042839f, 0.24645413f, -0.12130959f, 0.05428670f, 
    -0.01665948f, 0.08236953f, 0.06018268f, 0.10084083f, 0.27048290f, 0.11027092f, -0.25845677f, 0.10831588f, 
    0.05990530f, -0.09553317f, 0.07010204f, 0.36566627f, -0.15262794f, -0.05080752f, 0.19635776f, 0.08735327f, 
    -0.32564253f, 0.14498113f, -0.05100947f, -0.17085071f, 0.12642395f, -0.01821777f, 0.11736722f, 0.17566335f, 
    0.14542198f, -0.00436473f, 0.15261386f, 0.09721998f, 0.18350656f, -0.24276489f, 0.05654360f, 0.00729410f, 
    0.04675386f, 0.08004667f, -0.19679187f, -0.00130660f, -0.09588233f, -0.08681862f, -0.04532585f, 0.14420089f, 
    0.01425955f, 0.07370387f, -0.03927033f, 0.11570157f, 0.08048399f, 0.06991928f, 0.13061082f, 0.15200144f, 
    0.03331175f, 0.05472959f, 0.00361366f, 0.18668608f, -0.20224066f, 0.04270158f, 0.11844109f, -0.21488965f, 
    0.19581100f, 0.04681379f, -0.03132639f, -0.09030069f, 0.02725566f, 0.01987566f, 0.12324142f, -0.02095928f, 
    0.34877625f, -0.07270819f, -0.17121975f, -0.19948876f, -0.01969923f, 0.01955209f, -0.04639066f, -0.12361218f, 
    0.05866568f, 0.08136851f, -0.01298279f, 0.14335962f, -0.05086758f, -0.02935362f, -0.04526271f, 0.28216094f, 
    -0.02021012f, 0.00958526f, 0.03459427f, 0.04775974f, 0.03769223f, -0.01551040f, -0.04993576f, -0.04293481f, 
    -0.00573149f, 0.04554066f, -0.06301890f, 0.04297208f, -0.06856021f, 0.05378821f, -0.06721725f, -0.00375878f, 
    -0.00321347f, 0.04130042f, 0.06224492f, -0.05556900f, -0.01310687f, -0.00842997f, -0.02136423f, -0.00235507f, 
    -0.02592550f, 0.03814675f, -0.00525988f, 0.02117031f, 0.00943723f, -0.04962745f, -0.05380761f, 0.00290347f, 
    0.00616630f, -0.01806708f, -0.05416594f, 0.03774842f, -0.04848189f, -0.07939673f, 0.04863616f, 0.00209610f, 
    0.01030821f, -0.00192294f, -0.04200418f, -0.05361044f, -0.02877798f, 0.05690666f, -0.00438021f, 0.05934703f, 
    0.05458749f, -0.02844461f, -0.01226671f, -0.07197771f, -0.00845789f, 0.06123105f, 0.04173900f, -0.00615139f, 
    -0.02393528f, 0.04561048f, -0.01922077f, 0.01553652f, -0.05559531f, -0.07704832f, 0.04075293f, -0.01897508f, 
    -0.03152891f, 0.04646628f, -0.01393303f, -0.04465798f, -0.00771399f, -0.06210295f, 0.04939436f, 0.04734850f, 
    0.01895758f, -0.00250589f, 0.06129719f, 0.02778111f, -0.02755847f, 0.02515542f, -0.03706936f, -0.01147586f, 
    0.00584218f, -0.07225935f, 0.02783857f, 0.01255196f, 0.01645289f, 0.04024794f, -0.07684933f, -0.02620870f, 
    -0.07553942f, -0.03215585f, -0.00411744f, 0.02199814f, -0.04489985f, 0.03070893f, -0.06832992f, 0.04216591f, 
    -0.05501937f, 0.05311902f, 0.05886503f, 0.02855410f, -0.00769719f, -0.00042455f, 0.06522275f, -0.04513218f, 
    0.04352353f, -0.02881460f, -0.00409909f, 0.03563475f, -0.00150175f, -0.07845498f, 0.03870508f, 0.05167339f, 
    -0.05658963f, -0.06995229f, 0.03072397f, 0.03723739f, 0.00085742f, -0.07573234f, -0.07564914f, 0.01660989f, 
    0.01816589f, 0.03579590f, 0.00985310f, -0.04725754f, -0.07089167f, -0.06329717f, -0.00149070f, -0.03523457f, 
    0.01594235f, -0.00019682f, 0.03964660f, -0.01406871f, 0.00437278f, -0.07419703f, 0.00451736f, 0.03627704f, 
    -0.01562883f, -0.03508617f, -0.03027439f, -0.07595856f, -0.06451356f, 0.04517766f, -0.06982671f, 0.00385756f, 
    -0.01763944f, 0.00673287f, -0.03430945f, 0.02843620f, 0.03346060f, -0.05137523f, -0.03741303f, 0.03627336f, 
    0.03975119f, -0.04803614f, -0.03429923f, -0.01610814f, 0.01635888f, -0.02305310f, -0.01594394f, 0.04444513f, 
    -0.00260666f, -0.04326237f, -0.03169582f, -0.05647713f, -0.03162826f, -0.01811422f, -0.06159284f, 0.04128772f, 
    0.03802732f, -0.06138887f, -0.05113130f, -0.03724869f, -0.00573255f, 0.04628941f, -0.00093584f, -0.07926321f, 
    0.01070725f, 0.02254213f, -0.03797375f, -0.02063676f, -0.01494482f, -0.00303753f, -0.04218453f, -0.07509584f, 
    -0.04527463f, 0.04075141f, 0.01618398f, -0.02903322f, 0.03435842f, -0.07165860f, 0.04673434f, -0.02684658f, 
    -0.05998896f, 0.00044068f, 0.04663337f, -0.04524153f, -0.06041926f, 0.03791768f, 0.01994943f, 0.04897541f, 
    -0.21231790f, -0.35135466f, -0.00366335f, -0.04846044f, -0.10499360f, 0.06055457f, 0.02493279f, 0.08741488f, 
    0.02622322f, 0.17241086f, -0.03689503f, 0.21699902f, 0.10879774f, 0.04015394f, 0.19639318f, -0.12343420f, 
    0.09817816f, 0.05516947f, -0.07213068f, -0.03256472f, -0.08645090f, -0.04860187f, 0.02171929f, -0.00042397f, 
    -0.02472628f, 0.06227564f, -0.04048501f, -0.12820330f, 0.09764238f, 0.06373893f, 0.02471780f, -0.07892304f, 
    0.04488539f, -0.17099507f, -0.06059084f, -0.26542947f, 0.54342473f, -0.35700443f, 0.21779160f, -0.03685802f, 
    0.13822265f, -0.22856946f, 0.11173042f, 0.03581182f, 0.07255736f, 0.11315490f, -0.03014200f, 0.08677249f, 
    -0.15399735f, -0.00607766f, 0.01855834f, -0.13653550f, -0.06609352f, 0.00044662f, -0.17254144f, 0.08086499f, 
    0.02732540f, 0.03328969f, 0.15921985f, 0.17334007f, 0.40082854f, 0.20712303f, 0.10891035f, -0.35982868f, 
    -0.01183566f, 0.03282190f, 0.08249094f, -0.02057372f, -0.03404099f, 0.02422003f, 0.14471661f, 0.03786214f, 
    -0.21731444f, 0.35682341f, -0.02395950f, 0.11030519f, -0.15254638f, 0.10356521f, 0.06886759f, -0.04907413f, 
    -0.05104003f, 0.02586362f, -0.06883316f, -0.31263870f, 0.27607360f, 0.17333639f, -0.12506437f, 0.10478534f, 
    -0.04721600f, 0.04983535f, -0.01565802f, 0.03854735f, -0.00494592f, 0.14114942f, 0.12520275f, -0.10028808f, 
    0.21914475f, -0.17793059f, 0.13619679f, 0.22796305f, -0.08341032f, 0.06902642f, 0.11415926f, 0.07869926f, 
    -0.08262391f, 0.04057090f, 0.04688801f, 0.09238911f, 0.03911489f, 0.08253572f, 0.20694040f, -0.00100161f, 
    0.01799699f, 0.01740338f, 0.10680024f, -0.05996392f, 0.13922663f, 0.04123628f, -0.03702215f, -0.04317524f, 
    0.44073382f, -0.24017136f, -0.01188877f, -0.19951752f, 0.09843547f, -0.17663810f, 0.01478459f, 0.10993963f, 
    -0.13494553f, -0.05951497f, 0.02471668f, -0.07078043f, 0.10038754f, 0.20311651f, 0.07042204f, 0.07500900f, 
    0.26294228f, 0.03591858f, -0.01628726f, 0.09596220f, -0.03238447f, 0.10606239f, 0.00778320f, 0.02871772f, 
    0.36765417f, -0.07674272f, -0.17187689f, -0.10322713f, 0.15804224f, -0.02163231f, 0.03599967f, 0.01662844f, 
    -0.12949340f, -0.07566281f, 0.08490217f, 0.07804150f, -0.17467819f, -0.03681707f, 0.06942930f, -0.07802583f, 
    -0.05545717f, -0.02079813f, -0.11910175f, -0.08151134f, -0.15803024f, 0.03643905f, -0.10194191f, -0.09760037f, 
    0.16438125f, -0.47845095f, 0.13712449f, 0.30962741f, 0.15715230f, -0.04849019f, -0.04356420f, -0.23412363f, 
    -0.15419720f, -0.02490515f, -0.01483815f, 0.06453946f, -0.07374564f, -0.01764453f, 0.06914392f, 0.21628961f, 
    -0.12227156f, 0.01611934f, -0.01205849f, 0.02230262f, 0.03022344f, 0.09601761f, 0.07725120f, 0.15214658f, 
    -0.05878225f, 0.02514821f, 0.00889783f, -0.01636240f, -0.07199307f, -0.00881550f, 0.03091020f, 0.01631865f, 
    0.00833376f, -0.00869739f, -0.01679850f, 0.01553457f, 0.03193545f, -0.07875828f, 0.04696983f, 0.04769562f, 
    -0.05278701f, -0.04535894f, -0.06654301f, 0.02301665f, -0.06387954f, -0.07402490f, -0.00452700f, 0.03618302f, 
    0.02774690f, 0.05959180f, 0.05485621f, -0.06234645f, 0.00147843f, -0.07759231f, -0.02633422f, -0.06649549f, 
    0.03170222f, 0.05955242f, 0.01580100f, -0.03565642f, -0.05163407f, -0.00432260f, 0.05736426f, 0.02369038f, 
    -0.04476940f, -0.05770803f, 0.03547954f, -0.04408794f, -0.01475976f, -0.05918352f, -0.05700297f, -0.01498178f, 
    0.00162209f, 0.02598106f, -0.07037210f, -0.00145049f, 0.02697953f, -0.05967692f, 0.00805540f, -0.07125029f, 
    0.01711931f, -0.01702507f, 0.00667629f, 0.03959030f, -0.04247541f, -0.01565274f, 0.02579171f, 0.03702463f, 
    -0.02983464f, -0.04215727f, 0.04058753f, -0.05597934f, 0.00053559f, -0.04947851f, 0.02539203f, -0.07000208f, 
    0.05637202f, 0.04281685f, -0.04668133f, -0.05991406f, -0.03908473f, -0.07627325f, 0.01695085f, -0.04737010f, 
    0.06072501f, -0.08024973f, 0.02302806f, -0.00311825f, -0.00692779f, 0.00052190f, -0.02027562f, 0.02999217f, 
    -0.01385980f, -0.01301345f, 0.04051008f, 0.03416904f, 0.00053801f, -0.01542831f, -0.00241405f, 0.01998603f, 
    -0.02544069f, -0.03267182f, 0.06079770f, -0.05647849f, -0.04738264f, 0.02654381f, -0.06646326f, 0.02564101f, 
    -0.05980092f, -0.05762646f, -0.05472434f, 0.04796460f, 0.04317877f, 0.00285581f, 0.06154646f, 0.02716538f, 
    -0.02390807f, -0.00914851f, -0.00652257f, -0.06090426f, 0.03892210f, -0.05628097f, -0.01761970f, -0.00440279f, 
    0.02371238f, 0.02595527f, 0.06365158f, -0.02752109f, 0.00622170f, 0.02289400f, 0.03424907f, -0.05104105f, 
    -0.07677719f, -0.02340260f, -0.00194201f, -0.03260956f, 0.05741548f, -0.01955546f, 0.00608470f, -0.07580787f, 
    -0.08093451f, -0.00299754f, -0.02853855f, -0.03950179f, 0.06397650f, -0.03424452f, 0.03290057f, -0.05032807f, 
    0.04113250f, -0.06240308f, 0.05203129f, -0.02790895f, 0.04627687f, 0.00796859f, 0.03482415f, -0.00059656f, 
    0.04558161f, -0.01466030f, 0.02790377f, -0.07152756f, 0.01921441f, -0.04714921f, 0.06744552f, -0.01343925f, 
    -0.04548331f, 0.02772931f, -0.07874721f, -0.01570980f, -0.00853669f, -0.00648516f, -0.02658664f, 0.03917406f, 
    0.03406510f, 0.04922179f, -0.05781665f, -0.01970376f, -0.03715743f, -0.00443416f, -0.04841077f, -0.05083161f, 
    0.01563592f, -0.02029037f, -0.06858005f, 0.02432024f, 0.06243911f, -0.04869411f, -0.01489291f, -0.04650745f, 
    -0.07189780f, -0.03351287f, 0.02022437f, -0.02568082f, -0.00471811f, 0.03761556f, -0.05923176f, 0.06292912f, 
    -0.24154563f, 0.12912843f, 0.26647410f, 0.16907643f, 0.05682595f, 0.10463427f, 0.02152596f, 0.10872728f, 
    -0.04590759f, 0.15278670f, 0.10849822f, 0.06956531f, -0.07514504f, -0.12798521f, 0.13944644f, 0.22121881f, 
    0.12447810f, 0.13379984f, 0.04650771f, -0.07808560f, -0.04462349f, -0.10733739f, 0.03285059f, -0.19953242f, 
    -0.08073942f, 0.09932619f, -0.02074339f, -0.07285185f, -0.22121923f, 0.10248286f, 0.02909388f, 0.18425792f, 
    -0.05671313f, 0.10640879f, 0.05994631f, -0.05449717f, 0.15929694f, -0.01002471f, 0.03735239f, -0.24237943f, 
    0.11597172f, -0.15400262f, -0.04732480f, 0.05701682f, -0.08351558f, 0.09252642f, -0.16360989f, 0.03145156f, 
    0.07994340f, 0.23408820f, 0.15453750f, 0.10302946f, 0.05517142f, -0.15961418f, 0.14675619f, 0.09724072f, 
    -0.01811879f, -0.08407058f, 0.08546796f, -0.05338527f, 0.35934249f, 0.25922322f, 0.01334051f, 0.08604190f, 
    -0.01920591f, 0.00832729f, 0.11892578f, 0.07053201f, -0.15948676f, -0.14469425f, 0.14475320f, -0.01317265f, 
    0.27495545f, 0.18985413f, -0.14338253f, 0.02856974f, -0.08247860f, 0.07959858f, 0.02815633f, -0.10919961f, 
    -0.10554529f, 0.08511101f, -0.02960139f, -0.21250388f, 0.42984363f, -0.01111283f, 0.12556757f, -0.13535403f, 
    -0.01050972f, 0.01930018f, -0.02665620f, 0.01014450f, -0.05564435f, -0.02682901f, -0.01032319f, 0.16604233f, 
    0.24419715f, -0.05557773f, 0.19295362f, 0.25645170f, -0.06941082f, -0.27266714f, 0.09327234f, -0.19906729f, 
    0.07137275f, -0.13285989f, -0.01702108f, -0.00073375f, -0.52147532f, -0.18921018f, 0.26567522f, -0.01012192f, 
    -0.13236226f, 0.03547828f, -0.06871514f, -0.20611332f, 0.15854879f, 0.07395381f, -0.09516446f, -0.00431953f, 
    0.18233790f, -0.19479826f, 0.10346197f, 0.02880096f, 0.11839028f, -0.13381988f, -0.02704833f, -0.10389224f, 
    -0.06928159f, -0.01199133f, -0.05492048f, -0.05051659f, -0.03385296f, 0.43242091f, 0.01684752f, 0.01292193f, 
    -0.01068445f, 0.03089379f, 0.22519815f, -0.11070066f, -0.08240405f, 0.11746055f, 0.14896145f, -0.07142571f, 
    0.07963944f, -0.12191476f, -0.17802477f, -0.09827583f, -0.05986144f, -0.09435629f, -0.08104896f, 0.01328333f, 
    -0.06281701f, -0.04627297f, -0.04353466f, -0.01716780f, 0.13194558f, -0.20795207f, 0.00871507f, 0.15212746f, 
    -0.13378209f, 0.04021964f, -0.02869393f, 0.14739145f, 0.03759607f, 0.12844543f, -0.20780407f, 0.01443805f, 
    -0.18490367f, 0.06046098f, 0.22428125f, 0.17567955f, 0.16671562f, 0.03712425f, 0.00469938f, 0.03260731f, 
    -0.03855628f, -0.10025647f, -0.04107555f, 0.05261971f, 0.16159061f, -0.10076465f, 0.10829164f, -0.09327126f, 
    -0.06360047f, 0.00005704f, -0.00093132f, -0.07428408f, 0.03635142f, -0.08291620f, 0.03268005f, 0.02598106f, 
    0.37216896f, 0.08197608f, -0.04046113f, -0.18234600f, -0.19543661f, -0.06823991f, 0.04582774f, -0.13336219f, 
    0.16768780f, -0.01381746f, -0.01487618f, -0.12344946f, 0.04072579f, 0.22567853f, -0.21909353f, -0.16282614f, 
    0.06588436f, -0.13623405f, -0.01964159f, 0.03212568f, -0.07909858f, -0.00828539f, 0.08487340f, 0.19564682f, 
    -0.08807296f, -0.20503059f, 0.06715605f, 0.05570864f, 0.07160283f, 0.03904949f, -0.07409280f, -0.09633826f, 
    0.07939508f, 0.04073870f, -0.02048536f, -0.03605451f, 0.33436242f, -0.15723974f, 0.04551746f, 0.04570261f, 
    -0.10001986f, 0.19823568f, -0.03728872f, -0.02898428f, 0.19894391f, 0.07893363f, 0.02689851f, -0.10770178f, 
    -0.11243062f, 0.06419453f, -0.22248320f, -0.01267993f, -0.08151330f, 0.07339556f, -0.18884081f, -0.05711159f, 
    0.07818279f, 0.17537707f, -0.01733181f, 0.01474849f, -0.38475615f, -0.01360966f, 0.06371371f, -0.03903034f, 
    0.16672896f, 0.08043960f, -0.09838419f, -0.02783211f, -0.00215046f, 0.06434795f, 0.04083915f, -0.02446821f, 
    -0.19889402f, -0.09096085f, 0.28240207f, -0.06884329f, 0.14184730f, -0.02406079f, 0.00433173f, 0.11236314f, 
    0.02661299f, 0.01051253f, 0.02127371f, 0.13929865f, 0.24678989f, 0.11226886f, -0.23685475f, 0.16756319f, 
    -0.12511197f, 0.04078952f, 0.13269566f, 0.11893693f, -0.03636301f, -0.04243037f, -0.02901372f, -0.14230873f, 
    -0.13013819f, -0.03673447f, -0.21939267f, -0.08994672f, 0.07104245f, 0.15375639f, -0.10485505f, 0.14187549f, 
    -0.04571533f, 0.09903970f, 0.02260060f, 0.11330347f, 0.58232015f, -0.02649970f, 0.10261074f, -0.14135939f, 
    0.01921150f, 0.07200907f, 0.02828218f, 0.05151080f, -0.02859353f, 0.10864861f, 0.02422133f, 0.00412217f, 
    0.34588900f, 0.05124025f, -0.27155101f, 0.09314580f, -0.03426737f, -0.04094820f, 0.05835566f, -0.06203040f, 
    0.05514370f, 0.02706079f, 0.01868957f, 0.06101605f, 0.07175364f, -0.57509899f, 0.15577789f, 0.02209248f, 
    0.07196126f, -0.06155691f, 0.02963319f, 0.14594856f, 0.04212143f, -0.08114322f, 0.04603251f, 0.09939262f, 
    0.03411990f, 0.36885828f, -0.05316023f, -0.00660492f, 0.20676689f, 0.06626397f, 0.15218890f, -0.01692044f, 
    0.10277607f, 0.14762139f, 0.05009306f, 0.11557084f, -0.22885405f, 0.18853037f, 0.03729753f, -0.21719190f, 
    0.13268349f, 0.05494790f, -0.00398195f, -0.11841987f, 0.03787357f, -0.01547019f, 0.20742919f, 0.04632275f, 
    0.42852798f, 0.05228940f, -0.02006498f, 0.07499444f, -0.15907256f, 0.05349213f, 0.05787644f, -0.01970802f, 
    0.11444239f, 0.14412138f, 0.11544824f, 0.07242949f, -0.20563857f, 0.02675759f, -0.23173554f, -0.01905639f, 
    0.04214614f, -0.01390560f, -0.06062099f, -0.05849560f, -0.03316614f, 0.12218128f, -0.01297174f, -0.09006540f, 
    0.05718794f, 0.14720920f, 0.25325617f, 0.08622746f, -0.01057463f, -0.12314966f, 0.08718949f, 0.11792219f, 
    0.06379974f, -0.00533228f, 0.10146886f, -0.04341340f, 0.17772810f, 0.13642010f, -0.33629888f, 0.30522609f, 
    -0.08650056f, 0.08039906f, 0.05366463f, -0.18629751f, -0.08033060f, 0.12234824f, 0.02350715f, -0.14920147f, 
    -0.15876570f, 0.00986109f, 0.21162805f, 0.33569810f, 0.11259710f, 0.05065063f, -0.00352116f, -0.09185384f, 
    -0.07327937f, -0.00423133f, -0.13279364f, -0.21176195f, 0.18552798f, -0.21503910f, 0.15867455f, 0.06006785f, 
    -0.21704555f, 0.11118923f, 0.03400394f, -0.02467808f, 0.10750958f, 0.15601958f, 0.05318713f, 0.02756443f, 
    0.28736693f, 0.22699521f, 0.00860484f, 0.03770656f, 0.00836275f, 0.09766468f, -0.13234776f, 0.24025124f, 
    -0.07317222f, 0.04244673f, -0.11213345f, 0.01779107f, 0.27824876f, 0.16424115f, -0.30132994f, 0.11271153f, 
    -0.09028361f, 0.06842069f, -0.03586258f, 0.11323699f, 0.02860669f, 0.18325135f, 0.03429471f, -0.08662352f, 
    0.23389296f, -0.17527813f, -0.23308615f, 0.19712467f, -0.08505502f, -0.07655740f, -0.01624648f, 0.02530002f, 
    0.12598634f, 0.01988636f, 0.03696576f, -0.13461603f, 0.28566775f, 0.19722202f, 0.03071536f, -0.16403522f, 
    0.03729437f, -0.01065137f, -0.01451886f, 0.10453709f, 0.10291877f, -0.15048634f, 0.11681087f, -0.02089924f, 
    -0.18633473f, -0.00997506f, 0.04949522f, 0.00746581f, -0.04687270f, 0.01300606f, 0.00081867f, -0.05548450f, 
    -0.09007381f, 0.09403433f, -0.04533806f, -0.12343188f, 0.47870374f, -0.13633654f, -0.06353625f, -0.07251360f, 
    0.05741632f, 0.00335866f, -0.02903883f, 0.03637088f, -0.00908958f, -0.17456570f, -0.06963579f, -0.00205279f, 
    0.01520469f, 0.09134304f, -0.16894522f, 0.06280176f, -0.00857752f, -0.09458207f, 0.01324862f, -0.01752237f, 
    -0.15565737f, 0.03102277f, 0.09649447f, -0.17409992f, 0.34737769f, -0.34306329f, 0.04794134f, 0.04739010f, 
    -0.05078734f, -0.13020667f, -0.04667643f, 0.16911395f, -0.16809900f, 0.23257080f, 0.06533545f, 0.03703881f, 
    0.22795410f, -0.14875263f, -0.27270827f, 0.07483052f, -0.01540874f, -0.08420275f, 0.07146613f, -0.14841115f, 
    0.16112657f, 0.09006636f, 0.02140980f, -0.00133647f, -0.12431414f, 0.12441198f, 0.16968128f, 0.00199169f, 
    -0.01933341f, -0.06483907f, -0.23905207f, 0.02280699f, 0.00667227f, 0.06697249f, -0.00913026f, -0.12906235f, 
    0.30326235f, 0.17924970f, 0.23027956f, 0.07184875f, 0.21578769f, -0.03642244f, -0.01290447f, 0.03605301f, 
    -0.05364154f, -0.08618609f, -0.05013794f, 0.06217032f, 0.28382921f, 0.14358272f, -0.41146234f, -0.01264496f, 
    0.04853640f, -0.10812367f, -0.14309591f, -0.04467018f, 0.01046937f, -0.05090953f, 0.10187001f, 0.03943152f, 
    0.06150906f, -0.04473045f, -0.00055206f, 0.01185528f, -0.05350084f, -0.04130979f, 0.02466402f, -0.07696588f, 
    -0.01370651f, 0.04493488f, -0.07867809f, 0.04295949f, 0.02202670f, 0.03164903f, 0.00397129f, 0.02884555f, 
    -0.00278299f, -0.06047265f, -0.05228325f, 0.07575098f, -0.05076887f, -0.01805052f, -0.00836689f, -0.03845385f, 
    0.03739796f, 0.04325437f, -0.05944875f, 0.01000725f, -0.05714260f, 0.05847631f, 0.01203078f, 0.03966177f, 
    -0.02683963f, -0.04602718f, 0.02138502f, -0.02944540f, 0.04106467f, -0.01805946f, 0.04783692f, -0.07084352f, 
    -0.00218690f, 0.01022328f, -0.04797876f, -0.05539383f, -0.06899119f, 0.02576361f, -0.05228015f, -0.02535024f, 
    0.05723334f, 0.02027571f, -0.03007717f, -0.04444745f, 0.01453825f, 0.02914773f, -0.04901179f, -0.06061596f, 
    -0.04646305f, -0.07924616f, -0.00025254f, -0.04996335f, -0.04861640f, 0.00860615f, 0.01210838f, -0.04671087f, 
    -0.02693416f, 0.01642393f, 0.00700182f, -0.04579046f, 0.03030462f, -0.00406980f, -0.05378436f, -0.03771934f, 
    -0.01668331f, 0.00693580f, -0.04989620f, -0.00498435f, -0.06480639f, 0.03346569f, -0.01572924f, 0.03279085f, 
    -0.00549475f, 0.07405047f, 0.06617106f, 0.05210194f, 0.01900994f, 0.05042579f, -0.01454391f, 0.03503368f, 
    -0.04023355f, 0.02989825f, -0.07601153f, -0.05318825f, -0.08277492f, -0.02870879f, -0.02758651f, 0.05320872f, 
    -0.06901460f, -0.07770920f, 0.02717174f, -0.06323365f, -0.04011170f, -0.05674236f, 0.01954444f, -0.06613977f, 
    -0.05524366f, -0.07222586f, -0.05322813f, -0.00553826f, 0.00795043f, 0.03842447f, 0.03667442f, -0.03817818f, 
    0.00498075f, 0.01799705f, 0.04530672f, -0.08753689f, -0.00612023f, 0.02700229f, 0.01856140f, 0.05763369f, 
    0.03893070f, 0.05936546f, -0.00959222f, 0.01586191f, 0.04434751f, 0.02107638f, 0.04625351f, -0.07458483f, 
    -0.04838103f, -0.00628504f, -0.04464460f, 0.04400047f, 0.02443455f, -0.05534398f, -0.01751971f, 0.07122745f, 
    -0.05630462f, -0.07401480f, -0.07025392f, 0.03652728f, 0.04436801f, -0.02040550f, -0.03021836f, 0.05856425f, 
    0.03482466f, -0.08390369f, 0.03785176f, -0.07116545f, -0.05725401f, -0.05925441f, 0.00393573f, 0.05955327f, 
    -0.03533270f, 0.02917870f, 0.00131602f, 0.05054056f, 0.03908186f, -0.04615980f, -0.03192881f, -0.03283114f, 
    0.01781493f, 0.04710574f, -0.05846071f, -0.02838513f, -0.06290450f, 0.00777107f, -0.01477113f, -0.01737981f, 
    0.04672879f, 0.07862625f, -0.00616616f, -0.03427010f, 0.01947030f, 0.04721373f, -0.06602430f, 0.02602960f, 
    0.00303143f, 0.02299109f, 0.00172557f, 0.05504314f, 0.03137740f, -0.04096383f, 0.03550342f, -0.03109175f, 
    -0.02342920f, -0.06636529f, -0.01275662f, -0.03727841f, 0.01934856f, -0.01585731f, -0.03511812f, -0.06931647f, 
    -0.03839372f, -0.05297413f, 0.29687604f, 0.31264395f, 0.03609329f, -0.00020242f, 0.24258918f, 0.20800067f, 
    -0.12227400f, 0.17622967f, 0.19325963f, -0.00081608f, -0.15131323f, 0.22065631f, 0.08450928f, -0.16366287f, 
    0.11789052f, -0.09052727f, -0.26058528f, -0.09502252f, 0.10235260f, 0.06524292f, -0.08223686f, -0.12430042f, 
    -0.16360725f, 0.21761262f, -0.07893750f, -0.08895222f, 0.01841309f, -0.00275912f, -0.04315514f, 0.03815540f, 
    0.10335006f, -0.07201592f, -0.06163416f, -0.18046120f, 0.38739249f, 0.02420064f, -0.01145317f, -0.08537840f, 
    0.18087958f, -0.04624850f, -0.03208281f, 0.05382496f, -0.10570539f, 0.17471683f, 0.03407146f, 0.12421062f, 
    0.44633439f, 0.01718952f, -0.15536579f, -0.17905775f, 0.11708526f, 0.01660580f, -0.06532410f, -0.14055724f, 
    -0.07966395f, -0.01203386f, 0.12090383f, 0.11466343f, 0.09411991f, 0.27754760f, 0.22068925f, -0.31958181f, 
    0.26915374f, 0.01599301f, -0.04243169f, -0.09651812f, -0.08566509f, 0.01718545f, -0.07091173f, 0.06779771f, 
    -0.26411700f, 0.09107031f, -0.27554449f, -0.05245242f, -0.03644456f, 0.20482695f, 0.24802279f, 0.02313177f, 
    0.24367660f, 0.05386037f, -0.08291362f, -0.30739421f, 0.30629408f, -0.33360860f, 0.22319774f, -0.06116052f, 
    -0.00872484f, 0.20810543f, -0.06144771f, 0.00685901f, 0.14550863f, 0.03036360f, 0.13758807f, 0.08283871f, 
    0.40146875f, -0.08026218f, -0.30272824f, 0.15590782f, 0.12143859f, -0.15721141f, -0.06084412f, 0.12195988f, 
    0.03525111f, 0.06280135f, 0.04207860f, 0.16827914f, 0.26074713f, -0.24262378f, 0.31195787f, 0.17684267f, 
    0.14766011f, 0.08137453f, -0.01573544f, -0.05137882f, 0.07442588f, -0.18490601f, -0.22038043f, -0.08291158f, 
    0.28223664f, -0.12953481f, 0.07258486f, 0.02130333f, 0.02891083f, -0.02235759f, -0.06610803f, -0.02159908f, 
    -0.02333855f, -0.05676473f, -0.11606701f, -0.10335622f, -0.30620319f, 0.27890769f, -0.05722874f, 0.05919111f, 
    0.05367293f, -0.01711023f, 0.02053469f, 0.10212368f, 0.16060242f, 0.16444260f, 0.01853312f, 0.00672289f, 
    -0.17983165f, 0.19494553f, 0.21261056f, -0.34924012f, 0.06012638f, -0.07605378f, -0.17655502f, -0.31469059f, 
    0.06069930f, 0.05662283f, -0.06279168f, 0.05542957f, 0.10750221f, -0.11011876f, 0.09481292f, -0.13314284f, 
    -0.03673485f, 0.08658396f, -0.03866479f, -0.06438674f, -0.20803736f, 0.14949021f, 0.13377813f, -0.26037931f, 
    0.14053652f, 0.03912962f, 0.19175275f, 0.09030683f, 0.05393044f, 0.05825778f, -0.07320937f, 0.04755242f, 
    0.03592870f, -0.23368034f, -0.05291184f, 0.05207735f, -0.24852931f, -0.01301563f, 0.12082204f, 0.05632487f, 
    -0.01349885f, -0.04322515f, -0.13502684f, -0.16755833f, -0.10892939f, 0.02424406f, 0.05040810f, 0.22633952f, 
    -0.00395116f, -0.01710131f, 0.05461497f, 0.05096490f, -0.04013706f, 0.02360373f, -0.01400831f, -0.04338946f, 
    0.02859683f, 0.02092759f, -0.03777473f, 0.00815009f, -0.07428701f, -0.06124473f, 0.05966096f, 0.05934351f, 
    -0.02926703f, -0.03831797f, -0.06050232f, -0.03523258f, -0.04933416f, -0.00216234f, -0.06331607f, -0.02039438f, 
    0.02417075f, -0.05762059f, 0.03259457f, 0.01736083f, 0.06492402f, 0.01142455f, 0.02057990f, 0.02118689f, 
    -0.03596851f, -0.04021451f, 0.02946370f, -0.00746447f, 0.03462493f, -0.06241987f, 0.06673737f, 0.01742392f, 
    -0.04086361f, -0.04874996f, 0.05305243f, -0.03655899f, 0.05762582f, -0.00045889f, -0.02578096f, -0.02123101f, 
    -0.01684120f, -0.07690962f, -0.06395284f, -0.00957762f, -0.04120702f, 0.02865560f, -0.01835261f, -0.00528401f, 
    -0.03198808f, -0.00346631f, 0.03125295f, -0.07137511f, 0.05876398f, 0.02984690f, -0.05048791f, 0.03155946f, 
    0.00597222f, 0.04492609f, 0.06500121f, -0.02851369f, -0.04963882f, -0.03939292f, -0.05598566f, -0.03529183f, 
    0.04789761f, -0.07456306f, -0.03183959f, 0.01197060f, 0.01026805f, -0.01333344f, 0.00426877f, -0.00070565f, 
    -0.05441500f, 0.04024653f, -0.02002041f, -0.01496490f, -0.04697259f, -0.06705856f, -0.07615966f, -0.03245297f, 
    0.02242629f, 0.02352198f, -0.05841308f, 0.00627958f, 0.02372183f, -0.04105407f, 0.01320733f, -0.07164475f, 
    -0.07817252f, 0.03059186f, -0.07657839f, -0.06327479f, 0.03138930f, 0.05666320f, 0.01512836f, 0.00254996f, 
    0.00314498f, 0.03347449f, 0.04117823f, -0.06258811f, 0.00061880f, -0.03281323f, -0.06891485f, 0.06236432f, 
    -0.07766910f, 0.06417847f, -0.02119418f, -0.04621457f, -0.03034318f, -0.02596472f, -0.07499632f, 0.02822165f, 
    0.06303864f, 0.02104544f, 0.00956018f, -0.07344776f, -0.03378895f, 0.00210187f, 0.02502302f, -0.02885721f, 
    0.06682628f, -0.00891397f, 0.05836443f, -0.07342754f, -0.01008775f, -0.05783474f, 0.02905318f, 0.02381287f, 
    0.03648352f, 0.02916156f, -0.07379083f, -0.07482321f, -0.03799172f, 0.05743806f, -0.05094786f, -0.01074402f, 
    -0.02347954f, -0.01210012f, -0.07202259f, 0.05783388f, 0.01462118f, 0.03235351f, -0.01975781f, -0.01203598f, 
    -0.05649589f, -0.01230738f, -0.00628750f, -0.06607263f, -0.05446703f, 0.05035575f, -0.03657906f, 0.03709670f, 
    0.00769480f, -0.00861080f, -0.00069880f, -0.00544093f, -0.05611073f, -0.01559815f, -0.00990219f, 0.04749839f, 
    0.02413808f, -0.00764364f, -0.01600266f, -0.05756573f, -0.04950748f, -0.02321774f, -0.04996151f, 0.06147932f, 
    -0.03545914f, -0.01109106f, -0.05526631f, -0.05945114f, -0.06382655f, 0.01792832f, 0.05816078f, -0.04393535f, 
    -0.07259136f, 0.04159282f, -0.00793496f, 0.03032338f, 0.04444285f, 0.00104246f, 0.04530776f, -0.01926278f, 
    -0.60828155f, -0.42331326f, -0.10921533f, 0.24351746f, -0.09797391f, -0.10558340f, -0.06287812f, 0.06313317f, 
    -0.11216430f, -0.02604749f, 0.09011493f, -0.11326091f, 0.26688269f, 0.17198519f, 0.49457145f, 0.12605241f, 
    0.30619568f, -0.06370940f, -0.04329744f, -0.13271146f, 0.00296564f, 0.08487342f, 0.06536882f, 0.22374557f, 
    -0.32090175f, 0.12780486f, -0.17924778f, -0.02302500f, 0.00076451f, 0.04270852f, 0.17881890f, -0.01459944f, 
    0.03894664f, 0.03128473f, 0.06342706f, 0.11749468f, -0.09642496f, -0.23347561f, 0.23830985f, -0.41554737f, 
    0.10217261f, -0.05770745f, -0.04960163f, 0.10177390f, -0.12162413f, 0.03482635f, 0.06201133f, -0.00722887f, 
    -0.52135772f, -0.06530672f, -0.05046858f, 0.08345105f, 0.02037879f, 0.01030861f, 0.12312090f, -0.07514910f, 
    0.14496326f, 0.01141934f, -0.12995484f, -0.10001370f, -0.03900786f, 0.29388323f, 0.37840715f, -0.10044524f, 
    0.05517256f, 0.12142021f, -0.12315223f, -0.17181706f, 0.08714873f, -0.01323974f, 0.08009955f, 0.28745723f, 
    0.00371419f, 0.37178057f, 0.27350250f, 0.28696495f, 0.12245505f, -0.06602248f, -0.01440985f, 0.01518546f, 
    -0.00674913f, 0.10837086f, -0.01192000f, 0.08179191f, 0.28368351f, -0.12578921f, -0.12730347f, -0.17299202f, 
    -0.09287261f, -0.04453332f, 0.16341844f, -0.00037451f, -0.00732139f, 0.11718628f, -0.17228228f, -0.11006067f, 
    0.29701465f, 0.07959024f, 0.15888236f, -0.05610111f, -0.03832891f, 0.10792116f, 0.05672583f, 0.09000664f, 
    -0.10505477f, -0.00925435f, -0.04386393f, 0.05161020f, -0.34466764f, -0.09543522f, -0.00522413f, -0.17330027f, 
    0.03683325f, 0.05809431f, 0.02015215f, 0.25472781f, 0.16314062f, 0.03610327f, -0.02178961f, -0.08651385f, 
    0.39253110f, -0.27018228f, 0.11473192f, -0.07380430f, 0.01986021f, 0.01948807f, 0.14102216f, -0.04169109f, 
    0.09553155f, -0.03012958f, 0.00449212f, 0.03591510f, 0.08343574f, 0.15906583f, -0.34347862f, 0.00451717f, 
    -0.04688649f, -0.05660966f, 0.08740225f, 0.10487862f, 0.03472384f, -0.03378394f, -0.06662539f, 0.07686684f, 
    -0.08022124f, -0.02507232f, 0.30228144f, 0.22087412f, 0.11532400f, 0.02557054f, -0.00362155f, -0.02687570f, 
    0.04384511f, 0.05420745f, 0.06857333f, 0.01923075f, 0.01846717f, -0.19215731f, -0.06090933f, -0.16753651f, 
    0.10467780f, 0.07917488f, 0.15751432f, -0.22467284f, -0.12364224f, -0.16442525f, -0.02555826f, 0.19687025f, 
    -0.45972124f, -0.26051018f, -0.18751897f, 0.09316412f, 0.09666544f, -0.01916303f, 0.06377044f, 0.05742505f, 
    -0.10849521f, -0.00034670f, 0.14341013f, 0.01672618f, 0.12180302f, -0.28589141f, -0.15671121f, 0.07455831f, 
    0.00129875f, 0.01568779f, -0.10344322f, 0.05436081f, -0.04007155f, -0.00369901f, -0.02514230f, 0.03331687f, 
    0.17723694f, 0.12801418f, 0.13108015f, 0.44172803f, 0.10059737f, 0.02437264f, 0.02665643f, 0.02995830f, 
    -0.00488547f, -0.08847279f, 0.15545461f, -0.05524044f, -0.04495491f, -0.12207115f, -0.12727335f, 0.31792727f, 
    0.01018989f, 0.10023079f, -0.01335624f, 0.07734390f, -0.13476096f, 0.04403742f, -0.06765878f, -0.01238214f, 
    -0.22678371f, 0.09595554f, 0.15618707f, 0.09550626f, -0.09804358f, 0.01675973f, 0.04161394f, 0.03071477f, 
    -0.23427051f, 0.02280838f, 0.15288930f, 0.25733948f, -0.26827878f, 0.19186941f, -0.14475013f, -0.06291320f, 
    -0.05329733f, 0.08542860f, -0.19449553f, 0.08182343f, 0.02524595f, -0.07409409f, -0.00105146f, 0.02986245f, 
    0.05879521f, 0.31687564f, 0.12644786f, 0.20930590f, 0.22993188f, -0.08062489f, 0.22289604f, 0.15798247f, 
    0.04009000f, -0.02791102f, -0.11749842f, -0.21589233f, -0.07802227f, 0.07682336f, 0.03665562f, 0.17118247f, 
    -0.17479882f, 0.12078162f, -0.08686277f, 0.00899929f, 0.01363735f, -0.04543434f, -0.04903442f, -0.09991360f, 
    0.45265630f, -0.11985065f, 0.07443193f, 0.04979463f, 0.18080573f, -0.18109667f, 0.05968142f, -0.01051135f, 
    -0.00566766f, -0.05573310f, 0.02675900f, 0.14191590f, -0.00306007f, -0.03081218f, 0.23303658f, -0.27174631f, 
    0.16735494f, -0.08437549f, 0.10776683f, 0.04205401f, 0.01881131f, -0.10022906f, -0.11654729f, -0.01878746f, 
    0.34860492f, 0.07442420f, 0.01784727f, -0.15203510f, -0.00346903f, 0.06204372f, 0.02084581f, -0.01216993f, 
    -0.06658062f, 0.00332395f, 0.01146791f, -0.07859636f, 0.00864442f, -0.02275497f, -0.01619303f, 0.01689989f, 
    0.21350968f, 0.14668705f, -0.20502524f, 0.06873287f, -0.07659663f, -0.09197912f, 0.04874603f, -0.06414541f, 
    -0.07430638f, 0.09547840f, 0.00623100f, 0.06237124f, 0.04071941f, 0.18983825f, 0.12431075f, -0.13919014f, 
    0.10221136f, -0.00671166f, 0.07806823f, 0.05998093f, 0.00379270f, -0.17495652f, -0.09374996f, -0.12296037f, 
    -0.19820698f, -0.15384331f, -0.02945219f, -0.12541384f, -0.14603132f, -0.00689402f, -0.18397269f, -0.00728126f, 
    -0.43547046f, -0.15255891f, 0.23078835f, 0.01481134f, -0.30834293f, 0.03299670f, -0.01627760f, -0.09908950f, 
    0.03983027f, -0.02299257f, 0.04868789f, -0.16536988f, 0.38508382f, -0.04207234f, 0.10805559f, 0.23410121f, 
    0.14164177f, 0.04135700f, 0.21411377f, 0.08258983f, 0.13494274f, 0.01021111f, 0.07132566f, 0.19995780f, 
    -0.10851682f, 0.40219283f, 0.04497857f, -0.02542532f, -0.03840556f, 0.00262122f, -0.07525618f, 0.24511085f, 
    0.02348145f, 0.03239498f, -0.03119646f, -0.05415992f, 0.04287972f, -0.04188071f, -0.11780731f, -0.22128062f, 
    -0.10071514f, 0.04272995f, -0.11928602f, -0.03997652f, -0.01189752f, -0.08478517f, 0.07915542f, -0.05482218f, 
    0.06263064f, -0.02882306f, -0.06184042f, -0.01054794f, 0.03063479f, 0.03693435f, -0.00326296f, 0.05217834f, 
    0.01600099f, 0.02074495f, -0.05948614f, -0.06898808f, 0.03913845f, -0.00738900f, -0.05259729f, -0.00462154f, 
    0.02731837f, -0.06111193f, 0.04192512f, 0.03896416f, 0.02742048f, -0.01986210f, -0.04661332f, 0.04859511f, 
    0.03482855f, 0.03197846f, -0.05930645f, 0.05921529f, -0.05650841f, 0.00549256f, 0.00952443f, -0.03263764f, 
    0.04248167f, -0.02492672f, -0.05114523f, -0.04144688f, 0.03459323f, 0.01801038f, -0.02803051f, -0.01826769f, 
    -0.01747305f, -0.03442525f, 0.04192961f, -0.06635667f, -0.05255209f, -0.00790000f, 0.06072120f, -0.00320363f, 
    -0.04611839f, 0.06016938f, -0.03697110f, -0.05867049f, -0.08065365f, -0.06601096f, 0.04553379f, -0.00726443f, 
    -0.04074882f, 0.00214274f, 0.05410377f, -0.05635969f, 0.06092595f, 0.01187180f, -0.03703431f, -0.03419221f, 
    -0.04025235f, -0.05178092f, -0.04037212f, -0.07721125f, 0.01685140f, 0.00005941f, 0.01344250f, 0.03624212f, 
    0.00993800f, -0.07525872f, -0.02685582f, -0.03937957f, 0.05317428f, -0.00550082f, -0.06654405f, -0.07008767f, 
    -0.00194213f, -0.03718771f, -0.00601975f, -0.06441353f, 0.00932688f, -0.07872415f, 0.04017958f, -0.01915964f, 
    -0.01269570f, -0.02249877f, 0.02388944f, -0.03208212f, -0.01827416f, -0.02057225f, 0.06807307f, -0.02455608f, 
    -0.07922102f, 0.06107187f, -0.04990186f, 0.05205089f, 0.02356777f, 0.05998993f, -0.01791007f, 0.05916254f, 
    -0.06179130f, -0.03213825f, -0.00740892f, -0.05501228f, 0.05237783f, 0.02914593f, -0.06595551f, 0.02634657f, 
    -0.00786824f, -0.07350408f, -0.06311769f, 0.03978564f, 0.03891738f, 0.01139560f, -0.00198016f, 0.03276213f, 
    0.04973993f, -0.00004107f, -0.07500254f, -0.05526734f, -0.00891647f, 0.00883716f, 0.06029975f, 0.01287995f, 
    -0.04558379f, 0.03960282f, -0.01357900f, -0.06319762f, -0.03222182f, 0.04841825f, 0.02027222f, 0.00401993f, 
    -0.04725375f, 0.03278819f, 0.03499889f, -0.06381676f, 0.02195823f, -0.04210181f, -0.03963958f, 0.03379891f, 
    -0.06300410f, -0.01652576f, -0.02079842f, -0.05822092f, -0.03884429f, 0.02739714f, -0.06707458f, 0.03994258f, 
    0.04726532f, -0.08030351f, -0.01713560f, 0.05519077f, 0.01243690f, 0.00738800f, -0.06045125f, -0.00546776f, 
    0.04027905f, 0.01558946f, -0.04866418f, -0.02836318f, -0.03996542f, -0.08106750f, 0.00025062f, -0.05371393f, 
    0.04225828f, 0.05182209f, -0.04050478f, -0.01181453f, 0.02200958f, -0.01694650f, -0.03319489f, 0.05919781f, 
    0.01873697f, -0.00312742f, 0.03551895f, -0.01248645f, -0.07517692f, -0.00411610f, 0.01231750f, 0.06921443f, 
    -0.00818835f, 0.04040288f, -0.00627388f, -0.00710521f, -0.07900495f, -0.04942583f, -0.02193196f, 0.01907428f, 
    0.26541486f, -0.03697521f, 0.29595333f, 0.08735321f, -0.13936010f, 0.01133364f, 0.01871372f, 0.01710427f, 
    0.02345301f, 0.05869238f, 0.03085481f, -0.23589700f, -0.17328796f, -0.19368018f, -0.05769809f, 0.19902761f, 
    0.09023890f, 0.11092035f, -0.15907775f, -0.05988989f, -0.16431078f, 0.02165586f, 0.09480166f, -0.02901356f, 
    -0.25716290f, -0.10384882f, -0.11037008f, 0.02906274f, 0.04324317f, -0.03892576f, 0.07114996f, 0.04086477f, 
    0.02131870f, 0.20692527f, -0.05285969f, -0.22956857f, 0.21851906f, -0.31095207f, 0.12702137f, 0.04094733f, 
    -0.11650778f, -0.06128744f, -0.04785412f, -0.06242547f, 0.03510071f, 0.01072395f, 0.04401714f, 0.07538532f, 
    -0.34495094f, 0.37706348f, -0.13322307f, -0.34529364f, 0.18525523f, -0.11498713f, -0.02746237f, -0.05358332f, 
    0.03453190f, -0.00709724f, -0.01468964f, 0.06146738f, -0.16966631f, -0.24138656f, 0.10095391f, -0.13532628f, 
    0.19215956f, 0.01687934f, -0.06353138f, -0.06540684f, 0.07492553f, 0.02706506f, -0.01324110f, -0.06161208f, 
    -0.06994878f, -0.07102899f, -0.11204998f, 0.20989537f, 0.05764411f, -0.08195185f, 0.01905211f, 0.02428082f, 
    0.05100166f, 0.06167106f, 0.03766368f, -0.10773239f, 0.19261225f, 0.15626746f, -0.25147229f, 0.00571416f, 
    -0.13976902f, -0.06319572f, 0.11550214f, 0.07139000f, 0.11197361f, -0.03020544f, -0.05880455f, 0.09513481f, 
    0.26333046f, 0.06125283f, -0.06139343f, 0.02404404f, 0.24328269f, 0.15546018f, -0.20591334f, 0.06588405f, 
    -0.04865372f, 0.12798484f, -0.07887302f, 0.07286924f, 0.69935572f, -0.07947428f, 0.15465949f, 0.09172840f, 
    -0.01578264f, 0.00752518f, 0.01184397f, -0.00104167f, -0.10109711f, 0.00938623f, -0.02820336f, 0.02905692f, 
    0.10568574f, -0.07511161f, -0.21919908f, -0.17327124f, 0.04883306f, -0.07199845f, 0.08408369f, 0.03544233f, 
    0.15427607f, 0.07830537f, 0.14177127f, 0.13772370f, 0.23379432f, -0.15010951f, -0.00784618f, 0.37027571f, 
    0.08017948f, 0.03488063f, -0.18592179f, -0.07335906f, -0.06694794f, 0.01008737f, 0.08639116f, 0.12867352f, 
    0.06694297f, -0.07008800f, -0.10030834f, 0.01658146f, 0.12939849f, 0.11436596f, 0.14047022f, -0.08215991f, 
    0.16946493f, 0.22552924f, 0.04991013f, 0.11922326f, -0.17526190f, 0.21483541f, 0.42580834f, -0.05535643f, 
    0.09609883f, 0.19940658f, -0.08698121f, -0.03162079f, -0.17815061f, -0.06205007f, 0.14482282f, 0.11917478f, 
    0.53526610f, -0.13961744f, 0.09762588f, 0.17462806f, -0.02711906f, -0.11943411f, -0.07995320f, -0.00071238f, 
    -0.15345071f, 0.19195789f, 0.01707810f, -0.03450510f, -0.20031223f, -0.22650766f, -0.08668676f, 0.11446474f, 
    -0.09336711f, -0.11518803f, -0.04380337f, 0.07434189f, 0.15951841f, 0.01415469f, 0.02209650f, -0.04273668f, 
    -0.11444388f, 0.05556296f, 0.17331675f, 0.01919617f, 0.15725544f, 0.03535949f, -0.16815910f, -0.26443100f, 
    0.07084908f, -0.03284540f, 0.00113717f, 0.15716425f, 0.09001194f, 0.00761226f, 0.30761170f, -0.05880549f, 
    0.08085737f, -0.00131813f, 0.08523424f, 0.08702436f, 0.08783722f, -0.06491908f, 0.00301010f, -0.18682669f, 
    -0.15780191f, 0.07720841f, -0.06323044f, -0.18338227f, -0.21400298f, -0.07748627f, 0.05235507f, -0.02966395f, 
    -0.10191375f, 0.08751757f, 0.04004164f, 0.14747632f, 0.05601508f, -0.04963324f, 0.06267701f, 0.09986764f, 
    0.13416652f, -0.17793623f, 0.04942959f, -0.04566282f, -0.05894898f, -0.03344288f, 0.06175842f, 0.12237659f, 
    0.02284109f, 0.38913199f, 0.28958833f, 0.09654398f, 0.09147543f, -0.11589235f, 0.12677447f, 0.07437670f, 
    0.07312839f, -0.06124225f, -0.03784960f, -0.04679617f, 0.27940878f, 0.25875539f, -0.04371637f, 0.07600683f, 
    -0.10514175f, -0.04663971f, 0.00927535f, -0.01925400f, -0.05366144f, -0.11294871f, 0.06706000f, -0.02964744f, 
    0.40678775f, 0.16807853f, 0.06907006f, 0.13131292f, -0.14781074f, -0.07493038f, -0.05575632f, 0.09904155f, 
    -0.09265969f, 0.08050767f, -0.08203293f, -0.13045539f, 0.01711334f, 0.09319122f, -0.04219291f, 0.13242039f, 
    0.14131805f, 0.02133311f, 0.04832138f, -0.18134223f, -0.15667865f, -0.04315112f, -0.11897693f, 0.12021527f, 
    0.23575623f, -0.15073442f, 0.20482230f, -0.00912513f, -0.03215662f, 0.03007975f, 0.10979819f, -0.16059129f, 
    -0.04891624f, -0.15578660f, -0.04327651f, -0.06700449f, -0.22889537f, 0.24020515f, 0.17438887f, 0.09802809f, 
    0.18727672f, 0.05989505f, -0.03115137f, 0.03964295f, 0.05344022f, 0.04959156f, 0.09956187f, 0.10645193f, 
    0.08188784f, -0.48721018f, 0.25597483f, -0.16631262f, 0.05593768f, -0.09449086f, 0.20070238f, -0.02584169f, 
    0.17437944f, -0.00493520f, 0.06983371f, -0.01880830f, 0.23688790f, 0.14151424f, -0.26112071f, -0.18093222f, 
    -0.08958656f, -0.01716208f, -0.02049500f, -0.15852214f, -0.18678451f, 0.01346985f, -0.11915719f, -0.05903247f, 
    -0.41708359f, -0.17755483f, -0.06897186f, 0.09106040f, -0.06714900f, -0.07392563f, 0.00379929f, 0.20262003f, 
    -0.10737072f, -0.06914267f, 0.10873323f, 0.09546988f, 0.20931324f, 0.05332244f, 0.10742410f, 0.20622687f, 
    0.15852450f, -0.00227832f, 0.07799394f, 0.11175507f, -0.02870351f, 0.01355715f, -0.16405705f, 0.00226175f, 
    -0.06285416f, 0.00610355f, -0.01529969f, 0.08446062f, 0.12034702f, 0.21845251f, -0.03312980f, -0.19331221f, 
    -0.07280239f, -0.15224478f, 0.02535497f, 0.07784953f, 0.02037052f, -0.03305052f, -0.06529581f, 0.06750531f, 
    -0.16032487f, -0.06655988f, -0.06512754f, 0.07974613f, -0.01563339f, -0.18752107f, 0.03328561f, -0.02734939f, 
    -0.24789208f, 0.18484735f, -0.34777644f, -0.36990437f, 0.05875201f, 0.14278135f, -0.06693197f, -0.20743164f, 
    0.02142494f, 0.08035352f, -0.02474617f, 0.29698336f, 0.11832570f, 0.21198960f, 0.29747185f, -0.23951413f, 
    -0.01761517f, -0.02305957f, 0.10990907f, 0.02353835f, 0.02258457f, -0.09578532f, 0.10271220f, -0.04778894f, 
    0.30841422f, 0.01235493f, 0.06353376f, 0.02527242f, -0.03324090f, 0.00003514f, -0.09014111f, -0.09566890f, 
    0.02982718f, -0.07036395f, -0.05053674f, 0.11810276f, 0.24817707f, -0.00508833f, 0.12095646f, -0.10770591f, 
    0.15003093f, -0.14533535f, 0.12828790f, 0.05150986f, -0.04232463f, -0.06267129f, -0.04979320f, -0.03663461f, 
    0.24553420f, 0.02074010f, 0.13216349f, 0.41762343f, -0.10918281f, 0.09766760f, 0.07913066f, 0.14161885f, 
    -0.06104397f, 0.12929049f, 0.12078375f, -0.03399526f, 0.15276338f, 0.13930826f, -0.13355231f, 0.10124280f, 
    -0.19560365f, -0.11927391f, 0.06139560f, -0.01379999f, 0.02356432f, -0.06731366f, 0.13195021f, 0.07335346f, 
    0.03050175f, 0.23795623f, 0.35162807f, -0.17079374f, -0.18247205f, 0.13405897f, -0.11819872f, -0.06813014f, 
    -0.13671778f, -0.01814244f, -0.05044801f, -0.03872650f, 0.08457385f, 0.21982341f, -0.00101515f, 0.42396861f, 
    0.03174365f, 0.17981470f, -0.04135111f, 0.00414361f, -0.23643616f, 0.12262823f, 0.02660500f, 0.01402569f, 
    -0.36362439f, -0.09888691f, 0.27417997f, -0.00059944f, -0.08560214f, -0.09732500f, 0.03046297f, -0.13162756f, 
    0.07251014f, -0.00594323f, -0.01846709f, 0.02869608f, -0.49766520f, 0.18850301f, 0.09134548f, -0.10746935f, 
    0.07491878f, -0.08809116f, 0.09835094f, -0.13615493f, 0.06017945f, 0.11143360f, 0.17181870f, -0.06565660f, 
    0.25484329f, -0.34326157f, 0.25041005f, 0.22452313f, 0.14959618f, -0.13742827f, -0.08977436f, -0.03737586f, 
    -0.04715757f, 0.05432864f, -0.01182154f, -0.04253797f, -0.16035864f, 0.00235028f, -0.02469789f, -0.09786309f, 
    0.04795303f, 0.07084690f, 0.23110628f, -0.10335533f, -0.01492937f, 0.06165307f, -0.09667267f, 0.04657763f, 
    0.35850888f, -0.06035754f, -0.11905973f, 0.29876429f, 0.05983766f, -0.13017510f, -0.09605091f, 0.25464499f, 
    -0.16787410f, -0.05896904f, 0.00923336f, 0.00198058f, 0.03729678f, 0.00267310f, -0.07007816f, -0.00593592f, 
    0.10921804f, -0.11321296f, -0.03034373f, 0.09872502f, -0.05890881f, -0.01990242f, -0.17074816f, -0.08670419f, 
    -0.26475611f, -0.04453045f, -0.13757995f, 0.01000469f, 0.12154831f, 0.17062050f, 0.12505706f, -0.18048581f, 
    0.06045460f, -0.13521731f, 0.09512129f, 0.06287341f, 0.24490060f, 0.37379110f, 0.19114253f, 0.16453543f, 
    -0.03752042f, 0.04179336f, 0.17460784f, 0.11612838f, -0.05403029f, 0.12826706f, -0.01904246f, -0.01605093f, 
    -0.06637311f, 0.05159780f, 0.01688170f, -0.02208866f, 0.02956587f, -0.01700104f, -0.03602125f, 0.00213656f, 
    -0.01722351f, -0.02058022f, 0.03987534f, 0.03556423f, -0.01443595f, -0.00289134f, -0.05229784f, 0.01706788f, 
    0.02353979f, -0.02664144f, -0.01058771f, -0.05617427f, -0.00571244f, 0.05810941f, 0.04166830f, 0.03981365f, 
    0.04127064f, -0.05497639f, 0.02090169f, -0.06398464f, -0.07443351f, -0.00400833f, -0.03771328f, 0.03088928f, 
    -0.07290520f, 0.04302518f, -0.04755830f, -0.03046689f, 0.05492962f, -0.02640890f, -0.00711171f, -0.06666832f, 
    -0.04861671f, 0.04210910f, 0.03136596f, 0.03837717f, -0.06649199f, -0.03983068f, 0.05445984f, -0.04789079f, 
    -0.02052462f, 0.03344201f, 0.00884262f, 0.06325085f, -0.05121883f, 0.06200881f, 0.02089123f, 0.06308502f, 
    0.04171044f, -0.07013705f, 0.00953405f, -0.07462462f, -0.07072601f, -0.05115359f, 0.00946113f, 0.01078185f, 
    -0.06497789f, -0.04975166f, 0.03293588f, -0.01268834f, 0.04569516f, 0.02625797f, -0.06496367f, -0.06936993f, 
    -0.05691352f, -0.04303717f, -0.01759883f, -0.01387886f, -0.07297116f, -0.06967571f, 0.01151284f, -0.04732967f, 
    0.00986077f, -0.04856917f, -0.00448363f, -0.02000719f, 0.03708361f, 0.03888012f, -0.02239461f, 0.03935846f, 
    -0.06467621f, 0.01190746f, -0.04907421f, -0.07119949f, 0.02835881f, -0.06338826f, 0.01580854f, -0.00158182f, 
    -0.06180549f, -0.05909996f, -0.04893849f, 0.03148733f, 0.00179020f, -0.02271849f, -0.03959530f, 0.01337809f, 
    -0.02287256f, -0.01227861f, -0.07181885f, -0.05460364f, 0.05168302f, -0.06876596f, -0.06811060f, -0.00903167f, 
    -0.00830576f, 0.02450906f, -0.02054390f, -0.06282450f, 0.02833318f, -0.00263633f, -0.02431753f, 0.05601940f, 
    -0.04573271f, -0.00771667f, 0.00470230f, 0.00436169f, -0.06102400f, -0.06599406f, 0.03076976f, 0.00374932f, 
    0.00008263f, -0.02246154f, -0.01475415f, 0.01742805f, 0.01539172f, -0.03653979f, -0.05314882f, -0.06401785f, 
    0.03504132f, -0.05946536f, 0.00369132f, -0.03649845f, 0.01922472f, 0.06437440f, -0.00994256f, 0.04057287f, 
    -0.00455543f, -0.01481501f, -0.03735884f, -0.07326923f, -0.03338395f, -0.07599688f, 0.00763416f, 0.02781766f, 
    -0.02413282f, 0.06403732f, -0.04296420f, -0.02096634f, -0.00601817f, -0.05355529f, -0.03902440f, -0.03616299f, 
    -0.00910544f, 0.04399230f, -0.05311536f, 0.04287574f, -0.01229928f, 0.03992228f, -0.01062333f, 0.00401167f, 
    -0.03735729f, -0.03153341f, 0.05099845f, 0.01061212f, -0.02376253f, -0.00111275f, 0.01097301f, -0.03883989f, 
    -0.04117765f, -0.00606725f, 0.00262382f, -0.03805485f, -0.00860696f, 0.03218411f, -0.05797633f, 0.05521323f, 
    0.02712735f, 0.02303651f, 0.02857750f, -0.02487561f, -0.04592466f, -0.04252855f, -0.07649092f, -0.02902878f, 
    0.02001062f, -0.04452489f, 0.02186614f, -0.04103879f, -0.01985669f, -0.00963017f, -0.02246433f, -0.06086661f, 
    -0.01650712f, 0.02843340f, -0.01845586f, -0.07034259f, 0.02343242f, 0.01971108f, 0.04708372f, 0.04519488f, 
    -0.01389971f, 0.05052961f, -0.04034103f, -0.07752924f, 0.00300034f, -0.04787068f, -0.05647251f, -0.06266115f, 
    -0.06257778f, 0.00220158f, 0.01475785f, -0.01910268f, 0.05903725f, -0.05436357f, -0.03159404f, 0.05602548f, 
    -0.05923823f, -0.00533753f, 0.02228821f, 0.04807922f, 0.04911645f, 0.02909172f, -0.07544260f, 0.02836667f, 
    -0.02187269f, 0.06600342f, 0.00714434f, -0.01225329f, -0.07792898f, 0.03672404f, -0.02972519f, -0.06904894f, 
    0.02321512f, 0.01181396f, 0.00821100f, -0.07557578f, 0.00327245f, 0.05556910f, 0.02957628f, -0.06434157f, 
    -0.00937734f, -0.06212135f, 0.04647143f, 0.04404811f, -0.03507219f, 0.03565698f, -0.04176809f, -0.06068797f, 
    -0.00137260f, -0.03598021f, 0.00328602f, -0.02085203f, -0.06151118f, -0.02608850f, -0.01933737f, -0.02112045f, 
    -0.03244489f, -0.07239127f, -0.02201490f, -0.06352629f, 0.01778721f, -0.07039782f, 0.05807059f, 0.00144621f, 
    -0.01231127f, -0.00426393f, 0.07091011f, -0.02364279f, 0.03085369f, -0.05300604f, -0.02155212f, -0.05859789f, 
    -0.01211058f, 0.01783352f, 0.01107497f, 0.04719698f, 0.05021224f, -0.02411535f, 0.02381399f, 0.06758960f, 
    0.06222465f, -0.00014687f, 0.03233873f, 0.01250300f, 0.04197117f, -0.03117988f, -0.07415318f, 0.03265860f, 
    -0.06602880f, 0.00390012f, -0.03215769f, 0.01414995f, -0.00422626f, -0.06665763f, -0.00511500f, 0.06290591f, 
    0.05168395f, -0.00887439f, -0.02509583f, -0.00925107f, 0.01481783f, 0.06182335f, 0.03902736f, -0.04519003f, 
    0.04575561f, 0.06470002f, 0.04456028f, -0.07121333f, -0.05238627f, 0.00758563f, 0.06517742f, -0.00004252f, 
    -0.02564900f, -0.03421791f, -0.05546786f, -0.05184795f, -0.00672082f, -0.05864538f, -0.03223066f, 0.04772903f, 
    -0.05239151f, 0.02539503f, -0.03513892f, 0.00077083f, -0.02180097f, 0.01978548f, 0.00866533f, 0.01621918f, 
    0.03418333f, 0.02221037f, 0.05413066f, -0.06871638f, -0.00576765f, 0.01229034f, -0.01627168f, 0.04054807f, 
    0.01676754f, 0.04439458f, 0.01987872f, -0.02608301f, -0.04206734f, -0.07467472f, -0.07229078f, 0.01672508f, 
    -0.06490061f, -0.04557629f, -0.03722707f, 0.01607595f, -0.04712429f, 0.06156906f, 0.01851057f, -0.07354973f, 
    -0.00254690f, -0.00204804f, -0.01486637f, 0.04756842f, -0.03946481f, -0.05183233f, -0.07357290f, -0.05171373f, 
    -0.06528310f, -0.06197219f, -0.00698319f, -0.04134148f, -0.05414214f, -0.03008192f, 0.03107878f, -0.02382590f, 
    0.00919899f, -0.05212135f, -0.02389425f, -0.05538885f, -0.04959147f, 0.03539015f, 0.02436466f, -0.03825444f, 
    -0.03223881f, -0.02431079f, -0.35859692f, -0.19901235f, 0.01603639f, 0.03087410f, 0.05583544f, -0.12953986f, 
    0.02565233f, 0.01432796f, -0.07973123f, 0.18570882f, -0.19665654f, 0.21898596f, 0.20519386f, -0.52877343f, 
    -0.06054430f, -0.14582174f, 0.09891166f, 0.12173746f, 0.21594231f, 0.04599692f, 0.02845659f, 0.14963031f, 
    0.55356675f, 0.05330618f, 0.03035330f, -0.11454829f, 0.06788810f, 0.05174481f, -0.03944791f, 0.04470669f, 
    0.04463639f, -0.05373263f, 0.06632480f, 0.14084581f, -0.05637999f, 0.27150902f, 0.06879298f, -0.02744417f, 
    0.22185060f, 0.09378218f, 0.06445182f, 0.05388034f, -0.00093245f, 0.01126883f, -0.07891330f, -0.08237715f, 
    0.13242765f, -0.20100091f, -0.06581288f, 0.21229115f, -0.11670294f, 0.07457730f, 0.01628819f, -0.12211461f, 
    -0.08812402f, 0.09436009f, 0.08966949f, -0.01431966f, -0.37513670f, -0.07043501f, 0.09279551f, 0.01992214f, 
    0.14764807f, 0.07093483f, 0.08462247f, 0.06410141f, 0.00343753f, -0.11203720f, -0.02824862f, 0.18236607f, 
    -0.29918215f, -0.06344779f, 0.12165155f, -0.32106301f, -0.00007883f, 0.12952848f, -0.02802340f, 0.00007574f, 
    0.06722860f, -0.03580114f, 0.02416275f, 0.26333776f, -0.35660043f, -0.25022593f, 0.12275200f, 0.27128100f, 
    0.12679152f, 0.00906555f, 0.03264897f, -0.01114003f, 0.00813902f, 0.05250686f, 0.01350509f, -0.01282708f, 
    -0.25509396f, -0.00639214f, 0.01345937f, -0.08325548f, 0.00894869f, -0.09307399f, -0.02202695f, 0.11308493f, 
    0.12459616f, 0.06069838f, 0.08045933f, 0.09257551f, -0.32823297f, 0.05796317f, 0.00195790f, -0.00763491f, 
    -0.02313758f, -0.08122643f, -0.04757099f, 0.00031402f, 0.15352406f, 0.11581528f, 0.15383855f, -0.08769836f, 
    -0.14050190f, 0.04242489f, 0.19047219f, 0.12535171f, 0.05396733f, 0.05991617f, 0.05385382f, 0.01634223f, 
    0.08516104f, 0.03796422f, -0.00089887f, 0.09979203f, -0.36829287f, 0.12657519f, -0.02110867f, -0.17063808f, 
    -0.02746025f, 0.12244323f, 0.23787744f, 0.00165353f, 0.13084622f, -0.11683165f, 0.05994046f, -0.02013852f, 
    -0.01646391f, 0.28770101f, 0.26759040f, 0.05299694f, -0.00938555f, 0.09818594f, 0.00516597f, 0.12857854f, 
    -0.00390540f, -0.07213346f, 0.00661255f, -0.00639398f, 0.10518245f, 0.05292976f, -0.15093684f, -0.06861809f, 
    -0.01908950f, -0.02360124f, 0.17063266f, 0.01941717f, -0.01262763f, 0.00102512f, 0.12728730f, -0.05267983f, 
    -0.32030895f, 0.06826347f, -0.28919101f, -0.20491205f, -0.22561339f, 0.07577235f, 0.07117840f, 0.03179397f, 
    0.11318889f, 0.08189265f, -0.01597840f, 0.02779376f, 0.09732718f, 0.21799350f, 0.43721110f, 0.22769292f, 
    0.04381764f, 0.18265422f, 0.18020299f, 0.09610183f, -0.11787117f, 0.14210860f, -0.07448345f, 0.12119837f, 
    -0.01265341f, 0.00435205f, -0.15903056f, -0.18375891f, 0.17097501f, 0.13215834f, 0.05306695f, 0.34938350f, 
    0.03630012f, 0.00848753f, 0.08268741f, 0.11329711f, 0.23780560f, -0.02981081f, 0.07606987f, 0.71509087f, 
    -0.06064705f, 0.09901377f, -0.08502156f, -0.22410235f, -0.03533765f, -0.08997928f, 0.07917417f, 0.09863241f, 
    -0.11127338f, 0.08152820f, -0.01579486f, 0.01606738f, -0.17513464f, 0.07911347f, 0.03719561f, 0.15173236f, 
    0.00381334f, 0.21282516f, -0.01169176f, 0.14681000f, 0.07287233f, 0.07074884f, -0.23672171f, 0.00742693f, 
    0.00474092f, -0.06223942f, -0.13682520f, 0.09065618f, 0.00228000f, -0.12669134f, 0.14161819f, -0.09633630f, 
    -0.18882552f, -0.15541629f, 0.13819678f, -0.04175300f, 0.27011728f, -0.06068257f, 0.14941801f, 0.01567886f, 
    0.04529994f, -0.07097428f, 0.06453020f, -0.09733779f, 0.08368303f, -0.01670816f, -0.19447643f, 0.42756122f, 
    -0.30949649f, 0.01523276f, 0.07108256f, -0.08862413f, 0.05224003f, 0.10752653f, 0.06382860f, -0.01219003f, 
    0.52602291f, 0.29917926f, 0.21095355f, -0.02160710f, 0.09823588f, -0.19598812f, -0.15701967f, -0.13118605f, 
    -0.04093498f, -0.07596361f, -0.01012627f, 0.17062527f, -0.35913265f, 0.03244428f, -0.03542414f, -0.35270467f, 
    0.23783119f, -0.10471309f, 0.08698453f, 0.09989340f, -0.09364285f, 0.02207327f, -0.06596064f, -0.06333975f, 
    0.36465946f, 0.11600889f, 0.25827059f, 0.21179444f, 0.04172901f, 0.13345908f, -0.10774055f, -0.18106259f, 
    -0.09034422f, 0.06627768f, 0.04853395f, -0.01872934f, -0.52291811f, -0.14991336f, -0.17296053f, -0.02398426f, 
    0.15727615f, 0.02661419f, 0.03103770f, 0.01966704f, -0.07216837f, 0.17491150f, 0.01714488f, 0.05739321f, 
    0.00050639f, 0.25347024f, -0.05470863f, 0.05266827f, -0.06446619f, 0.03694854f, -0.01355335f, 0.06383977f, 
    -0.05742279f, 0.10654566f, 0.03097313f, 0.09322205f, 0.24173743f, 0.06638285f, 0.08726227f, -0.12812647f, 
    0.12086717f, -0.08137814f, -0.05480758f, -0.04179154f, -0.02788050f, 0.06352828f, 0.14682844f, -0.00612431f, 
    -0.11534353f, -0.10921591f, 0.05191661f, 0.28597781f, -0.25255436f, 0.08454681f, 0.06865332f, -0.11260355f, 
    0.03147358f, 0.08507667f, 0.02559276f, 0.05841810f, 0.10757914f, -0.16594730f, -0.10295812f, 0.43192929f, 
    0.11482341f, 0.08883183f, -0.10441117f, 0.07574920f, 0.17294464f, 0.03722626f, -0.14707580f, 0.15933011f, 
    -0.11563458f, 0.07523376f, -0.21595529f, -0.30340815f, 0.19353856f, 0.01089526f, -0.08566386f, 0.10646225f, 
    -0.00514887f, 0.11907838f, -0.06581831f, 0.02083009f, 0.07798795f, -0.13665019f, -0.20568195f, -0.09838408f, 
    -0.06435238f, -0.09838518f, 0.00712525f, -0.12234326f, 0.21907033f, -0.07718193f, -0.03644577f, 0.00639567f, 
    0.28411788f, 0.14427084f, -0.01133393f, -0.17408259f, 0.06623599f, 0.06416507f, -0.19276187f, -0.12964702f, 
    0.08181424f, -0.14447197f, -0.04636318f, 0.07073423f, 0.27676252f, 0.35558811f, 0.03576583f, 0.01787627f, 
    -0.13784473f, -0.08932580f, 0.05431258f, 0.03753188f, 0.00541922f, -0.17519541f, 0.01704454f, 0.03828591f, 
    -0.18749063f, 0.06218014f, -0.02407572f, -0.06106926f, -0.00538500f, -0.01000520f, -0.12582566f, -0.08089563f, 
    -0.06987547f, 0.00683800f, -0.06256613f, -0.01151610f, 0.20156811f, -0.02693740f, -0.01416161f, 0.10899622f, 
    -0.08322890f, 0.06770673f, 0.00029195f, -0.14710629f, 0.19615741f, 0.02235765f, 0.17967936f, -0.08105978f, 
    -0.04681476f, -0.08352777f, 0.08255001f, 0.20761643f, -0.10236175f, 0.17489105f, 0.06896468f, 0.03645851f, 
    0.00013224f, 0.08506601f, -0.03568585f, 0.08147816f, 0.21217619f, 0.23823462f, -0.02010985f, 0.19887903f, 
    -0.18116727f, -0.01608334f, -0.13220139f, 0.06472949f, -0.12580730f, 0.12987611f, -0.02696221f, -0.06830407f, 
    0.34567696f, 0.34273615f, 0.33442116f, 0.06597128f, 0.00411806f, -0.05154635f, -0.18111125f, 0.17550954f, 
    -0.08796109f, 0.05251004f, -0.06112515f, -0.02713838f, 0.22038123f, 0.17057532f, -0.18367483f, 0.22890210f, 
    0.11888471f, 0.00642468f, 0.20324691f, -0.04988163f, 0.03539220f, 0.01829170f, 0.05925619f, -0.16379267f, 
    -0.09287737f, -0.21195799f, 0.10099887f, -0.26586235f, -0.03785143f, 0.08429869f, -0.12607044f, 0.00157536f, 
    -0.08691479f, -0.03309330f, 0.08334241f, 0.00785142f, 0.02775108f, 0.09042800f, 0.10162332f, -0.12107453f, 
    0.19158907f, 0.06947719f, -0.10223114f, -0.03757878f, -0.19046107f, 0.06679593f, 0.14549300f, 0.10713222f, 
    0.43417260f, -0.10490094f, -0.22195163f, 0.18021546f, -0.10840010f, -0.08189233f, -0.02068971f, -0.13577810f, 
    0.04452597f, -0.08104666f, 0.11307727f, -0.00367637f, 0.03936249f, -0.36753550f, 0.18683833f, -0.15870574f, 
    0.10592132f, -0.06454622f, -0.08804636f, 0.02986265f, -0.12411144f, -0.03657300f, -0.13294289f, 0.00588552f, 
    0.17090456f, 0.17058419f, -0.00527795f, 0.06995666f, -0.03341420f, -0.04352939f, 0.05874949f, 0.16504394f, 
    0.00334505f, -0.02934416f, 0.02045056f, 0.03829563f, -0.14603081f, 0.02999087f, -0.13515507f, -0.08932031f, 
    0.12872133f, -0.10766106f, -0.04913605f, -0.01713976f, -0.01229189f, -0.05789727f, -0.10787909f, -0.05796845f, 
    -0.09399100f, 0.10259889f, 0.07867815f, -0.10850117f, 0.05786214f, 0.09230059f, -0.02066012f, -0.11817794f, 
    0.09212440f, -0.03145165f, 0.03710712f, 0.01847740f, -0.07207632f, 0.13667242f, -0.18314530f, -0.11998042f, 
    0.05275179f, -0.08810325f, 0.03580070f, -0.03687357f, -0.08626816f, 0.14591856f, -0.06022660f, -0.19270121f, 
    -0.01473803f, 0.04913139f, 0.04677934f, -0.03489709f, -0.03193377f, 0.06308414f, -0.06032047f, 0.00553603f, 
    0.01685702f, -0.04368844f, -0.06217814f, -0.02964836f, -0.06240626f, 0.05710373f, -0.06224946f, -0.05067889f, 
    -0.02489794f, -0.04963536f, 0.03244032f, 0.00017235f, 0.05655288f, 0.04088722f, -0.02967311f, -0.05503533f, 
    -0.02336754f, 0.01551178f, -0.01564248f, -0.05341922f, -0.04253660f, -0.04023984f, 0.04176638f, -0.06882887f, 
    0.04920239f, -0.01245245f, 0.00124266f, -0.05951713f, -0.01680836f, 0.03701173f, -0.07734415f, 0.03934456f, 
    0.04882842f, -0.04827554f, 0.05222470f, -0.03108536f, -0.05853340f, 0.01886354f, -0.02292319f, -0.06158354f, 
    -0.01093415f, 0.05566840f, 0.03094711f, -0.03761179f, -0.08265996f, 0.01536785f, -0.03112790f, -0.00973366f, 
    0.00561863f, 0.03331617f, -0.07811638f, 0.01439359f, -0.04501117f, -0.06928076f, 0.04790715f, -0.00611547f, 
    -0.03032739f, 0.04256524f, 0.03555326f, 0.00544967f, 0.02690525f, -0.04750456f, -0.04635477f, -0.03503665f, 
    -0.00029909f, -0.03109015f, -0.03688407f, -0.06124039f, 0.02094791f, -0.02205197f, -0.04396587f, -0.07458533f, 
    -0.02255097f, -0.01425842f, -0.01889852f, 0.06207365f, -0.02668115f, -0.07317157f, -0.01610938f, -0.00118891f, 
    -0.03526034f, 0.06039833f, 0.00958574f, -0.05758300f, -0.06124608f, 0.02102360f, 0.04018958f, -0.04961159f, 
    0.05954902f, 0.00714419f, 0.03828910f, 0.00317723f, -0.04928889f, 0.03373062f, 0.05381838f, 0.04815356f, 
    -0.05048511f, 0.05257340f, -0.00724139f, -0.04153104f, 0.05964833f, 0.06471290f, 0.04469448f, -0.05460241f, 
    -0.03415979f, -0.05968592f, -0.00101659f, 0.06135843f, -0.07799059f, -0.03271836f, -0.05543697f, 0.05809082f, 
    0.04691146f, 0.02798822f, -0.00204900f, -0.05956080f, -0.06243373f, 0.04848787f, -0.03987024f, 0.05583565f, 
    -0.05093963f, -0.06002533f, 0.05724638f, 0.06178114f, -0.04314674f, -0.07357948f, -0.06016212f, -0.06417322f, 
    -0.05481609f, -0.07107507f, -0.01808987f, -0.02215922f, 0.02769860f, -0.04008342f, 0.06833790f, -0.00497854f, 
    0.01434749f, -0.02510418f, 0.00712008f, -0.00544083f, -0.04624279f, -0.07221717f, -0.04406163f, 0.02443050f, 
    0.03294479f, -0.07586031f, 0.00488843f, -0.05947151f, 0.04912569f, -0.04340610f, 0.04966442f, 0.03390933f, 
    0.04761635f, 0.04979486f, -0.03284698f, -0.01687176f, 0.05494249f, 0.00523759f, 0.01433222f, 0.02874272f, 
    -0.01831632f, 0.00062101f, -0.02474277f, -0.04114192f, -0.07168231f, 0.00898011f, -0.00968060f, 0.00380003f, 
    -0.02835880f, -0.07309023f, -0.06798271f, -0.00295423f, -0.08261372f, 0.00022222f, -0.03303094f, 0.04416332f, 
    0.02428749f, -0.01696343f, -0.06575274f, -0.07752879f, -0.05643022f, 0.03051244f, 0.05868141f, -0.03587820f, 
    -0.01246749f, 0.04062878f, -0.05494244f, -0.06027640f, 0.05561421f, 0.02375167f, 0.03893287f, -0.05173483f, 
    0.05117758f, 0.00794749f, -0.05851640f, 0.04045068f, 0.04620373f, -0.06212230f, -0.00070554f, -0.02484211f, 
    -0.07200301f, -0.03384160f, -0.01823890f, 0.06245742f, -0.07185075f, 0.06054002f, 0.06445073f, 0.01016846f, 
    0.00316227f, 0.04575290f, 0.05640863f, -0.01908431f, 0.02954278f, 0.05617112f, -0.01479199f, 0.03946221f, 
    0.00426610f, 0.01067513f, -0.05106324f, 0.03591557f, -0.00654152f, 0.05371617f, 0.06233716f, -0.02627280f, 
    -0.00587673f, -0.02344537f, -0.01506818f, 0.05060408f, 0.01789853f, 0.01109914f, -0.07948336f, -0.05865617f, 
    0.02550748f, 0.05306788f, -0.00120191f, -0.03633187f, 0.03890182f, 0.05174225f, 0.05296639f, -0.07286140f, 
    -0.05439873f, -0.03283516f, -0.02534724f, -0.01966407f, -0.03527590f, 0.04214365f, -0.06553501f, -0.05972992f, 
    -0.06144987f, -0.07952976f, 0.00037393f, 0.00371243f, 0.03619299f, -0.03166682f, -0.03820432f, 0.01269316f, 
    0.00082613f, 0.00921925f, 0.01211010f, -0.03005478f, 0.01601958f, 0.02524733f, -0.06381757f, 0.03577266f, 
    -0.01176096f, 0.02124843f, -0.05363712f, -0.07161584f, -0.04312671f, -0.07352920f, 0.05654410f, 0.01434554f, 
    -0.04951469f, -0.06469267f, -0.01749234f, 0.05190209f, 0.00680300f, -0.05263857f, -0.04530452f, -0.05967494f, 
    -0.03265430f, -0.04956227f, 0.04694071f, 0.01422485f, -0.02458077f, 0.01192675f, -0.07323095f, -0.04025519f, 
    0.01406768f, 0.05302264f, -0.06911890f, 0.03071554f, -0.06298893f, -0.07013140f, -0.01243219f, -0.04787764f, 
    -0.07932530f, -0.02853077f, 0.04414319f, 0.03043856f, -0.02629565f, -0.03262979f, -0.06240544f, 0.03204695f, 
    0.05618488f, 0.06270897f, -0.05584900f, -0.00952071f, -0.05523498f, -0.03600194f, -0.06939550f, 0.03864009f, 
    0.04121538f, -0.06244811f, -0.06937096f, -0.03777613f, -0.03397393f, -0.07014826f, -0.02414862f, -0.05256943f, 
    0.01022056f, -0.05223875f, 0.03274299f, -0.05322217f, -0.01851747f, 0.00042230f, -0.02893268f, 0.04535639f, 
    0.04332968f, 0.01290824f, 0.04050060f, 0.02874397f, 0.06178608f, 0.05884148f, -0.06029381f, 0.02129821f, 
    -0.01366356f, -0.04352433f, -0.05133430f, -0.03503186f, 0.01374610f, 0.00145811f, 0.02834558f, -0.03507027f, 
    0.05092519f, -0.02280243f, 0.00542567f, 0.01277381f, 0.01458328f, 0.00339750f, 0.06156787f, 0.04071120f, 
    -0.05480161f, -0.04523053f, 0.05372277f, 0.00893053f, -0.01615287f, 0.04347601f, 0.02544093f, -0.07676814f, 
    -0.05637326f, 0.03942293f, -0.05550344f, -0.05956338f, -0.06702240f, -0.08049914f, 0.01962098f, -0.06676132f, 
    0.01644281f, -0.06057699f, 0.06119918f, -0.03006114f, 0.04209119f, 0.00500445f, -0.03415537f, -0.07332087f, 
    -0.56181055f, 0.02667236f, -0.13780993f, 0.07570343f, -0.16104367f, -0.03128048f, 0.14137159f, 0.00241364f, 
    -0.01744245f, 0.03150304f, -0.04540519f, 0.13269059f, -0.03864565f, -0.02382586f, 0.18474586f, -0.11659943f, 
    0.08099569f, -0.03423584f, 0.02559836f, -0.01035226f, 0.06825752f, 0.08474743f, -0.02623864f, 0.00013734f, 
    0.36804897f, -0.01534191f, 0.07716498f, 0.21002072f, -0.00385914f, -0.01633270f, 0.09139550f, 0.01982867f, 
    0.17657188f, -0.13971743f, 0.02925528f, 0.12047593f, -0.07304867f, -0.04263674f, 0.22143842f, -0.30667791f, 
    0.24563745f, -0.03416085f, 0.02289450f, -0.00069753f, -0.02038472f, 0.11422053f, -0.07569487f, 0.04312767f, 
    0.46722931f, 0.15001912f, -0.01843474f, 0.04128280f, -0.10620853f, 0.06455939f, 0.03441609f, 0.05445977f, 
    -0.05447412f, 0.14682823f, 0.02566960f, 0.03399500f, -0.29510421f, -0.09851950f, 0.01758227f, 0.00511645f, 
    0.07081621f, -0.01683126f, 0.15546860f, -0.04426870f, 0.04834031f, -0.01336006f, 0.05981706f, 0.12414424f, 
    -0.39965042f, -0.18946241f, 0.01556382f, -0.17980625f, -0.14757097f, 0.06912722f, 0.05810061f, 0.03293686f, 
    -0.04714048f, -0.02313957f, -0.01976912f, 0.05570409f, 0.24108920f, 0.04520585f, -0.07388797f, -0.04386085f, 
    -0.11967646f, 0.11130473f, -0.05362501f, -0.02657321f, -0.08071972f, 0.08094504f, 0.10986888f, 0.02974174f, 
    -0.37761259f, 0.22012401f, 0.09870341f, 0.07324886f, -0.16970101f, -0.08516042f, 0.04448209f, 0.01595842f, 
    0.16125964f, 0.01427780f, -0.14042161f, 0.03994979f, -0.23029995f, -0.04988136f, 0.22104521f, -0.15842061f, 
    -0.20693399f, -0.18415213f, 0.00142733f, -0.02924533f, 0.21243063f, 0.06583840f, 0.00832637f, -0.04949805f, 
    -0.16394128f, -0.04798563f, 0.29060680f, 0.05528232f, 0.09875061f, -0.07526745f, -0.00317274f, 0.06062085f, 
    0.05736063f, 0.00123514f, 0.02774053f, 0.03587964f, 0.01499338f, 0.08748887f, -0.19905362f, -0.07319471f, 
    -0.08431306f, 0.06484188f, 0.30899763f, -0.08886527f, 0.11649507f, 0.00811585f, 0.08141549f, 0.02237671f, 
    0.10857129f, -0.18447892f, 0.11128247f, 0.16644841f, 0.03246435f, -0.02519902f, -0.04931455f, 0.17402491f, 
    0.12117722f, -0.11882015f, -0.00412410f, -0.11024334f, 0.00478150f, 0.09636651f, -0.05214950f, 0.05698255f, 
    -0.12867880f, -0.13589858f, -0.03714274f, -0.10980833f, 0.01816898f, 0.20716031f, -0.09763236f, 0.15902062f, 
    -0.16971885f, -0.07936560f, -0.12140325f, -0.02768233f, -0.07446893f, 0.04654742f, 0.05534211f, -0.00605639f, 
    -0.02292949f, -0.09597304f, 0.09958804f, 0.08652797f, 0.58583075f, 0.17059274f, 0.44218373f, 0.24836889f, 
    0.14214307f, -0.01417577f, 0.07733159f, 0.08304887f, 0.08916032f, 0.17832583f, 0.05859005f, 0.00854061f, 
    0.16302620f, 0.07201380f, -0.11246555f, 0.06011295f, 0.19012083f, 0.12473257f, 0.01578874f, -0.05097315f, 
    -0.05426881f, -0.13552079f, -0.09093508f, -0.13676597f, -0.09962047f, -0.18667738f, -0.13646378f, -0.15102115f, 
    0.01701605f, 0.14655796f, -0.15817520f, -0.06496198f, -0.00319378f, -0.09118736f, -0.01662363f, 0.24048394f, 
    0.00127866f, -0.14534581f, -0.12867859f, 0.00571992f, -0.13818499f, -0.23651247f, -0.05191793f, 0.00250678f, 
    -0.09102425f, 0.20446165f, 0.08795208f, 0.27815458f, -0.43508729f, 0.45022419f, -0.30761525f, 0.14650013f, 
    -0.02800367f, -0.00550491f, -0.09997277f, 0.09159402f, 0.07153773f, -0.10133300f, 0.04254311f, -0.04221878f, 
    -0.64866626f, -0.41361725f, 0.16173910f, 0.35777453f, 0.12311174f, -0.05704486f, 0.17313169f, -0.09843750f, 
    0.19572918f, -0.08518384f, 0.11000382f, -0.00687127f, 0.14931355f, -0.16737650f, 0.11776072f, -0.09629613f, 
    0.10106815f, 0.04697330f, -0.10428365f, -0.07529902f, 0.01102227f, -0.04294037f, -0.00803598f, -0.02368833f, 
    0.28927690f, 0.17643346f, 0.10581726f, -0.16602787f, 0.17893596f, -0.06387956f, -0.07257723f, -0.16064765f, 
    0.10114451f, -0.02191420f, 0.06606422f, 0.13641411f, 0.18457323f, -0.21008499f, 0.26553378f, 0.05844551f, 
    0.10812529f, -0.14558247f, 0.10990287f, 0.15838334f, -0.02874980f, 0.14573294f, -0.02000167f, 0.03514933f, 
    0.17151000f, 0.02658545f, -0.04172780f, -0.14943172f, 0.03832538f, -0.14559127f, -0.06939513f, -0.01386969f, 
    0.02994636f, 0.02717640f, 0.13321316f, 0.00746959f, -0.32511571f, 0.05134005f, 0.09189048f, -0.02375106f, 
    0.16498540f, 0.20385437f, 0.09596258f, -0.09279751f, -0.02082993f, 0.18895751f, -0.11055358f, 0.14772236f, 
    0.26191545f, 0.07095811f, -0.02954132f, 0.04639149f, -0.17689690f, -0.02409288f, -0.28143737f, -0.01950584f, 
    0.04625148f, 0.11100658f, 0.09007969f, 0.16127534f, -0.40021905f, 0.19247489f, 0.04263237f, -0.04462456f, 
    0.02176694f, -0.00665081f, 0.09149902f, -0.00260142f, 0.27398804f, -0.10292066f, 0.04077739f, -0.03367192f, 
    0.27835384f, 0.23393737f, 0.18108955f, -0.00699379f, -0.01880475f, -0.02422327f, -0.06452969f, -0.03211262f, 
    -0.12887789f, -0.01007337f, 0.12262107f, -0.07777791f, 0.08115662f, 0.02321072f, -0.09782715f, 0.23793264f, 
    0.11531115f, 0.11217459f, 0.18709572f, 0.09960485f, 0.08569454f, -0.03932321f, -0.06750128f, 0.10236939f, 
    -0.39485043f, 0.03743485f, -0.10497794f, -0.10514766f, 0.10924918f, -0.00477217f, 0.04566278f, 0.20036094f, 
    -0.00468050f, 0.12151357f, -0.06653411f, -0.15655319f, -0.38667041f, 0.09414631f, 0.20891631f, -0.15012504f, 
    -0.15074034f, 0.06207403f, 0.08435281f, 0.09986022f, -0.03845915f, 0.04091582f, 0.09611404f, -0.07596946f, 
    0.07230435f, 0.02637298f, 0.02057780f, -0.01798529f, 0.04851715f, -0.00518711f, -0.05133763f, -0.07661710f, 
    0.05821798f, -0.01730770f, 0.06338971f, -0.03560911f, 0.01369082f, -0.00766250f, -0.05858062f, 0.05527091f, 
    -0.07854991f, 0.00523087f, -0.03474206f, -0.00260045f, 0.04093494f, 0.05953350f, 0.04412637f, -0.06812793f, 
    0.00971795f, -0.03404060f, 0.01829000f, 0.00383641f, 0.03542501f, -0.00550678f, 0.01240292f, 0.00119986f, 
    0.03119798f, 0.04939483f, 0.03495443f, 0.03070314f, -0.04471722f, -0.07038525f, -0.06151287f, -0.06530704f, 
    -0.02483403f, -0.01596072f, 0.04830873f, -0.00139276f, -0.01505083f, 0.03318919f, 0.02135240f, 0.04970100f, 
    0.03167941f, 0.05103471f, -0.00801066f, -0.04214974f, 0.02187478f, -0.07237706f, -0.04735546f, -0.03209375f, 
    -0.06535202f, -0.06780899f, -0.00085767f, -0.03077201f, -0.03031552f, -0.04175487f, 0.03547883f, -0.00539234f, 
    -0.00317340f, -0.04129215f, 0.05466420f, -0.06504188f, -0.03268354f, -0.00467622f, 0.06082362f, -0.06767965f, 
    -0.01417391f, -0.05400647f, -0.03523749f, -0.01105126f, -0.07464769f, -0.07933512f, -0.03596724f, -0.01527880f, 
    0.01849929f, -0.02441233f, -0.00661346f, -0.06606508f, -0.03142601f, -0.05054237f, 0.04206260f, 0.04454089f, 
    -0.03836284f, 0.01366230f, 0.03038898f, -0.00696581f, -0.02679037f, 0.04006176f, 0.05423243f, -0.04914697f, 
    -0.06566799f, -0.03525152f, 0.00176501f, -0.04510657f, 0.04305582f, -0.05098937f, -0.00713209f, 0.02429336f, 
    -0.06020305f, -0.03981482f, -0.03625350f, 0.05162494f, -0.05027027f, -0.00439906f, -0.06443655f, -0.03821433f, 
    0.02906258f, -0.00110408f, 0.01535441f, -0.06507736f, -0.02143242f, -0.04671720f, -0.08270250f, -0.07052457f, 
    0.04909509f, 0.01480253f, 0.00259659f, -0.06464618f, -0.01570692f, -0.05105636f, -0.03662126f, 0.02407114f, 
    -0.02430856f, 0.00702994f, 0.00531111f, 0.01086355f, -0.00720117f, -0.00799195f, -0.00893756f, -0.06956473f, 
    0.03688709f, -0.03639152f, 0.01596639f, -0.07156184f, -0.04239152f, -0.05035758f, -0.06476220f, -0.06176504f, 
    -0.06682760f, -0.05142313f, 0.02574387f, -0.01678818f, 0.06328589f, -0.03932623f, 0.06766703f, 0.05103161f, 
    0.04896050f, -0.05223545f, 0.02963337f, 0.00698665f, 0.05200514f, 0.02344656f, -0.01764538f, -0.05319590f, 
    0.06068315f, -0.07547870f, 0.05143776f, -0.06845881f, -0.03811979f, -0.05061719f, -0.00557038f, 0.03158796f, 
    -0.05373370f, 0.04795726f, 0.00727512f, -0.02934334f, 0.05107361f, -0.01105752f, 0.02463592f, 0.05624982f, 
    -0.01450465f, -0.01665190f, 0.05763042f, -0.04359788f, -0.06396770f, -0.04759519f, -0.00973987f, -0.01511944f, 
    0.00134374f, -0.05914854f, 0.03703469f, -0.01549225f, 0.06253652f, -0.02214822f, -0.02478266f, -0.03592310f, 
    0.05217026f, 0.12488396f, 0.06325963f, 0.16264077f, 0.15090306f, 0.07814042f, 0.19716264f, 0.36654085f, 
    -0.17701213f, 0.13055930f, 0.16065344f, 0.14434239f, 0.15524329f, 0.01256921f, -0.03167063f, 0.21197344f, 
    -0.13879642f, -0.14093028f, -0.26330107f, -0.21078761f, 0.02919153f, 0.05413741f, 0.01482654f, -0.04682600f, 
    0.15276021f, 0.24676825f, 0.05231493f, 0.18080825f, -0.00922392f, 0.10582173f, -0.03454731f, 0.12393763f, 
    0.04762513f, -0.14892265f, -0.13062087f, 0.09050766f, -0.35916424f, 0.34691206f, -0.17498790f, 0.05841818f, 
    0.02410787f, 0.06605973f, -0.20398116f, -0.05324994f, -0.14111194f, 0.05569431f, 0.01547338f, 0.13904630f, 
    0.43660077f, 0.17802343f, 0.12245876f, -0.07727849f, 0.02227797f, -0.03183071f, 0.04462513f, 0.00227123f, 
    0.09330984f, 0.01828037f, -0.01480325f, 0.08241109f, 0.48342767f, -0.01841581f, -0.31782103f, 0.02660764f, 
    -0.05762887f, 0.00203680f, -0.02391115f, -0.14900395f, 0.11752484f, 0.06386798f, -0.03937478f, 0.06985185f, 
    0.25210795f, -0.19992919f, -0.50387776f, -0.12800999f, -0.11107460f, -0.02321078f, 0.01883125f, -0.17693946f, 
    0.17764395f, -0.15644012f, -0.01506121f, -0.09288644f, -0.16566664f, -0.05470712f, 0.36634672f, -0.17268711f, 
    0.09238174f, 0.13036345f, -0.20827934f, 0.03505872f, 0.24021710f, -0.00957877f, 0.07912046f, 0.13900065f, 
    -0.11663915f, 0.02324175f, -0.16692436f, 0.24042673f, -0.03016344f, -0.06312634f, 0.03651059f, 0.02661010f, 
    0.02529637f, 0.02535017f, 0.06552909f, 0.10696415f, -0.13529527f, 0.01177405f, 0.00242114f, 0.03071574f, 
    0.13390942f, -0.10140509f, -0.02729999f, 0.03866215f, 0.01304716f, -0.15546514f, -0.08961730f, -0.08861095f, 
    -0.27700317f, 0.20018408f, 0.14551559f, 0.10402162f, -0.00609366f, 0.06816441f, -0.11463404f, -0.06466209f, 
    -0.14348660f, -0.14087036f, -0.13327707f, -0.28264832f, 0.07101955f, 0.19672242f, 0.03474836f, -0.08742217f, 
    0.02271010f, -0.13663988f, 0.07416147f, 0.03082994f, 0.02947867f, 0.22538100f, 0.20076635f, -0.02045396f, 
    0.17368448f, -0.11026936f, 0.05784595f, -0.02693974f, -0.15921746f, -0.03469223f, -0.15667899f, -0.33020845f, 
    0.10297547f, 0.11422430f, -0.03094915f, 0.14215358f, 0.04667550f, 0.05166234f, 0.19484851f, 0.35603967f, 
    -0.08685436f, -0.07859131f, -0.27022883f, 0.07214550f, -0.08759119f, 0.23745729f, 0.08777913f, -0.21929850f, 
    -0.10080332f, 0.38691905f, -0.00704350f, -0.17459185f, 0.16804928f, 0.13588732f, -0.02726677f, 0.17424706f, 
    -0.06028151f, -0.30199167f, -0.02046632f, 0.00847260f, 0.06950793f, 0.11900849f, 0.05173200f, -0.12540884f, 
    0.03047343f, 0.14306554f, -0.04002302f, -0.22298823f, 0.03416046f, 0.00274889f, 0.22302021f, 0.12581366f, 
    -0.06349323f, -0.01035042f, -0.04192809f, 0.01698783f, -0.07625238f, 0.01957787f, -0.02509801f, -0.07931963f, 
    0.05806488f, 0.05408360f, -0.00676640f, -0.04533422f, -0.07228723f, -0.07056606f, -0.03300235f, -0.02202213f, 
    -0.03348922f, 0.03534885f, 0.01294321f, -0.03441096f, 0.01698499f, 0.05269292f, 0.03663554f, -0.00230642f, 
    0.01958174f, 0.04634621f, -0.01824591f, 0.03500250f, -0.03129319f, -0.01390861f, -0.03206918f, 0.04318864f, 
    0.05978373f, -0.04436608f, -0.04785949f, -0.05799066f, 0.05381852f, -0.01486164f, 0.00094933f, -0.07032961f, 
    -0.02956834f, 0.00778804f, 0.00007534f, 0.01211547f, -0.02545302f, -0.07354353f, -0.03064194f, -0.03312428f, 
    -0.04922229f, 0.02264481f, -0.03877738f, 0.01555517f, -0.02256308f, 0.01509916f, 0.02829189f, 0.04560329f, 
    -0.07620376f, -0.01416001f, 0.04988066f, -0.01929144f, -0.03237242f, 0.05247076f, -0.00416812f, -0.07635586f, 
    -0.01648890f, -0.00264427f, -0.06581027f, -0.04128721f, -0.01501377f, -0.04378179f, -0.02839156f, -0.05342334f, 
    0.02532537f, 0.01436981f, 0.00061382f, 0.02043927f, -0.05762996f, 0.00974083f, -0.06239229f, -0.05185531f, 
    0.02504566f, 0.04165536f, 0.01763740f, -0.06587069f, 0.03082416f, -0.06196002f, 0.01824158f, 0.01961711f, 
    -0.03304571f, -0.01899525f, -0.04759765f, -0.05556694f, -0.07060459f, -0.04832945f, -0.00335434f, 0.05112274f, 
    0.04607453f, 0.05534705f, -0.02654360f, -0.07680381f, 0.04777889f, -0.06188999f, 0.00267874f, 0.00166967f, 
    0.01551000f, 0.02405470f, -0.04615000f, -0.07349055f, -0.04464613f, -0.07735109f, 0.04257120f, -0.00048245f, 
    0.01224541f, -0.02362794f, 0.05522063f, 0.04567525f, 0.02514223f, -0.04199715f, -0.06220181f, -0.00816286f, 
    0.00166187f, 0.03114828f, -0.02015613f, -0.02813165f, -0.02723791f, 0.05407093f, 0.05583018f, -0.02045423f, 
    -0.03217391f, 0.04248723f, -0.03285355f, 0.04618686f, -0.03707725f, 0.00737718f, 0.06334947f, -0.06804431f, 
    0.04315901f, -0.03652309f, -0.03235923f, -0.00147361f, -0.03174860f, 0.04695588f, -0.07498065f, -0.07129727f, 
    0.00520678f, -0.00173523f, -0.03193691f, -0.02354225f, -0.07722278f, -0.07015166f, 0.03153007f, 0.01251509f, 
    0.02964601f, 0.04375407f, -0.00041958f, -0.01803320f, 0.02426614f, 0.05925892f, 0.01207397f, -0.07867499f, 
    -0.00336553f, 0.02223593f, -0.02332345f, -0.06380481f, -0.01431649f, 0.05543951f, -0.03279828f, -0.04166821f, 
    -0.02393654f, -0.01723799f, 0.01888809f, -0.00493297f, -0.07002341f, -0.00661018f, -0.01718752f, -0.04088050f, 
    -0.00329482f, -0.04131237f, -0.04774514f, -0.04432502f, 0.05736860f, -0.04858100f, -0.01186810f, -0.05265522f, 
    -0.05255499f, -0.02155387f, 0.00808114f, -0.04169225f, -0.08104617f, 0.02951446f, -0.06306037f, 0.00643871f, 
    0.06270245f, -0.04946050f, 0.14474936f, 0.05523022f, 0.16259767f, 0.08372109f, -0.04934182f, 0.13360161f, 
    -0.00823393f, -0.02298372f, 0.00228858f, 0.17110008f, 0.20494017f, 0.08034522f, 0.02763947f, 0.23490931f, 
    0.08375970f, -0.13271400f, 0.10262924f, 0.03579522f, 0.12660207f, 0.05996843f, 0.05756274f, -0.00574545f, 
    -0.05301109f, -0.07244711f, -0.05624661f, -0.21367580f, -0.04669052f, 0.10494561f, -0.03005253f, 0.11053036f, 
    0.04888777f, 0.04360757f, 0.09408905f, 0.07158519f, 0.29312986f, -0.07278952f, -0.11178314f, -0.14186671f, 
    -0.03570192f, -0.01773584f, 0.05116265f, -0.02774159f, -0.06309283f, -0.00983522f, 0.00786161f, 0.01183398f, 
    0.13085362f, 0.06463941f, 0.14287925f, -0.30242833f, 0.27973855f, -0.06724354f, 0.05171995f, -0.11047959f, 
    0.09803692f, 0.00362299f, 0.02811315f, -0.09757591f, -0.10214524f, -0.03226530f, 0.02433890f, 0.43179742f, 
    0.07422191f, -0.00825185f, 0.07730124f, 0.03569655f, -0.14438049f, 0.02703139f, 0.01903912f, -0.08796106f, 
    0.22924705f, 0.01604465f, 0.14804420f, -0.13590273f, 0.17649531f, 0.07178169f, 0.10978776f, 0.02692262f, 
    0.03601086f, 0.07436626f, 0.12272195f, 0.10808218f, -0.19812225f, -0.11197152f, 0.01012218f, -0.23177855f, 
    -0.00107348f, 0.02597405f, 0.00732430f, -0.01910315f, -0.03851189f, -0.14007935f, -0.00907168f, -0.05009364f, 
    0.51682603f, 0.00217023f, -0.03078719f, 0.29222706f, -0.12273297f, 0.02303277f, 0.01068850f, -0.04204209f, 
    0.08175465f, -0.16375448f, 0.03131877f, 0.04983060f, -0.49127761f, -0.35729179f, -0.05352903f, 0.16950220f, 
    -0.07762389f, 0.19740966f, -0.18010500f, -0.01516239f, -0.05243191f, 0.00934603f, -0.03469449f, 0.10003156f, 
    -0.04486904f, 0.31496820f, -0.04818330f, -0.16519502f, 0.17568710f, 0.18592964f, 0.16107576f, -0.08613579f, 
    -0.00919609f, -0.02880768f, -0.12849392f, 0.10823699f, 0.08165341f, 0.24553035f, 0.15791659f, -0.12508394f, 
    -0.05029900f, -0.05151185f, 0.16198322f, 0.03868889f, 0.00842598f, -0.12286983f, 0.09368586f, -0.06109539f, 
    -0.40134546f, 0.11127618f, 0.18032016f, -0.12192439f, -0.06813370f, 0.12944297f, -0.01429765f, -0.03430298f, 
    -0.07278540f, -0.05191275f, -0.17695792f, -0.00355601f, 0.03224327f, -0.38718024f, -0.18558003f, 0.12405702f, 
    0.00005450f, 0.13239710f, 0.15673922f, 0.08637794f, 0.13186356f, 0.16551112f, 0.00763971f, 0.06009264f, 
    0.17518193f, 0.04860520f, -0.02317572f, -0.01569946f, -0.07279625f, 0.00679560f, -0.11568198f, 0.12134154f, 
    0.09803923f, -0.06531397f, 0.03550968f, 0.08459128f, -0.11648117f, -0.19059943f, 0.06524269f, -0.06103055f, 
    0.02985717f, -0.01628557f, -0.05562159f, -0.12361216f, -0.13672104f, -0.07850949f, -0.13346502f, 0.01846971f, 
    -0.11059330f, -0.26418355f, -0.04213817f, 0.05159507f, 0.25699857f, 0.09075504f, -0.03239425f, 0.27124718f, 
    -0.11414202f, 0.18052514f, 0.14742345f, 0.16820760f, -0.14510313f, 0.20599784f, 0.12556820f, -0.19147231f, 
    -0.08051237f, 0.00762790f, 0.06779654f, -0.04514250f, 0.13225946f, -0.05194225f, -0.05700835f, -0.07411839f, 
    -0.00005823f, 0.21234576f, 0.03420652f, -0.31519479f, 0.04951172f, 0.16470020f, -0.03785487f, 0.15536977f, 
    -0.08394141f, -0.14236240f, -0.07242329f, -0.08014689f, 0.41730320f, 0.12640816f, -0.12561356f, -0.01567271f, 
    -0.00224707f, 0.02800929f, 0.04995039f, 0.11674619f, -0.04900635f, 0.06886877f, -0.03160769f, 0.02589829f, 
    -0.13993251f, -0.23428033f, 0.07610700f, 0.02772392f, -0.03878892f, -0.11919393f, -0.07756235f, -0.05224226f, 
    0.00756160f, -0.09445524f, 0.18508911f, -0.01667625f, 0.10351528f, 0.24916047f, 0.02757851f, -0.15031861f, 
    0.04690685f, 0.03647558f, 0.08049508f, 0.16404761f, 0.00343114f, 0.05616004f, 0.02994682f, -0.02865793f, 
    -0.02940302f, 0.42103860f, -0.05598669f, -0.21051532f, 0.09719047f, 0.14572939f, 0.21139595f, 0.00344522f, 
    -0.04190911f, 0.01765317f, 0.02248657f, -0.07811396f, -0.20524319f, -0.21463044f, 0.17186074f, -0.02717382f, 
    0.05443714f, 0.02071759f, -0.06549227f, 0.02871254f, -0.09342764f, -0.07815945f, 0.07723894f, -0.11221159f, 
    0.53504288f, -0.36566579f, -0.03719838f, 0.22605507f, -0.03109043f, 0.08127631f, 0.13140158f, -0.03170132f, 
    0.11171375f, -0.05970188f, 0.01934656f, 0.14557646f, -0.22158676f, -0.17931974f, -0.09201662f, 0.36522505f, 
    -0.07007580f, 0.05165432f, -0.07604154f, -0.05797978f, 0.13380812f, 0.07069088f, 0.07502930f, -0.12181974f, 
    -0.00186156f, 0.14747088f, 0.19345737f, -0.08410184f, 0.06265675f, 0.15898535f, 0.02024100f, 0.10193443f, 
    -0.11171549f, -0.03989254f, -0.19817211f, -0.20020500f, -0.32315752f, 0.32718897f, 0.26147723f, -0.09090587f, 
    0.18626481f, 0.12853839f, -0.04133106f, 0.06613688f, -0.02103905f, 0.14779258f, 0.19409639f, -0.04991839f, 
    -0.28479815f, 0.03958682f, 0.12950204f, -0.28556401f, -0.07439335f, 0.12989855f, -0.01290823f, -0.10413825f, 
    -0.23963355f, -0.04204335f, -0.03457956f, 0.01920114f, 0.15393367f, -0.18979849f, -0.26027030f, 0.31599525f, 
    -0.13837735f, 0.02673389f, 0.01186437f, 0.12689075f, -0.03145204f, 0.02066633f, 0.10187797f, -0.15717150f, 
    -0.03738625f, -0.06568680f, -0.01490451f, 0.07894874f, 0.07620182f, -0.04748529f, -0.19352145f, -0.04583555f, 
    -0.00379847f, -0.00250612f, 0.06049253f, -0.05034025f, -0.26580134f, -0.09995030f, 0.10722394f, -0.04693535f, 
    -0.06027269f, 0.16280341f, 0.10367045f, -0.08077879f, -0.05246364f, 0.07894982f, -0.00435253f, 0.20657603f, 
    -0.18116640f, -0.15052487f, -0.22961193f, 0.32081881f, -0.06877795f, -0.05305600f, 0.08656792f, 0.11940219f, 
    -0.11660036f, 0.14021024f, 0.10766745f, -0.04786288f, 0.17119144f, 0.22598095f, -0.13588379f, -0.11275788f, 
    -0.06234917f, -0.05308680f, -0.04502090f, -0.01428854f, 0.02643359f, -0.05000146f, -0.11860473f, -0.01579930f, 
    -0.36539114f, 0.09406970f, 0.17389011f, 0.08854588f, 0.06081182f, -0.04381340f, 0.01219506f, -0.07413299f, 
    -0.07851636f, -0.23280126f, 0.01955922f, -0.01917533f, -0.05305008f, 0.15921809f, -0.04960803f, -0.23601125f, 
    0.00398176f, 0.14680985f, -0.27528915f, 0.07786930f, -0.04786814f, 0.06978597f, 0.01534660f, -0.11980853f, 
    0.11105432f, -0.17815691f, -0.05425876f, 0.28681192f, -0.08570395f, 0.05718644f, 0.04727317f, 0.07548361f, 
    -0.04644052f, 0.06013028f, 0.01840139f, 0.07186037f, -0.11269703f, 0.25608152f, -0.06352753f, -0.36322218f, 
    0.05216710f, 0.09735444f, 0.00556368f, 0.12585066f, -0.15599218f, 0.00044261f, 0.07982271f, 0.02007960f, 
    -0.10819253f, 0.17643972f, 0.04572105f, -0.03520767f, 0.05281822f, 0.02740668f, 0.13691111f, -0.05227776f, 
    -0.02499982f, -0.06630301f, -0.09852249f, -0.00581154f, 0.41471586f, -0.11657235f, 0.06962340f, -0.10644712f, 
    -0.03205300f, -0.00426960f, 0.03977365f, 0.27888370f, 0.02449458f, -0.05894595f, -0.10510655f, -0.15440701f, 
    -0.00487486f, -0.00007386f, -0.20182148f, -0.12206580f, 0.01105077f, -0.11331358f, 0.16972823f, 0.16165170f, 
    -0.05164033f, -0.01137786f, -0.07847541f, 0.04039149f, 0.21847804f, 0.02396855f, -0.08220420f, -0.15305421f, 
    0.12527734f, 0.02130986f, 0.10691378f, -0.03011162f, 0.06709325f, -0.01735545f, 0.13465525f, -0.15506950f, 
    0.18912779f, 0.01554894f, -0.02167922f, 0.20987034f, -0.12644160f, -0.06334133f, -0.10873149f, -0.06418602f, 
    -0.10521553f, -0.10473259f, -0.15631045f, -0.07016803f, -0.04045441f, -0.27326322f, 0.08971740f, -0.09555214f, 
    0.04790242f, -0.07217412f, 0.06553105f, 0.10254809f, 0.18261179f, 0.04353255f, 0.00690183f, -0.05622175f, 
    -0.07882000f, 0.01029700f, 0.16771157f, 0.04308375f, -0.08335879f, -0.02533212f, -0.01907637f, -0.20196612f, 
    0.06384539f, -0.05894382f, -0.10917568f, -0.09657072f, 0.18365803f, -0.03672962f, -0.19395447f, 0.07496500f, 
    -0.19800934f, -0.23919880f, 0.02471508f, 0.00308927f, -0.14545144f, -0.04680722f, 0.17986809f, 0.00625303f, 
    -0.24234036f, 0.07268139f, -0.06693681f, 0.09396121f, -0.05798800f, -0.12936400f, -0.05203200f, 0.13229030f, 
    -0.10818966f, -0.14405090f, -0.01986981f, -0.04543225f, 0.06917430f, 0.04765271f, -0.17548166f, -0.23839390f, 
    -0.00387931f, 0.16302323f, 0.00418760f, -0.12748648f, -0.03423355f, 0.10129708f, 0.09515519f, 0.06076576f, 
    -0.10734430f, 0.39996347f, -0.17351013f, -0.01765755f, -0.00280528f, 0.00991621f, 0.02912135f, -0.06957045f, 
    -0.06000005f, -0.10418452f, 0.01895344f, 0.03037653f, 0.01547844f, -0.10117926f, 0.11661354f, 0.12126889f, 
    -0.00480091f, 0.00904337f, 0.08756232f, 0.03487253f, 0.09207290f, -0.02996971f, 0.00867390f, 0.03036137f, 
    0.41622317f, -0.13369147f, 0.02897713f, 0.26475367f, -0.07503103f, 0.07393264f, 0.00235519f, 0.10951654f, 
    0.05616859f, 0.07307255f, 0.16855833f, 0.28776410f, -0.26766947f, 0.31070372f, 0.02620931f, -0.10281647f, 
    0.12468480f, 0.03439708f, 0.05697409f, 0.00370540f, -0.03312628f, -0.09420178f, -0.06868884f, 0.02431648f, 
    0.36011299f, 0.06239250f, 0.22171223f, 0.24696587f, 0.08157710f, 0.00572354f, 0.20572801f, 0.14744280f, 
    0.04763436f, 0.04693512f, 0.05576312f, -0.07365381f, -0.06447453f, -0.21530533f, -0.19263119f, 0.39937732f, 
    -0.13394219f, -0.01329357f, 0.05107652f, -0.01691763f, -0.05767324f, -0.12487365f, -0.00768004f, 0.03235662f, 
    0.10491660f, -0.19032893f, 0.11265246f, -0.28221872f, -0.04122381f, 0.09281775f, -0.12214027f, 0.01848816f, 
    -0.07621653f, 0.03905499f, 0.02719412f, 0.23330118f, -0.12235989f, 0.04314266f, 0.13332027f, -0.17796998f, 
    0.12776306f, -0.00547034f, -0.03067129f, 0.00354727f, -0.02545263f, 0.02905755f, 0.04457071f, 0.03672765f, 
    -0.38911766f, 0.25527868f, 0.25778663f, -0.00489928f, -0.10184996f, -0.21856925f, -0.00283926f, -0.15194935f, 
    0.11169661f, -0.02785631f, -0.02951517f, -0.12628102f, -0.66659975f, 0.00825318f, -0.05727620f, -0.15279479f, 
    -0.04721265f, -0.13471298f, -0.04873858f, -0.01395634f, -0.06145369f, 0.10070513f, 0.08912800f, 0.11528026f, 
    -0.46329910f, 0.22387946f, 0.25123915f, 0.19961847f, 0.12480355f, 0.00767042f, 0.03390237f, -0.05534379f, 
    0.00543832f, 0.02107607f, 0.06042486f, 0.07906956f, -0.03842703f, 0.09248037f, -0.08128210f, -0.24789542f, 
    -0.05734040f, 0.06532536f, 0.33774990f, -0.06731579f, 0.11214286f, -0.09906750f, 0.03949531f, -0.07111818f, 
    0.07158565f, -0.12016135f, 0.08656618f, 0.34925297f, -0.16427687f, 0.10452110f, -0.08798041f, 0.17076828f, 
    -0.05129129f, -0.13888969f, 0.00662667f, -0.05110872f, 0.07531279f, -0.10379788f, -0.14500532f, 0.30544505f, 
    0.10694647f, -0.10472076f, 0.20865522f, 0.06181375f, 0.19953766f, 0.12083385f, -0.17829467f, 0.17414036f, 
    -0.25404450f, 0.17544122f, -0.08056565f, -0.28980640f, -0.02807937f, 0.01457315f, 0.16291507f, 0.16598201f, 
    0.09835198f, -0.01322071f, 0.06253387f, 0.04441353f, 0.50937283f, 0.12149087f, 0.30905488f, 0.09686542f, 
    0.13001710f, 0.02779735f, 0.03982580f, 0.10975476f, -0.00591579f, 0.06124249f, 0.08827604f, -0.14211042f, 
    -0.04112917f, 0.02298721f, -0.05325404f, -0.05131319f, 0.05050653f, -0.02216172f, -0.03587360f, 0.00438506f, 
    -0.03874804f, -0.04112099f, -0.06316063f, -0.04883520f, -0.03637495f, -0.00650514f, 0.05677831f, 0.03193392f, 
    -0.05311863f, 0.04996251f, 0.02545671f, -0.00718816f, 0.06268308f, -0.04736301f, -0.03391207f, -0.04106338f, 
    0.01045649f, 0.00042588f, -0.06116122f, 0.06336833f, -0.02128554f, 0.06202420f, 0.02338560f, 0.04312313f, 
    0.06216154f, -0.02869147f, -0.03726266f, -0.05063140f, -0.02216553f, 0.02092290f, 0.04110411f, -0.07942040f, 
    0.03242141f, -0.04163057f, -0.01541661f, -0.07465991f, -0.01798167f, 0.01932118f, 0.02130286f, -0.03994985f, 
    -0.01134753f, -0.07865611f, 0.05129439f, -0.02921131f, 0.03897111f, 0.02955915f, 0.00827094f, -0.05994062f, 
    0.05108265f, 0.05102659f, -0.00908673f, -0.04294559f, 0.02239180f, -0.04449374f, 0.02618901f, -0.07438597f, 
    0.00000061f, 0.02128623f, -0.03844522f, -0.05353794f, -0.00140201f, -0.00861681f, 0.02136946f, 0.02148436f, 
    -0.02010624f, -0.03177900f, 0.06148331f, 0.01656904f, -0.03360161f, -0.06108963f, 0.03501054f, -0.00965008f, 
    -0.04564114f, -0.04944343f, 0.02663338f, -0.01217482f, 0.03167005f, -0.02055730f, 0.01199453f, -0.07280811f, 
    0.05454969f, -0.04585847f, 0.00795406f, 0.00779645f, -0.03726644f, -0.06832454f, 0.00208515f, -0.01324600f, 
    -0.06987624f, 0.05285759f, -0.07735154f, -0.04123210f, -0.06548978f, -0.01598201f, -0.06576686f, -0.06558233f, 
    0.00764494f, 0.02810326f, 0.01667907f, -0.05012067f, 0.04741750f, -0.07185074f, 0.04901700f, -0.06649543f, 
    0.05726464f, -0.01724618f, -0.05381375f, -0.02431925f, 0.01439186f, -0.03362263f, 0.04706731f, 0.03028276f, 
    0.00230500f, -0.00080049f, 0.02904169f, -0.02387886f, -0.03628561f, 0.01476965f, 0.02214013f, -0.02304038f, 
    0.02028959f, 0.01219840f, -0.00069087f, -0.07228541f, -0.04042679f, 0.05155006f, 0.05552841f, -0.05667911f, 
    -0.06703053f, -0.03918310f, -0.02012466f, 0.01494529f, -0.01166140f, 0.01672086f, -0.01123429f, -0.04042090f, 
    0.04622399f, 0.05040806f, -0.06909502f, 0.01435657f, -0.01559106f, -0.02111317f, -0.07651711f, -0.03012965f, 
    -0.04091788f, -0.03263666f, -0.05912054f, -0.01410868f, -0.07531595f, -0.06748829f, 0.01362478f, -0.07571258f, 
    0.00007022f, -0.01606307f, -0.02546804f, 0.05081262f, 0.01878969f, -0.03185292f, 0.01258959f, -0.02647218f, 
    0.05408577f, 0.01064050f, -0.06332890f, 0.03972002f, 0.03541536f, 0.01321029f, -0.06969081f, -0.03903194f, 
    -0.06273180f, 0.02683816f, 0.06245394f, -0.01281638f, -0.07040913f, -0.03278457f, 0.00627697f, -0.00295119f, 
    -0.05253495f, 0.02844583f, 0.05151917f, -0.04979350f, 0.05542444f, 0.05493098f, -0.04238202f, -0.03686984f, 
    0.10513079f, -0.34385148f, 0.03399070f, 0.27526376f, -0.00508539f, -0.06976116f, 0.03007231f, 0.24210525f, 
    -0.02092166f, 0.15646575f, 0.15573621f, 0.12712911f, 0.21845762f, 0.18951501f, -0.03178742f, 0.15295057f, 
    -0.13712865f, -0.01622695f, 0.14666425f, 0.04608038f, -0.01376419f, 0.02675384f, -0.03399737f, -0.09743005f, 
    -0.27597100f, 0.26720604f, 0.18729144f, -0.15522093f, 0.19694699f, 0.19573562f, 0.10396928f, -0.07453667f, 
    -0.02260281f, -0.16270669f, 0.01017034f, -0.04588406f, 0.18223369f, -0.11907546f, -0.02836500f, 0.06014536f, 
    -0.07985776f, 0.08413565f, -0.06649356f, 0.09231061f, -0.06919470f, 0.16033584f, 0.04857660f, 0.00500472f, 
    0.29721802f, -0.03815073f, -0.07382950f, -0.15214908f, 0.06184940f, 0.09356406f, -0.14115749f, 0.11876097f, 
    -0.04638598f, 0.08081845f, -0.15713297f, 0.06310026f, -0.21944584f, 0.28478441f, 0.01421937f, -0.01284520f, 
    0.03062123f, 0.17729621f, 0.05489159f, 0.20916145f, -0.10153940f, 0.08562629f, -0.07566157f, 0.09010490f, 
    -0.00248568f, -0.06578486f, -0.02404723f, 0.12486938f, 0.07460839f, -0.04349877f, 0.13988896f, 0.16190225f, 
    0.11196732f, -0.11089229f, 0.00161933f, 0.02171930f, -0.35892567f, -0.11179323f, 0.09654660f, -0.24567063f, 
    0.06026369f, -0.00338328f, 0.03737221f, 0.04360300f, -0.02941069f, 0.00097440f, -0.05807695f, -0.08274113f, 
    0.25265351f, -0.02205641f, -0.18516731f, 0.03228052f, 0.05308319f, 0.13076444f, 0.11706510f, 0.15112644f, 
    -0.07692544f, 0.01652323f, -0.10991777f, 0.06963880f, 0.39970878f, -0.10270759f, -0.28470129f, 0.14183226f, 
    -0.03952494f, 0.01738359f, -0.03913254f, 0.22105783f, -0.04508086f, -0.15888442f, 0.06784559f, -0.05777485f, 
    -0.07402101f, 0.22758810f, -0.02388848f, -0.14746220f, -0.01245709f, 0.08448983f, 0.12702402f, 0.11146878f, 
    -0.02267444f, -0.06249562f, -0.06927590f, -0.06033886f, 0.12368657f, -0.13329066f, -0.00459193f, 0.02845692f, 
    -0.10675421f, -0.10340764f, -0.14514486f, 0.11173927f, -0.07077331f, 0.08584679f, -0.00128021f, -0.04099835f, 
    -0.41556886f, -0.00461195f, 0.11813825f, -0.12290721f, -0.06707443f, -0.00755249f, 0.03091793f, -0.14696939f, 
    0.06719018f, -0.01104054f, -0.11794955f, 0.12493374f, 0.03694114f, -0.05023796f, -0.07662421f, -0.10648841f, 
    -0.00976518f, -0.00351946f, 0.00859180f, -0.06595007f, -0.02092977f, 0.11981034f, 0.25616360f, -0.11166424f, 
    0.19662684f, 0.04914837f, -0.18262024f, 0.02031669f, 0.05956677f, -0.18659909f, -0.20497797f, -0.02375589f, 
    0.00909014f, -0.03212957f, -0.06252336f, 0.03455968f, 0.02245168f, -0.06049660f, -0.30820483f, -0.14932029f, 
    0.07670903f, 0.12030924f, -0.17219599f, -0.11573085f, -0.13233010f, -0.10397316f, -0.00532741f, 0.11360962f, 
    -0.28387079f, 0.10025356f, -0.03859812f, 0.01790139f, -0.04127368f, 0.07199134f, 0.14139974f, 0.00048959f, 
    -0.04902973f, 0.19542941f, 0.04491788f, 0.07327108f, -0.28398511f, -0.07478075f, 0.21531573f, -0.50678861f, 
    -0.05032751f, 0.01748466f, -0.02102965f, -0.00922120f, 0.11529939f, 0.08376598f, -0.11268096f, -0.07541666f, 
    0.50912255f, 0.08908781f, -0.00066421f, 0.14238758f, -0.00527037f, -0.02807066f, 0.00052710f, 0.08960374f, 
    0.15262009f, -0.05130685f, -0.02325447f, 0.02926903f, -0.13032784f, 0.17094210f, 0.11666410f, -0.15670460f, 
    0.16622183f, -0.01855923f, 0.07858629f, 0.10893162f, -0.09108667f, 0.08608409f, -0.05946823f, 0.14501722f, 
    0.20120710f, 0.03591159f, -0.02786582f, 0.21097201f, -0.12223586f, -0.05336273f, 0.10653102f, -0.05243628f, 
    -0.10354514f, -0.01675144f, 0.20561978f, 0.08158070f, 0.00728374f, 0.02584274f, 0.08447647f, -0.32000133f, 
    0.03731510f, -0.06405513f, 0.05013781f, -0.08878265f, 0.22521259f, -0.01344801f, -0.04289564f, 0.12668265f, 
    -0.41511926f, -0.07749990f, -0.35277757f, -0.13818178f, -0.21509738f, 0.15885803f, -0.06732500f, -0.00133657f, 
    0.01025886f, 0.03473972f, 0.02691180f, -0.07091600f, 0.21910989f, 0.08549045f, 0.11518675f, 0.29842287f, 
    0.04019285f, 0.05291207f, -0.12920064f, -0.01013316f, 0.08968388f, 0.08285429f, 0.10500496f, 0.19834146f, 
    -0.16435228f, -0.00031592f, 0.05842976f, 0.01967243f, 0.03525209f, -0.18461591f, -0.01601702f, 0.05052227f, 
    0.13113725f, 0.04506544f, -0.06414114f, 0.08595989f, -0.21433440f, 0.23128881f, 0.11917026f, 0.06742533f, 
    -0.05572112f, -0.02779479f, 0.11076380f, 0.01355627f, 0.25523710f, 0.01968268f, -0.04685439f, -0.12177147f, 
    -0.09181784f, -0.18260558f, 0.43725526f, 0.29422194f, 0.08910619f, -0.05057579f, -0.02492123f, 0.04500132f, 
    0.08929507f, 0.02107005f, -0.04995399f, -0.03271409f, -0.25695047f, 0.41522309f, -0.09050413f, 0.12307257f, 
    0.00839996f, 0.07981059f, 0.07047607f, -0.01017296f, 0.07412136f, 0.18895824f, 0.13338938f, 0.01408228f, 
    0.31756309f, -0.11500708f, 0.04516942f, 0.09985933f, 0.01826664f, -0.13676012f, -0.11447727f, -0.02836178f, 
    0.05853269f, -0.09392875f, -0.04823077f, 0.02736491f, 0.17096639f, 0.14488183f, 0.00622211f, 0.05609690f, 
    -0.16122147f, -0.03974104f, 0.03477490f, -0.01110818f, -0.16561915f, 0.10258918f, 0.04918029f, -0.13975728f, 
    -0.25229821f, -0.06663886f, 0.01506371f, -0.02870015f, 0.09493402f, 0.20490602f, -0.00235350f, -0.04641197f, 
    -0.06603160f, -0.08146436f, 0.03102265f, -0.03795535f, 0.29495266f, 0.27082971f, 0.57739490f, 0.27718866f, 
    -0.05460845f, -0.02169251f, 0.17897056f, 0.03900019f, 0.03831888f, 0.00845585f, -0.01062002f, 0.08394465f, 
    -0.33258370f, 0.09446291f, -0.04000488f, 0.26272810f, -0.26540467f, -0.14133584f, 0.09296457f, -0.15357932f, 
    0.11206708f, 0.07901443f, 0.00883390f, -0.07106403f, -0.00061882f, -0.10239193f, 0.04018200f, 0.05606225f, 
    0.23217858f, 0.14376725f, 0.08474683f, 0.06408852f, 0.01625907f, 0.20858739f, 0.14069916f, -0.00815258f, 
    0.14565045f, -0.07217443f, 0.21006277f, 0.30188403f, 0.02802066f, 0.05093757f, 0.00274025f, 0.02947195f, 
    0.18802525f, -0.07736159f, 0.11706541f, 0.08942297f, -0.24737471f, 0.00102307f, 0.23728099f, -0.30663121f, 
    0.06949016f, 0.16207074f, -0.00580685f, 0.01849228f, -0.01517082f, 0.08675220f, -0.04304786f, 0.07138514f, 
    0.38891366f, 0.43048725f, -0.02705934f, -0.07205035f, 0.01770988f, 0.05257462f, 0.15355419f, 0.20832932f, 
    0.02374190f, 0.05805654f, -0.13241059f, -0.08036849f, -0.35858130f, -0.13400398f, -0.00264524f, -0.02411614f, 
    0.06055937f, 0.15764262f, 0.08188621f, -0.01664422f, 0.03893806f, -0.00593884f, 0.12053402f, 0.11128607f, 
    -0.13134770f, -0.44048828f, -0.07428803f, -0.05497357f, 0.06715956f, 0.02353019f, -0.00228797f, 0.03966445f, 
    -0.10042179f, -0.02713438f, -0.02761864f, 0.08816037f, 0.35273510f, 0.04120459f, -0.04139019f, -0.25786543f, 
    -0.07782931f, 0.08014175f, 0.01435448f, -0.02800914f, 0.12803757f, -0.05579317f, -0.01257510f, 0.12905712f, 
    -0.42608809f, 0.27373353f, -0.09153451f, 0.04091735f, -0.07027330f, -0.13333428f, 0.02736872f, 0.04559999f, 
    0.04335083f, 0.01042055f, -0.08364994f, -0.12527321f, 0.19859102f, 0.00411990f, 0.18919788f, -0.24617863f, 
    -0.09727899f, -0.13185589f, -0.00720367f, 0.03766662f, 0.06844282f, 0.04038559f, -0.05557033f, 0.01835155f, 
    -0.16805890f, -0.09156886f, 0.06337208f, 0.20663443f, 0.17560595f, -0.03258375f, 0.18381512f, 0.00473932f, 
    0.06232672f, 0.00003211f, 0.13025445f, 0.11597542f, 0.17104350f, -0.17929687f, -0.26539010f, 0.01900101f, 
    -0.12211183f, 0.03528961f, 0.21051759f, -0.05815258f, 0.06966381f, -0.04840061f, -0.14977244f, 0.08948735f, 
    -0.10993759f, -0.16173592f, 0.12603848f, 0.11183006f, 0.05142331f, -0.05721739f, -0.00048518f, 0.00784307f, 
    0.27142221f, 0.02107491f, 0.05918201f, -0.08362513f, 0.13544609f, 0.15606305f, 0.10957540f, -0.05065151f, 
    0.02290681f, -0.12117285f, 0.11455520f, -0.14869379f, -0.01108818f, 0.08252341f, 0.06261858f, 0.09383819f, 
    -0.04487829f, 0.17138696f, 0.04524739f, 0.05343047f, -0.12556307f, 0.05985552f, 0.12106653f, -0.02340377f, 
    0.05846086f, -0.12733668f, 0.12357370f, -0.01138420f, 0.55455565f, 0.05414936f, 0.02382314f, 0.12737589f, 
    0.12252626f, -0.01317850f, -0.08185707f, 0.11247252f, 0.08721227f, 0.08283914f, -0.01433025f, -0.04231425f, 
    0.01862990f, -0.07048617f, -0.01543789f, 0.01495781f, 0.04926153f, 0.05749637f, -0.05378041f, -0.00669781f, 
    -0.04087713f, 0.00466926f, -0.03694238f, 0.04772635f, -0.03678330f, 0.05002192f, 0.02817371f, -0.03504217f, 
    -0.00791090f, 0.00406732f, -0.02572493f, 0.05518091f, 0.02995190f, 0.04354553f, -0.04400443f, -0.08893389f, 
    -0.02867854f, -0.01702275f, 0.01946666f, 0.01479813f, 0.04563102f, -0.04393506f, 0.04577852f, -0.07990746f, 
    0.03071143f, -0.00888924f, 0.03121490f, 0.06305646f, 0.04245141f, 0.03145624f, -0.00393709f, 0.04659699f, 
    0.02179032f, -0.06861833f, -0.00185475f, -0.05942439f, 0.02951836f, 0.03337345f, -0.02433345f, -0.03907324f, 
    -0.07585509f, 0.01978169f, 0.04910989f, 0.01047957f, 0.04372538f, -0.01085518f, 0.04156044f, 0.06101025f, 
    0.04320141f, -0.03673764f, 0.01399273f, -0.05263095f, 0.02524331f, 0.03077124f, -0.04741314f, -0.04974528f, 
    0.04867033f, 0.01074217f, -0.06713554f, -0.00118597f, -0.07659762f, -0.05944108f, -0.05664821f, -0.05415856f, 
    -0.01016524f, -0.07376324f, -0.00968457f, 0.01610310f, 0.02466858f, -0.08575284f, -0.01731192f, -0.00286081f, 
    -0.03660810f, -0.03538498f, 0.05842167f, 0.02050450f, -0.00048878f, -0.04958237f, -0.07052554f, 0.02863928f, 
    -0.06840046f, 0.03732027f, 0.02436531f, -0.03840799f, -0.03881723f, 0.00307337f, -0.02006306f, 0.05174617f, 
    0.00275702f, 0.06752638f, -0.04495789f, 0.02507618f, 0.05634579f, -0.07094353f, -0.01735988f, -0.07791439f, 
    -0.01385795f, -0.01432952f, -0.07632558f, -0.05586939f, 0.01249946f, -0.02006847f, 0.04225630f, -0.01216908f, 
    -0.03234539f, 0.06350276f, -0.04109384f, 0.01593721f, -0.00482029f, -0.04079180f, -0.00311126f, 0.03807106f, 
    -0.01739404f, -0.02269631f, -0.05638012f, -0.02483039f, 0.02363769f, -0.06251435f, -0.03291075f, -0.02363996f, 
    -0.02255313f, -0.04526655f, -0.01685829f, -0.05864899f, 0.04155305f, -0.01913872f, 0.07394890f, -0.04363111f, 
    0.01760112f, -0.04259048f, 0.02493877f, -0.02723440f, -0.05312939f, -0.01620618f, -0.00078108f, -0.00640660f, 
    -0.06390630f, 0.00376728f, -0.04124895f, -0.01895913f, 0.04555925f, 0.02435644f, -0.01951642f, -0.02997089f, 
    -0.03938793f, -0.02680252f, -0.06783383f, 0.00923596f, -0.04392893f, -0.02767195f, -0.03139025f, 0.00522187f, 
    -0.01341363f, 0.03253049f, -0.02532264f, -0.00288554f, 0.00601509f, 0.01087929f, 0.00291493f, -0.06035413f, 
    -0.07704636f, 0.05700609f, -0.00159154f, -0.00358460f, -0.05393909f, -0.05973320f, 0.06372332f, 0.04628688f, 
    0.03549879f, -0.04069803f, 0.02064517f, 0.05659339f, -0.01022038f, 0.05977346f, -0.01102411f, -0.02261171f, 
    -0.04143260f, -0.00558856f, 0.05378251f, 0.03384870f, 0.01614268f, 0.05062344f, 0.01466324f, -0.01497592f, 
    -0.05067588f, -0.06102277f, -0.03295816f, 0.01281927f, 0.02080300f, -0.00955133f, 0.00253485f, 0.03608199f, 
    -0.04953136f, -0.05247561f, -0.02165597f, 0.05522279f, -0.07648538f, 0.06252248f, -0.01696269f, -0.06309222f, 
    -0.04366310f, -0.01826288f, 0.04487529f, -0.00383661f, 0.05512340f, 0.06129336f, 0.04451341f, -0.05981003f, 
    -0.03400040f, -0.07237930f, -0.06178913f, -0.02272600f, 0.00498300f, -0.03700260f, 0.04224939f, -0.05070136f, 
    -0.04493646f, -0.05822585f, -0.00832664f, -0.04763230f, 0.00148144f, -0.05607724f, -0.02155844f, 0.02099998f, 
    -0.04465204f, -0.05174760f, 0.00548188f, -0.07306131f, -0.02721691f, 0.01621784f, 0.00208355f, -0.03164728f, 
    0.03181633f, -0.06996089f, 0.03714460f, -0.03494606f, -0.05055296f, -0.03973265f, 0.02424546f, -0.05798206f, 
    -0.01825184f, -0.05491238f, 0.00726648f, -0.05582283f, 0.02118640f, -0.07323623f, 0.02010993f, -0.04039360f, 
    0.01138427f, -0.03283332f, 0.04016120f, -0.01961170f, -0.01552121f, -0.02866714f, -0.01192289f, 0.04729159f, 
    -0.05119277f, -0.04942764f, -0.00938362f, 0.02787127f, -0.00929369f, -0.00183642f, -0.01719057f, -0.02772228f, 
    0.00765513f, 0.04388391f, -0.01839514f, -0.03370110f, 0.02705705f, -0.03007736f, 0.06212999f, 0.04259126f, 
    0.03864297f, 0.05652269f, -0.04630081f, 0.02998931f, 0.00619394f, -0.05684547f, -0.02597924f, 0.06052415f, 
    -0.02366859f, 0.02538750f, -0.03548736f, 0.03698209f, -0.06041319f, -0.02260439f, 0.01251612f, -0.02447627f, 
    0.02558858f, 0.05839780f, 0.06430883f, -0.02468091f, -0.00668555f, 0.00965183f, -0.00351061f, 0.01265801f, 
    -0.02276956f, -0.02831027f, -0.01729537f, 0.02728461f, -0.01305834f, -0.06512804f, 0.01651926f, 0.04776371f, 
    -0.00184670f, -0.02209675f, -0.02894366f, 0.06527694f, -0.00333273f, -0.06825067f, -0.06538364f, 0.04400149f, 
    -0.03404984f, 0.05788164f, -0.07342947f, -0.05005663f, -0.05960590f, -0.04164336f, -0.00613091f, -0.03481365f, 
    -0.03436728f, -0.05910224f, 0.02294074f, 0.02040970f, 0.06327584f, -0.07591952f, 0.04395612f, 0.05016046f, 
    -0.03401555f, -0.04740768f, -0.00077746f, -0.00623587f, -0.02671411f, -0.05197521f, 0.03196980f, 0.00455311f, 
    -0.05891202f, -0.00422887f, -0.01021810f, 0.00470350f, 0.00897035f, 0.00050153f, -0.07253121f, 0.04963628f, 
    -0.05285738f, 0.01582520f, 0.05915854f, -0.01902378f, 0.03624538f, -0.00723427f, 0.03678612f, 0.03719430f, 
    -0.01388300f, -0.02314621f, 0.02395923f, 0.01182606f, 0.03974757f, -0.02062284f, -0.00139447f, 0.05907083f, 
    0.04351802f, -0.00137114f, -0.06935748f, -0.03110279f, -0.07406378f, 0.04760719f, 0.00017330f, 0.06107275f, 
    0.01384737f, 0.01116931f, 0.00156843f, -0.03656682f, 0.00095015f, 0.03362387f, 0.00688388f, -0.03296507f, 
    0.18340103f, -0.12375652f, -0.09853633f, -0.19740979f, -0.00163621f, 0.14635038f, -0.27614686f, -0.13005950f, 
    0.14164996f, -0.11807723f, -0.16207291f, 0.03097279f, 0.18422002f, -0.14052190f, 0.19957684f, 0.05057386f, 
    0.06449436f, -0.05503854f, 0.07579371f, 0.11938593f, -0.00130380f, -0.08610666f, -0.07133055f, 0.09081908f, 
    0.00062488f, -0.08083139f, -0.05734213f, -0.28964064f, -0.07958931f, -0.09357180f, 0.00122431f, 0.06897452f, 
    -0.10320951f, 0.05748032f, 0.07518016f, 0.19638205f, -0.10197556f, -0.13645005f, -0.01191306f, 0.29227483f, 
    -0.01526770f, -0.09732560f, 0.00995538f, -0.01473643f, 0.07739942f, -0.19251092f, 0.06753749f, 0.02460037f, 
    -0.34573236f, -0.02807615f, 0.13247566f, -0.10173213f, 0.13622709f, -0.03703632f, 0.04127210f, -0.07097051f, 
    0.01570630f, 0.08935391f, 0.01387589f, -0.07825945f, 0.03062231f, -0.14532450f, 0.11732362f, 0.23112597f, 
    0.04655125f, -0.08275309f, -0.07900394f, 0.02669367f, 0.08362389f, 0.07109392f, 0.05519979f, -0.06396797f, 
    0.15851185f, 0.03153576f, 0.31411561f, 0.00352137f, 0.03748352f, -0.09008496f, -0.05127140f, 0.00056053f, 
    0.00675811f, 0.00248743f, -0.06156507f, 0.15604417f, -0.47182068f, -0.00247633f, -0.13953659f, 0.13855232f, 
    0.12563223f, 0.00489061f, 0.07802973f, -0.00050326f, -0.11336722f, 0.14842424f, -0.08657257f, -0.08561298f, 
    0.22203068f, 0.00796909f, 0.03350781f, -0.00234317f, -0.01851450f, 0.24917252f, -0.01328758f, 0.03156376f, 
    -0.05046263f, -0.02928570f, 0.09737723f, -0.02381195f, -0.06583427f, 0.16991203f, -0.11756682f, 0.16377370f, 
    0.16880795f, 0.15848936f, 0.05563454f, 0.14913909f, -0.18436590f, 0.05936409f, 0.11963158f, 0.15269566f, 
    -0.13724731f, -0.01225858f, -0.00570000f, -0.24832222f, 0.01024831f, 0.14876013f, 0.04762099f, 0.09841796f, 
    0.25074327f, 0.01946651f, 0.04639104f, 0.18458751f, 0.02389696f, -0.05049468f, 0.03728503f, -0.05553482f, 
    0.12715335f, 0.03742175f, -0.02147686f, -0.03753062f, -0.12731856f, -0.19869795f, -0.09439889f, 0.03245255f, 
    -0.14065930f, 0.08989709f, 0.12202369f, 0.17480451f, -0.03385227f, 0.08405925f, 0.09530417f, 0.25834957f, 
    -0.07060774f, -0.00740667f, 0.08143769f, 0.00123648f, 0.03497256f, 0.05087814f, 0.05022535f, 0.07700343f, 
    0.14852646f, 0.09140545f, 0.15627968f, 0.09771340f, 0.05814940f, -0.12332997f, 0.01136500f, 0.16176166f, 
    0.04780608f, -0.11891561f, -0.21286097f, -0.08815492f, -0.01593778f, -0.03824500f, -0.07378970f, -0.10191847f, 
    -0.01392573f, 0.18094061f, -0.03987808f, -0.01008306f, -0.23952967f, -0.06481460f, 0.07142897f, 0.09714190f, 
    -0.09930076f, 0.07084061f, 0.01462178f, 0.11926728f, -0.01513356f, -0.12055490f, -0.03886770f, -0.02966569f, 
    0.12376960f, -0.10002603f, 0.07927230f, -0.00494105f, 0.14263193f, -0.08829447f, -0.16739078f, 0.03144629f, 
    0.13240518f, 0.07524443f, 0.06096514f, 0.21346785f, 0.47776550f, 0.33203283f, 0.05152631f, 0.23669346f, 
    -0.04853050f, -0.02115894f, 0.15682091f, 0.08618531f, 0.07458664f, -0.00798135f, 0.00850263f, -0.10827619f, 
    -0.39024320f, 0.16602683f, 0.10448261f, -0.30274040f, 0.11145088f, 0.11834799f, -0.12879616f, -0.04526500f, 
    -0.10444393f, 0.01064668f, 0.06928233f, -0.09291086f, 0.11317121f, -0.01865947f, -0.25408149f, 0.23463447f, 
    -0.05479400f, 0.07306027f, -0.03846271f, -0.08738796f, 0.10714938f, -0.06435511f, 0.07542849f, 0.03425962f, 
    0.04472575f, -0.06365741f, 0.08766370f, -0.26029277f, -0.11083496f, 0.12269997f, -0.08322218f, 0.07015559f, 
    -0.02226178f, 0.11216975f, -0.08273333f, 0.16392535f, 0.38441622f, 0.42290014f, -0.11146937f, 0.15534236f, 
    -0.04009723f, -0.05416578f, -0.00875475f, 0.02686378f, -0.13484001f, 0.15272902f, 0.12245824f, -0.00766815f, 
    0.46882051f, 0.20076755f, 0.18717238f, 0.13188325f, 0.01487807f, -0.12170405f, 0.00344070f, 0.08539920f, 
    0.15373568f, 0.05408182f, -0.04760370f, -0.03161380f, -0.16658635f, -0.01714090f, -0.08533527f, 0.05684858f, 
    0.06585506f, 0.04108921f, 0.14341737f, -0.07547025f, -0.13367349f, 0.02067353f, 0.13600600f, -0.14786187f, 
    0.30032262f, -0.14016385f, 0.02156595f, -0.02047650f, 0.02932861f, 0.16520858f, 0.16792710f, 0.00606207f, 
    -0.06228571f, -0.03117656f, 0.10112654f, -0.00626976f, 0.07970091f, 0.04535103f, 0.02593992f, 0.11773027f, 
    0.18346815f, 0.22359359f, 0.03755233f, 0.17746969f, -0.02432125f, -0.11146436f, 0.01679605f, 0.12563311f, 
    0.22379369f, 0.01931643f, -0.12392182f, -0.21422364f, -0.04063053f, 0.06044153f, 0.05102773f, -0.01060002f, 
    -0.10697085f, 0.02500764f, 0.08125901f, -0.11092859f, 0.25784922f, -0.17888340f, 0.23641442f, -0.18607916f, 
    0.09437662f, -0.06552950f, -0.13192718f, 0.04539518f, -0.19845459f, 0.04741315f, -0.09760524f, -0.03322203f, 
    -0.31477177f, 0.30062115f, 0.07738198f, -0.17902970f, -0.10526147f, -0.01352940f, 0.12696867f, -0.00047665f, 
    -0.04530932f, 0.07142338f, 0.03304652f, 0.11300208f, -0.09634200f, -0.19938441f, -0.15772067f, -0.14434576f, 
    0.04545690f, -0.00116309f, 0.07989698f, 0.17778549f, 0.08211037f, -0.04241721f, -0.01567216f, -0.03319948f, 
    0.02375839f, 0.04541196f, 0.02660274f, 0.00277783f, 0.10014494f, 0.02371829f, -0.10128941f, -0.00125991f, 
    0.00118900f, -0.06207975f, 0.02490816f, 0.12580247f, -0.30771765f, -0.11835497f, -0.31990626f, -0.11962968f, 
    -0.04375907f, 0.06214130f, -0.09300154f, -0.15888654f, -0.11578218f, -0.03211504f, -0.19417982f, 0.03945800f, 
    -0.02320928f, -0.06529311f, -0.01843357f, -0.04569399f, -0.07441301f, -0.00782179f, -0.01814182f, -0.08126684f, 
    -0.02180864f, -0.01426329f, 0.04135347f, -0.07170028f, -0.07242972f, 0.01863604f, -0.05505702f, -0.08045999f, 
    -0.05693036f, -0.03924169f, -0.05785936f, 0.03444992f, -0.01179841f, -0.07004587f, 0.01684810f, -0.06807306f, 
    -0.01361389f, 0.03733134f, 0.04919299f, 0.01087868f, 0.03437094f, -0.00315795f, -0.05865217f, 0.03853879f, 
    -0.06295624f, -0.05384964f, 0.02072548f, 0.02995677f, -0.01630895f, 0.03015464f, -0.03702385f, -0.00899391f, 
    -0.02511979f, 0.03263375f, -0.07522979f, 0.05800547f, -0.05999960f, -0.06952819f, -0.07234276f, -0.07920783f, 
    -0.04509254f, -0.05113007f, 0.00793282f, 0.03539098f, -0.01356961f, -0.00754551f, 0.03576250f, 0.02179402f, 
    0.00662419f, -0.03684897f, 0.00775810f, -0.04298902f, 0.04993229f, -0.07379647f, -0.01449933f, 0.00792272f, 
    -0.04361761f, 0.00819320f, -0.00574758f, -0.06688841f, -0.00372552f, -0.00683278f, 0.05486242f, 0.00167336f, 
    -0.06783995f, 0.03646695f, -0.01710549f, -0.07205925f, 0.03424820f, 0.03528829f, -0.02176285f, -0.07462189f, 
    0.02072062f, -0.06235988f, -0.04532014f, -0.07976971f, 0.01550016f, 0.04780958f, 0.03665267f, -0.07866718f, 
    -0.03807623f, 0.05129253f, 0.05302042f, -0.02399200f, -0.01671437f, -0.03411785f, -0.03969491f, -0.02099668f, 
    -0.00327422f, -0.07103027f, -0.05887850f, 0.00035775f, -0.00117298f, 0.03270666f, -0.07600151f, -0.06664026f, 
    0.02582283f, 0.03056119f, -0.02338635f, 0.04986760f, -0.00166827f, -0.02969377f, 0.04944945f, 0.02774581f, 
    0.03597692f, -0.07163450f, 0.02818399f, -0.07348748f, 0.04026489f, -0.05713394f, -0.04357849f, -0.05870570f, 
    -0.00038662f, -0.04409352f, -0.04617048f, 0.01376844f, -0.05383502f, 0.01463130f, -0.01429244f, 0.01400448f, 
    -0.06485599f, 0.04008596f, -0.06105983f, 0.01418610f, -0.00631795f, 0.02607967f, -0.07071681f, -0.00264726f, 
    -0.03116340f, 0.01435146f, -0.04123221f, 0.02011900f, 0.05491962f, -0.05087971f, -0.02529612f, -0.05235588f, 
    -0.04649563f, -0.04618416f, -0.08345773f, 0.02417210f, -0.02535684f, -0.04325847f, -0.00516705f, -0.06763539f, 
    -0.05176863f, -0.04760552f, -0.05456645f, -0.04402560f, -0.06113845f, 0.00213788f, -0.00414604f, -0.03522999f, 
    0.00796655f, -0.06710090f, -0.05221377f, 0.02381440f, -0.08309928f, 0.04180969f, 0.04243476f, -0.05332191f, 
    -0.02403915f, -0.06701505f, 0.04896014f, 0.00940144f, 0.03413881f, 0.01166013f, -0.02395202f, 0.00037582f, 
    0.04697888f, -0.06752269f, -0.06221835f, -0.00436249f, 0.03920294f, -0.00586882f, 0.05445644f, -0.04599497f, 
    -0.01438912f, 0.01355414f, -0.05804582f, -0.02448270f, -0.06167504f, 0.01619577f, -0.04423108f, 0.00973086f, 
    0.21320400f, -0.21693970f, -0.07383541f, -0.14315526f, 0.18516047f, 0.06751438f, -0.18310311f, -0.00482609f, 
    0.05508782f, -0.00162926f, -0.04352389f, 0.06439655f, -0.18024695f, 0.02905737f, 0.23306152f, -0.22148527f, 
    -0.03629635f, -0.09538617f, -0.10157771f, 0.04407407f, 0.01682295f, 0.05516155f, 0.03153573f, 0.09125157f, 
    0.10054079f, 0.02617448f, -0.15625612f, -0.24147497f, -0.05968033f, -0.12598409f, -0.01897306f, 0.10271786f, 
    0.02306980f, 0.10989278f, 0.04003333f, 0.16592111f, 0.15585344f, 0.11724716f, -0.08608636f, 0.20084985f, 
    -0.02660718f, -0.06932758f, 0.02304794f, 0.00677938f, -0.01695193f, -0.01800992f, -0.00247667f, -0.03085415f, 
    -0.30655971f, -0.12987776f, 0.00836330f, -0.06461673f, 0.07590729f, -0.00986681f, -0.02669059f, -0.13785945f, 
    0.01726474f, 0.00745573f, 0.08732192f, -0.01452601f, -0.30057141f, -0.10962294f, 0.25449553f, -0.04941618f, 
    0.15390417f, -0.07991580f, -0.12301920f, -0.04399203f, 0.11496314f, 0.02148887f, -0.02266261f, 0.05759488f, 
    -0.24228682f, 0.13141327f, 0.20897305f, -0.20297681f, 0.12275842f, 0.03477392f, 0.12913015f, -0.00423340f, 
    0.02533610f, 0.18955834f, 0.02694635f, 0.11031679f, -0.54072911f, -0.16629742f, -0.10555058f, 0.16996832f, 
    0.06476951f, -0.00327941f, 0.08768445f, 0.01169013f, -0.01232985f, 0.01522135f, 0.11222203f, 0.01549967f, 
    0.39062324f, -0.10583495f, -0.03821792f, 0.03384980f, 0.05022626f, 0.13572749f, -0.05991814f, 0.01102050f, 
    0.17104608f, 0.04010914f, 0.09563258f, 0.18745002f, -0.12210809f, -0.02673044f, -0.10084399f, 0.27013600f, 
    0.08164179f, 0.23553661f, 0.04998438f, 0.20005374f, 0.00044224f, 0.21027750f, -0.04724351f, 0.01826341f, 
    0.03508752f, 0.20238121f, 0.07278790f, -0.15689851f, -0.08200675f, 0.10949066f, 0.11982918f, -0.01973424f, 
    0.12375277f, 0.06003796f, 0.07655015f, 0.08124398f, -0.34538636f, 0.04883936f, 0.09859236f, -0.11459311f, 
    0.07291127f, 0.01537871f, -0.06947934f, 0.02756180f, 0.01453853f, -0.23651949f, 0.00604404f, 0.05533482f, 
    -0.26505002f, 0.34061477f, 0.21070035f, -0.07738821f, -0.09133881f, 0.05181706f, -0.04518598f, -0.02412728f, 
    -0.19545646f, 0.00950725f, 0.01178455f, 0.12612197f, -0.05119818f, 0.00203287f, 0.01615746f, -0.01674887f, 
    0.09556269f, 0.17453076f, 0.12943642f, 0.07066074f, 0.01715466f, -0.03238017f, 0.03820777f, 0.03376411f, 
    0.15560831f, -0.24897262f, -0.23808360f, -0.04553399f, -0.06547109f, -0.03363526f, -0.04880912f, 0.04103002f, 
    0.03431991f, 0.16326129f, -0.08643097f, 0.03201902f, -0.44168055f, -0.13910538f, 0.25502810f, 0.18305352f, 
    -0.11214165f, -0.00491400f, 0.02589863f, -0.01605190f, -0.07754593f, 0.01603318f, -0.04595507f, 0.06256209f, 
    -0.40496340f, -0.32796746f, 0.00083764f, 0.26986885f, -0.11123338f, -0.13271770f, 0.02737416f, -0.10879235f, 
    0.08109972f, 0.14207365f, -0.00025883f, -0.03997881f, 0.24824733f, -0.18960565f, 0.16395625f, 0.00865949f, 
    0.08090217f, 0.18044941f, -0.02819756f, 0.08408772f, 0.05015215f, 0.03008622f, -0.08687526f, -0.02413622f, 
    -0.29028824f, 0.19860014f, -0.10553292f, 0.12425239f, 0.17702581f, -0.10892121f, 0.19329040f, 0.00245448f, 
    0.13459674f, -0.08226277f, 0.14029746f, 0.10131777f, -0.74303710f, -0.00264008f, 0.12630002f, -0.04696304f, 
    0.15566076f, -0.11760239f, -0.03635518f, 0.11128149f, -0.07280331f, -0.07079960f, 0.03258094f, 0.16874354f, 
    -0.24444476f, 0.01452584f, 0.06270514f, -0.06418312f, -0.05315328f, -0.06323512f, 0.13756545f, -0.00266171f, 
    0.07838852f, -0.03888892f, -0.10392678f, 0.10982139f, 0.36903828f, 0.08585339f, 0.30934322f, -0.29374078f, 
    0.19838253f, 0.08185166f, -0.05879483f, 0.00899157f, 0.19688514f, -0.00279034f, 0.06335926f, 0.24819545f, 
    -0.02193438f, -0.06254583f, -0.32575491f, 0.31504279f, -0.04998752f, -0.13037643f, -0.04291133f, 0.07627567f, 
    0.02398848f, 0.01045571f, -0.09157769f, -0.01092950f, 0.15738541f, -0.06945271f, -0.05482684f, 0.02542936f, 
    -0.08813631f, -0.12895511f, 0.07590283f, -0.05418301f, 0.08204275f, 0.19601014f, -0.02447029f, 0.12610951f, 
    -0.07295806f, 0.12796266f, -0.12662038f, -0.10175663f, 0.24772914f, 0.07113460f, 0.10208328f, 0.18226464f, 
    -0.12864852f, 0.09292153f, -0.07929487f, 0.07483589f, 0.33221525f, 0.42002299f, 0.01005104f, -0.03558419f, 
    -0.04487566f, -0.01632219f, 0.14289214f, 0.05014943f, 0.11427421f, -0.08854929f, 0.02666237f, 0.03961797f, 
    0.05451588f, -0.32964864f, 0.18101361f, -0.09373870f, -0.00720992f, -0.02598480f, 0.00868660f, 0.03636145f, 
    0.21620592f, 0.03980492f, 0.16300222f, 0.08486616f, 0.04451138f, 0.01213674f, -0.30604041f, 0.10980827f, 
    -0.05382087f, -0.11045530f, 0.01350349f, -0.03775664f, 0.02639709f, 0.14083961f, -0.16561700f, 0.07348437f, 
    0.24447049f, -0.14717239f, 0.15858996f, -0.01634837f, 0.23696207f, -0.09754287f, 0.00716790f, 0.04778432f, 
    0.25547078f, -0.03891978f, 0.16159767f, 0.05468790f, 0.13919140f, 0.29997423f, 0.06492127f, -0.09572089f, 
    -0.05519426f, -0.03157001f, 0.03741221f, -0.08210283f, -0.08278047f, -0.15776962f, -0.00242266f, 0.09954780f, 
    -0.41649601f, -0.11736205f, -0.16227616f, 0.18837966f, 0.04599192f, 0.10622192f, -0.08816120f, -0.06006767f, 
    -0.13114348f, -0.03719055f, 0.03688135f, -0.12808259f, -0.01380973f, -0.00740058f, 0.01013574f, -0.03031330f, 
    -0.07754452f, 0.04958978f, 0.06365750f, 0.18323231f, 0.04031206f, -0.08895545f, 0.11022853f, 0.14350601f, 
    0.16049926f, -0.01885057f, 0.11036441f, 0.17120121f, 0.03442424f, 0.11741360f, -0.08233874f, -0.02492845f, 
    -0.00292860f, -0.05587914f, 0.00241686f, -0.04929566f, -0.17984222f, -0.26651260f, -0.07631127f, -0.01457048f, 
    0.22950031f, 0.12305798f, -0.15042041f, -0.01587399f, -0.01903543f, -0.04187945f, 0.04478802f, 0.26920247f, 
    -0.44284454f, -0.09259429f, -0.14652406f, -0.12265667f, -0.00645160f, -0.14210935f, 0.01283329f, -0.00032948f, 
    0.05713729f, 0.30701068f, -0.00924421f, 0.13516615f, 0.16139035f, 0.04902107f, -0.21251377f, 0.03063250f, 
    0.07884653f, -0.14710394f, -0.03538137f, -0.06255798f, 0.14630400f, -0.15193753f, 0.06566961f, 0.05261546f, 
    -0.55835515f, -0.05435695f, 0.19007592f, 0.14279094f, -0.01499452f, -0.11843348f, 0.12930535f, -0.16141790f, 
    0.20273320f, -0.05014971f, 0.17296112f, 0.11558857f, 0.36692879f, -0.06359315f, 0.12274199f, -0.24255468f, 
    0.15608642f, 0.05769347f, -0.11555224f, -0.07040919f, -0.05741406f, -0.08631232f, 0.11904956f, -0.00475745f, 
    0.26894748f, 0.37249321f, 0.03426823f, 0.16417642f, 0.13503122f, 0.00120683f, -0.07050018f, -0.13888592f, 
    -0.13903551f, 0.07761122f, -0.01371792f, -0.05763688f, 0.59567434f, -0.01659797f, 0.06822444f, 0.03358629f, 
    0.15506250f, -0.04924370f, 0.07596492f, 0.15179220f, -0.01681701f, 0.06646227f, 0.00113754f, 0.00549479f, 
    0.37291881f, -0.11083481f, -0.05902644f, -0.01085990f, 0.13280766f, 0.05084868f, -0.03616328f, -0.12206867f, 
    0.03675029f, 0.07665725f, 0.16672164f, -0.10098500f, -0.16754869f, -0.12173968f, 0.42380244f, 0.02071348f, 
    0.00089247f, 0.18373038f, -0.05883884f, -0.28972855f, 0.01805938f, 0.19013944f, -0.20290072f, 0.15460588f, 
    0.45810622f, -0.29739445f, -0.28400239f, -0.01272397f, -0.20290342f, 0.00604630f, -0.22313213f, -0.07245807f, 
    0.04778994f, -0.02635973f, 0.01698389f, 0.10187028f, -0.03573576f, 0.33252972f, 0.02077347f, 0.09011059f, 
    0.20351760f, 0.04728054f, -0.12958771f, -0.02411065f, 0.14787273f, 0.00770276f, -0.07258300f, 0.10783891f, 
    0.13822764f, 0.08909909f, -0.05006531f, -0.21394691f, 0.13998093f, 0.04710410f, 0.08562908f, -0.09385519f, 
    -0.09291982f, 0.00996339f, 0.22983526f, -0.05693056f, -0.12157144f, -0.08052480f, -0.06438029f, 0.02247367f, 
    0.02569295f, 0.14245498f, 0.04377673f, 0.12185916f, 0.01104606f, -0.09311746f, -0.07453712f, 0.05732191f, 
    0.05520062f, -0.00551737f, 0.19652258f, 0.09169048f, 0.01288838f, 0.09845944f, 0.05250486f, 0.15848149f, 
    -0.02539612f, 0.05963115f, 0.16683578f, -0.06005720f, -0.57297814f, -0.17621420f, -0.03505088f, -0.07216296f, 
    -0.05184342f, -0.11413477f, -0.04165461f, -0.03753814f, -0.02239138f, 0.01945397f, -0.04448001f, -0.01771787f, 
    -0.67597193f, -0.13979831f, 0.14364257f, 0.13326603f, 0.07076593f, -0.00561831f, 0.07894617f, 0.02237704f, 
    0.10634727f, 0.08994298f, 0.16417745f, 0.07982312f, 0.22199161f, 0.10937210f, 0.20646344f, 0.03286591f, 
    0.03805648f, -0.17960432f, -0.08694456f, -0.08572498f, 0.15440339f, 0.18124329f, -0.03972739f, -0.13962585f, 
    -0.16545667f, 0.12346752f, 0.00645811f, -0.07968783f, 0.00213408f, 0.06332728f, 0.12498518f, -0.07076406f, 
    0.18046072f, -0.18531646f, 0.05713615f, -0.08218360f, -0.29629284f, -0.10218826f, 0.15487364f, -0.11438784f, 
    0.05050406f, 0.00841307f, 0.09875480f, -0.03757081f, 0.04809710f, 0.18030351f, 0.04355055f, 0.12832537f, 
    0.18147032f, 0.45680901f, 0.03820136f, -0.14567401f, 0.00304928f, 0.07763167f, 0.16020744f, 0.15652606f, 
    0.02625609f, 0.13651328f, -0.08065117f, -0.01318437f, -0.09624950f, 0.14403161f, 0.16164768f, -0.09790257f, 
    0.09454297f, 0.13182710f, -0.08944852f, -0.13920894f, -0.10804049f, 0.02964316f, 0.05971393f, 0.12940153f, 
    -0.02417694f, -0.20545241f, -0.18583196f, -0.02163609f, -0.06867862f, -0.00632355f, -0.05004289f, 0.14677741f, 
    -0.09020213f, -0.13031766f, 0.00086968f, -0.03890195f, -0.17877822f, -0.06610803f, -0.17343010f, -0.22945626f, 
    -0.03827181f, 0.04356831f, 0.12341581f, 0.00478819f, 0.09267656f, -0.01176648f, -0.22228387f, -0.05430716f, 
    -0.12674475f, 0.10390543f, -0.07863719f, 0.13349015f, -0.13804539f, 0.12602499f, -0.01376842f, -0.03122352f, 
    0.01806284f, -0.00511586f, -0.09756820f, 0.18252619f, -0.12436542f, 0.05116502f, 0.01685864f, -0.05573680f, 
    -0.00558819f, 0.11320411f, -0.02064108f, 0.23017722f, 0.25013465f, -0.01059313f, -0.10350189f, 0.08826411f, 
    -0.17916287f, -0.13675420f, 0.05495163f, -0.23765011f, 0.11234638f, -0.06056191f, 0.22169931f, -0.11277736f, 
    0.16898885f, 0.02243150f, -0.12196259f, 0.03437534f, 0.20948598f, -0.25328654f, -0.31993237f, -0.08422412f, 
    -0.07737457f, 0.08716773f, 0.08247185f, -0.14347455f, -0.06535473f, -0.21830213f, 0.13788785f, -0.11934929f, 
    -0.36648142f, -0.12176339f, 0.13636509f, -0.04906439f, 0.06051912f, -0.12130682f, -0.01619047f, -0.06267163f, 
    0.23147517f, 0.12374998f, 0.06830382f, 0.07825313f, 0.07875729f, -0.00051949f, 0.07669468f, 0.00778640f, 
    0.08667792f, -0.05338124f, -0.02329748f, -0.22322270f, 0.03375480f, 0.18866776f, 0.04240109f, 0.05050179f, 
    -0.21864264f, -0.23237017f, -0.09324192f, -0.03460401f, 0.08567480f, 0.19617584f, 0.05844470f, 0.02213016f, 
    -0.05888242f, -0.13131402f, -0.02131075f, 0.13589077f, 0.26958120f, -0.06334052f, -0.05677404f, 0.07968711f, 
    0.20014143f, -0.03215453f, -0.05495951f, 0.06490505f, 0.00478269f, 0.00475652f, -0.14781366f, 0.09331642f, 
    0.03871955f, -0.00395982f, -0.00137401f, 0.01974491f, -0.09233955f, -0.06925525f, 0.04588003f, -0.07163779f, 
    -0.03037293f, -0.01596862f, 0.00917368f, -0.02836013f, -0.05692602f, 0.04713450f, 0.06027487f, -0.05459805f, 
    -0.04667383f, -0.07882528f, 0.06439594f, -0.02977933f, -0.06270310f, -0.05654196f, -0.04267785f, -0.04931712f, 
    -0.01810803f, 0.00366794f, -0.00113697f, 0.02592577f, 0.05075376f, -0.05134767f, 0.04425577f, 0.02686879f, 
    -0.07884246f, 0.05352198f, -0.03393912f, 0.04745410f, 0.00038330f, 0.04953599f, 0.04519349f, 0.05281453f, 
    -0.05790515f, 0.01546957f, 0.02666014f, -0.05229738f, -0.00919474f, 0.06024032f, -0.06552485f, 0.05686779f, 
    0.05611042f, -0.03288693f, 0.05375765f, 0.03650770f, -0.02634327f, -0.05778950f, -0.08406939f, 0.05108751f, 
    0.02363343f, -0.02643361f, 0.04049860f, 0.03864876f, -0.06048347f, 0.03499310f, 0.00762846f, 0.03035122f, 
    0.05381940f, -0.00170512f, -0.02883892f, -0.03693090f, 0.04956260f, -0.07396599f, 0.04769079f, 0.04876000f, 
    -0.00896529f, -0.04466226f, 0.02250599f, 0.02628531f, 0.03422003f, -0.07676028f, 0.01434669f, -0.00888772f, 
    0.05785014f, -0.00879831f, 0.04816583f, 0.02553409f, 0.00473743f, -0.04499911f, 0.02391507f, -0.03138468f, 
    -0.04208569f, -0.07394566f, -0.00976070f, 0.04298573f, -0.04969643f, -0.01627323f, 0.00806818f, 0.05317155f, 
    0.05055707f, 0.02120637f, 0.02401426f, 0.00176298f, 0.06524374f, -0.01391786f, -0.03214522f, -0.04388005f, 
    -0.00577854f, -0.04985113f, 0.04361131f, -0.07462092f, -0.04448947f, -0.01539364f, 0.01563453f, 0.02935677f, 
    -0.00302427f, 0.02048724f, 0.01106960f, 0.06206236f, 0.01662194f, -0.03287839f, -0.04073841f, -0.08626692f, 
    -0.01140895f, 0.02203811f, -0.01175123f, -0.08589500f, -0.01279996f, -0.03721489f, -0.03755484f, -0.05585016f, 
    0.03557685f, 0.05011535f, -0.04053280f, -0.03628033f, -0.01394900f, 0.01093226f, -0.01216667f, 0.07254300f, 
    -0.02615464f, 0.05238967f, -0.04666556f, 0.02296936f, 0.03244427f, 0.02662139f, -0.04046468f, -0.06083310f, 
    -0.00372175f, -0.02469821f, -0.06306190f, -0.03796292f, -0.05718090f, -0.04298884f, -0.07191909f, -0.05402012f, 
    -0.05749902f, 0.04158389f, -0.02714497f, 0.05307164f, -0.05667448f, -0.07138436f, -0.01026852f, -0.02649672f, 
    -0.05789121f, -0.01781082f, -0.00598189f, -0.06442928f, 0.01818435f, -0.05935230f, -0.03677162f, -0.02014423f, 
    0.01663124f, -0.04750522f, -0.05997223f, -0.05556256f, 0.05144811f, -0.09388602f, -0.00087539f, 0.03808787f, 
    -0.08358619f, 0.05690810f, -0.04845223f, -0.04120324f, -0.02192793f, 0.04046357f, 0.04041220f, -0.03562988f, 
    0.00890987f, 0.02184068f, -0.01914908f, -0.05263264f, 0.06708968f, 0.04523120f, -0.03598757f, -0.05983555f, 
    -0.14624511f, -0.14771548f, -0.10291434f, -0.18208711f, 0.09064538f, -0.07861984f, 0.06697737f, -0.05779106f, 
    0.16954960f, -0.18905176f, -0.03184360f, -0.12321947f, 0.64003503f, 0.31586570f, 0.04971623f, 0.34344444f, 
    -0.12304088f, -0.14427637f, 0.01723251f, -0.13241830f, 0.03711614f, 0.10158375f, 0.10946525f, 0.20846787f, 
    -0.09110866f, 0.15266852f, 0.19558279f, 0.09211909f, -0.00272487f, -0.09358617f, -0.06824670f, -0.15777484f, 
    0.08341432f, -0.11709224f, 0.07840160f, 0.19387570f, -0.43503591f, 0.20494105f, -0.06579439f, 0.13525884f, 
    -0.05719314f, 0.09037916f, 0.02370946f, -0.10708319f, 0.17184237f, 0.05228874f, 0.03358774f, -0.05985262f, 
    -0.02258595f, -0.23540673f, -0.00992092f, -0.01594188f, -0.12457833f, 0.28362709f, 0.09512224f, 0.08995268f, 
    0.05395144f, 0.06946942f, -0.13745554f, -0.03811894f, 0.26553199f, 0.34608886f, -0.02255106f, 0.32451978f, 
    -0.07946793f, -0.05147739f, -0.20094587f, -0.15753701f, 0.10985529f, 0.09258910f, 0.19324125f, 0.18034218f, 
    0.41177151f, 0.01652997f, 0.17508206f, 0.16474243f, 0.19024362f, -0.01308341f, -0.05498866f, 0.08079808f, 
    0.17967822f, 0.11774974f, 0.15956892f, 0.13256045f, -0.09459434f, -0.01974720f, -0.18483527f, -0.00308051f, 
    -0.00449344f, 0.11257313f, 0.21145405f, -0.06039666f, -0.01819624f, 0.00724970f, 0.05383154f, -0.11462183f, 
    -0.14235891f, 0.15563779f, -0.28659567f, -0.10873916f, 0.06164590f, 0.05995758f, -0.17681822f, 0.02414205f, 
    -0.05893666f, 0.17641442f, 0.20165814f, 0.01326632f, -0.34871215f, -0.13649260f, -0.11889873f, -0.23465289f, 
    0.23398143f, 0.13197982f, 0.09330264f, 0.15590490f, 0.11552318f, 0.07121322f, -0.04544956f, -0.03049025f, 
    0.20620143f, 0.18537812f, 0.05785516f, 0.22849707f, -0.17389785f, -0.04618809f, 0.04861883f, -0.14487374f, 
    0.00059130f, -0.00599980f, 0.15622625f, 0.01867644f, 0.05051862f, -0.42718822f, 0.04774069f, -0.31182370f, 
    0.15962198f, -0.19729732f, 0.18716213f, -0.02481863f, -0.03724319f, -0.02381863f, -0.01135338f, -0.01856952f, 
    0.12996280f, 0.38377339f, 0.31722042f, 0.18895318f, -0.13882847f, -0.24855597f, -0.05191256f, -0.04182812f, 
    0.04152142f, -0.01368067f, 0.16124983f, 0.09571352f, -0.37188780f, -0.17194527f, -0.11609033f, -0.06035798f, 
    0.01993704f, -0.10304121f, -0.02655073f, -0.00271909f, 0.05639558f, -0.00597284f, -0.06672547f, -0.09205592f, 
    -0.48052233f, 0.08648580f, -0.30605286f, -0.20069155f, 0.09044641f, 0.23226768f, 0.21580370f, 0.17277537f, 
    -0.03421954f, -0.14345813f, -0.07100862f, -0.03323229f, 0.01346797f, 0.05129761f, -0.14711136f, -0.00298555f, 
    0.05285474f, 0.02951222f, -0.08094138f, -0.06290383f, 0.00401610f, 0.00203647f, -0.19463506f, -0.10996169f, 
    0.22822338f, 0.10098270f, -0.10527616f, -0.58240986f, 0.02582787f, 0.02084611f, 0.05578494f, 0.11773895f, 
    -0.02699639f, 0.05089943f, 0.05997356f, 0.18893914f, -0.01818997f, 0.19826387f, -0.07174011f, -0.12705895f, 
    0.02072838f, -0.15854099f, -0.07626314f, 0.07435243f, 0.04315857f, -0.01199460f, 0.08626688f, -0.07252730f, 
    0.35521948f, -0.12761018f, -0.16223210f, -0.16692932f, -0.06120313f, 0.03530189f, -0.16541587f, 0.13030057f, 
    0.11265967f, 0.00680060f, -0.12722778f, -0.08374358f, 0.55413061f, -0.20011966f, 0.20707223f, 0.16807260f, 
    0.05918856f, 0.06200016f, 0.15075155f, -0.04263840f, 0.02721245f, 0.07834061f, -0.04498807f, 0.11672893f, 
    0.29695356f, -0.25343910f, -0.07691557f, -0.33010784f, -0.21428123f, 0.09874520f, -0.14847159f, -0.10370871f, 
    -0.12203215f, 0.05031219f, 0.15033241f, 0.12810645f, 0.02459839f, -0.16540638f, -0.03861146f, 0.25944000f, 
    0.08667127f, -0.05088840f, -0.07621780f, -0.06823063f, 0.07747172f, 0.09595219f, 0.02069787f, 0.01679887f, 
    -0.02155941f, 0.02549946f, 0.03484341f, -0.11637542f, 0.03984204f, 0.17985393f, 0.05494964f, 0.06773455f, 
    0.05131644f, 0.17412487f, 0.17601979f, -0.00672895f, -0.14441726f, -0.06864854f, -0.12715702f, 0.18819487f, 
    -0.02780245f, 0.13469373f, 0.11467833f, -0.10163127f, 0.03827643f, -0.02556336f, 0.10038311f, 0.06363970f, 
    -0.06770702f, -0.11816584f, 0.10093179f, 0.24835138f, -0.04410488f, -0.05447316f, -0.12648863f, -0.09677774f, 
    0.09821302f, -0.01869423f, 0.11316751f, 0.06828305f, -0.38948661f, -0.38517517f, 0.12411032f, 0.08201720f, 
    -0.17498593f, -0.00237328f, -0.12851709f, -0.00175232f, -0.02147222f, 0.03012194f, -0.14166990f, 0.01092647f, 
    0.09763198f, 0.20455854f, -0.12874156f, -0.21842918f, 0.15758273f, -0.03368232f, 0.11863170f, 0.12183275f, 
    0.02995972f, 0.05998358f, -0.07660179f, 0.04386655f, -0.14843681f, 0.33971602f, 0.20338221f, 0.09450351f, 
    0.11980832f, 0.14110008f, 0.07298589f, 0.17512840f, 0.14253110f, 0.02470907f, 0.19986655f, -0.07042063f, 
    0.07361586f, 0.34940305f, -0.06530693f, -0.15517110f, 0.09661777f, 0.03256117f, -0.06434894f, -0.02789360f, 
    -0.19732212f, 0.10408029f, -0.02449069f, 0.12604852f, -0.44125557f, -0.41419336f, 0.04747770f, -0.19005802f, 
    -0.15304357f, 0.04955338f, -0.13686208f, 0.03059574f, 0.04869811f, 0.15101172f, 0.06056296f, -0.11508796f, 
    0.46154666f, 0.00163753f, 0.04801194f, -0.28498903f, 0.09608405f, -0.03209488f, 0.06569498f, 0.09057473f, 
    0.11690035f, 0.03126454f, -0.11170927f, 0.17468797f, -0.11572185f, -0.14354733f, 0.15627955f, 0.22595067f, 
    -0.06096638f, -0.00837487f, 0.11870773f, -0.03589375f, -0.09705854f, 0.05502532f, -0.10251001f, 0.17839888f, 
    -0.24018796f, -0.08243693f, -0.11955857f, 0.09304325f, -0.08610816f, 0.04983972f, -0.06504399f, -0.18868966f, 
    0.13794164f, -0.10659972f, 0.00657827f, -0.05870632f, 0.36407959f, -0.05825597f, 0.05179803f, 0.05086748f, 
    0.09463652f, 0.02655447f, 0.08235562f, 0.07242730f, 0.11338025f, -0.05724581f, 0.09213713f, 0.10468115f, 
    -0.18181145f, -0.05380670f, 0.10828462f, 0.01147252f, 0.07421393f, -0.16831027f, 0.07169571f, -0.03811822f, 
    0.00937333f, -0.09993187f, 0.17466554f, 0.19708832f, -0.47476393f, 0.02035902f, -0.00847127f, -0.18357828f, 
    0.01277479f, 0.03719097f, -0.03662837f, 0.03254348f, -0.00303512f, -0.11009829f, 0.13310564f, -0.07708898f, 
    -0.13156870f, -0.08645977f, 0.04697583f, 0.08688457f, -0.13040438f, 0.13290046f, 0.14449100f, 0.04562299f, 
    0.11964954f, 0.18057185f, -0.04755732f, 0.06766306f, 0.01543762f, 0.03574096f, 0.14186917f, 0.03645903f, 
    0.03159941f, 0.02336552f, -0.07520468f, -0.01274691f, 0.01396237f, -0.03708665f, 0.17056386f, 0.04061357f, 
    0.08406323f, -0.04523400f, 0.17590085f, 0.07895351f, 0.07250306f, -0.04211547f, -0.01359416f, 0.08144887f, 
    0.03852231f, 0.02793033f, -0.13168544f, 0.05559448f, 0.30662891f, -0.05267355f, -0.21308392f, -0.04740723f, 
    -0.06020908f, -0.05799186f, 0.07232407f, 0.05006991f, 0.00496137f, 0.14245898f, -0.08041049f, -0.00027894f, 
    -0.29075816f, 0.19611973f, -0.02124576f, -0.12041590f, 0.08950320f, -0.03978116f, 0.03288841f, 0.01576171f, 
    -0.00842441f, -0.05367094f, 0.00585996f, 0.01622808f, -0.04325205f, 0.09741800f, 0.15733449f, -0.23232134f, 
    0.04460387f, 0.04889005f, 0.09684143f, 0.00139991f, 0.08633375f, 0.15310630f, -0.01802986f, -0.00449091f, 
    0.21566278f, -0.12533529f, -0.11455299f, -0.01723351f, -0.12236559f, -0.05253419f, 0.03433271f, -0.14024709f, 
    0.09913154f, 0.00696859f, 0.14179315f, 0.13228652f, 0.00617889f, -0.32470503f, -0.01208304f, -0.18336327f, 
    0.09648535f, 0.02184660f, 0.19202599f, -0.04594289f, 0.10041045f, -0.10384979f, -0.19710508f, 0.02842512f, 
    0.13562912f, 0.03467126f, 0.14574338f, 0.12904501f, 0.12070078f, -0.06870710f, 0.11034439f, 0.21179391f, 
    0.18612206f, -0.07755579f, 0.10097526f, 0.00303613f, -0.07131338f, 0.06192629f, -0.15684371f, -0.14251271f, 
    -0.01595588f, -0.11446655f, 0.16499744f, -0.13816746f, 0.04966120f, -0.13278887f, -0.12215307f, 0.14841190f, 
    -0.49670917f, 0.08420777f, -0.19285193f, 0.03297497f, -0.05618160f, 0.05082376f, 0.06474676f, 0.08625562f, 
    0.00877327f, -0.09214516f, 0.08061174f, 0.06504089f, 0.08682264f, 0.08263134f, 0.06437670f, -0.05808652f, 
    0.02279847f, 0.03014094f, -0.00254984f, 0.09933922f, 0.04304862f, 0.10186195f, -0.02443057f, 0.01095324f, 
    0.13399264f, 0.09604287f, 0.23333682f, -0.02894424f, -0.07220247f, -0.24882935f, 0.08441385f, 0.18300860f, 
    -0.02212130f, -0.04260278f, 0.08373860f, 0.01741906f, 0.04300934f, -0.05088462f, -0.22280686f, 0.54892927f, 
    0.01460218f, 0.16638425f, -0.03708171f, -0.10701460f, -0.22097473f, 0.03350500f, -0.12082206f, -0.05019795f, 
    0.14117211f, -0.04847402f, 0.13211928f, 0.33297053f, 0.15984268f, 0.14442801f, -0.01242788f, 0.07938707f, 
    0.04574327f, -0.04765240f, -0.02281848f, -0.05648220f, -0.14161262f, -0.08583929f, 0.01044771f, 0.14120626f, 
    -0.08946597f, 0.11811543f, 0.02605497f, 0.01436643f, 0.02855911f, 0.13745409f, 0.04375700f, -0.01026282f, 
    0.41714123f, 0.16889849f, -0.07758547f, -0.39259198f, 0.11909108f, -0.07499018f, -0.10836586f, -0.00504759f, 
    -0.01936863f, -0.01912978f, -0.06016518f, 0.04664107f, 0.11083951f, -0.16256645f, -0.29109743f, 0.35277888f, 
    -0.06425481f, 0.11638318f, 0.13164411f, 0.11812585f, -0.01500434f, 0.17944828f, -0.09630489f, 0.03763843f, 
    0.19453387f, -0.33850023f, -0.17974533f, 0.21148925f, 0.06317662f, -0.02437974f, 0.00895846f, 0.04405135f, 
    0.18613268f, -0.05791264f, -0.08654977f, 0.00664729f, -0.10170008f, 0.09431542f, -0.05560162f, -0.29939803f, 
    -0.02965702f, -0.00318151f, -0.03881200f, 0.00551682f, 0.18063347f, -0.19918388f, 0.13674366f, 0.07527770f, 
    -0.29350951f, 0.19571599f, -0.04805167f, 0.26222128f, 0.09701142f, 0.11387590f, -0.10274662f, 0.17147367f, 
    -0.02361746f, 0.04957150f, -0.01063994f, -0.03736147f, 0.34795761f, -0.14928414f, -0.29533589f, 0.08798423f, 
    -0.11809816f, -0.15585385f, -0.02430197f, 0.12640288f, -0.00989762f, -0.23439756f, 0.03637917f, 0.00335928f, 
    -0.42164481f, 0.31872013f, -0.12122553f, -0.05194934f, 0.02172720f, 0.06417858f, 0.07755748f, 0.09484327f, 
    -0.02906704f, -0.12942876f, 0.01273441f, -0.06012231f, 0.37241265f, -0.20462392f, 0.10207753f, 0.15890595f, 
    -0.12006245f, -0.11014333f, -0.15188257f, 0.11019367f, -0.18860422f, 0.30628160f, 0.13074185f, 0.04463730f, 
    0.05617059f, -0.19097617f, -0.31841788f, 0.10422339f, 0.09773170f, 0.18013383f, 0.17663991f, -0.08835948f, 
    0.04865607f, 0.16941795f, -0.02023649f, 0.01341716f, -0.27220050f, 0.00115834f, 0.08316733f, 0.05950417f, 
    -0.00125984f, -0.02566691f, -0.17201893f, 0.02650195f, 0.05055486f, 0.06780045f, 0.13102384f, 0.01604340f, 
    0.36814031f, 0.25788933f, 0.13648933f, -0.18229674f, 0.00980618f, -0.20353450f, -0.11105718f, 0.00762348f, 
    -0.14296570f, -0.10196611f, 0.00574829f, 0.08174654f, 0.26617447f, -0.20994234f, -0.34344494f, -0.03785520f, 
    0.05389674f, 0.09047228f, -0.03309394f, 0.04813733f, 0.01412218f, -0.12460604f, 0.12575966f, 0.06269108f, 
    -0.07221060f, -0.01971693f, 0.04054413f, -0.05400838f, -0.04491146f, 0.04043777f, -0.05925138f, 0.01445724f, 
    0.02962690f, -0.02845049f, 0.02051540f, -0.06250299f, 0.01634562f, -0.05446465f, -0.01634585f, 0.04775417f, 
    0.02235065f, -0.04555149f, -0.06743687f, -0.03698063f, 0.03691332f, 0.00891488f, -0.00169013f, -0.01685380f, 
    -0.02142946f, -0.03202845f, -0.07450952f, 0.02894361f, -0.03156663f, 0.00208420f, -0.00697381f, -0.01624093f, 
    0.05516593f, -0.04465990f, 0.05016274f, 0.01157636f, -0.06267740f, 0.01670112f, -0.04323452f, -0.07973532f, 
    -0.04060870f, -0.02690216f, 0.01576970f, 0.00480481f, -0.06969992f, 0.00966367f, -0.00025189f, -0.02161533f, 
    0.03069632f, -0.03690044f, -0.04632166f, 0.03992528f, 0.01627697f, 0.02515101f, -0.02072066f, 0.05032724f, 
    -0.04108014f, -0.05616744f, 0.03750323f, 0.00795850f, 0.01288422f, -0.00291415f, -0.00533400f, 0.03465138f, 
    -0.07968656f, 0.02403229f, 0.04331106f, 0.00270454f, 0.02875583f, 0.02500015f, -0.02002574f, 0.05890302f, 
    -0.06230555f, -0.02190719f, 0.05894018f, 0.01437995f, 0.00728874f, -0.05710705f, 0.02168872f, 0.03500009f, 
    -0.02135254f, 0.02055697f, 0.04299869f, -0.03416836f, 0.03225388f, -0.04153687f, -0.03391258f, -0.04866105f, 
    0.00761595f, 0.02221334f, -0.07007906f, -0.02017698f, -0.02570677f, -0.03904890f, -0.06937826f, -0.08187030f, 
    -0.03883401f, 0.00352069f, 0.02530877f, 0.01861041f, 0.00498667f, -0.07830620f, -0.05156496f, 0.02710078f, 
    0.01421071f, 0.02453530f, -0.02086855f, 0.03406600f, -0.03002008f, -0.02093648f, 0.05074514f, -0.02693738f, 
    -0.02802153f, 0.03057075f, 0.00144242f, -0.06002909f, -0.01205641f, -0.01299123f, 0.01273572f, -0.04653509f, 
    -0.02837730f, 0.04430636f, -0.03874024f, -0.06870119f, -0.01136252f, -0.02584499f, -0.07182601f, -0.01343683f, 
    -0.05647387f, -0.01357374f, 0.06193791f, 0.03179639f, -0.02232317f, 0.04784997f, -0.05109299f, 0.00867470f, 
    -0.02236618f, -0.04525640f, -0.05785333f, 0.05726276f, -0.07419600f, -0.07012004f, -0.04706327f, -0.05782616f, 
    -0.05175086f, -0.05429664f, -0.07323971f, 0.04498020f, 0.05810563f, 0.03069104f, 0.03170219f, -0.01879244f, 
    -0.03894867f, 0.01874056f, -0.07261193f, -0.06260998f, -0.05440410f, 0.03735447f, -0.04722285f, -0.01702295f, 
    0.02243689f, -0.07722672f, 0.01196338f, 0.05411610f, 0.00696344f, -0.03634237f, 0.03605206f, -0.01049325f, 
    0.03387182f, 0.01598168f, 0.03693323f, 0.04362882f, -0.00934175f, -0.01118653f, -0.00260643f, -0.07903942f, 
    0.03788546f, -0.02406566f, -0.02589841f, -0.02035086f, -0.03213603f, 0.02403048f, -0.04188659f, -0.05951778f, 
    -0.01845018f, 0.03215502f, 0.03334461f, -0.04855722f, -0.06986100f, -0.00547331f, 0.00255845f, 0.03422910f, 
    0.03391211f, 0.00261579f, -0.04544633f, 0.05727894f, -0.06525132f, -0.04623239f, 0.03343223f, 0.02894864f, 
    -0.08451261f, 0.00048331f, -0.05717362f, -0.01769808f, -0.05445879f, 0.00997151f, -0.07118130f, -0.01762316f, 
    -0.00698166f, -0.00636499f, -0.02657771f, 0.02654575f, 0.04515760f, 0.04865073f, 0.03593589f, 0.02328418f, 
    -0.04599054f, -0.07827119f, -0.00809738f, 0.00057457f, 0.01713292f, -0.08399601f, -0.05032431f, 0.01739440f, 
    0.04332944f, -0.01229296f, 0.00827051f, 0.01482168f, -0.06434415f, -0.00704788f, 0.04046556f, 0.00679311f, 
    0.02899620f, -0.00562191f, -0.04068569f, 0.00190113f, -0.04955900f, -0.01433542f, -0.05127299f, -0.04837563f, 
    0.03292942f, -0.01945904f, 0.01996401f, -0.00824048f, -0.06488015f, 0.02579104f, -0.00069534f, -0.04683388f, 
    0.03078518f, 0.06153964f, -0.04879133f, 0.00793586f, 0.00479777f, -0.03304781f, 0.01241670f, -0.07370780f, 
    0.00773141f, 0.05050188f, 0.05905027f, 0.00474827f, 0.05449710f, 0.02196971f, 0.00151096f, -0.08542866f, 
    0.01983852f, -0.04913675f, -0.07004852f, 0.04139467f, -0.00125241f, 0.02164108f, -0.00054799f, -0.01844342f, 
    0.05443515f, -0.05987202f, 0.02354338f, 0.00369152f, 0.01789252f, -0.03716858f, -0.04694198f, -0.01192456f, 
    -0.03476367f, -0.01212681f, 0.00553375f, -0.05811537f, -0.07178255f, 0.00775253f, -0.06947037f, -0.02341702f, 
    -0.04308578f, 0.05298585f, -0.04746493f, -0.00343976f, -0.05622104f, 0.04452161f, -0.02961235f, 0.01988584f, 
    0.05654697f, -0.08347400f, 0.03483914f, -0.03157122f, -0.07422686f, 0.02976942f, -0.04884493f, -0.05272104f, 
    0.00300474f, 0.03836913f, -0.00728931f, 0.05419545f, -0.02505676f, -0.01205039f, 0.04506964f, 0.03375882f, 
    -0.08177385f, 0.02913142f, 0.02868979f, -0.01248651f, 0.05195348f, -0.04173124f, -0.00872250f, -0.06256036f, 
    -0.04701308f, -0.00011149f, -0.02441321f, 0.04961312f, -0.00604902f, -0.00471924f, -0.02040127f, 0.01306469f, 
    -0.01063767f, 0.05640796f, 0.05581288f, 0.02512537f, -0.07091819f, 0.00897105f, 0.03341079f, 0.01224923f, 
    0.03345920f, 0.06066287f, -0.08781335f, -0.05655596f, 0.00531225f, 0.02561016f, -0.04702300f, -0.04941766f, 
    0.06770825f, -0.02449417f, -0.06102270f, -0.06366810f, 0.05478270f, 0.06133925f, 0.02066467f, -0.00604961f, 
    -0.00284444f, -0.02957807f, -0.05764575f, -0.07784226f, 0.05487256f, -0.01670352f, -0.04705626f, 0.02845515f, 
    -0.08814110f, -0.04167216f, 0.03640991f, -0.05630520f, -0.04037767f, -0.01141942f, -0.01489214f, -0.05272154f, 
    -0.02362114f, -0.03956725f, -0.00762957f, 0.05583805f, -0.00468262f, -0.01022440f, -0.03539228f, 0.01950403f, 
    -0.01177601f, -0.05169432f, 0.03556000f, -0.03771018f, -0.08098027f, -0.00799435f, 0.01236136f, -0.04028330f, 
    -0.00988797f, -0.14456983f, -0.08135733f, 0.34323242f, 0.05770687f, 0.16418923f, 0.14757679f, 0.20473884f, 
    -0.13441487f, 0.24161726f, 0.05037328f, -0.06868459f, -0.58624142f, -0.07562411f, 0.02884770f, -0.44156668f, 
    -0.01432557f, 0.02804447f, -0.10452982f, -0.00014654f, 0.17329912f, -0.04263385f, -0.08134034f, 0.03068116f, 
    0.05235930f, 0.08303123f, -0.01799405f, 0.04720554f, 0.03076561f, -0.09079323f, 0.18239729f, 0.07730622f, 
    0.09780934f, 0.05477042f, 0.05650217f, 0.04066169f, 0.25813964f, 0.24686088f, -0.08605444f, -0.08895411f, 
    0.10868420f, 0.02324907f, -0.02062405f, 0.18875273f, -0.03542849f, 0.13332969f, 0.04775878f, -0.01701743f, 
    -0.08082104f, 0.00278798f, -0.14067541f, 0.22181007f, 0.15427132f, -0.16647036f, -0.01458620f, -0.08505532f, 
    0.04241783f, 0.08231150f, 0.13188612f, -0.04161400f, -0.49471587f, 0.01207733f, 0.24639933f, -0.54783720f, 
    0.22683127f, 0.08533997f, 0.06360070f, 0.09462166f, -0.01502171f, -0.06748673f, -0.05712499f, 0.12749450f, 
    -0.54725480f, 0.08539068f, -0.18380418f, -0.14172278f, -0.00419636f, 0.16064188f, 0.14647938f, -0.08785325f, 
    -0.05225385f, -0.00934516f, 0.04421052f, 0.10130725f, -0.00301244f, -0.23340997f, 0.33159599f, 0.07093084f, 
    0.00052995f, -0.01598457f, -0.11921384f, 0.29205430f, 0.04141674f, -0.02638601f, 0.00362367f, -0.04597854f, 
    0.30275553f, -0.21838635f, -0.17691199f, -0.11430997f, 0.04989513f, 0.06058553f, -0.00677977f, 0.08995184f, 
    0.07413125f, 0.11697823f, -0.06152220f, 0.09994841f, 0.16824403f, -0.01233940f, -0.04197406f, 0.21134214f, 
    -0.00301619f, -0.01175252f, -0.03972199f, -0.11983363f, 0.01483718f, 0.11225293f, 0.00326320f, -0.16004911f, 
    0.02705806f, 0.05971943f, 0.25683793f, 0.13368814f, 0.07827234f, 0.08990478f, -0.00785785f, 0.04558625f, 
    -0.01013802f, 0.04658822f, -0.03986546f, 0.00477648f, -0.36256605f, 0.19094528f, -0.07967232f, 0.06488746f, 
    0.01400950f, 0.12419916f, 0.01551060f, 0.06300174f, 0.19799894f, -0.05063995f, 0.10145184f, -0.01263951f, 
    -0.23812667f, 0.09230378f, 0.24093074f, -0.11269272f, 0.03465204f, 0.04745714f, -0.03787119f, -0.09149330f, 
    0.05786343f, 0.05360561f, -0.00868406f, -0.06613455f, 0.36221749f, 0.17100783f, 0.03582979f, 0.19429882f, 
    -0.04228912f, 0.11918984f, 0.02338648f, -0.06808734f, -0.13782071f, 0.09516180f, 0.19516239f, -0.06946343f, 
    0.06496926f, -0.04709594f, -0.07678992f, 0.15857124f, -0.16538456f, -0.14748901f, -0.07292777f, 0.13277994f, 
    0.04740264f, 0.06671010f, 0.08519940f, -0.04837999f, -0.07762154f, 0.06095911f, 0.34900764f, 0.12143603f, 
    -0.03183226f, 0.14178690f, 0.09181752f, 0.07947152f, -0.06882463f, 0.04230357f, 0.10216624f, 0.04334200f, 
    0.25581983f, 0.19499435f, 0.18074027f, 0.23210695f, -0.02285660f, 0.08995350f, -0.04342191f, -0.03167325f, 
    0.09520103f, -0.24138153f, -0.10376535f, -0.23243544f, -0.22593921f, -0.44355208f, -0.11354440f, 0.28521875f, 
    0.22495599f, 0.14955169f, -0.09288768f, -0.03285923f, -0.09116305f, 0.01833824f, 0.13710187f, 0.26435059f, 
    -0.27716991f, -0.13493849f, -0.23781335f, -0.01779124f, -0.04493332f, -0.11516184f, -0.01566718f, -0.00400769f, 
    -0.14373818f, 0.35059881f, 0.17523591f, 0.25774601f, -0.17661662f, 0.16732097f, -0.22489393f, 0.05915181f, 
    -0.08747069f, -0.03544021f, -0.04022973f, 0.02940994f, 0.01903682f, -0.06192422f, 0.05236636f, 0.00746033f, 
    -0.66047919f, 0.15110178f, 0.05686193f, 0.09018662f, 0.28649879f, -0.14145303f, 0.18395953f, -0.04572851f, 
    0.15393180f, -0.02185469f, -0.02690796f, -0.09970223f, -0.14924040f, -0.23158377f, 0.16838463f, 0.17742603f, 
    0.08071814f, 0.00326451f, -0.04579596f, -0.13301077f, 0.02246918f, -0.09118582f, -0.08414106f, -0.03175206f, 
    0.30383730f, 0.01465239f, 0.06136435f, -0.04173558f, 0.24620096f, -0.03001004f, -0.01365061f, -0.11047412f, 
    -0.00572242f, 0.00726651f, 0.15947157f, 0.07077253f, 0.11837883f, 0.07688612f, 0.05448765f, -0.16296425f, 
    0.15957783f, -0.09512967f, 0.09708120f, 0.08178189f, 0.06484179f, 0.01265134f, -0.14152043f, 0.08267397f, 
    0.46930119f, 0.03791320f, 0.09839140f, 0.00521439f, 0.12803082f, 0.14202040f, -0.07744459f, -0.14417383f, 
    -0.05986157f, 0.03010742f, 0.13907543f, -0.10568407f, -0.12675104f, -0.19107546f, 0.12877178f, 0.05949210f, 
    0.14148256f, 0.10520136f, -0.10238161f, 0.02438492f, -0.09300040f, 0.14890131f, -0.12946218f, 0.08100285f, 
    -0.01401941f, -0.05807080f, -0.17840229f, -0.03056420f, -0.13179061f, 0.14074609f, -0.06972974f, -0.09773932f, 
    0.20134173f, 0.10102698f, 0.21176203f, 0.26586196f, -0.02681353f, 0.24443850f, -0.05416666f, -0.02359085f, 
    0.02961763f, 0.07122090f, -0.07429234f, -0.02293906f, 0.13125691f, -0.27819201f, 0.03219041f, -0.01888067f, 
    -0.17125049f, 0.00054240f, 0.09740095f, 0.02582362f, 0.07032498f, 0.14551578f, 0.09739035f, -0.02250438f, 
    0.00488522f, -0.02588149f, 0.13381432f, -0.01589454f, 0.17051579f, -0.09277638f, 0.14376515f, 0.22930032f, 
    0.22639321f, 0.12374651f, 0.16366938f, -0.00738948f, -0.02132430f, -0.01250131f, -0.06842909f, 0.31473091f, 
    0.14033432f, 0.11793505f, 0.03258973f, -0.02250094f, -0.07502491f, -0.02290888f, 0.15826719f, 0.14193699f, 
    0.03048964f, 0.16170624f, 0.01583064f, -0.06969503f, -0.31793532f, -0.32797268f, -0.12529801f, -0.03133401f, 
    -0.04843140f, -0.04236978f, 0.02450616f, 0.13481446f, 0.02598637f, -0.10992113f, 0.05310860f, -0.15195405f, 
    0.01222830f, -0.16907696f, -0.19749220f, -0.05369439f, 0.03243261f, -0.12312650f, 0.06262252f, 0.07451890f, 
    -0.00787153f, 0.07893111f, 0.22363801f, 0.11573358f, 0.66967243f, 0.31491980f, -0.02986367f, 0.17167342f, 
    -0.15729482f, 0.05101451f, -0.01884293f, 0.05930731f, 0.06106923f, -0.05961121f, -0.21882242f, 0.00982026f, 
    -0.01566037f, 0.18995464f, 0.20598790f, 0.15340416f, 0.28074107f, -0.02290720f, 0.00157193f, 0.04840884f, 
    -0.01103784f, -0.17050315f, 0.01450659f, -0.01738801f, -0.63927048f, 0.31720644f, -0.09923611f, 0.27703476f, 
    -0.09045491f, 0.15127009f, -0.09774422f, -0.00391757f, 0.01809817f, -0.04461788f, 0.08898722f, -0.04881646f, 
    0.11077084f, -0.39058238f, 0.09827228f, 0.01019273f, -0.18149033f, 0.18383165f, -0.06635679f, 0.10747601f, 
    0.00226138f, 0.06800155f, 0.02880739f, 0.19227971f, 0.48142174f, 0.34873742f, -0.11511242f, -0.09012139f, 
    -0.01804221f, 0.04915632f, -0.02030616f, 0.19928482f, 0.15111583f, 0.10456418f, -0.01836302f, 0.11371885f, 
    0.32579222f, 0.04879208f, -0.13514356f, 0.04647680f, 0.10291597f, -0.01476025f, -0.03858899f, 0.10115672f, 
    0.17930448f, -0.10832272f, -0.14908920f, 0.05967407f, -0.07101344f, -0.06368126f, 0.10247109f, 0.07666367f, 
    0.05232327f, -0.02474198f, 0.10223994f, 0.14319623f, 0.14222792f, 0.05185715f, 0.07412099f, -0.04646754f, 
    -0.51666701f, 0.14785469f, -0.16990919f, -0.13996956f, 0.07573082f, -0.00301261f, 0.07619018f, 0.12436744f, 
    -0.00971024f, 0.10738612f, 0.09647457f, 0.14615108f, 0.26722598f, 0.19083865f, -0.28884587f, 0.04484798f, 
    -0.00530507f, -0.07141513f, 0.22193816f, 0.10460468f, -0.02020117f, -0.05183933f, 0.12023395f, 0.05633111f, 
    -0.08827939f, 0.19933385f, 0.01527303f, 0.00035374f, -0.03415977f, 0.12441064f, -0.03835185f, 0.03037591f, 
    -0.03484642f, -0.05885325f, -0.05695241f, -0.07121252f, 0.02170936f, -0.27506343f, 0.21028039f, -0.04656778f, 
    0.03018190f, -0.18013978f, 0.03049252f, 0.11945786f, -0.00779405f, 0.19095033f, -0.00805393f, -0.03365242f, 
    0.42824343f, 0.11574049f, -0.00648669f, -0.09656169f, 0.06467719f, -0.02836768f, 0.14411186f, -0.00007872f, 
    0.15065277f, 0.08230036f, 0.00507345f, -0.04146568f, -0.07310677f, 0.12093307f, -0.06818950f, -0.05956023f, 
    -0.14428385f, -0.25538737f, -0.05009704f, 0.07553798f, 0.04217251f, -0.10093665f, 0.13592860f, -0.10023888f, 
    -0.40136427f, 0.11726461f, -0.11315923f, -0.08606198f, 0.22164847f, -0.01527891f, -0.05090185f, 0.12064794f, 
    -0.03513253f, -0.06258514f, 0.00409057f, -0.05713127f, 0.02898030f, 0.05293164f, -0.18417257f, -0.16526279f, 
    0.09899776f, 0.19832668f, 0.11227096f, 0.09913698f, -0.01713680f, 0.00001516f, 0.03323053f, 0.01586290f, 
    -0.05611075f, -0.07125765f, 0.05098858f, 0.05703164f, -0.00829541f, -0.05587307f, -0.01422221f, 0.07291088f, 
    0.00945554f, -0.03956152f, 0.00883744f, -0.01725632f, 0.05265852f, 0.04222943f, -0.07967515f, 0.06511603f, 
    -0.02554607f, -0.03288444f, -0.05296627f, 0.00550377f, -0.04771669f, -0.01135982f, -0.02778065f, -0.00563975f, 
    0.04422157f, -0.04226152f, -0.02630469f, -0.01164979f, -0.00680839f, -0.05198720f, 0.01967724f, 0.01967129f, 
    -0.05679749f, 0.03558110f, 0.06350961f, -0.00699792f, -0.01411367f, -0.01422885f, 0.04110065f, -0.04565482f, 
    -0.01203707f, -0.06007183f, 0.02813222f, -0.05331813f, 0.06347121f, -0.04557128f, -0.00047770f, -0.04181781f, 
    -0.02251370f, -0.00318622f, 0.02117006f, -0.04612517f, 0.02880388f, -0.06219417f, -0.03343969f, 0.05256544f, 
    -0.01503751f, 0.01251701f, -0.02553522f, -0.03446364f, -0.03153759f, -0.05166827f, -0.00297775f, -0.06640857f, 
    0.06284510f, -0.04115181f, -0.03885249f, -0.00419560f, 0.05084059f, -0.04926400f, 0.04309661f, -0.03842628f, 
    -0.01865068f, 0.01785279f, -0.06801283f, -0.07147109f, -0.07125251f, -0.00769895f, 0.06316732f, 0.00145492f, 
    -0.03068228f, -0.05568336f, 0.02388636f, -0.05039161f, -0.00922796f, 0.03688660f, -0.07547960f, -0.01795194f, 
    -0.05217591f, -0.07973677f, 0.00208254f, 0.01082893f, -0.05233422f, 0.04156702f, 0.01075403f, -0.04200236f, 
    -0.06087359f, -0.03452927f, 0.02119780f, 0.01372106f, -0.05626791f, -0.00384061f, 0.02258031f, -0.01711244f, 
    -0.07427299f, -0.04298034f, -0.00245389f, 0.04597783f, 0.06587163f, -0.08038398f, 0.07145070f, -0.01323684f, 
    -0.04318573f, -0.03336103f, 0.01305892f, -0.07818499f, 0.01883339f, -0.02154357f, 0.04524019f, -0.03900094f, 
    -0.07220493f, -0.00537176f, 0.04521352f, -0.07405921f, 0.02516338f, -0.07493927f, -0.00736811f, -0.00119341f, 
    -0.01284633f, -0.06056421f, -0.07035842f, -0.05570025f, -0.07075615f, -0.01458203f, 0.02460660f, -0.01161218f, 
    0.01229832f, 0.00610376f, 0.05056589f, -0.02781350f, -0.06422183f, 0.03753457f, 0.02581345f, 0.02819435f, 
    0.02176454f, -0.05244881f, 0.02821183f, 0.03736380f, -0.04127273f, -0.02298595f, 0.05573712f, 0.06001054f, 
    0.01997839f, 0.01352506f, -0.00345661f, -0.06850949f, -0.00584703f, 0.03821612f, -0.02615232f, 0.07017123f, 
    -0.05911041f, 0.05269232f, 0.01642849f, 0.06436794f, -0.01335805f, -0.06443281f, 0.03749061f, 0.03921824f, 
    0.01134707f, -0.06732493f, 0.04048063f, 0.06204400f, -0.05699101f, 0.05220183f, -0.01961453f, -0.01453060f, 
    0.00641955f, 0.03116051f, 0.03464072f, 0.06808063f, -0.01943597f, -0.06341446f, -0.05889747f, 0.02881033f, 
    0.05671450f, -0.05300781f, 0.02095818f, -0.00366295f, -0.08594827f, -0.07293728f, -0.00939272f, 0.02741919f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07997743f, 0.00573493f, -0.00214462f, 0.10580447f, 0.03573429f, 0.12407242f, -0.03795771f, 0.05025307f, 
    0.05392904f, 0.05248494f, 0.02735119f, 0.02062029f, -0.14487231f, 0.01116446f, -0.12295299f, -0.03136498f, 
    0.01905839f, 0.06343193f, 0.15511666f, -0.07082131f, 0.03618087f, 0.05986188f, -0.06942508f, -0.02372201f, 
    0.01237063f, 0.01362129f, 0.14982180f, 0.00380148f, -0.02300001f, -0.00889313f, 0.06127536f, 0.06673372f, 
    0.04518386f, 0.01797776f, 0.00354508f, 0.05858974f, -0.01015592f, -0.03861599f, -0.01987777f, -0.00561585f, 
    -0.03046941f, -0.04085611f, 0.10681316f, 0.05040003f, 0.03610536f, 0.05788778f, 0.13605855f, -0.04509152f, 
    -0.00652202f, 0.08211492f, 0.11400639f, 0.02779272f, 0.12958319f, -0.07033160f, -0.02029392f, -0.07202093f, 
    0.09244077f, 0.00433385f, 0.02934792f, -0.05370586f, 0.11463633f, 0.05056272f, 0.01921329f, 0.04918461f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.19328889f, 0.04877457f, 0.04079366f, -0.74572116f, 0.13998595f, 0.08418060f, 0.29679435f, -0.12325854f, 
    0.13533066f, -0.05837635f, -0.39058828f, 0.05421566f, 0.04934528f, -0.16565028f, 0.04379338f, -0.12222766f, 
    -0.03887523f, -0.06237297f, -0.79897249f, -0.02093794f, 0.02753706f, -0.31296811f, -0.02884588f, -0.03416601f, 
    0.11159408f, 0.05189108f, 0.07234268f, 0.28367403f, 0.12757601f, -0.09994029f, 0.07488147f, -0.24580887f, 
    -0.06614790f, 0.05333712f, 0.44062391f, 0.10905444f, 0.25041097f, 0.03864256f, -0.33020365f, 0.26447505f, 
    -0.05904129f, -0.05147111f, -0.06206786f, -0.25751123f, 0.09877390f, -0.12791879f, 0.01196175f, 0.19270492f, 
    0.10704391f, -0.02006667f, -0.45278630f, -0.22648585f, -0.33508450f, 0.00650145f, 0.16752680f, 0.45734563f, 
    -0.20312211f, 0.21985748f, -0.11776426f, 0.05202414f, -0.44563156f, -0.12483481f, 0.10021808f, 0.11626171f, 
    -0.31045005f, -0.02659582f, -0.04108878f, -0.55929512f, 0.21771856f, 0.27830631f, -0.06191947f, -0.02729931f, 
    0.27577701f, -0.09258140f, -0.11526081f, -0.07525300f, -0.28124541f, 0.01129553f, 0.05384359f, 0.08053845f, 
    -0.66093922f, -0.03888876f, 0.25257635f, 0.15776779f, 0.01024781f, 0.18651870f, 0.17683761f, -0.22859746f, 
    -0.08785169f, 0.10129068f, -0.27276137f, 0.31537479f, 0.20247741f, -0.07748881f, -0.07934199f, -0.57658780f, 
    0.00890922f, 0.04579493f, -0.31855172f, 0.05081910f, -0.02987614f, -0.22107942f, -0.19885688f, -0.23150136f, 
    0.06680432f, 0.08800151f, -0.30417731f, -0.21794526f, 0.12098975f, 0.00642340f, 0.28862435f, 0.26417413f, 
    0.09318561f, 0.07538657f, 0.18826696f, -0.01193162f, 0.10660185f, -0.01177618f, 0.25489721f, -0.30274674f, 
    0.05545083f, 0.15411024f, 0.05947281f, -0.08356903f, -0.40611216f, 0.20765461f, 0.09973899f, -0.13059795f, 
    0.24831381f, -0.05354547f, -0.08779970f, 0.36041451f, -0.03159393f, -0.30683622f, -0.26328364f, 0.08055766f, 
    -0.07156534f, -0.11614546f, -0.02504515f, -0.10526750f, -0.16622092f, 0.34717342f, 0.20698054f, -0.03731259f, 
    0.34606978f, 0.04294512f, -0.11029705f, 0.13702093f, -0.09141263f, 0.21962248f, -0.37375164f, -0.62684464f, 
    -0.00071475f, -0.09495933f, -0.34503093f, 0.16120285f, 0.07472108f, 0.08786126f, 0.04299145f, -0.34445855f, 
    -0.36419398f, 0.07098535f, -0.09621395f, 0.04491601f, 0.36657697f, 0.16933557f, 0.38375938f, -0.51430184f, 
    -0.12394862f, 0.38852388f, -0.56506664f, -0.11036099f, -0.04167882f, 0.05353203f, -0.10865401f, 0.28241521f, 
    0.09292202f, 0.02249307f, -0.41345742f, 0.03845030f, -0.24649252f, 0.06965226f, -0.17042863f, 0.08725434f, 
    -0.11346386f, 0.17656171f, -0.10622445f, 0.02550175f, 0.10457234f, 0.08792989f, -0.14255482f, -0.11674293f, 
    0.17597675f, -0.12362465f, 0.08255158f, 0.02476792f, 0.02087867f, 0.07015992f, 0.14705378f, 0.07161140f, 
    0.04337200f, -0.10985322f, 0.07473643f, 0.05860534f, 0.04302516f, -0.14184409f, 0.25855190f, -0.11758516f, 
    -0.42986178f, 0.10763594f, -0.65683407f, -0.15955594f, 0.02737621f, 0.06204467f, -0.28096411f, 0.07476798f, 
    -0.12738022f, 0.06441025f, -0.02365757f, 0.23001826f, -0.52246863f, 0.01328837f, 0.06120708f, 0.43686056f, 
    -0.59107524f, -0.03655659f, 0.20405838f, 0.03810307f, -0.29235393f, -0.20121515f, -0.00713794f, 0.35065627f, 
    -0.01909349f, -0.10875168f, 0.23692332f, 0.22041166f, 0.02537706f, 0.09053333f, -0.20814860f, -0.71362847f, 
    -0.03389488f, -0.67155141f, 0.01186535f, -0.60935223f, 0.05203035f, 0.05408990f, -0.75588232f, -0.15442502f, 
    -0.18749985f, 0.40706655f, 0.10445526f, 0.09876936f, 0.00239159f, -0.23249638f, 0.01140579f, -0.09588582f, 
    -0.33683676f, 0.06106293f, 0.11341012f, 0.07625473f, -0.22360386f, -0.14934951f, 0.30786690f, -0.03672338f, 
    -0.24507044f, -0.05358089f, -0.26889855f, -0.05566661f, 0.12664345f, -0.37133387f, -0.14319283f, 0.01667674f, 
    0.12992896f, -0.10444010f, 0.20090471f, 0.25762466f, -0.08831667f, -0.22465988f, 0.14056122f, -0.18799840f, 
    0.05415240f, -0.07540354f, 0.06608646f, -0.03233994f, -0.40068161f, 0.00568014f, 0.04293982f, 0.24082160f, 
    -0.27860650f, -0.04931904f, 0.21011822f, -0.09459841f, 0.14594883f, 0.04254550f, 0.16800830f, 0.13548513f, 
    -0.09791785f, 0.23560578f, 0.14201462f, 0.19342142f, -0.03766094f, -0.03503744f, -0.11260211f, 0.05657997f, 
    -0.11726840f, -0.15720245f, 0.30668789f, -0.31687987f, 0.59514606f, 0.04068128f, 0.01698345f, -0.52995473f, 
    0.11954422f, 0.03919854f, -0.02987400f, 0.11587636f, 0.07434255f, -0.11949954f, 0.03054094f, -0.05431250f, 
    -0.08607801f, 0.04786199f, -0.01329838f, -0.12855144f, -0.02312744f, -0.16251527f, -0.34691730f, -0.11409362f, 
    -0.08658148f, -0.01604943f, -0.21682468f, 0.11302783f, -0.00118380f, -0.07008349f, -0.41899931f, 0.04251298f, 
    -0.51938486f, -0.01638183f, 0.20437351f, 0.07342992f, 0.08468051f, -0.36789706f, 0.06883573f, 0.21068972f, 
    0.06636969f, 0.03851891f, 0.28044298f, 0.22018425f, 0.17160623f, -0.01017991f, 0.04130351f, 0.05999562f, 
    0.47109663f, -0.04087996f, -0.36742312f, 0.07835742f, 0.10946647f, 0.06366360f, 0.05663404f, 0.37881312f, 
    0.03177350f, -0.24226676f, -0.01777693f, -0.11038457f, -0.00816334f, 0.07308133f, 0.19903040f, 0.02951992f, 
    -0.03587095f, 0.12572527f, -0.06963670f, 0.12548767f, -0.34801394f, 0.02937200f, 0.06935062f, -0.16008781f, 
    0.23900685f, -0.56973088f, -0.05971421f, 0.11096179f, -0.03344546f, 0.19704251f, -0.02948818f, -0.11103465f, 
    0.21121345f, 0.08241855f, -0.08719032f, 0.22708084f, -0.39621648f, 0.03079414f, -0.09528443f, -0.10648411f, 
    0.22867453f, 0.10104927f, 0.40294313f, -0.12752055f, -0.10196265f, 0.10575062f, -0.16997103f, -0.04768081f, 
    0.05376967f, 0.10546616f, 0.22389264f, -0.65427476f, -0.03822825f, -0.11204911f, 0.16160136f, 0.31062973f, 
    -0.07105529f, -0.04844847f, 0.23872432f, -0.26720947f, 0.15280931f, 0.06548298f, -0.01137420f, 0.22246717f, 
    -0.61271119f, 0.02621840f, -0.56303477f, -0.11316060f, 0.02726037f, 0.13667965f, -0.09495714f, -0.18644252f, 
    0.00793292f, 0.02445078f, 0.14326763f, -0.12152485f, -0.07505817f, 0.00530710f, 0.10452551f, 0.17461546f, 
    -0.08849573f, 0.16911107f, -0.05966919f, -0.25209948f, 0.17837489f, 0.07201943f, 0.05171630f, 0.32379699f, 
    0.01013326f, -0.29457483f, 0.05408740f, -0.01383906f, -0.06484135f, -0.76801449f, -0.13247144f, -0.13432625f, 
    0.29090807f, -0.06070434f, -0.05259737f, 0.31015989f, -0.38814688f, 0.10957130f, 0.09720983f, 0.06167531f, 
    -0.37560597f, -0.11691854f, 0.01461894f, 0.10520004f, 0.26833361f, 0.02003873f, 0.23387994f, -0.03947018f, 
    0.29496729f, 0.11294037f, -0.21088162f, 0.23798892f, 0.01963538f, 0.09559134f, 0.35000345f, 0.15765777f, 
    -0.06625535f, 0.00787302f, -0.25830179f, 0.00801679f, 0.29390669f, -0.07790065f, 0.02931263f, -0.22006813f, 
    -0.11240518f, -0.09797323f, 0.10156363f, -0.09134552f, -0.24071939f, 0.00837441f, 0.01086799f, -0.14466332f, 
    0.04984711f, -0.28093046f, 0.17459613f, -0.08584715f, 0.09546518f, -0.12951477f, -0.42511156f, -0.00694346f, 
    -0.03184247f, -0.36177689f, -0.31353757f, 0.12673804f, -0.27334753f, -0.01933928f, -0.51979637f, -0.30219784f, 
    -0.43467477f, -0.28611720f, -0.09311052f, -0.09131642f, 0.13556384f, 0.09285503f, -0.67037368f, 0.02980031f, 
    -0.41780138f, -0.04291170f, 0.04490850f, 0.22518450f, 0.24471466f, -0.46209970f, -0.34385094f, 0.02159822f, 
    -0.07292180f, -0.04569877f, 0.24027586f, 0.11073574f, 0.37018946f, -0.00340604f, 0.00077167f, -0.00450827f, 
    0.02220333f, 0.06133304f, 0.37671492f, -0.10607459f, -0.07921334f, 0.29489410f, 0.19972771f, -0.14331804f, 
    -0.01173110f, 0.04846919f, -0.54716480f, -0.00442234f, -0.01863339f, -0.02307637f, 0.10423502f, 0.12328476f, 
    -0.06287126f, -0.04573289f, -0.68949562f, -0.01462944f, 0.20644829f, -0.56884551f, -0.59917438f, -0.06550435f, 
    0.10566199f, -0.47452003f, -0.10669349f, 0.09297865f, -0.00580913f, -0.00801301f, 0.04528311f, 0.02815510f, 
    0.07190683f, -0.24192828f, 0.15100303f, 0.35057244f, 0.27018529f, 0.00310582f, -0.11715301f, 0.10031483f, 
    0.17378697f, 0.01706824f, -0.09288712f, -0.06803338f, -0.43765682f, 0.33570260f, -0.46649641f, -0.12297098f, 
    -0.19436158f, -0.01559174f, 0.07942786f, 0.30062845f, -0.11529494f, 0.15721229f, 0.14144358f, -0.02192645f, 
    -0.12148673f, -0.10644820f, 0.30359539f, -0.10504755f, 0.11272051f, -0.26018673f, -0.42067134f, -0.06885586f, 
    0.31195119f, -0.03276740f, 0.08999939f, -0.24236166f, 0.01717833f, 0.08151114f, -0.03209068f, -0.25336972f, 
    0.00752608f, -0.08917824f, -0.00459048f, 0.09141850f, -0.39525935f, 0.00115409f, -0.08388808f, -0.30228245f, 
    0.33637658f, -0.13424201f, 0.07626080f, 0.00288438f, 0.08980170f, 0.48385844f, -0.05312689f, -0.46589130f, 
    -0.07694599f, -0.02036077f, 0.18842985f, -0.58720863f, -0.07391674f, -0.03416645f, 0.09068529f, 0.02248994f, 
    0.01245241f, 0.32505250f, 0.12370770f, 0.24655539f, -0.37855712f, 0.01374102f, -0.34532037f, 0.12406271f, 
    -0.29110375f, -0.27189100f, 0.07552159f, 0.04248751f, 0.33927068f, 0.13068393f, -0.15403169f, 0.08568142f, 
    0.07423784f, 0.06928898f, -0.09086428f, 0.22888063f, 0.20529586f, 0.26446667f, -0.29538751f, 0.03179578f, 
    0.28952205f, -0.07540217f, -0.53412855f, 0.04889216f, -0.66521960f, 0.31777486f, -0.19709265f, -0.06755391f, 
    0.00754885f, 0.09230762f, -0.38130176f, -0.03262578f, 0.05413401f, 0.28264061f, -0.43177027f, -0.39341018f, 
    0.01330065f, -0.12813076f, 0.34833479f, -0.78039694f, -0.27501634f, 0.10466916f, 0.11535653f, 0.11542140f, 
    -0.00412995f, 0.04887668f, -0.39731979f, -0.07716869f, -0.02187875f, -0.51614392f, -0.26533875f, 0.02362731f, 
    0.00567584f, -0.02149034f, 0.14101559f, 0.17958897f, -0.10142900f, -0.07399470f, 0.07618680f, -0.45596164f, 
    -0.06259229f, 0.27638701f, -0.04227498f, -0.19666441f, 0.03185032f, 0.02260564f, -0.49259537f, 0.08434225f, 
    -0.11017731f, 0.03334926f, 0.02778228f, 0.01301450f, 0.32727644f, 0.23608759f, -0.33105636f, -0.09515165f, 
    -0.06811124f, 0.01670498f, 0.04572048f, -0.00315158f, 0.15334573f, -0.11194570f, 0.07954863f, -0.04368685f, 
    -0.16238925f, -0.00845601f, 0.14703785f, -0.03205090f, -0.11786580f, 0.14197364f, 0.14360963f, 0.11052068f, 
    0.15205638f, 0.07095649f, -0.14085503f, -0.39261913f, -0.10758116f, 0.00014737f, -0.29255185f, 0.03579102f, 
    0.00862371f, 0.06594573f, 0.01899537f, -0.75294793f, 0.21748443f, 0.05354449f, 0.05724944f, 0.04604721f, 
    0.24472013f, -0.05507420f, 0.12516390f, 0.10688698f, -0.73622644f, -0.47253034f, 0.31996587f, -0.21317367f, 
    -0.03983695f, -0.24059163f, 0.24569865f, 0.04374981f, 0.07647248f, -0.03863488f, -0.25656915f, -0.00700578f, 
    -0.00464871f, -0.39904991f, 0.44637758f, 0.11535041f, -0.57967299f, -0.08145160f, 0.19930276f, -0.21969764f, 
    0.28861988f, -0.03474946f, -0.00370271f, 0.04370615f, -0.12086106f, -0.26085728f, 0.47177932f, 0.11008879f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06543283f, -0.04276739f, -0.02125952f, 0.11356191f, -0.10425287f, 0.08294465f, -0.00110505f, -0.00593410f, 
    -0.01143696f, 0.01024279f, 0.01720586f, 0.18363170f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
