#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.30173156f, 0.19907045f, -0.95220470f, -0.51817721f, 0.55005097f, 0.05804981f, 0.13750958f, -0.68213671f, 
    -0.75065416f, -0.80385303f, -0.38811243f, 0.56745631f, -0.27201298f, -0.13167536f, -0.49386853f, -0.10283346f, 
    -0.12458615f, 0.05055173f, -0.03117286f, 0.00483464f, 0.02230038f, 0.00225549f, -0.07112719f, 0.23613626f, 
    -0.31156740f, 0.93830466f, 0.69310600f, -0.08361820f, 0.05880388f, -1.23082638f, -0.23046291f, -0.21648493f, 
    0.40983960f, 0.00716244f, -0.15357558f, -0.01506638f, -0.19159333f, 0.41080669f, -0.13467188f, -0.38861507f, 
    0.07007319f, 0.27479428f, 0.02045336f, -0.16038826f, -0.31875426f, -0.02930296f, -0.13032642f, -0.35338554f, 
    -0.06946513f, -0.04587803f, 0.58693254f, 0.05811224f, 0.14897567f, 0.06323089f, -0.84336436f, 0.48551750f, 
    0.33608738f, -0.29330075f, -0.32108912f, -0.28732046f, 0.20424287f, -0.35373634f, -0.19177678f, -0.10467539f, 
    0.04748131f, -0.15814184f, -0.04684798f, 0.10909947f, 0.07239518f, -0.17250736f, -0.43435225f, -0.05829990f, 
    -0.42881289f, -0.49272451f, -0.77300310f, 0.08473776f, 0.25954184f, -0.01768380f, -0.19567132f, -0.55931461f, 
    0.45168307f, 0.13928306f, -0.21315426f, 0.37580138f, -0.12585747f, 0.41733989f, -0.17198186f, 0.12914909f, 
    -0.03796133f, -0.46752277f, 0.01871543f, 0.06796516f, 0.17053500f, -0.19333364f, -0.05887843f, 0.19029643f, 
    0.33836079f, 0.17707597f, -0.21426369f, 0.52787435f, -0.93899810f, -0.87911981f, -0.30508760f, 0.18604536f, 
    1.00231242f, 0.36284307f, 0.10341950f, -0.30351573f, -0.00499210f, 0.52481323f, 0.16949867f, -0.29089707f, 
    -0.05791655f, -0.02191030f, 0.08554919f, -0.13611871f, -0.05482825f, 0.41354015f, -0.36445525f, 0.16327003f, 
    -0.10194090f, -0.40295848f, -0.18005204f, 0.08399884f, -0.19915305f, -0.75467283f, -0.44294631f, -0.58992404f, 
    -0.61515850f, -0.09291798f, 0.01946233f, -0.11547133f, 0.32217461f, 0.63076544f, 0.51685846f, 0.10309310f, 
    0.14048032f, 0.00295448f, -0.18186235f, 0.17703699f, -0.00335094f, -0.12902738f, -0.17081942f, -0.14225858f, 
    -0.11562860f, -0.01394772f, -0.36439136f, -0.22375150f, -0.10113261f, -0.56247556f, -0.99694353f, -0.37057599f, 
    -0.72694433f, -0.71508503f, -0.45479608f, 0.71626770f, 0.22386882f, 0.16503939f, 0.44766298f, 0.83987451f, 
    0.09456935f, 0.04031138f, -0.34153709f, 0.08373815f, -0.31721732f, -0.04782657f, 0.12843697f, -0.02457877f, 
    0.14833538f, -0.14582838f, 0.13085495f, -0.13648310f, 0.28624347f, 0.03919470f, 0.07225553f, 0.19955617f, 
    0.21499369f, -0.20021659f, 0.14720541f, -0.39393061f, 0.33715931f, -0.06830644f, 0.24153575f, -0.09596659f, 
    -0.11045248f, -0.32929200f, -0.01660236f, 0.18343103f, 0.45173377f, -0.55142415f, -0.46339917f, 0.10832997f, 
    0.58024561f, 0.11812028f, -0.29446381f, -0.12988594f, -0.07347561f, -0.21930568f, 0.24895607f, 0.26899073f, 
    0.22099078f, -1.30974948f, -0.59266263f, -0.42245963f, 0.73145038f, -0.69356835f, -0.43853527f, -0.31080264f, 
    0.43303517f, 0.44942659f, 0.34537497f, 0.26078066f, 0.46265101f, -0.00441377f, -0.22025551f, -0.16964111f, 
    -0.09057466f, -0.09718829f, -0.25917518f, -0.16873173f, 0.26170418f, -0.38353169f, -0.28637293f, -0.23810337f, 
    0.40971899f, 0.11211647f, -0.39755329f, -0.38709593f, -0.24540256f, 0.04541286f, 0.46444827f, -0.60384727f, 
    -0.33866265f, -0.29194194f, -0.00600984f, 0.27309680f, 0.79420638f, -0.16139379f, 0.01938301f, 0.17191455f, 
    -0.18293467f, 0.06494510f, -0.34985083f, 0.06731595f, 0.29325309f, -0.10715862f, -0.01092831f, 0.19867089f, 
    0.09516530f, -0.23331307f, -0.70357108f, -0.64537823f, -0.15286052f, 0.67323780f, 0.42925897f, -0.80158788f, 
    -0.25731331f, -0.11837199f, -0.06104525f, -0.73917466f, -0.02596508f, 1.02546799f, -0.22262520f, -0.00667646f, 
    -0.32641187f, 0.08836660f, 0.02020307f, 0.38860506f, -0.14953823f, -0.48844725f, -0.24965440f, -0.12758824f, 
    0.16409799f, 0.14339311f, -0.06833252f, -0.09738798f, 0.57821620f, -0.12335876f, 0.13416027f, 0.60518825f, 
    -0.95982510f, -0.78767377f, 0.13311037f, -0.19878606f, 0.32552040f, -0.26164401f, -0.50106680f, 0.31332153f, 
    0.32450807f, -0.05938833f, 0.23436286f, 0.16817264f, 0.20810375f, 0.01179182f, -0.48827663f, -0.32272890f, 
    -0.19265166f, -0.04559577f, 0.18006866f, -0.06741421f, -0.88845074f, -0.24629559f, -0.17522314f, -0.69802809f, 
    -0.60596108f, -0.26277155f, -0.19563112f, -0.84500939f, -0.86710453f, -0.42402092f, -0.18012418f, -0.00272233f, 
    0.03675684f, -0.52678192f, -0.22481968f, 0.41018677f, 0.27480808f, -0.04839397f, 0.02999605f, 0.13500716f, 
    0.06102208f, 0.01743637f, 0.20823088f, 0.33977190f, 0.32693422f, -1.25869012f, -1.03786850f, -0.60166687f, 
    0.12838335f, 0.31354773f, 0.42666140f, 0.03587481f, -0.76227337f, -0.12694308f, 0.93297160f, 0.02311675f, 
    -0.41044131f, 0.03927541f, 0.33464748f, 0.23205529f, -0.28587389f, -0.08530492f, -0.19182067f, -0.50028217f, 
    -0.43703720f, -0.16456011f, 0.15547900f, -0.01243232f, 0.23721611f, 0.14259271f, -0.50023687f, -0.74185467f, 
    -0.85819030f, -0.95055437f, -0.48270425f, 0.17178524f, 0.17883800f, 0.08152679f, 0.16069371f, -0.33073920f, 
    0.44150943f, 0.28815985f, -0.05378204f, -0.29942235f, -0.51602685f, -0.76384109f, -0.00630108f, -0.23869447f, 
    -0.48341209f, -0.46090075f, -0.52817118f, 0.21643426f, 0.02022817f, 0.25340927f, -0.17401706f, -1.14584732f, 
    0.28720698f, 0.50846946f, 0.41008604f, -0.01924196f, 0.60547715f, 0.06745918f, -0.29472893f, -0.21925172f, 
    -0.40858361f, 0.08343230f, 0.02032795f, 0.01141561f, -0.18085167f, -0.29460242f, 0.02807656f, 0.03243618f, 
    -0.07192829f, -0.38029841f, -0.46417144f, -0.35717124f, -0.16579123f, -0.29819763f, -0.05997964f, -0.67859650f, 
    0.05943033f, 0.16261370f, 0.15056290f, 0.29989666f, 0.55276245f, 0.11327795f, 0.29510027f, 0.11224502f, 
    -0.07880145f, -0.05937209f, 0.03998487f, -0.39947528f, -0.17047366f, 0.06262719f, 0.18953757f, -0.18044172f, 
    -0.08206464f, 0.06169785f, 0.02551783f, 0.07887029f, 0.12034564f, -0.29013327f, -0.17652562f, -0.37718734f, 
    -0.41866753f, -0.41802770f, -0.05130143f, -0.59810865f, 0.41189465f, -0.42988071f, -0.23516625f, -0.29881212f, 
    -0.09229950f, 0.06486005f, 0.47425622f, -0.01451281f, -0.24434550f, 0.19238399f, -0.42875150f, 0.03468196f, 
    0.43031982f, 0.14063606f, 0.14192759f, 0.21821930f, -0.01432642f, 0.09965470f, -0.33714819f, -0.39228502f, 
    -0.07452426f, -0.64174759f, 1.12912762f, 0.01979774f, 0.10647082f, -0.14420949f, -0.49661648f, -0.23488018f, 
    0.28690335f, -0.60057622f, 0.19394268f, -0.68483269f, -0.07111137f, 0.00914224f, -0.11152669f, -0.05703035f, 
    0.29653722f, 0.15085824f, 0.49779657f, 0.13379337f, -0.20963588f, 0.16810440f, -0.41285798f, -0.04900851f, 
    -0.10535960f, -0.01650815f, -0.18854567f, -1.15146375f, -0.66248995f, -0.02692750f, 0.65178996f, 0.53939939f, 
    0.54891729f, 0.01323990f, 0.02945911f, 0.13233799f, 0.08859152f, -0.34758627f, -0.21444498f, -0.08374885f, 
    0.36505753f, -0.32859531f, 0.00953814f, 0.07732961f, -0.14017035f, 0.05811955f, -0.32456580f, -0.02885861f, 
    0.13058718f, 0.15215716f, 0.27366683f, 0.06884588f, 0.27027366f, -0.15697686f, 0.10848460f, 0.10940976f, 
    0.41450176f, 0.23832107f, 0.32025373f, -0.01595120f, 0.35349599f, 0.15344197f, -0.19635221f, 0.30058548f, 
    0.21448739f, -0.01902616f, -0.01284419f, -0.25892833f, -0.23730566f, -0.16523521f, -0.02418055f, -0.27819055f, 
    -0.21816668f, 0.18277442f, -0.22643524f, 0.17897364f, 0.06885960f, -0.09946517f, -0.44781372f, -0.10998903f, 
    -0.49388692f, -0.78906476f, 0.98995376f, 0.62934226f, -0.10182128f, -0.19842219f, 0.28868991f, 0.17833400f, 
    -0.21800226f, 0.19954678f, 0.01041762f, -0.16110234f, 0.18164909f, -0.12103456f, -0.08889206f, 0.08478264f, 
    -0.14492013f, -0.20628296f, -0.03688595f, 0.10394463f, 0.00691506f, -0.05788250f, -0.54177266f, -0.54163730f, 
    -0.48630154f, -0.39663175f, -0.36225843f, -0.53306234f, -0.36202529f, -0.43742093f, -0.51757371f, -0.23282401f, 
    0.54153961f, -0.12098279f, 0.19677694f, 0.26314256f, 0.24961963f, -0.11494634f, -0.24150658f, -0.40462863f, 
    -0.28436723f, -0.68296528f, -0.18664771f, -0.35220349f, -0.17733058f, -0.09307022f, -0.49979460f, -0.18230765f, 
    0.72824854f, -0.23341866f, -1.00111949f, -0.90123057f, -0.38679603f, -0.12341157f, 0.37110236f, 0.54770321f, 
    0.39772427f, 0.04882910f, -0.24494678f, 0.60555601f, -0.43452498f, -0.23445778f, -0.25890476f, -0.51076144f, 
    -0.16174407f, 0.01562309f, 0.27858725f, -0.28879216f, 0.29126248f, -0.11494146f, -0.01299667f, 0.57540655f, 
    0.34805307f, 0.28598464f, 0.32609224f, -0.13577551f, -0.24147472f, -0.03665982f, -0.36062893f, 0.08630553f, 
    0.45422256f, 0.33114275f, 0.20977782f, -0.35830632f, -0.19576140f, -0.03068286f, -0.37637880f, -0.04128824f, 
    -0.33453873f, 0.12218864f, 0.05229842f, 0.15808259f, -0.25095111f, 0.29367352f, 0.09032172f, -0.07262729f, 
    0.01745156f, -0.67542821f, -1.04669654f, 0.47107753f, 1.51468813f, 0.88514328f, -0.08212842f, -0.43176636f, 
    -1.04678607f, -0.65355557f, 0.13260235f, -0.08741232f, 0.42011359f, -0.15540259f, 0.27792853f, 0.03452919f, 
    -0.09689874f, 0.04681703f, -0.09695315f, 0.31176543f, 0.12231427f, 0.43502912f, -0.24586509f, -0.09200784f, 
    -0.02295592f, -0.07955740f, 0.34915632f, -0.03904358f, 0.20563182f, 0.03358384f, -0.19988330f, -0.50796980f, 
    -0.20819792f, -0.63566130f, -0.66264826f, -0.53470683f, 0.33322346f, 0.43478665f, -0.19687511f, 0.12296087f, 
    0.18359162f, 0.10081720f, 0.23575270f, -0.03216214f, 0.09930813f, -0.35369152f, -0.13097781f, -0.08847316f, 
    -0.02065563f, -0.03544552f, 0.15421379f, 0.52995372f, 0.89403635f, 0.61051059f, 0.08793060f, -0.15175769f, 
    -0.17991874f, -0.46342233f, -0.54449356f, -0.26127055f, -0.40160564f, 0.06961573f, 0.19123398f, 0.55248457f, 
    -0.38541484f, -0.03726448f, -0.39132905f, -0.33047923f, 0.16119027f, 0.16332737f, 0.16784643f, -0.10159402f, 
    0.18620279f, 0.05563204f, -0.00177750f, 0.11224968f, 0.72434598f, -0.20107774f, 0.10032270f, 0.05412362f, 
    -0.47784883f, 0.56305653f, -0.65264165f, -0.35719758f, 0.45765224f, 0.02203720f, 0.38042760f, -0.08177447f, 
    -0.25297135f, -0.05669650f, -0.30732584f, -0.36348960f, 0.21415676f, -0.22225931f, 0.10121054f, -0.02926686f, 
    0.09602055f, -0.38138196f, -0.15202321f, -0.22688013f, -0.29930171f, -0.84920937f, -1.01572537f, -0.82288599f, 
    -0.53396368f, -0.31775752f, -0.21438394f, -0.46877614f, -0.60492688f, -0.88853019f, -0.68827116f, -0.23891488f, 
    -0.28673154f, -0.08876001f, 0.47305942f, -0.30379373f, -0.03439981f, -0.48518676f, -0.22635424f, 0.19020563f, 
    -0.15630791f, -0.20920618f, -0.10742787f, -0.26439428f, -0.04455616f, -0.22372831f, 0.60897768f, 0.46289858f, 
    -0.31021988f, 0.37203401f, -1.13585830f, 0.04038247f, -0.46597713f, -0.28362182f, 0.44397682f, 0.42584133f, 
    -0.05021245f, 0.18468459f, -0.28476048f, -0.12780111f, -0.17675379f, 0.05698795f, -0.10774794f, 0.00789664f, 
    0.25955921f, -0.17140082f, 0.07444118f, -0.14750564f, -0.06193559f, 0.30430374f, -0.15600285f, 0.69306105f, 
    -0.68161070f, -0.38619214f, 0.25760248f, 0.23774344f, 0.78597200f, 0.97780532f, -0.06290897f, -0.74807256f, 
    -0.70760036f, -0.10304335f, -0.07351915f, 0.20376526f, -0.43066576f, -0.03309366f, -0.18033530f, 0.16239049f, 
    0.05986167f, 0.01393358f, -0.23961529f, 0.19461387f, -0.27620649f, 0.15342231f, -0.07074835f, 0.13595808f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.34611261f, 0.43178070f, -0.05537071f, 0.16233242f, 0.46582556f, 0.02262413f, -0.04935064f, 0.38267517f, 
    0.44661146f, 0.40112999f, 0.46287933f, 0.29249546f, -0.30344972f, 0.40222579f, -0.11988801f, -0.02976388f, 
    -0.06865393f, 0.03822639f, 0.13339992f, 0.33220074f, 0.29920283f, 0.23300786f, -0.34487143f, 0.57631516f, 
    0.47693244f, 0.35147959f, -0.01864863f, 0.31652653f, -0.02088693f, -0.54117835f, 0.16525012f, 0.44766498f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.22294647f, 0.13006230f, -0.44884986f, -0.07130791f, 0.21745583f, 0.03208089f, 0.00209475f, 0.06911148f, 
    -0.09489798f, -0.01153346f, -0.01483133f, -0.08931944f, -0.62380028f, -0.81892085f, -0.07438551f, -0.13016845f, 
    0.01563826f, 0.01910270f, -0.06060116f, -0.00746183f, -0.19101837f, 0.00612276f, -0.15088555f, 0.21860491f, 
    0.11653528f, -0.19837400f, -0.26073429f, -0.09312139f, 0.06924100f, -0.06389731f, -0.20602486f, -0.07639206f, 
    -0.19141394f, 0.08917295f, 0.17995231f, 0.24831444f, -0.03579736f, -0.03254883f, -0.07583544f, 0.07137379f, 
    -0.30035278f, -0.04747436f, -0.08141626f, -0.08881409f, -0.09879439f, -0.16451608f, -0.09675402f, -0.21606773f, 
    0.39804605f, 0.21258056f, 0.03486816f, -0.05319026f, 0.00193313f, 0.14071915f, 0.10443732f, 0.01851808f, 
    0.09939337f, -0.02781495f, -0.01809736f, 0.00663534f, -0.02714102f, 0.06202460f, 0.02403516f, 0.00618494f, 
    0.11670255f, 0.18654166f, 0.09926791f, 0.06219245f, -0.01065663f, 0.10420343f, 0.13351297f, 0.23115981f, 
    0.10766958f, -0.12721106f, 0.00402948f, 0.00836844f, 0.14538069f, 0.24927635f, 0.06973293f, 0.09111603f, 
    -0.00983906f, 0.15046096f, 0.07101186f, -0.05679457f, -0.07456925f, -0.42762822f, -0.17576227f, 0.05275149f, 
    -0.11193946f, 0.04655087f, -0.07669813f, -0.07857403f, -0.14766286f, -0.19665922f, -0.09156760f, -0.09755560f, 
    0.06392857f, 0.38364968f, -0.01903586f, -0.46022722f, 0.01459425f, 0.09604714f, 0.13637744f, -0.38111567f, 
    -0.14899987f, -0.13268648f, 0.01848591f, 0.09639151f, 0.27754799f, 0.24378650f, -0.13481936f, -0.05557112f, 
    -0.05300957f, -0.21423113f, -0.17403488f, -0.10725982f, -0.01065842f, -0.03076550f, -0.01603493f, -0.08766960f, 
    0.20525496f, 0.25035399f, 0.00512130f, -0.31845087f, -0.02011857f, -0.18227112f, -0.15145043f, -0.06591599f, 
    0.02052101f, -0.06547530f, -0.10041940f, 0.01138509f, -0.41263169f, 0.36987215f, 0.20728798f, -0.16414553f, 
    -0.05637144f, -0.21052144f, -0.09500266f, -0.11392900f, -0.05415673f, -0.10594837f, -0.01334946f, 0.11605535f, 
    0.40981433f, 0.38246918f, -0.32519680f, -0.35632205f, 0.13775676f, 0.08370299f, -0.04805141f, 0.12208204f, 
    0.00445966f, -0.04998022f, 0.05347221f, -0.02688899f, 0.32356539f, 0.20719798f, 0.16443059f, -0.30806664f, 
    0.05648429f, 0.15211761f, 0.08611134f, -0.32914641f, -0.04725647f, -0.16253862f, -0.10424282f, -0.09858110f, 
    0.36011723f, 0.13545038f, -0.14257316f, -0.03639033f, 0.12560590f, 0.11118802f, -0.07317664f, -0.03697202f, 
    -0.28491020f, -0.07414034f, -0.01312890f, -0.00596148f, 0.26379237f, 0.20039593f, -0.14493068f, -0.08451229f, 
    -0.05414638f, -0.10961848f, -0.04162260f, 0.06945173f, -0.06449518f, 0.05957344f, 0.04216147f, 0.14811005f, 
    -0.07760997f, -0.09256034f, 0.05064751f, 0.09236750f, 0.06468292f, 0.03565449f, 0.09123579f, -0.00101451f, 
    0.03646817f, 0.02248152f, -0.01639639f, 0.22989190f, 0.05565686f, 0.22997162f, 0.12402990f, 0.06979780f, 
    0.14295407f, 0.12229549f, -0.00557377f, 0.09524546f, -0.06605218f, 0.09065359f, 0.05048255f, 0.21217294f, 
    0.02576459f, -0.16172056f, 0.01373482f, -0.03992246f, -0.26989093f, 0.04926589f, 0.00397195f, -0.10651461f, 
    -0.06377571f, 0.03774139f, 0.05174281f, 0.03209602f, 0.16948830f, 0.04621873f, 0.13949572f, -0.26640362f, 
    -0.24299029f, -0.08489291f, 0.12160777f, 0.03967249f, -0.10791910f, -0.05250015f, -0.11940330f, -0.22768010f, 
    -0.02071565f, -0.29458240f, -0.28025755f, 0.16666712f, 0.06808426f, 0.04937206f, -0.02013769f, 0.06505129f, 
    -0.07561983f, 0.00149956f, -0.01411728f, -0.30772144f, 0.06021138f, -0.30902353f, -0.38233167f, 0.09524904f, 
    0.07106456f, 0.03148440f, -0.13003746f, 0.03663415f, 0.02794769f, 0.01863153f, -0.09405036f, -0.01299196f, 
    0.35128611f, 0.23533691f, 0.03225204f, -0.17866307f, -0.11212599f, 0.00057221f, -0.28703535f, 0.09205696f, 
    -0.07009993f, -0.08914627f, -0.06240289f, -0.02220592f, -0.20050074f, -0.22309540f, 0.06918407f, -0.24332559f, 
    0.03690023f, -0.12267193f, -0.24456277f, -0.27488133f, 0.06232748f, -0.41807383f, -0.04769366f, -0.01545933f, 
    -0.79672092f, -0.00039333f, -0.12303942f, -0.37976089f, -0.05950708f, -0.01251080f, 0.00182572f, 0.09475847f, 
    0.01860825f, -0.05046449f, -0.03831171f, 0.02389767f, 0.35016432f, 0.17165755f, 0.11502911f, -0.24343634f, 
    0.08820719f, -0.16716380f, -0.01796198f, -0.05920473f, 0.04481861f, -0.09971088f, -0.02888526f, -0.04571973f, 
    0.26327810f, 0.02560939f, -0.13303356f, -0.07996543f, 0.03391480f, -0.14780368f, -0.10404870f, 0.06205969f, 
    0.00876805f, 0.05872914f, 0.05926572f, -0.03917238f, -0.18697762f, -0.21513055f, -0.62446392f, -0.20509650f, 
    0.04914469f, -0.13318032f, -0.09882074f, -0.03159115f, 0.00975681f, 0.01097385f, 0.08928716f, -0.02006369f, 
    -0.46393308f, -0.24500190f, -0.09070766f, -0.30382505f, 0.00196303f, -0.06448567f, 0.06219519f, 0.08654267f, 
    -0.12975504f, -0.05068497f, 0.08710443f, 0.17047803f, 0.53253323f, 0.24292023f, 0.00342744f, -0.15248898f, 
    0.32703969f, 0.32557863f, 0.31297666f, 0.13520980f, -0.07945009f, -0.09825215f, -0.04687392f, -0.03442504f, 
    -0.32466936f, -0.19336490f, -0.16487616f, -0.26067495f, 0.07994691f, -0.01197279f, -0.07494757f, -0.15083006f, 
    -0.10212990f, -0.15915428f, -0.11982474f, 0.03875353f, 0.15478523f, -0.60405743f, -0.39798805f, -0.05107346f, 
    -0.10244427f, -0.18548875f, 0.08537631f, 0.01918683f, 0.04526939f, -0.12161312f, 0.00094782f, -0.00780017f, 
    0.25934321f, -0.27576184f, -0.24752228f, 0.11894998f, -0.05245157f, -0.08892171f, 0.00484984f, -0.08361182f, 
    0.03352490f, 0.04266268f, -0.06194380f, 0.10920636f, 0.48910508f, -0.30831704f, 0.29150999f, -0.41454300f, 
    0.00821782f, -0.00881577f, 0.10034126f, -0.09780441f, 0.05442577f, -0.17845029f, -0.18393831f, 0.15414807f, 
    0.10462874f, -0.03690581f, 0.02323967f, -0.06387291f, -0.06471668f, -0.03707037f, -0.19309030f, 0.05934799f, 
    -0.22278582f, -0.36175910f, 0.10415143f, -0.11953308f, 0.11485046f, -0.01392934f, 0.05235937f, -0.11091127f, 
    0.14712213f, 0.00152427f, 0.00714963f, -0.00817013f, -0.09355640f, 0.06327329f, -0.00267113f, -0.04525893f, 
    0.23908845f, 0.06337114f, -0.10286234f, 0.06014419f, 0.05357362f, 0.00094657f, 0.06265580f, -0.05710310f, 
    0.16253294f, -0.02213364f, -0.23444745f, -0.10812272f, -0.17253029f, -0.06409441f, -0.16444121f, -0.13986979f, 
    -0.03443933f, 0.06326406f, -0.14115101f, -0.11905530f, -0.19980182f, -0.07685235f, 0.03734380f, -0.06676022f, 
    0.15526591f, 0.29599333f, -0.11426283f, -0.14071806f, -0.10584871f, -0.06416418f, -0.09252693f, -0.22557637f, 
    -0.07841158f, -0.18305810f, -0.07166547f, -0.12669402f, 0.24772255f, 0.01750868f, 0.09155679f, -0.23221347f, 
    -0.00289370f, 0.03604484f, 0.01847095f, -0.06325474f, 0.27991503f, 0.03668079f, 0.22745922f, 0.09617172f, 
    -0.58250713f, -0.23929858f, -0.25142682f, 0.20189919f, 0.00584882f, 0.10375801f, 0.00771583f, -0.29915243f, 
    0.27760544f, 0.07110484f, 0.00060174f, 0.07284040f, -0.11706551f, 0.06894595f, -0.28474313f, 0.02749015f, 
    0.16410375f, 0.03577043f, 0.14686915f, 0.25608894f, -0.01811960f, 0.19844323f, -0.06953804f, 0.00608316f, 
    -0.43564695f, -0.13536720f, -0.15131602f, -0.25186408f, -0.26993626f, 0.33953345f, 0.05693859f, 0.23710847f, 
    -0.00008470f, -0.00130783f, 0.02981627f, 0.10013455f, -0.45162997f, 0.17200817f, -0.15450145f, 0.01354436f, 
    0.34695259f, 0.02815579f, 0.14364672f, -0.17240414f, 0.00141110f, 0.09140327f, 0.07747664f, 0.04213000f, 
    0.34688643f, 0.29481915f, 0.22451460f, 0.12761460f, -0.16752493f, 0.09795046f, -0.08928701f, -0.13149069f, 
    0.01886502f, 0.02223645f, -0.09529936f, -0.02603468f, 0.00894823f, -0.07430617f, -0.10460942f, -0.05888179f, 
    0.03865768f, 0.02822965f, 0.16698684f, -0.00868289f, -0.13630852f, 0.05402308f, 0.14434376f, -0.11831176f, 
    0.09200344f, -0.07680113f, -0.20684808f, -0.19290507f, 0.00563478f, 0.11581376f, 0.09443789f, 0.24613690f, 
    0.06138221f, 0.09424408f, -0.18965755f, -0.00343990f, 0.10649378f, -0.22726327f, -0.04497541f, -0.14889875f, 
    -0.05431993f, -0.00225384f, 0.02828255f, 0.03823941f, -0.28459352f, -0.42059138f, -0.52970070f, -0.20631562f, 
    0.14603794f, 0.14970621f, 0.16256538f, 0.15825726f, 0.00672387f, -0.08702974f, -0.04136134f, 0.00215379f, 
    0.00005521f, -0.00220197f, 0.21185717f, -0.04070285f, -0.20860276f, 0.03918619f, -0.02009432f, -0.00394977f, 
    0.03222602f, -0.36307365f, -0.25045928f, -0.13360824f, 0.09405238f, -0.20218693f, -0.12348568f, 0.03637991f, 
    0.11652233f, -0.11052871f, -0.08137899f, -0.05857835f, -0.13437660f, -0.00259922f, 0.19261956f, -0.00160234f, 
    0.09228438f, 0.23343417f, -0.16058466f, 0.06213805f, -0.19386658f, -0.03380658f, 0.12788028f, 0.06516649f, 
    -0.07548431f, -0.04451583f, 0.19433179f, 0.05218558f, 0.10691073f, -0.06060823f, -0.09140158f, 0.11662181f, 
    0.21514095f, 0.13020280f, 0.13594009f, 0.21578181f, -0.04285323f, -0.02488833f, 0.03125302f, -0.05896875f, 
    0.05812775f, 0.22652672f, -0.21956538f, 0.16134974f, 0.55865842f, -0.03485728f, -0.06532441f, -0.02839261f, 
    -0.04948949f, -0.09027910f, 0.03763572f, 0.01276297f, -0.00883629f, 0.16949770f, 0.14319944f, -0.17416149f, 
    -0.16848865f, -0.14821734f, 0.09079503f, -0.22753827f, 0.01943688f, 0.00779727f, -0.08097851f, 0.11727926f, 
    -0.04429732f, 0.06528387f, 0.08710179f, -0.04656900f, -0.24344052f, -0.13674934f, -0.02695576f, -0.29616845f, 
    -0.01988833f, 0.35084787f, -0.10020790f, -0.11584374f, -0.01105995f, 0.30939227f, -0.23036426f, -0.10899009f, 
    0.17972483f, 0.32716352f, 0.23630859f, 0.00753036f, -0.06721453f, 0.03440727f, -0.10794831f, 0.03844849f, 
    -0.02037358f, 0.05598661f, 0.00258564f, -0.05312008f, -0.29666734f, 0.33331570f, -0.10480523f, -0.03372768f, 
    -0.10246874f, -0.11283875f, 0.11328837f, 0.11370483f, 0.01610383f, -0.06080931f, 0.02131308f, -0.02082288f, 
    -0.06869259f, 0.02616791f, -0.16135445f, -0.30754444f, -0.24048001f, -0.07868641f, -0.07758949f, -0.17091121f, 
    -0.07262484f, -0.00237370f, -0.03069139f, 0.15495685f, 0.43635648f, 0.13735390f, -0.09232689f, -0.05435346f, 
    0.09020514f, -0.10597461f, -0.15370893f, -0.09384522f, -0.11796407f, 0.02652239f, 0.02825970f, 0.10537082f, 
    0.07747669f, 0.16341338f, 0.11964285f, -0.14634468f, -0.02156669f, -0.06616937f, -0.16338781f, 0.06089904f, 
    -0.03477408f, 0.08096659f, -0.12661043f, -0.22136828f, 0.20104043f, 0.14159884f, 0.45847055f, 0.35558075f, 
    0.06237946f, 0.01045508f, 0.05771790f, -0.32056373f, 0.03674419f, -0.00568576f, 0.03168725f, -0.03953821f, 
    -0.00414043f, -0.06506666f, 0.45054087f, -0.52758348f, -0.16667949f, -0.09559879f, 0.02639242f, -0.00497440f, 
    -0.06921785f, -0.05108344f, 0.26577991f, -0.06638613f, 0.74788088f, -0.40765870f, 0.38956261f, 0.34588876f, 
    -0.03961515f, -0.10483415f, -0.03100760f, -0.04093304f, 0.24107054f, 0.03342525f, 0.00577621f, 0.10936045f, 
    -0.16325384f, -0.13549419f, 0.02883582f, -0.32146695f, 0.02169607f, -0.04748712f, 0.07351805f, 0.10764888f, 
    -0.02853034f, -0.05353381f, -0.03233276f, 0.04197670f, -0.38600767f, 0.16161440f, -0.12200226f, -0.08047982f, 
    0.00365525f, 0.04354528f, -0.02899656f, -0.07757095f, 0.10488024f, -0.11111076f, 0.05266603f, 0.03770965f, 
    -0.08358312f, 0.07764444f, 0.06640062f, -0.21102270f, 0.02655035f, -0.05311358f, -0.07877074f, -0.15250996f, 
    0.22171621f, 0.22172548f, -0.03728859f, 0.03993096f, -0.12299337f, 0.03171996f, -0.03908402f, -0.10725068f, 
    0.11454174f, -0.05935585f, -0.15065621f, 0.08882605f, -0.03457088f, -0.09535637f, 0.01242879f, 0.08546173f, 
    0.04183525f, -0.16664837f, 0.13336553f, 0.14104506f, 0.08011986f, 0.06536512f, 0.00179451f, 0.08956790f, 
    -0.03230672f, 0.10223989f, 0.12578246f, -0.04528103f, 0.09422987f, 0.39233273f, 0.14322969f, 0.34746844f, 
    -0.06626463f, 0.00776081f, 0.11006694f, -0.04981960f, -0.05223587f, 0.04286910f, -0.08174364f, 0.28494996f, 
    -0.11399215f, 0.50667089f, 0.28411245f, 0.25494802f, -0.07125656f, 0.07176988f, 0.02851779f, 0.04486884f, 
    0.09429725f, -0.08649687f, -0.02548707f, 0.18436834f, -0.42019427f, 0.14385353f, -0.05909333f, -0.11108556f, 
    -0.05184040f, 0.03883950f, -0.00405721f, -0.00144487f, -0.00600639f, -0.17929979f, 0.33108407f, -0.16909803f, 
    0.11360633f, 0.18394484f, -0.28327426f, 0.19902584f, 0.13762574f, 0.09451123f, -0.39858788f, 0.12962237f, 
    -0.05249295f, 0.11833968f, -0.06454654f, 0.12003840f, -0.05721233f, -0.06237923f, -0.02094866f, 0.13378456f, 
    0.10628081f, -0.16559568f, -0.12823565f, 0.05141190f, 0.23036468f, 0.10986291f, -0.12918279f, 0.04635318f, 
    -0.16613579f, -0.34361100f, -0.33901286f, -0.02241493f, -0.13836335f, 0.08447153f, 0.01998762f, 0.00948722f, 
    -0.02548565f, -0.00915582f, -0.01552852f, 0.02764487f, -0.04591357f, -0.48813763f, 0.02689055f, 0.15977424f, 
    -0.21118154f, 0.09013359f, 0.15267688f, -0.19824381f, -0.03081717f, -0.01477489f, 0.04531030f, -0.09576127f, 
    -0.59783041f, -0.48773789f, -0.10819709f, -0.38901514f, 0.03779974f, -0.03280440f, -0.01618844f, -0.02586499f, 
    -0.06377258f, 0.05532773f, -0.02031853f, -0.00981738f, -0.00855388f, -0.44228041f, 0.54424673f, 0.61091930f, 
    0.09397325f, 0.01092632f, -0.11855442f, 0.15857901f, 0.02107998f, -0.13050447f, 0.00206816f, -0.10587765f, 
    -0.21604112f, 0.72851670f, 0.37556946f, 0.08189403f, -0.12791628f, -0.07305077f, 0.14181793f, -0.00646993f, 
    -0.07381897f, -0.30368266f, -0.21823327f, -0.00999309f, 0.14889491f, 0.06220299f, -0.15592834f, -0.34282222f, 
    0.05497126f, -0.07252878f, -0.09506615f, 0.01148668f, -0.06551848f, 0.18320034f, 0.10201360f, 0.08395573f, 
    0.06167577f, -0.04615373f, -0.21806175f, -0.09072297f, 0.00737415f, -0.04878704f, 0.06489600f, 0.11277013f, 
    0.03361654f, 0.00903954f, -0.19606838f, 0.07172352f, 0.00528321f, -0.06272266f, -0.02011065f, 0.18507105f, 
    0.24805570f, 0.14571594f, 0.02701766f, -0.06428291f, 0.03957485f, 0.11680101f, 0.18730426f, 0.14504239f, 
    -0.26976350f, -0.01610355f, -0.03085840f, -0.15270017f, 0.07166197f, -0.03348403f, -0.21829951f, -0.38753349f, 
    0.09755930f, 0.03756868f, -0.02289100f, 0.09625645f, -0.14880408f, -0.18357871f, -0.03662384f, 0.23053113f, 
    0.15636669f, 0.02980684f, 0.01797292f, -0.03227234f, 0.11520504f, -0.17995247f, 0.01454706f, -0.04287779f, 
    -0.08037864f, 0.05687433f, -0.09071575f, 0.03136431f, 0.00312020f, 0.01814210f, 0.06521192f, 0.04298851f, 
    -0.09622520f, -0.10346665f, 0.12314603f, -0.12974761f, -0.11219907f, 0.04931353f, 0.66486603f, 0.12476379f, 
    -0.00060228f, -0.01098581f, 0.12494851f, -0.04619630f, 0.09192178f, -0.12021524f, 0.04744894f, 0.08782697f, 
    -0.41045633f, -0.42191911f, 0.11596215f, -0.23547864f, -0.03571514f, 0.02951939f, 0.06985520f, -0.36976835f, 
    -0.08884908f, -0.00816608f, 0.04664654f, 0.07597787f, 0.25447917f, 0.43058601f, -0.29421863f, 0.19109631f, 
    0.15501699f, 0.17131293f, -0.15214400f, 0.07404316f, 0.02700672f, 0.03967642f, -0.14736745f, 0.08622266f, 
    -0.35822240f, 0.11138611f, 0.02268752f, -0.16519095f, 0.04299541f, 0.02512052f, 0.02807176f, 0.14785062f, 
    0.00354455f, -0.00988188f, -0.04738178f, 0.00734528f, -0.01737782f, 0.33768898f, -0.26180065f, 0.01283175f, 
    -0.02419798f, -0.24187393f, -0.24189298f, 0.18072788f, -0.03794952f, -0.01907565f, 0.01693988f, -0.03801310f, 
    -0.25654593f, -0.16411273f, -0.04202027f, 0.04014624f, -0.13968438f, -0.08648490f, -0.36649585f, -0.16910174f, 
    0.12723151f, -0.01293193f, -0.03942300f, 0.01546165f, -0.60948116f, -0.13677111f, 0.31164554f, -0.55610234f, 
    0.09743411f, 0.13894528f, -0.10714489f, 0.10782764f, 0.01180286f, 0.02595550f, 0.10198925f, -0.06653149f, 
    -0.37536460f, 0.56284165f, -0.11434965f, -0.01117816f, -0.05727748f, -0.06960998f, -0.06273577f, -0.03291885f, 
    0.00461773f, 0.00087798f, -0.19036059f, 0.24648340f, -1.05431402f, -0.59185314f, 0.31821054f, -0.19331875f, 
    0.00709599f, -0.26116663f, 0.06917112f, 0.06298958f, 0.01917142f, -0.00501049f, 0.03148947f, -0.11043100f, 
    -0.37812862f, 0.54676569f, 0.20542377f, -0.13425799f, -0.01479201f, 0.05962196f, -0.07605619f, 0.09203393f, 
    -0.10530391f, 0.04985077f, 0.04149710f, 0.01341228f, -0.25547615f, -0.04968609f, -0.25493199f, -0.14139862f, 
    0.02066246f, -0.08538999f, 0.02308151f, 0.11881910f, -0.00710914f, -0.05869645f, 0.05547656f, -0.09349184f, 
    0.07973851f, -0.08538540f, 0.17664303f, 0.12828310f, 0.14243932f, -0.13114968f, -0.05032563f, 0.01235447f, 
    -0.06033347f, -0.08503738f, -0.04986843f, 0.04672379f, -0.47504842f, -0.03718904f, -0.05117784f, -0.08404592f, 
    -0.29602942f, 0.05276386f, -0.21427527f, 0.04211521f, 0.00046370f, 0.21205106f, 0.03217541f, 0.01293288f, 
    -0.28806743f, 0.14511140f, 0.38797429f, 0.51121205f, -0.13246833f, -0.00937808f, 0.00863530f, 0.03077695f, 
    0.19661260f, 0.05708233f, 0.11427533f, 0.03367845f, -0.17737165f, -0.16672255f, -0.09922531f, 0.30803019f, 
    0.15205052f, 0.03434182f, -0.16307169f, -0.07108703f, 0.02605118f, 0.31264070f, -0.14717494f, -0.07149952f, 
    -0.40294603f, 0.30797359f, -0.37131840f, -0.61157560f, 0.27050570f, 0.01119677f, -0.01212740f, -0.20963961f, 
    -0.22790104f, 0.07422727f, -0.19417796f, -0.19181697f, 0.26005316f, -0.10373918f, -0.13475201f, 0.11526190f, 
    0.20789838f, 0.08094538f, 0.13968526f, -0.17106029f, -0.12853831f, 0.14916992f, -0.19255196f, 0.05516068f, 
    0.61938930f, -0.42957756f, -0.10311351f, 0.21669047f, 0.34141374f, 0.12816392f, 0.14001195f, -0.10023254f, 
    -0.04908958f, 0.00843952f, 0.05937637f, 0.07662228f, -0.27607948f, -0.50821537f, -0.09321440f, 0.07675327f, 
    0.03147018f, -0.07914017f, -0.09079407f, -0.14335905f, -0.12295913f, 0.08902652f, 0.02802880f, 0.08316825f, 
    -0.16328591f, 0.06508283f, -0.31647611f, 0.09403564f, 0.02704391f, -0.03002362f, 0.05397008f, 0.08560193f, 
    -0.05244275f, -0.04433067f, -0.20436768f, -0.20177558f, -0.30655563f, -0.26519838f, -0.40252697f, 0.01335190f, 
    0.10476549f, 0.00164678f, 0.26887071f, 0.09457479f, 0.08045016f, 0.06449817f, 0.12426464f, 0.12088466f, 
    0.13574255f, -0.06496296f, -0.14160495f, -0.00678990f, 0.04117914f, 0.08661867f, 0.16440523f, 0.16826327f, 
    -0.04503350f, -0.03063102f, -0.07853206f, 0.02825268f, 0.21151905f, -0.07441684f, -0.17078647f, 0.07333812f, 
    -0.50723487f, -0.00718033f, -0.23254983f, -0.08062430f, 0.29730624f, -0.01213583f, 0.11589537f, -0.06891359f, 
    0.12837331f, -0.23961811f, -0.03454848f, 0.23189782f, 0.03218266f, -0.05189160f, 0.01249032f, -0.09835579f, 
    0.01044119f, 0.06565550f, -0.23717515f, 0.02840705f, 0.09234046f, -0.03175871f, -0.21286748f, -0.15101382f, 
    0.22093129f, 0.02232142f, -0.20604187f, -0.06163151f, 0.03073261f, 0.05075260f, -0.11569522f, 0.10455031f, 
    -0.11083128f, -0.08700036f, 0.03340004f, 0.28743044f, 0.06662372f, -0.10064400f, 0.11992170f, 0.00728316f, 
    0.06060780f, 0.11755611f, -0.16572997f, 0.18082532f, 0.01752503f, 0.40808022f, 0.17683044f, 0.13594373f, 
    -0.00453828f, -0.02177886f, 0.17041206f, -0.05360654f, -0.18882936f, 0.05559039f, 0.03850434f, 0.02102901f, 
    0.20011443f, 0.20521066f, -0.39771485f, -0.30409560f, -0.06510408f, 0.14364064f, 0.03701239f, -0.06567898f, 
    0.10295611f, 0.04113324f, 0.19475606f, 0.11100581f, 0.13928364f, -0.03715751f, -0.02454726f, -0.02981844f, 
    -0.14689988f, 0.09027857f, -0.14188574f, -0.18491241f, -0.10948538f, -0.03436405f, 0.13240176f, 0.09121269f, 
    -0.36738515f, -0.10450003f, 0.26900998f, 0.43242440f, -0.16919295f, -0.02440625f, 0.21266232f, -0.07286154f, 
    -0.12557958f, 0.08358105f, -0.30602896f, -0.00838313f, -0.22114499f, 0.58780593f, -0.22882250f, -0.76062691f, 
    0.10061631f, 0.17915145f, -0.13687564f, 0.04266504f, -0.56707931f, -0.02602467f, -0.07423783f, -0.07873534f, 
    -0.49340478f, 0.28518474f, -0.15951082f, -0.34228593f, 0.13241036f, -0.16984491f, -0.01508518f, -0.17164330f, 
    -0.30401340f, 0.00426719f, -0.03109288f, 0.01216043f, -0.31391877f, -0.21757044f, 0.17029476f, 0.21403623f, 
    0.30651629f, 0.25327352f, 0.02125851f, 0.05869899f, -0.00263909f, -0.14531659f, -0.00869362f, -0.13894722f, 
    0.06425984f, -0.08916268f, -0.09638973f, 0.21886963f, -0.03718863f, 0.10836910f, 0.15165110f, 0.12934789f, 
    -0.05521302f, 0.10163692f, 0.04482140f, 0.03409265f, 0.49763244f, 0.10743841f, -0.05903080f, 0.42693302f, 
    -0.07110320f, -0.04778323f, -0.23769368f, -0.09476327f, 0.00063250f, 0.03627791f, 0.24358602f, -0.09904644f, 
    -0.26165625f, -0.32421532f, 0.15820037f, -0.23424947f, -0.12626746f, -0.01322692f, -0.10540849f, -0.05558575f, 
    -0.16339415f, -0.09376722f, 0.14419800f, -0.16637592f, -0.21114208f, 0.67604190f, -0.35529628f, 0.38599461f, 
    0.08504158f, -0.10119284f, 0.00852308f, -0.08510569f, -0.02466057f, 0.04857431f, -0.03412449f, 0.27070963f, 
    0.03393761f, -0.23502988f, -0.04894328f, 0.38500309f, 0.15056531f, 0.25148925f, 0.09915085f, 0.14691167f, 
    0.09442133f, 0.05478037f, -0.01351575f, 0.16311371f, -0.22216374f, -0.12974361f, 0.28307146f, 0.12840046f, 
    -0.09681774f, -0.07124745f, -0.24710467f, -0.01627842f, -0.07070865f, 0.00819795f, -0.20411617f, 0.02385649f, 
    -0.57736742f, -0.11500236f, -0.18199520f, -0.04649240f, -0.25422761f, 0.24656707f, -0.07884123f, -0.26598436f, 
    -0.08038171f, 0.30344117f, -0.06934700f, 0.08305574f, -0.21518567f, -0.08547857f, -0.21084349f, 0.24254687f, 
    -0.00182377f, 0.02903057f, 0.06464428f, -0.02414136f, 0.05945610f, -0.02859011f, -0.01090312f, -0.09066736f, 
    -0.41313609f, -0.09995462f, -0.05959502f, 0.02863057f, -0.15083523f, 0.04955048f, -0.09281716f, 0.01163421f, 
    0.03617611f, -0.03998658f, -0.00416477f, 0.09284903f, -0.55281717f, 1.09024286f, -0.56391072f, 0.43857619f, 
    0.27742916f, -0.14594381f, 0.19469868f, -0.30248317f, -0.16836566f, -0.13848099f, -0.05506398f, -0.06816705f, 
    -0.17528643f, 0.01704216f, 0.04742203f, 0.17185971f, 0.10245491f, -0.00061471f, -0.17986391f, -0.12947515f, 
    -0.02267576f, 0.02786087f, -0.00430645f, -0.18916425f, -0.06144471f, -0.23475315f, -0.17102227f, 0.08117507f, 
    0.02071397f, -0.00386163f, -0.08908574f, -0.00039450f, 0.01686274f, 0.11636949f, 0.06725775f, -0.08270752f, 
    0.01751146f, 0.18232389f, -0.13946618f, 0.05454952f, 0.13354988f, -0.13474475f, 0.12807138f, -0.21316762f, 
    0.09381577f, 0.03415075f, -0.03077685f, 0.18904948f, 0.21903309f, 0.04582502f, 0.12090296f, 0.03494287f, 
    -0.00955551f, -0.03473305f, -0.07911300f, 0.00717831f, 0.05832025f, -0.22560564f, 0.07004903f, -0.19044206f, 
    -0.28864619f, -0.35735419f, -0.11337262f, 0.01669330f, -0.21043146f, -0.04211174f, -0.12632759f, -0.01624031f, 
    -0.14067955f, 0.12238339f, -0.00381423f, -0.03458045f, -0.16992989f, 0.08992948f, -0.05601417f, 0.06133825f, 
    -0.07136422f, -0.01982365f, 0.04109150f, 0.14658323f, 0.10805093f, -0.08617886f, -0.05790997f, 0.15094967f, 
    -0.01542598f, 0.36451149f, -0.06729215f, 0.06069509f, -0.15200451f, -0.15850770f, -0.02110197f, 0.14278445f, 
    0.02145525f, -0.03017191f, -0.11241189f, 0.17577083f, -0.19270799f, -0.14169367f, 0.01847541f, 0.03347811f, 
    0.04077164f, -0.03299958f, 0.08274899f, 0.08982484f, -0.13591480f, -0.13624577f, -0.23995349f, -0.27458242f, 
    0.29305166f, -0.05177555f, 0.12036271f, 0.05186809f, -0.08665868f, -0.00525764f, -0.33325925f, -0.31382310f, 
    -0.18912338f, 0.06091607f, -0.08666747f, -0.20848511f, 0.11520708f, 0.01083287f, 0.11721387f, -0.10250628f, 
    0.01816063f, -0.05234401f, -0.02132693f, -0.07906923f, 0.03396759f, -0.08202156f, -0.07709084f, 0.05109785f, 
    0.06029378f, -0.02463871f, 0.30119783f, 0.16975996f, -0.27935740f, -0.04677781f, -0.14187269f, -0.05011189f, 
    -0.09067362f, 0.05123923f, 0.02733928f, -0.18786521f, 0.02307306f, 0.07437747f, 0.22391815f, 0.08658178f, 
    -0.22569682f, 0.04485155f, -0.12007940f, 0.13336796f, 0.08006873f, -0.04182298f, -0.14704792f, -0.05873225f, 
    -0.11219447f, 0.07385785f, 0.06440683f, 0.26112211f, -0.00290673f, -0.07443060f, 0.17693980f, -0.06721377f, 
    -0.00887162f, -0.03139300f, 0.04837256f, 0.00498142f, 0.03113691f, 0.28949094f, -0.19661200f, 0.17014635f, 
    -0.20099561f, -0.10912205f, 0.04391515f, -0.25282493f, -0.29696053f, -0.07386131f, -0.01461485f, -0.13933589f, 
    0.12526053f, 0.11406605f, 0.15330079f, 0.16869749f, -0.02736273f, -0.10572326f, 0.00901680f, -0.23410966f, 
    -0.07116227f, -0.05485520f, 0.08348689f, -0.09248968f, 0.26251236f, -0.41905528f, -0.21805713f, 0.17993039f, 
    0.01785452f, -0.11756148f, -0.11126285f, -0.10941347f, 0.22271807f, 0.30740350f, 0.09465129f, 0.22231716f, 
    -0.06210426f, 0.01711642f, -0.00626937f, 0.04979573f, 0.07933968f, 0.07606877f, 0.03532153f, 0.08812079f, 
    0.12872119f, 0.01738263f, 0.06228741f, 0.18578203f, 0.04877196f, -0.12476653f, -0.02295727f, 0.08029164f, 
    -0.11381107f, -0.17149617f, -0.03728214f, -0.09956126f, 0.00753381f, 0.03976232f, 0.05160724f, 0.17161307f, 
    0.30604500f, 0.30860278f, 0.05776307f, 0.10895196f, 0.11067948f, -0.09917477f, -0.12798816f, -0.18910380f, 
    0.19166486f, -0.05588172f, 0.15695778f, -0.04552323f, 0.22985178f, -0.57219577f, 0.03561513f, 0.00430642f, 
    -0.05333481f, 0.13767244f, -0.05061408f, 0.01158279f, 0.10069057f, 0.02933377f, -0.12676941f, -0.16214019f, 
    -0.04598894f, -0.26236412f, -0.15845160f, -0.14691116f, 0.08392155f, 0.05925380f, 0.00664113f, 0.00376452f, 
    -0.08050576f, -0.16814794f, -0.16372785f, -0.08795922f, -0.18334275f, 0.39809126f, -0.01722481f, 0.02576072f, 
    -0.00680923f, -0.12672907f, 0.02743632f, -0.07731822f, -0.16879508f, -0.19664170f, 0.04776159f, 0.03211963f, 
    0.22369568f, 0.28679568f, 0.15058570f, 0.28786680f, -0.06707437f, -0.03645634f, 0.12435291f, 0.14030844f, 
    0.25209936f, 0.10953212f, 0.07421689f, 0.27676579f, -0.22887626f, 0.02212535f, -0.09881820f, 0.01966534f, 
    -0.13459884f, -0.16312660f, -0.14195712f, -0.04793033f, -0.02608944f, -0.40242535f, -0.08673117f, -0.17038529f, 
    0.35942757f, -0.18767427f, -0.11369311f, -0.05465110f, 0.04409027f, 0.03435431f, 0.05266664f, 0.00346141f, 
    0.16779107f, 0.00452432f, 0.01302606f, 0.00649410f, 0.02245686f, -0.37528935f, 0.51634932f, 0.41504246f, 
    0.02873006f, -0.15146481f, -0.24875131f, -0.06562353f, -0.12010629f, 0.00136438f, -0.04660250f, 0.16463253f, 
    0.12112285f, 0.30071580f, 0.25886554f, 0.18742278f, -0.02180257f, 0.05482913f, 0.15782990f, 0.18418382f, 
    0.08556087f, 0.00257767f, -0.00181835f, -0.13139170f, 0.03783992f, 0.32884920f, 0.17019819f, 0.27781257f, 
    -0.09305123f, -0.18447037f, 0.23731461f, -0.05820499f, 0.01181550f, 0.00347290f, 0.03287145f, -0.13316764f, 
    0.42144072f, -0.23980014f, -0.16097395f, 0.13189897f, 0.11781844f, 0.00319107f, -0.05870719f, 0.09763920f, 
    0.11464559f, 0.00407255f, -0.05157626f, 0.06316727f, -0.10870846f, 0.04523462f, 0.19364354f, 0.14955381f, 
    -0.27473554f, -0.06155053f, -0.03319989f, 0.22430626f, 0.02569683f, 0.00069696f, -0.03357770f, 0.13787635f, 
    -0.28497684f, -0.10558250f, -0.60246593f, -0.09451342f, -0.02731989f, -0.23060788f, -0.04176266f, 0.12902966f, 
    0.05484803f, 0.08511363f, -0.15234339f, 0.02629244f, -0.12110833f, -0.35615900f, -0.10292520f, -0.41120493f, 
    0.19719462f, 0.23471309f, -0.04349301f, -0.01597624f, 0.01348253f, -0.02917425f, 0.06818890f, -0.16633461f, 
    -0.03192932f, 0.42257845f, 0.08225437f, -0.27836233f, -0.08872015f, 0.07933993f, 0.18288340f, 0.12241194f, 
    -0.00945454f, -0.08187169f, 0.05668334f, 0.03860740f, 0.38644820f, -0.01816602f, -0.42396885f, 0.34715804f, 
    0.11335453f, 0.02514042f, -0.02095471f, 0.13958099f, 0.11537912f, -0.31972319f, 0.04873633f, -0.13078454f, 
    0.02207634f, -0.04537329f, -0.26733828f, -0.22766382f, 0.01161114f, 0.19428109f, 0.06766298f, 0.10350185f, 
    -0.16452256f, -0.22033803f, -0.42061600f, -0.54658794f, 0.04461773f, 0.01211904f, -0.23468363f, 0.05734180f, 
    0.06264561f, -0.05509751f, 0.04578233f, -0.13703622f, 0.13478655f, -0.09098697f, 0.00874127f, 0.21503204f, 
    -0.17803071f, -0.03282441f, 0.34640372f, 0.00354402f, -0.17694099f, -0.00956752f, 0.06052277f, 0.10368606f, 
    -0.04041101f, -0.20071705f, -0.03385978f, 0.17403154f, -0.31694272f, -0.31937379f, -0.08571979f, -0.16832159f, 
    -0.01184944f, -0.07593477f, 0.07288536f, 0.20580149f, 0.14340925f, -0.24417880f, 0.07323132f, -0.22270925f, 
    -0.88085812f, -0.62230390f, -0.05834858f, -0.22901207f, -0.00450147f, 0.02189809f, 0.00029175f, 0.02823532f, 
    0.05462162f, -0.07837132f, 0.11404445f, -0.04279032f, 0.10386536f, 0.13752554f, -0.33119515f, 0.06072789f, 
    -0.01303700f, -0.03705586f, -0.21266790f, 0.07695067f, -0.05596120f, -0.05585659f, -0.23072842f, -0.02404966f, 
    0.45634040f, -0.20461543f, 0.38987172f, -0.15860739f, -0.16511844f, 0.12684736f, 0.11356728f, 0.45225993f, 
    -0.01235731f, -0.16612764f, 0.08797011f, 0.16900954f, 0.06476107f, 0.03930686f, 0.17084803f, -0.22149277f, 
    0.03291753f, 0.15071583f, -0.11864620f, -0.35055411f, 0.06160140f, -0.03184041f, 0.15411621f, -0.07678685f, 
    0.33440578f, 0.27050081f, 0.17909878f, 0.06994923f, 0.51967716f, -0.10059719f, 0.32688066f, -0.29839265f, 
    0.11419690f, -0.03145149f, 0.02451054f, 0.08512917f, -0.07413390f, -0.18812865f, 0.20565522f, 0.05191603f, 
    0.05612322f, 0.02285312f, -0.15359370f, 0.03305940f, -0.02871295f, 0.05791884f, 0.09192130f, -0.00165628f, 
    -0.12584835f, 0.23475389f, 0.22623566f, -0.21289246f, 0.25608796f, 0.17295088f, 0.07727859f, 0.17342280f, 
    0.07474279f, -0.01364106f, 0.07518332f, 0.16549960f, -0.32505989f, -0.18621752f, 0.32963783f, -0.09519527f, 
    -0.09841408f, -0.02973643f, -0.03429894f, 0.09659701f, 0.30619338f, -0.02998419f, -0.28479704f, 0.05233356f, 
    -0.03283011f, 0.04681731f, -0.11785390f, -0.18190317f, -0.10751507f, 0.03443541f, -0.01983300f, -0.12151008f, 
    0.21121019f, -0.17120212f, 0.23130490f, -0.06578205f, -0.48667166f, 0.07216259f, 0.26726848f, 0.17978181f, 
    0.01209244f, 0.02163747f, -0.02400124f, -0.03691073f, 0.18755578f, -0.56263441f, -0.01305377f, -0.03482360f, 
    -0.16427478f, -0.08226430f, 0.02475059f, -0.09496550f, 0.02588102f, -0.05272270f, -0.01387753f, -0.04911191f, 
    -0.17344184f, 0.04197380f, -0.23629966f, -0.38916025f, -0.01058075f, -0.07190896f, 0.11218230f, -0.10300430f, 
    -0.10473176f, -0.20961374f, 0.06491782f, 0.22377399f, -0.41409075f, -0.04097111f, 0.11866574f, -0.19000870f, 
    -0.16089679f, -0.05744456f, -0.18971246f, -0.12976152f, 0.14741848f, 0.03251360f, -0.13838734f, 0.01910941f, 
    -0.02913033f, -0.22970560f, 0.20413896f, -0.09441477f, -0.15982586f, -0.03746893f, 0.08954970f, 0.13268197f, 
    -0.09549027f, -0.00348219f, -0.07557804f, -0.10436116f, 0.05011780f, 0.00647008f, 0.09995458f, -0.02725734f, 
    -0.07103815f, -0.24419349f, 0.15940180f, 0.08172518f, -0.00025548f, -0.02484884f, -0.06315591f, -0.04280744f, 
    0.23243980f, -0.04620562f, 0.27245724f, 0.07311387f, -0.39713055f, -0.37003180f, -0.53298742f, -0.41518191f, 
    0.05274419f, 0.07982165f, -0.11853707f, 0.03666425f, 0.19886816f, 0.07025417f, -0.15621428f, 0.05084784f, 
    -0.06930763f, 0.14165586f, 0.16131535f, -0.05634999f, 0.09391905f, 0.05021612f, -0.02296994f, -0.30488053f, 
    0.07801973f, -0.25916401f, -0.19917816f, -0.23023623f, -0.07068392f, -0.07658539f, -0.06001242f, 0.13739260f, 
    0.06329370f, -0.00932274f, 0.07082871f, 0.18960474f, 0.16401576f, 0.04046594f, 0.04629453f, 0.26936206f, 
    0.12063957f, -0.14808609f, -0.35658574f, 0.25329039f, 0.14145668f, -0.05076608f, 0.01608812f, -0.00817123f, 
    0.02523723f, 0.03338361f, -0.01037203f, 0.07203124f, 0.26849639f, -0.33290124f, 0.47540948f, -0.14070262f, 
    0.01953291f, 0.14803712f, 0.05600717f, 0.12141834f, 0.11106129f, -0.00168879f, -0.04569934f, -0.04015071f, 
    0.00383991f, 0.07039668f, 0.03826442f, -0.11248946f, 0.25481200f, 0.11183761f, -0.03145086f, 0.02312703f, 
    -0.03991655f, 0.00711751f, 0.09925009f, 0.02772384f, -0.24520011f, -0.15007588f, -0.33201343f, 0.11929122f, 
    0.11416273f, -0.03433977f, -0.00077285f, -0.03555457f, 0.02173091f, -0.06477305f, 0.00958664f, 0.04371543f, 
    0.10540558f, -0.17035452f, -0.06639406f, -0.10724834f, -0.02708196f, 0.10654242f, -0.11308719f, 0.13026220f, 
    0.06432425f, -0.23377015f, 0.21452419f, -0.21193184f, 0.06918737f, 0.16783209f, 0.03777813f, -0.20232598f, 
    0.24069941f, -0.04160674f, -0.15875979f, -0.13698697f, 0.04457843f, -0.01284693f, -0.00289349f, 0.03485635f, 
    0.75197309f, -0.05941376f, -0.20325173f, 0.08551782f, 0.14353393f, -0.02960137f, -0.22299057f, 0.04768752f, 
    0.06298587f, 0.18765438f, -0.16109668f, -0.07657931f, -0.22365375f, 0.13995434f, -0.52190870f, -0.44722244f, 
    -0.13631421f, -0.09960771f, 0.10323355f, 0.12848741f, -0.12604488f, 0.05601702f, -0.08869547f, -0.01980749f, 
    -1.08957601f, -1.24099195f, -0.07330018f, 0.22588636f, 0.23258646f, 0.11455131f, -0.23519978f, -0.27245712f, 
    -0.02450473f, -0.01331946f, 0.07427119f, 0.07738256f, 0.45672765f, 0.20144308f, -0.18913928f, -0.35547784f, 
    -0.09183320f, 0.00702799f, 0.23427428f, 0.04692613f, -0.04705925f, 0.29250911f, -0.12197442f, 0.05903076f, 
    0.02354959f, -0.07958386f, 0.11568064f, -0.00865290f, 0.06462139f, 0.04599284f, 0.21642862f, -0.01807049f, 
    0.17427164f, 0.15526682f, 0.30875343f, 0.11605940f, -0.09090876f, 0.03734993f, 0.10649083f, -0.09969021f, 
    -0.18194805f, -0.26173133f, 0.19041334f, 0.00613405f, 0.05928380f, -0.02966916f, -0.06911945f, -0.21677978f, 
    -0.07444238f, 0.20801331f, 0.33521444f, 0.08479553f, 0.02015501f, -0.07191804f, 0.02406127f, 0.20684312f, 
    0.03994280f, 0.10225686f, 0.19480798f, 0.07035963f, 0.02441585f, 0.43724540f, 0.12812291f, 0.08728869f, 
    -0.02387743f, 0.04715020f, 0.01721665f, 0.07043030f, -0.04019448f, 0.00510449f, 0.21139549f, 0.00776510f, 
    -0.46299440f, 0.05258853f, 0.38451082f, 0.33004090f, -0.04621430f, -0.11560849f, -0.21691149f, 0.19954497f, 
    -0.05545292f, 0.13984041f, -0.00735447f, -0.10361255f, -0.11357110f, 0.22885641f, 0.19348799f, -0.34327251f, 
    -0.00706033f, -0.09099118f, 0.13661183f, 0.08508296f, -0.04409335f, 0.13038242f, -0.63051289f, 0.27680159f, 
    -0.19826855f, 0.20977399f, 0.18729059f, -0.01351363f, -0.10120060f, -0.06017558f, 0.05155320f, 0.19506551f, 
    0.14592563f, 0.13130078f, -0.15043738f, -0.09947651f, -0.32315832f, 0.15548442f, 0.30893502f, 0.27511287f, 
    -0.12483135f, -0.05441613f, -0.26064584f, -0.12628865f, -0.04712304f, -0.31155619f, 0.09237494f, -0.00872717f, 
    -0.86560535f, -0.65600175f, 0.03692866f, -0.35523182f, -0.23185299f, -0.21375008f, -0.20272021f, -0.34693187f, 
    -0.04349677f, -0.02664962f, -0.04466716f, -0.02859628f, 0.02379863f, -0.29065990f, -0.66620088f, -0.19474055f, 
    -0.28130779f, 0.17167053f, 0.06621820f, 0.22264890f, -0.03740124f, -0.02561666f, -0.12772787f, 0.08582581f, 
    -0.63515908f, -0.71846294f, -0.87035829f, -0.15611415f, -0.16412659f, -0.26393747f, -0.14826134f, -0.27434582f, 
    -0.07314648f, -0.06561895f, -0.04663496f, -0.09086137f, -0.61450660f, -0.53551733f, 0.18910636f, -0.29241922f, 
    -0.15513884f, -0.13575965f, 0.01595925f, 0.26646602f, -0.11845406f, 0.19960843f, 0.07924566f, 0.12962720f, 
    -0.91683775f, 0.22660907f, 0.31625795f, -0.31404674f, -0.02301394f, -0.06305962f, -0.19954860f, -0.17750847f, 
    -0.13381246f, 0.19011292f, 0.05459073f, -0.07572960f, -0.29799381f, -0.22302735f, 0.12153210f, -0.19738038f, 
    0.02622203f, 0.07514190f, 0.06998041f, 0.02239637f, 0.27374867f, 0.20454381f, 0.10821231f, 0.00790850f, 
    -0.10083649f, -0.04987818f, -0.06059844f, 0.02519412f, 0.10441656f, -0.02361544f, 0.04835583f, -0.01396548f, 
    -0.08506741f, -0.26093283f, -0.06411586f, -0.00458856f, 0.10050652f, 0.05282221f, -0.03177227f, 0.02069986f, 
    -0.17621712f, 0.27211136f, 0.24298234f, -0.07205185f, 0.07408586f, 0.17013948f, 0.06381138f, 0.02826438f, 
    0.30700645f, 0.01054715f, 0.12117643f, -0.01584424f, 0.04137127f, 0.19529758f, 0.24640481f, -0.26830000f, 
    0.22184560f, -0.17347680f, 0.01501159f, 0.12882340f, -0.08727229f, -0.12809137f, 0.07433058f, -0.22048138f, 
    -0.12536241f, -0.21735616f, -0.12063912f, 0.07944601f, -0.11947167f, 0.15605500f, -0.02549486f, 0.09288199f, 
    -0.05272702f, 0.10138464f, 0.07356441f, 0.00480003f, 0.02623192f, -0.01119552f, -0.03712927f, 0.04967188f, 
    0.00017585f, -0.04753844f, 0.04584898f, 0.19853528f, 0.03392212f, 0.26758403f, 0.33766037f, 0.00699611f, 
    0.05200448f, -0.11508240f, 0.01970575f, 0.04098575f, -0.15313038f, -0.01224873f, -0.10710845f, 0.17693715f, 
    -0.59850389f, -0.40030092f, -0.26866215f, -0.29945731f, -0.18881328f, -0.03746905f, -0.11569902f, -0.16161001f, 
    -0.03008377f, -0.08228400f, 0.05731470f, 0.10655838f, 0.43205881f, 0.02696776f, -0.03078232f, 0.86309391f, 
    0.00883429f, -0.21389922f, -0.02201600f, 0.03975328f, -0.00438702f, -0.03608945f, -0.08243369f, 0.01190648f, 
    0.20362708f, 0.12988202f, -0.05769948f, 0.08496507f, 0.04719818f, -0.00036162f, -0.03981572f, 0.00802904f, 
    -0.07698396f, -0.12068896f, 0.05390474f, -0.07505622f, -0.36115524f, -0.48405433f, -0.47162211f, 0.38473597f, 
    0.24453759f, 0.31108588f, 0.16519253f, -0.13828290f, 0.03482508f, -0.00811607f, 0.02952741f, 0.05010919f, 
    -0.04996622f, -0.47680274f, -0.30139121f, -0.17630391f, -0.04069021f, -0.06202240f, -0.05175412f, -0.38616028f, 
    0.02814366f, -0.06358095f, -0.06483103f, -0.02758374f, 0.10516162f, -0.60983622f, -0.27452689f, 0.08146635f, 
    0.08704256f, 0.17042738f, 0.25114638f, -0.10902814f, -0.04762693f, -0.03883537f, -0.04808463f, 0.11262713f, 
    0.30910695f, -0.02786576f, 0.01067392f, -0.04738810f, 0.10144667f, 0.08392432f, 0.12860078f, 0.00396434f, 
    0.12984955f, 0.20123701f, 0.20966099f, -0.13453512f, -0.65587395f, -0.63588458f, -0.60082597f, -0.14740102f, 
    -0.24595824f, -0.11815435f, -0.06049631f, -0.42352942f, -0.04105975f, 0.05171268f, -0.04726465f, 0.03517229f, 
    0.77193427f, -0.13575208f, -0.32094276f, 0.27457821f, 0.10902553f, -0.12057269f, 0.34389281f, 0.01521498f, 
    0.13662617f, 0.04473467f, -0.06602203f, -0.14964929f, -0.46320012f, -0.03264630f, -0.03697294f, 0.26856741f, 
    0.23116827f, 0.18529268f, -0.03119397f, -0.03698616f, 0.06437436f, 0.15089744f, -0.07910586f, 0.03843903f, 
    -0.89252770f, 0.50750381f, 0.53631884f, 0.01144841f, 0.01987727f, -0.11598588f, 0.15221959f, 0.10320561f, 
    0.00521262f, -0.13447237f, 0.01770111f, 0.00463063f, -0.17014185f, 0.26717001f, -0.08198220f, 0.16471460f, 
    0.01093735f, 0.07143597f, -0.04309427f, -0.01177575f, -0.04460899f, -0.00129619f, -0.03224281f, 0.05626069f, 
    0.05840763f, 0.18350442f, 0.03208559f, -0.01410641f, 0.00857144f, -0.05795749f, 0.07115123f, -0.00697038f, 
    0.05167492f, 0.04854754f, 0.09831281f, 0.09377035f, 0.06718985f, 0.03626101f, -0.01611880f, -0.06944086f, 
    -0.27314624f, 0.10600951f, 0.15374358f, 0.11101808f, 0.03876598f, -0.10858428f, 0.05464620f, 0.08391835f, 
    0.48711014f, -0.37139377f, -0.14992005f, -0.77624667f, 0.03675608f, 0.01771143f, -0.07784745f, -0.02753024f, 
    0.15062305f, 0.10987888f, -0.02842618f, -0.27317894f, 0.63138896f, -0.53384149f, -0.05852623f, -0.27370504f, 
    0.01436223f, -0.02186536f, -0.02502714f, -0.03527152f, 0.26526791f, -0.00434332f, -0.19819832f, 0.03312291f, 
    0.62702060f, -0.20997618f, -0.19270851f, -0.21073933f, -0.03385666f, -0.12129556f, -0.17950588f, 0.02027758f, 
    0.09324034f, 0.07463229f, 0.02284156f, -0.00501981f, 0.09752911f, 0.11545838f, -0.03075875f, -0.06619830f, 
    -0.03269412f, 0.14648055f, 0.02753196f, -0.00462625f, -0.16429569f, -0.04907236f, -0.10047208f, -0.05570356f, 
    -0.33582237f, -0.87401617f, 0.05847958f, -0.08990694f, 0.01301843f, -0.08178272f, 0.15620571f, -0.07286483f, 
    -0.20818877f, -0.04058989f, -0.14530532f, 0.05667170f, -0.32927108f, -0.34346610f, 0.18376929f, 0.18982622f, 
    0.08637411f, 0.05043992f, 0.02562777f, 0.07041538f, -0.07321701f, -0.01229890f, 0.16170619f, 0.00162078f, 
    -0.27413744f, -0.61751300f, 0.06910419f, 0.26092297f, 0.03455591f, -0.00641918f, -0.05088001f, -0.08282889f, 
    -0.02394194f, -0.00212798f, 0.06823596f, -0.02122729f, -0.24241832f, -0.12447102f, -0.08681981f, 0.03148935f, 
    -0.13069858f, -0.14744975f, -0.19043820f, -0.13616732f, 0.02779710f, -0.10959303f, -0.00216981f, -0.04945105f, 
    -0.51785755f, -0.62357229f, -0.03713882f, 0.19666862f, 0.17734040f, -0.14884521f, -0.19848076f, 0.27312639f, 
    0.06082950f, -0.00398616f, -0.06540319f, -0.05378572f, 0.75443882f, -1.08077896f, 0.27578506f, -0.77093589f, 
    -0.21430808f, -0.02009869f, -0.19669671f, 0.10608041f, 0.03000513f, 0.19319223f, 0.09633373f, -0.04908473f, 
    -0.01860665f, -0.67789012f, -0.51363236f, -0.31456622f, -0.11725768f, -0.04727722f, -0.09967985f, -0.02372546f, 
    0.04943744f, 0.07040270f, -0.01186126f, -0.08579196f, 0.16337372f, 0.09434113f, 0.01883044f, -0.14617932f, 
    -0.02286876f, -0.13435347f, -0.03417461f, 0.14729327f, -0.06876779f, 0.14030068f, 0.21017246f, -0.00388644f, 
    0.10583346f, 0.02254838f, 0.08378964f, -0.02815107f, 0.00284905f, -0.05151159f, -0.02420673f, -0.10606677f, 
    0.13263978f, 0.02253464f, 0.10983060f, -0.08035813f, 0.12251379f, -0.05030073f, 0.00387562f, -0.03154254f, 
    -0.10278115f, 0.31769964f, -0.01512167f, -0.02307571f, 0.02213923f, -0.19404165f, -0.14905305f, 0.06145120f, 
    0.03213871f, 0.10874446f, 0.00910325f, -0.11838187f, -0.17357786f, -0.03631996f, 0.02796776f, -0.00123187f, 
    -0.13244848f, 0.01478271f, 0.14592850f, 0.08532148f, 0.46551442f, -0.00967594f, -0.14869468f, -0.36211783f, 
    -0.01809452f, -0.00376904f, 0.02617887f, 0.14211649f, -0.23270968f, 0.14666064f, 0.02283170f, -0.12546784f, 
    0.05540779f, -0.06044596f, -0.06596068f, -0.12736472f, 0.06541434f, 0.05121157f, 0.00481424f, -0.05601383f, 
    0.05309306f, -0.22014879f, -0.29834750f, -0.47259894f, 0.01127700f, 0.03222060f, 0.13795230f, -0.00360572f, 
    -0.09401723f, 0.08787417f, -0.05680046f, 0.03790878f, 0.03539472f, -0.07920738f, 0.01388840f, 0.08426590f, 
    -0.21434076f, -0.37662408f, -0.16210009f, 0.27736649f, 0.17987269f, 0.06105302f, 0.02055221f, 0.02380565f, 
    -0.00605034f, -0.00034229f, -0.00017781f, 0.00389552f, -0.57066065f, -0.49803892f, -0.65715098f, 0.01223883f, 
    0.00791999f, 0.09759676f, 0.15283705f, -0.17780818f, -0.11267738f, -0.26855707f, 0.20208499f, 0.01389995f, 
    -0.16820088f, -0.21637297f, 0.14568633f, -0.08837709f, 0.06345106f, 0.08546190f, -0.00641693f, -0.12555371f, 
    0.06886431f, 0.03398683f, 0.05394640f, 0.00638212f, 0.04923875f, -0.40885288f, 0.08381581f, -0.26998281f, 
    0.01903704f, 0.10322700f, 0.13139677f, 0.00055541f, 0.02330438f, 0.06640071f, 0.00224231f, 0.03531220f, 
    -0.34405112f, -0.04843402f, 0.04054591f, 0.14053017f, 0.06802659f, 0.00053197f, 0.17836003f, 0.04118409f, 
    0.01377734f, -0.01375651f, 0.10144256f, -0.02901576f, -0.52904212f, 0.19157407f, 0.01795551f, -0.02078143f, 
    -0.00317500f, -0.02797617f, -0.14718160f, 0.13882416f, 0.10983712f, 0.03724919f, 0.06477305f, -0.02248091f, 
    0.06239218f, -0.13730216f, 0.23612855f, -0.23631690f, 0.03075655f, -0.00083323f, 0.04310013f, -0.00966496f, 
    0.08784151f, 0.03451544f, 0.09919228f, 0.05687419f, -0.44504774f, -0.47959831f, -0.07341490f, -0.29520771f, 
    0.04549902f, -0.01719849f, 0.05666241f, 0.38942960f, -0.03870527f, -0.04615980f, -0.12282861f, -0.04072056f, 
    0.00962733f, 0.00454652f, 0.23327731f, -0.14901893f, 0.06496214f, 0.22213563f, -0.12557121f, -0.01583128f, 
    0.04680321f, -0.00997640f, 0.00216108f, 0.12608507f, 0.09192358f, 0.17089269f, 0.35826683f, -0.14421350f, 
    0.01913622f, -0.07045007f, 0.16987392f, 0.02491849f, -0.00852628f, 0.02937118f, 0.08627255f, -0.11186562f, 
    0.09149554f, 0.30408421f, -0.22617970f, 0.22748990f, -0.19336794f, -0.05680115f, 0.03090058f, -0.25613254f, 
    0.04434244f, 0.05564900f, 0.11124316f, 0.01463936f, -0.86730200f, 0.15048259f, 0.09218069f, 0.48695785f, 
    -0.10901942f, 0.01373445f, -0.17810720f, -0.08894627f, -0.11506535f, -0.12786831f, 0.06153394f, -0.16157675f, 
    -0.28593430f, -0.01868735f, 0.01902062f, 0.22032459f, 0.00760646f, -0.02034368f, -0.08577103f, -0.04102682f, 
    -0.19552231f, 0.14000060f, -0.31251884f, -0.45131034f, -0.26826972f, 0.06541155f, -0.07397746f, 0.07238888f, 
    0.08753468f, -0.02082331f, -0.07063042f, -0.00914964f, -0.01169172f, 0.26401880f, 0.16728525f, 0.19541492f, 
    0.26534247f, -0.09368283f, -0.34797287f, -0.18926594f, 0.02689252f, -0.02189519f, 0.01966683f, 0.00157645f, 
    0.16145498f, -0.21409707f, 0.07790217f, -0.07933156f, -0.22839302f, -0.28754953f, -0.15642719f, -0.10838721f, 
    0.03514697f, 0.08270009f, 0.06530508f, 0.03349090f, -0.23481879f, -0.13928634f, -0.14906688f, -0.41863146f, 
    -0.32132453f, -0.24995555f, -0.29196590f, 0.09684044f, 0.01240002f, 0.19036043f, 0.07449602f, 0.14367525f, 
    0.00111618f, 0.07373016f, -0.00757961f, -0.03554138f, -0.36827520f, 0.07452664f, 0.27969521f, 0.30696678f, 
    -0.03356583f, -0.09567868f, 0.00971280f, -0.13395220f, 0.27657485f, 0.04260881f, 0.06271608f, 0.25805923f, 
    0.85898739f, -0.54959363f, -0.61571544f, -0.18200371f, 0.17108172f, -0.05403766f, 0.07918258f, -0.09512066f, 
    -0.01827650f, 0.10246383f, 0.16967419f, 0.01200867f, 0.09080260f, -0.24363048f, 0.03826074f, 0.03675309f, 
    -0.34208837f, 0.02305437f, 0.02395032f, 0.12907231f, -0.12394678f, -0.06832567f, 0.06132828f, -0.07980028f, 
    0.49396563f, 0.19723193f, -0.25300691f, 0.05816775f, 0.12102493f, 0.17917997f, 0.12741780f, 0.01819075f, 
    0.21646672f, 0.13257320f, -0.00811087f, 0.12548983f, 0.33432364f, 0.06270299f, -0.00549429f, 0.00225728f, 
    0.24205704f, -0.01114601f, 0.22250576f, 0.07454306f, 0.13176368f, -0.03062965f, 0.07177390f, -0.08624928f, 
    -0.50775641f, -0.30489999f, -0.29038969f, 0.04913941f, 0.01064135f, 0.15819694f, 0.15639096f, -0.18230025f, 
    0.00364356f, -0.01989911f, -0.01074015f, 0.10988319f, -0.14816141f, -0.51039356f, -0.56935477f, -0.41582426f, 
    0.13603976f, 0.30086255f, 0.32414299f, 0.11584567f, 0.07920799f, 0.15887856f, 0.01930264f, 0.09026065f, 
    -0.73437494f, -0.71375597f, -0.51119417f, -0.14443059f, 0.06479690f, 0.20536235f, 0.18487483f, 0.07598958f, 
    -0.05690956f, 0.05225299f, -0.02789174f, 0.07788158f, 0.15470050f, 0.30748573f, -0.24726714f, -0.32553235f, 
    -0.02761917f, -0.09488595f, 0.11161558f, 0.05778818f, -0.03433245f, 0.12032569f, -0.33058280f, -0.28405821f, 
    -0.15090556f, -0.17213219f, 0.02515473f, -0.37184709f, -0.06579477f, -0.12756076f, -0.09817915f, -0.17028442f, 
    -0.38456780f, -0.21931261f, -0.25939402f, -0.22815098f, 0.06457428f, -0.17193620f, -0.19818138f, 0.03271194f, 
    0.26900795f, 0.26959443f, 0.14251877f, -0.05303117f, -0.05740486f, 0.02711693f, -0.25286782f, -0.55399632f, 
    -0.52011305f, -0.10587601f, 0.07660869f, 0.18081276f, 0.15668243f, 0.12886339f, -0.26222610f, -0.05560310f, 
    -0.07321753f, -0.12941357f, -0.06608871f, -0.02887632f, 0.09426844f, -0.00395569f, -0.15449247f, -0.13322993f, 
    0.01137865f, -0.15894526f, -0.10958005f, -0.01614957f, 0.16547143f, 0.19319040f, 0.13065426f, 0.20945428f, 
    -0.04800840f, -0.01109233f, -0.19833203f, -0.24807739f, 0.02069673f, -0.02418371f, 0.02375538f, -0.10618307f, 
    0.22689761f, 0.19161956f, 0.01997525f, 0.20655435f, -0.29601899f, -0.19428527f, 0.13452773f, 0.27269971f, 
    -0.21428813f, 0.14113450f, -0.02595857f, 0.15096065f, 0.06156237f, -0.05330462f, 0.02716283f, -0.14375697f, 
    -0.01472330f, -0.50686216f, -0.17878351f, -0.53551996f, 0.01958071f, -0.01487872f, 0.16139808f, 0.15178029f, 
    0.00980712f, -0.23557137f, -0.07062270f, -0.24688421f, -0.13407175f, 0.08262125f, -0.07094136f, 0.36174536f, 
    0.10981881f, 0.09499598f, 0.26489529f, 0.06694206f, -0.26452014f, 0.13586962f, 0.05509599f, 0.20803541f, 
    -0.07580545f, 0.25875658f, 0.11735544f, 0.05929387f, -0.02358397f, -0.05602786f, -0.06909353f, -0.00370163f, 
    -0.09748507f, 0.04196804f, -0.00320396f, 0.04156834f, 0.59874517f, 0.23468170f, -0.06312336f, -0.29236749f, 
    -0.17344564f, -0.16118123f, -0.03308054f, -0.47374558f, -0.02512743f, 0.14399922f, 0.02527256f, -0.00469078f, 
    -0.02077908f, -0.00301338f, 0.02080730f, -0.02094153f, -0.01430416f, -0.02779172f, -0.03543139f, 0.09433779f, 
    0.06410750f, 0.14694662f, -0.07355305f, -0.00462926f, 0.12421601f, -0.01405784f, 0.04603500f, 0.12573658f, 
    -0.09694600f, -0.04731734f, 0.07785895f, -0.04465733f, -0.02749871f, 0.11723009f, 0.02813231f, 0.01325472f, 
    -0.24060392f, 0.21058366f, -0.06551781f, -0.02490142f, 0.02516490f, -0.06996363f, -0.06079502f, 0.00858516f, 
    -0.18052121f, -0.02007046f, -0.23196113f, -0.29615587f, 0.33893323f, -0.48655719f, -0.86714393f, -0.45479107f, 
    -0.14856841f, -0.17961849f, 0.17296894f, -0.14007461f, -0.00250058f, -0.04465915f, 0.01040371f, -0.00119161f, 
    -0.57561219f, 0.14795555f, 0.13342309f, 0.38552848f, 0.26934043f, -0.12781444f, -0.08899247f, 0.04168778f, 
    -0.00273604f, -0.07617617f, 0.14431235f, 0.11386579f, -0.17673637f, 0.00516220f, -0.01187180f, -0.01065265f, 
    -0.28596714f, -0.04528198f, -0.00262736f, 0.00196529f, -0.10021824f, -0.12282344f, 0.01625075f, 0.24826723f, 
    0.00473941f, -0.31986472f, 0.04475696f, -0.68486667f, -0.07445557f, -0.21408845f, 0.07557421f, 0.13479601f, 
    0.05513336f, 0.08982841f, 0.01901048f, -0.15233555f, -0.25506601f, 0.43397313f, -0.15488799f, 0.11438263f, 
    0.14295913f, -0.12422423f, 0.04254693f, 0.07897434f, 0.04993700f, 0.19505717f, 0.04686696f, -0.12361144f, 
    0.12266100f, -0.11686122f, 0.14221348f, -0.10953965f, -0.10675833f, 0.04649201f, 0.20329425f, 0.20721421f, 
    0.13762259f, 0.02669021f, 0.18514659f, 0.31875965f, 0.14465035f, 0.00203720f, -0.07018545f, -0.03790857f, 
    0.09560005f, 0.12610683f, 0.02360315f, 0.09506973f, 0.05188703f, 0.09921027f, -0.07401344f, -0.06824515f, 
    0.16168720f, -0.14401445f, 0.37005982f, 0.55665493f, 0.09442038f, -0.06940487f, -0.20182219f, -0.21698599f, 
    0.03188568f, -0.01264652f, -0.04889616f, 0.10279349f, 0.13694589f, 0.00819758f, 0.53682399f, 0.07214551f, 
    -0.06183214f, -0.21906166f, -0.15267441f, -0.35869133f, 0.03139677f, 0.11982243f, -0.05632208f, -0.00154166f, 
    0.39196211f, -0.12844039f, 0.29647589f, -0.00864927f, -0.03238091f, -0.15969896f, -0.12265216f, -0.26128855f, 
    0.03349114f, -0.01235015f, 0.06217353f, 0.15976503f, 0.13459571f, -0.22274184f, -0.10871510f, -0.02048295f, 
    0.19577567f, -0.05285447f, 0.09325883f, -0.01844064f, -0.06082584f, -0.01417715f, -0.13487081f, -0.05464687f, 
    -0.15527695f, 0.13990064f, 0.70069760f, -0.04624467f, 0.04732427f, -0.63393134f, 0.08466176f, -0.16323993f, 
    -0.07754359f, 0.06291784f, -0.00870673f, 0.07046103f, 0.40727121f, -0.11640489f, 0.26632014f, -0.42392096f, 
    -0.18287683f, -0.13099246f, -0.05572059f, 0.01604717f, -0.10359381f, -0.03853573f, -0.05251566f, -0.06910689f, 
    -0.39476624f, -0.33262941f, -0.32755846f, 0.02409077f, 0.19646454f, -0.29578522f, -0.05537961f, 0.13521402f, 
    0.03059391f, -0.08244812f, -0.06842630f, -0.09190159f, -0.29480338f, 0.12308963f, -0.52852917f, 0.20430511f, 
    0.37979013f, -0.29278132f, 0.24189383f, -0.09679979f, -0.08785085f, -0.16694352f, -0.05340484f, -0.02056673f, 
    -0.78426123f, -0.07950591f, 0.24568096f, -0.39071539f, -0.38605618f, -0.14277114f, 0.04148025f, 0.18647793f, 
    0.08960507f, -0.01636157f, 0.07003342f, -0.02848177f, 0.31990555f, -0.29685554f, 0.19912446f, 0.35390323f, 
    -0.06856661f, -0.08177165f, -0.21436945f, -0.08340051f, -0.07766846f, -0.19370580f, -0.05726413f, 0.02463003f, 
    0.18142641f, -0.05281762f, 0.35001886f, -0.23451802f, 0.12686828f, -0.11252839f, -0.14055336f, 0.17173634f, 
    0.08900249f, 0.05733494f, -0.00414508f, 0.00017817f, -0.18695308f, -0.27931789f, -0.12526409f, 0.23743923f, 
    0.04642830f, 0.26415843f, -0.00511944f, 0.08441496f, -0.01524146f, 0.10671028f, 0.19171707f, -0.03292089f, 
    -0.04565807f, -0.11318082f, 0.16731168f, 0.06019826f, -0.02277935f, 0.20086604f, 0.07677033f, 0.04206830f, 
    0.04419982f, 0.05726920f, 0.06316168f, 0.16281909f, -0.11833718f, 0.06860093f, 0.03389772f, -0.08293317f, 
    -0.11926056f, -0.13294037f, -0.29453355f, -0.09444088f, 0.29998213f, 0.14262103f, -0.09810892f, 0.08734310f, 
    0.07814961f, 0.01589108f, -0.36768705f, -0.18983646f, 0.04775782f, 0.01789675f, 0.16738434f, 0.23188318f, 
    -0.17215899f, 0.04124314f, 0.07510484f, -0.02469946f, 0.03782127f, 0.14721264f, 0.03937643f, 0.55215037f, 
    0.02964993f, 0.15866470f, -0.07616369f, 0.17292599f, 0.00623015f, -0.20095204f, 0.02549475f, -0.18681225f, 
    0.07289037f, -0.00969283f, 0.29826134f, 0.00964786f, 0.06776141f, -0.07365029f, -0.08035187f, -0.11890548f, 
    -0.00852258f, 0.12355797f, 0.04380740f, 0.02904175f, 0.30940050f, 0.10023692f, -0.23928253f, -0.13469385f, 
    -0.19301489f, -0.07321741f, -0.13831714f, 0.09848665f, 0.14756919f, 0.05077524f, 0.08427051f, -0.03044571f, 
    -0.10548132f, -0.07943876f, -0.02011381f, 0.07726103f, 0.03566015f, -0.01856107f, 0.02119662f, 0.03962447f, 
    -0.02566864f, 0.04661643f, 0.06689978f, 0.00212763f, -0.31550398f, 0.50346535f, 0.04061508f, -0.86146611f, 
    -0.02891922f, -0.27979565f, 0.24872276f, -0.12874873f, -0.18468824f, 0.14010699f, -0.04350499f, 0.01748786f, 
    -0.16404511f, -0.27169037f, -0.49444118f, 0.07298788f, -0.04562713f, 0.13609913f, 0.23145922f, -0.01732088f, 
    0.02166828f, -0.01674998f, -0.07360803f, 0.04927728f, 0.06222058f, -1.26229036f, 0.23022570f, -0.13124694f, 
    -0.01147522f, 0.15630962f, -0.08509527f, 0.06710951f, -0.13419186f, 0.09272909f, 0.04662506f, 0.01598050f, 
    0.38525477f, 0.02301600f, -0.00380371f, -0.05200446f, -0.02403737f, 0.06708273f, 0.14398199f, 0.24401388f, 
    0.02787804f, 0.07611240f, -0.20655927f, -0.07462165f, 0.13590512f, -0.01592402f, -0.45591632f, 0.02088315f, 
    0.00780772f, 0.24249493f, 0.06103854f, 0.10160142f, 0.00131938f, -0.03162733f, -0.14109059f, -0.09280768f, 
    0.15237176f, -0.29598352f, -0.05533128f, 0.09769554f, -0.04700797f, 0.05054755f, 0.10308959f, -0.07181276f, 
    -0.12276869f, -0.03673875f, -0.05268318f, 0.04438798f, -0.66712707f, -0.12861706f, -0.12519750f, -0.05467315f, 
    -0.19362316f, 0.17295676f, 0.03434644f, 0.34425867f, 0.13598078f, 0.08275404f, 0.04321504f, 0.01842805f, 
    -0.26668149f, -0.08050259f, -0.36622062f, -0.17400116f, -0.31570819f, 0.04472256f, 0.05944018f, -0.22066359f, 
    -0.00088226f, -0.14634505f, -0.00343963f, 0.17269763f, 0.13507362f, -0.56384492f, 0.32673466f, -0.37291211f, 
    0.13980718f, 0.07087804f, -0.17720456f, 0.03321353f, -0.13567989f, 0.10621599f, -0.12523174f, -0.03885853f, 
    0.00203824f, -0.36688864f, 0.52598155f, 0.30987111f, 0.04414270f, 0.06223087f, 0.04958031f, 0.06356746f, 
    0.01358438f, -0.02493114f, 0.10811411f, 0.07625830f, -0.01334551f, -0.08367570f, 0.14164878f, 0.28709623f, 
    -0.00714147f, 0.00204915f, 0.01153762f, -0.08707517f, -0.21168153f, -0.27420858f, -0.03979545f, -0.17040183f, 
    0.10719067f, -0.01257944f, 0.08532926f, 0.09643842f, -0.01718930f, 0.03502914f, 0.03771777f, 0.03843262f, 
    -0.32485950f, -0.28836972f, -0.18940139f, -0.48001945f, 0.04193006f, 0.20539576f, 0.16649438f, 0.02126795f, 
    -0.22307028f, 0.03795649f, 0.13266712f, -0.07385316f, 0.08565431f, 0.04300648f, 0.14531130f, 0.23238410f, 
    -0.52286911f, 0.31526908f, -0.38704768f, 0.04339121f, 0.17977867f, 0.28762153f, -0.15759523f, -0.01714660f, 
    -0.11187774f, -0.04428275f, 0.15934692f, -0.14730778f, -0.01983385f, 0.13363433f, -0.09618282f, -0.29201537f, 
    0.04670486f, -0.06533927f, -0.19727358f, 0.13169724f, -0.11854228f, -0.25167727f, -0.33342606f, -0.44901407f, 
    0.07964592f, 0.18309358f, -0.00571407f, 0.03099410f, 0.09765103f, -0.29026148f, 0.08735052f, -0.04635834f, 
    -0.07823005f, 0.03983404f, -0.04888656f, -0.20892631f, -0.00095907f, 0.16723172f, -0.00721395f, 0.53528857f, 
    -0.04598151f, 0.06459326f, 0.18630280f, -0.10338359f, 0.12772024f, 0.11043260f, 0.17338262f, 0.07974723f, 
    -0.54069346f, 0.27524915f, -0.15102741f, 0.17947058f, -0.19684842f, 0.23028877f, 0.04355455f, 0.19222979f, 
    0.07360411f, -0.28280461f, 0.15476277f, -0.12400462f, -0.36891955f, 0.20823659f, 0.18275814f, 0.18486531f, 
    0.03920673f, -0.00019220f, 0.07656422f, 0.10356742f, -0.14971320f, 0.08975223f, 0.20094825f, -0.01769191f, 
    -0.58496684f, 0.28411007f, 0.35949016f, 0.23326896f, -0.09874335f, 0.06453745f, -0.21811272f, 0.19411364f, 
    -0.12068612f, 0.15761764f, 0.12823744f, 0.01075805f, -0.29816377f, 0.13044131f, 0.03570353f, -0.05482478f, 
    -0.19569363f, 0.31584200f, 0.18569870f, -0.03684971f, -0.14325084f, 0.12234485f, -0.19688886f, 0.05840592f, 
    0.09622951f, -0.75710499f, -0.01807476f, 0.12428258f, -0.14191483f, 0.11274040f, 0.23645559f, 0.02314586f, 
    -0.07176351f, 0.05678786f, 0.14998609f, 0.06628995f, -0.37336153f, 0.47232750f, -0.45620781f, 0.04804603f, 
    -0.01989408f, 0.05403439f, 0.15906295f, 0.03066272f, -0.09703194f, 0.17801182f, 0.07687982f, 0.11920895f, 
    -0.06179865f, -0.17470235f, -0.15761045f, 0.05918054f, -0.01401858f, -0.03717628f, 0.01564561f, -0.10492925f, 
    0.05329718f, -0.11098940f, -0.13831398f, -0.12152023f, 0.25053626f, 0.08126919f, -0.13279179f, -0.05850261f, 
    -0.01642171f, 0.07221203f, -0.03439793f, 0.04394827f, -0.07054540f, -0.37187517f, -0.31018293f, -0.18826711f, 
    -0.07368509f, -0.16412529f, -0.12057216f, -0.35263139f, -0.18571061f, -0.06418408f, -0.08851010f, -0.13768885f, 
    -0.02236980f, -0.23394094f, -0.13217679f, -0.22990791f, -0.04631786f, -0.04492680f, -0.07625983f, -0.16272980f, 
    0.07883225f, 0.22371814f, -0.21393161f, 0.10709420f, -0.08444008f, -0.23108332f, -0.23919657f, -0.20095851f, 
    -0.13951597f, 0.39172092f, 0.41503429f, 0.03214360f, 0.05484587f, -0.01762070f, -0.38042721f, 0.27617070f, 
    -0.40822908f, -0.08670244f, 0.04726036f, -0.26371020f, -0.19649367f, 0.41569152f, -0.18903631f, -0.03762321f, 
    0.06159212f, 0.10079398f, 0.06551035f, -0.14850201f, 0.02876029f, 0.10654204f, 0.01925872f, 0.28473470f, 
    -0.34808284f, 0.06352728f, -0.01812432f, -0.20627601f, -0.13159829f, 0.03237984f, -0.00421964f, -0.04632381f, 
    0.01284210f, -0.07820809f, 0.03639182f, 0.09546894f, 0.25047129f, -0.07502136f, 0.28894582f, 0.21389027f, 
    0.16264315f, -0.19871150f, -0.07168560f, -0.12597963f, -0.18988234f, 0.13305475f, -0.27881137f, -0.03887110f, 
    -0.14021212f, 0.01054646f, -0.36914790f, 0.20035857f, 0.13637383f, 0.08744313f, -0.03209854f, 0.04994986f, 
    0.09367904f, 0.09611506f, -0.04182746f, -0.11199231f, 0.25293431f, 0.05560387f, 0.45575294f, 0.09965324f, 
    -0.15472175f, -0.01326672f, 0.25249994f, 0.04618818f, 0.11512197f, 0.08715207f, 0.09825067f, 0.01534791f, 
    -0.10631261f, 0.02073423f, -0.21205740f, 0.02551328f, -0.20021889f, -0.25064114f, -0.01491541f, -0.06476427f, 
    0.03624672f, 0.15111047f, -0.13318613f, 0.04657736f, -1.08932745f, -0.12835966f, -0.30497837f, -0.00420093f, 
    -0.15716222f, 0.25970832f, 0.01282595f, 0.14207527f, 0.02537019f, -0.08258489f, 0.04502859f, -0.03382587f, 
    -0.27065176f, -0.29569677f, 0.21908914f, -0.17670067f, 0.12426196f, -0.05295856f, 0.15236841f, -0.04517185f, 
    -0.11598892f, 0.04616906f, 0.12541290f, -0.13934524f, -0.28199318f, -0.56852603f, 0.23395355f, -0.00556720f, 
    -0.10618804f, 0.06637509f, 0.00499851f, 0.11878245f, 0.13171293f, 0.08042163f, 0.10232012f, 0.05815146f, 
    -0.00104754f, 0.37970281f, -0.54746604f, 0.11244348f, -0.03133553f, -0.13448492f, 0.03694628f, 0.06869028f, 
    -0.18407810f, -0.12403638f, -0.25569937f, -0.34883970f, -0.09575810f, -0.00341947f, -0.62179047f, -0.04281041f, 
    -0.20700529f, -0.21867378f, -0.42885923f, -0.04955652f, 0.08215903f, 0.10756070f, -0.03669557f, -0.08249337f, 
    -0.04131409f, 0.05226491f, -0.05320174f, 0.15756232f, -0.00434838f, 0.21221884f, 0.22684926f, -0.09955860f, 
    0.08196711f, -0.07760517f, 0.10132392f, -0.09790603f, -0.22294083f, 0.33547068f, 0.09705107f, 0.24061844f, 
    -0.10093023f, -0.02283512f, -0.18904582f, 0.08010071f, 0.10055880f, -0.24451180f, 0.15048295f, 0.22661860f, 
    -0.35555995f, 0.17227808f, -0.17610262f, 0.10666430f, -0.40142885f, 0.28184620f, -0.16138119f, -0.08965810f, 
    0.00486976f, 0.17273527f, -0.04375480f, 0.00998484f, 0.27808493f, -0.23258814f, 0.45072716f, -0.06405979f, 
    0.01586520f, -0.09632225f, 0.16087519f, 0.06289342f, -0.11084068f, 0.02992310f, 0.26418784f, -0.11545051f, 
    -0.04912067f, 0.16384618f, -0.07804036f, 0.15767826f, -0.01628882f, 0.02974303f, 0.06720047f, 0.05558250f, 
    0.14212027f, 0.14175348f, 0.19704732f, 0.12395895f, -0.24231043f, -0.17249128f, 0.20869818f, 0.19546486f, 
    0.07743867f, 0.16361527f, -0.02923930f, 0.00338880f, -0.11240620f, -0.00629280f, -0.09800388f, -0.36743873f, 
    -0.72844374f, -0.09573847f, -0.40746355f, 0.22806206f, 0.00676209f, -0.04864143f, 0.12089246f, -0.10357777f, 
    -0.04667428f, 0.09487835f, 0.28836638f, 0.16462198f, -0.10749148f, -0.18185443f, -0.02697030f, -0.34409013f, 
    -0.09305809f, -0.02964738f, 0.00738035f, -0.06151725f, 0.03960217f, 0.22582029f, 0.05746230f, -0.12289721f, 
    -0.16944249f, 0.21652499f, -0.18537761f, -0.08810898f, 0.10840703f, -0.00118543f, 0.03236739f, -0.00790268f, 
    -0.13110788f, -0.06244599f, -0.02186844f, -0.08842163f, 0.04799457f, -0.07331256f, 0.20327693f, 0.19330984f, 
    -0.05210888f, -0.14359300f, -0.06512070f, 0.15295456f, -0.17009994f, 0.15211982f, 0.06789757f, -0.17007808f, 
    -0.47961390f, -0.11096865f, -0.11957987f, 0.14867619f, 0.40636280f, -0.12765984f, -0.02598237f, -0.07056212f, 
    0.12811346f, 0.02720793f, 0.08473737f, -0.25979698f, -0.03061686f, 0.05517496f, -0.00248383f, 0.40104374f, 
    -0.19550611f, -0.01994509f, -0.12746617f, -0.06859332f, -0.11955880f, 0.02960627f, -0.27122706f, 0.03123096f, 
    0.21845473f, -0.39656883f, -0.04605843f, 0.27194557f, -0.05560942f, 0.13449460f, -0.16980577f, -0.01897383f, 
    0.10885108f, 0.09030980f, -0.02589081f, -0.14877038f, 1.00112307f, -0.03489477f, 0.45412171f, -0.35011348f, 
    0.11192540f, -0.09523752f, -0.16013713f, 0.31995809f, -0.12362359f, 0.10955364f, 0.04215818f, -0.10060945f, 
    -0.16693552f, 0.00669986f, 0.01702794f, -0.11399302f, -0.26025683f, -0.24824879f, -0.11244554f, -0.21456255f, 
    0.01021561f, -0.00141070f, -0.14984252f, -0.15389921f, -0.70169711f, 0.20114426f, -0.72697407f, 0.46126840f, 
    0.07712670f, -0.23486519f, 0.00082066f, 0.03025329f, 0.13970393f, 0.00238449f, 0.10125529f, 0.07497390f, 
    -0.40199810f, -0.36784345f, -0.28377411f, -0.10874391f, -0.00713311f, -0.17794031f, -0.10748011f, -0.00999208f, 
    -0.02896343f, 0.09113566f, 0.05817783f, 0.07997064f, -0.44317597f, 0.01517672f, -0.04070061f, 0.03358711f, 
    0.10852858f, 0.05957736f, 0.01502601f, -0.00897696f, 0.00433871f, 0.27939066f, 0.23274128f, 0.09676790f, 
    -0.03333060f, 0.12475944f, -0.31213135f, -0.18433288f, -0.06083959f, 0.15368283f, 0.10433845f, 0.11561244f, 
    0.20439047f, 0.13716243f, 0.02071035f, 0.02792385f, 0.19267561f, -0.02020594f, -0.23477826f, -0.08557493f, 
    0.07148696f, -0.14767040f, 0.38748068f, 0.22388200f, 0.16265425f, 0.12929562f, 0.21765339f, -0.04983170f, 
    0.08036113f, -0.10304767f, 0.19299972f, 0.16356207f, -0.03483699f, -0.11336807f, -0.12369841f, 0.22406617f, 
    -0.00022296f, -0.05964248f, -0.16480349f, -0.07794546f, -0.26841527f, -0.20538534f, -0.39750212f, 0.24903783f, 
    0.17896044f, 0.00016347f, -0.06045596f, -0.05882880f, -0.04987950f, -0.11408555f, 0.06205200f, -0.08322503f, 
    -0.01324285f, 0.04374783f, -0.17120193f, 0.08642840f, -0.03693553f, 0.08043486f, 0.04695417f, 0.10215447f, 
    -0.01251613f, -0.00214681f, 0.00436275f, -0.07370303f, -0.51361370f, 0.42946362f, -0.23757029f, 0.21598808f, 
    -0.06602807f, -0.02636498f, 0.18207489f, -0.05474598f, -0.13805737f, -0.03262256f, 0.02966413f, 0.14798386f, 
    -0.26214084f, -0.31318671f, -0.09393717f, -0.12194552f, -0.02468973f, -0.17760061f, -0.14000316f, -0.09206266f, 
    -0.03813998f, 0.04118062f, 0.05114608f, 0.10425886f, 0.18830098f, -0.40934041f, 0.60674131f, -0.70460862f, 
    0.05912191f, -0.04991442f, -0.05511067f, 0.24983720f, -0.09604321f, 0.04887105f, 0.03647034f, -0.20799048f, 
    0.29884398f, -0.16176334f, 0.23755236f, 0.06923642f, -0.14145032f, -0.00214587f, 0.09662290f, 0.03131237f, 
    -0.04742376f, -0.05995453f, 0.02761455f, 0.01278288f, -0.30405515f, 0.33728394f, -0.33703899f, -0.07783236f, 
    -0.02901500f, -0.30102324f, 0.11450945f, -0.06954546f, 0.00938823f, -0.04096820f, -0.13024102f, 0.04726485f, 
    0.07711864f, 0.25600031f, 0.19962874f, 0.13167611f, -0.26934880f, -0.09594890f, -0.12716135f, -0.28794715f, 
    -0.05158152f, -0.04265570f, 0.05007773f, -0.04153319f, 0.58445728f, 0.35941797f, 0.55038160f, -0.16440625f, 
    -0.14307490f, -0.08545438f, -0.07691975f, -0.04687885f, -0.17851859f, 0.07258610f, -0.06140099f, 0.08866341f, 
    0.11640378f, -0.04677702f, 0.21139129f, 0.56229872f, -0.03220462f, -0.08183810f, 0.19005312f, -0.03339836f, 
    -0.06501905f, 0.04588525f, 0.04802279f, 0.24189253f, 0.20220698f, -0.28407022f, -0.02674416f, -0.12892225f, 
    -0.09313215f, -0.21613544f, 0.01342470f, -0.00005001f, 0.07460921f, -0.01290225f, -0.02881332f, -0.06837521f, 
    -0.10262045f, -0.18699069f, 0.42656600f, 0.47430807f, 0.13721971f, -0.00764536f, 0.14531365f, 0.01537287f, 
    -0.12121011f, 0.04547619f, -0.15113707f, -0.08248791f, -0.46210912f, 0.37463430f, -0.22463582f, 0.07885835f, 
    -0.01688080f, 0.14382496f, 0.06623114f, 0.04772416f, -0.21012165f, 0.12571949f, -0.04637755f, 0.05369623f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22118756f, 0.13977179f, 0.14222541f, -0.12481619f, -0.11756151f, 0.04185159f, 0.05676562f, -0.11878611f, 
    0.04489313f, 0.01497031f, 0.06445109f, -0.04616660f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
