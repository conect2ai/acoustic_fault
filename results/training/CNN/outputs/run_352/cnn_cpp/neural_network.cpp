#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.47082353f, -0.88770729f, -0.67330199f, -0.29656219f, 0.21655557f, -0.37117800f, 0.55309838f, 0.41016638f, 
    -0.36639193f, 0.30715054f, -0.25323653f, -0.14901653f, -0.16165772f, -0.13684429f, -0.01359341f, -0.30200601f, 
    -0.21714805f, -0.11774894f, -0.06235778f, -0.11569400f, 0.04250474f, 0.05837157f, 0.08391432f, 0.09707064f, 
    -0.09604171f, 0.97123033f, 0.70866704f, 0.01624215f, 0.40013391f, 0.70902377f, 0.60586214f, -0.28858057f, 
    -0.59458560f, 0.01491721f, -0.17630859f, 0.00245165f, 0.20254418f, -0.20004559f, 0.20735483f, -0.01216280f, 
    0.03552853f, -0.09596476f, 0.25759792f, 0.23297106f, -0.00205631f, 0.14867014f, 0.07346082f, -0.16899607f, 
    -0.25560230f, 0.13546325f, 0.74889028f, 0.70834994f, 0.73758721f, 0.74222147f, 0.57352793f, 0.08163707f, 
    0.24108511f, 0.15694250f, -0.28895491f, 0.39346588f, 0.13910119f, -0.19269532f, -0.00901952f, 0.04413918f, 
    -0.18840685f, 0.09692802f, -0.00752003f, -0.09200787f, -0.02883754f, -0.29888445f, 0.05858769f, 0.08914717f, 
    0.11502627f, 0.42360166f, -0.21944162f, -0.70887679f, -0.03684277f, -0.59242070f, -0.70927012f, -0.34467801f, 
    0.25490272f, -0.27541745f, 0.16525969f, 0.10380774f, 0.28327224f, 0.09332641f, 0.11378192f, -0.03742321f, 
    0.03414532f, -0.22157395f, 0.21482967f, 0.21493386f, 0.15916298f, 0.10788634f, 0.01887768f, -0.18131810f, 
    0.07048315f, -0.19297685f, -0.04064490f, 0.41849983f, 0.12995604f, -0.68588752f, 0.05925802f, 0.77273059f, 
    -0.22255085f, -0.65013885f, 0.34214777f, 0.16460997f, 0.31827569f, -0.29307163f, -0.09784430f, -0.05364937f, 
    -0.03702487f, -0.25028816f, 0.01164859f, -0.35468784f, -0.20513842f, 0.14676139f, -0.12398630f, -0.33102983f, 
    0.10563605f, -0.24840774f, -0.10785693f, -0.16821320f, 0.05471788f, -0.22025266f, 0.97037053f, -0.24472210f, 
    -0.09685919f, 0.10821528f, -0.21441796f, -0.32760409f, 0.17582159f, -0.19652402f, 0.07535481f, -0.31617677f, 
    -0.23537762f, -0.30845279f, -0.02094264f, -0.54134202f, -0.17461592f, 0.17665762f, -0.10740745f, -0.21403685f, 
    -0.50146383f, -0.22840554f, -0.14096051f, -0.22386767f, -0.32857355f, -0.00156612f, -0.23849221f, -0.29903400f, 
    0.56491297f, 0.81222689f, 0.63522780f, -0.84763783f, 0.09374774f, -0.41957426f, -0.18701211f, -0.10203175f, 
    0.48036233f, 0.20930311f, 0.09109135f, -0.02905132f, 0.01711624f, 0.20713165f, 0.17090528f, -0.00483384f, 
    0.08145884f, 0.13397706f, 0.00467688f, -0.08943474f, -0.12536196f, -0.14697917f, -0.08803080f, 0.73975891f, 
    -0.40786353f, -0.34725419f, -0.33955014f, 0.23291773f, 0.61046875f, 0.65777063f, 0.10181662f, 0.07499155f, 
    0.09510791f, -0.33769694f, 0.56314254f, -0.03842503f, 0.15398161f, 0.36230895f, -0.09734704f, -0.33389211f, 
    -0.02623267f, -0.00869167f, -0.08770812f, 0.08304384f, 0.01606378f, 0.31955609f, 0.09185379f, -0.08528493f, 
    -0.86730009f, -0.36328909f, 0.07839281f, 0.17381135f, -0.57719761f, 0.08940001f, -0.13747278f, -0.32034522f, 
    -0.60677481f, -0.30268896f, 0.14292313f, 0.42961496f, 0.05177192f, 0.28820330f, 0.24264112f, -0.23946461f, 
    -0.19331686f, 0.16184580f, 0.05400277f, 0.03918613f, -0.01411320f, -0.11921661f, 0.23742226f, 0.13905710f, 
    0.27961785f, -0.07852662f, 0.98243707f, 0.55819505f, -0.16774862f, -0.08590209f, -0.84234059f, 0.82689947f, 
    -0.20848095f, -0.48728350f, -0.13208091f, 0.10614552f, 0.08653803f, 0.00930410f, 0.01046290f, 0.10424076f, 
    -0.02092581f, -0.10679840f, 0.20440334f, -0.02175569f, -0.19116229f, 0.22941673f, 0.23362342f, 0.22058274f, 
    0.24707519f, 0.15352933f, 0.13199544f, 0.25564057f, 0.52346545f, 0.00413646f, -0.09428713f, -0.47528371f, 
    -0.77034837f, -0.44739977f, -0.52992141f, -0.31567848f, 0.27655721f, 0.31477553f, 0.03237876f, -0.18956535f, 
    -0.13081820f, -0.19399229f, -0.08852075f, -0.18375361f, 0.08989435f, 0.09892206f, 0.44256678f, 0.05726207f, 
    -0.08416514f, -0.11968429f, 0.10985851f, -0.39299014f, -0.72712052f, -0.48966733f, -0.19485982f, -0.43102428f, 
    -0.45797327f, -0.14919829f, -0.42280486f, -0.22115868f, 0.31924242f, 0.21096459f, 0.46939954f, -0.17909624f, 
    0.01569394f, -0.18310940f, 0.02971675f, 0.18057229f, 0.34325209f, -0.04151737f, 0.11726269f, -0.32927647f, 
    -0.13575669f, 0.25179160f, -0.11615832f, 0.07675348f, 0.30179513f, -0.28033799f, -0.60269344f, -0.60767901f, 
    0.13064833f, 0.24125387f, 0.48746192f, 0.03177194f, 0.20517105f, 0.67276305f, -0.41288552f, 0.22725408f, 
    -0.14202662f, -0.00175122f, -0.01913616f, -0.16554213f, 0.31577224f, 0.18883725f, -0.10615323f, -0.04658553f, 
    -0.11287417f, -0.15956898f, -0.18724163f, -0.08858742f, 0.19288383f, 0.61205530f, -0.00415074f, 0.35363418f, 
    -0.25186461f, 0.27425906f, 0.21819299f, -0.06738733f, -0.63744450f, -0.52181798f, -0.54921210f, -0.10959861f, 
    0.10304702f, 0.17265797f, 0.27375847f, 0.28429794f, -0.16088742f, 0.12525351f, -0.51590818f, -0.04531697f, 
    -0.21234567f, -0.28498572f, 0.16178060f, 0.09700657f, -0.01260179f, -0.06980486f, -0.97150350f, 0.32198936f, 
    0.10979243f, -0.65153259f, -0.37449446f, 0.80841589f, 0.49840140f, 0.10139298f, 0.37010381f, 0.30415717f, 
    0.22805238f, -0.30464369f, 0.16373830f, -0.04875453f, 0.03455582f, -0.04956726f, -0.09268734f, -0.13168332f, 
    0.01269853f, -0.05639714f, -0.08767829f, -0.09310479f, 0.18094510f, 0.18349905f, -0.01845057f, -0.27451047f, 
    -0.52159476f, -0.76873869f, -0.46675706f, 0.22604400f, 0.05214047f, -0.25986090f, -0.26723495f, 0.16042738f, 
    -0.29538727f, -0.50015384f, -0.21472126f, -0.04154973f, -0.11250312f, -0.06167103f, 0.42841747f, -0.14432473f, 
    -0.04105498f, 0.19262519f, 0.13171329f, 0.30773577f, -0.06807006f, 0.20713662f, -0.07358872f, -0.17257969f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18955496f, 0.08416275f, 0.21137750f, 0.06096966f, 0.10084399f, 0.01809074f, 0.05344712f, 0.22917368f, 
    0.22122456f, 0.04413264f, 0.16066466f, 0.16691855f, 0.13359578f, 0.04806177f, -0.03851530f, 0.32342926f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.24218877f, -0.33224371f, -0.06044180f, 0.19665836f, -0.00525373f, 0.09787604f, -0.02584781f, -0.06981485f, 
    0.07569565f, 0.04688757f, 0.04287484f, -0.12185107f, -0.31814817f, 0.22750884f, -0.03195876f, 0.02440221f, 
    0.24022929f, -0.08226726f, -0.04971925f, -0.08935813f, -0.05898079f, 0.00146015f, -0.03235950f, 0.04872559f, 
    0.09226386f, -0.01569950f, -0.14227521f, 0.07183699f, 0.25784209f, 0.07928543f, 0.02421384f, -0.06249593f, 
    0.07567935f, -0.07882942f, -0.08794317f, -0.04151729f, -0.25230819f, -0.09094854f, 0.20962341f, 0.12095479f, 
    -0.08249670f, 0.05175643f, -0.00987376f, 0.08793041f, -0.07093388f, -0.10875362f, 0.08573075f, 0.10985944f, 
    -0.12222183f, -0.01873955f, 0.13243674f, -0.03956692f, 0.01014689f, -0.11630218f, -0.07918399f, 0.15047130f, 
    -0.00115639f, 0.03690774f, 0.04675611f, 0.01557781f, 0.04921032f, -0.26504046f, -0.07526367f, -0.11046951f, 
    0.02421856f, -0.01083864f, -0.09699853f, -0.03978065f, -0.03521901f, 0.10468172f, 0.15815885f, 0.07704400f, 
    -0.15460812f, 0.08112217f, -0.07486018f, -0.10562735f, 0.04584504f, -0.10797653f, -0.07815275f, 0.01968738f, 
    -0.01947127f, 0.04983512f, 0.08323466f, 0.00594731f, 0.08678171f, 0.30379897f, -0.09763328f, 0.21970336f, 
    0.03986873f, 0.03719449f, 0.07408008f, 0.00055191f, 0.06087648f, -0.04113163f, -0.03074168f, -0.00442421f, 
    0.11370859f, -0.10155264f, -0.21391194f, -0.00948108f, -0.05603545f, -0.03495561f, 0.03515013f, -0.07757628f, 
    -0.01963207f, 0.04004880f, 0.11058786f, 0.09926468f, 0.38433531f, -0.07957756f, -0.14222668f, -0.03391737f, 
    0.05652986f, 0.07669286f, -0.01552774f, 0.02390302f, -0.00216542f, -0.05634462f, 0.10913978f, 0.12176353f, 
    0.09062803f, -0.01306430f, -0.03434947f, -0.15605804f, 0.07466673f, -0.00826625f, -0.08356350f, 0.15504727f, 
    0.14561209f, 0.07460774f, 0.03729396f, -0.05763940f, 0.05504152f, -0.03589299f, 0.01041216f, -0.35371181f, 
    -0.01068533f, 0.23340070f, 0.01059591f, -0.08688365f, 0.07351059f, -0.01789988f, 0.02870006f, 0.07199703f, 
    0.06881455f, 0.20269515f, -0.01138045f, 0.13653047f, 0.04407997f, 0.00676203f, -0.03350025f, 0.11768489f, 
    0.08326335f, 0.03265455f, -0.04567041f, -0.06319901f, -0.08663368f, 0.07834956f, -0.22333896f, 0.07631373f, 
    0.23003004f, 0.21738946f, 0.03550497f, 0.05207527f, 0.21753599f, -0.00877696f, -0.02700195f, 0.11194225f, 
    -0.25808308f, 0.08113574f, -0.01905657f, 0.02323882f, -0.01109593f, -0.06387525f, -0.00007277f, 0.01463881f, 
    -0.01267448f, 0.07410937f, 0.02656021f, 0.04674688f, -0.14151105f, -0.16370617f, -0.04496089f, 0.21035308f, 
    0.02063987f, -0.05549419f, -0.07262245f, 0.04208818f, 0.08801951f, -0.04622984f, -0.02835852f, 0.11992959f, 
    -0.04526144f, -0.06847691f, 0.06352498f, -0.12239475f, 0.05127710f, 0.02334309f, 0.00572081f, -0.07508741f, 
    0.01139536f, 0.07990827f, -0.01625712f, -0.20390362f, -0.03746050f, -0.10094463f, 0.06816798f, 0.18439342f, 
    -0.06129918f, 0.07581399f, -0.22732608f, -0.07876085f, 0.02626309f, 0.09461372f, 0.11162647f, 0.17690723f, 
    0.30820709f, 0.03183257f, 0.14379045f, 0.06976818f, 0.09560823f, -0.06072765f, 0.12428452f, -0.06443906f, 
    0.02527687f, -0.07840261f, -0.05807791f, 0.08109792f, -0.15422694f, 0.14314266f, 0.08316009f, 0.00261640f, 
    -0.05316616f, 0.24497047f, -0.00366598f, -0.15006363f, 0.13421488f, 0.05003260f, 0.00144405f, 0.05688098f, 
    -0.05561420f, -0.11491251f, 0.14803986f, -0.07095147f, 0.09855376f, -0.03884318f, -0.03812510f, 0.11233447f, 
    -0.00114356f, 0.00344580f, 0.06962721f, -0.11709315f, -0.08934768f, 0.21547154f, -0.05526600f, 0.09292391f, 
    0.13855369f, -0.05541544f, -0.14193337f, 0.00769078f, -0.02025589f, -0.13172424f, -0.11212604f, -0.10369740f, 
    0.22575301f, -0.04576601f, -0.06024301f, -0.16160782f, 0.05659148f, -0.13690075f, -0.06974258f, -0.04549100f, 
    0.03370032f, -0.04954109f, 0.14722633f, 0.20149638f, 0.19579265f, 0.00131317f, 0.10541679f, 0.00624611f, 
    -0.04045467f, -0.00026197f, -0.02361229f, 0.11496344f, 0.14027144f, 0.05716065f, -0.08757732f, -0.01874963f, 
    0.00165070f, -0.02521568f, -0.09146567f, 0.20480312f, 0.00983963f, 0.07507213f, 0.14543289f, -0.16510479f, 
    -0.03961314f, 0.05666377f, 0.07644273f, 0.04638351f, 0.25376853f, 0.01246916f, -0.25175929f, 0.08946359f, 
    -0.14326562f, -0.06165472f, 0.02133004f, 0.12417005f, 0.08010893f, 0.05403601f, 0.16664277f, 0.01965912f, 
    0.16221116f, 0.01825166f, -0.10660896f, -0.05565546f, -0.02901349f, 0.02470198f, -0.06000772f, -0.00738073f, 
    0.08701537f, 0.03914301f, 0.09684362f, 0.07370871f, -0.03236504f, 0.17167863f, -0.19690220f, -0.14759955f, 
    0.00539680f, -0.10311221f, -0.02031024f, -0.12503447f, 0.04846660f, -0.00779996f, 0.04479393f, 0.13482572f, 
    0.27416715f, 0.06368975f, -0.11880221f, -0.10222699f, -0.05259722f, 0.03959956f, -0.05530336f, -0.06461712f, 
    -0.01146740f, -0.15064891f, 0.09716426f, -0.03815193f, 0.16780758f, 0.04118756f, -0.13759951f, 0.20256490f, 
    -0.09576707f, -0.10434914f, 0.15722896f, -0.12402612f, 0.11265185f, 0.01662288f, -0.05974494f, -0.06070565f, 
    -0.36504039f, -0.27664733f, -0.03905604f, 0.10151554f, -0.18474835f, -0.01332156f, 0.07078601f, -0.14878727f, 
    0.07954803f, -0.09392916f, 0.02642362f, 0.06349510f, 0.02270145f, -0.02606160f, 0.18983187f, -0.13980004f, 
    0.17836982f, -0.04890632f, -0.11222594f, -0.04093985f, 0.04309855f, 0.07724259f, 0.06164080f, -0.01424916f, 
    -0.06562109f, 0.14504556f, -0.12702501f, -0.01609785f, 0.03207210f, -0.01066775f, 0.01486848f, 0.03877448f, 
    0.03949319f, 0.08269139f, -0.04446836f, 0.04706599f, 0.32144761f, -0.38176018f, 0.17821661f, 0.27137911f, 
    0.10890935f, -0.08685085f, -0.00776610f, -0.03465831f, -0.02388738f, 0.03554859f, 0.10297997f, 0.01453954f, 
    0.05782291f, -0.15225205f, 0.01462746f, 0.31112337f, -0.11674023f, -0.04197006f, -0.07945828f, 0.03565748f, 
    -0.02645799f, -0.03114396f, 0.08726307f, 0.03696656f, 0.09626866f, 0.01229114f, -0.01664089f, -0.33314347f, 
    -0.00017660f, -0.03375854f, 0.02706547f, -0.03875741f, 0.19015460f, -0.05196191f, -0.02803926f, 0.02504907f, 
    -0.11040852f, 0.06834051f, -0.16150023f, 0.24577536f, -0.08259988f, 0.02740346f, -0.03427113f, -0.01605985f, 
    0.17087685f, -0.08436271f, -0.06085634f, -0.04049652f, 0.09571292f, 0.07218021f, 0.01649792f, -0.10292684f, 
    0.09816567f, -0.01405305f, -0.01771372f, -0.02126890f, 0.08429660f, -0.06735348f, 0.01853803f, -0.17812428f, 
    0.01727864f, -0.11612590f, -0.18305850f, 0.33101416f, 0.05003903f, 0.03568808f, 0.04389025f, 0.03144561f, 
    -0.05193125f, 0.02298759f, 0.07611983f, 0.08726216f, 0.12999830f, -0.12895617f, 0.03623946f, -0.16233228f, 
    0.02201135f, -0.03303831f, -0.02248496f, -0.00984404f, -0.20993979f, -0.03217370f, 0.17928344f, 0.07671322f, 
    -0.09246581f, 0.01751777f, -0.01234551f, -0.00382135f, 0.01933918f, -0.04581472f, -0.03758691f, 0.18750058f, 
    0.02866657f, -0.05901352f, -0.01436711f, -0.05831246f, -0.17693067f, 0.35452661f, -0.05209431f, -0.06683468f, 
    0.05102402f, 0.05412819f, -0.09367279f, -0.09300296f, -0.01823692f, 0.00430906f, -0.00178798f, 0.07852472f, 
    0.01796851f, 0.14464439f, 0.07552344f, 0.23749325f, -0.05874956f, 0.06593549f, 0.02297880f, 0.02609514f, 
    0.03734726f, 0.02444716f, -0.13332811f, -0.07570407f, -0.01800991f, -0.09636259f, -0.07372850f, 0.00370576f, 
    -0.00409370f, -0.13731690f, 0.08976346f, 0.09465431f, 0.12699328f, -0.01647784f, 0.02698461f, 0.00666647f, 
    0.35791314f, -0.06655760f, 0.03795859f, -0.22143714f, -0.03917633f, 0.04778751f, -0.06746610f, 0.03024367f, 
    -0.05689684f, -0.04475738f, 0.08028194f, 0.10513923f, 0.09710077f, 0.01796331f, 0.14267966f, 0.03713680f, 
    -0.08402923f, 0.00805929f, 0.07242822f, 0.02821922f, 0.08539562f, 0.04148036f, -0.11623579f, -0.10872902f, 
    0.21491069f, 0.14810270f, 0.27612394f, -0.28832951f, 0.03071161f, 0.06255997f, 0.02079856f, 0.03400020f, 
    0.04448306f, 0.02150360f, 0.05129664f, -0.06942516f, -0.03771781f, 0.01742546f, 0.02503539f, 0.02867698f, 
    -0.04427044f, 0.06959067f, 0.03187985f, 0.04578694f, -0.04115866f, -0.04358023f, 0.01923875f, -0.03582441f, 
    -0.30280361f, -0.02533751f, -0.18346576f, -0.23149076f, 0.02249754f, 0.04321650f, -0.02381289f, 0.02059319f, 
    -0.03638801f, -0.01999046f, 0.03283196f, -0.00413373f, -0.15343010f, 0.22217171f, 0.08440303f, -0.05219704f, 
    -0.02320167f, 0.07501647f, 0.01771364f, -0.06853947f, 0.07921302f, 0.00551711f, 0.03864798f, 0.11906371f, 
    0.12405962f, 0.18278128f, 0.10859460f, -0.08674534f, 0.00452101f, 0.10134368f, -0.04039552f, 0.06854396f, 
    0.01443477f, -0.09216110f, 0.08282705f, 0.03891323f, 0.07799581f, -0.13731013f, -0.04869225f, -0.21319088f, 
    -0.04393641f, 0.00048248f, -0.12500925f, 0.09998742f, 0.12548706f, 0.00627277f, 0.04379712f, 0.03325931f, 
    -0.22927114f, 0.05779615f, -0.25061592f, 0.22336221f, 0.14871781f, 0.04204820f, 0.05137384f, -0.01357992f, 
    0.02674765f, 0.00512841f, 0.03245725f, -0.04073591f, 0.00213746f, 0.08186425f, 0.08659513f, 0.06515217f, 
    -0.06266557f, 0.02530500f, 0.00184012f, 0.02455523f, 0.01125038f, 0.07879780f, -0.14333920f, 0.03139361f, 
    0.14617546f, 0.24665540f, 0.08203136f, -0.14076114f, -0.00074764f, -0.03052644f, -0.06864495f, -0.01557085f, 
    0.20509063f, 0.11575861f, 0.09714635f, 0.02468127f, -0.16039330f, -0.01557140f, 0.07694573f, -0.04289275f, 
    -0.04704968f, 0.00890529f, 0.02006049f, 0.00109687f, 0.13769172f, 0.09148300f, -0.07052509f, -0.03753557f, 
    -0.44795257f, 0.00928301f, 0.04384355f, 0.05880193f, 0.15011291f, -0.00731478f, 0.02587011f, -0.09285516f, 
    0.09273411f, 0.11549699f, -0.06839826f, 0.06065097f, -0.11374443f, -0.14914590f, 0.23648407f, 0.16863434f, 
    -0.09749928f, 0.05878137f, -0.14636023f, 0.06522959f, 0.04373962f, -0.03641018f, 0.05228268f, 0.10465615f, 
    0.01940219f, 0.01259157f, 0.12605473f, -0.00587509f, -0.04284065f, -0.07771625f, -0.13162062f, -0.14017829f, 
    -0.00572451f, 0.08629678f, 0.00609645f, 0.19478169f, -0.23543046f, -0.15807998f, -0.17415199f, 0.01997848f, 
    0.07962901f, -0.07834524f, 0.05602305f, 0.15677094f, 0.03577854f, 0.15232667f, 0.03275498f, 0.03032656f, 
    -0.06370012f, -0.00284535f, -0.09320759f, -0.29468453f, 0.10669551f, -0.02100565f, 0.11144953f, 0.02126406f, 
    0.09424410f, 0.04981970f, 0.06813813f, -0.06159257f, 0.05577936f, 0.07625856f, 0.16426419f, 0.02716978f, 
    -0.01993553f, -0.05852588f, -0.00544374f, 0.03597137f, 0.03322974f, -0.05156849f, 0.01693806f, 0.05090699f, 
    0.03465075f, -0.46799910f, -0.01745963f, -0.14131613f, -0.10172080f, 0.02889256f, 0.16082950f, 0.11509614f, 
    0.05711394f, -0.13378522f, -0.00172442f, -0.03180623f, 0.00143097f, -0.06498863f, -0.04684315f, -0.05445670f, 
    0.16395546f, -0.03703034f, 0.07130136f, 0.01447185f, 0.10210828f, -0.00867569f, 0.02863637f, -0.02069787f, 
    0.02776985f, 0.10456812f, 0.03877540f, -0.15894197f, 0.03660575f, 0.02181148f, 0.11712042f, 0.00331566f, 
    0.05711078f, -0.07374389f, 0.01390834f, -0.08606181f, 0.20156129f, -0.29373848f, -0.01624396f, 0.25383314f, 
    -0.02240230f, 0.02891354f, -0.11321161f, -0.01714031f, 0.01309212f, 0.03736068f, 0.06734181f, 0.15144379f, 
    0.16273472f, -0.00120481f, 0.28435963f, 0.18030785f, -0.09175906f, -0.04262525f, 0.07305016f, 0.10275068f, 
    -0.04038107f, 0.01140769f, 0.08812398f, 0.20233420f, -0.12177768f, 0.10617407f, -0.11725666f, -0.11184745f, 
    -0.08402032f, 0.03207593f, 0.00955252f, -0.09459225f, 0.06704392f, -0.01476417f, -0.00196395f, 0.10898161f, 
    0.05785286f, -0.09533681f, 0.05859161f, -0.11146019f, -0.06164877f, 0.03866228f, -0.07434930f, 0.16305031f, 
    -0.00861209f, 0.09095845f, 0.08387339f, -0.03407387f, -0.06113375f, 0.25082502f, -0.12476352f, 0.10673012f, 
    0.13551724f, 0.06886028f, -0.02206076f, 0.08063094f, 0.06390703f, -0.07005254f, -0.04729023f, -0.06875335f, 
    0.03026774f, -0.08067083f, 0.18695115f, 0.06682095f, 0.00175748f, -0.00909549f, -0.00002436f, -0.06696404f, 
    -0.05022008f, -0.02125834f, -0.02223007f, 0.06793599f, 0.24006771f, -0.09779644f, 0.04375385f, -0.09821869f, 
    -0.05688842f, 0.05851571f, -0.09025258f, -0.01616837f, -0.04154980f, 0.04116781f, -0.06701153f, 0.07476172f, 
    -0.05329090f, -0.00546593f, 0.09404121f, -0.07267345f, -0.08622463f, 0.05062852f, -0.02833303f, -0.02252399f, 
    -0.08328968f, -0.10014805f, 0.05451204f, 0.00153664f, -0.19576254f, 0.22901382f, -0.09410200f, 0.00308051f, 
    0.06962433f, -0.10974899f, 0.11315388f, 0.09074974f, 0.09040898f, 0.08090740f, 0.05636132f, 0.09973246f, 
    0.08269074f, -0.06115492f, -0.14152330f, 0.10681430f, 0.02367819f, 0.13218705f, 0.07068976f, 0.09237570f, 
    0.02839146f, 0.16380954f, -0.04584271f, 0.03916714f, -0.07907709f, 0.24537735f, -0.13664533f, 0.06868301f, 
    -0.06228133f, -0.01011919f, -0.13784312f, -0.05578455f, -0.04920077f, -0.00062367f, -0.01212069f, 0.25539818f, 
    0.13138179f, -0.00570669f, 0.04264103f, -0.13881449f, 0.08622266f, 0.06997260f, -0.04921755f, -0.05659088f, 
    -0.06088368f, -0.10454009f, 0.13376962f, 0.00390466f, 0.21796294f, -0.01154013f, 0.10935402f, 0.08913748f, 
    -0.04566532f, 0.02708738f, 0.00778556f, -0.01709768f, 0.10357504f, 0.05463500f, 0.09992535f, -0.04441416f, 
    -0.28542805f, -0.02037774f, -0.05744268f, -0.02635010f, -0.08485015f, -0.06709988f, 0.02762488f, -0.08660999f, 
    -0.02669432f, 0.04999815f, -0.05557084f, -0.02855903f, -0.05464936f, 0.16480896f, 0.03667063f, -0.20470934f, 
    0.10217387f, 0.10661571f, 0.03202097f, 0.01730229f, -0.00786246f, 0.08201789f, 0.08172975f, -0.01367547f, 
    -0.29087445f, 0.15543972f, 0.16620044f, -0.14675666f, 0.15091829f, -0.06748718f, 0.10349238f, -0.08504741f, 
    -0.02875236f, -0.12025273f, 0.12944226f, 0.04398232f, 0.49399427f, 0.39206535f, 0.04015439f, 0.13665158f, 
    0.04545813f, 0.05231117f, 0.03508724f, -0.09210302f, 0.00281315f, -0.08852784f, -0.05407948f, -0.03810298f, 
    0.47272429f, 0.21507628f, 0.02495639f, 0.14027244f, 0.00534873f, -0.01211813f, -0.02386406f, 0.12905145f, 
    -0.07552981f, 0.01127983f, 0.04359861f, -0.11193898f, 0.06289639f, -0.09712875f, 0.05895342f, 0.11996280f, 
    0.09184324f, -0.03089287f, -0.11609842f, 0.03857970f, 0.01332756f, -0.04305826f, 0.03804727f, 0.02697312f, 
    0.10333507f, 0.08817864f, 0.18519299f, -0.20801325f, 0.07178424f, 0.02156597f, -0.10626961f, -0.20294724f, 
    -0.03259686f, 0.07574675f, 0.18022719f, 0.09064187f, 0.16083191f, -0.07978576f, 0.08694207f, 0.06903771f, 
    -0.07472079f, -0.01980791f, 0.06503853f, 0.03693474f, -0.05261334f, 0.22894725f, 0.05431167f, 0.00534915f, 
    -0.00638502f, -0.13450158f, 0.04374764f, 0.07749007f, -0.07780852f, -0.06575127f, 0.04921849f, -0.07783940f, 
    0.08124276f, 0.02709667f, -0.13577510f, 0.00556873f, 0.02987621f, 0.10283097f, -0.07049375f, -0.10119020f, 
    0.02014889f, -0.02864001f, 0.00587062f, -0.07463866f, 0.01723046f, -0.04641608f, 0.01762079f, -0.04138939f, 
    -0.05465571f, 0.00222729f, 0.18766320f, -0.02165825f, -0.07848475f, 0.02337771f, -0.04216028f, 0.07678101f, 
    -0.03401309f, 0.03656438f, 0.00514250f, 0.06031905f, 0.46294495f, 0.03941276f, -0.05098843f, 0.22121987f, 
    0.07461990f, -0.10796435f, 0.09664243f, 0.02625163f, -0.02485195f, -0.06432199f, 0.01682610f, 0.09272341f, 
    -0.05627064f, -0.30566844f, -0.12838300f, -0.02796642f, -0.04614947f, 0.03251510f, 0.07778523f, -0.12615404f, 
    -0.00466907f, -0.08807061f, -0.03679452f, 0.00325659f, -0.14682524f, -0.03094882f, 0.09746447f, 0.01820057f, 
    0.00787267f, 0.04845170f, -0.09767325f, 0.00518573f, -0.02864128f, 0.08693684f, -0.11632834f, -0.03221931f, 
    -0.03343909f, 0.17039977f, 0.02862746f, 0.06774697f, -0.11645359f, -0.05220215f, 0.08742121f, -0.08699068f, 
    0.11108701f, 0.14226972f, -0.00544878f, 0.08698490f, 0.21279955f, -0.13992107f, 0.00621838f, -0.00788168f, 
    -0.12568769f, 0.06734049f, 0.00451265f, -0.00560400f, -0.09793076f, -0.04885351f, 0.05434449f, 0.07625661f, 
    0.01806133f, -0.04770711f, 0.00885361f, 0.10252485f, 0.03021160f, 0.10639618f, 0.04451887f, 0.01911289f, 
    0.02834883f, 0.02513142f, 0.02870002f, 0.06457543f, -0.03650108f, 0.14521375f, 0.01622581f, -0.16859150f, 
    -0.09830721f, 0.08109159f, -0.00936720f, 0.04663029f, 0.08586816f, -0.08127569f, 0.08294918f, -0.12356538f, 
    0.19865760f, -0.01352679f, -0.12596677f, 0.05837909f, -0.05530016f, 0.07877279f, -0.04987482f, -0.01167634f, 
    -0.06552080f, 0.08762752f, -0.00678289f, 0.07682588f, -0.26961109f, 0.34103930f, -0.04727572f, -0.22340959f, 
    0.12167909f, 0.09619191f, 0.15757328f, -0.08502614f, 0.00820042f, 0.09728583f, 0.03938189f, -0.06751407f, 
    -0.11172426f, 0.05059823f, -0.04847626f, -0.31182078f, 0.12988716f, -0.03428669f, 0.01573518f, -0.10252701f, 
    -0.05402572f, 0.02324170f, 0.02087764f, -0.06224112f, -0.06690694f, -0.03086006f, 0.02062698f, 0.22773239f, 
    -0.02441347f, -0.00398675f, -0.02817295f, -0.07387042f, -0.15586060f, -0.04790714f, -0.11492932f, -0.06207746f, 
    0.18326189f, 0.10164414f, 0.28553334f, -0.22075520f, 0.06138915f, 0.03053394f, 0.08646020f, -0.06663169f, 
    0.01512781f, 0.07863759f, 0.03830908f, 0.03392581f, -0.06655753f, -0.02950104f, 0.09019589f, 0.14418198f, 
    0.03662777f, -0.03663886f, -0.03580153f, -0.08052150f, -0.05327073f, 0.22428161f, 0.04106796f, 0.24566635f, 
    0.41557747f, 0.20436257f, -0.09067724f, -0.20105435f, 0.08126296f, 0.02482395f, 0.07404541f, -0.00632163f, 
    -0.05161449f, -0.02635661f, 0.09474061f, 0.03419979f, -0.23900010f, 0.02615779f, 0.01238514f, 0.18910864f, 
    -0.08085834f, 0.02048362f, -0.00801931f, 0.21052356f, 0.09862731f, -0.07839097f, 0.05317304f, -0.01673423f, 
    0.12056859f, 0.12020054f, 0.04094075f, 0.20475672f, -0.04440573f, 0.07285452f, 0.10062545f, -0.00295018f, 
    -0.01810650f, 0.07106090f, 0.13139285f, -0.07146756f, 0.52135277f, -0.29252356f, 0.00236785f, 0.18731834f, 
    0.10478083f, -0.02294291f, 0.01403274f, 0.11612381f, -0.17861558f, 0.00860001f, -0.03855266f, -0.05379139f, 
    0.23549533f, 0.05481195f, -0.00702127f, 0.02832470f, 0.03729084f, -0.06288078f, 0.09804955f, 0.05269708f, 
    -0.04520783f, -0.13258660f, -0.08994410f, 0.00282237f, 0.02788130f, 0.11541338f, -0.04358460f, 0.00297186f, 
    0.09008886f, -0.02644201f, -0.07504076f, -0.08522037f, 0.00052429f, 0.07466663f, -0.16648951f, -0.01235469f, 
    -0.17370269f, 0.03885910f, -0.10680035f, 0.00706327f, -0.03677898f, 0.08048693f, 0.16769738f, 0.02713296f, 
    0.07370691f, 0.04070529f, -0.01025876f, 0.10769183f, 0.03602275f, -0.00149769f, -0.14122146f, 0.19516222f, 
    0.08553597f, 0.11591534f, 0.02410150f, -0.04586799f, -0.05807187f, -0.02767838f, -0.04522776f, -0.02449984f, 
    0.00637032f, -0.14879830f, -0.08425539f, 0.09034913f, -0.15444253f, 0.11681373f, -0.07879954f, -0.00167472f, 
    0.06004379f, -0.01968581f, -0.00589607f, -0.00167075f, 0.03578629f, 0.05846373f, 0.01410560f, 0.14219423f, 
    0.05227703f, 0.06123547f, -0.10758557f, -0.12313290f, -0.07873748f, -0.08746530f, -0.02555272f, 0.08839960f, 
    -0.00482844f, -0.03358239f, 0.04289066f, 0.02335859f, -0.01676927f, -0.08933417f, -0.07832114f, -0.07291205f, 
    -0.07128940f, 0.00144400f, 0.01839171f, -0.05457502f, -0.07956641f, -0.02926338f, -0.02441802f, -0.03556411f, 
    -0.07623555f, -0.03031342f, -0.04412561f, -0.00501925f, -0.04491921f, -0.06116809f, -0.03896532f, 0.00078985f, 
    -0.04870928f, -0.03855001f, -0.08949802f, -0.00591201f, -0.07736512f, -0.02100879f, 0.02909525f, -0.05351242f, 
    -0.01667973f, 0.00876263f, 0.00849043f, -0.02232910f, -0.08128914f, 0.01781038f, -0.03449022f, 0.00289124f, 
    0.04633239f, 0.03887669f, 0.03186051f, -0.03375788f, -0.06434978f, 0.02211450f, -0.06764521f, -0.06808411f, 
    -0.04073960f, -0.02411400f, -0.01592807f, 0.02263006f, -0.05499522f, 0.00128820f, 0.03606993f, -0.06593903f, 
    -0.03675868f, -0.06435194f, -0.01733406f, 0.00837614f, -0.05508841f, 0.03689497f, 0.02435185f, -0.08187268f, 
    -0.05888977f, 0.01500399f, -0.02579316f, -0.06076916f, 0.01743501f, -0.04420364f, -0.06108968f, 0.05251320f, 
    -0.04391635f, -0.05127400f, -0.02292586f, -0.04170545f, -0.07058134f, 0.04469408f, 0.03147225f, 0.03638401f, 
    -0.06209083f, -0.04550576f, -0.01192834f, -0.08119016f, -0.07214719f, 0.04392763f, 0.03741758f, -0.02423885f, 
    -0.00951687f, -0.09010440f, 0.01669694f, -0.02434937f, -0.00605717f, -0.02984508f, -0.05886327f, -0.06963359f, 
    0.01536449f, -0.03247998f, 0.04568332f, -0.06374711f, -0.06602977f, 0.04085300f, -0.02596404f, 0.03140743f, 
    -0.02856379f, -0.00078424f, -0.05426385f, -0.00946038f, 0.02490323f, 0.00677466f, 0.01263820f, -0.08481597f, 
    -0.00088902f, -0.00193158f, 0.04121960f, 0.01882518f, -0.04776253f, -0.01030601f, -0.06433484f, 0.01657889f, 
    -0.07479243f, 0.05014667f, 0.04858845f, -0.07616752f, -0.01051087f, 0.04706514f, -0.07303497f, -0.08308879f, 
    -0.00054117f, -0.05443849f, -0.04754679f, -0.07286603f, 0.00956214f, -0.07285871f, -0.01002858f, -0.01823801f, 
    -0.03876811f, -0.08388883f, -0.02430318f, -0.05208426f, -0.01952164f, 0.03590529f, -0.04635023f, -0.06217710f, 
    0.03762491f, -0.09031037f, -0.05458743f, 0.01261005f, -0.03764807f, 0.03374084f, -0.07634111f, 0.03223295f, 
    -0.00758942f, 0.02658386f, 0.02794974f, 0.00384118f, -0.03092143f, -0.04729566f, -0.05161544f, -0.04223011f, 
    -0.07551994f, 0.02584767f, -0.00261173f, 0.05035958f, -0.03691258f, -0.02524393f, 0.02567477f, -0.00782384f, 
    -0.03677519f, -0.06771106f, 0.04844477f, -0.06815454f, -0.07980952f, -0.00050267f, 0.00713353f, -0.01991516f, 
    0.00438270f, -0.06877102f, 0.03891053f, -0.07749502f, -0.08954863f, 0.00637326f, -0.07006907f, -0.08625473f, 
    -0.01424526f, -0.07816205f, 0.00701064f, -0.02961105f, 0.00371923f, -0.00071859f, -0.06954736f, 0.03341285f, 
    0.03292922f, -0.03844145f, -0.02300354f, -0.05282131f, -0.02080064f, -0.03459243f, 0.04245339f, -0.03199465f, 
    -0.00099883f, 0.03000590f, -0.03334592f, 0.04911744f, -0.07264305f, 0.02713464f, 0.02132439f, -0.03471895f, 
    -0.07342672f, -0.06557618f, 0.05304283f, -0.03919042f, 0.02317547f, 0.05891848f, 0.05506188f, 0.04269272f, 
    0.03118450f, -0.01369584f, -0.06928300f, -0.01656455f, -0.05727057f, 0.06058200f, 0.05971817f, 0.02499747f, 
    -0.04604102f, 0.00963195f, -0.03958749f, 0.05572329f, -0.01281765f, 0.02703555f, -0.04289462f, -0.03211394f, 
    0.04948734f, 0.04241436f, 0.05522209f, 0.02777592f, 0.02329116f, -0.02518741f, -0.06811302f, 0.04212985f, 
    0.02249891f, 0.00974589f, 0.03410069f, -0.04862366f, 0.05697649f, -0.05271863f, -0.05706836f, 0.03586317f, 
    0.06576333f, 0.01918526f, 0.06686634f, -0.05576685f, -0.02223567f, 0.03633006f, -0.00210291f, -0.06534082f, 
    -0.04743575f, 0.00713869f, 0.00519427f, -0.00857653f, -0.03176047f, 0.06813753f, -0.02394947f, -0.01573924f, 
    -0.05788807f, -0.03332946f, -0.01473206f, -0.05760450f, -0.03874890f, -0.05820357f, -0.06171106f, 0.01616688f, 
    -0.07817335f, -0.04530979f, -0.01001824f, -0.06916099f, 0.00074838f, 0.01123288f, -0.02008114f, 0.02085142f, 
    0.04011691f, -0.04942282f, 0.01320290f, 0.03383051f, -0.05565866f, 0.00657666f, 0.01512709f, -0.03500768f, 
    -0.01941442f, -0.03110198f, 0.03700235f, -0.02235843f, 0.00225134f, -0.03634328f, 0.02405424f, 0.07391735f, 
    0.03622074f, 0.06448513f, 0.02662081f, 0.06779420f, -0.00969971f, 0.01522007f, -0.05761813f, 0.04942579f, 
    -0.00398913f, -0.03561657f, -0.04198975f, 0.05501125f, 0.00678527f, -0.02204991f, -0.07204306f, 0.04585962f, 
    -0.02390529f, 0.01358203f, 0.06749720f, -0.01521899f, 0.03123619f, -0.03053943f, -0.04287042f, -0.01086389f, 
    -0.05573738f, -0.01707601f, -0.00622433f, -0.00246571f, 0.01061682f, -0.05948605f, -0.07086442f, -0.07295507f, 
    -0.00730100f, -0.03309473f, 0.04485160f, -0.03341532f, -0.06323533f, -0.06615478f, -0.01356964f, -0.02462025f, 
    -0.02909425f, 0.01859863f, 0.02330127f, -0.07429046f, -0.01057633f, -0.04872471f, -0.06826983f, 0.04001587f, 
    -0.08051497f, -0.03569546f, 0.00429376f, -0.07586250f, -0.04619797f, 0.00860463f, 0.05105920f, -0.00200491f, 
    -0.05900473f, -0.07079478f, -0.05275939f, 0.04057778f, -0.06296659f, 0.04177784f, -0.05919957f, -0.01857575f, 
    0.03486269f, -0.06089409f, -0.03236803f, -0.06660201f, -0.00989095f, -0.05547235f, 0.00147420f, 0.03156956f, 
    0.06685471f, -0.02923181f, -0.01927448f, -0.07270793f, -0.05300851f, -0.01974333f, -0.01454598f, -0.06031766f, 
    -0.01865053f, 0.03666854f, 0.06397898f, 0.04637677f, 0.05609215f, -0.02297582f, -0.04405893f, 0.04348852f, 
    0.44174373f, -0.11592109f, 0.01641595f, 0.15648378f, -0.04066448f, 0.00232903f, -0.09668151f, 0.02504326f, 
    0.02555810f, 0.02818693f, -0.07583481f, -0.14206678f, -0.07240213f, -0.07830314f, 0.05452755f, -0.01270489f, 
    0.18475358f, -0.03022297f, -0.07807270f, -0.05769002f, -0.09421668f, 0.02446992f, 0.11752629f, -0.09932102f, 
    0.24767233f, 0.02652293f, -0.00702170f, 0.17936055f, 0.16861552f, -0.04026271f, 0.13568422f, -0.10251532f, 
    0.03199599f, -0.05752130f, 0.05097129f, 0.00873081f, -0.07611898f, 0.08081234f, 0.24893858f, -0.10469255f, 
    -0.04368034f, 0.11593129f, 0.15068036f, -0.05356346f, 0.08135611f, -0.03215016f, 0.00201323f, 0.01667004f, 
    -0.16976425f, 0.06839925f, -0.12670733f, 0.25499868f, -0.02911221f, -0.01553584f, 0.11747248f, 0.03397006f, 
    0.11808442f, -0.01036149f, -0.05767344f, -0.02522462f, -0.18382888f, -0.09522661f, -0.10768819f, -0.31425628f, 
    0.17972504f, 0.01637638f, -0.06706066f, -0.11739253f, 0.06692182f, -0.05272331f, -0.01508689f, -0.07254766f, 
    0.25824362f, -0.17170392f, -0.16091035f, 0.00652690f, 0.06578875f, -0.09375476f, -0.02386408f, 0.02811973f, 
    0.03547918f, -0.02274997f, 0.06600066f, 0.05407140f, 0.27697060f, 0.03426996f, 0.19844060f, -0.02019191f, 
    -0.11085206f, -0.01724372f, 0.02161433f, -0.00095495f, 0.02936336f, -0.03696833f, -0.01350262f, -0.07342685f, 
    0.00959941f, -0.03391824f, -0.26410505f, 0.21823831f, 0.00643663f, 0.02008818f, -0.02244125f, -0.00954795f, 
    -0.04317659f, 0.06542595f, 0.04889506f, -0.07643416f, 0.37892526f, -0.01702899f, -0.18103115f, -0.22033735f, 
    0.04873905f, 0.20571436f, 0.02826429f, -0.01937713f, 0.04072559f, -0.04600313f, 0.06092099f, 0.02474594f, 
    -0.03678616f, 0.12557831f, -0.02395063f, -0.18692464f, 0.08772818f, -0.05109455f, 0.08280115f, 0.11159003f, 
    0.17298388f, 0.08283481f, 0.12470371f, 0.05791043f, 0.15614679f, -0.04426264f, -0.09836604f, -0.17912312f, 
    0.01241749f, -0.10708053f, 0.07009499f, -0.03088905f, 0.07785795f, -0.06026858f, 0.05467188f, -0.04280680f, 
    0.39775825f, -0.00981338f, 0.12216774f, -0.00043890f, 0.14607905f, 0.04955169f, -0.10830822f, 0.06478790f, 
    -0.06401330f, -0.06485209f, -0.01139779f, -0.02845140f, 0.00904677f, -0.00187771f, -0.21821666f, -0.04811242f, 
    0.10469027f, -0.03605403f, 0.08154128f, -0.06838099f, 0.01156578f, 0.09891576f, -0.10655081f, -0.01702549f, 
    -0.06761228f, -0.02997009f, 0.23011015f, 0.04762312f, 0.09030347f, 0.00313253f, 0.02657036f, -0.05820465f, 
    0.00238271f, 0.10141690f, -0.01345914f, -0.06176308f, -0.16267876f, -0.03805149f, 0.08857983f, 0.02347592f, 
    0.07754991f, 0.03598453f, 0.03021129f, 0.03757067f, 0.07818736f, 0.03071114f, -0.02066701f, 0.16068040f, 
    0.03552655f, 0.04632531f, -0.04553440f, 0.02056758f, -0.05154696f, 0.03001492f, -0.00886938f, -0.01858912f, 
    0.02762501f, -0.08070839f, 0.00093103f, -0.03864526f, -0.03642083f, 0.05019876f, 0.03534305f, 0.05020362f, 
    0.02008171f, -0.07941905f, 0.01170043f, -0.00682760f, -0.00085712f, -0.07396866f, -0.06863174f, -0.04369321f, 
    -0.02174908f, 0.00911458f, -0.05802916f, 0.06165599f, 0.05280489f, 0.00776154f, -0.01253365f, -0.06566942f, 
    0.04738271f, 0.05299211f, 0.00878648f, -0.03735970f, -0.02281072f, -0.00723167f, -0.04051450f, -0.01860163f, 
    -0.07885145f, 0.00795152f, 0.01820140f, 0.04643962f, 0.06185376f, -0.07154554f, -0.00057330f, -0.01894601f, 
    -0.02374717f, 0.05531248f, 0.02905756f, 0.02053136f, -0.01722159f, 0.00854720f, 0.00215048f, 0.00530035f, 
    -0.03676792f, 0.03559615f, -0.04002827f, -0.03075767f, -0.00884740f, 0.04414957f, -0.06905925f, -0.02208924f, 
    -0.03033336f, -0.00835251f, -0.01124865f, -0.06159905f, -0.04286797f, 0.05245681f, 0.01049447f, -0.05168473f, 
    -0.04143847f, 0.00949849f, 0.00207023f, 0.01050815f, -0.03010247f, 0.03340909f, -0.07057593f, -0.07649033f, 
    -0.06563056f, 0.01844279f, 0.05238589f, 0.01548496f, -0.03522483f, 0.03937717f, -0.00489421f, 0.04076326f, 
    -0.00884484f, -0.01122962f, -0.04515499f, 0.01587065f, -0.07762147f, -0.05381079f, -0.03520810f, 0.03174826f, 
    -0.03105133f, -0.02866242f, 0.04875555f, -0.05406204f, -0.07316203f, -0.07104951f, -0.00273062f, -0.02800236f, 
    -0.05870373f, -0.01203386f, 0.03473744f, 0.05435542f, 0.00454196f, 0.02035232f, 0.00236731f, -0.07479296f, 
    0.05184821f, 0.02202966f, 0.02434862f, 0.05932851f, -0.04134009f, 0.01383384f, 0.02191039f, 0.02411632f, 
    -0.07586646f, -0.01429061f, -0.04034621f, -0.01109747f, -0.00770764f, 0.05220395f, -0.06647300f, 0.00132223f, 
    0.00468105f, 0.01063875f, 0.05198850f, 0.02019891f, -0.03504041f, 0.02968078f, 0.03997307f, -0.00594781f, 
    -0.02171944f, 0.02363096f, 0.00260046f, 0.00948791f, -0.06256671f, -0.07736369f, -0.02106521f, -0.03611612f, 
    0.01578116f, -0.01460552f, -0.03258835f, -0.03341909f, 0.03913616f, -0.02541069f, 0.02679913f, -0.06624344f, 
    -0.06541283f, -0.03434987f, 0.03737298f, -0.00240253f, -0.03534438f, -0.06860889f, 0.00829299f, 0.05766479f, 
    -0.06226232f, -0.04204853f, 0.05793782f, 0.05018873f, -0.05037984f, 0.00327228f, 0.01037161f, -0.07992052f, 
    0.01583600f, -0.02901993f, -0.00804593f, -0.06118492f, -0.03088006f, 0.05983278f, 0.05428107f, -0.07927290f, 
    -0.07853341f, -0.00828972f, -0.01850712f, 0.00710074f, -0.02676507f, -0.05507348f, 0.02686612f, 0.04633062f, 
    0.02743303f, -0.07420555f, 0.02578069f, -0.08213513f, 0.04287124f, -0.01073340f, -0.00027829f, 0.04782117f, 
    -0.00406473f, 0.01172742f, -0.07749042f, 0.01680524f, -0.03556165f, 0.05321041f, -0.01284137f, -0.06951104f, 
    0.06169581f, -0.06563235f, 0.01770633f, 0.01401818f, -0.07606816f, 0.03439403f, 0.01016189f, -0.07311358f, 
    0.03847162f, -0.05095846f, 0.03992874f, 0.00204745f, -0.02947224f, -0.05492560f, -0.04213496f, -0.03247714f, 
    -0.02339219f, 0.05685120f, -0.04231260f, -0.05725326f, 0.02341696f, 0.00354738f, 0.03640171f, -0.06643893f, 
    -0.00089407f, 0.01775384f, -0.05683186f, -0.05123999f, 0.02606228f, -0.06915884f, -0.03869341f, 0.03833139f, 
    0.00971961f, 0.03432663f, -0.00171252f, 0.02162092f, -0.02473038f, -0.03650004f, -0.04151740f, 0.02431922f, 
    -0.01822120f, -0.04752063f, 0.02314330f, -0.01419672f, 0.00227063f, -0.02111517f, -0.03642805f, 0.02018650f, 
    0.06406942f, -0.03176846f, -0.06826372f, 0.05543854f, 0.02025768f, -0.07099769f, -0.02641500f, 0.05318219f, 
    -0.02527948f, -0.01474363f, -0.05419128f, -0.05309350f, 0.01412795f, 0.04130092f, 0.02459973f, -0.00659480f, 
    -0.02650842f, 0.00182346f, 0.04399320f, -0.03216130f, 0.06482889f, 0.05886122f, -0.01769239f, -0.05301044f, 
    -0.06751288f, 0.02778252f, 0.01286076f, 0.04190835f, -0.00875871f, -0.07229424f, -0.03081395f, -0.02813406f, 
    -0.00086886f, 0.00498320f, -0.00481729f, 0.03433831f, 0.03850285f, -0.07321763f, -0.01974472f, -0.03780693f, 
    -0.01813011f, 0.03789062f, 0.02765137f, -0.00369405f, -0.05829013f, -0.07912928f, 0.02345236f, -0.03454973f, 
    0.05626538f, 0.02252820f, 0.00112558f, -0.07732229f, -0.04778233f, -0.05379023f, -0.00832634f, -0.01464102f, 
    -0.03476460f, -0.06133924f, -0.04642368f, 0.04315868f, -0.02279448f, 0.00664306f, -0.03490359f, -0.00904278f, 
    0.03775990f, 0.00618139f, -0.02253053f, 0.03691738f, 0.00026296f, 0.01368750f, -0.03756064f, -0.01094894f, 
    -0.01961770f, 0.00542691f, -0.02155118f, -0.04927192f, 0.04747750f, 0.06182633f, 0.01392863f, 0.00964486f, 
    -0.07489584f, 0.00784771f, -0.05317524f, 0.04568599f, -0.05040798f, 0.05931678f, -0.07599168f, 0.00625123f, 
    0.00200875f, 0.03441586f, -0.02684839f, -0.01479449f, 0.03760983f, 0.05833561f, -0.02573993f, -0.00165553f, 
    0.01661599f, -0.01126548f, -0.07305352f, -0.06908841f, -0.02485294f, 0.00063401f, -0.02350897f, 0.03905594f, 
    0.04246422f, -0.03838401f, -0.01705552f, -0.07687208f, 0.04367230f, -0.07256939f, 0.01676751f, -0.06124353f, 
    -0.07124034f, 0.02274137f, 0.04582645f, -0.03999384f, -0.04175201f, 0.03342573f, -0.06267987f, 0.03362027f, 
    -0.05778408f, 0.00570805f, -0.06176814f, 0.00237649f, 0.05732535f, -0.05895271f, 0.01246972f, 0.02388314f, 
    0.00234924f, -0.02063697f, 0.02412011f, -0.01059412f, 0.00242913f, -0.00969563f, -0.00520264f, -0.04129000f, 
    0.34221557f, -0.06008550f, 0.03673861f, 0.21173735f, -0.03620852f, -0.01270530f, 0.07168694f, 0.08494458f, 
    0.07323521f, 0.12557742f, -0.10375603f, -0.14999382f, -0.25376889f, -0.14917348f, 0.00836121f, 0.06573779f, 
    0.17649987f, 0.00640397f, -0.07389249f, -0.09391762f, -0.09178266f, 0.04339174f, 0.06514975f, -0.00688562f, 
    -0.17539428f, -0.15668847f, -0.09369475f, -0.04411411f, 0.18103039f, -0.10126567f, -0.01530149f, -0.10097353f, 
    0.06703570f, -0.07166755f, -0.10404926f, -0.05613885f, -0.04013148f, 0.21474271f, 0.18960142f, 0.11309584f, 
    0.02704789f, 0.23520243f, 0.07115231f, 0.00791171f, 0.05891707f, 0.02987165f, 0.07602237f, 0.04547547f, 
    0.01947419f, 0.09901274f, 0.01086129f, -0.00322904f, -0.10366435f, 0.00809563f, -0.07724258f, 0.14932898f, 
    -0.03366276f, 0.08950779f, -0.03581585f, -0.06393339f, -0.03489439f, -0.02731332f, -0.06052705f, 0.09086010f, 
    0.05538216f, -0.01614953f, -0.13746379f, -0.04598627f, -0.03251654f, -0.05794704f, 0.00570733f, -0.07845877f, 
    0.09155655f, -0.00863508f, -0.11992560f, -0.14989258f, 0.10824689f, -0.02209238f, -0.01697203f, 0.07213020f, 
    -0.07782828f, -0.10571226f, 0.11526027f, 0.00366768f, -0.01336534f, 0.05646416f, -0.03180654f, 0.09658936f, 
    0.02714339f, -0.05324756f, 0.00999705f, 0.04212440f, 0.10453690f, -0.05345481f, 0.04588280f, -0.04633757f, 
    0.19847688f, -0.01088184f, -0.13652542f, 0.16590609f, -0.01696613f, 0.03742258f, -0.05668863f, 0.07777961f, 
    -0.05164408f, 0.00906500f, -0.02443255f, -0.02487921f, 0.21594293f, -0.06820446f, -0.19099474f, -0.12070810f, 
    -0.10835878f, 0.03924948f, -0.02969916f, -0.02968052f, -0.01662358f, 0.00920394f, 0.01522303f, -0.03781894f, 
    0.24205682f, 0.21813615f, 0.02607329f, 0.16577628f, 0.05031766f, -0.15005507f, -0.02888266f, 0.00913232f, 
    0.00764680f, 0.18779697f, -0.00764400f, -0.08174834f, 0.21583760f, 0.10536611f, 0.02447112f, -0.16331810f, 
    -0.00511415f, 0.14474291f, 0.06750035f, -0.04147065f, 0.02274850f, -0.19948740f, 0.01827198f, 0.11964632f, 
    0.26168063f, 0.12454598f, -0.06403685f, 0.05104826f, -0.07187079f, 0.05946354f, 0.09788220f, -0.05414581f, 
    -0.08240179f, -0.04042511f, -0.01304527f, -0.12297480f, 0.03420956f, -0.02576319f, -0.16974954f, 0.23502558f, 
    0.06969134f, 0.18991438f, 0.06198884f, -0.14831319f, 0.10392193f, 0.09985670f, -0.09954048f, -0.05302885f, 
    -0.22215526f, 0.22483790f, 0.06298378f, 0.00789240f, 0.07193442f, -0.09476069f, -0.00246701f, 0.08260344f, 
    0.11722331f, 0.00383181f, 0.07133306f, -0.00145115f, 0.08151525f, 0.07089422f, 0.08097257f, 0.09743629f, 
    0.08166399f, 0.03233514f, -0.00879388f, 0.07353502f, -0.08208009f, -0.04423277f, -0.11211462f, 0.02717973f, 
    0.12138177f, -0.05425467f, 0.13308996f, 0.14693403f, -0.02281072f, -0.07985722f, -0.01939971f, -0.06599177f, 
    0.00874640f, -0.03450793f, 0.07787652f, 0.24800837f, 0.10460678f, 0.22566131f, -0.12630606f, 0.00648439f, 
    -0.05237557f, -0.06235649f, 0.11973581f, -0.05905086f, 0.13178796f, -0.07601877f, -0.03834049f, -0.01458202f, 
    -0.16377808f, -0.17103252f, -0.17447734f, -0.32761583f, -0.10618670f, 0.00429432f, 0.01403355f, 0.09681167f, 
    -0.02420108f, 0.06800239f, 0.14208660f, -0.03181985f, -0.01294014f, 0.00167892f, -0.12716280f, -0.06580682f, 
    -0.12873966f, -0.18751281f, 0.08325702f, 0.06632897f, -0.10423527f, 0.02112453f, -0.08962947f, -0.03440833f, 
    0.19399704f, 0.04663474f, 0.19590260f, -0.22469418f, 0.15742563f, -0.04875270f, 0.03470216f, -0.07735955f, 
    0.05549321f, 0.08182537f, 0.02060595f, 0.19062231f, 0.08311819f, -0.00454561f, -0.06822886f, -0.02940278f, 
    0.01321153f, -0.08170983f, 0.17839451f, 0.07360166f, 0.02457345f, 0.18958640f, 0.12381295f, 0.27496433f, 
    -0.11432439f, 0.21593210f, 0.06992114f, 0.05489713f, -0.08462136f, 0.14489745f, -0.03640194f, 0.02459186f, 
    -0.03063961f, -0.01793052f, 0.00251014f, -0.17994133f, -0.17730191f, -0.13717107f, -0.09002957f, 0.10450637f, 
    0.12239601f, 0.15334491f, -0.00724194f, 0.05242114f, -0.04007157f, -0.02241518f, 0.03614913f, 0.01641663f, 
    0.15001576f, 0.18347394f, 0.09221283f, 0.07035756f, 0.10104749f, 0.03656085f, -0.01561371f, 0.02338661f, 
    -0.00218873f, -0.00029917f, -0.05681040f, -0.03354126f, -0.05730250f, -0.06592153f, 0.18924764f, 0.15620060f, 
    0.11289042f, -0.01557546f, -0.01153423f, 0.00699634f, -0.15995152f, 0.05634597f, 0.02716890f, 0.04410497f, 
    0.12583834f, 0.11298572f, -0.00886695f, 0.11061818f, 0.13334066f, 0.04611470f, 0.04514461f, -0.06458789f, 
    0.09520758f, -0.20080592f, -0.05143934f, -0.13388363f, 0.16196531f, 0.18745968f, 0.03132220f, -0.00244089f, 
    -0.04507032f, -0.06691337f, -0.11424188f, -0.07808324f, -0.16512424f, 0.14954092f, -0.08698872f, -0.14093558f, 
    -0.26800534f, -0.04082352f, -0.02544010f, 0.24688587f, -0.09791137f, -0.11824723f, 0.15826091f, 0.06409808f, 
    0.08284356f, 0.16089913f, -0.10649905f, 0.09139948f, -0.08830186f, -0.10211350f, -0.04942463f, 0.04180086f, 
    0.03340152f, -0.01393809f, -0.05522460f, -0.00739475f, 0.13937609f, -0.00706657f, 0.10994761f, 0.12667057f, 
    0.09195033f, -0.04607801f, -0.17044908f, 0.00956003f, -0.00210508f, 0.11950367f, -0.04823284f, 0.20316894f, 
    0.06267235f, 0.10936058f, 0.04440658f, 0.06381416f, 0.28702015f, 0.11370628f, -0.04060906f, 0.32713839f, 
    -0.24407616f, -0.15833741f, 0.01998154f, -0.04669713f, -0.12409748f, -0.00722362f, 0.00517483f, 0.03130331f, 
    -0.12215276f, 0.08948741f, -0.11697294f, -0.10279715f, 0.16615663f, -0.06086259f, 0.01414468f, 0.00947282f, 
    0.02273871f, 0.00230829f, 0.09985294f, -0.05644867f, 0.28634340f, 0.27467510f, -0.17116530f, 0.01079087f, 
    0.13955013f, 0.17808832f, -0.00508144f, -0.11631802f, -0.10684032f, 0.00844982f, -0.08555892f, -0.01537067f, 
    0.08896586f, -0.00959174f, 0.11688165f, 0.00075613f, -0.06915247f, 0.05219446f, 0.07156495f, 0.00104806f, 
    -0.00035580f, -0.07345961f, -0.10722634f, -0.00636347f, -0.04434548f, -0.14888169f, 0.00482707f, 0.01639359f, 
    0.00658705f, 0.01014052f, -0.04036234f, -0.02636933f, 0.05893098f, -0.03145643f, -0.04555551f, 0.12815741f, 
    -0.07181997f, 0.22633146f, 0.06086972f, 0.06169712f, -0.04996243f, 0.00742507f, -0.15295428f, -0.09547196f, 
    0.05478671f, -0.01839951f, 0.07004239f, -0.03080945f, 0.20049170f, -0.06614865f, 0.05980885f, 0.31808031f, 
    -0.09226257f, -0.07325166f, 0.05229146f, -0.02447864f, -0.04211753f, 0.15198097f, -0.09787497f, 0.12479075f, 
    -0.12725568f, -0.06668327f, 0.13316920f, -0.12728333f, 0.13762097f, 0.01811553f, 0.03465053f, -0.05855857f, 
    0.06581534f, 0.00253047f, -0.00786358f, -0.06324293f, 0.13411847f, -0.02883147f, 0.03755129f, -0.11017057f, 
    0.09604640f, -0.00062744f, -0.09796382f, 0.05660572f, -0.00603115f, -0.05014154f, -0.00783359f, 0.05765975f, 
    -0.25238764f, 0.08985246f, 0.18271938f, 0.05852871f, -0.09924117f, -0.12618059f, -0.04021703f, 0.12732485f, 
    -0.00845813f, -0.07471431f, 0.02464444f, 0.00495184f, 0.31766465f, -0.12018140f, 0.06497508f, 0.17032777f, 
    0.03381240f, -0.07482727f, -0.02055715f, 0.08534449f, 0.04408797f, 0.15383665f, -0.03516442f, 0.07503722f, 
    -0.01484147f, -0.22459114f, -0.18320593f, 0.09295693f, -0.06919695f, 0.04312548f, 0.03215345f, -0.04315759f, 
    -0.07706298f, 0.03426411f, -0.07841706f, 0.02932733f, -0.24142389f, -0.06586281f, -0.05739096f, 0.07497258f, 
    0.05131530f, 0.10923344f, -0.06104422f, 0.15949622f, 0.07942284f, -0.02668502f, -0.08058946f, 0.06055766f, 
    0.20562723f, -0.08822812f, 0.02268190f, -0.16102472f, 0.06533618f, 0.07894869f, 0.03432756f, -0.10485459f, 
    0.05522642f, 0.02973305f, -0.01694484f, -0.05139640f, 0.25039250f, -0.01105980f, 0.10159764f, 0.23004384f, 
    -0.07185223f, 0.30004829f, 0.05030999f, 0.09095109f, -0.09314577f, -0.05700898f, -0.00456487f, 0.04497049f, 
    -0.36780882f, -0.13401675f, 0.12078228f, 0.03639884f, 0.13146801f, -0.02543387f, 0.05710429f, -0.06523096f, 
    0.08606158f, -0.05022162f, -0.03616840f, -0.00427895f, 0.09431016f, 0.14594075f, -0.02338581f, 0.01458695f, 
    0.05216400f, 0.14618348f, -0.09739886f, -0.08965804f, 0.06629022f, 0.12747708f, 0.10167740f, -0.07483874f, 
    -0.10296589f, -0.05618957f, 0.01837261f, -0.03930293f, 0.12948357f, 0.15978660f, 0.09996057f, -0.06309430f, 
    -0.00421015f, -0.01755001f, 0.04309218f, -0.04469376f, -0.22090432f, 0.55499417f, -0.12040007f, -0.27152330f, 
    -0.02536342f, 0.07992506f, 0.07829235f, -0.07530426f, -0.08654545f, 0.02635454f, -0.02050285f, 0.03842767f, 
    -0.04658062f, 0.12938158f, 0.03712655f, -0.19484203f, -0.01544918f, 0.01423243f, -0.03363381f, -0.06118898f, 
    0.01214603f, -0.14751974f, -0.07111005f, 0.01891950f, 0.01566891f, -0.07081810f, -0.01712294f, 0.21219161f, 
    0.19813891f, 0.12497669f, -0.00825084f, 0.09134173f, 0.00816019f, -0.02111316f, 0.00150237f, 0.08880484f, 
    0.08430185f, 0.06455261f, 0.15737371f, -0.11361279f, -0.01830512f, -0.02701974f, -0.09246660f, -0.12829317f, 
    -0.14089833f, -0.02599703f, 0.07207328f, -0.05158531f, 0.06632469f, -0.15257788f, 0.11686010f, 0.37175387f, 
    -0.15714961f, 0.02237225f, 0.02992232f, 0.02761143f, -0.07012586f, 0.10785849f, -0.11176238f, 0.12409921f, 
    0.00310719f, -0.01627536f, 0.13215823f, -0.16034588f, 0.07511242f, -0.04493416f, 0.05709568f, -0.02416125f, 
    0.11255312f, 0.08221915f, 0.00407562f, 0.02727248f, -0.25931007f, 0.23782085f, -0.02987399f, 0.08933241f, 
    -0.02657266f, 0.02474516f, 0.06908454f, 0.02910817f, 0.13558052f, -0.05400230f, -0.05298085f, -0.05389173f, 
    -0.04993261f, -0.01174897f, 0.13888806f, 0.08040869f, 0.06942734f, -0.05067280f, 0.07712860f, 0.00109502f, 
    -0.06543083f, 0.07052445f, -0.01392690f, -0.04006188f, 0.24370575f, -0.29772386f, 0.16091858f, 0.25098467f, 
    -0.06351265f, -0.01833482f, 0.00440062f, 0.04382579f, -0.05250698f, 0.07413374f, -0.04075857f, -0.05640223f, 
    -0.05447068f, -0.25220159f, -0.07805869f, 0.02642347f, 0.01162050f, -0.15184329f, -0.09217890f, -0.06653507f, 
    -0.03533506f, 0.00491134f, -0.09875879f, 0.10377996f, -0.15726286f, 0.04116013f, 0.09268492f, 0.14862807f, 
    0.10111693f, 0.12054014f, 0.08401793f, 0.12370886f, 0.06389738f, 0.09411725f, -0.06065240f, -0.06193915f, 
    -0.11744139f, 0.07260098f, -0.01312605f, -0.03575856f, -0.07173193f, 0.00453922f, 0.02147374f, -0.04937581f, 
    0.03649031f, 0.05338338f, 0.01766876f, -0.01535314f, 0.03635681f, -0.01848280f, -0.02902581f, 0.09885608f, 
    -0.06050730f, 0.18355156f, -0.08005547f, 0.09478273f, -0.02859767f, 0.00200851f, 0.01633765f, 0.04157112f, 
    -0.00443037f, -0.17558347f, -0.01490634f, 0.11491869f, 0.04426663f, -0.00441698f, 0.07354170f, -0.05430180f, 
    -0.10000676f, 0.00852121f, 0.04275894f, -0.02557418f, -0.03197079f, 0.08372781f, 0.02512292f, 0.01083488f, 
    0.05374224f, 0.08022801f, -0.06223088f, 0.02611322f, 0.07005750f, -0.00347247f, 0.01031637f, -0.01615312f, 
    0.14391969f, -0.08233577f, -0.12296899f, 0.00577685f, -0.04862226f, -0.00183090f, 0.00100860f, -0.04281911f, 
    0.01845064f, -0.03665518f, 0.12044628f, 0.22016314f, 0.29844025f, 0.02230455f, 0.01973463f, -0.05066428f, 
    0.15600559f, -0.08047505f, 0.12313527f, 0.03468865f, -0.04207811f, -0.06347340f, -0.11643991f, -0.09851407f, 
    0.02048910f, 0.09737735f, -0.00952001f, -0.05453017f, 0.02634554f, 0.07627505f, 0.01197267f, 0.09613180f, 
    0.07345375f, 0.08858937f, -0.00992543f, 0.06581927f, -0.01313376f, -0.15936083f, -0.12038188f, -0.03810104f, 
    -0.11616071f, -0.13844885f, 0.12271285f, 0.04014800f, -0.00497446f, 0.09579393f, -0.09136514f, -0.05318953f, 
    -0.14489608f, 0.07770471f, 0.00921721f, -0.01546119f, 0.10325495f, -0.00342208f, 0.07942555f, 0.08369258f, 
    0.05225523f, 0.09339668f, -0.03946242f, 0.19493139f, 0.17704397f, -0.16008399f, -0.19888492f, -0.12512134f, 
    -0.13212329f, 0.05564782f, 0.21295583f, 0.04325396f, -0.01814197f, 0.23365425f, 0.06351946f, 0.17258161f, 
    -0.18477458f, 0.13113891f, 0.16483387f, 0.10418042f, 0.01267471f, 0.07184970f, 0.09468818f, -0.00917275f, 
    -0.02663889f, -0.12673390f, 0.06119938f, -0.08831321f, -0.03365550f, -0.10282562f, 0.12322448f, 0.03802075f, 
    0.23835167f, 0.07410061f, -0.02490955f, 0.06051977f, -0.08119392f, 0.02729372f, 0.06097467f, 0.00881921f, 
    -0.07460881f, 0.16657534f, -0.05273376f, -0.04764521f, -0.00524801f, -0.00259249f, -0.18135870f, 0.09813505f, 
    0.06855343f, -0.13581045f, -0.13219921f, -0.03249987f, -0.06958591f, 0.30220705f, 0.04554319f, -0.11021592f, 
    0.01856915f, -0.03588276f, -0.00355828f, 0.12579593f, -0.05352313f, 0.02206120f, -0.02304951f, 0.02868805f, 
    -0.05140139f, 0.13055262f, -0.03256996f, 0.08390444f, -0.06636640f, 0.10913352f, 0.05033382f, 0.00370988f, 
    0.01012168f, 0.00000675f, 0.03629949f, -0.17999387f, 0.05529047f, 0.01687131f, 0.05029789f, -0.04328697f, 
    0.04479818f, 0.06241669f, -0.06921094f, 0.06061411f, -0.01553336f, 0.04709845f, 0.08657511f, -0.12059873f, 
    0.00974758f, -0.23229200f, 0.10725376f, -0.02143672f, 0.12464123f, -0.12766309f, 0.07706663f, 0.14591755f, 
    0.03477914f, 0.08179520f, 0.01787575f, -0.05894075f, -0.08404566f, -0.00904825f, 0.01147128f, -0.13132383f, 
    0.13882421f, 0.01236097f, -0.07380784f, 0.07674164f, -0.04225161f, -0.02997055f, 0.01451546f, 0.12785092f, 
    -0.00969565f, 0.05846780f, -0.04218968f, -0.13778286f, -0.00176285f, 0.03352504f, -0.16482976f, 0.07256973f, 
    -0.02183457f, 0.13259393f, -0.08172390f, 0.04648850f, 0.08140565f, -0.10253362f, -0.12130976f, 0.25078768f, 
    -0.03345996f, -0.06930342f, 0.01618698f, 0.03164956f, 0.08936286f, -0.01024305f, 0.04666485f, 0.05244887f, 
    0.03501763f, 0.04265318f, -0.04352785f, -0.07358604f, 0.01211353f, -0.01302094f, 0.06680241f, -0.05132603f, 
    0.05832477f, -0.05092726f, 0.05762123f, 0.05384611f, -0.09265695f, -0.16372222f, -0.01117171f, 0.02807112f, 
    0.17331921f, 0.07956608f, -0.07619553f, 0.01781892f, 0.08598524f, 0.07201844f, 0.08337051f, 0.14384192f, 
    -0.09455921f, 0.03219362f, 0.12106493f, -0.33018270f, 0.01662253f, -0.01880421f, -0.02172792f, -0.04802328f, 
    0.01273870f, 0.14812244f, -0.01736849f, -0.00512317f, 0.07307416f, 0.19846472f, -0.06906166f, 0.25698254f, 
    -0.01860405f, -0.10059770f, -0.00616339f, -0.13624726f, -0.14020455f, 0.12559599f, -0.14236863f, -0.09959641f, 
    0.29015303f, -0.00310964f, 0.12957720f, -0.29991055f, 0.03159771f, -0.01259391f, -0.07594395f, 0.07287832f, 
    0.05551500f, 0.15562113f, 0.09938342f, -0.05456665f, -0.22556436f, 0.25351098f, -0.04997228f, 0.15551271f, 
    0.10722657f, 0.10474782f, -0.00365402f, -0.10149544f, 0.04093700f, -0.10495010f, 0.08979388f, 0.07226675f, 
    0.48110065f, 0.05674591f, -0.09482487f, -0.06979728f, 0.04085974f, 0.04185259f, -0.09772563f, 0.01050379f, 
    -0.05401701f, 0.04131249f, 0.05746838f, 0.11143084f, -0.16761978f, -0.15897322f, 0.04297366f, -0.08625318f, 
    -0.08462083f, -0.05661061f, 0.10012577f, 0.08260423f, 0.15446562f, 0.00808540f, -0.00426054f, 0.01141767f, 
    0.14927696f, -0.03934952f, 0.07948332f, 0.07433548f, -0.03307912f, 0.11357637f, 0.00399318f, 0.02913930f, 
    0.03193908f, 0.02330721f, 0.08498418f, -0.03550601f, 0.27720481f, -0.02891343f, -0.07736549f, 0.17111671f, 
    0.04413054f, -0.05619214f, 0.04171141f, -0.10752385f, -0.03303117f, 0.16286196f, 0.03412137f, -0.06399336f, 
    0.07940517f, -0.00299918f, 0.00638610f, 0.23450090f, 0.05010091f, 0.03680564f, 0.13116434f, -0.01825450f, 
    -0.04315229f, -0.11855067f, -0.13369654f, 0.07227478f, 0.11512474f, 0.12009308f, -0.13748421f, -0.03756040f, 
    0.02548225f, -0.14904447f, -0.09474909f, -0.07484923f, -0.10377241f, -0.07485254f, -0.10862503f, 0.00488985f, 
    -0.14418012f, -0.02421492f, -0.19040149f, 0.11151063f, -0.14418761f, 0.05358404f, 0.16283309f, 0.08330689f, 
    -0.06476758f, -0.06779834f, -0.06830136f, 0.02478721f, 0.11883064f, -0.15667033f, -0.02512119f, 0.14616174f, 
    0.02355653f, -0.08243435f, 0.05602910f, -0.09087592f, 0.10806612f, 0.06638297f, 0.01185544f, -0.02209407f, 
    0.04038556f, -0.01295215f, -0.20818569f, 0.24609029f, -0.10555030f, -0.01799451f, 0.00525556f, 0.09666472f, 
    0.04883729f, 0.05497520f, -0.01900412f, -0.08120684f, 0.13689014f, 0.05861280f, 0.01999998f, -0.04563339f, 
    -0.03648667f, 0.04290112f, -0.15566823f, -0.07336878f, -0.00255971f, 0.06553751f, 0.04196961f, -0.04339819f, 
    0.29363942f, 0.08970823f, 0.28660232f, -0.03407636f, 0.07183834f, 0.09288967f, -0.12253663f, 0.11826731f, 
    -0.12147701f, -0.06034598f, 0.09550520f, 0.02033614f, 0.23912334f, 0.14764264f, -0.09473616f, 0.12421560f, 
    0.03246738f, -0.02880348f, -0.13272503f, 0.06914767f, -0.20253445f, -0.14765805f, 0.00719147f, 0.00882966f, 
    0.22812998f, -0.09509148f, 0.07045720f, 0.12730154f, -0.09807535f, 0.00433673f, -0.00028575f, 0.07368959f, 
    -0.07383724f, -0.16668241f, -0.07680272f, 0.02892235f, 0.17441770f, 0.10805435f, 0.27328396f, 0.10722842f, 
    0.06456419f, -0.02584707f, 0.03973399f, 0.23130944f, 0.04599191f, 0.10058342f, 0.11283077f, 0.05296755f, 
    -0.00653563f, -0.01859450f, 0.09280163f, -0.04869379f, -0.19041888f, -0.04614257f, 0.00170467f, -0.11224828f, 
    -0.19003454f, 0.00907233f, 0.09262113f, 0.01460044f, 0.20178160f, -0.13537158f, -0.11377172f, 0.09652480f, 
    -0.21647981f, 0.07840473f, 0.02189859f, 0.11207859f, 0.04820205f, 0.09722771f, -0.09936163f, 0.29919800f, 
    -0.53809595f, -0.19936347f, 0.19787872f, -0.07390027f, 0.03138175f, 0.04408162f, 0.08556803f, -0.17672776f, 
    -0.23643661f, 0.03011432f, -0.07920163f, -0.08274473f, 0.27882779f, 0.03310373f, 0.00122286f, 0.06214364f, 
    0.14529788f, 0.08702171f, -0.24630488f, -0.06439882f, -0.00562430f, 0.05625413f, -0.06918544f, -0.03487229f, 
    0.04382144f, 0.05754580f, 0.16598241f, 0.10703564f, 0.03417312f, 0.03152459f, -0.09800258f, -0.01062033f, 
    -0.14655909f, -0.03737991f, -0.19817424f, 0.13889013f, -0.11575610f, -0.30194941f, 0.01432643f, -0.11232393f, 
    -0.04550442f, 0.06749598f, -0.01485383f, 0.21581815f, 0.01478756f, -0.11155158f, -0.06497344f, 0.04419461f, 
    -0.16860725f, -0.22576882f, -0.24060012f, -0.02688383f, -0.13195136f, 0.08363538f, -0.13949110f, -0.07616445f, 
    -0.12786330f, -0.00400100f, -0.14020769f, -0.03112812f, 0.09605823f, 0.12034682f, 0.20109548f, 0.22805059f, 
    0.04221714f, 0.00229372f, 0.00402719f, 0.16371068f, -0.09410891f, 0.01667302f, 0.08734892f, 0.07259360f, 
    0.14972082f, 0.00398178f, 0.14868355f, 0.00137746f, 0.14299330f, -0.13970774f, -0.11833096f, 0.05512122f, 
    -0.04780421f, 0.03791648f, 0.02134981f, -0.06518102f, -0.06490281f, -0.29946443f, -0.09313273f, 0.14836872f, 
    -0.05231592f, 0.04447628f, -0.06381959f, 0.10938089f, -0.26856586f, -0.10639436f, -0.07959872f, 0.13058439f, 
    -0.25356475f, 0.14174807f, 0.20398569f, 0.03143714f, 0.20483392f, -0.13051966f, -0.14486785f, 0.08909326f, 
    0.04461940f, -0.01707954f, 0.09259504f, 0.00520473f, 0.22041118f, 0.12590007f, 0.00167506f, 0.16999118f, 
    -0.06235839f, -0.03945494f, 0.06126317f, -0.08636376f, 0.01738787f, 0.00285289f, 0.07086830f, -0.01336269f, 
    -0.22872746f, -0.17471693f, -0.26477453f, -0.05606548f, 0.03357593f, 0.02191572f, -0.09996855f, 0.06046503f, 
    -0.06255111f, 0.05582795f, 0.00386129f, -0.02687847f, -0.16480458f, 0.31871232f, -0.01679485f, 0.00925047f, 
    0.23070043f, 0.07648480f, -0.00454794f, -0.04127182f, -0.07734021f, 0.13455357f, 0.01737634f, -0.02517325f, 
    -0.06603619f, 0.11228524f, 0.16353172f, -0.07115558f, 0.02589255f, 0.02938323f, -0.01821916f, -0.08211712f, 
    -0.02062547f, 0.00851840f, -0.08748958f, -0.00841367f, -0.25660297f, -0.47650585f, 0.10830720f, -0.02178203f, 
    0.04478890f, 0.09464534f, -0.08385800f, -0.06407950f, -0.03355428f, -0.03542104f, 0.04313020f, 0.01152391f, 
    -0.14973648f, 0.13310297f, -0.01486844f, 0.05853790f, 0.00008660f, -0.03998687f, -0.02039434f, -0.04902557f, 
    0.02727802f, -0.03544724f, 0.01515808f, -0.01531155f, 0.05149814f, -0.13730031f, 0.00057177f, 0.30218026f, 
    -0.09325705f, -0.16729602f, -0.03489225f, -0.05146976f, 0.05703058f, 0.13584176f, 0.12487423f, 0.16652164f, 
    0.05382995f, 0.21602389f, 0.05245847f, -0.20107879f, 0.10679198f, 0.01377385f, -0.03212894f, 0.01136589f, 
    0.15808965f, 0.11992985f, 0.05561333f, 0.09897074f, -0.26767913f, 0.15235253f, 0.06493834f, 0.15732761f, 
    0.10414182f, -0.02229351f, -0.05723541f, 0.01025265f, 0.03763036f, 0.14083686f, 0.02428780f, 0.15534610f, 
    -0.15414472f, -0.12524305f, -0.25890884f, 0.15647221f, -0.01402979f, 0.03534552f, 0.02905384f, -0.06720136f, 
    -0.08660462f, 0.06304936f, 0.02689939f, 0.05417145f, 0.14884308f, -0.24255665f, 0.21163055f, 0.13472383f, 
    -0.02628323f, 0.06530701f, -0.04829610f, 0.06666096f, -0.08397442f, 0.00525408f, -0.00859207f, -0.18442659f, 
    0.06480192f, -0.03959448f, -0.01290370f, 0.17588441f, -0.13071610f, -0.12008276f, -0.01633981f, 0.12555432f, 
    0.05729035f, 0.13003741f, -0.06148051f, -0.01676918f, -0.17604332f, -0.25717485f, -0.19818844f, -0.01830724f, 
    0.02346595f, 0.16582081f, 0.01522278f, -0.01756677f, 0.10558932f, -0.04987611f, 0.07754647f, 0.05103484f, 
    -0.15716562f, -0.11958108f, -0.04831751f, -0.12822747f, 0.00343307f, 0.04691739f, -0.03453282f, 0.03301084f, 
    0.04570380f, -0.01777122f, -0.06554102f, -0.03374191f, 0.09605072f, 0.00433487f, 0.13167286f, 0.18203147f, 
    0.02675332f, 0.28116259f, 0.00555676f, -0.01339444f, -0.04015961f, 0.03657903f, 0.06319844f, 0.01268444f, 
    -0.36707932f, -0.37093544f, -0.01012517f, -0.04605020f, -0.01501010f, -0.16877313f, 0.04414764f, -0.00705011f, 
    0.03580490f, 0.02435869f, 0.10044001f, 0.01139607f, -0.18536665f, -0.37787083f, -0.27029204f, 0.03669302f, 
    0.18947770f, 0.09310945f, -0.06255376f, -0.03276646f, 0.08655062f, 0.08007111f, -0.04865045f, 0.14404339f, 
    -0.19946533f, 0.18446226f, -0.01388876f, -0.14721686f, 0.15299721f, 0.00315398f, 0.07962373f, -0.09489874f, 
    0.01131888f, -0.09670837f, 0.11495189f, 0.07952645f, 0.29130584f, 0.16704193f, -0.09788375f, 0.11899459f, 
    -0.13312498f, 0.17920297f, -0.02604857f, -0.07257047f, 0.04513659f, -0.05439091f, 0.02047366f, 0.00320636f, 
    0.07116582f, -0.03850886f, 0.12715836f, -0.12418441f, -0.08393830f, -0.04040069f, 0.03387309f, -0.03741840f, 
    -0.01540551f, 0.10168572f, -0.06017935f, -0.02436911f, 0.05301742f, 0.10235410f, -0.09332065f, -0.07082457f, 
    0.01894159f, 0.03326000f, -0.08236326f, -0.08778402f, -0.02808777f, 0.08270933f, -0.00958723f, -0.00983738f, 
    0.03741727f, 0.14558724f, 0.27924183f, -0.20859450f, 0.11907112f, 0.03995914f, -0.03631878f, -0.00169933f, 
    -0.00189975f, 0.00422985f, 0.17049487f, -0.00057171f, 0.08569065f, 0.20268312f, 0.04149644f, 0.28871152f, 
    0.01316071f, -0.03677434f, 0.05444731f, 0.04195112f, 0.11058612f, 0.05635286f, -0.02399907f, 0.05700906f, 
    -0.03178800f, 0.07512791f, 0.06686004f, -0.08719008f, -0.03274178f, 0.04164051f, 0.12755099f, -0.08842398f, 
    0.08568645f, 0.04355415f, 0.04039132f, -0.01266536f, -0.04436523f, -0.22594841f, 0.01202430f, -0.02282168f, 
    -0.00606596f, 0.10177720f, 0.01555099f, 0.04330502f, 0.10353749f, -0.04708486f, -0.03306673f, 0.02804965f, 
    -0.04876308f, 0.03212320f, 0.19219594f, 0.02199261f, 0.00677756f, -0.03646974f, 0.09480277f, -0.03475854f, 
    0.05449776f, 0.03186327f, 0.07488808f, -0.02503718f, 0.01411100f, -0.07464575f, 0.11175521f, 0.28538483f, 
    0.05512044f, -0.15248238f, 0.12200205f, 0.10850561f, -0.02931716f, 0.11861765f, 0.01241087f, -0.03136826f, 
    0.16281472f, -0.13117351f, -0.08554999f, 0.20550862f, 0.01333734f, 0.04351337f, 0.01956870f, -0.12299950f, 
    -0.02917152f, 0.03992127f, -0.06975082f, 0.03397385f, -0.07212899f, 0.15627608f, -0.16560589f, 0.04659463f, 
    0.06944139f, -0.08243655f, -0.13799110f, -0.07207771f, -0.02644600f, 0.01038279f, -0.14193860f, 0.05333103f, 
    -0.10542362f, 0.02846844f, -0.13925515f, -0.10417474f, -0.05400260f, -0.01105770f, 0.06519292f, -0.10143569f, 
    -0.02394671f, 0.10236061f, 0.04035146f, 0.07238364f, 0.35557076f, -0.11003536f, 0.09690188f, 0.34913144f, 
    -0.14517812f, 0.05573221f, 0.04789693f, 0.01082734f, -0.01769716f, -0.05747989f, 0.04515508f, 0.01396635f, 
    -0.21082872f, -0.19473265f, -0.01225292f, -0.04003204f, -0.01931118f, 0.05618014f, 0.00976172f, -0.04205999f, 
    0.05030314f, -0.04316739f, 0.04194480f, 0.13119237f, 0.19383858f, 0.29024813f, 0.03855423f, -0.05245781f, 
    -0.01030381f, -0.07027338f, -0.01538837f, -0.01574359f, 0.01953930f, 0.00348326f, 0.09988361f, -0.08657774f, 
    0.25633794f, -0.11057901f, 0.19104420f, 0.21322653f, 0.12679695f, 0.10856797f, 0.06873044f, 0.08893905f, 
    -0.15653074f, 0.11613360f, -0.14877430f, -0.07884606f, -0.28565204f, 0.22452256f, -0.09425771f, -0.18091494f, 
    -0.07396494f, -0.13491897f, -0.07477675f, -0.03141442f, 0.00979316f, -0.04415156f, 0.10546000f, 0.03401636f, 
    -0.31665632f, -0.26431751f, -0.27755335f, 0.00368411f, -0.00143402f, -0.16483679f, -0.04423644f, -0.09357714f, 
    0.06519164f, -0.14541112f, -0.11407116f, -0.01838301f, 0.01161184f, 0.04933150f, 0.28133145f, -0.01898425f, 
    0.18284246f, 0.19713537f, 0.02694626f, 0.12553722f, -0.03576039f, -0.08701446f, 0.04295607f, 0.08639286f, 
    0.06272580f, 0.06280081f, 0.01068162f, 0.08623949f, -0.23179497f, -0.10172564f, -0.00802140f, -0.09746870f, 
    0.00834079f, 0.09455404f, -0.14128613f, -0.11311667f, 0.07237357f, -0.11901148f, 0.05071889f, 0.11600212f, 
    -0.18941623f, -0.16528693f, -0.22648373f, -0.09469165f, -0.02416543f, 0.06149112f, 0.05287599f, -0.11701428f, 
    -0.33385333f, -0.11524226f, 0.09235901f, 0.02063169f, -0.01208508f, -0.05174629f, -0.05492193f, 0.16393834f, 
    -0.03565625f, 0.06440216f, -0.02777605f, 0.04967798f, 0.01660870f, 0.27214575f, -0.10827949f, 0.14914548f, 
    0.01398588f, 0.10412033f, 0.05691015f, -0.07534713f, 0.03305477f, 0.06274225f, 0.23085347f, 0.00880605f, 
    0.13534029f, 0.08241392f, -0.09901941f, 0.05643211f, 0.14030987f, -0.05920635f, 0.12121176f, -0.12576528f, 
    -0.11347232f, 0.15742296f, -0.01744493f, -0.01942158f, 0.00475254f, -0.26246575f, 0.13109758f, -0.08687735f, 
    -0.04121622f, 0.07720778f, -0.07932863f, 0.00577986f, 0.04070512f, -0.01263004f, 0.14322193f, 0.14347622f, 
    0.15130210f, 0.20017651f, -0.08794526f, 0.03883117f, 0.00794101f, -0.11464958f, -0.16570055f, -0.03507349f, 
    0.03504881f, 0.13373436f, 0.02527894f, -0.01806038f, 0.11050908f, 0.14289246f, 0.12462800f, 0.00391305f, 
    -0.06621314f, 0.18436155f, 0.11765592f, 0.00800237f, 0.07251547f, 0.03076822f, -0.08366417f, -0.01293445f, 
    -0.03141033f, 0.06879305f, 0.06542906f, -0.01495181f, 0.18708616f, 0.13948148f, -0.07671105f, 0.07076978f, 
    0.08683722f, 0.10312825f, 0.03789946f, 0.04733375f, -0.05334100f, 0.07133996f, -0.11363664f, 0.04958275f, 
    0.09040176f, -0.01542140f, -0.09090081f, 0.00403747f, -0.07247587f, -0.01770775f, -0.08540315f, 0.00707573f, 
    -0.17408535f, 0.15595758f, 0.17037734f, -0.00781407f, 0.21366560f, -0.14171891f, 0.06537151f, -0.00731547f, 
    0.12456798f, -0.06778798f, 0.04230363f, -0.04187484f, 0.09373023f, 0.00341994f, 0.09264390f, 0.24808446f, 
    0.16353109f, 0.05644559f, 0.09298195f, -0.01080029f, -0.12638894f, 0.03286345f, 0.05433238f, -0.11434872f, 
    0.05138270f, -0.06453254f, -0.02680320f, 0.05726026f, -0.00191806f, -0.03423965f, -0.04215845f, -0.07166826f, 
    0.05883078f, -0.04339148f, 0.02202218f, 0.06637780f, -0.07159829f, 0.06537283f, -0.04478495f, -0.03863776f, 
    -0.07751986f, 0.01245027f, -0.03936452f, -0.00881935f, -0.00376742f, -0.06102943f, 0.03529187f, 0.00118495f, 
    0.06732550f, 0.02011884f, 0.04346700f, 0.04306316f, 0.05844779f, -0.03770131f, 0.05421554f, 0.01896687f, 
    0.01397233f, -0.06732310f, -0.05153002f, 0.05069209f, -0.00979596f, -0.07563845f, -0.07204711f, 0.02496168f, 
    -0.05936056f, 0.03342606f, -0.05814810f, -0.02763276f, 0.01344252f, -0.01488109f, -0.00345084f, -0.07457217f, 
    -0.02832067f, 0.00651007f, 0.01270171f, -0.05104687f, -0.05030898f, -0.05054752f, -0.05946666f, 0.03610815f, 
    -0.07809230f, -0.03021371f, -0.07763426f, 0.04303543f, -0.03975435f, 0.00319574f, 0.05497923f, -0.03472258f, 
    -0.03958432f, 0.00372737f, 0.01318333f, -0.04089667f, 0.03820023f, -0.03570787f, -0.07091893f, 0.03668004f, 
    0.00664991f, -0.01068551f, -0.00003052f, -0.04285198f, 0.04277335f, 0.03003056f, -0.07552507f, 0.05835063f, 
    -0.02686694f, -0.05469641f, 0.03425709f, 0.05145391f, -0.05479554f, 0.04824921f, 0.05407050f, 0.00878715f, 
    -0.01177638f, 0.04415645f, -0.06784303f, -0.05743194f, -0.04310692f, 0.05572851f, -0.07911438f, 0.02466047f, 
    0.01274721f, -0.06023766f, -0.04850923f, 0.04062631f, 0.03366407f, -0.00998905f, -0.07114041f, -0.00914812f, 
    -0.00131549f, -0.07084834f, -0.01059278f, -0.05148756f, 0.02775438f, -0.01538191f, -0.05271228f, 0.06411613f, 
    -0.00478155f, 0.02102691f, -0.05483473f, 0.05415640f, 0.04409306f, 0.05368742f, 0.02554403f, 0.01117672f, 
    0.00672123f, -0.03019777f, -0.07118388f, -0.05227123f, -0.04853577f, -0.06043001f, -0.01937121f, -0.01427865f, 
    0.03155529f, -0.00340294f, 0.01386085f, 0.03004311f, 0.04506932f, 0.01431848f, -0.01285209f, 0.02498632f, 
    0.04257135f, 0.04943184f, -0.01609304f, -0.00703708f, 0.00159746f, -0.06434801f, 0.03873112f, -0.00455827f, 
    0.00684787f, 0.06136454f, -0.07336951f, 0.02434953f, -0.07658576f, -0.08181193f, 0.00340783f, 0.04173935f, 
    -0.03260782f, -0.06829887f, -0.07717945f, -0.05302462f, 0.01268026f, 0.03544886f, -0.03967081f, -0.02665295f, 
    -0.06993322f, -0.03878170f, -0.01610907f, 0.05670392f, -0.06607779f, -0.02344980f, 0.00540665f, -0.04679380f, 
    -0.01758958f, -0.07305241f, 0.05073651f, 0.04678348f, 0.01235045f, -0.04835670f, -0.02219562f, 0.02895000f, 
    -0.02937002f, -0.01665401f, 0.04529943f, -0.01032030f, -0.03720891f, -0.06475102f, 0.03191650f, -0.05325121f, 
    -0.04219547f, 0.04789216f, -0.00235435f, -0.01941103f, 0.06255201f, -0.05850343f, 0.06044345f, 0.00404466f, 
    -0.13366196f, 0.07196094f, -0.00160602f, -0.18848510f, 0.04983637f, 0.09507831f, -0.02437167f, 0.00926159f, 
    -0.10321634f, -0.03760390f, 0.00448306f, -0.03801425f, -0.03559819f, 0.38487139f, 0.05461585f, -0.00695240f, 
    -0.05528637f, 0.05430420f, 0.08563238f, -0.08572925f, 0.09953909f, 0.03431112f, -0.05579602f, -0.05843239f, 
    0.22699921f, 0.20835039f, 0.17232406f, -0.02460564f, 0.03414141f, 0.02100914f, 0.10569644f, -0.14844099f, 
    -0.12403551f, 0.07103831f, 0.01765277f, -0.02440334f, -0.09620242f, -0.15551901f, -0.03134384f, -0.09342177f, 
    -0.01529317f, -0.00454871f, 0.00743335f, -0.07168397f, -0.11390822f, 0.02422714f, -0.12586752f, 0.02526831f, 
    0.02186675f, 0.15164243f, 0.06540222f, 0.17855668f, 0.11708864f, 0.01923925f, 0.14338602f, -0.06994028f, 
    0.03234424f, -0.08045087f, 0.05173911f, 0.08351064f, -0.12251116f, 0.05078405f, 0.21358825f, 0.09051984f, 
    0.00328874f, -0.12350203f, -0.02285254f, -0.07125619f, -0.07472298f, 0.09863882f, -0.05738244f, 0.08394399f, 
    0.38629436f, 0.09629153f, 0.19884707f, -0.10697660f, 0.03344315f, -0.04257495f, 0.03227458f, 0.02097077f, 
    0.12537907f, -0.06852733f, 0.02838462f, 0.03547030f, 0.02998917f, 0.13217391f, 0.00512702f, 0.00547686f, 
    -0.12630571f, -0.02463902f, 0.06087532f, -0.00137606f, 0.17380171f, -0.07798068f, -0.00993593f, -0.01042752f, 
    -0.33162633f, 0.05866131f, 0.03233593f, 0.17107515f, 0.10191871f, 0.02701846f, 0.15596259f, -0.14403486f, 
    -0.06792611f, 0.11360113f, 0.02060880f, 0.00345331f, 0.45443690f, -0.23129033f, 0.04429683f, 0.18571144f, 
    0.13285761f, -0.07693008f, -0.03134676f, 0.13472742f, -0.16967373f, 0.02826241f, -0.00196945f, -0.07637111f, 
    0.05686940f, -0.00925743f, -0.00640755f, -0.05412903f, 0.05099187f, 0.02172752f, 0.09357709f, -0.00964092f, 
    -0.10813649f, -0.03830705f, -0.06765029f, 0.16674475f, -0.36787084f, -0.07875645f, -0.13667992f, -0.06041288f, 
    0.10530391f, -0.05816301f, 0.03069649f, 0.03367902f, -0.06670284f, 0.08151882f, -0.17036849f, 0.02724865f, 
    -0.03699907f, 0.11189710f, -0.01498752f, -0.18721299f, 0.04167460f, 0.11739457f, -0.00904834f, -0.08574519f, 
    0.00726153f, 0.00712691f, 0.00669409f, 0.16117884f, 0.35509929f, 0.14470059f, -0.04555515f, 0.09563127f, 
    -0.08690669f, 0.11410729f, 0.06520025f, 0.00320690f, -0.12357427f, 0.06633485f, 0.00893247f, 0.04460600f, 
    0.05432593f, -0.47856054f, 0.01200372f, 0.04671982f, -0.10112285f, 0.07845150f, 0.04427892f, -0.05257298f, 
    -0.08944784f, -0.01028264f, 0.12818460f, 0.10169663f, -0.17880289f, -0.02740279f, 0.05856947f, -0.07572789f, 
    -0.02440230f, 0.02915714f, 0.08035921f, -0.13943963f, -0.03371623f, 0.02886839f, -0.03391012f, 0.01030102f, 
    -0.07313184f, 0.08080053f, -0.05925547f, -0.13847125f, 0.02459775f, 0.08332713f, 0.00076655f, 0.02164368f, 
    0.00375337f, -0.02453970f, -0.08536528f, -0.20665021f, 0.06337920f, -0.17655072f, 0.03625660f, 0.05778735f, 
    0.07781122f, 0.04252221f, -0.08464179f, 0.04262726f, 0.03447057f, 0.01911388f, 0.06985077f, 0.11205854f, 
    0.13653138f, 0.06411520f, 0.06758486f, 0.22089845f, 0.10437160f, 0.02409107f, 0.01127873f, 0.01487062f, 
    0.03488376f, 0.06060926f, 0.06059043f, 0.00154445f, -0.03117242f, 0.00762828f, 0.10807838f, 0.00793521f, 
    -0.00329881f, 0.24082081f, -0.09925064f, -0.08258745f, 0.06762033f, 0.05188118f, -0.00684643f, 0.06246404f, 
    -0.20432566f, -0.07824402f, -0.11444362f, 0.16574685f, 0.04508435f, 0.10580239f, -0.02932646f, 0.13740425f, 
    -0.01392174f, -0.00844066f, 0.06858321f, -0.11033475f, -0.06902022f, 0.15291533f, -0.02166777f, 0.04868635f, 
    0.20525105f, 0.03248892f, -0.04127872f, -0.00005630f, 0.00305971f, -0.09502125f, -0.08451039f, -0.18320048f, 
    0.44707343f, -0.08864341f, -0.06025820f, 0.00708096f, -0.05115786f, -0.05266816f, -0.05646709f, 0.01087778f, 
    -0.00293825f, 0.01428980f, -0.00962825f, 0.19546957f, 0.16050072f, -0.03461104f, 0.16447130f, -0.09072234f, 
    -0.08360223f, -0.07742091f, -0.05384829f, 0.04055647f, 0.08326522f, 0.00116837f, 0.03182003f, -0.02082413f, 
    -0.21541218f, -0.09488923f, -0.04306208f, 0.00371749f, -0.08593906f, 0.00084319f, 0.09179268f, 0.00834556f, 
    0.09727012f, -0.00530716f, 0.07699867f, 0.15314387f, 0.01224626f, 0.07411230f, -0.18506680f, -0.00139676f, 
    -0.00905138f, -0.05599378f, 0.06487679f, 0.04092201f, 0.06380998f, 0.12862216f, -0.02730829f, -0.05838925f, 
    0.03299592f, 0.00368927f, 0.05948737f, -0.05023018f, -0.06253698f, 0.06442976f, 0.01458674f, 0.12071660f, 
    -0.08470754f, 0.10403365f, -0.07675140f, 0.12051626f, -0.18854140f, -0.09465434f, -0.07306717f, 0.05852170f, 
    0.12338217f, -0.06273364f, 0.13156855f, 0.08264126f, 0.10541979f, -0.09927834f, 0.12162475f, 0.12300272f, 
    0.31192830f, 0.11225288f, 0.00759000f, -0.14213821f, 0.02799600f, 0.14545842f, -0.02195843f, 0.00946139f, 
    -0.03794748f, -0.17657286f, 0.13708155f, 0.06727111f, 0.17116135f, 0.22169088f, -0.02217693f, 0.05010828f, 
    -0.10509989f, 0.09440365f, 0.14224331f, 0.01770462f, -0.01879809f, 0.01649025f, 0.00251151f, -0.05489579f, 
    -0.00105987f, -0.23227775f, 0.01102109f, -0.00624371f, -0.12157236f, -0.03114433f, 0.03829843f, -0.09140353f, 
    -0.04296366f, -0.07374851f, -0.02688563f, -0.06359165f, -0.06176990f, -0.04902045f, 0.03743290f, -0.18514219f, 
    0.11947880f, 0.13646506f, -0.00807856f, -0.01517482f, 0.03850894f, 0.06813421f, -0.08468249f, 0.10264780f, 
    -0.33536407f, 0.05343632f, -0.02139928f, 0.00797582f, 0.13829519f, -0.02710404f, 0.13697106f, 0.00353833f, 
    0.01985810f, -0.00610509f, 0.11216579f, -0.07960053f, 0.00131652f, 0.08746696f, -0.12365124f, 0.04599680f, 
    -0.02374222f, 0.04961322f, -0.01368782f, -0.02730573f, -0.07258177f, -0.02554256f, -0.00305899f, 0.14693925f, 
    -0.09371814f, -0.10979365f, -0.05974650f, -0.11906512f, 0.00087201f, 0.02003758f, -0.16645053f, -0.01111017f, 
    0.07455015f, -0.08268134f, -0.18497622f, 0.02372955f, -0.00532307f, 0.08986699f, 0.03562680f, 0.18156324f, 
    0.04677917f, 0.08901569f, -0.11472876f, 0.03365493f, 0.03262691f, 0.02774779f, 0.07705966f, 0.17004061f, 
    -0.07611269f, -0.03835121f, 0.18229024f, -0.12858948f, 0.05990848f, 0.00367441f, -0.13030383f, 0.00416884f, 
    -0.14229211f, 0.07683503f, 0.01408091f, -0.00469161f, 0.14014314f, 0.03367932f, 0.13101459f, 0.35508251f, 
    -0.12851043f, 0.04108531f, -0.11209817f, 0.01338935f, 0.09176684f, 0.03833406f, 0.01562245f, 0.11202969f, 
    -0.38079908f, 0.02838491f, 0.03238741f, -0.14692502f, 0.00518749f, 0.00250158f, 0.01465282f, 0.12269445f, 
    0.03063762f, 0.07953915f, -0.00110383f, 0.09802684f, -0.12538533f, 0.12981340f, -0.14629117f, 0.04580196f, 
    0.09554517f, 0.03070262f, 0.00034106f, 0.00470142f, 0.10976116f, 0.07609631f, 0.03447343f, 0.06891454f, 
    0.07404941f, -0.11509743f, 0.14549454f, -0.03579613f, 0.02210317f, 0.10435015f, 0.06450013f, -0.01927129f, 
    -0.07838351f, -0.05412059f, -0.00586564f, 0.13657840f, -0.17919503f, -0.02704964f, 0.22726345f, 0.25813806f, 
    -0.15616240f, -0.06876730f, -0.06468876f, 0.03188155f, 0.16687062f, 0.06129652f, -0.06434755f, 0.08203124f, 
    0.13290578f, -0.06176643f, -0.03695752f, 0.23904189f, -0.01101932f, -0.08031704f, -0.08194456f, 0.00853910f, 
    0.03692475f, 0.06965960f, -0.01140833f, 0.06855417f, 0.11053287f, 0.22050604f, 0.10060228f, 0.04128718f, 
    0.07245149f, 0.05748469f, 0.03488815f, -0.04747549f, 0.08541747f, 0.08054969f, 0.02313571f, 0.06876033f, 
    -0.07793577f, 0.05259031f, -0.07533721f, 0.20938726f, -0.11353021f, 0.01145841f, -0.00512596f, 0.01241066f, 
    0.05033004f, 0.02873403f, 0.00870119f, -0.05004860f, 0.02001236f, -0.04303973f, 0.09288988f, 0.18374260f, 
    0.04438471f, 0.12773757f, -0.10514724f, 0.00954097f, 0.05213696f, -0.13019182f, 0.02320320f, 0.06656797f, 
    -0.18829009f, 0.08392161f, -0.09831767f, 0.05562200f, 0.07196784f, -0.06146068f, 0.16238657f, -0.07296971f, 
    -0.07058759f, -0.04073704f, 0.01977932f, -0.02704619f, 0.29012737f, 0.06242228f, -0.08272265f, 0.09018889f, 
    0.10837151f, -0.11238540f, -0.08190884f, 0.06120920f, -0.00316093f, 0.01087512f, 0.08069285f, -0.08378705f, 
    0.00376518f, -0.06276775f, 0.02465934f, -0.06109483f, 0.00054504f, -0.07333904f, -0.06239398f, 0.05646953f, 
    0.02123089f, -0.06967002f, 0.00316189f, -0.03411705f, -0.05744962f, 0.02650255f, 0.06535438f, 0.05470150f, 
    0.01198669f, -0.04858131f, -0.00370018f, 0.02949596f, 0.05773864f, 0.06090055f, 0.06176310f, -0.07700285f, 
    0.05426149f, 0.03214547f, -0.03558651f, -0.06220720f, -0.06246844f, -0.00138298f, 0.01510712f, 0.03863019f, 
    -0.02371827f, -0.01215107f, -0.07697472f, 0.02530635f, -0.01360443f, 0.04015706f, -0.07690325f, -0.05410055f, 
    -0.07197890f, -0.02337837f, 0.05712706f, 0.02781084f, 0.03884242f, 0.05459474f, -0.04563700f, -0.02828785f, 
    0.01191165f, 0.06020521f, -0.00299865f, -0.00082842f, 0.01090994f, 0.03588705f, -0.02724878f, -0.07177071f, 
    -0.02157994f, 0.06009536f, -0.02933443f, -0.06099870f, 0.06532987f, -0.05914025f, 0.03641442f, -0.03219534f, 
    -0.05755854f, -0.00138826f, 0.00058731f, -0.04553583f, 0.05073615f, -0.00498176f, -0.06309513f, 0.01316326f, 
    -0.03870420f, -0.00623757f, 0.00811615f, 0.03054912f, -0.06333740f, -0.02021555f, -0.00514880f, -0.02614806f, 
    -0.03956424f, 0.03015284f, 0.03095287f, -0.04804332f, -0.07389193f, 0.05462828f, -0.03175266f, 0.04990008f, 
    -0.00110074f, 0.05972888f, -0.03630022f, -0.06457900f, 0.04638125f, -0.00124339f, 0.05204672f, -0.06338155f, 
    0.05151407f, 0.00169510f, 0.04491235f, 0.00197763f, -0.07031123f, -0.04670070f, 0.02266145f, -0.03664165f, 
    -0.03661977f, -0.05390149f, -0.00353293f, 0.04554119f, 0.02182637f, -0.02708217f, 0.01077421f, 0.04160628f, 
    -0.01182347f, -0.02244441f, 0.03992738f, -0.07693122f, -0.01553201f, -0.02306839f, -0.01376716f, -0.02279988f, 
    -0.07315705f, -0.01357867f, 0.02204966f, -0.01220598f, 0.01015352f, 0.00174603f, -0.03372204f, -0.02487660f, 
    -0.00916906f, -0.06603555f, -0.06101968f, 0.02784426f, -0.02391972f, 0.05196392f, -0.05287353f, -0.06719134f, 
    0.03318471f, 0.05416821f, 0.02938387f, -0.06643118f, -0.00729738f, -0.00724254f, -0.04967016f, 0.03373701f, 
    -0.00969600f, -0.02621373f, 0.05038927f, -0.03589822f, -0.04553070f, -0.07587446f, 0.03435271f, -0.05677220f, 
    -0.02762284f, -0.02573318f, -0.00625906f, -0.00955523f, -0.05464181f, 0.05126116f, 0.00670509f, 0.01192460f, 
    0.06111305f, -0.02402163f, -0.05155954f, -0.07581211f, 0.05028475f, -0.00832399f, -0.07039978f, -0.03461583f, 
    -0.05877749f, -0.04717292f, 0.04981405f, -0.07293433f, 0.04610545f, 0.05604176f, 0.03224577f, -0.06777854f, 
    0.03514814f, -0.05372700f, 0.01693577f, 0.03085270f, -0.00139894f, 0.03456387f, 0.00680898f, -0.01635538f, 
    -0.00638097f, -0.03612750f, -0.06834098f, 0.01600550f, -0.05165192f, -0.07974441f, -0.05762848f, 0.05450721f, 
    -0.24210833f, -0.06797972f, -0.10198449f, 0.08791488f, 0.09458746f, -0.02180507f, 0.06626508f, -0.06666026f, 
    0.07742288f, -0.07489761f, 0.09182398f, 0.23724300f, 0.38893375f, 0.25406697f, -0.00126299f, 0.08919605f, 
    0.01125361f, -0.08275375f, 0.13292071f, 0.05154085f, -0.06681962f, -0.14127465f, -0.08122803f, -0.01438075f, 
    0.07407826f, 0.07074552f, -0.09583768f, -0.08480427f, -0.05289968f, 0.06954298f, -0.02433543f, 0.01683082f, 
    0.04531444f, 0.07132608f, -0.00784773f, -0.08950627f, 0.11096805f, -0.13371021f, -0.08380429f, 0.04445820f, 
    -0.03280064f, -0.08946352f, 0.03877567f, 0.04009980f, -0.07464051f, 0.13536125f, -0.03748849f, -0.08905745f, 
    -0.22123778f, 0.10909662f, 0.01837342f, -0.00119036f, 0.03570811f, 0.00987012f, 0.04784118f, -0.03486393f, 
    0.10018296f, 0.02885276f, 0.01931162f, 0.23232190f, 0.18630563f, -0.24955435f, 0.00816535f, -0.16460225f, 
    -0.23068109f, 0.00597014f, 0.17240466f, 0.15356696f, 0.13465089f, 0.14107578f, 0.08387683f, 0.13083504f, 
    -0.35488805f, 0.01156706f, 0.04414630f, 0.08064368f, -0.01873158f, 0.05732612f, 0.01795928f, -0.00542885f, 
    -0.01088675f, 0.04177435f, 0.06055859f, -0.13943653f, -0.13422067f, -0.06855477f, -0.00261055f, 0.12857062f, 
    0.13991049f, 0.02762954f, -0.05319835f, -0.05085948f, -0.10258081f, 0.07676990f, 0.02134292f, 0.05121614f, 
    -0.16817717f, 0.13355350f, 0.02878487f, 0.04079649f, 0.07808221f, 0.01680653f, -0.14638883f, 0.07261582f, 
    0.13207707f, -0.01766635f, -0.01880396f, -0.08654194f, 0.09604131f, 0.11604483f, 0.19600217f, 0.01263041f, 
    -0.05805481f, 0.04029221f, -0.00503116f, -0.05814148f, -0.05653843f, 0.00550932f, -0.09782008f, 0.00818601f, 
    -0.04085789f, -0.09763585f, 0.10241843f, 0.06258746f, -0.01628876f, 0.01739304f, 0.01295177f, -0.02548411f, 
    0.01513573f, -0.07151236f, 0.02770167f, -0.10731123f, 0.15748557f, -0.04669165f, 0.10611860f, 0.00333801f, 
    -0.00868494f, 0.00837207f, 0.02817682f, 0.03777345f, -0.08760606f, 0.05002033f, 0.03280470f, -0.25302643f, 
    -0.00659384f, -0.17384370f, 0.12213818f, 0.14481659f, -0.02274967f, -0.16765636f, 0.21099751f, 0.02854914f, 
    -0.00993113f, 0.14287375f, -0.01279459f, -0.07116404f, -0.06733079f, -0.01127783f, 0.02088513f, -0.01481452f, 
    0.01810267f, 0.02970514f, -0.11285988f, 0.09379983f, 0.01563201f, -0.02757638f, 0.00675402f, 0.09169582f, 
    -0.04406399f, -0.09791963f, 0.01261455f, -0.03560976f, 0.09367251f, 0.19093449f, -0.03655540f, 0.07183779f, 
    0.01731718f, 0.10864393f, -0.03400252f, 0.04268810f, 0.20566371f, -0.03716835f, -0.03492514f, 0.26742843f, 
    -0.01550698f, -0.05545525f, -0.02831558f, 0.05867217f, -0.00715090f, -0.11165279f, 0.06820720f, 0.07649343f, 
    -0.28522140f, 0.08508093f, 0.01416775f, 0.06290817f, -0.00060933f, 0.01273511f, 0.12494796f, 0.10295960f, 
    0.01984349f, -0.06004700f, 0.16580659f, 0.09551204f, 0.11194631f, -0.16202055f, 0.06249633f, 0.24499160f, 
    -0.16081059f, -0.07685220f, 0.02558636f, 0.06723810f, 0.01785093f, -0.10282437f, 0.03970164f, 0.06515503f, 
    -0.07267895f, -0.13102908f, -0.00770924f, 0.26060119f, -0.06699724f, 0.05546905f, -0.06062673f, 0.04010376f, 
    0.11116920f, 0.01932993f, 0.06097171f, 0.19001243f, -0.00186598f, 0.12732410f, -0.09771556f, 0.08175391f, 
    0.00316467f, -0.09050512f, -0.12134978f, 0.15655778f, -0.04784924f, -0.05159447f, 0.10660665f, 0.13689475f, 
    0.08563058f, -0.20068470f, 0.01515088f, -0.12943819f, -0.04228459f, 0.10336260f, 0.03610587f, 0.04296426f, 
    -0.06795818f, 0.08359634f, -0.06181252f, -0.03511797f, 0.26888159f, 0.09439514f, -0.02211981f, 0.14515379f, 
    -0.08572865f, 0.14727649f, 0.10088989f, 0.07058793f, 0.06434891f, 0.05214070f, 0.11410565f, -0.04845643f, 
    -0.48807886f, -0.04327715f, 0.13614099f, 0.27737147f, -0.13017716f, 0.02246563f, 0.00764719f, 0.04962026f, 
    -0.03164470f, 0.09862877f, -0.11942098f, -0.03997819f, -0.02517319f, 0.09566946f, -0.21895427f, -0.17047051f, 
    0.06116186f, 0.07062519f, 0.13026054f, -0.14171799f, -0.08563232f, -0.01674056f, 0.14336765f, 0.05222717f, 
    0.08753715f, -0.18097740f, 0.15424205f, -0.46004903f, 0.03592116f, 0.07042950f, -0.11685100f, -0.00470988f, 
    -0.06793426f, -0.01765484f, -0.10904412f, 0.14876027f, -0.47190702f, 0.28726947f, 0.05063808f, 0.03009461f, 
    -0.01593281f, 0.04416206f, 0.05479836f, -0.05951601f, 0.20856310f, -0.07390568f, -0.11311450f, 0.02686493f, 
    -0.12795979f, -0.01037323f, 0.01265586f, 0.02876876f, -0.02833161f, 0.01752955f, 0.02654340f, -0.09711681f, 
    0.12713343f, -0.01202352f, -0.00532072f, 0.02066946f, -0.06915483f, 0.11812333f, 0.12666018f, 0.03652452f, 
    0.03453032f, 0.02711320f, 0.01561443f, 0.01633123f, 0.06067380f, 0.01021486f, 0.05534068f, 0.06555033f, 
    -0.34994775f, 0.11099226f, 0.02164118f, 0.19825576f, -0.01086979f, -0.01052338f, 0.00903948f, 0.07356259f, 
    -0.07023587f, 0.00549191f, -0.07093192f, 0.01645434f, -0.10008185f, -0.15410845f, 0.19234534f, -0.11920660f, 
    0.05228607f, 0.01889044f, -0.15610453f, 0.07403388f, 0.15225764f, -0.02102754f, 0.03404147f, 0.01277672f, 
    0.04318963f, 0.38035184f, -0.03120720f, 0.06650619f, 0.15570161f, -0.10910621f, 0.05136300f, 0.11348929f, 
    -0.05767110f, -0.08314602f, -0.07784250f, 0.00758828f, -0.08315304f, 0.08184078f, -0.14692113f, -0.01227912f, 
    -0.11631633f, -0.06741172f, 0.09027619f, 0.13471742f, -0.01373244f, 0.04812793f, 0.04162816f, -0.06974292f, 
    -0.13031182f, 0.01827092f, -0.31437162f, 0.04003905f, -0.03056109f, -0.00703262f, -0.01655639f, -0.02397262f, 
    -0.01361427f, -0.02637192f, 0.07793371f, 0.08033499f, -0.07093817f, 0.08522468f, -0.20538722f, -0.01708518f, 
    0.17220888f, 0.11085633f, 0.01443976f, 0.04836877f, 0.03226899f, -0.01252225f, -0.07269175f, 0.12849520f, 
    -0.03154811f, -0.02866982f, -0.09133564f, -0.41245160f, 0.01980346f, -0.00937903f, 0.06840198f, -0.01917493f, 
    -0.07269701f, 0.02492379f, -0.04071389f, 0.02214743f, 0.14087999f, -0.14522123f, 0.04287717f, 0.02167765f, 
    -0.04903413f, 0.07583798f, 0.04134448f, -0.09171273f, -0.08011787f, 0.12592636f, -0.11988019f, -0.08540426f, 
    -0.32813549f, 0.13027482f, 0.02972722f, 0.03717877f, 0.11002365f, -0.03503082f, -0.06272783f, 0.04044944f, 
    0.06229190f, 0.03420604f, 0.13765697f, 0.01097076f, -0.16685487f, -0.09102421f, 0.11522489f, 0.00712649f, 
    -0.04783320f, -0.09778928f, 0.04832787f, -0.07860339f, 0.01550706f, 0.00537334f, 0.06622987f, 0.16796541f, 
    0.06028597f, 0.23575561f, -0.11429168f, -0.28734607f, 0.06432789f, -0.07789357f, -0.11442029f, 0.12098257f, 
    -0.06446166f, 0.03717196f, 0.17772992f, 0.08664467f, -0.14215234f, -0.07639873f, 0.03056348f, 0.12837902f, 
    0.16150741f, 0.04503477f, -0.03857861f, 0.15108386f, 0.17023720f, 0.04114839f, 0.02266019f, 0.09744412f, 
    -0.06336371f, 0.10130329f, -0.04961430f, 0.11886720f, -0.03935833f, 0.02651859f, 0.02387142f, 0.02843011f, 
    0.12156662f, -0.02800035f, 0.13590994f, -0.00367916f, 0.12699822f, -0.05249491f, 0.04533393f, 0.09852853f, 
    -0.15475212f, -0.07147994f, 0.01819957f, 0.11898081f, -0.02882349f, 0.13108531f, -0.01508378f, -0.09994818f, 
    0.23143815f, 0.12235747f, 0.16735329f, 0.03988779f, 0.08468052f, 0.01973273f, -0.11705314f, 0.02104338f, 
    -0.04220770f, -0.01651771f, 0.11999200f, 0.12064489f, 0.13787737f, 0.04343436f, -0.10506412f, -0.01311539f, 
    0.10696419f, -0.04713172f, -0.00159517f, -0.03731119f, -0.05592511f, -0.01504569f, 0.00667791f, -0.00958563f, 
    0.10386387f, -0.14600445f, -0.08741660f, 0.14785545f, 0.04638511f, 0.03533588f, 0.18579035f, 0.08143102f, 
    0.07744972f, 0.01311515f, 0.07495623f, -0.11352225f, 0.04728745f, 0.03047900f, 0.07551900f, 0.23017521f, 
    0.08993016f, 0.13468902f, 0.01532041f, -0.04760417f, 0.05936052f, 0.03008048f, 0.10525861f, 0.11294194f, 
    -0.27708873f, -0.34638360f, -0.09384605f, 0.10966077f, -0.01268238f, 0.12683599f, -0.05064969f, 0.03195352f, 
    -0.08673925f, 0.11531574f, 0.01330204f, 0.00476067f, 0.25983989f, -0.00729121f, 0.04390684f, 0.21286169f, 
    0.14216183f, -0.02812201f, 0.01291996f, -0.02030994f, 0.04867247f, -0.02544871f, 0.02887207f, 0.03620955f, 
    -0.40611672f, 0.19970663f, 0.12393774f, -0.14698680f, 0.16285536f, 0.05101987f, -0.05734469f, -0.00368839f, 
    -0.05320844f, 0.07886530f, -0.00457935f, -0.03554529f, 0.16519056f, 0.31823114f, 0.02149563f, 0.11661634f, 
    -0.17873161f, 0.04801210f, 0.00167415f, 0.11682331f, -0.10019600f, 0.04353668f, -0.00210652f, 0.04305414f, 
    0.21906660f, 0.03021633f, -0.00680180f, 0.13266711f, -0.08085100f, 0.10258841f, -0.12491822f, 0.09368153f, 
    -0.01878992f, -0.09286699f, -0.05131323f, -0.10353109f, 0.16171478f, -0.07863300f, 0.07225807f, -0.06311559f, 
    0.17303824f, 0.03254571f, 0.05287878f, 0.12639537f, 0.16164425f, 0.06691751f, 0.09834138f, 0.05001333f, 
    -0.09397753f, 0.04601870f, -0.04717546f, 0.22128390f, 0.07601619f, 0.01208030f, -0.04707970f, -0.15012129f, 
    -0.02896933f, -0.05235245f, -0.04883352f, 0.02955253f, 0.13304253f, -0.02890443f, 0.26182404f, 0.05060833f, 
    -0.14992434f, -0.10892251f, 0.07595915f, 0.01777593f, 0.04301392f, 0.01349034f, -0.06689596f, 0.00495137f, 
    -0.31872791f, -0.13888623f, 0.02241386f, 0.00888629f, -0.01319316f, 0.00604195f, 0.11268578f, -0.05948858f, 
    0.18047009f, 0.11149266f, 0.01528237f, -0.03236676f, 0.02072872f, -0.00428209f, -0.01700805f, -0.03552111f, 
    0.07135958f, -0.01665280f, 0.00914514f, -0.16429068f, 0.06624782f, 0.07167362f, 0.03886192f, 0.02094059f, 
    -0.21193333f, 0.05722466f, 0.10062731f, 0.11552461f, 0.10616960f, 0.05134370f, 0.09704299f, 0.05286849f, 
    0.05312625f, 0.05582713f, -0.02763463f, 0.10542186f, -0.08577962f, -0.17084494f, 0.26743522f, 0.14163689f, 
    -0.05726189f, -0.01063105f, 0.00437257f, -0.07192119f, 0.08047373f, 0.03495697f, 0.01807930f, -0.03688258f, 
    -0.13767730f, -0.12541741f, 0.00163133f, 0.03589637f, -0.10161944f, -0.07411876f, -0.09096857f, -0.03986583f, 
    -0.03909705f, 0.07391632f, -0.00364981f, 0.01249928f, -0.01074704f, -0.04944799f, 0.01620126f, 0.24116267f, 
    0.07858736f, 0.06275504f, 0.05662591f, 0.03331589f, 0.09095250f, 0.18525435f, -0.06476722f, -0.02333418f, 
    0.06680305f, 0.01874107f, -0.02898821f, -0.16888134f, 0.06343544f, -0.05165512f, -0.02371092f, -0.09864378f, 
    0.10018778f, 0.08181730f, 0.04095604f, -0.05110331f, 0.08557474f, -0.02647557f, 0.07576637f, 0.08064011f, 
    -0.16948591f, -0.06873101f, -0.02528039f, -0.00080330f, -0.08689648f, -0.08854466f, 0.05091326f, 0.15702435f, 
    -0.06528577f, -0.02146428f, -0.00158002f, -0.08028086f, 0.15767057f, 0.02839082f, 0.10613922f, -0.08939489f, 
    0.05760446f, -0.08679000f, 0.04004057f, 0.04402964f, 0.09128308f, 0.17605060f, 0.13077797f, -0.05246178f, 
    0.09283574f, -0.06983617f, 0.06223221f, 0.04697978f, -0.00659250f, -0.06085193f, 0.02717146f, -0.01808831f, 
    0.04828016f, 0.02106741f, 0.04863835f, -0.11100169f, 0.02097708f, -0.06368220f, 0.05158301f, 0.02936473f, 
    0.10429993f, -0.02013620f, 0.03680231f, -0.00539565f, 0.27504000f, -0.29927272f, 0.05197807f, 0.16439481f, 
    0.02313361f, -0.02311523f, -0.03041111f, 0.06544837f, -0.09815496f, 0.07895416f, 0.11327613f, 0.12192544f, 
    0.19488052f, 0.11845700f, 0.11280659f, 0.05327383f, -0.10728601f, -0.08786339f, 0.02224151f, 0.05097192f, 
    0.07897206f, 0.09396241f, -0.04089345f, 0.06127939f, 0.07636373f, 0.22208127f, 0.00155140f, 0.19525959f, 
    -0.01302172f, 0.10498700f, 0.07656581f, -0.19129671f, 0.15926205f, 0.05019424f, 0.03285624f, 0.01993099f, 
    0.08686748f, 0.05375722f, -0.21520418f, -0.07404436f, -0.08370390f, 0.15439238f, -0.09075867f, 0.14832182f, 
    -0.02732762f, 0.08390149f, 0.13884796f, -0.09271757f, -0.03391894f, 0.15119687f, 0.09303053f, 0.10682578f, 
    0.13295054f, 0.12364655f, 0.02321936f, -0.05033385f, 0.05169214f, -0.17559612f, -0.09928362f, -0.04359667f, 
    0.28884923f, -0.19604012f, -0.10868378f, -0.05202924f, -0.00246624f, 0.07217335f, -0.04066290f, -0.13977650f, 
    -0.02695373f, 0.01219591f, 0.02165505f, 0.08028624f, 0.13784856f, -0.31667215f, 0.21354486f, -0.19519836f, 
    -0.07322899f, -0.02538249f, -0.14601107f, 0.05353405f, -0.00911641f, -0.01440029f, -0.03253749f, 0.09215064f, 
    0.07730570f, -0.12140541f, -0.02710113f, 0.05692504f, -0.04960305f, 0.02280006f, -0.12886198f, 0.16658507f, 
    0.01117068f, -0.07688527f, 0.03367058f, -0.01964994f, 0.09882533f, 0.25255439f, -0.20180224f, 0.02086169f, 
    -0.15474185f, -0.06087005f, 0.04067584f, -0.03604144f, 0.09958917f, 0.01612199f, -0.03565032f, 0.00993558f, 
    -0.09469093f, -0.17845550f, -0.03772051f, 0.31605434f, -0.07177144f, 0.00929854f, 0.05246051f, 0.00001842f, 
    -0.03959107f, 0.10191437f, -0.05021362f, 0.08086602f, 0.02618876f, 0.10023328f, -0.03062523f, 0.14186132f, 
    0.05060880f, -0.18983668f, 0.10978286f, 0.01571213f, -0.11578152f, -0.16210797f, 0.07093021f, 0.10998110f, 
    0.30638048f, -0.03973549f, 0.03499988f, -0.05328578f, 0.00587034f, 0.01000689f, 0.07498739f, -0.04303277f, 
    -0.08116454f, -0.06650298f, -0.04595613f, -0.16115721f, 0.04598250f, -0.08404265f, 0.14252575f, 0.17601332f, 
    -0.04671206f, -0.00059748f, 0.22115552f, -0.17470150f, 0.01777545f, 0.15197425f, -0.01561235f, -0.00886804f, 
    -0.07826811f, 0.18857545f, 0.09423067f, 0.10336922f, 0.04923997f, -0.08022289f, 0.05054873f, 0.01920772f, 
    0.00799606f, 0.11931168f, -0.12834710f, -0.07165040f, -0.00091555f, 0.11506535f, 0.02244189f, -0.15363474f, 
    0.16270667f, 0.12011290f, -0.11380935f, -0.01188034f, 0.09468554f, 0.09860265f, -0.07839616f, -0.11517829f, 
    -0.17428008f, -0.05992319f, 0.16557331f, 0.09914237f, 0.04397639f, 0.03992750f, 0.00722363f, -0.00922998f, 
    0.13088125f, -0.08765496f, 0.09623567f, 0.15250221f, 0.04904889f, 0.20072578f, -0.03264512f, 0.13029744f, 
    -0.08279136f, -0.09043825f, -0.06590508f, -0.03544309f, 0.12723166f, -0.12637512f, -0.09672678f, -0.11705799f, 
    0.23931602f, 0.06486253f, 0.01871371f, 0.10076930f, -0.01566184f, -0.12971061f, -0.03131098f, 0.01684950f, 
    -0.08698678f, 0.15296027f, 0.14297557f, 0.09768613f, -0.03340541f, 0.02922904f, -0.15599488f, 0.11373346f, 
    -0.11789262f, -0.06207458f, -0.10003795f, 0.16679761f, -0.02080996f, -0.03372677f, 0.03319932f, -0.10703572f, 
    0.04926744f, -0.14796962f, 0.25765920f, -0.33707383f, 0.09346633f, 0.05989742f, 0.08534228f, -0.05324008f, 
    -0.05594260f, 0.13465002f, 0.09463412f, 0.15579061f, 0.04447570f, 0.02963945f, -0.12707436f, -0.28927180f, 
    0.00125436f, 0.05298863f, -0.06750537f, 0.06391874f, -0.04095005f, 0.19684824f, -0.01500865f, 0.07294328f, 
    -0.06926252f, 0.01113368f, 0.18171994f, 0.05881758f, -0.03912997f, -0.03067248f, 0.05991826f, 0.01534208f, 
    0.01182453f, 0.06325102f, -0.09010065f, -0.05992150f, 0.03211948f, 0.12552437f, -0.21094206f, 0.04156989f, 
    0.11190660f, 0.15709326f, 0.08855747f, -0.03817943f, 0.03045860f, -0.07612748f, -0.07949792f, 0.00695967f, 
    0.04979374f, -0.07630911f, 0.09764376f, -0.26849005f, -0.10437017f, 0.07272787f, 0.06652842f, -0.10802524f, 
    0.08538847f, -0.02487322f, -0.07838719f, 0.02630345f, 0.14466335f, 0.02420987f, -0.07599669f, -0.02237663f, 
    0.10403882f, -0.01358791f, 0.01246588f, 0.00943652f, -0.02547742f, -0.03158462f, 0.09566822f, 0.03772001f, 
    -0.00993382f, -0.12551874f, -0.04017461f, -0.34228271f, 0.19910292f, 0.01840454f, 0.13004355f, 0.09466896f, 
    0.21006508f, -0.07024959f, 0.04842618f, -0.06099095f, 0.05731603f, 0.07677350f, -0.08081206f, -0.14314657f, 
    -0.10185731f, 0.03548592f, -0.07053635f, -0.03426067f, 0.00445774f, 0.15049639f, -0.01941499f, -0.06650198f, 
    -0.36702469f, 0.22563368f, 0.02397786f, 0.34707493f, 0.08804323f, -0.14974709f, 0.05645058f, 0.10364780f, 
    0.06476159f, 0.12931669f, -0.04461517f, 0.05086933f, 0.02823319f, -0.05363102f, -0.17593701f, -0.16752584f, 
    0.05890737f, -0.04737072f, -0.15138558f, -0.07526600f, 0.18762970f, 0.03089602f, -0.00046077f, 0.05244432f, 
    0.06777754f, -0.03705665f, -0.22621301f, 0.16911006f, -0.04269779f, 0.16949800f, -0.07435934f, 0.06269709f, 
    -0.06538756f, 0.12954271f, 0.04947416f, 0.13361973f, -0.19779725f, 0.07611760f, -0.02024148f, -0.12579402f, 
    -0.11610781f, -0.12062067f, 0.03149178f, 0.11564111f, 0.02897189f, -0.00751140f, -0.01171671f, -0.09036329f, 
    0.29842082f, 0.01287552f, -0.05979996f, 0.00753881f, 0.00957054f, -0.03035891f, -0.05414389f, -0.01901368f, 
    0.10824768f, -0.07651352f, -0.06162665f, 0.10734244f, 0.16294037f, -0.07410262f, 0.15176792f, 0.01604773f, 
    0.18216926f, 0.04405682f, -0.00381107f, -0.01448130f, 0.03676645f, -0.05043020f, -0.03878069f, -0.02314019f, 
    0.19220233f, 0.06754681f, 0.09637554f, -0.05257697f, 0.00975650f, -0.06963532f, 0.12674314f, -0.04699494f, 
    -0.01023873f, 0.12719595f, 0.07893290f, -0.01629604f, -0.10120896f, -0.09457724f, -0.05839073f, -0.11019590f, 
    -0.19436075f, 0.01937546f, -0.01040169f, -0.04277235f, -0.00854886f, 0.13795982f, -0.08774810f, -0.03658878f, 
    0.03880396f, 0.00667109f, 0.10899741f, 0.00827931f, 0.16282558f, -0.01094252f, 0.13974035f, 0.05457733f, 
    0.17615223f, 0.03720098f, 0.05611732f, 0.02593322f, -0.14727303f, 0.22362660f, -0.13496666f, -0.30127585f, 
    0.09060095f, -0.08415145f, 0.04423035f, 0.03948269f, 0.00047025f, 0.03791865f, 0.00147205f, 0.09233075f, 
    0.44563183f, 0.08024124f, 0.02464401f, -0.07208049f, 0.02909449f, -0.01697068f, 0.07180740f, 0.01504971f, 
    -0.04298887f, -0.09094863f, 0.05391573f, 0.04288171f, 0.14088896f, -0.18399084f, 0.19737045f, 0.08375500f, 
    -0.01549240f, -0.03923479f, -0.01702669f, 0.15187711f, 0.13657142f, -0.08525198f, -0.08707880f, 0.02690345f, 
    -0.09755201f, 0.14281036f, -0.04462340f, 0.12496152f, -0.13239460f, -0.00569751f, 0.02552639f, -0.02336689f, 
    -0.00513628f, -0.00755899f, -0.00370611f, -0.09307320f, 0.31035900f, 0.10472047f, -0.21678081f, -0.05696078f, 
    0.08969893f, -0.10433077f, 0.09627832f, 0.04344288f, -0.15373088f, 0.05616690f, 0.03466353f, 0.00053536f, 
    0.16165613f, 0.10560596f, -0.05711688f, -0.14679404f, 0.16468494f, 0.17578572f, 0.15994459f, 0.00889023f, 
    0.02472005f, -0.04131024f, 0.03164948f, 0.01285277f, 0.04345916f, 0.01609889f, -0.18270248f, -0.19559427f, 
    0.03958726f, -0.16792317f, -0.01998442f, -0.19571331f, -0.09518686f, -0.07997826f, -0.11706900f, 0.02532888f, 
    0.08845281f, -0.06911735f, 0.05871447f, -0.12397391f, 0.06667711f, 0.09570947f, 0.04374517f, 0.07124097f, 
    -0.06991088f, -0.03790560f, 0.12306249f, 0.05058110f, 0.16904888f, -0.01503780f, -0.24061711f, 0.01217884f, 
    0.00323644f, -0.04035191f, 0.15015024f, -0.15030807f, 0.08447058f, 0.07367013f, -0.03348810f, -0.07174589f, 
    0.01129110f, -0.40379572f, -0.00251171f, -0.03333119f, -0.15503331f, 0.15184055f, -0.07645782f, -0.04304002f, 
    0.05504087f, 0.13646077f, -0.01445636f, 0.02324795f, -0.02773420f, -0.03876308f, 0.05362920f, -0.03539446f, 
    -0.03006946f, 0.02530392f, -0.07146649f, -0.03304836f, 0.03047793f, 0.04730991f, -0.06307969f, 0.11737423f, 
    0.00803368f, -0.04910969f, -0.02786907f, -0.06910214f, -0.05198788f, -0.05885332f, 0.04928105f, -0.04425979f, 
    0.03917585f, -0.05451690f, 0.06005750f, -0.06841325f, -0.03459997f, -0.03275422f, -0.02364433f, -0.01306672f, 
    -0.02652267f, -0.01669382f, 0.03358891f, -0.07935602f, -0.03426671f, 0.03581309f, -0.04387202f, -0.07405565f, 
    -0.04293729f, -0.05718965f, 0.02989450f, -0.04743921f, 0.00235579f, -0.02162288f, -0.08296787f, -0.06627448f, 
    -0.00931562f, -0.04624274f, -0.00161939f, -0.06711000f, 0.02576943f, -0.00842215f, 0.03672059f, -0.07087552f, 
    -0.07384633f, -0.00878257f, -0.07931291f, 0.03201757f, 0.00211425f, 0.00591105f, -0.02384113f, -0.03093210f, 
    0.05959773f, 0.00722060f, 0.05070497f, -0.00119416f, 0.02161689f, -0.03972459f, -0.03510532f, 0.01292488f, 
    0.04119365f, -0.07130773f, 0.04404356f, 0.01177505f, -0.01531543f, 0.03548343f, 0.00930909f, 0.04554800f, 
    0.00425513f, -0.05376272f, 0.02139753f, 0.03758227f, 0.03247136f, 0.02828424f, 0.04488457f, -0.00859904f, 
    0.04958666f, 0.03923063f, 0.05551509f, -0.07497769f, 0.05592329f, 0.03568495f, 0.01696386f, 0.04572879f, 
    0.01697981f, -0.05696660f, 0.00747490f, -0.00875170f, -0.07691002f, -0.00691970f, 0.03180637f, -0.02076734f, 
    -0.05583998f, -0.06274516f, -0.04736454f, 0.04897380f, 0.04591050f, 0.06146567f, -0.05850545f, 0.03270718f, 
    0.03316554f, 0.03536295f, 0.04847077f, -0.04158824f, -0.07779153f, 0.01896493f, -0.03970351f, 0.01164922f, 
    0.05156089f, -0.07107896f, -0.05933306f, 0.02848312f, -0.04033096f, 0.04669569f, -0.03428930f, 0.05233879f, 
    -0.03881141f, -0.03377503f, 0.02878612f, 0.03850881f, 0.01174644f, -0.05988804f, 0.00234738f, -0.06155580f, 
    -0.03842796f, 0.06192097f, -0.02783215f, -0.00682414f, 0.04604576f, -0.02129512f, -0.08280277f, 0.00564321f, 
    -0.04756913f, -0.03695201f, -0.03601177f, -0.02867472f, 0.01822814f, -0.02147521f, 0.01828779f, -0.01933980f, 
    -0.01739392f, -0.00704701f, -0.05981290f, 0.05668651f, -0.05177088f, 0.04610664f, -0.06898551f, -0.04539954f, 
    0.02153831f, -0.04875223f, -0.03616450f, 0.04226903f, 0.02402416f, -0.06821080f, -0.00099309f, -0.04069507f, 
    0.00167237f, -0.05322292f, 0.04778026f, 0.01731566f, -0.01703817f, -0.01836763f, -0.07665948f, 0.01818886f, 
    -0.06279457f, -0.04516650f, 0.04127556f, 0.03203030f, 0.03909633f, -0.04184813f, -0.00733914f, 0.03653380f, 
    0.02207093f, -0.03041342f, -0.00547426f, -0.06625074f, -0.03526558f, -0.07403010f, 0.01099495f, -0.02539499f, 
    -0.07302660f, 0.00562428f, 0.03784936f, 0.04259758f, -0.06524099f, -0.04829689f, -0.03830509f, 0.00169575f, 
    0.00992407f, 0.04191559f, -0.00675530f, -0.07461228f, 0.05284515f, -0.02398641f, 0.00863079f, -0.00027900f, 
    0.24042170f, -0.18609439f, -0.04671977f, 0.00979180f, -0.06894322f, 0.03368137f, -0.00170598f, -0.00241563f, 
    -0.00010027f, 0.05939489f, 0.03227499f, 0.03327244f, -0.26185879f, 0.22898088f, 0.09570315f, -0.27008188f, 
    -0.05836700f, -0.04039401f, 0.07810054f, 0.06344061f, 0.01113770f, 0.01955759f, -0.05762269f, -0.07942294f, 
    -0.33996654f, 0.11397002f, -0.04262074f, -0.24420550f, -0.00465330f, 0.15308134f, -0.03381060f, 0.10356767f, 
    0.00338152f, 0.04157374f, 0.05345760f, 0.07468584f, 0.09763253f, -0.02374343f, -0.03653354f, -0.00302041f, 
    0.02979954f, -0.15285586f, 0.01356367f, 0.21268213f, -0.12384831f, 0.08237649f, 0.00304247f, 0.04493667f, 
    0.18284662f, -0.09692744f, 0.02385497f, 0.11244322f, 0.00831662f, -0.06379150f, 0.12911169f, -0.04360150f, 
    -0.08770084f, 0.01868032f, -0.10207393f, 0.14856073f, 0.07463695f, -0.15205869f, 0.11408472f, -0.02674071f, 
    -0.01236959f, 0.07507771f, 0.18247104f, 0.03580254f, -0.04570981f, 0.05610770f, 0.04886081f, 0.14768413f, 
    -0.09825078f, 0.21174604f, 0.28930017f, -0.08342304f, -0.01044973f, 0.10208399f, -0.02377297f, 0.03896100f, 
    0.10455111f, -0.02078160f, 0.02296238f, -0.10077272f, -0.16613637f, -0.00967331f, -0.08876300f, 0.16151474f, 
    0.06804813f, 0.09982273f, 0.04809972f, 0.07702418f, 0.11429637f, 0.07315250f, 0.00814927f, 0.08971307f, 
    0.09907211f, 0.22390071f, 0.07969028f, -0.02562530f, 0.17791891f, 0.05814384f, 0.04145833f, 0.02604049f, 
    0.09770810f, -0.01047190f, -0.11784460f, -0.05782613f, -0.22970249f, -0.09017842f, 0.34326813f, -0.05923526f, 
    0.10416946f, 0.11059898f, -0.05318524f, 0.07111560f, 0.01904725f, -0.07092246f, -0.14018026f, 0.02809083f, 
    -0.12297152f, 0.19680595f, 0.12632640f, -0.16600372f, 0.01378730f, 0.03946279f, 0.01657830f, 0.06487279f, 
    -0.00772426f, -0.14139417f, 0.16434892f, 0.05370315f, 0.05792553f, 0.06842525f, 0.12417755f, 0.12809147f, 
    -0.00226378f, 0.14139336f, 0.05144271f, 0.05526545f, -0.11316096f, 0.10391258f, 0.00619383f, -0.13625240f, 
    -0.38404876f, -0.13844718f, 0.17556922f, 0.06951974f, 0.04674136f, -0.11741859f, 0.07430971f, 0.11247589f, 
    0.07583064f, 0.13962056f, -0.03032210f, 0.05954705f, -0.24148014f, 0.09837989f, 0.05287170f, -0.19805597f, 
    0.09628946f, -0.01745380f, -0.16442893f, 0.09991046f, -0.08751983f, -0.09930617f, 0.06840415f, 0.13495621f, 
    0.25822443f, 0.05230780f, -0.12655717f, -0.01297150f, 0.06138005f, 0.09668027f, -0.04806031f, 0.11224817f, 
    0.01180009f, 0.06833045f, -0.03334270f, -0.03457782f, 0.12580553f, -0.13159281f, -0.13679698f, 0.18652615f, 
    -0.01462806f, -0.09829734f, 0.14951201f, 0.11357974f, 0.03822985f, -0.02923462f, 0.04353913f, 0.01608937f, 
    0.15082709f, -0.08541641f, -0.02013449f, 0.09034607f, -0.03235884f, 0.12765568f, 0.02088230f, 0.02939531f, 
    0.04561237f, 0.00711918f, 0.12997092f, -0.02356473f, -0.39793679f, 0.29110616f, -0.15937586f, -0.20453177f, 
    -0.09312563f, 0.11093283f, 0.02720372f, -0.05473268f, 0.04737699f, -0.01216774f, -0.11345273f, 0.13710427f, 
    -0.37683195f, -0.14899196f, -0.02414650f, -0.23348953f, 0.00260741f, -0.05382461f, -0.11931122f, -0.13023622f, 
    -0.01069172f, -0.05654223f, -0.04342670f, 0.20192356f, 0.03236362f, 0.07590606f, -0.00276942f, 0.05936648f, 
    0.02881937f, 0.04344736f, -0.10203321f, 0.04362598f, -0.03828934f, -0.11272187f, 0.02664844f, 0.09499269f, 
    0.19790144f, -0.11458293f, 0.22203298f, -0.14696710f, 0.01447462f, -0.08252846f, -0.10067555f, -0.05391948f, 
    -0.05863979f, 0.01576828f, 0.03837569f, -0.00817613f, -0.11606508f, -0.02436723f, -0.01330894f, 0.38970479f, 
    -0.01585729f, -0.04068318f, -0.08444162f, -0.00028028f, -0.07934306f, 0.05328910f, 0.04629925f, 0.10604393f, 
    -0.04615902f, 0.17872626f, 0.21818979f, -0.15882446f, 0.06112150f, 0.02153076f, -0.03495504f, 0.07235581f, 
    0.02425777f, 0.06266285f, -0.06756683f, -0.01502633f, -0.10682761f, 0.14609997f, -0.11185763f, 0.10828464f, 
    -0.00433047f, 0.04351262f, 0.06766758f, 0.11325467f, 0.15562008f, -0.00161342f, 0.06216500f, 0.07151917f, 
    0.16186550f, -0.06268702f, 0.08527609f, -0.18921888f, -0.00239150f, 0.10507659f, 0.02651455f, 0.09959128f, 
    -0.06168677f, 0.09231659f, 0.06114889f, 0.07636154f, -0.15020618f, -0.13749808f, 0.20928542f, 0.04410047f, 
    0.10488560f, -0.06919016f, 0.05471054f, 0.00968149f, -0.01317604f, 0.12248619f, -0.05026656f, 0.09043541f, 
    0.05547541f, 0.07938682f, 0.01967406f, 0.02332572f, 0.03257927f, -0.00462312f, -0.06057446f, 0.08934999f, 
    -0.07142466f, 0.06494936f, -0.02657071f, 0.09760075f, -0.11097261f, 0.25156987f, 0.02769538f, 0.01012456f, 
    -0.03767134f, 0.23581854f, -0.02433289f, 0.02181341f, 0.09437591f, 0.14792866f, -0.02661874f, 0.13179861f, 
    -0.28207853f, 0.11335427f, -0.08982237f, 0.08309697f, -0.11509149f, 0.09514353f, -0.07598388f, 0.01773026f, 
    0.08674811f, -0.03126131f, 0.03927300f, 0.14074185f, 0.06056200f, 0.03098570f, 0.06268775f, 0.11513206f, 
    0.18269314f, 0.13765849f, -0.06970023f, 0.04604629f, 0.05045765f, -0.06112410f, 0.14194946f, -0.04531145f, 
    -0.08789667f, 0.21384077f, -0.18211311f, -0.01452557f, -0.05227797f, -0.08381142f, -0.00920784f, -0.11900794f, 
    -0.06196236f, -0.07431848f, 0.04257293f, -0.00812279f, 0.03711109f, 0.09665643f, -0.15146470f, 0.04764323f, 
    -0.00756538f, 0.04785695f, 0.03294203f, 0.01893935f, -0.05345017f, 0.12567952f, 0.01040217f, 0.01424930f, 
    0.00450410f, -0.06616058f, -0.07272531f, 0.04460946f, -0.01304582f, -0.01804490f, 0.02342938f, -0.01328203f, 
    0.03734620f, -0.00762065f, -0.04882580f, -0.00003141f, 0.03804221f, 0.04766157f, -0.01569577f, -0.07492561f, 
    -0.00257528f, 0.03273047f, 0.01595113f, 0.00903518f, -0.04500818f, 0.04625659f, 0.06273052f, 0.01011417f, 
    0.04582129f, 0.03207875f, 0.05565565f, -0.07646073f, -0.07795391f, -0.06130164f, 0.01578855f, 0.00041606f, 
    -0.06799266f, -0.04538983f, -0.01697277f, 0.01325633f, -0.07872521f, -0.04212488f, -0.01280368f, -0.00951934f, 
    0.00253338f, -0.06334445f, 0.05221162f, -0.05392076f, -0.06469380f, -0.06319596f, 0.05968063f, -0.00763729f, 
    -0.00840241f, 0.03478198f, -0.07418513f, 0.00422904f, -0.07050677f, 0.04383083f, 0.03561799f, 0.01170507f, 
    0.05756296f, -0.04854989f, 0.00007559f, 0.04398138f, 0.04881281f, -0.01247898f, -0.04362405f, -0.03515980f, 
    0.04542515f, 0.04956670f, -0.04702943f, 0.04427453f, 0.03774981f, 0.03811858f, 0.03220119f, -0.02311671f, 
    -0.03297832f, 0.01823172f, 0.03619302f, -0.06517942f, -0.01574443f, 0.06138227f, 0.00724089f, -0.04875450f, 
    0.02291204f, 0.00039016f, 0.00331246f, -0.04513553f, 0.05354589f, -0.06405938f, 0.06020306f, -0.03764920f, 
    0.05101517f, 0.02772599f, 0.02906648f, -0.06758334f, -0.03777307f, -0.05091570f, 0.02504076f, -0.01076340f, 
    -0.04301328f, -0.01362192f, 0.05946120f, -0.03874667f, -0.03814545f, -0.03232863f, -0.06338593f, -0.04452827f, 
    0.03495236f, 0.06145827f, -0.06313130f, -0.02826909f, 0.01992193f, 0.03778208f, -0.04032614f, -0.03741811f, 
    -0.05767040f, -0.01700778f, -0.07307575f, -0.00905936f, 0.06332494f, -0.06009450f, 0.01137633f, 0.04309199f, 
    0.04718800f, -0.04269009f, -0.04440475f, 0.04384315f, 0.02841671f, -0.06579555f, 0.04691045f, -0.04211630f, 
    0.00389621f, -0.00115460f, -0.01442376f, 0.04058000f, -0.04688390f, 0.01387752f, 0.03717566f, 0.06138115f, 
    -0.04699437f, 0.05047022f, -0.03743869f, -0.00825625f, -0.03452123f, 0.01588027f, -0.02845280f, -0.04958957f, 
    -0.06670618f, -0.05505195f, -0.04576973f, -0.02641709f, -0.02617542f, -0.03536123f, 0.05286863f, -0.01777944f, 
    -0.04033544f, 0.01132275f, -0.02311398f, 0.01389663f, 0.00787258f, -0.02089416f, 0.01994849f, -0.06304356f, 
    -0.05712931f, -0.03996544f, -0.02154733f, -0.04047960f, 0.00290030f, -0.01269216f, 0.01122967f, -0.01103622f, 
    -0.02701253f, 0.00520268f, 0.00111223f, 0.02400830f, -0.03493841f, 0.00283809f, -0.00773238f, -0.01041209f, 
    -0.01651644f, -0.03782107f, 0.05422961f, -0.07753064f, -0.06885426f, -0.00919187f, 0.01090552f, -0.01671767f, 
    0.06201902f, -0.06013516f, -0.02935864f, -0.01980865f, 0.03945490f, 0.02916468f, -0.04046649f, 0.00638262f, 
    -0.36979648f, -0.17660186f, -0.19489208f, 0.15134160f, -0.17500076f, 0.04898435f, 0.00539219f, 0.04495892f, 
    0.04599228f, 0.05594039f, -0.06246639f, -0.31866550f, -0.02744618f, 0.09205249f, -0.07181349f, 0.00991903f, 
    0.25210655f, -0.01862336f, 0.04472476f, -0.03927578f, -0.10789216f, 0.25975165f, 0.07405832f, 0.05385647f, 
    0.27317891f, 0.02582178f, -0.00733622f, -0.09039984f, 0.26034433f, 0.10432477f, -0.03077503f, -0.05172355f, 
    0.06818323f, -0.04022608f, -0.19507027f, 0.08948648f, -0.14430277f, 0.16559188f, 0.20293117f, 0.27924293f, 
    -0.13367780f, -0.10025857f, -0.16893557f, -0.02331383f, 0.07069318f, -0.24077170f, -0.11183213f, 0.07534913f, 
    -0.22188434f, -0.17228171f, -0.10405119f, -0.05903789f, 0.05106673f, -0.00036844f, -0.16461636f, 0.20117450f, 
    0.07735111f, -0.00618310f, 0.08871935f, -0.01914469f, -0.26089704f, -0.28529912f, -0.08129695f, 0.08174487f, 
    0.27128068f, 0.06258640f, -0.14937150f, 0.03483756f, 0.04608066f, -0.09405719f, 0.23790583f, 0.27057877f, 
    -0.14352211f, -0.04127111f, -0.42025393f, -0.02167147f, 0.24150576f, 0.08535141f, -0.09885117f, 0.04679407f, 
    0.18821715f, 0.13329057f, 0.01470930f, 0.19113824f, 0.14187795f, 0.43715271f, -0.02142360f, 0.05815627f, 
    -0.04754260f, 0.01809769f, 0.19728287f, 0.02012891f, 0.11483455f, -0.08842766f, 0.10742260f, 0.18453321f, 
    -0.21684413f, -0.29524276f, 0.01404356f, -0.15210970f, -0.14070164f, -0.03725949f, -0.04419295f, -0.09901276f, 
    0.02378597f, 0.13715351f, 0.27244920f, 0.15374006f, 0.17180617f, -0.06941129f, -0.10704639f, -0.06916814f, 
    -0.02278181f, 0.11393829f, 0.01724527f, -0.03453641f, 0.21901551f, 0.00437405f, 0.04868196f, -0.02509739f, 
    -0.38977906f, -0.44564354f, -0.10016174f, -0.05460852f, 0.04154426f, 0.01958401f, -0.14152059f, -0.01769688f, 
    0.05913823f, 0.18731360f, 0.02672254f, -0.00213907f, -0.45933819f, -0.19181357f, 0.05654036f, -0.12894294f, 
    -0.06272510f, -0.07546161f, -0.03369322f, 0.14792101f, 0.09672705f, -0.03311102f, 0.04207050f, 0.12821427f, 
    0.01618399f, 0.17716980f, -0.01977089f, 0.11971783f, -0.26567286f, 0.10927892f, -0.08217607f, 0.16233368f, 
    0.04503112f, -0.08454665f, -0.07566397f, 0.01736054f, -0.19899563f, -0.16079749f, -0.01907034f, 0.08841051f, 
    0.30784938f, 0.27367368f, 0.01001295f, 0.08111276f, 0.24663292f, -0.01220010f, -0.00280496f, 0.03400883f, 
    -0.00299918f, 0.25845414f, 0.03911496f, 0.01287808f, 0.04130232f, -0.07755509f, 0.09508175f, -0.10621294f, 
    -0.03110889f, -0.04995275f, 0.05048187f, -0.04259556f, -0.37241927f, -0.37922946f, -0.08136377f, 0.08568712f, 
    -0.07328553f, 0.01332374f, -0.12432741f, 0.02478725f, 0.17403734f, -0.00916593f, 0.05221904f, -0.03973217f, 
    0.35368195f, -0.04732126f, -0.00020769f, 0.10339382f, -0.13894702f, -0.05858424f, -0.14053959f, -0.02662920f, 
    -0.04259796f, 0.00081048f, -0.02652118f, 0.23879097f, -0.31339052f, -0.14651041f, 0.05353367f, -0.21758407f, 
    0.11795220f, -0.04812860f, 0.01921092f, -0.07061921f, 0.05784333f, 0.00685650f, 0.13389508f, 0.03546381f, 
    -0.34972954f, 0.01816952f, 0.02110171f, -0.20962720f, 0.08884460f, 0.04033905f, 0.00477103f, 0.04677815f, 
    -0.03730461f, 0.07239829f, 0.09266970f, 0.12870309f, -0.05707949f, 0.17684217f, -0.02286834f, 0.01255190f, 
    -0.24679580f, -0.11322887f, 0.03782540f, -0.05653758f, -0.13425443f, 0.06582236f, -0.07336813f, -0.08016686f, 
    0.33658358f, -0.10242820f, 0.15341471f, -0.09453247f, -0.03656292f, 0.09032208f, 0.10269895f, 0.06251497f, 
    0.01048108f, 0.08345719f, 0.02851282f, -0.01527942f, -0.16255070f, 0.12818621f, -0.10098897f, 0.03430144f, 
    0.10513245f, 0.16393504f, -0.03435229f, -0.13074607f, -0.11740817f, -0.12913994f, 0.02327606f, -0.05430724f, 
    0.37437299f, 0.20852691f, 0.12630315f, -0.07867940f, -0.08760937f, 0.00246804f, -0.02344975f, -0.03969925f, 
    -0.06191984f, -0.08578094f, -0.01083926f, -0.04058845f, -0.04382608f, -0.04943417f, 0.05744614f, 0.02402757f, 
    -0.05985333f, 0.00601260f, -0.01717235f, 0.14891349f, 0.06538744f, -0.03192469f, -0.01503392f, 0.11198703f, 
    0.36261785f, 0.17715393f, -0.06836643f, -0.09905845f, -0.00901077f, 0.04340717f, 0.00081430f, 0.01048154f, 
    0.15398845f, 0.06291276f, -0.02966671f, -0.01500886f, -0.13243416f, 0.00422126f, -0.00700162f, -0.04735738f, 
    0.36222079f, 0.06004296f, 0.13795592f, -0.04065633f, -0.16674808f, 0.01425420f, -0.07257964f, 0.10066251f, 
    0.07891333f, 0.30129766f, 0.00847370f, -0.09321586f, 0.10550199f, 0.13755532f, 0.02408847f, 0.03837667f, 
    -0.04089976f, -0.05958718f, -0.07372320f, -0.02782750f, 0.20510095f, 0.16607036f, -0.00428792f, -0.05128203f, 
    -0.04999027f, -0.20789556f, -0.05239019f, -0.05155042f, -0.08990201f, 0.10381145f, -0.05404138f, 0.02990281f, 
    -0.18297240f, -0.08434574f, -0.07338464f, 0.17353660f, -0.09801383f, -0.13520709f, 0.11075245f, 0.14309967f, 
    0.08105208f, 0.11375853f, 0.08438520f, 0.00424058f, -0.06776481f, 0.06986488f, 0.10997143f, -0.02995530f, 
    0.14329261f, -0.14794780f, -0.03361652f, -0.03268863f, 0.07641255f, -0.07265375f, 0.01880280f, -0.08694249f, 
    0.18004024f, 0.07308980f, -0.24627043f, -0.07094005f, -0.09545957f, -0.12820686f, -0.11135973f, 0.03555832f, 
    0.03790604f, 0.12937035f, -0.04964205f, 0.08142444f, 0.00648678f, -0.01691954f, 0.01210958f, 0.00108686f, 
    -0.10704741f, -0.06440122f, 0.01924873f, -0.10314081f, 0.03656890f, 0.05177997f, 0.02348820f, 0.11911413f, 
    -0.21760868f, 0.12103971f, 0.22454858f, 0.05179464f, 0.07278320f, 0.04513675f, 0.04453189f, 0.00868422f, 
    0.00648234f, -0.01693876f, -0.01511450f, 0.11215802f, -0.07022947f, -0.00212214f, 0.23053588f, -0.05149025f, 
    -0.10013351f, 0.00728987f, 0.10597434f, -0.00531730f, 0.16647376f, 0.10500217f, 0.06865890f, 0.03108503f, 
    0.13201745f, 0.17479344f, 0.07834885f, 0.12723197f, -0.01637902f, -0.06593021f, 0.02745513f, -0.00282565f, 
    -0.01377929f, -0.05151577f, 0.13324054f, 0.01142720f, 0.12637316f, 0.16814847f, 0.04366923f, 0.20617798f, 
    0.24984461f, 0.02357364f, -0.01810920f, 0.14680044f, -0.00421931f, 0.05413136f, 0.00326647f, 0.01181272f, 
    0.36933139f, -0.10128335f, -0.03633711f, -0.13582668f, -0.10121915f, -0.02946955f, 0.03334947f, -0.07491004f, 
    -0.03202739f, 0.05132751f, -0.10127422f, -0.02127928f, 0.11515652f, -0.03607917f, 0.11447085f, -0.16530171f, 
    0.01039283f, 0.00689780f, 0.09365616f, 0.01631489f, -0.10013032f, -0.06136471f, 0.10978076f, -0.13585617f, 
    0.21373424f, -0.18727203f, -0.07404059f, 0.21678737f, -0.15494187f, -0.10653358f, 0.01996970f, 0.04477137f, 
    0.14720817f, 0.00032547f, -0.13379517f, 0.02382835f, -0.16084422f, 0.12642775f, -0.06097355f, -0.03508947f, 
    -0.08155743f, -0.06063531f, 0.09743731f, -0.19153740f, -0.00356891f, -0.05121631f, 0.11873204f, -0.09977113f, 
    0.11811154f, -0.07166589f, 0.05654333f, -0.12799948f, 0.11893719f, 0.02113655f, 0.03499677f, 0.04289777f, 
    0.05009582f, 0.12431298f, -0.06822600f, -0.06758279f, 0.04026716f, -0.12755927f, 0.08287285f, 0.07881119f, 
    0.12512155f, 0.02574622f, 0.01400382f, -0.17442444f, 0.06205481f, -0.08992781f, -0.04589313f, 0.01003514f, 
    -0.24553385f, -0.18501157f, 0.01609214f, -0.16258435f, -0.01876082f, -0.05390629f, -0.05312162f, -0.02843503f, 
    0.02437661f, -0.12831539f, -0.07000960f, -0.00009914f, 0.11463892f, -0.10501666f, 0.23006107f, -0.01055270f, 
    -0.04952363f, 0.03427081f, 0.17290658f, 0.04212830f, 0.08029528f, 0.07079405f, -0.13795877f, -0.04518949f, 
    -0.21552266f, 0.21148503f, 0.11856196f, 0.20398708f, -0.09906212f, -0.03666980f, 0.05207505f, -0.01510056f, 
    0.01639879f, 0.10314949f, -0.01076139f, 0.01791406f, -0.18081167f, 0.02261144f, -0.04760009f, -0.32572305f, 
    -0.09697023f, -0.08390460f, 0.00582230f, -0.04165102f, 0.06789573f, 0.00928080f, 0.01380914f, 0.02918543f, 
    0.61393893f, 0.28348392f, 0.01836089f, 0.21603508f, 0.10603174f, 0.03811487f, 0.08391224f, 0.06231713f, 
    0.00549861f, -0.03041013f, 0.03028688f, -0.06590322f, -0.30424282f, 0.02673339f, 0.04032443f, -0.19625470f, 
    -0.00346454f, 0.06093266f, -0.05094615f, 0.06872988f, 0.02312572f, -0.12405878f, -0.07743353f, 0.04261016f, 
    0.11391372f, 0.01465041f, -0.16240031f, -0.18114419f, 0.00775950f, -0.04616115f, 0.06561245f, 0.04351015f, 
    0.11793938f, -0.01278637f, 0.06110808f, -0.18122378f, 0.03807051f, -0.31020349f, -0.01835833f, 0.17280984f, 
    0.00911860f, -0.02189143f, -0.11114686f, -0.01001486f, 0.06797941f, -0.00623888f, 0.14477162f, 0.13284597f, 
    0.04762270f, -0.00729041f, 0.19240989f, 0.17593630f, 0.02885503f, 0.02020812f, 0.06105692f, 0.08671398f, 
    0.07113120f, 0.06834106f, -0.11759340f, 0.15163106f, -0.18306090f, 0.16868047f, -0.05754070f, 0.05300615f, 
    -0.03967274f, 0.10243250f, -0.03603524f, -0.12628855f, 0.10120467f, -0.06662726f, 0.04338944f, 0.12500674f, 
    -0.08454744f, -0.05155813f, -0.00759074f, -0.02582430f, -0.08645567f, 0.08263122f, -0.10466133f, 0.17526007f, 
    -0.10258482f, 0.00284239f, 0.15122281f, -0.05193914f, -0.12312414f, 0.09408665f, -0.06857845f, 0.08736137f, 
    0.09235507f, 0.14680126f, -0.07675196f, -0.01901397f, 0.03403967f, -0.21049282f, -0.06446502f, -0.13491969f, 
    -0.01169257f, -0.00970094f, 0.03792665f, -0.15985070f, 0.04298136f, 0.03763108f, -0.09951281f, 0.00539826f, 
    -0.03819796f, -0.02528556f, 0.03732986f, 0.16426197f, 0.19415271f, -0.11499704f, 0.07327358f, -0.09732294f, 
    0.05077168f, 0.04399642f, -0.06234999f, 0.09170780f, 0.09355398f, -0.09268874f, -0.01451306f, 0.14031440f, 
    0.01744873f, -0.09961531f, -0.13632019f, -0.07734634f, -0.01937657f, 0.09188536f, -0.02754067f, -0.00567556f, 
    -0.10013723f, -0.05354463f, 0.09682979f, 0.05811002f, -0.18242961f, 0.20439656f, -0.22944814f, -0.06025206f, 
    -0.02981714f, -0.13094147f, 0.01187286f, 0.07842393f, 0.04858071f, 0.05828438f, 0.00707446f, 0.07997794f, 
    0.09078009f, -0.01319113f, -0.11238012f, 0.14170830f, 0.00948651f, 0.06862024f, 0.04146369f, 0.06387287f, 
    -0.06807779f, 0.14866497f, 0.04418116f, 0.12127511f, -0.03782444f, 0.21280313f, -0.25326508f, -0.01461512f, 
    -0.02874002f, -0.05705713f, 0.01188995f, -0.09646823f, -0.02668564f, -0.11949983f, 0.11554888f, 0.21112385f, 
    0.21647301f, 0.03067962f, -0.09137824f, -0.06122636f, 0.09724125f, 0.07732686f, 0.01123027f, -0.06978507f, 
    0.02676491f, -0.17029478f, 0.03566392f, -0.05863972f, 0.14446968f, -0.08570781f, 0.07566568f, 0.21187502f, 
    0.08240452f, 0.10382240f, 0.13797799f, -0.07263044f, 0.05765777f, 0.02622107f, -0.00096032f, -0.00536419f, 
    -0.45454496f, 0.07954225f, -0.02869195f, 0.05054484f, -0.07115760f, -0.08134680f, 0.11766469f, -0.16839807f, 
    -0.01484842f, 0.04193418f, 0.00564067f, 0.00719079f, 0.09288541f, -0.02725298f, -0.00488682f, -0.12585659f, 
    0.15384752f, 0.04341514f, -0.11522667f, 0.04291186f, 0.05398619f, 0.19601212f, -0.01716967f, -0.08108193f, 
    0.19730657f, 0.05290210f, -0.09420276f, -0.04947567f, -0.03704585f, -0.09105728f, -0.00857189f, 0.08516362f, 
    0.13653627f, 0.03929738f, 0.05454138f, 0.23297335f, 0.33501491f, 0.03587401f, 0.13003857f, -0.01310500f, 
    0.03700523f, -0.13143791f, 0.00852570f, -0.16577812f, -0.13175157f, -0.02079447f, -0.05313632f, -0.06849583f, 
    -0.01386484f, -0.01702353f, -0.00127086f, 0.10022256f, 0.00592865f, -0.02986069f, 0.00566075f, -0.08885774f, 
    -0.01109274f, -0.08615240f, 0.00120681f, -0.10545746f, 0.10529941f, -0.15192969f, -0.06473520f, -0.44960320f, 
    -0.03628010f, -0.10878809f, 0.13807446f, 0.12546194f, 0.13171366f, 0.07194857f, -0.08229451f, -0.10891489f, 
    0.04005323f, 0.10199690f, -0.24392794f, 0.23267612f, 0.00568552f, -0.00326563f, 0.14990424f, -0.06412676f, 
    0.16401388f, 0.08385424f, -0.11856928f, 0.14352138f, 0.17794158f, -0.09257844f, -0.01204739f, -0.13144228f, 
    -0.09206620f, 0.06414817f, 0.12701935f, 0.11763877f, 0.08725868f, 0.16049837f, 0.09009402f, 0.00426488f, 
    -0.16742891f, -0.17799298f, -0.02740356f, 0.22639851f, 0.07734188f, 0.09101935f, 0.04024344f, -0.07279105f, 
    0.07528132f, 0.10443830f, 0.02117360f, -0.13183215f, 0.12495297f, 0.09812920f, -0.15282418f, -0.12880006f, 
    0.09335117f, -0.05355614f, -0.00301320f, -0.01372650f, -0.05572470f, -0.10730003f, -0.01687729f, -0.01836215f, 
    -0.09263538f, 0.19957206f, -0.02565874f, 0.10971273f, 0.04427866f, -0.22866479f, -0.07380982f, 0.09148265f, 
    -0.01308756f, -0.03674592f, -0.02938119f, -0.02260743f, 0.08637121f, 0.26045877f, -0.14128140f, -0.09878623f, 
    0.11254551f, 0.10109042f, -0.04500395f, -0.15070836f, -0.11516216f, 0.02101498f, -0.02348889f, 0.06202508f, 
    -0.09055122f, 0.15924615f, 0.00392554f, 0.22446573f, -0.04206865f, 0.01881118f, -0.01190135f, -0.05778055f, 
    0.05320031f, 0.10018741f, 0.03012096f, -0.06334504f, -0.05702293f, -0.20785950f, 0.01835411f, -0.11412464f, 
    -0.01664016f, -0.14102362f, -0.09072275f, 0.12033830f, 0.09067448f, 0.13582623f, 0.05723521f, -0.08430254f, 
    0.34106255f, -0.20332184f, 0.08905130f, -0.29630190f, 0.06206519f, -0.00142791f, 0.11805862f, -0.10847613f, 
    0.12496830f, 0.06002113f, -0.09811677f, 0.04604730f, -0.04890569f, 0.00601708f, -0.02891226f, -0.04526610f, 
    -0.06927951f, 0.08619858f, 0.01882492f, 0.10461392f, 0.00991286f, 0.05084153f, -0.01522004f, 0.07360504f, 
    0.17810071f, 0.06849223f, 0.10360219f, -0.38671750f, 0.00243759f, 0.03644381f, -0.06381894f, -0.00028114f, 
    0.10760915f, -0.00972406f, 0.00795361f, 0.02483415f, -0.11715971f, -0.01656773f, 0.12170129f, 0.21883667f, 
    -0.06047860f, -0.00638709f, 0.02484822f, 0.00836032f, 0.07021703f, -0.03234327f, -0.07106416f, 0.05550320f, 
    0.12721452f, -0.06089253f, 0.06512102f, 0.04548832f, -0.10455205f, -0.00568137f, 0.04083761f, -0.03880436f, 
    0.14178218f, -0.04303613f, 0.00009272f, 0.13435204f, 0.06412271f, -0.27470025f, 0.07966477f, 0.14417765f, 
    -0.04216659f, -0.04037713f, -0.03803786f, -0.01156714f, 0.09137701f, -0.13872065f, -0.03956480f, -0.02809214f, 
    -0.02583916f, 0.01937773f, 0.04109622f, 0.27295658f, 0.10308521f, -0.05027093f, 0.06173578f, 0.03193465f, 
    -0.01511753f, 0.09487967f, 0.04520847f, 0.21142581f, -0.13187158f, 0.16245304f, -0.06194688f, 0.01115197f, 
    -0.16539192f, 0.00663565f, -0.07739041f, 0.12016038f, -0.12976550f, 0.01733816f, 0.12115225f, -0.01998735f, 
    0.07473204f, -0.24760257f, 0.05613014f, -0.13524409f, 0.04674204f, 0.04423336f, -0.00092308f, 0.19216992f, 
    -0.11465891f, 0.08248992f, 0.04267379f, 0.04851932f, 0.03417787f, 0.14076935f, -0.13745201f, -0.13288420f, 
    0.08726790f, 0.14431013f, 0.00833410f, 0.16684833f, 0.03456986f, -0.03220981f, 0.03115491f, -0.07301159f, 
    -0.04499674f, 0.10458155f, 0.18439065f, 0.17890771f, -0.08006322f, -0.04710785f, -0.02452801f, 0.05145271f, 
    -0.05537425f, -0.08789992f, -0.12744181f, -0.11293645f, 0.07970089f, 0.03822498f, -0.00413467f, 0.02836106f, 
    0.01622790f, 0.06617901f, 0.04622931f, -0.03897004f, -0.07432836f, -0.03965835f, -0.07414413f, 0.11749738f, 
    0.28448752f, -0.00953939f, 0.05656476f, -0.33936316f, -0.02655555f, 0.01715717f, -0.12288000f, 0.03839055f, 
    0.08507915f, -0.07423726f, -0.03143279f, -0.07327663f, -0.29237363f, 0.23057936f, -0.02867859f, -0.12475336f, 
    0.14694190f, -0.03764648f, 0.17509128f, -0.09289246f, 0.03510998f, -0.10914860f, 0.05256441f, 0.15261176f, 
    -0.11614016f, 0.03388431f, 0.08157407f, -0.06054309f, 0.00379075f, 0.14736037f, 0.04401434f, 0.07155877f, 
    0.08915053f, -0.05398589f, 0.11166839f, 0.03186704f, 0.05580143f, 0.13679753f, 0.05508178f, -0.04945375f, 
    -0.04876477f, 0.03565120f, -0.01058044f, -0.08694372f, -0.06668923f, 0.03444898f, 0.11732517f, 0.10724225f, 
    -0.24214253f, 0.02106187f, 0.13367866f, 0.27054358f, 0.04027262f, -0.16317005f, -0.04905144f, 0.16355138f, 
    0.05685852f, 0.06080239f, 0.04022916f, -0.00557731f, -0.14241108f, -0.05008632f, 0.03983808f, -0.15866490f, 
    0.18074106f, -0.08157090f, -0.03393535f, -0.04129509f, 0.10701894f, 0.02788579f, 0.03958960f, 0.10620928f, 
    0.14014494f, 0.17908369f, -0.06648809f, -0.01581765f, -0.10492879f, 0.00189315f, 0.00074951f, 0.10925773f, 
    -0.08677424f, 0.07205872f, -0.01552524f, -0.01372635f, -0.06707912f, -0.12073909f, -0.22381203f, -0.02520507f, 
    -0.09370275f, -0.04406174f, 0.01293307f, 0.07921530f, 0.07363984f, 0.06114244f, -0.00181060f, -0.02816759f, 
    0.32124567f, -0.02387675f, -0.02138940f, 0.04702109f, -0.03327847f, 0.08911808f, -0.15053360f, 0.07756431f, 
    -0.13595429f, -0.05964198f, 0.02109700f, 0.02061171f, -0.44261020f, 0.30097109f, 0.11192675f, -0.33016220f, 
    -0.08240727f, -0.05216588f, -0.03448514f, 0.00565224f, -0.09072157f, 0.00585508f, -0.17543297f, -0.09019197f, 
    -0.09051887f, 0.13116823f, 0.11575244f, -0.12276009f, 0.05968469f, 0.06907982f, -0.07409139f, 0.05314281f, 
    0.05225151f, -0.06539617f, -0.10708181f, 0.12820689f, -0.00781262f, -0.05388361f, -0.00679653f, 0.25914085f, 
    0.15798178f, 0.11866421f, 0.05070670f, 0.16698764f, -0.12178580f, -0.02923556f, 0.02965760f, 0.05005489f, 
    0.09290895f, -0.07007449f, 0.00875179f, 0.02744300f, -0.02412124f, -0.06401216f, 0.02653668f, -0.14525948f, 
    -0.09340753f, 0.04234020f, 0.00736358f, 0.07805347f, 0.09681639f, -0.17390640f, 0.14122696f, 0.05645941f, 
    -0.05915217f, -0.04664198f, -0.06778111f, 0.01044277f, -0.12122474f, 0.05133854f, -0.02051211f, 0.13503015f, 
    0.09190594f, 0.08408702f, 0.25780240f, -0.27930850f, -0.10080655f, -0.09078733f, -0.00777216f, 0.08933053f, 
    -0.01552462f, 0.00742989f, 0.02148313f, -0.13377906f, -0.01190538f, 0.04749259f, -0.00081718f, 0.21740161f, 
    -0.11929136f, 0.04256312f, -0.08065052f, 0.01162741f, 0.07074089f, -0.01766037f, -0.02398341f, 0.06490438f, 
    0.03627540f, 0.07570191f, -0.02948947f, 0.17092559f, 0.03817269f, 0.15362036f, 0.01732198f, -0.06350230f, 
    -0.02144223f, -0.02021189f, -0.06937321f, -0.06020410f, 0.04137247f, -0.23671243f, 0.17363782f, 0.07543556f, 
    0.07351784f, -0.04352390f, 0.05747294f, 0.04534404f, -0.01433904f, -0.04340827f, -0.17150669f, 0.00662876f, 
    -0.06160280f, -0.03426324f, 0.12030526f, -0.17386055f, -0.02036310f, -0.08461467f, -0.06979451f, 0.02460201f, 
    0.00377611f, -0.07897630f, 0.10511734f, -0.06252472f, 0.21750854f, 0.00837992f, -0.04290649f, 0.15444861f, 
    0.17799404f, 0.23417580f, 0.16143568f, -0.05154040f, -0.00445331f, 0.07639059f, -0.03054808f, -0.01685875f, 
    -0.02963085f, -0.07543238f, 0.15678428f, 0.12482432f, 0.10738928f, 0.00975835f, -0.05457517f, 0.15686151f, 
    0.10883186f, -0.03746972f, 0.01039594f, -0.01559266f, -0.20693475f, 0.26555291f, -0.01300251f, 0.00994387f, 
    0.01569085f, -0.00832699f, -0.13760373f, 0.00124880f, -0.05935148f, -0.01008479f, 0.04909207f, 0.04456332f, 
    -0.09990969f, -0.11697884f, -0.14354047f, 0.17926818f, 0.09312296f, -0.04547629f, 0.04470967f, -0.11195476f, 
    -0.16693754f, 0.13180771f, 0.06379693f, 0.05430171f, 0.19263564f, -0.03473706f, -0.04483232f, -0.05551351f, 
    0.03106011f, -0.03599805f, 0.11051439f, 0.05024109f, 0.09142828f, -0.09591074f, 0.05106082f, 0.00275618f, 
    0.05240287f, 0.03929147f, -0.05854412f, 0.00470512f, -0.01837954f, -0.01805704f, -0.00999952f, -0.06358488f, 
    0.00487068f, 0.05636910f, 0.03871793f, -0.00740554f, -0.03492609f, 0.03482365f, -0.01418032f, 0.04649759f, 
    -0.03471124f, -0.04068588f, -0.01006417f, -0.05867149f, -0.05927961f, 0.04843137f, -0.06886154f, 0.01743070f, 
    0.06027966f, -0.00417178f, 0.02385581f, -0.03657084f, -0.01198878f, -0.00758729f, -0.07580218f, 0.03746761f, 
    -0.00436478f, -0.06586169f, -0.06337152f, 0.06311470f, -0.06482374f, -0.02385190f, -0.02193909f, -0.01890129f, 
    -0.02005140f, -0.00492228f, -0.06416129f, 0.06531002f, -0.01703167f, -0.02546216f, -0.07119921f, 0.01228184f, 
    -0.06347194f, -0.06400176f, 0.03156457f, -0.05992224f, -0.07710408f, 0.00468668f, -0.00003834f, -0.01559273f, 
    0.02004709f, -0.00889395f, 0.00297106f, -0.00625522f, 0.05495835f, -0.07011930f, -0.01627923f, -0.01978937f, 
    -0.04419085f, -0.06717063f, -0.00693763f, -0.02037890f, 0.06492114f, -0.00717846f, 0.03094925f, -0.06627763f, 
    -0.04702768f, 0.05307556f, -0.04540255f, 0.05510508f, 0.01102855f, -0.03195551f, -0.03584104f, -0.01551555f, 
    0.00366192f, -0.06341051f, 0.06408431f, -0.00613376f, -0.05826225f, -0.00045595f, 0.00048806f, -0.00204055f, 
    0.05938831f, -0.05688801f, -0.04755666f, -0.00581558f, -0.03228825f, 0.01432268f, -0.07506829f, -0.03761305f, 
    0.01358200f, 0.04536837f, 0.06439508f, 0.00009299f, 0.03100148f, -0.04648595f, -0.02034508f, -0.07041124f, 
    0.03023293f, -0.07747920f, -0.01809700f, 0.05051602f, -0.03142923f, -0.03617392f, 0.06650407f, -0.01576893f, 
    -0.00367084f, 0.05020643f, -0.00960779f, 0.05410028f, 0.04751743f, -0.05060924f, 0.02333502f, -0.05027659f, 
    0.01253365f, 0.04281782f, -0.06532089f, -0.03687938f, 0.05567626f, -0.02868062f, -0.04932497f, 0.05585241f, 
    -0.04156954f, -0.01085383f, 0.00105701f, -0.05692350f, -0.06985773f, -0.02004318f, 0.01597860f, 0.05337346f, 
    -0.06827886f, -0.03781721f, 0.02279899f, -0.05368561f, -0.07205790f, 0.03602013f, -0.03626527f, 0.01624324f, 
    -0.05581656f, -0.06823360f, -0.03451703f, -0.07263998f, -0.06379426f, 0.01302553f, 0.02808205f, -0.05633154f, 
    -0.06469305f, -0.01322455f, -0.04626615f, -0.00396548f, 0.02386096f, -0.04917712f, -0.07503526f, -0.03270892f, 
    -0.06130108f, 0.00745232f, -0.04094686f, -0.04227732f, -0.06913563f, -0.02055120f, 0.03285146f, 0.05446947f, 
    0.01841690f, -0.04375676f, -0.00945216f, -0.03518340f, 0.04998860f, -0.03347930f, -0.04711751f, 0.02054013f, 
    -0.00826506f, -0.02943362f, 0.04210422f, 0.02707502f, -0.07738879f, -0.02913445f, 0.02755086f, 0.05146939f, 
    0.04135894f, -0.05741908f, -0.05225167f, 0.05564722f, -0.06527437f, 0.05631566f, 0.05735139f, 0.05677887f, 
    -0.33422366f, 0.06273853f, -0.03946082f, -0.03391432f, 0.13064635f, 0.07326381f, 0.10216050f, -0.07765579f, 
    0.06816665f, -0.00010562f, 0.21407247f, 0.09991802f, 0.14113605f, 0.29459521f, -0.06657537f, 0.04873316f, 
    0.03881489f, 0.05693440f, 0.07174776f, -0.06100610f, 0.01980448f, 0.04049642f, -0.06276218f, -0.05504970f, 
    -0.08806938f, 0.00591542f, 0.06405477f, -0.14975753f, -0.11181287f, -0.03671095f, -0.05124256f, 0.06811999f, 
    -0.03837105f, 0.03918655f, 0.03951265f, -0.08237944f, 0.08082946f, -0.09438832f, -0.04810539f, 0.22130962f, 
    0.05647359f, -0.08796545f, -0.07914309f, -0.08065800f, -0.08916572f, -0.01914238f, -0.04149572f, -0.03788435f, 
    0.17265095f, 0.09755187f, 0.24014775f, -0.39682183f, 0.06808810f, 0.06300654f, -0.01729229f, -0.09462666f, 
    0.04393566f, 0.11704028f, 0.06396458f, 0.01579072f, 0.20716493f, -0.07402035f, 0.05602053f, 0.31603956f, 
    -0.13357225f, 0.07325150f, 0.19424568f, 0.08859663f, 0.05181975f, 0.17659478f, 0.06453275f, 0.16964851f, 
    0.10903168f, 0.11629739f, -0.02311081f, -0.11496106f, 0.00599745f, 0.11878796f, 0.13909712f, -0.07082886f, 
    -0.08773582f, 0.11235969f, -0.09887372f, 0.00464323f, -0.29194573f, 0.02380096f, -0.08529383f, 0.04567451f, 
    0.11772656f, -0.02849730f, 0.10124849f, 0.02370518f, 0.00770976f, 0.04596001f, 0.00179726f, 0.00888410f, 
    0.03057117f, -0.07249933f, 0.30313259f, -0.10707066f, 0.04795831f, -0.06300234f, 0.02727584f, -0.01641276f, 
    -0.05587022f, -0.03207186f, 0.08433143f, 0.04931965f, 0.34886149f, -0.04022683f, 0.09814529f, 0.35874248f, 
    0.01070111f, -0.17337525f, 0.00846468f, -0.05208624f, -0.00251186f, -0.02730168f, -0.06641525f, -0.06817622f, 
    0.10721585f, -0.21250248f, 0.00435930f, 0.13954379f, 0.09124239f, 0.03856298f, 0.04555453f, -0.11367851f, 
    -0.00972044f, -0.06073950f, -0.19261710f, 0.03385628f, -0.12730399f, -0.08980023f, 0.13861121f, 0.09673593f, 
    -0.01988569f, 0.00153356f, -0.08809157f, -0.05377199f, -0.01050275f, 0.03802149f, -0.08079952f, 0.02836682f, 
    -0.29114512f, 0.02293064f, -0.08191895f, 0.09158438f, -0.07384143f, -0.07991260f, 0.08735812f, -0.06871384f, 
    0.06191245f, 0.14773940f, -0.10951632f, 0.02933082f, 0.18581054f, -0.10901286f, -0.02691623f, 0.18127269f, 
    -0.06805608f, 0.18739456f, -0.08585708f, 0.06850407f, 0.02134069f, -0.05353849f, 0.05995091f, 0.04503283f, 
    0.14310583f, 0.00850368f, -0.03472591f, 0.12188302f, 0.00080682f, 0.11348054f, -0.02296534f, 0.05714305f, 
    -0.01142808f, -0.06308619f, 0.00933044f, 0.02644547f, 0.01207910f, 0.13148625f, -0.06081622f, 0.10399988f, 
    -0.14528757f, 0.03050058f, -0.10947758f, 0.02575852f, -0.01869635f, -0.00302834f, 0.10006864f, -0.06329346f, 
    -0.11294258f, 0.01813763f, -0.03076490f, 0.20887029f, 0.03382246f, -0.21388744f, -0.08145900f, -0.04150829f, 
    0.09124357f, -0.06516077f, -0.39057481f, 0.08219950f, 0.04005513f, 0.07944296f, 0.25974000f, 0.04191576f, 
    0.02410459f, -0.01058442f, -0.11284290f, 0.08126248f, -0.06652374f, -0.00663851f, 0.09989525f, 0.06455197f, 
    -0.04666610f, -0.07318137f, -0.06337035f, -0.12642081f, 0.10844558f, 0.02394006f, 0.03324625f, 0.11277320f, 
    0.12750775f, 0.13006073f, 0.05707666f, -0.20345806f, 0.02247264f, 0.13655277f, -0.01763050f, 0.07876650f, 
    -0.16007489f, 0.08657072f, -0.28238240f, -0.21111384f, 0.08122760f, -0.23880398f, 0.01398986f, 0.06778084f, 
    0.24796335f, -0.07797460f, -0.01727640f, 0.02559832f, -0.02024980f, -0.11984450f, -0.06325166f, -0.09806857f, 
    -0.03265092f, 0.02608531f, -0.14964473f, -0.04005377f, -0.07183867f, 0.12000744f, -0.23829311f, 0.10027251f, 
    -0.03739109f, -0.24833381f, -0.14318909f, 0.12870927f, 0.08085267f, -0.05783985f, -0.02369471f, -0.16814359f, 
    0.12158056f, 0.15863870f, 0.07889187f, 0.17444424f, 0.04308315f, -0.02259773f, 0.14557612f, 0.14952573f, 
    0.04801316f, 0.23023348f, -0.01480915f, -0.08144864f, 0.17491002f, 0.14303033f, -0.00303295f, 0.10431059f, 
    0.02868704f, 0.08771116f, 0.04620759f, -0.08052668f, 0.08408138f, -0.05640319f, 0.13417542f, 0.18489698f, 
    0.07142760f, 0.07448467f, 0.02122189f, -0.01102874f, 0.12854670f, -0.04321505f, -0.03182503f, -0.25329903f, 
    -0.08339770f, -0.02185618f, 0.09426316f, 0.14699237f, -0.11083879f, -0.01448653f, -0.07380038f, 0.23078063f, 
    0.23777255f, 0.09799809f, -0.08398349f, 0.08101458f, -0.05142562f, -0.06435487f, 0.05433623f, 0.20186558f, 
    -0.14766860f, -0.09401540f, -0.20051020f, 0.04655697f, 0.19042142f, -0.15353450f, -0.09706544f, -0.10425988f, 
    -0.29071364f, -0.03755827f, -0.04209888f, 0.11727418f, 0.00642714f, 0.02385119f, -0.08690576f, 0.01406185f, 
    -0.13715069f, 0.09150366f, -0.07464654f, -0.41065273f, 0.10095785f, -0.09493588f, -0.17520092f, 0.14859682f, 
    -0.02316892f, -0.03275814f, 0.00121847f, 0.12335709f, -0.07022078f, 0.05676306f, 0.11888021f, -0.26164904f, 
    0.02977161f, 0.03760757f, 0.05488234f, 0.20576157f, 0.08609618f, -0.15037477f, 0.21900734f, 0.09087646f, 
    -0.16258082f, 0.04811098f, -0.29301313f, 0.01497124f, -0.27417037f, 0.04081837f, 0.14382493f, 0.15431510f, 
    0.09719048f, 0.06092009f, -0.05088220f, 0.07845329f, -0.03795436f, 0.01969823f, -0.17362888f, 0.06787269f, 
    -0.07626005f, -0.02518306f, 0.05740831f, -0.06693511f, -0.08332129f, -0.06349172f, -0.05497807f, -0.12968884f, 
    0.02439772f, 0.00848744f, -0.04343612f, -0.15735322f, 0.06745961f, -0.38293236f, -0.02582785f, -0.08431405f, 
    -0.22097975f, -0.06667916f, -0.20589459f, 0.11471658f, -0.09702542f, -0.03073758f, 0.15106925f, 0.07312042f, 
    0.11730421f, 0.02522211f, 0.02659585f, 0.16722259f, 0.03011634f, -0.36397901f, 0.00720180f, 0.05267943f, 
    0.09050909f, -0.08487528f, 0.02054674f, 0.01724033f, 0.13448855f, -0.07494648f, 0.08632123f, 0.02290392f, 
    -0.28380203f, -0.03158848f, -0.11393952f, 0.05143570f, 0.08023211f, -0.01864373f, -0.06133415f, 0.09528811f, 
    0.14435612f, 0.07610624f, 0.11601549f, 0.06011729f, 0.11213507f, -0.09021920f, -0.05963675f, 0.00807879f, 
    0.04120757f, -0.13662341f, -0.02040262f, 0.12251767f, -0.01286549f, -0.10021067f, 0.04191653f, -0.09830458f, 
    -0.15289894f, -0.00696144f, -0.09434921f, 0.06801388f, -0.02754698f, 0.08012986f, -0.07846717f, 0.17454565f, 
    0.03716538f, 0.04872556f, -0.01700319f, 0.09607774f, 0.01529980f, 0.00826919f, -0.01145422f, -0.11284772f, 
    0.05297688f, 0.12200934f, 0.20535122f, -0.01652258f, -0.04308086f, -0.09380996f, 0.14568070f, 0.08669119f, 
    -0.03078864f, 0.28332093f, 0.02673714f, 0.18310973f, -0.05246902f, 0.05576261f, 0.03996953f, 0.09264658f, 
    0.02230334f, 0.02464425f, 0.00788093f, 0.07983649f, -0.18193066f, -0.04553620f, -0.06687520f, -0.01683400f, 
    0.09965073f, 0.07980926f, 0.15986300f, 0.03527396f, -0.02653560f, 0.06410632f, 0.10631362f, 0.02051846f, 
    0.14197545f, -0.04731191f, -0.00137713f, -0.23220152f, 0.04738542f, 0.13005911f, -0.09763133f, 0.09624650f, 
    0.09942580f, 0.03748777f, 0.06915067f, 0.06485906f, -0.53452563f, 0.32822782f, 0.06302593f, -0.08528151f, 
    -0.05137661f, 0.16346264f, 0.04140209f, -0.10522845f, -0.00656996f, -0.03868277f, -0.04627162f, -0.05596327f, 
    -0.00945770f, 0.25182688f, 0.20435798f, 0.04534519f, -0.08177733f, 0.00433260f, -0.06632061f, -0.03675503f, 
    0.09205213f, -0.00742521f, -0.06173166f, -0.01041916f, 0.07164539f, -0.12624171f, 0.13796104f, -0.01293322f, 
    0.04165980f, -0.01177493f, 0.00698970f, 0.09174734f, 0.06228579f, -0.03930105f, 0.06266379f, -0.05688648f, 
    -0.09045937f, -0.04102794f, -0.00520174f, 0.10335584f, -0.11640342f, -0.06387848f, 0.18524164f, 0.10784530f, 
    0.08199612f, -0.05736435f, -0.05378668f, 0.07388186f, -0.20196909f, 0.15911688f, 0.14633611f, -0.12987477f, 
    0.05672952f, 0.09112660f, 0.00699724f, 0.04211206f, 0.09102058f, -0.03503544f, 0.00104697f, -0.00263245f, 
    0.32921347f, 0.15781686f, 0.01662839f, -0.10993194f, 0.08965554f, -0.08679341f, 0.03668403f, 0.09166083f, 
    -0.03554811f, -0.03045352f, -0.01069262f, -0.09174111f, 0.11478988f, -0.17566103f, -0.01746090f, 0.13613877f, 
    -0.00615892f, 0.01553712f, 0.01754958f, 0.09665129f, 0.11390390f, -0.01789061f, 0.06315953f, 0.02935377f, 
    -0.18816479f, 0.07085447f, -0.25552660f, -0.12237630f, 0.06034137f, -0.00930319f, 0.06511867f, 0.07424138f, 
    0.00014423f, -0.03356930f, -0.05733736f, -0.12707677f, -0.25946742f, -0.14349996f, 0.10866496f, -0.11273851f, 
    -0.00975886f, -0.01695088f, 0.03067699f, 0.16631888f, 0.05500016f, 0.09747083f, 0.14301185f, 0.10625838f, 
    -0.15139930f, 0.10850251f, 0.03067790f, 0.13571593f, 0.12157980f, -0.01640044f, -0.07989334f, 0.01136088f, 
    0.14812799f, 0.01405538f, 0.05088365f, 0.11001513f, 0.08742721f, -0.03659061f, 0.12525074f, -0.00051779f, 
    0.09660228f, 0.13731740f, -0.10707480f, 0.08484542f, -0.01463935f, -0.09858171f, -0.00773171f, -0.01354384f, 
    -0.19153920f, -0.04612667f, -0.14266810f, 0.29773101f, -0.07184982f, 0.15544875f, -0.06882813f, 0.05124885f, 
    -0.02771926f, -0.08807429f, -0.05133183f, -0.14994092f, 0.01984912f, 0.03644604f, 0.04541643f, 0.14267367f, 
    0.00907519f, 0.16267522f, -0.03705480f, -0.02561520f, -0.08884896f, -0.18719515f, 0.06423354f, -0.05476943f, 
    0.08127093f, 0.18188190f, 0.08915453f, -0.05406686f, 0.01871428f, -0.11710677f, -0.06432991f, 0.02987231f, 
    0.10292473f, 0.01121968f, 0.02481434f, 0.22331113f, -0.17032187f, 0.14400211f, 0.09094365f, -0.15270892f, 
    -0.01647838f, -0.10668162f, 0.02423717f, 0.06902735f, 0.06309294f, 0.06067064f, 0.14833519f, -0.00429025f, 
    -0.06054028f, -0.10450323f, -0.08199026f, -0.16240217f, 0.04963890f, 0.08644094f, 0.10496163f, 0.05161321f, 
    0.08059242f, 0.00630639f, 0.14344233f, 0.07547854f, -0.27852768f, 0.15764059f, 0.04253500f, 0.06256390f, 
    -0.07248019f, 0.12944065f, -0.07977399f, -0.02931449f, 0.13363485f, 0.01170403f, -0.11079502f, -0.02498903f, 
    -0.05179927f, 0.19677001f, 0.26482359f, 0.04363650f, -0.12318003f, -0.12397195f, -0.13955627f, 0.04473158f, 
    -0.08653806f, 0.19218844f, 0.03059816f, 0.19840947f, -0.14135203f, -0.07940076f, 0.13225597f, 0.08987325f, 
    0.15890191f, 0.11634166f, 0.18805374f, 0.18635204f, 0.11554479f, -0.05566173f, 0.12189989f, 0.08217858f, 
    -0.00006511f, 0.00572845f, -0.00623604f, -0.01019859f, -0.02055613f, 0.06694718f, 0.07619803f, 0.09282798f, 
    -0.02183313f, -0.15377359f, -0.02124176f, -0.01899032f, -0.07125971f, 0.25196376f, 0.26186708f, -0.17161696f, 
    0.04294562f, 0.02209339f, 0.00001046f, 0.03656982f, 0.02702278f, -0.13775264f, 0.07221300f, -0.00103259f, 
    0.23163530f, 0.03844070f, 0.06406081f, -0.00137311f, 0.07308614f, -0.10940163f, 0.17832051f, -0.14145926f, 
    -0.15843558f, -0.01913797f, -0.04026621f, -0.14916171f, -0.20110877f, -0.17416818f, -0.09617470f, -0.11179999f, 
    0.18714832f, 0.16357729f, 0.12956867f, -0.03098766f, 0.13926125f, 0.07572713f, -0.00589315f, -0.04553301f, 
    -0.01033460f, -0.02984251f, -0.04312846f, -0.03578046f, -0.00327148f, 0.03245305f, -0.03220013f, 0.01773293f, 
    -0.05898729f, -0.07812302f, -0.00788411f, -0.01894934f, -0.05874877f, -0.03622364f, -0.00614790f, 0.05691141f, 
    0.01569166f, 0.01267507f, 0.05783034f, 0.01827359f, 0.01096062f, -0.05573159f, -0.03596178f, 0.03678411f, 
    0.05623780f, -0.07911293f, 0.00115103f, 0.04152961f, -0.07441059f, 0.04282510f, 0.00088450f, -0.05246401f, 
    -0.05156179f, -0.03022588f, -0.05478071f, 0.01534420f, 0.03297248f, -0.02870275f, -0.02126591f, -0.03254921f, 
    -0.03674586f, -0.06402040f, 0.02056556f, -0.07691932f, -0.03847637f, 0.03462322f, -0.05864269f, 0.02427438f, 
    -0.04418984f, -0.00067608f, 0.03585325f, 0.01248016f, 0.04998141f, -0.05441367f, -0.05242358f, 0.00973629f, 
    0.05121322f, -0.03623639f, -0.00008018f, -0.06589673f, -0.01792394f, 0.06231375f, 0.05251279f, -0.04668946f, 
    0.03200100f, 0.04000475f, 0.00170176f, 0.05815393f, -0.03118528f, 0.03001291f, 0.01873902f, 0.04780292f, 
    0.01769943f, -0.07880998f, -0.00261373f, -0.03714895f, -0.03180126f, -0.04432120f, -0.03037401f, -0.06790974f, 
    -0.00573773f, -0.05943943f, 0.03429735f, 0.04314189f, 0.06007533f, -0.02180257f, -0.04764848f, -0.01032773f, 
    -0.02535894f, -0.03300695f, -0.07179341f, -0.07852927f, 0.01089066f, 0.01822129f, 0.03949938f, -0.06521489f, 
    -0.00963406f, 0.01887724f, -0.05849136f, -0.04027564f, -0.00523181f, 0.04886431f, -0.01028239f, 0.05646267f, 
    -0.03456934f, 0.04065413f, 0.02775485f, -0.06471595f, -0.05438316f, -0.03156497f, 0.01127243f, 0.03889683f, 
    -0.00485409f, -0.02929972f, -0.04964137f, 0.01799697f, 0.05844801f, -0.05432468f, -0.07391031f, 0.04547218f, 
    -0.03063458f, -0.03528076f, 0.05945072f, 0.05799777f, -0.00638520f, -0.01897505f, -0.01516414f, 0.04059573f, 
    -0.06045532f, -0.00298928f, -0.03617696f, -0.05458874f, 0.04897154f, -0.01258482f, -0.03059882f, -0.00391303f, 
    -0.05542191f, -0.05486728f, -0.05650540f, 0.01203324f, -0.01201593f, -0.04788117f, -0.03317507f, 0.05861392f, 
    0.02108693f, 0.05367808f, -0.04345002f, 0.06095644f, -0.02025422f, 0.02790661f, -0.05972366f, 0.02034537f, 
    -0.05161178f, 0.02393841f, 0.05792972f, 0.00752456f, -0.04853902f, 0.02676527f, 0.00291957f, -0.04145925f, 
    -0.01789711f, -0.02197075f, 0.03867385f, -0.04271568f, -0.06445894f, -0.03597493f, 0.04288786f, -0.04785667f, 
    0.03830319f, -0.03795147f, 0.03860341f, 0.01641648f, -0.03347190f, 0.00150107f, 0.00042876f, 0.04850084f, 
    0.05490756f, -0.04511584f, 0.00712475f, -0.07120383f, -0.01730491f, 0.05465081f, -0.04406673f, 0.01187864f, 
    0.00691000f, -0.02388616f, 0.01125093f, -0.05239559f, -0.01503832f, 0.05561094f, -0.06823894f, -0.02701281f, 
    0.18966724f, -0.01202877f, -0.19622797f, -0.09584378f, -0.06848723f, 0.01662077f, -0.12320283f, 0.04848695f, 
    -0.01428090f, -0.00773206f, 0.02112003f, -0.07284512f, -0.02844860f, 0.09420544f, 0.10306045f, -0.17942154f, 
    -0.03926785f, 0.06382054f, 0.07290230f, 0.12548164f, -0.11320745f, -0.02899459f, -0.02782407f, -0.04313488f, 
    -0.15749492f, 0.03084391f, 0.14998125f, 0.06758802f, -0.12956916f, 0.03306460f, -0.00461418f, 0.09108647f, 
    -0.06675522f, 0.00002936f, -0.00862761f, 0.01118025f, 0.10497990f, -0.20756391f, 0.14290297f, 0.14165354f, 
    0.11551456f, 0.04587586f, -0.08562569f, 0.08046153f, 0.03697907f, -0.11614446f, 0.05278032f, 0.04340648f, 
    -0.01872843f, 0.05030799f, -0.16564234f, 0.08872426f, -0.07838541f, 0.07897142f, 0.08096886f, 0.02019119f, 
    0.03688128f, 0.01497047f, -0.06051165f, -0.04607060f, 0.13763520f, -0.12743945f, -0.09650168f, -0.00601999f, 
    -0.07561820f, 0.01542843f, 0.14433080f, 0.06824361f, -0.07495714f, 0.05801823f, -0.09034692f, 0.01475483f, 
    0.13171309f, 0.00310480f, 0.13120136f, -0.01345260f, 0.07394704f, 0.04886030f, 0.09923017f, -0.03610380f, 
    -0.01254008f, -0.06302218f, -0.04251304f, -0.10172464f, -0.04703325f, 0.15824588f, 0.13995121f, -0.07444882f, 
    0.06312452f, 0.06331930f, -0.09203269f, 0.00212842f, -0.05967725f, -0.00108354f, -0.01521102f, 0.16258806f, 
    -0.11500765f, 0.09521137f, 0.06741948f, 0.06456843f, -0.06741503f, -0.16671929f, -0.04707309f, 0.05139237f, 
    0.01785140f, 0.05741931f, 0.06230576f, 0.02086185f, -0.18835256f, 0.05771909f, 0.11007086f, -0.12700164f, 
    0.04764927f, -0.00969646f, -0.07958682f, 0.02271565f, -0.01717470f, -0.04113636f, -0.05739280f, -0.00441606f, 
    -0.17146491f, 0.05382488f, -0.06413708f, -0.02405385f, -0.05714417f, 0.04726921f, -0.02102591f, 0.09017836f, 
    -0.06744979f, 0.07804658f, 0.13788041f, -0.01918243f, -0.11621648f, -0.10874232f, 0.05919812f, 0.16710031f, 
    0.08224201f, 0.06170947f, -0.08448894f, 0.08733800f, 0.07453038f, -0.05781882f, 0.06228913f, 0.00062914f, 
    0.16585834f, -0.12751420f, 0.17389360f, -0.10128484f, 0.07196987f, 0.13242519f, -0.11116000f, 0.08239748f, 
    0.09641033f, -0.06259403f, -0.03542668f, 0.02744805f, 0.07263037f, 0.17595768f, 0.18828937f, -0.14529574f, 
    0.04648045f, 0.10182250f, 0.04442678f, 0.20179507f, -0.11053786f, -0.05409135f, 0.09610228f, -0.12170075f, 
    0.01138086f, 0.10190291f, 0.00357334f, 0.02714819f, 0.15663275f, -0.13665146f, -0.03944597f, -0.10630513f, 
    -0.06473976f, -0.05923818f, 0.01349538f, 0.06371722f, -0.05217081f, -0.14450400f, -0.12274650f, 0.02655062f, 
    0.02472386f, 0.18763487f, -0.00294358f, 0.01949908f, 0.15082115f, 0.07164042f, 0.03829769f, -0.02273472f, 
    0.34498924f, -0.35738146f, -0.00592482f, -0.09241078f, 0.06926980f, -0.09865645f, -0.01959689f, 0.07406892f, 
    0.02240641f, -0.07270443f, -0.06378450f, -0.03796649f, 0.14086504f, -0.03979373f, 0.20726646f, 0.29160851f, 
    -0.09839790f, -0.04653016f, 0.07421496f, 0.03240428f, -0.02373658f, -0.04689292f, 0.03780545f, 0.06790677f, 
    0.32316980f, 0.27188382f, 0.30066493f, 0.19303340f, -0.10856082f, 0.06029298f, 0.15979797f, -0.09467353f, 
    -0.04952722f, 0.10322622f, 0.05536982f, 0.15895645f, -0.57591611f, -0.08098811f, -0.31752318f, -0.11087897f, 
    -0.15076415f, -0.00360632f, 0.10830668f, -0.03107890f, 0.06060985f, 0.15808053f, -0.03160788f, -0.09394652f, 
    0.21050739f, -0.12365082f, -0.00526230f, -0.09283169f, -0.00181066f, 0.14281408f, 0.00097615f, 0.13936108f, 
    -0.04995581f, 0.03025570f, 0.03494075f, 0.04435138f, -0.03862534f, 0.22370401f, -0.00296919f, -0.01352180f, 
    0.04113232f, -0.00131821f, -0.17869315f, 0.01391251f, 0.13874140f, -0.00163992f, -0.04563876f, -0.01783947f, 
    0.19209141f, -0.02055516f, 0.36168554f, 0.01391499f, -0.05101198f, 0.04960039f, -0.00115934f, -0.04945688f, 
    0.09089924f, 0.01573016f, -0.05761781f, 0.08551794f, 0.20385958f, -0.23560195f, 0.12395880f, -0.12919310f, 
    0.04262612f, 0.24099615f, 0.01359367f, 0.06415730f, 0.02081879f, -0.04978210f, -0.04518803f, 0.03254697f, 
    -0.20266595f, 0.07140599f, -0.23879334f, -0.14893554f, -0.01426153f, -0.08457938f, -0.08095239f, 0.07237218f, 
    -0.02875813f, -0.02693962f, -0.07570520f, -0.13487405f, -0.00710114f, 0.26196998f, -0.07832457f, 0.04905881f, 
    0.13422924f, 0.01375801f, 0.12218669f, -0.08092040f, 0.12048315f, 0.04997455f, 0.10716820f, 0.13669494f, 
    -0.16900808f, 0.01435483f, -0.07047388f, 0.00588656f, 0.05558688f, -0.01045521f, 0.10315557f, 0.08785686f, 
    0.02542823f, 0.01854517f, 0.12609917f, -0.03551535f, -0.31538454f, 0.17087452f, -0.66231114f, -0.25567669f, 
    0.01498271f, -0.04339205f, -0.04998294f, -0.04229418f, -0.07225940f, -0.00941581f, -0.04974067f, 0.09101042f, 
    0.00758740f, -0.12275433f, 0.05972064f, -0.10254275f, 0.13896461f, 0.06968645f, 0.04692112f, 0.10593401f, 
    -0.05272208f, -0.12125933f, 0.10940816f, -0.07940617f, 0.16624033f, 0.01837622f, 0.04347954f, 0.15271583f, 
    -0.07341592f, -0.22871740f, 0.09336344f, -0.09207192f, 0.09324279f, 0.07922496f, 0.12489650f, 0.08493777f, 
    -0.42354217f, 0.00346159f, -0.10542800f, -0.08002082f, -0.03728692f, 0.11097118f, 0.04678456f, 0.11586341f, 
    -0.07720626f, 0.10638064f, -0.02637461f, -0.01829872f, -0.16014892f, 0.06666206f, -0.04990430f, -0.19303267f, 
    0.01186116f, -0.07420374f, -0.03076242f, 0.15952563f, 0.10293950f, 0.10451496f, -0.13745575f, -0.04425533f, 
    -0.08104797f, 0.08489403f, -0.09930509f, -0.20269518f, 0.11982004f, -0.07023909f, 0.08209567f, 0.11958189f, 
    -0.00506745f, 0.09140384f, -0.05938715f, -0.20578718f, -0.02419779f, -0.22298163f, 0.02103656f, 0.02844364f, 
    -0.07755651f, 0.11195251f, -0.15949458f, 0.12210265f, -0.04438798f, 0.08640810f, 0.12476108f, 0.14207484f, 
    -0.12416301f, -0.08105625f, 0.04629935f, 0.20972793f, -0.07936791f, 0.10228036f, -0.10580041f, -0.05672794f, 
    0.01498562f, -0.08869924f, -0.15265158f, 0.15604997f, 0.04986130f, 0.04055689f, 0.05811524f, -0.11588891f, 
    0.10258882f, 0.15671262f, -0.06445185f, 0.04088953f, 0.10187712f, -0.08817694f, 0.15364842f, 0.13061075f, 
    -0.15717934f, -0.10987189f, -0.14642869f, 0.20665865f, -0.06260242f, 0.05234772f, -0.04341126f, 0.02239760f, 
    -0.02028713f, -0.06807405f, -0.02644442f, -0.07093471f, 0.10364924f, 0.12414236f, 0.00248246f, 0.26154441f, 
    0.01239350f, -0.02583222f, -0.15550265f, -0.03471591f, 0.00104499f, -0.15268335f, -0.11255736f, -0.14775310f, 
    -0.30411264f, -0.02158979f, 0.06701772f, -0.00941044f, 0.09062647f, 0.04107192f, -0.02714883f, -0.00962015f, 
    0.05333367f, 0.05662367f, -0.01498015f, 0.10948233f, 0.17490663f, 0.09561253f, 0.01194323f, -0.05508282f, 
    -0.04358884f, -0.00470642f, -0.00016828f, 0.03161640f, -0.10263618f, 0.02830282f, 0.12550588f, 0.04251638f, 
    -0.10851192f, -0.02028771f, 0.08127127f, -0.05076393f, 0.00760860f, 0.06299497f, 0.04658065f, 0.09665667f, 
    -0.01585793f, 0.04392207f, 0.08991753f, 0.16914065f, -0.47904548f, 0.02824065f, 0.07831758f, 0.02434374f, 
    -0.07480537f, 0.06357437f, -0.05425537f, -0.00050239f, 0.12425354f, 0.02721920f, 0.04946423f, 0.01565611f, 
    0.08307561f, 0.05603002f, 0.07139996f, 0.28293362f, -0.08060188f, -0.06914403f, -0.04857066f, 0.07591355f, 
    -0.08471289f, 0.14923653f, 0.05417236f, 0.14809948f, -0.03176863f, 0.13982421f, 0.00728052f, 0.20809866f, 
    0.07198924f, 0.02613287f, 0.01574236f, 0.10183810f, 0.12324137f, -0.00974922f, 0.10428574f, 0.13305241f, 
    0.21584363f, -0.04446723f, -0.12734993f, -0.16374145f, 0.03789479f, 0.05362555f, -0.08744361f, -0.11611468f, 
    0.00159763f, -0.14539480f, 0.03227768f, 0.01130221f, 0.06426783f, -0.07566697f, 0.31541449f, 0.12967320f, 
    -0.02142803f, 0.05806866f, 0.10623793f, 0.05813481f, -0.00638590f, 0.00355910f, 0.06551716f, -0.00126108f, 
    -0.20052464f, 0.21634132f, 0.09646430f, -0.18450937f, 0.09511776f, -0.17426826f, 0.15587847f, -0.12812993f, 
    -0.01076922f, -0.12414588f, -0.05010729f, 0.01907505f, 0.06659497f, 0.02249088f, -0.03914863f, -0.11285776f, 
    0.17342453f, -0.03500658f, 0.00892004f, 0.06119654f, 0.08985570f, 0.16346610f, 0.00732001f, -0.11665665f, 
    0.04334560f, -0.06071581f, -0.01934250f, -0.04926659f, -0.05453603f, -0.00466984f, 0.04504182f, 0.05270306f, 
    -0.02870040f, -0.02003018f, 0.00981080f, 0.05626597f, -0.02836866f, -0.04312271f, 0.05461062f, -0.03272571f, 
    0.06480254f, -0.02378992f, 0.05778607f, 0.01761994f, -0.02944703f, -0.05686943f, -0.01621357f, 0.04974682f, 
    -0.05991725f, -0.04014429f, -0.04722578f, -0.06345115f, -0.02916590f, 0.00337189f, -0.03273342f, -0.03406702f, 
    0.01495348f, 0.00685407f, -0.06086870f, -0.02699911f, 0.05555457f, -0.04498959f, -0.01442017f, 0.02521020f, 
    0.00194924f, -0.06596538f, -0.00892966f, 0.03308564f, -0.02263556f, 0.05304592f, -0.05791522f, 0.03564117f, 
    -0.04609422f, -0.03185562f, -0.04813724f, 0.02707453f, 0.02473781f, -0.03957523f, -0.07204945f, 0.01399271f, 
    -0.05399009f, -0.05476512f, -0.05007486f, 0.04541453f, 0.02178759f, 0.02802744f, 0.05141761f, 0.00912966f, 
    -0.04280544f, -0.01028605f, -0.07108343f, 0.05494457f, -0.03523521f, -0.00914114f, -0.03241843f, -0.00470119f, 
    -0.06646953f, 0.02306759f, 0.06270978f, -0.01026681f, -0.00442871f, 0.00032854f, -0.06016563f, -0.01491359f, 
    -0.07236608f, -0.01353957f, -0.01417013f, -0.06282041f, 0.00861105f, -0.07612511f, -0.06229114f, -0.06563222f, 
    -0.05449636f, -0.00033379f, 0.02645155f, -0.04692397f, -0.00236638f, -0.04103742f, -0.06995837f, 0.01030887f, 
    -0.01761693f, 0.04422483f, 0.04202579f, -0.00330820f, -0.05536364f, 0.05073909f, -0.01312861f, -0.00345316f, 
    -0.07166933f, 0.00118440f, -0.01455350f, 0.02792894f, 0.00095903f, 0.06548409f, -0.04725652f, -0.05291557f, 
    -0.02544245f, -0.02065002f, -0.05762060f, -0.03096875f, 0.06279898f, -0.03156734f, -0.02374305f, -0.06688759f, 
    -0.05646837f, 0.03402989f, -0.05016228f, 0.00298671f, 0.01002550f, 0.03552959f, 0.04524350f, 0.06856196f, 
    0.01971607f, 0.03314269f, 0.01406006f, -0.00638390f, -0.00222328f, 0.00483402f, -0.02778786f, 0.02969013f, 
    -0.04863983f, -0.05054596f, -0.04834783f, -0.05033356f, -0.01101924f, 0.01669312f, -0.03644311f, -0.02476558f, 
    0.05356951f, 0.01893204f, -0.06676328f, -0.06506106f, -0.04145148f, -0.03426268f, 0.06664247f, 0.05400447f, 
    0.05365734f, 0.04514722f, 0.05745969f, -0.03118325f, 0.03181380f, -0.06763422f, -0.07458048f, 0.02045234f, 
    -0.05911502f, -0.01794840f, 0.02775441f, 0.02609709f, 0.00677610f, 0.01772469f, 0.04068207f, 0.01874484f, 
    -0.03550510f, 0.01560197f, 0.05068814f, 0.00637468f, -0.00844906f, 0.03484318f, -0.04224395f, -0.00239744f, 
    0.06531975f, -0.00536778f, -0.01943264f, -0.00845561f, 0.02396147f, 0.04656876f, -0.00724368f, -0.07242686f, 
    -0.06190434f, -0.05540990f, 0.05551282f, -0.07847895f, -0.03783905f, 0.02616145f, -0.04248452f, 0.00472776f, 
    0.34133863f, 0.03550695f, 0.08598534f, 0.09383163f, -0.10132596f, -0.11414409f, -0.03233560f, 0.06206524f, 
    0.00689380f, 0.14793284f, -0.09912271f, 0.10735698f, -0.29930899f, -0.39787716f, 0.16032694f, 0.08737776f, 
    0.11743199f, -0.00390286f, -0.06792548f, -0.04657782f, 0.16000095f, 0.09252533f, 0.12299224f, -0.11127046f, 
    -0.26770291f, -0.19646034f, -0.03838499f, -0.06651816f, 0.06642076f, -0.10286581f, -0.01223268f, -0.09649993f, 
    -0.02729941f, 0.03420560f, 0.08892886f, -0.02465465f, -0.00495472f, 0.20622736f, 0.02157727f, -0.07100302f, 
    -0.20222488f, -0.11244030f, 0.12675630f, -0.00317583f, 0.03205419f, 0.00979016f, 0.00311962f, -0.04124486f, 
    0.21540898f, 0.09334808f, -0.02436614f, 0.06207512f, 0.07948024f, 0.05500064f, 0.03550503f, 0.03352521f, 
    0.10611755f, 0.05640189f, -0.04091741f, -0.02803623f, -0.13692926f, 0.23251295f, -0.18246484f, -0.08906171f, 
    0.04798603f, 0.13899626f, -0.10536646f, 0.04033568f, 0.11471134f, -0.02661532f, 0.05943841f, -0.04047806f, 
    0.12599692f, -0.00958024f, -0.15645863f, 0.12836374f, 0.02514925f, 0.07528331f, -0.07444968f, 0.13977832f, 
    -0.10198953f, -0.13361214f, 0.09091622f, 0.06145774f, 0.11500476f, -0.06431393f, -0.10031700f, 0.07402445f, 
    -0.16119343f, -0.00771965f, 0.03200281f, 0.04418463f, -0.08056219f, 0.09793609f, 0.07637687f, 0.03839880f, 
    0.42760631f, 0.05713695f, -0.05951840f, -0.11992901f, -0.02678250f, 0.00406233f, -0.09856854f, 0.00810050f, 
    0.07223572f, 0.14884056f, -0.01786709f, -0.00814482f, -0.17371592f, 0.15162624f, -0.06012447f, -0.15373452f, 
    0.27262303f, 0.13024807f, -0.01180078f, 0.04952328f, -0.10770397f, 0.07436153f, 0.03177469f, 0.11333083f, 
    0.09320342f, 0.07356474f, -0.04163327f, -0.11241136f, 0.14978166f, 0.18805085f, 0.19096273f, 0.03969210f, 
    -0.01479290f, 0.08856098f, 0.07520935f, -0.02783928f, 0.20771602f, 0.17052075f, -0.13898514f, -0.10896906f, 
    -0.09686570f, -0.10151884f, -0.07134096f, -0.09211507f, -0.05522361f, -0.06952992f, 0.04692891f, 0.14710496f, 
    -0.02954164f, 0.01014566f, -0.10498150f, 0.19277130f, -0.11352331f, -0.01090140f, -0.06119150f, -0.03541549f, 
    -0.09468441f, 0.06362146f, 0.02073003f, 0.09749638f, -0.11030738f, -0.14790367f, -0.02909523f, -0.03852581f, 
    0.16577506f, -0.01125586f, 0.09781262f, 0.01115869f, 0.23006940f, 0.11656962f, -0.04221923f, -0.11521088f, 
    0.28609845f, 0.15512288f, -0.02106174f, -0.12276855f, -0.23442052f, -0.16679351f, -0.12262700f, 0.12443373f, 
    0.07204799f, 0.11131937f, -0.06880298f, 0.03582846f, -0.04638134f, 0.05665011f, 0.08061896f, 0.02726337f, 
    -0.05104695f, -0.15436707f, 0.17270294f, -0.09571863f, -0.19823921f, 0.06774692f, -0.02208831f, -0.01396395f, 
    -0.12963893f, 0.10390408f, 0.02149302f, -0.13913479f, 0.01292822f, 0.05606352f, -0.04204714f, -0.02795876f, 
    0.07626697f, -0.08374919f, 0.00049981f, -0.06194251f, 0.15939984f, -0.11373292f, 0.17433088f, 0.03240252f, 
    0.05296067f, -0.04970568f, -0.15968513f, 0.13574277f, 0.17216887f, -0.01827249f, 0.06019887f, -0.08943056f, 
    0.47067121f, 0.29247031f, 0.09239386f, 0.27394712f, 0.11401173f, 0.02562315f, 0.05359906f, 0.11037888f, 
    -0.09686933f, 0.08841113f, 0.09424394f, -0.02386438f, 0.02155164f, -0.12720855f, -0.01021988f, -0.01384256f, 
    0.01839272f, 0.07118411f, -0.00567299f, 0.09930541f, 0.00094284f, -0.03155325f, -0.04039350f, 0.00359754f, 
    -0.18087250f, -0.06168297f, -0.01681573f, 0.17376183f, 0.13065264f, 0.13779573f, 0.09861955f, 0.11992358f, 
    0.09917819f, -0.02567101f, 0.15530589f, 0.07546426f, 0.00851008f, 0.07951431f, 0.02550175f, -0.33443129f, 
    0.12808228f, -0.00118101f, -0.03863738f, 0.05113874f, -0.04064675f, 0.02775341f, -0.03965382f, -0.09938682f, 
    0.21989405f, -0.02327930f, 0.03284495f, -0.00341897f, -0.08786466f, -0.03700535f, 0.00812047f, -0.04300511f, 
    0.08760578f, -0.00600786f, 0.00966799f, 0.12539998f, 0.09021169f, -0.01199194f, 0.00518211f, -0.02086525f, 
    0.06564856f, -0.00986096f, -0.01220099f, -0.00529582f, 0.01624302f, 0.05033696f, -0.11755905f, 0.01194599f, 
    -0.24733618f, -0.08485335f, -0.02129917f, -0.09004044f, 0.02618470f, 0.09072148f, 0.06151183f, -0.00186484f, 
    0.13765162f, -0.04625963f, 0.00310739f, 0.00140503f, 0.20036365f, 0.11205236f, -0.21637185f, -0.04917639f, 
    -0.06548702f, 0.00053169f, 0.03585378f, 0.00537086f, -0.01952669f, -0.00237577f, 0.00959281f, 0.03153862f, 
    -0.02866535f, -0.00142669f, 0.11743396f, -0.27920619f, -0.04980271f, 0.09293430f, 0.07309316f, 0.08097859f, 
    0.03422740f, 0.03115406f, 0.04309942f, 0.05403467f, -0.07214732f, -0.07852621f, -0.00018990f, -0.04945678f, 
    0.00773448f, -0.01960131f, 0.01599163f, 0.04033424f, 0.00470455f, -0.04437208f, 0.05222648f, 0.15503740f, 
    0.12010007f, 0.04852584f, 0.09011774f, 0.00012532f, 0.11851855f, 0.00561506f, 0.01383158f, 0.12964909f, 
    0.09431117f, -0.09208704f, 0.03530768f, 0.01130056f, 0.11738618f, 0.18574838f, -0.02891367f, -0.21117765f, 
    -0.00796517f, -0.09271345f, 0.03332217f, -0.03345304f, -0.02461446f, 0.05798325f, 0.00414184f, 0.03729074f, 
    0.05936128f, -0.35201249f, -0.01060981f, -0.04258441f, -0.10845091f, 0.13826005f, 0.04992150f, 0.00789469f, 
    0.00835443f, 0.09802362f, 0.00435271f, 0.07293507f, -0.07095919f, -0.00502477f, 0.09370498f, -0.08326687f, 
    0.12351584f, -0.04412992f, -0.02141980f, 0.00177078f, 0.16627742f, -0.09458209f, -0.05672946f, 0.06876178f, 
    -0.24179259f, 0.13519044f, 0.10533421f, -0.13915338f, 0.03270451f, -0.08688216f, 0.04519482f, -0.00538656f, 
    0.04673369f, 0.05324339f, 0.00827237f, 0.08081245f, 0.48039597f, -0.33052251f, -0.01875244f, 0.22909565f, 
    -0.02667929f, -0.01609061f, -0.08455797f, 0.04167197f, 0.07620247f, -0.01008517f, 0.09553346f, 0.05237766f, 
    0.22719415f, -0.04067993f, -0.00528683f, 0.22552972f, -0.13655820f, 0.00290294f, 0.02236530f, 0.10323300f, 
    -0.01887409f, 0.00177957f, 0.12405824f, -0.02238355f, 0.02158663f, 0.14919776f, -0.03696785f, -0.20864660f, 
    -0.07003336f, 0.01616565f, 0.01108347f, -0.01177350f, 0.09003831f, 0.00298338f, 0.04248394f, -0.12777525f, 
    -0.15077992f, 0.10045386f, 0.01668308f, 0.17541762f, 0.07409475f, 0.05134039f, 0.10418213f, 0.04375653f, 
    0.06442149f, -0.07403108f, 0.06186090f, -0.00170949f, 0.15076920f, 0.21790351f, -0.06065442f, -0.10161889f, 
    0.01335768f, 0.01007014f, 0.09362523f, 0.08203879f, 0.13587053f, -0.09048790f, 0.02732521f, -0.02921028f, 
    -0.15648898f, -0.16566408f, -0.07882850f, 0.25872219f, -0.01343144f, 0.05216127f, 0.12151610f, -0.05664192f, 
    0.01035651f, -0.00225935f, 0.00580549f, 0.02124114f, 0.18773092f, -0.18959776f, 0.02097744f, -0.12724119f, 
    0.03974649f, 0.05835270f, -0.05864414f, -0.07313267f, -0.20057072f, -0.00001891f, 0.05504670f, 0.01802086f, 
    -0.07013605f, -0.02901485f, -0.00109980f, 0.05375244f, -0.06802031f, 0.04284143f, 0.00499401f, 0.03286594f, 
    -0.02203093f, 0.00135245f, -0.02152676f, 0.08912052f, -0.10785825f, 0.28109238f, -0.14211431f, -0.12189454f, 
    -0.03091770f, -0.05782581f, 0.02003057f, 0.05014473f, 0.03278074f, 0.01918184f, 0.17432904f, -0.00197641f, 
    0.10553591f, 0.04429096f, -0.10442439f, 0.14423291f, 0.02888323f, 0.13429148f, 0.16736382f, -0.03017787f, 
    -0.00486999f, -0.02686996f, -0.06080011f, -0.05630351f, -0.01733244f, -0.04945103f, -0.15409778f, 0.03890330f, 
    -0.06172010f, -0.11738838f, -0.00087484f, -0.00213157f, -0.03129534f, 0.05007930f, 0.00527089f, 0.04031477f, 
    0.21868658f, -0.10408022f, 0.03387079f, -0.08878883f, -0.02183980f, -0.04147607f, -0.00630954f, -0.03158100f, 
    -0.10704428f, 0.03206329f, 0.06002864f, 0.06220867f, 0.07820497f, -0.10454593f, 0.04870246f, 0.10826313f, 
    -0.13154536f, -0.09500613f, -0.00382302f, 0.03509730f, 0.06001386f, 0.11012562f, 0.02246888f, -0.06070893f, 
    0.03896402f, -0.04909848f, 0.14142482f, -0.14404500f, -0.01772789f, 0.06914263f, -0.06661057f, 0.08262628f, 
    0.16208416f, 0.01872899f, -0.02205956f, 0.05647700f, -0.01470017f, 0.16609959f, 0.14706577f, -0.01815351f, 
    -0.10196494f, -0.03113450f, 0.04124320f, -0.09703210f, 0.01443148f, -0.02543804f, 0.06840539f, -0.01523088f, 
    0.27587852f, -0.04545053f, -0.00113737f, 0.08874521f, -0.02186136f, -0.02199875f, -0.13291238f, 0.01133224f, 
    0.04402057f, -0.02024683f, -0.04946680f, 0.10781042f, 0.16195688f, 0.00030613f, 0.16339882f, 0.06201620f, 
    0.09098236f, -0.10834823f, 0.02576524f, 0.00571308f, 0.02386915f, -0.04850304f, 0.03361801f, -0.09148970f, 
    0.29207632f, 0.19747843f, 0.11761165f, 0.02992184f, 0.13272181f, 0.05657220f, 0.08250078f, 0.01344098f, 
    -0.06196396f, 0.21830530f, 0.13287596f, 0.02266797f, -0.01997502f, -0.12941758f, -0.09122149f, 0.01810707f, 
    -0.15214811f, 0.02245415f, 0.10365912f, -0.02912400f, -0.04506160f, 0.11738873f, -0.03345910f, -0.15594484f, 
    0.01547311f, 0.05026866f, 0.03196876f, -0.06581253f, 0.08134072f, 0.02468629f, 0.12661266f, 0.07878163f, 
    0.04385410f, 0.03049918f, 0.13946363f, 0.12212187f, -0.01942524f, -0.00248466f, -0.16490723f, -0.34152964f, 
    0.06077643f, -0.06160098f, -0.04410558f, -0.00598989f, -0.01272662f, 0.11089579f, -0.05808294f, 0.04381653f, 
    0.30633500f, 0.00864821f, 0.06141619f, -0.09618744f, 0.06609192f, 0.01526289f, -0.01332988f, -0.03108419f, 
    -0.00808209f, 0.00032605f, 0.05231822f, -0.02188927f, 0.16839257f, -0.10525799f, 0.17013541f, 0.00935007f, 
    0.12115664f, 0.09034878f, -0.03907142f, 0.11886287f, 0.08214813f, -0.09053548f, -0.06888972f, 0.02019698f, 
    -0.07150514f, 0.05237931f, -0.11941294f, 0.15911075f, -0.03910787f, -0.06204110f, -0.00689083f, -0.01073344f, 
    0.07576612f, -0.02238942f, 0.00970351f, -0.07149249f, 0.38789290f, 0.15236726f, -0.28067395f, -0.04842230f, 
    -0.01345856f, -0.06329972f, 0.02814839f, 0.00192358f, -0.16028698f, -0.03691616f, 0.11404906f, 0.05632474f, 
    0.02306095f, 0.02686670f, -0.01867828f, -0.15147181f, 0.03321174f, 0.21302795f, 0.15046991f, 0.11755493f, 
    0.03093288f, -0.11948435f, 0.13039875f, -0.00127541f, 0.14186633f, -0.06348417f, -0.23963761f, -0.07920536f, 
    0.00848003f, -0.11094450f, -0.08211429f, -0.09781541f, -0.05025355f, 0.05415715f, 0.02683326f, 0.00621294f, 
    0.10421046f, -0.14783239f, 0.06273106f, 0.04674804f, 0.13166095f, -0.07331713f, 0.10096858f, 0.17277324f, 
    -0.00186029f, -0.03163952f, 0.03682027f, 0.00613824f, 0.11747374f, 0.03412534f, -0.24500148f, -0.09372599f, 
    0.05019026f, -0.08739013f, 0.06455719f, -0.09647779f, 0.12143961f, 0.11998766f, 0.00168335f, 0.05372935f, 
    -0.12949537f, -0.34337685f, -0.04380310f, 0.04437379f, -0.12293634f, 0.14710326f, -0.14781846f, 0.06574236f, 
    0.01480176f, 0.08628942f, 0.04264718f, 0.10248522f, -0.02567466f, -0.00827880f, -0.00606571f, 0.05311931f, 
    0.03290841f, -0.04609754f, -0.08537418f, 0.05819920f, 0.11010181f, -0.07041074f, 0.02653376f, 0.07446305f, 
    0.05046151f, -0.03042290f, 0.14506005f, 0.21396516f, 0.04179678f, 0.00789397f, -0.12803243f, 0.04710125f, 
    -0.07720038f, 0.03777074f, 0.11794198f, 0.09330997f, -0.37655085f, 0.27083826f, 0.02597333f, -0.31116277f, 
    0.04783773f, -0.06774334f, 0.09307259f, -0.03283472f, -0.02747375f, 0.04882245f, -0.08116364f, -0.08507871f, 
    -0.07421300f, 0.11616977f, -0.17140648f, -0.34014198f, 0.04574785f, -0.00394273f, 0.03455798f, -0.03016152f, 
    -0.06479952f, -0.17408971f, -0.02631042f, -0.10905982f, 0.14534281f, 0.06550270f, 0.20028982f, 0.15118912f, 
    0.12635872f, 0.00870314f, 0.16411944f, 0.04475754f, 0.02527757f, 0.10531843f, -0.03524309f, -0.01169917f, 
    -0.03774735f, 0.10725538f, -0.02830003f, 0.01160695f, 0.03042828f, -0.07799029f, 0.09892420f, -0.02549969f, 
    -0.02993015f, -0.05630161f, 0.03501042f, 0.10512630f, 0.02892106f, -0.15678193f, 0.16932227f, -0.13345934f, 
    -0.09928759f, -0.08903552f, -0.01021632f, -0.04266668f, -0.06616649f, 0.02816526f, 0.09354056f, 0.08423077f, 
    -0.10427830f, 0.05645075f, -0.04733159f, -0.22886321f, -0.08097502f, -0.12289287f, -0.02017280f, 0.08365969f, 
    -0.03161026f, -0.01585962f, 0.03675249f, 0.04749471f, -0.12444537f, -0.08427703f, 0.03688106f, 0.19590580f, 
    -0.10472240f, 0.05099580f, -0.01361421f, -0.00086506f, 0.20080742f, -0.03465103f, -0.05952376f, -0.04695437f, 
    0.09440590f, 0.01845558f, -0.08766989f, 0.21666153f, 0.16908573f, 0.13196076f, 0.08636672f, -0.03620910f, 
    0.04964175f, 0.01637499f, -0.01018455f, 0.00010671f, 0.22458631f, -0.25076604f, 0.02354974f, 0.03374957f, 
    -0.02134030f, 0.05583395f, -0.13055874f, 0.01289356f, -0.12962034f, -0.06887946f, -0.06084256f, -0.02452656f, 
    0.00389356f, 0.02529567f, 0.10165595f, -0.04225909f, -0.02558308f, -0.20436595f, -0.14621001f, -0.05992861f, 
    0.00045206f, -0.17574963f, 0.01318295f, -0.00670383f, 0.40060365f, 0.04788768f, 0.10937734f, 0.09607535f, 
    0.06411639f, -0.01253256f, 0.10975870f, -0.08050063f, -0.04841054f, 0.18576777f, -0.05262643f, -0.13018015f, 
    -0.03009087f, -0.06410135f, -0.00321908f, 0.17340727f, 0.00240249f, -0.09852792f, 0.12439958f, 0.07131626f, 
    0.05016023f, 0.00105209f, -0.13750543f, -0.06045695f, -0.17649487f, 0.11086576f, -0.18693809f, -0.08983812f, 
    0.01657243f, 0.04967187f, 0.03298290f, -0.03721847f, -0.11579977f, 0.04709883f, 0.05818961f, 0.11420285f, 
    -0.17125101f, -0.01849304f, -0.01842552f, 0.22125170f, 0.02214642f, -0.01990556f, 0.02440814f, 0.09366453f, 
    -0.00231671f, 0.17910776f, 0.06912579f, -0.00870389f, 0.17643002f, -0.01417110f, 0.13577187f, 0.28836751f, 
    -0.00848452f, -0.04025487f, -0.04751061f, 0.00606835f, -0.03575907f, -0.07031076f, 0.06420980f, 0.16942544f, 
    -0.03263434f, 0.05709410f, -0.03394228f, -0.06445617f, 0.05470672f, -0.02748008f, -0.07629648f, -0.03575752f, 
    -0.04759762f, -0.01438261f, -0.07663628f, -0.03361541f, 0.04135094f, -0.05200140f, -0.04597405f, -0.07573191f, 
    0.04100594f, -0.06782034f, -0.00141487f, 0.01045328f, -0.04073041f, 0.05703349f, -0.01667169f, -0.06039768f, 
    -0.06322804f, 0.00871726f, -0.03720804f, -0.00014324f, -0.03932325f, -0.01081912f, 0.00652773f, 0.05129501f, 
    -0.06356324f, 0.05318299f, -0.04268946f, -0.05257479f, -0.04708662f, -0.05546686f, -0.06754287f, -0.06240362f, 
    -0.03425246f, -0.04506310f, -0.02122520f, -0.04465417f, 0.04068685f, -0.06343228f, -0.00019584f, -0.02074998f, 
    0.01410776f, -0.05347503f, -0.04091238f, -0.06025951f, 0.03435823f, 0.02992847f, -0.05598171f, -0.02930751f, 
    -0.07325877f, -0.06463774f, -0.07397874f, 0.01506106f, -0.01068731f, -0.03084020f, -0.01096027f, 0.02656835f, 
    0.05802092f, -0.03468840f, -0.01808609f, 0.00796966f, 0.04299508f, 0.00037452f, -0.01081919f, -0.01296617f, 
    0.05119051f, 0.05874886f, 0.02297510f, 0.06217124f, -0.02404709f, -0.07800603f, -0.07133745f, 0.00412100f, 
    -0.05064631f, -0.06387253f, 0.04285111f, -0.07350322f, -0.07700379f, 0.01344130f, -0.02680216f, 0.04682754f, 
    0.02203770f, -0.02278125f, 0.03073107f, -0.05935186f, -0.00534847f, 0.05921936f, 0.05697277f, 0.02640246f, 
    0.00886614f, 0.04699410f, -0.02496458f, 0.05229823f, -0.05187599f, 0.00570831f, -0.06119609f, 0.01867355f, 
    0.04481213f, 0.04747725f, 0.05122413f, -0.05187551f, -0.07738329f, -0.06328694f, -0.00084326f, -0.05430856f, 
    -0.00328382f, -0.07698862f, 0.04144812f, -0.07157449f, -0.02007229f, -0.00427753f, -0.04595279f, 0.03586917f, 
    0.06249247f, 0.04306478f, -0.03089202f, -0.06980695f, -0.06212308f, -0.07268938f, 0.03020767f, 0.00452754f, 
    0.03638803f, 0.01451001f, -0.07593530f, 0.02812636f, 0.06229400f, 0.00541258f, 0.04132971f, -0.06169356f, 
    0.03796544f, 0.04280493f, 0.00621949f, -0.04179064f, -0.06049778f, 0.05154530f, 0.06075048f, -0.06577549f, 
    -0.05123891f, 0.00007778f, 0.01313017f, 0.03678912f, 0.00576702f, -0.03667163f, -0.01600510f, -0.02841648f, 
    -0.02218551f, -0.06812231f, -0.04918985f, -0.02137310f, 0.00815442f, -0.05630405f, -0.01668036f, -0.01736258f, 
    0.02779287f, -0.01930152f, -0.02042441f, -0.03505373f, 0.06065536f, -0.06839868f, -0.00897764f, -0.02982589f, 
    -0.02744535f, -0.02295674f, -0.04763611f, -0.02486619f, -0.00692073f, 0.00542334f, 0.03224206f, -0.02400768f, 
    -0.06147245f, -0.03746732f, 0.02403389f, -0.07254520f, 0.05846806f, 0.03587979f, 0.05790722f, 0.05292672f, 
    -0.00122792f, -0.04301528f, 0.02525308f, 0.03462762f, -0.00459992f, 0.00803827f, 0.02482484f, -0.03492228f, 
    0.04158138f, 0.00964009f, 0.13998631f, 0.14783114f, -0.06118399f, -0.08387750f, 0.16082768f, -0.01113247f, 
    0.08358256f, -0.02156877f, 0.01885248f, -0.05987662f, -0.20668150f, 0.01473908f, -0.10944941f, 0.11743557f, 
    0.09635916f, -0.01861370f, -0.14239676f, -0.05789202f, 0.04829457f, 0.05644517f, -0.00955272f, 0.06434021f, 
    -0.01453280f, -0.27564189f, -0.11334189f, -0.13038567f, 0.03516645f, -0.05910375f, -0.03181041f, -0.00336962f, 
    0.02517500f, -0.00151846f, -0.02656442f, 0.09868015f, -0.00899540f, 0.29909495f, 0.10664052f, 0.11189080f, 
    -0.13096417f, 0.21586853f, 0.14452623f, 0.00768661f, -0.02860942f, 0.01031977f, 0.08618429f, 0.03238637f, 
    -0.12162530f, -0.13117917f, 0.12475935f, -0.00722114f, -0.17303318f, -0.10010776f, -0.10860673f, 0.06339598f, 
    -0.05287495f, 0.16804478f, 0.02970187f, -0.07940025f, -0.12834741f, -0.01054239f, -0.12017706f, 0.08514801f, 
    0.11682609f, -0.04704965f, -0.31495091f, 0.05352180f, 0.03723116f, -0.10799324f, -0.09307880f, 0.00782758f, 
    -0.20026802f, 0.14870855f, 0.00090469f, -0.21196374f, -0.03781115f, -0.00908419f, -0.06487107f, 0.12362620f, 
    -0.16320717f, 0.01211488f, 0.01381795f, 0.09621533f, 0.12076232f, 0.04491127f, -0.09549730f, 0.20200706f, 
    -0.05613827f, 0.09667555f, 0.02368892f, 0.03912117f, 0.06539313f, -0.03088755f, -0.05022443f, 0.03396350f, 
    0.21495870f, 0.01925783f, 0.05179868f, -0.03073634f, -0.04585811f, 0.09810209f, 0.07919095f, 0.01184064f, 
    -0.08326905f, 0.06670494f, 0.02033758f, 0.07270590f, 0.11955667f, -0.14862289f, -0.13923660f, 0.05543840f, 
    -0.09385324f, -0.05975780f, -0.07762951f, 0.06631745f, 0.06774832f, 0.03744554f, 0.10157426f, 0.14046304f, 
    0.09258500f, 0.06004361f, 0.06785276f, 0.00464958f, 0.13043486f, -0.10978983f, -0.04232251f, 0.06615179f, 
    -0.03883250f, -0.03867494f, -0.08748404f, 0.05673920f, 0.22905503f, 0.35002494f, 0.03344886f, -0.09927126f, 
    -0.00351292f, 0.00334904f, 0.00451496f, -0.06273581f, 0.04593459f, -0.09087361f, -0.03714073f, 0.13183659f, 
    0.09018213f, 0.22494972f, -0.16307364f, 0.22686380f, -0.03641213f, 0.00364102f, 0.07552991f, 0.11002626f, 
    0.05677039f, 0.04964247f, 0.03065984f, 0.02347657f, 0.07920539f, -0.10030960f, -0.20731321f, 0.21048921f, 
    0.11689273f, -0.01805248f, -0.07513565f, -0.10486427f, 0.13039097f, -0.02751215f, 0.01992013f, 0.10192896f, 
    -0.15444623f, 0.15056752f, 0.06026786f, 0.08528942f, -0.16591738f, -0.07367893f, -0.07441475f, 0.07078607f, 
    0.05271031f, 0.10687893f, 0.01835020f, -0.03438256f, 0.16645439f, 0.18696177f, 0.10552938f, -0.00381744f, 
    -0.07527462f, -0.04966972f, -0.08249605f, 0.04042397f, -0.01972049f, -0.07883541f, 0.02244068f, -0.08513435f, 
    0.36673084f, -0.15576527f, 0.16239522f, 0.16811264f, -0.01886835f, 0.08416500f, -0.04719961f, 0.07171021f, 
    -0.05035528f, 0.01405261f, 0.14318579f, 0.19211209f, 0.05366614f, 0.14724876f, 0.09999881f, -0.10773876f, 
    -0.01541705f, -0.13488363f, 0.10343486f, 0.02072502f, -0.12400039f, -0.19849627f, -0.04483907f, -0.08093251f, 
    -0.07414214f, -0.07603269f, 0.11229738f, 0.17689939f, -0.07284047f, 0.02418669f, -0.05058094f, 0.00802859f, 
    0.00039260f, -0.08314675f, -0.01846875f, 0.00237429f, 0.00555394f, 0.05833172f, 0.04283472f, 0.00334818f, 
    -0.02956943f, -0.13395470f, -0.03237930f, 0.18011498f, -0.01179545f, 0.09232336f, 0.12105095f, 0.01214037f, 
    0.21994455f, -0.13212807f, 0.07475200f, -0.09167530f, -0.03240304f, 0.00509471f, 0.07441377f, 0.04499681f, 
    -0.08074068f, 0.04035320f, -0.07249373f, 0.11525908f, 0.36018211f, -0.21930984f, -0.10566633f, -0.08880145f, 
    -0.09352563f, 0.11882309f, 0.07344037f, 0.08236834f, 0.03159533f, 0.19435287f, 0.04707193f, 0.10361556f, 
    -0.28545207f, -0.03700344f, 0.16726077f, 0.07116139f, 0.03661191f, 0.12171064f, 0.11410380f, -0.15132897f, 
    0.00653684f, 0.05980749f, -0.16355485f, -0.25057277f, -0.02335188f, 0.15480122f, -0.05772506f, -0.02573449f, 
    0.00719016f, 0.12997173f, -0.01389888f, -0.06339811f, -0.10235785f, -0.03928065f, -0.03060800f, 0.06356011f, 
    0.03000752f, 0.03842481f, 0.11443235f, -0.09206891f, 0.05991255f, -0.09828289f, -0.17878261f, 0.06435566f, 
    -0.06882865f, -0.05163780f, -0.07696231f, -0.03835298f, -0.13442940f, -0.01803373f, -0.00074202f, -0.07379736f, 
    0.15021099f, -0.00219653f, -0.09113463f, -0.02822091f, -0.06017927f, -0.05105786f, -0.11072993f, 0.00777300f, 
    -0.27507108f, -0.15441270f, -0.06370398f, 0.00359750f, -0.03309349f, 0.08121432f, -0.05632425f, -0.01149527f, 
    0.04550060f, 0.03326897f, 0.04711759f, -0.08547847f, 0.16704319f, 0.06990673f, 0.20406589f, 0.14737707f, 
    0.01560401f, 0.21162163f, -0.04603758f, 0.15986648f, 0.07589085f, 0.15180142f, 0.05963584f, 0.00488471f, 
    -0.18786579f, -0.02745581f, 0.10466111f, 0.09216451f, 0.02154856f, -0.08818085f, -0.09185158f, -0.04865557f, 
    0.10089514f, 0.03885534f, -0.03579449f, 0.06468432f, -0.25249442f, -0.02367268f, 0.08514561f, -0.18499915f, 
    0.14702365f, 0.00138920f, -0.11780247f, 0.17637312f, -0.01252302f, -0.04308148f, 0.13287802f, 0.03734967f, 
    -0.03067906f, 0.31834880f, 0.03853989f, 0.06735145f, 0.17922971f, -0.07588696f, -0.18816601f, 0.14615114f, 
    -0.01415977f, 0.01507316f, 0.01920256f, 0.00308450f, -0.02774513f, 0.06617488f, -0.06148682f, 0.12665181f, 
    -0.16924562f, 0.08320802f, 0.11806379f, 0.11229964f, 0.07290616f, 0.08241872f, 0.04471695f, 0.03142806f, 
    0.44140136f, -0.29989946f, -0.12870060f, 0.16808708f, -0.08133710f, 0.09043992f, -0.14912228f, -0.07567795f, 
    0.03366270f, 0.04607160f, 0.07503151f, 0.03840294f, -0.25636742f, 0.33937639f, -0.10354280f, -0.17410736f, 
    0.15840614f, -0.09095532f, 0.08662394f, -0.11184921f, 0.01125693f, -0.09315310f, -0.03063192f, -0.09631012f, 
    -0.05323771f, 0.04949442f, -0.07470977f, -0.19483241f, 0.17539945f, -0.02152243f, 0.07170756f, -0.08541401f, 
    -0.09289222f, 0.03731075f, 0.00602802f, -0.01481907f, -0.18041615f, -0.18542878f, 0.06570758f, -0.01383165f, 
    -0.01803190f, -0.03874609f, 0.07781877f, 0.13737684f, -0.13795866f, 0.02618897f, -0.08435362f, -0.00474345f, 
    0.05293016f, 0.11279407f, 0.20540459f, -0.01409753f, 0.12715420f, -0.14828183f, 0.18041846f, 0.02482840f, 
    -0.03493709f, 0.10781831f, 0.03878407f, 0.15927485f, 0.04493433f, -0.20364726f, -0.11391566f, -0.12287203f, 
    0.07762566f, -0.04596313f, 0.05927066f, 0.05266098f, -0.06704485f, 0.16626374f, 0.04829454f, 0.22788237f, 
    -0.08835127f, 0.24988824f, 0.05252711f, -0.02124542f, 0.06501319f, -0.04286160f, -0.02555344f, -0.03134229f, 
    0.03200305f, -0.02943657f, 0.00702340f, -0.05828751f, -0.05083665f, 0.28529543f, -0.01621731f, 0.31590021f, 
    0.03010412f, 0.08409278f, 0.05652495f, 0.11656862f, 0.13898578f, 0.02429072f, -0.04214702f, 0.02494123f, 
    0.06089170f, 0.08431567f, -0.12015299f, 0.09995393f, -0.03342189f, 0.01004954f, -0.00117653f, -0.05918923f, 
    -0.03200896f, -0.00437534f, 0.05894695f, -0.07241156f, 0.30039433f, -0.16605936f, 0.00634308f, 0.01751393f, 
    0.04465407f, 0.04858264f, 0.02817658f, 0.15092516f, -0.23316613f, 0.03241308f, 0.05276267f, 0.00963485f, 
    0.09991723f, 0.04639740f, 0.03555293f, -0.24944173f, 0.02279886f, -0.00576807f, 0.04797769f, -0.00069139f, 
    0.06246878f, -0.07204216f, 0.06206331f, 0.00027489f, 0.07738476f, -0.02302139f, 0.07175420f, -0.21779564f, 
    -0.03689827f, 0.11551414f, 0.00166399f, -0.04466701f, 0.02977473f, 0.01214088f, -0.01828935f, -0.10439563f, 
    -0.20781371f, 0.08338393f, 0.05515287f, 0.13394313f, 0.04945836f, -0.00637500f, 0.02687775f, 0.08439621f, 
    0.14065203f, 0.07664313f, -0.05119826f, -0.00548501f, -0.07830946f, -0.02831728f, -0.25351888f, -0.11819910f, 
    0.20080355f, 0.00923546f, -0.10294848f, 0.07950237f, 0.03922112f, -0.02842949f, -0.02917288f, 0.09338970f, 
    -0.02188613f, -0.16458490f, -0.07679068f, 0.03811834f, -0.13205267f, -0.03565095f, -0.02806254f, 0.13559090f, 
    0.07780466f, 0.10092781f, 0.12326444f, 0.10649371f, 0.02406332f, -0.14322071f, -0.00668275f, 0.27577215f, 
    -0.09112555f, 0.02944051f, -0.03694243f, 0.00372735f, -0.05922285f, -0.08605971f, 0.04321511f, 0.13161707f, 
    0.16016519f, -0.11741267f, -0.13005753f, 0.16341695f, 0.10727732f, 0.01611863f, -0.11149113f, 0.09959436f, 
    -0.09172535f, 0.18322936f, -0.05899817f, 0.01294442f, -0.23792127f, 0.25410518f, 0.08223862f, -0.23416531f, 
    0.04683663f, -0.02061339f, 0.15131707f, -0.07001588f, -0.08656618f, 0.12961622f, 0.02823055f, -0.11501464f, 
    -0.00789761f, 0.11142066f, -0.13841210f, -0.08087416f, 0.15346642f, 0.05490704f, -0.03324279f, -0.02211104f, 
    -0.05966032f, -0.17110291f, -0.05009307f, -0.06149020f, 0.12952542f, -0.13205470f, 0.21048281f, 0.03348436f, 
    0.17162643f, 0.01987234f, 0.08908341f, 0.08699798f, 0.03907325f, 0.00189597f, -0.02639290f, -0.02773432f, 
    -0.03908828f, 0.24431399f, -0.18806697f, 0.22021952f, -0.01683288f, -0.00214675f, 0.04597819f, -0.19435225f, 
    0.14766446f, -0.00914808f, -0.13871059f, 0.05160182f, -0.00195137f, -0.31112167f, 0.12318810f, -0.08414173f, 
    -0.00004164f, -0.05472728f, 0.09891266f, -0.20019686f, -0.17001604f, -0.00079242f, 0.03486705f, -0.04946183f, 
    0.07218867f, -0.02504202f, -0.11120385f, 0.02698105f, 0.05941698f, 0.05062241f, -0.05089482f, 0.05770772f, 
    0.08763913f, -0.04042007f, 0.09475156f, -0.02002756f, -0.17146765f, 0.16198701f, 0.04062045f, 0.11176133f, 
    0.02544559f, -0.14386319f, -0.07404712f, -0.04287725f, -0.00512742f, 0.10128511f, 0.03853754f, -0.04065313f, 
    -0.05332755f, -0.01407866f, -0.16170761f, 0.23812447f, 0.09152397f, 0.04716661f, -0.01030640f, 0.09866963f, 
    0.08788911f, -0.01005514f, 0.01210557f, -0.01761839f, 0.27095801f, -0.26102814f, 0.08852634f, -0.11425965f, 
    0.08343492f, 0.19296898f, -0.09940949f, -0.09567390f, -0.06540376f, -0.03926231f, 0.03172292f, -0.11681132f, 
    -0.10463979f, 0.06951952f, 0.07666720f, 0.02930604f, -0.04843521f, -0.08656249f, -0.11043790f, -0.08391348f, 
    -0.03072814f, 0.00440906f, -0.00603507f, 0.07568207f, 0.06990075f, -0.34475279f, 0.21730639f, 0.12206582f, 
    0.03902291f, 0.04093999f, 0.18866771f, 0.09299123f, 0.12783813f, -0.04936294f, -0.03747711f, -0.13901426f, 
    0.06371030f, -0.02620635f, 0.10248791f, -0.00367808f, 0.01387336f, 0.00778838f, 0.08510067f, -0.03931791f, 
    0.07157733f, 0.04310312f, -0.08745271f, 0.05534609f, -0.06842729f, 0.09416696f, -0.02853258f, -0.12695679f, 
    -0.03778268f, 0.03905644f, 0.02239436f, 0.08974872f, -0.14286025f, -0.05270125f, -0.06745698f, 0.03963905f, 
    0.24867307f, -0.07545263f, 0.17466033f, 0.02618577f, 0.16270544f, 0.03146823f, 0.05124324f, 0.04006714f, 
    0.09183513f, 0.06405657f, 0.13705486f, 0.04566088f, -0.12912513f, -0.11171329f, 0.06730274f, 0.15487307f, 
    0.04540235f, 0.16684422f, 0.06792305f, 0.01938693f, 0.00746505f, -0.08046053f, -0.06228565f, 0.09308664f, 
    -0.50344557f, 0.20192708f, -0.18226394f, -0.13495149f, 0.04522220f, 0.02112781f, 0.03616150f, -0.02970495f, 
    -0.06818924f, -0.05720479f, 0.11360745f, 0.21382400f, 0.13530727f, -0.04440033f, 0.07461295f, 0.00434159f, 
    -0.11904655f, 0.04827894f, 0.07728031f, 0.18149707f, 0.10967326f, -0.07832936f, -0.01797067f, 0.00566195f, 
    -0.07976162f, 0.10493819f, 0.04012589f, -0.06371874f, -0.10621442f, -0.03154628f, -0.04753542f, 0.12785885f, 
    -0.02543652f, 0.11813980f, 0.10294674f, 0.02899592f, 0.15334456f, -0.18361971f, -0.23399656f, -0.06866037f, 
    0.09054298f, -0.11568359f, -0.01800638f, 0.01531577f, -0.01496711f, 0.07973527f, -0.07018007f, 0.00438540f, 
    0.01439780f, 0.07153028f, -0.02375600f, 0.05812208f, 0.04647817f, 0.11610570f, 0.01657340f, -0.06992365f, 
    0.08551225f, 0.01301457f, -0.01556198f, 0.03445778f, 0.10762013f, 0.17989059f, 0.11554537f, 0.12890936f, 
    -0.08072401f, 0.08974819f, 0.21213213f, 0.05696852f, -0.01818984f, 0.07464078f, 0.07508513f, 0.07380081f, 
    -0.11492202f, 0.25212419f, 0.06439570f, 0.09222297f, 0.02000435f, 0.07930514f, 0.03243540f, 0.03336381f, 
    0.09147530f, 0.11783846f, 0.01160167f, -0.01882656f, -0.25046825f, -0.09716848f, 0.03068810f, -0.13363227f, 
    0.09926145f, -0.04637499f, 0.09370203f, 0.02399615f, -0.06917515f, 0.12267441f, 0.11711047f, 0.02575072f, 
    -0.16505015f, 0.02311786f, 0.09741384f, -0.13315012f, 0.07979658f, 0.00978262f, 0.01084696f, 0.07952921f, 
    0.13468312f, 0.03328360f, -0.07131204f, -0.04487588f, -0.49850705f, 0.16835779f, 0.22991712f, 0.20195282f, 
    -0.07963523f, 0.03076512f, 0.06471858f, -0.03770859f, -0.02757945f, 0.04396892f, -0.12769753f, -0.04752848f, 
    -0.06295770f, 0.01133992f, 0.19249992f, 0.16041900f, 0.04708191f, 0.16613553f, -0.05522965f, -0.01090167f, 
    -0.09694681f, -0.03669179f, -0.02938068f, 0.13413748f, -0.08023312f, -0.06073032f, 0.01139323f, 0.18827847f, 
    0.09055905f, -0.07731532f, 0.08384631f, 0.12124151f, -0.05087520f, 0.14385967f, 0.01523613f, -0.06967461f, 
    -0.22995538f, -0.18700995f, -0.02694224f, 0.04871314f, -0.04779828f, -0.06306309f, 0.16353805f, 0.04101604f, 
    0.00077782f, 0.13509497f, -0.03085405f, 0.02866287f, 0.05183977f, 0.10654158f, 0.28509977f, -0.06286260f, 
    -0.13711821f, -0.00364695f, -0.06655992f, 0.06969175f, 0.03235314f, -0.06514513f, 0.01568055f, 0.04854337f, 
    0.30946371f, -0.05315836f, -0.13515213f, -0.15429282f, -0.04388196f, 0.08839475f, -0.00005711f, -0.02903265f, 
    -0.01815829f, 0.04120771f, 0.01808796f, 0.03661640f, 0.11843753f, -0.08692613f, -0.09591316f, 0.09693886f, 
    -0.01187259f, -0.00954844f, 0.08703886f, 0.03550655f, -0.04715585f, 0.04528798f, 0.08864249f, -0.02577537f, 
    -0.09206669f, 0.02215165f, 0.15781206f, 0.13524477f, 0.11437104f, 0.06817564f, 0.02568923f, 0.09533072f, 
    -0.07688297f, 0.06416213f, -0.00788097f, -0.02043854f, -0.17694029f, 0.13296911f, -0.11260170f, 0.05374251f, 
    -0.00728306f, -0.06132299f, 0.09766202f, 0.05614524f, -0.08417721f, -0.03704991f, -0.07175165f, -0.03775078f, 
    -0.26471129f, -0.17394678f, -0.17450382f, -0.04059210f, -0.05529991f, -0.02226600f, -0.14288260f, -0.02644968f, 
    0.01159149f, -0.14504836f, -0.10287149f, -0.05844624f, 0.04789575f, 0.02656403f, 0.12334775f, -0.06180573f, 
    0.20127107f, 0.01936341f, 0.00144576f, 0.10002042f, 0.04829561f, -0.04424685f, 0.07838663f, 0.09669794f, 
    -0.09926038f, 0.08367253f, 0.00288330f, 0.14899838f, -0.01260800f, -0.05959751f, 0.04904781f, -0.06231729f, 
    -0.03690558f, 0.02767793f, -0.08032352f, 0.01321418f, 0.03015373f, -0.10448958f, 0.10653991f, 0.07296824f, 
    0.00435477f, -0.13276167f, -0.07448793f, -0.06631055f, -0.08925629f, 0.06187331f, 0.16047770f, 0.02418775f, 
    -0.32555592f, -0.10261044f, -0.05837465f, 0.17438799f, -0.04284844f, -0.01090429f, -0.04029292f, -0.00676255f, 
    0.05554204f, -0.00886220f, -0.01397610f, 0.04658566f, -0.02324414f, 0.26673862f, -0.16679575f, 0.08037071f, 
    -0.01104473f, -0.01193736f, 0.12305622f, -0.11349922f, -0.02353213f, 0.08127299f, 0.19386248f, -0.00289672f, 
    0.11499979f, 0.03000037f, -0.01682302f, 0.01134688f, 0.18272589f, -0.03479151f, 0.08608423f, -0.05833409f, 
    0.06128648f, 0.12477425f, -0.03353293f, 0.00380011f, -0.12259604f, -0.19871074f, 0.14906870f, -0.11833917f, 
    -0.07200513f, 0.22257833f, -0.14416444f, -0.09057598f, -0.01436157f, -0.05460660f, -0.02281514f, 0.03295477f, 
    0.03344110f, 0.10796538f, 0.07393714f, 0.02145720f, 0.01095976f, -0.12068195f, -0.06396513f, 0.03384629f, 
    -0.00533069f, 0.07435509f, 0.06626764f, -0.00618968f, 0.07801141f, -0.10271494f, 0.28304455f, -0.01288239f, 
    0.09216386f, 0.16530789f, 0.13095511f, 0.16866501f, 0.12371211f, 0.05288190f, 0.03477253f, -0.08788362f, 
    -0.01113804f, -0.00432088f, -0.03632420f, 0.04753299f, 0.04146571f, -0.05182233f, 0.01086375f, -0.02142408f, 
    -0.01438395f, 0.06183169f, -0.06376716f, 0.10697584f, -0.23752093f, 0.07519387f, 0.06505147f, -0.05190421f, 
    -0.01832148f, 0.03289067f, -0.06725689f, 0.04155764f, 0.04854514f, -0.02603604f, 0.00449529f, 0.02522988f, 
    0.05913116f, 0.23536490f, 0.06475803f, -0.13513571f, 0.20989829f, -0.10826527f, 0.06839600f, 0.08300948f, 
    0.10610000f, -0.00399567f, 0.05740791f, 0.03835551f, 0.03589180f, -0.05533082f, 0.10686414f, 0.11045104f, 
    0.04274627f, 0.00345804f, 0.11906365f, 0.01536161f, -0.05102728f, 0.01276155f, 0.05954113f, 0.07829353f, 
    -0.29195443f, -0.07824300f, 0.02757864f, 0.11656335f, 0.08552782f, 0.12647317f, -0.00909535f, -0.01150688f, 
    0.05195908f, -0.05899478f, 0.03033265f, 0.00726910f, -0.37222919f, 0.47274747f, -0.13756451f, 0.01380054f, 
    -0.00794953f, 0.02779299f, 0.10772728f, -0.03242613f, 0.03087554f, -0.02787266f, -0.06746531f, -0.07647049f, 
    0.04790564f, 0.15745309f, -0.02793881f, 0.02743086f, 0.14835800f, 0.02838027f, -0.00750671f, -0.01735903f, 
    0.04484843f, -0.03509793f, -0.11427122f, 0.03590037f, -0.01972987f, -0.09652457f, -0.04489776f, 0.05642584f, 
    -0.00732201f, 0.02993213f, -0.04496494f, 0.08335090f, 0.00665267f, -0.05583711f, 0.07724653f, 0.11542657f, 
    -0.20252506f, -0.12494545f, 0.08196732f, -0.00744562f, 0.11234671f, 0.05251947f, 0.07472792f, -0.00920615f, 
    -0.02986062f, 0.01254621f, 0.00215309f, 0.06914282f, 0.00530639f, -0.20809163f, 0.00724344f, 0.05378822f, 
    0.02504858f, -0.03812924f, -0.03694791f, 0.01455702f, -0.10243034f, 0.08643413f, 0.14378203f, 0.06282444f, 
    -0.28973794f, 0.05095829f, 0.11887846f, -0.14438270f, 0.08649424f, -0.09197365f, -0.04371721f, 0.13756174f, 
    0.03199317f, -0.00722454f, -0.14711483f, 0.06698786f, -0.12290785f, 0.25594968f, -0.08835667f, 0.15182284f, 
    0.04298258f, 0.00705749f, 0.05406668f, -0.15288971f, 0.06316539f, -0.02884110f, -0.04072876f, -0.00332570f, 
    -0.02837618f, -0.15450865f, -0.00656004f, -0.12365340f, 0.02840349f, 0.07399808f, 0.13723284f, 0.00488260f, 
    -0.00574281f, 0.04795599f, 0.09635957f, 0.06649611f, 0.23956162f, -0.31837252f, 0.22717713f, 0.00778800f, 
    0.04973822f, 0.02892159f, 0.05206527f, 0.03732985f, -0.06975979f, 0.00060440f, -0.03740111f, -0.08075815f, 
    -0.06297346f, -0.10836952f, 0.04058067f, -0.24150237f, 0.03515344f, -0.01866387f, 0.04393148f, 0.07308795f, 
    0.12156344f, 0.02844968f, -0.00745037f, 0.07267576f, -0.12039866f, -0.02523250f, 0.10773187f, -0.07019821f, 
    0.02108366f, 0.22903316f, 0.07112823f, 0.01959412f, 0.09056499f, 0.20195682f, 0.02987933f, 0.13867688f, 
    -0.34812558f, 0.16493857f, -0.04269338f, 0.26100478f, 0.00305481f, -0.04649115f, -0.05158522f, -0.05138095f, 
    0.18232128f, 0.07587313f, -0.11962883f, 0.17139141f, -0.10894757f, 0.01752994f, -0.12853944f, -0.09621885f, 
    0.07464619f, 0.10262365f, -0.08798943f, -0.04041425f, -0.02045248f, -0.06519184f, 0.05295002f, 0.02587507f, 
    0.05693726f, -0.11806363f, -0.05521945f, 0.13412641f, 0.00521422f, 0.01480414f, 0.09159585f, 0.04130561f, 
    -0.14336719f, 0.01953407f, 0.18029234f, -0.03241065f, -0.15947279f, -0.10427100f, -0.18824244f, -0.00288128f, 
    -0.02269007f, -0.02495175f, -0.02505067f, 0.08593082f, 0.04807870f, -0.04859027f, 0.04795586f, 0.07872175f, 
    0.00314690f, 0.04825195f, -0.03670479f, 0.02199366f, 0.00003282f, 0.02129806f, 0.05810076f, -0.05211965f, 
    0.06558028f, -0.03524972f, 0.03233437f, -0.06209115f, 0.00541299f, -0.02169596f, -0.07087696f, 0.01801641f, 
    -0.07376447f, -0.01674876f, 0.00810588f, 0.02835526f, 0.02827839f, 0.05802636f, -0.04099325f, 0.03010604f, 
    -0.03335965f, 0.06378732f, 0.03200808f, -0.00101653f, -0.00956109f, -0.04527009f, -0.06969434f, 0.05238407f, 
    -0.04291514f, -0.03855268f, -0.01325626f, -0.07815783f, -0.06908832f, -0.01180036f, 0.06177603f, 0.02796862f, 
    -0.05744577f, -0.05066890f, 0.00700987f, -0.07458401f, 0.03099179f, 0.05393970f, -0.04397441f, -0.07415083f, 
    -0.03041435f, -0.06461726f, -0.03710022f, -0.02671415f, -0.03782747f, -0.05948308f, -0.00576531f, -0.06258351f, 
    -0.05212869f, -0.05450258f, -0.05180934f, 0.04099240f, 0.00305541f, -0.04827981f, -0.07256439f, -0.06591845f, 
    0.04379382f, 0.05966713f, 0.01702698f, 0.05418321f, -0.03002479f, 0.01669575f, -0.05670352f, -0.02158602f, 
    0.00876574f, 0.00974304f, 0.04048612f, -0.05839833f, -0.07035027f, -0.03126840f, 0.00722761f, -0.02515762f, 
    -0.06511413f, -0.01049182f, 0.01609941f, -0.03394831f, -0.03116595f, -0.00630947f, 0.04382567f, 0.02331921f, 
    0.00294536f, 0.01403170f, -0.00700429f, -0.07670281f, -0.01141246f, 0.06485529f, -0.02612913f, -0.04321842f, 
    -0.07804384f, -0.02637073f, -0.02841279f, 0.00986597f, -0.04749297f, -0.01342981f, -0.03508891f, 0.00412744f, 
    -0.05752844f, 0.01366939f, -0.00037232f, -0.05586890f, -0.04067768f, 0.05672922f, -0.07718094f, -0.04587455f, 
    0.00344585f, -0.01023424f, 0.05740980f, 0.03013591f, -0.00837974f, 0.03580291f, -0.06416013f, 0.04320811f, 
    -0.01696888f, -0.06238173f, 0.01851064f, -0.01930632f, 0.00360292f, -0.05441491f, 0.05863988f, 0.03324950f, 
    -0.07553575f, -0.04155831f, -0.00863607f, 0.03659195f, -0.03508236f, 0.05302228f, 0.02249651f, -0.03808669f, 
    -0.05801489f, 0.05604686f, 0.06035937f, 0.01667795f, -0.00891686f, 0.04448732f, -0.02843376f, -0.06259818f, 
    -0.06002272f, 0.02982227f, -0.01367494f, -0.07809123f, 0.01658027f, 0.02665983f, 0.01239562f, -0.01250430f, 
    -0.02627488f, 0.02462934f, 0.02030638f, -0.04341305f, -0.03728240f, -0.06358635f, 0.00731129f, -0.02632686f, 
    0.05421863f, 0.02375845f, -0.04323189f, 0.00579939f, -0.04873078f, 0.01067815f, -0.01706911f, 0.00938154f, 
    0.05179892f, 0.00167939f, -0.03786544f, -0.04851840f, -0.01664167f, -0.03014571f, 0.03187608f, 0.02433357f, 
    -0.02377021f, -0.03164117f, 0.01005048f, -0.02443241f, 0.06086123f, 0.02126352f, -0.02581695f, 0.06176708f, 
    -0.01763811f, -0.01080257f, -0.00273109f, 0.06450182f, -0.00072077f, 0.02477345f, 0.02667963f, -0.01919749f, 
    0.01088355f, 0.09330501f, -0.03309638f, -0.14661388f, 0.04404181f, 0.02118904f, 0.02582138f, 0.09458406f, 
    -0.09661677f, 0.01591250f, 0.05175859f, -0.16013220f, 0.24936043f, -0.17571521f, -0.06588316f, 0.09654391f, 
    -0.01760066f, 0.02338088f, -0.08971905f, -0.01406021f, -0.20446818f, -0.05926165f, 0.08484568f, 0.08542657f, 
    -0.10472804f, -0.12452586f, 0.11304153f, 0.17391631f, -0.07342238f, 0.08840413f, 0.04242092f, -0.01421128f, 
    -0.03524049f, -0.14476611f, -0.10777338f, 0.06852552f, -0.05833261f, 0.05483729f, 0.07459260f, -0.20368230f, 
    0.07141560f, 0.14347287f, -0.04839763f, 0.02346327f, 0.21005186f, 0.00986678f, 0.06219587f, 0.15292871f, 
    -0.14809854f, -0.04522510f, -0.05717989f, 0.15946333f, -0.00081810f, -0.05380696f, -0.00340669f, 0.01993047f, 
    -0.10141319f, -0.04106479f, -0.02954748f, -0.09161176f, 0.17770937f, -0.05436489f, -0.05410332f, 0.18340901f, 
    -0.13209443f, 0.05892750f, -0.03423894f, 0.02417134f, 0.01270285f, -0.06718273f, -0.05402357f, 0.03850624f, 
    -0.37283066f, -0.14485888f, 0.12088542f, 0.05540938f, 0.08900855f, 0.01143848f, 0.04060134f, -0.01890567f, 
    -0.06576103f, 0.01409107f, -0.02542998f, -0.02986916f, 0.22626048f, 0.04230802f, 0.01787476f, -0.12927780f, 
    0.13150914f, 0.12917562f, -0.04431203f, -0.01113670f, -0.04166636f, 0.14011720f, 0.03098951f, 0.02670300f, 
    -0.16973570f, 0.05723757f, 0.07048807f, -0.02384807f, 0.10618886f, -0.05806515f, -0.06189442f, 0.09569277f, 
    -0.11195782f, -0.04779800f, 0.06328242f, 0.09259660f, -0.34132811f, 0.16549920f, 0.08110522f, -0.07517277f, 
    -0.02141018f, 0.08649935f, 0.02186562f, 0.08061834f, 0.14843071f, -0.00292754f, -0.03850832f, 0.09843957f, 
    -0.04080982f, -0.03811726f, -0.14318852f, 0.19797377f, -0.01950565f, 0.00262554f, -0.10843994f, 0.04261977f, 
    -0.00626560f, 0.18573609f, -0.06845279f, 0.02810518f, -0.05729655f, 0.10528059f, -0.06098881f, 0.20801678f, 
    0.07744259f, 0.11592146f, -0.00941981f, 0.13035129f, 0.11301904f, 0.06087983f, 0.09405802f, 0.07163575f, 
    0.19185305f, -0.14794165f, -0.01427381f, -0.15242536f, 0.07958598f, 0.08184570f, -0.09860221f, -0.04681095f, 
    -0.04989537f, -0.07999688f, 0.08013704f, -0.12945624f, 0.05998850f, 0.00585839f, 0.23718363f, 0.20461711f, 
    -0.06884824f, 0.16476369f, -0.01696855f, 0.08318474f, -0.06341931f, -0.09017792f, -0.01047204f, 0.11869535f, 
    -0.31342119f, 0.14993392f, 0.03647685f, -0.11624599f, 0.17257433f, -0.08559383f, 0.02187109f, -0.13489263f, 
    0.03257059f, -0.05822399f, -0.03414292f, -0.09569163f, 0.27214539f, 0.07575233f, 0.01401520f, 0.00355361f, 
    0.05868532f, -0.06461819f, 0.03764722f, 0.07841013f, 0.10937824f, 0.19042659f, 0.00606290f, -0.03340538f, 
    -0.07189012f, -0.00224630f, -0.03559290f, -0.01843807f, 0.01416213f, 0.06523953f, -0.05342763f, 0.01599924f, 
    0.01274098f, 0.04944137f, -0.06582777f, 0.06471600f, -0.06607134f, -0.00931233f, -0.01237664f, -0.00303881f, 
    -0.03354152f, -0.06267133f, -0.04008680f, 0.00220527f, 0.01231928f, -0.06852073f, 0.01276876f, -0.07462627f, 
    0.03221691f, -0.00680520f, 0.03752925f, -0.04338555f, -0.04577573f, 0.02956500f, 0.02821714f, -0.06010127f, 
    -0.03143352f, -0.06432754f, -0.07318044f, -0.00320967f, -0.02141651f, 0.04212402f, 0.03226936f, 0.06228929f, 
    0.04227813f, 0.03423515f, 0.00310734f, -0.00361484f, -0.07388950f, -0.03010231f, -0.00751893f, -0.02042765f, 
    -0.01513988f, 0.03264609f, -0.07592698f, -0.01859770f, -0.06247234f, 0.06512500f, -0.00073978f, -0.03685966f, 
    0.02383617f, 0.03812467f, -0.06549317f, -0.05999867f, -0.00124875f, 0.02578275f, -0.01156687f, -0.03982629f, 
    0.05340735f, -0.01732290f, -0.03234050f, 0.04827869f, -0.01529632f, -0.01500711f, 0.02370535f, 0.06657084f, 
    -0.00305929f, 0.03189025f, -0.04451550f, -0.01283303f, -0.03198747f, -0.02498728f, -0.02322295f, -0.04980716f, 
    -0.05529943f, -0.07032958f, 0.04217906f, -0.00248687f, -0.02229747f, -0.03685344f, 0.02728148f, -0.00244412f, 
    0.00566033f, 0.02710028f, -0.01538532f, 0.00504866f, 0.00624108f, 0.06254253f, -0.07002146f, -0.07197467f, 
    -0.00956987f, -0.07729931f, -0.04915031f, -0.06426471f, -0.01818080f, -0.02734375f, -0.01573772f, 0.00084932f, 
    -0.03679066f, 0.02215359f, -0.06696144f, -0.02299515f, 0.02516919f, 0.00863359f, -0.00097665f, 0.01469292f, 
    -0.04181115f, 0.05361642f, 0.02538171f, 0.01834528f, 0.06796873f, 0.00192429f, 0.04545961f, 0.00937330f, 
    0.06010346f, -0.01039531f, 0.06529488f, -0.00667937f, -0.05721718f, 0.03245134f, -0.06040041f, -0.01885825f, 
    -0.06472560f, 0.06559620f, 0.00567967f, 0.00210560f, -0.03433887f, 0.05437032f, 0.04989988f, -0.07565925f, 
    -0.01312900f, -0.04305899f, -0.07367591f, -0.01164684f, -0.07604586f, -0.03976682f, -0.04204505f, -0.05985044f, 
    -0.01213330f, -0.03993306f, -0.02013166f, -0.05644119f, 0.04102201f, -0.04649648f, 0.00852442f, -0.05112795f, 
    -0.04477143f, 0.03029284f, -0.03140808f, 0.05849044f, 0.03037113f, 0.04521295f, 0.03702527f, -0.01094633f, 
    0.05689004f, -0.00634539f, -0.00955223f, -0.04274325f, -0.04747683f, -0.07404047f, -0.06930483f, -0.00280575f, 
    -0.04096449f, -0.01837648f, -0.03183969f, 0.03268839f, 0.05358191f, 0.02690015f, 0.05951929f, 0.04586004f, 
    -0.05813241f, 0.02003822f, 0.00714023f, -0.03499248f, -0.04866576f, -0.02324266f, -0.01428363f, 0.01537510f, 
    -0.04550035f, -0.05756718f, -0.01273349f, -0.00134124f, -0.00667189f, 0.06325360f, 0.03851550f, 0.04675933f, 
    -0.13183998f, 0.10338610f, -0.11331800f, -0.07009082f, -0.09000777f, -0.18965726f, -0.17685376f, -0.17178231f, 
    -0.05184173f, -0.21660866f, -0.21641211f, -0.08547409f, -0.11320552f, 0.07661271f, 0.26078868f, -0.13877018f, 
    -0.04650692f, -0.06782605f, 0.12712097f, 0.08940253f, 0.07292501f, 0.18191853f, 0.07737556f, 0.30429581f, 
    -0.06648199f, 0.02565843f, 0.09590964f, -0.05961202f, -0.02982143f, 0.02093065f, 0.04161810f, 0.11017204f, 
    0.11324677f, -0.00331238f, 0.03427537f, -0.02083251f, 0.14144775f, 0.22437266f, -0.02632897f, 0.03698125f, 
    0.01142553f, -0.05724765f, -0.14482166f, -0.00553696f, -0.02962035f, -0.37181219f, -0.02690199f, -0.01978805f, 
    -0.06447902f, -0.08121221f, 0.10931307f, -0.22427432f, 0.06201329f, -0.23711480f, -0.22383544f, 0.02093732f, 
    -0.08295587f, 0.12450840f, 0.06073849f, 0.02606784f, 0.15238988f, -0.29659387f, -0.12515812f, 0.16495393f, 
    -0.16115141f, -0.10462859f, -0.11653905f, 0.17374103f, -0.05529135f, -0.17891091f, 0.16452123f, 0.25106585f, 
    -0.04190069f, 0.06549085f, -0.00474704f, -0.12755427f, 0.16265903f, -0.06708173f, 0.18383101f, 0.22681963f, 
    0.06210089f, 0.19671248f, 0.15682554f, 0.11159866f, 0.08535869f, 0.07807903f, 0.09463643f, 0.11603112f, 
    0.03787786f, 0.10120083f, 0.04692468f, 0.08191503f, 0.04411756f, -0.09210218f, 0.15486829f, 0.03443395f, 
    -0.04815398f, -0.06819547f, -0.04420413f, -0.04682579f, -0.19903097f, -0.03220019f, 0.07261725f, 0.02019354f, 
    0.09206721f, 0.00799269f, -0.10971186f, 0.10781322f, 0.02597707f, -0.04624287f, 0.02379397f, 0.36448824f, 
    0.10447858f, -0.00654195f, 0.03336143f, 0.12833239f, -0.04574097f, 0.15538396f, 0.05900322f, 0.03899765f, 
    -0.08136969f, -0.18847810f, -0.18127011f, 0.16703172f, 0.07117163f, -0.01088267f, -0.05097058f, -0.03844114f, 
    -0.11573970f, -0.00232593f, -0.04452337f, 0.11006654f, -0.11636987f, -0.16947451f, -0.04448892f, -0.15885293f, 
    -0.13878791f, -0.10627672f, -0.00302823f, -0.06829760f, 0.00909115f, -0.17876674f, -0.12762718f, 0.01369255f, 
    -0.01194322f, 0.12211864f, 0.14931977f, 0.09619203f, -0.12886755f, 0.10244619f, 0.05804285f, 0.00340044f, 
    0.07134669f, -0.00876978f, -0.01951182f, -0.09438182f, -0.20902877f, -0.22801331f, 0.11159874f, 0.07697556f, 
    -0.21523355f, 0.15126070f, -0.01231938f, 0.13297281f, -0.14309829f, -0.08114397f, 0.04375390f, -0.05701645f, 
    0.25916776f, 0.13425253f, 0.03220128f, 0.11123487f, 0.06327372f, -0.06791795f, -0.03631015f, -0.07959582f, 
    -0.00215698f, -0.25078321f, 0.02101821f, -0.09366877f, 0.09625444f, -0.13478670f, -0.23505588f, -0.16582072f, 
    0.10999859f, 0.03500436f, -0.12047610f, 0.08005137f, -0.04328866f, -0.06777447f, -0.06727187f, -0.19227017f, 
    -0.02485063f, -0.04152332f, -0.14047040f, 0.11860088f, 0.00888533f, 0.03411134f, 0.04335532f, 0.05639420f, 
    0.05892279f, 0.10423945f, 0.02905433f, -0.01207559f, -0.22699079f, 0.25188187f, -0.11144682f, -0.15822926f, 
    0.14599392f, 0.03325188f, 0.08678719f, -0.05930335f, -0.04598778f, 0.08085658f, -0.01776811f, 0.11451986f, 
    -0.16408895f, -0.07027885f, -0.20686489f, -0.20472623f, 0.15581818f, 0.00021348f, -0.00357169f, -0.06972542f, 
    0.03763106f, -0.09385531f, -0.19211121f, 0.01802540f, 0.06252503f, -0.04975189f, 0.04895424f, 0.27516955f, 
    0.13119167f, 0.02382148f, 0.02932918f, -0.06282829f, -0.11572567f, -0.03589866f, 0.01216070f, 0.06498264f, 
    -0.05612240f, 0.04264817f, -0.01752215f, -0.00549360f, -0.05492602f, -0.02496533f, -0.16115077f, 0.07751456f, 
    -0.08356573f, 0.04367341f, -0.06352003f, -0.04347251f, 0.11894292f, -0.25398436f, 0.12523018f, 0.22655782f, 
    -0.03172649f, 0.05087425f, 0.03703510f, 0.02854084f, 0.04860859f, 0.02894562f, 0.11121593f, 0.11781512f, 
    -0.19608791f, 0.15096039f, -0.10881857f, -0.17919959f, 0.08046682f, -0.07389952f, -0.02848467f, 0.04499443f, 
    0.03893513f, 0.10670701f, 0.14234781f, 0.09032098f, -0.25909543f, 0.24674089f, -0.04925559f, 0.04511749f, 
    0.08889173f, -0.01982783f, 0.11682663f, -0.01130667f, 0.09133165f, -0.00201558f, -0.02186947f, 0.02786055f, 
    0.14583284f, 0.02754381f, -0.05842259f, 0.06751665f, 0.02623937f, 0.00369551f, 0.01968799f, 0.08476562f, 
    0.03182371f, 0.06882534f, 0.09927733f, 0.01316682f, 0.09353177f, -0.15075280f, 0.18184805f, 0.21316138f, 
    -0.14850959f, 0.05379504f, -0.07264909f, -0.05036046f, 0.05715982f, -0.04051486f, -0.00701713f, -0.00638060f, 
    0.06481181f, 0.06688959f, 0.14495720f, 0.15171424f, -0.04655934f, -0.19818167f, -0.13562177f, -0.05125910f, 
    0.02248286f, 0.04913892f, 0.01200902f, 0.01363382f, 0.10526209f, 0.01497514f, 0.11738141f, 0.09993963f, 
    0.07456168f, 0.17680128f, -0.02296503f, -0.03991290f, 0.00681529f, 0.00883532f, 0.08178536f, -0.06908052f, 
    -0.01373157f, -0.04629493f, -0.09684267f, 0.18327162f, 0.00489342f, 0.03057884f, 0.13513540f, 0.03709401f, 
    0.00298488f, -0.01943550f, -0.09918291f, -0.05896280f, -0.05342802f, 0.00213604f, 0.03372050f, 0.18049201f, 
    0.02103200f, 0.19338328f, -0.03402239f, 0.04497740f, 0.04354079f, -0.04912858f, 0.06889223f, 0.07087215f, 
    -0.17367505f, 0.06059325f, -0.02594621f, 0.15866075f, 0.00947271f, -0.07043977f, 0.06707715f, -0.04992600f, 
    0.01328515f, -0.01383458f, -0.01004715f, -0.03939019f, 0.17298155f, -0.03123865f, -0.04999640f, 0.21846651f, 
    0.05732824f, -0.04965367f, 0.01597550f, 0.05654046f, -0.00586794f, -0.03534140f, 0.08013758f, 0.02692774f, 
    -0.01381047f, 0.01014534f, -0.00864630f, 0.06410048f, -0.01365785f, -0.03275625f, -0.06505813f, 0.05561168f, 
    -0.06266169f, 0.03160255f, 0.03920390f, 0.04277609f, -0.01478897f, 0.00447439f, 0.04912312f, -0.00289003f, 
    -0.05036558f, 0.02629819f, -0.01820568f, 0.04467365f, -0.00667824f, 0.05904777f, -0.07212544f, -0.04497169f, 
    -0.05352859f, 0.01168836f, -0.00435027f, -0.00913891f, 0.00356246f, 0.00790568f, 0.00329280f, 0.00643811f, 
    0.04097449f, -0.07560273f, -0.01503531f, -0.00027844f, -0.03825593f, -0.04851137f, -0.04489399f, -0.03871045f, 
    -0.03236381f, -0.03742248f, 0.01284756f, -0.02914234f, 0.00508658f, -0.06589925f, -0.02129708f, 0.01499418f, 
    -0.04759630f, -0.05143821f, 0.02986318f, -0.04105243f, 0.00621907f, -0.06826413f, -0.03985634f, -0.06580909f, 
    0.04972418f, 0.01122875f, -0.00469521f, -0.07189234f, 0.05821327f, 0.02413522f, 0.02390883f, -0.02559823f, 
    -0.04057510f, 0.03794022f, -0.04859555f, 0.02606241f, 0.05584331f, 0.00298791f, -0.06239952f, 0.05116053f, 
    -0.02270392f, -0.06173624f, 0.04997497f, -0.05404504f, -0.04533555f, -0.02171856f, -0.04065289f, -0.05150613f, 
    0.01347233f, 0.05047733f, -0.01916329f, 0.02488970f, -0.05976811f, -0.06770034f, -0.06703942f, -0.01375882f, 
    0.04034499f, 0.02809139f, -0.00276379f, -0.05159125f, 0.01665917f, -0.06954574f, 0.00916551f, 0.02112681f, 
    -0.04095633f, 0.03139676f, -0.04034473f, 0.00811227f, 0.02464463f, -0.04537628f, 0.05119500f, 0.00540886f, 
    -0.04047260f, 0.06653748f, -0.00476125f, -0.02301877f, -0.02264896f, 0.03431224f, 0.02933290f, -0.04115195f, 
    -0.06162308f, -0.06440963f, -0.02883800f, -0.06175752f, -0.03780979f, 0.06089541f, -0.04808528f, 0.01833525f, 
    -0.06660178f, 0.01650735f, -0.06683344f, -0.01539287f, -0.00433035f, -0.00279692f, -0.06615309f, -0.01475362f, 
    -0.03916904f, -0.06017828f, -0.00970247f, -0.04682662f, -0.04778663f, -0.01272868f, 0.02346884f, -0.06503940f, 
    0.02365181f, -0.02558102f, -0.01339611f, -0.06224224f, 0.00612601f, -0.02237920f, 0.05275687f, 0.01625686f, 
    -0.01322582f, 0.00144788f, 0.01483229f, 0.01867125f, -0.00065610f, 0.05890326f, 0.04211176f, 0.02396008f, 
    0.03225338f, -0.02015613f, -0.02190555f, -0.02435931f, -0.01204263f, -0.05835921f, 0.01886065f, -0.05965389f, 
    -0.07379468f, -0.01018844f, -0.05740063f, 0.06302644f, -0.03638001f, -0.04129924f, 0.02625704f, -0.07603090f, 
    -0.03196252f, 0.00564099f, -0.04527902f, -0.03582714f, 0.05318076f, -0.06922247f, 0.03527935f, -0.01641067f, 
    0.01094989f, 0.04039880f, 0.04677527f, 0.00288034f, -0.01756367f, -0.02991674f, -0.03787719f, -0.00940140f, 
    -0.07625050f, -0.06857163f, -0.06811804f, 0.02918341f, 0.05077358f, 0.05196401f, 0.03402959f, -0.01528251f, 
    -0.12920998f, -0.02184934f, -0.09939294f, -0.00850717f, 0.09211820f, 0.05233045f, 0.03140540f, 0.03572945f, 
    -0.04563401f, 0.10563108f, 0.08672696f, 0.26267081f, 0.19512345f, 0.34503314f, -0.03194543f, -0.09881323f, 
    -0.01833588f, -0.06414679f, 0.11402141f, 0.00448712f, 0.05545163f, -0.17491817f, -0.14262652f, -0.09006161f, 
    0.01271765f, -0.12647703f, -0.18119963f, -0.15599242f, 0.05045996f, -0.08910193f, -0.01615022f, -0.04815916f, 
    -0.01541155f, 0.12258458f, 0.19495337f, 0.00931629f, 0.15033466f, -0.25173223f, -0.02980702f, -0.30566454f, 
    -0.05112294f, -0.12061819f, 0.10958236f, 0.16370057f, -0.10006999f, -0.02052228f, -0.14073397f, -0.12858903f, 
    -0.00969497f, 0.03825329f, 0.13250394f, 0.00202184f, 0.11461067f, -0.10189464f, 0.20284010f, 0.00390114f, 
    0.00619900f, 0.07929792f, 0.02292727f, 0.08771907f, 0.17730990f, -0.05017465f, -0.01249287f, -0.09255780f, 
    -0.11860541f, -0.01979520f, 0.17271148f, 0.03183309f, 0.09505718f, 0.34548354f, 0.05996108f, 0.25405130f, 
    -0.29468685f, 0.19945362f, -0.08600445f, 0.05452361f, -0.02780344f, -0.01818313f, -0.03353843f, 0.14483412f, 
    -0.02778507f, 0.01134260f, 0.04319082f, -0.21541655f, -0.03688162f, 0.03439087f, -0.20950820f, 0.17286253f, 
    0.15781872f, 0.05616361f, 0.05612762f, -0.10865224f, -0.08038724f, 0.05119471f, 0.01203743f, -0.02104308f, 
    -0.14385837f, 0.14750300f, 0.01172787f, -0.04952227f, 0.16015486f, -0.02143396f, -0.04235866f, -0.05542325f, 
    0.03460193f, 0.08411313f, 0.03926421f, -0.10997020f, -0.00081501f, 0.01413585f, 0.17491466f, 0.03342129f, 
    0.00351702f, 0.00192766f, -0.05403058f, 0.01899073f, -0.16248253f, 0.04387930f, -0.04238072f, 0.01968957f, 
    0.09225741f, 0.05403420f, 0.04817429f, -0.05719622f, 0.00017511f, 0.15439740f, 0.11037289f, 0.02369741f, 
    0.10608119f, -0.07940190f, 0.05952356f, -0.02330576f, 0.02536716f, -0.07577728f, -0.00421097f, -0.01503275f, 
    0.04401033f, 0.04809859f, -0.11235673f, 0.01172843f, 0.01759856f, 0.17252521f, -0.06965976f, -0.25563610f, 
    -0.18599401f, -0.07428295f, 0.01591544f, 0.03515360f, 0.01518412f, -0.12829410f, 0.07354759f, 0.11165366f, 
    0.06328693f, 0.15696855f, -0.12704642f, 0.20383553f, 0.02986308f, -0.03438279f, -0.21006437f, -0.01133976f, 
    0.02209058f, -0.01509590f, -0.19283457f, 0.05533459f, 0.02124165f, -0.08088032f, 0.00693969f, 0.02295750f, 
    0.28969967f, -0.21585682f, -0.02826266f, -0.28259829f, 0.06187130f, 0.18006906f, -0.08000549f, 0.17268170f, 
    -0.00315008f, 0.02556841f, 0.01654431f, 0.09543759f, 0.14900549f, 0.05264945f, 0.09711038f, 0.31255722f, 
    -0.17288436f, -0.08160279f, 0.15977569f, -0.11576458f, -0.06850366f, -0.11473780f, 0.11462915f, 0.04928602f, 
    0.04683251f, 0.01459730f, 0.00669555f, 0.02908184f, -0.02252560f, -0.02455226f, -0.02628006f, -0.01826881f, 
    -0.07558641f, -0.02762424f, 0.08903111f, 0.27638617f, 0.24694632f, 0.25554296f, 0.09799617f, -0.10269771f, 
    0.04694065f, -0.15340559f, 0.10180462f, -0.12918425f, 0.04349912f, -0.15026376f, -0.06609669f, -0.05488943f, 
    0.00701530f, -0.08124337f, -0.05886344f, -0.12579422f, -0.01361138f, -0.07626005f, -0.09220567f, -0.02056718f, 
    -0.01444089f, 0.16341852f, 0.24850364f, -0.01623316f, 0.19484712f, -0.08846252f, 0.01980889f, -0.01015169f, 
    0.09211470f, -0.26377824f, 0.05393341f, 0.16614306f, -0.05934513f, -0.10892823f, -0.20877650f, -0.21067977f, 
    0.24090444f, 0.03696889f, 0.03849673f, -0.04800669f, 0.04975984f, -0.09852543f, 0.11921854f, -0.12723927f, 
    0.03447060f, 0.20829266f, -0.02169575f, 0.23976129f, 0.15955493f, -0.00584392f, -0.09410167f, 0.01952240f, 
    -0.15761286f, 0.10216489f, 0.18118586f, 0.12213279f, 0.01003242f, 0.33068040f, 0.13716297f, 0.26272476f, 
    0.07110828f, 0.16340204f, 0.01840096f, 0.10065673f, 0.07177318f, 0.06855440f, 0.05019366f, -0.00824268f, 
    -0.05167250f, 0.05501579f, -0.03565579f, -0.24132784f, -0.17792366f, 0.02008132f, -0.22591516f, 0.01013088f, 
    0.12529013f, 0.07801323f, 0.09083373f, -0.03110450f, -0.04744050f, -0.03541085f, -0.02512053f, 0.08734792f, 
    -0.00082967f, 0.10266877f, 0.15333579f, -0.12759764f, 0.07872282f, -0.11346442f, -0.08852286f, 0.06031351f, 
    -0.01094351f, 0.06665695f, -0.07544164f, -0.06177106f, 0.06768384f, 0.10994346f, 0.08873042f, 0.05870286f, 
    0.19585001f, -0.06716599f, -0.01783913f, -0.16026017f, -0.10901339f, -0.10628295f, -0.12049174f, 0.01826410f, 
    0.04025082f, 0.12134502f, 0.00886530f, 0.11629214f, 0.09200075f, 0.17413829f, 0.14694287f, -0.25035828f, 
    -0.02047252f, -0.07520930f, -0.03197004f, 0.00535514f, 0.07566364f, -0.11887042f, 0.12115805f, 0.04270684f, 
    -0.00337626f, -0.05854068f, -0.07146829f, 0.00595444f, -0.16558109f, 0.14653650f, -0.14803645f, -0.21011733f, 
    -0.26838395f, -0.20874183f, -0.01767952f, -0.04294769f, 0.02868459f, -0.13682032f, 0.20528629f, 0.10296737f, 
    0.02399702f, 0.24106246f, -0.08410151f, 0.15639789f, 0.04440711f, -0.12558085f, -0.09034117f, 0.05654362f, 
    -0.10382239f, 0.01366268f, -0.06386454f, 0.12412657f, -0.01977083f, -0.05602281f, 0.08512019f, 0.02484419f, 
    0.40889168f, 0.02358215f, 0.01402307f, -0.22401580f, -0.01865108f, 0.05598759f, -0.01790130f, 0.22506993f, 
    -0.03655312f, 0.05793083f, 0.08029290f, 0.13202177f, 0.15396410f, 0.01887576f, 0.00894251f, 0.34321815f, 
    -0.18515183f, 0.03759975f, -0.01315450f, -0.11485998f, -0.00995504f, -0.08194332f, 0.12989073f, 0.03595019f, 
    0.19377330f, -0.02817540f, -0.03924141f, -0.04929551f, -0.09654276f, 0.08909479f, -0.22324194f, 0.11178297f, 
    0.06310274f, 0.03696349f, -0.11670962f, -0.05602555f, -0.06705911f, -0.00849661f, 0.23175775f, 0.01677802f, 
    0.01325139f, -0.05411769f, 0.01951811f, 0.04997284f, 0.08584151f, 0.08501832f, 0.09961634f, -0.08122260f, 
    0.28231958f, 0.30712473f, 0.04172531f, 0.28891218f, 0.06630325f, 0.01337300f, 0.04502402f, -0.03048355f, 
    -0.01105618f, 0.01548630f, 0.18326440f, -0.02918094f, 0.07700372f, -0.07691791f, 0.12139806f, -0.05096497f, 
    -0.01532763f, 0.00742801f, 0.01064574f, 0.10933125f, 0.07261727f, 0.01764164f, 0.00541012f, -0.04897840f, 
    -0.07934544f, -0.03089966f, -0.20024961f, 0.26784623f, 0.07196450f, 0.03974410f, 0.06370482f, 0.09594946f, 
    0.08608707f, -0.07305301f, -0.01032195f, 0.05718273f, -0.11810038f, 0.03346609f, 0.00688197f, -0.41840455f, 
    0.09685142f, -0.07074690f, -0.02629509f, -0.12356785f, -0.07439477f, -0.01768271f, -0.04085330f, -0.10000072f, 
    0.43260199f, -0.12376983f, -0.08773936f, 0.04807477f, -0.07750051f, 0.04614685f, -0.00002662f, -0.03278949f, 
    0.10059173f, -0.05765330f, -0.04440498f, -0.01670877f, 0.16877703f, 0.06851591f, 0.17094399f, -0.02363729f, 
    -0.00619208f, -0.02209902f, -0.00827326f, -0.01405171f, 0.00421723f, 0.07462740f, -0.04445013f, 0.01594765f, 
    -0.07962769f, -0.02366862f, -0.05453127f, 0.14180008f, 0.02408156f, -0.00948219f, 0.10166574f, 0.03156633f, 
    0.08679596f, 0.07354855f, -0.01120938f, -0.01488951f, 0.18831438f, -0.04547186f, -0.12800682f, -0.10423110f, 
    0.08077630f, 0.12342392f, 0.08920307f, 0.03781864f, 0.03408842f, -0.08516730f, -0.03472709f, -0.06603491f, 
    -0.06530576f, 0.08789673f, 0.07334124f, -0.29510146f, -0.00443913f, 0.06152553f, 0.00971322f, 0.13199921f, 
    0.05327686f, -0.09244373f, 0.13201819f, 0.01611590f, -0.02023932f, -0.21442007f, 0.02482978f, -0.08784835f, 
    0.03461319f, -0.02854610f, 0.18486452f, 0.01270091f, -0.01498607f, -0.04124656f, 0.04867133f, -0.02966377f, 
    0.24615589f, 0.13042970f, 0.15583332f, -0.11401571f, 0.07017452f, 0.04147062f, 0.04484187f, 0.07476799f, 
    -0.03606986f, -0.08639698f, 0.01407249f, 0.04426233f, -0.06854784f, 0.20788953f, -0.20791262f, -0.28228167f, 
    0.05247965f, -0.10228156f, 0.11017042f, -0.02196783f, -0.00987825f, 0.06429045f, -0.04137618f, -0.01573550f, 
    0.25489262f, -0.10652011f, 0.10130314f, -0.04501994f, 0.03521365f, 0.03100822f, -0.02026343f, 0.04381209f, 
    -0.01566156f, 0.01719203f, 0.01955436f, 0.00827402f, -0.26337305f, -0.14143403f, 0.07861605f, -0.03748608f, 
    0.04402316f, 0.06855272f, 0.13551211f, 0.07506227f, 0.11777934f, -0.07525223f, -0.09966183f, 0.11329795f, 
    -0.03388810f, -0.02429716f, -0.03135083f, -0.03768132f, 0.00281500f, -0.05840043f, 0.03476953f, 0.05504058f, 
    0.03148346f, -0.07813338f, -0.01821997f, 0.01389720f, 0.05630749f, -0.01977840f, -0.02821299f, 0.05051074f, 
    -0.02366631f, 0.03675231f, -0.07429999f, 0.04735846f, -0.03400872f, 0.01853541f, 0.01873726f, -0.03715318f, 
    0.03966108f, 0.03816429f, 0.04671190f, -0.07090605f, -0.06323956f, 0.00818233f, -0.02422845f, -0.08611687f, 
    -0.01066349f, 0.04089467f, -0.05954273f, 0.00404737f, 0.06222191f, 0.04367451f, 0.01290850f, 0.00708742f, 
    0.00223670f, -0.07508724f, -0.02153484f, -0.04094854f, -0.00902607f, -0.06002012f, -0.06080918f, 0.03281750f, 
    -0.00531366f, -0.00498403f, -0.10798368f, -0.03484178f, -0.01825428f, -0.03357722f, 0.00695230f, -0.08937878f, 
    -0.03239248f, 0.03738534f, -0.04200810f, -0.04158389f, 0.05167387f, -0.03235186f, 0.03684611f, 0.03362002f, 
    0.04330460f, -0.08266777f, -0.08153316f, -0.07263393f, 0.01246271f, -0.01729890f, 0.06360833f, 0.01620869f, 
    0.00226288f, 0.01841734f, -0.04052852f, -0.02244005f, 0.00869563f, 0.02986940f, -0.02023696f, -0.10911217f, 
    -0.07640019f, -0.03887793f, -0.00941523f, 0.05619239f, -0.02261250f, -0.07899997f, -0.06001356f, -0.05258285f, 
    -0.07097190f, -0.07433172f, 0.04522911f, -0.02241470f, -0.04521224f, -0.05677718f, 0.05090667f, -0.05039184f, 
    0.04148220f, -0.08462607f, 0.00085550f, -0.04669954f, 0.03903891f, 0.00855969f, 0.02714804f, 0.02882880f, 
    -0.01854929f, -0.02486581f, -0.08566326f, -0.09365536f, 0.00431689f, -0.03192553f, 0.00360047f, 0.01778466f, 
    -0.06494547f, -0.05502440f, 0.04410806f, 0.03568731f, 0.02711653f, 0.04737211f, 0.00760307f, -0.01415161f, 
    -0.09153217f, -0.07158839f, -0.03379151f, 0.00703973f, -0.08310090f, 0.01922608f, -0.01541009f, -0.02876261f, 
    0.04446538f, -0.04377494f, 0.03987253f, -0.05229636f, -0.06059887f, -0.10204818f, -0.01237591f, 0.03133965f, 
    -0.07935092f, -0.01851478f, 0.06270651f, 0.05661824f, 0.05993088f, -0.06132090f, 0.02487701f, 0.00501454f, 
    -0.01689117f, 0.04255905f, -0.05838679f, 0.03194465f, -0.06055183f, -0.06518105f, -0.05585828f, -0.05756330f, 
    -0.02089240f, -0.06212428f, 0.04051403f, -0.05494156f, 0.01156160f, 0.03749900f, -0.01510040f, -0.03659932f, 
    0.00609139f, -0.06006330f, 0.00283004f, -0.04668009f, -0.03684144f, -0.09121510f, -0.06472189f, -0.06129845f, 
    0.05951973f, 0.06228375f, -0.03253728f, -0.01685955f, -0.05076193f, 0.01921444f, 0.05332048f, 0.07967917f, 
    -0.01415736f, -0.02010616f, 0.03817450f, 0.01965566f, 0.04315880f, 0.02284586f, 0.00972467f, 0.05678973f, 
    -0.05064027f, -0.04713602f, -0.04060243f, -0.07070776f, -0.02305148f, -0.04599144f, -0.02612489f, -0.02098775f, 
    -0.04447631f, 0.06308149f, 0.10813364f, 0.13662566f, 0.05939706f, -0.01908573f, 0.02186382f, -0.03689045f, 
    0.00469260f, 0.04667807f, 0.03864948f, -0.03436695f, 0.31320742f, 0.12714213f, -0.08932208f, 0.29635224f, 
    0.18468510f, 0.03171464f, 0.04507599f, -0.09341221f, -0.24775214f, -0.08346746f, -0.04386003f, -0.02784739f, 
    0.25078079f, 0.04137896f, -0.06727687f, 0.37129053f, 0.06121393f, 0.01146585f, -0.00500333f, -0.02035966f, 
    0.01424147f, -0.04365279f, -0.12118959f, -0.00603761f, -0.02491033f, 0.10660431f, 0.13631253f, 0.16465516f, 
    0.08632974f, 0.09691612f, -0.04618793f, -0.02548246f, 0.15680771f, 0.03036221f, 0.12271049f, 0.12937501f, 
    -0.19441837f, 0.04070190f, -0.11759143f, -0.10803451f, -0.04394543f, 0.05919510f, -0.14117055f, -0.02125035f, 
    -0.04220819f, 0.05046147f, -0.00805918f, -0.02863301f, 0.32015830f, -0.22069220f, -0.10524183f, -0.09184912f, 
    -0.12426037f, -0.03099734f, -0.07421897f, -0.02560620f, 0.09978972f, 0.11209012f, 0.08394253f, 0.05895036f, 
    -0.28911507f, -0.23185180f, -0.13950807f, 0.20526880f, 0.01669434f, -0.03019939f, 0.07153425f, -0.08439586f, 
    -0.01439531f, 0.06842381f, -0.03037280f, 0.00116287f, 0.07495862f, 0.17504647f, -0.13378966f, 0.01971521f, 
    0.07523317f, 0.04148598f, 0.01687087f, -0.12879859f, -0.15393856f, 0.04121557f, 0.04167462f, 0.01907918f, 
    0.04778565f, -0.15003596f, 0.06224599f, -0.10000192f, -0.01724695f, -0.08380340f, -0.12330540f, 0.03903036f, 
    -0.08129767f, -0.03619250f, -0.07559390f, 0.05065228f, 0.23790014f, 0.04420479f, -0.19944832f, -0.01663167f, 
    0.03312776f, 0.17325734f, -0.00591374f, -0.01765391f, 0.05628984f, -0.01928789f, -0.01655675f, 0.05691785f, 
    -0.14692417f, -0.14104377f, -0.20641302f, 0.14782095f, -0.13002603f, -0.12199455f, -0.00384431f, -0.10488969f, 
    0.19450553f, 0.03701286f, -0.07690869f, -0.05781211f, 0.03328408f, -0.10282821f, 0.24745177f, -0.04661765f, 
    -0.02216832f, 0.16999042f, 0.04407250f, 0.11425420f, 0.13747390f, -0.02278827f, 0.16209303f, 0.01396049f, 
    0.18840162f, 0.13511191f, 0.14811242f, 0.06673928f, 0.05732381f, -0.05385068f, 0.07690403f, -0.09394395f, 
    -0.02598756f, 0.03899587f, 0.01086171f, -0.09795742f, -0.13613702f, -0.16754995f, -0.13538872f, -0.07527694f, 
    -0.05540175f, 0.22684748f, 0.08102562f, 0.04017218f, -0.01381902f, 0.05872129f, -0.10387539f, 0.03628908f, 
    -0.09402041f, 0.20710775f, 0.16916175f, 0.13566370f, 0.15543401f, -0.02302288f, -0.03805244f, 0.08152151f, 
    0.01732228f, 0.02225954f, 0.02517710f, -0.04658547f, -0.06954598f, 0.06364420f, -0.00320841f, 0.07007099f, 
    -0.04288786f, 0.04340436f, 0.00815063f, 0.05056277f, 0.04990307f, -0.06176648f, 0.06697624f, 0.00154461f, 
    0.03917834f, -0.03244990f, 0.09622769f, -0.12950128f, -0.09636491f, 0.04388394f, 0.09802796f, 0.12407634f, 
    -0.00060423f, 0.03222102f, -0.02239259f, 0.03116796f, -0.08130974f, -0.16531265f, 0.03115242f, -0.15953080f, 
    -0.13420536f, 0.02226492f, -0.10579987f, 0.21315704f, 0.08405908f, 0.10620788f, 0.07287887f, 0.19270636f, 
    -0.01962887f, 0.15622829f, 0.15749791f, -0.18769637f, -0.04643159f, 0.05960924f, 0.01915331f, 0.14348871f, 
    0.05227066f, 0.10433864f, -0.06087247f, 0.08336248f, 0.02764324f, 0.15802045f, -0.14352795f, 0.18832478f, 
    -0.00660597f, -0.02535021f, 0.03157899f, -0.12223354f, 0.02606106f, 0.00612071f, 0.04755021f, -0.03728061f, 
    0.20167463f, -0.06648961f, -0.05627554f, -0.06361488f, 0.06116758f, 0.00519719f, -0.09188211f, -0.00226484f, 
    -0.08691474f, -0.03219825f, 0.03954390f, -0.10285980f, -0.06969171f, 0.28218952f, 0.10556579f, 0.19397222f, 
    0.01853697f, 0.07555726f, -0.04243055f, -0.05349251f, -0.00864508f, -0.11741103f, -0.13746002f, -0.08499163f, 
    0.14413844f, 0.06778926f, 0.06095770f, -0.14738816f, -0.02146934f, 0.02968827f, -0.03033846f, 0.00589727f, 
    0.07674965f, 0.05238821f, 0.02181820f, 0.09589006f, 0.02006118f, -0.30675909f, 0.05361371f, -0.16120346f, 
    -0.15503252f, -0.00515242f, 0.00197385f, -0.02389308f, 0.02001410f, -0.04869794f, -0.03394900f, 0.01642403f, 
    0.02197120f, 0.07502406f, 0.09263651f, 0.03579937f, -0.03326703f, 0.07932087f, 0.06119907f, -0.06210183f, 
    -0.00304003f, 0.03051102f, -0.07234412f, -0.06128027f, -0.29910451f, -0.13276541f, 0.18825746f, 0.14307903f, 
    0.03332253f, -0.01367363f, 0.13335280f, -0.01598501f, 0.19542338f, 0.09126654f, -0.08527032f, -0.03497036f, 
    -0.00217433f, -0.03222141f, 0.13844629f, 0.04910523f, -0.02742999f, 0.11604869f, 0.02016212f, -0.02413967f, 
    -0.01434258f, -0.04639433f, 0.06595771f, 0.17300454f, 0.03800191f, 0.14852951f, -0.07619197f, 0.13509279f, 
    -0.03078468f, -0.06770135f, 0.05283930f, 0.03178262f, 0.00289291f, 0.01289667f, 0.02677856f, 0.00237270f, 
    0.01978879f, -0.02703386f, -0.01135692f, -0.11235915f, -0.05115978f, -0.03790640f, -0.00919630f, -0.04060794f, 
    -0.01096279f, -0.05771540f, 0.01379343f, -0.01904478f, 0.04874555f, 0.05406104f, 0.15708692f, 0.05341720f, 
    -0.06864975f, -0.06952088f, 0.05174918f, -0.04669694f, 0.01828450f, 0.05457429f, 0.03569191f, 0.09849995f, 
    -0.01480736f, -0.03681948f, -0.14665133f, 0.09998842f, 0.05215202f, -0.04432903f, 0.09324358f, -0.16690931f, 
    -0.03429246f, 0.05619550f, 0.01069582f, -0.03020318f, 0.09169504f, 0.09795102f, 0.07210650f, -0.12758538f, 
    0.18134771f, 0.01524067f, -0.02147141f, 0.10954981f, -0.03718894f, 0.06433325f, -0.02943738f, -0.03898264f, 
    -0.26194820f, 0.13346677f, 0.07539260f, -0.04181467f, 0.11140529f, 0.02195166f, 0.00454223f, -0.04357104f, 
    0.07306577f, -0.13440239f, 0.12369565f, 0.01623468f, 0.15103239f, 0.01074265f, 0.08421849f, 0.14094837f, 
    0.00743729f, 0.04384342f, -0.00246019f, 0.04176946f, 0.05745553f, -0.03762200f, -0.04050674f, 0.05983644f, 
    0.52538389f, 0.38039222f, 0.06921545f, 0.07961429f, -0.06981707f, -0.08245867f, 0.01206555f, 0.16686407f, 
    -0.01803544f, 0.15930097f, 0.03634300f, 0.02058547f, 0.05023346f, -0.00713834f, -0.00756234f, 0.30577818f, 
    0.05608573f, 0.05565961f, -0.09041781f, -0.01461794f, 0.08988865f, 0.06012122f, 0.08719063f, 0.05097544f, 
    -0.13423145f, 0.02570109f, 0.04647100f, -0.06359504f, 0.00073425f, 0.07708951f, -0.14142406f, 0.02830773f, 
    -0.09948683f, -0.04094377f, 0.09172768f, 0.08174297f, 0.05419519f, -0.05319150f, -0.00181160f, -0.07500428f, 
    -0.05198919f, 0.12262104f, -0.04268647f, -0.01504690f, 0.04951384f, -0.06828763f, 0.06112960f, -0.04824888f, 
    0.20774427f, -0.13171132f, 0.09574797f, -0.09863675f, -0.05837276f, -0.04898258f, -0.08608639f, -0.08321528f, 
    -0.00202413f, -0.00622512f, -0.01154358f, 0.12605546f, 0.09036124f, -0.19803841f, 0.08693904f, -0.02844158f, 
    0.03769833f, -0.03686962f, -0.06900789f, -0.02578772f, 0.12127899f, -0.01305128f, -0.17586869f, 0.05105383f, 
    -0.17113426f, -0.15053979f, 0.00161987f, -0.06000266f, -0.03068839f, 0.06066320f, -0.05812865f, 0.04283115f, 
    -0.00355086f, -0.13047245f, 0.06003341f, 0.03033260f, 0.31121689f, 0.06877027f, -0.14438622f, 0.06457543f, 
    -0.18699481f, -0.05651946f, 0.07641813f, -0.01395834f, 0.15217493f, 0.05672986f, -0.05256917f, -0.08595875f, 
    -0.12471109f, -0.24566561f, 0.01336571f, -0.10375563f, -0.00003041f, 0.00362247f, 0.00051768f, 0.02125453f, 
    0.04200315f, -0.04505122f, 0.14494003f, 0.08738408f, 0.07988919f, -0.08712253f, 0.04489033f, 0.04547442f, 
    0.09943043f, -0.00489181f, 0.14995721f, -0.01416063f, -0.01222424f, 0.00518431f, 0.03368623f, 0.06247304f, 
    0.20514175f, 0.00580487f, 0.08732937f, 0.06591823f, 0.02498763f, -0.02767196f, 0.08302621f, -0.00016534f, 
    -0.01358665f, -0.04241790f, -0.00014400f, -0.12024043f, -0.01271796f, 0.00222893f, -0.05636936f, -0.01912199f, 
    -0.08440235f, -0.07936353f, 0.07037777f, -0.13901201f, 0.11407907f, 0.09645829f, -0.02402527f, 0.06575884f, 
    -0.21105026f, -0.18363833f, 0.01317197f, 0.13837838f, -0.04686454f, 0.10454636f, 0.10244869f, 0.04245129f, 
    0.00274815f, 0.09852258f, 0.01153818f, -0.05758471f, -0.06124142f, -0.01476829f, 0.01728074f, -0.05620123f, 
    0.15461451f, 0.03238799f, -0.10522715f, 0.07557851f, 0.19547401f, -0.10744631f, -0.05886612f, 0.04497766f, 
    -0.08432017f, 0.02842175f, -0.09117420f, 0.00505808f, -0.05744138f, -0.06573822f, 0.05925884f, 0.05735929f, 
    -0.04311894f, -0.03230466f, -0.03809249f, 0.04468917f, 0.01125289f, -0.04813387f, -0.08000039f, -0.02653857f, 
    0.01447720f, -0.00998252f, -0.04777493f, -0.05633794f, -0.00745583f, -0.04738871f, 0.01289168f, -0.03628527f, 
    -0.06845811f, -0.03506726f, 0.01291435f, -0.01077920f, -0.01867650f, -0.05016744f, -0.05243450f, -0.08017688f, 
    -0.03260997f, 0.04349901f, 0.03929045f, -0.03585817f, 0.06288905f, 0.00033227f, 0.02275684f, -0.02646251f, 
    0.00253673f, -0.06624404f, 0.01102871f, -0.02530518f, 0.03027836f, -0.03415161f, -0.00656525f, -0.01494609f, 
    0.03269149f, 0.01996424f, 0.00722827f, 0.01894260f, -0.06911445f, -0.06291251f, 0.04330285f, 0.04856040f, 
    0.00075414f, 0.00400494f, -0.04896886f, -0.00428580f, 0.03223043f, -0.02243089f, -0.01074771f, 0.03398687f, 
    -0.04255122f, 0.05336756f, 0.02126278f, 0.04952796f, -0.02921645f, 0.03468063f, -0.07179929f, 0.03203018f, 
    0.01463181f, -0.04113100f, -0.04860216f, -0.05413650f, -0.01428575f, -0.04361776f, -0.05189830f, -0.04951743f, 
    -0.01229399f, 0.00274772f, 0.03026632f, -0.04825550f, -0.07810095f, -0.01172419f, 0.01599106f, 0.01197697f, 
    0.01345393f, 0.02186480f, -0.00394503f, -0.04655948f, -0.04471782f, -0.01642660f, -0.00220346f, 0.05737701f, 
    -0.06436328f, 0.04370293f, -0.02086608f, -0.03049943f, 0.05315292f, -0.00572184f, -0.01872889f, -0.06606437f, 
    -0.06066967f, -0.07901451f, 0.03400128f, -0.06837852f, 0.01375878f, 0.01571487f, -0.04539430f, -0.00728929f, 
    -0.09406866f, 0.03255101f, -0.08477696f, 0.04974360f, 0.04670214f, 0.01820488f, 0.00876733f, 0.05280746f, 
    -0.03844733f, -0.07235031f, 0.00853799f, -0.01788800f, -0.02875754f, 0.02901338f, -0.07835728f, -0.07632338f, 
    -0.02027393f, -0.06849932f, -0.00884646f, -0.05334876f, 0.00609488f, -0.03670710f, 0.03406363f, -0.05686317f, 
    -0.07316764f, -0.03488664f, 0.05362437f, 0.06791739f, -0.05851955f, 0.06009666f, 0.02944049f, -0.02494883f, 
    0.05661553f, 0.04983373f, -0.06943459f, -0.06231830f, 0.05442976f, 0.05415319f, -0.03317228f, 0.01552697f, 
    -0.04508707f, 0.05267566f, -0.08629266f, 0.00232553f, -0.00108037f, 0.03159999f, -0.03880481f, 0.06199214f, 
    -0.03060462f, -0.03147915f, -0.04811908f, -0.05879599f, -0.05230432f, 0.04908076f, -0.04624311f, -0.05702508f, 
    0.00146565f, -0.06613418f, -0.06263486f, 0.00126016f, 0.00529879f, -0.04661617f, -0.02993441f, -0.01206939f, 
    -0.00015945f, -0.07553279f, -0.00261727f, 0.06531842f, -0.05026533f, 0.04193722f, -0.08370548f, -0.02625322f, 
    0.03098501f, 0.03527634f, 0.05023529f, -0.04704940f, -0.06273480f, -0.07574449f, 0.03034307f, 0.04540867f, 
    0.09405397f, 0.10715918f, -0.23898797f, -0.11550409f, 0.02122346f, 0.04604433f, 0.12197592f, 0.02579526f, 
    0.00265247f, -0.02111113f, -0.06169408f, -0.11625642f, 0.00705057f, -0.48376247f, 0.10129181f, 0.02090622f, 
    0.06010961f, -0.03122118f, -0.12067553f, 0.14976265f, 0.07095155f, 0.09779570f, 0.19101907f, 0.20819522f, 
    -0.18947923f, -0.07436623f, 0.18114541f, 0.16432078f, 0.05632990f, 0.05045091f, 0.02735583f, -0.00967109f, 
    0.08860405f, 0.02514018f, 0.05472673f, 0.11809345f, 0.06649966f, 0.08171491f, -0.05459577f, 0.12368464f, 
    0.05703383f, 0.02491649f, 0.02025418f, -0.05042680f, 0.10553905f, 0.01719976f, 0.02088427f, 0.10076394f, 
    -0.02345496f, -0.10696954f, -0.20448920f, 0.04560965f, -0.10863414f, 0.18241318f, -0.06154804f, 0.14451443f, 
    -0.06574528f, -0.02120633f, 0.01629632f, -0.00378093f, -0.09684587f, 0.13023072f, -0.05393612f, 0.19112457f, 
    0.08220139f, 0.09954268f, -0.01251558f, -0.06937483f, -0.03979435f, -0.14555818f, -0.09720536f, -0.13939212f, 
    0.17404214f, 0.10184859f, 0.00205504f, 0.07902225f, -0.01329854f, -0.00491089f, 0.01870808f, -0.00025844f, 
    -0.01473990f, -0.07730224f, 0.04152894f, 0.09031902f, -0.00273422f, -0.15291561f, 0.09591759f, -0.13877983f, 
    -0.12922782f, -0.07921015f, -0.05766689f, -0.00228236f, 0.01434854f, -0.05624750f, 0.09890199f, 0.11351307f, 
    0.02841716f, -0.03383391f, -0.05015501f, -0.12177504f, 0.00112532f, 0.10003985f, -0.05546056f, 0.13020895f, 
    0.03473281f, 0.05694781f, 0.06773014f, 0.11165008f, -0.51798779f, 0.23883624f, -0.04895636f, -0.09202930f, 
    -0.04677717f, 0.05382484f, -0.00550685f, 0.00521969f, 0.18383071f, 0.03938006f, -0.00842984f, -0.02903508f, 
    -0.06848545f, 0.12921673f, 0.10566077f, 0.17190041f, 0.00984427f, -0.05891133f, -0.00590652f, 0.04446210f, 
    -0.05448852f, 0.19402382f, -0.05853964f, 0.16328315f, 0.01192262f, -0.01990532f, 0.01098210f, 0.15431322f, 
    0.08186909f, -0.08426706f, 0.10429823f, 0.06830919f, 0.10497841f, -0.06201102f, 0.14687544f, 0.09407811f, 
    0.15430425f, -0.17389728f, -0.00735377f, 0.00834810f, 0.05003187f, 0.03309777f, -0.04555238f, 0.05206911f, 
    -0.08003332f, -0.12849328f, -0.00765303f, -0.11440665f, 0.04827700f, 0.03979385f, 0.25380242f, 0.05943675f, 
    -0.05244808f, 0.02768988f, 0.13834500f, 0.00706722f, 0.05832927f, -0.03040893f, -0.04228756f, 0.03712681f, 
    0.03395969f, 0.22913978f, -0.06426118f, -0.04100908f, 0.04370632f, -0.13646907f, 0.05699852f, -0.05380932f, 
    -0.12048624f, -0.00417520f, -0.09830672f, -0.08001626f, -0.03586059f, -0.07264698f, -0.13012998f, -0.17602143f, 
    0.20107326f, 0.05406119f, -0.03978421f, 0.10807426f, 0.05421145f, 0.17133045f, 0.04769449f, -0.03907034f, 
    0.30146182f, -0.02116762f, 0.02713021f, -0.13314180f, -0.00144246f, 0.06390182f, -0.01896564f, 0.00067615f, 
    -0.05583563f, 0.08890865f, -0.07649010f, -0.09049974f, -0.09757678f, 0.10307489f, -0.08115169f, -0.16287227f, 
    -0.11467554f, 0.11319219f, -0.01427430f, -0.02003556f, 0.02372942f, -0.01277631f, -0.04575783f, -0.02050790f, 
    -0.21924458f, -0.19060120f, 0.05423709f, -0.17533846f, -0.04605454f, 0.04505482f, 0.05986181f, -0.04825942f, 
    -0.11171090f, 0.08327792f, 0.10089083f, -0.01538505f, 0.04078867f, -0.03641758f, -0.05637455f, -0.14210881f, 
    0.04407835f, -0.00528909f, 0.00086953f, -0.04141681f, -0.02733384f, 0.09839793f, -0.14964432f, 0.09743702f, 
    0.13213402f, 0.08102216f, 0.27337956f, 0.06141934f, 0.13117491f, -0.02736132f, 0.14407755f, -0.12563428f, 
    0.05696476f, 0.00140953f, 0.00186731f, 0.04659765f, -0.10102434f, 0.22583586f, 0.00410022f, 0.29341987f, 
    0.08556157f, -0.01985463f, 0.01440012f, 0.02930748f, -0.04559303f, 0.04237820f, -0.12815772f, 0.02871466f, 
    0.24773371f, 0.18791319f, 0.08525857f, -0.12472527f, -0.00774645f, 0.06045031f, 0.05143244f, -0.01954026f, 
    0.03026192f, 0.00667880f, 0.01801472f, -0.07885779f, 0.04057724f, 0.02606829f, 0.08929983f, 0.09167223f, 
    -0.09594161f, 0.05519415f, -0.03473964f, 0.17195477f, 0.13242619f, 0.04947573f, 0.11129819f, 0.02279042f, 
    0.09720518f, 0.23682518f, 0.07413612f, 0.09947015f, 0.07103952f, -0.02601651f, 0.06147547f, 0.04124708f, 
    -0.02316457f, 0.08798928f, -0.01441221f, -0.10310339f, -0.06909688f, -0.18137576f, 0.08693443f, 0.15182351f, 
    0.06226145f, -0.11984096f, -0.00976867f, 0.15038623f, -0.07523406f, 0.12725225f, -0.00417856f, 0.05231447f, 
    0.12090727f, 0.10852408f, -0.04109846f, 0.09268365f, 0.16741997f, 0.01433987f, 0.01353045f, 0.11278238f, 
    -0.24413623f, -0.04164864f, -0.08770247f, 0.08794431f, -0.05233530f, 0.13808678f, -0.16946755f, -0.00659682f, 
    0.03783225f, -0.00865223f, -0.06024814f, -0.04794748f, -0.07125323f, 0.03478066f, -0.05020385f, 0.02573664f, 
    -0.11596623f, -0.05368738f, -0.09458426f, -0.18856686f, 0.05535164f, 0.12100444f, -0.00963612f, -0.10620303f, 
    -0.02648455f, 0.05319139f, 0.08713175f, 0.15053740f, 0.29844192f, -0.04667759f, 0.02355247f, 0.18154965f, 
    -0.08286480f, 0.05674046f, -0.05589576f, 0.11041453f, -0.04765066f, -0.07829194f, 0.03216212f, 0.00925899f, 
    0.02426281f, -0.12990211f, 0.00611968f, -0.05037395f, -0.10406680f, -0.01159329f, 0.02977602f, -0.02869420f, 
    0.00598055f, -0.06482971f, 0.10370057f, 0.05221968f, 0.08106445f, 0.13517898f, 0.07426973f, -0.00588533f, 
    0.03667703f, 0.04884299f, 0.02055308f, -0.03127023f, -0.17708632f, 0.11894865f, 0.05613634f, 0.00967268f, 
    -0.35839728f, 0.09259218f, -0.11882808f, -0.04942460f, 0.08317566f, -0.01234142f, -0.05510299f, -0.02779417f, 
    -0.01608460f, -0.09212952f, 0.12567218f, 0.16759136f, 0.30414662f, 0.27262145f, 0.14262095f, 0.02359579f, 
    -0.02653490f, 0.05146771f, 0.00675775f, 0.07086369f, 0.12150052f, -0.03849803f, -0.06078123f, -0.04837660f, 
    0.40210304f, 0.24421373f, 0.00899120f, -0.13703448f, 0.05704260f, -0.04581150f, -0.01818248f, 0.13021708f, 
    -0.06009814f, 0.22080408f, 0.09050439f, -0.00603433f, 0.09273274f, -0.14393947f, -0.12670617f, -0.02531736f, 
    -0.07512729f, -0.13727245f, 0.06070687f, 0.05270546f, -0.03038169f, 0.07113293f, -0.09416918f, -0.04473427f, 
    -0.09277893f, 0.07851134f, 0.06340104f, -0.07789138f, 0.12594351f, 0.09076243f, 0.02116079f, -0.02961027f, 
    0.05612462f, 0.03043209f, 0.11706270f, 0.21000414f, 0.06175011f, -0.01773483f, 0.06770984f, -0.20919672f, 
    -0.05218439f, -0.04145481f, 0.18432648f, 0.01519528f, 0.03319842f, 0.14134623f, 0.04067975f, 0.09659001f, 
    0.10561500f, 0.10433888f, 0.11279483f, 0.06889574f, -0.00225988f, 0.02746626f, -0.06529092f, 0.03383275f, 
    0.05008510f, 0.05712113f, 0.02455491f, -0.05471659f, -0.09831067f, -0.14616399f, 0.00249779f, -0.03921815f, 
    0.19293672f, -0.01174817f, 0.02614284f, -0.06971455f, 0.00789050f, 0.03995026f, -0.13205145f, -0.03463271f, 
    -0.12188835f, -0.02764264f, -0.04876747f, 0.04208598f, -0.03652424f, 0.10595082f, -0.02580294f, -0.03039609f, 
    0.15099855f, -0.02606818f, -0.11896435f, 0.00268144f, 0.30768672f, 0.09117998f, 0.04676339f, 0.16888759f, 
    -0.00824970f, -0.09772024f, -0.00383181f, -0.07397162f, -0.06949750f, -0.05368287f, -0.01511132f, -0.02083854f, 
    0.01524194f, -0.17397124f, 0.07768151f, -0.12077223f, 0.00792071f, 0.02167668f, 0.01243975f, -0.02389081f, 
    0.05557750f, -0.20905589f, 0.00877204f, 0.07505912f, -0.00508926f, -0.08907694f, -0.09755914f, -0.02315870f, 
    0.06831568f, -0.03770050f, -0.09613867f, -0.03377161f, -0.09261508f, 0.09875054f, -0.19868536f, -0.08697242f, 
    -0.06561238f, -0.06194791f, 0.13792472f, 0.16901658f, -0.03620826f, -0.10000280f, 0.22617975f, 0.10588097f, 
    0.03351480f, 0.18741326f, -0.04988372f, -0.00330865f, -0.05717371f, 0.00047275f, -0.00251537f, -0.10705408f, 
    -0.02597866f, -0.05416463f, -0.08014133f, -0.13288608f, 0.13437946f, 0.01930220f, 0.09912103f, 0.15888615f, 
    0.12541309f, -0.33628398f, -0.12496747f, 0.05948485f, 0.00739573f, 0.22855501f, 0.03858478f, 0.13326849f, 
    -0.03584438f, 0.05285008f, 0.00805963f, 0.04912084f, -0.02469108f, 0.01954908f, 0.11871814f, 0.13005741f, 
    -0.08864118f, -0.16879350f, 0.03766004f, -0.01455567f, -0.00876635f, -0.20776913f, -0.03944694f, -0.03103152f, 
    -0.45406017f, 0.19845141f, 0.00836316f, -0.17648900f, 0.18852626f, -0.10393419f, 0.10671839f, 0.05501344f, 
    0.02813326f, -0.09846665f, -0.00253834f, -0.07680691f, 0.37919188f, -0.08009955f, -0.13648982f, 0.25289226f, 
    -0.01218673f, 0.10599988f, -0.16937257f, 0.00465514f, 0.03840586f, -0.04137316f, 0.06394380f, 0.17332301f, 
    0.18380398f, -0.03124472f, 0.00086418f, 0.12740989f, -0.02962920f, -0.06230808f, -0.02018380f, 0.06948929f, 
    -0.02724272f, -0.01803532f, -0.08292086f, 0.03763822f, 0.07227165f, 0.13236497f, -0.02585034f, -0.03213805f, 
    -0.08694346f, 0.12435786f, -0.03662409f, -0.11392024f, 0.03457591f, -0.01690591f, 0.09819816f, 0.03190297f, 
    -0.24717189f, 0.07513475f, 0.02971707f, -0.06774666f, -0.04177057f, 0.08983892f, -0.09487361f, 0.06392233f, 
    -0.11392102f, 0.00517152f, 0.11905690f, -0.08744396f, 0.04447960f, 0.21877509f, 0.05794334f, 0.23219788f, 
    -0.06356926f, -0.01077238f, -0.10367084f, 0.04904389f, 0.15373065f, 0.01832511f, -0.02256809f, 0.00897589f, 
    -0.18742862f, -0.01667407f, -0.04473608f, 0.01329916f, 0.09066179f, -0.04072142f, -0.00341864f, 0.06346960f, 
    0.03493024f, 0.09471332f, 0.03790195f, 0.06322730f, 0.14989202f, -0.09651931f, -0.05967480f, -0.18477575f, 
    0.07790450f, -0.03568767f, -0.01525754f, -0.00028064f, 0.01301338f, 0.10888907f, 0.04394205f, 0.10737941f, 
    -0.04300663f, -0.10713528f, 0.08234018f, -0.00334419f, 0.00697380f, 0.02251427f, 0.02671784f, -0.01062107f, 
    -0.02333982f, -0.05792651f, 0.11113771f, 0.11464017f, -0.14335597f, 0.26533559f, 0.02855260f, 0.21479164f, 
    -0.25094485f, -0.08968039f, -0.00859629f, 0.08785951f, 0.08168767f, 0.12120111f, 0.10101128f, 0.10084797f, 
    0.14780395f, -0.13176511f, -0.05007616f, 0.29053661f, -0.08224355f, -0.03432801f, 0.01572873f, 0.01591796f, 
    -0.01912188f, 0.06365850f, -0.03577111f, 0.13635111f, -0.12126598f, 0.20157702f, -0.00828500f, 0.07765215f, 
    0.12513337f, -0.11367618f, -0.11663198f, -0.02572479f, 0.08184914f, -0.02481175f, 0.07498210f, 0.12044235f, 
    0.08922115f, -0.03055885f, -0.10501365f, -0.09608166f, -0.03952882f, 0.01850630f, 0.04735958f, -0.04410126f, 
    -0.07631728f, -0.12028565f, 0.03172762f, -0.06482463f, 0.18656726f, -0.10651195f, 0.15436554f, 0.21633133f, 
    -0.14334573f, 0.06553271f, 0.12289585f, -0.01851179f, 0.10973446f, -0.05252640f, 0.10313685f, 0.06344583f, 
    -0.28900692f, -0.08568596f, 0.03403905f, -0.04897241f, 0.02332300f, 0.06507652f, 0.03105476f, -0.04203743f, 
    -0.01064064f, -0.09332945f, -0.07449315f, 0.00479243f, 0.19071445f, 0.06191677f, 0.00804157f, -0.08479629f, 
    0.10345248f, -0.04332207f, -0.10099936f, -0.02600917f, 0.02253485f, 0.05238324f, 0.01796696f, -0.07878211f, 
    -0.04277531f, 0.05281875f, -0.00246752f, 0.05946452f, 0.02929411f, -0.01789439f, -0.06398054f, -0.06897605f, 
    0.02392313f, -0.04520005f, -0.05573678f, 0.00215150f, 0.02848388f, 0.03343426f, 0.02736251f, 0.04601235f, 
    0.01620146f, -0.00495956f, 0.03838647f, -0.07116877f, 0.01674474f, -0.03768948f, -0.07772034f, -0.07507037f, 
    -0.07169797f, -0.06372036f, 0.03680503f, 0.00476406f, 0.04939064f, -0.02606233f, -0.06290008f, -0.01481811f, 
    -0.03001823f, 0.03985728f, 0.02063285f, 0.03818492f, 0.04715087f, 0.01526912f, 0.00525818f, -0.00617326f, 
    -0.05632459f, 0.03112178f, -0.03676316f, 0.06173000f, -0.05160919f, -0.05698092f, -0.08039390f, -0.06494828f, 
    0.06873054f, 0.00388680f, -0.00886300f, -0.03529952f, 0.05751578f, 0.00889593f, -0.02641036f, 0.00493887f, 
    -0.06184510f, -0.03936297f, 0.01585342f, 0.04214090f, 0.02497362f, 0.04295401f, -0.01869891f, -0.02685719f, 
    -0.02506367f, 0.01630469f, 0.06384841f, 0.01189974f, 0.04135254f, 0.00783337f, 0.04429917f, -0.04226061f, 
    -0.05154167f, -0.06517950f, -0.01210887f, 0.03271988f, 0.06387940f, -0.07252232f, -0.07186790f, -0.06630278f, 
    0.00871254f, -0.00778443f, 0.06166215f, 0.01721149f, -0.05719320f, -0.01951678f, -0.06095079f, -0.07213107f, 
    0.02740804f, 0.00602289f, -0.04464995f, 0.03698709f, 0.05016533f, -0.02999355f, -0.00827145f, -0.02457583f, 
    -0.02219003f, -0.02314172f, 0.04278235f, -0.01765020f, 0.00947240f, -0.01031423f, -0.05359887f, 0.01694453f, 
    -0.07367745f, 0.06862342f, -0.01536303f, 0.01973100f, -0.06832763f, -0.02839215f, -0.03977988f, 0.01615942f, 
    -0.06194853f, -0.04458006f, -0.05399769f, -0.01233759f, 0.02010109f, -0.04128770f, -0.04256709f, -0.05170227f, 
    0.01912435f, -0.06395189f, 0.02970207f, -0.06385861f, 0.00050349f, 0.05723592f, -0.00751958f, -0.05386924f, 
    -0.00713656f, 0.05264565f, -0.04193458f, 0.00649978f, 0.06989007f, -0.01247735f, 0.03975812f, 0.05137777f, 
    0.05658558f, -0.07652999f, 0.05447199f, -0.04731455f, -0.03800563f, 0.02822715f, -0.00736667f, -0.06493486f, 
    -0.03971066f, 0.05949423f, -0.02266061f, 0.00805647f, 0.03237588f, 0.03258179f, 0.00241669f, -0.06480512f, 
    -0.05558361f, -0.02510469f, -0.01170232f, -0.05672732f, 0.04722978f, 0.05982525f, 0.02852420f, -0.05541577f, 
    -0.00673570f, -0.01661014f, 0.05715290f, 0.00359774f, 0.03248716f, -0.01141229f, 0.01435638f, -0.01354169f, 
    0.01293702f, -0.07201315f, 0.04120711f, 0.05610062f, -0.01280226f, 0.04543392f, -0.00035824f, -0.00760648f, 
    -0.02714657f, -0.04668561f, 0.02116392f, 0.01283960f, -0.07440405f, -0.05503304f, -0.06938995f, -0.02599667f, 
    -0.05737800f, -0.00134672f, -0.07656185f, -0.04776114f, 0.00887311f, 0.02958139f, 0.01404607f, 0.05525466f, 
    -0.27598208f, 0.10126454f, -0.09848137f, -0.15760246f, -0.01441212f, -0.01289053f, 0.00507980f, 0.08262953f, 
    0.08606903f, -0.09245336f, 0.00762047f, 0.13069125f, 0.15699707f, -0.07473048f, 0.19264410f, 0.02522673f, 
    -0.11165069f, -0.10494827f, -0.01647880f, 0.21536218f, 0.03144186f, -0.02163727f, -0.08227883f, -0.04068311f, 
    0.22606522f, 0.26910964f, 0.03074572f, 0.13176209f, -0.10735989f, 0.01583742f, 0.04740352f, 0.14220501f, 
    0.01397434f, 0.15377429f, 0.16052644f, 0.09888067f, 0.18729857f, -0.02379023f, -0.14338300f, -0.00512104f, 
    0.05938878f, 0.01321986f, 0.03043516f, 0.14257766f, -0.04061249f, 0.08070622f, 0.04601421f, -0.06129085f, 
    -0.18233804f, -0.06700628f, -0.13131300f, 0.16251722f, 0.09380173f, 0.18609682f, 0.00615354f, 0.13638188f, 
    -0.10464662f, -0.09764203f, 0.08225703f, 0.15828234f, 0.11756986f, 0.01584770f, 0.11890722f, -0.13986583f, 
    0.00003481f, 0.07877602f, 0.09506450f, 0.03653485f, -0.05565129f, -0.11664836f, -0.06421598f, -0.01178283f, 
    -0.05367861f, 0.05330046f, 0.18081416f, 0.04512308f, -0.14176789f, -0.08910931f, 0.01496633f, 0.09576553f, 
    0.06324888f, 0.08311688f, -0.04651895f, -0.00284601f, 0.04844745f, -0.22931656f, 0.05120834f, -0.09698934f, 
    0.08073105f, -0.02997329f, -0.01525344f, -0.10799930f, -0.04915152f, 0.04925657f, -0.05648851f, -0.01634198f, 
    -0.26892540f, 0.02893621f, -0.05470421f, -0.08327761f, 0.10972138f, 0.05621999f, -0.07499909f, -0.00699736f, 
    0.07795539f, -0.03639135f, 0.00492833f, 0.09143892f, -0.42432284f, 0.19071966f, 0.16445428f, -0.08738918f, 
    -0.16344853f, 0.05644789f, 0.09344483f, -0.00917510f, 0.12109780f, -0.04989262f, -0.07743548f, 0.01144756f, 
    -0.22422554f, 0.04042520f, 0.19636258f, -0.11270428f, -0.09854683f, 0.13128901f, -0.08714245f, -0.04255642f, 
    0.09127145f, -0.04143987f, 0.16005327f, 0.10985616f, 0.00950427f, -0.03519299f, 0.01087576f, 0.12665589f, 
    0.04842362f, 0.05703611f, 0.19130191f, 0.07349591f, -0.02927876f, 0.16427016f, 0.07352328f, 0.04096487f, 
    0.06191607f, -0.05750548f, 0.17365643f, -0.05167504f, 0.11546706f, 0.00986046f, -0.01022379f, 0.13662951f, 
    0.00879843f, -0.05256394f, 0.05935190f, 0.01872968f, -0.12606063f, 0.19342777f, 0.13304909f, -0.28744593f, 
    0.01572541f, -0.03031954f, 0.03516214f, -0.06009357f, -0.02642716f, -0.00269885f, 0.07409442f, 0.06065610f, 
    0.14791669f, -0.23424344f, -0.04742580f, -0.02943211f, 0.01680794f, 0.05568851f, 0.08549052f, -0.07280391f, 
    -0.13746123f, 0.03045993f, -0.01605939f, -0.04226465f, 0.04745410f, -0.07034905f, -0.00309456f, -0.06143262f, 
    0.08185323f, -0.07366869f, 0.16346085f, 0.07426942f, 0.16486186f, 0.00352472f, 0.07869573f, -0.05906058f, 
    0.01912227f, -0.05206906f, 0.00770677f, 0.03591165f, 0.00482179f, -0.00119475f, 0.02034584f, 0.01162968f, 
    0.00748917f, 0.01507932f, -0.05933434f, 0.06566168f, 0.00827182f, -0.04323416f, 0.05816690f, -0.04167024f, 
    -0.06321926f, 0.06393210f, -0.05572931f, -0.02337003f, 0.01827958f, -0.04102674f, 0.00433136f, -0.05694991f, 
    0.04507435f, -0.06873744f, -0.00567126f, -0.04706021f, 0.03839165f, -0.00396377f, 0.03203381f, -0.04931239f, 
    -0.04393151f, -0.01648939f, -0.03342178f, -0.01395025f, -0.00523082f, 0.02213217f, 0.04921970f, -0.01613645f, 
    -0.01919223f, -0.03270442f, 0.06590939f, -0.00487018f, -0.03286352f, -0.00468021f, 0.06172122f, -0.07083966f, 
    -0.03207916f, -0.00509276f, 0.01899672f, 0.02102129f, -0.06513783f, 0.03025946f, 0.01103258f, -0.04993135f, 
    -0.06989309f, -0.02041583f, 0.00385704f, -0.01495443f, 0.02480075f, 0.01135498f, -0.03418115f, -0.05501829f, 
    0.02485621f, -0.01161057f, -0.05509287f, -0.01942739f, 0.05110296f, -0.00873724f, 0.02255222f, -0.02094195f, 
    -0.04446837f, -0.04302165f, 0.06224516f, -0.03838379f, 0.03855043f, 0.03132167f, -0.07382002f, -0.06974628f, 
    -0.03840963f, 0.04185765f, 0.03342353f, -0.03278985f, -0.05286933f, -0.02582375f, -0.06733178f, 0.02044867f, 
    -0.01857415f, -0.02175550f, 0.00188709f, -0.06306368f, 0.05356906f, -0.00728398f, -0.05854630f, -0.04116646f, 
    -0.00655338f, 0.00904780f, 0.03813570f, 0.01778172f, -0.07184378f, -0.05299509f, -0.07551633f, 0.01154323f, 
    -0.05205829f, -0.03657246f, -0.01561790f, 0.00307467f, -0.03535121f, -0.02712211f, 0.00327985f, 0.01830084f, 
    -0.02551283f, -0.03240032f, 0.02019677f, 0.03384817f, 0.00730150f, 0.05052020f, -0.07695197f, -0.06031201f, 
    0.06271474f, -0.05524964f, 0.05438770f, -0.01647451f, -0.00160281f, 0.03157139f, -0.01318096f, -0.00667765f, 
    -0.03423283f, -0.04354235f, 0.02921148f, -0.02183780f, 0.04736976f, -0.04262641f, 0.05842247f, -0.03829638f, 
    0.05012901f, 0.01073785f, -0.02405061f, -0.00609181f, 0.05251122f, -0.05809217f, 0.02799530f, -0.04152399f, 
    0.00151861f, 0.04026124f, -0.06541178f, -0.05204344f, 0.04670706f, -0.03108918f, -0.05172448f, -0.01011752f, 
    0.05664846f, 0.00606009f, -0.02973750f, 0.05423791f, -0.06383146f, -0.06591108f, -0.03322549f, -0.03048347f, 
    0.04183238f, -0.02542627f, -0.03994784f, -0.04925080f, -0.05563486f, 0.04050719f, 0.02796445f, 0.03511174f, 
    0.00434667f, 0.04159659f, 0.03265676f, -0.00585428f, 0.04360551f, -0.04240341f, -0.04302882f, -0.06256276f, 
    -0.05151959f, -0.03135673f, 0.05105409f, -0.01916964f, -0.02949532f, 0.01836173f, -0.01321080f, -0.04835240f, 
    0.05394579f, 0.00930563f, -0.07607468f, -0.06749680f, -0.02005656f, -0.06693801f, 0.00851266f, -0.00649232f, 
    -0.05112241f, 0.00431757f, 0.08515222f, 0.07728603f, -0.00119658f, -0.09349897f, -0.15114658f, -0.01228809f, 
    -0.04520256f, 0.05264495f, -0.11839397f, -0.05057905f, -0.11930661f, -0.21929295f, -0.00414862f, 0.20376185f, 
    0.00219374f, -0.00324151f, -0.09476877f, 0.08802927f, 0.11494340f, 0.06007985f, 0.11709924f, 0.07788704f, 
    0.13712972f, -0.12385815f, -0.17218068f, -0.01400901f, 0.16915603f, 0.00842202f, 0.04984986f, -0.07114184f, 
    0.03309618f, 0.07251176f, 0.07469272f, 0.01427635f, 0.08123119f, 0.15234360f, 0.03236534f, -0.19824663f, 
    -0.08152764f, 0.14227921f, 0.01866999f, -0.00074629f, 0.16697244f, 0.06877253f, 0.00966823f, -0.10544206f, 
    -0.24507722f, -0.03342810f, -0.04868551f, 0.19353452f, 0.05592649f, 0.00525636f, -0.01046898f, 0.06706771f, 
    -0.02194038f, 0.02042160f, -0.05235982f, -0.08899002f, -0.32120633f, 0.09060256f, 0.03642963f, -0.30498275f, 
    0.08070351f, -0.04167163f, -0.24877155f, -0.03330037f, 0.01246934f, -0.15702018f, -0.03914087f, -0.01050945f, 
    -0.15281171f, -0.04579633f, -0.21567971f, 0.02179342f, -0.02405365f, -0.15686668f, -0.04740569f, 0.11122375f, 
    0.08742154f, 0.04482615f, 0.04784010f, 0.14201583f, 0.18295552f, -0.04320292f, -0.02126474f, 0.06576204f, 
    0.07529995f, 0.01500228f, 0.11129504f, 0.08384787f, 0.09350383f, 0.15454841f, -0.03562849f, -0.00186429f, 
    0.04272980f, 0.07618937f, -0.20733114f, 0.26473078f, -0.04475557f, 0.08802243f, 0.09593163f, -0.11535957f, 
    0.10997765f, 0.04917154f, 0.06007788f, 0.05986603f, 0.06130121f, 0.03306270f, -0.03181540f, -0.10826701f, 
    -0.18522701f, 0.13769256f, 0.03932642f, 0.11242775f, 0.01377242f, -0.01305916f, 0.11816838f, 0.00581086f, 
    0.15727280f, 0.21820194f, 0.06635349f, -0.11853682f, 0.04673064f, 0.00855921f, -0.08810428f, 0.14113200f, 
    0.14726999f, 0.09685180f, 0.13588157f, 0.06715568f, 0.21380034f, 0.07827380f, -0.11263171f, -0.14873938f, 
    -0.09974622f, -0.06645868f, 0.07673066f, -0.10982086f, -0.00892835f, -0.05695447f, -0.05132873f, 0.01052890f, 
    0.10221344f, 0.07833983f, -0.12352789f, 0.08409223f, 0.03603953f, -0.01923738f, 0.00469495f, 0.07337829f, 
    -0.02706994f, -0.02218773f, 0.12455976f, 0.04168731f, -0.06781071f, -0.05857486f, -0.18681049f, 0.05539861f, 
    0.08632888f, -0.12436234f, 0.13958666f, -0.11048141f, 0.18294883f, 0.07411362f, -0.00183919f, 0.01653212f, 
    -0.02830977f, -0.15714358f, 0.08536431f, -0.11464781f, -0.04664665f, 0.04234758f, 0.01003981f, 0.02828336f, 
    0.07774050f, 0.00832883f, 0.00683791f, 0.04636651f, 0.06992370f, -0.01862484f, 0.19729795f, 0.15550180f, 
    -0.03294354f, -0.19284892f, -0.03236085f, 0.07537877f, -0.01227734f, -0.02368130f, 0.06084293f, -0.01566812f, 
    0.06318539f, -0.06518217f, 0.02974468f, -0.06924027f, 0.04597800f, -0.01984286f, -0.07772737f, 0.04048543f, 
    -0.05986994f, -0.05486258f, -0.05003731f, 0.03723734f, 0.01114465f, 0.04798297f, -0.00396489f, -0.02564995f, 
    -0.04508966f, 0.03039265f, 0.01599618f, 0.04761764f, -0.05493451f, -0.00449931f, 0.02664932f, 0.02287571f, 
    -0.04832141f, -0.00004990f, 0.00271865f, 0.03738953f, 0.04464328f, -0.00404317f, 0.05520296f, -0.01917048f, 
    -0.07671914f, 0.02149117f, 0.05276147f, 0.06239220f, -0.02689272f, -0.05298571f, -0.06288914f, 0.03697022f, 
    -0.07810605f, 0.05450971f, -0.06522845f, -0.06420314f, 0.06442901f, -0.06418221f, -0.02155125f, -0.02062631f, 
    -0.01215541f, 0.04936891f, 0.05434153f, -0.06110485f, -0.04503888f, -0.07641219f, -0.03169102f, 0.05549229f, 
    0.03855066f, -0.06785049f, -0.07276467f, -0.07819772f, 0.03909891f, -0.03113984f, 0.02613180f, 0.05067595f, 
    -0.02218302f, -0.06061347f, -0.05400008f, -0.02222637f, -0.06833784f, 0.03824008f, -0.07385632f, 0.03225814f, 
    -0.03282865f, -0.01677472f, -0.05158521f, 0.00665199f, -0.00797648f, -0.02002875f, 0.02140285f, -0.05149537f, 
    -0.01347848f, -0.00632417f, -0.05769076f, -0.02823091f, -0.05267385f, -0.02162913f, 0.04307492f, 0.02732122f, 
    -0.05868029f, -0.00938889f, -0.04800569f, -0.02085204f, -0.03882878f, -0.06099051f, -0.03230827f, 0.01558902f, 
    -0.03045374f, 0.04492724f, 0.06130385f, 0.01168259f, 0.05679552f, 0.01128132f, 0.04532482f, 0.01993708f, 
    0.02347304f, -0.06709723f, -0.01787804f, -0.03942151f, 0.04373805f, -0.02850474f, -0.00802581f, -0.00577317f, 
    0.00090069f, 0.02498992f, -0.07219673f, 0.01694421f, 0.05988260f, -0.01864263f, 0.01301473f, -0.02642218f, 
    0.05280536f, -0.02434684f, 0.04206043f, -0.05422537f, -0.00262988f, 0.00076477f, -0.06041683f, 0.04550399f, 
    0.00722215f, 0.01761204f, 0.03631778f, -0.03110369f, -0.02011895f, -0.00425712f, 0.00128020f, 0.00052435f, 
    -0.06888581f, -0.03790435f, -0.05801031f, -0.01871948f, -0.06764253f, 0.06556711f, -0.05552878f, 0.01938430f, 
    -0.04552595f, -0.01506426f, -0.07022052f, 0.04392017f, -0.06381617f, -0.07724822f, 0.04218397f, 0.05202396f, 
    0.05670376f, 0.02020942f, -0.06513470f, -0.01034123f, -0.04809532f, 0.03061989f, 0.05827344f, -0.01706638f, 
    -0.02792030f, -0.04166549f, 0.00005014f, -0.01696245f, -0.00658635f, 0.00705852f, -0.02859122f, -0.07208503f, 
    0.04272119f, -0.02001230f, -0.05317544f, -0.07216789f, -0.04773093f, 0.03591093f, -0.06605272f, -0.06144571f, 
    -0.02362100f, -0.06551615f, 0.01782857f, 0.06206388f, -0.05142285f, 0.06414443f, 0.05027712f, 0.06116454f, 
    -0.00617036f, 0.02862725f, 0.01320374f, -0.03990776f, 0.04040987f, 0.06215871f, 0.00785652f, -0.01729992f, 
    -0.29169041f, -0.06253299f, -0.10978919f, 0.02477958f, 0.05480752f, 0.04675199f, 0.00942222f, 0.13253471f, 
    -0.08900031f, 0.00383348f, -0.06416334f, -0.23623966f, -0.02771147f, 0.11105882f, 0.27478951f, 0.04440930f, 
    -0.04818533f, -0.03345760f, 0.08407689f, 0.07923537f, -0.04406636f, 0.08199562f, 0.12391518f, -0.00338425f, 
    0.26023367f, 0.21193592f, 0.14871579f, 0.45501551f, 0.09536684f, 0.08807446f, -0.03271063f, 0.06395114f, 
    0.11385802f, 0.01357799f, 0.01802987f, 0.10424108f, -0.07120360f, -0.29077396f, 0.03886503f, -0.07449959f, 
    0.21014617f, 0.18893129f, -0.00494460f, 0.17009850f, 0.16393024f, -0.12746516f, -0.00434604f, 0.01323980f, 
    -0.04560728f, -0.13787442f, -0.35252047f, 0.38901144f, -0.06382582f, -0.05387730f, -0.02333843f, 0.05089883f, 
    0.13748820f, -0.04538586f, 0.02440728f, 0.02662409f, 0.21447517f, 0.00120177f, -0.00764381f, -0.09074905f, 
    -0.02499393f, -0.09443723f, -0.10515286f, -0.04510900f, 0.00548239f, 0.01768941f, 0.03560874f, -0.00632909f, 
    -0.04251507f, -0.12106593f, -0.04749226f, 0.32347506f, -0.02223410f, -0.12621298f, 0.01705922f, 0.09686710f, 
    0.22427344f, 0.08983879f, 0.01199875f, 0.12432105f, 0.04932401f, 0.20173050f, -0.00415466f, -0.23383668f, 
    -0.01534257f, 0.10777134f, 0.01198728f, -0.04763058f, -0.03632912f, 0.06190411f, 0.04253731f, -0.05479630f, 
    -0.19319163f, -0.29404604f, -0.06709929f, -0.10483514f, 0.11661950f, 0.02372611f, -0.01623841f, -0.00104414f, 
    0.06217966f, 0.00175310f, -0.08963122f, 0.12291811f, -0.11905627f, 0.02554851f, 0.12638922f, 0.05076197f, 
    -0.03911268f, 0.07978348f, -0.09836895f, -0.04731712f, 0.08333248f, -0.09176591f, -0.01529773f, 0.00811527f, 
    -0.21324773f, 0.04018348f, 0.08036330f, 0.00415259f, -0.07007578f, -0.15723252f, -0.16210057f, -0.05383096f, 
    0.08992928f, 0.13300106f, 0.08054876f, 0.12811266f, -0.30360055f, -0.34366110f, -0.00997285f, 0.09498278f, 
    0.12294247f, 0.09990178f, 0.12521480f, 0.16462831f, 0.19126523f, -0.00944991f, -0.00255863f, -0.03946156f, 
    0.16961035f, 0.10458567f, 0.17779842f, -0.20270135f, 0.16884100f, 0.02971669f, -0.04605868f, 0.03757723f, 
    0.00045900f, 0.05740895f, 0.09186222f, -0.04489105f, -0.01792626f, 0.22863247f, 0.23679951f, -0.17091930f, 
    -0.09157622f, 0.16925417f, 0.01364204f, -0.00620234f, -0.11600579f, -0.08266397f, -0.06928893f, -0.04263711f, 
    0.17419942f, 0.07550398f, 0.00582317f, -0.18000527f, 0.21911693f, -0.00621074f, 0.14258966f, -0.00494743f, 
    -0.05299195f, -0.03551375f, -0.01712610f, -0.07419566f, -0.39660826f, -0.27561519f, -0.01284987f, -0.17146218f, 
    0.13201696f, 0.03704463f, 0.08247384f, -0.02879599f, 0.11188728f, -0.05116307f, 0.05307737f, 0.00856627f, 
    -0.26929253f, -0.25921109f, 0.01319899f, 0.01586002f, 0.07997721f, -0.02418291f, 0.02877671f, 0.19100013f, 
    0.02018430f, -0.03570019f, 0.00630070f, -0.15083024f, -0.10355166f, 0.13406882f, 0.31954715f, 0.01243989f, 
    0.15095371f, -0.03274682f, 0.04804576f, 0.02564558f, -0.14658560f, 0.06671339f, 0.00094861f, 0.05719213f, 
    0.32279095f, 0.24177115f, 0.16215378f, 0.32316399f, 0.12252973f, 0.09279753f, -0.01222826f, 0.02120055f, 
    0.04930302f, -0.09867042f, -0.05640020f, 0.11005610f, -0.14985165f, -0.18057191f, 0.10201189f, 0.23067662f, 
    0.20768794f, 0.12381434f, -0.03277402f, 0.11310549f, 0.15110788f, -0.08948278f, 0.14342028f, 0.05761820f, 
    -0.01047103f, -0.08419960f, -0.28172007f, 0.18331750f, -0.05168857f, 0.03774695f, -0.03389934f, 0.15159400f, 
    0.03511706f, -0.13675776f, 0.02445434f, -0.10464585f, 0.21827345f, -0.14479275f, -0.04415483f, 0.10558479f, 
    -0.01026459f, 0.03017559f, -0.05290649f, -0.09051340f, -0.07052153f, -0.13636179f, 0.10545906f, 0.02433630f, 
    0.04267379f, -0.09616915f, -0.07778875f, 0.13771166f, -0.02918724f, -0.02961468f, -0.04919392f, -0.02393570f, 
    0.14482060f, -0.00283224f, 0.09010322f, 0.11537022f, 0.00888181f, 0.21988235f, 0.10649907f, -0.25595874f, 
    0.00421163f, 0.01964078f, 0.01973589f, 0.08133576f, -0.00601165f, -0.01161755f, -0.11894076f, -0.04919902f, 
    -0.29972023f, -0.23990589f, -0.18793973f, -0.16409312f, 0.07238995f, 0.02410973f, -0.10991896f, 0.08166010f, 
    -0.04225706f, 0.05726368f, 0.04651291f, 0.12469633f, -0.04377212f, 0.04688296f, 0.05803525f, 0.03371082f, 
    0.02938129f, 0.13610776f, -0.07061716f, -0.04265143f, 0.09658901f, 0.02258299f, 0.11882556f, 0.00985418f, 
    -0.28062549f, -0.00314267f, 0.12661372f, 0.04038118f, -0.18240252f, -0.20968516f, -0.18573424f, 0.01552259f, 
    0.03290425f, 0.05881061f, 0.12101410f, 0.11807835f, -0.27530459f, -0.35504794f, 0.05564613f, 0.07854684f, 
    0.04841820f, 0.16885476f, 0.10802091f, 0.15090041f, 0.07018787f, -0.07647022f, 0.03281597f, 0.08226936f, 
    0.17727643f, 0.03218891f, 0.20306396f, -0.12647456f, 0.07009768f, 0.08611168f, -0.03462422f, 0.00426612f, 
    0.07467303f, 0.00303323f, 0.04142930f, -0.13537136f, -0.15343158f, 0.21463397f, 0.19965221f, -0.04048737f, 
    0.00841778f, 0.19072117f, -0.03942910f, 0.00070846f, -0.04908077f, -0.03927025f, 0.06528341f, 0.07628185f, 
    -0.14729558f, 0.21288897f, 0.10089665f, -0.05787013f, 0.10081004f, -0.06731327f, 0.12155388f, 0.00042856f, 
    0.00513798f, -0.10063928f, -0.13364993f, -0.03193311f, -0.38000223f, -0.27505916f, -0.04377676f, -0.11395496f, 
    0.20450611f, 0.10392568f, -0.06017920f, 0.06718667f, 0.12602822f, 0.07790868f, -0.04214501f, 0.01343385f, 
    -0.03091517f, 0.14490791f, -0.02981906f, -0.04123073f, 0.05754812f, 0.08949275f, 0.12172640f, 0.00828873f, 
    -0.08179954f, 0.00120401f, 0.01318707f, 0.04057068f, -0.15963531f, 0.14283405f, -0.05274613f, -0.28496501f, 
    -0.09907060f, 0.02518102f, 0.15708543f, -0.04332762f, 0.04109391f, 0.05973092f, 0.02505492f, 0.04332817f, 
    -0.11545599f, 0.06790361f, 0.10737064f, -0.25327924f, -0.02632765f, 0.06399795f, 0.01911377f, 0.02838908f, 
    0.01436291f, -0.02608992f, 0.04798870f, 0.01744112f, 0.06726212f, 0.09492174f, -0.05238775f, 0.15787950f, 
    0.19544001f, 0.02616557f, -0.09416364f, -0.03249764f, -0.09348454f, -0.06117232f, -0.08127266f, -0.03865189f, 
    0.39314356f, -0.04459640f, 0.07674333f, -0.15458409f, 0.03550518f, 0.10938507f, 0.02245785f, -0.02421517f, 
    0.00220667f, 0.01436677f, -0.04544657f, -0.10609227f, -0.07392496f, 0.19595733f, 0.25905764f, 0.32412273f, 
    0.08980583f, 0.16409662f, 0.07618528f, -0.04947535f, -0.10693733f, 0.03208692f, -0.06230193f, -0.07651822f, 
    0.38387471f, 0.02877031f, 0.07883254f, -0.09990998f, -0.02698584f, -0.04077747f, 0.03984374f, -0.05955349f, 
    -0.02550525f, -0.03364269f, 0.03419536f, 0.05232553f, -0.27949974f, -0.05333957f, -0.00147165f, -0.09401395f, 
    -0.19257565f, -0.03255886f, 0.06591002f, -0.01148927f, 0.10447411f, -0.11861745f, 0.14672425f, -0.02689411f, 
    0.08805419f, 0.03992009f, 0.13437665f, 0.01591844f, 0.11760319f, 0.06051422f, 0.14411578f, -0.03484807f, 
    -0.00536951f, 0.12427403f, 0.07282634f, -0.06347028f, 0.04658026f, -0.25525919f, 0.13656758f, 0.26010722f, 
    0.12688199f, -0.06376865f, 0.02850100f, 0.01263531f, 0.01901379f, 0.11340696f, -0.04822106f, -0.08196036f, 
    0.05184119f, -0.06904393f, 0.07217614f, 0.06645231f, 0.00889619f, 0.02059960f, 0.01667305f, 0.02169365f, 
    -0.10310931f, -0.09083413f, -0.11062466f, 0.11060368f, -0.07907483f, 0.06171718f, 0.02623157f, 0.12611300f, 
    0.02213830f, 0.03379154f, 0.03112734f, 0.00268107f, 0.03731435f, -0.04072074f, -0.13256468f, 0.06802045f, 
    -0.18263005f, 0.14176983f, -0.07023134f, -0.07447216f, -0.07301521f, 0.01182536f, 0.03336547f, -0.04276586f, 
    -0.00387749f, -0.04612704f, -0.03041567f, 0.02539104f, 0.15113710f, 0.05502703f, 0.08827953f, 0.13732220f, 
    -0.07226607f, 0.05850006f, 0.09542096f, -0.03543092f, -0.16227631f, -0.04064197f, 0.08149379f, -0.01135817f, 
    0.44098240f, -0.00611115f, -0.12430811f, 0.09407968f, 0.03337759f, -0.00694946f, 0.13634802f, 0.00419096f, 
    0.01433193f, -0.03395883f, 0.03981027f, -0.02430611f, -0.15921089f, 0.04564755f, -0.01768756f, -0.18790604f, 
    0.05076417f, 0.06495023f, -0.03000201f, -0.04260243f, -0.08574168f, 0.05075238f, -0.02044718f, -0.04960644f, 
    0.03819555f, 0.08669633f, -0.01200410f, 0.15869139f, -0.00264313f, 0.08242134f, 0.19541088f, -0.03897976f, 
    0.12814854f, 0.09177083f, -0.07458244f, -0.06511014f, -0.15498842f, -0.08147169f, -0.23150903f, 0.05181417f, 
    0.12389735f, 0.01571503f, -0.00811581f, -0.07673216f, -0.06837207f, -0.03363217f, 0.05808368f, 0.16149412f, 
    -0.27385047f, -0.16396546f, -0.17890643f, -0.10211341f, 0.04446689f, -0.08280189f, -0.03402837f, 0.00772691f, 
    -0.03987048f, -0.16816767f, -0.12830880f, 0.09023076f, 0.18260513f, 0.20789465f, 0.15940663f, 0.25309548f, 
    0.12156907f, 0.11826482f, 0.04178821f, -0.06896824f, 0.15239900f, -0.01179068f, 0.07247535f, -0.00823265f, 
    -0.09278167f, 0.11880073f, -0.01933202f, 0.08804586f, -0.16312614f, -0.06985589f, -0.14168160f, 0.06350081f, 
    -0.05949371f, -0.05562038f, -0.13943517f, -0.09680197f, 0.07486871f, -0.13088156f, -0.01107265f, 0.27217039f, 
    -0.00561505f, 0.03606538f, -0.22943500f, -0.13365559f, -0.02934170f, -0.02820304f, 0.04495358f, -0.08428267f, 
    -0.26687455f, 0.11532497f, -0.03380681f, -0.05894958f, 0.03551749f, -0.03152509f, -0.02253984f, 0.12616062f, 
    -0.00718660f, 0.03227173f, 0.07994326f, 0.19166523f, -0.13798803f, 0.13166679f, -0.01735664f, 0.12707105f, 
    0.02334137f, -0.01857978f, 0.11283562f, 0.08402982f, -0.05198878f, 0.05297993f, 0.01489429f, 0.03914321f, 
    0.23656015f, 0.00238405f, 0.00145176f, 0.07316025f, 0.09582283f, -0.05150526f, -0.00424330f, -0.07130209f, 
    -0.00294475f, -0.04880534f, 0.05256964f, 0.05682677f, -0.05727168f, -0.00469196f, 0.01875519f, 0.17510779f, 
    -0.18673927f, -0.02761411f, -0.09249375f, -0.02226622f, 0.07574829f, 0.05944796f, 0.05374718f, 0.03395168f, 
    0.28451219f, 0.15651454f, 0.05318558f, 0.25075862f, -0.01539676f, -0.22340372f, -0.16551250f, -0.08524428f, 
    0.00056264f, 0.16317584f, -0.05559305f, 0.01553378f, 0.21492612f, 0.15618536f, 0.11970304f, 0.10594267f, 
    0.10183460f, 0.16070263f, -0.02010943f, -0.04210849f, 0.04086235f, -0.08018767f, 0.08761502f, 0.05002079f, 
    0.09528174f, -0.02254970f, -0.14462656f, 0.05763419f, -0.02187527f, 0.11849234f, -0.02793633f, 0.02942561f, 
    0.02070242f, -0.00386156f, -0.02159184f, -0.07942821f, 0.07200473f, -0.07496907f, 0.03390314f, 0.23273492f, 
    0.01649944f, 0.14708616f, -0.11140059f, -0.07022239f, 0.05255500f, 0.00103958f, -0.06338737f, 0.06447596f, 
    -0.21850251f, 0.04369659f, 0.00114991f, 0.05438126f, 0.04022739f, -0.03110881f, 0.12462814f, -0.01525334f, 
    -0.04725870f, -0.07795048f, -0.10372297f, -0.13710611f, 0.30199492f, 0.15297185f, 0.03591302f, 0.17730613f, 
    0.15625224f, 0.05986875f, -0.05415500f, -0.13764511f, 0.10562615f, 0.01900242f, 0.01561970f, -0.13405269f, 
    -0.02828561f, 0.05462041f, 0.01265911f, -0.02255634f, 0.03862885f, -0.06592744f, 0.01498657f, -0.06042770f, 
    -0.06225615f, 0.03278760f, -0.07773399f, 0.00454672f, 0.04445899f, 0.04253096f, -0.06624799f, 0.05496928f, 
    -0.00462023f, -0.07920755f, -0.04442256f, -0.06661952f, -0.02950697f, -0.01455332f, -0.04250108f, -0.01041367f, 
    -0.06632007f, 0.02249785f, -0.00618191f, 0.02568027f, -0.01547192f, 0.07099496f, -0.00421489f, -0.00726808f, 
    -0.06161129f, -0.01656504f, -0.00828276f, -0.01893985f, -0.00593190f, -0.02637160f, -0.06301041f, -0.05315275f, 
    0.04911201f, -0.05443559f, 0.01418189f, 0.04146954f, 0.04463319f, 0.06729437f, 0.05744424f, 0.03804206f, 
    0.02128988f, -0.04028798f, -0.05742822f, -0.05876480f, -0.04170660f, -0.07161602f, 0.01401849f, 0.06340349f, 
    0.01825885f, -0.04471227f, -0.03550342f, -0.05004733f, -0.00972754f, 0.01779138f, 0.00902202f, 0.06142124f, 
    -0.01760255f, -0.04273997f, -0.00695592f, 0.02724462f, 0.04007019f, 0.02725605f, -0.05969983f, 0.04647711f, 
    0.05439607f, 0.01308378f, 0.00489693f, -0.05992417f, 0.00589785f, -0.02299017f, 0.02725239f, 0.02768194f, 
    -0.06022941f, 0.05213313f, -0.06737826f, 0.04099080f, 0.00031459f, 0.01572230f, 0.00450840f, -0.00295968f, 
    -0.03173349f, -0.02368766f, -0.07734257f, -0.02289565f, -0.06275015f, -0.04416321f, -0.01820771f, -0.06317015f, 
    0.06174232f, -0.00950151f, -0.05820115f, 0.04669822f, 0.04015303f, -0.02585692f, 0.01624906f, -0.06391129f, 
    0.00247025f, 0.02871823f, 0.06593516f, -0.04959723f, -0.05426779f, -0.07244211f, -0.07924475f, 0.00009245f, 
    0.05717259f, 0.05201138f, 0.02495190f, -0.03606134f, 0.02215074f, -0.06292095f, -0.00286538f, 0.02082267f, 
    -0.06023122f, 0.03585495f, -0.07791720f, -0.07556268f, -0.03690742f, 0.03986141f, 0.05207427f, -0.04354120f, 
    0.04339687f, -0.03048995f, -0.06055147f, 0.04334662f, 0.01844716f, 0.04089197f, -0.00792710f, 0.01080360f, 
    0.05359020f, 0.04187529f, 0.05323300f, 0.05063577f, -0.01505464f, 0.00420925f, -0.06736235f, -0.04683381f, 
    0.05625381f, -0.07050266f, -0.06366073f, 0.03727433f, -0.00111177f, -0.05780180f, 0.03428946f, -0.01106302f, 
    -0.01524447f, 0.00038225f, -0.02800333f, -0.06977011f, -0.00704838f, -0.04696232f, -0.06994686f, 0.05491171f, 
    -0.05311482f, -0.06563582f, -0.00206092f, -0.03595525f, 0.05584814f, 0.03160831f, -0.05992700f, 0.01812621f, 
    0.06574810f, -0.03789747f, -0.07707333f, 0.04142948f, -0.02501289f, -0.01835644f, 0.00832414f, -0.01142142f, 
    -0.05340582f, -0.04621321f, -0.05611680f, 0.00580040f, -0.03630830f, 0.02884723f, 0.01604127f, -0.01781181f, 
    -0.06424230f, -0.07159328f, -0.00028898f, -0.06603190f, 0.03860119f, 0.05367794f, 0.00509907f, 0.03887174f, 
    0.04079232f, 0.04911857f, -0.05562441f, 0.06178816f, -0.04415038f, -0.01991388f, 0.01010695f, 0.05096874f, 
    -0.06548604f, -0.05139186f, -0.02849718f, 0.00381935f, -0.00093586f, 0.01722738f, -0.00089929f, -0.07354646f, 
    -0.04126242f, -0.02027827f, -0.03832603f, 0.02949568f, 0.00594955f, 0.03265917f, 0.03781361f, 0.01121110f, 
    0.04042017f, -0.00971124f, -0.02023442f, -0.05558218f, -0.06124616f, 0.00551137f, -0.00889298f, -0.05600464f, 
    0.02504670f, -0.06123418f, -0.04947659f, -0.06012704f, 0.05393111f, 0.00270747f, 0.00457230f, -0.00588823f, 
    -0.06128656f, -0.01929727f, -0.02986804f, -0.06252913f, -0.06599372f, -0.03995578f, -0.04967646f, -0.01584134f, 
    0.01751081f, 0.05314614f, 0.02260515f, 0.03157614f, 0.02134214f, 0.06488458f, -0.01854536f, 0.05595371f, 
    0.00656300f, 0.06363101f, -0.00681234f, -0.01626568f, 0.04654235f, -0.03218983f, 0.03519240f, -0.07703080f, 
    -0.02407916f, 0.01529168f, 0.01330245f, -0.06631157f, 0.02176151f, -0.01879204f, 0.05441250f, -0.00127566f, 
    -0.07307078f, -0.01081039f, 0.01090346f, 0.00102418f, 0.06372389f, 0.06054464f, 0.01651988f, -0.03848582f, 
    -0.00531152f, -0.03916075f, 0.04850947f, -0.06527267f, 0.00339890f, -0.05037300f, 0.01337769f, 0.04920818f, 
    -0.06342471f, -0.04931257f, -0.06561268f, -0.05991943f, 0.03400078f, -0.01784042f, 0.02680212f, -0.01479200f, 
    -0.06705134f, -0.00986632f, 0.00950021f, -0.01781284f, -0.02744322f, 0.04941993f, -0.02350180f, 0.06460556f, 
    -0.04815247f, 0.04765480f, 0.03251180f, -0.05672444f, -0.06748296f, 0.02032486f, 0.03596804f, 0.04211473f, 
    0.00462158f, -0.00053100f, -0.05067249f, -0.06542014f, -0.03603169f, 0.04519293f, -0.02899989f, -0.03346989f, 
    -0.02048703f, -0.07757762f, -0.00693988f, -0.00252722f, 0.03030413f, 0.01957703f, 0.02032610f, 0.05721181f, 
    -0.01505082f, -0.03531237f, -0.07130411f, 0.01239072f, -0.07128765f, -0.07287034f, -0.02141502f, 0.02758818f, 
    0.04139723f, -0.06182509f, -0.00835392f, -0.07716308f, -0.05221736f, -0.05313485f, -0.04087373f, 0.01736265f, 
    0.02613547f, -0.02789219f, 0.01616825f, 0.01389213f, -0.06770051f, -0.02515027f, -0.00955281f, -0.01972622f, 
    -0.06690203f, 0.06143817f, 0.02368429f, -0.06025703f, 0.01188568f, -0.00047798f, -0.02697389f, -0.06543440f, 
    0.01622553f, 0.06396135f, -0.01842638f, -0.06600574f, 0.01739434f, -0.05178557f, -0.02891974f, -0.03492047f, 
    -0.00767349f, -0.02449544f, -0.04237387f, 0.05918432f, -0.02239912f, -0.03764515f, -0.02358840f, 0.03326439f, 
    0.01071034f, -0.00681381f, 0.02799067f, 0.02014904f, 0.05177454f, -0.07361047f, -0.01139287f, -0.05199042f, 
    -0.05346509f, 0.01922118f, -0.05870920f, 0.02392239f, -0.04208834f, -0.02850327f, -0.07450730f, -0.02976087f, 
    0.03937562f, 0.00185561f, 0.01643960f, -0.13884534f, 0.04652416f, -0.07306864f, 0.10882831f, 0.12946118f, 
    -0.03126439f, 0.00080283f, 0.00410144f, -0.04441860f, 0.12993284f, -0.50884449f, -0.05296633f, 0.26841998f, 
    0.02905320f, 0.03025574f, -0.21159086f, 0.08621248f, 0.03837314f, 0.09812214f, 0.09470752f, 0.07976228f, 
    0.01561164f, -0.17908882f, 0.07631064f, 0.21291631f, -0.04082424f, -0.04410448f, 0.00058255f, 0.01351255f, 
    0.02554220f, -0.00594256f, 0.09776643f, 0.07800382f, -0.00561417f, 0.22980919f, 0.00330622f, -0.04336570f, 
    -0.03524601f, 0.03462200f, 0.02389296f, -0.08193493f, 0.20605433f, -0.01245151f, -0.01932981f, 0.02494257f, 
    -0.02251828f, -0.13091819f, -0.02500452f, 0.15468360f, -0.02205751f, 0.10577563f, -0.04684517f, 0.19248790f, 
    0.00271440f, -0.00701255f, 0.04833272f, -0.11500273f, -0.02656362f, 0.29104099f, -0.01197181f, 0.09258971f, 
    0.01429139f, 0.12356070f, -0.04799496f, 0.05999171f, 0.12110244f, -0.25070971f, -0.13597332f, -0.19330408f, 
    -0.05913662f, -0.05332910f, 0.00936188f, 0.13560422f, 0.07429994f, -0.01149066f, -0.00669029f, 0.05888703f, 
    -0.00684102f, 0.06532502f, 0.06226867f, 0.15157588f, 0.32562536f, -0.26114780f, 0.06651304f, -0.21854204f, 
    -0.08733176f, 0.03385920f, 0.07972734f, 0.06088258f, -0.00918797f, 0.06380247f, 0.00851262f, 0.07545431f, 
    0.14607503f, -0.09202443f, 0.00106288f, -0.11051162f, -0.09532794f, 0.04980740f, -0.02845641f, 0.04750744f, 
    0.06989314f, 0.05377149f, 0.06953909f, 0.14264715f, -0.30230850f, 0.38853189f, -0.13511106f, -0.17874192f, 
    -0.04936280f, -0.03138926f, 0.02405586f, -0.01424714f, 0.12928165f, 0.03579872f, 0.12308796f, 0.12366036f, 
    0.06429023f, 0.08523553f, -0.00385362f, 0.22884031f, 0.01254905f, 0.09314864f, 0.05661510f, 0.06372558f, 
    0.06701015f, 0.17787212f, 0.04922717f, -0.01460173f, 0.09930751f, 0.25500879f, -0.18413192f, 0.06095793f, 
    0.03142729f, -0.10878716f, -0.04327637f, -0.02286005f, 0.03693254f, -0.03654349f, 0.09411142f, 0.11081472f, 
    0.29471439f, 0.00061836f, -0.05308583f, -0.03231765f, -0.04492498f, 0.10394698f, -0.04600300f, 0.06324842f, 
    -0.03225251f, -0.03869643f, 0.14560831f, -0.03285991f, 0.08822154f, -0.04501508f, 0.18304849f, 0.16301408f, 
    -0.01649084f, -0.02572263f, 0.07765293f, -0.04108217f, 0.11143191f, 0.04055593f, -0.03051295f, -0.03954378f, 
    -0.21827260f, 0.15050927f, -0.01802761f, -0.17946777f, -0.06356253f, -0.02229884f, 0.00080754f, 0.03452257f, 
    -0.02679411f, -0.03534733f, -0.06854142f, -0.05794523f, 0.08987359f, 0.03573900f, 0.07637084f, -0.06242783f, 
    0.00801428f, -0.05244280f, 0.00390746f, 0.11505493f, 0.07381371f, 0.17470446f, 0.00769161f, -0.11001851f, 
    0.10847521f, 0.22291587f, 0.03463633f, 0.08808134f, 0.10936083f, 0.03567556f, 0.13994181f, 0.07392130f, 
    0.05869063f, 0.08465581f, 0.15016145f, 0.08089302f, 0.09887820f, -0.08180586f, 0.08469228f, -0.04008594f, 
    0.03667878f, 0.03382041f, 0.03463988f, -0.25481045f, -0.00685084f, -0.13746497f, 0.03556943f, -0.11796906f, 
    -0.16800901f, -0.08608306f, -0.09920633f, -0.01782116f, 0.09088025f, -0.09524859f, -0.13267508f, -0.29596093f, 
    -0.07357045f, -0.07760735f, 0.07920729f, -0.24849272f, 0.32424590f, 0.19393550f, 0.07484644f, -0.17679965f, 
    0.17953953f, -0.07002210f, 0.00111620f, 0.00399793f, 0.09471162f, 0.09101060f, -0.02700414f, -0.07695302f, 
    0.30844417f, 0.15752903f, -0.33146137f, 0.24727944f, 0.00674932f, 0.08982376f, -0.01009601f, 0.03625010f, 
    0.17011434f, -0.03352462f, -0.15521310f, -0.01727760f, -0.00687008f, 0.14590454f, 0.13947724f, 0.12791604f, 
    0.05620943f, 0.08011542f, 0.13242210f, -0.00502117f, -0.09147811f, 0.10433505f, 0.01293370f, -0.06209291f, 
    0.16619256f, -0.00903860f, -0.19493334f, 0.29518467f, -0.06973238f, -0.04719056f, -0.05943099f, 0.05048811f, 
    -0.18461382f, -0.03021623f, 0.05606597f, -0.19364579f, -0.06168542f, -0.16639665f, -0.11746217f, -0.21842772f, 
    -0.23508202f, -0.18269634f, 0.06717306f, -0.03469380f, -0.10134976f, -0.11407287f, 0.03470442f, -0.11116012f, 
    0.04593869f, 0.04118080f, 0.00525480f, 0.06022105f, 0.00615316f, -0.10519528f, -0.04882675f, -0.09053195f, 
    0.02343685f, 0.14859700f, 0.02917466f, -0.07635954f, -0.20491020f, -0.03859384f, -0.07367466f, -0.03361610f, 
    -0.02197751f, 0.02581492f, -0.34750757f, 0.02386868f, 0.02070613f, 0.07465722f, -0.08043250f, -0.03853263f, 
    0.18272059f, 0.25695208f, 0.26694599f, 0.25194031f, 0.08573171f, 0.00866573f, 0.07107514f, -0.01696609f, 
    -0.06804299f, -0.01694962f, 0.02290057f, 0.11345910f, 0.00450253f, -0.06239762f, 0.12445462f, 0.29726836f, 
    0.12680104f, -0.15284066f, -0.11160131f, 0.07828104f, 0.09285098f, 0.17087200f, -0.11976742f, -0.17749055f, 
    0.18883914f, -0.12345096f, -0.18720432f, -0.16770183f, -0.02694406f, -0.04711423f, 0.03224476f, -0.01255717f, 
    -0.07030815f, 0.02112871f, -0.11500765f, 0.06971009f, 0.15007377f, 0.12715334f, 0.08334882f, 0.16425388f, 
    -0.20453198f, -0.13956392f, -0.02046227f, -0.07572105f, -0.04830431f, -0.05196701f, -0.07277980f, -0.01128596f, 
    0.49729216f, 0.26965821f, 0.11635770f, -0.30475050f, 0.01021702f, -0.01857605f, 0.02181663f, 0.11631891f, 
    -0.08805160f, 0.03629770f, -0.05989490f, 0.10725589f, -0.02396235f, 0.16842899f, 0.16134374f, 0.11491617f, 
    0.02895914f, 0.12738547f, 0.11803102f, -0.07907546f, -0.02025438f, 0.04897036f, 0.08520655f, 0.02804640f, 
    -0.00279209f, -0.00074667f, 0.03159124f, -0.05051142f, 0.02672897f, 0.00642618f, -0.07552015f, 0.01793685f, 
    -0.04974518f, -0.06156322f, -0.05781712f, 0.03277913f, 0.01639681f, -0.05820219f, -0.02708555f, 0.00793414f, 
    0.06095072f, -0.01016842f, 0.05414372f, 0.01285970f, 0.03940433f, 0.00057452f, -0.03936353f, 0.05525953f, 
    -0.07298034f, -0.06968433f, -0.03969019f, -0.05160740f, 0.02779617f, -0.04603964f, -0.05301706f, 0.06024164f, 
    -0.05419763f, -0.05411604f, 0.05365280f, 0.01428021f, 0.04209040f, -0.06599913f, 0.04462175f, -0.06198096f, 
    -0.07406914f, -0.04775079f, -0.07051669f, -0.03271447f, 0.01104259f, 0.04274425f, 0.04544080f, 0.02829971f, 
    -0.05563397f, -0.02985504f, 0.00882837f, 0.02797192f, -0.04980284f, -0.05988679f, 0.04829127f, -0.07581332f, 
    0.04939456f, 0.01087227f, -0.07921693f, -0.03320371f, -0.00090372f, -0.06026997f, 0.02901263f, 0.01201801f, 
    -0.03716188f, -0.05731240f, -0.07423681f, 0.05309270f, -0.07320897f, 0.01842733f, 0.05632154f, 0.02758482f, 
    -0.03386756f, -0.04673259f, -0.01931265f, -0.04693737f, -0.00661285f, -0.06410250f, -0.05514292f, 0.03248564f, 
    -0.04605402f, 0.05696598f, -0.04874816f, -0.06268921f, -0.06226153f, 0.02138995f, -0.05808251f, 0.05267267f, 
    0.04984060f, 0.03330540f, -0.06092405f, 0.02237565f, 0.04864117f, 0.02608291f, 0.04199128f, -0.05491582f, 
    -0.00033685f, 0.01636418f, 0.03714317f, 0.05435018f, 0.00167074f, -0.01904345f, -0.01857723f, -0.07032388f, 
    -0.07010418f, -0.05168774f, 0.00710845f, -0.02999500f, -0.04269530f, -0.03575698f, -0.03988779f, 0.06753951f, 
    0.00069093f, -0.06673722f, -0.01352879f, -0.01263256f, -0.04991917f, 0.04463036f, 0.00837902f, -0.06856863f, 
    -0.06508951f, -0.03804246f, 0.04875165f, 0.04060802f, 0.00534138f, -0.04729696f, -0.06906691f, -0.03059909f, 
    0.03521866f, -0.04608100f, -0.05299573f, 0.02270546f, 0.04694693f, -0.06963930f, 0.00365060f, 0.05831548f, 
    0.02850021f, -0.04296810f, -0.06796742f, -0.06231397f, -0.03285383f, 0.01464415f, -0.05795920f, 0.02816301f, 
    0.01862974f, 0.01613273f, -0.06591088f, 0.03688873f, 0.03577163f, -0.07854887f, 0.02948790f, 0.01477862f, 
    0.03636656f, 0.01628643f, 0.01275488f, 0.06189698f, -0.02097181f, -0.03455008f, -0.02437274f, 0.01355494f, 
    -0.03182074f, -0.04668004f, 0.02888312f, 0.01895181f, -0.06000814f, -0.04965014f, 0.05333408f, 0.06668515f, 
    -0.03339852f, 0.03578399f, 0.02272648f, 0.04268510f, -0.03101100f, 0.02057002f, -0.04953294f, 0.02284878f, 
    -0.07524768f, -0.01944325f, -0.02524752f, -0.08032434f, -0.06280993f, -0.05309121f, 0.00842153f, -0.05807449f, 
    0.02280398f, -0.00418639f, 0.03146412f, 0.05936727f, 0.00899576f, 0.02461281f, 0.06017843f, -0.05034865f, 
    -0.05556806f, 0.09575997f, -0.13514836f, -0.01551513f, 0.08622212f, 0.11929671f, 0.02168234f, -0.11002231f, 
    -0.04187411f, -0.07025568f, 0.01888913f, -0.03413860f, -0.16003004f, 0.07706640f, -0.09223150f, -0.07669693f, 
    -0.01491833f, 0.05819248f, 0.00178113f, -0.04382118f, 0.11879285f, -0.10576786f, 0.00642193f, -0.01886662f, 
    -0.30155313f, -0.16560163f, 0.04709383f, -0.07999142f, 0.06841986f, -0.02694928f, 0.00287953f, -0.00294405f, 
    -0.01186752f, 0.00387213f, 0.03986487f, 0.14720382f, -0.17909665f, -0.02235952f, 0.03730441f, 0.02683766f, 
    -0.06967194f, 0.08088858f, -0.05608160f, -0.04331539f, -0.10069352f, -0.17541029f, 0.00360392f, 0.08914145f, 
    0.09974490f, -0.11358665f, 0.27932304f, -0.14370471f, 0.09651948f, 0.03750865f, 0.08285122f, 0.12546170f, 
    -0.05209459f, 0.05455998f, 0.04525442f, -0.02174943f, -0.00896714f, 0.15294127f, -0.08432876f, 0.32950479f, 
    0.07484499f, 0.04739707f, -0.15676866f, 0.07417678f, 0.01696988f, 0.11971551f, 0.02038977f, 0.08788192f, 
    0.03907489f, 0.17222759f, 0.20706916f, 0.07921991f, -0.06165161f, 0.05018282f, 0.08192611f, 0.05038990f, 
    -0.01917393f, 0.03766884f, -0.08778595f, 0.02725663f, -0.05319379f, 0.11494443f, -0.17838311f, 0.10940044f, 
    -0.02298101f, -0.01819835f, 0.05143932f, 0.08622906f, 0.07535828f, 0.03950165f, 0.10731170f, 0.09454729f, 
    0.08618791f, -0.03397137f, 0.24218725f, -0.23267861f, -0.03309428f, 0.01680002f, 0.06697465f, -0.07835402f, 
    -0.03124127f, 0.04369400f, 0.17580394f, -0.02132651f, -0.22842091f, 0.10483103f, 0.16872612f, 0.19423772f, 
    0.03912209f, -0.12262359f, -0.02307497f, 0.13083026f, -0.04410258f, 0.15032451f, -0.02424887f, 0.12574254f, 
    0.12625104f, 0.11636599f, -0.02941177f, 0.03367079f, 0.10494599f, 0.12583148f, 0.09419148f, -0.00566463f, 
    -0.18001682f, -0.00743117f, -0.18721312f, 0.04843739f, -0.17031409f, 0.08717409f, -0.07637183f, -0.02681514f, 
    0.10797607f, 0.04409418f, -0.12502795f, -0.07271273f, 0.06664007f, 0.06983038f, -0.02300904f, 0.17634550f, 
    -0.25612986f, 0.12699020f, -0.13036531f, 0.04916245f, -0.04599279f, 0.05135475f, -0.04522772f, 0.07960340f, 
    -0.01220307f, -0.03914827f, 0.06637900f, 0.19734588f, 0.13476965f, -0.06071690f, 0.01578724f, 0.07863694f, 
    0.09345353f, 0.14188153f, -0.01945608f, 0.10844625f, 0.04468452f, -0.06757142f, 0.04521165f, -0.06225171f, 
    0.12489528f, -0.06581093f, -0.13204540f, 0.03778012f, -0.11513975f, -0.08903825f, -0.05406528f, 0.00508748f, 
    0.03805868f, -0.06817873f, 0.12121058f, 0.08479159f, -0.10216088f, 0.03452389f, -0.02079518f, -0.07642738f, 
    -0.09743649f, -0.04515165f, -0.01574221f, -0.02924188f, -0.02877344f, 0.10367434f, -0.00561608f, -0.04759004f, 
    0.35007855f, -0.05547610f, 0.30358696f, -0.07228061f, -0.05193443f, 0.09595605f, -0.09520838f, 0.04417469f, 
    0.02657337f, 0.02012211f, -0.00181918f, -0.01906458f, -0.09360349f, -0.13027158f, 0.19420156f, -0.05721100f, 
    -0.16931374f, -0.02012688f, -0.11344457f, 0.08591749f, 0.11655228f, -0.05859803f, 0.04898392f, -0.02259265f, 
    0.09772336f, 0.08912229f, 0.11721115f, 0.17102455f, -0.04745496f, -0.09257658f, 0.14257699f, 0.03411232f, 
    -0.01080228f, 0.12435284f, 0.13216050f, 0.17773773f, -0.09399766f, 0.19599454f, 0.00504552f, -0.01411075f, 
    -0.03676764f, -0.05078519f, -0.05860426f, 0.13221194f, -0.01454808f, -0.00859301f, -0.05417159f, -0.02122135f, 
    0.42940661f, -0.19819771f, 0.05607736f, -0.03163043f, -0.04392792f, 0.11450989f, 0.14032264f, 0.01238520f, 
    0.05071358f, 0.02534614f, 0.06236188f, 0.01141073f, -0.09148422f, 0.33414781f, -0.08003549f, -0.10797072f, 
    0.13827465f, 0.13241658f, -0.03421200f, -0.03855071f, -0.09681141f, -0.03256323f, -0.10038079f, -0.09653372f, 
    0.28871855f, -0.15861754f, 0.08700367f, 0.13382635f, -0.10634846f, 0.05329529f, -0.01868777f, -0.03225811f, 
    -0.05425461f, 0.01684219f, -0.11283067f, -0.04233063f, 0.26434386f, -0.01199456f, 0.05336445f, -0.08089150f, 
    -0.14780298f, 0.01254909f, 0.01801599f, 0.01951563f, -0.09204230f, -0.02119583f, 0.06211517f, 0.02752974f, 
    0.16018291f, 0.15435423f, 0.05981106f, -0.06971431f, 0.01265776f, 0.05846358f, 0.07401883f, 0.04932408f, 
    0.06828554f, 0.05277140f, -0.13355865f, 0.02436584f, -0.04567941f, -0.03814888f, -0.12421566f, -0.16380523f, 
    0.20913397f, -0.00868438f, 0.11445357f, -0.02333530f, -0.05047576f, -0.01461784f, 0.05321549f, 0.04412555f, 
    -0.06966693f, 0.02086205f, 0.01044823f, -0.16560884f, 0.10204014f, 0.10214859f, 0.06169991f, 0.08160298f, 
    0.05141459f, -0.03157420f, 0.04957424f, -0.01194757f, -0.06274188f, 0.08174597f, -0.01624580f, -0.05466816f, 
    -0.12006698f, -0.03316681f, -0.03598016f, 0.05490858f, -0.08338688f, 0.08957435f, -0.02448302f, 0.05320892f, 
    -0.10762768f, 0.17701808f, 0.05062276f, -0.07511641f, 0.00690839f, -0.00569562f, -0.15903233f, 0.05095469f, 
    0.03496214f, -0.02268763f, 0.11459877f, 0.07246099f, 0.01301285f, -0.02174954f, -0.12995207f, -0.18186608f, 
    0.10130595f, -0.13558631f, 0.05091601f, -0.08622830f, 0.01820896f, -0.01867084f, -0.01480026f, -0.06111970f, 
    0.36667830f, 0.16295213f, -0.01455386f, 0.03384984f, -0.10197701f, 0.03236937f, 0.00841806f, -0.00688726f, 
    -0.02187723f, 0.04263768f, 0.10274896f, 0.04321576f, -0.30743527f, 0.02071344f, 0.03877128f, -0.30370912f, 
    -0.08824161f, 0.08500075f, 0.11567695f, -0.00091789f, -0.04402715f, -0.00820274f, -0.00816025f, -0.00574268f, 
    0.06226553f, -0.07799340f, 0.05794024f, 0.05373057f, 0.02001470f, 0.00787743f, 0.01793501f, -0.05280223f, 
    -0.00339917f, -0.08084957f, -0.02559116f, -0.04199258f, -0.06755865f, -0.05846819f, 0.07384499f, -0.02561224f, 
    -0.02514994f, 0.04383368f, 0.02720574f, -0.00315420f, -0.07548993f, 0.06481528f, -0.01735835f, -0.02946655f, 
    -0.07376995f, 0.00199438f, 0.01311942f, 0.00197796f, -0.01786730f, -0.01135433f, 0.05788772f, 0.03643684f, 
    0.04534996f, 0.06341708f, -0.04981749f, 0.01246692f, 0.05983463f, -0.01927268f, -0.02168836f, 0.01311221f, 
    0.05517821f, -0.08021425f, 0.00806825f, 0.05809304f, -0.04852810f, -0.02611009f, 0.05569020f, 0.03492421f, 
    -0.02713057f, -0.00338130f, -0.03330668f, -0.04590623f, -0.02348273f, -0.00488795f, 0.01357304f, -0.00734945f, 
    -0.02028167f, -0.06867636f, 0.06509796f, -0.07275266f, -0.04106254f, -0.02558823f, -0.07302203f, 0.04981625f, 
    -0.06371262f, -0.07207524f, -0.00151392f, 0.04451265f, -0.03793203f, -0.00071798f, 0.03153263f, -0.04290354f, 
    -0.06874792f, 0.06355940f, 0.03105690f, -0.07084488f, -0.07896059f, 0.02186065f, -0.07801776f, -0.04518520f, 
    0.01073766f, -0.04990063f, -0.01168620f, -0.00847409f, -0.04047746f, 0.00799860f, -0.02702722f, -0.00174374f, 
    -0.04435774f, -0.06695192f, -0.02615853f, 0.02208824f, -0.05728164f, -0.07388556f, -0.03458518f, -0.05127025f, 
    0.03847151f, 0.02472884f, 0.01214383f, -0.05803026f, -0.00005639f, -0.04349293f, 0.01647328f, 0.05902322f, 
    0.01021221f, 0.01707358f, -0.04287177f, 0.01998504f, 0.05934827f, -0.03053220f, 0.01662723f, -0.06154444f, 
    0.05451313f, -0.04337886f, 0.03989347f, -0.06581590f, -0.06663588f, -0.04938994f, 0.03581331f, -0.04052517f, 
    -0.07376134f, -0.01197639f, 0.03814754f, 0.00071652f, 0.01180927f, 0.04505244f, 0.02757488f, 0.02781216f, 
    0.01879752f, 0.00529367f, -0.06254902f, 0.04980150f, -0.06086820f, -0.03922629f, 0.04213550f, 0.01367637f, 
    0.03103571f, -0.01976218f, 0.06485134f, 0.01845170f, 0.01687983f, 0.01231382f, 0.03391795f, -0.06346954f, 
    -0.03450564f, -0.01440411f, -0.02895373f, -0.04442765f, 0.04591978f, 0.00663511f, -0.04694801f, 0.02388674f, 
    -0.03584413f, 0.02975609f, 0.04059168f, -0.01123959f, 0.01804236f, -0.02350600f, -0.01749324f, -0.01775874f, 
    -0.06753097f, 0.05397532f, -0.03356488f, -0.05008024f, 0.03948117f, -0.01144459f, -0.05819409f, 0.06643156f, 
    0.06625745f, 0.05905969f, 0.01319046f, -0.04979068f, -0.03853948f, -0.01873873f, -0.03825992f, -0.06911501f, 
    -0.05936175f, 0.04228048f, 0.00120675f, 0.05869820f, 0.01386868f, -0.02741184f, 0.05701347f, 0.01865667f, 
    -0.03339840f, 0.03562148f, -0.02664745f, -0.07497813f, 0.03264284f, 0.05381752f, -0.03050168f, -0.03509644f, 
    -0.15295297f, -0.01648511f, 0.14702882f, 0.11271377f, 0.13425967f, 0.00673761f, 0.16064635f, 0.04313994f, 
    0.07406218f, -0.00982849f, 0.13106646f, 0.04204559f, 0.21397178f, 0.15293263f, -0.12680057f, 0.26100841f, 
    0.08804995f, -0.02116259f, 0.04873784f, -0.07955963f, -0.08782975f, -0.09182984f, 0.01919511f, -0.01834497f, 
    0.03271726f, -0.07571396f, -0.04080157f, 0.03706916f, -0.01266895f, -0.04840538f, -0.02406669f, 0.02680176f, 
    -0.00107285f, -0.09031892f, -0.11540083f, 0.02344863f, -0.03448354f, 0.04871284f, 0.05468053f, 0.24905181f, 
    -0.00207247f, -0.01156631f, -0.01078792f, 0.03559578f, -0.04090683f, -0.06571027f, 0.05371379f, 0.06969180f, 
    0.27624503f, -0.07646027f, 0.09785793f, -0.41023675f, -0.10080861f, 0.05266479f, -0.03398602f, -0.09978291f, 
    -0.01830942f, 0.16309687f, 0.04072993f, 0.00949862f, 0.22756805f, -0.03301731f, -0.06863472f, 0.21613504f, 
    -0.11714368f, 0.01019453f, 0.00983300f, 0.06164674f, 0.11906523f, -0.00360845f, 0.06022057f, 0.00429559f, 
    -0.28630638f, -0.16002664f, -0.05849223f, 0.14098221f, 0.06357664f, 0.08729561f, 0.00501415f, -0.09709311f, 
    0.00185715f, 0.02499744f, -0.13953274f, -0.08072475f, -0.07834547f, 0.08386269f, -0.13840973f, -0.03986312f, 
    0.03295901f, 0.12485206f, 0.07263498f, -0.06571856f, -0.10080338f, 0.00044354f, 0.01115451f, 0.02855358f, 
    0.23152237f, -0.16651466f, 0.21739715f, -0.19852166f, 0.04663001f, -0.00874463f, -0.02268147f, 0.02583382f, 
    -0.08257627f, 0.03314869f, -0.09264232f, -0.02371591f, 0.06575871f, 0.03613828f, 0.06622545f, 0.15456375f, 
    0.11944138f, -0.03469191f, 0.07072492f, -0.08521287f, 0.00807429f, -0.00058659f, 0.00484639f, 0.02111869f, 
    -0.05799812f, -0.14177892f, -0.04684006f, 0.20724480f, 0.03207396f, -0.05648216f, -0.01959324f, -0.04439228f, 
    0.08707689f, -0.02296332f, -0.12606074f, -0.06491318f, 0.08358988f, 0.07552142f, 0.19079241f, 0.00261232f, 
    0.01674857f, 0.11838781f, -0.10453773f, 0.01384210f, -0.00753083f, -0.00966198f, 0.01984020f, 0.07957520f, 
    -0.22359762f, 0.07952015f, -0.05515190f, 0.18350959f, -0.09881798f, -0.04688026f, 0.09284724f, -0.03790623f, 
    -0.01522060f, 0.04271981f, -0.03351237f, 0.02865714f, -0.09965372f, -0.21593870f, -0.01716834f, 0.12285190f, 
    -0.02965224f, 0.17502396f, -0.08790348f, -0.05310013f, 0.10899772f, 0.08144329f, -0.05721428f, 0.06674611f, 
    -0.00561683f, 0.31630602f, 0.08805092f, 0.05101689f, 0.08154584f, -0.04987374f, 0.07358026f, 0.20001097f, 
    0.04243743f, -0.03582220f, -0.02553198f, 0.02750254f, -0.04108229f, 0.10990348f, -0.08777539f, -0.00480513f, 
    -0.06807506f, 0.03722400f, -0.06748920f, 0.03856637f, 0.06051738f, -0.00639365f, 0.01629780f, -0.14771616f, 
    0.00977543f, -0.05996181f, 0.05274449f, 0.09859554f, -0.02372666f, 0.06466735f, 0.04540519f, 0.03457124f, 
    -0.02380909f, -0.04850885f, 0.08752657f, 0.04762812f, -0.00692023f, 0.25395283f, 0.01709030f, -0.02095163f, 
    0.00194819f, 0.08731398f, 0.10767640f, -0.04171767f, -0.05171207f, 0.02337229f, -0.00764316f, 0.04179062f, 
    -0.34313405f, -0.12227842f, -0.05294268f, -0.02631567f, 0.00195932f, 0.06656596f, -0.03926376f, -0.01117687f, 
    0.00441245f, -0.09242740f, -0.05543095f, -0.01070632f, -0.08244974f, 0.10023955f, 0.01157693f, 0.22906244f, 
    0.14101724f, -0.17540342f, 0.02853630f, 0.05562113f, -0.08276241f, -0.08614879f, 0.02056171f, 0.04312193f, 
    0.26404089f, 0.05565096f, 0.03419382f, -0.18833572f, -0.14583050f, -0.06019703f, 0.00155489f, -0.01469599f, 
    -0.01899927f, 0.05453097f, -0.09753187f, 0.01344517f, 0.19468170f, -0.19760792f, 0.06801882f, 0.20135529f, 
    -0.02652380f, 0.13436559f, 0.06302932f, 0.09303698f, -0.02313909f, 0.17883761f, 0.08959723f, 0.15865572f, 
    -0.19761881f, 0.02354576f, 0.16449803f, 0.08840505f, 0.08121970f, 0.10693005f, 0.02326174f, -0.05100191f, 
    0.04880498f, -0.02723611f, -0.05082101f, -0.05636770f, -0.12971108f, 0.15234020f, -0.07330231f, -0.05011449f, 
    0.02693297f, 0.00422337f, 0.10295495f, -0.00828996f, -0.09922166f, -0.02579372f, 0.12879850f, -0.02842062f, 
    0.10161523f, 0.03088976f, 0.11575329f, -0.14772609f, 0.05082814f, -0.04347685f, -0.02572751f, 0.15545183f, 
    -0.07663067f, 0.04639710f, -0.06691466f, -0.07582714f, -0.04760516f, -0.02165864f, 0.18797410f, 0.11582258f, 
    0.08204726f, -0.02182139f, 0.03529352f, -0.12642023f, 0.09777781f, -0.09957307f, -0.08282377f, 0.02451814f, 
    -0.20231366f, -0.07014705f, 0.05156963f, 0.23001303f, 0.00640772f, -0.04033357f, -0.01417303f, -0.10300250f, 
    -0.00409963f, 0.03591532f, 0.01975510f, -0.06473386f, 0.00337241f, -0.04627040f, 0.14929973f, 0.02229842f, 
    0.03401209f, 0.17004897f, -0.02565985f, 0.15515253f, 0.04229867f, -0.01529311f, 0.04120266f, -0.01924647f, 
    -0.22696219f, 0.03679182f, -0.02986591f, 0.04454905f, -0.00768950f, -0.09413135f, 0.05270932f, -0.00427003f, 
    0.04462362f, 0.06108901f, -0.16114202f, -0.00119720f, -0.20783542f, -0.05381098f, 0.04513041f, 0.05290087f, 
    0.07531681f, 0.12310813f, -0.06938424f, 0.06623241f, -0.01197591f, -0.02302348f, -0.04451235f, -0.05377393f, 
    0.08141571f, 0.33378845f, -0.00900593f, 0.11651680f, 0.11794921f, -0.07677951f, 0.01651606f, 0.10833554f, 
    0.00988401f, -0.07314301f, 0.03558397f, -0.02274629f, 0.03325033f, 0.05418000f, -0.09929404f, 0.13077204f, 
    -0.08692586f, 0.12020540f, 0.03344192f, -0.01729412f, 0.02068287f, -0.08293366f, 0.08906899f, 0.00251820f, 
    0.13302885f, -0.04909715f, 0.16961887f, 0.33337939f, -0.02593295f, 0.00462142f, 0.00598670f, -0.03789124f, 
    -0.04999999f, 0.02000211f, 0.00211039f, 0.09345114f, 0.04595340f, 0.12130176f, -0.17566673f, -0.04561766f, 
    0.11903692f, -0.10246320f, -0.06709120f, -0.08285723f, -0.09609850f, -0.12828401f, -0.01330743f, -0.06302164f, 
    -0.02352381f, -0.04536301f, -0.29731232f, -0.19674987f, 0.01244891f, 0.04888686f, -0.04670690f, -0.04807710f, 
    0.02250439f, -0.03954990f, 0.07489724f, -0.02751181f, 0.09453852f, 0.15493084f, 0.31506002f, 0.25392130f, 
    0.03922486f, -0.15207902f, 0.06747136f, 0.13262153f, -0.10753413f, 0.07899515f, 0.01266501f, -0.04168581f, 
    -0.23869036f, 0.02540354f, 0.01978388f, 0.02522262f, 0.05507540f, -0.14270708f, 0.02752911f, 0.02824817f, 
    -0.03393546f, 0.07743347f, -0.06045901f, 0.01256503f, 0.17645550f, -0.21397969f, -0.07729041f, -0.12777843f, 
    -0.30722865f, 0.09037687f, 0.13172504f, -0.07837948f, -0.03022092f, 0.15759185f, 0.15896858f, 0.18835700f, 
    -0.25173345f, -0.00417219f, -0.06805776f, -0.19667366f, 0.03951488f, 0.04334802f, -0.00295295f, -0.05583362f, 
    -0.10763916f, -0.03164658f, 0.11626881f, -0.02070839f, -0.07961651f, -0.09174722f, -0.05181381f, 0.17937821f, 
    0.04941658f, 0.03834238f, -0.06893050f, 0.01589892f, -0.10918500f, 0.03132470f, -0.04448191f, 0.04023401f, 
    0.24742559f, 0.16478291f, -0.00418383f, 0.08497375f, 0.11478411f, 0.06983721f, -0.17804776f, 0.13705955f, 
    -0.00757802f, -0.13060048f, -0.07791553f, -0.01253663f, 0.11502507f, -0.01532672f, -0.05807881f, -0.11449279f, 
    -0.16543238f, 0.24351108f, -0.18571469f, -0.04721715f, -0.11976362f, -0.07354947f, -0.03546708f, -0.01699409f, 
    0.03396387f, 0.16023487f, 0.11194158f, 0.08405522f, -0.03531613f, 0.01915774f, -0.09719876f, -0.19810650f, 
    -0.05634056f, -0.04492014f, 0.04444693f, -0.05907522f, 0.48655722f, 0.06092564f, 0.31435341f, 0.20522586f, 
    0.10065619f, 0.01365500f, 0.10534223f, 0.07303224f, -0.17950714f, -0.03970867f, 0.06290684f, -0.14701602f, 
    0.04592220f, -0.07959563f, 0.04360436f, 0.12254744f, 0.11125218f, -0.16032523f, 0.08368910f, 0.14393532f, 
    0.04455229f, 0.07333487f, -0.01822830f, -0.11088137f, -0.16215757f, 0.00181614f, -0.26861930f, 0.13958576f, 
    0.01275941f, 0.10243067f, -0.01346856f, 0.06573817f, -0.00036318f, -0.09416696f, 0.02196592f, 0.17134251f, 
    -0.23772424f, 0.08088725f, 0.12149908f, 0.11133502f, 0.12181351f, 0.02973545f, -0.12129343f, 0.12367421f, 
    0.00556997f, 0.03519770f, -0.01751571f, -0.16626258f, 0.38648897f, 0.06228404f, 0.13669223f, 0.59130800f, 
    -0.01134198f, 0.05531381f, -0.06313138f, -0.13259919f, -0.00714233f, -0.03421899f, 0.05204924f, 0.20303988f, 
    -0.05220660f, 0.18460472f, 0.13972050f, -0.00850316f, -0.02528843f, -0.07876485f, 0.17959122f, 0.06539888f, 
    0.11450806f, 0.01242158f, -0.02415282f, 0.08243280f, 0.22241652f, -0.31723118f, -0.00438733f, 0.20848350f, 
    0.13581824f, 0.04612269f, 0.09176882f, -0.06359540f, 0.10112523f, 0.05525715f, 0.08923492f, 0.01360760f, 
    -0.16872379f, -0.13371189f, -0.11159232f, -0.01838154f, -0.06659394f, -0.01932357f, 0.04540530f, -0.05840606f, 
    0.00455301f, 0.06789985f, 0.07564409f, -0.08302163f, 0.05956132f, 0.17907420f, 0.06448244f, -0.08639906f, 
    -0.00955461f, -0.01134636f, -0.00907609f, -0.13675977f, 0.06946438f, 0.12176880f, -0.02262955f, -0.01521772f, 
    0.06911226f, 0.15773049f, 0.00609615f, 0.10029282f, -0.04054556f, 0.08857092f, -0.03943150f, 0.00504293f, 
    0.07531295f, 0.13803089f, 0.03933845f, -0.03555243f, -0.13128513f, 0.17020223f, 0.02108044f, 0.02713570f, 
    0.14422734f, 0.03211505f, 0.06505521f, -0.07789609f, 0.09022348f, -0.08712293f, 0.05947056f, -0.02539566f, 
    0.08756116f, 0.01825243f, -0.30621037f, 0.22984624f, 0.06858072f, 0.08824694f, 0.10292212f, -0.01373386f, 
    -0.05802105f, -0.03845271f, 0.16497312f, 0.07916886f, -0.05347181f, -0.19970749f, 0.03980042f, -0.04765618f, 
    -0.07050273f, -0.00791931f, 0.12649724f, 0.08739882f, -0.10355289f, 0.04434673f, 0.16554332f, 0.06482161f, 
    0.16863604f, -0.04682299f, 0.08642928f, 0.13736463f, 0.02141627f, -0.04478492f, 0.01696100f, 0.08958288f, 
    0.09897753f, -0.01643664f, 0.07292914f, -0.04760827f, 0.07450397f, 0.13273714f, -0.10432421f, -0.00623961f, 
    -0.07426156f, -0.04997258f, 0.01607586f, -0.04693535f, -0.04997213f, 0.03063229f, 0.13626502f, 0.00934568f, 
    0.29116982f, 0.09745118f, 0.02950002f, 0.31298718f, 0.02712533f, 0.00842870f, 0.09879449f, -0.01542025f, 
    -0.00558545f, -0.01686473f, -0.12584341f, -0.12014927f, 0.09158286f, 0.01810712f, 0.04712209f, 0.05417226f, 
    -0.01804119f, -0.21755280f, -0.05922543f, -0.09945477f, -0.01416637f, -0.12286946f, 0.03569441f, -0.04570032f, 
    0.17875631f, -0.04108268f, -0.12287310f, -0.04366636f, -0.09118081f, 0.11228695f, 0.14381355f, 0.00997362f, 
    -0.12693287f, 0.00117681f, -0.02977448f, 0.05219110f, 0.17409666f, -0.20625404f, 0.07419077f, 0.17615120f, 
    -0.07801465f, -0.05379858f, 0.05381129f, -0.08908738f, 0.02460231f, 0.03366139f, -0.08213001f, -0.02411838f, 
    0.12066105f, 0.14024010f, 0.18455943f, 0.00015007f, -0.07153999f, -0.03870478f, 0.04490416f, 0.05496206f, 
    0.12779035f, -0.07532297f, -0.05590072f, -0.02685591f, 0.13186039f, 0.16238713f, 0.14457895f, 0.09203350f, 
    -0.04405820f, 0.08744707f, -0.02352230f, -0.08673490f, -0.12791543f, -0.05247725f, 0.05522798f, 0.02435979f, 
    0.05246711f, 0.00694128f, 0.02398680f, 0.20337567f, -0.16086377f, -0.04438902f, 0.05342663f, 0.05791971f, 
    0.11019076f, -0.07780398f, 0.02746524f, 0.09356498f, -0.27654216f, -0.07029362f, 0.16684720f, 0.07074579f, 
    0.30800405f, 0.05194259f, 0.02649438f, -0.09860429f, 0.15353210f, 0.05359920f, 0.17942330f, -0.08823510f, 
    -0.00070969f, 0.02118572f, -0.03589306f, 0.12720393f, 0.15088603f, 0.02553217f, -0.00453814f, -0.04678494f, 
    0.00877887f, -0.06572033f, -0.00033407f, -0.11091489f, 0.03621297f, 0.21387389f, 0.08220605f, 0.26162514f, 
    0.08065961f, 0.01012523f, -0.09060471f, 0.06753040f, -0.10364809f, -0.02260910f, 0.12673186f, 0.02043396f, 
    -0.00470066f, 0.02968768f, -0.01148032f, -0.07995271f, 0.05779261f, 0.03305271f, -0.14018098f, 0.15459011f, 
    0.03168633f, 0.04056321f, -0.11387817f, -0.14377838f, -0.24510032f, -0.14141254f, -0.05593993f, -0.09909200f, 
    0.22578932f, 0.13503364f, 0.02282728f, -0.07432587f, 0.00576424f, -0.13978638f, 0.15488231f, -0.05575050f, 
    0.33051643f, -0.02997014f, -0.06714190f, 0.02291192f, 0.17946248f, -0.08750543f, -0.19837591f, 0.03900320f, 
    -0.06217200f, -0.05829076f, 0.03906988f, 0.07061809f, -0.14358850f, 0.10799136f, -0.09606290f, -0.01026800f, 
    -0.11208132f, -0.14233433f, 0.05087966f, -0.01161391f, -0.01535673f, -0.07527301f, -0.01939568f, 0.07986308f, 
    0.29019734f, -0.12467505f, -0.05986932f, -0.31781390f, 0.03076516f, -0.01471362f, 0.03066145f, -0.17083988f, 
    0.06498794f, 0.02002069f, -0.06700632f, -0.00540631f, 0.33688086f, 0.03191498f, -0.29870614f, 0.13219412f, 
    -0.01113477f, 0.14242712f, -0.01826309f, -0.14339191f, 0.02550611f, 0.05137438f, -0.04068136f, -0.09086908f, 
    -0.04597741f, 0.04264335f, -0.02934872f, -0.18232676f, 0.04426337f, -0.15475452f, -0.03492635f, 0.00560031f, 
    0.08240025f, -0.16320524f, -0.04033336f, 0.02524170f, -0.00007232f, -0.06970249f, 0.10826052f, -0.22752258f, 
    0.02112182f, 0.01620217f, -0.06307667f, -0.05607639f, 0.02689141f, -0.16019163f, -0.04070530f, 0.05365418f, 
    0.00051339f, 0.22708406f, -0.00185839f, 0.29758400f, -0.14301381f, -0.07485331f, 0.08853179f, 0.16836149f, 
    0.03676064f, 0.04478133f, 0.07590050f, 0.01202836f, -0.25781038f, -0.09015729f, -0.28303760f, -0.07925561f, 
    -0.00366779f, 0.01526634f, 0.07709343f, -0.05070458f, 0.09802948f, 0.06401769f, -0.17708179f, -0.05153534f, 
    0.36315927f, 0.33902395f, -0.13819440f, 0.12187857f, -0.04168866f, -0.01546077f, 0.05504754f, 0.25973272f, 
    0.09265870f, 0.08893582f, 0.08159738f, 0.01709538f, -0.14794159f, -0.07390641f, -0.06446871f, -0.06081498f, 
    -0.02271038f, 0.01323073f, -0.04305979f, 0.06381371f, 0.06826290f, -0.14873759f, -0.02587724f, 0.06680532f, 
    -0.50233138f, 0.13514793f, 0.11564147f, 0.11895347f, 0.01804444f, -0.06541654f, 0.03202275f, -0.04161073f, 
    -0.03370106f, -0.00414309f, 0.01186821f, 0.13224900f, 0.19997373f, 0.00373436f, 0.03100019f, 0.18772531f, 
    -0.04858516f, -0.06692285f, 0.08985606f, 0.07669742f, 0.09943150f, 0.01254057f, -0.03965653f, -0.07441662f, 
    0.16244031f, 0.01027354f, -0.26313779f, -0.05682911f, -0.05894365f, -0.00676708f, -0.01918299f, 0.02672748f, 
    0.05488191f, -0.04619467f, 0.09805910f, -0.07968640f, 0.24343920f, -0.03475875f, -0.03495880f, -0.09094245f, 
    0.02245127f, -0.07090490f, 0.07964884f, 0.08568422f, 0.10912450f, 0.06440402f, -0.00531051f, -0.00993576f, 
    -0.20969167f, 0.03543209f, -0.03149626f, 0.14695583f, 0.01726642f, -0.06441647f, -0.05952494f, -0.10560608f, 
    0.03867463f, -0.01505749f, -0.05953088f, 0.14084080f, 0.12217877f, -0.04822531f, 0.08226430f, -0.23603626f, 
    -0.00379378f, -0.03008108f, -0.02940490f, 0.02488123f, 0.14996618f, -0.00190802f, 0.14510499f, -0.01210962f, 
    -0.29415983f, -0.02333483f, -0.17527436f, 0.22449374f, -0.02914461f, -0.06638034f, 0.04186412f, 0.14976373f, 
    0.07485495f, 0.06807994f, 0.07262947f, 0.04239283f, -0.05699213f, 0.02324433f, -0.12935013f, 0.06753954f, 
    0.05209928f, -0.01141257f, 0.06997071f, -0.13550317f, 0.01551262f, 0.13643447f, 0.02412522f, -0.02089176f, 
    -0.01907881f, -0.08431860f, -0.07057732f, 0.03841552f, -0.01025774f, -0.00351459f, 0.08364494f, -0.12689534f, 
    0.11110836f, -0.00000850f, 0.09083987f, 0.12649953f, 0.03194757f, -0.03629614f, 0.08881743f, 0.05924731f, 
    -0.08015034f, 0.01174385f, -0.03738429f, -0.06060584f, -0.00028581f, -0.11259703f, 0.05957238f, -0.04206222f, 
    0.15173364f, 0.01681017f, 0.08513012f, 0.10017929f, 0.06723853f, -0.04284926f, -0.05327274f, -0.11173722f, 
    0.17760791f, -0.10851203f, 0.00677886f, -0.07084732f, 0.19479746f, -0.04751131f, 0.10508288f, 0.02339554f, 
    -0.04576832f, -0.01430629f, 0.09843701f, -0.01040459f, 0.11026422f, 0.00198470f, -0.05831565f, -0.17923778f, 
    0.02042276f, 0.04023808f, 0.00583318f, 0.09407286f, -0.01640069f, -0.07538790f, 0.11676197f, -0.07865230f, 
    0.00215349f, 0.12354178f, 0.04179086f, 0.04489192f, -0.01869861f, -0.05267752f, -0.01327399f, 0.05811549f, 
    -0.04754618f, -0.07215843f, -0.01436217f, -0.03552378f, 0.06912287f, 0.07876785f, -0.02058616f, 0.10320537f, 
    0.12102583f, 0.00197439f, 0.04552849f, 0.00280469f, 0.03816464f, 0.03222303f, 0.02599023f, 0.01642253f, 
    0.04905801f, -0.03472269f, 0.03270319f, 0.06542014f, 0.09722953f, 0.07785432f, 0.13744195f, 0.14237884f, 
    -0.00344906f, -0.14460483f, 0.08552097f, -0.00719015f, -0.05572643f, -0.15454166f, 0.10263748f, 0.03630712f, 
    -0.12452308f, -0.13860045f, -0.18854620f, -0.16853786f, 0.15194057f, 0.07532948f, -0.07015500f, 0.12311247f, 
    0.04370164f, -0.02925977f, -0.05459503f, -0.13350855f, -0.07536130f, 0.25541323f, 0.06970906f, 0.07413112f, 
    0.01605212f, -0.00147182f, -0.07697153f, -0.06515912f, -0.05877661f, 0.10301584f, 0.01790370f, 0.01965857f, 
    0.11798289f, 0.23454224f, 0.36516735f, 0.14934354f, 0.08320963f, 0.09815946f, 0.11243954f, -0.08194306f, 
    -0.10894080f, -0.07107217f, -0.19135898f, 0.14832790f, -0.48946297f, -0.24873827f, 0.01246073f, 0.00523000f, 
    0.08291931f, 0.08322645f, -0.14817967f, -0.00843079f, 0.00375668f, -0.01128715f, -0.01287580f, 0.05534453f, 
    -0.03715004f, 0.07468753f, 0.00741999f, -0.07175916f, -0.12726793f, -0.10313427f, -0.05050715f, -0.04726933f, 
    -0.04572884f, -0.10493152f, 0.04234411f, -0.03142644f, 0.01847233f, 0.09417916f, -0.06771269f, 0.11733403f, 
    0.04948151f, -0.12952776f, -0.14486231f, -0.05955645f, 0.03244119f, 0.04456604f, -0.02644739f, 0.04990966f, 
    0.21638934f, 0.04415632f, 0.32741836f, -0.05352718f, 0.02251959f, 0.05479734f, 0.05203025f, -0.09817980f, 
    0.20700316f, 0.04350506f, 0.06615204f, 0.06160853f, 0.05953435f, 0.18156031f, 0.13727811f, 0.05115869f, 
    0.00994499f, 0.09446219f, 0.00328926f, 0.06934505f, 0.04292699f, 0.03924320f, -0.07813238f, 0.08007567f, 
    -0.09936234f, -0.09019595f, -0.18712968f, 0.07313938f, -0.04076834f, 0.03180777f, 0.08804392f, -0.10438888f, 
    -0.03047686f, -0.01913930f, 0.00584078f, 0.07075444f, 0.22252409f, -0.12124051f, 0.08693786f, 0.09783147f, 
    -0.02501572f, 0.02841953f, -0.00258549f, 0.01776600f, -0.03226207f, -0.02408732f, 0.09375357f, -0.01048241f, 
    0.12115121f, 0.02238288f, -0.02686914f, -0.00436433f, -0.07161387f, -0.14650597f, -0.00644596f, 0.12964553f, 
    0.02481150f, 0.03489459f, -0.06678850f, 0.00137695f, -0.18395416f, -0.06847603f, -0.34703159f, -0.12678637f, 
    0.03254697f, 0.11283199f, -0.00547270f, -0.01493437f, 0.02441202f, -0.04831959f, 0.01788102f, 0.16387017f, 
    -0.04034651f, -0.05809741f, -0.11508888f, -0.20793314f, 0.09848738f, 0.00025612f, -0.09299392f, -0.01381323f, 
    0.03024339f, -0.10675208f, 0.12998416f, -0.03751770f, 0.27981988f, 0.00186470f, 0.12526220f, 0.10663554f, 
    -0.04113961f, 0.16981667f, 0.07300841f, 0.07601532f, 0.08989538f, 0.02929378f, 0.00403170f, -0.11310577f, 
    -0.43908149f, -0.30127892f, -0.11803781f, -0.08964025f, -0.05122132f, -0.01170231f, -0.08781961f, -0.02533075f, 
    0.07055692f, -0.07085204f, 0.06529474f, -0.11297862f, -0.30604509f, -0.24657856f, -0.01634838f, -0.17866348f, 
    0.21503609f, -0.01758852f, -0.03532115f, 0.06074823f, 0.05909432f, 0.08704213f, -0.09228604f, 0.06803844f, 
    -0.02194352f, -0.10502926f, -0.21427344f, 0.00300803f, -0.13702822f, 0.06267162f, -0.04673531f, 0.08292045f, 
    0.00338817f, -0.00254377f, -0.00031659f, 0.10321865f, 0.12289617f, -0.01473194f, 0.16457826f, -0.05568216f, 
    0.02378581f, -0.11772769f, 0.11594197f, 0.05378270f, -0.09548433f, -0.09257770f, -0.10212993f, 0.02587429f, 
    -0.16186483f, 0.15197621f, 0.06611296f, 0.14116146f, -0.00012018f, 0.03674407f, -0.02397497f, 0.11781240f, 
    0.02831200f, 0.05842672f, 0.07502393f, 0.03733729f, 0.10455783f, -0.07230522f, 0.00301480f, 0.06461656f, 
    0.07092728f, -0.12207836f, 0.03877351f, 0.07307730f, -0.08908769f, 0.02097848f, 0.05450017f, 0.02622849f, 
    0.00991622f, 0.01992704f, -0.14106576f, 0.14218201f, 0.00478298f, 0.08267787f, 0.02059748f, -0.01929574f, 
    0.05180878f, -0.01951484f, -0.06382174f, 0.06742918f, 0.20911516f, -0.11032838f, -0.09184468f, -0.19645262f, 
    -0.07399658f, 0.08396881f, 0.16326155f, 0.04779309f, 0.01902098f, 0.03920472f, -0.04243040f, 0.07499140f, 
    -0.04079965f, 0.13851821f, 0.11999390f, 0.14581932f, -0.01110393f, 0.12172629f, 0.01979153f, -0.11186688f, 
    -0.00498974f, -0.07642131f, -0.03814766f, -0.10584813f, -0.18102929f, -0.04605148f, 0.06586453f, -0.10155754f, 
    0.01370232f, 0.00337255f, -0.02393951f, 0.04573504f, -0.08639722f, -0.04313566f, 0.14498997f, 0.13437007f, 
    -0.01539098f, 0.08149177f, -0.06539339f, -0.13082634f, 0.08373871f, -0.06323082f, -0.07726206f, 0.14586596f, 
    0.12443551f, -0.03047169f, -0.05712099f, 0.04952861f, -0.40876386f, 0.21465753f, 0.08097807f, -0.11312584f, 
    0.03817064f, 0.09044372f, -0.06529017f, -0.13502097f, 0.02341822f, -0.04071759f, -0.11665413f, -0.01133187f, 
    -0.23395011f, 0.13062112f, 0.10363626f, 0.10207839f, -0.05714824f, 0.07884640f, -0.08094770f, -0.04920457f, 
    -0.00569541f, 0.02136814f, 0.10794152f, -0.04104871f, -0.04049573f, -0.11553564f, 0.19043565f, 0.15318605f, 
    0.06765372f, 0.02345558f, 0.13079552f, 0.13932863f, -0.04220618f, 0.07558113f, 0.03896670f, -0.02359960f, 
    -0.02529528f, -0.12018418f, 0.14311203f, 0.00972637f, 0.09182039f, 0.01207225f, 0.08464167f, 0.09904749f, 
    0.03896255f, -0.06097780f, 0.00429223f, -0.03489976f, -0.19235513f, 0.11184940f, 0.25459948f, -0.24508587f, 
    0.11695310f, 0.07428459f, -0.05455547f, 0.17872053f, -0.06618518f, -0.08733010f, 0.02578770f, -0.01031241f, 
    0.31685150f, 0.13924813f, 0.00966298f, 0.02452991f, 0.09824293f, 0.02210954f, -0.05143038f, 0.01802919f, 
    -0.04492774f, 0.00110897f, 0.00224594f, -0.08054213f, -0.11866452f, -0.19510479f, -0.13040766f, 0.14801411f, 
    0.03973003f, 0.01421226f, 0.12822656f, 0.04999331f, 0.06737132f, 0.07364912f, 0.05850706f, 0.14132123f, 
    -0.45746627f, 0.16739233f, -0.11504269f, -0.20861836f, 0.09074420f, 0.05442095f, 0.15510164f, -0.04885094f, 
    -0.04254583f, -0.03491551f, 0.05585759f, 0.13402118f, 0.20286477f, 0.13330467f, -0.02591503f, -0.03110895f, 
    -0.15072998f, 0.05915581f, 0.13116819f, 0.00101532f, 0.09240641f, 0.01277932f, -0.02193363f, 0.02612589f, 
    -0.01849899f, 0.15294451f, 0.18950026f, -0.05450567f, -0.16642080f, 0.05053245f, 0.04941709f, 0.12973508f, 
    -0.02525681f, 0.03489703f, 0.03037419f, -0.05283153f, 0.07071229f, -0.20633578f, -0.13588704f, 0.08994754f, 
    0.11579434f, -0.03905181f, -0.05459043f, 0.05140159f, -0.03408504f, 0.02502548f, -0.02674951f, 0.09489317f, 
    0.09833857f, 0.10210664f, 0.02960366f, -0.14017266f, -0.04253077f, 0.01979260f, -0.04979016f, -0.10352328f, 
    -0.04049276f, 0.02350580f, 0.11031632f, 0.04861027f, 0.20275097f, 0.13356894f, 0.17684837f, 0.25554642f, 
    -0.14287820f, 0.03024012f, 0.20139356f, 0.02283431f, -0.03463465f, 0.04607114f, -0.05303448f, 0.09312290f, 
    0.15506969f, 0.19620404f, 0.20959482f, -0.04269430f, 0.02477260f, -0.05031966f, 0.06955965f, 0.00350670f, 
    0.12817717f, 0.09054586f, -0.08227482f, -0.07365122f, -0.27647078f, -0.13289873f, 0.04258959f, -0.06294906f, 
    -0.02552402f, -0.04685390f, -0.04583154f, 0.05129797f, 0.09942680f, -0.02382552f, 0.11885277f, 0.07974024f, 
    -0.11965956f, -0.13449286f, 0.29720515f, -0.15330255f, 0.12989259f, 0.04139772f, -0.04054675f, 0.05216227f, 
    0.02662678f, -0.04662238f, -0.03009954f, -0.02394354f, -0.18787429f, -0.00717324f, 0.19156672f, 0.26289946f, 
    0.03010814f, -0.11604708f, -0.01897703f, 0.04676123f, -0.01005838f, 0.06254604f, -0.15060230f, -0.09434660f, 
    -0.09428108f, -0.13439853f, 0.08044368f, 0.05974946f, -0.00470832f, 0.00028975f, -0.02183596f, -0.09262722f, 
    -0.06984529f, -0.02972842f, -0.04104687f, 0.10779950f, -0.26639283f, -0.15671770f, 0.05293452f, 0.13467294f, 
    0.15522958f, 0.01833336f, 0.06359189f, 0.00660262f, -0.03942735f, 0.05536957f, -0.01837078f, 0.05325566f, 
    -0.22035766f, -0.05262903f, -0.04536013f, 0.03825228f, -0.04391916f, -0.04670200f, 0.01871966f, -0.02081424f, 
    0.09248197f, 0.01918174f, 0.05520637f, 0.00902380f, 0.11197130f, 0.05306874f, 0.27342287f, 0.02755605f, 
    -0.09214161f, 0.10615782f, -0.05003197f, 0.04050839f, -0.11398391f, -0.11653577f, 0.08260757f, 0.00845039f, 
    0.26225710f, -0.08331183f, -0.15342639f, 0.10046530f, 0.04164016f, 0.08368593f, 0.04473758f, -0.03655081f, 
    -0.07060938f, -0.01346772f, -0.04855253f, 0.08690412f, 0.00913282f, 0.00915634f, -0.08893740f, -0.05375222f, 
    0.01563293f, 0.04874427f, -0.04543000f, -0.05490891f, -0.00574845f, 0.00907540f, 0.13858113f, -0.00477058f, 
    0.59350163f, -0.37960634f, -0.22206640f, 0.06428595f, -0.09024754f, 0.04784371f, -0.22013740f, 0.02085092f, 
    0.08815195f, 0.06097286f, -0.05846191f, -0.04499386f, -0.20522049f, 0.28582588f, 0.14764732f, -0.04829374f, 
    0.12945257f, 0.11009157f, 0.13211575f, -0.03331381f, -0.07967313f, 0.18553342f, -0.02975143f, -0.05194145f, 
    0.12361621f, 0.29153669f, 0.22946745f, -0.16310544f, 0.11547168f, 0.16994116f, 0.25190514f, -0.03510580f, 
    0.09651850f, 0.06692467f, -0.01072514f, 0.12269375f, -0.38637477f, -0.23455103f, -0.01057819f, -0.12083855f, 
    -0.17660160f, -0.02724642f, -0.13930887f, 0.12575115f, 0.22127283f, -0.08320573f, -0.10557741f, -0.06912696f, 
    0.14041881f, 0.06254199f, -0.20401005f, -0.11790489f, 0.04264446f, -0.00482097f, -0.00320302f, 0.12253678f, 
    0.12680323f, 0.19181888f, 0.09772678f, 0.04762740f, -0.21722876f, -0.01057885f, 0.03021681f, -0.11464691f, 
    0.13393782f, -0.03217262f, -0.01943659f, 0.06381478f, 0.13640969f, -0.00407974f, 0.18413205f, 0.08560009f, 
    0.21231620f, -0.01826144f, 0.01748225f, -0.05489647f, 0.02626065f, 0.00810317f, 0.06899772f, -0.00838353f, 
    0.04942188f, 0.02796018f, 0.02076960f, 0.05101337f, 0.04622390f, 0.03481543f, 0.07195847f, 0.07613739f, 
    -0.01038951f, 0.10151105f, -0.04396058f, 0.18755326f, 0.10442728f, -0.14154908f, -0.10757848f, 0.03244551f, 
    -0.01600696f, 0.10252783f, -0.12708831f, 0.35148224f, -0.12344771f, -0.04332117f, -0.07812448f, -0.08527623f, 
    -0.02697386f, 0.05169409f, 0.04259510f, -0.04035819f, 0.41458130f, 0.04826824f, -0.00233777f, -0.12789902f, 
    0.17808041f, 0.05109987f, 0.05358022f, 0.00360614f, -0.04592980f, -0.01587808f, 0.09019782f, 0.03360163f, 
    -0.14868200f, 0.02509110f, 0.01081069f, -0.00714485f, -0.09932319f, -0.10916986f, 0.06365541f, 0.11784933f, 
    -0.02779615f, 0.16703980f, -0.05275951f, 0.03793021f, -0.22630721f, -0.21699367f, -0.07685079f, -0.07669234f, 
    -0.13059090f, -0.03251550f, 0.03833581f, -0.00003357f, -0.01016723f, -0.03534305f, -0.01748499f, -0.02629450f, 
    0.04607261f, -0.24203394f, -0.01680106f, -0.25987041f, 0.05341542f, 0.04399693f, -0.06677679f, 0.13630885f, 
    0.11437432f, -0.11574113f, 0.04379642f, -0.05054079f, -0.10849246f, 0.15362346f, -0.08508327f, 0.05927952f, 
    0.15307634f, 0.01545977f, 0.13653322f, 0.01980044f, 0.11147282f, 0.02658368f, 0.02631719f, 0.00580499f, 
    -0.46299365f, -0.11210873f, -0.09393805f, -0.18795730f, -0.07422531f, -0.11659741f, 0.00351682f, -0.05196432f, 
    0.02569189f, -0.01036243f, -0.11262827f, -0.04457813f, -0.27494699f, -0.17499867f, -0.18282066f, 0.02317758f, 
    -0.03133943f, 0.04026428f, -0.19744527f, 0.11711759f, 0.00766698f, 0.06341045f, -0.18283708f, 0.18122342f, 
    0.01723043f, -0.13652906f, 0.02377043f, 0.09550533f, -0.02451516f, -0.01125714f, -0.07056150f, -0.01038683f, 
    0.08112552f, 0.16674227f, -0.18325540f, -0.15547429f, -0.03504204f, -0.00279617f, -0.19730504f, 0.17533083f, 
    0.19329463f, -0.02961058f, -0.00644212f, -0.06903313f, 0.04303098f, -0.07946421f, 0.14062282f, 0.02409290f, 
    -0.10276864f, -0.27986726f, -0.21650577f, -0.07311154f, 0.13585466f, 0.06915419f, -0.06737118f, -0.13523526f, 
    0.01234617f, 0.03016189f, 0.13097030f, -0.00731641f, -0.13130613f, 0.13657403f, 0.03748147f, -0.32793298f, 
    -0.29326719f, 0.02128826f, 0.00417864f, -0.05831631f, 0.07371877f, -0.04429395f, 0.02872932f, -0.00963749f, 
    -0.17048284f, -0.07304506f, 0.11342432f, 0.12387288f, -0.00969429f, -0.02463417f, -0.02999542f, 0.14640671f, 
    0.09061018f, 0.07794889f, -0.07303642f, -0.09401996f, -0.12087335f, 0.07069411f, -0.22674580f, 0.05241211f, 
    0.19678885f, -0.09400777f, -0.29272085f, 0.10901675f, 0.05120240f, 0.01665577f, 0.11001711f, 0.09330086f, 
    -0.40520638f, 0.01512416f, -0.22502913f, 0.21180737f, -0.02299065f, -0.01267465f, -0.07174635f, 0.09649690f, 
    -0.12719518f, 0.09814158f, 0.04556859f, 0.04039509f, 0.20931628f, 0.16433887f, -0.14308788f, 0.11301252f, 
    0.05765858f, 0.06124619f, 0.17913947f, 0.14330746f, -0.05211689f, 0.12956646f, 0.11103367f, 0.09444376f, 
    0.19713290f, 0.01782117f, 0.01017715f, -0.03593307f, -0.05670154f, 0.00596534f, 0.05336513f, -0.05298300f, 
    -0.02045157f, 0.09652105f, 0.14486073f, 0.06076809f, -0.08540142f, 0.15311404f, -0.00267099f, -0.00374471f, 
    0.05020358f, 0.08317227f, 0.06444423f, 0.05067777f, -0.07538337f, 0.08771601f, 0.23356549f, 0.09855577f, 
    0.21072415f, 0.19500871f, 0.01888840f, 0.06621693f, 0.10348070f, 0.02948414f, -0.00317669f, 0.05850136f, 
    0.08340856f, 0.15318313f, -0.09070837f, -0.07613449f, -0.05480540f, 0.13953783f, 0.03831246f, -0.11969502f, 
    0.00376555f, -0.00643978f, -0.18427166f, -0.02879244f, 0.10015729f, -0.00609179f, 0.11127941f, 0.15210409f, 
    0.07288466f, 0.14993970f, -0.17604788f, 0.06018949f, -0.11958921f, 0.04962022f, -0.13938235f, 0.01377746f, 
    0.13676211f, 0.02336278f, 0.00439059f, 0.09874602f, -0.00587580f, -0.12922554f, -0.02318157f, 0.08189401f, 
    0.18016057f, 0.06929218f, -0.03949802f, 0.06771151f, 0.17742267f, -0.09994934f, -0.08929462f, -0.05404618f, 
    -0.14698520f, 0.01778899f, -0.05742321f, -0.13432524f, -0.07825913f, -0.04835158f, 0.00932501f, 0.01211333f, 
    0.14029323f, -0.09987629f, 0.07834988f, 0.06052618f, 0.05508327f, 0.00300423f, 0.11440627f, 0.20634501f, 
    -0.09271479f, -0.14173993f, 0.05255907f, 0.01267046f, -0.02800849f, -0.01328283f, -0.02569827f, -0.01283751f, 
    -0.06095442f, 0.04890834f, 0.01057201f, -0.06755607f, 0.02798375f, 0.02014514f, -0.01401440f, -0.04082875f, 
    0.00322474f, -0.05083833f, 0.01457024f, 0.06517980f, 0.06285880f, 0.05798100f, -0.06656921f, -0.05439479f, 
    0.03931654f, -0.07910635f, -0.02991087f, -0.03200212f, 0.05835282f, 0.05063219f, -0.01394279f, -0.03043585f, 
    -0.07310506f, -0.01414372f, -0.04434514f, -0.04497017f, 0.03994708f, -0.03203274f, 0.00991300f, -0.04105763f, 
    -0.05507836f, 0.05529506f, -0.04032668f, 0.05143449f, -0.01230412f, -0.04954309f, 0.01802507f, 0.04953751f, 
    -0.07162148f, -0.06070568f, 0.05146081f, 0.06084784f, -0.05523363f, -0.03619920f, -0.03936164f, -0.02805869f, 
    -0.05784231f, -0.08013806f, 0.04477509f, 0.01435221f, 0.05921919f, -0.06723475f, 0.00237314f, 0.05393491f, 
    -0.00965603f, -0.02430065f, -0.01487575f, 0.02494669f, 0.03706899f, -0.02341248f, 0.01875333f, -0.06215558f, 
    0.01555770f, -0.06243845f, 0.01583769f, -0.03414031f, -0.00764243f, -0.00329062f, 0.00953545f, 0.06425145f, 
    -0.05765104f, -0.05541868f, -0.07349649f, -0.02745249f, 0.01396526f, 0.05493696f, -0.07013178f, -0.05822639f, 
    -0.03667182f, -0.03899501f, -0.05357964f, 0.04359778f, 0.03634572f, 0.02903800f, -0.02349391f, -0.00053385f, 
    -0.06265704f, 0.00487381f, -0.03156968f, -0.04370715f, 0.04956667f, 0.05807042f, -0.06066972f, -0.07583316f, 
    0.02937501f, 0.04213172f, -0.03233940f, 0.03635248f, -0.00727955f, -0.04744006f, -0.03889696f, -0.02353436f, 
    0.01598860f, -0.05498381f, -0.03673657f, -0.00221601f, -0.01397616f, -0.07004929f, 0.03219338f, 0.06412028f, 
    0.01704170f, 0.05086860f, -0.05234082f, -0.00486167f, -0.04162675f, -0.05491799f, -0.05692574f, -0.02718767f, 
    0.04223760f, -0.03764310f, -0.03780434f, -0.02914591f, -0.01031598f, -0.03240934f, 0.00603754f, 0.05023123f, 
    -0.07937226f, -0.06847420f, -0.08024696f, -0.00416295f, 0.05761018f, -0.04003415f, 0.05108313f, -0.01142752f, 
    -0.02882965f, 0.05446705f, -0.05731989f, -0.00026383f, 0.01568223f, 0.03570191f, 0.03694715f, -0.02317465f, 
    0.02003757f, 0.04031555f, 0.05138106f, -0.03169890f, 0.02217508f, -0.06349319f, -0.05645313f, -0.04764473f, 
    -0.06862080f, -0.02044633f, -0.03526866f, 0.01319104f, -0.03688117f, 0.04826687f, -0.06476332f, -0.03284646f, 
    0.00204558f, -0.04750965f, -0.03809906f, -0.04822491f, -0.00439132f, -0.02380310f, -0.07594648f, 0.03739400f, 
    0.03770872f, 0.05139983f, -0.06418036f, -0.01803005f, -0.02121490f, -0.03921987f, 0.01735644f, -0.05870561f, 
    -0.01504604f, -0.04729956f, 0.05389446f, -0.01986018f, 0.01388571f, -0.00620368f, -0.00264395f, -0.03983041f, 
    -0.01546477f, -0.00528906f, 0.00715243f, -0.03651140f, -0.02042061f, -0.03850612f, -0.01014050f, 0.05601972f, 
    -0.14842451f, 0.24475032f, -0.02810235f, 0.02159234f, 0.13276990f, 0.03481830f, -0.07234471f, -0.05723506f, 
    0.02825602f, 0.00568787f, -0.00597220f, -0.05157181f, 0.21204206f, 0.29295865f, -0.03251787f, 0.03103555f, 
    0.09458521f, 0.12504998f, 0.08215214f, -0.02262739f, -0.08357004f, 0.10940541f, 0.06368586f, -0.00787442f, 
    0.34937879f, 0.11988446f, -0.14541966f, -0.08545119f, -0.01883878f, 0.01887532f, 0.08720706f, -0.06088721f, 
    -0.10915740f, -0.03186154f, 0.07419772f, -0.22254534f, 0.15086327f, -0.11728684f, 0.09573216f, 0.04902864f, 
    0.07640801f, 0.02217906f, -0.03352488f, -0.03899919f, 0.10409235f, -0.00141254f, -0.17846353f, 0.03644978f, 
    -0.08786740f, 0.13407740f, -0.05579523f, 0.07225391f, 0.04791152f, 0.02247464f, 0.03326572f, -0.16402753f, 
    0.18092307f, -0.02917911f, 0.09114958f, -0.04353647f, -0.00455393f, -0.04767987f, 0.09263445f, 0.00233204f, 
    0.06888001f, -0.10536586f, 0.06307565f, -0.07209957f, 0.07339496f, 0.01853806f, 0.00714315f, 0.03229668f, 
    0.22235164f, -0.27655941f, -0.22217339f, -0.04977995f, 0.05577783f, -0.07434957f, 0.03918312f, -0.01713523f, 
    0.01553415f, 0.09651128f, 0.14790408f, 0.11840057f, -0.00007643f, 0.12376843f, 0.00861061f, -0.08465423f, 
    -0.08521268f, -0.18619795f, 0.01792008f, -0.00404692f, -0.04070033f, 0.08339161f, 0.07792097f, -0.13192986f, 
    -0.19501236f, -0.06501298f, 0.13598244f, 0.18508470f, -0.08377211f, -0.07189216f, 0.02829312f, -0.04580010f, 
    0.02667569f, -0.02207576f, 0.03856130f, 0.06247560f, 0.70155573f, -0.24326749f, -0.22154213f, 0.08638151f, 
    0.01896230f, 0.03756630f, 0.02187951f, -0.08056110f, -0.10885822f, 0.00971420f, -0.02213578f, -0.01488359f, 
    0.15515627f, -0.10746187f, -0.07864435f, -0.08194665f, 0.00750498f, 0.00216823f, 0.03719220f, -0.08404964f, 
    -0.03136967f, -0.01838669f, -0.09632511f, -0.01988741f, -0.17560522f, -0.19966991f, -0.00200189f, -0.02579674f, 
    0.04021706f, -0.11531466f, -0.07107598f, 0.03517268f, 0.12802996f, 0.00929602f, -0.07738642f, -0.08712450f, 
    0.27219763f, 0.17184038f, -0.06179785f, -0.08240785f, -0.14396413f, 0.06082152f, -0.02575065f, -0.03403222f, 
    -0.06412624f, 0.02380176f, 0.01067042f, 0.01663749f, 0.30231491f, 0.04819511f, -0.18596718f, 0.11959679f, 
    -0.08951196f, -0.01248956f, 0.13333598f, 0.05742573f, -0.08325922f, 0.04367922f, -0.00217115f, -0.08661542f, 
    0.12511040f, -0.15331189f, 0.27433720f, 0.08576203f, -0.01001938f, 0.13089335f, -0.01845741f, 0.02864013f, 
    0.05399214f, -0.10061321f, 0.11775853f, 0.05539607f, -0.08001345f, 0.05090822f, 0.23862323f, 0.06019866f, 
    0.00331873f, 0.11928709f, -0.09259909f, -0.11141772f, 0.05237392f, -0.05331172f, -0.10525443f, 0.00121423f, 
    0.24867064f, -0.04548283f, 0.16715030f, 0.00088176f, -0.01487757f, 0.11307362f, -0.03019108f, 0.00249258f, 
    -0.01673525f, 0.04870676f, -0.05220776f, -0.11521639f, 0.13231336f, 0.15784097f, 0.06362718f, -0.06774535f, 
    -0.06665948f, 0.00497763f, -0.01043588f, -0.05019833f, -0.01109414f, -0.05545111f, 0.01184011f, -0.03380965f, 
    0.07470039f, 0.00141680f, 0.07363188f, 0.29006004f, -0.08897174f, 0.03931227f, -0.02324421f, 0.06828282f, 
    0.02515947f, -0.00709580f, 0.08142148f, 0.05893309f, -0.16653843f, -0.02082246f, 0.05648898f, -0.16965605f, 
    -0.08544840f, -0.02532090f, 0.07876635f, 0.18187708f, 0.03874940f, -0.06516308f, 0.04682847f, 0.11019015f, 
    0.08753327f, -0.06634028f, 0.14713420f, 0.01785060f, -0.02739863f, -0.04926819f, 0.14244491f, -0.00945208f, 
    -0.02785270f, -0.12119941f, 0.05402711f, 0.05312030f, 0.11593843f, -0.00618910f, -0.07487060f, -0.06559602f, 
    -0.02588781f, -0.08620552f, 0.01063274f, 0.17542280f, -0.04579905f, 0.20453151f, -0.17034909f, 0.07274715f, 
    -0.17633219f, -0.14384414f, 0.30082408f, 0.12432158f, 0.01385844f, 0.05383310f, 0.01899907f, 0.00838988f, 
    0.06405015f, -0.03868778f, -0.07824516f, -0.11918753f, 0.19230670f, 0.15718848f, -0.05225893f, 0.05314785f, 
    0.04782311f, 0.07608525f, -0.06788243f, -0.08675876f, -0.04644315f, 0.00699214f, -0.03566850f, 0.04554736f, 
    -0.11321104f, 0.10870831f, 0.10224602f, 0.03865490f, 0.03091694f, -0.11768238f, -0.02427778f, 0.00427292f, 
    -0.07827322f, 0.01139713f, -0.07180003f, 0.04016661f, -0.04730066f, 0.05165034f, 0.02257887f, -0.16076666f, 
    0.10631558f, -0.03918684f, -0.01461497f, 0.05541098f, 0.01091228f, -0.01134400f, 0.06231061f, 0.12654877f, 
    -0.17694405f, 0.01615104f, -0.13020450f, -0.19128914f, 0.03405074f, 0.11171674f, 0.06791348f, 0.13820019f, 
    -0.07342819f, 0.01374952f, -0.01981069f, -0.03202124f, -0.14421579f, 0.00091252f, 0.00398077f, 0.08185311f, 
    -0.01533475f, 0.14068581f, 0.02127245f, 0.11580444f, 0.01542733f, 0.07757993f, -0.03137445f, 0.10229287f, 
    0.01058661f, 0.02904037f, 0.15803277f, -0.08379576f, 0.21861109f, 0.07481243f, -0.26989082f, -0.02023860f, 
    -0.03086686f, 0.06255429f, 0.09135254f, 0.11802255f, 0.11288832f, -0.02741292f, -0.00384412f, -0.01533485f, 
    -0.05501555f, -0.05611274f, -0.13225512f, 0.08301317f, -0.12555288f, -0.06571941f, -0.02529655f, -0.09702495f, 
    -0.08471611f, -0.00605404f, 0.10815983f, -0.10849343f, 0.04516968f, 0.04084928f, 0.00960921f, 0.02131987f, 
    0.09213295f, -0.05555494f, 0.12091598f, -0.00354588f, -0.04997727f, 0.00198601f, -0.02816595f, -0.12900643f, 
    0.01340054f, 0.00262102f, 0.05520392f, 0.00032115f, -0.02437131f, 0.11303325f, -0.03328979f, 0.01496920f, 
    0.65333641f, -0.07311419f, 0.26278019f, 0.14753805f, -0.11974560f, 0.05618976f, -0.09944468f, 0.03570380f, 
    0.02388750f, -0.00260177f, -0.13628554f, 0.08213098f, -0.15135953f, -0.16688871f, 0.19930464f, -0.12507415f, 
    0.01430367f, -0.08137675f, -0.04981931f, -0.02940348f, -0.02765191f, -0.07404668f, -0.05601730f, -0.03182310f, 
    0.13845140f, 0.12622702f, 0.03937825f, 0.19272433f, -0.00483287f, -0.04152666f, 0.08331499f, 0.05693263f, 
    -0.09733181f, 0.04945205f, 0.06559102f, 0.02188396f, -0.07454350f, 0.24332651f, -0.00727454f, 0.04370037f, 
    -0.06325288f, 0.05097198f, 0.10475058f, 0.17484234f, 0.07770732f, 0.13458700f, -0.05882194f, 0.02717661f, 
    0.27260128f, -0.12150086f, -0.00014264f, 0.10203855f, -0.11951908f, 0.07496353f, 0.04590768f, 0.00647059f, 
    -0.01644971f, 0.04305504f, 0.09501600f, 0.01083429f, -0.15363479f, 0.05910731f, -0.07263276f, -0.25462466f, 
    0.15430737f, 0.08383086f, -0.00059936f, -0.07992138f, 0.01547234f, -0.03831901f, -0.09679668f, -0.01281988f, 
    0.41318834f, -0.14009947f, 0.07967975f, 0.00587586f, -0.06591491f, -0.00189430f, 0.01674644f, -0.10150639f, 
    -0.09638005f, -0.14819916f, 0.03550207f, -0.12617943f, 0.28321433f, -0.12267568f, 0.20271431f, 0.04527866f, 
    -0.10345131f, 0.09769890f, 0.00664799f, -0.07923382f, -0.00918184f, -0.05537932f, -0.17503262f, 0.02695967f, 
    0.12189619f, 0.22612022f, -0.12823099f, 0.11553926f, -0.01244230f, -0.04249410f, 0.00845892f, -0.05698417f, 
    -0.02100017f, 0.10110336f, -0.02064065f, -0.13040133f, 0.05441573f, 0.00823981f, -0.20094489f, -0.22799215f, 
    0.15422025f, 0.05415710f, 0.07492057f, -0.02887033f, 0.00640109f, -0.05030251f, 0.07328672f, 0.05116871f, 
    -0.21129975f, 0.00566816f, -0.12789623f, -0.23744982f, 0.12515293f, 0.09320150f, 0.12663664f, 0.12794060f, 
    0.06208202f, 0.03640177f, 0.08634035f, 0.00682208f, 0.19640768f, 0.13004529f, -0.02090229f, -0.09245963f, 
    -0.05070763f, -0.02065482f, 0.06908062f, -0.05330944f, -0.07192627f, 0.02374554f, -0.04274976f, 0.05653391f, 
    0.08780660f, -0.04397618f, 0.23296191f, -0.07161948f, 0.00238052f, -0.00870526f, -0.12357772f, 0.06010531f, 
    0.05485402f, -0.06694914f, 0.11238632f, 0.00083842f, -0.03406194f, 0.05737264f, -0.21373622f, -0.12979437f, 
    0.16988686f, -0.11710373f, 0.13717557f, -0.05797387f, -0.00869836f, 0.06315123f, -0.04853236f, -0.04343725f, 
    0.07056522f, 0.03885555f, 0.01675514f, 0.07665160f, -0.03463842f, 0.04579560f, -0.12814248f, 0.03513655f, 
    0.04423981f, 0.10881273f, 0.00951406f, 0.03299305f, -0.16038744f, -0.00204878f, 0.02267674f, -0.07405242f, 
    0.00585560f, -0.00915760f, 0.06806252f, 0.05363310f, 0.03944098f, 0.08563778f, -0.15824310f, 0.07858052f, 
    -0.00940818f, -0.03575355f, 0.03920663f, 0.03561323f, 0.04230529f, 0.02885373f, -0.07282841f, 0.00938710f, 
    0.05632346f, 0.00457515f, 0.02479173f, -0.03455123f, 0.05395959f, -0.05022201f, -0.03716018f, -0.06109034f, 
    -0.05600547f, 0.01737743f, -0.00381171f, -0.01767728f, 0.03504390f, -0.05985685f, 0.04247382f, -0.02238514f, 
    -0.01992291f, -0.01081867f, -0.02653689f, -0.00967130f, -0.03199083f, 0.03359987f, -0.05866385f, -0.02857311f, 
    0.03764848f, -0.01512423f, -0.02158423f, 0.06067478f, -0.02306915f, -0.00010752f, -0.04702953f, -0.01009163f, 
    0.03876959f, -0.02133877f, 0.01294860f, -0.01731229f, -0.02260959f, 0.04876065f, -0.04702833f, -0.02151284f, 
    -0.00464912f, -0.05290132f, 0.00722001f, 0.01589090f, 0.00838102f, -0.00771195f, 0.05884250f, 0.02543623f, 
    0.02170912f, 0.00571369f, 0.04294231f, -0.01155431f, 0.00250519f, -0.01920082f, -0.02669750f, 0.00225796f, 
    -0.03969416f, -0.00061053f, -0.07280722f, -0.06573596f, -0.04603835f, 0.02515665f, -0.01380768f, 0.05148803f, 
    0.00758849f, 0.04433715f, -0.01050263f, 0.05938134f, -0.01665921f, -0.01295718f, -0.01047431f, -0.00360455f, 
    0.05726188f, -0.04209903f, -0.07931873f, 0.04104163f, -0.01500417f, -0.04051370f, -0.05425648f, 0.02023142f, 
    0.01538760f, 0.04806329f, -0.07327428f, -0.05835968f, -0.02913046f, -0.03104721f, -0.04854395f, -0.00030693f, 
    -0.01117972f, 0.00612570f, -0.02505762f, -0.03046519f, -0.07764629f, 0.01164163f, -0.05711398f, 0.03913447f, 
    0.01543699f, 0.03249701f, 0.01928439f, -0.03700848f, -0.03487504f, 0.02338353f, -0.01041344f, 0.01100014f, 
    0.03679629f, -0.06906252f, 0.03592663f, 0.02670994f, -0.00705546f, 0.04348042f, 0.00800096f, -0.04922518f, 
    -0.05695121f, 0.00041832f, -0.02077030f, 0.03938721f, -0.05631113f, -0.02796226f, 0.00800520f, -0.02147618f, 
    -0.01176961f, 0.02682472f, 0.02681456f, -0.07593866f, -0.04763221f, -0.03009935f, 0.04783497f, 0.02373663f, 
    -0.07082683f, -0.03510769f, -0.02598558f, -0.07859995f, 0.03501478f, -0.07485706f, 0.03775642f, 0.05588933f, 
    -0.01937095f, -0.06328758f, -0.02059188f, -0.01156407f, 0.03973108f, -0.05839438f, 0.03027778f, -0.05017483f, 
    0.04573479f, -0.07432970f, 0.01916889f, 0.03876600f, -0.04849686f, 0.02572688f, 0.02634007f, -0.05716168f, 
    0.05493207f, -0.04797838f, 0.04575813f, 0.00486802f, -0.06729498f, -0.06308264f, 0.06157635f, -0.03404296f, 
    0.03194141f, -0.03708446f, 0.05833809f, -0.00409455f, -0.05452388f, 0.00194824f, -0.04905367f, 0.00177197f, 
    -0.01166465f, 0.05773528f, -0.01937799f, -0.00976228f, -0.01513979f, -0.02035151f, -0.05356384f, -0.07153818f, 
    -0.06281088f, 0.05645203f, 0.06246974f, 0.01355386f, -0.03945941f, 0.02023837f, -0.06433654f, -0.05938902f, 
    0.36880210f, -0.08626272f, -0.04912505f, 0.11772431f, -0.12627973f, 0.07952268f, -0.03331093f, -0.10269942f, 
    -0.06628754f, 0.06231521f, 0.00196456f, -0.00145001f, -0.18483785f, 0.14764848f, -0.05720519f, -0.15884665f, 
    0.06471611f, 0.02503651f, 0.08535625f, -0.01293828f, 0.08608272f, -0.02676468f, 0.12836488f, -0.02762397f, 
    -0.21988520f, -0.05002476f, -0.04003731f, -0.14252599f, 0.12543002f, 0.00487817f, 0.05105861f, -0.00789510f, 
    0.03289650f, 0.01063512f, 0.07117237f, 0.00677354f, -0.18713267f, 0.11711790f, -0.01144071f, -0.02050645f, 
    -0.09048214f, -0.05407613f, 0.02476828f, 0.10403802f, -0.02012296f, -0.07649244f, -0.10965075f, 0.00605819f, 
    0.27369285f, 0.02499753f, 0.16914323f, -0.08755986f, 0.00947229f, 0.01394931f, 0.08483199f, -0.05486866f, 
    0.01946385f, 0.03855023f, -0.02183420f, -0.01484074f, -0.10454360f, 0.05904504f, -0.21978916f, -0.01103786f, 
    0.13555126f, -0.06252937f, -0.07333432f, 0.00681397f, -0.11065152f, 0.02339603f, 0.14065251f, 0.02084684f, 
    0.26958355f, 0.04894402f, 0.03082879f, 0.15867136f, 0.03402409f, -0.00826798f, 0.03667702f, 0.03300970f, 
    0.00987990f, 0.06156215f, -0.10138749f, -0.08514228f, -0.06331511f, 0.21923447f, -0.10287704f, 0.11039464f, 
    -0.03237768f, -0.03170731f, 0.12775725f, 0.05095161f, 0.05291918f, -0.10479386f, 0.11209763f, -0.06169156f, 
    0.20629412f, 0.02904393f, 0.10014541f, -0.13489895f, -0.02135947f, -0.04427334f, 0.06920912f, 0.02885159f, 
    0.05956326f, 0.12586743f, 0.08342788f, 0.01330847f, 0.23272900f, -0.03725687f, -0.02817523f, -0.08968271f, 
    0.35559437f, 0.02319194f, 0.05998737f, 0.03058893f, -0.05614576f, -0.08507461f, 0.04301578f, 0.05507265f, 
    0.06719703f, 0.10323923f, -0.03818911f, -0.20383552f, 0.15711017f, 0.00403692f, 0.13991381f, 0.11113000f, 
    0.03192853f, -0.04721646f, -0.01505600f, -0.01507701f, -0.09844770f, -0.00509337f, 0.15677284f, -0.16386808f, 
    0.01268991f, 0.01249808f, -0.15740100f, 0.05967446f, 0.03301245f, 0.06071623f, -0.12096886f, 0.01853933f, 
    -0.14083250f, 0.11607709f, -0.01706474f, -0.00843714f, -0.15260769f, -0.01264194f, 0.06403355f, -0.00256434f, 
    0.08081590f, 0.05171541f, -0.03139580f, 0.13029866f, 0.04231754f, 0.10408925f, -0.18757842f, -0.19197945f, 
    0.12804629f, 0.03864908f, 0.04928221f, 0.00888279f, -0.01509127f, -0.02413507f, -0.00024754f, -0.06280680f, 
    0.37919047f, 0.05230615f, -0.02215456f, -0.02591166f, -0.07162708f, 0.00220682f, -0.09893908f, 0.05869384f, 
    0.04499206f, 0.02486639f, 0.01657668f, 0.05802555f, -0.36371407f, -0.03026639f, 0.03433498f, 0.08700222f, 
    -0.08809789f, -0.01073760f, -0.00313386f, 0.02819167f, -0.12799270f, -0.10769182f, 0.00920912f, 0.01693051f, 
    0.05255030f, 0.04313022f, 0.00397378f, 0.07226893f, -0.02622632f, -0.08686724f, -0.16068707f, 0.04332149f, 
    0.06326295f, 0.01464043f, -0.04027665f, -0.00465143f, 0.22927871f, -0.09621000f, 0.04879957f, 0.09169776f, 
    0.07986077f, 0.01605891f, -0.09876677f, 0.05962678f, 0.09669168f, 0.04623162f, 0.07361786f, -0.07452934f, 
    0.20466360f, 0.01860660f, -0.10792393f, 0.09395559f, 0.05853590f, -0.04929335f, 0.04463512f, -0.04324401f, 
    -0.05038579f, 0.04392444f, 0.12113660f, -0.01809967f, 0.14309876f, -0.03067476f, 0.18779796f, -0.31384376f, 
    -0.06764788f, 0.03426642f, 0.12640926f, -0.00114845f, 0.07883192f, 0.03600767f, -0.00945051f, -0.01775481f, 
    -0.27907580f, 0.04799904f, -0.14796805f, 0.24078387f, 0.04388011f, 0.02777086f, 0.05113088f, 0.06968438f, 
    0.09262156f, -0.03784846f, -0.03632522f, 0.01146909f, -0.13928807f, 0.00593173f, 0.00626363f, -0.41180673f, 
    0.13625048f, -0.09890445f, 0.01089713f, 0.02245167f, 0.01718397f, -0.01211025f, 0.08929702f, -0.11532632f, 
    0.07902668f, -0.14750686f, -0.23722900f, 0.22414792f, 0.02385637f, 0.00151158f, -0.07549693f, 0.06959530f, 
    -0.01799883f, -0.01012752f, 0.04528474f, 0.02909955f, 0.25722787f, 0.00307413f, 0.10086281f, 0.01453989f, 
    -0.00651419f, -0.10852830f, 0.05592436f, 0.08514221f, -0.06151547f, 0.10722104f, -0.01511959f, 0.06466772f, 
    -0.16018648f, 0.01714148f, -0.04135656f, 0.18061039f, -0.06585678f, -0.03565580f, 0.02108832f, -0.08224875f, 
    0.04576317f, 0.11163180f, 0.01043257f, -0.00040315f, 0.23298046f, 0.21047257f, -0.16366936f, -0.18148187f, 
    -0.03810426f, 0.14138933f, -0.03301091f, -0.05598234f, -0.00677764f, 0.01135292f, 0.13690826f, 0.00058526f, 
    0.04738284f, 0.17838241f, -0.03366607f, -0.13347080f, 0.02228291f, 0.06750458f, 0.08243957f, -0.00825540f, 
    0.14495856f, 0.04286490f, 0.09645159f, -0.07003962f, -0.03362406f, -0.18364641f, -0.06787956f, -0.16004260f, 
    0.01284257f, -0.09335978f, -0.02696610f, -0.00223543f, 0.00181948f, 0.02645208f, 0.02895500f, 0.03429655f, 
    0.31151256f, -0.06316891f, 0.12485716f, -0.10881189f, -0.02519831f, 0.08398470f, -0.03897002f, 0.00056599f, 
    -0.00570307f, 0.08551209f, 0.04175165f, 0.03915677f, 0.13591853f, 0.06104883f, -0.07847537f, -0.06516121f, 
    0.04268130f, -0.08099534f, 0.06439931f, -0.02037264f, -0.00464371f, -0.01029839f, 0.03160628f, -0.03553917f, 
    0.14707911f, -0.19613361f, 0.11216734f, -0.17334041f, -0.01560901f, 0.10809235f, -0.06846930f, -0.03042203f, 
    0.15452471f, -0.04833910f, 0.03368282f, -0.00601518f, -0.07121690f, 0.00163461f, 0.24851260f, 0.06780975f, 
    -0.03078376f, 0.00148370f, -0.00740575f, -0.06786855f, -0.05293114f, -0.09576897f, 0.03083434f, 0.10618609f, 
    0.15130801f, 0.02980842f, 0.00597906f, 0.10746932f, -0.07031970f, -0.08332592f, -0.12636156f, -0.05400600f, 
    0.02261937f, 0.06273615f, -0.16985288f, -0.00913790f, -0.00834335f, -0.02825333f, -0.02688453f, -0.00873318f, 
    0.22207955f, 0.01326779f, 0.02599000f, 0.01125997f, 0.07104644f, 0.07043784f, 0.19345964f, -0.07353516f, 
    -0.04888324f, -0.12943739f, -0.15865014f, 0.01183113f, 0.15345110f, -0.03453666f, 0.05913711f, -0.09982206f, 
    -0.01824899f, 0.05694562f, 0.11245157f, -0.08984595f, -0.02197602f, 0.02609568f, 0.12051023f, -0.34415796f, 
    -0.08889120f, 0.03945533f, -0.01340000f, -0.00332922f, 0.05733906f, 0.05870891f, -0.00253702f, -0.07787371f, 
    -0.19895999f, 0.07245732f, -0.15065838f, 0.20611963f, -0.00277479f, -0.00226317f, 0.14433417f, -0.03996353f, 
    0.17039135f, 0.01375060f, 0.00931265f, 0.00980710f, -0.13650654f, -0.05314745f, -0.09264141f, -0.24766669f, 
    0.10360300f, -0.03518960f, -0.09758732f, -0.08486739f, -0.00519008f, -0.00638219f, 0.05381863f, -0.03933439f, 
    0.15150523f, -0.00288972f, -0.21699461f, 0.23681314f, 0.01853984f, 0.02545232f, 0.01635583f, 0.09496744f, 
    0.03283345f, 0.00778257f, 0.08845492f, 0.11020394f, 0.12329784f, 0.11351348f, -0.02616826f, -0.00016302f, 
    0.04987762f, -0.03901699f, 0.13269460f, 0.16181031f, 0.05714726f, 0.08662717f, 0.03598450f, -0.00509478f, 
    0.10094827f, 0.11742774f, -0.11102032f, 0.18974967f, -0.02600254f, -0.12986673f, 0.00246677f, 0.01389494f, 
    0.09971492f, 0.12289038f, 0.08138347f, 0.00243526f, 0.19132638f, 0.10621867f, -0.16995947f, -0.16271397f, 
    0.01547216f, 0.14304461f, -0.00149033f, 0.00798930f, -0.02707336f, -0.05528182f, 0.11447850f, 0.00519311f, 
    0.11808318f, 0.31042621f, 0.04785758f, -0.09105796f, 0.12403028f, 0.03635671f, 0.00005920f, 0.06877179f, 
    0.08652142f, 0.05356514f, 0.03523899f, 0.01218079f, 0.00147740f, -0.13873251f, 0.03657875f, -0.15517457f, 
    -0.00564402f, -0.12059382f, 0.00316222f, 0.02364311f, 0.05091377f, 0.01712703f, 0.01064398f, -0.06412920f, 
    0.25726515f, 0.07827383f, 0.00517641f, -0.10222982f, -0.05161102f, 0.06599125f, -0.00344499f, 0.07299145f, 
    0.01851869f, 0.01880932f, 0.07712442f, 0.16542682f, 0.06725188f, 0.04923150f, -0.21016714f, -0.04917848f, 
    0.05132396f, 0.01145735f, 0.07685012f, 0.08732712f, 0.00174785f, 0.09085888f, -0.03459667f, -0.03031653f, 
    0.10942668f, 0.01122186f, 0.10436036f, -0.19220392f, 0.04536605f, -0.05953834f, -0.06739745f, 0.00297934f, 
    0.11961120f, -0.00461065f, -0.00243121f, 0.04411485f, -0.20554489f, -0.06982159f, 0.15195784f, 0.10558707f, 
    -0.08506479f, -0.03848561f, 0.04851101f, -0.08518559f, -0.07484668f, -0.08307392f, -0.08602921f, 0.13706085f, 
    0.02821597f, 0.05929191f, -0.07467622f, 0.04209984f, -0.04865743f, -0.03305802f, -0.02757149f, -0.07813305f, 
    0.03937147f, -0.05799576f, -0.03844016f, 0.06597511f, 0.02387387f, -0.05839501f, -0.00075081f, -0.05025832f, 
    0.00346895f, -0.02592452f, -0.06187225f, 0.05578783f, -0.04175931f, 0.00304294f, -0.01203042f, -0.03824221f, 
    -0.00418955f, 0.04813780f, 0.04021363f, 0.02212952f, -0.05730446f, -0.04838614f, 0.05921372f, 0.03858478f, 
    0.04008776f, 0.00880968f, -0.07376857f, -0.06437973f, 0.04005228f, -0.08419940f, 0.01801532f, 0.03357237f, 
    0.02155968f, 0.04156094f, -0.05810483f, 0.05208682f, -0.05132956f, -0.04305923f, -0.03461695f, -0.07342857f, 
    -0.03924328f, 0.01979410f, 0.01303361f, 0.02669080f, -0.05596768f, -0.04216091f, -0.01764418f, -0.04653911f, 
    -0.03855282f, 0.03108207f, -0.02197163f, -0.01910251f, -0.06593937f, 0.03450021f, -0.05377390f, 0.06236590f, 
    -0.00762698f, -0.05368176f, 0.05583131f, -0.02803191f, 0.01370248f, 0.02513703f, 0.04500568f, 0.01215837f, 
    0.04053329f, -0.06019202f, -0.03910413f, -0.03479323f, 0.02737135f, 0.05594911f, 0.00122364f, 0.04060167f, 
    -0.00806065f, 0.05758746f, -0.02684531f, 0.04298353f, 0.06431460f, 0.02126341f, 0.02531573f, 0.00774273f, 
    -0.00802498f, 0.02647521f, 0.02563760f, 0.01829367f, -0.06663787f, -0.06543691f, 0.03169408f, 0.01541261f, 
    -0.04106988f, -0.01144875f, -0.01818850f, -0.06171583f, 0.01915677f, -0.06020164f, 0.04820170f, -0.03434644f, 
    -0.07680176f, 0.02166333f, -0.06141257f, -0.07342859f, 0.04341931f, -0.05088715f, -0.07492367f, -0.02346963f, 
    -0.04936958f, 0.00000847f, -0.00679672f, 0.02801602f, -0.00760551f, 0.03275834f, -0.00106181f, 0.02582594f, 
    -0.08316692f, 0.04183484f, -0.02205407f, 0.03550095f, 0.02775205f, 0.01258964f, -0.05557518f, -0.01341151f, 
    0.04930307f, -0.04232964f, -0.02951735f, -0.03665892f, -0.04236576f, -0.02274506f, 0.04103033f, -0.07446619f, 
    0.00547253f, -0.06798031f, -0.03751218f, 0.03871809f, -0.06038890f, -0.08092890f, 0.04442246f, -0.05931305f, 
    -0.03211536f, -0.05916031f, -0.07631620f, 0.00459613f, -0.06463909f, -0.04107534f, -0.05486286f, 0.04418490f, 
    0.00690183f, 0.02322143f, 0.01185655f, -0.01818023f, 0.05440054f, -0.01749719f, 0.04846171f, -0.01995085f, 
    -0.00600196f, -0.02720634f, 0.04148818f, 0.01533693f, -0.06078574f, -0.07845143f, 0.03095573f, 0.04718025f, 
    0.03058673f, -0.04580247f, -0.02752246f, -0.01362977f, 0.05578113f, -0.02323757f, -0.02226526f, -0.05378596f, 
    -0.01686295f, 0.06364217f, -0.04535127f, -0.07857623f, -0.06652305f, -0.05994784f, -0.06137902f, -0.00123957f, 
    -0.03550754f, -0.08185343f, 0.00555423f, 0.05391209f, 0.00334881f, -0.00475152f, -0.00296835f, -0.00373304f, 
    0.13876009f, -0.02474909f, 0.21840343f, -0.07181395f, -0.03684933f, -0.04113255f, 0.04332612f, 0.03614080f, 
    -0.00811631f, -0.08709292f, -0.06920373f, -0.01544736f, -0.14899985f, -0.03313237f, -0.00104851f, -0.08355776f, 
    -0.19273062f, -0.07785668f, -0.12365595f, 0.07488903f, -0.05119833f, 0.06961643f, 0.00217436f, 0.13370095f, 
    -0.05467637f, -0.04183935f, 0.10223993f, -0.05956672f, 0.00093182f, 0.06450235f, -0.03975169f, -0.04635403f, 
    0.08124233f, 0.03810096f, -0.00689188f, 0.13308065f, -0.00118115f, 0.04958044f, -0.04714260f, 0.01428793f, 
    0.01244970f, 0.03770579f, 0.07816154f, 0.18576749f, 0.13166836f, 0.15365286f, 0.17435952f, -0.03433601f, 
    0.11671184f, -0.10832052f, -0.05537293f, 0.11489318f, -0.01062350f, 0.04175144f, 0.01336901f, -0.02850307f, 
    -0.10352066f, -0.04976466f, 0.06649289f, 0.04677515f, -0.02876034f, 0.07533602f, 0.13836922f, 0.05304823f, 
    -0.07088866f, 0.01068099f, -0.07206828f, 0.08881901f, 0.10177602f, -0.12793228f, -0.18472490f, 0.04569926f, 
    -0.19137974f, -0.09465138f, 0.20077120f, -0.13892141f, -0.05110502f, -0.05376020f, -0.17156702f, -0.06500965f, 
    0.08477317f, 0.05230175f, 0.07841538f, -0.02870452f, 0.20477477f, -0.18469228f, 0.00369509f, 0.02354052f, 
    0.02421147f, 0.04940787f, -0.08125066f, -0.09486935f, 0.12210278f, 0.03911079f, -0.13786083f, 0.04006590f, 
    0.11046435f, 0.08085134f, 0.01117057f, 0.08796289f, 0.08879837f, 0.05348878f, 0.00908704f, 0.02105500f, 
    -0.09903779f, -0.05155683f, -0.16018389f, -0.06996291f, -0.57580215f, -0.00686000f, 0.27696508f, -0.09028918f, 
    -0.01125667f, 0.14116968f, 0.05800286f, 0.00509361f, 0.14237030f, -0.00613733f, -0.13177957f, 0.09516434f, 
    -0.21718064f, 0.06081242f, 0.04096461f, 0.02715277f, 0.03704183f, 0.04350382f, -0.03600474f, 0.12757564f, 
    -0.00407129f, -0.04297785f, 0.15361087f, -0.00000822f, 0.15420008f, 0.34030804f, -0.07475045f, 0.17703031f, 
    0.02282943f, 0.02780957f, 0.16608772f, 0.14893487f, -0.09885786f, 0.12169424f, -0.02096940f, -0.07142651f, 
    0.04099616f, -0.08813678f, 0.11506397f, -0.14591965f, 0.10453212f, -0.08556638f, -0.05616689f, 0.08338744f, 
    0.04524496f, -0.05708975f, 0.03017126f, -0.02666020f, -0.16161914f, -0.03515858f, 0.19773348f, 0.07859769f, 
    0.14663461f, -0.05068667f, -0.01971298f, -0.01685820f, -0.03546356f, 0.05890780f, 0.09516091f, 0.19446404f, 
    -0.24350667f, 0.16194689f, -0.02109476f, -0.11113293f, 0.06936744f, -0.00077099f, 0.02750863f, -0.10469767f, 
    -0.04444912f, 0.05085305f, -0.11042407f, 0.05314855f, 0.30986795f, 0.08381267f, 0.05271692f, 0.03039979f, 
    0.09230372f, -0.12369022f, 0.06371002f, 0.06627988f, 0.07082251f, 0.14615189f, -0.00844162f, -0.05083919f, 
    0.07528413f, -0.05104338f, -0.00848761f, -0.05085189f, -0.03275758f, -0.04572377f, -0.04734321f, 0.04721611f, 
    -0.03324093f, 0.06959225f, 0.04110492f, 0.04984901f, -0.00870239f, -0.07466014f, -0.02699794f, -0.01144984f, 
    0.00223673f, -0.02160788f, 0.02019350f, 0.01957972f, -0.07432088f, -0.05254669f, 0.06237140f, -0.00571542f, 
    -0.02428581f, -0.00120988f, 0.04851495f, -0.02030191f, 0.01126603f, -0.00350016f, -0.02302090f, -0.05002280f, 
    -0.01491165f, 0.01661198f, 0.01724894f, -0.02934309f, -0.07014427f, 0.00734973f, 0.06322509f, 0.05287062f, 
    -0.06427192f, 0.02506356f, 0.04491326f, -0.06701639f, -0.03368805f, -0.02723288f, -0.03472187f, -0.01685848f, 
    -0.05536088f, -0.01753201f, 0.01242958f, 0.02404616f, 0.04660067f, 0.02033129f, -0.03767944f, 0.00156833f, 
    0.02949344f, 0.03014769f, -0.04327353f, -0.03555531f, 0.04094781f, -0.00479903f, 0.04732236f, -0.00065579f, 
    -0.07725128f, 0.04738981f, 0.06501760f, 0.04522784f, 0.01097586f, 0.06021995f, -0.05563535f, 0.02312779f, 
    0.05962090f, -0.05709718f, -0.01423835f, 0.04271599f, -0.05772249f, 0.00654453f, -0.01283849f, -0.00266648f, 
    -0.03991419f, -0.01599478f, -0.04313039f, 0.00542619f, -0.00688111f, -0.04719919f, 0.05850350f, 0.03695510f, 
    0.02842745f, -0.05840315f, 0.07337765f, 0.00192253f, -0.05935180f, -0.00494435f, -0.04673306f, -0.06244048f, 
    0.03502688f, -0.02756682f, 0.04490502f, -0.02087466f, -0.00484670f, -0.02653526f, -0.06660042f, 0.00550304f, 
    -0.03549664f, -0.05444676f, -0.01341120f, -0.04554692f, -0.02585278f, -0.07006517f, 0.05985728f, -0.00122478f, 
    -0.01642913f, 0.00268191f, -0.05283033f, -0.03259392f, -0.05187354f, -0.06434467f, 0.01957433f, 0.00868806f, 
    -0.00746873f, 0.06073273f, 0.03203776f, -0.02236173f, -0.01946926f, -0.06161144f, -0.04223968f, 0.02787304f, 
    -0.07497717f, -0.02530193f, 0.05516754f, -0.04497360f, 0.02686621f, -0.06619043f, -0.03646475f, -0.04879202f, 
    -0.07633892f, -0.04953993f, -0.06802711f, -0.00126800f, -0.01121945f, 0.00151407f, -0.02186980f, -0.04008310f, 
    -0.04386440f, 0.02434647f, -0.05079711f, -0.05392895f, 0.06972012f, -0.05046255f, 0.05958653f, -0.00856825f, 
    -0.04268016f, 0.06478360f, -0.03806187f, 0.03041452f, -0.01083581f, 0.02887613f, 0.01070358f, 0.02410034f, 
    0.00181532f, -0.00756960f, 0.06938449f, -0.04215254f, 0.03868898f, -0.04691843f, 0.02261362f, -0.01722383f, 
    -0.04016288f, -0.00214346f, 0.05758506f, -0.06132661f, 0.02918010f, -0.02747333f, 0.05201714f, 0.00237231f, 
    -0.04452664f, -0.05316631f, 0.02484450f, -0.02499947f, 0.02567082f, -0.07051313f, -0.08120540f, -0.03576722f, 
    -0.06352466f, -0.02195352f, -0.01100604f, -0.00813495f, -0.04544059f, 0.05274452f, -0.00249253f, -0.01293347f, 
    -0.33983955f, 0.03685388f, -0.26042348f, -0.05020941f, 0.11224557f, 0.11100095f, 0.05289694f, -0.09702861f, 
    0.04320736f, -0.01290706f, 0.05409194f, 0.02225665f, -0.02026764f, 0.42459381f, -0.21058851f, -0.07832395f, 
    0.14025481f, 0.03841950f, -0.03404120f, 0.02773233f, -0.03384520f, -0.04623239f, -0.02436008f, 0.03380153f, 
    0.03957298f, -0.06084347f, -0.02883693f, -0.24132635f, 0.02416845f, 0.03824015f, -0.08301487f, -0.03995247f, 
    -0.04024691f, -0.03206640f, -0.18072872f, 0.03379166f, 0.04314268f, -0.27283561f, 0.05121192f, -0.03884077f, 
    -0.08587424f, 0.12038347f, -0.09072367f, -0.04015736f, -0.02770627f, -0.01106564f, -0.07418834f, 0.10084617f, 
    -0.39193320f, 0.08728325f, 0.20574044f, 0.07199061f, 0.09456988f, -0.06902152f, -0.13314030f, 0.07342841f, 
    0.00848642f, -0.01410287f, 0.14624093f, -0.08582222f, 0.06876417f, -0.06349843f, 0.00489966f, 0.23588584f, 
    -0.04006404f, -0.09810576f, -0.07976514f, 0.07977387f, 0.07390133f, 0.18635432f, 0.10873062f, 0.13021791f, 
    -0.17992097f, 0.21363397f, 0.05317018f, -0.29857293f, 0.07678372f, -0.06889011f, 0.00797556f, 0.00948268f, 
    0.03445869f, 0.02475996f, -0.02152894f, 0.10637370f, -0.13646744f, 0.13503385f, 0.07191950f, 0.20853359f, 
    0.12417117f, 0.09553978f, 0.06653791f, 0.10097201f, 0.16708030f, 0.05519661f, -0.04748793f, 0.08953372f, 
    -0.22268133f, 0.04105037f, -0.00934774f, 0.13404171f, 0.02596687f, 0.00546178f, -0.02083038f, -0.06014217f, 
    -0.04649061f, 0.00025770f, 0.16418539f, 0.12915610f, 0.08053999f, -0.02487507f, 0.10927791f, 0.26397946f, 
    -0.11279213f, -0.11476148f, -0.00664892f, 0.17141481f, 0.02055090f, 0.18549213f, 0.01561242f, 0.06333973f, 
    0.21929938f, 0.00047745f, -0.00637622f, 0.01623371f, -0.09221845f, -0.01373556f, -0.12167367f, -0.01183682f, 
    -0.10662984f, 0.08550529f, 0.00918463f, 0.10252078f, -0.23115130f, 0.05959925f, -0.04000826f, 0.00244979f, 
    0.03822952f, 0.14248307f, 0.02049235f, 0.00660847f, 0.12043864f, -0.00116296f, -0.03296243f, 0.07300106f, 
    0.00429154f, -0.00769480f, -0.03456540f, -0.08278628f, 0.07357471f, 0.08358737f, 0.10746914f, 0.00538466f, 
    0.11723851f, -0.05752861f, 0.05746938f, -0.01745572f, 0.19580518f, 0.13166390f, 0.02464509f, 0.16693404f, 
    -0.04143658f, 0.25770900f, 0.02612698f, 0.13465710f, -0.03234493f, -0.02655002f, 0.04518475f, 0.15299875f, 
    -0.39684087f, -0.27506736f, -0.03722591f, 0.03958484f, -0.05139033f, 0.03789324f, 0.00494343f, -0.04098275f, 
    -0.04052304f, -0.01302938f, -0.01669109f, 0.03486067f, 0.12152578f, -0.03393299f, -0.04383134f, 0.09326625f, 
    0.10575585f, 0.01131363f, -0.01378283f, 0.01532285f, 0.05213500f, 0.07836208f, 0.10040643f, -0.07549471f, 
    0.02876540f, -0.06715029f, 0.05352889f, 0.00600764f, -0.01106418f, 0.03436932f, 0.04879664f, 0.03608595f, 
    -0.05621676f, 0.03602755f, 0.02711515f, -0.00717601f, -0.05315906f, 0.02411629f, 0.01636201f, -0.06774960f, 
    0.03223341f, 0.02538069f, -0.04869717f, -0.01389488f, 0.00144996f, -0.01369581f, -0.05912689f, 0.00872213f, 
    0.05088035f, -0.05565989f, -0.02245471f, -0.00198343f, -0.01502171f, 0.03583104f, 0.02609592f, 0.04840877f, 
    -0.07892078f, -0.03841510f, -0.03510272f, -0.06364577f, -0.07720503f, -0.03386067f, 0.06156486f, 0.04277029f, 
    -0.00014462f, -0.02042389f, -0.01415220f, -0.07010847f, 0.01734676f, 0.04120913f, 0.05161220f, -0.05636351f, 
    -0.05523338f, 0.05552165f, -0.07733890f, -0.05658853f, -0.02129345f, 0.04966274f, -0.07147311f, -0.06598490f, 
    0.01526450f, -0.05152914f, -0.00207366f, 0.04054980f, -0.03475351f, -0.06127058f, 0.04159378f, -0.05797486f, 
    0.06055769f, -0.07392186f, -0.07865277f, -0.06401753f, 0.02638371f, 0.02339025f, 0.02290120f, -0.07713692f, 
    -0.01844850f, -0.05324828f, -0.07509577f, -0.07255024f, 0.03215624f, -0.00212302f, -0.00500410f, -0.05473635f, 
    0.04858688f, -0.01554780f, -0.04963683f, -0.00017502f, -0.01596480f, 0.03523812f, -0.07917165f, -0.02351029f, 
    0.00558870f, 0.01681743f, 0.05850895f, 0.04104085f, -0.02959839f, -0.00517277f, -0.07914461f, 0.02627945f, 
    -0.04531059f, 0.05662965f, 0.03911616f, 0.00760720f, 0.03628298f, -0.02864752f, 0.05677280f, 0.04683536f, 
    -0.04021150f, -0.06867741f, 0.02498679f, -0.03455536f, -0.01802943f, -0.04369185f, -0.01955540f, 0.05436648f, 
    -0.03702413f, -0.02134497f, 0.02051857f, 0.00633957f, -0.04286152f, 0.04043116f, 0.04063270f, -0.03469599f, 
    0.02527613f, 0.04673647f, -0.07317016f, 0.04065635f, 0.05179647f, 0.02254433f, -0.02421154f, -0.02987916f, 
    -0.07563873f, -0.01844335f, 0.03636399f, 0.05111369f, -0.00258406f, -0.06983256f, -0.05076681f, -0.03961950f, 
    -0.07757869f, -0.01815400f, 0.01109409f, 0.06313374f, -0.04146535f, -0.03017713f, 0.02799904f, -0.04605734f, 
    -0.02873402f, -0.00321633f, -0.06819277f, 0.00055693f, 0.04433846f, -0.01829269f, -0.04256967f, 0.01101958f, 
    0.00933330f, 0.04435190f, -0.07045394f, -0.05233612f, -0.00453644f, 0.01109017f, -0.06309792f, 0.06319560f, 
    0.02765616f, 0.05183518f, -0.06496176f, -0.00864285f, -0.02281249f, -0.04493242f, -0.02478316f, -0.07347133f, 
    0.00884570f, 0.05298585f, 0.00011107f, -0.07394939f, -0.04327053f, -0.04361783f, 0.01665982f, -0.07608751f, 
    0.02658565f, -0.00044511f, -0.06672433f, 0.06015411f, -0.00041966f, 0.04712665f, -0.04004763f, 0.01629734f, 
    -0.03025246f, -0.07664940f, -0.03000748f, -0.00477193f, -0.04962661f, -0.00703752f, -0.03063691f, -0.06677098f, 
    -0.17828539f, 0.00169067f, -0.17034221f, 0.06210170f, 0.00516757f, -0.00082867f, -0.10093489f, -0.00997372f, 
    0.06354605f, -0.09068923f, 0.09528705f, 0.25640944f, 0.04300820f, 0.08573866f, 0.05091887f, -0.13314185f, 
    0.04053564f, -0.07241280f, 0.14635041f, 0.08726735f, 0.11315164f, -0.14553255f, -0.07446905f, -0.03253614f, 
    0.02929963f, 0.16176596f, -0.03723601f, -0.17937104f, 0.02804677f, -0.00820682f, -0.01169274f, 0.12765658f, 
    0.03161518f, 0.06747022f, 0.10090446f, -0.00198091f, 0.11661550f, -0.12447426f, -0.15120521f, 0.12142607f, 
    -0.06486490f, -0.16699329f, 0.02438373f, 0.11115284f, -0.12739174f, 0.03125928f, -0.01947843f, -0.14184456f, 
    -0.01939728f, 0.05832044f, -0.01902414f, -0.09024300f, 0.04108138f, 0.00137188f, 0.02141146f, -0.03735395f, 
    -0.02470855f, 0.08003920f, 0.04889257f, 0.16710545f, 0.02431256f, -0.11716197f, -0.04941244f, -0.18862355f, 
    -0.00812225f, 0.09431688f, 0.23797947f, 0.00384156f, 0.05983618f, 0.16635641f, 0.04843853f, 0.14890987f, 
    0.15790111f, 0.25130090f, 0.05800358f, 0.06825100f, 0.04962012f, -0.01149242f, 0.00547712f, -0.04225752f, 
    0.07792293f, 0.02607000f, 0.02806762f, -0.10080367f, -0.31529853f, -0.03877824f, 0.00502389f, 0.15439717f, 
    0.08233213f, 0.00111909f, 0.07031103f, 0.03716209f, 0.04717349f, 0.02271526f, 0.03292692f, -0.05698826f, 
    -0.04437806f, 0.03854408f, -0.01916562f, -0.18643686f, 0.08573951f, 0.10361329f, -0.03805986f, 0.05513658f, 
    0.18741709f, -0.04554528f, 0.02199764f, -0.04740065f, 0.08168425f, 0.03164407f, 0.08284052f, 0.02622355f, 
    0.02299082f, 0.02298195f, 0.07671413f, -0.09366075f, -0.11813869f, -0.02505870f, -0.16812517f, -0.03478852f, 
    -0.17485273f, 0.02486964f, 0.15932857f, -0.15305664f, 0.08747584f, 0.15410502f, 0.06806131f, -0.09080256f, 
    0.08647063f, -0.09719270f, 0.02768981f, 0.08215641f, -0.00408256f, -0.16400206f, 0.10101861f, 0.00617783f, 
    0.05442213f, 0.00286547f, 0.09006312f, 0.03825125f, -0.01832608f, 0.08160357f, 0.00663592f, -0.15503269f, 
    -0.28927857f, -0.07417123f, 0.08194020f, 0.23587278f, 0.02520904f, -0.07569946f, 0.13730443f, 0.19288874f, 
    0.06613173f, 0.05240711f, -0.07884648f, 0.12759852f, -0.23876981f, 0.07633904f, -0.09434789f, -0.25435725f, 
    0.08031259f, -0.05843432f, -0.00778279f, -0.03484164f, 0.03303996f, -0.06713485f, 0.00395231f, 0.15405400f, 
    0.44052613f, -0.04439083f, -0.14685771f, 0.09062860f, -0.06597812f, 0.12470380f, 0.01503560f, 0.09844285f, 
    0.00295054f, 0.13367695f, -0.02588962f, 0.02621073f, -0.01752073f, -0.14518468f, -0.04596943f, 0.16565178f, 
    -0.02575272f, -0.08134012f, 0.04559269f, 0.10494289f, -0.02875371f, -0.14015916f, 0.08011439f, 0.12999894f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06354290f, 0.08487982f, -0.10945503f, 0.06529484f, 0.04227252f, -0.11376456f, 0.11313684f, -0.07886665f, 
    0.03339542f, -0.04849003f, -0.06797665f, 0.01312935f, 0.03628770f, 0.05990796f, 0.04419948f, -0.01670463f, 
    0.06477507f, 0.10229142f, -0.00789669f, 0.03404168f, -0.01576406f, 0.03741998f, 0.05162528f, 0.01433399f, 
    -0.03084381f, 0.04702390f, 0.06101440f, -0.01031856f, -0.00232028f, 0.12925261f, -0.10346822f, -0.00906832f, 
    0.00390998f, 0.05787983f, 0.03449471f, 0.00270562f, 0.09569213f, -0.05995735f, 0.16240799f, -0.03909293f, 
    -0.11181644f, 0.09741422f, -0.06554171f, 0.04849198f, 0.07332047f, 0.04224830f, -0.00274649f, 0.08853687f, 
    0.08710455f, 0.10277449f, -0.07585373f, 0.01546334f, 0.02771513f, -0.00571985f, -0.06431635f, 0.01477172f, 
    0.06465989f, -0.05063200f, 0.04544464f, 0.07413528f, 0.03491621f, 0.17190778f, -0.06658463f, 0.09728065f, 
    -0.06710114f, 0.06228975f, -0.03594120f, 0.05068642f, 0.03206176f, -0.02567111f, -0.00963770f, 0.00009140f, 
    0.05986098f, 0.00003885f, 0.03086637f, -0.00052204f, 0.02642124f, 0.03940023f, -0.07496297f, -0.03457817f, 
    -0.02095517f, 0.00734055f, 0.00253943f, 0.09940831f, 0.07593662f, 0.03972068f, 0.05325730f, 0.03021920f, 
    0.04550676f, 0.04172631f, 0.00901573f, -0.03116074f, -0.00406095f, -0.01053144f, 0.07283835f, -0.05315997f, 
    -0.05557299f, -0.00325735f, -0.03110356f, -0.00887280f, 0.15599409f, -0.01552301f, -0.04299224f, 0.02544420f, 
    -0.03115030f, -0.03481114f, -0.04020521f, 0.01610326f, 0.06838420f, 0.04547331f, 0.02624087f, -0.03110751f, 
    0.10248020f, 0.04415061f, 0.04737917f, -0.12083897f, 0.01516281f, -0.05862598f, 0.03081580f, -0.04815552f, 
    -0.00612524f, 0.03356902f, -0.00597468f, 0.08001269f, -0.02536298f, 0.12722288f, -0.01326543f, 0.02561113f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.52452326f, -0.15611736f, 0.25659108f, 0.17259897f, -0.07202185f, 0.05378350f, -0.27135375f, -0.03100952f, 
    0.02124714f, 0.01119045f, -0.07655804f, 0.03992631f, -0.42518103f, -0.10364088f, -0.09935820f, -0.23449056f, 
    -0.06088363f, -0.19012526f, -0.07973754f, -0.33069310f, -0.00118948f, -0.13487339f, 0.03579170f, 0.15529902f, 
    0.10499421f, -0.21710141f, -0.04638703f, 0.04876016f, -0.03603985f, -0.17564486f, 0.20875187f, 0.00758108f, 
    -0.16882651f, 0.01942503f, -0.05593112f, -0.03211010f, -0.53375399f, -0.04852980f, -0.55612803f, -0.20445481f, 
    0.22767836f, -0.24214166f, 0.26595160f, -0.12230997f, -0.38430357f, 0.03281813f, -0.07814081f, -0.11859494f, 
    0.08761065f, 0.09812821f, -0.08154610f, 0.02218414f, -0.23447956f, 0.05871920f, 0.08643045f, -0.02577808f, 
    0.15507290f, 0.28215361f, -0.04670857f, -0.11189593f, 0.03837913f, -0.56867248f, -0.15812349f, -0.40758023f, 
    0.17070882f, 0.21297516f, 0.08462471f, -0.28182974f, 0.00240089f, -0.05314957f, 0.05574436f, -0.08128215f, 
    -0.32550505f, 0.00847191f, 0.18236825f, 0.17618909f, 0.19152345f, 0.00872244f, -0.08444450f, 0.04471412f, 
    -0.02535245f, 0.00044804f, 0.01935495f, -0.01900842f, 0.12066179f, -0.03454205f, -0.02114583f, 0.18648010f, 
    0.07055633f, 0.05766557f, -0.06418850f, 0.20673673f, -0.00327169f, 0.08053685f, -0.39790112f, 0.03110243f, 
    -0.02361601f, 0.03005118f, 0.35910535f, 0.02059579f, -0.20366068f, 0.14371221f, -0.05553355f, -0.21118912f, 
    -0.16999735f, -0.16813549f, 0.13673058f, -0.23248369f, 0.22976057f, -0.28859270f, 0.09250538f, 0.11476260f, 
    -0.53266734f, -0.23401588f, -0.06676809f, 0.23997143f, 0.03713832f, -0.00799000f, -0.02087787f, -0.10971731f, 
    0.23659599f, 0.16722077f, 0.08808624f, -0.05438348f, -0.05202988f, -0.23089433f, 0.00148388f, 0.05957142f, 
    -0.00368010f, 0.17865412f, 0.09843340f, 0.02385355f, 0.22584133f, -0.04616033f, -0.40483904f, 0.08007889f, 
    -0.07632148f, 0.24900249f, 0.04277701f, -0.08816102f, 0.00083945f, -0.21964592f, 0.03687996f, -0.28401241f, 
    0.06850497f, -0.29575133f, 0.42487547f, -0.06880657f, -0.09781602f, 0.00407079f, -0.04794638f, -0.09810017f, 
    0.10174508f, -0.11474545f, 0.03090246f, -0.01422361f, -0.08738274f, -0.11525900f, 0.02755484f, 0.20283748f, 
    -0.05135497f, 0.11457982f, 0.04349154f, -0.13401057f, -0.29787731f, -0.04152545f, -0.20942797f, -0.07071558f, 
    -0.24698418f, 0.25366509f, 0.16322665f, 0.08307181f, 0.10383029f, -0.00901154f, -0.41710132f, -0.30556995f, 
    -0.11128855f, -0.02508765f, -0.00022249f, 0.11407097f, 0.55603117f, 0.12593323f, -0.03253844f, -0.04421030f, 
    0.14502522f, 0.16060185f, 0.17178588f, 0.02865614f, -0.00554528f, 0.06328133f, 0.11929215f, -0.16577633f, 
    -0.15657465f, -0.15098841f, -0.14807761f, -0.25681251f, -0.09224897f, 0.26757246f, 0.06097765f, -0.42252758f, 
    -0.27075559f, 0.00671495f, -0.41870108f, -0.41926530f, 0.12340891f, -0.13985367f, 0.11380745f, 0.05416667f, 
    0.13911006f, -0.05434082f, 0.09875766f, -0.13375811f, -0.06520732f, 0.03819433f, -0.03151705f, 0.12363793f, 
    -0.05692088f, 0.06424450f, -0.01742995f, 0.15030561f, 0.20682088f, -0.39235494f, -0.09830984f, -0.00014500f, 
    -0.05100010f, 0.21346965f, -0.40472364f, -0.04372283f, -0.30969429f, 0.10202939f, -0.06112051f, -0.16225900f, 
    -0.25110209f, 0.25125277f, -0.09987195f, -0.31248558f, -0.10400876f, 0.23026948f, -0.00622582f, -0.20816652f, 
    0.32014865f, -0.12037934f, -0.03155181f, -0.10951280f, 0.17980509f, 0.27543321f, 0.04898751f, -0.24923356f, 
    0.13109989f, 0.00924489f, 0.01167618f, 0.22234695f, -0.05049116f, -0.08358136f, 0.06575921f, -0.21418148f, 
    0.00671375f, -0.26210511f, 0.13343824f, -0.44699168f, -0.11165761f, -0.06494951f, 0.12442810f, 0.00732713f, 
    0.03672400f, 0.20834954f, -0.04441238f, 0.04901182f, 0.08602296f, -0.12829901f, -0.16935201f, -0.27721080f, 
    0.11394218f, 0.16238715f, -0.26906604f, -0.32739118f, -0.43406305f, -0.36558381f, 0.02234623f, -0.21124297f, 
    0.03627776f, -0.46109661f, -0.06176402f, -0.04553419f, -0.06658460f, -0.24325964f, -0.42957374f, 0.20183516f, 
    -0.09083880f, 0.13982211f, -0.00272006f, -0.01960794f, -0.25057656f, -0.04766959f, 0.06548255f, 0.17708419f, 
    0.22393565f, -0.10508989f, 0.25328258f, 0.15104088f, -0.21461004f, -0.01374025f, 0.02226982f, -0.34646949f, 
    0.17460035f, 0.09889515f, -0.07890790f, 0.12980919f, -0.01246638f, -0.33191910f, 0.00608099f, 0.14595972f, 
    0.06644282f, -0.08338219f, 0.12727644f, -0.10221034f, -0.00616244f, -0.20913903f, 0.16811198f, 0.05202642f, 
    0.19610453f, -0.09813099f, -0.16205376f, -0.24910773f, 0.01172879f, -0.40829083f, 0.02122038f, -0.02920248f, 
    -0.08910579f, 0.07886314f, -0.20467895f, 0.19172198f, 0.18595988f, 0.05344120f, 0.16287407f, -0.14733838f, 
    0.01750226f, 0.02019707f, 0.14931017f, -0.22377191f, -0.12330568f, -0.49351907f, -0.00138238f, -0.09889711f, 
    0.05380168f, -0.23798254f, -0.01825731f, 0.00086043f, 0.13787653f, 0.15314481f, -0.22408971f, -0.03474673f, 
    0.03905722f, -0.08210686f, 0.17888673f, -0.02109283f, -0.13634042f, 0.17182672f, 0.04280410f, 0.04051314f, 
    0.13473377f, 0.04532138f, 0.11740032f, 0.37351760f, -0.23364703f, -0.29783392f, 0.23286316f, -0.06649012f, 
    0.20745610f, -0.25634900f, -0.03674914f, 0.04824019f, -0.08877697f, 0.25304326f, 0.01807830f, 0.22887877f, 
    0.05402276f, 0.14522158f, 0.01285892f, -0.47422349f, 0.06264267f, -0.52043140f, 0.05205731f, 0.17650822f, 
    -0.11976615f, -0.25228581f, 0.17830929f, -0.36254096f, 0.14563523f, -0.10629065f, -0.15890576f, -0.05394865f, 
    -0.07742844f, -0.34990039f, 0.07723583f, 0.04074759f, -0.05242624f, 0.18826669f, 0.03322522f, -0.17232101f, 
    0.20041095f, -0.16820967f, 0.17357667f, -0.13806422f, 0.13556804f, 0.13470493f, -0.05067722f, -0.68304896f, 
    -0.24651058f, 0.12525824f, 0.02607820f, 0.07839271f, 0.34581542f, -0.15922464f, -0.03285557f, -0.12871623f, 
    -0.10223250f, -0.16697478f, 0.05651440f, 0.05804429f, 0.17303331f, 0.06331890f, -0.28611836f, 0.05136991f, 
    -0.29198232f, 0.03263771f, 0.26984096f, 0.15962417f, -0.34326914f, 0.05745677f, 0.07804637f, 0.24820761f, 
    0.14602678f, -0.14178263f, 0.03323560f, 0.05504896f, -0.32600510f, 0.21173321f, -0.07158165f, 0.12046599f, 
    -0.22432917f, 0.19627810f, -0.24474154f, -0.31904906f, 0.04382496f, 0.00307554f, 0.23333099f, -0.03676538f, 
    -0.38124353f, 0.12339854f, 0.12870961f, -0.28863916f, -0.07742728f, 0.30742744f, -0.07727926f, 0.20990460f, 
    -0.04167587f, -0.00288334f, 0.26402509f, 0.21644025f, -0.41415781f, -0.05162458f, 0.06728546f, -0.14172868f, 
    -0.53658617f, 0.02727225f, 0.05936562f, 0.13677183f, -0.41914275f, 0.09923530f, -0.00075292f, -0.17195229f, 
    0.06970844f, -0.12343687f, -0.01336342f, -0.40437284f, -0.76805454f, -0.15104114f, 0.09558997f, -0.03001381f, 
    -0.03938091f, 0.17486054f, 0.06952927f, -0.09611678f, 0.25058845f, -0.03994446f, -0.06342485f, 0.18067606f, 
    0.18838580f, 0.05681913f, 0.14371736f, -0.54851073f, -0.02223406f, -0.15750308f, 0.11237447f, -0.01745870f, 
    -0.41445398f, 0.28087631f, -0.04800674f, -0.42041722f, 0.23294790f, -0.23576833f, -0.00107853f, 0.03803414f, 
    -0.10527735f, 0.01964742f, -0.00745571f, 0.04228372f, -0.06146480f, -0.02964777f, 0.01889894f, -0.19676013f, 
    -0.07170213f, -0.38540229f, -0.13010323f, 0.03822340f, -0.14824910f, 0.04870196f, -0.21053115f, -0.06595154f, 
    -0.04725292f, -0.38820648f, 0.05637940f, -0.01333398f, -0.24923703f, 0.03628104f, -0.07478048f, 0.06404759f, 
    0.08841185f, -0.11111627f, 0.02952771f, -0.22139119f, -0.05307428f, -0.12759174f, -0.05414458f, -0.30073696f, 
    -0.13437708f, 0.20997211f, 0.03928467f, 0.19173203f, 0.35423562f, 0.02450336f, 0.10338638f, -0.04713738f, 
    0.18105583f, -0.36218780f, 0.03729142f, 0.16618493f, 0.02741747f, -0.00184154f, 0.11884514f, -0.16940087f, 
    0.17307797f, -0.09428912f, -0.13743713f, 0.16533612f, 0.14336367f, -0.05065301f, 0.13101158f, 0.29708681f, 
    0.23585670f, 0.16786177f, 0.05350651f, 0.07268269f, -0.29314637f, 0.05816924f, 0.03868947f, -0.24320069f, 
    0.03404000f, -0.08314791f, -0.19395745f, 0.14824440f, 0.03922642f, -0.02606462f, 0.12944520f, -0.10520057f, 
    -0.02883035f, 0.22571938f, 0.09607536f, 0.15762432f, -0.06778675f, 0.02258308f, -0.08720315f, 0.29272738f, 
    0.17516345f, -0.05816090f, 0.08767857f, 0.05954110f, -0.11680344f, 0.04914246f, 0.13384697f, 0.05163494f, 
    0.10798583f, -0.00719985f, 0.06988490f, -0.26260194f, 0.14773734f, 0.02786610f, 0.03798058f, 0.22045168f, 
    0.07858304f, -0.15573971f, -0.00764439f, 0.14023489f, 0.16671757f, -0.04034692f, 0.10323050f, 0.04963709f, 
    -0.08190878f, -0.09502698f, -0.11647880f, -0.08643769f, -0.06405753f, -0.20448817f, 0.06397552f, 0.11644194f, 
    0.12261268f, 0.12042710f, -0.16757789f, 0.19993012f, 0.11993159f, -0.47242737f, 0.21555154f, 0.22028235f, 
    -0.79663205f, -0.25859439f, 0.06544928f, -0.27086952f, -0.13373460f, -0.31801900f, 0.00962376f, -0.25072306f, 
    -0.26361758f, -0.28131309f, 0.05206417f, 0.11302213f, -0.06893811f, 0.03645264f, -0.09334044f, 0.22396107f, 
    -0.11366839f, 0.16188245f, -0.03706106f, 0.15596336f, 0.10723939f, 0.03283034f, 0.09380003f, 0.03851688f, 
    0.01066614f, -0.10562090f, 0.07290241f, -0.00683615f, -0.00499112f, -0.31152502f, 0.24468152f, 0.19306870f, 
    -0.14780200f, 0.10403891f, -0.19787738f, 0.44129118f, 0.18138881f, -0.03832011f, 0.03094064f, 0.18764894f, 
    0.19716905f, 0.13863580f, 0.04782044f, -0.13113518f, -0.22917043f, 0.09635222f, 0.06501932f, 0.16742688f, 
    -0.41332376f, -0.04677238f, 0.00140349f, -0.21400200f, 0.09539874f, -0.07248364f, 0.51201922f, -0.46287096f, 
    -0.24376699f, 0.20932187f, -0.13467894f, -0.32255110f, -0.04268631f, -0.04888932f, 0.11557736f, 0.12968920f, 
    -0.08798336f, 0.17958309f, 0.03837350f, 0.12176079f, -0.13510141f, 0.25213069f, -0.03175617f, -0.45312408f, 
    0.03997985f, -0.06036494f, -0.15064383f, -0.41541550f, 0.03263030f, -0.04229795f, -0.42221600f, -0.26852563f, 
    0.00973282f, 0.03073061f, -0.11135199f, -0.06863154f, 0.08095828f, 0.16900195f, 0.00044365f, 0.28380677f, 
    0.11919647f, 0.07634602f, -0.33568814f, -0.29469109f, -0.08738270f, 0.00217254f, -0.04424107f, 0.11346012f, 
    0.04813080f, -0.07516537f, 0.17745461f, 0.11281449f, -0.15423022f, 0.19504499f, 0.03880540f, -0.05350422f, 
    0.06374714f, -0.15166032f, -0.06865359f, 0.06714680f, 0.19102760f, 0.21268946f, 0.20370443f, 0.00945350f, 
    -0.04359167f, 0.03900737f, 0.23657180f, 0.04307251f, 0.07430529f, -0.22421849f, 0.02784886f, -0.09614271f, 
    -0.08729883f, -0.44027358f, 0.02001351f, -0.18518904f, -0.17940842f, 0.23936652f, -0.09382834f, 0.16958779f, 
    0.15529351f, -0.11215737f, 0.00432002f, 0.20421939f, -0.08748619f, -0.35295191f, -0.01809509f, -0.18807761f, 
    -0.11166117f, -0.09110871f, -0.00655812f, -0.07439282f, -0.02897420f, 0.21820946f, -0.02900501f, -0.21792632f, 
    -0.14232624f, 0.03005520f, -0.36403850f, 0.10298322f, 0.07766224f, 0.11267199f, 0.24853538f, 0.08549721f, 
    -0.03914842f, -0.22287159f, 0.01877851f, -0.03329666f, -0.37061366f, 0.15447862f, -0.01804524f, 0.13276695f, 
    0.03274032f, 0.22637850f, -0.17259896f, -0.08810586f, 0.18860722f, -0.53076005f, 0.03820404f, 0.26145458f, 
    -0.00094557f, -0.07151268f, -0.07730747f, -0.00976823f, -0.09842058f, 0.01445750f, -0.06541281f, -0.09152125f, 
    0.26470202f, 0.23465787f, -0.04093912f, 0.15049170f, 0.13026035f, 0.04351989f, -0.75187403f, 0.41427016f, 
    0.03839914f, -0.08526456f, -0.28509632f, 0.12482216f, 0.20558032f, -0.06084001f, 0.18921770f, 0.21688460f, 
    -0.10139045f, -0.09544391f, -0.06843353f, -0.00212814f, 0.22221911f, -0.31201974f, -0.03053786f, 0.17829023f, 
    0.12557580f, -0.09637249f, 0.18240590f, -0.12229654f, -0.07147980f, -0.09221866f, 0.01800877f, 0.13959055f, 
    -0.18782263f, 0.10443741f, -0.37796456f, 0.04579507f, -0.08954563f, -0.36562130f, -0.08319980f, -0.27988178f, 
    -0.20110887f, -0.01624790f, 0.09753693f, 0.16668366f, 0.01997217f, -0.05970105f, -0.38482088f, 0.13412872f, 
    0.05025034f, -0.05354365f, -0.13127357f, 0.19186725f, 0.19266734f, -0.13760236f, -0.05359922f, 0.06401618f, 
    -0.06004377f, -0.18003176f, 0.04287793f, -0.17263038f, -0.22060578f, 0.24396840f, -0.51184422f, 0.09141209f, 
    0.03169883f, -0.18844679f, -0.29983065f, -0.07232432f, 0.20711684f, 0.27829421f, 0.04055246f, -0.07366750f, 
    -0.08460646f, -0.52335012f, -0.19528428f, -0.08642711f, -0.20259868f, 0.05464217f, -0.03487121f, 0.19473158f, 
    0.06098658f, -0.31859088f, 0.04285794f, -0.04281674f, 0.12419772f, 0.24548717f, -0.07699165f, 0.18662786f, 
    -0.14728642f, -0.14811622f, 0.07696704f, 0.01424073f, -0.04353337f, 0.03153743f, -0.05863760f, 0.16733286f, 
    -0.02785073f, -0.04123634f, -0.46981522f, -0.27139348f, -0.16903652f, 0.04195040f, 0.22528078f, -0.02054107f, 
    -0.02167550f, 0.01011312f, -0.04549280f, -0.03619081f, 0.12315866f, 0.10378212f, 0.01154971f, 0.25790441f, 
    -0.22997332f, 0.21396522f, 0.16053842f, -0.10485840f, 0.07796015f, 0.17241991f, -0.04323052f, -0.01766620f, 
    -0.33874032f, 0.11104605f, -0.01815298f, -0.05709654f, -0.13768664f, -0.12398130f, 0.09145659f, 0.10563891f, 
    -0.05908423f, -0.21133210f, 0.03657751f, 0.04010648f, 0.16349433f, -0.07238074f, -0.11459465f, 0.02702200f, 
    0.21606769f, -0.12786536f, -0.13746889f, -0.17948020f, 0.18232800f, -0.01151034f, 0.09590466f, 0.10439664f, 
    -0.32926676f, -0.48752448f, 0.07276217f, -0.17794095f, 0.20248695f, -0.05951628f, -0.05584881f, 0.04096380f, 
    -0.29697365f, -0.15258017f, -0.21545398f, 0.24779470f, -0.05753443f, 0.12594414f, 0.15014949f, 0.01811319f, 
    0.15068710f, -0.28049845f, 0.14577703f, -0.02754784f, 0.00457839f, -0.06763667f, -0.08771325f, 0.06485501f, 
    0.17385560f, -0.07165287f, -0.15313870f, 0.06584153f, -0.17289579f, 0.00903980f, 0.08163719f, 0.14229502f, 
    -0.09499399f, -0.00457291f, -0.17781791f, 0.08192872f, -0.19555603f, -0.21025290f, 0.06008165f, -0.38711187f, 
    -0.02904475f, -0.07174522f, 0.00382843f, -0.37520126f, 0.00015572f, 0.23740056f, 0.13857353f, -0.04443246f, 
    -0.03551380f, -0.11983737f, 0.20769383f, -0.02858003f, -0.24625708f, 0.05005337f, -0.05880775f, 0.20784751f, 
    0.19710547f, 0.11514947f, 0.07080033f, 0.25459865f, 0.01257562f, -0.06208208f, -0.26348850f, -0.16118133f, 
    0.15315278f, -0.21400920f, -0.06884602f, 0.04877410f, -0.06448703f, 0.12440333f, -0.04368590f, 0.02618187f, 
    -0.31686273f, -0.13976301f, 0.06415799f, 0.15649928f, 0.02711115f, -0.27270123f, -0.03420793f, -0.22710949f, 
    0.20736614f, 0.22602411f, -0.00568504f, -0.19594912f, 0.12992658f, 0.12970728f, -0.16464671f, -0.07573924f, 
    0.00681267f, 0.12526792f, 0.06451178f, 0.01045632f, 0.04702649f, -0.31252217f, -0.23498487f, 0.00853763f, 
    -0.43299973f, -0.12676302f, -0.03075850f, -0.14264952f, -0.11690415f, 0.11581290f, -0.00180954f, 0.03871919f, 
    0.13941622f, 0.07825229f, -0.02606527f, -0.39104289f, 0.27276522f, -0.41650376f, -0.03162480f, -0.08257236f, 
    0.29759666f, -0.10044611f, -0.01569198f, -0.38404456f, 0.07542497f, -0.04392939f, 0.31818867f, -0.13117370f, 
    0.29280832f, 0.08682038f, -0.54424483f, 0.16841827f, -0.20035717f, 0.07886534f, -0.04394984f, 0.11392658f, 
    -0.10338673f, 0.06761984f, 0.04179397f, -0.28743365f, -0.05069906f, 0.06721269f, -0.01981134f, 0.16706079f, 
    0.14993839f, 0.04143931f, -0.11347997f, -0.17569919f, 0.02188508f, 0.16936161f, -0.03681371f, -0.05830091f, 
    -0.21595597f, -0.33353582f, 0.06506155f, 0.31286773f, -0.01438965f, -0.11272128f, 0.00816100f, 0.05660440f, 
    -0.15659833f, 0.07709361f, -0.29652488f, -0.42282483f, 0.07482509f, -0.08724086f, 0.25234658f, -0.13641469f, 
    0.06151625f, 0.00935696f, -0.05323418f, -0.24753867f, -0.20381591f, 0.05131508f, -0.04467327f, -0.12785092f, 
    0.00019518f, 0.09278508f, 0.00280297f, 0.25598207f, 0.20790869f, -0.00170976f, -0.01941180f, 0.04848641f, 
    -0.04983482f, 0.09128810f, -0.50121331f, 0.02194015f, 0.18175286f, 0.23708887f, 0.05047606f, 0.18145193f, 
    -0.09380593f, -0.40955105f, -0.07784379f, 0.33817434f, 0.03606181f, 0.14353910f, -0.34561905f, -0.20745774f, 
    -0.40831900f, 0.24119665f, -0.06248167f, 0.08903527f, 0.11929964f, 0.02301607f, 0.03329758f, 0.19988610f, 
    0.04178021f, 0.08853024f, 0.02484222f, -0.29928172f, 0.00600849f, -0.12241551f, 0.03262938f, -0.22550377f, 
    0.26658955f, -0.12334168f, -0.23341092f, 0.12015843f, -0.42414483f, -0.02337493f, 0.22165273f, -0.03619252f, 
    -0.01514243f, 0.12912980f, 0.04774252f, -0.03462483f, 0.00969061f, 0.00848588f, 0.03799029f, 0.19893895f, 
    0.06795146f, -0.38297698f, 0.09818132f, 0.33081785f, -0.16014087f, 0.30690381f, 0.04976604f, 0.19743691f, 
    -0.09176324f, -0.03901308f, 0.08072012f, 0.10873920f, -0.40073910f, 0.08899011f, 0.03958159f, -0.47579131f, 
    -0.02062926f, -0.00503926f, 0.00833316f, 0.17097430f, 0.08683889f, 0.05952678f, 0.27337700f, -0.10034145f, 
    -0.13316393f, -0.41983202f, 0.21556242f, -0.23260008f, 0.29542488f, -0.06738640f, -0.02428558f, -0.60367751f, 
    -0.06844269f, -0.00152643f, -0.03687128f, 0.12465433f, -0.41426519f, -0.18783267f, 0.07520422f, -0.16868363f, 
    0.04647580f, -0.33162606f, 0.04252991f, 0.29110330f, -0.04150223f, -0.09659524f, 0.07901660f, 0.40859297f, 
    0.33925581f, -0.09223109f, 0.18588805f, 0.32901618f, -0.06799457f, -0.10141736f, 0.07439046f, -0.07949097f, 
    0.19576322f, 0.00023044f, 0.26606160f, 0.06998115f, 0.09978908f, -0.01855907f, 0.05736701f, -0.33584583f, 
    -0.12818107f, -0.00897165f, -0.40315253f, 0.04171737f, 0.01683174f, -0.34304118f, -0.00359834f, -0.07592729f, 
    0.00015264f, 0.01486205f, -0.06578362f, 0.06906598f, 0.04423528f, -0.11725369f, 0.05101210f, 0.01651639f, 
    -0.08030845f, -0.48350209f, -0.21163933f, -0.03847274f, -0.04904471f, -0.20034167f, 0.00742442f, -0.17497729f, 
    0.00654980f, 0.16812323f, -0.27278173f, -0.10620449f, 0.00641986f, 0.10369133f, 0.01558104f, -0.10426684f, 
    0.31106448f, 0.14649357f, -0.01402451f, 0.13587824f, 0.14823030f, -0.05408939f, 0.00682182f, 0.16596960f, 
    0.09835992f, 0.18803984f, -0.00524457f, -0.10764887f, -0.01173538f, 0.17408696f, -0.03793821f, 0.07698889f, 
    0.05576478f, 0.16164735f, -0.08348141f, -0.00073135f, -0.03892644f, -0.62100679f, 0.12741937f, -0.02402024f, 
    -0.06608639f, 0.11167321f, -0.07520397f, -0.02950053f, 0.17792106f, 0.02250242f, -0.58519161f, -0.23790075f, 
    -0.08866405f, 0.21740416f, -0.38434860f, -0.14336781f, -0.16745883f, 0.11584491f, 0.03067759f, -0.43290976f, 
    0.04888174f, 0.03111184f, -0.00481298f, -0.21702529f, -0.15072973f, 0.18279070f, -0.24323715f, -0.02769274f, 
    -0.27988702f, 0.06725213f, 0.06126412f, 0.14792015f, 0.19643407f, -0.02803750f, -0.01964769f, 0.34246689f, 
    -0.21932805f, 0.17170502f, -0.41652432f, 0.08603738f, 0.24103548f, 0.04516760f, -0.37641585f, -0.14557411f, 
    0.22292066f, 0.24318378f, -0.01004993f, -0.08914690f, -0.45463574f, 0.13012190f, -0.08800044f, 0.27113870f, 
    -0.03506403f, -0.15336148f, -0.02940150f, 0.18015961f, -0.06888214f, 0.20374812f, -0.25205556f, 0.12697570f, 
    -0.01367146f, -0.00185226f, 0.06020924f, -0.08216644f, -0.09415699f, -0.11030600f, -0.02464128f, 0.00072402f, 
    0.13520862f, -0.05400862f, -0.22867429f, -0.26454875f, 0.00932665f, -0.00864616f, -0.53336769f, 0.20705561f, 
    -0.22375399f, -0.01036865f, 0.26808560f, 0.13895498f, -0.37878826f, -0.13984331f, -0.03496517f, -0.01480445f, 
    0.01770743f, 0.25078171f, 0.07787456f, -0.40566757f, -0.33426556f, 0.08718764f, 0.19685498f, -0.08978987f, 
    -0.01571607f, 0.19707657f, 0.09040423f, 0.03665274f, 0.10498802f, 0.07288991f, 0.01192484f, -0.28479522f, 
    -0.16553544f, 0.01286586f, 0.09871128f, 0.13200957f, -0.05292480f, -0.18598667f, -0.01303228f, -0.31656763f, 
    -0.02154914f, 0.20246987f, -0.03134689f, -0.54418242f, -0.29455525f, 0.12459451f, 0.06617304f, 0.08964487f, 
    -0.00878919f, 0.16420315f, 0.04900185f, 0.17160934f, 0.00992446f, -0.08162834f, 0.00983132f, 0.00042383f, 
    0.08329234f, 0.22939759f, -0.00072630f, -0.14178966f, -0.01766718f, 0.12491494f, 0.19829367f, -0.01425638f, 
    -0.05296253f, 0.05712261f, 0.00426781f, 0.05388724f, 0.05685359f, 0.16291253f, 0.05464175f, -0.13070989f, 
    0.07370535f, 0.24804217f, -0.20006391f, -0.26830333f, 0.19015153f, -0.22611426f, 0.07087979f, -0.02278182f, 
    -0.02449278f, 0.05480245f, -0.04699246f, 0.19455540f, -0.27328956f, 0.26199168f, -0.04439009f, 0.12833336f, 
    0.08347247f, 0.26655638f, 0.02736051f, -0.26966694f, -0.24181932f, 0.07222380f, -0.16865899f, -0.11246292f, 
    -0.30808735f, 0.04936503f, -0.01454742f, -0.11376208f, -0.37369508f, 0.03675619f, 0.18457396f, -0.16262962f, 
    -0.02936571f, -0.28887108f, 0.07691056f, -0.43699184f, -0.06395812f, -0.28372741f, 0.00070031f, 0.02835809f, 
    0.10523225f, 0.22324742f, 0.24629259f, 0.07068816f, 0.00516804f, 0.12258181f, -0.39592135f, 0.13446827f, 
    -0.11814221f, -0.04047389f, -0.17180485f, -0.16059798f, -0.03952890f, -0.20243563f, -0.03095690f, -0.36578736f, 
    0.06798023f, 0.06281433f, 0.13969091f, 0.10080571f, -0.07425879f, 0.05040315f, 0.12615430f, -0.16340633f, 
    0.17816484f, 0.07331528f, -0.25624850f, -0.08331315f, 0.26028106f, 0.17659461f, -0.04083182f, -0.10855288f, 
    0.02405045f, 0.16703838f, 0.00693153f, -0.58640069f, -0.61901921f, -0.23893178f, 0.10350794f, -0.00533155f, 
    0.01007923f, 0.01727431f, -0.13701351f, 0.04977284f, -0.12480245f, -0.30618989f, 0.04492572f, 0.04217297f, 
    -0.20191777f, 0.16408488f, 0.23292670f, 0.05805206f, 0.22664584f, -0.36187869f, -0.27107495f, -0.12353881f, 
    -0.27065951f, 0.13905287f, -0.04457580f, 0.30231917f, -0.29103506f, -0.18645139f, 0.06091615f, -0.11223751f, 
    0.18577422f, 0.12828006f, -0.06367937f, -0.24483979f, 0.05285094f, 0.15028453f, -0.03675202f, 0.05361316f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05919726f, 0.08942804f, -0.06424551f, 0.07061712f, 0.07011712f, -0.01588580f, 0.05211774f, -0.03295656f, 
    -0.07459678f, -0.03227779f, 0.04474686f, 0.05015502f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
