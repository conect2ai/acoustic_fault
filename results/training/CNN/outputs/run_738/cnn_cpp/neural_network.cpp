#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.74771726f, 0.69007909f, -0.11195998f, -0.52266461f, -0.27785864f, -0.25223655f, 0.71142662f, -0.01868559f, 
    0.27424607f, -0.38573849f, -0.51727200f, -0.04736323f, 0.09404524f, 0.08496701f, -0.01677591f, 0.09300207f, 
    -0.32716653f, -0.16793551f, -0.20226924f, -0.08328187f, 0.14386953f, 0.03600286f, 0.19205405f, 0.17279370f, 
    0.26907298f, 0.89658099f, 0.75693935f, -0.18038040f, 0.68189520f, -0.51613837f, -0.35338685f, 0.32241830f, 
    -0.25015688f, 0.41114032f, 0.20328987f, 0.37398514f, 0.13579506f, -0.07871952f, -0.09003781f, -0.33930355f, 
    0.28978914f, -0.07944947f, 0.29272005f, -0.19259705f, 0.38526639f, -0.08363169f, -0.09385876f, 0.16160201f, 
    0.07870443f, 0.17890093f, -0.28940597f, -0.69778609f, -0.91788429f, -0.43389404f, -0.15512809f, -0.76257229f, 
    -0.12472668f, 0.20163621f, -0.24518360f, 0.17862593f, 0.35179138f, -0.02184696f, 0.08989803f, -0.03738028f, 
    0.07622787f, 0.01787768f, 0.29511166f, 0.01376128f, -0.21901794f, -0.09656135f, 0.02049720f, -0.07316808f, 
    0.22274081f, 0.06928798f, 0.37038970f, 0.63693827f, 0.39477170f, 0.70862603f, 0.83706915f, 0.49062154f, 
    -0.82187229f, 0.31692591f, -0.56210148f, -0.31684458f, 0.32755768f, 0.46478546f, -0.04471241f, -0.28990582f, 
    0.40900293f, -0.04855617f, -0.16218960f, 0.16933009f, 0.34125227f, 0.20484868f, -0.22172928f, -0.01497129f, 
    0.16081251f, 0.28366971f, 0.04349305f, 0.03965700f, 0.52137595f, 0.37149701f, -0.54641235f, 0.12752379f, 
    0.29513180f, 0.09603237f, -0.32465041f, -0.77023959f, -0.32535377f, 0.06827071f, 0.41473007f, -0.15116818f, 
    -0.12079750f, 0.11969536f, -0.09854814f, 0.32664165f, 0.35221329f, 0.22116569f, -0.09798562f, 0.38122457f, 
    0.39636579f, -0.10360247f, -0.29843682f, 0.10575736f, -0.11825377f, -0.60917646f, -0.11443457f, 0.66786194f, 
    0.36770889f, -0.68830979f, -0.00413175f, 0.23524007f, -0.19910006f, -0.44095784f, 0.02313412f, 0.17044537f, 
    0.03775863f, 0.17355989f, -0.07528758f, 0.49553770f, 0.38296548f, -0.63979912f, -0.07299765f, -0.46343371f, 
    -0.36548311f, -0.00367234f, 0.29530680f, 0.03101790f, 0.01826000f, -0.17421986f, 0.52727991f, 0.02251149f, 
    0.58390617f, 0.48570088f, 0.84393883f, 0.32970619f, 0.32130069f, -0.08621477f, -0.83453512f, -0.41128883f, 
    0.23121151f, 0.35408717f, 0.27449682f, 0.27435520f, -0.07250920f, 0.02321227f, 0.34833109f, 0.38140249f, 
    0.20424050f, -0.07039082f, -0.10169075f, 0.12067215f, 0.09211260f, -0.00973238f, 0.04908642f, 0.50053239f, 
    0.46725667f, -0.03491943f, 0.48613414f, 0.64839065f, 0.52405071f, 0.15953369f, 0.23145862f, 0.55869395f, 
    0.57016551f, -0.26325881f, 0.29838955f, -0.21500880f, 0.22055024f, -0.15460920f, -0.32445720f, -0.17485879f, 
    -0.12890320f, -0.11425012f, 0.12610638f, -0.17031871f, 0.03618482f, -0.16075322f, -0.33378753f, 0.03432371f, 
    -0.55761880f, -0.63647592f, -0.60875905f, -0.19948785f, -0.31803027f, 0.32386029f, 0.18669787f, -0.29132393f, 
    0.66659194f, 0.11585962f, -0.27909186f, 0.00516606f, 0.03312774f, 0.17070381f, 0.34213623f, -0.05023304f, 
    0.11923915f, 0.23311663f, 0.11440410f, -0.27836770f, 0.29250991f, -0.08729390f, -0.12032287f, 0.36199442f, 
    0.19366190f, 0.84931469f, 0.48997068f, -0.02512927f, -0.36498594f, -0.55814916f, 0.22411175f, 0.13428079f, 
    -0.17576109f, -0.04353822f, 0.17919093f, 0.32900086f, 0.41566125f, 0.04925044f, 0.01022418f, -0.07941005f, 
    -0.21067952f, -0.16116731f, -0.28032666f, 0.07643323f, 0.15202679f, -0.17804277f, -0.09360465f, -0.02600549f, 
    0.23636501f, 0.05958371f, -0.06088224f, 0.26672882f, -0.60928917f, -0.69566500f, -0.34158480f, -0.20932981f, 
    0.39155716f, 0.71796840f, 0.09410971f, -0.01461994f, -0.41890761f, 0.23075411f, -0.34486267f, -0.34299842f, 
    0.12692143f, -0.23400262f, -0.23631532f, -0.24318069f, -0.14219770f, -0.33726233f, 0.13236129f, 0.34657419f, 
    0.11773724f, 0.11155844f, 0.03391604f, -0.25743511f, 0.02393657f, -0.25511885f, -0.65343791f, -0.08451397f, 
    0.69250476f, 0.22801761f, 0.47139424f, 0.75261927f, 0.61582208f, -0.21708541f, -0.37406924f, -0.26159170f, 
    -0.19906291f, -0.12381230f, 0.03430285f, -0.01655439f, -0.19991332f, 0.38928884f, -0.06670743f, 0.02234773f, 
    0.23216122f, -0.58971411f, -0.03391889f, 0.03605498f, 1.05039978f, 0.46103370f, 0.03133090f, 0.33408129f, 
    0.83063561f, -0.16453154f, -0.29328546f, -0.03511387f, 0.55091870f, -0.07006612f, -0.01487565f, -0.19269517f, 
    0.22803633f, -0.15341492f, 0.16060837f, -0.32708088f, -0.31342903f, -0.19485849f, -0.22222304f, -0.10379454f, 
    0.54783565f, 0.01471943f, 0.08614768f, 0.02814002f, 0.04607238f, 0.51149696f, -0.21968591f, -0.58499640f, 
    -0.80771065f, 0.67926908f, 0.54508144f, -0.75424510f, 0.61070740f, 0.33078453f, -0.03910570f, -0.35691279f, 
    -0.06036857f, -0.33271328f, -0.14692332f, -0.29749888f, 0.17326474f, 0.08418772f, 0.31969282f, 0.22927243f, 
    0.13919461f, -0.15544270f, -0.04941614f, 0.00573095f, 0.28808945f, -0.11748721f, -0.22367020f, 0.34908640f, 
    0.58564615f, -0.74078125f, -0.77779776f, 0.08330128f, -0.61693668f, -0.57262945f, -0.41350546f, 0.03726846f, 
    -0.13899051f, 0.23719266f, -0.31440011f, 0.34457457f, -0.15767464f, -0.36835968f, 0.14957504f, -0.09767850f, 
    -0.21261582f, 0.09883810f, -0.00180919f, 0.07100108f, -0.05621101f, 0.12024274f, 0.23851463f, -1.46824491f, 
    0.24838841f, -0.50936419f, 0.97019088f, -0.41851753f, 0.26196980f, 0.93279260f, -0.28800833f, 0.34285417f, 
    0.09248008f, -0.05693800f, -0.19374649f, 0.14340299f, -0.30056196f, 0.07164771f, -0.01281621f, 0.04892056f, 
    -0.05547561f, -0.11766291f, -0.20836440f, 0.03982759f, 0.06772065f, 0.08202607f, -0.03610321f, -0.08223294f, 
    -0.22683425f, -0.15303682f, 0.45795763f, 0.35248020f, 0.52723324f, -0.24168085f, 0.57177693f, -0.15292671f, 
    0.09708682f, 0.27007851f, 0.27101409f, 0.29772833f, -0.20482320f, -0.25907391f, 0.30404690f, 0.04315484f, 
    0.19994661f, -0.55483633f, 0.13752778f, -0.14684989f, -0.12252863f, -0.38037363f, -0.25341645f, -0.11719349f, 
    -0.03838300f, -0.40677169f, 0.69168109f, -0.31425601f, 0.44944489f, -0.24724308f, -0.08222466f, 0.79779851f, 
    0.03161116f, -0.30721185f, -0.11911267f, -0.00877884f, -0.36405259f, 0.26352122f, 0.08110134f, 0.28852549f, 
    -0.03969666f, 0.13305831f, -0.20784016f, 0.23451200f, -0.05303722f, 0.35089406f, -0.04564670f, 0.00108050f, 
    0.23608041f, 0.30695656f, 0.61041069f, -0.78264505f, -0.38315469f, 0.49797326f, -0.13512564f, -0.79777014f, 
    0.51422936f, -0.28801012f, -0.59286654f, 0.41517994f, 0.38095963f, 0.38091898f, 0.15957707f, -0.07987922f, 
    0.33050227f, -0.43385929f, -0.05257369f, 0.11863316f, -0.01491917f, -0.34843001f, 0.06518639f, -0.05094538f, 
    0.37867317f, 0.01870411f, 0.07149260f, 0.36292374f, -0.66812617f, -0.29106349f, -0.25831965f, -0.64373612f, 
    0.06716435f, 0.46387279f, 0.67381096f, 0.51679051f, -0.07492745f, 0.13771470f, 0.00218760f, -0.40213174f, 
    0.21100253f, -0.28964162f, 0.23554927f, 0.09777296f, -0.22071724f, -0.08127622f, 0.15181623f, -0.03877670f, 
    -0.26557279f, 0.00455593f, -0.29251608f, -0.06919395f, 0.47891983f, -0.16203447f, 0.39349535f, 0.94406444f, 
    -0.64421558f, 0.12217363f, -0.34438807f, 0.42341667f, -0.42615205f, -0.24553283f, -0.07406941f, -0.10126430f, 
    -0.23314796f, -0.05498526f, 0.03770258f, -0.26989245f, 0.31815386f, 0.46754259f, 0.22493027f, -0.24198031f, 
    0.18530557f, -0.00956582f, -0.41258964f, 0.10714670f, -0.27973706f, 0.48509055f, 0.67899281f, 0.17122585f, 
    0.42536771f, -0.00742657f, 0.72184455f, 0.09420861f, -0.16125900f, 0.02121113f, -0.14767495f, 0.41838136f, 
    0.17104739f, -0.05836328f, 0.09101716f, 0.20311226f, 0.47918829f, -0.02516715f, -0.09352606f, 0.01421441f, 
    0.36308643f, -0.17180890f, 0.08267470f, 0.25428089f, -0.25391230f, 0.33655027f, -1.21190608f, 0.83958071f, 
    0.58492780f, -0.31014040f, 0.71175152f, 0.21564128f, -0.22533186f, 0.24031100f, 0.40875730f, -0.71882081f, 
    -0.04282862f, -0.41265431f, 0.09994729f, 0.48426092f, -0.04389101f, -0.07745664f, -0.13378672f, -0.04991967f, 
    -0.06482334f, -0.03075315f, -0.25248647f, -0.25968161f, -0.08152148f, -0.09162760f, 0.04367612f, 0.45801285f, 
    0.77455324f, 0.52505821f, 0.53625447f, -0.13177766f, 0.07336733f, 0.09191384f, -0.16917351f, -0.21420272f, 
    -0.15875129f, 0.25348794f, 0.04757526f, 0.08727453f, 0.16390790f, -0.61464155f, 0.19413641f, 0.19184910f, 
    -0.00168388f, 0.33181497f, -0.46014819f, 0.23933002f, 0.05827976f, -0.29371235f, -0.19769301f, 0.31324553f, 
    -0.36734346f, -0.76021433f, -0.23870371f, -0.06001939f, -0.35967687f, -0.13647270f, -0.17248830f, 0.02365982f, 
    -0.15548004f, 0.34797460f, -0.24237560f, -0.06342586f, -0.29625413f, -0.37785551f, -0.44024378f, 0.09735475f, 
    0.25685990f, 0.30066085f, 0.00715786f, -0.40167004f, -0.01581926f, -0.38622275f, -0.24706767f, 0.26130232f, 
    0.57664311f, 0.01331913f, -0.54696357f, -0.93076718f, 0.72659737f, 0.85516876f, 0.36939698f, 0.65411323f, 
    -0.19337085f, 0.47352290f, -0.75354415f, -0.11281349f, 0.46017253f, -0.33224291f, 0.00692026f, 0.01852587f, 
    -0.01677636f, -0.21341290f, 0.01411276f, -0.11089016f, -0.19266394f, 0.17278855f, -0.06616259f, 0.11420600f, 
    0.05382130f, 0.02091890f, -0.66810608f, -0.28522590f, 0.24505070f, -0.31553364f, -0.01574029f, -0.10048046f, 
    -0.07756492f, -0.61018640f, -0.65949917f, -0.63524604f, -0.46632969f, 0.46749300f, 0.21709064f, 0.51505119f, 
    -0.13493980f, 0.33954763f, -0.05282256f, -0.11074969f, 0.07847690f, -0.31525505f, -0.20021082f, 0.00945482f, 
    0.11901078f, -0.08003620f, 0.31708038f, 0.24405482f, 0.39750007f, 0.54798311f, 0.41735977f, 0.51222497f, 
    0.50523728f, 0.03149171f, -0.06492209f, -0.39182338f, 0.13133909f, -0.10441731f, -0.31689158f, 0.06939841f, 
    -0.50734371f, -0.00625932f, -0.40892479f, -0.41042134f, -0.16620165f, -0.11653271f, -0.24714084f, 0.59090322f, 
    0.19991164f, 0.21768153f, 0.14950587f, 0.14386144f, -0.41911754f, -0.96572351f, 0.03252642f, 0.66345900f, 
    0.32709953f, -0.81334257f, 0.58332878f, 0.45815718f, -0.34853300f, 0.25418001f, 0.21624933f, -0.06492786f, 
    0.14139989f, 0.04872037f, 0.00349478f, -0.02049347f, 0.18035580f, 0.13901126f, 0.23652287f, -0.37052625f, 
    0.09433217f, 0.34699461f, -0.22280091f, 0.03341028f, 0.09761348f, 0.23218124f, 0.14940661f, 0.41903138f, 
    0.09289952f, -0.48376539f, -1.02561462f, -0.45400587f, -0.47078133f, -0.38528711f, -0.35300577f, 0.50048685f, 
    0.28206962f, -0.15807334f, 0.05288677f, -0.38403639f, -0.39319140f, -0.24613503f, -0.37183192f, 0.23816326f, 
    -0.29304329f, 0.13119166f, -0.15324216f, -0.20035732f, 0.27572197f, 0.05006438f, 1.14602518f, 0.80615717f, 
    0.40322009f, -0.30452415f, -0.41928181f, -0.46783558f, -0.54166996f, -0.15318723f, 0.14223798f, 0.35314515f, 
    -0.01002441f, -0.00371717f, 0.19892696f, 0.10930318f, -0.04855564f, -0.06173406f, -0.12245466f, -0.08617976f, 
    -0.00740808f, 0.14526941f, -0.07161827f, 0.48866147f, -0.09298512f, -0.01040702f, 0.01199752f, 0.14533773f, 
    0.24244747f, 0.49731746f, 0.95538920f, 0.43769047f, 0.06340368f, 0.43519536f, 0.03213646f, 0.33601192f, 
    0.26849958f, -0.10761008f, -0.31279075f, -0.22964497f, -0.18186614f, -0.08994550f, 0.13892227f, -0.02385464f, 
    -0.36550945f, -0.08295762f, 0.15697511f, 0.17672423f, 0.40827858f, -0.34452048f, 0.14470239f, -0.15890820f, 
    0.52665031f, 0.32418054f, 0.34095791f, 0.68580139f, 0.65128982f, 0.30313340f, -0.47024474f, -0.00872963f, 
    -0.23281458f, -0.06136176f, -0.35345814f, -0.24393269f, -0.49891642f, -0.03073435f, 0.04426897f, 0.37841702f, 
    0.46543539f, 0.00726155f, -0.07915360f, 0.07408961f, 0.19143566f, -0.19762418f, 0.23297033f, 0.21094818f, 
    0.50852805f, -0.48538539f, -0.74680722f, -0.70792925f, -0.53561789f, 0.12005571f, -0.13343108f, 0.63531506f, 
    0.23449470f, 0.40349445f, 0.33966517f, -0.11815684f, -0.11410537f, -0.07133896f, -0.25712600f, -0.38736454f, 
    -0.01442216f, -0.02265475f, 0.17324370f, -0.08593518f, -0.01103894f, -0.11413515f, -0.12181076f, -0.10673442f, 
    0.01175772f, 0.02719125f, -0.12124602f, 0.49758849f, 0.66759253f, -0.37747326f, -0.44355497f, -0.43214491f, 
    0.83050615f, -0.56078857f, -0.58123493f, 0.03473802f, 0.26602507f, 0.50326145f, -0.26087737f, -0.21389653f, 
    -0.22946131f, -0.13505305f, -0.35000515f, 0.06643008f, 0.00133643f, 0.16866772f, -0.09867162f, 0.23327777f, 
    0.41888142f, 0.11146674f, 0.34307915f, -1.07798302f, 0.53207934f, 0.25146788f, -0.74600083f, -0.21575972f, 
    0.45851350f, 0.55892599f, 0.06842890f, 0.42362171f, 0.58830452f, 0.19064009f, 0.21764052f, -0.10468233f, 
    -0.11005112f, 0.07525218f, 0.21622328f, 0.24234872f, 0.07615008f, 0.28064370f, -0.02027484f, -0.02722664f, 
    0.18913722f, 0.04474991f, 0.05363599f, 0.30445746f, -0.51030439f, -0.27726567f, -0.20873107f, 0.13320428f, 
    -0.01140014f, -0.65419489f, -0.13105911f, -0.36249781f, -0.33483809f, 0.60958099f, 0.14696123f, 0.42653584f, 
    -0.02414123f, 0.10551230f, -0.23146404f, 0.15047237f, -0.01828594f, 0.26770258f, -0.09394392f, 0.26517567f, 
    -0.34503931f, -0.42503005f, -0.18921173f, -0.35947871f, 0.26158649f, 0.71773636f, 0.64579457f, 0.45100531f, 
    0.26865792f, 0.45989987f, 0.81737709f, 0.26032954f, 0.08360625f, 0.08587296f, -0.06925729f, -0.46641201f, 
    0.04364281f, 0.02426929f, 0.04834621f, 0.26195720f, 0.15722460f, 0.21128523f, -0.02969674f, 0.24019566f, 
    0.01299081f, -0.17697179f, 0.19592594f, -0.13972206f, -0.40546986f, 0.23033488f, -1.04449093f, 0.58584839f, 
    0.75684702f, 0.13589767f, 0.07392529f, 0.30722311f, -0.12004548f, 0.63523656f, 0.02434751f, -0.10089485f, 
    -0.44736421f, -0.04820670f, -0.42324144f, -0.38249925f, -0.27470919f, -0.21924718f, -0.02650941f, -0.46400854f, 
    -0.09802692f, -0.12892298f, -0.02543404f, 0.17736833f, 0.02206000f, 0.24965134f, -0.28215098f, 0.63547820f, 
    0.56114626f, 0.18154828f, 0.44469610f, -0.01808399f, 0.46517831f, -0.36053824f, -0.25107756f, 0.51174819f, 
    0.55164844f, -0.47986817f, -0.21818154f, 0.13986914f, -0.03814094f, -0.46966481f, -0.25923464f, 0.13420245f, 
    0.10572683f, 0.16392386f, -0.14115693f, 0.15641344f, 0.08351316f, -0.32116336f, 0.18474804f, 0.32295650f, 
    -0.17986649f, -0.55025882f, -0.37201223f, -0.66010869f, -0.31333944f, 0.19600771f, -0.54280931f, -0.29110104f, 
    -0.51952595f, -0.08272865f, 0.49603933f, 0.13485561f, -0.04902994f, 0.05665461f, -0.09125245f, -0.07427227f, 
    0.06621268f, -0.19701794f, 0.08335374f, -0.01317572f, 0.21039805f, 0.24216877f, -0.12714291f, 0.22551966f, 
    0.03887892f, -0.27382705f, -0.40995485f, -0.32703629f, 0.44143924f, 0.54045808f, 0.57528538f, 0.65789890f, 
    0.51482636f, 0.31391037f, 0.08374780f, 0.09606800f, -0.25231686f, 0.04673820f, 0.42587191f, 0.43923199f, 
    0.40178269f, 0.09050156f, -0.35468528f, -0.14082372f, 0.09397324f, 0.24841940f, -0.02527271f, -0.31298056f, 
    0.11269881f, 0.22070916f, 0.40607959f, -0.41191575f, -0.73779565f, -0.65800899f, 0.03052734f, 0.53184521f, 
    -0.53757721f, -0.28600264f, -0.29993969f, 0.19583718f, -0.62093002f, 0.07396702f, 0.26816660f, 0.09782168f, 
    0.03800497f, -0.19424801f, 0.17588681f, -0.10124388f, -0.05244884f, -0.00358079f, -0.11151259f, 0.24670519f, 
    -0.16070335f, -0.15775146f, 0.15172398f, 0.75589329f, 0.44157627f, 0.39598337f, 0.25338581f, -0.16282037f, 
    0.04065368f, -0.03074981f, 0.23085217f, 0.44306555f, 0.69181246f, -0.56426573f, 0.53515714f, -0.20422786f, 
    -0.44035727f, -0.11312851f, 0.16979155f, -0.25412264f, -0.34406555f, -0.07634341f, 0.11496168f, -0.12300865f, 
    -0.13040616f, 0.23361447f, -0.23370880f, -0.06351360f, -0.05600729f, -0.31330428f, 0.19965099f, 0.21773063f, 
    -0.08540884f, -0.81950700f, -0.13109863f, -0.64637202f, -0.10242629f, 0.16987523f, -0.29859820f, 0.14524767f, 
    -0.43583459f, -0.16438100f, -0.38274357f, -0.54312670f, 0.02041030f, 0.23399517f, 0.08109478f, -0.11636846f, 
    0.29831558f, 0.09156084f, -0.13311560f, -0.13012971f, -0.21027045f, 0.66963315f, -0.05789484f, 0.85762280f, 
    0.15687282f, -0.43708616f, 0.24969104f, -0.67535084f, 0.32034215f, 0.25353301f, 0.13609777f, 0.55986786f, 
    0.04257254f, -0.06773800f, -0.09048007f, -0.09656296f, -0.33757392f, -0.06961717f, -0.03071008f, -0.20372218f, 
    0.09375969f, 0.17867543f, 0.16771290f, 0.32556781f, 0.32164684f, 0.02218935f, 0.68333954f, 0.21913974f, 
    0.60648751f, 0.22248419f, -0.08835690f, 0.39632657f, -0.43262133f, -0.07189496f, -0.20071913f, -0.05242034f, 
    0.39224193f, -0.18734202f, -0.00370828f, 0.55006528f, -0.48957503f, 0.00967270f, 0.26051319f, 0.11535810f, 
    -0.27160218f, 0.19459121f, -0.59899157f, -0.12081058f, 0.41976494f, -0.42309982f, -0.00305862f, -0.77554655f, 
    -0.82986140f, 0.11581875f, 0.14424236f, -0.69622308f, 0.04381805f, -0.05659933f, -0.51267636f, 0.02957479f, 
    -0.06487334f, 0.46332076f, 0.21429241f, -0.19123632f, 0.74523276f, 0.29283407f, 0.22266828f, -0.30350906f, 
    -0.02864041f, 0.11072603f, 0.04534115f, 0.16562544f, 0.09170079f, -0.12712459f, -0.06662048f, 0.30567408f, 
    -0.51449865f, 0.73343575f, -0.61593735f, -0.92018914f, -0.31500655f, 0.06407692f, 0.13491438f, 0.34615150f, 
    0.52265191f, 0.30850741f, -0.29736301f, 0.17278585f, 0.21789494f, -0.18217097f, -0.40693930f, 0.29345870f, 
    -0.10730400f, 0.34892669f, 0.29191831f, -0.08802482f, -0.42546025f, 0.05835175f, -0.11343188f, -0.24541135f, 
    -0.16817261f, -0.51070696f, -0.73569214f, -0.24083102f, 0.18649435f, -0.23959948f, -0.56199068f, 0.39049298f, 
    0.80586022f, -0.81141448f, -0.00874909f, 0.31110859f, 0.10581493f, -0.07007473f, -0.15609570f, 0.06627926f, 
    -0.31647378f, -0.02554143f, 0.26911154f, -0.10818879f, -0.02730281f, -0.15587148f, -0.45396468f, 0.30353081f, 
    -0.00856253f, -0.00056751f, 1.00057161f, 0.08547269f, -0.94011247f, -0.42653733f, -0.48449826f, 0.03295684f, 
    0.45478565f, -0.22068885f, -0.01557417f, 0.25657257f, -0.06870422f, -0.07296313f, 0.01387502f, 0.07211810f, 
    -0.05311524f, 0.01010147f, -0.25237495f, -0.21775004f, -0.13288236f, -0.03055144f, -0.19478655f, -0.18754579f, 
    -0.32334620f, 0.02768469f, 0.07777593f, 0.57744062f, 0.24040616f, 0.33954436f, 0.54846263f, 0.60920364f, 
    -0.56396037f, -0.85907459f, -0.43987054f, -0.47349572f, -0.21253127f, 0.30147645f, 0.41940010f, 0.19622958f, 
    0.38487303f, 0.10009445f, 0.16677491f, 0.01905927f, -0.16635604f, 0.06629153f, 0.08951970f, -0.14839530f, 
    0.06532533f, 0.15447594f, 0.19073455f, 0.10032793f, -0.12185909f, 0.60203779f, 0.81733578f, -0.37798557f, 
    -0.25152496f, -0.86525881f, 0.64501905f, 0.27030885f, -0.36522159f, 0.11100531f, -0.13183810f, 0.45934650f, 
    -0.17223039f, -0.16349788f, -0.36736891f, 0.25038895f, -0.07204198f, 0.12046070f, -0.10621189f, 0.04790841f, 
    -0.03430130f, 0.08846534f, -0.11858768f, -0.36222184f, -0.35641986f, -0.65924019f, -0.36233863f, -0.38591766f, 
    -0.22577256f, -0.45547670f, 0.48041216f, -0.11572066f, 0.35103595f, 0.08672713f, 0.01171953f, 0.07906487f, 
    0.05734153f, -0.13328029f, 0.18799946f, 0.11747818f, -0.10887337f, 0.05927314f, -0.35823828f, -0.45211828f, 
    0.22204654f, -0.29926181f, 0.31160834f, 0.37464738f, 0.48695534f, 0.15319784f, -0.56543112f, -1.36543274f, 
    -0.34137255f, 0.30957466f, 0.13824815f, -0.25615820f, 1.15832627f, 0.55506426f, -0.18846790f, 0.15125297f, 
    -0.07261511f, -0.13992839f, -0.17855959f, 0.11984802f, 0.07401354f, -0.24799821f, -0.02470632f, -0.21009903f, 
    -0.00952863f, -0.02759547f, 0.10939819f, -0.05984895f, 0.09649454f, 0.00148389f, -0.11025336f, 0.88112509f, 
    0.58997077f, -0.21048342f, 0.51897347f, 0.70172417f, 0.18363227f, 0.02904386f, 0.52206582f, 0.54953808f, 
    -0.01170739f, -0.42331728f, -0.23363850f, -0.04560636f, -0.38365921f, -0.09804443f, 0.17147943f, -0.12622961f, 
    -0.13514067f, -0.15228677f, 0.09804114f, 0.05405548f, -0.24101532f, -0.19467816f, -0.19883408f, -0.30054882f, 
    -0.51174039f, -0.20141537f, -0.60988665f, -0.56838179f, -0.15037575f, 0.38048807f, -0.00941648f, -0.19324978f, 
    -0.38077781f, 0.26045784f, 0.21605229f, -0.18539517f, 0.24642447f, -0.31065938f, 0.11046816f, -0.12776884f, 
    -0.27347058f, 0.31436861f, 0.00448699f, -0.33218241f, 0.15419564f, -0.15115771f, 0.19173717f, 0.31134352f, 
    -0.10492174f, 1.19266927f, -0.70765781f, 0.41957176f, -0.64196479f, -0.40393144f, 0.18943095f, 0.11176711f, 
    0.08749592f, 0.19768429f, -0.40328589f, 0.09901450f, 0.12940581f, 0.00101685f, 0.10262325f, -0.31154910f, 
    0.06996280f, -0.09287027f, -0.13809048f, -0.10689156f, 0.02441968f, -0.17775732f, 0.13176161f, 0.23190215f, 
    0.09741201f, -0.08014557f, -0.92509222f, 0.49906942f, 0.28906044f, -0.28989455f, -0.82233059f, 0.68305773f, 
    0.10576664f, -0.40607840f, 0.04780971f, 0.51021433f, -0.22025782f, -0.04338431f, -0.25247967f, 0.37134233f, 
    0.24394035f, -0.12872712f, -0.03411311f, -0.06908555f, 0.22136442f, -0.03038125f, -0.02480229f, -0.03478697f, 
    0.16086139f, -0.00600920f, -0.03141148f, 0.50709927f, 0.53697509f, -0.20133916f, -0.83935475f, -0.68240869f, 
    0.23193593f, -0.23182222f, -0.16884927f, -0.26086885f, 0.01738326f, -0.24572149f, 0.18441920f, -0.36584392f, 
    -0.12370665f, 0.15550761f, -0.00167600f, 0.32802749f, 0.12578586f, 0.08420108f, 0.13119793f, 0.35331818f, 
    -0.07321320f, -0.31799707f, 0.32728979f, -0.24051228f, -0.08744419f, 0.81017709f, -0.15792389f, 0.48869050f, 
    -0.65874439f, -0.56477064f, -0.10448370f, -0.63307649f, 0.35969570f, -0.28298131f, 0.34866428f, -0.14899077f, 
    0.31937832f, 0.03533450f, -0.12504990f, -0.01502142f, 0.07431401f, 0.25492096f, 0.26483095f, -0.04720421f, 
    0.07343069f, -0.09270225f, -0.25892696f, -0.17812318f, -0.19649172f, 0.53454387f, 0.19215864f, -0.45383245f, 
    -0.67417490f, -0.07776063f, 0.27918097f, 0.17898245f, 0.41565120f, -0.18422863f, 0.32040331f, -0.01305361f, 
    0.38029307f, -0.19670454f, 0.11481339f, 0.27559665f, -0.05280444f, -0.02903661f, -0.42541677f, 0.22800490f, 
    -0.09804033f, -0.01118177f, 0.22199456f, -0.17400302f, 0.31880248f, 0.44706807f, 0.33095944f, -0.70796967f, 
    -0.43419710f, 0.13723549f, 0.04469911f, 0.47769988f, 0.10318323f, -0.35947880f, 0.19868734f, -0.10753008f, 
    0.17469378f, 0.36113635f, -0.52860165f, 0.31028092f, 0.40254474f, 0.12665014f, 0.13721563f, 0.24632736f, 
    0.28964806f, 0.48248920f, -0.31952637f, -0.03920548f, 0.10937811f, -0.10115135f, -0.17190772f, 0.76117933f, 
    -0.04726938f, 0.20160915f, -0.22380896f, -0.34204736f, 0.56209302f, -0.45190302f, 0.09627241f, 0.33419022f, 
    0.43757242f, 0.34134880f, 0.29805353f, -0.28323382f, 0.09430616f, -0.17904808f, 0.12840270f, -0.05122734f, 
    0.21288185f, -0.01313798f, 0.26661462f, 0.30062023f, 0.13818952f, -0.00680855f, 0.21274507f, 0.31322163f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01893200f, 0.30548140f, 0.36057520f, 0.00000681f, 0.12837380f, -0.03613392f, 0.17249726f, -0.00417681f, 
    0.05300245f, -0.00058184f, 0.17287475f, 0.02980692f, 0.10737632f, 0.11090384f, 0.19840771f, 0.04477520f, 
    -0.06045673f, 0.11029735f, 0.23546144f, 0.12657829f, 0.08854060f, 0.18729033f, 0.17099629f, -0.02275038f, 
    0.18332088f, 0.08826541f, 0.33560669f, 0.26863357f, 0.20571539f, 0.24671546f, 0.23797828f, 0.09346698f, 
    -0.00235233f, 0.07936214f, 0.08471304f, 0.06749586f, 0.21705787f, 0.30804074f, 0.01752347f, 0.19144508f, 
    0.39025134f, 0.14720398f, 0.22499199f, 0.09267603f, 0.23518863f, 0.22112183f, 0.03732872f, 0.31562519f, 
    0.16759767f, 0.18306629f, 0.03512903f, 0.03865652f, 0.09186222f, -0.04788534f, 0.26437825f, 0.15802859f, 
    0.30403015f, 0.15747702f, 0.04658525f, -0.01892314f, 0.18920748f, 0.27052480f, 0.18399976f, 0.16680339f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.26020661f, 0.02548424f, 0.01307940f, -0.31963316f, -0.06480221f, 0.05695671f, 0.07028987f, 0.00110376f, 
    -0.02393437f, -0.00228694f, -0.01012173f, 0.01309115f, -0.03540050f, 0.07607599f, -0.06047926f, 0.12429400f, 
    -0.14318377f, -0.05684010f, -0.11297212f, 0.04053218f, 0.06449921f, 0.13145995f, 0.01841116f, -0.08309364f, 
    -0.40520859f, -0.14652675f, -0.09461377f, -0.04336099f, 0.02888012f, 0.00234624f, 0.00106601f, 0.00917329f, 
    -0.05563921f, -0.00686172f, -0.01930657f, -0.03736001f, 0.20649381f, 0.04252055f, -0.14384286f, 0.19643334f, 
    -0.13811669f, -0.15812530f, -0.01494262f, 0.00952960f, -0.05801187f, 0.00708294f, -0.04617316f, -0.04044164f, 
    0.08074626f, -0.02206727f, 0.15685062f, 0.03035899f, -0.11619924f, -0.00905924f, 0.08303854f, 0.02729859f, 
    0.05714019f, 0.03934830f, 0.03934490f, -0.00397100f, -0.09045536f, 0.15553188f, -0.04337140f, 0.15437815f, 
    -0.00303545f, 0.13221712f, 0.03120631f, -0.07621805f, -0.05353178f, 0.13141771f, 0.11397578f, -0.05685280f, 
    -0.03775376f, -0.01289101f, -0.15207009f, -0.06414393f, -0.17155178f, -0.02704250f, 0.07200041f, 0.03841959f, 
    0.01063839f, 0.08333762f, 0.01186937f, -0.00995854f, 0.07473207f, -0.17437302f, 0.00538228f, 0.14290851f, 
    -0.09775939f, 0.06404015f, -0.02171312f, 0.00728294f, 0.02057016f, 0.09251582f, -0.05347952f, 0.02617521f, 
    0.10523395f, 0.07051234f, -0.12607409f, -0.18656260f, 0.14749077f, -0.00102196f, 0.03734756f, 0.07858665f, 
    0.10805371f, -0.09708484f, -0.05812811f, 0.03387498f, -0.11769841f, -0.03441208f, 0.07649490f, -0.13372463f, 
    -0.00485477f, 0.03814550f, 0.00049390f, 0.15004586f, 0.00685231f, -0.05009278f, 0.02814158f, 0.04939253f, 
    -0.05222665f, 0.05595158f, -0.05242123f, -0.28671369f, 0.02213471f, -0.06409794f, -0.01990077f, -0.04314028f, 
    0.01356920f, 0.01115496f, -0.03420383f, 0.03803704f, 0.26564720f, 0.12677519f, 0.03252143f, -0.09899984f, 
    0.00915361f, 0.01769895f, 0.10497957f, -0.13384648f, -0.07550640f, 0.05620359f, 0.01233133f, 0.12285066f, 
    0.21721867f, 0.05430673f, 0.07953515f, -0.05141010f, 0.00354796f, -0.04347446f, -0.00802702f, 0.02455202f, 
    -0.09926702f, 0.03624658f, -0.00078894f, 0.00439710f, 0.27405310f, -0.01103370f, 0.14084147f, -0.15546072f, 
    0.03240318f, 0.09537409f, 0.08302525f, -0.03193048f, -0.09317764f, 0.05647240f, -0.05805752f, 0.03229233f, 
    -0.46108702f, 0.23300579f, 0.11783314f, -0.03474853f, 0.04559723f, 0.01031831f, 0.06058791f, 0.01326623f, 
    -0.12486070f, -0.01653816f, -0.09557069f, 0.10592104f, 0.70795298f, 0.28753644f, 0.00469990f, 0.02401456f, 
    -0.00344607f, 0.10062239f, -0.11610591f, -0.04959404f, 0.06121118f, 0.02846931f, -0.10230746f, -0.04794233f, 
    -0.03865983f, -0.12912257f, 0.03892181f, 0.13372335f, -0.08037485f, 0.03539932f, 0.04411625f, -0.02944080f, 
    -0.01596147f, 0.03842954f, -0.04711451f, 0.06715427f, 0.05196314f, 0.14283101f, 0.06817159f, -0.15273632f, 
    -0.14973202f, -0.01027029f, -0.05306961f, -0.05132018f, 0.00064482f, -0.07586860f, 0.02291740f, 0.08247533f, 
    -0.04365409f, -0.15327744f, 0.09336840f, 0.18003675f, -0.05846060f, -0.13957371f, -0.05260068f, -0.05718495f, 
    0.04113770f, 0.10236981f, -0.09722261f, 0.01555053f, 0.01296827f, 0.11931273f, -0.17872632f, -0.16587061f, 
    -0.02327233f, 0.07424290f, 0.10397875f, -0.07798608f, 0.02530144f, -0.02881031f, -0.04543570f, -0.09436019f, 
    -0.00154294f, 0.00828832f, -0.14279185f, 0.26505363f, 0.02176347f, 0.00339861f, 0.00060852f, -0.05353663f, 
    -0.01912567f, -0.05932723f, -0.00683251f, -0.00417081f, 0.03365031f, -0.02874595f, -0.05793032f, -0.07735988f, 
    -0.15499222f, -0.00452817f, -0.04583105f, 0.12006684f, 0.03748407f, -0.00630977f, 0.00025340f, 0.02278392f, 
    -0.32942161f, 0.05005389f, 0.06740046f, -0.02702446f, -0.06673328f, -0.04562028f, 0.04033634f, 0.05194621f, 
    0.09324262f, -0.04226273f, 0.05503603f, 0.05630204f, 0.03648216f, 0.15329820f, -0.21772560f, -0.01796819f, 
    -0.01103508f, 0.02816097f, 0.03481317f, -0.01815623f, -0.08308475f, -0.05282051f, -0.03836428f, -0.09023833f, 
    -0.00148851f, -0.07663373f, -0.13479395f, 0.04352093f, -0.00998710f, 0.05394805f, -0.09422827f, 0.05147110f, 
    0.02469644f, 0.05730771f, -0.16535328f, 0.03776356f, -0.38066134f, 0.17659001f, -0.10993820f, 0.01171664f, 
    0.05325044f, -0.00748392f, 0.02212626f, -0.03184883f, -0.01285514f, -0.06060503f, 0.11493381f, -0.17638925f, 
    -0.47266281f, -0.03658705f, 0.14443882f, 0.04205909f, 0.00755674f, 0.07304955f, -0.03616334f, 0.03780670f, 
    0.00266092f, 0.06565138f, -0.08324510f, -0.08876348f, 0.04463154f, -0.01364151f, 0.04891150f, 0.08777673f, 
    -0.15386787f, -0.15471563f, -0.00497799f, -0.08268558f, -0.08844259f, -0.02190263f, -0.06246013f, 0.06785563f, 
    -0.08472455f, 0.14109965f, -0.12664886f, 0.21646015f, 0.00551773f, 0.00915235f, 0.02847422f, 0.03645060f, 
    -0.07358879f, -0.08677462f, -0.12629417f, 0.03022619f, -0.06798845f, -0.03350526f, 0.05301869f, 0.13073495f, 
    -0.00959830f, 0.01995539f, 0.02356670f, -0.07512742f, 0.06014046f, 0.00215576f, 0.04549154f, 0.05212262f, 
    0.02952069f, 0.06062133f, -0.01859927f, -0.26297218f, 0.01433006f, -0.08625764f, -0.07996839f, 0.04357175f, 
    -0.04916073f, -0.02756789f, -0.00403344f, 0.02980182f, -0.00163825f, -0.00729008f, 0.00086789f, 0.24246946f, 
    -0.17718662f, 0.07279821f, 0.00758789f, -0.00086912f, -0.07632478f, 0.02178604f, -0.02573759f, 0.01175832f, 
    0.07293051f, -0.10846850f, 0.02489933f, 0.14664765f, 0.07621954f, -0.06284327f, 0.02099986f, 0.09592891f, 
    -0.01513410f, -0.00679393f, 0.05714606f, -0.08708833f, -0.07814041f, 0.28984734f, 0.02383622f, -0.25681970f, 
    0.00562277f, 0.01393805f, 0.06801533f, 0.05165391f, -0.00886370f, 0.03134508f, -0.01818203f, 0.05701737f, 
    -0.14091198f, -0.01332398f, 0.27002460f, -0.00498871f, 0.06148789f, 0.10589808f, -0.06934077f, 0.08635699f, 
    -0.00482213f, 0.05684695f, -0.00248717f, -0.05963831f, 0.34212995f, 0.10863125f, 0.13922846f, -0.14175077f, 
    -0.00532411f, 0.02529369f, 0.00093476f, -0.07321601f, 0.01608990f, -0.03767538f, -0.06920467f, 0.03686220f, 
    -0.07726713f, -0.15678866f, -0.01711006f, 0.06312586f, -0.07862362f, -0.03410634f, -0.01327104f, 0.01067212f, 
    0.01692112f, 0.09044520f, -0.04201584f, 0.02153027f, 0.06942136f, -0.10650112f, -0.08794244f, 0.00350770f, 
    -0.12449447f, -0.10703646f, -0.02079447f, 0.05580334f, 0.03180356f, 0.03327830f, -0.04510211f, 0.08373174f, 
    -0.25478613f, 0.09376280f, 0.19316861f, 0.19851881f, -0.03815078f, -0.05160384f, 0.03769787f, -0.12461193f, 
    -0.05694606f, -0.07450455f, 0.02738906f, -0.01925589f, 0.14497787f, -0.03219530f, -0.05595566f, 0.15098469f, 
    0.00369670f, -0.07301290f, -0.04471543f, -0.08972208f, -0.02627930f, 0.04995679f, -0.05429723f, 0.14556935f, 
    -0.29796621f, -0.36780068f, 0.06010355f, -0.00342122f, -0.04893435f, 0.00659549f, 0.09553927f, 0.00701988f, 
    -0.05470819f, -0.01018869f, 0.05571234f, 0.05258381f, -0.08153600f, 0.04843105f, -0.00555938f, 0.09819756f, 
    0.03082607f, 0.06337753f, -0.07845145f, -0.07660522f, 0.07772354f, 0.04364442f, -0.03037445f, 0.03677493f, 
    0.20445599f, -0.32970273f, 0.12193975f, -0.34072948f, 0.00899055f, -0.08498827f, 0.07878966f, -0.05489114f, 
    -0.15285203f, -0.01786563f, 0.06972887f, 0.07993230f, 0.13522999f, -0.07890254f, -0.18928859f, 0.09524659f, 
    -0.07629251f, -0.17273983f, -0.11519764f, 0.03991376f, 0.02600598f, -0.00621397f, 0.05602384f, -0.04318340f, 
    0.10248342f, -0.26097530f, -0.00690580f, 0.09431180f, -0.02611901f, -0.08661412f, 0.00096402f, -0.04886716f, 
    -0.03026503f, 0.08167037f, -0.09475719f, 0.02659949f, 0.20159402f, -0.10552858f, -0.09278832f, 0.11613080f, 
    -0.05757834f, -0.01977341f, 0.00539296f, -0.09568898f, -0.03248604f, -0.04584297f, -0.10798490f, -0.02338834f, 
    0.06694120f, 0.02438325f, -0.03644708f, -0.00381948f, -0.20606019f, -0.04659941f, -0.01193869f, 0.09356383f, 
    -0.03064935f, 0.06078717f, -0.19785358f, -0.02177775f, -0.24145953f, -0.06420864f, -0.07650173f, 0.11080132f, 
    -0.14454058f, 0.00187123f, -0.04148614f, 0.03924092f, 0.06880877f, 0.00882518f, -0.01380895f, 0.01403949f, 
    0.17742404f, 0.10418749f, -0.12882246f, -0.44006407f, 0.05953938f, -0.08280294f, 0.03214484f, -0.15101111f, 
    0.02001642f, -0.07798558f, -0.06311605f, -0.00087626f, -0.42366931f, 0.06195812f, -0.08454090f, 0.03218140f, 
    0.03201610f, 0.03489995f, 0.00768394f, 0.00690064f, 0.16001752f, 0.02419154f, 0.02469965f, 0.05867274f, 
    -0.17669040f, -0.19220407f, 0.05295081f, -0.20121032f, -0.05667575f, -0.17219988f, -0.01295214f, 0.08265977f, 
    0.01398564f, -0.00852203f, 0.06188013f, 0.03197946f, 0.20937997f, -0.00086451f, 0.11856216f, 0.10421221f, 
    -0.09810807f, -0.03597889f, -0.05045033f, 0.10904600f, 0.01102083f, -0.02479591f, -0.01193733f, -0.01073932f, 
    -0.23391347f, 0.05699729f, 0.00161445f, 0.03717300f, -0.00592772f, -0.01628499f, -0.05529619f, -0.02848105f, 
    0.02284794f, -0.04148306f, 0.13152191f, -0.05231902f, 0.15598068f, 0.02205146f, -0.02722830f, -0.16318788f, 
    -0.06583942f, 0.11072031f, 0.02402907f, 0.00881240f, -0.11985615f, 0.00135976f, -0.03015427f, 0.05155357f, 
    -0.20783593f, 0.19285123f, -0.08801021f, 0.00141422f, 0.01043761f, 0.03064478f, -0.04319283f, 0.01757769f, 
    0.00621394f, -0.04869131f, -0.02151328f, -0.00897689f, 0.12402055f, 0.05219434f, 0.09337673f, 0.13539298f, 
    -0.11289211f, 0.04164990f, 0.05279437f, 0.01429329f, -0.02263318f, 0.04714001f, -0.02568962f, 0.00969335f, 
    0.11791588f, -0.12258422f, 0.08330664f, -0.19688062f, 0.05075219f, 0.03525925f, 0.00675726f, 0.06741206f, 
    0.00942631f, 0.02795127f, -0.05023060f, -0.02295922f, 0.05119510f, 0.08295111f, 0.10453293f, -0.06589478f, 
    -0.04546555f, -0.06023214f, -0.10402221f, -0.00588645f, -0.11781256f, 0.09998626f, -0.04598130f, -0.13487530f, 
    0.29255170f, 0.09307968f, 0.00485655f, 0.05424189f, 0.01141137f, -0.04786047f, 0.05293494f, -0.09447667f, 
    0.07961184f, 0.02576795f, 0.00226648f, -0.01142631f, -0.16380213f, 0.23110469f, 0.12715520f, -0.39530802f, 
    -0.14721523f, 0.02958786f, -0.07064053f, -0.03781746f, -0.16966003f, -0.05566975f, -0.00305408f, 0.03350963f, 
    -0.08795114f, 0.09682788f, -0.04689134f, -0.01621656f, -0.00417357f, 0.01194503f, 0.00422183f, 0.01614915f, 
    -0.03034501f, -0.04897653f, 0.03880947f, -0.00967221f, 0.02897192f, -0.09632558f, 0.03119148f, -0.35954836f, 
    0.02253506f, -0.04588551f, 0.06926171f, -0.04592969f, -0.05328664f, 0.05751872f, 0.02446686f, 0.04514755f, 
    -0.09185279f, -0.08714850f, 0.12997386f, -0.00906329f, -0.07003687f, 0.00517116f, 0.04170183f, -0.13608386f, 
    0.08241565f, -0.11648813f, 0.06859993f, -0.06557419f, 0.18926732f, -0.17671578f, -0.05247150f, 0.00649248f, 
    0.02437547f, -0.02687491f, -0.00934733f, -0.00652174f, -0.00999015f, -0.03055974f, -0.00833975f, 0.02286806f, 
    -0.35284618f, -0.16436678f, -0.08490803f, -0.33341137f, 0.04957747f, -0.00372422f, 0.00153710f, 0.13598254f, 
    -0.02767851f, -0.11162242f, -0.05744210f, 0.08479851f, 0.32198235f, -0.08266102f, -0.06512967f, 0.13607830f, 
    -0.05054830f, -0.09469314f, 0.08791517f, -0.00304849f, -0.06980457f, -0.10708090f, -0.03879456f, 0.17537385f, 
    0.19916745f, -0.00948572f, -0.05121413f, 0.03474803f, 0.04577878f, 0.04094598f, -0.05656338f, 0.05262378f, 
    0.05544228f, -0.05850823f, 0.09113546f, 0.04729345f, 0.19656123f, -0.06185710f, 0.00819529f, 0.12331270f, 
    -0.09092776f, 0.01446464f, 0.03589481f, -0.00199868f, 0.12549719f, -0.04686458f, 0.00834003f, 0.02358786f, 
    0.03942329f, -0.15541011f, -0.03835861f, -0.24118909f, -0.10167542f, -0.01194569f, -0.10945152f, -0.08723053f, 
    -0.02138514f, -0.01958380f, -0.01234962f, 0.02511193f, -0.22604051f, -0.01720245f, -0.11783223f, -0.02850752f, 
    -0.03752637f, 0.08298495f, 0.09341788f, 0.01107914f, -0.04531996f, -0.32726258f, -0.13042559f, 0.04130891f, 
    0.04618740f, 0.14373162f, 0.04800561f, 0.06630403f, -0.06257246f, -0.00444262f, -0.03261321f, 0.07776626f, 
    0.00541647f, -0.00020621f, 0.08973666f, -0.00492069f, 0.23382373f, -0.00664294f, 0.05081201f, 0.02161332f, 
    0.03959659f, -0.03094066f, 0.06163232f, -0.02000226f, 0.07827462f, -0.00563804f, -0.00813732f, -0.06065510f, 
    0.10612255f, 0.02742851f, -0.08588638f, -0.02605342f, 0.04247010f, -0.03460256f, 0.04045710f, 0.06621446f, 
    0.02412798f, -0.02635199f, 0.02893682f, 0.08819494f, 0.21644829f, -0.01566888f, 0.04409077f, -0.04055283f, 
    -0.09705139f, -0.01191957f, -0.01184241f, -0.14007734f, -0.07912364f, 0.04567625f, -0.02044584f, 0.02579531f, 
    0.07094719f, -0.09487892f, 0.01880003f, -0.26587519f, 0.11265184f, 0.03612117f, -0.03511761f, -0.00642365f, 
    0.06164916f, -0.00871968f, -0.08478517f, -0.04449081f, -0.09069953f, -0.00869669f, 0.04777634f, -0.04710541f, 
    0.12569194f, -0.14250107f, -0.12029701f, 0.01002453f, 0.09792228f, 0.06917740f, -0.01405267f, -0.03530805f, 
    0.08784129f, -0.07481935f, 0.13583557f, 0.28219256f, -0.07242785f, -0.01613346f, 0.04805961f, 0.06255182f, 
    -0.03778492f, -0.07121736f, -0.21579240f, 0.01150968f, 0.02051979f, -0.24616441f, 0.11812646f, -0.30235296f, 
    0.01146971f, 0.03793380f, -0.02895318f, 0.00978887f, 0.11409571f, 0.06870151f, 0.01210505f, -0.00702289f, 
    -0.28347611f, 0.05249649f, -0.22959104f, -0.13162531f, -0.13328604f, -0.00740814f, 0.03926034f, 0.03009192f, 
    0.02534497f, 0.05517518f, 0.05452161f, -0.11986417f, -0.37717119f, -0.04385986f, -0.29642358f, 0.04725866f, 
    0.13933177f, 0.05561802f, -0.02513386f, 0.07263823f, 0.02140126f, -0.01336936f, 0.07660051f, 0.10654105f, 
    0.07843972f, 0.02733040f, 0.00135500f, 0.00731443f, -0.04809720f, -0.04997819f, -0.02822115f, -0.03363928f, 
    -0.02717187f, -0.09041932f, -0.01732962f, -0.00052676f, 0.01593865f, -0.12286656f, -0.17168862f, 0.06927122f, 
    -0.04398678f, -0.01908625f, 0.03980203f, -0.03803541f, 0.08291109f, 0.08651994f, -0.07334653f, -0.01441379f, 
    0.10577597f, -0.29636687f, -0.08942054f, 0.06055422f, -0.00668120f, 0.09384321f, -0.05436680f, 0.12657864f, 
    -0.00187292f, 0.04056027f, 0.05430486f, -0.04191265f, 0.19373897f, -0.18581524f, -0.04864920f, -0.05260941f, 
    0.00444289f, -0.03462206f, -0.03439207f, 0.02480089f, -0.06469391f, 0.01815796f, 0.05656042f, 0.00562020f, 
    -0.13579930f, 0.03430893f, -0.15572986f, 0.21165332f, 0.00048011f, -0.04592566f, 0.03312793f, -0.07058088f, 
    0.12056702f, -0.02607041f, 0.03583190f, 0.09926652f, -0.03529272f, -0.06347596f, 0.17306295f, 0.00160556f, 
    -0.05719868f, -0.06474543f, -0.04363243f, -0.04028849f, 0.02017609f, 0.06994228f, -0.09783100f, 0.09249135f, 
    -0.06012027f, 0.23231502f, -0.23191856f, -0.09901045f, 0.09092613f, 0.13056971f, -0.04608222f, -0.14455862f, 
    -0.11470214f, 0.03598807f, -0.09428694f, -0.00329640f, 0.04854117f, -0.04804276f, 0.12255997f, 0.15183331f, 
    -0.16607633f, 0.08977138f, -0.04780337f, 0.05007843f, -0.01038112f, -0.05597210f, 0.01470922f, -0.08229778f, 
    0.02730708f, 0.02961718f, -0.05794940f, -0.02062068f, -0.01600105f, -0.03790706f, 0.02154043f, -0.04530569f, 
    0.03056725f, -0.08804580f, 0.05647456f, -0.04657954f, 0.26917750f, -0.26012564f, -0.15042190f, 0.10929025f, 
    -0.02627201f, 0.07782694f, -0.03600705f, 0.08439833f, -0.09912612f, 0.11195502f, -0.09081535f, -0.01623402f, 
    -0.08910526f, 0.03176665f, -0.04222541f, -0.09863058f, -0.05251217f, 0.01147123f, 0.10831764f, 0.03353169f, 
    0.05056731f, 0.06152767f, -0.11344491f, 0.05750243f, 0.17918763f, 0.08424022f, 0.06543397f, 0.17902626f, 
    -0.08654656f, 0.12637691f, 0.05837568f, 0.05551720f, -0.02786259f, 0.02348254f, 0.11271895f, 0.05294545f, 
    0.03188077f, -0.06292393f, -0.03897201f, 0.13660133f, -0.13321319f, -0.00656082f, -0.09087484f, 0.09253764f, 
    0.04166317f, 0.01254508f, 0.06684797f, 0.05350002f, -0.27956140f, -0.11351582f, -0.42280599f, -0.02416099f, 
    -0.01078957f, 0.07152262f, 0.01618489f, 0.07086339f, 0.06164720f, 0.11553948f, 0.00544934f, -0.04308780f, 
    0.24078746f, -0.06733133f, -0.01604925f, -0.01225805f, 0.05283937f, -0.14044270f, 0.08394016f, 0.03896830f, 
    -0.05607622f, -0.04959114f, -0.01099557f, 0.04819471f, 0.25558567f, 0.06122379f, 0.01900481f, 0.15992881f, 
    0.00414186f, 0.01628961f, 0.02650111f, -0.02953624f, 0.02246036f, 0.03871004f, 0.05377685f, 0.07206388f, 
    0.23160659f, 0.07850383f, 0.03661695f, 0.18378434f, -0.12160941f, 0.14392385f, -0.01693439f, -0.02574211f, 
    -0.00357682f, 0.00581737f, -0.06746941f, -0.00344777f, 0.23870857f, -0.15267780f, -0.04119622f, -0.14014100f, 
    0.06692787f, -0.02821292f, -0.08252240f, -0.03116103f, 0.07403860f, -0.08780049f, -0.10997055f, 0.01405909f, 
    -0.21807048f, 0.15821978f, -0.22840823f, -0.13869746f, -0.15024623f, -0.01558066f, 0.00527249f, -0.03440259f, 
    0.12635122f, -0.00985249f, 0.04954527f, -0.00422910f, -0.33364317f, -0.03258949f, -0.12034518f, -0.12134433f, 
    -0.10208951f, -0.04297423f, -0.02411171f, 0.12371442f, 0.10599782f, 0.07980853f, -0.00665692f, -0.01397655f, 
    -0.03636143f, -0.02737565f, -0.06279258f, -0.00155148f, 0.02428711f, -0.14019720f, -0.02818229f, -0.08342860f, 
    -0.05135619f, -0.05316440f, 0.05130357f, -0.00434256f, 0.30282062f, 0.09591749f, 0.10115819f, 0.04000317f, 
    -0.07759342f, -0.03808831f, -0.03030421f, 0.02710946f, 0.00130841f, -0.03146847f, 0.08378513f, 0.00330794f, 
    -0.02401616f, 0.04971790f, -0.11691324f, 0.01025643f, 0.04912475f, 0.12570910f, -0.02174594f, -0.05767922f, 
    0.03140025f, 0.00257363f, -0.12162550f, -0.15741903f, 0.12386800f, -0.00261935f, 0.10627654f, 0.06043411f, 
    -0.13569130f, 0.04404812f, 0.03277682f, 0.07916777f, 0.03262345f, -0.06452207f, -0.04438614f, -0.17985064f, 
    0.07862090f, 0.10393397f, -0.04246882f, -0.00514096f, -0.04722057f, -0.02170101f, -0.00101970f, 0.09082247f, 
    0.06427770f, 0.00820617f, -0.04799994f, 0.03246957f, 0.14045481f, 0.11252586f, -0.04802953f, 0.03805898f, 
    -0.08497176f, -0.05451613f, -0.00886186f, -0.01578682f, -0.03381802f, 0.15268241f, -0.04481149f, 0.01420426f, 
    0.06432208f, -0.00735697f, 0.15562704f, -0.18561988f, -0.04742936f, 0.00668932f, 0.03935587f, 0.07149956f, 
    -0.16471316f, -0.06311527f, 0.10755382f, -0.14496009f, 0.27610111f, 0.11023446f, 0.16028249f, 0.15950374f, 
    0.07108311f, -0.02306707f, 0.09431194f, 0.00101376f, 0.01587853f, -0.09556792f, -0.06302307f, -0.01302833f, 
    -0.18879330f, -0.02369466f, -0.25499550f, -0.02805330f, 0.03681076f, -0.03476023f, -0.00139388f, 0.05869969f, 
    0.01739761f, -0.13547076f, 0.07063967f, -0.09383717f, -0.19821981f, 0.17862494f, 0.14148591f, 0.13332802f, 
    -0.10136864f, -0.02484905f, 0.01862419f, 0.09119049f, 0.04355979f, 0.03034491f, 0.08397025f, -0.08179782f, 
    0.02707407f, 0.17367975f, 0.05358400f, -0.02837757f, 0.06488764f, -0.01161926f, 0.01618955f, -0.08157291f, 
    -0.12054065f, -0.03279748f, 0.15659070f, 0.05373828f, -0.21445642f, 0.06203907f, -0.13142923f, 0.02740835f, 
    -0.01405884f, 0.06427679f, 0.02656320f, 0.11130952f, -0.17204916f, -0.00049508f, -0.03157200f, 0.05443356f, 
    -0.19362132f, -0.02514046f, 0.04601543f, -0.34259525f, 0.05760263f, 0.02627195f, -0.02328174f, 0.05749875f, 
    0.08427573f, 0.01807760f, 0.03913292f, -0.00100566f, 0.09246292f, -0.04630242f, -0.13503906f, 0.17997722f, 
    -0.12935124f, 0.02210206f, -0.19706731f, 0.02040678f, -0.09717931f, -0.17094937f, 0.07496767f, -0.01723180f, 
    0.33963755f, -0.23796356f, 0.07577071f, -0.25429422f, -0.04568592f, -0.03882623f, -0.06643402f, -0.02356079f, 
    -0.12776044f, -0.07499588f, -0.10073980f, -0.01641439f, -0.19290517f, -0.04374781f, 0.09312853f, 0.03872902f, 
    0.07475989f, 0.01155135f, 0.05670078f, -0.01593224f, 0.07974096f, 0.03953704f, -0.02967170f, 0.05469852f, 
    -0.25555786f, 0.14161305f, -0.11916938f, -0.16937535f, 0.11139535f, -0.08457936f, -0.04638839f, -0.05756273f, 
    -0.05065948f, -0.07597901f, -0.05757739f, -0.04734971f, -0.13218679f, 0.02885642f, -0.07165900f, -0.01888999f, 
    0.07195152f, -0.01569488f, -0.10555592f, -0.00936668f, 0.07328174f, -0.02742059f, 0.02899152f, 0.09853927f, 
    0.36543244f, -0.08742846f, -0.05092642f, 0.00881257f, -0.11219884f, 0.04233082f, 0.03549464f, -0.01537562f, 
    0.02875707f, 0.03227379f, -0.07891321f, 0.00379131f, 0.09794678f, -0.11290945f, 0.04685965f, 0.19505583f, 
    0.01080341f, -0.00743637f, -0.04956447f, 0.00862964f, 0.02323242f, 0.00920137f, -0.06433737f, -0.10625703f, 
    0.18564637f, 0.00849093f, -0.04601379f, -0.12347395f, -0.09760097f, -0.04735660f, 0.06356420f, -0.06302273f, 
    0.00882876f, -0.03669908f, -0.03000598f, 0.03286508f, 0.20346265f, -0.29735222f, -0.17963202f, -0.08572342f, 
    0.12905397f, -0.14235593f, 0.03379647f, -0.09903188f, 0.05596739f, 0.00754026f, 0.06436903f, -0.09103309f, 
    -0.48153794f, -0.03475625f, -0.06182735f, -0.02096902f, -0.00844901f, 0.00419835f, 0.06183864f, -0.19218804f, 
    -0.01315226f, 0.02904881f, -0.15454808f, -0.04802420f, 0.09499885f, -0.02206309f, 0.01839842f, -0.10432035f, 
    0.10735132f, -0.05005250f, 0.12836428f, 0.07179780f, 0.06108495f, 0.11488389f, 0.01641744f, -0.01595670f, 
    0.10355765f, -0.25666246f, -0.19219470f, -0.04550846f, 0.01711775f, -0.03126064f, -0.02013728f, 0.08507811f, 
    -0.06111764f, -0.05494444f, -0.00769296f, 0.11888608f, 0.18938224f, -0.07495688f, 0.12152104f, -0.18611838f, 
    0.01695097f, 0.05012687f, -0.08454707f, 0.01775258f, -0.07558668f, -0.06045489f, 0.04429306f, 0.05392127f, 
    0.29070407f, -0.08219959f, -0.10165149f, 0.02420746f, 0.11349155f, 0.01374969f, 0.03639003f, 0.04545105f, 
    -0.05896164f, 0.04942331f, 0.04088847f, 0.11103643f, 0.03983114f, 0.01844957f, 0.11240404f, -0.13140944f, 
    -0.05589155f, -0.07234818f, -0.06139604f, 0.05104699f, 0.09861693f, 0.03255714f, 0.09802619f, 0.01796316f, 
    0.17002058f, 0.14755422f, -0.24831979f, 0.00304106f, -0.05993846f, 0.00576165f, 0.02018654f, -0.04208774f, 
    -0.01851184f, -0.00314674f, 0.08591278f, -0.02234476f, 0.12668413f, 0.04583598f, 0.00926849f, -0.01677541f, 
    0.01197429f, -0.02476026f, 0.02159211f, 0.06033184f, -0.06294989f, -0.01896995f, -0.01255925f, -0.08733191f, 
    0.31125909f, -0.13319278f, 0.08912011f, 0.06511527f, -0.11677433f, 0.00502916f, -0.04819233f, -0.11720602f, 
    -0.05736153f, -0.02770386f, 0.08782823f, -0.01106897f, 0.14054358f, 0.09132189f, 0.05393820f, 0.05340311f, 
    0.07779028f, 0.03784798f, -0.03583144f, -0.00832438f, -0.06938919f, -0.00912542f, -0.04174755f, 0.05450688f, 
    -0.05181647f, -0.19257744f, -0.03861365f, -0.01699753f, 0.05624380f, -0.08628491f, 0.02793701f, -0.02495839f, 
    0.00252468f, -0.11095465f, 0.00924672f, 0.01937208f, 0.20310554f, -0.03824664f, -0.11897127f, -0.25335604f, 
    -0.07186346f, -0.03540660f, -0.05511992f, 0.04440090f, 0.11632633f, 0.06342951f, -0.01882574f, -0.15706256f, 
    0.09147488f, -0.04512201f, -0.01491755f, 0.06387518f, 0.06519400f, -0.00420839f, 0.03234822f, -0.01413175f, 
    -0.05404440f, -0.02282057f, -0.17554353f, 0.05216007f, 0.23266992f, -0.07314980f, -0.06125442f, 0.01780338f, 
    0.02823821f, 0.00264296f, 0.01500055f, 0.02247740f, -0.00660144f, 0.06487194f, 0.04367851f, 0.03124308f, 
    0.14514297f, 0.07395478f, -0.00122690f, 0.18205601f, -0.03614015f, -0.07253442f, -0.07920781f, 0.12444813f, 
    -0.06453679f, 0.05139547f, -0.05410751f, 0.01423807f, 0.01574820f, 0.10179985f, 0.08427704f, -0.18690373f, 
    -0.03171419f, -0.06540774f, 0.05161268f, -0.00610610f, -0.04145774f, -0.00110666f, 0.06454028f, 0.01470350f, 
    0.13946629f, 0.12603129f, -0.03020651f, 0.17800571f, -0.15903953f, -0.08102081f, 0.01584994f, -0.02526159f, 
    -0.04082672f, -0.08820016f, 0.10772314f, 0.02643128f, 0.09148873f, 0.21925044f, 0.06428573f, 0.23351932f, 
    -0.02132709f, -0.06847764f, 0.08291198f, 0.01678840f, -0.09438819f, 0.00069813f, -0.10113697f, 0.08939318f, 
    -0.07498641f, 0.17284457f, -0.09984804f, -0.09389406f, 0.06477521f, -0.06829529f, 0.10589413f, -0.07602263f, 
    0.01820518f, 0.05935638f, 0.02508523f, 0.00820526f, -0.43093589f, 0.00519567f, 0.01124156f, 0.14493075f, 
    0.04071591f, 0.09793632f, -0.04560771f, 0.00010829f, -0.04840654f, 0.00894885f, -0.05125189f, 0.03312521f, 
    -0.21499573f, -0.00044255f, -0.14846747f, -0.27298939f, 0.04557910f, 0.10836471f, -0.00809437f, -0.02587761f, 
    0.04358600f, -0.01501705f, -0.00804556f, -0.01063767f, 0.15222096f, -0.07762097f, -0.03256398f, -0.19053930f, 
    0.03264781f, 0.05097419f, -0.21239629f, -0.01502425f, -0.03034484f, -0.03000723f, 0.00405555f, -0.01081509f, 
    0.24285938f, -0.12645645f, 0.06011530f, 0.07083765f, -0.04299657f, 0.01679457f, 0.11619216f, -0.05627669f, 
    -0.01485413f, 0.00529955f, 0.04340045f, -0.05437946f, -0.00916498f, 0.05666203f, -0.14254263f, -0.11389135f, 
    0.07317340f, 0.03190109f, 0.02602407f, -0.04161267f, -0.03511164f, 0.02214143f, -0.04774733f, -0.00308284f, 
    0.41135833f, -0.06367501f, 0.10830534f, -0.13143212f, 0.02328705f, -0.01956872f, 0.05030419f, -0.04313994f, 
    -0.01322686f, -0.01058066f, -0.01336357f, -0.08601230f, 0.05095498f, 0.10113644f, 0.01763696f, 0.11356182f, 
    -0.10377285f, -0.13376948f, 0.02783657f, 0.12455174f, -0.02999052f, -0.00704141f, -0.01236725f, -0.02348013f, 
    -0.28736603f, -0.01437492f, -0.00119857f, -0.14825505f, -0.05480381f, 0.05999060f, -0.04116096f, 0.05252862f, 
    -0.01780293f, -0.11820396f, -0.02918643f, -0.08060613f, 0.13125595f, -0.03576991f, -0.06661648f, 0.00370289f, 
    0.04174161f, -0.04001144f, 0.02462633f, 0.03573119f, 0.02238602f, -0.02772779f, -0.06503672f, -0.04916706f, 
    0.13718863f, 0.00905810f, -0.16160958f, 0.06378385f, -0.02159922f, 0.01167898f, 0.12054366f, -0.08626480f, 
    -0.04926585f, 0.02691215f, -0.09976403f, 0.09352539f, 0.00832693f, 0.04813959f, -0.15802987f, -0.06718369f, 
    0.06716914f, 0.08369649f, 0.07235225f, -0.03706347f, -0.06417581f, 0.06989527f, -0.00751898f, -0.08934771f, 
    -0.00678943f, -0.19892550f, 0.06881604f, -0.00164308f, 0.00407490f, -0.07250279f, 0.05028820f, -0.02526864f, 
    0.00504587f, 0.05449586f, 0.03482472f, 0.00630606f, 0.00355205f, -0.26626375f, 0.01553427f, -0.19907627f, 
    -0.11788485f, 0.07447416f, -0.01023808f, 0.00135454f, 0.01044226f, -0.08073357f, -0.04706819f, 0.06768122f, 
    0.05284875f, -0.00885098f, -0.14996170f, -0.21984524f, -0.02085193f, -0.08883990f, -0.11020008f, 0.05152781f, 
    -0.03998806f, 0.04038018f, -0.08879919f, 0.00077942f, -0.04915492f, -0.08353207f, 0.04937615f, -0.03528414f, 
    0.03522586f, -0.07272545f, -0.05123655f, -0.14099176f, 0.07187550f, 0.09094127f, 0.03737466f, 0.08607201f, 
    0.44692570f, -0.09261936f, -0.00735323f, 0.12094799f, -0.08298731f, 0.09754077f, 0.08654303f, -0.05716620f, 
    -0.02638976f, -0.03647935f, -0.04189658f, -0.01776816f, -0.14864077f, 0.00197325f, -0.09802242f, -0.17083797f, 
    -0.01392316f, 0.07699428f, 0.07304990f, -0.09382921f, 0.03279220f, 0.00805308f, 0.03707620f, -0.02398379f, 
    -0.28282499f, 0.12248193f, 0.07613085f, -0.15106182f, -0.00021217f, -0.02255135f, 0.08556774f, 0.02118914f, 
    -0.05791267f, -0.03675527f, -0.01909925f, -0.04879004f, -0.03284260f, -0.10728166f, -0.01130348f, -0.03596651f, 
    0.03149332f, -0.00396947f, 0.01534098f, -0.11880262f, 0.03995073f, -0.00116908f, 0.03820235f, -0.09337731f, 
    -0.08091882f, -0.12496383f, -0.11068220f, 0.02065011f, 0.08589752f, -0.02787261f, -0.04804719f, -0.01594921f, 
    -0.00351831f, -0.06990662f, -0.04349453f, -0.08745040f, 0.11022724f, 0.00881132f, 0.09013115f, 0.16677125f, 
    -0.12537427f, -0.05083565f, -0.01173569f, 0.10902602f, 0.02364634f, 0.04956727f, -0.03353313f, 0.03891483f, 
    0.12419840f, 0.00221662f, -0.00956573f, -0.20382133f, 0.02049725f, 0.03437603f, -0.09762581f, -0.01711065f, 
    -0.01207707f, -0.05148980f, 0.02881303f, -0.07504447f, 0.29682615f, 0.07436644f, 0.05976728f, 0.06521491f, 
    -0.07941166f, -0.07315042f, 0.02211513f, 0.00856925f, -0.06137527f, -0.02815139f, -0.04373227f, -0.02742060f, 
    0.20301685f, -0.06871379f, -0.02763722f, 0.04780612f, -0.02713659f, 0.01630726f, -0.06212937f, 0.00822927f, 
    -0.08517342f, -0.02555072f, -0.04404823f, -0.11369684f, -0.09437144f, -0.07735898f, 0.08782787f, -0.04656279f, 
    0.12770356f, -0.01502670f, -0.00662538f, 0.01684044f, -0.04260936f, 0.00495381f, -0.04688511f, -0.00214028f, 
    0.20316532f, -0.08648700f, -0.18065269f, 0.01086165f, -0.05173266f, 0.04034865f, 0.02840118f, -0.02213150f, 
    -0.00310325f, 0.01853789f, 0.08109591f, -0.07429121f, 0.10714998f, -0.07577831f, 0.02359642f, 0.05538289f, 
    0.01772444f, 0.01144791f, 0.02074501f, -0.03461711f, -0.00490541f, 0.07607079f, -0.05167808f, -0.00840795f, 
    -0.25834545f, -0.20456772f, 0.06904823f, -0.18377045f, -0.07209428f, 0.01165041f, 0.02329217f, -0.08022341f, 
    0.01470269f, -0.05216039f, -0.02046667f, -0.02437506f, 0.13093558f, -0.00251397f, 0.10702458f, 0.06486367f, 
    -0.01732181f, -0.06243390f, -0.04456821f, -0.00733886f, 0.08378353f, 0.03341633f, 0.03084394f, -0.01042237f, 
    -0.25813606f, -0.20084336f, 0.05063429f, -0.10787286f, -0.01947196f, -0.07530189f, 0.02576023f, -0.08915000f, 
    -0.05698393f, 0.05428939f, -0.18406983f, 0.03127072f, 0.10037506f, 0.03488817f, 0.00076518f, -0.03897291f, 
    -0.05180443f, 0.07211290f, 0.06990079f, 0.10213926f, -0.00340067f, -0.02379687f, 0.09461334f, -0.03792993f, 
    -0.11079825f, -0.06640984f, -0.01279332f, -0.08706550f, -0.03056283f, -0.02410976f, 0.07872374f, -0.07614996f, 
    0.00551719f, 0.04333134f, -0.05829207f, 0.09996524f, -0.17670926f, 0.12225338f, 0.00379513f, -0.01365023f, 
    -0.10775062f, 0.05168371f, 0.02056545f, -0.00541883f, -0.07051250f, -0.02223006f, -0.01640042f, 0.04364867f, 
    -0.21066751f, 0.12593223f, -0.02912919f, 0.09900964f, 0.11556795f, 0.06927315f, 0.02346015f, 0.01384601f, 
    -0.05368323f, 0.12271439f, -0.15217610f, -0.01860354f, 0.27308795f, -0.05813755f, -0.02303911f, -0.16794901f, 
    -0.12747391f, 0.01763091f, -0.01746066f, 0.04424967f, 0.07237959f, -0.01345970f, -0.04170128f, -0.08710162f, 
    0.06801345f, 0.14272669f, -0.14907476f, 0.13336030f, 0.02782684f, 0.03716527f, 0.04253019f, 0.04939425f, 
    -0.02642881f, 0.01032567f, 0.00280216f, -0.02792661f, 0.40078640f, -0.00507099f, -0.05558192f, 0.06472455f, 
    -0.07060509f, 0.02052754f, 0.03130154f, -0.02360816f, -0.02413386f, 0.00993360f, 0.01201422f, -0.03746054f, 
    0.02068228f, -0.03896289f, -0.02315236f, -0.03860334f, -0.07109058f, -0.19815862f, 0.06216846f, 0.06517632f, 
    -0.04766705f, 0.07848500f, 0.00869157f, 0.00668363f, 0.04181105f, 0.10072423f, -0.10554675f, -0.01333337f, 
    0.06806606f, 0.10506735f, 0.01174057f, -0.08050851f, -0.09289107f, -0.01456187f, 0.04799807f, -0.15229645f, 
    0.18987353f, 0.07755091f, -0.08242466f, -0.03847940f, -0.00505547f, -0.01276328f, 0.06075442f, 0.03093161f, 
    -0.05873869f, -0.00535731f, -0.07927008f, -0.02643884f, 0.13143387f, 0.18851441f, 0.23424719f, 0.13102153f, 
    -0.13280430f, -0.07405721f, -0.19211715f, -0.03596368f, -0.06181605f, 0.04868041f, 0.11592826f, -0.08176027f, 
    0.28510106f, -0.02959905f, 0.07867270f, 0.09747524f, -0.14181381f, -0.00756216f, -0.03680344f, 0.04777098f, 
    0.07366522f, -0.00036762f, 0.07928808f, 0.08936494f, 0.03113815f, 0.01110481f, -0.07094067f, 0.01456281f, 
    0.08902506f, -0.00911374f, 0.05829003f, 0.00280562f, 0.00606839f, -0.04114652f, 0.02838431f, -0.02119716f, 
    -0.03999350f, -0.03752380f, 0.06455287f, 0.06286879f, 0.00465140f, 0.00422896f, -0.12073281f, -0.00226598f, 
    -0.01341995f, 0.02190773f, -0.00472708f, -0.05380072f, -0.53103584f, 0.04166035f, -0.07288027f, -0.18449031f, 
    -0.01830370f, -0.02319662f, 0.08904824f, 0.09960906f, -0.10945322f, -0.02708626f, -0.06291232f, -0.02138070f, 
    0.33794150f, 0.07793552f, -0.08955897f, -0.19465958f, -0.03622277f, 0.02361736f, -0.00947311f, 0.01674359f, 
    -0.09545765f, 0.01045555f, -0.00126119f, -0.06328719f, -0.27031007f, -0.14469351f, 0.08509466f, -0.39070132f, 
    -0.04781880f, -0.05593458f, 0.05388896f, 0.01019982f, -0.00972596f, -0.16825874f, 0.01386696f, -0.11697222f, 
    -0.16937697f, 0.00408891f, -0.18023475f, -0.10342982f, 0.01417796f, -0.01008446f, 0.01897728f, -0.14973645f, 
    -0.09880009f, 0.02755275f, -0.06744365f, -0.07188191f, -0.01773986f, 0.00163320f, 0.07766753f, 0.07838610f, 
    -0.03033739f, -0.12137307f, 0.05048642f, -0.05076554f, -0.02537818f, -0.07780027f, 0.02430715f, 0.04782687f, 
    -0.01322229f, -0.18315893f, 0.06086555f, -0.03018708f, 0.00922310f, -0.05849908f, -0.04682665f, 0.07020115f, 
    -0.05422613f, -0.13472793f, 0.00748814f, -0.00643176f, -0.07889042f, 0.04601141f, 0.13620530f, -0.02964347f, 
    -0.03560764f, 0.06363743f, -0.00232701f, 0.02602107f, 0.01253323f, -0.00214840f, 0.01980691f, -0.07012868f, 
    -0.01389761f, 0.27327591f, 0.05243240f, 0.05379240f, -0.07986382f, 0.13514867f, 0.05482631f, -0.01056313f, 
    -0.02422713f, -0.07660907f, 0.03112185f, 0.00853534f, 0.07304113f, -0.22441797f, -0.43752220f, -0.07832866f, 
    -0.07762477f, 0.05806034f, -0.03113652f, 0.07351007f, -0.04982675f, -0.07794768f, 0.03431636f, -0.03728760f, 
    0.10789739f, -0.05820407f, -0.01441141f, 0.05845271f, -0.04212923f, -0.10943642f, -0.03391182f, -0.04501402f, 
    -0.00561467f, 0.00928842f, -0.11181249f, 0.02680844f, -0.71706891f, -0.20930593f, -0.02489700f, 0.14146867f, 
    -0.04496626f, 0.11306448f, -0.06774153f, -0.06682336f, 0.02395435f, -0.00080843f, -0.01060018f, -0.08543964f, 
    0.20443609f, 0.06438161f, -0.04396598f, 0.09411572f, 0.04013614f, 0.07287633f, 0.01414779f, -0.10272311f, 
    -0.03222849f, 0.02983617f, 0.02216789f, -0.04391487f, -0.03710126f, 0.10223546f, 0.05318488f, -0.19931878f, 
    0.07344718f, -0.17240755f, -0.14253634f, -0.04347684f, 0.04204709f, 0.09162431f, 0.02872311f, -0.01897860f, 
    -0.41740641f, -0.29480472f, 0.31933314f, 0.10664438f, 0.05526484f, 0.06988104f, 0.02190069f, -0.02274230f, 
    -0.01760138f, -0.06168453f, -0.15550689f, -0.01317299f, -0.15932798f, -0.03531196f, -0.33339491f, -0.10054290f, 
    -0.04019929f, 0.06427305f, -0.08247758f, -0.10587305f, 0.03491259f, 0.01121727f, -0.06300445f, 0.05453871f, 
    0.03250097f, 0.05240959f, -0.01497712f, -0.15129338f, -0.10583083f, -0.08769030f, -0.00634493f, -0.01087468f, 
    -0.00560666f, -0.03433941f, -0.05356856f, 0.03418425f, -0.06599750f, -0.19828437f, -0.16318890f, -0.01334136f, 
    -0.09295045f, -0.03608551f, 0.10223100f, 0.21085966f, -0.01369396f, 0.00125132f, -0.03719636f, 0.00540703f, 
    -0.03546306f, -0.08041722f, -0.01419026f, 0.05596923f, -0.01283574f, 0.08014262f, 0.14429507f, -0.06820630f, 
    -0.12612526f, 0.10067038f, 0.03733431f, 0.11158342f, -0.41333336f, 0.05216308f, -0.07728247f, -0.19592011f, 
    -0.01274516f, 0.03750703f, 0.00100341f, -0.06160539f, 0.04903210f, -0.06752274f, -0.02086572f, 0.00800944f, 
    0.06532455f, -0.20868099f, -0.09707523f, -0.02814776f, 0.02203903f, -0.00680774f, -0.04896229f, -0.19803850f, 
    -0.02485527f, 0.07641704f, 0.08042876f, -0.02496617f, -0.15192664f, -0.00878812f, -0.01409605f, 0.10219263f, 
    -0.14208902f, 0.02016407f, 0.04677653f, -0.06729060f, 0.02896739f, 0.05678907f, -0.04786091f, 0.09032228f, 
    0.23890509f, 0.10608173f, 0.11501021f, -0.01608918f, 0.09391581f, -0.02892717f, 0.07957680f, 0.03401863f, 
    0.07473401f, -0.05668992f, -0.04131068f, 0.00101325f, -0.12545511f, 0.31512427f, -0.08693513f, -0.06161611f, 
    0.05157609f, 0.00640144f, 0.01583448f, 0.08949664f, 0.06070296f, -0.00868895f, 0.02118270f, -0.08619931f, 
    -0.45816889f, 0.16586119f, -0.00669029f, 0.07469840f, 0.04246741f, 0.04314031f, 0.09022024f, 0.01993923f, 
    -0.09884350f, 0.10181292f, -0.08709963f, -0.01371265f, -0.20235424f, 0.07710917f, 0.01195262f, -0.00581033f, 
    0.03874089f, -0.01863975f, 0.04354159f, 0.01553684f, -0.01439176f, 0.01838624f, -0.08383972f, 0.04881825f, 
    0.09037568f, -0.06243101f, 0.08616202f, 0.04407610f, -0.02357904f, 0.02781608f, -0.09024169f, 0.04348268f, 
    0.14097261f, 0.12179965f, -0.03658913f, -0.06239447f, 0.00825903f, -0.20650379f, -0.05682448f, -0.00516822f, 
    -0.03708585f, -0.00796825f, -0.09965611f, 0.00395992f, -0.03607307f, 0.09634371f, 0.00276378f, -0.03696521f, 
    0.23719721f, -0.28336802f, 0.08641423f, 0.12376948f, -0.05235783f, 0.08177464f, 0.15729432f, 0.02839765f, 
    -0.06085083f, -0.07422971f, 0.00825485f, 0.06320056f, -0.04249766f, -0.03720436f, -0.12221102f, 0.11100739f, 
    -0.05601644f, -0.03993405f, -0.02019845f, 0.13013278f, -0.08356214f, -0.01190931f, -0.05142253f, -0.05682884f, 
    0.43159208f, 0.27880907f, 0.09320362f, 0.04337590f, 0.03087262f, -0.05026127f, 0.04481970f, 0.04450167f, 
    -0.00527524f, 0.00063324f, 0.01393115f, -0.09641039f, -0.03343909f, -0.30125105f, -0.15494965f, 0.15938826f, 
    -0.03831983f, 0.03466811f, 0.05202487f, -0.04645510f, -0.11796246f, -0.00353633f, 0.00590615f, -0.08489011f, 
    0.06268352f, 0.01623423f, 0.06717379f, -0.04605266f, -0.01125582f, -0.07596795f, -0.00721847f, 0.06422491f, 
    -0.00822879f, 0.05382835f, -0.05895831f, -0.04451121f, 0.22323494f, 0.10027152f, 0.12910077f, 0.03690020f, 
    0.03448480f, 0.01652035f, -0.00425802f, 0.00194903f, -0.03707020f, 0.05426526f, 0.00707825f, 0.01462534f, 
    0.14883575f, 0.08042848f, 0.08302676f, 0.14157994f, 0.03972441f, 0.03752598f, -0.06907372f, 0.04031643f, 
    -0.02588975f, -0.00140021f, 0.01335010f, 0.02630334f, -0.23425744f, -0.40986687f, -0.06869905f, 0.08701381f, 
    -0.01043128f, -0.07040258f, -0.01345295f, -0.00803119f, 0.10217594f, 0.01350845f, 0.09280130f, 0.02124648f, 
    -0.16343923f, 0.15943320f, 0.08872145f, 0.07458049f, -0.02904982f, 0.01389095f, 0.10384480f, -0.01006735f, 
    -0.07727391f, -0.03736749f, -0.10485555f, 0.00853097f, -0.06563147f, 0.20899929f, 0.05270339f, 0.13423805f, 
    0.01962656f, 0.06217163f, 0.06064828f, -0.06234365f, -0.01351714f, 0.08177155f, 0.01449088f, -0.09025441f, 
    -0.05249745f, -0.23605344f, -0.22027792f, -0.05319781f, -0.06388818f, 0.06993981f, -0.00443515f, 0.04313912f, 
    0.07143203f, -0.08963638f, -0.01446357f, -0.00423962f, -0.40919623f, -0.12605886f, -0.12707978f, 0.01116208f, 
    -0.09045555f, -0.07786247f, 0.03970367f, 0.00375054f, -0.05110201f, 0.00342216f, 0.15786126f, -0.09064300f, 
    -0.19298619f, -0.36877304f, -0.15536955f, 0.18022062f, -0.04567137f, -0.06255011f, -0.08661143f, -0.02416889f, 
    0.02488382f, -0.12388375f, -0.01552294f, -0.00310475f, -0.10356283f, 0.04623693f, -0.06541658f, 0.04480807f, 
    -0.12571043f, -0.03223613f, 0.03527651f, -0.01193857f, -0.07698136f, 0.08834552f, 0.02653920f, -0.02946063f, 
    -0.27035859f, 0.36542416f, 0.00190152f, 0.10413024f, 0.12931636f, 0.01515219f, -0.10069525f, -0.00410916f, 
    0.01742717f, -0.02507295f, -0.00293073f, 0.06208452f, -0.22330579f, 0.08273993f, 0.13081984f, -0.28079173f, 
    0.02877405f, -0.07962793f, -0.08852717f, -0.00100669f, 0.03206167f, -0.12389023f, -0.09222572f, 0.05369544f, 
    -0.15688914f, 0.16391309f, 0.00655225f, 0.10371048f, -0.03501086f, 0.06170288f, 0.05066812f, -0.00879685f, 
    -0.03121814f, -0.02681748f, -0.03466437f, -0.02313098f, -0.19970675f, -0.46660644f, -0.12973304f, 0.07654745f, 
    -0.08597284f, -0.09010425f, 0.00883479f, 0.03812429f, -0.07666463f, -0.11058190f, -0.03305615f, 0.11756551f, 
    -0.35714832f, 0.06563098f, 0.02608455f, -0.05493262f, 0.06166549f, -0.12139380f, -0.01840268f, 0.04659006f, 
    0.00496154f, -0.00670809f, 0.12693889f, 0.07564455f, -0.04580612f, -0.11617254f, -0.28831941f, 0.07919021f, 
    -0.03455224f, -0.11464901f, 0.07179459f, -0.00081194f, 0.04862700f, -0.09579588f, -0.05605489f, 0.11084002f, 
    0.11602505f, 0.06819365f, -0.03391195f, -0.00309203f, -0.12612711f, -0.02104514f, 0.04262039f, -0.02339696f, 
    -0.05035360f, -0.01568099f, 0.01153319f, -0.01912245f, -0.11371879f, 0.02947112f, -0.17224073f, -0.06051707f, 
    -0.00124778f, -0.00230973f, 0.02901321f, -0.19820520f, 0.05212874f, -0.05691453f, -0.00396788f, -0.05262476f, 
    0.09994874f, 0.00296756f, -0.04173129f, 0.12372071f, -0.01377388f, 0.03061616f, -0.02834907f, -0.00183986f, 
    -0.05118632f, 0.09077457f, -0.03507855f, 0.02937712f, -0.18194690f, -0.17862532f, -0.24081516f, 0.03390106f, 
    -0.01314428f, -0.09434216f, -0.06216914f, -0.03477130f, -0.07291126f, 0.09177076f, -0.06223106f, 0.05647858f, 
    -0.08763225f, 0.33354500f, 0.07297733f, 0.13622691f, -0.00725748f, 0.03842786f, -0.03811692f, 0.02866258f, 
    -0.09072603f, 0.12179829f, -0.02979634f, 0.13923633f, -0.01045012f, -0.33616945f, -0.12889379f, -0.00992444f, 
    0.03096413f, -0.01483903f, 0.04984401f, -0.01412265f, 0.00144750f, 0.02077222f, 0.01824859f, 0.01650803f, 
    0.08195069f, -0.28515106f, -0.03460350f, 0.20107481f, -0.09474256f, 0.07484384f, -0.00784738f, 0.07170790f, 
    0.07740022f, -0.03220081f, 0.01924674f, -0.01981449f, 0.08066062f, 0.09051368f, 0.13103618f, -0.14034116f, 
    0.04503765f, -0.00514153f, -0.00771349f, -0.04677690f, -0.03855084f, 0.01580972f, 0.06396772f, 0.07069772f, 
    -0.16607082f, 0.03685130f, 0.02207146f, -0.07644079f, -0.11707053f, 0.13439694f, -0.07486918f, 0.06427552f, 
    -0.04211063f, -0.00295729f, -0.08774652f, 0.11578390f, 0.08331179f, -0.04295777f, 0.19310826f, -0.11759420f, 
    0.06610903f, 0.04128749f, 0.08009940f, 0.04630464f, -0.00328667f, -0.01011547f, -0.10345350f, 0.00620565f, 
    0.11731035f, -0.14492360f, 0.13592471f, 0.18488649f, -0.03955293f, 0.00755684f, 0.05849972f, 0.08111293f, 
    -0.00368878f, 0.10823305f, 0.03097643f, 0.00498327f, 0.00035778f, -0.22349551f, 0.03763145f, 0.21472196f, 
    -0.01564031f, 0.09992060f, 0.01188728f, 0.00783750f, 0.01845852f, -0.12837642f, -0.00374073f, -0.24980989f, 
    -0.30193478f, 0.37992454f, 0.07160668f, 0.06602041f, 0.05606848f, 0.06994776f, 0.03439682f, 0.03060121f, 
    0.04034518f, 0.05214157f, -0.02832320f, 0.05372690f, 0.15250994f, 0.03840239f, -0.14874291f, -0.09934004f, 
    -0.07067142f, -0.02588419f, 0.04326472f, 0.06984049f, -0.07007543f, 0.00051544f, 0.05614221f, -0.08405781f, 
    0.03701139f, -0.00173825f, 0.01011398f, 0.05127654f, -0.06542533f, -0.01464389f, 0.08781295f, -0.02636355f, 
    -0.09337159f, -0.00612988f, 0.04794278f, 0.00001000f, -0.08983769f, -0.24546491f, -0.06236236f, -0.03870946f, 
    -0.08900677f, -0.06362854f, -0.01296435f, -0.03900984f, -0.00314558f, -0.07146504f, 0.10330986f, 0.02671230f, 
    0.04153136f, 0.11549353f, 0.00999930f, -0.06823619f, -0.04459211f, -0.09235790f, 0.02634322f, -0.00551611f, 
    -0.03121633f, -0.00747412f, 0.01112187f, 0.10310994f, -0.03332051f, -0.06376153f, -0.10211428f, 0.12163491f, 
    -0.06819204f, 0.04978124f, -0.08724139f, 0.27293625f, 0.04969483f, 0.04462456f, 0.01242306f, -0.02835053f, 
    0.06722553f, 0.19350901f, 0.14100245f, -0.07848412f, -0.04033334f, -0.03933385f, 0.07582491f, 0.11274958f, 
    -0.02678666f, -0.11006636f, 0.08877810f, 0.08970553f, 0.04033596f, -0.09177555f, 0.19874857f, 0.00326624f, 
    -0.05546200f, 0.14550835f, 0.03335229f, 0.07009759f, 0.03397550f, 0.01155807f, -0.03841461f, -0.02975874f, 
    0.12609656f, 0.20311363f, -0.27984273f, 0.06831376f, -0.03988132f, 0.17339137f, 0.06236095f, -0.01788242f, 
    -0.06626219f, -0.03887571f, -0.02825764f, -0.05433229f, 0.01786277f, -0.12690669f, -0.03895940f, 0.03365178f, 
    0.02643904f, -0.11694998f, 0.11351179f, -0.01501108f, -0.08337495f, 0.10394906f, 0.02824954f, 0.04391078f, 
    0.03030836f, -0.02701802f, -0.18760583f, -0.07106715f, -0.02674342f, 0.05932266f, 0.06230084f, 0.00538836f, 
    -0.00672708f, -0.06218105f, 0.04932001f, 0.06226550f, -0.08618116f, -0.04103341f, -0.10424460f, -0.01710208f, 
    0.02171032f, 0.03174832f, 0.04529879f, 0.08467326f, -0.00466961f, 0.05170245f, -0.05064292f, 0.00044596f, 
    0.05192587f, 0.11434151f, 0.02364498f, -0.07458548f, 0.02963507f, -0.13981003f, 0.00554378f, -0.06615573f, 
    0.06421060f, 0.04963093f, -0.13299446f, -0.04562655f, -0.08667229f, -0.05832878f, 0.02222152f, -0.05286540f, 
    -0.03418733f, -0.00255051f, -0.00022588f, -0.00776226f, 0.01641925f, 0.04110927f, -0.07417271f, -0.18602590f, 
    0.06005643f, 0.09567726f, -0.04933028f, 0.07531933f, 0.03891117f, -0.08025095f, 0.14458749f, 0.20450740f, 
    -0.02833847f, 0.02737698f, 0.03791140f, -0.00895698f, -0.38531053f, -0.04246090f, 0.16103287f, 0.06245738f, 
    -0.07628144f, 0.08032838f, -0.05795008f, -0.01621764f, 0.03987827f, 0.06161672f, 0.01529098f, -0.10744307f, 
    -0.05479189f, 0.05951287f, 0.05059678f, 0.07611348f, -0.03914471f, 0.13426699f, -0.00414240f, -0.07291861f, 
    -0.00351860f, -0.03058388f, -0.06565622f, -0.08027632f, -0.26566285f, -0.13115729f, -0.00023446f, -0.17567599f, 
    0.07428575f, -0.08686738f, -0.09690115f, 0.06146751f, -0.05385034f, -0.05609370f, -0.05864948f, 0.04409537f, 
    -0.08496061f, 0.01750087f, 0.02916537f, -0.05519994f, 0.04805845f, -0.01046095f, -0.05816405f, 0.03427507f, 
    0.01264759f, -0.04091308f, -0.02033816f, -0.00753820f, 0.00253412f, -0.11729981f, -0.01639971f, 0.15819627f, 
    0.02565417f, 0.00952417f, 0.12467073f, 0.10912974f, -0.04808719f, -0.05870396f, 0.02356621f, -0.01308554f, 
    -0.13927291f, 0.00827996f, 0.09683659f, 0.10796799f, 0.04643878f, -0.07169140f, 0.06268762f, -0.01960562f, 
    -0.08835356f, -0.09291505f, -0.03876864f, -0.00908695f, -0.23283504f, -0.10764036f, -0.02292760f, -0.06231337f, 
    0.08164927f, 0.02756307f, -0.03839815f, -0.02953104f, 0.03663329f, 0.02036550f, -0.00005551f, -0.09032069f, 
    -0.02472526f, -0.09284505f, 0.03592376f, 0.02601762f, -0.00354439f, -0.00035826f, 0.07121604f, -0.02367538f, 
    -0.05103068f, -0.03924535f, 0.09053627f, 0.05564820f, -0.01363381f, -0.15523483f, -0.01094326f, 0.22860409f, 
    0.11580383f, 0.01600327f, 0.04417886f, -0.02176775f, -0.08187962f, -0.01171000f, 0.09082194f, -0.03526725f, 
    0.34860304f, -0.17739780f, 0.07071367f, 0.11985761f, -0.03495261f, -0.02945633f, -0.03727217f, -0.16889144f, 
    0.01535264f, 0.06466294f, 0.00514741f, -0.05284109f, -0.02131644f, -0.20631243f, -0.38910532f, 0.14360182f, 
    0.03412032f, -0.12482852f, -0.01561126f, -0.07709878f, -0.02387650f, -0.03984031f, 0.06969441f, 0.01225748f, 
    0.30190364f, -0.12607931f, 0.14794570f, -0.12071963f, -0.01163354f, 0.13426988f, -0.06634308f, 0.05075780f, 
    0.06747709f, 0.04032269f, -0.00227364f, 0.04286720f, -0.40040097f, -0.12498894f, 0.08328714f, -0.19649419f, 
    0.04937215f, 0.13863020f, 0.04858223f, -0.01591287f, 0.00384621f, 0.01808363f, -0.04214234f, -0.02790950f, 
    -0.37149781f, 0.10763457f, -0.01305836f, 0.00367739f, 0.02845172f, -0.10211173f, 0.03840490f, 0.10970210f, 
    -0.03458197f, 0.19327430f, 0.00658853f, -0.11982177f, -0.08735256f, -0.07291698f, 0.04737251f, -0.09623004f, 
    0.13463169f, -0.05685273f, 0.04364271f, -0.01063415f, -0.03934674f, 0.01219900f, 0.08938550f, -0.03708705f, 
    -0.33270928f, 0.11357536f, 0.03490233f, -0.04155632f, -0.00057456f, 0.02094998f, -0.00755181f, -0.12888865f, 
    -0.05496821f, -0.09923529f, -0.16711715f, 0.04806343f, -0.36388621f, 0.10667398f, 0.26159790f, 0.04778823f, 
    -0.09502913f, 0.08574218f, -0.03158108f, -0.06514093f, 0.02194754f, 0.07085673f, 0.12167738f, 0.11708514f, 
    -0.03373690f, 0.10456598f, 0.05812240f, -0.20727025f, 0.05133027f, 0.01675224f, 0.04193439f, 0.05363348f, 
    0.02090408f, 0.05551751f, 0.00716683f, 0.10146137f, -0.08584440f, 0.06911604f, -0.01647442f, -0.10080856f, 
    0.02060499f, -0.00188086f, -0.11310462f, 0.02191707f, 0.01162567f, -0.11272128f, 0.08701405f, -0.18710649f, 
    0.26857546f, 0.33477619f, -0.12097632f, -0.15462337f, 0.00364866f, -0.08737285f, 0.00188563f, 0.06852667f, 
    -0.03794160f, -0.08764692f, 0.05612054f, 0.01630178f, -0.15240856f, -0.02979928f, 0.00424777f, -0.01981875f, 
    -0.04569974f, -0.05941291f, 0.04427189f, 0.16127937f, 0.00877290f, -0.01539788f, 0.02541073f, -0.02459653f, 
    -0.17991967f, -0.03777468f, 0.20648664f, 0.13830127f, 0.11055865f, -0.12138501f, -0.00246177f, 0.09049292f, 
    -0.11261686f, 0.07162043f, 0.11314330f, 0.14370765f, 0.11956006f, 0.02076209f, -0.16565029f, -0.30299634f, 
    -0.01587114f, -0.15426584f, -0.07783239f, -0.08517290f, -0.04382505f, -0.10812429f, 0.05745558f, -0.00484795f, 
    0.03811309f, 0.04944052f, 0.15386695f, -0.13041592f, 0.00894674f, -0.05352659f, -0.01521283f, -0.02829884f, 
    0.03492906f, 0.00987546f, -0.02720301f, 0.09572975f, 0.04561118f, 0.10969763f, 0.03877296f, 0.09746037f, 
    0.04089369f, -0.00799548f, -0.06302997f, 0.10231101f, -0.02534132f, -0.13441163f, 0.07659255f, -0.00911616f, 
    -0.52956969f, 0.05268878f, -0.05997894f, -0.04177903f, 0.03575701f, 0.00412440f, 0.05900829f, -0.05769649f, 
    0.09519535f, 0.02535243f, 0.01274091f, -0.01272375f, -0.15400404f, -0.41655487f, 0.12366472f, 0.06556010f, 
    -0.01522924f, 0.02784787f, 0.06725132f, -0.12807615f, 0.03566746f, -0.07030483f, 0.04755120f, -0.00921694f, 
    -0.11063676f, -0.33863789f, -0.00643300f, 0.06767289f, -0.17176399f, -0.01912687f, 0.06713520f, -0.05907515f, 
    0.06260408f, 0.07297809f, -0.00886556f, -0.03522868f, -0.03174410f, 0.12552959f, -0.08961955f, 0.10761109f, 
    -0.05446126f, 0.05865112f, 0.00550619f, 0.15598480f, 0.01525192f, -0.02426363f, -0.03659710f, -0.02199690f, 
    0.20867065f, 0.14844717f, 0.12343284f, 0.02716096f, -0.02797821f, 0.05856166f, 0.07629810f, 0.04348309f, 
    0.01352930f, 0.10486582f, -0.05904835f, 0.03599497f, -0.34058619f, -0.03019031f, 0.11536504f, 0.26042569f, 
    0.04131068f, -0.02695915f, 0.04331754f, 0.03930728f, 0.00822615f, 0.02659339f, 0.09691317f, 0.05672662f, 
    -0.32608762f, 0.02223470f, 0.08023781f, -0.17434363f, -0.01698986f, 0.08748668f, 0.08807530f, -0.03698977f, 
    -0.03980057f, 0.02546469f, -0.07626275f, -0.03155345f, 0.14589094f, 0.11267700f, 0.00021631f, 0.02273359f, 
    0.04834663f, 0.02604047f, 0.06095409f, -0.04576159f, -0.08054435f, 0.03384741f, -0.01727941f, -0.02249112f, 
    0.08052741f, -0.11493097f, 0.11570172f, 0.11473357f, 0.03749873f, 0.06833135f, 0.00766783f, 0.00917428f, 
    0.00961032f, 0.06484070f, 0.03641482f, 0.05112950f, -0.00647467f, 0.05752530f, -0.06456085f, -0.04945962f, 
    -0.00441341f, -0.10938746f, -0.06090662f, 0.12552810f, -0.03471817f, 0.05155308f, 0.02815744f, -0.05266942f, 
    0.47503522f, 0.14559208f, -0.02987386f, -0.07080832f, 0.02604843f, 0.00137396f, 0.01256682f, 0.06933582f, 
    0.06247664f, -0.00789497f, 0.04192656f, 0.00039597f, -0.11111860f, -0.06834652f, 0.03400749f, 0.12541132f, 
    0.06356090f, -0.01225505f, 0.01683244f, 0.01005180f, -0.03457540f, -0.00338891f, 0.00981384f, 0.10340052f, 
    -0.02086574f, 0.07026985f, 0.08780893f, 0.01049806f, 0.08384321f, 0.05810962f, -0.01517169f, 0.10857423f, 
    -0.06137329f, 0.01683922f, -0.01585927f, -0.00761427f, -0.20056503f, -0.12501840f, -0.13417649f, -0.04481254f, 
    0.01629139f, -0.08345730f, 0.02226544f, 0.09586099f, 0.01350975f, -0.07586613f, 0.11000469f, -0.02362977f, 
    -0.17057088f, -0.11452696f, -0.12300678f, 0.23989488f, 0.06685518f, 0.00964185f, 0.03926528f, 0.01584627f, 
    0.08068275f, 0.04191408f, -0.05005620f, 0.05449215f, -0.29602653f, 0.04438178f, 0.19094990f, -0.08920716f, 
    -0.03934974f, 0.06090284f, -0.04776559f, 0.08596424f, -0.02054254f, 0.06987561f, 0.09153411f, 0.09513994f, 
    -0.00723001f, -0.01898205f, 0.14489119f, 0.13301510f, -0.00937940f, 0.12770060f, -0.09341109f, 0.05396394f, 
    0.01650960f, 0.03722323f, 0.13957708f, -0.00108009f, -0.11564188f, -0.02855671f, 0.18481863f, -0.08157421f, 
    -0.00696006f, 0.00666506f, -0.15080075f, -0.02516782f, -0.02147422f, 0.00035952f, 0.00566947f, 0.00825104f, 
    -0.19416043f, -0.01420069f, 0.01919211f, -0.07481901f, 0.00366916f, 0.06051662f, -0.09232122f, -0.01424119f, 
    -0.04065874f, -0.03809958f, 0.04118608f, 0.07586189f, 0.08952508f, 0.03983334f, 0.17642489f, -0.11691121f, 
    0.10671054f, 0.00034311f, -0.12053300f, 0.01407024f, 0.07986192f, -0.09134260f, -0.08954270f, -0.08155864f, 
    0.19746488f, 0.01701060f, 0.05119274f, 0.25402221f, -0.05961396f, -0.07783940f, 0.03219708f, 0.00645933f, 
    0.07191007f, 0.04161057f, 0.00509960f, 0.11317506f, -0.29116201f, 0.01043297f, 0.05332600f, -0.00431601f, 
    0.02716867f, 0.01230046f, 0.02480576f, -0.00164334f, -0.13963111f, 0.04695168f, -0.11399057f, 0.04353545f, 
    -0.03513617f, 0.01237558f, 0.07521503f, 0.09983722f, 0.11012215f, 0.10808240f, 0.10081403f, -0.01509747f, 
    -0.09139676f, -0.03803050f, 0.03991015f, -0.05569070f, -0.32153466f, -0.16262121f, 0.16368255f, 0.20853876f, 
    -0.14832354f, -0.01122795f, -0.10828000f, -0.10068794f, 0.07027683f, 0.09357372f, -0.06058038f, -0.10600391f, 
    -0.21101779f, -0.03118010f, 0.18080653f, -0.05391071f, -0.15509313f, 0.03843706f, 0.12709309f, 0.03153834f, 
    0.02312327f, 0.08707336f, -0.04881453f, -0.04260334f, -0.04131267f, -0.13003266f, -0.10227290f, 0.01707790f, 
    0.08100953f, 0.09881905f, -0.03840296f, 0.12706961f, -0.05992973f, -0.12066861f, -0.12142266f, -0.09286078f, 
    -0.76620978f, 0.13442488f, -0.06925958f, 0.05205676f, 0.03458538f, -0.05139403f, 0.04046953f, 0.07929232f, 
    -0.02300428f, 0.00055063f, 0.09623072f, 0.06445283f, 0.31841058f, -0.12351626f, -0.03904888f, 0.04575213f, 
    -0.05639572f, 0.03371062f, 0.10999807f, 0.05005438f, 0.05210957f, 0.03029856f, 0.02049516f, 0.04200549f, 
    -0.14762715f, 0.03169103f, -0.02878580f, 0.09628139f, 0.04942046f, -0.06656282f, 0.02944182f, 0.02387084f, 
    -0.07796784f, -0.09148885f, -0.11413246f, -0.04097942f, -0.12270731f, 0.14550868f, 0.17793898f, -0.23980111f, 
    -0.04541684f, 0.08260162f, -0.02177096f, 0.01619265f, 0.03811900f, 0.00272456f, 0.07386172f, 0.00178984f, 
    0.24147527f, -0.10937112f, -0.03954850f, -0.17226192f, 0.02882633f, -0.04965150f, -0.05870789f, 0.12768647f, 
    0.03588799f, 0.00168480f, -0.00392980f, -0.01380564f, -0.02208737f, -0.16643578f, 0.05380134f, 0.00935782f, 
    0.09280909f, -0.04318580f, 0.13021262f, -0.10489792f, 0.09372937f, -0.05859720f, -0.09181228f, 0.08626518f, 
    -0.07387162f, -0.19518685f, 0.03567087f, -0.03156037f, 0.08337282f, 0.07759606f, 0.08992604f, -0.02518251f, 
    0.13793798f, 0.01208489f, -0.15989216f, -0.01447240f, -0.19649018f, -0.01121729f, -0.18265744f, 0.00033802f, 
    0.11872142f, 0.00450473f, -0.05765406f, -0.11212152f, 0.03769661f, -0.00565393f, -0.00921350f, -0.09396986f, 
    -0.08067700f, 0.31071153f, 0.09045086f, 0.09132169f, -0.06940582f, -0.05874518f, 0.03754861f, 0.06028352f, 
    -0.02184019f, -0.15960765f, -0.02452876f, -0.01892386f, -0.16653205f, -0.03201109f, 0.02671703f, 0.00407151f, 
    0.05257989f, 0.03645495f, -0.04782113f, -0.16565070f, 0.00257075f, -0.03544917f, -0.01549754f, -0.08455989f, 
    -0.12338895f, -0.12663609f, -0.05748229f, 0.32259217f, 0.03775926f, 0.06990471f, 0.00484217f, 0.00358810f, 
    0.21271969f, 0.14397235f, 0.00312668f, -0.04945692f, 0.02668047f, 0.03972914f, -0.04983307f, -0.08581358f, 
    -0.01131722f, 0.04213862f, -0.00345155f, -0.07139813f, 0.01971289f, -0.10536084f, 0.06956005f, 0.05074267f, 
    -0.40751791f, -0.10832712f, -0.03848380f, 0.00551399f, 0.13227993f, 0.06804136f, -0.05110099f, 0.06667151f, 
    0.07863216f, 0.06903271f, -0.09777443f, 0.14212209f, -0.00465675f, -0.06162078f, 0.05389911f, -0.07967204f, 
    0.00295082f, -0.08429054f, -0.00301539f, 0.01117848f, -0.06858216f, -0.06438670f, 0.11000101f, 0.10014988f, 
    0.05156973f, -0.04189502f, 0.01538097f, -0.01514248f, 0.03103735f, -0.11289818f, 0.05848666f, 0.02490391f, 
    0.06324254f, 0.12364363f, -0.04578662f, 0.20510247f, -0.08679575f, -0.02623755f, 0.10691987f, 0.07933115f, 
    -0.09592152f, -0.09584698f, -0.00193880f, 0.22028695f, 0.00860688f, -0.06737345f, -0.11521306f, -0.05430324f, 
    -0.00013663f, 0.01561389f, 0.31497920f, 0.13464971f, -0.02125098f, 0.00466162f, 0.07530514f, -0.07208390f, 
    0.00251869f, 0.00069344f, 0.14461040f, 0.15374392f, 0.07081831f, 0.13377497f, 0.18362515f, -0.11394241f, 
    0.10758962f, 0.00637201f, -0.00873471f, -0.08111331f, -0.12340426f, -0.11794405f, -0.02948286f, -0.08982427f, 
    -0.47278962f, -0.18140662f, -0.09046704f, 0.00998139f, 0.10119109f, 0.11873036f, -0.07605857f, -0.04143203f, 
    0.20081854f, 0.08862126f, 0.14867951f, -0.00406242f, 0.06421772f, 0.10466122f, -0.09951642f, 0.10492729f, 
    -0.08165379f, -0.02078823f, 0.17445242f, 0.05416944f, -0.04804748f, -0.14764592f, 0.01511446f, -0.01678698f, 
    -0.09448740f, -0.18225962f, -0.11980758f, -0.04805321f, 0.03446761f, 0.10464515f, 0.05047550f, 0.13671769f, 
    0.12338311f, -0.02079504f, -0.18004073f, -0.04386536f, 0.22472548f, 0.02247008f, -0.06579342f, -0.14801544f, 
    0.00725618f, 0.04895173f, -0.18682234f, -0.09605331f, 0.09658802f, -0.01626009f, -0.06524704f, -0.08790587f, 
    0.01074779f, -0.04405110f, -0.02181029f, -0.15255530f, -0.09132920f, -0.07135548f, 0.03458156f, 0.09497179f, 
    0.03839227f, -0.02562533f, 0.01960747f, -0.12032484f, 0.11754617f, 0.03652974f, 0.17548507f, -0.05511260f, 
    0.05593121f, -0.00131249f, -0.04278601f, 0.03207587f, 0.03858090f, -0.10167515f, 0.02925788f, -0.08593605f, 
    -0.19520544f, 0.04103976f, 0.13148247f, 0.18611777f, -0.00308003f, -0.11018273f, -0.02580807f, 0.02962063f, 
    -0.05568147f, -0.02305166f, 0.00735793f, -0.05730839f, -0.61815554f, 0.15472312f, 0.20109503f, -0.10305935f, 
    -0.06460482f, 0.00284666f, 0.13459672f, -0.03832375f, 0.07246600f, -0.08368140f, 0.09274472f, -0.07266764f, 
    -0.03697542f, 0.04288887f, 0.06921849f, -0.30815959f, 0.01274943f, 0.05780163f, -0.00351931f, -0.01672782f, 
    -0.07221971f, 0.01962727f, -0.01006139f, -0.04142904f, -0.12554272f, 0.16452624f, 0.12628007f, -0.00296430f, 
    -0.10541121f, 0.06184571f, -0.00883054f, 0.07111445f, 0.04870690f, -0.10325653f, 0.08500886f, -0.01200079f, 
    -0.09100517f, -0.02802613f, 0.14761668f, 0.04237119f, -0.02717064f, -0.06639098f, 0.02903104f, 0.04485739f, 
    0.03072670f, -0.32265669f, -0.04361040f, -0.09872155f, -0.21120195f, 0.00397697f, -0.31979886f, 0.10658399f, 
    0.05447366f, -0.08588130f, -0.05140331f, -0.18869437f, -0.02271197f, 0.09474683f, -0.21497655f, 0.03062043f, 
    0.13055252f, 0.05043465f, -0.04237680f, -0.09941913f, -0.08084023f, 0.00107741f, -0.24095933f, 0.13555580f, 
    -0.05207418f, -0.01552049f, 0.10116614f, -0.10111257f, 0.03724575f, 0.10988351f, -0.03616397f, 0.05239533f, 
    0.04747077f, 0.12915255f, 0.10768234f, -0.10441783f, 0.03861547f, 0.05630929f, -0.01366754f, 0.13224825f, 
    -0.20009775f, -0.37013146f, 0.30953556f, 0.21748050f, 0.00411188f, 0.05469705f, 0.12790973f, -0.05621278f, 
    -0.02793865f, 0.01277929f, 0.08349987f, -0.02994574f, -0.04555700f, 0.00189778f, 0.11321330f, 0.13045578f, 
    -0.04663467f, -0.01070293f, -0.03304133f, -0.10510222f, 0.03313636f, -0.06779934f, 0.02071794f, 0.19630258f, 
    -0.03809137f, 0.16313884f, -0.16883411f, 0.01845952f, 0.11176248f, 0.18078820f, 0.03689984f, -0.04338312f, 
    0.10700192f, -0.09559023f, 0.05822068f, -0.06070586f, -0.33669674f, 0.25808182f, 0.24875058f, -0.44593799f, 
    0.06900641f, 0.04502109f, -0.10719345f, -0.06012872f, 0.13825476f, 0.01194623f, 0.01640371f, 0.08094510f, 
    -0.05190130f, -0.03322567f, -0.10955759f, 0.17395301f, 0.01373464f, -0.00503932f, -0.12747434f, 0.01887867f, 
    -0.11281751f, -0.03701384f, 0.25107208f, 0.09286352f, -0.13288094f, -0.09108494f, 0.07734375f, 0.01879947f, 
    -0.07507762f, 0.04233187f, 0.03349893f, 0.15863426f, 0.11315949f, 0.09498046f, -0.07171080f, -0.33738035f, 
    -0.21076535f, 0.09739841f, -0.09686807f, -0.24745966f, 0.16538453f, -0.04459863f, -0.11199537f, 0.04326702f, 
    0.01618270f, 0.00654696f, 0.07071622f, -0.06717783f, 0.06913730f, 0.13826402f, 0.13654473f, 0.16453014f, 
    -0.16682960f, -0.10222404f, 0.06481155f, 0.11571480f, -0.15840918f, -0.14906330f, -0.00220017f, 0.04352964f, 
    0.12211240f, 0.12266500f, 0.03463485f, 0.05351689f, -0.02311117f, -0.08450064f, 0.07592558f, -0.04588193f, 
    0.02930969f, -0.05035502f, 0.10099961f, -0.10510838f, -0.06286675f, 0.07502601f, 0.16121067f, -0.16481601f, 
    -0.05282387f, -0.09649251f, -0.01935318f, 0.04220172f, 0.08790264f, 0.12488534f, -0.12541783f, 0.02669557f, 
    -0.07970853f, 0.02253033f, 0.06005510f, -0.01647864f, -0.01663187f, -0.16915500f, 0.08744621f, -0.06566466f, 
    0.15017842f, 0.12809880f, 0.01738436f, 0.19274639f, 0.07395269f, -0.01924968f, -0.14953911f, -0.16109559f, 
    0.06400897f, 0.13621847f, -0.05327225f, -0.14452082f, -0.00126231f, -0.07541148f, -0.05757104f, -0.03158640f, 
    0.00251972f, -0.15334222f, -0.00926224f, 0.10467628f, -0.06595963f, -0.13454694f, 0.11479312f, 0.04169057f, 
    0.05443658f, 0.01791691f, -0.06557492f, 0.08819290f, -0.07828179f, -0.13864329f, 0.00572590f, -0.05233600f, 
    0.04387106f, 0.03529291f, -0.01456560f, -0.14324564f, 0.10090435f, -0.06062371f, 0.01027420f, 0.13662589f, 
    0.01257780f, -0.16167343f, -0.06570300f, 0.00201281f, 0.02467962f, 0.16086112f, -0.00873786f, 0.11153349f, 
    0.08412933f, -0.01136759f, 0.08642000f, 0.05121765f, 0.10161530f, 0.04527888f, 0.12709810f, 0.06800179f, 
    -0.00275066f, 0.08951975f, 0.11555323f, -0.17671660f, -0.01817966f, 0.05990937f, -0.01026014f, 0.12631130f, 
    -0.20607159f, 0.02010289f, 0.07098922f, 0.08363266f, -0.00799911f, -0.14117815f, 0.02131446f, -0.01956892f, 
    0.00346989f, 0.02988184f, -0.20596416f, 0.00312787f, 0.14297244f, -0.05756586f, 0.08436458f, -0.09945077f, 
    0.09800477f, 0.01677928f, -0.11671547f, 0.02863664f, 0.10264868f, -0.06955071f, 0.00510776f, -0.04671295f, 
    -0.17987093f, -0.16803020f, 0.00761740f, 0.20463389f, 0.04254163f, -0.04074712f, -0.06140052f, 0.06545467f, 
    0.01122936f, 0.06356490f, -0.02801159f, 0.03944946f, -0.31483454f, 0.19588232f, 0.02082763f, -0.21320051f, 
    0.02458370f, 0.16338457f, 0.05475701f, -0.04645409f, 0.08211829f, -0.01027379f, -0.06299211f, 0.08265419f, 
    -0.21481249f, -0.02451026f, 0.06487677f, 0.02099846f, 0.03794442f, -0.00807540f, -0.07080442f, 0.09588159f, 
    0.19662748f, 0.05196411f, 0.10971232f, -0.09010083f, 0.21874373f, -0.00630561f, -0.01664419f, -0.09683154f, 
    -0.02204485f, -0.01417363f, 0.00125910f, -0.08403127f, -0.09449961f, -0.01522441f, -0.21786770f, -0.00722340f, 
    -0.02145022f, 0.00255706f, -0.07034869f, 0.11352335f, 0.07070201f, 0.01335252f, 0.03181609f, 0.07127801f, 
    0.01982378f, 0.02090197f, -0.05686625f, -0.13191383f, 0.06414837f, -0.04309336f, -0.03527163f, 0.14729454f, 
    0.00318392f, -0.00567872f, 0.04612581f, 0.03653300f, 0.11839255f, -0.03298901f, 0.03986401f, 0.03315385f, 
    -0.11108181f, -0.06328368f, 0.03317930f, 0.19873172f, -0.24391241f, -0.03754227f, 0.08800122f, -0.07339281f, 
    0.03028639f, -0.20852816f, 0.05808442f, 0.08972862f, -0.29908797f, -0.18628949f, -0.08858054f, 0.06278098f, 
    -0.02316319f, -0.03317447f, -0.00501233f, -0.00347565f, 0.02320019f, 0.07019506f, 0.14036985f, 0.09732521f, 
    0.09371223f, -0.22063044f, -0.09432883f, 0.03401574f, 0.05581804f, -0.01276548f, -0.14936393f, -0.08575625f, 
    -0.07980936f, -0.01112294f, 0.02859912f, 0.02470591f, -0.16126248f, 0.01864064f, -0.12898155f, -0.17978375f, 
    0.08159339f, -0.09284428f, 0.05413875f, 0.00265562f, 0.05602049f, -0.04156366f, 0.03587359f, -0.03352540f, 
    -0.02406380f, -0.07897426f, -0.22430529f, 0.00594873f, 0.05862744f, 0.07208060f, -0.07364205f, -0.07640792f, 
    -0.06238125f, 0.02391155f, 0.02085298f, -0.03495993f, 0.08695234f, 0.09150131f, -0.02082699f, 0.05220330f, 
    -0.15133370f, -0.03558099f, -0.01037032f, 0.03827862f, -0.08946378f, -0.08409682f, 0.10367491f, 0.28432086f, 
    0.17638461f, -0.11477228f, -0.19945253f, 0.07402096f, -0.08025428f, -0.14202154f, -0.08280120f, 0.01704919f, 
    0.09732813f, 0.12699312f, -0.01376896f, 0.04487412f, -0.29866254f, -0.08100906f, -0.00363158f, -0.01297850f, 
    0.00815336f, -0.04717261f, 0.26090589f, 0.00268409f, 0.04280842f, 0.16478762f, -0.10960481f, 0.03530648f, 
    -0.40347365f, 0.14115262f, -0.12322647f, -0.21342801f, 0.14515810f, -0.00624678f, 0.02761938f, 0.02603039f, 
    -0.04813658f, -0.04113007f, -0.02207300f, -0.17087746f, 0.14506204f, 0.14476946f, 0.12215159f, -0.16319309f, 
    0.03684942f, -0.08336792f, -0.10643069f, -0.14955841f, -0.08182166f, -0.00060121f, -0.04604556f, -0.01926905f, 
    -0.39517257f, -0.14457519f, -0.03168613f, 0.07981211f, 0.12197409f, 0.11643832f, 0.01135920f, 0.02920786f, 
    0.10791863f, -0.07285921f, 0.10152734f, -0.10399368f, -0.23664711f, 0.00852753f, 0.10164351f, 0.17040589f, 
    -0.04658956f, -0.00555213f, 0.09728145f, -0.00284530f, 0.10945780f, -0.09618002f, -0.15411542f, 0.05805652f, 
    -0.18847935f, -0.03178539f, 0.05619195f, -0.03273673f, 0.01283357f, -0.01554941f, 0.06800680f, -0.05006051f, 
    -0.11338161f, -0.06886768f, 0.08867197f, -0.01040840f, 0.03970761f, -0.16743305f, -0.12282857f, 0.00554561f, 
    0.05911278f, -0.15301324f, -0.08333661f, 0.04247083f, -0.03492155f, -0.00616465f, 0.11024354f, -0.12209807f, 
    -0.04382345f, 0.22944646f, 0.11412905f, 0.09648138f, -0.08534478f, -0.15302368f, -0.02618060f, 0.00761674f, 
    0.01952933f, -0.05646240f, 0.08130297f, 0.03842932f, -0.09229074f, -0.02316284f, 0.01800669f, 0.00316934f, 
    -0.01694245f, 0.05280466f, 0.01096919f, 0.08247800f, -0.00269560f, -0.01637185f, -0.01491721f, 0.02919842f, 
    -0.44574782f, 0.01544804f, -0.10687245f, -0.02817774f, 0.03073354f, 0.04305195f, -0.08782411f, -0.16951799f, 
    0.01872227f, 0.18017288f, -0.03151954f, 0.10637290f, 0.02461012f, 0.02852356f, -0.19059572f, 0.08858474f, 
    0.02186165f, 0.05402416f, 0.01206489f, -0.04521189f, 0.09251136f, -0.02418831f, 0.00812119f, 0.03786762f, 
    0.06595769f, -0.18691626f, 0.00492900f, 0.02624323f, 0.04020187f, 0.01548620f, -0.05207239f, -0.10428496f, 
    -0.08147877f, -0.11100372f, -0.05889464f, -0.05216484f, -0.18294537f, 0.15245831f, 0.11309543f, 0.06657062f, 
    0.07318111f, 0.01887868f, -0.03400232f, 0.03903149f, -0.00287134f, -0.02242104f, 0.09422823f, -0.11545068f, 
    -0.17234525f, 0.06182007f, -0.07804199f, -0.14296472f, -0.03070416f, 0.00228581f, 0.01221795f, -0.13353762f, 
    0.10121919f, -0.03580699f, 0.01797980f, -0.20225963f, 0.23774353f, 0.25063363f, 0.10557875f, -0.34277928f, 
    0.12279776f, -0.05581035f, 0.09035916f, -0.00803868f, 0.01122795f, 0.12876202f, -0.03621731f, 0.06000456f, 
    0.04841247f, 0.07986590f, -0.12799674f, 0.04292547f, 0.09628694f, 0.04097849f, -0.10846575f, 0.16330306f, 
    -0.04401641f, -0.11293782f, 0.00868141f, -0.17566475f, 0.05144372f, -0.01244923f, 0.13284735f, -0.03166269f, 
    0.05031336f, -0.11359765f, -0.03715205f, -0.03790150f, -0.02645008f, 0.13770978f, 0.20634720f, -0.15873069f, 
    0.20694780f, -0.04108035f, -0.02948011f, -0.21003114f, 0.06676292f, 0.00416825f, -0.04167541f, 0.00662535f, 
    0.07420012f, 0.02433313f, -0.06074726f, -0.12182570f, -0.27112812f, 0.09378749f, 0.04647721f, -0.16069458f, 
    -0.26214713f, -0.06173206f, -0.03967500f, 0.09370358f, 0.08499240f, 0.00308695f, 0.06876649f, 0.13931957f, 
    0.07084931f, -0.02751718f, -0.11165770f, -0.28966895f, -0.11843058f, 0.09967986f, -0.07078118f, -0.10882530f, 
    -0.18012710f, 0.03783509f, -0.11300628f, -0.01781029f, -0.09448921f, 0.08239917f, -0.05236627f, 0.18244959f, 
    0.04841233f, 0.06075265f, -0.07802250f, 0.01994865f, 0.05965412f, 0.08434265f, -0.05075132f, 0.02347560f, 
    -0.11973916f, 0.07261696f, -0.05841749f, 0.10567677f, -0.06488511f, -0.10074426f, -0.01666540f, -0.11594301f, 
    0.02421002f, -0.03478010f, 0.08748309f, 0.04130500f, -0.28736913f, -0.13264008f, -0.18313730f, -0.07551159f, 
    -0.11780952f, -0.10307228f, 0.08709399f, -0.02002977f, -0.12594172f, 0.07284673f, 0.03295743f, 0.09703033f, 
    -0.27093029f, 0.21071674f, 0.06855187f, -0.16526967f, -0.05528678f, 0.03572943f, -0.03363418f, 0.00975406f, 
    -0.09235688f, -0.02779421f, 0.20142485f, 0.08660159f, -0.14190783f, -0.08798956f, 0.05290551f, -0.10581720f, 
    -0.00136088f, -0.01650753f, 0.09257996f, 0.02688483f, 0.06193770f, 0.01404466f, -0.07666899f, -0.00132908f, 
    -0.04230760f, 0.00331356f, -0.03734419f, 0.20757799f, -0.00806335f, 0.07353102f, 0.00463884f, -0.09744607f, 
    -0.03940640f, -0.02869858f, -0.01656731f, 0.01753452f, 0.40360311f, -0.13828894f, 0.27543607f, 0.09005746f, 
    0.03854916f, -0.04114226f, -0.01655989f, -0.02930759f, 0.01488945f, 0.00161619f, 0.02363405f, 0.01796267f, 
    0.32854176f, -0.00701344f, 0.02263986f, 0.12090826f, -0.13158686f, -0.00660353f, 0.03059068f, 0.01066929f, 
    0.17690235f, -0.09424426f, 0.09178839f, 0.15009330f, -0.02478424f, 0.09072585f, 0.19565281f, 0.14561559f, 
    0.05113365f, 0.00215159f, 0.07985205f, 0.10448934f, -0.05294403f, 0.03422814f, -0.03645996f, -0.10111207f, 
    0.21116279f, 0.07196530f, 0.00430924f, -0.06569086f, -0.00090903f, -0.05458197f, -0.08269802f, 0.05301516f, 
    0.06962349f, 0.09362619f, -0.03298444f, 0.03488263f, -0.20867932f, -0.09302064f, -0.05164449f, 0.03581509f, 
    0.05476590f, -0.04630892f, 0.05332340f, 0.02374608f, -0.00340184f, -0.13562804f, 0.25126895f, 0.10080166f, 
    0.17267552f, -0.05129284f, 0.23879059f, -0.12874919f, 0.09738486f, 0.03214344f, 0.12274221f, 0.10519984f, 
    0.01603393f, 0.10199434f, -0.18586256f, 0.13113515f, -0.00485621f, 0.06920059f, 0.00191194f, 0.11252251f, 
    -0.10226735f, 0.00177080f, 0.00920258f, -0.01150875f, 0.11990666f, -0.00882867f, 0.09236975f, -0.20600255f, 
    0.19598225f, -0.16230030f, 0.12936367f, -0.02639612f, -0.14373572f, -0.11487368f, -0.00830943f, -0.07825977f, 
    0.02924033f, 0.06332751f, -0.13829780f, -0.02644855f, 0.14114314f, 0.11076142f, 0.03340495f, -0.12580822f, 
    -0.03767358f, 0.06810892f, 0.09616740f, 0.06555368f, -0.01993156f, 0.02339139f, 0.00744734f, 0.11791363f, 
    -0.09238826f, -0.09017706f, -0.24205297f, -0.32243997f, -0.10088672f, -0.05530363f, -0.07066096f, -0.00922680f, 
    0.02838839f, 0.00791843f, 0.01006044f, 0.09831999f, 0.16279303f, -0.25108096f, 0.01925250f, 0.06885600f, 
    0.04147164f, 0.11722211f, 0.05093363f, 0.20824654f, 0.10214832f, -0.11536987f, -0.06304638f, -0.02708369f, 
    0.04605195f, -0.14011799f, -0.11719187f, -0.10977612f, -0.08447558f, 0.00654335f, 0.04852193f, 0.00835258f, 
    -0.00989947f, 0.00379534f, -0.00429077f, -0.10353458f, 0.07334404f, 0.06254346f, 0.00017824f, -0.16671018f, 
    -0.00937385f, -0.01579122f, -0.05948846f, 0.08241132f, -0.04011578f, -0.02794540f, 0.11969697f, 0.12888022f, 
    0.32220647f, -0.22613059f, 0.10781994f, -0.13911161f, -0.13915232f, 0.01154014f, 0.22532442f, -0.11397934f, 
    -0.03373621f, -0.02635660f, 0.03588776f, 0.14295538f, -0.05457802f, -0.07098354f, 0.02919056f, -0.13730973f, 
    0.18117027f, 0.07051411f, -0.08858624f, 0.08211663f, 0.06011673f, -0.01221975f, -0.05050498f, 0.12459628f, 
    -0.47729748f, 0.09285713f, -0.06644842f, 0.23677771f, 0.02930291f, 0.19893388f, -0.09654424f, 0.10603655f, 
    -0.00753303f, 0.05281004f, -0.02923460f, -0.08249796f, 0.15616398f, 0.05313550f, 0.05362840f, -0.24923106f, 
    0.09509921f, 0.08745413f, 0.02314021f, 0.03934359f, -0.18495098f, -0.13874131f, 0.14631981f, -0.08279460f, 
    -0.05257087f, 0.05994536f, 0.10805286f, -0.42622903f, -0.01285700f, 0.08479910f, 0.07826791f, 0.05320262f, 
    0.08261408f, -0.14684786f, -0.13329136f, -0.11273029f, -0.11384724f, -0.26232913f, -0.09956796f, -0.28991643f, 
    0.01054298f, -0.03243540f, 0.01813155f, 0.01408170f, -0.02063809f, 0.02655651f, 0.04520402f, 0.09548882f, 
    0.08592605f, -0.18426600f, -0.00499085f, 0.04904471f, 0.07811910f, -0.02557372f, -0.03372680f, 0.00179779f, 
    -0.11131623f, 0.00729100f, -0.07054784f, -0.05463618f, -0.12630589f, -0.11178392f, -0.17583252f, 0.12201111f, 
    -0.06076141f, 0.00060060f, 0.10502724f, 0.03160345f, -0.15318601f, 0.01359316f, -0.08890011f, -0.10465091f, 
    -0.14794143f, 0.13764970f, -0.14071006f, -0.01352955f, -0.02437143f, -0.12385210f, -0.02244507f, 0.01045517f, 
    -0.00671158f, -0.05706175f, -0.00511686f, -0.02330298f, -0.20495287f, 0.10601689f, -0.01276895f, -0.00251741f, 
    -0.11550194f, 0.01234494f, -0.04517814f, 0.05192538f, 0.03452894f, -0.02048103f, 0.01780966f, -0.20303681f, 
    0.17522846f, -0.11634257f, -0.09909582f, -0.08614106f, -0.06680468f, -0.02059720f, 0.04702899f, 0.07344045f, 
    -0.06185150f, -0.01733470f, 0.07616608f, 0.06287821f, -0.21903048f, 0.26782706f, 0.03087124f, -0.13075259f, 
    -0.18295938f, -0.02648869f, 0.14045468f, -0.06695695f, 0.02121920f, 0.14580834f, 0.13709408f, 0.03944988f, 
    -0.02672181f, 0.04674532f, -0.17133005f, -0.15583751f, -0.00886569f, 0.09740981f, -0.05564640f, -0.02486208f, 
    -0.11198834f, -0.04536920f, -0.05230995f, -0.07326452f, -0.04898363f, -0.43172875f, 0.05576738f, 0.02096267f, 
    -0.00384828f, -0.01073254f, 0.03104854f, 0.03291001f, -0.03857498f, -0.09709460f, 0.08014870f, -0.18942301f, 
    0.09753689f, -0.11647744f, -0.21259433f, -0.16838488f, -0.03381440f, -0.00096680f, -0.01417556f, -0.07946423f, 
    -0.04971940f, -0.00030965f, 0.04120049f, 0.03180178f, -0.32976049f, 0.14891833f, 0.14251120f, 0.15606207f, 
    -0.09641654f, -0.01815597f, -0.11954336f, 0.12173100f, -0.08144549f, 0.03819388f, 0.08793871f, 0.07554977f, 
    0.11359042f, 0.08011393f, 0.06071547f, -0.16563396f, 0.09706662f, -0.04520337f, 0.02609496f, -0.14128871f, 
    -0.10508489f, 0.01295619f, -0.03577216f, 0.13925061f, -0.14725564f, -0.00130187f, 0.02058695f, 0.02353216f, 
    0.02883166f, 0.01145195f, 0.03258254f, 0.01857401f, -0.09678771f, 0.05582361f, -0.08376708f, -0.01882570f, 
    0.08217677f, 0.10848250f, -0.02318949f, 0.01049565f, 0.02570768f, -0.02972690f, -0.02701547f, 0.00704984f, 
    0.10206922f, 0.03838117f, -0.09438114f, 0.00415366f, -0.21921870f, 0.14745322f, 0.04170779f, -0.10638920f, 
    0.03452274f, -0.01914021f, 0.02293617f, -0.08283743f, -0.01401423f, -0.01068223f, 0.10746690f, -0.23316003f, 
    -0.32154220f, -0.05384718f, 0.01213841f, 0.15403396f, 0.03679667f, 0.03982102f, 0.22855978f, 0.00162215f, 
    0.14762688f, 0.01338960f, -0.04617596f, 0.08719327f, 0.08482840f, -0.10219259f, -0.00034656f, -0.19101816f, 
    0.05215425f, -0.02258178f, 0.03316291f, 0.05778364f, 0.00885357f, 0.12244071f, -0.03761997f, 0.02223846f, 
    0.00291380f, -0.19291808f, -0.16997610f, 0.18392515f, 0.08011676f, 0.10019344f, 0.07005446f, -0.05063533f, 
    0.03163021f, 0.02168892f, 0.05139065f, 0.01671006f, 0.15800022f, 0.16580383f, 0.02253030f, -0.29277623f, 
    -0.03486019f, -0.00873687f, 0.01367659f, -0.02332525f, -0.01634908f, 0.01292449f, -0.04867679f, -0.09731361f, 
    -0.11444483f, -0.11610176f, -0.03685693f, 0.06947141f, 0.10911053f, 0.04144477f, 0.04740900f, -0.04251988f, 
    -0.12776916f, -0.04844875f, 0.06156428f, -0.04924204f, 0.16380852f, -0.03279074f, -0.08680902f, -0.15009312f, 
    -0.13746223f, 0.07376266f, -0.12515923f, -0.20175058f, -0.03058679f, -0.07090581f, 0.01255780f, -0.04719100f, 
    0.22437537f, -0.45794910f, 0.05546927f, -0.19532561f, -0.00078987f, 0.00341278f, 0.06409318f, -0.07270811f, 
    0.05216935f, -0.04022244f, 0.13587295f, 0.13229676f, -0.32336193f, 0.14260466f, 0.08495580f, -0.17137639f, 
    -0.09951333f, 0.05915100f, 0.08174445f, 0.07522415f, -0.03737307f, 0.01554381f, 0.05266799f, 0.05781136f, 
    -0.06065516f, 0.13044858f, -0.17878729f, -0.05603522f, -0.04086966f, 0.02057588f, -0.11915931f, -0.12450072f, 
    -0.15239047f, 0.14127390f, 0.02718672f, 0.09764660f, 0.00148397f, 0.06684986f, -0.08690007f, 0.10264275f, 
    0.08194376f, 0.03124310f, -0.01540492f, -0.08631568f, -0.05377351f, 0.03721001f, 0.08593750f, 0.04303745f, 
    0.32667282f, 0.01607286f, 0.04682578f, 0.26780212f, -0.12335610f, 0.05805402f, -0.07997909f, 0.09744096f, 
    -0.02334434f, 0.02700218f, -0.02473475f, -0.03577768f, 0.01417040f, 0.01047722f, -0.13480479f, 0.35357907f, 
    0.01844595f, 0.07488143f, 0.00751538f, 0.10637731f, -0.02225053f, -0.02498373f, 0.10089756f, -0.13174558f, 
    0.09287909f, 0.11812384f, 0.18961239f, 0.18469484f, 0.08520895f, 0.09687918f, 0.09322552f, 0.01771614f, 
    0.00659972f, 0.00965878f, -0.08711474f, -0.00056574f, -0.05584961f, 0.09944154f, -0.16694991f, 0.03983303f, 
    -0.00352979f, -0.01908646f, -0.07298324f, 0.05096222f, 0.07346855f, -0.03216960f, 0.02089955f, -0.08904587f, 
    0.00421644f, -0.09795376f, -0.06245139f, -0.18551803f, -0.07164192f, -0.00120064f, -0.00146902f, 0.13786013f, 
    0.04410166f, -0.02725388f, -0.15275642f, -0.18512280f, -0.21543792f, 0.14623509f, -0.00091214f, 0.17362668f, 
    0.01067495f, -0.01244089f, -0.00239925f, -0.04283804f, -0.06192023f, -0.05526806f, -0.01835333f, -0.20095475f, 
    0.09738763f, -0.03266868f, 0.08863308f, 0.11006237f, -0.01849375f, 0.04623664f, 0.00211856f, -0.06909309f, 
    -0.08968491f, 0.03365086f, -0.02451788f, -0.00418788f, -0.36970529f, 0.02872414f, 0.01498402f, -0.13486850f, 
    -0.12598214f, 0.04970959f, -0.03527678f, -0.02415932f, 0.01839789f, -0.02677175f, -0.00799402f, -0.11208556f, 
    0.15457323f, 0.07769497f, 0.18196270f, 0.08654852f, -0.01857427f, -0.01527788f, -0.01134275f, -0.01225547f, 
    -0.00604203f, 0.02587503f, -0.04212078f, -0.08912231f, 0.09339843f, -0.16007519f, -0.13889140f, -0.20112711f, 
    -0.05257568f, -0.01892756f, -0.05036505f, -0.03226305f, -0.04230836f, -0.02143925f, 0.01389207f, -0.03215520f, 
    -0.34518611f, 0.10686705f, -0.22419754f, 0.02149652f, -0.06360082f, 0.01792720f, -0.12618756f, -0.03832348f, 
    -0.00185156f, -0.03513366f, -0.01470365f, 0.00630907f, 0.26652426f, -0.08291632f, -0.01242611f, 0.03432968f, 
    0.08427902f, 0.05105400f, 0.01128146f, -0.01980512f, -0.02557413f, -0.02313387f, -0.00771797f, -0.03343105f, 
    -0.11337555f, -0.18624380f, -0.04739845f, 0.10819080f, -0.02480422f, -0.04653744f, 0.03682271f, -0.08669490f, 
    0.06043078f, 0.02473227f, -0.05754134f, -0.10264318f, -0.13040519f, 0.11433797f, -0.03398333f, -0.09301871f, 
    -0.00419364f, 0.01441365f, 0.00782791f, -0.10469890f, -0.00196189f, -0.00391743f, -0.01901899f, -0.15106709f, 
    -0.12858982f, 0.14632499f, 0.11532720f, 0.06544017f, 0.01592329f, 0.06415315f, 0.07388715f, -0.06319346f, 
    -0.06952684f, -0.04293194f, 0.03836077f, -0.09345049f, -0.20540752f, -0.07798995f, -0.05327496f, -0.05762879f, 
    -0.07857123f, -0.06985259f, -0.05808359f, 0.03089612f, -0.00411873f, 0.02115226f, -0.04915101f, -0.00536450f, 
    0.13393563f, 0.03150027f, 0.11752056f, 0.13921182f, 0.00497148f, 0.04653839f, -0.02028363f, -0.02808072f, 
    -0.01065986f, 0.03398838f, 0.05743314f, 0.01456861f, 0.12998120f, 0.12131706f, -0.04307630f, 0.03735367f, 
    -0.00381165f, 0.00566325f, 0.05591207f, 0.01900023f, 0.01783316f, 0.00653360f, 0.06297721f, 0.01312475f, 
    -0.20637959f, 0.05041358f, -0.13244152f, -0.16088028f, 0.07561874f, 0.05558360f, -0.01640582f, -0.06259606f, 
    -0.11277402f, -0.10791795f, 0.10472717f, -0.05245056f, 0.21961334f, 0.18241161f, 0.01616595f, 0.11041719f, 
    0.05667344f, -0.01552627f, -0.03691136f, -0.05142355f, -0.06615072f, 0.05186559f, -0.01371306f, 0.01102633f, 
    0.13562466f, 0.03649554f, 0.05666458f, 0.28707182f, 0.05749660f, -0.13551103f, -0.03724652f, -0.06154932f, 
    -0.00969078f, 0.02154175f, -0.08104628f, -0.06245460f, -0.06934445f, -0.07393962f, 0.14467050f, -0.06721795f, 
    0.13739213f, -0.16312513f, 0.05288389f, 0.05027599f, -0.07770945f, 0.04731705f, 0.10966438f, 0.00384262f, 
    -0.06480209f, -0.15279204f, 0.00130081f, -0.09549208f, 0.02152953f, 0.05836160f, -0.00914119f, 0.01231361f, 
    0.00619777f, -0.04763706f, 0.00055016f, -0.06562997f, 0.01801153f, -0.13163175f, 0.06420956f, -0.05966897f, 
    -0.07025523f, -0.03035012f, -0.02988810f, -0.08966666f, 0.00563573f, -0.07382122f, -0.01430726f, -0.00664689f, 
    0.18056691f, 0.11582197f, 0.07208595f, -0.10143638f, -0.16025935f, -0.01965626f, -0.05355085f, 0.00201550f, 
    -0.07283251f, 0.02333259f, -0.06563900f, 0.01203318f, 0.08370649f, 0.12241030f, 0.09639707f, 0.07103764f, 
    0.00697583f, 0.06450956f, 0.07268115f, 0.09200931f, 0.00810320f, 0.01524452f, -0.06988007f, -0.04760030f, 
    0.11360791f, 0.07486897f, 0.02053286f, -0.01383506f, -0.04546414f, -0.09139576f, 0.08029243f, 0.01111300f, 
    -0.04378684f, 0.03161475f, 0.04272699f, -0.10391550f, -0.26372075f, 0.04453333f, 0.10395256f, -0.07911637f, 
    -0.06687265f, -0.02936432f, 0.04685107f, -0.03853867f, -0.04030932f, -0.02938015f, 0.02107297f, 0.00566782f, 
    -0.08838010f, -0.06901930f, 0.17416923f, 0.15237543f, 0.07477856f, -0.03071462f, -0.04880018f, -0.08239000f, 
    -0.03606709f, -0.01432283f, -0.06777183f, -0.09363178f, -0.10960691f, -0.07557990f, 0.01222028f, -0.03761683f, 
    -0.01311806f, -0.03218263f, 0.01010112f, -0.08348949f, -0.04173523f, 0.00544760f, -0.10665487f, 0.02878410f, 
    0.11039780f, 0.12122656f, 0.10792825f, 0.12885021f, 0.07085311f, 0.03191309f, 0.07078911f, 0.00405701f, 
    -0.02738645f, 0.06144572f, 0.03269753f, -0.05842060f, -0.05177984f, -0.02271186f, 0.19698060f, -0.08449368f, 
    -0.15539394f, -0.04478241f, 0.04068603f, -0.02511727f, 0.00241912f, 0.05384136f, -0.00983361f, -0.00106136f, 
    0.12900539f, -0.06424758f, 0.12489228f, 0.18241833f, -0.01048551f, 0.00068064f, -0.04440132f, -0.10662754f, 
    0.04802291f, 0.02660084f, -0.04455371f, -0.01722019f, -0.17090794f, -0.04544796f, -0.08826829f, -0.13228396f, 
    -0.04167485f, -0.07590322f, -0.01287134f, -0.06211809f, -0.06330765f, -0.06958643f, -0.08282947f, -0.00443318f, 
    0.13700958f, -0.24994448f, 0.16154657f, -0.20758149f, -0.00656578f, -0.02688934f, 0.00318653f, -0.02063190f, 
    -0.00363592f, 0.01969474f, -0.03737463f, -0.03180941f, 0.11682785f, -0.09897105f, 0.00307424f, 0.07498451f, 
    -0.06134243f, -0.06577419f, -0.09712444f, -0.05352034f, -0.09318555f, -0.02871045f, -0.00373618f, -0.01987548f, 
    -0.10008398f, -0.02311390f, -0.30598372f, -0.07424726f, -0.09274933f, -0.00847079f, -0.08827139f, -0.00876792f, 
    -0.12883362f, 0.04343636f, 0.09181334f, -0.03154038f, -0.14638162f, -0.02303975f, -0.01955603f, -0.13792127f, 
    0.01015858f, -0.04979643f, -0.07759389f, -0.10866446f, 0.02409721f, -0.03075689f, -0.02315302f, -0.04125127f, 
    -0.19262482f, 0.05026398f, -0.02611533f, -0.06707834f, -0.07742348f, -0.04555862f, -0.05536965f, -0.02432124f, 
    0.00112296f, 0.05129671f, 0.01530642f, -0.01364472f, -0.05481748f, 0.12837943f, 0.13639194f, 0.06753342f, 
    0.07260101f, 0.07822760f, 0.06815573f, -0.01662857f, -0.04835565f, -0.01643864f, 0.03580688f, 0.01417935f, 
    0.15808721f, -0.00444188f, 0.10180236f, 0.08778138f, -0.03687397f, -0.03356765f, 0.00667135f, 0.01699909f, 
    -0.12445595f, -0.05126885f, 0.00257837f, 0.02810864f, 0.08144470f, 0.19281347f, 0.03997857f, 0.05580441f, 
    0.09926542f, 0.04564900f, 0.05953107f, -0.01443977f, 0.01901595f, -0.04576096f, 0.06521823f, -0.02218545f, 
    0.10022829f, -0.05608280f, 0.07085114f, -0.01958098f, -0.04077330f, 0.02420036f, -0.07726771f, 0.07481076f, 
    -0.04879994f, -0.10749271f, -0.12657791f, -0.05647752f, -0.05349942f, 0.09166449f, -0.06545641f, -0.09603897f, 
    -0.03579916f, -0.05348330f, 0.01127213f, -0.06839915f, -0.00602721f, 0.00987929f, -0.01496798f, 0.01214640f, 
    0.00633631f, -0.09097487f, 0.03797781f, -0.04241145f, 0.03674529f, 0.04874219f, 0.00835860f, -0.10311126f, 
    0.01378710f, 0.02611137f, 0.00696712f, -0.04895109f, 0.07122850f, 0.11394492f, -0.04399530f, -0.15289971f, 
    0.02369498f, -0.02200541f, -0.00117349f, 0.00835362f, -0.01767406f, 0.08196525f, -0.05819269f, -0.00393153f, 
    0.04499495f, 0.07944261f, 0.07121979f, 0.16839090f, -0.02199519f, -0.00240924f, 0.00929753f, -0.04110169f, 
    -0.04122622f, -0.01629841f, -0.04959549f, -0.00694975f, -0.11499055f, -0.10298388f, 0.07665506f, -0.04908416f, 
    -0.03562761f, 0.00726950f, -0.02495517f, -0.01866619f, 0.01233161f, -0.04602268f, 0.00081115f, -0.00137164f, 
    0.09461363f, 0.15530173f, 0.04899817f, 0.14953798f, -0.08076877f, 0.03985128f, 0.01202868f, -0.02523035f, 
    -0.01991451f, -0.03816707f, -0.02945567f, -0.05104473f, -0.17777967f, 0.00496538f, -0.09325569f, -0.13246001f, 
    -0.05343265f, 0.07963703f, -0.04876444f, -0.01740192f, 0.01797111f, -0.00456264f, -0.02762705f, -0.11903428f, 
    0.17073984f, -0.02922202f, 0.02901368f, 0.01358285f, 0.01941256f, -0.02950827f, -0.03276229f, -0.06804872f, 
    -0.08666238f, -0.03714655f, -0.03037085f, -0.02903340f, -0.03630634f, 0.01010530f, -0.07686807f, -0.18560858f, 
    0.02385832f, 0.03748205f, -0.05081406f, -0.04214587f, 0.00840108f, -0.06805541f, -0.00144730f, -0.05265702f, 
    -0.17677660f, -0.16500901f, -0.00224740f, -0.03716125f, -0.09084772f, -0.06820063f, -0.02549537f, -0.03765533f, 
    -0.06019946f, 0.04223992f, -0.00368775f, -0.04508932f, 0.14641696f, 0.10087282f, 0.12043374f, 0.04500647f, 
    0.04427952f, 0.03196583f, -0.02999150f, -0.10508411f, 0.01662894f, -0.04384358f, -0.06177634f, -0.01465533f, 
    0.02721037f, 0.12123112f, 0.01527568f, 0.11699627f, 0.07484891f, -0.03530740f, 0.01883464f, -0.06805196f, 
    0.05217039f, 0.04430787f, 0.01444446f, -0.02508529f, 0.27588627f, -0.06888782f, 0.15783013f, 0.00254939f, 
    0.02256573f, -0.00275232f, -0.04253235f, -0.04969435f, -0.05852477f, 0.10469370f, -0.02121847f, -0.10367566f, 
    -0.04814187f, 0.19846787f, -0.06897065f, 0.02687041f, -0.11581136f, 0.11236024f, 0.02918157f, 0.01272101f, 
    0.02620663f, 0.01227638f, -0.03483870f, -0.03018304f, 0.00364562f, 0.00399490f, -0.23503773f, 0.01762395f, 
    -0.07240969f, -0.06331681f, -0.07223796f, -0.02933741f, -0.06834208f, -0.01365188f, -0.00426981f, -0.04186989f, 
    0.26760754f, -0.27959040f, 0.14411756f, -0.03978532f, 0.01571774f, 0.03072713f, -0.01928271f, -0.02473373f, 
    -0.05846183f, -0.04028668f, -0.08269882f, -0.03596521f, 0.05214080f, 0.14979707f, 0.07893819f, 0.26181775f, 
    0.16077143f, 0.04820522f, 0.00245952f, 0.07648961f, -0.09602050f, 0.03955774f, -0.02655696f, -0.05003669f, 
    0.14887764f, -0.07739132f, 0.17162803f, -0.06177473f, -0.00719327f, 0.01533499f, -0.01561800f, 0.01459168f, 
    0.00370362f, 0.09844004f, -0.03294830f, -0.02127440f, 0.09999536f, 0.16084293f, 0.06872620f, -0.09302326f, 
    -0.08352552f, 0.01418537f, 0.01248856f, -0.04763104f, -0.01416980f, -0.05381054f, -0.01812916f, -0.00090834f, 
    0.01848946f, 0.13839640f, 0.10674424f, 0.16194269f, 0.03766520f, -0.05586816f, -0.01902966f, 0.00579002f, 
    -0.05245085f, 0.00108901f, -0.03720135f, 0.02287530f, 0.04438961f, 0.05418447f, -0.19413023f, 0.07257612f, 
    -0.08496946f, -0.02973118f, -0.06039466f, -0.00187230f, 0.00871283f, 0.01539339f, -0.05419907f, -0.01711143f, 
    0.17772655f, 0.02304607f, -0.11442980f, 0.16339840f, 0.14344820f, -0.01690532f, 0.00351977f, 0.03739841f, 
    0.02664740f, 0.02864010f, 0.02676492f, 0.04643232f, 0.00988818f, 0.04647385f, -0.19483219f, 0.11893341f, 
    0.00918866f, 0.01967088f, -0.04008822f, -0.03819555f, 0.00547081f, -0.03561770f, 0.01019016f, -0.00271800f, 
    -0.16578117f, -0.01797900f, -0.06766892f, 0.01424524f, -0.08076155f, -0.03207318f, -0.07042423f, -0.00610149f, 
    -0.04192533f, -0.03403800f, -0.06237118f, -0.10454189f, -0.06356175f, -0.00048496f, 0.00190825f, -0.01265085f, 
    -0.05759052f, -0.01260852f, -0.01944711f, -0.09851401f, 0.00375650f, -0.01975825f, 0.02715817f, 0.03035571f, 
    -0.25426722f, 0.05066527f, 0.00150960f, 0.00110610f, -0.11991666f, 0.05369766f, -0.04883924f, -0.06913841f, 
    -0.00695047f, -0.00832147f, -0.07887329f, -0.14079012f, -0.09672842f, 0.12099966f, -0.00930021f, -0.02249036f, 
    -0.02922190f, 0.01883758f, 0.01255979f, -0.01874287f, -0.00516014f, -0.01101641f, -0.03443770f, -0.11269768f, 
    0.04066954f, -0.03377670f, -0.00654886f, -0.12616302f, 0.00675637f, -0.00100024f, -0.00583364f, 0.05015489f, 
    0.01350132f, 0.04807312f, -0.01555081f, -0.02246299f, 0.07753532f, -0.10889322f, -0.14409888f, 0.07975720f, 
    0.06827226f, -0.02626280f, -0.05835834f, -0.08467693f, 0.01278133f, 0.00592281f, 0.00619113f, 0.08150464f, 
    -0.19776715f, 0.11712355f, 0.12361138f, -0.06683096f, -0.02137693f, 0.02839214f, -0.00079473f, -0.02357486f, 
    -0.02404092f, -0.03480442f, -0.06473011f, 0.12105608f, -0.07763996f, -0.12498345f, -0.09227761f, 0.17161059f, 
    0.17720722f, -0.03065823f, 0.03055956f, 0.01344839f, 0.00664333f, -0.03893246f, 0.16845526f, 0.09968536f, 
    -0.14733508f, 0.01736780f, -0.18224919f, 0.05511414f, -0.02765246f, -0.06340511f, 0.00311983f, 0.04550932f, 
    0.04019363f, 0.03280457f, 0.03861910f, 0.10277303f, 0.05837697f, -0.19658785f, -0.04863085f, -0.17861590f, 
    0.06431900f, 0.01623264f, 0.11317062f, -0.06254774f, -0.00294949f, 0.12513234f, -0.04020066f, 0.01999759f, 
    0.04958186f, -0.03622326f, -0.07249567f, 0.10435388f, 0.04439221f, 0.01964986f, -0.08423477f, -0.06321026f, 
    0.05573295f, -0.07613352f, 0.04657483f, 0.05414440f, 0.22293742f, 0.02527286f, 0.01790249f, 0.15148804f, 
    -0.01012886f, -0.02740524f, -0.08771636f, -0.06990194f, 0.00580373f, -0.00216689f, -0.00569802f, -0.11140713f, 
    -0.06643892f, -0.00804138f, 0.21264756f, 0.04713200f, -0.11164732f, 0.09939862f, -0.01061666f, -0.01075208f, 
    -0.00356792f, 0.06320026f, 0.06138207f, -0.08432659f, 0.23240680f, 0.12024314f, -0.31704926f, 0.01240016f, 
    0.01500990f, -0.02215315f, 0.04740623f, -0.05897156f, -0.03671174f, -0.02973946f, 0.01533441f, 0.04969292f, 
    0.01333393f, 0.16261227f, -0.14746785f, 0.01867775f, -0.04064083f, -0.08441328f, 0.01363496f, 0.09944940f, 
    -0.01842570f, 0.05923750f, -0.16610841f, -0.03478110f, 0.05516475f, 0.05661375f, 0.06733051f, 0.11684674f, 
    -0.16628790f, -0.00301932f, 0.04061433f, 0.08179190f, -0.06408419f, -0.07959390f, -0.00734651f, -0.07868903f, 
    -0.02484433f, -0.19032605f, 0.04142513f, 0.09080159f, 0.06953933f, -0.03405555f, -0.05213680f, 0.04632844f, 
    0.01373403f, 0.05723224f, 0.05046017f, -0.18101811f, -0.20344554f, 0.15652362f, -0.02124017f, -0.03226432f, 
    -0.17142610f, -0.00328154f, -0.02990808f, -0.04795102f, 0.06819411f, -0.01348950f, 0.06585344f, 0.00988758f, 
    0.03249429f, -0.20201138f, -0.24475373f, -0.38125834f, -0.02776950f, -0.05400481f, 0.08817939f, -0.01669536f, 
    0.01144838f, -0.05751825f, -0.09080073f, -0.03559896f, 0.11134786f, -0.20776007f, -0.01615982f, 0.13996048f, 
    -0.08997809f, -0.11380028f, -0.04772138f, -0.11959559f, 0.06272019f, -0.10198364f, -0.16792390f, -0.00959955f, 
    -0.06420687f, -0.03317311f, -0.04697710f, 0.11275933f, 0.03119176f, -0.07907335f, -0.10160282f, -0.06295677f, 
    -0.00213154f, -0.03228505f, -0.12553926f, -0.03121918f, 0.20011289f, 0.00055007f, -0.12776724f, -0.02364835f, 
    -0.00085013f, -0.01118085f, -0.13010363f, -0.09466811f, -0.05484324f, 0.02574917f, 0.05261893f, -0.00097645f, 
    0.01356437f, 0.19838168f, -0.22083223f, -0.19911286f, -0.02205122f, 0.01282366f, 0.01657727f, -0.01751970f, 
    0.00974063f, -0.03385990f, 0.09948888f, -0.00950478f, 0.01738929f, 0.01636821f, 0.06174627f, -0.04116036f, 
    -0.05236786f, -0.04083376f, -0.03330276f, 0.00141681f, -0.03346153f, -0.00722495f, -0.07169931f, 0.02436730f, 
    0.00425985f, -0.00876573f, 0.03886170f, -0.05991096f, 0.03224518f, -0.07029079f, -0.05240048f, 0.09001143f, 
    0.03894077f, 0.00232986f, 0.08822078f, 0.01202262f, 0.06939705f, 0.09478383f, -0.01869239f, 0.10718709f, 
    0.04551841f, -0.00825171f, -0.06067592f, -0.09507903f, -0.01432247f, -0.01537937f, -0.02264621f, 0.03553482f, 
    0.00142155f, -0.18372263f, 0.01691058f, -0.11233184f, 0.05671821f, -0.03061902f, -0.14639553f, -0.06835452f, 
    0.01102613f, 0.06891709f, 0.07782977f, -0.08895201f, 0.04874646f, -0.00551994f, -0.04635517f, 0.12234636f, 
    0.04131364f, 0.00175827f, -0.07327762f, -0.06371041f, -0.08819651f, -0.08970339f, 0.09635791f, 0.05850403f, 
    -0.20868798f, -0.14046344f, 0.04009468f, -0.13674407f, -0.04655049f, 0.06438734f, -0.00625241f, -0.07229643f, 
    0.05738494f, -0.10833852f, -0.11990007f, 0.01915371f, 0.00053741f, -0.09470011f, -0.01354322f, 0.08728693f, 
    -0.17214322f, 0.00976681f, 0.05420034f, -0.03288348f, -0.02787266f, 0.00323377f, -0.07976209f, 0.09360650f, 
    -0.05425867f, -0.17609565f, -0.11670801f, -0.23059572f, 0.04102273f, 0.08936069f, 0.09939332f, -0.10494023f, 
    -0.00819459f, -0.05183822f, 0.07341992f, -0.04203848f, 0.15572338f, -0.03907054f, -0.04716058f, 0.16837184f, 
    0.03460854f, 0.01740800f, -0.06088763f, -0.03940408f, 0.07802749f, 0.03463133f, -0.09766909f, -0.19853832f, 
    -0.06995542f, -0.03718540f, 0.05229180f, -0.01675832f, 0.05116374f, -0.01734835f, -0.04775089f, -0.01931746f, 
    0.01476578f, -0.01589145f, 0.01544540f, -0.04200977f, 0.03075781f, -0.10040579f, -0.09544889f, -0.23099051f, 
    0.09529901f, -0.10345568f, -0.01080398f, -0.05084011f, 0.02687475f, 0.04441477f, -0.02429750f, 0.00865949f, 
    0.00882632f, -0.06750487f, -0.18350784f, -0.08914462f, 0.02982397f, 0.04345957f, -0.05956279f, 0.02874386f, 
    0.10280655f, 0.08009811f, 0.07886253f, -0.06602205f, 0.07176630f, -0.06495781f, 0.04093565f, 0.18382415f, 
    0.01530669f, -0.16551337f, -0.05224455f, 0.00522224f, 0.00894619f, -0.08881051f, -0.12033208f, -0.03539212f, 
    -0.16652086f, -0.03154083f, 0.05972414f, 0.15622586f, 0.05154817f, 0.03374446f, 0.03106061f, -0.04559884f, 
    0.07573625f, 0.00675378f, 0.02624013f, 0.11901756f, -0.17676394f, 0.02498282f, 0.13267487f, 0.05156826f, 
    -0.07165222f, -0.00594327f, -0.06782036f, -0.18885322f, 0.06082386f, -0.07224343f, -0.03232607f, -0.01225678f, 
    0.19885078f, -0.02099604f, -0.32280159f, -0.02070441f, 0.02116896f, 0.02463435f, 0.03541977f, -0.08864360f, 
    -0.03876490f, -0.02645215f, -0.05274546f, 0.18243882f, 0.08308092f, 0.06088605f, 0.05507519f, 0.17579032f, 
    -0.07671200f, -0.11021386f, 0.05408399f, -0.02490719f, 0.03006556f, -0.05840162f, 0.07449345f, 0.09277016f, 
    -0.09296685f, 0.02167864f, 0.01675545f, -0.05682521f, -0.04105179f, -0.00163081f, -0.01630821f, -0.06578464f, 
    -0.00963662f, 0.01853966f, 0.05175553f, 0.11066379f, 0.09598656f, 0.08152614f, 0.04214174f, 0.14260499f, 
    0.02110016f, 0.07566845f, -0.01715661f, -0.02252321f, -0.01195606f, 0.02556137f, 0.01132880f, -0.07213457f, 
    0.07318696f, 0.03276711f, 0.06669012f, 0.04534812f, 0.06293890f, -0.10203417f, 0.00852691f, -0.10761710f, 
    0.04239241f, -0.08413250f, -0.17831962f, -0.05830633f, 0.13021871f, -0.10420392f, 0.09337009f, 0.07323951f, 
    0.06545535f, -0.02252111f, -0.09498042f, 0.01184220f, -0.06009429f, -0.09550310f, 0.09802677f, -0.05738444f, 
    -0.10738087f, 0.11848668f, 0.07988171f, -0.14103547f, -0.10166292f, -0.04685980f, -0.00063487f, 0.03619203f, 
    0.01744548f, -0.05590370f, 0.02646902f, 0.09721840f, 0.04788612f, -0.02120176f, 0.08162499f, 0.07651964f, 
    -0.09251118f, 0.00557306f, 0.02726463f, 0.00182613f, -0.10917270f, 0.03161730f, 0.01172776f, 0.01418598f, 
    -0.24251918f, 0.14848125f, -0.05775688f, -0.17639102f, 0.02122211f, -0.00360472f, -0.18538237f, 0.07518391f, 
    0.10418618f, 0.00993759f, -0.03314208f, -0.02057285f, 0.20300505f, -0.06105651f, -0.04076524f, 0.01631214f, 
    0.09603968f, -0.09361659f, -0.01406498f, -0.05696635f, -0.06043429f, 0.03653960f, -0.19825193f, 0.10725506f, 
    -0.10551180f, -0.10305515f, -0.19405337f, -0.26158652f, -0.02071379f, -0.04375062f, -0.09065360f, 0.04075528f, 
    0.08818783f, -0.12556806f, 0.05762216f, -0.05850664f, 0.11824625f, 0.07570560f, 0.02309940f, 0.05583060f, 
    0.09989715f, -0.02979058f, 0.02721516f, -0.05006335f, 0.04614415f, 0.07241784f, 0.01172717f, 0.02397376f, 
    0.01782055f, 0.02007506f, 0.03108355f, 0.08080027f, 0.13164696f, 0.00806445f, -0.05199162f, -0.04014704f, 
    -0.05869148f, -0.05018964f, 0.05184753f, -0.04200650f, 0.10229623f, -0.23791620f, 0.19377263f, -0.12057077f, 
    -0.01872247f, 0.00181022f, -0.02316983f, -0.04717255f, -0.04585681f, 0.04279749f, 0.05311513f, 0.08745714f, 
    -0.05736551f, 0.22682188f, -0.01545639f, 0.05719500f, 0.02487759f, -0.13969928f, -0.13746481f, 0.09055611f, 
    0.01071514f, -0.08272593f, 0.03954315f, -0.06268796f, -0.17819764f, -0.13947462f, 0.15599449f, -0.08396206f, 
    -0.02976040f, -0.08087361f, 0.09252144f, -0.13380998f, 0.04434744f, 0.04748694f, 0.02710393f, 0.05304816f, 
    -0.11853110f, 0.29042417f, -0.06733038f, -0.05652402f, -0.02993930f, 0.00850243f, -0.15012547f, 0.01172830f, 
    0.04361517f, -0.05084091f, -0.02412139f, 0.00857053f, -0.07047322f, -0.19029407f, -0.17020680f, -0.02577751f, 
    0.05688369f, 0.03513645f, 0.05318877f, -0.03367013f, 0.04209374f, 0.09912739f, 0.02625063f, 0.06486233f, 
    0.22785904f, -0.00660445f, -0.09247801f, -0.03099288f, 0.04733412f, 0.00028130f, -0.00133791f, -0.06624507f, 
    -0.03138020f, 0.09317937f, -0.01651733f, 0.10276818f, -0.11560424f, 0.01993405f, 0.15920070f, -0.07542116f, 
    -0.07406094f, 0.01893125f, 0.13990228f, -0.13698187f, -0.07216923f, -0.01264076f, -0.02190497f, 0.06144954f, 
    -0.07373222f, -0.04354183f, 0.15324892f, 0.07169547f, -0.00913011f, -0.03146538f, 0.05015128f, -0.07498799f, 
    0.03010523f, -0.07006349f, -0.00430899f, -0.05935906f, 0.10962111f, -0.07975613f, 0.04521007f, 0.08471216f, 
    0.11273146f, -0.08819478f, -0.05023874f, -0.06080495f, -0.05308807f, 0.05871183f, -0.01573849f, -0.02598320f, 
    -0.19691047f, 0.06251293f, -0.01994574f, 0.04791035f, 0.00835565f, 0.04451137f, 0.12396989f, -0.10415319f, 
    -0.04124118f, -0.00956714f, 0.03437989f, -0.05899130f, 0.11162069f, 0.14965728f, 0.00098207f, -0.07705255f, 
    -0.00198290f, 0.05819709f, 0.02610583f, -0.16830009f, 0.01435073f, 0.03435421f, 0.03431232f, 0.04439035f, 
    0.07021330f, -0.10751805f, 0.07163711f, -0.00532959f, 0.01463156f, -0.13513641f, 0.04303514f, -0.05898287f, 
    0.06272345f, -0.08319688f, 0.04579954f, -0.02293947f, 0.15481569f, 0.21686190f, -0.42562959f, -0.29751620f, 
    -0.01414660f, 0.00068375f, 0.01221510f, 0.01357369f, 0.07466377f, -0.08443838f, -0.05645378f, 0.08195288f, 
    0.10091693f, -0.13859956f, -0.20939954f, -0.13760719f, 0.12945774f, -0.14594649f, -0.06679107f, 0.00041081f, 
    -0.01923866f, 0.06550084f, 0.08607218f, -0.06544217f, 0.03829046f, 0.14407930f, -0.15485105f, 0.05144455f, 
    -0.03524439f, 0.03804725f, 0.03434548f, 0.02806612f, 0.02514592f, 0.06979960f, 0.04525940f, 0.08639439f, 
    -0.02661935f, 0.03186599f, -0.03350065f, -0.09143339f, -0.18929352f, -0.04329221f, 0.00068812f, -0.06003657f, 
    0.01543775f, 0.04171124f, 0.05503117f, 0.11199405f, 0.08285398f, 0.08383132f, -0.00811234f, 0.01598460f, 
    -0.03452189f, 0.03481400f, 0.05630793f, -0.05087115f, 0.04120189f, -0.01824778f, 0.03878367f, 0.09672670f, 
    0.19524562f, -0.17592260f, 0.19215916f, 0.21668166f, 0.00534880f, -0.03654702f, -0.04943512f, 0.00954141f, 
    0.01772998f, -0.05935447f, 0.15598620f, 0.04579372f, -0.22714169f, 0.16549492f, 0.24680306f, -0.08413942f, 
    0.00197067f, -0.02170560f, 0.06248221f, -0.03106377f, 0.00352454f, -0.03040709f, -0.09108217f, -0.01876847f, 
    0.00025368f, -0.24127637f, -0.06410642f, 0.08575681f, -0.09448029f, -0.01751596f, -0.02316969f, 0.04274292f, 
    -0.12976822f, -0.05412674f, -0.01517728f, -0.02056482f, -0.39578354f, -0.05398958f, 0.09719839f, -0.24378547f, 
    -0.05513671f, -0.00351201f, -0.15601057f, -0.04625319f, -0.02500314f, -0.05591170f, -0.05873510f, -0.08148441f, 
    -0.18789285f, 0.21991889f, 0.17556760f, -0.15597373f, 0.10334720f, -0.03966628f, 0.01763299f, 0.00627729f, 
    -0.03174805f, 0.03064808f, -0.05265547f, -0.07234767f, 0.11244847f, 0.12772836f, 0.01412593f, 0.00772721f, 
    -0.03746561f, 0.11654322f, 0.02130841f, -0.09304231f, 0.09910639f, 0.16674851f, -0.05288329f, 0.08505928f, 
    -0.01647658f, 0.27088588f, -0.34411168f, -0.35521659f, 0.09856382f, -0.03278448f, 0.03965206f, 0.07931121f, 
    -0.08407151f, 0.06518268f, -0.09683312f, -0.11881904f, -0.31491122f, 0.29001087f, -0.00814753f, -0.09232944f, 
    0.13094747f, -0.00161955f, -0.07763182f, -0.03432481f, 0.08278419f, 0.03083955f, 0.00828782f, 0.05671854f, 
    -0.30721736f, -0.24539486f, 0.00700817f, 0.13392951f, 0.09002195f, -0.15436657f, 0.05223106f, -0.04021405f, 
    0.05272782f, -0.03354728f, -0.10374653f, 0.06006773f, 0.07699458f, 0.21485990f, 0.20711952f, 0.12891500f, 
    -0.04993984f, -0.05505612f, -0.05690185f, 0.00628041f, 0.04791493f, 0.00867292f, 0.12326909f, 0.04796329f, 
    0.05066856f, -0.06034162f, 0.09851085f, 0.09223234f, -0.00560063f, -0.05261265f, -0.10922293f, 0.09941082f, 
    0.02225629f, 0.15575318f, 0.02471995f, 0.00787655f, -0.17118099f, -0.10521595f, 0.14909995f, -0.05595079f, 
    0.01683792f, 0.09530228f, 0.02261413f, 0.12171540f, 0.03631747f, -0.01121732f, 0.09652885f, 0.04383799f, 
    -0.29838139f, 0.17568889f, -0.07060470f, -0.09867970f, 0.03615984f, 0.06071390f, 0.04373312f, -0.05548431f, 
    0.03792389f, -0.08355205f, -0.03871471f, 0.06907437f, 0.17917681f, 0.20693336f, -0.12914272f, 0.10101318f, 
    -0.18252721f, 0.02989717f, -0.00022480f, 0.07821178f, -0.06678355f, -0.00814401f, 0.04056034f, -0.04551643f, 
    0.06842445f, -0.03278273f, -0.00289350f, -0.24319476f, -0.00781690f, -0.09824521f, -0.06553667f, 0.00066835f, 
    -0.09848748f, -0.05174579f, 0.07459600f, 0.07730516f, 0.27751780f, -0.23923647f, -0.23566027f, 0.19698147f, 
    -0.07302250f, 0.02123546f, -0.00492469f, -0.03940013f, -0.05326475f, 0.09439843f, -0.07395997f, 0.05672625f, 
    -0.05390229f, -0.12387615f, -0.03808266f, -0.14572673f, 0.14945255f, 0.03124824f, 0.01935998f, -0.04047348f, 
    0.15728040f, -0.01985653f, 0.09739541f, -0.12687890f, 0.27005771f, -0.17283443f, -0.11174365f, -0.06717624f, 
    0.08527156f, -0.03331237f, 0.06877993f, 0.00865061f, -0.01443868f, 0.00180886f, -0.09185550f, 0.07868072f, 
    -0.50028098f, -0.09127023f, -0.13565496f, 0.05457366f, -0.07464692f, 0.03223858f, 0.13971594f, -0.02444151f, 
    -0.04357611f, 0.10748858f, 0.08172761f, 0.03489032f, 0.30927750f, 0.09599043f, -0.10707213f, 0.00028828f, 
    0.10958320f, 0.06604249f, 0.11998227f, 0.07160052f, 0.03446093f, -0.06253839f, -0.00692367f, -0.09072494f, 
    0.00896910f, 0.09490166f, -0.18395197f, 0.02917653f, -0.03825402f, -0.04966246f, 0.10163673f, -0.17698301f, 
    -0.07292300f, 0.00296528f, -0.06087387f, -0.13825899f, -0.11643267f, 0.13414337f, 0.12042999f, -0.15708531f, 
    0.12219694f, 0.09283320f, 0.00803679f, 0.04440208f, -0.02838285f, -0.06630564f, -0.00262098f, -0.07813477f, 
    0.08199288f, -0.33157966f, -0.42597035f, -0.00149177f, -0.03538740f, -0.05346731f, -0.01879331f, 0.16965142f, 
    0.06614117f, 0.00344455f, 0.06489590f, -0.05929790f, -0.07585303f, 0.07300207f, 0.16498660f, -0.03449016f, 
    0.09228894f, -0.11831279f, -0.05008695f, -0.08027981f, 0.03779366f, 0.15300147f, -0.03939796f, -0.12547524f, 
    0.09373108f, -0.12913033f, -0.10492995f, -0.03823024f, 0.04057181f, -0.04115912f, 0.01353443f, -0.09410271f, 
    -0.14036974f, 0.10706887f, -0.01004390f, 0.01143724f, -0.46478665f, 0.34965298f, -0.32772928f, 0.44765675f, 
    0.06916369f, -0.03996405f, 0.12310086f, -0.06237475f, -0.03567363f, 0.07764981f, -0.00663130f, 0.04645102f, 
    0.10537920f, -0.03432811f, -0.08572847f, 0.03848088f, 0.08593044f, -0.00580042f, -0.01671902f, 0.02715221f, 
    -0.08983076f, 0.00542701f, -0.12788145f, 0.03766449f, -0.11426656f, 0.01317146f, 0.00598967f, -0.25477922f, 
    0.14894861f, 0.06634061f, -0.02267770f, -0.10517969f, -0.16195433f, -0.07151432f, -0.12757459f, 0.11000093f, 
    0.09396744f, -0.06488075f, -0.04060120f, -0.09346322f, -0.06421705f, -0.11856060f, 0.01875362f, 0.00063917f, 
    0.00297275f, 0.08341164f, 0.00752613f, 0.02565292f, 0.02630702f, 0.05663417f, 0.04521137f, -0.14426525f, 
    -0.10560362f, -0.00546232f, -0.00046250f, -0.05230979f, 0.00668585f, 0.02561538f, 0.07238197f, 0.02427517f, 
    0.15469527f, -0.01565573f, 0.23267923f, 0.02374075f, 0.00919500f, 0.05225810f, -0.01107513f, -0.16163908f, 
    -0.11008144f, -0.04815186f, -0.07430045f, -0.00358784f, -0.01809010f, -0.07833222f, 0.02518029f, -0.08372134f, 
    0.07040770f, 0.01513601f, -0.03481737f, -0.13071500f, 0.06040232f, -0.13633858f, -0.00135748f, 0.06455350f, 
    -0.09771522f, 0.04272929f, -0.21593779f, -0.21860376f, 0.09306429f, -0.03923391f, -0.13140921f, -0.08557320f, 
    -0.20735937f, -0.12789868f, 0.12446554f, -0.16496110f, -0.00832255f, -0.21339755f, -0.03111335f, 0.05693890f, 
    0.02559705f, 0.03260347f, -0.05209795f, 0.12951383f, -0.02926291f, 0.03719667f, 0.00106755f, -0.02377346f, 
    0.01177702f, -0.17321916f, 0.19993277f, -0.05999729f, 0.07604685f, -0.03814708f, -0.04227162f, 0.00711487f, 
    -0.02472806f, 0.03485100f, -0.00341655f, 0.06963810f, -0.03814695f, -0.42530623f, 0.08326827f, -0.08559743f, 
    0.14866564f, 0.03008626f, -0.10150728f, -0.03271531f, 0.01511042f, -0.04584090f, 0.03768257f, -0.03403813f, 
    -0.11196146f, -0.16294938f, 0.15507662f, -0.04933085f, 0.07282905f, 0.05199883f, 0.11346588f, 0.00500363f, 
    0.05741546f, 0.05503703f, -0.06501407f, -0.05552389f, -0.13399039f, 0.17033526f, 0.05479902f, 0.00168121f, 
    0.19386995f, 0.05572749f, 0.06149685f, -0.01111395f, -0.07208029f, 0.02482213f, -0.10431118f, 0.01233915f, 
    0.07333554f, -0.12791352f, 0.03122544f, 0.08477411f, -0.01477378f, -0.08656590f, -0.13849668f, 0.01154167f, 
    -0.13267440f, -0.00704752f, 0.10638390f, 0.20676929f, -0.23663007f, 0.13184348f, 0.12115259f, -0.16153440f, 
    0.00729122f, 0.08182964f, -0.06134740f, -0.07793259f, -0.03221428f, 0.03090341f, -0.00968817f, 0.03846283f, 
    0.02947951f, -0.06075891f, 0.01393633f, 0.01193024f, 0.04100888f, -0.03812968f, 0.01389761f, -0.11420571f, 
    -0.06642976f, -0.02570917f, 0.14149259f, 0.00846675f, 0.22611080f, 0.13238820f, -0.19154245f, 0.01142459f, 
    0.08821326f, -0.08117509f, -0.05187253f, -0.07673120f, -0.06003575f, -0.01660361f, -0.01817810f, 0.01558467f, 
    -0.23620182f, 0.29136208f, 0.08331428f, 0.15145628f, 0.07717505f, 0.05858826f, -0.02708447f, -0.00990452f, 
    -0.02511205f, -0.00796082f, -0.12092873f, 0.07607187f, 0.01491793f, -0.01220732f, 0.05311209f, -0.04208837f, 
    0.05194504f, 0.08602177f, 0.08397260f, -0.10528240f, 0.09192163f, 0.02472269f, 0.10589667f, -0.02927136f, 
    -0.07303876f, -0.17490456f, 0.04907693f, -0.15861613f, -0.19177864f, -0.02305985f, 0.05091253f, -0.05707259f, 
    0.00736028f, 0.01511460f, -0.05439087f, 0.06252406f, 0.32583517f, 0.12942626f, -0.06399664f, -0.17650491f, 
    -0.03177364f, 0.00341028f, 0.05217370f, -0.07248374f, -0.05139944f, -0.08226360f, -0.03140604f, 0.04898965f, 
    0.08603416f, 0.00925701f, 0.10961249f, -0.37115055f, -0.11558216f, 0.07022021f, 0.03120300f, 0.11375592f, 
    0.14171880f, 0.07842239f, 0.01148113f, -0.17010236f, 0.15313214f, -0.21172568f, -0.27353951f, 0.02684257f, 
    0.00210428f, -0.00020023f, 0.10236706f, -0.07898630f, 0.02915196f, 0.04861687f, -0.13015313f, -0.03455589f, 
    0.11097972f, -0.39257407f, 0.19543646f, -0.03386140f, -0.09626739f, 0.04780311f, 0.04993184f, 0.22324297f, 
    -0.07346385f, 0.06544767f, 0.01829213f, 0.02085152f, 0.09676652f, -0.08918101f, -0.12856516f, 0.18651631f, 
    -0.01340296f, 0.05335411f, 0.05490359f, 0.00467299f, 0.03836557f, 0.02602706f, 0.05748380f, -0.04363537f, 
    -0.52663660f, 0.25533047f, 0.25962201f, 0.04727750f, 0.00276296f, -0.06760757f, -0.01280690f, 0.04167637f, 
    0.15581694f, 0.10724302f, 0.05775984f, -0.05464677f, -0.22430982f, 0.10171005f, -0.15544984f, -0.35307550f, 
    0.06229781f, 0.03008944f, -0.01730432f, 0.08581583f, 0.01097047f, -0.03279964f, -0.04167143f, -0.08343359f, 
    0.27099961f, -0.17137678f, 0.16743217f, -0.04037496f, 0.07396874f, 0.08794232f, 0.03221053f, 0.01363077f, 
    -0.04041821f, -0.04080591f, 0.05890108f, 0.06545501f, -0.08570401f, -0.02656243f, 0.02069082f, 0.09531238f, 
    0.09269696f, -0.17204590f, -0.19132443f, 0.09287197f, 0.03843360f, -0.08537430f, 0.05576293f, 0.01055525f, 
    0.12260814f, -0.14276375f, 0.01917525f, 0.04387378f, 0.08147429f, 0.04985738f, -0.14970639f, -0.03731842f, 
    -0.03779346f, 0.08656271f, -0.04878148f, -0.05192714f, -0.22966661f, 0.11823837f, -0.12468760f, 0.06557509f, 
    0.01014090f, -0.03335679f, 0.01565861f, 0.07982285f, 0.01909644f, -0.04157703f, 0.08772279f, 0.05002220f, 
    -0.18305291f, -0.33656830f, 0.15317523f, 0.02039466f, 0.05369366f, 0.03307217f, -0.01377529f, 0.06581490f, 
    0.07856210f, -0.01207971f, 0.03386661f, 0.02897638f, 0.42529565f, -0.04082383f, -0.20880742f, 0.16180883f, 
    0.04970027f, 0.09499724f, 0.02767630f, 0.11480030f, -0.04409572f, -0.03187951f, -0.02804589f, 0.06536483f, 
    -0.35140076f, -0.00337671f, 0.10484593f, -0.19310552f, 0.06959742f, 0.02916294f, -0.02893975f, -0.03729309f, 
    0.06248777f, -0.15879436f, 0.02446298f, 0.12989332f, -0.15526403f, 0.11161492f, 0.17783976f, -0.01841736f, 
    -0.16475381f, 0.06581230f, -0.05916845f, 0.01727076f, -0.10754895f, -0.00098890f, 0.00469012f, 0.11961088f, 
    -0.19830284f, -0.02708592f, 0.18412271f, -0.01799269f, -0.13287678f, -0.06751303f, 0.02845218f, 0.07636976f, 
    -0.08214401f, -0.05057987f, -0.07647271f, -0.13333121f, 0.01701498f, 0.14204340f, 0.20263387f, 0.14830798f, 
    -0.03983697f, -0.05467796f, -0.09689865f, 0.05598039f, 0.02297457f, 0.05700470f, -0.06548338f, -0.06420998f, 
    0.13731104f, 0.00977969f, -0.02563763f, 0.00357091f, 0.10046241f, 0.01746902f, 0.09712214f, 0.00431144f, 
    0.00454019f, -0.03283794f, 0.08021418f, -0.01846481f, 0.27845997f, 0.06145056f, 0.07504364f, -0.09174047f, 
    -0.00678394f, -0.03512787f, 0.06138766f, 0.09231801f, -0.07954665f, 0.03961091f, -0.05322601f, -0.10185253f, 
    -0.10276289f, -0.15801318f, -0.01314172f, -0.13250467f, -0.03950713f, 0.03082255f, -0.01218921f, -0.10114019f, 
    0.03103508f, 0.10478307f, 0.03698184f, 0.01521717f, -0.40953821f, -0.18900751f, 0.11258733f, 0.03503666f, 
    0.10894324f, 0.01690944f, -0.03193328f, -0.08367651f, 0.08826073f, 0.09859367f, 0.03237909f, 0.20328102f, 
    0.09375232f, 0.01776602f, 0.05882324f, -0.09812346f, 0.11192757f, 0.12753581f, -0.00389277f, 0.00627734f, 
    0.07443104f, 0.01662741f, 0.08538672f, -0.00472973f, -0.15918373f, -0.02671110f, -0.14391676f, -0.12559375f, 
    0.03393219f, -0.03038033f, 0.04155788f, 0.04388757f, -0.04783631f, -0.01150181f, 0.03643982f, 0.03986492f, 
    -0.04937088f, -0.09492749f, 0.02013167f, 0.02335553f, -0.00203813f, 0.01147150f, 0.07198282f, 0.06009888f, 
    -0.02712798f, 0.13400419f, 0.11023107f, 0.11611676f, -0.11024758f, 0.04582001f, -0.05684558f, 0.20924737f, 
    0.09572384f, 0.01594047f, 0.10252329f, -0.06741107f, -0.04098539f, -0.13913977f, -0.01377175f, 0.01726275f, 
    -0.18003446f, -0.08640752f, -0.20791546f, -0.13928521f, -0.09290960f, -0.00841722f, -0.05042097f, 0.00530065f, 
    -0.06627179f, 0.04457965f, 0.16608852f, 0.02973614f, -0.16049370f, -0.10381295f, -0.09008428f, -0.06492586f, 
    -0.01407134f, -0.04393486f, 0.02635247f, -0.00966156f, -0.05346100f, -0.03626762f, -0.11206346f, 0.03335137f, 
    0.23755716f, 0.00016967f, -0.10497463f, 0.04438367f, -0.03656761f, 0.06878558f, -0.01859421f, -0.00315944f, 
    -0.04595381f, 0.08082434f, 0.08352943f, -0.06839719f, -0.30542526f, -0.26596427f, -0.03424204f, 0.05113677f, 
    0.05070091f, 0.00972278f, -0.01049691f, 0.00179915f, 0.10548925f, -0.03874932f, -0.05302056f, -0.05658423f, 
    0.15554355f, -0.03178076f, 0.08254577f, -0.07620685f, -0.11979587f, 0.07378780f, -0.05569575f, 0.00907740f, 
    0.05213595f, -0.02197294f, -0.08970998f, -0.14521173f, 0.17713535f, 0.01072660f, -0.03609059f, 0.00622634f, 
    -0.05412729f, -0.06530217f, -0.02102152f, 0.00643621f, 0.01545411f, 0.09388481f, -0.07572212f, 0.00758839f, 
    -0.35568762f, -0.26220492f, -0.03468086f, -0.11521232f, -0.04473653f, -0.01605766f, 0.00755166f, 0.16264139f, 
    0.07447281f, 0.06580746f, -0.01833603f, 0.07689931f, -0.19812998f, -0.11023043f, 0.09934577f, 0.00135047f, 
    0.03000269f, 0.02942843f, 0.02332838f, 0.05181780f, 0.03017956f, 0.06985554f, -0.01007642f, -0.07311356f, 
    -0.12562945f, 0.13870353f, 0.02044963f, 0.09561362f, 0.06394396f, -0.03109221f, 0.01048881f, -0.00860441f, 
    0.00617745f, 0.05772366f, -0.07587354f, -0.03747667f, 0.20118824f, 0.02241728f, -0.06044887f, 0.23190168f, 
    -0.05188483f, -0.13403206f, -0.01169812f, 0.06099959f, -0.01687972f, -0.05876412f, -0.03805549f, 0.04263728f, 
    -0.12412681f, 0.09440804f, -0.08529198f, -0.00177153f, 0.04108813f, -0.03877949f, -0.22899909f, -0.07687560f, 
    0.01395736f, -0.14215925f, -0.10986368f, 0.02933020f, -0.16226241f, -0.05906968f, -0.05052541f, 0.09072492f, 
    0.04863641f, 0.11964853f, -0.04740332f, -0.00821137f, 0.05268126f, 0.11633956f, 0.08007775f, 0.05715018f, 
    0.00679593f, 0.00292877f, -0.02925872f, 0.07004119f, 0.04334598f, 0.13351211f, 0.05613606f, 0.09020470f, 
    0.07457550f, -0.00930628f, 0.05350785f, 0.05242262f, 0.10384849f, -0.02892654f, 0.14381741f, -0.14918113f, 
    -0.05724998f, -0.02950349f, 0.02077433f, -0.07008713f, 0.04299625f, -0.11806210f, -0.04453643f, 0.01259446f, 
    -0.37775871f, -0.05919480f, 0.04297586f, 0.10544545f, 0.04243518f, 0.03708513f, -0.12488660f, -0.09807784f, 
    -0.00281643f, 0.09966239f, 0.05663833f, 0.00351319f, -0.25296795f, -0.25847977f, -0.11555942f, -0.10840937f, 
    -0.00029551f, -0.01344866f, 0.06107392f, -0.01806946f, 0.10358912f, 0.10189749f, 0.07495897f, 0.06660469f, 
    -0.30174068f, -0.05691469f, -0.17311494f, -0.21665481f, 0.12188634f, 0.03031502f, -0.02459034f, 0.06508353f, 
    0.06103680f, 0.04029886f, -0.07921267f, 0.02133369f, -0.38048038f, -0.26353478f, -0.13663046f, -0.18291155f, 
    0.09212622f, 0.03094590f, -0.13198934f, -0.02809525f, 0.10043936f, -0.10910492f, 0.08870532f, -0.02120862f, 
    0.01799880f, 0.03702847f, -0.00955395f, 0.04081175f, -0.06115461f, 0.02952383f, -0.03698684f, -0.04484079f, 
    0.04942870f, -0.09573762f, 0.01614011f, 0.05533906f, 0.27112514f, -0.11367996f, -0.08731120f, 0.30389914f, 
    -0.03078758f, -0.03642432f, 0.04004080f, 0.05697300f, 0.00600913f, -0.02841187f, -0.13101341f, -0.09701342f, 
    0.18727110f, 0.06345398f, -0.07228549f, -0.06402484f, 0.01246577f, 0.01730670f, 0.15511924f, 0.00254339f, 
    0.03050943f, -0.06055956f, 0.03283723f, -0.06208922f, -0.12580976f, 0.16739078f, -0.14173745f, -0.17114769f, 
    0.07577626f, 0.01628049f, -0.00051023f, 0.04056783f, 0.12122702f, -0.00338704f, 0.03639271f, -0.03996247f, 
    0.08705930f, 0.02948434f, -0.02903982f, 0.07370817f, 0.09045151f, 0.09253591f, -0.02045009f, 0.08300556f, 
    -0.07438925f, 0.07905368f, 0.07754491f, 0.02006878f, 0.23794715f, 0.17353655f, 0.20673595f, -0.00128510f, 
    0.09608355f, 0.05694241f, -0.12499724f, 0.04971840f, -0.07608194f, -0.03933206f, -0.10275888f, -0.10128386f, 
    -0.48247382f, -0.14465310f, 0.28304484f, 0.12912934f, 0.14079288f, -0.01824010f, 0.06436344f, -0.05371413f, 
    0.00231498f, 0.10961019f, -0.05545731f, 0.11293844f, -0.18923767f, -0.13155894f, -0.18438925f, -0.21041149f, 
    0.12530310f, -0.05948733f, -0.09724949f, 0.03670505f, -0.00271519f, -0.03106518f, -0.12523535f, 0.17164616f, 
    -0.21152069f, -0.05332856f, -0.01407600f, -0.18169998f, -0.03492612f, -0.01070494f, 0.09356463f, 0.06672939f, 
    0.01862074f, 0.05778286f, 0.02396970f, 0.12103038f, 0.24214378f, 0.00951610f, -0.04841411f, -0.04688892f, 
    -0.04199621f, -0.05390213f, -0.01568192f, -0.09291738f, 0.02231750f, -0.09633698f, -0.01357752f, -0.09589913f, 
    -0.17606576f, 0.00794664f, -0.06353149f, -0.01535163f, -0.07145891f, -0.03450417f, 0.06695690f, 0.02675165f, 
    0.10287028f, 0.07629650f, -0.01338193f, -0.05186867f, -0.03606557f, 0.03505138f, -0.11656779f, 0.02453912f, 
    -0.05132253f, 0.06496895f, 0.05903740f, -0.01046430f, -0.04054864f, 0.07211580f, 0.01573295f, 0.03719196f, 
    0.24833637f, 0.12905149f, -0.01177443f, -0.05267011f, 0.14278106f, -0.08160000f, -0.05130487f, -0.04036236f, 
    -0.04435852f, 0.01877190f, 0.07207891f, 0.05802662f, -0.47131556f, -0.27276015f, -0.17614003f, -0.19302294f, 
    0.07427655f, -0.00907705f, -0.04128455f, -0.12094046f, 0.14731416f, -0.04750821f, 0.10022649f, 0.03609813f, 
    -0.28933889f, 0.10740832f, -0.09540411f, -0.15530591f, 0.02815424f, 0.05612108f, -0.04975623f, -0.00935670f, 
    0.04583299f, -0.04489350f, -0.13073897f, -0.02172824f, -0.43552300f, -0.34731048f, -0.09914330f, -0.02292369f, 
    0.13100618f, 0.03307856f, -0.02203557f, -0.05768523f, 0.05607055f, -0.09511013f, 0.03644360f, 0.01260938f, 
    0.15039392f, 0.02228555f, -0.00422774f, -0.02199830f, 0.05549608f, 0.05569100f, 0.00648808f, 0.01192694f, 
    0.05522433f, 0.00936414f, -0.00435562f, 0.04439782f, 0.23382032f, 0.09586254f, 0.01307021f, 0.01213172f, 
    -0.04064391f, -0.08942819f, 0.04469881f, 0.16948397f, -0.07720409f, 0.07775886f, 0.03460507f, 0.06345456f, 
    0.00878815f, 0.06473915f, -0.06708170f, 0.02923159f, 0.01227308f, 0.10664445f, 0.12181567f, 0.03294867f, 
    0.02470944f, -0.04661970f, 0.08087786f, -0.08935544f, -0.38831747f, -0.34486628f, -0.16344771f, -0.04027782f, 
    0.06424224f, 0.07998716f, 0.00960499f, -0.17311950f, 0.08827406f, -0.10859659f, -0.10039992f, 0.08445451f, 
    0.14200273f, 0.04590669f, 0.14194688f, 0.00875390f, 0.07606412f, -0.03410704f, 0.01403674f, -0.04774557f, 
    -0.05656445f, 0.01392062f, 0.02835813f, -0.11524428f, -0.23292902f, -0.07038645f, 0.03062001f, -0.02621950f, 
    0.07804830f, 0.06634638f, -0.01310465f, 0.00788826f, 0.02038050f, 0.16727176f, -0.02352261f, 0.04389490f, 
    -0.38052344f, -0.10818725f, -0.01981821f, -0.07012670f, 0.14930278f, -0.07275283f, 0.02267017f, -0.07558686f, 
    -0.07460292f, 0.06830556f, 0.01927949f, -0.07200275f, 0.07121196f, -0.03907938f, -0.04265738f, 0.13395941f, 
    -0.03692031f, 0.00037101f, 0.04978543f, 0.14786488f, -0.03342120f, 0.03490432f, 0.00854338f, 0.00183298f, 
    0.02142273f, 0.03076738f, -0.00000743f, -0.06810730f, -0.10346262f, -0.05151870f, 0.01002999f, -0.12589216f, 
    -0.11235759f, -0.09466315f, 0.04421399f, -0.13400897f, 0.02650810f, 0.12629086f, -0.05688030f, 0.00357799f, 
    0.00286141f, 0.06083805f, -0.08848184f, 0.01450311f, 0.06566852f, -0.01497318f, -0.02042880f, 0.17848590f, 
    -0.24939899f, -0.08584610f, -0.06119377f, -0.09460244f, 0.06674859f, 0.05312958f, 0.04463845f, -0.11979977f, 
    0.09745939f, -0.31623247f, -0.05162410f, -0.05955573f, 0.09233646f, -0.00532654f, -0.03451084f, -0.14942478f, 
    0.11408898f, 0.01080463f, 0.04232374f, 0.02895454f, 0.07163965f, 0.10349997f, 0.03088166f, 0.07458972f, 
    -0.28911155f, -0.08424441f, -0.10533142f, -0.02270960f, 0.06372349f, 0.00601383f, -0.03433933f, -0.05203663f, 
    -0.00089947f, -0.03874680f, -0.03833066f, 0.06431119f, 0.13930261f, -0.01850711f, 0.02290288f, -0.05133368f, 
    -0.12246712f, 0.02527129f, 0.02132036f, -0.16471334f, 0.20774397f, 0.14317249f, 0.03084308f, 0.08838836f, 
    0.31305811f, -0.02363347f, -0.07053980f, 0.02113036f, -0.08435004f, -0.09912824f, -0.03157948f, -0.01019840f, 
    -0.01609860f, -0.05619257f, -0.11448686f, -0.10266751f, -0.35329562f, -0.31997958f, -0.14499596f, -0.19478180f, 
    0.01210330f, 0.07263524f, -0.06088498f, -0.02608703f, -0.06112940f, -0.09700739f, -0.06426144f, -0.01246451f, 
    0.14669390f, 0.00676518f, -0.07763664f, 0.03109851f, -0.00749107f, 0.02634561f, 0.04063841f, -0.03384506f, 
    0.04360521f, 0.07449125f, -0.00724663f, -0.05640773f, -0.30866098f, -0.14275350f, 0.30846497f, 0.00754778f, 
    0.06206020f, 0.01258119f, 0.06680945f, -0.12942231f, -0.03623411f, -0.01951702f, 0.04607797f, 0.00865054f, 
    -0.29442319f, 0.04520644f, -0.10715160f, 0.17736045f, -0.03018513f, -0.04113730f, -0.04192506f, -0.00496120f, 
    -0.02663122f, 0.11506456f, 0.04102638f, -0.07329610f, -0.18096507f, -0.11215883f, -0.04321840f, 0.12627278f, 
    0.07193277f, 0.05495633f, -0.10801469f, -0.00959557f, -0.00049049f, 0.13820451f, -0.08543357f, 0.05202800f, 
    -0.01374302f, -0.00510009f, 0.24176614f, -0.04738402f, 0.10127145f, -0.03571600f, -0.11988818f, 0.07071953f, 
    -0.03266569f, 0.04056342f, 0.09192244f, 0.12169798f, 0.04947779f, 0.05064223f, 0.02189597f, 0.09158444f, 
    -0.04881160f, 0.14859313f, -0.09284246f, 0.04547050f, 0.09199202f, 0.04790186f, 0.00922784f, 0.07098696f, 
    0.07022516f, -0.02537020f, 0.04583807f, 0.13097623f, -0.00864393f, 0.00535377f, 0.05817069f, 0.06125895f, 
    0.12481560f, 0.07922674f, 0.10783708f, 0.14490451f, -0.18903019f, -0.12912944f, 0.05585255f, 0.18506110f, 
    0.01957799f, 0.03021810f, 0.02654592f, 0.02832052f, 0.05131641f, 0.07747230f, 0.05220235f, 0.15805767f, 
    -0.20159116f, 0.09033119f, -0.01329351f, 0.12992968f, 0.00158097f, 0.01374155f, -0.11129677f, 0.06041511f, 
    -0.17964526f, -0.02405509f, 0.02217045f, 0.03586898f, 0.21607074f, -0.06146937f, 0.03057524f, -0.12377103f, 
    0.06088210f, -0.03491673f, 0.02209997f, 0.05980139f, -0.03926186f, 0.07776836f, 0.03342288f, 0.06089721f, 
    0.07583065f, 0.15798576f, -0.04515243f, -0.06122500f, -0.07085025f, -0.07678299f, -0.03599260f, -0.06143988f, 
    -0.05266188f, -0.00369689f, 0.02153137f, -0.02857777f, 0.36956811f, 0.14382446f, -0.32279909f, -0.07705236f, 
    0.08175546f, 0.06009334f, -0.04092829f, -0.02163544f, -0.04766235f, -0.00409801f, -0.10653596f, 0.03458632f, 
    0.12206165f, -0.05573510f, 0.04127575f, 0.15882732f, 0.06732497f, 0.01549673f, -0.00728372f, -0.10883372f, 
    -0.01743419f, -0.05502238f, 0.01355590f, -0.09133517f, 0.20503561f, -0.05699985f, 0.07531203f, 0.16131949f, 
    -0.12854804f, 0.16633424f, 0.06813262f, -0.03740729f, 0.08227594f, 0.11395449f, 0.11569356f, 0.05678046f, 
    0.05845640f, -0.09490319f, -0.07619026f, 0.15949108f, -0.01184954f, -0.00785693f, 0.00835693f, -0.06034249f, 
    -0.02659600f, 0.01282708f, 0.00685625f, 0.00844788f, -0.25401098f, -0.29849666f, -0.10646636f, -0.21869065f, 
    0.04265217f, 0.04157060f, 0.09391604f, 0.09594444f, 0.10971508f, 0.05525210f, 0.02702323f, 0.01470292f, 
    0.22395144f, -0.07318792f, -0.02506152f, -0.02372616f, -0.15086292f, -0.01283862f, 0.04122806f, 0.02112938f, 
    -0.03334754f, -0.04033824f, -0.00209148f, -0.01651173f, 0.03933522f, -0.14006996f, 0.04609899f, 0.01622406f, 
    0.02621805f, 0.02039553f, -0.09112953f, -0.04785931f, 0.06564105f, 0.05179941f, -0.00894639f, 0.09555525f, 
    -0.23471066f, 0.07985634f, 0.00938580f, -0.00312999f, -0.00780600f, 0.01871959f, -0.07323496f, -0.07176813f, 
    -0.11196708f, 0.05514232f, 0.21219559f, -0.01120789f, -0.25505874f, -0.10089366f, -0.04307695f, -0.01336704f, 
    -0.10184545f, 0.08955044f, -0.05986992f, 0.04688198f, -0.06657153f, -0.01889728f, -0.06703466f, -0.04838926f, 
    0.17700335f, 0.19785543f, -0.09891126f, 0.08444108f, 0.05822849f, 0.04817780f, 0.02801328f, -0.00138432f, 
    0.06740461f, 0.02086631f, -0.03630776f, 0.01592307f, 0.04343722f, 0.16261221f, -0.11957601f, 0.22692724f, 
    0.13971062f, -0.13370791f, -0.04383343f, 0.02668649f, -0.23596582f, -0.01853535f, -0.13821732f, -0.10370543f, 
    0.14819102f, -0.12503858f, -0.09528331f, 0.15522131f, -0.17154232f, 0.02317418f, -0.10343162f, 0.00135111f, 
    0.13273256f, 0.04713340f, 0.08072843f, 0.04895998f, -0.17280270f, -0.07635336f, 0.00494196f, -0.07821746f, 
    -0.03648806f, -0.06113540f, 0.01221385f, 0.04653266f, -0.15061925f, 0.13674136f, 0.05838082f, 0.07433067f, 
    0.02554368f, -0.01038262f, -0.10466857f, -0.13740017f, -0.00416014f, 0.01459268f, 0.06424917f, 0.07404918f, 
    -0.07948687f, 0.00020516f, 0.05386085f, 0.06787628f, 0.01493896f, -0.12598848f, 0.01361646f, 0.06311101f, 
    -0.04061456f, -0.03566490f, -0.03047265f, 0.07908406f, -0.05485788f, -0.01068377f, -0.04450034f, 0.07224593f, 
    -0.07239221f, 0.23019944f, -0.05638380f, -0.04687724f, 0.27643281f, -0.07444312f, 0.01641839f, -0.02476570f, 
    -0.06003112f, -0.02271843f, 0.07592497f, 0.00040870f, -0.23278235f, 0.00367071f, 0.11437305f, -0.08844061f, 
    0.01443208f, -0.01165745f, -0.00227932f, 0.02501214f, -0.00529200f, 0.03068549f, 0.00633815f, -0.09793299f, 
    -0.08490846f, -0.02921755f, 0.10624021f, -0.10293093f, 0.03906263f, -0.03155193f, 0.02599675f, -0.10686599f, 
    0.07802639f, -0.00895113f, -0.01177164f, -0.10086206f, 0.23948422f, -0.35293370f, 0.03829272f, -0.02448093f, 
    0.07837626f, -0.05309281f, -0.01789324f, -0.04690509f, -0.10013196f, 0.00349769f, 0.00357250f, -0.00911224f, 
    -0.36496863f, -0.05467645f, 0.24778621f, 0.15473229f, 0.00906373f, 0.05341752f, -0.02882856f, 0.06859840f, 
    0.01163191f, -0.03560412f, 0.06757393f, 0.20775367f, 0.38393641f, -0.12846534f, -0.08301499f, -0.20284291f, 
    0.03561065f, -0.05222557f, -0.08060249f, -0.00862940f, 0.03498647f, 0.08480143f, -0.01234745f, -0.00585703f, 
    0.03877705f, 0.12866499f, -0.03662035f, 0.01576087f, -0.21196017f, -0.05733620f, 0.03098119f, -0.00606922f, 
    -0.04629526f, 0.00622134f, -0.01903288f, -0.10883398f, -0.02214576f, -0.14153975f, 0.18200409f, -0.09448493f, 
    -0.00823328f, -0.06212319f, 0.05113635f, -0.02909110f, -0.01463360f, 0.06848530f, 0.06885915f, 0.08429336f, 
    -0.13454321f, 0.03631428f, -0.01991010f, 0.14194189f, -0.04234729f, -0.07724048f, 0.04551101f, 0.01581415f, 
    0.10504452f, -0.05583122f, 0.02939118f, 0.00903530f, 0.20143631f, -0.14617574f, -0.13166609f, -0.06596473f, 
    -0.10755958f, 0.01209265f, 0.06151524f, -0.05620674f, 0.09542768f, -0.03307591f, -0.01045095f, 0.00205674f, 
    -0.40576670f, 0.19900236f, -0.08394004f, -0.00907348f, 0.04804535f, -0.02657904f, -0.00883524f, -0.07196813f, 
    -0.01960711f, -0.01029191f, -0.00571392f, -0.02403238f, 0.29788682f, 0.13875313f, -0.07943878f, -0.10078684f, 
    0.10339825f, -0.04436462f, -0.04689302f, 0.00660524f, 0.10197035f, 0.05097449f, 0.04751585f, 0.05074203f, 
    0.42329893f, 0.29725844f, -0.08758815f, -0.07767250f, -0.05984871f, 0.03047673f, -0.09264907f, 0.04870699f, 
    0.09402874f, 0.05162305f, 0.00564548f, 0.03979329f, -0.14686984f, -0.16686699f, -0.10661367f, -0.32886159f, 
    -0.02695980f, -0.02493628f, 0.01690944f, 0.01188393f, -0.05602660f, 0.01732890f, -0.00445100f, -0.04064472f, 
    0.08851012f, -0.10249132f, -0.04367124f, 0.00053046f, 0.04043831f, -0.01378087f, -0.03932795f, 0.09616491f, 
    -0.11600728f, 0.04842295f, 0.02236128f, -0.08447407f, 0.01362038f, 0.08673950f, -0.07453761f, -0.02073454f, 
    -0.05671984f, -0.15341708f, 0.12704153f, -0.01503408f, -0.07636344f, 0.04589672f, 0.04825621f, -0.09563103f, 
    0.45160404f, 0.02778960f, -0.17608617f, 0.18710561f, -0.01947353f, 0.03707338f, -0.06294639f, 0.04551966f, 
    -0.03895819f, -0.06830849f, 0.13211966f, -0.10048154f, -0.19542648f, -0.05745549f, 0.03420451f, 0.06837782f, 
    -0.09476913f, 0.05673357f, 0.03215183f, 0.17038076f, -0.07379157f, 0.02441383f, -0.01788506f, -0.11926085f, 
    0.04356940f, 0.26843265f, -0.14932455f, -0.12173472f, -0.05761065f, -0.00078774f, 0.04415440f, 0.02836692f, 
    -0.03818775f, -0.01679263f, -0.10666942f, -0.06310141f, -0.03753347f, -0.30290440f, -0.05603513f, -0.01559796f, 
    -0.02391635f, 0.05369602f, 0.04548066f, -0.05195836f, 0.02963073f, 0.05204277f, -0.02244693f, -0.02698738f, 
    -0.40554330f, -0.04243195f, 0.03402659f, -0.19902825f, -0.04222677f, 0.08145196f, -0.01093362f, 0.05375169f, 
    -0.03701691f, -0.00139140f, -0.00600512f, -0.00610164f, 0.08883212f, -0.05707705f, -0.08505306f, -0.26121989f, 
    0.01441146f, 0.03985888f, -0.02276033f, 0.10810604f, 0.01863300f, 0.00112725f, -0.07234992f, -0.04577311f, 
    0.05318084f, -0.07633982f, -0.13311669f, -0.03779098f, -0.01485519f, -0.01349066f, 0.00752895f, -0.02536473f, 
    -0.01654782f, -0.03148648f, -0.05138539f, -0.11671085f, -0.08104558f, -0.10728885f, 0.10834607f, -0.03823438f, 
    0.00027104f, -0.01551509f, 0.01161152f, 0.03979526f, -0.13866688f, -0.05863851f, -0.01679579f, 0.04789682f, 
    0.20394827f, -0.07940543f, -0.28747344f, 0.08648250f, -0.02398212f, -0.07095672f, -0.05620625f, 0.05989549f, 
    0.00175012f, 0.07652538f, -0.02069700f, 0.01409590f, -0.02997630f, 0.06233758f, -0.05749128f, -0.25078005f, 
    0.07630265f, 0.02685660f, -0.00672756f, 0.13530424f, 0.11233878f, -0.00372279f, 0.12190007f, -0.11081501f, 
    0.13360161f, 0.11404791f, -0.06769837f, -0.12189963f, 0.09119054f, 0.00693803f, -0.01637238f, -0.02229498f, 
    0.13903014f, -0.03154972f, -0.02482362f, 0.00281316f, 0.19553626f, -0.11277750f, -0.11516593f, -0.15099825f, 
    0.10690225f, -0.06660733f, -0.08637824f, 0.08623753f, 0.00246744f, -0.01662504f, 0.06081399f, -0.03742199f, 
    0.33161002f, -0.17114408f, -0.00215392f, 0.02833237f, 0.06891505f, -0.14620937f, -0.09124614f, 0.04173899f, 
    0.00188325f, 0.02360202f, 0.00735949f, -0.02684138f, 0.01326839f, 0.08535099f, -0.04376567f, 0.02635297f, 
    -0.01270798f, 0.07195746f, -0.07491075f, 0.01111565f, 0.06801941f, -0.10331282f, -0.01043845f, -0.01087379f, 
    -0.11949606f, 0.09614912f, -0.05064822f, 0.04701620f, -0.04050845f, 0.04608402f, -0.03988680f, -0.09472336f, 
    -0.01375539f, 0.04384402f, -0.06948374f, 0.00371731f, -0.38153553f, 0.21875526f, 0.04752924f, 0.06712960f, 
    -0.00758156f, -0.02758652f, 0.05532085f, -0.06724662f, -0.03106904f, 0.02126675f, 0.01914779f, -0.11245868f, 
    0.01460797f, 0.04054744f, -0.17212424f, 0.07890843f, 0.04573802f, -0.10424615f, -0.03652044f, -0.02812204f, 
    0.04467043f, 0.10262578f, -0.02757840f, 0.11043288f, 0.08129763f, 0.02314251f, -0.17889866f, 0.07404260f, 
    0.04079306f, -0.09382287f, -0.00285687f, 0.10598397f, -0.00903877f, -0.00152660f, -0.02886558f, -0.04507121f, 
    0.13143712f, 0.13796271f, -0.04382105f, 0.05130101f, -0.07543391f, 0.06096225f, 0.05167618f, 0.07090609f, 
    0.04301465f, -0.01055954f, 0.09690513f, -0.00715449f, 0.00851110f, -0.05763448f, 0.02191100f, -0.00993809f, 
    -0.05193060f, -0.07501677f, -0.06850708f, 0.01271780f, -0.09629532f, -0.04503185f, 0.12445735f, -0.02763213f, 
    -0.36096972f, 0.12843618f, 0.00487529f, 0.03305832f, 0.07283990f, -0.04384642f, 0.06696896f, 0.02072699f, 
    0.02512011f, -0.02107028f, 0.02825375f, 0.10034837f, -0.29358566f, 0.06320094f, -0.11574089f, -0.10462020f, 
    0.09739932f, 0.03592974f, -0.02701694f, 0.05481096f, 0.04704011f, 0.02462881f, 0.04525192f, -0.00845280f, 
    0.15880919f, -0.12611106f, -0.07786151f, 0.06206122f, -0.06718212f, -0.01501102f, -0.07312833f, 0.01924715f, 
    -0.04013875f, 0.03920790f, -0.01574039f, 0.01637927f, -0.12146534f, -0.00632863f, 0.00208213f, -0.05984998f, 
    0.06165522f, -0.10683586f, -0.00798678f, 0.01263698f, -0.06272624f, -0.03507501f, 0.04302508f, -0.06540122f, 
    -0.06862759f, -0.24069417f, 0.03391386f, 0.15579681f, 0.00009647f, 0.17308757f, -0.08366475f, 0.05281014f, 
    0.08167327f, -0.00853237f, 0.01196678f, 0.06074445f, 0.10316505f, 0.05430587f, 0.02152817f, -0.00656291f, 
    -0.14785615f, 0.04441464f, -0.09509505f, -0.10138668f, 0.05092542f, -0.00286331f, -0.01505027f, -0.02847161f, 
    0.17854828f, -0.05403288f, -0.13585898f, -0.08062883f, -0.18649055f, 0.01958016f, -0.00306418f, -0.06349657f, 
    0.06728699f, 0.00096229f, 0.05565434f, 0.03272479f, -0.05510968f, -0.00404176f, 0.03173079f, 0.12416406f, 
    0.06088118f, -0.09911355f, 0.04509405f, -0.00457853f, -0.02027224f, -0.07306615f, 0.01338630f, -0.08399355f, 
    0.10010892f, -0.16789225f, 0.07125448f, 0.00294134f, 0.06574889f, -0.06542071f, -0.01542980f, -0.01026938f, 
    -0.06910644f, 0.00168039f, -0.08077275f, -0.20160094f, 0.02917561f, -0.16255884f, 0.06697607f, -0.09442437f, 
    0.08549053f, -0.03460667f, -0.06276400f, 0.06921382f, -0.08413597f, 0.06281291f, -0.08128314f, 0.02950340f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04438033f, -0.00608790f, -0.00283374f, 0.03696846f, 0.04026705f, -0.00416987f, 0.00595443f, -0.04401483f, 
    -0.05099673f, 0.00414402f, 0.09372390f, 0.00625980f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
