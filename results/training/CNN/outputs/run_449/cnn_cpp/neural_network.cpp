#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.64289767f, 0.04879237f, -0.09333951f, 0.50476122f, -0.01061278f, -0.02888542f, 0.38718283f, -0.14127840f, 
    -0.35989907f, 0.23510228f, 0.35780057f, -0.28263545f, 0.00964841f, -0.44791186f, -0.35943258f, 0.29277363f, 
    0.05604187f, 0.22723831f, -0.33442247f, -0.24955754f, -0.48396695f, 0.22922887f, -0.40308410f, -0.00508164f, 
    -0.28327560f, -0.14627396f, -0.20027946f, -0.16378999f, 0.23320661f, 0.23235238f, 0.39029443f, 0.12421110f, 
    0.31717026f, -0.35813960f, 0.18833813f, -0.01185353f, 0.62859589f, 0.51959449f, 0.46457365f, 0.08370857f, 
    0.13282451f, 0.15998872f, 0.00228374f, 0.14269471f, 0.09016754f, 0.48186761f, 0.05785068f, -0.46221480f, 
    -0.19998983f, -0.01922158f, -0.13716638f, -0.21845102f, -0.37270740f, 0.29580355f, -0.80780160f, 0.04795536f, 
    -0.52559245f, -0.04975789f, 0.25847918f, -0.03792363f, 0.16559371f, -0.01959540f, 0.08929401f, -0.47219214f, 
    0.19200258f, -0.06726305f, 0.17836736f, -0.11808819f, -0.57627529f, -0.18871695f, 0.21877980f, 0.07969939f, 
    0.25458154f, -0.37817627f, -0.58649039f, -0.19342327f, 0.44102812f, 0.12516458f, -0.02441755f, 0.07294132f, 
    0.06363194f, -0.23068519f, 0.19576554f, 0.23013344f, -0.44637898f, -0.58741963f, 0.31524950f, 0.06000642f, 
    -0.05015439f, 0.12024324f, 0.18999334f, -0.68552917f, -0.36483192f, -0.09132157f, -0.33504289f, -0.13408577f, 
    0.07015228f, 0.28328806f, 0.18758583f, -0.03550730f, 0.06344593f, 0.31943217f, 0.38766736f, -0.45629516f, 
    -0.26233074f, -0.25317425f, -0.05430321f, 0.26690105f, 0.04669573f, -0.36887801f, -0.42876035f, 0.58099413f, 
    0.14075328f, 0.25436297f, 0.29071090f, -0.19587052f, -0.01844748f, -0.35144743f, -0.29883069f, -0.02662072f, 
    0.45456269f, 0.68407869f, -0.21103670f, -0.06875151f, -0.19679004f, -0.25336152f, -0.44057661f, 0.83006608f, 
    -0.29020777f, 0.09723782f, 0.00173844f, -0.20262775f, 0.09838583f, 0.03693753f, -0.02635464f, 0.40863323f, 
    0.40579069f, 0.39190993f, -0.49872717f, 0.04798849f, -0.52902019f, 0.23603000f, 0.07970572f, -0.10086416f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.37145939f, 0.17606305f, -0.15274015f, -0.45101756f, 0.40787137f, 0.09414703f, 0.20699966f, -0.12723723f, 
    -0.08799932f, 0.05800037f, -0.03377337f, -0.35007852f, -0.40308768f, -0.05843113f, -0.35679516f, 0.16149807f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03224128f, -0.07383028f, -0.07284302f, -0.06339025f, -0.06943835f, 0.03026280f, -0.10122451f, -0.02613392f, 
    0.05131327f, -0.04324595f, 0.03379805f, -0.08059029f, -0.00345920f, -0.07693825f, -0.08251613f, 0.01113636f, 
    -0.02089445f, 0.02698421f, -0.01214145f, -0.08089193f, -0.11289120f, 0.00588416f, 0.02757939f, -0.09344682f, 
    -0.05232151f, -0.04484003f, 0.00382232f, -0.04837331f, -0.06094063f, -0.02646580f, 0.02496524f, -0.04483312f, 
    0.02923864f, -0.01609275f, -0.08775704f, -0.05189712f, 0.00973615f, 0.04454814f, -0.09928860f, -0.07149801f, 
    -0.04710442f, -0.06575429f, -0.03869918f, 0.02748946f, 0.01829279f, 0.03818719f, -0.10537602f, -0.03450981f, 
    -0.07960747f, -0.04485339f, -0.05554490f, 0.00687563f, -0.06329270f, -0.03819137f, -0.04876926f, 0.01713260f, 
    -0.01203886f, -0.09724133f, -0.05616153f, -0.07511801f, -0.03439646f, -0.07550588f, 0.02125836f, 0.04556223f, 
    -0.09594162f, -0.00221494f, -0.05424998f, 0.02270449f, -0.01462208f, 0.00454725f, -0.10073515f, -0.06847408f, 
    0.00182980f, -0.07833353f, -0.09475304f, -0.08475724f, 0.01960690f, 0.05038443f, -0.03907734f, -0.07117104f, 
    -0.05702584f, 0.02022615f, -0.04887560f, -0.09521493f, 0.05267806f, -0.10883384f, 0.00338693f, -0.07158168f, 
    0.01513902f, -0.06604114f, -0.08916959f, -0.09367339f, -0.07681509f, 0.00711937f, -0.03622058f, -0.04632033f, 
    0.01225719f, 0.06382526f, 0.00185732f, -0.00033995f, -0.08147378f, -0.04686430f, 0.03153965f, -0.06219786f, 
    -0.06842551f, -0.08573133f, 0.05599213f, -0.05341848f, -0.03122900f, -0.04982714f, -0.03172045f, 0.04868203f, 
    0.03363843f, -0.03932314f, -0.01784103f, -0.09605706f, -0.02284415f, -0.04514538f, -0.04638961f, 0.00337771f, 
    -0.07628130f, -0.05020262f, 0.01894990f, 0.04459622f, -0.00155956f, -0.02872855f, -0.04524188f, -0.04155417f, 
    -0.09047601f, 0.10484146f, -0.03658587f, -0.02351614f, -0.02559339f, -0.09325347f, 0.03438857f, -0.05892947f, 
    -0.00044431f, 0.03260808f, -0.06909746f, -0.09764767f, 0.03652005f, 0.01791721f, -0.10272833f, 0.00249450f, 
    -0.08378671f, -0.24630092f, -0.28379402f, -0.19668706f, -0.09413886f, 0.14225228f, 0.07684086f, 0.05845295f, 
    0.04450620f, 0.00424843f, 0.16350816f, 0.03033698f, 0.00006915f, 0.01023855f, -0.04142702f, -0.03536299f, 
    0.06046161f, 0.08726927f, 0.02076034f, -0.13501671f, 0.04187521f, 0.00310941f, 0.18228702f, -0.03369260f, 
    -0.10048494f, -0.03226841f, -0.08507030f, 0.05972448f, -0.10688711f, -0.10774252f, -0.02484097f, 0.09333576f, 
    -0.01858537f, 0.16512185f, -0.07832813f, 0.10032600f, -0.97122991f, -0.27726766f, -0.17869885f, 0.11016238f, 
    -0.03037873f, 0.08677096f, -0.04809244f, 0.06596745f, 0.17527685f, -0.08108464f, -0.38946965f, 0.23138942f, 
    0.17181343f, 0.05665871f, 0.26303539f, -0.03607706f, -0.07594077f, -0.06890541f, -0.00367549f, -0.02296425f, 
    0.18571411f, -0.00091259f, 0.07277209f, 0.00818873f, 0.13698949f, 0.00803148f, 0.02837764f, 0.14550908f, 
    -0.04656331f, -0.29741040f, -0.01321216f, -0.09085961f, 0.13624887f, -0.06700397f, 0.01677364f, 0.02462556f, 
    0.14010756f, -0.01266222f, -0.01841006f, -0.02981301f, 0.00749167f, -0.02060643f, 0.09316150f, 0.12149097f, 
    -0.00135607f, 0.08325798f, 0.31451780f, -0.00279860f, -0.17599827f, 0.07115770f, 0.00662491f, -0.08937804f, 
    0.08938204f, 0.05670969f, -0.01317097f, -0.00614935f, 0.13940470f, -0.02676112f, -0.08470251f, -0.01177793f, 
    -0.05456378f, 0.13000560f, 0.04500960f, -0.14036697f, -0.14703414f, -0.09318064f, 0.10968637f, -0.02381257f, 
    0.03455721f, -0.05116057f, -0.06057194f, 0.05396423f, 0.16140035f, 0.25705156f, 0.03092736f, 0.00039834f, 
    -0.10990511f, -0.06430934f, 0.09070461f, 0.07678001f, 0.05193860f, 0.07554552f, 0.04155705f, -0.07319172f, 
    -0.00968313f, 0.03860809f, -0.14400144f, 0.09482153f, 0.02643909f, -0.08422300f, -0.18056893f, -0.14918226f, 
    -0.29106691f, -0.03385504f, 0.06132921f, -0.10642469f, 0.02692629f, 0.01207389f, -0.00492903f, -0.24930385f, 
    0.14383851f, 0.17172244f, 0.19123617f, -0.03564215f, 0.11218483f, -0.15511931f, -0.01281749f, -0.02462634f, 
    -0.57032841f, 0.11491814f, -0.27163461f, 0.10000990f, 0.02493559f, -0.03699392f, 0.08384756f, 0.16790202f, 
    0.00265127f, 0.04561729f, 0.00792440f, -0.16750085f, 0.07304595f, -0.07989679f, -0.10502017f, 0.06736552f, 
    0.08397055f, -0.07723159f, 0.31448305f, 0.15576547f, 0.04345337f, -0.24993630f, 0.05758227f, -0.08844069f, 
    0.14455016f, -0.20049544f, 0.24156377f, -0.05969967f, -0.00979200f, -0.14126265f, -0.04374818f, 0.11023636f, 
    0.14039865f, -0.10765253f, -0.06630076f, -0.27125144f, -0.28900149f, 0.20302625f, -0.22347744f, -0.08385286f, 
    0.06370630f, 0.08256236f, 0.02801562f, 0.14463313f, 0.01625477f, 0.29555395f, 0.06784443f, -0.03817392f, 
    -0.10296737f, -0.04537863f, 0.02169951f, 0.11400104f, 0.12279815f, -0.12973215f, 0.11874156f, 0.00064530f, 
    0.08411943f, -0.16778198f, 0.05048018f, 0.00797214f, -0.06045401f, -0.11146265f, 0.12173476f, 0.02197358f, 
    -0.08469838f, 0.04089561f, -0.12254584f, 0.14541626f, -0.06694735f, 0.13360597f, -0.02742495f, 0.10971695f, 
    -0.12506627f, 0.14354286f, -0.12435038f, 0.14008458f, 0.08493239f, 0.01233848f, 0.06739095f, -0.19285411f, 
    -0.09028486f, -0.04474466f, -0.10437330f, -0.00569347f, -0.12579300f, 0.11132113f, 0.00093362f, 0.03227445f, 
    0.13196550f, -0.08572616f, 0.02873930f, -0.03716099f, 0.10294165f, 0.15500580f, -0.09656414f, 0.18358742f, 
    0.07570951f, -0.03587839f, -0.22684239f, -0.03801141f, 0.02373437f, 0.02346702f, -0.31605905f, -0.15046462f, 
    0.06256027f, -0.09820287f, 0.04444057f, -0.16368294f, -0.13886981f, 0.11240033f, 0.06013792f, 0.19327052f, 
    0.15093076f, 0.05537154f, -0.06745385f, 0.07898638f, -0.08713703f, 0.03485445f, 0.06007949f, -0.10294563f, 
    0.02151124f, -0.01256446f, 0.10400837f, -0.10402179f, 0.12688585f, -0.08806358f, 0.01601468f, -0.23636317f, 
    0.10133776f, -0.03578955f, 0.01276531f, 0.01864724f, -0.08740563f, -0.05737573f, 0.06122261f, -0.09468327f, 
    0.24510917f, 0.08955316f, -0.06829369f, -0.02230078f, -0.19365233f, 0.01257766f, -0.02530652f, 0.21177849f, 
    0.40439832f, 0.14234640f, 0.12477737f, -0.16996086f, -0.00574934f, -0.02346184f, 0.14459492f, 0.02755032f, 
    0.00194473f, 0.19550285f, 0.20230579f, -0.18323159f, 0.13000754f, -0.00458717f, 0.01733675f, -0.00698582f, 
    -0.06950419f, 0.06405144f, -0.07816103f, 0.09127980f, 0.16564208f, 0.07194862f, -0.08064624f, -0.17632370f, 
    -0.00904979f, -0.15607511f, 0.06819382f, -0.15153328f, 0.07863673f, -0.17928779f, 0.05452580f, -0.02917494f, 
    -0.11892483f, -0.15102290f, 0.19323483f, 0.06722692f, 0.01448117f, 0.18997522f, 0.14845528f, 0.17648220f, 
    -0.05332100f, -0.09666824f, 0.05495238f, -0.09635271f, 0.09372906f, 0.18090500f, 0.02150274f, 0.04656601f, 
    0.02979230f, -0.01781457f, 0.02923742f, 0.09241776f, 0.06173410f, 0.01459415f, -0.59853303f, -0.06308023f, 
    0.26984486f, 0.11666437f, -0.06694840f, 0.19730607f, -0.03270663f, 0.10114712f, 0.01512707f, -0.37093541f, 
    -0.27801716f, 0.08921121f, 0.08029117f, 0.00621762f, 0.05620062f, -0.08116309f, -0.02546243f, 0.02516929f, 
    0.36369774f, -0.14002436f, 0.10762461f, 0.03523160f, 0.05157415f, -0.02619474f, 0.04591531f, -0.00925991f, 
    0.05243652f, -0.16833791f, 0.00288092f, -0.13137232f, 0.08518543f, 0.04749973f, 0.11606488f, 0.11994806f, 
    0.09015404f, 0.02853905f, -0.03577719f, -0.14453952f, 0.04336058f, 0.12152390f, -0.13833934f, -0.01204401f, 
    -0.08164625f, 0.00518985f, -0.01007720f, -0.10236344f, -0.14075194f, -0.40361869f, -0.10784895f, -0.01756067f, 
    0.02676768f, -0.06674517f, 0.09295540f, 0.01526451f, 0.12669414f, -0.01082274f, -0.08077446f, -0.05031246f, 
    0.05616667f, 0.02283519f, -0.08527470f, 0.01781097f, -0.14703372f, -0.13384999f, -0.31628004f, -0.02129218f, 
    -0.00662907f, -0.08429950f, -0.10953070f, 0.05352739f, -0.01459370f, 0.06713657f, -0.72144544f, -0.03134841f, 
    -0.16875286f, 0.08714231f, 0.04048058f, -0.05327630f, -0.11088683f, -0.12142182f, 0.03469585f, 0.09759846f, 
    0.03466970f, -0.29373085f, 0.09378727f, 0.00599218f, 0.11978251f, -0.09055267f, 0.08604062f, -0.00086061f, 
    -0.09159042f, 0.04316525f, -0.09070077f, -0.05001865f, -0.03504473f, 0.04622021f, 0.01629621f, -0.07942221f, 
    -0.07306666f, -0.06237878f, -0.08700217f, 0.04191377f, -0.03807833f, 0.06759016f, -0.05789756f, 0.06723931f, 
    -0.06546443f, -0.04021792f, -0.04074588f, -0.04406206f, -0.03649963f, -0.06325508f, 0.04547305f, -0.06219417f, 
    -0.00533248f, -0.01596912f, -0.02883318f, -0.02503440f, -0.00905450f, 0.00954654f, 0.06749204f, 0.07242586f, 
    0.02980910f, -0.06943540f, -0.07006954f, -0.07769216f, 0.05935214f, -0.03692657f, 0.06576357f, -0.08865894f, 
    -0.05680794f, -0.01923824f, -0.08151924f, -0.02374260f, 0.01092715f, 0.03515188f, 0.00761152f, 0.04281019f, 
    -0.02314074f, 0.03974435f, 0.02754261f, -0.08829612f, -0.01955439f, 0.06139486f, 0.01426709f, 0.04611060f, 
    -0.03491906f, -0.06371538f, 0.03669145f, 0.05465579f, 0.05947826f, 0.00611686f, -0.04531106f, 0.01719554f, 
    -0.00402020f, 0.04226079f, -0.07277275f, -0.00117760f, 0.06061862f, -0.01858690f, 0.01900664f, 0.05637224f, 
    -0.07108577f, 0.01804584f, -0.07680191f, -0.02462083f, -0.04042117f, -0.06691926f, -0.07743420f, -0.06609804f, 
    -0.04286590f, 0.02674947f, -0.08185259f, 0.00057602f, 0.01895934f, -0.04040651f, 0.00429987f, 0.00849995f, 
    -0.03972113f, -0.09555785f, -0.03578842f, -0.09829486f, 0.00216230f, -0.05492854f, -0.01119506f, -0.03313779f, 
    -0.02497079f, -0.05316072f, -0.00883541f, -0.01581402f, -0.05194745f, 0.02925761f, -0.02435917f, 0.04678870f, 
    -0.01368714f, 0.05791308f, -0.05039589f, -0.01452270f, 0.04294554f, 0.00318920f, -0.07423308f, -0.07322233f, 
    0.02717131f, 0.04206419f, -0.05194619f, -0.02684875f, 0.05877351f, 0.02586776f, 0.03926923f, -0.02301980f, 
    0.03774818f, -0.03604021f, -0.06685771f, 0.01568250f, 0.01198967f, 0.06487289f, -0.04162721f, -0.09615692f, 
    -0.07765503f, -0.00421756f, -0.05657014f, 0.05174053f, -0.00208009f, 0.03933817f, 0.03409995f, 0.05868674f, 
    0.05705106f, 0.01322113f, 0.05210605f, -0.02374558f, 0.03548444f, -0.07303313f, -0.06064532f, -0.05216218f, 
    0.10224522f, -0.05918752f, 0.01661164f, 0.08242792f, -0.14211847f, -0.15699174f, -0.00922650f, 0.00236910f, 
    0.10361460f, 0.34741095f, -0.23377910f, -0.10844801f, 0.08553290f, 0.14162815f, -0.12566264f, 0.20262444f, 
    0.00545692f, 0.09827887f, 0.08812010f, 0.18051237f, -0.22010940f, 0.20432685f, -0.02696720f, 0.07326752f, 
    -0.04318751f, -0.00777957f, 0.02752494f, 0.01288978f, 0.14915825f, -0.12608491f, 0.05168087f, -0.00370684f, 
    0.05023733f, 0.02467155f, 0.09816323f, 0.04544781f, 0.18659720f, -0.06667283f, 0.17259994f, 0.23685268f, 
    0.07179906f, -0.07647804f, -0.02910675f, -0.02032792f, 0.05664511f, -0.00859881f, -0.15259063f, -0.12633757f, 
    -0.03396093f, -0.00283882f, 0.07347318f, 0.00718856f, -0.05938351f, -0.20573071f, -0.10729115f, 0.06220685f, 
    -0.08973776f, 0.04407798f, 0.02995671f, 0.04772908f, -0.07236842f, 0.01944090f, -0.03511819f, -0.32027194f, 
    -0.10739441f, -0.19278049f, -0.12869173f, -0.20639907f, -0.02371652f, -0.02200161f, 0.05595371f, 0.03412907f, 
    0.26388457f, -0.07410157f, 0.05387008f, 0.10263354f, 0.00261305f, -0.15387389f, -0.02511401f, 0.04704097f, 
    0.00671438f, -0.19641246f, 0.16046652f, -0.05718518f, -0.02141690f, -0.26818603f, -0.01163737f, 0.01124647f, 
    0.00662894f, 0.02665061f, 0.39821559f, 0.08662555f, -0.06213034f, 0.18413976f, 0.01013864f, 0.08860394f, 
    -0.00289045f, -0.08106505f, 0.08783943f, -0.19118991f, 0.05526657f, 0.23388937f, 0.12440933f, -0.05523706f, 
    0.05510804f, -0.03185378f, 0.00411597f, -0.07282741f, -0.02400030f, 0.39833945f, 0.29394746f, -0.25006905f, 
    0.10930863f, -0.08436269f, -0.00819991f, 0.02424328f, -0.06017930f, -0.29399139f, -0.00178281f, -0.06013587f, 
    -0.18580604f, 0.06674617f, -0.07735837f, -0.13059536f, 0.12549824f, -0.07924405f, -0.05690252f, -0.12711674f, 
    -0.08562061f, -0.18077217f, -0.01961188f, 0.02625561f, 0.03096132f, -0.12615116f, 0.18805067f, 0.28115419f, 
    -0.39808556f, 0.01173506f, 0.20379996f, 0.00976638f, 0.11336401f, -0.11191778f, -0.03199252f, 0.02592130f, 
    0.15215865f, -0.38101640f, -0.17377284f, -0.04457728f, 0.02457392f, 0.05341876f, 0.08061256f, 0.05810241f, 
    -0.03761370f, 0.04891092f, -0.08792977f, 0.08649472f, -0.00488975f, 0.00497374f, 0.00933824f, 0.05401525f, 
    -0.06179198f, 0.05227501f, -0.31889275f, -0.00257777f, -0.02449504f, 0.05566342f, 0.01359872f, 0.05479521f, 
    0.09453788f, -0.10961321f, 0.09868778f, -0.13683213f, -0.36264101f, -0.02819718f, -0.07731977f, 0.22997183f, 
    0.09003525f, -0.04065568f, -0.15877332f, -0.15945846f, 0.29654261f, 0.19512334f, 0.38589659f, 0.03201781f, 
    -0.08630142f, -0.08468162f, -0.00123468f, -0.02868180f, -0.02507360f, 0.08042774f, -0.20098604f, 0.06984399f, 
    0.05666016f, -0.05734620f, 0.06241582f, -0.02309529f, -0.06020378f, 0.07357781f, -0.38958949f, -0.27307147f, 
    0.02884890f, 0.16658504f, 0.11718666f, -0.01007519f, -0.00201394f, 0.02314289f, -0.00152315f, -0.10374877f, 
    -0.04669559f, -0.06591763f, 0.18101062f, 0.01985248f, -0.09517257f, 0.04751838f, -0.01274689f, -0.23380005f, 
    -0.00513243f, -0.03564674f, 0.13712424f, -0.00685878f, 0.06223952f, 0.14630203f, 0.02608343f, -0.01787981f, 
    0.01058809f, 0.01679876f, -0.13831045f, -0.02867500f, -0.08764732f, 0.12931135f, -0.01084532f, 0.08130324f, 
    -0.15868410f, 0.15645956f, 0.01887248f, 0.17075849f, -0.20084855f, 0.07939875f, 0.14093381f, -0.09001469f, 
    0.02290308f, -0.07917093f, -0.03872541f, 0.09766921f, -0.03268890f, -0.24593069f, -0.10580357f, 0.01535189f, 
    0.10370436f, -0.12149946f, 0.10932191f, 0.14823909f, -0.22931392f, -0.05689979f, 0.00632769f, 0.19992821f, 
    0.05842185f, 0.05817590f, -0.10956352f, -0.02405495f, 0.05157052f, -0.39638245f, -0.23156378f, -0.15864933f, 
    0.12831523f, 0.09797886f, 0.00160439f, 0.12249761f, -0.07042152f, 0.04147474f, -0.19454534f, 0.20069878f, 
    0.25758117f, -0.06248616f, -0.08059344f, -0.03703174f, -0.07878255f, 0.04494254f, 0.03858599f, 0.19774351f, 
    0.22427450f, 0.13804701f, -0.10009876f, -0.09813039f, -0.07722707f, 0.04942206f, -0.03466410f, -0.05939422f, 
    -0.52568859f, -0.08245834f, -0.11939528f, 0.05525462f, 0.12003310f, -0.30689195f, 0.05619780f, 0.08194017f, 
    0.09169421f, 0.20956269f, -0.13581780f, 0.23189041f, 0.00188124f, -0.18282597f, -0.01047519f, 0.13397419f, 
    -0.09507637f, 0.12785363f, -0.02647929f, -0.16408393f, -0.06148029f, 0.19026299f, 0.00097618f, 0.03811282f, 
    0.00158356f, 0.07830293f, -0.18548706f, -0.37290084f, 0.30371326f, -0.09201229f, 0.12317604f, -0.02487991f, 
    0.02066639f, -0.09838720f, 0.03965208f, -0.02312873f, -0.08928639f, 0.03982688f, -0.06352204f, 0.10097310f, 
    0.08148438f, 0.02010153f, 0.19965999f, 0.01185433f, 0.14726916f, 0.24404398f, -0.19754323f, 0.04140855f, 
    0.12176815f, 0.00711588f, 0.03769136f, 0.06358396f, 0.05238732f, 0.13561422f, -0.28211105f, 0.11665276f, 
    -0.06308033f, 0.00455865f, 0.09663691f, 0.02652398f, 0.01346162f, -0.00245083f, 0.05483916f, 0.06541917f, 
    -0.10650618f, 0.02660595f, -0.07141750f, -0.21837036f, -0.09054793f, 0.10532404f, 0.08270207f, 0.11324475f, 
    -0.10784844f, 0.08994933f, 0.06233774f, 0.02834881f, -0.17860632f, -0.06443969f, -0.04865162f, 0.07295856f, 
    -0.02194748f, 0.07886866f, -0.06991400f, -0.20022430f, 0.14040361f, 0.14171547f, 0.11508720f, 0.00610052f, 
    0.02154715f, 0.07341550f, -0.19168258f, -0.32154444f, -0.19266514f, -0.26312673f, -0.28317061f, -0.03545570f, 
    -0.01845676f, -0.05015337f, 0.05352333f, -0.25572759f, -0.30344912f, -0.12712717f, 0.08882980f, 0.07679689f, 
    0.05388275f, 0.11787890f, -0.11286470f, 0.01413593f, -0.01453896f, -0.12832427f, -0.09555253f, 0.00062409f, 
    0.11568870f, -0.02060146f, -0.04266072f, -0.20182809f, 0.06911205f, 0.10851059f, 0.11442739f, -0.01141581f, 
    -0.02678563f, 0.05147306f, -0.08261627f, -0.02999744f, 0.06766982f, -0.03764144f, -0.64376241f, -0.30632171f, 
    0.04715195f, 0.09430203f, -0.04910218f, -0.09158267f, -0.10932176f, -0.01408589f, 0.06180108f, -0.05151378f, 
    0.00625201f, 0.03347466f, -0.06843303f, 0.01255618f, 0.09804493f, 0.06929982f, -0.03372341f, 0.14025858f, 
    0.05653027f, -0.39887446f, 0.03074132f, -0.14093199f, 0.04893637f, 0.02466241f, 0.07634179f, 0.07390783f, 
    -0.00582058f, -0.15628417f, -0.04698030f, 0.04590644f, -0.01725415f, 0.04660717f, -0.05870951f, -0.04496022f, 
    -0.04932765f, 0.20972213f, -0.19136462f, 0.00633976f, -0.21712190f, 0.11782230f, -0.02284957f, 0.04614962f, 
    0.07615908f, 0.14561501f, -0.07243874f, -0.04810005f, 0.22513053f, -0.00275789f, -0.11392473f, -0.08518111f, 
    -0.18971612f, -0.00415265f, -0.03789476f, 0.05008289f, 0.22254167f, 0.26959109f, 0.14578617f, -0.17212470f, 
    0.06520735f, 0.07928269f, -0.09150749f, 0.04257655f, -0.05377652f, 0.18603790f, -0.18614003f, 0.03819179f, 
    -0.05481658f, 0.05979919f, 0.13181591f, -0.03360546f, 0.13286102f, -0.05363996f, 0.49950966f, 0.16428585f, 
    -0.30626711f, 0.10634460f, 0.11597615f, 0.05068837f, 0.09203447f, -0.07694230f, -0.10046048f, -0.16751644f, 
    -0.07658235f, -0.00567173f, 0.03496310f, -0.04643723f, -0.15333870f, -0.03057720f, 0.06871134f, 0.03968894f, 
    0.17830499f, -0.09749601f, -0.08138687f, -0.09617086f, 0.11575595f, 0.03188393f, -0.17917594f, -0.12560785f, 
    0.08099306f, -0.11551548f, 0.00367952f, -0.17292291f, 0.11073852f, -0.05446598f, -0.14363638f, 0.06015597f, 
    0.08843753f, 0.04323188f, -0.14990157f, -0.31491569f, 0.03968100f, -0.05391111f, 0.21915969f, 0.00054468f, 
    -0.02188542f, 0.03316735f, -0.07032984f, -0.12796751f, -0.07314767f, 0.15122251f, -0.19619329f, -0.02387899f, 
    -0.11158639f, 0.07450464f, 0.06301509f, 0.11984688f, -0.14365681f, 0.05576818f, -0.11671677f, 0.14778070f, 
    0.14841653f, 0.04141847f, 0.01482626f, 0.06052874f, -0.12388703f, 0.38899547f, 0.01089231f, 0.14761582f, 
    0.01830902f, -0.00937893f, -0.17778994f, 0.03596806f, 0.06700492f, 0.03490199f, 0.15213671f, -0.16864266f, 
    -0.35684577f, -0.07106570f, -0.01033210f, 0.00604026f, -0.13583785f, -0.02887196f, 0.13729717f, 0.08698451f, 
    0.00465725f, -0.05872941f, -0.01416601f, -0.09501155f, 0.05820513f, 0.07549789f, 0.05561292f, 0.07084814f, 
    0.06798889f, -0.08263267f, -0.00607706f, -0.23067717f, -0.13082926f, 0.07740434f, 0.06021376f, 0.18030055f, 
    0.12242220f, 0.16893254f, -0.02703717f, 0.12357978f, 0.02304911f, -0.09865658f, 0.03976837f, 0.06431761f, 
    -0.05210958f, 0.00200375f, 0.10019397f, 0.30466655f, -0.15862332f, 0.09330311f, -0.00944404f, 0.11559965f, 
    0.08983882f, -0.00836988f, 0.02009988f, -0.42148620f, -0.06989627f, -0.05044895f, -0.13340378f, -0.06011096f, 
    -0.12035096f, 0.06083557f, -0.05259596f, 0.07261802f, -0.17466147f, -0.32459268f, 0.02313803f, -0.11576831f, 
    -0.07981853f, -0.00245888f, 0.03103374f, 0.12024602f, 0.18993095f, -0.01252918f, -0.15608652f, -0.04091373f, 
    -0.09637693f, 0.06402490f, 0.05914309f, -0.09742151f, -0.04902771f, -0.00804639f, -0.12022309f, 0.38206503f, 
    0.27461842f, 0.00455612f, -0.19757873f, 0.03786091f, 0.01134546f, 0.22817460f, -0.01611356f, 0.13072768f, 
    0.04509024f, 0.08257169f, 0.07735614f, -0.02906462f, -0.00904422f, -0.11868133f, -0.07854824f, -0.21810338f, 
    0.01464892f, -0.02076850f, -0.03101292f, 0.08768994f, 0.06619112f, -0.06421035f, 0.07479898f, 0.18552706f, 
    0.10422663f, -0.06967944f, -0.14859778f, -0.17602864f, 0.08790711f, 0.08899062f, 0.12277579f, -0.04783098f, 
    0.14436008f, 0.03413703f, 0.25322622f, 0.12601319f, -0.07543863f, -0.05562286f, -0.07690347f, 0.09040073f, 
    -0.03116114f, 0.07156919f, -0.06985225f, 0.02311460f, -0.20769806f, -0.10383386f, 0.02922790f, -0.11932272f, 
    0.15252276f, -0.10658344f, -0.18843669f, -0.04075295f, 0.14516948f, 0.24382322f, -0.04624694f, 0.03640728f, 
    0.13642389f, -0.18989368f, 0.12020207f, 0.18543814f, 0.05510369f, -0.03421970f, 0.03486148f, 0.10114626f, 
    -0.05060508f, 0.11922722f, -0.03419244f, -0.05297457f, 0.04004763f, -0.01121356f, 0.16641517f, -0.08399729f, 
    -0.02682075f, 0.16721387f, -0.02127697f, -0.10344989f, -0.12797211f, -0.13309854f, -0.08131569f, -0.12631294f, 
    -0.34282067f, -0.04368072f, -0.08901874f, 0.04310905f, 0.08937463f, -0.06405348f, -0.08111069f, 0.03701835f, 
    -0.22313811f, -0.12221048f, -0.10793752f, 0.00762217f, 0.04673876f, 0.01700345f, 0.04687045f, 0.05031416f, 
    -0.15507963f, 0.00627847f, -0.13606246f, 0.00986310f, 0.13462903f, 0.00878155f, 0.03678965f, 0.06095215f, 
    -0.04815730f, 0.05775668f, -0.12815513f, 0.02183105f, -0.22490798f, -0.14447397f, 0.04610499f, -0.05548229f, 
    -0.03179335f, 0.00304633f, -0.04936823f, -0.07432857f, 0.06893875f, -0.01369018f, 0.21300238f, -0.06778751f, 
    -0.26907691f, 0.15702496f, -0.08050960f, -0.10748823f, 0.03269127f, 0.18451312f, 0.30509084f, 0.04633930f, 
    0.13290927f, -0.06419048f, -0.04483074f, 0.04138891f, 0.16225639f, -0.14704022f, -0.01064447f, 0.06684487f, 
    0.18257266f, -0.12202919f, 0.05135978f, 0.00020705f, 0.04931920f, -0.02179356f, -0.19950844f, -0.18511060f, 
    0.00444549f, 0.00583656f, -0.07642988f, -0.02820998f, 0.11414737f, -0.05940943f, 0.09612072f, 0.00332205f, 
    0.05309417f, -0.13283151f, -0.03683204f, 0.15750636f, 0.02615454f, -0.03072434f, 0.09752844f, 0.09619201f, 
    -0.14259043f, -0.26095000f, -0.26836947f, 0.08458523f, 0.02238044f, 0.05623181f, 0.06486954f, -0.10283351f, 
    0.01056697f, 0.06512998f, 0.25750077f, -0.18816863f, -0.04460829f, 0.03823598f, 0.07996834f, -0.09896802f, 
    0.02128177f, 0.04615816f, -0.55077612f, 0.06512150f, -0.17879939f, -0.05858995f, 0.15953840f, -0.15029061f, 
    -0.00096585f, -0.01437172f, -0.02228944f, 0.16016470f, 0.09166724f, 0.31393299f, -0.00833975f, -0.07614298f, 
    0.10430703f, 0.12368374f, 0.01982151f, 0.08925430f, -0.25966558f, -0.09912464f, -0.32529873f, -0.04697343f, 
    -0.18648075f, 0.02594756f, -0.12329702f, -0.02248980f, -0.12212783f, -0.07078054f, -0.27173302f, -0.35584581f, 
    -0.22726095f, 0.04308239f, -0.02678567f, 0.06012332f, 0.00372621f, -0.08751113f, -0.35157540f, -0.12700137f, 
    -0.07909141f, 0.06097095f, -0.11320667f, 0.06285024f, -0.08389075f, -0.05917104f, 0.02645022f, 0.33545566f, 
    0.25682974f, 0.01711320f, 0.09702466f, 0.17179620f, 0.11010996f, 0.05088582f, -0.12787557f, 0.01508161f, 
    -0.05348618f, 0.13966838f, -0.12931450f, -0.09036251f, -0.10069009f, -0.00915588f, -0.04120904f, 0.20974113f, 
    -0.15667823f, 0.11334036f, -0.13254467f, 0.13007289f, 0.05622974f, -0.02443275f, -0.01188536f, -0.11649068f, 
    -0.08467978f, 0.06520776f, 0.11466262f, -0.16651841f, 0.27067310f, -0.03363879f, -0.06811582f, 0.03267226f, 
    0.07825204f, 0.08301961f, 0.15303472f, -0.15809520f, -0.16024701f, 0.07058711f, 0.26747859f, -0.18658495f, 
    0.14034365f, 0.05749564f, -0.01753861f, -0.28707337f, 0.00029516f, -0.34157214f, -0.06576418f, -0.00338377f, 
    0.00531847f, 0.18698147f, 0.07828244f, 0.02026802f, -0.10291154f, 0.23500630f, -0.11920376f, 0.18634826f, 
    -0.01612367f, -0.00875110f, 0.13391678f, 0.17261559f, -0.04480616f, 0.13536955f, -0.13724326f, 0.07281225f, 
    0.19027837f, 0.10879429f, 0.07173317f, -0.12249235f, -0.08983672f, -0.00104943f, 0.20100777f, 0.23232029f, 
    0.01263782f, 0.15815112f, -0.05512068f, 0.02256977f, 0.07794456f, -0.17944956f, -0.14470905f, -0.08194160f, 
    -0.00722497f, 0.05188741f, 0.11428839f, -0.02032195f, -0.07374199f, -0.19766639f, 0.02125526f, -0.03067121f, 
    0.04565591f, -0.01965624f, -0.28832233f, -0.14741947f, 0.01189332f, 0.19275692f, 0.04231456f, 0.09844980f, 
    -0.01657567f, -0.09853204f, 0.19604303f, -0.06767352f, 0.01426371f, -0.15221755f, -0.03713804f, -0.01580907f, 
    -0.05936326f, 0.02387044f, 0.02059791f, -0.14092767f, -0.22970870f, -0.05807528f, 0.02840988f, -0.14075257f, 
    0.13425818f, -0.24392059f, 0.13447542f, -0.07947520f, -0.00620742f, 0.00597608f, 0.21300167f, 0.03961917f, 
    0.00358188f, -0.00293196f, -0.06101619f, 0.01354896f, 0.05994994f, -0.14154480f, 0.00240118f, 0.07185643f, 
    0.00236300f, 0.00681744f, -0.00715076f, 0.13771647f, 0.29598117f, 0.19865818f, -0.24998470f, -0.13935085f, 
    0.03017238f, -0.09197589f, 0.03486826f, -0.08324368f, -0.02021898f, 0.03831133f, 0.04911457f, -0.05645260f, 
    -0.04394807f, -0.19385421f, -0.07339903f, 0.00867176f, -0.07738896f, -0.03752944f, -0.05123725f, 0.08422788f, 
    -0.05393330f, -0.05353475f, -0.08366680f, 0.12441298f, -0.06502505f, 0.20040596f, 0.01608664f, -0.00624840f, 
    -0.06440733f, 0.22706290f, -0.00047564f, 0.03834318f, 0.05712712f, -0.08253704f, -0.10031568f, 0.03815877f, 
    0.03213207f, -0.00137466f, -0.00063420f, 0.17209056f, 0.07199059f, -0.01920839f, -0.00650011f, -0.02378846f, 
    0.05923788f, -0.00510393f, 0.07961770f, 0.02169387f, -0.01323968f, 0.17930397f, -0.07397766f, -0.05272533f, 
    0.17957473f, -0.04123392f, -0.19873926f, -0.46140173f, -0.20328081f, -0.13825876f, -0.01348044f, -0.00130221f, 
    0.07688896f, 0.12211990f, -0.05067325f, -0.00759684f, -0.04311098f, 0.16178755f, 0.19931544f, -0.25458217f, 
    -0.00054328f, 0.13272908f, -0.12275919f, 0.01272368f, 0.09940846f, -0.16315278f, 0.11897111f, 0.08832647f, 
    -0.02290768f, -0.02926425f, 0.02635547f, 0.01160937f, 0.06187724f, -0.02758330f, -0.10147629f, 0.26719707f, 
    -0.00963000f, 0.13204126f, -0.10989311f, -0.05614819f, -0.09003955f, 0.04322496f, 0.08410466f, 0.01608928f, 
    0.00984843f, 0.29438698f, -0.11062444f, -0.06431450f, -0.14053868f, -0.01706303f, 0.06029320f, 0.20150475f, 
    -0.06835844f, 0.11136284f, -0.04734571f, 0.02629929f, -0.19585723f, -0.16232495f, -0.08706851f, 0.12951984f, 
    -0.03420109f, -0.06492220f, 0.10116440f, 0.00044105f, -0.16052389f, -0.04493117f, -0.04137116f, -0.12380387f, 
    0.03056325f, 0.04933388f, -0.06245768f, 0.17399849f, -0.24575305f, 0.09267146f, 0.24161585f, -0.03376043f, 
    0.12309757f, 0.04223623f, -0.23650140f, -0.06847039f, 0.11395854f, 0.08968433f, -0.12434758f, -0.22385682f, 
    0.00682423f, 0.15586165f, -0.22298340f, -0.02319259f, -0.00694951f, -0.02873013f, -0.04162899f, -0.00040315f, 
    -0.17711821f, 0.03983491f, 0.09628910f, -0.04970708f, 0.10240182f, 0.11994515f, 0.55068344f, -0.01782719f, 
    -0.09434064f, -0.00716845f, -0.12863187f, -0.03767163f, -0.10226122f, 0.17405589f, -0.11495096f, 0.07200047f, 
    -0.14239199f, 0.19307980f, 0.10973019f, 0.01189173f, -0.01838199f, -0.00927221f, -0.20584956f, 0.04883109f, 
    -0.02298958f, -0.06071344f, -0.10152216f, 0.01498348f, 0.06818742f, -0.06164930f, 0.03995761f, -0.01340577f, 
    -0.08232339f, -0.00489744f, -0.08391516f, -0.06600233f, -0.03661823f, 0.08601626f, -0.08619914f, -0.00991769f, 
    0.07286895f, -0.07995813f, -0.08920255f, 0.01685926f, -0.01771275f, -0.05391071f, 0.07886357f, -0.05107462f, 
    0.02772520f, 0.05631086f, 0.03885935f, -0.03812128f, -0.08706120f, -0.04164968f, 0.10295323f, 0.03897560f, 
    -0.01488015f, -0.05487437f, 0.06228758f, 0.05467708f, -0.07102431f, 0.02952685f, 0.00609990f, -0.03917104f, 
    -0.09619828f, 0.03490910f, -0.00414323f, -0.06926171f, -0.02181081f, -0.04290855f, -0.00865441f, -0.05546372f, 
    -0.08062470f, -0.08918331f, 0.08145983f, 0.05101279f, 0.01899893f, -0.00998485f, 0.01886646f, -0.09015922f, 
    0.06215526f, -0.01984046f, -0.08544409f, 0.05171165f, -0.07297359f, 0.03953977f, 0.00985358f, -0.08466697f, 
    -0.00206726f, 0.09904751f, -0.04402538f, -0.02831264f, -0.07274540f, 0.02860817f, 0.04252129f, 0.03000907f, 
    -0.10774947f, -0.04317887f, -0.01178152f, 0.00170637f, -0.07740677f, -0.02840571f, -0.08550043f, 0.04966822f, 
    0.04649188f, -0.04568008f, -0.10638585f, -0.07264719f, -0.03467378f, 0.05836805f, -0.05147423f, -0.02903793f, 
    0.01111333f, -0.05954721f, 0.06131277f, -0.07335013f, 0.04328655f, 0.05154768f, -0.00968895f, 0.02142790f, 
    -0.09078371f, -0.00981205f, 0.03458091f, -0.05862489f, -0.04086968f, -0.05835338f, -0.11020282f, -0.05882695f, 
    -0.00447460f, -0.05487356f, 0.04696135f, 0.03869028f, -0.05686427f, 0.06572465f, -0.00306186f, 0.06142867f, 
    0.01403004f, 0.04590015f, -0.06146171f, -0.02987736f, -0.09069643f, 0.01831620f, -0.05949379f, 0.00208149f, 
    -0.00205138f, 0.04389136f, -0.08587369f, -0.07159524f, -0.06022040f, 0.01661623f, -0.05415848f, -0.01935802f, 
    -0.08721638f, -0.10058219f, -0.05751900f, -0.07164793f, 0.00334644f, -0.08016576f, -0.03384050f, 0.05406647f, 
    0.04685033f, -0.02798204f, -0.01208364f, 0.03173226f, 0.04721831f, 0.04738492f, -0.07958607f, -0.02022675f, 
    -0.02211087f, -0.05762145f, -0.05737611f, 0.00817936f, 0.06260126f, -0.04585641f, -0.00561845f, -0.04801342f, 
    -0.05434830f, -0.00508212f, 0.01268586f, -0.09109612f, -0.02564484f, -0.02661397f, -0.03540863f, -0.08365810f, 
    0.04720173f, -0.07911905f, 0.01415772f, -0.02741250f, 0.06888501f, 0.03056021f, -0.03523459f, 0.06137403f, 
    -0.04750019f, -0.01177906f, 0.01879855f, -0.08534239f, 0.01937468f, 0.01037651f, 0.02835047f, -0.03030006f, 
    -0.06715915f, 0.07220042f, 0.05455328f, 0.05654509f, -0.01409678f, 0.05766455f, -0.01220499f, -0.08942503f, 
    -0.04659371f, 0.03402072f, -0.07768535f, -0.01557368f, 0.02447345f, -0.00551842f, 0.03400410f, 0.04531892f, 
    -0.01968383f, 0.06791088f, -0.05603205f, 0.00492208f, -0.00253851f, -0.05948704f, 0.00956195f, 0.01838014f, 
    -0.05902106f, 0.02956611f, -0.07746826f, -0.03557537f, 0.04123446f, 0.06935030f, -0.03888883f, 0.03019717f, 
    -0.00194233f, -0.07090526f, -0.06058805f, -0.06491441f, -0.00492514f, -0.05815494f, -0.00715693f, -0.02371097f, 
    -0.00729535f, -0.00085097f, -0.09024409f, 0.01098476f, 0.05890040f, -0.00185099f, 0.04304927f, 0.06127388f, 
    -0.02296076f, -0.00717965f, 0.02133781f, -0.03872005f, -0.07151454f, 0.02566133f, 0.06017644f, -0.08959079f, 
    0.04578818f, -0.00385636f, -0.05186407f, 0.00152557f, -0.06447440f, 0.01536925f, -0.01807526f, -0.00127765f, 
    -0.04464660f, 0.02485037f, -0.07850713f, -0.02541822f, -0.07974469f, 0.03352791f, -0.05499014f, 0.05550809f, 
    0.00531880f, -0.07260443f, -0.07106470f, 0.03874397f, -0.06476581f, -0.07407930f, 0.02241592f, -0.07931540f, 
    -0.08440398f, -0.08586042f, 0.05681252f, -0.02550423f, -0.08229966f, -0.01864647f, 0.05433930f, -0.00344766f, 
    0.02582114f, 0.03330051f, -0.01955993f, 0.03609131f, 0.02751075f, 0.03171903f, -0.05583223f, -0.01367146f, 
    -0.00599188f, 0.05869335f, 0.00264203f, 0.05619074f, -0.03047554f, 0.01670464f, 0.05174151f, -0.06271806f, 
    -0.02630016f, -0.04221303f, 0.00698130f, -0.04107817f, 0.06930821f, 0.02815918f, -0.03114928f, -0.00808722f, 
    0.05613822f, 0.08378684f, 0.07836316f, 0.08293631f, 0.01326725f, -0.11608398f, -0.04331942f, -0.03086592f, 
    0.07544339f, -0.20659842f, 0.05294571f, -0.00566072f, -0.32689881f, 0.06257474f, 0.00233531f, -0.01683269f, 
    -0.10543823f, -0.01339747f, 0.37010282f, 0.10431824f, 0.16239031f, 0.11934089f, -0.00530043f, 0.11267526f, 
    -0.02689256f, 0.01565800f, -0.10046639f, 0.15548304f, -0.04080082f, -0.00187446f, -0.21518052f, 0.18764228f, 
    0.05044402f, 0.10385894f, -0.06893574f, 0.04003997f, 0.04491845f, 0.01782654f, 0.03435918f, -0.07762660f, 
    -0.15000908f, -0.02645831f, -0.07199960f, 0.04911283f, 0.04079705f, -0.02245370f, -0.00943469f, -0.01866337f, 
    -0.04161144f, -0.07858217f, 0.07923006f, -0.01619764f, -0.00154873f, -0.08432531f, 0.30309772f, -0.03776525f, 
    0.11375307f, 0.17921034f, 0.13381225f, 0.07475218f, 0.01276146f, -0.09862993f, -0.02283537f, 0.03257349f, 
    -0.11919838f, 0.07657614f, -0.03098525f, -0.00710914f, -0.00017432f, -0.00938022f, 0.07428501f, -0.06514566f, 
    -0.12239986f, 0.17205119f, 0.00604374f, 0.09805236f, -0.13981058f, -0.04776966f, -0.05441969f, 0.00254446f, 
    0.08015951f, -0.08080059f, -0.34622490f, -0.11605468f, -0.11561556f, -0.11448045f, -0.02130499f, -0.05695265f, 
    0.03664860f, -0.03153361f, 0.06276153f, 0.22005677f, 0.21229170f, -0.06716472f, -0.08647996f, 0.02693457f, 
    0.01945761f, -0.03481206f, 0.10524010f, 0.01398582f, -0.19552402f, -0.09612966f, -0.13234983f, 0.09533776f, 
    -0.18772031f, 0.06255659f, 0.07706455f, -0.09981692f, 0.20127659f, 0.03106712f, -0.03827906f, 0.14799218f, 
    -0.07720252f, 0.09106479f, 0.14408496f, 0.08555888f, -0.05877263f, 0.31581154f, 0.37683284f, 0.15823649f, 
    0.23218954f, 0.06360419f, 0.00421662f, -0.04762093f, 0.03506225f, -0.02168286f, -0.05897819f, 0.06525601f, 
    0.00041413f, -0.03295513f, 0.03206502f, -0.01651121f, -0.07489708f, 0.01477952f, 0.08504014f, -0.24762011f, 
    -0.18401541f, 0.01369355f, -0.18435967f, -0.23242222f, 0.06671491f, -0.04020482f, 0.01669148f, -0.09259897f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.10586327f, 0.16649066f, 0.14463851f, 0.14355101f, 0.04127922f, 0.01368951f, -0.06243435f, 0.34720176f, 
    0.06013042f, 0.05316071f, 0.12553953f, 0.08324824f, 0.07230894f, -0.01130198f, -0.06040039f, -0.01147576f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.23789982f, 0.17479374f, 0.05954352f, -0.08899353f, 0.02263071f, -0.02537746f, -0.24317043f, -0.05141521f, 
    0.50382912f, -0.48784029f, -0.08195163f, -0.27419996f, 0.11767517f, 0.16685486f, 0.15638578f, 0.41875315f, 
    -0.04869246f, 0.31433892f, 0.33324933f, 0.04003903f, 0.13239035f, -0.22133420f, 0.37545812f, -0.24195674f, 
    -0.08073372f, 0.03783955f, -0.08204433f, -0.06893198f, 0.09497263f, 0.12167367f, 0.09914351f, -0.39956319f, 
    -0.05769484f, 0.19893707f, 0.23273146f, 0.20343278f, 0.09500432f, -0.01418466f, -0.46166554f, 0.10882302f, 
    0.24546459f, -0.11330960f, 0.26007959f, -0.09578890f, -0.20642008f, 0.19908303f, 0.21322800f, 0.62950820f, 
    0.02545818f, 0.33182046f, 0.21822332f, -0.25805965f, -0.09447659f, 0.34116474f, 0.29862976f, 0.41365695f, 
    -0.39593184f, -0.21102712f, -0.11510922f, -0.17123662f, -0.33378300f, 0.09142715f, -0.08706280f, 0.15694745f, 
    0.00705909f, 0.44855824f, 0.20491475f, 0.29297197f, -0.10776357f, -0.26516226f, -0.09029852f, -0.22083575f, 
    0.18204251f, -0.26253542f, 0.07670072f, 0.16253296f, 0.23630263f, 0.02392646f, 0.06383922f, -0.33054423f, 
    -0.07493015f, 0.24730276f, -0.34989771f, -0.00592206f, 0.06233027f, 0.18093866f, -0.25902429f, -0.16232415f, 
    -0.09802017f, 0.23105256f, 0.39740357f, 0.32063895f, 0.19712915f, -0.12718709f, -0.14251877f, -0.03414626f, 
    0.09179536f, -0.21963716f, 0.11697182f, -0.17851591f, -0.08343774f, -0.04015666f, -0.09157223f, 0.09715030f, 
    0.01293293f, -0.17938182f, -0.06125611f, -0.18428832f, 0.00049344f, 0.11999935f, 0.00074252f, -0.22885197f, 
    0.00182723f, 0.18623634f, -0.54789639f, -0.19399132f, -0.24844283f, 0.34837162f, 0.49770886f, -0.28088698f, 
    -0.11200395f, -0.37475479f, -0.21235378f, 0.19598310f, 0.15537448f, 0.18866536f, 0.11976957f, -0.34756747f, 
    -0.16546732f, 0.49852097f, 0.35543823f, -0.15447630f, -0.16168346f, -0.10168313f, 0.00100004f, -0.09533130f, 
    -0.16768818f, 0.04765344f, -0.08559246f, -0.10727248f, 0.29031944f, -0.21928512f, 0.00909683f, -0.42419887f, 
    -0.24085589f, -0.13491057f, -0.24223755f, 0.27644962f, -0.09498145f, -0.00287101f, 0.21222177f, -0.33794841f, 
    0.30970144f, 0.01029289f, 0.01807494f, -0.21098788f, 0.11662693f, 0.06563416f, -0.09818491f, 0.03253011f, 
    0.20955764f, -0.30406463f, 0.33979023f, -0.08956340f, 0.20904151f, 0.28887251f, -0.05173389f, 0.08670195f, 
    -0.24011217f, -0.13447402f, -0.11986516f, 0.15952764f, 0.23457740f, 0.01715300f, -0.24774145f, 0.27123526f, 
    0.02914228f, 0.26347682f, -0.15269315f, -0.19574293f, 0.17433624f, 0.28977799f, -0.27038264f, 0.42093712f, 
    0.11836018f, 0.30971915f, 0.15516390f, 0.15079154f, -0.11081605f, 0.19361457f, -0.11496964f, -0.33949819f, 
    0.12263652f, -0.50163513f, 0.11616349f, 0.10873293f, 0.16672944f, -0.07106036f, 0.39037338f, -0.01492902f, 
    0.25175723f, 0.02744868f, -0.36306897f, 0.23612514f, 0.02215064f, -0.25894508f, -0.00589776f, -0.28062883f, 
    0.06346326f, 0.18380553f, 0.23195960f, -0.27192241f, -0.14288212f, 0.00089772f, -0.13927466f, 0.23417901f, 
    0.11162955f, -0.33327949f, -0.73719972f, -0.12065760f, 0.14546223f, 0.00590601f, -0.02267444f, 0.22566234f, 
    0.15952747f, -0.00542799f, -0.01788421f, -0.20743802f, 0.08943660f, 0.06189699f, -0.14251302f, -0.10531634f, 
    0.33974993f, -0.04062796f, -0.47506246f, -0.09649000f, 0.28565583f, -0.15599920f, -0.05253268f, -0.27436355f, 
    -0.21633101f, 0.19818798f, -0.17949134f, -0.17549808f, 0.06081152f, -0.02824797f, -0.14119801f, -0.09877852f, 
    0.00446927f, -0.23964444f, 0.04101549f, -0.00203833f, -0.15658864f, -0.16884863f, -0.24252367f, 0.07118902f, 
    0.14688298f, 0.04171992f, -0.12945738f, -0.10643281f, 0.22867030f, -0.14662564f, 0.10458514f, -0.03176896f, 
    -0.10723471f, 0.07550223f, -0.18151091f, -0.01383600f, -0.23944095f, -0.09651500f, -0.16142535f, -0.19184008f, 
    -0.11844023f, -0.05296109f, -0.01833150f, 0.37338999f, -0.09912181f, -0.26647976f, 0.36576930f, -0.16186936f, 
    -0.02109448f, -0.11710978f, 0.30907226f, -0.33013502f, 0.37512633f, -0.10908347f, -0.08288109f, -0.20642462f, 
    -0.22953068f, -0.05515306f, 0.23285343f, -0.44048175f, 0.07953880f, 0.04273827f, 0.46858993f, 0.16875248f, 
    0.05191098f, -0.13636583f, 0.32602233f, -0.44449115f, -0.04197823f, 0.09221780f, -0.14412257f, 0.26973674f, 
    -0.00332676f, 0.15261282f, -0.27701530f, 0.28383705f, -0.05721803f, 0.16182655f, 0.17121165f, -0.25533104f, 
    0.14832062f, 0.24049710f, 0.31725839f, -0.30087924f, -0.19171606f, -0.22490804f, -0.09771555f, 0.02370382f, 
    0.20021614f, -0.08766451f, 0.10156765f, 0.42539471f, -0.14420342f, -0.46948433f, -0.18275483f, 0.56203067f, 
    -0.01060138f, 0.09150790f, 0.41038248f, -0.17681584f, -0.41190901f, -0.24370307f, 0.12219561f, 0.18413039f, 
    -0.04568722f, 0.00510718f, -0.08091606f, 0.29003990f, 0.24467216f, 0.40448192f, 0.32810763f, 0.32283509f, 
    -0.22956398f, 0.07130546f, -0.06933863f, -0.24596819f, 0.14450531f, 0.12323203f, 0.24589667f, -0.30760434f, 
    -0.03334479f, 0.11204487f, -0.06633566f, -0.01207115f, 0.10585393f, -0.12553380f, -0.19859420f, 0.05701987f, 
    -0.13247532f, 0.23126900f, 0.28058192f, 0.30335975f, 0.27329558f, -0.15497810f, -0.19372517f, -0.33658269f, 
    -0.03108197f, -0.07162875f, -0.08058703f, -0.09802875f, 0.24357948f, 0.05282465f, -0.13455701f, -0.12761626f, 
    -0.08335274f, -0.01216137f, -0.18017048f, -0.23362336f, -0.22182265f, 0.08748594f, -0.10745654f, -0.19479477f, 
    0.05640331f, 0.26174074f, 0.14543284f, 0.19749124f, 0.08006430f, 0.42627153f, -0.29793024f, 0.21321766f, 
    0.23360516f, -0.23680195f, -0.27712929f, -0.29040751f, -0.32333639f, 0.17693372f, -0.09156375f, 0.08244915f, 
    -0.16281860f, -0.18253681f, -0.42031834f, 0.03758342f, -0.06831340f, 0.25270393f, -0.00321952f, 0.32447475f, 
    0.12202391f, 0.42534754f, 0.08396749f, -0.28350890f, 0.10637518f, -0.12012548f, -0.17555413f, 0.06272424f, 
    0.17209333f, 0.01753907f, -0.10204814f, 0.18211100f, 0.20673707f, -0.21047314f, -0.10350026f, 0.02963187f, 
    -0.23319021f, 0.16063273f, -0.19003834f, -0.20474413f, -0.12376889f, 0.18877047f, 0.21702564f, -0.09365986f, 
    -0.02882779f, -0.47417507f, -0.13008657f, 0.14226224f, -0.13941276f, 0.24231979f, 0.35851794f, -0.19707814f, 
    0.19355078f, -0.03518537f, -0.44631281f, 0.01426225f, 0.29670069f, -0.02153582f, 0.09487595f, 0.23484682f, 
    0.14736621f, 0.23557937f, 0.20013206f, -0.28863439f, 0.06369799f, 0.09376816f, 0.21662255f, -0.13791876f, 
    0.19452725f, -0.19881177f, 0.27653053f, -0.17624652f, -0.14126079f, 0.05865701f, 0.12593272f, 0.12875415f, 
    -0.01008914f, 0.38712612f, 0.35905012f, 0.38816842f, 0.22724459f, -0.14291565f, -0.22905307f, -0.12047862f, 
    -0.23031652f, -0.29050419f, 0.01271840f, 0.35648945f, -0.04979815f, 0.10305753f, -0.17410377f, -0.29264879f, 
    0.21762022f, -0.01614847f, -0.20843078f, 0.00551373f, 0.16343136f, -0.14087461f, -0.06255089f, -0.11443395f, 
    -0.19877930f, -0.05144249f, 0.14621729f, 0.03680511f, 0.04816314f, -0.00801831f, 0.10511412f, -0.04937973f, 
    -0.16602889f, -0.26887506f, 0.04516075f, -0.23209935f, 0.23084034f, 0.29812667f, 0.07119440f, 0.28808445f, 
    -0.04974994f, 0.36750671f, 0.19303843f, -0.08988467f, 0.12490584f, 0.24455403f, 0.19928859f, -0.56104803f, 
    0.04817095f, 0.00486186f, 0.09565490f, -0.14570454f, 0.04641908f, -0.23027289f, 0.12317720f, 0.00917098f, 
    -0.08549547f, -0.16632825f, -0.06321341f, -0.20668128f, -0.08956516f, -0.01160729f, 0.07041785f, -0.18596858f, 
    0.11429793f, -0.09475753f, 0.24839546f, 0.36677513f, 0.06429315f, -0.28060141f, 0.39572719f, -0.21428905f, 
    -0.11580995f, -0.04232504f, -0.46147174f, -0.03999063f, -0.07771036f, -0.15771782f, -0.19662163f, 0.01887962f, 
    -0.05724346f, -0.16165045f, -0.09072980f, -0.20502242f, -0.19298474f, -0.22476342f, -0.09643611f, 0.00794708f, 
    0.17136545f, 0.24949701f, 0.37761962f, 0.11660070f, 0.31745940f, -0.07234495f, -0.09905309f, 0.42500633f, 
    0.04803663f, -0.24559548f, 0.04264659f, 0.09581769f, 0.00181183f, -0.22138727f, -0.10117197f, 0.08261192f, 
    -0.22684941f, -0.03473672f, -0.23012504f, -0.24929368f, 0.10874605f, 0.21990350f, 0.16368410f, -0.06077039f, 
    0.01709460f, -0.21681331f, 0.31991631f, -0.11567403f, 0.07881606f, 0.00582459f, 0.36202690f, 0.50597930f, 
    -0.21456923f, -0.06349096f, 0.35488218f, 0.09035502f, -0.03397888f, -0.10792656f, -0.22567336f, 0.35694078f, 
    -0.20130953f, 0.26132548f, 0.30096471f, 0.30928040f, -0.10650158f, 0.27286017f, 0.07091895f, 0.25019398f, 
    -0.28544000f, -0.26855189f, -0.29855186f, -0.20898485f, -0.02901987f, -0.18372281f, 0.14989296f, -0.12613890f, 
    -0.13746798f, 0.04275273f, 0.00409960f, -0.19204369f, -0.13863075f, -0.12128403f, -0.15573189f, 0.07993007f, 
    -0.26398236f, -0.01611361f, -0.18544638f, 0.00328791f, -0.08566228f, -0.20686376f, -0.04851159f, -0.27112100f, 
    -0.17709860f, 0.46056473f, -0.01932745f, -0.29663756f, -0.15305953f, 0.12679754f, 0.16289563f, 0.18244359f, 
    0.15133810f, -0.49135476f, -0.28873259f, 0.03400703f, 0.22834280f, 0.04617868f, -0.19691965f, -0.31467372f, 
    -0.20171605f, -0.20356694f, -0.23815751f, 0.33435518f, 0.06464759f, 0.19717985f, 0.05121588f, 0.02640310f, 
    -0.35724196f, 0.30033538f, -0.06792678f, 0.07135022f, 0.31110081f, 0.02485694f, 0.23332001f, 0.29248086f, 
    -0.02140054f, 0.13286360f, -0.14587781f, 0.38816729f, 0.03503833f, -0.09681567f, 0.12141226f, 0.17631947f, 
    -0.12276886f, -0.15737227f, 0.21111925f, 0.26557729f, -0.08142926f, -0.22325148f, -0.11825797f, 0.39151311f, 
    -0.01983950f, -0.26393896f, -0.02033779f, 0.16257559f, -0.05334780f, 0.19475758f, -0.40566194f, -0.03989847f, 
    0.28383350f, 0.12571032f, 0.16115680f, 0.15525743f, -0.44552433f, -0.04446537f, 0.22570512f, -0.01368656f, 
    0.00321348f, -0.06867369f, -0.27628604f, 0.42536697f, -0.08931454f, 0.10535249f, -0.07072790f, 0.27836716f, 
    -0.04600509f, 0.34549978f, 0.30471957f, -0.05732328f, -0.31756273f, 0.00352891f, -0.23604926f, -0.28519863f, 
    0.07866257f, -1.00958276f, 0.06444862f, 0.43659076f, -0.19692934f, 0.10442554f, -0.25105998f, 0.20915243f, 
    0.26548824f, -0.62663049f, -0.02375787f, -0.15234545f, -0.31011996f, -0.10103792f, -0.21057355f, -0.66800940f, 
    -0.18484613f, -0.01250015f, 0.36368540f, 0.21921070f, -0.23250782f, -0.34167188f, 0.11643489f, 0.14025687f, 
    0.16405177f, 0.07574808f, -0.28574577f, 0.07368262f, -0.05996989f, -0.03572299f, -0.23060958f, -0.30794603f, 
    -0.19710195f, -0.29824132f, 0.09437329f, 0.40351653f, 0.10351349f, 0.22054309f, 0.04280061f, 0.12400963f, 
    0.19591676f, 0.00137035f, -0.25941557f, 0.27531376f, -0.34399623f, 0.15112317f, -0.08368070f, -0.47554585f, 
    0.14764164f, 0.19297476f, 0.33407855f, -0.40675345f, -0.21591234f, -0.18181960f, 0.09167966f, 0.24208528f, 
    0.39565712f, 0.09460574f, 0.43507969f, -0.10077821f, 0.01904138f, -0.21442091f, -0.10215591f, -0.29540372f, 
    -0.17799416f, -0.13613848f, 0.43079439f, -0.11872708f, 0.09172954f, 0.00300511f, 0.19436473f, -0.11203991f, 
    0.15745942f, -0.14931357f, 0.17278585f, -0.11679496f, 0.00868121f, -0.15681182f, 0.10108154f, -0.17317094f, 
    -0.11301365f, 0.04036865f, 0.37901774f, -0.03580335f, -0.22485143f, 0.20207740f, -0.16788417f, -0.12298656f, 
    -0.19804448f, 0.10283466f, 0.14994600f, -0.30425152f, 0.06128525f, 0.03275212f, -0.18360347f, 0.02363589f, 
    -0.14999598f, -0.18430674f, -0.00768939f, -0.02234042f, -0.10137206f, -0.14829320f, -0.06978276f, 0.16146222f, 
    -0.21208444f, -0.23786330f, -0.16507560f, -0.01382279f, -0.10959202f, -0.24629858f, 0.07614678f, 0.03786626f, 
    0.24309190f, -0.42503420f, 0.01351129f, 0.20469813f, 0.08068561f, 0.26286554f, -0.28200123f, -0.19536787f, 
    0.26688236f, 0.16301966f, -0.51625001f, 0.12761784f, 0.17485115f, 0.05672797f, -0.19787249f, 0.08073872f, 
    0.08648516f, -0.20052437f, 0.33806363f, -0.24545585f, -0.00982145f, 0.32142290f, -0.19349127f, -0.02762780f, 
    -0.05052785f, 0.10574766f, -0.04232356f, 0.13765483f, -0.17593245f, -0.12575006f, -0.21258739f, 0.38510978f, 
    0.05063501f, 0.15860336f, 0.28516644f, -0.20733607f, 0.13177715f, 0.04839414f, -0.30357227f, 0.21459448f, 
    -0.13391821f, 0.13127126f, -0.05609435f, 0.27794564f, 0.23862502f, -0.06179523f, -0.02404412f, 0.12020714f, 
    0.12225255f, 0.33476427f, -0.01179163f, -0.62312067f, 0.12662613f, 0.05485597f, 0.03025295f, -0.45497063f, 
    0.22818606f, 0.12388878f, -0.29648229f, 0.32661003f, -0.24600355f, 0.23952973f, 0.20889366f, 0.05828390f, 
    0.05022062f, -0.11521058f, -0.02064001f, 0.28081295f, 0.01967493f, -0.20927596f, -0.05423989f, -0.52127439f, 
    0.17010915f, 0.17241256f, 0.24682304f, 0.12671417f, 0.13575387f, -0.28102234f, -0.20831873f, -0.38342410f, 
    0.09210071f, -0.07942128f, -0.04742813f, -0.02832327f, -0.19212684f, -0.40062147f, 0.17364730f, -0.03509175f, 
    0.28507233f, -0.11635052f, -0.42509332f, 0.31630313f, -0.39902884f, 0.18697661f, -0.17662248f, 0.12316868f, 
    -0.08954224f, -0.32841668f, 0.14728843f, 0.03847547f, -0.01997501f, 0.35243616f, 0.14400725f, 0.59158403f, 
    -0.21866767f, 0.06587807f, 0.19499032f, 0.19470420f, -0.28566471f, 0.16522260f, -0.16291782f, -0.24031992f, 
    0.12411305f, -0.07786193f, 0.18606183f, 0.31148601f, 0.15302004f, -0.28886205f, 0.08070429f, 0.07278293f, 
    0.19465825f, -0.04943289f, 0.19087182f, -0.03700930f, -0.20949210f, 0.07642980f, -0.16438104f, 0.47112268f, 
    0.06545186f, 0.15506275f, -0.47980097f, 0.24034697f, 0.10383109f, 0.33616897f, 0.23958203f, -0.38818684f, 
    0.26748815f, 0.02284259f, -0.29951280f, -0.16984090f, -0.19243266f, -0.11120244f, -0.02331122f, 0.10901297f, 
    0.20404342f, 0.46088767f, -0.14830494f, -0.11099839f, -0.22420540f, 0.22298105f, 0.22934029f, -0.07965025f, 
    -0.06501457f, 0.27923292f, -0.52893358f, -0.36594066f, 0.16743933f, -0.10591973f, 0.03841805f, -0.35415897f, 
    -0.13856122f, -0.00071567f, 0.03996328f, 0.21455549f, 0.03838507f, -0.06250144f, -0.46471694f, -0.13283075f, 
    0.27751788f, 0.30406541f, -0.44478920f, 0.34032270f, 0.02233322f, 0.06801042f, 0.13932070f, -0.14973919f, 
    -0.25057945f, 0.45172983f, 0.23946691f, 0.22377254f, -0.17358606f, -0.06250879f, 0.21299480f, 0.39141053f, 
    -0.15385491f, -0.36369541f, -0.08290899f, -0.21200739f, 0.01306295f, -0.26549119f, 0.11042035f, 0.37915722f, 
    0.10661951f, 0.33536285f, -0.41183776f, 0.08649767f, -0.01119388f, 0.36733735f, -0.14953873f, 0.10304016f, 
    -0.00791651f, 0.32505962f, 0.27125317f, -0.25596005f, 0.18817073f, 0.20106217f, -0.14154479f, -0.34651908f, 
    0.24345261f, -0.28591472f, 0.28623852f, -0.13875358f, -0.17187926f, -0.00223215f, -0.41092443f, 0.37878987f, 
    0.03901374f, 0.26106235f, -0.28717273f, 0.16992213f, 0.26217631f, -0.16498666f, -0.01847276f, -0.25877512f, 
    -0.17058669f, -0.03868846f, 0.53477311f, 0.26890120f, 0.18136007f, -0.22886015f, -0.10869930f, -0.00298352f, 
    -0.04510880f, -0.10630625f, 0.09646533f, 0.27632648f, 0.06171715f, 0.00017505f, -0.03822248f, 0.01220740f, 
    0.01628442f, 0.30862120f, 0.26168835f, -0.02964736f, -0.21016967f, -0.15273939f, 0.09694371f, -0.08092944f, 
    0.21759088f, -0.42524403f, -0.00956102f, -0.13249938f, -0.01346045f, -0.20529148f, -0.06871654f, 0.13611211f, 
    0.15197785f, -0.40609878f, -0.05619327f, 0.34426016f, 0.10259682f, 0.11902235f, -0.01960340f, 0.29650265f, 
    -0.22592571f, 0.12607589f, 0.36576456f, 0.20781194f, -0.38762629f, 0.22207233f, 0.18976519f, 0.36045715f, 
    -0.10264412f, 0.02253324f, -0.16909374f, -0.14919983f, 0.00009310f, -0.13488778f, -0.04257818f, -0.20948276f, 
    0.07052080f, -0.09615760f, -0.02285624f, 0.08299731f, -0.14695685f, -0.11902079f, 0.02977049f, -0.14508292f, 
    0.01691563f, 0.34026855f, 0.11244221f, 0.00606166f, -0.21838845f, -0.09579168f, -0.11030497f, 0.10568701f, 
    0.38577282f, -0.08203252f, -0.15873069f, -0.19208777f, -0.21132313f, -0.25879902f, 0.14373508f, 0.29883388f, 
    -0.23271134f, -0.29180625f, -0.06850225f, 0.02299136f, -0.11941192f, 0.15385662f, 0.21694496f, 0.22329322f, 
    0.19045410f, 0.36842561f, 0.08547707f, -0.10440300f, 0.14038867f, -0.00019433f, 0.09115236f, -0.23197117f, 
    0.05423983f, -0.40632367f, 0.02874353f, -0.35450658f, -0.06033988f, 0.06700630f, -0.02300588f, -0.08481829f, 
    0.53140891f, -0.21789825f, -0.01935748f, -0.22198778f, 0.15246575f, 0.12778200f, -0.01253158f, 0.14436412f, 
    0.08064830f, 0.14593115f, -0.00374922f, 0.44176003f, 0.23747155f, -0.24364181f, 0.31737366f, 0.35792619f, 
    -0.28084692f, -0.09957525f, -0.29977152f, 0.13846035f, -0.24709184f, 0.06596816f, -0.13526261f, 0.04723797f, 
    0.17168067f, 0.18403336f, 0.35511109f, -0.33373392f, 0.11837266f, -0.02636296f, 0.05778826f, 0.42018843f, 
    -0.28308693f, -0.10005711f, -0.17546517f, 0.02143169f, 0.31715578f, -0.02566857f, -0.18156047f, 0.27352005f, 
    0.20886734f, -0.08581752f, 0.20373826f, -0.15712348f, 0.10428715f, 0.38463432f, -0.21756588f, -0.05034105f, 
    -0.13532892f, -0.18532258f, 0.10722452f, 0.27119836f, 0.30640641f, 0.06769366f, -0.20705849f, -0.59606785f, 
    -0.01029217f, -0.28557417f, 0.04191800f, 0.47280777f, 0.07473133f, -0.38801107f, 0.07509620f, 0.19314948f, 
    0.06556872f, -0.16475007f, -0.12512419f, -0.00404433f, 0.09490774f, 0.14680681f, -0.21433184f, 0.14944074f, 
    0.12525204f, 0.33211380f, -0.06810094f, -0.14112981f, 0.18977374f, 0.33371317f, 0.21947914f, -0.08126837f, 
    0.05506343f, 0.11391128f, 0.42102790f, -0.30856514f, -0.28695726f, -0.20045350f, -0.09430395f, -0.07944668f, 
    -0.04530437f, -0.29695436f, 0.37579548f, 0.07002772f, -0.10154323f, -0.08342405f, 0.29947260f, 0.12127020f, 
    -0.31540951f, 0.30697656f, 0.24075508f, -0.42007774f, 0.39140448f, -0.22687957f, -0.15712447f, 0.10774079f, 
    0.06967086f, -0.31818792f, 0.27630296f, 0.07243489f, -0.22598842f, -0.16330817f, -0.12890278f, 0.10981773f, 
    -0.12227682f, 0.18574949f, -0.00978868f, 0.35493499f, 0.38178656f, -0.09698834f, 0.07152908f, 0.31042016f, 
    -0.15046202f, 0.27396303f, 0.41327190f, -0.21198261f, -0.14384420f, -0.27261063f, 0.15325877f, -0.12272450f, 
    -0.20896356f, 0.24592838f, 0.14811018f, 0.35161656f, 0.22619173f, 0.00232037f, 0.01775902f, -0.24829960f, 
    -0.24716163f, -0.35690802f, -0.17261542f, 0.42579642f, 0.10350824f, 0.00224070f, -0.27520993f, 0.07171686f, 
    0.39214388f, 0.25061467f, -0.04068714f, -0.30149841f, -0.60050696f, 0.06386667f, -0.08365326f, -0.00489625f, 
    0.14412399f, 0.01112719f, 0.24109244f, 0.32410699f, 0.03889728f, -0.26805142f, -0.14938331f, 0.14568628f, 
    0.38400722f, -0.16636689f, 0.07490123f, -0.18262929f, -0.19817735f, 0.04984628f, -0.00242180f, -0.13173291f, 
    -0.02230576f, -0.00072156f, -0.01124344f, 0.04822617f, -0.01060821f, -0.03355253f, -0.00534157f, 0.29659528f, 
    -0.30450803f, -0.00492383f, -0.07414135f, 0.34219456f, 0.29407692f, 0.10901665f, 0.02519469f, -0.47036767f, 
    -0.26462695f, 0.25199214f, -0.20661236f, 0.32579589f, -0.24218498f, -0.51725924f, 0.28325015f, 0.44262764f, 
    -0.30494136f, -0.07238924f, -0.09024180f, -0.08024485f, -0.02236592f, -0.13997437f, 0.10836445f, 0.47427627f, 
    -0.06927383f, -0.53296924f, 0.02139799f, 0.19964315f, -0.00861592f, 0.37321827f, 0.20248568f, -0.03885215f, 
    0.16650608f, -0.28658482f, 0.12087988f, -0.35622823f, -0.37590575f, 0.00267357f, -0.22230048f, -0.37460840f, 
    0.07022472f, -0.05807398f, 0.06614583f, 0.01249213f, 0.00788532f, 0.19082786f, 0.46371835f, -0.05600416f, 
    -0.06276506f, -0.35521173f, -0.17185462f, 0.13523796f, 0.02081831f, -0.13710555f, 0.11535463f, -0.21994524f, 
    -0.15472557f, -0.33585760f, 0.18679129f, -0.02174208f, 0.24364696f, -0.16365631f, -0.00950207f, 0.00377738f, 
    0.19383243f, 0.23312698f, 0.21019512f, 0.12306400f, 0.13580598f, 0.14511599f, 0.17737794f, 0.30591297f, 
    0.03328801f, 0.24322027f, 0.18431740f, 0.43042964f, -0.05626218f, 0.26327437f, -0.24080759f, -0.13971479f, 
    0.14148875f, -0.11784773f, -0.07444069f, -0.12389489f, -0.27926740f, -0.22229446f, 0.04166280f, 0.07500973f, 
    0.24244592f, -0.19545081f, -0.00017002f, -0.21118101f, -0.09128261f, -0.23264502f, -0.09510791f, -0.24172580f, 
    -0.20866604f, -0.08316233f, 0.01390464f, 0.16106589f, -0.19796163f, -0.12213194f, 0.18126865f, -0.02957722f, 
    -0.16104715f, 0.01877364f, 0.36448401f, -0.15906608f, -0.01492429f, -0.05432581f, -0.50053948f, 0.44903076f, 
    -0.02255980f, 0.30614775f, 0.13874909f, -0.01646545f, -0.19279030f, 0.02118950f, 0.05542547f, 0.19372430f, 
    -0.03678265f, 0.22986668f, -0.51003814f, 0.10826980f, -0.18740535f, 0.36709332f, 0.07282820f, 0.29467216f, 
    0.00511463f, -0.12060782f, 0.42277560f, -0.24289966f, -0.05094365f, 0.03411034f, 0.15732127f, -0.47366270f, 
    0.23665959f, -0.12054843f, -0.03352401f, -0.11734995f, -0.07436317f, -0.18652493f, -0.20778400f, -0.18912807f, 
    0.03074324f, -0.04160351f, -0.16011611f, -0.19284382f, 0.00855672f, 0.17926192f, -0.08425793f, 0.02583075f, 
    -0.21831177f, -0.16603705f, -0.26047522f, -0.30596253f, -0.09290412f, -0.20709778f, -0.10778002f, 0.16554192f, 
    0.16890006f, 0.12775430f, 0.80987418f, 0.21092542f, 0.33032018f, 0.10107256f, 0.00009434f, 0.12475618f, 
    -0.10667446f, 0.13260204f, -0.14421879f, -0.39546099f, 0.12529689f, -0.22906552f, 0.28277209f, 0.05945112f, 
    0.15917894f, -0.01759115f, 0.56412441f, 0.07690275f, -0.03894647f, -0.02142962f, -0.22341362f, 0.47899181f, 
    -0.07759108f, -0.35098109f, 0.26185080f, -0.43834755f, 0.12503047f, 0.07832480f, 0.20362145f, 0.15180719f, 
    0.10929647f, -0.22817451f, -0.11471838f, 0.30053288f, 0.24635227f, 0.25924733f, 0.01307728f, 0.54408294f, 
    -0.10581135f, 0.00993018f, -0.20644079f, 0.11168715f, 0.24839404f, -0.35349131f, 0.11334431f, -0.14809717f, 
    0.37893090f, 0.27749661f, 0.38174933f, 0.16681214f, -0.30072337f, 0.18709278f, -0.02100956f, -0.03704480f, 
    -0.16718027f, 0.03046816f, 0.30173084f, 0.35972977f, -0.21082960f, -0.13499379f, -0.19809753f, -0.30365163f, 
    0.38308573f, -0.10587566f, 0.25962511f, -0.15680082f, -0.24171649f, 0.08203511f, -0.02962563f, -0.13341480f, 
    -0.11457487f, 0.41597050f, 0.22598098f, -0.15862007f, 0.00738141f, 0.17282236f, -0.35984915f, 0.22914970f, 
    -0.13801537f, 0.22657922f, 0.15370034f, 0.01178253f, 0.30769712f, 0.22547336f, 0.14538188f, 0.05789018f, 
    -0.26331756f, 0.24450694f, -0.32416695f, -0.00646164f, -0.09304223f, 0.32332033f, 0.27398893f, -0.44857702f, 
    0.07064119f, -0.23597738f, 0.22268964f, -0.00877035f, 0.26498601f, -0.19797595f, -0.01589778f, -0.38148561f, 
    -0.09839281f, 0.07730033f, -0.00099802f, -0.16233824f, -0.06978369f, -0.25378773f, -0.12221723f, 0.04488919f, 
    -0.14835358f, -0.11558192f, -0.21709174f, -0.20130642f, 0.03113556f, -0.21436638f, -0.13576850f, -0.23605447f, 
    0.00971274f, 0.09698245f, -0.31831869f, 0.40255693f, 0.18224049f, -0.17264666f, 0.45601794f, -0.36307216f, 
    -0.07670969f, -0.26634011f, 0.12198469f, -0.06204977f, 0.33800513f, 0.15966998f, 0.18567260f, -0.27370828f, 
    0.17511576f, 0.45965594f, 0.25793791f, 0.12811565f, 0.22975753f, -0.02893965f, -0.00506037f, -0.14217126f, 
    -0.02947096f, 0.07625873f, 0.31337288f, -0.48256829f, 0.10382053f, 0.06036196f, 0.16887130f, -0.37946734f, 
    -0.04912380f, -0.35550615f, -0.08215533f, 0.31419346f, 0.24641585f, -0.37847322f, 0.10508488f, 0.34201527f, 
    -0.01485429f, 0.28771976f, 0.06405030f, 0.27020597f, -0.22203192f, -0.12560785f, -0.16456324f, -0.06632970f, 
    -0.25476256f, 0.14466733f, -0.16138105f, 0.05545640f, -0.19350998f, 0.43781894f, -0.13269953f, 0.31118533f, 
    0.27309534f, 0.05311286f, 0.20163622f, -0.18775582f, -0.16475974f, 0.20414492f, 0.21608502f, -0.38651782f, 
    0.14333041f, 0.42665884f, 0.14021263f, -0.28090119f, -0.04619473f, -0.31769100f, 0.27053550f, 0.26416907f, 
    0.01484645f, 0.11156996f, 0.36600417f, -0.32232386f, -0.16682908f, -0.04330138f, -0.08310211f, 0.37740195f, 
    0.12192631f, 0.13440806f, 0.12185015f, -0.26030773f, -0.20275058f, 0.18578331f, -0.34143454f, 0.28332302f, 
    -0.02579887f, 0.29149225f, -0.03778211f, -0.03486001f, 0.23457846f, -0.15092209f, 0.05587174f, 0.38759682f, 
    0.19278941f, -0.19667904f, -0.30371118f, 0.45474768f, -0.16219239f, 0.14387825f, 0.23482352f, -0.36445525f, 
    0.25790215f, 0.13054958f, -0.11108647f, -0.13070841f, -0.13977276f, 0.23433782f, 0.10645050f, 0.07353229f, 
    -0.19052358f, 0.24630578f, 0.05285056f, 0.01766545f, -0.11945599f, -0.32405302f, -0.00986238f, -0.31591132f, 
    0.49252903f, -0.48223940f, 0.08527612f, -0.42287135f, 0.08442218f, -0.13064691f, 0.22227760f, -0.15052582f, 
    0.19746402f, 0.25389510f, -0.07365944f, -0.13100186f, -0.12524386f, 0.23446529f, 0.15376450f, -0.04494369f, 
    0.06730249f, 0.06452056f, 0.12871592f, 0.14376943f, -0.26690304f, 0.03756939f, 0.09011484f, -0.28834280f, 
    -0.09530170f, -0.01106271f, 0.02735672f, -0.05972061f, -0.22625870f, -0.15352270f, -0.30333641f, 0.54943991f, 
    0.45627975f, -0.14599401f, -0.11852721f, -0.08966009f, -0.14243209f, -0.07692332f, -0.08602034f, 0.06344100f, 
    0.11936116f, -0.37463406f, 0.11569864f, -0.21267405f, -0.01445350f, -0.13055244f, 0.30390444f, -0.39213264f, 
    0.31527674f, -0.02846394f, 0.27451584f, 0.26206961f, -0.00474790f, 0.02098627f, -0.11441271f, 0.13556220f, 
    0.16927554f, 0.36621609f, 0.01001182f, -0.21114716f, 0.03135107f, 0.12526490f, -0.18606792f, 0.10899594f, 
    -0.18698466f, 0.24860136f, -0.09962723f, 0.24795349f, 0.19076103f, -0.02665835f, -0.14273080f, 0.04479578f, 
    0.14821725f, -0.27838698f, 0.34237167f, -0.15050854f, -0.23123677f, -0.16599689f, -0.32046950f, 0.17861113f, 
    0.20391543f, 0.04115726f, -0.35932034f, 0.01968673f, 0.29687372f, -0.15697384f, 0.08841118f, 0.11442111f, 
    -0.20133726f, 0.43036690f, -0.25919321f, -0.28886685f, -0.13693154f, 0.16170341f, 0.39017674f, -0.04428018f, 
    -0.15240803f, -0.35312992f, 0.05883005f, 0.03675863f, 0.15333997f, -0.08322150f, 0.06297198f, -0.33570483f, 
    0.15161392f, -0.42500165f, 0.35664371f, -0.12536035f, 0.23879781f, 0.29608646f, -0.02009301f, 0.08371975f, 
    -0.12187334f, -0.00007849f, 0.15406582f, 0.23728234f, -0.04847292f, -0.16744417f, 0.11785631f, 0.21500704f, 
    -0.10108940f, -0.14481765f, -0.05827451f, 0.28946584f, -0.02548027f, 0.44027948f, 0.18664335f, 0.36333799f, 
    -0.19592792f, -0.06419450f, -0.36878192f, 0.25387511f, -0.16077712f, 0.09687411f, 0.15314570f, -0.43373090f, 
    -0.25202405f, -0.05914745f, 0.27357185f, -0.22427048f, 0.02752087f, -0.29847613f, 0.22092646f, -0.22020748f, 
    0.26154834f, -0.30080336f, 0.25633165f, -0.17486022f, 0.10162329f, -0.08879060f, -0.21646753f, 0.04955550f, 
    -0.10076028f, 0.08747512f, -0.24603833f, 0.01293311f, 0.15717840f, -0.09662214f, 0.04502611f, 0.09527397f, 
    0.04518210f, -0.02616607f, -0.02736865f, 0.20587218f, -0.26063332f, -0.04405424f, -0.15336636f, 0.01147586f, 
    0.00491297f, 0.06879129f, -0.63160837f, 0.23595951f, -0.19723189f, 0.20709157f, 0.35849097f, -0.15099396f, 
    -0.22348201f, -0.18056650f, -0.02691160f, 0.57548463f, -0.06498966f, -0.05083743f, -0.11382970f, 0.15248315f, 
    -0.13636860f, 0.24853672f, -0.15172504f, -0.09475865f, 0.06150771f, 0.22254416f, 0.18678145f, -0.23930627f, 
    0.19780728f, -0.00478345f, -0.31624553f, -0.05132557f, -0.11445023f, 0.14865692f, -0.13437206f, 0.54344702f, 
    0.24846867f, -0.19124457f, -0.19235878f, -0.14696816f, -0.23535368f, 0.41848004f, -0.17490996f, -0.08249117f, 
    0.12602518f, 0.42272028f, 0.35935041f, -0.03182103f, 0.01867495f, 0.14711805f, -0.14025624f, -0.08978346f, 
    -0.10528281f, 0.15963368f, -0.03866156f, 0.10442517f, -0.20955357f, -0.16105719f, -0.12250076f, 0.39958197f, 
    -0.24228825f, 0.29026029f, -0.15028979f, 0.30614516f, -0.13619417f, 0.23253077f, -0.06471142f, -0.19369557f, 
    0.10790952f, -0.24031255f, 0.07145889f, 0.39154038f, -0.00481900f, 0.16303311f, -0.31467599f, -0.06882592f, 
    0.04144140f, -0.18604128f, -0.44385591f, 0.33121553f, 0.33655077f, 0.19158739f, 0.05944769f, -0.06255602f, 
    0.18748212f, 0.54943269f, 0.00538442f, 0.14266129f, 0.01418477f, 0.03451750f, -0.29597741f, 0.03953221f, 
    0.18306394f, 0.02780174f, -0.22170335f, -0.35086623f, 0.14899069f, 0.19478695f, 0.06089876f, -0.43583402f, 
    -0.28641871f, 0.15452640f, 0.12176095f, 0.20751373f, 0.20826331f, -0.20942892f, -0.07105979f, 0.12175485f, 
    0.41156796f, -0.35799497f, 0.14082299f, -0.15948717f, -0.10681301f, 0.11654897f, -0.18943305f, -0.14545383f, 
    0.12558313f, -0.29578987f, -0.09669212f, 0.32348371f, 0.16878521f, 0.47299400f, 0.11366435f, -0.08970834f, 
    0.08948660f, -0.13786310f, 0.25742096f, 0.22347137f, 0.00309405f, 0.22157992f, -0.06670240f, -0.38674754f, 
    0.05286443f, -0.08475888f, 0.23604031f, -0.16599029f, -0.09903811f, -0.25886294f, 0.36727583f, -0.22433816f, 
    0.30332732f, 0.03340716f, 0.24146536f, 0.13080576f, -0.13586637f, 0.08410214f, -0.10693198f, -0.26510295f, 
    -0.00843454f, 0.48551288f, -0.31191793f, 0.09834968f, -0.03099941f, 0.03364220f, -0.07698676f, 0.00651008f, 
    -0.10540215f, 0.04148490f, 0.05832366f, -0.33340225f, 0.20823149f, -0.09360793f, -0.18741788f, 0.29978442f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.21938802f, 0.34175143f, -0.26424849f, 0.28768814f, 0.11769124f, -0.12956634f, -0.18826360f, -0.05813348f, 
    0.20891766f, -0.00948712f, 0.09394513f, -0.06759243f, 0.08821119f, 0.51064098f, 0.38385311f, -0.13787474f, 
    -0.15767407f, -0.14112680f, 0.23436204f, -0.13936654f, 0.25976202f, 0.26313356f, 0.10748545f, 0.10723442f, 
    0.25335506f, -0.11206445f, -0.02395554f, 0.08448404f, 0.03207441f, 0.23336376f, -0.13087778f, 0.34715652f, 
    -0.10261390f, 0.23582745f, -0.32997811f, -0.16233140f, -0.11958875f, 0.33100724f, 0.06612312f, 0.30318552f, 
    -0.00837491f, -0.16233627f, 0.22680964f, 0.34508181f, 0.09180423f, 0.31954753f, 0.19653769f, -0.10393795f, 
    0.29511037f, 0.17236446f, 0.07142916f, -0.17658640f, 0.01508981f, -0.01194862f, -0.29925549f, 0.35237923f, 
    0.42558649f, 0.28195235f, -0.26657435f, -0.00788884f, -0.06612892f, 0.01995671f, -0.31105024f, -0.11854628f, 
    0.28548193f, 0.27473071f, 0.36226672f, 0.19767430f, -0.11052077f, -0.09623442f, -0.32343432f, 0.32360205f, 
    0.23636907f, 0.22081327f, 0.37138429f, 0.34492722f, -0.03998164f, -0.02574065f, -0.21793509f, 0.08324937f, 
    0.29523879f, 0.35875577f, 0.37117001f, 0.05461572f, -0.01098869f, 0.13468663f, -0.39842501f, -0.06803562f, 
    0.20722502f, 0.43113011f, -0.01862603f, -0.03059888f, -0.36355296f, -0.26633415f, -0.41218135f, -0.00914744f, 
    0.08286819f, -0.16173378f, -0.09669091f, 0.06774455f, 0.10041530f, 0.34235936f, -0.00162704f, -0.23962015f, 
    0.16980354f, -0.29475439f, -0.16915850f, 0.31136549f, 0.31538484f, 0.12650277f, 0.05235502f, 0.10427179f, 
    0.19012827f, -0.13740270f, 0.11214973f, 0.33749723f, 0.42313957f, -0.30972511f, -0.52153569f, -0.31331229f, 
    -0.05000741f, 0.33797714f, 0.18754517f, 0.04561669f, 0.28059667f, -0.04489776f, 0.38892829f, -0.00509402f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07481274f, 0.03758522f, 0.06943144f, -0.08325624f, 0.05505570f, -0.07057247f, 0.07175833f, 0.06546839f, 
    -0.05752059f, -0.05155588f, -0.05302558f, -0.00387034f, 0.03857790f, -0.02676182f, -0.06090514f, 0.07925933f, 
    -0.05449035f, -0.09870636f, 0.05602094f, -0.09847490f, 0.01452671f, 0.03556165f, 0.07018537f, 0.01867063f, 
    -0.04599835f, 0.04172600f, -0.00273993f, -0.03527400f, -0.09589427f, -0.06307825f, 0.05306970f, 0.05661138f, 
    0.05107401f, 0.01356753f, 0.01487376f, 0.06863426f, -0.09764518f, -0.09347048f, 0.03258105f, 0.03430984f, 
    0.00035245f, -0.05972913f, 0.06212731f, -0.04815542f, 0.09793971f, 0.01160761f, 0.00163086f, -0.07861913f, 
    -0.09138998f, -0.07841950f, -0.05894693f, 0.03504829f, 0.04473173f, -0.09792084f, 0.02403328f, -0.06316894f, 
    0.04614251f, 0.04344911f, -0.04525989f, -0.10329666f, 0.03931516f, -0.08581687f, 0.01200381f, 0.04609174f, 
    0.02791012f, -0.08505799f, 0.00775123f, -0.09701663f, -0.08491731f, -0.03122567f, -0.07933588f, -0.04365510f, 
    0.01945452f, 0.00510094f, -0.06093739f, 0.01608130f, -0.10738172f, -0.09183621f, 0.01859573f, -0.10746408f, 
    0.03419047f, 0.00543079f, -0.06347629f, -0.04691605f, 0.06057291f, -0.03941007f, -0.01257466f, -0.04859449f, 
    -0.02345300f, 0.03946904f, -0.02581120f, 0.05276776f, 0.00435623f, -0.10357449f, -0.08007014f, 0.02984145f, 
    -0.00967330f, -0.00565484f, -0.04483104f, -0.03255028f, -0.05228101f, -0.04496989f, 0.05941954f, 0.02236486f, 
    -0.04639078f, 0.04451764f, -0.08586717f, 0.05815845f, -0.07916196f, -0.02868151f, -0.07848730f, -0.03866242f, 
    -0.07977957f, 0.03222385f, -0.00208310f, 0.02364447f, 0.01243229f, 0.05613824f, -0.02916649f, -0.06703658f, 
    0.00667398f, 0.00341652f, -0.07604163f, -0.05801489f, -0.01017989f, -0.00547481f, 0.04610908f, -0.06994675f, 
    0.28390610f, 0.00935333f, 0.42634070f, 0.17976700f, 0.09673866f, 0.01338933f, 0.08100284f, 1.04061508f, 
    0.15905252f, 0.13053808f, 0.00414461f, 0.04680422f, -0.15171391f, 0.57594436f, 0.42837721f, -0.03820919f, 
    0.00075405f, 0.04276691f, -0.01122490f, -0.02435778f, -0.10175544f, -0.12537767f, -0.08214206f, -0.01980036f, 
    0.05098657f, -0.06495631f, 0.02300039f, 0.11838704f, 0.16372892f, 0.23555204f, -0.01209080f, -0.15367688f, 
    0.00223352f, -0.05250081f, -0.13592434f, -0.08405071f, -0.23708618f, -0.03684724f, 0.00730520f, 0.46530476f, 
    -0.29187343f, 0.11420501f, 0.12146309f, -0.29726845f, -0.00104440f, -0.17811500f, -0.05412814f, 0.12313502f, 
    -0.13861777f, -0.12593715f, -0.02064358f, 0.02760040f, -0.41458094f, -0.24268006f, 0.09741040f, -0.11288838f, 
    0.16243480f, -0.34524348f, 0.02627883f, 0.30695212f, 0.30509830f, 0.12069266f, 0.26042911f, 0.19526033f, 
    0.13110466f, -0.12126487f, 0.13473682f, -0.29535866f, 0.01864007f, 0.17161748f, -0.04992713f, 0.25829899f, 
    -0.10057946f, 0.07476951f, 0.04669219f, -0.31418762f, 0.19790182f, -0.23215626f, -0.29537627f, -0.15995334f, 
    0.09680051f, 0.06881949f, 0.04343016f, 0.13567388f, -0.22341006f, 0.09182034f, -0.24851705f, 0.11543746f, 
    -0.00177295f, 0.10851257f, 0.05334054f, -0.03019329f, 0.12543015f, 0.16710858f, -0.01379499f, -0.04433133f, 
    0.07690646f, -0.16047621f, 0.32758668f, -0.02249651f, 0.18263468f, -0.05647106f, -0.28750116f, 0.21604747f, 
    -0.03766840f, -0.19878042f, 0.20138456f, 0.41487527f, 0.05042732f, 0.39428329f, -0.02449715f, -0.05925135f, 
    -0.00045789f, 1.00169992f, -0.26264554f, -0.05911542f, -0.00119453f, -0.05019026f, 0.69287133f, 0.14555885f, 
    -0.14949605f, -0.04183498f, 0.36771321f, 0.42106384f, 0.14895688f, 0.04347330f, 0.00505926f, 0.12112559f, 
    -0.20644249f, -0.02667162f, -0.29141161f, -0.01535448f, -0.13829769f, 0.07361604f, 0.04895459f, -0.59602624f, 
    -0.18796471f, 0.03891164f, 0.06517294f, 0.07214850f, 0.19357888f, -0.19674101f, -0.10412684f, -0.01736382f, 
    -0.04764036f, -0.01677768f, 0.16216271f, 0.13695589f, 0.02963797f, 0.21663544f, 0.02302957f, 0.01513801f, 
    -0.05118128f, 0.25944203f, 0.00113043f, 0.12945297f, 0.06966664f, 0.06753264f, -0.01494161f, 0.24721564f, 
    0.06010986f, 0.00949745f, -0.05529450f, 0.01286458f, 0.14904004f, 0.09974172f, 0.08684909f, -0.05894432f, 
    0.06094621f, -0.01067937f, 0.10764913f, 0.50924367f, -0.65722811f, 0.09516845f, 0.32769284f, 0.04978416f, 
    0.19579694f, 0.02986712f, -0.05227831f, 0.01747369f, 0.08323020f, 0.04108087f, -0.16359036f, -0.02729108f, 
    -0.17268549f, 0.43184212f, -0.09559376f, -0.03474603f, 0.16919979f, 0.04333979f, -0.10709849f, 0.18034546f, 
    0.06682035f, -0.11447080f, -0.09645676f, 0.19392736f, 0.06497823f, -0.03302969f, 0.13810502f, -0.02495670f, 
    0.16220705f, -0.03283549f, 0.08919336f, -0.07318008f, 0.10166767f, 0.17704117f, -0.03420752f, -0.06635769f, 
    0.00297689f, 0.11020616f, 0.12407196f, -0.06396964f, -0.12831563f, 0.31823841f, 0.05354792f, 0.22401798f, 
    -0.04861699f, -0.13335535f, -0.18311033f, 0.06221210f, 0.11875081f, -0.08024988f, 0.10709409f, -0.01438381f, 
    0.13607325f, -0.06348442f, -0.20598955f, -0.06925716f, -0.16806972f, 0.04563423f, 0.04373292f, 0.06123550f, 
    -0.11252555f, 0.01525783f, 0.02132295f, -0.32723346f, 0.16037437f, -0.14766246f, -0.00993074f, -0.00938161f, 
    -0.12937629f, -0.56996256f, 0.13776407f, 0.43510115f, 0.10362925f, -0.19766952f, 0.05987381f, 0.03696402f, 
    0.29057068f, -0.13469017f, 0.06841799f, -0.18345217f, -0.03617371f, 0.16308975f, 0.11400787f, -0.15726513f, 
    0.13538203f, -0.00817389f, 0.02986665f, 0.34681380f, 0.05574780f, 0.16567661f, -0.04362239f, 0.15190776f, 
    -0.08518290f, 0.08291067f, 0.07155546f, -0.00226375f, 0.03808795f, -0.10250851f, 0.02143188f, 0.06202311f, 
    0.00855526f, -0.04305464f, 0.09790764f, 0.17736235f, -0.02305277f, 0.06773500f, -0.13469322f, -0.08190577f, 
    -0.00251144f, 0.06811559f, -0.08904293f, -0.01636856f, 0.13967942f, 0.13542764f, 0.07336794f, 0.07964687f, 
    0.05382738f, -0.19420892f, -0.01938720f, 0.07834023f, -0.00563806f, 0.04885832f, -0.07556347f, 0.22693399f, 
    -0.02206927f, 0.10291000f, 0.00613693f, -0.18208151f, -0.63851285f, -0.02924971f, 0.06910940f, 0.13864084f, 
    0.06826206f, 0.10718709f, 0.01230726f, 0.09683380f, 0.09308395f, -0.11844780f, 0.14353575f, -0.02491979f, 
    -0.11247987f, -0.07345343f, 0.02751612f, 0.09861270f, 0.12709205f, 0.02140713f, 0.02159891f, -0.17972752f, 
    -0.03250406f, -0.02422649f, 0.19952023f, -0.01191797f, 0.04525667f, 0.08082810f, 0.04127295f, 0.19147767f, 
    -0.05869789f, -0.01360252f, 0.06000218f, -0.12049477f, 0.18818732f, -0.04114586f, -0.05372837f, -0.01009571f, 
    0.12003908f, 0.11707672f, -0.09232569f, 0.02100593f, 0.11150176f, 0.03729521f, 0.00334949f, 0.11816417f, 
    0.01339173f, -0.08471832f, -0.32870796f, -0.04244832f, 0.01362607f, 0.14119571f, 0.04345511f, 0.10009138f, 
    0.15298171f, -0.13189615f, 0.03537292f, 0.01403689f, -0.00312079f, 0.01743216f, -0.07391860f, 0.05680656f, 
    0.16415927f, 0.00928118f, -0.03635044f, 0.22240023f, 0.06283404f, -0.04069068f, 0.12267072f, 0.00635387f, 
    -0.03008522f, -0.20089830f, 0.01094134f, -0.01459493f, 0.17546825f, -0.00228627f, -0.05443584f, 0.17367800f, 
    0.02659129f, -0.03394432f, 0.07165708f, 0.00519116f, 0.10137931f, 0.03985139f, 0.13802776f, 0.08888595f, 
    -0.09045001f, 0.29453793f, -0.71118218f, -0.03196468f, 0.21673186f, 0.10999496f, -0.05091171f, -0.79861331f, 
    0.06909052f, -0.02254531f, 0.03504388f, 0.00326662f, 0.28249979f, -0.01769047f, 0.09187087f, 0.03728203f, 
    0.00515617f, -0.00099896f, 0.05664942f, -0.14748041f, -0.32748631f, 0.11739220f, 0.24908988f, 0.07922433f, 
    -0.23361196f, -0.12436360f, -0.02144081f, 0.08412025f, 0.10308374f, -0.20455606f, 0.06336503f, 0.25558159f, 
    -0.00099486f, 0.17843382f, 0.09242701f, 0.07884934f, 0.22934149f, 0.00248535f, -0.01774743f, 0.15303935f, 
    0.15520418f, 0.05259871f, -0.12915212f, -0.13235927f, -0.90678281f, 0.04842985f, 0.04131476f, 0.16886260f, 
    0.09859153f, 0.04005793f, 0.08823298f, -0.13571389f, 0.07472726f, 0.01855471f, -0.13041368f, 0.20952503f, 
    -0.06647063f, 0.11637820f, -0.08013320f, -0.40334538f, -0.11643682f, -0.00755620f, -0.12396127f, -0.14218104f, 
    0.15541099f, 0.17427468f, 0.06392682f, -0.04482215f, 0.04912099f, -0.26769206f, 0.03204444f, -0.01581096f, 
    0.30813050f, 0.15460770f, 0.46336922f, 0.02992170f, -0.01506215f, 0.18977588f, 0.01373428f, 0.30820811f, 
    -0.46821079f, -0.15360594f, 0.32594040f, 0.09709983f, -0.62676030f, 0.29047635f, -0.02241948f, -0.27603185f, 
    -0.04074326f, -0.24352559f, -0.46019259f, 0.05175120f, 0.12067754f, 0.07889215f, 0.18547663f, 0.06523731f, 
    -0.07523833f, 0.05570134f, 0.07460046f, -0.03610020f, 0.14549676f, 0.08938584f, 0.19245514f, -0.11657055f, 
    -0.02918931f, -0.03626681f, -0.23614000f, -0.27995640f, 0.00573606f, -0.23532639f, 0.22859794f, 0.12569022f, 
    0.12357560f, -0.30301961f, 0.11410967f, 0.06833325f, 0.15136454f, -0.11693873f, -0.14384124f, -0.26195973f, 
    0.01715700f, 0.07478451f, 0.02403235f, -0.31989747f, -0.08341771f, 0.13245635f, 0.25826094f, -0.18763347f, 
    0.42313543f, -0.16585758f, 0.64599425f, -0.10858936f, 0.02393331f, -0.23923008f, 0.06936461f, 0.39622858f, 
    -0.01835185f, -0.20967755f, 0.26282278f, -0.33013836f, -0.05763386f, 0.35457742f, 0.06219264f, -0.06873103f, 
    -0.07128188f, -0.56629938f, 0.03930136f, -0.67867792f, 0.11694872f, -0.24835898f, -0.16271310f, -0.01303934f, 
    0.15727103f, -0.45263353f, -0.00610659f, 0.24105026f, 0.08405764f, 0.33337525f, -0.02469989f, -0.59692425f, 
    0.02189299f, -0.15001655f, 0.14490445f, -0.07790907f, 0.06347625f, 0.00847168f, 0.01551638f, -0.05082952f, 
    0.01464099f, 0.04885893f, -0.32296422f, -0.27715704f, -0.14146440f, -0.12893637f, -0.16366699f, -0.18773112f, 
    0.02292213f, 0.07319659f, 0.02089037f, 0.22404452f, 0.19103213f, 0.10281144f, 0.29010177f, -0.48505157f, 
    -0.69036913f, 0.02226832f, 0.27757087f, -0.30607289f, -0.14459369f, -0.00054024f, 0.25456512f, -0.51882941f, 
    0.16475128f, 0.06374399f, 0.16875710f, 0.04527896f, -0.07138022f, 0.31419548f, -0.42686114f, 0.34298667f, 
    0.05968245f, 0.25128424f, -0.27639711f, -0.04325010f, -0.73184127f, 0.04913595f, 0.28520587f, -0.09678359f, 
    -1.04949343f, -0.05275229f, -0.09558070f, 0.07397252f, -0.45552251f, -0.14153363f, 0.23486863f, 0.39048049f, 
    0.04136874f, 0.10488692f, -0.76495069f, -0.06649479f, -0.25956821f, -0.00401946f, 0.41102466f, -0.66859543f, 
    -0.09139824f, 0.12847309f, -0.38515234f, -0.04720886f, -0.46895361f, -0.30294186f, -0.34453881f, -0.11901683f, 
    -0.02754209f, 0.20766650f, -0.19584045f, -0.47865996f, -0.47662458f, -0.00250708f, 0.03033008f, 0.04863530f, 
    0.20015587f, -0.28263384f, 0.14267531f, 0.09455064f, -0.25058129f, -0.10183374f, -0.13087481f, 0.21624485f, 
    -0.42674717f, -0.17273748f, 0.19685586f, 0.24101441f, -0.29517853f, -0.07664769f, -0.66014713f, 0.01786723f, 
    -0.17245163f, 0.16748969f, -0.00704774f, 0.20730454f, 0.08899407f, 0.21403490f, -0.07682276f, 0.06111922f, 
    0.34643239f, -0.09219879f, 0.13569540f, 0.15633669f, -0.45038205f, 0.25735253f, 0.02825914f, -0.05082805f, 
    -0.07314076f, -0.00710207f, -0.12738298f, -0.01152250f, -0.03572839f, -0.04520319f, 0.29723716f, -0.05643591f, 
    -0.06665792f, -0.17798579f, -0.02148735f, -0.48907083f, 0.04154810f, 0.25214654f, 0.02750222f, 0.09953208f, 
    0.01050230f, 0.30276546f, 0.05224275f, 0.01400844f, -0.06342252f, 0.08105297f, 0.03933687f, 0.13106968f, 
    0.14504856f, -0.15409040f, -0.17142302f, -0.14664681f, -0.08187055f, 0.04773494f, -0.40242201f, -0.02117658f, 
    -0.25674340f, 0.19898540f, -0.06244651f, -0.18448457f, 0.20800628f, 0.24605773f, 0.39008418f, -0.12315290f, 
    -0.24215263f, -0.16442315f, -0.10263044f, -0.21976413f, 0.24496220f, 0.15624304f, 0.09646100f, 0.18801160f, 
    0.14094844f, 0.23291852f, 0.06703571f, -0.12151822f, -0.05487464f, -0.07448478f, -0.21956229f, -0.63841832f, 
    0.00419408f, 0.22376548f, 0.04739861f, -0.06618089f, 0.19435282f, 0.13393532f, 0.13579701f, 0.33799863f, 
    -0.33226511f, -0.21388330f, 0.24374464f, 0.10282543f, -0.17731771f, -0.18152989f, -0.12501498f, -0.11351141f, 
    -0.03881669f, 0.26634544f, 0.44566745f, 0.04166939f, -0.21192677f, -0.04484318f, -0.15728948f, -0.09996860f, 
    -0.17217566f, 0.42851725f, 0.11367945f, 0.03475724f, -0.09262200f, 0.13307741f, -0.14432465f, 0.00322982f, 
    0.16914737f, 0.25093549f, -0.23020095f, -0.06546777f, -0.09037809f, -0.20457619f, -0.25704709f, 0.31726557f, 
    0.08821656f, 0.20805417f, 0.03540779f, -0.16519326f, -0.40779352f, -0.06438009f, 0.21335323f, 0.01898020f, 
    -0.10287449f, 0.36687058f, -0.10914767f, 0.31263059f, -0.12718195f, -0.49530202f, -0.22934915f, 0.29968229f, 
    -0.07301408f, -0.04225491f, -0.05838411f, 0.00054797f, -0.08166265f, -0.03183621f, -0.00688349f, -0.04758357f, 
    0.05057450f, 0.00501583f, -0.07472917f, 0.00583693f, 0.06616193f, -0.01727191f, 0.03022980f, -0.03443255f, 
    0.02339339f, -0.02048341f, -0.05950198f, -0.07040795f, 0.03379355f, -0.06818853f, -0.00065358f, 0.03982600f, 
    0.05201215f, -0.03462858f, -0.02289198f, 0.01724567f, -0.08540870f, -0.05669450f, -0.02771403f, -0.05103670f, 
    0.03346885f, -0.01351203f, -0.10982837f, -0.07021118f, -0.03788133f, 0.01810872f, 0.08523657f, 0.08130499f, 
    0.02774024f, -0.00872244f, -0.05737857f, 0.07200631f, -0.06941705f, -0.08237706f, -0.08625262f, -0.05295069f, 
    -0.04649670f, -0.04971421f, -0.02867075f, -0.05619265f, -0.02174590f, -0.03546251f, -0.06637128f, 0.05870099f, 
    -0.07549544f, 0.07044888f, 0.05991093f, -0.05392296f, -0.07238863f, 0.04419149f, 0.05564399f, -0.00425891f, 
    0.03666430f, -0.07361301f, 0.00494226f, 0.04042896f, -0.02329361f, 0.04111259f, 0.01131633f, 0.06786333f, 
    -0.02861004f, 0.05488368f, -0.08253560f, 0.00208347f, 0.04338975f, -0.08173043f, 0.04121617f, 0.00822293f, 
    -0.06427430f, -0.01582945f, 0.06965563f, 0.02047853f, -0.06601305f, 0.02697730f, -0.02918707f, 0.00437637f, 
    -0.02367884f, 0.03225223f, 0.03749567f, 0.03269036f, 0.01992310f, 0.05567520f, -0.05989243f, 0.00252978f, 
    0.03591910f, -0.09244908f, 0.04555061f, 0.05363616f, -0.03477937f, 0.05218267f, 0.03286614f, -0.08117210f, 
    -0.04886497f, 0.03797895f, -0.01300295f, -0.02861240f, 0.07095306f, -0.00367585f, 0.05685456f, 0.03741487f, 
    -0.07073530f, 0.05883757f, -0.07443664f, 0.01595284f, 0.01816418f, 0.00722478f, -0.02294947f, -0.02728516f, 
    -0.02842373f, -0.07811794f, 0.04535684f, -0.01658420f, -0.01649194f, -0.08947178f, -0.03882426f, -0.05259818f, 
    -0.06731606f, 0.00269795f, -0.06721469f, -0.07261325f, -0.02962330f, 0.00139558f, 0.05411736f, -0.07714893f, 
    -0.09383693f, -0.01710292f, 0.04532057f, 0.06808864f, -0.08724511f, -0.06120037f, 0.00975267f, -0.06394441f, 
    -0.07751684f, -0.02905132f, 0.06332925f, -0.05176249f, -0.02849117f, 0.02188925f, -0.06521780f, -0.03989627f, 
    -0.05638444f, -0.00429814f, -0.00528411f, -0.03016193f, -0.00867456f, 0.01637421f, 0.04501983f, -0.00612936f, 
    -0.01622786f, -0.00038603f, 0.01016198f, 0.08382074f, -0.04615603f, 0.04316518f, -0.00263545f, -0.03570094f, 
    -0.04973631f, 0.05316512f, -0.04791715f, -0.00501584f, 0.03511326f, 0.00000657f, -0.01894954f, 0.06279764f, 
    0.07531453f, -0.03849165f, 0.02371438f, -0.05095313f, -0.05071665f, 0.06967410f, 0.05311978f, 0.07917147f, 
    -0.08172004f, -0.06966659f, -0.03992383f, -0.07376594f, 0.05721505f, -0.08542419f, 0.03932128f, -0.05003601f, 
    0.03153664f, 0.02573381f, 0.01361326f, -0.06167305f, -0.03044617f, 0.02323648f, -0.06883191f, -0.00357667f, 
    -0.07302135f, -0.03224046f, -0.01034490f, 0.03496159f, -0.07845458f, -0.04632876f, -0.07038704f, 0.01630310f, 
    -0.03545138f, -0.05080901f, -0.09174443f, -0.08250934f, 0.04111524f, -0.07566918f, -0.06675575f, 0.01990637f, 
    -0.04326517f, 0.01583435f, 0.05667108f, 0.01367326f, 0.00640847f, 0.04058101f, 0.05545325f, 0.05073806f, 
    -0.02750704f, -0.08251453f, -0.05790434f, 0.01905273f, -0.06071278f, -0.03419186f, -0.00796744f, 0.03678971f, 
    -0.07902415f, -0.07293148f, -0.03830274f, 0.07004666f, -0.01347464f, -0.01065223f, -0.00196400f, -0.02268681f, 
    0.04341308f, -0.05277324f, 0.04393462f, 0.06983173f, -0.00142311f, -0.06821575f, 0.00121022f, -0.00768390f, 
    -0.02969657f, 0.04026472f, 0.05236915f, -0.03835486f, -0.08640683f, 0.02841377f, -0.06100941f, 0.04837982f, 
    -0.05437718f, -0.07459804f, 0.05060452f, -0.12488203f, 0.01608044f, -0.03552425f, -0.05881459f, 0.03721081f, 
    -0.00771138f, -0.06630764f, 0.01268909f, -0.10834515f, -0.09507290f, -0.05309514f, -0.08547654f, 0.00381877f, 
    -0.01655002f, -0.05446878f, -0.09683181f, -0.11852487f, 0.06454509f, -0.00732649f, 0.01172770f, -0.00705172f, 
    -0.07160903f, 0.01593792f, -0.00977458f, -0.02856023f, 0.04485369f, -0.04229625f, -0.01530395f, -0.06963850f, 
    -0.03679216f, -0.11783870f, -0.05472386f, -0.03859953f, -0.04646788f, -0.03428348f, -0.05526298f, 0.01619287f, 
    -0.09368712f, 0.04344770f, -0.01726275f, 0.02518436f, 0.01307771f, -0.01418549f, -0.07174005f, -0.06956232f, 
    -0.06605422f, 0.04440701f, 0.05933455f, -0.11601297f, -0.01043323f, -0.02256312f, 0.00025341f, -0.09700451f, 
    -0.03948966f, 0.00893367f, -0.06525256f, -0.05750391f, -0.00832494f, -0.08295652f, -0.04048610f, -0.00674479f, 
    -0.02298490f, -0.00926526f, 0.04668820f, -0.11139328f, -0.04729106f, -0.09449591f, 0.01731496f, -0.08000360f, 
    0.00192721f, -0.07003684f, -0.10017306f, 0.08716817f, -0.04452152f, 0.01778094f, -0.11484584f, -0.01230890f, 
    0.00296427f, 0.04096472f, -0.02998598f, -0.08974373f, -0.04771014f, 0.04620675f, -0.02551886f, -0.11003754f, 
    -0.06540843f, -0.01260410f, 0.01622055f, -0.07357895f, 0.00826992f, 0.03550140f, 0.01002317f, 0.00114661f, 
    0.04314594f, 0.04756312f, 0.00982507f, 0.05611838f, 0.02554815f, -0.12480637f, -0.08335224f, 0.01438224f, 
    -0.02530614f, -0.10207693f, 0.04039495f, -0.06587859f, -0.07422037f, -0.08400510f, -0.03776805f, 0.00914673f, 
    -0.08331150f, 0.04810404f, -0.02867044f, -0.08555942f, -0.00932322f, 0.00430203f, -0.06181743f, -0.09612641f, 
    -0.04468969f, 0.05594664f, -0.06510279f, 0.02098074f, -0.09027319f, 0.02756749f, -0.06858374f, 0.01823299f, 
    -0.11674771f, -0.23306794f, -0.16330704f, 0.16078919f, -0.50769848f, 0.05424957f, -0.07638445f, 0.80057824f, 
    -0.43979755f, -0.04641508f, -0.12597284f, 0.42606944f, -0.04460729f, 0.02828774f, 0.10144533f, 0.09117579f, 
    -0.06410112f, 0.02950227f, 0.16675003f, 0.07299893f, 0.32205248f, 0.11724655f, 0.12211073f, -0.01928242f, 
    0.10237633f, 0.45281759f, 0.04093475f, -0.12505902f, -0.02699775f, -0.18428917f, -0.02632549f, 0.40041730f, 
    0.00130884f, -0.54037231f, 0.06902392f, 0.06913253f, 0.04531585f, -0.20258078f, -0.06824978f, 0.01184126f, 
    0.02545401f, 0.01442469f, 0.06528490f, 0.49668440f, -0.30637854f, -0.09487659f, 0.04580893f, 0.17357719f, 
    -0.08483224f, -0.06227565f, 0.03727994f, 0.02462477f, 0.00504287f, 0.03381962f, 0.05791486f, -0.14668955f, 
    0.08182301f, 0.22390048f, -0.21513635f, 0.16600315f, 0.20186807f, -0.02292464f, -0.13115661f, 0.38222474f, 
    0.12650998f, -0.42562053f, -0.17867535f, 0.14214431f, -0.01915439f, -0.01793137f, 0.10532025f, 0.08645122f, 
    -0.13921213f, -0.20308174f, -0.01776595f, -0.23698497f, 0.18192208f, 0.05922086f, -0.07454250f, -0.27397549f, 
    0.33437160f, 0.02732933f, 0.13559888f, -0.31969982f, 0.03504800f, -0.06149556f, -0.10004538f, -0.04271827f, 
    -0.06231409f, 0.57326746f, 0.40183878f, -0.07636719f, 0.35448310f, 0.12698856f, -0.04796225f, -0.04523611f, 
    -0.06024843f, -0.05689602f, 0.02203205f, 0.08487976f, -0.18914372f, -0.01067240f, 0.11102118f, 0.30484068f, 
    0.16865547f, 0.06132314f, -0.05560125f, -0.27672017f, 0.20737828f, 0.46562296f, -0.03628971f, 0.01427931f, 
    0.01804792f, 0.28353852f, 0.02331769f, 0.08956724f, -0.06814829f, 0.08377897f, 0.25323915f, -0.01184701f, 
    0.38033119f, 0.45405379f, -0.08823191f, -0.07300238f, -0.01829974f, -0.02897600f, -0.07759356f, -0.07109964f, 
    -0.09262542f, -0.26521194f, 0.41898283f, -0.14513294f, -0.17707729f, -0.08602808f, 0.07048211f, 0.15273264f, 
    -0.21175888f, -0.07451833f, 0.17546692f, 0.16190727f, -0.01130935f, 0.20160958f, -0.02074030f, 0.09938058f, 
    0.02493134f, -0.25455707f, -0.08474120f, -0.03148993f, 0.11634320f, 0.11091789f, -0.11526242f, -0.08749627f, 
    0.14693604f, 0.24839775f, -0.01929111f, -0.06679060f, -0.12720841f, 0.14048995f, -0.02630251f, 0.20183954f, 
    0.06595097f, -0.22534376f, -0.05894136f, -0.00740837f, -0.06987064f, 0.11172035f, 0.08955412f, -0.02256327f, 
    0.16276950f, -0.01531506f, 0.06646647f, 0.33026212f, -0.61185998f, 0.04910933f, 0.08318193f, -0.18926087f, 
    -0.09842172f, 0.13456298f, 0.07985997f, 0.13663624f, 0.25411582f, 0.03352039f, -0.35205224f, -0.25463879f, 
    -0.45806742f, 0.34687677f, 0.00427348f, 0.18048671f, 0.13504487f, 0.04162955f, -0.08425452f, 0.27459040f, 
    0.37858936f, 0.01935949f, -0.16069616f, 0.30716020f, 0.00704147f, -0.05018172f, 0.08627120f, -0.07334094f, 
    -0.14720729f, 0.05137876f, 0.04069527f, -0.27401829f, -0.06217746f, 0.10628190f, 0.08516699f, -0.21414958f, 
    -0.10184976f, -0.00927575f, 0.16107030f, -0.29121304f, -0.18138522f, -0.01032909f, 0.07315007f, 0.36687127f, 
    0.01636449f, 0.32130685f, 0.16554488f, -0.00621265f, -0.14819726f, -0.30152053f, 0.01728819f, -0.39271298f, 
    0.09596170f, 0.16150405f, -0.42068118f, 0.06747749f, -0.51584381f, -0.05671440f, -0.01580467f, 0.34867167f, 
    -0.27008191f, 0.23352098f, 0.02427820f, -0.66351783f, -0.09676950f, -0.06979083f, -0.11066133f, -0.06938031f, 
    0.14368361f, 0.28702220f, 0.17831588f, 0.28780034f, -0.37144116f, -0.04561549f, 0.05716569f, 0.02827825f, 
    0.24707152f, 0.19365491f, 0.14799143f, 0.29107824f, -0.08503901f, 0.21156745f, -0.23144518f, -0.02784661f, 
    0.06127971f, -0.00713645f, -0.02834296f, -0.00016991f, 0.03003374f, -0.10451309f, 0.08678014f, -0.07227538f, 
    -0.10880565f, 0.07146937f, 0.01706110f, 0.02699305f, -0.08341940f, -0.07127271f, 0.01487705f, -0.07882872f, 
    0.00102650f, -0.04047269f, 0.04577462f, 0.00889210f, 0.04442115f, -0.00087750f, 0.01360396f, 0.02877968f, 
    -0.05762353f, -0.02885315f, -0.03924275f, 0.02187818f, 0.04630651f, -0.07945055f, -0.03435324f, 0.03567991f, 
    0.02250304f, -0.04952898f, 0.04659642f, -0.00769595f, -0.00657372f, -0.03762329f, -0.04668348f, 0.02682131f, 
    0.05824411f, -0.03159763f, 0.07608031f, -0.05393192f, 0.06608576f, -0.09232561f, 0.01926815f, -0.08404746f, 
    0.03316778f, 0.03186146f, 0.06430797f, 0.00359376f, -0.05562266f, 0.00363398f, -0.08175071f, -0.08191790f, 
    -0.02797308f, -0.07747931f, -0.06393485f, -0.06856240f, -0.03899907f, -0.07454726f, -0.08384723f, -0.01214080f, 
    -0.02866938f, 0.03723573f, 0.05130630f, -0.08161160f, 0.07061930f, -0.06948543f, -0.00209693f, 0.07615204f, 
    0.04755305f, -0.03689568f, 0.04446086f, -0.05443219f, 0.01952460f, 0.05043779f, -0.07724697f, -0.02546082f, 
    0.06900222f, -0.01255356f, 0.04693388f, -0.03222641f, -0.02463322f, -0.10010807f, 0.04335175f, -0.02350218f, 
    -0.02096270f, -0.00520972f, 0.02939421f, -0.06012875f, 0.05197436f, -0.00578471f, -0.08304298f, -0.09072161f, 
    -0.02674251f, 0.06074209f, 0.04381201f, 0.03843613f, -0.08947428f, -0.08907387f, -0.02116936f, 0.05704312f, 
    0.05545283f, 0.06220571f, 0.00201591f, -0.02128571f, 0.00541735f, -0.05550663f, -0.06429563f, -0.06505567f, 
    -0.09700377f, -0.01193819f, -0.08682717f, -0.01414860f, -0.02321115f, 0.03258033f, -0.02212456f, 0.03886297f, 
    0.01826109f, 0.06451533f, -0.08468091f, 0.01959854f, 0.07529446f, -0.03546239f, -0.02594640f, 0.02024449f, 
    -0.06345136f, 0.07514997f, 0.10137695f, 0.06640175f, -0.01563881f, 0.15823196f, -0.05964293f, -0.48937824f, 
    -0.12082558f, 0.01431244f, 0.14723937f, 0.10456315f, 0.12916279f, -0.18913972f, -0.03362153f, -0.03130834f, 
    -0.03691042f, -0.06621479f, 0.15900905f, 0.04471251f, 0.48584059f, 0.07007167f, 0.09136819f, -0.07171369f, 
    0.05871211f, 0.20646417f, 0.05967027f, -0.03015617f, 0.01802951f, -0.33469313f, -0.02315525f, 0.18185599f, 
    -0.01154061f, -0.21100035f, 0.20551978f, -0.06204036f, 0.20592816f, -0.07799102f, 0.04847512f, -0.19324079f, 
    0.05434536f, 0.13494238f, 0.17151876f, 0.26605725f, -0.80674046f, 0.03033632f, 0.05062638f, 0.19249891f, 
    0.15149483f, 0.01796451f, -0.04025279f, -0.01711884f, 0.20412348f, 0.02401633f, 0.15411910f, 0.15003930f, 
    -0.22700451f, 0.43408957f, 0.11036611f, -0.08514208f, 0.02225241f, 0.00480790f, -0.05442269f, -0.01418593f, 
    -0.07911461f, 0.09780868f, -0.08083394f, 0.30996445f, -0.01825756f, 0.03731443f, 0.16215093f, 0.01590221f, 
    0.02021321f, -0.11883726f, -0.09574527f, 0.17170757f, 0.19440469f, 0.11320611f, 0.08262697f, 0.00212088f, 
    0.09473897f, 0.04907553f, -0.09080926f, -0.16701756f, -0.10768083f, -0.12154584f, 0.21123114f, -0.01589913f, 
    -0.04389982f, -0.08621892f, -0.32322177f, 0.06604440f, 0.40302563f, 0.30716088f, 0.05652636f, 0.14636838f, 
    0.00892513f, 0.13269725f, -0.20711447f, -0.05805313f, -0.22599262f, -0.02290091f, 0.26217774f, 0.05865689f, 
    0.09532128f, 0.03691294f, -0.13623345f, -0.15841132f, 0.19302164f, 0.00968096f, 0.17281628f, 0.08741667f, 
    0.06153855f, -0.53049248f, 0.25150537f, 0.03510856f, 0.14883664f, 0.07636774f, -0.48341563f, -0.05666007f, 
    0.30386209f, -0.22699496f, -0.00654767f, -0.27908891f, 0.06241264f, 0.05015582f, 0.10524239f, 0.00639174f, 
    0.06460657f, -0.14682300f, 0.11216210f, -0.21641327f, -0.02330134f, -0.42662850f, -0.02480532f, -0.59021044f, 
    -0.06521168f, 0.01458310f, 0.08385926f, -0.00936856f, 0.27999657f, 0.24244218f, 0.01316246f, -0.07478489f, 
    -0.04314746f, -0.19711618f, 0.06857432f, -0.29025930f, 0.23131371f, -0.00279974f, -0.14496095f, -0.04066553f, 
    0.21644971f, -0.02225734f, -0.04500034f, 0.24037474f, -0.14612374f, 0.15498173f, -0.00736923f, -0.00860291f, 
    -0.05406232f, 0.23146848f, -0.05802504f, 0.05176297f, 0.01320381f, 0.08704095f, -0.03598457f, 0.02468072f, 
    -0.00761604f, 0.07198276f, 0.10499982f, 0.19746573f, 0.10710029f, 0.11236773f, 0.16217859f, -0.07002117f, 
    0.06712636f, -0.18358226f, -0.03662990f, 0.21488476f, 0.00735430f, -0.00235521f, -0.56361318f, -0.13976550f, 
    0.27909228f, 0.09195090f, 0.16841567f, -0.17647274f, -0.12509581f, 0.02337121f, 0.04451307f, -0.29592630f, 
    0.21105358f, 0.12640528f, 0.08038275f, 0.12161893f, 0.06220958f, 0.15716638f, 0.10332395f, 0.20186614f, 
    0.17198361f, 0.09341171f, -0.02381000f, 0.22612882f, -0.46257228f, -0.00944754f, 0.08777958f, -0.06652146f, 
    0.40429443f, 0.08699502f, -0.06308638f, -0.03406890f, -0.15431088f, 0.05600109f, 0.03221608f, 0.24325863f, 
    0.00730131f, 0.17223750f, -0.32973558f, 0.02573481f, -0.20044889f, -0.16348863f, 0.15471536f, -0.17800111f, 
    0.09408292f, -0.16833214f, -0.31849515f, 0.01650009f, -0.23097269f, -0.19918439f, 0.12030563f, -0.14451577f, 
    -0.29979825f, -0.05855686f, 0.01936721f, 0.13738255f, -0.16401063f, 0.13449571f, 0.04218907f, -0.15812883f, 
    0.06654193f, -0.31058711f, 0.23209164f, 0.16748092f, 0.03748246f, -0.11124980f, -0.12281971f, -0.08832305f, 
    -0.06162036f, -0.07226512f, 0.13474543f, 0.04416922f, 0.13739659f, 0.02269615f, -0.03710265f, -0.23165864f, 
    0.54039109f, -0.19501600f, 0.49967650f, -0.34302562f, 0.18923818f, -0.19700377f, -0.06757569f, 0.26511884f, 
    0.15231451f, 0.10290594f, -0.13273005f, 0.02558224f, -0.00772960f, 0.51639074f, 0.17715493f, 0.01222264f, 
    -0.02375405f, -0.28312457f, -0.33191100f, 0.05041977f, 0.18257235f, -0.31056780f, -0.18083200f, 0.06283412f, 
    0.29747605f, -0.21015719f, -0.03452615f, -0.09774851f, 0.01727339f, 0.29124019f, -0.03407235f, -0.43992335f, 
    -0.07711302f, 0.36642241f, -0.21601436f, 0.03997771f, -0.31198135f, -0.07733062f, -0.07062607f, 0.01570536f, 
    -0.27975675f, -0.06318833f, 0.33754176f, 0.02405284f, 0.92918086f, 0.20826131f, 0.16817901f, -0.11734362f, 
    -0.13787258f, -0.26994759f, 0.03015434f, 0.07883468f, -0.03767754f, -0.01202945f, -0.25720504f, 0.10743153f, 
    0.77696645f, -0.39329576f, 0.26301053f, 0.14309768f, -0.16653121f, 0.32382554f, -0.16461413f, -0.22213385f, 
    0.07538863f, 0.19567914f, 0.31139874f, 0.07843607f, -0.00833510f, 0.45705897f, -0.33135819f, 0.21029481f, 
    -0.04656652f, -0.10470728f, -0.38991004f, 0.30817416f, -0.28618774f, -0.45980674f, -0.20097977f, 0.00602886f, 
    0.69814312f, 0.34025875f, -0.17633113f, 0.10331341f, 0.47584394f, -0.16004725f, -0.16362038f, 0.29815480f, 
    -0.04983506f, 0.27911362f, -0.19349231f, 0.04118432f, -0.49191204f, -0.27166027f, -0.27776629f, 0.18853585f, 
    0.20731479f, -0.11305682f, -0.22196262f, -0.07192749f, -0.03122045f, -0.08600183f, 0.10447822f, -0.01580092f, 
    -0.01880015f, -0.15846477f, 0.17103337f, 0.76590735f, -0.04012067f, 0.47233319f, -0.06071819f, 0.06565958f, 
    0.14560814f, 0.25765744f, -0.10442351f, -0.11699197f, 0.11499715f, -0.05172217f, 0.23837250f, 0.11864733f, 
    -0.31493187f, 0.33311701f, 0.15847006f, 0.41910201f, 0.10387268f, -0.11109826f, 0.02544502f, 0.05683361f, 
    0.18964410f, 0.05270682f, 0.03197688f, 0.34141836f, 0.12050194f, 0.09177280f, 0.02403481f, -0.77581221f, 
    0.01093864f, 0.02333323f, 0.08654737f, -0.17051925f, 0.22445616f, 0.06370971f, -0.07521200f, -0.00455502f, 
    -0.04604124f, 0.09642036f, 0.17590155f, 0.02632268f, -0.00128046f, 0.00215481f, -0.13481329f, 0.02412511f, 
    0.07506480f, -0.12507382f, 0.02246449f, 0.13594696f, 0.19487078f, -0.30757096f, 0.00142199f, -0.07077831f, 
    -0.01974175f, -0.15716270f, 0.16062924f, -0.00489930f, 0.24110883f, 0.01263897f, 0.01586616f, 0.18569233f, 
    -0.01906122f, 0.15955740f, 0.09979745f, -0.10795331f, -0.31898478f, 0.05716823f, 0.07617374f, 0.16311188f, 
    0.23133974f, 0.02602303f, -0.01844166f, 0.03285438f, 0.12717351f, -0.02524919f, 0.25976366f, 0.12518375f, 
    -0.00051582f, -0.05846167f, 0.13820803f, -0.16219927f, -0.11685279f, 0.01142661f, 0.22824539f, -0.35454589f, 
    -0.30709681f, 0.11692975f, 0.20548330f, 0.02921847f, -0.05907810f, 0.08358672f, 0.05608077f, 0.21754572f, 
    0.30534801f, -0.00291036f, 0.06077758f, 0.21458991f, 0.01623287f, -0.06877600f, -0.01821524f, 0.11399138f, 
    -0.08540425f, 0.14566936f, -0.11488172f, 0.34175003f, -0.03932101f, 0.22074746f, 0.18189147f, 0.02365231f, 
    0.05692518f, -0.35804635f, -0.49169996f, 0.02027019f, -0.03203679f, 0.26155522f, 0.25385487f, 0.21053067f, 
    -0.02937998f, -0.05997569f, -0.09245622f, -0.03926155f, 0.08194347f, -0.13448584f, 0.23734875f, -0.18065880f, 
    0.19755495f, -0.03735131f, -0.17564952f, 0.12398342f, 0.11856079f, 0.23768057f, 0.20128436f, -0.02863845f, 
    0.01144066f, -0.46843857f, 0.02476737f, 0.04545972f, 0.34796110f, 0.04237348f, -0.65901822f, 0.14924242f, 
    -0.08905721f, -0.12944826f, -0.10961345f, -0.24226534f, 0.12870455f, 0.01690174f, 0.23082142f, -0.00630948f, 
    0.06778017f, -0.07539269f, 0.52540779f, -0.18191059f, -0.02206807f, 0.06733157f, 0.02485681f, 0.04865594f, 
    0.14955057f, -0.08110611f, -0.02238054f, 0.13660924f, -0.12673964f, 0.17203383f, 0.01609300f, 0.05172192f, 
    0.01756095f, -0.02859771f, -0.20725620f, 0.07302633f, -0.13578868f, 0.15640330f, 0.07851297f, 0.01534196f, 
    0.16110453f, 0.12713331f, -0.05294520f, 0.01170042f, -0.04419839f, 0.11820631f, 0.03799453f, 0.02567059f, 
    -0.05325598f, -0.15865076f, 0.11565125f, -0.01381493f, -0.04287702f, 0.07101830f, 0.08711696f, 0.01529200f, 
    0.13221991f, -0.08174591f, 0.08227626f, 0.23457415f, 0.07336011f, -0.12953466f, -0.11366715f, 0.06468040f, 
    -0.22487004f, 0.15149888f, -0.00841011f, 0.14252831f, 0.07775062f, 0.21855669f, -0.11364646f, -0.04450557f, 
    -0.62787783f, 0.13795313f, 0.03971371f, 0.03787947f, 0.18590321f, -0.01125426f, 0.18328354f, 0.43682879f, 
    0.09555866f, -0.08215664f, -0.16275457f, -0.03900517f, -0.05975047f, 0.12558137f, 0.01282785f, -0.21557540f, 
    -0.16419519f, 0.12937900f, -0.00904202f, -0.12644552f, 0.04924306f, 0.13690227f, 0.14358254f, -0.07917824f, 
    -0.19759670f, -0.08707683f, 0.10115997f, -0.05910682f, 0.08237939f, -0.19418006f, -0.04213234f, 0.28044671f, 
    -0.06006965f, 0.22590573f, 0.49572536f, 0.05053788f, 0.05913831f, -0.16749494f, -0.05678892f, -0.30868727f, 
    0.15336290f, 0.32773268f, -0.01258096f, 0.00589420f, -0.10715510f, -0.02597693f, -0.12273230f, 0.34120283f, 
    -0.03466608f, 0.25015983f, 0.14527677f, -0.62555802f, -0.07509826f, -0.05309429f, -0.14561994f, 0.18082671f, 
    -0.00227123f, 0.27759489f, 0.04983069f, 0.13922197f, -0.60552889f, -0.05518179f, 0.19054374f, 0.04634278f, 
    0.06458345f, -0.07847417f, 0.15090957f, 0.37195003f, -0.06199471f, 0.11035109f, -0.32098895f, 0.17479709f, 
    0.15880129f, 0.06191174f, -0.37577865f, 0.29249358f, 0.01000414f, -0.03808114f, -0.03173840f, -0.40291011f, 
    0.04968420f, 0.02285378f, -0.01367304f, 0.04951358f, 0.12978934f, 0.11851907f, 0.17506891f, 0.02952486f, 
    0.06584086f, 0.11531594f, 0.25718772f, 0.12189052f, -0.06821355f, 0.09773646f, 0.02149255f, 0.00838132f, 
    -0.00846958f, 0.05428617f, 0.07312779f, 0.10063708f, 0.08637672f, -0.19756876f, -0.01213778f, 0.06609190f, 
    -0.07136215f, 0.07110832f, -0.09562714f, 0.02519700f, 0.09059328f, -0.03152021f, -0.07039434f, 0.17447184f, 
    -0.05420901f, 0.01492787f, 0.08693172f, -0.10830405f, -0.68515247f, 0.03516908f, 0.02061904f, 0.04421177f, 
    0.19797076f, 0.07388770f, 0.03950788f, -0.08991558f, 0.06884133f, -0.11423460f, -0.16625342f, 0.12369848f, 
    0.39242065f, -0.05203332f, 0.05212546f, 0.08891276f, 0.01751899f, 0.03966404f, -0.09920684f, -0.22527082f, 
    -0.03288578f, -0.11863432f, 0.14751871f, -0.06130489f, 0.02412602f, 0.02425440f, 0.07497621f, 0.16365364f, 
    0.19036198f, 0.09340137f, 0.07037123f, 0.10393776f, -0.02176910f, -0.05836136f, -0.11148225f, -0.00982102f, 
    0.35517508f, 0.20600203f, -0.06573171f, 0.15105215f, 0.45722020f, 0.10658415f, 0.02300500f, -0.02309617f, 
    -0.05194595f, -0.18496946f, -0.34728631f, -0.01380165f, -0.07409229f, 0.20623262f, 0.06793091f, 0.27316126f, 
    -0.06677549f, -0.03114844f, -0.02582856f, -0.00533187f, 0.11237859f, 0.06789028f, 0.02940193f, -0.11949518f, 
    0.23940332f, -0.10330705f, 0.04421957f, 0.47676539f, 0.04261150f, 0.10012899f, 0.08999977f, -0.06323227f, 
    -0.04240974f, -0.32595307f, -0.06979207f, 0.01600469f, 0.30853230f, 0.10603206f, -0.31093770f, 0.11063630f, 
    -0.05186633f, 0.14077465f, -0.17523269f, -0.30812198f, 0.08630395f, -0.24894977f, 0.22869848f, 0.02629225f, 
    -0.15547350f, -0.00106869f, -0.08349051f, 0.00868364f, -0.04163806f, 0.08443180f, -0.07364792f, 0.06757501f, 
    -0.07458685f, -0.02046593f, 0.13035187f, 0.04432238f, 0.15250060f, -0.22348620f, 0.06397046f, -0.01580144f, 
    0.01835781f, -0.04775873f, -0.10700170f, 0.06054674f, 0.08173680f, 0.18368515f, -0.00662144f, -0.04404606f, 
    -0.04244252f, 0.12537001f, 0.07922420f, 0.06059217f, -0.16224417f, -0.07587276f, 0.07331981f, 0.31501576f, 
    -0.02071071f, -0.07241393f, -0.13489786f, 0.07134860f, -0.16751076f, -0.07156004f, 0.06391623f, 0.11029222f, 
    0.09125985f, -0.10907033f, 0.01854779f, 0.01548953f, -0.67083573f, 0.09276969f, 0.38381726f, -0.04000726f, 
    0.08130949f, -0.00297920f, 0.03350299f, 0.04619366f, 0.10246916f, 0.05262583f, -0.09880929f, 0.00589574f, 
    0.17006436f, 0.12778170f, -0.23424204f, 0.18460113f, 0.29712096f, 0.28391343f, -0.18739653f, 0.22651207f, 
    0.07896923f, -0.07081642f, -0.05559737f, 0.02395154f, 0.06768853f, 0.02193276f, 0.06316774f, -0.17856753f, 
    0.04012546f, 0.00571718f, 0.13828380f, -0.18104038f, 0.02970052f, -0.02140160f, 0.03660359f, -0.07019183f, 
    -0.41896081f, 0.17762321f, 0.03021697f, -0.09947690f, -0.34217960f, 0.07394926f, -0.05377765f, 0.06910747f, 
    -0.06696169f, 0.05200108f, -0.30453557f, -0.00869465f, -0.15351240f, -0.10122712f, -0.05505634f, -0.11263239f, 
    0.16471206f, 0.04832575f, -0.26135641f, 0.08892769f, -0.10203883f, 0.11224610f, 0.04597431f, 0.03295092f, 
    0.00458854f, 0.00297726f, -0.09300887f, -0.52895653f, 0.11161574f, -0.04243584f, -0.01631400f, 0.12621184f, 
    0.05916035f, -0.09848672f, 0.04038743f, 0.33330464f, -0.03629507f, -0.07880022f, 0.13172224f, 0.13997991f, 
    0.07571518f, 0.15141632f, -0.03623556f, 0.11916334f, 0.02455912f, 0.10637079f, 0.04289347f, -0.02052218f, 
    -0.07713966f, -0.05683443f, 0.05453021f, 0.04542681f, -0.09993315f, -0.08149339f, 0.03306206f, 0.06125727f, 
    -0.11467300f, -0.06770150f, 0.02113634f, -0.06685156f, 0.04240766f, -0.03997317f, -0.03676025f, 0.06284800f, 
    -0.00033630f, 0.01598630f, -0.00956559f, 0.06607775f, -0.02686493f, 0.06520539f, -0.04164720f, -0.02100473f, 
    -0.05136285f, -0.11408578f, 0.04938724f, -0.06750619f, 0.07919690f, 0.05763439f, 0.06373106f, -0.05162824f, 
    -0.05763169f, 0.00610851f, 0.00427182f, 0.08596766f, 0.03215336f, -0.04119438f, -0.00999774f, -0.01893312f, 
    -0.00511210f, -0.09326386f, -0.01372930f, -0.08515172f, 0.02670866f, -0.09648254f, -0.10190482f, -0.00082588f, 
    0.01637891f, -0.02258945f, -0.06516626f, 0.03402195f, 0.04760943f, -0.06963684f, 0.07043003f, 0.02533959f, 
    -0.01573262f, 0.04247950f, -0.02802280f, 0.00988706f, 0.02335846f, -0.05528156f, -0.01252320f, 0.05448831f, 
    0.06332747f, -0.03119644f, 0.01329310f, -0.03909787f, 0.06954251f, -0.03224598f, 0.00976084f, 0.01822192f, 
    0.01840342f, -0.03710907f, -0.02706882f, -0.07435799f, -0.00916329f, -0.07667929f, -0.00640126f, -0.11218373f, 
    0.06170721f, -0.00602986f, 0.02482785f, 0.01400984f, 0.02805616f, -0.08048288f, -0.06733185f, 0.01844968f, 
    0.00655862f, 0.06623782f, -0.06838573f, 0.00853100f, -0.06732070f, -0.06064673f, 0.06469815f, 0.06366417f, 
    0.02813004f, -0.03161713f, -0.01821719f, -0.00545495f, -0.06394211f, -0.03231532f, -0.07316424f, -0.10357228f, 
    0.03421163f, -0.05368912f, 0.01873193f, 0.02129493f, -0.04922306f, -0.10551011f, -0.07398187f, -0.08221215f, 
    0.00353421f, -0.05959701f, 0.02239262f, -0.07395255f, 0.05863919f, 0.04288950f, -0.00744276f, 0.03269718f, 
    0.02229914f, -0.05961397f, -0.04651639f, -0.07277149f, 0.01950442f, -0.02954337f, -0.00611534f, 0.06708574f, 
    0.03002830f, -0.04093607f, -0.08784840f, -0.04133885f, -0.07718593f, 0.03907724f, 0.02198120f, -0.02007437f, 
    -0.10461082f, -0.03768513f, -0.08987200f, 0.02359490f, 0.02901119f, 0.03378402f, 0.01100470f, 0.01224349f, 
    0.06991122f, -0.10165086f, 0.00841019f, -0.12444113f, -0.06240104f, 0.07710259f, -0.02448964f, -0.00459136f, 
    0.02570245f, -0.10773480f, -0.07433639f, -0.11803623f, 0.06556647f, 0.00931360f, -0.05015802f, 0.07897986f, 
    -0.00474910f, 0.01104837f, -0.10863923f, 0.03938351f, 0.04262317f, -0.02018518f, 0.06113412f, -0.07539733f, 
    -0.05069268f, -0.04098946f, 0.01527358f, -0.07205413f, -0.03833729f, 0.03918437f, -0.00298207f, -0.00501350f, 
    -0.02809770f, -0.06727406f, 0.05521993f, -0.04943808f, -0.07514293f, -0.02506107f, -0.01035568f, 0.01549548f, 
    0.01540561f, -0.02469852f, 0.02643549f, 0.02790242f, -0.05240288f, -0.11150242f, 0.04297433f, -0.01463423f, 
    -0.11731441f, 0.00153112f, -0.03623297f, -0.03399068f, 0.07678410f, 0.02829524f, 0.03352190f, 0.00684167f, 
    -0.00543899f, -0.04440226f, -0.06855758f, -0.04774145f, -0.03199381f, -0.09064452f, -0.10380513f, 0.04582630f, 
    -0.04986984f, 0.00600059f, 0.00939732f, 0.01631914f, -0.08727147f, -0.05532457f, 0.01375769f, -0.06186392f, 
    0.07359084f, 0.04557641f, 0.06324495f, 0.03151249f, -0.01846949f, -0.06057886f, 0.03757232f, -0.07343294f, 
    -0.01161467f, -0.02863360f, 0.04352793f, -0.01169859f, -0.02790298f, -0.08205315f, -0.01138787f, -0.07533548f, 
    0.05117051f, 0.03426830f, -0.11739135f, -0.05471663f, -0.05950102f, -0.03701915f, 0.02539284f, -0.06024354f, 
    0.02216087f, 0.10750433f, 0.05656437f, 0.02604335f, -0.06474527f, 0.08409750f, 0.02446745f, -0.06319324f, 
    -0.05848075f, 0.06094553f, -0.06411371f, -0.03459350f, -0.09185383f, 0.07482693f, 0.05402815f, -0.04225524f, 
    0.53340316f, 0.09690471f, 0.02828663f, -0.12162331f, 0.27151597f, -0.02627010f, 0.03720934f, 0.56291860f, 
    0.12525010f, 0.24063444f, -0.00169622f, 0.06675677f, 0.14101769f, 0.57244575f, 0.39357740f, -0.04305741f, 
    -0.01912893f, 0.05431302f, 0.05841420f, 0.09538587f, -0.34452468f, -0.06160181f, -0.20404993f, -0.06409380f, 
    0.14119469f, -0.10389530f, -0.02555230f, 0.10711149f, 0.18378162f, -0.43411580f, 0.05961705f, -0.13169265f, 
    -0.00104232f, 0.05521432f, -0.10104092f, -0.01787991f, -0.14180629f, -0.07272439f, 0.06879152f, 0.47964394f, 
    -0.30581120f, 0.01662363f, 0.08936635f, -0.51537758f, -0.23643121f, 0.07770124f, 0.03068489f, 0.19555989f, 
    0.24222729f, -0.06372500f, 0.00325899f, 0.06946662f, -0.34842399f, -0.24565454f, -0.18048279f, 0.04314740f, 
    0.20845646f, -0.20398267f, 0.08360598f, 0.21378161f, 0.21256895f, 0.04976806f, 0.04924336f, -0.09050155f, 
    0.04810617f, -0.05588188f, 0.27733466f, -0.27830461f, 0.04149023f, 0.24613449f, 0.00384470f, 0.37158045f, 
    -0.11922360f, -0.15253787f, 0.08960383f, 0.01303625f, 0.06889521f, -0.23507738f, -0.32442924f, -0.07724685f, 
    -0.06561801f, 0.20730227f, -0.19399688f, -0.13511197f, -0.14263748f, 0.09822514f, -0.20075947f, 0.17175186f, 
    -0.04739528f, -0.06256730f, -0.31552884f, 0.00557225f, -0.06331938f, 0.17217365f, 0.03054077f, 0.17840356f, 
    0.25005141f, -0.39945170f, 0.35059008f, -0.04970945f, 0.14976402f, 0.12735243f, -0.20302388f, 0.19521876f, 
    0.07306836f, -0.42505434f, 0.09063597f, 0.71250105f, 0.02457331f, 0.36968878f, 0.13223876f, -0.31752732f, 
    0.14988743f, 0.40454739f, -0.12329854f, -0.10552911f, 0.38856339f, 0.17469236f, 0.38133749f, -0.04185338f, 
    -0.08812555f, -0.17648511f, 0.13301927f, 0.40388316f, 0.22578683f, 0.02286390f, 0.13858210f, -0.04541695f, 
    0.02923941f, 0.04252738f, 0.03725408f, 0.18235113f, -0.23528974f, -0.00219540f, 0.03628790f, -0.46392950f, 
    -0.18606327f, 0.03178144f, 0.00920695f, 0.11287513f, 0.01791675f, -0.13164510f, 0.09460758f, 0.02275019f, 
    0.00052718f, -0.03357766f, 0.27016708f, 0.00244813f, -0.06157824f, 0.17702343f, -0.03272948f, 0.03001742f, 
    -0.06048572f, 0.28530833f, 0.04787180f, 0.12552576f, 0.06924203f, -0.12828138f, 0.06332344f, 0.29188669f, 
    -0.07042559f, -0.30344388f, 0.15260865f, -0.07063378f, 0.18210304f, 0.09774660f, 0.01125059f, 0.15781945f, 
    0.09536690f, 0.05716033f, -0.04250986f, 0.17746969f, -0.72548306f, -0.01183974f, 0.05383318f, 0.10636898f, 
    0.08928079f, 0.09149429f, -0.05255540f, 0.05588491f, -0.00765144f, -0.15029763f, -0.10622761f, 0.08311236f, 
    -0.34983897f, 0.30555451f, -0.01283152f, -0.07684694f, -0.02974941f, -0.17149544f, 0.12562566f, -0.02290957f, 
    -0.15206671f, -0.10969254f, -0.10369612f, -0.02564011f, -0.09947687f, 0.06150296f, 0.10597018f, 0.22574432f, 
    -0.10252456f, -0.04659213f, 0.23505090f, -0.16742116f, 0.16523634f, 0.13940847f, -0.00563107f, -0.06316520f, 
    -0.13592587f, 0.09951381f, -0.00388640f, 0.01709972f, -0.12662196f, 0.05654992f, 0.17873606f, 0.10693838f, 
    -0.04095048f, -0.17692381f, 0.08754202f, -0.03982598f, 0.37675548f, 0.13554499f, 0.09682668f, -0.12657970f, 
    -0.03768609f, 0.02309044f, -0.06545506f, -0.00083499f, -0.26081619f, -0.03886677f, -0.00391646f, 0.27273709f, 
    0.12231820f, 0.08333125f, -0.04979395f, -0.39678115f, 0.14756858f, 0.00001709f, 0.06616393f, -0.13867514f, 
    -0.04435321f, -0.57621735f, 0.07325651f, 0.16557017f, 0.19873685f, -0.13256149f, -0.77632397f, 0.13842149f, 
    0.28655213f, -0.20528057f, 0.04696086f, -0.34962669f, 0.04962039f, 0.12131914f, 0.08504923f, 0.08699074f, 
    -0.13546570f, 0.07220408f, -0.26786718f, -0.00558381f, 0.02146460f, -0.09434474f, -0.03899307f, -0.90569067f, 
    -0.02961035f, -0.13964219f, 0.06714146f, -0.23854791f, 0.18269512f, -0.10961451f, -0.26226625f, 0.07320130f, 
    0.07871372f, 0.11309816f, 0.12840800f, -0.15590638f, 0.22610849f, 0.08629467f, 0.12306418f, 0.01013858f, 
    -0.03723953f, -0.01213580f, -0.03532872f, 0.09774346f, -0.03984558f, -0.00253289f, 0.02798473f, 0.12616438f, 
    -0.08020653f, 0.15685865f, 0.01616546f, -0.00341670f, 0.36341083f, 0.07822270f, 0.01095722f, -0.05555422f, 
    0.12250714f, 0.11210826f, -0.14089179f, 0.08521286f, 0.32507426f, 0.19672741f, 0.13538450f, 0.05908080f, 
    0.18247303f, 0.04367437f, 0.02632384f, -0.12270774f, 0.11899037f, 0.07246767f, -0.29849306f, 0.11053371f, 
    -0.01821107f, 0.30822131f, 0.15053415f, -0.35077769f, -0.22358774f, -0.24193493f, 0.09673960f, -0.27231380f, 
    0.00525849f, 0.12993418f, 0.01973899f, 0.28412649f, -0.05811379f, -0.15881400f, 0.14752068f, 0.03713652f, 
    0.25166899f, 0.23193382f, 0.07056402f, 0.29861781f, -0.22161396f, 0.21217887f, 0.24410453f, 0.10885826f, 
    -0.09194020f, 0.13479972f, 0.20084228f, 0.13717678f, -0.21659803f, 0.17155200f, 0.13151556f, -0.17535958f, 
    0.01146449f, 0.02581977f, -0.09000137f, -0.02348939f, -0.08776730f, -0.02168548f, 0.30523831f, -0.11309896f, 
    -0.13552690f, 0.05195745f, -0.25266305f, 0.00036578f, 0.03927052f, -0.11483695f, 0.35486999f, -0.29518524f, 
    -0.00940213f, 0.11065587f, -0.16459328f, -0.28162399f, -0.10013764f, -0.13384219f, 0.04083582f, -0.00606885f, 
    0.03286727f, -0.47932854f, 0.18834898f, 0.20717935f, 0.20508032f, 0.11451800f, -0.56106269f, -0.03023465f, 
    -0.22916810f, 0.05178150f, -0.09745591f, -0.44673258f, 0.00720152f, 0.07666264f, 0.13934806f, -0.20858359f, 
    0.07841637f, -0.10021979f, 0.22390518f, -0.17515343f, 0.00683347f, 0.14134488f, 0.05531148f, -0.04000935f, 
    -0.08159414f, 0.03640440f, 0.04430400f, 0.23271807f, -0.19472091f, -0.16606270f, -0.00849127f, 0.05165963f, 
    0.06781597f, 0.15201572f, 0.16083620f, 0.09978151f, 0.50503057f, -0.18459223f, 0.11219016f, 0.07236938f, 
    -0.13866900f, 0.12046412f, 0.07428116f, -0.24992979f, 0.00876797f, -0.35180324f, 0.03014509f, 0.13457245f, 
    -0.06446723f, -0.32372338f, 0.35101366f, -0.02590469f, 0.16509663f, -0.14429988f, 0.04698803f, -0.23843414f, 
    0.03610843f, 0.25808471f, -0.00047224f, 0.15944697f, -0.77018219f, 0.06758572f, -0.13903642f, 0.18143164f, 
    0.02409532f, 0.09045739f, 0.07370925f, -0.06447898f, -0.02889652f, 0.12186856f, 0.24207371f, 0.04087114f, 
    -0.34089425f, 0.14044607f, 0.20892349f, -0.19832766f, -0.09522308f, 0.04465624f, -0.06127241f, 0.01219273f, 
    -0.10856032f, 0.16078827f, -0.09341802f, 0.21265645f, 0.04551743f, -0.01420569f, 0.12362252f, 0.17444475f, 
    -0.40446484f, -0.15916428f, -0.15050368f, 0.10963478f, 0.14239921f, -0.05185632f, 0.05337277f, -0.07922467f, 
    -0.00947438f, 0.04349187f, -0.11664262f, -0.08995148f, -0.19537085f, -0.23670392f, 0.22063565f, -0.25226793f, 
    -0.07306488f, 0.11252011f, -0.09767281f, -0.04845408f, 0.51667678f, 0.39262709f, -0.10007270f, 0.30860814f, 
    0.05123603f, 0.09812217f, -0.16379020f, 0.08001924f, -0.16488913f, 0.09154712f, 0.25424534f, 0.15776443f, 
    0.15056612f, 0.12567887f, -0.08367664f, 0.25845924f, -0.01221103f, 0.22061732f, 0.03381971f, -0.03219539f, 
    0.15291287f, -0.18996246f, 0.07850580f, -0.16220278f, 0.17814687f, 0.06143823f, -0.13640659f, -0.03060553f, 
    0.08797084f, -0.20415029f, 0.01214892f, -0.16014507f, 0.05768736f, 0.11922233f, 0.09507350f, 0.08395473f, 
    -0.06144250f, -0.07441954f, 0.06203702f, -0.07407777f, -0.07043677f, -0.04038199f, 0.08070404f, 0.04267659f, 
    -0.06488428f, 0.00602406f, -0.08024000f, 0.05679662f, -0.03130149f, -0.05172949f, -0.04674494f, -0.05586286f, 
    0.03664496f, 0.04842746f, -0.08943937f, 0.03599430f, 0.05010553f, -0.06824418f, 0.06361295f, -0.02306130f, 
    0.04557527f, -0.02948171f, 0.01222825f, -0.10831266f, -0.01007919f, 0.06123079f, 0.06255983f, 0.05537705f, 
    -0.06240077f, -0.02992242f, -0.08811001f, -0.05381786f, -0.08884987f, -0.02361428f, 0.06983338f, -0.07573838f, 
    0.03735621f, -0.05686985f, 0.04676432f, -0.05443019f, 0.08190301f, -0.05253581f, -0.06246589f, -0.03814924f, 
    0.05585251f, -0.06803265f, 0.05805082f, 0.03553156f, 0.00070994f, 0.06428018f, 0.07509261f, -0.05502506f, 
    -0.04646327f, 0.06179305f, 0.00556353f, -0.08465783f, -0.02746063f, -0.05280673f, -0.02362930f, -0.02784371f, 
    0.01046164f, -0.05116406f, 0.03161560f, -0.11184005f, 0.06559131f, -0.01891569f, 0.01291974f, -0.04935520f, 
    -0.06815009f, 0.04747770f, 0.01759377f, 0.05799114f, -0.02436046f, 0.01838463f, -0.09975528f, 0.06457616f, 
    -0.09007027f, 0.00877705f, -0.01975713f, -0.07713170f, -0.05830442f, -0.07811641f, 0.04224852f, -0.06972937f, 
    0.03043902f, 0.03125230f, 0.00113423f, 0.03594586f, -0.07327221f, -0.07039011f, -0.09623764f, -0.01804147f, 
    0.02796726f, -0.09841395f, -0.03687315f, -0.00155277f, -0.06400067f, -0.08643206f, -0.05772322f, 0.02254091f, 
    -0.03250701f, 0.00017901f, 0.03477227f, 0.02755441f, -0.06578143f, 0.06641731f, -0.06067839f, -0.08872744f, 
    0.00605081f, -0.05481151f, -0.05659610f, -0.00445774f, -0.04058458f, -0.02259290f, -0.03458003f, -0.10109452f, 
    0.03951790f, -0.02913159f, -0.09850433f, -0.09891330f, -0.04180687f, 0.00701939f, 0.02251794f, 0.02273202f, 
    -0.23552887f, 0.05288050f, -0.36660531f, 0.04348212f, -0.13606539f, -0.08311668f, -0.00115319f, 0.43016201f, 
    -0.22590743f, 0.00967437f, -0.15434961f, 0.15851425f, 0.03933496f, -0.39769033f, 0.01936425f, 0.05618601f, 
    0.00524096f, 0.06307726f, -0.19427454f, 0.12777305f, 0.29667848f, 0.16514090f, 0.04847247f, -0.05903948f, 
    0.18533860f, 0.04272462f, -0.00894695f, 0.05056763f, -0.04831822f, 0.46768320f, -0.00777056f, 0.21738432f, 
    0.02443769f, 0.18704209f, -0.43471664f, -0.00124755f, -0.20171247f, 0.20865035f, 0.04210261f, -0.22924149f, 
    -0.04394798f, -0.16169924f, 0.24924807f, 0.50367045f, 0.88501924f, 0.00345436f, 0.31975257f, -0.08244357f, 
    0.09444559f, 0.14082752f, 0.00180561f, 0.03425270f, 0.04334895f, -0.02648835f, -0.30109784f, 0.10866428f, 
    0.15782611f, 0.24831180f, -0.22567536f, 0.24498503f, 0.08834933f, 0.09260916f, -0.20913677f, 0.27115342f, 
    0.11584027f, -0.07458610f, -0.14767498f, 0.16532156f, -0.02077870f, -0.02772569f, 0.12726647f, -0.01314441f, 
    0.03443355f, -0.38258740f, 0.26266816f, 0.16706170f, 0.12267936f, -0.10025179f, -0.22427672f, -0.22033237f, 
    0.67508978f, 0.13792814f, 0.08377515f, -0.16649991f, 0.34759185f, 0.01571859f, -0.23873043f, 0.14462557f, 
    -0.00512824f, 0.31549406f, 0.27830935f, 0.06813578f, -0.35964102f, -0.65286565f, -0.63491863f, -0.01297407f, 
    0.17613325f, -0.02611132f, 0.00169479f, -0.08317813f, -0.01432104f, 0.18370265f, -0.04998554f, 0.28503329f, 
    -0.40838826f, -0.00998201f, 0.16242318f, 0.09670337f, 0.11404647f, 0.21082522f, -0.07832187f, -0.10824317f, 
    -0.21888745f, -0.02739097f, 0.10721997f, 0.35662341f, -0.12141424f, 0.04803688f, -0.25052157f, -0.12740922f, 
    0.29204348f, 0.49610472f, 0.07085220f, 0.04675710f, 0.07156260f, 0.15501629f, 0.10677846f, -0.10904410f, 
    -0.00364983f, 0.06282602f, -0.10421073f, 0.23770782f, 0.04603041f, 0.12478700f, 0.03867266f, 0.18067804f, 
    0.12268647f, -0.06161474f, 0.03187670f, 0.17706217f, 0.03323594f, -0.00324295f, 0.25879079f, 0.06353129f, 
    -0.03416019f, -0.15420495f, -0.06613921f, -0.01624026f, -0.38253251f, 0.09115051f, 0.15914714f, -0.06537167f, 
    0.12728436f, 0.16088556f, 0.00541695f, 0.06064381f, 0.05028921f, 0.23813447f, 0.07462574f, 0.40437958f, 
    0.03232000f, -0.22595616f, -0.07555823f, -0.01536582f, -0.12691315f, 0.11103229f, -0.05365117f, 0.46494892f, 
    0.04490839f, -0.08418156f, -0.01061643f, 0.00508792f, -0.70401132f, 0.05637785f, 0.24052058f, 0.04477205f, 
    0.10813530f, 0.08838432f, -0.08658408f, 0.17654367f, 0.04488293f, -0.00185068f, -0.44614533f, 0.12704262f, 
    -0.29566330f, 0.27579480f, -0.23965323f, 0.10851400f, 0.27779365f, 0.02761159f, -0.05274633f, 0.25846851f, 
    0.17758270f, -0.11771037f, 0.10022293f, -0.15066072f, 0.09857598f, -0.13076399f, 0.17727971f, 0.03914538f, 
    -0.00839353f, 0.03864823f, 0.47212702f, -0.54855329f, 0.14631630f, 0.01661560f, -0.09075343f, 0.00263471f, 
    -0.31551105f, -0.07836095f, 0.24788098f, -0.26591271f, -0.29675785f, 0.17548527f, -0.22020882f, 0.11274822f, 
    0.02395947f, -0.03759564f, 0.40497950f, -0.05421430f, -0.03669308f, -0.18173864f, -0.04828638f, -0.22067437f, 
    0.00240023f, -0.00336977f, 0.10064559f, -0.06962793f, -0.04864617f, 0.20629199f, -0.23534650f, 0.39188972f, 
    -0.07901164f, -0.06883164f, 0.05283330f, -0.31585956f, 0.25967512f, -0.09671426f, -0.05508713f, 0.00021726f, 
    0.02872464f, 0.18997614f, 0.11344546f, 0.30119625f, -0.15908705f, -0.34910986f, -0.24847771f, 0.00629186f, 
    0.27059746f, 0.12225270f, 0.22149700f, 0.15267810f, 0.10152667f, 0.23359115f, 0.09997123f, 0.03422534f, 
    -0.06879614f, 0.03308964f, -0.04417143f, -0.01627826f, -0.03045367f, -0.04519766f, 0.03835255f, 0.07242764f, 
    -0.07001478f, -0.03154017f, -0.10722354f, 0.09430023f, -0.03642002f, 0.00264454f, 0.02962307f, 0.04096380f, 
    -0.01625244f, -0.03003488f, 0.05274824f, -0.02885565f, 0.06396781f, -0.06979603f, -0.01324028f, -0.02927542f, 
    -0.06470870f, -0.01321576f, -0.05117032f, -0.09696604f, 0.00244830f, -0.09523838f, 0.05212769f, -0.01552775f, 
    0.06021022f, -0.03903474f, -0.07225890f, -0.07072315f, 0.00029454f, -0.06990514f, 0.01658550f, 0.02385447f, 
    -0.00983969f, 0.07250815f, 0.04205624f, 0.08102349f, 0.01505772f, -0.07430495f, -0.05508389f, 0.00251061f, 
    -0.07247391f, 0.05969065f, 0.05987716f, -0.12824111f, 0.02775498f, -0.09243294f, -0.03924683f, -0.00356323f, 
    0.02285204f, 0.05474625f, -0.04718352f, -0.04627836f, -0.01155937f, -0.07561371f, -0.10924686f, -0.07054280f, 
    -0.05593830f, 0.03509652f, 0.00249228f, 0.04526565f, 0.03813811f, 0.05296852f, -0.07627027f, -0.04820378f, 
    -0.04217200f, -0.01491352f, 0.05916039f, -0.12299064f, -0.04545593f, -0.05203225f, -0.12171461f, 0.06344637f, 
    -0.05605021f, -0.00305579f, 0.04131846f, 0.02731845f, 0.04969363f, -0.00395830f, 0.02899178f, 0.01393418f, 
    0.05242809f, -0.01239976f, -0.01775958f, -0.03620120f, 0.02398895f, -0.02598798f, -0.07257196f, 0.00858910f, 
    0.00071478f, -0.04396279f, -0.07640175f, 0.02990366f, -0.09261959f, -0.07253115f, 0.05096835f, -0.08256210f, 
    0.00710082f, 0.04727071f, -0.02168172f, -0.04010787f, -0.00990642f, -0.10317833f, 0.03606702f, 0.00858711f, 
    -0.09017409f, -0.07112227f, -0.00340837f, -0.03304107f, -0.10432660f, 0.04764085f, 0.01406416f, 0.03231313f, 
    0.02612883f, -0.05957906f, -0.09531961f, 0.04787543f, -0.05817045f, -0.00024019f, -0.03373790f, 0.05493976f, 
    0.05864865f, -0.13763447f, 0.00842194f, -0.11536267f, -0.15752321f, 0.03824652f, -0.00866962f, -0.15953560f, 
    0.02175744f, -0.01941938f, -0.00883547f, 0.04988483f, -0.02937981f, 0.10498784f, 0.07996092f, 0.00944785f, 
    0.02622346f, 0.20494954f, 0.09531625f, 0.04889497f, -0.13768935f, -0.02167365f, 0.03686880f, -0.08656526f, 
    -0.15546860f, 0.16250558f, -0.05528826f, 0.27648780f, -0.00358159f, -0.11994518f, -0.07916018f, 0.09393679f, 
    0.08095288f, -0.24535298f, 0.23273984f, -0.04370268f, 0.01771562f, -0.01767879f, 0.10282522f, -0.25416189f, 
    0.10587332f, -0.12947431f, -0.18454966f, 0.01368158f, -0.06405414f, -0.08747808f, -0.23623215f, -0.01575877f, 
    -0.07177022f, -0.00781601f, -0.05341679f, 0.19208804f, 0.09203860f, 0.13046746f, 0.00945750f, -0.02665274f, 
    -0.25874892f, 0.01193239f, -0.15671065f, 0.13800479f, 0.12373950f, -0.03563530f, 0.16248007f, 0.12418472f, 
    0.03675983f, -0.24408901f, -0.19078115f, -0.00328362f, 0.06309290f, 0.10766175f, 0.11531088f, 0.21721785f, 
    -0.14697382f, 0.13280159f, -0.25438687f, -0.03827765f, 0.06221139f, 0.18873730f, 0.05112990f, 0.00451255f, 
    -0.17253613f, -0.20247746f, -0.07242638f, -0.13886386f, 0.21457526f, 0.05222347f, 0.17058988f, -0.04245836f, 
    -0.01784307f, -0.01271970f, -0.05794983f, -0.05971439f, 0.22293080f, 0.23313715f, 0.28777754f, -0.16668335f, 
    -0.24791810f, 0.23660965f, 0.05511250f, 0.02495124f, -0.01577750f, 0.00310559f, -0.16701557f, -0.04945501f, 
    -0.01558701f, 0.25306749f, 0.07540654f, -0.45293415f, -0.07072183f, -0.09471796f, -0.01795299f, 0.00629880f, 
    0.11185668f, -0.41990414f, 0.05771692f, -0.02544395f, -0.05153738f, 0.12159819f, 0.27701744f, 0.20006984f, 
    0.26113439f, 0.02106201f, -0.12136029f, -0.26771289f, -0.14086737f, 0.00655662f, -0.03837749f, 0.10502805f, 
    0.41319251f, 0.10613338f, 0.34454840f, -0.31449839f, 0.27664655f, -0.23252417f, -0.04867021f, 0.09919691f, 
    0.25459212f, 0.08914823f, -0.03869177f, -0.09251494f, 0.13766101f, 0.52899456f, 0.15618259f, -0.05479435f, 
    0.06892259f, -0.02520596f, -0.00509497f, -0.11012094f, -0.07563734f, -0.07729992f, -0.10296753f, 0.04853728f, 
    0.29280514f, -0.18613096f, 0.00431021f, 0.09062185f, 0.10413428f, 0.46141157f, 0.05708005f, -0.19498847f, 
    0.04297303f, 0.20571549f, -0.15792444f, -0.02748205f, -0.15510482f, 0.08132569f, 0.07507778f, 0.38247874f, 
    -0.20885925f, -0.01231044f, 0.22437310f, -0.29908499f, 0.18378198f, 0.11288743f, 0.27046514f, 0.00989945f, 
    0.09188853f, -0.12716961f, -0.06420221f, 0.06016149f, -0.04665209f, 0.04488373f, -0.42706382f, 0.04680579f, 
    0.28736508f, -0.29851627f, 0.10180354f, 0.04481385f, -0.02589494f, 0.09492157f, 0.06383035f, -0.20351003f, 
    0.16735019f, 0.23586538f, 0.47603032f, -0.12981844f, -0.04333742f, 0.42209125f, -0.15558021f, 0.26964319f, 
    -0.10698938f, 0.14420687f, 0.10646485f, 0.12364018f, -0.15510339f, -0.15471163f, -0.06232778f, -0.01336585f, 
    0.27419624f, 0.24198547f, -0.05187414f, -0.06324676f, -0.06395449f, 0.08752739f, -0.11497685f, 0.13393416f, 
    0.06349045f, 0.09781311f, -0.48629677f, 0.05133718f, -0.44273803f, -0.11358476f, -0.06963304f, -0.11147077f, 
    0.14460368f, -0.12263184f, 0.02651654f, 0.07884605f, -0.02065325f, 0.06185782f, -0.23188990f, 0.11907604f, 
    -0.12242054f, -0.10124651f, 0.10768869f, 0.79410213f, -0.01676298f, 0.31610006f, 0.05122376f, -0.14980093f, 
    0.07323311f, 0.27663058f, 0.02958854f, 0.03063709f, 0.28962249f, -0.05803191f, -0.17928824f, -0.07144340f, 
    -0.32616502f, 0.18044858f, 0.27260348f, 0.39229906f, 0.22898467f, 0.00353367f, 0.07752926f, -0.17225909f, 
    -0.09434462f, 0.02505455f, -0.30451751f, -0.05014723f, -0.04279470f, 0.05405792f, 0.04512424f, 0.39128998f, 
    0.00567735f, -0.03772423f, -0.02951179f, 0.05042972f, 0.31128025f, 0.11029893f, 0.16047047f, -0.06955087f, 
    0.08426835f, -0.01210200f, -0.13680814f, -0.05068546f, -0.29175550f, 0.08994014f, 0.12227497f, 0.01348081f, 
    0.07110081f, 0.18439355f, -0.07459319f, 0.28473848f, -0.03312776f, 0.23918426f, 0.01416591f, 0.21801569f, 
    0.00185622f, 0.29380515f, -0.06301425f, -0.02832603f, -0.19299231f, 0.02935536f, 0.10082486f, 0.18411626f, 
    0.00531276f, -0.19253206f, -0.03529838f, 0.11282108f, 0.95119202f, 0.04983031f, 0.30972359f, -0.08365728f, 
    0.00584975f, 0.05104916f, -0.01644704f, 0.07817423f, -0.05815841f, -0.00335434f, 0.06128132f, 0.09070636f, 
    0.47853383f, 0.04148566f, -0.20874223f, 0.22506177f, 0.19536453f, 0.07022031f, -0.00360998f, 0.23552833f, 
    0.28984150f, -0.11456928f, -0.07570740f, -0.09323007f, -0.00802999f, 0.08301957f, 0.09476592f, -0.00607134f, 
    0.14812529f, 0.04323399f, 0.31046081f, -0.10115935f, -0.14001402f, 0.08191116f, -0.06164075f, 0.04617219f, 
    0.26304805f, -0.07253141f, 0.19487455f, -0.19672756f, 0.31472909f, 0.18180446f, -0.01848256f, -0.02751624f, 
    0.05396447f, 0.22861803f, 0.32474399f, 0.05168094f, -0.22037064f, -0.35341704f, 0.03888224f, -0.20543745f, 
    0.03291797f, 0.06100132f, -0.01833335f, -0.01474648f, 0.10190364f, 0.05451378f, -0.19335920f, 0.02568037f, 
    -0.16706584f, 0.05161958f, 0.13239257f, 0.06321160f, 0.06337091f, -0.08022688f, -0.11039238f, 0.16192988f, 
    0.08149890f, 0.16188961f, 0.04986330f, 0.17874809f, 0.08267775f, 0.23999748f, 0.58428645f, -0.05596051f, 
    0.13889976f, 0.37504080f, 0.08565028f, 0.05380296f, -0.00732303f, 0.10273576f, 0.07627986f, 0.02805851f, 
    -0.05304362f, -0.09857010f, 0.03469924f, -0.02287495f, 0.02040520f, 0.06672636f, -0.08099275f, 0.06727552f, 
    -0.05500295f, -0.01384881f, -0.03488140f, 0.00072882f, -0.04873605f, -0.07562308f, -0.09602666f, 0.07336821f, 
    -0.00651108f, 0.00445560f, 0.01089492f, -0.02582820f, -0.00891114f, -0.08119634f, 0.05654337f, -0.02751931f, 
    0.04935950f, 0.02316789f, 0.02184398f, -0.01485540f, 0.03216236f, 0.01519608f, 0.06928016f, -0.02689766f, 
    -0.06988779f, -0.09754839f, -0.03696410f, -0.03937312f, -0.06356044f, -0.03103445f, 0.02414825f, 0.00601271f, 
    -0.00099888f, -0.05613627f, 0.02511993f, 0.06288666f, -0.08161910f, -0.00120237f, -0.06124401f, -0.09362505f, 
    0.01407113f, -0.00979244f, -0.05195260f, -0.15684527f, -0.10204983f, -0.05762396f, -0.04345790f, -0.03305252f, 
    -0.07457578f, 0.02948406f, -0.03029199f, 0.01051700f, 0.00395767f, -0.05675776f, -0.05457947f, 0.06996832f, 
    -0.06120886f, 0.03759000f, 0.02954326f, -0.04683742f, -0.00642325f, -0.08777463f, -0.13715871f, -0.03658947f, 
    0.04032130f, 0.04028046f, -0.00260322f, 0.04388866f, 0.05284599f, 0.04887308f, -0.08714537f, -0.10579222f, 
    -0.09751458f, -0.01433465f, -0.07485431f, -0.06830544f, -0.12116499f, -0.02427476f, -0.03208146f, -0.11581195f, 
    0.02492878f, -0.07420626f, 0.09117643f, 0.01979418f, -0.03008323f, 0.04371985f, -0.07521159f, -0.03113414f, 
    -0.03469827f, -0.01814196f, -0.08166285f, -0.08212662f, -0.07334583f, 0.01102946f, -0.00716322f, -0.09875219f, 
    0.03652402f, -0.05988369f, -0.02916525f, 0.03358771f, -0.08809130f, 0.09858868f, 0.02028456f, -0.04890332f, 
    -0.00014765f, 0.04359749f, -0.00314450f, -0.04260033f, -0.07721752f, -0.03826665f, -0.14444467f, -0.10396880f, 
    0.00602223f, 0.11672726f, -0.12025023f, -0.00097035f, 0.00396836f, -0.06368848f, 0.06654892f, -0.02724948f, 
    0.21211572f, 0.04633601f, -0.12826931f, -0.08822454f, 0.12394539f, -0.06857477f, 0.04202039f, -0.11724441f, 
    0.02574033f, -0.00954392f, -0.01515607f, 0.04005632f, 0.05119925f, 0.11620190f, 0.08695608f, 0.00168283f, 
    0.11586989f, 0.03692137f, 0.09683348f, -0.01336178f, 0.30580935f, -0.08224236f, 0.10343096f, -0.07040787f, 
    -0.00937720f, -0.05719394f, -0.01575098f, 0.00930286f, -0.01240890f, -0.38239360f, -0.08299034f, -0.01856722f, 
    -0.00932309f, -0.07770069f, 0.16927552f, -0.06316096f, 0.02789940f, 0.00503734f, 0.07007171f, -0.12215363f, 
    0.01317808f, 0.14041154f, -0.02135780f, -0.02707693f, 0.34094527f, 0.10049639f, 0.02762342f, 0.16456218f, 
    0.15747397f, -0.03531690f, -0.02543635f, 0.04705607f, -0.15661930f, 0.07822081f, 0.48591194f, 0.09379488f, 
    0.44669420f, -0.01166707f, 0.13011372f, -0.01252593f, -0.10151076f, 0.05754730f, -0.02708218f, -0.17292170f, 
    0.01508270f, 0.01567767f, 0.15291792f, 0.14982553f, -0.07723885f, 0.05625864f, -0.04404991f, 0.16187328f, 
    -0.07553709f, 0.05815899f, -0.21697411f, 0.47526592f, -0.01557541f, -0.07749445f, 0.12350633f, 0.12195875f, 
    0.32429263f, 0.19594489f, -0.08168164f, -0.00362990f, 0.09789809f, -0.14294358f, 0.19352147f, -0.05428703f, 
    0.01915002f, 0.19466063f, -0.32097781f, 0.03774601f, 0.10117630f, 0.14911050f, 0.18965480f, 0.30021501f, 
    0.11065204f, 0.06162740f, -0.01102628f, -0.09157404f, -0.06193268f, -0.10410684f, 0.35428074f, -0.15186928f, 
    0.14461620f, 0.07201090f, 0.01557112f, 0.47987452f, 0.03973384f, 0.27215767f, 0.08229966f, -0.04680338f, 
    0.12344803f, -0.07652953f, 0.01294358f, -0.04424388f, 0.28510559f, 0.24956426f, -0.05840110f, 0.03457891f, 
    -0.08701078f, 0.10970776f, -0.03288641f, -0.17120935f, 0.06488352f, -0.09402203f, 0.11158838f, -0.10300224f, 
    -0.00954899f, -0.05301399f, -0.09903649f, -0.10879467f, 0.01344014f, -0.07576808f, 0.02399296f, 0.04494917f, 
    -0.08440509f, -0.01904301f, -0.09167444f, 0.08560715f, -0.09156188f, 0.01335192f, 0.01660483f, -0.00511174f, 
    0.04465437f, -0.06698494f, 0.02097942f, -0.04603435f, -0.03828340f, -0.04353123f, -0.01581386f, -0.05565692f, 
    -0.04243667f, -0.08860898f, 0.06391548f, -0.00055971f, -0.08284274f, 0.04857484f, -0.00567297f, 0.03530138f, 
    0.06236493f, 0.07131707f, 0.08112446f, 0.04151258f, -0.03455384f, -0.00147790f, -0.01005956f, -0.02904475f, 
    -0.10611071f, -0.04073796f, 0.02141010f, 0.01097883f, -0.01681384f, -0.02603621f, -0.05208671f, -0.09243667f, 
    -0.01543094f, 0.05926057f, 0.00347082f, -0.06471256f, -0.05366984f, 0.00812575f, -0.04014722f, -0.01301212f, 
    -0.02138003f, -0.08927507f, -0.07095569f, -0.08825757f, -0.04230041f, -0.06766649f, -0.05701465f, -0.08323636f, 
    -0.10378642f, -0.07328510f, -0.03425416f, 0.00486833f, -0.00911134f, 0.00552150f, 0.03636710f, -0.08326857f, 
    0.03668506f, -0.05054148f, 0.04269916f, 0.00155465f, -0.06145570f, -0.02185693f, -0.10055806f, 0.06352282f, 
    -0.01325058f, -0.05906724f, 0.01229043f, -0.03792988f, 0.00291570f, -0.05969041f, -0.00416507f, 0.01427438f, 
    0.01026791f, -0.05101272f, 0.04405715f, 0.07152934f, 0.05912258f, -0.01941567f, -0.05805591f, -0.08546193f, 
    0.03585548f, -0.06198482f, -0.04709579f, 0.04022967f, -0.06892697f, 0.04644488f, -0.08946852f, -0.06129959f, 
    -0.09397142f, 0.02423901f, 0.04243056f, -0.07734396f, -0.11010776f, 0.00591901f, -0.11160657f, -0.05470720f, 
    -0.05101970f, 0.07903813f, 0.02247007f, -0.00224603f, 0.00669877f, 0.08769137f, 0.04746376f, 0.07938795f, 
    0.01539893f, -0.01648105f, -0.05402254f, -0.04424683f, 0.02818520f, -0.03125776f, -0.04919564f, -0.02947170f, 
    0.28321773f, 0.09877660f, 0.19515339f, 0.10136185f, -0.02885547f, -0.13405569f, -0.03416507f, 0.52981961f, 
    0.09076302f, -0.07242750f, -0.00526843f, 0.22931165f, 0.03155645f, 0.40535808f, 0.22755724f, 0.05667917f, 
    -0.04973394f, -0.18732822f, 0.13419171f, -0.11695622f, 0.01847374f, -0.02477997f, -0.06014124f, 0.02723206f, 
    0.11804982f, -0.03386736f, -0.03239626f, -0.00708323f, 0.04362520f, -0.26289287f, -0.05155828f, 0.09617262f, 
    -0.03496040f, -0.04882709f, -0.03807443f, 0.05655906f, 0.00468726f, 0.10177337f, 0.02012409f, 0.33008909f, 
    -0.22742891f, -0.09729842f, 0.15382490f, -0.27091211f, 0.07775000f, 0.09947719f, 0.12623617f, 0.10729863f, 
    0.08690815f, -0.14134175f, 0.02086212f, 0.11458528f, -0.07867771f, 0.06633493f, 0.00732376f, -0.01623109f, 
    0.29813048f, -0.07479138f, 0.11770777f, 0.08772270f, -0.00176317f, 0.14546071f, 0.05694978f, -0.20334066f, 
    0.22062068f, 0.15807955f, 0.15124746f, -0.11969839f, 0.02355888f, 0.22181909f, -0.01971274f, 0.13268080f, 
    -0.05846034f, 0.00006664f, -0.05249019f, 0.03334367f, -0.03465274f, 0.01087002f, -0.04650138f, 0.21293476f, 
    0.08949150f, 0.04597757f, 0.11865818f, -0.03470811f, -0.26122627f, -0.13872078f, -0.08923746f, 0.06920969f, 
    -0.01443667f, 0.55865031f, 0.22678730f, 0.02608344f, -0.30225003f, -0.07244402f, 0.03988973f, -0.01385785f, 
    0.01881800f, -0.07555454f, -0.12132370f, 0.04890708f, -0.26178452f, -0.07204539f, -0.05294566f, 0.10956360f, 
    0.19539213f, 0.01182708f, -0.06373295f, 0.27596879f, 0.01737669f, 0.48003355f, -0.05281263f, 0.03017171f, 
    0.20863375f, 0.48123875f, -0.00805388f, -0.14246587f, 0.12590349f, 0.19134071f, -0.18371344f, 0.10337913f, 
    -0.16414368f, 0.36842415f, 0.11036790f, 0.29256850f, 0.18122801f, -0.11218065f, -0.01347349f, 0.01902494f, 
    0.01983530f, 0.19577020f, -0.59143621f, 0.13269885f, 0.09942827f, -0.03966289f, 0.05963011f, -0.87906140f, 
    0.18278134f, 0.02799181f, 0.08733667f, -0.09691632f, 0.31576172f, 0.24640907f, 0.05151307f, -0.06551278f, 
    -0.01454788f, 0.08369929f, 0.22127901f, -0.17426556f, -0.22320876f, 0.18829139f, 0.06361155f, -0.01166962f, 
    -0.20606554f, -0.06501526f, 0.09154090f, 0.01762320f, 0.12980016f, -0.11200794f, -0.00863381f, 0.29575118f, 
    -0.06462213f, 0.29833233f, -0.16108631f, -0.07629696f, 0.24400143f, -0.05053741f, -0.00583502f, 0.35367748f, 
    0.05816766f, -0.11678494f, -0.09222686f, -0.05128336f, -0.07796245f, 0.22127755f, 0.10165466f, 0.11917292f, 
    0.21613818f, 0.12956551f, -0.05580861f, -0.23631853f, 0.06226619f, 0.01531588f, -0.49435756f, 0.10154144f, 
    0.16605720f, 0.13887212f, -0.07490029f, -0.39715332f, 0.00991302f, -0.10220705f, -0.02021557f, -0.29170826f, 
    0.15100387f, 0.22329865f, 0.16493914f, -0.06454402f, 0.04398479f, -0.19434805f, 0.09617378f, 0.03580381f, 
    0.22001797f, 0.13960214f, 0.53634208f, 0.09073696f, -0.16569328f, 0.23995195f, 0.04009546f, 0.14240095f, 
    -0.59863490f, -0.03952795f, 0.28678772f, 0.09602404f, -0.57562464f, 0.21037228f, -0.09381863f, -0.15661503f, 
    0.04062962f, -0.00462803f, -0.25913519f, 0.00188808f, -0.15043834f, -0.07196357f, 0.14053881f, -0.04868335f, 
    -0.10881233f, -0.10479663f, 0.05814525f, -0.05499364f, 0.22369286f, 0.10218137f, 0.20700470f, -0.26489621f, 
    0.11871976f, -0.03744517f, -0.15893829f, -0.07402734f, 0.00490663f, 0.02857046f, 0.08791546f, -0.01174204f, 
    0.09498881f, -0.27280280f, 0.00895139f, 0.21574318f, 0.38331482f, -0.21310489f, -0.34001926f, -0.21606769f, 
    -0.20677921f, 0.17732328f, -0.08513260f, -0.07508434f, -0.01943638f, 0.08517433f, 0.30195394f, -0.23217438f, 
    0.17561002f, 0.19408359f, 0.30713451f, -0.34425664f, 0.34478614f, 0.05687675f, 0.01647016f, 0.58788955f, 
    0.31192973f, 0.18630095f, -0.30419031f, -0.15338095f, -0.24669945f, -0.29951337f, 0.02986979f, -0.02004375f, 
    -0.07129472f, 0.15088835f, -0.16227145f, 0.19995129f, 0.19362387f, -0.01581915f, 0.04803303f, 0.02510497f, 
    -0.03630845f, -0.15509070f, 0.02528515f, -0.38026875f, 0.02071553f, 0.61535519f, 0.04270627f, -0.25074604f, 
    0.03380381f, 0.16491920f, -0.12986177f, 0.02435694f, -0.36619133f, -0.04562968f, 0.01662578f, 0.11087478f, 
    -0.24507913f, 0.01072153f, 0.14610198f, 0.03562379f, 0.75642174f, 0.09118257f, -0.07935818f, 0.02689674f, 
    0.03974925f, 0.11985858f, 0.05586458f, -0.14539769f, -0.45648083f, -0.06572371f, -0.24679364f, 0.18818738f, 
    -0.05560197f, -0.46473813f, 0.08493248f, 0.17152886f, -0.01816274f, 0.18512698f, 0.12814385f, -0.04428984f, 
    -0.07463826f, 0.05857017f, 0.20577511f, -0.29114994f, -0.00891399f, 0.12659104f, -0.13498449f, -0.03273910f, 
    -0.06466109f, -0.13784091f, 0.00160942f, 0.01731236f, 0.00440433f, -0.04060391f, -0.31373632f, 0.09550595f, 
    0.39285755f, 0.26783159f, 0.01414210f, 0.00821752f, 0.38546556f, -0.04022567f, -0.20254737f, 0.30191815f, 
    0.02909430f, 0.05923892f, -0.06585436f, -0.02411954f, -0.22905873f, -0.00840653f, -0.60661584f, 0.22417346f, 
    0.40363505f, 0.00772526f, 0.18101269f, 0.08461801f, 0.27459550f, 0.29439554f, -0.01963660f, -0.04496216f, 
    0.01042959f, -0.27956599f, 0.13955255f, 0.69203496f, 0.01459878f, -0.01880772f, -0.12780085f, -0.01659268f, 
    -0.16439120f, 0.66209161f, -0.31223017f, -0.21712984f, 0.17451875f, 0.08806792f, 0.36431244f, -0.21122900f, 
    -0.30730161f, -0.06654764f, 0.02607212f, 0.50426650f, 0.13876729f, 0.14027134f, 0.07421108f, 0.10419159f, 
    0.15585673f, 0.00627409f, 0.32547918f, 0.33668283f, -0.02284143f, 0.02600857f, 0.06119860f, -0.46902174f, 
    -0.08419979f, -0.04895738f, 0.03435050f, -0.06589288f, 0.08920223f, 0.12694383f, -0.16378041f, -0.04505545f, 
    -0.05734514f, 0.12952909f, 0.17763381f, 0.01448822f, 0.42754298f, 0.06413938f, -0.12636763f, -0.05200334f, 
    0.06289856f, -0.02261605f, -0.03170202f, 0.09302703f, 0.05024968f, -0.04438056f, 0.05164822f, -0.15258494f, 
    0.08700912f, -0.41942462f, 0.17634185f, 0.02004249f, 0.30587164f, 0.05415516f, -0.02817408f, -0.08560491f, 
    0.00731805f, 0.22379418f, 0.15718517f, 0.07752604f, 0.16462068f, -0.03121546f, -0.04687108f, 0.03154358f, 
    0.14751191f, 0.00935403f, 0.02517441f, 0.06302666f, 0.05868546f, 0.10331345f, 0.35011533f, 0.06505948f, 
    0.04025573f, 0.06685538f, 0.34645566f, 0.05872255f, -0.11978993f, -0.15067947f, 0.26182440f, -0.33313575f, 
    -0.33629096f, 0.02580706f, 0.14902164f, 0.32834214f, -0.00822406f, 0.29135078f, -0.01099538f, 0.32343826f, 
    0.09704277f, 0.12593138f, -0.23405387f, 0.30167940f, -0.05987151f, 0.07523467f, 0.12840655f, 0.05204859f, 
    0.41738233f, 0.22166041f, -0.20904899f, 0.23318546f, 0.33857322f, -0.07044344f, 0.28981620f, 0.10912520f, 
    0.04263889f, -0.03949998f, -0.35708195f, -0.08357324f, 0.20339674f, 0.28740874f, 0.35447028f, 0.26336944f, 
    -0.08403327f, -0.06879143f, -0.16078293f, -0.08486450f, -0.17460169f, -0.20943870f, 0.20566180f, -0.12863933f, 
    0.16226241f, 0.04394077f, -0.12743807f, 0.15943815f, 0.01890969f, 0.29012045f, 0.11767823f, 0.00695534f, 
    0.10306855f, -0.26122001f, 0.14520606f, -0.02759806f, 0.26213259f, 0.31794003f, -0.46496770f, 0.32848981f, 
    0.03820997f, -0.10421550f, 0.00138668f, -0.24093610f, -0.00518332f, -0.09894900f, 0.11664401f, 0.12071399f, 
    -0.21196228f, 0.21396329f, -0.45198080f, -0.01607177f, 0.08922702f, 0.13188590f, -0.02569127f, -0.69809514f, 
    0.08286048f, 0.12939790f, 0.01928071f, -0.04958300f, 0.20480646f, -0.16172329f, 0.15535611f, -0.05171260f, 
    0.03405667f, 0.05806316f, 0.02702517f, 0.03197932f, -0.52428234f, 0.31399304f, 0.07582704f, -0.04118345f, 
    -0.02889645f, 0.08071813f, -0.04445127f, 0.17473629f, -0.08098792f, 0.10629358f, -0.01365225f, 0.18772812f, 
    0.04639622f, 0.43698850f, -0.13053893f, 0.01292762f, -0.00351429f, 0.13221672f, -0.01023627f, 0.22710933f, 
    0.14353968f, -0.05155352f, 0.05570555f, -0.14024836f, -0.20377961f, 0.03296803f, 0.15990895f, -0.04584783f, 
    0.06306196f, 0.01898332f, -0.07882230f, 0.08584262f, 0.01253174f, -0.05745642f, -0.24362917f, 0.24133928f, 
    -0.19245648f, 0.08560831f, -0.23771198f, 0.02799443f, 0.23541327f, 0.01999913f, -0.00510855f, 0.17243569f, 
    0.18804257f, -0.05303659f, -0.07252184f, -0.02961812f, 0.03634835f, -0.23242490f, 0.11109893f, -0.21590665f, 
    0.31589091f, 0.11821047f, 0.61320430f, -0.23325042f, 0.15127105f, 0.09806837f, -0.06975017f, 0.17246105f, 
    -0.30266732f, -0.15686214f, 0.29756704f, 0.02361512f, -0.14285409f, 0.34996003f, -0.09421626f, 0.01722426f, 
    -0.04073384f, -0.28672129f, -0.07850994f, -0.01617214f, -0.03893312f, -0.22391595f, -0.15458512f, -0.09454024f, 
    -0.03359358f, -0.03551219f, 0.41525263f, -0.02319975f, 0.35074359f, 0.11205022f, -0.00795771f, 0.03648744f, 
    -0.21181367f, -0.15845008f, 0.24511115f, -0.25271353f, 0.03731571f, -0.50537169f, 0.05891700f, 0.12431286f, 
    -0.10359815f, -0.27945071f, 0.04263170f, 0.29462761f, -0.05204292f, -0.26530531f, 0.08352049f, -0.24053484f, 
    0.27655381f, -0.00688402f, 0.02240561f, -0.03387401f, -0.14215553f, 0.11091663f, 0.05351211f, -0.05715038f, 
    0.32350287f, 0.19891359f, -0.18452775f, -0.12216405f, 0.30485180f, 0.01100714f, -0.00532167f, -0.11206091f, 
    0.05685091f, 0.14788492f, 0.06257470f, 0.14330567f, 0.32332909f, 0.18525860f, 0.11306352f, 0.00815603f, 
    0.06508620f, -0.05515692f, 0.09857011f, 0.09679047f, -0.31071198f, -0.12750258f, 0.14050001f, 0.03587287f, 
    -0.06501877f, -0.02597189f, 0.04002584f, -0.04920670f, 0.16006061f, -0.65469408f, -0.02118025f, -0.01940318f, 
    -0.07340289f, 0.21785663f, 0.14145470f, 0.01531935f, 0.05899181f, -0.02024156f, 0.06142014f, 0.24981411f, 
    0.00623510f, 0.06035761f, -0.02395326f, -0.23916283f, -0.51482433f, 0.16859876f, 0.08868920f, 0.18740585f, 
    0.18237470f, 0.05226888f, 0.00301378f, 0.08811168f, -0.13463627f, -0.10913503f, 0.28920490f, 0.17049369f, 
    0.40092951f, -0.13451946f, 0.06150477f, 0.01788429f, 0.00049015f, 0.19741157f, -0.01175015f, -0.13505007f, 
    0.10866582f, 0.18971732f, 0.18197995f, -0.03316004f, 0.11635201f, 0.14622925f, 0.01071855f, 0.18598083f, 
    0.03676905f, -0.06221743f, -0.00833158f, 0.14464861f, -0.02045811f, 0.03048436f, -0.06250781f, 0.20722629f, 
    -0.03231952f, 0.12692554f, -0.04081159f, 0.03740571f, -0.15059310f, -0.00261718f, 0.22575162f, -0.02858819f, 
    0.05068064f, -0.01601849f, -0.48688677f, -0.01889191f, 0.05726674f, 0.31807104f, 0.18265535f, 0.20327306f, 
    0.06689601f, -0.09549905f, 0.07682532f, -0.02014817f, 0.04589124f, -0.01679344f, 0.19802742f, -0.04146428f, 
    0.10857993f, -0.18667378f, -0.01165958f, 0.68954766f, 0.16523518f, 0.31902876f, 0.21239492f, -0.08501728f, 
    0.21270585f, 0.03712533f, -0.07771956f, -0.17316672f, 0.38531759f, -0.09185557f, 0.05436121f, -0.07258009f, 
    -0.08930328f, 0.04828799f, 0.04970869f, -0.07985218f, 0.07690858f, -0.05569400f, 0.37268940f, -0.12881497f, 
    -0.08912651f, 0.17889941f, -0.39762744f, 0.09964448f, 0.14927818f, -0.00459088f, 0.05203141f, -0.95450121f, 
    0.02406429f, -0.14455430f, 0.06614558f, 0.04377025f, 0.09415749f, 0.02697374f, 0.06421397f, -0.00017548f, 
    -0.07213885f, -0.05420210f, 0.17817222f, -0.06286926f, 0.00924873f, 0.02671356f, 0.21640523f, -0.05492811f, 
    -0.12614921f, 0.03423699f, 0.08058603f, -0.09109161f, -0.02028120f, -0.09118465f, 0.09705994f, 0.22141652f, 
    -0.03197955f, -0.16186914f, 0.12562111f, -0.01451836f, 0.31804514f, 0.06470175f, -0.03426333f, 0.08124802f, 
    0.07638127f, 0.04466901f, -0.05643246f, 0.01278558f, -0.08203481f, 0.11505584f, 0.02468641f, 0.10661648f, 
    0.11646366f, -0.07775539f, -0.06473237f, -0.07903418f, -0.02664997f, 0.19281951f, 0.01952882f, 0.05749419f, 
    -0.17503501f, 0.28326863f, 0.03532103f, -0.35930336f, -0.24385703f, -0.10145832f, 0.01050025f, -0.15844913f, 
    0.10093068f, 0.14685370f, 0.00368293f, -0.01235783f, 0.01542311f, -0.13023746f, 0.05855099f, -0.03563401f, 
    0.23791629f, 0.11023163f, 0.30889654f, 0.24244358f, -0.01556575f, 0.22404417f, 0.14958875f, 0.24381708f, 
    -0.24056382f, 0.04364062f, 0.41724503f, 0.17542399f, -0.35115343f, 0.01713874f, 0.06396367f, -0.17660365f, 
    -0.01483178f, -0.03366562f, -0.13106790f, 0.04103716f, 0.07478010f, 0.02522795f, 0.26728502f, -0.04433402f, 
    -0.23185627f, 0.13719578f, -0.12006494f, -0.07989384f, 0.00593484f, 0.07222022f, 0.12714037f, -0.03425130f, 
    0.11274175f, 0.07972319f, -0.25339407f, -0.48425448f, 0.07420480f, -0.10129771f, 0.04561016f, 0.10428354f, 
    0.04645061f, -0.86875200f, 0.00924100f, 0.19006024f, 0.06627281f, -0.06472857f, -0.60944688f, -0.17317736f, 
    -0.12104015f, 0.16492352f, -0.05234708f, -0.31390876f, -0.01997778f, 0.03581255f, 0.12342701f, -0.22094819f, 
    0.07483156f, 0.01876823f, 0.00216097f, 0.00440403f, -0.02705044f, -0.07794237f, 0.02923263f, -0.03203441f, 
    0.06313208f, -0.00594494f, -0.05033049f, -0.05320930f, 0.04169825f, 0.02278743f, 0.07393707f, -0.06873546f, 
    0.07656103f, -0.05758849f, 0.03710427f, 0.06234904f, 0.02991945f, -0.03106840f, -0.06393347f, 0.00920503f, 
    -0.03846235f, -0.00997525f, 0.08248834f, 0.01988723f, -0.06354363f, -0.08815441f, -0.04559527f, -0.01191319f, 
    -0.01819623f, 0.01845920f, -0.10038605f, -0.05586395f, -0.03272479f, -0.06211989f, 0.07790257f, -0.07218520f, 
    -0.00868822f, -0.02111273f, 0.02825005f, -0.02525044f, -0.01459029f, -0.08664708f, 0.01404948f, -0.04087356f, 
    -0.02962850f, -0.02894529f, 0.07213914f, -0.01442827f, -0.00007167f, -0.05583157f, 0.08141258f, 0.02297186f, 
    -0.08290878f, 0.00740612f, 0.00009768f, -0.07050002f, 0.03500325f, 0.05655292f, 0.04319969f, 0.05551860f, 
    -0.07702500f, 0.01010699f, -0.09176025f, 0.07021536f, -0.07669170f, -0.05885047f, 0.02468275f, -0.05821323f, 
    -0.07017923f, 0.06151294f, -0.00481278f, 0.04552656f, -0.07164514f, 0.04715294f, 0.05336570f, -0.06588271f, 
    -0.05301411f, -0.12068032f, -0.06747608f, -0.05691784f, -0.07627031f, 0.02255261f, -0.06869585f, -0.00758399f, 
    0.04940811f, -0.02773816f, -0.05442731f, -0.07632297f, -0.10281228f, -0.04087240f, -0.02347200f, 0.03991514f, 
    0.05918502f, 0.04058660f, 0.03805730f, 0.02035880f, 0.05733383f, -0.08829957f, 0.01742953f, 0.05289642f, 
    -0.07528163f, -0.02402329f, 0.04363525f, 0.03522375f, 0.05854282f, -0.03734578f, 0.07424414f, 0.07223196f, 
    0.01599085f, 0.02513640f, 0.03969380f, -0.08285646f, 0.07610501f, 0.02520711f, -0.02028458f, -0.04683146f, 
    -0.03649750f, -0.01338245f, -0.02733821f, -0.01713901f, 0.07581400f, -0.00955413f, -0.04762776f, -0.02341496f, 
    0.04367522f, 0.12180704f, -0.12495473f, 0.19746158f, -0.18335649f, -0.10468636f, -0.01481322f, -0.29735368f, 
    -0.12951924f, 0.16575518f, -0.01080705f, -0.17653528f, 0.31903356f, 0.02651527f, 0.27484915f, 0.03504888f, 
    0.07734581f, -0.01247463f, 0.33099094f, 0.04885035f, 0.12219896f, 0.05839205f, -0.07217044f, 0.03705325f, 
    0.05335709f, 0.14161447f, -0.00610200f, 0.34247720f, 0.07218275f, -0.43235540f, -0.04205012f, 0.19696561f, 
    0.05712384f, -0.34353337f, 0.02445858f, -0.03619173f, 0.14684474f, -0.00973577f, -0.01298711f, 0.26761675f, 
    -0.16452400f, -0.18003942f, -0.11046759f, -0.15587749f, 0.09777100f, 0.14992984f, 0.18070349f, 0.15667510f, 
    0.22886913f, 0.04409743f, -0.04915831f, 0.09174893f, -0.03962754f, -0.12549572f, -0.39605635f, 0.16014434f, 
    0.07263117f, 0.17432290f, -0.10790157f, -0.01397867f, 0.03427058f, -0.23377435f, 0.13145801f, -0.29856378f, 
    -0.03840841f, -0.14485514f, 0.11094314f, -0.15779121f, 0.05024786f, 0.02624150f, 0.09085433f, 0.55005443f, 
    -0.06097028f, 0.13567427f, 0.21562865f, 0.08702650f, 0.10413454f, 0.14700814f, -0.06374874f, -0.06661285f, 
    -0.01949379f, 0.20524484f, 0.00581985f, 0.09638128f, -0.12066363f, 0.20001446f, 0.14496966f, -0.01440944f, 
    -0.08290807f, -0.15658639f, -0.27022007f, 0.06772637f, 0.02089033f, 0.11395033f, 0.24993138f, 0.01693154f, 
    0.00635751f, -0.15879603f, -0.18439180f, -0.03033283f, -0.16395566f, -0.08623320f, 0.01303877f, 0.06107182f, 
    0.11786246f, -0.00334676f, -0.13247801f, -0.08845412f, 0.00718545f, 0.23983419f, 0.26100180f, -0.16620174f, 
    0.06315562f, -0.27367821f, 0.05203023f, 0.16530275f, 0.37321097f, -0.17955342f, -1.00989676f, 0.04457214f, 
    0.06664625f, -0.27055660f, -0.12030569f, -0.20814760f, 0.07223062f, 0.04877887f, 0.22823372f, -0.07643813f, 
    -0.07731745f, 0.00603627f, -0.18394217f, 0.05083390f, -0.03768093f, -0.16168363f, 0.02838788f, -0.00741923f, 
    0.02022210f, -0.09225840f, 0.03140716f, -0.06910958f, -0.06002499f, 0.03914682f, -0.09607916f, -0.05372129f, 
    -0.06376662f, 0.08762041f, -0.04668745f, -0.14591515f, -0.00845302f, -0.07075109f, -0.08993156f, -0.00850882f, 
    0.04495620f, -0.18455905f, 0.00476322f, -0.00953750f, -0.10948926f, 0.09346187f, 0.03887086f, 0.07122601f, 
    0.00395620f, 0.06237141f, -0.20715506f, 0.04168240f, -0.07101265f, 0.09485330f, -0.07095604f, 0.06597434f, 
    -0.11889283f, -0.04979907f, -0.06339338f, 0.03672873f, 0.14020255f, 0.04495122f, 0.08168507f, -0.13161311f, 
    -0.00820951f, 0.05062928f, 0.01855146f, -0.02976808f, 0.00249972f, -0.08029759f, -0.09394555f, -0.05711711f, 
    0.01352377f, 0.07551136f, -0.00046648f, -0.10579916f, -0.06969726f, -0.00590944f, -0.03590221f, -0.02869591f, 
    0.04328793f, 0.05346521f, 0.04588977f, -0.00339854f, 0.02618621f, -0.04206421f, -0.09564075f, -0.04767194f, 
    -0.03400322f, 0.01572399f, 0.00242496f, 0.04145135f, -0.01689767f, -0.01945515f, -0.10766926f, 0.02519118f, 
    -0.02535553f, -0.02601416f, 0.08908418f, -0.03659324f, 0.04929355f, 0.09707602f, -0.11657428f, 0.05817436f, 
    0.02274674f, -0.05702894f, -0.06881674f, 0.02863577f, -0.04388921f, -0.16753401f, -0.09845404f, -0.11891100f, 
    -0.02180637f, -0.07523925f, 0.05209429f, 0.05172933f, 0.02056660f, -0.07348345f, -0.02093714f, -0.07198348f, 
    -0.02302867f, -0.19649059f, -0.11459973f, 0.07692609f, -0.08957012f, 0.10793453f, -0.04642995f, -0.06352532f, 
    -0.11529326f, -0.02170632f, -0.03166807f, 0.03392942f, 0.05447408f, 0.16985439f, -0.01048115f, -0.20175365f, 
    -0.10059864f, -0.02898377f, -0.01946116f, -0.11605917f, -0.03501432f, 0.07735825f, -0.04594192f, -0.01689781f, 
    0.01207258f, 0.21961640f, -0.05381041f, -0.02754225f, 0.00356423f, 0.15778628f, 0.00041202f, -0.22393116f, 
    0.11157416f, -0.11708709f, 0.00183260f, 0.42167509f, 0.02068217f, 0.29499495f, 0.15560305f, -0.03222070f, 
    0.00434989f, -0.08222715f, 0.05757271f, -0.09198839f, 0.01420617f, 0.01451579f, 0.41144630f, 0.01584516f, 
    -0.05044839f, 0.02575128f, 0.05576796f, -0.21610376f, 0.07458755f, -0.46258399f, 0.07048909f, 0.35456726f, 
    -0.01290517f, -0.23040816f, 0.21645738f, -0.00734398f, 0.17003416f, -0.09269968f, 0.07065621f, 0.09128652f, 
    -0.10370060f, -0.15931857f, 0.09789000f, -0.07248560f, -0.86898106f, 0.15071574f, -0.04399005f, 0.35677221f, 
    0.19589031f, 0.01989883f, -0.05939653f, -0.14168626f, 0.09945296f, 0.20461215f, 0.10904664f, 0.11169957f, 
    -0.19927284f, 0.12512824f, -0.17099912f, -0.35582289f, -0.08174831f, 0.16410717f, -0.09715337f, -0.00332244f, 
    0.25901729f, 0.07512114f, 0.06061943f, -0.01707919f, -0.05576824f, -0.09850261f, 0.08350178f, -0.01947858f, 
    -0.01418276f, 0.05477294f, 0.22669519f, -0.07402305f, 0.08976913f, 0.05710819f, 0.09104229f, 0.26743677f, 
    -0.34415099f, -0.01899369f, 0.10423774f, -0.04362160f, -0.44963840f, -0.05466671f, 0.08592206f, -0.12267540f, 
    -0.02401619f, 0.20880625f, 0.06758700f, -0.03067156f, 0.20696642f, 0.14046727f, 0.14347191f, 0.07598104f, 
    -0.11186600f, 0.27260742f, 0.02316955f, 0.05581430f, -0.28376520f, 0.09336735f, 0.07646301f, 0.00631262f, 
    0.13224427f, 0.10812128f, -0.29448628f, -0.26676878f, 0.00521334f, 0.47894850f, 0.05938455f, 0.00819079f, 
    0.17557429f, -0.09514893f, 0.19332960f, -0.11023620f, 0.14807992f, -0.05414290f, -0.29850426f, -0.28071454f, 
    0.14847672f, 0.22074132f, -0.08575238f, -0.00007414f, -0.07800234f, 0.04387287f, 0.14534551f, -0.22691816f, 
    0.23382214f, 0.17033987f, -0.19601898f, 0.44292364f, 0.03207647f, 0.08301388f, -0.00745742f, -0.18016966f, 
    0.09582862f, 0.13822502f, -0.04126428f, -0.06286473f, -0.00076008f, 0.38748190f, 0.23370209f, -0.06952900f, 
    0.03997350f, 0.05196304f, 0.35420683f, 0.11582489f, -0.34358439f, 0.19640157f, -0.02907668f, 0.01120150f, 
    0.00927649f, -0.03107332f, 0.03117263f, 0.14371753f, 0.13933432f, 0.26109728f, 0.04333100f, 0.13804448f, 
    0.05879902f, 0.00469846f, -0.10139293f, -0.07097281f, 0.04208139f, 0.10621583f, 0.02280200f, 0.56889886f, 
    -0.09078670f, -0.09798812f, 0.01899403f, -0.06971686f, -0.32077363f, 0.08134636f, 0.00420321f, 0.16733539f, 
    0.17984109f, 0.10482750f, -0.05628664f, -0.19910303f, -0.09686426f, -0.17145862f, -0.28709620f, 0.05391278f, 
    -0.24059513f, 0.01447276f, -0.00432830f, -0.03993203f, -0.07199432f, -0.29389918f, 0.20400247f, -0.07941373f, 
    -0.07431237f, -0.01845510f, 0.35710651f, -0.31129754f, 0.09192389f, 0.03270634f, 0.01369542f, 0.18213904f, 
    0.02297290f, 0.14490776f, 0.30155554f, -0.27632087f, 0.25845456f, 0.11261416f, -0.13925643f, 0.00442415f, 
    -0.23286775f, 0.05092317f, 0.13765328f, 0.23986873f, -0.14091218f, 0.20386580f, -0.10326622f, 0.02004660f, 
    -0.05987398f, -0.10814983f, 0.24503109f, -0.08802415f, 0.09849039f, 0.01951940f, 0.21672760f, -0.18266806f, 
    -0.02675660f, -0.02079503f, 0.18391506f, -0.00146559f, 0.20785490f, 0.11193530f, -0.30959815f, 0.12058335f, 
    0.22733295f, -0.18716383f, -0.07513992f, -0.09447370f, 0.19039595f, 0.13587861f, 0.08036356f, -0.07742023f, 
    -0.05979446f, -0.11900917f, -0.01297082f, 0.16049190f, 0.28689396f, -0.19144724f, -0.87664348f, 0.04358769f, 
    -0.05398361f, -0.07913179f, -0.13531375f, 0.04462260f, 0.08584645f, 0.06562851f, 0.05193344f, 0.13836375f, 
    0.06621150f, 0.01289068f, 0.34094855f, 0.00899963f, 0.01653906f, 0.08230458f, 0.00927032f, -0.32865438f, 
    0.23426966f, -0.00416238f, 0.21875614f, -0.00513599f, -0.18930875f, 0.29024622f, 0.21228816f, 0.00686898f, 
    -0.07803689f, 0.33743390f, 0.06829049f, 0.12369255f, 0.03368086f, -0.02117396f, 0.06892486f, -0.05123264f, 
    0.09751708f, 0.09687122f, -0.00636710f, 0.13505258f, 0.02354540f, 0.24969718f, -0.02029126f, -0.19155346f, 
    0.03705261f, -0.15456803f, 0.31707242f, 0.00594016f, 0.15180500f, 0.13847215f, -0.01811186f, -0.32641417f, 
    0.21298030f, -0.00229999f, -0.17713386f, -0.23792613f, 0.21856508f, 0.00062908f, -0.52817094f, -0.06906163f, 
    -0.07895713f, 0.05535595f, 0.02134208f, 0.15776458f, 0.09894095f, 0.20924948f, -0.01738607f, -0.10087381f, 
    -0.49513453f, -0.17492326f, -0.04645328f, -0.03547215f, 0.10521782f, 0.02681471f, 0.19659768f, 0.35486445f, 
    0.01334698f, -0.00996681f, -0.18672840f, -0.17306092f, 0.01783660f, 0.12429854f, -0.04854837f, 0.04475414f, 
    -0.17113630f, 0.18838035f, -0.13697803f, -0.04090925f, -0.07297952f, 0.23449236f, 0.29924384f, 0.04519478f, 
    -0.39814124f, -0.26552317f, 0.03394967f, 0.03861418f, 0.07971132f, -0.11822369f, 0.11016324f, -0.03480733f, 
    0.05205300f, 0.19137828f, 0.07176069f, -0.02758082f, 0.28151450f, 0.10348287f, 0.17724152f, -0.17420377f, 
    -0.22797330f, 0.18200895f, 0.13590865f, -0.01377780f, 0.18581791f, 0.13507748f, -0.30167463f, -0.21253411f, 
    0.18024163f, 0.32755035f, -0.10330231f, -0.21585496f, -0.29277283f, -0.05344277f, -0.09985029f, 0.08267408f, 
    0.25917724f, -0.31899497f, 0.06178034f, -0.30178520f, -0.18549250f, 0.11183377f, 0.12827444f, 0.07345612f, 
    0.04275157f, -0.16194755f, 0.14114346f, 0.04544387f, -0.24570224f, -0.21950465f, -0.28120938f, 0.27669123f, 
    -0.07346953f, -0.09961832f, 0.04020146f, 0.01762357f, -0.01404258f, -0.09397417f, -0.04935995f, -0.04905917f, 
    -0.05194690f, -0.03350010f, -0.05014680f, -0.10645665f, -0.01716430f, -0.04143205f, -0.01822034f, -0.06616849f, 
    0.08657009f, 0.01472756f, -0.06449513f, 0.01345198f, -0.00785586f, -0.00565859f, -0.10821757f, 0.07227857f, 
    -0.09890951f, -0.04228100f, 0.04635690f, 0.05585292f, -0.09930660f, -0.02809534f, -0.00594956f, 0.01632538f, 
    -0.03855438f, -0.01153780f, 0.00629224f, 0.08063976f, -0.02872420f, -0.01840507f, 0.08218621f, -0.06539805f, 
    -0.07157565f, 0.05624985f, 0.05719422f, 0.02321449f, -0.03773115f, -0.02788956f, 0.06221471f, -0.08435397f, 
    -0.00280196f, 0.06187766f, 0.01343604f, 0.03865913f, -0.10721496f, 0.01738356f, -0.03302626f, -0.06297079f, 
    0.02405406f, -0.09718081f, -0.00409975f, -0.05415917f, -0.00142747f, 0.02138584f, -0.08615772f, 0.05656469f, 
    -0.09921812f, -0.06795229f, -0.10022453f, -0.10239007f, -0.01725772f, 0.05252489f, 0.04170677f, -0.00239631f, 
    -0.00669048f, -0.09101937f, -0.01613648f, -0.05145198f, -0.07396543f, -0.06023270f, -0.00230571f, -0.11929217f, 
    -0.03966152f, -0.07193403f, -0.08433396f, -0.09137925f, 0.06889994f, 0.01166397f, -0.04932979f, 0.05658698f, 
    -0.04899111f, -0.02423283f, 0.05592263f, -0.03722712f, -0.09910899f, -0.09535988f, 0.03216210f, 0.01017152f, 
    -0.08176553f, -0.03065073f, 0.01517647f, 0.02253200f, -0.05006706f, -0.08258224f, 0.02221213f, -0.07828733f, 
    -0.10217878f, 0.05641557f, 0.00319556f, -0.09551005f, -0.09495846f, 0.02523164f, -0.09058499f, -0.02280873f, 
    -0.08495270f, -0.01686989f, -0.02146326f, -0.00465811f, -0.05359809f, 0.07238242f, -0.07911923f, -0.10207286f, 
    -0.10495169f, -0.06266426f, -0.09936994f, 0.00773500f, 0.00815188f, 0.00222656f, 0.05483209f, 0.04486679f, 
    -0.32439530f, -0.05302970f, -0.09314507f, -0.00582808f, -0.33962521f, 0.24622710f, 0.03921177f, 0.56074339f, 
    -0.46594599f, -0.07294598f, 0.15295054f, 0.18633266f, 0.24877919f, 0.04621821f, 0.15087287f, -0.00391321f, 
    -0.04414077f, -0.31211734f, -0.24871089f, 0.04008152f, -0.41421509f, 0.03148208f, 0.00272695f, -0.08787936f, 
    0.03006678f, 0.12891464f, -0.05218127f, 0.19749089f, -0.14966913f, 0.07612580f, -0.07675234f, 0.17265747f, 
    -0.03179459f, -0.13169457f, -0.10674886f, 0.06627098f, -0.16484979f, 0.01814103f, 0.05195038f, 0.19713885f, 
    0.12189136f, -0.00635823f, 0.17101562f, 0.24110092f, -0.89534342f, -0.00953050f, 0.26351944f, -0.44304255f, 
    0.02990644f, -0.15645677f, -0.03900223f, 0.33758900f, 0.27091181f, -0.01848764f, 0.38287628f, 0.01616292f, 
    0.06901138f, 0.20903668f, -0.30012494f, 0.27982545f, 0.18318611f, 0.22410886f, -0.35687554f, 0.29989862f, 
    0.21764976f, -0.14992192f, -0.34006000f, 0.04082364f, 0.09502151f, -0.21868379f, 0.07104822f, -0.09650061f, 
    -0.03502394f, -0.20530166f, 0.24686778f, -0.43622833f, 0.10520887f, -0.09119073f, -0.02974938f, -0.24505228f, 
    0.10576878f, -0.04737049f, 0.10087848f, -0.49508974f, -0.06812324f, 0.13319209f, 0.07775132f, 0.30869049f, 
    -0.05640873f, -0.01544066f, -0.01559878f, -0.04910273f, 0.06715865f, -0.10048711f, 0.19978969f, -0.23711549f, 
    -0.13261481f, 0.01733687f, 0.02599186f, 0.08202960f, -0.25053033f, -0.40019134f, -0.06285695f, 0.08511169f, 
    -0.37911734f, -0.03152518f, 0.12643370f, -1.15376174f, 0.14752305f, -0.22655162f, 0.08701570f, 0.11838254f, 
    -0.07773182f, 0.23836724f, 0.04122479f, 0.39425486f, -0.49766344f, 0.14660861f, 0.47589633f, 0.25635356f, 
    0.22589608f, 0.22087812f, 0.20872441f, -0.17034310f, -0.19863558f, 0.22471084f, -0.08605774f, -0.16885652f, 
    -0.04548917f, 0.11794983f, -0.17429370f, 0.43439624f, -0.06408210f, -0.09145415f, 0.02088861f, -0.31781369f, 
    0.23602402f, -0.19033018f, 0.00293851f, -0.01801695f, -0.04257703f, 0.53517258f, -0.09545179f, 0.05984696f, 
    0.06814977f, 0.01190066f, 0.09055018f, -0.21747136f, 0.38215035f, 0.12201232f, -0.04698373f, -0.01484019f, 
    0.11032780f, -0.05408976f, 0.02861140f, -0.08614857f, -0.02225103f, -0.00614513f, 0.01451254f, -0.14920093f, 
    -0.03396114f, 0.22677943f, 0.00812928f, 0.01734951f, 0.23786201f, 0.20798606f, -0.10499524f, 0.12070729f, 
    -0.00006059f, 0.06618446f, -0.34847060f, 0.09455951f, -0.15920952f, 0.02554383f, -0.21535417f, -0.09568753f, 
    -0.13235618f, 0.15610775f, -0.04910315f, -0.51237160f, 0.00459511f, -0.00777966f, 0.05391081f, -0.41987225f, 
    0.18221888f, 0.16626030f, 0.10436572f, -0.31485593f, 0.04278087f, -0.22980858f, 0.25683182f, -0.27433226f, 
    -0.10660730f, -0.00616683f, 0.14318261f, 0.15538242f, 0.07146627f, 0.05418241f, -0.19235648f, -0.21801674f, 
    0.41364914f, 0.24958690f, -0.37019709f, 0.31113717f, -0.08981865f, 0.09898554f, 0.11843518f, 0.10348567f, 
    0.42264274f, 0.09746436f, 0.13720287f, 0.57068157f, 0.23150164f, -0.03350983f, -0.12508591f, -0.29031786f, 
    0.09807359f, 0.13262597f, 0.08267957f, -0.06033360f, -0.08742261f, 0.02448274f, 0.07295368f, -0.14343518f, 
    -0.50683290f, 0.11415541f, -0.56597596f, 0.02234452f, -0.27668655f, 0.01455996f, 0.19766125f, -0.50304317f, 
    0.39809784f, -0.04611577f, -0.36145094f, 0.01132090f, -0.16169176f, 0.07157771f, -0.17047906f, 0.09296303f, 
    0.01231151f, -0.10031859f, -0.04219341f, -0.06467906f, 0.02425462f, -0.11919194f, -0.13658822f, 0.14488754f, 
    -0.42463791f, 0.38253036f, -0.26877308f, -0.13640061f, 0.01838434f, -0.86234552f, -0.17761397f, 0.09831867f, 
    -0.07754957f, 0.16593100f, 0.10196000f, -0.05932745f, 0.18520974f, -0.12198915f, -0.06898721f, 0.14118397f, 
    0.14957619f, 0.07975076f, -0.20954524f, -0.13161634f, -0.06270280f, -0.80110741f, -0.36622363f, 0.06881143f, 
    -0.08867631f, 0.20342813f, 0.19673052f, 0.32599708f, 0.34345210f, 0.11357594f, -0.02477087f, 0.00635048f, 
    -0.05088997f, 0.00675491f, 0.00595225f, -0.39624169f, 0.17849945f, 0.27126604f, 0.02994427f, 0.00717069f, 
    -0.03288446f, 0.14813535f, -0.10835092f, 0.05738824f, 0.00000190f, 0.01781793f, -0.01005394f, -0.26207370f, 
    -0.08378591f, -0.02701141f, 0.08634961f, 0.16301158f, 0.02898682f, 0.14399832f, -0.01505006f, 0.20051886f, 
    0.11864659f, 0.17596194f, -0.07183231f, -0.38131991f, -0.28455660f, -0.10058308f, -0.25241679f, 0.10499128f, 
    -0.20582637f, -0.08384167f, 0.21246220f, 0.00997014f, 0.19148600f, -0.06992370f, 0.16734843f, -0.00260765f, 
    -0.60414672f, 0.06942430f, 0.17077892f, -0.14907832f, -0.01853202f, 0.13131106f, 0.08229025f, -0.25725833f, 
    -0.21095783f, -0.14056703f, -0.44760650f, 0.01579318f, 0.13240644f, 0.17702769f, -0.16020326f, 0.08636010f, 
    0.57797760f, 0.17160581f, -0.17338012f, -0.06367462f, 0.07853247f, -0.00837268f, -0.08606346f, 0.08559511f, 
    -0.01865047f, -0.12287240f, 0.05337881f, 0.04940517f, -0.09415183f, 0.16395348f, -0.24211644f, 0.27277839f, 
    0.33957776f, 0.06955290f, -0.15281999f, 0.06687264f, 0.09946918f, 0.31500980f, 0.09624374f, 0.09572492f, 
    0.28147215f, -0.04454087f, 0.19486026f, 0.40782881f, 0.09134580f, -0.15411243f, 0.03230311f, -0.02294298f, 
    -0.22696346f, 0.00836070f, -0.15545736f, -0.07563209f, 0.20023192f, -0.22036579f, -0.35602021f, -0.05278480f, 
    -0.11301609f, -0.26470488f, -0.45264137f, 0.16090563f, 0.23165610f, 0.01970444f, 0.14473647f, 0.21864128f, 
    -0.07963835f, -0.06845483f, -0.07660944f, -0.05579754f, -0.07510697f, -0.02283262f, 0.01392615f, -0.00328499f, 
    0.01487415f, -0.06291538f, 0.03707799f, 0.05678611f, 0.01333607f, 0.08837342f, 0.00619319f, -0.05338510f, 
    0.08322983f, -0.00024416f, 0.04124282f, -0.01695125f, -0.01627129f, -0.10563558f, 0.07885119f, -0.02132610f, 
    -0.08104569f, 0.03041462f, -0.05442598f, -0.00922937f, -0.06685237f, -0.07120901f, 0.04890581f, 0.05082197f, 
    -0.07628202f, 0.02710444f, -0.11737806f, 0.02326163f, -0.11344161f, -0.07926635f, -0.07071841f, 0.01299333f, 
    -0.04030757f, -0.07197393f, 0.05625226f, -0.02123431f, -0.02267402f, -0.04687784f, -0.08423404f, -0.11606829f, 
    -0.04174778f, -0.07690509f, 0.05326101f, -0.04595543f, -0.10597630f, 0.03385356f, -0.07388200f, -0.02199506f, 
    -0.02038117f, 0.00115738f, -0.00858353f, 0.02232955f, -0.05008464f, -0.08488921f, -0.02128939f, -0.07487907f, 
    -0.05436224f, 0.07617379f, -0.05687227f, -0.09070281f, -0.04753276f, -0.08265247f, -0.07952084f, -0.07968146f, 
    -0.06725230f, 0.05977213f, 0.07843511f, 0.00979898f, -0.04823638f, -0.01596800f, -0.06493437f, -0.08397384f, 
    -0.07868029f, 0.04454497f, 0.00529561f, -0.10342617f, 0.01075448f, 0.01916414f, -0.05089422f, -0.01968349f, 
    -0.02608084f, -0.06378778f, -0.00312320f, -0.02027352f, -0.00593025f, -0.09520215f, 0.04315532f, 0.04907043f, 
    0.00784786f, -0.01744752f, 0.03860725f, 0.04755909f, -0.05531411f, -0.03693771f, 0.01675423f, -0.01806930f, 
    0.02074661f, -0.06184565f, -0.05398321f, -0.07327590f, 0.02292017f, 0.02148781f, -0.11026017f, 0.07032984f, 
    -0.08550674f, -0.01579415f, 0.00823130f, -0.08507884f, 0.01562115f, -0.00417766f, -0.00928085f, 0.04967013f, 
    -0.02035132f, -0.03137840f, 0.01887596f, -0.08263382f, -0.04154196f, -0.09560794f, 0.03048985f, -0.04956829f, 
    0.07301424f, -0.14907239f, 0.27364829f, 0.14232506f, -0.00406308f, 0.14028418f, 0.01993877f, -0.27616161f, 
    0.00756415f, -0.08824436f, 0.07221292f, 0.21256952f, -0.05383607f, 0.20539902f, 0.43249175f, 0.07725651f, 
    0.02112892f, -0.04195841f, 0.12157502f, 0.05017086f, -0.06265055f, -0.39665771f, 0.11909278f, 0.07767493f, 
    0.04153008f, 0.03272269f, 0.01345583f, -0.05821170f, 0.13682376f, -0.39708796f, -0.02762748f, -0.03294936f, 
    -0.03057039f, -0.34079692f, 0.40817243f, -0.08656077f, -0.02109610f, -0.32457811f, -0.04279382f, -0.07762316f, 
    0.00309086f, -0.20898415f, 0.12530927f, -0.51878476f, -0.54335195f, 0.01084455f, -0.25832474f, 0.26064837f, 
    -0.14209644f, -0.09592026f, -0.00061487f, 0.09407268f, 0.18994421f, 0.22549334f, 0.12128063f, -0.02474296f, 
    0.10590062f, -0.27969682f, 0.05301178f, 0.18753339f, 0.05568453f, 0.21577863f, -0.07950015f, 0.03475073f, 
    0.30935681f, 0.00767465f, -0.04998823f, -0.00309849f, 0.11683402f, 0.23762506f, -0.01842451f, 0.07551318f, 
    -0.35094020f, 0.18065514f, -0.03406945f, -0.11217521f, -0.01842793f, -0.00927124f, 0.18085797f, 0.10125385f, 
    -0.32891300f, -0.21547192f, -0.13287163f, -0.04010984f, -0.26277730f, -0.36356187f, 0.26590377f, -0.15524840f, 
    0.01468454f, 0.38678527f, -0.43345392f, -0.03736268f, 0.23775698f, 0.15808024f, 0.18344934f, 0.22015418f, 
    -0.17434074f, 0.23443201f, -0.02163524f, 0.02711114f, -0.25903702f, -0.17250612f, -0.09332477f, -0.08922934f, 
    0.24102536f, 0.30718341f, -0.09862319f, 0.08422271f, -0.04082415f, 0.27378702f, 0.13639417f, 0.18756109f, 
    0.30943450f, -0.21601067f, 0.11391086f, -0.49191448f, -0.08354595f, -0.00431852f, -0.61375606f, 0.07447100f, 
    0.06792542f, -0.15279104f, -0.03347446f, -0.08429022f, -0.23829460f, -0.32634515f, 0.00435653f, 0.09917237f, 
    0.05831094f, 0.35856554f, -0.44981113f, 0.15763400f, 0.23563391f, -0.07943229f, -0.02740603f, 0.03504881f, 
    0.41458490f, 0.06951665f, -0.06513418f, -0.15005411f, 0.12200689f, 0.24225461f, 0.22260469f, 0.00316421f, 
    -0.02306734f, 0.15616928f, 0.13457723f, 0.08712582f, -0.47507432f, 0.16768195f, 0.01500585f, -0.02243867f, 
    -0.16656506f, -0.12390883f, 0.05588321f, -0.07089399f, 0.03312718f, 0.16653898f, 0.02577990f, -0.03782908f, 
    -0.08683538f, 0.53164279f, -0.14887410f, 0.01897025f, -0.02108325f, 0.24083979f, -0.05285786f, 0.31522658f, 
    -0.03839186f, 0.02515730f, -0.34205186f, -0.49231011f, 0.06063126f, 0.11737096f, -0.18265504f, 0.05967312f, 
    0.13011232f, 0.12777233f, 0.04453241f, -0.19499926f, -0.27886242f, -0.05990501f, -0.18870965f, 0.02109097f, 
    0.38571796f, -0.24906802f, -0.04036831f, 0.03168195f, 0.33933565f, -0.03985914f, 0.12661983f, 0.15271631f, 
    0.14152059f, 0.04613062f, 0.20963641f, -0.35509133f, 0.00638745f, -0.02688302f, -0.08721650f, -0.04704914f, 
    0.22317480f, 0.19569032f, 0.28906843f, 0.10875248f, 0.17069153f, 0.09377111f, -0.03877496f, 0.23392327f, 
    -0.21286674f, -0.08630685f, 0.13652839f, 0.29476190f, -0.24361123f, 0.18263875f, -0.10651710f, -0.21646610f, 
    0.05778836f, -0.21609755f, 0.11487403f, -0.02230448f, -0.15770359f, 0.09716485f, -0.05395740f, -0.04291065f, 
    -0.05376294f, -0.05622678f, 0.37107736f, 0.07861052f, 0.37140185f, 0.14817552f, -0.09289622f, -0.19792043f, 
    0.19562151f, -0.20067295f, 0.06301633f, 0.33217117f, 0.00774864f, -0.13129647f, -0.03198855f, 0.06887018f, 
    -0.02482770f, 0.31556964f, -0.31147760f, -0.15818419f, 0.14082778f, -0.07985650f, 0.45446053f, -0.03657950f, 
    -0.16443610f, 0.10437580f, 0.09709221f, 0.31070480f, 0.00430936f, -0.03823739f, 0.18632220f, 0.12726341f, 
    -0.12772724f, 0.19575027f, -0.15381065f, -0.05251911f, 0.32221624f, 0.05795807f, -0.02528086f, 0.10961080f, 
    0.47353986f, -0.06116377f, 0.09219231f, -0.02636116f, -0.05703215f, 0.40640786f, 0.17718260f, 0.03757120f, 
    -0.08013708f, 0.02420489f, -0.17624737f, -0.07631732f, 0.07565840f, 0.00159572f, 0.22347704f, -0.05265116f, 
    0.12649232f, -0.21179019f, 0.04374472f, -0.20433713f, -0.16224459f, 0.59538656f, -0.07223939f, -0.04280529f, 
    0.04244265f, 0.42129567f, -0.34465411f, -0.08003961f, -0.15797256f, 0.25290456f, 0.06340666f, 0.18079764f, 
    0.11020040f, -0.02104221f, -0.01212385f, -0.00661471f, 0.40752211f, 0.24387451f, 0.16427843f, -0.09172357f, 
    -0.05229961f, -0.00478325f, 0.04355169f, -0.21330859f, -0.04660059f, 0.19136907f, -0.74623686f, 0.06614466f, 
    0.13417098f, -0.01715091f, -0.04316374f, -0.22094208f, 0.12005106f, 0.21405382f, 0.11112864f, 0.11958084f, 
    0.46743295f, 0.31678385f, 0.14808640f, 0.06063941f, -0.06273733f, -0.06570903f, -0.20405769f, -0.24422494f, 
    0.24612907f, 0.14856231f, 0.20911358f, 0.09668372f, -0.20516506f, 0.00904061f, -0.06835930f, 0.19844830f, 
    -0.23767352f, 0.11620060f, 0.30903590f, 0.03416381f, -0.43780777f, 0.15172002f, -0.39662293f, 0.07304266f, 
    0.08779104f, 0.16187133f, 0.21997234f, -0.03503286f, -0.80077249f, -0.44815165f, -0.43779159f, -0.09778067f, 
    0.16120359f, 0.20808142f, 0.08289716f, -0.07744932f, 0.20843896f, 0.26907063f, 0.06777335f, -0.14513747f, 
    0.00887829f, -0.03579954f, -0.19195159f, -0.02093951f, 0.01539456f, -0.10832164f, -0.22158329f, 0.14529307f, 
    0.13993454f, 0.43198308f, -0.05217057f, 0.06576298f, -0.07564456f, 0.06706570f, 0.28537816f, -0.31908640f, 
    -0.22948183f, 0.19976786f, 0.14179328f, 0.46643156f, 0.05518079f, -0.02122895f, -0.03644718f, 0.08228682f, 
    -0.11410870f, -0.09378766f, -0.02948282f, -0.08396287f, -0.07764360f, -0.00436154f, -0.06699871f, 0.02237779f, 
    -0.00078579f, -0.06873023f, -0.10995011f, 0.03136712f, 0.05438859f, -0.08250500f, 0.03218214f, -0.01155817f, 
    -0.06525578f, 0.05055775f, 0.08571311f, 0.07799549f, 0.10218667f, -0.09374496f, -0.10015023f, 0.05187229f, 
    -0.09358749f, 0.01540404f, -0.06397338f, -0.05836038f, -0.09390558f, -0.11155618f, 0.07495822f, -0.00045688f, 
    -0.03833947f, 0.07636330f, -0.02621910f, -0.08143738f, -0.01327173f, -0.07597523f, -0.02653872f, -0.08932525f, 
    -0.03925750f, 0.03236413f, 0.06283844f, -0.00663458f, -0.11318350f, -0.09730309f, -0.00499814f, 0.03153048f, 
    -0.05799292f, -0.03307672f, 0.04012200f, -0.02165861f, -0.10343167f, 0.01713546f, -0.01894520f, -0.01328396f, 
    0.03149297f, -0.08834541f, 0.03271743f, -0.06136557f, -0.10236464f, -0.02026500f, 0.01534049f, -0.06455123f, 
    0.03990026f, -0.02451836f, -0.09341121f, 0.10717124f, 0.03405768f, 0.08097559f, -0.02961225f, 0.02300097f, 
    0.05655007f, -0.02601009f, 0.01269150f, 0.08886073f, 0.03238696f, 0.03332012f, -0.03318423f, -0.08664413f, 
    -0.06521910f, -0.08464681f, -0.05471431f, 0.01270827f, 0.04739606f, -0.01974544f, 0.03377956f, -0.04711875f, 
    -0.00073499f, 0.06419346f, 0.04123801f, -0.04909630f, 0.02956748f, -0.00041558f, 0.05057223f, -0.04764089f, 
    -0.08160692f, -0.00779980f, -0.06409660f, -0.00867363f, -0.03010822f, -0.07715888f, 0.06806080f, -0.10513355f, 
    0.02535153f, -0.07189098f, -0.06139275f, -0.11086033f, -0.09049491f, -0.04873384f, -0.01225323f, 0.00074717f, 
    -0.04852894f, 0.01687938f, -0.05986830f, -0.06874670f, 0.03399191f, 0.08316836f, -0.08780821f, -0.02758133f, 
    -0.10655881f, 0.06447626f, -0.11408170f, -0.03766824f, -0.09439891f, 0.00881932f, -0.03295933f, -0.05275646f, 
    -0.36752346f, -0.07408485f, -0.07664613f, -0.36887667f, -0.23792113f, 0.10692611f, -0.00474799f, 0.15354377f, 
    -0.10652763f, -0.06687701f, 0.01001198f, 0.17395273f, -0.11127341f, -0.01070399f, -0.05016100f, 0.04088658f, 
    -0.04781372f, -0.36832190f, -0.05637494f, 0.19497025f, -0.33944201f, 0.05965862f, 0.12187787f, 0.01790204f, 
    -0.07292669f, 0.10793280f, 0.04389648f, 0.06284542f, 0.03380614f, 0.07499038f, -0.00935190f, 0.07647491f, 
    0.00191629f, 0.08048274f, -0.00126180f, -0.05110422f, -0.14188503f, -0.12718472f, 0.04865133f, -0.19996879f, 
    0.22059371f, -0.02840188f, 0.04891968f, 0.37963584f, -0.52150220f, -0.14045519f, 0.21710856f, -0.21261470f, 
    -0.11873272f, 0.03024598f, -0.08389024f, 0.22615664f, 0.17702562f, 0.03491301f, 0.22741200f, -0.10528556f, 
    0.04005817f, 0.14066289f, -0.12857078f, 0.29083544f, 0.13672553f, 0.15575914f, -0.27602014f, 0.24437213f, 
    0.14520480f, -0.12945311f, -0.29587984f, 0.19514002f, 0.04136018f, -0.17354864f, 0.05507095f, -0.14076550f, 
    -0.19532105f, -0.13361600f, -0.01622753f, -0.25102907f, 0.11440223f, -0.00281662f, 0.20275265f, -0.20761621f, 
    0.27425411f, -0.26303035f, 0.08508986f, -0.52522177f, 0.10497823f, -0.08794620f, -0.01135509f, 0.16059117f, 
    -0.04667960f, 0.04547938f, 0.25169614f, 0.01326363f, -0.00402851f, -0.04800827f, -0.11042257f, -0.10509521f, 
    0.06443896f, 0.11527629f, -0.07186715f, -0.03613245f, -0.40306139f, -0.00393603f, -0.08322439f, 0.14825465f, 
    -0.28919163f, 0.14256725f, 0.21673349f, -0.81478751f, 0.00381673f, -0.20752600f, 0.01373264f, 0.15855609f, 
    -0.13763237f, 0.01197184f, 0.13002890f, 0.10244522f, -0.50294286f, -0.11340622f, 0.42575744f, 0.10619277f, 
    0.39538008f, 0.10686138f, 0.10836123f, 0.09064379f, -0.27067158f, 0.13614105f, -0.11214712f, 0.08929531f, 
    -0.13518018f, -0.04897758f, -0.00837019f, -0.06379991f, -0.00400594f, 0.04928167f, -0.07041171f, 0.22689858f, 
    -0.15193047f, -0.02959057f, 0.09741660f, -0.08825730f, -0.00496719f, 0.11067268f, -0.31982854f, 0.07294425f, 
    0.02860969f, 0.31990302f, -0.02182346f, -0.10721777f, 0.05684283f, -0.06478671f, 0.17309386f, -0.00298955f, 
    -0.26843029f, -0.18702194f, -0.01542720f, 0.21115494f, 0.05933297f, 0.11570808f, 0.02546306f, -0.15657216f, 
    -0.04298754f, 0.31580570f, 0.21548942f, 0.04873328f, 0.18650664f, 0.09142666f, -0.07114550f, -0.27438915f, 
    0.15341957f, 0.31714568f, -0.24361452f, 0.00366037f, 0.14786778f, -0.15563022f, -0.38731810f, -0.25163537f, 
    -0.11729757f, -0.10579617f, 0.01391960f, 0.09020054f, 0.14843759f, 0.12384839f, 0.53204989f, -0.18618667f, 
    -0.01655600f, 0.07466777f, 0.00885185f, -0.14036351f, -0.28547877f, -0.14059496f, -0.03604598f, -0.07557308f, 
    -0.26453590f, 0.02639626f, -0.18540521f, 0.26077113f, -0.01966023f, -0.37172726f, -0.10401423f, -0.02475544f, 
    0.29746327f, 0.05958771f, -0.09845233f, 0.39250976f, -0.10250862f, 0.08708106f, 0.20112757f, 0.07149874f, 
    -0.34283137f, -0.44782481f, 0.06325401f, 0.14507948f, 0.06634467f, 0.26509807f, 0.11119603f, -0.38688773f, 
    0.02472299f, -0.13054428f, 0.48086539f, -0.04362931f, 0.24760802f, 0.23562513f, 0.18777303f, -0.10060961f, 
    -0.60919541f, 0.07249199f, 0.21096648f, -0.07214265f, 0.14141707f, -0.32796815f, 0.05618344f, -0.33458716f, 
    -0.04079796f, 0.07499332f, 0.00491601f, -0.09922595f, -0.21028505f, -0.82956797f, 0.17034414f, 0.07389461f, 
    -0.11911436f, 0.21108432f, 0.18908998f, 0.03418513f, -0.15020178f, -0.04224279f, 0.78936726f, 0.12782161f, 
    -0.03400122f, 0.06187996f, 0.01673714f, -0.48307881f, -0.22132929f, 0.10028560f, -0.13936183f, -0.12813781f, 
    0.04714888f, -0.08815548f, 0.35963917f, 0.13165526f, -0.01679023f, 0.18377642f, 0.01680022f, 0.17362094f, 
    0.02268111f, -0.27560258f, 0.15333106f, 0.58094501f, -0.18535168f, 0.22214705f, 0.11350488f, -0.04219146f, 
    -0.08507612f, -0.34316951f, -0.21836111f, -0.09064134f, -0.04493424f, 0.06440994f, 0.07421013f, -0.05580803f, 
    0.25771251f, 0.09323232f, -0.00728480f, -0.37079704f, -0.04631947f, 0.09241211f, -0.00379497f, 0.00318251f, 
    -0.07575524f, -0.49839133f, -0.15239130f, 0.07097123f, -0.17408511f, 0.12655738f, -0.08692355f, 0.11441035f, 
    -0.04859728f, 0.11291071f, 0.26163578f, 0.02611678f, -0.10652369f, -0.05461979f, 0.16185185f, 0.02221827f, 
    -0.17086767f, 0.13009188f, -0.04492787f, 0.07894227f, 0.11159405f, 0.23970042f, -0.05918440f, -0.22467813f, 
    -0.25055787f, 0.14489633f, -0.20942840f, 0.06798713f, 0.11881090f, 0.22547628f, 0.04410625f, 0.34141183f, 
    0.34589159f, 0.02591253f, -0.16297594f, -0.15143020f, 0.00655724f, 0.15971543f, -0.11771753f, -0.13858800f, 
    -0.09920963f, 0.07554213f, 0.16762884f, -0.37217590f, 0.06075638f, -0.21194185f, -0.08631974f, -0.09173044f, 
    -0.57162321f, -0.06959400f, 0.12776028f, -0.15725017f, -0.12351655f, -0.07178264f, -0.26947558f, 0.39648923f, 
    -0.01264313f, 0.35606480f, 0.38260210f, -0.08817890f, -0.25037289f, -0.23194472f, -0.02224548f, -0.34762162f, 
    0.04669406f, 0.27070233f, -0.16491199f, -0.01030021f, -0.40472162f, 0.06730510f, -0.21872623f, 0.53501397f, 
    -0.09750233f, 0.24472636f, -0.21970482f, -0.28996429f, 0.07898550f, 0.48595732f, -0.34267548f, 0.18994929f, 
    0.02365800f, -0.12036742f, 0.12870277f, 0.21593517f, -0.47765759f, 0.27146491f, 0.21594380f, -0.00629961f, 
    0.19718403f, 0.28944039f, 0.19660611f, 0.45950484f, -0.00691521f, 0.10135362f, -0.25667775f, 0.06778384f, 
    -0.04845531f, 0.02267057f, -0.11879864f, -0.11872874f, -0.02041059f, 0.05835322f, 0.00981873f, 0.10769793f, 
    0.05325387f, -0.01777654f, -0.07508096f, 0.05083886f, -0.08939164f, -0.08979414f, 0.03953949f, 0.01875743f, 
    -0.05490353f, -0.03229935f, -0.06829726f, -0.03882087f, 0.00251265f, -0.07947219f, -0.04508497f, -0.07107846f, 
    -0.12023553f, -0.01372262f, 0.08825358f, -0.05904179f, -0.12621048f, 0.06791887f, 0.08089975f, -0.05411070f, 
    0.04128270f, 0.01490516f, -0.00946037f, 0.00805208f, 0.02455443f, -0.01484441f, -0.03685864f, 0.01694986f, 
    0.00226745f, 0.06821364f, -0.01156514f, -0.10312382f, 0.04228982f, -0.02007225f, 0.04354705f, -0.07667907f, 
    0.02186311f, 0.04041921f, -0.01236312f, 0.06564203f, -0.13241300f, 0.03966050f, -0.12770796f, 0.02060139f, 
    -0.11857638f, -0.08069598f, -0.07770615f, 0.06112323f, -0.05312739f, -0.02973053f, 0.01914616f, -0.00139150f, 
    -0.07120712f, -0.00850374f, 0.06801476f, -0.13818192f, -0.04838917f, 0.01647446f, 0.00690917f, -0.01161787f, 
    0.01371468f, -0.11077039f, -0.07929641f, 0.01389428f, -0.04751055f, -0.04540508f, -0.07435294f, 0.01134088f, 
    -0.02042532f, -0.02081880f, -0.07106438f, -0.06735976f, -0.09012191f, 0.00966522f, -0.09246154f, -0.04605655f, 
    0.05200408f, -0.06501742f, -0.10583989f, -0.05792054f, -0.03482389f, -0.01146589f, -0.14991325f, -0.06463151f, 
    -0.03498158f, 0.06634733f, 0.02003947f, -0.07126699f, 0.10206885f, -0.08705465f, -0.03201878f, -0.05324393f, 
    -0.09155518f, -0.02849535f, -0.03062312f, -0.02092416f, 0.06969707f, -0.02479860f, -0.00154968f, 0.04157787f, 
    0.05171631f, -0.09126984f, 0.00724464f, 0.00867498f, -0.07579345f, -0.08642096f, -0.04373559f, 0.04414245f, 
    -0.03589677f, 0.01134793f, -0.08558892f, 0.05690674f, -0.04136617f, 0.04080187f, -0.03978896f, 0.06604141f, 
    0.06049643f, 0.03855968f, 0.14548020f, 0.00459972f, 0.00623792f, 0.08914061f, -0.03899806f, 0.69069028f, 
    -0.02365925f, -0.03543172f, -0.00714172f, 0.16510080f, 0.07331396f, -0.07898275f, -0.08173139f, 0.03417240f, 
    0.02523494f, 0.03054938f, -0.25376067f, 0.05306619f, 0.18084732f, -0.05202886f, -0.09640928f, 0.03363980f, 
    0.02781877f, -0.01782129f, 0.02531710f, -0.08889487f, 0.09673329f, 0.26444903f, -0.03869172f, -0.24475278f, 
    0.04922579f, 0.29086816f, -0.11987887f, 0.05323469f, -0.28232780f, -0.12740484f, 0.00971818f, -0.03261860f, 
    -0.09111521f, 0.02028274f, 0.24794199f, -0.00326946f, 0.61655688f, 0.08419848f, 0.21669739f, -0.18259037f, 
    -0.06077674f, 0.08379222f, -0.06514256f, -0.03884591f, 0.03642324f, 0.09837868f, 0.14602643f, -0.00313262f, 
    0.46244058f, -0.13707836f, 0.08118361f, 0.34095231f, 0.17907988f, 0.25549042f, -0.12553461f, 0.05050708f, 
    0.00244409f, -0.08677925f, 0.13098262f, 0.02034588f, 0.06154045f, 0.22788729f, -0.15344797f, -0.18721266f, 
    0.15549122f, -0.10532957f, -0.26873049f, 0.03105798f, -0.15711966f, -0.21832518f, -0.13788190f, -0.06048157f, 
    0.38238150f, 0.20743953f, -0.05627821f, -0.10054956f, 0.26010844f, -0.14087489f, -0.09907439f, 0.15328585f, 
    -0.09897585f, 0.28946161f, -0.25509688f, -0.05256794f, -0.32602543f, -0.06377041f, -0.17102125f, 0.04323407f, 
    0.18845989f, 0.00398134f, -0.24213061f, -0.00450277f, -0.03487900f, 0.05011152f, 0.02357629f, -0.14712302f, 
    -0.12018610f, -0.03534339f, 0.22663352f, 0.47128698f, 0.01725786f, 0.07411303f, -0.13720441f, 0.14933881f, 
    0.02864342f, 0.71003252f, -0.03865371f, 0.03303143f, -0.12848957f, 0.16225585f, 0.65687209f, 0.08778579f, 
    -0.08774137f, 0.30126101f, 0.03909261f, 0.21309415f, 0.02996676f, -0.13672784f, 0.00948353f, 0.08182721f, 
    0.05683805f, 0.11384408f, -0.13166094f, -0.12625752f, 0.16530043f, -0.00863234f, 0.00845726f, -0.06084268f, 
    0.16681531f, -0.04523539f, 0.11271039f, -0.00232909f, 0.30813584f, 0.31294152f, 0.00947735f, -0.00330740f, 
    -0.03627216f, 0.02953151f, 0.05551864f, -0.16523273f, -0.22814868f, -0.03274884f, 0.19044119f, -0.02087467f, 
    -0.04863463f, -0.17831810f, 0.04112053f, 0.15391231f, 0.01360804f, -0.20796633f, 0.00866631f, -0.01341541f, 
    -0.02199724f, 0.28114355f, -0.06027894f, 0.05595383f, 0.03961824f, -0.17136720f, 0.08910178f, 0.26928359f, 
    -0.04863686f, -0.02679600f, -0.01752472f, -0.34254593f, 0.20532893f, 0.13270439f, 0.04471915f, 0.11367703f, 
    0.00653182f, 0.02270741f, 0.01515063f, -0.03781516f, -0.00623148f, 0.11264564f, 0.03525429f, 0.06957482f, 
    0.36303356f, -0.18265307f, 0.02932712f, -0.05088444f, -0.10078287f, 0.16108842f, 0.05328327f, -0.28209767f, 
    0.26800153f, 0.23444074f, 0.20377402f, -0.09130507f, -0.04798805f, -0.03278136f, 0.06822484f, 0.08770737f, 
    0.24714427f, -0.00422403f, 0.28160420f, 0.22481938f, -0.14906043f, 0.04214358f, 0.07672133f, 0.20599467f, 
    -0.23930605f, -0.03086498f, 0.13599283f, 0.10341220f, -0.34997317f, 0.16074429f, -0.02583242f, -0.17969547f, 
    0.09576941f, 0.00655571f, -0.24745066f, -0.05989688f, -0.11990358f, -0.04588969f, 0.24942178f, -0.01219778f, 
    -0.03279245f, -0.09584071f, 0.14801610f, -0.01935193f, 0.03339456f, -0.12635136f, 0.20784986f, -0.18791556f, 
    -0.00191200f, -0.02500920f, -0.06612609f, 0.29574928f, -0.08154965f, 0.17147110f, 0.17393397f, 0.03269893f, 
    0.20767824f, 0.28286257f, 0.00545487f, -0.13869043f, 0.11746351f, -0.07414328f, 0.12501317f, 0.00348708f, 
    -0.22738245f, 0.04404968f, 0.17527230f, 0.05390659f, -0.04163137f, 0.03374499f, 0.21559389f, -0.20674212f, 
    -0.10077827f, -0.03002125f, 0.05323570f, 0.00285577f, -0.06778557f, -0.00200802f, -0.08177310f, 0.05764853f, 
    0.01306310f, -0.00112277f, -0.01545972f, 0.00137974f, -0.05185097f, -0.01195150f, 0.04144099f, 0.07488394f, 
    -0.03290172f, -0.09618650f, -0.09016216f, 0.03198766f, 0.05336767f, -0.04968395f, 0.06615096f, -0.06381317f, 
    -0.07272195f, 0.03836914f, 0.06581526f, -0.01603450f, 0.05695986f, 0.04296146f, 0.03254931f, -0.02729767f, 
    -0.08325906f, 0.00118267f, -0.08741694f, -0.05974064f, 0.05261976f, 0.04642880f, -0.01180481f, 0.01806406f, 
    -0.10291836f, 0.06405697f, 0.02583122f, 0.03481562f, -0.01217196f, -0.01872959f, -0.08407849f, -0.10716888f, 
    -0.06647179f, -0.07274263f, -0.07207862f, -0.03455365f, 0.01170434f, -0.01469116f, -0.00108267f, 0.04434280f, 
    0.05790085f, -0.03038950f, -0.07799322f, 0.04798887f, 0.03451126f, -0.00937627f, -0.01891455f, 0.00154523f, 
    -0.01801447f, 0.01092564f, -0.01462726f, -0.01299419f, -0.04874529f, 0.00100088f, 0.02330851f, 0.03618950f, 
    -0.03752570f, -0.05626687f, -0.05404679f, -0.10497326f, -0.03536116f, -0.11019250f, -0.06629106f, 0.03062660f, 
    -0.02457117f, -0.07052258f, -0.04681134f, -0.05320693f, -0.04617719f, -0.03509978f, -0.01157137f, -0.02234205f, 
    0.02610010f, 0.02957553f, -0.00710703f, 0.07910804f, 0.03857706f, 0.05597000f, -0.09718999f, -0.07310030f, 
    -0.03325149f, -0.03558184f, 0.03713932f, -0.01323288f, 0.05867455f, -0.08086365f, 0.01351025f, -0.01052639f, 
    -0.04283521f, -0.05649274f, 0.02753416f, 0.07506905f, -0.10874320f, 0.07384139f, 0.05885411f, -0.05351442f, 
    0.04018314f, 0.02225271f, -0.00751177f, -0.06120042f, -0.08209211f, 0.08095576f, -0.01978404f, 0.01987907f, 
    -0.00115967f, -0.00452484f, -0.03347060f, 0.04730726f, 0.00445981f, 0.04854592f, -0.08349422f, 0.06055732f, 
    0.11808120f, 0.20451017f, 0.12025555f, 0.22624701f, 0.17225680f, -0.12391359f, 0.02063612f, -0.45981938f, 
    0.05951569f, 0.10531259f, 0.09489426f, -0.05177352f, 0.05014159f, 0.15418619f, 0.07253914f, -0.02253634f, 
    0.03461165f, -0.10869892f, 0.36788556f, 0.06586907f, -0.14394160f, 0.20355959f, -0.05930258f, -0.05794355f, 
    0.20387918f, -0.17629081f, -0.06804755f, -0.07229728f, 0.19976886f, 0.61700159f, 0.01922488f, 0.07622969f, 
    0.08782358f, -0.05626696f, -0.23715638f, -0.06556999f, 0.06135546f, 0.22143304f, 0.03012706f, 0.28150415f, 
    -0.02786538f, 0.00610596f, 0.12924123f, 0.11837881f, 0.34231788f, 0.08165999f, 0.35513237f, 0.10109417f, 
    0.33249223f, 0.07462759f, -0.07041781f, -0.03520982f, 0.00952379f, -0.10779797f, -0.39895523f, -0.02591071f, 
    -0.06937952f, 0.11255206f, 0.22016600f, -0.12057786f, -0.03197543f, -0.08731576f, 0.17427659f, -0.25516710f, 
    -0.07346115f, 0.18161492f, 0.38239741f, 0.00139546f, -0.01618893f, 0.16567938f, 0.05208788f, 0.17855479f, 
    0.16563353f, -0.04393522f, 0.16281421f, -0.03401081f, 0.00327115f, -0.04466101f, -0.06125791f, 0.00522217f, 
    0.03241709f, 0.23702566f, -0.07876225f, -0.06738767f, -0.30198219f, 0.28577134f, -0.16180742f, 0.27975821f, 
    0.11281134f, -0.00073666f, -0.57763785f, 0.07880572f, -0.45872104f, -0.04184239f, -0.02391618f, 0.07718626f, 
    0.14594659f, -0.02657109f, -0.01775271f, -0.00389119f, -0.01615785f, 0.20819287f, -0.20594764f, 0.10840436f, 
    0.11183671f, -0.01215415f, -0.09911353f, 0.20708266f, 0.17013249f, -0.11308500f, 0.11188321f, -0.02238465f, 
    0.07303472f, -0.24438059f, -0.04674608f, 0.21636635f, 0.34782225f, -0.11670237f, -0.50311065f, 0.02907241f, 
    -0.14966944f, -0.07829995f, -0.00154014f, 0.14319447f, 0.03199773f, 0.05463270f, 0.14496420f, -0.14207712f, 
    -0.20887248f, 0.20071159f, -0.06829078f, 0.40621749f, -0.00588829f, 0.04354158f, -0.00623829f, -0.13495810f, 
    0.05911301f, -0.01462600f, 0.11467408f, -0.16783173f, -0.02661443f, 0.05228873f, -0.47033721f, -0.03649237f, 
    0.00365772f, 0.27744898f, -0.04366912f, -0.11019576f, 0.26900035f, 0.26451772f, 0.05394191f, 0.08549226f, 
    0.12252074f, -0.06413598f, 0.04485203f, -0.10822177f, -0.06498554f, 0.71469784f, -0.03578101f, -0.09854776f, 
    -0.05037057f, 0.42842248f, -0.22525363f, 0.02815224f, 0.22508745f, 0.41165522f, 0.01818560f, 0.06386706f, 
    0.17118511f, 0.22023448f, -0.19327746f, 0.25418285f, 0.46275449f, 0.12736447f, 0.12551017f, -0.33789074f, 
    -0.04492993f, 0.10179819f, 0.06013766f, -0.41473347f, 0.14610201f, 0.09835576f, -0.12123646f, -0.06028708f, 
    0.24781229f, 0.29562184f, 0.10337394f, 0.02509285f, -0.14660783f, -0.34883451f, 0.30236617f, -0.05902997f, 
    -0.26843804f, 0.10582253f, 0.18761535f, 0.25313294f, -0.05929140f, -0.08768696f, -0.18369073f, -0.31298232f, 
    0.68601501f, 0.26124349f, 0.03449924f, 0.23852468f, -0.04631667f, 0.09421531f, -0.08187220f, 0.17331606f, 
    -0.01019383f, 0.08308034f, 0.27262649f, 0.53819019f, 0.35481855f, 0.24803574f, -0.23686451f, 0.06352712f, 
    -0.01543062f, 0.06544132f, 0.59680152f, -0.07426432f, -0.53190190f, -0.12723602f, -0.09512149f, -0.14885010f, 
    -0.01930560f, 0.06902680f, -0.04715987f, -0.03945740f, 0.39142016f, 0.16497873f, 0.09290864f, -0.15923332f, 
    0.19038102f, -0.06927633f, -0.07393692f, -0.37462929f, 0.11660990f, -0.13071173f, -0.17295648f, 0.06063958f, 
    -0.24943309f, -0.47142473f, 0.05492445f, 0.31608263f, -0.16032612f, -0.15378863f, -0.17954764f, 0.04889314f, 
    -0.34062290f, 0.16410092f, -0.19654125f, -0.11087453f, 0.11397240f, -0.07611667f, -0.11846527f, 0.23587848f, 
    -0.02736009f, -0.05373337f, -0.04638782f, 0.04842605f, 0.06250505f, -0.01498177f, -0.00376601f, -0.07817458f, 
    -0.03903966f, -0.05955415f, -0.04682634f, 0.06010338f, -0.09588497f, -0.05097184f, -0.07569543f, 0.01002914f, 
    -0.05189457f, -0.06331250f, 0.02390823f, 0.03271445f, -0.08825069f, -0.07313006f, 0.03430454f, 0.00773514f, 
    -0.09949405f, -0.06745150f, 0.07029185f, 0.04658703f, 0.00744771f, -0.05745553f, -0.03166138f, 0.04688704f, 
    -0.07643788f, -0.06906197f, 0.03430359f, -0.07672673f, -0.04526458f, -0.07137462f, -0.04663928f, -0.06110944f, 
    -0.08337993f, 0.06084481f, -0.00142245f, -0.05612985f, 0.08425938f, -0.04169421f, 0.03818717f, -0.05304962f, 
    -0.06977955f, -0.09925476f, 0.07167348f, -0.01496152f, -0.08752975f, -0.07942002f, -0.06332070f, -0.03670214f, 
    -0.07870446f, -0.03329030f, -0.01574532f, 0.00326798f, 0.05587808f, -0.06786725f, -0.06449926f, 0.00992549f, 
    0.04180332f, 0.04001841f, 0.03110688f, 0.05187838f, -0.00907225f, 0.02787055f, -0.10775104f, 0.07302292f, 
    0.02577328f, -0.07718545f, -0.05738767f, -0.08979791f, 0.07331997f, -0.01217975f, -0.04796020f, 0.07566977f, 
    0.02944400f, 0.00084146f, -0.03185309f, 0.00061875f, -0.03136514f, 0.05957757f, 0.07258629f, -0.10423130f, 
    0.05797870f, 0.00230601f, -0.01533690f, -0.07888981f, -0.08238270f, 0.06460539f, 0.03456028f, -0.03199727f, 
    -0.00065036f, -0.05363568f, -0.05582032f, 0.02712238f, -0.03549577f, 0.02675569f, -0.05204381f, 0.04977771f, 
    -0.06124794f, 0.06269400f, -0.00488080f, -0.00337568f, 0.02635476f, -0.04221366f, 0.00212825f, -0.03234938f, 
    -0.02482506f, -0.06783895f, -0.07414072f, -0.04456067f, -0.01535934f, -0.01439503f, 0.04509113f, 0.01149451f, 
    0.05914330f, 0.03422038f, 0.01691136f, -0.03946050f, 0.05604136f, -0.05059887f, 0.02686592f, -0.03664386f, 
    -0.06002636f, -0.04977915f, 0.05265819f, -0.08919520f, -0.01912135f, -0.05110690f, 0.08082379f, 0.02881743f, 
    -0.05506368f, -0.03839304f, -0.05167128f, 0.01651910f, 0.05403284f, -0.05857561f, -0.07012172f, 0.08193696f, 
    -0.02895046f, -0.00004745f, -0.05787071f, -0.10298743f, 0.01351339f, -0.02087419f, 0.02519553f, -0.04647669f, 
    -0.01047144f, 0.03706789f, 0.08753266f, -0.10986900f, -0.06131310f, 0.04124714f, 0.07192530f, -0.06630925f, 
    0.06079826f, 0.02292615f, -0.04812128f, 0.08426032f, 0.05086475f, -0.00080004f, -0.04464718f, -0.08713890f, 
    0.01658923f, 0.03848158f, -0.02455901f, -0.02201783f, -0.05492738f, 0.00939421f, -0.10473593f, 0.05228778f, 
    -0.06690405f, -0.03219476f, -0.01839771f, -0.07929297f, -0.07796917f, 0.06633989f, -0.00796914f, -0.00170678f, 
    -0.07492978f, 0.04044013f, -0.06550124f, 0.00198872f, -0.07915692f, -0.03408139f, -0.01215521f, -0.05594039f, 
    -0.09046160f, -0.03421992f, -0.00936512f, -0.01433320f, 0.04649926f, 0.01734555f, 0.05203154f, 0.06145267f, 
    -0.04336589f, -0.09933976f, 0.03216973f, -0.03316892f, -0.02909997f, -0.09462814f, -0.10669611f, -0.02234133f, 
    -0.06657694f, 0.02635712f, 0.00609599f, -0.09862557f, -0.07214493f, -0.00558865f, -0.03479443f, 0.06225581f, 
    0.08582581f, 0.03909902f, 0.00506922f, 0.00087732f, -0.03138891f, 0.04547116f, -0.05447665f, 0.01047444f, 
    -0.06392734f, 0.00646302f, -0.04110633f, 0.02812933f, 0.02412372f, 0.00417608f, 0.03093816f, -0.08302047f, 
    -0.07341874f, -0.08761226f, 0.00948988f, -0.05936528f, 0.03156012f, -0.02031682f, -0.00621642f, -0.08467668f, 
    -0.02880962f, -0.08394639f, 0.04038732f, -0.03045321f, -0.09509537f, -0.01590315f, -0.06058277f, -0.05787697f, 
    0.07869993f, -0.05296965f, 0.06220134f, -0.09032546f, -0.09319712f, -0.08510859f, -0.08342296f, -0.07917792f, 
    -0.10867429f, 0.03170095f, -0.04695949f, 0.03781642f, -0.00793406f, -0.08895744f, 0.07547433f, 0.04881204f, 
    -0.05715197f, -0.08985037f, 0.01008600f, -0.03415417f, -0.02632031f, 0.06343224f, 0.06888655f, -0.00519041f, 
    -0.01813434f, -0.00366565f, 0.00150629f, 0.00686092f, -0.07260848f, -0.02998231f, 0.03290171f, 0.06659720f, 
    -0.05370638f, -0.05669973f, -0.01706184f, 0.05376925f, 0.02057294f, 0.01348789f, 0.02666156f, -0.03789616f, 
    -0.08199733f, 0.02356161f, -0.07128444f, -0.07094204f, 0.04963946f, -0.00857413f, -0.05982489f, 0.01931391f, 
    -0.07046147f, -0.11838098f, -0.05690008f, -0.06219134f, -0.01001766f, 0.01805048f, -0.06091664f, -0.06244764f, 
    -0.02323032f, -0.05919505f, 0.03401703f, -0.05391492f, -0.02463073f, -0.03400965f, -0.03770844f, -0.08736967f, 
    -0.00629587f, -0.02996380f, -0.11444151f, -0.01649928f, 0.01864660f, 0.00331694f, -0.09138900f, -0.03546995f, 
    0.05909513f, -0.08668195f, -0.09497578f, 0.00350565f, 0.07442304f, -0.04924540f, -0.00500295f, -0.03014930f, 
    -0.07016343f, -0.08441401f, 0.03031929f, 0.00571816f, -0.00569994f, 0.02137868f, -0.03093127f, -0.02136872f, 
    -0.00651192f, -0.03198287f, -0.04899138f, -0.11031669f, -0.02887422f, -0.02573158f, 0.00303354f, 0.02162698f, 
    -0.01063977f, -0.07910774f, 0.01556725f, -0.06125246f, -0.06556708f, -0.00371658f, -0.00920361f, 0.04991667f, 
    0.05996485f, 0.06731071f, 0.03207416f, -0.02498714f, -0.01687451f, 0.04793824f, 0.00051583f, -0.00802282f, 
    0.06482796f, -0.06211597f, 0.01703229f, -0.01802096f, -0.02407111f, -0.01522477f, 0.04447266f, -0.00988589f, 
    -0.05771700f, 0.00024798f, -0.06257554f, -0.05404816f, 0.03775111f, 0.06476874f, -0.03350841f, -0.06615669f, 
    0.03917756f, -0.05421655f, -0.05991802f, -0.04817459f, -0.08709918f, 0.00294787f, -0.00727889f, 0.04261547f, 
    -0.09541970f, 0.00598018f, 0.01884138f, 0.02669506f, -0.05293440f, 0.03425738f, 0.06485718f, -0.07431996f, 
    -0.03732808f, -0.06875906f, -0.00963891f, -0.02498158f, 0.03096873f, -0.11234517f, -0.03125491f, -0.06977695f, 
    -0.08215521f, -0.00756536f, -0.08497576f, -0.03268476f, -0.01144540f, -0.06231125f, 0.06073467f, 0.06979796f, 
    0.02268470f, 0.02204550f, 0.02470748f, -0.08411905f, 0.00733812f, 0.01810438f, -0.02056081f, -0.10830259f, 
    0.06066185f, 0.04529604f, 0.02137048f, -0.02155555f, 0.03682194f, -0.03686610f, -0.00300812f, -0.03018350f, 
    -0.01415652f, 0.04963541f, -0.07919948f, 0.00396689f, -0.00351572f, 0.00858020f, 0.05713285f, -0.10081468f, 
    -0.09530729f, -0.10191408f, -0.04195273f, 0.03743244f, 0.01155120f, -0.00906518f, 0.10827656f, 0.00023904f, 
    0.01209229f, -0.10795831f, -0.07111453f, -0.02101742f, -0.06627693f, 0.07911994f, -0.11605245f, -0.04535336f, 
    0.03556782f, -0.05810557f, 0.02464278f, 0.04715387f, 0.07906727f, -0.11068902f, -0.10823999f, -0.01699396f, 
    -0.05947503f, -0.12884380f, -0.08034439f, -0.06362819f, -0.08474081f, -0.09852334f, -0.08505968f, -0.06798846f, 
    0.00239361f, 0.01691147f, -0.08500595f, -0.07987694f, -0.05032120f, -0.09619953f, -0.03260365f, -0.05434667f, 
    0.03078317f, -0.08117158f, 0.05103015f, -0.00411682f, -0.02276616f, -0.04497528f, -0.02778972f, 0.02543936f, 
    -0.03081584f, -0.09366594f, -0.01815132f, 0.00959827f, 0.03764822f, -0.09016941f, -0.05697923f, -0.01368420f, 
    -0.00881796f, -0.10157402f, -0.00493257f, -0.05193093f, 0.05374069f, -0.05090460f, -0.05020147f, 0.06878960f, 
    -0.05364871f, -0.00962493f, -0.00887036f, 0.04516466f, -0.08075249f, -0.02901563f, 0.01190391f, 0.03719958f, 
    0.04467637f, -0.08021197f, -0.00901719f, -0.01585069f, 0.02936674f, -0.01894798f, -0.06954199f, -0.06781301f, 
    0.22594222f, -0.03821025f, 0.04235975f, 0.27490088f, -0.11341999f, -0.23481397f, 0.07399829f, -0.20696931f, 
    0.05243858f, 0.00242383f, -0.11519436f, 0.19891655f, 0.13354480f, 0.33260867f, 0.22315854f, 0.06585079f, 
    0.01043372f, -0.17676923f, 0.00412872f, -0.12523748f, 0.14748926f, -0.18524243f, -0.06173561f, -0.08149885f, 
    0.08340473f, 0.07677544f, -0.00088027f, -0.05955626f, 0.13741536f, -0.35404733f, -0.04731057f, -0.01576284f, 
    0.00036336f, 0.17563500f, 0.07508817f, 0.07417946f, -0.02521541f, -0.02468737f, 0.02488041f, 0.16021474f, 
    -0.23059960f, -0.23519494f, 0.14045021f, -0.06011965f, 0.68541598f, 0.19278568f, 0.03732105f, 0.17907383f, 
    -0.04664350f, -0.14842695f, -0.00375610f, -0.02221013f, 0.09204759f, 0.16161799f, 0.22891568f, -0.19363205f, 
    0.49992481f, 0.02459951f, 0.07611974f, 0.06388036f, 0.00840626f, 0.18572573f, -0.05083984f, -0.10396922f, 
    0.14533809f, -0.05496201f, 0.14630410f, 0.03490791f, 0.02955348f, 0.19078667f, -0.05332698f, 0.14263190f, 
    0.06974990f, 0.13036543f, -0.24646078f, 0.11366462f, -0.13650079f, -0.06956070f, 0.02719989f, 0.18751824f, 
    0.37695163f, 0.00455469f, -0.04963866f, -0.03421142f, 0.24350715f, -0.07369742f, 0.05727535f, -0.02269002f, 
    -0.01590152f, 0.34262836f, 0.17610110f, 0.02196939f, -0.23801324f, 0.02747339f, 0.08052381f, 0.14690675f, 
    0.00681532f, 0.02231427f, -0.27194104f, -0.08306227f, -0.47610879f, -0.17151360f, 0.16816665f, -0.16471580f, 
    0.13087068f, 0.15302674f, -0.03950664f, 0.30234617f, -0.08931837f, 0.49161085f, 0.03934996f, 0.00203213f, 
    0.13398689f, 0.05168647f, -0.02821091f, -0.06015160f, -0.01314207f, 0.08722825f, -0.35716256f, 0.19441050f, 
    -0.16258760f, 0.32611528f, -0.16728541f, -0.07409552f, 0.02520683f, -0.42543030f, 0.05447946f, -0.10244245f, 
    -0.09585439f, -0.01242628f, -0.10397613f, -0.00096182f, -0.09865229f, -0.02427662f, 0.04777205f, 0.06409891f, 
    0.00491271f, 0.01413199f, 0.06688224f, -0.01311168f, 0.04575562f, -0.06053188f, 0.04703931f, 0.06628934f, 
    -0.07753612f, -0.04919400f, -0.08234411f, -0.02766072f, -0.02251108f, 0.00100155f, -0.13503376f, 0.03364115f, 
    0.01342802f, -0.04723324f, -0.06231683f, 0.03673032f, -0.07035754f, 0.05991904f, 0.06702530f, -0.06023694f, 
    -0.06655283f, -0.01541698f, 0.00748403f, -0.07985547f, -0.03836500f, 0.04595501f, -0.02344767f, -0.06732088f, 
    0.06815696f, 0.05675185f, -0.08305455f, 0.05294212f, 0.05757809f, 0.04464380f, -0.07089246f, -0.07767604f, 
    -0.05018046f, -0.05654534f, 0.00776525f, -0.05616797f, 0.03189315f, 0.05619025f, 0.03286232f, -0.03732895f, 
    0.02931554f, 0.01001443f, -0.02426717f, -0.01093057f, 0.03396466f, -0.00658453f, -0.06874596f, 0.00166525f, 
    0.02281509f, -0.03414715f, -0.00609843f, -0.07431873f, -0.04359249f, -0.00949779f, -0.10258478f, 0.05809407f, 
    0.00052126f, -0.03963220f, -0.09123170f, -0.04153059f, -0.03264918f, 0.05542882f, -0.04311959f, -0.06459873f, 
    -0.06550499f, -0.09756311f, -0.01192542f, 0.05656485f, 0.05829868f, 0.03482874f, -0.04364221f, -0.00040887f, 
    -0.03463114f, 0.05774269f, 0.00788333f, -0.02164736f, -0.01870366f, -0.04293400f, -0.10252368f, -0.02230987f, 
    0.01023112f, -0.02226527f, -0.01852921f, -0.06755837f, 0.00610221f, -0.04816431f, -0.08876830f, -0.07070782f, 
    0.05504894f, 0.05373923f, 0.03559878f, -0.05020965f, -0.07512551f, -0.03111023f, -0.06800475f, -0.07892365f, 
    -0.02781929f, 0.00875328f, -0.07124668f, -0.01595443f, 0.04595144f, -0.03599177f, -0.03585949f, -0.05478816f, 
    0.07003679f, -0.07097206f, 0.02139522f, -0.01622459f, 0.04556523f, -0.05747301f, 0.00527926f, 0.06262650f, 
    -0.03900134f, 0.03822847f, 0.05252053f, 0.01895150f, 0.00421580f, 0.03075180f, 0.08491457f, -0.08255785f, 
    0.03503331f, 0.02872089f, -0.09666969f, 0.03860953f, -0.06062494f, -0.10784262f, -0.09713686f, 0.08754148f, 
    0.08540297f, -0.09729917f, -0.02491574f, -0.03667383f, -0.09236851f, -0.07093631f, -0.07390816f, 0.04421327f, 
    0.02592566f, -0.10351815f, -0.07700767f, 0.06042239f, 0.05396881f, -0.04184462f, 0.00556647f, 0.00031455f, 
    -0.08362320f, 0.05084943f, -0.02502054f, 0.00097425f, 0.02866920f, -0.01478860f, 0.02774617f, 0.04920338f, 
    0.03274698f, 0.01954535f, -0.00794373f, -0.05083016f, -0.00579381f, -0.06190689f, -0.08672138f, -0.07917856f, 
    -0.06440687f, -0.08214206f, 0.07717671f, -0.06498384f, 0.01450252f, 0.03601504f, 0.02889136f, -0.03349568f, 
    0.01128413f, -0.06391737f, -0.04379858f, -0.12151229f, -0.05156146f, -0.02124124f, 0.00333723f, -0.09287137f, 
    0.03356089f, -0.06122107f, 0.02480019f, -0.07734328f, -0.03822350f, -0.00937473f, -0.09955863f, 0.05261949f, 
    0.02927214f, 0.01638407f, -0.05506224f, 0.01426595f, 0.01503928f, -0.10807172f, -0.06075258f, -0.04765985f, 
    0.04965962f, -0.02358433f, 0.05348073f, -0.03357720f, -0.04579755f, -0.09859294f, 0.04467051f, -0.02431855f, 
    0.05380932f, 0.03061784f, -0.04856019f, -0.06928341f, -0.02331879f, 0.04167015f, -0.03671481f, -0.05096570f, 
    -0.02739236f, 0.06251608f, -0.09127749f, 0.05649317f, 0.03201835f, 0.03087280f, 0.02779651f, 0.02584528f, 
    0.03111310f, -0.04501558f, 0.04980796f, 0.02411464f, -0.04526493f, 0.06715865f, 0.02443093f, -0.08767770f, 
    -0.07758029f, 0.08075189f, 0.03754371f, -0.11896059f, 0.04422867f, -0.03387672f, 0.00768025f, -0.00177911f, 
    -0.07427735f, -0.03719948f, -0.02058901f, -0.10012694f, -0.11769587f, 0.03022740f, -0.06780751f, -0.02918688f, 
    -0.34730610f, 0.12476321f, -0.24745139f, -0.21973528f, 0.14824076f, -0.01651921f, 0.05308964f, -0.06836702f, 
    -0.08486427f, 0.10514197f, -0.34606487f, -0.15950468f, 0.01905259f, -0.53602576f, -0.29382083f, -0.04914058f, 
    0.08060713f, 0.05217792f, -0.18132746f, 0.08892638f, 0.16764762f, 0.10344403f, 0.00179851f, 0.08706262f, 
    -0.20295335f, 0.20648511f, 0.00364648f, 0.13214470f, -0.06595325f, 0.04654171f, 0.07866879f, -0.02667684f, 
    0.03824434f, 0.21868640f, -0.03587256f, 0.06796107f, 0.04465771f, -0.08110411f, 0.00183911f, 0.14933221f, 
    0.02247702f, 0.10570804f, -0.02132894f, 0.24104193f, 0.17518748f, 0.09552641f, 0.11893228f, 0.08254393f, 
    -0.10809957f, -0.28475726f, 0.01478216f, -0.29998392f, -0.49335071f, -0.20842466f, -0.04793010f, 0.02080769f, 
    0.35255346f, -0.06795862f, 0.06213390f, 0.23067558f, 0.33267969f, -0.12724838f, 0.17405751f, -0.08288403f, 
    -0.47024688f, -0.02243775f, -0.04195436f, -0.01074241f, -0.00809024f, 0.07278273f, 0.11248208f, -0.21407992f, 
    0.36283648f, -0.09470725f, -0.45185685f, 0.07857356f, -0.05123062f, -0.12424491f, -0.06794878f, -0.05260134f, 
    0.07620852f, 0.03495936f, 0.12748948f, 0.35527018f, -0.17260237f, 0.07077188f, -0.12030313f, -0.11310562f, 
    0.04744086f, -0.40804499f, -0.09956722f, 0.07657032f, -0.13371342f, 0.01947022f, 0.01339810f, 0.18709035f, 
    -0.17661929f, -0.11142918f, -0.16045320f, -0.07257845f, 0.12789123f, -0.05854690f, 0.23009431f, -0.02650916f, 
    0.07744411f, -0.13024600f, 0.16893066f, -0.12978268f, 0.06733401f, 0.04706987f, -0.03855747f, -0.01044492f, 
    -0.55001891f, -0.34301770f, -0.21257807f, 0.05520734f, -0.13011461f, 0.21169963f, 0.27842459f, 0.11632656f, 
    -0.24306905f, 0.23154764f, -0.22008964f, -0.18748510f, 0.00241492f, 0.05386725f, 0.05481116f, 0.39525741f, 
    0.09560174f, 0.00063941f, -0.05923688f, -0.18680383f, 0.00753043f, -0.22018990f, 0.05914555f, 0.60625684f, 
    -0.05135594f, -0.12322602f, -0.02326341f, -0.00924844f, 0.19643053f, 0.35424164f, 0.26814619f, 0.04277406f, 
    -0.02096933f, -0.09842563f, -0.23649730f, -0.16548032f, 0.07844196f, 0.10317466f, -0.12036423f, 0.07755128f, 
    0.18634336f, -0.12133366f, -0.01109544f, 0.13302971f, -0.15538535f, 0.72814089f, 0.05330249f, 0.05549107f, 
    0.01884259f, 0.32958308f, -0.55972183f, -0.07387374f, -0.38450712f, 0.24602783f, -0.08027011f, 0.27804196f, 
    -0.13870387f, -0.18098094f, 0.35383949f, 0.39113021f, 1.23820114f, 0.08237296f, 0.34695643f, 0.01814015f, 
    0.16594908f, -0.05068412f, -0.03701052f, 0.21822308f, -0.09011378f, -0.00171021f, 0.05332557f, 0.07680209f, 
    0.25208539f, 0.16402593f, -0.07711332f, -0.02111700f, -0.27868873f, 0.07433232f, -0.07965669f, 0.00338991f, 
    0.46695590f, 0.04990987f, 0.06536122f, 0.03514316f, -0.06693919f, 0.01910860f, -0.10389791f, 0.20189041f, 
    -0.04508071f, -0.01354373f, 0.30094820f, 0.15713581f, -0.23978041f, -0.27333018f, -0.09633716f, -0.12716943f, 
    0.76204264f, 0.20186573f, 0.18234201f, -0.25460556f, 0.55237228f, 0.03496541f, -0.13405021f, 0.23848836f, 
    0.02069169f, 0.31119552f, 0.14982668f, -0.00184240f, -0.54010820f, -0.74972022f, -0.35745248f, -0.07137882f, 
    0.12616552f, -0.15206596f, -0.03532247f, -0.05885983f, -0.12351570f, -0.06253039f, -0.10687131f, 0.16026887f, 
    -0.63499230f, -0.23704253f, 0.15755348f, 0.34340382f, 0.13320099f, 0.38444450f, -0.12515767f, -0.11471161f, 
    -0.02349736f, 0.24202010f, 0.00522677f, 0.28375342f, 0.06082762f, -0.08615854f, -0.19963019f, -0.42792156f, 
    0.12020204f, 0.57341331f, 0.21405931f, 0.23297335f, 0.10444634f, 0.09420075f, 0.00369619f, -0.45201588f, 
    -0.08688593f, -0.04610545f, -0.08373489f, 0.03122010f, -0.10105930f, -0.00559121f, -0.05857428f, 0.01123860f, 
    -0.06738205f, 0.00234414f, -0.01611472f, -0.09837759f, -0.01934899f, -0.10791013f, -0.05865619f, -0.04818815f, 
    0.01611542f, 0.05252512f, 0.05571872f, -0.07462113f, -0.02720961f, -0.06248159f, -0.02511487f, -0.02371141f, 
    -0.03828626f, 0.01282030f, 0.01057146f, -0.02616009f, -0.01444358f, -0.08756845f, 0.07669044f, -0.09324591f, 
    -0.01892088f, 0.09514273f, -0.01370620f, 0.03056719f, 0.02277752f, -0.10010056f, -0.06890290f, -0.03569126f, 
    -0.10410690f, 0.03298755f, 0.05929609f, 0.07539696f, -0.05099034f, -0.09306718f, 0.05546881f, 0.01849630f, 
    0.02896808f, -0.10398557f, 0.03482393f, -0.04307039f, 0.01008940f, -0.02702878f, 0.02774047f, -0.03518227f, 
    0.08098172f, 0.05149828f, 0.07403423f, 0.04560294f, -0.08103065f, -0.03083517f, -0.01420165f, -0.05567184f, 
    -0.04005755f, -0.03701697f, 0.04324499f, 0.00412794f, -0.06174800f, 0.02313343f, -0.09543417f, -0.03699420f, 
    -0.06114023f, -0.12220749f, -0.02524447f, 0.01063955f, -0.08549404f, -0.10612159f, -0.06880682f, 0.04557283f, 
    0.03547123f, -0.03369814f, -0.08317640f, -0.02953244f, -0.04619938f, -0.05349622f, 0.04980452f, -0.10431697f, 
    0.02300474f, -0.03976609f, -0.03128578f, 0.00586384f, 0.03945768f, 0.02150538f, -0.05365548f, 0.05412907f, 
    -0.02393036f, 0.00204962f, 0.00554298f, 0.00357522f, -0.08778989f, -0.01825918f, 0.02855015f, -0.10353839f, 
    -0.08532369f, -0.11803771f, -0.02486063f, -0.02315954f, -0.03335137f, 0.09478454f, -0.01757210f, -0.00879908f, 
    -0.06725503f, 0.03903716f, 0.07509444f, -0.02631913f, -0.00700583f, 0.06078553f, -0.05646233f, -0.05151760f, 
    -0.01083776f, -0.00264029f, -0.07120112f, -0.11612862f, -0.02748466f, -0.06521107f, 0.02648756f, 0.00922218f, 
    -0.17423996f, -0.04069895f, -0.40906677f, 0.05274426f, 0.09496582f, -0.10920975f, -0.02521486f, -0.50535941f, 
    0.00703619f, 0.28480831f, 0.02704929f, -0.38353565f, 0.10009787f, -0.75460392f, -0.23300456f, 0.03802403f, 
    0.01233423f, 0.34973583f, -0.28507113f, 0.33461648f, -0.01586445f, 0.25152722f, -0.04215691f, 0.02793342f, 
    0.10569692f, 0.23712498f, -0.00317265f, 0.32433936f, -0.25697765f, 0.11812723f, 0.07659353f, -0.08940636f, 
    -0.06758624f, 0.38953701f, -0.07995395f, 0.04415511f, -0.17822507f, 0.11456249f, -0.02746191f, -0.27605924f, 
    0.34116384f, 0.13913357f, 0.00267917f, 0.36014667f, 0.74373281f, -0.00303034f, 0.15280382f, -0.47066659f, 
    -0.23169848f, -0.03186513f, 0.01589809f, 0.11862057f, -0.15748507f, -0.19502433f, -0.61832064f, 0.18536554f, 
    0.02374183f, -0.13207994f, 0.01526224f, 0.23430024f, 0.32013014f, -0.15040012f, 0.21123040f, 0.28167552f, 
    -0.18275987f, 0.01729396f, -0.24198362f, 0.18371271f, 0.05347905f, -0.23456600f, 0.10686912f, -0.24758507f, 
    0.31334716f, -0.12502211f, -0.03378121f, 0.20651066f, -0.15750304f, 0.18032749f, 0.07809904f, -0.28138447f, 
    0.18306293f, -0.07389595f, 0.11550534f, 0.33915597f, 0.52871054f, 0.16334775f, -0.03422760f, 0.15511294f, 
    0.03746644f, -0.69749719f, -0.10678217f, 0.03213456f, -0.17064445f, -0.10143866f, -0.25299186f, 0.13294658f, 
    -0.00938359f, -0.10679734f, 0.11654378f, 0.00044765f, 0.58964807f, 0.11982381f, 0.22027554f, 0.00999698f, 
    -0.32690004f, -0.07347436f, 0.49899802f, 0.31477284f, -0.04158268f, -0.46523115f, -0.14541689f, 0.05130526f, 
    -0.27562061f, -0.40652016f, -0.13462543f, 0.22190568f, -0.11213975f, -0.09164275f, 0.57019955f, 0.00998560f, 
    -0.06948189f, 0.09358158f, 0.12132986f, 0.12744083f, 0.03121051f, 0.18171827f, -0.25801957f, 0.27006903f, 
    -0.01556513f, -0.00611431f, -0.10907990f, -0.01518929f, 0.12691739f, 0.10096762f, 0.06673955f, -0.35943761f, 
    0.19975524f, 0.12344102f, 0.17708711f, -0.09498951f, -0.17974907f, 0.05168426f, 0.08653130f, 0.02516189f, 
    0.03562632f, 0.61059099f, 0.12929845f, 0.00139820f, -0.16596508f, 0.06003656f, 0.05258771f, 0.03944826f, 
    -0.12121926f, 0.04750002f, -0.01295536f, 0.02202152f, 0.00686836f, 0.06577663f, 0.02983847f, -0.02303594f, 
    0.02050724f, 0.08776942f, 0.12658510f, -0.06535469f, 0.06372746f, 0.18008395f, -0.00828534f, -0.17299131f, 
    0.16191761f, -0.05163257f, -0.40311700f, -0.27241993f, -0.12916678f, -0.14978507f, -0.62843013f, 0.00282241f, 
    0.05164318f, 0.11650896f, 0.05453481f, 0.05443129f, 0.09394355f, 0.13382663f, 0.15021563f, 0.07729189f, 
    -0.55414629f, -0.29941303f, -0.02606319f, -0.14786656f, 0.16314711f, -0.13373131f, 0.15165648f, 0.19355300f, 
    -0.06108170f, -0.04723716f, -0.03021022f, -0.17981131f, -0.05701773f, -0.02944072f, -0.01514762f, 0.01741351f, 
    -0.25568959f, 0.17995566f, -0.05111411f, 0.18112655f, 0.05587113f, 0.23023018f, 0.09779492f, 0.07043187f, 
    -0.19777735f, -0.27333853f, -0.02424365f, -0.06413226f, -0.00264939f, -0.12038177f, 0.12437299f, -0.24739081f, 
    -0.03797789f, -0.08355437f, 0.00499224f, 0.03833514f, 0.19185390f, 0.18276896f, 0.17157759f, -0.05229462f, 
    -0.29629341f, 0.21104513f, 0.21339010f, -0.03387559f, 0.40635845f, 0.16539188f, -0.24044551f, -0.29166436f, 
    0.17889333f, 0.19558570f, -0.07435755f, 0.11074472f, -0.29532385f, -0.27005899f, 0.09560877f, 0.11994323f, 
    0.02588411f, -0.30593735f, 0.02983416f, -0.37678394f, 0.01560433f, -0.11178864f, 0.18266235f, 0.04972733f, 
    -0.02404871f, -0.14208132f, -0.02067308f, -0.03168591f, -0.17452995f, -0.10204826f, -0.08799566f, 0.24798344f, 
    -0.00622728f, -0.09659572f, 0.35945648f, 0.11876014f, -0.20864080f, -0.02023994f, -0.08743315f, -0.13634433f, 
    -0.09086850f, -0.11648346f, 0.02139153f, 0.08446775f, 0.09048636f, 0.12103491f, -0.19580348f, -0.07399176f, 
    -0.00482978f, -0.03003762f, 0.04330796f, 0.03275903f, 0.54294461f, 0.05280698f, -0.15175924f, -0.03720463f, 
    0.08109549f, 0.13943560f, 0.09508669f, 0.09300240f, -0.03129084f, 0.11206269f, 0.05688095f, 0.03041347f, 
    0.01061749f, 0.03259595f, 0.10658932f, 0.01238493f, 0.22207066f, 0.11018190f, -0.02679792f, -0.24654707f, 
    0.02946278f, 0.06126534f, 0.14829546f, 0.35552168f, 0.00289920f, 0.03690135f, 0.18790059f, -0.03996353f, 
    -0.05002372f, 0.05441974f, -0.04083771f, 0.05369077f, 0.24957539f, 0.17644535f, -0.02965275f, -0.00329559f, 
    -0.01187839f, 0.28703538f, 0.08666217f, -0.04394873f, -0.09166690f, -0.12174746f, 0.08800675f, -0.05550097f, 
    -0.14976743f, 0.05572639f, 0.00237333f, 0.53009629f, 0.06441990f, 0.04408151f, 0.04968758f, 0.16504924f, 
    0.05337085f, -0.04752922f, -0.29043049f, 0.18012965f, -0.00007724f, -0.01344598f, 0.20739636f, -0.21617584f, 
    0.34685221f, 0.04464741f, -0.22250436f, -0.07954539f, 0.25100559f, 0.00300283f, 0.17648505f, 0.23277535f, 
    -0.05221383f, 0.13603063f, -0.04754819f, 0.03831425f, 0.26747012f, 0.08360381f, 0.13815041f, 0.02488144f, 
    -0.01278445f, -0.07679065f, -0.27795833f, -0.07687982f, -0.18583699f, -0.23604161f, 0.18736628f, -0.04574756f, 
    -0.06523556f, 0.12130229f, 0.03749681f, -0.17151465f, -0.05621795f, 0.05074716f, 0.01859272f, 0.04396970f, 
    0.06354748f, -0.01742155f, 0.10663939f, 0.16112229f, -0.04800678f, -0.06659557f, 0.09629546f, 0.05983212f, 
    0.17847355f, -0.04585611f, 0.01195670f, -0.37408838f, -0.08013391f, 0.05080848f, -0.10467659f, -0.01203236f, 
    0.12189452f, 0.01930247f, 0.16228868f, 0.13926813f, -0.05763286f, -0.10611727f, -0.07770243f, -0.91845393f, 
    -0.06932748f, 0.10451269f, -0.05968989f, -0.16282329f, -0.20948435f, -0.54891676f, -0.28040472f, -0.07862522f, 
    -0.06996653f, 0.12371664f, 0.25162819f, 0.11114755f, 0.69130951f, 0.13328528f, -0.15676244f, -0.07668281f, 
    -0.08678936f, 0.07041924f, -0.03634461f, -0.37120295f, 0.14142230f, -0.45135319f, -0.06657908f, 0.06886965f, 
    0.06038456f, -0.44375211f, 0.14034411f, -0.06358553f, 0.26116157f, -0.00003138f, 0.08345363f, -0.15165856f, 
    -0.00073310f, 0.16842835f, -0.00163071f, 0.31337416f, -0.28632909f, 0.03943884f, -0.13103741f, 0.14421745f, 
    0.20715678f, 0.24827911f, -0.08618022f, -0.51504678f, 0.14042275f, -0.19809583f, -0.39950308f, -0.00343443f, 
    -0.48315850f, 0.22043480f, 0.19496678f, -0.30508310f, -0.22357123f, -0.55797172f, 0.17492665f, -0.36200094f, 
    -0.39256266f, 0.07055735f, 0.07701483f, 0.23035391f, 0.03677811f, 0.00555579f, 0.06467648f, 0.04478150f, 
    -0.16272591f, 0.01423282f, -0.27169991f, 0.23575500f, 0.15729465f, 0.27595887f, -0.04379910f, -0.12782654f, 
    0.28499296f, 0.24551462f, -0.22451651f, 0.14282961f, -0.05957538f, -0.03820042f, 0.00778842f, -0.29779342f, 
    0.08384138f, -0.12345117f, -0.22126655f, -0.06270668f, 0.21144401f, 0.19406037f, -0.04203154f, 0.17243207f, 
    0.05258900f, 0.02218016f, -0.12178987f, 0.01975298f, 0.07416400f, 0.12037254f, 0.17164484f, -0.03581893f, 
    0.31701598f, 0.03039782f, -0.23762642f, -0.00681066f, -0.08173523f, 0.13069341f, -0.03993319f, -0.22069143f, 
    0.06708233f, -0.56953037f, 0.11278838f, -0.03055022f, 0.20194343f, 0.16664085f, -0.83402121f, -0.18323931f, 
    -0.07381420f, -0.51074392f, -0.71447700f, -0.46473846f, 0.16693453f, -0.07420576f, 0.14195758f, 0.04040686f, 
    -0.06481437f, -0.04088260f, 0.07659354f, -0.18261696f, 0.13575043f, 0.13572387f, -0.07648971f, -0.08876622f, 
    0.17212443f, -0.08160177f, 0.00366578f, 0.15770634f, -0.03814575f, 0.11581871f, 0.21343085f, 0.05588780f, 
    -0.03359682f, 0.12500121f, -0.20231602f, -0.01078516f, 0.25427786f, 0.02432014f, 0.24830648f, 0.07808969f, 
    0.04545331f, 0.07003464f, 0.04463992f, -0.29591507f, -0.02118559f, -0.07002904f, 0.03053182f, 0.11512284f, 
    -0.00110087f, -0.26105201f, 0.23489155f, 0.02501456f, -0.02680249f, -0.00536345f, 0.00946034f, -0.00546694f, 
    -0.02877099f, -0.06884163f, -0.08065554f, 0.00725959f, 0.07650300f, 0.09089694f, -0.17333724f, 0.18562889f, 
    -0.12523788f, 0.08404183f, -0.04196093f, 0.02262525f, 0.01156296f, 0.20965520f, -0.01118925f, 0.12992299f, 
    -0.04697018f, -0.09999488f, -0.14470001f, -0.15421203f, 0.06544810f, 0.16653280f, -0.09352369f, 0.23224461f, 
    0.18073797f, 0.23593189f, -0.09927932f, -0.09898958f, 0.02480531f, -0.00005979f, 0.18126006f, -0.07380406f, 
    -0.05624739f, 0.06060880f, 0.11548403f, 0.21024026f, -0.15015945f, 0.15932505f, 0.25195509f, 0.15798324f, 
    -0.42768455f, -0.04172389f, 0.26047099f, 0.04510487f, -0.45263106f, -0.23862921f, 0.12465265f, -0.23290475f, 
    -0.02455525f, 0.47574726f, 0.13436899f, 0.03867605f, 0.21146096f, -0.03453717f, -0.04734317f, -0.07190394f, 
    0.00616777f, 0.28994381f, -0.08216795f, -0.01571442f, 0.05493905f, 0.15692367f, 0.03746739f, 0.07108156f, 
    0.02325958f, 0.13067611f, -0.23898038f, -0.24895698f, -0.05854525f, 0.12411301f, -0.01464055f, 0.20882818f, 
    0.19134045f, -0.13425647f, -0.01307931f, -0.03880760f, -0.17982180f, -0.00985993f, 0.01892469f, -0.13504301f, 
    0.06687772f, 0.20334449f, 0.02565067f, 0.24402624f, 0.04863235f, -0.07876465f, -0.02554769f, 0.16146742f, 
    -0.13392562f, 0.10376076f, 0.00555617f, 0.06754968f, 0.40930760f, 0.07171202f, -0.06341530f, -0.65341049f, 
    0.08111776f, 0.01539899f, -0.09416988f, -0.35958010f, -0.00931554f, -0.45942688f, -0.45582220f, 0.00306479f, 
    0.03724660f, 0.26583856f, -0.18293211f, 0.02114100f, 0.72035331f, 0.01568672f, 0.07355364f, -0.01800635f, 
    -0.22003818f, -0.15899393f, 0.06370243f, -0.20089170f, -0.13680927f, 0.20233887f, 0.10027701f, -0.32653230f, 
    -0.00881126f, -0.07204937f, 0.13013935f, 0.01103646f, 0.20494434f, 0.03408020f, 0.05516012f, -0.24413969f, 
    0.07893522f, 0.36184263f, -0.06109498f, 0.23222896f, 0.53967708f, 0.16338940f, 0.02760688f, -0.02498130f, 
    0.01375699f, -0.11022616f, -0.08239325f, -0.18448050f, -0.12475730f, 0.06430960f, 0.30121949f, 0.07712784f, 
    -0.18719158f, -0.06224156f, 0.18595520f, -0.27279606f, -0.27099490f, -0.04958768f, 0.16906108f, -0.20474108f, 
    -0.42911637f, 0.30947378f, 0.07165109f, 0.18547930f, -0.06959224f, -0.05201346f, 0.01494468f, -0.24366951f, 
    0.47234231f, 0.01594303f, -0.20852560f, 0.42007214f, -0.24727374f, 0.05551629f, 0.14817891f, 0.11246892f, 
    0.15642545f, 0.17373788f, 0.10524006f, 0.45093194f, -0.06926557f, 0.06664987f, 0.09815702f, -0.23635550f, 
    -0.07735249f, -0.33335936f, -0.30748120f, 0.05542319f, 0.13787888f, 0.12191172f, 0.05080713f, 0.27110401f, 
    -0.04406850f, 0.13234219f, -0.04933313f, 0.06385205f, 0.23032804f, 0.04570460f, 0.40166482f, -0.33812290f, 
    0.09529096f, 0.05539457f, -0.13037869f, -0.05887957f, -0.11593875f, -0.37274739f, 0.03333953f, -0.00879904f, 
    -0.09824517f, -0.46076080f, -0.15678185f, -0.05666597f, -0.01282107f, 0.08971419f, -0.15384661f, -0.03809530f, 
    -0.34702218f, 0.14754944f, -0.02406248f, -0.01739181f, 0.08095116f, -0.02761490f, -0.06259292f, 0.27706352f, 
    0.07785869f, -0.02051906f, 0.31207752f, -0.20418698f, -0.00803653f, -0.03651846f, 0.04770810f, 0.09276475f, 
    0.01812887f, -0.02551331f, 0.10540711f, 0.39650938f, -0.02970831f, -0.04673779f, -0.03752153f, 0.02214593f, 
    -0.05674254f, -0.11682777f, 0.16740014f, 0.00924151f, 0.66501701f, 0.02673000f, 0.18988667f, -0.01868977f, 
    0.12462512f, 0.01208157f, 0.02628606f, -0.19508809f, 0.13559686f, -0.32961103f, 0.05443389f, 0.17540057f, 
    0.02557200f, -0.33841720f, 0.26379037f, -0.00795503f, 0.18256745f, 0.03174100f, 0.06922634f, -0.20788836f, 
    -0.06852280f, 0.05373519f, 0.13823754f, 0.16034229f, -0.62150621f, 0.07086799f, 0.06170584f, 0.16245052f, 
    0.06841866f, -0.01856507f, -0.04631671f, -0.05047642f, 0.12336607f, 0.21412417f, 0.13829808f, 0.05198477f, 
    -0.09660377f, 0.31686157f, 0.00029619f, -0.15889095f, -0.05513924f, 0.18913117f, -0.06086422f, 0.04205030f, 
    0.19176656f, 0.17198782f, 0.05970699f, 0.25697303f, -0.01920712f, 0.10278925f, 0.12628086f, -0.04527811f, 
    -0.24900660f, -0.05479861f, -0.26460096f, 0.10058673f, -0.00474780f, -0.02866560f, 0.12554727f, 0.15173063f, 
    0.05726820f, 0.03404961f, -0.05638512f, -0.25813314f, -0.20102115f, -0.20306160f, 0.15529127f, -0.06758561f, 
    0.04318598f, 0.55453491f, 0.04245999f, -0.04629202f, 0.35731456f, 0.15077396f, 0.05387722f, 0.10256696f, 
    0.08146778f, 0.25866932f, -0.24208473f, -0.05049469f, -0.26892623f, -0.01361105f, 0.21451288f, 0.12300638f, 
    0.15694879f, 0.21873790f, -0.09358293f, -0.10461669f, 0.13756110f, 0.33507931f, 0.08183166f, 0.15863368f, 
    0.18966548f, 0.01312602f, 0.23649685f, -0.12461269f, -0.02236670f, 0.00822976f, -0.03552577f, 0.02556750f, 
    0.12876193f, 0.16803826f, -0.05536772f, -0.10610055f, 0.11450624f, -0.06307738f, 0.06380214f, -0.00674633f, 
    -0.01271866f, 0.09843422f, -0.08089603f, 0.60047543f, -0.11256561f, -0.09932827f, -0.05649205f, -0.41483581f, 
    0.05980482f, -0.10851945f, 0.07604986f, -0.17497604f, 0.04887307f, 0.13789743f, -0.29389915f, -0.04242495f, 
    -0.06701212f, 0.11672315f, 0.09755541f, 0.03452621f, 0.23618364f, 0.12457248f, -0.05368295f, -0.02655772f, 
    0.15373904f, 0.01345515f, 0.06222000f, 0.00706337f, 0.09792215f, 0.16067368f, -0.01080408f, -0.00988346f, 
    -0.00478594f, 0.11146963f, -0.22367534f, -0.02528392f, 0.16803040f, 0.23886357f, 0.00536315f, 0.29421404f, 
    0.10820383f, 0.10431065f, -0.18309021f, 0.11705941f, 0.47431812f, 0.05497843f, 0.11904793f, -0.16265281f, 
    -0.04511347f, 0.15671791f, -0.07809994f, -0.37540853f, 0.06983885f, 0.06383419f, 0.17685045f, -0.16608323f, 
    0.02917261f, 0.26175740f, 0.14055088f, -0.07209027f, 0.06554758f, -0.43960550f, 0.35818663f, -0.09209821f, 
    -0.30854493f, -0.08529887f, 0.17095856f, -0.01766589f, -0.06404922f, 0.10664649f, -0.03142545f, -0.19546056f, 
    0.42612186f, 0.11607482f, 0.14321347f, 0.08219936f, -0.01422275f, 0.14465111f, -0.17852698f, 0.03127690f, 
    -0.01310441f, 0.05456724f, 0.11985506f, 0.45338014f, 0.35093784f, 0.31769609f, -0.09017733f, 0.09110121f, 
    -0.06130604f, -0.10791081f, 0.28043005f, 0.03337259f, -0.25931233f, 0.16801901f, 0.13188444f, -0.10680642f, 
    -0.11911976f, -0.03187506f, -0.16139337f, -0.07141429f, 0.16465218f, 0.00842690f, 0.07296019f, -0.15956610f, 
    0.13250604f, 0.03873886f, -0.12526415f, -0.32374579f, 0.08323143f, -0.16315065f, -0.04255803f, 0.12244855f, 
    -0.27996644f, -0.45574912f, 0.05100231f, 0.30630210f, 0.09058289f, -0.04085496f, -0.27073523f, 0.12869164f, 
    -0.08127045f, 0.11707484f, -0.34715450f, -0.09885492f, -0.04635937f, -0.03656788f, -0.10523337f, 0.19239251f, 
    -0.09992598f, 0.13202713f, -0.14218359f, -0.31932065f, 0.02870762f, -0.10233311f, 0.08078970f, 0.47332662f, 
    0.03834305f, 0.01252965f, 0.07075237f, -0.01261692f, 0.19819425f, 0.05323616f, 0.17255746f, 0.02729883f, 
    -0.00914742f, -0.11655859f, 0.01383602f, -0.07529154f, -0.31315753f, 0.04424075f, -0.01894313f, 0.02569556f, 
    0.02326995f, 0.07396121f, 0.06267925f, 0.35306689f, -0.11401749f, 0.04102246f, 0.04234044f, 0.02116902f, 
    -0.02023371f, 0.52803367f, 0.04349106f, 0.07252401f, -0.07934138f, 0.05958584f, 0.02477014f, 0.17080526f, 
    0.10472880f, 0.02007613f, -0.16221520f, -0.16500397f, -0.11252510f, 0.00857899f, 0.10920941f, -0.06799525f, 
    0.08685967f, 0.14671320f, -0.08561178f, 0.25307146f, -0.05182760f, -0.04764164f, -0.48492727f, 0.09166470f, 
    0.13645525f, -0.10330343f, -0.08748306f, 0.02939484f, 0.18441251f, 0.10574935f, 0.02445033f, 0.17143708f, 
    0.31466609f, -0.00986086f, -0.09328661f, 0.07489531f, 0.11519728f, -0.06321548f, 0.01675006f, 0.01056507f, 
    0.12585549f, 0.01089845f, 0.25442332f, -0.04961265f, -0.21154219f, 0.12576251f, 0.20002502f, -0.02315729f, 
    -0.15102647f, -0.14366391f, 0.14718884f, -0.12054278f, -0.40494120f, 0.14939684f, 0.20065013f, 0.10460173f, 
    -0.07211436f, 0.15551181f, 0.13427736f, 0.08050170f, -0.05914510f, -0.11723897f, -0.05705798f, -0.12146056f, 
    0.01900901f, -0.05484315f, 0.06347781f, -0.09088963f, 0.10360682f, -0.03878343f, -0.01619315f, 0.05898850f, 
    -0.07477225f, -0.04380936f, 0.16825829f, 0.23673302f, -0.07203922f, -0.21210203f, 0.00554282f, -0.10321949f, 
    0.11933364f, 0.61235613f, 0.11759192f, 0.13940787f, 0.06841788f, 0.08181239f, 0.49269816f, 0.05162167f, 
    0.04196189f, 0.00433188f, 0.34752327f, 0.32028449f, -0.02168849f, 0.10927059f, -0.04158211f, 0.05228975f, 
    -0.09137475f, -0.13257286f, 0.06600114f, 0.02391228f, -0.05359543f, 0.04888922f, -0.07968042f, 0.08264248f, 
    -0.20114809f, -0.09497008f, -0.10482754f, -0.09027729f, 0.01625988f, -0.12540692f, -0.08420362f, 0.01929136f, 
    -0.03895332f, -0.17099789f, -0.01866423f, -0.05589449f, 0.04578002f, 0.00519058f, -0.04107852f, -0.08611451f, 
    -0.18100476f, -0.08985194f, 0.04996333f, -0.03390099f, -0.02660415f, -0.16496307f, 0.04487610f, -0.14407404f, 
    0.05551124f, 0.06404757f, 0.07677767f, 0.00245116f, 0.05503748f, -0.01591416f, -0.01296736f, -0.11434230f, 
    0.05267025f, -0.07284454f, -0.01444883f, -0.07476868f, -0.01263129f, -0.05580514f, -0.13453326f, -0.11573374f, 
    -0.02194431f, -0.04885099f, -0.03411915f, -0.08666661f, -0.01218951f, -0.12869248f, 0.05394062f, -0.05443360f, 
    0.05468648f, 0.01093198f, -0.09103709f, -0.03789924f, -0.00995542f, -0.16418339f, -0.08872927f, -0.03779249f, 
    -0.16677581f, 0.03018063f, -0.06021672f, -0.03839632f, -0.00496421f, -0.01165643f, 0.02590574f, -0.16124476f, 
    -0.07882969f, -0.00431312f, -0.05887941f, 0.06250681f, -0.04216778f, -0.06928091f, -0.02832827f, -0.03739822f, 
    -0.06428563f, -0.15455663f, -0.11904200f, -0.06484745f, -0.07455830f, -0.04334601f, 0.11212718f, -0.13655806f, 
    0.01546790f, -0.08948256f, 0.04283174f, 0.08767079f, -0.04874041f, 0.04014576f, 0.02781727f, -0.05057472f, 
    -0.07190172f, -0.09325706f, 0.04939724f, 0.05001671f, -0.08980676f, -0.18511993f, -0.05131955f, -0.08960041f, 
    0.02206142f, -0.11288238f, 0.06336971f, -0.15113485f, -0.09645380f, -0.15310435f, 0.04481342f, 0.01388158f, 
    -0.02785559f, 0.07812736f, 0.05305137f, -0.10058614f, -0.06208335f, 0.06182119f, 0.18224095f, 0.01018497f, 
    -0.00363093f, -0.03966338f, 0.02572775f, -0.04793907f, -0.13779710f, 0.03649553f, -0.08835477f, -0.00671171f, 
    0.05970412f, 0.10877647f, 0.12644036f, 0.05860730f, 0.06185490f, -0.03792032f, 0.05975312f, 0.59867936f, 
    0.04406924f, 0.13252991f, 0.09486388f, -0.09436811f, -0.08342330f, -0.21825007f, 0.11465894f, -0.02051988f, 
    -0.09606466f, 0.24392556f, 0.06530313f, 0.07881517f, 0.00616497f, 0.17041579f, -0.21598700f, -0.06199887f, 
    0.08664192f, 0.14676061f, -0.00497184f, 0.09794603f, -0.09761278f, 0.37672865f, 0.04935402f, 0.03614530f, 
    0.07628046f, 0.15078881f, -0.24847472f, 0.00232628f, -0.19741735f, 0.17773804f, -0.06733869f, 0.18139337f, 
    -0.03929516f, 0.03382802f, -0.01198023f, -0.02810676f, 0.17068368f, -0.01896874f, -0.01145245f, -0.11190929f, 
    0.13070205f, 0.08315738f, 0.02164327f, -0.00005318f, -0.15036717f, -0.26244646f, -0.37783045f, 0.01905572f, 
    -0.11453263f, -0.10750913f, 0.04116776f, 0.23859210f, 0.18828760f, -0.05479417f, 0.11932332f, 0.27846327f, 
    -0.14816594f, -0.14235835f, 0.08413122f, -0.06608122f, -0.05225477f, 0.10389692f, -0.07589622f, 0.17045081f, 
    -0.10445790f, -0.07193349f, 0.11114229f, -0.16786587f, 0.12841503f, 0.01013926f, -0.29838598f, -0.20459497f, 
    0.41658717f, 0.14309901f, 0.04581635f, 0.13635495f, 0.49406520f, 0.03630696f, -0.28703147f, 0.23494996f, 
    -0.05406667f, -0.14853556f, 0.15987903f, -0.07293113f, -0.19583505f, -0.17635030f, -0.40754217f, -0.18141681f, 
    0.15840417f, -0.14933726f, 0.23135751f, -0.00677316f, 0.24711423f, 0.19928351f, -0.34972331f, 0.12798832f, 
    -0.04559831f, -0.10912787f, 0.21824765f, 0.56239188f, 0.09523384f, -0.18046993f, -0.01661010f, -0.11704018f, 
    -0.13415729f, 0.32724950f, -0.19526790f, 0.10829867f, 0.09493944f, -0.11026134f, 0.15343174f, 0.02796792f, 
    0.14058948f, -0.27468944f, 0.15971330f, 0.18477115f, 0.13506071f, 0.07136753f, -0.13730499f, 0.20715754f, 
    0.14502317f, 0.00746081f, 0.02061462f, 0.16111885f, 0.01764038f, -0.04968623f, -0.05803141f, 0.11232155f, 
    0.12168072f, -0.19548213f, 0.10067576f, -0.11788269f, -0.16033299f, 0.12808968f, -0.09925190f, -0.02969480f, 
    0.04504519f, -0.03503059f, 0.13304086f, -0.03979202f, -0.07976567f, -0.17865048f, 0.02431075f, 0.03435495f, 
    0.05256392f, -0.18710089f, 0.05039731f, -0.09646946f, 0.19658411f, 0.01676652f, -0.05803574f, 0.06354028f, 
    0.02455202f, -0.29179156f, 0.07332120f, 0.00683295f, 0.09717383f, -0.05026399f, 0.01800549f, 0.16196525f, 
    -0.33668599f, -0.19630001f, -0.00168969f, -0.35711014f, -0.35903189f, -0.12748362f, -0.16739161f, 0.17972206f, 
    0.18593769f, 0.14536344f, -0.05977571f, -0.33988097f, 0.05308986f, 0.01411712f, 0.12497110f, -0.04771105f, 
    -0.10056692f, 0.06807190f, 0.02335889f, -0.42520630f, -0.21655509f, -0.16289620f, -0.05820853f, -0.24885871f, 
    -0.01644817f, -0.01858657f, 0.13153413f, -0.18772951f, 0.06272225f, -0.01247884f, -0.08203930f, 0.10285550f, 
    -0.29885939f, 0.16922002f, 0.27879974f, -0.12708218f, 0.13845417f, 0.04740223f, 0.02091052f, 0.07615565f, 
    -0.22967179f, 0.04718126f, 0.07182012f, -0.29631108f, -0.10975084f, 0.09810235f, -0.08402451f, -0.14470932f, 
    0.00646146f, 0.11480634f, -0.13507155f, 0.00404934f, 0.14548174f, 0.07503655f, 0.06285793f, -0.06780360f, 
    0.01528018f, 0.02898520f, 0.13356213f, 0.03501548f, -0.17564109f, 0.08945508f, -0.32572266f, -0.09700669f, 
    0.13349593f, 0.07170216f, -0.44461644f, 0.12633140f, 0.04359450f, 0.04649692f, 0.06189505f, -0.06813945f, 
    0.00943095f, 0.18626387f, 0.06075260f, -0.14290313f, 0.23716252f, 0.03743966f, -0.17480503f, -0.20204052f, 
    0.03876098f, -0.04675967f, -0.16302833f, -0.26443347f, 0.01058754f, -0.01512692f, -0.00547567f, -0.10886566f, 
    0.07337511f, 0.07388326f, 0.13053381f, -0.20932800f, 0.18971039f, -0.24364127f, 0.01197008f, 0.05290986f, 
    0.28661698f, 0.04193674f, 0.04094441f, -0.32321769f, 0.05682769f, 0.00507457f, -0.02961637f, 0.03817327f, 
    -0.06849847f, 0.03780011f, -0.24873398f, -0.02765880f, -0.14666796f, 0.10537887f, -0.09259075f, 0.04469875f, 
    0.07413954f, -0.07891596f, -0.06406751f, 0.14339752f, -0.02069097f, 0.60009187f, 0.03460543f, -0.27872086f, 
    -0.08120706f, 0.41818625f, 0.01507890f, 0.01076669f, -0.20134960f, 0.22370987f, 0.04650517f, -0.10454432f, 
    0.14954616f, -0.01018028f, 0.10048048f, 0.01584504f, 0.97927815f, 0.04292341f, 0.12306241f, -0.29114240f, 
    -0.18467344f, 0.25655666f, -0.03082371f, 0.14133112f, -0.00795020f, 0.06985775f, -0.58327353f, 0.02671508f, 
    0.14199258f, -0.23445751f, 0.11711716f, 0.13433506f, 0.14559266f, 0.08821054f, 0.18996948f, 0.13767153f, 
    0.24152154f, 0.15755968f, 0.11853439f, 0.00414842f, 0.11063392f, 0.21235810f, -0.06443051f, -0.13966765f, 
    0.28330037f, 0.19546066f, -0.00694204f, 0.13939932f, -0.38856316f, 0.03644333f, 0.07427189f, -0.06979828f, 
    0.08940329f, 0.06350897f, 0.06498465f, 0.01167089f, 0.16916470f, -0.01112531f, -0.06853394f, 0.23518333f, 
    -0.06951969f, 0.10735166f, 0.21498388f, -0.06533374f, -0.66889012f, -0.50954288f, -0.12680988f, -0.18481047f, 
    0.20799021f, 0.17459884f, -0.02602559f, -0.04700486f, 0.29374936f, 0.12017698f, -0.00719937f, -0.11927837f, 
    -0.20091601f, 0.20476896f, 0.21130666f, 0.18002634f, -0.07602555f, -0.13273872f, -0.07048088f, 0.15134981f, 
    0.11149021f, 0.47665644f, -0.03121967f, 0.18293706f, -0.20421799f, 0.07678224f, 0.28774670f, 0.07681081f, 
    -0.19318807f, 0.03130185f, 0.26354241f, 0.52169967f, -0.01461716f, 0.07308467f, -0.17128949f, 0.20860790f, 
    0.08000578f, -0.14532678f, 0.65558100f, -0.08960479f, 0.20433068f, 0.12137150f, -0.08267938f, -0.17723732f, 
    -0.12205198f, 0.00537318f, 0.03830652f, 0.00685995f, -0.00637001f, -0.30299163f, -0.30481458f, 0.06670088f, 
    0.01015346f, -0.00202741f, -0.05567599f, -0.00739092f, 0.78705466f, -0.14587069f, 0.05022695f, -0.03788282f, 
    0.13565454f, -0.13996276f, -0.04539488f, -0.29456317f, 0.05403745f, -0.09913097f, 0.02932280f, -0.15907910f, 
    0.04270415f, -0.30215976f, 0.16868976f, 0.07043677f, 0.16608207f, -0.00467238f, -0.10483469f, -0.49662328f, 
    0.09541690f, 0.28297761f, 0.26587319f, 0.27150121f, -0.04583124f, 0.02060595f, 0.09133071f, 0.00418276f, 
    0.08646894f, 0.04656810f, -0.02726849f, 0.08564296f, 0.19711994f, 0.22643450f, 0.37560591f, 0.03142603f, 
    -0.04801001f, 0.14794821f, 0.31485716f, -0.08069508f, -0.23368460f, 0.06453152f, 0.05434651f, -0.27976966f, 
    -0.08731418f, 0.20753542f, 0.05230340f, 0.50393516f, -0.00080803f, 0.22783895f, -0.07907345f, 0.09980696f, 
    -0.04288934f, -0.13711779f, -0.44621694f, 0.14915264f, -0.02496395f, 0.03467802f, 0.19131829f, -0.07680876f, 
    0.19880244f, 0.23942101f, -0.21310028f, 0.03960934f, 0.04214172f, -0.22601366f, 0.21038520f, 0.08808197f, 
    -0.04382197f, 0.14488441f, -0.24407992f, 0.07091327f, 0.11852621f, 0.13927571f, 0.10017364f, 0.41807413f, 
    0.24020366f, 0.20298599f, -0.50755388f, 0.00684650f, -0.13092983f, -0.01508281f, 0.37759888f, -0.04075422f, 
    0.03060225f, 0.19598880f, -0.08616621f, 0.03603992f, 0.03640600f, 0.19427076f, 0.04944509f, 0.05890917f, 
    -0.01551326f, -0.43148330f, 0.17046860f, -0.12903883f, 0.05366935f, 0.16455694f, -0.18696108f, 0.09988984f, 
    -0.03624634f, -0.11281115f, 0.00009065f, -0.21339642f, 0.15751091f, -0.09077761f, -0.01020765f, 0.04896528f, 
    -0.07532245f, -0.01023027f, -0.02930576f, 0.00384226f, -0.01710724f, 0.05810375f, -0.06092617f, 0.05966359f, 
    -0.06497545f, -0.05915387f, 0.07516582f, -0.11683936f, -0.03033353f, -0.09625588f, -0.09832529f, -0.04667518f, 
    -0.01189798f, -0.04817876f, -0.04670645f, -0.06986391f, 0.00429288f, 0.00656420f, -0.08513512f, 0.04542276f, 
    -0.00476295f, 0.04612646f, -0.03718845f, -0.09174374f, -0.00458934f, -0.01589194f, 0.06018146f, 0.02263097f, 
    0.02591634f, -0.05839919f, -0.02333990f, 0.08703810f, -0.05527271f, 0.02537088f, -0.05778021f, 0.07716489f, 
    -0.05977804f, -0.07611122f, -0.00115950f, 0.06673407f, 0.01741128f, -0.08357384f, -0.06474397f, -0.07432619f, 
    -0.02256951f, -0.09343982f, -0.00386169f, 0.02177208f, 0.05784576f, -0.07780816f, 0.01205730f, 0.06601825f, 
    0.01943265f, -0.05307887f, -0.01067974f, -0.08645304f, -0.04204399f, -0.03346178f, -0.02209065f, -0.06351990f, 
    0.01414434f, 0.06938328f, 0.00465479f, -0.09140707f, 0.02738856f, 0.02207696f, -0.13190837f, -0.07573055f, 
    -0.07854660f, 0.01610424f, 0.03466255f, -0.02394476f, 0.01955001f, -0.01517952f, -0.04266471f, -0.13235021f, 
    0.00744295f, -0.04188626f, 0.02514769f, 0.04317674f, -0.00803941f, -0.01478199f, 0.00333762f, 0.06481321f, 
    -0.08052883f, 0.05940945f, 0.03118237f, -0.03437184f, -0.01534802f, -0.11004978f, 0.06415620f, -0.02229111f, 
    0.07673579f, 0.00305747f, -0.03205622f, 0.08056022f, -0.03596202f, -0.09096614f, -0.09354687f, -0.07481959f, 
    0.06277785f, 0.03582715f, 0.02408926f, 0.08582786f, -0.07349089f, -0.06233750f, -0.01835829f, -0.01893719f, 
    -0.03462665f, 0.03865682f, 0.01902314f, -0.03383706f, -0.06229622f, -0.05175300f, 0.01859160f, -0.03290008f, 
    -0.01264583f, -0.06738939f, -0.03208382f, -0.08707269f, -0.08224970f, -0.03547700f, -0.00685769f, 0.01634735f, 
    -0.09676187f, -0.06613759f, -0.00594296f, -0.07791120f, -0.02408994f, 0.01758140f, -0.04684422f, -0.08800612f, 
    0.04496588f, 0.05780182f, -0.09286273f, 0.01197188f, 0.02675302f, 0.04403329f, -0.06788880f, -0.01691115f, 
    0.08608530f, -0.03224255f, 0.01255624f, -0.08265819f, -0.12618671f, -0.02541217f, -0.07049508f, -0.06135584f, 
    0.03538522f, 0.01352292f, 0.04718585f, 0.06259084f, 0.05280013f, 0.04528464f, 0.05331628f, 0.02528556f, 
    0.01697440f, -0.02473210f, 0.02544461f, -0.00255711f, -0.05647970f, -0.06846549f, 0.00923696f, 0.02770702f, 
    -0.04581993f, -0.07296024f, -0.08921088f, 0.03196050f, 0.06863941f, -0.10711037f, -0.06190923f, 0.06838201f, 
    0.02355586f, -0.02019666f, 0.02718896f, -0.06907678f, -0.03706427f, -0.01120221f, 0.01437004f, -0.06313191f, 
    -0.08655410f, -0.06620492f, -0.04883940f, -0.02569987f, -0.08588965f, -0.03080976f, -0.06465434f, -0.05741305f, 
    -0.01780969f, -0.01211650f, -0.10448933f, -0.01195634f, 0.05478476f, -0.09269875f, 0.04179367f, 0.03917231f, 
    -0.05645226f, -0.09336624f, -0.00465738f, 0.01431521f, -0.00595695f, -0.05586344f, 0.07080439f, -0.05877465f, 
    -0.03077319f, 0.01180361f, -0.04032126f, -0.09579179f, 0.07256175f, 0.02114178f, -0.02028872f, 0.00305895f, 
    0.03333941f, 0.03290562f, 0.03246175f, 0.00630105f, 0.05317780f, -0.00806109f, 0.02318414f, -0.04841040f, 
    -0.07458041f, 0.01777465f, 0.03348826f, 0.04301079f, -0.04572484f, -0.05501892f, 0.01650874f, -0.04836661f, 
    -0.10188027f, -0.10354691f, -0.04447984f, -0.10767958f, 0.02651565f, -0.00939595f, 0.07108137f, 0.04581965f, 
    0.04729281f, -0.01065342f, 0.00876036f, 0.00431533f, 0.04217312f, 0.02067259f, -0.04769520f, -0.05603568f, 
    0.04659373f, -0.09506284f, -0.04663676f, 0.05091846f, 0.03168764f, -0.00195314f, -0.01965425f, -0.08871043f, 
    -0.08856796f, -0.10347555f, -0.01168907f, 0.02596371f, 0.08282749f, -0.00803675f, -0.06029423f, 0.03348324f, 
    -0.04981683f, 0.00104089f, -0.10533171f, 0.04992093f, 0.02965394f, -0.02209932f, -0.07598553f, -0.00581297f, 
    0.05807453f, -0.02794176f, -0.06773781f, 0.02416127f, -0.05405776f, 0.00494912f, -0.03669187f, -0.06945182f, 
    0.06242258f, -0.05866534f, -0.05438840f, -0.03489309f, -0.06426589f, -0.06115217f, 0.04740491f, 0.05877238f, 
    -0.04056105f, 0.06889191f, -0.09676453f, -0.04092874f, -0.07927100f, 0.06691339f, -0.01280251f, 0.00500680f, 
    0.00653343f, 0.06441689f, 0.01267154f, -0.00624822f, -0.03122287f, -0.04815136f, -0.03574035f, 0.03900244f, 
    -0.04870973f, -0.05876909f, 0.05095198f, 0.04060974f, 0.00878733f, 0.03480734f, 0.06207884f, 0.03768201f, 
    0.06859078f, -0.00906834f, -0.09897639f, -0.01333978f, 0.07054554f, 0.00847271f, -0.02875106f, 0.06452084f, 
    0.02049958f, 0.02943481f, 0.00955824f, 0.00053315f, -0.03769098f, -0.10419424f, 0.01188345f, 0.05123439f, 
    -0.08895090f, -0.08915763f, -0.04942354f, -0.01869655f, -0.05155744f, 0.00451864f, -0.08531690f, -0.00413817f, 
    -0.03449657f, -0.00396612f, -0.06508952f, 0.00124432f, -0.00687191f, 0.03481419f, -0.05462564f, 0.04216905f, 
    0.05099807f, 0.04807962f, 0.01923951f, -0.06232861f, 0.02543959f, -0.05410590f, 0.05728842f, -0.06908467f, 
    -0.04200953f, -0.04279342f, 0.01609357f, -0.03404351f, -0.06815350f, -0.07698374f, 0.06126080f, 0.01988889f, 
    -0.00287032f, -0.02856840f, 0.05912444f, 0.01127711f, -0.07064254f, -0.03546795f, -0.04809674f, -0.04487449f, 
    0.00142812f, -0.00813942f, -0.09624000f, -0.04276511f, -0.00215139f, 0.07824121f, 0.03174324f, -0.09783249f, 
    -0.02444247f, -0.08097114f, 0.00376938f, -0.07063190f, -0.09806790f, -0.01192354f, -0.00254582f, 0.00183993f, 
    0.03586852f, 0.20193729f, 0.18581840f, -0.20017149f, 0.24940015f, -0.11981659f, -0.02538163f, 0.11558826f, 
    0.16438448f, 0.01385447f, -0.19856456f, -0.42213601f, -0.07742173f, -0.90590900f, -0.19545864f, -0.08743045f, 
    -0.00992641f, 0.17976905f, 0.03984868f, 0.17212360f, 0.34716865f, -0.07653024f, -0.27574870f, 0.03274957f, 
    -0.05206928f, -0.13844317f, -0.07661905f, -0.23340841f, 0.15287016f, 0.30919468f, 0.00949296f, -0.00455548f, 
    0.06080407f, 0.06125763f, -0.10555469f, -0.02942199f, -0.03750736f, 0.04263686f, -0.00551903f, -0.20992930f, 
    -0.10335940f, 0.06300109f, 0.08639249f, 0.14374849f, 0.15256676f, 0.04081577f, -0.09416530f, 0.29011932f, 
    0.23042694f, 0.22232431f, -0.03679343f, -0.13622727f, -0.10046941f, -0.29992515f, -0.37958509f, 0.19867757f, 
    -0.27887273f, -0.00236650f, 0.20625910f, -0.06466314f, -0.11790337f, -0.04458387f, -0.00692049f, -0.39355111f, 
    -0.56009579f, 0.25560197f, 0.24396047f, 0.07610977f, 0.06210852f, 0.16295756f, 0.01348917f, -0.10102533f, 
    -0.25218406f, -0.31497720f, -0.18373653f, 0.05233859f, 0.01076102f, 0.19614060f, -0.14343800f, 0.08816264f, 
    0.52663642f, 0.23956327f, -0.37469578f, -0.15203528f, 0.37964338f, -0.14937258f, 0.10673459f, 0.23154569f, 
    0.07024717f, -0.05064008f, -0.09583340f, -0.03853982f, 0.00835308f, 0.16851497f, -0.18534875f, 0.36914051f, 
    0.46547627f, -0.11973555f, -0.09957194f, 0.02247959f, 0.08625568f, 0.41446483f, 0.03524915f, 0.03943894f, 
    0.31190708f, -0.12518710f, 0.18270479f, 0.46518776f, -0.07858893f, -0.27955636f, 0.06210033f, -0.31828240f, 
    -0.07462375f, -0.28804031f, -0.03432056f, -0.21657962f, 0.29040414f, 0.15494664f, -0.26415762f, -0.03474234f, 
    -0.02085127f, -0.43026507f, -0.39853588f, 0.01640628f, 0.14662501f, -0.09917744f, 0.19293666f, 0.03092657f, 
    0.13628711f, 0.23619832f, -0.25660926f, -0.23536944f, 0.03267702f, -0.20009309f, -0.03053836f, -0.23953401f, 
    0.18989334f, 0.10471921f, -0.05353556f, -0.17050622f, 0.15435287f, 0.04529160f, 0.15775946f, -0.03631024f, 
    -0.04682500f, 0.11195441f, 0.16723236f, 0.07225526f, -0.17946272f, -0.00226802f, 0.04819009f, -0.03493725f, 
    0.07403690f, -0.06103847f, 0.10445293f, 0.01850200f, 0.10245184f, 0.14051431f, -0.07305027f, 0.15828791f, 
    -0.07955762f, 0.22170097f, -0.06404880f, 0.03055687f, -0.13561156f, -0.06084136f, -0.04113005f, 0.02097685f, 
    -0.02951546f, -0.17754948f, 0.05247565f, -0.12811604f, 1.00790155f, 0.12631549f, 0.06632045f, 0.06110564f, 
    0.23634730f, -0.00807400f, -0.04853487f, -0.00532481f, -0.03554612f, 0.00899587f, -0.13348788f, 0.29570827f, 
    0.53925556f, -0.24844575f, -0.04099020f, 0.02666792f, -0.12601006f, 0.01947632f, -0.21348782f, -0.09654265f, 
    0.17081286f, 0.10020532f, 0.20789920f, -0.11334202f, 0.03277520f, 0.11871912f, -0.04229519f, 0.12187335f, 
    -0.17934512f, 0.01555944f, 0.14565614f, 0.21193300f, -0.10650465f, 0.11626863f, 0.02252847f, 0.11044998f, 
    0.23255473f, 0.24210207f, -0.05937003f, -0.09249031f, 0.26040098f, -0.04365840f, -0.05566127f, -0.06268044f, 
    0.07092561f, 0.15459995f, -0.17275023f, 0.07133869f, -0.21590495f, -0.05829650f, -0.12897953f, 0.14069228f, 
    0.15326412f, 0.02572075f, 0.10075159f, 0.00640856f, 0.17159317f, 0.27634203f, 0.01206631f, -0.19089164f, 
    0.15380640f, -0.08528310f, 0.23852903f, 0.50536102f, 0.03316811f, -0.17866345f, 0.14907621f, 0.08147337f, 
    0.12633619f, -0.02968978f, -0.02431498f, -0.01385050f, 0.53915060f, 0.10212284f, -0.09723859f, -0.16146195f, 
    -0.02167474f, 0.01735319f, -0.03535935f, 0.08847011f, 0.12906915f, -0.11581472f, 0.27184761f, -0.09648912f, 
    -0.22480302f, 0.00337168f, 0.11429874f, -0.00760474f, 0.08900913f, 0.16797327f, -0.07029172f, 0.28920791f, 
    0.28602251f, -0.29323804f, 0.03553770f, 0.29859653f, -0.64821845f, 0.04268179f, -0.08357466f, 0.05582434f, 
    -0.06447988f, 0.06067451f, -0.14307711f, 0.03904323f, 0.31207883f, -0.01749382f, 0.35078701f, 0.01517674f, 
    0.03027681f, 0.05275629f, 0.05356377f, -0.63763374f, -0.01557286f, 0.15614624f, -0.06982245f, 0.15998431f, 
    0.05370411f, -0.01332578f, 0.07464168f, -0.07053345f, -0.05994299f, -0.01121204f, 0.00685799f, -0.06600681f, 
    0.11727991f, -0.11801647f, -0.02139275f, 0.10267743f, 0.04327643f, -0.04816552f, -0.30360419f, 0.13000618f, 
    -0.31334996f, 0.11475243f, 0.01774017f, -0.21774559f, 0.21760993f, 0.15391092f, 0.31731880f, -0.07638453f, 
    -0.51559383f, -0.11897685f, -0.09664025f, -0.11345502f, 0.26407370f, 0.14783406f, 0.03941894f, 0.41323018f, 
    0.18135574f, 0.00693143f, -0.15833411f, -0.03796773f, 0.07170224f, -0.00813685f, -0.23139010f, -0.70078099f, 
    -0.09146333f, 0.18867859f, 0.04435049f, -0.37115136f, 0.08726980f, 0.07462745f, -0.00098657f, 0.19602485f, 
    -0.17652640f, -0.06580590f, 0.21532638f, 0.16090201f, 0.06887834f, -0.30336934f, -0.30700955f, 0.06934334f, 
    0.05014014f, 0.31889731f, 0.62167233f, 0.01029703f, -0.06341545f, 0.01059846f, -0.21268667f, -0.03025902f, 
    0.01617440f, 0.41626254f, 0.06011614f, -0.05964515f, -0.03099405f, 0.27029371f, -0.15607640f, 0.20234190f, 
    0.24132514f, 0.19703022f, -0.29951584f, -0.23150623f, 0.00392321f, 0.10921437f, -0.37655839f, 0.23267801f, 
    0.06857766f, 0.19778198f, 0.05250041f, -0.18928863f, -0.49096909f, -0.10548490f, 0.31889725f, -0.02032533f, 
    0.08234785f, 0.22324298f, -0.12419611f, 0.32618165f, -0.03607078f, -0.21461138f, -0.31410241f, 0.15235391f, 
    -0.63657367f, -0.10333823f, -0.12982614f, -0.35622865f, 0.05291383f, 0.35918841f, 0.06338319f, -0.03642715f, 
    -0.00635222f, -0.12968633f, 0.12254582f, 0.12280048f, -0.04195555f, -0.37640902f, -0.16887709f, -0.00316989f, 
    -0.08741397f, -0.39322427f, -0.24466430f, 0.05748463f, -0.60334343f, -0.23285036f, 0.39533812f, 0.02443531f, 
    -0.68513721f, -0.04274460f, 0.01982392f, 0.03977828f, -0.17253752f, 0.09588138f, -0.06968542f, 0.01953403f, 
    -0.03611650f, 0.12060849f, 0.20012036f, 0.06414859f, -0.11722990f, -0.51543802f, 0.09700315f, -0.30702466f, 
    0.17365529f, 0.09107740f, -0.09834841f, 0.06162360f, 0.05760444f, -0.17169361f, -0.15959761f, -0.33556584f, 
    -0.27163270f, -0.17229065f, -0.02105554f, -0.06968667f, 0.13651201f, 0.15869237f, 0.27331623f, 0.04848301f, 
    0.22497420f, -0.14888948f, -0.44114131f, 0.12063447f, -0.02089053f, 0.26654622f, -0.36268684f, 0.24689768f, 
    0.01373573f, -0.07968465f, -0.50887924f, 0.11689616f, -0.06042194f, -0.51856631f, -0.17432629f, -0.63175488f, 
    -0.19749787f, 0.06971224f, 0.03730455f, 0.21541122f, -0.09868146f, -0.19099201f, 0.12420137f, 0.14424284f, 
    -0.53595680f, -0.44602016f, 0.21725042f, -0.14487778f, -0.41542009f, -0.13163811f, -0.07829184f, -0.36202383f, 
    0.02722790f, -0.06644665f, -0.44273949f, 0.05456802f, 0.09709196f, 0.09267978f, 0.01592793f, 0.02590121f, 
    -0.18283540f, 0.11534659f, 0.04771205f, -0.01099650f, 0.13736299f, -0.08665507f, -0.15607253f, -0.06825784f, 
    -0.09807855f, 0.16062252f, -0.08340544f, -0.31114593f, 0.04706544f, -0.37999320f, 0.09905256f, 0.28459194f, 
    -0.19026567f, -0.21380925f, 0.07728913f, -0.11230223f, 0.26500583f, -0.08630391f, 0.48518085f, 0.04853049f, 
    0.13380776f, 0.29478526f, 0.18397391f, -0.06123637f, -0.26031357f, -0.01512981f, -0.03920582f, 0.12813105f, 
    -0.05577532f, 0.12903647f, -0.22874723f, -0.12898740f, 0.19972809f, 0.04256067f, 0.01601457f, -0.29388356f, 
    0.12730576f, 0.17449090f, -0.01608352f, -0.17564094f, 0.07122585f, -0.52346730f, 0.09126636f, -0.02582548f, 
    -0.09001446f, 0.10627223f, -0.04363453f, 0.25504273f, 0.10184153f, 0.24157631f, -0.06926841f, 0.01483372f, 
    0.08646557f, 0.20024903f, 0.00248910f, 0.06924773f, -0.01659414f, 0.35792002f, -0.08090936f, 0.05847278f, 
    -0.08683573f, 0.32110268f, -0.19214696f, -0.06203466f, -0.23677170f, 0.23709564f, 0.01265898f, -0.00617066f, 
    0.07978144f, 0.11796921f, 0.12840010f, 0.39850122f, 0.29006988f, 0.13731593f, 0.25330034f, -0.05899332f, 
    0.22230712f, 0.22496483f, 0.07889738f, 0.15740518f, -0.12927641f, -0.16745347f, -0.60793680f, 0.18399109f, 
    -0.11815640f, 0.14331490f, 0.05998086f, 0.20867103f, -0.05363260f, 0.21645251f, 0.10845397f, -0.01443316f, 
    -0.07443302f, 0.15061483f, 0.08989843f, 0.01138624f, 0.03884256f, -0.01599400f, 0.05221153f, -0.03735984f, 
    -0.00542419f, -0.20152315f, -0.00956489f, 0.09837615f, 0.11819970f, 0.07611815f, -0.21137379f, -0.18589653f, 
    0.34254074f, 0.29949650f, -0.14112169f, 0.06579050f, 0.48278767f, 0.14643876f, 0.01483067f, 0.27319440f, 
    -0.05105387f, -0.21514066f, -0.22891442f, -0.05939491f, -0.18654531f, -0.18863253f, -0.41130418f, 0.09448115f, 
    0.32502016f, -0.07831237f, 0.01277449f, 0.06682639f, 0.15595540f, 0.26270160f, 0.00531799f, 0.13931681f, 
    -0.02632782f, -0.24754374f, 0.36721009f, 0.36532435f, 0.13839090f, -0.18542220f, -0.05205471f, -0.12915246f, 
    -0.19093244f, -0.16731052f, -0.11103313f, 0.19660409f, 0.13836202f, -0.03261881f, 0.19554658f, -0.26702675f, 
    0.19604532f, -0.02183791f, 0.15903303f, 0.11091445f, 0.11944030f, 0.18972467f, 0.14862314f, -0.02402552f, 
    0.05047343f, 0.03741577f, -0.08742767f, -0.05594068f, 0.08519340f, -0.08211165f, 0.06459844f, -0.01417499f, 
    -0.03781266f, -0.11236462f, 0.03457416f, -0.03100609f, 0.06657851f, -0.04590278f, 0.06151780f, -0.01814128f, 
    0.07239950f, -0.01628126f, -0.00074333f, -0.09685055f, 0.00305895f, -0.09157411f, -0.03578472f, 0.05379154f, 
    -0.07152999f, -0.09736509f, 0.02438781f, 0.02330873f, 0.04048852f, -0.02894523f, -0.02814822f, 0.03466623f, 
    -0.07861087f, -0.08099961f, 0.01374887f, 0.06462212f, -0.01738952f, -0.00500048f, 0.01769736f, 0.09135017f, 
    -0.06996957f, 0.04360492f, -0.06543063f, -0.04236833f, -0.07287471f, -0.08377063f, 0.05896724f, -0.08132288f, 
    0.02636193f, -0.10325862f, -0.00187466f, -0.08618548f, -0.01015604f, -0.09022085f, -0.06332453f, -0.08217634f, 
    -0.00562541f, -0.02957650f, 0.05726159f, -0.01838481f, -0.04334537f, -0.07138338f, 0.05109674f, -0.09904147f, 
    -0.05324150f, -0.01456355f, 0.02622935f, 0.03957109f, 0.06580166f, -0.06206324f, 0.05530114f, -0.09180700f, 
    0.07128374f, -0.04457801f, -0.07743800f, 0.03561042f, -0.04489476f, -0.06027495f, 0.05807622f, -0.05562492f, 
    0.07504169f, 0.02865320f, -0.00433933f, -0.05309702f, 0.06387810f, -0.04591794f, -0.10348247f, -0.05391172f, 
    0.01284076f, 0.00755866f, -0.04316620f, -0.06121746f, -0.00690725f, 0.02160821f, -0.03376330f, -0.09281474f, 
    -0.02065218f, 0.02935603f, -0.09383199f, -0.06915342f, -0.02021581f, -0.05935280f, 0.04363205f, 0.00602932f, 
    0.04000024f, -0.04719716f, -0.04813481f, -0.01385357f, -0.04212873f, 0.03642568f, 0.00974682f, -0.01380891f, 
    0.01607724f, -0.08525452f, -0.01346464f, 0.04216649f, 0.03840379f, -0.06474250f, 0.01229446f, -0.06450737f, 
    -0.12192406f, 0.05854925f, 0.00129578f, 0.02827562f, -0.03347767f, -0.04247916f, 0.03059473f, 0.01049500f, 
    0.04382727f, -0.06781664f, -0.01693136f, 0.00500142f, 0.00112019f, -0.01697360f, 0.06770433f, 0.03040694f, 
    0.01643038f, 0.04860007f, 0.05983078f, -0.06955402f, 0.04022604f, -0.01878756f, -0.06601938f, -0.00236018f, 
    0.05412449f, -0.00321119f, -0.03675040f, -0.02300060f, 0.05239202f, -0.07170368f, -0.00691745f, 0.04309073f, 
    -0.07302098f, 0.05272410f, -0.06336013f, 0.02940935f, -0.07978081f, -0.08265971f, -0.01077359f, -0.09161279f, 
    -0.07842143f, -0.06422544f, 0.01780656f, -0.05002468f, 0.03359632f, 0.05091475f, 0.02528288f, 0.04531948f, 
    -0.06910138f, 0.01722324f, -0.00618442f, 0.01480035f, -0.05382914f, 0.06794608f, -0.00156822f, -0.04184267f, 
    -0.07127725f, 0.00845359f, -0.02862971f, -0.07719008f, 0.04665799f, -0.07885095f, 0.03557606f, 0.05031475f, 
    -0.03048612f, -0.05441707f, 0.01320349f, -0.02861518f, -0.12338860f, -0.09763965f, 0.06257582f, 0.00900223f, 
    -0.05195339f, -0.05050402f, -0.02970532f, -0.05394123f, 0.00477647f, -0.07285566f, -0.01745141f, 0.04138839f, 
    0.04518736f, -0.09067445f, -0.08745906f, 0.01761883f, -0.08574765f, -0.08136908f, -0.04566329f, -0.07791568f, 
    -0.07209181f, 0.07821829f, 0.06876098f, -0.06735519f, 0.00096150f, 0.02478239f, 0.01146080f, 0.05276652f, 
    0.01542279f, 0.04911956f, -0.06414930f, 0.07756942f, 0.04680066f, -0.09300899f, -0.07294331f, -0.09791602f, 
    0.06111105f, 0.03564016f, -0.08373433f, 0.06262980f, -0.02223277f, -0.06938263f, -0.06111022f, -0.08957875f, 
    -0.03226233f, -0.02901998f, 0.07178701f, -0.06606664f, -0.05824002f, -0.07320479f, -0.06218903f, -0.10888784f, 
    0.07569915f, 0.05726672f, 0.00175957f, 0.04739774f, 0.06793540f, -0.05414373f, -0.06076393f, -0.01529537f, 
    0.01157525f, -0.03833045f, 0.06164974f, 0.05767518f, 0.04403687f, 0.00235085f, -0.04943445f, 0.01598390f, 
    0.07738329f, -0.05644529f, -0.03164183f, 0.01017615f, -0.00184985f, -0.02197368f, -0.05695848f, -0.11029132f, 
    0.04842512f, -0.02998057f, -0.10192513f, 0.03053738f, 0.02990785f, 0.04560738f, -0.06962845f, 0.02408925f, 
    0.00870167f, 0.05601196f, -0.02169822f, 0.00831341f, -0.04983070f, 0.02523456f, -0.08841708f, 0.00885376f, 
    -0.02522416f, -0.09866649f, 0.03731722f, 0.01228153f, -0.06032599f, 0.07226221f, 0.07306376f, -0.00833882f, 
    -0.02027613f, 0.03242290f, -0.10295930f, -0.04365840f, 0.02436527f, -0.11182675f, 0.01906009f, -0.02938790f, 
    -0.03370454f, -0.05750203f, 0.01570278f, 0.01464571f, -0.05224613f, -0.07376334f, 0.01593702f, 0.00442894f, 
    -0.08048677f, 0.00895368f, 0.05481135f, -0.05103014f, -0.03664953f, 0.00149700f, 0.01218727f, -0.09302156f, 
    -0.11691085f, -0.11317994f, 0.04335973f, 0.00124764f, -0.07741734f, 0.04290999f, -0.10210644f, 0.00061865f, 
    -0.01184317f, -0.10835648f, -0.10816143f, -0.07734240f, -0.00959321f, -0.06745026f, -0.04337173f, -0.01967585f, 
    -0.09716237f, -0.02414440f, -0.08547418f, 0.02220598f, -0.01922720f, -0.00714467f, -0.09063862f, -0.08432907f, 
    -0.01725526f, -0.06840090f, 0.01512715f, 0.03438810f, 0.01500067f, 0.04489106f, -0.09103083f, -0.01297950f, 
    0.05328708f, 0.05572906f, 0.01534715f, -0.02163083f, -0.09142758f, 0.00805826f, -0.01243056f, -0.09788145f, 
    -0.04130172f, -0.08240920f, -0.11418574f, -0.06244988f, -0.00560986f, -0.06716688f, -0.07725879f, -0.02036110f, 
    0.02994592f, -0.05805060f, -0.04418309f, -0.03822576f, -0.09904063f, -0.01722722f, -0.07844248f, -0.03280146f, 
    0.02064629f, -0.08330809f, -0.00983547f, -0.02628587f, -0.07979149f, -0.05211191f, -0.04101377f, -0.02202822f, 
    -0.05813444f, -0.07747937f, 0.01401802f, 0.06963003f, 0.02726021f, -0.09239451f, 0.04442754f, -0.04525591f, 
    0.01117007f, 0.11357844f, -0.27043763f, 0.44366014f, -0.01773262f, 0.02781514f, -0.04399595f, -0.27397740f, 
    0.16834041f, 0.06690753f, 0.08621126f, 0.06531636f, -0.00408108f, 0.24188368f, 0.19863951f, 0.02443713f, 
    0.01365267f, 0.02363368f, 0.01862472f, -0.03253990f, -0.58100361f, 0.21854106f, 0.07587871f, -0.06055181f, 
    0.11714111f, -0.01121208f, -0.06519782f, 0.14117196f, 0.13051744f, 0.16389506f, -0.07687126f, 0.26149088f, 
    0.07783145f, 0.04996818f, -0.17582974f, 0.05425356f, 0.16756973f, 0.08941185f, 0.01707111f, 0.55214494f, 
    -0.00172538f, -0.02769814f, -0.03355166f, -0.17064878f, 0.06492173f, 0.02313903f, 0.10678065f, 0.13227938f, 
    0.14981717f, -0.00584975f, 0.05955373f, -0.12517941f, -0.00739673f, -0.10376295f, -0.42279321f, -0.03862160f, 
    -0.15400188f, 0.17625415f, -0.15061861f, 0.04262020f, 0.05816432f, -0.21293721f, 0.08407090f, 0.06216346f, 
    -0.04676508f, -0.00429044f, 0.10827531f, -0.37588197f, -0.10707518f, -0.05732931f, 0.11704373f, 0.04355500f, 
    0.12102629f, 0.18560024f, 0.51058275f, -0.20884965f, 0.06201241f, 0.03225635f, -0.19385409f, 0.11987749f, 
    -0.31561121f, 0.00673617f, 0.21295440f, 0.07758878f, -0.00805596f, 0.41408321f, -0.18414199f, 0.07398897f, 
    0.08486197f, -0.18951342f, 0.49324408f, 0.02122896f, -0.10743111f, -0.07851098f, 0.16086949f, -0.35760126f, 
    -0.13814357f, 0.08111902f, 0.24213259f, -0.00143576f, 0.07882027f, 0.14515117f, -0.35322911f, 0.07558499f, 
    0.02119142f, -0.13472506f, -0.01197330f, -0.33191630f, 0.17957409f, 0.02240277f, 0.08163457f, 0.04400767f, 
    -0.10699197f, -0.20131338f, -0.03749740f, 0.32543260f, 0.13445094f, -0.14971815f, -0.42522645f, 0.02870839f, 
    0.08682613f, -0.00931859f, 0.00153518f, -0.07521722f, 0.07163424f, 0.19992352f, 0.11696313f, 0.07567893f, 
    -0.26768252f, 0.04632171f, 0.11928592f, -0.17889115f, 0.09571201f, 0.05110031f, -0.05141608f, 0.46011585f, 
    0.29332864f, -0.45358309f, 0.18014723f, 0.05479634f, -0.06942317f, 0.20841528f, 0.29364970f, -0.06388448f, 
    0.04277794f, -0.61407435f, -0.22949912f, -0.53229338f, 0.04030324f, -0.26639342f, 0.16613655f, 0.04144936f, 
    -0.03707583f, -0.31415722f, 0.01304888f, -0.19812536f, -0.10781130f, 0.23705056f, -0.03727414f, 0.22436878f, 
    0.08631230f, 0.17074895f, 0.00140023f, 0.06942583f, -0.07117306f, 0.01350514f, -0.04328427f, -0.02813166f, 
    0.04333511f, -0.44080839f, 0.01239081f, -0.16460684f, -0.01648002f, 0.14651723f, 0.02759177f, -0.00892279f, 
    -0.14009264f, 0.09527023f, 0.03238662f, 0.17073943f, 0.09102006f, 0.30035216f, 0.56872678f, -0.08776649f, 
    -0.24598159f, 0.14924505f, -0.26974943f, -0.56736505f, -0.06556488f, 0.23729789f, -0.17396918f, 0.22312166f, 
    0.46401468f, 0.38111454f, -0.24005862f, -0.04140197f, 0.07362242f, -0.17202002f, -0.20602210f, 0.08606413f, 
    -0.00523116f, 0.26579753f, 0.47838172f, 0.19463921f, -0.23866268f, 0.16939777f, 0.22889519f, 0.12220634f, 
    -0.60308617f, -0.24752191f, 0.41181704f, 0.01444301f, 0.15685172f, -0.21849063f, 0.08816238f, -0.13083269f, 
    -0.04676070f, 0.37624058f, -0.15535815f, -0.02708749f, -0.08232404f, -0.44625410f, 0.01821229f, -0.69713902f, 
    -0.06980684f, 0.32259303f, -0.12892954f, -0.00825840f, -0.42767671f, 0.05376715f, -0.16891013f, 0.12723373f, 
    -0.06645522f, 0.18215552f, -1.13956094f, -0.85250396f, -0.31731650f, -0.11229654f, -0.12413972f, 0.09803499f, 
    0.34633896f, 0.02553101f, 0.17967202f, 0.00170209f, -0.27696380f, 0.00525937f, -0.50433803f, -0.18868969f, 
    -0.03226931f, 0.38591859f, 0.36320269f, 0.29937872f, -0.35401550f, 0.01646235f, -0.15534917f, -0.01034161f, 
    -0.06474286f, 0.01252784f, 0.01413951f, -0.02242193f, -0.10294897f, -0.09959404f, -0.07615450f, 0.08039735f, 
    -0.06540018f, -0.03483921f, 0.04257661f, -0.05484842f, -0.02009279f, 0.03764794f, -0.07549312f, -0.05034421f, 
    -0.03939396f, -0.10533612f, -0.07134592f, 0.06490981f, 0.07138123f, -0.06391209f, 0.06081494f, -0.03864183f, 
    -0.08305652f, 0.00228599f, -0.03645976f, -0.07656960f, -0.00538975f, 0.06934155f, 0.08439311f, 0.00537108f, 
    0.05827625f, -0.05373479f, 0.02129053f, -0.04469476f, -0.09678214f, 0.09574959f, 0.08602946f, -0.07923118f, 
    -0.07455181f, -0.00183343f, -0.03596382f, 0.06738447f, 0.04333744f, -0.03472606f, 0.04023144f, 0.04224674f, 
    -0.08746164f, 0.03662188f, -0.07903850f, -0.05609013f, -0.06507607f, 0.03373650f, 0.07309005f, 0.06578285f, 
    -0.01885993f, -0.09333064f, -0.10447770f, -0.05113624f, -0.03588707f, -0.02653551f, -0.09927412f, -0.03739495f, 
    0.02555069f, 0.07462154f, -0.07645597f, -0.04999011f, 0.01879372f, -0.09162980f, 0.02529874f, 0.01771399f, 
    0.00602989f, -0.00947786f, -0.01859711f, -0.09017242f, 0.01292197f, -0.03909615f, -0.01990910f, 0.06195348f, 
    0.07364435f, -0.00781029f, 0.00586518f, 0.03719068f, 0.08828891f, 0.07559560f, -0.05573719f, -0.05920704f, 
    -0.04198969f, -0.07920040f, -0.02841013f, -0.01144311f, 0.03971542f, 0.00318403f, 0.04342606f, 0.07005044f, 
    0.06750695f, -0.00965310f, 0.07369067f, -0.08035979f, 0.03134405f, -0.07682636f, 0.05836580f, -0.11877867f, 
    -0.05008031f, -0.08852173f, 0.00088894f, -0.09781740f, -0.05361710f, 0.04667531f, -0.08425290f, -0.06157458f, 
    -0.02639800f, -0.01107669f, -0.09339067f, 0.04765972f, 0.02004193f, -0.05257336f, 0.07994755f, 0.07207049f, 
    -0.01732988f, -0.05851545f, -0.08459979f, 0.02881273f, -0.09156758f, -0.02851235f, -0.04752732f, 0.04126650f, 
    -0.21970522f, -0.02991121f, -0.27627856f, -0.19101806f, -0.06926591f, 0.16582967f, -0.02320989f, 0.27479726f, 
    0.09177532f, 0.10665754f, -0.08236700f, 0.19745898f, -0.08914936f, 0.08180857f, 0.19398740f, 0.04168979f, 
    -0.08745293f, -0.13171364f, -0.11982257f, 0.27716717f, -0.42903849f, 0.02281303f, 0.11308359f, 0.01166655f, 
    0.07691582f, 0.19138435f, -0.06931792f, 0.12514628f, -0.05446443f, -0.35400352f, 0.04365394f, 0.20556855f, 
    0.08392810f, 0.08434375f, 0.12039827f, 0.03338909f, -0.26658759f, -0.11417971f, -0.05341634f, -0.03816747f, 
    0.18003815f, -0.06247725f, 0.01540145f, 0.30172327f, -0.44782415f, -0.14892563f, 0.06459089f, -0.05889879f, 
    -0.36223799f, 0.06979772f, 0.06504759f, 0.18322560f, 0.13429461f, 0.05322380f, 0.02916603f, 0.08127921f, 
    0.02945389f, -0.02350358f, -0.24530907f, 0.32856214f, 0.22155613f, 0.24536100f, -0.25899437f, 0.43155426f, 
    0.24526678f, -0.25513586f, -0.44094428f, 0.06310620f, 0.08593893f, -0.09003905f, 0.12255920f, -0.29886431f, 
    -0.28623500f, -0.17626947f, -0.08950187f, -0.34532303f, 0.16398151f, -0.05012295f, 0.14607850f, -0.11657143f, 
    0.18000981f, -0.25982830f, -0.04606836f, -0.40977672f, 0.50416327f, -0.07451358f, 0.03168092f, -0.02806513f, 
    0.06111001f, 0.20484006f, 0.37038133f, 0.00941392f, 0.10570773f, -0.04471952f, -0.13924804f, -0.00703207f, 
    -0.12204612f, 0.07887320f, 0.16323659f, 0.05727823f, -0.05499557f, -0.04702400f, 0.05836549f, 0.30486175f, 
    -0.19117011f, 0.11226851f, 0.46858871f, -0.48695675f, 0.12882710f, -0.06426252f, -0.09450723f, 0.15178043f, 
    0.03056410f, 0.22456926f, 0.08837894f, 0.07325249f, -0.66439283f, 0.11566236f, 0.56881320f, -0.00629168f, 
    0.37938994f, 0.11453985f, 0.15014331f, 0.08278207f, -0.23970450f, 0.01407368f, -0.07555883f, 0.08574830f, 
    0.27983519f, -0.05905090f, 0.23215668f, 0.44448444f, -0.06387760f, 0.17368197f, 0.02471489f, 0.50191665f, 
    -0.07501274f, 0.13692762f, -0.03955220f, 0.15809587f, -0.31557754f, -0.01995876f, 0.07412007f, 0.02648587f, 
    -0.00514097f, 0.03070905f, -0.05552210f, 0.25696328f, -0.27048388f, 0.06255936f, -0.00733746f, -0.07702643f, 
    0.26571581f, 0.20768556f, 0.07806791f, -0.02069611f, 0.15474547f, 0.25077677f, -0.06515684f, -0.00405659f, 
    -0.02167275f, -0.39355993f, -0.17072766f, -0.07774023f, -0.09355363f, 0.17256457f, -0.00140553f, 0.47422141f, 
    0.15772189f, -0.01216080f, 0.26619110f, -0.11619964f, 0.31385270f, -0.17545246f, -0.01960866f, -0.13364665f, 
    -0.16064952f, 0.13065378f, -0.01049813f, 0.02844615f, 0.10643519f, -0.04993179f, 0.01121662f, -0.01648561f, 
    -0.07613318f, -0.12105677f, -0.06056170f, 0.51492584f, 0.33284220f, -0.04112804f, 0.17204154f, 0.37404913f, 
    -0.33447447f, -0.31521726f, 0.02092434f, -0.18750677f, 0.02311593f, 0.13303892f, -0.14731126f, -0.07147434f, 
    -0.04968547f, -0.05704581f, 0.20997958f, -0.41299379f, 0.19859688f, -0.15343966f, -0.29231092f, -0.08426884f, 
    -0.01738696f, 0.05006571f, -0.08209379f, 0.23734003f, 0.35993707f, 0.06682461f, -0.23105034f, 0.29517454f, 
    0.02234979f, -0.11543605f, 0.30324474f, 0.04997873f, -0.31784871f, -0.00407498f, 0.03380258f, -0.12214792f, 
    0.19322552f, 0.13178508f, 0.33209059f, 0.01725902f, 0.19341213f, 0.13579148f, -0.43553838f, 0.18427157f, 
    0.02859686f, 0.01971477f, 0.02035420f, -0.02816009f, 0.19211946f, 0.00232264f, -0.19552334f, 0.18566042f, 
    -0.21595134f, 0.07662324f, -0.08272879f, 0.15000048f, -0.31075677f, 0.07166588f, -0.31271386f, 0.40803540f, 
    0.14966697f, -0.00524667f, -0.02818095f, 0.13560691f, 0.05459267f, -0.00760864f, -0.17641224f, 0.44824529f, 
    0.27745473f, -0.00108969f, -0.26945564f, -0.44494388f, -0.04039833f, 0.04670507f, -0.07532210f, 0.15953270f, 
    -0.05632124f, 0.11840177f, 0.03999797f, 0.08315380f, 0.30787176f, 0.05619083f, 0.29130265f, -0.08231919f, 
    0.01170746f, -0.12185940f, 0.12723206f, 0.09660272f, -0.44293380f, -0.04205390f, 0.15667155f, -0.07728444f, 
    -0.02787171f, 0.08625020f, -0.11318758f, 0.35129187f, 0.01133360f, -0.51835787f, 0.04966521f, 0.07129899f, 
    0.01755718f, -0.02120017f, 0.22442608f, -0.00779554f, -0.13706943f, -0.17212142f, -0.04660966f, 0.16800159f, 
    0.03408910f, -0.03308149f, 0.04932778f, -0.27101585f, -0.69240564f, 0.07944558f, -0.01913852f, 0.12415411f, 
    0.03136266f, 0.01860730f, 0.08214879f, 0.37818429f, -0.14999597f, -0.05406396f, 0.09120784f, 0.08144647f, 
    0.06302479f, -0.03200774f, -0.11249682f, 0.08323845f, 0.16097280f, 0.28692734f, -0.18610726f, 0.05984714f, 
    0.30720565f, -0.12492530f, -0.13799274f, -0.15052818f, 0.01754609f, -0.06636545f, 0.17351875f, 0.36343899f, 
    -0.18462120f, -0.13977250f, 0.27181345f, -0.00114048f, -0.02709324f, 0.08719400f, 0.11755585f, 0.08591596f, 
    -0.19169746f, 0.04133849f, 0.08804746f, -0.27318698f, -0.20582965f, 0.01183426f, 0.32843634f, -0.12694874f, 
    -0.09574904f, 0.01538986f, -0.00373666f, 0.05623013f, 0.49275970f, 0.02278570f, 0.04345985f, 0.07140767f, 
    0.07174681f, -0.16170625f, 0.18265676f, -0.08312902f, -0.17649683f, -0.10313371f, 0.03316138f, 0.17116550f, 
    -0.07163386f, -0.11723511f, 0.27099755f, 0.39212218f, 0.00838387f, 0.32486492f, 0.24566714f, -0.09112443f, 
    0.13426729f, 0.17994931f, 0.01616717f, -0.06715561f, 0.14974700f, 0.04207550f, 0.12512949f, -0.05649290f, 
    0.28417197f, -0.01852480f, 0.24683818f, -0.00770790f, 0.01798246f, 0.05309612f, 0.26352012f, -0.13245998f, 
    0.03492830f, -0.00394284f, 0.21012594f, 0.00715328f, 0.03333795f, -0.13199684f, 0.01563348f, -0.38490298f, 
    0.11902274f, -0.25714648f, 0.11412542f, -0.02155791f, 0.09619613f, 0.33588442f, -0.02501424f, -0.03570190f, 
    0.08365415f, -0.37450457f, 0.04489662f, -0.38068900f, 0.02150206f, -0.22408615f, 0.05495389f, 0.07894319f, 
    0.07711262f, -0.38169840f, -0.07678149f, -0.09996831f, 0.00683375f, 0.40537369f, 0.07993083f, -0.08235538f, 
    0.05247182f, 0.08519106f, -0.00263692f, -0.07489967f, 0.20917845f, 0.14877543f, 0.06188645f, 0.11774648f, 
    -0.08971532f, -0.03150764f, 0.07049691f, -0.21153741f, 0.09968988f, 0.20607390f, 0.18013383f, 0.02360579f, 
    -0.05465109f, -0.07270539f, 0.00134793f, -0.06311409f, 0.21159643f, 0.17242736f, -0.20653957f, -0.16316715f, 
    0.21581991f, 0.13041596f, 0.05743309f, -0.41967526f, -0.15015374f, 0.06826968f, -0.00614995f, -0.36450085f, 
    0.26587009f, 0.37246895f, 0.07823177f, 0.06322047f, 0.06037116f, 0.01509787f, -0.21067384f, -0.06599020f, 
    0.24065354f, 0.19277987f, 0.03591395f, 0.07394850f, -0.34282875f, 0.07840977f, 0.15793802f, 0.16308025f, 
    -0.48865938f, 0.10414357f, 0.25077051f, -0.02490678f, -0.60347289f, 0.05180799f, 0.13488002f, 0.08498516f, 
    0.00577165f, 0.39690426f, 0.00327510f, -0.01519756f, -0.34293324f, -0.17342946f, 0.17979573f, -0.25677618f, 
    0.05023144f, 0.15446377f, -0.38914776f, 0.05151632f, -0.31367728f, -0.09657212f, -0.07143979f, -0.17173646f, 
    -0.08341948f, 0.15469399f, -0.42716202f, -0.11356432f, -0.15242936f, 0.17015553f, -0.05448890f, 0.08932145f, 
    0.27743271f, -0.07000290f, 0.21012184f, 0.12413333f, -0.02489782f, 0.02302431f, -0.39407897f, -0.05302419f, 
    -0.22714488f, 0.07029951f, 0.16908792f, 0.24077933f, -0.09130166f, -0.09234918f, -0.10212298f, -0.23272386f, 
    -0.03283703f, -0.07329316f, 0.02742156f, -0.06233173f, 0.02677824f, -0.08393104f, -0.05435865f, 0.01317084f, 
    0.03406694f, -0.08252093f, 0.00389900f, 0.05316634f, -0.04133896f, 0.06337371f, 0.03709680f, 0.02396635f, 
    0.04107621f, 0.04142178f, -0.03960118f, 0.04256808f, -0.05785749f, -0.09560967f, 0.03104374f, 0.01343676f, 
    -0.10076211f, -0.04375047f, -0.08456107f, -0.06596015f, -0.04376908f, -0.00864516f, 0.06075102f, -0.02569996f, 
    0.08356808f, 0.07983853f, -0.08435397f, -0.00390952f, -0.02603748f, -0.08050691f, -0.05521508f, 0.04017230f, 
    -0.08244038f, 0.03559960f, -0.04168893f, 0.01568422f, 0.06691156f, -0.04287181f, -0.05480295f, -0.08209473f, 
    -0.04943331f, 0.06155212f, -0.02897973f, -0.05161579f, 0.07750698f, -0.00547775f, -0.01957329f, -0.06410076f, 
    0.01791987f, 0.00533582f, -0.04018629f, 0.01973202f, -0.10247248f, 0.03262649f, 0.05233844f, -0.06346586f, 
    0.05295595f, -0.10280488f, -0.05981834f, 0.02738581f, -0.05808369f, 0.03587144f, -0.04626537f, 0.04631033f, 
    -0.06150006f, -0.10301764f, -0.02065309f, 0.00795828f, -0.06274910f, 0.01086285f, 0.00273497f, 0.00938364f, 
    -0.08824122f, 0.05998499f, 0.04853816f, -0.06492296f, -0.04094525f, 0.00630868f, -0.09808274f, 0.02521292f, 
    0.02097403f, -0.07007510f, -0.00442053f, -0.02327831f, 0.05016679f, 0.03820350f, -0.06962804f, -0.03072520f, 
    0.04218705f, 0.01604377f, 0.04486577f, -0.03394536f, 0.03845550f, 0.05724395f, -0.03679095f, -0.10632064f, 
    -0.08812324f, -0.08890571f, 0.08015069f, 0.02203029f, -0.00885822f, -0.03820760f, 0.05181364f, -0.10006278f, 
    -0.07930095f, -0.07874541f, -0.03081238f, 0.01026057f, 0.01458649f, 0.01513769f, -0.00636112f, 0.06947815f, 
    -0.00001518f, -0.02372078f, -0.00561017f, 0.03299269f, -0.07828629f, -0.03971639f, -0.08083135f, -0.09532987f, 
    0.15167546f, -0.05313483f, 0.20095129f, 0.00016190f, -0.17468536f, 0.14799829f, -0.02607702f, 0.35027930f, 
    -0.07338439f, -0.04555355f, -0.16865489f, 0.34287328f, -0.28140947f, -0.17101392f, -0.04141881f, -0.03569116f, 
    -0.11469243f, 0.05371678f, 0.25730762f, 0.16403073f, 0.33747324f, 0.02700177f, -0.06251569f, 0.02185866f, 
    -0.01790668f, 0.22719735f, 0.06179038f, -0.29413280f, 0.20305625f, -0.58278936f, 0.03809180f, 0.18250646f, 
    0.06129633f, -0.44168285f, 0.17855218f, 0.01422514f, 0.12257932f, 0.00358249f, -0.03471944f, -0.13415833f, 
    -0.13873275f, -0.07013602f, 0.08108781f, 0.23002338f, -0.43680996f, -0.08305036f, -0.18701236f, 0.32368425f, 
    0.08792026f, 0.01577731f, -0.03737482f, -0.21559803f, 0.02179272f, -0.07856601f, -0.00063160f, -0.04436764f, 
    -0.38928857f, 0.10956342f, 0.07627903f, 0.04096256f, 0.32433903f, -0.17447969f, 0.02897198f, 0.34386310f, 
    -0.13896511f, -0.23088574f, 0.03255968f, 0.04160985f, -0.04628774f, 0.08942579f, 0.16485682f, 0.01855672f, 
    -0.59132707f, -0.09872364f, -0.48279279f, -0.01966480f, 0.28367233f, 0.06137055f, -0.18307008f, -0.22965747f, 
    0.32387894f, 0.18381074f, -0.24785978f, -0.15522914f, 0.17751588f, -0.21773419f, 0.03628789f, -0.06220319f, 
    -0.04379819f, 0.27880725f, 0.06635116f, -0.03542780f, 0.41758347f, 0.36492938f, -0.01023426f, 0.17271633f, 
    0.04739819f, 0.17350842f, -0.16185649f, -0.01869804f, -0.20563099f, 0.19771078f, 0.11192098f, 0.27262518f, 
    0.26170421f, 0.04963413f, 0.00306012f, 0.19288029f, 0.03388159f, 0.18705764f, -0.13012865f, -0.14242309f, 
    -0.11461678f, -0.05797914f, -0.02246350f, -0.16852988f, 0.14540872f, 0.07524890f, -0.00283988f, 0.08104978f, 
    0.22620365f, -0.08354843f, -0.36086819f, 0.11727921f, 0.09020960f, -0.07859649f, 0.06412832f, 0.22319674f, 
    -0.03125608f, 0.01511449f, 0.00147527f, -0.04640220f, -0.09288456f, -0.09835579f, -0.00529914f, 0.02891989f, 
    -0.11302976f, -0.07233701f, -0.10668319f, 0.02910776f, 0.02814036f, -0.01544745f, -0.07107842f, 0.07129352f, 
    -0.06540202f, -0.09268176f, 0.03180273f, 0.03345012f, -0.06136196f, 0.02060136f, -0.05851972f, -0.01850176f, 
    -0.08277906f, -0.05472194f, 0.04780317f, 0.00902946f, -0.09345764f, -0.01986893f, -0.02663185f, 0.06960540f, 
    -0.07679953f, -0.07943664f, -0.04991320f, 0.00614854f, -0.12177160f, -0.09164273f, -0.05512650f, -0.05184802f, 
    0.04157168f, 0.00850954f, -0.04766729f, 0.00049222f, 0.03613823f, 0.01149181f, 0.01980489f, 0.02196310f, 
    -0.00753881f, -0.07221472f, 0.04827919f, -0.09339303f, 0.03161566f, 0.01010485f, -0.07443288f, -0.03047854f, 
    0.01575345f, 0.01994881f, 0.04527496f, -0.09097104f, -0.10075748f, -0.13085705f, -0.07623821f, -0.03260011f, 
    0.01103533f, 0.00349437f, 0.00238621f, -0.00783367f, 0.01966060f, 0.01505655f, -0.05702614f, -0.10204873f, 
    -0.07945587f, -0.04503940f, -0.03672197f, -0.09138455f, -0.03217187f, 0.03362731f, -0.12985507f, -0.05565896f, 
    -0.01701124f, -0.05320627f, -0.07889424f, 0.04792988f, -0.06211201f, 0.01571763f, 0.01299920f, 0.01804300f, 
    -0.00010584f, 0.01567936f, 0.04865620f, -0.03503700f, 0.08147332f, -0.10934085f, 0.00053393f, 0.03235666f, 
    0.03877350f, 0.03399345f, -0.09004704f, 0.02306636f, -0.00572172f, -0.05673428f, -0.02794105f, 0.04937882f, 
    -0.10305423f, 0.03940955f, -0.05250632f, -0.10565834f, -0.03993320f, -0.03223526f, -0.09941839f, 0.02905435f, 
    -0.04498453f, -0.04481844f, -0.05190425f, -0.07316076f, 0.07157091f, -0.04876789f, -0.04841419f, -0.03535639f, 
    0.01339068f, 0.06035637f, -0.09961765f, 0.06144920f, -0.05844638f, -0.08524884f, -0.00565579f, -0.01796433f, 
    0.11968946f, 0.08828312f, -0.08145551f, -0.03493201f, 0.22084953f, 0.08752575f, -0.00343493f, 0.98698217f, 
    0.27022499f, -0.09633216f, 0.00638179f, 0.22520465f, -0.27661547f, 0.42092735f, 0.29845139f, 0.07270341f, 
    0.02033412f, -0.06861822f, -0.12611912f, -0.10754777f, 0.00229208f, 0.13448194f, 0.27196941f, -0.05263313f, 
    0.08493398f, -0.07679681f, -0.01721691f, -0.34028262f, -0.07531419f, 0.21083288f, -0.00863538f, 0.21348545f, 
    -0.04112523f, -0.07164178f, -0.20508619f, 0.00513639f, -0.41326809f, 0.08820280f, -0.00090849f, 0.28898495f, 
    -0.09217763f, -0.26551148f, -0.02524037f, 0.01056201f, 0.45374545f, 0.06790641f, -0.09667584f, 0.02616035f, 
    -0.07089214f, 0.27085096f, -0.07346728f, -0.16770041f, -0.01847380f, 0.04974158f, -0.12421671f, 0.01831458f, 
    -0.35338446f, -0.10156669f, -0.43866998f, 0.23856743f, 0.40407211f, 0.22077395f, -0.00349784f, 0.32692498f, 
    0.35264409f, -0.03584113f, -0.00935492f, -0.39030486f, -0.00346156f, -0.04526078f, -0.18898229f, -0.20969155f, 
    -0.11743093f, 0.06802800f, 0.21850444f, -0.32909888f, 0.05833170f, 0.08957515f, -0.11421722f, 0.02886569f, 
    -0.09115942f, -0.03524613f, 0.24669208f, -0.15271664f, 0.02138109f, -0.08597744f, -0.40667382f, 0.18173064f, 
    -0.01997936f, 0.44213453f, 0.48329303f, -0.01174237f, -0.27430242f, -0.34144175f, -0.44750240f, -0.37295938f, 
    -0.00000982f, 0.31194937f, 0.19297624f, -0.07146586f, 0.06947182f, 0.33622348f, -0.21155709f, 0.17652969f, 
    0.05134710f, 0.04365472f, -0.09249106f, 0.23674913f, 0.09012436f, 0.15691057f, -0.46215618f, 0.16230042f, 
    0.22492288f, 0.54457730f, -0.09809378f, 0.09203135f, -0.17758217f, 0.11776557f, 0.05920906f, -0.13488311f, 
    -0.13840804f, 0.35472769f, 0.15147766f, 0.57950974f, 0.08721773f, 0.00289777f, -0.15759303f, 0.20635726f, 
    0.05215746f, 0.15212645f, 0.11850832f, 0.08132257f, 0.04856044f, 0.04652355f, -0.06963796f, 0.08805752f, 
    -0.00369666f, 0.13684866f, -0.16145159f, -0.02794690f, -0.12856640f, -0.74637616f, -0.26350984f, 0.01174205f, 
    -0.01158798f, 0.10145794f, 0.11396988f, 0.26314202f, 0.24484606f, 0.09732802f, -0.23888373f, -0.08667004f, 
    0.09459508f, 0.23383772f, -0.04975289f, -0.14491130f, 0.15054132f, -0.25201440f, -0.06221486f, 0.12635170f, 
    -0.00254266f, -0.24712618f, 0.01885807f, 0.08677535f, 0.20293580f, 0.09726882f, 0.08227188f, -0.12858516f, 
    -0.05414275f, 0.07791398f, 0.07190052f, 0.41269627f, -0.43568897f, 0.02190556f, 0.10586768f, 0.29662815f, 
    0.22870691f, 0.16520783f, -0.06938676f, -0.14332563f, -0.02588893f, -0.21467763f, -0.22735581f, -0.02410297f, 
    -0.40201357f, 0.14531076f, 0.19281846f, 0.10456395f, 0.08832318f, -0.21352009f, 0.05774878f, 0.11837601f, 
    -0.44344029f, -0.14768322f, 0.00943443f, -0.00837254f, 0.06922466f, 0.08569371f, 0.10419553f, 0.03543551f, 
    -0.22903484f, -0.27241734f, -0.17761636f, -0.08618689f, 0.30793300f, 0.20617008f, -0.26434344f, -0.20347565f, 
    0.45642170f, 0.09506249f, -0.22679479f, -0.09223915f, 0.16782874f, -0.13770640f, 0.08252583f, 0.04338025f, 
    0.02050427f, -0.24012506f, 0.08113528f, 0.07675006f, 0.20011337f, 0.26834732f, -0.19302270f, 0.28585902f, 
    0.27477983f, -0.13873257f, -0.01509482f, 0.04663584f, -0.03510626f, 0.36126226f, -0.05909215f, 0.35144392f, 
    0.31986398f, -0.13028012f, 0.08738849f, 0.15366842f, 0.20626873f, -0.11215974f, -0.05586230f, -0.15718652f, 
    -0.27226433f, -0.14664881f, -0.10047553f, 0.00593089f, 0.14063984f, -0.10143557f, -0.29250357f, 0.08629265f, 
    0.13915770f, -0.40723088f, -0.40781891f, -0.11848876f, 0.19099669f, 0.07271574f, 0.09328540f, 0.08493215f, 
    -0.03163780f, -0.05225730f, 0.03574123f, 0.00624490f, -0.08921984f, 0.06598161f, 0.08813994f, -0.02616064f, 
    -0.09186639f, -0.05028351f, -0.08876924f, -0.03267728f, -0.05736784f, 0.02553595f, -0.09840368f, 0.01519599f, 
    0.00994436f, -0.05771091f, 0.05450746f, 0.00023675f, -0.04568229f, 0.04879703f, 0.07051947f, 0.07259364f, 
    -0.08106659f, -0.10656836f, -0.04221715f, 0.05618440f, -0.09638631f, -0.07770176f, -0.07812014f, -0.03731811f, 
    0.05292228f, 0.07799593f, 0.01551802f, 0.01496046f, -0.10175992f, 0.01693187f, 0.08510119f, -0.05090937f, 
    -0.02266889f, 0.04187815f, -0.02645113f, 0.01853490f, -0.04164536f, 0.05429443f, 0.01875245f, 0.04904340f, 
    -0.02661756f, -0.08569458f, -0.00094963f, -0.06513747f, 0.07376872f, 0.04837165f, -0.05088364f, -0.05321660f, 
    -0.00648586f, -0.11093514f, -0.06307561f, -0.05807936f, 0.04392009f, 0.07284064f, 0.04481015f, 0.03271773f, 
    0.02124072f, 0.03056277f, -0.09636478f, 0.01155217f, 0.02357447f, -0.07502352f, -0.02512403f, -0.08585750f, 
    -0.05280695f, 0.03342460f, -0.05330424f, -0.03116319f, -0.10481630f, -0.07874463f, 0.01822069f, -0.07192709f, 
    0.04558426f, 0.05832747f, 0.03584621f, -0.02615208f, -0.07291789f, -0.02078009f, -0.07739726f, 0.00507962f, 
    -0.03722867f, -0.00290661f, -0.02319973f, -0.02729725f, -0.03656631f, -0.05740604f, -0.04774567f, 0.02512700f, 
    0.03555928f, 0.04723705f, -0.02327152f, -0.00304931f, -0.05497969f, 0.05227491f, -0.07468752f, 0.05400596f, 
    -0.06622181f, 0.03163445f, -0.02568114f, -0.00054520f, -0.08438785f, 0.00491680f, -0.01710653f, -0.04883563f, 
    -0.06944774f, -0.00960863f, 0.03214962f, -0.03625225f, -0.00485204f, 0.01332758f, 0.03120099f, 0.00670059f, 
    -0.05723683f, 0.06458560f, -0.03287400f, -0.01522580f, -0.04960436f, 0.04982109f, -0.04684822f, 0.06253394f, 
    0.00960023f, -0.03190508f, -0.08154149f, 0.01444225f, 0.04092208f, -0.11303368f, -0.01397770f, -0.01977053f, 
    -0.10281284f, -0.05671540f, -0.08679049f, -0.00358652f, -0.07867762f, -0.06729047f, -0.03444828f, -0.04959798f, 
    -0.03786659f, -0.10442747f, 0.01414393f, -0.09026094f, 0.03696216f, -0.11509971f, 0.05393766f, 0.03571030f, 
    -0.10408647f, 0.04350885f, 0.05785583f, 0.04383035f, -0.03274567f, -0.04327132f, 0.05018231f, 0.04767351f, 
    0.05977685f, -0.02997138f, 0.00647026f, -0.03558679f, 0.07130376f, 0.05184033f, -0.07409474f, -0.08631459f, 
    0.01993614f, 0.00740919f, 0.02307172f, -0.01184103f, 0.06506646f, -0.08698967f, -0.10936422f, -0.09855425f, 
    -0.06422195f, -0.09968103f, 0.04957023f, 0.04267899f, -0.00631257f, -0.07732978f, 0.00871341f, 0.04009267f, 
    0.01745698f, -0.03969793f, -0.06387214f, -0.00590708f, 0.00145588f, -0.02895332f, 0.01665351f, 0.06350554f, 
    0.04600014f, -0.02774057f, -0.06147299f, -0.03439347f, -0.04226808f, -0.07016230f, -0.00336140f, 0.04039403f, 
    0.02167430f, -0.11216332f, 0.01280732f, 0.02672955f, -0.09114775f, 0.01297829f, -0.09285665f, -0.09901263f, 
    -0.00570024f, -0.01801900f, -0.03077294f, -0.05509785f, -0.05237459f, -0.00729555f, 0.01433322f, -0.06253427f, 
    -0.06943934f, 0.05343367f, -0.08351754f, -0.00408223f, 0.03590818f, -0.09512275f, -0.09059016f, -0.01758681f, 
    -0.07919241f, -0.00930569f, -0.03608942f, 0.07028268f, -0.01695763f, -0.00813057f, -0.05849238f, -0.10273662f, 
    -0.04351566f, -0.01835236f, -0.02437504f, -0.00684652f, 0.01205057f, -0.04985596f, -0.11111766f, -0.10784800f, 
    -0.03625765f, -0.00593743f, -0.08778267f, -0.02709964f, -0.02621929f, -0.01159865f, -0.03969019f, -0.04680203f, 
    0.05249440f, -0.01757042f, 0.02025890f, -0.08870600f, -0.03413687f, 0.00975642f, 0.02309581f, 0.03912880f, 
    0.37207082f, -0.17460908f, 0.47308305f, -0.03292260f, 0.08906570f, 0.16082448f, 0.08627711f, 0.90235347f, 
    0.01455315f, -0.03722747f, -0.04428364f, 0.24125829f, -0.20395373f, 0.32657102f, 0.11229078f, -0.06188129f, 
    0.07221963f, 0.08545931f, 0.02844121f, 0.00018846f, 0.24898633f, -0.20140119f, 0.01315806f, 0.05613622f, 
    0.15806197f, -0.15910894f, 0.04810210f, -0.33061472f, 0.18595934f, 0.18991239f, -0.10892515f, -0.23994085f, 
    -0.06215176f, -0.25290111f, -0.11021504f, -0.02252463f, -0.24162002f, -0.11766697f, -0.03022957f, 0.15606251f, 
    -0.19229721f, 0.15425701f, 0.31017408f, -0.11584989f, -0.24748929f, -0.07728698f, -0.14298859f, 0.12219644f, 
    -0.04495491f, -0.00916365f, -0.05342287f, 0.02893985f, -0.03079721f, -0.11365952f, 0.10134899f, 0.02709908f, 
    0.03480973f, -0.16132598f, 0.00663781f, 0.19155394f, 0.13147114f, 0.20768262f, -0.06534867f, 0.02544482f, 
    -0.08387214f, -0.08135179f, 0.14378347f, 0.01835246f, 0.09837258f, 0.19988357f, -0.13736039f, 0.09289902f, 
    -0.10791622f, -0.11674421f, -0.24029888f, -0.16595943f, 0.08201478f, -0.37320346f, -0.23314673f, -0.11634607f, 
    -0.01059661f, 0.11313207f, -0.09544598f, -0.05699304f, -0.00020177f, -0.12424074f, -0.09263873f, 0.13564415f, 
    -0.05636277f, 0.15035224f, 0.14923717f, 0.01805056f, 0.07866269f, 0.17316942f, -0.17169558f, 0.16423601f, 
    0.23123772f, -0.04619962f, 0.17427066f, 0.00792370f, 0.07691731f, -0.02308147f, -0.10661781f, 0.23399952f, 
    0.00071285f, -0.02048666f, -0.02159815f, 0.40179110f, 0.08429901f, 0.32952935f, -0.06255344f, -0.03122896f, 
    0.00806431f, 0.59355551f, -0.08826830f, -0.26004499f, 0.02343428f, 0.19021331f, 0.40363139f, 0.05509239f, 
    -0.02966408f, 0.08188000f, 0.30661801f, 0.29904693f, 0.29923588f, -0.02167656f, -0.01778873f, 0.07271387f, 
    0.05230357f, -0.04909846f, -0.00506741f, 0.01080833f, -0.00229606f, 0.04298040f, 0.01852022f, -0.06379875f, 
    -0.00404037f, 0.02446257f, -0.00273234f, -0.00928917f, 0.05190171f, -0.00903621f, -0.04254815f, 0.02812522f, 
    -0.05154407f, -0.08018289f, -0.02928247f, 0.01750598f, -0.04101058f, 0.06121504f, 0.05834390f, 0.07844424f, 
    -0.09269587f, 0.02940061f, -0.02653584f, -0.00277864f, -0.03204149f, -0.10994344f, 0.04083272f, 0.04396513f, 
    -0.05902825f, 0.06907433f, -0.02940495f, 0.03849469f, -0.07645959f, -0.05118579f, 0.03447623f, -0.04972912f, 
    -0.05169448f, 0.01341481f, -0.09086047f, 0.02436836f, 0.04409425f, 0.05600053f, -0.10260612f, 0.03162772f, 
    -0.02244809f, 0.05944387f, -0.08523186f, -0.02800496f, -0.07713087f, -0.09407444f, 0.07109638f, -0.07381850f, 
    0.01208522f, 0.03158105f, -0.02939530f, -0.06729959f, -0.09942302f, -0.08321305f, -0.09139851f, -0.01563283f, 
    0.05054370f, -0.01701536f, -0.04631886f, 0.06859796f, 0.00001828f, 0.03038066f, -0.05027407f, -0.06286338f, 
    -0.05411680f, 0.00486701f, -0.06841870f, -0.00171717f, -0.08294419f, -0.09680386f, -0.05577189f, 0.02625489f, 
    0.00408944f, -0.09758485f, -0.09794563f, 0.03211256f, 0.06024981f, 0.02064345f, -0.07244242f, -0.00316316f, 
    0.03869223f, -0.00329602f, 0.00402937f, -0.01682962f, -0.05703646f, -0.08821365f, -0.03487206f, -0.11170171f, 
    -0.01266689f, -0.01739076f, -0.06340200f, -0.04821026f, 0.06883141f, 0.06841086f, -0.03063183f, 0.01282824f, 
    0.05748758f, -0.00314144f, -0.07678868f, -0.07342489f, -0.01764793f, 0.00980329f, 0.03995327f, 0.01179670f, 
    -0.09245761f, 0.02095288f, -0.08894046f, 0.00153067f, 0.03411695f, 0.06790072f, 0.05645150f, -0.02644723f, 
    0.04303800f, 0.03412009f, 0.06334367f, -0.02303999f, -0.07161070f, -0.02119223f, 0.06106793f, -0.02128263f, 
    -0.05729132f, 0.24800858f, -0.32334653f, -0.04798222f, 0.18950863f, -0.02215784f, -0.08354709f, -0.46560952f, 
    0.17571178f, -0.04627217f, -0.02264368f, -0.12084316f, 0.23807792f, 0.23677117f, 0.03521557f, -0.00683919f, 
    0.03747978f, -0.03335575f, -0.02153773f, -0.14930339f, -0.31446141f, 0.01832400f, 0.18041167f, -0.07661247f, 
    -0.11571250f, -0.09796805f, 0.08355191f, 0.08446684f, 0.08333415f, 0.05820690f, 0.00726956f, 0.00910718f, 
    0.05673764f, 0.36817023f, 0.04179380f, -0.06511357f, -0.02735691f, 0.08022925f, -0.04750347f, 0.19109143f, 
    -0.01582931f, 0.08574563f, 0.06434970f, -0.20978421f, 0.25651878f, 0.12412591f, 0.12453096f, 0.10901500f, 
    0.08414716f, 0.07876154f, 0.03858885f, 0.02172232f, 0.02837633f, -0.02068761f, -0.03400479f, 0.16924237f, 
    0.17621483f, -0.04683444f, 0.11978266f, -0.09493698f, -0.15254155f, 0.04156695f, 0.13641870f, -0.10045593f, 
    0.20180394f, 0.22540213f, 0.08679195f, -0.01697351f, 0.09156767f, -0.08812372f, 0.01529420f, 0.01400222f, 
    0.32048053f, 0.12019502f, 0.30832449f, 0.07704543f, -0.01757990f, 0.07132621f, 0.11765326f, 0.28975448f, 
    -0.26444826f, -0.01745043f, 0.25914267f, 0.20916903f, -0.19877142f, 0.20162545f, 0.00863225f, 0.03892892f, 
    -0.03603046f, -0.12117834f, -0.06799892f, -0.00403969f, -0.24593936f, -0.09930301f, 0.18032369f, -0.01878669f, 
    0.05142990f, -0.00829708f, 0.15125939f, -0.07963642f, 0.28679693f, -0.01926308f, 0.12669061f, -0.02202640f, 
    -0.12208481f, -0.13571092f, 0.03525790f, 0.17030670f, 0.01677422f, -0.12317719f, 0.14315462f, 0.10692958f, 
    0.13602182f, 0.09401786f, 0.06613307f, 0.05007774f, 0.05263192f, -0.02839048f, 0.23377855f, -0.10517582f, 
    -0.23305637f, -0.01007053f, 0.10148992f, 0.18823746f, -0.02977010f, 0.15404536f, 0.06435654f, -0.14684236f, 
    -0.34591621f, -0.15534189f, -0.05436344f, -0.39722946f, -0.27071092f, 0.17602527f, -0.03870606f, 0.17299578f, 
    -0.29212111f, -0.02072957f, 0.10644492f, 0.16125306f, 0.05785796f, -0.31332296f, -0.13011976f, 0.02598684f, 
    0.07042145f, -0.41915661f, -0.21543986f, 0.09573403f, -0.16114923f, 0.04399766f, -0.01209182f, 0.02310226f, 
    0.05786094f, 0.17278939f, 0.03723280f, 0.11544115f, -0.22175704f, 0.07399097f, -0.04320640f, -0.02957926f, 
    -0.05605116f, 0.33719313f, 0.13286264f, 0.02611835f, -0.13925052f, 0.06724801f, 0.04174392f, -0.35945210f, 
    0.34772620f, 0.08248048f, 0.15070924f, 0.24645655f, -0.39672589f, -0.09276248f, 0.12845299f, -0.49098939f, 
    -0.25174159f, 0.04821399f, -0.06934262f, 0.34062797f, 0.03231660f, 0.07837369f, 0.08143248f, -0.09133811f, 
    -0.06300628f, -0.01415936f, -0.00225922f, 0.25804490f, 0.14371891f, 0.15154195f, -0.16064054f, 0.31698924f, 
    0.15600066f, -0.12270863f, -0.51074177f, 0.34251738f, 0.05459006f, -0.09335898f, 0.13164638f, -0.26020890f, 
    0.06149028f, -0.17473587f, -0.21304043f, -0.14838989f, -0.02018150f, -0.00597675f, 0.26927647f, -0.20365676f, 
    0.30304819f, -0.17213820f, 0.08089433f, -0.12413714f, 0.18111505f, -0.14755720f, 0.17614308f, 0.20200738f, 
    0.03506510f, 0.05301020f, -0.14789292f, 0.04232464f, 0.12616564f, -0.01938302f, -0.11405687f, -0.05880455f, 
    -0.04731872f, 0.10371907f, -0.08098838f, -0.00094899f, -0.22184007f, -0.14524288f, 0.03413238f, -0.00173439f, 
    -0.30563104f, 0.12037913f, 0.37803108f, -0.88774830f, -0.11188064f, -0.36771512f, 0.00535279f, 0.08615416f, 
    -0.07472638f, -0.02668960f, 0.03807950f, 0.16843998f, -0.51761818f, -0.10034069f, 0.44505715f, 0.09780954f, 
    0.20707338f, 0.16490650f, 0.20099933f, 0.01991148f, -0.23075260f, 0.15113880f, -0.18693808f, 0.01948704f, 
    0.23799589f, 0.06728289f, 0.00412678f, 0.36503944f, 0.13783853f, -0.10916727f, 0.02535589f, -0.25767523f, 
    0.17274110f, 0.12144278f, 0.14956279f, -0.11259944f, -0.02843439f, 0.17164385f, 0.15090623f, -0.00904389f, 
    0.03885919f, 0.13361681f, 0.29971284f, 0.06755992f, 0.00663153f, 0.07830987f, -0.08611058f, 0.07475536f, 
    0.26730794f, -0.06652410f, -0.04400359f, 0.01384807f, 0.20492470f, 0.41898170f, 0.00667881f, 0.01640100f, 
    -0.07116643f, -0.07740799f, -0.20622624f, -0.04952854f, 0.02661745f, 0.32720360f, -0.04015066f, 0.31617600f, 
    0.01362400f, -0.09377180f, 0.22776410f, 0.08378417f, -0.40429527f, 0.03759549f, 0.21085456f, 0.23944280f, 
    0.35877538f, 0.06701422f, 0.07983488f, -0.17306302f, 0.07846653f, -0.04997442f, -0.51053518f, 0.07779972f, 
    -0.24969664f, 0.05762472f, 0.02529359f, -0.07234488f, -0.02086261f, -0.03468470f, 0.15677035f, -0.20209374f, 
    -0.12470771f, 0.10256127f, 0.45547751f, -0.05711421f, -0.06251712f, 0.08096231f, -0.07655612f, 0.26691973f, 
    0.01293248f, 0.13667960f, 0.16537836f, -0.00049299f, 0.15397818f, -0.04814163f, -0.11702987f, 0.03122122f, 
    0.26968914f, 0.20770997f, 0.02068318f, 0.13933195f, 0.08884115f, 0.25047866f, -0.12406460f, 0.16744691f, 
    -0.07211033f, -0.04277318f, -0.47427708f, -0.04588309f, -0.08239162f, 0.10863195f, 0.07979597f, 0.03521921f, 
    0.14587705f, -0.13877989f, 0.07108445f, 0.01553247f, 0.12518497f, 0.12657301f, -0.22750032f, 0.00562078f, 
    0.19005483f, -0.11842628f, -0.07643954f, 0.28540197f, 0.20655327f, 0.00321679f, -0.01613370f, -0.03363533f, 
    -0.09000795f, -0.18291521f, 0.07512037f, 0.16655967f, 0.39353612f, -0.03983216f, -0.60521257f, -0.05506531f, 
    -0.05752525f, 0.06507964f, 0.06503657f, 0.05878989f, 0.16226107f, -0.04888122f, 0.20989080f, 0.00001055f, 
    -0.04520487f, 0.05708479f, -0.02921401f, -0.07455791f, -0.07368904f, -0.00400049f, 0.03804691f, -0.04294564f, 
    -0.00695098f, 0.04021295f, 0.04213106f, -0.05755845f, 0.04699854f, -0.11870528f, -0.00807717f, -0.03853608f, 
    -0.01654759f, -0.08695271f, -0.12047166f, 0.00324898f, -0.03337895f, -0.01249740f, -0.03813450f, 0.02076953f, 
    -0.04962295f, 0.06006065f, -0.02836249f, 0.01705887f, -0.10107290f, -0.08284692f, -0.07156995f, -0.01931260f, 
    0.02634751f, 0.00953472f, 0.00548228f, 0.04589676f, 0.04895426f, -0.01023148f, -0.07750946f, -0.12974806f, 
    0.07207222f, 0.05484283f, -0.02782158f, -0.03801517f, -0.07819363f, -0.03329167f, 0.02231950f, -0.07697728f, 
    -0.07630672f, -0.11657441f, 0.05201593f, -0.08018011f, -0.12984891f, 0.01713639f, 0.06786992f, 0.03703544f, 
    0.02841798f, 0.02004755f, -0.05620566f, 0.04003502f, -0.00670521f, -0.02148124f, 0.01815686f, -0.01999949f, 
    -0.01886479f, 0.05596564f, 0.00188469f, -0.04446398f, 0.04563431f, -0.01274814f, 0.01044621f, -0.08831469f, 
    -0.03805685f, -0.07611255f, -0.03707437f, -0.04514655f, 0.00873859f, -0.09968358f, -0.13613124f, -0.04969808f, 
    0.00573174f, -0.03771857f, -0.07281392f, 0.04315569f, -0.11958533f, 0.01552422f, 0.03639202f, -0.02508122f, 
    0.08298092f, -0.04429140f, 0.04962632f, -0.01731480f, -0.00395737f, -0.02563013f, -0.10751508f, -0.08137850f, 
    0.01348080f, 0.03380577f, 0.06731025f, -0.05338679f, 0.00967817f, 0.00100758f, 0.05491584f, -0.11383769f, 
    0.04429127f, -0.07022519f, -0.00604521f, 0.04917299f, 0.01785382f, 0.05087512f, -0.03269882f, -0.01070793f, 
    -0.10538925f, 0.00206144f, -0.01533494f, 0.07612064f, 0.05920975f, -0.00844469f, -0.09188171f, 0.01506270f, 
    0.01175050f, -0.06569710f, -0.08367734f, 0.04897230f, 0.06881546f, 0.01872022f, 0.00608987f, 0.08198962f, 
    0.11328354f, -0.09485152f, 0.12103498f, 0.08886810f, -0.12523741f, 0.11704015f, -0.08540732f, -0.20961000f, 
    0.00540442f, 0.16629647f, 0.16666608f, -0.19657694f, -0.04711778f, 0.36716667f, 0.01602371f, 0.07762084f, 
    -0.06769095f, 0.37727606f, 0.21267976f, 0.08377636f, -0.02551062f, 0.05193674f, -0.07563412f, 0.03031594f, 
    -0.10907976f, 0.28895089f, 0.07929012f, 0.22913066f, 0.08509930f, 0.20763978f, -0.04631706f, -0.06558584f, 
    0.06287340f, -0.10200392f, 0.24092002f, 0.07510062f, 0.25602347f, 0.14859073f, 0.06718034f, -0.17871042f, 
    0.20509006f, 0.02882749f, -0.18461600f, 0.13890587f, 0.01125907f, -0.23388357f, -0.41316763f, -0.03135352f, 
    -0.11032926f, -0.04279081f, -0.02558999f, 0.12461599f, 0.18848626f, 0.02494569f, 0.08250304f, -0.07887122f, 
    -0.27419165f, -0.08581265f, -0.06630100f, -0.04721954f, -0.07368043f, -0.21350898f, 0.11252467f, 0.17516237f, 
    -0.10391854f, -0.16841187f, -0.16582251f, 0.05070456f, 0.02953609f, -0.09682564f, 0.12551245f, 0.35720086f, 
    -0.13254839f, 0.13780771f, -0.11086024f, 0.01623194f, 0.11845064f, 0.20751427f, 0.16061434f, -0.02423307f, 
    -0.00093157f, -0.50030220f, 0.16120040f, 0.09666353f, 0.18718556f, -0.05333797f, 0.26104107f, -0.22170140f, 
    0.10994977f, -0.10616658f, 0.18992552f, 0.04791712f, 0.36393338f, 0.22042647f, 0.28021196f, -0.08081781f, 
    -0.48937249f, 0.10515144f, 0.24143656f, 0.01121671f, 0.25717759f, -0.12692164f, -0.24855427f, -0.16445322f, 
    -0.01603550f, 0.24930795f, 0.04561570f, -0.54859680f, -0.26939207f, -0.30046234f, 0.02553652f, -0.00253704f, 
    0.02185400f, -0.38713479f, 0.13012066f, -0.07408506f, -0.06475385f, 0.07497362f, 0.45613670f, 0.08113962f, 
    0.18213764f, -0.19702782f, -0.11288272f, -0.29556450f, -0.27999213f, -0.10839331f, -0.26622045f, 0.20375510f, 
    -0.08608291f, 0.03255913f, -0.05010791f, 0.03360583f, -0.00992841f, -0.12404466f, -0.00488183f, 0.07413777f, 
    0.02796764f, -0.01184851f, -0.09174636f, -0.01403728f, -0.08756489f, -0.00536561f, -0.04557117f, -0.05157423f, 
    0.08690370f, -0.03619103f, -0.08805099f, -0.11188561f, -0.05957983f, 0.00556563f, 0.04415059f, 0.08208372f, 
    -0.04496054f, 0.03600809f, -0.08774658f, -0.06350221f, -0.10270652f, 0.06594300f, -0.02213846f, -0.03390078f, 
    -0.07057256f, 0.03990559f, -0.03707942f, 0.05957801f, -0.06296378f, 0.01580103f, 0.02903797f, -0.03567456f, 
    -0.01160469f, -0.11235364f, -0.00236435f, 0.01598556f, -0.04565499f, -0.11850071f, 0.04174943f, 0.01293205f, 
    -0.01469451f, 0.05623864f, 0.05215140f, -0.09271891f, -0.02113867f, 0.06390473f, -0.06682244f, -0.09787714f, 
    -0.07819068f, -0.03651994f, -0.00440166f, -0.09937448f, -0.05734903f, 0.01456415f, -0.05140171f, -0.03244035f, 
    -0.00710178f, -0.07532743f, -0.13201904f, 0.00709675f, 0.04046157f, 0.02546764f, -0.11950524f, -0.01967074f, 
    0.01703086f, 0.06571367f, 0.00283875f, -0.06812033f, -0.01918153f, -0.01760645f, -0.00495819f, 0.03705144f, 
    -0.03239876f, 0.02167082f, 0.00756219f, -0.10659371f, -0.09904380f, -0.00491575f, -0.01917145f, -0.00422634f, 
    0.02989000f, -0.04479554f, -0.06079715f, -0.02113998f, -0.10876506f, 0.04917179f, -0.01230528f, -0.07548242f, 
    0.03089247f, -0.09900894f, -0.00184395f, 0.02728147f, 0.03279838f, -0.11656952f, -0.04085546f, 0.03155279f, 
    0.04567504f, -0.01440355f, -0.00464924f, -0.09518179f, -0.09008949f, 0.05157299f, 0.02655925f, -0.10899962f, 
    -0.10360432f, 0.06837352f, -0.02770024f, 0.02573002f, -0.05429014f, -0.02809169f, -0.06398351f, 0.02735286f, 
    -0.11649119f, 0.07646173f, -0.04534002f, 0.04482414f, -0.10879655f, -0.06753136f, -0.03745803f, 0.01574961f, 
    -0.30349287f, 0.19614109f, 0.05697273f, 0.20941132f, 0.16199727f, 0.19871475f, -0.07117982f, -0.03184390f, 
    0.25788936f, -0.28140077f, -0.07585617f, 0.19047889f, -0.43444106f, -0.16960123f, -0.36941817f, -0.02720423f, 
    -0.05612236f, 0.12633085f, -0.13484661f, -0.11562669f, 0.57313108f, 0.16572700f, 0.41014984f, -0.00161675f, 
    -0.01350691f, -0.13242988f, 0.10368719f, -0.73207414f, -0.03419438f, 0.58974135f, -0.01184489f, 0.16850998f, 
    0.00541411f, -0.24102531f, -0.17374049f, 0.04733989f, 0.09825613f, 0.17355026f, 0.04805966f, 0.08086910f, 
    -0.04973597f, 0.14510882f, -0.07392481f, 0.41611159f, 0.33854374f, 0.10080818f, -0.09079926f, 0.06159435f, 
    -0.12541123f, 0.12604272f, 0.07503415f, -0.71621674f, -0.05392073f, 0.26543716f, -0.05955941f, 0.05146733f, 
    -0.25379226f, 0.27812713f, 0.00190445f, -0.41167718f, 0.05410826f, -0.17258386f, 0.21937628f, 0.33915472f, 
    -0.15943731f, 0.29566860f, -0.00441406f, 0.13415295f, 0.06474769f, -0.07891531f, -0.14834675f, -0.59560585f, 
    0.35368785f, 0.12327797f, 0.20053567f, 0.00839698f, -0.13666311f, -0.02854978f, 0.08634654f, 0.29646233f, 
    -0.10718711f, 0.06288769f, 0.36721930f, 0.25505590f, -0.42498428f, -0.02991117f, -0.36458334f, -0.02334529f, 
    0.01654387f, 0.35672849f, 0.41821367f, -0.07722183f, -0.14061682f, -0.18009244f, -0.27820447f, -0.06207301f, 
    -0.04049838f, 0.40902922f, -0.16099487f, 0.04549856f, 0.13329147f, 0.31519952f, 0.07579913f, -0.06126032f, 
    0.15259646f, 0.05008741f, -0.51958048f, -0.44681737f, 0.10082171f, -0.23885502f, -0.36244676f, 0.15615699f, 
    -0.14354326f, -0.16901200f, -0.07148693f, 0.14156026f, -0.23137835f, 0.16199587f, -0.33997828f, -0.20234235f, 
    -0.19666898f, 0.36512572f, -0.13728869f, 0.25487337f, -0.01562243f, -0.06460150f, -0.19526210f, 0.20902061f, 
    0.00359755f, -0.10741869f, -0.07192475f, 0.08425094f, 0.06529170f, 0.01996515f, 0.06916693f, -0.02299565f, 
    -0.05218880f, -0.03513643f, 0.00259889f, -0.02195125f, 0.01723932f, 0.03502536f, -0.08150207f, 0.07600260f, 
    -0.05533950f, 0.01310212f, 0.00462344f, -0.03652168f, -0.08097730f, 0.02224299f, 0.02394699f, -0.04667018f, 
    -0.04500839f, 0.03093006f, 0.08611421f, 0.07613289f, -0.03534828f, 0.01580891f, -0.00560449f, -0.07911319f, 
    -0.03777065f, -0.07914931f, -0.08132245f, -0.08772744f, 0.05798256f, -0.09817474f, -0.00947962f, -0.06153773f, 
    -0.05707714f, -0.03674522f, -0.10009833f, 0.03939059f, -0.02282904f, 0.02628650f, -0.02916890f, 0.06095025f, 
    -0.08553386f, -0.08742787f, 0.07666060f, -0.09884953f, -0.07748433f, 0.01451295f, -0.15314998f, 0.00302117f, 
    -0.00045067f, -0.00586395f, -0.06791844f, -0.04834652f, -0.02458808f, -0.02842744f, 0.07228888f, 0.05778586f, 
    0.02011815f, -0.03419627f, 0.03195517f, -0.01923912f, 0.02376760f, -0.05973408f, 0.03321579f, -0.05244308f, 
    -0.00662437f, 0.00016367f, -0.02078638f, -0.10077297f, 0.06736878f, 0.06147012f, -0.06736617f, -0.03971627f, 
    0.01936961f, -0.09243225f, 0.07618246f, -0.01650824f, -0.01280917f, 0.00037283f, 0.01517882f, -0.11577657f, 
    -0.08823539f, 0.00368015f, -0.08817564f, 0.04850560f, -0.04089859f, 0.06373743f, -0.04554500f, -0.08904071f, 
    -0.08053732f, 0.02496016f, 0.02921328f, -0.07652601f, -0.05116808f, -0.09336577f, 0.04555355f, 0.00046421f, 
    -0.10675060f, 0.04287701f, -0.10316224f, -0.16179921f, 0.00740192f, 0.02652975f, 0.04118196f, -0.03896786f, 
    0.00664264f, 0.00790498f, -0.08084581f, -0.04515769f, 0.01285917f, 0.05884885f, -0.09316545f, 0.07318112f, 
    -0.04858495f, -0.04019094f, -0.04880157f, -0.05986229f, 0.04861851f, 0.07903886f, -0.00779740f, 0.07491285f, 
    0.06123774f, 0.02511088f, -0.09028494f, 0.03615873f, -0.06497162f, -0.03505318f, 0.03713626f, 0.07650251f, 
    -0.09990779f, 0.03592148f, -0.01951987f, -0.03296800f, -0.08605751f, -0.11663509f, -0.11862004f, 0.02082451f, 
    -0.04537650f, -0.00570395f, -0.01572471f, -0.06642470f, -0.07640021f, 0.05868136f, 0.01588687f, -0.06163168f, 
    -0.05669228f, 0.00145553f, -0.01435331f, -0.02916126f, -0.09035224f, -0.05543922f, -0.02891315f, 0.02576984f, 
    -0.06890377f, -0.08990829f, -0.06180118f, -0.03576999f, 0.07311662f, -0.04849939f, 0.02809606f, 0.02538425f, 
    -0.04767642f, -0.01952429f, -0.03720938f, 0.02093885f, 0.08436897f, -0.06800882f, 0.07952464f, 0.04933256f, 
    -0.07519478f, 0.06139110f, -0.05593266f, -0.05557791f, -0.09495295f, -0.10791312f, 0.00437006f, 0.00297010f, 
    -0.07002576f, -0.01429946f, 0.01518488f, 0.02991586f, 0.08262712f, -0.01042555f, -0.08834271f, -0.05207221f, 
    -0.07148881f, -0.00824449f, -0.09902766f, 0.05244265f, 0.05797590f, 0.00495315f, 0.05750848f, -0.07394903f, 
    0.01027125f, -0.09466907f, -0.06126049f, -0.01889113f, -0.07860009f, -0.08911452f, -0.04354665f, -0.00382225f, 
    -0.02510089f, -0.04315026f, 0.06317444f, -0.04709272f, 0.01983504f, -0.05522818f, -0.02440908f, 0.03370668f, 
    0.06846340f, -0.14995497f, -0.01879800f, 0.07645501f, 0.03629818f, -0.05012995f, 0.00839295f, -0.05512938f, 
    -0.00856096f, 0.04346851f, 0.06983612f, -0.05116822f, 0.04699777f, 0.01848679f, 0.04458980f, 0.00966853f, 
    -0.06817614f, -0.13464840f, 0.07279401f, -0.10985269f, -0.02498732f, -0.03685917f, 0.05462991f, -0.02876255f, 
    -0.13917464f, -0.01013052f, -0.07237010f, -0.01040246f, -0.04000027f, -0.02233756f, 0.02068351f, 0.01250408f, 
    -0.06890676f, 0.03610957f, -0.07535109f, -0.09953513f, 0.03343776f, 0.00513293f, 0.02173605f, -0.11639710f, 
    -0.03979884f, 0.03869778f, -0.07698525f, 0.20055327f, -0.07265882f, 0.09658899f, -0.04808512f, -0.09193662f, 
    0.03232130f, -0.01502261f, 0.08164756f, 0.22583681f, 0.01500872f, 0.28723928f, 0.09003891f, -0.05590148f, 
    0.01659062f, -0.02289117f, 0.06885722f, -0.14018118f, -0.10910275f, 0.19854212f, 0.22549292f, -0.01384682f, 
    0.13610621f, 0.02010597f, 0.07450420f, 0.00644683f, -0.07294852f, 0.25385839f, -0.02047288f, 0.27863589f, 
    -0.08248725f, -0.29020768f, -0.12004664f, 0.08018784f, 0.15343902f, 0.19002239f, 0.02039425f, 0.28483853f, 
    0.03475515f, -0.08565694f, -0.02250777f, 0.10292600f, -0.14798009f, -0.01999227f, 0.14965230f, 0.06487991f, 
    0.09108064f, 0.08202965f, 0.07191106f, 0.12257041f, -0.00545163f, 0.10693237f, -0.36012426f, -0.09068223f, 
    -0.03047041f, 0.20974801f, -0.26167530f, 0.00174658f, 0.11694948f, -0.11162412f, 0.22160183f, 0.17823158f, 
    0.21015228f, 0.03806104f, 0.08890811f, -0.04838311f, -0.04590652f, -0.08780066f, 0.14470664f, 0.12071436f, 
    0.21334969f, 0.17760801f, 0.30372477f, -0.22923864f, 0.00187990f, 0.02405882f, 0.07271611f, 0.02208224f, 
    -0.37505460f, -0.02394640f, 0.28801256f, -0.14479700f, -0.17363238f, 0.13823800f, -0.08188962f, 0.05429749f, 
    -0.04107422f, 0.01046826f, 0.36468276f, -0.05179986f, 0.09325678f, -0.07402605f, 0.13203491f, -0.23973350f, 
    -0.13127403f, 0.05014685f, 0.04809224f, -0.07400724f, -0.14497477f, -0.04416345f, -0.06304666f, 0.09800280f, 
    -0.03736205f, 0.01013380f, -0.12347645f, -0.67040837f, 0.01857270f, 0.18254529f, 0.06664277f, -0.00027510f, 
    0.06287155f, -0.06810940f, 0.22302198f, 0.23299728f, -0.05911243f, -0.06359668f, -0.37022519f, -0.03726203f, 
    0.10034051f, 0.00384486f, 0.04179435f, -0.04325772f, -0.02044085f, 0.12620543f, -0.06514967f, -0.01772473f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03778008f, 0.02920682f, -0.03642729f, 0.10831758f, 0.13491800f, -0.14770162f, -0.00908780f, -0.03010895f, 
    0.03409033f, -0.10361428f, 0.05973687f, -0.04835281f, -0.09868812f, -0.03075574f, -0.04959099f, 0.13298409f, 
    0.15601389f, -0.09224322f, 0.17740653f, 0.13117084f, 0.01423559f, -0.05819779f, 0.10514434f, -0.05561643f, 
    0.14028013f, 0.03627562f, -0.09174802f, 0.24301782f, 0.07170638f, 0.01587266f, -0.12897801f, 0.18121798f, 
    0.06395804f, -0.02574221f, 0.01131532f, -0.03131986f, 0.02599154f, 0.23357952f, -0.01161729f, 0.07267094f, 
    0.17795892f, 0.12534368f, 0.13061664f, -0.03400801f, 0.21564277f, -0.10420380f, 0.04210764f, 0.12727469f, 
    -0.02232276f, -0.08275982f, -0.10494916f, 0.23609585f, -0.04655731f, -0.09167124f, 0.00441185f, 0.05798490f, 
    0.22266549f, 0.03291237f, -0.02467320f, -0.06569558f, -0.09476697f, -0.04037364f, 0.09521758f, 0.07606430f, 
    -0.00211656f, 0.15035583f, 0.22226463f, 0.04566190f, 0.05042424f, 0.01020761f, -0.09216470f, 0.12017965f, 
    -0.04499947f, -0.10692032f, 0.09990995f, 0.15346697f, -0.05392851f, 0.01672350f, -0.09064930f, -0.02363729f, 
    0.14033042f, 0.06602251f, -0.06629608f, -0.03929707f, 0.12009262f, 0.06612328f, -0.08043256f, 0.03390928f, 
    0.03717142f, -0.03398516f, -0.00941259f, 0.01928043f, -0.01479091f, 0.01622613f, -0.00479138f, 0.19230928f, 
    -0.07628626f, -0.04875333f, 0.14842746f, -0.01988915f, -0.05493775f, -0.09879577f, 0.05896539f, 0.07888420f, 
    0.00461894f, -0.05904454f, 0.11987367f, 0.01593104f, 0.03113993f, -0.02948899f, 0.04416330f, -0.09097096f, 
    0.05851014f, -0.10202725f, -0.01563076f, -0.03981772f, 0.05326242f, 0.05676723f, 0.05323466f, -0.06806801f, 
    0.26140353f, -0.01077090f, -0.17508446f, -0.04574817f, 0.10234835f, -0.10472370f, -0.09661157f, 0.10069818f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.02802666f, 0.26473388f, -0.27202973f, -0.01983379f, -0.02069156f, -0.86364967f, -0.11059621f, -0.02969781f, 
    -0.05823152f, 0.06697338f, 0.03880093f, -0.12921698f, 0.01203708f, 0.03055121f, 0.07411259f, 0.29668757f, 
    0.08713792f, -0.17997673f, 0.11571499f, -0.13149782f, -0.04525664f, -0.02601521f, 0.31334969f, -0.11523477f, 
    0.12737587f, 0.21176048f, -0.08320124f, -0.42605361f, -0.25171277f, -0.05912001f, -0.19683309f, 0.17928022f, 
    -0.14354672f, -0.08603209f, 0.17015618f, -0.09152352f, 0.21265514f, 0.04862455f, -0.11328283f, 0.12760131f, 
    -0.20381197f, 0.24012995f, 0.00253898f, 0.01994622f, 0.03753332f, -0.02205212f, 0.15135713f, -0.16799703f, 
    -0.20909368f, -0.09492019f, -0.11258630f, -0.31142220f, -0.39842704f, 0.04754572f, 0.24742830f, 0.23963515f, 
    -0.27740383f, 0.06150005f, -0.09043922f, -0.24319734f, 0.20950866f, 0.03526977f, 0.11917612f, 0.17176799f, 
    0.08137459f, -0.10754552f, -0.42243156f, -0.07278808f, 0.01451407f, 0.00527491f, -0.01325093f, 0.24929622f, 
    0.07176092f, -0.02966690f, 0.07742900f, -0.20436668f, -0.02591723f, -0.16832238f, -0.01212261f, 0.05689474f, 
    -0.33481520f, -0.01392321f, 0.10463030f, 0.14077744f, -0.08947013f, -0.00708814f, 0.04447355f, -0.09256903f, 
    0.22117102f, -0.24250539f, 0.20942262f, -0.04112411f, 0.03089828f, 0.04767412f, -0.29153737f, 0.01478859f, 
    -0.37977314f, -0.25345564f, -0.55481374f, -0.02085608f, -0.09565657f, -0.07976180f, -0.30181527f, -0.69678122f, 
    -0.00235502f, 0.15786430f, 0.23872654f, 0.25922969f, 0.04134647f, -0.01029739f, -0.13578637f, 0.02635794f, 
    0.06663639f, -0.51522690f, -0.02905924f, -0.10935201f, 0.37591070f, -0.02119838f, 0.02706446f, -0.13983642f, 
    -0.10246398f, -0.01978291f, -0.44772670f, -0.08373798f, -0.52248269f, -0.03326576f, -0.06287263f, -0.15469699f, 
    0.01010181f, -0.01455514f, 0.09394646f, 0.09360145f, -0.52728939f, -0.29106992f, 0.04542274f, 0.05594194f, 
    0.05155653f, -0.00353594f, 0.21526246f, 0.23759113f, 0.06971382f, 0.17347887f, 0.05093668f, 0.14424719f, 
    -0.07900931f, -0.01908468f, 0.06448538f, 0.14832258f, -0.07424484f, -0.04198953f, 0.15549412f, -0.00872285f, 
    -0.19033678f, 0.23508301f, -0.02255534f, -0.09817359f, -0.11701187f, 0.05358300f, -0.04683935f, 0.14223088f, 
    -0.11608535f, 0.00917862f, 0.05814867f, 0.01877236f, -0.03662220f, -0.34994522f, 0.09986138f, 0.05400005f, 
    -0.22934569f, 0.01697947f, -0.33628097f, 0.09140855f, -0.00532418f, -0.08469217f, -0.06953616f, -0.08786337f, 
    -0.12893401f, -0.05776216f, 0.35093582f, -0.85047632f, 0.24682862f, -0.01059033f, -0.27580681f, -0.02076841f, 
    -0.18383969f, -0.09585808f, 0.31310382f, 0.24554177f, -0.14701380f, 0.00725326f, 0.12989685f, -0.22241542f, 
    -0.04384049f, 0.07607482f, -0.73067391f, 0.00548052f, -0.01097802f, -0.04850931f, 0.07016991f, -0.25843748f, 
    -0.05839421f, -0.03645727f, -0.27320164f, -0.15937243f, 0.01315057f, -0.19174229f, -0.06973663f, 0.12649937f, 
    0.22982202f, -0.05378173f, -0.12222274f, 0.18127042f, -0.32476085f, -0.02719947f, 0.03638752f, 0.03363371f, 
    -0.35119370f, -0.06177155f, 0.25548947f, -0.05732862f, -0.03022383f, -0.09217569f, 0.24132457f, 0.03015127f, 
    0.12339889f, 0.56728399f, 0.20605092f, -0.04046912f, -0.10297938f, -0.03904306f, -0.32660624f, -0.28660420f, 
    -0.04473803f, 0.20180178f, -0.27311692f, -0.00843336f, -0.33937234f, -0.02600984f, 0.35456392f, -0.06609100f, 
    -0.21298403f, 0.17762010f, -0.02937140f, 0.00902384f, 0.19667058f, -0.08069107f, -0.27734911f, 0.44293779f, 
    0.14652787f, -0.11084323f, -0.14460540f, 0.03074612f, -0.31116399f, -0.08318877f, -0.01293951f, -0.22583942f, 
    -0.03391746f, 0.42607027f, -0.21293868f, 0.12490280f, -0.05394189f, -0.31445369f, -0.20987827f, -0.00508758f, 
    -0.02684568f, -0.09380961f, -0.12437650f, -0.41725057f, 0.06626815f, -0.47362670f, -0.13206719f, 0.27496970f, 
    -0.06074437f, -0.50478876f, 0.07144270f, -0.12976430f, 0.01751458f, -0.07303188f, 0.33909863f, -0.25317001f, 
    -0.50937486f, -0.39419612f, 0.08291256f, 0.00551159f, 0.03008476f, -0.05110078f, -0.27880991f, 0.24969734f, 
    0.10899690f, 0.00693268f, -0.03783714f, 0.03691697f, 0.06644783f, 0.00059693f, 0.32228372f, -0.12219990f, 
    0.05161974f, 0.12369315f, -0.43451223f, 0.05233022f, 0.02360691f, -0.02509130f, -0.67789125f, 0.16553064f, 
    -0.40267304f, -0.06742118f, -0.07759923f, -0.01801252f, 0.05599198f, -0.08399254f, -0.59751725f, 0.35053858f, 
    0.07930464f, 0.05828067f, -0.30760452f, 0.07243270f, -0.52671134f, 0.00194918f, 0.13512552f, 0.07727097f, 
    -0.02779438f, 0.09089261f, -0.15732405f, 0.08070966f, -0.05157087f, -0.03714369f, -0.05074278f, -0.05269447f, 
    -0.01946766f, -0.01224180f, -0.16489060f, 0.28869519f, 0.00043311f, 0.00849175f, -0.01144647f, -0.38034511f, 
    -0.47703734f, -0.64071429f, -0.26986080f, -0.63335901f, -0.08099533f, 0.12966388f, 0.07339747f, 0.27171335f, 
    0.17495076f, 0.13823800f, -0.35142541f, -0.05769846f, 0.07047772f, 0.04604610f, 0.22414577f, 0.14115058f, 
    -0.53491366f, -0.21885920f, 0.15526780f, -0.00440084f, -0.07206390f, -0.04806818f, 0.07002141f, 0.21406600f, 
    -0.02239015f, -0.57535172f, 0.22092634f, 0.09270524f, -0.28888232f, 0.02082037f, -0.17387782f, 0.03702898f, 
    0.12894699f, 0.06224269f, -0.01345936f, 0.01002665f, 0.16007616f, 0.06307613f, 0.05752412f, -0.43895078f, 
    0.15557520f, 0.02466037f, -0.16794443f, -0.02933994f, -0.22482924f, -0.11772697f, -0.09104472f, -0.32127699f, 
    0.03347093f, -0.19544479f, -0.05764488f, -0.32014742f, 0.23391728f, -0.38445660f, 0.22688352f, 0.03138381f, 
    0.03338450f, -0.03543521f, -0.14896742f, 0.05623092f, -0.05527400f, -0.19727336f, -0.14420740f, -0.16465753f, 
    -0.45912838f, 0.16676678f, -0.20021999f, 0.04489688f, 0.04166805f, 0.04587015f, -0.16723643f, -0.21721774f, 
    0.03374281f, -0.06299914f, 0.00006235f, -1.28807735f, 0.06006094f, 0.02706968f, 0.04645430f, -0.36912763f, 
    0.14193717f, 0.07152464f, -0.04016894f, -0.05399578f, 0.10184038f, 0.05076564f, -0.03220721f, -0.63286638f, 
    0.11037660f, -0.00226580f, 0.07256947f, 0.00991972f, -0.60540324f, -0.05362343f, 0.10737916f, -0.25925997f, 
    0.05086097f, 0.01059682f, -0.28705895f, -0.24292533f, 0.28881338f, -0.01310830f, 0.07867780f, 0.16466083f, 
    0.15984894f, 0.08708098f, 0.18528129f, 0.02546921f, 0.17746522f, -0.08513941f, -0.10316726f, 0.11755077f, 
    0.08580658f, -0.42762360f, -0.47955450f, -0.08265419f, 0.07726613f, -0.04512770f, 0.02685034f, -0.01741538f, 
    0.05704245f, 0.01252037f, 0.19037986f, -1.31647289f, -0.10597598f, 0.43146375f, 0.08210588f, -0.28108326f, 
    0.00893269f, 0.22806406f, -0.65782785f, 0.03601580f, -0.48537478f, 0.14985803f, -0.01405707f, -0.18472750f, 
    0.08893146f, 0.00157591f, -0.53451443f, -0.03862838f, 0.01262629f, -0.07534838f, -0.10541937f, 0.11736388f, 
    0.27396500f, 0.19867437f, 0.05493160f, -0.02930441f, -0.00995981f, 0.08087700f, -0.13683741f, 0.33182317f, 
    -0.05152830f, 0.29015404f, -0.13152112f, 0.14836738f, 0.02778397f, -0.09795786f, 0.31139341f, -0.07806651f, 
    0.30586571f, 0.42864257f, -0.09740519f, 0.06928263f, -0.03106301f, -0.04574260f, 0.12184980f, 0.19880927f, 
    -0.60702515f, -0.02088743f, -0.13211972f, -0.06814951f, 0.06726602f, -0.02707157f, 0.00530108f, 0.01345503f, 
    -0.10021173f, -0.05944625f, 0.07494547f, -0.08922490f, 0.20907207f, -0.53609467f, 0.13552935f, 0.03679510f, 
    -0.00530939f, -0.00166232f, 0.11717622f, -0.47503442f, 0.04455696f, -0.03408361f, 0.16392712f, 0.22488505f, 
    0.01453109f, -0.20457588f, 0.08870572f, -0.01663927f, 0.04837251f, -0.06491014f, 0.09554161f, 0.00743763f, 
    0.13415563f, -0.18005416f, 0.07189038f, 0.26902038f, -0.01044788f, 0.07104252f, 0.08628412f, 0.11721736f, 
    0.05480774f, 0.05960061f, 0.03705796f, -0.06934196f, 0.03054171f, 0.15533940f, -0.31454462f, 0.01580827f, 
    0.13998637f, 0.06316164f, 0.16617608f, 0.00932114f, -0.01836098f, 0.00530956f, 0.12651765f, 0.19116400f, 
    -0.03942737f, -0.00624646f, -0.16961981f, 0.67065489f, -0.78903776f, -0.08525955f, -0.08911462f, 0.05765792f, 
    0.18260624f, -0.04817040f, -0.09823180f, 0.09832775f, -0.53624380f, -0.12010081f, 0.03557160f, 0.09686448f, 
    -0.06346191f, 0.06744508f, 0.27786130f, 0.02423460f, -0.02338511f, -0.06239367f, 0.00266969f, 0.26689067f, 
    0.00225102f, -0.09415120f, -0.63133484f, 0.28912142f, 0.04062692f, -0.21124147f, 0.29803675f, 0.06419071f, 
    -0.24567279f, -0.01378157f, 0.02954505f, -0.03433090f, 0.08100578f, -0.04589076f, 0.01159370f, -0.04429090f, 
    0.00004810f, 0.04836239f, -0.25502244f, -0.03905970f, 0.04906140f, 0.04797377f, -0.80604452f, 0.01102423f, 
    -0.12416494f, -0.10536002f, -0.08897179f, 0.05372778f, -0.09587446f, 0.03554738f, 0.11547036f, -0.40835416f, 
    -0.09805547f, -0.15766203f, -0.26228344f, -0.00137796f, 0.07192849f, -0.07605401f, -0.05315218f, 0.04424599f, 
    -0.28199619f, -0.36627382f, 0.04691481f, 0.00123755f, -0.36732137f, -0.03609676f, 0.09278219f, -0.08501149f, 
    0.08632804f, -0.04918175f, 0.12178952f, -0.07007471f, -0.01459412f, 0.01835088f, -0.01179229f, 0.06541602f, 
    0.00151620f, -0.28930488f, -0.02709974f, 0.02197092f, -0.18588606f, -0.20277974f, -0.26614839f, 0.07178781f, 
    -0.04712082f, -0.04233722f, 0.14663619f, -0.35990137f, -0.01815012f, 0.08522278f, -0.11355921f, -0.33449835f, 
    0.05274471f, -0.18185975f, 0.08316902f, 0.03847017f, -0.06328186f, -0.01838335f, -0.22062992f, 0.12692069f, 
    0.06627899f, 0.07663282f, 0.08090881f, 0.18861832f, -0.09496123f, -0.01910219f, 0.23180939f, -0.20396702f, 
    0.10099605f, 0.01847281f, 0.08744261f, -0.06568595f, 0.08903211f, -0.10452913f, -0.31375134f, 0.17961134f, 
    -0.35365248f, -0.08422402f, 0.10412113f, -0.03760445f, 0.13926136f, 0.06127424f, -0.02489746f, 0.02004618f, 
    0.22379582f, 0.00396495f, 0.09893948f, -0.03499136f, 0.12386428f, -0.10489045f, 0.28766215f, -0.66333336f, 
    -0.36494741f, 0.09984086f, -0.14372870f, -0.50629300f, 0.16298184f, -0.07683934f, -0.04811040f, -0.13608931f, 
    0.05677630f, -0.03018649f, 0.21412964f, -0.02921605f, -0.07966163f, 0.02869420f, -0.01380010f, 0.15588941f, 
    -0.02503652f, 0.00529166f, 0.11391254f, 0.16173825f, 0.06995144f, -0.32570338f, 0.17412381f, 0.03103019f, 
    0.26710895f, 0.06314213f, 0.16840081f, 0.07428913f, 0.17667887f, -0.32209823f, 0.02871041f, 0.01342519f, 
    -0.02970752f, -0.56379473f, 0.13916937f, -0.07845951f, -0.09005853f, -0.02215622f, 0.19806951f, -0.01285526f, 
    -0.12226478f, -0.27183059f, -0.03663706f, -0.00933876f, 0.07096336f, -0.02183509f, -0.03092940f, 0.05676450f, 
    -0.02858119f, 0.11291379f, 0.26334167f, -0.07192703f, -0.08240066f, -0.08636848f, 0.09700496f, -0.04389869f, 
    -0.45386291f, 0.12133946f, -0.02529045f, 0.00864519f, -0.35485375f, -0.04026829f, -0.20568539f, -0.33844715f, 
    0.08159623f, 0.06980778f, 0.12666981f, 0.01221195f, 0.44625393f, 0.03283702f, -0.06355577f, 0.07222085f, 
    -0.02949495f, -0.23645912f, 0.16639332f, 0.13560295f, 0.39617652f, -1.22438061f, -0.38625166f, 0.03836432f, 
    0.02395304f, -0.01985315f, -0.43653890f, -0.09613805f, 0.00107833f, 0.13614771f, -0.28151760f, -0.32396424f, 
    0.24142186f, -0.14736287f, 0.18417464f, 0.11518728f, 0.05137104f, -0.03991048f, 0.04145681f, 0.14810751f, 
    0.09023158f, 0.06684105f, 0.05787341f, -0.48030952f, 0.13656871f, -0.06064358f, -0.21752945f, -0.19501300f, 
    -0.12999824f, -0.03445521f, 0.02690385f, 0.05542738f, -0.16988148f, 0.21372189f, -0.18019076f, 0.02766576f, 
    0.27633712f, 0.19124138f, 0.22887129f, 0.02529754f, 0.11502041f, 0.02117238f, 0.05709541f, 0.19447502f, 
    -0.47153640f, 0.03881882f, -0.12984507f, -0.14480656f, 0.05518528f, -0.11126222f, -0.12312310f, 0.09429796f, 
    -0.45414585f, -0.13018796f, 0.00708376f, -0.65669054f, -0.15350445f, -0.00997035f, -0.18398573f, 0.05516297f, 
    0.07230249f, 0.10534173f, 0.04138371f, 0.03759915f, -0.09651753f, -0.02381339f, 0.01005351f, -0.49225503f, 
    -0.03483894f, 0.02954201f, 0.25141996f, -0.55714995f, -0.01914265f, 0.15533060f, -0.35374141f, -0.14616677f, 
    0.30317625f, -0.19415878f, 0.15565491f, -0.09937160f, 0.20369393f, -0.19259001f, -0.05870646f, -0.14046021f, 
    0.24474105f, -0.34468234f, -0.04499542f, -0.04438338f, -0.03851571f, 0.01965971f, 0.06405579f, 0.02301929f, 
    -0.53847706f, 0.70889229f, 0.16806355f, -0.02145939f, -0.03504774f, -0.03811894f, 0.16581398f, -0.75317764f, 
    -0.13179640f, -0.08810424f, 0.17876044f, 0.06897702f, -0.52381533f, -0.00847232f, -0.14565481f, -0.00812624f, 
    -0.48158759f, 0.15795365f, 0.04410192f, -0.04365937f, -0.14831905f, 0.02013889f, 0.14425513f, -0.10165757f, 
    0.19950834f, -0.03700425f, -0.51372778f, 0.04698981f, -0.40508527f, 0.05132407f, 0.02047249f, 0.02217926f, 
    0.06137241f, -0.40002954f, -0.25730106f, -0.17707086f, -0.16995208f, 0.59228981f, 0.12803538f, 0.02221849f, 
    0.02537131f, -0.03082249f, -0.38108754f, 0.00920014f, 0.00025394f, 0.04853139f, 0.12980118f, -0.32251641f, 
    -0.05388181f, 0.14178127f, -0.34359035f, -0.52331138f, -0.08216739f, -0.03030160f, -0.25077555f, 0.01304915f, 
    -0.01773897f, 0.20011070f, 0.00109429f, -0.10076927f, -0.51023138f, -0.06894929f, 0.07766335f, -0.42650798f, 
    -0.63946891f, -0.09541370f, 0.09330962f, -0.01278638f, -0.03646092f, -0.72508168f, -0.51234090f, 0.13096187f, 
    -0.55728114f, -0.06361140f, 0.10631470f, -0.04592157f, -0.38357794f, 0.03886845f, 0.07557724f, -0.67647159f, 
    0.17502283f, -0.00710156f, -0.45764920f, 0.08152004f, 0.24439597f, -0.07480139f, 0.11152546f, -0.40939352f, 
    -0.02270585f, 0.00282309f, -0.01183127f, 0.29666877f, -0.18813972f, -0.05426002f, -0.66995025f, -0.02353558f, 
    0.05917481f, -0.45633519f, 0.08681007f, 0.03485989f, -0.02212898f, -0.00343254f, 0.10447334f, -0.03309964f, 
    -0.04551910f, 0.03972198f, -0.30975723f, -0.48646569f, -0.01630780f, 0.23827964f, 0.16796945f, 0.11607003f, 
    -0.52537286f, 0.07721835f, 0.22628419f, 0.17646943f, -0.23412220f, -0.21637072f, -0.08425003f, -0.08867043f, 
    -0.15470657f, 0.04660997f, 0.30700505f, -0.07383374f, -0.00527915f, 0.06534617f, -0.45160908f, -0.86496049f, 
    0.12278561f, -0.04763868f, -0.34121731f, -0.10109582f, 0.01365151f, 0.03140984f, -0.52081078f, 0.21969248f, 
    -0.02007008f, -0.04760219f, -0.68071097f, -0.04120367f, 0.09446795f, 0.02947685f, 0.10507904f, -0.01237687f, 
    -0.24909650f, 0.32245356f, -0.04351521f, -0.06667992f, 0.00423905f, 0.03132688f, -0.03687908f, -0.11309133f, 
    -0.55788523f, -0.00620715f, 0.22205335f, -0.06549355f, 0.07189528f, -0.06490357f, -0.09218425f, -0.08976416f, 
    -0.07058786f, -0.01234131f, 0.13965997f, -0.00585462f, -0.44479111f, -0.17218123f, -0.55354112f, 0.03607027f, 
    -0.00814429f, -0.07265506f, 0.27089107f, 0.15692270f, 0.04586276f, 0.06554985f, -0.34065214f, -0.86055130f, 
    -0.26262164f, 0.19226617f, -0.03383005f, 0.03028948f, -0.03579946f, 0.06705872f, -0.69821191f, 0.23625192f, 
    -0.37067279f, 0.09447169f, -0.01845985f, 0.25414449f, 0.19019364f, -0.05913143f, 0.12384720f, -0.52242321f, 
    0.06679514f, 0.00750597f, -0.37760299f, -0.05011395f, -0.47997829f, -0.23362026f, -0.43341500f, -0.11000541f, 
    0.12459166f, -0.49678740f, -0.62577111f, -0.03841820f, -0.07366470f, -0.08458789f, -0.40500942f, 0.00432612f, 
    0.26181960f, -0.00335308f, 0.31386462f, -0.53823829f, -0.09187325f, 0.06190057f, 0.27573481f, -0.23724437f, 
    -0.63344073f, -0.09000714f, 0.29793042f, -0.33940944f, 0.08425030f, 0.06606591f, -0.04109813f, -0.47813261f, 
    0.07338702f, -0.24197072f, 0.14250366f, -0.01939493f, -0.06708791f, 0.04276394f, -0.02825339f, -0.58391768f, 
    -0.04247321f, -0.03370240f, -0.13659723f, 0.11886663f, -0.02593520f, 0.13487400f, 0.10317788f, 0.13799542f, 
    -0.11780687f, -0.21541078f, -0.27928451f, -0.19071351f, 0.18432194f, 0.13132912f, 0.00022958f, 0.16015194f, 
    -0.06839671f, -0.03131154f, -0.13185169f, 0.05686099f, -0.02975698f, 0.01990807f, -0.07392929f, -0.27843389f, 
    -0.44935623f, -0.50924730f, 0.06421403f, 0.00420269f, 0.02523673f, 0.05508145f, 0.04918728f, -0.12261356f, 
    -0.11025477f, 0.25840104f, 0.19603315f, 0.09708253f, -0.41763416f, 0.03915341f, 0.02065840f, 0.04713130f, 
    -0.21836804f, 0.19924566f, -0.09317004f, 0.01231050f, -0.18978703f, -0.05147602f, -0.39648864f, 0.28029731f, 
    -0.25003922f, -0.07655230f, 0.21683815f, -0.04203140f, -0.52092880f, -0.11130857f, 0.01927556f, 0.11634728f, 
    0.01735968f, -0.42747557f, 0.07215466f, -0.14275980f, -0.03737061f, 0.12919490f, -0.26629284f, 0.08954386f, 
    -0.00845023f, 0.07149553f, -0.60335964f, -0.11469080f, 0.00420510f, -0.11684940f, 0.12062913f, 0.23708339f, 
    -0.00189198f, 0.15724088f, 0.00126765f, 0.00064012f, 0.02633289f, -0.02199676f, -0.29642415f, -0.30519170f, 
    0.22549053f, -0.23342845f, -0.05078534f, 0.14901137f, -0.37100476f, 0.04502898f, 0.21645069f, 0.05365316f, 
    0.12303235f, -0.06586609f, 0.03463442f, 0.02777371f, -0.22060309f, 0.08010560f, 0.39953852f, 0.04324975f, 
    0.07620747f, -0.09170312f, 0.03594913f, -0.07857873f, -0.00868578f, 0.10665259f, -0.15462130f, -0.27486825f, 
    0.21026801f, -0.00096281f, -0.62478459f, -0.20852171f, 0.03629710f, -0.05859126f, 0.16347155f, -0.06843024f, 
    0.13221484f, 0.01038401f, -0.41189644f, 0.26058719f, 0.00553137f, 0.06645929f, 0.16538244f, 0.08235775f, 
    -0.00038698f, 0.10696589f, 0.18646006f, 0.01264106f, -0.06337982f, 0.06983008f, 0.06942126f, 0.12611294f, 
    0.00110230f, 0.02642427f, 0.29288396f, 0.13675293f, -0.07690235f, 0.58563918f, 0.01618386f, 0.10805441f, 
    -0.14680029f, 0.06945879f, 0.23983985f, -0.11236164f, 0.14515521f, -0.07582118f, 0.01935413f, 0.00650943f, 
    -0.24858150f, 0.34465536f, 0.16135362f, -0.01392120f, -0.08852471f, -0.09570529f, 0.03202586f, 0.15199286f, 
    -0.21430121f, -0.04611879f, 0.21338278f, -0.00661358f, 0.00447450f, 0.06447122f, -0.18700044f, -0.57661384f, 
    0.01729239f, -0.70018816f, -0.35076579f, -0.44985676f, 0.11364437f, 0.03866534f, -0.68567491f, 0.01218365f, 
    -0.11554930f, -0.24714082f, -0.09091675f, -0.02482134f, -0.15980743f, -0.06085812f, 0.12864700f, -0.33643433f, 
    -0.02086433f, -0.03918902f, 0.31990391f, -0.06499414f, -0.28519869f, 0.07253478f, 0.00954057f, -0.14297201f, 
    -0.02698679f, 0.20756507f, -0.18995021f, -0.10568477f, -0.27242523f, 0.49215415f, 0.30011317f, -0.02014392f, 
    -0.08168940f, -0.02852061f, 0.10425542f, 0.08861436f, 0.00835896f, -0.41358528f, -0.49163741f, 0.16178362f, 
    -0.36481073f, 0.21940614f, -0.17359348f, 0.04546719f, 0.03690233f, 0.04509563f, -0.21928675f, -0.27775976f, 
    -0.32600942f, -0.32328725f, 0.00953027f, -0.14617376f, 0.14541665f, -0.02592772f, -0.21270186f, 0.00906062f, 
    -0.03528005f, 0.05819415f, -0.29921123f, -0.09759081f, 0.10207652f, -0.18119833f, 0.26539564f, -0.42996815f, 
    -0.00059674f, -0.31316778f, -0.10856955f, 0.05076623f, -0.46383888f, 0.09320578f, -0.01528459f, 0.09486704f, 
    0.02536866f, 0.02977000f, -0.17318296f, 0.17090844f, 0.27209151f, -0.05460927f, -0.08283158f, 0.02444395f, 
    0.27390340f, 0.03687372f, -0.07086627f, -0.14568396f, 0.30187690f, -0.04016928f, 0.04014597f, -0.04164415f, 
    -0.03297282f, -0.09049302f, 0.18691796f, -0.01132881f, -0.00956043f, -0.00030108f, 0.02843944f, -0.03381128f, 
    -0.02181216f, 0.03906732f, -0.10923402f, -0.15360746f, -0.03233436f, -0.48649168f, -0.06743230f, -0.24415061f, 
    -0.14454682f, 0.04592148f, -0.10705019f, -0.09287478f, 0.01929295f, -0.10142210f, 0.02485310f, 0.23934817f, 
    -0.22101809f, 0.07946354f, 0.02582124f, 0.00874045f, 0.02399943f, -0.08105307f, -0.07637756f, -0.18308684f, 
    0.31836867f, -0.40162992f, -0.29429990f, 0.02638788f, 0.00149600f, 0.00391862f, 0.09692474f, 0.19871667f, 
    0.00445802f, -0.07487801f, 0.20726000f, -0.39375111f, 0.11457957f, -0.05662614f, 0.07868389f, 0.02487366f, 
    0.37493619f, 0.17452119f, -0.02932209f, 0.00271950f, 0.32518697f, -0.05640084f, -0.04353407f, -0.40121013f, 
    -0.03081000f, -0.06212446f, -0.11986148f, 0.00552998f, 0.25240117f, -0.04365439f, 0.00940185f, 0.11619227f, 
    -0.04391545f, 0.07577197f, 0.16163716f, -0.05366227f, 0.17568463f, 0.37580603f, -0.27715695f, 0.07338407f, 
    0.00548968f, 0.04270809f, 0.06199515f, 0.19520815f, -0.01158687f, 0.00664395f, 0.21223606f, -0.78373879f, 
    -0.02452226f, 0.13240092f, -0.07574022f, 0.12564102f, -0.01279408f, 0.06491381f, -0.02909867f, 0.14433645f, 
    0.20726687f, -0.06211911f, -0.00405558f, -0.10596488f, 0.19291732f, 0.03363281f, 0.07338671f, 0.14082900f, 
    0.09837757f, -0.05879834f, -0.04799802f, 0.03440403f, 0.10065807f, 0.13071164f, -0.56684554f, -0.06920908f, 
    0.12190674f, 0.00606816f, 0.14447552f, -0.01029081f, 0.13774256f, -0.03540144f, 0.10177387f, 0.04546009f, 
    -0.21808177f, -0.01241664f, 0.17754540f, -0.39459035f, 0.15977390f, 0.06787676f, -0.25321183f, -0.16403283f, 
    0.09481853f, -0.00988505f, 0.02278676f, -0.17896852f, 0.20525272f, -0.00664332f, -0.22683425f, 0.13704766f, 
    0.06663423f, 0.10470662f, 0.12347499f, 0.07551152f, -0.02187891f, -0.01081629f, 0.00842960f, -0.16600350f, 
    0.02520764f, -0.02602631f, -0.33920839f, -0.08685071f, 0.02823468f, -0.59364057f, -0.30810156f, 0.00652458f, 
    -0.07066721f, -0.05118533f, -0.33439004f, 0.07774344f, -0.00890143f, 0.16067649f, -0.05266229f, -0.33537391f, 
    -0.30043373f, -0.04088643f, -0.11243595f, 0.06224024f, 0.03190025f, 0.01487217f, -0.27876595f, -0.12119492f, 
    -0.10757127f, -0.11227441f, -0.17617488f, -0.01728017f, -0.13904683f, -0.03676156f, 0.10573626f, -0.00190834f, 
    -0.10561405f, -0.16388837f, -0.17544842f, 0.15419853f, 0.24909392f, -0.05153312f, -0.41077745f, -0.03354387f, 
    0.08869202f, -0.29842916f, 0.03037257f, -0.00474620f, -0.17401139f, -0.01266071f, 0.12803583f, -0.02860806f, 
    -0.05335251f, -0.05003363f, -0.13431852f, 0.00845346f, 0.24267732f, 0.01594339f, -0.08304714f, 0.20241381f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.00382531f, -0.07256261f, 0.02808775f, -0.05913578f, 0.00008862f, -0.00546854f, -0.00344260f, -0.23824598f, 
    -0.04499801f, 0.10371995f, 0.02301479f, -0.00058814f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
