#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.42918909f, -0.45831731f, -0.53225243f, -0.55090332f, -0.20124415f, -0.06255190f, -0.63350815f, -0.13415727f, 
    -0.29139611f, -0.46276915f, -0.43753457f, -0.00304452f, 0.19141027f, 0.42609006f, 0.11726218f, 0.19554953f, 
    0.23436196f, 0.35491866f, 0.29573223f, -0.20065935f, 0.11212566f, -0.28261971f, 0.00336111f, 0.32354951f, 
    0.14739741f, 0.30915767f, 0.69650584f, 0.12969364f, 0.06788223f, 0.72211754f, -0.96192014f, -0.46953043f, 
    -0.46989641f, -0.57531261f, -0.58582979f, 0.19987808f, 0.06341060f, -0.16322345f, 0.06464349f, -0.07969054f, 
    0.19952175f, -0.14813845f, -0.00275962f, -0.19001989f, 0.01054896f, 0.00207093f, -0.13962089f, -0.09345234f, 
    0.25659502f, -0.05750134f, -1.18550456f, 0.33469445f, 0.36708373f, -0.41630065f, -0.65440392f, 0.58520544f, 
    0.27433366f, -0.45418394f, 0.30429873f, -0.15188576f, 0.23374286f, 0.08482484f, -0.15967239f, -0.01762001f, 
    0.31997943f, -0.08964568f, -0.28135297f, -0.14483364f, -0.22642913f, -0.17416708f, 0.04336153f, -0.02258338f, 
    0.30672884f, 0.00133437f, 0.14834243f, -0.19030488f, 0.72150892f, 0.56859642f, 0.50891256f, 0.27040336f, 
    -0.07716601f, 0.42603281f, -0.12685521f, 0.09239409f, -0.05324958f, 0.19982737f, -0.08639032f, 0.13692747f, 
    0.29451871f, 0.41251597f, 0.33521682f, 0.26252577f, -0.21645533f, 0.44360903f, 0.37370604f, -0.05896672f, 
    -0.08136539f, 0.42193481f, 0.15096204f, 0.07244162f, 0.10231468f, 0.54126316f, 0.36988753f, 0.56409812f, 
    0.32256547f, -0.36839548f, 0.78097451f, -0.12531792f, -0.67814702f, 0.42621869f, -0.12938423f, 0.37937954f, 
    0.44829226f, 0.04333332f, -0.13462663f, -0.07129673f, -0.24034704f, 0.19707766f, 0.17625105f, -0.41544372f, 
    -0.03844616f, 0.00435678f, 0.06666154f, 0.01981043f, 0.09087394f, 0.96048671f, 0.62394834f, 0.83094603f, 
    -0.48781130f, -0.46197721f, 0.03206378f, -0.38099203f, 0.53224814f, 0.10443468f, 0.36908904f, 0.19381768f, 
    0.11542839f, -0.08461721f, 0.07990414f, 0.11349208f, -0.02373046f, 0.04022826f, -0.05654343f, -0.04063552f, 
    0.06918755f, -0.03849418f, 0.15938810f, -0.08630673f, 0.28303373f, 0.09566676f, 0.83041036f, 1.07235754f, 
    -0.35842472f, -0.17024949f, -0.40828273f, 0.49094427f, -0.41685683f, -0.61980301f, -0.71514839f, -0.25413284f, 
    0.09652302f, 0.14936736f, 0.17711565f, 0.30045140f, -0.04486699f, -0.11134679f, -0.24791695f, -0.04426193f, 
    -0.01066139f, -0.04315643f, -0.25909880f, 0.24501184f, 0.00455707f, -0.25293109f, 0.06985345f, -0.60042441f, 
    0.35356995f, -0.04892693f, -0.33995077f, -0.40568903f, -0.48741072f, 0.64228582f, -0.31875247f, -0.45552585f, 
    -0.44863293f, 0.22892536f, 0.37500882f, -0.59096718f, -0.19636826f, -0.03377630f, 0.31558222f, 0.09403176f, 
    0.34799480f, -0.02945425f, -0.17212214f, 0.07881248f, 0.28740999f, -0.12645380f, -0.03879534f, -0.04789114f, 
    -0.59445786f, -0.61745840f, -0.38567030f, -0.43005762f, -0.61830622f, 0.59250075f, 0.51926142f, -0.34326300f, 
    -0.13286531f, -0.10563989f, -0.29641801f, -0.02766737f, 0.36227378f, 0.19381306f, 0.47497880f, -0.22673479f, 
    0.02034873f, -0.04416832f, 0.11882688f, 0.21868812f, -0.18074475f, -0.10059552f, -0.23560241f, -0.08983890f, 
    -0.16835347f, -1.00991738f, -0.62950116f, -0.19835021f, 0.35479462f, 0.53227603f, 0.48846221f, 0.91455567f, 
    0.33013180f, 0.03520001f, -0.11061209f, 0.03907201f, 0.09618951f, 0.24079932f, 0.21026468f, 0.44050023f, 
    0.20024164f, 0.20081957f, -0.23996904f, 0.07255205f, 0.20219882f, 0.06679261f, -0.16257320f, 0.07352687f, 
    -0.10688017f, 0.04727255f, -0.18094452f, 0.13150758f, 0.38587609f, -1.06708610f, 0.07206485f, -0.42490506f, 
    -0.38150668f, -0.59460276f, -0.36645731f, -0.31910998f, 0.11984947f, 0.34100971f, 0.18146624f, 0.17738713f, 
    0.25058478f, 0.15611236f, 0.06930979f, -0.21318217f, 0.02384480f, 0.30591848f, 0.14902283f, 0.13687409f, 
    0.21105109f, 0.15206061f, 0.45477730f, -0.41924730f, -0.30619875f, -0.78736508f, -0.60874516f, -0.23038211f, 
    0.61584944f, 0.59146780f, -0.01136068f, 0.41743523f, 0.60046053f, 0.11785024f, -0.24195182f, 0.19060341f, 
    -0.22044405f, -0.26913825f, -0.07164806f, 0.13045251f, 0.12078186f, 0.23601837f, -0.29941112f, -0.32173005f, 
    -0.32723358f, -0.26243228f, -0.20238058f, 0.16590926f, 0.32197031f, -0.19967051f, -0.46653691f, 0.60756075f, 
    0.78549731f, 0.62577367f, -0.40090334f, -0.73772329f, -0.40675059f, -0.20583180f, -0.02221127f, 0.40449110f, 
    -0.34429908f, 0.00968548f, -0.01182311f, 0.02740575f, -0.23420516f, -0.18828270f, -0.01490990f, -0.00991412f, 
    0.10189655f, -0.20180757f, -0.35973758f, 0.04571928f, -0.14295816f, 1.22355282f, 0.38076168f, 0.09971823f, 
    0.90029687f, 0.82945728f, 0.14499252f, 0.39051798f, 0.18929763f, 0.28100955f, 0.14618848f, -0.37600747f, 
    -0.28966814f, -0.36725292f, -0.11889821f, -0.15830195f, -0.03519929f, -0.09419662f, -0.18412293f, -0.11959399f, 
    0.01882200f, 0.15992768f, 0.00905069f, 0.01480457f, -0.07003817f, 0.05221158f, -0.47618324f, -0.63350308f, 
    -0.31116685f, 0.17681041f, -0.41599673f, 0.08345325f, 0.87784326f, -0.26625592f, 0.26992822f, 0.46187383f, 
    -0.19217284f, -0.27737981f, -0.35678312f, -0.21101157f, -0.11435211f, -0.06668393f, -0.01368791f, -0.00612771f, 
    -0.02084112f, -0.15789224f, 0.18631433f, -0.05331475f, 0.05860984f, -0.07940225f, 0.12953950f, 0.84505200f, 
    0.36988428f, 0.60569680f, 0.43798077f, -0.35241070f, -0.34137198f, -0.74216104f, -0.09049875f, -0.21566688f, 
    0.55078340f, 0.17454311f, -0.17687035f, -0.33893129f, -0.11398658f, -0.28566915f, -0.33946744f, -0.20261329f, 
    0.25742522f, -0.43552211f, -0.05102468f, -0.07540233f, 0.30504864f, -0.07650254f, -0.18311828f, -0.25617960f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.41897583f, 0.19302998f, 0.07353050f, 0.02704778f, 0.01320810f, 0.24289712f, 0.20211999f, 0.04585783f, 
    0.25019208f, 0.09517789f, 0.20793101f, -0.05863765f, 0.12977035f, 0.11481103f, 0.02592146f, 0.19940947f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.35224047f, -0.32949814f, -0.03120019f, 0.17923021f, 0.07026336f, -0.08316915f, 0.09070856f, -0.00626432f, 
    0.33050466f, 0.00037660f, 0.04826748f, 0.16664717f, 0.14239486f, -0.06310333f, 0.42172456f, -0.07741303f, 
    -0.22217952f, -0.09822529f, -0.25358066f, -0.01704455f, 0.16120751f, 0.12881285f, 0.05444461f, -0.02689502f, 
    0.14600709f, -0.09282003f, 0.04080462f, -0.19844604f, -0.03030227f, -0.04773405f, -0.01892847f, -0.10487402f, 
    0.04585754f, -0.02065874f, 0.04111246f, 0.07280535f, 0.06928443f, 0.03003568f, -0.03305437f, 0.03552144f, 
    0.13870823f, 0.10568029f, -0.02974413f, 0.13154206f, -0.12006491f, -0.13538478f, 0.09982987f, -0.02643032f, 
    0.08910294f, -0.04345469f, 0.26549545f, 0.05349695f, -0.11634116f, 0.10656550f, 0.03906643f, 0.09776486f, 
    -0.05686158f, -0.06387351f, -0.07415621f, -0.02982228f, 0.18951499f, -0.03647228f, 0.10608562f, -0.06993842f, 
    -0.02326545f, 0.01201163f, 0.11867341f, -0.08415811f, -0.14059901f, -0.19028230f, -0.04790617f, 0.12100014f, 
    -0.29855749f, 0.21675427f, 0.56679755f, -0.32566434f, -0.15669823f, 0.12334924f, -0.07232735f, -0.08464321f, 
    0.08899798f, 0.04789792f, -0.08609266f, -0.09278008f, -0.25115770f, -0.28832635f, 0.16378148f, 0.05457162f, 
    0.10380497f, 0.03302146f, -0.06283262f, 0.03186272f, 0.20230417f, -0.00499479f, 0.00026623f, -0.04806082f, 
    -0.37494588f, -0.17265917f, 0.07209736f, -0.22901587f, 0.06085743f, 0.05359295f, -0.06557322f, -0.03385946f, 
    0.19624035f, -0.10049665f, 0.04369049f, 0.10907201f, -0.01195730f, 0.22879706f, -0.17254564f, -0.12187745f, 
    0.12879026f, -0.01183815f, -0.03745853f, 0.12033700f, 0.19703348f, -0.10602992f, 0.05656271f, 0.01850156f, 
    -0.52474552f, -0.00132346f, 0.26267892f, -0.05862755f, -0.03478285f, -0.17131189f, -0.07156404f, -0.20373146f, 
    -0.01391590f, -0.14150460f, 0.18330018f, 0.12500992f, 0.35879368f, -0.01914119f, -0.13420570f, -0.43716982f, 
    0.13917334f, 0.10348460f, 0.12194855f, 0.15847228f, -0.01552224f, 0.24385606f, -0.10253619f, 0.12536883f, 
    -0.01349241f, -0.19548211f, 0.19515219f, 0.00384194f, 0.09379441f, -0.04759343f, 0.23693059f, -0.05231028f, 
    0.08160152f, 0.20122334f, 0.17291494f, 0.11030794f, 0.14244863f, 0.16188642f, -0.12089273f, 0.17863947f, 
    0.12278530f, 0.00231575f, -0.03357807f, -0.13820021f, 0.06740230f, -0.13835372f, 0.00231247f, -0.10940029f, 
    0.16043909f, -0.02127898f, -0.40124068f, -0.02266597f, 0.10487356f, 0.11225929f, 0.07588147f, 0.14363687f, 
    -0.01786555f, 0.06658858f, 0.02759331f, 0.14617576f, -0.05119531f, -0.00383894f, 0.07297954f, 0.14594497f, 
    -0.18252355f, -0.02440363f, -0.13970603f, -0.02945355f, -0.06970127f, 0.04967871f, 0.03495577f, 0.01370559f, 
    -0.12745653f, -0.07046914f, -0.01834813f, 0.01487411f, -0.20405070f, -0.04142905f, 0.04215915f, 0.06244338f, 
    0.05086256f, -0.10632670f, -0.04457247f, 0.06653998f, -0.00246298f, 0.31493062f, -0.09255930f, -0.12029536f, 
    -0.00054881f, 0.03367598f, -0.02278607f, 0.16251498f, -0.03724872f, 0.06281374f, -0.05681854f, -0.00697604f, 
    -0.17717928f, -0.20603338f, 0.17832009f, 0.19773766f, -0.03474966f, 0.03404364f, 0.06179623f, 0.04054467f, 
    -0.03988825f, 0.07230527f, 0.21677601f, -0.00930660f, 0.40107879f, -0.03108473f, 0.17939563f, 0.02740206f, 
    -0.01690189f, 0.10963491f, 0.11286011f, 0.00899724f, 0.12357817f, -0.09821374f, -0.16547059f, -0.03485582f, 
    0.14369825f, 0.25935525f, 0.08123219f, -0.06122738f, 0.14867677f, -0.10093565f, 0.08997988f, -0.12700804f, 
    0.04469149f, 0.13548028f, 0.04339034f, 0.04641879f, 0.32835850f, 0.38922399f, -0.09584152f, 0.16555947f, 
    -0.04434842f, -0.07333153f, 0.04721315f, 0.10044070f, -0.11736696f, -0.07573827f, 0.01267409f, -0.12213297f, 
    0.54889733f, 0.18470189f, -0.02636759f, 0.05776237f, -0.06026341f, 0.01996822f, -0.00730106f, 0.18651819f, 
    0.06823009f, 0.04363342f, 0.08315526f, 0.06014452f, 0.04958417f, 0.08057560f, -0.07209650f, 0.13957204f, 
    0.07086987f, -0.04042784f, -0.06920192f, 0.15660457f, -0.19116253f, -0.03235405f, 0.07014434f, -0.06504517f, 
    0.16776595f, -0.12522012f, -0.03360189f, -0.15787257f, -0.09098839f, 0.04947919f, -0.16870098f, 0.06598929f, 
    -0.02388575f, -0.06805462f, 0.07914510f, 0.03075703f, -0.17235634f, -0.17995119f, 0.08251826f, 0.01322554f, 
    0.09189243f, 0.15154433f, -0.04355512f, 0.01505819f, -0.01982764f, 0.16060723f, -0.00777014f, 0.07612769f, 
    -0.28287041f, -0.22052434f, 0.01890297f, 0.19662021f, -0.05455457f, 0.13335770f, -0.03222334f, -0.08960737f, 
    0.03809934f, 0.06214168f, -0.08400800f, -0.09807640f, 0.07881005f, -0.06147327f, -0.08606874f, -0.32738528f, 
    0.06000661f, 0.08009708f, -0.08867637f, 0.03494206f, -0.00129493f, 0.17009450f, -0.11693463f, 0.14620194f, 
    0.01879580f, -0.20464520f, 0.09536825f, 0.02533190f, -0.02569041f, 0.03916903f, -0.12215518f, -0.00060641f, 
    -0.06911355f, 0.09605681f, 0.04111970f, -0.09155224f, 0.04815657f, -0.02141469f, 0.33130988f, 0.23279600f, 
    -0.02769653f, 0.02032299f, -0.01813501f, 0.03161460f, 0.02605500f, -0.08725863f, 0.06251082f, -0.02673418f, 
    0.05240654f, -0.15501490f, -0.07095703f, -0.12914474f, 0.02394217f, 0.01568253f, 0.07617780f, -0.02982825f, 
    -0.05910552f, -0.07653774f, 0.09814323f, -0.06066503f, 0.39104632f, 0.17988686f, -0.12721737f, -0.14968087f, 
    0.01120077f, 0.07414258f, 0.04944090f, 0.06917667f, 0.00177987f, 0.14384183f, 0.15206105f, 0.06626488f, 
    0.05966268f, -0.06522541f, 0.03949542f, 0.04962838f, -0.03183508f, 0.05705137f, -0.05294046f, -0.03681879f, 
    -0.04511098f, 0.02129688f, -0.04128997f, -0.04743826f, -0.04456758f, -0.00951009f, 0.04232900f, -0.05376907f, 
    -0.02842221f, -0.06308558f, -0.07492889f, -0.05754666f, -0.00894915f, 0.00895663f, 0.02840776f, -0.06114521f, 
    0.02043436f, 0.04710010f, -0.00860601f, 0.02205265f, 0.04938783f, -0.06731819f, 0.05630205f, 0.00684859f, 
    0.04478526f, -0.00784000f, -0.05707746f, 0.05794252f, -0.03546049f, -0.01944247f, -0.05061087f, -0.01199672f, 
    -0.03542763f, -0.00241198f, 0.05964353f, 0.05216523f, -0.06164174f, 0.00763776f, 0.05762152f, -0.00733348f, 
    -0.07039452f, -0.02553547f, -0.03571054f, 0.03896241f, 0.03383462f, 0.06957685f, -0.07483994f, 0.02087646f, 
    -0.03212404f, -0.03584932f, 0.05709741f, 0.01260921f, -0.04889650f, -0.04127104f, 0.03900163f, 0.04666302f, 
    0.06092732f, -0.04483768f, -0.00094535f, 0.01924197f, -0.07287449f, -0.02452034f, -0.02149623f, 0.06912702f, 
    0.04702946f, -0.06389032f, 0.01810660f, -0.06550178f, -0.06648956f, 0.02844002f, 0.05655760f, -0.07441926f, 
    -0.06318526f, 0.03368731f, -0.06292487f, -0.01861238f, 0.03583443f, 0.05250537f, -0.06640016f, 0.04444744f, 
    -0.01643248f, 0.00457806f, 0.05818291f, 0.03220770f, 0.03611900f, 0.04690635f, 0.04113084f, -0.00023281f, 
    -0.05362738f, -0.04686979f, -0.03793606f, -0.02963866f, -0.06849055f, -0.04313818f, -0.01952493f, 0.00278766f, 
    -0.06858549f, 0.03616036f, -0.02479635f, 0.05407418f, 0.00273979f, -0.04495439f, 0.04344283f, 0.03167954f, 
    0.02896929f, -0.04831641f, 0.02055992f, -0.03066237f, -0.06805447f, 0.06385793f, -0.01543852f, 0.04157501f, 
    -0.06490020f, -0.02653060f, 0.03697877f, 0.03454177f, -0.05863243f, -0.05274388f, -0.05935555f, -0.00892598f, 
    -0.00514151f, 0.07114147f, 0.04479779f, -0.00760870f, 0.01424837f, -0.07074635f, 0.04705584f, -0.03152821f, 
    -0.03933333f, -0.06744760f, -0.01426553f, 0.01627847f, -0.03504805f, 0.00119341f, -0.05135614f, -0.01402609f, 
    0.00190600f, -0.04470029f, -0.05176833f, 0.05131481f, -0.05951925f, -0.04393906f, 0.02947474f, 0.02859708f, 
    0.02440984f, 0.06595887f, 0.06554691f, 0.00438118f, 0.02779804f, 0.03962108f, -0.07573226f, 0.02703490f, 
    -0.02496464f, -0.02722379f, -0.05439975f, -0.02337847f, 0.06769037f, 0.02124531f, -0.03958518f, -0.02195590f, 
    -0.01636608f, -0.03186491f, -0.06187794f, -0.07550400f, -0.07425039f, -0.04887110f, 0.05129997f, -0.00761873f, 
    0.00423949f, -0.03053426f, -0.01237336f, -0.03778925f, -0.02080254f, 0.02985794f, 0.04353608f, -0.01736088f, 
    -0.03801623f, -0.05698188f, -0.05305192f, 0.05258778f, -0.00584344f, 0.03419895f, -0.00738825f, -0.03524425f, 
    0.01241676f, 0.10823394f, -0.06308459f, -0.12555864f, 0.06454057f, -0.12286337f, 0.12219376f, -0.00910469f, 
    -0.14762414f, 0.01702165f, -0.01395056f, 0.08740771f, -0.23748349f, 0.20260850f, 0.25293478f, -0.08436618f, 
    0.18745382f, 0.14402148f, 0.07290181f, -0.19618559f, 0.02449397f, 0.02754170f, -0.06855237f, -0.20659471f, 
    0.21042773f, 0.15639117f, -0.12655567f, -0.29421759f, 0.03676624f, 0.04961285f, -0.06446066f, 0.06979281f, 
    -0.05880298f, -0.04533329f, -0.13540429f, -0.01149512f, -0.11609146f, 0.10497724f, 0.03284892f, 0.09506036f, 
    0.07454609f, -0.18870401f, 0.00447658f, 0.06139261f, 0.01333665f, -0.05642746f, 0.06150384f, -0.20201130f, 
    -0.20923083f, -0.02455306f, -0.00588359f, 0.22199391f, -0.04332121f, 0.05703278f, -0.01804055f, 0.14817363f, 
    0.00430460f, 0.15593216f, -0.15095642f, 0.10728914f, -0.01986016f, -0.22149007f, 0.11527746f, 0.21774288f, 
    0.11907893f, 0.10947087f, 0.07716358f, 0.03067866f, 0.14557199f, 0.14384405f, 0.14141221f, 0.03598753f, 
    0.17642188f, 0.05177877f, 0.00656489f, -0.01313089f, 0.19207907f, 0.07362980f, -0.02162307f, 0.07223619f, 
    0.06965396f, 0.00231884f, 0.10809584f, 0.11192826f, -0.16667664f, 0.12947138f, 0.06189779f, -0.15027566f, 
    -0.01968035f, 0.05736387f, 0.10279779f, -0.14080361f, 0.08000226f, 0.11841512f, -0.09322197f, 0.10659877f, 
    -0.03699088f, -0.09775823f, 0.02490195f, -0.06903230f, 0.00552006f, -0.15170567f, 0.08014748f, -0.02027617f, 
    -0.14161301f, 0.06963073f, -0.10619491f, 0.10405042f, 0.18097404f, -0.15649578f, -0.36689067f, 0.26143596f, 
    -0.00226847f, -0.22811320f, 0.01349985f, 0.10870673f, -0.05129365f, -0.04850925f, -0.06223285f, -0.11043014f, 
    0.06764397f, -0.08841197f, -0.01689177f, -0.15513553f, 0.07618915f, -0.04801267f, 0.05361551f, -0.02920858f, 
    0.10786815f, -0.10865013f, 0.04749032f, -0.13404414f, -0.49430671f, -0.22955002f, 0.09961925f, 0.27195802f, 
    -0.10253550f, -0.22066978f, -0.00530174f, 0.18311347f, 0.01182024f, 0.08120992f, 0.02444760f, -0.01954876f, 
    -0.02016671f, 0.08470924f, -0.08597456f, 0.00374467f, -0.06701291f, 0.09511418f, -0.05314711f, 0.13353331f, 
    0.18800938f, -0.11041189f, 0.14708437f, 0.01496188f, 0.15695804f, 0.20637910f, 0.03591258f, -0.02939444f, 
    0.03742652f, 0.02380042f, 0.06647835f, 0.10785031f, -0.05634851f, 0.04132427f, 0.26105708f, 0.21795139f, 
    -0.34364846f, -0.42851284f, -0.01091935f, 0.06255567f, -0.05796087f, -0.07927151f, -0.02944968f, 0.08774663f, 
    0.05407043f, 0.08176778f, 0.08243494f, 0.15270175f, -0.17307328f, -0.05488770f, 0.29035574f, 0.04213814f, 
    0.13402286f, 0.28759435f, 0.17155401f, 0.11253107f, 0.12469774f, -0.01238514f, -0.00258946f, 0.10019212f, 
    0.04512911f, -0.01855355f, -0.02744777f, -0.07364129f, -0.07627696f, 0.05323913f, -0.02880302f, 0.02360702f, 
    -0.07055745f, -0.00440920f, -0.01144839f, 0.04319193f, 0.00144278f, 0.04914308f, -0.00052022f, -0.06609312f, 
    0.00167617f, -0.06590293f, 0.02683276f, 0.02991495f, 0.03915564f, -0.01027877f, 0.03346715f, -0.03642684f, 
    -0.07095948f, -0.03969473f, 0.04428308f, -0.03927160f, -0.03166786f, -0.08083693f, 0.01048973f, 0.00830278f, 
    -0.01428169f, 0.00652471f, -0.04837615f, 0.03461108f, -0.06270132f, -0.05280501f, 0.02282543f, 0.03946740f, 
    0.02163783f, 0.02555769f, -0.08047324f, 0.00513512f, 0.05052545f, 0.00182703f, 0.02503491f, 0.05071647f, 
    0.04481657f, -0.00206371f, -0.01171671f, -0.00093645f, -0.07762583f, 0.03886645f, 0.06255268f, 0.00671296f, 
    -0.05715591f, -0.04280985f, -0.07566801f, -0.04252964f, -0.01960845f, 0.06235139f, 0.01553637f, -0.05431565f, 
    0.05446260f, -0.03602429f, -0.02375777f, 0.05513741f, 0.02363262f, 0.04317585f, -0.03436239f, -0.07195984f, 
    -0.05526217f, 0.03896694f, 0.01217335f, -0.07374843f, -0.04355621f, -0.06806324f, -0.03662387f, -0.02689299f, 
    -0.06349930f, -0.07248243f, 0.05013620f, -0.03989932f, 0.00617633f, 0.02593301f, -0.08569667f, 0.05571837f, 
    0.03192042f, 0.03707761f, 0.01527938f, -0.01120761f, -0.05393112f, -0.06702518f, 0.00700553f, 0.00707993f, 
    0.04786223f, 0.02500250f, 0.04807173f, -0.04275143f, -0.00247839f, -0.00562662f, 0.01480726f, 0.01438903f, 
    -0.03555488f, 0.02248048f, 0.01381245f, -0.05928919f, -0.01020153f, -0.03115546f, 0.00885598f, -0.02948800f, 
    -0.00264309f, 0.01210259f, -0.05779930f, -0.07494988f, -0.03365178f, 0.05756981f, 0.01898648f, -0.00994493f, 
    -0.01626712f, -0.03160484f, -0.03496268f, 0.03571877f, 0.04337458f, 0.05420469f, -0.03348364f, 0.01299552f, 
    0.05455544f, 0.05036483f, 0.00260742f, 0.00622343f, 0.00052897f, -0.04912855f, 0.02617038f, 0.01480564f, 
    -0.06223251f, -0.04272377f, 0.01856890f, 0.05200269f, 0.01344152f, -0.02818842f, 0.00969878f, -0.06400561f, 
    -0.05576808f, 0.05071783f, 0.00953379f, 0.03830746f, -0.02864622f, 0.00896564f, 0.04755237f, 0.05023976f, 
    -0.07147639f, 0.03326583f, 0.05025744f, -0.08004611f, -0.02170705f, 0.01446386f, -0.05910564f, -0.06220436f, 
    -0.03041749f, -0.00026832f, -0.01125847f, -0.07426468f, 0.02455399f, -0.06420698f, -0.03069062f, 0.03364109f, 
    -0.01729115f, -0.05053885f, -0.06640934f, -0.01246595f, -0.03031281f, -0.06769309f, -0.06827834f, -0.03069257f, 
    -0.05497137f, 0.03380029f, 0.03871915f, 0.00895560f, 0.02256560f, -0.05891231f, 0.02764562f, -0.04029441f, 
    -0.02580593f, -0.02323769f, -0.03271164f, 0.06319184f, -0.05013863f, -0.02907442f, 0.02332913f, -0.05981448f, 
    0.02413236f, 0.01175343f, -0.05783405f, -0.07626937f, 0.04581351f, 0.02427972f, 0.00909542f, -0.00484272f, 
    -0.02415307f, -0.00525651f, 0.00194675f, -0.02018647f, -0.06904608f, -0.06185715f, 0.06904147f, -0.06044171f, 
    -0.01643106f, -0.04947294f, 0.05334938f, 0.00614337f, -0.01968063f, 0.03456602f, -0.00883293f, -0.06710554f, 
    -0.05069163f, -0.07544121f, -0.05051988f, 0.04047495f, -0.00006550f, 0.03900525f, 0.00278613f, 0.06292741f, 
    -0.06526745f, 0.04250954f, 0.04705532f, 0.05562648f, 0.01501395f, -0.00748016f, 0.05759718f, -0.01142745f, 
    0.04446075f, 0.05640544f, -0.01937099f, -0.05469076f, -0.02871172f, -0.03100025f, 0.02732882f, -0.02863697f, 
    0.05068024f, -0.01370254f, -0.02135252f, 0.01392347f, 0.04506941f, 0.04013877f, -0.01071866f, -0.03629012f, 
    0.03908454f, -0.06563628f, 0.05360629f, -0.01875033f, 0.05556940f, 0.02664412f, -0.04663252f, 0.01914586f, 
    -0.00727131f, -0.03319547f, 0.02654996f, -0.07562267f, 0.04649127f, 0.00178386f, -0.00804483f, -0.02237975f, 
    -0.01210814f, 0.06022107f, -0.04290732f, -0.03629503f, -0.01590344f, -0.03597522f, -0.04489336f, 0.00195651f, 
    -0.04392250f, -0.02072816f, -0.07380689f, 0.01888460f, -0.03537215f, -0.06437555f, -0.02801279f, -0.03399866f, 
    0.03354910f, -0.04297547f, -0.05217270f, 0.03299800f, -0.03520809f, -0.01048637f, -0.03775827f, -0.00397060f, 
    -0.00726923f, 0.06008018f, 0.05915560f, -0.04500378f, 0.02359356f, -0.00364555f, -0.02556816f, -0.07399675f, 
    -0.01820432f, -0.04716476f, 0.00751848f, 0.01802558f, 0.05606354f, -0.06996278f, -0.00228195f, 0.01990371f, 
    -0.00066895f, 0.00243042f, 0.04928626f, 0.03211140f, -0.01707035f, 0.05860542f, -0.01279122f, -0.03816180f, 
    0.01635376f, 0.03632073f, -0.07044770f, 0.06711497f, -0.05063893f, -0.00113475f, -0.06400886f, -0.06018315f, 
    0.06897728f, -0.06769264f, 0.00105159f, 0.02853088f, 0.00155406f, -0.05090331f, -0.06945786f, -0.00950346f, 
    0.05425628f, 0.06491777f, -0.02731039f, -0.00418147f, 0.02120947f, 0.00711962f, 0.04161864f, 0.01278178f, 
    -0.03883927f, -0.03544067f, -0.06466950f, 0.05744025f, -0.03618295f, -0.08199190f, 0.04683957f, -0.05928905f, 
    -0.00353356f, -0.01665900f, 0.04071746f, 0.04373021f, -0.04811746f, -0.02816333f, 0.03095868f, -0.02102310f, 
    -0.05968004f, -0.04863166f, 0.06362161f, -0.02130754f, -0.08145653f, -0.07088641f, 0.05815637f, -0.07229546f, 
    0.05996655f, -0.02747353f, 0.02253663f, -0.04575070f, 0.02681609f, 0.05251462f, 0.06608213f, -0.07358925f, 
    -0.06627687f, -0.03337808f, -0.02822335f, -0.01349309f, -0.00747693f, -0.06430940f, 0.05137120f, -0.04710010f, 
    -0.01565851f, -0.05243627f, -0.03188709f, 0.00728532f, 0.01484752f, 0.01357620f, -0.03187549f, -0.02631611f, 
    -0.10618804f, 0.02102163f, 0.20242666f, 0.01923328f, 0.09821221f, 0.00354384f, 0.04110466f, -0.03435661f, 
    0.15536286f, 0.17762519f, 0.12716684f, -0.02543735f, -0.02646448f, -0.06361364f, 0.13098544f, 0.15768540f, 
    0.05644974f, -0.10550186f, 0.07576361f, 0.09930337f, -0.09092060f, -0.02637156f, 0.04990249f, 0.27781180f, 
    0.03022369f, 0.07548280f, 0.08080160f, 0.12806465f, 0.04213372f, 0.02332512f, 0.11002477f, -0.16218971f, 
    0.02926693f, 0.08126616f, 0.09937809f, 0.00220596f, -0.10156234f, 0.08025008f, 0.13076562f, 0.02224454f, 
    0.10418897f, 0.01085710f, 0.11781152f, -0.01067813f, 0.16997799f, 0.07334369f, 0.03791988f, 0.06926160f, 
    -0.08992289f, -0.14420143f, 0.19910814f, 0.10435277f, 0.03179530f, 0.03641542f, 0.00711212f, -0.00151833f, 
    -0.01896453f, 0.03707309f, 0.17210582f, 0.02489464f, 0.02213338f, 0.05019240f, -0.23697004f, 0.21510601f, 
    0.03039433f, -0.01204390f, -0.03041723f, -0.00703431f, 0.06660023f, -0.00218773f, 0.01482052f, -0.07986800f, 
    0.16265577f, 0.23413554f, -0.03312695f, 0.35469189f, -0.13127938f, 0.10752788f, -0.14193997f, 0.17219543f, 
    0.06621633f, 0.01793497f, 0.12522933f, 0.02457668f, -0.07001032f, 0.00169271f, 0.13401963f, 0.14282116f, 
    0.14911404f, -0.07561023f, -0.02282653f, 0.12699887f, 0.11516856f, 0.09196461f, -0.03709152f, 0.06011001f, 
    -0.16566223f, 0.07800872f, -0.17676899f, -0.20064969f, 0.01669867f, 0.05607038f, -0.00132777f, 0.05135907f, 
    0.01500857f, 0.07031305f, 0.14142884f, -0.09686305f, -0.66081840f, -0.07349963f, 0.09054618f, -0.14657471f, 
    0.00111562f, 0.19605251f, 0.11413924f, -0.02539440f, -0.09545910f, 0.00798443f, -0.01731046f, 0.04265930f, 
    -0.05437979f, 0.17477423f, 0.19842662f, 0.10953468f, -0.04493801f, -0.06160003f, 0.07875428f, 0.01563916f, 
    -0.08029078f, 0.04065942f, -0.04802059f, 0.06795594f, -0.26905257f, 0.36402905f, -0.30664149f, -0.34044248f, 
    -0.04295536f, 0.23303515f, -0.07715831f, -0.33830637f, 0.13784611f, -0.01219038f, -0.02087652f, 0.03336695f, 
    0.27315101f, -0.09379481f, 0.00435685f, -0.00997166f, -0.18014292f, 0.10342082f, -0.05248088f, 0.07258080f, 
    0.03449473f, -0.04287592f, -0.04060388f, -0.04351350f, 0.00179762f, -0.04247745f, 0.31748638f, 0.16375165f, 
    -0.12501502f, -0.02025453f, -0.16810404f, -0.09399889f, 0.15075248f, 0.09501070f, -0.09958335f, 0.00470541f, 
    -0.00849948f, 0.23983037f, 0.02587893f, -0.16705699f, 0.01186470f, 0.09124663f, 0.04791670f, -0.01341288f, 
    -0.03511393f, -0.20480122f, -0.03806796f, -0.14853474f, 0.24302717f, -0.06837124f, -0.32951766f, 0.23170246f, 
    0.13564520f, -0.03445020f, -0.16313864f, -0.03836597f, -0.01623454f, -0.00581465f, 0.09413975f, -0.09499931f, 
    -0.31325600f, -0.10072808f, -0.03348943f, -0.05961471f, -0.08702122f, 0.05539413f, -0.10754496f, 0.14612070f, 
    0.04816495f, -0.11338010f, -0.04976717f, -0.06224846f, -0.25892448f, -0.35411647f, -0.31659234f, 0.16778037f, 
    -0.07674950f, -0.07949635f, 0.05045795f, -0.13653642f, -0.04916208f, -0.00407076f, -0.05244574f, -0.12275711f, 
    0.43233210f, 0.08102494f, 0.01324337f, -0.13406034f, 0.04301558f, -0.08765227f, -0.09637050f, 0.05396616f, 
    0.03737323f, 0.06442998f, 0.12332190f, 0.18156999f, 0.22558922f, 0.17087081f, -0.07471560f, 0.24662511f, 
    0.07765957f, 0.11474404f, -0.07326669f, -0.07192294f, -0.16021815f, 0.03711537f, 0.11518949f, 0.10015906f, 
    0.49570119f, 0.04046061f, 0.05149465f, 0.10363640f, 0.20160767f, -0.04604302f, 0.02133900f, -0.05224179f, 
    -0.08167960f, 0.04748967f, 0.11206655f, 0.03161115f, 0.35805595f, 0.30396968f, 0.05405245f, -0.15971395f, 
    0.00540879f, 0.10547598f, 0.01940451f, -0.03753947f, 0.00412771f, 0.00470872f, 0.08688972f, -0.03721043f, 
    -0.25067949f, 0.09176177f, 0.11091653f, -0.23308353f, 0.13958941f, -0.07785873f, 0.06288607f, -0.11058592f, 
    0.02666346f, -0.04293142f, 0.10837987f, -0.04890014f, 0.14860512f, -0.01276945f, -0.11510245f, -0.10179517f, 
    -0.10724096f, -0.15460241f, 0.05776417f, 0.01257988f, 0.08448124f, -0.06980447f, -0.03473265f, 0.06760267f, 
    -0.09654924f, 0.11692470f, 0.25437441f, -0.27881396f, -0.09414229f, -0.19169578f, 0.02349119f, 0.06447739f, 
    0.05386985f, 0.06111147f, 0.00899522f, -0.11777136f, 0.15672307f, -0.00870860f, 0.19022603f, 0.05172112f, 
    -0.02227649f, 0.01312311f, -0.03047201f, -0.00911539f, 0.02178421f, 0.09373371f, -0.03617092f, 0.00388707f, 
    -0.07179602f, 0.03299667f, -0.20449817f, -0.07006097f, -0.08525322f, -0.14510834f, 0.00375989f, -0.02939704f, 
    -0.07106254f, -0.15374784f, 0.03063372f, 0.01507978f, 0.07752214f, 0.14562775f, 0.31307197f, 0.31871539f, 
    -0.16350491f, -0.11739466f, 0.01174584f, 0.13438122f, -0.07748538f, -0.13437602f, -0.00835792f, -0.02881347f, 
    -0.51910734f, -0.16732292f, 0.12352441f, 0.04806697f, 0.19301474f, -0.04781259f, 0.03504676f, 0.10666224f, 
    -0.05942888f, 0.09597549f, 0.11383718f, -0.03921674f, -0.03503374f, 0.14222300f, -0.08261885f, 0.08792441f, 
    0.26093030f, -0.11511198f, 0.06993824f, -0.03076234f, 0.09389567f, 0.22594516f, 0.10896228f, 0.08697393f, 
    -0.04767301f, 0.01353422f, 0.27972984f, 0.09491277f, -0.28519127f, -0.06686202f, -0.08008523f, 0.06073461f, 
    -0.06946121f, 0.13298115f, -0.06589437f, 0.04996537f, 0.00658586f, -0.06030038f, -0.05136802f, -0.24646470f, 
    0.05661557f, 0.08750372f, -0.11828915f, 0.08971210f, 0.17102046f, 0.04551204f, 0.00570141f, -0.12220895f, 
    0.05623919f, -0.07062630f, 0.06717035f, -0.03751545f, -0.06430472f, 0.06521644f, -0.05591562f, -0.03622828f, 
    -0.03836733f, 0.06877529f, 0.02302775f, 0.00414339f, 0.22530083f, 0.07003019f, -0.11046382f, 0.23685205f, 
    0.08034147f, -0.06547388f, 0.09023666f, 0.11201743f, -0.02398744f, 0.05605562f, -0.02594742f, 0.24472056f, 
    -0.06445806f, 0.02321325f, -0.09459320f, -0.08688554f, 0.05881901f, -0.02898707f, -0.05918780f, 0.06345166f, 
    0.06764597f, 0.02051641f, 0.10550504f, 0.10403133f, 0.05218420f, -0.04689609f, -0.07785022f, 0.01970668f, 
    -0.05166783f, 0.03354242f, 0.01896855f, 0.03657712f, 0.04987485f, 0.00535242f, 0.09120890f, 0.40636948f, 
    0.01775352f, 0.18728513f, 0.00847682f, 0.04291008f, 0.12160700f, 0.06326152f, -0.04838277f, -0.10676461f, 
    -0.03103936f, 0.04598593f, 0.22507545f, -0.01168739f, -0.26542264f, 0.14460073f, -0.27994621f, -0.13811611f, 
    -0.00923516f, -0.08397908f, 0.00832748f, 0.08919986f, -0.01035725f, -0.01988070f, -0.00166852f, 0.06385250f, 
    0.17592809f, -0.18093681f, -0.01261104f, -0.13519597f, 0.05372109f, -0.10220702f, 0.06438573f, 0.00936169f, 
    0.00592530f, 0.16236010f, -0.00780120f, -0.04241631f, 0.03031619f, 0.17899938f, -0.05255601f, -0.13256714f, 
    -0.11348841f, 0.00984960f, -0.11517768f, -0.00118317f, -0.07967028f, -0.03292042f, 0.06927801f, -0.07238342f, 
    0.26345035f, -0.05243893f, -0.01866934f, 0.05596623f, -0.13041063f, -0.06877905f, -0.06402817f, 0.09996038f, 
    0.14969838f, 0.01551519f, 0.08967182f, -0.10760057f, 0.08892305f, 0.12399096f, 0.33291680f, -0.17306724f, 
    -0.05996200f, 0.08366092f, -0.02448503f, 0.12727872f, -0.05597072f, 0.10536711f, 0.11097642f, 0.21295948f, 
    0.05377701f, 0.12670007f, 0.15250807f, 0.16575107f, 0.10741918f, 0.12235151f, 0.01932460f, 0.01771397f, 
    0.16402291f, 0.17686374f, -0.06442263f, 0.02984734f, 0.46387285f, 0.35610738f, -0.08839113f, -0.13955265f, 
    -0.01819457f, -0.02312398f, -0.05672115f, -0.03736724f, -0.07576730f, -0.20211694f, -0.04356324f, -0.09385790f, 
    0.36355779f, -0.50581044f, 0.29029807f, 0.11583959f, 0.14843500f, 0.04206391f, -0.05831176f, 0.01146909f, 
    -0.08755574f, 0.15377843f, 0.02007112f, -0.06277993f, 0.06212119f, -0.44591224f, -0.11422393f, 0.19233398f, 
    0.00686380f, -0.08846462f, -0.11289737f, -0.08883552f, 0.12619418f, -0.04614606f, -0.08661027f, -0.06722764f, 
    0.29490769f, 0.34975693f, -0.04215512f, 0.06742839f, -0.04044109f, 0.01871349f, 0.25352108f, 0.14703229f, 
    0.13203743f, -0.02647668f, -0.01573605f, -0.22714096f, 0.11357206f, 0.00264869f, -0.27356595f, 0.22615287f, 
    0.06473310f, -0.09294005f, -0.01739933f, 0.06515525f, -0.01305156f, -0.04050855f, 0.12351108f, 0.02757713f, 
    -0.09556951f, -0.02154053f, 0.08942385f, 0.11543164f, -0.04522463f, -0.10706494f, -0.11362862f, 0.08080954f, 
    0.11960532f, -0.00140273f, 0.03123172f, -0.01449268f, -0.28826135f, -0.33811307f, -0.24169624f, 0.17192566f, 
    0.14227802f, 0.01349832f, 0.04508593f, -0.11086451f, 0.07235005f, 0.10923283f, -0.02478735f, 0.09128092f, 
    -0.00846714f, 0.09127815f, 0.18747166f, -0.03557028f, 0.01553505f, -0.17451073f, -0.06455828f, 0.18066464f, 
    -0.02403168f, -0.01556179f, -0.00571852f, 0.19700268f, 0.25390258f, 0.07332854f, -0.22001049f, -0.09148479f, 
    0.05549552f, 0.09404187f, 0.03007880f, 0.04326054f, 0.04498774f, 0.06869784f, 0.18116210f, 0.17228584f, 
    0.43969053f, -0.02308881f, -0.23078498f, -0.19395700f, 0.19383825f, 0.03582213f, 0.07260429f, -0.09411929f, 
    0.06907255f, -0.01759553f, 0.23214684f, -0.08922562f, 0.15026675f, 0.26834649f, -0.10974292f, -0.18677852f, 
    0.02383529f, 0.16606410f, 0.25760010f, -0.07731103f, -0.10635293f, -0.05435197f, 0.06882145f, 0.17386970f, 
    -0.45732000f, 0.01141741f, 0.00974109f, -0.23942645f, 0.26402995f, -0.00169722f, 0.11674702f, -0.04430814f, 
    0.14693990f, 0.00876434f, 0.08169976f, -0.12747940f, -0.01861070f, -0.17015852f, -0.17844762f, 0.15869379f, 
    -0.12067156f, -0.10263273f, -0.07226422f, 0.21512775f, 0.18150634f, -0.09906867f, -0.16357590f, 0.01789596f, 
    -0.01371983f, 0.25640613f, 0.19875036f, -0.06132826f, -0.26777539f, -0.00580488f, 0.06158688f, 0.19196817f, 
    -0.04372657f, 0.12612911f, 0.14852080f, -0.22303466f, 0.53759301f, 0.01849666f, 0.00546755f, 0.05711132f, 
    -0.07354835f, -0.08320725f, 0.08337159f, 0.03846827f, -0.04734083f, 0.05031150f, -0.02074926f, 0.06227968f, 
    -0.09529510f, 0.08697044f, -0.01403381f, -0.03935087f, 0.10180745f, -0.02895841f, -0.02952246f, 0.01872688f, 
    -0.09472978f, 0.09627555f, 0.00810951f, 0.01981867f, 0.02496964f, 0.07065470f, 0.37033996f, 0.10804754f, 
    -0.22178963f, -0.09750944f, -0.13467430f, 0.03538194f, -0.03891161f, -0.19683655f, 0.05487344f, 0.10802160f, 
    -0.51288623f, -0.04052584f, -0.12370437f, -0.06646913f, 0.09663925f, -0.15875711f, -0.04375852f, 0.09594245f, 
    0.15334229f, 0.17028621f, -0.09271821f, 0.10758910f, -0.01625043f, 0.02878332f, -0.31303510f, -0.17748137f, 
    0.23178855f, -0.03630666f, -0.03162556f, -0.24472468f, 0.02337918f, 0.09378655f, -0.12898912f, 0.18243828f, 
    0.20702574f, -0.20436953f, 0.06875797f, 0.12259080f, -0.20115124f, -0.00548669f, 0.01373592f, 0.12462134f, 
    0.14197625f, -0.08625776f, -0.08780224f, -0.02521357f, -0.32540864f, -0.07150093f, 0.00121033f, -0.09460579f, 
    0.27916062f, -0.00869141f, 0.01835178f, 0.03596631f, 0.04411677f, 0.04453950f, 0.12341163f, -0.13428704f, 
    0.30885029f, 0.12278257f, -0.05780260f, 0.26926425f, 0.15222935f, -0.08947824f, 0.00807665f, -0.03064989f, 
    0.10519417f, -0.02307452f, 0.11556362f, -0.06006470f, 0.27908581f, -0.11251139f, 0.03459376f, 0.28753096f, 
    -0.25704220f, -0.06590204f, -0.08715332f, 0.14820951f, 0.02585311f, -0.11768770f, 0.07894430f, 0.01960825f, 
    0.14657067f, -0.10416526f, 0.16877165f, 0.14194110f, -0.11303376f, 0.07540039f, 0.04096054f, -0.08073401f, 
    -0.00301350f, 0.00740443f, 0.02698550f, -0.01640173f, -0.09465240f, -0.16552092f, 0.11266109f, -0.16120532f, 
    -0.06166326f, 0.09459697f, -0.00780924f, 0.01199534f, 0.01692036f, 0.02185785f, 0.08363620f, 0.10184987f, 
    -0.10998426f, -0.09620301f, -0.01742898f, -0.20963758f, -0.03159984f, -0.10140390f, 0.10547756f, 0.06985191f, 
    0.19051890f, 0.00715808f, -0.11552346f, -0.02373296f, 0.03084250f, -0.23408927f, 0.30609676f, -0.13950686f, 
    0.05703963f, 0.05309219f, -0.07502347f, 0.08247322f, 0.14868486f, 0.10299781f, -0.00296231f, 0.02219676f, 
    -0.34745854f, -0.05685886f, 0.11814774f, 0.12028079f, -0.07860914f, 0.05122585f, 0.06176825f, -0.03282177f, 
    -0.04876069f, -0.04343005f, -0.04664852f, 0.03167462f, 0.15688215f, -0.00471890f, 0.30152306f, 0.28823051f, 
    0.00361097f, -0.02818530f, -0.13866776f, -0.06435948f, -0.07929824f, 0.15786834f, 0.09220487f, -0.09016193f, 
    -0.00590654f, 0.03462073f, 0.01723900f, 0.10729001f, 0.04629165f, 0.05342904f, 0.07379203f, 0.00034370f, 
    0.20203066f, -0.01004532f, 0.03653621f, -0.00723807f, -0.28326046f, 0.18591553f, -0.00293440f, -0.19393738f, 
    0.02315110f, 0.03763552f, 0.17585123f, 0.02307435f, 0.09485473f, -0.03198648f, 0.12238957f, -0.03285259f, 
    0.10175774f, -0.01636811f, 0.09959272f, 0.25856137f, -0.20122145f, 0.01914359f, 0.02856866f, -0.02059041f, 
    -0.13555411f, -0.13289684f, 0.15170509f, 0.11403573f, 0.17207870f, 0.00461270f, -0.06873705f, -0.02874099f, 
    0.08567408f, 0.01637490f, 0.18624690f, -0.04600335f, 0.05482395f, 0.10336138f, 0.05341997f, -0.03172686f, 
    -0.00422184f, 0.12141995f, 0.02499066f, 0.02290777f, 0.03152033f, -0.12225550f, 0.21496969f, -0.00282186f, 
    -0.20474198f, 0.03996900f, 0.04542602f, 0.06590062f, -0.06730436f, 0.11746123f, -0.16910942f, -0.16257645f, 
    -0.03612239f, 0.17314841f, 0.10057867f, -0.13485302f, 0.11188123f, -0.07385051f, -0.00459873f, -0.00008567f, 
    -0.32834485f, 0.27924734f, -0.08647954f, -0.14926539f, 0.09612369f, 0.00880960f, -0.05653154f, -0.07678423f, 
    -0.22031802f, -0.03832326f, -0.00592180f, 0.04344924f, 0.15083165f, -0.02441231f, 0.03586804f, -0.16260476f, 
    -0.11031546f, -0.12605701f, 0.02239058f, -0.16674221f, -0.07113180f, 0.04788694f, 0.00036826f, 0.03069304f, 
    -0.18648489f, -0.17085457f, -0.18519692f, -0.00834413f, 0.12323374f, 0.17928995f, 0.01978371f, 0.01045755f, 
    0.02325932f, -0.03617731f, 0.10972849f, 0.01298409f, 0.28341889f, 0.21579403f, -0.01490132f, 0.03249126f, 
    -0.08723633f, -0.01860495f, -0.03786877f, -0.05325161f, -0.00066558f, 0.10870640f, 0.08884325f, 0.16321397f, 
    -0.72770298f, -0.41035476f, -0.04686856f, 0.05570970f, -0.11087484f, 0.00621816f, 0.14257881f, -0.08196761f, 
    0.09107545f, -0.11127845f, 0.00981003f, 0.14464463f, 0.27418941f, 0.03571012f, 0.05486823f, -0.01657850f, 
    -0.10901255f, 0.21704109f, 0.15522276f, -0.02756600f, 0.21064648f, 0.09704802f, 0.10000046f, 0.16183375f, 
    0.46494833f, 0.21848878f, 0.00838452f, -0.10712872f, -0.04640820f, 0.13169067f, 0.12170954f, -0.01054528f, 
    -0.00643072f, 0.09733198f, 0.06947944f, -0.02670084f, 0.14347984f, 0.29187781f, 0.23666234f, 0.02730200f, 
    0.06246243f, -0.07460834f, 0.19597027f, 0.00347745f, -0.04427943f, -0.18124801f, 0.03828897f, 0.07363723f, 
    0.06883749f, -0.11081047f, 0.21047084f, -0.22548610f, 0.08487192f, -0.10062259f, 0.18159556f, -0.16526005f, 
    -0.00317174f, 0.10255997f, -0.05685310f, 0.00766374f, -0.04255568f, -0.27825129f, -0.20856915f, 0.01166689f, 
    -0.09656601f, -0.05652546f, 0.08322041f, 0.18736686f, 0.01891274f, -0.19763821f, -0.05187286f, -0.00892496f, 
    -0.26160663f, -0.05753371f, -0.13146845f, -0.08253263f, 0.08515088f, 0.19759870f, 0.04874348f, 0.07265031f, 
    -0.05719642f, 0.07213144f, 0.04386092f, -0.27770397f, 0.20858142f, -0.02446634f, -0.05542661f, -0.05738548f, 
    0.10670760f, 0.13079114f, 0.06005485f, -0.02563903f, 0.02242002f, 0.04461848f, -0.03176410f, 0.03967630f, 
    -0.18401800f, 0.10923781f, 0.02724657f, -0.05400786f, 0.12775247f, 0.19242209f, 0.02195682f, 0.17381379f, 
    -0.07880991f, 0.13818938f, 0.10849497f, 0.11493010f, 0.27176413f, -0.27850279f, 0.06921129f, -0.16224380f, 
    0.05417741f, 0.15380466f, 0.03283963f, 0.00818468f, -0.01145459f, -0.15674174f, 0.08600961f, -0.07345455f, 
    -0.11577726f, 0.03029940f, 0.14140193f, -0.16350363f, 0.09587842f, -0.16275673f, -0.14540741f, 0.02186701f, 
    0.03106396f, 0.19260924f, 0.05826267f, 0.02490145f, -0.07000892f, 0.20212305f, 0.11478581f, -0.01023857f, 
    0.00748273f, 0.00404265f, -0.09583227f, -0.01905065f, 0.07659014f, 0.01012497f, -0.05882511f, -0.03454614f, 
    0.26169473f, -0.21460661f, -0.26794642f, -0.06076603f, 0.18934108f, 0.06504819f, 0.12274719f, -0.00897387f, 
    0.01873052f, -0.00923063f, -0.12927729f, -0.14802216f, -0.04982660f, 0.21782035f, 0.15303715f, 0.04846604f, 
    -0.08777348f, -0.07020769f, 0.04429248f, 0.08339614f, 0.09778797f, -0.00428106f, 0.04141314f, 0.00258978f, 
    -0.33046514f, -0.15047914f, 0.00432806f, 0.02388270f, 0.12518129f, -0.01335184f, -0.07672047f, 0.09747883f, 
    0.16539946f, -0.02073458f, -0.00280592f, 0.12550874f, 0.27400577f, 0.29150781f, 0.28219146f, 0.16255179f, 
    -0.13169937f, -0.07994681f, -0.05192060f, -0.04172230f, -0.05420684f, -0.06196756f, 0.03891757f, 0.09892208f, 
    -0.42378491f, -0.26476598f, -0.03919907f, -0.15950195f, 0.01540419f, -0.07731819f, 0.04596599f, 0.11043443f, 
    -0.07511467f, -0.04057819f, -0.01449737f, 0.08434772f, 0.16352749f, -0.02585956f, 0.13603510f, 0.04429542f, 
    -0.10289074f, 0.24088231f, 0.09382132f, 0.05630606f, 0.07513810f, 0.14578971f, -0.03562012f, 0.05453497f, 
    0.05657426f, 0.08662827f, 0.19299477f, 0.04155316f, -0.03159071f, 0.17699629f, 0.13508950f, 0.05646807f, 
    -0.04834693f, 0.08813844f, 0.07405093f, 0.04285125f, 0.04693728f, 0.11666197f, 0.26643121f, 0.16015784f, 
    -0.04835938f, -0.04782140f, 0.19549571f, -0.05583501f, -0.14162122f, -0.20104910f, 0.14512026f, -0.07313194f, 
    0.14199896f, 0.03023772f, 0.37202457f, -0.19646005f, -0.12121299f, -0.06969235f, 0.21445012f, 0.00149776f, 
    0.04852740f, -0.00864560f, 0.05339647f, -0.01373207f, -0.22425213f, -0.14464958f, -0.13916172f, -0.11200974f, 
    -0.12778226f, -0.04847405f, -0.01974724f, 0.16144736f, 0.10272258f, -0.05514446f, -0.09048673f, -0.10468937f, 
    -0.41371995f, -0.06678089f, -0.05513148f, -0.20034727f, 0.14650072f, 0.20523892f, -0.02991852f, 0.02549370f, 
    -0.02525737f, -0.00706932f, 0.11134247f, -0.19576599f, -0.20600110f, -0.03588151f, -0.26410657f, -0.08906809f, 
    0.18403168f, 0.17671192f, 0.05185586f, 0.14402238f, 0.04213267f, 0.03100584f, -0.08048698f, -0.00985716f, 
    -0.51549321f, 0.12380049f, 0.13170812f, 0.04550071f, 0.08366232f, 0.06076775f, 0.04018835f, 0.11565240f, 
    -0.09259991f, -0.02450720f, 0.00511306f, 0.11611310f, 0.11958193f, -0.16074413f, -0.08562814f, -0.12785694f, 
    0.14695074f, 0.18774189f, 0.08522543f, 0.04395641f, -0.01361204f, 0.01562166f, 0.10149357f, -0.01520129f, 
    -0.01532990f, -0.14518119f, 0.16289586f, -0.26948830f, 0.15222441f, -0.09519742f, -0.04476614f, -0.01463035f, 
    0.08138190f, 0.08141673f, 0.03628802f, 0.02363480f, 0.28392366f, 0.18853919f, 0.19689074f, 0.09114250f, 
    -0.06182216f, -0.07783511f, 0.02022513f, 0.10198654f, 0.17725323f, -0.11221702f, -0.00404088f, 0.03838909f, 
    0.06380382f, -0.24849689f, -0.27016556f, 0.02688509f, 0.14601000f, 0.06200332f, 0.05509957f, 0.03706287f, 
    0.01316254f, -0.03799977f, 0.04179823f, -0.06172304f, -0.13062681f, 0.23740804f, 0.18993968f, 0.12784460f, 
    -0.13445002f, -0.05900334f, 0.03610408f, 0.10316148f, 0.05296150f, -0.01417747f, -0.01708669f, -0.01760483f, 
    -0.03522354f, -0.01251689f, -0.11878207f, -0.06629978f, -0.06205255f, 0.11743311f, 0.05471391f, 0.00068908f, 
    0.00070647f, -0.01752051f, -0.00264220f, 0.01360259f, 0.24249552f, 0.18775548f, -0.11749642f, -0.13586120f, 
    -0.09638589f, 0.06076676f, -0.12698585f, 0.20454375f, -0.00271550f, -0.02719179f, 0.02265495f, 0.16363886f, 
    -0.31947631f, -0.31797418f, 0.11470353f, 0.14788140f, 0.05091713f, -0.03827441f, 0.11614180f, 0.00236112f, 
    0.05564720f, 0.04657168f, 0.27825257f, -0.01324384f, 0.19157106f, -0.29317078f, -0.08085721f, 0.01301201f, 
    0.10701858f, 0.08659537f, 0.04345375f, 0.07733697f, 0.01718344f, -0.05692709f, -0.12676530f, 0.23574188f, 
    0.30893359f, 0.07763691f, -0.27855492f, -0.00906486f, -0.02224822f, -0.08668654f, 0.00837233f, -0.05605881f, 
    0.03932805f, 0.04773793f, 0.24995679f, -0.16781744f, 0.57961994f, 0.32380518f, 0.10817832f, 0.20290534f, 
    0.03170109f, -0.12301908f, -0.02323132f, -0.05382831f, -0.07156213f, -0.08415485f, -0.00365945f, 0.18513292f, 
    0.22245367f, 0.07693514f, -0.11061928f, -0.11775173f, 0.01123735f, 0.06436997f, -0.02582547f, -0.13017297f, 
    0.09182292f, -0.11723521f, -0.05962917f, -0.11974822f, -0.04732805f, -0.16561610f, -0.16693123f, 0.13771921f, 
    -0.13292573f, -0.00275540f, 0.02642092f, 0.18556204f, 0.05223996f, -0.09761251f, 0.14362499f, -0.01839571f, 
    0.06698626f, -0.11008177f, -0.00577461f, -0.13191947f, -0.02544280f, 0.13430938f, -0.11273111f, 0.05249047f, 
    0.09923118f, -0.03355272f, 0.03714388f, -0.09493110f, 0.08084086f, -0.15147133f, 0.11478648f, 0.29067251f, 
    0.04639580f, 0.02634777f, -0.06333483f, -0.03461116f, 0.09587797f, 0.00913351f, 0.00252311f, 0.07130985f, 
    -0.05763241f, 0.08449464f, -0.10428995f, -0.10427198f, 0.07616899f, 0.09288023f, 0.08465035f, 0.13584656f, 
    -0.18447754f, 0.04572388f, -0.09567815f, 0.07302541f, 0.32054117f, -0.23948832f, 0.03451891f, -0.11207094f, 
    -0.01931646f, 0.09481267f, -0.13527197f, -0.05109414f, -0.00640933f, -0.09221017f, -0.06653254f, 0.12728548f, 
    0.00902303f, 0.04424834f, 0.00870368f, 0.05075811f, 0.05259074f, -0.07517371f, 0.12389874f, 0.08548104f, 
    -0.03157148f, 0.25708801f, 0.17389086f, 0.08050634f, -0.37554526f, 0.10828537f, -0.09369493f, -0.05340246f, 
    0.04752767f, -0.05708371f, -0.10082890f, -0.00786434f, 0.01983964f, -0.00891724f, 0.08576197f, -0.00604046f, 
    0.32426351f, -0.19581276f, -0.15499127f, -0.04247909f, 0.00437873f, 0.04872983f, 0.11334369f, -0.10662625f, 
    0.02141846f, 0.09335265f, -0.06662515f, -0.09798942f, 0.15106238f, 0.27277806f, 0.05319672f, -0.16033471f, 
    0.06217199f, -0.09775530f, -0.13509451f, -0.00605868f, 0.01325209f, 0.01606334f, 0.14513199f, -0.07831435f, 
    0.04347457f, -0.10691812f, 0.18632226f, -0.02478698f, 0.06134594f, 0.02543675f, -0.00688173f, 0.14794213f, 
    0.11028863f, 0.14556842f, 0.17440735f, -0.05579826f, 0.11936679f, -0.10767022f, 0.33157575f, 0.12166018f, 
    -0.07779530f, 0.12774314f, 0.13168786f, 0.09416232f, 0.01641823f, -0.07343066f, 0.09347389f, 0.19544132f, 
    0.24813418f, 0.12428244f, 0.07659148f, -0.06713647f, 0.03358051f, -0.01416421f, 0.00027735f, -0.05072714f, 
    0.04035053f, 0.08021015f, 0.05926649f, 0.03693553f, -0.42518735f, 0.09376645f, 0.04147919f, -0.04693192f, 
    0.08563351f, -0.09757829f, 0.06822038f, 0.15303090f, 0.05807292f, 0.12189638f, 0.16810820f, 0.03826533f, 
    -0.37516570f, -0.15617521f, 0.20442371f, 0.02471292f, 0.03499500f, 0.06349707f, -0.00578651f, -0.01265558f, 
    0.05428520f, -0.03872930f, 0.03208003f, 0.09256339f, -0.28285462f, -0.17618045f, 0.02064870f, 0.19417946f, 
    -0.02338980f, 0.01062930f, -0.10789894f, -0.06363022f, 0.21089488f, 0.09458891f, 0.04750902f, 0.03399025f, 
    0.02452030f, 0.09022482f, 0.10305361f, 0.07589328f, 0.00654345f, 0.10409465f, -0.11395684f, 0.17902994f, 
    -0.03100561f, -0.08410974f, 0.08072518f, 0.06585997f, -0.33619949f, 0.00734613f, 0.23323280f, -0.05803113f, 
    0.01416465f, -0.03712555f, 0.00333104f, 0.03336814f, 0.17482230f, 0.07836246f, 0.01890238f, 0.18552192f, 
    -0.13958971f, -0.07631310f, -0.09348235f, -0.08915868f, 0.01853846f, -0.04626352f, 0.10125156f, 0.04674092f, 
    0.08830675f, -0.06937747f, 0.09655475f, 0.06931363f, -0.53058636f, 0.10348779f, -0.03873353f, -0.17922823f, 
    -0.00150410f, -0.06780266f, 0.09054918f, 0.13610707f, -0.00688820f, -0.03594731f, -0.01590800f, 0.05467395f, 
    0.05170939f, 0.19853535f, 0.32942480f, -0.00580673f, 0.04627222f, 0.01483982f, 0.08908686f, 0.04243062f, 
    0.05623214f, -0.03718690f, -0.01432104f, 0.11854360f, -0.11784732f, 0.12818941f, -0.34274593f, -0.10300171f, 
    -0.17068772f, 0.06567056f, 0.00785471f, -0.14956196f, 0.07081274f, -0.11315811f, 0.07584628f, 0.03948325f, 
    0.35312748f, -0.09326965f, -0.01885723f, 0.04468636f, 0.00022225f, 0.08769397f, 0.13719647f, 0.04653518f, 
    0.09175409f, -0.06745829f, 0.00272799f, 0.04355597f, -0.06402276f, -0.11381760f, 0.14060397f, 0.08701868f, 
    -0.09142752f, -0.11635470f, -0.00833146f, 0.03146986f, 0.16678675f, 0.03342149f, -0.02948335f, 0.01283965f, 
    -0.16262774f, 0.19030501f, -0.07773875f, 0.04291047f, -0.05518574f, -0.03376742f, 0.06834956f, 0.01860721f, 
    0.02357994f, -0.03141330f, -0.02658914f, -0.09921375f, -0.04281977f, -0.23496923f, -0.07747791f, 0.23432668f, 
    0.12093276f, 0.05657110f, -0.06548019f, -0.03539229f, 0.01133574f, 0.08141457f, -0.10556417f, 0.03526509f, 
    0.33300757f, -0.01265643f, -0.02255200f, 0.00916653f, 0.07876879f, 0.09534260f, 0.03111330f, -0.05798146f, 
    0.01838941f, -0.14097896f, 0.03753145f, 0.00708424f, 0.01770460f, 0.06451331f, -0.04351177f, -0.02865686f, 
    -0.04817504f, -0.00841277f, -0.00669083f, 0.09631065f, 0.06736236f, 0.04038196f, 0.03297020f, 0.20830332f, 
    -0.72650182f, -0.17617148f, 0.17990105f, 0.21691877f, -0.09189958f, -0.04339795f, 0.12034468f, 0.07980879f, 
    0.00080320f, 0.00880923f, -0.09598225f, -0.04729655f, 0.00206027f, 0.02020920f, 0.06956682f, -0.08098923f, 
    -0.01283596f, 0.03175119f, 0.06129029f, -0.00885423f, 0.19494510f, 0.06851183f, -0.07343625f, 0.02987147f, 
    0.10103660f, 0.11737653f, 0.10618320f, -0.15121043f, 0.02167423f, -0.06571855f, 0.09002928f, 0.08939555f, 
    0.12405029f, 0.00984953f, -0.10816722f, -0.09405552f, 0.11348275f, 0.03342301f, 0.03499493f, 0.29640424f, 
    0.07145710f, 0.03514604f, 0.09114646f, 0.03043255f, -0.05907768f, -0.03415455f, -0.00002328f, -0.00285481f, 
    -0.01593395f, 0.03169024f, -0.05143924f, 0.27155086f, 0.01396715f, 0.02874515f, 0.05259571f, 0.05562509f, 
    -0.06381204f, -0.03730139f, -0.01568810f, -0.05501910f, 0.05779607f, -0.07043345f, -0.17491360f, 0.27629960f, 
    0.12329708f, 0.13062735f, 0.03252461f, 0.18568778f, 0.00028061f, 0.08043669f, -0.04954996f, -0.11380098f, 
    -0.08840657f, 0.04780362f, -0.25443423f, 0.19744933f, -0.05594024f, 0.22168754f, -0.02292843f, 0.05457237f, 
    -0.12577827f, 0.12312052f, 0.02142662f, 0.03118600f, 0.07671376f, 0.06169543f, -0.07826117f, 0.06125111f, 
    -0.07065440f, 0.12163561f, 0.16756420f, -0.03256149f, -0.10108295f, -0.02952966f, 0.00337013f, 0.04901753f, 
    0.01925973f, -0.15587497f, 0.04281002f, 0.13914020f, 0.05180005f, 0.04716915f, -0.06789877f, 0.07689703f, 
    -0.05052010f, 0.16975321f, 0.00542233f, -0.00182641f, -0.15162067f, -0.18941240f, -0.14304605f, -0.22514065f, 
    -0.03322061f, 0.08603509f, -0.02997312f, -0.03789927f, 0.06055857f, 0.05093055f, -0.02698629f, 0.13068365f, 
    -0.03427360f, 0.30080855f, -0.25398234f, -0.16707943f, 0.00412361f, 0.03762342f, -0.04345556f, -0.01071693f, 
    0.03439432f, -0.02358134f, -0.07192682f, 0.17363459f, -0.11984015f, 0.19821353f, 0.15764907f, -0.14482719f, 
    -0.12183729f, 0.09478218f, 0.02883956f, -0.05169813f, 0.03581389f, -0.06477875f, -0.01102947f, 0.10274031f, 
    0.01878195f, 0.03107022f, -0.23526087f, -0.19897267f, 0.18840252f, -0.08371355f, -0.11835692f, -0.04359265f, 
    0.13307093f, 0.08562291f, 0.00847415f, -0.00479393f, 0.11221249f, 0.10376516f, 0.17849854f, -0.03199434f, 
    0.02862490f, -0.04488506f, 0.09705818f, -0.07789182f, -0.05237127f, -0.07240539f, -0.04522146f, 0.12111355f, 
    -0.01192410f, 0.00703577f, 0.29125148f, -0.09282988f, 0.08075336f, -0.06809697f, 0.15846092f, 0.08349244f, 
    0.14454091f, 0.01844525f, 0.09902402f, 0.05351397f, -0.32473949f, -0.30406013f, 0.26481918f, 0.08567493f, 
    0.00467582f, -0.04209032f, 0.04989675f, -0.02750154f, 0.00178431f, -0.00264256f, 0.02822309f, 0.08944117f, 
    -0.16296771f, 0.16852586f, 0.05271770f, -0.05984139f, -0.02963612f, -0.04247729f, 0.14737137f, 0.01024737f, 
    -0.01588440f, 0.03432427f, -0.25416264f, -0.00743882f, -0.07988634f, 0.16053459f, 0.08415350f, 0.11093310f, 
    0.13397597f, -0.02885318f, 0.07914710f, -0.02994151f, 0.08612437f, 0.03398503f, 0.07747601f, 0.05412493f, 
    -0.01339111f, -0.04006132f, 0.16976511f, 0.34571984f, -0.03672097f, -0.03347260f, 0.06228126f, 0.10910100f, 
    -0.07045484f, -0.12874894f, 0.02999648f, -0.01894279f, 0.33502379f, -0.12154068f, -0.10188926f, -0.08887836f, 
    0.03183961f, -0.09342635f, 0.03225344f, -0.08605989f, -0.06575234f, 0.10147798f, 0.08987863f, -0.00636163f, 
    0.06619850f, 0.04198496f, 0.04937514f, 0.01305312f, -0.07219262f, -0.07701718f, -0.00046656f, 0.05477863f, 
    -0.09715059f, -0.09381103f, 0.09719208f, 0.00978396f, 0.00089760f, 0.20663331f, -0.04309528f, -0.23076382f, 
    -0.02242828f, 0.00670656f, 0.03522151f, 0.04254422f, 0.27070859f, 0.15688676f, -0.10690159f, 0.03533445f, 
    -0.31402329f, 0.00928782f, 0.04250244f, 0.09077279f, 0.15470438f, 0.05407205f, 0.05004045f, 0.05238823f, 
    -0.07698513f, 0.16913514f, -0.02557550f, -0.03868117f, -0.31108028f, 0.35947996f, -0.11583161f, -0.10201266f, 
    0.02146897f, 0.02116062f, -0.01986455f, -0.04583940f, -0.08964112f, 0.05533046f, -0.01576551f, -0.02316638f, 
    -0.07130633f, 0.02923476f, 0.16639979f, -0.00200366f, -0.04727893f, -0.15751727f, -0.00010140f, 0.00849904f, 
    0.07645506f, 0.03907342f, 0.13348955f, 0.12007987f, -0.21010929f, 0.17820258f, 0.02060951f, 0.07010543f, 
    0.09470937f, 0.12085914f, -0.03268840f, -0.17021741f, 0.09026663f, -0.03004559f, 0.17755768f, -0.02169553f, 
    -0.12169027f, 0.19394992f, -0.04573228f, -0.05203632f, -0.12261701f, 0.04932850f, -0.03631760f, -0.02954641f, 
    0.02352589f, -0.02885543f, -0.13042034f, 0.01320123f, 0.57722437f, -0.09448805f, 0.17236269f, 0.50242615f, 
    -0.06079789f, 0.00248806f, -0.00676375f, -0.10110679f, 0.03955180f, 0.04788571f, -0.11242925f, 0.04006917f, 
    -0.32850671f, 0.22364308f, 0.02547077f, 0.08266319f, 0.11227391f, 0.07020525f, -0.08160053f, 0.02193715f, 
    0.12851867f, -0.00377524f, -0.09202975f, 0.03156874f, 0.14811110f, -0.23586236f, -0.15784429f, 0.27432871f, 
    -0.09577242f, -0.01664259f, 0.04952601f, -0.02235609f, 0.11359373f, -0.12053490f, -0.04545050f, -0.03069482f, 
    0.03091809f, 0.00066530f, -0.14989570f, 0.08302515f, 0.02584643f, 0.19244666f, 0.03248907f, -0.00137490f, 
    -0.17148711f, 0.07765346f, -0.16408780f, -0.13177104f, -0.01738516f, 0.10201046f, -0.13267738f, -0.34858680f, 
    0.00464234f, 0.01940993f, -0.06332918f, 0.04909375f, 0.15675445f, 0.06533594f, 0.01099181f, -0.17264591f, 
    0.52150869f, 0.21836445f, -0.06381705f, 0.13815339f, 0.10008983f, 0.13397293f, 0.00362073f, 0.11398299f, 
    0.08523035f, 0.02809347f, 0.12816958f, -0.03490070f, 0.00547675f, -0.05075527f, -0.10106649f, 0.02832967f, 
    0.05193616f, -0.15610379f, -0.11181469f, 0.05277998f, -0.02455371f, -0.01772313f, -0.01384868f, -0.13128290f, 
    0.23333997f, 0.00357855f, -0.27284431f, -0.14371076f, -0.04679853f, 0.10938255f, -0.04295859f, 0.05663798f, 
    0.03080661f, 0.09364942f, -0.13562910f, -0.00477382f, -0.37331533f, 0.01489455f, 0.06954197f, 0.09272275f, 
    0.14081953f, 0.18915896f, 0.03090106f, 0.04708186f, 0.01227088f, 0.04171537f, -0.01823253f, 0.02996282f, 
    -0.23396261f, 0.11068732f, -0.14305238f, -0.11537620f, 0.13340175f, 0.04857454f, -0.00672560f, 0.00862745f, 
    -0.02358864f, 0.10763603f, -0.11817453f, 0.00875549f, 0.00186567f, -0.00114145f, 0.17624716f, 0.22049332f, 
    0.13894640f, 0.00584925f, 0.02768389f, -0.03838019f, -0.11253829f, -0.02740414f, 0.00014916f, 0.04863149f, 
    0.42370871f, 0.17054214f, 0.07805445f, -0.06468491f, 0.05123368f, -0.07086350f, 0.16165592f, 0.05297004f, 
    0.06545863f, -0.03366385f, -0.11898161f, 0.04652501f, 0.66178769f, -0.21109390f, 0.05746784f, 0.24894415f, 
    0.01951993f, -0.05573290f, 0.12641686f, -0.01210821f, 0.07174220f, -0.03813770f, -0.02126203f, 0.08907164f, 
    0.19736506f, -0.05028766f, -0.11325856f, -0.22575533f, -0.01261208f, 0.02211900f, 0.00983089f, -0.02957256f, 
    0.15524927f, -0.12427576f, -0.00804165f, -0.04800134f, -0.04580297f, -0.00609669f, 0.23305811f, 0.15166384f, 
    0.01770627f, -0.02823738f, 0.10723335f, 0.27336243f, 0.00829250f, 0.08439841f, -0.06229047f, 0.09184545f, 
    -0.03790218f, 0.38647047f, -0.01298468f, 0.16549689f, 0.01302955f, -0.10976742f, 0.04242973f, 0.01646575f, 
    0.06881540f, -0.09104176f, 0.10095488f, -0.12947257f, -0.25837314f, 0.12118983f, -0.17239369f, -0.23739867f, 
    0.15146299f, 0.00134960f, 0.06463519f, -0.05494555f, -0.10867107f, -0.03957985f, 0.08528853f, -0.02973265f, 
    0.25052777f, -0.11151756f, 0.21825761f, 0.15185075f, -0.02889452f, 0.06859999f, 0.02600117f, -0.02774645f, 
    0.03215081f, 0.20427477f, 0.10656895f, 0.18008696f, -0.22394846f, 0.15192030f, 0.12837511f, -0.11713561f, 
    0.12652221f, -0.05678841f, 0.10496918f, -0.15920959f, -0.12897773f, 0.02351149f, -0.06461578f, 0.15986292f, 
    0.04462403f, 0.02395512f, 0.04907300f, 0.00398544f, 0.03065743f, 0.08740831f, 0.08527624f, -0.01314666f, 
    0.03152764f, 0.10493970f, -0.13260767f, 0.01315647f, -0.14319310f, 0.08070382f, 0.06804767f, -0.27365050f, 
    -0.03055109f, -0.01097964f, -0.05705995f, -0.15068167f, 0.05139057f, 0.05347877f, -0.04806305f, 0.03455409f, 
    0.01213873f, 0.10561837f, -0.15488149f, -0.26599336f, 0.09380656f, 0.00782504f, -0.11796591f, 0.05054151f, 
    0.05678917f, -0.05381771f, -0.01764959f, 0.05091832f, -0.16717270f, 0.12902796f, -0.14441419f, 0.02802374f, 
    -0.05291954f, -0.08343775f, 0.04026673f, 0.13179603f, 0.06428396f, 0.06365816f, -0.08827569f, 0.03838023f, 
    -0.07008811f, 0.13716708f, -0.06345779f, 0.03073894f, -0.13570851f, 0.16452956f, 0.00458229f, 0.12830672f, 
    0.18199736f, 0.03353810f, -0.03574375f, 0.01544209f, -0.46056396f, 0.03591625f, 0.10594864f, 0.09337901f, 
    0.16965421f, 0.00095154f, 0.01892822f, -0.02561944f, -0.05813073f, 0.05529898f, 0.09842934f, 0.04455874f, 
    -0.08083444f, -0.18271579f, 0.18185596f, -0.49259380f, -0.01879932f, 0.01623554f, 0.03275795f, 0.08112911f, 
    -0.02232763f, 0.21030293f, -0.07478402f, 0.11764187f, -0.12057750f, 0.05088271f, 0.02430560f, -0.13883224f, 
    -0.04632729f, 0.07404704f, 0.10850478f, -0.01682981f, -0.10470118f, -0.00302694f, 0.03204753f, -0.02257818f, 
    0.26524612f, 0.19468990f, 0.08308371f, 0.11457224f, -0.07181323f, -0.07704454f, 0.02225589f, -0.00249011f, 
    -0.03653444f, 0.01636620f, -0.02085588f, 0.16517766f, 0.54722708f, 0.04519035f, -0.03702523f, 0.06920718f, 
    0.01358155f, 0.03467609f, -0.02198279f, 0.15632586f, 0.01746834f, 0.00032027f, -0.11084600f, 0.05279668f, 
    -0.15568519f, 0.10909963f, 0.11442284f, -0.32095110f, 0.14855008f, 0.16489913f, 0.08257455f, 0.13103501f, 
    0.11722588f, 0.08418570f, -0.02488763f, 0.01941471f, 0.23772518f, 0.03940692f, 0.17388767f, -0.15270032f, 
    0.10961048f, 0.02587575f, -0.01573610f, 0.10909200f, -0.04324146f, 0.02554529f, -0.04096540f, 0.05607257f, 
    0.00300065f, -0.12518656f, 0.05034551f, -0.01446227f, -0.05997876f, -0.07845474f, -0.00756956f, 0.06832170f, 
    -0.10052289f, -0.09341121f, -0.03723026f, -0.10290050f, 0.32810551f, 0.00157783f, 0.05968673f, 0.32093465f, 
    -0.09237388f, -0.00148279f, 0.04763210f, 0.20701925f, -0.02557059f, 0.12370756f, 0.03785128f, 0.01107988f, 
    0.47843471f, -0.10970114f, 0.02560981f, 0.08712885f, -0.02850712f, -0.14871711f, 0.07321741f, 0.12078123f, 
    0.13399015f, 0.07609174f, 0.11282789f, 0.11419293f, -0.49336651f, 0.07598154f, 0.03728356f, 0.22704209f, 
    -0.10989200f, 0.00112248f, 0.10230480f, -0.13969825f, -0.13022923f, -0.03168343f, -0.07071257f, 0.09603005f, 
    -0.03648624f, 0.03896074f, -0.07096016f, 0.28353199f, -0.04630718f, -0.03291340f, 0.00857244f, 0.06402611f, 
    -0.06134948f, -0.22753724f, -0.00170908f, -0.07656663f, 0.08323861f, -0.07333350f, -0.08870798f, 0.13724636f, 
    -0.07721500f, -0.10109200f, -0.11513995f, 0.12521753f, 0.07099614f, -0.09318970f, 0.02168953f, -0.17045900f, 
    0.57202691f, -0.03350835f, 0.10569060f, 0.17126410f, -0.06885046f, 0.08240795f, 0.02817493f, 0.01146270f, 
    -0.12641937f, 0.16855606f, 0.15652686f, -0.08608327f, 0.23599215f, -0.03581500f, 0.20471412f, -0.08032572f, 
    0.00050733f, -0.06851690f, 0.02530509f, -0.09642656f, -0.12215203f, 0.02140605f, 0.01056697f, -0.17173852f, 
    0.14746273f, -0.14073266f, 0.01025302f, -0.24706344f, 0.08487706f, -0.03053810f, 0.12200661f, 0.06322105f, 
    -0.01295419f, 0.01218020f, -0.02426850f, 0.09105801f, 0.11546426f, 0.16476475f, 0.19382189f, -0.01386791f, 
    -0.00145680f, 0.13448234f, -0.14838569f, 0.07903657f, 0.02501584f, -0.00879532f, -0.02742966f, -0.12369796f, 
    -0.13279578f, 0.19352713f, 0.03019146f, 0.36707380f, -0.09400082f, 0.05262865f, 0.04111186f, -0.01782964f, 
    0.01517158f, 0.01373710f, -0.01072025f, 0.11071858f, 0.25298804f, -0.06821118f, 0.37279490f, 0.28586698f, 
    0.17803058f, -0.12328203f, -0.02179320f, -0.00201281f, -0.14622973f, 0.13402294f, 0.05948930f, -0.11995209f, 
    -0.02345072f, 0.02056987f, -0.00440530f, -0.00461024f, -0.00944045f, 0.09876295f, -0.09507382f, -0.10481492f, 
    0.22485901f, -0.05794593f, -0.10885684f, 0.05131848f, -0.29623196f, -0.21799509f, 0.11787686f, -0.10007890f, 
    0.13789339f, 0.03698629f, 0.05987665f, -0.04145687f, 0.03451786f, 0.01559129f, 0.19272681f, -0.08494548f, 
    0.05578403f, -0.22743848f, -0.13124225f, 0.36514035f, -0.20980142f, -0.00480250f, 0.03199431f, -0.02900911f, 
    -0.08917128f, -0.21761164f, -0.05065426f, -0.00331850f, -0.04403245f, 0.01235441f, -0.06920230f, 0.05534262f, 
    0.11066292f, -0.01654090f, 0.12308750f, 0.02915214f, 0.09889635f, 0.17424743f, -0.02792615f, 0.13487799f, 
    -0.07805976f, 0.09246784f, -0.00010492f, 0.01844311f, -0.07517128f, -0.00173236f, 0.05551886f, 0.02698379f, 
    -0.01668319f, -0.02399657f, 0.12198984f, 0.02243177f, -0.05054352f, 0.26000261f, 0.04571324f, -0.31190988f, 
    0.10186020f, 0.11729621f, 0.05294214f, 0.02990680f, 0.11270986f, 0.02149927f, 0.05976226f, 0.01118198f, 
    -0.34637475f, 0.15747437f, 0.16715252f, -0.08342673f, -0.00086752f, 0.09364492f, 0.00998077f, -0.09016290f, 
    -0.26720399f, -0.02583575f, 0.03863099f, 0.06797640f, 0.39569291f, 0.00637625f, 0.06639068f, -0.33702463f, 
    0.07755815f, -0.00165374f, -0.01566882f, -0.02363007f, -0.00844877f, 0.17927073f, 0.11994341f, 0.02304067f, 
    0.10134662f, 0.06565239f, 0.02712093f, -0.03541066f, -0.01823071f, 0.10451354f, -0.03966727f, -0.04949221f, 
    -0.03729865f, -0.06729636f, -0.09484619f, 0.01401263f, 0.00181988f, -0.01212949f, 0.06807232f, 0.11249837f, 
    -0.02038130f, -0.05296772f, -0.04255377f, 0.00895460f, 0.12256243f, -0.00828419f, 0.02735245f, -0.17745072f, 
    0.32550043f, 0.15506928f, -0.07559767f, -0.24861310f, 0.10191464f, 0.09483553f, -0.14201374f, 0.03086886f, 
    0.11362334f, 0.02915714f, 0.13773677f, 0.11527967f, -0.07645448f, -0.08188355f, -0.14149411f, 0.13873641f, 
    0.02014694f, -0.02702005f, -0.12114593f, 0.07797246f, -0.19232881f, 0.02437051f, 0.10575212f, 0.13966385f, 
    -0.02619700f, -0.03080013f, -0.11526503f, 0.11247165f, -0.00427807f, -0.06075158f, -0.04245422f, 0.03143236f, 
    -0.01084922f, 0.05399378f, -0.04202647f, 0.08854279f, 0.09603180f, -0.26611608f, 0.02398688f, -0.26858601f, 
    -0.01865177f, 0.07320368f, -0.06894349f, -0.04398211f, 0.05748182f, 0.10756158f, 0.05693072f, 0.10778136f, 
    -0.03302966f, -0.08889690f, -0.01723708f, -0.08326241f, 0.00551338f, 0.02242835f, -0.05261362f, -0.09672721f, 
    0.05012716f, 0.04452851f, 0.02039564f, 0.08146615f, 0.09728279f, 0.24071409f, 0.29602602f, -0.17093492f, 
    -0.18312171f, 0.05853805f, -0.00814593f, -0.12205223f, -0.04449281f, 0.09832631f, 0.03793890f, 0.02259932f, 
    0.12999736f, -0.13943736f, 0.14380600f, 0.04437105f, 0.06945724f, -0.14604390f, 0.12126902f, 0.00287737f, 
    0.17510574f, -0.05848994f, -0.02651985f, 0.05971591f, 0.05073591f, 0.16440488f, 0.16630833f, 0.07816703f, 
    0.01789447f, -0.11059877f, 0.02925471f, 0.00157575f, -0.04064530f, 0.01075391f, 0.09054385f, -0.03148698f, 
    0.25591165f, 0.14099094f, -0.09706742f, 0.02541260f, -0.04738690f, -0.00596234f, -0.01344632f, -0.00337934f, 
    0.06827296f, -0.03036197f, 0.14670895f, 0.00693065f, 0.19065274f, 0.07124213f, 0.18319595f, 0.13678811f, 
    -0.06284159f, -0.24525738f, 0.17566288f, 0.25187743f, -0.02069524f, -0.07909866f, 0.00242291f, -0.12839831f, 
    0.07537521f, 0.02992115f, 0.27247211f, 0.33933407f, 0.15998711f, -0.05553306f, 0.13288403f, 0.00233099f, 
    0.06339145f, 0.07491697f, 0.19837148f, 0.03323891f, -0.01521979f, -0.18510866f, -0.41644344f, -0.04326142f, 
    0.20240945f, -0.01429436f, 0.02982873f, 0.04022337f, 0.05278816f, 0.08856294f, 0.16911733f, -0.03409927f, 
    -0.18585606f, 0.17938162f, 0.17899987f, 0.13023525f, -0.13585551f, -0.05850117f, 0.01478751f, 0.12087294f, 
    -0.05074671f, 0.06255750f, 0.05293769f, 0.08242141f, 0.04543279f, -0.21085925f, 0.11489940f, -0.09923030f, 
    0.08023193f, 0.02777502f, -0.02359707f, 0.01720439f, 0.12394950f, 0.12351247f, 0.01231734f, 0.02112393f, 
    0.17203332f, 0.15999222f, 0.01050741f, 0.17817228f, 0.11234953f, 0.03083839f, -0.01380407f, 0.10961439f, 
    -0.07122153f, -0.01260342f, -0.04303230f, 0.03272260f, 0.11349202f, -0.16280502f, 0.03313185f, 0.23416716f, 
    0.04187924f, 0.05807529f, 0.00783458f, -0.16608818f, 0.02482408f, -0.05285533f, 0.07167106f, -0.22871605f, 
    0.50908953f, 0.24535358f, -0.08781162f, 0.06424071f, 0.18608443f, 0.12715633f, -0.08727496f, 0.05644104f, 
    0.02509406f, 0.07116719f, -0.06079171f, -0.03887950f, -0.16226727f, -0.02248586f, -0.13452730f, -0.06545540f, 
    -0.05316013f, 0.00861190f, -0.03793591f, -0.02750900f, -0.16479750f, 0.07514697f, 0.20927958f, -0.06979962f, 
    -0.11636758f, -0.09126468f, 0.04456928f, -0.11536624f, -0.00004945f, 0.00983661f, -0.01037777f, 0.05512148f, 
    -0.04607822f, 0.01838919f, -0.03677886f, 0.06714289f, -0.56850380f, -0.21666563f, 0.04129037f, -0.18969814f, 
    -0.04322831f, 0.16469078f, 0.05063060f, 0.01958859f, 0.05315063f, 0.06958779f, 0.00309095f, 0.05143749f, 
    -0.47741896f, -0.10031942f, 0.03568700f, 0.11225717f, 0.09995643f, -0.04692702f, 0.00258176f, -0.09951873f, 
    -0.01269852f, 0.05034938f, -0.03730088f, 0.09367696f, 0.18684186f, 0.16007084f, 0.26937899f, 0.09608484f, 
    0.06732349f, -0.02331246f, -0.06198116f, -0.13648282f, -0.04112555f, 0.08170857f, 0.08715144f, 0.01932882f, 
    0.17200083f, 0.13502465f, 0.05045732f, 0.12245850f, 0.06333614f, -0.08575816f, 0.19688013f, 0.09889459f, 
    0.11373945f, -0.05026023f, -0.09819610f, 0.03056011f, 0.29062206f, 0.03806505f, 0.02040564f, -0.15346605f, 
    0.02666959f, -0.12816015f, 0.06185263f, 0.01284645f, -0.02103821f, -0.02104008f, 0.10821152f, -0.09844938f, 
    0.36964896f, 0.08265865f, -0.06235614f, 0.14672326f, 0.00055902f, -0.05176412f, 0.01767228f, -0.05665207f, 
    0.07194986f, -0.11891456f, 0.05971394f, -0.09445598f, 0.01022213f, 0.17721862f, 0.06318504f, 0.17057976f, 
    0.06687439f, -0.14211756f, 0.18960133f, 0.19143568f, 0.02563574f, -0.01312718f, -0.06214481f, 0.00457831f, 
    0.11404407f, 0.08230865f, 0.15766691f, 0.07240288f, 0.09159210f, -0.02751024f, 0.11132140f, 0.07307908f, 
    0.04886809f, -0.18930273f, 0.12860289f, -0.06678524f, -0.18670754f, -0.03399379f, -0.19875556f, -0.46526799f, 
    0.14172287f, -0.05611172f, 0.07016146f, -0.07715277f, 0.11268957f, 0.11285868f, 0.02036667f, 0.10707297f, 
    -0.07968323f, 0.16247191f, 0.18993033f, 0.16288674f, -0.09842555f, 0.11147683f, 0.06334685f, 0.03254310f, 
    -0.01786500f, 0.03806607f, 0.12746839f, 0.02530234f, -0.26464635f, -0.07427902f, 0.18273640f, 0.04944711f, 
    0.00151937f, 0.05965514f, 0.01210822f, -0.00503367f, -0.05691434f, 0.08383190f, 0.01079115f, 0.10464664f, 
    -0.05541323f, -0.05566089f, -0.03446879f, 0.23334680f, 0.20832352f, 0.05071449f, 0.01160972f, 0.10507763f, 
    0.03700873f, -0.02002973f, 0.19919442f, 0.03846738f, 0.17193997f, -0.02058052f, 0.12846646f, 0.14875336f, 
    -0.09004954f, 0.03879198f, 0.10774035f, -0.02145841f, -0.16436568f, -0.00985312f, 0.06152669f, 0.14513631f, 
    -0.27940819f, -0.18331274f, -0.04792734f, 0.15657702f, -0.08558255f, -0.12965663f, 0.11778781f, -0.03312257f, 
    -0.05353253f, -0.10623246f, -0.11645032f, 0.03071778f, 0.02545888f, -0.14051497f, 0.05416325f, -0.08669709f, 
    -0.10513772f, 0.19183826f, 0.02113376f, -0.08026125f, 0.09414231f, 0.07988632f, 0.03282957f, 0.05582815f, 
    0.25127104f, 0.01190964f, 0.00032517f, -0.22454491f, -0.08101519f, 0.06726798f, 0.08741933f, 0.12660134f, 
    -0.03471182f, -0.04883464f, -0.07331186f, -0.06097958f, 0.08539489f, 0.03774028f, 0.27121308f, -0.03682878f, 
    -0.05252139f, 0.03529241f, 0.02775249f, 0.00219894f, 0.02316155f, -0.12258860f, -0.06032316f, 0.00839508f, 
    -0.29311153f, -0.03247118f, 0.31072059f, -0.07787278f, -0.06201302f, -0.04740802f, 0.27325255f, -0.19131824f, 
    0.01309391f, -0.10677322f, -0.00068024f, -0.04194684f, 0.13283388f, -0.22478114f, -0.08806881f, 0.13507241f, 
    0.00000589f, 0.01278193f, 0.07011231f, 0.11527744f, 0.14955008f, 0.07528798f, -0.06720017f, -0.07561782f, 
    -0.20472397f, 0.16324842f, 0.09314249f, 0.12328202f, 0.06147834f, 0.14829329f, 0.05073046f, -0.06077953f, 
    0.08842038f, 0.16102934f, 0.00671379f, -0.09360601f, -0.01961730f, 0.05949931f, -0.07076357f, -0.25277516f, 
    0.02265947f, 0.02633960f, 0.01243108f, -0.07788958f, 0.10690958f, -0.08057271f, 0.12286351f, 0.06553342f, 
    -0.06669048f, -0.03549128f, 0.01171990f, 0.20294137f, -0.03634941f, -0.01607418f, -0.00581234f, 0.07540540f, 
    -0.18716846f, -0.02480705f, 0.09382179f, 0.07262150f, 0.12821677f, -0.12451167f, -0.00965299f, 0.08350867f, 
    0.17134373f, 0.21370384f, 0.01049140f, -0.06798369f, -0.01884232f, 0.02143053f, 0.16956945f, -0.08725897f, 
    -0.10354181f, 0.11042268f, -0.02955277f, -0.32161677f, 0.10284741f, 0.04358787f, -0.01746449f, 0.01549129f, 
    -0.03406877f, 0.06317554f, 0.05992214f, 0.15195780f, 0.04574240f, 0.30285874f, 0.07882266f, -0.31146130f, 
    0.04349590f, 0.06431133f, 0.00042855f, -0.12454461f, 0.14516483f, -0.04621363f, -0.14988738f, 0.07718214f, 
    0.04981454f, -0.01147770f, -0.14222018f, 0.03347355f, 0.17243208f, 0.05593239f, 0.03395700f, -0.00574862f, 
    0.14302807f, -0.02871397f, -0.10673053f, -0.14495254f, -0.09667618f, 0.17387871f, 0.18894166f, -0.08120190f, 
    0.03854737f, 0.04845085f, -0.05825029f, -0.02180071f, -0.00352045f, 0.04673507f, 0.01328405f, -0.03654879f, 
    -0.02859889f, -0.06351993f, -0.05796768f, 0.06254073f, 0.01738179f, -0.02506714f, -0.05554529f, 0.03124210f, 
    -0.02352504f, 0.01985101f, -0.03133817f, -0.05742188f, -0.04566469f, -0.00951907f, -0.04876670f, -0.04532214f, 
    0.06746309f, 0.04077280f, 0.03813507f, -0.04183336f, -0.01411952f, 0.03902329f, 0.00312675f, -0.05393953f, 
    0.05415852f, -0.04604424f, -0.00195516f, -0.07276703f, 0.07453541f, 0.00951257f, -0.02961167f, -0.05993860f, 
    -0.01717818f, 0.01392105f, -0.06483629f, -0.05977242f, 0.00505198f, 0.00885272f, 0.02242034f, -0.01298593f, 
    0.04282886f, -0.02375045f, 0.04229213f, 0.05384836f, -0.02216745f, 0.05215294f, -0.04140904f, -0.04253015f, 
    -0.06147788f, -0.05343946f, -0.00983564f, -0.05757759f, -0.06666797f, 0.06235648f, -0.03168309f, -0.06820099f, 
    0.02631699f, 0.04953136f, 0.01082790f, -0.06062020f, 0.01465797f, -0.02843149f, -0.00778093f, -0.00372835f, 
    -0.07191969f, 0.06091579f, -0.03864165f, -0.06914383f, 0.06604777f, 0.03589092f, -0.04370128f, -0.00740747f, 
    -0.07136468f, -0.01913775f, -0.04546493f, 0.06340878f, -0.05745055f, -0.00018281f, -0.03149628f, -0.07236379f, 
    0.01821053f, -0.07167364f, 0.00922216f, -0.02237988f, -0.02063484f, 0.04526790f, 0.03813318f, -0.05280706f, 
    -0.00735911f, -0.04158118f, -0.05854916f, 0.01779645f, 0.05653103f, 0.02003252f, 0.00046001f, -0.04058827f, 
    0.00533056f, -0.07395955f, 0.01408921f, 0.05156716f, -0.06495766f, -0.05580088f, -0.01948780f, 0.02376129f, 
    -0.03715414f, 0.01104594f, -0.00588009f, -0.02760292f, -0.01082411f, 0.05957987f, 0.03691871f, 0.00928049f, 
    0.06091571f, -0.05381358f, 0.05457931f, -0.06357130f, -0.01604868f, 0.03601163f, 0.02294696f, -0.04683464f, 
    0.00828365f, -0.00171708f, -0.05017904f, -0.02569603f, -0.01125867f, -0.00812852f, -0.00027228f, 0.04412755f, 
    -0.04264865f, -0.01590360f, -0.04024557f, -0.04535144f, -0.00611397f, -0.05365957f, -0.04377297f, 0.01662245f, 
    0.02069946f, -0.03242865f, 0.02995455f, -0.05024243f, 0.05382955f, -0.04933099f, 0.04892911f, 0.02441207f, 
    -0.02115867f, 0.01972160f, -0.07486576f, -0.03673634f, 0.03122707f, 0.00068863f, 0.05569818f, 0.03497891f, 
    -0.02148620f, 0.04383886f, -0.01551284f, 0.02046832f, -0.04310036f, -0.02566839f, -0.02297820f, -0.01342188f, 
    0.00085575f, 0.04685564f, -0.00771816f, 0.02040333f, 0.01167694f, -0.08036760f, 0.06459003f, -0.05333019f, 
    -0.00217650f, -0.06781403f, -0.07950462f, -0.02478091f, 0.02068646f, 0.01861651f, 0.00014430f, -0.04890483f, 
    -0.04096246f, -0.07189585f, 0.02888774f, -0.03071921f, -0.04459208f, 0.00219566f, -0.01124979f, 0.03042177f, 
    0.04631197f, 0.04957527f, 0.00310705f, 0.06476384f, -0.04001145f, 0.04249344f, -0.00678258f, -0.02838676f, 
    -0.01580741f, -0.03825945f, -0.03956906f, -0.05961971f, -0.04992184f, -0.05317385f, 0.04917296f, 0.06166238f, 
    0.05976810f, -0.07208738f, 0.02518782f, -0.06306940f, 0.00428306f, -0.02466923f, 0.00262184f, 0.05543423f, 
    -0.00487108f, 0.04131496f, 0.00929426f, -0.02098759f, -0.05229932f, 0.02880942f, 0.05708404f, 0.02347908f, 
    0.05885193f, -0.02192344f, 0.05540883f, -0.03328818f, -0.00216451f, 0.06149839f, 0.00282455f, -0.05141775f, 
    -0.00832488f, -0.02364190f, -0.01852166f, 0.03409838f, -0.07130502f, -0.02990728f, -0.06954751f, 0.03705783f, 
    -0.03820049f, -0.03029024f, 0.01964182f, -0.03995338f, -0.02948412f, -0.01639210f, 0.04600649f, -0.06611309f, 
    -0.02096813f, 0.03362533f, -0.05398765f, 0.01886043f, -0.04598267f, -0.00018732f, -0.05804227f, 0.01340144f, 
    -0.05373703f, 0.01684208f, -0.06644046f, 0.01995123f, -0.01379428f, -0.03047781f, -0.00142940f, -0.01276421f, 
    0.06269521f, 0.04600335f, -0.00895474f, -0.05306407f, 0.05997529f, -0.03459461f, 0.00298469f, -0.02490572f, 
    0.01120479f, 0.06464599f, -0.00134883f, 0.00484312f, -0.02985614f, -0.02804772f, -0.02906735f, -0.00698215f, 
    -0.00549693f, -0.05808543f, -0.02659429f, -0.01860923f, 0.06728570f, -0.02295258f, -0.03253374f, 0.05474143f, 
    0.04791297f, -0.01476984f, -0.07060501f, 0.01147864f, 0.07338026f, -0.03188523f, -0.03852748f, 0.00970896f, 
    -0.06571416f, 0.03786753f, -0.07165392f, -0.04688635f, -0.01860756f, 0.03161261f, -0.00629072f, -0.01293513f, 
    -0.02438749f, -0.03435471f, 0.00244998f, 0.02671021f, 0.01568384f, 0.06327631f, -0.04730267f, -0.04152174f, 
    -0.03387696f, 0.04546195f, -0.06565195f, 0.02885650f, 0.01779221f, -0.07634376f, -0.02145519f, 0.03858896f, 
    -0.03658566f, 0.04787191f, -0.01472752f, -0.01053591f, 0.04493415f, 0.05615855f, 0.01089106f, -0.01731709f, 
    -0.01266160f, -0.05134061f, 0.02234736f, 0.06102800f, 0.02548367f, -0.06180523f, 0.03648053f, 0.06201113f, 
    -0.03140787f, 0.03293916f, 0.02041422f, -0.03988875f, 0.02580230f, 0.06374852f, -0.04969717f, 0.01594585f, 
    0.00650212f, 0.01486596f, -0.02330710f, -0.04379119f, 0.05001776f, 0.03102392f, 0.03076786f, -0.00874062f, 
    -0.06462497f, -0.07300059f, -0.07179616f, 0.05826762f, -0.04999170f, 0.05571316f, 0.03341028f, 0.02614688f, 
    0.02013919f, 0.00164942f, -0.03093451f, -0.01980777f, -0.02654970f, -0.07051060f, -0.00951098f, -0.00980391f, 
    -0.05932552f, -0.01981549f, -0.06700128f, -0.05790602f, -0.06317383f, -0.00619072f, -0.06531735f, 0.06281009f, 
    -0.06191861f, -0.03800488f, -0.07606721f, 0.06663767f, 0.02461717f, 0.00450700f, -0.07405643f, -0.06077437f, 
    -0.01153511f, -0.04571022f, -0.05913325f, -0.00223870f, -0.00142078f, -0.03026820f, 0.01798701f, -0.03784963f, 
    0.03086256f, -0.12701382f, -0.16584502f, 0.07979123f, 0.02290000f, -0.03768606f, -0.00008193f, 0.02538138f, 
    0.02016460f, 0.07621244f, 0.01452990f, 0.09866002f, 0.27944624f, 0.15962259f, 0.04959507f, -0.10623551f, 
    0.12769161f, 0.06820776f, 0.04150128f, 0.16809887f, 0.05923666f, -0.07441913f, 0.04076142f, -0.02608759f, 
    -0.07186861f, -0.00367377f, 0.16656688f, 0.07839966f, -0.03250244f, 0.00768504f, -0.00545698f, -0.00189575f, 
    0.06677745f, 0.07475013f, 0.18016005f, -0.02890467f, 0.03575234f, -0.07187151f, -0.00833678f, -0.13386594f, 
    0.07152425f, 0.08581467f, -0.01552815f, 0.12213116f, -0.00464242f, -0.15984148f, -0.04062783f, -0.10398275f, 
    -0.31431919f, -0.08736864f, 0.20335265f, -0.19075985f, 0.08209177f, 0.08601300f, 0.07780681f, -0.05550183f, 
    0.10892381f, 0.12765521f, -0.01845446f, 0.08227034f, 0.05259329f, 0.10187354f, 0.08489405f, 0.25032482f, 
    -0.04982483f, 0.12779142f, 0.11123559f, 0.07311621f, 0.02679789f, 0.00230335f, 0.00032472f, -0.00831617f, 
    0.32641631f, -0.01634470f, 0.16725247f, 0.07204711f, 0.13728999f, 0.16825366f, 0.06440920f, 0.17086375f, 
    0.10065398f, -0.01641661f, 0.00683395f, 0.05037848f, -0.25877813f, -0.00568152f, 0.08697940f, 0.05701257f, 
    0.07318175f, 0.02262025f, 0.00923170f, -0.01222128f, -0.04011236f, -0.17813189f, 0.06364717f, 0.07837743f, 
    0.00263554f, -0.04412957f, -0.17149152f, -0.24073550f, -0.13831259f, -0.05538480f, 0.00285931f, 0.04149019f, 
    -0.01392003f, -0.14924461f, 0.06978696f, 0.01274989f, 0.14410590f, -0.08226779f, -0.01909685f, 0.19021358f, 
    0.03040572f, 0.02460343f, -0.06873260f, 0.08496279f, 0.06288133f, -0.14846593f, 0.02459803f, 0.00950640f, 
    -0.00639432f, 0.03667633f, 0.09348051f, 0.04326075f, 0.16451359f, 0.13336031f, -0.03071367f, -0.05045207f, 
    -0.09490786f, 0.03078393f, -0.02091539f, 0.00395581f, 0.27491015f, -0.14442597f, -0.20167340f, -0.34659195f, 
    -0.21192162f, -0.12997355f, 0.09132314f, 0.06785719f, 0.06406198f, 0.05169292f, -0.06650022f, 0.11475921f, 
    0.32549715f, -0.10653558f, -0.02393000f, 0.14769024f, 0.27816802f, 0.09529737f, -0.06276079f, 0.07387193f, 
    -0.06558878f, 0.00588759f, 0.18849005f, 0.04874543f, -0.63734806f, -0.00620733f, -0.10201129f, -0.42627391f, 
    -0.02772414f, 0.03143509f, -0.00545194f, 0.03639994f, 0.10596944f, -0.01537727f, 0.06123616f, -0.04870693f, 
    0.13986953f, -0.20882098f, -0.16593285f, -0.22940484f, -0.05006183f, -0.06550477f, 0.04886749f, -0.03905205f, 
    -0.09857332f, -0.11193632f, 0.09550156f, -0.01641413f, 0.12490814f, 0.26080588f, -0.19452208f, 0.04166951f, 
    0.07593139f, 0.07803517f, -0.06989544f, 0.13400374f, -0.13391396f, 0.05662138f, 0.15062182f, 0.02488023f, 
    -0.20064802f, 0.04182014f, -0.02231023f, -0.10301902f, -0.04553971f, 0.02148606f, -0.10264689f, -0.02845776f, 
    -0.19606848f, -0.04231459f, 0.11546086f, 0.01164535f, -0.04658936f, 0.24804522f, -0.13580400f, 0.22448558f, 
    0.12204885f, 0.11136721f, 0.06161192f, 0.00464227f, -0.01534775f, -0.02529550f, -0.02151744f, 0.18051168f, 
    0.71268994f, 0.02791367f, 0.01723521f, -0.03750579f, -0.02250934f, 0.00782074f, -0.03100452f, -0.09488734f, 
    -0.07480506f, 0.14548388f, 0.04763971f, -0.09191289f, 0.06671921f, 0.00782960f, 0.15137336f, 0.08809901f, 
    -0.05705371f, -0.07375971f, 0.08963320f, 0.00981180f, -0.05445286f, 0.17043710f, 0.04212683f, 0.02244286f, 
    0.05845664f, 0.19295247f, -0.13612469f, 0.04581095f, 0.11910514f, 0.13290125f, -0.00858247f, -0.10810283f, 
    -0.04837277f, 0.02744139f, 0.28421086f, 0.02051016f, -0.41085258f, 0.28326014f, -0.21833503f, 0.14661902f, 
    0.03287714f, 0.05310369f, -0.04217308f, 0.06551284f, 0.14141747f, 0.03540817f, 0.05885008f, -0.03481686f, 
    0.09485117f, 0.11874193f, -0.29251796f, 0.30557582f, 0.11645684f, 0.03729417f, -0.05407419f, -0.00578230f, 
    0.15785432f, 0.02054468f, 0.00172790f, 0.15861443f, 0.01733267f, -0.03761886f, -0.00460975f, -0.02753842f, 
    0.07982818f, -0.16403542f, -0.00117021f, -0.07338852f, -0.11039221f, 0.09940249f, -0.06985353f, 0.04825605f, 
    0.50136924f, -0.01102215f, -0.01065382f, -0.06409218f, 0.00373623f, -0.15163431f, -0.10621569f, -0.01995108f, 
    0.14766815f, 0.00331898f, 0.08641263f, -0.00422766f, -0.16456442f, -0.30163020f, 0.33554432f, -0.07755937f, 
    -0.04736093f, 0.05019772f, 0.00202038f, 0.12868959f, -0.00239009f, -0.04874951f, 0.01449792f, 0.08593529f, 
    0.03329403f, -0.04548694f, -0.13747939f, 0.08030538f, -0.12605982f, 0.13317896f, -0.01145163f, -0.00071727f, 
    -0.06618772f, -0.06873930f, -0.09554376f, 0.09780362f, -0.10964593f, 0.14575885f, -0.13088951f, 0.06301618f, 
    -0.27547339f, -0.07650095f, -0.02923779f, -0.23247647f, -0.06700131f, -0.08833322f, -0.07803763f, 0.02375721f, 
    0.21789838f, -0.31555128f, 0.06974214f, -0.11759294f, -0.20000365f, 0.04444206f, 0.01364752f, 0.08183073f, 
    0.15810849f, -0.11850483f, -0.10792458f, -0.02544345f, -0.03529073f, 0.03300236f, 0.28583440f, -0.21361014f, 
    0.15946248f, -0.09684654f, 0.02526154f, 0.01237498f, 0.04569080f, 0.18709536f, 0.07842182f, 0.14918230f, 
    0.10657124f, 0.03270556f, 0.16868980f, 0.00209429f, -0.18867259f, 0.05919383f, -0.06116849f, 0.04997488f, 
    -0.03413207f, -0.21220733f, 0.00349909f, -0.16474248f, -0.17961973f, 0.01928540f, 0.06970236f, -0.04377934f, 
    0.19442803f, -0.04451542f, -0.12358049f, -0.02849682f, -0.03523064f, 0.13410212f, 0.10523181f, 0.09081910f, 
    0.46519548f, 0.32210529f, 0.04873144f, 0.17070046f, 0.00040026f, 0.10127744f, 0.15609656f, -0.13899007f, 
    -0.06505588f, -0.11341225f, -0.06852130f, 0.14420149f, 0.19464082f, -0.04766311f, -0.14705302f, 0.12754418f, 
    0.05128324f, -0.02312303f, 0.04310739f, 0.06441759f, -0.06035984f, -0.07859602f, -0.05945048f, -0.02946664f, 
    -0.37723452f, 0.19096288f, 0.33329087f, 0.39112118f, 0.06408317f, -0.00660854f, 0.08593041f, 0.18283446f, 
    0.03126089f, 0.04633844f, -0.04889871f, -0.04113426f, -0.03291054f, -0.24189879f, -0.00874903f, -0.15863411f, 
    -0.01287836f, -0.00601188f, -0.03979572f, 0.02813884f, 0.01793547f, -0.20758921f, -0.04879801f, 0.05865501f, 
    -0.39547732f, -0.29813999f, -0.17164393f, -0.12039725f, -0.03865490f, -0.13213837f, 0.01969586f, 0.06112396f, 
    0.00143240f, -0.09797627f, -0.07383959f, -0.01006533f, 0.15834433f, -0.23534539f, -0.14758885f, -0.28186044f, 
    -0.16525261f, -0.00234317f, 0.02908277f, 0.06089583f, -0.00891681f, -0.05608682f, -0.02410811f, 0.01387337f, 
    0.25506276f, -0.12387086f, -0.31972918f, 0.29141569f, 0.04202574f, -0.17533590f, -0.09148978f, -0.05110952f, 
    -0.05686387f, -0.01087919f, 0.03733034f, 0.00437777f, 0.34232455f, 0.19877835f, -0.04239366f, 0.21664448f, 
    -0.09981740f, 0.24032663f, 0.02313857f, -0.07307559f, -0.26061809f, 0.05338986f, 0.00943112f, -0.06474317f, 
    0.33909926f, 0.24169882f, 0.03263929f, 0.54524714f, -0.02490889f, 0.06589966f, 0.15720329f, 0.07122280f, 
    -0.02867126f, 0.02087445f, 0.02122985f, -0.02154317f, 0.10485740f, 0.21570633f, 0.14040397f, 0.15854083f, 
    -0.19528101f, -0.15856393f, 0.16583744f, -0.10130616f, -0.19641303f, 0.03946068f, -0.05944252f, -0.08343655f, 
    0.50772846f, 0.02666382f, 0.07937611f, 0.32374260f, -0.03697665f, -0.09722858f, -0.07823122f, -0.13822316f, 
    -0.05052674f, 0.12699562f, -0.05726866f, -0.09976052f, 0.08663844f, 0.37686178f, 0.16893177f, 0.09667010f, 
    -0.08915911f, -0.00541814f, 0.26270276f, 0.18070659f, 0.03584221f, 0.03927949f, 0.03777143f, -0.00019638f, 
    0.17718336f, 0.28907427f, -0.20533638f, 0.26336265f, 0.18905452f, -0.09117666f, -0.04455784f, -0.05221683f, 
    0.01467072f, -0.00468408f, 0.01520500f, -0.02140931f, -0.38844556f, -0.36468783f, -0.23278904f, -0.26335254f, 
    -0.07011813f, -0.00306167f, -0.02299854f, -0.10484529f, 0.09456455f, -0.09643170f, 0.04563856f, -0.14281452f, 
    0.07524177f, 0.54686528f, 0.16634604f, 0.09047837f, 0.12477593f, -0.10641140f, 0.05702046f, 0.15639445f, 
    0.08679783f, -0.02261699f, -0.01825053f, -0.03817035f, 0.21863499f, -0.08857021f, -0.15264235f, 0.06483166f, 
    -0.03558010f, 0.12133893f, -0.01158854f, -0.08471686f, 0.04908784f, 0.04924978f, -0.06420565f, -0.03322398f, 
    0.11482418f, 0.11085752f, 0.03086941f, 0.21401745f, 0.28240019f, -0.01297508f, 0.04313212f, 0.10206617f, 
    0.06501111f, 0.02689669f, 0.09764062f, 0.00275488f, 0.13383709f, -0.20591122f, 0.25481561f, 0.15456600f, 
    -0.06869294f, -0.02702511f, -0.00906458f, 0.01768713f, -0.05333462f, -0.09899768f, 0.02975638f, -0.06424617f, 
    0.44873857f, 0.29075214f, -0.00177145f, 0.08589631f, 0.07581365f, 0.07299472f, 0.00332736f, 0.03593032f, 
    0.01889608f, -0.03335782f, 0.02542586f, -0.06305423f, -0.27667391f, -0.09069800f, -0.06072896f, -0.12956764f, 
    -0.06793199f, -0.02948860f, -0.01960058f, 0.04018573f, -0.12010631f, 0.07143757f, 0.13856231f, -0.04383767f, 
    -0.23948120f, -0.25020143f, 0.12058077f, -0.12984221f, -0.12899268f, 0.05355532f, 0.02052650f, 0.09196581f, 
    0.03732934f, 0.04496669f, -0.13540953f, 0.09910500f, -0.53909367f, -0.27404422f, 0.18768780f, 0.00147390f, 
    0.01914590f, 0.19008373f, 0.00223803f, 0.04310118f, 0.07119925f, -0.01103288f, 0.01737510f, -0.02644952f, 
    -0.54004478f, -0.03501513f, 0.27255604f, 0.11965024f, -0.07420399f, 0.12249303f, 0.04256437f, 0.01185693f, 
    -0.05337526f, -0.05416610f, 0.01869579f, 0.08381514f, 0.01865500f, 0.08028572f, 0.40241429f, 0.02229030f, 
    0.19542557f, 0.02987718f, 0.08200624f, -0.01983877f, -0.02113477f, 0.07394492f, 0.04431023f, 0.10029527f, 
    -0.02513207f, 0.13916680f, 0.04360195f, 0.02356516f, 0.07473309f, 0.01089523f, 0.14148559f, 0.08872183f, 
    0.19799405f, -0.02584412f, 0.06143624f, 0.11933906f, -0.03102630f, 0.14722465f, -0.08323076f, -0.11818743f, 
    -0.08413901f, -0.08243510f, 0.12743816f, 0.01539478f, 0.05096512f, -0.13525631f, 0.06909458f, -0.07270840f, 
    0.34943902f, 0.14232001f, 0.06028970f, 0.16511188f, 0.04707102f, -0.02109855f, 0.04353039f, 0.01602803f, 
    -0.07476514f, -0.14480913f, 0.02850674f, 0.03455989f, -0.00538973f, 0.22159383f, -0.12825762f, 0.11403736f, 
    0.09705134f, -0.12315051f, 0.24488635f, 0.02423179f, 0.02529561f, 0.06859414f, -0.00602072f, -0.03244603f, 
    0.12197920f, 0.15834828f, 0.09463295f, 0.03775239f, -0.06733837f, -0.05508312f, 0.06544972f, -0.03497451f, 
    0.09431355f, -0.13923603f, 0.13535477f, 0.00095514f, -0.19822951f, 0.01062191f, -0.19095220f, -0.35754028f, 
    -0.08767533f, 0.00557920f, 0.02384524f, -0.05297616f, 0.02818264f, -0.03403148f, -0.01666167f, 0.07226440f, 
    -0.04699661f, 0.26645398f, 0.10806924f, 0.03133700f, 0.01907499f, 0.08104533f, 0.04321500f, 0.01616997f, 
    0.00894479f, 0.02304846f, 0.11388484f, 0.02901250f, -0.18600760f, -0.05636403f, 0.04948105f, 0.15736525f, 
    -0.05272974f, 0.11690896f, 0.03532184f, -0.10060859f, -0.13741080f, 0.03324896f, -0.10534412f, 0.08433671f, 
    0.15050860f, 0.03410188f, -0.02877686f, -0.08880776f, 0.03396786f, -0.09124012f, 0.06412348f, 0.05722242f, 
    -0.15986967f, -0.10232320f, -0.09480111f, -0.04233286f, -0.18309803f, 0.12049945f, -0.01451465f, -0.22852220f, 
    0.21889025f, 0.17766064f, -0.03297744f, 0.03240029f, 0.07730034f, 0.08090156f, 0.00193736f, -0.32434908f, 
    0.23052654f, 0.09694847f, 0.08854728f, 0.00242807f, -0.00373077f, 0.09712250f, 0.05236474f, 0.07996628f, 
    0.09712972f, 0.04047013f, 0.02301006f, -0.02227466f, 0.07728668f, -0.01115911f, 0.07623624f, 0.03495144f, 
    0.17569417f, -0.10827708f, -0.10272427f, 0.00163670f, -0.10923156f, -0.14719212f, -0.04277913f, -0.34917974f, 
    -0.05981117f, 0.00449160f, -0.04135454f, 0.08772836f, 0.03531527f, -0.12148187f, 0.01531243f, 0.08383510f, 
    0.07685540f, 0.12418987f, -0.11672908f, 0.16511652f, 0.29284221f, -0.09676880f, 0.04229542f, 0.11106514f, 
    0.00672627f, 0.17487356f, -0.03273011f, -0.06843952f, 0.10554951f, 0.12308942f, 0.02187149f, 0.07404049f, 
    0.22145464f, 0.14808708f, -0.13731776f, 0.16425622f, 0.12482446f, 0.17994386f, -0.10823662f, 0.11369933f, 
    0.08759449f, -0.02137914f, -0.00960376f, 0.06094651f, -0.02717012f, 0.16153741f, 0.11089368f, 0.13427605f, 
    0.00789518f, -0.03165009f, 0.11597835f, -0.12555584f, -0.08660434f, 0.03381211f, -0.00421967f, 0.17805810f, 
    0.01326720f, -0.13682368f, -0.04605659f, -0.13918164f, 0.03227442f, -0.12377931f, 0.02724500f, 0.05792282f, 
    -0.00698278f, -0.08849740f, -0.11671067f, 0.11099606f, 0.08457915f, -0.11346302f, -0.16343118f, 0.33663651f, 
    -0.04778205f, -0.23368113f, 0.01260621f, 0.04082655f, -0.02807797f, 0.00113073f, -0.02238522f, -0.02574225f, 
    0.18880814f, -0.08431159f, -0.28278711f, -0.07466421f, 0.06860309f, -0.06581190f, 0.09987064f, 0.00791265f, 
    0.02661638f, -0.14925227f, 0.01379446f, -0.09869003f, -0.40232587f, -0.32060909f, 0.04302942f, 0.06117446f, 
    -0.12677349f, -0.09459319f, 0.08343505f, 0.24818504f, 0.01331082f, 0.10168503f, 0.05113642f, 0.09776377f, 
    -0.16456766f, 0.37417337f, -0.13145672f, 0.17709143f, -0.06957057f, 0.06380825f, -0.02565447f, -0.01779757f, 
    0.12141849f, 0.02735620f, 0.13952993f, -0.00841211f, -0.27900112f, 0.20156313f, -0.17855386f, -0.16470753f, 
    0.14133614f, 0.07351094f, 0.02237881f, 0.02597473f, 0.01678738f, 0.00964357f, 0.28923512f, 0.10794356f, 
    -0.36177403f, -0.33746499f, 0.03580107f, 0.04675136f, -0.14687826f, 0.01417094f, 0.01326313f, -0.07793510f, 
    -0.12694286f, 0.04888031f, 0.07417222f, 0.14466669f, 0.19055535f, 0.01108277f, 0.22532310f, -0.18225729f, 
    0.09070669f, 0.23891008f, 0.07904841f, 0.02559698f, 0.09855176f, 0.10242391f, 0.04363159f, 0.21762089f, 
    0.01979727f, 0.02085196f, -0.09030498f, -0.05100190f, -0.14701831f, -0.07196674f, -0.04252290f, -0.09023845f, 
    -0.03377797f, 0.09392516f, 0.08328863f, 0.01268943f, 0.01659876f, 0.19914360f, -0.25971538f, 0.16950087f, 
    0.14754075f, 0.11243174f, 0.08244190f, 0.03773734f, -0.03480281f, 0.10769724f, -0.05912260f, 0.17485186f, 
    -0.25138432f, -0.15185994f, -0.04383484f, 0.02528677f, -0.04808350f, 0.09093266f, 0.02076495f, 0.00840017f, 
    -0.04860239f, 0.03961607f, -0.02194502f, -0.10758977f, 0.22968534f, 0.05335246f, 0.07148135f, 0.05819597f, 
    -0.07692765f, -0.03418345f, 0.03812318f, -0.02935829f, 0.09013562f, -0.00762146f, 0.03349140f, 0.04450573f, 
    0.08313679f, 0.23734643f, 0.02993159f, -0.00584261f, 0.18609203f, -0.00689740f, 0.02772568f, 0.01164668f, 
    -0.01912651f, 0.05706387f, 0.18126160f, 0.02345189f, -0.25736788f, 0.34377128f, -0.10690459f, 0.21876697f, 
    -0.10879685f, 0.06227627f, 0.12818867f, 0.07874334f, -0.06838584f, 0.00876273f, -0.03857086f, -0.05179928f, 
    0.30745456f, -0.13822138f, -0.20486726f, 0.16914567f, 0.16772133f, -0.13784018f, -0.00042177f, -0.01257163f, 
    0.08898770f, 0.12532704f, -0.00045797f, -0.02350950f, 0.10845922f, 0.06469849f, -0.39868370f, -0.04510567f, 
    -0.01273512f, -0.02392919f, 0.08802468f, 0.14154992f, 0.00694882f, -0.01281054f, -0.06017357f, -0.03525360f, 
    0.38259691f, -0.04121710f, -0.16884826f, 0.14023657f, -0.09333394f, 0.02304866f, -0.10288733f, 0.15742348f, 
    -0.07610852f, 0.02782769f, 0.00937845f, -0.08389530f, 0.27936226f, -0.23219575f, 0.12358543f, -0.06088800f, 
    -0.00102488f, 0.09270428f, -0.06623071f, 0.13616347f, -0.10219528f, 0.07324645f, 0.02241151f, 0.12645523f, 
    -0.08341847f, -0.08156903f, -0.02668611f, 0.18511108f, 0.13704965f, 0.11049111f, -0.01848348f, 0.04521026f, 
    0.00966814f, 0.31781104f, -0.13468212f, -0.00987208f, 0.05507386f, -0.21289583f, 0.04930849f, -0.09611148f, 
    -0.05210843f, 0.00400492f, -0.12755956f, -0.02665239f, -0.15861253f, -0.08944540f, -0.09176714f, -0.08068951f, 
    0.13737077f, -0.29759064f, -0.06381773f, -0.17204744f, 0.04431206f, 0.07084133f, -0.23080404f, 0.03280630f, 
    0.09117432f, 0.04277264f, -0.17675777f, -0.02639503f, -0.04997583f, -0.06623589f, 0.20695136f, -0.26629695f, 
    0.07443728f, 0.06583992f, 0.03714534f, 0.05183405f, 0.02889196f, 0.05604945f, -0.07604594f, 0.04368503f, 
    0.30737868f, -0.27814648f, -0.09733781f, -0.01899085f, -0.06635960f, -0.00240309f, 0.08057559f, 0.03739697f, 
    0.07829975f, -0.09217016f, -0.00109260f, -0.13814454f, 0.01118393f, 0.23421840f, 0.05231233f, 0.01282747f, 
    0.14018305f, 0.06554043f, 0.05054112f, 0.06932519f, 0.11860809f, -0.01759491f, 0.06310389f, 0.07930133f, 
    0.35397658f, 0.12951189f, 0.08478560f, 0.30622008f, -0.11908429f, -0.06975167f, 0.14417684f, 0.00243718f, 
    -0.09367669f, -0.14147377f, -0.26902741f, -0.04735909f, -0.04741982f, -0.05624810f, 0.17528324f, 0.06955376f, 
    -0.03065943f, -0.13700411f, -0.21166380f, -0.07548511f, 0.20948434f, -0.00922864f, 0.11958217f, -0.31725445f, 
    0.23521766f, 0.40791753f, 0.05453800f, -0.20528384f, 0.03369381f, 0.12275051f, 0.01237109f, 0.21446168f, 
    -0.00521862f, -0.02206711f, 0.17803425f, 0.04104225f, -0.00725052f, 0.05077173f, 0.01023658f, -0.02291093f, 
    0.05700723f, -0.06551716f, -0.11837558f, 0.00440716f, -0.17841057f, -0.23383658f, -0.07920699f, -0.02371759f, 
    -0.17145339f, -0.07743739f, -0.22739385f, 0.01066425f, -0.06452230f, -0.07182252f, -0.19960041f, -0.06875502f, 
    -0.01515093f, 0.23586577f, -0.06837147f, 0.05691716f, 0.19086652f, -0.18912198f, -0.24794784f, -0.26140967f, 
    0.00819369f, -0.14442055f, -0.10953980f, -0.07040417f, -0.11922528f, 0.13146740f, 0.14163029f, 0.11043269f, 
    0.22368431f, -0.11329788f, 0.10272021f, -0.12631407f, -0.11412748f, 0.00689607f, -0.01959121f, 0.04161001f, 
    0.04152190f, -0.02130382f, 0.08461682f, 0.24022976f, -0.04704458f, 0.24920526f, 0.29142529f, 0.04405288f, 
    -0.10069769f, 0.22998625f, -0.06153959f, -0.13772362f, -0.16583374f, -0.05412931f, 0.12084252f, -0.30813029f, 
    0.30985039f, 0.04492513f, 0.10141500f, 0.01294956f, -0.02201816f, -0.05542499f, 0.09660766f, 0.16971520f, 
    0.00773384f, -0.20085029f, -0.20007101f, 0.16987489f, 0.14378621f, 0.13921638f, -0.18862511f, -0.03638703f, 
    0.25382274f, 0.07548485f, 0.05193515f, 0.15162967f, -0.24872366f, 0.01288361f, -0.05197851f, -0.06281743f, 
    -0.04026916f, -0.11232150f, 0.04091765f, 0.12177966f, -0.12293198f, 0.00955829f, -0.03651052f, -0.02373708f, 
    0.12423646f, -0.15858456f, -0.01036221f, -0.16541252f, 0.02874378f, 0.09566463f, 0.04634805f, -0.33052438f, 
    0.17656972f, -0.06387752f, 0.16792044f, 0.24616911f, -0.02259923f, -0.00537300f, -0.02285869f, 0.08661856f, 
    0.07688428f, -0.10308184f, 0.14679186f, 0.21864226f, 0.18193924f, -0.20116717f, 0.14244132f, -0.08352930f, 
    0.08384062f, 0.10131404f, 0.13996491f, -0.06355450f, 0.20605411f, -0.16253121f, -0.27642503f, 0.20197463f, 
    -0.16419865f, -0.18431881f, -0.03605530f, -0.06599508f, 0.09554058f, 0.15426625f, 0.25832456f, 0.02547810f, 
    -0.22813690f, 0.03967354f, -0.03158541f, -0.17951250f, -0.04060407f, 0.02622962f, 0.16914876f, 0.05865078f, 
    -0.12391756f, 0.14183861f, 0.08853590f, 0.18440177f, 0.33700213f, -0.12078639f, -0.13490090f, 0.00069867f, 
    -0.06172233f, -0.06384303f, 0.09413988f, -0.12757751f, 0.10240439f, 0.07032363f, 0.22784314f, 0.17560345f, 
    -0.05234817f, -0.04718912f, 0.05144440f, 0.02736038f, -0.02589287f, -0.04017933f, -0.04892390f, -0.06757320f, 
    -0.07344423f, -0.02952618f, 0.02506950f, 0.01620780f, -0.04986167f, 0.00413825f, 0.03738393f, 0.03261802f, 
    -0.05233283f, -0.07200519f, 0.01252250f, -0.00734927f, -0.00621414f, -0.07077947f, -0.03226784f, 0.06660371f, 
    0.05108881f, -0.00826719f, 0.03741691f, -0.06009462f, 0.04016196f, -0.07057295f, -0.05418646f, -0.03527724f, 
    -0.00145974f, 0.06016412f, 0.02976689f, 0.01862891f, -0.03117113f, 0.03940801f, 0.05547896f, -0.05422655f, 
    -0.02847338f, -0.06089183f, -0.02857052f, 0.00434310f, 0.06201879f, -0.04454639f, -0.01494884f, 0.02139636f, 
    -0.04584523f, 0.05776582f, 0.05152743f, -0.06842612f, 0.03137263f, -0.06738851f, 0.00975135f, -0.04656313f, 
    0.00998588f, 0.06336227f, -0.01214773f, 0.02417129f, -0.05317972f, -0.06564587f, -0.05982368f, -0.05564937f, 
    0.03276796f, 0.01567563f, -0.04515813f, -0.03235518f, -0.06867059f, -0.02568586f, -0.07355390f, -0.01831927f, 
    0.00664192f, 0.06434286f, -0.00027966f, -0.00969233f, -0.02819209f, -0.00461310f, -0.01807427f, -0.06853454f, 
    -0.03644096f, 0.00258113f, 0.02943577f, 0.02017831f, 0.01444694f, 0.01182477f, -0.07469196f, -0.00204582f, 
    0.01632779f, -0.01332502f, -0.06866093f, 0.02974670f, -0.03693322f, 0.03742458f, 0.04591912f, -0.04025178f, 
    0.01850671f, 0.01704122f, 0.03959331f, -0.03657321f, 0.03316019f, 0.01574045f, -0.03295952f, -0.07142849f, 
    0.04318573f, -0.02358290f, -0.06704967f, -0.03511325f, -0.04147206f, 0.02645167f, 0.02529109f, -0.02982867f, 
    -0.04656601f, -0.02710732f, 0.05286845f, -0.04419531f, 0.02654152f, -0.01345227f, -0.05773562f, 0.02832862f, 
    -0.04346504f, 0.01420457f, 0.00009138f, 0.03400086f, 0.04828179f, -0.00335841f, 0.01991234f, 0.05454141f, 
    0.02474695f, 0.04332472f, 0.02833530f, -0.03567543f, -0.06009651f, -0.02948235f, -0.02108082f, -0.03198501f, 
    -0.01543863f, 0.02394242f, 0.06223413f, 0.03531827f, 0.00300639f, 0.04761747f, -0.02602694f, -0.07354846f, 
    0.03311542f, 0.00891179f, -0.04573090f, -0.01446722f, 0.07327373f, 0.01809301f, -0.06636250f, 0.04443570f, 
    -0.03969582f, -0.05036145f, 0.02597397f, -0.02618369f, 0.04324929f, -0.04430411f, -0.00471572f, 0.02242956f, 
    -0.07922589f, -0.03315916f, -0.05526190f, -0.00233236f, -0.00365466f, -0.03195693f, 0.05695763f, -0.07098184f, 
    -0.02135023f, 0.05246302f, -0.02524567f, 0.00926432f, -0.04256263f, 0.00906520f, -0.03960298f, 0.00355418f, 
    0.05431543f, 0.06814368f, -0.04029103f, -0.00917450f, -0.03955697f, 0.00758894f, 0.00047895f, 0.04191139f, 
    0.02677651f, -0.05200123f, -0.00869096f, 0.03919176f, -0.04679925f, 0.06288545f, -0.03035592f, 0.03366326f, 
    -0.17867392f, -0.06504645f, -0.20800772f, 0.05775055f, -0.11257668f, 0.11639971f, -0.08767989f, 0.02020276f, 
    -0.02986347f, -0.09639448f, 0.03650974f, -0.06338944f, 0.07872032f, 0.20833735f, -0.21849054f, -0.23799936f, 
    -0.13257171f, -0.01588797f, -0.01779970f, 0.12698126f, 0.12153142f, 0.00863375f, -0.05465965f, 0.16114944f, 
    0.20506224f, -0.34824780f, 0.05026652f, 0.21590270f, 0.03507834f, -0.10285015f, 0.09386685f, -0.08234467f, 
    -0.05600571f, 0.11488617f, 0.31038648f, -0.05983482f, 0.45036748f, -0.11309569f, -0.00168985f, 0.09329489f, 
    0.01930658f, 0.04549326f, 0.11314196f, -0.01849994f, 0.06005179f, 0.04352827f, -0.07928329f, -0.02442621f, 
    0.56618786f, 0.11820086f, -0.20569406f, -0.12692082f, 0.09277017f, -0.07330863f, 0.03521974f, -0.04279700f, 
    0.01053003f, 0.04816936f, 0.12700595f, -0.16836403f, 0.23644239f, 0.36543530f, 0.13151637f, 0.23130076f, 
    0.06412902f, 0.11834191f, -0.02121309f, 0.05334698f, -0.01912526f, -0.07459665f, -0.07485452f, 0.04784994f, 
    -0.04153195f, 0.23369181f, -0.12854706f, 0.16021420f, 0.01051227f, 0.08966484f, -0.02230725f, 0.03204842f, 
    0.13870867f, 0.07242002f, -0.08524536f, -0.01774865f, 0.13973886f, -0.33988976f, -0.17936236f, 0.29442292f, 
    0.09783322f, -0.07313477f, -0.04694334f, 0.13808343f, 0.02587991f, -0.02401024f, -0.03790823f, -0.03343485f, 
    0.03208818f, 0.02247725f, -0.01205841f, -0.26730528f, -0.07105925f, 0.02216429f, -0.03392187f, -0.12035199f, 
    0.07016444f, 0.03773800f, 0.08647890f, -0.17598291f, 0.04307854f, -0.29532877f, 0.20265095f, 0.10847238f, 
    0.09821968f, 0.15203179f, -0.01097149f, -0.10682132f, 0.07886427f, -0.03429553f, 0.09878351f, 0.07235999f, 
    -0.06560885f, -0.01301305f, -0.17889369f, -0.02898916f, -0.25223964f, 0.18674786f, -0.12649810f, -0.09850118f, 
    -0.17175557f, -0.03036179f, -0.02492616f, 0.16613962f, 0.16307496f, -0.00201191f, 0.03437049f, -0.02518141f, 
    -0.03690328f, 0.13749282f, -0.06509606f, -0.01243356f, 0.02657417f, 0.14440368f, 0.00614730f, 0.15280901f, 
    -0.23213254f, 0.03928775f, -0.06947803f, -0.07791789f, -0.08704094f, -0.07960965f, 0.10791006f, 0.03260108f, 
    0.04654998f, 0.11507487f, 0.03956969f, -0.00405601f, -0.26691350f, 0.36889613f, 0.17602441f, 0.02850256f, 
    0.19231512f, 0.12974137f, 0.03679749f, -0.03655609f, -0.05675225f, 0.05425549f, -0.01185646f, -0.05608298f, 
    0.34859148f, -0.16676435f, 0.17086102f, -0.10963422f, -0.03205474f, 0.09068605f, 0.05119964f, -0.04651557f, 
    -0.05448120f, 0.02160696f, 0.02977497f, 0.05030320f, -0.03171919f, 0.16289522f, 0.02706051f, -0.28865275f, 
    0.20175628f, -0.09528808f, -0.19710293f, -0.04997036f, 0.06308737f, 0.18893515f, 0.11553612f, -0.07245903f, 
    -0.02764176f, -0.07897409f, -0.03465774f, -0.00782994f, 0.20076109f, 0.16295902f, -0.08663725f, 0.00800699f, 
    0.12803800f, -0.01343960f, 0.05487435f, 0.01973215f, 0.02199695f, -0.25294480f, -0.07579625f, -0.12676319f, 
    0.14767921f, 0.05216931f, 0.01095449f, 0.09927091f, -0.05413691f, 0.13792588f, 0.14256024f, 0.14050445f, 
    0.02985768f, 0.09090635f, 0.21090704f, 0.22722249f, -0.00651949f, -0.09813639f, 0.06898396f, 0.02676284f, 
    0.11295890f, 0.04378292f, 0.04747207f, 0.08051730f, 0.04022888f, -0.04868506f, -0.09197000f, -0.11663903f, 
    0.22301920f, 0.11296616f, -0.00007966f, 0.13235344f, 0.03865916f, 0.13115586f, 0.23332873f, -0.06486797f, 
    0.17183477f, -0.35153520f, -0.17342713f, -0.01938668f, -0.11632450f, -0.07636944f, 0.04363355f, -0.04045005f, 
    -0.14840494f, 0.00895525f, 0.16150662f, 0.03232664f, 0.13115297f, -0.01538646f, -0.02179149f, 0.10671879f, 
    0.02884411f, 0.22003889f, 0.11676638f, 0.00609165f, 0.02281182f, 0.01215030f, -0.14772220f, 0.05617287f, 
    -0.15781386f, 0.32866400f, -0.02721392f, 0.24186283f, 0.13154896f, 0.05176821f, -0.04151338f, 0.04886404f, 
    0.00709616f, -0.05856598f, 0.10827928f, -0.07417278f, -0.08163998f, -0.07045127f, 0.02642477f, 0.20832054f, 
    0.15026639f, -0.02402535f, 0.09279626f, 0.05863676f, 0.19961426f, -0.04911266f, -0.07692108f, 0.14676517f, 
    -0.33325833f, 0.00511368f, 0.01037621f, -0.14439990f, 0.03707497f, 0.01339321f, -0.00656803f, 0.00815823f, 
    -0.11747360f, -0.01485343f, 0.08920558f, -0.14765044f, 0.11983503f, -0.13008119f, -0.09121584f, 0.22921556f, 
    -0.05724388f, -0.08512462f, 0.12487336f, -0.10556459f, -0.00882714f, -0.04916071f, 0.02691144f, 0.03291859f, 
    0.46959403f, 0.24746780f, -0.05901914f, -0.18907636f, 0.14068042f, -0.08308110f, 0.04583883f, -0.04097913f, 
    0.00285141f, -0.02006324f, -0.00279357f, 0.08837007f, -0.21252072f, 0.02233930f, -0.01816456f, 0.02369807f, 
    -0.17323712f, 0.03085811f, -0.09858147f, -0.12117480f, 0.00540008f, -0.05152256f, -0.02331000f, 0.00555570f, 
    -0.02106624f, 0.54989690f, -0.16558377f, 0.07634678f, 0.04199971f, -0.01682691f, -0.00130911f, -0.05735886f, 
    0.07540116f, 0.13622028f, 0.12575643f, 0.10767853f, -0.66878086f, 0.06539062f, -0.24890158f, -0.21147703f, 
    0.12267697f, -0.05005245f, -0.05736650f, -0.29107508f, -0.04730520f, -0.10118128f, 0.05552708f, -0.10897595f, 
    0.05379485f, -0.12545276f, 0.12195975f, 0.05955132f, 0.12646344f, 0.22152884f, 0.00043013f, 0.04176900f, 
    0.22133330f, -0.03819719f, -0.13061833f, -0.09164121f, 0.00108085f, -0.05232275f, -0.14683470f, -0.01909300f, 
    0.23985445f, 0.02377089f, -0.02966415f, 0.08747698f, -0.07229622f, 0.06534541f, 0.03334657f, -0.06432702f, 
    0.17752825f, -0.04713086f, -0.01337091f, 0.17158593f, 0.15516858f, -0.11937264f, 0.06875373f, 0.10963944f, 
    0.05975833f, 0.05545473f, 0.04409884f, 0.07647295f, 0.10689217f, -0.22909723f, 0.36347935f, 0.08329199f, 
    -0.11311600f, 0.10206722f, 0.00684763f, 0.02734550f, 0.06127344f, 0.02269899f, 0.12305898f, -0.17470732f, 
    -0.05169556f, 0.17144246f, 0.10363258f, 0.06871500f, 0.06770984f, 0.09182036f, 0.02531693f, -0.00393143f, 
    0.13254288f, -0.04709015f, -0.01919748f, -0.03812524f, -0.23259789f, -0.03485950f, -0.00361166f, -0.07242823f, 
    0.13293324f, -0.02864693f, -0.10504556f, 0.10799777f, -0.01420183f, 0.02689656f, 0.10742300f, -0.01074118f, 
    -0.31563333f, -0.28308755f, 0.13842081f, -0.01888567f, -0.06364500f, -0.08308444f, 0.11355397f, -0.01975251f, 
    -0.03349791f, -0.04367760f, -0.11069306f, 0.07749811f, 0.15234908f, -0.35433462f, 0.18873179f, -0.07122564f, 
    -0.05290549f, 0.04645932f, -0.01787020f, -0.00898530f, 0.07663359f, 0.10777108f, -0.02102114f, 0.00661507f, 
    -0.24939992f, 0.01028851f, 0.15863618f, 0.07001449f, -0.01741540f, 0.10261849f, -0.01331514f, 0.05633117f, 
    -0.02982510f, -0.12801875f, 0.08279980f, -0.01044723f, -0.01066410f, 0.14712650f, 0.31948853f, 0.16105025f, 
    -0.03451907f, 0.03255903f, -0.01606179f, 0.04834537f, 0.06883986f, 0.05829410f, 0.10206684f, 0.08937202f, 
    -0.46141079f, -0.10041461f, -0.06382458f, 0.06349044f, 0.19667308f, 0.10207989f, 0.07288716f, 0.09342201f, 
    0.11978792f, 0.03105086f, 0.02697257f, 0.07835383f, -0.32320756f, 0.27221841f, -0.23420002f, -0.05766970f, 
    0.04042497f, -0.14823855f, 0.06324776f, -0.01040541f, -0.05199084f, -0.04452319f, 0.15160720f, -0.08648614f, 
    0.30791217f, 0.08661460f, -0.00692262f, 0.00114932f, 0.05650651f, -0.15739156f, 0.08081498f, -0.04232843f, 
    -0.02123048f, -0.09256504f, 0.14786893f, 0.03794315f, -0.12503113f, -0.07568379f, -0.12514588f, 0.03167268f, 
    -0.04188900f, -0.13259248f, 0.10492771f, 0.08677578f, 0.09039611f, 0.02580957f, 0.05780941f, 0.01991338f, 
    0.15266588f, 0.35896882f, -0.06038938f, 0.01838436f, 0.09986714f, 0.00995636f, 0.01384653f, -0.02674972f, 
    0.12207233f, 0.06714503f, 0.14309327f, 0.10486671f, -0.21770914f, 0.03603918f, -0.11296257f, -0.14119223f, 
    -0.01806442f, -0.00124488f, 0.06394818f, -0.12642699f, -0.03681425f, -0.02922743f, 0.06606910f, 0.08307724f, 
    -0.43168560f, 0.15166563f, 0.01818779f, -0.05335872f, 0.02078521f, 0.08837713f, -0.04752440f, -0.01127850f, 
    -0.06176118f, 0.08567040f, -0.01228279f, -0.00699075f, 0.12150877f, -0.04790698f, 0.08578653f, 0.05710654f, 
    0.06986423f, 0.09683423f, -0.00562046f, -0.01935003f, 0.05011577f, 0.00780925f, -0.03380482f, -0.05685838f, 
    0.00011216f, 0.01694417f, -0.02509325f, -0.00832946f, 0.02195337f, 0.19205637f, 0.12087148f, -0.03756131f, 
    0.01354219f, -0.06575332f, 0.04861030f, 0.01134360f, -0.01944043f, 0.03741213f, -0.06174449f, 0.06092675f, 
    -0.06077527f, 0.00621655f, 0.01821568f, -0.14831471f, -0.07802546f, -0.04430253f, 0.02080461f, 0.02656781f, 
    -0.24678652f, -0.19098619f, -0.14816162f, -0.36449215f, -0.04080311f, 0.00067881f, -0.14352766f, 0.08040375f, 
    0.07142653f, -0.01577533f, -0.18724741f, 0.12318332f, -0.05914927f, -0.03071111f, -0.11504485f, 0.09639747f, 
    -0.03627121f, 0.05571053f, -0.04515253f, -0.12219924f, -0.00672929f, 0.02267082f, 0.10447846f, 0.24150141f, 
    0.14286619f, 0.19577658f, -0.13616574f, 0.07395401f, 0.08694480f, 0.04109904f, 0.03545095f, 0.13852209f, 
    0.05045709f, 0.02416939f, 0.11746016f, 0.00030437f, 0.36589837f, -0.07616592f, 0.08076603f, -0.23233889f, 
    0.12753353f, -0.12616093f, -0.07614422f, -0.12047419f, 0.07570912f, 0.04766675f, 0.15360719f, 0.23161869f, 
    0.02134624f, -0.32084212f, 0.07833801f, -0.46538815f, 0.09208779f, -0.12258344f, 0.08951131f, -0.12069914f, 
    0.03821801f, -0.05650292f, 0.12503868f, -0.04835231f, 0.05731204f, 0.00770943f, -0.19561297f, -0.28575969f, 
    -0.21964887f, 0.07776600f, 0.07798218f, -0.04971513f, 0.04773859f, 0.03989198f, 0.09030725f, 0.10667798f, 
    -0.05238969f, -0.19346990f, 0.17668329f, 0.18132503f, 0.00181315f, -0.00463055f, 0.07530094f, 0.04273868f, 
    0.01588091f, 0.08948084f, -0.06729032f, -0.05189348f, 0.23507774f, 0.16484807f, 0.07313461f, -0.09294736f, 
    -0.15071787f, -0.04359601f, 0.00341171f, 0.09436269f, 0.08208060f, 0.09374723f, 0.13762760f, 0.07170072f, 
    -0.03311140f, 0.12443934f, 0.08495612f, -0.15997252f, 0.22417046f, -0.01269425f, 0.07419384f, 0.11189323f, 
    0.05753873f, 0.16170394f, 0.06431343f, 0.09171890f, 0.36129537f, -0.18655834f, 0.28979996f, 0.20380817f, 
    -0.05554883f, -0.07972279f, 0.00968488f, 0.22175317f, -0.00760937f, -0.05725970f, 0.13311304f, -0.22243178f, 
    -0.04248071f, -0.22946711f, 0.13068245f, -0.07335266f, 0.19943760f, -0.04373753f, -0.03878015f, 0.08347108f, 
    -0.04980870f, 0.06124829f, -0.04290029f, 0.05476805f, 0.41201931f, -0.21769980f, -0.30123580f, 0.27578494f, 
    0.11875778f, 0.01376990f, 0.02226448f, 0.05338116f, 0.04142884f, 0.11547547f, 0.02279977f, 0.02376245f, 
    -0.02143207f, -0.11417928f, -0.13409032f, 0.14910725f, -0.08190212f, -0.04150319f, -0.05160943f, 0.07455491f, 
    0.03924489f, 0.05355525f, -0.05680827f, -0.00040224f, -0.05923398f, -0.00115434f, 0.24243882f, -0.05465081f, 
    -0.09420281f, -0.06804749f, -0.01903012f, -0.03484304f, 0.18477824f, -0.13115491f, -0.10027302f, 0.00587036f, 
    0.04535139f, 0.04679146f, -0.00303351f, -0.06735051f, -0.05782995f, -0.10055839f, -0.06515002f, 0.06464159f, 
    0.04211487f, 0.17044824f, 0.12673339f, 0.07550596f, 0.23370522f, 0.16409263f, 0.17195025f, 0.40070266f, 
    0.14080745f, 0.03602681f, 0.18755315f, 0.07251076f, -0.08836468f, 0.02736879f, -0.05482858f, 0.04628235f, 
    -0.22408426f, -0.05358745f, 0.06679727f, -0.04538380f, -0.13379507f, 0.09807219f, -0.02522764f, 0.01701792f, 
    0.00030060f, 0.06262529f, 0.10171811f, 0.00518559f, -0.04776017f, 0.06650627f, 0.13935117f, -0.01454639f, 
    -0.07075988f, 0.12080830f, 0.05689697f, 0.03275657f, 0.12780005f, -0.00117033f, -0.00054232f, 0.19881982f, 
    -0.39499661f, 0.09099934f, 0.27397859f, 0.03799107f, 0.13132422f, 0.06917666f, 0.09177173f, -0.06391728f, 
    0.04342893f, 0.09218848f, 0.04633135f, 0.07271808f, -0.20970292f, 0.11141822f, -0.10794973f, 0.10206369f, 
    -0.07680335f, -0.09820122f, 0.10391340f, 0.08116053f, 0.01856270f, 0.00498043f, 0.00485120f, -0.05874312f, 
    0.36086130f, -0.20682970f, 0.06662016f, 0.08985395f, 0.02143340f, -0.08807936f, 0.10004391f, 0.02390104f, 
    -0.00500138f, 0.03014367f, 0.08521972f, 0.09571596f, -0.23454939f, 0.12320599f, 0.02646868f, -0.17785859f, 
    -0.03168330f, -0.05568206f, 0.01240728f, -0.05000402f, -0.00900693f, -0.02791521f, 0.08561962f, -0.08448309f, 
    0.15910302f, -0.06382828f, -0.17905046f, -0.00927306f, -0.13604900f, -0.07283334f, -0.01524031f, 0.10785505f, 
    0.09641588f, -0.00559651f, 0.15549734f, 0.04643437f, -0.41193748f, 0.18985127f, 0.09053296f, -0.18563448f, 
    0.08257258f, 0.07677174f, 0.00089202f, 0.18466139f, -0.00419546f, 0.05635046f, 0.00477145f, 0.14987430f, 
    -0.12381065f, 0.05960298f, 0.27694303f, 0.30219388f, 0.06782811f, 0.15794109f, 0.03532291f, 0.02875330f, 
    0.00385879f, 0.06788293f, -0.06898206f, 0.07261027f, 0.26024351f, 0.17304532f, -0.37957990f, -0.32103717f, 
    -0.05859131f, 0.01904908f, -0.04062839f, -0.17795895f, 0.03171189f, -0.13740627f, -0.12419347f, -0.03474834f, 
    0.43599367f, -0.57129675f, 0.13667634f, -0.00380636f, 0.15502822f, 0.13596603f, -0.10520580f, 0.07370691f, 
    -0.02282737f, -0.00661735f, 0.02053827f, -0.02208894f, -0.02329980f, -0.40593717f, 0.23753795f, -0.04721827f, 
    -0.15278113f, -0.06475368f, 0.02838957f, -0.01194893f, 0.11833648f, -0.03075650f, -0.03048429f, -0.00033111f, 
    0.10460009f, 0.17895499f, -0.25044140f, -0.16168173f, -0.08417787f, 0.02085932f, 0.13677742f, 0.10512008f, 
    0.03222699f, -0.07690968f, -0.00220548f, -0.18983999f, 0.27296156f, -0.05721806f, -0.19771242f, 0.22030886f, 
    0.00621577f, 0.05790606f, -0.10373184f, 0.08507006f, 0.06980786f, 0.01538408f, 0.11817511f, 0.08088775f, 
    -0.04711894f, -0.04713836f, -0.05957436f, -0.04263232f, -0.05980396f, -0.01495442f, 0.01513629f, 0.04016427f, 
    -0.05197268f, -0.00466912f, -0.01362801f, -0.00126245f, -0.00073094f, -0.07638443f, -0.09244016f, 0.04371714f, 
    -0.03896647f, -0.03284050f, 0.04736252f, -0.07604701f, 0.00799728f, -0.02858942f, 0.00110333f, -0.05505360f, 
    -0.01180472f, 0.01782263f, 0.01893682f, 0.03899937f, -0.04321352f, 0.04974398f, 0.04754772f, -0.02192936f, 
    -0.07718959f, 0.02450488f, 0.01133177f, -0.01595860f, 0.01285497f, 0.02964161f, 0.00425761f, -0.06909718f, 
    0.05126745f, -0.01600311f, -0.01459848f, 0.03784376f, -0.05896826f, -0.01100324f, 0.01690879f, 0.05696490f, 
    -0.06800527f, -0.07682295f, -0.07053710f, 0.00177775f, 0.07094399f, -0.03905473f, -0.04647925f, 0.05154572f, 
    -0.01927331f, 0.00092770f, 0.04001286f, -0.01571928f, -0.02468087f, 0.01187080f, -0.04185491f, 0.04618490f, 
    -0.01922115f, -0.08373520f, 0.03301882f, 0.00216704f, 0.00818904f, 0.01008002f, -0.02946616f, 0.01826113f, 
    -0.01975127f, -0.07104923f, 0.04176631f, 0.00103845f, -0.07240334f, -0.06698592f, 0.01674978f, 0.04551439f, 
    0.05590922f, 0.01301986f, -0.07801191f, 0.02698299f, 0.01825941f, 0.05118804f, 0.00607869f, 0.07723157f, 
    -0.05775799f, -0.02724964f, -0.06607771f, -0.02471970f, -0.02032602f, -0.06379216f, -0.03252372f, -0.07860778f, 
    -0.04410934f, -0.01369657f, -0.06999375f, 0.03067951f, -0.10015343f, -0.05525538f, -0.05311041f, -0.01214426f, 
    -0.08226522f, 0.02920004f, -0.07239486f, 0.02966828f, -0.00752718f, 0.02818660f, 0.03293493f, -0.02202239f, 
    -0.01183082f, 0.03684906f, 0.01915206f, 0.05294924f, 0.05958908f, 0.00198916f, -0.03658375f, -0.04940860f, 
    0.02297984f, -0.05557106f, -0.05429911f, -0.05335855f, -0.08010986f, -0.02882449f, -0.04671559f, 0.02908027f, 
    -0.03612999f, -0.00966874f, -0.06664895f, 0.02338248f, -0.04928205f, -0.03658301f, 0.00935374f, -0.05686677f, 
    0.04468467f, -0.06804784f, -0.05562021f, -0.01500173f, 0.00534766f, 0.00290784f, 0.01340684f, 0.05173518f, 
    0.03617121f, -0.03094957f, -0.00591616f, 0.00400879f, 0.03342887f, 0.00856476f, -0.03421326f, 0.04818378f, 
    -0.05703280f, 0.06021833f, -0.05188295f, 0.00604517f, -0.07037542f, 0.04442780f, 0.04504405f, -0.01698634f, 
    0.07411355f, -0.01911818f, 0.00411873f, 0.03867090f, 0.04634065f, -0.06863941f, 0.03205137f, 0.01698386f, 
    -0.04708565f, -0.07140065f, -0.05372584f, -0.01827965f, 0.03948403f, -0.04825433f, -0.01784314f, 0.04273410f, 
    -0.06414486f, -0.05379637f, -0.08800066f, -0.01766707f, 0.01334718f, -0.03968390f, -0.07461780f, 0.03480259f, 
    0.03425505f, 0.00267645f, -0.07152420f, -0.05008253f, -0.04295041f, 0.04653798f, -0.02050373f, 0.01624760f, 
    -0.29629728f, 0.01584177f, 0.03428231f, -0.03578815f, 0.07621366f, -0.10690241f, -0.01828332f, 0.16726817f, 
    0.11456399f, 0.11098517f, 0.15779245f, 0.02103074f, -0.08944685f, -0.13591200f, 0.20699532f, 0.13626276f, 
    -0.02824065f, 0.09868775f, 0.10413230f, 0.02489781f, -0.11906949f, -0.11823834f, -0.07420905f, -0.05441851f, 
    0.45331162f, 0.06624530f, 0.05368390f, -0.03598053f, -0.00454419f, -0.13646959f, 0.05596018f, -0.01516063f, 
    -0.08922329f, 0.03068617f, 0.02059203f, 0.01155310f, 0.04303779f, 0.10340768f, 0.12950736f, -0.02596519f, 
    0.16134603f, 0.01798715f, 0.08604007f, -0.01991370f, -0.03515530f, 0.03171385f, 0.11618856f, -0.14996348f, 
    -0.04004436f, -0.15085450f, 0.16753584f, 0.13567320f, 0.00733351f, -0.03869229f, 0.09496748f, -0.04219576f, 
    -0.18285121f, -0.05299306f, 0.08918834f, 0.09762332f, 0.12736471f, 0.07414836f, 0.00316519f, 0.02775293f, 
    -0.03326200f, 0.00432148f, -0.07883659f, -0.01198896f, 0.02655687f, 0.01579290f, -0.05973956f, -0.10630811f, 
    0.04442309f, 0.34554425f, 0.06792267f, 0.18495058f, -0.07956479f, 0.08354531f, 0.07090975f, 0.12956809f, 
    -0.05879983f, -0.17305413f, 0.04591981f, 0.09156614f, -0.08669228f, -0.06708997f, 0.23414242f, -0.04399559f, 
    0.13593896f, -0.07868899f, 0.01514532f, 0.03978874f, 0.15947087f, 0.09060574f, -0.11039733f, 0.10127204f, 
    -0.32790476f, -0.11513503f, 0.11475552f, -0.30249399f, 0.11111487f, 0.02728485f, -0.03533306f, -0.10440563f, 
    0.08100743f, -0.04718329f, 0.11585929f, 0.04240351f, -0.52253091f, 0.01575163f, -0.01995626f, -0.10094920f, 
    0.11337662f, 0.01940534f, 0.04080599f, -0.08688151f, 0.07687972f, -0.01433702f, 0.08224174f, -0.09448596f, 
    -0.09344663f, 0.15485856f, 0.14882416f, 0.00354987f, -0.10306792f, -0.10866389f, 0.00870709f, 0.01113326f, 
    0.00057705f, -0.16961695f, 0.00471049f, 0.05340827f, -0.13184258f, 0.18852176f, -0.16410971f, 0.03752578f, 
    -0.03454709f, 0.06438827f, -0.02805478f, -0.11160307f, 0.03342412f, -0.01346125f, 0.05237045f, 0.09702495f, 
    -0.08889605f, -0.03009643f, 0.05237351f, -0.02082177f, -0.08729836f, 0.11936836f, 0.07216139f, 0.06969753f, 
    -0.00098711f, -0.07285978f, 0.16378734f, 0.06288997f, 0.19361328f, 0.14199577f, 0.28764328f, 0.18566431f, 
    0.00136084f, 0.00287474f, -0.03567297f, 0.07958230f, -0.00352496f, 0.09408153f, 0.02123438f, 0.03847650f, 
    -0.19816856f, 0.04533552f, 0.23929951f, 0.08191153f, -0.02289408f, 0.17157601f, -0.01117481f, -0.02194087f, 
    -0.02662376f, -0.11903708f, -0.03879521f, -0.00548616f, 0.19937903f, -0.18207707f, -0.05156258f, 0.13807619f, 
    -0.10041270f, 0.11401330f, -0.14270172f, 0.11003108f, 0.00536763f, 0.06323101f, -0.04816285f, -0.08927286f, 
    0.03483853f, -0.03928133f, 0.00248740f, -0.07475810f, -0.05561154f, 0.01673718f, 0.01219457f, -0.00879642f, 
    0.02252370f, -0.07039738f, 0.00471882f, 0.04424463f, -0.05561478f, -0.06811456f, 0.01531116f, -0.03946608f, 
    0.00807673f, 0.06105072f, 0.05393975f, -0.07701921f, -0.02028296f, 0.02026280f, -0.04983357f, 0.00278854f, 
    -0.02543116f, -0.05500532f, 0.01679985f, -0.05518227f, -0.07713961f, -0.03213236f, -0.00336311f, -0.07015926f, 
    0.01837398f, 0.01608400f, -0.02652461f, 0.02011658f, -0.07038047f, -0.03029245f, -0.03449883f, -0.06742046f, 
    0.04172816f, -0.02934760f, -0.03194521f, -0.06485128f, 0.04123367f, 0.03991167f, -0.07556282f, -0.06712680f, 
    -0.00586561f, 0.04978318f, -0.04049733f, -0.06761675f, -0.07371570f, -0.02543308f, 0.01989954f, -0.05740102f, 
    -0.07207458f, -0.06809738f, -0.02487587f, 0.01139832f, 0.01734213f, 0.06349385f, 0.02503233f, 0.00519743f, 
    0.05332452f, -0.03964943f, -0.01470718f, -0.07501990f, 0.03332162f, -0.07293727f, -0.06256549f, -0.03821093f, 
    -0.04623273f, 0.04882444f, -0.02656995f, 0.00516786f, 0.01996666f, -0.02155459f, 0.03015655f, -0.01625383f, 
    0.01148356f, -0.07421935f, -0.05898731f, -0.02416191f, 0.02182961f, -0.04395944f, 0.01499569f, -0.02766572f, 
    -0.06593132f, 0.00104978f, 0.02513586f, -0.06746835f, -0.01793743f, -0.04651520f, -0.00053475f, -0.06399217f, 
    0.01609004f, 0.01641682f, 0.05511418f, -0.03156139f, -0.02040039f, 0.02970420f, -0.05507611f, 0.03340359f, 
    0.03663053f, -0.04975364f, -0.03722039f, -0.04073419f, -0.01649119f, 0.02353786f, -0.02864777f, -0.02978957f, 
    -0.07623429f, 0.02146582f, -0.02764508f, 0.04705876f, -0.05409497f, -0.07036766f, -0.06264412f, 0.00037266f, 
    -0.02442180f, -0.01042331f, 0.05571414f, -0.01342142f, 0.06162037f, 0.05531400f, -0.02342927f, 0.04676712f, 
    0.06674790f, -0.02906016f, 0.02917009f, 0.02295396f, 0.05415203f, 0.05560397f, 0.01727144f, -0.04527768f, 
    -0.01039891f, -0.06846336f, -0.07114379f, -0.02068073f, 0.02243673f, 0.03582212f, 0.01339344f, 0.00087790f, 
    -0.00984941f, 0.02459628f, -0.00526134f, -0.04448437f, 0.06037953f, -0.06180901f, 0.00070484f, 0.06030273f, 
    -0.01194865f, -0.06590719f, 0.05605211f, 0.03121991f, -0.01323532f, -0.07602318f, -0.07611340f, -0.05161403f, 
    0.06291300f, 0.02044424f, -0.01462915f, 0.04031347f, -0.07132816f, -0.03345363f, -0.05596168f, 0.03339529f, 
    0.05199880f, 0.04179017f, 0.00512801f, 0.01462300f, 0.02778451f, -0.01050531f, -0.07506035f, 0.03732147f, 
    -0.00513989f, -0.00397410f, -0.06982002f, 0.02165197f, 0.01148580f, -0.03310123f, -0.01074993f, 0.00780486f, 
    0.03359442f, -0.00452635f, -0.01833990f, -0.07681338f, -0.02305993f, -0.04101668f, -0.02480944f, 0.04421748f, 
    -0.04871163f, -0.01592716f, 0.25995997f, 0.15043500f, 0.19419107f, -0.03763818f, 0.07678476f, 0.04334966f, 
    0.12240157f, -0.06228463f, 0.14210027f, 0.00772362f, -0.22059405f, -0.13904555f, 0.17604470f, 0.10050049f, 
    -0.18159439f, -0.08468159f, 0.02014783f, -0.02282702f, 0.00794072f, -0.01985424f, 0.00016528f, 0.28751415f, 
    0.01346328f, -0.02285448f, 0.00517936f, 0.13381073f, -0.03352110f, -0.06187101f, 0.13904689f, -0.09240642f, 
    -0.04553383f, -0.04265245f, -0.16186781f, 0.03093016f, -0.07636244f, 0.04184482f, 0.07130104f, -0.04475706f, 
    0.02186471f, 0.00599161f, 0.02047473f, -0.09955726f, 0.20980003f, 0.19760144f, 0.06451865f, 0.11327410f, 
    0.17563246f, -0.02326704f, 0.06709946f, -0.03877168f, -0.08055592f, 0.00529663f, 0.01128061f, 0.03554993f, 
    0.12245972f, -0.13954352f, 0.12825942f, -0.17792653f, 0.07794449f, 0.05434392f, -0.00575230f, 0.00582983f, 
    0.02160288f, 0.06610961f, -0.11622672f, -0.07475083f, -0.03806298f, -0.03712344f, 0.12446064f, -0.05182761f, 
    -0.23476148f, 0.24575566f, 0.08029363f, 0.15827970f, -0.14532991f, 0.02241235f, 0.03470549f, 0.00548896f, 
    -0.05559769f, -0.00663639f, 0.08155925f, -0.01569072f, 0.18481049f, -0.12780046f, 0.11668666f, 0.02007715f, 
    0.14840135f, -0.00166353f, -0.03586507f, 0.09807707f, 0.21838541f, 0.13546672f, -0.10372125f, -0.09065193f, 
    -0.21053348f, 0.15031250f, 0.02107958f, 0.05387805f, 0.03138831f, 0.14077711f, 0.02387199f, -0.15826167f, 
    0.00210810f, 0.22802515f, 0.01729675f, -0.07676583f, -0.33611953f, 0.17973928f, -0.09574184f, -0.17002758f, 
    -0.06829879f, 0.10896950f, 0.06008427f, -0.10459480f, -0.03262196f, -0.03100446f, 0.02374808f, -0.00555366f, 
    -0.08659841f, 0.01851905f, 0.06807821f, 0.07466815f, -0.21734619f, 0.00571905f, 0.01508788f, -0.01172332f, 
    -0.09607558f, -0.04523230f, 0.05582909f, 0.17835169f, -0.15900828f, 0.11232816f, -0.01258392f, -0.00209169f, 
    0.25964776f, 0.29660362f, 0.01622671f, -0.26888242f, 0.05406804f, 0.07772335f, 0.13057424f, 0.03238486f, 
    -0.25215873f, 0.11477066f, -0.09037635f, -0.14568147f, -0.23502736f, -0.04799723f, -0.05878611f, -0.02295302f, 
    0.05983202f, -0.08478457f, -0.10075477f, 0.18505040f, 0.46184537f, 0.23237394f, 0.45668018f, 0.30973956f, 
    -0.15214004f, 0.08792316f, 0.01419615f, -0.08912999f, -0.01953678f, 0.00371625f, -0.02912845f, -0.03989143f, 
    -0.05514345f, 0.20606788f, -0.02981334f, 0.02998205f, 0.20245206f, 0.11243435f, -0.09108158f, 0.03431317f, 
    0.12374708f, 0.05138298f, -0.08029731f, -0.02238610f, -0.07494215f, -0.15900619f, -0.06059161f, 0.12784907f, 
    -0.10507889f, -0.09056081f, -0.03217283f, -0.08008955f, 0.03093240f, -0.03744838f, -0.07078763f, -0.06882799f, 
    0.29850647f, -0.02650552f, -0.16633545f, -0.01480765f, 0.01605563f, 0.06838507f, -0.00510309f, -0.09710409f, 
    -0.13224147f, 0.02961724f, -0.03737571f, 0.05136303f, 0.09140155f, 0.12634961f, 0.00483503f, -0.19535442f, 
    0.06867804f, 0.06887182f, -0.09212727f, 0.07391164f, 0.15295713f, 0.04766385f, 0.15400892f, 0.06640434f, 
    -0.27425420f, 0.00174716f, -0.06514554f, 0.12149674f, 0.05056781f, 0.10626349f, -0.01570898f, -0.03939204f, 
    0.05152576f, 0.09981240f, 0.11181635f, -0.13836108f, -0.21618584f, -0.10315197f, -0.02083900f, 0.02055271f, 
    -0.07603447f, 0.01377565f, 0.05627391f, 0.10234418f, -0.01167197f, 0.04144383f, 0.07523428f, -0.03753660f, 
    -0.12217794f, -0.10497113f, -0.25308231f, -0.15075086f, -0.03587427f, -0.02830137f, 0.00767542f, 0.11565878f, 
    0.20458902f, 0.04884583f, -0.09589878f, -0.08877067f, 0.06604520f, -0.13768691f, 0.29521006f, 0.29426718f, 
    0.04435398f, 0.10853649f, 0.01690749f, 0.01642803f, 0.18804073f, 0.04433647f, 0.06186757f, 0.09900738f, 
    0.02610593f, -0.16377284f, -0.00713852f, 0.01191680f, 0.04317119f, 0.04839304f, -0.06510480f, 0.02744849f, 
    0.05948171f, -0.00479424f, -0.01229258f, 0.05891411f, -0.07661883f, -0.05525850f, 0.04481319f, 0.20500830f, 
    -0.02734118f, 0.03738550f, 0.17877641f, -0.10334905f, -0.07360247f, 0.00201325f, 0.17482287f, 0.03995527f, 
    -0.01092095f, -0.02773077f, -0.19745813f, 0.10039847f, 0.04577340f, 0.02659964f, 0.10237176f, -0.02284116f, 
    -0.02631411f, 0.00396011f, 0.00993132f, 0.15803002f, 0.28352964f, 0.02992677f, -0.15035799f, 0.18798062f, 
    -0.09312826f, -0.11345977f, 0.12187358f, 0.11357310f, 0.03685374f, -0.10705605f, 0.01762636f, 0.05903542f, 
    0.23205993f, -0.11498406f, -0.07389939f, -0.01730992f, 0.16912699f, 0.07584216f, 0.05626717f, 0.00049597f, 
    -0.07685481f, 0.03939250f, -0.03507602f, 0.01950594f, 0.00186647f, -0.28080195f, 0.03823527f, -0.01606129f, 
    -0.14932995f, -0.14782535f, 0.07835528f, 0.06332596f, 0.11408572f, 0.12162652f, -0.08753086f, 0.07676279f, 
    0.06523095f, 0.24517392f, -0.19660664f, -0.05936240f, 0.07595870f, -0.10663296f, 0.04246025f, -0.00108686f, 
    0.11705834f, 0.02968198f, 0.10933680f, 0.14479075f, -0.47864789f, 0.19598630f, -0.23014943f, -0.41953984f, 
    -0.07906019f, 0.17360833f, 0.04655307f, 0.05102029f, 0.03781765f, -0.04613586f, 0.13736352f, 0.13917470f, 
    -0.06068552f, -0.25723651f, -0.24148613f, -0.06477486f, -0.12701842f, -0.10806274f, -0.03742893f, -0.09759549f, 
    0.00443338f, 0.02157729f, -0.03399767f, 0.06630999f, -0.11543762f, 0.11478572f, 0.25202438f, -0.18026872f, 
    0.15842195f, 0.11009371f, 0.13036726f, -0.10566075f, -0.01574429f, 0.06462428f, 0.03681285f, 0.16979444f, 
    0.31386572f, 0.13457231f, 0.07269503f, 0.19707717f, -0.13026173f, -0.07262261f, 0.20610456f, -0.00269736f, 
    -0.10806999f, -0.21360812f, -0.21196824f, -0.00717479f, -0.02422694f, -0.00285779f, -0.03224042f, -0.34502691f, 
    0.03154537f, 0.05590520f, -0.09239611f, 0.13917522f, 0.14428531f, 0.05592445f, 0.00383654f, -0.26986203f, 
    -0.20917673f, 0.10744508f, 0.17364046f, 0.27106166f, 0.02189700f, 0.05351322f, 0.09240279f, 0.07005303f, 
    -0.04196450f, -0.02041301f, 0.12058367f, 0.09889762f, 0.10345733f, -0.10593241f, 0.10260760f, -0.06232814f, 
    0.06681698f, -0.09402285f, 0.03353294f, 0.00747627f, -0.10483686f, -0.28817806f, -0.15528326f, -0.24031948f, 
    -0.02513723f, 0.06582466f, -0.12127139f, -0.10308857f, 0.05334700f, -0.16944639f, 0.00742975f, -0.03368020f, 
    0.07599998f, 0.06880667f, -0.09758084f, 0.01393660f, 0.24851708f, -0.07999104f, 0.00517549f, -0.13775773f, 
    0.07833327f, -0.12336198f, -0.04496429f, 0.10938644f, -0.00538263f, 0.04972711f, 0.07198935f, 0.06216205f, 
    0.39749292f, -0.12299495f, -0.26682770f, 0.07038967f, -0.14872965f, 0.09643927f, -0.07101349f, 0.13469067f, 
    -0.03881358f, 0.05530585f, -0.02822773f, 0.03460201f, 0.21498659f, 0.21025094f, 0.04731613f, 0.33444530f, 
    -0.03258572f, 0.22315434f, 0.05710854f, 0.06046591f, -0.28239062f, -0.05971040f, 0.03290724f, -0.05857380f, 
    0.29075062f, -0.01978597f, -0.04185298f, 0.26818651f, -0.02890613f, 0.01527652f, 0.03055237f, 0.03547086f, 
    -0.09171218f, -0.06774991f, -0.04058035f, 0.15432312f, 0.14225017f, -0.20882985f, -0.06475949f, 0.28635007f, 
    0.08065353f, -0.00286835f, 0.04179150f, -0.02769176f, -0.10462525f, 0.05604902f, -0.00077788f, 0.05007654f, 
    0.00592840f, -0.27060232f, -0.05576945f, 0.13550982f, -0.06950132f, -0.03434916f, -0.00962914f, -0.04315530f, 
    0.06516552f, -0.17358840f, -0.02536536f, -0.22137751f, -0.30124360f, -0.27798122f, 0.03711013f, -0.12896752f, 
    -0.06313357f, -0.17781202f, 0.04006197f, 0.11699239f, 0.03366766f, 0.11886061f, 0.01320021f, 0.15138285f, 
    -0.05744944f, 0.25146374f, -0.28772691f, 0.07461111f, 0.11334145f, 0.08731733f, -0.00089126f, 0.00691466f, 
    -0.02202223f, 0.04223965f, 0.09363179f, -0.03146533f, -0.11968362f, 0.07101364f, -0.09225419f, -0.06362102f, 
    -0.02681544f, 0.16938818f, 0.07365988f, -0.01494890f, -0.03667963f, -0.13885030f, 0.21207657f, 0.00085157f, 
    -0.29334593f, -0.12590055f, -0.01115652f, -0.10942104f, -0.02165171f, -0.03439099f, 0.03268114f, -0.06176106f, 
    -0.03700273f, 0.02900882f, 0.18175580f, 0.24639411f, 0.35802346f, 0.18160596f, -0.12052449f, -0.32140431f, 
    0.01106643f, 0.11050052f, 0.20130722f, 0.04433517f, 0.13689633f, 0.03692276f, 0.00994266f, 0.10775400f, 
    -0.08571533f, -0.03398097f, 0.01321317f, 0.24621865f, 0.08888988f, -0.04539481f, 0.01878724f, 0.12760225f, 
    0.09286946f, -0.04286877f, -0.05439880f, 0.01695559f, -0.05840260f, -0.03909431f, 0.16377440f, -0.25953576f, 
    -0.13986528f, -0.07317907f, -0.01359990f, -0.02727046f, 0.05436291f, -0.07218085f, 0.02983590f, -0.26163998f, 
    0.48632309f, 0.07751644f, 0.05346907f, 0.09773842f, -0.02816173f, 0.02456108f, 0.11678381f, 0.03266959f, 
    -0.10893229f, 0.00112909f, 0.09624809f, 0.01174151f, 0.13832963f, 0.12852566f, 0.07248276f, -0.06458472f, 
    -0.09268212f, -0.05730318f, 0.05640671f, -0.03373767f, 0.02049775f, 0.02748390f, -0.07143758f, -0.22907752f, 
    0.08623380f, -0.11082391f, 0.20837204f, -0.27280074f, -0.09477336f, 0.01589826f, 0.01473258f, 0.10113180f, 
    0.07229468f, -0.03373831f, -0.20946568f, -0.03442804f, -0.14925843f, -0.00514635f, 0.18744718f, -0.00506429f, 
    -0.02812344f, 0.05962327f, -0.00651739f, -0.03038389f, -0.09852087f, -0.05898362f, 0.07619238f, -0.18973491f, 
    -0.36914429f, 0.16047356f, 0.27748504f, -0.14382811f, -0.21263130f, 0.13765289f, 0.13370383f, 0.12290813f, 
    -0.18586977f, 0.09499221f, -0.07338916f, 0.13005416f, 0.17305285f, -0.07585439f, 0.26161531f, 0.19108911f, 
    0.23575358f, 0.03994698f, 0.05912769f, 0.05811768f, -0.05481255f, 0.03937368f, 0.01120688f, -0.12423324f, 
    0.08103074f, 0.23738977f, 0.19438992f, -0.01175412f, 0.03416250f, -0.00956303f, 0.07732346f, -0.01128771f, 
    0.18211772f, -0.08980998f, -0.07305645f, 0.07907119f, 0.17807887f, -0.06064826f, -0.09872989f, 0.01044769f, 
    0.06690431f, 0.05021882f, 0.09568915f, -0.01753701f, 0.03708814f, -0.05991809f, 0.01615762f, -0.00374333f, 
    -0.23451126f, -0.22333118f, 0.01702389f, -0.00654035f, -0.06902524f, 0.01151803f, 0.00278208f, 0.02695799f, 
    0.02841889f, -0.27415463f, 0.06720728f, -0.09996853f, -0.04882800f, 0.12203173f, 0.06231083f, 0.06347749f, 
    0.28172135f, 0.04059349f, 0.10409760f, 0.07545628f, 0.06688407f, 0.26151666f, 0.09714209f, 0.13042584f, 
    -0.33957800f, 0.20771509f, -0.01463731f, -0.08615277f, -0.14740030f, -0.00851573f, 0.05519258f, -0.04281152f, 
    -0.05602580f, -0.09390838f, 0.03383838f, 0.04588523f, 0.27516153f, 0.42513454f, 0.06212575f, 0.02737273f, 
    -0.08460403f, 0.09964736f, 0.04264704f, 0.10960530f, -0.02517964f, -0.00015818f, 0.08087166f, 0.00008123f, 
    0.07333192f, 0.00226529f, 0.25109333f, 0.02996144f, 0.07047081f, 0.06419541f, -0.06737367f, -0.07072196f, 
    -0.08832154f, 0.10136212f, 0.08401101f, 0.18824273f, -0.03084977f, -0.02656816f, 0.09025916f, -0.05887218f, 
    -0.18516612f, 0.08599325f, 0.03342714f, -0.03123710f, -0.15334028f, 0.06201638f, -0.14151181f, -0.06923959f, 
    0.04416295f, -0.03720431f, 0.05141586f, -0.06181059f, 0.02707233f, -0.03726859f, 0.00467920f, -0.05615696f, 
    -0.04248133f, 0.01024498f, 0.01781694f, 0.04101263f, -0.02285376f, 0.03948531f, 0.05433324f, -0.06544200f, 
    -0.05172170f, 0.05811976f, 0.01658690f, 0.05904697f, 0.01644112f, -0.03092954f, 0.00798599f, 0.05797739f, 
    -0.02413496f, 0.05176555f, -0.04751762f, 0.03055407f, 0.00875438f, -0.01566103f, -0.02524976f, -0.02404070f, 
    -0.07697783f, -0.01579457f, -0.00033592f, 0.03413658f, -0.05194617f, 0.03591998f, 0.05899625f, -0.03291573f, 
    -0.03201972f, -0.04133030f, -0.03317199f, -0.07132857f, -0.02667626f, 0.01207955f, -0.01021745f, 0.05232479f, 
    0.03046200f, 0.05667366f, 0.07036053f, -0.03010505f, -0.03084384f, 0.00172337f, -0.03868344f, 0.02846709f, 
    0.06174272f, 0.01805012f, 0.01703923f, -0.03667874f, -0.03491666f, -0.00639176f, -0.02318372f, -0.06698377f, 
    -0.01432365f, 0.04554525f, -0.02991184f, 0.04029147f, 0.01439665f, 0.02451722f, -0.05976491f, 0.01231487f, 
    -0.03444745f, -0.01797979f, -0.00229637f, -0.07433507f, 0.00250109f, 0.05350292f, 0.01761401f, -0.01435737f, 
    -0.06754316f, -0.08196251f, 0.00314854f, -0.05150825f, -0.01455299f, -0.07563755f, -0.05759861f, -0.02763575f, 
    0.00681387f, -0.00983530f, 0.05633406f, -0.01525842f, 0.01271632f, -0.01551812f, -0.03354020f, -0.00729726f, 
    -0.03959960f, -0.00793748f, -0.00964970f, -0.00946532f, -0.03117373f, 0.02343498f, 0.00093392f, -0.05256313f, 
    -0.06331652f, 0.02594444f, 0.04109569f, -0.04988309f, -0.01764582f, -0.01642476f, -0.06821357f, -0.02456154f, 
    0.05961446f, -0.06667028f, 0.05025573f, -0.07862636f, 0.05189532f, 0.00391553f, -0.04804386f, 0.03536113f, 
    -0.03116098f, -0.01005598f, -0.03883536f, 0.00185622f, -0.03251427f, 0.00808412f, -0.04134113f, -0.00901058f, 
    0.00247620f, -0.02404003f, -0.03449902f, -0.02304455f, -0.03824197f, -0.01284358f, -0.06072778f, 0.02899740f, 
    -0.06597234f, 0.00051321f, -0.00859291f, -0.04829513f, 0.06111949f, 0.05157962f, 0.04735992f, 0.06114523f, 
    -0.04893295f, 0.02369363f, -0.02037750f, 0.02290965f, -0.00339271f, 0.02809097f, -0.06412784f, -0.02470895f, 
    -0.01706479f, -0.03732083f, -0.01174191f, 0.02915936f, -0.06783825f, -0.03553547f, -0.06563173f, -0.01568186f, 
    -0.02455269f, -0.05256526f, 0.03173648f, -0.05970561f, 0.01062972f, -0.01999674f, 0.02218409f, -0.01683283f, 
    0.02672902f, -0.06284213f, 0.02380478f, -0.07422581f, -0.02487793f, -0.07532147f, -0.01048628f, 0.03122977f, 
    -0.02585863f, 0.05686586f, -0.01661897f, -0.01755186f, 0.06378303f, 0.03255314f, 0.00643001f, -0.01212036f, 
    0.01957321f, -0.02962825f, 0.05186721f, -0.07380822f, 0.06301711f, 0.00577989f, -0.02973394f, 0.01277689f, 
    0.13667724f, 0.14930069f, 0.11150757f, 0.04392184f, -0.07705821f, -0.11992942f, 0.03507299f, 0.03976486f, 
    0.03795910f, -0.14916657f, -0.02103644f, 0.09445060f, -0.18804224f, -0.13394028f, 0.06920332f, 0.13474777f, 
    0.01513951f, 0.01662759f, 0.01080559f, -0.05924343f, -0.00995322f, -0.01039973f, 0.06604974f, -0.04208630f, 
    -0.33067819f, -0.05021956f, 0.07749286f, -0.12140834f, -0.10129827f, -0.03073680f, -0.04337655f, -0.03494154f, 
    0.05883064f, -0.02778666f, -0.05192907f, 0.08759729f, 0.04551184f, 0.00495214f, 0.02145784f, 0.08807742f, 
    -0.01013920f, -0.00676977f, -0.04503703f, 0.00683524f, -0.04565183f, -0.06075256f, -0.03593808f, 0.04127345f, 
    0.10689174f, 0.11343261f, 0.11978373f, 0.28372440f, 0.08641070f, -0.07352015f, -0.01476218f, 0.14642024f, 
    0.07671405f, -0.00090434f, 0.00896371f, -0.07867184f, 0.52782112f, -0.18474868f, -0.00128859f, -0.20533144f, 
    0.02076311f, -0.11312950f, 0.00958176f, -0.00274993f, -0.02231869f, 0.02380297f, 0.08744800f, 0.05611540f, 
    0.29287213f, -0.12025577f, 0.04327490f, -0.09030680f, -0.12352388f, -0.04998832f, 0.01284538f, -0.07285506f, 
    0.00246728f, 0.01484597f, 0.13071941f, 0.06852061f, 0.17488272f, 0.18343276f, -0.06955017f, -0.16476613f, 
    -0.20880997f, 0.09516241f, -0.01728254f, -0.03017402f, 0.14539638f, 0.11044043f, 0.00237535f, -0.08210465f, 
    -0.17399243f, -0.09242988f, 0.11035145f, 0.11169653f, -0.01485348f, -0.00942447f, -0.01224786f, -0.07390892f, 
    0.02889328f, 0.09879533f, -0.02957035f, 0.02500637f, -0.25494128f, 0.27208024f, -0.04674002f, -0.07260514f, 
    0.00023495f, -0.01188368f, -0.00036119f, -0.05830367f, 0.04762405f, 0.07588323f, 0.13194425f, -0.06047581f, 
    -0.16762079f, -0.10325034f, -0.00893364f, 0.15148570f, -0.12236609f, -0.15379491f, 0.03699711f, 0.09526535f, 
    -0.03843467f, -0.00939944f, 0.06175951f, -0.00222576f, -0.02666840f, -0.07827298f, 0.13796724f, 0.09332579f, 
    0.06234119f, -0.02134098f, 0.07286873f, 0.04225767f, 0.04524860f, -0.00298522f, 0.06555547f, -0.03893272f, 
    -0.17143303f, -0.07658816f, 0.07424731f, 0.05683538f, -0.03522724f, -0.02400306f, 0.01449859f, -0.00469502f, 
    0.00067116f, 0.09829339f, -0.05899781f, 0.12222862f, 0.51760125f, 0.01808442f, 0.06334262f, 0.35307139f, 
    -0.00039398f, 0.13142666f, 0.05887020f, -0.00317189f, 0.00865231f, -0.01302358f, -0.02580980f, 0.07078557f, 
    -0.35659015f, 0.23148671f, -0.12472564f, -0.02454605f, 0.06716888f, -0.01802979f, -0.05652063f, -0.00302828f, 
    -0.12619206f, -0.01665662f, -0.09053516f, 0.00028892f, 0.25902748f, -0.06614687f, 0.09054792f, -0.03345469f, 
    -0.04184759f, 0.06937028f, 0.15553567f, -0.04190592f, 0.15406899f, -0.04246055f, 0.03996886f, 0.08354636f, 
    0.04023233f, 0.07629008f, 0.12371595f, -0.08764748f, -0.14980085f, 0.01429536f, 0.12540321f, -0.09881932f, 
    -0.07791723f, 0.09037580f, 0.05876737f, 0.05354927f, -0.13506413f, 0.39100316f, 0.08148987f, 0.03806291f, 
    0.01522645f, 0.11197659f, 0.11889107f, 0.06278419f, 0.13984950f, 0.10012802f, -0.02487159f, 0.17741965f, 
    -0.14617401f, -0.22089908f, -0.02743523f, -0.22475752f, 0.00607190f, 0.09768403f, -0.10005556f, -0.10527109f, 
    0.02703617f, 0.03086809f, -0.07200395f, 0.03870559f, -0.05073673f, 0.10817642f, 0.05431094f, 0.14677806f, 
    0.05751373f, -0.04250474f, 0.02717296f, 0.00567866f, 0.13461034f, 0.08755231f, -0.12604612f, 0.20412636f, 
    -0.10553476f, 0.23418707f, -0.03578074f, 0.07586157f, 0.10886825f, 0.12772802f, -0.03746101f, 0.04597755f, 
    0.21427679f, 0.03087311f, 0.19981836f, -0.00560033f, 0.02202540f, 0.18088651f, -0.02595985f, 0.26057523f, 
    0.16318713f, -0.05780461f, -0.06205746f, -0.00172474f, 0.15023685f, 0.13622692f, 0.06095860f, 0.03409436f, 
    0.44678923f, -0.14090918f, -0.07041273f, -0.15511079f, 0.11721528f, 0.05110506f, -0.03135502f, 0.06882248f, 
    0.23103637f, 0.10008451f, 0.01169947f, 0.09435846f, -0.14210549f, 0.09719829f, -0.23800720f, -0.08224433f, 
    -0.12310436f, -0.06973150f, 0.08921826f, -0.05768536f, -0.03311205f, 0.06236029f, -0.01959685f, -0.00226212f, 
    0.12253498f, -0.11288995f, -0.04782263f, 0.08360930f, -0.05808307f, -0.09094584f, 0.02223420f, -0.04771100f, 
    -0.07276377f, 0.14440042f, -0.02092107f, 0.09919099f, -0.16972667f, 0.05535003f, 0.01661544f, 0.00223262f, 
    0.02171080f, 0.02262984f, -0.00941458f, 0.11932294f, -0.02501745f, 0.02839164f, 0.00623177f, 0.15890957f, 
    -0.33287612f, -0.04120016f, -0.00203515f, -0.05791184f, 0.03458810f, 0.08760070f, 0.03964299f, 0.10365188f, 
    0.03432978f, 0.15666614f, 0.03759707f, 0.13741618f, 0.06759055f, -0.17996518f, -0.11740901f, -0.13131419f, 
    -0.09010673f, 0.03003375f, -0.09344913f, -0.07695082f, 0.01427636f, 0.05825448f, 0.03667973f, 0.01994953f, 
    0.19753528f, -0.42280957f, 0.02988031f, -0.12423734f, -0.08363823f, -0.01273952f, -0.09933534f, 0.13388687f, 
    0.02516097f, -0.06595956f, -0.08860470f, 0.00397156f, 0.56362718f, -0.05952914f, 0.17455883f, 0.19387755f, 
    -0.09621529f, 0.02708557f, 0.02428566f, 0.17734849f, 0.03283564f, 0.15743485f, -0.01533942f, 0.10162687f, 
    0.07964046f, -0.18891603f, -0.13781694f, 0.01723063f, -0.18518566f, -0.11809234f, -0.00585337f, 0.02558663f, 
    0.00258499f, -0.02297102f, 0.03414435f, -0.03661986f, -0.02884727f, 0.11372438f, 0.10220604f, 0.13919590f, 
    0.12731320f, -0.00201420f, 0.06467486f, 0.03032308f, 0.14280473f, -0.09458417f, -0.04938971f, 0.17665987f, 
    0.07099152f, 0.06999826f, 0.07206908f, 0.07826412f, -0.15715411f, -0.16619998f, -0.00202827f, 0.00069751f, 
    -0.09948297f, -0.11443423f, -0.00825757f, 0.07726339f, -0.09298023f, 0.28159010f, -0.07666320f, 0.25039384f, 
    0.08237423f, 0.04933420f, 0.11565411f, -0.07268416f, -0.04567328f, -0.04435337f, -0.05761788f, -0.10625727f, 
    -0.05185054f, -0.14127156f, 0.05325149f, -0.18553382f, -0.04247872f, 0.07622889f, -0.10044544f, -0.01047334f, 
    -0.11616799f, 0.04336889f, -0.09399951f, -0.02331199f, 0.21707770f, 0.03195717f, 0.14054008f, 0.00055736f, 
    -0.16162471f, -0.03630156f, -0.02000374f, -0.02386782f, -0.05747959f, -0.05584574f, 0.04481147f, 0.04677809f, 
    0.07427493f, 0.35210937f, 0.03951178f, 0.08146197f, 0.21153469f, -0.07033832f, 0.01047385f, 0.10416184f, 
    0.05578731f, 0.01624296f, 0.04152272f, -0.08537541f, 0.22817107f, 0.14236400f, 0.10248861f, -0.01055037f, 
    -0.05254800f, -0.04587932f, -0.06790829f, 0.01054785f, 0.08648878f, 0.05823696f, 0.19172575f, 0.04597807f, 
    0.30564609f, -0.17482677f, -0.09244802f, 0.11204277f, 0.01709836f, -0.09480973f, 0.04405953f, -0.15729304f, 
    0.18067257f, 0.04989381f, 0.09276500f, -0.02010379f, 0.21599105f, -0.00399979f, -0.16962914f, -0.12821582f, 
    -0.11775532f, -0.07799616f, 0.05523927f, -0.00500015f, 0.01149025f, 0.07394641f, 0.07664696f, 0.02532051f, 
    0.05822976f, -0.14252527f, 0.06814355f, 0.21317993f, -0.05611591f, 0.00648249f, -0.10232182f, -0.00396589f, 
    0.04831069f, 0.10135370f, -0.08252653f, 0.11356913f, -0.12569898f, -0.03349703f, -0.06477904f, -0.10679802f, 
    -0.04395060f, -0.12205318f, -0.16387953f, 0.09025706f, 0.02141868f, 0.06236852f, 0.08657256f, -0.06409936f, 
    -0.08694685f, -0.13690050f, -0.15034308f, 0.27575287f, -0.08143088f, -0.02777741f, 0.07954083f, 0.04514802f, 
    -0.02981790f, -0.00581149f, -0.01306637f, 0.06126866f, -0.06791905f, -0.19370592f, 0.10901899f, 0.13374886f, 
    -0.08341586f, -0.07856788f, 0.03229678f, 0.12301106f, -0.03319981f, 0.03204584f, -0.00078277f, -0.13287669f, 
    -0.06130377f, -0.25983199f, 0.03325050f, -0.13166560f, 0.09629671f, -0.00753854f, -0.10190523f, 0.08479773f, 
    0.17764711f, -0.08990960f, -0.14399859f, 0.03703613f, 0.48103485f, -0.01900532f, 0.19460371f, -0.15048237f, 
    0.07290604f, 0.08478443f, 0.21042912f, 0.10389964f, 0.06294119f, 0.05339193f, 0.05691235f, 0.24392289f, 
    -0.36844942f, -0.17266263f, -0.19647308f, 0.00399993f, -0.12830375f, -0.03920903f, -0.07017688f, 0.00144428f, 
    -0.01784962f, -0.03422732f, 0.01076528f, -0.05077846f, 0.17163540f, 0.08622725f, 0.28466755f, -0.17233568f, 
    0.12026971f, 0.15485024f, 0.11064082f, 0.06822311f, 0.23381531f, -0.01442718f, 0.04906388f, 0.16623263f, 
    0.04449795f, 0.01781774f, 0.05565914f, -0.03913973f, -0.13504934f, 0.00897919f, 0.14537401f, 0.01359714f, 
    0.09860958f, -0.04020964f, 0.10508695f, 0.09587716f, 0.02602238f, 0.00381694f, -0.19340006f, 0.00645770f, 
    0.14173324f, 0.01350382f, -0.01458408f, 0.01415908f, 0.00209040f, 0.07187583f, 0.12164009f, 0.02242350f, 
    -0.64022636f, -0.18052623f, 0.10114465f, 0.11913571f, 0.01331381f, -0.02456677f, -0.06257393f, -0.08468889f, 
    0.05216041f, 0.06746834f, -0.09251868f, 0.15099485f, 0.14159162f, -0.06452341f, -0.00725052f, -0.09762491f, 
    0.13560440f, 0.11871500f, 0.03003921f, 0.03384732f, -0.01605059f, -0.13576457f, -0.11074936f, 0.19436339f, 
    0.18143930f, 0.17359464f, -0.22395496f, 0.07041516f, 0.16796145f, -0.02946466f, 0.09527797f, -0.11041398f, 
    0.12606722f, -0.13057153f, 0.17667694f, -0.00245447f, 0.65794218f, 0.16109003f, -0.06854371f, -0.14744039f, 
    -0.01028667f, -0.08945556f, 0.09341172f, 0.02684671f, -0.00584215f, 0.00088182f, 0.02375866f, 0.16073899f, 
    0.30905148f, -0.11806336f, -0.11091992f, -0.08994274f, 0.13864498f, 0.00379484f, 0.08543734f, -0.04243088f, 
    0.06558257f, 0.07028918f, -0.02924754f, -0.12946142f, -0.04792152f, 0.11550704f, -0.30026865f, -0.05577805f, 
    -0.06410863f, 0.04171523f, -0.15953977f, 0.20628300f, 0.08093669f, -0.00086491f, 0.05240579f, 0.07883549f, 
    -0.02910410f, -0.15205900f, 0.04776642f, -0.02124213f, -0.12782450f, 0.06947891f, -0.09289137f, 0.06452975f, 
    -0.11855389f, -0.00414801f, -0.04102974f, -0.03595664f, 0.08227120f, 0.07790615f, 0.10898083f, 0.15291807f, 
    -0.00678023f, 0.04450078f, -0.12748981f, -0.11629714f, 0.13463131f, 0.19444516f, 0.06177936f, 0.02413721f, 
    -0.01695266f, 0.03010473f, -0.00673019f, 0.06097105f, 0.11851707f, -0.07850346f, -0.02738302f, 0.03020260f, 
    0.04432518f, 0.28797540f, -0.04286899f, -0.06035644f, 0.18276069f, -0.03294724f, 0.15869169f, -0.10182536f, 
    -0.04623231f, -0.04699381f, -0.11560681f, -0.07824276f, -0.11345255f, -0.08951568f, -0.03546786f, -0.00477758f, 
    -0.08438616f, -0.07327865f, 0.05918719f, 0.06034494f, 0.11762566f, 0.01505136f, -0.09483764f, -0.05909530f, 
    -0.01534801f, 0.15326260f, 0.01773076f, 0.05303930f, -0.07182898f, -0.25586036f, -0.14958377f, -0.00803851f, 
    0.02654675f, -0.02785667f, -0.00533700f, -0.04200974f, 0.06631309f, -0.03795242f, -0.08637441f, -0.02482145f, 
    -0.04826004f, -0.04930343f, -0.21222167f, -0.07094949f, 0.05240344f, -0.02166455f, 0.07936514f, 0.01491575f, 
    0.11759375f, 0.06798955f, -0.12342622f, -0.21949109f, 0.35530561f, 0.04017896f, -0.07892519f, -0.02987036f, 
    0.05997857f, 0.00585482f, 0.01766044f, 0.01511576f, 0.09107816f, 0.06429933f, 0.10286688f, 0.03669584f, 
    0.00334187f, -0.04826886f, -0.02943233f, 0.06090352f, 0.01076179f, 0.03147846f, -0.10284626f, 0.04773698f, 
    0.04614877f, 0.06666873f, -0.05728100f, 0.01301144f, 0.10674333f, 0.10372251f, -0.00618879f, -0.27648771f, 
    0.02343911f, 0.07887992f, -0.07122735f, -0.00599780f, 0.06659457f, 0.04170906f, -0.01809200f, 0.05612209f, 
    -0.16006635f, -0.03903271f, -0.06801482f, 0.11586268f, -0.04207185f, -0.05583461f, 0.00699206f, 0.00389352f, 
    0.09391281f, -0.03885157f, -0.02409713f, 0.03658075f, 0.06529239f, 0.01305388f, -0.05480995f, -0.15747541f, 
    0.00651711f, 0.18638791f, -0.01717186f, 0.14379576f, 0.19746912f, -0.01084311f, 0.03914928f, 0.03530424f, 
    0.10938896f, -0.04363428f, -0.12980992f, -0.27319697f, 0.01784978f, 0.18149641f, -0.02220236f, -0.01157717f, 
    0.04380623f, 0.11632156f, -0.09578298f, -0.00687256f, -0.34462890f, 0.14633943f, 0.16044377f, 0.29106086f, 
    0.09080363f, 0.03803097f, 0.18880975f, 0.00717888f, 0.02177052f, 0.06464816f, -0.05837474f, 0.09605893f, 
    -0.23977649f, 0.06511728f, 0.20946415f, -0.29154179f, 0.12229922f, 0.08688964f, 0.05672837f, 0.04913110f, 
    -0.08485240f, -0.02362021f, -0.10061683f, 0.12988719f, -0.08968372f, -0.14415100f, -0.12194399f, 0.13821338f, 
    0.08857713f, 0.05153349f, 0.12502041f, 0.03278279f, -0.00766120f, -0.13192146f, 0.07893982f, 0.00627950f, 
    0.13396348f, 0.22222920f, -0.10584840f, -0.02196572f, -0.02174463f, -0.07941242f, 0.09071836f, 0.01306776f, 
    -0.11796020f, 0.01539885f, 0.00655122f, 0.03081637f, 0.72694004f, -0.07569616f, -0.10242324f, 0.07776569f, 
    0.04750501f, 0.05767549f, 0.05086651f, 0.03601082f, -0.00175142f, 0.01014966f, 0.05653101f, 0.08079877f, 
    -0.05100812f, -0.05578207f, -0.02318937f, -0.18560179f, 0.19360273f, 0.13576707f, 0.02867456f, 0.05194931f, 
    -0.00974336f, 0.12534168f, 0.01459876f, 0.01360641f, 0.07267407f, -0.22367261f, -0.11137934f, -0.14499457f, 
    -0.10156737f, -0.16912939f, -0.01756491f, 0.02207791f, -0.05638001f, -0.02355915f, -0.07382468f, 0.04126711f, 
    0.04626296f, 0.21907012f, -0.05352712f, -0.06405199f, 0.03805505f, 0.00128239f, -0.09909887f, 0.07347982f, 
    0.07180147f, 0.03070746f, -0.02772095f, 0.00585061f, -0.41135982f, 0.14351341f, -0.07355980f, -0.39819723f, 
    -0.01436251f, 0.02369208f, 0.04145414f, 0.05098595f, 0.07635909f, 0.00596118f, 0.04038183f, 0.11723734f, 
    0.39301547f, -0.46211573f, -0.24804048f, -0.12526193f, 0.00191373f, -0.07069757f, 0.03619131f, -0.10471928f, 
    0.14801978f, 0.07433043f, 0.07353488f, -0.01126708f, -0.37112525f, 0.21070413f, 0.19137897f, 0.06775621f, 
    -0.01575141f, 0.04946510f, 0.04318275f, 0.02711806f, -0.06982537f, -0.00684438f, -0.04734638f, 0.08845111f, 
    -0.01014645f, 0.03189332f, -0.01037183f, 0.02569607f, 0.15735295f, -0.16143106f, -0.03733748f, 0.06143383f, 
    -0.02678663f, -0.04886691f, 0.00097183f, 0.08634900f, -0.16103640f, -0.02626953f, 0.17807935f, -0.05602510f, 
    0.22030696f, 0.13509637f, -0.03060902f, -0.03162766f, 0.02790102f, 0.08687571f, 0.01119567f, -0.37313855f, 
    0.31786504f, 0.25817508f, 0.09005253f, 0.13748224f, 0.01805489f, 0.04514589f, 0.06343210f, 0.07142702f, 
    -0.07761874f, 0.06929507f, 0.00060496f, -0.06206757f, 0.01377671f, 0.07528077f, 0.12505473f, -0.01299579f, 
    -0.03264457f, -0.02709916f, -0.02328839f, -0.00052962f, -0.06512387f, -0.08556062f, 0.06366580f, -0.44237062f, 
    -0.25823170f, -0.20255916f, 0.34638605f, -0.02001628f, 0.05580763f, 0.00410064f, 0.05534539f, 0.06440794f, 
    -0.06048481f, 0.08943383f, -0.24770591f, 0.15575491f, -0.23707575f, -0.08028673f, 0.10797206f, 0.21912298f, 
    -0.11275597f, 0.10363541f, 0.12401732f, 0.14904469f, -0.01194285f, -0.02931456f, 0.04096473f, -0.13096701f, 
    0.00684495f, 0.15717763f, 0.01073188f, 0.32494998f, 0.02619602f, 0.05404613f, 0.07137570f, 0.12286169f, 
    -0.12430169f, -0.05610257f, 0.00600360f, 0.06995077f, 0.00540782f, 0.02710862f, 0.20548700f, 0.06522693f, 
    0.23735094f, 0.00578962f, 0.07945214f, 0.02946978f, 0.03843519f, -0.01243382f, 0.00880473f, 0.11848089f, 
    -0.04419439f, 0.13307241f, -0.05933492f, -0.13016677f, 0.12091660f, -0.05734788f, -0.01989658f, 0.08933961f, 
    0.01621071f, -0.01666351f, -0.00030149f, 0.07963654f, 0.15255935f, -0.07528883f, -0.15454900f, -0.02134500f, 
    0.09750327f, -0.22963016f, 0.06502773f, 0.00410714f, -0.05491650f, -0.17635685f, -0.07433545f, -0.19061773f, 
    0.08682065f, -0.13471204f, -0.08363916f, 0.23372176f, 0.05953426f, -0.05667733f, -0.01373490f, -0.04877135f, 
    0.01416589f, -0.13841820f, 0.02284990f, -0.16695838f, -0.30391705f, -0.09055659f, -0.10306061f, 0.06840311f, 
    -0.01905293f, -0.06435469f, 0.03686564f, 0.04845097f, -0.03337548f, 0.16806282f, -0.00884322f, 0.12325316f, 
    -0.02497167f, 0.26060200f, -0.07223567f, 0.04953891f, -0.01400964f, 0.15401264f, -0.03628821f, -0.04444933f, 
    0.12043057f, -0.20887777f, 0.09830238f, -0.00692063f, -0.27394396f, 0.32171261f, 0.03965982f, -0.38951492f, 
    0.01765782f, 0.02757891f, 0.15990154f, 0.04584893f, 0.01817962f, 0.09860313f, 0.12790844f, 0.16148593f, 
    -0.29144987f, -0.16833135f, 0.15817586f, 0.00768592f, -0.00519655f, 0.12574223f, -0.02945506f, 0.03750980f, 
    -0.00355058f, 0.04806705f, 0.19326891f, 0.13051890f, 0.02596295f, 0.11092222f, 0.05361072f, 0.05343414f, 
    0.03819843f, 0.20170639f, 0.14859825f, 0.05340388f, -0.05836768f, 0.04581610f, 0.07366802f, 0.16321851f, 
    0.02129069f, -0.06684636f, -0.02224838f, 0.00122009f, 0.02200226f, -0.07114206f, -0.07173555f, -0.01627985f, 
    -0.07526947f, -0.04838888f, -0.02905098f, -0.04396630f, -0.04494231f, -0.04607674f, -0.02733089f, 0.03341928f, 
    -0.00089993f, 0.06576277f, -0.07356626f, -0.04224302f, -0.05355714f, 0.02887805f, 0.05768199f, -0.03983915f, 
    -0.06861866f, 0.05757084f, 0.05888070f, 0.00074256f, 0.01740345f, 0.02111041f, -0.04248535f, 0.04977790f, 
    -0.07344940f, 0.00215621f, -0.05532117f, -0.05393276f, -0.06689465f, 0.06465603f, -0.03416383f, -0.03779041f, 
    0.01664980f, -0.03812832f, -0.06325883f, -0.06726180f, 0.04197567f, 0.04900229f, -0.07267244f, -0.01002139f, 
    0.02147820f, 0.04576046f, 0.00227207f, -0.02789489f, -0.01754817f, -0.06904643f, -0.00299825f, 0.02507561f, 
    0.01400819f, 0.01505304f, 0.05851329f, 0.05936595f, -0.04822401f, -0.03649207f, -0.01780873f, 0.06110441f, 
    -0.03658729f, -0.02567788f, 0.00078012f, -0.04009251f, 0.01840549f, 0.02577258f, 0.06436777f, 0.05536838f, 
    0.00642533f, 0.01344580f, -0.07073123f, 0.06359473f, 0.00657579f, -0.05740105f, 0.03630885f, -0.06270386f, 
    0.02547777f, -0.05354328f, 0.02488090f, -0.01909511f, 0.04909834f, -0.01455791f, 0.03365897f, 0.05200380f, 
    0.00886864f, -0.01993394f, 0.00738047f, 0.05081414f, -0.04284068f, 0.03152922f, -0.03649616f, 0.00890639f, 
    0.00237180f, 0.02270069f, 0.00406120f, 0.04717530f, 0.03163804f, -0.04957183f, 0.01394370f, -0.04967755f, 
    -0.02334588f, -0.01447737f, 0.02616479f, 0.00640738f, -0.00782251f, -0.00064523f, -0.06094101f, -0.01700025f, 
    0.03477427f, -0.01784020f, -0.02059595f, -0.02491255f, -0.01373064f, -0.06250537f, 0.01130809f, -0.06080677f, 
    -0.07074656f, 0.03458347f, 0.01989392f, -0.06990349f, -0.05690131f, 0.01688289f, 0.00598503f, 0.03479074f, 
    -0.05949388f, -0.02710455f, -0.02450198f, 0.01387652f, -0.03602317f, -0.04007949f, 0.05589071f, -0.01676504f, 
    0.05096390f, -0.06644434f, -0.02370095f, 0.03119630f, -0.02716168f, -0.01285023f, 0.05420376f, 0.04476264f, 
    0.00636053f, -0.04315590f, 0.01488668f, -0.06505030f, 0.00378034f, 0.03088121f, 0.03190001f, -0.03505202f, 
    0.01416270f, -0.05348578f, -0.04535618f, 0.00486452f, 0.06440914f, 0.02320242f, 0.04618880f, -0.02355045f, 
    0.05144585f, 0.02141549f, 0.01514951f, 0.02496706f, -0.05803359f, 0.04077499f, 0.00767068f, -0.04736184f, 
    0.05761237f, -0.04877314f, 0.04920356f, -0.02247054f, -0.02221957f, -0.00481808f, -0.00287446f, -0.06748419f, 
    -0.01659835f, -0.03150215f, 0.01422194f, 0.00398781f, -0.07240074f, -0.02208422f, 0.00397165f, -0.03619718f, 
    0.02840141f, 0.03355761f, -0.01992493f, -0.05939900f, -0.02043376f, -0.05511932f, -0.06574316f, -0.03813479f, 
    -0.07471478f, 0.01981458f, -0.05341877f, -0.03220451f, -0.00540894f, -0.06836813f, 0.06321616f, -0.01587021f, 
    -0.04878726f, -0.07563319f, -0.06897143f, 0.04519183f, -0.05355431f, -0.01728006f, -0.07708769f, -0.01353253f, 
    0.02325617f, 0.04727581f, 0.05564152f, -0.02601019f, 0.01597739f, 0.00493251f, 0.04824543f, 0.01492620f, 
    0.01197907f, -0.07282296f, -0.06113926f, -0.06628982f, -0.04610354f, -0.05277481f, -0.02796519f, -0.05662275f, 
    0.03729994f, 0.04182094f, 0.00232696f, -0.06951926f, 0.00861984f, -0.06680898f, 0.05385274f, 0.03530715f, 
    0.00414441f, -0.06648320f, 0.00370514f, 0.04087333f, -0.03352908f, 0.04800701f, -0.03173940f, 0.02846667f, 
    -0.01398466f, -0.02559312f, 0.02411965f, 0.06049265f, -0.01350177f, -0.02908403f, -0.01986137f, 0.05682246f, 
    -0.03724180f, 0.00868684f, -0.04985613f, 0.01771447f, -0.06496724f, -0.03382193f, -0.00560192f, -0.03391271f, 
    0.00423596f, -0.01232746f, -0.02754045f, 0.00394150f, -0.05331595f, -0.01202263f, 0.00297405f, -0.00217853f, 
    0.05737284f, -0.03805052f, -0.01877875f, 0.00310884f, -0.06115216f, -0.07882230f, 0.02604073f, 0.02712397f, 
    -0.06251763f, 0.05136772f, -0.04166300f, 0.01980367f, -0.07882538f, 0.01984737f, 0.01484344f, -0.03536564f, 
    -0.02355848f, 0.00461615f, -0.01301562f, -0.07095810f, 0.02559485f, -0.02509201f, -0.00537644f, 0.03521489f, 
    -0.02020411f, 0.02242947f, -0.04077701f, -0.03535569f, -0.06253888f, -0.02574924f, -0.01726120f, -0.01111860f, 
    -0.05214123f, 0.00924529f, 0.05412627f, -0.01790982f, -0.04936954f, 0.02489645f, 0.02183355f, -0.06673697f, 
    -0.03396232f, -0.05032199f, -0.01630764f, 0.01031905f, -0.00372926f, -0.07536413f, 0.06328432f, 0.01017101f, 
    0.01461867f, -0.02580125f, -0.02117309f, 0.04502413f, 0.05131572f, 0.02988169f, 0.00991360f, -0.03014409f, 
    -0.03028410f, -0.01128607f, -0.07817605f, 0.02916180f, -0.06406827f, -0.01263346f, 0.01532746f, 0.05152222f, 
    0.01987211f, 0.05071095f, -0.07333622f, -0.04569510f, -0.00909350f, -0.07050548f, 0.04604667f, -0.06140456f, 
    -0.01304440f, 0.00598265f, -0.04912130f, -0.00573594f, -0.00128124f, 0.04349890f, 0.03971445f, -0.06267408f, 
    -0.02113402f, 0.03047063f, -0.07811388f, 0.05337647f, 0.01284333f, -0.02402594f, -0.07668438f, 0.01666529f, 
    -0.04718907f, 0.03952866f, 0.04900973f, -0.06940041f, -0.04271698f, -0.07382995f, 0.02120316f, -0.00648019f, 
    -0.06611630f, -0.03451916f, 0.03572677f, 0.00586605f, -0.06036994f, 0.00977630f, -0.04952664f, -0.06588675f, 
    0.05713363f, 0.00209861f, -0.00760488f, -0.05050587f, -0.05503091f, -0.06211604f, -0.03125505f, 0.02977850f, 
    0.00694767f, 0.02162577f, 0.03393030f, 0.04247707f, 0.02552596f, -0.02139060f, -0.06518357f, -0.00352241f, 
    0.04712933f, -0.06487922f, 0.01193315f, -0.18129717f, -0.14707969f, 0.16500533f, 0.03384270f, -0.01364204f, 
    0.00962601f, 0.22081622f, 0.08789238f, -0.00086837f, 0.16296533f, 0.22945043f, -0.03995764f, 0.17577633f, 
    0.04268157f, -0.05675659f, 0.03309647f, 0.06420678f, 0.07023966f, 0.09738190f, -0.02439446f, 0.18954919f, 
    -0.02587389f, -0.09185231f, -0.10260244f, -0.21687916f, 0.06196808f, -0.04621546f, -0.03890272f, -0.09412748f, 
    0.13265778f, 0.07427244f, 0.01108122f, 0.04782907f, -0.14909917f, -0.03725974f, -0.20717724f, 0.18409707f, 
    0.07199346f, -0.03293400f, 0.09144924f, 0.10783494f, 0.13603641f, 0.02404209f, 0.10050127f, 0.35517865f, 
    -0.02233258f, 0.08907064f, -0.20567113f, 0.24533725f, 0.14568581f, 0.00607767f, -0.11273459f, -0.16118455f, 
    0.00880614f, 0.01971796f, 0.22747226f, 0.03441132f, 0.01875775f, -0.00482703f, -0.30538854f, 0.01798805f, 
    0.08897012f, 0.06067310f, -0.08379130f, 0.00542812f, 0.23884870f, 0.12225349f, -0.11854036f, 0.15822652f, 
    0.13803944f, -0.06426010f, -0.12972561f, -0.17378630f, 0.06835406f, 0.00495575f, -0.07809865f, -0.14411734f, 
    0.19534896f, 0.08678883f, 0.00818722f, -0.08937535f, -0.14554188f, 0.10250950f, -0.07090679f, -0.21852545f, 
    -0.19686012f, -0.01745337f, 0.04603552f, -0.12467725f, 0.06484140f, 0.08155422f, -0.01206091f, 0.14813794f, 
    0.08622517f, -0.01838955f, -0.02740265f, -0.07436582f, -0.11301798f, -0.16738310f, 0.01712139f, 0.10698984f, 
    0.06821423f, 0.06819978f, 0.19914438f, -0.11409580f, -0.15371734f, 0.02036607f, 0.25062054f, 0.07937300f, 
    -0.04166137f, 0.07511187f, -0.02857328f, 0.05410755f, -0.06843153f, 0.07900888f, -0.00387933f, 0.11065742f, 
    0.12868677f, 0.31628308f, 0.14109941f, -0.23854913f, 0.13300328f, 0.13994165f, 0.01705734f, -0.06776746f, 
    0.16895881f, 0.10570867f, -0.00226923f, 0.11081117f, 0.22572897f, 0.10814840f, 0.03745518f, 0.00544734f, 
    -0.13150446f, 0.00317363f, -0.08514531f, -0.09751219f, -0.09689562f, -0.29065809f, -0.06712011f, -0.13582143f, 
    0.32101882f, -0.31933305f, 0.24793515f, 0.08035024f, -0.00185200f, -0.00149219f, 0.13177115f, 0.03849328f, 
    -0.00081661f, 0.18075666f, 0.04818645f, -0.02707430f, -0.12289476f, -0.45214927f, -0.25482467f, 0.14610328f, 
    0.14160047f, -0.13030775f, -0.10110190f, 0.07593745f, 0.00166954f, 0.10581753f, -0.11576788f, -0.05937964f, 
    0.30092961f, 0.02091335f, -0.06504525f, 0.10006756f, -0.08166141f, -0.13704705f, 0.25158012f, 0.03756913f, 
    0.00945526f, -0.08256175f, -0.04450673f, -0.08800034f, 0.00522715f, -0.03125489f, -0.12431552f, 0.18539910f, 
    0.10890041f, -0.07345294f, -0.11104684f, 0.05044591f, 0.05099508f, 0.00933712f, 0.11193492f, -0.02105197f, 
    -0.16272680f, 0.06463224f, 0.09857346f, -0.16131753f, -0.20652419f, -0.03057528f, -0.01821574f, 0.05099656f, 
    -0.04206090f, 0.01620090f, -0.21144107f, 0.04878243f, -0.10467278f, 0.08729590f, 0.04629086f, -0.09741390f, 
    0.12418877f, 0.05758436f, 0.07723211f, -0.02204659f, 0.04250896f, -0.01407670f, -0.08052109f, -0.33077618f, 
    0.33093742f, 0.16486190f, -0.13495159f, -0.26692197f, 0.06265524f, 0.07398090f, -0.12711608f, 0.16044606f, 
    0.13806823f, 0.04477295f, 0.08674924f, 0.04717605f, 0.18848543f, 0.19485852f, -0.03069731f, 0.14987956f, 
    -0.07871069f, 0.04198871f, 0.03322404f, 0.04436782f, -0.12897405f, -0.10010696f, -0.13881259f, -0.17987925f, 
    0.02792657f, 0.18642540f, 0.13503775f, 0.26834628f, 0.01309372f, 0.08990265f, -0.04303201f, -0.04518588f, 
    -0.12330519f, 0.06718595f, -0.12580827f, 0.07342171f, -0.09121150f, 0.05426766f, -0.16258816f, -0.19563311f, 
    -0.08123049f, -0.11562809f, 0.13372314f, 0.09700784f, -0.18537337f, -0.02652598f, 0.05372620f, -0.08060421f, 
    0.43173131f, 0.01444915f, 0.03044160f, -0.25028285f, 0.09849475f, -0.13812165f, 0.03194988f, 0.05485691f, 
    -0.06023623f, 0.05568225f, -0.01094912f, 0.05369252f, -0.09764608f, 0.34376213f, 0.02681273f, -0.22915332f, 
    -0.13385829f, 0.04866173f, 0.02604789f, -0.04002231f, -0.06913215f, -0.04506382f, 0.04252923f, -0.03290771f, 
    0.28288528f, 0.03075891f, 0.21376653f, -0.15614250f, -0.05613144f, -0.16583072f, -0.07469720f, 0.17578670f, 
    -0.00156759f, -0.10455861f, -0.09887549f, 0.10476208f, 0.41723236f, 0.09509369f, 0.04334771f, 0.14583972f, 
    0.03492602f, 0.04450596f, -0.16363131f, 0.08369795f, -0.04568152f, 0.04361236f, -0.06988652f, -0.00483762f, 
    -0.21474582f, -0.04596929f, 0.00874081f, -0.12374549f, 0.06599299f, 0.00881549f, 0.02826736f, -0.01544460f, 
    0.20535235f, -0.12613845f, -0.05009606f, -0.10452758f, 0.22099507f, 0.09862494f, 0.23617721f, 0.04628513f, 
    0.07176019f, -0.04459817f, 0.04228735f, 0.26753956f, -0.09512538f, 0.02827680f, -0.07545145f, -0.01409147f, 
    -0.07182124f, -0.34476981f, 0.24955599f, 0.19145381f, 0.14428207f, 0.06798207f, -0.13123420f, 0.02315234f, 
    -0.06513317f, 0.07162551f, 0.00158937f, -0.11463019f, 0.33897421f, -0.23760629f, 0.01626272f, 0.44519308f, 
    0.00796757f, -0.02052440f, 0.17665918f, 0.24014145f, -0.02652744f, 0.14365636f, 0.18799326f, -0.08561167f, 
    0.18200631f, -0.03090291f, 0.12690204f, 0.02089120f, -0.06255208f, -0.08261225f, 0.03828911f, 0.11584131f, 
    -0.02894376f, 0.13770789f, 0.08607765f, 0.14668964f, 0.08272395f, -0.02655926f, -0.03752488f, 0.09644723f, 
    -0.19658612f, -0.01321190f, 0.15572362f, 0.05609088f, 0.09242454f, 0.01384601f, 0.04531129f, -0.02978224f, 
    -0.11358768f, -0.01263784f, 0.11156365f, -0.18328425f, 0.04820391f, 0.14827076f, 0.03291385f, 0.01433812f, 
    -0.01826043f, 0.08740921f, -0.05710031f, -0.00254455f, -0.27566448f, 0.04533605f, -0.13794887f, -0.35915303f, 
    0.00684475f, 0.06865051f, 0.07682502f, -0.05681880f, 0.02404904f, 0.09514763f, -0.03437760f, 0.26129594f, 
    -0.09888463f, 0.08156653f, -0.07172438f, -0.06158866f, 0.02397318f, -0.02515942f, -0.04842566f, 0.00743456f, 
    -0.05017550f, -0.00391559f, -0.10944010f, -0.07797843f, 0.10842270f, 0.09991241f, -0.06774648f, 0.12395009f, 
    0.03323291f, 0.04442275f, 0.03820954f, -0.07791620f, 0.13266328f, 0.11496916f, -0.13443308f, -0.00861723f, 
    0.17121600f, 0.21501610f, -0.04681079f, 0.05824005f, -0.03530897f, 0.08050495f, 0.00620575f, 0.00979539f, 
    0.15752146f, 0.03102159f, -0.02993410f, -0.05680900f, -0.27829540f, 0.23334223f, 0.00022977f, 0.18116181f, 
    0.12947918f, 0.01103914f, 0.07626603f, -0.11130287f, -0.14637040f, 0.04355951f, 0.17483144f, 0.10772103f, 
    -0.00122466f, -0.02158229f, -0.00751377f, -0.36201179f, 0.15575859f, -0.06465220f, 0.01793743f, 0.00483058f, 
    -0.15374477f, 0.18568580f, 0.00793052f, -0.03528004f, -0.02880343f, -0.08168448f, -0.38214639f, -0.13549057f, 
    0.06298316f, 0.12216487f, 0.07301465f, 0.13500799f, -0.02095032f, 0.00519863f, -0.07375542f, -0.03125083f, 
    0.17834629f, 0.30512318f, 0.08490817f, 0.08376312f, -0.13949767f, -0.14692351f, 0.06003924f, 0.10185088f, 
    -0.11275315f, 0.08654033f, -0.02835039f, 0.08854250f, 0.64095962f, -0.06551631f, -0.05499670f, 0.14797141f, 
    -0.08508320f, -0.00569679f, -0.08568882f, 0.01140023f, -0.01190683f, -0.01559848f, -0.17438793f, 0.09574804f, 
    -0.33830944f, -0.01735725f, 0.00565950f, -0.25648716f, 0.14745945f, 0.15958463f, 0.08213224f, 0.08336502f, 
    0.04876864f, 0.04069983f, 0.00862906f, 0.05462536f, 0.14991553f, 0.14054477f, 0.13460338f, -0.04030464f, 
    0.15419866f, 0.06607234f, -0.07615608f, 0.07340077f, -0.01653536f, -0.03510869f, 0.01382925f, -0.03916543f, 
    -0.20512024f, -0.10868517f, -0.02432405f, -0.14733738f, 0.02732865f, -0.06305772f, -0.05357918f, 0.00978533f, 
    0.01113074f, -0.07876252f, -0.17091964f, -0.04500392f, 0.41110745f, 0.09501594f, 0.21621366f, 0.34369555f, 
    -0.15191145f, 0.05686100f, 0.04849269f, 0.12475134f, -0.01007304f, 0.09265121f, -0.03668948f, 0.00499862f, 
    0.53954804f, -0.07387209f, 0.01441221f, 0.07997411f, -0.00522185f, -0.20638148f, 0.01942061f, 0.09955683f, 
    0.14395314f, 0.06522987f, 0.13317692f, 0.08923979f, -0.34472707f, 0.06463400f, 0.02622991f, 0.17567340f, 
    0.00634209f, -0.06456244f, 0.13869141f, -0.07636908f, -0.04042592f, -0.02702355f, -0.09629934f, 0.07393584f, 
    -0.03961889f, -0.04850505f, -0.00759105f, 0.02164674f, 0.05675639f, 0.02398174f, -0.07261975f, -0.04494216f, 
    -0.01007665f, 0.03229757f, 0.03957166f, -0.07520383f, -0.06507589f, 0.03891590f, -0.04926458f, 0.03739514f, 
    -0.07067199f, -0.06201861f, -0.04117054f, -0.03825973f, 0.00260205f, -0.01468955f, 0.00821021f, -0.03039851f, 
    0.00286737f, -0.05369797f, 0.01906364f, 0.04954494f, -0.07178650f, 0.03944054f, 0.01757324f, 0.03354201f, 
    -0.01038841f, -0.00715199f, -0.06573994f, -0.03682471f, -0.00595960f, -0.06616328f, -0.03258254f, -0.02705671f, 
    -0.04331979f, -0.07585406f, -0.07177152f, 0.06289141f, -0.02564049f, -0.05798650f, 0.00552433f, -0.00092496f, 
    0.01356804f, -0.02281469f, -0.00795899f, -0.04982213f, -0.01399584f, -0.06535497f, 0.04728623f, 0.04396325f, 
    0.04159765f, -0.05478896f, -0.05965339f, 0.04332162f, -0.01570634f, 0.01119377f, 0.03642654f, -0.07398517f, 
    -0.07365050f, 0.03860590f, 0.00248412f, -0.06948606f, -0.03083326f, -0.03491475f, -0.05655557f, -0.07741345f, 
    0.04436180f, -0.06402002f, -0.03706099f, 0.05932431f, -0.02835618f, -0.00591146f, -0.07088677f, -0.00821035f, 
    0.03831761f, -0.06485619f, -0.02820754f, -0.02110871f, -0.07037620f, 0.00307286f, -0.06572235f, 0.03644076f, 
    0.04528912f, -0.06313763f, 0.00163930f, 0.05876925f, -0.05985018f, -0.07510978f, 0.00866835f, -0.07709712f, 
    0.05051669f, -0.05731326f, 0.05347720f, 0.05464742f, -0.02967524f, -0.04662849f, 0.03410035f, 0.02098174f, 
    -0.05388653f, -0.01365286f, 0.04583358f, -0.06241731f, -0.00868424f, 0.04059072f, -0.07162452f, 0.04863119f, 
    0.06301055f, 0.03145985f, 0.03030581f, -0.05255252f, -0.04348274f, 0.00316153f, -0.06807076f, 0.02231602f, 
    -0.06419601f, -0.03098524f, 0.03282380f, 0.05255903f, 0.02154932f, -0.04681243f, 0.00798779f, 0.00420365f, 
    -0.02921072f, 0.01135816f, 0.04262778f, -0.00354417f, -0.02077987f, 0.03888532f, -0.04460716f, 0.00688705f, 
    0.02514234f, 0.05602222f, -0.05219101f, 0.01432772f, 0.01118068f, 0.04370660f, 0.04045045f, 0.00485231f, 
    -0.01241185f, 0.01630463f, -0.07675549f, -0.06601571f, -0.06325382f, -0.05943998f, -0.00279091f, -0.00866708f, 
    -0.07059451f, -0.05342737f, -0.00977806f, -0.03379608f, -0.03225216f, 0.02798969f, 0.03332446f, 0.05694035f, 
    -0.07672716f, -0.00731754f, 0.06671938f, -0.04480806f, -0.06260387f, -0.02182564f, 0.02292743f, 0.05033259f, 
    -0.04744230f, -0.04519420f, 0.04542556f, -0.06359810f, -0.02385523f, -0.06825794f, 0.05346349f, 0.02967945f, 
    -0.04956875f, 0.01899615f, 0.05950299f, -0.06593946f, 0.02106451f, -0.03238127f, -0.06891493f, -0.06550126f, 
    -0.01765884f, 0.03664324f, 0.05267786f, -0.00105161f, 0.00416232f, -0.04740119f, 0.01283631f, 0.02995812f, 
    -0.19809206f, -0.16126007f, -0.06163827f, 0.08699542f, 0.03306023f, 0.02276837f, -0.00807892f, 0.06904846f, 
    0.01483024f, -0.12864073f, -0.05004813f, -0.05870416f, 0.17831272f, -0.09455271f, -0.12765884f, -0.15200986f, 
    -0.17232731f, -0.11285729f, -0.14623062f, 0.14116669f, 0.01672210f, -0.06674433f, 0.07854537f, -0.10115155f, 
    0.40949646f, -0.16868253f, 0.02489678f, 0.05411269f, 0.02576596f, -0.00843690f, 0.02812397f, -0.07927769f, 
    0.13731195f, 0.01573262f, 0.34469163f, 0.08038521f, 0.17593566f, -0.11993748f, -0.12676902f, 0.09752053f, 
    0.16578154f, 0.12471634f, 0.03685409f, -0.02427738f, -0.06052274f, -0.11567720f, -0.03909355f, 0.03849854f, 
    0.27664867f, -0.03571897f, -0.20107304f, -0.05616758f, -0.10582159f, -0.00363329f, 0.03717268f, -0.11545830f, 
    -0.00807942f, -0.01311540f, -0.01791624f, 0.01498961f, 0.53909647f, 0.01093421f, 0.05269654f, -0.23219259f, 
    0.10555561f, -0.00628992f, -0.03359722f, -0.00911155f, 0.01111463f, -0.07551847f, -0.10939986f, 0.06229106f, 
    -0.03950418f, 0.26259640f, 0.10110446f, -0.09035499f, -0.02385311f, 0.12802491f, -0.04112472f, -0.00707159f, 
    -0.02828132f, -0.05140740f, -0.07758927f, -0.08977280f, 0.10656299f, -0.16814661f, 0.21632382f, 0.17801057f, 
    -0.10511900f, 0.02243743f, -0.17536584f, -0.06349207f, -0.06554938f, -0.07364336f, 0.12947215f, -0.08015946f, 
    -0.09877735f, -0.12150177f, 0.14636149f, -0.15008263f, 0.09008457f, 0.15015320f, -0.05406539f, -0.03908531f, 
    0.20096779f, -0.14411132f, -0.03935900f, 0.00669726f, -0.04209810f, -0.01993712f, 0.15858622f, 0.15809098f, 
    0.11809808f, 0.00720129f, -0.08624887f, -0.17060573f, 0.16794038f, 0.03682254f, 0.06128632f, -0.02609940f, 
    -0.01820969f, 0.07827957f, -0.11342330f, -0.20917891f, -0.11196300f, 0.03072549f, -0.07035317f, -0.01116873f, 
    0.01615086f, -0.19727330f, 0.08456361f, 0.06608377f, 0.22573565f, 0.12301364f, 0.24912845f, 0.03229000f, 
    0.10872105f, 0.10151482f, 0.10730856f, 0.09888541f, -0.02776982f, 0.04087816f, -0.01786031f, 0.14385344f, 
    -0.17013812f, 0.24675341f, 0.04090834f, 0.19119087f, 0.02792101f, -0.08354453f, 0.15229830f, -0.02524276f, 
    -0.02539121f, 0.17535329f, 0.26553994f, 0.07744160f, -0.14230710f, 0.17604095f, -0.24894358f, 0.18320012f, 
    0.16703901f, 0.01936326f, -0.04642842f, 0.09705748f, -0.00295133f, -0.06137935f, 0.15585096f, -0.13432418f, 
    0.07662278f, 0.02661075f, 0.32206428f, -0.03026894f, -0.03931860f, 0.09475407f, 0.14860368f, -0.11121115f, 
    -0.04997325f, 0.03465473f, 0.04269783f, 0.13688213f, 0.27230948f, 0.05037011f, -0.11248522f, -0.16389525f, 
    0.01638765f, -0.12287647f, -0.11678639f, 0.05321077f, -0.00776093f, 0.12681030f, -0.03156593f, -0.12693730f, 
    0.01595280f, -0.00665735f, -0.00776708f, -0.00575621f, 0.02705549f, -0.04485997f, 0.00293458f, 0.04327688f, 
    -0.06240788f, -0.01744460f, 0.03684923f, 0.04753198f, -0.04623578f, -0.01324123f, 0.05981835f, 0.03394335f, 
    -0.06749339f, 0.01861473f, -0.06610088f, -0.03751422f, -0.03404018f, -0.02486067f, -0.03876146f, 0.05623826f, 
    0.01311752f, 0.03647015f, 0.06099004f, -0.04117424f, -0.05905572f, -0.04528929f, -0.04657833f, 0.03023827f, 
    -0.00296396f, -0.07569230f, -0.01204891f, -0.04721344f, -0.04074326f, 0.01467143f, 0.02431899f, -0.00288566f, 
    -0.05751364f, -0.07220908f, 0.03474721f, -0.03260747f, 0.04558568f, -0.01927657f, -0.07719275f, -0.02504835f, 
    -0.07610796f, 0.03945873f, -0.05270860f, 0.05317854f, -0.02599415f, 0.01324964f, -0.05393969f, -0.01322494f, 
    -0.02213174f, 0.01944394f, 0.01030791f, 0.04807754f, 0.05392450f, -0.01277379f, 0.03822264f, 0.03068411f, 
    -0.03016426f, 0.01449627f, 0.03504728f, -0.08234242f, 0.02355061f, 0.03468658f, 0.01232942f, 0.01215104f, 
    0.00169207f, -0.06693758f, -0.07771322f, 0.00269431f, -0.08020733f, -0.07630195f, -0.07014236f, 0.02016705f, 
    -0.00607769f, -0.04586085f, -0.05841287f, 0.03328571f, 0.03557243f, 0.03759284f, 0.04426068f, 0.03612296f, 
    -0.02184223f, -0.06062474f, 0.03855248f, 0.05500115f, 0.00585994f, 0.05649958f, -0.02503896f, 0.04245306f, 
    -0.01846711f, 0.05466807f, -0.02945492f, -0.02091137f, -0.03811212f, 0.03241475f, -0.01415623f, 0.03970633f, 
    0.04260030f, 0.00365025f, -0.06289943f, -0.03465888f, -0.03028297f, 0.02405403f, 0.05981813f, 0.04769308f, 
    -0.03924779f, 0.05061370f, -0.08271885f, 0.05983518f, -0.00549607f, -0.05049038f, -0.00949208f, -0.07738932f, 
    0.03768288f, -0.04627767f, 0.05572861f, -0.04373997f, 0.02148270f, 0.03902202f, 0.04059088f, -0.03456594f, 
    -0.03951703f, -0.03280487f, -0.05529909f, -0.03502624f, 0.05511265f, 0.03667983f, 0.04030667f, -0.05900265f, 
    -0.01046911f, -0.02514759f, -0.07209446f, -0.00605358f, -0.04589740f, -0.03836918f, -0.04280136f, -0.03550494f, 
    -0.05047108f, 0.00122742f, -0.04907966f, -0.05298949f, 0.03446229f, -0.05219582f, -0.01923564f, -0.01602187f, 
    -0.03886497f, -0.06451658f, -0.02662249f, 0.03975415f, -0.01272902f, 0.03933703f, -0.05170277f, -0.01699690f, 
    0.00252595f, -0.05175258f, -0.04656427f, 0.04823546f, 0.03541207f, 0.00329465f, 0.03145030f, -0.01632918f, 
    -0.07650334f, -0.00522638f, 0.04427468f, -0.06962372f, -0.02466881f, 0.06277102f, -0.00620551f, -0.03917467f, 
    0.03186749f, -0.01539364f, 0.00529821f, 0.02534975f, -0.01611038f, 0.00702233f, 0.05089290f, -0.00642413f, 
    -0.00065199f, 0.04295103f, -0.00766462f, 0.01842684f, -0.04269718f, -0.01174886f, -0.01393036f, -0.04665677f, 
    -0.16991346f, -0.03930148f, 0.16193517f, -0.28597403f, -0.13775244f, 0.03434781f, 0.03542155f, -0.00784228f, 
    0.11734855f, 0.09164163f, 0.03499892f, 0.02745287f, -0.38026428f, -0.34750989f, -0.01498657f, 0.03123786f, 
    0.14127837f, 0.06053363f, 0.10332546f, -0.12602380f, -0.01555155f, 0.06665038f, 0.01537092f, 0.03689634f, 
    -0.48435986f, -0.01630113f, -0.06891814f, -0.16917852f, -0.11205816f, -0.13453758f, 0.05072334f, 0.09034215f, 
    0.07075651f, -0.07766562f, -0.27381492f, 0.10654638f, 0.11957652f, 0.21853520f, -0.03732696f, 0.03700997f, 
    0.14891347f, -0.03846211f, 0.12276411f, -0.06462005f, 0.03666717f, 0.04491775f, 0.03874473f, 0.09597427f, 
    0.30735409f, 0.15179949f, 0.11472712f, 0.18473922f, 0.20320870f, 0.04359363f, -0.06256927f, 0.06153785f, 
    0.03711460f, -0.00603968f, 0.11686689f, -0.05751343f, 0.40173453f, 0.05934778f, -0.05079411f, -0.06652900f, 
    0.19472422f, 0.01924242f, 0.15714803f, -0.15693200f, -0.07814718f, -0.05499327f, 0.18176872f, 0.08680806f, 
    -0.00342744f, -0.04183580f, -0.01926673f, -0.33746684f, 0.18234850f, -0.06603559f, 0.12257029f, 0.04871843f, 
    -0.15271130f, -0.00553734f, 0.01126735f, -0.07058492f, -0.17203563f, 0.04601876f, -0.36897221f, -0.08848818f, 
    -0.21005978f, 0.11196357f, 0.17443565f, 0.16577710f, 0.12838362f, 0.04835977f, 0.04012550f, 0.17393646f, 
    -0.14029843f, 0.11696923f, -0.05627621f, -0.01911183f, 0.00407402f, 0.01706138f, 0.08509655f, 0.13487081f, 
    -0.19340573f, 0.16238815f, 0.02919206f, -0.06985978f, 0.32189718f, 0.24769706f, -0.13101597f, 0.05043641f, 
    -0.07548244f, -0.06035351f, 0.01067324f, -0.00302877f, -0.03723583f, 0.03438530f, 0.01206805f, -0.07091683f, 
    -0.14811666f, -0.12793307f, 0.02317472f, -0.14520830f, 0.17942774f, -0.00717600f, 0.12151437f, 0.12998444f, 
    0.07438336f, 0.19214568f, 0.20364240f, -0.01620710f, -0.15149398f, -0.03307053f, 0.08077002f, -0.03184806f, 
    0.02583677f, -0.09413043f, -0.17302412f, 0.03693299f, 0.03791818f, -0.12869267f, 0.10735299f, -0.14519443f, 
    -0.24385631f, 0.24757586f, -0.11456612f, 0.21718465f, -0.00449603f, -0.02924410f, -0.08494652f, 0.13275845f, 
    -0.04608642f, 0.06471438f, -0.12839621f, -0.01772653f, 0.35920319f, 0.03610320f, -0.11599322f, 0.30676895f, 
    -0.11946581f, -0.03770280f, 0.02893188f, -0.12199914f, -0.00662377f, -0.03791830f, -0.03987734f, 0.04062902f, 
    -0.09453230f, -0.21102333f, -0.16100666f, 0.10452010f, 0.01976283f, -0.22357515f, -0.06149049f, 0.00713583f, 
    0.15352736f, 0.10144322f, 0.01797830f, -0.02008679f, -0.06299574f, 0.07257468f, -0.06103808f, 0.17933644f, 
    0.08993302f, -0.03456853f, 0.12874764f, 0.00476539f, 0.12665313f, -0.13077217f, 0.02652296f, -0.01287180f, 
    -0.09040356f, 0.04206004f, -0.02973938f, -0.18532695f, -0.10361757f, -0.02236401f, -0.11399920f, 0.02232766f, 
    -0.00659418f, 0.01810720f, 0.23056865f, 0.07492339f, -0.00184597f, -0.09591062f, -0.15623721f, 0.23798080f, 
    0.21559700f, 0.06598863f, 0.12032423f, -0.11485220f, -0.02363002f, 0.03572370f, 0.00358304f, 0.09133209f, 
    -0.10170139f, -0.20465399f, -0.08969270f, -0.32211557f, 0.09898799f, 0.03176031f, -0.06740617f, 0.04016225f, 
    -0.06679651f, 0.02995553f, -0.10333046f, -0.07331870f, 0.15346645f, -0.00377208f, 0.09894375f, 0.10587417f, 
    -0.08771907f, -0.03278113f, -0.14957626f, -0.03787607f, -0.15644123f, 0.08462019f, 0.21941932f, 0.11642686f, 
    0.15082137f, 0.18410930f, -0.01602272f, 0.28089350f, 0.22060972f, -0.02831918f, -0.11898470f, 0.02799683f, 
    -0.03059331f, -0.05669953f, 0.20365964f, -0.02089319f, 0.18857685f, 0.13799022f, 0.04088950f, -0.07037945f, 
    0.04023460f, 0.09841540f, -0.01595661f, -0.10586698f, 0.09658191f, 0.07142398f, 0.04137924f, -0.02341549f, 
    -0.00159096f, 0.01737321f, -0.19700807f, 0.22855067f, 0.04617076f, 0.05165178f, 0.16080908f, -0.14654776f, 
    0.14102052f, -0.02821271f, 0.15801638f, 0.05519475f, 0.15573211f, -0.04379486f, -0.19249085f, -0.23068261f, 
    -0.19009182f, -0.11844198f, -0.05576611f, -0.03467851f, 0.17531751f, 0.11060802f, 0.03212521f, 0.05145183f, 
    -0.18022101f, -0.15881023f, -0.17499569f, 0.03779283f, 0.08200079f, 0.06846187f, 0.08064025f, -0.16745649f, 
    -0.03423862f, 0.22942884f, 0.08468004f, -0.09384328f, -0.31222621f, 0.03819603f, 0.00775211f, -0.13712958f, 
    -0.10828369f, -0.03721654f, 0.03032788f, 0.00020531f, -0.00122815f, -0.06524853f, 0.12461179f, -0.16922410f, 
    0.23740412f, -0.04614897f, -0.12519307f, 0.08174505f, -0.11159334f, -0.07635536f, -0.05280542f, 0.04970989f, 
    -0.06692806f, 0.07762025f, 0.05151146f, 0.07212464f, -0.18896699f, -0.04551429f, 0.04268445f, 0.27791780f, 
    -0.07853997f, -0.03668290f, 0.03188611f, -0.12702242f, 0.00197672f, -0.08010393f, 0.07948077f, -0.08762164f, 
    -0.08795730f, -0.11677669f, -0.07764436f, -0.08370424f, 0.01344922f, -0.02555714f, -0.02598162f, 0.18789692f, 
    0.15414354f, 0.03232608f, -0.12611219f, 0.06716529f, 0.38318077f, -0.02187552f, -0.00338531f, -0.06050712f, 
    0.25125277f, -0.10812181f, 0.10627373f, -0.04004364f, 0.07197630f, -0.01362018f, 0.02657221f, 0.31609219f, 
    -0.37012458f, -0.04147376f, -0.14739823f, 0.12262487f, -0.11981111f, 0.14830817f, -0.07332237f, 0.09746951f, 
    0.02306849f, -0.10140336f, -0.07728922f, -0.09885848f, 0.01475262f, -0.07358278f, 0.06973158f, -0.06490806f, 
    0.09768221f, 0.16365428f, 0.01538931f, 0.02599693f, 0.19698511f, 0.07509628f, 0.01343357f, -0.03267214f, 
    -0.06206345f, -0.06268535f, -0.00553256f, -0.00817498f, -0.06111280f, 0.01229005f, -0.04027718f, 0.06218395f, 
    -0.03024156f, -0.08008276f, -0.02480430f, -0.03351627f, -0.04744208f, 0.05780308f, -0.07369439f, -0.00558311f, 
    -0.06194357f, -0.05881016f, 0.02367308f, 0.03931287f, -0.01415509f, -0.02982066f, -0.06576385f, 0.04509322f, 
    0.01691015f, 0.00485256f, -0.00877362f, -0.01080220f, 0.04316023f, -0.03962109f, -0.00340735f, 0.06127849f, 
    -0.03321322f, 0.01065228f, -0.01315439f, -0.00513082f, -0.05254950f, -0.05251525f, -0.01341566f, 0.00542838f, 
    -0.06654973f, -0.00511154f, -0.05709048f, 0.02626076f, -0.03709321f, 0.05613480f, 0.01315410f, -0.06980268f, 
    -0.06067926f, 0.02110546f, -0.03178519f, 0.05367960f, -0.02204910f, -0.06111255f, -0.05920925f, -0.07674605f, 
    0.05253538f, -0.08005781f, 0.03861059f, 0.01766017f, -0.02051711f, -0.02834369f, -0.00057240f, -0.02750491f, 
    -0.00639547f, 0.01392927f, 0.03958578f, -0.05716272f, 0.00331288f, 0.03315002f, -0.00004413f, 0.00093352f, 
    0.04134653f, 0.04957856f, 0.01097467f, -0.02378715f, 0.05356096f, -0.02830803f, -0.02610584f, 0.01654257f, 
    0.03781271f, 0.03148721f, -0.04871992f, -0.02903476f, -0.05955612f, -0.04914054f, 0.06044358f, 0.05865624f, 
    -0.07146621f, -0.00258752f, -0.00166270f, -0.06921501f, -0.03479167f, 0.04934131f, -0.01966636f, 0.05585102f, 
    0.04552652f, 0.04127525f, 0.04198305f, -0.07480989f, -0.00758381f, 0.03638586f, -0.01140435f, 0.00940688f, 
    0.04580269f, 0.00034168f, 0.02289334f, -0.02054306f, -0.06783359f, 0.06032194f, 0.05011865f, -0.05671718f, 
    0.01485317f, 0.00719246f, 0.02616800f, -0.03449332f, 0.05786763f, -0.07741445f, -0.00735769f, -0.02012609f, 
    -0.00314577f, -0.01339358f, 0.05312654f, 0.03965136f, -0.07373992f, -0.03697496f, -0.02632683f, 0.05361059f, 
    0.00242846f, -0.04399768f, -0.02785021f, 0.06142841f, 0.00362236f, -0.04894235f, -0.03574354f, -0.06212444f, 
    0.02783381f, -0.05738223f, 0.03464760f, 0.00948077f, -0.05588577f, -0.05602404f, -0.06796457f, -0.02065751f, 
    0.02780621f, 0.00058945f, -0.03549903f, -0.00481742f, -0.05858522f, 0.00031613f, 0.00422406f, 0.02982127f, 
    0.02920613f, 0.04303596f, 0.05765475f, -0.01177895f, -0.07150549f, 0.00260724f, -0.01442347f, 0.04282400f, 
    -0.01931456f, -0.05833979f, 0.06349860f, 0.01102027f, -0.00406985f, -0.07977660f, -0.03402106f, 0.02640706f, 
    0.05175209f, 0.01482676f, 0.02426316f, -0.06588763f, -0.01077524f, 0.06489091f, 0.05319009f, -0.01062550f, 
    0.04131630f, 0.00377083f, -0.05179078f, 0.01657636f, -0.05394377f, 0.05300587f, -0.02292731f, -0.06052151f, 
    -0.04340574f, 0.06095560f, -0.07955039f, 0.02936900f, 0.03362165f, 0.02792431f, 0.00278098f, -0.05508616f, 
    0.22726685f, -0.01873079f, -0.02670453f, 0.02800697f, 0.06853440f, 0.02412371f, 0.08083659f, -0.01462640f, 
    0.13376369f, 0.00836782f, 0.25658759f, -0.05236678f, -0.01456082f, -0.08133657f, 0.14302233f, 0.27985379f, 
    0.08365541f, -0.07292717f, 0.04380246f, 0.00475976f, -0.11713216f, 0.04022263f, 0.08511982f, 0.23014075f, 
    -0.48996887f, -0.16177554f, -0.01865700f, -0.07980452f, -0.03344301f, -0.05357792f, -0.00904457f, -0.01281033f, 
    -0.04212146f, 0.04311390f, -0.24308014f, 0.05902860f, -0.17308211f, -0.04849979f, 0.04832148f, 0.02860614f, 
    0.06731491f, 0.02757707f, -0.02439152f, -0.02773423f, -0.03213560f, 0.03711540f, 0.23521413f, 0.27657655f, 
    0.06003026f, -0.02793652f, -0.05716781f, 0.20381317f, 0.01427410f, -0.06590392f, 0.05042478f, 0.08782840f, 
    0.03715423f, -0.12060936f, 0.14835019f, -0.10039975f, 0.41894737f, -0.22222927f, 0.04142013f, -0.01265049f, 
    -0.00973270f, 0.12372223f, -0.01757914f, -0.06215185f, 0.04621083f, 0.02420700f, 0.05415525f, 0.01172294f, 
    -0.27326745f, -0.03202968f, 0.04889069f, 0.13939498f, 0.08710077f, -0.01162902f, 0.12733372f, -0.15206161f, 
    0.05576156f, -0.09839909f, 0.07378698f, -0.05213358f, 0.05561321f, -0.13404055f, -0.02645129f, -0.08759038f, 
    -0.12234930f, 0.07909829f, -0.01226949f, -0.02640748f, 0.26614937f, 0.09552865f, 0.03733400f, 0.07864025f, 
    -0.51285136f, -0.04179055f, -0.16425014f, 0.19456942f, 0.15294217f, 0.13895935f, 0.13963600f, -0.06282149f, 
    -0.01593382f, 0.18461952f, -0.03331214f, -0.13231999f, -0.39688146f, 0.27986646f, -0.12535478f, -0.13453311f, 
    -0.05464476f, -0.06340695f, 0.14559768f, -0.04336169f, 0.03405601f, 0.03062742f, 0.05886747f, -0.08574390f, 
    0.34281245f, 0.09468548f, 0.01271515f, 0.10077085f, 0.01707964f, -0.14456217f, 0.00147742f, 0.01487755f, 
    -0.13054651f, 0.15092814f, 0.03759547f, 0.07046516f, -0.09972444f, 0.02077205f, 0.08744760f, 0.23153543f, 
    -0.00779801f, 0.02149667f, 0.03926221f, -0.10801492f, 0.11409884f, -0.16922241f, 0.12355714f, -0.06058685f, 
    -0.05059236f, 0.32274538f, -0.09843277f, -0.18380089f, 0.04677299f, -0.04133630f, -0.00343988f, 0.01326195f, 
    0.05834240f, 0.04421088f, -0.06899019f, 0.19774528f, 0.11884677f, -0.02101633f, -0.01650982f, -0.02020373f, 
    0.00719855f, 0.02682412f, -0.00482644f, -0.12946205f, 0.08625609f, -0.03461032f, -0.03354821f, 0.07850506f, 
    -0.31724781f, 0.14584629f, -0.16710143f, 0.00022250f, 0.10429340f, 0.04705326f, -0.01382070f, -0.05382226f, 
    0.14686456f, -0.03621078f, -0.17042753f, -0.15680483f, -0.06647223f, -0.16177881f, 0.21851325f, 0.02774414f, 
    0.15063976f, 0.00161725f, 0.05246976f, -0.08069386f, 0.07280080f, -0.06409469f, -0.03596997f, 0.01193529f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.08490212f, -0.10494541f, 0.06409574f, 0.10266996f, -0.05036973f, -0.05217320f, -0.07770436f, -0.02747643f, 
    -0.05278544f, 0.13673986f, 0.04161059f, 0.01164913f, 0.01519006f, 0.06712390f, 0.05573685f, 0.07554443f, 
    -0.10081912f, 0.09505456f, -0.03662359f, -0.07173792f, 0.04984547f, 0.01944680f, 0.07000978f, -0.01184707f, 
    0.04584672f, 0.11528273f, 0.07538171f, 0.05731416f, 0.08851133f, 0.11433429f, 0.10175766f, -0.00824459f, 
    0.03031844f, -0.03731028f, 0.07628866f, 0.02653834f, 0.13522716f, -0.03020285f, -0.02132490f, -0.11402130f, 
    0.05921739f, -0.08842704f, 0.14719294f, 0.05685641f, -0.12365005f, -0.08249920f, -0.03170170f, 0.03499025f, 
    0.00883388f, 0.10503963f, 0.09170108f, 0.10473726f, -0.00778699f, 0.05954037f, 0.10016647f, 0.00546021f, 
    -0.00200217f, -0.00884638f, -0.10374794f, -0.02815074f, 0.11026154f, 0.12183525f, -0.04182249f, 0.15841261f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.43984371f, 0.17931108f, -0.05088570f, -0.22496997f, -0.04692918f, 0.11092646f, 0.10221682f, -0.02218020f, 
    0.21177471f, -0.44340834f, 0.05362298f, 0.02586211f, 0.15324742f, 0.08085180f, 0.09652455f, -0.33477423f, 
    0.03641166f, -0.07165585f, 0.27117240f, 0.04190372f, 0.03160878f, -0.24783672f, -0.13007954f, 0.03286861f, 
    0.00166307f, 0.02573565f, -0.02597048f, -0.81358051f, -0.13939889f, -0.32855657f, -0.24013439f, 0.40413454f, 
    -0.06654701f, 0.10027810f, -0.55717641f, -0.16072269f, -0.01636395f, 0.15817520f, -0.03415706f, 0.17438196f, 
    0.10571212f, 0.07498177f, -0.42429900f, -0.14417703f, 0.21199493f, 0.05433906f, 0.04332680f, 0.14211616f, 
    -0.22014953f, -0.14504239f, -0.30420598f, -0.31488347f, -0.03435040f, 0.09035652f, 0.08167727f, 0.25479844f, 
    0.07555058f, -0.00966953f, 0.37372181f, -0.02445660f, -0.34135860f, -0.62486213f, -0.06035477f, -0.51782745f, 
    0.02318283f, 0.10562393f, 0.04798444f, 0.01119704f, -0.03394348f, -0.01307654f, -0.12949876f, -0.25384021f, 
    0.11180884f, -0.06643666f, -0.25742212f, 0.32983521f, 0.28174788f, -0.03712737f, -0.20915970f, 0.12116133f, 
    0.24679850f, -0.29200703f, 0.25375366f, -0.42524683f, -0.21075685f, -0.35741812f, 0.07499546f, -0.02196432f, 
    0.02213366f, -0.20514658f, -0.27647617f, 0.33306581f, -0.38279632f, -0.31942984f, 0.19438331f, -0.01326577f, 
    0.02585898f, -0.19557393f, -0.47100809f, -0.26804426f, 0.24266566f, 0.09207574f, -0.11963080f, -0.17316771f, 
    -0.05003857f, 0.12189263f, -0.18571641f, 0.22831497f, -0.07199351f, 0.04800563f, 0.26761982f, 0.26015672f, 
    0.12889415f, 0.24689029f, 0.07744811f, -0.28595555f, -0.00044634f, -0.01145533f, -0.05684978f, 0.12741616f, 
    0.28453675f, 0.07442021f, -0.37166300f, 0.01856467f, 0.33757088f, 0.08175034f, 0.00929532f, 0.12128486f, 
    0.03236558f, -0.12759803f, 0.03193125f, 0.04542514f, 0.10782123f, -0.09468465f, -0.62964833f, 0.36392492f, 
    0.14334996f, 0.27233401f, -0.41096205f, 0.19661905f, 0.10509237f, 0.03066667f, -0.51372856f, -0.59767228f, 
    -0.36453649f, 0.26525033f, 0.17246343f, -0.10031444f, 0.03852595f, 0.24293025f, 0.20221601f, -0.02775470f, 
    -0.11006863f, -0.01767020f, 0.17162789f, -0.49265850f, 0.02739618f, -0.18226175f, 0.25297138f, -0.19253629f, 
    -0.10359367f, 0.14013204f, -0.13136685f, -0.42210099f, 0.13604596f, -0.14990731f, 0.07076609f, -0.03437243f, 
    -0.02621535f, -0.36248416f, -0.27995825f, -0.39825472f, 0.12375904f, -0.02200775f, -0.30622816f, -0.12108465f, 
    0.03196797f, -0.11678506f, 0.23460822f, 0.08936688f, 0.05685844f, -0.06950346f, -0.00102755f, 0.28262925f, 
    0.18019439f, 0.07436172f, 0.04343756f, 0.00604658f, -0.15370546f, 0.02662333f, -0.04065625f, -0.40393129f, 
    -0.19554630f, -0.01816195f, 0.01950823f, 0.20980056f, -0.07734049f, 0.04323510f, 0.21007191f, -0.47585434f, 
    0.16625710f, -0.39654344f, -0.18029764f, -0.86163002f, -0.41420597f, -0.35956568f, 0.28308284f, -0.18839517f, 
    0.15057582f, -0.11779720f, -0.20464087f, -0.21642208f, 0.09625322f, 0.04747581f, -0.61320841f, 0.10375430f, 
    -0.01653684f, 0.33899295f, -0.05037080f, 0.25470695f, 0.07625420f, 0.20203358f, 0.07381415f, 0.25375643f, 
    0.11690939f, -0.83801520f, 0.24629384f, 0.24498799f, -0.37389773f, 0.32877654f, -0.11045358f, 0.13908134f, 
    -0.07259604f, -0.36752278f, -0.04863372f, 0.15148363f, -0.28579539f, -0.01302585f, -0.09177157f, -0.06075087f, 
    -0.26804170f, 0.10854272f, -0.30150253f, 0.30367696f, -0.08347202f, 0.11303528f, 0.06397483f, 0.20167923f, 
    -0.43020576f, 0.10441642f, -0.28682920f, 0.11414165f, 0.00067923f, -0.40913749f, 0.03359314f, -0.09778320f, 
    0.14435858f, -0.28211361f, 0.03855103f, 0.33213970f, -0.05551971f, -0.02186207f, -0.12859130f, 0.11171018f, 
    -0.33690515f, -0.34351924f, 0.19436046f, -0.32506534f, 0.00387733f, -0.40720591f, 0.15062486f, -0.21080610f, 
    0.24996303f, -0.15549687f, -0.08284050f, 0.17943059f, 0.14280675f, 0.10164543f, 0.10014647f, 0.02211056f, 
    0.11379464f, -0.28168476f, 0.01665676f, -0.19243127f, 0.17078911f, 0.12047222f, -0.38956031f, 0.06823149f, 
    -0.03780594f, -0.25593066f, -0.20749742f, 0.26958656f, 0.15458174f, -0.15009455f, 0.00231878f, 0.24029756f, 
    0.08990593f, 0.18482454f, 0.02138409f, -0.05023118f, 0.19057240f, 0.00661809f, 0.26914304f, 0.05757990f, 
    0.22932658f, -0.40394014f, -0.46912783f, 0.16583331f, 0.10372768f, 0.06267887f, -0.24961826f, -0.08308408f, 
    -0.19448251f, -0.07922039f, -0.11506565f, -0.10947409f, 0.03050052f, 0.40958691f, -0.12361643f, 0.24683863f, 
    0.20550825f, 0.10098290f, 0.08641288f, -0.31287789f, -0.00002391f, 0.00747324f, 0.32842064f, 0.19386986f, 
    0.05133002f, 0.47420475f, 0.17018659f, 0.21572776f, 0.23509477f, 0.11846447f, 0.18357760f, 0.11342204f, 
    0.11358914f, -0.55901128f, -0.42480412f, 0.07558761f, -0.32983652f, -0.22023451f, 0.31902537f, 0.11788825f, 
    0.10087625f, 0.13327752f, -0.00283700f, -0.02324422f, -0.02769331f, -0.35994810f, 0.04392536f, -0.70386219f, 
    0.09381372f, 0.10623752f, 0.20321053f, 0.09151078f, -0.16782899f, 0.26663604f, 0.02282167f, 0.22220212f, 
    0.00032908f, 0.23689425f, -0.14935704f, -0.63641435f, -0.09643672f, 0.05908724f, -0.00645744f, -0.01474416f, 
    -0.04830180f, 0.10597384f, -0.10228560f, -0.09007882f, 0.04895914f, -0.00170093f, -0.05013544f, -0.49518156f, 
    -0.28380325f, 0.03940685f, -0.10183636f, -0.06152467f, -0.09852564f, 0.11488470f, 0.08957528f, 0.27620137f, 
    -0.20247334f, 0.30719545f, -0.04287458f, 0.20464991f, -0.04279008f, -0.02971070f, 0.14388692f, -0.74898267f, 
    -0.30753845f, -0.54035932f, -0.16071202f, -0.02100462f, 0.03507083f, 0.02480724f, -0.02818844f, 0.14106791f, 
    -0.23178384f, 0.19603275f, 0.01097000f, 0.24383846f, -0.42693067f, -0.14709803f, -0.04621243f, -0.08193718f, 
    -0.00452538f, 0.21554571f, 0.42476037f, -0.53311849f, -0.13750663f, 0.19865063f, 0.34090203f, -0.20552376f, 
    -0.06182077f, 0.30080834f, -0.02318512f, -0.25256476f, -0.55266601f, -0.00353238f, 0.07603485f, 0.07063451f, 
    0.06851014f, 0.03085314f, 0.15310873f, 0.30814648f, 0.19575129f, -0.04530903f, -0.26174158f, 0.21212339f, 
    0.10104007f, -0.32306057f, 0.27468133f, 0.30815899f, 0.07701740f, 0.02222445f, -0.28255138f, -0.11243014f, 
    0.11328822f, -0.12361380f, -0.28436160f, -0.03683731f, -0.67693388f, -0.17251159f, 0.07329580f, -0.45523894f, 
    -0.18350327f, -0.22671671f, -0.01481243f, -0.38749066f, -0.08523451f, -0.01707871f, 0.05593073f, 0.19779284f, 
    0.05977406f, 0.12457220f, 0.28330195f, -0.40750423f, -0.57295406f, -0.62286907f, -0.15689519f, 0.03911258f, 
    0.13877377f, 0.18323559f, -0.12552084f, 0.35377425f, 0.02790978f, 0.23817122f, 0.08381400f, -0.11974161f, 
    -0.08837595f, -0.41615301f, -0.01877857f, 0.31070006f, 0.26513669f, -0.20635484f, -0.17527485f, 0.15740469f, 
    -0.00969683f, 0.03196162f, 0.10233475f, 0.09663926f, -0.38715881f, -0.23533973f, -0.06636136f, -0.03908874f, 
    0.07650296f, 0.28404665f, -0.22884637f, 0.10416821f, 0.32221198f, 0.01599717f, -0.03578436f, -0.42959493f, 
    -0.32455850f, -0.29212371f, -0.22058794f, 0.11745198f, -0.08963609f, -0.00845840f, -0.39396477f, -0.15829752f, 
    0.02716481f, -0.01667912f, 0.00584745f, -0.01031758f, -0.01825051f, -0.13824663f, 0.01129526f, 0.05272489f, 
    -0.57866436f, -0.03818526f, -0.10389289f, 0.01879801f, -0.00177518f, -0.11353882f, 0.20787843f, 0.29910052f, 
    0.02709783f, 0.31788096f, -0.55609173f, -0.05688746f, -0.32393390f, 0.30431530f, -0.10733023f, -0.29620582f, 
    0.26067287f, 0.05019309f, -0.18047555f, -0.20591865f, 0.07739815f, -0.31858653f, -0.25729126f, -0.07093327f, 
    0.00356113f, -0.67778766f, 0.24707061f, -0.21609712f, -0.53486770f, 0.15342957f, 0.01210589f, -0.44961017f, 
    -0.05541276f, 0.32261813f, 0.39345801f, -0.27026761f, 0.08996949f, -0.46408552f, 0.07600162f, 0.19243047f, 
    -0.01224413f, 0.17506097f, -0.37551504f, -0.23181695f, -0.35457486f, 0.07780687f, 0.03136320f, 0.09328447f, 
    -0.09967296f, 0.22971602f, -0.50447690f, -0.44974953f, 0.07693014f, -0.07046343f, 0.27161935f, -0.06918524f, 
    0.06268845f, 0.06952716f, 0.34282225f, 0.10238206f, 0.19999522f, 0.32018733f, -0.08979611f, 0.22556397f, 
    0.25504535f, 0.00234296f, 0.09229175f, 0.07102349f, 0.01842483f, -0.10158210f, -0.38281637f, 0.07371792f, 
    -0.60427284f, 0.14764695f, 0.12575859f, 0.25100806f, 0.10101757f, 0.32428420f, -0.34961531f, 0.19706535f, 
    -0.16763589f, 0.23345836f, -0.11770040f, 0.05555777f, -0.08880310f, -0.17378783f, 0.16729194f, 0.11850362f, 
    -0.06111845f, 0.22930658f, -0.78677785f, 0.05266339f, -0.08271510f, 0.27019876f, -0.34831533f, -0.04701667f, 
    0.01079435f, 0.20712416f, 0.45488775f, 0.21487446f, -0.07595532f, -0.59322625f, 0.01058204f, -0.11602569f, 
    0.11154809f, -0.08525336f, 0.39981654f, 0.31105796f, 0.19601469f, 0.06123827f, -0.01294469f, -0.21931297f, 
    -0.25214666f, 0.19468600f, 0.38180330f, 0.12043320f, 0.00701858f, -0.07362203f, -0.44631991f, -0.22189219f, 
    -0.12003556f, -0.05990251f, 0.40442815f, 0.07068453f, 0.27588108f, -0.36841160f, -0.11723772f, 0.06445080f, 
    -0.64578992f, -0.69760615f, 0.10986602f, -0.03696619f, -0.09628738f, -0.04223564f, -0.13609681f, -0.40743956f, 
    0.21053249f, 0.10972477f, 0.16787483f, -0.04465564f, -0.42776796f, 0.06618509f, 0.23015036f, 0.03206653f, 
    -0.38238162f, 0.25117034f, 0.34397954f, -0.35851717f, 0.11071603f, 0.18256046f, 0.06912492f, -0.09111212f, 
    -0.08945544f, 0.16556013f, 0.10644662f, 0.16813980f, 0.23955640f, -0.27557167f, 0.06702458f, -0.07286441f, 
    -0.06548979f, -0.12009139f, 0.16561221f, 0.08056570f, 0.09860031f, 0.06834944f, 0.09933306f, -0.49118271f, 
    -0.09489869f, -0.17441566f, 0.47483626f, -0.33292180f, -0.26641712f, -0.05925956f, -0.51404500f, 0.07126732f, 
    -0.34648952f, -0.18155955f, 0.47929120f, -0.25775489f, 0.09576017f, -0.00627372f, 0.24680719f, -0.39300010f, 
    0.06728192f, 0.08678724f, -0.40685600f, -0.05922060f, -0.05640157f, -0.17116013f, -0.01978859f, 0.17510888f, 
    -0.53681153f, 0.28109208f, -0.01762237f, -0.17793404f, -0.04121427f, 0.06288327f, -0.19910038f, -0.05035070f, 
    0.19058940f, -0.31802279f, 0.18987127f, 0.01879514f, -0.19403036f, 0.24395005f, -0.29069692f, -0.05693289f, 
    -0.29200280f, -0.14861019f, -0.55826491f, 0.28385970f, 0.18406539f, -0.05624052f, -0.07861993f, 0.03395567f, 
    -0.10865435f, 0.17376544f, 0.12980689f, 0.17272259f, -0.26182461f, 0.11342815f, 0.24707688f, 0.24949864f, 
    0.00169970f, 0.10877641f, -0.26023570f, -0.04957168f, 0.19092451f, 0.17483814f, -0.01920310f, -0.22276053f, 
    -0.09602965f, -0.42338261f, 0.16476606f, 0.34868699f, -0.32376406f, -0.10736854f, 0.19849269f, 0.09021816f, 
    0.34818652f, 0.34834439f, -0.32218978f, -0.16474399f, -0.04705773f, -0.07059837f, 0.04381910f, -0.02312146f, 
    -0.54665548f, 0.02445797f, 0.13669498f, 0.05879307f, -0.74684691f, 0.22830942f, -0.01026839f, 0.00591119f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16443445f, 0.13603459f, -0.01300174f, 0.06618522f, -0.03589806f, 0.04717387f, -0.01259151f, -0.11520153f, 
    0.04286039f, -0.09146805f, 0.13994446f, -0.04107808f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
