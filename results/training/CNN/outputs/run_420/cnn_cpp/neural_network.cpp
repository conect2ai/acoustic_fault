#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.02003923f, -0.48412052f, -0.53232735f, -0.48619887f, -0.10564595f, 0.38706753f, 0.53042108f, 0.45503440f, 
    -0.13738638f, 0.02001276f, -0.03372250f, -0.04398080f, -0.21579015f, -0.21425360f, 0.11023704f, 0.07317629f, 
    -0.18369763f, -0.04445821f, -0.05567515f, 0.03457724f, 0.03862052f, -0.01400256f, -0.29991493f, 0.23101667f, 
    0.40530878f, -0.47747314f, 0.16441165f, -0.04122346f, -0.48009101f, -0.18394549f, 0.11057518f, -0.05459281f, 
    -0.33636296f, 0.09315881f, -0.07057394f, 0.27925181f, -0.51887268f, 0.16653338f, -0.39512381f, -0.24503601f, 
    -0.27990392f, -0.40450284f, -0.30874723f, -0.38248608f, -0.43139040f, 0.07324161f, 0.22051080f, 0.06255543f, 
    0.04647547f, -0.37108803f, -0.07775036f, 0.81379145f, -0.05843659f, -0.59963828f, 0.52628374f, -0.58052200f, 
    0.68290114f, 0.51818383f, 0.01309523f, 0.18439279f, -0.17057543f, 0.16992706f, -0.18000709f, -0.42596817f, 
    -0.22356933f, 0.01412451f, -0.13734685f, -0.09074093f, -0.12697524f, -0.11427346f, 0.02318925f, 0.07891805f, 
    0.10862751f, -0.03149815f, -0.27783957f, 0.02199087f, 0.21277860f, 0.12300897f, -0.36728430f, -0.66217911f, 
    0.68305558f, 0.25551057f, 0.00867658f, 0.20070891f, 0.36971676f, 0.26478016f, -0.27960426f, -0.34719297f, 
    -0.46797213f, -0.51270694f, -0.02026836f, 0.14925261f, -0.03047458f, 0.17413567f, 0.15137847f, 0.43087208f, 
    -0.04306872f, -0.23513222f, -0.25369975f, -0.28350484f, 0.12469480f, -0.48172209f, -0.55975562f, -0.34324777f, 
    -0.02075662f, 0.39425904f, 0.03685403f, -0.34537569f, 0.13324088f, -0.32174003f, -0.46156219f, -0.09681652f, 
    0.36649165f, 0.28663439f, -0.54460758f, -0.13851170f, 0.10069381f, -0.08850233f, 0.21356420f, 0.13105071f, 
    0.01823178f, 0.01751402f, -0.34598905f, -0.18921570f, 0.13179992f, -0.01838828f, -0.86672395f, 0.30502427f, 
    0.79454470f, 0.04662058f, -0.05740979f, 0.45734197f, -0.39269945f, 0.51020646f, 0.32047799f, -0.06502210f, 
    -0.10478334f, -0.02681664f, 0.39010787f, -0.30797592f, -0.20130375f, 0.06521577f, -0.07411931f, 0.14705516f, 
    -0.07808547f, -0.16648538f, 0.26752675f, -0.19156529f, -0.04707175f, -0.04374746f, -0.80130309f, 0.70772487f, 
    0.77239013f, 0.33708251f, -0.34380975f, 0.44961008f, -0.38817605f, 0.00175294f, -0.20776528f, -0.36194316f, 
    -0.30929407f, -0.20256186f, -0.04287500f, 0.34144932f, -0.00214159f, -0.27915901f, 0.06388011f, -0.05587275f, 
    -0.00540293f, 0.05242117f, -0.31084475f, -0.43547806f, -0.30614385f, -0.30923662f, -0.36926705f, -0.03870644f, 
    -0.34689608f, 0.02277031f, 0.72351819f, -0.29722705f, -0.02011504f, 0.58662641f, 0.44054672f, 0.48165426f, 
    0.44141632f, -0.04807286f, 0.16369168f, 0.26079130f, -0.56291354f, -0.54450369f, -0.32037541f, -0.00652890f, 
    -0.08800501f, 0.28463829f, 0.05849406f, 0.14835164f, -0.18631607f, -0.43078858f, -0.13159195f, 0.15493666f, 
    -0.89153653f, 0.44224578f, -0.08394189f, -0.45287737f, -0.65404874f, 0.70164508f, 0.59236366f, -0.49890596f, 
    0.12639093f, 0.45950785f, -0.19127749f, -0.11539157f, 0.35664168f, 0.06800883f, -0.04586825f, -0.05758839f, 
    0.10742328f, 0.06444256f, -0.01372107f, 0.04800864f, 0.05176787f, -0.32994866f, 0.03247254f, -0.06484059f, 
    0.12869105f, 0.00457545f, -0.62648422f, 0.56511921f, 0.45634523f, 0.35364348f, -0.16797763f, -0.24890903f, 
    -0.12116799f, 0.02649073f, 0.16220911f, 0.46426600f, 0.25727212f, 0.06883049f, 0.44089791f, -0.30077401f, 
    -0.15438958f, -0.39875627f, 0.02005196f, 0.11575451f, -0.01397238f, -0.05340379f, -0.02314804f, 0.17002174f, 
    -0.04729785f, 0.04259890f, -0.82885838f, -0.03055963f, -0.36262172f, -0.25812107f, -0.13989414f, 0.29903725f, 
    0.61334938f, 0.10040069f, 0.27537012f, 0.55595553f, -0.09014033f, 0.14010188f, 0.28571260f, 0.00422542f, 
    0.26058713f, 0.16556354f, -0.01564385f, -0.17292635f, 0.31832647f, 0.06003875f, -0.02727620f, -0.13471591f, 
    0.03516306f, -0.20712973f, 0.12529688f, -0.09854431f, -0.52003300f, -0.53934413f, -0.09600077f, -0.14210524f, 
    -0.36613461f, -0.48525569f, -0.06960583f, 0.35638744f, -0.17712104f, -0.12643279f, -0.14190498f, 0.42048356f, 
    0.08101159f, -0.30429938f, -0.15195696f, 0.05548597f, 0.16515855f, 0.29690370f, 0.23074619f, -0.14811000f, 
    0.15200454f, -0.03263717f, 0.25925839f, 0.12821202f, 0.55210042f, 0.79323542f, -0.68587583f, -0.54819363f, 
    -0.75039089f, 0.55944139f, 0.11785828f, -0.29490140f, -0.02919233f, 0.03242734f, 0.36705729f, 0.00920619f, 
    0.06599043f, 0.11433804f, -0.24466069f, 0.18020687f, 0.11881525f, 0.14080004f, 0.04104358f, 0.03612827f, 
    -0.03591624f, -0.36736664f, 0.04862701f, -0.07371789f, 0.20571826f, -0.12187854f, -0.46282110f, -0.57240164f, 
    -0.48110756f, -0.31738150f, 0.23603439f, 0.49915940f, 0.34057039f, 0.48780423f, 0.39483243f, -0.17583115f, 
    -0.38685921f, -0.11060358f, -0.51087260f, -0.33823949f, -0.24724770f, 0.15472654f, 0.11962795f, -0.17089960f, 
    -0.08408446f, -0.17451808f, -0.28721985f, -0.01263297f, -0.28748444f, -0.00923438f, -0.07623772f, -0.32508731f, 
    0.25309142f, 0.57564461f, -0.25920913f, -0.95199209f, -0.63625044f, -0.13652524f, -0.34448671f, 0.05181501f, 
    0.07367752f, 0.22844276f, -0.41728842f, -0.05798811f, -0.15344134f, 0.12997085f, -0.05595538f, -0.13510597f, 
    -0.08487430f, -0.14981338f, -0.12636082f, -0.08847908f, 0.34429491f, 0.36111161f, -0.04667284f, -0.65680385f, 
    -0.62142646f, -0.54952514f, 0.40490553f, 0.26387230f, -0.95165420f, 0.47181270f, 0.43137920f, -0.69847858f, 
    0.21917763f, 0.28654832f, 0.12981345f, 0.33886960f, -0.20006147f, 0.38670680f, -0.10635980f, 0.14107457f, 
    0.40928727f, 0.20423296f, -0.36345878f, -0.16162308f, -0.06833232f, -0.29572418f, 0.28125161f, -0.08415888f, 
    -0.60457861f, -0.11716627f, -0.15487616f, -0.48223248f, -0.37557468f, -0.41120800f, -0.02257502f, -0.32619283f, 
    -0.44526124f, 0.00481341f, -0.26252043f, 0.31990600f, 0.06337619f, 0.59526223f, 0.25696495f, 0.12796117f, 
    0.01068890f, 0.13451530f, 0.34551668f, -0.24038658f, 0.11893962f, -0.03744045f, -0.07650062f, 0.21544887f, 
    0.13580936f, 0.34469968f, -0.63253182f, 0.41254658f, -0.25865671f, 0.21961547f, 0.55807394f, -0.26147467f, 
    0.06593955f, 0.03414524f, -0.38233683f, 0.21084198f, -0.31729019f, 0.02838391f, -0.09718300f, -0.11437408f, 
    0.32858333f, 0.56125253f, -0.34755880f, -0.12317563f, -0.32278427f, 0.12604848f, 0.13343140f, -0.01852147f, 
    0.12350937f, 0.59320438f, 0.11190883f, 0.79100132f, 0.73772609f, 0.41038993f, 0.15748517f, -0.80877513f, 
    0.66396046f, -0.32687217f, -0.46892297f, -0.18811041f, 0.22381434f, 0.19825733f, -0.18514025f, 0.04001344f, 
    0.43949637f, 0.17468168f, 0.28542158f, 0.17627332f, 0.06976565f, 0.10269495f, 0.18902056f, -0.04924585f, 
    0.05398057f, 0.02773120f, 0.06909781f, -0.76378942f, 0.29243833f, 0.49037638f, -0.04290906f, 0.22854456f, 
    0.12520073f, 0.53244162f, 0.11480520f, 0.49482560f, 0.24582057f, 0.06609590f, -0.41724512f, 0.21279186f, 
    -0.13155949f, -0.39738560f, 0.11431985f, 0.04152201f, -0.26424977f, 0.05606928f, -0.42459852f, -0.20442393f, 
    0.05878319f, 0.14901879f, 0.47100130f, 0.25855273f, -0.45564330f, -0.58743781f, -0.58769381f, -0.33547437f, 
    -0.37161556f, 0.06399812f, 0.50751829f, 0.46643105f, 0.21611792f, 0.59497613f, 0.28258288f, -0.13977219f, 
    0.05953346f, 0.04639441f, 0.04804773f, -0.04777123f, -0.07933389f, 0.16952708f, 0.14761469f, -0.22725984f, 
    -0.29407588f, 0.09833679f, 0.17851898f, -0.11233899f, 0.05172635f, 0.61583257f, 0.30366033f, 0.06589772f, 
    0.69335163f, 0.72470456f, 0.56799448f, 0.37877029f, 0.23352227f, 0.08188491f, 0.07302479f, -0.05584785f, 
    0.01898197f, -0.31719211f, 0.07183059f, -0.34713897f, 0.01293603f, -0.27068293f, -0.02653476f, 0.21002997f, 
    -0.31768733f, -0.16120170f, 0.12945296f, 0.04164425f, -0.13144840f, -0.23654391f, 0.73986608f, -0.46425322f, 
    0.43639851f, -0.31806907f, 0.44747287f, 0.01510666f, -0.77572674f, -0.09963389f, -0.30738631f, 0.20261844f, 
    -0.22173715f, 0.40226239f, 0.17626603f, -0.14842866f, -0.11485834f, -0.34382442f, -0.24072161f, 0.09697488f, 
    -0.24673070f, 0.08341752f, 0.05036994f, -0.14348134f, -0.28616261f, -0.23827259f, -0.06908661f, 0.51713222f, 
    0.19257140f, 0.30751443f, 0.54768050f, 0.97566795f, 0.29470715f, 0.24104820f, 0.22973049f, 0.18211193f, 
    -0.01745785f, -0.05589650f, -0.01038394f, -0.01660966f, -0.34067714f, 0.19494025f, 0.41853896f, -0.15630120f, 
    0.05327606f, -0.30619669f, 0.19624960f, 0.25707772f, 0.18395229f, -0.10570869f, 0.15467085f, 0.32236931f, 
    0.38145941f, 0.48923159f, -0.66817600f, -0.61193383f, -0.29653126f, 0.07222467f, -0.50546622f, -0.01756064f, 
    -0.43143985f, 0.14783898f, 0.12802048f, -0.22019008f, 0.38529354f, 0.17733507f, -0.40069532f, -0.01949519f, 
    0.05311646f, -0.27318054f, 0.03434352f, 0.26105532f, -0.05682916f, 0.31361720f, 0.25075993f, -0.06117087f, 
    -0.12379679f, 0.86793208f, 0.29596674f, -0.25443989f, -0.55203056f, -0.25652963f, -0.34248075f, 0.17655426f, 
    -0.54882306f, 0.27044308f, 0.55124879f, 0.10657971f, -0.17016213f, -0.05877050f, -0.12806912f, -0.17854883f, 
    -0.04406933f, 0.31425574f, 0.09177253f, 0.04504634f, 0.33133069f, -0.21771656f, 0.26461452f, -0.07812259f, 
    0.00359005f, 0.10712408f, -0.01532545f, -0.64402801f, -0.70952421f, -0.36788884f, 0.02013145f, 0.37727502f, 
    0.05448121f, -0.06586929f, 0.36885223f, 0.31492230f, -0.08435018f, -0.27530307f, 0.03130734f, -0.12642595f, 
    -0.13025659f, 0.06897987f, 0.05922699f, 0.19797756f, 0.09346765f, -0.04789753f, 0.41572720f, -0.05118242f, 
    0.27730149f, -0.05431773f, -0.09664636f, -0.99559015f, 0.36475477f, -0.20140304f, -0.51993012f, -0.53581297f, 
    0.12518866f, -0.05600426f, -0.09075475f, 0.64769232f, -0.45597729f, 0.00524026f, -0.18414469f, -0.41706005f, 
    0.06466517f, 0.02061214f, 0.15469570f, 0.03684502f, 0.02409294f, -0.08318829f, 0.16642457f, -0.15803328f, 
    0.11067182f, 0.15655081f, -0.01770455f, 0.30000168f, -0.32087171f, -0.72824836f, -0.60160768f, -0.14596431f, 
    -0.29397991f, -0.26894349f, -0.03289805f, 0.06824563f, -0.09034439f, 0.00051463f, 0.32294425f, 0.19426557f, 
    0.13362858f, 0.36200505f, 0.22839777f, -0.58011138f, 0.09407408f, 0.09552799f, -0.31549913f, -0.16464448f, 
    0.23653725f, 0.09116689f, -0.30148342f, -0.15239733f, -0.23289995f, -0.38569194f, -0.37918273f, -0.15818563f, 
    -0.30216542f, 0.26661208f, -0.53240317f, -0.45159042f, -0.64517480f, -0.30546796f, 0.17858277f, 0.41756922f, 
    0.13342538f, -0.26289850f, -0.37289852f, -0.30831176f, 0.19501875f, -0.04376636f, -0.33328614f, -0.14627628f, 
    0.01231999f, 0.35996944f, 0.00449671f, -0.06607644f, -0.04972039f, 0.12452970f, -0.33600405f, -0.63667816f, 
    -0.05133518f, 0.02713037f, -0.01457798f, 0.06606898f, -0.02653335f, -0.05230451f, 0.56428409f, 0.31558731f, 
    0.36566117f, 0.28267184f, -0.11726870f, 0.31168437f, -0.24767748f, -0.13561799f, 0.18619652f, 0.17694235f, 
    0.38520887f, 0.08113116f, 0.37406644f, -0.18959048f, 0.28927192f, -0.14183030f, 0.19814090f, -0.59068167f, 
    -0.33668199f, -0.13400626f, -0.35835788f, -0.33703238f, 0.40622520f, -0.43213674f, -0.27639610f, 0.09867746f, 
    0.26096228f, 0.31305584f, -0.17443976f, 0.01564474f, 0.03994242f, 0.33305436f, -0.19251132f, 0.36499849f, 
    -0.05528222f, 0.22451970f, 0.41987211f, 0.10152582f, -0.00577452f, 0.28326997f, 0.41800010f, -0.19262017f, 
    -0.53837794f, -0.68866348f, -0.66534203f, 0.02634831f, -0.06070934f, 0.29422021f, 0.47068730f, 0.40105128f, 
    0.22935937f, 0.17169189f, -0.48839337f, -0.21649431f, -0.47243267f, -0.24278688f, 0.06827506f, 0.31864798f, 
    -0.15702206f, 0.13089335f, -0.29969230f, -0.12707527f, -0.10796021f, -0.01576504f, 0.19878432f, -0.13812570f, 
    -0.11696047f, 0.14224949f, -1.00531614f, -0.41127464f, 0.32365420f, -0.12355530f, -0.42336941f, 0.72987956f, 
    0.79023826f, -0.45823196f, 0.25905254f, 0.10462927f, 0.16561732f, -0.60568780f, -0.40072066f, -0.20577703f, 
    -0.07919109f, -0.02529228f, -0.15073420f, -0.01569224f, -0.25491872f, -0.10027307f, 0.05525869f, 0.10834409f, 
    0.13364099f, 0.08023383f, 0.30136710f, 0.63086551f, 0.52386659f, 0.23495747f, 0.29465085f, -0.09680260f, 
    0.49529096f, 0.17616481f, -0.36856779f, 0.27570140f, 0.33803982f, 0.39279383f, 0.23426925f, -0.10720741f, 
    -0.11225590f, 0.29334280f, -0.12612069f, -0.19917306f, 0.14349617f, 0.21299998f, -0.16360785f, 0.15906887f, 
    0.06491266f, 0.17435777f, -0.01572489f, -0.74524999f, -1.07601464f, -0.36341864f, 0.48954150f, 0.17991789f, 
    0.70726103f, -0.25939608f, 0.34539101f, 0.11694144f, -0.67442119f, 0.08691037f, -0.26427865f, -0.17799808f, 
    0.65079343f, 0.15940726f, 0.22986436f, 0.38492557f, 0.01523743f, 0.04810664f, 0.22639255f, -0.04424401f, 
    -0.19913420f, 0.04412296f, -0.05347581f, -0.15444025f, 0.06229657f, 0.00762832f, 0.39389819f, 0.82844508f, 
    0.29869190f, 0.18045585f, 0.56140095f, 0.15100086f, -0.20955445f, 0.41333449f, 0.05765335f, -0.27011368f, 
    -0.25789499f, 0.07995102f, 0.18688723f, -0.20528999f, -0.35483566f, -0.19028798f, 0.14643407f, -0.23859946f, 
    0.52249497f, 0.20683344f, -0.21197560f, 0.13036211f, 0.14603876f, -0.43862978f, -0.18069556f, -0.12499969f, 
    0.12079203f, -0.43554744f, -0.36913523f, -0.41215330f, -0.37782124f, -0.19828747f, 0.45174724f, -0.21976164f, 
    0.14648356f, -0.20996732f, 0.11837420f, -0.05508037f, -0.31585410f, -0.17073634f, 0.25526303f, -0.32154617f, 
    -0.24323429f, -0.04097734f, 0.05490465f, -0.43965644f, 0.07049631f, -0.01354817f, 0.22493993f, 0.67499316f, 
    0.47763851f, 0.49884394f, 0.35978562f, -0.64504558f, -0.29809192f, -0.40447664f, -0.53256297f, -0.15591957f, 
    0.35955524f, -0.12963931f, -0.11012127f, 0.18877900f, -0.30092922f, -0.05823228f, 0.09207312f, 0.03551164f, 
    -0.06929400f, -0.06322959f, 0.32549942f, 0.37587452f, 0.58720618f, 0.27535960f, 0.01300261f, 0.77506083f, 
    0.39900815f, 0.24254051f, -0.13268524f, -0.38929874f, 0.29528490f, 0.08274420f, -0.16545352f, 0.26600504f, 
    0.48244524f, 0.00641004f, 0.40390041f, -0.16935870f, 0.24263053f, -0.02933779f, -0.18614854f, -0.14276879f, 
    0.06871454f, 0.03512484f, -0.20619290f, -0.19558546f, -0.04229853f, -0.11232450f, 0.03992758f, 0.15684074f, 
    -0.14691308f, -0.15336268f, -0.44627652f, -0.58731544f, 0.69269884f, -0.06506649f, -0.35014307f, 0.21561958f, 
    0.37628165f, -0.05871074f, 0.09797390f, -0.27897480f, 0.14059941f, 0.08545723f, -0.22847857f, 0.53958291f, 
    0.06343038f, 0.16650555f, -0.07629892f, -0.41015682f, -0.17856109f, -0.23197453f, 0.07784744f, 0.43182385f, 
    0.35997245f, -0.36990449f, -0.19966286f, 0.26506245f, 0.13960294f, -0.02509744f, -0.96372533f, -0.04623268f, 
    -0.11682952f, -0.73336351f, -0.30846512f, 0.19599929f, 0.31451818f, 0.31964177f, -0.14244558f, -0.06138950f, 
    -0.26759297f, -0.19099855f, 0.06867910f, -0.05663808f, -0.09047944f, 0.24050258f, 0.16777006f, 0.04633223f, 
    0.04133474f, -0.22078231f, 0.44726864f, 0.60541511f, 0.47015312f, -0.14794929f, -0.66473114f, 0.34173119f, 
    0.09659548f, -0.00654282f, -0.02758146f, 0.01377513f, 0.39970657f, 0.48150721f, -0.26630747f, 0.10022881f, 
    0.25615224f, 0.14254779f, 0.14835118f, -0.14530356f, -0.05236802f, 0.24850914f, -0.18438707f, 0.38568535f, 
    0.01007288f, -0.10332788f, 0.27044442f, 0.44022784f, -0.16318101f, -0.10894980f, 0.23957436f, 0.73486680f, 
    0.65151507f, -0.61559558f, -0.81199461f, -0.73792917f, -0.25169528f, -0.17029645f, 0.59305918f, -0.02068390f, 
    0.15062301f, -0.18888468f, -0.16765136f, 0.07498799f, -0.21940623f, 0.34963211f, -0.07403225f, 0.12050333f, 
    0.09119735f, -0.11940763f, -0.12071452f, -0.09271029f, 0.83373857f, 0.74330354f, 0.43825254f, 0.36989725f, 
    -0.12687691f, -0.22392760f, 0.18383020f, -0.46577442f, 0.18679002f, -0.03175322f, 0.17551383f, 0.01850777f, 
    0.10623808f, -0.09425929f, -0.27221513f, 0.12673058f, -0.25178254f, 0.41863683f, 0.10405160f, -0.12241670f, 
    -0.29898691f, -0.14864816f, -0.03500877f, -0.01838314f, -0.15649937f, -0.14901003f, 0.43296957f, -0.48667589f, 
    -0.51559365f, -0.32229829f, 0.55314112f, 0.08467467f, -0.09324387f, 0.37889972f, 0.38529056f, 0.48374707f, 
    -0.15652746f, -0.18946467f, 0.23351759f, 0.31649259f, -0.03348394f, -0.46315888f, 0.12153188f, -0.12132574f, 
    0.28435326f, 0.27726391f, -0.10754722f, 0.10720599f, 0.01362951f, 0.08490691f, -0.14630951f, -0.44414097f, 
    -0.26111218f, -0.39427349f, -0.45477974f, 0.48600471f, 0.03399469f, -0.29860896f, -0.30407265f, 0.25544289f, 
    -0.40213791f, -0.18379644f, 0.00624102f, 0.02779068f, -0.19842218f, -0.45492885f, 0.01583517f, 0.15286179f, 
    -0.01090774f, -0.27761546f, -0.21366571f, 0.17452006f, -0.19669372f, 0.41157600f, 0.31152570f, 0.35062516f, 
    0.14276525f, 0.30691788f, 1.14240789f, -0.26027367f, 0.03783062f, -0.23074083f, 0.18093532f, 0.23478504f, 
    0.40456834f, -0.41783604f, -0.02899047f, 0.19348367f, 0.13957773f, -0.27268103f, 0.01094643f, 0.12343945f, 
    -0.05331068f, -0.04533298f, -0.06152809f, 0.16362670f, 0.02424086f, -0.37158868f, -0.03092117f, 0.01734566f, 
    0.76540720f, -0.23228197f, 0.36695957f, -0.57912147f, -0.49945796f, 0.30921432f, 0.23213607f, 0.48373726f, 
    0.19126891f, -0.29205599f, 0.20102724f, 0.53423822f, -0.24739754f, 0.26253462f, -0.12962700f, -0.08010050f, 
    -0.20077008f, -0.13410445f, -0.20068142f, 0.13467325f, 0.21329191f, 0.13579969f, 0.15124434f, -0.04250647f, 
    0.06365353f, 1.15416980f, 0.32657433f, -0.68445647f, 0.59733564f, 0.02469023f, -0.15898128f, -0.06248669f, 
    0.50606096f, 0.53722864f, 0.06793352f, -0.24717222f, -0.27621037f, -0.03144605f, -0.28091538f, 0.16720667f, 
    -0.00131459f, -0.25626603f, -0.02659259f, -0.41137242f, 0.09569559f, 0.01339056f, 0.00133682f, 0.05779235f, 
    0.13971183f, -0.28604645f, 0.72189415f, 0.74150449f, 0.55335879f, 0.40116334f, 0.61459315f, 0.28788713f, 
    -0.51718217f, 0.14620689f, -0.10953882f, 0.10339396f, 0.11864179f, 0.26936340f, -0.35772255f, 0.14273806f, 
    0.01545432f, 0.35424876f, -0.04994414f, -0.03080398f, 0.02421393f, -0.03686961f, 0.35789642f, 0.15807202f, 
    0.01716461f, -0.33743045f, 0.52991521f, -0.30218062f, -0.32381395f, -0.39642486f, -0.26682189f, -0.47132936f, 
    -0.41081423f, -0.30753827f, -0.04530808f, 0.26277047f, 0.35885012f, 0.01010652f, 0.08355112f, -0.18433744f, 
    0.22505662f, -0.42101923f, -0.10633112f, 0.01192886f, 0.18224022f, 0.10865707f, -0.14195158f, 0.26204491f, 
    -0.19718136f, 0.04080820f, 0.21626422f, 0.45417657f, -0.05150668f, -0.33296940f, 0.17547990f, -0.35212311f, 
    -0.21575235f, -0.47079939f, -0.72083640f, 0.37818676f, 0.28432950f, -0.32941890f, -0.24617131f, 0.22734548f, 
    0.52854961f, -0.30782035f, -0.41837779f, 0.13754128f, 0.11174101f, -0.30615580f, -0.08510670f, 0.09782467f, 
    -0.11906423f, -0.19158810f, 0.08930142f, -0.25719640f, -0.27117649f, 0.75963807f, -0.97769099f, 0.66939521f, 
    0.45336455f, 0.34941766f, 0.41364515f, 0.45564717f, 0.25014138f, -0.29710814f, -0.26049274f, 0.02587461f, 
    -0.17597124f, -0.24428196f, -0.18914367f, -0.16914570f, -0.09902068f, -0.29864174f, -0.08996347f, -0.01439383f, 
    -0.39939454f, -0.20436636f, -0.05790701f, -0.04709776f, -0.24955890f, 0.04489443f, -1.24898601f, 0.05117215f, 
    -0.85943967f, 0.48432922f, 0.24679409f, -0.04017135f, 0.94782615f, -0.36515474f, 0.24965055f, 0.13213749f, 
    0.00401448f, -0.07317711f, 0.25800222f, -0.23340441f, 0.19113041f, -0.25330955f, -0.07213983f, -0.10479970f, 
    -0.06691915f, -0.34385431f, 0.13635907f, 0.10157907f, -0.07767062f, 0.15268731f, -0.03396747f, -0.15898204f, 
    0.32680330f, 0.56613314f, 0.65776569f, 0.45715910f, 0.14027461f, 0.17467830f, -0.18109460f, 0.37974501f, 
    -0.40165707f, 0.27803618f, -0.01479187f, -0.05284971f, -0.35440674f, -0.41573015f, -0.31182116f, 0.10910376f, 
    -0.11056390f, 0.13345200f, -0.12081823f, -0.03595665f, -0.06579962f, 0.10317259f, 0.22139601f, 0.08286992f, 
    0.86975288f, 0.15273921f, 0.55449963f, 0.79166013f, 0.53445834f, -0.24871519f, 0.25952914f, -0.26125348f, 
    -0.04186730f, 0.37457067f, -0.11020966f, -0.02779938f, 0.08079651f, 0.05509105f, 0.00417351f, -0.26085800f, 
    0.05637410f, -0.04755875f, -0.16748874f, -0.19441304f, -0.06956113f, 0.09793679f, 0.00519905f, -0.12638155f, 
    -0.07412405f, -0.99681288f, 0.82700396f, 0.47893316f, -0.82647914f, 0.58833623f, -0.39230180f, 0.33812711f, 
    0.37368739f, -0.10128225f, -0.23481521f, -0.09872455f, 0.13314831f, -0.12937935f, 0.07800817f, 0.30664822f, 
    0.22525492f, -0.25086623f, -0.24264675f, -0.09495495f, 0.17663783f, 0.11090119f, 0.24920340f, 0.24284405f, 
    0.31267408f, 0.19443773f, -0.06938042f, 0.00917713f, -0.64516938f, -0.36380202f, -0.24452768f, 0.44798699f, 
    -0.62600648f, -0.23538017f, -0.13882169f, -0.46355838f, -0.40459800f, -0.11197603f, 0.06883455f, 0.30296215f, 
    0.40463763f, 0.28282425f, 0.25097290f, 0.04708423f, 0.07651123f, 0.07788049f, 0.16697708f, -0.19172038f, 
    0.12500861f, 0.11768590f, 0.08156545f, 0.80677545f, 0.62692785f, 0.86362392f, -0.59772992f, -0.73798043f, 
    -0.09208627f, -0.62949109f, -0.39541140f, -0.19202872f, -0.10880414f, 0.13155156f, -0.04591518f, 0.28972030f, 
    0.00868414f, 0.11479142f, -0.16515473f, 0.10045865f, -0.07791261f, -0.00830880f, -0.07173761f, 0.12205759f, 
    -0.03008165f, 0.15455677f, 0.03424660f, 0.31620377f, 0.72650445f, 0.33129659f, -0.02825991f, -0.36064771f, 
    -0.05499372f, -0.64799231f, 0.15489353f, 0.04272952f, -0.28871751f, 0.66071308f, 0.08854534f, 0.08172932f, 
    0.01624313f, -0.21090649f, 0.37473270f, -0.26778507f, 0.23156308f, -0.14170147f, -0.33915043f, -0.19319056f, 
    -0.04731434f, -0.02345906f, -0.18562761f, 0.07507627f, -0.20089339f, 0.77944148f, 0.19726557f, -0.61863464f, 
    -0.48488876f, 0.15091462f, 0.60498863f, 0.49952033f, -0.60887957f, -0.14075047f, 0.19334422f, -0.08096917f, 
    0.35225964f, -0.15889485f, 0.13691586f, 0.22537656f, 0.05465297f, -0.28071097f, -0.01099898f, 0.18181634f, 
    -0.22362870f, 0.12390722f, 0.38462326f, 0.01516354f, -0.17752507f, 0.11384801f, -0.64873928f, 0.72845852f, 
    -0.62625581f, -0.12088390f, 0.73176557f, 0.77530247f, -0.30312487f, -0.71527302f, 0.23776668f, -0.41513690f, 
    0.01317279f, -0.13386850f, -0.56736767f, 0.21654995f, -0.13403122f, -0.18658806f, -0.12116306f, 0.11818975f, 
    -0.33554912f, 0.17587753f, 0.21836638f, 0.08346421f, -0.07626501f, 0.04935254f, -0.29707286f, 0.29417476f, 
    0.28322878f, 0.52254039f, 0.28749111f, 0.15746729f, -0.56889498f, -0.70982534f, -0.68256396f, -0.63981062f, 
    -0.24419971f, -0.23936473f, 0.32970634f, 0.35249478f, 0.25130978f, 0.12816100f, 0.12158518f, -0.33405608f, 
    0.01365576f, 0.33862552f, 0.30126604f, 0.10813462f, 0.18712212f, -0.24253218f, -0.04701924f, 0.06188287f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28297725f, 0.11363823f, 0.19309315f, -0.12574930f, 0.29136547f, -0.02664976f, 0.02108432f, 0.18911946f, 
    -0.17128813f, 0.07208791f, -0.07372966f, -0.00228636f, -0.03435133f, -0.11024612f, 0.24937081f, 0.20264004f, 
    0.24464427f, 0.23865624f, 0.10441921f, -0.07848871f, -0.02130397f, 0.12877567f, 0.12222269f, -0.01373792f, 
    0.11170814f, 0.01583084f, 0.06336956f, 0.16865148f, 0.09043989f, 0.32578766f, 0.21998353f, 0.07162982f, 
    -0.18409510f, 0.17829560f, 0.18370454f, 0.37312880f, 0.22738539f, 0.11805501f, 0.15204546f, 0.04144292f, 
    0.27999765f, 0.18583259f, 0.17650886f, 0.04815808f, -0.00957437f, 0.27341098f, -0.04084933f, 0.17896420f, 
    0.04298188f, 0.10035740f, 0.13939060f, 0.06088783f, -0.00144145f, 0.01528791f, 0.15514785f, 0.03034010f, 
    0.11813080f, 0.22377485f, 0.21470925f, 0.24288332f, 0.07436942f, 0.11735324f, -0.07671371f, 0.23339112f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02809349f, -0.00949278f, -0.03283571f, -0.03139931f, -0.01561794f, 0.02570109f, 0.01256930f, -0.00876112f, 
    0.00555679f, -0.04016503f, 0.00797063f, -0.01054423f, -0.02257725f, 0.03077381f, -0.00016998f, -0.02187440f, 
    -0.01989520f, -0.03138446f, 0.02277555f, 0.03344323f, -0.01607707f, -0.00343764f, 0.01904146f, -0.02281928f, 
    -0.00792306f, -0.02015558f, -0.02626296f, -0.01369339f, 0.00069256f, 0.02423616f, 0.03407105f, 0.02379340f, 
    -0.01507287f, -0.01280881f, -0.02343681f, -0.03472614f, 0.01808382f, -0.01030774f, 0.00597189f, 0.01426159f, 
    0.00971449f, -0.01984586f, 0.00640693f, -0.02643495f, 0.00332495f, -0.01401718f, -0.01721756f, 0.02700718f, 
    -0.02414126f, 0.02092041f, 0.00873143f, 0.00711447f, 0.02654920f, 0.02569145f, -0.00661635f, 0.02165199f, 
    0.01846452f, 0.00568600f, 0.02265817f, -0.03028532f, 0.00842164f, 0.01091560f, -0.03366614f, -0.02139526f, 
    -0.02025753f, 0.00966003f, 0.00407832f, -0.03195423f, -0.03065903f, -0.00115574f, -0.03114630f, -0.02373994f, 
    0.01692473f, -0.01443191f, 0.03293636f, 0.01097729f, -0.02813549f, -0.01293474f, -0.00478793f, 0.00289485f, 
    0.03287379f, -0.03569606f, 0.01440007f, -0.01544785f, 0.00706159f, 0.02363863f, -0.02688552f, 0.02502974f, 
    -0.01739489f, -0.00779084f, 0.01036437f, 0.00218267f, -0.03099738f, 0.03106912f, -0.01225376f, -0.03453585f, 
    -0.03491887f, 0.02417183f, 0.00107144f, -0.04238988f, 0.01312838f, 0.02944228f, -0.01149256f, 0.02732779f, 
    -0.01733571f, 0.01850670f, 0.00371308f, -0.02237728f, 0.02087642f, -0.01359613f, 0.01601799f, -0.00939489f, 
    0.00531835f, 0.02140938f, -0.04348557f, -0.00419694f, 0.00250426f, -0.00463503f, 0.02918313f, -0.01775218f, 
    -0.03970353f, 0.00751342f, -0.02281490f, 0.00647801f, -0.01432018f, 0.01892849f, -0.00153973f, -0.02608313f, 
    -0.01055583f, -0.02727584f, -0.01710458f, 0.01993797f, -0.04164644f, -0.03399565f, 0.01155666f, -0.01123831f, 
    0.00666520f, -0.00887402f, 0.00803878f, 0.01942589f, -0.00127354f, 0.02921146f, 0.00673521f, -0.00954849f, 
    -0.03286080f, 0.01440317f, 0.00964362f, -0.01315358f, -0.01433725f, 0.00441416f, -0.00860861f, -0.03573710f, 
    0.01316986f, 0.01378242f, 0.03309641f, -0.01433844f, 0.01796609f, 0.01771169f, -0.01293534f, 0.02034077f, 
    -0.01784992f, -0.02006056f, -0.02753715f, 0.03008477f, -0.00940230f, 0.02454042f, -0.03038954f, 0.00524300f, 
    0.01640838f, -0.00496145f, -0.02294604f, -0.02914637f, -0.03980873f, 0.01135224f, 0.01251223f, 0.01425210f, 
    -0.01888986f, 0.00625440f, -0.00950827f, -0.01286262f, 0.01766459f, 0.00665426f, -0.03119988f, -0.01177230f, 
    -0.00665498f, 0.01593701f, 0.01943143f, -0.00305442f, -0.03889056f, 0.01955875f, -0.02197011f, 0.02549504f, 
    -0.02941976f, 0.01936418f, -0.02276003f, -0.01477037f, -0.01491604f, 0.02198975f, 0.00475350f, -0.03321297f, 
    -0.00756997f, 0.02087543f, -0.04241009f, 0.02864842f, 0.03466160f, 0.01334957f, 0.01085408f, -0.00099043f, 
    0.01870938f, -0.00839416f, -0.03300954f, -0.02501373f, -0.02124820f, 0.02915098f, -0.01845101f, -0.02689516f, 
    -0.03346527f, 0.01800780f, -0.03572005f, 0.02321592f, 0.00115141f, 0.00373706f, 0.00602262f, 0.01451030f, 
    -0.03416669f, 0.01047126f, -0.01496428f, 0.02350726f, -0.02810989f, -0.02355687f, -0.02455421f, -0.02750515f, 
    0.02726163f, 0.01169536f, -0.03648878f, -0.02877367f, -0.00466316f, -0.00830375f, -0.03628987f, -0.00311699f, 
    -0.01898725f, -0.03209096f, 0.02307654f, -0.00130952f, 0.01309598f, -0.01648955f, -0.00113304f, -0.00371615f, 
    0.00365668f, -0.03918483f, -0.02736000f, 0.02000928f, -0.00276134f, 0.02729941f, -0.01924506f, -0.03786214f, 
    0.00983719f, 0.00894752f, 0.02394793f, 0.00889065f, -0.03015141f, -0.02763834f, -0.03476023f, -0.04049227f, 
    -0.01115247f, -0.03634191f, 0.01298191f, 0.01208617f, -0.01259066f, -0.01786588f, 0.00618523f, 0.03129104f, 
    -0.03353351f, -0.01116509f, 0.00297464f, -0.02058907f, 0.02922167f, 0.01942723f, -0.00164980f, -0.02735687f, 
    0.00408597f, -0.01192844f, -0.02889519f, -0.01584894f, -0.01244362f, -0.03250537f, 0.00022706f, -0.00643779f, 
    0.02756213f, -0.02263139f, -0.02891719f, 0.02366731f, 0.02348525f, 0.01257317f, 0.03276283f, 0.01088180f, 
    -0.02221732f, -0.03152107f, 0.02755508f, -0.00791440f, -0.00286391f, -0.00282420f, -0.00709582f, 0.01709296f, 
    0.00100666f, -0.04019078f, 0.03034344f, 0.01278506f, 0.01403018f, -0.00531018f, 0.01656707f, -0.00724358f, 
    -0.02198558f, -0.03945548f, 0.02090536f, -0.01717503f, -0.01307987f, -0.02108085f, 0.00705962f, 0.00431060f, 
    0.01007972f, -0.00574693f, -0.02941643f, 0.02430725f, -0.02443380f, -0.02340667f, 0.01670157f, 0.02679842f, 
    0.00327814f, -0.01570879f, -0.00743638f, -0.00408257f, -0.01813457f, -0.03062862f, 0.03419880f, 0.00045930f, 
    -0.01487071f, -0.01000412f, -0.01825732f, -0.02975425f, -0.03297333f, -0.02634678f, 0.02288495f, -0.01729780f, 
    -0.01244144f, 0.00856882f, -0.03343697f, 0.02222863f, 0.02801448f, -0.01966114f, 0.02091925f, -0.02628923f, 
    -0.03392694f, -0.03254736f, -0.03929500f, 0.00598466f, -0.02272452f, 0.00233260f, 0.00841246f, 0.01009438f, 
    -0.01638472f, -0.03523113f, 0.02733340f, 0.01134875f, -0.02329526f, 0.00994467f, -0.01386512f, -0.03581936f, 
    0.00208326f, -0.04021771f, 0.01959815f, -0.00038656f, 0.00055342f, 0.02718029f, 0.02825330f, 0.00356336f, 
    0.02478708f, -0.00008870f, -0.01244596f, 0.02812031f, -0.02721945f, 0.01347563f, 0.02427256f, 0.02868551f, 
    0.02034437f, 0.01884123f, 0.00933695f, 0.02218541f, -0.01697504f, -0.00714988f, -0.00427032f, -0.03625058f, 
    -0.03201103f, -0.03395664f, 0.03044514f, 0.01562579f, 0.02669283f, 0.02367158f, 0.02847553f, 0.02746611f, 
    0.00577543f, 0.01200871f, -0.01871981f, -0.00437095f, 0.02278797f, -0.02949177f, 0.03326640f, 0.02553715f, 
    -0.01940427f, -0.00335046f, -0.02842238f, -0.03594404f, -0.00594877f, 0.00988653f, 0.02571216f, -0.03129953f, 
    -0.02453191f, -0.01130430f, -0.01540058f, 0.01406403f, 0.03122408f, -0.03722160f, -0.04161680f, 0.00491043f, 
    0.02455861f, 0.00865836f, 0.02339368f, 0.00039945f, 0.00031023f, 0.01388273f, 0.00935460f, -0.00364588f, 
    -0.00521583f, 0.02450000f, -0.02890069f, -0.03367501f, 0.03066609f, -0.00892677f, -0.03478211f, -0.02817535f, 
    -0.01243280f, 0.01433623f, -0.00042945f, 0.02795377f, -0.02492575f, 0.00166962f, -0.02613265f, -0.02612159f, 
    -0.00553213f, -0.01767405f, -0.02456852f, -0.00233562f, -0.03067316f, 0.03247856f, 0.03125921f, -0.00422066f, 
    0.01768486f, 0.01277523f, -0.01491547f, 0.03430037f, -0.02543570f, -0.00431732f, -0.00322679f, -0.01580811f, 
    0.02738585f, 0.00065678f, 0.00640825f, 0.02271360f, -0.00384948f, 0.00187151f, -0.02781968f, 0.01462465f, 
    0.01925438f, 0.00720285f, -0.00514846f, -0.02986198f, 0.02079086f, 0.02918260f, -0.03112541f, 0.02398336f, 
    -0.01314270f, 0.02847150f, 0.00712887f, -0.03544391f, -0.01085911f, -0.00302321f, 0.02302040f, -0.00559620f, 
    -0.03371203f, -0.00623601f, 0.01817266f, 0.01447923f, 0.01839821f, -0.02359516f, 0.01010234f, -0.02923271f, 
    -0.01950188f, 0.02858087f, 0.00197887f, 0.00606907f, 0.00699472f, -0.03315401f, 0.03388765f, -0.00857154f, 
    0.01028677f, -0.02455885f, 0.02787751f, -0.01075019f, -0.03070474f, 0.01647888f, 0.02744244f, 0.00295598f, 
    -0.01198906f, -0.01453563f, 0.03220488f, -0.04051040f, 0.00801170f, 0.02918680f, 0.03797469f, -0.01914021f, 
    -0.02555091f, -0.01143536f, -0.03013999f, 0.01984496f, 0.02397897f, -0.02106141f, 0.03313871f, 0.00362792f, 
    0.01244469f, 0.02193416f, -0.02948303f, -0.00628596f, -0.02224948f, -0.03184796f, 0.00951504f, -0.02775170f, 
    -0.02647900f, -0.00943506f, 0.02711625f, 0.02226274f, 0.00676225f, -0.02840519f, 0.01892554f, -0.00713306f, 
    -0.01518998f, -0.04334658f, 0.01591097f, -0.00013341f, -0.02907034f, -0.00376196f, 0.00490280f, -0.03584186f, 
    -0.03135376f, -0.01971495f, 0.02681294f, 0.01375386f, -0.00775016f, -0.03768557f, -0.03624418f, -0.01675239f, 
    0.00173864f, -0.02848977f, 0.00986777f, -0.02212441f, -0.03129626f, 0.00637400f, -0.02656904f, -0.00296724f, 
    0.02343832f, 0.02143698f, -0.03561462f, -0.00734644f, -0.02705458f, -0.03436673f, 0.02449350f, 0.00472615f, 
    0.02559829f, -0.01620495f, 0.02312701f, -0.02289814f, 0.02343251f, -0.02961759f, 0.00356258f, 0.00081251f, 
    -0.03534223f, -0.02627289f, 0.02700739f, 0.02228990f, -0.03693009f, -0.02166106f, 0.02529963f, -0.00284621f, 
    0.01107121f, -0.02510038f, 0.01598177f, 0.01257665f, 0.00681614f, -0.01234862f, 0.00092263f, -0.02430838f, 
    -0.02388857f, -0.00237804f, 0.03034227f, -0.02204461f, 0.02426263f, -0.02884431f, 0.00111547f, -0.02128405f, 
    -0.01028286f, -0.03877306f, 0.00998582f, -0.03752564f, -0.02352745f, -0.03367013f, 0.02337497f, -0.02355322f, 
    0.00289238f, 0.02409366f, 0.01361598f, -0.02029936f, 0.01500288f, -0.01237979f, 0.01942905f, 0.02134243f, 
    0.02785577f, 0.02202119f, 0.02839828f, -0.02103012f, 0.02170753f, 0.03233793f, 0.01850864f, 0.00097635f, 
    -0.04337984f, -0.03542396f, 0.00132874f, -0.01359566f, 0.03141532f, 0.01963613f, 0.00785307f, -0.00020419f, 
    0.02459989f, 0.02422173f, 0.02734065f, -0.02570019f, -0.00187593f, 0.03460373f, 0.01509154f, -0.03356298f, 
    -0.01942618f, -0.01241772f, 0.00666447f, -0.03631887f, 0.02860341f, -0.00006247f, -0.03009281f, -0.02779954f, 
    -0.01451233f, -0.02156961f, -0.01375147f, 0.00585772f, 0.02285035f, 0.02261869f, 0.01707228f, -0.01274633f, 
    0.01858271f, 0.02024517f, 0.02657877f, 0.01239263f, -0.03296947f, -0.00978394f, 0.03132541f, -0.00809058f, 
    0.01148215f, 0.03402789f, 0.02565079f, -0.03256667f, 0.00826962f, 0.02035386f, 0.00887677f, -0.03763868f, 
    -0.00612465f, -0.03636349f, 0.00669246f, 0.00067978f, -0.00984849f, -0.00610470f, -0.01494166f, 0.02155785f, 
    0.02267792f, -0.03613346f, 0.00539183f, 0.01191183f, 0.00227285f, 0.02076006f, 0.02155116f, 0.01878951f, 
    0.02823664f, -0.02737890f, 0.00477842f, 0.02408073f, 0.03537438f, -0.03555147f, -0.00403955f, -0.02082266f, 
    0.02635807f, 0.03648702f, 0.02722871f, -0.01056935f, -0.03486041f, 0.02183240f, -0.00951748f, -0.00288208f, 
    -0.01678630f, -0.00374120f, -0.02344076f, -0.02393196f, -0.00940299f, -0.02423346f, -0.00823267f, 0.02543831f, 
    -0.00590447f, -0.04080990f, -0.02057159f, 0.02349581f, 0.02156662f, 0.02255528f, 0.01302829f, -0.00848939f, 
    -0.02156693f, -0.02911683f, 0.00994862f, -0.03669607f, 0.00025876f, 0.00515232f, 0.00191690f, -0.02310770f, 
    -0.00592816f, 0.00058788f, 0.02318426f, 0.00609917f, -0.01261591f, 0.03211759f, -0.03523297f, -0.00269121f, 
    -0.01305261f, 0.02824862f, -0.03751694f, 0.02208428f, -0.02205815f, 0.01224551f, -0.00995671f, 0.03400221f, 
    0.02461650f, 0.02914704f, 0.00403029f, -0.00839670f, -0.03157078f, -0.02850675f, -0.01653037f, 0.01401381f, 
    -0.03458164f, 0.00195921f, -0.02019395f, -0.00149027f, -0.03024554f, -0.03537015f, 0.00684951f, -0.01938962f, 
    0.16184317f, 0.05687301f, -0.02508759f, -0.12942608f, 0.01771635f, 0.07021732f, -0.03514428f, 0.15447155f, 
    0.15804270f, 0.05445119f, -0.11888681f, -0.03063040f, -0.11327226f, -0.18162860f, 0.00912647f, 0.00934312f, 
    0.15187307f, -0.00850241f, -0.01513648f, 0.07158080f, -0.02573405f, -0.21374699f, -0.18419136f, -0.21551163f, 
    0.32387260f, -0.07402914f, -0.02727583f, -0.10056120f, 0.01464266f, -0.12138000f, -0.09171305f, 0.05122877f, 
    0.13246423f, -0.04510418f, -0.02857658f, 0.02920026f, 0.18647355f, -0.13126323f, -0.17042303f, -0.01780400f, 
    0.19215724f, -0.09734669f, -0.03256330f, -0.05317763f, 0.17811392f, -0.15254343f, -0.02983863f, 0.00052797f, 
    0.04135213f, -0.19645607f, 0.06665403f, -0.13847391f, 0.09455916f, 0.10090853f, 0.08827712f, 0.04236006f, 
    0.01490965f, 0.06466315f, 0.11771777f, -0.06046059f, 0.18686256f, -0.20962766f, -0.00589050f, 0.07018509f, 
    0.02983610f, -0.12944385f, -0.17516378f, -0.00733559f, -0.01426903f, 0.01242325f, 0.14585420f, -0.05743039f, 
    -0.34898815f, 0.03935189f, 0.07675598f, 0.13513373f, 0.11841156f, -0.05335017f, -0.10187812f, -0.22231777f, 
    -0.08983389f, -0.03462499f, -0.00927833f, -0.15146263f, 0.32145965f, 0.03537990f, -0.07406404f, 0.09536470f, 
    -0.01525745f, -0.03167594f, -0.13148442f, 0.03132036f, 0.12581973f, -0.15826650f, -0.07230781f, 0.07090001f, 
    -0.30964634f, -0.10855502f, -0.01565963f, -0.12600110f, 0.02846083f, -0.02376917f, 0.02416809f, -0.06888726f, 
    -0.01086238f, -0.00152156f, 0.18893564f, -0.15654823f, 0.18204564f, 0.05346281f, 0.02215135f, -0.06328171f, 
    -0.07636628f, 0.08955765f, -0.01298741f, 0.14592901f, 0.04731632f, -0.10888056f, 0.06892933f, 0.04555615f, 
    0.16417477f, 0.02399448f, -0.03903282f, -0.13915738f, 0.04775905f, -0.00531021f, 0.10778018f, -0.16057825f, 
    0.03562407f, 0.09795069f, 0.08943570f, 0.10025079f, -0.15136400f, -0.21598786f, 0.03577995f, -0.10161621f, 
    0.08519691f, 0.02928127f, -0.01845228f, -0.00047928f, -0.04040178f, 0.02141599f, 0.13454325f, 0.02998028f, 
    0.00235771f, 0.02685907f, 0.07158270f, -0.22189862f, -0.03985192f, -0.05033974f, -0.07008700f, 0.00200329f, 
    -0.00235183f, -0.01349820f, 0.07237743f, 0.03130771f, 0.36020851f, 0.01966340f, -0.09478873f, -0.10975769f, 
    0.11662938f, 0.09572680f, -0.14684804f, -0.13057634f, 0.07314985f, -0.19275156f, -0.17985749f, -0.15999326f, 
    0.03545961f, 0.13831466f, -0.05985662f, -0.02952886f, 0.03135603f, -0.01759268f, -0.00187332f, 0.01665597f, 
    0.00178509f, -0.14778899f, 0.11305489f, 0.08002553f, 0.31685323f, 0.01985157f, -0.11438347f, 0.03439942f, 
    0.04898013f, 0.13537249f, -0.07721743f, 0.04565757f, -0.05120790f, -0.07428517f, 0.23819788f, 0.04291976f, 
    -0.07891753f, -0.05536275f, -0.20775048f, 0.06323431f, 0.03191605f, 0.16334796f, -0.00022907f, 0.07741091f, 
    -0.01562452f, 0.12248104f, 0.08558191f, 0.01398587f, -0.04167426f, 0.07418691f, 0.16274619f, 0.13367185f, 
    0.06177343f, 0.06981299f, 0.04616970f, 0.13028292f, 0.12825204f, 0.02226092f, 0.02871121f, 0.17779990f, 
    0.15359893f, 0.00711012f, -0.19766213f, -0.13738553f, -0.02368427f, 0.03678851f, -0.04206542f, -0.01106081f, 
    0.13695405f, 0.10262480f, 0.09757532f, 0.20951615f, -0.05914833f, -0.03452390f, 0.10721868f, 0.19369687f, 
    0.03636641f, 0.14788418f, 0.06562385f, -0.08784374f, 0.09506816f, 0.01171495f, 0.01173179f, 0.14098115f, 
    0.14998503f, 0.02242823f, -0.07808388f, -0.05380443f, 0.09588804f, -0.04620043f, 0.07868353f, -0.13694814f, 
    0.08199995f, -0.05999757f, 0.01801166f, 0.04579907f, 0.15787737f, 0.16740976f, 0.29149440f, 0.07084574f, 
    -0.02303413f, -0.07094198f, -0.05863680f, -0.02997230f, -0.03881753f, -0.01088559f, -0.05067364f, 0.10959142f, 
    0.01828938f, 0.00421589f, 0.18846251f, -0.10630105f, -0.02880946f, -0.16961342f, 0.01979771f, 0.05450188f, 
    0.00067122f, -0.01288662f, 0.09010848f, -0.07165243f, 0.05197093f, 0.16208862f, 0.23162076f, -0.04224351f, 
    0.02702610f, 0.12534106f, 0.00566891f, 0.06013484f, 0.07563291f, 0.09533673f, -0.11867853f, 0.26173884f, 
    -0.12489264f, -0.05182603f, 0.20195442f, -0.16372034f, 0.18167168f, -0.07702022f, 0.08098575f, 0.04613855f, 
    0.04100555f, -0.04619069f, 0.09115989f, -0.07611644f, 0.23450693f, -0.14202353f, -0.01344359f, -0.05364291f, 
    0.12368529f, -0.12628272f, 0.01228240f, -0.09373697f, -0.05975524f, 0.03441030f, 0.12925333f, -0.05990234f, 
    0.15226404f, -0.10135797f, 0.00724904f, -0.11090940f, 0.10025096f, 0.09050329f, 0.00095281f, 0.04951199f, 
    0.15610634f, 0.06019273f, -0.02322890f, 0.09352288f, -0.26762280f, -0.26543602f, 0.03845398f, 0.17528850f, 
    0.12451082f, 0.08932588f, 0.01286655f, 0.14928405f, 0.04754725f, 0.19249381f, 0.05581613f, 0.09914712f, 
    -0.11554643f, -0.17026030f, 0.04268299f, 0.07768334f, 0.15493524f, 0.02119318f, 0.01344502f, 0.04442062f, 
    0.02200729f, -0.07815773f, 0.03411296f, -0.05075106f, 0.21687759f, -0.09595779f, -0.11172836f, -0.15750967f, 
    0.02116638f, 0.08507607f, 0.05764530f, 0.08219600f, 0.03321519f, -0.04090678f, -0.16908450f, 0.10238232f, 
    -0.02528910f, -0.15865198f, -0.09943637f, 0.10423388f, 0.10318570f, -0.05528437f, -0.02487580f, 0.10550053f, 
    0.19363868f, 0.00437431f, 0.05941816f, 0.19338700f, -0.32280537f, 0.05193619f, 0.11422994f, 0.11404354f, 
    0.13520575f, -0.16338162f, 0.02276847f, -0.20435509f, 0.10546876f, 0.16823149f, 0.03152175f, 0.04222585f, 
    0.27578726f, 0.25491202f, -0.00821878f, -0.11587068f, 0.04920181f, 0.01990775f, 0.05798260f, -0.04628013f, 
    0.14193721f, 0.08295407f, -0.20486940f, -0.07205803f, 0.25175750f, -0.06672110f, -0.11687725f, -0.10387584f, 
    -0.04475184f, 0.02478097f, 0.01928424f, 0.02202522f, 0.18387593f, -0.14272207f, -0.13709603f, -0.09063827f, 
    0.15982726f, 0.17563984f, 0.12153167f, -0.02199533f, -0.00171336f, 0.07393634f, 0.01092834f, -0.09251579f, 
    0.05564956f, 0.02734373f, 0.00469482f, 0.10682458f, -0.09241419f, 0.06183041f, -0.04684791f, 0.05926326f, 
    0.11969618f, 0.01655198f, 0.09140068f, 0.06306106f, 0.01018560f, 0.24900471f, -0.02994980f, 0.08459449f, 
    0.29590386f, 0.13739680f, 0.04741658f, 0.05503470f, 0.01437796f, 0.12121917f, 0.05109434f, 0.08189113f, 
    -0.00615507f, 0.17053552f, -0.13460149f, 0.01618825f, -0.07350992f, 0.08437461f, -0.20482814f, 0.15058598f, 
    0.09601668f, -0.00323160f, 0.04477300f, -0.01258815f, -0.06406600f, -0.06757911f, -0.02263687f, -0.15135054f, 
    0.15919296f, 0.17536829f, -0.01380123f, -0.08240227f, 0.03910019f, -0.08534217f, 0.17162144f, 0.10514650f, 
    0.00421097f, 0.02272598f, 0.08917538f, 0.19892833f, 0.16348170f, 0.15078788f, 0.03780714f, 0.05180502f, 
    0.03262575f, -0.03733208f, 0.11576664f, -0.03808944f, -0.15408827f, -0.13680610f, -0.01361368f, -0.05394750f, 
    -0.09817403f, -0.06501090f, 0.10761933f, -0.13251740f, 0.17355873f, 0.20701173f, 0.05647901f, 0.04579774f, 
    0.04607105f, -0.08132088f, 0.00632420f, 0.15807909f, 0.15997215f, 0.01685094f, -0.24392863f, -0.06075607f, 
    0.03020224f, 0.01222771f, 0.10495804f, 0.12367771f, 0.03169684f, -0.00235526f, 0.14814681f, -0.05582218f, 
    -0.09122297f, 0.14179887f, -0.00139262f, 0.03076818f, 0.05131172f, 0.08073609f, 0.17159623f, -0.03490848f, 
    -0.00289551f, 0.12109664f, -0.01120503f, 0.13321359f, 0.12008366f, -0.05031345f, -0.00090530f, -0.27328005f, 
    0.00998507f, -0.02994810f, 0.12436103f, 0.04218211f, -0.12618095f, 0.05684022f, 0.16482875f, -0.05477097f, 
    0.08272497f, -0.02709757f, 0.21714586f, 0.07297483f, 0.04115201f, -0.06899343f, 0.03906947f, -0.07428273f, 
    -0.04790264f, -0.11801123f, 0.11315637f, 0.18645957f, -0.03225028f, -0.16344386f, -0.09300566f, -0.06613187f, 
    -0.03871560f, -0.04484567f, 0.09885456f, 0.05326925f, 0.09129408f, 0.21786149f, -0.06982880f, 0.05018511f, 
    -0.06297216f, 0.11971766f, -0.07927270f, 0.00434371f, 0.03535635f, 0.13347897f, 0.02523854f, 0.00218627f, 
    0.00067405f, -0.04413594f, 0.08011901f, -0.20432064f, 0.02398520f, 0.05077686f, 0.11605276f, 0.05609637f, 
    0.02565124f, -0.06691874f, -0.14553416f, 0.01079057f, 0.01816045f, -0.03884974f, 0.11310858f, 0.02721716f, 
    0.13127767f, 0.04205895f, -0.05042914f, 0.16771543f, -0.06155610f, -0.08136141f, 0.14378180f, 0.00418457f, 
    0.02110481f, 0.02162847f, -0.15006147f, -0.03636312f, -0.01479010f, 0.05019145f, 0.06019824f, -0.01472634f, 
    -0.02076331f, -0.09171186f, -0.07899722f, 0.00647708f, 0.01795594f, 0.00310210f, -0.17158440f, 0.10957653f, 
    0.05268205f, 0.17323355f, 0.24709737f, -0.12956998f, 0.06811599f, 0.01672368f, 0.03999227f, 0.06276792f, 
    -0.07351086f, 0.02025976f, -0.04714517f, 0.26843435f, -0.11598945f, -0.07993968f, -0.15065120f, 0.04156468f, 
    0.14640276f, 0.09278701f, -0.04064957f, 0.02330078f, 0.07364897f, -0.08484256f, 0.03031683f, -0.06606107f, 
    -0.18369995f, -0.22888990f, 0.05349061f, -0.01511815f, 0.13461776f, -0.09464946f, 0.08459370f, -0.04887348f, 
    -0.03722829f, -0.17812203f, -0.08071888f, -0.02071670f, 0.02194206f, -0.02353372f, 0.14403145f, 0.18733956f, 
    -0.08186449f, 0.03205043f, -0.03612820f, -0.04703387f, -0.02989642f, -0.16592537f, -0.04400838f, -0.09201331f, 
    0.03705383f, -0.04720121f, -0.21732049f, -0.07093982f, 0.14882474f, -0.00782796f, 0.01077991f, 0.05146371f, 
    -0.01840476f, 0.04638049f, 0.17039551f, -0.15216899f, -0.07497662f, 0.05478609f, -0.05408626f, 0.06305961f, 
    0.02532689f, 0.09482143f, 0.03141338f, -0.03728582f, -0.00110595f, -0.07927045f, 0.03163972f, -0.01146115f, 
    0.19720896f, -0.00892663f, 0.14507186f, 0.02557277f, -0.02168986f, -0.04153331f, 0.07091524f, -0.00525728f, 
    0.00675860f, -0.08462930f, 0.05349051f, -0.07080561f, -0.07611353f, -0.10107598f, 0.02444231f, -0.17014383f, 
    0.03596040f, 0.24070574f, 0.02727434f, 0.04579641f, 0.18926005f, 0.16874295f, 0.00070280f, 0.08045118f, 
    -0.16637495f, -0.07826991f, 0.00244608f, -0.16571242f, -0.05082515f, -0.00035494f, 0.04769327f, 0.01972679f, 
    0.18450686f, 0.21556467f, 0.09828306f, 0.12557666f, -0.17839222f, 0.21972756f, 0.15091114f, 0.01873389f, 
    0.08590865f, -0.13096815f, 0.10957571f, 0.06372862f, -0.05853673f, -0.11457244f, 0.07561102f, 0.14631529f, 
    0.17654285f, 0.09335189f, 0.02210012f, -0.06794555f, 0.04475020f, 0.01620376f, 0.13067545f, -0.01030063f, 
    -0.04380537f, -0.10221253f, 0.00637409f, -0.02257187f, 0.12474405f, -0.18029119f, 0.05800535f, -0.17175581f, 
    -0.05666869f, 0.02160997f, 0.07208850f, 0.01632457f, 0.02755517f, 0.06668790f, 0.06432245f, -0.03939502f, 
    -0.57235914f, -0.26747137f, 0.10074971f, -0.11683761f, -0.00145570f, -0.14523049f, 0.05055436f, 0.18277162f, 
    0.00190578f, 0.17563368f, -0.17931868f, -0.02248084f, 0.13361950f, 0.12397287f, -0.04449190f, -0.15431498f, 
    -0.10476984f, -0.08970655f, 0.02081088f, 0.01080723f, -0.11978877f, 0.22597691f, 0.13845006f, 0.12413782f, 
    -0.04900610f, 0.00561258f, -0.05476326f, 0.04454747f, 0.04681531f, 0.05544752f, -0.00502874f, -0.01278331f, 
    0.01090977f, -0.00295557f, 0.02315184f, 0.12135065f, 0.02362328f, -0.02538155f, 0.06671640f, -0.19249001f, 
    -0.04277450f, 0.04333809f, -0.11638657f, -0.01484916f, 0.03663434f, 0.07961396f, 0.07980803f, 0.09599602f, 
    0.04077173f, 0.05380845f, -0.03794096f, 0.09233524f, 0.10820266f, -0.04590739f, -0.02831071f, 0.14743336f, 
    0.03789353f, 0.02124910f, 0.15768486f, 0.04327339f, -0.03093590f, -0.01865612f, -0.10997956f, 0.07475670f, 
    -0.05967713f, 0.09484459f, 0.05486063f, 0.02478660f, 0.02994694f, 0.00792450f, -0.01846602f, -0.03328413f, 
    -0.01689950f, 0.00144246f, 0.07562032f, -0.10397868f, 0.03426996f, 0.00531054f, -0.02734107f, 0.04366992f, 
    -0.02580894f, 0.02200320f, -0.02428223f, 0.01603760f, 0.27311966f, -0.28567806f, 0.13449098f, -0.04786631f, 
    0.04296749f, -0.09570486f, -0.04684187f, 0.06943627f, 0.11152510f, 0.08975629f, -0.06162644f, 0.05889924f, 
    0.22277950f, -0.04905698f, 0.06440778f, -0.21801589f, -0.08062481f, -0.11920464f, -0.08198448f, -0.02046011f, 
    0.10515317f, -0.05992094f, 0.07374356f, 0.15036672f, -0.05476625f, -0.23070441f, 0.03295373f, 0.20601846f, 
    0.09834981f, 0.01546730f, 0.03877288f, 0.01625805f, 0.06446253f, -0.04344978f, -0.10137346f, 0.13338539f, 
    -0.13300741f, -0.24011400f, 0.05748349f, 0.02921608f, -0.06862196f, 0.10597506f, 0.04489615f, 0.06606168f, 
    0.03230328f, 0.14025687f, -0.05814412f, 0.17070922f, 0.19403003f, 0.05042408f, 0.07742345f, -0.02615015f, 
    0.08661423f, -0.02134477f, 0.06233554f, 0.03511329f, 0.07377949f, 0.00927743f, 0.01001139f, 0.00917062f, 
    -0.03952637f, -0.25393426f, 0.00891385f, 0.12786160f, -0.02547036f, -0.00556539f, 0.03376684f, 0.08958241f, 
    -0.03069593f, 0.05517471f, -0.05875963f, -0.02150956f, -0.15015507f, -0.04613493f, 0.03877969f, -0.13858756f, 
    -0.02817255f, -0.12698233f, -0.00705973f, 0.10164942f, -0.01108599f, 0.01854205f, -0.02974826f, 0.00233965f, 
    0.18382278f, 0.02228633f, 0.14201190f, 0.02628062f, 0.12959386f, 0.03613998f, 0.04062279f, -0.02492958f, 
    0.02286519f, 0.05511016f, 0.04822377f, 0.04423455f, -0.10081286f, -0.20020489f, 0.02534413f, 0.07457113f, 
    0.01023943f, -0.02914144f, 0.00659395f, -0.00405797f, 0.09114596f, 0.05522083f, 0.06322691f, 0.10917182f, 
    -0.29907432f, 0.04252879f, 0.02733017f, -0.26203689f, 0.09051614f, 0.00867653f, 0.04629217f, 0.06513285f, 
    -0.03761500f, 0.04256845f, 0.08556571f, 0.03838259f, -0.04148942f, -0.02801141f, 0.00272776f, 0.15984675f, 
    -0.07466627f, 0.05562016f, 0.09569796f, 0.04226634f, 0.07036552f, -0.03599830f, 0.08573741f, -0.00221966f, 
    -0.07204773f, -0.00175499f, -0.05239008f, -0.10321268f, -0.03221307f, 0.03173396f, 0.06049019f, -0.09516672f, 
    0.01034808f, 0.06458615f, -0.01249511f, -0.02748433f, 0.22788987f, -0.00201816f, 0.04937414f, -0.17438902f, 
    0.00552509f, 0.05198580f, -0.01064967f, 0.04308696f, 0.05496766f, 0.00345665f, 0.22638264f, 0.05081617f, 
    0.25081080f, 0.06983027f, 0.03209588f, -0.03428011f, 0.08099265f, -0.08514590f, -0.05945913f, -0.03838914f, 
    -0.01703958f, -0.03806907f, -0.06784418f, -0.02234965f, 0.06087585f, -0.28867164f, 0.04366726f, 0.06863330f, 
    0.01555801f, 0.01381258f, 0.02765567f, -0.02726329f, 0.00782474f, 0.16261381f, 0.09681769f, 0.03194213f, 
    -0.08066268f, -0.17583258f, 0.04169085f, 0.06607024f, -0.05812147f, 0.02432223f, 0.01826785f, 0.09449576f, 
    0.06896407f, 0.08026382f, 0.00814128f, -0.10490801f, -0.02212175f, 0.05434908f, -0.20759700f, 0.12217566f, 
    0.08456564f, 0.03912069f, 0.01533136f, 0.06532754f, 0.00587213f, 0.15264246f, 0.09691367f, 0.03353927f, 
    0.01889021f, 0.25969642f, -0.03059626f, -0.12446665f, -0.04870043f, 0.02394465f, 0.03406836f, -0.01888246f, 
    0.12259761f, 0.05312034f, 0.18270935f, 0.05970740f, 0.05619984f, 0.04535704f, -0.00179745f, 0.11740987f, 
    0.01710176f, -0.00622814f, -0.05649119f, -0.01900759f, 0.01092812f, -0.09474664f, 0.02267707f, -0.05108840f, 
    0.13578834f, 0.08787165f, -0.14075987f, -0.18165068f, -0.10393775f, 0.16045821f, 0.01983543f, -0.00774136f, 
    -0.00221090f, 0.05682790f, 0.09701499f, 0.04563791f, 0.22753102f, 0.17181672f, 0.05913251f, 0.18199465f, 
    0.07945010f, 0.09855992f, 0.02653584f, 0.04017954f, 0.00702168f, 0.01349002f, 0.02864618f, -0.07811377f, 
    -0.13389985f, -0.06102160f, 0.15733783f, -0.07679178f, 0.03233288f, 0.00209679f, 0.01150145f, 0.05592968f, 
    0.03270188f, 0.03504705f, 0.01065681f, 0.03878945f, -0.12745807f, -0.18008861f, 0.04687279f, -0.09441684f, 
    -0.07380564f, 0.02677503f, -0.08366226f, 0.04051666f, 0.01975671f, 0.02778985f, -0.01997469f, 0.02508912f, 
    0.02034411f, -0.00841036f, 0.14469054f, -0.03863390f, 0.09957068f, 0.14535452f, 0.12441038f, 0.01008196f, 
    0.04158206f, -0.07614912f, -0.08676336f, -0.08309007f, -0.05711809f, -0.02361945f, -0.06973898f, -0.32662037f, 
    -0.00173095f, 0.07745749f, 0.08224880f, 0.04096688f, 0.04777105f, -0.09241732f, 0.00530616f, 0.04610522f, 
    0.08432658f, -0.11489704f, 0.04445678f, 0.15509722f, 0.01173217f, 0.09336966f, -0.02143049f, 0.05443814f, 
    0.02022839f, -0.05315227f, -0.02265345f, 0.05760897f, 0.07731067f, -0.02892073f, 0.04977508f, -0.15308079f, 
    -0.08030330f, 0.03081236f, -0.00420245f, 0.14643955f, -0.12326159f, -0.04651967f, -0.00573564f, 0.01983739f, 
    -0.04398891f, -0.16768491f, 0.04961493f, 0.09161196f, 0.07427748f, -0.07062880f, -0.04705647f, 0.05870053f, 
    -0.02636653f, 0.07333180f, 0.03147180f, 0.04460736f, -0.10209527f, -0.07475800f, -0.19475393f, 0.07411785f, 
    0.04899813f, -0.07935958f, 0.06198662f, -0.03470607f, 0.01569999f, -0.06822092f, 0.05395320f, 0.07104861f, 
    0.20554540f, 0.17358011f, -0.07395177f, 0.11008067f, 0.05181374f, 0.06748048f, -0.01777706f, -0.03245746f, 
    0.02831455f, 0.05001859f, 0.03732560f, -0.05860981f, 0.26370776f, 0.00513806f, 0.10449596f, 0.02474317f, 
    -0.05085354f, -0.01110044f, 0.00488462f, 0.12161049f, -0.13079664f, -0.00497340f, -0.06484336f, 0.04290754f, 
    0.23955716f, -0.08403835f, -0.12714247f, 0.16796675f, 0.02177480f, 0.02337216f, -0.01852369f, -0.03160981f, 
    -0.00827229f, 0.04780320f, -0.00630486f, 0.16234852f, -0.15014839f, -0.09309776f, 0.01565485f, -0.19176146f, 
    -0.06178147f, 0.02268201f, 0.14585200f, -0.03451570f, 0.07054149f, -0.01242895f, -0.03390143f, 0.09315259f, 
    0.10996670f, 0.10173454f, -0.03532306f, -0.14583996f, 0.13338386f, 0.09137826f, 0.05323483f, 0.06469549f, 
    0.02120534f, 0.06507743f, -0.00680181f, -0.00210434f, 0.27148676f, 0.26767331f, 0.06959037f, 0.12702800f, 
    0.01468358f, 0.06982370f, -0.09786982f, -0.02595666f, 0.11424328f, 0.04027446f, -0.03402949f, 0.03446150f, 
    -0.05985311f, -0.08372038f, 0.03622220f, -0.06410579f, -0.04304181f, 0.05317822f, 0.03428559f, 0.17152975f, 
    -0.07534119f, 0.06694798f, 0.02642922f, 0.15252073f, -0.15528323f, -0.07129636f, -0.11931377f, -0.28253689f, 
    0.01722251f, 0.12344930f, 0.10782853f, 0.06983279f, 0.00250407f, 0.02478274f, 0.05854778f, 0.01328468f, 
    0.31433386f, 0.06739911f, 0.02507009f, -0.00904598f, 0.05798922f, 0.08703907f, -0.01301371f, -0.03916926f, 
    0.05189355f, -0.02298267f, 0.08106392f, -0.00469283f, -0.06070996f, 0.18294640f, -0.20022224f, -0.16985835f, 
    0.00298874f, 0.02349294f, 0.06710371f, 0.01639486f, 0.06301490f, 0.02107398f, 0.09776051f, -0.10251115f, 
    0.25912943f, 0.14187455f, 0.17509589f, -0.05246828f, 0.18619169f, -0.06640040f, -0.06733857f, -0.01309940f, 
    0.03816918f, 0.02641360f, -0.01371060f, 0.02851571f, -0.11025915f, -0.08537665f, 0.15086350f, 0.06693217f, 
    0.00639882f, 0.07508676f, 0.02941857f, 0.07329049f, -0.00280320f, 0.08269224f, -0.03177450f, 0.00765605f, 
    -0.00456454f, -0.01718299f, 0.02374730f, -0.13770059f, -0.03904970f, 0.02474066f, 0.03915582f, -0.09036568f, 
    0.14661436f, 0.11616900f, -0.00273752f, 0.11816650f, -0.05724307f, 0.00740860f, 0.18818572f, -0.05828120f, 
    0.07173038f, -0.09822591f, -0.07397064f, -0.03082407f, 0.09650480f, 0.02710726f, 0.09134579f, -0.11512559f, 
    0.31801882f, 0.07334851f, -0.04937339f, 0.02755431f, 0.10889243f, 0.03195029f, 0.02045752f, 0.03637014f, 
    -0.04794548f, -0.04142528f, 0.01757274f, -0.03949153f, -0.34169433f, 0.08240395f, 0.11667810f, 0.13710497f, 
    0.07375289f, -0.07774421f, 0.02905185f, 0.09976048f, 0.19375336f, 0.05826687f, 0.02123813f, 0.10019574f, 
    0.20048989f, 0.25008112f, 0.07520669f, -0.01458857f, 0.09279139f, 0.05293437f, -0.07230823f, 0.03369270f, 
    -0.04579962f, 0.01759870f, 0.05301754f, -0.05701678f, -0.12269298f, -0.04439197f, 0.04126392f, -0.19612303f, 
    -0.11760344f, -0.04327440f, -0.05229358f, 0.02655928f, -0.05090222f, -0.01644840f, 0.04222237f, 0.09317965f, 
    -0.21023570f, -0.04686812f, 0.13053739f, -0.19501269f, 0.06742854f, 0.05928482f, -0.01860112f, 0.20671824f, 
    0.00759831f, 0.05787743f, 0.01019035f, 0.05959309f, 0.46354800f, -0.15750736f, -0.19832222f, -0.08991823f, 
    0.13008252f, -0.07448087f, 0.09236663f, -0.06478140f, 0.09161500f, 0.10486517f, 0.13667254f, 0.13780922f, 
    0.37265423f, -0.20742013f, -0.14213476f, 0.34610200f, 0.03174536f, 0.04035564f, -0.04333377f, -0.01544281f, 
    0.07962914f, 0.07256832f, -0.00123448f, 0.10102296f, 0.25082043f, -0.01577541f, -0.09922276f, 0.00841869f, 
    -0.03395460f, -0.03788748f, 0.01726595f, -0.04323455f, -0.00895893f, 0.01296723f, 0.06908117f, 0.01590976f, 
    0.02703139f, 0.13306849f, 0.03302372f, 0.00409957f, 0.09027722f, -0.05794415f, -0.00186154f, 0.03638288f, 
    -0.02265806f, 0.01998702f, 0.01868979f, 0.01093774f, 0.01103656f, -0.18785521f, -0.00165718f, -0.03938932f, 
    0.06913422f, -0.01782219f, -0.02188667f, 0.08929582f, -0.01038017f, -0.01596925f, 0.06184733f, -0.00919670f, 
    -0.08398346f, -0.00216594f, 0.00521123f, -0.10162652f, -0.09849873f, 0.04800415f, 0.13486554f, 0.02562263f, 
    -0.04938090f, -0.07859746f, -0.06584278f, -0.07945687f, 0.34093696f, 0.17930113f, -0.08607419f, -0.04575111f, 
    0.07433598f, 0.14855966f, -0.09314694f, 0.01761389f, 0.07082720f, 0.06978777f, 0.05769346f, 0.04640164f, 
    0.19821981f, 0.18466328f, 0.01934478f, 0.19010966f, 0.04994450f, 0.09067813f, 0.02430861f, -0.01569538f, 
    0.06247588f, 0.12115603f, -0.03989200f, 0.16924660f, 0.19829597f, 0.40110514f, -0.04232943f, 0.10058565f, 
    0.17301416f, 0.08131197f, 0.01450109f, -0.00690091f, -0.08098857f, -0.05828746f, -0.04157477f, -0.06695943f, 
    -0.45328936f, -0.19170678f, -0.03987261f, 0.14586727f, 0.08547968f, 0.09990752f, -0.08694532f, 0.11872310f, 
    0.09847619f, 0.02095543f, 0.10453312f, 0.07589263f, -0.00318134f, 0.05806643f, -0.09312731f, -0.25660685f, 
    0.07732221f, -0.00673041f, 0.06818009f, 0.00679968f, 0.15673764f, -0.02613512f, -0.04696690f, -0.09028873f, 
    0.01507959f, 0.01377023f, 0.01222339f, -0.00384495f, -0.01991463f, 0.02465682f, -0.01909190f, -0.01694373f, 
    -0.02139939f, -0.01273318f, -0.01530716f, -0.01909290f, 0.03314199f, 0.01379683f, 0.00579322f, -0.02579445f, 
    -0.03567551f, 0.01000788f, -0.00726569f, 0.02419233f, -0.01768981f, -0.00866095f, -0.02236412f, 0.03482556f, 
    -0.02297807f, 0.00814165f, 0.02574883f, 0.02586885f, 0.00709200f, 0.01483587f, 0.02044172f, 0.00100867f, 
    -0.02911815f, -0.01518953f, 0.01020421f, 0.01795725f, 0.02435638f, -0.01821339f, -0.01341417f, 0.03093042f, 
    0.01051262f, -0.00675393f, -0.01204156f, 0.03123271f, -0.01478903f, -0.00321855f, -0.03384446f, -0.01796128f, 
    0.02385365f, -0.03519768f, -0.03574365f, -0.03017943f, -0.02351124f, -0.03008779f, -0.02388047f, 0.02809407f, 
    -0.01705783f, -0.02781987f, 0.00946661f, -0.01403033f, -0.01835422f, 0.00538643f, 0.02988362f, 0.00569634f, 
    -0.01938086f, -0.03069440f, -0.00124940f, 0.02216421f, -0.03594863f, 0.01142346f, 0.02262427f, -0.03054962f, 
    -0.03112791f, -0.03318634f, 0.03501635f, -0.01203699f, -0.03084111f, -0.00273298f, -0.01540438f, 0.03138708f, 
    -0.02970580f, 0.02147880f, -0.03022051f, 0.00076823f, -0.01841921f, 0.02807674f, 0.00526195f, -0.02282051f, 
    0.02408845f, -0.02809168f, -0.01822495f, 0.03052914f, -0.02190467f, -0.03302175f, -0.00897092f, -0.02633074f, 
    -0.00040933f, 0.02326584f, 0.00610333f, -0.00072848f, 0.02090321f, -0.03456458f, -0.00871397f, -0.00780075f, 
    0.02381536f, 0.02361442f, 0.02024634f, 0.02814385f, 0.01782172f, 0.02209917f, -0.00213689f, 0.01968335f, 
    0.01875710f, 0.02751139f, 0.00971052f, -0.00568354f, 0.02173227f, 0.02076252f, 0.02431836f, 0.01426248f, 
    -0.01535462f, -0.01297930f, -0.02398359f, -0.00102700f, 0.00352133f, -0.00527973f, -0.02387485f, 0.00510136f, 
    0.00768218f, 0.00072392f, 0.02148078f, 0.02965168f, -0.03074102f, 0.03331292f, 0.02388461f, -0.01192870f, 
    -0.02516348f, -0.00451033f, -0.01106559f, -0.00192147f, -0.03551396f, -0.01419312f, 0.03132645f, -0.01430249f, 
    -0.02793572f, -0.01971995f, 0.02793081f, -0.01307338f, -0.02831629f, -0.03559927f, 0.00488675f, 0.01156364f, 
    0.02287882f, 0.01756880f, -0.00537038f, -0.01465266f, -0.02840124f, -0.03095855f, -0.00435486f, 0.03606428f, 
    0.02105087f, 0.00789101f, -0.00094062f, 0.03216965f, 0.00582198f, -0.03187291f, -0.00656522f, 0.01595128f, 
    0.03123371f, -0.03194689f, 0.00516021f, 0.02270726f, -0.03604241f, -0.01418382f, -0.02611614f, -0.02653421f, 
    0.01386654f, -0.02704609f, 0.01674250f, -0.03019108f, -0.00470452f, -0.00862906f, -0.03229947f, -0.01314212f, 
    0.02861893f, 0.01202319f, -0.00618436f, -0.02095369f, 0.02414408f, 0.02698181f, -0.02850530f, 0.02450304f, 
    -0.01916202f, 0.00065137f, -0.01423116f, 0.00328071f, 0.02550645f, 0.01047313f, -0.02856958f, -0.02713937f, 
    -0.02941538f, -0.02313028f, 0.01994240f, -0.00414828f, 0.00008053f, 0.00922344f, -0.03134550f, 0.01108728f, 
    0.01150843f, 0.02619584f, 0.02475547f, -0.02620799f, 0.03157084f, 0.01499560f, -0.00987579f, 0.00356188f, 
    0.02307797f, -0.03517036f, -0.02143427f, -0.00352421f, 0.01846426f, -0.03488383f, -0.01276090f, 0.00485333f, 
    0.01725300f, 0.02911465f, -0.01695065f, -0.00312980f, -0.02424303f, 0.01134099f, -0.00090639f, -0.02680407f, 
    0.03122203f, 0.02213169f, 0.03426836f, -0.01618056f, -0.02681175f, 0.00737140f, 0.03042060f, 0.01578556f, 
    -0.00540496f, 0.02595546f, -0.01804424f, -0.01463003f, 0.01970383f, 0.00215940f, -0.03428197f, -0.01448191f, 
    -0.01902383f, -0.01534433f, 0.01249288f, -0.01372902f, 0.02618669f, 0.00107477f, 0.00713073f, 0.00861221f, 
    -0.01190006f, -0.02782154f, 0.03114521f, -0.02583401f, -0.01018308f, 0.02489649f, 0.02597905f, -0.01670781f, 
    0.02866136f, 0.00977983f, 0.02291528f, -0.01694879f, -0.00566772f, 0.01987414f, -0.00777067f, -0.00653687f, 
    -0.03162359f, 0.01073453f, -0.02200984f, 0.00629916f, -0.03297070f, -0.02824095f, -0.01218219f, -0.01159438f, 
    0.02236682f, -0.03488846f, 0.02282089f, -0.02112087f, -0.02485571f, -0.02123310f, -0.02983119f, -0.02002305f, 
    -0.01282076f, 0.01491216f, -0.02225619f, 0.01784216f, -0.00477626f, -0.02307198f, 0.02994660f, -0.01026715f, 
    -0.01296523f, -0.00238367f, 0.02127580f, -0.00172596f, -0.01476361f, -0.00450627f, 0.01194938f, -0.02097582f, 
    0.03552790f, 0.00980310f, 0.02369095f, -0.01981805f, -0.01203416f, 0.00643599f, 0.01746583f, 0.02604368f, 
    -0.03186635f, 0.03054389f, -0.03094511f, 0.02183520f, -0.00783461f, -0.00426944f, 0.02163708f, 0.00380419f, 
    -0.00278041f, -0.02549601f, -0.02858393f, 0.01077712f, 0.00430325f, -0.02156473f, 0.02712024f, -0.00624254f, 
    0.00367778f, -0.03331266f, -0.01239983f, 0.03063538f, 0.01102886f, -0.02920970f, -0.01496788f, 0.00086524f, 
    0.01365320f, 0.01380339f, 0.03353296f, 0.03155894f, -0.03120905f, 0.02098159f, 0.01535115f, -0.00809507f, 
    -0.03174503f, 0.02666969f, -0.02954075f, 0.02058792f, -0.02540956f, 0.02380088f, -0.00750900f, 0.00881121f, 
    -0.00274240f, -0.02049409f, -0.01879303f, -0.02725168f, -0.03221991f, 0.03374196f, 0.01797682f, 0.00543574f, 
    0.03473465f, -0.02349932f, -0.02859357f, 0.02540386f, 0.02029562f, -0.00251722f, 0.00409897f, 0.02204897f, 
    0.02355842f, 0.00385584f, -0.01854573f, -0.00920861f, 0.01866336f, -0.03605200f, -0.01663840f, 0.02103617f, 
    0.01629786f, 0.03321274f, -0.02114432f, 0.02863881f, 0.02388141f, 0.02920705f, -0.01085460f, -0.03114954f, 
    0.02323335f, 0.01199193f, 0.01608061f, -0.02998316f, 0.01696463f, 0.01489597f, -0.01116519f, -0.02301833f, 
    -0.00727393f, 0.01028313f, -0.02607995f, -0.03091030f, -0.01714021f, -0.02468920f, -0.01606713f, -0.02760030f, 
    0.01945213f, 0.00969709f, -0.01686915f, -0.03247387f, -0.00155064f, -0.00790691f, 0.02661087f, -0.01518043f, 
    -0.02231675f, 0.02058911f, 0.01374360f, 0.01971572f, -0.02664237f, -0.03570065f, 0.03444223f, -0.03205683f, 
    -0.02204593f, -0.01679721f, -0.02281228f, -0.00659707f, -0.01194290f, 0.02383607f, 0.01617554f, 0.02668030f, 
    -0.01339248f, -0.01180798f, 0.03461282f, -0.00860845f, -0.03509185f, 0.03399647f, -0.00157703f, -0.03130268f, 
    0.00976641f, -0.03211195f, -0.01125582f, -0.00562187f, -0.03410346f, -0.01747010f, 0.00764762f, 0.00442835f, 
    -0.02542003f, 0.00271890f, 0.01252901f, -0.02505610f, 0.03387265f, 0.00310254f, -0.03119953f, 0.01670071f, 
    -0.01967439f, -0.01020303f, -0.02147098f, -0.00291055f, -0.00028382f, -0.00880357f, 0.02485352f, -0.00481921f, 
    -0.01994575f, -0.01075267f, 0.02909274f, -0.00029004f, 0.00642960f, -0.02889176f, 0.00508707f, -0.02593234f, 
    -0.03366889f, 0.00949433f, 0.00964878f, -0.01321869f, -0.00413996f, 0.02677378f, -0.00278342f, -0.00685865f, 
    -0.00104179f, -0.02121851f, -0.00736871f, -0.00610120f, -0.00403265f, -0.00193991f, 0.00374981f, 0.03254231f, 
    0.01687141f, -0.00023079f, 0.01486864f, 0.00218870f, 0.01569925f, 0.02905649f, 0.01087529f, -0.01379354f, 
    -0.00748320f, -0.02932592f, 0.03042106f, 0.02837311f, 0.00464520f, -0.03185958f, -0.02007449f, 0.03416879f, 
    0.02867117f, -0.00030261f, 0.01437734f, 0.02031394f, -0.02361261f, 0.02866722f, -0.01802951f, -0.01220442f, 
    -0.01254416f, -0.00207351f, 0.01815163f, -0.00834714f, 0.00189396f, -0.02699644f, 0.01648477f, 0.00543936f, 
    0.00655828f, -0.03141497f, -0.02132850f, -0.03016005f, -0.00784790f, 0.02538073f, -0.02186078f, -0.00632501f, 
    0.02062113f, -0.02229257f, -0.00622823f, -0.00916729f, -0.02875838f, -0.01243867f, -0.00834156f, 0.01281045f, 
    -0.00781389f, -0.03600500f, 0.01506051f, 0.02414285f, 0.02531477f, -0.01355506f, 0.02006133f, -0.00885165f, 
    -0.00990385f, 0.02976034f, 0.01060800f, -0.03181259f, 0.01316942f, -0.01567616f, -0.03570283f, -0.02434834f, 
    0.03115410f, -0.02882837f, -0.01410473f, -0.01690518f, -0.00860004f, 0.02856891f, 0.00029979f, 0.03492935f, 
    -0.02763562f, -0.02030945f, -0.01529310f, -0.03423015f, -0.01541756f, -0.02339497f, 0.03483619f, 0.02218947f, 
    -0.02110276f, -0.01808550f, -0.01676911f, 0.01015527f, -0.03289706f, -0.03004915f, 0.01920776f, 0.03350018f, 
    0.02329366f, -0.00879448f, -0.02428186f, 0.02033788f, -0.01910028f, 0.03585555f, 0.02455120f, -0.01816695f, 
    0.03108762f, 0.02177857f, -0.00920158f, 0.01087413f, 0.02607307f, -0.03344104f, -0.00089175f, -0.01789594f, 
    0.02399239f, 0.03300276f, 0.01695061f, -0.00357034f, 0.00801301f, 0.00701886f, 0.03384975f, -0.03443777f, 
    -0.02652242f, -0.00207010f, 0.01141238f, -0.02994789f, -0.01136706f, 0.00042616f, -0.01695047f, -0.01864552f, 
    -0.03109953f, 0.00113476f, 0.03149537f, 0.01369903f, -0.01644926f, -0.01638932f, 0.01616762f, 0.00920179f, 
    -0.00712858f, 0.01401106f, 0.02918543f, 0.00993069f, 0.00143520f, 0.00092951f, 0.01697515f, -0.03084939f, 
    0.03166401f, 0.01859365f, -0.03367274f, -0.01560043f, 0.01030589f, 0.00762091f, -0.01329373f, 0.03502331f, 
    0.00512989f, 0.00418111f, 0.02842132f, 0.01325577f, -0.02110485f, 0.00067425f, -0.00640765f, 0.00371695f, 
    -0.00435783f, -0.00090714f, -0.02774513f, -0.02757386f, 0.01015197f, 0.02358963f, 0.01469657f, -0.00433953f, 
    -0.02774245f, -0.03289669f, -0.03582064f, 0.01496510f, 0.03554313f, -0.02076581f, -0.02403928f, 0.00782563f, 
    -0.02984001f, -0.03001238f, -0.02289625f, -0.02357950f, -0.00869262f, -0.02481368f, -0.02392836f, 0.00850794f, 
    0.00992086f, -0.02697701f, -0.03478961f, -0.02152201f, -0.03368764f, -0.01019707f, -0.01982642f, -0.01254232f, 
    -0.01846440f, -0.01863926f, 0.00305143f, -0.01045933f, -0.02289617f, 0.02371051f, 0.02015165f, -0.02341085f, 
    0.00542533f, 0.01599431f, -0.03371941f, 0.02929340f, -0.01683688f, -0.03460151f, 0.02089296f, -0.02269354f, 
    -0.02772151f, 0.02438851f, -0.03068272f, -0.00248816f, -0.03287049f, -0.02898490f, 0.02747764f, 0.00477049f, 
    0.00405381f, 0.02984500f, -0.02988222f, -0.02014202f, 0.03561679f, 0.01257768f, -0.01067048f, -0.01941647f, 
    0.01666356f, -0.03538302f, 0.03547565f, 0.01693020f, 0.00513527f, -0.01141849f, 0.03332798f, 0.02163321f, 
    0.00864687f, 0.00765429f, -0.03377511f, 0.00666690f, -0.00102952f, -0.02590602f, 0.03488292f, -0.00113117f, 
    -0.02649589f, 0.01517083f, -0.00187719f, -0.02905167f, 0.01204629f, 0.01904969f, 0.02138080f, 0.01114770f, 
    0.01181784f, 0.02642423f, 0.03522823f, 0.00306900f, 0.02153928f, -0.01657142f, -0.01796909f, 0.01434787f, 
    -0.02336199f, 0.00124470f, -0.00567974f, -0.00016200f, -0.01486371f, -0.00814823f, -0.01784564f, 0.02800093f, 
    -0.01483501f, 0.02503621f, -0.01255206f, -0.01715536f, 0.02353106f, 0.02650825f, -0.03241409f, -0.02559941f, 
    -0.00306636f, 0.02687632f, -0.02663395f, -0.02294195f, 0.00459344f, -0.01658290f, -0.00755593f, 0.02113843f, 
    -0.00142546f, 0.00490872f, -0.03314317f, -0.01880635f, -0.02610173f, 0.03312369f, -0.00000743f, -0.01861808f, 
    -0.03065506f, -0.02605858f, 0.00590132f, -0.03374158f, -0.00018717f, -0.02547154f, 0.02871305f, -0.03500827f, 
    -0.01697892f, -0.01139246f, -0.00886500f, -0.01034909f, 0.00838781f, 0.00866214f, -0.01245670f, -0.03348928f, 
    -0.01210703f, 0.02207055f, -0.04166563f, 0.02350958f, -0.01863098f, -0.00588830f, 0.00696655f, 0.01887552f, 
    -0.01488491f, -0.02547821f, 0.01840497f, -0.02835508f, 0.00122213f, 0.02279987f, -0.03561613f, -0.02014807f, 
    -0.02592642f, -0.02565148f, -0.00072669f, -0.02969876f, 0.01733116f, 0.01357227f, -0.03140673f, -0.03035076f, 
    -0.03531659f, -0.03430001f, 0.01897706f, -0.02044472f, -0.01151196f, 0.00758472f, 0.02538923f, 0.01053339f, 
    0.01970764f, -0.00335226f, 0.00638634f, -0.03692188f, -0.02161148f, -0.00401211f, -0.00689605f, 0.02131808f, 
    -0.02516116f, -0.01369963f, -0.00974500f, 0.02604110f, 0.00022936f, -0.00449020f, 0.02530359f, 0.01207156f, 
    0.01781614f, -0.04039967f, -0.03842515f, 0.01113048f, 0.00745957f, 0.01698839f, 0.00563609f, -0.03713910f, 
    -0.02393403f, 0.01684702f, -0.01871418f, 0.01253024f, 0.02172594f, 0.00873187f, -0.02303140f, 0.01658687f, 
    0.01553033f, -0.00633721f, 0.01012708f, -0.01936327f, -0.01994272f, -0.02369761f, -0.01556444f, -0.01369766f, 
    -0.00336909f, 0.00695635f, 0.01995867f, -0.00307451f, -0.00032906f, 0.01632973f, -0.01993908f, 0.01830290f, 
    0.00798962f, 0.00083509f, -0.03364294f, 0.01723686f, 0.01309365f, -0.03862207f, 0.02854628f, -0.03103875f, 
    -0.01187532f, -0.03933959f, -0.00541981f, 0.00030339f, -0.02703875f, 0.00928919f, -0.02805179f, -0.03714706f, 
    -0.01802651f, 0.01968582f, 0.01391504f, -0.00767805f, -0.00319313f, -0.01896303f, 0.00519536f, -0.02870434f, 
    0.02380491f, 0.02130948f, 0.02545330f, 0.02139407f, 0.02842423f, -0.01759940f, 0.00474381f, 0.02459641f, 
    -0.00836839f, 0.02291288f, 0.01994751f, -0.02201800f, -0.03456048f, -0.00673826f, 0.00076294f, 0.00749235f, 
    0.00304586f, 0.02715914f, 0.02644319f, 0.01070312f, -0.00917555f, 0.03028837f, 0.00140353f, -0.03048570f, 
    0.00000920f, 0.00907509f, -0.01463359f, -0.00151547f, -0.01582576f, 0.00733744f, -0.01857122f, 0.00307520f, 
    0.00153715f, -0.01381153f, -0.01752802f, 0.01150362f, -0.02669807f, -0.01153652f, -0.01161207f, 0.00872377f, 
    0.02478557f, -0.00171118f, -0.03313217f, -0.01134286f, -0.00681979f, -0.02981384f, 0.02725727f, -0.03915302f, 
    -0.02261209f, -0.03824943f, -0.00194920f, -0.03797150f, -0.01127892f, -0.02598634f, -0.03327737f, 0.00783793f, 
    0.00858854f, -0.03739366f, 0.00694350f, -0.00144694f, -0.01407395f, -0.00438178f, 0.02718514f, -0.03461915f, 
    0.02172787f, -0.00798701f, -0.02747991f, -0.02559983f, -0.01774331f, 0.01230859f, -0.02063212f, 0.02165947f, 
    -0.01857817f, -0.04092071f, -0.02313286f, -0.02204530f, -0.01818869f, -0.02787423f, 0.00338823f, 0.01222825f, 
    -0.03812581f, -0.03631557f, -0.01620200f, 0.02188578f, -0.02051762f, 0.01373408f, -0.02442007f, 0.00469971f, 
    0.00841235f, 0.02790048f, -0.00866871f, 0.01159147f, -0.02814430f, 0.00622716f, -0.02636636f, -0.02769690f, 
    -0.04089496f, -0.04072977f, -0.02159656f, 0.00701228f, 0.00493050f, 0.02478423f, 0.01602522f, -0.01024573f, 
    0.00148855f, -0.01358758f, -0.02532813f, 0.02592681f, 0.01602332f, 0.00195425f, -0.02375447f, 0.02550891f, 
    -0.01570478f, 0.02591949f, -0.02010515f, -0.02801478f, 0.01564347f, -0.03977390f, 0.02992470f, -0.03789184f, 
    0.02772105f, 0.01315125f, 0.02671667f, -0.02840159f, 0.02290764f, 0.01072197f, 0.00346090f, -0.02104013f, 
    -0.02450463f, -0.01853694f, -0.01490491f, 0.02343645f, -0.02390195f, 0.02340581f, 0.01745312f, -0.00607469f, 
    -0.03067609f, 0.00732681f, -0.00365388f, -0.00928283f, -0.04105918f, -0.03169176f, 0.02132807f, 0.02374087f, 
    -0.00284998f, 0.00800544f, -0.01848005f, 0.01950841f, -0.02111774f, 0.01738214f, 0.00246733f, 0.02056611f, 
    0.01004031f, -0.04133416f, -0.04067167f, 0.00292917f, 0.01826056f, -0.03468977f, 0.01534435f, -0.00636249f, 
    -0.00214657f, -0.03362680f, -0.02101677f, 0.00181245f, -0.03645969f, -0.00926867f, -0.00898629f, -0.02479870f, 
    0.01960011f, 0.02284339f, -0.03042799f, 0.00690484f, -0.00878131f, 0.02164252f, 0.00020862f, -0.02305482f, 
    -0.01725168f, -0.00630899f, -0.00228300f, 0.02669113f, 0.02994723f, -0.01907555f, -0.00135011f, 0.03005829f, 
    -0.00219674f, 0.00088368f, 0.01236983f, -0.02007922f, -0.01182257f, -0.04084582f, -0.00357741f, -0.00336921f, 
    0.00101533f, -0.03522499f, 0.00770645f, -0.02535259f, -0.02588884f, -0.00073452f, 0.01911286f, 0.02384708f, 
    -0.03355092f, 0.00790688f, -0.01718665f, -0.01356230f, -0.02048934f, 0.00243184f, 0.01698597f, -0.03463222f, 
    -0.01138029f, -0.01430821f, -0.03065156f, 0.01407405f, -0.03940189f, -0.02879419f, -0.02784508f, -0.03531396f, 
    -0.01036732f, 0.02299709f, 0.00327238f, 0.02535306f, -0.01851275f, 0.02061746f, 0.00717461f, 0.00201711f, 
    -0.01549449f, 0.03091744f, -0.00858427f, 0.02380132f, -0.01678989f, -0.01076636f, -0.00897463f, -0.03422593f, 
    0.01463042f, 0.01814456f, -0.02671151f, 0.01901061f, -0.01612504f, -0.01900099f, -0.00521053f, 0.01094676f, 
    -0.01096473f, -0.01792612f, -0.03266121f, 0.00714539f, -0.02521727f, -0.04202234f, -0.04180054f, -0.02238198f, 
    0.01273682f, -0.00966490f, 0.00735465f, 0.01958185f, 0.01729773f, -0.00702180f, -0.03387884f, -0.01603831f, 
    0.01619636f, -0.03338220f, -0.03320004f, 0.00742077f, 0.02120578f, 0.00456889f, -0.01445779f, 0.00811012f, 
    0.00456997f, 0.00670373f, -0.03029566f, 0.01768294f, 0.02444495f, 0.01980189f, 0.01853707f, -0.02337226f, 
    -0.03018502f, -0.04059740f, -0.01171482f, -0.01403580f, 0.01169675f, 0.01663318f, -0.00656065f, 0.00914439f, 
    -0.04056488f, 0.00976313f, -0.00960058f, -0.03078737f, -0.02149342f, 0.02513635f, 0.01066938f, -0.02028947f, 
    -0.03752603f, -0.01793340f, -0.03904564f, 0.02273944f, 0.02512087f, 0.02252520f, 0.02439532f, 0.02424292f, 
    0.00921478f, 0.00743050f, 0.02194579f, 0.02544072f, 0.00982566f, 0.02220109f, 0.01890234f, 0.01579320f, 
    0.02454578f, -0.03122537f, -0.00085263f, 0.02288764f, 0.00703975f, -0.02475055f, 0.00635653f, -0.02873811f, 
    -0.03858708f, 0.02943891f, -0.00864636f, -0.00114189f, 0.02470503f, -0.02421673f, -0.00001571f, -0.02709430f, 
    0.03003233f, -0.00607259f, 0.01611070f, -0.00336514f, 0.00697017f, 0.02767808f, -0.02747720f, -0.02085289f, 
    0.01146288f, 0.03008385f, -0.02242401f, 0.00791592f, 0.01572069f, 0.00705552f, 0.00611696f, -0.00535466f, 
    -0.03034800f, 0.01835662f, -0.00916368f, -0.02068534f, -0.01852909f, 0.02941704f, -0.01263752f, 0.02883730f, 
    -0.02208208f, 0.02219385f, -0.01650682f, -0.02234999f, -0.01113075f, -0.03117760f, -0.02917227f, 0.02321482f, 
    0.00197681f, -0.01000400f, -0.01395883f, -0.00026801f, 0.00173146f, 0.02032247f, -0.03751209f, -0.01479073f, 
    -0.02121236f, -0.01689019f, 0.01700966f, 0.01519078f, -0.03525570f, 0.02814320f, -0.00968263f, -0.01551706f, 
    0.02440647f, -0.02201551f, 0.00887234f, 0.02813461f, -0.02158446f, -0.03000676f, 0.00665699f, 0.00303952f, 
    -0.03703988f, -0.02311644f, -0.01066787f, -0.01064293f, -0.00327845f, -0.02687663f, -0.03667596f, 0.01771346f, 
    0.01422893f, 0.00533811f, -0.03695836f, -0.00257891f, 0.00571310f, 0.02047295f, -0.03360315f, 0.02328786f, 
    -0.01517597f, 0.00979180f, -0.01571316f, -0.01785284f, -0.01133219f, 0.00584119f, -0.02392648f, -0.01656024f, 
    0.00608595f, 0.00769217f, 0.01813607f, 0.00793319f, -0.00147309f, -0.01391589f, -0.03274371f, -0.03482453f, 
    0.00153986f, -0.01080943f, 0.00909019f, 0.00948659f, -0.01027686f, -0.02816165f, -0.01146758f, -0.01799784f, 
    -0.02671079f, -0.01899504f, -0.04072642f, 0.01837273f, 0.00528200f, -0.03474387f, -0.02055468f, 0.00424107f, 
    0.03001667f, -0.00708791f, -0.00959117f, -0.00171516f, -0.00791872f, 0.00372657f, -0.03540899f, -0.02077380f, 
    0.01004420f, -0.04028483f, 0.01766117f, -0.02745559f, -0.03592525f, -0.01238372f, -0.04046955f, -0.01403063f, 
    0.00087249f, -0.00375128f, 0.00595888f, 0.02418645f, 0.00131295f, 0.02401358f, 0.01047997f, 0.00729245f, 
    0.02021266f, 0.00727345f, -0.01732999f, -0.03438798f, -0.01110304f, 0.01031467f, -0.02260212f, -0.02186238f, 
    0.00807975f, -0.00896408f, 0.00432771f, 0.00258701f, -0.03781679f, -0.00913126f, 0.00640558f, -0.03034231f, 
    0.02864662f, -0.01111386f, -0.03885901f, -0.03373168f, -0.00327684f, 0.01342840f, -0.03333287f, 0.01914269f, 
    0.01093767f, -0.01187040f, -0.04036080f, 0.00445229f, -0.02446439f, -0.02634557f, 0.02729058f, -0.02774028f, 
    0.01865502f, -0.01538184f, -0.00848356f, 0.00456055f, -0.01797963f, -0.01780580f, -0.04067757f, -0.02510392f, 
    0.01019841f, 0.00928267f, -0.01708286f, -0.00173536f, 0.00594435f, -0.00952742f, 0.02885968f, -0.03596690f, 
    -0.02881381f, -0.03089218f, -0.01829319f, -0.03689238f, -0.00894456f, 0.00632397f, -0.00854849f, 0.01329455f, 
    -0.03261834f, -0.00223529f, -0.00874198f, -0.02256336f, -0.01850893f, -0.00777204f, -0.02679042f, -0.01175799f, 
    -0.00496157f, -0.02848157f, 0.01345089f, -0.00875826f, -0.02339610f, -0.00576313f, 0.01977786f, -0.02927493f, 
    0.00925638f, -0.00016711f, -0.00341012f, -0.01789453f, -0.00132344f, -0.03657601f, -0.00351390f, -0.03082956f, 
    -0.02381018f, 0.01719255f, 0.01590825f, 0.02853524f, 0.01988235f, -0.00026792f, -0.03346943f, -0.01698119f, 
    -0.04031899f, -0.02783824f, 0.01759307f, -0.02532583f, -0.00875950f, 0.01136446f, -0.03013336f, -0.01202368f, 
    0.02152822f, -0.01169514f, -0.01536186f, 0.01769466f, 0.02955337f, -0.02029955f, -0.03899571f, -0.02614380f, 
    -0.00907482f, 0.01662916f, -0.00686279f, -0.02243977f, -0.01560972f, 0.02342117f, 0.02281860f, -0.02509053f, 
    0.00678809f, 0.01457580f, -0.04074024f, -0.03918947f, -0.02307799f, 0.01937751f, 0.00945473f, -0.03263573f, 
    0.01433339f, -0.01967763f, 0.00646558f, -0.02222108f, -0.01386250f, 0.00120646f, -0.01938323f, -0.01154660f, 
    -0.00393582f, 0.02644293f, -0.02307819f, 0.02847095f, -0.03745449f, -0.02218079f, -0.00511924f, -0.00480070f, 
    -0.03286023f, 0.01348240f, 0.00209887f, -0.03995093f, 0.00377161f, 0.02844310f, -0.01701913f, 0.00020724f, 
    -0.02211715f, -0.00037304f, -0.00922729f, -0.01367631f, 0.00357775f, 0.01692297f, 0.00846524f, -0.01278273f, 
    0.00665099f, -0.03861914f, 0.01917022f, -0.04008837f, 0.00074548f, -0.02568234f, 0.01409068f, -0.01201492f, 
    0.01553786f, -0.01678720f, -0.03000611f, -0.02034856f, 0.01374617f, -0.00048899f, 0.02776830f, -0.00096405f, 
    -0.03156298f, 0.02134545f, -0.00454422f, 0.01257614f, -0.00696191f, -0.04067027f, -0.00122188f, 0.02650653f, 
    -0.01258731f, 0.02420617f, -0.04009918f, -0.02499269f, -0.03384555f, 0.00833772f, -0.00343129f, -0.02994442f, 
    0.00273721f, -0.02576753f, -0.00453286f, 0.01658541f, 0.01230950f, -0.03715790f, -0.02308462f, 0.02196646f, 
    -0.03230531f, -0.01028674f, -0.04094024f, -0.01262783f, 0.02712900f, -0.02580709f, 0.00072085f, -0.00204233f, 
    -0.01619784f, -0.00472260f, -0.02036592f, -0.01019419f, -0.02725344f, -0.02740705f, 0.01777212f, -0.03664049f, 
    -0.03764134f, 0.01396892f, -0.13368464f, -0.08643585f, 0.10132487f, 0.12902804f, -0.00243882f, 0.06618439f, 
    0.02011497f, 0.12501170f, 0.00930464f, -0.00857076f, -0.20342757f, -0.04368033f, 0.10273041f, 0.26569721f, 
    0.10033491f, 0.00294160f, 0.03494950f, 0.18187875f, 0.02329183f, -0.04785356f, -0.04951094f, -0.08130287f, 
    0.00679840f, -0.07810072f, 0.00538937f, 0.14093149f, -0.00281911f, -0.04247777f, -0.08847974f, 0.06568956f, 
    0.03395058f, 0.10343327f, -0.09097532f, 0.02291058f, 0.21070738f, 0.03572886f, -0.18495187f, -0.08776789f, 
    0.02378529f, 0.02421980f, -0.21768379f, 0.15059058f, 0.08183689f, -0.06325152f, 0.11453342f, 0.04760487f, 
    0.16511545f, -0.03010845f, -0.24566604f, 0.08013115f, 0.03764213f, 0.15884249f, 0.03143179f, 0.04579450f, 
    0.15998663f, -0.04566650f, 0.18588457f, 0.03427238f, -0.34709984f, 0.11444816f, 0.19301590f, -0.05919693f, 
    0.20751300f, -0.06139794f, -0.09343032f, -0.11442576f, 0.10801063f, -0.07140404f, 0.29933408f, -0.00901126f, 
    0.08962233f, -0.28317344f, 0.35618529f, 0.07933037f, 0.07609433f, 0.04073107f, -0.07947359f, 0.06922945f, 
    -0.01756064f, 0.10930118f, 0.04146504f, 0.00644014f, 0.11427713f, 0.03300181f, 0.11742883f, -0.13856778f, 
    -0.04575370f, -0.00165181f, -0.11956844f, 0.08728557f, 0.01954227f, 0.04339625f, 0.06806150f, -0.05264872f, 
    -0.38597068f, -0.05882757f, 0.00095855f, -0.06581517f, -0.05276698f, 0.09146327f, 0.03512582f, -0.12443346f, 
    -0.06426494f, -0.24243437f, 0.17305836f, -0.05077001f, 0.00864457f, -0.05949614f, 0.14675833f, -0.02005209f, 
    0.14539646f, 0.09175549f, 0.03454073f, -0.02929307f, 0.16099380f, -0.02980939f, 0.16053209f, 0.13158269f, 
    -0.48001489f, -0.15290809f, -0.02699884f, -0.12997819f, 0.14148690f, 0.09645628f, 0.05304450f, -0.16842644f, 
    -0.02876469f, -0.07478672f, 0.13256560f, -0.01099078f, -0.11050770f, 0.09075809f, -0.03821531f, 0.05523388f, 
    0.00666176f, 0.03147056f, -0.06680299f, -0.08011284f, 0.01733068f, -0.09242336f, 0.10976658f, 0.04539981f, 
    0.05931047f, 0.31502905f, -0.12748975f, 0.11579708f, 0.02958992f, 0.07994345f, -0.05495061f, 0.02944539f, 
    0.04957511f, -0.07568924f, 0.07827345f, 0.04348610f, -0.03617039f, -0.03445418f, -0.21010499f, -0.14510275f, 
    0.01504198f, 0.13938753f, -0.12048741f, -0.10654564f, -0.03600648f, -0.03380334f, 0.00321100f, -0.02019886f, 
    -0.00585211f, 0.09759585f, -0.00929207f, -0.08391947f, 0.08646338f, -0.08434337f, 0.05387114f, 0.05380765f, 
    0.09192052f, -0.03431240f, -0.09799083f, 0.05960696f, -0.53661317f, 0.10456987f, 0.07059064f, -0.23706856f, 
    0.03241921f, -0.01711149f, 0.09944410f, 0.04832283f, -0.02243868f, -0.01357220f, 0.08028156f, 0.07009282f, 
    -0.10983559f, -0.03465749f, -0.00232313f, 0.11267977f, -0.08341740f, -0.03455221f, -0.07723590f, -0.09037237f, 
    0.01888780f, 0.04362149f, 0.30129653f, 0.10838686f, 0.14518082f, 0.07101168f, -0.05038207f, 0.25555190f, 
    -0.07844823f, 0.09468625f, 0.07570004f, 0.11454552f, 0.01636396f, 0.00239753f, -0.22399999f, 0.13125429f, 
    0.22591197f, -0.04826491f, 0.04993226f, 0.10312727f, 0.08309451f, 0.02556814f, 0.06599430f, 0.05855075f, 
    -0.04437747f, 0.04194900f, 0.04026789f, 0.15316218f, -0.25036901f, 0.10411184f, -0.03573637f, 0.02749202f, 
    -0.04338570f, -0.01818443f, 0.14849950f, 0.03749894f, -0.01761681f, -0.05088942f, -0.05995325f, 0.12829444f, 
    -0.29522553f, -0.21422039f, -0.09609094f, -0.15717031f, 0.08032110f, -0.01521942f, -0.02985893f, -0.15927751f, 
    0.01043661f, -0.07300772f, 0.00644016f, 0.11944690f, -0.07567170f, 0.06191517f, 0.10472380f, -0.03617011f, 
    -0.02253678f, -0.05238624f, 0.03623177f, -0.08576468f, 0.10679635f, -0.09568022f, 0.02344258f, 0.09586340f, 
    0.15984441f, 0.10754384f, -0.09685297f, 0.36937928f, 0.11819603f, -0.02429613f, 0.03637916f, -0.05216587f, 
    0.02153669f, -0.05488336f, -0.06900696f, -0.04130853f, -0.01290762f, 0.07583091f, 0.20877784f, -0.10670928f, 
    0.05230502f, 0.10720559f, -0.00101458f, -0.06541389f, 0.03870662f, 0.08286196f, -0.05199144f, 0.05235424f, 
    0.15060563f, 0.10542317f, 0.07227286f, 0.16219726f, 0.06414028f, -0.10186414f, -0.19965331f, 0.21164453f, 
    0.27921429f, -0.17287271f, -0.04585752f, 0.06118659f, 0.15424491f, 0.05963021f, -0.18352863f, 0.04656804f, 
    -0.03912107f, 0.01132975f, -0.12560268f, -0.02878451f, 0.00038776f, -0.04143008f, 0.00360239f, 0.12245311f, 
    0.01934482f, -0.03398078f, -0.08179178f, -0.15567768f, 0.05840430f, 0.02302538f, -0.01239046f, 0.06986472f, 
    0.12414274f, -0.04961273f, -0.01839702f, -0.18254565f, -0.16736038f, -0.08305130f, 0.20006256f, 0.14771950f, 
    0.11104201f, 0.05513421f, 0.01731097f, -0.07769734f, 0.03226584f, 0.06983445f, 0.03920529f, 0.09398345f, 
    -0.49952787f, 0.00113530f, -0.04114875f, -0.01905155f, 0.06919888f, -0.05591296f, -0.15541050f, 0.06270107f, 
    0.01637282f, 0.20629665f, 0.15126312f, 0.03439590f, -0.19061311f, 0.15734409f, -0.13942997f, 0.18801552f, 
    0.05981908f, 0.07790925f, 0.04611394f, -0.01746189f, -0.00943903f, 0.08633383f, -0.16148536f, 0.11112361f, 
    -0.09733661f, -0.04086847f, -0.01656365f, -0.16587315f, 0.02933065f, -0.03364011f, 0.02325881f, -0.13223648f, 
    0.10633197f, 0.00629824f, -0.04521945f, 0.05821030f, -0.18874300f, -0.15359922f, -0.08492550f, 0.03437624f, 
    0.02048719f, -0.04321554f, 0.04093226f, -0.01709118f, 0.12169650f, -0.06605459f, 0.00503174f, -0.08135422f, 
    -0.21417533f, 0.16231082f, -0.00809555f, -0.25647610f, 0.10865112f, -0.04392214f, 0.12628400f, -0.07374110f, 
    -0.07273699f, 0.04883522f, -0.10883506f, -0.08641501f, -0.28064418f, 0.09581944f, 0.01571035f, -0.14163621f, 
    0.10917435f, -0.05058680f, 0.09366623f, 0.07462084f, 0.03123481f, -0.05141016f, -0.15110548f, -0.02249516f, 
    0.08876230f, -0.11029864f, 0.06716178f, 0.02734255f, 0.08143120f, -0.02182019f, 0.08421268f, 0.01788455f, 
    -0.00536597f, 0.01791370f, 0.04751295f, 0.04649666f, -0.33353716f, -0.16881739f, 0.11392179f, -0.14179704f, 
    0.05039836f, -0.01797645f, 0.09791449f, -0.21524847f, -0.04784210f, 0.13838859f, 0.06675442f, 0.15111838f, 
    0.06947616f, -0.08305357f, 0.04449185f, -0.15064800f, 0.01106509f, -0.06375317f, -0.04804526f, 0.10494424f, 
    -0.01089984f, -0.04378771f, -0.04706194f, -0.07598327f, 0.01697589f, 0.20101032f, 0.00014928f, 0.03928994f, 
    0.06751108f, -0.05017015f, 0.00385023f, 0.08334848f, -0.02609652f, 0.07417659f, 0.24453673f, -0.08505753f, 
    0.09790354f, -0.16621138f, 0.01487659f, 0.19957279f, -0.00305724f, -0.07038721f, 0.01641568f, 0.09817039f, 
    0.05294227f, 0.01478425f, -0.01755751f, 0.10839379f, 0.19404891f, 0.03165836f, -0.15293515f, 0.02937247f, 
    0.05093871f, -0.02204083f, 0.08627760f, -0.01055352f, -0.08655763f, -0.05281774f, 0.07915355f, -0.02658072f, 
    0.02932892f, 0.11032057f, 0.14292377f, 0.07356228f, 0.06514151f, 0.05198455f, 0.09642275f, -0.11063920f, 
    0.05859412f, -0.06417272f, 0.09343413f, 0.04490406f, -0.21176259f, 0.07115322f, 0.15753019f, 0.13161114f, 
    0.08125685f, -0.05552588f, -0.04185383f, 0.02362827f, 0.03822467f, -0.01214887f, -0.02275787f, 0.09889159f, 
    0.30899304f, 0.18753582f, -0.05354999f, 0.13603202f, -0.02981670f, 0.03831090f, -0.01098084f, 0.09004630f, 
    -0.04425167f, 0.10285965f, -0.00338897f, -0.08148000f, 0.14571217f, 0.00873591f, -0.12139501f, 0.35086679f, 
    -0.00117050f, 0.04419212f, 0.13891000f, 0.05703569f, 0.02247419f, -0.02985927f, 0.11970860f, 0.12492253f, 
    0.11278990f, -0.00544551f, -0.08568051f, 0.24113810f, 0.11323118f, 0.11960695f, 0.09706710f, -0.15017226f, 
    0.02452236f, 0.01421682f, 0.16133852f, 0.12795740f, -0.05662524f, 0.08041615f, -0.06419376f, -0.00577619f, 
    0.04680725f, 0.00354898f, -0.08456147f, -0.04031613f, 0.05144259f, 0.12352656f, 0.06502035f, 0.04032576f, 
    0.09056018f, -0.07778135f, -0.14799748f, 0.04787629f, -0.00632067f, 0.08141996f, 0.08953088f, 0.06613864f, 
    -0.00546271f, -0.14364539f, 0.09915529f, -0.21671173f, 0.30570552f, -0.00887181f, 0.15388039f, -0.13051136f, 
    -0.02920913f, -0.09615018f, 0.05736846f, 0.12400170f, -0.01094277f, 0.07718981f, 0.02876862f, 0.07623155f, 
    0.15915823f, 0.08595007f, -0.02933973f, 0.19532086f, 0.04000228f, -0.09784919f, 0.00816257f, 0.03607798f, 
    0.08750815f, 0.06033008f, -0.07094228f, 0.05808566f, 0.19507016f, 0.06855957f, -0.00319956f, -0.33033839f, 
    0.06124003f, -0.04622009f, -0.05127481f, -0.13095199f, -0.05077840f, 0.03185027f, 0.00886106f, -0.09495627f, 
    0.05521298f, 0.08390359f, -0.11607073f, 0.23717563f, 0.01495855f, 0.22837695f, -0.00589425f, -0.03382672f, 
    -0.03850897f, -0.03682233f, -0.09447571f, 0.09726368f, 0.06430513f, -0.00325045f, -0.12050485f, 0.02980600f, 
    0.13010426f, 0.02305624f, -0.00306618f, -0.14860855f, 0.04737277f, -0.04007461f, 0.05146740f, 0.01533807f, 
    0.07321710f, -0.00033461f, 0.00168584f, 0.14220034f, -0.08329182f, -0.07510880f, 0.04082622f, -0.02439362f, 
    0.04379564f, -0.05616259f, -0.04379655f, 0.20754066f, -0.14845185f, 0.09019976f, 0.09462559f, 0.38413793f, 
    0.01264980f, 0.04940426f, -0.11160687f, -0.08079146f, 0.07241275f, -0.07768544f, 0.01861499f, 0.18577808f, 
    -0.62402546f, 0.19236761f, 0.04337492f, -0.06558827f, -0.04877692f, -0.01714272f, 0.16501047f, 0.08192097f, 
    -0.03294697f, -0.01412192f, 0.11748238f, -0.08586393f, -0.00086052f, -0.07550142f, 0.25796589f, -0.05273224f, 
    0.19222765f, 0.04031814f, 0.02905534f, -0.02777693f, 0.01556140f, 0.06656571f, -0.11041410f, 0.12077335f, 
    0.10900372f, -0.03840349f, 0.08800883f, -0.11904451f, 0.17299145f, 0.03655083f, -0.00668899f, -0.07060704f, 
    0.13589442f, -0.10779957f, 0.06804408f, -0.01762596f, -0.23716599f, -0.04911077f, 0.35894337f, 0.27140313f, 
    -0.05058839f, 0.00871578f, 0.02665912f, 0.12477637f, -0.00515453f, 0.06965812f, -0.03102178f, 0.01560416f, 
    0.08743671f, -0.03602406f, 0.04516966f, -0.00424395f, 0.02855879f, -0.06330051f, -0.08868194f, -0.04219036f, 
    0.13640198f, 0.16212058f, 0.21869092f, 0.00684747f, 0.44340453f, 0.12593636f, -0.19283257f, 0.25063884f, 
    0.00814005f, -0.03445289f, 0.10020922f, 0.06199940f, 0.03100993f, -0.04641688f, 0.00530243f, -0.02869427f, 
    -0.03564567f, 0.14694284f, -0.08099967f, -0.07119003f, 0.12219689f, 0.06290374f, -0.01094867f, 0.10340305f, 
    -0.01801927f, 0.04431601f, 0.10731253f, -0.05095812f, 0.17155172f, 0.04225813f, -0.12417086f, 0.16391249f, 
    -0.06346450f, 0.07195577f, -0.06255888f, 0.07432894f, 0.08095738f, 0.04107636f, 0.06892867f, -0.03545171f, 
    0.33550656f, 0.03778899f, 0.21373893f, 0.21765861f, -0.04703585f, -0.03280076f, -0.06393322f, 0.12258376f, 
    0.01798419f, 0.07193834f, -0.06786060f, -0.01100153f, 0.30113712f, -0.04928322f, 0.04729728f, 0.23877715f, 
    0.00919120f, -0.04929768f, 0.09092492f, 0.04234745f, -0.05851474f, -0.00825171f, 0.18943439f, 0.14069524f, 
    -0.03342041f, -0.01352685f, -0.01713062f, -0.03379013f, -0.01788323f, 0.00322650f, -0.02315925f, -0.02413113f, 
    -0.01978821f, 0.01603874f, 0.02437088f, -0.02087891f, 0.00550149f, -0.02430684f, 0.01999565f, -0.02906013f, 
    -0.00644631f, -0.01315076f, 0.02695975f, 0.02268612f, 0.02761346f, -0.02479697f, -0.02281665f, 0.02352660f, 
    -0.01335447f, -0.01041279f, 0.02272450f, 0.04156316f, 0.01658160f, 0.01287142f, -0.02413771f, 0.01950688f, 
    0.00849960f, -0.03045249f, 0.02574074f, -0.02701616f, 0.02395421f, -0.03352104f, 0.01973849f, -0.00386564f, 
    0.00426688f, -0.03062097f, -0.02320640f, -0.00697934f, 0.00204958f, -0.02182097f, -0.00027872f, 0.03454692f, 
    0.04109161f, 0.01225230f, -0.02144137f, 0.02823713f, -0.01316814f, 0.02165464f, -0.00915812f, -0.03054174f, 
    -0.02235673f, -0.00053964f, 0.02205989f, -0.02774418f, -0.01520867f, 0.04053722f, -0.03991573f, -0.04174902f, 
    -0.01389694f, 0.00346702f, 0.02444110f, 0.03986192f, -0.02570245f, -0.04197596f, -0.01899241f, 0.02257969f, 
    -0.01568252f, -0.01549760f, 0.00377450f, -0.01515916f, 0.02341440f, 0.00513137f, 0.01669675f, -0.01900631f, 
    0.00758064f, -0.02760059f, 0.00448798f, 0.01576586f, -0.01185920f, 0.02909813f, -0.01241222f, 0.01038615f, 
    0.02062416f, -0.00423018f, 0.00134627f, 0.01442950f, 0.01550711f, 0.01802339f, 0.03376938f, -0.02374909f, 
    -0.02728580f, 0.00198180f, -0.02234631f, 0.03019383f, -0.02123734f, 0.01001367f, 0.02698237f, -0.02449029f, 
    -0.00765273f, 0.00529430f, -0.03488513f, -0.01308956f, -0.02503640f, 0.01838717f, -0.02630776f, 0.00791592f, 
    -0.02080309f, 0.01058816f, 0.04102371f, 0.03905625f, 0.00900107f, -0.00308835f, 0.00964537f, -0.02893808f, 
    -0.02797319f, -0.01719515f, 0.00838654f, 0.02815844f, 0.01990662f, -0.01273848f, 0.02413128f, -0.02057655f, 
    0.02075534f, 0.00720074f, -0.02188866f, 0.00145366f, -0.02270714f, 0.00188513f, -0.00493928f, 0.00818151f, 
    -0.03198308f, 0.00929436f, -0.03882432f, 0.01908083f, -0.00727679f, 0.02517991f, 0.02310251f, 0.01416475f, 
    -0.00177621f, -0.00231169f, -0.03466088f, -0.01841160f, -0.02031189f, -0.02640555f, -0.02433885f, 0.01227262f, 
    0.02971593f, 0.02251035f, -0.01202982f, -0.01711751f, 0.02218089f, 0.01860503f, -0.02323555f, -0.02719813f, 
    0.01703344f, -0.03577547f, -0.00175944f, -0.00633021f, -0.02593461f, -0.00669575f, -0.04136929f, -0.01634942f, 
    -0.00869836f, 0.02489409f, -0.02922888f, -0.04073564f, -0.02339887f, -0.01429973f, -0.03771491f, 0.01118334f, 
    0.02724867f, -0.01221192f, -0.02433738f, 0.01580437f, 0.00374234f, -0.02797171f, -0.01340614f, 0.00772954f, 
    -0.02715458f, 0.03624626f, -0.01083573f, 0.00473127f, -0.00629256f, -0.02965370f, -0.01942033f, -0.00419711f, 
    -0.03288727f, -0.01402169f, 0.02325490f, 0.00812546f, 0.02669095f, 0.01881408f, -0.01494089f, -0.01743810f, 
    0.00199878f, 0.00479915f, 0.01592839f, -0.02242481f, -0.01008571f, 0.00708617f, -0.01256046f, -0.02832516f, 
    -0.01229579f, 0.01383489f, -0.00278731f, -0.03840781f, -0.02545422f, -0.00538402f, -0.01036792f, 0.00240328f, 
    -0.01643668f, 0.00590668f, -0.01767931f, -0.00261184f, -0.02771948f, -0.02901951f, 0.02248013f, 0.00529961f, 
    0.00553828f, -0.00214123f, -0.02746429f, 0.01829601f, 0.01392971f, 0.03443302f, -0.01458720f, -0.02687751f, 
    -0.00837846f, -0.01022086f, -0.00157178f, -0.02347945f, 0.01471596f, 0.01010577f, -0.01154768f, -0.01024654f, 
    -0.01661809f, 0.02549604f, -0.02297013f, -0.00482191f, -0.02342542f, -0.01286620f, -0.02448269f, -0.00887474f, 
    0.01891225f, 0.03342788f, 0.02388532f, 0.00354306f, -0.03487875f, 0.01678579f, -0.03959307f, 0.00748960f, 
    0.01208963f, -0.01077746f, -0.00592322f, 0.01009208f, 0.02170917f, -0.00870467f, -0.03581134f, 0.01335406f, 
    0.01999040f, 0.02938175f, -0.00640740f, 0.00985410f, 0.00593825f, 0.02153715f, -0.02345342f, -0.03687457f, 
    0.00771839f, -0.00674764f, 0.01996381f, 0.00307104f, -0.02257544f, -0.02034993f, -0.01415688f, -0.02260603f, 
    -0.03211793f, -0.03162237f, 0.02027750f, 0.00733221f, 0.01474390f, -0.00325251f, 0.01400494f, -0.01915470f, 
    -0.02181053f, -0.00533785f, -0.02539558f, -0.03160615f, -0.02489778f, 0.01154465f, 0.00833072f, -0.01477045f, 
    -0.04075125f, -0.04131417f, -0.03297330f, -0.02629527f, -0.01659584f, -0.00411012f, 0.01253641f, -0.01648743f, 
    0.00170875f, -0.03299545f, -0.00940172f, 0.00199218f, 0.00195863f, 0.02973711f, 0.00379825f, 0.01395154f, 
    -0.00247433f, 0.00298016f, -0.00461591f, 0.00412062f, 0.00574698f, 0.00083398f, -0.03291382f, 0.02811833f, 
    -0.03948611f, 0.01395065f, -0.02559425f, 0.00783057f, 0.02583576f, 0.03027338f, -0.03593523f, 0.02641298f, 
    0.03618479f, -0.00808534f, -0.01855449f, -0.03878509f, -0.02285501f, 0.00030200f, -0.00780884f, -0.00819246f, 
    0.04119536f, 0.01271182f, 0.02285077f, 0.02344289f, 0.02984267f, -0.03439734f, -0.03841634f, -0.01592232f, 
    -0.02255533f, 0.00344147f, 0.02101810f, -0.04007876f, -0.01493196f, -0.03803629f, -0.03774903f, 0.02703659f, 
    0.00281098f, -0.00461171f, -0.02777585f, -0.03324724f, -0.00897974f, 0.02065906f, 0.01921569f, -0.01437826f, 
    -0.02062714f, -0.03531583f, 0.00383781f, 0.01612770f, -0.02360287f, 0.01453532f, 0.03491268f, 0.01418997f, 
    -0.03601499f, 0.01341281f, 0.00503451f, -0.00424948f, -0.01007562f, 0.02122647f, 0.01476994f, -0.02743336f, 
    -0.02295977f, -0.02375876f, 0.00672039f, -0.00027432f, 0.01824099f, 0.03442847f, -0.00067524f, 0.01817033f, 
    -0.03850004f, -0.00598656f, -0.03057550f, 0.01321221f, -0.00221425f, -0.01924227f, -0.00008116f, -0.02503358f, 
    -0.02945227f, -0.01103945f, 0.02694314f, -0.02854928f, -0.01081064f, -0.03524594f, 0.00495463f, -0.02416617f, 
    0.00621478f, -0.00291195f, 0.01232714f, -0.00099566f, -0.01667175f, -0.00852451f, -0.02459214f, -0.00794780f, 
    0.01712949f, 0.01263469f, -0.00312372f, 0.03971395f, 0.02259888f, 0.01218568f, -0.01940125f, 0.02010657f, 
    -0.02378599f, -0.01415723f, 0.01906899f, 0.00121332f, 0.02498770f, -0.03714552f, -0.03784564f, -0.04090082f, 
    0.00762763f, -0.02673639f, -0.02196682f, 0.02893659f, 0.00575792f, -0.04083110f, -0.02009075f, -0.03586564f, 
    -0.03779084f, -0.02791120f, -0.00330778f, 0.00286691f, 0.02793454f, 0.01279167f, 0.00854294f, 0.01680214f, 
    -0.00805655f, -0.03792707f, 0.00392749f, 0.01802994f, 0.03231538f, -0.01500206f, 0.00801631f, 0.00422302f, 
    0.02146864f, 0.02056187f, 0.00283751f, -0.01143921f, 0.03866915f, 0.03141997f, 0.01566637f, 0.00633632f, 
    -0.01923599f, 0.00217563f, -0.01513662f, -0.03113541f, -0.03525178f, 0.02030103f, -0.03127891f, -0.04041986f, 
    0.00334485f, 0.00277326f, 0.01373626f, -0.02170865f, 0.01937611f, -0.03675203f, -0.02021519f, 0.01198561f, 
    0.02513707f, 0.02864548f, 0.01632989f, -0.01049441f, -0.00912776f, 0.02174681f, 0.02580667f, -0.00707413f, 
    -0.02480491f, 0.01743599f, 0.02396744f, 0.01286708f, -0.00502132f, -0.02187544f, -0.00866831f, 0.02542817f, 
    -0.01803050f, 0.02212132f, 0.02839059f, -0.00978523f, 0.00879836f, -0.01951265f, -0.03385110f, 0.02639730f, 
    0.01591506f, -0.02504741f, -0.00117287f, -0.03662614f, -0.00901099f, 0.00422542f, -0.01521936f, -0.00383262f, 
    -0.02801262f, 0.02365271f, -0.00499158f, -0.02859634f, -0.02011557f, 0.01879423f, -0.01713142f, -0.00335926f, 
    -0.01119067f, -0.04161220f, 0.00635988f, 0.01210293f, -0.01352492f, 0.01930997f, 0.01567308f, 0.00551847f, 
    0.02855219f, 0.00648761f, -0.01430847f, -0.03152704f, 0.03464945f, 0.00918631f, 0.02249578f, 0.01404388f, 
    -0.01146711f, 0.02154000f, -0.01955221f, 0.02935137f, 0.02752814f, 0.02510591f, 0.02111543f, 0.00019017f, 
    -0.01111672f, -0.01808419f, -0.02959790f, 0.03210280f, -0.02616502f, 0.00488688f, 0.00328789f, -0.01333899f, 
    -0.01876228f, -0.01694136f, -0.01459647f, 0.02065037f, 0.02887720f, 0.02337023f, -0.04006549f, -0.00133837f, 
    -0.00396364f, -0.01826979f, 0.02190565f, 0.01004715f, -0.03153326f, 0.03516844f, -0.03391903f, 0.01450567f, 
    0.01028910f, 0.00174639f, -0.02043778f, 0.00258415f, -0.02993739f, -0.01562235f, 0.02244085f, 0.01492059f, 
    0.02679526f, 0.04132963f, 0.02943151f, -0.01765732f, -0.02112764f, -0.02584994f, 0.02793476f, 0.02380049f, 
    -0.04202361f, -0.01671216f, -0.00190334f, -0.01652413f, -0.03116244f, -0.00681804f, -0.03979833f, 0.00606809f, 
    -0.00011101f, -0.03362618f, -0.03196311f, 0.00593919f, 0.00109882f, 0.01558805f, 0.00934300f, -0.00228189f, 
    -0.03742720f, -0.00832216f, -0.01052747f, -0.01608539f, -0.02483804f, 0.01810083f, -0.00193352f, -0.00669777f, 
    0.01734263f, -0.00376354f, 0.01299197f, -0.02497591f, 0.01635843f, 0.01103782f, -0.01086788f, -0.01448805f, 
    0.00252188f, 0.00787042f, -0.03185594f, 0.00247221f, 0.03092769f, 0.01729476f, -0.04182797f, -0.01300783f, 
    -0.02021849f, 0.01049595f, -0.02086219f, -0.01183084f, -0.02657733f, 0.04147469f, -0.02925049f, -0.04131899f, 
    -0.03440048f, 0.01230559f, 0.02877683f, 0.00978135f, 0.01775462f, 0.00880268f, 0.00614387f, 0.02065462f, 
    0.02614539f, 0.01998047f, 0.01561154f, 0.02890547f, -0.01982981f, -0.04011295f, -0.02630985f, 0.01866361f, 
    -0.00297697f, -0.02379399f, -0.01147480f, 0.02773438f, 0.02506265f, -0.03595315f, -0.01024407f, -0.01664300f, 
    -0.02484389f, 0.01518415f, 0.00583512f, -0.00342450f, -0.00999871f, -0.01572969f, -0.01916625f, -0.01778572f, 
    -0.01540387f, 0.00865216f, -0.02385791f, 0.00815104f, -0.02611942f, -0.02102967f, -0.01608093f, -0.00995238f, 
    -0.00283285f, -0.01046295f, -0.01577289f, -0.01799902f, 0.02089018f, -0.01182338f, -0.00575594f, 0.00344641f, 
    0.02199272f, 0.02833492f, 0.00716644f, 0.00885513f, 0.00701906f, 0.01000271f, 0.01473197f, 0.02463076f, 
    -0.01685530f, -0.02678093f, -0.02893392f, -0.01191990f, -0.04181997f, 0.02287140f, -0.02019517f, 0.00449806f, 
    -0.01241615f, -0.03714421f, 0.01842347f, -0.02285037f, -0.03337610f, 0.02981663f, 0.02086897f, -0.01627903f, 
    -0.02181788f, 0.01021208f, -0.02147357f, -0.04171265f, -0.02298681f, 0.02823749f, -0.04018303f, 0.02578017f, 
    0.02778734f, 0.01531869f, 0.00855739f, -0.01704957f, 0.02594787f, 0.02076130f, -0.02307774f, 0.01720592f, 
    -0.03863147f, -0.02085220f, -0.03032400f, -0.00231627f, 0.00489970f, -0.00286306f, 0.00293259f, 0.01823140f, 
    -0.01364043f, 0.03580347f, -0.03245592f, -0.02301813f, -0.02687059f, -0.01801661f, 0.00758825f, -0.01317266f, 
    -0.02663961f, -0.01176105f, 0.01319746f, 0.00198307f, 0.03499179f, 0.01011552f, 0.02336875f, -0.01942790f, 
    0.01152195f, -0.00582411f, -0.01121408f, -0.02293383f, 0.00840000f, -0.02189936f, -0.02033004f, 0.01331551f, 
    -0.03827493f, -0.02027510f, 0.00180703f, 0.03542896f, -0.04123718f, 0.00935593f, -0.02326662f, -0.03554932f, 
    0.02678598f, 0.02478200f, -0.03575651f, -0.04163308f, -0.03134441f, -0.03321410f, 0.01850326f, -0.01666684f, 
    0.02055572f, 0.00987267f, -0.00000196f, 0.00065922f, -0.02300452f, 0.00346032f, -0.02157957f, -0.00980905f, 
    0.04205222f, -0.27865669f, -0.11140150f, 0.04127909f, -0.02398690f, 0.03741494f, -0.02092374f, -0.07555442f, 
    -0.01678773f, -0.07266946f, 0.12201556f, 0.00396254f, 0.00174934f, 0.16705295f, 0.02306354f, -0.05460700f, 
    -0.05228159f, -0.03522498f, 0.04297149f, -0.01121998f, -0.03004579f, -0.07262858f, -0.09588034f, 0.08411744f, 
    -0.20093270f, 0.23282640f, 0.00844537f, 0.01303436f, 0.06639084f, 0.11287067f, 0.07497615f, 0.12568091f, 
    0.01537656f, -0.09488758f, 0.01518778f, -0.02177384f, -0.47133130f, -0.08860346f, 0.08209980f, 0.01400382f, 
    -0.06257619f, -0.02860037f, -0.01606067f, 0.14403789f, 0.06144729f, 0.05042740f, -0.12480741f, 0.02462107f, 
    0.02900445f, -0.10251800f, -0.05797939f, 0.06432802f, -0.04404937f, -0.05229931f, -0.04570090f, 0.13384990f, 
    -0.02178310f, 0.03064103f, 0.08675151f, 0.02645326f, -0.02197658f, 0.14173685f, -0.16380529f, -0.01962850f, 
    -0.00117194f, 0.05876533f, -0.00093074f, 0.01331700f, 0.18266790f, 0.02932852f, 0.06665298f, -0.04954611f, 
    0.20712163f, 0.03416111f, -0.15609059f, -0.13910437f, -0.02432524f, 0.13029931f, -0.01589805f, -0.02602471f, 
    -0.06059427f, -0.03959802f, -0.01345163f, 0.07592325f, -0.17702134f, -0.14478642f, -0.04820373f, -0.01725879f, 
    0.04898472f, 0.06794618f, -0.06993915f, 0.04874295f, -0.00732448f, 0.03916816f, 0.07854121f, 0.01671420f, 
    -0.54486036f, -0.02503153f, 0.03442717f, 0.01498076f, -0.07522655f, -0.10878281f, 0.10750099f, -0.05119848f, 
    -0.03513241f, 0.06673012f, -0.12279807f, -0.01881957f, -0.21863063f, 0.14943042f, 0.20058389f, -0.01074864f, 
    0.10461408f, -0.03517848f, -0.03605363f, 0.10188317f, 0.05777907f, 0.01426574f, 0.01473234f, -0.07741174f, 
    -0.28253707f, 0.04730496f, -0.10951349f, -0.03684263f, -0.08432956f, 0.00121298f, -0.02649529f, 0.10105367f, 
    0.01262244f, 0.07702356f, -0.01845453f, 0.04473687f, 0.12031158f, -0.10870127f, 0.01092695f, -0.03795166f, 
    -0.06811985f, 0.04357172f, 0.01407441f, 0.06634270f, -0.01431933f, 0.06326333f, 0.01652186f, 0.04767303f, 
    0.01105229f, -0.31223786f, 0.02581445f, 0.05280552f, 0.03899049f, 0.02340535f, 0.04746454f, -0.01209422f, 
    0.02279620f, 0.10841906f, -0.01001915f, -0.05329215f, -0.17518282f, -0.23574691f, 0.03614633f, -0.06933987f, 
    -0.05699981f, -0.12065148f, -0.03070811f, -0.04512716f, 0.06280380f, -0.02203914f, 0.09278863f, -0.04103172f, 
    -0.28781202f, 0.01097457f, 0.11872441f, 0.16399826f, 0.10244344f, 0.07307959f, 0.06563418f, 0.05977030f, 
    -0.08851164f, 0.11069580f, -0.07281011f, 0.06994532f, -0.22812171f, -0.02017492f, 0.06113626f, 0.11719854f, 
    -0.05597337f, -0.00864362f, 0.05848887f, 0.07444248f, 0.00412992f, -0.03331584f, -0.07291493f, 0.08270454f, 
    0.07076262f, 0.09092385f, 0.06025947f, -0.01269704f, -0.05554661f, -0.02418910f, 0.06696729f, -0.01442578f, 
    0.11847420f, 0.07904962f, 0.01858474f, 0.09949177f, 0.09940095f, 0.05813265f, 0.05810114f, -0.05249641f, 
    -0.04343931f, 0.12246587f, -0.07827958f, -0.02278333f, 0.15095286f, 0.11529319f, 0.06194483f, 0.04774141f, 
    -0.30499718f, 0.21400028f, 0.15180582f, 0.02471633f, -0.02927723f, -0.05735015f, -0.04159160f, 0.00333268f, 
    0.08361498f, -0.03514677f, 0.04282902f, 0.05046607f, -0.23783569f, 0.17910200f, -0.14365427f, -0.07310220f, 
    0.04094328f, -0.04761317f, -0.00953711f, 0.17866454f, -0.02224237f, 0.06682047f, 0.11017431f, -0.06892183f, 
    0.04957059f, -0.12497994f, -0.19110374f, -0.07830769f, -0.13059841f, 0.03627372f, -0.02798888f, -0.01033618f, 
    0.01936858f, 0.06019900f, -0.02541804f, -0.02381195f, 0.12304878f, -0.10477531f, -0.11653373f, 0.02622604f, 
    0.02311246f, -0.00288145f, 0.05031618f, 0.10896402f, 0.05970988f, 0.00340687f, -0.04258158f, 0.06579268f, 
    0.04409496f, 0.02020730f, 0.08007929f, 0.16256931f, 0.09413853f, 0.17904457f, -0.08084513f, 0.01144187f, 
    0.13073041f, -0.07918228f, 0.01345692f, -0.09441747f, 0.11572159f, -0.02129966f, -0.11166435f, 0.12889384f, 
    -0.12682252f, -0.01405288f, 0.06910003f, 0.01222411f, 0.01947174f, -0.01657529f, 0.12541814f, 0.05499984f, 
    0.31951830f, -0.13749161f, -0.19075106f, -0.06409885f, -0.02893015f, -0.02499917f, -0.01161434f, 0.03125168f, 
    0.00752658f, 0.07316767f, -0.00711761f, 0.12281689f, 0.14411971f, -0.13010243f, 0.02981246f, -0.07351386f, 
    -0.01829810f, 0.06383613f, 0.08806413f, 0.00383368f, 0.02179844f, 0.01670171f, -0.04627667f, 0.06565861f, 
    0.08100443f, -0.14705443f, -0.04800598f, -0.13530016f, -0.02205131f, -0.02159459f, -0.00448407f, -0.00853125f, 
    0.04828571f, 0.06882390f, 0.03767233f, 0.04201955f, -0.14443824f, 0.15204886f, 0.03096719f, -0.28977415f, 
    -0.08221806f, -0.00782580f, 0.09299853f, 0.09762385f, 0.11831926f, 0.05938800f, 0.09576898f, 0.04472928f, 
    0.14643332f, 0.12885448f, -0.09584582f, -0.06950989f, -0.03016058f, 0.01332712f, -0.05333280f, -0.02226927f, 
    0.05973168f, -0.02325950f, 0.07970103f, 0.02033148f, 0.07740334f, 0.17947169f, -0.02698897f, 0.05503000f, 
    0.05337340f, 0.04914971f, 0.03034568f, 0.06554757f, -0.04299281f, 0.05633794f, 0.12167910f, -0.02006635f, 
    0.17137289f, 0.19699317f, -0.06140519f, -0.01194462f, -0.01662230f, 0.08672500f, -0.02110676f, 0.07458846f, 
    -0.03530477f, 0.04485400f, 0.10191750f, 0.01601172f, 0.05258981f, 0.02524641f, -0.10119292f, -0.00723143f, 
    0.00332479f, -0.01860458f, 0.01248809f, 0.02339173f, 0.11198445f, 0.05844522f, -0.04748993f, 0.11926293f, 
    -0.01965906f, -0.30663332f, -0.17410859f, -0.00190961f, -0.06610739f, -0.08658794f, -0.03188756f, 0.03582796f, 
    0.04446484f, 0.14535876f, 0.04544419f, -0.00421496f, -0.20038953f, -0.16311572f, -0.02627535f, 0.06238785f, 
    -0.00270322f, 0.00674195f, 0.07041042f, 0.05454212f, -0.06711598f, -0.08165381f, 0.02704463f, 0.05778112f, 
    -0.14622584f, 0.01208569f, -0.00297919f, -0.04878450f, -0.05014261f, -0.11364465f, -0.03739865f, 0.03748168f, 
    0.05159322f, 0.02287691f, -0.00139363f, -0.01315759f, 0.20571330f, 0.17991818f, -0.16008312f, 0.04648379f, 
    0.00064055f, 0.02476843f, 0.09192566f, 0.05215160f, 0.05964246f, 0.01879470f, -0.03989115f, 0.09117249f, 
    -0.07996517f, 0.04261298f, -0.08648054f, 0.12702882f, -0.02004473f, 0.02348343f, 0.01500332f, 0.11561050f, 
    0.02295976f, 0.04336368f, 0.09944363f, 0.05180490f, 0.04686736f, 0.09828231f, 0.07039966f, -0.03884634f, 
    -0.09293276f, -0.01259884f, -0.03717855f, 0.12583832f, 0.05404805f, -0.14120422f, 0.05887321f, 0.09799080f, 
    -0.07787597f, -0.09298509f, 0.14226972f, 0.09494232f, 0.02111724f, 0.11188566f, 0.04670949f, 0.02758814f, 
    0.05827049f, 0.03708725f, 0.07134368f, -0.02440463f, -0.11715265f, -0.02881721f, 0.11099132f, 0.05549269f, 
    0.04913463f, 0.05780125f, -0.07912520f, -0.06029372f, 0.09713987f, -0.03201187f, -0.11535931f, 0.14503737f, 
    0.25307822f, -0.06948535f, -0.01181636f, -0.02849076f, -0.05930930f, -0.08264621f, 0.01578755f, 0.09525717f, 
    -0.06208596f, 0.13199235f, -0.02513462f, -0.01112943f, -0.34315073f, 0.15834536f, 0.14050624f, 0.04683031f, 
    -0.04437695f, 0.07456948f, -0.00693673f, 0.04960407f, 0.09282845f, 0.06886859f, 0.10532801f, 0.03939973f, 
    -0.04992015f, -0.07249363f, 0.02499481f, 0.01954952f, -0.01684355f, 0.00051584f, -0.08598374f, -0.06841568f, 
    0.04808083f, 0.04085302f, 0.02579827f, -0.10480028f, 0.25091085f, 0.04576161f, 0.07515737f, 0.15864232f, 
    0.09220357f, -0.06254766f, -0.00378032f, 0.03392032f, 0.12095017f, -0.11012810f, -0.17297609f, 0.05931362f, 
    0.12469757f, -0.12630287f, 0.05917653f, 0.03668528f, 0.01373365f, -0.00003062f, -0.01678406f, -0.01347339f, 
    0.08348320f, -0.03275673f, 0.00763495f, 0.14866577f, -0.10904220f, -0.02850370f, -0.00500006f, -0.06437102f, 
    -0.00564411f, 0.06610812f, -0.11856069f, 0.07021045f, -0.02445045f, -0.00438814f, 0.01117194f, 0.00926720f, 
    -0.00448496f, -0.09211242f, -0.06260665f, -0.00108254f, -0.04323380f, -0.13323022f, 0.00314577f, 0.00674654f, 
    0.08533742f, -0.01441925f, -0.04556810f, 0.02570658f, 0.04084677f, -0.07652652f, -0.00222484f, 0.06562921f, 
    -0.05716503f, -0.00673614f, 0.01105051f, 0.02948009f, 0.05523954f, -0.02748435f, 0.06360602f, -0.01176066f, 
    0.03574326f, -0.13355641f, 0.10988403f, -0.23300034f, 0.06467363f, 0.07552006f, -0.00360398f, 0.06451490f, 
    -0.04824257f, -0.06265531f, -0.00834014f, -0.13063687f, 0.08160628f, -0.38654280f, 0.10696290f, 0.07160306f, 
    0.06405321f, 0.02874527f, 0.11328492f, -0.00849822f, 0.08446311f, -0.03311472f, -0.10030854f, 0.02252352f, 
    0.03743616f, -0.12020677f, -0.06314272f, 0.26362225f, -0.03400023f, -0.04280647f, 0.00050340f, -0.02452051f, 
    0.13322894f, -0.00414525f, -0.06015875f, 0.10424017f, 0.12783626f, -0.01131308f, -0.02553717f, -0.08807649f, 
    -0.05887382f, 0.02310416f, -0.02781594f, 0.07130037f, 0.07248417f, 0.05973601f, 0.02349864f, 0.11902060f, 
    0.00419181f, 0.02806573f, -0.02115856f, -0.08772835f, -0.08854996f, -0.00283932f, -0.00017416f, -0.05940274f, 
    -0.03522566f, 0.00185365f, -0.01006281f, 0.05028329f, -0.09052821f, 0.03024219f, -0.04985114f, -0.17426392f, 
    0.03772864f, 0.09828404f, -0.06134674f, 0.11901400f, 0.05157205f, 0.03555694f, -0.01844526f, 0.02114637f, 
    -0.06099010f, 0.13776141f, -0.34517410f, 0.09079511f, -0.00591591f, 0.09707104f, 0.09143106f, 0.12685609f, 
    0.02289014f, -0.00730325f, 0.00489236f, 0.00706557f, 0.18071353f, 0.03508583f, -0.03374166f, 0.06680477f, 
    -0.00545215f, 0.02299946f, 0.02179456f, 0.14160189f, -0.04597852f, 0.10069449f, 0.09666539f, -0.08843869f, 
    -0.00727241f, -0.01933332f, 0.04020629f, 0.07609419f, 0.04042945f, 0.04177674f, -0.01693308f, 0.05094188f, 
    0.13519315f, -0.01854345f, -0.00825766f, 0.07122829f, -0.17254324f, 0.32196212f, -0.12847337f, -0.09523649f, 
    0.05172960f, 0.01552801f, 0.04758667f, 0.04526999f, -0.04252166f, 0.05109624f, 0.05936200f, 0.04523225f, 
    0.17207277f, -0.09077523f, -0.00345109f, 0.01962534f, -0.00044209f, 0.06330296f, 0.16654980f, -0.06813836f, 
    0.00802668f, 0.05641544f, -0.01315006f, -0.05083472f, 0.05416011f, -0.12931089f, -0.03580850f, 0.04483998f, 
    0.02408483f, 0.12754861f, 0.04572544f, -0.00212681f, 0.13392305f, 0.15315109f, 0.03628883f, -0.02588185f, 
    0.09546456f, -0.04292640f, 0.07756116f, 0.11933684f, -0.02192735f, 0.16079126f, -0.03637770f, 0.04494592f, 
    0.12388755f, 0.11490448f, 0.03597970f, 0.08870604f, 0.13111001f, -0.12805796f, 0.04186707f, -0.05467442f, 
    0.06896963f, -0.06236878f, -0.06087976f, 0.05931243f, -0.08780814f, -0.09019587f, -0.14368369f, -0.00561855f, 
    0.47589421f, -0.03341473f, -0.35919231f, -0.13071032f, 0.11267382f, -0.03770364f, -0.01538841f, -0.06323735f, 
    -0.08071896f, 0.08477768f, 0.13507856f, -0.14084718f, -0.04674698f, -0.07399708f, 0.16439305f, 0.13475843f, 
    0.03313414f, 0.08290784f, -0.01479244f, 0.04041117f, 0.15777190f, -0.00962438f, 0.05609887f, 0.01023791f, 
    -0.00622206f, -0.01570928f, 0.01538294f, 0.04432450f, -0.00430822f, -0.00301504f, -0.00592353f, -0.02088323f, 
    -0.02892935f, -0.00790836f, -0.02972658f, 0.01981083f, -0.01145039f, -0.00415502f, -0.03363055f, 0.02760527f, 
    -0.03820996f, 0.01360681f, -0.01474008f, -0.03351862f, -0.01850208f, -0.03700031f, 0.00180986f, 0.00751129f, 
    -0.01719680f, -0.01682613f, -0.01848489f, 0.01601768f, -0.04041263f, 0.02087736f, -0.00208791f, 0.00984941f, 
    -0.02297751f, -0.01939245f, -0.02602368f, -0.02706783f, 0.01788455f, -0.01784051f, 0.02886878f, 0.00635026f, 
    0.03620017f, 0.00774128f, -0.01643297f, 0.01663000f, -0.00984192f, 0.02282830f, -0.00551883f, -0.02852795f, 
    0.00292649f, 0.03261211f, 0.02607436f, -0.02198165f, -0.03640226f, 0.00299199f, 0.00740853f, -0.03342764f, 
    0.02548230f, -0.00232748f, -0.01124683f, -0.01428058f, -0.02577906f, 0.01276013f, -0.02705779f, 0.02403366f, 
    0.00379955f, 0.01054533f, 0.02820564f, 0.03005778f, 0.02739880f, -0.00473847f, 0.02521720f, 0.02057487f, 
    0.02608080f, -0.00755692f, 0.03109153f, 0.01618139f, -0.00385810f, -0.00142615f, -0.00840134f, 0.01256188f, 
    0.01805460f, -0.04446793f, 0.00930570f, -0.00080049f, -0.02637728f, 0.02239590f, -0.03770771f, -0.04147143f, 
    0.02676865f, 0.00677633f, 0.04345062f, 0.00221930f, -0.01785969f, -0.02988118f, 0.00175538f, 0.02791946f, 
    -0.02137890f, -0.02616323f, -0.00883774f, -0.02642804f, 0.00382987f, 0.02165120f, -0.00059040f, 0.01538024f, 
    0.01337539f, -0.01728041f, 0.01199086f, 0.01912699f, -0.04192054f, -0.01346980f, 0.00427194f, 0.02098720f, 
    -0.02829824f, -0.03187113f, 0.00427454f, 0.01993939f, -0.01541402f, -0.03501629f, -0.01762213f, -0.03605252f, 
    0.01228841f, 0.01898196f, -0.00682821f, -0.01162564f, -0.00661891f, -0.03989696f, -0.03886447f, 0.00998951f, 
    -0.02820410f, 0.02791736f, -0.04268806f, 0.01015544f, -0.00002458f, -0.02284998f, -0.00702550f, -0.03617360f, 
    0.02561755f, -0.03859065f, -0.02490761f, 0.01279916f, 0.02529674f, 0.00683684f, 0.01782128f, -0.00949641f, 
    -0.02742056f, -0.01550578f, 0.02632326f, -0.00372965f, 0.01394042f, -0.02225681f, -0.00996605f, 0.01536043f, 
    -0.03923428f, 0.00652574f, 0.00614140f, -0.03428258f, 0.02619274f, -0.00949699f, -0.01749557f, 0.02665741f, 
    -0.02309666f, -0.02781361f, 0.01232619f, 0.02898783f, -0.03139855f, 0.02939508f, -0.02121804f, 0.01035167f, 
    0.01792323f, 0.00413550f, -0.03580170f, 0.00779860f, 0.01132597f, -0.00549850f, -0.01449617f, -0.00203740f, 
    0.00335466f, 0.01388487f, -0.03283828f, -0.01152321f, -0.02194717f, 0.02216576f, -0.00180227f, 0.00604803f, 
    -0.01335736f, -0.00995209f, -0.02847425f, 0.02020456f, 0.00035233f, 0.00002121f, -0.03427391f, -0.01520692f, 
    0.02686550f, -0.04398688f, 0.01079287f, 0.03320365f, -0.01718286f, -0.02157434f, 0.02358831f, 0.01041025f, 
    0.02461632f, -0.01062106f, 0.02937526f, 0.02467221f, 0.03665480f, 0.02774619f, 0.01693282f, -0.00508482f, 
    -0.01214852f, -0.00228634f, -0.02418099f, 0.00473981f, 0.02119621f, 0.01070397f, 0.01025558f, 0.02524597f, 
    0.01713469f, -0.01523544f, 0.02661488f, -0.04138673f, -0.00575346f, -0.00720596f, 0.01716936f, 0.00503640f, 
    0.02456533f, 0.01980565f, 0.00476051f, -0.03607653f, 0.02127648f, 0.02294514f, 0.00211295f, 0.01661717f, 
    0.03600079f, -0.02651648f, 0.00508180f, -0.02073307f, -0.01647062f, -0.02176036f, -0.04307213f, -0.03666271f, 
    -0.01870451f, 0.00717654f, -0.01903376f, 0.01869735f, -0.02491981f, -0.00293866f, 0.01176003f, -0.03731424f, 
    -0.02955393f, 0.00996520f, 0.00894104f, 0.00897446f, -0.03267257f, 0.02529014f, -0.03375492f, -0.04205154f, 
    -0.03333744f, 0.03209283f, -0.02559602f, 0.03470414f, -0.00276721f, 0.00943778f, -0.00564733f, -0.00872439f, 
    0.02481283f, -0.01243130f, 0.02024344f, 0.00810498f, -0.00762974f, 0.00335540f, -0.01774611f, 0.01387892f, 
    0.02293020f, -0.00348130f, -0.02803314f, -0.01879967f, -0.01828500f, -0.01529459f, -0.01008106f, -0.03952110f, 
    -0.01522543f, -0.02085141f, -0.03114494f, 0.02512256f, -0.03215237f, 0.01635821f, -0.02410095f, 0.00806172f, 
    -0.01819432f, -0.04407825f, 0.00181467f, 0.00930300f, 0.02593252f, -0.02435810f, -0.02644279f, -0.01757451f, 
    -0.01250825f, 0.02126693f, -0.00443974f, 0.04374257f, 0.00274475f, -0.01585094f, 0.02350849f, -0.02256330f, 
    -0.00562709f, 0.02051746f, 0.00633097f, -0.00223212f, 0.01485784f, 0.01877966f, 0.02557959f, -0.01222499f, 
    0.03374682f, 0.02583008f, -0.04054527f, -0.03395234f, 0.02822737f, 0.03937780f, 0.00261416f, 0.00098415f, 
    -0.00213484f, 0.01906219f, -0.00242258f, -0.04214691f, -0.02472817f, -0.02144977f, -0.01292129f, 0.02228102f, 
    -0.01080455f, 0.02203720f, 0.01544956f, 0.00496904f, -0.04304221f, 0.00299601f, 0.01722244f, -0.01373616f, 
    0.00590260f, -0.03587070f, -0.01786414f, 0.02366520f, -0.00730008f, 0.00408625f, -0.00651086f, 0.01222875f, 
    -0.03050125f, 0.02370156f, -0.02248400f, -0.00572116f, -0.03279470f, -0.00650261f, 0.00348613f, -0.01227758f, 
    0.01763119f, 0.01847416f, 0.01732358f, -0.02431798f, -0.03227421f, -0.03841620f, 0.02217050f, -0.01056003f, 
    -0.03021554f, -0.04375792f, 0.00338794f, -0.01371604f, -0.00663327f, -0.00886943f, -0.02642305f, 0.00411970f, 
    0.02889470f, 0.01360175f, -0.03204229f, 0.00971777f, -0.02540951f, 0.00729969f, 0.00577709f, -0.03344356f, 
    0.03440453f, -0.03831745f, -0.00355115f, -0.00819032f, 0.02026053f, 0.01710665f, 0.01166728f, -0.00397023f, 
    -0.01629584f, -0.02172584f, 0.01130739f, -0.04046309f, -0.00927833f, 0.01949016f, 0.02455991f, -0.02144156f, 
    -0.03324090f, -0.02955963f, -0.03534988f, -0.00814141f, -0.00870182f, 0.02615618f, 0.00980871f, 0.02306570f, 
    -0.00662611f, -0.01723498f, -0.00339375f, -0.02625721f, -0.03182519f, 0.00761589f, -0.03412319f, 0.01530080f, 
    -0.01129852f, -0.03638867f, -0.01753047f, 0.00108298f, -0.01064971f, 0.02731872f, -0.02002708f, -0.03244338f, 
    -0.03448138f, 0.02415558f, 0.02460856f, -0.00209975f, -0.03822596f, 0.01019206f, -0.00847055f, -0.02001671f, 
    0.01463552f, 0.00228070f, -0.00664408f, 0.00995133f, 0.01561350f, -0.02097200f, -0.02170130f, -0.01008249f, 
    0.01024521f, 0.00676770f, 0.00455050f, 0.01357709f, 0.00374362f, 0.01815025f, 0.01548184f, 0.01047369f, 
    -0.03286098f, -0.02357299f, -0.02655590f, -0.03953208f, -0.00457193f, -0.00524438f, 0.00579959f, 0.02070178f, 
    -0.02874789f, -0.00986786f, 0.02559708f, 0.03053977f, 0.02740829f, -0.01594963f, -0.02063623f, -0.02294027f, 
    -0.02857118f, 0.00567863f, 0.00799442f, -0.00970536f, -0.01804273f, 0.01225263f, 0.00602498f, 0.00331700f, 
    -0.02483981f, -0.01499191f, -0.03971573f, 0.00809649f, -0.01648123f, -0.03885119f, -0.03442086f, -0.02783195f, 
    0.02303201f, -0.02721170f, -0.00612943f, -0.03097958f, -0.02375534f, -0.00857814f, -0.02884162f, 0.02416801f, 
    0.01920014f, -0.04186802f, -0.04023981f, 0.01875380f, -0.02923456f, -0.01377374f, -0.03237477f, -0.02532522f, 
    -0.02062355f, 0.00070878f, 0.00257902f, -0.03367279f, -0.03110543f, -0.03128248f, -0.03859235f, 0.02565934f, 
    -0.01091850f, 0.00381854f, 0.01199089f, 0.01944617f, -0.03073047f, -0.02081973f, 0.01243320f, -0.01159832f, 
    -0.03166057f, 0.00457925f, -0.03705431f, 0.00896459f, -0.03388520f, 0.03762021f, -0.00699764f, 0.01258130f, 
    -0.01415199f, 0.02645860f, -0.00591875f, -0.01066552f, -0.02384444f, -0.00195896f, -0.02963525f, 0.01562781f, 
    -0.02017440f, -0.03001207f, -0.00464795f, -0.01554523f, 0.00799976f, -0.00941532f, 0.03257750f, 0.00962420f, 
    0.01938771f, 0.01861907f, 0.02407860f, -0.02144770f, -0.04068455f, 0.00411629f, -0.04076019f, -0.01117720f, 
    0.02343412f, 0.01481754f, -0.00904406f, 0.02237678f, -0.00694648f, -0.03430087f, 0.02782052f, 0.02438730f, 
    0.03121928f, -0.02947821f, -0.03239736f, -0.02239287f, -0.02661285f, -0.02659910f, -0.01855225f, 0.01432824f, 
    0.01430185f, -0.03191675f, -0.02667476f, 0.01715758f, -0.02318338f, -0.04104118f, -0.04074432f, 0.03226668f, 
    0.00383600f, -0.03128382f, 0.01611089f, -0.04056624f, 0.02596907f, 0.03207584f, 0.02706428f, -0.03171284f, 
    0.02757455f, 0.02578195f, -0.02444621f, 0.01490675f, -0.03199920f, -0.03226696f, 0.02208410f, 0.01346790f, 
    0.02023234f, -0.02475147f, -0.02990466f, -0.03772254f, -0.00429823f, -0.01777639f, -0.02799868f, 0.00930812f, 
    0.03110360f, -0.01535700f, 0.01414688f, 0.00693468f, -0.02854906f, 0.03180186f, -0.00984862f, 0.02016369f, 
    0.00291834f, -0.00953304f, -0.00541844f, 0.00954165f, 0.02044331f, -0.01527102f, 0.03474498f, 0.00443722f, 
    0.01674523f, 0.01638267f, 0.02024512f, -0.03275478f, 0.02311191f, -0.00550708f, 0.02509877f, -0.01837497f, 
    -0.00204614f, -0.03920342f, -0.03582376f, -0.01124203f, -0.01987852f, -0.03874342f, 0.02439198f, 0.01455810f, 
    -0.01667959f, -0.03784458f, 0.01314360f, -0.02972001f, 0.02302237f, 0.02736698f, 0.01725495f, -0.03283957f, 
    0.01964003f, -0.00511824f, 0.00439321f, -0.02010250f, -0.03712470f, -0.01587089f, -0.01340915f, 0.02580258f, 
    -0.00389926f, -0.01605627f, -0.01624702f, 0.02378244f, -0.02670288f, -0.02117819f, 0.02355692f, -0.00962783f, 
    -0.00656940f, -0.03242911f, 0.02533317f, -0.00906893f, 0.00616548f, -0.02715955f, -0.03952612f, 0.00656743f, 
    -0.01051049f, -0.02557486f, -0.03728198f, -0.03905393f, -0.00913275f, 0.03043690f, -0.00149096f, 0.00081548f, 
    -0.01348002f, 0.02896498f, 0.01629084f, -0.00042345f, 0.00563782f, 0.02495359f, 0.01697976f, -0.02061074f, 
    0.00674282f, -0.00799801f, 0.01978190f, 0.01080232f, 0.01927795f, 0.00781327f, 0.00915906f, -0.01185372f, 
    -0.03584228f, 0.00658517f, 0.01633745f, 0.00858259f, 0.01206973f, -0.03623057f, -0.02005992f, 0.01487424f, 
    0.00106752f, -0.02221065f, 0.01895451f, 0.02255803f, -0.00728815f, -0.02665647f, 0.02036053f, 0.00888347f, 
    -0.02166558f, -0.01010794f, -0.00504282f, -0.01505824f, -0.01947577f, -0.02391875f, -0.02790660f, -0.03243944f, 
    0.01256188f, 0.01630312f, -0.00697894f, -0.00245256f, -0.00331883f, 0.03731754f, -0.01390486f, 0.00889556f, 
    0.02066805f, 0.00670296f, -0.00841334f, -0.04319922f, 0.00495336f, 0.01160760f, -0.03518465f, -0.01290169f, 
    0.03139452f, -0.02525327f, 0.01325196f, 0.02505421f, -0.02201541f, 0.00927706f, 0.02461432f, -0.02602213f, 
    0.00807392f, -0.03368435f, -0.00604363f, -0.02632209f, -0.01849405f, -0.02435863f, -0.03275200f, -0.01915205f, 
    -0.02886582f, -0.01075337f, -0.02326993f, 0.00415926f, -0.00345930f, -0.03222081f, -0.03502187f, -0.02892672f, 
    0.01190919f, -0.03561478f, -0.02645331f, 0.01555273f, 0.01581764f, 0.00388846f, -0.03451311f, 0.00029278f, 
    -0.00236460f, 0.00555403f, -0.00674707f, -0.03010215f, -0.01452546f, -0.01729626f, -0.00149672f, 0.00305675f, 
    0.00021739f, -0.00263390f, -0.00298107f, 0.01201099f, -0.01901725f, -0.01285884f, 0.00603339f, 0.01899906f, 
    0.02524884f, -0.02423590f, -0.02840349f, 0.01091469f, -0.01169199f, 0.02855839f, -0.01853097f, -0.00612468f, 
    0.01799763f, 0.02753589f, -0.01595664f, -0.00386242f, 0.00181519f, -0.00682691f, -0.02273035f, -0.03397809f, 
    0.01146216f, -0.00159868f, 0.00513038f, 0.00751939f, 0.00633760f, 0.02937276f, 0.00100430f, -0.02343969f, 
    0.00222109f, 0.02621446f, -0.03914353f, -0.02871529f, 0.00059994f, 0.00259092f, -0.00822950f, 0.00217783f, 
    -0.02313023f, 0.01896729f, -0.01047259f, -0.01192647f, -0.01810368f, -0.02622768f, -0.00992998f, -0.00309724f, 
    -0.02902253f, -0.03863902f, 0.02375647f, 0.00223262f, -0.00984952f, -0.02677573f, -0.00699130f, -0.01780357f, 
    0.00638675f, 0.02961612f, 0.01662631f, -0.02722381f, 0.01893625f, -0.02476447f, -0.01686862f, -0.02210569f, 
    -0.02215297f, -0.01964025f, 0.00161002f, 0.02518550f, -0.03262222f, 0.01053084f, 0.01137098f, -0.02735846f, 
    0.01563096f, 0.00325328f, -0.00876508f, 0.00320290f, -0.02643331f, 0.01556319f, -0.03504315f, 0.00863793f, 
    0.01154130f, -0.02605659f, 0.01984427f, -0.01540005f, -0.04271539f, -0.00191550f, -0.04011493f, -0.00686686f, 
    0.02148695f, -0.02952515f, -0.01290430f, -0.04366253f, -0.04183698f, 0.02100901f, -0.01759451f, -0.01719900f, 
    -0.03115358f, -0.01819650f, -0.00357096f, -0.03350114f, -0.04416257f, -0.01306339f, -0.01681316f, -0.03654853f, 
    0.03094862f, -0.03092141f, 0.00606479f, 0.00178094f, -0.03478502f, -0.03785277f, 0.00611923f, -0.00643721f, 
    0.02469421f, -0.03636013f, -0.02492227f, 0.00104816f, -0.03439507f, 0.00174588f, -0.02771829f, 0.00787964f, 
    0.00675354f, -0.03901535f, -0.00034109f, 0.01627629f, -0.03745656f, -0.02164570f, -0.00116758f, -0.01438717f, 
    -0.00940678f, -0.02734111f, -0.04008083f, 0.00512639f, -0.00880739f, -0.04382218f, 0.02164554f, -0.02471821f, 
    0.00157297f, -0.01144167f, 0.00477321f, -0.00676751f, 0.01070014f, -0.00248518f, 0.01667049f, -0.03177872f, 
    -0.02321235f, -0.02315904f, -0.03735615f, -0.00611938f, -0.01066587f, -0.01289152f, 0.01625170f, -0.01701635f, 
    0.02536457f, 0.02546804f, 0.01823092f, -0.01332325f, 0.01939324f, 0.00621701f, -0.00136898f, -0.01441228f, 
    -0.00975200f, -0.03888217f, -0.02817596f, -0.03822256f, 0.00251725f, -0.02654567f, -0.02136144f, 0.03000059f, 
    0.02392237f, -0.02955668f, 0.00920365f, 0.02033239f, -0.01546186f, 0.02037254f, 0.00793465f, -0.01860829f, 
    -0.00166651f, -0.02828912f, -0.01315714f, -0.02822975f, -0.03758782f, 0.00992693f, 0.01613317f, -0.01260870f, 
    -0.01938029f, -0.00529746f, -0.00478039f, -0.02362507f, -0.04466892f, 0.01334985f, -0.01831860f, 0.01298580f, 
    0.01805988f, -0.02780516f, 0.00242343f, -0.03118263f, -0.00150858f, -0.01252680f, -0.02079373f, -0.01486661f, 
    -0.03557580f, -0.02968826f, -0.01658846f, -0.03712818f, -0.02180725f, -0.02405157f, -0.02981715f, -0.01863917f, 
    -0.00086299f, 0.03729970f, 0.02016227f, -0.01244900f, -0.00359950f, -0.02925564f, 0.00183421f, 0.01076517f, 
    0.01751960f, 0.01058538f, -0.04161544f, 0.00679080f, 0.02218595f, -0.02472476f, -0.03200610f, -0.02188245f, 
    -0.01120553f, 0.02598300f, -0.03713245f, -0.00204713f, -0.03741708f, 0.00938641f, -0.04067636f, 0.02052354f, 
    -0.00021848f, -0.02197588f, -0.00014324f, 0.00399645f, -0.03218700f, 0.02839993f, -0.00731679f, -0.02824247f, 
    0.00372838f, 0.00926368f, 0.00356209f, -0.02733295f, 0.02102374f, -0.03246469f, 0.01840241f, -0.02164316f, 
    -0.02642423f, -0.02917790f, -0.02690443f, -0.00886857f, -0.01984093f, 0.00386307f, -0.01765442f, 0.01834804f, 
    -0.02568008f, -0.01859792f, -0.02243466f, 0.02964403f, -0.02757125f, -0.00297161f, 0.01345146f, -0.00104415f, 
    -0.03765868f, 0.00171577f, -0.01575120f, -0.01618876f, 0.03266001f, -0.04581712f, -0.04028350f, -0.04392044f, 
    -0.03274952f, 0.01833314f, 0.02296506f, -0.03358382f, 0.01770712f, -0.02949525f, 0.00406948f, -0.03473039f, 
    0.02169360f, 0.00053103f, -0.04334947f, 0.02370751f, 0.02312825f, -0.01097141f, 0.00998625f, -0.00182431f, 
    0.00813765f, 0.01349247f, -0.02376080f, 0.00496452f, -0.01921024f, 0.02635947f, -0.02906503f, -0.01127343f, 
    -0.02360187f, -0.01742057f, -0.02842453f, 0.03082368f, -0.02132215f, -0.02933734f, 0.01903630f, 0.03461893f, 
    0.00226880f, 0.00007037f, 0.01984419f, 0.02742982f, 0.00190773f, 0.00657434f, 0.02404873f, -0.03516788f, 
    0.03198793f, 0.02611992f, -0.02095356f, -0.04045231f, -0.01255554f, -0.04078829f, 0.02511333f, -0.01119103f, 
    0.00951150f, -0.03570390f, -0.03421491f, -0.03555606f, -0.02608711f, 0.00817692f, -0.00790340f, -0.03791032f, 
    0.03229700f, -0.00339582f, 0.02584242f, -0.01680208f, -0.02503217f, 0.02768996f, -0.01918011f, -0.01437926f, 
    -0.00678049f, -0.01358493f, -0.02309957f, 0.02229333f, -0.01675377f, -0.02195979f, -0.02354860f, 0.02920160f, 
    -0.03360759f, -0.01102308f, 0.02233453f, -0.03500624f, -0.03737029f, -0.00626857f, -0.01273136f, -0.02789601f, 
    0.03131913f, 0.01463827f, -0.01936751f, 0.00348479f, -0.00917904f, -0.04420944f, -0.02017144f, -0.00082858f, 
    0.01724184f, 0.02145549f, -0.03412726f, -0.03776970f, 0.02897010f, 0.02769371f, -0.00289925f, -0.00260606f, 
    -0.00603898f, 0.01209577f, -0.03624025f, -0.01509866f, -0.02745511f, -0.01969242f, 0.01739328f, -0.03772628f, 
    -0.03811643f, -0.02169813f, -0.02418786f, -0.00174203f, 0.00375881f, -0.00625890f, 0.01724708f, -0.01997890f, 
    -0.02443296f, -0.02867967f, -0.00521146f, -0.02233820f, -0.02558898f, 0.00942456f, -0.00071591f, 0.03683661f, 
    0.00310953f, 0.01186455f, 0.00168653f, 0.01592169f, 0.01274373f, -0.00630273f, -0.01023531f, -0.04645467f, 
    -0.00476386f, -0.03955964f, -0.02342024f, 0.02256385f, 0.03389429f, -0.02388982f, -0.01487989f, -0.04452917f, 
    0.01501712f, -0.03926932f, -0.00954703f, -0.02776784f, 0.02326871f, -0.03555866f, -0.04190912f, -0.02047951f, 
    -0.01785392f, -0.03516052f, 0.02683569f, -0.03436449f, -0.02135937f, 0.00970233f, -0.02117202f, -0.02587112f, 
    -0.03948768f, -0.03587312f, 0.00100091f, 0.00368196f, -0.01537159f, 0.01105627f, 0.01646639f, 0.01239565f, 
    0.02695678f, 0.02513070f, 0.00868207f, -0.00906842f, 0.00469593f, -0.03029457f, -0.00314563f, 0.00246299f, 
    -0.02759848f, -0.00650612f, -0.03356582f, -0.04286634f, -0.03965833f, 0.00628123f, -0.03099238f, -0.03268892f, 
    -0.03935012f, -0.03091275f, -0.04582653f, -0.04020304f, -0.04547260f, -0.01640531f, -0.02443600f, 0.01266164f, 
    0.01348491f, -0.02751838f, -0.01162535f, -0.00052012f, 0.00155761f, -0.02838313f, 0.01812473f, -0.02931623f, 
    -0.02636904f, 0.00661106f, 0.01614607f, -0.02560409f, -0.03049058f, -0.03105229f, 0.02144972f, -0.04232800f, 
    0.03923047f, -0.00670780f, -0.00999080f, 0.01692464f, -0.04118252f, -0.00983421f, -0.03703907f, 0.00829824f, 
    0.02486903f, -0.00160744f, -0.02886935f, -0.01800981f, 0.01588192f, -0.01882648f, 0.02500263f, -0.04598442f, 
    0.00329721f, -0.01142267f, -0.03285784f, -0.03631169f, -0.01360881f, -0.03354483f, 0.02887778f, -0.03195081f, 
    0.02970041f, -0.03406794f, -0.00009636f, 0.01904344f, 0.01841444f, 0.02502117f, -0.01789008f, -0.01972786f, 
    0.03354536f, -0.03363550f, -0.03715719f, -0.03702539f, -0.01915235f, 0.02845227f, -0.02847432f, 0.02186575f, 
    -0.00906910f, 0.02181237f, 0.02056465f, 0.02361094f, -0.02264623f, -0.00668445f, 0.00309200f, -0.00269358f, 
    0.01134880f, 0.00130279f, 0.01926625f, 0.01431629f, 0.01139607f, 0.00043977f, -0.01366271f, -0.01833307f, 
    -0.00682469f, -0.01471185f, -0.02923976f, 0.00312648f, 0.01715506f, -0.03107888f, 0.01445901f, 0.00797470f, 
    -0.03172481f, 0.01824097f, -0.01812220f, -0.04022901f, 0.01632051f, 0.00900334f, 0.03049077f, 0.00335272f, 
    -0.02258715f, 0.00305858f, -0.00673013f, -0.01069905f, 0.00689471f, 0.00449474f, 0.02313228f, -0.03246111f, 
    0.02122965f, -0.02995367f, -0.03469104f, -0.02459401f, -0.00768032f, -0.00107613f, 0.01608921f, 0.00850349f, 
    -0.03249881f, 0.01989512f, -0.00775649f, -0.02932531f, 0.01306383f, 0.00181307f, 0.01590503f, -0.00855218f, 
    0.00345182f, -0.01630438f, -0.02879528f, -0.00868061f, -0.04517440f, -0.00679519f, 0.01448803f, -0.00035441f, 
    -0.02539008f, -0.03047384f, 0.02193307f, 0.02280367f, 0.00164125f, -0.03123728f, -0.01969126f, -0.02630924f, 
    0.00565315f, -0.04300469f, -0.00635491f, 0.02845943f, -0.00797626f, 0.02639369f, 0.02042026f, 0.01038288f, 
    -0.02393682f, -0.00910739f, -0.03803303f, -0.00068918f, -0.00202097f, -0.04070834f, -0.00079267f, 0.01055215f, 
    -0.01086688f, 0.00877199f, -0.02664102f, 0.00828652f, 0.00718346f, 0.01346616f, -0.03219398f, -0.03677591f, 
    -0.00262149f, -0.00966848f, -0.00228961f, 0.00134618f, 0.02919531f, -0.03157467f, -0.03055215f, 0.01502721f, 
    -0.01650989f, -0.00081768f, 0.00396371f, -0.03690405f, -0.01252772f, -0.01562285f, -0.02836718f, -0.01622763f, 
    -0.01912565f, -0.02387236f, -0.02952943f, -0.00022547f, 0.00363949f, 0.02148562f, -0.02905784f, -0.02435271f, 
    0.01599156f, -0.02019243f, -0.03070796f, -0.01855767f, -0.01331985f, -0.01657013f, 0.02371068f, 0.02377600f, 
    -0.03431101f, 0.00216619f, 0.01371818f, 0.00021120f, -0.03533635f, 0.01655628f, -0.01764594f, -0.00746486f, 
    -0.00028996f, 0.00663519f, 0.01131606f, -0.01760820f, 0.00303018f, -0.02754015f, -0.01158678f, -0.03207153f, 
    -0.02494277f, 0.01422546f, -0.03535517f, -0.02187401f, -0.01479975f, 0.03068494f, 0.01218601f, 0.02313288f, 
    -0.02563403f, -0.00759055f, -0.01592539f, 0.03392510f, 0.00742388f, -0.04398662f, -0.01170341f, 0.01694836f, 
    -0.00395559f, 0.01715108f, 0.01097506f, 0.00778776f, 0.01418537f, -0.02377669f, 0.00958970f, -0.03758920f, 
    -0.02055164f, 0.02985605f, -0.03346702f, 0.01378957f, -0.02703423f, -0.03667007f, -0.04013900f, -0.02571272f, 
    -0.00946065f, 0.01733267f, -0.05149844f, -0.01604265f, 0.01944485f, 0.00065343f, -0.01347048f, -0.03021990f, 
    -0.01336506f, 0.01196355f, -0.00284484f, 0.01133531f, -0.02065164f, -0.01029955f, 0.02531670f, -0.02976810f, 
    -0.00331499f, -0.03106695f, -0.00556940f, -0.04020818f, 0.02841334f, 0.00222179f, 0.00104954f, 0.00234451f, 
    0.02144258f, -0.00557261f, 0.01470662f, -0.01827390f, -0.01503773f, 0.02709286f, 0.01385722f, 0.00672352f, 
    -0.01693683f, 0.01919625f, 0.02534158f, -0.00327979f, 0.01745217f, 0.01264809f, -0.01726716f, -0.00400349f, 
    -0.01856110f, 0.02044797f, -0.01728275f, -0.00399966f, -0.02651486f, 0.03144521f, 0.02151855f, -0.01216854f, 
    0.00616939f, -0.03173455f, -0.04052523f, -0.01235224f, -0.01416217f, -0.03713818f, 0.01404726f, 0.02841096f, 
    0.01312783f, 0.01670083f, -0.03153294f, 0.02112840f, 0.01902400f, -0.02753094f, -0.04252666f, -0.02868973f, 
    -0.01630823f, 0.02536983f, 0.00321374f, -0.00924542f, -0.02919954f, -0.00099238f, -0.01713947f, 0.01892725f, 
    0.01680308f, -0.02281205f, -0.01684702f, 0.02865323f, 0.01409294f, -0.02360662f, 0.00037599f, -0.04175659f, 
    -0.03671463f, -0.02627839f, 0.02385859f, -0.03942658f, -0.02623274f, -0.03578699f, 0.03126390f, 0.01314862f, 
    0.01479339f, 0.01960742f, 0.00658860f, -0.02037598f, 0.00842563f, 0.01520217f, -0.00194449f, -0.04146363f, 
    -0.03734685f, -0.04625086f, -0.03515929f, -0.00707159f, 0.01025007f, -0.02259039f, -0.03868281f, 0.01639440f, 
    0.00668218f, 0.01632426f, -0.01955591f, -0.03620907f, -0.02182724f, -0.03646794f, 0.01807428f, 0.03029019f, 
    -0.02177881f, 0.01963413f, -0.01644970f, -0.02674896f, 0.02021353f, 0.01580717f, 0.00905274f, 0.03194354f, 
    -0.02265599f, -0.02186321f, 0.04057832f, 0.02145412f, 0.00016328f, -0.00560785f, -0.01805356f, 0.01399012f, 
    -0.00485463f, 0.00137618f, 0.00876664f, -0.01632440f, 0.00280236f, 0.02246378f, -0.00169773f, -0.01201603f, 
    -0.00836191f, -0.01461873f, -0.01821022f, -0.02857747f, -0.01679457f, 0.00008334f, -0.01690366f, -0.03760077f, 
    -0.01877266f, -0.01010261f, 0.02041353f, 0.01692377f, -0.00922343f, -0.02467808f, 0.00731314f, -0.02821468f, 
    0.01966728f, -0.03794403f, -0.00371472f, 0.00572923f, 0.01115400f, -0.02035891f, 0.02588691f, 0.01722068f, 
    0.00578421f, 0.01924931f, -0.02157558f, -0.01035433f, 0.03772681f, -0.01634492f, -0.03821824f, -0.03774400f, 
    0.00063621f, -0.04127949f, 0.03390587f, -0.00387790f, 0.01769466f, 0.02678924f, -0.02416419f, -0.02086693f, 
    -0.00525615f, -0.00047883f, -0.00713068f, -0.02995028f, -0.02168835f, 0.00276310f, -0.03577023f, 0.01067161f, 
    0.02912793f, -0.04210442f, -0.00164137f, -0.00602168f, -0.02160325f, 0.01317817f, 0.02063775f, -0.02994110f, 
    0.01388796f, -0.03991445f, 0.01606552f, -0.03043651f, -0.02404879f, -0.02830284f, -0.03855651f, -0.02193473f, 
    -0.02398238f, 0.00283869f, 0.00389225f, -0.02561793f, -0.01988334f, -0.02709461f, -0.00495110f, -0.02972769f, 
    -0.00881218f, 0.02624713f, 0.02118887f, 0.02054204f, -0.00991534f, 0.02420260f, -0.01679844f, 0.01194288f, 
    -0.03690813f, -0.03212881f, -0.04069047f, 0.01738257f, 0.01855055f, 0.00185748f, -0.01952746f, -0.02507352f, 
    -0.01044013f, -0.01583957f, 0.02655717f, 0.01642985f, -0.03179048f, -0.02716292f, -0.03555610f, -0.03140979f, 
    -0.01947977f, -0.03276359f, -0.02073211f, 0.00515818f, 0.02007640f, 0.00247801f, -0.03328541f, -0.00179530f, 
    -0.02582093f, -0.01259678f, -0.00250421f, -0.03886308f, -0.00050897f, -0.01762033f, 0.02258817f, -0.02051554f, 
    0.00149225f, 0.02857764f, -0.00830891f, -0.03480989f, -0.01680388f, -0.01745095f, -0.02010199f, -0.00359565f, 
    -0.00174374f, -0.02987549f, 0.01648520f, -0.02170551f, -0.00273395f, -0.01018460f, -0.02418072f, 0.03167811f, 
    0.02363582f, -0.04121016f, 0.00457534f, 0.01878654f, -0.03233121f, 0.00090619f, -0.02453532f, -0.03329058f, 
    -0.03210292f, -0.00190296f, -0.01339037f, 0.00868767f, -0.02736188f, -0.02158522f, 0.02048774f, -0.00218291f, 
    0.00224101f, -0.00004038f, -0.01303249f, -0.00455348f, 0.01763833f, 0.02357370f, -0.02747940f, -0.01081161f, 
    0.00173909f, -0.01755613f, -0.04068894f, -0.00187768f, -0.03173486f, -0.03624625f, -0.01597839f, -0.01534704f, 
    0.02118825f, 0.02084790f, 0.02092204f, 0.02121841f, 0.03340441f, 0.00436013f, -0.00956183f, 0.01084879f, 
    0.01798441f, -0.00875585f, 0.01657767f, 0.01091624f, 0.02596447f, -0.00603666f, 0.00501798f, 0.00067937f, 
    -0.01956712f, -0.00665883f, -0.00262160f, -0.00340295f, -0.03538491f, -0.03130464f, 0.01318735f, 0.01341305f, 
    0.01291451f, 0.03170775f, -0.00554372f, 0.01206402f, -0.00691363f, 0.01538264f, -0.04010528f, -0.00946020f, 
    -0.01055474f, -0.03944283f, -0.02847991f, -0.04745913f, 0.02623507f, -0.00255039f, 0.02028615f, -0.01404622f, 
    0.01488682f, -0.03088157f, -0.03025879f, -0.01177670f, -0.03745445f, 0.01150010f, 0.02148000f, 0.01428421f, 
    -0.02784139f, 0.01264994f, -0.02551123f, -0.01035267f, -0.04079338f, 0.03079618f, -0.00864006f, -0.02175356f, 
    0.01742693f, -0.02920289f, 0.01815951f, 0.02599657f, -0.01295935f, -0.00114681f, 0.03053511f, -0.00290288f, 
    0.01307996f, -0.02235514f, 0.00914298f, -0.02941346f, 0.01184343f, -0.01383003f, -0.00147404f, -0.00149461f, 
    -0.01574298f, 0.03080084f, 0.03766949f, -0.03040696f, 0.01403823f, 0.02707596f, -0.00400415f, 0.01113659f, 
    -0.02147133f, -0.01641529f, -0.00678434f, -0.01797528f, 0.03403532f, -0.00438768f, -0.04399521f, 0.00839356f, 
    -0.01708311f, -0.03341417f, -0.03182285f, 0.02248773f, 0.00674551f, 0.00944200f, 0.00087214f, 0.02455367f, 
    -0.01638396f, -0.01934480f, 0.01201642f, -0.01916357f, -0.01637306f, 0.00740380f, -0.01818523f, -0.01885127f, 
    -0.03910506f, 0.03574072f, -0.01658364f, 0.01795464f, -0.01875392f, -0.01816286f, -0.02207361f, 0.00686953f, 
    0.02058565f, -0.00794074f, 0.01142291f, 0.01644227f, -0.01816170f, 0.01472664f, -0.02668218f, -0.00472882f, 
    0.00254606f, 0.02566309f, 0.00365949f, -0.00279957f, -0.01241054f, 0.01403406f, -0.03652163f, -0.00882660f, 
    -0.01771499f, 0.00050106f, 0.01550062f, -0.03773592f, -0.01526370f, -0.01709510f, -0.03198666f, -0.02317696f, 
    0.00590614f, -0.04458754f, -0.02037764f, -0.00278485f, 0.02005061f, 0.01812175f, 0.01132592f, -0.02980009f, 
    0.01919255f, -0.04357360f, -0.01904568f, -0.00112072f, -0.00290690f, -0.01194004f, -0.03090733f, -0.02224170f, 
    0.01486535f, 0.00224366f, 0.01204794f, -0.03048185f, -0.00238722f, 0.01847106f, 0.01590486f, -0.01314814f, 
    -0.01877734f, -0.02427544f, -0.03096593f, -0.04019989f, -0.03010037f, -0.00368506f, 0.01336177f, 0.02070722f, 
    0.02613279f, 0.02427441f, -0.02360211f, 0.01677375f, -0.01830011f, -0.01404574f, -0.02677184f, -0.02207513f, 
    0.02078144f, -0.01198781f, -0.02241994f, 0.00118591f, -0.02884311f, -0.01932253f, -0.01717478f, -0.03120872f, 
    0.02862099f, -0.00131074f, 0.00476529f, -0.03062965f, 0.02000458f, -0.03449823f, 0.00829629f, 0.01108545f, 
    0.02107126f, -0.03755291f, -0.03132430f, 0.02603693f, 0.01868337f, -0.00005046f, 0.00720121f, -0.02394499f, 
    -0.02326091f, 0.02436942f, 0.00722479f, -0.03833709f, 0.00941188f, -0.01810817f, 0.00808027f, 0.01620334f, 
    0.02914393f, -0.01082474f, 0.01849286f, 0.01048841f, -0.01405160f, 0.02520793f, 0.02749201f, 0.02208163f, 
    -0.01270123f, 0.00651347f, -0.03163791f, 0.02644812f, 0.03229913f, -0.03079534f, -0.04726310f, 0.01164345f, 
    -0.03350376f, 0.03122171f, -0.02110141f, -0.01750125f, 0.01758286f, 0.01749942f, 0.02746546f, -0.00014940f, 
    -0.02499605f, 0.01731770f, -0.02622687f, -0.03310714f, -0.03543415f, -0.02683985f, 0.01680986f, -0.01334801f, 
    -0.00902978f, 0.02401322f, -0.02527087f, 0.01414213f, -0.00374741f, -0.01108796f, -0.03042965f, -0.02721333f, 
    -0.02256314f, -0.00042518f, 0.01325477f, -0.00993180f, -0.02473251f, 0.00864265f, -0.00063191f, 0.01190626f, 
    0.00951818f, -0.01090872f, 0.02555666f, -0.03180807f, -0.00564651f, -0.03953733f, 0.00351831f, -0.02171641f, 
    -0.02789303f, -0.00653840f, 0.00824688f, -0.00560498f, -0.00185047f, 0.01194118f, -0.02214750f, -0.02139592f, 
    0.00999204f, -0.02531943f, -0.01232805f, -0.01971110f, -0.00606445f, -0.01235919f, 0.00165373f, -0.03630875f, 
    -0.01380925f, -0.03429329f, -0.02546170f, -0.04050398f, -0.01954356f, -0.01227290f, -0.02962789f, 0.00561464f, 
    -0.02542300f, 0.01959919f, -0.00861680f, -0.00646554f, 0.00006571f, 0.01644032f, -0.00245623f, -0.00996073f, 
    0.02552483f, -0.00790205f, -0.03106075f, -0.03296061f, 0.00743930f, -0.04114159f, -0.01738672f, -0.03146907f, 
    0.00040724f, -0.00468680f, 0.00332051f, 0.01124514f, -0.04024453f, 0.02840327f, 0.02331748f, -0.03126406f, 
    0.01940502f, 0.02764706f, -0.03472323f, -0.04436221f, 0.00539797f, 0.01341289f, 0.03148165f, -0.01681012f, 
    -0.00851342f, -0.02072022f, -0.03509066f, -0.02148972f, 0.01923671f, 0.02672512f, -0.03114342f, -0.00736218f, 
    0.02518058f, -0.02441162f, -0.00691602f, -0.03299738f, -0.03158824f, 0.00507909f, -0.00359797f, -0.00549884f, 
    0.01040443f, 0.03437309f, -0.03003660f, -0.03831042f, 0.00324768f, 0.02543953f, -0.02480278f, 0.00811934f, 
    -0.01638776f, 0.02508345f, 0.01408755f, -0.00620967f, 0.01887468f, -0.01018739f, -0.03991860f, -0.01678695f, 
    -0.00961092f, -0.01000962f, 0.02466727f, 0.01555813f, 0.01492485f, -0.01100234f, 0.01362975f, -0.03051202f, 
    0.00469032f, -0.00174448f, -0.00383478f, -0.01786511f, -0.03554837f, -0.02980725f, -0.03642252f, -0.01042451f, 
    0.01728826f, 0.03289959f, 0.00958031f, -0.00696971f, -0.01195186f, -0.03653847f, -0.02543812f, 0.00496387f, 
    0.01006151f, 0.02783358f, -0.01534565f, 0.01933335f, -0.00474468f, 0.00090572f, -0.00583994f, -0.04536467f, 
    -0.02755727f, -0.00860390f, 0.02496663f, 0.00695138f, -0.00440271f, -0.01887980f, 0.01532579f, 0.03767805f, 
    -0.02343075f, 0.02493465f, -0.00835843f, -0.01223093f, -0.03659396f, -0.00698516f, 0.00780182f, -0.00010582f, 
    -0.02421407f, -0.02041965f, -0.01932653f, -0.02259559f, 0.01332598f, 0.02069074f, 0.00461628f, 0.02275817f, 
    -0.03152902f, 0.02280696f, -0.01652732f, 0.02790418f, -0.02389450f, -0.02234249f, -0.01797972f, 0.02395019f, 
    0.02762334f, -0.02296587f, -0.03492114f, 0.01419139f, 0.01651648f, 0.02745008f, -0.00226788f, 0.00965927f, 
    0.01686110f, -0.03027657f, -0.03215941f, 0.02154832f, -0.00017545f, 0.02250434f, 0.00437989f, 0.02159940f, 
    0.00726020f, -0.01272064f, 0.02462837f, 0.02318643f, -0.01467465f, -0.03528226f, -0.00882459f, -0.00131274f, 
    -0.01977781f, -0.01611582f, 0.02405363f, 0.00518083f, -0.01628574f, 0.00093814f, 0.01898491f, -0.02595765f, 
    -0.00034010f, 0.02161598f, -0.03316533f, -0.01228651f, -0.03590183f, -0.02074251f, 0.02741465f, -0.03596705f, 
    -0.01338841f, -0.02295168f, -0.00324465f, 0.00683626f, 0.03081058f, -0.03144714f, -0.00486889f, -0.00739427f, 
    0.01661432f, 0.03409697f, 0.02658327f, 0.00179041f, -0.00722276f, 0.01229636f, -0.04340190f, -0.00009367f, 
    -0.03352351f, 0.03032309f, 0.03735683f, -0.01720655f, -0.01420839f, -0.02436025f, 0.03036792f, -0.00217894f, 
    0.00036077f, -0.03726201f, 0.03777062f, 0.01895304f, 0.00307684f, 0.01861904f, -0.00702725f, -0.01383447f, 
    0.00929679f, 0.02738413f, 0.02782740f, 0.02405533f, -0.02708375f, -0.02238453f, -0.03927559f, 0.00619574f, 
    -0.02517884f, -0.01075369f, -0.00337352f, -0.03951509f, 0.03015218f, -0.04245268f, -0.03403958f, -0.01532421f, 
    0.00968935f, -0.00869306f, 0.01201347f, -0.03675190f, -0.00014152f, -0.04098633f, 0.00073443f, 0.00736909f, 
    0.02722826f, -0.01514152f, 0.01729450f, -0.03076998f, 0.02459983f, -0.02118982f, -0.01260077f, -0.00370758f, 
    0.00207117f, 0.03443699f, 0.03603052f, -0.02532270f, -0.01254371f, -0.01618204f, 0.00638957f, 0.01278760f, 
    0.00680053f, 0.02437671f, -0.02597610f, -0.02082197f, -0.00014182f, 0.01864361f, 0.03301604f, 0.00923433f, 
    0.02301819f, -0.03536968f, -0.03753963f, 0.00881066f, 0.02219003f, 0.01318808f, -0.01532935f, 0.00981458f, 
    -0.03756280f, 0.01211679f, 0.00472785f, -0.00475181f, -0.03915058f, -0.02325599f, 0.02524650f, 0.01510229f, 
    0.02147444f, 0.00658726f, -0.01472701f, -0.01856765f, -0.01752905f, -0.00018039f, 0.01981882f, 0.02381360f, 
    -0.01767290f, 0.00689323f, 0.02154976f, -0.02125859f, 0.02073092f, 0.02506884f, -0.01275115f, 0.02115083f, 
    -0.04478893f, 0.05795559f, 0.00287757f, 0.07351668f, -0.02581038f, 0.04034737f, 0.00578114f, 0.02894615f, 
    0.01226904f, -0.02736165f, -0.03486730f, -0.00506371f, -0.07603067f, 0.13347600f, -0.04315446f, 0.15919231f, 
    0.27421540f, 0.08337063f, 0.27347007f, 0.05133932f, -0.03384301f, -0.06736171f, -0.10785279f, -0.10130183f, 
    0.32973683f, 0.13797905f, -0.00825627f, 0.10175554f, -0.13890915f, 0.09195387f, 0.04339516f, -0.14881307f, 
    0.06865278f, 0.05912226f, -0.03760042f, -0.00446906f, 0.16129132f, 0.21500432f, 0.17351805f, -0.01982914f, 
    0.04517192f, -0.01021671f, -0.04181705f, 0.05936913f, 0.05063742f, 0.02702032f, 0.03200227f, 0.04484187f, 
    0.02388925f, 0.08578061f, 0.00911795f, 0.09142917f, -0.04682000f, 0.10461856f, 0.00362443f, 0.13356705f, 
    0.06807347f, -0.03208291f, 0.05943261f, -0.13197111f, -0.17636827f, 0.19592032f, -0.00299867f, 0.00626408f, 
    -0.04581914f, -0.01484603f, -0.10268824f, 0.02041734f, -0.04933854f, -0.11959873f, -0.02532007f, -0.13570383f, 
    -0.06790598f, -0.01701958f, -0.02401095f, -0.00855528f, 0.12220046f, 0.01969465f, -0.03623832f, -0.02592807f, 
    -0.18682699f, 0.06842865f, -0.00729339f, -0.11910757f, -0.01333673f, 0.05031020f, 0.08657675f, 0.09857865f, 
    -0.06584376f, -0.04234558f, -0.09507898f, 0.02341765f, -0.13988073f, 0.03542493f, 0.24349613f, -0.14655028f, 
    -0.10786749f, 0.11160571f, -0.01859563f, 0.07199938f, 0.11251956f, -0.13464127f, 0.16308719f, -0.04308725f, 
    0.02985832f, 0.07907658f, 0.14837746f, -0.10225728f, -0.28318533f, -0.00067618f, -0.02735543f, 0.00554814f, 
    0.08112666f, -0.04262160f, 0.00138109f, -0.04494028f, -0.06334031f, -0.00789310f, 0.10710562f, -0.01976649f, 
    -0.08290239f, 0.20672829f, 0.24420922f, 0.20650299f, 0.06314331f, -0.05626598f, 0.00670669f, -0.00598425f, 
    0.04516867f, 0.04147600f, 0.14507629f, -0.02200929f, 0.22515571f, 0.21215458f, 0.08709104f, 0.17408289f, 
    0.07352529f, 0.14007202f, 0.01580188f, -0.00922573f, 0.05278058f, 0.07769345f, 0.17624775f, -0.03552277f, 
    -0.16725722f, 0.21513437f, -0.08905773f, -0.06364121f, -0.05673844f, 0.01735200f, -0.06892899f, -0.03701671f, 
    0.00454570f, -0.10343910f, -0.00492135f, 0.05161334f, -0.00557131f, 0.13643707f, 0.14305067f, 0.20928614f, 
    -0.00485977f, 0.05028933f, 0.03496680f, 0.01920624f, -0.03093408f, -0.04038940f, -0.03347785f, -0.06706921f, 
    0.05824528f, -0.21427348f, 0.11367801f, 0.13669084f, 0.03007790f, -0.04413256f, 0.04249326f, -0.04381756f, 
    -0.06174725f, -0.01931337f, -0.09857696f, 0.12856056f, 0.03933922f, 0.06687509f, 0.05185261f, -0.08131500f, 
    0.05972856f, -0.11025605f, -0.03301926f, -0.01176635f, -0.08040609f, 0.03779197f, 0.07539322f, -0.05770887f, 
    0.19675757f, 0.17944075f, 0.13117638f, 0.08048347f, 0.14370775f, 0.00007205f, 0.05756537f, 0.10319881f, 
    0.17847906f, 0.02040991f, 0.08632695f, 0.03823294f, -0.09798563f, 0.09614056f, 0.06151948f, -0.00965074f, 
    0.06973664f, 0.03885081f, -0.06510479f, -0.01465907f, 0.05302635f, -0.04441373f, -0.11921225f, 0.14873445f, 
    -0.20645915f, -0.16921867f, 0.04300965f, 0.22766811f, -0.03753263f, 0.02913484f, -0.05508137f, 0.01835251f, 
    0.16371207f, 0.14521925f, 0.09933418f, 0.20489946f, -0.05466531f, 0.32996047f, -0.04766660f, 0.01576786f, 
    0.04579871f, 0.05075968f, -0.10434032f, -0.00565974f, 0.07160193f, -0.10117449f, -0.03847958f, -0.06117658f, 
    0.01677551f, 0.22674304f, 0.15701692f, 0.33750719f, 0.07002923f, 0.09272559f, 0.07735535f, -0.00393255f, 
    -0.04320111f, -0.06030564f, -0.00531833f, -0.01892761f, 0.33516625f, 0.16814733f, 0.05390301f, 0.20787880f, 
    0.00201409f, -0.07563311f, -0.01099978f, -0.06078124f, -0.01702357f, -0.02774845f, -0.10814884f, -0.05251474f, 
    -0.11525767f, -0.31398562f, -0.00996168f, -0.03391939f, 0.01397756f, -0.07638147f, -0.15539886f, -0.04152660f, 
    -0.01120163f, -0.00624349f, -0.11066781f, -0.10566644f, 0.29373524f, -0.06714433f, 0.01645067f, 0.16369998f, 
    -0.02443499f, -0.01439067f, -0.01635478f, -0.07857381f, 0.10451266f, 0.11846152f, -0.08733189f, 0.03573136f, 
    0.05501652f, 0.12144552f, 0.04495876f, 0.12742484f, 0.03941891f, -0.18570185f, 0.08708479f, 0.04840721f, 
    -0.01684589f, 0.03438564f, 0.02133349f, 0.02978330f, 0.00525680f, -0.08816195f, -0.16593526f, -0.09357054f, 
    -0.05678434f, 0.00738920f, 0.02167585f, -0.04217188f, 0.11247063f, -0.03280376f, -0.03180648f, 0.01422150f, 
    0.05313932f, 0.17519785f, 0.10092658f, 0.32345408f, 0.01821483f, 0.10423785f, 0.01973441f, -0.08238067f, 
    0.05438999f, -0.06459467f, -0.03591216f, -0.15157402f, 0.21725868f, 0.19644557f, 0.03686263f, -0.07694580f, 
    0.19961254f, 0.02048819f, -0.00378078f, 0.07367181f, 0.08662760f, 0.03375786f, 0.00951040f, 0.05378339f, 
    0.07103081f, 0.18253054f, 0.08876365f, -0.02004971f, 0.07076974f, -0.00366640f, -0.18036669f, 0.20093159f, 
    -0.01430492f, 0.12290017f, 0.08640001f, -0.01864463f, -0.06796116f, 0.05693596f, 0.19309889f, 0.13188834f, 
    0.04089896f, -0.04838900f, 0.04209134f, 0.13090324f, 0.01903354f, 0.09326390f, -0.00887810f, 0.14822873f, 
    -0.00372140f, 0.09970585f, 0.11963283f, 0.14829454f, -0.05264806f, 0.02576021f, -0.00880740f, -0.05095665f, 
    0.00163694f, -0.03586950f, 0.13349541f, 0.05185212f, -0.02723896f, 0.09367750f, 0.13451850f, 0.35827464f, 
    0.12952992f, -0.00883503f, 0.03596640f, -0.22032727f, 0.10775838f, 0.07625477f, -0.01649868f, 0.11352070f, 
    -0.09986223f, 0.13997000f, 0.07170700f, 0.16010468f, 0.06246199f, 0.10720745f, 0.08871638f, -0.00541716f, 
    0.09525695f, 0.00081155f, -0.10124843f, -0.03183801f, -0.29175937f, 0.22499546f, 0.06628770f, 0.05451689f, 
    -0.00322341f, -0.00408653f, 0.04235121f, 0.06863236f, -0.00707678f, 0.02888653f, -0.09461344f, 0.04244589f, 
    0.05758691f, -0.06071163f, -0.03536348f, -0.03792372f, 0.01904353f, -0.07544761f, 0.02545295f, -0.01907092f, 
    -0.05910495f, 0.03787690f, -0.04700453f, 0.07981453f, -0.31621513f, 0.09860915f, 0.06756247f, -0.12640277f, 
    0.04184828f, -0.06663812f, 0.04588553f, -0.00899226f, -0.03183728f, 0.13247199f, 0.05630787f, 0.08955085f, 
    -0.11148755f, 0.16181670f, 0.04768108f, 0.12198820f, -0.00773054f, -0.06105797f, -0.03757268f, 0.11744754f, 
    -0.05228107f, 0.00386838f, 0.03728420f, -0.12597254f, 0.14422728f, -0.05592856f, 0.17680803f, 0.09903809f, 
    0.07755102f, -0.03235348f, -0.07947836f, 0.16832778f, 0.03538267f, -0.11739407f, 0.04711300f, -0.01481040f, 
    -0.21498610f, -0.08992452f, 0.15529864f, 0.33184484f, -0.13209918f, -0.02882889f, 0.04552135f, -0.05912067f, 
    0.08777857f, -0.00652005f, 0.06821541f, -0.00412467f, 0.15706834f, -0.13204688f, -0.16291164f, -0.14470144f, 
    0.13872083f, 0.00314567f, 0.01633902f, -0.02028800f, 0.03324875f, -0.14011607f, 0.10973623f, 0.02862501f, 
    0.00505516f, 0.07436895f, -0.06446400f, 0.17764603f, 0.03553398f, 0.00817094f, 0.05820315f, 0.03179299f, 
    -0.02029094f, -0.09852048f, 0.15784703f, 0.00674812f, -0.02886135f, -0.12290528f, 0.22531337f, 0.05553993f, 
    -0.04716670f, -0.10134872f, -0.00154724f, -0.06267150f, -0.02691884f, 0.02337206f, 0.02225500f, 0.01659854f, 
    0.10257131f, -0.03254463f, -0.13748495f, -0.19074936f, -0.05024493f, -0.00468612f, -0.02299242f, -0.07563828f, 
    -0.01116692f, -0.00084001f, -0.11955429f, 0.06206782f, -0.22456355f, 0.00700283f, 0.04194658f, 0.18290083f, 
    -0.06355986f, -0.07481637f, -0.09028038f, -0.05494307f, 0.05142603f, 0.04752101f, -0.09564078f, 0.11796267f, 
    -0.00441000f, -0.26979080f, -0.12013257f, 0.11774562f, -0.06855021f, 0.08876374f, 0.03014602f, -0.07774503f, 
    -0.00208521f, -0.13497449f, 0.13172832f, -0.00718314f, 0.04611512f, 0.09607399f, -0.09545785f, 0.05660677f, 
    0.11489999f, 0.04276494f, -0.01492181f, -0.01752691f, -0.08710700f, -0.05769591f, -0.03331163f, 0.06513119f, 
    -0.08268575f, 0.07453168f, 0.13127100f, 0.18422548f, 0.14574288f, 0.03766250f, 0.03308666f, 0.12240420f, 
    -0.12393177f, -0.18623655f, 0.00965552f, -0.13401842f, 0.17091241f, -0.07383469f, 0.01202657f, 0.04658123f, 
    0.00052992f, 0.02184101f, -0.06502437f, -0.00812986f, 0.00021524f, 0.00583794f, 0.03776767f, 0.03729289f, 
    0.06298099f, 0.00859366f, 0.07902103f, -0.26108709f, -0.07478692f, 0.12171266f, -0.08733258f, -0.09826379f, 
    0.18283902f, 0.04310451f, -0.00059260f, 0.05391231f, 0.56207526f, -0.11037264f, -0.02483453f, -0.09283295f, 
    -0.06365573f, -0.01213379f, -0.04117209f, -0.12039303f, -0.04238964f, 0.06480974f, -0.04218535f, -0.07854028f, 
    -0.05847122f, -0.20209719f, -0.04988034f, 0.24453740f, -0.01745468f, -0.02163571f, 0.00282173f, -0.10502872f, 
    0.10573721f, 0.02520429f, -0.05933783f, 0.09820054f, 0.16077608f, 0.06889320f, 0.17830202f, 0.31359538f, 
    0.04755271f, 0.11497622f, 0.04804860f, 0.12147055f, 0.03612415f, -0.01871540f, 0.10245468f, 0.03063862f, 
    0.22367641f, -0.19894829f, 0.04274492f, 0.11740232f, -0.08346680f, 0.01775933f, 0.01887484f, -0.04389001f, 
    -0.02571365f, -0.04770697f, 0.00717751f, 0.08786689f, -0.30028576f, 0.42895958f, 0.12016398f, 0.07210401f, 
    -0.03421044f, -0.03043464f, -0.08084254f, -0.06496315f, 0.02750029f, -0.11530855f, -0.07290261f, -0.03926224f, 
    -0.51172483f, 0.05864878f, 0.03403276f, -0.26979408f, 0.06656516f, 0.02091130f, 0.05463232f, -0.00513806f, 
    0.07009352f, -0.10401774f, -0.01989732f, -0.09856430f, -0.21213278f, 0.02636555f, 0.17107768f, 0.12243501f, 
    0.12026636f, -0.01712750f, -0.03935982f, -0.04420560f, 0.00768228f, 0.01233439f, -0.07843044f, -0.12961727f, 
    0.15363017f, -0.07468954f, -0.04364209f, 0.19295040f, 0.00903177f, 0.01032006f, -0.03611620f, -0.01206228f, 
    0.10710708f, -0.06646272f, -0.01398547f, -0.06498543f, 0.11393931f, 0.20097603f, -0.01398088f, -0.00693560f, 
    -0.11368591f, -0.06158224f, 0.00390736f, -0.07301548f, 0.00122798f, 0.05195656f, -0.02296120f, 0.11983775f, 
    0.04281122f, 0.19298841f, 0.05878849f, -0.04106648f, 0.00723309f, 0.13374153f, 0.01655384f, 0.01105892f, 
    0.06848870f, 0.08308908f, 0.07468804f, 0.07366987f, 0.01347061f, -0.10092692f, -0.03968286f, -0.13865912f, 
    -0.05603656f, -0.01614164f, 0.01491837f, -0.08088472f, 0.08782385f, 0.03840875f, 0.01428518f, 0.05626715f, 
    0.06202165f, -0.13843845f, -0.15969618f, -0.28422105f, -0.03593076f, 0.00613378f, -0.05987774f, -0.07938530f, 
    0.11834638f, 0.05065138f, 0.02442179f, -0.14802662f, -0.00943567f, -0.03695202f, -0.17807816f, -0.03121311f, 
    -0.07826820f, -0.05560944f, -0.07512817f, -0.07253353f, 0.09183262f, -0.00065196f, 0.03106271f, 0.08403504f, 
    0.11678544f, 0.19007322f, -0.16563916f, -0.23432696f, -0.09670538f, -0.00626307f, 0.01105839f, -0.11142147f, 
    -0.05688638f, -0.00744538f, 0.08320393f, -0.04060923f, -0.15663128f, -0.30417094f, -0.00754572f, 0.20060951f, 
    -0.04523117f, -0.13594802f, -0.12170403f, -0.05796577f, 0.06528706f, 0.10868160f, 0.17000590f, 0.02058156f, 
    0.07886387f, 0.15216875f, 0.06930970f, -0.09507173f, 0.05246737f, -0.07270641f, 0.03030771f, 0.10712049f, 
    0.05286426f, -0.00491783f, 0.05425712f, 0.05899430f, 0.05058478f, -0.05046546f, 0.13106385f, 0.09354557f, 
    -0.01400044f, 0.01307843f, 0.04946687f, 0.12011710f, 0.17043664f, 0.08014205f, 0.07265780f, 0.02385210f, 
    0.22303556f, -0.33090115f, 0.02353467f, -0.16193859f, 0.08676685f, -0.00019137f, -0.11227711f, 0.07282646f, 
    -0.10545366f, 0.14315917f, 0.02208198f, 0.05447337f, 0.05482341f, 0.07842338f, 0.06319002f, -0.05378668f, 
    0.03612671f, 0.11735742f, -0.02822494f, 0.02150047f, -0.03907556f, -0.00212026f, -0.06372169f, 0.16668232f, 
    -0.15069577f, 0.25508842f, 0.11540128f, -0.00146178f, 0.15901610f, -0.05320190f, 0.00604276f, 0.02621059f, 
    0.02258661f, 0.01895948f, -0.07743154f, 0.09281427f, -0.13659151f, -0.02343656f, 0.03675562f, 0.24635091f, 
    -0.05277634f, -0.08313558f, -0.03500345f, 0.05483597f, -0.12380739f, 0.10708892f, -0.10274717f, 0.15288715f, 
    -0.15354238f, 0.12265534f, -0.08396733f, 0.32914671f, 0.02274026f, -0.07413154f, 0.14180189f, 0.02834893f, 
    0.04114082f, 0.04779422f, -0.00611098f, 0.05713893f, 0.03193514f, 0.14348575f, -0.11418875f, 0.04376637f, 
    0.08278605f, 0.07010709f, 0.12125521f, -0.01938217f, 0.01275358f, 0.02529709f, -0.15060769f, 0.05137187f, 
    0.44243434f, 0.19378386f, 0.08910615f, -0.25008544f, 0.04896260f, -0.07667994f, -0.06731620f, 0.07363301f, 
    0.10324509f, -0.03924937f, -0.03555660f, 0.09124211f, 0.02768189f, 0.02587096f, -0.17557524f, -0.12397447f, 
    -0.07901210f, 0.07693157f, -0.05675453f, -0.13008888f, 0.01145997f, 0.15336978f, -0.06889956f, -0.09346157f, 
    0.31939447f, -0.00911067f, 0.01008927f, -0.23297875f, 0.11908350f, -0.02647200f, -0.02472041f, -0.03168005f, 
    0.13421533f, -0.10821798f, -0.01149767f, 0.05213580f, 0.11137288f, -0.05328100f, 0.00783583f, 0.06616875f, 
    0.02915559f, 0.01863250f, -0.01508393f, -0.00430100f, 0.00937900f, -0.04520647f, 0.03839082f, 0.00903056f, 
    -0.30592906f, 0.10640872f, 0.42293006f, -0.23151284f, -0.07282943f, -0.06745284f, -0.02256467f, 0.17264169f, 
    0.03501604f, -0.00882817f, 0.03726335f, 0.00953249f, 0.04676979f, 0.15755491f, -0.08910687f, -0.09249360f, 
    -0.01074601f, 0.16066116f, 0.07470632f, 0.19719063f, -0.01480084f, 0.11785913f, -0.01732461f, 0.05803823f, 
    0.07679189f, -0.03566191f, 0.10008760f, 0.20755313f, -0.02014791f, -0.05862823f, -0.08734463f, -0.07867678f, 
    0.08562843f, 0.02659202f, 0.17995779f, -0.07845682f, -0.00681977f, -0.02870541f, 0.03319994f, -0.01944999f, 
    0.03390941f, 0.00328462f, -0.00038711f, 0.01817120f, 0.08501104f, 0.02952397f, -0.00530523f, -0.07892472f, 
    0.04424409f, -0.15944016f, 0.09946119f, 0.00740214f, 0.06167104f, -0.02197416f, -0.00108590f, -0.07230554f, 
    0.01007830f, -0.08711097f, -0.17028680f, 0.06029253f, 0.26247415f, 0.02307206f, -0.04365904f, -0.04603430f, 
    0.16904435f, -0.02094840f, 0.06156708f, -0.01639115f, -0.07154004f, -0.04203800f, 0.10010159f, 0.05947702f, 
    -0.23606102f, -0.10823067f, 0.02303025f, -0.06035753f, -0.04515570f, 0.03092755f, -0.03513068f, 0.06115795f, 
    -0.04636435f, -0.07778174f, 0.02822544f, -0.08447046f, 0.10113330f, -0.15692723f, 0.04351149f, -0.09953465f, 
    0.16351828f, -0.01360492f, -0.19272147f, 0.04206748f, -0.03347464f, 0.03128315f, 0.11498883f, 0.07095350f, 
    0.08904529f, -0.01803901f, -0.02626489f, -0.18737048f, 0.10733186f, 0.00714915f, 0.01751660f, 0.01577856f, 
    0.04593789f, 0.01876755f, -0.01267307f, 0.07260182f, -0.29205573f, 0.17788936f, -0.12306061f, 0.00217466f, 
    -0.02305262f, 0.03836678f, -0.06372026f, -0.14373794f, 0.01779922f, -0.04863799f, 0.14212315f, -0.04314554f, 
    0.14234453f, 0.07844637f, -0.10302899f, -0.00269008f, -0.09894309f, 0.10469091f, 0.11137706f, -0.02914669f, 
    -0.06317363f, 0.08093577f, -0.08624335f, 0.06550895f, -0.25401959f, 0.01137271f, -0.25031707f, -0.10343016f, 
    0.13115785f, -0.10832623f, -0.14756793f, -0.05574222f, -0.05212976f, 0.03323895f, 0.07256132f, 0.01415151f, 
    -0.20404065f, -0.03323276f, 0.29083291f, -0.03326397f, -0.00604363f, 0.09908108f, -0.07916639f, 0.04138098f, 
    -0.01047109f, 0.05730643f, -0.03203410f, 0.10790659f, -0.24984989f, -0.04995949f, 0.16460815f, -0.01022966f, 
    0.02235059f, 0.03212269f, -0.07313555f, 0.09821784f, 0.04345689f, 0.02936988f, -0.04363608f, 0.07307758f, 
    0.01927591f, 0.04494680f, -0.01920951f, -0.05904708f, 0.03498640f, 0.06473886f, 0.07630426f, 0.01474672f, 
    -0.00663278f, 0.02432433f, 0.05939896f, 0.05017687f, 0.04723702f, 0.02034218f, 0.03258239f, 0.16853248f, 
    -0.01025070f, 0.08534604f, 0.02748111f, 0.06064073f, -0.08068406f, -0.12865101f, -0.03049606f, -0.08843805f, 
    0.01637986f, -0.25752300f, -0.12068691f, 0.09966848f, -0.05618590f, -0.00614315f, 0.07603801f, -0.05988638f, 
    -0.01249496f, 0.03059146f, -0.08461352f, 0.05695250f, -0.06182924f, -0.03858861f, 0.15909915f, 0.20962617f, 
    -0.01713744f, -0.00192876f, 0.05451887f, -0.06290220f, 0.06612548f, 0.08664962f, 0.02487237f, -0.07769421f, 
    -0.09484711f, -0.10899659f, -0.04316387f, -0.12342440f, 0.09478100f, -0.06956921f, -0.00484573f, -0.02006657f, 
    0.02740836f, -0.01052258f, 0.07447794f, -0.03824919f, -0.00026383f, -0.00938246f, -0.25335538f, -0.12106536f, 
    0.02770348f, 0.04505068f, 0.05362985f, 0.08945259f, -0.03600427f, -0.09988039f, 0.03768093f, -0.01005184f, 
    0.07096482f, 0.16826959f, -0.06898753f, 0.08187471f, 0.01523017f, 0.05889918f, 0.10633414f, -0.00522870f, 
    -0.02305973f, -0.08355279f, 0.06390622f, -0.04421835f, 0.04801611f, 0.00750786f, -0.03162473f, 0.09781098f, 
    0.01984195f, 0.07922733f, -0.08271472f, 0.04035792f, 0.00539951f, 0.05374689f, 0.07907245f, -0.00133532f, 
    -0.14939100f, -0.18027854f, -0.03415548f, -0.06470241f, 0.00360480f, 0.06199599f, -0.12108207f, 0.02978823f, 
    0.07537453f, -0.02548405f, -0.08156828f, 0.03969846f, 0.30373067f, -0.04345000f, -0.14413863f, 0.31992510f, 
    0.12187341f, -0.05579177f, -0.00076801f, -0.00906769f, -0.01820793f, -0.08616329f, -0.00138478f, -0.04262783f, 
    -0.28457770f, -0.00142318f, 0.00087146f, -0.13347349f, 0.09012037f, -0.02168907f, -0.05683293f, -0.21142516f, 
    -0.01425469f, -0.06269208f, 0.03630770f, 0.00126693f, -0.11022920f, -0.00265465f, 0.07700897f, 0.11319711f, 
    -0.04606271f, 0.02210751f, 0.09516067f, -0.02328715f, -0.05779539f, 0.08926032f, -0.03176896f, 0.01894355f, 
    -0.16781707f, -0.04158464f, -0.04234478f, -0.19101344f, -0.02970851f, 0.01211140f, -0.14226012f, -0.02739869f, 
    0.05814274f, -0.01978614f, -0.00430554f, -0.06781016f, -0.10964301f, -0.02556937f, 0.09891523f, -0.05302183f, 
    -0.03106538f, 0.00427519f, 0.04198377f, -0.01085349f, 0.02447693f, 0.04147854f, -0.01060493f, 0.03914615f, 
    0.04803588f, 0.14471792f, -0.00289079f, 0.12050965f, 0.04303312f, -0.06500019f, -0.06484625f, 0.02263380f, 
    0.12428307f, 0.05428727f, 0.11166049f, -0.07261546f, 0.09598691f, 0.21714306f, 0.11466743f, 0.07542836f, 
    0.05958071f, 0.03062240f, -0.02787743f, -0.01987945f, -0.00785964f, 0.04487047f, -0.07860633f, 0.03164979f, 
    -0.09231521f, 0.10542586f, 0.10384698f, 0.02650361f, 0.10065980f, 0.03840689f, 0.05844023f, 0.13105018f, 
    0.03810261f, -0.01876520f, 0.01404024f, 0.16559453f, 0.00425833f, 0.38101682f, -0.07718417f, 0.09934145f, 
    -0.06370974f, 0.14255276f, -0.02349434f, 0.01250782f, -0.02136995f, 0.11365347f, 0.08217829f, 0.04767275f, 
    -0.29565620f, 0.02304111f, -0.02561688f, -0.05228094f, -0.05288937f, -0.00586551f, -0.12936886f, 0.06304484f, 
    0.01084049f, 0.08993898f, -0.13680112f, -0.11119385f, 0.01110245f, 0.13847487f, 0.17922379f, -0.24622509f, 
    -0.04031514f, -0.02562194f, 0.14641608f, 0.07549167f, 0.02031840f, -0.07939287f, 0.03460220f, 0.00577976f, 
    -0.02088603f, 0.12119868f, 0.12031073f, -0.15080884f, 0.12282696f, -0.08415893f, 0.01037636f, 0.06264627f, 
    0.10672004f, 0.09380218f, -0.01133638f, 0.15869553f, -0.05379587f, -0.02388899f, -0.29603493f, 0.20933062f, 
    0.08826804f, -0.04565708f, 0.13190342f, -0.19215962f, -0.00781961f, -0.06911566f, -0.03067990f, 0.16439191f, 
    0.34279418f, 0.02477124f, 0.03705261f, 0.02838576f, -0.03319838f, 0.01230656f, 0.04636402f, 0.01434804f, 
    -0.00673585f, 0.18400559f, 0.02649243f, 0.19216312f, -0.02990073f, 0.13128482f, -0.08587582f, 0.03005806f, 
    -0.05388119f, 0.09315263f, -0.04341387f, -0.10569537f, 0.07757124f, -0.08133206f, 0.15559119f, -0.05636036f, 
    -0.12660487f, -0.06071347f, -0.09345488f, -0.14994185f, -0.06879911f, 0.04133827f, -0.07269198f, -0.01966661f, 
    -0.12419463f, 0.02961966f, -0.00117591f, -0.15588336f, 0.07427148f, -0.07801452f, -0.00055935f, -0.09636717f, 
    0.00167860f, -0.07154901f, 0.11410028f, -0.03843677f, -0.09190900f, 0.05493474f, -0.09426210f, 0.07104073f, 
    0.30311975f, 0.06863364f, 0.01005778f, 0.11378737f, -0.02025346f, 0.07132857f, 0.01383937f, 0.14761859f, 
    -0.03048057f, 0.08016997f, -0.02566390f, -0.03148584f, 0.20654522f, 0.09126305f, -0.08379836f, 0.09215671f, 
    -0.06099598f, -0.06694252f, 0.05635540f, 0.00279435f, -0.11739886f, -0.00617601f, 0.03424820f, 0.02145599f, 
    0.45301747f, -0.00235362f, 0.13821852f, 0.10561056f, 0.03752444f, -0.07281281f, 0.05656392f, 0.03915286f, 
    -0.11241207f, 0.09499523f, -0.15409295f, 0.10933369f, -0.23565826f, -0.00812934f, -0.04494773f, 0.01578088f, 
    0.06703255f, -0.06407019f, 0.02474538f, 0.07835656f, -0.04755255f, -0.11910407f, 0.02589327f, 0.03674902f, 
    -0.33992776f, -0.15021934f, -0.18623856f, -0.00653921f, -0.08210130f, -0.05445723f, -0.04115925f, -0.05412316f, 
    -0.15563728f, 0.00185295f, -0.12243424f, 0.04998859f, 0.19217779f, -0.23925145f, 0.09443030f, -0.09103403f, 
    0.06061229f, -0.02056051f, 0.02956991f, -0.05461208f, 0.00625427f, -0.13342030f, 0.07683554f, 0.06161461f, 
    0.02884997f, 0.00007371f, 0.06378076f, 0.06475216f, 0.03488166f, 0.01937548f, -0.04716954f, 0.02845383f, 
    -0.02187274f, -0.03014934f, -0.06646170f, 0.12929922f, 0.05928457f, -0.04205009f, 0.18021411f, -0.06520003f, 
    -0.01216401f, -0.01591677f, -0.03029629f, -0.00271302f, -0.10150736f, -0.05422743f, -0.01976701f, 0.07032971f, 
    -0.17102146f, -0.24611138f, -0.00801871f, 0.14279436f, -0.00251991f, -0.06330661f, 0.03121062f, -0.05410173f, 
    -0.08623016f, -0.08738837f, -0.00201786f, -0.01694835f, -0.37068737f, 0.41508874f, 0.26724711f, 0.06945186f, 
    0.06680840f, -0.01395689f, -0.00018765f, 0.02451527f, 0.06343694f, 0.08644752f, 0.09411316f, 0.07122928f, 
    -0.00780483f, 0.22223116f, 0.19160266f, -0.00082295f, -0.00292199f, 0.01178890f, 0.06338141f, 0.05873536f, 
    -0.01405570f, -0.13740453f, 0.02663972f, -0.11205549f, 0.06322807f, -0.02142879f, -0.00351715f, -0.17761081f, 
    -0.07400919f, 0.10522855f, -0.00131597f, 0.05890004f, -0.01607074f, 0.06226186f, -0.22616830f, 0.02285430f, 
    -0.01220142f, -0.00114354f, -0.00121315f, -0.04431274f, -0.02499254f, -0.01093590f, -0.01321800f, 0.03577823f, 
    -0.02287443f, -0.02335351f, 0.01044297f, -0.03554759f, 0.00261375f, -0.03086180f, -0.01995011f, -0.04121507f, 
    -0.00409679f, -0.00793803f, 0.00738868f, -0.00805071f, -0.02261497f, 0.02599352f, -0.01867498f, 0.00654273f, 
    0.00414395f, -0.00566111f, -0.02221882f, 0.01861420f, -0.03410201f, 0.02314038f, 0.00361580f, 0.00380586f, 
    0.02380154f, -0.02450697f, 0.03199763f, -0.01901116f, -0.02399750f, 0.00091241f, -0.02317271f, 0.03133054f, 
    0.01966891f, 0.01033915f, 0.01476536f, -0.03145765f, -0.00916154f, -0.00727899f, 0.02445802f, -0.02049479f, 
    0.01797972f, 0.02024431f, 0.01814538f, -0.02956922f, -0.00036890f, 0.00633615f, -0.03710568f, -0.02748044f, 
    0.01075798f, -0.03033582f, 0.02677764f, 0.03170700f, -0.00522314f, 0.03266585f, 0.01587488f, -0.01385512f, 
    -0.02584175f, -0.02161520f, -0.02416846f, 0.00771078f, -0.01298420f, -0.02463589f, 0.01246987f, -0.02400805f, 
    0.00325236f, 0.00669680f, -0.00004730f, 0.01949045f, 0.02372708f, 0.01248891f, 0.00242732f, -0.03127528f, 
    -0.01847441f, -0.01396679f, -0.01185047f, -0.01198333f, 0.02381028f, 0.01313271f, 0.02972607f, -0.00101655f, 
    -0.02062731f, -0.01096332f, 0.00728291f, -0.04595666f, 0.03962349f, -0.00376333f, 0.00865113f, 0.00502993f, 
    0.03168292f, -0.01971582f, 0.00343864f, -0.03301384f, -0.03662637f, -0.02825933f, -0.03115712f, 0.02528580f, 
    0.01959315f, 0.01616936f, 0.01849328f, 0.02215960f, -0.01390520f, -0.02916027f, 0.02552217f, -0.00310440f, 
    -0.00619229f, -0.01652692f, 0.00313688f, -0.04009093f, -0.01446823f, -0.02013915f, 0.02352424f, 0.00896633f, 
    -0.00875758f, -0.01974604f, 0.03075983f, 0.01912660f, 0.02241388f, 0.01007164f, 0.02531238f, 0.00551391f, 
    -0.01676871f, 0.00191384f, 0.00420357f, -0.00302384f, 0.04359908f, -0.02197023f, -0.00803400f, -0.03853654f, 
    -0.03122149f, 0.02270665f, -0.01805644f, -0.02725898f, 0.03906982f, -0.00139246f, -0.03212257f, 0.03502205f, 
    0.00527577f, -0.02006165f, 0.01077850f, -0.03097247f, -0.02988476f, 0.02979009f, -0.00434500f, 0.00618826f, 
    0.03203297f, 0.01164368f, -0.01826747f, -0.04130749f, 0.00308508f, 0.02920680f, 0.00411985f, 0.02749676f, 
    -0.00090467f, 0.00401244f, 0.02035624f, 0.02791886f, 0.00727154f, -0.03196415f, -0.00767420f, -0.00094164f, 
    -0.02069295f, -0.02619795f, 0.01809756f, 0.03301664f, 0.02705043f, 0.00463178f, -0.00022918f, 0.00317853f, 
    -0.02006934f, -0.00045796f, 0.00092182f, -0.02977043f, -0.00899906f, -0.03021619f, 0.00038361f, 0.02388563f, 
    -0.02454868f, -0.00425401f, -0.02499548f, -0.00806793f, -0.02051549f, 0.02897086f, -0.01092912f, -0.02256618f, 
    0.03666920f, 0.02506062f, -0.02125290f, 0.02114976f, -0.03335305f, -0.02222002f, -0.03919518f, -0.02643603f, 
    0.00392503f, 0.00391384f, -0.02539602f, -0.00143553f, -0.02768513f, 0.01962976f, -0.03487144f, -0.03120582f, 
    -0.01425721f, -0.00808891f, -0.03534253f, -0.01442174f, 0.00126856f, 0.01591587f, 0.00757037f, -0.02573150f, 
    -0.00374527f, -0.02262620f, -0.02622556f, 0.02217094f, 0.01993232f, -0.02028109f, -0.00058390f, 0.02774771f, 
    0.00695918f, -0.03234481f, 0.00510172f, -0.02823557f, -0.03994865f, -0.02303388f, -0.01952124f, -0.03855307f, 
    0.01045989f, 0.00198417f, -0.00305256f, 0.02774964f, 0.01103988f, 0.02654965f, -0.00309230f, -0.03208104f, 
    -0.02935207f, 0.00541714f, -0.00810820f, -0.00626516f, -0.03278780f, -0.03343325f, 0.00639218f, -0.00037838f, 
    0.02507764f, -0.01380139f, -0.02694806f, -0.01585932f, -0.02156388f, -0.00517832f, 0.00298464f, -0.01383981f, 
    -0.01627193f, -0.02994156f, 0.02881573f, -0.02877010f, 0.00967215f, 0.02966765f, -0.02091674f, -0.01375995f, 
    -0.02324963f, -0.01135751f, 0.02049146f, 0.00511685f, -0.01780132f, -0.03255761f, 0.03316820f, -0.00249325f, 
    0.02908356f, -0.02134819f, 0.00725066f, -0.02248775f, -0.03877080f, -0.02100810f, -0.00113290f, -0.03966940f, 
    0.00365954f, -0.03156660f, 0.03063902f, 0.00051106f, -0.02073435f, -0.02860280f, 0.02217036f, -0.03699375f, 
    -0.00466341f, -0.02099999f, 0.02783903f, -0.00918917f, 0.01343645f, 0.00228695f, 0.02476572f, 0.00956684f, 
    0.01134552f, -0.02896770f, 0.03565211f, 0.01633277f, -0.03383286f, 0.00068636f, 0.03653800f, -0.01523979f, 
    -0.00791067f, 0.00458081f, -0.01551211f, -0.02468437f, 0.03410609f, -0.00291778f, -0.00028965f, 0.02254684f, 
    -0.02268037f, -0.00968785f, 0.03162567f, 0.02567631f, 0.00780889f, -0.01191295f, 0.02353388f, -0.01528366f, 
    -0.01198728f, -0.02515370f, -0.02708641f, -0.01359970f, 0.01882198f, 0.02669989f, -0.00248844f, 0.01121785f, 
    0.02387026f, 0.01416283f, -0.01911996f, 0.01162697f, -0.00177226f, 0.01466891f, 0.01812373f, -0.01766781f, 
    0.01365264f, 0.01736101f, 0.02278651f, -0.02836310f, 0.01769181f, 0.00508572f, -0.00009336f, -0.01262808f, 
    0.00075412f, -0.03743425f, -0.04378968f, -0.00798008f, -0.01049018f, 0.02563763f, 0.00048551f, -0.03493052f, 
    -0.03633801f, -0.02125457f, 0.00702789f, -0.00541277f, -0.02398993f, -0.02584922f, -0.00544822f, -0.01567712f, 
    -0.03207767f, 0.02038042f, 0.01960586f, -0.03204866f, 0.02939638f, 0.02916708f, -0.02723897f, -0.02605020f, 
    0.02390379f, 0.01845537f, -0.00789901f, -0.03736715f, -0.00592154f, -0.03257808f, -0.01342126f, 0.00303979f, 
    -0.00308225f, -0.00239537f, -0.03010172f, 0.02478014f, 0.00931798f, 0.00083629f, 0.01746751f, 0.01706276f, 
    -0.02751747f, 0.02876131f, 0.02605603f, -0.03180796f, 0.03588943f, 0.00730119f, -0.02811629f, -0.01934738f, 
    0.01739801f, -0.00739957f, 0.01253469f, -0.01932272f, -0.00721994f, -0.04205120f, -0.01872781f, 0.00110093f, 
    -0.00467550f, 0.02024269f, 0.01188922f, 0.01228509f, -0.03156009f, -0.01105572f, 0.01989028f, -0.03840366f, 
    0.00399250f, -0.00967801f, -0.01965661f, 0.00666698f, 0.02422109f, 0.03734011f, 0.01006003f, 0.01832760f, 
    -0.01648470f, 0.00335681f, 0.00281519f, 0.00806252f, -0.03485499f, -0.01878783f, -0.00327445f, -0.00198771f, 
    -0.02872296f, 0.01761247f, -0.01322565f, -0.02533664f, -0.03742122f, -0.04350512f, 0.01841929f, -0.03438428f, 
    0.01200726f, -0.00959381f, -0.03327651f, 0.01654127f, 0.01419004f, 0.00858165f, 0.00441854f, 0.00411096f, 
    0.01652753f, -0.01574314f, -0.02474298f, 0.01031908f, -0.03461264f, 0.01562849f, -0.01050674f, -0.02350299f, 
    -0.00877241f, 0.00116681f, -0.02013525f, -0.00842608f, -0.02242589f, 0.02178832f, 0.00915738f, -0.00507787f, 
    0.02210872f, -0.02081100f, 0.02538542f, 0.01198362f, -0.01062816f, -0.00443175f, -0.04387942f, -0.03888017f, 
    -0.03313040f, -0.01691746f, -0.00167998f, -0.00602452f, -0.01450158f, -0.01964048f, 0.00357121f, -0.02770550f, 
    -0.00230749f, -0.00473705f, -0.01230394f, 0.01090678f, 0.02372776f, 0.01726115f, -0.00422613f, 0.01372705f, 
    -0.00773994f, -0.02329633f, 0.01497433f, 0.01787292f, -0.00349532f, 0.01814915f, -0.02126203f, -0.03360013f, 
    -0.01023595f, 0.00611374f, -0.00918512f, -0.00220088f, 0.01900874f, 0.02636503f, -0.01449087f, -0.00432072f, 
    -0.04156452f, -0.04006545f, -0.02516231f, 0.01020278f, -0.00804228f, 0.01671591f, 0.02008640f, -0.04199230f, 
    0.02208606f, -0.03276091f, -0.01317644f, 0.01831032f, -0.00878100f, 0.00223070f, -0.04392072f, -0.01461506f, 
    0.00340980f, -0.00390273f, 0.01717463f, -0.01694139f, 0.04193807f, -0.02959120f, -0.02106400f, -0.02534936f, 
    0.02684270f, -0.01413900f, -0.02875807f, 0.00973523f, 0.02651821f, 0.03802966f, -0.02246397f, -0.01667640f, 
    0.02410341f, 0.00040523f, 0.01253343f, -0.02851842f, 0.00126384f, -0.02053296f, -0.01405973f, -0.00062306f, 
    0.00172008f, -0.03409791f, -0.02033625f, -0.03289979f, 0.01737913f, -0.01015492f, 0.00790623f, -0.01574694f, 
    -0.02603961f, -0.01856862f, 0.00872285f, -0.01045463f, -0.00948365f, 0.02807129f, 0.02105784f, -0.01563653f, 
    0.02776979f, 0.01446611f, -0.02496429f, -0.01223652f, 0.02695099f, 0.02887847f, -0.00895706f, -0.00566746f, 
    0.03283035f, 0.01404360f, 0.02523349f, 0.00026783f, 0.02251269f, -0.02702859f, -0.02327020f, 0.01398077f, 
    -0.01015435f, -0.01884024f, 0.02338364f, -0.00325623f, 0.03790849f, 0.00037716f, -0.03551320f, 0.00006042f, 
    0.01334280f, 0.02738701f, -0.00481508f, 0.01056789f, -0.03167928f, 0.00107956f, 0.00503599f, 0.00480733f, 
    -0.01497627f, -0.02920071f, -0.00703566f, -0.02682533f, -0.00410069f, -0.03903829f, -0.02431604f, 0.03389215f, 
    -0.01043946f, 0.00515304f, -0.00339816f, -0.03471998f, -0.02807803f, 0.00677364f, 0.02689227f, -0.01789426f, 
    -0.03281140f, 0.01344153f, -0.02737050f, 0.01700478f, 0.00162629f, -0.00422992f, 0.02177248f, -0.00109059f, 
    -0.00218943f, -0.00413572f, 0.01854619f, 0.00412749f, 0.04448995f, -0.01174206f, 0.02274544f, -0.00702496f, 
    -0.00691318f, -0.00923678f, 0.00649317f, -0.00357209f, 0.01151952f, -0.01297099f, -0.02445702f, 0.01441823f, 
    0.01237012f, 0.03342360f, -0.03623161f, 0.01757073f, -0.00553598f, -0.00397783f, 0.01660254f, -0.01307488f, 
    -0.01478346f, -0.00035926f, -0.03200766f, -0.00220703f, -0.03286446f, -0.01649518f, 0.01718984f, 0.01406081f, 
    -0.03597095f, 0.01693211f, -0.02349964f, 0.01533447f, 0.00480884f, 0.00304394f, -0.01242030f, 0.01365120f, 
    -0.01046636f, 0.02586300f, -0.03217548f, -0.01937615f, -0.01953778f, -0.01553753f, -0.04310896f, 0.01208793f, 
    -0.01198429f, -0.01491013f, -0.00748317f, -0.02432838f, -0.00241662f, 0.02017384f, 0.02599606f, -0.03713412f, 
    0.01738416f, -0.02502791f, 0.00751847f, 0.01990961f, 0.02095776f, -0.00597366f, -0.00917689f, -0.03511439f, 
    0.00053656f, -0.02582805f, -0.02541295f, 0.03497270f, 0.02944641f, 0.00337307f, -0.03294616f, -0.01851776f, 
    -0.00502242f, 0.00587847f, 0.03183217f, 0.01764061f, 0.01644398f, 0.03225300f, -0.00517320f, 0.02103597f, 
    -0.03052609f, 0.00066231f, -0.03554782f, -0.00989954f, 0.00128564f, -0.00592820f, -0.00494138f, -0.03473832f, 
    0.01004837f, 0.01469310f, 0.02325290f, -0.01531815f, -0.00623500f, 0.02134910f, -0.01146908f, 0.01048073f, 
    -0.02435284f, 0.02104086f, -0.01756598f, -0.00453463f, -0.00169903f, 0.00900134f, -0.03824382f, 0.01208458f, 
    -0.01820405f, 0.01448879f, 0.03326755f, 0.00965424f, -0.03987247f, 0.02587331f, 0.01694151f, 0.00065764f, 
    -0.03292151f, -0.00958063f, 0.01546144f, 0.01436559f, -0.01336414f, 0.01870552f, -0.01982572f, 0.01857338f, 
    -0.04029401f, -0.01888880f, 0.02188059f, 0.01943164f, 0.02846386f, 0.00770838f, 0.01009884f, -0.01278118f, 
    -0.04259199f, 0.01166284f, -0.02266229f, -0.01201586f, -0.01554391f, -0.02668806f, 0.01917400f, 0.00636144f, 
    0.03588209f, -0.02686847f, -0.02836299f, -0.04008796f, 0.00894173f, 0.00168591f, -0.01032381f, -0.01005594f, 
    -0.01280515f, -0.01470918f, 0.02902385f, -0.00042433f, -0.02899133f, -0.03261787f, -0.02130090f, 0.03091695f, 
    0.01840201f, -0.00763770f, 0.00242835f, 0.02933528f, -0.02817620f, 0.01086380f, 0.01649434f, -0.00053353f, 
    0.20021681f, 0.08969967f, 0.11520526f, -0.01139297f, -0.16567324f, -0.10127649f, 0.06918851f, 0.02827451f, 
    0.02147856f, 0.06110688f, -0.03106617f, -0.05078593f, 0.08880079f, -0.02939205f, -0.04516587f, -0.05586005f, 
    -0.05180901f, -0.05896950f, -0.07096360f, -0.03820831f, 0.10371197f, -0.00142256f, 0.06227245f, -0.04651751f, 
    -0.02986448f, 0.03380484f, -0.19539565f, -0.05542078f, 0.06645364f, -0.00627678f, 0.00815283f, -0.06143664f, 
    -0.02111235f, 0.08329874f, -0.00145958f, 0.08974946f, 0.24875493f, 0.02174293f, -0.10389034f, -0.06719915f, 
    0.09946609f, -0.01378271f, 0.02938516f, -0.09080004f, -0.03510528f, -0.02432306f, 0.05619017f, -0.10571444f, 
    -0.04876595f, -0.01795198f, 0.01092897f, 0.01676931f, 0.00893102f, 0.04523697f, 0.11758306f, -0.05936838f, 
    0.03035348f, -0.07179900f, 0.04546528f, -0.05179907f, 0.05385183f, -0.20643143f, 0.13288316f, 0.05819255f, 
    -0.04198490f, -0.01755386f, -0.04063677f, 0.09452164f, -0.03620511f, -0.06329434f, 0.08022638f, 0.04234596f, 
    -0.21244314f, -0.07269017f, 0.02088322f, 0.18861619f, 0.07490786f, -0.01785002f, -0.03582178f, 0.02823737f, 
    0.03469357f, -0.02357972f, 0.03002194f, -0.11693961f, 0.23639444f, 0.09049498f, -0.03470697f, -0.07937343f, 
    -0.12195937f, -0.01750154f, -0.00529702f, 0.11881946f, 0.03939521f, -0.02903615f, -0.03895045f, 0.00666995f, 
    0.37924957f, 0.19754733f, -0.18173178f, -0.00229146f, -0.04152109f, 0.03289489f, -0.14317912f, 0.06728663f, 
    -0.02770429f, -0.10598853f, 0.14308171f, -0.04155154f, 0.11237168f, 0.02483350f, -0.03393022f, 0.15178420f, 
    -0.09250376f, 0.16969676f, -0.04403089f, 0.02859664f, -0.15597299f, 0.03144737f, 0.14530514f, -0.01647880f, 
    0.25708285f, 0.16421941f, 0.06701952f, 0.09423149f, -0.08571567f, -0.10897921f, -0.08611222f, 0.04081036f, 
    -0.05283336f, -0.02356224f, 0.05523648f, -0.08449893f, -0.01749172f, 0.13023345f, 0.02704380f, -0.14566505f, 
    -0.05634749f, 0.04028352f, -0.02455264f, -0.07231246f, 0.06054216f, -0.05127998f, 0.11591552f, -0.04155162f, 
    -0.02621751f, 0.17707628f, -0.17362434f, 0.00238857f, -0.03354070f, -0.06223398f, -0.06750382f, -0.00110159f, 
    0.02911212f, -0.06534524f, 0.01299508f, 0.02449690f, 0.18723190f, 0.15051265f, -0.01430734f, -0.03162229f, 
    -0.17246543f, -0.03433013f, 0.04851933f, 0.01699156f, -0.01456949f, -0.02220155f, -0.14198957f, -0.11979537f, 
    0.35968775f, 0.16497621f, -0.04401273f, -0.02727940f, 0.04088442f, 0.07118758f, -0.02591292f, -0.01273894f, 
    0.08883637f, -0.06898180f, 0.01460469f, 0.11024463f, 0.31562594f, 0.09490782f, 0.00936989f, 0.00787910f, 
    0.00179395f, 0.08535825f, 0.05541429f, -0.02480194f, -0.06147265f, 0.05630077f, 0.07252720f, 0.01537416f, 
    0.15288627f, 0.04307370f, -0.14921030f, -0.12666084f, -0.10275681f, 0.09434835f, -0.06823142f, 0.00451625f, 
    -0.05570179f, 0.05736103f, 0.11609863f, 0.03556635f, -0.29189056f, 0.00557412f, 0.02956326f, 0.15765354f, 
    0.02042096f, -0.05955117f, 0.08820638f, 0.08922993f, 0.05846002f, 0.02022430f, -0.04450081f, 0.03796719f, 
    0.03851334f, 0.01163267f, -0.23955448f, 0.05365508f, 0.03048857f, 0.07171264f, -0.00241282f, 0.04783945f, 
    -0.05353343f, 0.02514007f, 0.02111438f, 0.06145921f, 0.05103565f, 0.03949172f, -0.01171449f, 0.04807794f, 
    -0.11909294f, 0.07270303f, -0.03388303f, -0.05498686f, 0.03004402f, -0.05094655f, -0.06133034f, 0.07787412f, 
    0.19109367f, 0.09257872f, 0.11210854f, 0.07228952f, -0.10708875f, -0.10983755f, 0.02199453f, -0.03934146f, 
    -0.05233847f, -0.03825905f, -0.04121524f, 0.01751164f, -0.05107110f, -0.20342569f, 0.13875549f, -0.11821976f, 
    -0.00510699f, -0.03906003f, -0.04601085f, -0.04913855f, 0.06454257f, 0.01712278f, 0.00402771f, -0.04895566f, 
    -0.18499078f, 0.08349909f, -0.00722484f, 0.00876899f, 0.10873045f, -0.03330203f, -0.02502833f, -0.01398121f, 
    0.02493262f, 0.11045809f, -0.01513907f, 0.02686962f, -0.23912376f, -0.16415630f, 0.08997993f, -0.06623059f, 
    0.13653998f, 0.02503635f, -0.01638325f, 0.01037392f, 0.02326908f, 0.18137962f, -0.03032833f, 0.11211540f, 
    -0.21263464f, 0.21752931f, 0.03018936f, 0.02545917f, 0.14422412f, 0.10040159f, -0.02332033f, 0.01896442f, 
    0.15467316f, -0.06614511f, 0.06248818f, -0.03784635f, -0.24090566f, -0.02248536f, 0.02963801f, 0.10654476f, 
    0.02165697f, 0.06282751f, -0.03411047f, -0.05123796f, 0.12543868f, -0.00550226f, 0.05817616f, 0.10172293f, 
    0.11541168f, 0.02633280f, -0.01723535f, 0.11163056f, -0.19092423f, 0.05182572f, 0.06703425f, -0.03603397f, 
    0.03496138f, 0.01363830f, -0.02976618f, -0.02135775f, 0.11451268f, -0.05485428f, 0.02552418f, -0.02095911f, 
    -0.03198429f, 0.05818135f, -0.06674178f, -0.06275569f, -0.07314520f, 0.12039464f, -0.03480234f, 0.01222042f, 
    0.22952898f, -0.00348039f, 0.02782240f, -0.06105997f, -0.19723718f, 0.00221742f, 0.06321819f, 0.00805234f, 
    -0.02873629f, 0.10721958f, -0.01815469f, -0.00959423f, 0.14766331f, 0.02131917f, 0.04055154f, 0.04989675f, 
    -0.03106523f, 0.02373660f, 0.00436539f, -0.08298512f, -0.01977721f, -0.01868363f, -0.07633767f, 0.09781287f, 
    0.02916758f, -0.12113227f, 0.08709853f, 0.03401680f, -0.16149527f, -0.03281400f, 0.01461874f, 0.03498454f, 
    0.10402679f, 0.02478107f, 0.00855052f, 0.03970436f, 0.06612788f, 0.08253761f, 0.06633383f, -0.05592430f, 
    -0.05671675f, -0.01633712f, -0.05938545f, -0.07700857f, -0.00747361f, 0.07557213f, 0.02693450f, 0.02175047f, 
    0.18700893f, 0.02016746f, 0.11890546f, -0.02193869f, -0.19975081f, -0.13953769f, 0.11408615f, -0.05676420f, 
    0.02928469f, 0.05653206f, -0.07507610f, -0.14789586f, 0.39257911f, -0.06724402f, 0.07789994f, -0.00406214f, 
    -0.05910748f, -0.06401833f, 0.04695296f, 0.02561052f, 0.11424241f, 0.09208746f, -0.11142031f, -0.01021145f, 
    0.04837126f, 0.00932097f, -0.00973024f, 0.05264750f, 0.12577836f, 0.06993779f, -0.01252823f, -0.00226207f, 
    -0.08038383f, 0.02110153f, 0.06297819f, 0.12267942f, -0.03695709f, -0.12681380f, 0.22428158f, -0.00467118f, 
    -0.07447625f, -0.03262450f, -0.03059862f, 0.00157926f, 0.00540107f, 0.04983189f, 0.06606630f, -0.00833826f, 
    0.01819209f, -0.09083683f, -0.01491292f, -0.00946890f, 0.04072527f, 0.00486785f, -0.05246395f, -0.05169060f, 
    0.02188044f, 0.07356763f, -0.05668876f, 0.04488716f, 0.16499045f, 0.06190516f, -0.04932890f, 0.00409215f, 
    -0.00172640f, 0.00434391f, -0.01787494f, 0.01414865f, 0.02445002f, 0.04963562f, -0.04287577f, -0.08026041f, 
    0.05973670f, 0.04829910f, -0.19762416f, 0.06009739f, 0.14765872f, -0.00809110f, 0.02950040f, 0.03068903f, 
    0.08401828f, 0.00589258f, 0.09122249f, 0.02652022f, -0.08870239f, -0.11617277f, -0.12660052f, 0.06999856f, 
    0.02123901f, 0.02383867f, 0.10522246f, 0.00293959f, -0.03209597f, -0.01445525f, 0.08376679f, -0.04826338f, 
    -0.17530201f, 0.12618543f, 0.08325132f, 0.06167993f, 0.04447159f, 0.06106714f, 0.02970405f, -0.10641162f, 
    0.06643955f, 0.06829843f, -0.07009913f, 0.05643202f, 0.43221346f, 0.33723044f, -0.04605843f, 0.02069909f, 
    0.06687900f, 0.07808004f, 0.07484999f, 0.02799983f, 0.01336518f, 0.06857193f, -0.00043542f, -0.03569927f, 
    -0.04598418f, -0.04040942f, -0.05682515f, 0.00860436f, 0.00629328f, -0.06653690f, 0.05589694f, 0.06409176f, 
    0.01631022f, 0.01037933f, 0.01681832f, 0.06123643f, 0.13720520f, -0.17764068f, 0.03404158f, 0.04535616f, 
    0.10481178f, 0.02533792f, 0.14343333f, -0.05635804f, -0.04047899f, 0.05053135f, 0.09113097f, -0.10989390f, 
    -0.15973918f, -0.07238161f, -0.17914504f, 0.07546826f, 0.12900814f, 0.04684798f, -0.00853494f, -0.06782461f, 
    -0.14623018f, 0.08508158f, 0.05299966f, -0.01001437f, 0.14661010f, 0.09141040f, -0.04828743f, 0.07681404f, 
    -0.04763395f, -0.08145215f, 0.11001374f, -0.00155279f, 0.03874187f, 0.11890528f, 0.03298350f, 0.09337934f, 
    0.09570812f, 0.08455464f, -0.06365240f, -0.04280129f, -0.03166159f, 0.03794809f, 0.01067790f, 0.05496179f, 
    0.01791260f, -0.05174027f, 0.01922359f, -0.10264201f, -0.02232250f, -0.16235858f, -0.10454046f, 0.03872984f, 
    0.08234467f, -0.01418387f, -0.06184544f, 0.04070991f, 0.01323415f, 0.02307365f, -0.06684802f, 0.06540995f, 
    -0.07460250f, 0.01903629f, -0.03286524f, 0.08315204f, -0.03355068f, -0.07903109f, 0.02407927f, 0.01044295f, 
    0.09058642f, 0.02387744f, -0.00509479f, 0.01926203f, -0.16118589f, -0.08672094f, -0.07622557f, -0.03897747f, 
    0.04905163f, 0.01723122f, 0.05370321f, 0.07794399f, 0.00732170f, 0.01517547f, 0.00315734f, -0.07747569f, 
    -0.13349412f, -0.16700599f, -0.12455337f, -0.04468409f, 0.15220398f, 0.04523910f, 0.05803037f, 0.00850715f, 
    0.00982832f, 0.01011233f, 0.06431244f, 0.09466381f, -0.03469748f, 0.03606389f, 0.03754229f, 0.07727163f, 
    -0.03773755f, -0.02491886f, -0.01020329f, -0.10984358f, -0.01809555f, -0.11381777f, 0.01527079f, -0.12216595f, 
    -0.13217682f, 0.21453296f, 0.12487293f, -0.09230521f, 0.07136803f, -0.06668787f, 0.07637893f, 0.03876933f, 
    0.01579913f, 0.07733233f, -0.02264890f, -0.02917244f, -0.33511248f, -0.14312989f, 0.02702014f, 0.17759033f, 
    -0.06208688f, 0.05304845f, -0.15127318f, -0.06794750f, -0.01784535f, -0.04092611f, -0.03331657f, -0.03587171f, 
    0.14992861f, 0.14734074f, 0.00603222f, 0.13026975f, -0.10245286f, -0.07451713f, -0.06333286f, 0.01580683f, 
    0.07142040f, -0.01591228f, 0.02394941f, -0.03623229f, -0.09294692f, -0.16780141f, -0.04263738f, -0.00944992f, 
    0.05974854f, -0.03128200f, -0.06428720f, -0.05608005f, 0.09783617f, 0.00159336f, -0.00428945f, 0.07327036f, 
    -0.19859616f, -0.21587567f, -0.10670513f, 0.09105307f, 0.12460969f, -0.02468043f, 0.01815831f, -0.07377124f, 
    -0.04048533f, 0.06236073f, 0.05926096f, -0.07021565f, -0.00578776f, 0.11305765f, 0.07438376f, 0.01498356f, 
    0.06900578f, 0.12844783f, -0.00502816f, -0.00765710f, 0.08790272f, 0.15173709f, -0.08719531f, 0.05918207f, 
    0.04894818f, -0.03688511f, -0.13646096f, -0.10143657f, 0.05289618f, -0.02375568f, -0.11279569f, -0.02675140f, 
    -0.01656116f, 0.14016576f, 0.02805086f, 0.03021353f, -0.28057706f, -0.01523273f, -0.03224480f, -0.03207147f, 
    0.07894853f, -0.09924314f, -0.00121473f, 0.02310196f, -0.02583206f, -0.02931503f, 0.02492276f, 0.06249386f, 
    -0.11361683f, 0.15205453f, -0.04661670f, -0.06495114f, 0.01868181f, -0.01988900f, 0.11426846f, 0.09094770f, 
    -0.06161822f, -0.07017877f, -0.03479493f, -0.00517589f, -0.00331974f, -0.09223917f, -0.03887995f, 0.00676661f, 
    -0.02945683f, -0.01866333f, 0.08649990f, -0.06268067f, 0.06743107f, -0.00367106f, 0.16287947f, 0.04189961f, 
    0.25257331f, -0.05681878f, 0.18733759f, 0.16731471f, 0.05130402f, -0.09273219f, 0.11051768f, 0.10921184f, 
    0.12484416f, 0.09060957f, -0.06811410f, 0.10919803f, 0.09133545f, -0.01933608f, -0.02675594f, -0.00078522f, 
    0.06645717f, 0.02705453f, -0.01259849f, -0.00176554f, -0.01196855f, 0.09103431f, 0.02461544f, -0.03469415f, 
    -0.05142649f, 0.03228424f, 0.03653552f, 0.19335563f, 0.02571511f, 0.08754871f, 0.02722680f, 0.00259543f, 
    0.00311265f, 0.05995079f, 0.07565109f, -0.01417544f, 0.03050549f, 0.14697561f, 0.02474162f, 0.15553492f, 
    -0.04941472f, -0.02130080f, -0.06617991f, 0.03728961f, -0.05732052f, 0.19008988f, 0.15614767f, 0.13262965f, 
    -0.09933968f, -0.30271932f, 0.07370438f, 0.40161866f, 0.12055280f, 0.00100701f, 0.02042364f, 0.06222077f, 
    -0.08124258f, -0.02113201f, 0.13319977f, -0.06351452f, -0.05484639f, 0.07390015f, -0.09188065f, 0.16491228f, 
    -0.06571475f, 0.15961650f, 0.06677514f, 0.08637912f, -0.05534277f, 0.00541061f, 0.12198224f, 0.04834228f, 
    0.21410722f, 0.26639548f, -0.08776934f, 0.08274980f, 0.01388544f, 0.00952635f, 0.04507225f, -0.10116842f, 
    0.07825745f, 0.04613982f, -0.12857893f, 0.08045007f, 0.17334686f, 0.14206737f, 0.22721933f, -0.35540858f, 
    0.06757116f, 0.08892729f, 0.10398960f, 0.00532873f, -0.08554067f, 0.03774672f, 0.02235199f, 0.13944425f, 
    0.26563928f, -0.09881344f, 0.16604970f, -0.08964641f, -0.01414256f, -0.04417326f, -0.02163541f, 0.06932136f, 
    0.16976841f, 0.03062602f, 0.07554634f, 0.03888476f, 0.00267572f, -0.13725217f, 0.13816151f, -0.26739940f, 
    -0.04580884f, -0.03886374f, 0.05007571f, 0.01011212f, 0.08273584f, 0.17641494f, 0.00330335f, 0.04991427f, 
    0.11806990f, -0.01889016f, 0.05316988f, 0.19372442f, 0.02259851f, 0.10744467f, 0.00182980f, 0.04116452f, 
    0.06197157f, 0.11997769f, -0.13816236f, 0.06888664f, 0.26859009f, 0.00153384f, -0.06797043f, -0.15190978f, 
    0.02299497f, -0.01175248f, 0.04546165f, -0.08971085f, 0.06490059f, -0.05451365f, -0.02175484f, 0.09758250f, 
    -0.20770276f, -0.24365476f, 0.00994322f, 0.10202938f, 0.11975054f, 0.09731045f, 0.09130596f, 0.03358917f, 
    -0.03248634f, -0.02809083f, -0.05858358f, -0.01844607f, 0.14261875f, 0.24819028f, -0.01270764f, 0.02863058f, 
    -0.01749225f, 0.00736850f, -0.02645528f, -0.02570528f, -0.09066848f, 0.04141466f, -0.20196386f, -0.06999846f, 
    -0.15280452f, 0.13539316f, -0.08732060f, 0.38553363f, 0.13688292f, 0.02872191f, 0.03921167f, 0.01042541f, 
    0.09859002f, 0.07678988f, -0.03650134f, -0.01179923f, -0.15137868f, 0.00641397f, -0.01755623f, 0.09783576f, 
    -0.01493510f, 0.02037034f, 0.10461821f, -0.00004577f, 0.01896285f, 0.18583937f, 0.17341323f, 0.16902171f, 
    0.25706974f, 0.21021025f, -0.09127972f, -0.29561549f, -0.00063120f, -0.00619457f, -0.00216548f, -0.04000841f, 
    0.02085967f, 0.05511837f, 0.04916405f, -0.10263516f, -0.00971462f, -0.04506743f, 0.09630806f, -0.18925004f, 
    -0.09490642f, 0.04087097f, 0.14747408f, -0.05608111f, 0.07544568f, 0.00203961f, -0.03535335f, -0.02844123f, 
    0.08850858f, -0.00419307f, 0.02849457f, 0.08534718f, -0.00341977f, -0.04226432f, 0.03332330f, -0.15643615f, 
    -0.03866768f, -0.10916265f, 0.03582450f, -0.09064249f, 0.12791359f, -0.01659442f, -0.20729858f, 0.01828830f, 
    -0.01712648f, -0.02353489f, 0.03136390f, 0.02817693f, -0.16748722f, 0.02182325f, -0.02506152f, -0.12476774f, 
    0.42167798f, -0.21180797f, 0.17954171f, -0.13666266f, 0.11468418f, -0.08533201f, 0.01692851f, 0.02801731f, 
    -0.10199219f, -0.03911633f, -0.08656108f, -0.07902808f, 0.00811363f, -0.17743473f, 0.07602567f, -0.06079040f, 
    0.02168955f, -0.08066175f, 0.08077513f, 0.02763961f, -0.06840933f, 0.11822877f, 0.02904128f, 0.05494869f, 
    -0.27930477f, 0.01955749f, 0.04609164f, 0.05014667f, 0.04690979f, 0.04457378f, -0.01805534f, -0.03151223f, 
    -0.01904613f, 0.16508257f, 0.05537352f, -0.09872784f, -0.31341064f, 0.04273795f, -0.09473453f, -0.20497051f, 
    0.05432777f, 0.05076251f, 0.06134177f, 0.02950023f, 0.02164383f, 0.03896490f, 0.02304007f, -0.06604153f, 
    0.06471997f, 0.21562044f, -0.21106082f, 0.14942354f, -0.04436253f, -0.02531564f, 0.05155353f, -0.04271775f, 
    -0.14205629f, 0.02507796f, 0.04644430f, 0.13758893f, -0.11239191f, 0.09770183f, 0.06660319f, -0.17690732f, 
    0.07042120f, 0.02440383f, -0.01792452f, -0.04714696f, -0.09381533f, -0.08370546f, 0.06598235f, -0.09203630f, 
    0.00293075f, 0.06582046f, -0.07290093f, 0.38890678f, -0.01912049f, 0.06567225f, -0.17893727f, -0.00717630f, 
    0.05154168f, 0.04388243f, -0.07487910f, 0.01727263f, -0.15086409f, 0.17941122f, -0.09241288f, 0.34053984f, 
    0.08822285f, 0.03605790f, -0.04355028f, -0.01019049f, 0.04005039f, 0.07970539f, -0.02778741f, -0.06277012f, 
    -0.13459602f, 0.12240766f, 0.06443942f, 0.03224319f, -0.05639329f, 0.03640592f, -0.06199162f, -0.08089361f, 
    -0.11358395f, -0.01482710f, 0.01204774f, 0.01901392f, 0.02052886f, 0.07532268f, 0.02520135f, 0.29673266f, 
    0.10358598f, -0.01846588f, -0.02657539f, -0.15076068f, -0.11405852f, -0.07311520f, 0.02922712f, -0.00034886f, 
    -0.02637744f, 0.14628842f, 0.14626390f, -0.02337059f, -0.04037746f, -0.01353670f, 0.05823255f, -0.08351509f, 
    0.05272910f, 0.04561344f, 0.02083609f, 0.04534682f, -0.02137987f, 0.07331655f, -0.03330711f, -0.11081274f, 
    0.00609101f, 0.05577525f, -0.04156226f, -0.10576458f, -0.01610849f, -0.06505977f, 0.05569036f, -0.04370054f, 
    -0.10870178f, 0.03414191f, 0.10376351f, -0.15031494f, 0.05253654f, -0.00003348f, 0.07364739f, -0.19087906f, 
    -0.01196761f, 0.09751474f, -0.07918597f, -0.12157269f, 0.03492254f, -0.02188961f, -0.06336088f, 0.02744952f, 
    -0.13421783f, 0.11864285f, 0.01148695f, 0.28329235f, -0.06566826f, 0.04567093f, 0.06335620f, -0.18648082f, 
    -0.11708115f, -0.13598703f, 0.16718575f, -0.01699813f, 0.08417746f, 0.10085396f, -0.06870605f, 0.14006256f, 
    -0.15745433f, -0.02313603f, 0.16001052f, 0.09709138f, 0.34187222f, -0.03065110f, 0.14911522f, -0.05410431f, 
    0.07938495f, 0.01299920f, 0.03058177f, -0.02990349f, -0.04884635f, 0.12410304f, 0.15222692f, -0.07519411f, 
    0.11682920f, 0.01447958f, -0.03750810f, 0.00976599f, 0.07161092f, 0.05263029f, 0.01959083f, 0.02158866f, 
    -0.01464454f, 0.01607071f, 0.04496167f, -0.08311512f, 0.08971118f, -0.02801936f, 0.15635711f, -0.11501329f, 
    -0.07718653f, -0.02907627f, -0.05339127f, -0.07377136f, 0.00159389f, -0.08758791f, -0.02484690f, -0.06693024f, 
    0.18027557f, -0.20331460f, -0.05571764f, -0.32640538f, 0.05655756f, -0.06955238f, -0.01435116f, -0.00372201f, 
    0.04008113f, -0.04966421f, 0.03881457f, 0.06539787f, 0.09101576f, 0.02218789f, 0.03140109f, -0.04807759f, 
    0.15032412f, 0.03572946f, 0.06603475f, -0.09031655f, -0.01410728f, 0.15985347f, 0.06677767f, 0.02699384f, 
    0.01619641f, -0.04702967f, -0.14183068f, -0.20759965f, 0.07650066f, 0.04191067f, -0.12511648f, 0.03132251f, 
    -0.06826221f, 0.02978151f, 0.01936825f, 0.05634282f, -0.20039588f, 0.08524062f, 0.03806622f, 0.12096868f, 
    -0.03267807f, 0.04750242f, 0.05962333f, 0.07035597f, 0.14974773f, 0.09545380f, -0.03293721f, -0.01188989f, 
    -0.16292731f, 0.02029431f, -0.03682886f, 0.05020992f, 0.00843597f, -0.09502891f, -0.01915330f, 0.02412742f, 
    -0.04178546f, 0.06578378f, 0.05580246f, 0.01447996f, 0.20505780f, -0.22969760f, -0.01308142f, 0.01978330f, 
    0.05052102f, -0.03200411f, 0.00100171f, -0.06570636f, 0.00138123f, -0.09888626f, -0.07412893f, 0.02665935f, 
    0.09950762f, 0.00108659f, 0.05465835f, 0.23190001f, 0.08147070f, 0.03088582f, -0.10053989f, 0.03820742f, 
    0.08129120f, -0.06498152f, 0.02705071f, -0.14608219f, -0.10418503f, 0.16428454f, -0.31149146f, 0.04342146f, 
    -0.03980841f, -0.00513550f, -0.02880508f, 0.06216067f, 0.07036462f, -0.01375433f, 0.06939535f, -0.06593364f, 
    -0.11065704f, 0.20752616f, 0.14903858f, -0.14014970f, 0.07166410f, 0.05682891f, 0.03774550f, 0.01155170f, 
    0.02577468f, 0.13794091f, -0.02530281f, -0.03796124f, -0.14624196f, 0.10747941f, 0.08673359f, 0.26124531f, 
    0.05562159f, 0.00873345f, -0.04675128f, -0.00120391f, 0.04990658f, 0.02854136f, 0.02362176f, -0.07257269f, 
    0.09223448f, 0.07634512f, -0.08982242f, 0.16189960f, -0.08950769f, 0.10091657f, 0.07448747f, -0.04189705f, 
    0.03754410f, 0.16508742f, 0.03074717f, 0.12422829f, 0.05607266f, 0.24866264f, 0.17435439f, -0.50504941f, 
    0.01623126f, 0.02136298f, 0.04735596f, 0.03204763f, -0.03807105f, 0.10928104f, -0.05239181f, -0.04557830f, 
    -0.23471326f, 0.04420283f, -0.09945788f, 0.29038724f, 0.07878198f, -0.07555885f, 0.08527751f, 0.07895654f, 
    0.07215656f, -0.03237250f, 0.10105936f, 0.04701591f, -0.37502596f, 0.39425012f, 0.01288245f, -0.17472254f, 
    0.08522706f, 0.01869010f, 0.04856744f, 0.02555385f, 0.05228815f, -0.04775032f, 0.10350199f, 0.01202703f, 
    -0.12975588f, 0.27794513f, -0.11145581f, -0.30809870f, 0.08745915f, 0.06098580f, -0.03236327f, 0.03606296f, 
    -0.04846567f, 0.03691562f, 0.07784382f, -0.13549457f, 0.04518689f, 0.18552090f, 0.08611897f, 0.02758693f, 
    0.06620456f, -0.11455081f, 0.04923500f, -0.16725473f, -0.04952218f, 0.16083150f, -0.04351497f, -0.04098592f, 
    0.17173354f, 0.16275319f, -0.05135268f, 0.09178013f, 0.01965120f, 0.17544588f, -0.02906454f, 0.07301769f, 
    0.13555427f, 0.06423649f, 0.11563919f, 0.06714025f, 0.37985310f, -0.21484923f, -0.07347588f, -0.11704111f, 
    0.07465675f, -0.04940300f, 0.09055127f, -0.03427112f, -0.04604207f, 0.12679532f, 0.08816005f, 0.20488414f, 
    -0.13551591f, -0.23430395f, 0.32124957f, 0.15292135f, -0.01925209f, -0.03259272f, 0.07808356f, 0.06670920f, 
    -0.02082478f, 0.04780798f, 0.08633664f, 0.13136439f, 0.11632064f, -0.05244444f, 0.07072151f, -0.35312945f, 
    0.00885888f, -0.04544322f, -0.04100031f, -0.04701283f, 0.08746403f, 0.00875047f, 0.02458711f, 0.14150691f, 
    0.03280716f, 0.20409203f, -0.01764212f, -0.50139403f, 0.06975875f, 0.03731856f, 0.00374251f, -0.05023619f, 
    -0.06591459f, -0.00652578f, 0.02810256f, 0.05882495f, 0.23500773f, -0.40181723f, 0.17884855f, 0.45723093f, 
    0.02671912f, -0.11175741f, -0.04352763f, -0.03408424f, -0.08706583f, -0.12073947f, 0.03300501f, -0.06837969f, 
    0.18668336f, 0.15306607f, -0.03079768f, 0.34166074f, 0.01235860f, -0.02386380f, -0.11434612f, 0.02437776f, 
    -0.06138260f, -0.17250387f, 0.02385054f, -0.06120620f, 0.14343162f, -0.03805683f, -0.15285918f, 0.24746017f, 
    0.05864711f, 0.05990632f, -0.17733207f, -0.01998115f, -0.02689160f, 0.07544094f, 0.01602537f, -0.06995916f, 
    -0.14154463f, 0.11813536f, 0.02178748f, 0.20969383f, 0.16651921f, 0.01731066f, 0.08286465f, -0.07180400f, 
    -0.00895691f, 0.02977073f, -0.01003248f, 0.13433611f, -0.21374445f, 0.26400897f, -0.19456506f, 0.34801000f, 
    0.12280811f, 0.12361643f, 0.02569789f, -0.02716909f, 0.06177286f, 0.02151821f, -0.02986589f, -0.03983681f, 
    -0.16142328f, 0.15968539f, 0.05966993f, 0.26254871f, 0.06588856f, 0.16738640f, -0.09531794f, 0.09179880f, 
    0.07435530f, -0.07265034f, 0.02931074f, 0.21225625f, 0.04434592f, 0.03521411f, -0.11633524f, -0.06192619f, 
    0.03948318f, -0.05465981f, 0.07193235f, 0.06409899f, 0.02545933f, -0.15104429f, -0.03357290f, -0.07537714f, 
    -0.02198811f, -0.02128455f, -0.02371551f, -0.03026530f, 0.00212703f, -0.03514469f, -0.02700795f, 0.00201292f, 
    0.02336676f, -0.01449661f, -0.00310573f, 0.02071334f, 0.02093954f, -0.02197565f, -0.00031387f, -0.00311880f, 
    -0.02928420f, -0.03658152f, 0.01854730f, -0.03288924f, -0.00758894f, 0.01708841f, -0.03720234f, -0.03977101f, 
    0.02046119f, -0.00853499f, 0.02550438f, -0.00914676f, -0.03333149f, 0.01446367f, -0.01998307f, 0.02390367f, 
    -0.02310129f, -0.00567822f, -0.01017211f, -0.02867394f, -0.02227751f, 0.01506866f, 0.01094887f, 0.01453595f, 
    0.01179474f, 0.02504976f, -0.02446214f, -0.02284753f, 0.02905886f, -0.03926479f, -0.02012893f, 0.03171889f, 
    0.00782370f, -0.02016414f, -0.01227723f, -0.03312120f, 0.02074901f, -0.02214267f, 0.02809307f, -0.01684923f, 
    0.01785569f, 0.02000577f, -0.00573170f, -0.00402331f, 0.03218253f, -0.02214099f, 0.02870922f, -0.01084540f, 
    -0.00926506f, 0.01544954f, -0.00180066f, -0.02305955f, -0.01097143f, -0.01519741f, 0.03565762f, -0.01309053f, 
    -0.00429447f, -0.03501837f, 0.00933603f, -0.00230474f, 0.00908104f, 0.02364911f, 0.01589113f, 0.02478811f, 
    -0.00691404f, 0.01709902f, 0.01810849f, -0.02561203f, -0.00709211f, 0.00871807f, -0.01218431f, -0.00093971f, 
    0.02825429f, 0.00328572f, -0.03053265f, -0.00990962f, -0.01064201f, 0.04412520f, -0.03141842f, -0.01210353f, 
    -0.00497474f, -0.00571459f, -0.00583769f, 0.00523581f, -0.00350863f, 0.00982843f, -0.00976587f, 0.00716214f, 
    0.00164186f, -0.03392463f, 0.00212830f, -0.03472473f, 0.00557954f, -0.04122476f, 0.03235959f, 0.01710492f, 
    0.00091579f, 0.00436231f, 0.03158194f, -0.00165845f, -0.00591716f, -0.03492148f, 0.03829699f, 0.00786401f, 
    -0.03270701f, 0.02439184f, -0.01329695f, 0.01421175f, 0.02252362f, 0.03627306f, 0.02266836f, 0.01779174f, 
    0.02356839f, -0.02033922f, -0.01782855f, 0.01509968f, 0.03312479f, -0.00739735f, 0.02705007f, -0.00380776f, 
    0.02036920f, -0.01033576f, 0.03272985f, 0.00844545f, 0.01759145f, 0.01937286f, -0.00231810f, 0.00792358f, 
    0.03066728f, -0.00904984f, -0.03145422f, 0.00219391f, -0.03032540f, 0.04340570f, 0.01175422f, 0.00889533f, 
    -0.03167522f, 0.02783730f, -0.01061740f, 0.00685633f, -0.02792576f, -0.03354979f, 0.02529435f, 0.03302225f, 
    0.01440725f, 0.02328646f, -0.03897042f, -0.01179468f, -0.03446019f, -0.00936032f, 0.02108108f, 0.00521284f, 
    0.00660731f, -0.02356023f, -0.03151988f, -0.01327038f, 0.01138953f, -0.01959944f, -0.02012542f, -0.01898802f, 
    -0.03203684f, -0.01720730f, -0.02129802f, 0.02693324f, -0.01934577f, 0.03070118f, 0.00235726f, -0.01190061f, 
    -0.03884108f, 0.02130244f, 0.02697888f, 0.02479252f, 0.02559073f, -0.00765362f, 0.00041475f, -0.00338257f, 
    0.02344511f, -0.00090697f, 0.00119663f, -0.02689556f, 0.00777023f, -0.01748189f, -0.00241575f, -0.02003439f, 
    0.00532389f, 0.01747408f, 0.02261021f, -0.02349419f, -0.00936849f, 0.00428159f, -0.03903914f, -0.01368103f, 
    -0.02291863f, 0.02782047f, 0.02191810f, 0.02492664f, 0.01363418f, 0.02921746f, -0.04045003f, 0.00392490f, 
    0.00211494f, -0.03791595f, -0.00830120f, 0.02285541f, 0.01708916f, -0.01183129f, 0.01084473f, 0.02186822f, 
    -0.03326766f, -0.00804464f, -0.01915529f, 0.02081720f, -0.01224682f, -0.01490715f, -0.01475518f, -0.02647551f, 
    0.00200788f, 0.01856523f, -0.00556092f, 0.01514786f, 0.02566503f, 0.02320235f, -0.01107398f, -0.00920558f, 
    -0.02043215f, 0.01929547f, -0.02937096f, 0.02813162f, -0.01350925f, -0.01791436f, -0.02921237f, -0.03206185f, 
    -0.01778189f, -0.04010493f, -0.01208407f, -0.00213879f, 0.03008550f, -0.03395953f, 0.02714292f, -0.01006406f, 
    -0.03503010f, -0.01467847f, 0.01218781f, 0.03630365f, 0.03234454f, 0.02969062f, 0.01101287f, 0.03004425f, 
    0.03223596f, 0.01950401f, -0.01762893f, 0.00970353f, 0.02548952f, -0.02714084f, -0.03616025f, 0.01579093f, 
    -0.01780146f, 0.02627701f, -0.00611764f, 0.01119988f, -0.00774746f, -0.01269037f, -0.02101682f, -0.02781102f, 
    0.00426231f, 0.02540581f, -0.03279049f, -0.03465859f, -0.00374099f, -0.01502883f, 0.02919727f, 0.02783540f, 
    -0.02486363f, 0.00217832f, 0.02728347f, -0.02634148f, -0.00454420f, 0.02428421f, 0.01871955f, 0.02188804f, 
    -0.00881891f, -0.03000287f, 0.02987477f, 0.01167812f, -0.02475648f, -0.00898515f, 0.03320586f, -0.03217098f, 
    0.00811869f, -0.01237428f, -0.01937988f, -0.01338333f, -0.03476163f, 0.00720616f, -0.00416674f, 0.02472519f, 
    -0.01960624f, -0.00545164f, -0.02511712f, -0.01429530f, 0.02435054f, 0.02100036f, 0.00243610f, 0.02317853f, 
    -0.02333135f, 0.01606166f, -0.01767758f, 0.00918851f, -0.03250904f, -0.02857349f, -0.01544069f, -0.02469142f, 
    0.00922257f, -0.01090560f, 0.02878016f, 0.03129925f, -0.01320245f, 0.02782212f, -0.03550551f, -0.02719326f, 
    -0.01611899f, 0.02143813f, -0.00809297f, -0.03531081f, 0.02104844f, 0.02804312f, -0.02818942f, -0.02364152f, 
    0.00873014f, -0.00854645f, -0.01609130f, -0.00749888f, 0.00603076f, 0.01246152f, 0.01429490f, 0.03071074f, 
    0.01025692f, -0.00979922f, 0.00581500f, -0.01113865f, -0.03123476f, 0.01655899f, -0.00746308f, -0.00200445f, 
    0.02497986f, -0.02243788f, -0.02578447f, -0.02374401f, 0.01032597f, 0.00731216f, -0.00621589f, -0.00263603f, 
    0.01727206f, -0.03408869f, -0.03441072f, -0.02710170f, 0.01167054f, -0.03490666f, 0.01068458f, -0.00399499f, 
    0.03141801f, 0.00795202f, 0.02855084f, 0.00485755f, 0.00948705f, -0.02439293f, 0.01454956f, -0.03079371f, 
    -0.00198436f, -0.01967140f, 0.01816414f, 0.03209518f, -0.01634753f, 0.01162853f, -0.01031547f, 0.01172850f, 
    -0.02393358f, -0.02069643f, 0.01936113f, 0.03065057f, 0.00053158f, 0.00945708f, 0.01545913f, 0.00602258f, 
    -0.00975109f, -0.02029659f, -0.01748819f, -0.02800939f, -0.02709655f, -0.02564693f, -0.01532392f, 0.00762789f, 
    -0.00484135f, -0.02066598f, 0.00512085f, -0.03617409f, 0.02836933f, -0.01684454f, 0.01036944f, -0.02183999f, 
    -0.03344842f, -0.00161987f, -0.02015357f, 0.01026332f, -0.01455229f, 0.00329236f, -0.00693694f, -0.00438408f, 
    0.00433969f, 0.02472580f, -0.01881875f, 0.02673440f, 0.03293188f, -0.02323523f, 0.01117847f, 0.01195602f, 
    0.00825110f, -0.01655653f, -0.03486700f, -0.02238869f, -0.03137299f, -0.00732107f, -0.00709695f, -0.00274223f, 
    -0.00438241f, 0.02939431f, 0.02507093f, -0.00496885f, -0.02496106f, -0.03175651f, 0.02011622f, 0.00336285f, 
    -0.03552037f, -0.03068474f, 0.00072569f, -0.02200412f, -0.01709706f, 0.02964310f, 0.01271035f, 0.01310773f, 
    0.03059307f, 0.01155034f, -0.00281280f, -0.02788989f, -0.02103659f, 0.02919111f, 0.02595758f, 0.02156880f, 
    0.01484146f, -0.00011802f, -0.03136639f, -0.02969775f, -0.00597649f, -0.00327547f, 0.02023036f, -0.03189798f, 
    0.01242490f, -0.01409053f, 0.02466168f, -0.02275323f, -0.00879883f, 0.02456655f, -0.02600309f, 0.02403889f, 
    0.01472627f, 0.01656903f, 0.01216431f, -0.02063782f, -0.02745458f, 0.03740115f, 0.02927613f, -0.00475793f, 
    0.00757620f, -0.01288866f, 0.00496571f, -0.02587462f, -0.00994872f, -0.04008090f, 0.04426706f, 0.02545686f, 
    0.02031164f, -0.01370481f, 0.02955824f, 0.00785483f, -0.01140286f, 0.02163821f, -0.01124245f, 0.01823365f, 
    -0.01079312f, 0.02412313f, -0.02642645f, 0.01210419f, -0.02327208f, 0.00932456f, -0.00809251f, -0.02947238f, 
    0.01442042f, -0.01322708f, -0.02266684f, 0.03181669f, -0.03774930f, -0.03662531f, -0.03253420f, 0.02226363f, 
    0.00038974f, 0.00384170f, -0.02883237f, 0.03010013f, 0.01164151f, -0.01897074f, 0.01933562f, 0.01959802f, 
    0.03659054f, -0.02815387f, 0.01236749f, -0.01219925f, 0.02911173f, 0.01117665f, 0.02456855f, 0.00847572f, 
    -0.02838372f, 0.01078915f, 0.01160422f, 0.00430673f, -0.00920058f, -0.02678698f, -0.03953198f, 0.00447693f, 
    -0.02842533f, 0.00411986f, 0.00345784f, -0.00171320f, -0.01249678f, -0.02573829f, 0.00684210f, -0.03084075f, 
    0.00907500f, 0.00750835f, 0.03628514f, 0.00780704f, 0.00161345f, -0.02902788f, 0.02232794f, -0.02806253f, 
    0.00846005f, -0.00765407f, 0.00747991f, -0.02101392f, 0.02739751f, -0.02803523f, -0.00699824f, 0.00889819f, 
    -0.01206121f, -0.01489983f, -0.03225814f, 0.02177786f, 0.00296961f, -0.00090451f, -0.00305265f, 0.00974460f, 
    -0.03800409f, -0.01387817f, -0.03750401f, -0.04004330f, -0.02671854f, 0.01586111f, -0.02406823f, 0.02531975f, 
    -0.01054955f, -0.03195499f, 0.01666268f, 0.03485066f, 0.03289092f, 0.01979662f, 0.01170972f, 0.01717527f, 
    0.00702559f, -0.01439252f, -0.01576597f, 0.01544120f, -0.02569218f, -0.03417022f, 0.00945193f, -0.02604534f, 
    0.01786981f, 0.00613847f, 0.02213806f, -0.01710129f, 0.02701235f, 0.01614731f, -0.00276911f, -0.04112307f, 
    -0.02127148f, 0.01751366f, -0.00237185f, -0.01985806f, 0.02434598f, -0.02360372f, 0.01676732f, -0.01842541f, 
    0.02603528f, -0.02249839f, -0.02454321f, -0.00570495f, -0.01543533f, 0.00167100f, 0.00568398f, 0.02334597f, 
    -0.01680529f, 0.00868477f, 0.03649249f, 0.01442444f, -0.03162288f, -0.03188412f, -0.02480816f, -0.00188095f, 
    0.02066219f, 0.00111065f, -0.00959754f, 0.00864202f, 0.04302352f, -0.00714071f, 0.00135713f, -0.00145095f, 
    -0.01110523f, 0.00334430f, -0.00422709f, -0.01837883f, -0.00104464f, -0.02013503f, 0.02097837f, -0.03760280f, 
    -0.03423345f, 0.02935897f, 0.00101779f, -0.03094058f, 0.02604078f, 0.00309392f, -0.00088035f, -0.00302903f, 
    0.00409078f, 0.02379469f, 0.00772170f, -0.03464935f, -0.00663444f, -0.00947484f, -0.01254234f, 0.00650091f, 
    -0.02267748f, 0.03179896f, 0.00954143f, -0.03571248f, -0.00037377f, -0.03486975f, 0.01482844f, -0.02828211f, 
    -0.02680440f, -0.02349866f, -0.01906831f, -0.02303139f, 0.00055553f, 0.02016411f, -0.02805628f, -0.01982124f, 
    -0.01149584f, 0.00022741f, -0.00221107f, 0.01712044f, 0.01422092f, 0.03160436f, 0.03065813f, -0.03983670f, 
    -0.01910334f, 0.00085138f, -0.02713576f, 0.01654883f, -0.02018728f, -0.03536106f, 0.00056692f, 0.03473984f, 
    -0.00901840f, 0.03117782f, 0.02716092f, -0.01997727f, -0.03344091f, -0.02720723f, 0.02969298f, -0.02336783f, 
    0.00209157f, -0.00351166f, -0.01508598f, 0.03044488f, 0.02553144f, -0.01347381f, -0.00695656f, -0.01809539f, 
    -0.01050528f, -0.02205999f, -0.00249773f, -0.02013798f, -0.00395727f, 0.00550506f, -0.00259311f, -0.01077435f, 
    0.02807900f, -0.01407485f, -0.01340819f, 0.01905354f, 0.02668493f, 0.00947877f, -0.03375779f, 0.02942930f, 
    -0.03212163f, 0.03327785f, 0.02621749f, 0.01024606f, 0.02351088f, 0.02226912f, 0.01848205f, 0.00334911f, 
    0.01285743f, 0.01665278f, -0.03139003f, 0.01797099f, 0.00298968f, -0.02116751f, -0.01855463f, -0.03481880f, 
    -0.00771976f, 0.01835885f, 0.02342070f, 0.00746200f, 0.02304913f, -0.02669504f, 0.00618596f, -0.02242971f, 
    -0.02410029f, -0.01304175f, -0.02914380f, 0.02382980f, 0.02278739f, -0.03371903f, -0.00239947f, -0.00443686f, 
    -0.02569527f, -0.03922655f, -0.01970161f, 0.01865059f, -0.01357440f, -0.03552496f, -0.01137069f, -0.00668597f, 
    -0.03202079f, -0.02334765f, -0.01641574f, 0.00370530f, 0.00007322f, -0.00221040f, 0.02961172f, -0.00157534f, 
    -0.01670936f, 0.01405076f, 0.00686645f, 0.00313000f, 0.02578665f, 0.02808646f, 0.00192406f, -0.01832652f, 
    0.01678273f, 0.03257793f, 0.02066569f, 0.02188359f, -0.01225382f, -0.03577797f, 0.02801384f, 0.02531787f, 
    0.02249703f, 0.02576040f, -0.00574763f, -0.02594751f, 0.00215975f, 0.00263280f, -0.02852415f, 0.03301505f, 
    -0.03011864f, -0.01179260f, 0.02964799f, 0.01566021f, -0.03444599f, -0.00784746f, 0.02520517f, 0.01552681f, 
    0.02339357f, -0.01244854f, -0.00770772f, -0.02884850f, 0.03013115f, -0.02331083f, 0.00279000f, -0.02131884f, 
    0.01507466f, 0.01282061f, -0.02332134f, 0.03005894f, 0.00603318f, -0.02887647f, -0.00233499f, -0.02673747f, 
    0.02641334f, -0.03856974f, 0.00254149f, 0.01172440f, -0.03979593f, -0.00700762f, -0.01291719f, 0.00385825f, 
    -0.02466914f, 0.00979540f, -0.02081550f, -0.03014317f, -0.03230645f, -0.01121962f, 0.00173899f, -0.01840576f, 
    -0.02178697f, -0.01128005f, 0.00261133f, 0.02149342f, -0.01866901f, -0.03043033f, -0.01762261f, -0.03298794f, 
    -0.01916968f, -0.01462037f, -0.00950808f, -0.01648224f, 0.00483214f, -0.02673000f, 0.02438957f, -0.00265446f, 
    -0.02323154f, -0.01391780f, 0.01798159f, 0.01827343f, -0.02274306f, -0.00523101f, -0.01025151f, 0.00258792f, 
    0.04025586f, -0.01106547f, -0.01433361f, 0.01410719f, 0.01421236f, -0.00151472f, -0.00814814f, -0.01234384f, 
    -0.03425287f, 0.00178638f, 0.02536303f, 0.03785498f, -0.02342988f, 0.03059465f, 0.00858955f, 0.03051641f, 
    -0.03236554f, 0.03024152f, -0.02499033f, -0.02833220f, 0.02036776f, 0.02134183f, -0.00369639f, 0.02122002f, 
    -0.02575895f, -0.01211828f, 0.03561371f, -0.00024051f, -0.03535439f, 0.01137958f, -0.02868450f, 0.00505933f, 
    -0.00648565f, 0.02435737f, -0.02530003f, -0.02041470f, 0.01350976f, -0.01774193f, -0.01592224f, -0.00312714f, 
    -0.02462987f, 0.02271848f, 0.00822176f, -0.03314778f, -0.01445001f, 0.02656867f, -0.00022211f, 0.01836087f, 
    0.01893830f, -0.03551427f, 0.02276482f, 0.01927290f, 0.00006567f, 0.00218850f, -0.01390216f, 0.00017335f, 
    0.02496157f, -0.02783154f, 0.02273187f, 0.03125037f, -0.03353698f, 0.02253959f, -0.00912375f, -0.00287204f, 
    -0.00676938f, 0.01151571f, 0.02453250f, -0.00196301f, -0.00649860f, -0.01649040f, 0.01202816f, 0.01829681f, 
    -0.03444347f, -0.03676449f, -0.01569976f, -0.01675331f, 0.00091410f, -0.00623646f, 0.02089802f, 0.02922527f, 
    0.02131824f, 0.03431835f, 0.01953150f, -0.02631468f, 0.03449371f, 0.03317811f, 0.03011513f, -0.01736848f, 
    -0.01734692f, -0.03199650f, 0.02101910f, 0.00262986f, 0.02734348f, 0.01646007f, 0.02407435f, 0.00432502f, 
    -0.01142128f, 0.03024372f, -0.01483535f, -0.02176090f, -0.03182207f, -0.02403070f, -0.03240207f, -0.03306259f, 
    -0.00038957f, -0.01732284f, -0.03520008f, -0.01639327f, -0.01817508f, 0.00070949f, -0.03962627f, -0.01248518f, 
    0.00241438f, -0.02839060f, -0.02464584f, 0.00218964f, -0.03071453f, -0.01217491f, -0.00970123f, -0.02483092f, 
    -0.01124133f, 0.01547677f, 0.01087004f, 0.02515771f, 0.02615556f, -0.03227419f, -0.03542234f, 0.00865022f, 
    0.00585918f, -0.00110904f, 0.00856561f, -0.00670061f, 0.00423502f, -0.01291879f, -0.02607427f, -0.00134573f, 
    -0.00392396f, -0.00805537f, 0.02608405f, -0.00229959f, -0.03562063f, 0.02210492f, 0.02030010f, 0.02803224f, 
    0.01967300f, -0.04451986f, 0.00880125f, 0.04082118f, -0.03112861f, -0.02509854f, -0.00424281f, -0.01924540f, 
    0.01727416f, -0.03940442f, -0.02743602f, 0.02262598f, 0.01049959f, 0.01105509f, -0.01178193f, 0.01617927f, 
    -0.01817680f, -0.02522622f, 0.00914954f, -0.01546160f, -0.03349987f, -0.03675129f, -0.00520640f, 0.01524635f, 
    0.03043481f, 0.01187460f, -0.01101617f, -0.02450379f, 0.02186561f, 0.01380824f, 0.00006379f, 0.00104635f, 
    -0.00151670f, 0.01071303f, -0.04124667f, 0.01238525f, -0.00087177f, -0.02604960f, -0.01671857f, 0.00948071f, 
    -0.02826179f, 0.01847230f, 0.02020915f, 0.03446773f, -0.01103256f, 0.01495789f, -0.00174254f, 0.03837894f, 
    -0.01641062f, 0.00799225f, -0.03646879f, 0.01830933f, 0.01411333f, 0.00341798f, 0.00031444f, -0.01821012f, 
    0.02520151f, -0.01293969f, 0.01434545f, -0.00165487f, 0.02111839f, -0.03146495f, 0.01449319f, 0.00767964f, 
    -0.02755351f, -0.02619871f, -0.00226115f, -0.02928291f, -0.00981410f, 0.01489453f, 0.00178508f, -0.03142469f, 
    0.02879924f, 0.02165470f, -0.04091989f, 0.01100161f, 0.02395802f, -0.02649427f, 0.01008795f, -0.00657749f, 
    -0.01650389f, -0.02147861f, 0.03385611f, -0.00775521f, -0.01220749f, -0.03917031f, -0.00374871f, 0.01982552f, 
    0.02796417f, 0.00741006f, -0.02442547f, -0.01279029f, -0.01132486f, -0.01910859f, 0.01474773f, -0.00235074f, 
    -0.01967536f, -0.03509556f, -0.01037802f, -0.00686003f, -0.01398191f, -0.03014089f, -0.01670205f, 0.01039994f, 
    -0.00588194f, -0.00347020f, -0.03370654f, -0.02868182f, -0.01747806f, 0.00902219f, -0.00928214f, -0.03378570f, 
    0.01940957f, 0.02341642f, -0.03838023f, 0.00057198f, -0.00024086f, 0.00193616f, -0.00879854f, 0.02409855f, 
    0.01300331f, 0.00367446f, 0.01629098f, -0.00044348f, -0.02879946f, -0.02840394f, 0.00478420f, -0.00383378f, 
    -0.03314245f, 0.01427254f, 0.01589109f, -0.02739872f, 0.01856543f, -0.01076098f, 0.01222311f, 0.01224013f, 
    -0.03128724f, -0.00516333f, -0.00904264f, -0.01154858f, -0.01470699f, 0.01784221f, -0.02980678f, 0.01509803f, 
    -0.03446319f, 0.02777449f, -0.00493323f, -0.01974066f, 0.02867663f, -0.01149396f, -0.02919811f, -0.00347236f, 
    0.02722910f, -0.02834804f, -0.01939481f, 0.02103532f, -0.01216328f, 0.00091946f, -0.03804647f, -0.00721871f, 
    -0.02748676f, -0.00874061f, -0.04092441f, -0.03975147f, -0.03611101f, 0.01774369f, -0.01898639f, -0.02369752f, 
    -0.03010590f, -0.02633649f, -0.01210759f, 0.01266515f, 0.04065701f, -0.01868372f, -0.01963731f, -0.00042548f, 
    0.02096337f, -0.03762532f, -0.03003855f, -0.00288119f, 0.02569041f, 0.01223410f, -0.00521048f, -0.02365476f, 
    0.00483393f, 0.01406564f, -0.00671340f, 0.01958776f, -0.03181081f, 0.03301778f, -0.03017106f, -0.02897391f, 
    -0.01687756f, -0.04176024f, 0.00234931f, -0.01039124f, -0.04167245f, -0.00204459f, 0.00521871f, -0.00500851f, 
    -0.03382651f, 0.01828300f, -0.00376226f, -0.03483547f, -0.00267426f, 0.03298378f, -0.00902755f, -0.03474726f, 
    0.01690685f, 0.01708467f, -0.03707627f, -0.02540178f, -0.01173631f, 0.00997418f, -0.00720597f, 0.02975385f, 
    -0.02742683f, 0.00216560f, 0.02365239f, -0.03347741f, -0.02250039f, 0.00069307f, -0.03385863f, -0.02703848f, 
    0.00087701f, -0.03488385f, 0.00576757f, -0.01801359f, -0.03780223f, 0.00941988f, 0.02141754f, -0.03323928f, 
    0.01350693f, 0.03616770f, 0.02792470f, -0.00802045f, -0.03185872f, 0.00890094f, -0.03494096f, -0.03522219f, 
    -0.00990639f, 0.02807277f, -0.03665849f, -0.02324292f, 0.01458615f, -0.01494205f, 0.01159410f, 0.02689259f, 
    -0.00633547f, -0.00857437f, -0.01503432f, -0.01489961f, -0.00131402f, -0.03731968f, -0.02067000f, 0.03646173f, 
    -0.02454959f, -0.00162908f, -0.00787154f, 0.01930034f, 0.03285244f, -0.02012515f, -0.01714814f, 0.00357564f, 
    -0.02951289f, -0.02856626f, -0.02843836f, -0.02822109f, 0.01694779f, -0.03771152f, 0.03172799f, 0.03417291f, 
    0.01327733f, -0.03466994f, 0.01781260f, -0.00973670f, -0.04041668f, -0.03506691f, -0.02029679f, -0.00139305f, 
    0.01303710f, 0.02112816f, -0.02875421f, 0.02618471f, 0.00644975f, 0.00541065f, -0.02991140f, 0.00425169f, 
    0.00274455f, -0.03507258f, -0.02024685f, -0.01824623f, -0.02757625f, -0.02952348f, 0.00658361f, 0.00989317f, 
    -0.03452301f, 0.00013212f, -0.02582278f, 0.02903259f, 0.01953737f, -0.02820639f, 0.03353101f, -0.01333740f, 
    -0.02591615f, -0.03720408f, -0.01269328f, -0.03353126f, 0.01272301f, -0.02558221f, 0.00014459f, -0.00676332f, 
    -0.01872596f, 0.00956701f, -0.00517404f, 0.02146707f, 0.02768965f, 0.00640330f, -0.00613243f, 0.02819729f, 
    0.00090636f, 0.00832844f, -0.01247154f, 0.01623861f, -0.03820600f, 0.00942602f, -0.02201456f, -0.03466490f, 
    -0.03175125f, 0.03051904f, 0.02460811f, 0.03403861f, -0.01583288f, -0.00176639f, 0.02212634f, -0.00008558f, 
    0.04263525f, 0.00431956f, 0.00562696f, -0.02176930f, 0.01741249f, -0.00648905f, -0.01980953f, 0.00350597f, 
    -0.00341364f, -0.01646704f, -0.00747414f, 0.00345482f, -0.00693281f, -0.02845373f, -0.02883352f, -0.00808933f, 
    0.00559705f, 0.02293447f, -0.01588370f, 0.00559389f, -0.02499807f, -0.01115069f, -0.01263055f, 0.00911343f, 
    -0.01832140f, -0.00849829f, 0.01959180f, 0.01077923f, 0.00427816f, 0.02694060f, 0.02782173f, -0.03462031f, 
    0.02498309f, 0.00789432f, 0.02112917f, -0.02120971f, 0.02508543f, 0.03341560f, -0.01353475f, -0.02101692f, 
    -0.01010082f, 0.02784279f, -0.02157052f, -0.02075827f, 0.00319589f, -0.03394279f, 0.01065612f, 0.00546979f, 
    0.01997495f, -0.02031812f, 0.00566850f, 0.00218283f, 0.01679560f, -0.01967726f, -0.03140664f, -0.01719891f, 
    0.00205100f, -0.02374183f, 0.02652586f, -0.00815031f, -0.02761355f, -0.02419270f, -0.03391884f, 0.00951801f, 
    -0.01958866f, 0.00493341f, -0.03750202f, 0.00586420f, -0.00949085f, 0.02421628f, 0.02739705f, 0.00688635f, 
    -0.00241291f, 0.02442404f, -0.01810514f, -0.01977008f, 0.00330120f, -0.03199222f, 0.01042484f, 0.03040325f, 
    0.02684798f, -0.03704271f, -0.02840873f, -0.03017733f, 0.00997711f, -0.00828342f, -0.03831747f, 0.03199265f, 
    -0.01239635f, -0.01974696f, -0.02181974f, -0.03073299f, 0.00923970f, 0.02032715f, 0.00537664f, -0.03361553f, 
    -0.02378001f, -0.01494060f, -0.03260835f, -0.01488062f, -0.02865543f, 0.03145544f, -0.03748105f, 0.00449229f, 
    -0.00169145f, -0.01368897f, 0.02700463f, 0.00777952f, 0.00463582f, 0.02062394f, -0.02400826f, 0.02259807f, 
    -0.01141681f, 0.00254993f, 0.03117041f, 0.00563098f, -0.02374696f, -0.02404675f, 0.01586063f, 0.03337719f, 
    -0.03399077f, 0.00886700f, -0.00890480f, 0.02060130f, 0.00200687f, -0.01614964f, 0.03365689f, 0.01936245f, 
    0.00532269f, 0.01647950f, 0.01142251f, 0.01985499f, -0.01884880f, -0.01534861f, -0.01426130f, 0.01977119f, 
    -0.00754796f, 0.01166199f, -0.01835201f, 0.00846878f, -0.01784305f, -0.00914818f, -0.02465041f, 0.01836599f, 
    -0.00511543f, 0.02966998f, 0.02707509f, 0.02986874f, 0.01600590f, 0.00510320f, -0.00702829f, 0.02583353f, 
    0.02063769f, 0.00020088f, -0.00031402f, 0.02515936f, -0.00526266f, -0.00753398f, -0.02169940f, 0.01064296f, 
    0.03188755f, -0.00111839f, 0.00244910f, -0.02237774f, -0.02128335f, 0.01221414f, 0.03162685f, -0.00645719f, 
    0.02967196f, -0.02487783f, -0.01582203f, -0.02794380f, -0.03984365f, -0.01387845f, -0.00484190f, -0.00538783f, 
    -0.00639265f, -0.01237062f, -0.01990264f, -0.04062754f, 0.02144827f, 0.02340214f, -0.03044181f, -0.00549051f, 
    -0.03252662f, -0.01311050f, 0.01323112f, 0.03098411f, -0.03242218f, 0.01767787f, -0.01498593f, 0.02139712f, 
    0.19058536f, 0.08156151f, -0.01542124f, -0.16473657f, 0.00820280f, -0.03135225f, 0.07178288f, 0.02514489f, 
    0.01217163f, 0.01049652f, 0.03171546f, 0.01181960f, 0.18055855f, 0.15029179f, 0.02577415f, -0.15875787f, 
    -0.11997864f, -0.04592469f, -0.07792059f, -0.02488698f, -0.04703871f, 0.01654612f, 0.14348429f, 0.09625809f, 
    -0.54501671f, 0.14517596f, 0.04160812f, -0.12215448f, -0.00650590f, 0.03912957f, 0.05775877f, -0.02856790f, 
    0.08575445f, -0.01188329f, -0.01419380f, 0.08878955f, 0.06523111f, 0.11917842f, -0.09294023f, 0.05776013f, 
    0.05600130f, -0.05991549f, 0.08713145f, -0.18398666f, -0.10929419f, 0.07001843f, 0.04498744f, 0.10880608f, 
    -0.11372642f, 0.07618403f, 0.02032666f, -0.17051113f, -0.02284988f, -0.06969135f, 0.15192729f, 0.02600901f, 
    -0.01398728f, -0.00916809f, 0.06057597f, 0.03051331f, 0.15881084f, 0.02515303f, -0.05201029f, 0.48372844f, 
    -0.14372864f, 0.07783582f, 0.07863865f, 0.01096723f, -0.03429556f, -0.04126606f, 0.05413990f, 0.02567270f, 
    0.01196728f, 0.07088001f, 0.02170816f, 0.12230041f, -0.01044763f, -0.05642431f, 0.15885797f, 0.17305316f, 
    0.15038145f, -0.01549254f, 0.03517199f, -0.03270426f, 0.06499285f, 0.04410094f, 0.00567592f, -0.00061801f, 
    -0.03914712f, 0.05618555f, 0.05983049f, -0.10469417f, 0.08980222f, 0.01955644f, 0.00954454f, 0.09100632f, 
    0.54292721f, 0.16338378f, -0.13705885f, 0.07085153f, -0.07442814f, 0.04150565f, -0.00305139f, 0.05148217f, 
    -0.04170715f, 0.07768732f, 0.00357076f, 0.03105395f, 0.02353962f, -0.15385956f, 0.09429350f, 0.22283067f, 
    -0.03369165f, -0.00417987f, -0.01444865f, -0.04164455f, 0.02214271f, 0.11591149f, 0.10424194f, -0.06741237f, 
    0.22729073f, 0.16373301f, 0.00285150f, 0.04834586f, -0.14404793f, 0.00549227f, -0.09207118f, 0.14671455f, 
    0.00310147f, -0.02201572f, -0.05565320f, 0.03270302f, -0.05513668f, 0.00685150f, 0.11702890f, -0.04374366f, 
    -0.02724983f, 0.11191053f, 0.16296148f, 0.05996236f, 0.05309812f, -0.10331681f, 0.01748117f, 0.01471557f, 
    0.15030569f, -0.03384906f, -0.33077246f, 0.12933400f, 0.05442979f, 0.11479573f, 0.06259104f, -0.07478373f, 
    -0.05476202f, 0.01460541f, -0.00896235f, 0.06596246f, 0.01336128f, 0.12295474f, 0.04764395f, -0.24829651f, 
    -0.04686158f, -0.09471337f, 0.09924493f, -0.03659151f, 0.03265686f, 0.06323355f, 0.06630215f, 0.08952096f, 
    0.03472629f, -0.11005951f, 0.00989815f, 0.22005251f, -0.01558644f, 0.09228795f, 0.04207644f, 0.01962436f, 
    0.07674634f, 0.09485204f, -0.08852382f, 0.03447062f, -0.32663840f, 0.14725880f, 0.01492783f, 0.17850761f, 
    0.05430234f, 0.04860396f, 0.05856247f, 0.09480805f, 0.07797959f, 0.04329775f, -0.16164519f, 0.19230863f, 
    -0.05102930f, 0.06643923f, 0.05679433f, -0.08615865f, -0.01790406f, 0.03573785f, 0.04817220f, -0.00951744f, 
    -0.04199947f, 0.11672437f, 0.02709726f, -0.04308082f, -0.08108654f, -0.01997666f, 0.10530663f, -0.03850278f, 
    -0.09689206f, -0.00579864f, 0.06383346f, -0.09991223f, 0.12003945f, 0.12237488f, 0.10837837f, -0.14897169f, 
    -0.27067226f, 0.20343521f, 0.01355471f, -0.02003903f, 0.01145263f, -0.04569824f, 0.05980111f, 0.01095316f, 
    -0.04064170f, 0.09023981f, -0.01387800f, -0.09526464f, 0.22711013f, 0.10206129f, -0.00115434f, 0.01847659f, 
    -0.10224687f, 0.03149110f, 0.04622191f, -0.02902784f, 0.05615366f, -0.15225373f, -0.03742177f, -0.01390150f, 
    0.10185497f, 0.07796024f, 0.09181070f, -0.18187365f, -0.06641575f, 0.03648720f, 0.02117754f, 0.00601089f, 
    -0.00968743f, 0.02189675f, 0.04750687f, 0.11638977f, 0.13958317f, -0.21585877f, 0.01050760f, 0.04193697f, 
    -0.15594068f, 0.04036763f, 0.00896528f, 0.17549735f, 0.01625611f, 0.04799953f, 0.03506563f, 0.05468934f, 
    0.13242675f, -0.02441935f, 0.27988058f, -0.12254876f, 0.10484268f, 0.13974671f, 0.04995143f, 0.01947157f, 
    0.06944000f, 0.01859307f, -0.00133005f, 0.05073342f, 0.13059600f, -0.12773557f, 0.01996185f, -0.00469254f, 
    -0.08176222f, -0.04623920f, 0.03829431f, 0.18540014f, -0.11269155f, -0.01599881f, 0.15555844f, 0.00899646f, 
    -0.01000511f, 0.06809434f, -0.14192155f, -0.10891485f, -0.02567886f, 0.18001854f, 0.10112739f, -0.03485110f, 
    0.00211581f, 0.05932129f, -0.01107415f, -0.10814034f, -0.37039465f, -0.04367321f, 0.07347814f, 0.04037814f, 
    0.06846033f, 0.12432639f, 0.08368830f, 0.02514866f, 0.14089614f, -0.03431059f, 0.04185172f, -0.04408975f, 
    -0.00240358f, 0.10917789f, 0.02035820f, -0.11418087f, -0.12743212f, 0.01975031f, 0.17562245f, 0.05514595f, 
    -0.03574885f, 0.03402271f, 0.05425730f, -0.01729318f, 0.40893400f, 0.10605018f, -0.02009954f, -0.25707036f, 
    -0.12096586f, -0.00659891f, 0.05261184f, -0.06380462f, 0.03999506f, 0.03522374f, -0.05645273f, -0.03934319f, 
    0.03188521f, 0.12073253f, 0.06134100f, -0.05420517f, -0.10158716f, 0.00894254f, 0.10191156f, 0.05943260f, 
    -0.00275404f, 0.01268859f, -0.01402706f, 0.08004272f, 0.06926935f, 0.12618507f, 0.10329045f, 0.05483979f, 
    -0.01654710f, -0.02035864f, -0.10212942f, -0.00336823f, -0.00889345f, -0.06498872f, 0.03203315f, 0.00314855f, 
    0.06595351f, 0.18683578f, 0.05267711f, 0.06769877f, -0.02425408f, -0.06725229f, 0.05125660f, 0.10899318f, 
    0.01454676f, 0.05401422f, -0.03686252f, -0.06237005f, 0.17332080f, 0.02190096f, -0.07873379f, -0.14770724f, 
    -0.04631041f, 0.04424632f, 0.14989915f, -0.01063767f, -0.08857434f, 0.12148324f, -0.08499081f, 0.03502175f, 
    0.06781401f, -0.09542510f, 0.06573369f, -0.11551560f, -0.10577635f, -0.00065749f, -0.02492983f, -0.02560085f, 
    0.04482634f, 0.04168288f, 0.10407636f, 0.13342898f, 0.09810290f, 0.03220982f, 0.13185793f, -0.10865604f, 
    0.01595911f, 0.05511082f, -0.03020974f, -0.05425040f, -0.01388390f, 0.04706316f, 0.09393751f, 0.02652697f, 
    -0.27306902f, 0.03262314f, -0.08228045f, 0.00659329f, 0.03332992f, -0.00848032f, -0.00845872f, 0.04744514f, 
    0.03883116f, 0.03007823f, 0.11315009f, 0.02432757f, -0.28494567f, -0.13576867f, 0.07527512f, -0.01233822f, 
    0.00557784f, 0.10756108f, 0.08022354f, 0.08315720f, 0.08499838f, -0.03578549f, -0.01510977f, -0.03278145f, 
    0.07338825f, -0.02231274f, 0.05809573f, 0.13897797f, -0.06391497f, -0.00991001f, 0.00322243f, 0.08776186f, 
    0.07293886f, -0.01300887f, 0.13021141f, 0.07897792f, 0.03838851f, 0.00322851f, -0.02002398f, 0.05693898f, 
    -0.11739784f, 0.00845896f, -0.01283176f, -0.06235052f, -0.01752914f, 0.04967356f, -0.00191840f, 0.13479374f, 
    0.01651916f, 0.04921496f, 0.03320267f, -0.00136901f, 0.12011642f, -0.00588868f, -0.05502056f, 0.05332998f, 
    0.04149282f, 0.05238443f, 0.06094945f, 0.06624302f, -0.25679004f, -0.08269784f, -0.14073847f, 0.17962243f, 
    0.06518606f, -0.05419390f, 0.02571341f, 0.05106299f, 0.00617729f, 0.11637963f, -0.00812025f, 0.09113721f, 
    -0.03589095f, 0.11325916f, 0.14871044f, -0.18315855f, -0.04773740f, 0.01625178f, -0.08787633f, -0.09740737f, 
    0.11772424f, 0.09180796f, 0.01050070f, -0.07742409f, -0.03694667f, 0.09877805f, 0.03106262f, 0.05242691f, 
    0.13527836f, 0.10851566f, -0.03419043f, -0.02138842f, 0.02377087f, 0.04473016f, 0.06708520f, 0.10871536f, 
    -0.35777101f, 0.05092319f, -0.01494153f, 0.11192625f, -0.04052706f, -0.06784765f, -0.09500555f, 0.03305626f, 
    0.02008422f, 0.01854546f, 0.01608101f, 0.03785446f, 0.43012494f, -0.23687266f, 0.30667686f, -0.18108967f, 
    -0.01955797f, 0.10353091f, 0.01438585f, -0.02498161f, 0.10354433f, -0.10340244f, 0.09325043f, -0.01701902f, 
    -0.14451259f, 0.12281145f, 0.00952209f, 0.04227718f, 0.05671842f, 0.11831435f, -0.03392542f, 0.18750711f, 
    0.06650078f, 0.13294646f, -0.00420306f, -0.02828300f, 0.27393004f, 0.04528541f, -0.21814990f, 0.00756124f, 
    -0.03233722f, 0.07542500f, 0.05266400f, -0.05492350f, 0.03279521f, -0.01881550f, 0.03745270f, 0.08649722f, 
    0.20302716f, 0.10579827f, 0.06458425f, -0.12027691f, -0.09690403f, 0.06308538f, 0.01304494f, 0.01854906f, 
    -0.06765961f, 0.15187363f, -0.01268260f, 0.09660317f, -0.00120185f, -0.13602513f, -0.02357279f, 0.36403221f, 
    0.03701139f, 0.04644394f, 0.05147797f, 0.07707155f, -0.04504807f, -0.04577868f, -0.03911039f, 0.01359259f, 
    0.05649525f, 0.03338935f, -0.11998241f, 0.00976951f, -0.01160663f, 0.11161289f, -0.03958474f, -0.08681624f, 
    -0.05346044f, 0.07749784f, 0.08517658f, 0.04478380f, -0.05999428f, -0.25171241f, 0.01010563f, 0.21730474f, 
    -0.08089514f, 0.08970637f, 0.03126059f, 0.00271553f, 0.00774893f, -0.00405721f, -0.00105997f, -0.03108174f, 
    -0.16356622f, -0.03723166f, 0.06541760f, 0.04207725f, -0.10688712f, -0.09148393f, 0.01165388f, 0.08479640f, 
    0.13394572f, 0.04050713f, 0.04409043f, -0.04598993f, -0.06578399f, 0.01975412f, -0.06591998f, -0.08547959f, 
    -0.02635608f, -0.01231696f, -0.04767005f, 0.02529394f, -0.04298127f, 0.03859804f, -0.00447653f, -0.03485145f, 
    -0.11363165f, 0.14566496f, 0.15214534f, -0.10207964f, 0.03252023f, 0.04723993f, 0.00478677f, -0.00232918f, 
    0.05077630f, 0.06393934f, 0.03808051f, 0.07061363f, 0.24679297f, -0.00949823f, 0.06708010f, 0.08648311f, 
    -0.18378650f, 0.03877302f, 0.09457606f, 0.03033284f, 0.02917660f, 0.09931578f, 0.05307841f, -0.09236293f, 
    0.26704362f, 0.39646783f, 0.11106887f, 0.34296671f, -0.08584242f, 0.08913209f, -0.00128805f, -0.09992570f, 
    0.02388514f, -0.01852663f, -0.14170986f, 0.13246058f, 0.20665881f, 0.00631098f, -0.00888580f, 0.01333643f, 
    -0.06727843f, -0.10303987f, 0.07533110f, 0.02836553f, 0.16563436f, 0.04847592f, 0.06794813f, 0.22009148f, 
    0.07586698f, -0.06771019f, 0.01411293f, 0.30994719f, -0.10300595f, -0.02222931f, 0.05102287f, 0.08161107f, 
    0.05287906f, 0.12739153f, 0.08929485f, 0.01338535f, -0.21006724f, 0.27437517f, 0.03817845f, -0.08096667f, 
    0.08114053f, 0.00908528f, 0.09421779f, -0.04072198f, 0.06053672f, 0.04885747f, -0.03888545f, 0.03628073f, 
    0.21776040f, -0.12909827f, -0.05026792f, 0.00991736f, 0.06676395f, -0.04013807f, -0.02307886f, -0.08529191f, 
    -0.03011675f, 0.02320202f, -0.00788414f, -0.03615871f, -0.31132266f, 0.03509741f, 0.03322135f, 0.02901972f, 
    0.07229156f, 0.01707637f, -0.00911146f, 0.02527877f, 0.06304715f, 0.06911483f, -0.03737520f, 0.00513617f, 
    -0.36510926f, 0.02820938f, 0.02327891f, 0.06584676f, 0.06795596f, 0.06063783f, -0.05567923f, 0.11652202f, 
    0.03101368f, -0.03116696f, -0.00856369f, 0.07611608f, -0.03373388f, -0.19163759f, -0.03861925f, -0.06856386f, 
    -0.01290493f, 0.00099690f, 0.08695073f, 0.11434496f, -0.01473065f, -0.00310859f, 0.03684811f, 0.05002977f, 
    0.38117534f, -0.12699357f, 0.18270171f, 0.10338381f, 0.12883613f, 0.07414674f, 0.04710576f, 0.03150402f, 
    0.15851855f, 0.07522551f, 0.10599546f, 0.12849796f, -0.03530896f, 0.08409636f, 0.23022896f, 0.01130452f, 
    0.13094899f, 0.10644915f, -0.04368440f, 0.08891817f, 0.01583526f, -0.04344586f, -0.00192432f, -0.04452880f, 
    -0.14781874f, 0.05634438f, 0.20958696f, 0.17761037f, -0.03651671f, -0.06995669f, 0.04289933f, -0.00238523f, 
    -0.00836253f, -0.01200457f, 0.00527061f, 0.06375444f, 0.11985553f, -0.01515571f, -0.00990870f, 0.01252409f, 
    -0.05614155f, 0.12361988f, 0.04921109f, -0.12523018f, 0.08045779f, 0.10632092f, 0.11414474f, 0.07281972f, 
    0.10598391f, 0.00079445f, -0.06190335f, 0.05482800f, -0.00750238f, 0.11414965f, 0.08228565f, -0.01151748f, 
    0.00922084f, 0.05495097f, 0.12046897f, -0.04467102f, 0.00664859f, -0.10479861f, 0.17836297f, -0.06279048f, 
    -0.11305169f, 0.10272532f, 0.15690975f, 0.03405049f, -0.12494072f, 0.08389147f, 0.00334267f, -0.07394890f, 
    -0.01205609f, 0.15577900f, 0.14042649f, 0.12641022f, -0.02924619f, -0.07940038f, -0.02073069f, -0.06552860f, 
    0.03820255f, -0.06283055f, -0.12142025f, -0.00377038f, -0.03311174f, 0.12403002f, 0.03058061f, -0.21008281f, 
    0.04745753f, 0.03877796f, 0.06745571f, 0.18840511f, -0.02273236f, 0.02767244f, -0.26731321f, 0.05438185f, 
    -0.01805258f, 0.08458631f, -0.07646479f, -0.03367081f, -0.07108532f, 0.01589064f, -0.03675842f, -0.04395167f, 
    0.03038808f, -0.01790733f, 0.00811156f, 0.07988945f, -0.25327510f, -0.02483500f, 0.01802931f, 0.01260428f, 
    0.07219310f, 0.06356900f, 0.11655570f, 0.08031172f, -0.02984380f, 0.01994882f, -0.02833012f, -0.03778956f, 
    0.35894445f, 0.00050434f, -0.05223141f, 0.12569505f, 0.05531059f, 0.05908507f, -0.07940517f, 0.13901499f, 
    0.07485256f, 0.11154101f, -0.07696085f, 0.14125064f, -0.03893215f, 0.07051031f, -0.15252995f, -0.06073939f, 
    0.08193935f, -0.01651704f, 0.00940824f, 0.06480811f, -0.01035973f, 0.07070455f, -0.08577863f, -0.01335374f, 
    0.24647005f, 0.09411024f, 0.15918359f, 0.16157658f, 0.02861335f, -0.00534454f, -0.05134802f, 0.13399665f, 
    0.01335807f, -0.01134728f, -0.08283967f, -0.06901889f, 0.21763998f, 0.15738414f, -0.00206937f, 0.08345371f, 
    0.06612202f, -0.04120704f, 0.04007734f, 0.01885061f, 0.10124782f, 0.13761120f, -0.00801168f, -0.06463382f, 
    -0.04209672f, -0.08748086f, 0.08732227f, -0.03566522f, 0.01419965f, -0.01273514f, 0.03596289f, 0.03422133f, 
    -0.03136297f, 0.01563930f, -0.09085757f, 0.01124706f, -0.09541181f, 0.03513927f, 0.15297966f, 0.19797570f, 
    -0.06513017f, -0.01746607f, 0.14471798f, 0.17951134f, -0.01512645f, 0.11596039f, 0.09279079f, -0.00831395f, 
    0.10084137f, -0.00555367f, 0.06577928f, -0.06592114f, 0.08929851f, 0.06787973f, 0.04298231f, -0.04191556f, 
    0.01336349f, 0.03573907f, 0.04823274f, -0.05293259f, 0.11983542f, 0.07705872f, -0.04244471f, 0.06543760f, 
    0.02180484f, -0.06083289f, -0.00145905f, -0.09875844f, 0.00515572f, 0.07152736f, 0.00814187f, -0.07497089f, 
    0.12786867f, 0.06694812f, 0.01993017f, 0.00719671f, 0.03829545f, -0.00099108f, 0.04203935f, 0.08039190f, 
    0.07060604f, -0.12799563f, -0.06912955f, 0.03698124f, -0.03779035f, -0.12116905f, -0.03937536f, -0.11304120f, 
    0.13090236f, -0.06905113f, 0.00995034f, -0.04134523f, -0.10301952f, -0.03719724f, 0.11490419f, -0.02912207f, 
    0.17968836f, -0.10129747f, -0.06893238f, 0.12360223f, -0.02288214f, -0.06097146f, -0.06121026f, -0.00033268f, 
    -0.05675742f, 0.00166546f, -0.04037339f, -0.08844704f, 0.02470354f, -0.06833031f, 0.04845984f, -0.13574894f, 
    0.08595902f, 0.02720278f, -0.07962070f, 0.08861815f, -0.02763643f, 0.08883539f, 0.03857558f, -0.09648708f, 
    -0.04621578f, 0.19670366f, 0.16328758f, 0.15424106f, -0.04027639f, 0.04074020f, -0.01299664f, 0.19392915f, 
    0.04504739f, 0.08624220f, 0.02831935f, -0.11590168f, -0.06081019f, -0.05867518f, -0.20287670f, -0.07607631f, 
    0.12823531f, 0.03509565f, 0.04878142f, -0.00694169f, 0.00611990f, 0.01236061f, 0.03936761f, -0.12990636f, 
    -0.13068730f, -0.06632914f, -0.20674597f, -0.12209872f, 0.02646966f, -0.01311289f, -0.02831675f, 0.04848523f, 
    -0.00771866f, 0.12667924f, 0.01664602f, 0.06635220f, -0.06156857f, -0.13623002f, -0.20640717f, 0.06797710f, 
    0.05468986f, -0.08975640f, -0.05847839f, -0.02492370f, -0.02996610f, -0.04461646f, -0.03144125f, -0.01118118f, 
    0.06399429f, 0.06881491f, -0.08690038f, 0.06194373f, 0.00960773f, 0.00460320f, -0.00133595f, -0.10605067f, 
    -0.07476027f, 0.09711584f, 0.02698334f, 0.01436159f, -0.03192157f, 0.12852919f, 0.11042242f, 0.06123570f, 
    0.03416992f, 0.07489895f, 0.05660575f, 0.07806849f, 0.04606089f, 0.11904886f, -0.01874990f, -0.02344477f, 
    0.02518863f, 0.02976049f, 0.10864489f, 0.28804392f, 0.02106691f, -0.01639221f, 0.03436568f, -0.06349859f, 
    -0.07238482f, -0.00250252f, 0.02935943f, 0.07083482f, 0.22398348f, 0.13485938f, -0.12510288f, 0.01235267f, 
    0.01671720f, -0.01437230f, -0.02946967f, 0.00166538f, -0.05719722f, -0.03661183f, 0.01714325f, -0.00417062f, 
    0.20951514f, 0.06881904f, 0.07257291f, -0.05038344f, 0.02665129f, 0.01304030f, 0.00104257f, -0.02561014f, 
    0.06795812f, 0.01611569f, -0.00044881f, -0.07656841f, 0.03787357f, -0.06185427f, 0.04032812f, 0.01681768f, 
    0.01886817f, 0.00273171f, 0.05895582f, 0.03561395f, 0.02462961f, -0.04127300f, 0.06823083f, -0.04291410f, 
    -0.02639196f, 0.02348188f, 0.05880611f, -0.01288210f, -0.06083117f, 0.13409339f, 0.05173517f, 0.01501684f, 
    -0.06110353f, 0.02317702f, 0.03384318f, -0.08425733f, 0.27742088f, -0.02556936f, 0.11294272f, 0.07297494f, 
    -0.11146697f, 0.07987195f, -0.16777337f, 0.07093585f, -0.09561000f, -0.09086068f, 0.03235886f, -0.05479419f, 
    -0.00344155f, -0.00184433f, 0.06413618f, 0.17555913f, 0.02967819f, 0.00162661f, -0.03623810f, 0.10474630f, 
    -0.06499461f, -0.08007193f, 0.11647436f, 0.01974691f, -0.16930492f, 0.14679570f, -0.03419507f, 0.17175044f, 
    -0.00387802f, 0.02694670f, 0.04067053f, -0.01247411f, -0.04447987f, 0.12763594f, 0.03923104f, 0.09484591f, 
    0.16971175f, -0.05404041f, -0.15381458f, 0.02057374f, 0.02543216f, 0.02316660f, -0.00549296f, 0.07906507f, 
    -0.04040827f, -0.00799919f, 0.01603652f, -0.06071160f, 0.29679868f, 0.10375832f, 0.13529773f, 0.01839830f, 
    -0.07399902f, -0.06995149f, -0.09609826f, 0.05255254f, -0.02202514f, -0.15196306f, 0.06650733f, -0.02203285f, 
    -0.15801743f, -0.04055111f, -0.07224865f, 0.00631691f, 0.02644894f, -0.00675203f, -0.03880218f, -0.03933093f, 
    -0.00757644f, -0.04607714f, 0.04550368f, 0.06052995f, 0.16526000f, -0.04197554f, 0.09357327f, -0.13266706f, 
    -0.00021154f, 0.11623883f, 0.05864929f, 0.01239515f, 0.07637925f, 0.02897350f, -0.11137731f, 0.02757691f, 
    0.11747345f, 0.03087311f, -0.14593434f, -0.05715979f, -0.02742255f, 0.03655299f, -0.08816101f, -0.08424709f, 
    0.04243429f, -0.07897582f, 0.02642150f, -0.03534460f, 0.05457620f, -0.13964514f, 0.01456257f, -0.09825701f, 
    0.05559023f, 0.04714638f, -0.08121879f, 0.01981895f, 0.15409012f, 0.12190612f, 0.06549264f, 0.01452453f, 
    0.05054405f, 0.05214400f, -0.14364588f, 0.25912899f, -0.03166526f, -0.11053893f, 0.07156463f, 0.14947695f, 
    -0.06967326f, 0.01249706f, 0.00530550f, -0.02461358f, 0.08347414f, 0.04050478f, 0.01433998f, 0.01015646f, 
    -0.03909743f, 0.06945687f, 0.04357047f, -0.05392174f, -0.00784086f, 0.02716672f, -0.07177173f, -0.08811365f, 
    0.18767640f, -0.22831179f, 0.09215078f, -0.07796849f, 0.07281381f, -0.06174814f, -0.00443259f, -0.02913062f, 
    0.05206125f, -0.05499669f, -0.00925347f, 0.03744659f, -0.32722741f, 0.10386823f, 0.01978020f, 0.12315253f, 
    0.07618073f, 0.03811300f, -0.09590702f, -0.04303737f, 0.01356587f, 0.10116486f, -0.08627976f, -0.00037806f, 
    0.06166320f, -0.05813583f, -0.11144448f, -0.15653026f, -0.06573540f, -0.03737025f, -0.07461677f, -0.00216354f, 
    -0.00442074f, -0.01741461f, -0.05767575f, -0.11249202f, 0.10894257f, -0.01267037f, 0.15945005f, 0.11787139f, 
    0.00203448f, 0.08001851f, -0.02571112f, 0.05312435f, -0.03718216f, -0.04358044f, -0.00582691f, -0.03725768f, 
    -0.04710320f, -0.03250800f, 0.04436660f, 0.08106870f, -0.00768733f, -0.06834481f, -0.07407267f, -0.03490006f, 
    0.13805370f, -0.00309971f, -0.01632527f, 0.16331702f, -0.15776597f, -0.02189831f, -0.05283047f, -0.17399555f, 
    0.08920816f, 0.10567136f, 0.04733121f, -0.05197198f, 0.13538568f, -0.00243146f, -0.01687458f, -0.01962120f, 
    -0.17963313f, -0.11005536f, 0.09318422f, -0.13365760f, 0.03339547f, 0.06265086f, -0.08092079f, -0.00141983f, 
    -0.00420569f, 0.00435584f, 0.12905371f, 0.02377769f, -0.13253187f, 0.20304048f, -0.08959977f, 0.03567019f, 
    0.07437502f, 0.03404864f, 0.05648510f, 0.09035514f, 0.07131570f, 0.03706490f, 0.17509283f, -0.02930555f, 
    0.15676354f, -0.13085678f, -0.16210802f, -0.09497008f, 0.08377509f, -0.06635404f, -0.02710709f, -0.05057010f, 
    -0.00536499f, 0.05177108f, 0.00695405f, -0.11429640f, 0.12021931f, 0.07277700f, 0.15574589f, -0.02667881f, 
    -0.07566388f, 0.02728547f, 0.09144755f, 0.02431057f, 0.03347256f, 0.05167578f, 0.02986490f, -0.00413323f, 
    0.12231071f, 0.19054373f, -0.04369822f, -0.06267206f, -0.09141410f, 0.12146081f, 0.01367614f, 0.05463252f, 
    0.00513042f, 0.09101688f, 0.08484804f, -0.06257625f, -0.17497416f, 0.00802100f, -0.16875249f, -0.27014256f, 
    0.07757846f, -0.10936004f, 0.04506943f, -0.06672850f, -0.00374083f, 0.12771317f, -0.01160903f, 0.08119749f, 
    0.29500943f, -0.18078795f, 0.19642277f, -0.00545217f, 0.01398855f, -0.01089879f, -0.03964484f, 0.01916429f, 
    0.08851621f, -0.00422293f, 0.02718823f, 0.12497835f, -0.09724272f, -0.03448819f, -0.10962372f, -0.10794704f, 
    -0.07732926f, -0.02818036f, -0.06800060f, -0.03520710f, 0.04059517f, 0.04712048f, 0.00224435f, -0.05380458f, 
    -0.08453577f, 0.01193736f, -0.23758988f, -0.10458620f, 0.07319822f, -0.02346221f, -0.02936583f, 0.01411338f, 
    0.01601206f, 0.02619954f, -0.08048104f, 0.01864839f, 0.16443329f, -0.01847863f, -0.07040836f, 0.08402908f, 
    0.01078011f, -0.09925471f, -0.01633532f, 0.06899635f, -0.09731951f, -0.10676344f, 0.08663107f, 0.01412015f, 
    0.16117182f, 0.07005765f, -0.04668858f, 0.08094445f, 0.00981354f, 0.08955940f, 0.02402324f, 0.04410033f, 
    -0.15227677f, -0.06775305f, -0.07824751f, -0.00011228f, 0.22545330f, -0.00249377f, -0.00689910f, -0.15240626f, 
    -0.02800215f, 0.00957331f, -0.11000900f, -0.07190016f, 0.05940637f, 0.12190364f, 0.02054472f, 0.01444575f, 
    0.04702400f, 0.04433680f, -0.03683990f, 0.00108439f, -0.04533517f, -0.05035425f, 0.01749440f, -0.06197075f, 
    0.08365907f, 0.09826331f, 0.00043356f, 0.03359995f, -0.04585249f, 0.20878699f, -0.03457025f, 0.18977323f, 
    0.07001808f, -0.00524110f, 0.00148615f, -0.06155000f, 0.08537199f, -0.00502756f, 0.02446943f, 0.05167548f, 
    0.08542832f, 0.15939631f, -0.03572805f, 0.09380823f, 0.02415852f, 0.08975434f, 0.05616738f, -0.03725379f, 
    0.06492010f, -0.11499942f, 0.10040942f, 0.07812386f, -0.05563499f, 0.01153685f, -0.08720723f, 0.03303517f, 
    0.02296692f, -0.01771084f, -0.02840846f, 0.01707137f, 0.13654886f, -0.03301897f, -0.13457803f, -0.09292690f, 
    0.00746316f, -0.03621581f, -0.02179980f, 0.02278356f, -0.00055305f, 0.02258861f, -0.01198332f, -0.01544616f, 
    0.00008524f, -0.03556127f, -0.01663705f, -0.00899200f, 0.01419014f, -0.03544876f, 0.02135888f, -0.01997282f, 
    0.00081275f, 0.01855660f, 0.01010544f, 0.01888624f, -0.02669197f, -0.00671928f, -0.02779020f, -0.03376224f, 
    -0.00713155f, -0.00249046f, 0.01503995f, 0.01287153f, -0.01974223f, 0.02029755f, 0.00456699f, -0.03303700f, 
    0.01019915f, 0.00180558f, -0.00565518f, 0.01153856f, -0.03106802f, 0.01632516f, -0.00193420f, 0.01260587f, 
    -0.02046788f, -0.00608581f, 0.01095135f, 0.00419844f, 0.00161866f, -0.01957287f, -0.01273278f, -0.00077079f, 
    -0.01278722f, 0.00081260f, -0.03899207f, -0.04539377f, -0.03048608f, 0.00524516f, -0.04137719f, -0.01769009f, 
    0.00361297f, -0.03838997f, -0.01445551f, -0.00268911f, -0.04139255f, -0.02272384f, 0.02373534f, 0.00629191f, 
    0.00254679f, 0.02742426f, -0.01771676f, -0.03202623f, -0.00940667f, -0.03807521f, 0.00331192f, -0.03026776f, 
    0.01304211f, 0.01745458f, -0.01355764f, -0.02339744f, 0.01132815f, 0.00084860f, -0.00005190f, -0.02005924f, 
    -0.02565645f, -0.01295039f, -0.02483181f, 0.01495842f, -0.00274214f, 0.00921545f, 0.01975735f, -0.01780146f, 
    -0.00448536f, -0.03350520f, -0.03493026f, -0.03115967f, 0.01099978f, 0.01780526f, -0.04050883f, 0.02190822f, 
    -0.02486811f, 0.02133792f, -0.02607159f, 0.00110421f, 0.01143306f, -0.04143504f, 0.02614400f, 0.01592664f, 
    0.00834119f, 0.02747013f, -0.01928425f, -0.02110256f, -0.02328859f, 0.01777172f, -0.00622642f, -0.03337477f, 
    -0.04378706f, -0.03154255f, 0.00773741f, 0.00401561f, -0.01436360f, -0.01575727f, -0.00697726f, -0.01690064f, 
    0.00873877f, -0.01949551f, 0.01783535f, -0.01167646f, -0.02527631f, 0.02376019f, -0.00762433f, -0.00640214f, 
    0.02017738f, 0.02037737f, -0.01273273f, -0.01870997f, -0.00441493f, -0.01438673f, -0.00883375f, -0.00152326f, 
    0.01587125f, -0.01440359f, 0.02570394f, -0.00707654f, 0.02932938f, -0.00621336f, 0.01480912f, 0.02358347f, 
    0.02921785f, -0.00375632f, 0.00399249f, -0.01892455f, 0.00249196f, 0.02215371f, -0.01095262f, 0.01548375f, 
    -0.02937235f, 0.00826254f, -0.03247375f, -0.02321353f, -0.03427063f, 0.00448113f, 0.01674298f, -0.03497352f, 
    0.00045905f, -0.00398854f, -0.02413840f, -0.03205680f, -0.02064121f, 0.02132592f, 0.00628734f, 0.02728968f, 
    -0.00574932f, -0.03455941f, -0.04016311f, -0.02184307f, -0.01274372f, 0.02573637f, -0.01241829f, -0.00071335f, 
    -0.04320098f, -0.02859798f, -0.01996525f, -0.00339990f, 0.03094476f, -0.02063987f, -0.03883500f, 0.03006559f, 
    -0.01594772f, -0.00818270f, -0.01656183f, -0.01074257f, -0.00690292f, 0.00317753f, -0.03159490f, -0.03500053f, 
    -0.01781552f, -0.00580178f, 0.02710727f, -0.03520314f, 0.01645547f, -0.01232806f, 0.02033752f, 0.00125783f, 
    -0.03149281f, -0.00179266f, 0.00120608f, 0.01735207f, 0.02088577f, -0.01005930f, 0.02416549f, 0.01439711f, 
    -0.00042217f, -0.00892026f, -0.03601949f, 0.01003073f, 0.00992356f, 0.02067717f, -0.02269186f, -0.02156703f, 
    -0.03766550f, 0.02792712f, 0.00324102f, 0.01735568f, 0.01534137f, -0.00073437f, 0.00534891f, 0.02252465f, 
    -0.01290547f, 0.02287082f, -0.01834374f, -0.03061807f, -0.03098048f, 0.02562661f, -0.03605266f, 0.01182542f, 
    0.00003750f, 0.00121916f, -0.01899276f, -0.01211697f, 0.00194189f, 0.02890102f, 0.00722780f, -0.02259327f, 
    -0.00772982f, 0.02232018f, -0.03181595f, -0.00467629f, 0.01560305f, -0.04598890f, 0.01472517f, -0.04036809f, 
    -0.02374007f, -0.01463354f, -0.00935998f, 0.01857720f, 0.00369600f, -0.02564834f, 0.00483036f, 0.01131520f, 
    0.02340165f, -0.02231997f, -0.01212370f, 0.02113714f, 0.00372146f, -0.02876545f, -0.03646425f, -0.01971938f, 
    -0.02119810f, -0.00807049f, 0.00009893f, 0.02790230f, -0.00626831f, 0.02267588f, -0.03503786f, -0.03527394f, 
    0.00487316f, -0.03337391f, -0.00761928f, -0.01987460f, 0.01153007f, -0.03201247f, 0.00624699f, 0.01327641f, 
    0.01322304f, -0.03320370f, -0.00281269f, -0.01165440f, 0.02507667f, 0.02054447f, -0.02226643f, 0.01335390f, 
    0.02409537f, 0.02421780f, -0.00071058f, -0.03564059f, -0.02043498f, 0.02753201f, -0.03728667f, -0.00666235f, 
    -0.04371972f, 0.01033521f, 0.00972468f, 0.02187081f, -0.01662632f, -0.03109732f, -0.01935965f, -0.01024129f, 
    0.00648251f, 0.00135136f, 0.00572611f, -0.01434423f, 0.00160776f, -0.00327534f, -0.01677902f, -0.01705644f, 
    -0.00473590f, -0.01078677f, -0.04116257f, -0.00775827f, 0.02089371f, -0.01478708f, -0.04045524f, 0.00866288f, 
    -0.03001234f, -0.01777098f, 0.01830989f, -0.02753228f, 0.01595099f, -0.03195662f, -0.01019691f, -0.00422955f, 
    -0.04214995f, -0.03184018f, -0.04034030f, 0.02562417f, -0.00919733f, 0.02689624f, 0.01249871f, -0.04553321f, 
    -0.03669470f, -0.02997379f, -0.03674100f, -0.03021022f, 0.01187696f, 0.00969094f, -0.00285570f, 0.00727228f, 
    -0.00500778f, 0.01580620f, -0.00649040f, -0.00774896f, -0.02244734f, 0.01202042f, -0.00020661f, -0.02882127f, 
    0.01394096f, 0.00574801f, -0.04449826f, 0.00942289f, 0.02525985f, -0.01281658f, 0.01328256f, -0.02150202f, 
    -0.04118026f, -0.02864906f, 0.00694124f, -0.00592814f, -0.03870731f, 0.01073685f, 0.02103476f, 0.02344699f, 
    -0.02154929f, 0.01564268f, -0.03345926f, 0.00756128f, -0.03198764f, 0.01636673f, -0.03473217f, 0.01706684f, 
    -0.01082506f, -0.00640184f, 0.02930998f, -0.04245818f, 0.00379504f, -0.02971727f, -0.03678946f, 0.00874417f, 
    -0.00674358f, -0.04500529f, 0.02157790f, -0.01953323f, -0.00093586f, -0.04107416f, -0.01418902f, -0.02809709f, 
    0.02887934f, -0.02487803f, 0.01846812f, 0.03289225f, -0.01525755f, 0.02187871f, 0.00176565f, 0.01534326f, 
    -0.00006618f, 0.00464434f, 0.02490050f, 0.00782627f, -0.00077693f, 0.00190865f, -0.01258462f, -0.03746451f, 
    -0.00690759f, -0.04085022f, 0.00599894f, -0.00073900f, 0.00295541f, -0.02545430f, 0.00627458f, 0.01708217f, 
    -0.02069792f, -0.02790983f, -0.02437719f, -0.02000445f, -0.01387483f, 0.01540914f, 0.01097676f, -0.00055803f, 
    0.01306078f, -0.01099210f, 0.00569514f, -0.03198951f, -0.02513364f, -0.01111757f, -0.00630460f, 0.00077072f, 
    -0.01414015f, -0.03990727f, 0.00822471f, -0.03825180f, -0.04451193f, -0.00017415f, -0.00971979f, -0.01355555f, 
    -0.02023889f, 0.01607870f, -0.01399079f, 0.01342814f, -0.03091409f, -0.04008737f, -0.01995107f, 0.02261327f, 
    0.00847600f, -0.01186967f, -0.01462299f, -0.03229954f, -0.00298518f, -0.00067783f, 0.02022944f, -0.00813371f, 
    0.02071183f, 0.01364114f, 0.02340597f, 0.00777840f, 0.00195983f, -0.00913620f, 0.02235345f, -0.00945449f, 
    -0.03993410f, -0.02686246f, -0.01367366f, -0.01089518f, -0.00736817f, 0.00709058f, -0.01980225f, -0.03032906f, 
    -0.01663708f, -0.00411460f, -0.00051555f, -0.00363983f, -0.02568167f, 0.00418053f, -0.02655963f, -0.00586538f, 
    0.02667815f, -0.00344197f, 0.01943747f, -0.01864398f, -0.00762458f, -0.02084917f, -0.03026016f, 0.01061335f, 
    -0.03780206f, -0.04205554f, -0.02321791f, -0.04048251f, -0.03577056f, -0.01769259f, 0.00510676f, -0.02975081f, 
    -0.01285683f, -0.01156626f, 0.01715187f, -0.01992291f, -0.01963443f, -0.02285763f, 0.00329710f, -0.03250293f, 
    0.00508692f, -0.00138714f, -0.01580860f, 0.02009211f, -0.01693437f, 0.00118255f, -0.00382110f, -0.03899845f, 
    0.00541556f, -0.03533851f, 0.01281053f, 0.00095107f, 0.01135711f, 0.01023471f, -0.03626297f, -0.00173234f, 
    0.00117508f, 0.02174618f, -0.02705270f, -0.00094605f, -0.00725568f, -0.04146181f, -0.00290304f, 0.02746782f, 
    0.00052821f, 0.00837386f, -0.00537129f, -0.03115078f, -0.00456886f, 0.01777733f, 0.02020602f, 0.01587545f, 
    0.00794339f, 0.02132429f, 0.02494847f, -0.03821193f, 0.03067709f, -0.02383224f, -0.00667877f, -0.01941174f, 
    -0.02317237f, 0.00127231f, 0.00802048f, -0.00388021f, -0.02939527f, 0.01598615f, 0.01996906f, 0.00688932f, 
    -0.01290464f, 0.00881405f, -0.02822471f, -0.04342462f, 0.02330958f, -0.03993741f, -0.01649564f, -0.02830772f, 
    -0.00653102f, -0.01602545f, 0.02477797f, 0.00711596f, -0.00923730f, 0.02481464f, -0.01444718f, -0.00079165f, 
    -0.02308249f, 0.02427045f, 0.01427648f, -0.02320988f, 0.00011573f, 0.00084154f, -0.00593121f, -0.03682943f, 
    -0.01467617f, -0.02634731f, 0.00094406f, -0.03257416f, 0.02436535f, 0.00133756f, 0.01372376f, -0.00405147f, 
    0.02087642f, 0.00050723f, -0.00466375f, -0.03482267f, 0.00253554f, -0.00433127f, -0.00954419f, -0.02164421f, 
    -0.00405619f, 0.02375596f, 0.01787445f, 0.00294695f, -0.03849196f, 0.01869825f, 0.01917860f, -0.03928439f, 
    -0.01250433f, 0.01887856f, -0.03424588f, -0.03244692f, 0.01720488f, -0.00715012f, 0.01164891f, -0.00154573f, 
    -0.03844832f, -0.00839022f, -0.00427550f, 0.01304198f, 0.00443827f, -0.02248327f, -0.00490508f, 0.01459707f, 
    -0.04107519f, -0.01047308f, -0.02293052f, 0.01989782f, -0.01364949f, 0.02568255f, 0.02328884f, 0.00224701f, 
    -0.00335640f, -0.02291626f, -0.02916475f, -0.01224066f, -0.03197479f, 0.01308431f, -0.03694320f, -0.02659701f, 
    0.02666421f, 0.00048631f, -0.01815942f, -0.02494012f, -0.00969742f, 0.01838739f, -0.01587276f, -0.03093067f, 
    -0.00290652f, -0.02798261f, 0.01057833f, -0.00273829f, 0.01733528f, 0.01359590f, -0.03866414f, -0.00415068f, 
    0.02931820f, 0.00224149f, 0.00496248f, -0.01255435f, 0.00760823f, 0.03658435f, -0.00438302f, -0.00398238f, 
    -0.03497333f, -0.01521123f, -0.01138836f, -0.04630341f, 0.01160450f, -0.02583356f, -0.01619687f, 0.01874681f, 
    0.00274201f, -0.01538900f, 0.00164521f, -0.01774560f, -0.03271218f, 0.01547735f, -0.00444568f, -0.00112501f, 
    -0.00883070f, -0.00981896f, 0.02382275f, -0.00954952f, 0.02588320f, 0.00017691f, -0.03406856f, -0.01925703f, 
    0.01438042f, -0.02305963f, -0.02337571f, -0.02494890f, 0.00597938f, -0.01237557f, 0.01839358f, -0.01898916f, 
    -0.00373142f, -0.01879492f, 0.02372313f, 0.02177989f, -0.04228418f, 0.03011548f, 0.02292855f, 0.01062458f, 
    -0.03385273f, -0.04401313f, -0.01166030f, 0.01849886f, -0.01886726f, 0.01684344f, -0.00080973f, 0.01158506f, 
    0.02305977f, -0.03757713f, 0.02162046f, 0.02042030f, -0.01585516f, -0.03622797f, -0.03641433f, -0.01430634f, 
    0.01530858f, -0.02979073f, -0.01503970f, 0.01179893f, -0.02776022f, -0.03553576f, -0.00546008f, -0.03449640f, 
    0.00214130f, -0.01143563f, -0.04125973f, -0.00777422f, -0.00798864f, -0.01099806f, -0.02157820f, -0.00627860f, 
    -0.01703084f, 0.02528938f, 0.02686523f, 0.00740952f, -0.00603407f, 0.00394192f, -0.01128902f, -0.01912625f, 
    0.01619297f, 0.00726721f, 0.01850163f, 0.02767944f, -0.04696116f, -0.00249360f, 0.01922088f, -0.01252627f, 
    0.01065878f, 0.00643458f, 0.00250755f, -0.01979692f, -0.00713909f, 0.01398824f, 0.00638364f, -0.02405618f, 
    -0.00377346f, 0.01642793f, 0.02191645f, -0.03405199f, -0.03468858f, -0.02265405f, -0.00444873f, -0.03110641f, 
    -0.00779034f, 0.00466495f, -0.00693804f, 0.02372667f, 0.02396160f, -0.00384575f, -0.03481925f, -0.01317968f, 
    -0.06637722f, 0.08643667f, 0.03728384f, 0.09780518f, 0.08874828f, -0.02555228f, 0.00397270f, 0.10293125f, 
    0.00280760f, 0.03137848f, 0.00480209f, 0.00309690f, 0.03656786f, -0.08277273f, -0.02907220f, 0.14017701f, 
    0.10140639f, 0.03426493f, 0.18848071f, 0.03955318f, 0.05222743f, 0.09783346f, 0.11349015f, -0.01167601f, 
    0.22089352f, -0.19823903f, -0.03161171f, 0.08446316f, -0.14568134f, 0.07671724f, 0.07513866f, -0.03895755f, 
    0.05950698f, 0.09046135f, 0.00919624f, -0.02925140f, 0.24480133f, -0.17666608f, 0.12182309f, -0.07326522f, 
    0.05412921f, 0.09676381f, 0.13620898f, -0.02891151f, -0.07389047f, -0.06409585f, 0.05464425f, 0.04384485f, 
    -0.05585641f, 0.14724506f, -0.00247713f, 0.18931596f, 0.01689561f, 0.05524821f, -0.01547998f, 0.03785709f, 
    0.16307187f, -0.03660673f, 0.05892808f, 0.04616092f, -0.39417529f, 0.23083267f, -0.09444739f, -0.11247087f, 
    0.19160131f, -0.06196028f, -0.07947819f, 0.11187021f, 0.02245231f, 0.02722739f, -0.12539446f, 0.00446642f, 
    -0.38743502f, 0.01789279f, 0.05596491f, -0.20771922f, 0.02074771f, 0.12044033f, 0.01069956f, -0.01925140f, 
    -0.11067960f, 0.01474137f, -0.05444009f, 0.06539392f, -0.14152893f, 0.19864485f, -0.02463088f, 0.02142646f, 
    -0.00098522f, 0.02120796f, -0.03835318f, 0.18634349f, -0.02934719f, -0.08088166f, 0.02452684f, -0.00292562f, 
    0.00600772f, -0.04883924f, -0.07788264f, -0.00356571f, -0.00637272f, 0.04042755f, 0.03795714f, 0.02578568f, 
    0.01657200f, 0.00090117f, 0.12829329f, -0.09635135f, 0.04296137f, 0.02027256f, -0.11739603f, -0.09727598f, 
    0.10009113f, -0.00143683f, 0.02199859f, 0.08151383f, 0.12900722f, 0.05359546f, -0.07949599f, 0.03194436f, 
    0.13335440f, 0.00457079f, 0.00629849f, -0.01470327f, -0.01704366f, 0.02038646f, 0.07289110f, 0.01259475f, 
    -0.01470481f, -0.02732303f, 0.04592843f, 0.03398399f, 0.03520725f, -0.04760617f, -0.12823093f, 0.28233111f, 
    0.12360972f, 0.07470028f, -0.07690467f, -0.06721422f, 0.08284140f, 0.01085330f, 0.01784957f, -0.00739917f, 
    -0.17648672f, -0.15726613f, 0.14315808f, -0.05035035f, -0.01209318f, 0.01463176f, 0.05559547f, -0.00597925f, 
    0.00940047f, -0.09477998f, 0.02970121f, 0.03292625f, -0.05306260f, -0.00709036f, -0.01101508f, 0.04693418f, 
    -0.05563533f, 0.00910781f, 0.05657401f, 0.10560908f, -0.02670706f, -0.05142379f, -0.00760141f, 0.01072849f, 
    0.15339671f, 0.04405914f, 0.13294646f, 0.10088204f, 0.05349145f, 0.05321197f, 0.01082862f, 0.00802568f, 
    0.07947511f, -0.06664503f, 0.01563580f, 0.02682492f, -0.06476054f, 0.16307774f, -0.15706119f, 0.04828282f, 
    0.16314739f, 0.03258263f, -0.01243468f, 0.02923221f, 0.01509625f, 0.05492099f, 0.02839740f, -0.05334407f, 
    0.04595968f, -0.14590847f, -0.05798361f, 0.03723297f, 0.00802877f, 0.01681814f, -0.06731983f, 0.18061800f, 
    -0.02410859f, -0.05073118f, 0.00036416f, -0.00156233f, -0.00137127f, 0.05516162f, 0.10946126f, 0.05658163f, 
    0.17355105f, 0.00288076f, 0.13108496f, -0.01555146f, -0.00206507f, -0.05990152f, 0.00093643f, 0.03843231f, 
    0.05876483f, 0.02793837f, -0.02986014f, -0.00299193f, -0.04613670f, 0.07727730f, -0.04288283f, 0.06730741f, 
    0.03207009f, 0.04447007f, 0.06015580f, 0.07657575f, 0.04125295f, -0.06279931f, -0.05018675f, 0.01405699f, 
    0.09521430f, 0.04289226f, 0.00565716f, 0.05738070f, 0.01054627f, 0.03332971f, -0.05102159f, -0.06254396f, 
    -0.07334388f, 0.07311638f, -0.02483264f, 0.13896890f, 0.10656393f, 0.05385689f, 0.06794051f, 0.12452583f, 
    0.02592441f, 0.04409130f, 0.00401359f, -0.00619216f, -0.07575855f, 0.08254169f, -0.06607226f, -0.15929420f, 
    0.08644785f, -0.05642534f, 0.06677938f, -0.03570902f, 0.03189326f, -0.02573123f, -0.03684626f, 0.05005437f, 
    -0.09795322f, -0.23513538f, 0.08995445f, -0.05157473f, 0.08885236f, -0.08266296f, 0.06932315f, 0.00851583f, 
    0.03297126f, 0.01976136f, 0.05319134f, 0.07455540f, 0.02027573f, -0.01845482f, -0.05451052f, -0.22639880f, 
    0.17886296f, 0.01240240f, 0.12763883f, 0.06870531f, 0.04704238f, 0.05989705f, -0.08422705f, 0.20999219f, 
    -0.16548394f, -0.16971226f, 0.13343884f, 0.22246109f, 0.05390256f, -0.01852916f, 0.10112905f, -0.01392248f, 
    0.00067924f, 0.00055049f, -0.03217896f, 0.05687233f, -0.13201503f, -0.22731726f, 0.28152955f, 0.11455227f, 
    -0.00933516f, -0.02237235f, 0.12622704f, -0.01107346f, -0.00011327f, 0.00857850f, -0.05817311f, -0.00511579f, 
    0.08294314f, -0.05179717f, -0.10881805f, 0.20982327f, 0.10895316f, -0.05692020f, -0.02669000f, 0.01421005f, 
    0.01027542f, -0.08267497f, 0.01834577f, -0.01683516f, 0.29064670f, -0.15606736f, -0.07872798f, 0.19642557f, 
    0.02857247f, -0.08348352f, 0.05508018f, 0.01819256f, 0.00170689f, -0.01900843f, 0.00260076f, 0.07289747f, 
    -0.16240062f, -0.10846182f, -0.02567013f, 0.03660329f, 0.22271796f, -0.06502048f, -0.04299111f, 0.05899215f, 
    0.03844528f, 0.10515290f, -0.00189331f, 0.02612405f, 0.26314303f, -0.04704026f, 0.00035160f, 0.09542339f, 
    0.07656826f, -0.04483900f, 0.05444668f, 0.05514967f, 0.08637549f, 0.07751847f, -0.00806966f, 0.10062346f, 
    -0.03862176f, 0.07555472f, -0.09133840f, -0.00658114f, 0.11759921f, 0.02833428f, 0.11454031f, 0.04992680f, 
    0.06470802f, 0.08106668f, -0.02763984f, -0.02440031f, 0.02359292f, -0.06874062f, 0.12571825f, 0.20907445f, 
    -0.00495817f, 0.00626513f, -0.05038246f, -0.11108997f, 0.03990019f, 0.10619595f, 0.00756193f, 0.04080841f, 
    -0.09963248f, 0.18669833f, -0.19801044f, 0.03369216f, -0.03851555f, 0.08946431f, -0.00050813f, 0.02892104f, 
    0.00687691f, -0.08727328f, -0.07800629f, -0.03266972f, -0.50766438f, 0.32739490f, -0.22040613f, 0.01674372f, 
    0.09177359f, 0.05156072f, 0.00680719f, 0.00838485f, 0.00734212f, 0.02833110f, 0.01858556f, -0.07039124f, 
    0.01106302f, -0.11732909f, -0.14397043f, -0.11895674f, 0.06853803f, 0.03062550f, 0.00164955f, 0.03050494f, 
    0.06445297f, -0.00817402f, 0.05926188f, 0.04166471f, 0.03890330f, -0.05226268f, -0.02144073f, -0.11003402f, 
    0.03068619f, -0.08552750f, -0.02224150f, -0.00681182f, 0.09690357f, 0.05627498f, 0.13098447f, 0.04407357f, 
    -0.17920332f, 0.11506768f, 0.00530819f, -0.15212056f, 0.14128327f, -0.03334358f, -0.02629907f, 0.06953067f, 
    0.03736260f, 0.02463515f, -0.01435035f, 0.03449077f, 0.13726355f, -0.01458579f, 0.01823790f, 0.14599489f, 
    0.08981154f, 0.09153607f, 0.06169735f, 0.03658255f, -0.01864126f, 0.02000159f, 0.04671548f, 0.05055748f, 
    0.10952120f, 0.17144588f, 0.12399143f, 0.04692334f, -0.14670627f, -0.09849104f, -0.04962327f, -0.02742691f, 
    0.04111047f, 0.04655041f, -0.02301967f, 0.09364361f, -0.10701109f, -0.11288669f, 0.12075447f, -0.05838824f, 
    0.09348157f, 0.07523839f, 0.04441775f, 0.02820119f, 0.04746989f, 0.01672959f, 0.02407461f, -0.01568614f, 
    0.18010703f, -0.02118760f, -0.11847302f, 0.20141779f, 0.03629901f, -0.03174299f, 0.11039134f, 0.06555329f, 
    0.09416320f, -0.10621825f, 0.10697690f, -0.04152203f, 0.04908681f, 0.13768904f, -0.08053660f, 0.12176491f, 
    0.04088495f, -0.07874047f, 0.06964821f, 0.09606352f, -0.03224883f, -0.00921932f, -0.03006222f, 0.06302500f, 
    -0.05766794f, -0.00427864f, 0.07746328f, -0.06182563f, 0.11264643f, 0.04213750f, 0.07916679f, -0.00282927f, 
    0.03913797f, 0.01848657f, 0.05693803f, 0.13019046f, -0.04389148f, 0.08386376f, 0.12686078f, -0.01553668f, 
    0.15930891f, 0.01871509f, 0.05780043f, 0.04920746f, -0.03424752f, 0.11984384f, 0.11384609f, 0.17961992f, 
    -0.24805465f, 0.01555800f, 0.09596881f, -0.19780475f, -0.02177704f, 0.05737380f, 0.02467175f, -0.09853976f, 
    0.08714388f, -0.04743313f, 0.01068120f, -0.00329955f, 0.17815816f, -0.09314835f, 0.06405880f, 0.08212667f, 
    0.00653394f, 0.00490387f, 0.04715467f, 0.11864811f, 0.09701465f, 0.10520174f, -0.00463497f, 0.02427246f, 
    -0.15382014f, -0.01574025f, -0.07113909f, 0.15574311f, 0.08572124f, 0.04319266f, -0.05932108f, -0.02685833f, 
    0.08895455f, -0.02766573f, 0.08738267f, -0.01055797f, -0.20302460f, 0.04681274f, 0.00490817f, -0.15789595f, 
    0.09606732f, 0.10772470f, -0.01504588f, 0.06224936f, 0.07783026f, 0.06011271f, -0.02832656f, 0.18918444f, 
    -0.26900923f, 0.12566848f, 0.25239083f, 0.00186273f, -0.04907446f, 0.01601115f, -0.00098868f, -0.05876470f, 
    0.00245781f, 0.11446095f, -0.03707935f, 0.13405849f, -0.08255692f, 0.09169541f, -0.08266862f, -0.02584047f, 
    0.14379713f, 0.09099860f, 0.02913335f, -0.09572111f, -0.03425075f, 0.03763479f, 0.10338365f, 0.07497536f, 
    0.06686926f, 0.01844227f, 0.05032266f, -0.17140883f, 0.07277212f, -0.01424697f, 0.07427099f, 0.04304157f, 
    0.02278927f, 0.03971832f, -0.00508112f, 0.11430013f, 0.11797865f, -0.09538008f, -0.08484560f, 0.09502808f, 
    0.05043784f, 0.11979468f, 0.05418712f, 0.03732858f, 0.04621985f, 0.04392866f, 0.00824846f, 0.01334560f, 
    0.17731676f, -0.09942594f, -0.09869400f, 0.06270715f, -0.06429245f, 0.10091183f, 0.05437780f, -0.04957828f, 
    -0.03368409f, -0.06709351f, -0.01274178f, 0.06726114f, -0.35598850f, 0.37375841f, 0.01912089f, -0.15215881f, 
    0.10035749f, 0.00161546f, -0.01075872f, 0.03161930f, -0.05240570f, -0.02361469f, -0.04622821f, 0.02389391f, 
    -0.08749281f, -0.20015320f, 0.13653392f, -0.04839351f, -0.01829637f, -0.01221805f, 0.10121021f, 0.03575951f, 
    0.00752064f, -0.00251359f, 0.00634421f, -0.00802394f, -0.09305707f, 0.23661025f, 0.00704391f, -0.24199581f, 
    0.02377583f, -0.02182665f, 0.01376525f, 0.04402879f, 0.05451133f, -0.04493718f, -0.08220720f, 0.02287110f, 
    -0.20942616f, 0.03487677f, -0.03356887f, -0.20273361f, 0.07998074f, 0.00779456f, 0.06705719f, 0.00552920f, 
    -0.01373879f, 0.02280732f, -0.03440481f, 0.06983121f, 0.17598495f, -0.00029934f, -0.06705663f, 0.07366863f, 
    -0.09630317f, -0.03523731f, 0.02529328f, 0.02945560f, 0.03069284f, -0.02464705f, 0.10049644f, 0.09756716f, 
    0.05017230f, -0.10136086f, 0.09829225f, 0.06940258f, 0.06451643f, -0.02388556f, 0.01060910f, 0.06019977f, 
    0.02648859f, 0.09533474f, 0.10506380f, 0.05568454f, -0.06059439f, 0.10994624f, 0.38072202f, 0.00121693f, 
    -0.08002514f, 0.07127053f, -0.04297140f, -0.04574413f, -0.03003515f, -0.03668487f, -0.00717348f, 0.12791117f, 
    -0.01825586f, -0.11532377f, 0.06227076f, -0.03246833f, 0.10012896f, -0.05586362f, 0.08990501f, -0.06164341f, 
    0.01213064f, -0.01510200f, 0.00286888f, -0.15711068f, -0.20228270f, -0.09307658f, 0.08864607f, 0.05601307f, 
    -0.00637805f, 0.03070448f, 0.06330278f, 0.05765567f, 0.17349188f, 0.08158094f, 0.11740852f, -0.00042944f, 
    -0.05126414f, -0.12376539f, 0.18126117f, -0.06861465f, -0.07186539f, 0.05496265f, 0.06201737f, 0.03067324f, 
    -0.02470215f, -0.01748838f, -0.02156879f, 0.12696850f, 0.00513260f, 0.10728374f, 0.11795335f, 0.03808648f, 
    -0.05682751f, -0.02233226f, -0.06342247f, 0.00446720f, -0.02524227f, 0.00985873f, 0.03004510f, 0.13066618f, 
    0.08918502f, 0.03182339f, 0.07324994f, 0.19530167f, -0.03307122f, -0.11521591f, -0.09727202f, 0.03784628f, 
    0.07799179f, -0.04696679f, -0.02037806f, 0.04474521f, -0.12952453f, 0.15870376f, 0.03141205f, -0.13772087f, 
    0.06533982f, -0.06430774f, 0.06797786f, 0.06702920f, 0.02691297f, 0.09555305f, -0.04200143f, 0.01020763f, 
    0.49293754f, -0.08512276f, -0.08449443f, 0.14006817f, 0.17698491f, 0.05069286f, -0.00349775f, -0.03807377f, 
    -0.09640986f, 0.14492488f, 0.05502167f, 0.09788454f, -0.06400202f, 0.10442055f, 0.11127504f, 0.07301332f, 
    -0.07088780f, 0.00511946f, 0.06142458f, 0.13266730f, 0.09100857f, -0.06435825f, 0.05667640f, 0.06645161f, 
    -0.34264022f, 0.04699593f, 0.08138612f, 0.05821918f, 0.09192813f, -0.01459134f, -0.14806786f, 0.10271051f, 
    -0.04774104f, 0.03796481f, -0.03132686f, 0.01211579f, 0.15604076f, -0.17177480f, 0.14043730f, -0.14332849f, 
    -0.10199662f, -0.03131180f, -0.11154854f, 0.13231863f, 0.03741029f, 0.14243189f, 0.06811000f, 0.01761328f, 
    0.23983161f, 0.08848433f, -0.18421999f, -0.25978532f, 0.01272514f, 0.06038159f, -0.03306079f, 0.04607899f, 
    -0.05604176f, 0.10931428f, -0.03227009f, -0.01490620f, 0.19498365f, -0.15866551f, 0.09904942f, 0.20736897f, 
    -0.01785986f, -0.01735742f, 0.02699766f, -0.05209702f, -0.17818739f, 0.02541431f, 0.07843355f, 0.07485335f, 
    -0.13425744f, 0.16932908f, 0.11888737f, -0.13716125f, -0.02967458f, -0.14446384f, 0.07746885f, 0.07601580f, 
    0.03769994f, 0.08740684f, 0.12613401f, -0.06548207f, 0.06251214f, 0.12384681f, 0.11994426f, -0.09300851f, 
    0.00941322f, 0.08906543f, 0.04243788f, -0.08169188f, -0.02414153f, 0.05288511f, 0.02760682f, -0.02446190f, 
    0.12071974f, -0.04691336f, 0.07176553f, 0.21271303f, -0.06313039f, -0.08950265f, 0.02819410f, 0.02326337f, 
    0.01579407f, -0.00921325f, 0.09857264f, 0.03247251f, -0.07268296f, -0.14865419f, -0.08142427f, -0.03708654f, 
    0.03131104f, -0.01363422f, -0.17701797f, 0.07054742f, -0.10469878f, 0.05758971f, -0.02243460f, 0.09360764f, 
    -0.13421349f, 0.23018998f, 0.24547051f, -0.07052755f, -0.04167807f, -0.06481089f, 0.00777926f, 0.05955735f, 
    0.01689780f, -0.05382382f, 0.12566757f, -0.10335074f, -0.03852684f, -0.10843924f, 0.09916469f, 0.32253253f, 
    -0.09627168f, 0.03734184f, -0.01292015f, 0.06507587f, -0.00324780f, -0.01419544f, -0.06275068f, 0.01580094f, 
    -0.10149854f, -0.02403475f, 0.15806587f, -0.26175874f, -0.04780266f, 0.08841493f, -0.02468649f, -0.06706955f, 
    0.03962591f, 0.04873241f, 0.09120982f, 0.01348727f, 0.73005587f, -0.22123663f, 0.05855643f, 0.03759434f, 
    -0.12771748f, 0.09729584f, 0.01049614f, 0.06145906f, -0.04278671f, -0.00056821f, 0.13599759f, -0.14041993f, 
    0.23807950f, -0.06493548f, -0.04020214f, -0.18956904f, 0.14383754f, -0.09531555f, -0.07535789f, 0.00167440f, 
    -0.06382287f, -0.03563470f, -0.03210898f, -0.01364939f, 0.02201428f, 0.17734513f, -0.04384758f, -0.04338909f, 
    0.09796365f, 0.05062995f, -0.00428981f, -0.06753094f, 0.02673053f, -0.12063358f, 0.01332741f, 0.19791721f, 
    -0.12784541f, -0.07656514f, 0.03799940f, -0.03398506f, 0.14335190f, 0.11131111f, -0.04383664f, 0.06965133f, 
    0.06433305f, -0.03391211f, 0.04122281f, -0.05135996f, 0.22653723f, -0.12689947f, -0.01161025f, 0.20002893f, 
    -0.01443840f, -0.04607443f, -0.02390942f, -0.04803972f, 0.02385424f, 0.00871231f, 0.08598050f, 0.04589134f, 
    0.16356440f, -0.14752296f, 0.07476203f, 0.24202438f, -0.06474265f, -0.12622654f, -0.00687410f, 0.13083304f, 
    -0.01825304f, -0.08861119f, 0.03069989f, -0.05039744f, -0.09774125f, 0.23688895f, -0.03710829f, 0.15249215f, 
    0.16769001f, -0.04624925f, 0.01425918f, 0.01674930f, 0.01778200f, -0.01859512f, 0.07562360f, 0.06466074f, 
    -0.28515938f, 0.23582849f, 0.01060809f, -0.09375547f, 0.00084221f, 0.20148844f, -0.06964678f, -0.04634051f, 
    0.04781318f, -0.02649704f, -0.00002460f, -0.07894880f, -0.06718742f, 0.11153586f, -0.09484965f, 0.09450181f, 
    0.15047231f, -0.09059276f, -0.04301867f, -0.06620036f, 0.11823145f, -0.04373230f, -0.05523929f, 0.05809513f, 
    -0.16896270f, 0.17264652f, 0.02145011f, -0.08564658f, -0.08631758f, 0.08677576f, 0.06807950f, 0.01289743f, 
    -0.03903950f, -0.03467717f, 0.10960552f, 0.17680977f, -0.07991993f, -0.05395022f, 0.12215261f, 0.01159018f, 
    -0.05959015f, 0.05801168f, -0.00865692f, 0.01486002f, -0.04976642f, -0.05440038f, -0.05335463f, 0.03958049f, 
    -0.19420676f, -0.00803275f, 0.09183524f, 0.18792129f, -0.05665771f, 0.09346804f, -0.08645546f, -0.00189588f, 
    -0.04134549f, 0.03030823f, 0.01641997f, 0.00615149f, -0.23651041f, -0.11498646f, -0.10161140f, -0.02783929f, 
    0.03120064f, -0.05209811f, -0.05554598f, 0.06921148f, 0.00604961f, -0.01063764f, 0.03762238f, 0.04065701f, 
    0.26108918f, -0.13030094f, 0.01463116f, 0.02594147f, -0.03270501f, -0.02565736f, 0.04357946f, 0.08907256f, 
    0.00538598f, 0.02761714f, -0.11966420f, 0.03303608f, 0.13940248f, -0.03310968f, 0.07656837f, -0.16859618f, 
    0.07045107f, 0.02896647f, 0.04578674f, -0.05197353f, 0.07169260f, 0.01970113f, 0.02734337f, 0.07535874f, 
    0.12886353f, -0.17371462f, 0.16305597f, 0.11327806f, -0.01903378f, 0.03766313f, -0.06512871f, -0.08305085f, 
    0.02244116f, -0.05028009f, 0.08395208f, 0.08757051f, -0.05318823f, 0.13523164f, 0.01542698f, -0.09407310f, 
    0.08844778f, -0.07989705f, 0.02924235f, 0.02331688f, 0.09505955f, 0.03738815f, 0.11300831f, 0.06990086f, 
    0.06437365f, -0.04733003f, -0.05054920f, 0.26088911f, -0.06857818f, -0.08863718f, 0.00816969f, 0.00623922f, 
    0.11319402f, -0.04819944f, -0.05093284f, 0.01885309f, 0.36391222f, -0.23552847f, 0.01232079f, 0.13979606f, 
    -0.04892492f, -0.04947481f, 0.01024062f, 0.04763355f, 0.05275728f, -0.03507978f, 0.01905654f, 0.05647797f, 
    0.06375866f, 0.02883772f, 0.11314965f, 0.14652592f, 0.03930792f, 0.04395740f, -0.03338662f, -0.10336421f, 
    0.03923582f, -0.00578113f, -0.05085918f, 0.09528340f, 0.12435826f, 0.10631192f, -0.12336078f, 0.07435409f, 
    -0.03372670f, -0.07384057f, 0.05863730f, 0.13804524f, 0.01941539f, 0.01710700f, -0.08142411f, 0.06437580f, 
    -0.04661022f, 0.06703796f, -0.03221352f, 0.05068507f, 0.09687861f, 0.06433029f, 0.02437921f, -0.07494495f, 
    0.06355249f, 0.08706872f, 0.00666148f, 0.04955011f, -0.11488363f, -0.12674882f, 0.13850133f, -0.19382106f, 
    0.02822833f, 0.04395017f, 0.04332180f, 0.06025256f, 0.04587856f, -0.04200888f, 0.06045947f, 0.07983486f, 
    -0.39823243f, 0.03824275f, 0.00594056f, -0.05557302f, 0.05236301f, 0.14109689f, 0.12762198f, -0.01408939f, 
    -0.04810468f, 0.06460731f, 0.02098697f, -0.01048956f, 0.13308431f, 0.12434977f, 0.05698578f, 0.00762364f, 
    -0.06921713f, 0.16335924f, 0.14179875f, 0.00377186f, -0.02895566f, -0.06065115f, 0.06210953f, -0.01355537f, 
    -0.15386920f, -0.08824424f, -0.22280775f, 0.03281239f, -0.06742584f, 0.01273738f, -0.04735304f, 0.03416651f, 
    -0.06302952f, -0.04990399f, 0.01735830f, 0.09210085f, 0.33695900f, 0.03135465f, 0.13511187f, -0.29521930f, 
    -0.05524709f, 0.06513990f, 0.07561126f, 0.01408661f, -0.01818517f, 0.07336242f, 0.01938382f, 0.07610217f, 
    0.02357108f, 0.13848245f, 0.03984065f, -0.09930494f, 0.02472170f, 0.10070971f, 0.13577779f, -0.00707315f, 
    -0.00031684f, -0.04650757f, -0.01117785f, -0.05730916f, -0.22475319f, 0.35679036f, -0.27110437f, -0.10562210f, 
    0.07611636f, 0.10351533f, -0.02335817f, 0.06504013f, 0.05281780f, -0.08255794f, 0.07127075f, -0.04924663f, 
    -0.13663462f, -0.00406688f, 0.15238883f, -0.03886993f, 0.12031875f, 0.02741638f, 0.02607077f, 0.04398181f, 
    -0.08789577f, -0.01076157f, 0.05698950f, -0.00608513f, -0.09748045f, 0.13329446f, 0.24904622f, 0.05518072f, 
    0.05365579f, -0.06583126f, 0.03904638f, 0.05907219f, -0.10848372f, -0.07279555f, -0.03679938f, -0.07669659f, 
    -0.19077151f, 0.04549165f, 0.11218301f, -0.03929928f, 0.07046326f, -0.05257883f, -0.10541137f, 0.01773054f, 
    0.08534794f, 0.01381412f, 0.03106918f, 0.14237021f, -0.14683247f, 0.00107426f, 0.03037439f, 0.00056210f, 
    0.02107484f, -0.05065815f, -0.01647818f, -0.07523955f, 0.00368952f, 0.03859296f, 0.05381465f, -0.00287541f, 
    0.30569950f, 0.15866160f, 0.06055307f, -0.00914597f, -0.02811646f, -0.02444790f, 0.07237177f, 0.02314720f, 
    -0.02853578f, -0.05556584f, 0.02173872f, 0.13824846f, 0.09218699f, 0.01178388f, 0.01602424f, 0.08685354f, 
    -0.00982407f, -0.07286821f, 0.12165926f, 0.00526928f, 0.13574897f, -0.04566254f, 0.04132655f, 0.02728233f, 
    -0.30200669f, 0.07897473f, 0.05669595f, 0.05476946f, 0.08961470f, 0.12652180f, 0.04644802f, -0.10656300f, 
    -0.02937184f, -0.05145184f, 0.00485853f, -0.06354006f, -0.02706697f, -0.17766467f, 0.20647648f, 0.06890978f, 
    0.04494957f, 0.02911423f, -0.06451670f, 0.08883037f, -0.05665604f, 0.00363922f, 0.03482333f, 0.19780912f, 
    0.03439555f, -0.15966345f, 0.06102843f, 0.02523310f, 0.08545650f, 0.09642935f, 0.02453346f, 0.06749166f, 
    0.00421791f, 0.07273951f, -0.08177059f, 0.14822035f, -0.02124694f, 0.14995886f, -0.01180323f, -0.15410219f, 
    0.23945510f, 0.06850634f, -0.04096000f, 0.03655685f, -0.00913674f, -0.07362358f, 0.06937833f, -0.02749195f, 
    0.10578872f, -0.27903152f, -0.23541859f, 0.02596531f, 0.05315649f, -0.01970916f, -0.13622560f, 0.04044292f, 
    0.09372933f, 0.02533120f, -0.08480711f, -0.00019364f, -0.08966023f, 0.07526663f, -0.05893939f, 0.17508496f, 
    0.07424984f, 0.05154853f, -0.01249086f, 0.03062228f, -0.10866394f, -0.03771227f, 0.07953890f, -0.07586128f, 
    -0.31176227f, -0.00828617f, 0.09218217f, 0.00483127f, 0.13046472f, 0.11813527f, -0.04748076f, -0.00780877f, 
    -0.01498020f, -0.05326009f, -0.04545129f, -0.00850989f, 0.45717812f, -0.16954371f, -0.20572418f, -0.07920115f, 
    0.06783169f, -0.05602250f, 0.04133517f, -0.17771323f, -0.00213316f, 0.08537491f, -0.05788868f, 0.05872923f, 
    -0.42820963f, 0.08861662f, -0.01455500f, -0.09781446f, 0.07373186f, 0.05107399f, 0.03870438f, -0.00110660f, 
    0.00571197f, -0.13570260f, -0.06808672f, 0.06234241f, -0.22534512f, -0.13516536f, 0.05349198f, -0.14941512f, 
    0.12175582f, 0.19447853f, 0.06096683f, 0.01483448f, -0.04234926f, 0.03767633f, 0.00197980f, 0.00066863f, 
    0.18197809f, -0.11834178f, -0.01767327f, 0.17728528f, -0.03558673f, 0.17239039f, 0.03812542f, -0.04668824f, 
    0.02722944f, -0.01634209f, -0.08735343f, 0.00148321f, -0.04981633f, 0.30616584f, 0.15598848f, -0.03729446f, 
    0.11488195f, 0.00693820f, 0.02230916f, -0.00694579f, -0.02508364f, 0.01600497f, -0.03199281f, 0.07385264f, 
    -0.22910032f, 0.08620235f, -0.29219335f, -0.24952520f, 0.02611515f, -0.05273157f, -0.02238080f, 0.01553614f, 
    -0.08359651f, -0.03978320f, 0.04773246f, -0.06226059f, -0.25123763f, -0.05785852f, -0.17070733f, -0.24774182f, 
    0.13831867f, 0.06822482f, 0.11043308f, -0.06481403f, 0.00834494f, 0.06773271f, 0.05860953f, -0.03498121f, 
    -0.01115391f, 0.01348472f, -0.03095159f, 0.00799491f, -0.04076514f, 0.00438075f, -0.01940639f, 0.00540629f, 
    -0.02171505f, 0.00523048f, 0.02120322f, -0.03073796f, -0.03088107f, 0.00453652f, -0.00030865f, -0.04092252f, 
    0.01393447f, -0.00632654f, -0.00360038f, -0.00710566f, -0.02942806f, -0.00103677f, -0.02922355f, -0.03284325f, 
    -0.03237584f, 0.00356532f, 0.00913613f, 0.02156293f, 0.02837091f, 0.02325789f, 0.00202594f, 0.02958382f, 
    -0.03337734f, -0.01521414f, 0.02363892f, -0.02736012f, -0.01165583f, -0.01827597f, -0.03752760f, 0.00981662f, 
    0.02140509f, 0.01936199f, -0.00800361f, -0.01220374f, 0.00918130f, -0.02192203f, -0.01070934f, 0.00737697f, 
    -0.03487295f, -0.03739755f, 0.01842501f, -0.00239084f, 0.00211816f, -0.01711956f, 0.02992859f, -0.00260564f, 
    -0.03503725f, -0.02850391f, -0.00910785f, -0.01895952f, 0.00608581f, -0.00242423f, -0.02172990f, -0.03988556f, 
    -0.03339056f, -0.02823212f, -0.01292386f, -0.02020679f, 0.01889666f, -0.02155950f, 0.02819931f, -0.00489141f, 
    0.02808880f, -0.03944005f, 0.00366199f, -0.01789050f, -0.03729453f, -0.02483682f, -0.00172694f, -0.03002265f, 
    -0.03365690f, 0.02229450f, 0.01205131f, 0.00643849f, 0.00790589f, 0.01990448f, 0.01498343f, 0.00623124f, 
    0.02065069f, 0.01268748f, -0.00309529f, -0.03426499f, -0.02602476f, -0.03558236f, -0.00828175f, 0.01032325f, 
    0.00090041f, 0.02921862f, -0.02507016f, -0.02593824f, -0.02808783f, -0.01306707f, -0.01428024f, 0.00588879f, 
    0.02302010f, -0.01323135f, 0.00453296f, -0.02000957f, 0.02409205f, 0.00196913f, -0.01948223f, 0.00925093f, 
    0.02262522f, -0.01009350f, 0.00900024f, -0.02771529f, -0.01526167f, -0.04110616f, 0.01175055f, -0.03059526f, 
    0.01144245f, -0.03367093f, 0.02634222f, -0.02209444f, -0.03960169f, 0.01664477f, -0.01670327f, -0.02622480f, 
    0.01407262f, -0.01034251f, -0.00701654f, -0.01441378f, -0.01525271f, -0.00033257f, 0.00914302f, -0.01487650f, 
    -0.00294229f, -0.01284624f, -0.01955619f, 0.01131811f, -0.02138245f, -0.01111027f, 0.01692209f, -0.01687908f, 
    -0.01445544f, -0.02721707f, 0.02145625f, 0.00947155f, -0.02485908f, -0.00690514f, 0.00209618f, -0.03603964f, 
    -0.04057616f, 0.01562490f, 0.03426789f, 0.00132951f, -0.02190941f, -0.02378953f, 0.00350411f, 0.01674364f, 
    -0.03879951f, -0.00221165f, -0.03304921f, 0.02436412f, 0.01699670f, 0.02976422f, -0.00109177f, -0.02395105f, 
    0.01285958f, -0.03449886f, -0.03475355f, -0.00405480f, 0.02970627f, -0.00240388f, 0.00035106f, -0.02600946f, 
    0.01867448f, -0.02923911f, 0.01385544f, 0.01406332f, -0.02458222f, 0.00546705f, -0.00732843f, -0.00107335f, 
    0.02680072f, -0.02141905f, -0.03790483f, -0.03098976f, -0.02222245f, -0.00794514f, 0.00078433f, -0.04145258f, 
    -0.01081001f, 0.02519085f, -0.01191338f, -0.02374462f, -0.03644319f, -0.00393726f, -0.01073170f, -0.01554487f, 
    -0.01814263f, -0.01347022f, 0.01618978f, -0.01170152f, 0.00978993f, -0.00951730f, -0.00385252f, 0.01678966f, 
    -0.00450165f, -0.02353616f, -0.02659975f, -0.02030833f, -0.02698378f, 0.01229297f, -0.03464409f, -0.02936672f, 
    0.01467755f, -0.01361399f, 0.02847951f, 0.01882923f, -0.01696975f, 0.02522465f, -0.03496767f, -0.01525687f, 
    0.01130696f, 0.00722369f, 0.02885163f, -0.00701211f, 0.00509944f, 0.02060144f, -0.01892482f, 0.00433700f, 
    0.01564984f, 0.01638521f, 0.00319169f, 0.02276286f, -0.01420349f, -0.03887783f, 0.01302098f, -0.02441165f, 
    -0.03864785f, -0.02568088f, -0.03751399f, 0.01039531f, -0.00073284f, -0.02350639f, 0.00192218f, -0.01413860f, 
    -0.03981330f, -0.01775050f, 0.02003077f, -0.03475197f, 0.02769393f, 0.00707154f, -0.01568557f, 0.02703178f, 
    0.00088520f, 0.02269064f, 0.00814082f, -0.01900603f, 0.00415859f, -0.03103840f, 0.02974683f, -0.02627258f, 
    0.00027087f, -0.03016895f, -0.00085616f, 0.01850529f, 0.01185221f, 0.00408141f, -0.01830164f, -0.00935654f, 
    -0.02952741f, -0.00540745f, -0.01678509f, -0.03489694f, -0.01280367f, 0.02698900f, -0.02025018f, 0.02419811f, 
    0.02957388f, -0.02256220f, 0.00204061f, -0.03725442f, 0.01566860f, -0.03892118f, 0.01048734f, -0.02452834f, 
    0.00694756f, 0.02546803f, 0.02761968f, -0.03912236f, 0.01108431f, -0.00080604f, -0.00543085f, 0.02462274f, 
    0.02536760f, 0.00180559f, 0.02016154f, 0.00660686f, -0.03080493f, 0.00780782f, -0.01869907f, -0.03073803f, 
    0.00687971f, -0.02673428f, 0.00000326f, -0.02959904f, -0.01012015f, -0.01592127f, 0.02585796f, -0.02337223f, 
    -0.00255929f, -0.02302507f, -0.00648030f, -0.01604524f, -0.03218569f, 0.02671112f, 0.00247969f, -0.02582019f, 
    0.00985864f, 0.00123591f, -0.00685596f, 0.00439607f, 0.01288444f, -0.01096045f, -0.01623786f, 0.01513021f, 
    -0.03398632f, 0.01507736f, 0.00918526f, 0.00971599f, 0.00469443f, -0.02035598f, -0.02027548f, 0.02117582f, 
    -0.03514222f, -0.03071354f, -0.03048833f, 0.00838762f, -0.02836486f, 0.01175255f, 0.03148595f, -0.02960513f, 
    0.01085321f, -0.03948501f, 0.01518411f, 0.00927230f, 0.00005806f, 0.00829290f, -0.00185296f, -0.02145686f, 
    -0.00416171f, -0.01181619f, -0.02858257f, -0.00677239f, -0.01923087f, -0.00630131f, 0.01118689f, 0.01684083f, 
    -0.00571117f, -0.00412185f, -0.01041036f, 0.00422284f, -0.02377485f, -0.00480404f, 0.00997656f, -0.00432204f, 
    -0.00851887f, -0.00836557f, -0.02778443f, 0.01337937f, -0.04002178f, 0.01445183f, -0.00569481f, 0.02138949f, 
    0.00297933f, 0.02779965f, 0.02968174f, -0.00513401f, -0.01143927f, 0.02094656f, -0.02693562f, 0.01277837f, 
    -0.00412544f, -0.03032541f, -0.03025835f, -0.03449061f, -0.01475057f, 0.02760330f, 0.01797413f, -0.03536779f, 
    -0.01701767f, -0.03844604f, -0.01037793f, -0.03291104f, -0.00144842f, 0.00076297f, -0.03080047f, -0.03842121f, 
    0.01109382f, -0.02844881f, 0.02863993f, 0.01225668f, -0.01456592f, 0.00461268f, -0.03295446f, -0.01067931f, 
    -0.01750652f, -0.03026268f, -0.02418863f, -0.00499847f, -0.00367299f, -0.00941957f, -0.03487967f, 0.01407843f, 
    -0.00177753f, 0.02010858f, 0.01216222f, 0.00437843f, -0.00635614f, -0.02175792f, -0.02181447f, -0.01199170f, 
    -0.03381323f, -0.02170300f, -0.02005737f, -0.00313268f, -0.02854997f, -0.02591073f, 0.00731441f, 0.01095717f, 
    -0.03889936f, -0.00154347f, 0.01105654f, 0.01863661f, 0.02087801f, -0.00461130f, -0.03853395f, -0.03134308f, 
    0.00471532f, -0.00349846f, 0.00895038f, 0.01566569f, -0.00809438f, 0.00923840f, -0.02977455f, 0.02539920f, 
    0.01265267f, -0.02715700f, -0.02848548f, -0.00913510f, 0.02787742f, 0.00612951f, 0.02571602f, 0.00474351f, 
    -0.00783796f, -0.03137561f, -0.03674810f, -0.00824309f, -0.02565179f, -0.00366717f, -0.02272625f, 0.01154731f, 
    0.00414900f, -0.01452273f, -0.02517101f, 0.00601011f, 0.01447302f, -0.02950335f, -0.01927699f, 0.02403145f, 
    -0.00415067f, -0.01718521f, 0.01122006f, -0.03326112f, 0.02751209f, 0.00363760f, 0.01698645f, 0.01465021f, 
    -0.00988411f, -0.01137260f, -0.03911782f, -0.03417083f, -0.03266952f, -0.00725786f, -0.00519602f, 0.00308503f, 
    -0.03251557f, 0.01888950f, 0.00510728f, -0.03156860f, -0.02044962f, 0.00666440f, -0.00846260f, 0.02922670f, 
    0.03574828f, 0.01391492f, 0.01064699f, -0.02892909f, -0.01700096f, 0.00375410f, 0.01636736f, -0.02861492f, 
    0.01880123f, 0.00298260f, -0.01085116f, 0.00421634f, 0.00667531f, -0.01535564f, -0.03546188f, 0.00610412f, 
    0.01301684f, -0.03115138f, -0.03056337f, 0.00257129f, -0.03637714f, -0.01149000f, 0.02896746f, -0.04103451f, 
    -0.02610520f, -0.02009711f, -0.00225420f, -0.01538061f, -0.02628345f, -0.02754728f, -0.00043323f, 0.00965950f, 
    -0.00530281f, -0.00578298f, -0.02838667f, -0.02104149f, -0.02282829f, -0.02110679f, -0.00440131f, -0.02914107f, 
    -0.04115906f, 0.01327431f, -0.00840335f, 0.00535812f, -0.02568218f, 0.01645861f, 0.00632924f, -0.04166662f, 
    0.00662465f, -0.00465279f, 0.00570661f, -0.01828692f, 0.00140084f, -0.03165531f, -0.00514996f, 0.01100032f, 
    -0.03896444f, -0.01203984f, -0.01008457f, -0.01631160f, 0.01612481f, -0.02036818f, 0.01615611f, -0.03250368f, 
    -0.00486609f, 0.01807744f, -0.02089162f, -0.01924223f, -0.03947785f, -0.03199713f, -0.03894541f, -0.00231567f, 
    0.02725138f, -0.03963515f, -0.03809043f, 0.01167059f, 0.01891177f, -0.02360259f, 0.02139605f, -0.02380400f, 
    0.00908755f, -0.01020721f, -0.01918304f, 0.02994673f, 0.02604895f, -0.01494618f, 0.01849066f, -0.02891156f, 
    -0.00274879f, -0.01963117f, -0.00506728f, -0.00357722f, -0.02250975f, -0.01198637f, -0.03874121f, -0.00193105f, 
    -0.01984691f, 0.00736985f, -0.01378365f, 0.01709314f, 0.02806166f, -0.02764384f, 0.02299896f, -0.01674537f, 
    0.00272954f, 0.02377726f, 0.00444955f, -0.03395559f, -0.00782566f, 0.02603321f, 0.00592176f, -0.03090249f, 
    0.00851606f, 0.02031709f, 0.02994295f, -0.00222155f, -0.01831582f, -0.03866595f, -0.00701825f, -0.02536854f, 
    -0.03722384f, 0.03399228f, -0.00266411f, -0.00096751f, -0.04040534f, -0.01824377f, -0.00304557f, 0.02856418f, 
    -0.00406270f, -0.00114184f, -0.01029169f, 0.01568587f, -0.03110065f, 0.00874355f, 0.00641040f, 0.02417103f, 
    0.02426879f, 0.01493918f, -0.01872667f, -0.03888589f, -0.00009148f, 0.02578772f, -0.00372936f, -0.02606023f, 
    -0.02735462f, -0.03137418f, -0.00302599f, -0.01572557f, -0.00011958f, -0.00395735f, -0.03297901f, -0.00784043f, 
    0.02783325f, -0.03967562f, 0.00051349f, -0.00166797f, -0.00075871f, -0.01651121f, 0.01511434f, -0.03603309f, 
    -0.00541196f, -0.04094825f, 0.02893521f, -0.02445861f, 0.01469146f, -0.00248492f, 0.01309862f, -0.02843954f, 
    0.02414772f, -0.01883206f, -0.02591609f, -0.00430563f, -0.00185774f, 0.02911329f, 0.01761546f, -0.02436380f, 
    -0.00277639f, -0.03759671f, 0.01436954f, 0.00731508f, 0.01238267f, -0.01461396f, -0.01209447f, 0.02135418f, 
    -0.01668901f, 0.01143156f, -0.00733067f, -0.02264350f, -0.00055060f, 0.01830711f, 0.02146972f, -0.03442964f, 
    -0.01701525f, -0.01938527f, 0.01307785f, 0.01783878f, 0.01879078f, 0.00189860f, -0.00220279f, -0.00058074f, 
    0.02125016f, 0.00817182f, 0.01912060f, -0.02772989f, -0.03630376f, 0.02374949f, -0.02261028f, 0.01869533f, 
    0.02546343f, 0.02058433f, 0.00341842f, -0.00064945f, -0.02038092f, -0.01931084f, -0.03483829f, 0.01670370f, 
    0.01007487f, -0.02310906f, 0.00641030f, 0.00038845f, -0.02001537f, 0.02910891f, -0.00937109f, 0.00485929f, 
    -0.01810814f, 0.02156186f, 0.00185621f, 0.02529581f, -0.03793636f, 0.01427830f, 0.00572905f, 0.01314669f, 
    -0.02758586f, -0.00738943f, -0.03412422f, -0.02586721f, -0.04047416f, -0.03033386f, -0.01866672f, -0.01507706f, 
    0.00790197f, -0.02010525f, -0.01386278f, -0.01421687f, 0.00448328f, -0.02105451f, -0.03296305f, 0.00594262f, 
    0.00701916f, -0.00482422f, -0.01403749f, -0.02502136f, -0.03553711f, -0.02645639f, 0.00496705f, -0.01297294f, 
    0.02428597f, 0.02059052f, -0.03635701f, -0.04012632f, -0.00476415f, 0.01748323f, 0.02963673f, -0.02588465f, 
    -0.03408731f, 0.00097385f, -0.04096679f, -0.03070496f, -0.00111415f, 0.02659976f, -0.02601299f, 0.01713848f, 
    0.02544626f, 0.00419842f, 0.00252721f, -0.00284005f, -0.03316314f, -0.03682556f, 0.02182679f, 0.00962330f, 
    0.02764785f, -0.04242792f, -0.01857248f, 0.00766266f, 0.02543239f, -0.00993132f, -0.01682074f, 0.00867198f, 
    0.01073041f, -0.02359300f, 0.01578290f, 0.00567554f, -0.01453833f, 0.00300038f, -0.02496945f, 0.00033282f, 
    -0.03191377f, -0.00111097f, -0.02086078f, 0.01851453f, 0.00876746f, 0.00592623f, 0.00837952f, 0.01957027f, 
    -0.02968242f, 0.00120828f, -0.02188225f, 0.01010436f, 0.01184268f, 0.00311571f, 0.01585421f, 0.00243684f, 
    0.01549126f, -0.01486444f, 0.02096568f, 0.00481502f, 0.00236424f, 0.00671614f, -0.00765431f, 0.01896963f, 
    0.02627268f, -0.00648461f, -0.01729686f, 0.02672514f, -0.02440011f, 0.01828093f, 0.01013827f, -0.01627107f, 
    0.02280767f, -0.03594644f, 0.01651647f, -0.01091141f, -0.01103142f, -0.03613562f, -0.04017008f, -0.00136497f, 
    -0.03944938f, -0.00537715f, 0.02067993f, -0.00654895f, -0.02771674f, 0.00985147f, 0.00276485f, -0.03451616f, 
    -0.00190927f, -0.00197485f, -0.03373569f, 0.03010797f, -0.01992447f, 0.01549891f, -0.02974470f, 0.01542145f, 
    -0.03270102f, -0.01625921f, -0.01795597f, 0.00199940f, -0.02560944f, 0.00341833f, 0.01222165f, -0.03689294f, 
    -0.03536468f, 0.00964325f, -0.03933113f, 0.01832916f, -0.01986962f, 0.01365237f, -0.03729929f, -0.02411536f, 
    0.01759667f, -0.01895061f, -0.04025679f, 0.02006414f, -0.02473256f, -0.01139899f, 0.00000971f, -0.01132132f, 
    -0.02334023f, -0.03797769f, 0.01513379f, -0.02763777f, 0.02953310f, -0.03312070f, 0.01414857f, -0.00532187f, 
    0.00662982f, 0.01279661f, 0.02224212f, 0.00594946f, -0.00863807f, 0.01188468f, 0.02023561f, 0.03157236f, 
    0.00728545f, -0.03920345f, -0.00018163f, 0.00802127f, 0.01481811f, 0.00104003f, -0.03852151f, 0.01028281f, 
    -0.02717203f, 0.00588909f, 0.00160668f, 0.00055657f, 0.01486194f, -0.02361954f, -0.03270841f, 0.00977963f, 
    0.02084921f, 0.03219854f, -0.03870283f, 0.00495543f, 0.01814214f, 0.02800237f, -0.03489554f, -0.03341959f, 
    -0.01806254f, 0.01252547f, -0.03283783f, -0.01379592f, -0.00512222f, -0.00250386f, 0.02690970f, 0.01256610f, 
    -0.04163251f, -0.02355980f, 0.01071657f, -0.01426708f, -0.02141066f, -0.00550492f, -0.02306171f, 0.02188718f, 
    -0.03937500f, 0.00138545f, 0.01938549f, -0.02952942f, 0.01944686f, 0.02287504f, 0.03243852f, 0.00771989f, 
    0.00476705f, -0.02245397f, 0.01945304f, 0.01343042f, 0.01859972f, -0.00773357f, 0.00199229f, 0.02641658f, 
    -0.01328749f, 0.01108006f, -0.04011128f, -0.01080818f, -0.02318228f, 0.00106884f, -0.01748354f, 0.01087789f, 
    -0.04012993f, 0.00777187f, -0.00650473f, 0.00375975f, -0.03458607f, 0.00762608f, -0.01553295f, -0.01593353f, 
    0.00111933f, 0.02486926f, -0.01723733f, 0.01395712f, -0.03568609f, 0.01389421f, -0.02902294f, -0.03417975f, 
    -0.00083291f, 0.01300553f, -0.00859766f, -0.01863029f, -0.00593597f, -0.00406629f, 0.02357509f, -0.02343333f, 
    -0.01365375f, -0.00076403f, 0.02534005f, -0.00343322f, -0.00985860f, -0.03654680f, 0.01339156f, 0.00690551f, 
    0.02617852f, -0.03599956f, -0.00423659f, -0.02527402f, 0.01011861f, -0.04038483f, 0.00094466f, 0.02033960f, 
    -0.03649916f, 0.02564199f, 0.02021477f, -0.02019238f, -0.00917480f, -0.02173669f, -0.02640899f, 0.00400660f, 
    -0.02579849f, -0.03949827f, 0.00416340f, 0.00636476f, 0.00186100f, -0.01017730f, 0.01676027f, 0.00865149f, 
    0.01997219f, 0.02069725f, 0.00676954f, 0.00139808f, 0.01481267f, 0.02601502f, 0.01115224f, -0.01590114f, 
    -0.03655099f, 0.00678497f, 0.01453662f, 0.01261265f, -0.02014485f, 0.02229515f, 0.00886090f, 0.02036763f, 
    0.01243126f, 0.01986618f, -0.02735385f, -0.00895598f, 0.00853168f, -0.03911005f, 0.00156533f, 0.00376556f, 
    -0.02807453f, -0.02688093f, 0.02419976f, -0.00214001f, 0.00897709f, 0.01548818f, 0.00144276f, -0.02612486f, 
    0.02131023f, 0.01844320f, 0.01119152f, -0.00258291f, 0.02044475f, 0.02159454f, -0.01642353f, -0.03692414f, 
    0.02643737f, -0.00104322f, -0.02226973f, -0.02438612f, 0.02154343f, -0.01755945f, 0.00387880f, -0.03123781f, 
    0.00011645f, -0.01017525f, -0.01449614f, 0.01747065f, -0.02052676f, -0.02830097f, -0.02153974f, 0.02683477f, 
    -0.01452141f, 0.01122738f, -0.00608407f, -0.00445191f, 0.01449326f, 0.01272583f, 0.00272893f, -0.02233825f, 
    -0.02671485f, -0.01884894f, 0.00427909f, 0.02158941f, -0.01371018f, 0.03034693f, -0.03459487f, -0.02125710f, 
    0.01647462f, -0.04046803f, 0.00719989f, 0.01694635f, 0.00831091f, -0.01004333f, 0.02849889f, -0.03550167f, 
    0.02784320f, -0.01869971f, -0.04172543f, 0.02351133f, 0.02332328f, -0.02204689f, 0.02891125f, -0.02784776f, 
    -0.00561969f, 0.01142639f, 0.02303788f, 0.01043673f, 0.00757516f, 0.03122277f, -0.02387917f, 0.02401800f, 
    -0.01285270f, 0.03542420f, 0.01073437f, 0.01519580f, -0.03815427f, -0.01038380f, -0.01655945f, 0.00365075f, 
    -0.01715673f, -0.01612284f, 0.00378098f, 0.01108390f, -0.01332863f, -0.03853771f, 0.01733658f, -0.01011934f, 
    0.03094211f, 0.02238392f, -0.01311637f, -0.00354237f, -0.03079304f, -0.00318579f, 0.01775008f, -0.00527949f, 
    0.00313194f, -0.03493760f, 0.01885847f, -0.02682672f, 0.03001736f, 0.00481401f, -0.01546722f, -0.00900616f, 
    -0.04140558f, 0.00728412f, -0.03216774f, 0.01828052f, 0.00027191f, -0.00589084f, -0.01052149f, -0.02067070f, 
    0.01608976f, -0.03873233f, -0.02461001f, 0.03050441f, -0.01030351f, -0.03940416f, -0.03915331f, 0.01752493f, 
    -0.02660590f, 0.01448103f, 0.02624565f, 0.02157930f, -0.01672868f, 0.00744918f, 0.02012904f, 0.00080780f, 
    0.00062950f, -0.01342624f, 0.00033754f, -0.02494417f, 0.04046534f, 0.01078056f, 0.01232477f, -0.00940811f, 
    -0.03476371f, 0.00188260f, -0.00168997f, 0.01193157f, -0.01414483f, 0.02012040f, 0.02231069f, -0.01270489f, 
    -0.02164465f, -0.00583604f, -0.00703654f, -0.00955645f, 0.01920911f, -0.00969742f, -0.01088698f, -0.03577066f, 
    -0.03013041f, -0.02101821f, 0.01346272f, -0.01596444f, 0.00924082f, -0.02949104f, -0.00358058f, -0.00700510f, 
    -0.02450707f, -0.03324275f, 0.01489375f, 0.02561921f, -0.00683469f, 0.02669027f, -0.01268020f, -0.02744700f, 
    0.00773768f, -0.02306467f, -0.04005478f, -0.00642094f, -0.01656411f, -0.01479243f, -0.01496092f, -0.03785435f, 
    -0.01085785f, -0.03742251f, -0.03681335f, -0.03166666f, -0.02256362f, 0.02656893f, 0.02347627f, -0.02992962f, 
    -0.01286188f, 0.00419346f, -0.02695038f, 0.02880659f, 0.00747469f, 0.01136926f, 0.00436702f, 0.01702093f, 
    0.02010402f, -0.01761622f, 0.00199581f, 0.02695529f, -0.00977321f, -0.02129786f, -0.01519206f, -0.03199999f, 
    -0.03867705f, -0.00128197f, 0.01213724f, -0.01026938f, -0.00828816f, 0.00597427f, 0.02023266f, 0.00204300f, 
    0.00786537f, -0.03452687f, -0.01097883f, -0.00048211f, 0.01332960f, 0.02321015f, -0.00978442f, -0.03877962f, 
    0.02236396f, -0.00204458f, 0.00513747f, -0.01375363f, 0.02597217f, 0.01689938f, 0.00390212f, -0.01888484f, 
    0.01573100f, -0.03184954f, -0.03046774f, -0.01361201f, -0.03048414f, 0.00614399f, -0.03197141f, -0.02783043f, 
    0.02982519f, -0.02508467f, -0.03411173f, -0.00448329f, -0.02052799f, 0.00108596f, 0.00124149f, 0.01871897f, 
    0.01500693f, 0.02377941f, 0.00341502f, 0.01189875f, 0.01636106f, 0.01719125f, -0.00736350f, -0.04364290f, 
    -0.03542722f, 0.01681966f, -0.00747053f, -0.00719266f, -0.00013919f, -0.00017723f, -0.01644984f, -0.03170013f, 
    -0.02142994f, 0.00533082f, -0.01085604f, -0.04062628f, -0.00366514f, -0.00927712f, -0.03102010f, -0.04357934f, 
    -0.00919745f, 0.02303674f, -0.04317116f, 0.02940262f, -0.01312526f, -0.01339244f, 0.00650135f, -0.00905891f, 
    -0.00198838f, 0.03138988f, 0.02064238f, -0.00064668f, 0.00778134f, 0.00264540f, -0.00056557f, -0.01772061f, 
    -0.02876679f, -0.04321397f, 0.00765460f, -0.02716124f, -0.03378452f, -0.03716867f, -0.02508656f, 0.02132196f, 
    0.00098502f, -0.00496611f, 0.02670375f, 0.02729270f, -0.01822728f, -0.03133761f, -0.01850693f, 0.02162901f, 
    -0.03677716f, 0.00095265f, -0.03670434f, -0.00501569f, -0.03261676f, 0.02160195f, -0.03853993f, -0.01666934f, 
    -0.01980532f, -0.02558315f, 0.02667550f, -0.01926574f, -0.01596013f, -0.02238848f, -0.02136876f, -0.01215483f, 
    0.01173213f, 0.00853718f, 0.00738236f, 0.00738005f, -0.03611536f, 0.02118258f, 0.02714767f, 0.00136985f, 
    -0.03440892f, 0.02827306f, -0.03478461f, 0.02189845f, 0.00590688f, 0.02232227f, -0.02577095f, 0.01765045f, 
    -0.03443066f, 0.01116433f, 0.00279310f, -0.03397979f, -0.00641609f, -0.01318990f, 0.02336979f, -0.00692060f, 
    -0.03491384f, -0.01182074f, -0.03009409f, -0.03403505f, -0.04113377f, 0.00580576f, 0.01073886f, -0.02119656f, 
    -0.00661721f, -0.02406250f, 0.00921793f, 0.00458645f, -0.01385215f, 0.00559428f, -0.03622192f, 0.02857056f, 
    0.01588858f, 0.00497817f, 0.02231385f, 0.00852423f, 0.00789260f, 0.02516220f, -0.03165358f, 0.01516201f, 
    0.01448206f, 0.00423786f, 0.01944096f, 0.02375264f, 0.02239130f, -0.02591717f, 0.02745740f, -0.01472927f, 
    -0.00290655f, 0.00579860f, -0.03051321f, -0.01858033f, 0.01351295f, -0.00758252f, 0.02197267f, 0.02537037f, 
    -0.03385514f, 0.01172192f, 0.03590862f, 0.03484033f, -0.02178061f, 0.00174911f, -0.01987323f, 0.02614291f, 
    -0.03700655f, -0.03612987f, -0.02835601f, 0.00455732f, -0.02492968f, -0.01399646f, -0.01472477f, -0.02760771f, 
    -0.01067343f, 0.02681701f, 0.00373931f, 0.01154097f, -0.02263240f, -0.00756465f, -0.04004691f, -0.02455418f, 
    -0.01725223f, -0.02294759f, -0.02563816f, 0.02130534f, -0.03850242f, -0.03074493f, 0.00819677f, -0.01366314f, 
    -0.03752745f, -0.03373834f, -0.02154156f, -0.00598538f, -0.01854521f, -0.03126401f, -0.00904022f, 0.02337067f, 
    -0.01954695f, -0.03442927f, 0.01982305f, 0.01718782f, -0.01541065f, -0.00511658f, 0.00455252f, 0.00901930f, 
    -0.00260202f, -0.01621778f, 0.02901200f, -0.00894019f, 0.02620764f, 0.01632982f, -0.03366290f, -0.02562817f, 
    0.00020533f, -0.02559341f, -0.00396244f, 0.02650728f, 0.02749840f, -0.00615000f, -0.01921659f, 0.01460360f, 
    0.02152737f, 0.02300275f, 0.01799122f, -0.02932411f, -0.00194365f, -0.00235665f, 0.00453489f, -0.02740694f, 
    0.01708358f, 0.02000191f, -0.01335532f, -0.02372590f, -0.01866148f, -0.02560103f, 0.02358969f, 0.00716589f, 
    -0.01479420f, 0.01928204f, -0.02493707f, 0.00796645f, 0.01549454f, -0.00403904f, 0.01502663f, 0.00396799f, 
    0.00232248f, -0.01030140f, 0.01161823f, -0.02491578f, -0.02986464f, 0.02677086f, -0.03553945f, -0.00934020f, 
    0.00483939f, -0.01815472f, -0.03091735f, 0.02623563f, -0.03322410f, 0.02904291f, 0.01151613f, -0.03832025f, 
    -0.02590294f, -0.00456368f, -0.02409459f, 0.01285176f, -0.02622340f, 0.00473899f, -0.03583436f, -0.01238645f, 
    0.02910369f, -0.02480525f, 0.00239479f, -0.01147532f, 0.02713155f, -0.00924803f, -0.03236788f, -0.02575793f, 
    -0.03823645f, -0.01537558f, 0.00363324f, -0.01048957f, 0.00183102f, 0.01406806f, 0.02909284f, 0.01474998f, 
    -0.03062727f, 0.00264196f, 0.00081112f, -0.04030693f, 0.02079700f, -0.00660180f, -0.02390628f, -0.03486318f, 
    0.02228986f, -0.00578761f, -0.04101792f, -0.00511371f, -0.03470296f, -0.03436002f, 0.00937362f, -0.03653177f, 
    -0.02844740f, -0.02347834f, -0.02156847f, -0.03300291f, -0.02643377f, 0.01739496f, -0.02253298f, -0.02536075f, 
    0.02052060f, -0.01108895f, -0.03962103f, -0.01823306f, 0.01623600f, -0.02810881f, -0.02452521f, 0.01348143f, 
    0.00410603f, -0.03032408f, 0.02282286f, -0.00883000f, 0.00287389f, 0.01137521f, -0.04322895f, -0.02730063f, 
    -0.02611430f, -0.01163552f, 0.02355587f, 0.01726069f, -0.01502556f, 0.02083726f, -0.01590455f, 0.01534532f, 
    -0.00714611f, -0.02965788f, 0.02462932f, 0.01711161f, -0.01968742f, 0.00164584f, -0.02529014f, 0.00372463f, 
    0.01283429f, -0.02272801f, 0.00455702f, 0.02541604f, -0.04166370f, -0.00770840f, 0.00494707f, 0.00891987f, 
    -0.03243360f, 0.02587291f, 0.02755389f, 0.01845661f, 0.01672565f, -0.02681170f, -0.02645143f, -0.01557524f, 
    -0.00347508f, -0.03560555f, 0.00488398f, -0.00712509f, 0.01089923f, 0.00237511f, 0.02377259f, 0.01810162f, 
    -0.02139316f, -0.03623066f, -0.02429702f, -0.00224851f, 0.00590662f, 0.00524571f, -0.01110187f, -0.02023198f, 
    0.02856077f, -0.03084259f, -0.00312941f, -0.00714508f, -0.00662084f, -0.03994901f, 0.02894595f, 0.01609064f, 
    -0.00558444f, -0.02553608f, 0.00749728f, -0.00380316f, 0.01119337f, 0.01955434f, 0.02603402f, -0.00636573f, 
    -0.02144839f, -0.03508481f, 0.01667665f, 0.00116459f, -0.02997808f, -0.04235559f, 0.00788656f, 0.03122700f, 
    0.00040605f, 0.00677215f, -0.01626639f, -0.02276952f, -0.02665485f, 0.01299794f, -0.03379430f, 0.01782736f, 
    0.00470349f, -0.03584922f, 0.01631874f, 0.01965793f, -0.03653190f, 0.01103820f, 0.03438667f, 0.02939804f, 
    -0.01468450f, 0.00229459f, -0.00746173f, -0.02371192f, 0.02294802f, -0.02605732f, 0.02449111f, 0.00293204f, 
    -0.00072160f, -0.00839588f, -0.00406532f, 0.01386485f, 0.03504612f, 0.01781897f, 0.01752051f, -0.00426636f, 
    0.01772375f, -0.04331575f, -0.00755995f, 0.02128006f, 0.01360475f, -0.01767110f, -0.01334426f, -0.00839929f, 
    0.01201460f, -0.03394614f, 0.00212910f, 0.01479919f, 0.02953518f, 0.03186866f, 0.01497810f, -0.00832539f, 
    0.00582157f, -0.01387429f, -0.00311749f, 0.01370533f, 0.01355924f, 0.01434869f, -0.03217785f, -0.02274266f, 
    -0.01559180f, -0.00398860f, -0.01593155f, 0.01796668f, -0.01392136f, -0.01583463f, -0.04171523f, -0.00549373f, 
    -0.03145982f, 0.01456136f, -0.01848557f, -0.01479493f, 0.02111321f, 0.02665525f, 0.01349555f, -0.02739900f, 
    0.02775173f, 0.01446192f, 0.02631909f, -0.01095835f, -0.01726867f, -0.00008078f, 0.01201279f, 0.02868715f, 
    -0.02273937f, -0.01387753f, 0.00847223f, -0.03536295f, -0.01927507f, -0.00088226f, 0.01637085f, 0.01924370f, 
    -0.03615720f, -0.00155862f, 0.02349495f, -0.01969156f, -0.03810830f, -0.00278018f, -0.02957187f, 0.02483988f, 
    -0.03291962f, -0.01099477f, 0.00954904f, -0.00349585f, 0.00198900f, 0.01585557f, 0.01239275f, -0.01041537f, 
    -0.02396227f, 0.02562618f, 0.00633814f, -0.01116825f, -0.01435662f, -0.00589412f, 0.02432662f, 0.01199784f, 
    -0.03674393f, 0.01774952f, 0.02374644f, -0.00739075f, -0.03579427f, -0.02211256f, -0.03657772f, 0.01741323f, 
    -0.01504199f, -0.01632031f, 0.02561690f, -0.03715810f, -0.02334487f, -0.01358876f, 0.00267989f, -0.03040887f, 
    -0.02701835f, -0.02953149f, 0.02903961f, -0.02026692f, -0.03471882f, 0.01583758f, 0.01880269f, 0.02486695f, 
    -0.02378381f, 0.00359007f, 0.00864892f, 0.02714372f, -0.03828306f, -0.03633580f, -0.01342419f, 0.02248656f, 
    0.01145714f, -0.02942957f, -0.02843671f, -0.03315223f, 0.01792864f, -0.01027670f, -0.01296977f, 0.02336405f, 
    0.00038328f, 0.02403917f, 0.01876492f, -0.03041514f, -0.00998421f, -0.01528910f, -0.01557123f, -0.00070467f, 
    -0.02937578f, -0.00577172f, -0.03411159f, -0.03911340f, 0.02706814f, 0.00730807f, -0.04353829f, -0.02865481f, 
    0.01588259f, -0.01183363f, 0.01687249f, 0.01774830f, 0.02466020f, 0.02437571f, -0.00724609f, 0.02624949f, 
    0.02617538f, 0.02363211f, -0.00554204f, 0.01596642f, 0.01038538f, 0.00584186f, 0.01584698f, -0.02990948f, 
    0.01295635f, 0.01840753f, 0.01915542f, 0.02223505f, 0.01545398f, -0.04313633f, -0.01348263f, -0.02309791f, 
    -0.01808993f, -0.02043988f, -0.02468666f, 0.01653168f, 0.00958052f, 0.02111420f, -0.01737697f, -0.04077711f, 
    -0.02839839f, -0.00747165f, -0.00289692f, -0.03418953f, 0.00527579f, -0.00166357f, 0.02379017f, 0.01197708f, 
    0.01913689f, 0.00941160f, -0.01245357f, 0.01745416f, 0.02438256f, -0.03483643f, 0.03061157f, -0.02300270f, 
    -0.04223411f, -0.01242336f, -0.02780956f, 0.02604262f, 0.00073558f, 0.01726894f, -0.02224896f, 0.01975676f, 
    0.01780436f, -0.00700548f, -0.00924359f, -0.01033854f, -0.02893697f, -0.02558038f, -0.02436954f, -0.03139088f, 
    -0.01723111f, 0.00482318f, -0.00845065f, -0.02580402f, 0.00200013f, -0.03587870f, -0.01858550f, -0.03817680f, 
    0.00797966f, 0.00530053f, -0.04108702f, -0.02418590f, 0.00815066f, -0.01413894f, 0.02696523f, 0.01429035f, 
    -0.01738654f, 0.02107378f, 0.02451882f, 0.03018903f, 0.02211120f, 0.02210281f, 0.00061677f, -0.00793803f, 
    -0.04146331f, -0.04234188f, 0.01531950f, 0.00915310f, -0.00443013f, 0.02733907f, -0.00147658f, -0.01135203f, 
    -0.03025779f, 0.01407140f, -0.02534478f, 0.02909750f, -0.00804806f, -0.03493681f, -0.01288113f, 0.00632212f, 
    -0.00360337f, -0.01707481f, -0.02877665f, 0.02763837f, -0.00453307f, 0.01250477f, -0.01467788f, 0.02284762f, 
    -0.03789484f, -0.03225730f, -0.02131984f, 0.03574949f, -0.00413446f, 0.02678555f, 0.00585352f, 0.00596849f, 
    -0.00233199f, 0.00644828f, -0.01760861f, 0.01826165f, -0.04154686f, -0.03658491f, -0.01725904f, -0.00783168f, 
    0.02659743f, -0.00211797f, -0.03264303f, -0.02031423f, 0.00068003f, -0.03124231f, -0.02273512f, -0.00555611f, 
    -0.03376921f, -0.04221246f, -0.03918489f, -0.02357404f, -0.00797589f, -0.02356477f, 0.02459102f, -0.03815744f, 
    -0.03854364f, -0.04102334f, 0.02492688f, -0.02831521f, -0.03621919f, -0.00838334f, 0.03024318f, -0.02438828f, 
    0.02765017f, 0.02545920f, -0.00134312f, -0.02867680f, -0.01961727f, 0.02304050f, 0.00956543f, -0.02916930f, 
    -0.03164122f, -0.03580980f, 0.02602053f, -0.01366893f, -0.02410592f, -0.01301383f, -0.02636938f, -0.02296757f, 
    0.01630943f, -0.01135061f, 0.02137875f, -0.00024252f, -0.00220858f, -0.01836529f, -0.02150143f, 0.00143624f, 
    -0.00520517f, 0.00567576f, -0.02705761f, 0.00417698f, -0.01385096f, 0.01473537f, -0.03000817f, 0.01186728f, 
    -0.01036175f, 0.01323955f, -0.02980254f, -0.01393779f, 0.00333784f, -0.00854389f, -0.03420044f, -0.03560337f, 
    0.02194236f, 0.00854560f, 0.02491688f, -0.02188366f, 0.01073386f, 0.02403837f, -0.02111968f, 0.00298450f, 
    -0.00254061f, -0.00446844f, -0.02062727f, 0.00998811f, -0.01731272f, 0.02290512f, -0.01126212f, -0.01823292f, 
    -0.02730996f, 0.01070576f, -0.01893878f, -0.00225258f, -0.02711689f, -0.01218747f, -0.03628553f, -0.02833086f, 
    0.02049027f, 0.02499924f, 0.01339485f, -0.03005276f, -0.01181146f, 0.01045102f, -0.01244855f, -0.00135032f, 
    0.01067927f, 0.00973409f, 0.02696741f, -0.01382536f, 0.02009767f, 0.00598125f, -0.00438346f, -0.03833406f, 
    -0.00749789f, 0.00069928f, -0.02336035f, -0.00857540f, -0.04081656f, -0.01601283f, 0.00412374f, -0.03977444f, 
    -0.02843900f, 0.00987715f, -0.01752694f, -0.01259500f, 0.02673160f, -0.00263359f, 0.01225544f, -0.01516230f, 
    -0.00329940f, 0.02284068f, -0.01789415f, 0.00251315f, -0.02291423f, -0.01390583f, -0.02545549f, 0.01936192f, 
    -0.01179538f, -0.03581970f, 0.01076936f, 0.02037999f, -0.01135571f, -0.01611626f, -0.03715575f, -0.01464006f, 
    0.00736814f, -0.00999393f, -0.00772021f, -0.00132653f, -0.01588483f, -0.00760064f, 0.02236861f, -0.01573580f, 
    -0.03101625f, 0.00990504f, -0.03990151f, -0.00881037f, 0.01766487f, -0.03236018f, -0.00363203f, -0.01910441f, 
    -0.01215096f, -0.03619122f, -0.01390400f, -0.03040045f, -0.00486833f, 0.01438061f, -0.02445017f, 0.00321853f, 
    -0.02538181f, -0.03615182f, -0.01307473f, 0.02682512f, -0.01575247f, -0.03030769f, -0.03642699f, 0.02533324f, 
    -0.02548555f, -0.03354605f, -0.02749680f, -0.03308528f, -0.03163129f, 0.01412858f, 0.00361425f, -0.02445819f, 
    0.01528138f, -0.00449693f, -0.00373092f, -0.01337329f, -0.02445762f, 0.02032411f, -0.04166794f, 0.02439173f, 
    -0.00435537f, 0.02454377f, 0.00502529f, -0.02727445f, -0.03374109f, -0.00265646f, 0.02000893f, -0.00845189f, 
    -0.00561418f, -0.02610174f, -0.00261647f, 0.01147494f, 0.01383976f, -0.00955062f, -0.02463956f, -0.00297984f, 
    0.00475454f, -0.02287361f, 0.01433195f, -0.00446650f, -0.02216145f, -0.01973939f, 0.01567108f, -0.03022626f, 
    0.01082410f, -0.01534222f, -0.03040428f, -0.02377620f, 0.01663412f, -0.01532420f, -0.02988973f, -0.01025566f, 
    -0.02118770f, -0.01170206f, 0.02468607f, -0.03757151f, -0.02466371f, -0.03550799f, -0.02421836f, -0.02273235f, 
    -0.01490968f, -0.00846542f, -0.00856832f, 0.02290104f, 0.01801323f, -0.03351666f, -0.03310066f, 0.01324703f, 
    0.02360027f, -0.02134716f, 0.02185880f, -0.02139447f, 0.00282886f, -0.00254728f, -0.01165012f, 0.00414649f, 
    -0.03025729f, -0.03914827f, 0.02102362f, 0.02290347f, -0.00464775f, 0.00732303f, 0.00017570f, -0.02139963f, 
    -0.02310213f, -0.02662479f, -0.00177200f, -0.01553756f, -0.03418274f, 0.00114431f, -0.01526323f, 0.01316796f, 
    0.00776037f, -0.02016666f, -0.00936624f, -0.02453919f, 0.00365264f, -0.00830912f, -0.03290253f, -0.00734393f, 
    -0.04176970f, 0.02014751f, -0.03547636f, 0.02352400f, 0.01747662f, -0.02124345f, 0.00697046f, 0.02800451f, 
    -0.03979654f, 0.02111441f, 0.00178805f, 0.01372366f, 0.01635287f, -0.02120576f, -0.03878550f, -0.02139341f, 
    0.00670448f, -0.00699681f, -0.00888190f, 0.02032225f, -0.00564671f, 0.02111921f, -0.03023828f, -0.03781478f, 
    0.03204303f, -0.02834800f, 0.02074941f, 0.02808750f, -0.00883011f, 0.02602245f, 0.02148667f, -0.03616403f, 
    0.02464387f, -0.03443683f, -0.02114708f, 0.00834618f, 0.02905961f, -0.01047820f, -0.02146286f, -0.02975942f, 
    0.00736050f, -0.03927477f, -0.01288998f, -0.02371484f, 0.00229808f, -0.03830136f, 0.02656326f, 0.01673177f, 
    -0.02407140f, -0.00317627f, 0.00789755f, -0.01853866f, 0.02433730f, 0.00907689f, -0.01385159f, -0.01019004f, 
    0.02359904f, 0.01329320f, -0.00408051f, 0.02051478f, -0.02194993f, -0.00813933f, -0.03451270f, -0.02681249f, 
    -0.00566516f, 0.01431563f, -0.01546249f, -0.01310337f, -0.01019655f, 0.00719468f, 0.01473111f, -0.01412210f, 
    -0.00994593f, -0.00651361f, 0.00867990f, -0.04233138f, -0.02329197f, -0.01953870f, -0.00462872f, -0.03338043f, 
    -0.03189530f, -0.02886804f, -0.02723017f, -0.03126670f, -0.02657413f, -0.03355864f, -0.02872619f, 0.01404122f, 
    -0.01225993f, -0.02615525f, 0.02453994f, -0.02075555f, -0.00775533f, -0.04088502f, -0.02764961f, 0.01094977f, 
    -0.01353181f, -0.00908559f, 0.00613156f, 0.00422780f, -0.02586535f, -0.00820704f, -0.01668819f, -0.02485622f, 
    -0.00257756f, -0.01658246f, -0.00112277f, -0.01792216f, -0.01270161f, 0.01888430f, -0.00288289f, 0.00268656f, 
    0.01600332f, -0.03754610f, -0.03669271f, -0.04012531f, -0.03022182f, -0.02651399f, 0.00622289f, -0.03025118f, 
    0.01937160f, 0.00954611f, -0.01322811f, 0.01294775f, -0.00603656f, 0.00013752f, 0.01872730f, -0.00268911f, 
    0.01905178f, 0.02469852f, -0.03975368f, 0.00187472f, -0.00586033f, -0.00270735f, 0.00866787f, -0.04047871f, 
    -0.03898500f, -0.02027949f, 0.01979476f, -0.01104367f, 0.01634628f, -0.02655259f, -0.03150428f, 0.01362480f, 
    -0.03824433f, -0.02513167f, -0.00737202f, -0.01555362f, -0.00810447f, 0.01193620f, 0.00967469f, -0.03345305f, 
    -0.02278318f, 0.00698305f, -0.03577051f, 0.00418206f, 0.02468572f, -0.02847244f, -0.01374595f, 0.00898448f, 
    -0.01513966f, -0.00211023f, -0.00311869f, -0.02967425f, 0.00036899f, 0.01156425f, -0.02243743f, 0.00906975f, 
    0.02189719f, -0.02438544f, -0.03302387f, -0.01186659f, -0.02616107f, -0.01104054f, -0.02415192f, 0.01675503f, 
    0.01763050f, -0.00805942f, -0.04201928f, -0.00308466f, -0.02799532f, 0.02573084f, -0.01224666f, -0.00204169f, 
    -0.01462276f, 0.00098246f, 0.00651908f, -0.01205983f, -0.03349552f, -0.03415103f, -0.03790089f, 0.00821791f, 
    0.00432063f, 0.01440006f, -0.00900723f, -0.02204330f, 0.00181139f, -0.01658947f, -0.02506020f, -0.04356359f, 
    -0.00697149f, -0.02514662f, 0.01773952f, -0.02121908f, -0.02087362f, -0.03844966f, 0.01926849f, 0.02703572f, 
    -0.01548028f, 0.01658302f, 0.00125664f, 0.00178666f, -0.01892464f, -0.01841472f, -0.00456393f, 0.03287395f, 
    -0.04168930f, 0.00057557f, 0.00520959f, -0.00122873f, -0.03557116f, -0.00094347f, -0.00977208f, -0.03949662f, 
    -0.00586478f, 0.02636786f, 0.03125203f, 0.00573038f, -0.01615884f, -0.04381932f, 0.01093521f, 0.01862972f, 
    -0.01275693f, -0.02215606f, 0.00026136f, 0.01396414f, -0.00680281f, 0.00698550f, 0.01440387f, 0.00371264f, 
    0.03133143f, 0.01980839f, -0.00241197f, 0.01203131f, 0.00587410f, 0.01997600f, -0.03178013f, 0.01600068f, 
    0.03228362f, 0.01028930f, 0.01522105f, -0.00834831f, -0.00266587f, -0.01777449f, -0.01311030f, 0.00388834f, 
    -0.04203298f, -0.01169252f, -0.00959187f, 0.01245050f, 0.02448770f, 0.00326749f, 0.01369534f, 0.01804516f, 
    0.02518075f, -0.01970446f, -0.02459688f, -0.00548709f, 0.00555894f, 0.00131069f, -0.03865839f, -0.02580253f, 
    -0.01352830f, -0.03674197f, 0.01571032f, 0.00793316f, -0.00919873f, -0.00432068f, -0.00479689f, 0.02196547f, 
    0.00615256f, -0.02126961f, -0.02263764f, -0.01043386f, -0.04026973f, 0.01967776f, -0.02356810f, -0.01849437f, 
    0.01386880f, 0.01055799f, -0.00529732f, 0.01014877f, -0.01227065f, -0.02657804f, 0.02592591f, 0.01009451f, 
    -0.03802377f, -0.00325700f, 0.02707943f, -0.03132963f, 0.02513211f, -0.00536583f, 0.02835019f, -0.01002913f, 
    -0.02652876f, -0.02980400f, -0.01263216f, -0.00487692f, -0.03120121f, -0.02058708f, -0.03725233f, 0.01902248f, 
    0.01241315f, -0.01713597f, 0.01242253f, -0.04047312f, 0.02580853f, -0.02829366f, -0.02543500f, 0.00061041f, 
    -0.01067679f, -0.01345392f, 0.01075270f, 0.02758808f, 0.01676823f, -0.01933900f, 0.01350368f, -0.00682115f, 
    0.02562653f, -0.02044240f, -0.03314592f, -0.01679623f, 0.02654751f, -0.00778604f, -0.02759755f, -0.01004609f, 
    -0.03580889f, 0.02334123f, -0.01506910f, -0.02816208f, 0.01151631f, -0.04042190f, -0.03869174f, 0.01288943f, 
    0.01691766f, -0.00208014f, -0.02226105f, -0.00344995f, -0.01702360f, -0.01556178f, -0.00882991f, 0.01071241f, 
    0.01166777f, -0.03296613f, -0.04094325f, -0.00721042f, -0.04314769f, -0.01483347f, -0.01437157f, 0.02530362f, 
    -0.01978495f, -0.02578522f, 0.01643345f, 0.00839757f, -0.04210013f, -0.00927376f, -0.01693375f, -0.02014574f, 
    -0.02257469f, -0.02237790f, -0.03475087f, -0.03411736f, 0.01363790f, -0.00658074f, -0.01245357f, -0.00562346f, 
    -0.01390783f, 0.02541705f, 0.00512334f, 0.00869245f, 0.01769304f, -0.00348026f, -0.00101851f, -0.00956755f, 
    -0.00299032f, 0.00682737f, -0.01901439f, -0.02421733f, -0.03318055f, 0.02637803f, -0.01356306f, 0.00335838f, 
    -0.00052156f, 0.02046988f, -0.03619296f, 0.02495903f, -0.01805516f, 0.00570455f, -0.04294796f, 0.01508820f, 
    -0.03534416f, -0.00648012f, -0.03093117f, 0.00126095f, -0.03490040f, 0.00698770f, -0.03167306f, -0.03245604f, 
    -0.00709820f, -0.00671251f, 0.02662224f, -0.01706551f, -0.00142820f, 0.00113107f, 0.00661420f, -0.04227979f, 
    0.01839066f, -0.00707612f, -0.02157849f, 0.02686617f, -0.00225805f, -0.01863884f, -0.01928641f, -0.03241023f, 
    -0.00062687f, -0.01609263f, 0.01882707f, 0.02059166f, -0.01300676f, -0.02795080f, -0.00134940f, -0.00261969f, 
    0.02587192f, 0.02879985f, -0.02556572f, 0.02907004f, 0.02535968f, -0.01357443f, -0.02158512f, -0.01866847f, 
    -0.00594011f, -0.02452153f, -0.04170234f, -0.00954772f, 0.00697687f, -0.01988562f, -0.03669334f, -0.02702599f, 
    -0.03253482f, -0.00074244f, 0.01297354f, 0.01242086f, 0.00038762f, 0.02793109f, 0.01147521f, -0.02656922f, 
    0.02403843f, -0.03094126f, 0.02747043f, -0.00636318f, 0.01041268f, 0.01543605f, -0.03044611f, 0.02699424f, 
    -0.02394199f, 0.02055794f, -0.01495397f, -0.03534720f, -0.02104797f, -0.02909772f, -0.03128633f, -0.03418066f, 
    -0.02469501f, 0.02077659f, -0.01820851f, 0.00206700f, -0.01468283f, -0.00975183f, -0.00171918f, 0.02124373f, 
    -0.01016513f, -0.03269883f, -0.03931013f, 0.01263205f, 0.02728846f, -0.03962710f, 0.00427253f, -0.02846953f, 
    -0.01504905f, -0.00059860f, -0.03697587f, -0.00654729f, -0.01736415f, 0.02747489f, -0.02826842f, -0.00880944f, 
    -0.02471860f, -0.02616706f, 0.00313930f, -0.03304911f, 0.02137437f, 0.02398678f, 0.01165274f, -0.02349097f, 
    0.00426604f, -0.00678776f, 0.00497676f, -0.02808391f, -0.00974979f, 0.01006041f, 0.01117022f, -0.01559272f, 
    -0.02045491f, 0.02788483f, -0.02433411f, -0.02998322f, -0.03628233f, -0.03036634f, 0.00390139f, 0.02788680f, 
    -0.01712251f, -0.02082649f, -0.01218869f, -0.00719057f, 0.00277992f, -0.02978293f, 0.00492243f, -0.03468300f, 
    -0.00538887f, 0.00302322f, -0.01577310f, -0.01105063f, 0.01882402f, 0.00526127f, -0.00362758f, -0.01563634f, 
    -0.01074350f, 0.02318226f, -0.02334608f, 0.00723333f, -0.02933237f, -0.01543494f, -0.01876801f, 0.02129828f, 
    -0.03318900f, 0.02056728f, 0.00750163f, 0.00857669f, -0.00379477f, -0.00348122f, -0.00931057f, -0.03485256f, 
    -0.04427361f, -0.02814760f, 0.00035666f, -0.02532419f, -0.04402046f, 0.01990152f, 0.02659658f, 0.02935350f, 
    -0.04178523f, 0.01070630f, 0.01445263f, 0.00079085f, -0.01410263f, 0.01391813f, -0.02337490f, 0.00091967f, 
    0.01955215f, -0.01912309f, 0.02428984f, -0.00644532f, -0.03327531f, -0.02693101f, -0.00192535f, -0.02743525f, 
    -0.00781816f, 0.00281380f, -0.04209663f, -0.03050349f, -0.02568492f, -0.03053584f, 0.01733816f, -0.02940509f, 
    -0.01443991f, 0.00049518f, -0.02536760f, 0.01144454f, -0.04041739f, -0.04223950f, -0.02417465f, 0.00258272f, 
    -0.00756181f, 0.01429569f, 0.00367223f, 0.01350606f, -0.01736116f, 0.01368752f, 0.00919529f, -0.04238325f, 
    -0.02413149f, -0.03341868f, 0.00790555f, -0.00739029f, -0.02326517f, 0.01680562f, -0.03252609f, 0.00788771f, 
    -0.02294039f, -0.02079914f, 0.02224618f, -0.01569503f, 0.00973799f, -0.03410387f, 0.01335232f, 0.02388665f, 
    -0.00284073f, -0.03391457f, 0.00359388f, -0.00993636f, -0.01585109f, 0.00128923f, 0.00234588f, -0.00524895f, 
    0.02426709f, 0.02415276f, -0.03556843f, 0.01717477f, 0.01541244f, -0.03024597f, -0.01777398f, -0.01688329f, 
    -0.02062268f, 0.00677022f, 0.02742286f, -0.03588825f, -0.01208799f, -0.02498940f, -0.01486966f, 0.01291727f, 
    -0.01065516f, -0.01763731f, 0.01572103f, -0.02270567f, 0.01724497f, 0.00292193f, -0.01441687f, -0.00050250f, 
    0.03801714f, -0.04143119f, -0.01401326f, 0.01992277f, -0.02919625f, -0.00856341f, -0.02432689f, -0.02393109f, 
    -0.00934436f, 0.00927197f, 0.00223275f, -0.00312094f, -0.03716094f, 0.00164265f, 0.01344172f, -0.00611938f, 
    0.01658687f, 0.01694928f, 0.02285580f, 0.01486715f, 0.00630035f, -0.00497694f, -0.02461172f, 0.00841716f, 
    0.00560297f, -0.03730965f, -0.04238123f, -0.00702764f, -0.03567508f, -0.00025401f, 0.01609207f, 0.02098416f, 
    -0.02557909f, 0.02283347f, -0.00926169f, 0.01604740f, 0.00029337f, -0.03599087f, -0.02004346f, -0.02778589f, 
    -0.02450123f, 0.01749426f, 0.01615032f, 0.01607280f, -0.02950723f, -0.01199549f, -0.00348869f, -0.03508177f, 
    0.02068044f, -0.00559253f, -0.00532733f, 0.00530227f, -0.01205322f, -0.00569168f, 0.01486054f, 0.02692528f, 
    -0.01563867f, -0.03516020f, -0.04189010f, -0.02310842f, -0.01099692f, 0.00749532f, 0.03511541f, -0.00519445f, 
    0.01490842f, 0.00124040f, -0.00071255f, -0.02484131f, -0.02214266f, 0.01939063f, -0.01146908f, -0.03931921f, 
    -0.01463927f, -0.01621715f, -0.02215235f, -0.01089992f, 0.02192765f, 0.01694402f, -0.02117618f, -0.03046444f, 
    0.00355828f, -0.00839661f, -0.02817901f, -0.02697424f, 0.00029210f, -0.01048950f, -0.02004738f, -0.01049955f, 
    -0.00407670f, -0.03011722f, -0.01216837f, -0.04097940f, -0.01468003f, 0.02563426f, 0.01328697f, 0.01808960f, 
    0.02868544f, -0.03179595f, -0.04096540f, -0.02721821f, 0.00121367f, -0.04180436f, 0.02281939f, -0.02789272f, 
    0.03729066f, -0.00636902f, -0.02522915f, -0.00735624f, -0.01770754f, -0.03947474f, 0.01139357f, -0.01380448f, 
    0.02370946f, 0.02915178f, -0.02143374f, -0.03286214f, 0.00092684f, 0.01397277f, -0.02469649f, 0.02029370f, 
    0.00727475f, 0.01636172f, -0.02913588f, -0.03000340f, -0.03085775f, -0.01645794f, 0.01505340f, 0.01402630f, 
    -0.00375356f, 0.00064057f, -0.00555970f, -0.02453020f, -0.02734065f, 0.00542543f, -0.02361447f, -0.03011314f, 
    -0.02939593f, 0.01649529f, 0.02449296f, -0.00463522f, -0.01616722f, -0.03377801f, -0.02484029f, -0.01928447f, 
    0.01779683f, 0.02516898f, -0.01773601f, 0.00311209f, -0.00140367f, 0.01508686f, 0.01223522f, -0.00152543f, 
    -0.00350962f, 0.01596479f, 0.02110467f, 0.02239067f, 0.01927115f, -0.04408610f, -0.00777394f, 0.02765367f, 
    0.00051491f, -0.02777290f, -0.00189514f, 0.02617573f, -0.01185636f, -0.02978878f, -0.01937223f, -0.04021374f, 
    -0.03768383f, -0.03904761f, 0.02505976f, -0.00233496f, -0.01802654f, 0.02391886f, 0.02303171f, -0.03933955f, 
    0.00801442f, 0.00648160f, -0.00425400f, -0.04198702f, -0.04078660f, -0.00972994f, 0.02519813f, 0.01473027f, 
    0.00864769f, -0.00573576f, 0.01509403f, -0.03423859f, 0.02079154f, 0.02202298f, -0.00091240f, 0.00707497f, 
    -0.03559530f, -0.03392069f, 0.01757449f, 0.02277754f, 0.01572776f, 0.00464353f, 0.01827314f, -0.04053317f, 
    0.00716616f, -0.01891138f, 0.01791466f, 0.02804680f, 0.00436942f, -0.03017207f, 0.02896399f, -0.02356219f, 
    0.00156227f, -0.00253370f, 0.02275973f, -0.03703806f, -0.03212274f, 0.02817138f, -0.03844952f, -0.00620472f, 
    0.34263748f, -0.08279654f, 0.16142602f, 0.15739372f, -0.11344168f, 0.03153784f, 0.06226542f, 0.01789198f, 
    -0.06881382f, -0.01443630f, 0.03588017f, -0.04472578f, 0.03663313f, 0.11410496f, 0.09755728f, 0.17645997f, 
    -0.11288453f, -0.02771586f, -0.07453035f, 0.00293996f, 0.05031212f, -0.00350537f, -0.02700343f, 0.10531095f, 
    -0.16821592f, -0.01691844f, -0.03678164f, -0.01927212f, 0.06559153f, 0.12521963f, 0.00572023f, 0.06212174f, 
    0.02520875f, 0.01370827f, 0.00771761f, -0.08400440f, -0.19323640f, 0.02384440f, -0.01137097f, -0.09124313f, 
    -0.03280410f, -0.05640296f, 0.01006663f, 0.09044091f, 0.01489852f, 0.00163261f, -0.05611401f, -0.04235278f, 
    0.36445796f, 0.10392962f, -0.02242543f, 0.12168477f, -0.08728609f, 0.01132007f, 0.02561481f, 0.07818519f, 
    -0.06631283f, 0.02991374f, 0.02876261f, -0.01460431f, -0.03433038f, -0.00459978f, -0.01238948f, -0.15113144f, 
    0.01960029f, -0.01417466f, 0.01063851f, 0.05930607f, 0.05302862f, -0.03473973f, 0.05852662f, 0.07012470f, 
    -0.14371900f, -0.21702209f, -0.02687855f, 0.25359938f, 0.09149592f, -0.08738064f, 0.01511987f, -0.13391423f, 
    -0.04688985f, -0.00333980f, 0.02920330f, 0.10955008f, -0.09077733f, 0.01970529f, -0.05104352f, -0.16956899f, 
    0.02375223f, -0.04208148f, -0.03242845f, 0.10875606f, 0.11552495f, 0.06194760f, -0.10011907f, 0.03340873f, 
    -0.30280554f, 0.11226994f, 0.02376775f, 0.04687880f, 0.04390760f, 0.01702157f, -0.05118003f, 0.05154530f, 
    0.00685270f, -0.12433904f, 0.02353813f, -0.05874169f, -0.03624462f, 0.02581190f, -0.10513985f, -0.08658852f, 
    0.07973478f, -0.01875680f, -0.06559385f, 0.09077892f, -0.01846534f, -0.15098281f, -0.02543576f, -0.08511842f, 
    -0.01885937f, 0.20568903f, 0.01053327f, -0.03004531f, -0.02305910f, -0.04753499f, 0.00673524f, -0.02721604f, 
    -0.12298124f, -0.01302789f, -0.03224307f, -0.04683496f, 0.23372220f, 0.16151623f, 0.04449090f, -0.11537098f, 
    -0.06423400f, -0.03076911f, 0.03835786f, -0.02369209f, -0.01082840f, 0.06877508f, -0.03906172f, -0.06624945f, 
    0.06002659f, -0.10865381f, -0.05049114f, -0.01050151f, -0.01938319f, -0.05257910f, -0.00793291f, 0.12522303f, 
    0.01311179f, 0.09125597f, -0.07888057f, -0.10944847f, 0.25413808f, 0.07758620f, 0.06297480f, -0.00909348f, 
    -0.05308097f, -0.07479902f, 0.07720407f, -0.03198732f, 0.02402063f, -0.00983605f, -0.01327862f, -0.19834489f, 
    0.11450651f, 0.32349119f, 0.08352230f, 0.08974072f, 0.16020198f, 0.07714530f, -0.01661722f, 0.05502463f, 
    -0.11024517f, -0.09138750f, 0.06400412f, 0.12253857f, -0.04534087f, 0.08279917f, 0.14414708f, 0.05154618f, 
    -0.02235744f, 0.07922540f, 0.06828608f, 0.06612377f, -0.10387963f, -0.00073241f, -0.04892869f, -0.01028357f, 
    0.17812541f, 0.07886714f, 0.00010231f, 0.05149196f, -0.07542241f, 0.06219487f, 0.03780412f, -0.01116780f, 
    -0.00611347f, -0.00468671f, 0.00111700f, 0.06581218f, -0.00965318f, -0.10558496f, 0.02335375f, 0.16116893f, 
    -0.01383883f, 0.00979250f, -0.06279612f, 0.16931668f, -0.04953742f, 0.12188042f, 0.00912287f, 0.01632318f, 
    -0.12231692f, -0.01779713f, -0.14399776f, -0.06780310f, 0.02652205f, 0.07083526f, -0.05532875f, 0.00232163f, 
    -0.07957002f, -0.06112587f, 0.00863957f, 0.06386344f, -0.36641926f, 0.03921611f, 0.01403812f, -0.06349001f, 
    -0.02187653f, 0.01404238f, -0.03525497f, 0.19275101f, 0.01135851f, 0.15765485f, 0.05261597f, 0.08122644f, 
    0.28084445f, 0.17515601f, -0.02458804f, 0.00601809f, -0.06791628f, 0.00725742f, 0.05324694f, 0.00665847f, 
    0.00350291f, 0.02016274f, -0.03905101f, -0.03513044f, -0.16603361f, -0.22335942f, -0.09687907f, -0.17226239f, 
    -0.03973137f, -0.00600423f, -0.07146347f, -0.07157984f, 0.02427932f, -0.04223990f, 0.09541923f, -0.06462196f, 
    0.11969868f, 0.07650117f, -0.14532760f, 0.26882210f, 0.07630184f, -0.03318348f, -0.09494822f, 0.09103527f, 
    0.08471274f, -0.01628964f, 0.07851929f, -0.03313143f, -0.27860031f, -0.10072659f, -0.10888823f, -0.14815833f, 
    -0.06650470f, 0.02686658f, 0.03542013f, -0.04492166f, -0.02256173f, 0.04846754f, 0.13759339f, 0.01161498f, 
    0.11215700f, 0.06941947f, -0.03238837f, 0.12775515f, 0.07181160f, 0.00850780f, -0.11877328f, 0.05177460f, 
    0.03743718f, 0.08789213f, 0.07508255f, 0.03089717f, 0.02887915f, -0.06157687f, -0.05464943f, -0.01985195f, 
    -0.03116326f, -0.02993534f, 0.02415919f, -0.10419227f, 0.03998591f, 0.04133878f, -0.07875489f, 0.01865532f, 
    0.36559740f, 0.06272866f, 0.03857607f, 0.04455179f, -0.06219281f, 0.00622186f, 0.05293471f, -0.13054618f, 
    -0.01047617f, 0.02366553f, 0.05790583f, -0.00966199f, -0.13087296f, 0.15728182f, 0.27291614f, 0.07124130f, 
    0.07844066f, 0.00253121f, 0.09699734f, 0.07365981f, -0.05678076f, -0.03034076f, 0.05454879f, 0.04325155f, 
    0.28429216f, 0.12166140f, -0.03664894f, 0.09153878f, -0.19457154f, -0.00785157f, 0.04443063f, -0.18726201f, 
    -0.00755926f, 0.02483516f, 0.08382130f, 0.00673592f, 0.16861053f, 0.09162290f, -0.04718113f, 0.10018181f, 
    -0.03641582f, 0.06297506f, 0.06836977f, -0.04536038f, -0.07809917f, -0.03309860f, 0.01420981f, -0.08177441f, 
    0.14532118f, 0.11945148f, 0.05377854f, -0.04507511f, 0.01623943f, 0.03651605f, 0.03280581f, 0.06211983f, 
    -0.02148888f, 0.05037436f, 0.05127218f, -0.01013305f, 0.08718584f, 0.14489153f, 0.02168378f, 0.08162564f, 
    0.03631940f, -0.06385770f, -0.10773927f, -0.04142806f, 0.14199288f, -0.10539655f, -0.01309182f, -0.00623799f, 
    0.30149412f, 0.05075071f, 0.07413033f, 0.05337939f, -0.06196215f, -0.13961798f, 0.06375582f, -0.03251427f, 
    -0.04765332f, 0.09477077f, -0.02773012f, -0.11096074f, 0.36870882f, -0.01337644f, 0.12758280f, 0.15675375f, 
    -0.08981618f, -0.00534166f, 0.05298870f, 0.10478887f, -0.01381891f, -0.04930551f, -0.06747442f, 0.00095329f, 
    -0.02881694f, -0.19122843f, -0.08012092f, -0.13885964f, 0.01212956f, 0.02633980f, -0.03848777f, 0.02741856f, 
    -0.05857712f, -0.01305402f, -0.06430542f, -0.01077316f, 0.38256091f, 0.07405186f, 0.05679880f, 0.20836751f, 
    0.03786962f, -0.08310565f, 0.06891895f, 0.07385590f, -0.10499585f, -0.04348934f, 0.02115910f, 0.02493914f, 
    -0.10232171f, -0.21323739f, -0.08513981f, -0.14028083f, 0.03867443f, 0.00093492f, 0.00950128f, -0.07968429f, 
    0.11871897f, 0.08738261f, 0.05185302f, 0.04952946f, 0.12377311f, 0.27681255f, 0.06801398f, 0.08236107f, 
    -0.06896541f, -0.02127657f, 0.03296262f, 0.05133045f, -0.01575784f, -0.06078104f, -0.01308259f, 0.03744069f, 
    0.10168319f, -0.16409145f, -0.18254149f, -0.07546300f, 0.03636537f, 0.00521642f, -0.02553694f, -0.05393921f, 
    -0.03818493f, -0.02947332f, -0.01426824f, -0.00386615f, -0.15421568f, -0.13074058f, -0.11570806f, -0.10013831f, 
    0.07002803f, -0.06683540f, -0.02742022f, 0.00146149f, 0.09837563f, 0.02356767f, -0.08766138f, 0.01703497f, 
    0.19515501f, 0.02143008f, 0.16366626f, 0.19147123f, 0.00423735f, -0.08538862f, 0.03347925f, 0.06143146f, 
    0.07304049f, 0.07187827f, -0.07420654f, 0.02812141f, 0.01364981f, 0.32579476f, -0.00118600f, 0.15050961f, 
    0.02139645f, 0.08267282f, -0.01359416f, 0.07321607f, 0.02051713f, 0.05040358f, -0.01565014f, -0.05446772f, 
    0.03193527f, -0.16540743f, -0.04462237f, 0.00162271f, 0.12218022f, -0.06934796f, 0.06735045f, 0.03075108f, 
    0.02949974f, 0.10973585f, -0.06939804f, -0.03431935f, 0.16551888f, -0.01960277f, -0.12832451f, 0.30750674f, 
    0.13232663f, 0.01016619f, -0.01525775f, -0.00582737f, -0.10661506f, -0.10346750f, -0.05421007f, -0.04720128f, 
    -0.02273181f, -0.26787347f, -0.29805070f, -0.04952951f, 0.03694647f, -0.00752052f, -0.04793648f, -0.04202849f, 
    0.07286792f, -0.03954102f, -0.04851483f, 0.07697668f, 0.00789019f, 0.07835163f, 0.10472144f, 0.04371359f, 
    0.07014656f, 0.02162762f, -0.03484273f, -0.01245624f, 0.09575479f, 0.02740801f, 0.01393346f, -0.00835974f, 
    0.22188690f, 0.08915182f, -0.05155577f, 0.17041543f, -0.07553475f, -0.06023767f, -0.05965822f, 0.08087052f, 
    0.09201627f, -0.02342599f, 0.02677475f, -0.03119165f, -0.02290128f, -0.15531176f, -0.22518066f, -0.19792975f, 
    -0.01762342f, -0.03473559f, 0.04729735f, -0.03735881f, 0.14145702f, -0.09023232f, 0.04223628f, -0.01485116f, 
    0.04348799f, -0.21279168f, -0.01270456f, 0.01898821f, -0.02086304f, -0.07288857f, -0.06249268f, 0.10895704f, 
    -0.01507899f, -0.03787306f, -0.09415233f, -0.12645867f, -0.09212577f, -0.14222912f, -0.06456326f, -0.15754415f, 
    0.05088079f, -0.00619478f, 0.02513366f, 0.04359889f, 0.12365180f, -0.03114694f, -0.02763476f, 0.06532662f, 
    0.04890791f, -0.17910090f, -0.30430278f, -0.08183516f, 0.11267140f, -0.00469789f, 0.00435929f, -0.08124595f, 
    -0.07249870f, -0.02805394f, -0.09185591f, 0.10728712f, 0.20013785f, 0.22216874f, 0.15969752f, -0.03671093f, 
    0.02459647f, 0.04428221f, -0.00759857f, -0.04124628f, 0.09650724f, -0.06551077f, 0.00711411f, 0.00244396f, 
    0.09963907f, 0.19404128f, 0.07561766f, -0.01626595f, -0.00454023f, 0.07849964f, 0.10123243f, 0.01479885f, 
    -0.05067048f, 0.08021232f, -0.07316798f, -0.04791885f, -0.13913822f, -0.31219852f, -0.05585122f, -0.01586006f, 
    -0.04029952f, 0.05529005f, -0.06414149f, -0.02703902f, 0.06613629f, 0.06589998f, 0.02356911f, 0.02497839f, 
    -0.04733729f, 0.21576478f, -0.01649070f, 0.16603786f, -0.10285621f, -0.07243605f, 0.07862179f, 0.16502112f, 
    -0.08617435f, -0.02402164f, 0.12553824f, 0.02340791f, -0.10746865f, -0.16592634f, -0.14362161f, -0.18701471f, 
    -0.04653855f, 0.07260052f, -0.03457652f, 0.08528560f, -0.04093500f, 0.01427571f, 0.01608206f, -0.03618105f, 
    -0.20050073f, -0.29315051f, -0.21817446f, -0.21802142f, 0.00302603f, -0.02476736f, 0.00705268f, -0.03343132f, 
    0.05842950f, -0.07594955f, -0.01501840f, -0.05244027f, -0.30131781f, 0.04030874f, 0.13443407f, 0.01867491f, 
    0.01597652f, 0.06299873f, -0.06426942f, 0.05912432f, 0.05794763f, 0.12070593f, -0.03122314f, 0.03593703f, 
    0.29616407f, 0.10275947f, -0.05294776f, 0.17939202f, -0.02753665f, 0.10437348f, 0.02898268f, -0.06444349f, 
    -0.09395883f, 0.01944505f, -0.02885420f, -0.02167283f, 0.09147466f, -0.18478371f, -0.07641669f, 0.04313871f, 
    0.07361701f, -0.02107094f, 0.00143269f, 0.03761133f, 0.05655667f, 0.10290042f, -0.01277316f, 0.05973244f, 
    0.01507479f, 0.07166493f, 0.01614111f, 0.03633723f, 0.00183410f, 0.12510628f, 0.10018947f, -0.07016051f, 
    -0.00571439f, -0.02977123f, -0.02041882f, -0.05072589f, 0.13826585f, -0.09748106f, -0.11759195f, 0.10705894f, 
    0.01489249f, -0.04738675f, -0.04343766f, -0.12037711f, -0.06798556f, -0.04742612f, 0.02717220f, -0.09680086f, 
    0.21556824f, 0.16240335f, -0.24278566f, 0.20997475f, 0.03708569f, -0.08051766f, 0.02903580f, -0.01333131f, 
    -0.03802818f, 0.04535438f, 0.15516479f, -0.04688555f, 0.10255200f, -0.07900227f, 0.02147150f, 0.04055695f, 
    0.03808959f, 0.01777371f, -0.01780904f, 0.06145507f, 0.04388117f, -0.02107662f, -0.10478032f, -0.01393954f, 
    0.01333984f, 0.01338863f, 0.01010128f, 0.01516820f, -0.01413590f, -0.02593182f, -0.02667134f, -0.02645177f, 
    -0.03448782f, 0.00160728f, -0.03916523f, 0.00342931f, -0.02342596f, -0.02979549f, 0.00325795f, 0.02266273f, 
    0.01145008f, -0.03517686f, 0.02102245f, 0.03403690f, 0.01539270f, -0.03040225f, -0.02709683f, 0.02975681f, 
    -0.01728603f, -0.03547750f, 0.01191435f, -0.02804579f, 0.02772341f, -0.00011045f, -0.02190101f, -0.01293844f, 
    -0.02175871f, 0.01539071f, -0.03829009f, 0.01056940f, -0.02848250f, -0.01249560f, -0.02117039f, 0.03732606f, 
    0.01538508f, -0.00591954f, -0.00698859f, -0.00357391f, -0.00957258f, -0.01361908f, 0.01188700f, 0.02050339f, 
    -0.01983796f, -0.03992281f, 0.00075359f, 0.02073435f, -0.02832866f, 0.02696821f, -0.00174994f, 0.02164183f, 
    0.01908758f, 0.03453920f, -0.00821992f, -0.02263504f, 0.01056504f, 0.00242783f, 0.02350978f, -0.01867684f, 
    -0.03591005f, 0.00713194f, -0.02965021f, 0.02165072f, 0.00494202f, 0.01198286f, 0.02513118f, 0.01427767f, 
    -0.02345823f, 0.02957885f, -0.01244832f, 0.02459546f, 0.00662935f, -0.00116023f, 0.01186532f, 0.01093113f, 
    -0.02666905f, 0.01279209f, 0.00790797f, -0.02139257f, 0.01665641f, -0.00319312f, 0.01562076f, 0.01818839f, 
    -0.01972750f, 0.02118225f, -0.02034015f, 0.00276457f, 0.02643669f, 0.02707643f, -0.02921093f, 0.01393324f, 
    0.01846597f, 0.02419830f, 0.03162438f, -0.02544835f, -0.02258303f, -0.00771814f, -0.03887512f, -0.03277245f, 
    0.01920024f, -0.00858346f, -0.02837296f, -0.02875989f, -0.02914282f, -0.01452073f, 0.00850753f, -0.01784336f, 
    0.02968660f, -0.01492225f, -0.01590606f, -0.03658115f, 0.02323853f, -0.02551687f, -0.02437031f, -0.02881705f, 
    0.00764686f, 0.01462060f, 0.03417456f, -0.00208743f, 0.00738333f, -0.04560594f, -0.04078123f, -0.01045351f, 
    -0.03024299f, -0.00337119f, 0.01288680f, -0.02955988f, -0.03722218f, -0.02563072f, -0.01139844f, -0.00357518f, 
    0.02549116f, 0.01621937f, 0.00661765f, -0.00771855f, -0.03453316f, -0.02309122f, 0.01085211f, -0.01784429f, 
    -0.01277660f, 0.00863691f, 0.00523997f, -0.02504920f, -0.02764750f, 0.02045487f, 0.01756655f, -0.02747867f, 
    -0.01867173f, -0.02249536f, 0.02006688f, 0.02848005f, -0.01871673f, 0.00924253f, -0.02059133f, 0.01558291f, 
    0.01247669f, -0.01082116f, -0.00805042f, 0.02800817f, -0.00797585f, 0.03072783f, -0.03577376f, 0.00810708f, 
    0.00246580f, 0.01756694f, -0.04208818f, 0.02784798f, -0.01966016f, -0.00091505f, 0.00628690f, -0.01332537f, 
    -0.00281294f, -0.01629263f, -0.01393601f, -0.02358777f, 0.00675999f, -0.02848522f, -0.01479191f, -0.01923510f, 
    -0.03591883f, 0.00352970f, 0.01512960f, 0.00581457f, 0.03060997f, -0.00732337f, -0.02298162f, -0.00720984f, 
    -0.03761328f, 0.01999463f, 0.01236822f, 0.02211537f, -0.00542450f, -0.01105739f, 0.00366163f, 0.01218338f, 
    0.00979041f, -0.02362995f, 0.03664195f, -0.02131745f, -0.00701893f, -0.02494827f, -0.01444688f, 0.03549102f, 
    0.00948355f, -0.00207217f, 0.02750439f, -0.00370355f, 0.00575996f, -0.01330217f, -0.00491975f, 0.00835765f, 
    0.01470129f, -0.01197981f, -0.01063644f, 0.00432348f, 0.01192776f, 0.01901268f, 0.02188020f, 0.02288693f, 
    -0.00307279f, 0.02233585f, -0.00195825f, 0.00568168f, -0.01662436f, 0.02225388f, 0.02371549f, -0.01438263f, 
    0.02234739f, 0.00151405f, 0.03369687f, -0.01764093f, 0.02435213f, -0.01317916f, -0.00643583f, -0.01162475f, 
    0.04041913f, -0.02227404f, -0.00414024f, 0.02293753f, -0.02485061f, 0.00533300f, 0.01910741f, -0.03114790f, 
    0.00493162f, -0.01105612f, -0.03000802f, 0.02929190f, -0.02375856f, -0.00614414f, 0.03113151f, -0.02376511f, 
    -0.01191211f, 0.03232008f, -0.02994348f, 0.02326631f, -0.01673244f, 0.01926614f, 0.00552363f, -0.03846632f, 
    0.00847683f, 0.02277469f, 0.03298935f, 0.01710117f, -0.02479103f, 0.02304423f, -0.01166629f, 0.03788740f, 
    0.01781762f, -0.03440968f, -0.00266910f, -0.00579131f, -0.01835914f, -0.03179267f, -0.01570428f, 0.01273169f, 
    -0.04295300f, 0.00704300f, 0.02124954f, 0.00483508f, -0.01032219f, 0.01206777f, -0.03891087f, 0.02826679f, 
    -0.00065575f, -0.03679907f, -0.01066213f, -0.02301778f, 0.01901649f, -0.03526647f, 0.03885168f, -0.03618795f, 
    -0.01337194f, -0.01806840f, -0.00738752f, -0.00412620f, -0.00241284f, 0.01882724f, -0.03787376f, -0.04755614f, 
    0.02067909f, 0.02536092f, 0.00406845f, 0.01810948f, -0.02946804f, 0.02999069f, 0.04345994f, 0.02668560f, 
    -0.01344694f, -0.03656028f, -0.03771385f, -0.01118482f, -0.04274373f, 0.01309580f, -0.04098133f, -0.00752899f, 
    0.02451847f, 0.02408651f, -0.03711617f, 0.01689026f, -0.00008116f, -0.02743190f, -0.03843334f, -0.03211846f, 
    0.01948751f, 0.01219306f, -0.00596622f, 0.02557098f, -0.01615216f, -0.01577164f, -0.03829446f, -0.03091969f, 
    -0.03310135f, 0.00961831f, 0.00294788f, 0.02650579f, -0.05150256f, -0.04629127f, -0.01471898f, -0.01935160f, 
    0.02456536f, -0.03285278f, -0.00753989f, 0.02339078f, 0.01095269f, -0.00338693f, -0.01654732f, 0.02590906f, 
    0.00305009f, -0.00149099f, -0.02638026f, 0.00162049f, -0.02283508f, -0.02225900f, -0.03304065f, -0.02547400f, 
    0.00598819f, -0.01889580f, 0.02371336f, 0.00682147f, 0.01355278f, 0.01742636f, -0.02881050f, -0.01949595f, 
    0.03004776f, 0.03039477f, 0.01718350f, 0.00152801f, 0.00268353f, -0.01198063f, 0.00678600f, -0.03696039f, 
    -0.01910218f, -0.01362040f, 0.02124074f, -0.03479059f, -0.00870088f, -0.02753014f, 0.02926360f, 0.00240978f, 
    0.02500636f, -0.04426215f, -0.01834201f, -0.01422381f, -0.03126477f, -0.02578973f, -0.04116601f, 0.01283894f, 
    -0.00248759f, -0.03983837f, 0.00762465f, 0.02948063f, -0.03516690f, 0.01064213f, -0.03502430f, 0.00870145f, 
    0.00087064f, 0.03294298f, -0.04095395f, -0.00642466f, 0.00977023f, -0.01782216f, 0.01823267f, -0.00604356f, 
    -0.03030802f, 0.03154877f, 0.02382860f, 0.03142812f, 0.02439652f, -0.02259732f, -0.03114593f, -0.01434403f, 
    0.00057844f, -0.01393285f, -0.00668391f, 0.01109786f, 0.01601720f, -0.03310781f, -0.01923901f, 0.01251837f, 
    -0.02613261f, -0.02661769f, -0.00786331f, -0.03036486f, 0.02124791f, 0.00615112f, -0.02651521f, 0.00900117f, 
    -0.01249874f, -0.01259196f, 0.02745343f, -0.01858947f, 0.01623270f, 0.01323228f, 0.01416634f, 0.00353705f, 
    -0.03754088f, -0.03196880f, -0.00322852f, 0.02243605f, -0.02945429f, -0.01509533f, 0.02529346f, -0.00318135f, 
    -0.04313746f, -0.01832506f, -0.01166276f, -0.03972275f, 0.01397172f, 0.02589128f, -0.02784733f, -0.00632278f, 
    -0.03328963f, 0.01428592f, 0.00732691f, 0.00508856f, -0.02054164f, -0.01131529f, -0.02901186f, 0.02380380f, 
    -0.02882626f, -0.01377603f, -0.03998339f, -0.00502296f, 0.01388303f, 0.02932517f, 0.02205956f, 0.00023133f, 
    -0.01286333f, -0.02756753f, -0.00814952f, 0.01750431f, 0.00471802f, -0.00272476f, 0.00437718f, -0.00010632f, 
    -0.00366487f, 0.01429938f, 0.02284901f, -0.02604360f, -0.01394887f, -0.02892647f, -0.00023340f, -0.01943116f, 
    -0.03124662f, 0.01836758f, 0.01000972f, 0.01825314f, -0.02430403f, 0.01534673f, 0.00226210f, 0.02679280f, 
    0.00152354f, -0.03129526f, -0.01855217f, -0.00126008f, -0.01299700f, -0.03846880f, 0.03649890f, 0.02381796f, 
    -0.03953087f, -0.01884616f, -0.00350216f, -0.02229868f, 0.01589308f, -0.03569224f, -0.01904636f, -0.02774289f, 
    -0.03639599f, 0.01741391f, 0.00699070f, 0.00135377f, -0.03173704f, -0.03118576f, 0.01265114f, -0.00309752f, 
    -0.02500017f, 0.01725735f, -0.03458682f, -0.00546693f, 0.00259132f, -0.02355807f, -0.01455791f, -0.01248700f, 
    0.03403067f, -0.01288955f, 0.00563319f, -0.03523293f, 0.02769207f, -0.00333424f, 0.03427684f, 0.01144333f, 
    -0.02522441f, 0.02741846f, -0.01936945f, 0.04212618f, -0.02194672f, 0.00991572f, -0.00763602f, -0.03948402f, 
    0.01282499f, -0.03153518f, -0.02471689f, -0.03921903f, -0.03858962f, 0.01745886f, -0.00915890f, -0.01946500f, 
    0.01332068f, 0.01617696f, -0.02244118f, 0.02705314f, 0.02450926f, -0.01695694f, -0.03047963f, -0.02638936f, 
    0.02648243f, -0.01057820f, 0.01457194f, -0.02089905f, -0.01474429f, 0.03268599f, -0.02613283f, -0.02335580f, 
    0.01671960f, -0.01365067f, -0.00531426f, -0.01399131f, -0.00601176f, 0.01148398f, -0.00796856f, -0.01662281f, 
    0.00393711f, -0.02665570f, 0.01258916f, 0.00749881f, -0.02618706f, -0.00078011f, 0.01667748f, 0.02258163f, 
    0.00808080f, -0.02579068f, -0.01990751f, -0.00112221f, 0.02047972f, 0.00158781f, 0.00719459f, 0.02134622f, 
    -0.01690108f, -0.04410008f, 0.01061896f, 0.02791746f, 0.03243124f, -0.00098529f, -0.04602957f, -0.02443980f, 
    -0.01397637f, 0.00013122f, -0.01464154f, 0.01129517f, -0.04084927f, 0.01340469f, -0.00571201f, 0.01171971f, 
    0.01488257f, 0.03357457f, -0.00645249f, 0.02566494f, 0.01853600f, -0.03039262f, -0.04216275f, -0.04419839f, 
    0.02106399f, -0.02379654f, -0.03963838f, 0.01573526f, -0.03881771f, 0.02863374f, -0.03428183f, 0.00260989f, 
    -0.02979133f, -0.00066310f, -0.01708118f, 0.01945294f, -0.02472983f, -0.03120983f, 0.02044757f, -0.03368070f, 
    -0.02375349f, -0.03731058f, 0.01150709f, -0.03060555f, 0.00158530f, 0.01184443f, 0.01323602f, 0.02024115f, 
    -0.02653027f, 0.00258724f, 0.00331068f, -0.01920124f, -0.03699242f, -0.00389052f, -0.04210313f, -0.02129922f, 
    0.02208279f, 0.02667140f, 0.00496405f, 0.00219680f, -0.02544150f, -0.03088961f, 0.00623173f, -0.02365056f, 
    -0.02557355f, 0.01503219f, -0.02100114f, -0.03158859f, -0.02720671f, 0.02074218f, -0.03960204f, -0.00349425f, 
    0.02699399f, 0.02151824f, 0.00377214f, -0.03080569f, -0.01685028f, -0.04448038f, -0.02166559f, -0.03525094f, 
    -0.01487166f, -0.01651964f, -0.00230922f, 0.00896729f, 0.00772910f, -0.01131792f, -0.00738875f, 0.01551434f, 
    -0.01292767f, -0.04096514f, 0.00868650f, -0.04569297f, -0.03395302f, 0.02921997f, -0.03506309f, -0.00618190f, 
    -0.01581682f, -0.03158057f, -0.00994928f, 0.01090818f, 0.00366495f, 0.02999834f, -0.01694912f, -0.00496185f, 
    0.02055628f, 0.02572021f, 0.01664186f, -0.03051614f, -0.02744451f, 0.03341861f, 0.00154440f, -0.01362787f, 
    0.01315942f, -0.01385900f, -0.02571233f, 0.02966799f, -0.02068429f, -0.02474816f, -0.02489246f, -0.04320202f, 
    -0.02307208f, -0.03159659f, -0.00999042f, -0.01829798f, -0.01551260f, 0.01416176f, 0.01052858f, -0.01013368f, 
    -0.03364622f, -0.02524292f, -0.03554370f, -0.00801961f, 0.00328353f, -0.00486490f, 0.01830352f, 0.01519625f, 
    -0.03740569f, -0.00879124f, -0.00615988f, 0.00660044f, -0.02917191f, -0.01823886f, 0.01068410f, -0.02645164f, 
    0.01805279f, -0.01381942f, 0.02749880f, 0.02563939f, -0.02326501f, -0.01044568f, -0.01177322f, -0.01183700f, 
    -0.02861001f, 0.01265566f, 0.01350620f, 0.01059116f, 0.02455697f, 0.00036846f, -0.01040437f, -0.01571557f, 
    -0.00518370f, 0.01673840f, 0.00657406f, -0.02546832f, -0.02884321f, -0.01517581f, -0.00626500f, -0.00049336f, 
    -0.02534184f, -0.00797003f, 0.03070623f, 0.00375268f, -0.02399946f, -0.00039427f, 0.00505954f, 0.00818707f, 
    -0.02490025f, -0.04054888f, -0.00783645f, 0.02095008f, -0.02519864f, 0.01520104f, 0.00491383f, -0.03645056f, 
    -0.03268322f, -0.02054679f, 0.02002666f, 0.01529694f, 0.01078009f, -0.01553351f, 0.00636567f, -0.01439199f, 
    -0.00461376f, -0.03139405f, -0.00025466f, -0.03122465f, -0.02964573f, -0.02866839f, -0.02100320f, 0.00466377f, 
    -0.01645915f, -0.00938398f, -0.00743797f, 0.03169886f, 0.01766108f, -0.03489484f, 0.00478989f, -0.02774042f, 
    0.00856841f, 0.03265898f, -0.02360646f, -0.01250506f, -0.01842481f, -0.02309381f, -0.01357122f, -0.03991367f, 
    -0.00718808f, 0.02025135f, 0.01871137f, -0.01955087f, -0.01790422f, 0.01826347f, 0.00289051f, -0.01270525f, 
    0.01910395f, -0.02421543f, 0.00129416f, -0.00581410f, 0.02256246f, 0.01401811f, 0.02594241f, -0.02855414f, 
    -0.01192315f, -0.03092763f, -0.01602661f, 0.00835498f, -0.02241271f, 0.02976784f, -0.02416319f, 0.00453519f, 
    0.00818944f, 0.02224424f, -0.02276582f, 0.00177673f, 0.03889640f, 0.01149332f, -0.01125502f, 0.01188916f, 
    -0.02967854f, 0.02533801f, -0.01648129f, -0.03287082f, 0.03537016f, -0.00150385f, 0.00808675f, 0.00261452f, 
    0.00970807f, 0.02240115f, -0.03220885f, -0.00822678f, -0.01299426f, 0.00647034f, 0.02023809f, -0.01160152f, 
    -0.01363228f, -0.02576499f, -0.04198237f, 0.00607133f, -0.00778970f, 0.03101433f, -0.00629615f, -0.00142684f, 
    0.00981489f, -0.00621474f, 0.03026832f, -0.01374808f, 0.01067846f, 0.00068811f, -0.03192730f, -0.00406481f, 
    -0.04461649f, -0.01516672f, 0.02063355f, -0.00415945f, 0.02355581f, -0.00570364f, 0.00314303f, 0.02990719f, 
    -0.01808859f, -0.00112935f, -0.02167577f, -0.02581419f, 0.02553571f, -0.01078045f, -0.00284114f, -0.01993088f, 
    -0.00799192f, 0.00871640f, 0.00074118f, -0.00289995f, 0.00966510f, -0.00606464f, 0.01696608f, 0.00687085f, 
    -0.01341546f, -0.02551013f, 0.01717993f, 0.02918051f, -0.01545492f, 0.02587718f, -0.01560080f, 0.01163613f, 
    -0.02543372f, -0.00053131f, -0.00288438f, -0.03424085f, -0.02185256f, -0.03265708f, -0.02502728f, -0.02340340f, 
    0.00030052f, 0.02396952f, -0.01725976f, -0.02675239f, -0.00230402f, 0.01771578f, -0.02667690f, 0.00360416f, 
    0.01120146f, -0.00211204f, -0.02688179f, -0.00827539f, 0.03059875f, 0.01566496f, 0.01922291f, -0.03562889f, 
    -0.02896417f, 0.01167742f, -0.03517992f, 0.02406701f, -0.01513224f, -0.02031181f, -0.00953913f, -0.02290294f, 
    -0.00538244f, -0.02873536f, -0.03298500f, 0.00195988f, -0.01236007f, -0.00878036f, -0.00200625f, 0.00792616f, 
    -0.01729484f, 0.02561362f, -0.01320580f, -0.03766708f, 0.03676194f, -0.02622441f, -0.01855685f, -0.01863891f, 
    -0.04193360f, 0.00808078f, -0.01875953f, -0.00554837f, -0.00745027f, 0.01646950f, -0.03636621f, -0.02510306f, 
    0.02258466f, -0.03522906f, -0.01966117f, 0.01092731f, -0.03625000f, -0.00907193f, -0.04344132f, 0.02517428f, 
    -0.00411592f, -0.01737050f, -0.00655139f, 0.01158848f, 0.00341250f, -0.00609537f, -0.03985051f, -0.02286837f, 
    0.01205213f, -0.03262036f, -0.02631951f, -0.00500441f, 0.02438001f, -0.02867799f, -0.02074103f, -0.01663949f, 
    0.00389680f, -0.02474678f, 0.00136765f, -0.02252054f, 0.02178161f, 0.03699571f, -0.01496586f, -0.01109336f, 
    0.01260710f, 0.02389151f, -0.00264658f, 0.00523452f, -0.01197847f, 0.02842967f, -0.04271211f, -0.02858478f, 
    -0.02123147f, 0.01543493f, -0.01064253f, 0.01392818f, 0.01035182f, 0.01184617f, 0.01171409f, -0.01836124f, 
    -0.01361664f, -0.02617703f, 0.00180939f, 0.03036960f, -0.01699728f, -0.03006277f, 0.02016820f, 0.01478355f, 
    -0.00762671f, 0.02837159f, -0.01976820f, 0.02495700f, -0.00398101f, -0.02127934f, 0.03641449f, 0.00316584f, 
    -0.00329953f, 0.00935153f, -0.00059608f, -0.00637323f, -0.02570416f, -0.01406145f, -0.01291248f, -0.03870258f, 
    0.02288538f, 0.01820388f, 0.01301865f, -0.04040674f, -0.03631582f, 0.01678549f, 0.02453185f, 0.01826714f, 
    0.00715004f, 0.01197043f, -0.00285326f, -0.04344794f, -0.02787509f, -0.02262910f, 0.01621964f, -0.01968706f, 
    0.00265549f, -0.03601476f, -0.00421335f, -0.02337563f, 0.01568520f, -0.00626255f, 0.01461293f, -0.00717635f, 
    0.00911354f, -0.02729982f, 0.00533044f, -0.01522954f, -0.01259560f, 0.00098266f, -0.01345774f, -0.03532635f, 
    -0.03023019f, -0.02537592f, -0.02051266f, 0.00418652f, -0.03349976f, -0.00550242f, 0.00010249f, -0.03364851f, 
    -0.01754313f, 0.02670174f, 0.02381746f, -0.02764116f, -0.03778586f, -0.02447031f, 0.00012762f, 0.00284874f, 
    -0.01928421f, -0.03398726f, -0.02443611f, -0.03025606f, -0.04255509f, 0.02363175f, -0.02594420f, 0.01046416f, 
    0.02478575f, 0.01053094f, -0.02643101f, 0.02356633f, 0.01028686f, -0.03765249f, -0.00933895f, 0.00953162f, 
    -0.01418031f, 0.00770006f, -0.01554595f, -0.02278541f, 0.00187496f, -0.03264209f, 0.00696879f, -0.03591513f, 
    0.01583317f, 0.00563191f, -0.00819694f, -0.03568010f, 0.01423808f, -0.02034706f, -0.01758711f, 0.00880850f, 
    -0.00237363f, -0.00410540f, 0.01111251f, -0.03132808f, -0.02443479f, 0.00796603f, -0.02249534f, -0.03092945f, 
    0.02599003f, -0.03882967f, -0.00967100f, -0.02628795f, -0.02360552f, -0.02735589f, -0.02222600f, 0.00515659f, 
    -0.02538250f, 0.02055874f, 0.02784823f, -0.02183571f, 0.00483288f, -0.01386245f, -0.00855899f, -0.02556261f, 
    -0.02675672f, -0.02477315f, -0.00585578f, 0.01365191f, -0.00530796f, 0.02701974f, -0.00391165f, -0.00882374f, 
    -0.03176528f, -0.01074495f, 0.00820653f, -0.00807040f, -0.01231152f, -0.01867894f, 0.00183070f, -0.01595327f, 
    0.03331460f, -0.00737871f, -0.00015735f, -0.02449235f, 0.02566225f, -0.02906918f, -0.01897083f, 0.00332282f, 
    0.01294208f, 0.00529521f, -0.00110643f, -0.00635483f, 0.00392472f, -0.02638084f, 0.00248500f, -0.03862302f, 
    -0.03757424f, -0.02175766f, -0.03899812f, -0.00509739f, -0.02562790f, 0.01457554f, 0.02557156f, -0.01960338f, 
    0.00681529f, 0.03037148f, 0.02025731f, -0.01716007f, 0.01628175f, -0.02042320f, 0.00858114f, -0.02501188f, 
    -0.04404256f, -0.02159097f, -0.00588749f, -0.00380925f, -0.02610712f, -0.00806973f, -0.02360407f, 0.01407526f, 
    -0.02835453f, -0.02349044f, 0.01934509f, -0.01379051f, 0.01289674f, -0.03824604f, -0.00285981f, 0.00797858f, 
    -0.02648544f, -0.01618859f, 0.01208665f, 0.01905873f, -0.01201002f, -0.04058658f, -0.03119816f, 0.02978195f, 
    0.02055556f, -0.00176013f, 0.00759884f, -0.01696486f, 0.01670604f, -0.01746814f, -0.03898216f, -0.01076495f, 
    -0.00407549f, -0.00625094f, 0.00456451f, 0.00585254f, 0.02161375f, -0.01997679f, -0.01304396f, -0.01614789f, 
    -0.00775579f, -0.02009581f, -0.00449308f, -0.02066778f, 0.01736112f, -0.00707099f, -0.03331408f, -0.03472583f, 
    -0.01586299f, -0.03064706f, -0.03748367f, 0.00582337f, -0.02817407f, 0.01254993f, 0.00114276f, -0.02597019f, 
    0.02678455f, -0.00551896f, -0.00448737f, -0.01627691f, 0.00219921f, 0.01477983f, -0.02711797f, -0.03854839f, 
    0.01052713f, -0.00313094f, -0.00956611f, 0.03184376f, 0.02786529f, 0.02132979f, -0.02332143f, -0.03398620f, 
    -0.03998142f, -0.00585800f, -0.01792097f, 0.02547015f, -0.00968780f, -0.02531407f, -0.02406341f, -0.04405247f, 
    0.00639849f, -0.02496200f, 0.00083417f, 0.00197179f, -0.01805300f, -0.00641897f, -0.01723309f, -0.03741573f, 
    0.02475859f, 0.02259744f, -0.02830737f, 0.02189634f, 0.00845983f, 0.01032264f, -0.02388271f, 0.01872910f, 
    -0.02675778f, 0.01530156f, -0.00892870f, -0.00325178f, -0.03025528f, 0.00077525f, -0.02138791f, 0.00576856f, 
    -0.00527458f, 0.02628834f, 0.02747481f, -0.02225002f, 0.02212926f, -0.00188630f, 0.01242526f, -0.01496196f, 
    -0.01182638f, 0.00431294f, -0.02288315f, 0.01675111f, -0.02030403f, -0.02827223f, 0.01797338f, -0.00806969f, 
    -0.01678337f, -0.03093100f, 0.00078144f, -0.02527872f, 0.00356027f, 0.01932820f, -0.01546155f, 0.01057927f, 
    0.00597122f, 0.02774405f, -0.01686086f, -0.01798008f, -0.01234931f, 0.00235158f, 0.00557393f, 0.00334053f, 
    -0.01438547f, 0.02494136f, 0.02366669f, -0.02429243f, 0.02167919f, -0.02769118f, -0.03062775f, -0.01876619f, 
    0.00173780f, 0.02296824f, 0.02841819f, -0.00109014f, -0.03152359f, -0.02513798f, -0.03907555f, 0.02389060f, 
    0.00668591f, -0.00875434f, -0.00267448f, -0.00234292f, 0.01250074f, -0.01305196f, -0.00342360f, 0.01224675f, 
    -0.02324557f, 0.00281853f, 0.00599209f, -0.02498952f, -0.03412960f, 0.00129277f, -0.04098794f, 0.00866860f, 
    0.00883581f, -0.01869965f, -0.00467047f, 0.02175351f, -0.01429162f, -0.00004195f, -0.01994396f, -0.02995180f, 
    0.02380896f, 0.01929355f, -0.01558864f, -0.03048590f, 0.02250242f, -0.03535567f, -0.03978219f, 0.00816136f, 
    0.03054433f, 0.01545086f, -0.00737333f, 0.01155953f, 0.01800729f, 0.00749717f, 0.01047776f, -0.01789536f, 
    -0.03920517f, 0.01896721f, 0.00871059f, -0.01017881f, -0.00327708f, 0.01426369f, 0.00149971f, 0.01229341f, 
    -0.01435559f, 0.00563505f, 0.02017316f, 0.00374558f, 0.00461998f, -0.02177300f, -0.01561308f, -0.02992725f, 
    -0.04051046f, -0.02126528f, -0.00411182f, 0.02409548f, 0.00458947f, -0.00089979f, -0.01098077f, 0.00784098f, 
    0.00233509f, 0.00891952f, -0.00506524f, -0.00042839f, 0.02278965f, -0.02699406f, -0.00469763f, -0.01925936f, 
    0.01131209f, -0.01447225f, -0.03832391f, -0.01202376f, -0.00867004f, 0.01104395f, -0.03688163f, -0.01984515f, 
    0.01943235f, -0.04420288f, -0.02105023f, -0.03200934f, -0.02052001f, -0.04002325f, 0.02288575f, 0.00626025f, 
    0.01869753f, 0.01052404f, -0.02431364f, 0.02753544f, -0.02523284f, 0.01294038f, -0.00106183f, -0.03584873f, 
    -0.03221950f, -0.02443506f, 0.02298297f, -0.00699195f, 0.01225493f, -0.01539834f, 0.01694019f, 0.02330766f, 
    0.00197220f, 0.03594496f, 0.01971519f, 0.01033579f, 0.01987833f, -0.00174166f, -0.03378118f, 0.01162260f, 
    -0.03866347f, 0.02493241f, 0.00031968f, 0.00350982f, -0.03665899f, 0.01998878f, -0.00493362f, -0.02913744f, 
    -0.01325072f, 0.01092657f, 0.00459493f, 0.01793385f, -0.02405167f, -0.03615610f, 0.02599784f, -0.03656140f, 
    -0.04084107f, -0.01566540f, -0.00365942f, -0.00338046f, 0.01152027f, -0.03107692f, -0.02644671f, -0.03441329f, 
    -0.01164308f, -0.01085914f, 0.02222923f, -0.00156538f, -0.00645186f, -0.03508820f, 0.02735461f, -0.00310813f, 
    0.00463658f, -0.01846510f, -0.02808308f, -0.01959080f, 0.02240565f, 0.02246987f, -0.03100981f, -0.03164019f, 
    -0.01649202f, 0.03480730f, 0.02513300f, 0.00928969f, -0.01113867f, 0.00486509f, 0.01736663f, -0.03864032f, 
    -0.01708287f, 0.01661748f, -0.01792117f, 0.00662487f, 0.00176238f, 0.00214803f, 0.01750113f, 0.01109473f, 
    -0.01904309f, -0.03064614f, 0.01504381f, -0.03056348f, 0.01232357f, -0.02909749f, -0.02746991f, -0.00940871f, 
    0.00110189f, 0.00863824f, -0.01816151f, 0.01513678f, -0.01855830f, -0.04179894f, -0.03633004f, 0.01967914f, 
    -0.01405581f, -0.00520143f, 0.02563829f, -0.03889252f, -0.01827202f, -0.01009530f, 0.01449913f, -0.03225565f, 
    -0.02075485f, 0.02386048f, -0.01330779f, -0.01614333f, 0.00352188f, -0.03631574f, -0.00883253f, 0.01612481f, 
    -0.05447821f, -0.04740933f, 0.09212903f, -0.03060772f, -0.00066218f, -0.08122666f, 0.03378954f, 0.01463401f, 
    -0.01031929f, -0.03494082f, 0.04560311f, 0.10298504f, 0.07670976f, -0.18978436f, -0.00061671f, -0.17645185f, 
    -0.01737588f, 0.10785741f, -0.08621641f, -0.04886675f, 0.08568684f, -0.03702453f, -0.05773478f, 0.03665948f, 
    0.13120043f, 0.35561094f, -0.08222237f, -0.21686749f, 0.03616460f, 0.02302255f, 0.00071678f, 0.05457932f, 
    0.05790373f, -0.05744697f, 0.12174070f, -0.01411760f, -0.00220091f, -0.09402180f, 0.09490228f, -0.11947427f, 
    -0.00888439f, -0.08087581f, 0.04218145f, 0.02522968f, 0.06377986f, 0.12941460f, -0.13006701f, -0.18054023f, 
    0.08358417f, -0.37702945f, 0.23138620f, -0.14760743f, 0.00409315f, -0.03863751f, -0.02678673f, -0.02586611f, 
    -0.09886022f, 0.06786708f, 0.00008764f, -0.05585071f, 0.14992198f, -0.19959305f, -0.13543445f, 0.05735968f, 
    -0.02221907f, 0.00867335f, 0.11493779f, 0.06829997f, 0.10461053f, -0.00403623f, -0.13225038f, -0.08462858f, 
    0.06110525f, 0.14670563f, -0.12498598f, 0.20111023f, -0.06799283f, 0.06672145f, -0.00554503f, -0.10077501f, 
    -0.03825612f, -0.08390005f, 0.02158931f, 0.06173143f, -0.02258284f, -0.02225000f, -0.14176127f, 0.20206428f, 
    0.11244415f, 0.04449069f, 0.18518749f, -0.01031088f, 0.02029745f, -0.06344283f, -0.10666069f, 0.01410980f, 
    0.11039032f, -0.03525897f, 0.13377817f, -0.14610118f, 0.04253613f, 0.03439807f, -0.04690158f, 0.06514300f, 
    0.00393286f, 0.06306916f, -0.05744426f, 0.12210841f, -0.09066164f, 0.05667675f, -0.10359433f, 0.09777779f, 
    -0.05917360f, 0.05101211f, 0.04445912f, 0.09527135f, -0.09228490f, -0.03566974f, -0.01563964f, -0.02330398f, 
    0.27335131f, 0.21938957f, 0.04188392f, 0.00634704f, 0.04452090f, -0.03452142f, -0.05263561f, 0.13101901f, 
    -0.04397368f, 0.07839565f, -0.11063229f, -0.10382303f, -0.07934950f, -0.10865869f, 0.03297998f, -0.16526571f, 
    -0.02976918f, -0.13069814f, 0.02628372f, 0.07995513f, 0.08331314f, 0.10221903f, 0.07403711f, 0.02138778f, 
    0.33551160f, -0.15837260f, 0.16333897f, -0.30431232f, -0.03082767f, -0.07136552f, 0.00703584f, 0.02008123f, 
    -0.05251548f, 0.15734765f, -0.02452305f, 0.02602609f, 0.22771865f, 0.06665340f, 0.10042571f, 0.03008112f, 
    0.11951686f, 0.02971771f, 0.01500484f, 0.15170074f, 0.03737500f, 0.03053740f, -0.00784138f, -0.04376448f, 
    -0.19848183f, -0.10779906f, -0.10455263f, 0.07011019f, 0.02236318f, -0.00699704f, -0.03678252f, 0.01458095f, 
    -0.05934029f, -0.02517132f, 0.18113053f, 0.00154987f, 0.36644733f, -0.02378635f, -0.03597846f, 0.14806129f, 
    -0.04746225f, -0.04941171f, -0.12721033f, 0.01083562f, -0.00537044f, -0.05221245f, 0.05724804f, 0.01458285f, 
    -0.06780925f, 0.15770617f, -0.07751010f, -0.03282321f, -0.07352218f, 0.03154166f, 0.06027148f, 0.07407688f, 
    0.08308259f, -0.00876033f, -0.14678228f, 0.01490291f, -0.09071960f, -0.23385805f, 0.11977234f, -0.08860499f, 
    -0.02073778f, -0.00876256f, -0.07037992f, 0.03009562f, -0.00690235f, 0.01224624f, 0.13217990f, 0.08680917f, 
    0.39991409f, 0.13342978f, -0.19879247f, 0.15767655f, -0.08019926f, -0.02977393f, -0.02283276f, -0.04472046f, 
    0.00068243f, -0.03500834f, -0.03698603f, 0.02560128f, -0.03198536f, 0.07088768f, 0.17135501f, 0.05390894f, 
    -0.04172444f, 0.03208901f, -0.07948978f, 0.02116783f, -0.07107197f, 0.14308254f, 0.07151255f, -0.01401679f, 
    0.20731297f, 0.13801458f, 0.01472734f, 0.04897136f, -0.04997982f, 0.03316819f, 0.01125557f, 0.15989320f, 
    0.05504375f, -0.03600188f, 0.01150315f, -0.03204338f, 0.22750929f, -0.06180443f, 0.08830293f, 0.18266211f, 
    0.03507586f, 0.04675860f, -0.03748712f, -0.01611290f, -0.01737833f, 0.06725042f, 0.06883042f, -0.07494861f, 
    -0.00769068f, 0.10601041f, -0.08964806f, -0.14577514f, -0.05649415f, -0.06057866f, -0.00713624f, 0.07812790f, 
    0.05784565f, 0.10266314f, 0.02702471f, -0.06014482f, 0.07575575f, -0.06338461f, 0.02039882f, 0.28997493f, 
    -0.04059298f, -0.01258109f, 0.00700113f, -0.11406770f, 0.11884795f, 0.00116156f, -0.03441516f, -0.01335321f, 
    0.14676426f, -0.00065334f, 0.02014343f, -0.40633446f, 0.05252682f, -0.13448577f, 0.08232949f, 0.00034951f, 
    -0.11056970f, 0.05943518f, 0.10567623f, 0.02125494f, 0.47284392f, 0.20147093f, 0.01391539f, -0.22326718f, 
    -0.02080454f, -0.03778486f, 0.07446122f, 0.05978533f, -0.06570017f, 0.13618445f, 0.12287870f, 0.00680435f, 
    0.19762592f, -0.04711076f, 0.07543547f, -0.04624730f, 0.06161822f, 0.02395330f, 0.01752769f, 0.02731195f, 
    0.04774611f, 0.03565070f, -0.04902914f, 0.14349155f, -0.21892482f, 0.10950111f, -0.08342347f, -0.05224918f, 
    -0.01572795f, 0.04759416f, -0.04461261f, 0.15689403f, 0.01950617f, 0.07871055f, 0.00633668f, -0.05044321f, 
    0.24549371f, -0.09024952f, -0.03891260f, 0.01310897f, 0.02905034f, 0.13189137f, 0.03835309f, -0.08137177f, 
    0.06552740f, -0.12743296f, -0.06876992f, -0.12604825f, -0.10281025f, -0.22235139f, -0.03828859f, -0.13552366f, 
    -0.05260819f, 0.09271786f, 0.09966069f, 0.05395916f, -0.02540819f, 0.00717085f, 0.07070366f, -0.02406228f, 
    0.06009547f, -0.16635115f, -0.01559172f, 0.09385534f, -0.05891928f, 0.09321159f, -0.09234277f, 0.14062119f, 
    -0.08085013f, -0.13465920f, -0.00355282f, 0.01644798f, 0.08700566f, 0.03359081f, 0.22019872f, -0.03370629f, 
    0.02616319f, 0.06670024f, -0.11310636f, -0.02163933f, -0.11319184f, -0.20207542f, 0.03372807f, -0.03450313f, 
    0.19265798f, 0.12317435f, 0.04822483f, 0.07207643f, 0.09184156f, 0.01636987f, -0.01864348f, 0.10208998f, 
    0.09044549f, 0.04337203f, 0.07332219f, -0.01038895f, 0.02855723f, -0.02269579f, -0.01178308f, 0.17043345f, 
    -0.12427993f, 0.03518622f, 0.02962260f, 0.06812015f, 0.10979871f, 0.01293686f, 0.00731038f, 0.12351823f, 
    0.36674204f, 0.18075237f, 0.12939838f, 0.10984405f, -0.02007213f, 0.04212637f, -0.01192810f, -0.00088626f, 
    -0.07263411f, -0.00322142f, -0.06947965f, -0.03608497f, 0.25036424f, 0.20652130f, 0.04664918f, 0.18723632f, 
    0.02947056f, 0.12328155f, -0.12030935f, 0.01801452f, -0.08163752f, -0.05007571f, -0.00035949f, -0.00760255f, 
    0.07421529f, 0.02960392f, 0.03236717f, 0.24938938f, -0.02489600f, 0.07746283f, 0.09446772f, -0.14465441f, 
    -0.05823939f, 0.10863318f, 0.06553733f, 0.05256504f, -0.10383761f, -0.05766537f, -0.08533025f, -0.14104936f, 
    -0.10689645f, 0.05083661f, 0.04953679f, -0.02984866f, 0.07703058f, -0.04173437f, -0.13196106f, -0.06451473f, 
    0.26759589f, 0.04037804f, -0.10667923f, 0.07034903f, 0.02895354f, 0.03330672f, 0.04037449f, -0.04797926f, 
    0.03590149f, -0.09962863f, 0.05225171f, -0.05102201f, 0.41587684f, 0.06754281f, 0.04977708f, -0.15201384f, 
    -0.08832296f, -0.01447130f, -0.00786065f, -0.01987999f, 0.03327955f, 0.04379127f, 0.07667246f, -0.00893607f, 
    -0.04317341f, -0.01455959f, -0.02043260f, 0.06411320f, 0.06444354f, 0.02678022f, 0.00411115f, 0.06939048f, 
    0.00564940f, 0.03878547f, -0.09936474f, 0.06844348f, -0.08637094f, -0.02054170f, -0.20390046f, -0.03020644f, 
    -0.08145425f, 0.01041341f, -0.01643553f, -0.02051767f, 0.06770390f, 0.08554089f, 0.11109433f, -0.11608978f, 
    0.28166604f, -0.12326263f, 0.04537936f, -0.15380824f, -0.05401278f, 0.02117684f, 0.06437705f, -0.03743088f, 
    0.04638713f, 0.07447203f, 0.01265813f, 0.02013806f, -0.20583260f, -0.22201650f, 0.15405585f, 0.02096645f, 
    0.04285826f, -0.04631295f, -0.00196607f, -0.07048268f, -0.08227099f, 0.03225913f, -0.09022731f, -0.04395132f, 
    0.58462298f, 0.02159026f, -0.15108328f, 0.09326069f, -0.03063704f, -0.12733197f, -0.02174075f, 0.00418925f, 
    -0.09052760f, -0.05532432f, 0.00786836f, -0.03078167f, 0.05233837f, -0.11850064f, 0.09958394f, -0.05086809f, 
    -0.04015062f, -0.00589714f, 0.05213608f, -0.01096607f, 0.00588711f, -0.05091991f, -0.04797803f, -0.01955793f, 
    -0.02645523f, -0.10388482f, 0.09830000f, -0.13980515f, 0.05173862f, -0.04048716f, -0.05337420f, 0.03541204f, 
    -0.01673590f, 0.01406053f, -0.03566470f, -0.00443065f, 0.02301629f, 0.05273936f, -0.07309486f, 0.17018771f, 
    -0.02243071f, 0.03786450f, -0.05613586f, -0.00468201f, 0.07730174f, 0.01203644f, 0.06430972f, -0.11139877f, 
    0.06704778f, -0.14013183f, 0.01335102f, -0.24193947f, 0.05578040f, 0.00160385f, -0.00861261f, 0.02759948f, 
    -0.06320748f, -0.06164493f, 0.02615532f, -0.19288616f, 0.16959633f, 0.12590151f, -0.02470775f, 0.14600512f, 
    -0.02650249f, -0.10682991f, 0.01024281f, 0.18618801f, 0.07173272f, 0.07640841f, -0.01280615f, 0.02684727f, 
    0.41342676f, -0.07192533f, 0.05470774f, 0.07705369f, 0.04753673f, -0.06677128f, -0.01119332f, -0.02445840f, 
    -0.01515035f, -0.00175304f, 0.01674490f, -0.00364982f, -0.07202616f, -0.06305207f, 0.01852727f, -0.05665671f, 
    -0.13527755f, 0.02430598f, 0.02454310f, 0.07599995f, 0.07123884f, -0.09519789f, 0.01057243f, -0.03491765f, 
    -0.32422623f, 0.14426245f, -0.07142892f, -0.05612354f, 0.03414667f, -0.04648067f, 0.06385454f, 0.07296485f, 
    0.00657767f, 0.04165639f, -0.02260648f, -0.18401504f, -0.22985795f, -0.28855440f, -0.01416296f, 0.01006964f, 
    0.02047874f, 0.01678402f, 0.02348963f, 0.03046281f, 0.08670425f, 0.03475410f, -0.04080006f, -0.05165094f, 
    0.31280416f, 0.08188009f, -0.16570157f, -0.17348678f, 0.18027967f, 0.04369075f, -0.17506297f, -0.01310348f, 
    0.00901458f, 0.04367959f, 0.06038133f, -0.00904281f, 0.06006318f, -0.12169888f, -0.15666959f, 0.35739195f, 
    -0.09951533f, 0.15362942f, 0.01722585f, -0.05748710f, -0.09500368f, 0.02124090f, 0.06713010f, -0.11266077f, 
    0.33238503f, 0.06179621f, -0.04122776f, 0.27796316f, -0.04546974f, 0.04191018f, 0.05460321f, 0.03743994f, 
    0.00711143f, 0.07802211f, 0.00689114f, -0.05789630f, -0.12871468f, 0.08715793f, -0.13503543f, -0.19624147f, 
    0.02148089f, 0.15013205f, -0.08141958f, 0.10268056f, -0.05030809f, 0.04970592f, 0.08027350f, 0.00466065f, 
    -0.10343260f, 0.06914714f, 0.00232893f, -0.18587752f, -0.05841701f, 0.03000225f, 0.18289392f, 0.06533457f, 
    0.00318105f, -0.06979528f, -0.04176813f, 0.05822745f, 0.25948596f, 0.11727605f, -0.14761701f, -0.21091011f, 
    -0.08898214f, -0.06981537f, 0.10041223f, 0.05682481f, 0.04968368f, -0.02618895f, 0.07132638f, 0.02243087f, 
    0.35400036f, 0.15738663f, 0.01859545f, -0.19022119f, -0.12939525f, -0.10863040f, 0.02272618f, 0.08938530f, 
    0.02056171f, 0.05679942f, -0.06951658f, 0.02641835f, 0.37342846f, -0.05477835f, 0.09971476f, -0.21163461f, 
    0.06430127f, -0.05352690f, 0.04156427f, -0.08992988f, -0.14509632f, -0.08103495f, -0.09333587f, 0.03021835f, 
    -0.24667984f, -0.00573422f, -0.09727818f, -0.07614657f, 0.02184514f, -0.08923966f, 0.08033397f, -0.07395680f, 
    0.07167584f, 0.03894889f, -0.01641767f, -0.09403707f, -0.00285919f, 0.08227652f, -0.11762002f, 0.00223030f, 
    0.03343633f, 0.02647007f, 0.08451983f, -0.05789760f, 0.05330254f, 0.02362232f, -0.10071773f, -0.01491523f, 
    -0.03225736f, -0.12336677f, 0.00303763f, 0.00084957f, 0.15964651f, 0.06580467f, 0.01718985f, -0.06634644f, 
    -0.02920522f, -0.06263680f, 0.14854796f, 0.08066048f, 0.07174402f, 0.16625696f, 0.07539640f, 0.08573372f, 
    -0.04579095f, 0.01884156f, -0.00424877f, 0.05970653f, -0.03560485f, 0.08427798f, 0.04557927f, 0.19328092f, 
    -0.16623986f, 0.22766088f, 0.20827921f, -0.03385419f, -0.04123056f, 0.04205976f, 0.08490184f, -0.00117905f, 
    0.04681894f, -0.05465063f, -0.01316912f, 0.03128621f, -0.25588384f, 0.08721307f, 0.13887081f, 0.08865949f, 
    -0.06827530f, -0.07158701f, -0.02303256f, 0.10285193f, 0.08087783f, 0.15363961f, 0.07147605f, 0.11084870f, 
    0.06710510f, -0.08395449f, 0.02217448f, -0.03177384f, 0.04315246f, -0.00843126f, 0.01786078f, 0.04341357f, 
    -0.01672505f, 0.14632249f, 0.06828202f, 0.07972394f, 0.04445074f, 0.15256956f, -0.12570606f, 0.17445460f, 
    -0.04824616f, 0.20115557f, 0.21016762f, -0.13545275f, 0.08083280f, 0.11115750f, 0.04131887f, -0.04529018f, 
    0.43527490f, 0.26567009f, -0.05576184f, 0.09142336f, -0.09232437f, 0.21358164f, 0.21314825f, 0.09653687f, 
    0.03174787f, 0.08784752f, 0.01028721f, 0.15127356f, -0.12002760f, 0.04084019f, 0.00359237f, -0.00248846f, 
    -0.02681887f, 0.04970874f, 0.17263593f, -0.07105339f, -0.00925313f, 0.14217047f, 0.14155696f, -0.05314649f, 
    -0.01368421f, 0.02741024f, 0.24109878f, -0.00838787f, 0.08606075f, -0.00324657f, 0.08363202f, 0.06062920f, 
    0.00786831f, 0.07303001f, -0.14440425f, 0.07339700f, -0.22029042f, 0.02990858f, 0.06902770f, 0.10484951f, 
    -0.00303005f, -0.01344715f, 0.00601329f, -0.05889970f, -0.00827265f, -0.00555309f, -0.03799842f, -0.02676822f, 
    -0.09015138f, 0.07769110f, -0.09450196f, -0.11387993f, 0.05286775f, 0.11695914f, -0.01859612f, 0.11794851f, 
    0.04472037f, 0.03748330f, -0.05966363f, 0.05735140f, 0.11920949f, -0.05215216f, 0.00424061f, 0.11877817f, 
    0.01133333f, 0.03827334f, 0.11277609f, 0.11238471f, -0.04575124f, -0.02055890f, -0.12242235f, 0.09066291f, 
    0.07174049f, -0.13169974f, 0.02631978f, 0.12924072f, -0.01501067f, 0.03171264f, 0.15609625f, 0.09658174f, 
    -0.00791416f, 0.12920433f, -0.01056549f, -0.05063114f, -0.11844207f, 0.02984858f, -0.00296563f, 0.00965774f, 
    0.11837984f, 0.05501870f, 0.08885445f, 0.10720913f, 0.04778104f, 0.19798155f, 0.21784276f, 0.19361013f, 
    -0.08190206f, -0.12839946f, -0.07360966f, 0.30828458f, -0.13107672f, 0.01467203f, -0.02222798f, 0.03921846f, 
    -0.03170639f, 0.12948942f, -0.00847811f, -0.08816924f, -0.04369906f, -0.07994137f, 0.05539818f, -0.04423564f, 
    0.00528413f, -0.03725655f, -0.03914850f, 0.05411763f, 0.09277806f, -0.05200090f, -0.08779958f, 0.08858335f, 
    -0.05211705f, 0.13514765f, 0.18167913f, 0.09154543f, 0.07744410f, -0.05053156f, 0.02736787f, 0.08130558f, 
    0.06337996f, 0.02643514f, -0.08049262f, 0.04358052f, 0.08052824f, -0.01474651f, -0.04454890f, 0.02450322f, 
    -0.07698440f, 0.00848641f, -0.11896330f, -0.09751142f, -0.02921145f, 0.08600896f, 0.01426890f, -0.14618921f, 
    -0.04961470f, 0.15243430f, 0.26778710f, 0.06363128f, -0.01190201f, 0.01390243f, 0.05866725f, -0.03604928f, 
    0.00397284f, -0.09605920f, -0.05054330f, -0.14843920f, 0.08467257f, 0.24658215f, -0.01695473f, -0.01512975f, 
    0.02191437f, -0.09151168f, 0.09172852f, 0.14877868f, -0.05697123f, -0.02099457f, 0.05942265f, -0.09569489f, 
    -0.01589148f, 0.02143759f, -0.06979339f, -0.13075268f, 0.09023904f, 0.15064281f, 0.00438349f, 0.02688802f, 
    0.03346471f, -0.03388749f, 0.03173792f, 0.04220935f, 0.16363475f, -0.02369832f, 0.09982087f, 0.05859986f, 
    -0.08202475f, 0.08161341f, 0.05515055f, 0.16994505f, 0.08525049f, 0.05237543f, 0.05128037f, 0.09064949f, 
    0.13150121f, 0.02167076f, 0.07054883f, 0.11346038f, 0.04635149f, 0.17630260f, 0.07463434f, 0.03219859f, 
    -0.04428111f, -0.01858940f, -0.09877480f, 0.04937545f, 0.20507826f, 0.04187966f, 0.02077059f, 0.08452458f, 
    -0.11696834f, 0.00522271f, 0.06295789f, 0.01247978f, -0.00796580f, -0.07263337f, 0.15043277f, -0.21596800f, 
    0.14682445f, -0.11819198f, 0.00254296f, 0.01557537f, -0.02143126f, -0.03293373f, 0.03819695f, -0.04028125f, 
    -0.04610815f, 0.03393291f, -0.06165934f, -0.02893676f, 0.11222757f, 0.02346991f, -0.03860594f, -0.18560696f, 
    -0.08339387f, -0.05076067f, 0.04870320f, 0.15558594f, -0.03844542f, -0.00563289f, 0.03193223f, -0.01717199f, 
    -0.02627116f, -0.01860201f, -0.06497832f, -0.16770403f, 0.03602893f, 0.02619953f, 0.04531508f, 0.02245297f, 
    -0.06196875f, -0.04733427f, -0.00937829f, 0.05339973f, 0.03731548f, 0.30169305f, 0.01729329f, 0.00678951f, 
    0.04852078f, -0.00544351f, 0.14258479f, 0.06631263f, 0.06669857f, -0.06556926f, 0.02365790f, -0.01705993f, 
    -0.00522677f, 0.03576970f, -0.06095453f, 0.10368670f, -0.01720269f, 0.03668072f, 0.04392115f, 0.00149665f, 
    0.08936948f, -0.02541278f, 0.03824025f, 0.11113275f, -0.17120959f, 0.02542731f, 0.09589671f, 0.15913740f, 
    0.03679214f, 0.06419379f, -0.10811858f, 0.03975990f, 0.03338441f, 0.04820209f, 0.14598992f, -0.04094685f, 
    0.00454420f, 0.12583336f, -0.04993119f, -0.08903738f, 0.01094056f, 0.00822323f, 0.04523420f, -0.02748978f, 
    -0.08925352f, 0.02993839f, -0.01571636f, -0.12299557f, 0.03838130f, 0.01932689f, -0.02429108f, -0.10018416f, 
    0.08321910f, 0.10377228f, 0.06219245f, 0.13783284f, -0.01360684f, -0.12822352f, 0.01360289f, -0.02639111f, 
    -0.07345582f, -0.08322149f, -0.09739450f, 0.00514677f, 0.10539785f, 0.17169113f, -0.02510043f, 0.10855205f, 
    0.03936590f, -0.00121778f, 0.13241009f, 0.16249552f, 0.05349727f, -0.05656861f, 0.23736559f, -0.03916619f, 
    0.04599142f, 0.14263198f, -0.08958336f, 0.11180208f, -0.07566090f, 0.10712939f, 0.20428209f, 0.03171425f, 
    -0.09832018f, 0.12885493f, 0.19587712f, 0.01967313f, -0.11017955f, -0.05983739f, 0.03168285f, 0.06106893f, 
    -0.00050724f, -0.00359012f, -0.03875487f, -0.09404825f, -0.18998533f, 0.07882776f, -0.19436616f, 0.03812994f, 
    0.09779745f, 0.17575142f, 0.02638316f, -0.01333543f, 0.18671271f, -0.10397440f, -0.05876886f, -0.04115431f, 
    -0.04126489f, 0.09021410f, 0.10968736f, 0.06571337f, -0.07195161f, 0.05503821f, 0.09143542f, -0.02215158f, 
    0.01471246f, -0.06047774f, 0.16617742f, -0.11733314f, -0.05577138f, -0.00311750f, 0.06758748f, 0.05166528f, 
    0.02069727f, 0.12335954f, -0.01882126f, 0.07142284f, 0.03800342f, 0.09537219f, 0.12043528f, 0.09032741f, 
    0.01602792f, -0.11404836f, 0.15814491f, 0.23601373f, -0.05602756f, 0.05634833f, -0.12643263f, -0.08159195f, 
    -0.05407147f, -0.02671833f, -0.03603204f, -0.03574569f, -0.04426966f, 0.08661546f, 0.14094806f, -0.01377478f, 
    -0.07363960f, -0.00605174f, 0.03604386f, 0.06613979f, 0.01263541f, 0.06978214f, -0.01165631f, 0.03199382f, 
    0.05508113f, -0.01557687f, -0.00640804f, -0.08464825f, 0.02302841f, -0.09132688f, -0.09514600f, -0.01179971f, 
    0.02711605f, 0.12490752f, -0.00954337f, -0.09330876f, -0.14787996f, -0.20894527f, 0.11373604f, 0.21191381f, 
    0.03191357f, 0.00611751f, -0.17009100f, -0.09197421f, 0.02010474f, 0.00008229f, -0.02259040f, 0.02776213f, 
    -0.17641290f, 0.07702325f, 0.04261991f, 0.02944788f, -0.08768672f, 0.02221885f, -0.06486911f, 0.07990582f, 
    -0.03654593f, -0.00011322f, 0.02947103f, -0.15184951f, 0.06242161f, -0.15972997f, 0.25612122f, 0.04612762f, 
    0.03797294f, -0.00836339f, -0.09655325f, -0.02375301f, 0.05138728f, -0.08665791f, -0.08710558f, 0.06967523f, 
    0.12810041f, 0.28231785f, 0.01951147f, 0.09736669f, -0.15696128f, 0.01435566f, 0.07322098f, 0.17779459f, 
    0.08418936f, 0.04338565f, -0.03686814f, -0.01586670f, -0.06285182f, 0.04824777f, 0.02178442f, -0.13325320f, 
    0.06974059f, -0.04343583f, 0.00403162f, -0.08747110f, -0.02009780f, -0.13956065f, 0.09911680f, -0.00559368f, 
    0.05352744f, -0.09196882f, 0.14928328f, 0.00407517f, 0.05591812f, -0.04120390f, 0.00391726f, 0.15713158f, 
    -0.09269804f, 0.12533699f, -0.04518031f, 0.15846828f, 0.16652782f, 0.23687673f, 0.00007177f, 0.16059430f, 
    -0.15208089f, 0.10300059f, 0.12221544f, 0.05757577f, -0.04011258f, 0.07444385f, -0.00258524f, -0.04671906f, 
    -0.08824875f, -0.05391594f, -0.01203773f, -0.03211936f, 0.01024080f, -0.02877679f, -0.02122868f, 0.02749569f, 
    -0.12220375f, -0.01883950f, 0.02347098f, -0.06760490f, 0.47630996f, -0.02310704f, 0.04238042f, 0.16072476f, 
    -0.08627026f, 0.07508042f, 0.06023753f, -0.02212647f, -0.07363255f, 0.05926483f, 0.04858769f, 0.01765830f, 
    0.16212142f, 0.01938087f, 0.07596550f, 0.21759143f, -0.17586033f, -0.04943087f, 0.06734112f, 0.04199842f, 
    0.06854831f, 0.02482805f, 0.03280548f, -0.08302853f, 0.08360999f, 0.00322883f, -0.04555846f, 0.07390895f, 
    0.03938908f, 0.01113499f, 0.06630871f, 0.13978928f, 0.03157800f, 0.06111640f, 0.00239029f, 0.00158701f, 
    0.13272108f, 0.03377594f, -0.12621623f, 0.20492844f, -0.02176315f, 0.00459822f, 0.00051301f, -0.02150640f, 
    0.06002444f, 0.11889859f, 0.04715709f, -0.04957208f, 0.13054694f, 0.01884851f, 0.09502847f, -0.00205190f, 
    -0.01442794f, 0.10794017f, 0.11402889f, 0.15991786f, 0.06553037f, 0.10905690f, 0.09373415f, 0.00957859f, 
    -0.16399060f, 0.19069897f, 0.02988196f, -0.22933266f, 0.10608673f, 0.11103006f, 0.09377095f, 0.01213587f, 
    -0.05138162f, -0.06256227f, 0.00764819f, 0.07223795f, 0.27391222f, 0.09716283f, 0.10064777f, 0.16520001f, 
    0.00011880f, 0.05365697f, 0.09470876f, 0.04387517f, -0.03280387f, 0.13590397f, 0.11457493f, 0.05120831f, 
    0.37115014f, 0.17090729f, 0.19625859f, 0.10643941f, -0.14289410f, 0.14900532f, 0.01634598f, 0.11257682f, 
    0.05705715f, 0.12662511f, 0.04051381f, 0.12339606f, 0.04104370f, 0.12968612f, -0.11475833f, 0.04666725f, 
    -0.04637464f, -0.03878383f, 0.00624600f, -0.09244949f, -0.13341329f, -0.04672692f, 0.01542089f, -0.07685357f, 
    0.01521875f, 0.09885097f, 0.10586591f, 0.17342615f, 0.03033942f, -0.09348191f, 0.08508785f, 0.08138153f, 
    0.01817768f, -0.08439109f, -0.05098585f, 0.02114532f, -0.13438621f, -0.09412024f, -0.08875091f, 0.12771302f, 
    -0.04377889f, 0.07341115f, 0.06893373f, 0.03517026f, 0.00436665f, 0.07300290f, 0.04900832f, -0.12870465f, 
    0.06908431f, -0.11949887f, 0.11970098f, -0.01040406f, -0.06949967f, -0.03984090f, -0.07283756f, 0.13417225f, 
    0.03575085f, 0.05297456f, 0.07562061f, 0.07782882f, 0.01452226f, -0.20202191f, 0.14362980f, -0.17937340f, 
    0.03871285f, -0.08311844f, -0.07450181f, 0.09671593f, -0.06757589f, -0.01480667f, -0.14429267f, 0.01705122f, 
    0.30701688f, 0.17288862f, -0.06723641f, -0.05670786f, -0.05452964f, 0.01493753f, -0.01516128f, -0.18169615f, 
    -0.06231953f, -0.00564029f, 0.09610048f, -0.04446828f, -0.05535633f, 0.12768638f, 0.12342035f, 0.20451994f, 
    0.02739305f, 0.08541111f, -0.01518789f, -0.01632701f, -0.01818510f, -0.15325904f, -0.01931422f, 0.00388984f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00261696f, 0.00701539f, 0.03685387f, -0.02196912f, -0.00688648f, 0.06487463f, 0.00308220f, 0.10055482f, 
    -0.03436068f, 0.00580638f, 0.00276515f, -0.01089673f, -0.02737780f, -0.02475054f, 0.00898892f, 0.03017228f, 
    0.03156646f, -0.01287782f, 0.03939516f, 0.00405465f, -0.02584536f, 0.04085587f, 0.03554437f, -0.03096418f, 
    -0.02129220f, 0.02367430f, 0.00858465f, 0.03117624f, -0.00279563f, -0.01309288f, -0.02130821f, -0.01362787f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07059363f, 0.04537680f, -0.11384954f, 0.08696184f, 0.15072694f, -0.21280102f, 0.16320454f, -0.37073508f, 
    -0.04414435f, -0.04255482f, -0.05196475f, -0.12335757f, 0.42561382f, -0.09530960f, 0.01034551f, -0.46096539f, 
    0.12978050f, -0.13220198f, 0.32393724f, -0.03486908f, -0.08923879f, 0.02764245f, -0.59754544f, -0.02546888f, 
    -0.05266379f, 0.15892328f, 0.15855360f, -0.68683237f, -0.13844492f, -0.16371597f, 0.26003140f, 0.15078448f, 
    0.04670890f, 0.30140814f, 0.07915914f, -0.13555147f, 0.02733859f, -0.08352509f, 0.09537077f, 0.29889074f, 
    -0.10569339f, -0.06173006f, 0.11097193f, -0.04060487f, -0.54926288f, -0.05756531f, -0.29923669f, -0.49661526f, 
    -0.11728548f, 0.05585947f, -0.17754357f, -0.36867815f, 0.14900318f, -0.25092399f, -0.08440997f, 0.05011344f, 
    -0.10140460f, -0.02781470f, -0.04218998f, 0.28439194f, 0.15683368f, 0.02477865f, 0.41014767f, 0.15889806f, 
    -0.02102645f, 0.03223828f, -0.07718626f, -0.17154680f, -0.05229103f, -0.59003246f, 0.05971858f, -0.46188003f, 
    -0.17596863f, -0.05135778f, -0.04684601f, -0.16650097f, -0.03718975f, 0.06341855f, 0.39561468f, -0.22106495f, 
    0.08906274f, -0.01052285f, -0.16438250f, 0.23928654f, -0.02083563f, 0.12095281f, 0.34942895f, -0.04788762f, 
    0.14221098f, 0.00557472f, -0.01112690f, -0.40321100f, -0.16048293f, -0.03448869f, 0.38234121f, -0.05380682f, 
    -0.15722145f, -0.63564104f, -0.35958895f, -0.03530197f, -0.06113834f, 0.15027212f, 0.10332625f, 0.32208058f, 
    -0.12981904f, 0.01601002f, -0.07931800f, -0.05254532f, 0.23808558f, 0.16224404f, 0.17681046f, -0.21123630f, 
    -0.10469232f, 0.16420841f, 0.12034743f, -0.12703133f, 0.04870639f, -0.30296040f, -0.16254990f, -0.13359210f, 
    0.10940068f, 0.07044109f, -0.02090778f, 0.32144472f, 0.04530568f, -0.16690600f, -0.19097069f, 0.19257641f, 
    0.13289140f, -0.44729674f, -0.08915053f, -0.06951185f, -0.11546677f, -0.11651252f, -0.01303684f, 0.26428616f, 
    -0.08365496f, 0.11327100f, -0.01253180f, 0.34099892f, -0.16713864f, -0.05027114f, -0.57710975f, -0.12384896f, 
    -0.06407093f, -0.12195081f, -0.02352665f, 0.12425408f, -0.13497721f, 0.23948926f, -0.07156868f, -0.00929097f, 
    -0.07946520f, -0.04101475f, -0.02931999f, -0.35237357f, -0.07864002f, -0.12443668f, -0.27116159f, 0.23327757f, 
    -0.02349835f, 0.29662335f, -0.20317347f, -0.12123343f, -0.14037956f, 0.46261871f, 0.15315549f, -0.22143853f, 
    0.13455990f, 0.02009328f, -0.03590349f, 0.03689650f, -0.17174493f, -0.14666000f, -0.00265800f, -0.11631710f, 
    0.11945297f, -0.03432132f, -0.18232512f, -0.52989805f, -0.02370132f, 0.24964112f, -0.25246760f, 0.10226950f, 
    -0.05166761f, 0.10166843f, -0.13798498f, -0.21034636f, -0.13003571f, -0.08845142f, -0.30500612f, 0.00622298f, 
    0.01102675f, -0.08806806f, 0.20240106f, 0.07210048f, -0.11559062f, 0.04240191f, -0.01220959f, -0.03941083f, 
    0.13736714f, -0.13885388f, 0.09490762f, -0.78660470f, -0.27240831f, 0.14522900f, -0.14588127f, 0.37555474f, 
    -0.12401247f, -0.17082296f, 0.23036091f, -0.36443144f, 0.14219883f, -0.24287164f, -0.18312798f, -0.00768959f, 
    -0.03263612f, 0.06925049f, -0.15293504f, -0.30351847f, -0.11721613f, 0.06026737f, -0.38795102f, 0.19445060f, 
    -0.08688873f, -0.11822389f, -0.44736755f, 0.15152748f, 0.02277014f, -0.09300624f, -0.13405886f, -0.45335859f, 
    0.02269058f, 0.03776525f, -0.04783129f, 0.30428383f, 0.16485162f, -0.06696977f, 0.07774610f, 0.36509976f, 
    0.11622224f, -0.16085543f, -0.31701839f, 0.15647869f, 0.03629345f, -0.23797044f, -0.16754983f, -0.16643411f, 
    0.03800343f, 0.03748320f, 0.14135858f, 0.27790636f, -0.12062653f, -0.11380919f, -0.05181859f, 0.04349859f, 
    -0.10999372f, 0.08176932f, 0.26305896f, 0.00161591f, -0.00253036f, 0.16302291f, 0.07980245f, -0.31152406f, 
    -0.16763887f, -0.02042401f, -0.10606398f, 0.35987163f, -0.40204743f, -0.13536891f, 0.27249822f, -0.22495599f, 
    0.16311742f, 0.12700109f, -0.08439558f, -0.08872010f, -0.08173168f, -0.33705014f, 0.14262834f, -0.15470728f, 
    -0.09751067f, -0.01701272f, 0.01104251f, -0.38446087f, -0.07945973f, -0.08441986f, 0.07595947f, -0.45323241f, 
    0.16283636f, -0.05400828f, 0.24152945f, -0.05834976f, -0.04028839f, -0.13242784f, -0.08923591f, -0.18215869f, 
    0.09576995f, -0.10247627f, 0.07865240f, -0.40958515f, 0.59972799f, -0.14969626f, -0.45868585f, 0.09711411f, 
    0.14691798f, 0.00642945f, -0.38334057f, 0.15869653f, -0.05253696f, 0.14065439f, 0.24013110f, -0.17200302f, 
    0.05717072f, -0.05105938f, 0.12435649f, -0.10188127f, 0.15204081f, 0.06516320f, -0.06155305f, -0.12410197f, 
    -0.17091388f, 0.26084623f, -0.18226889f, 0.07156081f, -0.01032690f, -0.25590703f, 0.01960079f, 0.07477415f, 
    0.10655380f, 0.07965691f, 0.04874820f, -0.11579313f, 0.08515312f, 0.16505282f, 0.40164998f, -0.23722652f, 
    -0.16265117f, -0.06824058f, 0.16057631f, -0.07508657f, 0.05851157f, 0.27729958f, -0.07119554f, 0.12863119f, 
    0.11871485f, 0.00060177f, 0.01684501f, 0.33629748f, -0.06820250f, 0.00855062f, -0.54688603f, -0.42982954f, 
    -0.08493058f, -0.24043207f, 0.18009320f, 0.15945804f, -0.01470698f, 0.09224308f, 0.12521370f, 0.08026763f, 
    -0.14540523f, 0.15259117f, -0.06837760f, -0.29107207f, -0.44245696f, 0.17487605f, -0.07823708f, 0.12599309f, 
    -0.12649277f, -0.06476053f, -0.22510435f, 0.41058362f, -0.07443201f, 0.09443983f, -0.73158610f, -0.02216894f, 
    -0.13776220f, 0.04371843f, 0.11576023f, 0.17782782f, -0.16792947f, -0.12927295f, 0.34938309f, -0.09561200f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.13981630f, 0.01039405f, 0.03634583f, -0.13687629f, -0.07888045f, -0.05143618f, 0.15608205f, -0.22625151f, 
    -0.04171773f, 0.02798128f, -0.12016055f, -0.11194598f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
