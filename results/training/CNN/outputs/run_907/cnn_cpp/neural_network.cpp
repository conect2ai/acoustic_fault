#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.14668638f, 0.24370064f, 0.78256381f, -1.18733799f, -0.03507283f, -0.85430819f, 0.21824996f, -0.31713718f, 
    0.13985375f, -0.18960731f, -0.62847561f, -0.23858157f, -0.53777337f, 0.64781481f, -0.67707789f, 0.53097177f, 
    -0.29709455f, 0.02636939f, -0.85409451f, -0.70046163f, -0.84868836f, -0.17068847f, 0.83913356f, 0.30087027f, 
    -0.10104360f, -0.20590755f, -0.12579204f, -0.49584618f, -0.63330120f, -0.71060419f, 0.54352397f, 0.10284006f, 
    -0.05686698f, -0.48726091f, -0.48610222f, -0.29812878f, -0.86066246f, -0.77783465f, 0.54865628f, 0.89736658f, 
    0.60069001f, 0.39702114f, -0.15191062f, -0.02875115f, -0.26476812f, 0.73133093f, 0.28254932f, 0.45939505f, 
    -0.83160466f, 0.52393293f, 0.00229728f, -0.02305246f, -0.04831686f, 0.54821193f, -0.34289965f, -0.53519517f, 
    -0.62314427f, -0.37809247f, -0.71642083f, 0.26160687f, -0.37022883f, -0.17001401f, -0.21886918f, -0.25432423f, 
    0.60839993f, -0.35550007f, -0.64438140f, 0.63682806f, 0.77860999f, -0.24828000f, 0.24751589f, -0.53663623f, 
    -0.51197332f, 0.84098107f, 0.09625761f, 0.55102426f, -0.24908346f, -1.10669410f, -0.09358779f, -0.11254236f, 
    0.52141505f, -0.75985754f, -0.51555485f, -0.48319310f, 0.47165763f, 0.58062905f, 0.83453500f, 0.26666376f, 
    0.04354732f, 0.40003082f, 0.43821034f, 0.74486095f, -0.80115741f, 0.21187234f, 0.73527831f, 0.25903836f, 
    0.73825800f, 0.06321681f, 0.39207083f, 0.76585752f, -0.42723277f, -0.93384141f, -0.06282672f, 0.31139061f, 
    -0.12003257f, -0.21594429f, -0.18176465f, 0.29779211f, -0.20290081f, 0.64576334f, -0.42220974f, -0.42333353f, 
    -0.74920845f, -0.78855866f, 0.61820191f, -0.05409069f, -0.36476082f, 1.07679379f, -0.33054361f, 0.31140360f, 
    0.68041313f, -0.13005902f, 0.19091576f, 0.22531447f, -0.00651720f, -0.94657540f, -0.93371540f, -0.89892811f, 
    -1.02134669f, 0.11313553f, -0.37619093f, -0.00632714f, 0.10173186f, 0.22056042f, 0.23052076f, -1.08865678f, 
    -0.66257817f, 0.24052522f, -0.58026588f, -0.24226536f, 0.57390857f, 0.17533296f, -0.08826213f, 0.44541991f, 
    -0.11654527f, 0.36744767f, 0.99407887f, -0.01391347f, 0.47395062f, 0.04923917f, -0.55845106f, -0.27086607f, 
    -0.03813991f, -0.69942236f, 0.87623578f, -0.33984861f, 0.80962539f, -0.16139922f, -0.37243357f, -0.09048134f, 
    -0.04561210f, -0.41614825f, 0.66304100f, 0.59301180f, 0.69823217f, 0.79011524f, 0.43583792f, 0.16182086f, 
    0.15241584f, 0.61485988f, 0.33020633f, -0.18091117f, -0.17100964f, -0.92568070f, 0.37924403f, 0.95988220f, 
    -0.58225888f, -0.23239130f, 0.44275853f, -0.19858852f, -0.73128057f, -0.47881722f, 0.07334448f, 0.17047834f, 
    0.80172384f, -0.88945490f, -0.33623996f, 0.00833636f, -0.64124942f, -0.02042202f, -0.96803284f, -0.65233874f, 
    -0.87687558f, -0.31296608f, -0.15382111f, -0.29273915f, 0.64773047f, 0.21321657f, 0.87390906f, 0.78650188f, 
    0.30471647f, -0.10245094f, 0.28484288f, -0.22903723f, -0.37540084f, 0.35610625f, -0.03677613f, -0.46480596f, 
    0.48339695f, -0.53907287f, 0.59663326f, -0.18835038f, 0.36181402f, 0.47875413f, -0.81565273f, -0.28863367f, 
    0.62439448f, 0.45008302f, -0.04068491f, 0.32593367f, 0.27529210f, 0.00358665f, 0.54181957f, 0.68744302f, 
    -0.11356302f, 0.74763966f, 0.49265161f, 0.91176718f, -0.02607303f, -0.30401003f, 0.60995334f, -0.54189646f, 
    -0.51031250f, -0.04695169f, 0.89968419f, 0.79860920f, 0.78063327f, -0.13429639f, -0.72431749f, -0.16463602f, 
    0.49373955f, 0.14685871f, 0.08618696f, -0.52272809f, 0.49568656f, -0.39926344f, -0.63479280f, -0.25727138f, 
    -0.80341393f, -0.46303990f, -0.01475608f, 0.09203911f, 0.11207837f, -0.97471249f, 0.65175998f, 0.68398380f, 
    -1.26327837f, 0.78900826f, -0.13154268f, -0.37981021f, 0.02620958f, 0.43491253f, 0.54329598f, -0.80618596f, 
    -0.08273250f, -0.91577137f, -0.32858869f, 0.41500032f, 0.21839482f, 0.22958462f, -0.44835627f, 0.69427609f, 
    0.27405336f, 0.55142415f, 0.35573792f, 0.59586042f, 0.61760503f, -0.07100540f, 0.37026939f, 0.39704970f, 
    -0.52058774f, 0.66653800f, 0.76124728f, 0.39393571f, 0.48564136f, -0.43004444f, -0.69236809f, 0.03503186f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03774309f, -0.02462546f, 0.00172336f, -0.34863803f, 0.14855106f, 0.03758947f, 0.15677224f, 0.10392038f, 
    -0.31101403f, -0.04283165f, -0.37967488f, 0.23015237f, 0.08441932f, 0.19755232f, 0.12734666f, -0.00898754f, 
    -0.33294776f, -0.20421648f, -0.02549724f, 0.13315889f, -0.08185796f, 0.25742894f, 0.10604665f, 0.13778372f, 
    0.26990312f, 0.24042326f, -0.20285307f, 0.09983280f, -0.22019553f, 0.25078100f, -0.02598396f, 0.21228272f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.00159600f, 0.01556003f, -0.00076108f, -0.02467608f, -0.04389230f, -0.00081018f, -0.01385785f, 0.01441688f, 
    -0.01382636f, -0.05882978f, 0.00859331f, -0.03623030f, 0.00675715f, -0.05800468f, -0.05582944f, -0.04932050f, 
    -0.01035810f, -0.01187141f, -0.02549210f, -0.02101620f, 0.03889147f, -0.01973898f, -0.07374159f, -0.04864315f, 
    -0.00969641f, 0.02883570f, -0.05829122f, 0.01675149f, 0.01395610f, -0.03832177f, 0.03956407f, 0.02474505f, 
    0.01127392f, -0.06210842f, -0.02145718f, 0.01472158f, 0.00276224f, 0.00984949f, -0.04261087f, 0.02122353f, 
    0.02667066f, -0.00194160f, 0.04755570f, 0.01348609f, -0.02334942f, -0.00758349f, 0.01103156f, -0.03857913f, 
    -0.05448522f, -0.05252055f, -0.00099810f, -0.00911274f, -0.05424725f, -0.03653601f, 0.01633953f, 0.04183498f, 
    -0.04473918f, -0.06189490f, 0.02601009f, -0.02425658f, 0.01094317f, 0.00466011f, 0.00047739f, 0.00081337f, 
    -0.01207479f, -0.04253923f, -0.05653749f, 0.03759229f, -0.03853739f, -0.05558996f, -0.06781614f, 0.01330397f, 
    0.02097624f, -0.04981625f, -0.01847136f, 0.03797074f, -0.01242339f, -0.01727451f, 0.01202272f, -0.02836473f, 
    0.00425840f, 0.00992566f, -0.02448033f, 0.04945086f, -0.06039960f, -0.05759558f, -0.06713729f, 0.04390696f, 
    -0.00158852f, -0.03485362f, -0.05482803f, 0.00126892f, -0.05797718f, 0.03546984f, -0.02967161f, -0.04027381f, 
    -0.02552775f, 0.04578234f, 0.01362623f, 0.03274334f, -0.00039521f, 0.03993221f, -0.04984799f, -0.01526378f, 
    0.03774096f, -0.06026153f, -0.03600960f, -0.04104217f, 0.01641368f, -0.00967909f, -0.01335128f, -0.01018715f, 
    -0.05660744f, -0.03654354f, -0.02958660f, -0.04063650f, -0.00628464f, 0.01945959f, -0.05138331f, 0.04155200f, 
    -0.02542503f, -0.04103442f, -0.02477936f, 0.02052536f, 0.01545106f, 0.02539628f, -0.02984261f, -0.02357019f, 
    0.04401325f, 0.02299177f, -0.05392710f, 0.04421061f, 0.01303522f, -0.01128270f, -0.03892367f, -0.03653625f, 
    0.00307425f, 0.02836637f, 0.03783793f, -0.06004163f, 0.02640757f, -0.01375229f, -0.03219104f, 0.04443062f, 
    0.04970314f, -0.03435726f, -0.01622779f, 0.01144549f, -0.03695391f, -0.05185155f, 0.01263696f, -0.04136948f, 
    0.01270453f, -0.00508428f, -0.01349785f, 0.00809654f, -0.05130992f, -0.02524995f, 0.03336932f, -0.05120173f, 
    0.05172549f, -0.01301481f, -0.05375101f, -0.01840779f, -0.05224098f, -0.00377196f, -0.00883141f, 0.01110466f, 
    -0.04133712f, 0.03860961f, -0.02715676f, -0.00458717f, -0.05401029f, 0.04504803f, 0.01507180f, 0.00566412f, 
    0.03077236f, -0.07130342f, -0.00814863f, -0.03411581f, 0.05137945f, -0.02664703f, -0.01940209f, 0.02602846f, 
    -0.00722369f, 0.02729344f, -0.04389568f, -0.01735702f, 0.00208121f, 0.04161636f, -0.04738089f, 0.01646228f, 
    -0.03327785f, -0.01366504f, -0.05420529f, 0.00660035f, 0.03071434f, -0.04611760f, 0.02883163f, 0.03113146f, 
    -0.00512355f, -0.00693645f, 0.03868819f, -0.01204929f, -0.06038743f, -0.00601022f, -0.05884235f, 0.04067196f, 
    0.01610305f, -0.05028784f, -0.03528913f, -0.01247436f, -0.01420844f, 0.01042452f, -0.05106428f, 0.00591877f, 
    0.01402998f, -0.04525243f, -0.03082640f, 0.03836057f, -0.01145659f, 0.02914324f, 0.00935961f, 0.01231776f, 
    0.01338667f, -0.00071603f, 0.04172789f, 0.01013619f, 0.01842186f, -0.00215744f, 0.05078620f, -0.00083926f, 
    0.02025902f, -0.01306759f, 0.04109795f, -0.02540624f, 0.01657159f, -0.02334253f, -0.00681945f, -0.01766719f, 
    0.02625023f, 0.02662014f, 0.00104603f, -0.07046298f, -0.05647439f, -0.06083706f, -0.06067083f, -0.03366802f, 
    -0.03242240f, 0.00065152f, -0.02355337f, 0.02104814f, -0.03617574f, -0.00390716f, 0.04418749f, 0.02932645f, 
    0.01709440f, -0.05396907f, -0.00086552f, 0.00377819f, -0.00639366f, -0.03030471f, -0.06262540f, 0.03955190f, 
    -0.06585986f, -0.00673791f, 0.01188749f, -0.05308750f, -0.03081010f, -0.03707385f, 0.04198596f, -0.04919808f, 
    0.01876601f, -0.04823177f, -0.02508914f, -0.05376261f, 0.04420304f, -0.04293241f, -0.05559795f, -0.00311753f, 
    0.00646039f, -0.00553132f, 0.03460834f, -0.03478991f, 0.04046388f, -0.04656439f, 0.02140137f, -0.06086442f, 
    0.12925914f, -0.13352804f, -0.24638225f, 0.11999483f, 0.02553279f, 0.10123257f, -0.18188806f, 0.07204615f, 
    -0.12660891f, 0.34263334f, 0.03531606f, -0.08150479f, -0.06404848f, -0.10427137f, 0.19287981f, -0.04618466f, 
    0.10045929f, -0.10083717f, 0.29854700f, 0.04015210f, -0.02369825f, -0.02641211f, 0.00499044f, -0.04869923f, 
    0.07876731f, 0.04103414f, -0.16599756f, 0.17166288f, 0.17420390f, 0.00756900f, -0.02152372f, 0.10705391f, 
    -0.13220818f, -0.01656349f, 0.14501500f, 0.00249767f, 0.12626337f, 0.12440848f, 0.23539165f, 0.10345367f, 
    0.06356575f, -0.05128568f, 0.05566523f, 0.04908659f, 0.03679091f, -0.07075647f, 0.02719947f, -0.08041382f, 
    0.08165762f, -0.02156145f, 0.10933121f, 0.06574214f, 0.06230384f, 0.15732129f, 0.03615868f, -0.05353590f, 
    -0.17817946f, 0.16006818f, 0.04031282f, 0.02255859f, 0.00334866f, 0.04668030f, -0.05860882f, 0.05793615f, 
    -0.00453532f, -0.03980767f, 0.06529892f, -0.07830201f, -0.23885164f, 0.09969638f, 0.11704363f, -0.06805736f, 
    -0.16937062f, -0.15785193f, -0.30139667f, 0.11579005f, 0.22952205f, -0.02386570f, 0.01751663f, -0.00881927f, 
    0.11038937f, 0.18944153f, 0.32158387f, 0.20360494f, -0.12447055f, -0.09643409f, 0.08866425f, 0.00069118f, 
    0.02214461f, 0.02046550f, 0.16879459f, -0.15088041f, 0.01452513f, -0.13659048f, -0.08576184f, -0.12132042f, 
    0.11046860f, -0.07714483f, 0.06104457f, -0.03728662f, -0.03648176f, -0.02339313f, -0.03685506f, 0.05355014f, 
    0.21533783f, 0.01036091f, -0.06656998f, -0.09773719f, -0.14726868f, -0.14027311f, -0.07573241f, 0.16208929f, 
    0.04086387f, 0.07786115f, -0.08095982f, -0.19975986f, -0.24834043f, -0.21989834f, 0.10602517f, 0.01428383f, 
    0.05701186f, 0.07086911f, -0.01049458f, -0.00471967f, 0.09215903f, -0.03357709f, 0.18990774f, 0.10846723f, 
    -0.09419646f, -0.16771376f, -0.03444571f, 0.17434944f, -0.02273735f, 0.18238886f, -0.04227439f, 0.12965669f, 
    0.09115016f, -0.03286676f, 0.11297227f, -0.00324252f, 0.07862169f, 0.12978542f, -0.15218477f, 0.11807294f, 
    -0.08912952f, -0.23559758f, -0.21588321f, 0.20155334f, 0.07104672f, -0.00664063f, -0.00647006f, -0.08181447f, 
    0.21138746f, -0.18650660f, -0.15992694f, -0.13171187f, 0.10524384f, 0.10008304f, -0.09899039f, -0.09327139f, 
    -0.04047478f, -0.18790585f, -0.09511944f, 0.05125906f, 0.00916416f, 0.06160354f, -0.01296899f, -0.19137271f, 
    -0.01113393f, -0.03171526f, 0.23705728f, 0.12269159f, -0.04960723f, 0.00341062f, -0.21393681f, 0.01588535f, 
    0.00909602f, 0.17560939f, 0.02454988f, -0.14447433f, 0.10319356f, -0.01181733f, -0.20566963f, -0.07418480f, 
    0.14712124f, 0.17362441f, 0.08513787f, -0.07383341f, -0.16769138f, 0.08278018f, -0.07472207f, -0.25049210f, 
    0.08149506f, -0.01729636f, 0.12334686f, -0.06046611f, -0.08599194f, -0.03718783f, -0.09623406f, 0.01691568f, 
    -0.08829234f, 0.02756970f, -0.02847663f, 0.03818789f, -0.11222270f, 0.12665558f, 0.03560706f, 0.15069692f, 
    0.17032655f, -0.09530734f, 0.02399388f, 0.08805635f, -0.11581835f, 0.02227653f, 0.11212353f, -0.03486703f, 
    0.07280929f, -0.07912432f, 0.22504224f, 0.06555663f, 0.00928175f, -0.05969596f, 0.21007918f, 0.03738320f, 
    0.16107613f, -0.25427336f, 0.06269779f, -0.16241439f, -0.02771865f, 0.04815168f, -0.04540186f, -0.18412699f, 
    0.01039890f, 0.20017402f, -0.08557031f, -0.00854790f, -0.10909926f, 0.04397788f, 0.00684501f, 0.03839671f, 
    -0.08767392f, 0.08755814f, -0.04259628f, 0.05817920f, -0.26676881f, -0.08068327f, 0.14789782f, 0.03540797f, 
    0.18367389f, -0.30177748f, -0.15123883f, -0.07446644f, -0.55667901f, 0.21949366f, 0.07257164f, -0.09560081f, 
    -0.03119871f, 0.01470822f, 0.00952206f, 0.06692381f, 0.18080132f, -0.13249868f, -0.21629028f, -0.06699259f, 
    0.04799220f, 0.08140540f, 0.21819973f, 0.14953879f, -0.13168184f, -0.00619146f, 0.16683421f, 0.15209542f, 
    -0.06804099f, -0.26635462f, 0.03656818f, 0.08696288f, 0.04974555f, 0.10631042f, 0.11065811f, -0.17199895f, 
    0.20846415f, 0.07973240f, 0.00405388f, 0.06397512f, -0.00753369f, -0.05474860f, 0.03834862f, 0.09408193f, 
    -0.00155114f, -0.05512330f, 0.02475704f, -0.03994457f, -0.04705276f, 0.04547206f, -0.05156279f, -0.04124150f, 
    0.02412905f, 0.01847609f, 0.00294053f, -0.02592778f, 0.00107526f, -0.05515693f, -0.01042266f, -0.05396203f, 
    0.01277220f, 0.00403356f, -0.02792151f, 0.01671431f, -0.02366146f, -0.02875892f, -0.03649923f, -0.01127637f, 
    -0.04657639f, 0.00336233f, -0.01663277f, -0.01380856f, -0.06656310f, -0.02682397f, 0.00314972f, 0.01250394f, 
    -0.05993483f, 0.04600228f, 0.00039294f, 0.04601499f, 0.02360819f, 0.01330842f, -0.04262299f, -0.04091534f, 
    0.01102404f, 0.04390467f, -0.05672847f, -0.05919175f, 0.03051826f, 0.03800621f, 0.03225782f, -0.03630355f, 
    0.04817019f, -0.05256061f, 0.02850345f, 0.03589245f, -0.05722846f, -0.04068223f, 0.04760177f, 0.02940687f, 
    -0.00719839f, -0.01994038f, -0.03845531f, 0.00771232f, -0.03474715f, -0.01278069f, 0.04279316f, -0.00064446f, 
    0.01336017f, -0.04880506f, 0.04975712f, -0.00396663f, 0.00213234f, -0.04222602f, -0.05853565f, 0.03948595f, 
    0.03138078f, -0.01328374f, -0.00807848f, -0.04103706f, -0.05627204f, 0.03889448f, -0.06248740f, 0.01725408f, 
    -0.04022779f, 0.04249906f, -0.02812870f, -0.00651969f, 0.04257851f, -0.04981769f, 0.04715497f, -0.02987041f, 
    0.00703076f, -0.03301662f, -0.03140548f, -0.04146002f, 0.03237220f, 0.00986342f, 0.01787805f, 0.00888445f, 
    0.04097266f, 0.01956880f, -0.02920129f, -0.05506288f, 0.04218904f, -0.06283230f, -0.06362525f, -0.01115364f, 
    -0.03355407f, 0.01068340f, 0.00167729f, 0.01578846f, 0.02843423f, -0.01877982f, -0.05814151f, 0.02529084f, 
    -0.01116033f, -0.04877672f, 0.01711630f, -0.05688982f, 0.00497845f, 0.03485321f, -0.03940733f, -0.05414496f, 
    -0.00288183f, -0.02239261f, 0.01234951f, 0.04627875f, -0.05829209f, -0.04039431f, 0.04017048f, -0.05417740f, 
    -0.05172950f, 0.04392996f, 0.00139686f, 0.04195131f, 0.01901261f, 0.02370853f, -0.01419683f, -0.01088577f, 
    -0.06327759f, -0.04871310f, -0.02694718f, -0.05881419f, -0.06252448f, -0.03294657f, -0.05635008f, 0.00749396f, 
    0.01445251f, -0.02784713f, -0.00477164f, -0.02728992f, -0.01593388f, 0.02904058f, 0.03405056f, -0.00585168f, 
    -0.05717193f, -0.03779040f, -0.05998342f, -0.02628424f, -0.01200919f, -0.01630077f, 0.01153310f, -0.00410346f, 
    -0.02734692f, -0.04214751f, -0.02272385f, -0.03117502f, 0.04127606f, -0.00477823f, 0.01139361f, -0.04571329f, 
    -0.00451786f, -0.00282736f, -0.00379493f, -0.00598800f, 0.00982501f, -0.03433275f, 0.01115886f, 0.00768550f, 
    -0.03257633f, 0.01688001f, 0.04013062f, 0.03591550f, -0.04008980f, 0.03148696f, -0.01483481f, 0.00403663f, 
    -0.03899274f, 0.00873998f, -0.05123236f, 0.01999863f, 0.03563008f, -0.06095573f, -0.05103305f, -0.06202583f, 
    -0.02429016f, 0.03886659f, 0.02580895f, -0.00314524f, 0.04507148f, -0.00629826f, -0.01593308f, 0.00217921f, 
    -0.02723708f, 0.04839143f, -0.05939818f, -0.05171239f, 0.03989967f, -0.00248557f, 0.00968164f, -0.01468746f, 
    0.02364597f, -0.04881894f, 0.02223150f, 0.03810160f, 0.02034326f, 0.04382348f, -0.05043810f, -0.05015649f, 
    0.02589563f, 0.00072379f, 0.01781885f, 0.00488070f, -0.01779192f, -0.00974777f, -0.04677809f, 0.03829706f, 
    -0.02080997f, 0.02797631f, 0.00641708f, 0.01380428f, -0.01566637f, 0.01942606f, 0.04570429f, 0.02572447f, 
    0.00930903f, -0.01214706f, -0.03199213f, -0.03568437f, -0.00024630f, -0.04232610f, 0.02608516f, 0.01766958f, 
    0.03372116f, -0.03549444f, -0.06077729f, -0.01843571f, 0.00451543f, 0.05180319f, -0.05333634f, 0.03002262f, 
    -0.03219233f, -0.04290351f, -0.04652075f, -0.00381024f, -0.03943559f, -0.04879630f, -0.00006643f, 0.02801892f, 
    0.02212280f, -0.00424013f, 0.04196056f, -0.05222517f, 0.02732334f, 0.02596871f, -0.00221197f, 0.01304825f, 
    -0.04663621f, -0.03569667f, 0.00075301f, 0.02292950f, 0.02007262f, 0.01325009f, 0.02495282f, -0.00776373f, 
    0.00163085f, -0.05532990f, 0.02550749f, 0.02773983f, -0.00014190f, 0.03864139f, -0.04134789f, 0.02850377f, 
    -0.00854271f, 0.01455418f, -0.05013745f, -0.04616983f, 0.04341068f, -0.04556351f, -0.02249131f, 0.01156598f, 
    -0.01414642f, 0.14442340f, -0.02453394f, 0.11468904f, -0.18499932f, -0.11596927f, 0.00902023f, 0.14390703f, 
    0.23823613f, -0.15629731f, -0.00896630f, -0.00124579f, -0.11978897f, -0.00765683f, -0.17121047f, -0.07357422f, 
    0.03440664f, 0.15176152f, -0.23389514f, -0.03090289f, 0.17109628f, 0.03673869f, -0.03772963f, 0.11895178f, 
    -0.10070211f, 0.15364778f, 0.14857800f, -0.23282173f, -0.19259195f, 0.10111851f, -0.09746166f, 0.05415995f, 
    0.25440598f, -0.13407522f, 0.10069726f, 0.21137838f, -0.01255795f, -0.29168943f, 0.02342349f, 0.03424238f, 
    0.05930173f, 0.12378366f, -0.01775186f, 0.04943629f, -0.14613222f, -0.03864109f, -0.11473202f, -0.02692519f, 
    -0.01103067f, 0.08288018f, 0.02882310f, -0.02196433f, 0.04232876f, 0.02698235f, 0.03294248f, 0.00760443f, 
    0.15377030f, -0.00709229f, -0.02432495f, 0.10281190f, 0.11500499f, -0.02101276f, 0.18961507f, -0.25221568f, 
    0.25574094f, 0.17227066f, -0.11148760f, -0.07445160f, 0.07825974f, 0.27703542f, 0.01776598f, -0.27425146f, 
    0.17198519f, -0.04162706f, 0.16447720f, 0.04931490f, 0.01479030f, 0.10913247f, -0.12182379f, -0.12612657f, 
    -0.13687007f, 0.05475760f, -0.06244160f, 0.08757666f, 0.14074022f, 0.05662348f, -0.12251735f, -0.09594320f, 
    -0.07499986f, -0.03922505f, -0.15101889f, -0.07687014f, 0.20340648f, 0.17610370f, 0.20683308f, 0.01498748f, 
    -0.04335086f, -0.21385038f, -0.12037874f, 0.12037638f, 0.13868128f, 0.09761392f, -0.11940240f, -0.00313246f, 
    0.03699180f, -0.02564579f, 0.07790349f, 0.05047452f, 0.08520300f, 0.20316075f, 0.09408941f, -0.05889914f, 
    -0.05843679f, -0.00503250f, 0.07085586f, 0.09380221f, 0.13142951f, -0.05500188f, -0.03061161f, -0.25582263f, 
    -0.01014861f, 0.14837208f, 0.04249699f, -0.04586656f, 0.02336309f, -0.17670596f, -0.00467515f, -0.13149761f, 
    0.10577551f, 0.02571467f, 0.01480030f, 0.01967084f, -0.03241767f, -0.15714402f, -0.06047276f, -0.03184279f, 
    -0.05297105f, -0.04296538f, 0.07331890f, -0.05196739f, -0.11559489f, 0.10491265f, -0.08841546f, -0.13981284f, 
    0.13105056f, -0.02175681f, 0.05206973f, 0.18709393f, -0.15568867f, 0.25441951f, -0.08638617f, -0.03096004f, 
    -0.11312257f, 0.17285191f, 0.03318445f, 0.13627116f, -0.16497740f, -0.11003858f, 0.11804657f, 0.04059761f, 
    0.06468480f, 0.01955880f, -0.17833003f, -0.19733804f, -0.20878376f, 0.13692631f, 0.04434092f, 0.15556058f, 
    -0.12606928f, 0.07111648f, -0.02309863f, -0.16678201f, 0.17903624f, 0.15204147f, -0.03599549f, -0.05394212f, 
    -0.07671926f, 0.06764723f, 0.08020320f, 0.03623224f, -0.12837140f, -0.04685866f, 0.22747670f, 0.15460812f, 
    -0.08872038f, -0.03162033f, 0.06126184f, 0.02803762f, 0.20870645f, 0.07571675f, -0.02895434f, 0.12036151f, 
    0.00471112f, -0.11477846f, 0.03741166f, 0.00322884f, 0.01608684f, -0.00533018f, -0.05710946f, -0.14645548f, 
    -0.20581140f, 0.07999947f, 0.00626883f, 0.03859286f, 0.08212996f, 0.07270461f, -0.10702682f, -0.03870449f, 
    -0.05955380f, 0.12183045f, -0.09318426f, -0.03616616f, 0.13108361f, -0.03632072f, -0.00407479f, 0.06301191f, 
    0.00038876f, -0.04879316f, -0.01867178f, 0.03821847f, -0.04163474f, 0.00104295f, -0.13346888f, -0.04912481f, 
    -0.07816911f, 0.09541514f, -0.03390415f, -0.29685536f, 0.14862101f, 0.11908510f, 0.15806410f, 0.22875683f, 
    -0.04538567f, -0.15088725f, -0.18620493f, -0.07440482f, -0.09970536f, 0.00237091f, 0.17510925f, -0.04529235f, 
    0.03587036f, -0.01645098f, 0.09605873f, 0.10156583f, 0.15178901f, 0.17495912f, 0.06901731f, -0.07110548f, 
    -0.28470212f, 0.11034024f, 0.02004321f, 0.14847341f, 0.25272375f, -0.00288553f, -0.07235327f, -0.11538501f, 
    0.08643153f, 0.01164121f, -0.05687347f, -0.00344606f, -0.14200436f, 0.14856839f, 0.00699548f, 0.06604481f, 
    -0.00172246f, -0.05871198f, -0.09101903f, -0.06973297f, 0.00579256f, 0.04922811f, -0.09224123f, -0.01563762f, 
    0.02224223f, 0.04873279f, -0.07340483f, 0.05328591f, -0.00257050f, -0.02309661f, -0.18085635f, -0.02004167f, 
    0.01495463f, -0.21541607f, -0.10479984f, -0.00504429f, 0.17261718f, 0.07654916f, 0.04379473f, -0.35129106f, 
    0.12144753f, 0.04212413f, -0.07718437f, 0.14658456f, 0.06604907f, 0.02149144f, 0.01543432f, 0.10578138f, 
    0.18293223f, -0.12750927f, -0.05614625f, -0.04623811f, -0.07946881f, 0.02810995f, 0.11501629f, -0.04112413f, 
    0.10295674f, 0.07850176f, -0.18975832f, -0.18334672f, -0.21908115f, 0.09287073f, -0.09925108f, -0.06521778f, 
    -0.09577664f, -0.01906473f, -0.11606267f, -0.00357996f, 0.11045893f, -0.23025882f, 0.04523413f, -0.14419247f, 
    -0.25955120f, 0.15874611f, 0.09855777f, -0.17121133f, -0.01043742f, -0.05647263f, -0.08642267f, -0.07438861f, 
    -0.03915572f, -0.10467378f, 0.12225533f, -0.01855669f, 0.08997115f, 0.17568967f, 0.02157338f, 0.17756572f, 
    0.05109607f, -0.06155274f, 0.01575186f, 0.01773700f, -0.04728423f, 0.15433589f, -0.15727219f, 0.20386541f, 
    -0.08906753f, -0.03099176f, 0.05210037f, -0.11323136f, -0.05068897f, 0.06804466f, 0.10681815f, 0.05625430f, 
    -0.36303598f, 0.03981409f, -0.02503114f, -0.03692981f, -0.01615596f, 0.06686196f, -0.05711462f, 0.14439529f, 
    0.11618192f, -0.04348819f, -0.08346357f, 0.07697009f, 0.04999471f, 0.04993138f, -0.03167117f, 0.21089160f, 
    0.01934998f, -0.29744646f, -0.09540120f, -0.22554524f, -0.09695698f, -0.18297084f, 0.05260905f, 0.04256257f, 
    -0.06424930f, -0.15530244f, -0.02606247f, 0.16784470f, -0.02890019f, -0.24212238f, -0.21550661f, -0.14005691f, 
    -0.31321007f, -0.00079254f, 0.07700458f, -0.58856171f, 0.03501850f, -0.05682858f, 0.19265218f, -0.11050822f, 
    0.05843439f, 0.00388504f, 0.10937076f, 0.03402392f, 0.03896144f, 0.04647739f, 0.00863258f, -0.09904113f, 
    0.11995665f, 0.14939548f, -0.03176859f, 0.02013776f, -0.04207914f, 0.49200106f, -0.04415764f, 0.04947826f, 
    -0.12641037f, -0.07728311f, 0.06766787f, 0.10032766f, 0.13802509f, 0.02588906f, -0.62474018f, -0.00996939f, 
    0.04982882f, -0.05780846f, -0.01326832f, -0.11808021f, 0.02011533f, 0.07166002f, 0.03103338f, -0.28589591f, 
    -0.18530379f, 0.16092768f, -0.13526009f, 0.01020710f, 0.10444286f, 0.16085312f, -0.07041235f, 0.08316757f, 
    -0.27099404f, -0.01824365f, 0.05797930f, -0.05667917f, -0.00106818f, -0.07446771f, 0.10435326f, 0.06025947f, 
    -0.08191675f, -0.43636355f, -0.20504110f, 0.12036780f, 0.13227381f, -0.03084514f, -0.09999765f, 0.02542371f, 
    0.03167016f, 0.05004138f, 0.19741245f, 0.35029209f, 0.09461559f, -0.04726584f, -0.01831728f, -0.02503250f, 
    -0.01062598f, -0.04190903f, -0.02192455f, -0.22521272f, 0.01227005f, -0.13639820f, 0.17259420f, -0.11602677f, 
    0.08578847f, -0.01520297f, 0.00542543f, -0.07984868f, -0.25371107f, -0.32202747f, -0.24575050f, 0.04905890f, 
    0.07845839f, 0.07502118f, 0.10445757f, 0.01325772f, 0.02941119f, -0.31337941f, 0.08757230f, -0.12562639f, 
    -0.01956589f, 0.19466822f, 0.01337205f, -0.12813781f, -0.03765307f, 0.00858651f, 0.13973489f, 0.09696388f, 
    -0.08520725f, -0.05957779f, -0.00077299f, 0.01273983f, -0.02210340f, 0.11797277f, 0.02994793f, -0.22083370f, 
    -0.02776952f, 0.04869717f, -0.07104016f, -0.03810132f, 0.23547114f, 0.04899342f, 0.11242587f, -0.15437405f, 
    0.26878288f, 0.27438602f, 0.05337327f, -0.22083014f, -0.02638206f, -0.01951157f, -0.02701623f, 0.11925332f, 
    0.17916837f, -0.00655527f, 0.18896629f, 0.12221515f, 0.04978619f, -0.07367742f, 0.14295641f, 0.04766780f, 
    0.18607239f, -0.06678168f, 0.28719899f, 0.15164408f, 0.05742554f, -0.07960133f, -0.04580538f, 0.08206601f, 
    0.08610402f, 0.08119847f, -0.09124403f, 0.00862721f, -0.01940069f, -0.27161404f, 0.14563553f, -0.13113835f, 
    0.11199581f, 0.03523756f, 0.14055432f, 0.10155278f, 0.27989346f, -0.00654536f, 0.09242547f, -0.02246328f, 
    -0.15612541f, 0.01589093f, 0.11361668f, 0.12349705f, 0.34739578f, -0.14683303f, 0.09064777f, 0.20227000f, 
    0.09851272f, 0.08421415f, 0.05047418f, -0.06088705f, 0.00182397f, -0.06218173f, -0.13958174f, -0.14545539f, 
    -0.02792410f, -0.08363654f, -0.23219247f, 0.06760675f, -0.03059829f, -0.08035856f, -0.02325384f, 0.17000785f, 
    0.11506755f, 0.05238036f, -0.08602974f, -0.05401120f, 0.00327698f, -0.00971924f, 0.13609892f, 0.15071838f, 
    0.04710901f, 0.10817581f, 0.34419012f, 0.18958983f, -0.11030997f, -0.02344031f, -0.03648558f, -0.02635078f, 
    -0.00491656f, -0.17122322f, 0.01162502f, -0.10811915f, 0.10238659f, -0.03749284f, 0.15741549f, -0.00615943f, 
    0.08553077f, -0.05154503f, 0.17990564f, 0.10642173f, -0.05978082f, -0.08984252f, -0.00379646f, -0.11352275f, 
    0.01552862f, 0.16657716f, -0.05737510f, 0.22967346f, 0.05558227f, -0.12337986f, -0.16610393f, 0.05440816f, 
    0.07315680f, 0.01137543f, -0.01464498f, -0.01998950f, 0.28813004f, 0.23315053f, -0.03807563f, 0.06953801f, 
    -0.08375162f, -0.02578912f, -0.01584730f, 0.18720582f, -0.06785891f, -0.43100134f, -0.23882999f, 0.01778826f, 
    0.14420140f, 0.07297983f, -0.05328065f, 0.19502254f, 0.00203875f, -0.01996057f, -0.12768784f, -0.19560561f, 
    0.08984060f, 0.02280276f, 0.13765942f, 0.09464800f, -0.04999289f, 0.01532821f, -0.14749120f, -0.03706903f, 
    -0.21540900f, -0.08561996f, -0.05287230f, -0.05427235f, -0.17254190f, 0.03705451f, 0.08962696f, -0.02787452f, 
    0.12479103f, -0.36179581f, -0.25020450f, -0.07622277f, 0.04552263f, 0.00493972f, 0.03908753f, -0.03645898f, 
    0.13049062f, 0.32907724f, 0.09138600f, -0.05786663f, 0.04926360f, 0.12254401f, 0.02410372f, -0.09636991f, 
    0.24216923f, -0.08748113f, -0.21419640f, -0.11192720f, -0.13804999f, -0.00219408f, -0.08569647f, -0.12900139f, 
    -0.21982603f, 0.00832150f, 0.01516495f, 0.07323369f, 0.02933100f, 0.05630100f, 0.10703556f, 0.00188207f, 
    -0.01739976f, 0.06508444f, 0.07863168f, -0.05967959f, 0.27845055f, 0.19172789f, 0.02800661f, 0.13721143f, 
    0.01588829f, 0.06582361f, 0.01265080f, -0.02477980f, -0.02541918f, -0.22196181f, -0.23579584f, -0.05240744f, 
    -0.01899187f, 0.15989609f, 0.01500286f, 0.05422628f, 0.07607510f, -0.04604321f, 0.05743518f, -0.00573649f, 
    -0.05100901f, -0.01831711f, 0.03928202f, -0.01990612f, -0.07888717f, 0.15371940f, 0.02904363f, 0.11217038f, 
    0.06765601f, -0.10345729f, -0.10175210f, -0.11733793f, -0.11901618f, 0.01641103f, 0.19123903f, 0.01037194f, 
    -0.04522321f, -0.10064725f, -0.13998774f, 0.08172160f, 0.03922455f, 0.13441484f, 0.05962203f, -0.09465504f, 
    -0.27282485f, -0.11627989f, -0.14072880f, -0.16167162f, 0.05810469f, 0.05703395f, 0.01328678f, 0.17715314f, 
    -0.14681646f, 0.08797070f, -0.80399585f, -0.23180346f, -0.20983584f, 0.03868937f, -0.00840153f, 0.01323116f, 
    0.12103343f, -0.06816152f, 0.01575582f, 0.22170448f, 0.06227246f, -0.03252962f, -0.04725691f, -0.02041798f, 
    0.10765865f, 0.01476411f, 0.09662731f, 0.02834094f, -0.02435133f, -0.07921795f, -0.08242319f, -0.15599258f, 
    -0.00053050f, 0.14605764f, -0.00887192f, -0.01027748f, 0.02391049f, 0.14653088f, 0.02686669f, -0.00011699f, 
    0.08100792f, -0.08738475f, 0.08141851f, 0.13428794f, 0.08191942f, 0.03452246f, -0.73502129f, -0.26843056f, 
    0.05693040f, 0.16217658f, 0.05356437f, -0.08355866f, 0.07228659f, -0.09597285f, 0.00426751f, 0.12844463f, 
    -0.19022907f, -0.09662454f, 0.10893653f, 0.16115460f, 0.02691728f, 0.02646801f, -0.21383271f, -0.12249751f, 
    -0.29777202f, -0.09561588f, -0.17165439f, -0.08716449f, 0.03049407f, -0.06609945f, -0.00387192f, 0.20362668f, 
    0.11678653f, -0.39801446f, -0.36988065f, 0.01685129f, 0.20463921f, 0.06636188f, 0.09510561f, -0.07441910f, 
    -0.02048825f, -0.09853037f, -0.35159084f, -0.09318588f, -0.06852228f, 0.16045691f, -0.00824849f, -0.05244046f, 
    -0.06447760f, 0.19033423f, 0.04028710f, 0.08924142f, -0.08109010f, 0.21016183f, 0.17141949f, 0.07368039f, 
    0.06359017f, -0.00296697f, -0.00334411f, 0.00307458f, -0.24703640f, 0.01616557f, 0.10363492f, 0.22430906f, 
    0.07404138f, 0.10906533f, -0.07974614f, 0.12943231f, 0.03989672f, 0.19775911f, 0.01942038f, -0.06048216f, 
    0.09544814f, -0.00750585f, -0.08611836f, -0.05514518f, 0.13775095f, 0.14699885f, 0.00969405f, -0.05370797f, 
    -0.07518566f, 0.19915335f, 0.02120342f, 0.04251954f, 0.10211144f, -0.07872482f, -0.08116665f, 0.05674379f, 
    0.14172339f, 0.02261744f, 0.01601308f, 0.03016304f, 0.08659619f, 0.01423000f, 0.27062392f, -0.07409091f, 
    0.35479850f, -0.37432036f, 0.16007645f, -0.05875451f, -0.15432623f, 0.06619076f, -0.11821908f, 0.10336779f, 
    0.02123498f, -0.06463052f, 0.14378335f, 0.26267079f, 0.00996778f, -0.01893103f, -0.03056243f, -0.04516657f, 
    -0.12149820f, -0.08303505f, 0.18150717f, -0.07257485f, 0.16974497f, 0.21112944f, 0.13318960f, 0.09853940f, 
    -0.08890933f, 0.03679602f, 0.12265712f, 0.06570885f, 0.10873677f, 0.12666672f, 0.13672432f, 0.18757148f, 
    0.14634262f, 0.17351124f, 0.02241358f, 0.08816304f, 0.17757449f, 0.21321942f, -0.19386223f, 0.03868547f, 
    0.05260780f, -0.10999012f, 0.10595769f, -0.04869910f, 0.05918191f, 0.17985444f, -0.36440784f, 0.06750937f, 
    -0.18690974f, -0.06415861f, -0.05452970f, -0.12593123f, -0.04818437f, -0.09017716f, 0.06801193f, -0.01430788f, 
    0.19232891f, 0.05001122f, 0.05805903f, -0.00931756f, -0.10422534f, -0.00325728f, 0.04987849f, 0.20572564f, 
    -0.31125179f, -0.00692382f, -0.01628616f, -0.14791392f, -0.08185868f, 0.02611046f, 0.05704183f, -0.02307587f, 
    0.00541134f, 0.01918221f, -0.18542232f, -0.07970561f, -0.15046236f, 0.13169244f, 0.01030689f, -0.04234627f, 
    0.14932807f, 0.18088344f, -0.01690993f, -0.05161360f, 0.08226071f, 0.03623778f, 0.14840901f, 0.10677305f, 
    0.01271796f, 0.05654151f, -0.32866597f, -0.16818863f, 0.17380993f, 0.07997386f, -0.00496704f, -0.17213210f, 
    0.15031348f, -0.07179583f, 0.13142101f, 0.13778466f, 0.00215018f, 0.04116395f, -0.03338097f, -0.08100939f, 
    -0.05566384f, 0.06134363f, 0.12684613f, -0.06856348f, -0.31616548f, 0.04647583f, 0.00224255f, -0.17271756f, 
    -0.27153119f, -0.00412777f, 0.24088183f, 0.04606862f, -0.01770963f, -0.03672683f, -0.04833651f, -0.14970000f, 
    -0.13689330f, -0.02855254f, -0.00331676f, 0.04621285f, -0.09199660f, -0.08228645f, -0.09544551f, -0.04498402f, 
    0.15256411f, 0.13442734f, 0.03306434f, 0.14072147f, 0.01947725f, 0.02381332f, -0.01989135f, 0.02821087f, 
    -0.17110085f, -0.18293318f, -0.02032046f, -0.05540152f, -0.02041392f, 0.00671945f, 0.05415612f, -0.02419952f, 
    0.16084628f, -0.00884338f, 0.22896193f, 0.11727454f, 0.06085822f, 0.07025805f, 0.20417486f, 0.10409638f, 
    -0.07321438f, -0.13417816f, 0.12532905f, -0.06181232f, -0.12078860f, -0.07551207f, 0.05890492f, 0.11119505f, 
    -0.01166729f, 0.06903317f, 0.10684661f, -0.03897673f, 0.09408787f, 0.02105743f, 0.05606744f, 0.12631424f, 
    0.03634727f, -0.00050052f, 0.10145711f, -0.14785267f, -0.23635644f, 0.12125788f, -0.01488240f, 0.01481606f, 
    0.03133302f, 0.13921390f, 0.05865051f, -0.00089532f, -0.11461420f, 0.19411866f, 0.33906457f, 0.11288329f, 
    -0.04560949f, 0.12646410f, -0.10546654f, 0.01370602f, 0.14205772f, 0.05093637f, 0.01141800f, 0.24387427f, 
    -0.09427328f, 0.00905100f, -0.09067783f, 0.03535654f, -0.02121342f, -0.09145988f, -0.11928670f, 0.16096218f, 
    -0.13869701f, -0.05280703f, -0.04017469f, -0.00850126f, 0.03234261f, 0.10118268f, -0.11540542f, -0.26468906f, 
    0.00805627f, -0.16866307f, -0.04161698f, 0.22932987f, -0.08926188f, 0.07392722f, 0.08099805f, -0.14434905f, 
    -0.22654304f, 0.05595157f, 0.10411488f, 0.03135724f, -0.08892485f, -0.05531892f, 0.03215238f, -0.11034794f, 
    -0.05180772f, 0.21625204f, -0.00003701f, -0.11165208f, -0.04849121f, -0.13797174f, -0.02803608f, 0.00442433f, 
    0.05617569f, -0.13104533f, -0.34628135f, 0.03268312f, -0.18821862f, -0.30257478f, -0.11478606f, -0.00919703f, 
    -0.02600663f, 0.01814680f, 0.01518200f, -0.07291277f, -0.07189308f, -0.01076237f, 0.06474345f, -0.20153494f, 
    0.04948260f, -0.08309636f, -0.16791831f, 0.00028276f, 0.23725347f, -0.01139930f, -0.11507839f, -0.14964734f, 
    -0.05502775f, 0.13617295f, -0.02846267f, -0.09575935f, -0.18972914f, -0.15522632f, 0.13499647f, 0.00953180f, 
    -0.18806133f, 0.01162796f, -0.04189539f, -0.05107227f, -0.03625004f, 0.02455282f, -0.02222897f, 0.02343346f, 
    0.14019971f, -0.03860151f, -0.15742619f, 0.12728858f, -0.12271599f, -0.03604597f, -0.05728488f, 0.23895836f, 
    -0.06762640f, -0.10135275f, -0.14216378f, -0.02085073f, 0.01687934f, 0.15363815f, 0.00282555f, 0.01699970f, 
    -0.13742687f, 0.22335894f, 0.06722085f, -0.16328630f, 0.09165776f, -0.07468719f, -0.00684923f, 0.07140507f, 
    0.08661076f, -0.25953659f, -0.33421344f, 0.05100315f, 0.00833744f, 0.21131362f, 0.00386295f, 0.21529630f, 
    -0.10938351f, 0.01402118f, -0.69386739f, -0.30769879f, 0.32629216f, -0.01012211f, 0.15611599f, -0.05171357f, 
    -0.00799864f, -0.04590939f, -0.01221005f, -0.25884706f, 0.02446269f, 0.18213826f, 0.13482797f, 0.12071608f, 
    -0.05907752f, 0.02203153f, 0.15797892f, -0.00775483f, 0.24770662f, -0.22868797f, -0.25657454f, -0.00649937f, 
    -0.05460780f, 0.18347004f, 0.05049562f, -0.12472834f, 0.07816365f, -0.24818552f, 0.14035198f, 0.04510342f, 
    -0.08078385f, 0.16322117f, 0.09188492f, 0.13664746f, -0.05406839f, 0.14822200f, -0.15130742f, -0.25183392f, 
    0.13902889f, 0.19413561f, 0.11143319f, 0.01265407f, 0.10971698f, -0.00036269f, 0.01236425f, -0.04058015f, 
    -0.15874502f, 0.08387685f, -0.01957265f, 0.00526761f, -0.12483232f, 0.09650412f, 0.12979695f, -0.00238503f, 
    -0.39526632f, -0.00138571f, -0.06280734f, -0.06927022f, 0.18625192f, 0.21885265f, 0.10587639f, -0.05595519f, 
    -0.01941705f, -0.27582818f, -0.18738198f, 0.13210134f, 0.08949360f, 0.11195452f, 0.11507969f, -0.01446346f, 
    -0.09287439f, 0.17182659f, -0.02075581f, -0.04492718f, -0.11841777f, -0.07304162f, 0.03277502f, -0.25085288f, 
    -0.00673243f, -0.12288903f, -0.12525603f, 0.09435798f, -0.17169993f, -0.02160235f, 0.04353928f, -0.11945862f, 
    0.11327560f, -0.04867804f, -0.13266316f, 0.10619725f, 0.13219905f, 0.22114217f, -0.12816425f, -0.14595118f, 
    0.00777029f, -0.05797165f, -0.10071155f, 0.03738943f, -0.09802426f, -0.00598974f, 0.09520052f, 0.16844031f, 
    0.23502621f, 0.11423480f, 0.13016304f, 0.12547174f, -0.03002650f, 0.13777187f, -0.55573457f, -0.20272243f, 
    0.22441868f, 0.26101556f, 0.17661975f, 0.04495456f, 0.05233812f, 0.02423593f, 0.09709413f, -0.26923862f, 
    -0.15872972f, 0.03064532f, 0.19693413f, 0.01064396f, 0.05471670f, -0.01814882f, 0.01162231f, 0.19095345f, 
    0.07524832f, 0.10797732f, -0.33527961f, -0.06152982f, 0.10900912f, -0.05686511f, 0.05269022f, -0.04305679f, 
    -0.01436752f, -0.09591890f, -0.00739432f, 0.00008091f, 0.02905301f, 0.08905514f, 0.02287671f, 0.12214480f, 
    -0.16456598f, -0.30748537f, -0.11810562f, -0.05844085f, -0.05628582f, 0.00878536f, -0.01056973f, 0.13145727f, 
    0.05853935f, 0.05247737f, 0.14024159f, -0.31973186f, 0.06760375f, 0.24285898f, 0.03981087f, -0.05926746f, 
    -0.14133583f, -0.09672689f, 0.10946070f, 0.00695147f, -0.33807883f, -0.07748090f, -0.12158770f, 0.08068709f, 
    0.04816065f, 0.04298300f, 0.07075725f, -0.03044914f, -0.05305659f, 0.17747545f, -0.08242464f, 0.03184420f, 
    -0.04309740f, 0.06970315f, 0.00246486f, -0.00013242f, 0.08948047f, -0.04067664f, -0.28137839f, 0.02885795f, 
    0.28061026f, 0.12842155f, 0.08708053f, 0.03552094f, -0.10380857f, -0.01134078f, -0.06585800f, -0.07703455f, 
    -0.06190411f, -0.03513710f, -0.04559134f, 0.10174565f, -0.02409843f, 0.01720530f, -0.00642823f, -0.06938847f, 
    -0.08397166f, -0.09995757f, 0.09529081f, 0.04997231f, -0.16419116f, -0.16501394f, 0.09557343f, -0.08181526f, 
    -0.06028121f, 0.04849562f, 0.18202868f, 0.20852038f, 0.24784742f, 0.09998100f, 0.18235841f, -0.10653609f, 
    -0.02662526f, 0.01970397f, -0.33046353f, 0.12476307f, 0.25833684f, 0.06956744f, -0.03366199f, -0.08151285f, 
    -0.25796062f, 0.01237068f, -0.04257175f, 0.05076049f, 0.15456605f, 0.26915941f, -0.00042306f, 0.09645840f, 
    0.02912910f, -0.01337952f, -0.00260580f, -0.07242552f, 0.16850021f, -0.31644934f, -0.26652524f, 0.02530722f, 
    0.04767552f, -0.14759324f, -0.18878809f, -0.11955956f, 0.09921126f, -0.03833381f, -0.03347422f, 0.00171176f, 
    -0.16885345f, -0.07909952f, 0.04684472f, -0.08595391f, -0.08980282f, 0.13435492f, 0.06326602f, -0.07062164f, 
    0.11894335f, 0.12079235f, -0.00685998f, -0.06181950f, -0.11972065f, -0.01664725f, -0.10622180f, 0.42015919f, 
    0.00816582f, 0.03351296f, 0.02752727f, -0.07328279f, 0.01221335f, 0.05923169f, 0.02970650f, 0.09472232f, 
    0.02164711f, 0.04329721f, -0.05566425f, 0.03133882f, -0.05052771f, -0.00522867f, -0.03886943f, 0.00078916f, 
    0.02137774f, 0.04740068f, 0.00528548f, 0.00320733f, 0.00045502f, -0.03953197f, -0.06238430f, -0.01776875f, 
    0.04694317f, -0.01650285f, -0.03384098f, -0.01469104f, -0.04745053f, -0.04866427f, -0.01923847f, -0.01595338f, 
    0.03770588f, -0.05747757f, 0.02031590f, 0.05731194f, -0.03351424f, 0.00552041f, 0.05741422f, 0.00596021f, 
    -0.05034395f, -0.02101589f, -0.00390453f, 0.00004734f, 0.00009822f, 0.01996622f, -0.01328169f, 0.04387171f, 
    0.04653001f, -0.05960512f, 0.05076403f, -0.05415190f, -0.02304726f, -0.04903054f, -0.01430176f, 0.00296977f, 
    0.04935201f, -0.01306155f, 0.00509802f, 0.01007456f, -0.04823491f, 0.03184987f, 0.01505984f, -0.02201902f, 
    0.04239808f, -0.01567323f, 0.02254328f, 0.02814006f, -0.03944153f, -0.03484868f, -0.03454839f, 0.02675405f, 
    0.03006145f, 0.04694097f, -0.01188263f, -0.01567699f, 0.00734313f, 0.01292950f, 0.03083830f, 0.01183775f, 
    -0.05984241f, -0.01721143f, -0.04761321f, 0.00101282f, -0.00862661f, -0.00381135f, -0.02171289f, -0.05678049f, 
    0.00088784f, -0.02285417f, 0.03400427f, 0.03429818f, -0.02909026f, 0.00505755f, 0.04031736f, -0.03207014f, 
    0.04322198f, 0.01184959f, 0.02241864f, 0.04973632f, 0.02050050f, -0.03685832f, -0.04124084f, -0.04157352f, 
    -0.06374297f, -0.01081018f, -0.02226071f, -0.01009483f, 0.05124624f, -0.01163527f, 0.05107640f, 0.01704803f, 
    0.01990817f, 0.02069187f, -0.06228376f, -0.06407691f, -0.04558657f, -0.03207255f, 0.01719487f, -0.05527195f, 
    0.01099344f, 0.04705109f, -0.03248830f, -0.04391368f, 0.02539056f, -0.04593525f, -0.03692817f, -0.05207467f, 
    0.03400293f, -0.01328598f, -0.01587695f, 0.02217980f, -0.00716050f, -0.04363797f, -0.04695452f, 0.03979841f, 
    0.04231785f, -0.03750353f, 0.02283291f, 0.02683968f, -0.04060761f, 0.03932176f, -0.03203819f, -0.02806466f, 
    -0.05001956f, 0.05290669f, -0.00166325f, -0.04992530f, -0.00378348f, -0.04084060f, -0.05379063f, 0.04623174f, 
    -0.02085908f, 0.06090283f, -0.00744637f, -0.02514170f, 0.03157398f, -0.02578649f, 0.02063123f, -0.02183366f, 
    0.00548600f, -0.03401342f, -0.05142875f, 0.01307286f, 0.05041403f, -0.01646393f, -0.04538084f, -0.06204804f, 
    -0.00528933f, 0.04943890f, -0.03578575f, -0.00672749f, 0.05108898f, -0.03236278f, -0.06532820f, -0.04351759f, 
    0.03609044f, -0.01490326f, 0.02368084f, -0.00549299f, -0.00874235f, 0.05115686f, -0.01035202f, -0.03020609f, 
    -0.01531114f, 0.02493049f, -0.04949725f, -0.01675410f, -0.03455831f, 0.02334440f, -0.00322167f, 0.00292548f, 
    -0.03456383f, -0.00919693f, 0.03984400f, 0.05375485f, -0.01967171f, -0.02099677f, -0.00721192f, -0.02257026f, 
    0.04802291f, 0.03571566f, -0.03848665f, -0.04269300f, -0.02646649f, 0.04192156f, 0.04235700f, 0.03912374f, 
    0.01014075f, 0.04763041f, 0.03058084f, -0.02948499f, -0.02339021f, 0.05240982f, -0.01727563f, 0.00226492f, 
    0.00801092f, 0.02786232f, -0.06172536f, -0.02024058f, 0.01256875f, -0.04956791f, -0.02188636f, -0.05532820f, 
    -0.02306073f, 0.03705214f, -0.04022917f, 0.02743131f, -0.02817652f, -0.06128561f, 0.02139636f, 0.05009799f, 
    0.02456653f, 0.00268701f, -0.02474578f, 0.01693769f, 0.04836347f, 0.00545139f, -0.02824066f, 0.04754071f, 
    0.05154211f, 0.01221038f, -0.00046034f, -0.01212442f, -0.03785891f, -0.05066157f, -0.01083199f, -0.02278696f, 
    0.00598780f, 0.00614135f, -0.03054727f, -0.01347032f, 0.05473104f, -0.04894720f, 0.02564041f, -0.03910301f, 
    -0.03257839f, -0.00646855f, -0.05782747f, -0.03592308f, -0.00482376f, -0.03451855f, -0.02335835f, -0.04307616f, 
    -0.01401340f, -0.04572602f, -0.05599317f, -0.01611914f, 0.02373232f, -0.00627870f, -0.03469373f, 0.04031920f, 
    0.01936983f, -0.00080482f, 0.04360857f, -0.05330275f, -0.00106659f, 0.01137344f, -0.05365640f, -0.02818419f, 
    -0.05593215f, -0.03396735f, 0.05086248f, -0.03184104f, -0.02648873f, -0.00086580f, -0.04890160f, 0.03984767f, 
    0.00976511f, -0.01100746f, 0.00600091f, -0.05278267f, -0.02815626f, -0.04321106f, -0.03612176f, -0.00275538f, 
    -0.01623240f, 0.03145224f, 0.02734785f, -0.04337795f, -0.04221157f, -0.02861287f, 0.01109955f, 0.03792552f, 
    -0.01258888f, -0.04468771f, -0.03589148f, -0.05729664f, 0.00711052f, -0.00827384f, 0.04350553f, -0.03369511f, 
    -0.06723389f, 0.00574286f, 0.03307284f, -0.02703270f, -0.02082516f, -0.05336849f, -0.02594393f, -0.04539541f, 
    0.03862495f, -0.06029284f, 0.03560432f, -0.02379341f, -0.02158815f, -0.03082599f, -0.01123937f, 0.04645465f, 
    -0.04763039f, 0.05252218f, 0.04167079f, 0.03602783f, 0.04816691f, -0.05385097f, 0.04676529f, 0.02918585f, 
    -0.05118741f, 0.00084122f, 0.01102597f, 0.03901432f, -0.03577434f, 0.04035783f, -0.04345256f, 0.02743318f, 
    -0.00393557f, -0.01527963f, -0.02170209f, 0.01873336f, 0.02555660f, -0.04384214f, -0.03487145f, -0.04109966f, 
    -0.00154704f, 0.02050595f, 0.01692997f, -0.02211167f, -0.03794980f, 0.02790163f, 0.03063901f, 0.01434796f, 
    -0.00114949f, 0.05707774f, -0.04121369f, 0.00255682f, 0.04074821f, -0.03999469f, 0.02632815f, -0.00989566f, 
    0.01217704f, -0.05173891f, 0.02043413f, 0.01722397f, -0.02868585f, -0.02773782f, 0.01850406f, -0.03210539f, 
    0.02160058f, -0.04495752f, -0.05757260f, 0.04329192f, 0.02671717f, -0.01980282f, -0.03749907f, -0.04119811f, 
    -0.05843166f, -0.02746927f, 0.02935359f, 0.01017656f, -0.01064907f, -0.02461557f, -0.04496429f, -0.02495032f, 
    -0.03757991f, 0.00044458f, 0.00796280f, -0.03672196f, -0.00475404f, 0.02574533f, -0.05563975f, -0.03946343f, 
    0.01460023f, -0.00622356f, 0.04008906f, -0.01394988f, -0.03462667f, -0.04549567f, -0.03086622f, 0.02378539f, 
    0.02405396f, 0.02860826f, 0.02214137f, -0.02282413f, 0.03103665f, 0.00931912f, 0.04957874f, 0.04098975f, 
    -0.01591585f, -0.02567565f, 0.02735400f, 0.00402417f, -0.03397767f, -0.05211568f, 0.04511128f, 0.02278361f, 
    -0.06192924f, -0.06042653f, 0.01275075f, -0.01998324f, -0.04993010f, -0.00226115f, -0.04500968f, -0.02545747f, 
    -0.04722574f, -0.03052116f, 0.02013906f, 0.01536521f, 0.01024651f, 0.00766552f, 0.00154405f, 0.01252110f, 
    -0.03352831f, -0.04660413f, -0.05243872f, -0.06284545f, -0.01361145f, 0.05115224f, -0.03453932f, -0.05175709f, 
    0.03793211f, 0.04502773f, 0.00665206f, 0.05459432f, 0.02145534f, -0.00286642f, -0.00927605f, 0.00587289f, 
    0.03536114f, -0.01251949f, 0.03552651f, 0.01169361f, -0.02171913f, 0.02304587f, -0.05668828f, 0.01061586f, 
    0.04302070f, -0.00825149f, -0.03961384f, 0.04286101f, -0.04765014f, -0.05054463f, -0.02599732f, -0.02423960f, 
    0.01998146f, -0.00993528f, 0.03845667f, 0.00965589f, -0.00049515f, 0.03548134f, 0.02159293f, -0.05892219f, 
    -0.01550364f, 0.05810268f, 0.01818575f, 0.02025109f, -0.01942152f, -0.01242904f, 0.03767957f, 0.03641629f, 
    0.02460500f, 0.02653447f, -0.06107448f, 0.00809689f, 0.00103750f, -0.05897841f, 0.01854639f, -0.00597670f, 
    -0.05663773f, 0.04393435f, -0.01792813f, -0.00181885f, 0.02101984f, 0.01043793f, -0.05872311f, -0.05999815f, 
    -0.02825523f, -0.06156409f, -0.05447463f, -0.01532719f, 0.01632289f, -0.06475627f, -0.00853434f, -0.01579286f, 
    -0.06620281f, -0.06493268f, 0.02841355f, -0.00092710f, -0.01609967f, -0.06153928f, -0.03312015f, -0.03265430f, 
    -0.04422405f, -0.02548062f, 0.02347798f, 0.02196743f, 0.01039280f, -0.01442558f, -0.02392057f, 0.04208677f, 
    0.03593040f, -0.01459690f, -0.02394893f, -0.04942760f, 0.02178612f, -0.04812010f, 0.03281027f, -0.03442609f, 
    -0.04089755f, -0.06500196f, -0.02396297f, -0.05085351f, -0.06051119f, -0.04652627f, -0.05739909f, 0.04404705f, 
    0.04487824f, 0.02367321f, -0.04373812f, -0.03814442f, 0.04265204f, -0.01559988f, -0.04291151f, 0.00823759f, 
    0.01395317f, 0.03474861f, 0.03324448f, 0.03384181f, -0.00799342f, 0.02702376f, -0.04950867f, 0.03887067f, 
    -0.04339381f, -0.02028562f, 0.05060028f, 0.05092722f, 0.01236026f, -0.03438977f, 0.03398925f, -0.04031533f, 
    -0.05826033f, 0.01130320f, -0.03022224f, 0.00550877f, -0.05456281f, -0.05264931f, 0.00567322f, -0.02816278f, 
    -0.05370836f, 0.00601994f, 0.03272607f, -0.05865442f, 0.00272100f, 0.03934740f, 0.01741734f, -0.02211464f, 
    -0.27694753f, 0.13253932f, 0.18662795f, 0.07867180f, 0.21676455f, -0.14234197f, 0.09939460f, -0.08222967f, 
    0.00009688f, -0.25965884f, -0.01393170f, 0.13699502f, 0.02373065f, 0.04144334f, -0.01643423f, -0.14404187f, 
    -0.09443516f, 0.13345204f, 0.00807387f, 0.08615651f, 0.01450207f, 0.04140835f, -0.01183038f, 0.21751854f, 
    0.02005626f, 0.04634341f, 0.06557392f, -0.08819920f, -0.08481484f, -0.07415944f, -0.00629343f, -0.03059755f, 
    0.16845863f, -0.12908135f, -0.08265952f, -0.03789527f, 0.14960766f, -0.10630922f, -0.07737181f, 0.00325393f, 
    0.05035037f, 0.06796278f, 0.03915337f, 0.11266436f, -0.05044554f, -0.20355220f, -0.09139854f, 0.14754698f, 
    -0.06843197f, 0.19650397f, 0.04088669f, -0.16222277f, 0.08816998f, -0.02485941f, 0.00780595f, -0.10683800f, 
    0.09394437f, 0.00335204f, -0.02171373f, 0.08300036f, -0.06995682f, -0.02046906f, 0.08067521f, -0.11260211f, 
    -0.06562383f, 0.10721347f, -0.01316087f, 0.05675917f, 0.03350860f, 0.13866720f, 0.00743487f, -0.02289733f, 
    0.33994147f, -0.04626204f, -0.00031895f, 0.02356124f, -0.14246283f, -0.09150541f, -0.09598545f, 0.04982994f, 
    -0.02267358f, 0.17186972f, -0.10189441f, -0.11730301f, -0.11858790f, 0.07116318f, -0.06318089f, 0.04175068f, 
    0.02314014f, 0.00690955f, 0.08419290f, 0.00084714f, -0.08721548f, 0.01871359f, -0.09076965f, 0.03713623f, 
    -0.03151430f, -0.06876314f, -0.10664848f, 0.11531425f, 0.02248010f, 0.17899802f, -0.02966263f, -0.04270682f, 
    0.02639564f, 0.08111889f, 0.05274135f, 0.06771704f, 0.34800777f, 0.02434638f, -0.13585149f, 0.06353047f, 
    -0.04392010f, 0.00092140f, -0.09362656f, 0.15017229f, -0.12684864f, -0.32886776f, 0.00597754f, -0.21443821f, 
    0.04999964f, 0.06705593f, -0.03118503f, -0.07083802f, -0.06894787f, 0.06139765f, 0.11295556f, -0.17320731f, 
    0.05025107f, 0.06479488f, -0.10487707f, -0.04281918f, 0.00704562f, -0.08061570f, -0.05822787f, 0.12409803f, 
    -0.17475259f, -0.05944911f, -0.07332920f, -0.00867510f, -0.14115249f, 0.07098868f, 0.00894646f, 0.17684515f, 
    0.10386864f, 0.19341053f, 0.13996673f, 0.06859998f, -0.09944822f, 0.18905362f, -0.10159310f, -0.01734996f, 
    -0.06800251f, 0.71574348f, 0.11127191f, -0.01919485f, 0.14244282f, 0.02664211f, 0.04187515f, -0.06302521f, 
    0.08634247f, 0.15140362f, -0.31576955f, 0.03758641f, 0.08135684f, -0.03077081f, -0.21188203f, 0.12185533f, 
    -0.01232912f, 0.08837302f, -0.03888870f, 0.02541636f, -0.01368699f, 0.01531387f, -0.12560931f, -0.06701488f, 
    0.04032310f, -0.15492423f, 0.02487754f, 0.06044247f, -0.16821153f, -0.00531211f, 0.15291150f, 0.10215886f, 
    -0.03376433f, 0.03190941f, -0.08292902f, -0.12650587f, 0.10479144f, 0.05993513f, 0.08672042f, 0.09204530f, 
    0.05427880f, -0.01116157f, -0.02324160f, 0.07371521f, -0.02388801f, 0.00054014f, -0.24531458f, -0.21169388f, 
    0.00330976f, -0.02776607f, 0.04896845f, 0.03007031f, 0.08573874f, 0.06695458f, -0.05923370f, 0.07339230f, 
    0.17446363f, -0.18198991f, 0.12108074f, 0.07018911f, 0.14352825f, -0.10058358f, -0.14539826f, 0.16721678f, 
    -0.05691034f, -0.11712116f, -0.08549547f, 0.03341867f, -0.03623503f, -0.07849217f, -0.09821925f, -0.02802842f, 
    0.04594713f, 0.09223045f, -0.19649965f, -0.00603943f, -0.06223086f, 0.00016641f, 0.01837517f, 0.12689982f, 
    0.03977728f, -0.02295149f, -0.47952554f, -0.46784309f, 0.23497902f, 0.07909913f, 0.22324193f, -0.04752839f, 
    -0.06831264f, -0.02534877f, -0.15934481f, 0.26743707f, 0.09542465f, -0.02958180f, 0.06127923f, -0.04914393f, 
    -0.15137179f, 0.05422145f, -0.02211230f, -0.05665782f, 0.46087396f, -0.29136658f, 0.02542289f, -0.04077791f, 
    -0.04936792f, -0.07242549f, -0.13682026f, -0.09035930f, -0.07978020f, 0.16838981f, 0.01244942f, -0.21125467f, 
    -0.03806396f, 0.06125383f, -0.09153982f, 0.05106416f, 0.21720572f, -0.03956870f, -0.06413648f, 0.11002803f, 
    -0.01660993f, 0.01205820f, 0.00155882f, 0.07351380f, 0.10713399f, -0.11006520f, 0.14543922f, -0.12026496f, 
    -0.07869095f, -0.25953889f, -0.02144225f, -0.14810683f, 0.02143322f, 0.03342725f, 0.04956562f, 0.06744320f, 
    -0.17274435f, -0.36987951f, 0.08893665f, 0.10704046f, 0.02565247f, 0.02355738f, 0.07580245f, -0.02263588f, 
    0.04887623f, -0.24669227f, 0.07879814f, 0.21775612f, 0.00905780f, 0.10014718f, -0.07875253f, -0.02707821f, 
    0.06724343f, -0.06149923f, 0.12426838f, 0.46454009f, 0.11701018f, 0.09769583f, -0.00080702f, 0.04828303f, 
    0.06302244f, 0.03597505f, 0.00229359f, 0.06037602f, 0.13080233f, -0.02974204f, 0.03632661f, 0.02695383f, 
    0.23471354f, 0.27423218f, -0.05155095f, 0.04927934f, -0.21963730f, 0.18226689f, 0.10873763f, -0.05241564f, 
    0.04552955f, 0.12123372f, 0.02258334f, -0.04404383f, 0.12435370f, 0.09410315f, -0.18104520f, -0.03665475f, 
    -0.26977903f, -0.05268895f, 0.07933355f, 0.09282473f, 0.01838701f, 0.06672502f, -0.05960945f, 0.15456310f, 
    0.13064900f, -0.09924003f, 0.08101510f, -0.01477405f, -0.11857668f, -0.05451908f, 0.09465440f, -0.17606737f, 
    0.06660812f, 0.03443073f, -0.07815207f, -0.02580021f, 0.10001937f, 0.05445819f, 0.04631325f, 0.18957008f, 
    0.11353737f, -0.49367064f, -0.08569796f, -0.15422826f, -0.08784637f, -0.11128031f, -0.05624069f, 0.00941512f, 
    -0.15417813f, 0.15358604f, 0.33774918f, -0.10897124f, 0.04458118f, 0.00890454f, 0.04532044f, 0.12989217f, 
    0.24145098f, 0.04787863f, 0.11327600f, 0.11631944f, 0.05263339f, -0.07651342f, -0.03381000f, 0.11300904f, 
    0.17864136f, 0.05750733f, 0.18831708f, 0.18806620f, 0.12676528f, -0.16490348f, -0.04459217f, 0.11835302f, 
    -0.04691965f, -0.17721482f, -0.11119365f, -0.05041125f, 0.02943142f, -0.09930294f, -0.18033616f, -0.04253775f, 
    0.10853022f, -0.10211191f, -0.06090342f, -0.11397929f, 0.03832920f, -0.08113784f, -0.40216082f, -0.02382261f, 
    -0.07749219f, 0.01142380f, -0.10426273f, -0.29380348f, 0.19988336f, 0.08269095f, 0.05631975f, 0.16387483f, 
    0.00816243f, -0.11413438f, -0.10356784f, 0.04773019f, 0.09369002f, -0.00665187f, -0.02892642f, -0.39367899f, 
    0.21330853f, 0.02746380f, -0.09792844f, -0.12875606f, 0.02381673f, 0.03047445f, 0.16732155f, 0.04442072f, 
    -0.19284062f, 0.29686332f, 0.26839337f, 0.06649248f, -0.04809211f, 0.13371952f, -0.04402984f, 0.14517747f, 
    0.18984857f, 0.58379036f, -0.16261052f, -0.03549312f, -0.01018400f, -0.05973303f, -0.14377391f, 0.03087865f, 
    0.14962988f, -0.09447307f, -0.26626906f, 0.22569868f, 0.01495412f, -0.05100328f, -0.07631851f, 0.11029272f, 
    0.06625192f, 0.10463568f, -0.00742476f, 0.21783113f, 0.05883112f, 0.16930427f, -0.01134162f, -0.02832192f, 
    -0.03222935f, -0.14787827f, 0.10368466f, -0.09162146f, -0.18836765f, 0.26601171f, 0.34004170f, 0.05017535f, 
    0.15718015f, 0.20897259f, -0.11660451f, -0.05190778f, 0.07181896f, 0.05058200f, 0.21446747f, -0.12287692f, 
    -0.07005546f, -0.01559387f, 0.08884977f, 0.04699164f, -0.01704455f, -0.19021566f, 0.21291301f, -0.38888708f, 
    -0.00131262f, -0.21462670f, -0.12236753f, -0.09666196f, 0.05136833f, 0.01926954f, 0.22554787f, 0.22688241f, 
    -0.01085738f, 0.07045504f, -0.07452712f, 0.00393217f, -0.03640048f, -0.05750812f, -0.00310394f, 0.10126066f, 
    -0.12373942f, -0.12988542f, 0.14133446f, -0.15749729f, 0.15151030f, 0.20632030f, -0.04575807f, 0.09430655f, 
    -0.03079991f, -0.13250451f, 0.06713438f, -0.15397020f, -0.06788867f, -0.08908956f, -0.08039650f, 0.07598425f, 
    0.08329207f, 0.18081310f, -0.19411783f, -0.66384614f, -0.19978684f, -0.02283302f, 0.07274935f, 0.13494383f, 
    0.09290453f, -0.14036110f, 0.11526550f, 0.01385286f, -0.02431606f, -0.08742566f, 0.07137015f, 0.05397145f, 
    0.05293793f, -0.03071714f, -0.07211540f, 0.03947994f, 0.18453874f, -0.03609242f, -0.12805603f, 0.00841236f, 
    0.11723893f, -0.22694430f, -0.16544718f, -0.01218158f, 0.03065998f, 0.25990975f, -0.33935714f, -0.09582963f, 
    -0.19375476f, 0.07309345f, 0.04025289f, 0.03017408f, 0.01605335f, -0.00994222f, -0.11595201f, 0.08532780f, 
    0.18177804f, 0.17359030f, 0.07478326f, 0.13502806f, 0.00084417f, 0.09947160f, 0.00068303f, -0.12131678f, 
    -0.21026863f, 0.02796344f, -0.09287688f, -0.00901787f, -0.03768342f, 0.12010412f, 0.07743789f, 0.10255886f, 
    -0.33360782f, -0.31384370f, 0.08802968f, 0.06055164f, 0.16992305f, 0.00541300f, 0.22228910f, 0.01047747f, 
    0.05973387f, -0.37821364f, -0.17128861f, 0.02374171f, 0.10628178f, 0.05917277f, 0.09737003f, 0.07019854f, 
    -0.13929488f, 0.07714412f, -0.04276247f, 0.10309137f, 0.16513348f, -0.05133307f, -0.06340837f, -0.05808817f, 
    -0.03267036f, -0.02659637f, -0.05369649f, 0.14529449f, -0.25274581f, 0.19825915f, -0.08108801f, -0.06277185f, 
    0.02650546f, 0.11580616f, -0.02031938f, 0.12824275f, 0.35056603f, -0.04026910f, 0.23181522f, 0.00150508f, 
    -0.02116921f, 0.00954807f, 0.00685270f, 0.08081130f, -0.02340293f, -0.03814968f, -0.07993954f, -0.14664963f, 
    0.02027862f, 0.08400150f, -0.01668273f, 0.09718218f, -0.16055091f, -0.02797403f, -0.12928519f, -0.23530921f, 
    -0.01989637f, 0.01985426f, 0.09116011f, 0.07468533f, -0.09291814f, 0.04780611f, 0.05858552f, 0.01423970f, 
    0.11903331f, -0.20270684f, 0.02790605f, 0.02674124f, 0.01203744f, 0.08424298f, 0.10396917f, -0.16343595f, 
    -0.48715308f, -0.17913552f, -0.53457129f, -0.08093549f, -0.06130024f, -0.03591460f, 0.09598989f, -0.06490064f, 
    0.05675846f, 0.19260655f, -0.19444498f, 0.08212650f, -0.13646643f, 0.19219585f, 0.00255866f, -0.07021474f, 
    0.00237011f, -0.06253667f, 0.07262178f, 0.19221212f, -0.23315938f, 0.10881982f, -0.18705234f, 0.01341889f, 
    -0.10550509f, -0.04431387f, 0.07968445f, -0.25693461f, 0.19492321f, -0.17090863f, -0.00415450f, 0.01292572f, 
    -0.01320695f, 0.01520951f, -0.11254542f, 0.01331304f, -0.19177255f, -0.30476984f, -0.20653138f, 0.10443600f, 
    0.18569794f, -0.05250888f, 0.14618585f, 0.14169031f, -0.03960836f, 0.05223706f, 0.16332516f, 0.01860875f, 
    0.00597910f, 0.00969801f, 0.06949707f, 0.07885156f, -0.07248679f, -0.02867875f, -0.08147653f, -0.00423799f, 
    0.26921320f, 0.06078388f, 0.06669816f, 0.06672267f, 0.00078326f, 0.09902015f, 0.05130391f, 0.12146361f, 
    -0.05312284f, 0.27984452f, 0.03048571f, -0.14299628f, 0.00262240f, -0.06332451f, -0.04770189f, 0.02362273f, 
    -0.00518324f, -0.20728011f, 0.32438523f, 0.04435166f, 0.06409560f, -0.01338536f, -0.02979678f, 0.19523327f, 
    0.04668380f, -0.47947285f, -0.28733063f, -0.56400394f, -0.00849588f, -0.08484753f, -0.05344085f, 0.17972021f, 
    -0.01721446f, 0.14290027f, 0.18435042f, 0.07443485f, -0.06305868f, 0.17346746f, -0.12740357f, -0.02935853f, 
    0.03350740f, 0.13874143f, -0.00366157f, 0.13485968f, -0.00628629f, -0.33178899f, -0.03242034f, -0.08513046f, 
    0.04062635f, 0.00791891f, 0.00876994f, 0.03577951f, -0.07849878f, -0.30252627f, 0.00750641f, -0.05633080f, 
    -0.04464263f, 0.13465846f, -0.04306456f, -0.03972605f, 0.12046336f, -0.66590071f, 0.30093917f, 0.06523304f, 
    0.12547791f, -0.10058099f, -0.04545597f, 0.06441075f, 0.08164673f, -0.05164839f, 0.20513694f, -0.08488658f, 
    0.00247167f, 0.11672025f, -0.01630707f, -0.07091570f, -0.08390147f, 0.05309747f, -0.08360207f, 0.11714813f, 
    0.10554489f, -0.12906776f, 0.04608344f, -0.09096163f, -0.05284991f, 0.06536791f, 0.08098809f, -0.08904710f, 
    0.17801456f, 0.24612005f, 0.02350680f, 0.06205078f, -0.01013265f, 0.11587413f, 0.04924003f, -0.08364736f, 
    -0.10030652f, 0.00599024f, -0.00108095f, 0.33075446f, 0.10321713f, 0.21306239f, 0.02801086f, -0.00285274f, 
    0.00755740f, -0.01717991f, -0.04362404f, 0.19427304f, 0.07135824f, -0.06244843f, -0.03280349f, -0.09786487f, 
    -0.00564538f, -0.03845697f, 0.00670202f, -0.27989000f, -0.20944144f, -0.55154210f, 0.22926718f, 0.01314821f, 
    -0.00931668f, 0.00943291f, 0.05464057f, -0.08227197f, 0.13058360f, 0.19188002f, -0.05652938f, 0.01869744f, 
    0.02977665f, 0.00575034f, -0.03864890f, -0.04843983f, 0.04532093f, -0.16739507f, 0.10057443f, -0.04006404f, 
    0.00408669f, 0.04029100f, -0.00287148f, -0.01692641f, 0.14791422f, -0.05623882f, 0.24686447f, 0.28963637f, 
    0.01310106f, -0.02244429f, 0.00114446f, -0.13579822f, -0.08235033f, 0.03906642f, 0.02035387f, 0.20275381f, 
    0.07528481f, 0.30761704f, -0.07740720f, 0.06347594f, -0.09948836f, 0.18211935f, 0.17085120f, 0.02647845f, 
    0.05682717f, -0.06372593f, 0.05847261f, -0.26029992f, -0.10063577f, 0.06836278f, 0.06127079f, -0.13376170f, 
    -0.03794219f, 0.16504380f, 0.22177321f, -0.20999122f, -0.09960179f, 0.13356589f, 0.00817614f, 0.03953168f, 
    0.02091029f, -0.36424968f, 0.15112342f, 0.21430075f, -0.01553890f, 0.13362657f, 0.01442288f, -0.12464876f, 
    0.06858055f, 0.05003159f, -0.07200377f, 0.33577624f, 0.25851312f, 0.12337490f, 0.11516543f, -0.07768691f, 
    -0.10500162f, 0.00792664f, -0.05376523f, 0.32651278f, -0.04451951f, -0.02962587f, 0.07167430f, 0.15408646f, 
    0.03173021f, 0.02005900f, -0.00614110f, 0.07016429f, 0.20229676f, 0.03521898f, -0.02104301f, 0.13470308f, 
    -0.15599701f, 0.02588451f, 0.15508105f, 0.07325092f, -0.01860400f, 0.00788455f, 0.30306086f, 0.17628436f, 
    -0.01011719f, -0.09276981f, -0.16967115f, -0.13676168f, 0.08826642f, 0.14604416f, -0.09220508f, -0.03102625f, 
    -0.14965990f, -0.06193250f, 0.18453565f, 0.02868577f, -0.12470277f, -0.29512504f, 0.21247932f, -0.10203458f, 
    -0.16199413f, -0.13221222f, 0.31768236f, -0.21692191f, -0.00556818f, -0.15078254f, -0.00511545f, -0.17507513f, 
    0.00136981f, -0.08349204f, 0.10565345f, -0.02898290f, 0.28591579f, 0.05309857f, 0.01471421f, 0.04346670f, 
    0.08370451f, -0.00039145f, -0.46525136f, -0.13418928f, 0.10814318f, 0.01412865f, 0.04358188f, -0.05025328f, 
    0.09569217f, 0.03233105f, -0.03065622f, 0.03290318f, 0.06240516f, 0.14276369f, -0.13352585f, 0.12493634f, 
    -0.03207483f, 0.00938512f, 0.05842859f, -0.20396988f, 0.09263789f, -0.14173727f, 0.25709513f, -0.20858349f, 
    -0.14293739f, -0.02090820f, 0.00005076f, -0.07526396f, -0.00887775f, -0.23377268f, -0.26174408f, -0.22113414f, 
    0.10178298f, 0.04586133f, 0.03924542f, 0.05532651f, -0.05554084f, 0.16531971f, 0.18977068f, 0.18522552f, 
    0.09376214f, 0.12607639f, -0.01280053f, -0.19764856f, 0.04358651f, 0.01283307f, -0.13331036f, -0.03168107f, 
    0.05414532f, -0.16259250f, 0.13869250f, 0.03927042f, 0.04354480f, -0.13412292f, 0.15927434f, -0.02684717f, 
    0.01002431f, -0.08285623f, -0.07855088f, -0.21933334f, -0.01882522f, 0.12410651f, -0.14804922f, 0.08035318f, 
    -0.04528188f, -0.10584593f, -0.02189313f, 0.32701516f, 0.01184504f, -0.03950379f, -0.03010369f, -0.11459848f, 
    0.10121895f, 0.13883002f, 0.04268585f, 0.13039596f, 0.03228251f, 0.05610174f, 0.05589679f, 0.09601238f, 
    0.18867734f, -0.06172825f, 0.07547090f, 0.05434434f, 0.16532080f, 0.05116452f, 0.01059217f, -0.10567717f, 
    0.02654251f, -0.03333228f, 0.13773122f, 0.05530427f, 0.24129349f, 0.25498712f, 0.09374232f, 0.01376005f, 
    0.07825132f, -0.01135332f, -0.08265300f, 0.00267371f, 0.05489574f, 0.03683692f, -0.06112262f, 0.02874584f, 
    -0.10978036f, -0.08261838f, -0.14054862f, 0.07804769f, -0.01604689f, -0.10753641f, -0.10209420f, -0.14126036f, 
    -0.01049601f, -0.05829265f, -0.00966335f, 0.02511129f, 0.04571417f, -0.10539497f, 0.14977781f, -0.11739981f, 
    -0.06971187f, 0.06295238f, 0.04367474f, -0.01994880f, -0.06949450f, 0.18228897f, -0.06145049f, 0.06879842f, 
    -0.04799301f, -0.00862788f, 0.05655995f, 0.00653995f, -0.09633863f, -0.00977867f, 0.05194644f, 0.03331320f, 
    -0.01408608f, -0.07224268f, -0.00396907f, -0.21739964f, -0.06045047f, -0.01494117f, 0.03735889f, 0.06270523f, 
    -0.03120388f, -0.02020964f, 0.12696420f, -0.04615635f, -0.07276066f, -0.17953429f, -0.30218944f, -0.02177134f, 
    0.09199446f, -0.01547810f, 0.12824744f, -0.03050968f, -0.05292395f, 0.14378442f, -0.00366460f, -0.04720110f, 
    -0.04279544f, -0.05216116f, -0.13727713f, -0.03741915f, 0.26275545f, -0.39573622f, -0.18983458f, 0.08273607f, 
    -0.10153508f, 0.08500432f, -0.09284260f, 0.05059202f, -0.00064880f, -0.06113927f, 0.06561866f, 0.13811059f, 
    0.04575450f, -0.21871023f, -0.08825779f, 0.13533217f, 0.01563097f, -0.09843868f, -0.22399022f, -0.03492923f, 
    -0.06009803f, 0.14569040f, -0.13122286f, 0.03179870f, -0.00386517f, 0.08837948f, 0.03843685f, -0.22027312f, 
    -0.12218551f, -0.37649387f, 0.08605915f, 0.14163184f, -0.14081432f, -0.00925836f, -0.11281984f, 0.19510351f, 
    0.34536567f, -0.17849140f, -0.17999697f, 0.04972886f, 0.18645892f, 0.00861445f, -0.08836377f, 0.02860056f, 
    0.00730488f, 0.03707931f, 0.04675820f, -0.26751006f, 0.13170467f, 0.01977344f, -0.04936185f, 0.06721167f, 
    -0.03133440f, -0.06322504f, 0.06485173f, 0.29013467f, -0.16292052f, 0.06198613f, 0.02841264f, -0.00587067f, 
    -0.05405417f, -0.02325782f, -0.14641798f, 0.18633720f, 0.14952447f, -0.22419052f, -0.08187080f, -0.02938697f, 
    -0.04903577f, 0.17007816f, -0.07606287f, -0.10871793f, -0.17834730f, 0.20811430f, 0.01397835f, -0.10532978f, 
    0.18037736f, 0.04219246f, 0.03531364f, -0.06548984f, 0.00574740f, -0.12003851f, -0.18980156f, -0.08938592f, 
    0.04478646f, -0.03913300f, 0.08676416f, -0.02947577f, 0.08242115f, 0.04777795f, -0.01680274f, 0.13928285f, 
    -0.23898418f, 0.04299628f, -0.04088647f, 0.06136720f, -0.02014077f, 0.06315631f, 0.22823557f, -0.25503352f, 
    -0.03263794f, -0.08895410f, 0.02969435f, -0.11295725f, -0.05040615f, 0.06798477f, -0.05659984f, 0.00475948f, 
    -0.05745238f, -0.22092538f, -0.11275141f, 0.06417476f, -0.07979523f, -0.05943612f, -0.09405472f, 0.09069277f, 
    -0.07324048f, -0.12286497f, 0.22637871f, -0.16297178f, -0.03010174f, -0.13431092f, 0.01973706f, -0.02174298f, 
    0.03622777f, -0.03174965f, 0.09430391f, -0.20376505f, -0.08504966f, -0.08615695f, -0.00107499f, 0.12503245f, 
    -0.11307292f, 0.16498093f, 0.15862252f, 0.02193761f, -0.00129182f, -0.16262639f, 0.01899666f, 0.13088192f, 
    0.07887519f, -0.07856867f, 0.09500974f, -0.00809592f, 0.10467396f, -0.07207142f, -0.15412964f, 0.09166382f, 
    0.01680795f, 0.19256628f, 0.03561016f, -0.01931170f, 0.03580132f, 0.20519930f, -0.07695983f, 0.00206966f, 
    0.11136714f, 0.06277170f, -0.06169391f, -0.04306331f, 0.17467645f, 0.05734102f, 0.01312044f, 0.27754921f, 
    -0.40255269f, 0.06739689f, -0.02361605f, 0.07449702f, 0.03012613f, 0.00651737f, -0.00833182f, -0.61181182f, 
    0.43781668f, -0.22071528f, 0.01384952f, -0.08275302f, -0.11615019f, -0.02760424f, 0.05287317f, -0.00627890f, 
    -0.11481567f, -0.02511831f, -0.14572558f, -0.07399242f, -0.10616971f, -0.24940418f, -0.11006175f, 0.03553860f, 
    -0.12162409f, -0.25135154f, -0.22477353f, -0.20820870f, -0.09595835f, -0.12505284f, -0.04638116f, 0.01099972f, 
    -0.07237127f, 0.03909548f, 0.16243845f, 0.04839566f, 0.04775711f, 0.08477303f, 0.07927692f, -0.21792936f, 
    0.07260468f, 0.12807024f, -0.08149057f, 0.24091496f, -0.21873713f, -0.05112452f, -0.16842464f, -0.01661512f, 
    0.04052572f, -0.03754574f, 0.01848064f, 0.02814665f, -0.19185190f, -0.05883937f, 0.10636346f, -0.16664307f, 
    0.04070685f, 0.05038578f, 0.03344599f, 0.08499087f, -0.05383034f, 0.12931232f, 0.07337212f, -0.23102328f, 
    -0.03731757f, -0.15746388f, 0.14628305f, 0.00520901f, 0.06319980f, 0.13477106f, -0.03170268f, -0.07805109f, 
    -0.00844767f, -0.09024120f, -0.11111331f, -0.11950016f, 0.04694999f, -0.10701591f, 0.07175770f, 0.04659561f, 
    -0.00864437f, 0.00034561f, 0.10935749f, 0.17055032f, -0.03387344f, 0.12057111f, 0.21953455f, 0.17376289f, 
    0.13063414f, -0.05588904f, 0.02565078f, 0.03414023f, 0.11025065f, -0.00950883f, 0.01202851f, -0.01494555f, 
    0.18360312f, -0.00564852f, 0.07321629f, 0.06815364f, 0.12237639f, -0.27312776f, -0.09096056f, -0.04606767f, 
    0.00384013f, -0.05951719f, 0.50526315f, 0.05252856f, 0.18865624f, 0.00151583f, -0.05511785f, -0.04060652f, 
    -0.13840592f, -0.06575833f, 0.04803357f, -0.00988161f, -0.25851130f, -0.15185481f, 0.01531640f, 0.08192400f, 
    0.03266680f, 0.02375356f, -0.12788071f, -0.03743152f, 0.09632298f, 0.09172968f, 0.00012628f, 0.10501564f, 
    -0.00608636f, 0.03876199f, 0.07397591f, 0.08162406f, -0.04157649f, 0.41997668f, 0.21509296f, -0.14346352f, 
    0.10524703f, 0.07115371f, 0.01084434f, -0.06500093f, 0.00805151f, 0.06884366f, 0.12695061f, -0.07016638f, 
    -0.06237197f, -0.06471279f, -0.00240744f, -0.10394966f, -0.03800412f, 0.10545811f, 0.07313949f, 0.20043269f, 
    0.00248879f, -0.00963562f, 0.00820406f, -0.01730477f, -0.16870998f, 0.10968106f, 0.11211412f, -0.07317574f, 
    -0.04417132f, 0.21203919f, 0.10031319f, -0.05431737f, -0.35480237f, -0.10525526f, -0.03726119f, 0.18469657f, 
    -0.01455706f, -0.15219125f, -0.04680580f, -0.02901807f, -0.05319607f, 0.00272101f, 0.00270190f, 0.03620192f, 
    0.29646301f, 0.11639935f, -0.01726342f, -0.17024060f, -0.04474714f, -0.18653421f, -0.16741103f, 0.14890470f, 
    0.01465611f, 0.08194023f, 0.17372814f, -0.27434129f, -0.26822984f, -0.13313681f, -0.03402197f, -0.02865656f, 
    0.04233292f, -0.12165026f, 0.02682197f, 0.15826051f, 0.13055453f, -0.26792940f, -0.15429468f, 0.07791699f, 
    -0.05602611f, -0.01247714f, 0.04295773f, 0.15278754f, 0.05267807f, -0.05729071f, 0.15886568f, 0.06615102f, 
    0.17966190f, -0.01907171f, 0.08972389f, -0.07694578f, 0.04117297f, 0.02820056f, -0.08348410f, -0.00631423f, 
    0.02788913f, -0.05513620f, 0.12704372f, 0.11046484f, 0.04590480f, -0.01399370f, 0.03697011f, -0.28754011f, 
    0.15407223f, 0.09362224f, -0.19415708f, 0.14164786f, 0.06027057f, 0.00778786f, 0.11838645f, 0.12082524f, 
    0.12426817f, 0.01146585f, -0.22775567f, -0.00657193f, 0.04079586f, -0.09247074f, 0.04794655f, -0.09819721f, 
    -0.06477577f, 0.00272438f, -0.22933872f, 0.08107021f, 0.04426719f, 0.07419140f, -0.03320893f, 0.01039768f, 
    0.10007674f, -0.04169290f, 0.02724180f, -0.13612014f, 0.23444408f, 0.12374967f, 0.09680229f, -0.12631460f, 
    -0.09711466f, -0.02282169f, -0.10542138f, 0.22043131f, 0.06329509f, 0.19687147f, -0.16965714f, 0.00712695f, 
    -0.06134452f, 0.12064996f, -0.05189228f, 0.13941211f, 0.08682737f, 0.19494431f, 0.14562351f, 0.01667458f, 
    -0.05601517f, -0.22535098f, 0.08352040f, 0.16641171f, 0.27087656f, 0.15475786f, 0.05869994f, -0.01269537f, 
    0.03416669f, 0.05362349f, 0.25999931f, -0.00112629f, -0.03743524f, 0.02106221f, 0.15072417f, -0.00290731f, 
    0.15246466f, 0.03385948f, 0.00233523f, 0.03284032f, -0.00321434f, -0.15332338f, -0.13488735f, 0.05300551f, 
    -0.04801457f, 0.01760896f, -0.10199764f, -0.00272564f, 0.08319802f, -0.01882221f, -0.05319264f, -0.12905002f, 
    0.01952493f, 0.18877737f, -0.05297851f, 0.10447776f, -0.10759959f, 0.09273701f, -0.01465836f, -0.01259403f, 
    -0.11468652f, 0.10967502f, 0.16999818f, 0.04540318f, -0.03810017f, -0.09914388f, 0.11265243f, -0.00469931f, 
    0.11145888f, 0.15993163f, 0.05724552f, -0.14555682f, -0.10797930f, 0.13022228f, -0.01418075f, 0.10094802f, 
    -0.03788444f, -0.01234499f, 0.00462022f, 0.14568527f, 0.01723415f, 0.25163305f, 0.14815567f, 0.01207776f, 
    0.05083775f, -0.05138101f, 0.09973947f, 0.04420635f, -0.18278797f, -0.28662363f, -0.22796209f, 0.07832572f, 
    -0.00138977f, -0.01697153f, -0.05824393f, 0.07917112f, 0.05579679f, 0.12729566f, -0.00192189f, -0.02791114f, 
    -0.16426073f, -0.01787146f, 0.08196427f, 0.21396258f, -0.02844691f, -0.06597272f, 0.20904636f, 0.22550151f, 
    0.10125288f, 0.14686622f, -0.12335529f, -0.05067925f, 0.09740200f, -0.05028567f, -0.03733512f, -0.13239717f, 
    0.00389584f, 0.10373148f, 0.02094303f, -0.09880392f, 0.15863156f, -0.16040428f, 0.22317465f, 0.01896705f, 
    0.19843297f, -0.00521618f, -0.13754098f, 0.11691815f, 0.10247408f, -0.09307016f, -0.05475831f, 0.06586125f, 
    -0.04291097f, 0.11033851f, 0.16704579f, 0.10089422f, 0.07750383f, 0.08017614f, 0.05951314f, 0.24099901f, 
    -0.11026977f, -0.05530198f, 0.27413785f, 0.09181394f, 0.14780654f, 0.09447679f, 0.06787961f, -0.17484012f, 
    0.11823289f, 0.01517364f, -0.07972466f, 0.05979146f, 0.24854746f, 0.28170046f, 0.05347744f, 0.05363433f, 
    -0.12971380f, 0.12847333f, 0.02366196f, 0.24907698f, 0.02033496f, -0.09268387f, -0.01861852f, 0.07264327f, 
    0.01395373f, 0.30604580f, -0.22003990f, -0.03493899f, -0.05349876f, 0.17710951f, -0.06735425f, 0.14893515f, 
    -0.03960483f, 0.03981069f, -0.17363732f, 0.05727255f, 0.09108762f, -0.07852474f, 0.12115667f, -0.23735026f, 
    0.00873453f, -0.07876208f, -0.01190459f, 0.13286604f, 0.08983902f, 0.08353017f, -0.16061565f, 0.03441619f, 
    0.03407796f, -0.05307137f, 0.07763494f, -0.01471744f, 0.20931429f, 0.19625501f, 0.08059819f, 0.01773576f, 
    0.27028355f, -0.17755011f, -0.07863905f, 0.00173862f, -0.00281589f, -0.04714470f, 0.09999431f, 0.03226363f, 
    0.26936081f, -0.09267347f, 0.12629859f, -0.19458351f, 0.04511480f, 0.07511162f, -0.10337614f, 0.02194380f, 
    0.03388530f, 0.05574202f, 0.19259089f, 0.21543184f, -0.01647383f, 0.18971771f, 0.19063322f, 0.19675332f, 
    -0.11385147f, -0.17547992f, 0.26120195f, 0.25525194f, 0.29692003f, -0.19931908f, 0.13119765f, 0.07262339f, 
    0.12274514f, 0.02017006f, -0.00576290f, 0.19416788f, -0.02338784f, 0.05074073f, 0.15965733f, 0.21558879f, 
    0.18337977f, -0.03077646f, -0.01525503f, -0.21936673f, 0.02761632f, 0.09916504f, 0.07929085f, -0.01773231f, 
    -0.08289294f, -0.28479591f, -0.06274018f, 0.02217520f, -0.10308269f, -0.19740863f, 0.07230204f, 0.05100514f, 
    0.07760206f, 0.06806992f, 0.09674550f, 0.01522844f, 0.00513194f, 0.18048120f, 0.13057610f, -0.02889538f, 
    -0.07864940f, 0.12134396f, -0.03631622f, -0.06022683f, -0.00371956f, 0.03604615f, -0.12302677f, -0.04553970f, 
    0.16567825f, -0.00497882f, -0.04430805f, 0.15673611f, -0.12198067f, 0.11107720f, 0.00909409f, -0.10714880f, 
    -0.07439993f, 0.06391446f, 0.00736785f, 0.11206567f, 0.03567145f, 0.25506428f, 0.06660287f, -0.02897415f, 
    -0.06707436f, 0.03088047f, -0.41643763f, 0.25675294f, 0.02173122f, -0.22746155f, 0.12656577f, 0.06546564f, 
    -0.00512775f, -0.33657068f, -0.11660469f, 0.09654413f, 0.04589015f, 0.20080248f, 0.04419084f, 0.04483625f, 
    -0.02505993f, -0.23951271f, 0.02779958f, -0.00468500f, -0.07991003f, 0.05980130f, -0.04587107f, -0.01574810f, 
    -0.12903544f, 0.02608564f, 0.13759328f, 0.02664725f, 0.13575572f, 0.31179750f, -0.12593776f, 0.09941933f, 
    -0.26672167f, 0.15378723f, 0.05548756f, 0.05990686f, 0.12062702f, -0.33849505f, -0.41736481f, -0.08070447f, 
    -0.04990660f, 0.14739038f, 0.14514735f, -0.12008494f, 0.03869421f, -0.01975808f, 0.11814886f, -0.17304464f, 
    -0.16093665f, -0.01752832f, 0.06954298f, 0.09283128f, -0.05736800f, -0.01736753f, 0.09302028f, 0.05398021f, 
    -0.13266191f, 0.22584634f, 0.30140960f, -0.04049144f, -0.00415300f, -0.02907158f, 0.01399441f, 0.02236224f, 
    0.07939892f, 0.17630325f, 0.05222845f, 0.26234853f, -0.00114004f, -0.11371104f, 0.04815998f, -0.07971921f, 
    0.17003228f, 0.05389148f, 0.01807275f, 0.05297753f, 0.10951729f, 0.09389673f, -0.04729259f, -0.06283309f, 
    0.10285697f, -0.17738809f, -0.37310991f, 0.23424433f, 0.13393012f, 0.12132840f, 0.16041848f, 0.04944295f, 
    -0.01188100f, 0.00420985f, -0.17523724f, -0.02331866f, -0.17135610f, 0.07295603f, -0.01856685f, 0.06356113f, 
    0.12273508f, 0.22157031f, 0.03924398f, -0.03331357f, 0.02266152f, -0.14158949f, 0.04193724f, -0.22806972f, 
    0.06897795f, 0.03737681f, 0.00358831f, 0.01216983f, 0.05163774f, -0.05999077f, 0.15583216f, 0.21126503f, 
    0.00787693f, -0.03811176f, -0.14430046f, -0.21150337f, 0.07812405f, 0.01473237f, -0.14460698f, -0.09289209f, 
    -0.16279010f, -0.03673186f, 0.12347458f, -0.13198222f, 0.08562705f, 0.08199326f, 0.05631094f, -0.19525164f, 
    -0.07003678f, 0.02898756f, -0.08192647f, -0.13006966f, 0.07324801f, 0.03166476f, -0.03423524f, -0.05287090f, 
    0.01304516f, 0.13322683f, 0.24385388f, -0.02067636f, -0.09460733f, -0.00735590f, -0.10135843f, -0.10771007f, 
    0.02629612f, -0.16865607f, 0.20670649f, 0.22221571f, -0.18589726f, -0.20984305f, -0.14082864f, -0.08897611f, 
    0.06589268f, -0.18944560f, 0.03215592f, -0.05881818f, -0.01307658f, -0.19759376f, 0.07082812f, 0.07911763f, 
    0.10093004f, 0.12367704f, -0.11829655f, 0.06190255f, 0.14800799f, -0.16578242f, -0.44690683f, -0.10744257f, 
    0.04639348f, 0.01185114f, 0.11547051f, 0.03236775f, -0.03308111f, 0.00933862f, 0.02229915f, -0.05934680f, 
    0.02136965f, -0.08493850f, -0.03634883f, -0.07582397f, 0.10187360f, 0.02052120f, 0.04239453f, -0.14188202f, 
    0.14539503f, -0.11734441f, -0.04958639f, 0.00726597f, -0.25306645f, -0.12421360f, -0.30391514f, 0.09918313f, 
    0.16813630f, 0.01488558f, 0.03181862f, -0.02319332f, -0.13271137f, -0.18071923f, -0.03744027f, 0.05739621f, 
    0.04010826f, -0.00212123f, -0.01563306f, -0.02994678f, 0.02223648f, -0.05141087f, -0.03774403f, 0.04954366f, 
    0.04468817f, -0.03813570f, -0.00647534f, 0.02847759f, 0.05232656f, 0.02757853f, 0.00850305f, -0.01384206f, 
    0.04783184f, 0.04897593f, 0.02410671f, 0.02528529f, -0.04296825f, 0.03541063f, -0.00650907f, -0.00843967f, 
    -0.01546702f, 0.00309799f, 0.00736939f, -0.02144777f, 0.02594687f, 0.03445886f, -0.05293569f, 0.01904574f, 
    0.04300109f, 0.00720249f, 0.02585157f, -0.02430273f, -0.05872159f, 0.01128083f, -0.02632986f, 0.02622288f, 
    0.00716718f, 0.02383224f, 0.04808230f, 0.00200785f, -0.04060065f, 0.00452381f, -0.03596878f, 0.01443820f, 
    -0.01560954f, -0.05765927f, -0.00747938f, 0.00105836f, 0.02904114f, -0.01180778f, 0.00300473f, 0.03683105f, 
    0.01594073f, -0.04938276f, 0.04865845f, -0.02447200f, -0.06637088f, -0.06058011f, 0.00117483f, 0.01323001f, 
    0.01679292f, 0.01677822f, -0.06582396f, -0.02506533f, -0.02832304f, 0.00049221f, -0.04347631f, -0.01750170f, 
    0.02432324f, 0.02626274f, 0.04779470f, -0.03878155f, -0.03085792f, -0.01170331f, 0.02663718f, -0.02351581f, 
    0.01086811f, -0.01962168f, 0.00334742f, 0.00301443f, -0.04811319f, 0.04713294f, -0.05083866f, -0.06379718f, 
    0.04378435f, -0.02657116f, -0.03903151f, -0.01592368f, -0.05253898f, -0.04195156f, 0.03929049f, -0.04960313f, 
    0.02290929f, -0.03258651f, -0.04546390f, 0.00769074f, -0.03978335f, -0.01079085f, 0.04879123f, 0.04664035f, 
    0.02279357f, 0.03896371f, -0.05469284f, -0.05756679f, 0.04870762f, 0.03561611f, 0.00635286f, -0.05625197f, 
    0.01657914f, -0.01153870f, -0.00963862f, -0.06120696f, 0.00497581f, -0.02297601f, -0.04258222f, -0.00487104f, 
    -0.00303460f, -0.02722946f, -0.02462753f, -0.04491092f, 0.03445645f, 0.04453713f, -0.02332348f, -0.00334247f, 
    0.03699948f, -0.03362580f, 0.02482890f, -0.06014271f, -0.03315677f, 0.00573279f, -0.02410343f, -0.00803356f, 
    -0.02570199f, -0.00043542f, 0.02745653f, -0.05058577f, -0.03695759f, 0.04146538f, 0.04998547f, 0.00033592f, 
    0.01580760f, -0.03185600f, 0.02995402f, -0.03935990f, -0.02761774f, -0.04579210f, 0.00409072f, 0.03275649f, 
    0.03294048f, -0.01119602f, -0.06274662f, -0.00675024f, -0.05852937f, 0.04213746f, 0.01566680f, -0.00864020f, 
    -0.00175746f, 0.01161067f, -0.00387744f, 0.04355533f, 0.04138593f, 0.02779945f, 0.04809713f, -0.06604706f, 
    -0.05692068f, -0.04462893f, -0.02901044f, 0.00174787f, 0.04029480f, -0.01092015f, -0.02670665f, -0.05983839f, 
    -0.04773688f, 0.01389365f, -0.02033193f, -0.03882050f, -0.01979249f, 0.00264229f, 0.04575480f, 0.01987412f, 
    -0.04734058f, 0.04833148f, -0.01678506f, -0.01448847f, 0.03413454f, -0.00823918f, -0.06570357f, -0.06220338f, 
    -0.05692175f, -0.03102294f, -0.01605227f, -0.02939690f, -0.04276125f, -0.04884825f, -0.01160708f, -0.00440496f, 
    -0.04902314f, -0.04148035f, 0.00442720f, -0.03219945f, -0.02588625f, -0.00576830f, 0.03015836f, -0.04226344f, 
    0.04131623f, -0.00635234f, 0.00462549f, 0.01777427f, -0.02491172f, -0.03949585f, -0.04671212f, 0.04888546f, 
    0.04808494f, -0.03312434f, 0.02740742f, 0.04149564f, -0.00245466f, 0.03065309f, -0.05404002f, 0.01233742f, 
    -0.04784826f, 0.00814527f, -0.03823075f, 0.00861106f, -0.00884069f, -0.02627437f, -0.03694959f, -0.05572291f, 
    -0.03437322f, -0.03838329f, -0.00785739f, 0.03996005f, -0.02271888f, -0.01793678f, -0.02766503f, -0.03789590f, 
    0.04007141f, 0.03714060f, 0.04543414f, -0.02049810f, 0.04312797f, -0.05593890f, -0.02911280f, -0.05523488f, 
    0.00296606f, -0.00371685f, -0.06109371f, 0.00628055f, 0.02366427f, 0.02090933f, -0.00942047f, -0.00172242f, 
    -0.04768967f, -0.00443975f, -0.01723478f, 0.02436932f, 0.01124443f, -0.03284135f, -0.05420733f, 0.03511251f, 
    0.02773827f, -0.03776314f, 0.00959521f, -0.00736026f, 0.00896529f, -0.02616599f, -0.01602405f, -0.03305776f, 
    0.02720231f, 0.02920702f, -0.05407675f, -0.00429798f, -0.05966177f, -0.00100711f, -0.02798142f, -0.05411795f, 
    0.00674821f, 0.01501423f, 0.00446298f, -0.05025335f, -0.02270315f, 0.01034038f, -0.01522066f, -0.02220384f, 
    -0.13804150f, -0.20354638f, 0.16894522f, 0.02866292f, 0.03197099f, -0.16102831f, 0.00873416f, -0.19641924f, 
    0.12019877f, -0.03133589f, 0.07057419f, 0.18274514f, 0.06414717f, -0.05643888f, 0.15953138f, 0.10538831f, 
    -0.05947154f, -0.16082606f, 0.27987432f, 0.17466816f, 0.03487147f, 0.20227964f, -0.10143781f, 0.08828256f, 
    0.02803523f, -0.10982973f, 0.12399229f, 0.25075269f, 0.18838038f, 0.07145777f, 0.22628836f, 0.04703278f, 
    0.20701718f, 0.18014233f, 0.00174241f, 0.02442505f, 0.25729823f, 0.07688913f, 0.04108289f, 0.01181945f, 
    0.07511995f, -0.01352177f, 0.12279281f, -0.04868479f, 0.07128980f, -0.17098005f, 0.12534356f, -0.03901396f, 
    -0.09152716f, 0.06332578f, 0.00500667f, -0.23172539f, -0.02587045f, 0.00855533f, 0.11600617f, 0.15067764f, 
    0.12340856f, 0.07838937f, -0.12249008f, 0.16726077f, 0.07405680f, 0.02459122f, 0.10743691f, -0.08971590f, 
    0.07346138f, -0.06281555f, 0.05893297f, 0.07341534f, 0.13157612f, -0.05473204f, 0.01462299f, -0.17129309f, 
    -0.20077345f, 0.05052906f, -0.28826675f, 0.00053116f, -0.15399384f, 0.11020034f, 0.10546722f, 0.08292654f, 
    -0.18606190f, 0.40595326f, 0.17422834f, 0.07868470f, 0.07064171f, 0.04341939f, 0.16402932f, 0.23498616f, 
    -0.29274929f, -0.01304387f, -0.04752010f, 0.02473625f, -0.04530339f, 0.08886237f, -0.07578031f, -0.08898478f, 
    0.16723855f, -0.06013386f, 0.06695113f, 0.12949653f, -0.08629771f, -0.17918266f, 0.12810501f, 0.02788060f, 
    0.07229282f, 0.04231390f, 0.11357614f, -0.02771295f, -0.17034484f, -0.01586743f, -0.11190441f, -0.12625891f, 
    0.04620833f, 0.03624004f, 0.01109347f, 0.19870047f, 0.01841372f, -0.12643047f, 0.21797979f, -0.12091138f, 
    -0.02809758f, 0.11477992f, 0.01871007f, 0.04340350f, -0.09086630f, 0.21698576f, 0.41738838f, 0.31832200f, 
    0.19004163f, 0.07217629f, 0.04751983f, 0.22206287f, 0.19986327f, -0.05201536f, 0.02203280f, 0.18286577f, 
    0.04556571f, -0.01716460f, 0.07701994f, -0.13165346f, 0.08271733f, 0.18481395f, 0.18359753f, 0.03563923f, 
    0.38879055f, 0.15438050f, 0.25242010f, -0.06632687f, 0.22094566f, -0.17084835f, 0.19005015f, -0.03067115f, 
    0.04177225f, 0.19975612f, 0.12126683f, -0.04330949f, 0.20611599f, 0.05025402f, 0.09235564f, -0.05450853f, 
    0.20489949f, 0.07127272f, -0.05371866f, 0.16471253f, -0.11725251f, 0.01992577f, -0.11535474f, 0.01217426f, 
    0.24736315f, 0.12634140f, -0.08108031f, -0.12197196f, 0.14789826f, 0.07352882f, 0.12216696f, -0.00873694f, 
    0.00554148f, 0.19269797f, -0.00776107f, 0.01108161f, -0.06122261f, 0.21232331f, 0.16176769f, 0.12765750f, 
    0.02533638f, -0.00831153f, -0.06455541f, -0.05555791f, -0.11805774f, -0.02325629f, 0.17559960f, 0.18333089f, 
    0.04637569f, 0.07673669f, 0.12510526f, 0.07192410f, 0.15673418f, 0.02289981f, -0.22906552f, 0.21105255f, 
    0.23513164f, -0.15532534f, -0.02990803f, -0.06447993f, 0.08915128f, 0.03713201f, 0.08336980f, -0.05409755f, 
    -0.03796154f, -0.03471905f, 0.05985471f, 0.16170366f, 0.15363865f, -0.25232032f, 0.02609238f, 0.03556340f, 
    -0.30023018f, 0.08526004f, -0.10233693f, 0.11919798f, -0.19642840f, 0.01253514f, 0.13911426f, -0.06166719f, 
    0.13171607f, 0.22615969f, 0.09208232f, 0.24240460f, 0.01927459f, 0.05882000f, 0.00096839f, 0.17471649f, 
    0.22496289f, 0.07221437f, -0.49975851f, -0.01330897f, -0.19921958f, 0.00212923f, 0.13741755f, 0.00049930f, 
    -0.06751071f, 0.04436000f, -0.01824279f, -0.08418964f, 0.00695682f, 0.01003309f, -0.06176206f, 0.01238472f, 
    -0.04950170f, -0.06322533f, -0.16358086f, -0.01975390f, 0.10593270f, -0.19267941f, 0.14097083f, 0.04221956f, 
    0.04435449f, 0.00475382f, -0.02272721f, 0.00334345f, -0.18652970f, -0.25888005f, -0.11432560f, -0.06561170f, 
    -0.17141111f, 0.15731701f, -0.08022182f, 0.10589223f, 0.09027670f, 0.01794790f, 0.05007429f, 0.10784570f, 
    0.03255196f, -0.12996608f, 0.11758414f, -0.07693758f, 0.03926898f, 0.01174468f, -0.07976127f, 0.17054445f, 
    -0.10377827f, -0.03830379f, 0.00309186f, 0.09377288f, 0.00577941f, 0.18867891f, 0.04425776f, -0.17719597f, 
    -0.04273554f, 0.01868931f, -0.01855052f, -0.05530341f, -0.00373627f, -0.06109983f, -0.00661309f, -0.03820302f, 
    0.02826033f, -0.04466064f, -0.03303901f, -0.05314304f, 0.01787332f, 0.00126372f, 0.01176549f, -0.01656110f, 
    0.04262586f, -0.01590027f, -0.01407261f, -0.02726709f, 0.03410166f, -0.04931494f, -0.00959798f, -0.00765514f, 
    -0.00099261f, 0.00478315f, 0.00899857f, -0.04260042f, -0.02196424f, -0.03562337f, -0.02158470f, -0.01955150f, 
    -0.03076698f, -0.01707439f, 0.02303955f, -0.01715461f, -0.06193951f, -0.05913909f, -0.03702090f, -0.03815803f, 
    -0.03184890f, 0.00865006f, 0.04565220f, -0.00435155f, -0.05012447f, 0.00242998f, -0.01385302f, 0.02714543f, 
    0.00329847f, 0.04417234f, 0.01543574f, 0.02682235f, 0.04065156f, -0.00800189f, 0.03862307f, 0.02933276f, 
    0.00142341f, -0.01252168f, -0.06160879f, 0.00472895f, -0.01520057f, 0.01327487f, -0.03877082f, 0.03376802f, 
    -0.03250590f, -0.01872114f, 0.04050648f, -0.03674371f, 0.04848761f, 0.02768821f, 0.03063681f, 0.00782638f, 
    -0.02166243f, -0.00385277f, 0.04425783f, 0.00007374f, 0.02364020f, -0.04956414f, -0.01221934f, 0.03505347f, 
    -0.03555487f, -0.04310065f, -0.04761549f, 0.02453360f, 0.03242846f, -0.04481449f, -0.04640809f, 0.02291106f, 
    0.00254800f, 0.03985965f, -0.02617796f, -0.02339569f, -0.03649929f, 0.01567147f, -0.02920214f, 0.03160215f, 
    -0.03819133f, 0.02544161f, -0.02676750f, 0.01816864f, 0.01308912f, -0.00257737f, -0.02027142f, -0.03761735f, 
    -0.01260170f, 0.01026129f, -0.06112880f, -0.03397824f, -0.02743961f, -0.01530573f, -0.05589807f, 0.03135983f, 
    -0.02698349f, 0.03759095f, 0.00711857f, 0.03066125f, 0.03627443f, 0.03902184f, -0.01304464f, 0.00481497f, 
    -0.03493102f, -0.01352847f, -0.00740017f, -0.05260459f, -0.04341451f, 0.04789085f, 0.04122137f, -0.06147387f, 
    -0.05954472f, -0.00858747f, 0.03402893f, 0.01967265f, -0.03815475f, 0.03622419f, -0.01131622f, -0.02041711f, 
    -0.05331732f, 0.03569205f, -0.05748630f, -0.00726960f, -0.00178442f, 0.00319651f, -0.00837770f, -0.00470092f, 
    0.00658951f, 0.05221178f, -0.01789535f, -0.02413743f, -0.06466180f, -0.00978149f, -0.01914671f, -0.02526267f, 
    0.04630271f, -0.05391552f, -0.05783339f, 0.05219723f, 0.03391096f, -0.00452866f, 0.03647947f, 0.03062734f, 
    -0.03035489f, 0.01683832f, -0.03617234f, 0.00534663f, 0.00561113f, -0.03549137f, -0.05660465f, 0.04925769f, 
    0.01099955f, 0.03666729f, 0.01843903f, 0.02426865f, 0.03285585f, 0.05275709f, -0.04237071f, -0.00446127f, 
    -0.02495046f, 0.04425614f, -0.04899162f, -0.00417899f, -0.04414244f, 0.00530300f, -0.01350485f, 0.05015118f, 
    -0.01924063f, -0.00255015f, 0.03702256f, -0.04287050f, 0.00717846f, -0.00410183f, 0.02595188f, 0.02494403f, 
    0.01018019f, -0.03641613f, -0.05356074f, 0.03715315f, -0.05937222f, 0.02241686f, 0.00059596f, 0.02373500f, 
    0.04531013f, 0.01845038f, -0.05382245f, 0.03127762f, 0.05144717f, -0.01831825f, -0.04016327f, 0.01775861f, 
    -0.05421549f, -0.04284414f, -0.00698317f, 0.03778083f, -0.03100555f, 0.01107120f, -0.02870036f, -0.04984956f, 
    -0.05224263f, -0.00244006f, -0.04338570f, 0.02797697f, 0.01622642f, 0.00879221f, -0.03557824f, 0.01206584f, 
    -0.01376253f, -0.00334823f, -0.04166686f, -0.01735663f, 0.02724415f, 0.00313987f, 0.04807959f, -0.05893488f, 
    0.00241756f, -0.00364921f, -0.03369279f, 0.00881326f, -0.00940874f, -0.01090180f, 0.02560490f, -0.05832266f, 
    -0.05553276f, 0.04898454f, 0.02602895f, 0.01201843f, -0.01690886f, -0.03053643f, -0.06337117f, -0.05758676f, 
    0.02055352f, -0.05074241f, 0.05629587f, -0.03493225f, 0.02164698f, -0.01108424f, -0.00641713f, -0.03202016f, 
    -0.06357051f, -0.03563865f, -0.05646486f, -0.02336583f, -0.03119533f, -0.02726897f, 0.01696567f, 0.02002860f, 
    -0.02575756f, -0.02318303f, -0.03137538f, -0.05055613f, -0.04220784f, -0.02937097f, -0.02380066f, -0.04595472f, 
    -0.03594902f, -0.02619414f, -0.03601709f, -0.04335884f, -0.05448475f, 0.03203648f, 0.01881056f, -0.04928511f, 
    -0.03678881f, -0.01465566f, -0.01153987f, -0.03559340f, 0.01019566f, 0.00058429f, 0.01278058f, -0.02196734f, 
    -0.22053398f, 0.02667631f, -0.28014240f, 0.00685310f, 0.12043744f, 0.07877851f, -0.00268323f, -0.00743403f, 
    0.04779917f, -0.02412783f, -0.00349595f, -0.05022581f, 0.08754566f, -0.05840173f, -0.11044025f, 0.04418329f, 
    0.06657971f, -0.11703066f, -0.42691651f, -0.13475123f, 0.14532699f, -0.10026737f, -0.06117288f, -0.16347276f, 
    -0.11509775f, -0.13168834f, -0.04006757f, 0.06505433f, -0.21012180f, 0.15398598f, -0.01763362f, -0.03784264f, 
    -0.16513090f, -0.01181454f, -0.19986010f, -0.08309499f, -0.20629323f, -0.12544094f, -0.06154964f, 0.01348967f, 
    -0.10411119f, -0.09461192f, -0.13960165f, 0.15040205f, 0.11030877f, 0.02122982f, 0.00653064f, 0.00383265f, 
    0.13942820f, -0.14206050f, 0.13365363f, -0.10192532f, 0.05311642f, 0.12232949f, 0.06887268f, 0.13972676f, 
    -0.01574378f, 0.04131486f, -0.08906385f, -0.08901077f, 0.02712034f, 0.05836768f, -0.02789886f, -0.36951825f, 
    0.07702436f, 0.01627882f, -0.08258809f, -0.04084301f, 0.04758118f, -0.16329259f, 0.21648319f, -0.12694050f, 
    -0.10911603f, -0.17663449f, -0.25673467f, 0.25666627f, -0.01577674f, 0.10853864f, 0.12700936f, -0.20354186f, 
    -0.01150255f, -0.42002097f, -0.13124675f, 0.10714466f, -0.03929620f, 0.08857299f, -0.05110241f, -0.07588838f, 
    -0.05517982f, -0.06950646f, 0.09018707f, 0.23466504f, -0.04932268f, -0.09269954f, 0.04795114f, 0.02907191f, 
    0.01340779f, 0.03621649f, 0.09137326f, 0.28276628f, 0.16556591f, -0.00007024f, 0.19559044f, -0.02656267f, 
    -0.06689648f, 0.12190425f, 0.04149757f, 0.06986104f, 0.13629864f, -0.02021115f, -0.14555478f, 0.03312968f, 
    0.04483427f, 0.10139892f, 0.07545434f, 0.17719969f, -0.08284394f, 0.06810574f, -0.01111127f, 0.08355352f, 
    0.19611843f, 0.15545270f, 0.15878823f, -0.04146143f, 0.22838028f, -0.10864928f, -0.16516702f, 0.06886508f, 
    0.21268398f, 0.01607756f, 0.03682059f, -0.02492649f, -0.00630267f, -0.09411220f, -0.02791744f, -0.20361541f, 
    0.15244254f, 0.01872643f, 0.15879925f, 0.09061231f, 0.01939630f, -0.06046661f, -0.05792692f, 0.00410576f, 
    -0.33769295f, 0.08409172f, -0.32619131f, -0.09959479f, -0.02715986f, -0.09839763f, -0.04820423f, -0.10286420f, 
    0.19541217f, -0.34877586f, -0.14323965f, -0.13432710f, 0.18383649f, -0.08472009f, -0.00720163f, -0.00220750f, 
    -0.35374367f, 0.08307051f, 0.33202890f, -0.20643111f, 0.02926916f, 0.07123431f, 0.15386793f, -0.19662029f, 
    0.16429144f, 0.03633631f, 0.01802672f, 0.10117906f, -0.17749792f, 0.17469424f, -0.03710911f, 0.05246473f, 
    0.02516681f, -0.12460890f, -0.15609933f, -0.01897853f, -0.31624919f, -0.03841612f, -0.20651425f, 0.02220599f, 
    -0.09845812f, -0.03351264f, 0.00018139f, 0.06808636f, -0.00298139f, -0.00276778f, 0.10688815f, -0.31318763f, 
    0.04881867f, -0.09706290f, 0.05415452f, 0.01741759f, -0.02868337f, -0.00163662f, 0.19783889f, -0.12116490f, 
    -0.00094981f, 0.04869495f, -0.04048514f, -0.00318657f, 0.02795593f, -0.04385801f, 0.08179347f, -0.25794888f, 
    0.04617197f, -0.14536166f, -0.02105968f, 0.17891164f, 0.04514845f, -0.19528906f, 0.13321492f, -0.01397402f, 
    0.31989378f, 0.01310171f, 0.05925177f, 0.14484286f, 0.01299207f, 0.02925426f, 0.02862763f, 0.06272503f, 
    -0.05635688f, 0.11481768f, 0.09778155f, -0.06954639f, 0.11101560f, 0.05559479f, 0.02942657f, -0.06087467f, 
    -0.12579300f, 0.21334787f, 0.38124561f, 0.06539471f, -0.14962290f, 0.10123240f, 0.05292784f, -0.10241009f, 
    0.02840184f, 0.08045206f, 0.08466013f, -0.32274160f, -0.12794183f, -0.01402876f, 0.17633961f, 0.15983304f, 
    0.20364600f, 0.01921329f, -0.07405858f, 0.05099572f, 0.01315331f, -0.05379367f, -0.10442036f, 0.11423181f, 
    0.09210154f, 0.05648085f, 0.01266131f, 0.02298815f, 0.27097905f, 0.23379511f, 0.36037484f, -0.16272323f, 
    0.16326961f, 0.05700864f, -0.04313236f, 0.03403777f, 0.15962258f, 0.02817191f, -0.19403596f, -0.03968319f, 
    -0.00299495f, -0.02269052f, -0.05023329f, -0.05749698f, -0.00374822f, 0.12610073f, 0.06515267f, 0.08294816f, 
    0.01564011f, 0.08226983f, -0.08922488f, 0.06414153f, -0.04218465f, -0.01434177f, 0.05099987f, 0.05845599f, 
    0.28941286f, -0.01335100f, -0.10814503f, -0.15324563f, 0.04224387f, 0.04438400f, -0.01378892f, -0.15957369f, 
    0.09363297f, -0.10953659f, -0.27137411f, -0.07994398f, -0.04854868f, 0.11788281f, -0.01192096f, -0.10044204f, 
    -0.15382388f, -0.07374205f, 0.09885938f, 0.13739368f, -0.49569511f, 0.08717371f, 0.05398542f, 0.17534609f, 
    -0.08743198f, -0.08607307f, 0.04776829f, 0.13618840f, 0.18687202f, -0.40623146f, -0.02323912f, -0.04938576f, 
    -0.04353573f, 0.26859739f, 0.03420414f, -0.00137327f, -0.10216109f, -0.03138025f, 0.02749235f, 0.17976303f, 
    0.02870898f, 0.18850659f, -0.01205472f, 0.01426116f, 0.00504414f, 0.07737788f, 0.16824411f, -0.11702965f, 
    -0.03217540f, -0.11446356f, 0.20580497f, -0.02546067f, 0.00091135f, 0.08090025f, -0.33130243f, -0.08648881f, 
    -0.06356522f, 0.06068198f, -0.02092584f, -0.07795902f, 0.11824843f, 0.12616219f, 0.00019276f, -0.23640417f, 
    0.08804731f, -0.12368477f, 0.18150818f, -0.01822417f, 0.00203961f, 0.05255541f, -0.10158956f, 0.07179939f, 
    0.24905187f, -0.37421912f, 0.11106326f, -0.08566348f, -0.09012716f, -0.25990069f, 0.08051235f, 0.13247862f, 
    0.27823785f, -0.20722868f, -0.17546196f, -0.25371391f, 0.12908399f, 0.16465648f, 0.25532645f, -0.01566695f, 
    -0.15665150f, -0.23683022f, -0.34408203f, 0.18954352f, 0.18702209f, -0.05605014f, 0.12072358f, 0.07231262f, 
    0.08846068f, -0.13302939f, -0.21200469f, -0.40848917f, -0.20569275f, -0.02809103f, -0.09373563f, -0.02236708f, 
    0.02755962f, 0.08733673f, 0.08115076f, -0.00441553f, -0.14138889f, 0.05482680f, -0.00643109f, 0.11930597f, 
    -0.13529004f, -0.13461101f, 0.10168895f, 0.12214240f, 0.14174476f, -0.12826695f, -0.00464137f, 0.13683555f, 
    -0.11562559f, -0.00617216f, 0.14312366f, 0.07087355f, 0.21513844f, -0.09635757f, -0.46181121f, -0.03579437f, 
    -0.25604323f, -0.10678846f, -0.01120741f, -0.00426687f, 0.01490156f, 0.13342242f, 0.03363510f, -0.50758439f, 
    -0.39558628f, 0.04008367f, 0.06816417f, -0.09327190f, 0.06482598f, 0.12416064f, 0.16814424f, -0.04963194f, 
    0.00071359f, -0.06052883f, 0.12651734f, 0.00807828f, 0.04233020f, -0.09354004f, 0.24428223f, -0.04830442f, 
    -0.08615894f, 0.03979915f, -0.17945133f, -0.01834253f, 0.08680280f, -0.20944823f, -0.13962331f, 0.08376943f, 
    0.09482004f, -0.04372749f, 0.08375005f, 0.23442636f, 0.34076026f, 0.05483640f, 0.19409339f, 0.00695576f, 
    0.08671205f, 0.02510652f, -0.01292141f, -0.06673300f, -0.05247675f, -0.06795938f, 0.15388957f, 0.21187073f, 
    0.08418104f, -0.16156456f, -0.11350855f, -0.03690136f, 0.02354235f, 0.24669632f, -0.05289676f, -0.02037135f, 
    0.05624760f, 0.11931054f, -0.07689778f, -0.14134538f, -0.19382752f, -0.19542551f, -0.06037652f, -0.03747229f, 
    0.00387569f, -0.12008505f, 0.03845790f, 0.17668122f, 0.10855860f, 0.11072874f, -0.07333020f, 0.19766824f, 
    0.00780599f, 0.01852190f, 0.05981671f, 0.16277826f, -0.01267465f, -0.07858404f, 0.03645233f, 0.03877519f, 
    -0.02016565f, -0.10404706f, 0.11879784f, 0.02839508f, 0.17266361f, 0.16579898f, 0.11566930f, -0.03434429f, 
    0.00681027f, 0.10214627f, 0.10417864f, 0.11029128f, 0.02334741f, -0.03672504f, -0.01249261f, 0.01689827f, 
    0.05709983f, -0.04969924f, 0.25038660f, 0.17827603f, 0.06994881f, 0.11638166f, 0.06454063f, 0.26474151f, 
    0.11596969f, -0.08138430f, 0.17427774f, 0.37217343f, 0.05268082f, 0.12800464f, 0.01057346f, -0.09324204f, 
    0.03940207f, -0.07394514f, 0.14552368f, 0.07671233f, -0.13858370f, 0.07261465f, -0.08995645f, -0.05448793f, 
    -0.08482585f, -0.05239862f, 0.25694451f, 0.34275636f, -0.46833491f, -0.17799260f, 0.01633262f, -0.11245672f, 
    0.16178815f, 0.13754325f, -0.06156779f, -0.25268245f, 0.01741653f, -0.17219299f, -0.08580828f, 0.22679047f, 
    -0.13009912f, -0.10537938f, -0.06032411f, 0.08200622f, -0.06774697f, -0.02024773f, -0.05843758f, -0.24345195f, 
    0.11293926f, 0.14584251f, -0.01879714f, 0.07433023f, 0.06671230f, 0.03482712f, -0.10647044f, -0.01619785f, 
    0.05461423f, 0.08243479f, -0.04630900f, 0.14287725f, 0.17010218f, 0.17558943f, 0.05982758f, 0.01168766f, 
    -0.12701483f, -0.18309721f, -0.47325262f, 0.02941446f, -0.01985116f, 0.36631796f, -0.12545937f, 0.07326901f, 
    -0.12967090f, 0.24290898f, -0.01384874f, 0.05292124f, -0.03644019f, -0.00258737f, 0.01407473f, -0.13033041f, 
    -0.03353497f, -0.08528668f, 0.19842914f, -0.03473703f, 0.12524225f, -0.04177700f, 0.07841984f, -0.13973932f, 
    -0.05365450f, -0.04808342f, 0.06817120f, 0.46227929f, 0.21621147f, 0.23459950f, -0.18752088f, -0.05309717f, 
    -0.09394272f, 0.02241143f, -0.12677315f, 0.04921879f, 0.09180629f, -0.09709901f, -0.02123751f, 0.10647737f, 
    0.04237724f, -0.18987463f, -0.07490414f, 0.01378921f, 0.14055857f, -0.21252905f, 0.00743276f, -0.04216269f, 
    0.20761009f, -0.06260560f, 0.05686460f, -0.08326714f, -0.06011969f, 0.13156009f, 0.20029597f, 0.05720568f, 
    0.02684225f, 0.18491594f, -0.06082027f, -0.04805626f, 0.02361283f, -0.01940693f, -0.05431904f, -0.07184830f, 
    -0.04636427f, 0.17438796f, 0.14829977f, 0.07104614f, -0.08522017f, -0.01849499f, -0.00671213f, 0.09708070f, 
    -0.31813928f, 0.10136370f, -0.05653661f, 0.15324143f, 0.07246538f, -0.06135062f, 0.19684136f, 0.01258233f, 
    0.22126719f, 0.12132072f, -0.11562085f, 0.09836563f, 0.05315817f, 0.09371280f, 0.06460662f, -0.02666768f, 
    -0.05184198f, 0.08254699f, -0.10202537f, 0.03333042f, -0.19727263f, -0.01585457f, 0.02546836f, -0.03234790f, 
    0.06958131f, 0.00429362f, 0.15352470f, 0.03718184f, 0.11012208f, 0.11014770f, 0.04378744f, 0.02248474f, 
    0.09897421f, -0.06886083f, -0.06060478f, -0.17021064f, -0.14791396f, 0.01476942f, -0.07405383f, 0.01624831f, 
    0.10144752f, 0.08740069f, 0.10496783f, -0.00045295f, -0.07593545f, 0.11788230f, -0.16664025f, 0.28280148f, 
    0.00741772f, 0.00960237f, -0.03414929f, 0.18871452f, -0.00487028f, 0.12931445f, 0.25136364f, 0.18005985f, 
    0.11971378f, -0.04742656f, 0.06471394f, 0.10882526f, -0.06494397f, -0.01649374f, 0.10669211f, 0.33180952f, 
    -0.07263869f, -0.11336590f, 0.13104899f, -0.11379023f, 0.06897123f, 0.07466419f, -0.07866021f, 0.09879404f, 
    -0.60417604f, -0.12893544f, -0.48852977f, -0.07996029f, -0.05747573f, -0.07997606f, -0.04647703f, 0.15362523f, 
    0.10164238f, -0.30563077f, 0.12674029f, 0.06095486f, 0.02001266f, 0.05717632f, 0.11723584f, 0.03834093f, 
    -0.11917221f, -0.03477196f, 0.30525732f, 0.28905573f, -0.24776077f, -0.07317856f, 0.07600764f, -0.20367670f, 
    0.12919728f, 0.08519708f, 0.22294559f, -0.00671644f, -0.02546334f, 0.17709966f, 0.00031700f, 0.05382293f, 
    0.07575307f, -0.04469658f, 0.10879916f, -0.03880370f, 0.13513643f, 0.09402788f, 0.23707910f, -0.06731337f, 
    -0.14284919f, -0.00984439f, -0.15880768f, 0.04234046f, -0.02377651f, -0.15125851f, -0.09424115f, 0.09183747f, 
    0.04667834f, -0.10301939f, -0.10038155f, -0.15646869f, 0.03530919f, -0.01771252f, 0.17087156f, 0.08258890f, 
    -0.11610574f, 0.00423843f, 0.03064667f, 0.04215332f, 0.11159642f, 0.06904160f, 0.08481227f, -0.10384642f, 
    -0.06813232f, -0.10835011f, 0.12561075f, 0.09948403f, 0.19326313f, 0.22160237f, -0.19887830f, -0.06804847f, 
    0.18235092f, 0.14611571f, 0.07055651f, -0.00155617f, 0.04225991f, -0.10205655f, 0.11577501f, 0.15133965f, 
    0.02742264f, -0.04580849f, -0.12750456f, -0.04948640f, -0.07611918f, -0.06412262f, 0.01585440f, 0.06954905f, 
    0.07885187f, 0.05382500f, 0.00403693f, 0.24047747f, -0.19867453f, -0.18259396f, -0.12120700f, 0.01751074f, 
    -0.01681756f, 0.16496558f, 0.25110722f, -0.23467916f, -0.08290944f, 0.26885116f, -0.03877458f, 0.03307815f, 
    -0.00038555f, -0.12571859f, 0.05966547f, -0.12692323f, -0.01814556f, -0.23185243f, -0.20001544f, -0.07518168f, 
    -0.06677766f, -0.02315179f, 0.02924502f, 0.02457450f, -0.00050764f, -0.18526906f, 0.10938313f, -0.02222312f, 
    0.07673196f, -0.00143886f, 0.14255117f, -0.04437742f, 0.16477256f, -0.06894663f, 0.01709201f, -0.21557492f, 
    -0.07137771f, 0.01198907f, 0.18732418f, 0.06679286f, -0.07198054f, 0.13770661f, 0.10804477f, -0.03365388f, 
    -0.04851047f, -0.05293462f, -0.11872005f, 0.11976696f, -0.24467316f, -0.12174477f, 0.05247223f, 0.11697332f, 
    -0.03621073f, -0.00759773f, 0.07562035f, 0.02481188f, 0.00939753f, 0.00990739f, -0.32913557f, 0.01772800f, 
    0.05061873f, 0.10747540f, 0.19813006f, -0.02599321f, 0.09635063f, 0.10446025f, 0.26323202f, 0.08382367f, 
    -0.09163867f, -0.18147868f, 0.12076116f, 0.15973575f, 0.06521266f, 0.30593038f, -0.04171203f, -0.04341026f, 
    0.13034186f, 0.03520522f, -0.13974103f, 0.30843624f, 0.29635096f, 0.02442049f, 0.11294258f, 0.13380834f, 
    0.03954429f, -0.03932384f, -0.06883244f, -0.17174222f, 0.11263601f, 0.10915811f, 0.17451404f, -0.04793242f, 
    0.00656507f, -0.18040463f, 0.04338752f, 0.11899088f, 0.08534403f, -0.28568956f, -0.20016572f, -0.08632448f, 
    -0.01436933f, -0.04101544f, -0.06420583f, 0.00975599f, 0.02467427f, -0.06425155f, -0.01981250f, 0.29085898f, 
    0.03043145f, -0.02419920f, 0.11218530f, -0.16937637f, -0.16101776f, -0.07527380f, -0.09813706f, -0.00654380f, 
    -0.10813119f, -0.05894338f, 0.24131051f, -0.18929057f, -0.23033027f, 0.06781099f, -0.16507888f, -0.00219234f, 
    0.25979313f, 0.06102014f, 0.16714068f, 0.00337154f, -0.01723683f, -0.18451481f, 0.18011992f, 0.17331249f, 
    -0.17187722f, -0.02576946f, 0.03767486f, 0.13914886f, 0.02705048f, -0.01669252f, -0.01493612f, 0.03527756f, 
    0.06771071f, 0.01721735f, 0.09586672f, 0.06565645f, -0.17878781f, 0.04003579f, -0.13760324f, -0.09595721f, 
    0.07614680f, 0.08240322f, -0.00372910f, 0.09709271f, -0.00145012f, -0.21706451f, -0.03675305f, -0.00957003f, 
    -0.07473290f, -0.08711925f, -0.05991844f, 0.03419334f, 0.07223680f, 0.01280678f, -0.11250463f, -0.02181689f, 
    -0.11334361f, 0.08385839f, -0.17534052f, -0.05186262f, -0.12281211f, 0.01344068f, -0.17852853f, -0.09824928f, 
    -0.01802013f, -0.06626385f, -0.02023262f, 0.06767774f, -0.02816254f, -0.00796400f, -0.10108296f, 0.27203357f, 
    0.19894798f, 0.00871740f, -0.09605274f, 0.08187693f, -0.06337547f, 0.13839760f, 0.00785671f, -0.01030827f, 
    0.03158655f, 0.14290063f, -0.10190970f, 0.00015998f, -0.12464807f, -0.08233108f, 0.18565652f, 0.07379143f, 
    -0.07025729f, -0.06123844f, -0.15162903f, -0.04775625f, -0.04803309f, 0.01572546f, -0.11821844f, 0.24333741f, 
    -0.03276309f, 0.40444863f, 0.06111360f, 0.08203606f, -0.04927753f, 0.09351149f, -0.01640164f, -0.04357820f, 
    0.05653858f, 0.05726859f, -0.28680977f, -0.02535122f, 0.04837285f, 0.04978370f, -0.04490347f, 0.00619995f, 
    0.07232830f, 0.33836165f, -0.06892919f, -0.00486579f, 0.13566205f, -0.18806602f, 0.08801781f, 0.08974962f, 
    -0.08753458f, 0.04572453f, 0.06972739f, -0.02114571f, 0.33450532f, 0.26321754f, 0.17302422f, 0.11851914f, 
    0.08619217f, 0.09568496f, -0.15827775f, -0.09672311f, 0.02162254f, 0.15829690f, 0.27410218f, 0.04785791f, 
    -0.19498272f, -0.13189289f, -0.19252875f, 0.06090126f, 0.06084108f, -0.11541210f, -0.26019180f, -0.30106461f, 
    0.05336112f, -0.04598440f, 0.05033469f, -0.04283621f, -0.09273436f, -0.09749665f, -0.02617688f, 0.24906839f, 
    0.03030666f, -0.06487049f, -0.14511873f, -0.05373217f, 0.08840720f, -0.11447945f, -0.09058723f, 0.08437029f, 
    -0.11607639f, -0.11509805f, -0.07861716f, -0.04006144f, -0.00362947f, -0.10362534f, 0.10802602f, 0.19096613f, 
    -0.03254478f, -0.18474217f, -0.13235533f, -0.02838696f, -0.09610303f, -0.14249222f, -0.13045698f, 0.00491493f, 
    -0.25057101f, 0.14363715f, -0.24380365f, -0.45379844f, -0.13377646f, -0.05058414f, 0.02051476f, 0.08168008f, 
    -0.13461636f, 0.17858389f, 0.00913779f, 0.06051040f, 0.03201948f, 0.22110161f, -0.12484229f, -0.02561527f, 
    0.12140507f, -0.22015224f, -0.16124694f, -0.03114787f, 0.29599455f, 0.22286600f, -0.09262186f, 0.18484382f, 
    -0.12128761f, 0.01135716f, 0.08463364f, 0.09091009f, -0.01912775f, 0.13355008f, 0.10339305f, -0.18108468f, 
    -0.05462521f, -0.12552893f, 0.05005206f, -0.16626284f, 0.02749654f, -0.09485567f, 0.00474835f, 0.01118692f, 
    0.13733336f, 0.03225056f, -0.12727101f, -0.21605782f, 0.02367103f, -0.06623316f, -0.00117941f, -0.08324820f, 
    -0.21312979f, -0.18306226f, -0.05365864f, 0.02169321f, -0.33643514f, 0.06078716f, 0.03315927f, -0.08490218f, 
    -0.01894311f, 0.01926121f, 0.01567845f, -0.02848235f, 0.00206703f, 0.01360144f, -0.05744573f, -0.01896880f, 
    0.02608544f, -0.05007029f, 0.03523719f, 0.04206424f, -0.04780573f, 0.04025705f, -0.00704982f, -0.04406883f, 
    -0.00954608f, -0.00493386f, -0.03449291f, -0.04729668f, 0.01222444f, 0.02411985f, -0.06182003f, -0.00190911f, 
    0.02490574f, -0.01101107f, 0.00375753f, -0.02081081f, 0.03591543f, 0.01627157f, 0.03906255f, 0.00320150f, 
    0.02040382f, 0.00944071f, 0.01014032f, -0.01786719f, 0.02375392f, 0.01496556f, 0.04288225f, -0.01192256f, 
    0.01808608f, -0.02169758f, 0.02008757f, -0.04400864f, 0.02535442f, 0.03917750f, -0.04524708f, -0.03941975f, 
    -0.05882006f, 0.01212480f, 0.00514753f, -0.03639906f, 0.01305864f, -0.04678454f, -0.04082286f, 0.05324064f, 
    0.02590060f, 0.03818932f, 0.04348261f, 0.00606013f, -0.05157246f, -0.04018937f, 0.05378642f, -0.01199202f, 
    -0.01989791f, 0.04923241f, 0.01015989f, -0.04083387f, -0.00940383f, -0.02587964f, -0.02975077f, -0.02428219f, 
    -0.03535285f, -0.02297165f, -0.02255021f, 0.01015863f, -0.03643581f, -0.04496976f, -0.05595667f, 0.02512618f, 
    -0.00867791f, -0.00773468f, -0.00495512f, -0.00464760f, -0.05452685f, 0.03405525f, 0.04822509f, -0.04876561f, 
    -0.06414805f, -0.04532406f, 0.00970482f, -0.04968417f, -0.04197601f, 0.02305768f, -0.01020929f, 0.01317635f, 
    -0.02113542f, -0.05387494f, 0.03550707f, -0.00305352f, -0.05514741f, -0.03931197f, 0.04535463f, 0.04776315f, 
    0.01728956f, 0.02154624f, 0.03000601f, -0.02716278f, -0.04693750f, -0.03588001f, -0.05936242f, -0.00700000f, 
    0.04710360f, 0.00249797f, 0.04236740f, -0.06539643f, -0.00725717f, -0.01888228f, 0.05088999f, -0.02558543f, 
    -0.03820490f, -0.05389751f, -0.04751278f, -0.03856538f, 0.00639643f, 0.01036397f, 0.01948189f, -0.01758407f, 
    -0.03799276f, -0.03171596f, 0.04920398f, 0.00128356f, 0.01196012f, 0.00488145f, 0.00421425f, -0.00681488f, 
    -0.06185154f, 0.01343917f, -0.00590735f, -0.05635662f, 0.00667383f, -0.05792230f, -0.05729729f, 0.01239504f, 
    0.02911536f, -0.00692496f, -0.05991051f, 0.01368072f, -0.01146509f, -0.03194265f, 0.00677405f, -0.03605307f, 
    0.01991559f, 0.04031312f, 0.01167839f, -0.02940923f, -0.01554645f, 0.04890095f, -0.05309957f, -0.01041389f, 
    0.01323940f, 0.02719329f, -0.04202311f, 0.04930108f, -0.03568958f, 0.00241958f, -0.02161547f, -0.02437294f, 
    -0.04092503f, -0.06544654f, 0.00096378f, -0.05958967f, -0.00816564f, 0.02808037f, -0.04976330f, -0.00671588f, 
    -0.03398447f, 0.03607407f, -0.04461688f, 0.03934269f, -0.03119434f, -0.04552558f, -0.01703818f, 0.00383977f, 
    0.02287648f, -0.04309993f, -0.05445141f, -0.05746964f, -0.05923732f, -0.04888191f, 0.01168075f, 0.04511295f, 
    -0.01434398f, -0.03567420f, 0.03655048f, -0.00582664f, -0.06210334f, -0.03298191f, -0.05020328f, -0.01820548f, 
    0.04461465f, 0.01589854f, -0.00386999f, 0.00223616f, 0.05018701f, -0.00816785f, 0.04425523f, 0.00782891f, 
    0.01692431f, 0.04074305f, 0.03317468f, 0.02517013f, 0.00256710f, -0.04907905f, -0.06324872f, 0.03403208f, 
    0.03261676f, -0.01181196f, 0.03492440f, 0.03424063f, -0.00427252f, -0.02539343f, -0.00897533f, -0.00189066f, 
    0.04224026f, -0.04053912f, -0.02342953f, -0.02592025f, 0.02437935f, -0.00273757f, -0.04198034f, 0.04611097f, 
    -0.00297837f, 0.00760969f, 0.01715280f, -0.03906288f, -0.00723743f, -0.05064002f, 0.01779328f, 0.02362733f, 
    -0.00016864f, -0.04200997f, -0.04977957f, -0.05586376f, 0.01432315f, 0.02607200f, 0.02389233f, 0.00660459f, 
    -0.01040845f, 0.00085362f, -0.01435277f, 0.01058332f, 0.01749974f, -0.04888926f, -0.01430679f, -0.01799011f, 
    -0.00413739f, -0.01461306f, 0.02030431f, -0.02505587f, -0.00828625f, 0.00409660f, 0.00862059f, -0.05616003f, 
    0.01137632f, 0.01416620f, -0.06232706f, -0.04541385f, -0.05406075f, 0.04754541f, 0.02034475f, 0.04501166f, 
    0.03966367f, 0.00469672f, -0.04658065f, -0.02146639f, -0.04276151f, -0.01124464f, -0.04193398f, -0.03014612f, 
    0.03910521f, -0.05683283f, -0.02082833f, 0.03320900f, -0.03432381f, 0.04413502f, 0.04100085f, -0.05081767f, 
    -0.01896795f, 0.04023230f, -0.13159415f, -0.00903639f, -0.01653604f, -0.03887896f, -0.00332392f, -0.11072744f, 
    0.26199439f, 0.19720820f, -0.33112103f, 0.03639909f, 0.05569541f, 0.01619320f, 0.29384345f, 0.10335167f, 
    -0.00109642f, -0.21540135f, 0.20966430f, -0.20842332f, -0.09545308f, 0.03694071f, 0.08018214f, 0.10783349f, 
    0.12017374f, -0.04027056f, -0.08786152f, 0.13790455f, 0.05351824f, -0.16350457f, 0.16208075f, 0.05391432f, 
    -0.04090828f, 0.21711935f, 0.09820115f, 0.05702219f, 0.17205392f, -0.09611110f, 0.04193637f, 0.04250342f, 
    0.08092844f, -0.19545685f, 0.04601211f, 0.03565276f, 0.02675820f, 0.15014662f, 0.20278661f, -0.02593929f, 
    0.03830870f, -0.14194869f, -0.02225896f, 0.09674413f, -0.13155766f, -0.00177563f, -0.04090437f, -0.02910328f, 
    -0.09895326f, 0.07741644f, -0.02454964f, 0.09079671f, 0.04663927f, -0.02429147f, 0.11861737f, -0.12367541f, 
    0.22143282f, -0.20048265f, 0.08738430f, -0.09883119f, -0.15882455f, 0.14071624f, -0.08815523f, 0.04955959f, 
    -0.26766470f, -0.15622349f, 0.01326829f, -0.15881909f, 0.04400095f, 0.13986608f, -0.08342493f, -0.09622255f, 
    0.14214505f, 0.08550891f, 0.16344032f, -0.24871297f, 0.12832239f, -0.02821966f, -0.11674433f, 0.04474012f, 
    -0.07046320f, -0.10221275f, 0.23396429f, -0.34254524f, -0.00412460f, 0.01396954f, -0.32862842f, -0.18098940f, 
    -0.13833384f, -0.03325144f, -0.10260569f, -0.15608865f, -0.61983663f, 0.03420224f, -0.06536695f, -0.07693805f, 
    -0.07024644f, 0.06017914f, -0.07808089f, 0.04707703f, -0.11120639f, -0.17438968f, -0.31667483f, 0.04304052f, 
    -0.03631489f, 0.00948149f, -0.18582366f, 0.08208462f, -0.01228710f, 0.02652587f, -0.07746978f, 0.08594397f, 
    0.05504413f, 0.02019322f, -0.01192631f, 0.05017629f, -0.03624069f, -0.17412172f, 0.30843273f, 0.27130640f, 
    0.08951610f, 0.03139148f, 0.03268925f, -0.02828804f, 0.01650731f, -0.05409608f, 0.11315376f, -0.11941077f, 
    0.14095946f, 0.12275735f, -0.01713546f, -0.09288365f, -0.11733922f, -0.13873084f, -0.05723593f, -0.07092679f, 
    0.08787630f, 0.02663422f, -0.20458926f, 0.02160273f, -0.02409760f, -0.00744095f, -0.16923706f, 0.14870875f, 
    -0.14174558f, -0.30395475f, -0.49692258f, -0.35992554f, -0.11478563f, 0.01444230f, 0.01104155f, 0.11012438f, 
    -0.01319474f, -0.00873491f, -0.12734774f, 0.11297436f, 0.27155393f, -0.20239505f, 0.06931357f, -0.15822606f, 
    -0.02152677f, -0.12402683f, 0.06386016f, -0.02908203f, -0.34328941f, -0.18886635f, 0.20185284f, 0.04621340f, 
    0.09757778f, -0.08850764f, 0.12702824f, -0.03201295f, 0.05671199f, -0.36986586f, -0.36910200f, 0.14982633f, 
    0.18091306f, 0.23685373f, -0.12677743f, -0.10344022f, 0.01290014f, -0.41937387f, 0.07918252f, 0.10987536f, 
    0.10435623f, 0.13440642f, 0.15876940f, -0.03940669f, 0.01180592f, 0.01386428f, 0.18647394f, 0.15626998f, 
    0.17546813f, 0.04856717f, -0.08215746f, 0.11862984f, 0.04897189f, 0.05816666f, -0.06864469f, 0.22070770f, 
    0.38500887f, -0.24897936f, 0.18949153f, -0.09718104f, 0.00270871f, -0.11698906f, 0.10996094f, 0.03112018f, 
    -0.03788263f, -0.19370282f, 0.19394664f, -0.11611914f, -0.07520540f, -0.05079599f, 0.14216802f, 0.07852759f, 
    -0.01611196f, 0.02936216f, 0.06082576f, 0.03572903f, 0.02873682f, -0.11046706f, 0.06349047f, -0.01362316f, 
    0.07673659f, 0.10068557f, 0.02067708f, 0.04734660f, 0.18187724f, -0.19169426f, -0.04219484f, 0.00023316f, 
    0.06891605f, -0.06398705f, -0.02089318f, -0.00967239f, 0.22689626f, -0.24423878f, 0.16895300f, 0.03985937f, 
    0.35480523f, -0.17510134f, 0.17973566f, 0.23357649f, -0.53301269f, 0.23739021f, 0.11134392f, 0.11277839f, 
    -0.02562979f, 0.04542788f, -0.03935315f, -0.10235954f, -0.16845812f, -0.26776177f, -0.18177874f, 0.10182467f, 
    0.03025375f, 0.06350584f, -0.02433897f, -0.02512542f, -0.11542549f, 0.03094934f, -0.00453792f, 0.14980842f, 
    -0.01604113f, -0.04709342f, 0.13783924f, 0.00243856f, 0.11681375f, -0.07291637f, -0.00635877f, -0.01563051f, 
    0.06353517f, 0.12345019f, 0.10329936f, -0.00883294f, -0.10760020f, 0.14249359f, 0.13599230f, -0.04669837f, 
    -0.18291670f, 0.00560220f, 0.10680784f, 0.00761803f, -0.29392987f, -0.05241271f, 0.09284096f, 0.03754045f, 
    0.13538879f, -0.17348731f, -0.11591799f, -0.24711357f, 0.12691993f, 0.14086400f, 0.09199309f, -0.06518892f, 
    -0.02193574f, -0.06094952f, 0.20808727f, -0.21944323f, -0.17831819f, 0.09100687f, 0.12271338f, 0.18435900f, 
    -0.24379009f, -0.20293088f, -0.16520101f, -0.08530445f, -0.23164152f, -0.24074131f, 0.16681504f, -0.04822955f, 
    0.00077410f, -0.01995515f, -0.22497451f, 0.08111633f, 0.41139418f, 0.02359871f, -0.16640629f, 0.09060762f, 
    0.10047328f, 0.13698609f, 0.02051411f, -0.04450557f, -0.08808490f, -0.15436789f, -0.15846777f, 0.26631811f, 
    -0.17213944f, -0.17967594f, -0.07949194f, -0.01600145f, 0.06598790f, -0.03187503f, 0.03716359f, 0.18516009f, 
    -0.16478123f, -0.00049036f, 0.09542768f, 0.05244992f, -0.05652250f, -0.04557913f, 0.15645491f, 0.02433726f, 
    -0.23581193f, -0.08139988f, -0.06385096f, 0.01896324f, -0.01466810f, -0.06437407f, 0.11708046f, 0.07641321f, 
    -0.11919619f, -0.08735546f, 0.00224191f, -0.07129241f, -0.15541385f, -0.25498638f, 0.11182259f, 0.14722066f, 
    -0.08088230f, 0.49099901f, 0.04451241f, -0.42854920f, 0.21836491f, 0.07960767f, 0.13369817f, 0.00182070f, 
    -0.20307234f, -0.14930306f, -0.20288554f, -0.43020371f, 0.01955415f, -0.08037317f, -0.06351316f, -0.02358022f, 
    0.07171880f, -0.01160928f, -0.06144791f, -0.18629192f, -0.00778351f, -0.18266135f, 0.08921724f, -0.00431643f, 
    0.01405875f, -0.04656052f, 0.12698765f, 0.03932998f, 0.00989316f, 0.22918656f, 0.19140014f, -0.03838588f, 
    0.08168114f, -0.04547673f, -0.14274196f, 0.11759613f, 0.04866444f, 0.31112549f, 0.01971410f, -0.10656267f, 
    0.09805297f, -0.05965611f, 0.17969115f, 0.14875510f, 0.13689680f, 0.22154652f, -0.04270671f, 0.13089021f, 
    -0.04600216f, 0.19304177f, -0.03455105f, -0.04307937f, -0.03651256f, -0.11355933f, -0.15861851f, 0.08714993f, 
    -0.01861928f, -0.20139423f, -0.04916134f, 0.10480418f, 0.01331732f, -0.05156707f, 0.04512253f, -0.20714043f, 
    0.00922217f, -0.06693601f, 0.19612098f, -0.13555649f, 0.01934989f, -0.09886362f, 0.24941061f, 0.01977423f, 
    -0.18267208f, -0.06752067f, -0.17135923f, 0.09378023f, -0.15099861f, 0.07556776f, 0.01441200f, -0.01750528f, 
    0.00850539f, 0.05233473f, -0.33035254f, -0.06151489f, -0.01129499f, -0.18864802f, -0.04360640f, -0.03688185f, 
    -0.01727196f, 0.10497357f, -0.25505191f, -0.08171576f, -0.17761590f, 0.20194063f, 0.20570283f, -0.08081629f, 
    0.04530162f, 0.06242533f, 0.14293568f, -0.08828865f, -0.07085302f, -0.26948628f, -0.35371998f, 0.14066622f, 
    0.03642030f, 0.00285443f, -0.00676925f, -0.04655367f, -0.09980542f, -0.15157579f, 0.08187808f, -0.18909191f, 
    0.00420568f, 0.33644375f, 0.03476219f, 0.06840252f, -0.15129352f, -0.15247601f, 0.15285337f, 0.22701481f, 
    0.34810781f, -0.03550782f, -0.40995929f, -0.23540297f, -0.06434723f, 0.25236759f, 0.01508990f, 0.10053671f, 
    0.07995481f, -0.10292129f, 0.01633282f, 0.07300822f, 0.16331203f, 0.10378427f, 0.00273753f, 0.17952763f, 
    -0.01170277f, -0.12744313f, -0.08395687f, -0.01440989f, 0.01556879f, -0.07195728f, 0.09772988f, 0.15019749f, 
    0.02836248f, 0.19074243f, 0.23508026f, 0.29011607f, -0.14689218f, -0.17751294f, -0.10496050f, 0.20845461f, 
    0.13726568f, 0.06484994f, -0.06620846f, 0.11766184f, 0.20258480f, -0.19173953f, -0.25811654f, -0.27075002f, 
    -0.12749425f, 0.07263419f, -0.03562834f, -0.13185172f, -0.00078962f, 0.12827855f, 0.21420938f, 0.03309171f, 
    -0.04480486f, 0.07016964f, -0.00740153f, 0.07471351f, 0.34927794f, 0.00982820f, -0.42037773f, 0.01256274f, 
    -0.07534998f, 0.04397829f, -0.08063463f, 0.00834325f, 0.16276650f, -0.21506660f, -0.15335953f, 0.06304131f, 
    -0.05881138f, 0.09878023f, -0.04056539f, 0.03858404f, 0.04086806f, 0.05993108f, 0.12039472f, -0.09650627f, 
    -0.10935701f, -0.09316187f, 0.35940430f, 0.19527510f, 0.02069533f, 0.00902680f, -0.18518947f, 0.28552929f, 
    0.00438166f, 0.02247402f, 0.14760606f, 0.00001294f, 0.17133483f, 0.27484813f, 0.05834985f, 0.03541828f, 
    0.43965155f, 0.27722946f, 0.08538141f, 0.09833150f, -0.02822768f, -0.02101389f, -0.16894212f, -0.08995657f, 
    -0.11825433f, 0.29396051f, -0.00236541f, -0.03778383f, -0.05413096f, -0.03298597f, -0.01578219f, -0.08054201f, 
    0.02602701f, 0.01451608f, 0.15074307f, -0.10984462f, 0.04011805f, -0.14083388f, -0.15317822f, 0.03901544f, 
    -0.03474118f, -0.11455426f, 0.04578361f, -0.04267684f, -0.07417705f, 0.09059633f, -0.04750854f, 0.03364028f, 
    0.00048542f, -0.01083870f, 0.09870935f, 0.12311903f, 0.38667694f, -0.13594343f, -0.10794631f, -0.18003467f, 
    -0.12068546f, -0.10111517f, 0.02732341f, 0.03359605f, -0.01534124f, 0.05024193f, 0.48265314f, -0.11614741f, 
    0.17800097f, 0.08376632f, 0.11930171f, 0.01944385f, -0.03039921f, 0.00738536f, -0.08576141f, -0.21930690f, 
    0.02569312f, 0.02283770f, 0.18031919f, 0.10329551f, -0.13824832f, -0.08636535f, -0.04104089f, -0.00645783f, 
    0.10519642f, -0.29303309f, -0.20289056f, 0.04138097f, -0.05964772f, -0.16293228f, -0.01654275f, 0.23615022f, 
    0.55199510f, 0.04561847f, -0.16885002f, -0.04795758f, -0.03898871f, -0.14116301f, -0.02010840f, 0.05469560f, 
    0.00094077f, 0.23510359f, 0.17543402f, 0.15160492f, -0.22325240f, -0.19143797f, 0.01138505f, 0.05127488f, 
    -0.18300270f, -0.00336401f, 0.09597328f, -0.07480080f, -0.04183123f, 0.03431365f, -0.18709594f, -0.06685347f, 
    0.06417145f, -0.07290737f, 0.04301452f, 0.05601162f, -0.32160473f, 0.02185119f, -0.03725713f, -0.13283482f, 
    0.07118692f, 0.05172199f, -0.03248373f, 0.07452050f, -0.02388266f, 0.07866101f, 0.06051071f, 0.10764620f, 
    0.02913553f, 0.08594994f, -0.11681605f, 0.11362564f, 0.15237452f, -0.14363307f, 0.27915546f, -0.08428106f, 
    0.10961585f, 0.10438865f, 0.05271785f, 0.08731501f, -0.14377794f, 0.19067501f, 0.08170513f, -0.00123388f, 
    0.19968888f, -0.08772174f, 0.04103478f, -0.10113638f, -0.03208175f, 0.01170914f, -0.05181024f, 0.36872515f, 
    -0.20395666f, -0.23242499f, -0.09573641f, 0.00506913f, 0.08701412f, -0.09935918f, 0.00203214f, -0.09794582f, 
    0.30070478f, 0.00819780f, -0.26560444f, 0.00461749f, 0.09506972f, -0.00054847f, -0.07318767f, 0.04739198f, 
    0.10256215f, 0.34718615f, -0.20071784f, -0.08426929f, -0.15752016f, 0.09855391f, -0.14444150f, -0.21754438f, 
    -0.02142779f, 0.07293760f, -0.32928574f, 0.07670490f, 0.07968377f, 0.08085508f, 0.06128622f, 0.15850338f, 
    -0.12270614f, 0.05373547f, -0.09341654f, 0.21826716f, -0.00049921f, 0.24550304f, -0.07578419f, 0.01647645f, 
    0.07292455f, 0.04045992f, -0.18453285f, 0.10737459f, 0.29354155f, -0.34246269f, -0.32867366f, -0.15031785f, 
    -0.05584097f, -0.13979886f, -0.04376644f, -0.05766478f, -0.08204399f, 0.64908367f, -0.09920391f, -0.20793366f, 
    0.00536579f, 0.16281737f, 0.07475868f, 0.00766829f, -0.01941058f, 0.01419118f, -0.16388121f, 0.35817325f, 
    0.05969539f, 0.17988771f, 0.08306029f, 0.14307131f, -0.01814779f, 0.09160209f, -0.13428181f, 0.22484574f, 
    -0.03819625f, -0.07363760f, -0.13693467f, 0.01346965f, -0.05294996f, 0.08403336f, -0.04893732f, -0.05440021f, 
    0.03788674f, 0.10054948f, -0.03862744f, 0.12213457f, 0.03788616f, 0.07549725f, 0.03506100f, 0.13359948f, 
    -0.04611894f, -0.43024915f, 0.13279848f, -0.03289203f, 0.17282461f, 0.04416857f, -0.01586078f, 0.04860783f, 
    0.11295770f, 0.18377350f, -0.05303306f, 0.44390252f, 0.14536683f, 0.16406906f, 0.14393713f, 0.12910104f, 
    -0.11963724f, 0.02743490f, 0.02327414f, 0.02571468f, 0.14422326f, 0.06508482f, -0.11918805f, 0.18453635f, 
    0.00548156f, 0.07520422f, 0.05597657f, 0.15208705f, -0.66992670f, -0.05014451f, 0.02298355f, -0.04441617f, 
    0.08793292f, -0.14229898f, -0.01674360f, -0.23829651f, 0.10817194f, 0.03321894f, -0.03110157f, -0.09236697f, 
    -0.01045951f, 0.04931803f, 0.01076543f, -0.03351476f, 0.20474523f, -0.12416014f, 0.37148947f, -0.07691240f, 
    0.03164184f, -0.07834003f, 0.04173294f, 0.18252105f, -0.04107808f, 0.02038222f, 0.03388576f, -0.35876182f, 
    0.11616665f, 0.08166251f, 0.17011140f, -0.01149498f, -0.05663970f, 0.11764741f, -0.02738398f, 0.18155417f, 
    -0.05625911f, 0.02199208f, -0.02197189f, -0.01477479f, 0.02396642f, -0.03743004f, -0.02911893f, 0.05076749f, 
    -0.04388596f, -0.02458270f, -0.04470453f, -0.04864106f, -0.05735252f, -0.02905414f, 0.01075172f, 0.03357268f, 
    0.02505654f, -0.04158146f, -0.00956524f, 0.00626580f, 0.05165343f, -0.05563876f, -0.02861588f, -0.05809511f, 
    0.00344744f, -0.00291013f, 0.02758044f, -0.02627889f, -0.03927098f, -0.02720661f, 0.01937224f, -0.06405912f, 
    -0.04803455f, 0.03756962f, 0.02289468f, 0.00950187f, 0.04154051f, 0.02514736f, 0.01719880f, -0.04634072f, 
    -0.02049583f, -0.03694452f, 0.05316414f, 0.00230187f, -0.03531482f, -0.00575349f, 0.03955850f, 0.02873409f, 
    0.04642054f, -0.05100102f, 0.02191793f, -0.05999571f, 0.05266374f, 0.00375213f, 0.04245342f, 0.01189093f, 
    -0.00408250f, -0.04903180f, 0.02231490f, 0.01646513f, -0.02857670f, 0.00065771f, 0.04356336f, 0.02857279f, 
    -0.03829519f, -0.04908682f, -0.06118774f, 0.03409046f, 0.04032958f, 0.00084909f, -0.04657292f, 0.00178586f, 
    -0.05241834f, -0.00330727f, 0.01527277f, -0.04966585f, 0.01476407f, -0.03685443f, -0.04266416f, -0.04697777f, 
    0.02217008f, -0.00258633f, -0.04507101f, -0.01667155f, -0.03315447f, 0.05074399f, -0.05786934f, 0.03750142f, 
    -0.00362054f, -0.05129160f, -0.06229741f, 0.03531652f, -0.02375980f, -0.04481067f, 0.04487702f, 0.00914106f, 
    0.02958135f, -0.02241800f, 0.05397103f, 0.03345838f, 0.03502526f, -0.06112111f, 0.01800493f, 0.01492140f, 
    -0.00342916f, -0.04575690f, 0.04405715f, -0.05658365f, 0.04859263f, -0.05982859f, 0.05061161f, 0.00552939f, 
    -0.02413222f, -0.04862041f, 0.03847801f, 0.00500122f, 0.02966116f, -0.03921770f, -0.05404058f, 0.03226779f, 
    -0.01108898f, -0.00880189f, -0.02083017f, 0.03360092f, -0.01120624f, 0.05380949f, -0.02918537f, 0.01294302f, 
    -0.03536150f, 0.01757380f, -0.04959571f, -0.03861388f, 0.01887974f, -0.03407208f, 0.01299005f, -0.02004706f, 
    0.03116427f, 0.00515575f, 0.00998379f, -0.00584104f, -0.01013366f, 0.00734255f, -0.04952564f, 0.04614792f, 
    -0.00294406f, 0.05033155f, 0.05213298f, 0.02312118f, 0.04724630f, 0.04712860f, -0.00667017f, 0.01862484f, 
    -0.06638711f, -0.05330300f, 0.02372481f, -0.05748922f, 0.00114672f, -0.06367467f, 0.02317315f, 0.03476520f, 
    -0.01897511f, -0.01230257f, 0.00238507f, -0.03859643f, 0.04633851f, 0.02806099f, -0.00675703f, -0.00224446f, 
    -0.04624864f, 0.01621725f, -0.03644660f, -0.03703682f, -0.05812623f, 0.03673793f, 0.03326329f, -0.03917897f, 
    0.00953030f, -0.02833311f, 0.00201178f, -0.03830398f, 0.01010920f, 0.01897719f, 0.00141611f, 0.04774067f, 
    -0.04911113f, 0.00215194f, 0.03596785f, -0.01162277f, -0.03913166f, -0.03937386f, 0.04676733f, -0.05346071f, 
    0.02917669f, -0.05322556f, 0.02631584f, -0.02173982f, -0.02261087f, -0.04041659f, -0.01548541f, -0.00902360f, 
    -0.05163253f, -0.05202845f, -0.00875379f, -0.00447933f, 0.03015826f, -0.03716534f, -0.02536549f, -0.02799674f, 
    -0.00772469f, -0.00205255f, -0.02258836f, -0.00023752f, -0.04820378f, -0.04062309f, -0.06217052f, -0.04690946f, 
    -0.05531771f, 0.00375204f, -0.02658622f, 0.03542276f, -0.05439192f, 0.03867649f, 0.05350984f, -0.05632526f, 
    -0.06061653f, 0.01924245f, 0.02316162f, 0.03396028f, 0.03969644f, 0.03150384f, -0.05107477f, 0.01476065f, 
    -0.05616938f, 0.00230297f, -0.00885327f, 0.02333906f, 0.02779565f, -0.02663150f, 0.05035067f, -0.00418224f, 
    0.00043536f, -0.05412369f, 0.02014806f, 0.03967896f, 0.00996406f, 0.00817943f, -0.03132889f, -0.05469385f, 
    -0.04712003f, 0.01794173f, 0.03447060f, -0.04457603f, -0.00199293f, -0.00218252f, -0.03155136f, 0.00903749f, 
    0.02838892f, 0.04853710f, 0.05366980f, 0.04945619f, -0.05222701f, -0.04794104f, 0.01787746f, -0.01539795f, 
    -0.03277254f, -0.06449833f, 0.00221776f, -0.03719294f, -0.03886731f, -0.02487690f, -0.06144486f, 0.05091090f, 
    -0.02338776f, -0.01626598f, -0.05482840f, 0.02522969f, 0.00098668f, -0.04658006f, 0.04156227f, -0.03034358f, 
    0.03253939f, -0.03985935f, 0.03719815f, -0.06008186f, 0.00291341f, 0.03815335f, 0.01067674f, -0.05744245f, 
    0.27713835f, 0.16002485f, -0.05242261f, -0.30554345f, -0.10249051f, 0.04694486f, 0.06693344f, -0.02210603f, 
    -0.01236826f, 0.06095179f, 0.08565778f, -0.04350719f, -0.02300418f, -0.00403965f, 0.28035939f, -0.17805313f, 
    0.08395471f, -0.05015929f, -0.04354135f, 0.06859969f, 0.11269054f, 0.10877863f, -0.07780467f, -0.02804694f, 
    -0.06521077f, 0.09768121f, 0.05553085f, -0.03926351f, -0.10513442f, -0.00773538f, -0.05681063f, 0.05461366f, 
    0.05804854f, -0.03828719f, -0.03701564f, 0.05891421f, -0.25526732f, -0.17705797f, -0.15127857f, 0.09248846f, 
    0.22981386f, 0.00781338f, -0.12890027f, 0.05592200f, 0.09065824f, 0.07215265f, 0.25088772f, 0.04928578f, 
    -0.03674758f, 0.10793304f, -0.04809932f, 0.14954947f, 0.08694638f, -0.02835359f, 0.20828155f, 0.15421122f, 
    -0.09126911f, 0.03859008f, -0.07380990f, -0.07423183f, -0.04152234f, -0.00476108f, 0.12662725f, -0.10224383f, 
    0.03918309f, -0.02886099f, -0.15778746f, 0.04220897f, -0.00442707f, -0.04028120f, -0.09319106f, 0.02665683f, 
    0.05994010f, -0.16193831f, -0.16571550f, 0.21823373f, 0.03102568f, -0.00580492f, 0.22301881f, -0.28585950f, 
    0.08307541f, -0.30446666f, 0.01182619f, -0.10198423f, 0.22214888f, 0.21491492f, 0.12245005f, -0.05776878f, 
    0.11946258f, -0.02909063f, -0.05179646f, -0.54307687f, 0.41556078f, 0.12678240f, 0.19145666f, 0.00173283f, 
    0.17141187f, 0.06186244f, -0.03210001f, 0.03106777f, -0.03185519f, -0.04788932f, 0.06204880f, -0.00977434f, 
    -0.09863420f, 0.12939379f, -0.09332093f, -0.18153913f, 0.22714682f, 0.00043828f, -0.20597357f, -0.08300818f, 
    0.03392924f, -0.19337206f, 0.03804653f, -0.00094343f, 0.04802370f, -0.09900260f, -0.18985364f, -0.23221579f, 
    0.11559588f, 0.06410373f, -0.05354770f, -0.12692501f, 0.12092704f, -0.10094913f, 0.33870810f, 0.13080567f, 
    -0.10606432f, 0.04918351f, 0.04554580f, -0.13518764f, 0.14422657f, 0.07071140f, -0.07598075f, -0.30937809f, 
    0.13562633f, -0.03137971f, -0.01226376f, 0.15300418f, 0.04942520f, -0.01766983f, 0.00778105f, -0.06292566f, 
    0.04565847f, -0.07688475f, 0.12874837f, 0.00552784f, 0.06849705f, -0.09597991f, 0.04076368f, -0.04722558f, 
    0.14399683f, -0.22014223f, -0.00162157f, 0.04696150f, -0.04476159f, 0.04018423f, -0.06952140f, 0.07210055f, 
    -0.11937502f, 0.16254959f, 0.25640911f, -0.32983434f, -0.01680630f, 0.11735812f, 0.13882685f, 0.11131630f, 
    0.12930080f, 0.07022254f, 0.11022450f, -0.06867155f, -0.01235630f, 0.21605144f, 0.18495111f, 0.02071870f, 
    -0.00178530f, -0.00892338f, -0.00589176f, -0.06774905f, -0.23647918f, 0.01574611f, -0.08688731f, 0.01010338f, 
    -0.03933406f, 0.03048470f, -0.23029350f, 0.02945980f, -0.03415189f, 0.08087023f, 0.31432381f, -0.16086578f, 
    -0.01483180f, -0.09138080f, -0.03334878f, 0.18162313f, 0.16484328f, -0.17807055f, 0.40768570f, 0.28290421f, 
    0.02852063f, 0.13856579f, 0.07191577f, -0.15287553f, -0.02501483f, 0.11406858f, 0.04081161f, -0.20921557f, 
    -0.29599610f, 0.06948782f, -0.06294163f, 0.16444415f, -0.05034383f, -0.07388347f, 0.09899079f, -0.20695418f, 
    0.14185841f, -0.12532330f, 0.05063298f, 0.07338197f, -0.02794167f, 0.03621284f, 0.08635108f, 0.11896827f, 
    -0.05827563f, 0.19149038f, 0.16218230f, 0.16227224f, 0.09080398f, -0.02298334f, 0.05234527f, 0.03725625f, 
    -0.06671579f, 0.14048629f, 0.78761882f, 0.18152937f, -0.17603630f, 0.11414452f, -0.14005433f, -0.03982840f, 
    0.21182175f, 0.11169823f, 0.08702753f, 0.01061536f, 0.12867917f, -0.11457279f, -0.10733132f, -0.06854942f, 
    -0.14602470f, 0.09994097f, 0.00681226f, 0.05630968f, -0.05907660f, -0.17151222f, -0.30103052f, 0.07696252f, 
    0.03223033f, 0.06060520f, -0.14841734f, -0.21092235f, -0.01058369f, 0.08230559f, 0.28317562f, -0.01600631f, 
    0.28474632f, 0.04200720f, -0.07759377f, 0.00134739f, 0.12100672f, 0.04902551f, -0.29600415f, -0.27787301f, 
    0.05876166f, 0.06928765f, 0.10083216f, 0.07547730f, 0.10107436f, 0.17305675f, -0.13471511f, -0.24626343f, 
    -0.21784632f, 0.02942245f, 0.08546346f, 0.11783211f, 0.04542157f, 0.07729340f, -0.18625066f, -0.01022576f, 
    0.06408661f, -0.02654886f, 0.22798443f, 0.04089953f, -0.02105848f, 0.14885089f, -0.13362883f, 0.06385970f, 
    0.13517390f, -0.11914418f, 0.08524239f, 0.03763069f, 0.08114712f, 0.01572679f, 0.02206428f, 0.03041717f, 
    0.10834317f, -0.09159357f, 0.12126266f, 0.21645638f, 0.07785244f, -0.06773601f, -0.03568074f, -0.14398901f, 
    0.12950929f, 0.04292830f, -0.00613877f, 0.15232570f, 0.16267084f, 0.08346805f, 0.00084969f, 0.08067106f, 
    -0.07507410f, 0.04745739f, 0.07339030f, 0.05062230f, -0.05740557f, 0.17009960f, 0.07524711f, 0.17819853f, 
    -0.12767255f, -0.02378087f, -0.10978185f, 0.14684565f, 0.02322108f, -0.50084639f, -0.16692884f, -0.01228315f, 
    0.17500389f, -0.07716748f, 0.04105784f, -0.01686124f, 0.09406694f, 0.16312715f, -0.10269536f, 0.06448017f, 
    -0.06788033f, 0.03800507f, -0.05525966f, -0.02091405f, -0.06322411f, 0.11533347f, -0.08212467f, -0.10404766f, 
    0.00678872f, -0.04284524f, -0.04284912f, -0.05014379f, -0.18075551f, 0.00399685f, -0.02253368f, 0.00118144f, 
    0.06082657f, -0.46972036f, -0.06975915f, -0.13726799f, 0.06455280f, 0.03366595f, 0.10899888f, -0.17928411f, 
    0.06294475f, 0.08935557f, 0.25108427f, 0.04702427f, 0.02177788f, 0.09887346f, -0.15194154f, -0.00775065f, 
    0.15728478f, 0.05268219f, 0.01724716f, 0.01536367f, 0.00836317f, -0.12667523f, -0.02675219f, -0.05156234f, 
    -0.20382594f, 0.05768883f, 0.04829791f, 0.02079189f, 0.20568946f, -0.04731677f, 0.15925549f, 0.01885417f, 
    0.07909294f, 0.00567371f, 0.04341225f, -0.09587524f, 0.26310641f, -0.10794035f, 0.02945657f, 0.02098016f, 
    0.03942617f, 0.23018651f, 0.20617604f, -0.12186204f, -0.17269941f, -0.15156630f, -0.33719105f, 0.00422163f, 
    -0.01004993f, 0.18007770f, 0.03135578f, 0.12729175f, 0.06855815f, -0.00409481f, 0.07181706f, 0.17645249f, 
    0.14395951f, -0.13179345f, -0.11964681f, -0.09988973f, 0.15854985f, 0.16349487f, 0.09723693f, -0.24138489f, 
    0.10971239f, -0.08382344f, -0.04751544f, -0.12844595f, -0.02438581f, -0.07185071f, 0.01229037f, 0.16978095f, 
    -0.21793352f, 0.06706008f, -0.08832713f, 0.03880190f, -0.08210976f, 0.09559145f, -0.11314090f, -0.11939505f, 
    0.23285708f, 0.05715689f, -0.25562587f, -0.17773914f, -0.04146345f, -0.02192401f, -0.05095192f, -0.05763176f, 
    0.03741160f, -0.01694211f, -0.12666240f, -0.04037435f, -0.02840607f, -0.02128691f, 0.13457191f, 0.00035338f, 
    0.09180816f, -0.10747532f, 0.10989792f, 0.19174223f, -0.05024201f, -0.11062378f, -0.05430184f, 0.00081592f, 
    0.04241900f, 0.00591195f, -0.00999635f, 0.12275213f, -0.18800867f, 0.10401485f, -0.11656785f, -0.01531350f, 
    0.12059820f, 0.07938255f, -0.04175853f, 0.11525188f, 0.12410333f, 0.08993680f, 0.13011038f, 0.02394237f, 
    -0.15197669f, -0.18648642f, 0.01700149f, 0.18477620f, -0.01064627f, -0.01981913f, -0.20810169f, -0.12378660f, 
    -0.09758809f, -0.07557976f, 0.01615728f, -0.09323613f, -0.05423099f, -0.19337527f, 0.09460410f, 0.04464535f, 
    -0.03367259f, 0.03643511f, 0.01617339f, 0.11803616f, -0.03377482f, 0.07560705f, -0.15831879f, -0.09934610f, 
    -0.12812456f, -0.03354928f, 0.01157218f, -0.01040670f, -0.02647182f, -0.07310469f, 0.16003932f, 0.03989099f, 
    0.07339084f, -0.10898691f, -0.34581199f, 0.02388238f, 0.02727454f, 0.13883360f, 0.08231268f, -0.18157087f, 
    -0.07801565f, 0.13429347f, 0.23795077f, -0.58102167f, 0.04763243f, 0.06295211f, -0.09403854f, 0.16055657f, 
    0.04352079f, -0.07975575f, 0.04474814f, -0.01065387f, -0.10505337f, 0.17839488f, 0.00146832f, 0.09643739f, 
    0.07947068f, -0.04167153f, -0.12841895f, 0.00486779f, -0.02820736f, -0.11257041f, 0.04123615f, 0.04553332f, 
    0.17312782f, 0.14072073f, -0.08611630f, 0.12959956f, 0.04301953f, 0.30601951f, -0.05990969f, 0.00941366f, 
    0.02623207f, 0.01930748f, 0.12136523f, 0.24916774f, 0.02228617f, -0.27682072f, -0.18384407f, -0.04128195f, 
    0.02239256f, 0.10268291f, 0.04605924f, 0.04693615f, -0.04086572f, -0.17781478f, -0.06657513f, -0.20009120f, 
    -0.02082519f, -0.09378088f, 0.17129423f, 0.05368811f, 0.04853777f, -0.02823831f, -0.03420234f, -0.03394938f, 
    0.09176840f, -0.24033703f, -0.28609571f, 0.09533804f, 0.02916701f, 0.14302713f, -0.03569306f, -0.06182842f, 
    -0.04006386f, 0.04559674f, 0.00129975f, 0.03701594f, 0.13467172f, 0.18296731f, 0.09028532f, -0.02975459f, 
    -0.26150325f, -0.06857178f, 0.07639094f, 0.14509311f, 0.35222673f, 0.01403132f, -0.00092845f, 0.02477013f, 
    -0.11177259f, -0.00535509f, 0.02682078f, 0.18336351f, -0.00857138f, 0.26808921f, 0.11128533f, 0.04902896f, 
    -0.07397474f, 0.04845548f, -0.00274282f, 0.15291789f, 0.13653871f, 0.16110802f, 0.06565417f, -0.03994687f, 
    0.00400212f, -0.02041793f, -0.00586375f, 0.11174742f, 0.11354067f, 0.10884529f, -0.08170248f, -0.25549006f, 
    -0.01469632f, 0.12857138f, -0.05970411f, -0.05039573f, -0.08417381f, -0.03135767f, 0.09202258f, -0.05744343f, 
    0.20544434f, 0.11159416f, 0.05536629f, -0.06573763f, 0.02507722f, -0.00728132f, 0.06227927f, -0.08801007f, 
    -0.27349579f, 0.02489069f, -0.05214770f, -0.01177773f, -0.00139071f, 0.00391901f, 0.08415518f, -0.15043657f, 
    -0.01322174f, -0.14959945f, -0.53903645f, 0.08088349f, -0.13481149f, 0.03528056f, 0.01203933f, -0.04675692f, 
    0.22688496f, 0.09980446f, 0.01787439f, 0.19948946f, -0.06388142f, -0.03096420f, -0.02421309f, 0.00679538f, 
    0.14829014f, 0.18398035f, -0.05906883f, 0.22726363f, -0.10490638f, -0.01646683f, -0.03803723f, 0.00894544f, 
    0.02533886f, 0.05756848f, 0.01823950f, 0.19760628f, 0.04087181f, 0.17398196f, -0.04043286f, 0.01239716f, 
    -0.01253239f, -0.11922894f, -0.00468040f, -0.02771987f, -0.06829951f, 0.03472529f, -0.30956361f, -0.06525999f, 
    -0.12403261f, -0.12886988f, -0.03220247f, 0.16755056f, -0.15077655f, 0.17040391f, -0.10333582f, 0.05359715f, 
    -0.15776499f, 0.09844207f, 0.04923671f, 0.13905078f, -0.02977062f, 0.11528821f, -0.33675233f, -0.00187594f, 
    0.42657107f, 0.01851615f, 0.04661745f, -0.01396051f, -0.03145887f, 0.08244894f, 0.04248586f, 0.06702025f, 
    -0.22763766f, 0.16061877f, -0.12864994f, -0.07604443f, -0.00231817f, 0.03759005f, -0.07851694f, 0.26849890f, 
    -0.12883881f, 0.14538242f, 0.13971715f, 0.14321178f, 0.05832681f, 0.00091989f, 0.11597519f, 0.19627503f, 
    0.00862666f, -0.32446051f, -0.01662957f, -0.33055648f, -0.02370401f, -0.04927965f, -0.06246633f, 0.06240714f, 
    -0.05327400f, 0.17568246f, 0.01994954f, 0.01239015f, -0.08683939f, 0.07449207f, 0.00226188f, 0.06464181f, 
    -0.02410380f, 0.10791463f, 0.17061532f, 0.00680259f, 0.11068009f, 0.00137076f, -0.06192405f, -0.15629485f, 
    -0.04229056f, -0.02360790f, 0.11478394f, -0.02594993f, -0.04226962f, -0.06633151f, 0.10787074f, 0.00107902f, 
    -0.15240850f, 0.02994754f, 0.09527124f, -0.04242448f, 0.11698071f, -0.00925894f, 0.11791957f, 0.07242470f, 
    0.06815910f, -0.13621771f, -0.07920350f, 0.10681845f, -0.07385888f, -0.17139155f, 0.09168518f, -0.03844609f, 
    -0.06942876f, 0.15028295f, -0.07075806f, -0.04081546f, 0.03237921f, 0.08201983f, -0.03802473f, -0.15089576f, 
    -0.05535510f, -0.12982349f, 0.09784070f, 0.11997836f, 0.00212591f, -0.04969972f, 0.00240047f, -0.03674281f, 
    0.06898696f, 0.21768993f, 0.01834394f, -0.04706249f, -0.10883188f, 0.08122612f, 0.10004482f, 0.01080802f, 
    0.04950914f, -0.09630246f, -0.01350731f, -0.01531928f, 0.04077796f, 0.12928641f, -0.03897918f, -0.04488595f, 
    0.11459973f, -0.01476934f, -0.18323402f, 0.27466860f, -0.03343884f, 0.11469943f, -0.05810824f, -0.14860034f, 
    -0.10480541f, -0.02205075f, -0.14103366f, -0.18812768f, -0.18835312f, -0.21136126f, 0.27466482f, -0.17964207f, 
    -0.07257883f, -0.09905708f, 0.18816833f, -0.10927206f, 0.20246811f, -0.09986359f, -0.23408215f, -0.01426145f, 
    0.08761771f, 0.16471584f, -0.07725690f, 0.08178769f, -0.12228037f, 0.10161501f, 0.19481902f, -0.18496715f, 
    -0.07955438f, -0.08100845f, -0.01570076f, -0.13602024f, 0.01471688f, -0.14001434f, 0.21766382f, 0.05202961f, 
    0.12370551f, 0.04457609f, 0.04215791f, -0.04402551f, -0.08107325f, -0.11582687f, 0.08527896f, 0.16603611f, 
    0.16149367f, -0.06380127f, -0.03756294f, -0.01779910f, 0.08343079f, 0.08905697f, -0.00077071f, -0.04608623f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.02194776f, 0.07152484f, -0.01932078f, 0.00785466f, 0.12308632f, 0.05992329f, -0.08211342f, 0.06899313f, 
    -0.05250152f, -0.00465812f, 0.06832813f, 0.03583834f, -0.00447078f, -0.01823878f, 0.04435112f, 0.11554739f, 
    -0.04810379f, -0.03644698f, 0.12888345f, -0.01195688f, 0.01444019f, 0.17032927f, -0.03009267f, -0.16414188f, 
    0.03188350f, 0.13363546f, 0.18012616f, 0.13855986f, 0.04035783f, 0.11466770f, 0.08570939f, -0.17830066f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06854204f, 0.19411656f, 0.00150608f, 0.19737902f, 0.32511085f, 0.43610045f, -0.45670700f, 0.42755193f, 
    0.03281892f, -0.08112729f, 0.05785045f, -0.30303216f, -0.41422126f, -0.11462034f, -0.07764234f, 0.25593755f, 
    -0.11517853f, -0.00065065f, -0.05205541f, -0.11572254f, 0.52817601f, 0.16736013f, 0.08106811f, 0.30417514f, 
    -0.09650622f, -0.43875051f, -0.05391795f, 0.23806322f, 0.08817466f, 0.04374133f, -0.06133479f, -0.12458199f, 
    0.08935651f, 0.28080237f, 0.10167404f, 0.19816731f, 0.10607989f, 0.04097921f, 0.09517135f, -0.42160034f, 
    0.11696347f, -0.01266795f, -0.36583003f, 0.01404202f, 0.20946676f, 0.09629685f, 0.13344876f, 0.01159678f, 
    0.33726412f, 0.11698458f, -0.00355387f, -0.17361109f, -0.28214470f, -0.02556249f, -0.08079231f, -0.81327254f, 
    -0.04564994f, 0.04028372f, 0.15375280f, 0.33694547f, 0.11251670f, 0.03284036f, -0.20035037f, 0.59303546f, 
    0.00579115f, 0.27924997f, -0.00983366f, -0.14672387f, 0.55012399f, -0.28249532f, 0.04453316f, -0.30938053f, 
    0.02724037f, -0.10436183f, -0.08836634f, -0.00309281f, -0.51112366f, 0.06898701f, 0.02785950f, -0.06764703f, 
    0.51523608f, 0.01454382f, 0.11343400f, 0.01954206f, -0.35840976f, 0.29645905f, 0.22701257f, 0.21779145f, 
    0.16697788f, 0.19215761f, 0.19999437f, 0.13716716f, -0.03691065f, 0.08703811f, -0.33900699f, -0.18897896f, 
    -0.01206709f, 0.06722296f, 0.15706843f, 0.07698842f, 0.16204357f, -0.14311954f, -0.05900946f, -0.09204606f, 
    -0.12580575f, 0.00869336f, -0.06192626f, -0.15266286f, -0.07166587f, -0.10996157f, -0.07684268f, -0.08469403f, 
    -0.11911649f, -0.01305471f, -0.15809968f, -0.11612588f, -0.17160918f, 0.05348836f, -0.10678547f, -0.03023996f, 
    -0.01455071f, 0.02085316f, -0.01451792f, 0.10808939f, -0.11245017f, -0.09551454f, -0.00513129f, 0.01655345f, 
    0.01714936f, 0.22963223f, 0.11745145f, -0.07975833f, -0.58265442f, 0.08735544f, 0.24926001f, 0.25018561f, 
    -0.09679875f, -0.02211607f, 0.10870065f, -0.14145370f, -0.33512726f, 0.44058883f, -0.14257756f, -0.14949405f, 
    0.14204112f, 0.14059635f, 0.24021336f, 0.07060448f, -0.44523907f, -0.07372049f, 0.46893829f, 0.21595891f, 
    -0.06415458f, -0.23488814f, -0.05900106f, -0.11614688f, 0.08598391f, 0.04412997f, 0.21537055f, -0.10281684f, 
    0.14267401f, -0.12946582f, 0.09118353f, -0.17366488f, -0.09944675f, 0.10999440f, 0.00046634f, 0.11891907f, 
    -0.03894333f, -0.15248440f, -0.00949955f, -0.12386227f, 0.02761465f, -0.18571867f, -0.17796490f, -0.08364869f, 
    0.02460157f, -0.09872197f, -0.14365232f, 0.10200629f, 0.12465963f, -0.18772519f, 0.10815774f, 0.08010931f, 
    -0.01130663f, -0.10533381f, 0.09128419f, -0.04351985f, -0.13430634f, -0.10734956f, -0.12426913f, 0.09782948f, 
    -0.17294310f, 0.13588837f, -0.16625172f, -0.07297997f, 0.17534599f, -0.00807948f, 0.04132204f, 0.00973201f, 
    -0.00344645f, -0.07589446f, -0.27382332f, -0.08707063f, 0.50668526f, 0.20381242f, 0.46121493f, 0.04644006f, 
    0.25241560f, 0.06194704f, -0.12254296f, -0.04827854f, 0.46850049f, -0.31756213f, 0.50360775f, -0.02805896f, 
    0.07815760f, -0.28717351f, 0.17210719f, -0.22407672f, -0.02839292f, -0.15016942f, 0.37307563f, 0.11835820f, 
    0.04080053f, 0.00303643f, 0.11822326f, 0.34923935f, -0.07986985f, 0.16891451f, 0.21368662f, -0.05472505f, 
    -0.16896877f, 0.05165228f, 0.50693178f, 0.32702944f, 0.35806468f, -0.31545079f, 0.00432104f, -0.03783853f, 
    0.02620422f, 0.11362069f, 0.00623231f, 0.16099629f, -0.55492508f, 0.08003514f, -0.04637460f, 0.03450607f, 
    -0.06957410f, -0.66226482f, -0.01450841f, 0.19784956f, 0.05057051f, -0.29292625f, 0.22189084f, 0.38001657f, 
    0.08158388f, -0.37832114f, 0.16126509f, 0.35066321f, -0.18427907f, 0.58636492f, 0.09196168f, 0.36377338f, 
    -0.07928265f, -0.06388462f, 0.17118821f, 0.05308853f, -0.53562933f, -0.09195910f, -0.48563465f, 0.37151691f, 
    0.01721647f, -0.13832894f, 0.19931453f, -0.15367346f, 0.40424365f, 0.14543913f, -0.25128344f, 0.14707343f, 
    -0.01483669f, -0.41765028f, -0.01087391f, 0.10536833f, -0.08716784f, 0.29243097f, 0.00255259f, -0.06557368f, 
    0.00903828f, 0.59939003f, -0.04299836f, -0.15093996f, -0.12752144f, 0.30116823f, -0.07311571f, -0.17753333f, 
    -0.07702685f, 0.13385443f, -0.05348928f, 0.23996587f, 0.39944422f, 0.27628627f, -0.04111690f, 0.11260233f, 
    -0.44482177f, 0.12135082f, -0.06636380f, 0.03900528f, 0.00718336f, -0.21471342f, 0.14449780f, 0.23056407f, 
    0.03181722f, 0.26344436f, -0.39200372f, 0.24619152f, 0.08905984f, 0.04669185f, 0.45101625f, -0.13190192f, 
    0.11273988f, 0.06521206f, -0.01815469f, -0.06675515f, 0.33609974f, -0.41279316f, 0.16917869f, -0.10396165f, 
    0.16797893f, 0.06790822f, -0.47057927f, -0.16661432f, 0.10415561f, 0.24420169f, -0.01216276f, -0.18103987f, 
    0.00841641f, 0.15916571f, 0.13078283f, 0.05175985f, 0.40879646f, 0.14406845f, 0.36279735f, 0.26456648f, 
    0.12388169f, 0.16803969f, -0.01252959f, -0.26636720f, 0.01976685f, -0.04041917f, 0.11688498f, 0.27266097f, 
    -0.10136153f, -0.39830384f, 0.10346050f, 0.23016323f, -0.21457817f, 0.13909951f, -0.43578604f, 0.10686646f, 
    -0.01238814f, -0.01360287f, 0.54526138f, 0.42371601f, -0.18241651f, -0.17495902f, 0.15356350f, 0.28991097f, 
    -0.18896022f, -0.01435339f, 0.09128111f, -0.11884291f, -0.11310007f, 0.10829698f, -0.59147620f, -0.26608723f, 
    0.14864853f, 0.11192952f, -0.04048155f, 0.28593937f, 0.02469308f, 0.36687768f, 0.11609410f, -0.34519738f, 
    -0.15869242f, 0.38006625f, 0.04021379f, 0.11625692f, -0.25747088f, -0.09867492f, -0.05570175f, -0.52569377f, 
    0.12638311f, 0.15885176f, -0.28996438f, 0.19659509f, 0.37910381f, 0.27658051f, 0.46365196f, 0.04469576f, 
    0.46590209f, 0.17758597f, -0.06747286f, 0.06633340f, 0.21833225f, -0.21397747f, 0.08613913f, -0.56515795f, 
    0.03805037f, 0.09504487f, -0.23080485f, -0.02419920f, 0.08813051f, 0.32221651f, 0.28388095f, 0.23017079f, 
    0.03107029f, -0.08677832f, -0.14509258f, -0.11783107f, 0.43092486f, -0.16593969f, -0.36288103f, 0.61081672f, 
    0.06814440f, 0.07223707f, -0.23047426f, -0.02439562f, -0.09443121f, 0.07432660f, -0.31825364f, -0.15100823f, 
    -0.03126291f, -0.03587393f, 0.23668873f, -0.07493615f, -0.02993140f, 0.49309477f, 0.29489839f, 0.18181629f, 
    -0.02152951f, 0.40481412f, 0.25135970f, 0.09647979f, 0.07728612f, -0.04940142f, -0.22987774f, -0.43633544f, 
    0.16177195f, -0.11241847f, -0.14697179f, 0.14611609f, 0.09006356f, -0.05012280f, -0.08320015f, -0.04656306f, 
    -0.17045781f, 0.11258923f, 0.04508807f, -0.11574616f, 0.08755267f, -0.02858892f, 0.08495355f, -0.17419143f, 
    -0.14242281f, 0.15033692f, -0.11125824f, 0.10881250f, -0.17005424f, -0.18033701f, 0.15016329f, 0.14617001f, 
    0.11883548f, 0.03159011f, 0.08192489f, -0.12116209f, -0.05941487f, -0.00701012f, -0.09194747f, 0.04890128f, 
    -0.11215112f, -0.06486832f, -0.14756288f, 0.18870370f, -0.10944719f, 0.28785598f, 0.34912339f, -0.11679036f, 
    0.09319443f, 0.10602580f, 0.65903848f, 0.35473883f, 0.11003059f, -0.04585017f, 0.20271745f, -0.08308155f, 
    -0.36092570f, -0.15514360f, 0.42084491f, 0.00718581f, -0.45859331f, 0.46406561f, -0.20139544f, 0.13116936f, 
    -0.08310767f, 0.04984660f, 0.04635166f, -0.23751532f, 0.14623831f, -0.19552082f, 0.37742379f, -0.00415900f, 
    -0.04833869f, -0.25409725f, -0.07907743f, 0.51163256f, -0.56802356f, -0.25584489f, 0.66732198f, -0.23505846f, 
    0.16516267f, -0.14432062f, 0.21949898f, 0.18046792f, 0.12298901f, 0.40130144f, -0.34341055f, 0.15883800f, 
    0.46983188f, -0.07563045f, 0.21542455f, -0.04515158f, -0.27852878f, 0.14203516f, -0.04983601f, -0.36341518f, 
    -0.15020022f, -0.07866376f, 0.27247122f, 0.02274280f, 0.13900036f, 0.20067295f, -0.20098232f, -0.09312824f, 
    0.11500292f, -0.04917181f, 0.05259095f, -0.03993900f, 0.26758739f, -0.36595237f, 0.47839996f, 0.05982764f, 
    -0.16693953f, -0.13152881f, -0.39303747f, 0.09592746f, -0.16267385f, 0.60241699f, 0.46197075f, -0.11856304f, 
    0.19971254f, -0.03086949f, 0.10788438f, 0.06725074f, 0.40408030f, 0.58681011f, 0.20965935f, 0.38411993f, 
    -0.05017490f, -0.06453209f, -0.22312854f, -0.46129525f, -0.17057396f, 0.29704106f, 0.15824589f, -0.06746685f, 
    -0.08041450f, -0.36638880f, 0.04532056f, 0.40141591f, -0.41950554f, 0.46407694f, -0.11824893f, 0.02520210f, 
    -0.10151976f, 0.08920717f, 0.57452637f, 0.05246576f, -0.18681005f, 0.09154753f, -0.05882155f, 0.38168535f, 
    0.11913478f, -0.11284287f, 0.10412759f, 0.07092962f, 0.19597210f, 0.08966000f, -0.06300192f, -0.40045077f, 
    0.11356007f, -0.23103778f, 0.23369068f, -0.11471252f, 0.12706582f, 0.28001949f, -0.00843527f, -0.27696246f, 
    0.07713979f, -0.18009409f, -0.12353396f, 0.12805471f, 0.04314914f, 0.27757177f, -0.43103284f, 0.62640303f, 
    -0.16991137f, -0.08723227f, -0.27466699f, -0.29111680f, -0.34640488f, -0.01970147f, -0.58873272f, 0.21597804f, 
    0.02571662f, -0.07157589f, 0.07153936f, 0.02962213f, 0.13196602f, 0.12818840f, 0.34267175f, -0.00728996f, 
    0.09144260f, -0.36525464f, 0.06006448f, 0.33431828f, -0.05861979f, 0.15421148f, -0.09266181f, -0.03229658f, 
    -0.04284219f, -0.20504120f, 0.13950571f, 0.07652000f, -0.09544213f, -0.04916513f, 0.10370160f, -0.05961551f, 
    -0.09496292f, -0.15717481f, 0.08253437f, -0.16924244f, -0.09106737f, -0.02985241f, -0.02265281f, 0.03457237f, 
    -0.16459000f, -0.10339332f, -0.00368947f, -0.13039160f, -0.08722149f, -0.13195859f, 0.09880654f, -0.01027218f, 
    0.11961488f, -0.15039557f, -0.09034931f, 0.13139388f, -0.15385589f, -0.17757249f, -0.14991666f, -0.07968155f, 
    -0.09223920f, -0.48859987f, 0.06285601f, 0.22440661f, 0.24081743f, -0.30957890f, -0.05449423f, 0.55089301f, 
    -0.13969100f, -0.08311402f, -0.13845421f, 0.11608845f, 0.28713417f, -0.27240396f, 0.22588202f, 0.21994929f, 
    0.12112723f, -0.14296211f, -0.15662040f, 0.08503050f, 0.62515199f, -0.26078638f, -0.13281091f, 0.18380496f, 
    0.02958285f, -0.13771573f, 0.55051637f, 0.00417497f, 0.00558953f, 0.28109118f, -0.38091034f, 0.56917471f, 
    -0.04777205f, 0.49447632f, -0.16779791f, -0.38693410f, 0.18926236f, 0.43446001f, -0.71014881f, -0.28393942f, 
    0.08061329f, -0.11663783f, -0.36647740f, 0.07576444f, -0.03518428f, 0.11761444f, 0.55046153f, 0.03432107f, 
    -0.33427075f, -0.15303145f, 0.04984788f, -0.14288932f, 0.31505656f, 0.02999234f, -0.12363224f, 0.03930114f, 
    -0.01789271f, 0.43707833f, -0.13035528f, 0.22356245f, -0.17938295f, 0.39423865f, 0.28184509f, -0.34069487f, 
    -0.03416719f, 0.12960635f, 0.16631590f, -0.17001995f, 0.45008478f, -0.13350253f, -0.29563838f, -0.01927881f, 
    0.05516466f, -0.11606616f, -0.50598562f, -0.09593219f, -0.41538474f, 0.14481731f, 0.19465588f, 0.24530900f, 
    0.14765027f, 0.09600550f, -0.11840474f, 0.14227007f, 0.03642873f, 0.08155745f, 0.37713969f, -0.23133175f, 
    0.11711824f, 0.71998662f, 0.40826422f, 0.32903904f, 0.00802672f, 0.50370944f, -0.16723555f, -0.40297005f, 
    -0.10157565f, 0.13975021f, -0.04260060f, -0.19545758f, 0.24245825f, -0.21798900f, 0.20087969f, 0.08301044f, 
    0.01605786f, -0.06586736f, 0.21319024f, 0.02494088f, 0.16966233f, 0.00865387f, -0.13862132f, -0.03061679f, 
    -0.41148981f, -0.08953900f, 0.23970181f, -0.17663562f, -0.48568359f, 0.28576389f, 0.35335255f, 0.08500615f, 
    -0.03427995f, 0.49763998f, 0.36263022f, -0.07166542f, 0.08195756f, -0.07277555f, -0.18283454f, -0.26734379f, 
    0.01924593f, 0.32141784f, 0.02706587f, -0.29675382f, 0.50473893f, -0.32686371f, 0.02002529f, 0.00654732f, 
    0.08601305f, -0.06236684f, -0.29050612f, 0.10178044f, 0.11719450f, -0.03270936f, 0.15910167f, -0.10680830f, 
    0.13480486f, -0.07425893f, 0.19598849f, -0.10612109f, -0.25946525f, 0.29263636f, 0.22474889f, 0.16394703f, 
    -0.05869038f, 0.33747244f, 0.34223390f, -0.08860899f, -0.00191717f, -0.20702693f, -0.29003924f, -0.01175757f, 
    -0.05389000f, 0.14771470f, -0.14221410f, -0.14240244f, -0.24534211f, -0.38047424f, 0.25778282f, 0.46384469f, 
    0.10997268f, -0.09678912f, 0.37538025f, 0.15823033f, 0.53234488f, -0.25606593f, -0.34891579f, -0.08591626f, 
    -0.32175174f, 0.10952781f, 0.36729136f, 0.12058585f, -0.35014975f, 0.09796973f, -0.07339633f, 0.26542795f, 
    -0.01271291f, 0.64581692f, -0.05075301f, 0.12516557f, -0.12542306f, -0.20007171f, -0.05158301f, 0.12562868f, 
    -0.07427837f, 0.34916952f, -0.06380748f, -0.15500209f, -0.08098856f, 0.47273773f, -0.14429861f, 0.28438342f, 
    0.14390139f, 0.03273278f, -0.16195779f, -0.03471822f, 0.13642129f, -0.41669533f, -0.20412202f, -0.09179480f, 
    -0.23388357f, 0.05658181f, 0.17026764f, -0.11458430f, -0.17693236f, -0.47186333f, 0.20769548f, 0.26673174f, 
    -0.15466298f, 0.39958364f, 0.13878064f, 0.17468815f, 0.10248147f, -0.12129513f, 0.10014125f, 0.56849229f, 
    -0.05003235f, 0.10804436f, 0.14950342f, -0.01720386f, -0.02165128f, 0.05891321f, 0.41028735f, 0.25218901f, 
    0.00648848f, 0.15179941f, -0.13835968f, -0.07709614f, 0.61202097f, -0.16431305f, 0.22614053f, 0.00034597f, 
    -0.39366558f, 0.10638244f, 0.19574958f, 0.14114906f, 0.08989796f, -0.29967636f, 0.39082578f, 0.04676768f, 
    0.09855040f, 0.25579116f, 0.34766394f, -0.40881774f, -0.00800573f, -0.25270128f, 0.19865337f, 0.39638838f, 
    -0.15190506f, 0.00569739f, 0.08313944f, -0.02681358f, -0.18394299f, -0.13720140f, 0.07613859f, -0.01615907f, 
    0.09995534f, 0.03899285f, 0.01368488f, -0.08189940f, 0.00272641f, 0.09203193f, 0.05657838f, 0.07195578f, 
    -0.15985034f, 0.01842835f, -0.03833176f, 0.14810754f, -0.12283522f, -0.21870732f, -0.13637577f, -0.18429886f, 
    -0.01138703f, -0.12533678f, -0.15507410f, -0.06668630f, 0.05984372f, 0.12766147f, 0.11300564f, -0.07691409f, 
    0.06654378f, -0.02517113f, 0.01209210f, 0.31834838f, 0.06843211f, -0.18814476f, 0.55274510f, -0.02077312f, 
    -0.16531233f, 0.10751165f, -0.12289872f, -0.23056737f, 0.10966887f, -0.00935852f, -0.24247245f, 0.09689791f, 
    0.40985796f, 0.02722438f, 0.03138939f, 0.06434172f, 0.09296833f, -0.48757437f, 0.50033987f, -0.07722530f, 
    -0.01188069f, -0.25426859f, 0.31418860f, 0.16503349f, 0.09638116f, -0.06423488f, -0.34243962f, 0.80621034f, 
    0.06284082f, -0.06618380f, -0.16408922f, -0.08375591f, 0.14915211f, -0.00232153f, 0.39326480f, -0.38385031f, 
    -0.10932475f, 0.16244563f, 0.56933719f, 0.38261783f, 0.07063459f, 0.16153605f, 0.52617770f, -0.11459084f, 
    0.25316435f, 0.10057995f, -0.04153650f, 0.12608239f, -0.17751645f, 0.35267070f, -0.07087320f, 0.65062720f, 
    0.13687667f, -0.44575611f, -0.19598724f, -0.11830121f, 0.00019017f, -0.34994659f, 0.29621512f, 0.13839601f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.30277300f, 0.14978686f, -0.02208497f, 0.11183683f, 0.01295048f, -0.15645860f, -0.05672473f, 0.19287963f, 
    0.11701107f, 0.11073414f, 0.07578959f, 0.25005931f, 0.11131112f, 0.13950084f, -0.19094788f, 0.31491250f, 
    0.14047690f, -0.19517599f, 0.31227499f, 0.14544694f, -0.06114653f, 0.01572671f, 0.12448890f, 0.20465295f, 
    0.05604931f, -0.02767518f, -0.04014146f, 0.02498602f, 0.11972894f, -0.04797702f, -0.08103448f, 0.08004129f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.52398437f, 0.28153664f, 0.20440103f, -0.15487081f, -0.28088704f, -0.07726243f, 0.07404559f, 0.43527061f, 
    -0.22530256f, -0.24631633f, -0.20720743f, -0.14486906f, 0.06972556f, -0.24202050f, -0.03689867f, 0.33907598f, 
    0.45444614f, -0.03343607f, 0.12049222f, -0.37470308f, 0.02953737f, -0.26456404f, -0.37598085f, -0.14217684f, 
    0.16442768f, 0.23598240f, -0.12110518f, -0.34562951f, 0.04905868f, -0.04806104f, 0.09410707f, 0.22077896f, 
    -0.46443206f, -0.13029140f, 0.11129712f, -0.11900913f, -0.27880630f, -0.01030047f, -0.09565484f, -0.33350435f, 
    -0.64564782f, 0.13179657f, 0.06657261f, -0.20371987f, -0.16962555f, 0.17794260f, -0.08634184f, 0.15439942f, 
    -0.19889800f, -0.19649762f, -0.40941361f, -0.51667625f, 0.00444001f, -0.12716457f, 0.08249304f, 0.18244724f, 
    0.48522890f, 0.37971443f, 0.49308679f, 0.46859902f, 0.40558425f, -0.11439645f, -0.16230287f, -0.24125819f, 
    0.04756998f, 0.52418351f, 0.41252831f, 0.08835840f, -0.83086228f, 0.01278097f, -0.20179270f, 0.23620787f, 
    -0.17119759f, 0.06489180f, -0.23730882f, -0.21202044f, 0.15949261f, -0.08983875f, -0.15469925f, -0.71935713f, 
    0.02450872f, -0.82331771f, -0.50066411f, 0.22905895f, -0.02371016f, 0.00197005f, -0.07806047f, 0.25724998f, 
    -0.42202196f, 0.13681272f, 0.06431622f, 0.55166137f, -0.57632965f, 0.02439015f, 0.48838100f, -0.49943927f, 
    0.15077606f, -0.72461969f, -0.41137731f, 0.15032181f, -0.19649419f, -0.00470790f, -0.25783494f, 0.55434430f, 
    0.18235381f, 0.14326592f, -0.59053016f, 0.73406386f, -0.14530730f, -0.34992412f, -0.00528767f, 0.37905508f, 
    -0.05552677f, -0.30040514f, 0.30422091f, -0.13765249f, 0.06991554f, -0.15420240f, -0.12039124f, -0.48356450f, 
    -0.51603240f, -0.65834546f, 0.10181495f, -0.16982229f, -0.45900786f, -0.08237266f, -0.49589542f, 0.59317374f, 
    -0.07869499f, -0.09622387f, -0.57720673f, 0.12476312f, 0.31091228f, 0.02787477f, -0.39188951f, 0.09115919f, 
    0.25834835f, -0.16189443f, -0.65037340f, 0.32345438f, -0.31485599f, 0.09466682f, -0.21896671f, 0.03993740f, 
    0.29287079f, -0.37896562f, 0.23539799f, 0.31261554f, 0.13919932f, 0.11320428f, -0.45298609f, -0.14979038f, 
    0.02930680f, -0.24119045f, 0.51539898f, 0.22980526f, 0.12581262f, -0.05301575f, 0.04497458f, -0.85265332f, 
    0.17623675f, -0.26062837f, 0.32243446f, -0.12696181f, 0.48746246f, -0.08984418f, -0.10788927f, -0.31302086f, 
    -0.18831426f, -0.03011717f, 0.21453191f, -0.48353043f, -0.21652722f, 0.45809814f, 0.02571659f, -0.04812949f, 
    -0.20471807f, 0.53318399f, -0.32259899f, 0.23193219f, 0.00231924f, -0.37186584f, 0.03150550f, 0.16157243f, 
    0.17484169f, 0.33167854f, 0.02762767f, -0.48805058f, -0.38080305f, 0.04000590f, -0.31941909f, 0.03657544f, 
    0.17123263f, -0.01980465f, 0.33899075f, -0.11250688f, -1.02324307f, -0.17540976f, -0.65609431f, -0.29943281f, 
    0.39417925f, -0.52603215f, -0.55214912f, 0.46917763f, -0.34787256f, 0.11295251f, -0.21952416f, 0.01719722f, 
    0.07420095f, 0.09694086f, 0.18236725f, 0.08815891f, -0.06226301f, 0.15274587f, 0.07148188f, 0.26624465f, 
    -0.07885589f, 0.10610016f, -0.32254729f, -0.35543427f, -0.62354141f, -0.14912352f, -0.24718788f, -0.16212358f, 
    -0.56969202f, -0.00687449f, -0.15130816f, -0.16607960f, 0.23812717f, 0.03754211f, -0.17052226f, 0.16213523f, 
    0.17523889f, 0.07364617f, 0.39449152f, -0.76754862f, -0.19036742f, -0.52262080f, -0.17801836f, 0.29418677f, 
    0.30965859f, 0.42648360f, -0.28944468f, -0.59093559f, -0.05788065f, -0.26580405f, -0.64208347f, -0.85938144f, 
    -0.09793741f, -0.08263282f, 0.36234063f, 0.01983348f, 0.21973509f, -0.07247356f, 0.21446659f, 0.31611753f, 
    -0.29950744f, 0.08624031f, -0.60718590f, -0.00407617f, -0.13331354f, 0.05207543f, 0.55989307f, 0.15584984f, 
    -0.63913810f, 0.06131580f, 0.19263238f, -0.37671778f, 0.28823513f, -0.24810775f, -0.19868076f, -0.19453542f, 
    -0.66672194f, 0.29192832f, -0.67635220f, -0.62316537f, -0.13165565f, 0.49603561f, 0.18281485f, -0.14342713f, 
    -0.36150071f, 0.22125283f, -0.00723460f, -0.00143633f, 0.36101192f, 0.03428337f, -0.04598091f, 0.25487038f, 
    0.24935621f, -0.16680463f, -0.11440455f, -0.00366545f, 0.05346065f, -0.08378275f, 0.45345408f, -0.19295570f, 
    0.06411099f, -0.75971818f, 0.28144881f, -0.68712956f, -0.23003882f, -0.01932262f, 0.06712861f, -0.29801828f, 
    -0.02927390f, 0.11615051f, 0.11438835f, 0.25458202f, 0.02166190f, 0.44557858f, -0.63795245f, 0.05805101f, 
    -0.30605975f, -0.00736351f, -0.47935626f, 0.02594186f, 0.30049643f, -0.04211631f, 0.47498292f, -0.14537255f, 
    0.42167816f, -0.04472934f, -0.48782787f, -0.08657712f, 0.21714590f, 0.13823760f, 0.12244770f, 0.04507140f, 
    0.17831641f, 0.36641046f, -0.22693369f, -0.27123454f, -0.10915050f, -0.34930789f, 0.06136643f, 0.10535090f, 
    -0.52462906f, -0.33594453f, 0.03930511f, 0.22356477f, 0.01925170f, -0.75142324f, 0.41647047f, -0.10340121f, 
    -0.36815709f, -0.31468156f, -0.42123592f, 0.52524793f, 0.20149541f, 0.12173504f, -0.23628154f, -0.24712034f, 
    -0.17557900f, 0.09908011f, -0.26463643f, 0.01965602f, -0.09783157f, 0.03510352f, 0.13361491f, -0.42874992f, 
    -0.02631294f, 0.26959383f, -0.08201010f, 0.21338643f, 0.57498139f, -0.47482324f, -0.07342749f, -0.17131807f, 
    0.31133556f, 0.36596072f, 0.27790484f, -0.17308529f, -0.06767648f, -0.22107294f, 0.33032629f, 0.22537638f, 
    -0.80501157f, -0.48363322f, -0.60302871f, -0.75528592f, -0.31817418f, -0.09550883f, -0.18222688f, -0.27665278f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00533049f, -0.16983804f, 0.13564453f, -0.20394276f, 0.11672076f, 0.05555658f, -0.14781114f, -0.22950366f, 
    -0.11471213f, -0.13134612f, 0.09169315f, -0.02802208f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
