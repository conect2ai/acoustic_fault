#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.25020975f, -0.34125564f, -0.35661948f, -0.51021975f, -0.30977860f, -0.12358563f, -0.14880334f, -0.25618058f, 
    0.06218352f, -0.18223839f, 0.23138285f, 0.30280474f, 0.24191989f, 0.53132093f, -0.23159072f, -0.15725537f, 
    0.23444685f, -0.08487418f, -0.16220923f, -0.31205568f, -0.16209903f, -0.05378168f, 0.23348796f, -0.24613088f, 
    -0.17728734f, 0.73425895f, -0.40893894f, -0.20505053f, 0.07689144f, -0.30452180f, 0.22812590f, 0.06211814f, 
    0.25013688f, 0.41137317f, -0.38929057f, -0.38062617f, -0.30050144f, 0.18421972f, -0.08542386f, -0.04304584f, 
    -0.20604919f, 0.23317493f, 0.29014665f, 0.01462932f, -0.28812939f, 0.08963206f, -0.06051491f, -0.17881781f, 
    0.04226957f, 0.20118952f, -0.85414213f, -0.02305134f, 0.21631257f, 0.24099225f, 0.08848020f, 0.27009997f, 
    0.51053834f, 0.14419529f, 0.11578459f, 0.24118134f, 0.05184694f, -0.07784566f, 0.08810214f, -0.00267899f, 
    -0.04428175f, -0.21211533f, 0.15760258f, 0.09155148f, -0.42298287f, -0.02213231f, 0.11851488f, -0.04455104f, 
    0.24728419f, 0.21270041f, -0.16717413f, 0.40235567f, 0.32162845f, 0.24239144f, 0.17035952f, 0.22661224f, 
    0.31994379f, 0.10481378f, -0.15188456f, -0.07537752f, 0.12528177f, 0.28314120f, 0.03265656f, -0.11998986f, 
    -0.23600355f, 0.03653413f, 0.11928429f, 0.09543102f, -0.02332496f, -0.12288942f, -0.19122134f, 0.16583689f, 
    -0.06427030f, -0.09630718f, 0.07752494f, -0.09383844f, 0.56172532f, 0.38446036f, -0.28850779f, 0.02211144f, 
    0.03208491f, 0.19009206f, -0.25912476f, -0.20941128f, -0.16929300f, 0.52834535f, -0.13071296f, -0.14062388f, 
    -0.06077624f, 0.06770732f, -0.20040536f, 0.20572142f, -0.22498463f, -0.29773962f, 0.28516060f, -0.25683635f, 
    -0.23442173f, -0.09829414f, 0.04053311f, 0.15184318f, -0.23909082f, 0.57498586f, 0.07470290f, 0.31584057f, 
    0.34999290f, 0.24572444f, 0.30520236f, -0.12167579f, -0.05125637f, 0.00803792f, -0.21550074f, -0.10825362f, 
    0.18054987f, 0.02626593f, 0.03274222f, -0.21031199f, 0.12705801f, -0.10588548f, 0.09552892f, -0.04568382f, 
    -0.06322470f, 0.10863813f, 0.04107204f, 0.05392291f, -0.17710650f, -0.02311990f, -0.40996656f, 0.29181081f, 
    0.03183809f, -0.31801865f, 0.40592960f, -0.29589409f, -0.03821641f, 0.30447346f, 0.35646522f, 0.17575024f, 
    -0.38391253f, -0.08923192f, 0.40156621f, 0.01781081f, -0.21704818f, 0.42524284f, 0.09957952f, -0.42240471f, 
    -0.26390392f, 0.15663156f, 0.02063714f, 0.43971556f, -0.06001505f, -0.19818874f, -0.18326259f, -0.26215318f, 
    0.44903004f, -0.40678352f, -0.24715841f, 0.15963933f, -0.17701618f, 0.43320361f, -0.00881759f, 0.69445390f, 
    -0.43857053f, -0.12418749f, 0.12519112f, 0.03982930f, -0.34052563f, -0.04631947f, -0.11946877f, -0.29078510f, 
    -0.02760289f, 0.05650051f, 0.35536218f, 0.05365939f, 0.03281386f, -0.10738881f, 0.07604375f, 0.23094569f, 
    0.32288295f, 0.26610765f, 0.35883933f, 0.00089363f, -0.10225663f, 0.09613542f, 0.02898943f, -0.02614282f, 
    -0.03797939f, 0.04068758f, 0.06260390f, -0.22151588f, 0.08800545f, 0.30582687f, -0.09411687f, 0.06619703f, 
    0.11108565f, -0.28069636f, -0.18449399f, 0.14333697f, 0.06390361f, -0.12114140f, -0.26417893f, -0.30959886f, 
    -0.17057247f, -0.26920614f, -0.26495823f, -0.15579137f, 0.36795625f, 0.20700265f, 0.61266690f, 0.08648258f, 
    -0.32732081f, -0.50433308f, -0.71422637f, -0.03654774f, 0.24333169f, 0.07891152f, -0.04830093f, 0.03020938f, 
    -0.17575131f, 0.15412141f, 0.21494263f, 0.18308215f, -0.22381996f, 0.08762557f, -0.45695174f, 0.06154637f, 
    0.10521840f, 0.11773318f, -0.45198613f, -0.13772528f, 0.22558956f, 0.28372768f, 0.30599183f, -0.40832409f, 
    -0.40900096f, 0.38302028f, 0.08140171f, -0.21292342f, 0.28593239f, -0.12516186f, 0.32257912f, -0.20151961f, 
    0.07658068f, 0.06293526f, -0.27840477f, 0.15519349f, -0.20423436f, -0.26972720f, 0.15992677f, -0.19804899f, 
    -0.11053704f, 0.40779060f, 0.31050044f, -0.77095145f, -0.31289339f, -0.37176087f, -0.05939629f, -0.41490331f, 
    -0.06708330f, -0.38591322f, -0.59088558f, -0.47611508f, -0.30734143f, -0.24812196f, -0.27285317f, -0.04073766f, 
    -0.43551686f, -0.10800036f, -0.08926513f, -0.29017383f, -0.19794351f, -0.12436952f, -0.15151228f, 0.08689121f, 
    -0.20202620f, -0.09312905f, -0.07999647f, 0.30384147f, 0.43162194f, 0.27194503f, 0.18438970f, -0.18226804f, 
    0.01525450f, 0.18183939f, 0.02542443f, 0.00549927f, -0.06942297f, 0.14900000f, -0.04862258f, 0.19453861f, 
    -0.11398041f, 0.16203481f, 0.05031478f, -0.04061550f, -0.27981079f, -0.05335473f, 0.19152388f, -0.05316663f, 
    -0.28729570f, 0.22018106f, 0.05732889f, -0.03713197f, 0.31641930f, 0.17118853f, -0.60441202f, -0.70390731f, 
    -0.67759132f, -0.22356807f, 0.09735944f, 0.31372330f, 0.53118759f, 0.33499792f, 0.16757068f, 0.04463763f, 
    0.52724338f, -0.16365710f, -0.16213441f, 0.03301181f, -0.19435835f, -0.13312154f, 0.13324633f, -0.41196182f, 
    -0.28516623f, 0.21046674f, 0.04763679f, -0.04568980f, 0.24311545f, 0.27627814f, -0.50964922f, 0.37407863f, 
    0.38579816f, -0.40534082f, -0.27110314f, 0.16825676f, -0.16495012f, -0.43998945f, -0.38111955f, -0.17511125f, 
    0.18448271f, 0.43528044f, -0.19137409f, -0.23768535f, -0.06361340f, 0.27685517f, -0.21418740f, -0.07119985f, 
    0.29010805f, -0.12051937f, 0.03767792f, -0.13579561f, -0.31515664f, 0.03912137f, -0.47220680f, -1.06484151f, 
    -0.36238995f, 0.22129120f, -0.84468704f, -0.66529346f, 0.50801307f, -0.24141861f, -0.25759178f, 0.30064285f, 
    0.36818042f, -0.17813517f, -0.28145376f, -0.18901537f, 0.08497508f, -0.05414018f, 0.28392565f, 0.13010687f, 
    0.10990397f, 0.21666934f, 0.11003409f, -0.06311770f, 0.29401049f, 0.08395562f, -0.21946953f, -0.09792151f, 
    0.24632974f, -0.10045519f, 0.24134912f, 0.56717014f, -0.90790337f, -0.27696958f, 0.02632029f, -0.44660220f, 
    -0.38689539f, -0.64687365f, 0.10963035f, 0.06585740f, 0.07775766f, -0.26659203f, 0.00666707f, 0.16400883f, 
    -0.15371381f, 0.05571556f, -0.04862452f, -0.22400963f, -0.06501205f, 0.01151048f, -0.10436869f, 0.02369549f, 
    -0.33533895f, 0.22451317f, 0.24861735f, 0.23113950f, 0.06806269f, -0.25968319f, -0.33941877f, -0.25646472f, 
    -0.50966293f, -0.42811891f, -0.20136681f, 0.11614805f, 0.36702543f, -0.39327610f, -0.33170646f, 0.31401318f, 
    -0.24013580f, 0.21633534f, -0.17826352f, 0.31487766f, 0.16827580f, 0.02225234f, -0.30229244f, -0.01143916f, 
    -0.00121736f, 0.22427057f, 0.08443841f, -0.11487866f, -0.13990878f, 0.25626707f, -0.25848046f, 0.49137250f, 
    -0.46571386f, -0.20561907f, 0.26749280f, 0.26825634f, 0.13382055f, -0.00457904f, 0.05049434f, -0.16495249f, 
    -0.09466307f, -0.18310699f, 0.20522217f, 0.50504214f, -0.05457971f, -0.45077765f, -0.17268591f, 0.35764146f, 
    -0.06802986f, 0.26093078f, -0.11342255f, 0.15765220f, -0.00369100f, -0.32408136f, -0.69549578f, -0.56696141f, 
    0.15970874f, -0.17047909f, 0.28584039f, 0.01491794f, 0.26743197f, -0.18676351f, 0.24426159f, 0.33473083f, 
    0.28866252f, -0.13193324f, 0.03129951f, -0.19870898f, 0.24142694f, 0.12050527f, -0.24536936f, -0.09179836f, 
    -0.13348179f, -0.16161270f, -0.01805903f, -0.02600008f, -0.10490562f, 0.42298442f, 0.69919360f, -0.22221470f, 
    -0.49233463f, -0.66693127f, 0.10200679f, 0.12700146f, 0.16995627f, -0.04130235f, 0.33323491f, -0.09086638f, 
    0.38608477f, -0.33778617f, -0.27058706f, 0.00467637f, -0.26010293f, -0.08112682f, 0.23805232f, -0.26798570f, 
    -0.22053955f, 0.13873579f, 0.04493276f, -0.12728176f, 0.47781837f, -0.61726606f, -0.27126771f, -0.11879188f, 
    0.85060734f, 0.69307363f, 0.20697838f, -0.21983495f, -0.35239843f, -0.31343600f, 0.19660567f, -0.08114769f, 
    -0.17130110f, -0.21891151f, -0.13527098f, 0.09517529f, 0.05119506f, -0.10132031f, 0.09493580f, -0.07653946f, 
    0.20752956f, -0.12301193f, 0.19820395f, 0.03726598f, -0.09798389f, 0.18084605f, -0.21796973f, 0.06088585f, 
    -0.69449037f, -0.21907777f, 0.41294333f, -0.31293064f, 0.22017519f, -0.27804029f, -0.03750057f, -0.11333829f, 
    -0.13083863f, -0.24571843f, -0.05946592f, 0.16181006f, -0.26549438f, -0.04263509f, -0.09301015f, 0.22400802f, 
    -0.43422511f, -0.35733733f, -0.03478003f, 0.08616926f, 0.26854408f, 0.30163044f, 0.27133694f, -0.16211139f, 
    -0.43349791f, -0.39347538f, -0.26921597f, -0.28202879f, 0.00048227f, 0.15953153f, 0.09979614f, 0.35941720f, 
    -0.01677684f, -0.41189501f, -0.58805537f, -0.36265308f, -0.00739129f, 0.18120378f, 0.00390867f, -0.13976078f, 
    -0.18991268f, -0.08328161f, -0.12141522f, -0.33376834f, -0.33125454f, -0.08065195f, -0.49028650f, -0.59171224f, 
    -0.34037101f, -0.44054392f, -0.18747960f, 0.27576110f, -0.25021702f, -0.00112954f, -0.08325793f, -0.39050493f, 
    -0.32346335f, -0.33865944f, 0.36138985f, 0.32283294f, 0.27468053f, 0.60466766f, 0.11104643f, -0.00848773f, 
    -0.21221115f, 0.01039933f, -0.12612824f, -0.20362802f, -0.06342965f, 0.33610040f, -0.12121207f, -0.01188836f, 
    0.28844655f, -1.07498860f, -0.19324756f, -0.36921474f, -0.32998675f, 0.13023093f, 0.64259791f, -0.27602944f, 
    0.19350550f, 0.54060453f, 0.70468599f, 0.06151491f, -0.10906658f, -0.04250365f, -0.08114296f, 0.05923714f, 
    -0.08633624f, -0.05246095f, -0.07329559f, 0.23454840f, -0.18580027f, -0.12980807f, 0.01528778f, 0.21195655f, 
    0.02373835f, -0.15932269f, 1.11867595f, -0.48843369f, -0.39860928f, -0.45191070f, -0.84910452f, 0.61021900f, 
    0.20543094f, 0.54354030f, -0.17928849f, -0.12094044f, 0.16821064f, -0.08489637f, 0.24249740f, -0.40203202f, 
    0.17402337f, 0.14096820f, -0.22384147f, 0.11459843f, 0.09868582f, -0.13094625f, 0.05518628f, -0.18347581f, 
    -0.22280286f, 0.01044299f, 0.08641624f, -0.53233230f, -0.66792566f, 0.14046510f, 0.61938071f, 0.28972313f, 
    0.17515200f, -0.17179061f, -0.26543716f, 0.13699888f, 0.29760331f, 0.27135628f, -0.36297393f, -0.06815178f, 
    0.40431282f, -0.07304343f, -0.08171008f, -0.16958937f, 0.03932396f, 0.23859383f, -0.04040201f, 0.14787710f, 
    0.07864347f, 0.07930097f, 0.00885296f, -0.26514995f, 0.27140409f, -0.43263519f, -0.41160482f, -0.28241470f, 
    -0.36893520f, -0.42227432f, -0.16137342f, -0.05554222f, -0.38061669f, -0.15109994f, 0.10249126f, 0.62196201f, 
    -0.02506083f, -0.43361130f, -0.22969241f, -0.18783872f, 0.27617225f, 0.11692041f, -0.21480481f, 0.34061462f, 
    0.09763060f, 0.07561029f, -0.04627782f, -0.02654950f, -0.20415133f, -0.34868661f, 0.41146243f, 0.10020232f, 
    0.05649497f, -0.22908385f, -0.13117495f, -0.24217616f, 0.23743027f, -0.15209012f, -0.08528266f, -0.12174352f, 
    0.27807504f, -0.29806024f, 0.23815398f, -0.16569744f, 0.09876931f, -0.21856347f, 0.03403362f, -0.13744687f, 
    -0.22765076f, 0.16491529f, 0.39895484f, 0.06848822f, 0.17462702f, 0.18662626f, 0.47496995f, 0.88656640f, 
    0.35817391f, -0.21176788f, -0.02131170f, -0.85851151f, -0.66748965f, -0.05479453f, 0.08670209f, -0.08230431f, 
    -0.16763990f, -0.16973713f, 0.24549869f, 0.40931669f, 0.04562480f, -0.09225143f, 0.36480224f, 0.21456015f, 
    -0.08803016f, -0.17486688f, -0.29912186f, 0.03904969f, -0.24311900f, 0.14262943f, -0.02461484f, -0.41590330f, 
    0.35317880f, 0.33291915f, 0.27148387f, 0.18947987f, -0.75464684f, -0.58280033f, 0.22842339f, -0.00285291f, 
    0.45476237f, 0.32165554f, 0.39422867f, -0.27812162f, -0.13305032f, 0.06408389f, -0.03011911f, 0.10310147f, 
    0.03199781f, -0.14740112f, -0.23924504f, 0.12780994f, -0.18331653f, 0.20450935f, 0.06193310f, -0.20363773f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06527328f, 0.07570828f, -0.09265082f, -0.26706010f, 0.32111663f, -0.12927550f, 0.01979315f, 0.03964255f, 
    -0.11783887f, 0.17850070f, 0.15542065f, -0.28153771f, -0.15282546f, 0.17347592f, -0.10884620f, -0.26770735f, 
    -0.06983399f, 0.30764598f, 0.05573433f, 0.09135605f, 0.09022148f, 0.10314010f, -0.09603409f, -0.20945476f, 
    0.06093534f, 0.23506409f, 0.21576191f, 0.31794909f, 0.07025678f, 0.03492631f, 0.01011102f, 0.21865165f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11389318f, -0.19287996f, 0.00612247f, 0.02678608f, -0.01310585f, 0.05410050f, 0.02451261f, 0.17940964f, 
    0.04129281f, 0.02701643f, 0.01996057f, 0.02983324f, 0.35855117f, -0.10029309f, 0.00669029f, 0.18618831f, 
    -0.03373134f, 0.01136987f, 0.15784353f, -0.11420813f, 0.05905209f, 0.10493392f, 0.04069469f, 0.01527915f, 
    -0.01956042f, 0.00120890f, -0.21742861f, -0.08968322f, -0.02006897f, 0.03674610f, -0.07758585f, 0.03316618f, 
    -0.04835251f, 0.09763464f, -0.01452840f, 0.06869324f, 0.20503488f, 0.08413363f, 0.13298044f, -0.09514312f, 
    -0.16155757f, -0.10040164f, -0.00295684f, -0.04537283f, -0.06573942f, -0.04442795f, -0.04555418f, 0.00711848f, 
    0.28781369f, -0.14580514f, 0.13911615f, -0.03073310f, -0.00848185f, -0.10394495f, 0.00724279f, -0.09166314f, 
    0.01806019f, 0.02181283f, 0.23150325f, 0.15743551f, 0.20779876f, 0.17951311f, 0.05629061f, -0.07298774f, 
    -0.11685794f, -0.08407991f, -0.07730211f, -0.02978308f, -0.04659487f, -0.05165970f, -0.03126348f, -0.03969863f, 
    0.03155590f, -0.05782939f, -0.12708293f, 0.10434765f, 0.03274591f, -0.04747173f, -0.06865559f, 0.06255345f, 
    -0.07546696f, 0.11107073f, 0.04959542f, 0.09945124f, 0.30834001f, -0.16728239f, -0.42253706f, 0.15728766f, 
    0.12362572f, 0.10420060f, -0.06876998f, -0.04047839f, -0.03443333f, 0.35207680f, -0.03179057f, -0.04093711f, 
    -0.02165699f, 0.04571825f, 0.06237669f, -0.11981800f, -0.01262061f, -0.06040407f, -0.07125032f, -0.00486255f, 
    0.16976020f, 0.10946773f, 0.25551552f, -0.01135277f, -0.21955679f, 0.03310950f, 0.25159094f, 0.04649564f, 
    0.04823523f, 0.04162251f, 0.08192955f, -0.12751198f, 0.07905077f, -0.07512873f, -0.00908203f, 0.09967943f, 
    0.07937369f, 0.14042258f, -0.26930302f, 0.00731678f, 0.08046301f, 0.02383598f, 0.09653725f, 0.07298318f, 
    -0.03935726f, 0.05819613f, 0.07166982f, -0.08406486f, -0.01398771f, -0.11526632f, 0.10258923f, 0.00431120f, 
    0.10638540f, -0.02165663f, 0.01186561f, -0.00995096f, 0.02841449f, -0.01981733f, -0.12488140f, -0.03577840f, 
    0.11012203f, 0.04037626f, 0.09320772f, -0.10513335f, -0.01648766f, 0.01282854f, -0.08586343f, -0.05440206f, 
    -0.08777155f, -0.07056300f, -0.03748528f, 0.01114577f, -0.04956160f, 0.03427462f, -0.09860437f, 0.11260748f, 
    0.03996184f, 0.06898006f, 0.07893054f, 0.08868702f, -0.08995385f, 0.25337318f, -0.04599427f, 0.05597032f, 
    -0.13615459f, -0.13016519f, 0.04888421f, 0.07107656f, 0.02262415f, 0.16729173f, 0.11316382f, 0.06244140f, 
    0.01413289f, -0.02079832f, 0.02868797f, 0.11659923f, 0.28330466f, -0.05945307f, 0.22663635f, 0.07627203f, 
    0.09859850f, 0.24246624f, -0.18311732f, 0.01712199f, -0.01108913f, -0.05806582f, 0.00297581f, 0.00380474f, 
    -0.21751823f, -0.01031033f, -0.13563837f, 0.18588872f, -0.03116997f, -0.12249043f, 0.13907640f, 0.09462526f, 
    0.04554775f, 0.04851050f, -0.00905551f, 0.02315228f, 0.09442020f, -0.13816611f, 0.04662628f, 0.02170809f, 
    0.01532512f, 0.11217237f, -0.11524933f, -0.04142025f, -0.02902711f, -0.06143741f, -0.13335827f, 0.11604617f, 
    -0.13644002f, 0.04620712f, 0.27603963f, -0.27694124f, 0.07665427f, 0.03989999f, 0.08753727f, 0.08253518f, 
    -0.03686238f, 0.14163114f, 0.05132546f, -0.06907387f, -0.03206123f, -0.10978976f, 0.00111511f, 0.04606126f, 
    -0.04513990f, 0.15279451f, 0.05674920f, 0.07285392f, 0.12774466f, 0.00779015f, 0.17202567f, 0.08307187f, 
    0.10929214f, 0.30740508f, -0.14785266f, -0.07524466f, 0.03590145f, 0.28427953f, -0.16600238f, -0.08539843f, 
    -0.01629045f, 0.10521215f, 0.04705545f, -0.11429994f, 0.18431512f, 0.06010729f, -0.18795517f, -0.14008757f, 
    0.16578862f, -0.07686760f, -0.02148931f, -0.07796650f, 0.00976829f, 0.04486959f, 0.05284775f, -0.04887902f, 
    0.14997250f, -0.10844100f, 0.02448622f, -0.07736679f, 0.10828257f, -0.18889424f, -0.00029854f, -0.11076750f, 
    0.10298095f, 0.03851511f, 0.00051091f, -0.12791684f, 0.08372494f, -0.13601345f, 0.20786247f, 0.15477440f, 
    0.08514050f, 0.13326193f, 0.06801131f, 0.06630723f, 0.03590048f, 0.09737308f, 0.13770151f, 0.17035486f, 
    -0.35005537f, -0.35437226f, -0.10051951f, 0.19552727f, 0.16696833f, -0.01982564f, 0.06524619f, 0.04651125f, 
    -0.09722769f, -0.07328953f, -0.01656541f, -0.00285358f, 0.46712577f, -0.03648676f, 0.06594531f, -0.10538223f, 
    0.06031187f, 0.02378277f, -0.08343852f, -0.08112282f, -0.01429258f, -0.05297479f, 0.16257444f, 0.13859017f, 
    0.14041077f, 0.14233112f, -0.02725015f, -0.12166402f, -0.17593357f, 0.02233980f, 0.28972855f, -0.02087386f, 
    -0.12577799f, 0.07366315f, 0.16231415f, 0.03738277f, 0.11676872f, 0.02275054f, 0.01633541f, -0.11183070f, 
    0.09873253f, 0.09448525f, 0.02902181f, 0.11298954f, 0.02566388f, -0.05501237f, 0.38402975f, -0.10987350f, 
    -0.00448179f, 0.05908101f, -0.19836760f, 0.01867365f, -0.12536511f, 0.02622386f, 0.06141983f, 0.05378066f, 
    0.02172326f, -0.04155111f, -0.15288626f, 0.05572066f, -0.02794568f, 0.00931305f, -0.21714047f, 0.09835104f, 
    0.11848594f, -0.20572160f, 0.00549757f, 0.05164329f, -0.05715282f, 0.01956508f, -0.02674449f, -0.02720519f, 
    0.06868266f, -0.10644440f, 0.15184258f, -0.09852417f, 0.07795484f, -0.00828881f, 0.00173177f, 0.03575211f, 
    0.02771915f, -0.08097256f, 0.09045757f, 0.10523686f, 0.41877928f, -0.02652452f, -0.01774246f, 0.04968325f, 
    0.04863307f, 0.08228984f, -0.01442476f, 0.01065599f, 0.14621805f, -0.08311714f, -0.15608539f, 0.04526246f, 
    -0.01388041f, -0.06158392f, 0.03311559f, -0.00758412f, -0.01477532f, -0.03304633f, -0.05431946f, -0.04502420f, 
    -0.02217255f, -0.08680551f, 0.00457521f, -0.00481100f, -0.04874882f, -0.02900718f, -0.07034796f, -0.01696943f, 
    -0.06174606f, -0.01987257f, -0.01710119f, -0.00584286f, -0.01206503f, -0.07890957f, -0.05231081f, -0.01844330f, 
    -0.07148629f, -0.04599138f, -0.07259110f, -0.01212544f, -0.05572636f, -0.06568043f, 0.01855251f, -0.01789156f, 
    -0.01927273f, -0.08011318f, -0.00495583f, 0.01328079f, -0.04118871f, 0.01643419f, -0.03595995f, -0.03153604f, 
    -0.06110163f, -0.05511411f, -0.02861253f, 0.01463760f, -0.00226951f, -0.07750668f, -0.04257679f, -0.01410937f, 
    -0.06470765f, -0.00237701f, -0.04895606f, -0.03033803f, 0.00957601f, -0.01541277f, -0.04682522f, -0.00176242f, 
    -0.00413458f, -0.01783604f, 0.00452582f, -0.02818426f, -0.01206397f, -0.05230692f, -0.00515011f, -0.05890162f, 
    -0.01121450f, -0.03388045f, 0.03170399f, -0.01403455f, 0.03431020f, -0.04069874f, -0.01308020f, -0.04004122f, 
    -0.01925031f, -0.06458083f, -0.01496517f, 0.00506764f, -0.01244132f, -0.01249465f, -0.07252421f, -0.00756466f, 
    -0.00803222f, -0.08479459f, -0.00401192f, 0.00614104f, -0.02482329f, -0.01577041f, -0.08032198f, -0.06731261f, 
    -0.00985741f, -0.06716578f, 0.00350017f, 0.01295373f, -0.05832138f, -0.05002279f, 0.00487715f, 0.01765662f, 
    0.01121742f, -0.02437912f, -0.04881102f, 0.01983768f, 0.03123709f, -0.00537385f, 0.01601249f, -0.07267444f, 
    -0.00757734f, -0.05091909f, -0.05244852f, -0.00760899f, -0.05154996f, -0.01159574f, 0.01070452f, -0.06014618f, 
    -0.00507973f, -0.03611025f, -0.05702759f, -0.06416335f, -0.03782101f, -0.00152022f, -0.05451575f, -0.00750198f, 
    0.00829587f, 0.00132809f, -0.04889698f, -0.04134926f, 0.03208028f, 0.01552968f, -0.07248951f, -0.05007005f, 
    0.02364282f, 0.02744039f, -0.05483298f, -0.05974706f, -0.06028385f, -0.01000699f, -0.02918774f, -0.01778621f, 
    -0.02064652f, -0.01831044f, -0.01704824f, 0.01201987f, -0.00682235f, 0.02613326f, -0.02082258f, 0.00676698f, 
    -0.00242820f, -0.05388157f, -0.00779296f, -0.01133204f, -0.07091479f, -0.06564318f, -0.07889983f, -0.01370444f, 
    -0.00533334f, -0.01034307f, 0.01905298f, -0.04076089f, -0.00589567f, -0.00605540f, -0.01149740f, -0.01513430f, 
    -0.00854389f, -0.06889026f, -0.08243870f, 0.00492145f, -0.00095282f, -0.03689778f, -0.03618661f, -0.06169324f, 
    -0.05342775f, 0.00543641f, -0.06332907f, -0.01914577f, 0.01245181f, -0.05720100f, -0.03798961f, -0.05749347f, 
    0.02996408f, 0.02806525f, 0.01838436f, -0.00020118f, -0.08401152f, -0.02534163f, -0.03649235f, 0.01745400f, 
    -0.04836996f, -0.07923683f, -0.07156374f, 0.01466520f, -0.04482763f, 0.02217986f, 0.01804504f, -0.02203642f, 
    -0.01893196f, -0.00714417f, -0.04517389f, -0.03042307f, -0.02157643f, -0.08407945f, -0.02503753f, 0.02879638f, 
    -0.00133713f, 0.00956796f, -0.05258880f, 0.00554739f, 0.03766294f, -0.02000999f, -0.01578103f, -0.02624635f, 
    0.00059972f, -0.02678186f, 0.01812908f, 0.01110024f, -0.02837041f, -0.03950934f, -0.07829790f, -0.02608232f, 
    -0.07875781f, 0.01609720f, -0.03018816f, 0.00757538f, -0.01726709f, -0.05878182f, -0.05895911f, -0.03350293f, 
    0.00075543f, -0.05824869f, 0.00776100f, 0.00047172f, -0.06820869f, 0.00910546f, -0.02896577f, -0.03902756f, 
    0.00582758f, 0.00280405f, -0.02702264f, -0.01184046f, -0.01675586f, -0.01662353f, -0.02020068f, -0.05029498f, 
    -0.00838773f, -0.01886444f, 0.00516666f, -0.00456790f, 0.02146335f, -0.03555544f, -0.02691877f, -0.06570855f, 
    0.00975647f, -0.05470924f, 0.01773400f, 0.00457343f, 0.01164502f, -0.00570040f, -0.03122962f, -0.02520876f, 
    0.01400853f, 0.03267515f, -0.03278492f, 0.01440502f, 0.00230498f, -0.01630837f, -0.03606722f, -0.02966419f, 
    -0.01719262f, -0.01079014f, -0.04840568f, -0.03762253f, -0.04509489f, -0.03072057f, -0.00106286f, -0.02323748f, 
    -0.00928331f, -0.01863047f, -0.00047262f, -0.02263426f, -0.03121147f, -0.07377063f, -0.02346540f, 0.03640406f, 
    0.03786105f, -0.04782902f, -0.04182040f, 0.01969006f, -0.06298648f, 0.00657612f, -0.00868655f, 0.03347732f, 
    -0.07093731f, -0.02336835f, -0.06876535f, -0.06152067f, -0.01198524f, -0.06370184f, 0.01469600f, -0.04260969f, 
    -0.02048364f, -0.08206570f, -0.01324425f, 0.03066694f, -0.03350567f, -0.03143975f, 0.00743306f, -0.04391438f, 
    -0.05589954f, 0.00461335f, -0.03006249f, -0.06783177f, 0.00197309f, -0.05765629f, -0.04798585f, -0.02471512f, 
    0.00508988f, -0.00317147f, -0.01055651f, -0.03843446f, -0.03475878f, -0.02368986f, 0.01094628f, -0.00112476f, 
    0.00765092f, 0.01366859f, -0.04145022f, -0.03928313f, -0.04076512f, -0.00982944f, -0.03599069f, -0.02585518f, 
    -0.05812128f, -0.01166025f, -0.05132927f, -0.03852880f, -0.03216044f, -0.00832343f, -0.01252997f, 0.01109175f, 
    -0.03983937f, -0.06621795f, -0.02352746f, -0.02160498f, -0.03595812f, -0.04160515f, 0.00360854f, -0.01025928f, 
    -0.03093268f, -0.05478006f, -0.04481206f, -0.05842151f, -0.00661543f, -0.03299924f, -0.00537968f, 0.00966240f, 
    -0.07397144f, -0.07275328f, -0.04680161f, -0.03552945f, -0.06960530f, 0.02361027f, 0.02730510f, -0.00373266f, 
    0.03619329f, 0.03899704f, -0.05323436f, -0.01281123f, -0.06758113f, -0.05607559f, -0.06694790f, -0.02752742f, 
    -0.04815691f, -0.06959301f, -0.01457295f, 0.00816579f, -0.00313487f, -0.01633667f, -0.06182958f, -0.05424755f, 
    -0.04610367f, -0.06847375f, -0.04386563f, -0.03496873f, -0.07366628f, -0.04832630f, -0.02462986f, -0.05148287f, 
    0.10257544f, -0.19938360f, -0.14690442f, -0.07445397f, 0.14227177f, 0.26560125f, -0.06308047f, 0.18179809f, 
    -0.03117492f, -0.11561940f, 0.06535608f, -0.15626168f, 0.49439389f, -0.32970941f, -0.10541886f, 0.03850738f, 
    -0.02584260f, 0.08421201f, 0.08037620f, -0.13775052f, 0.19744244f, -0.17925635f, 0.00976411f, -0.06106997f, 
    0.25269696f, 0.17014854f, -0.03184880f, -0.12558241f, -0.09982023f, -0.03223485f, 0.02804906f, 0.01392521f, 
    0.03373694f, -0.03350622f, -0.01353210f, 0.00382712f, -0.02140616f, 0.10419482f, 0.20831619f, -0.05802774f, 
    -0.02473198f, -0.04797325f, -0.02040744f, 0.01951101f, 0.09850503f, -0.01692216f, 0.04910680f, 0.12476218f, 
    -0.15303765f, 0.02492374f, 0.00654281f, -0.08737563f, 0.05090437f, -0.03749966f, -0.01899336f, -0.03218545f, 
    0.07101383f, -0.05601855f, 0.07077325f, 0.14388764f, 0.09884887f, 0.02021771f, 0.13889086f, -0.05062060f, 
    -0.03963460f, -0.14949468f, -0.07005960f, -0.04933555f, 0.01987087f, 0.01186907f, 0.07100706f, 0.04235528f, 
    -0.14127040f, 0.03979449f, 0.00306263f, 0.20260882f, 0.04716591f, -0.17624278f, -0.02594662f, 0.03357260f, 
    -0.19722536f, 0.11389365f, -0.03804275f, 0.06742682f, 0.00124385f, 0.07316085f, -0.42164245f, 0.12250577f, 
    -0.22092293f, 0.04972026f, 0.11618511f, -0.15334889f, -0.13963903f, 0.08663726f, 0.01136303f, 0.18884851f, 
    -0.10734493f, 0.14082888f, 0.06365840f, 0.10580432f, 0.05444972f, -0.01134690f, -0.03942813f, 0.02029658f, 
    0.07556195f, 0.03615341f, -0.01980232f, -0.10270309f, 0.27054554f, 0.02586862f, 0.06514636f, -0.12924738f, 
    -0.10400718f, -0.06473745f, 0.08252508f, 0.10929704f, 0.18132560f, -0.09717388f, 0.02338049f, 0.03307492f, 
    0.10491384f, 0.07177802f, 0.03752077f, 0.06995524f, -0.03503036f, 0.01622684f, 0.03725644f, -0.06996558f, 
    0.03477602f, -0.03849807f, 0.06624655f, 0.13884254f, 0.43882266f, 0.53855747f, 0.25175542f, -0.17501338f, 
    0.19653691f, 0.02535382f, -0.03516995f, 0.15448533f, -0.02944599f, -0.10206913f, -0.01842559f, 0.07911018f, 
    -0.11546044f, 0.04098643f, 0.12828141f, -0.05522278f, -0.01832164f, -0.03566995f, -0.05586291f, -0.02735513f, 
    0.00717376f, 0.05350852f, 0.01544196f, 0.22235245f, 0.03136705f, -0.37746111f, -0.26576710f, -0.13072152f, 
    -0.03254123f, 0.09998725f, 0.11553434f, -0.05312780f, 0.21201807f, 0.05722959f, 0.14515276f, -0.03954605f, 
    -0.12482508f, 0.08908945f, -0.01132380f, 0.13686757f, 0.11933243f, 0.12496565f, -0.12861748f, 0.15436728f, 
    -0.05654380f, -0.06466071f, 0.09419289f, -0.18258438f, -0.01301658f, 0.02997313f, -0.00945394f, -0.34835261f, 
    0.07018325f, 0.23710619f, -0.19237544f, 0.17252615f, -0.01301667f, -0.05285368f, -0.02868054f, -0.07394422f, 
    0.13740484f, 0.15572599f, -0.03989141f, -0.02843632f, -0.10498302f, -0.04809222f, -0.01907557f, 0.11186775f, 
    -0.08346992f, -0.09444054f, 0.00691217f, -0.07217085f, 0.02748011f, 0.13766038f, -0.08218386f, -0.12378085f, 
    -0.01812895f, 0.02916295f, -0.03518856f, 0.06147493f, -0.09234333f, -0.03500826f, 0.06003699f, -0.05918383f, 
    0.12628335f, 0.00747848f, 0.03081752f, -0.27588204f, 0.04163893f, -0.02744693f, -0.00103138f, 0.19256902f, 
    -0.05924251f, 0.02594380f, -0.01144527f, 0.02516195f, -0.09471054f, -0.42484829f, -0.17516552f, 0.02236682f, 
    0.03099224f, 0.24532087f, 0.04019776f, 0.06371406f, -0.11491972f, -0.01963397f, 0.06983164f, 0.01982533f, 
    -0.20284750f, 0.26068559f, -0.34279752f, 0.25712827f, -0.07297482f, -0.04079065f, -0.19986780f, -0.07167448f, 
    -0.02106273f, 0.15294796f, -0.01160921f, 0.00315802f, 0.44644243f, -0.09494172f, 0.08737517f, -0.32005841f, 
    -0.04472427f, -0.24207743f, 0.16143981f, -0.06329522f, 0.02412976f, 0.11204916f, -0.08387212f, 0.06929635f, 
    -0.02045995f, -0.00121831f, 0.25036049f, -0.10472053f, 0.26580736f, 0.04756222f, 0.02778310f, -0.17404090f, 
    0.14434725f, 0.01035870f, -0.03933641f, 0.12900648f, 0.28360346f, -0.05556148f, 0.07623433f, 0.14713891f, 
    0.03328359f, -0.01784138f, -0.03614555f, -0.14203300f, -0.01625388f, -0.08453652f, -0.17515053f, -0.14441222f, 
    0.24272670f, -0.00534496f, -0.01630126f, -0.08471164f, 0.12786999f, 0.08768164f, 0.17845421f, 0.06961259f, 
    0.07272573f, 0.15096746f, 0.00494573f, 0.08765109f, 0.52475375f, -0.12068444f, -0.19324079f, -0.34374326f, 
    -0.14953379f, 0.06944445f, 0.02125191f, 0.08803823f, 0.11252410f, -0.07928874f, 0.04883922f, 0.03932448f, 
    0.38644519f, -0.21691485f, -0.26743090f, 0.08267665f, -0.01975756f, 0.04244777f, 0.09594660f, -0.08030094f, 
    0.04849548f, -0.12566549f, -0.16845059f, 0.02485163f, 0.49160942f, -0.09450337f, 0.11954233f, -0.37470540f, 
    0.00951246f, 0.02012447f, 0.01807828f, 0.09150602f, -0.02266409f, 0.04525748f, 0.05822698f, -0.03742906f, 
    0.29332730f, 0.15857723f, -0.15300624f, 0.07583021f, 0.09904166f, -0.02847528f, -0.00135811f, -0.01660328f, 
    0.01646237f, -0.10775432f, 0.12370998f, 0.09319580f, -0.04942489f, 0.09450869f, -0.00757011f, 0.23680872f, 
    0.03306147f, 0.10589656f, -0.08728855f, -0.01403831f, -0.04733992f, 0.02458427f, 0.03783423f, 0.13681749f, 
    -0.28339672f, 0.15026136f, -0.03261292f, 0.07373417f, 0.04818289f, -0.05121350f, 0.06651722f, -0.10401309f, 
    0.11743134f, -0.01920449f, 0.13138229f, -0.01639126f, -0.02161701f, -0.01732714f, 0.02536965f, -0.11822119f, 
    0.08634683f, 0.01529724f, 0.07881991f, -0.02773906f, 0.09123933f, 0.00255425f, -0.06228519f, 0.01280098f, 
    -0.15117070f, 0.09145314f, 0.18068057f, 0.05274838f, 0.04157300f, 0.08538408f, 0.02634070f, -0.07581674f, 
    0.05255479f, 0.11994658f, -0.10003167f, 0.08833243f, -0.17411368f, 0.66720796f, 0.10873868f, -0.04494904f, 
    0.06669708f, 0.15157762f, 0.07286977f, -0.20585385f, 0.12142211f, 0.08349079f, 0.09189443f, 0.14406112f, 
    -0.03761173f, -0.13822648f, 0.21253124f, -0.15176755f, -0.06191589f, -0.05829021f, -0.14700338f, -0.05351070f, 
    0.17414448f, 0.11993530f, 0.03438430f, 0.21105283f, -0.36099079f, -0.20632814f, -0.05572329f, -0.17340040f, 
    -0.06348255f, -0.20491961f, -0.14516652f, -0.01161730f, -0.00413224f, -0.13889931f, -0.07743918f, -0.12167751f, 
    0.05447149f, 0.14908212f, 0.18902530f, -0.05989888f, -0.05561096f, 0.10875237f, 0.03320702f, -0.02119562f, 
    0.19950509f, 0.22284152f, -0.07779893f, -0.02035296f, -0.44683844f, -0.15478332f, -0.16940391f, -0.07081480f, 
    -0.16808431f, -0.08731871f, -0.11824623f, -0.11371014f, -0.05132378f, -0.04242825f, -0.12204194f, 0.02031749f, 
    0.29675138f, -0.08968688f, -0.03863346f, -0.11012836f, -0.15074795f, -0.18413332f, 0.15784918f, 0.02097624f, 
    -0.03893293f, 0.10077212f, -0.08782225f, 0.03938140f, 0.35700572f, 0.27037415f, 0.23931739f, 0.23991576f, 
    -0.11041765f, -0.14330976f, 0.02707052f, -0.08040886f, 0.00141657f, 0.05150394f, -0.08992245f, 0.16423605f, 
    0.01977503f, -0.08488546f, -0.10560787f, -0.04077956f, -0.14305346f, -0.11292145f, -0.22703007f, -0.13489911f, 
    -0.10485957f, 0.03063917f, -0.06927504f, -0.11012428f, -0.15908119f, -0.08108386f, -0.07052593f, 0.10293101f, 
    0.00433794f, 0.13432552f, 0.13554852f, -0.04221343f, 0.06615798f, 0.09782335f, 0.07013967f, 0.03067230f, 
    0.16353555f, -0.15390351f, -0.36910221f, -0.09594402f, -0.03326776f, -0.20080319f, 0.11192083f, -0.05550467f, 
    0.02067045f, 0.09422820f, 0.13988733f, 0.24731065f, -0.41722503f, -0.36084041f, -0.07287210f, 0.22115849f, 
    -0.01692450f, -0.01490840f, -0.04516881f, -0.06746749f, 0.05205179f, 0.12922476f, 0.01589864f, 0.12409268f, 
    -0.28111807f, -0.17709038f, -0.13466008f, -0.08104661f, -0.08841395f, -0.11993381f, -0.08259480f, -0.02268936f, 
    0.06261688f, 0.01673627f, -0.04734391f, 0.02712916f, 0.04596220f, 0.42958623f, 0.16382983f, 0.19614971f, 
    -0.11992651f, -0.02256181f, 0.08807300f, 0.13026708f, 0.26432422f, 0.13834299f, 0.00666514f, 0.02848203f, 
    0.05189937f, -0.22158420f, 0.25700477f, 0.04322876f, 0.27311558f, 0.03018722f, -0.03647323f, -0.05442424f, 
    -0.01814741f, 0.05668278f, -0.04030630f, -0.08393030f, -0.07730844f, -0.12819293f, -0.07977639f, 0.48677918f, 
    0.22493750f, -0.14747453f, -0.00180069f, 0.08649792f, -0.16746941f, 0.03199091f, -0.08493020f, 0.00472789f, 
    -0.08303923f, -0.30405459f, -0.03076421f, 0.14565684f, 0.13773511f, 0.18421851f, -0.01737542f, -0.23840520f, 
    0.03666038f, -0.02584328f, -0.03189403f, 0.06777712f, -0.12666439f, -0.22608104f, 0.13055888f, 0.14493191f, 
    0.14260218f, 0.15947632f, -0.02360702f, -0.03445909f, 0.02076886f, -0.07117339f, 0.00906244f, 0.01648415f, 
    -0.08499809f, 0.08568586f, -0.05047585f, 0.08980206f, -0.10014382f, 0.03552010f, 0.06924421f, 0.02631491f, 
    -0.06208299f, -0.09330819f, -0.02799273f, 0.08270951f, 0.15604250f, 0.14270157f, -0.18715580f, 0.28075287f, 
    0.10953622f, -0.01025791f, 0.09814955f, 0.06063354f, 0.07283591f, -0.04264816f, -0.04828539f, -0.02391579f, 
    0.30025539f, 0.09923320f, -0.10783519f, -0.17667983f, 0.01786954f, -0.06753251f, 0.00287219f, -0.05354784f, 
    -0.02440005f, 0.00712934f, 0.01682146f, 0.11342181f, -0.20440052f, 0.13523175f, -0.05136511f, 0.39996791f, 
    -0.01140432f, 0.14393075f, -0.04463752f, 0.19089012f, -0.00405607f, -0.01894342f, 0.04723914f, 0.11419167f, 
    0.02805982f, -0.18552069f, -0.02720064f, 0.11762249f, -0.07892240f, 0.06192839f, 0.01254405f, 0.10971482f, 
    0.15601833f, 0.14353879f, 0.10641994f, 0.23525973f, -0.12920119f, 0.11466409f, -0.15752216f, 0.15799746f, 
    -0.01224886f, 0.03617518f, 0.03407927f, -0.00925912f, 0.06662491f, -0.01458365f, -0.01292424f, -0.26769173f, 
    -0.21690336f, -0.20873314f, -0.07593723f, -0.09786702f, 0.12574165f, 0.05329326f, -0.14817984f, 0.08583363f, 
    -0.07463715f, 0.01863203f, 0.01711004f, 0.12860183f, -0.08370367f, -0.10277246f, 0.04332181f, 0.12609623f, 
    0.05042827f, -0.06175587f, 0.01819535f, 0.04135450f, -0.10735799f, 0.12055030f, 0.13280031f, 0.05965949f, 
    0.13696727f, 0.44905365f, 0.03193391f, 0.45077103f, 0.13918060f, 0.03161887f, -0.10972530f, -0.05230350f, 
    0.19906548f, 0.07857378f, 0.18129198f, 0.17318498f, -0.20698683f, 0.25380412f, -0.13982780f, -0.35735542f, 
    -0.04371963f, 0.07373878f, -0.04801742f, 0.13784769f, -0.05935219f, 0.07778503f, 0.05225222f, -0.00025852f, 
    -0.25844771f, -0.18336976f, 0.08058338f, 0.10098088f, -0.00338799f, 0.15535448f, 0.05530097f, -0.14710812f, 
    0.02721541f, -0.00424771f, -0.03973702f, 0.01871862f, 0.13169156f, -0.08058513f, -0.19650148f, -0.09922346f, 
    0.15542327f, -0.02751553f, 0.06239873f, 0.08302592f, 0.00588174f, 0.17449707f, 0.18839414f, 0.06135333f, 
    -0.20858474f, -0.41400179f, -0.19369721f, 0.04841386f, -0.05085580f, 0.16243096f, 0.08337620f, -0.05832288f, 
    -0.11066342f, 0.01034864f, -0.06258254f, -0.00469065f, 0.36790401f, 0.09613703f, -0.21584237f, -0.19520354f, 
    0.08679377f, -0.27920356f, -0.02115040f, 0.14059423f, 0.03620092f, 0.04518683f, 0.13222854f, -0.12016518f, 
    0.01918160f, 0.16454157f, 0.10235266f, 0.12261686f, -0.07123011f, -0.01445032f, -0.00269873f, -0.12310871f, 
    0.17568669f, 0.01446135f, 0.00754647f, 0.01582673f, 0.12209277f, 0.18863879f, 0.21663353f, -0.19373940f, 
    0.10933641f, 0.02530820f, 0.02164125f, -0.03467886f, 0.13114336f, 0.08284514f, 0.16521502f, -0.09788100f, 
    0.25247329f, -0.17840670f, 0.28627416f, -0.06049737f, -0.10022285f, -0.10529105f, 0.08151323f, 0.05700671f, 
    -0.08833610f, -0.04219767f, -0.12122387f, -0.02900655f, 0.20034781f, 0.03898572f, 0.10565157f, 0.13827956f, 
    0.00793098f, -0.03586077f, 0.07722282f, 0.00137685f, 0.04454970f, 0.03366535f, -0.00513825f, 0.04890054f, 
    -0.13958403f, 0.07288141f, -0.04459146f, 0.15311648f, 0.03979314f, 0.04322366f, 0.02946690f, -0.00789505f, 
    -0.00990315f, 0.17103077f, 0.03668329f, 0.00606247f, 0.02042576f, 0.02463544f, -0.00810628f, 0.14107575f, 
    -0.05072692f, -0.05005863f, 0.01477595f, 0.05423902f, 0.06117576f, 0.06169386f, 0.04038208f, 0.06238709f, 
    -0.08727140f, 0.05826709f, 0.07651918f, 0.04531360f, -0.14638676f, 0.00282379f, 0.00699140f, 0.10495798f, 
    -0.07358879f, 0.03004949f, -0.10547768f, -0.09324347f, -0.54288930f, 0.21075551f, 0.10627062f, 0.02286848f, 
    0.04661668f, -0.11329903f, 0.11231427f, -0.02529671f, 0.03222612f, 0.03780957f, -0.17871144f, -0.00843639f, 
    0.01386672f, 0.05762998f, -0.02726029f, 0.14318472f, 0.03088218f, -0.08205271f, -0.02613096f, 0.00812764f, 
    0.03340996f, 0.10254541f, -0.10480605f, 0.11837646f, 0.17502302f, -0.36883169f, 0.06854630f, -0.00457346f, 
    0.00373861f, 0.01180605f, -0.02096307f, 0.12345975f, 0.17955467f, 0.02518482f, -0.00347052f, 0.00805663f, 
    -0.34445468f, 0.05471219f, 0.09669548f, 0.11743951f, -0.14664121f, 0.09190600f, 0.08375490f, -0.01691653f, 
    0.03055255f, -0.09219567f, -0.05508181f, 0.06580304f, 0.04526107f, 0.03822386f, -0.01508214f, 0.12509942f, 
    -0.06197869f, 0.04903999f, -0.01306597f, 0.00640922f, 0.00905348f, -0.03677833f, 0.00544964f, 0.01738784f, 
    0.08991297f, -0.07900781f, 0.01093751f, 0.09522640f, 0.01596915f, -0.01175478f, 0.01117401f, 0.02254569f, 
    0.02104434f, 0.02067201f, -0.03844717f, -0.01067714f, 0.13031863f, 0.28356299f, 0.14875866f, -0.21952121f, 
    -0.14374365f, 0.08612610f, 0.05423341f, -0.02930679f, 0.12345297f, -0.06325886f, 0.02983498f, -0.00237980f, 
    0.15959144f, -0.11592124f, 0.10112532f, 0.01740719f, 0.08651137f, -0.11687633f, -0.17201081f, 0.01154502f, 
    -0.03879215f, 0.14934392f, -0.04055201f, -0.00037377f, -0.34459600f, 0.32570314f, 0.08162809f, 0.20109706f, 
    -0.07940802f, -0.12542675f, -0.06152204f, 0.05144888f, -0.01136300f, 0.07759984f, 0.09241609f, -0.13086188f, 
    -0.03938945f, -0.03994134f, 0.03250683f, -0.33020008f, -0.03596270f, 0.00475434f, -0.07328767f, -0.00376300f, 
    -0.07616306f, 0.00836889f, -0.01035703f, -0.01418938f, -0.02619469f, 0.11297845f, -0.15900636f, -0.14238973f, 
    0.17103463f, 0.06995856f, -0.05348441f, 0.03792669f, 0.04602411f, 0.06278305f, 0.04080119f, -0.08413982f, 
    0.06844221f, 0.23962905f, -0.18308823f, -0.00957924f, 0.07785335f, -0.04202947f, -0.04277495f, -0.04918984f, 
    0.02812472f, -0.04283237f, -0.12369583f, 0.04857088f, 0.06953226f, 0.12050894f, 0.10451807f, -0.00421434f, 
    0.09171414f, -0.04602525f, -0.11404647f, -0.13725364f, 0.05364626f, -0.00464254f, 0.03075922f, 0.04680746f, 
    0.01901275f, -0.02871156f, 0.15521798f, -0.38222200f, -0.02186281f, -0.04406363f, 0.05426984f, 0.04523170f, 
    0.04519334f, -0.00230163f, -0.07963724f, 0.03766083f, -0.06116928f, -0.27480939f, -0.06489983f, 0.29791182f, 
    0.01652753f, -0.03104112f, 0.13639587f, 0.06070148f, -0.07653367f, 0.07951476f, -0.00037937f, 0.15899047f, 
    -0.12472378f, -0.05649670f, 0.09620197f, -0.06912289f, 0.09948210f, 0.16893788f, 0.12317549f, 0.02596324f, 
    0.00292523f, 0.01120580f, 0.05290497f, -0.07279778f, -0.19430116f, 0.18510848f, -0.04084611f, 0.00666156f, 
    -0.13692883f, -0.07218742f, -0.10062053f, -0.14899650f, -0.12640396f, -0.04726097f, -0.11904763f, -0.02073503f, 
    0.07152503f, 0.08667098f, 0.13060440f, -0.02277169f, -0.08115644f, -0.04602604f, 0.05059513f, -0.05332574f, 
    0.05648826f, 0.10385400f, 0.02427063f, 0.03294509f, -0.27942124f, 0.41978654f, -0.05017713f, 0.15549515f, 
    -0.08254602f, -0.02222226f, -0.05100891f, 0.07731201f, 0.14200176f, 0.05531633f, -0.13671723f, -0.06409632f, 
    0.62686956f, 0.07936424f, 0.11756437f, 0.01748759f, 0.12722029f, 0.03333051f, -0.21203689f, -0.20455483f, 
    0.16888273f, -0.11747818f, -0.09613261f, -0.00429963f, 0.03219189f, 0.01228584f, -0.10390463f, 0.06023956f, 
    -0.13768582f, -0.08375857f, 0.12372224f, 0.05048499f, 0.06993272f, 0.04588317f, -0.20716931f, 0.04658348f, 
    0.05265617f, -0.04171133f, 0.16799857f, -0.00894158f, 0.08619739f, -0.07993472f, -0.14253275f, -0.13825382f, 
    0.04272014f, -0.08787324f, 0.00718040f, 0.03942457f, -0.11305737f, 0.05050013f, 0.13955744f, 0.07744503f, 
    -0.09933168f, 0.06810156f, 0.04135995f, -0.03247321f, 0.08116397f, -0.13159901f, 0.04436646f, -0.01901318f, 
    -0.20085935f, 0.21764812f, -0.15814495f, -0.00326068f, 0.11219833f, 0.02055848f, -0.03857192f, -0.16561234f, 
    0.10686730f, 0.04843245f, -0.07654919f, 0.12373134f, -0.37582445f, -0.03511004f, 0.12863404f, 0.16400696f, 
    -0.08477066f, -0.05007173f, -0.05355625f, 0.15640774f, 0.11406936f, -0.03847270f, 0.09262158f, 0.03711561f, 
    0.09140909f, 0.10910884f, 0.04249097f, 0.33276132f, -0.07541046f, 0.11379588f, 0.07964297f, -0.03603552f, 
    0.27243802f, -0.08588869f, 0.02093763f, 0.09181116f, 0.27199572f, 0.02803223f, -0.05302106f, -0.13380930f, 
    -0.01580797f, 0.14670475f, 0.11606150f, -0.03693851f, -0.03270533f, -0.06610575f, 0.12555534f, -0.01844152f, 
    0.14531909f, -0.12408050f, 0.13645887f, -0.16713484f, 0.14228669f, -0.02763475f, 0.16560994f, 0.03319368f, 
    -0.10096309f, 0.06485282f, -0.11292304f, -0.07677449f, -0.63921201f, -0.51062047f, -0.18327896f, -0.21729366f, 
    0.02963222f, -0.11687766f, -0.04372434f, 0.00840899f, -0.03510047f, 0.04874008f, 0.01567172f, 0.14055745f, 
    -0.46974960f, -0.23555495f, -0.26294503f, 0.09185342f, 0.01363323f, 0.04014038f, -0.13986909f, -0.11595384f, 
    -0.10474861f, -0.00854168f, 0.06810769f, -0.00253879f, -0.34875786f, -0.29484832f, -0.18951333f, -0.17362769f, 
    -0.06581900f, -0.10852051f, -0.08743872f, 0.07698969f, 0.07253882f, 0.03906295f, 0.12200269f, 0.12163295f, 
    -0.23806122f, -0.19904889f, -0.02743813f, 0.06280408f, -0.13655008f, -0.04982856f, -0.03949973f, 0.16622214f, 
    0.04550219f, 0.07488069f, -0.26763386f, -0.05359437f, -0.01572586f, -0.07329746f, -0.11144183f, -0.02308477f, 
    -0.01169302f, 0.00567423f, -0.04702228f, 0.00051856f, -0.09280015f, -0.09323160f, -0.30358902f, -0.13811113f, 
    -0.33876151f, -0.18024971f, -0.25317979f, -0.09434579f, 0.04813832f, -0.02123947f, -0.14376746f, -0.00890238f, 
    -0.06671396f, 0.07238503f, -0.06336237f, -0.07630337f, 0.25211942f, 0.00293984f, 0.16605054f, 0.02791257f, 
    0.00833485f, 0.07666183f, -0.00217752f, 0.30441025f, 0.17388141f, -0.04917152f, -0.00290466f, -0.06609417f, 
    -0.17470601f, 0.12854163f, 0.02496891f, 0.06705157f, -0.07496610f, -0.10229290f, -0.03966564f, 0.07503595f, 
    -0.07266901f, 0.03941699f, -0.11691477f, -0.05979645f, 0.07808825f, 0.02530977f, 0.05606074f, 0.28763106f, 
    -0.02176490f, 0.10632762f, 0.03606795f, 0.00932477f, 0.05520479f, 0.05586319f, -0.09817116f, -0.15888925f, 
    -0.28614384f, -0.34221265f, -0.21916158f, -0.14014719f, 0.14052123f, -0.03311839f, 0.01818642f, 0.01587784f, 
    -0.09160165f, 0.12784332f, -0.00404524f, 0.05098876f, 0.19828731f, 0.29659858f, 0.14832495f, 0.07110074f, 
    -0.08838772f, 0.12743372f, 0.12154392f, -0.09316665f, 0.02571962f, -0.14884312f, 0.01765569f, -0.01115857f, 
    0.39640680f, 0.10974377f, -0.01077019f, 0.23769493f, 0.26103267f, -0.01455703f, -0.12949412f, 0.03708180f, 
    -0.00786278f, 0.06477778f, -0.05446931f, 0.02349667f, 0.11236314f, 0.24440397f, 0.22466311f, 0.33871022f, 
    -0.04283990f, 0.02736659f, -0.04342892f, 0.14406341f, 0.07924460f, 0.11191591f, 0.05812671f, -0.09394120f, 
    0.04700600f, 0.22730510f, 0.15099949f, -0.13601017f, -0.02287779f, -0.04065706f, -0.02270165f, 0.13721068f, 
    -0.06222270f, 0.03322089f, -0.04878366f, -0.16048205f, -0.09454945f, 0.25669995f, 0.08585931f, 0.17778589f, 
    0.13889977f, 0.01953579f, 0.01655707f, 0.19071649f, -0.07798636f, 0.06233653f, -0.07323646f, -0.11125173f, 
    0.09454012f, 0.06423479f, -0.01311285f, -0.27602386f, -0.06632949f, -0.03673418f, -0.04283805f, 0.10019613f, 
    -0.00432414f, -0.11000025f, -0.07447971f, -0.05155878f, -0.00228310f, 0.02791428f, 0.12768161f, 0.36179096f, 
    0.07165547f, 0.10363964f, 0.00825835f, 0.01129702f, -0.00038670f, -0.04368308f, 0.14902969f, 0.02114630f, 
    -0.26303431f, -0.05693002f, 0.20922099f, -0.15191630f, 0.03654656f, 0.12817222f, -0.16116363f, -0.09866872f, 
    -0.02462841f, -0.04424717f, -0.05330374f, -0.10473362f, 0.01780380f, -0.05438527f, -0.02974621f, 0.07158157f, 
    -0.05558383f, -0.26154181f, 0.05771450f, 0.17157516f, 0.13193144f, 0.13234343f, -0.12518626f, 0.05983413f, 
    0.07002725f, 0.09179319f, 0.15555459f, 0.12902613f, 0.09921537f, 0.09443915f, 0.04257935f, -0.03304917f, 
    -0.04316100f, -0.10018110f, 0.06118963f, -0.36753398f, -0.17271288f, 0.01509448f, 0.15036774f, 0.07972877f, 
    0.05534764f, 0.00510168f, -0.07446544f, -0.15727635f, 0.07378532f, 0.11147887f, 0.00601693f, 0.12077076f, 
    0.27728742f, 0.13850084f, 0.19801427f, 0.17679459f, 0.01417954f, 0.15244405f, 0.05981720f, 0.15063164f, 
    0.22252208f, 0.02461886f, 0.09871614f, 0.06951015f, 0.30164006f, 0.26650643f, 0.02275358f, 0.14373268f, 
    0.12326702f, 0.04090155f, 0.05906128f, 0.09138256f, 0.12040029f, -0.14185497f, -0.02433613f, 0.08602693f, 
    0.09912849f, 0.23870987f, 0.17786628f, 0.23964797f, 0.05261169f, 0.14585677f, -0.09902697f, -0.32002920f, 
    -0.12129506f, -0.26120776f, -0.01290238f, 0.08312814f, -0.14823700f, 0.01359384f, -0.07442409f, -0.19952281f, 
    -0.09699657f, -0.14466906f, -0.01405507f, -0.01433059f, -0.00915723f, -0.01243290f, -0.13712732f, 0.09245495f, 
    0.13653658f, 0.06030618f, 0.03709270f, 0.15932569f, 0.11853231f, -0.11902962f, 0.00535753f, 0.10081711f, 
    0.10912431f, -0.06375488f, -0.00272823f, -0.00876938f, 0.06119414f, 0.21077091f, 0.29249412f, 0.01319837f, 
    -0.01809210f, 0.06513403f, -0.00400744f, -0.02365899f, 0.02398477f, -0.08837469f, -0.00298094f, 0.01895191f, 
    -0.34203181f, 0.04455779f, 0.02836822f, 0.11008955f, 0.01906720f, 0.12928884f, -0.17031039f, -0.16453598f, 
    0.04833285f, -0.00326177f, 0.03812600f, 0.02296418f, -0.53327870f, -0.22155765f, 0.04698598f, -0.10962203f, 
    -0.03613060f, -0.10461942f, 0.03537717f, 0.07546951f, 0.05047340f, 0.01936997f, 0.01274487f, 0.07219165f, 
    -0.17934026f, -0.07427970f, -0.07215185f, 0.06502323f, 0.03083124f, 0.05312567f, 0.14675049f, 0.09932640f, 
    0.07748939f, 0.14525183f, -0.01003834f, 0.16708753f, 0.25785884f, 0.34234273f, 0.33965763f, 0.20758256f, 
    -0.03658186f, -0.06932783f, -0.02264758f, -0.08757933f, 0.01732268f, 0.11746716f, 0.04503470f, -0.03978182f, 
    -0.05638029f, -0.11583018f, 0.05123723f, -0.10665138f, 0.04417666f, 0.05163089f, -0.00414553f, -0.00654934f, 
    -0.06665904f, 0.13065040f, 0.00635902f, 0.08998855f, 0.30510560f, 0.24653776f, 0.07164579f, 0.21096285f, 
    -0.23335400f, -0.03625994f, 0.02478411f, -0.01443853f, -0.16189618f, 0.07247105f, -0.03522216f, 0.07263412f, 
    0.18142971f, 0.24011648f, 0.18670097f, 0.17588314f, -0.00427997f, -0.04326721f, -0.04565904f, -0.01900386f, 
    -0.06303661f, 0.15184140f, 0.21045153f, 0.08336873f, 0.31244338f, 0.35436115f, 0.12424176f, 0.12955028f, 
    -0.22233209f, -0.08113632f, -0.04551455f, -0.03742564f, -0.06498753f, 0.09048786f, 0.01891723f, -0.07141616f, 
    0.01397612f, -0.04869860f, 0.14710850f, 0.13229769f, -0.19869429f, 0.04378328f, -0.05354108f, 0.12028053f, 
    -0.08207423f, 0.07229377f, -0.04444646f, 0.15133974f, 0.06261180f, -0.10617046f, 0.12316201f, 0.06511361f, 
    0.14499781f, 0.13256072f, -0.00090731f, 0.00365469f, 0.11705966f, 0.08535048f, -0.17793649f, -0.19580643f, 
    0.14611438f, 0.07444198f, 0.17267728f, -0.01060587f, -0.06635690f, -0.04218953f, -0.11782037f, -0.03394120f, 
    0.12875362f, 0.11591455f, 0.17500672f, 0.03027189f, -0.11267843f, -0.05061534f, 0.02896051f, 0.24151729f, 
    0.00682149f, 0.06746560f, 0.03623403f, -0.07320831f, 0.10507407f, -0.12099213f, 0.07081880f, 0.04278849f, 
    -0.11725295f, 0.12686384f, 0.06004407f, -0.06924867f, -0.04177207f, 0.00030143f, 0.01271626f, 0.06188481f, 
    -0.05789913f, 0.10162680f, 0.04894697f, -0.02483914f, -0.04348550f, -0.06302401f, -0.08730596f, 0.05782713f, 
    -0.01923870f, 0.05164764f, -0.04295744f, -0.16417535f, 0.00173313f, 0.03633676f, -0.03278664f, -0.09921499f, 
    0.22410347f, 0.15034491f, 0.00126106f, 0.06402238f, -0.03483984f, -0.04964227f, -0.17373925f, -0.02459720f, 
    -0.08939841f, 0.03917172f, -0.04673318f, -0.15989403f, -0.13800274f, 0.28813049f, 0.01472725f, -0.00700667f, 
    -0.08222499f, 0.12546292f, 0.06304739f, 0.08128920f, -0.04973103f, 0.12923737f, -0.12420707f, 0.05023465f, 
    0.14207788f, -0.15356570f, 0.08111230f, 0.01110322f, -0.01500578f, 0.08028392f, 0.01351390f, 0.15838538f, 
    -0.01535150f, -0.00000207f, -0.00887143f, 0.02124710f, 0.35276100f, 0.31069577f, 0.30000260f, 0.23263431f, 
    -0.04635198f, 0.02384255f, -0.11451035f, 0.00104384f, -0.15835790f, -0.02963636f, 0.02038881f, -0.22075804f, 
    -0.26464206f, -0.31536162f, -0.03834642f, -0.23063929f, -0.13250661f, -0.17339425f, 0.13711654f, 0.11637213f, 
    0.02669990f, 0.07322795f, 0.14981098f, 0.15570496f, 0.11417181f, 0.04279897f, 0.02145671f, -0.09945998f, 
    -0.09635774f, -0.06651369f, -0.23615021f, -0.01695993f, -0.10082132f, -0.07179613f, -0.11850654f, 0.01766996f, 
    -0.28154048f, 0.24305438f, 0.06960238f, 0.14679193f, 0.10417640f, 0.03174506f, -0.08927814f, 0.01202916f, 
    -0.24417511f, 0.10979578f, 0.12050274f, 0.06244379f, 0.01583174f, -0.08266079f, -0.05115863f, 0.13054827f, 
    0.02944885f, 0.03540731f, -0.00417542f, -0.01458572f, 0.13988674f, -0.01277644f, 0.14524841f, -0.02375779f, 
    0.42027497f, 0.01240626f, 0.64343315f, -0.43786064f, 0.05083460f, 0.20464069f, -0.13038126f, 0.05573504f, 
    -0.07121988f, -0.10962825f, -0.03405887f, -0.16926345f, -0.26447776f, 0.23258178f, -0.40433317f, 0.13545638f, 
    0.08721222f, 0.02689129f, 0.02396666f, -0.04850461f, -0.01124854f, -0.02056331f, -0.05901295f, 0.05176072f, 
    0.07752536f, -0.16389313f, -0.01190699f, -0.12946378f, -0.05095693f, 0.15896262f, -0.00608953f, -0.06921970f, 
    -0.07191212f, -0.08153191f, -0.00641821f, -0.21796173f, 0.07218431f, 0.04369687f, 0.23664653f, 0.09165785f, 
    0.13048998f, 0.07074745f, 0.09096763f, -0.12150390f, -0.08071540f, 0.07594612f, 0.15203384f, -0.04882637f, 
    -0.54090130f, -0.18546917f, -0.07885807f, 0.04454549f, 0.01569359f, 0.02977251f, 0.02074131f, -0.03025510f, 
    -0.05030213f, -0.01179241f, -0.02991227f, -0.07356116f, -0.03870095f, 0.32497790f, -0.12623498f, -0.05275130f, 
    0.09084307f, 0.10746769f, 0.03434598f, -0.06128833f, -0.09069008f, 0.09030090f, 0.13463628f, 0.02244579f, 
    0.35305151f, 0.08015352f, -0.00208676f, 0.06920467f, -0.15172271f, 0.03635919f, 0.08027658f, -0.02638557f, 
    0.04757399f, 0.03667922f, 0.11251937f, 0.03025421f, -0.26046833f, 0.33145273f, -0.12554674f, 0.07559121f, 
    0.07998902f, 0.01244785f, 0.15555659f, 0.10337146f, 0.03520691f, -0.07723080f, 0.21109942f, 0.00455035f, 
    -0.04188070f, -0.04635281f, -0.19439070f, 0.11243860f, -0.18811494f, 0.00468328f, -0.08080611f, -0.04247049f, 
    -0.02861299f, 0.09029327f, -0.25868982f, 0.06362447f, -0.00444429f, -0.10840555f, 0.03024982f, -0.18848352f, 
    0.08979391f, -0.02466708f, -0.11242136f, 0.04232085f, -0.13208044f, -0.08488219f, -0.05140279f, 0.04955069f, 
    0.20752618f, -0.29479465f, 0.48795041f, -0.22620088f, 0.09484324f, -0.06586881f, -0.10245056f, -0.05943939f, 
    -0.03555302f, -0.00439955f, -0.07900698f, 0.09079953f, 0.15478052f, 0.19744349f, 0.33426079f, 0.05009237f, 
    0.02882823f, 0.03956185f, -0.05112238f, 0.06355012f, 0.08766401f, -0.10001694f, -0.14362510f, 0.10741318f, 
    -0.11139067f, -0.14958854f, 0.24318121f, -0.08486264f, 0.04746599f, 0.12962767f, -0.09549338f, -0.09092920f, 
    0.02459172f, -0.04302237f, -0.05869751f, -0.15995064f, -0.13231689f, -0.13756193f, 0.32884243f, 0.13978888f, 
    0.02419348f, 0.09192080f, 0.02850667f, -0.03905705f, 0.09872331f, 0.05394175f, -0.04551507f, 0.01462006f, 
    0.03163174f, -0.05522727f, -0.14574730f, -0.24062562f, -0.08360133f, 0.08852012f, 0.00084540f, 0.00964638f, 
    0.20071404f, 0.07800846f, 0.07153627f, 0.18364947f, 0.08215878f, 0.16171519f, 0.14035970f, -0.09999714f, 
    -0.04406312f, -0.06916899f, 0.02948296f, 0.04165661f, -0.12243311f, 0.04514346f, -0.04326871f, -0.02995651f, 
    0.21250774f, 0.15756401f, 0.10061608f, -0.09530305f, -0.01634740f, -0.08497299f, -0.03389874f, 0.16403654f, 
    0.02413904f, -0.00596946f, 0.10307153f, 0.07216598f, 0.04124137f, 0.09586895f, 0.10352005f, -0.03357246f, 
    -0.09521636f, -0.03299581f, -0.01383839f, -0.02464483f, -0.00789406f, 0.00280420f, -0.09597251f, -0.05175712f, 
    0.23513545f, 0.02714044f, -0.03156218f, -0.19438906f, 0.01027934f, 0.07090550f, 0.10070552f, 0.04247340f, 
    -0.03713281f, -0.01443651f, 0.16406132f, 0.11790919f, -0.00814646f, 0.07905184f, 0.13470817f, 0.24738634f, 
    -0.22277664f, 0.15782590f, 0.02714501f, -0.07118569f, -0.07892770f, 0.15796778f, 0.23917168f, -0.03323069f, 
    0.02411485f, 0.02002567f, 0.09000299f, -0.06759933f, -0.07690285f, 0.01160908f, -0.01221482f, 0.03096469f, 
    -0.03578651f, -0.05593274f, 0.05003781f, -0.05721693f, -0.18812783f, -0.07104216f, 0.05885384f, 0.00197781f, 
    -0.02021288f, -0.05048939f, 0.00984961f, -0.21366869f, -0.01926433f, -0.10850553f, -0.21071811f, -0.06710239f, 
    0.25346854f, 0.03669409f, -0.07422603f, -0.07195855f, 0.05958575f, -0.04600466f, -0.01759800f, 0.12330475f, 
    -0.07769185f, -0.03302106f, 0.12227714f, -0.09547284f, -0.06331213f, -0.42500335f, -0.15569715f, -0.26465949f, 
    0.09706765f, -0.23871809f, 0.04942349f, -0.08919737f, -0.01359355f, 0.01251538f, 0.04872404f, 0.03517908f, 
    0.04807182f, 0.07163552f, 0.09822283f, -0.04177027f, -0.03962010f, 0.00097758f, -0.03352404f, 0.12001845f, 
    -0.01044453f, -0.06771660f, -0.00466314f, 0.14260341f, -0.30401775f, -0.24028127f, -0.31704500f, 0.30799749f, 
    -0.13089059f, 0.06547965f, 0.17908612f, 0.10492397f, 0.04496496f, 0.06633668f, 0.02794812f, -0.12749270f, 
    -0.16311730f, -0.44949251f, 0.02321748f, 0.35339978f, 0.45435894f, 0.16473623f, 0.10028484f, -0.11306170f, 
    0.07599892f, 0.21961628f, 0.09762204f, -0.08564916f, -0.18032514f, -0.24912436f, 0.07976144f, 0.20960677f, 
    0.31912708f, 0.06692772f, -0.06258498f, -0.14244685f, -0.12680209f, -0.08918004f, -0.17894123f, -0.01464297f, 
    -0.44355884f, -0.29186696f, -0.10862868f, 0.13271929f, 0.16044587f, 0.02512034f, 0.12792465f, -0.28482622f, 
    0.11684048f, 0.09700678f, -0.05481315f, -0.05452647f, 0.04514275f, 0.06259315f, -0.02975214f, 0.05721698f, 
    0.09253424f, 0.03096309f, 0.02805925f, -0.19657178f, 0.04367489f, -0.15828660f, 0.09493965f, -0.00973884f, 
    -0.13507161f, 0.02093011f, 0.08967016f, 0.06426936f, 0.03234445f, -0.12101249f, 0.10589261f, 0.07858458f, 
    0.05525884f, 0.15816076f, -0.02860037f, -0.00419643f, 0.10450725f, -0.12333779f, -0.19507156f, 0.15710899f, 
    -0.00415425f, 0.23605315f, 0.12599602f, 0.12735276f, 0.04086993f, -0.00053376f, -0.06808122f, 0.02375770f, 
    0.13615213f, 0.09603421f, -0.19160679f, 0.14483462f, -0.01043017f, -0.01314907f, 0.07553086f, -0.10655103f, 
    -0.02253601f, 0.00540498f, -0.00981172f, -0.01199912f, 0.33099669f, 0.10428904f, 0.01405132f, 0.01545078f, 
    0.01126344f, 0.06683291f, -0.01712802f, 0.02029131f, -0.15671580f, -0.01423661f, 0.15692583f, -0.00584385f, 
    -0.07719427f, -0.27948165f, -0.07887750f, 0.03030796f, -0.08871396f, -0.01109470f, -0.28704533f, 0.10478052f, 
    0.03923812f, 0.05423483f, -0.03868156f, 0.02393176f, -0.03760791f, -0.14388649f, -0.07660697f, -0.07935140f, 
    -0.06388873f, 0.03454318f, 0.13371702f, 0.00708855f, -0.04139558f, -0.04336409f, 0.12822066f, 0.17599270f, 
    -0.34640902f, -0.37739363f, 0.18192321f, 0.11349311f, 0.07902387f, -0.15304859f, -0.09887744f, -0.12055827f, 
    -0.05341403f, -0.02620771f, -0.18950787f, -0.17219232f, 0.15680045f, -0.10720922f, -0.18789041f, -0.02727365f, 
    -0.16943935f, -0.06001248f, -0.07306992f, 0.25709650f, 0.12193805f, 0.05586766f, 0.07454976f, 0.09657616f, 
    0.14043553f, 0.15843202f, -0.21341127f, 0.27678621f, -0.09486139f, 0.02246654f, 0.27622074f, 0.06907770f, 
    0.08503098f, -0.06627620f, 0.11587233f, 0.12234277f, 0.16726615f, 0.02578670f, -0.03432432f, -0.22271898f, 
    0.19374664f, 0.21982367f, -0.00404416f, 0.13005815f, 0.02838501f, 0.13181305f, 0.09906617f, 0.16103014f, 
    -0.16914734f, -0.04166826f, -0.20145303f, 0.15132926f, -0.06159598f, 0.14271234f, 0.07166191f, -0.17015792f, 
    0.01524759f, -0.09987628f, 0.00944523f, -0.06943433f, -0.05610707f, -0.19631481f, -0.14263347f, -0.02552743f, 
    0.22519237f, -0.20969985f, -0.04783449f, 0.02626809f, -0.16155876f, -0.04563855f, 0.02784781f, -0.00186919f, 
    0.13904892f, -0.23947798f, 0.02549099f, -0.17878480f, -0.01151324f, 0.01303731f, 0.10096601f, 0.16513659f, 
    0.04888880f, -0.15677777f, -0.06076881f, 0.01834385f, 0.54619974f, 0.04084849f, -0.17153910f, 0.05643539f, 
    -0.11757670f, -0.02966462f, 0.10674839f, -0.03761942f, 0.00349329f, -0.05574926f, 0.08674974f, 0.05685557f, 
    0.04149550f, -0.01103276f, -0.03145322f, -0.04058024f, 0.01210221f, -0.04531484f, 0.00123443f, -0.03926868f, 
    -0.04422874f, -0.04695755f, -0.03086945f, -0.02297609f, 0.00037605f, -0.03458472f, 0.03850527f, 0.03108792f, 
    0.02097629f, -0.02286897f, 0.03088403f, 0.04272508f, 0.03126817f, -0.03479975f, 0.01386722f, -0.02414231f, 
    0.03572434f, -0.03581260f, -0.01115441f, -0.04244312f, 0.00420263f, -0.03733591f, 0.03713448f, -0.05263985f, 
    -0.00799322f, -0.03022514f, -0.01219066f, 0.01420170f, -0.04598527f, 0.02766334f, 0.02687253f, -0.04920208f, 
    0.01700221f, -0.00006959f, -0.03699406f, 0.04802028f, 0.00078024f, 0.02885203f, -0.03150053f, 0.00880224f, 
    -0.01917090f, 0.00001010f, 0.03201877f, 0.02888487f, 0.02158342f, -0.02402318f, 0.00577944f, 0.03646427f, 
    -0.04595128f, -0.01447352f, -0.02711930f, -0.04695291f, -0.01422148f, 0.01034730f, -0.01725281f, 0.00934608f, 
    -0.04613191f, -0.05340875f, -0.03956236f, 0.00848322f, 0.04046807f, -0.02447413f, 0.00720187f, 0.01784609f, 
    -0.04899062f, 0.04092754f, -0.00900968f, 0.01573562f, 0.04782366f, 0.03980346f, 0.01120750f, -0.02325547f, 
    -0.01635063f, 0.01285590f, 0.01514591f, -0.00714585f, -0.00411800f, 0.02764033f, -0.00592780f, 0.00565732f, 
    0.04384761f, 0.00481126f, -0.04475796f, -0.04074791f, 0.03350383f, 0.04203843f, 0.02587204f, 0.00550869f, 
    0.01017873f, 0.02919614f, 0.01499788f, 0.03066688f, 0.00033242f, -0.04535246f, 0.00521445f, -0.05687656f, 
    -0.02172331f, -0.03003431f, -0.01578064f, 0.03184587f, -0.01372781f, 0.00106276f, -0.02624524f, 0.03589055f, 
    0.00593732f, 0.02203283f, -0.04402116f, -0.02964153f, 0.01839730f, -0.04384148f, 0.01473429f, 0.04137865f, 
    0.00242472f, -0.05133414f, 0.01739113f, -0.01279322f, 0.01071311f, -0.02469328f, -0.01735910f, 0.01152348f, 
    0.00364712f, -0.01369583f, -0.01144162f, -0.01009764f, 0.04086811f, -0.01361677f, 0.00519998f, 0.01524856f, 
    -0.04578088f, -0.04823938f, 0.04129890f, 0.01849031f, 0.01585810f, 0.01021892f, 0.00692554f, -0.01905225f, 
    0.03846211f, -0.03275846f, -0.03279639f, -0.02980620f, -0.05526977f, 0.02899623f, 0.01785395f, -0.00857026f, 
    -0.02259309f, 0.00344461f, -0.00166714f, 0.02106287f, 0.02882043f, -0.02485174f, 0.01171042f, -0.03732044f, 
    -0.01963529f, 0.02982499f, -0.02812734f, 0.00737736f, 0.02302321f, 0.01627940f, -0.04826775f, -0.02320198f, 
    0.03884375f, 0.03731255f, 0.02873237f, 0.03192892f, -0.01174953f, -0.00043749f, -0.00046099f, -0.04253311f, 
    -0.02869936f, 0.01270700f, -0.02229009f, 0.02430401f, -0.02914160f, -0.02556240f, 0.03887954f, -0.02569604f, 
    -0.04608296f, -0.00545707f, 0.00976279f, 0.00885002f, 0.00298344f, -0.05271334f, -0.03848499f, -0.03066003f, 
    0.01350190f, -0.02256406f, -0.04308536f, -0.00821264f, -0.00316163f, -0.02794996f, 0.03197687f, 0.00621702f, 
    -0.05432801f, 0.00966335f, -0.01692922f, -0.03022355f, -0.01846672f, -0.03510242f, -0.03702991f, -0.01019145f, 
    0.00318064f, -0.05109813f, -0.00555251f, -0.01657446f, -0.04344408f, -0.04798262f, -0.05604603f, 0.01563700f, 
    -0.00583755f, -0.04365499f, 0.02975821f, -0.04351845f, 0.01325624f, -0.01518540f, 0.03746166f, -0.04045785f, 
    0.00790808f, 0.00257174f, -0.00136079f, -0.03525855f, 0.03547894f, -0.01634560f, 0.03489094f, 0.04240639f, 
    -0.05097931f, -0.02635686f, 0.00451133f, -0.01959101f, -0.04543364f, -0.02726429f, -0.02893618f, -0.01670229f, 
    -0.01681020f, 0.03146900f, 0.02192849f, 0.00432406f, -0.04371030f, -0.01941254f, -0.03377921f, -0.00502838f, 
    -0.04653797f, -0.00942654f, -0.02100364f, 0.03929461f, -0.01858387f, 0.03895117f, 0.01543301f, -0.03319255f, 
    0.03268163f, 0.00995144f, 0.03765314f, -0.00803687f, -0.05628062f, -0.02763577f, 0.03797810f, -0.01665220f, 
    0.01726760f, -0.01200515f, 0.01509525f, 0.02365762f, -0.02707173f, 0.03944409f, 0.04055475f, -0.01951953f, 
    0.01794459f, -0.03897719f, 0.01584176f, -0.02263634f, -0.02563762f, 0.01493394f, 0.01283826f, -0.01027327f, 
    0.01653165f, 0.00661018f, 0.03267556f, -0.01068321f, -0.00045659f, 0.01586850f, -0.00025191f, -0.00125504f, 
    -0.02699172f, 0.01747044f, 0.03946020f, -0.02896990f, 0.04324281f, -0.00748945f, 0.01778406f, -0.03540366f, 
    0.01121902f, -0.05063801f, 0.02421078f, 0.03114704f, 0.04146351f, -0.00218157f, -0.01630534f, -0.03122474f, 
    -0.05137745f, -0.01326559f, -0.00288719f, 0.04371685f, -0.03704567f, -0.04128230f, -0.03250702f, 0.02554576f, 
    -0.01419826f, -0.03011141f, -0.04613086f, -0.01546920f, 0.01899427f, 0.03703174f, 0.04148593f, 0.00625607f, 
    -0.02882319f, 0.00017911f, -0.02622317f, -0.00488689f, 0.02247139f, 0.00517482f, 0.00105003f, 0.02090458f, 
    -0.01587881f, 0.02336017f, -0.04274676f, 0.00866693f, -0.00310963f, -0.05538158f, -0.03404716f, 0.00253911f, 
    -0.04812105f, -0.02965804f, -0.00238653f, 0.03937127f, 0.01957199f, -0.04331584f, -0.05098731f, -0.00712945f, 
    -0.05459460f, 0.03832894f, -0.05017672f, 0.03930016f, 0.00397393f, -0.04071130f, 0.02895505f, -0.00882438f, 
    -0.02140098f, -0.04495073f, 0.04444438f, -0.01993176f, -0.03609948f, 0.02632475f, -0.05474622f, -0.04497118f, 
    -0.04777870f, -0.04274662f, -0.03800145f, 0.00998630f, 0.02974295f, 0.00839533f, 0.02832634f, 0.02288536f, 
    0.00556033f, -0.04097267f, 0.00817991f, 0.02184423f, 0.00629603f, -0.04950636f, -0.04260979f, -0.02761820f, 
    0.04167633f, -0.02334694f, -0.05330082f, -0.01779421f, -0.03898102f, -0.04120747f, -0.03269922f, 0.03546893f, 
    -0.12255682f, -0.03920498f, 0.02974138f, 0.01724444f, 0.10418662f, -0.02175567f, 0.00829456f, 0.06881601f, 
    -0.03186605f, 0.02804659f, 0.04033271f, 0.01453872f, -0.02400816f, 0.25226417f, 0.08952295f, 0.26284227f, 
    0.06710078f, 0.00917078f, -0.13422602f, 0.07400110f, -0.00072621f, 0.00653847f, 0.06158563f, -0.01980819f, 
    -0.08196684f, 0.12271258f, -0.11334371f, -0.13613038f, -0.08350658f, 0.01360953f, -0.07227295f, -0.15770581f, 
    0.16295522f, 0.12468732f, 0.09776104f, -0.00557785f, -0.34210512f, -0.00818470f, -0.02376943f, -0.03225239f, 
    -0.13405934f, -0.03176414f, -0.11872548f, -0.04316163f, -0.03782970f, -0.07516075f, -0.00361945f, -0.07647460f, 
    -0.00496723f, 0.23027334f, 0.08645829f, 0.06313743f, -0.08940150f, 0.05631775f, 0.01139474f, 0.07895504f, 
    0.06274342f, 0.07434316f, 0.00342136f, 0.05509837f, -0.14147948f, 0.00861784f, -0.01899663f, -0.09399399f, 
    -0.14428625f, 0.02536447f, -0.00852703f, -0.09417713f, -0.04569136f, 0.02047760f, -0.07418092f, -0.03966714f, 
    0.06736345f, -0.02210241f, 0.15893707f, -0.19379808f, -0.07651336f, -0.06728187f, 0.01556373f, -0.20039734f, 
    0.06719659f, -0.04138236f, -0.06243651f, 0.10611717f, 0.46432722f, 0.18344617f, 0.41944483f, -0.17925569f, 
    -0.07310084f, -0.06921777f, 0.03165117f, 0.12550284f, -0.10472866f, -0.10988609f, 0.03306410f, 0.12137174f, 
    -0.13592477f, -0.00052131f, 0.08508748f, -0.02877685f, -0.03071428f, -0.06565352f, -0.01233624f, -0.07114512f, 
    -0.05981698f, 0.03556794f, -0.05439895f, 0.00158984f, -0.00283107f, 0.20438893f, -0.07532389f, 0.06383453f, 
    -0.03018818f, 0.05008688f, 0.09451102f, 0.13586473f, -0.12369482f, -0.00463802f, 0.10006201f, -0.02634729f, 
    0.26342586f, -0.15263215f, 0.05893086f, -0.03207513f, 0.03478963f, -0.08524264f, -0.06207330f, -0.08374413f, 
    0.14949645f, 0.07523597f, 0.04198074f, 0.17673551f, -0.24404497f, -0.17870611f, -0.05298561f, 0.13506918f, 
    0.01095355f, 0.01409531f, 0.03187834f, 0.15806757f, 0.09201129f, 0.03846763f, -0.01063250f, 0.03473467f, 
    -0.19145972f, -0.00269916f, -0.20053275f, -0.07909225f, -0.11355537f, -0.11942881f, -0.10298921f, -0.04685226f, 
    0.14513165f, 0.08689331f, 0.10139222f, -0.08736379f, -0.08310167f, -0.17447419f, -0.00884445f, 0.12541677f, 
    0.04128342f, -0.06307144f, 0.00544895f, 0.03594554f, 0.12336817f, -0.06566158f, 0.04613988f, 0.09604715f, 
    -0.02985936f, 0.07912011f, 0.21564735f, 0.04681190f, -0.01874244f, -0.14121301f, 0.08548810f, -0.02932075f, 
    -0.11313432f, 0.00581012f, -0.04378820f, -0.02352220f, 0.11164643f, -0.02367222f, -0.14254001f, 0.05753567f, 
    0.01627288f, -0.28310373f, 0.21530856f, 0.11465254f, -0.08233500f, 0.03029905f, -0.00338035f, 0.00072731f, 
    -0.04086317f, 0.01429166f, 0.20197392f, 0.24527773f, 0.00528010f, 0.15985024f, -0.02676139f, 0.03808998f, 
    -0.03159531f, -0.10796033f, -0.00576762f, 0.00784780f, -0.04710285f, 0.19551733f, 0.31517297f, 0.27057740f, 
    -0.07815140f, -0.05632496f, -0.02507851f, 0.06498291f, -0.03055297f, 0.04039355f, 0.02528861f, -0.04476791f, 
    0.04792411f, -0.20339705f, 0.00170731f, 0.22512290f, -0.09122698f, 0.07682928f, 0.07191491f, -0.10599079f, 
    -0.11652773f, -0.14658071f, 0.13167818f, 0.09300138f, -0.17585494f, -0.12026068f, -0.03999514f, -0.01495806f, 
    0.08006779f, -0.14623982f, 0.05526580f, 0.17843460f, -0.11769687f, -0.00713829f, -0.06245312f, -0.08456183f, 
    0.07633583f, 0.11229788f, 0.20420943f, 0.19889650f, 0.05385023f, 0.00138933f, 0.11147562f, 0.08651122f, 
    0.10871598f, -0.00838201f, 0.07091852f, 0.12358022f, -0.19038467f, 0.25981286f, -0.05591779f, -0.07320632f, 
    -0.14314106f, 0.23449226f, -0.03628786f, -0.11105335f, 0.03410693f, -0.05082798f, -0.06608061f, 0.00358462f, 
    0.06832988f, 0.14025861f, 0.01816539f, 0.31675535f, -0.09631919f, -0.01625644f, 0.06020754f, 0.09158088f, 
    0.03695883f, 0.09920625f, 0.01042729f, 0.27029681f, 0.06139696f, -0.02916754f, -0.19252269f, 0.00680654f, 
    0.09163071f, -0.05486909f, 0.02247391f, 0.10244085f, 0.03023370f, 0.00961317f, -0.13761505f, -0.34639624f, 
    0.12687866f, 0.21817425f, -0.07127321f, -0.01893182f, 0.06734771f, 0.12312041f, 0.02672945f, 0.15356252f, 
    0.08352776f, 0.02080949f, -0.00144049f, -0.01076849f, 0.10829263f, -0.31462628f, -0.23172392f, -0.15048464f, 
    0.08046070f, 0.02916374f, 0.10866160f, -0.06336287f, -0.10058547f, 0.09321950f, 0.10259449f, 0.00208893f, 
    -0.35364315f, -0.18616749f, 0.21037741f, 0.30468106f, -0.00645144f, -0.06989085f, -0.05628129f, 0.25210309f, 
    -0.05902785f, -0.03214559f, -0.01572164f, 0.09338149f, -0.07091422f, 0.07834449f, -0.05623735f, -0.05465747f, 
    0.01185756f, -0.04607185f, 0.02524455f, -0.16328740f, -0.07738512f, -0.00041388f, -0.00374331f, 0.12844105f, 
    -0.19099203f, -0.14983188f, 0.18987508f, 0.19436903f, -0.06742413f, -0.06249719f, 0.01660222f, 0.15703817f, 
    -0.06972824f, 0.04207507f, 0.05964672f, -0.00194771f, 0.19904274f, 0.04484253f, 0.11546021f, 0.06334015f, 
    0.06229465f, 0.21157703f, 0.09075143f, 0.12093066f, -0.02446479f, 0.16875932f, 0.12222187f, 0.06982109f, 
    0.01115758f, -0.04397451f, 0.16949394f, 0.12107249f, 0.10269254f, 0.01495987f, 0.04157583f, 0.15476578f, 
    -0.07752712f, -0.06731357f, 0.03717423f, -0.12343236f, 0.25466976f, 0.21000201f, 0.01263527f, -0.11685333f, 
    0.16493303f, -0.08856069f, -0.05673172f, -0.14067030f, -0.09958013f, -0.04384914f, -0.04673374f, 0.06942300f, 
    -0.01494601f, 0.00535991f, -0.06105496f, -0.30656499f, 0.07504272f, 0.02698795f, -0.10845046f, 0.13505684f, 
    -0.13230653f, 0.11306915f, 0.08108895f, -0.06871679f, 0.30799875f, -0.22193789f, 0.01977779f, 0.17163013f, 
    -0.12502083f, -0.03045381f, -0.11048644f, 0.03803363f, 0.13643548f, -0.06476693f, -0.14898512f, 0.17581807f, 
    -0.19920555f, 0.13025193f, -0.17753471f, 0.11538766f, -0.07645445f, -0.05484009f, -0.04654440f, -0.08547685f, 
    0.11192670f, 0.01455052f, 0.12392718f, -0.07263120f, 0.24245964f, 0.36104786f, 0.01897059f, 0.13933894f, 
    -0.08059023f, 0.07067093f, -0.09293718f, -0.01140102f, -0.02837816f, -0.09545457f, 0.03204533f, -0.14641483f, 
    0.33609515f, 0.32305953f, -0.04923994f, -0.02034647f, -0.00226924f, 0.01760283f, 0.00424859f, 0.15463984f, 
    0.10089603f, 0.02398182f, -0.10414439f, -0.05154298f, 0.31948406f, 0.09361701f, 0.20619242f, 0.12221368f, 
    0.00605163f, 0.06023306f, -0.02487895f, -0.15607449f, -0.03795226f, 0.02961972f, -0.05892459f, -0.08904151f, 
    -0.13089265f, 0.06358746f, 0.27241102f, -0.21528098f, 0.09656107f, -0.02961291f, -0.01444063f, -0.02507403f, 
    0.00345937f, -0.04875292f, 0.13422278f, -0.05110754f, -0.07987646f, -0.12256327f, 0.22688688f, 0.09331277f, 
    -0.04045996f, 0.26379186f, 0.04629111f, -0.09099399f, 0.07562348f, -0.08027670f, 0.04589014f, 0.08476081f, 
    0.12605938f, 0.01087442f, 0.16885614f, 0.05186721f, -0.03608420f, 0.04174769f, 0.04226867f, 0.03202451f, 
    -0.03783444f, -0.01334307f, 0.03613541f, -0.15310861f, -0.22521435f, 0.29845101f, -0.09597321f, 0.02599524f, 
    0.04750085f, -0.07076179f, 0.04552617f, -0.12901378f, -0.10748512f, 0.09203476f, 0.08163877f, 0.09183026f, 
    0.06016505f, -0.03241162f, 0.29084548f, -0.13185889f, 0.22498772f, 0.02758360f, -0.19082002f, 0.00980980f, 
    0.03704930f, 0.05833073f, 0.06404625f, 0.04322594f, 0.24252206f, 0.33242947f, 0.16368048f, -0.18997256f, 
    0.06669568f, -0.00220155f, -0.05521010f, -0.05580620f, 0.02866178f, 0.03052361f, 0.11355492f, 0.04978215f, 
    0.17482734f, 0.12895752f, 0.05897112f, 0.12316269f, -0.09287420f, 0.02662763f, 0.01120927f, -0.05996128f, 
    0.13099954f, 0.05763665f, 0.01815852f, 0.07816286f, -0.08704689f, -0.35464394f, -0.27643353f, -0.06093445f, 
    0.14797819f, -0.01691777f, -0.05847050f, 0.25799581f, 0.05162523f, 0.05617006f, 0.12929414f, -0.08043311f, 
    -0.25474477f, 0.17382158f, 0.04525985f, -0.10584431f, -0.30767804f, 0.01860449f, 0.08698426f, 0.01400191f, 
    -0.14463018f, -0.22969432f, 0.04184083f, -0.02342250f, -0.02538000f, -0.03126682f, -0.11127289f, -0.52038896f, 
    0.19525287f, 0.02493295f, 0.17088102f, -0.02916873f, -0.09754347f, -0.02168464f, 0.00118073f, -0.06657138f, 
    0.12957236f, 0.00546494f, 0.01089336f, 0.16916810f, -0.14846526f, 0.15471482f, 0.11988740f, 0.00499778f, 
    -0.02670065f, -0.04141101f, 0.04781649f, 0.17335872f, 0.33965334f, -0.06429922f, -0.07361267f, 0.06386886f, 
    -0.11780936f, 0.01107976f, 0.10007928f, -0.14534676f, 0.04846171f, -0.01004691f, 0.13648577f, 0.09923611f, 
    0.01427852f, -0.03519164f, 0.04032491f, 0.15130860f, -0.02661620f, -0.04858800f, 0.12073797f, -0.01384016f, 
    -0.12338495f, 0.13072971f, 0.13703409f, -0.08613052f, 0.07580392f, -0.21330802f, -0.08581772f, -0.30905956f, 
    -0.05968851f, -0.04623424f, -0.00863333f, 0.17018737f, 0.01179476f, 0.09003702f, -0.13604523f, -0.09652380f, 
    0.18028186f, -0.08639091f, 0.22826114f, 0.21919329f, 0.03724876f, -0.18340382f, 0.14439836f, -0.08827303f, 
    -0.11833848f, 0.20251492f, -0.06389090f, 0.26529250f, -0.01972110f, 0.06876192f, 0.01957961f, -0.16435356f, 
    -0.08139660f, -0.00320930f, 0.02029026f, -0.08107809f, 0.09053067f, 0.00719813f, 0.00925641f, 0.02321415f, 
    0.09211149f, 0.33871549f, 0.10083061f, -0.00699060f, -0.06386247f, 0.02070240f, -0.01064975f, 0.12343333f, 
    0.10396381f, 0.06676209f, -0.03521346f, 0.24450140f, 0.31390524f, 0.01804459f, -0.01120018f, -0.10049290f, 
    0.05050617f, -0.06023952f, -0.08509661f, -0.02745642f, 0.04106233f, -0.01973096f, 0.02068838f, -0.14898393f, 
    -0.10498627f, 0.16371241f, 0.01087131f, -0.14025386f, 0.04094483f, 0.02740999f, 0.17300296f, -0.03638920f, 
    -0.11324823f, 0.12274940f, 0.01348832f, 0.04301860f, -0.28401744f, -0.21064301f, -0.15464927f, -0.30563268f, 
    -0.05983849f, 0.02942204f, -0.10961036f, 0.00499455f, -0.04125499f, 0.19786151f, 0.06801482f, -0.08638190f, 
    0.35162276f, -0.28145310f, -0.27235213f, -0.12526955f, -0.06396189f, -0.14691016f, 0.08689944f, 0.34471270f, 
    0.09391816f, -0.03408324f, -0.12128175f, -0.04288917f, 0.01239422f, -0.09296454f, 0.08974496f, 0.04457195f, 
    0.07598756f, -0.00091678f, -0.00645540f, -0.07939131f, 0.01183139f, 0.17955641f, 0.05982364f, -0.04260866f, 
    0.12868968f, 0.09074391f, 0.06209457f, 0.19699505f, -0.05313051f, 0.09537308f, -0.03508319f, -0.08872635f, 
    -0.04297438f, -0.02813701f, 0.06702051f, 0.06645440f, -0.07386013f, -0.05776941f, 0.06222857f, -0.01959068f, 
    0.09525207f, 0.13008277f, -0.01384390f, 0.06974033f, -0.14068124f, 0.17917980f, 0.06637286f, 0.02135210f, 
    0.43660882f, -0.00730851f, -0.03246000f, -0.13863912f, 0.14483306f, -0.01491182f, 0.22551370f, 0.30827990f, 
    -0.06952702f, 0.08420493f, 0.08811531f, 0.05131973f, 0.17518537f, 0.04591997f, 0.02462803f, -0.00020906f, 
    0.07339212f, -0.00837653f, 0.02335119f, 0.14546017f, -0.18400560f, 0.09959737f, -0.00235852f, -0.07368855f, 
    0.06295688f, -0.01077426f, 0.12280913f, -0.00788788f, -0.08953721f, -0.10644197f, 0.05619580f, -0.14638729f, 
    0.03945831f, -0.03442174f, -0.05017220f, -0.01167209f, -0.44159770f, -0.21898527f, -0.02546803f, 0.06128501f, 
    0.04338353f, 0.00802831f, 0.00178382f, 0.05973664f, -0.12343542f, -0.10641494f, 0.23917565f, -0.03785358f, 
    -0.10996481f, -0.02939823f, -0.13501905f, 0.08344753f, 0.17536312f, 0.03435748f, 0.02442298f, 0.02826191f, 
    0.07837235f, -0.09409962f, -0.04706261f, -0.09900864f, -0.00307388f, -0.02010429f, -0.07595991f, -0.10552945f, 
    0.16476499f, 0.02964986f, 0.07050730f, 0.11631811f, -0.00919822f, 0.03536700f, 0.08276898f, -0.01433891f, 
    0.23152405f, -0.31916970f, 0.13492303f, -0.12780528f, 0.08621854f, 0.09341522f, 0.08463782f, 0.05229563f, 
    0.06829172f, 0.06367063f, 0.08642229f, 0.10702442f, -0.00451199f, 0.09846898f, 0.00892142f, 0.06259221f, 
    0.12729970f, 0.04328677f, 0.12941292f, 0.13485712f, 0.02296351f, 0.05119580f, -0.02830395f, -0.00299327f, 
    0.18566242f, -0.05719025f, -0.18641040f, -0.06547747f, 0.09611220f, 0.14496405f, 0.13085473f, 0.05743236f, 
    0.16414760f, -0.07083441f, 0.01333720f, -0.07089929f, 0.25253627f, -0.27673161f, 0.01822769f, 0.12653741f, 
    0.03067171f, 0.08754218f, -0.37665486f, 0.19261521f, 0.03737042f, -0.05627992f, 0.11274005f, 0.04900276f, 
    0.10205156f, -0.09807059f, 0.06227844f, -0.09551441f, 0.09642573f, 0.05991364f, 0.08914693f, 0.05915494f, 
    0.05267704f, 0.01860107f, 0.16842224f, 0.15718304f, 0.02448127f, 0.23491238f, 0.07097269f, 0.00469188f, 
    0.11591539f, 0.09031828f, 0.05744095f, -0.07119211f, -0.12855990f, 0.10524483f, -0.08388219f, -0.06221350f, 
    0.28277522f, -0.05431412f, -0.06979848f, 0.02404844f, -0.00118738f, -0.00814555f, -0.09187325f, 0.09407653f, 
    -0.08864409f, -0.06144086f, -0.00338629f, -0.10371117f, -0.12929098f, -0.15003222f, 0.20108430f, 0.06706338f, 
    0.02922931f, -0.06808385f, 0.05748548f, -0.06149341f, -0.06579439f, 0.00941151f, -0.00701924f, 0.04093367f, 
    0.08893974f, -0.01912621f, 0.00096462f, 0.05632551f, 0.05526951f, 0.07682027f, -0.00117481f, 0.06984860f, 
    0.03568180f, -0.09254979f, -0.05025877f, 0.01783909f, -0.15622124f, -0.01099599f, 0.01976977f, 0.27065474f, 
    -0.02302191f, -0.02338327f, 0.01858957f, -0.21136506f, -0.09737699f, -0.01865489f, -0.03680119f, 0.05735775f, 
    0.00984895f, 0.04195618f, -0.14787364f, -0.04288108f, 0.02310768f, -0.01993536f, 0.12491234f, -0.08654973f, 
    0.06490567f, -0.00016986f, 0.05904648f, 0.04319806f, -0.14844312f, -0.35408056f, 0.23190242f, 0.19893920f, 
    0.08835177f, 0.03365280f, 0.17388321f, -0.03291517f, 0.11022799f, -0.01972008f, 0.04035491f, 0.14355987f, 
    -0.01761058f, 0.26450527f, -0.02820016f, 0.21798331f, 0.09574876f, -0.11424362f, 0.00055424f, -0.19454075f, 
    0.04099349f, 0.10027508f, 0.04503232f, -0.13863114f, -0.01255061f, 0.13176498f, 0.18654151f, 0.17011525f, 
    0.05790681f, 0.02301286f, 0.07247514f, 0.01581718f, 0.06427952f, 0.05118303f, -0.04359188f, 0.10006332f, 
    0.02691043f, -0.07342682f, 0.07044972f, 0.10567234f, 0.00728268f, 0.00503753f, 0.15506753f, -0.08047624f, 
    0.23733863f, 0.05475410f, -0.01479342f, -0.13538511f, 0.07902511f, 0.12908013f, 0.04737401f, -0.00448647f, 
    -0.08166933f, 0.07723904f, 0.08810835f, 0.01740275f, 0.03749829f, 0.00695298f, 0.06654175f, -0.03653682f, 
    -0.12804620f, -0.09546903f, -0.30021974f, 0.21022084f, 0.25866091f, -0.05259621f, -0.02706899f, 0.08235631f, 
    -0.05350636f, 0.01201220f, -0.04639988f, 0.02806943f, -0.04608350f, 0.10776409f, 0.27454719f, 0.05848019f, 
    0.00694845f, 0.00217254f, -0.09706724f, 0.06598325f, 0.03055273f, -0.08614472f, 0.02497152f, -0.04108446f, 
    0.04845656f, 0.00373556f, -0.07991328f, 0.07030620f, -0.05658612f, -0.12897630f, -0.31889144f, -0.09225269f, 
    -0.12825647f, -0.02648842f, -0.02063696f, -0.03154440f, -0.09960595f, -0.07585566f, 0.21304187f, 0.00624745f, 
    -0.05017313f, -0.10050324f, 0.08316294f, 0.12711130f, 0.11247890f, 0.13577658f, 0.13884224f, 0.40291008f, 
    0.13129291f, -0.20338947f, -0.00917820f, 0.14088845f, -0.04061958f, -0.03295053f, -0.07273795f, -0.01644094f, 
    0.05741940f, -0.08524736f, -0.07888117f, -0.10611577f, -0.38611081f, -0.22172999f, 0.19626795f, 0.19421172f, 
    0.05675978f, -0.00405479f, 0.03030587f, 0.07730898f, 0.13819322f, -0.07296029f, -0.07523100f, 0.04832087f, 
    -0.61667198f, 0.30785117f, 0.10256161f, -0.33480775f, -0.00452597f, 0.15182273f, 0.00762235f, -0.09898946f, 
    -0.22154394f, 0.21828766f, 0.18716851f, 0.02317896f, -0.00750668f, -0.15712163f, 0.12119957f, 0.26216125f, 
    0.11325815f, -0.00082388f, 0.00825603f, 0.01278108f, 0.10348350f, 0.01458227f, 0.00703950f, -0.00902637f, 
    0.08733761f, 0.20476870f, -0.03551459f, -0.16202621f, 0.01302061f, 0.19604662f, 0.19669326f, 0.10238218f, 
    0.03014993f, 0.04662471f, 0.01384988f, -0.15514387f, 0.15972011f, -0.04413114f, -0.22374809f, -0.02955804f, 
    0.09521390f, -0.13844839f, -0.10666657f, -0.09450810f, 0.08689681f, -0.06141505f, -0.12441497f, -0.12284583f, 
    0.30165115f, -0.06665235f, 0.17047103f, 0.18638581f, -0.13235755f, 0.15054847f, -0.19720446f, -0.01435770f, 
    0.05033597f, 0.02803896f, 0.02566414f, -0.00763852f, 0.15788744f, -0.05709659f, -0.17100196f, 0.23928002f, 
    -0.00251402f, -0.05598037f, -0.05186909f, 0.03711755f, -0.02601612f, 0.11798616f, 0.07648274f, 0.08859929f, 
    0.17836751f, 0.00648336f, -0.24632555f, -0.13812192f, 0.07627259f, 0.03652399f, -0.04589457f, 0.14319637f, 
    -0.23564316f, -0.13762045f, -0.03955862f, 0.01922587f, -0.14051589f, 0.08003230f, 0.13399896f, 0.01655640f, 
    -0.07939222f, 0.00248428f, -0.10116293f, 0.03565095f, 0.17490830f, 0.15488181f, 0.00052522f, 0.13377626f, 
    0.01924280f, -0.14971584f, 0.10746279f, -0.10070632f, -0.11848120f, 0.04731501f, 0.01909694f, 0.03269996f, 
    -0.03634048f, 0.14025334f, -0.01076977f, -0.00281448f, -0.20774551f, 0.10373780f, -0.07603668f, 0.06927373f, 
    -0.00547346f, 0.05567969f, 0.01819512f, 0.05285984f, -0.05020901f, -0.01269844f, 0.05324673f, 0.05334076f, 
    -0.51911348f, 0.15681027f, -0.21935400f, 0.13524871f, -0.03996456f, -0.06254282f, 0.04195986f, 0.07111350f, 
    -0.09204211f, -0.04396209f, 0.02784438f, 0.00430112f, -0.15611950f, 0.03906742f, -0.03642232f, 0.00517863f, 
    -0.11527846f, -0.03730224f, -0.07724772f, 0.08672535f, -0.00964253f, 0.03232287f, 0.04269590f, -0.00671256f, 
    -0.17215575f, 0.00074429f, 0.25332901f, -0.02125132f, -0.01086609f, -0.05880775f, 0.05725984f, -0.00496249f, 
    0.01133689f, 0.17208964f, 0.10542402f, 0.08851160f, -0.19735773f, 0.32137585f, 0.25401831f, -0.12489690f, 
    -0.03752990f, 0.08203559f, 0.03234521f, -0.03963701f, 0.05713386f, 0.01335888f, 0.18849662f, -0.13211820f, 
    -0.18896276f, -0.02448973f, 0.05948757f, 0.06189149f, -0.07049942f, -0.03150028f, 0.05435472f, -0.01209602f, 
    -0.03350966f, -0.02107417f, -0.09888647f, -0.11664616f, 0.15237644f, 0.13460900f, -0.23166752f, -0.02266936f, 
    -0.10179172f, -0.14007309f, -0.00802654f, 0.03557293f, 0.06795698f, -0.16086456f, 0.15243711f, -0.00727381f, 
    -0.12574162f, -0.00473527f, 0.19774784f, -0.19187658f, 0.01204210f, 0.19222510f, 0.01620232f, 0.00123748f, 
    0.14612262f, -0.01476240f, 0.01202035f, 0.11241005f, 0.26484403f, 0.26317516f, -0.10766274f, -0.25187188f, 
    0.04664277f, 0.04421004f, -0.05494603f, -0.06691300f, -0.06470758f, -0.06243405f, -0.09885141f, -0.06635322f, 
    -0.08627653f, 0.04329051f, -0.01890612f, 0.07377913f, -0.07626239f, 0.04827082f, 0.00518789f, 0.00628349f, 
    -0.08570760f, 0.06913280f, 0.12004357f, 0.02415705f, -0.02351152f, -0.03335762f, -0.13525933f, -0.05781315f, 
    0.04708847f, 0.13903964f, -0.05731006f, -0.09184907f, -0.03173880f, -0.04275042f, -0.12568259f, -0.09784877f, 
    0.06298098f, 0.11617605f, -0.15343095f, -0.07020498f, 0.01862359f, 0.17546846f, -0.10107660f, 0.06036691f, 
    0.06408758f, 0.01370733f, 0.06528049f, -0.10025591f, 0.41842598f, 0.27308968f, 0.10113181f, -0.24788910f, 
    -0.01158157f, 0.16198842f, -0.00654217f, 0.00787523f, -0.14019386f, 0.04304793f, -0.04182027f, -0.07331511f, 
    0.00544328f, -0.20980136f, -0.05912622f, -0.18907952f, -0.08861025f, 0.08136363f, -0.10808395f, 0.02866924f, 
    -0.09803937f, -0.05786112f, 0.01933874f, 0.15604936f, -0.03774945f, 0.00048438f, -0.17704612f, -0.25608629f, 
    -0.12378074f, -0.02282809f, -0.11919070f, -0.08104589f, 0.00267996f, -0.01010260f, 0.08138972f, -0.04218172f, 
    -0.20912866f, 0.10199305f, -0.04331649f, 0.17947200f, -0.03141514f, 0.10334907f, -0.07766670f, 0.06770379f, 
    -0.16134666f, 0.11299472f, 0.08384574f, 0.17360672f, 0.01597593f, -0.18314274f, 0.03005218f, 0.16331379f, 
    0.13488364f, 0.03696889f, -0.01112420f, -0.02469613f, -0.02412557f, -0.06648375f, -0.00254534f, 0.05479163f, 
    0.06411923f, -0.22321936f, 0.49700728f, -0.02457915f, -0.15882811f, 0.02852159f, 0.01672897f, -0.03708187f, 
    0.08467542f, -0.01759253f, -0.02430336f, 0.01973690f, 0.11332233f, 0.23473705f, -0.14561738f, -0.03944818f, 
    -0.11239935f, -0.01511807f, 0.17336687f, -0.18593620f, 0.04685220f, -0.03291522f, 0.05490055f, -0.00158428f, 
    0.11720745f, 0.19024906f, -0.02974617f, -0.21484941f, 0.00701148f, 0.11737806f, 0.15793888f, -0.12701119f, 
    0.00448850f, -0.03118770f, 0.04431705f, -0.00887411f, 0.28912610f, 0.04401329f, 0.12594077f, 0.07063492f, 
    0.05417610f, 0.11002345f, -0.04263954f, -0.06258167f, -0.07255978f, -0.01186514f, 0.03968497f, -0.10728137f, 
    0.07305738f, 0.20938174f, -0.09146846f, -0.09047150f, 0.04324684f, 0.05496399f, 0.07330219f, -0.11970671f, 
    -0.00914791f, -0.07895521f, -0.02490728f, -0.00725171f, 0.09353372f, 0.20131852f, -0.14156286f, -0.04657592f, 
    -0.02551625f, 0.18516532f, 0.14342287f, 0.13978644f, -0.04845262f, 0.17331125f, 0.08278856f, -0.08864734f, 
    -0.04912150f, -0.57546437f, -0.24626444f, 0.31018591f, 0.00762264f, -0.02687247f, -0.06922607f, 0.04731076f, 
    0.14231075f, -0.05176703f, -0.12734093f, 0.00754947f, -0.05361312f, 0.40665135f, 0.07978041f, -0.06790569f, 
    -0.12705387f, 0.04133905f, 0.03040661f, 0.05374895f, 0.09273099f, -0.08762305f, -0.01043472f, -0.02024270f, 
    0.21001227f, 0.02519242f, -0.09044224f, -0.00899993f, 0.01274119f, -0.08657377f, -0.16824453f, -0.12953992f, 
    -0.10747298f, -0.03011506f, -0.03553207f, 0.04897703f, -0.04726268f, -0.13557123f, 0.24637505f, -0.07709680f, 
    -0.04389068f, 0.24226870f, -0.12292641f, 0.01128808f, -0.01548777f, 0.06266940f, 0.10342818f, 0.12417868f, 
    -0.04705461f, 0.03749606f, 0.35182565f, -0.19493033f, 0.09240882f, -0.01778506f, 0.06184155f, -0.06115581f, 
    -0.04270873f, 0.08952319f, 0.01092446f, 0.04844687f, -0.23181280f, 0.17608830f, 0.46436816f, -0.26620793f, 
    -0.06119734f, 0.12170966f, 0.04448305f, 0.08744323f, 0.11181659f, -0.02870672f, -0.10735235f, 0.09778430f, 
    0.21490319f, -0.01603167f, 0.08826326f, 0.40266863f, 0.00987824f, 0.04149611f, 0.15128085f, 0.13813527f, 
    0.10584171f, 0.01585561f, -0.01422941f, 0.17609806f, 0.14875701f, 0.02772776f, -0.25883126f, -0.18700151f, 
    -0.03389422f, 0.02081304f, 0.09245472f, -0.00316986f, 0.10989869f, 0.13090143f, 0.00734393f, -0.02184955f, 
    -0.04450275f, -0.14266506f, -0.12831107f, -0.30796561f, 0.25475827f, 0.03627625f, 0.07706688f, -0.04296266f, 
    -0.11348143f, 0.08617695f, -0.11630505f, 0.03937806f, -0.24139437f, -0.50913084f, -0.25367817f, 0.06333648f, 
    -0.08887781f, -0.00389464f, -0.04268361f, -0.14627996f, -0.09339566f, -0.06805369f, 0.00131855f, 0.08775251f, 
    -0.36742425f, -0.21448131f, -0.22846960f, 0.04434685f, -0.15192805f, -0.09663667f, -0.21801424f, -0.16227454f, 
    -0.10233618f, -0.19892102f, 0.10481978f, -0.00272342f, -0.12099531f, -0.13017313f, -0.20866112f, -0.04012873f, 
    -0.18078266f, -0.08487808f, -0.07342900f, -0.13738436f, 0.02435934f, 0.04436799f, -0.01469678f, 0.05642064f, 
    -0.07522577f, -0.39878607f, -0.10996055f, 0.09947742f, 0.01935174f, -0.08341249f, -0.06372727f, 0.08458409f, 
    0.07061250f, -0.03998399f, -0.02743897f, 0.06307903f, 0.30160561f, -0.28261891f, -0.19887778f, -0.12361412f, 
    0.05660327f, -0.13439302f, -0.27164209f, 0.24358831f, 0.15273589f, -0.02773644f, -0.30383191f, -0.10838027f, 
    -0.29568058f, -0.21974929f, -0.19966228f, 0.00315338f, -0.06966098f, -0.05554662f, -0.11956366f, -0.17889626f, 
    0.17961960f, 0.04990209f, 0.14395681f, 0.05974768f, 0.27263221f, 0.16787380f, 0.10004129f, 0.09922656f, 
    0.09904567f, 0.09990956f, 0.06764987f, 0.11026485f, 0.04700312f, 0.04636674f, 0.01365987f, -0.00380205f, 
    -0.03530955f, 0.02595468f, 0.15749614f, -0.05553899f, -0.03904302f, 0.05399778f, 0.00731847f, 0.10506480f, 
    -0.01124926f, 0.01866012f, -0.08196447f, -0.13020468f, 0.29266849f, 0.09806375f, 0.06046667f, 0.27246881f, 
    0.01701058f, 0.17597860f, 0.04847049f, 0.04607783f, -0.05981239f, -0.02653109f, -0.07909568f, -0.03381874f, 
    -0.16999479f, -0.31219283f, -0.44261956f, -0.13130917f, 0.18474837f, -0.09530217f, -0.11054545f, -0.12897885f, 
    -0.15620038f, -0.00678746f, -0.06135044f, -0.12192154f, 0.18561645f, 0.22792634f, -0.02323803f, 0.08727448f, 
    0.07040063f, 0.16065396f, -0.02597392f, -0.10975280f, 0.01743517f, 0.07795330f, 0.00637560f, 0.07263367f, 
    0.28062260f, 0.35801944f, 0.00054370f, 0.27795410f, 0.22822538f, 0.01621997f, 0.05542669f, 0.07680484f, 
    0.02308102f, 0.07717506f, 0.13224806f, 0.14187954f, 0.47838175f, 0.08676496f, 0.36807039f, 0.18927388f, 
    -0.01285756f, 0.04217998f, -0.02085905f, -0.02819752f, 0.05360316f, 0.06677284f, 0.03941916f, 0.02524236f, 
    0.24777380f, 0.44104111f, 0.18605448f, 0.08053085f, 0.06693163f, -0.09234852f, 0.06670865f, 0.24017136f, 
    -0.01518798f, -0.02859926f, 0.11081479f, 0.05306096f, 0.10122140f, 0.22121085f, 0.26777321f, 0.25892282f, 
    -0.09851300f, 0.05044165f, 0.00216996f, 0.21409778f, -0.12384670f, 0.01421459f, -0.09851721f, -0.06194006f, 
    -0.17912331f, -0.03475320f, 0.12894283f, -0.30750313f, 0.08382181f, 0.11092009f, -0.09741878f, -0.06780067f, 
    -0.06662599f, 0.05890090f, 0.12807696f, -0.01907941f, -0.17600515f, -0.19389601f, 0.01212486f, 0.28669968f, 
    0.05540022f, -0.02111444f, 0.00283210f, 0.05227124f, 0.07087072f, 0.02798505f, 0.22762667f, 0.14502375f, 
    -0.02965619f, -0.10497212f, 0.32537791f, -0.02267480f, 0.04582109f, 0.19006558f, -0.14059649f, -0.01898548f, 
    -0.03036962f, -0.08012176f, -0.11648469f, -0.18303175f, -0.25276050f, 0.15555046f, -0.08975624f, 0.01291428f, 
    0.06283429f, -0.05017493f, -0.12634480f, -0.08066670f, 0.04988863f, 0.05466628f, -0.10931166f, 0.05727185f, 
    0.17980599f, 0.27663282f, 0.02344025f, 0.31674764f, 0.00769699f, 0.01732539f, 0.17709066f, -0.00019471f, 
    -0.19791453f, -0.11194603f, 0.03294008f, -0.20313026f, 0.03895339f, -0.02359992f, 0.21428001f, 0.23911625f, 
    0.11765476f, 0.11585151f, 0.10983511f, 0.02934113f, -0.00390876f, 0.04760536f, 0.04762556f, 0.15114030f, 
    0.23232432f, 0.22432970f, 0.10805608f, 0.18463255f, 0.05770085f, 0.11585946f, 0.05059900f, 0.13270427f, 
    0.16392563f, 0.08382425f, 0.09655714f, -0.04888724f, 0.27323833f, 0.12452972f, 0.01859021f, -0.11994261f, 
    0.20428641f, 0.07288537f, 0.12098608f, -0.06732596f, -0.02936218f, -0.06834864f, 0.00366715f, 0.00402062f, 
    -0.26608977f, 0.03016808f, -0.08040933f, 0.06050907f, -0.01817581f, 0.14906913f, 0.01693704f, -0.21026006f, 
    -0.03178018f, -0.02790290f, 0.01542356f, -0.04182896f, -0.29562613f, -0.05451820f, -0.07851758f, -0.06802612f, 
    -0.00287801f, -0.10806801f, -0.12853029f, -0.08873958f, 0.03133688f, -0.11261021f, 0.04099583f, -0.01761842f, 
    0.18805893f, 0.12397046f, -0.01630068f, 0.20780297f, 0.10268667f, -0.05039645f, 0.01092363f, 0.25567165f, 
    -0.05312903f, 0.02338387f, -0.05038198f, 0.09689082f, 0.19735454f, 0.12935381f, 0.25016952f, 0.06069148f, 
    0.08981130f, 0.02902692f, 0.04802006f, -0.12069922f, 0.01260586f, -0.21961200f, -0.01832954f, -0.03676534f, 
    0.05036426f, 0.10336266f, 0.44215903f, -0.01969898f, -0.19098842f, 0.03005925f, -0.03352888f, 0.02079110f, 
    0.14818999f, 0.03666884f, 0.01487967f, 0.05042568f, -0.26886767f, -0.16368948f, 0.21754989f, -0.03233482f, 
    0.02353585f, -0.00547382f, -0.05029076f, -0.12709476f, -0.02571522f, -0.05567478f, -0.03575817f, 0.15286718f, 
    0.18409738f, 0.07343345f, 0.07154310f, -0.01269258f, 0.19769967f, 0.09731999f, 0.04818802f, 0.04045872f, 
    -0.06379917f, 0.02808034f, -0.03153891f, -0.11303035f, -0.28540021f, 0.00784110f, -0.11147028f, 0.23210330f, 
    0.00978735f, -0.04243094f, -0.20510982f, -0.06165063f, 0.09664737f, -0.01706835f, -0.02971180f, 0.20837988f, 
    -0.00092580f, 0.16306546f, -0.04220318f, 0.03329188f, -0.07262333f, 0.04096998f, -0.08941649f, 0.03203689f, 
    0.20933060f, 0.11065329f, 0.13885200f, 0.02614045f, -0.28382787f, -0.02291694f, -0.00975305f, -0.07278331f, 
    0.00989436f, -0.00162152f, -0.04588200f, -0.04653467f, -0.03949570f, -0.07412229f, 0.01132775f, -0.01462098f, 
    -0.01790217f, 0.19285625f, 0.01634244f, 0.00353089f, -0.11367024f, 0.05932155f, -0.03246305f, -0.01957892f, 
    0.12418418f, -0.16540879f, -0.03675871f, -0.06507821f, -0.23633216f, -0.12365497f, 0.00594695f, 0.00747617f, 
    0.01884938f, -0.02578697f, -0.03251050f, -0.04700830f, -0.07093097f, 0.00877524f, -0.13528857f, -0.01329838f, 
    0.16922508f, -0.11864543f, -0.00288299f, -0.19640592f, 0.12806799f, -0.04758327f, 0.13305634f, -0.13139293f, 
    0.17043695f, -0.10089263f, 0.06703681f, 0.15416920f, 0.42096108f, 0.20819634f, 0.10179614f, -0.00596240f, 
    -0.15399715f, -0.02287713f, -0.00222361f, -0.07111630f, -0.01941741f, -0.07933290f, 0.21714561f, 0.19730252f, 
    -0.18537222f, -0.13569441f, -0.03416397f, -0.06032513f, -0.04222094f, 0.01305381f, 0.00928316f, -0.06986419f, 
    -0.07088189f, -0.07555720f, -0.05243110f, -0.06515798f, 0.05335850f, 0.36477283f, -0.17451198f, 0.02810757f, 
    0.01313918f, 0.11663491f, 0.07993221f, -0.05900933f, -0.16822088f, -0.03408433f, -0.03768845f, 0.05191956f, 
    0.28435776f, -0.23187982f, 0.06264017f, -0.14360633f, 0.13716842f, 0.04496665f, 0.00232296f, -0.00925839f, 
    0.10085545f, -0.02104299f, 0.04960478f, 0.08288786f, 0.05183711f, 0.07862951f, 0.00747753f, 0.06768733f, 
    0.17110525f, 0.04143048f, 0.01922455f, 0.09438435f, -0.02062690f, 0.00666360f, -0.04452698f, 0.03719686f, 
    -0.25247684f, 0.01841400f, -0.07123570f, -0.00968345f, 0.07405101f, -0.00523292f, 0.02586075f, -0.06208878f, 
    0.12672576f, -0.03705184f, 0.14481390f, 0.16875477f, -0.09493270f, -0.17674202f, -0.13449173f, 0.28476462f, 
    0.13123257f, -0.00276452f, 0.07830688f, 0.04489341f, 0.23708494f, 0.05844030f, 0.06376748f, -0.03038704f, 
    -0.04354818f, 0.27344796f, 0.01119816f, 0.05604478f, 0.13713163f, 0.03822253f, 0.05622903f, 0.01948039f, 
    0.01596880f, -0.00526461f, 0.02189304f, -0.05442426f, 0.18984011f, -0.16530599f, -0.06095919f, -0.02954415f, 
    0.22736089f, 0.02596178f, 0.21999021f, 0.06459631f, -0.12843363f, -0.10802581f, -0.14266238f, 0.10847602f, 
    0.24362028f, 0.11270810f, 0.07512262f, 0.43762189f, 0.21767443f, 0.25499862f, -0.00968335f, -0.02472993f, 
    -0.04241867f, 0.01334803f, -0.04226725f, 0.03916997f, -0.02138450f, 0.07447398f, 0.32482085f, 0.26973644f, 
    0.08943507f, 0.02201359f, 0.16045372f, 0.00574556f, -0.01431348f, -0.00175962f, 0.05921638f, -0.03830442f, 
    0.13342103f, -0.22378147f, -0.03842330f, 0.03936779f, -0.03076532f, 0.05251726f, 0.02756031f, -0.05391001f, 
    0.05011348f, 0.07492797f, 0.15472019f, 0.09923624f, -0.01100574f, -0.11207864f, -0.11175623f, 0.11548047f, 
    0.00558655f, -0.06438720f, -0.05352657f, 0.18428588f, -0.06239355f, 0.00010541f, -0.08070285f, -0.09034891f, 
    -0.06642395f, -0.04897447f, -0.22298303f, 0.45381457f, 0.20400661f, -0.13508250f, -0.03045445f, 0.00326138f, 
    0.05936879f, 0.02000672f, 0.06835838f, 0.24270758f, 0.13870606f, 0.28969133f, 0.25808179f, -0.03646003f, 
    -0.11044434f, 0.04309697f, -0.05150618f, -0.01613621f, 0.01045563f, -0.04385118f, -0.05810903f, -0.01630685f, 
    0.16636531f, 0.17528749f, -0.11903545f, 0.08944582f, -0.02316646f, -0.11326917f, 0.04137780f, 0.06365538f, 
    0.09167716f, -0.05142704f, -0.03355910f, 0.34423751f, 0.26519278f, -0.02399420f, -0.05143510f, -0.00892667f, 
    0.06780582f, 0.06543694f, 0.05255113f, 0.14455406f, 0.11185402f, 0.03146915f, -0.05672203f, -0.12843509f, 
    0.28103778f, 0.11854180f, -0.09599089f, -0.02285801f, 0.17285073f, 0.15571283f, 0.05045938f, 0.07479766f, 
    0.08031846f, -0.02900635f, -0.08205508f, -0.03847577f, 0.14839828f, -0.42022657f, 0.05504490f, -0.11913698f, 
    0.05662259f, 0.10109250f, 0.13867453f, 0.12522227f, 0.06871440f, 0.13266890f, 0.03732224f, 0.05036887f, 
    -0.53582567f, -0.05833540f, -0.13061167f, 0.26469064f, 0.03438132f, 0.01573058f, -0.06144865f, 0.15274216f, 
    0.07261483f, 0.01166640f, 0.00291376f, 0.07109721f, 0.03143553f, 0.02810109f, 0.21292265f, -0.17496724f, 
    0.10296232f, 0.13233538f, 0.00504959f, -0.06590559f, 0.06595577f, 0.07791007f, 0.07153845f, 0.12362416f, 
    0.16123194f, 0.02976644f, 0.08735947f, 0.07827260f, 0.13134551f, 0.08838437f, 0.14905581f, -0.03359243f, 
    -0.10821474f, -0.04239272f, 0.06600868f, -0.10150266f, 0.18541047f, 0.05317187f, -0.03071070f, -0.10803338f, 
    0.12792389f, 0.10574705f, 0.06657511f, -0.05106717f, 0.01979773f, 0.14927357f, 0.07279820f, 0.11617361f, 
    -0.08194819f, -0.18238373f, 0.17461932f, 0.34410843f, -0.10324880f, 0.23804347f, 0.11821353f, 0.11094953f, 
    0.02105582f, -0.00078141f, 0.06491521f, -0.17511237f, 0.27773431f, 0.17417158f, 0.09699850f, -0.10431460f, 
    0.11912336f, -0.06477409f, -0.01417113f, -0.02176596f, -0.03214744f, 0.14571375f, 0.02690586f, 0.05375488f, 
    -0.03658443f, -0.02911844f, 0.01487824f, 0.00369225f, -0.00121882f, -0.04555609f, -0.05518126f, 0.00435928f, 
    -0.00952466f, -0.05137371f, 0.00257758f, 0.02279214f, 0.01115290f, 0.00045293f, 0.01912498f, 0.01080228f, 
    -0.05335445f, -0.04339065f, -0.06117964f, -0.03093400f, 0.00900858f, 0.00952700f, -0.03883282f, -0.02461763f, 
    -0.04192112f, -0.02570609f, -0.04121264f, -0.04967545f, -0.03660908f, -0.03746050f, -0.00702305f, -0.00657437f, 
    0.01182247f, 0.04341832f, -0.00162858f, 0.01962158f, -0.01963400f, 0.03681262f, 0.01887800f, -0.02724361f, 
    -0.04515973f, -0.04950568f, 0.02743755f, 0.03519391f, 0.00460577f, 0.02867722f, -0.00819095f, -0.02818764f, 
    0.03020304f, 0.02197785f, 0.01317151f, 0.03544395f, -0.04063141f, 0.01623679f, 0.03272804f, -0.00359966f, 
    -0.05062907f, -0.03027337f, 0.03009497f, 0.00900413f, -0.03238006f, -0.03024098f, -0.01373755f, -0.03022067f, 
    0.03552981f, -0.05927385f, 0.03552965f, 0.00433785f, -0.01657544f, 0.01000909f, -0.01275923f, -0.05175246f, 
    -0.02319022f, -0.02672444f, 0.00248199f, 0.02171132f, -0.00162257f, -0.02502317f, -0.00655825f, -0.03164100f, 
    0.01200316f, -0.03589407f, -0.05695895f, 0.04126399f, -0.00172712f, -0.04548627f, 0.03417760f, 0.00054007f, 
    -0.02614638f, 0.02799037f, -0.03070322f, -0.01463036f, -0.01984351f, 0.03862957f, 0.00146979f, -0.03307001f, 
    -0.00664666f, -0.05599761f, 0.03175367f, 0.02391839f, -0.03042378f, -0.03413503f, 0.00384167f, -0.05531659f, 
    0.03518144f, 0.02672198f, 0.03537343f, 0.02724974f, -0.01535767f, 0.01887768f, -0.05399202f, 0.01052353f, 
    0.04143292f, -0.00528970f, 0.02875655f, -0.00720115f, -0.02918630f, -0.04305506f, -0.02997730f, 0.03150975f, 
    0.01388430f, -0.03065632f, 0.03422112f, -0.02473769f, -0.03366352f, -0.02601014f, 0.02136311f, -0.03101640f, 
    -0.03792387f, 0.03658277f, 0.00334136f, -0.03061954f, 0.03094437f, 0.02906173f, -0.02666719f, -0.02053286f, 
    -0.05946758f, -0.03776931f, -0.04470095f, -0.05046962f, 0.03449122f, 0.00135346f, 0.02587477f, -0.00811220f, 
    0.01405509f, 0.00935459f, -0.02501060f, -0.02124842f, -0.00880643f, 0.02335167f, -0.01385402f, 0.03709713f, 
    0.03804558f, -0.01164916f, -0.01324759f, 0.00291083f, -0.00553481f, 0.01548707f, -0.02562691f, 0.01174527f, 
    0.00376656f, -0.02946226f, 0.02021885f, -0.00037687f, 0.01718228f, -0.00537779f, 0.00312148f, -0.03450885f, 
    0.00563127f, 0.01327045f, 0.01222338f, 0.02361618f, 0.03781978f, -0.01326789f, -0.05237877f, 0.01592632f, 
    -0.01617860f, -0.01960576f, -0.05958227f, -0.03330891f, -0.01262719f, 0.03255174f, 0.03058028f, 0.03729953f, 
    0.00239463f, 0.02365064f, 0.03973373f, -0.00097623f, 0.02866003f, 0.00239821f, -0.02149937f, -0.03321164f, 
    0.03733397f, -0.04177437f, -0.05284383f, 0.03708498f, -0.03431409f, -0.00707649f, -0.05190326f, 0.01552715f, 
    -0.01611132f, -0.00747231f, -0.03590224f, -0.04680423f, -0.02565117f, -0.04912843f, -0.00508512f, -0.01265021f, 
    0.02981308f, 0.00347261f, -0.01904786f, -0.03576510f, 0.02263422f, 0.02711360f, -0.00999903f, -0.01048263f, 
    0.02648723f, -0.00582734f, -0.02730317f, 0.01548397f, -0.01862038f, -0.05484922f, -0.05170935f, 0.03447191f, 
    -0.05657859f, -0.02343990f, -0.00465146f, -0.04830563f, -0.02794168f, 0.02760558f, -0.04192507f, -0.01804356f, 
    0.02694396f, 0.03585260f, -0.01124205f, -0.03295656f, -0.03996291f, 0.03463157f, 0.02485040f, 0.02421270f, 
    -0.02178460f, 0.02368553f, -0.02323610f, -0.04448587f, -0.02301369f, 0.03472630f, -0.04586331f, -0.00568738f, 
    0.03463342f, -0.02697970f, -0.04698446f, -0.02413022f, 0.02125078f, 0.01228021f, -0.00960869f, -0.03133064f, 
    -0.05175173f, -0.01175538f, -0.01027571f, 0.00506916f, 0.03141562f, 0.00301524f, -0.03506797f, 0.03522469f, 
    -0.03294145f, 0.02714468f, -0.04029743f, -0.00897286f, -0.01264311f, -0.02291979f, -0.02540942f, -0.05636115f, 
    -0.00424010f, 0.02215426f, 0.03733737f, -0.02369962f, 0.01773730f, -0.04501032f, 0.00710420f, -0.02324612f, 
    -0.01039821f, -0.06121251f, 0.01538162f, -0.03772065f, 0.02659613f, -0.02854871f, 0.00592048f, -0.02861387f, 
    -0.01746986f, 0.03306274f, -0.00033201f, 0.00716819f, -0.00314776f, 0.02408978f, 0.02365211f, -0.05005659f, 
    0.04130593f, -0.03510074f, 0.02446687f, 0.03118834f, 0.03580296f, 0.01956997f, -0.00376313f, -0.06194171f, 
    -0.00967838f, -0.00390545f, -0.00996771f, 0.01619202f, 0.00883973f, -0.01124368f, -0.01990075f, -0.02263442f, 
    0.02456655f, -0.00125495f, 0.00207704f, 0.01350796f, 0.03905899f, -0.02394647f, 0.01185951f, 0.00403081f, 
    -0.01563266f, 0.01234832f, -0.03200482f, -0.00814056f, 0.02401884f, 0.00348599f, -0.04009118f, -0.00708732f, 
    -0.04261613f, -0.00634072f, 0.03726194f, 0.03226915f, 0.00523355f, -0.05722514f, -0.02475834f, 0.03790032f, 
    -0.06139077f, 0.00149665f, 0.02080982f, -0.03616123f, 0.02729204f, -0.01081383f, -0.02915767f, 0.03335087f, 
    -0.02493572f, -0.02446202f, -0.03544480f, 0.02087962f, 0.03338177f, -0.02078912f, -0.01089379f, -0.04140192f, 
    -0.00215703f, -0.03487943f, -0.00976373f, -0.05450855f, -0.01370403f, -0.02092841f, 0.02157063f, 0.02552144f, 
    -0.05170004f, 0.02979448f, -0.05463520f, 0.02071980f, -0.04436020f, 0.01017886f, -0.00471021f, -0.05226134f, 
    0.00207184f, -0.02754852f, 0.01642224f, 0.03946295f, 0.01007966f, -0.01391516f, -0.02220975f, -0.05618944f, 
    0.02130896f, -0.01821861f, 0.02636780f, 0.01709757f, -0.04888251f, -0.02242623f, -0.01097136f, -0.03688334f, 
    -0.00630455f, -0.04213829f, -0.01172163f, 0.03213518f, 0.02582505f, -0.01724705f, -0.00055706f, -0.05395394f, 
    -0.05399202f, 0.01535232f, 0.03860684f, 0.00383315f, 0.03832745f, 0.00744100f, -0.01219634f, 0.03565544f, 
    0.02122658f, 0.01746010f, -0.00672481f, -0.02307043f, -0.00152448f, 0.02545480f, -0.00414692f, -0.00658158f, 
    -0.00027299f, -0.02380943f, 0.00478086f, -0.01298528f, 0.01414142f, -0.04660358f, -0.02743774f, -0.00811432f, 
    -0.01697458f, 0.00542592f, -0.00519430f, -0.04694453f, -0.00174336f, 0.02642365f, 0.04433222f, -0.05175391f, 
    -0.05167645f, 0.02811901f, -0.04900143f, -0.04228593f, -0.02014865f, -0.00594869f, -0.04012401f, 0.01834789f, 
    -0.04478262f, -0.04620332f, -0.02560333f, -0.03157950f, 0.01024067f, 0.04072189f, -0.05435624f, -0.02611709f, 
    -0.01506991f, -0.02566162f, -0.02785116f, -0.05190395f, -0.00595806f, 0.01163508f, 0.04111348f, -0.00280850f, 
    0.03001665f, 0.02510046f, -0.02764046f, 0.00570030f, 0.01975447f, 0.03674483f, -0.04247738f, 0.02877408f, 
    0.02805496f, 0.02185878f, 0.03439163f, -0.01033456f, -0.01655483f, -0.03130583f, -0.03557473f, 0.02752048f, 
    -0.05170294f, -0.04246414f, -0.03529407f, 0.01773395f, 0.04657191f, 0.01313390f, -0.01777767f, -0.05109659f, 
    -0.05058108f, 0.04048175f, 0.00704836f, 0.03913601f, -0.02965598f, -0.01476076f, -0.00479676f, 0.04428813f, 
    -0.01991782f, -0.03861705f, -0.04236935f, 0.04327543f, -0.04491047f, -0.00702773f, 0.03023199f, 0.00772080f, 
    0.04045265f, -0.05333577f, -0.02385052f, 0.00475046f, -0.00400914f, 0.01832155f, 0.00732967f, -0.01436245f, 
    0.03277519f, -0.04120627f, 0.04461240f, -0.05555618f, 0.02165418f, -0.04681120f, 0.00243586f, -0.05534985f, 
    0.00866811f, -0.01579508f, 0.01624873f, -0.02696664f, 0.00715199f, 0.02400017f, -0.04059076f, -0.01054668f, 
    -0.01632968f, 0.01500328f, 0.01601921f, -0.03050502f, 0.03258282f, 0.02618757f, -0.00056072f, -0.01969558f, 
    0.00835058f, 0.01190420f, -0.02978931f, 0.02893716f, 0.01896822f, -0.02249778f, -0.03091168f, 0.00750761f, 
    -0.02186265f, 0.04810011f, -0.02959925f, -0.01565375f, 0.03290555f, -0.04051116f, -0.03918213f, 0.00025053f, 
    -0.05355942f, -0.01865552f, 0.03744668f, 0.04138079f, 0.02827099f, -0.02297924f, 0.01514627f, 0.02756670f, 
    0.00908786f, -0.04911247f, 0.01211718f, -0.03946365f, 0.01859487f, 0.02459780f, -0.05531538f, -0.03348294f, 
    -0.00247009f, -0.00691629f, -0.04971292f, 0.01045341f, -0.02076114f, -0.00414677f, 0.03936504f, -0.00492358f, 
    -0.03723587f, 0.01634591f, -0.04941925f, -0.02336134f, -0.04696026f, -0.01788767f, -0.00420967f, 0.02711742f, 
    0.01310819f, -0.02158276f, 0.04228236f, -0.04768992f, 0.03747430f, 0.00317869f, 0.00050285f, -0.00777570f, 
    -0.00950413f, 0.00941269f, -0.03723022f, 0.03227461f, -0.03559175f, 0.01232238f, 0.04190733f, 0.00459854f, 
    0.03355345f, -0.05422878f, -0.00288057f, -0.01504632f, -0.01766186f, 0.03941209f, 0.03317176f, -0.05001591f, 
    -0.00225352f, 0.00477430f, 0.02883760f, 0.00574191f, -0.04634696f, -0.01573533f, -0.04260843f, 0.02239974f, 
    -0.01006087f, 0.00895735f, -0.03133803f, 0.03476617f, -0.01176615f, -0.03950782f, -0.02586793f, -0.04342007f, 
    -0.00637010f, -0.05689363f, 0.00956787f, 0.02938987f, 0.04261369f, -0.02775920f, 0.02714285f, -0.04522780f, 
    0.01661301f, -0.05508919f, 0.00989339f, -0.03062248f, -0.01441423f, -0.01554121f, -0.01387355f, 0.03407522f, 
    0.01710380f, 0.02192949f, -0.04435198f, -0.04164401f, -0.03651215f, 0.01198200f, -0.05196432f, 0.01910714f, 
    -0.02815539f, -0.04223051f, -0.02575943f, 0.02991974f, -0.02305684f, 0.03531699f, -0.01566366f, -0.03447262f, 
    -0.00076371f, 0.02722279f, 0.02303219f, 0.03611337f, 0.00257448f, -0.01767345f, -0.04808587f, 0.02428908f, 
    0.01342205f, -0.04797146f, 0.01149284f, -0.03989613f, -0.04305653f, -0.01898055f, 0.03772795f, 0.01415455f, 
    0.01509032f, 0.01258177f, -0.00938593f, -0.01098604f, 0.00014380f, -0.02752362f, 0.03112014f, -0.00620733f, 
    -0.01602476f, 0.03227846f, -0.05519650f, 0.04034246f, 0.02185004f, -0.01942034f, -0.04427973f, -0.04863866f, 
    -0.00585608f, -0.00226026f, -0.04053567f, -0.02684309f, 0.03184625f, 0.02033742f, 0.01274451f, -0.00648281f, 
    -0.00446333f, 0.02970647f, -0.04667188f, 0.02877853f, -0.02011341f, -0.01256980f, -0.04122366f, 0.03802009f, 
    0.04264760f, 0.00583166f, 0.02235592f, 0.01417128f, 0.02828754f, -0.00252480f, 0.01344087f, -0.02621350f, 
    -0.01993874f, 0.00540524f, -0.03699134f, -0.00084325f, -0.05456026f, -0.03609384f, -0.05034235f, -0.05302441f, 
    -0.03280704f, -0.04897874f, 0.00179633f, 0.01890747f, -0.05473583f, -0.03736255f, -0.00395289f, -0.04428006f, 
    0.00258972f, 0.02660832f, -0.02121566f, 0.00208496f, 0.01222774f, -0.02007550f, -0.00211380f, -0.01262084f, 
    0.04016706f, -0.03496657f, -0.01934145f, -0.04946976f, -0.01262785f, 0.02122791f, 0.01801065f, 0.01005080f, 
    -0.03450916f, 0.01996930f, -0.01000920f, 0.02281514f, -0.01002978f, -0.04693733f, 0.04349384f, -0.05735235f, 
    0.00216742f, -0.00401740f, -0.00701405f, -0.01015788f, -0.02863138f, -0.02654867f, 0.02798387f, -0.00538972f, 
    -0.04801581f, -0.04875799f, 0.00333214f, -0.03324447f, -0.03308902f, -0.00506598f, -0.04010715f, 0.01936537f, 
    -0.02185447f, 0.03028818f, 0.00451781f, -0.02813808f, -0.05238580f, -0.05493998f, -0.05642785f, 0.01401943f, 
    0.03895786f, -0.01214718f, -0.03273645f, 0.03570575f, -0.05354171f, -0.02511941f, 0.03976449f, 0.02946434f, 
    -0.02232840f, -0.03563119f, -0.04489176f, 0.01170738f, 0.00789850f, 0.00680515f, -0.00656018f, 0.00982440f, 
    0.00939162f, -0.01894785f, -0.01356053f, 0.01984588f, -0.00674020f, -0.04863957f, -0.05266269f, 0.00327613f, 
    -0.02242301f, -0.00057909f, -0.02066062f, 0.04340547f, -0.02249527f, 0.02405975f, 0.00321882f, -0.03310787f, 
    0.01372020f, -0.00114645f, 0.03242410f, -0.02802641f, 0.01741101f, -0.00863710f, 0.00729855f, 0.02829842f, 
    0.03836044f, 0.04293076f, -0.00206939f, 0.01840884f, 0.01510430f, 0.00840369f, -0.05435269f, 0.02987489f, 
    -0.06225042f, -0.02051475f, -0.05105798f, -0.05479060f, -0.04206869f, -0.01511132f, 0.01163416f, -0.02614362f, 
    0.03549650f, 0.03389744f, -0.00985743f, 0.00109448f, -0.01521011f, -0.05363241f, 0.01176000f, 0.01381018f, 
    -0.01411856f, -0.00674026f, -0.04873350f, 0.02608073f, -0.04679056f, -0.03725390f, 0.00880559f, 0.01912772f, 
    -0.00237863f, -0.01834265f, 0.02496418f, -0.03160016f, -0.05322019f, -0.02106124f, -0.00953461f, -0.05461666f, 
    0.01290449f, -0.04882733f, -0.04918541f, -0.01270337f, -0.03141833f, 0.03894034f, 0.02459228f, 0.03591667f, 
    -0.05528623f, -0.02304066f, 0.02827423f, 0.04901487f, 0.03653251f, 0.01608057f, -0.00471067f, -0.00757959f, 
    0.04488102f, -0.02119472f, 0.03671934f, -0.05341899f, 0.02350315f, 0.01049152f, 0.02579161f, -0.02156724f, 
    0.00017072f, -0.04446214f, -0.03737432f, -0.02038451f, -0.00105492f, -0.00099176f, -0.02153696f, -0.05122885f, 
    -0.00524680f, -0.03609592f, 0.03187969f, 0.00054153f, -0.05134521f, -0.04994602f, -0.00841452f, -0.03810843f, 
    -0.01898978f, 0.00969264f, -0.02475895f, 0.02853927f, -0.03825948f, -0.03519019f, -0.02022175f, 0.00648804f, 
    -0.03549884f, 0.02551456f, 0.00329888f, 0.02549233f, 0.02162627f, 0.04238261f, 0.00781738f, -0.05101068f, 
    -0.05335823f, 0.01942245f, -0.01490401f, -0.01977071f, 0.00819168f, -0.03677889f, -0.02260296f, 0.01628285f, 
    -0.02325589f, -0.04008687f, 0.03031508f, -0.00721413f, -0.00674312f, 0.01366532f, -0.02880408f, -0.01888018f, 
    -0.00917549f, -0.03728215f, -0.03296620f, 0.01936416f, 0.00455299f, -0.02312547f, -0.00787257f, 0.00265749f, 
    0.02661783f, 0.03239328f, 0.02209739f, -0.05181484f, 0.01518616f, -0.02028306f, -0.02358601f, -0.01067726f, 
    -0.03180661f, 0.04470358f, -0.02654930f, 0.00597190f, 0.03430112f, -0.01469265f, -0.01587478f, 0.01511976f, 
    -0.03970138f, -0.04082549f, -0.03193431f, -0.03886228f, -0.01401468f, 0.01671027f, 0.01543684f, -0.05089932f, 
    -0.01587222f, -0.02843798f, -0.00835093f, 0.02745348f, 0.01286854f, 0.01006328f, 0.00326908f, -0.04660407f, 
    0.03192159f, -0.05562997f, 0.02892469f, 0.03877075f, -0.02107580f, 0.01936516f, 0.00265978f, 0.00374549f, 
    -0.04263975f, 0.01201778f, 0.00219214f, 0.01612267f, -0.02734308f, 0.00581742f, -0.03495280f, 0.02644113f, 
    -0.02291982f, -0.01933318f, -0.03307403f, -0.04437111f, 0.01389829f, 0.00262475f, -0.00132894f, 0.03178753f, 
    0.02004962f, -0.03757869f, -0.03611350f, -0.02240816f, -0.02645980f, -0.05580254f, -0.05689138f, -0.00562750f, 
    0.04216683f, 0.00231438f, 0.01185656f, 0.03176723f, -0.04255384f, 0.01064659f, 0.02221991f, 0.01522379f, 
    0.01639153f, -0.00737379f, 0.01767408f, 0.00538540f, -0.04429181f, -0.02546364f, 0.00377738f, -0.00804899f, 
    -0.02270545f, -0.01428175f, -0.00575099f, -0.04653700f, -0.01285340f, 0.00661339f, 0.00674817f, 0.02726718f, 
    -0.02347756f, 0.01877465f, -0.03252471f, 0.03043302f, 0.04442145f, 0.02922242f, -0.01174398f, 0.04227061f, 
    0.04035191f, -0.04945325f, -0.02329104f, 0.00439668f, 0.03166694f, -0.04464263f, -0.00749490f, 0.03251529f, 
    -0.03985274f, 0.01333208f, -0.03089767f, -0.01124875f, 0.02203754f, 0.03142118f, -0.04626332f, 0.03614215f, 
    -0.04351287f, 0.01598169f, -0.02403048f, 0.00312826f, 0.01226736f, 0.02542206f, 0.02310890f, -0.01201689f, 
    -0.01826544f, -0.04623748f, 0.05024072f, 0.03364924f, -0.01163687f, -0.02836267f, 0.03018256f, -0.02468683f, 
    0.00850303f, -0.02729226f, -0.00310079f, 0.03058453f, -0.05855759f, 0.03764472f, 0.01320744f, -0.03502795f, 
    -0.03212263f, -0.02447655f, 0.02532722f, -0.02283004f, -0.01124555f, 0.02624428f, -0.04270943f, 0.03044710f, 
    -0.00388207f, 0.02686380f, 0.04548519f, -0.02053691f, -0.01582303f, 0.00321115f, -0.05372956f, 0.03455449f, 
    -0.02493220f, -0.00851020f, -0.01025822f, -0.00963553f, 0.00043595f, -0.03158969f, 0.03275764f, -0.00888024f, 
    -0.03458375f, -0.01012413f, -0.00120983f, 0.01509861f, 0.03785337f, -0.01117937f, 0.01164171f, -0.05299712f, 
    -0.03381950f, 0.02081029f, -0.05033306f, -0.04092313f, -0.02635204f, -0.01939135f, -0.00108487f, -0.03420172f, 
    -0.05612602f, 0.01328541f, -0.05081972f, -0.05751137f, -0.01781411f, -0.05008174f, 0.00598296f, -0.00176234f, 
    0.04455480f, -0.03221795f, -0.03108105f, 0.04148683f, -0.05940485f, -0.04019975f, 0.01442590f, 0.01233090f, 
    0.03582040f, 0.03801446f, -0.00753877f, 0.03084005f, -0.04752576f, 0.01663996f, -0.00040521f, 0.03466611f, 
    0.02908812f, -0.03328422f, 0.02724277f, -0.01473398f, 0.02978903f, 0.00055290f, -0.04417981f, -0.01591552f, 
    0.00647465f, -0.00713564f, -0.02368733f, -0.01696547f, 0.03805732f, -0.00774193f, 0.02458297f, 0.00931390f, 
    -0.02037700f, -0.01013893f, -0.02546284f, 0.01972247f, -0.05939496f, -0.02572891f, 0.04168572f, 0.00702024f, 
    0.03973483f, -0.02506650f, -0.00510890f, -0.01992990f, 0.03984876f, -0.03693451f, -0.00773535f, -0.03444752f, 
    -0.03538343f, -0.01622157f, 0.02302014f, -0.03669045f, -0.03935271f, 0.01033976f, -0.00574817f, -0.02274578f, 
    -0.03688504f, -0.06322203f, -0.06474141f, 0.00341385f, 0.02953647f, 0.00530252f, 0.02683345f, -0.00773895f, 
    0.01436840f, 0.01383250f, 0.00074920f, 0.04025416f, -0.04869687f, 0.02402103f, -0.04928546f, -0.00344808f, 
    -0.02798623f, -0.00817582f, 0.03374881f, 0.04040719f, 0.02101105f, 0.02684038f, -0.03469909f, 0.01236995f, 
    0.01678869f, 0.01890240f, -0.05322415f, 0.01164262f, -0.02209816f, 0.01613447f, -0.00257074f, -0.00122381f, 
    0.02364475f, -0.05031172f, -0.07459832f, -0.03984302f, -0.00668872f, 0.02332660f, -0.01782829f, -0.02762078f, 
    0.00480773f, -0.00949834f, -0.02490840f, -0.03717187f, -0.04671182f, -0.01836306f, 0.02555421f, -0.05049250f, 
    -0.03554436f, -0.03816893f, -0.02485838f, 0.00035938f, -0.08362945f, -0.00056524f, -0.01424472f, -0.04030057f, 
    -0.04059210f, 0.00911425f, 0.02688992f, -0.06507818f, 0.02281883f, -0.01087688f, 0.00680479f, -0.03891841f, 
    -0.05163317f, -0.02609534f, -0.02506031f, -0.05248831f, 0.01912826f, 0.02592178f, 0.04394348f, 0.00229950f, 
    -0.06093796f, 0.00408513f, -0.06028769f, 0.03619339f, -0.04977387f, 0.03547962f, 0.00831654f, 0.01843724f, 
    -0.04184276f, -0.02420667f, 0.05385842f, -0.03148222f, -0.06047777f, 0.01726219f, 0.00063179f, -0.02901234f, 
    -0.04827863f, -0.00842272f, 0.00895601f, 0.01605973f, -0.05871691f, -0.04912642f, -0.00512862f, -0.02555109f, 
    -0.04064800f, -0.00637561f, -0.00649851f, 0.02516341f, 0.03675767f, -0.05036067f, -0.00224693f, 0.00222961f, 
    0.02036586f, 0.02636825f, -0.05578699f, -0.02876191f, -0.04887893f, -0.00061812f, -0.04830909f, -0.00875690f, 
    0.04490040f, 0.00713944f, 0.01518493f, -0.05868555f, 0.01223285f, 0.04303180f, 0.03396917f, -0.05277691f, 
    0.02413036f, -0.05315934f, -0.01497478f, -0.04228832f, 0.03933575f, -0.00930133f, -0.02657043f, -0.04145784f, 
    -0.01703975f, -0.00806268f, -0.01640621f, 0.01636795f, 0.02338282f, -0.04686446f, 0.00206255f, 0.01965817f, 
    -0.02717287f, -0.05552424f, -0.03626464f, 0.04004313f, -0.03428653f, 0.03320047f, 0.00730711f, -0.04463974f, 
    0.02946308f, 0.02285667f, -0.00752527f, -0.03533708f, -0.02362405f, 0.03618636f, 0.01453992f, 0.01688716f, 
    -0.05691550f, -0.02830907f, -0.02119683f, -0.06561664f, 0.00604234f, 0.02567529f, 0.02095297f, 0.00350634f, 
    0.02909162f, -0.04876487f, 0.01674371f, 0.01527347f, 0.03518013f, -0.04506915f, -0.00151573f, -0.01854506f, 
    0.03344495f, -0.02170955f, -0.02389221f, -0.01468303f, -0.05048455f, -0.03818097f, -0.06476253f, 0.04629324f, 
    -0.01818114f, -0.04222440f, -0.03482760f, 0.02415162f, -0.00018469f, 0.02686688f, -0.04547551f, 0.03133115f, 
    -0.03721582f, -0.04002694f, -0.00882264f, 0.03469626f, -0.02869686f, -0.00611360f, -0.02907062f, -0.00540946f, 
    -0.04185766f, -0.03257788f, -0.03016658f, -0.04228834f, 0.00802106f, 0.00517835f, 0.02699417f, 0.00197548f, 
    -0.02249534f, -0.00934585f, -0.01777881f, 0.02490037f, -0.01244707f, -0.00803653f, -0.06858433f, -0.03353340f, 
    -0.02698215f, 0.00420350f, -0.05596612f, 0.04675207f, 0.02187817f, -0.04427375f, -0.01558315f, 0.00054086f, 
    0.03287898f, -0.01868899f, -0.03081474f, -0.00386353f, 0.01482917f, -0.03355414f, -0.01379545f, 0.00093331f, 
    -0.03563653f, -0.01397248f, 0.00731272f, -0.05104221f, -0.03898955f, -0.03934433f, 0.03523352f, -0.00345200f, 
    0.02232897f, 0.02969678f, -0.02886944f, 0.02248823f, -0.01938009f, 0.04349966f, 0.04106399f, -0.02710208f, 
    -0.01190251f, -0.00410576f, 0.01744686f, 0.01159480f, 0.01663597f, -0.02688521f, -0.04823954f, 0.03916355f, 
    -0.05409205f, 0.05060326f, -0.00976840f, -0.00484799f, -0.00124778f, -0.04404912f, 0.02655786f, -0.02432274f, 
    0.02228696f, 0.02946166f, 0.04964881f, -0.01593071f, 0.02240534f, 0.06645823f, -0.01694191f, -0.04561074f, 
    -0.01379413f, 0.04414980f, -0.03889828f, 0.02999173f, -0.04187172f, 0.03181821f, 0.03946045f, 0.00252145f, 
    -0.02535479f, -0.02723873f, -0.04181540f, 0.00493174f, -0.05891807f, -0.01242900f, -0.01118661f, 0.00003705f, 
    -0.06757672f, 0.02791462f, -0.03259449f, 0.01630893f, -0.01756875f, 0.03535892f, -0.00314549f, -0.00699148f, 
    -0.03145872f, 0.02942462f, -0.02948267f, -0.02643063f, -0.01986997f, -0.02674178f, -0.02290418f, 0.00421990f, 
    0.01827415f, -0.04531527f, 0.02416521f, -0.02018452f, -0.05834487f, 0.01544444f, 0.00067896f, 0.02990722f, 
    0.00326508f, 0.00869012f, 0.04312342f, -0.04063059f, -0.06627847f, -0.05621418f, -0.03160740f, 0.01339527f, 
    0.04069718f, -0.02488443f, -0.01583948f, -0.03699950f, 0.02145938f, 0.00263377f, 0.01920477f, -0.03322839f, 
    0.01146578f, -0.03011117f, 0.00152405f, -0.03601502f, 0.00010612f, -0.05070851f, -0.05738289f, 0.02211943f, 
    0.00923467f, -0.05243540f, 0.03263633f, 0.03543628f, -0.04706062f, -0.05424310f, -0.03933639f, -0.01428052f, 
    -0.04766717f, 0.00283946f, -0.03552317f, -0.06341036f, 0.01874546f, -0.01743345f, -0.05050586f, 0.00755516f, 
    -0.00514133f, 0.00623880f, -0.02764720f, -0.03219111f, -0.06626935f, 0.03170344f, -0.01182577f, -0.00926514f, 
    -0.03746320f, 0.02554407f, -0.05030333f, -0.05245337f, -0.04951238f, -0.04984457f, -0.04854699f, 0.04502996f, 
    -0.02694250f, 0.00511329f, -0.02025235f, 0.00916398f, -0.02300775f, -0.06684916f, 0.01265107f, 0.00409127f, 
    -0.05464857f, -0.06343382f, -0.04801970f, -0.06499194f, -0.00918595f, 0.01500315f, -0.04095102f, 0.01232893f, 
    0.40380120f, 0.15903503f, -0.04660727f, -0.03310210f, 0.02484058f, 0.05256413f, -0.01016236f, 0.06777389f, 
    0.22296274f, -0.00512813f, 0.06262931f, 0.07196988f, -0.41912594f, -0.36221454f, 0.04345983f, -0.04140716f, 
    -0.05685146f, -0.15346874f, -0.03654826f, 0.17689930f, 0.07130366f, 0.05359793f, 0.11525614f, 0.08872696f, 
    0.40874267f, 0.19009982f, 0.22473845f, 0.27314243f, -0.31462479f, -0.18591629f, -0.12035648f, 0.03820370f, 
    0.10361923f, -0.14928256f, -0.05981666f, -0.06140245f, 0.14146748f, -0.00951366f, 0.27898729f, 0.07124260f, 
    0.14496756f, -0.05300785f, -0.04149992f, -0.07911530f, -0.11250943f, 0.01985317f, -0.04281637f, 0.20790768f, 
    -0.37388122f, -0.06933215f, 0.00416760f, 0.24947083f, 0.12136797f, -0.05859382f, -0.02320292f, -0.16782485f, 
    -0.27823991f, -0.16641581f, 0.01754403f, 0.17309529f, 0.03818213f, -0.07150386f, 0.11887974f, 0.17273487f, 
    0.22193253f, -0.07545695f, -0.08338460f, 0.19337112f, -0.13373107f, -0.22106270f, 0.03317164f, 0.02306337f, 
    0.02781079f, 0.10433519f, -0.19559462f, 0.22330898f, 0.09050906f, 0.18798235f, -0.12244947f, -0.29122776f, 
    0.17831251f, -0.09084066f, 0.06939182f, -0.02874167f, -0.14028920f, 0.05204964f, -0.16937792f, -0.26920992f, 
    0.12598819f, -0.08570159f, -0.03724983f, 0.05254396f, 0.03464869f, -0.41398096f, 0.17413890f, -0.09360892f, 
    -0.18014689f, 0.04074711f, -0.06111138f, 0.09714512f, 0.00217800f, -0.00267052f, -0.11692861f, -0.10167439f, 
    0.08077151f, 0.05446326f, 0.08094016f, 0.22324865f, 0.39526308f, 0.06035166f, -0.13661668f, -0.22495456f, 
    -0.03792095f, 0.13785286f, 0.05655636f, 0.18213218f, -0.10169039f, -0.11965887f, -0.05760134f, -0.11978794f, 
    -0.21396671f, -0.11458346f, 0.28434306f, 0.03409756f, 0.00027393f, 0.16639125f, -0.00142786f, 0.12108027f, 
    -0.31343699f, -0.21129234f, -0.22639833f, -0.36290163f, 0.31315979f, 0.27807140f, -0.04878417f, -0.15940911f, 
    0.02921902f, 0.05060996f, 0.16544048f, 0.10327802f, -0.09953046f, 0.00187215f, 0.05176044f, 0.07168367f, 
    -0.16410708f, -0.03350617f, 0.09199692f, 0.06243404f, 0.15754767f, -0.15063268f, 0.03895920f, -0.46272004f, 
    -0.36999476f, -0.42239505f, -0.18488778f, -0.17565151f, 0.15445438f, 0.04940396f, 0.08274718f, 0.07743669f, 
    0.04365453f, 0.05928096f, -0.12879607f, -0.21408542f, 0.03430842f, -0.07238508f, -0.04480819f, 0.01976055f, 
    0.21448210f, 0.30535027f, -0.20972861f, 0.01422055f, 0.00764990f, 0.04403897f, 0.01402265f, 0.10301487f, 
    0.20348211f, 0.13027240f, 0.07542946f, 0.21326125f, 0.16751164f, 0.03592491f, 0.03240765f, -0.21404190f, 
    -0.04611592f, 0.20338771f, -0.02261947f, -0.05212415f, 0.18152460f, 0.01578611f, -0.02083714f, 0.09446802f, 
    0.20389374f, 0.23835786f, 0.04128794f, -0.03987184f, 0.08182754f, 0.05278227f, -0.04856947f, 0.14255586f, 
    0.00975084f, 0.11247683f, -0.04635944f, 0.11640576f, -0.10153449f, 0.22961800f, 0.01921343f, -0.01651994f, 
    0.05112131f, 0.15720128f, 0.21725930f, 0.16988485f, -0.04890180f, -0.02096837f, -0.01524137f, -0.17867161f, 
    0.08001123f, -0.09297261f, 0.01502572f, -0.05548419f, -0.00968322f, 0.05335972f, -0.28151047f, 0.06485686f, 
    0.06859019f, -0.09773633f, -0.07074091f, -0.04561358f, 0.01563025f, -0.05277644f, 0.14515185f, 0.06308091f, 
    -0.13198431f, 0.04313485f, -0.06225437f, -0.11113158f, 0.05587979f, 0.09652171f, -0.00740161f, 0.20876326f, 
    -0.47635561f, -0.10354788f, -0.02092871f, 0.28263947f, -0.02451046f, 0.01692238f, 0.06049151f, 0.09184726f, 
    -0.09048790f, -0.23397817f, -0.03732286f, -0.12751791f, 0.21881944f, 0.04519018f, 0.28150070f, -0.31359750f, 
    0.13568325f, 0.04211711f, -0.05508851f, -0.17600153f, -0.18227263f, -0.09421790f, -0.17699173f, -0.36114749f, 
    0.02922879f, 0.10054238f, 0.00010590f, -0.05357482f, 0.20777358f, 0.05690027f, 0.10125977f, -0.07486895f, 
    -0.32979074f, -0.30747306f, -0.12594356f, -0.09732432f, 0.14408106f, 0.03065146f, 0.05754324f, -0.07360004f, 
    0.04925970f, 0.08305480f, 0.09858962f, 0.04033131f, 0.22631486f, 0.21024258f, 0.11353613f, 0.37241399f, 
    0.30891174f, 0.21187234f, -0.06817995f, -0.15895824f, -0.05263540f, 0.01456274f, 0.23173329f, 0.00472393f, 
    0.22940509f, -0.02307548f, -0.03908612f, -0.08789505f, 0.33241415f, 0.11394636f, 0.23277815f, 0.19908851f, 
    -0.14324807f, 0.06768754f, -0.05225804f, -0.03242376f, 0.22528224f, 0.02822297f, -0.04917670f, 0.06504466f, 
    -0.46341622f, -0.21363246f, -0.11400579f, -0.05234812f, 0.09062944f, 0.12426694f, 0.05585177f, -0.02541728f, 
    0.11683641f, 0.21461703f, -0.00841590f, 0.11822842f, 0.28152162f, -0.06706142f, 0.29198968f, 0.04622176f, 
    -0.04854606f, -0.04372022f, -0.02343053f, -0.02984812f, 0.12562446f, -0.01891378f, -0.04427454f, 0.06863648f, 
    0.29113284f, 0.16250762f, 0.01803445f, -0.13126482f, 0.14102848f, -0.02817501f, 0.04318346f, 0.23187843f, 
    -0.01033887f, 0.01389137f, 0.12279183f, -0.03530179f, -0.07627359f, -0.08960874f, 0.20369022f, 0.05050392f, 
    0.03843394f, 0.14636779f, 0.00944229f, -0.03575470f, -0.27979675f, -0.38055602f, -0.36958590f, -0.33217353f, 
    -0.28792536f, 0.42034507f, 0.15333515f, 0.20664527f, 0.09329244f, 0.08875696f, 0.05426955f, 0.03378089f, 
    -0.01966509f, -0.03636682f, -0.01957549f, -0.16019720f, -0.40160996f, -0.05294308f, 0.40316176f, 0.15674791f, 
    -0.01722432f, 0.15798672f, 0.01105214f, -0.16691904f, -0.06417180f, 0.01686758f, 0.01845603f, 0.14639577f, 
    0.09750626f, 0.04968875f, -0.01559602f, -0.20910570f, 0.10359321f, 0.08437974f, -0.06366002f, 0.02757365f, 
    -0.05061856f, -0.05829431f, 0.09452499f, -0.11555313f, 0.41520828f, -0.57117480f, -0.33560288f, 0.05964836f, 
    -0.04966900f, -0.07381956f, -0.13650860f, -0.13826522f, 0.15157752f, -0.07883839f, 0.00274477f, -0.01117491f, 
    -0.26961926f, -0.10293682f, -0.18949081f, 0.40436095f, -0.17842036f, -0.14770284f, -0.17665623f, -0.06782735f, 
    0.16391321f, 0.05155581f, 0.17244273f, -0.05288494f, -0.19249271f, -0.09682020f, 0.00574005f, -0.00200245f, 
    0.02753089f, -0.06341965f, -0.08243528f, 0.01797427f, 0.14343724f, -0.14584047f, -0.08288170f, -0.11163501f, 
    0.12328570f, -0.05199060f, 0.09566171f, 0.03164311f, -0.01882609f, -0.06294851f, 0.09086066f, 0.00372619f, 
    0.14331456f, -0.15410431f, -0.01196656f, -0.19482568f, -0.11030425f, -0.28904596f, -0.04815844f, -0.08190215f, 
    -0.02538425f, -0.01261350f, 0.05791878f, 0.06208839f, -0.09300571f, -0.20253962f, -0.06855398f, -0.23842473f, 
    -0.39736584f, -0.04181974f, -0.02393300f, 0.22370341f, 0.29812238f, -0.13100441f, -0.11334943f, -0.06477167f, 
    0.24032213f, -0.07221280f, 0.18485250f, 0.17786007f, -0.25450614f, -0.12730888f, -0.40462384f, 0.07998262f, 
    0.02184876f, 0.13242139f, 0.10480894f, -0.17112176f, -0.04836810f, -0.02236168f, 0.01888452f, 0.34993225f, 
    -0.21634801f, -0.06429573f, -0.02058062f, -0.00971000f, 0.09364175f, 0.05798427f, 0.00456180f, -0.02724046f, 
    -0.04852248f, -0.20573308f, -0.03725896f, -0.05527686f, 0.20205964f, 0.20994771f, 0.01923317f, -0.18131109f, 
    0.03364385f, 0.00563027f, 0.14849652f, 0.12438462f, 0.05994435f, 0.09176695f, 0.16288680f, 0.07824327f, 
    -0.06335328f, -0.04386690f, 0.06872439f, 0.06760927f, 0.12345750f, 0.18416043f, 0.11702591f, -0.08214919f, 
    0.19498302f, -0.10759681f, -0.00632746f, 0.21280068f, 0.17698282f, 0.44751430f, 0.30835974f, -0.16313198f, 
    0.15605319f, 0.02945742f, 0.05575626f, 0.05774532f, 0.11903188f, -0.08301117f, 0.04716385f, 0.11263639f, 
    -0.26733658f, -0.18401504f, -0.15457942f, -0.02997626f, -0.05550306f, -0.01528280f, -0.04915965f, -0.07060491f, 
    0.29994223f, -0.02947803f, -0.03307426f, 0.17311600f, 0.06652835f, -0.52090079f, -0.08829276f, -0.16882037f, 
    0.06355605f, -0.04979179f, -0.04232928f, -0.15348302f, 0.15783428f, 0.02302876f, 0.17023718f, 0.03334310f, 
    -0.23924243f, 0.32495055f, 0.05810390f, -0.23484753f, -0.29490849f, 0.01994870f, 0.06149064f, -0.00910570f, 
    -0.04420009f, -0.08384041f, -0.08571255f, -0.07060830f, -0.32257304f, -0.05679824f, -0.14388479f, -0.41134119f, 
    0.07675303f, 0.01563071f, 0.15372072f, 0.16561052f, 0.05522206f, -0.13208461f, 0.00951148f, -0.03061679f, 
    0.25804752f, 0.33433035f, -0.10850830f, -0.14451933f, 0.03168333f, 0.07586629f, -0.06442668f, 0.04109062f, 
    -0.06320177f, -0.09311317f, -0.01647089f, -0.04030299f, 0.13418910f, 0.05865144f, 0.00852679f, -0.05528153f, 
    0.08541092f, -0.06536096f, 0.08187032f, 0.25929156f, 0.07175655f, 0.08790932f, 0.01534900f, 0.11681136f, 
    0.32465425f, -0.27441791f, 0.06563766f, -0.05234635f, -0.04005868f, 0.14114243f, -0.03447978f, 0.10051624f, 
    0.23869756f, 0.09302598f, 0.20905845f, 0.06038716f, -0.05801922f, -0.11974564f, 0.05282758f, -0.30424345f, 
    -0.03648801f, 0.02133740f, -0.09574563f, 0.04841590f, -0.13151371f, 0.09688767f, 0.04355367f, -0.07472754f, 
    -0.42633697f, 0.08070379f, -0.63217759f, 0.31393632f, 0.16952226f, -0.20229250f, -0.05065721f, -0.04435872f, 
    0.16348718f, 0.10281060f, -0.17519613f, 0.23969942f, 0.16536805f, -0.23025359f, 0.31467044f, -0.33813825f, 
    -0.01307553f, 0.17163891f, 0.19943060f, 0.09870635f, 0.19890958f, -0.10105305f, -0.17472486f, 0.02485481f, 
    0.01000629f, 0.19956599f, 0.18118642f, -0.15496744f, -0.03876470f, -0.08892202f, 0.26064822f, 0.12942618f, 
    0.07903343f, -0.08044568f, 0.01207075f, 0.18601829f, 0.11502023f, -0.04259253f, 0.19576085f, 0.02327248f, 
    0.09817709f, -0.08153024f, 0.01815863f, -0.00365350f, 0.05345958f, 0.03956435f, -0.08697825f, -0.22086546f, 
    0.41739842f, 0.23722443f, 0.05351935f, -0.12557298f, 0.00016808f, 0.03138990f, 0.09722050f, -0.03022744f, 
    0.06322481f, -0.08950037f, -0.01764855f, 0.13014939f, -0.46469787f, -0.29144239f, 0.16545534f, -0.03148701f, 
    -0.11346657f, 0.00839870f, -0.01729010f, -0.07490571f, 0.14963259f, -0.05920767f, 0.04737855f, 0.04593315f, 
    0.21275905f, -0.31996971f, -0.16593234f, -0.49783802f, 0.04084743f, 0.05783640f, 0.08974928f, 0.04226948f, 
    0.04112303f, 0.05173549f, -0.07069798f, -0.00637756f, 0.22993445f, -0.23628390f, 0.20504306f, 0.16866194f, 
    0.07853099f, -0.08438039f, 0.03380476f, 0.01323798f, 0.13098094f, 0.12519979f, -0.02331178f, 0.11997145f, 
    0.33674195f, 0.27758992f, 0.15981297f, -0.03013382f, 0.05759940f, 0.11762458f, 0.08227332f, -0.00622739f, 
    -0.08456243f, -0.07313855f, 0.15192990f, 0.08951356f, -0.16352701f, 0.05294022f, -0.18127035f, 0.01121497f, 
    -0.01325839f, 0.20535171f, -0.01387581f, 0.06524597f, 0.13217163f, 0.11114271f, -0.08032297f, 0.11530408f, 
    -0.07526405f, 0.08519946f, -0.38406041f, 0.10473043f, 0.18199278f, 0.00507850f, -0.02610509f, -0.06868912f, 
    0.05034924f, -0.10019892f, 0.13209739f, -0.05623048f, -0.22320506f, 0.05185955f, 0.12452817f, 0.23364002f, 
    0.07896176f, 0.11518668f, -0.01224686f, 0.03172498f, -0.01659825f, 0.06053856f, -0.09507189f, 0.05629887f, 
    -0.05172688f, 0.19788988f, 0.06332208f, -0.12956607f, 0.03070810f, 0.10494340f, 0.13738810f, 0.04000844f, 
    -0.05928906f, -0.07988902f, 0.02991409f, -0.05182509f, 0.38879842f, 0.16255575f, -0.13562800f, -0.01279399f, 
    -0.00026974f, -0.06109903f, -0.07163521f, -0.15299544f, 0.28458491f, -0.04928382f, 0.01318988f, -0.01738521f, 
    -0.01584284f, -0.08238942f, 0.08498371f, 0.21742076f, -0.16032957f, -0.03758384f, -0.04745447f, -0.05293561f, 
    0.25577489f, 0.06008291f, 0.08452939f, 0.16544949f, -0.01830663f, 0.08200803f, 0.00358231f, 0.16957748f, 
    -0.04095513f, -0.07375618f, -0.03346286f, -0.06869928f, -0.01362004f, -0.07078531f, -0.00419828f, -0.05529568f, 
    0.12206774f, 0.20029841f, 0.09986270f, 0.12376978f, -0.00805054f, -0.05115399f, 0.04429692f, 0.00125800f, 
    0.09116978f, 0.07168052f, -0.02507378f, -0.08222838f, -0.08604179f, -0.03020327f, 0.01214461f, 0.05862248f, 
    -0.05375618f, -0.00058941f, -0.07588729f, -0.13426165f, -0.01912316f, -0.04089497f, -0.00378533f, -0.09381457f, 
    -0.20249279f, -0.06119042f, 0.11198068f, 0.24002999f, 0.13829049f, -0.14547138f, -0.01926955f, -0.06111032f, 
    -0.00606740f, -0.02829930f, -0.00501018f, 0.21127088f, -0.32597834f, 0.18941201f, -0.00170996f, 0.13714761f, 
    -0.09921075f, -0.01157949f, 0.24781780f, -0.15894783f, 0.09969790f, -0.06970760f, -0.03376613f, 0.16630766f, 
    -0.03383336f, 0.09089292f, -0.06457898f, 0.09185804f, -0.03829463f, -0.06624844f, -0.10441314f, -0.04475937f, 
    -0.10660139f, -0.13920976f, -0.17668922f, -0.01587061f, 0.05007343f, 0.01633799f, -0.10597914f, -0.07791782f, 
    0.01835194f, 0.00845286f, 0.13442950f, 0.12719019f, 0.21342531f, 0.05733471f, 0.13081111f, 0.06422386f, 
    -0.22640070f, -0.03712071f, -0.03162402f, 0.07831102f, 0.02941762f, -0.04535088f, 0.15961584f, -0.13310342f, 
    0.18339986f, 0.07814141f, 0.07149469f, 0.17268389f, -0.10626338f, 0.18483520f, 0.18261363f, 0.00643555f, 
    -0.01813772f, 0.08416009f, -0.08992412f, 0.03444828f, 0.10469862f, 0.03901143f, 0.13363825f, 0.15523998f, 
    -0.10693360f, -0.01032012f, -0.01759893f, 0.01386246f, -0.12355711f, -0.03170644f, -0.06487888f, -0.02289362f, 
    0.23273118f, 0.04269872f, -0.00393007f, 0.11935683f, 0.06439113f, -0.01904772f, 0.14034791f, -0.18211964f, 
    -0.08568881f, 0.10976076f, -0.00607978f, -0.00258792f, 0.27179399f, 0.01140812f, -0.06192946f, 0.02359219f, 
    -0.05870695f, 0.12012257f, 0.26852000f, -0.19190100f, -0.06020723f, -0.11871938f, -0.04880283f, 0.08311936f, 
    -0.07408797f, -0.02377161f, -0.14605483f, -0.14529330f, -0.45328885f, 0.12854668f, -0.15458205f, 0.02084138f, 
    0.08055776f, -0.12702718f, 0.06932294f, 0.15591072f, -0.08111185f, -0.05180821f, -0.05333925f, -0.08966365f, 
    0.04783146f, -0.03422067f, -0.04929622f, -0.29433507f, -0.10280748f, 0.11380657f, -0.07601708f, -0.11886064f, 
    -0.08193427f, -0.11005549f, 0.10643043f, 0.06872758f, -0.00674543f, 0.02559255f, -0.00385014f, -0.13029443f, 
    0.16817436f, 0.04847399f, -0.07057936f, 0.17580993f, 0.01151971f, -0.00190919f, 0.08400060f, -0.02352462f, 
    0.00088939f, 0.08584345f, -0.18632312f, 0.16693549f, 0.04130019f, -0.01243695f, -0.08671031f, 0.04149642f, 
    -0.01726883f, 0.00198475f, 0.11421943f, 0.30295148f, 0.04029618f, 0.00848145f, -0.03754717f, -0.02613803f, 
    0.03315902f, 0.04724582f, 0.06820197f, -0.04425030f, -0.04946338f, 0.00863792f, -0.10840631f, 0.00701141f, 
    0.04532695f, 0.07519461f, -0.04303201f, -0.15678170f, 0.03285304f, -0.07437638f, 0.00123065f, 0.06341556f, 
    0.08182380f, -0.03530473f, 0.00719141f, 0.08754288f, 0.02735397f, -0.26116136f, 0.04059531f, 0.03210516f, 
    0.06986806f, -0.00376217f, 0.13171719f, 0.07087883f, 0.08461934f, -0.00076081f, -0.06479012f, 0.04674714f, 
    -0.06429413f, 0.00654558f, 0.23706271f, -0.21721075f, 0.05840134f, 0.10123208f, 0.24801761f, 0.21199200f, 
    0.10455563f, 0.03885672f, 0.10163712f, 0.26413578f, -0.01129510f, 0.00988955f, -0.01363438f, 0.06352948f, 
    -0.01331704f, 0.06503206f, -0.03880469f, -0.08917697f, -0.17268890f, -0.11181274f, -0.20780465f, -0.51242882f, 
    0.04655502f, 0.14139067f, 0.01761214f, -0.20836668f, -0.02000636f, 0.11792558f, 0.15177688f, 0.02077477f, 
    -0.02426626f, -0.04041041f, -0.10343994f, 0.03174940f, -0.61562282f, 0.04777004f, -0.00716962f, 0.12067425f, 
    -0.14117233f, 0.01812981f, 0.02127199f, -0.00789035f, 0.03742965f, 0.15558016f, -0.03416055f, 0.02003722f, 
    0.73371154f, -0.18667057f, -0.02507912f, -0.08930939f, 0.06457696f, 0.03033531f, -0.10816358f, -0.06175180f, 
    0.33802301f, -0.08262165f, -0.02381405f, 0.11712316f, 0.07005097f, -0.08289534f, 0.03837109f, 0.02567581f, 
    -0.00930110f, -0.13056101f, 0.08359967f, 0.07245239f, 0.12114712f, 0.15976243f, -0.04103569f, 0.08840264f, 
    0.13168192f, 0.00148620f, 0.27759513f, 0.10421852f, 0.12656690f, 0.17382963f, -0.05664541f, -0.10318100f, 
    -0.00848977f, -0.04839729f, -0.02845780f, 0.08220056f, -0.13802391f, 0.00201257f, -0.02477853f, 0.03333946f, 
    0.03695582f, 0.21056941f, -0.12675959f, 0.12190325f, -0.01313598f, 0.07249363f, 0.15034704f, 0.11802533f, 
    -0.31932616f, -0.02231336f, -0.24133933f, 0.16882043f, 0.05513099f, 0.12332394f, -0.03929286f, -0.22523354f, 
    -0.02761606f, -0.10184582f, -0.07035512f, -0.07393453f, -0.13827573f, 0.06170860f, 0.17622215f, 0.09041856f, 
    0.05030804f, -0.14178008f, -0.10281962f, 0.06296655f, 0.08028518f, 0.07476650f, 0.05673727f, -0.07713765f, 
    0.00385946f, -0.23300052f, -0.20459387f, 0.08801929f, 0.14491223f, 0.12864941f, 0.05856987f, 0.21041048f, 
    -0.02026750f, 0.01497392f, -0.01760732f, 0.01442853f, 0.39430574f, 0.20310955f, 0.09217149f, 0.24152081f, 
    -0.08638312f, 0.01396605f, -0.14084832f, -0.00599211f, 0.06457844f, 0.04762804f, -0.04782315f, -0.14912532f, 
    0.10133277f, -0.06091155f, 0.02450434f, -0.21956639f, 0.03947041f, 0.05184439f, -0.00335326f, -0.11851069f, 
    -0.06689651f, 0.18531887f, 0.05312530f, 0.13683090f, 0.14819761f, 0.28503641f, 0.16698466f, 0.14161019f, 
    -0.14446680f, -0.04264345f, -0.02765547f, -0.04205046f, -0.08519375f, -0.06312189f, -0.03955188f, -0.00963291f, 
    -0.02579018f, 0.24686652f, 0.12520230f, 0.19812773f, -0.12310832f, -0.05102880f, -0.00200210f, -0.10386658f, 
    -0.05811333f, -0.07241061f, -0.03594442f, -0.03912042f, 0.24652499f, 0.29257888f, 0.08189873f, 0.02901336f, 
    -0.18103984f, -0.14172761f, -0.06590723f, -0.02140497f, -0.03132237f, 0.01788626f, 0.06493542f, 0.00350449f, 
    -0.02785360f, -0.11437143f, 0.07185166f, 0.17713395f, -0.12385452f, -0.17295888f, -0.12821051f, -0.01306121f, 
    -0.13822126f, 0.10029785f, -0.09901211f, 0.16774847f, 0.30606446f, 0.07650618f, -0.08603610f, -0.10109028f, 
    0.01018479f, 0.11882449f, 0.06512704f, -0.05567072f, 0.16819780f, 0.05291417f, -0.17321756f, -0.06525088f, 
    0.00060307f, 0.06968272f, 0.12066559f, 0.09241235f, -0.12084007f, -0.17042500f, -0.07075153f, -0.03990436f, 
    0.06722645f, -0.04571539f, -0.03176725f, -0.11284042f, -0.02345599f, 0.11674835f, 0.00754105f, 0.09715838f, 
    -0.08197955f, 0.05084043f, 0.15133764f, 0.10218368f, 0.16095699f, -0.06821828f, 0.19111045f, 0.03329210f, 
    -0.11627098f, 0.00426659f, 0.09681609f, -0.06417694f, -0.05193890f, 0.00851925f, -0.07110178f, 0.01769965f, 
    0.09598832f, 0.17810443f, 0.12447552f, 0.07336310f, 0.06594818f, 0.10806635f, 0.02092678f, -0.04479981f, 
    0.08344081f, 0.10371293f, -0.00351595f, 0.10053645f, 0.00513096f, -0.00190770f, -0.09270191f, -0.03797121f, 
    0.06304294f, 0.08850581f, -0.03576166f, -0.06025121f, -0.05640767f, -0.04985480f, -0.09504759f, -0.03083994f, 
    0.08820257f, 0.20966734f, -0.01655374f, 0.02444734f, -0.02704450f, -0.11047555f, -0.09765709f, -0.10038158f, 
    0.02951985f, 0.21015346f, 0.10978335f, 0.05380386f, 0.01165312f, 0.04990156f, -0.00977569f, -0.04794011f, 
    0.07011046f, 0.02281368f, 0.13879542f, -0.07371113f, -0.01540301f, 0.07984783f, -0.00367216f, 0.19730803f, 
    -0.19386823f, -0.01451969f, -0.02136107f, 0.05817647f, 0.35741100f, 0.35427421f, 0.18706265f, 0.01752098f, 
    -0.00637253f, 0.05559073f, -0.15571694f, 0.14641200f, -0.12404578f, 0.09769822f, 0.02278604f, -0.14585401f, 
    -0.07226356f, -0.15684560f, 0.11257090f, -0.01845439f, -0.10326884f, -0.10332587f, -0.00013065f, 0.26645672f, 
    -0.08639819f, -0.09813096f, 0.01033888f, 0.02490853f, -0.01741638f, 0.10216118f, 0.09855005f, -0.03813291f, 
    -0.09553195f, -0.06756321f, -0.29348287f, 0.09547373f, -0.00940739f, 0.03851825f, -0.04414214f, -0.03114003f, 
    -0.20112291f, 0.04395432f, 0.00487434f, 0.03258706f, 0.15048036f, 0.04278381f, -0.09806261f, 0.02318153f, 
    -0.17506164f, 0.09824549f, 0.21495685f, 0.16254689f, -0.17034777f, -0.35065201f, -0.10473026f, 0.10051111f, 
    0.09734868f, 0.03678238f, -0.00204109f, -0.02870506f, 0.06518032f, -0.05960078f, 0.12959516f, -0.03391668f, 
    0.18205167f, 0.15238300f, 0.48816982f, -0.23770218f, -0.10023322f, 0.22970890f, -0.08726460f, -0.02195681f, 
    0.09698298f, -0.01788837f, 0.02104614f, -0.03396399f, -0.03445712f, 0.22873823f, -0.36112809f, -0.09478524f, 
    -0.00901450f, 0.12940219f, 0.05801321f, -0.13211271f, 0.04130137f, -0.01231540f, -0.07100415f, 0.04896010f, 
    0.10714636f, 0.08197916f, 0.08212666f, -0.09767650f, 0.01096088f, 0.17524184f, 0.17634420f, -0.07682994f, 
    0.11051200f, -0.01141163f, 0.03044658f, 0.05228331f, 0.22549853f, 0.00631163f, 0.14446589f, 0.08149737f, 
    0.08506629f, 0.07216119f, -0.05422729f, -0.14853372f, -0.13908504f, -0.08283140f, -0.12501602f, -0.32896802f, 
    -0.22696973f, -0.00004980f, -0.14971183f, -0.03353998f, 0.11369500f, 0.11258306f, 0.03684866f, 0.08144366f, 
    -0.06515227f, 0.15401345f, 0.02618656f, 0.02555485f, 0.28362328f, 0.01419136f, -0.27713621f, -0.21954457f, 
    -0.00260976f, 0.14222197f, 0.08353039f, -0.13103731f, -0.10429294f, 0.08489861f, 0.01829639f, -0.04137892f, 
    0.25792703f, -0.29292220f, -0.09646808f, 0.20552574f, -0.04959021f, -0.02812055f, 0.00049214f, 0.07497471f, 
    0.02339787f, -0.07680144f, -0.01330117f, -0.10266233f, -0.02940903f, 0.25247118f, -0.09810960f, -0.07266796f, 
    -0.03208449f, -0.09122492f, 0.09502856f, 0.05934775f, 0.05732156f, -0.01164954f, 0.16219930f, 0.01191808f, 
    0.03049248f, -0.06311245f, -0.12466615f, 0.12798719f, -0.03898038f, -0.06496754f, -0.11820893f, 0.04064502f, 
    -0.03716550f, -0.00851870f, -0.12849765f, 0.16908756f, 0.02025117f, -0.07840054f, 0.12749101f, -0.03167074f, 
    0.06410135f, 0.11060672f, -0.00189879f, 0.10661092f, -0.00496578f, 0.01443450f, 0.20246916f, 0.15731062f, 
    -0.06670713f, -0.04590954f, 0.39829323f, -0.23577525f, 0.10582892f, -0.10865285f, -0.01094317f, -0.04645201f, 
    -0.00303096f, 0.04836426f, -0.04510632f, 0.06628560f, -0.02811291f, 0.12030982f, 0.37597373f, -0.14539680f, 
    0.04242543f, 0.01524245f, -0.05758350f, 0.01939396f, 0.06830151f, -0.07678401f, -0.18874711f, 0.08779460f, 
    0.05012339f, 0.02357604f, 0.04298861f, -0.00185196f, -0.01105956f, 0.04726124f, -0.02993440f, -0.03131095f, 
    0.02775561f, -0.04961265f, -0.00523206f, 0.00789001f, 0.00003458f, -0.05524379f, 0.01697987f, -0.03426988f, 
    -0.04630264f, -0.04757389f, 0.03651686f, -0.02798247f, 0.03042913f, -0.03684627f, -0.00278120f, -0.00785534f, 
    -0.02350271f, 0.02555587f, 0.01828639f, 0.01163614f, -0.03588776f, -0.03955789f, 0.03398924f, -0.04744631f, 
    -0.02681708f, 0.00249207f, -0.00257896f, 0.01617988f, 0.01135915f, -0.03480979f, 0.02679540f, -0.00532775f, 
    0.00281905f, -0.00945413f, 0.00002509f, 0.03459906f, 0.03416123f, -0.05499626f, -0.04167655f, 0.01387046f, 
    -0.04221592f, 0.03744232f, -0.03354862f, -0.03263946f, 0.00342081f, 0.02245330f, -0.05192024f, 0.03046741f, 
    0.02215190f, 0.04057040f, -0.05181131f, 0.00189470f, 0.00432591f, -0.03073859f, -0.03498267f, -0.01842778f, 
    -0.03934450f, -0.05528336f, -0.04245688f, 0.01880333f, -0.04493229f, -0.02371593f, -0.03411550f, -0.00707514f, 
    -0.02411777f, -0.05343549f, -0.02251456f, -0.03602516f, 0.02809172f, 0.02520201f, 0.00073712f, -0.04539651f, 
    0.00462504f, 0.01095434f, -0.01030683f, -0.02598273f, 0.01205772f, 0.01865927f, 0.02515415f, 0.02244513f, 
    0.01255066f, 0.04113700f, 0.02008827f, -0.05063712f, 0.02689941f, -0.01130147f, -0.02686286f, -0.05288281f, 
    -0.00663457f, 0.03533697f, 0.00835701f, -0.03364286f, 0.03781353f, 0.03508887f, -0.05525551f, -0.02633497f, 
    -0.04947997f, 0.01740416f, -0.04694788f, -0.01732993f, 0.03695662f, 0.00137811f, 0.01279392f, -0.02358603f, 
    0.04200005f, -0.05039794f, 0.03317448f, 0.00768281f, -0.02645253f, -0.01561411f, 0.02135074f, 0.02596127f, 
    0.03668268f, 0.00981074f, -0.01569108f, -0.00973046f, 0.03766505f, -0.00866019f, 0.04169853f, 0.03041310f, 
    0.00856365f, -0.02967096f, -0.04726023f, -0.00038198f, 0.04042646f, -0.01890448f, 0.00865037f, -0.01021110f, 
    0.02809690f, 0.01570615f, 0.01020086f, -0.00045782f, -0.02299167f, -0.04765816f, -0.01208102f, -0.01699718f, 
    0.00905543f, -0.02700136f, -0.00062105f, 0.04214231f, 0.03138816f, -0.04513909f, -0.04050235f, 0.01979318f, 
    -0.03648485f, 0.03951550f, 0.00503692f, -0.05614382f, -0.03134292f, 0.00278522f, -0.02284719f, -0.04682445f, 
    0.01200871f, 0.00546544f, -0.02466615f, -0.02750251f, 0.04908498f, -0.02715856f, -0.03005194f, 0.00194927f, 
    0.00877235f, 0.02908264f, -0.04103499f, -0.02027825f, -0.02983958f, -0.04366073f, -0.04984367f, -0.00079992f, 
    -0.00813028f, -0.02037354f, -0.04424011f, -0.04616540f, 0.01662014f, -0.03907454f, 0.02491830f, -0.03742456f, 
    0.01173163f, -0.01224774f, -0.04422863f, -0.04746118f, -0.04883762f, -0.03053482f, -0.02844428f, 0.04057966f, 
    -0.04778179f, -0.02247895f, 0.01717369f, -0.02403815f, 0.01617905f, 0.01081057f, 0.04792815f, 0.00366103f, 
    0.03357105f, 0.01125984f, 0.02928881f, -0.04969689f, -0.03907384f, -0.01284338f, -0.02030076f, 0.04710294f, 
    -0.03711896f, -0.04624735f, -0.01222756f, -0.04449295f, -0.00289542f, 0.03093138f, 0.00209454f, -0.02636855f, 
    -0.05049079f, 0.03339663f, -0.01573968f, 0.02209598f, 0.00183589f, 0.04290134f, -0.00291504f, -0.00553033f, 
    -0.00382264f, -0.01990619f, 0.03328013f, -0.00079541f, 0.03611467f, -0.02015385f, 0.03116389f, 0.01301536f, 
    0.00378953f, 0.01286781f, -0.04795845f, -0.00713396f, -0.02886310f, 0.03147758f, -0.02676625f, -0.04662089f, 
    0.02043491f, 0.04546950f, 0.04269532f, 0.00455622f, 0.04541841f, -0.01205859f, -0.01490867f, -0.02798478f, 
    -0.03856831f, 0.01329707f, -0.01808304f, -0.00339734f, 0.02115586f, 0.00353027f, -0.05228090f, 0.01453227f, 
    0.00170958f, -0.02265788f, 0.02287642f, -0.01178023f, -0.00534151f, 0.01551613f, -0.04241438f, 0.01940798f, 
    -0.03411619f, -0.01041177f, -0.02224709f, 0.03464551f, -0.03745420f, 0.04014071f, -0.01884237f, -0.02712856f, 
    -0.04334072f, 0.02608830f, 0.03732903f, 0.02370862f, 0.01678385f, -0.04973226f, -0.01867068f, 0.04247237f, 
    0.01039476f, 0.01664455f, -0.04221286f, -0.04897317f, -0.04200784f, -0.01224722f, -0.00460306f, 0.04910348f, 
    -0.04694873f, 0.00254171f, -0.00496770f, 0.03512940f, -0.02137107f, 0.01402196f, -0.04363901f, 0.03808523f, 
    0.01890218f, -0.00572537f, 0.03637889f, -0.00857159f, -0.00473306f, -0.00111371f, -0.03924797f, 0.00853676f, 
    0.02476613f, -0.00521698f, -0.05635446f, 0.00162840f, 0.01367448f, 0.03873076f, 0.04017748f, -0.01831915f, 
    0.03432905f, -0.03189847f, 0.04041828f, -0.05431416f, 0.01746437f, -0.00275808f, 0.02721881f, 0.00831150f, 
    0.01773725f, -0.00481085f, 0.00525885f, -0.01170202f, -0.05126577f, 0.01047921f, -0.01916434f, 0.01135034f, 
    0.03133200f, -0.02514480f, 0.02545873f, 0.01009375f, -0.01463515f, -0.02729210f, -0.00325320f, -0.01598492f, 
    0.03377356f, 0.01726424f, -0.01891768f, -0.00359109f, -0.05080216f, -0.03969887f, 0.03173258f, 0.04752588f, 
    -0.03068660f, 0.01322549f, 0.02506628f, -0.04348859f, -0.01881979f, -0.00630740f, -0.03426313f, 0.03372817f, 
    -0.02337219f, -0.01090760f, 0.00483325f, -0.03699180f, 0.01444609f, -0.04387790f, -0.02628034f, -0.04192328f, 
    0.01631896f, -0.00478658f, -0.00153513f, -0.04388388f, -0.03062876f, -0.05033028f, 0.02598301f, -0.05575538f, 
    0.02500023f, -0.02438236f, -0.04714163f, -0.03682572f, 0.00457126f, -0.03752632f, 0.00148602f, 0.00045598f, 
    -0.03660600f, 0.00081923f, 0.02865781f, -0.01969998f, -0.02466856f, -0.03205004f, 0.00455907f, 0.02261499f, 
    -0.10302468f, 0.20950422f, 0.05639452f, -0.16632524f, 0.03342482f, -0.06223466f, 0.09351403f, -0.06805642f, 
    0.00705342f, -0.02790977f, 0.04726858f, -0.05437546f, 0.29431868f, 0.00544934f, 0.13595894f, 0.14703041f, 
    0.00750338f, -0.12421010f, -0.12569982f, 0.04092629f, -0.03059383f, -0.03650140f, 0.05948924f, 0.03528427f, 
    -0.30988333f, -0.12606545f, -0.00809161f, 0.24734028f, -0.08996659f, -0.08750591f, -0.04742173f, -0.06507838f, 
    0.11714991f, -0.01946046f, 0.17422041f, -0.03761268f, 0.06936501f, 0.15562178f, -0.09947325f, 0.16327736f, 
    -0.10231620f, -0.02127957f, 0.02623040f, -0.00659402f, -0.05706638f, -0.05922285f, -0.03448373f, -0.06066484f, 
    0.38434020f, 0.16977671f, 0.09066386f, 0.14989923f, 0.00936508f, 0.02031818f, 0.07369453f, 0.05024337f, 
    0.01052354f, 0.13107361f, -0.10448719f, -0.06371949f, 0.06584497f, 0.11673934f, -0.03886511f, 0.09677436f, 
    0.00117128f, 0.02030288f, -0.04082037f, 0.08966583f, -0.00913960f, -0.08964329f, 0.02797235f, -0.06791136f, 
    -0.29881182f, 0.02201665f, 0.13872147f, 0.00609152f, 0.13934107f, 0.09945329f, -0.02996182f, -0.05104006f, 
    0.16039161f, -0.07259671f, 0.09231482f, 0.05969938f, -0.57358837f, -0.06547520f, 0.39612141f, 0.14881562f, 
    0.07152209f, 0.17542873f, 0.05970681f, 0.07462707f, 0.15885681f, -0.08523209f, 0.01729044f, -0.01543956f, 
    0.06835715f, -0.05917023f, 0.02000153f, 0.07621115f, 0.04890445f, -0.06178858f, -0.00612099f, -0.07379004f, 
    -0.05330743f, -0.04448869f, 0.02236710f, 0.08919568f, 0.09692985f, -0.02880471f, 0.05903271f, 0.08297711f, 
    0.05027670f, 0.00393969f, 0.00439916f, 0.05533485f, 0.09879988f, 0.09175397f, 0.08225033f, 0.03589406f, 
    -0.20746434f, 0.07813977f, 0.12596554f, 0.03152228f, 0.13764431f, 0.01698612f, 0.10127806f, -0.01521532f, 
    0.03305981f, 0.03085263f, 0.07563931f, 0.08388151f, -0.10714576f, 0.11430091f, 0.17797619f, 0.04981354f, 
    -0.15687078f, 0.03558540f, -0.02180079f, -0.09462109f, 0.12565976f, 0.08996523f, 0.11975168f, -0.01986137f, 
    0.12952104f, -0.02085433f, -0.02686581f, 0.06596192f, -0.10389214f, 0.01496128f, -0.00437944f, 0.04605096f, 
    0.10445174f, 0.01989857f, -0.04651533f, 0.08938009f, 0.03296594f, -0.15363899f, 0.15958931f, -0.23364826f, 
    0.04288670f, -0.05119900f, -0.08013635f, -0.08357729f, -0.01777467f, -0.15607947f, 0.00418406f, 0.00633081f, 
    0.04614120f, 0.06851019f, 0.07037280f, -0.15985599f, -0.31647736f, -0.19168843f, 0.01824742f, -0.04853767f, 
    -0.04743069f, -0.09932952f, -0.09587936f, 0.01279486f, -0.49943796f, 0.30147204f, -0.06207588f, -0.08373679f, 
    -0.07757246f, -0.19837023f, 0.13493238f, 0.07278038f, -0.02476407f, -0.01107502f, 0.08911975f, -0.09813356f, 
    -0.00003501f, 0.12080593f, 0.06927550f, -0.42799482f, -0.17480889f, -0.03155782f, -0.13840814f, 0.03644304f, 
    0.07108003f, -0.04205601f, 0.12315562f, 0.01343767f, 0.21228540f, 0.23455258f, -0.08060408f, -0.15868504f, 
    0.00838626f, -0.06296784f, 0.01640236f, 0.16059238f, 0.02334911f, 0.00271614f, -0.00332680f, -0.03402291f, 
    -0.02812552f, 0.16004467f, -0.23577720f, 0.35587010f, -0.09253677f, -0.08674261f, 0.01117092f, -0.07008290f, 
    -0.00701695f, -0.00031026f, 0.10271252f, 0.09473787f, 0.08413672f, 0.06083442f, 0.17700881f, -0.29738995f, 
    -0.01417596f, -0.08453773f, -0.03532349f, -0.01341931f, -0.00616319f, 0.06022925f, -0.01723778f, -0.00117069f, 
    -0.09089645f, -0.14442076f, 0.35810372f, -0.17908083f, 0.13185282f, -0.15779504f, 0.18544321f, 0.15033615f, 
    -0.02453886f, -0.00815439f, -0.13610634f, 0.25178289f, -0.37814963f, -0.15726323f, 0.04721342f, 0.08506919f, 
    -0.01689133f, 0.11365555f, 0.19207664f, 0.12219498f, 0.06841961f, -0.04926737f, -0.05789779f, 0.01397682f, 
    -0.06414434f, 0.14660619f, 0.20672162f, -0.09643228f, -0.12127402f, 0.19011313f, 0.10911594f, 0.16473511f, 
    0.01374747f, -0.03150486f, -0.01748613f, 0.08076705f, -0.14479044f, 0.09518743f, 0.15852779f, -0.15659074f, 
    -0.02962051f, -0.04498390f, -0.07289422f, 0.01791275f, 0.01983358f, 0.02814320f, -0.04576653f, -0.18139379f, 
    0.11860541f, 0.30288389f, 0.16967085f, -0.06539308f, -0.04396562f, 0.08819664f, 0.09523980f, 0.02161638f, 
    0.06011781f, -0.14469880f, -0.03908484f, -0.00606860f, -0.97109157f, 0.33725601f, -0.02036550f, 0.20310992f, 
    -0.06675794f, -0.06429736f, 0.01631275f, -0.02170384f, 0.06549492f, 0.04059272f, 0.01025975f, 0.04251610f, 
    0.42749196f, -0.30536857f, 0.15637869f, -0.48626029f, 0.02467347f, -0.00819019f, -0.05928288f, 0.19622393f, 
    0.05571296f, 0.02411736f, -0.05970627f, 0.05132849f, -0.08712577f, -0.04671909f, -0.02623389f, 0.56174546f, 
    0.03930785f, -0.10630752f, 0.18989256f, 0.01746523f, 0.09035677f, 0.14532024f, -0.09101754f, 0.14824721f, 
    0.16442125f, 0.15124512f, 0.31859022f, -0.04471731f, -0.02012561f, 0.10340646f, -0.11330791f, 0.01848953f, 
    0.06212767f, 0.04477606f, 0.01730696f, -0.04351734f, -0.20955414f, 0.01595481f, 0.10853811f, -0.02284089f, 
    -0.05825726f, 0.12922715f, -0.11859287f, 0.12913987f, -0.04797041f, -0.01050964f, 0.00561973f, -0.02951669f, 
    0.16160497f, 0.06875908f, -0.10496874f, 0.03053861f, 0.32015949f, -0.04263377f, -0.11644661f, 0.00256485f, 
    -0.13438150f, 0.09335256f, -0.10340141f, 0.06810710f, -0.30111045f, 0.16745183f, 0.16417234f, 0.35210466f, 
    -0.01380707f, -0.05465756f, -0.02207008f, 0.11306705f, -0.06801758f, 0.07621238f, 0.07021132f, 0.00022226f, 
    -0.00085940f, 0.01311043f, 0.04037617f, -0.00077451f, 0.03647811f, 0.00828907f, -0.04830304f, 0.02560052f, 
    -0.05286369f, -0.00297885f, 0.03970573f, 0.00154963f, -0.03698228f, -0.00063137f, -0.04834948f, -0.01980816f, 
    0.04546057f, -0.05155474f, 0.02181539f, 0.02184170f, -0.04910316f, -0.05170695f, 0.03311790f, 0.03753202f, 
    -0.05086366f, -0.00030892f, -0.00970219f, 0.03205470f, -0.03768340f, -0.01273104f, 0.03119625f, -0.02530758f, 
    -0.02269140f, -0.05277011f, -0.04510731f, 0.00028547f, -0.03509834f, 0.04189241f, -0.01460130f, -0.02578830f, 
    0.02594796f, -0.03339400f, -0.02102131f, -0.02535241f, -0.04418403f, -0.05095936f, -0.01758681f, -0.02221712f, 
    -0.03670679f, 0.03715522f, -0.03004182f, -0.04688415f, 0.01199792f, -0.03909456f, 0.03715063f, 0.00176462f, 
    0.02275774f, -0.00083499f, 0.01471502f, 0.02890394f, -0.01588390f, -0.00963112f, 0.02482277f, -0.00988610f, 
    0.03003455f, 0.04334329f, -0.01259831f, -0.05330532f, -0.00647824f, 0.00579429f, -0.01369826f, 0.00548563f, 
    0.04559492f, -0.04461568f, -0.02525282f, 0.00766270f, 0.00484825f, 0.03801466f, -0.04451986f, 0.03946361f, 
    -0.03739504f, 0.00200348f, 0.01020572f, -0.05561607f, 0.01529014f, -0.00257113f, -0.03074073f, -0.02050776f, 
    -0.04683799f, -0.02063823f, -0.05538758f, 0.00983912f, -0.00138624f, -0.04968940f, -0.00060338f, 0.00102480f, 
    0.02176903f, 0.00235119f, 0.04442128f, -0.03214824f, -0.01284283f, -0.03085706f, 0.03446231f, -0.01989229f, 
    -0.02452172f, 0.02351750f, 0.02711810f, -0.05334205f, 0.01827047f, -0.05517044f, -0.04444404f, -0.01084727f, 
    -0.01119533f, -0.03571575f, -0.04714346f, -0.01986839f, 0.03473831f, -0.04203633f, -0.03533168f, -0.00801212f, 
    0.01478076f, 0.01107453f, -0.01599056f, 0.04313576f, -0.01802159f, 0.02618768f, 0.00605393f, 0.03869325f, 
    -0.04807523f, -0.00263641f, -0.03612249f, -0.05074311f, -0.02492028f, -0.00209347f, 0.00251508f, -0.02133537f, 
    0.02398820f, 0.02685034f, 0.01883200f, -0.04395357f, 0.04349650f, -0.05104323f, -0.01244123f, 0.02690174f, 
    -0.02119181f, 0.02132318f, -0.04967453f, -0.01778588f, -0.00652720f, 0.04480278f, -0.02418986f, 0.03906990f, 
    -0.02462846f, -0.00848504f, 0.04511490f, -0.02317503f, -0.01969877f, 0.01063886f, -0.01282605f, -0.01678721f, 
    -0.03969615f, 0.01213550f, 0.02239806f, -0.00755405f, -0.01939155f, 0.02761808f, -0.01505110f, -0.01210100f, 
    0.01270626f, 0.03296698f, -0.05527152f, -0.04158625f, -0.02837321f, -0.04055391f, -0.01455521f, -0.03572366f, 
    0.02148930f, -0.00453947f, -0.00424633f, -0.04982385f, -0.00324779f, -0.04562528f, 0.04165275f, -0.00739902f, 
    -0.00971409f, -0.03784635f, 0.00286909f, 0.03667647f, -0.04236060f, 0.00432302f, -0.03198159f, 0.01170843f, 
    -0.00409750f, -0.04723211f, -0.04778124f, 0.00437797f, -0.02682175f, -0.02266403f, -0.02251058f, -0.05361409f, 
    0.03053418f, -0.03188933f, -0.01444311f, -0.03837100f, -0.03308026f, -0.02813475f, -0.04728718f, -0.02078089f, 
    -0.03137258f, 0.00216465f, -0.02527893f, -0.04554739f, 0.03651440f, 0.04221760f, 0.00010962f, -0.03187639f, 
    -0.01669345f, -0.00809534f, -0.03464685f, -0.04412420f, 0.03310923f, 0.00994643f, 0.03166704f, -0.04038841f, 
    0.00198339f, 0.00472319f, -0.03156042f, -0.01009457f, -0.04695350f, -0.01335622f, 0.03937023f, -0.00432147f, 
    0.02393320f, 0.03086901f, -0.00495853f, 0.01446967f, 0.00646748f, 0.00767789f, 0.04291135f, 0.02611716f, 
    0.00790694f, -0.00375887f, 0.01544627f, -0.05067284f, -0.03413905f, -0.03048698f, 0.03185641f, -0.02672272f, 
    0.02038344f, 0.00041406f, -0.03174194f, -0.04404679f, -0.01295682f, -0.04526338f, -0.02126345f, 0.01904498f, 
    0.00176701f, 0.04979721f, -0.01559469f, -0.00422714f, -0.04283368f, -0.01642930f, 0.01296272f, -0.03538710f, 
    0.01275192f, 0.02978793f, 0.04970968f, -0.02858075f, -0.01709420f, -0.02861313f, 0.01745658f, 0.02084518f, 
    -0.03480712f, -0.03499235f, -0.01638811f, -0.01541696f, 0.02887828f, -0.02194418f, -0.04944718f, 0.03562252f, 
    0.01237147f, -0.04673134f, 0.04288465f, -0.05149745f, -0.05317911f, -0.00275216f, -0.04927145f, -0.01232566f, 
    0.02526561f, -0.00294849f, -0.03909028f, -0.01462909f, 0.02937885f, -0.01070830f, -0.02690875f, 0.00248780f, 
    -0.01576605f, -0.05606647f, -0.05079598f, -0.05209962f, 0.00793422f, 0.00314822f, -0.00354659f, 0.03892978f, 
    0.03432149f, -0.00801551f, -0.03309016f, 0.00257061f, -0.02237301f, 0.02171750f, -0.02096797f, 0.03891619f, 
    -0.02889750f, -0.04831051f, -0.01192128f, 0.03824879f, -0.03328031f, -0.04672766f, 0.01492529f, 0.02393159f, 
    -0.02510940f, 0.01062762f, -0.00844605f, -0.00634165f, 0.03598377f, -0.00305178f, -0.01370782f, 0.01841406f, 
    -0.02945648f, -0.02669090f, 0.00926170f, 0.01264277f, 0.00598344f, 0.01392542f, -0.02058474f, 0.00276303f, 
    0.01795253f, 0.02619660f, 0.01889148f, -0.01644735f, -0.03833484f, -0.05513458f, -0.05333531f, -0.01917690f, 
    0.03544455f, -0.01355826f, -0.02829240f, 0.01703106f, -0.03290246f, 0.01418580f, 0.04142790f, -0.04656431f, 
    -0.00648795f, 0.02333192f, 0.02045998f, -0.05252116f, 0.02073524f, -0.00454959f, 0.03551055f, -0.03282219f, 
    -0.05011684f, 0.01253345f, -0.01227315f, 0.01949827f, -0.02514675f, -0.00768761f, 0.03187649f, -0.02613345f, 
    0.04536035f, -0.05306627f, 0.01096287f, 0.03507112f, 0.00171533f, -0.05631055f, 0.01034135f, -0.02389660f, 
    -0.03444705f, 0.01592869f, -0.01551504f, -0.00293968f, 0.01118268f, -0.01940753f, 0.04438418f, -0.00647520f, 
    -0.18900473f, 0.17290676f, 0.32044423f, 0.07580868f, 0.04308232f, -0.00472077f, 0.14899692f, -0.07808746f, 
    0.19691490f, 0.21269301f, -0.00993193f, 0.13946366f, 0.05713474f, 0.31642857f, 0.20941640f, -0.02699780f, 
    0.04060806f, -0.04613892f, 0.06681905f, 0.07795274f, -0.05146161f, 0.21882217f, 0.05788590f, 0.14927825f, 
    -0.19592015f, 0.02028872f, -0.09870318f, 0.01427225f, 0.05286995f, -0.08312360f, -0.08928103f, -0.02906992f, 
    0.11422545f, 0.10948354f, 0.10695216f, 0.08407843f, 0.06321885f, -0.14135402f, -0.03288479f, -0.08973917f, 
    -0.02616946f, -0.06145943f, -0.04349954f, -0.04156648f, -0.02011717f, -0.06439639f, -0.09699094f, -0.08554247f, 
    0.50201315f, 0.01550952f, 0.14366212f, 0.04542082f, 0.01004970f, 0.01890185f, -0.01834967f, -0.00358829f, 
    0.07753844f, 0.09987517f, 0.11462194f, 0.01312417f, -0.03293536f, -0.00833957f, -0.04557409f, -0.03292919f, 
    -0.02634098f, 0.07999951f, 0.06920038f, -0.05960902f, -0.05085810f, -0.07396857f, -0.05054875f, -0.02699520f, 
    0.22151408f, -0.00564946f, -0.18076763f, -0.05678868f, 0.05268690f, 0.12441549f, 0.06793611f, -0.02861448f, 
    0.17499864f, 0.02277473f, 0.08731953f, 0.10746785f, 0.26526389f, -0.16017498f, 0.18443032f, 0.28664845f, 
    0.19739689f, 0.03387378f, 0.00662198f, 0.10674531f, 0.06332531f, 0.00948669f, -0.03695565f, 0.06242954f, 
    0.14181313f, -0.09979039f, -0.11483935f, -0.10853606f, -0.07212645f, 0.02094890f, -0.06250598f, -0.10850143f, 
    0.11353229f, -0.00570436f, 0.22258985f, 0.10363763f, -0.20284334f, -0.04470410f, 0.33756608f, 0.18187511f, 
    0.23109423f, 0.23587146f, 0.10454109f, -0.02485089f, -0.00760273f, 0.12660536f, -0.14073089f, -0.05354529f, 
    -0.01223604f, 0.02876382f, -0.20774844f, 0.13679922f, 0.20564924f, -0.10265236f, 0.04676459f, 0.13156164f, 
    -0.14232977f, 0.03715335f, -0.02641631f, -0.12292963f, -0.30829391f, -0.35649121f, 0.14718634f, 0.26536760f, 
    0.03436029f, -0.01301184f, 0.05318795f, -0.00368961f, 0.03248032f, 0.03547137f, 0.03986708f, -0.01058664f, 
    0.09398783f, -0.12106875f, -0.07899114f, -0.10393301f, -0.03014774f, -0.02528950f, -0.01648923f, -0.02940593f, 
    -0.00930714f, -0.10021894f, -0.06184619f, -0.01397577f, 0.17255734f, 0.44632491f, 0.39744234f, 0.27646583f, 
    0.02397703f, -0.07332964f, 0.02520773f, 0.21237227f, 0.09994196f, 0.09827268f, 0.05739590f, 0.10389029f, 
    0.00880767f, -0.20323004f, 0.06998333f, 0.01235880f, 0.07633504f, 0.09997512f, 0.19717468f, 0.04539779f, 
    0.12664811f, 0.16135021f, 0.06447209f, 0.10813601f, -0.20457074f, -0.13614275f, 0.15325664f, 0.37591690f, 
    0.04481314f, -0.04295029f, 0.08104747f, -0.04119565f, 0.05032975f, -0.07126760f, -0.07750499f, 0.02435701f, 
    -0.04074172f, 0.07201426f, 0.02621922f, 0.22033307f, 0.16560215f, 0.14584525f, 0.22723073f, -0.01676957f, 
    0.10469847f, 0.13261548f, 0.05357266f, -0.01055448f, 0.24794585f, 0.03987626f, 0.20429122f, 0.30381307f, 
    0.16668089f, 0.17400002f, 0.25277594f, 0.11077392f, 0.02489821f, 0.02813153f, -0.08734039f, 0.06280884f, 
    -0.01290293f, 0.07402977f, 0.12799813f, 0.03329579f, 0.07511313f, 0.08279217f, 0.12356241f, 0.08093608f, 
    0.07564341f, 0.03927433f, -0.00517060f, -0.11120438f, 0.17115454f, 0.41196084f, 0.13851686f, -0.09311060f, 
    0.00059453f, 0.01651365f, 0.04986643f, 0.06928577f, 0.26971689f, 0.16682871f, 0.00149453f, 0.04450879f, 
    0.21445321f, 0.07919233f, -0.16339184f, 0.04129717f, 0.17248234f, 0.08869735f, 0.01250677f, -0.02436520f, 
    -0.06546250f, -0.03908932f, -0.07765885f, -0.04622543f, -0.24619758f, -0.12013474f, 0.11973000f, 0.22568555f, 
    0.32986236f, 0.09625607f, -0.13197470f, 0.18260969f, -0.07493730f, -0.06672125f, 0.05770558f, -0.09701788f, 
    -0.03525871f, -0.17286307f, -0.01366872f, 0.25560749f, -0.02844897f, 0.02713536f, -0.05155790f, 0.21100277f, 
    -0.04552966f, -0.02861846f, -0.07177991f, -0.08876602f, -0.16725409f, 0.13264847f, 0.09320220f, -0.06120155f, 
    -0.00823424f, 0.02067867f, 0.13875060f, 0.12675236f, 0.22037573f, 0.10818385f, 0.12012634f, 0.32941055f, 
    -0.13924357f, -0.07015510f, 0.17989919f, 0.16591401f, -0.02118949f, -0.02234379f, -0.04062195f, 0.06993297f, 
    0.07405037f, -0.04415583f, -0.08391842f, -0.05390236f, -0.19555481f, 0.19982672f, 0.27424616f, 0.32367942f, 
    0.09649383f, -0.04392708f, -0.00731591f, 0.01656337f, 0.08745950f, 0.03299598f, 0.09646308f, 0.18927847f, 
    0.06311759f, 0.61884296f, 0.27613431f, -0.22577854f, -0.02804520f, 0.04915862f, 0.16305298f, 0.07579635f, 
    -0.04442863f, 0.23496556f, 0.36339203f, 0.06895377f, -0.10659197f, -0.06570829f, -0.03818073f, 0.25667992f, 
    0.15424533f, 0.12909065f, 0.02341438f, 0.09877853f, 0.13408098f, 0.07154639f, 0.25193694f, 0.10237502f, 
    -0.16163772f, 0.08371869f, 0.13739879f, -0.00062327f, -0.02765047f, 0.15835698f, 0.12315530f, 0.14060648f, 
    0.04841434f, 0.03132516f, -0.00023797f, -0.08908544f, -0.06390598f, -0.05341711f, -0.18582015f, 0.02297103f, 
    0.27131155f, -0.05291668f, 0.11835665f, 0.08252920f, 0.03655865f, -0.09614737f, -0.08664550f, -0.14825164f, 
    0.26389143f, -0.20451868f, -0.15989636f, 0.03191504f, 0.07114818f, 0.14411683f, 0.11119863f, 0.25517550f, 
    -0.00607382f, 0.07233864f, -0.05056663f, 0.03093282f, 0.25211367f, -0.08928489f, -0.15940998f, 0.25028628f, 
    0.07493833f, -0.01396289f, 0.06415544f, 0.09461768f, -0.00719050f, 0.04873017f, 0.05990551f, -0.05431388f, 
    -0.02220624f, 0.27570614f, 0.18348679f, 0.01509319f, 0.02376414f, -0.12072432f, 0.03048490f, 0.02491200f, 
    0.14899552f, -0.04009723f, 0.07261784f, -0.01203816f, 0.02600053f, -0.02701781f, 0.07416427f, -0.18361089f, 
    0.09945871f, -0.07642768f, -0.04050185f, 0.14892289f, -0.10713936f, 0.03104785f, 0.17345554f, 0.11741048f, 
    0.06353763f, 0.16993976f, 0.23896381f, 0.21263839f, 0.03654881f, -0.18664788f, -0.04857835f, -0.00487300f, 
    0.05837462f, -0.05752339f, 0.00715901f, -0.09296680f, -0.19311278f, -0.31819412f, -0.17749375f, -0.05026373f, 
    0.04693111f, 0.00793093f, 0.00115949f, -0.07297244f, 0.15563965f, 0.06230595f, -0.06442273f, 0.08519869f, 
    -0.00024363f, -0.10204163f, -0.10831075f, 0.02018690f, 0.01946545f, 0.01205831f, 0.04544312f, -0.02203835f, 
    0.09738587f, 0.12364480f, -0.06015554f, 0.00545788f, -0.16590312f, -0.40294239f, -0.11859956f, 0.03175418f, 
    0.16899373f, 0.06290857f, 0.15420179f, 0.06130880f, 0.08004484f, -0.02768896f, 0.02795324f, 0.01087788f, 
    -0.29497102f, 0.24436945f, -0.04246156f, -0.10237508f, 0.04905146f, 0.11222981f, -0.00310398f, 0.02001158f, 
    0.19986907f, 0.04172197f, 0.03765623f, -0.14299907f, -0.43059567f, -0.02197950f, 0.23216362f, -0.06916910f, 
    0.16005640f, -0.09350173f, 0.08198967f, 0.08987141f, 0.00452189f, -0.03919345f, 0.02131708f, 0.13953599f, 
    -0.01160440f, -0.18476158f, -0.27352455f, -0.01965206f, 0.11450703f, 0.04427547f, 0.07156703f, -0.02248472f, 
    0.09153397f, 0.16010533f, 0.06789027f, 0.15881479f, 0.13623051f, -0.20579545f, 0.11291745f, 0.03383639f, 
    0.16306244f, 0.11299164f, -0.05817287f, 0.20425656f, -0.01414903f, 0.08692352f, -0.13314693f, -0.10267524f, 
    -0.19201197f, -0.03862658f, 0.00013219f, 0.15546152f, 0.02964840f, 0.15384892f, 0.16408834f, -0.13254280f, 
    -0.09299131f, -0.18487152f, -0.17637534f, -0.09914668f, -0.03601762f, -0.07013236f, 0.02368356f, 0.10845832f, 
    -0.12228099f, -0.00364215f, 0.01966187f, 0.10572759f, 0.08967411f, 0.01573397f, 0.08372605f, -0.00694433f, 
    -0.08243569f, -0.22244030f, -0.08383799f, -0.06286583f, 0.11528405f, 0.03222769f, 0.12739705f, -0.01690635f, 
    0.02825035f, -0.05470188f, 0.01749012f, -0.04682121f, 0.30431390f, 0.16643630f, 0.31804454f, -0.04320759f, 
    0.00833264f, -0.23983799f, -0.09894142f, -0.06643082f, 0.09762495f, -0.01776774f, 0.18343994f, 0.12910415f, 
    0.05092444f, 0.03915076f, -0.07050122f, 0.01808073f, -0.07580519f, -0.10553208f, 0.03853993f, 0.06042451f, 
    0.08171289f, 0.02345148f, -0.02281959f, 0.07927188f, -0.37090355f, -0.03462191f, -0.25360069f, -0.09926046f, 
    -0.12966003f, -0.13726746f, 0.06471159f, -0.04335788f, 0.11308080f, -0.00536220f, 0.01219866f, -0.00965413f, 
    0.15931423f, 0.21172869f, 0.01079486f, -0.02981403f, 0.14493838f, 0.11250035f, 0.02148701f, 0.15659574f, 
    -0.02860386f, -0.04197646f, -0.00170271f, 0.01045906f, 0.08344618f, 0.06287552f, -0.04797268f, 0.07516836f, 
    0.11789095f, 0.14635214f, 0.17780933f, 0.19251944f, 0.02108916f, 0.05118234f, -0.05383526f, -0.06075772f, 
    0.30197811f, -0.02547557f, -0.17044744f, 0.01428055f, 0.01733749f, 0.03686382f, 0.09331211f, -0.07444265f, 
    0.15763767f, -0.13616356f, -0.11056117f, -0.02058131f, 0.10397759f, 0.31615964f, 0.16766898f, -0.15068612f, 
    -0.02874868f, -0.24312598f, 0.02308271f, 0.11259976f, 0.07731520f, 0.04676515f, 0.01780796f, 0.04009860f, 
    -0.15308364f, 0.02402968f, -0.18408111f, 0.07613894f, -0.00554942f, -0.19472195f, 0.14188477f, 0.02480061f, 
    0.02265980f, -0.09310561f, -0.05084958f, -0.01068354f, -0.12964632f, -0.43148714f, 0.21085306f, 0.06521027f, 
    0.06771100f, -0.00196771f, 0.05349549f, 0.13075303f, -0.09334097f, -0.03022334f, -0.03845400f, -0.02853650f, 
    -0.10117123f, 0.03871329f, -0.03913795f, 0.05824517f, 0.05060613f, 0.05998441f, 0.00169040f, 0.11273971f, 
    -0.10768728f, -0.07585646f, -0.02772120f, -0.04602997f, -0.16740118f, 0.13339794f, -0.07934985f, -0.03920560f, 
    0.02695213f, -0.09048259f, -0.06314068f, 0.14271912f, 0.08497022f, 0.14026795f, -0.03914089f, 0.19984339f, 
    0.32939401f, 0.26955473f, 0.14023013f, 0.08320570f, -0.01992234f, 0.05710546f, 0.09202844f, 0.09156357f, 
    0.03351646f, -0.03910810f, 0.02065202f, -0.06379819f, -0.09279449f, 0.36965600f, 0.28569877f, 0.20783654f, 
    0.00966398f, -0.09214509f, -0.07287239f, 0.05285069f, 0.08892379f, 0.00830179f, -0.06041788f, 0.14104040f, 
    0.03316838f, 0.17639747f, 0.24757481f, -0.17422146f, 0.12069625f, -0.07097487f, -0.09144399f, 0.20802838f, 
    -0.05821801f, 0.00047684f, 0.02753717f, 0.03685616f, 0.03736717f, -0.10288382f, -0.00220199f, 0.25068310f, 
    -0.03399888f, 0.08398767f, -0.06480767f, -0.18123773f, 0.07571781f, 0.07527635f, -0.19025841f, 0.14114369f, 
    -0.07747511f, 0.06268192f, 0.27145416f, -0.14116861f, 0.14707538f, -0.00208088f, 0.07593437f, 0.15249677f, 
    0.09791750f, 0.01459907f, 0.12802194f, -0.06601979f, 0.00711491f, 0.18826689f, 0.02077691f, 0.09904297f, 
    -0.03076087f, 0.07228536f, 0.21978769f, 0.00904937f, 0.19895107f, -0.02328707f, -0.18644084f, -0.15310326f, 
    -0.04447478f, 0.30098718f, -0.53632444f, 0.09415553f, 0.06063886f, 0.10741904f, 0.12737885f, 0.09859369f, 
    -0.03615643f, -0.00886392f, 0.02450305f, -0.09853745f, -0.40129995f, -0.08769316f, -0.21833426f, 0.09175642f, 
    -0.09587041f, 0.16841197f, 0.08738565f, -0.09367205f, 0.06575865f, 0.03022305f, 0.02926192f, -0.02238237f, 
    -0.06820936f, -0.00079302f, 0.17629588f, -0.19221212f, 0.07614391f, 0.12240349f, -0.01952382f, -0.05747182f, 
    -0.23752204f, 0.12117688f, 0.04482296f, -0.07499097f, -0.33593959f, -0.02158863f, 0.02733322f, 0.09629387f, 
    0.02603274f, 0.06967934f, 0.07737904f, -0.08913514f, 0.10742961f, -0.10994110f, -0.03934762f, 0.19042745f, 
    -0.05879374f, 0.07804755f, -0.07745354f, -0.00096219f, -0.03171130f, 0.04901784f, -0.07368748f, -0.01334148f, 
    0.23455931f, 0.09254205f, 0.07079204f, 0.23971014f, -0.09337173f, 0.09400494f, 0.19477734f, -0.07118682f, 
    0.08958078f, -0.02550952f, -0.00635765f, -0.03591616f, -0.15129274f, -0.01868237f, -0.02565050f, -0.21353948f, 
    0.06421468f, 0.08985862f, 0.14430992f, -0.04870992f, -0.01772486f, 0.03143307f, -0.04720610f, 0.08409856f, 
    -0.05661025f, -0.08452421f, -0.13498765f, -0.00857001f, -0.10750886f, 0.00361609f, 0.01496787f, -0.01661313f, 
    0.04717835f, -0.02175135f, 0.02519909f, -0.12081227f, -0.07955126f, -0.03340702f, -0.05061184f, -0.03383473f, 
    0.22243081f, 0.01843103f, 0.01534143f, -0.11883326f, 0.04553713f, 0.00004499f, 0.01323547f, -0.06293755f, 
    0.06578773f, -0.04330502f, 0.14306203f, 0.05026838f, 0.01478993f, -0.13673644f, 0.22091386f, 0.21608165f, 
    -0.08620246f, -0.17536029f, 0.01454887f, -0.00279754f, -0.01232204f, -0.13336499f, 0.23757894f, 0.20851740f, 
    0.06984828f, 0.06442849f, 0.07173432f, -0.05893393f, -0.06995025f, 0.04125079f, -0.00059614f, -0.09168235f, 
    -0.36648732f, -0.17692868f, -0.08135518f, -0.09326568f, -0.08033267f, 0.15208621f, -0.10289835f, -0.16793691f, 
    -0.05927315f, -0.04194175f, 0.11730093f, -0.26984525f, -0.07803389f, 0.01602778f, -0.05472418f, -0.02092175f, 
    0.19052066f, -0.09126070f, -0.04946717f, -0.23996030f, 0.04211310f, -0.15475264f, -0.11131967f, 0.06232944f, 
    0.01092785f, 0.10982185f, 0.08547843f, 0.08848938f, 0.00938924f, -0.07931442f, -0.12703925f, -0.38315016f, 
    -0.00504314f, -0.20812201f, 0.09586868f, -0.16082381f, -0.05032199f, -0.06628577f, 0.04396962f, 0.16382784f, 
    -0.08484153f, 0.00425217f, 0.00576331f, -0.07961399f, -0.02698055f, -0.00198974f, -0.02128904f, 0.06183618f, 
    -0.05013646f, -0.04071236f, -0.00958838f, 0.09160958f, -0.34051347f, -0.15564451f, -0.18084794f, 0.45668477f, 
    0.09605812f, 0.09851116f, 0.03420689f, 0.08115711f, 0.19609754f, 0.04756433f, 0.21470113f, 0.06792367f, 
    -0.16732565f, -0.05808415f, -0.04443461f, -0.07638206f, 0.17353743f, 0.09745649f, 0.00951409f, -0.07341444f, 
    -0.15789112f, 0.02469965f, 0.06399106f, -0.18465458f, -0.40421003f, -0.46041521f, -0.23145328f, -0.11135264f, 
    0.26280841f, 0.06310680f, 0.11031881f, -0.03908538f, 0.00459276f, -0.00759520f, -0.12068313f, 0.05263674f, 
    0.01847518f, -0.08502607f, -0.39038762f, 0.09223321f, -0.02764149f, 0.13754183f, -0.03591830f, -0.32703003f, 
    0.02478203f, 0.15792659f, 0.06825835f, 0.07572678f, 0.11563446f, -0.05962873f, -0.15916918f, 0.05439791f, 
    0.13988645f, 0.12795691f, 0.22777115f, -0.25565392f, 0.10792012f, -0.04853197f, 0.11225379f, 0.06221299f, 
    -0.01025744f, 0.02787028f, 0.03763844f, 0.04952650f, -0.03164051f, -0.04012783f, 0.10399721f, 0.03053427f, 
    0.10434190f, 0.19081917f, -0.04622103f, 0.10086823f, 0.09026281f, -0.12118804f, -0.18735155f, 0.04065904f, 
    0.02374514f, 0.14742838f, 0.06399728f, 0.14830440f, -0.13459830f, 0.14564797f, -0.14496982f, 0.10753955f, 
    -0.00684695f, -0.15218684f, -0.43359604f, 0.35544136f, 0.14481282f, -0.06241348f, 0.04657852f, 0.06228354f, 
    -0.01139980f, 0.13857247f, 0.08107992f, 0.16756059f, 0.23262958f, -0.07787641f, 0.06573621f, -0.00870034f, 
    0.18504626f, -0.03479751f, 0.07791860f, -0.02335617f, 0.12860857f, -0.08830476f, 0.08897322f, 0.03341508f, 
    -0.04790533f, -0.01558036f, -0.01455571f, 0.00041891f, -0.00864608f, -0.10818937f, -0.16683246f, 0.30288896f, 
    0.17768423f, 0.10912738f, 0.02303824f, 0.27495608f, -0.06731027f, -0.21641679f, -0.12425368f, -0.04915260f, 
    -0.08525884f, -0.01509705f, 0.17113791f, 0.02423146f, 0.16763163f, -0.14604014f, 0.09993052f, -0.01507816f, 
    -0.06039496f, -0.13053332f, 0.00118453f, -0.08414423f, -0.11413191f, -0.03234429f, -0.01813478f, -0.21745478f, 
    0.01113646f, 0.11095003f, -0.05393105f, 0.07329281f, 0.04396753f, -0.28391966f, -0.02511719f, -0.14489032f, 
    -0.07441055f, -0.00369109f, 0.01480270f, 0.05939366f, 0.09472718f, 0.24343631f, 0.07266739f, 0.02874414f, 
    -0.16588937f, 0.17798622f, -0.25233376f, 0.28741267f, 0.00244893f, 0.10777590f, 0.17718355f, 0.00214604f, 
    0.05740628f, -0.07818658f, 0.07226795f, 0.17987598f, 0.16628814f, -0.15681957f, 0.08607309f, -0.18852542f, 
    0.06520148f, 0.03839906f, -0.00502158f, -0.01463289f, 0.12131660f, 0.11776389f, -0.03493038f, 0.08467021f, 
    0.03599341f, 0.04123371f, -0.20290630f, 0.02489834f, -0.10061252f, 0.19341601f, 0.08852675f, -0.20087966f, 
    0.03419336f, -0.07820821f, -0.01306494f, -0.02759323f, -0.13346776f, -0.09104776f, -0.18238796f, -0.09727780f, 
    0.03382321f, -0.06888558f, -0.04047305f, 0.10545995f, 0.00586766f, 0.20466146f, 0.06123114f, 0.08853566f, 
    0.20588788f, -0.08225944f, -0.19993223f, 0.04917338f, 0.09251020f, 0.22022764f, 0.19766191f, 0.13501990f, 
    0.07169329f, -0.03388446f, -0.12004466f, -0.03824991f, 0.46672404f, 0.08673707f, -0.20736027f, 0.09411660f, 
    0.08342052f, -0.12959306f, -0.05095951f, 0.10543744f, -0.12218575f, 0.18165353f, 0.10235072f, -0.10723993f, 
    -0.13991229f, -0.02983660f, 0.11583890f, 0.19467334f, -0.01258112f, -0.00156376f, 0.01891846f, 0.12920199f, 
    0.17290717f, 0.06513318f, 0.11288936f, -0.03965558f, 0.55340225f, -0.12283795f, -0.22281803f, -0.14328285f, 
    0.03988155f, -0.04083882f, 0.07301237f, -0.00476684f, 0.07285374f, -0.07379156f, 0.01493974f, -0.14074653f, 
    0.26548079f, 0.26626766f, 0.06668319f, 0.07187504f, -0.03625871f, -0.02248168f, -0.05997848f, 0.04007879f, 
    -0.09007469f, -0.09892733f, -0.07120714f, -0.07625226f, 0.28556904f, -0.13579467f, 0.11648402f, 0.03641421f, 
    0.08810507f, 0.00796032f, -0.00673685f, -0.09536531f, 0.15715490f, 0.01893827f, -0.08282182f, 0.06908076f, 
    0.17245033f, -0.16093338f, 0.08822814f, -0.02186847f, 0.12822920f, -0.05187238f, 0.00638940f, -0.12149826f, 
    0.06482224f, 0.08783506f, 0.03355556f, 0.03647775f, 0.17117198f, -0.06829191f, 0.08546504f, -0.00699376f, 
    0.13713001f, 0.03273084f, 0.00919143f, -0.08764766f, 0.08900170f, -0.01454601f, 0.02150013f, 0.05018106f, 
    0.00772168f, 0.12294187f, -0.15748832f, 0.21767159f, 0.02404914f, 0.02312858f, -0.10725488f, 0.02118140f, 
    -0.01620928f, -0.11175662f, -0.04074936f, -0.06065913f, 0.02624223f, -0.15041502f, -0.45178032f, 0.03074934f, 
    0.09780522f, -0.14651507f, 0.10497242f, -0.08533326f, -0.10458600f, 0.15334557f, -0.17817971f, 0.24902175f, 
    0.05329370f, 0.09388374f, -0.05586944f, 0.03053974f, 0.10420638f, -0.00511274f, 0.02623804f, 0.01528240f, 
    0.21828556f, 0.07319610f, -0.00258416f, 0.03909953f, -0.06195255f, -0.25101161f, 0.15821823f, -0.03888767f, 
    0.19186874f, 0.11614301f, 0.05206184f, 0.14573248f, 0.08901713f, 0.18044674f, -0.02217689f, 0.01019153f, 
    0.00151246f, 0.13533035f, -0.13353449f, 0.14848854f, -0.01586451f, 0.04296245f, 0.13969544f, -0.14516644f, 
    0.00236637f, -0.09476960f, -0.12666576f, -0.11941802f, -0.16516350f, -0.10008318f, 0.18370210f, 0.28002104f, 
    0.04947352f, 0.02290299f, -0.03701709f, 0.22675416f, -0.03052085f, -0.02236470f, -0.04205256f, -0.02955334f, 
    0.03547043f, 0.02096074f, 0.11831819f, -0.02070373f, 0.17488962f, 0.03095724f, -0.01469939f, -0.10083415f, 
    0.11125734f, -0.03224069f, -0.01217140f, -0.06421737f, 0.32525498f, 0.07272641f, 0.24743052f, -0.14657183f, 
    0.00581622f, -0.18403547f, -0.01591764f, -0.01002331f, 0.14507909f, 0.15619819f, 0.21824187f, 0.12975386f, 
    -0.14950074f, -0.21811745f, 0.05689694f, 0.01620823f, 0.00961329f, 0.08056019f, 0.14581965f, 0.03581466f, 
    -0.00301817f, -0.00926088f, 0.03022720f, 0.03446848f, -0.44629595f, -0.31042141f, -0.27545187f, -0.15378086f, 
    -0.04443491f, 0.07480434f, -0.15142767f, -0.00480365f, 0.10971499f, -0.02620511f, 0.07079868f, -0.00610190f, 
    0.16198577f, 0.21361075f, -0.10065472f, 0.32382768f, 0.14764594f, 0.00404613f, 0.09944066f, 0.23655704f, 
    -0.02174097f, -0.01209786f, -0.01970350f, -0.06374683f, 0.10753375f, -0.18963927f, -0.02205035f, 0.13370946f, 
    0.07927167f, 0.17032528f, 0.18808761f, 0.17654772f, 0.00391899f, 0.06601249f, -0.01859902f, 0.07002001f, 
    0.35042164f, -0.06140097f, 0.05981225f, -0.31314015f, 0.10728548f, 0.09234024f, 0.03901330f, 0.07790748f, 
    0.17745134f, -0.04352568f, 0.05329124f, -0.06309056f, -0.06311424f, 0.15136082f, 0.07211588f, -0.21733664f, 
    -0.16619106f, -0.08697145f, -0.08627754f, 0.11247015f, 0.06297621f, 0.06613515f, 0.11079741f, 0.08321860f, 
    -0.11834342f, 0.35082525f, -0.52004743f, 0.08893862f, 0.11128525f, 0.09858145f, -0.13352224f, -0.14580628f, 
    -0.00333115f, 0.05926327f, -0.06469415f, -0.04908163f, 0.09878533f, -0.44834632f, 0.06476207f, -0.21192656f, 
    0.04003492f, -0.04996603f, 0.00068336f, 0.06572782f, 0.00763323f, 0.04775400f, -0.04990919f, 0.00496612f, 
    0.02807343f, -0.13705759f, 0.04884813f, 0.14883828f, 0.20096922f, -0.06099190f, 0.06576025f, -0.10871388f, 
    -0.05322390f, 0.02985466f, 0.03281647f, -0.05621561f, -0.19390666f, -0.02776675f, -0.10455158f, 0.03999466f, 
    -0.01629349f, -0.08878448f, -0.09241929f, 0.07342689f, 0.02552559f, 0.05511963f, -0.10200178f, 0.12772849f, 
    -0.07017388f, -0.16259007f, 0.03531104f, 0.00487400f, 0.09918693f, 0.02926103f, 0.05435000f, 0.23019715f, 
    0.01082439f, 0.21028273f, 0.09878749f, -0.02486610f, 0.34635234f, 0.05562876f, 0.22486058f, -0.13054381f, 
    -0.05851958f, -0.11804736f, -0.16153540f, -0.16465886f, -0.01598147f, -0.15230893f, -0.02829419f, 0.10095780f, 
    0.35463101f, 0.18342154f, 0.10078409f, -0.14303111f, 0.06115761f, -0.09199805f, 0.07893334f, 0.05075255f, 
    0.04828291f, 0.04613101f, 0.01415510f, -0.06666031f, 0.20977129f, -0.16929266f, 0.08631202f, -0.05409472f, 
    0.01791582f, 0.06194163f, -0.06980737f, -0.10307664f, -0.00488596f, 0.02379989f, 0.01794112f, -0.02245971f, 
    -0.09864293f, 0.06509639f, 0.13006271f, 0.02558967f, 0.02491048f, 0.05203284f, 0.13559030f, 0.23034711f, 
    0.01249541f, -0.10506562f, 0.02560604f, 0.07500283f, 0.01258090f, 0.19048578f, -0.23596370f, 0.14657240f, 
    -0.02712940f, -0.05591430f, 0.27423677f, -0.04884483f, 0.10958518f, -0.08804324f, -0.10722221f, -0.04035581f, 
    -0.27950495f, 0.21465498f, -0.52906847f, 0.11043432f, 0.04019809f, -0.05486649f, 0.11920508f, 0.00248103f, 
    0.08719391f, -0.06346454f, 0.12607832f, 0.08599907f, -0.05575526f, -0.26232409f, -0.28622350f, 0.10624987f, 
    0.08430853f, 0.24021108f, 0.10827896f, -0.01959592f, 0.06352141f, -0.01933637f, 0.02363958f, 0.07014724f, 
    -0.01531623f, -0.07971660f, -0.06235533f, 0.02298529f, 0.02821920f, -0.04025422f, 0.04818652f, -0.01813556f, 
    -0.07866839f, -0.10419892f, -0.01393459f, 0.07826900f, -0.08841591f, 0.33051428f, -0.08035640f, 0.29768878f, 
    0.05115465f, 0.02850685f, -0.09393530f, -0.11397971f, -0.02758425f, -0.01162606f, 0.14050052f, -0.06094845f, 
    -0.20685284f, -0.06712420f, -0.11360344f, -0.07267146f, 0.12566699f, -0.01308138f, -0.15508193f, -0.14610662f, 
    0.04491051f, 0.20690468f, 0.10702898f, -0.07374662f, -0.14441210f, 0.08096927f, -0.03852991f, -0.01057718f, 
    -0.19165179f, -0.10735004f, -0.28871194f, -0.06404494f, -0.20291172f, -0.16954806f, -0.00000994f, -0.05249509f, 
    0.01595663f, 0.13345338f, 0.23398066f, 0.03034210f, 0.01606128f, 0.10096048f, -0.01080123f, -0.02707091f, 
    0.08504481f, -0.06374490f, 0.04921937f, 0.05942361f, -0.02164557f, 0.35640267f, 0.07534991f, 0.00677192f, 
    -0.25210726f, -0.15533054f, -0.30489931f, -0.14031345f, -0.17461935f, -0.04039241f, -0.05712756f, -0.10335306f, 
    0.23509507f, -0.13910188f, 0.02448794f, 0.06332369f, -0.01748133f, -0.17696545f, -0.05788238f, -0.02882456f, 
    -0.04083842f, 0.03442347f, -0.03665697f, 0.07361259f, 0.76451337f, 0.07165667f, 0.12225108f, 0.16198835f, 
    0.01325607f, 0.24680278f, -0.09336830f, 0.23389746f, 0.00316194f, -0.01057536f, -0.01329535f, 0.08584882f, 
    -0.06707369f, -0.07169331f, 0.17297362f, -0.04567556f, -0.01663848f, -0.09523328f, -0.18059874f, -0.08226226f, 
    -0.04498409f, -0.07365603f, 0.08919189f, -0.08810174f, -0.18307406f, 0.39752921f, -0.22952554f, 0.09287653f, 
    0.04921567f, 0.09442668f, 0.18740344f, 0.00514618f, 0.02664683f, -0.03469230f, 0.14524063f, 0.13409308f, 
    0.27175975f, -0.06122043f, 0.00467329f, -0.06571510f, 0.04692185f, -0.13155961f, -0.04480424f, 0.15682566f, 
    0.18880811f, 0.09493370f, 0.21429703f, 0.12511654f, -0.23230988f, -0.19456442f, -0.11716181f, 0.04932651f, 
    0.08228675f, 0.09143937f, 0.01256317f, -0.11758497f, -0.02016841f, -0.02213191f, -0.13456288f, -0.14238118f, 
    -0.10741056f, 0.03955895f, -0.08983959f, -0.05182740f, -0.08279593f, -0.09446722f, -0.33508843f, -0.12854500f, 
    -0.06505247f, 0.01793628f, -0.07326797f, 0.07083717f, -0.14842536f, 0.02166830f, -0.07028182f, 0.14820246f, 
    -0.04884415f, 0.08524282f, 0.03850240f, 0.05269088f, 0.01607597f, 0.07360612f, 0.04713424f, 0.07495003f, 
    0.06648720f, 0.09806817f, 0.00945603f, -0.22227752f, 0.05674786f, -0.00581379f, 0.02107893f, 0.05690268f, 
    -0.04049505f, -0.01530343f, -0.10139857f, 0.03595360f, 0.40090016f, -0.03959049f, 0.12841776f, 0.23129134f, 
    0.04060944f, 0.01362710f, 0.08626815f, 0.11132082f, -0.11039770f, 0.14008805f, 0.02029135f, 0.08140695f, 
    -0.19733715f, -0.20178828f, -0.04649847f, 0.10495725f, 0.06108552f, -0.10201378f, 0.02447093f, -0.02871694f, 
    0.03155392f, -0.17156820f, 0.00789017f, -0.01798036f, -0.19238926f, 0.07022508f, 0.21296315f, 0.07819322f, 
    0.00476068f, 0.03249871f, -0.18808724f, 0.06259081f, 0.00211818f, 0.10550798f, 0.02006997f, 0.18555690f, 
    -0.20670246f, -0.10047940f, 0.05700594f, 0.19074801f, 0.03734533f, 0.03211631f, -0.00738340f, -0.11367135f, 
    -0.09612320f, 0.09098897f, 0.20779666f, 0.03804563f, 0.00722086f, -0.06871024f, -0.22094332f, 0.23435900f, 
    0.07471712f, -0.03831179f, 0.01146293f, -0.03861613f, -0.00276001f, -0.08212008f, 0.08113803f, -0.13685805f, 
    0.23316808f, 0.05298121f, 0.28065515f, 0.01693614f, 0.24873348f, 0.18187203f, -0.09617484f, 0.03038474f, 
    0.00883980f, -0.08363863f, 0.06119197f, 0.07668994f, -0.13750033f, 0.59725809f, -0.16978040f, 0.08314395f, 
    -0.11277279f, -0.04720600f, -0.04730976f, 0.13613826f, 0.15203664f, -0.02753201f, -0.09290585f, 0.07699832f, 
    0.07622626f, 0.02573296f, -0.03973307f, -0.04601206f, 0.01226101f, 0.00437612f, 0.08601807f, -0.01803423f, 
    0.03579595f, 0.04014852f, 0.03758653f, 0.17263311f, 0.10805304f, -0.05753109f, 0.10100293f, 0.11917903f, 
    0.14682806f, 0.03155448f, 0.01372005f, -0.13250419f, -0.13265696f, -0.06497008f, -0.02758732f, -0.21936473f, 
    -0.14640436f, -0.18043996f, -0.29694963f, -0.00123880f, 0.13188502f, 0.21555661f, -0.00190598f, 0.09756146f, 
    0.05576418f, -0.03905154f, 0.09424122f, -0.00596501f, 0.01798430f, -0.19658786f, 0.06368596f, 0.02455971f, 
    0.18111236f, -0.04621241f, 0.08407125f, -0.21413958f, -0.13320252f, 0.07916488f, 0.13735484f, -0.00729599f, 
    -0.48123860f, 0.08818271f, 0.13421263f, 0.16080891f, -0.11028931f, 0.12835555f, -0.12380837f, -0.06564134f, 
    0.06137549f, 0.02279783f, 0.12742524f, 0.03126482f, -0.22172928f, 0.19656949f, -0.04839024f, 0.06246031f, 
    0.09076994f, -0.12148756f, -0.03639586f, 0.12202382f, 0.00893122f, -0.05579115f, 0.20812753f, 0.06680746f, 
    -0.03050083f, -0.17696543f, -0.07551260f, -0.00668275f, -0.11516441f, 0.01906277f, 0.00542230f, 0.00531982f, 
    -0.13164702f, 0.10092996f, -0.01802620f, -0.04754554f, 0.08881509f, -0.02987392f, -0.03992885f, -0.14336480f, 
    0.15657754f, 0.11220340f, -0.06230357f, 0.07473578f, 0.03522057f, 0.15233603f, 0.16062075f, 0.21942575f, 
    -0.04203256f, -0.64152080f, 0.46807942f, -0.09510759f, -0.00052052f, 0.11225937f, 0.04962001f, 0.01173765f, 
    -0.07319295f, 0.08656980f, 0.06384720f, 0.00969839f, 0.38058797f, 0.22897138f, 0.25977969f, -0.12794504f, 
    0.17107508f, -0.14811590f, -0.19802645f, 0.08391224f, -0.01335710f, -0.04169362f, -0.09941234f, 0.15552923f, 
    -0.18682627f, -0.00810682f, 0.07656792f, 0.17403552f, -0.07696012f, 0.06162440f, 0.07231806f, 0.06200391f, 
    0.13627994f, 0.01637357f, -0.02145573f, 0.05513120f, 0.40274462f, -0.01493142f, 0.08177853f, -0.18626834f, 
    0.00079796f, -0.06879260f, 0.12573551f, -0.05273225f, 0.11729003f, 0.20000559f, -0.12289875f, -0.10895684f, 
    0.13172321f, -0.08504583f, -0.02098727f, 0.03592855f, -0.04502805f, -0.03943324f, -0.00972852f, 0.00743745f, 
    -0.09728989f, -0.05508592f, -0.09607731f, 0.01722984f, 0.25506198f, 0.04118872f, 0.16185181f, 0.06853457f, 
    -0.04659479f, -0.03253826f, 0.00847127f, -0.07077085f, -0.03919119f, 0.00922374f, -0.03631501f, 0.03422550f, 
    0.17186379f, -0.00919445f, 0.12079810f, 0.11240645f, 0.02645133f, -0.09568131f, 0.03030948f, -0.01088067f, 
    -0.03765431f, 0.12083860f, 0.14025427f, -0.08823579f, 0.17088094f, 0.09321038f, 0.06145491f, -0.05041271f, 
    -0.06418934f, -0.02135417f, -0.06993172f, 0.00730263f, 0.01120888f, -0.01314949f, 0.05768645f, 0.08619289f, 
    0.08434673f, 0.01801900f, -0.10519771f, 0.15945578f, -0.10333528f, 0.06000883f, -0.01564138f, 0.10941181f, 
    -0.10537887f, -0.04219524f, -0.05126182f, 0.13047266f, -0.11280522f, 0.08696023f, -0.47694156f, 0.10633428f, 
    0.10314836f, 0.01449355f, 0.11004026f, -0.15796176f, 0.07713757f, 0.23201251f, -0.15437390f, -0.12795737f, 
    0.13035128f, 0.13118003f, -0.02304678f, 0.01143757f, -0.03250204f, -0.06992257f, -0.10623636f, 0.04729768f, 
    0.17983301f, -0.00276826f, 0.12309418f, 0.08296960f, -0.02739891f, -0.26343399f, 0.19901478f, -0.03082288f, 
    0.01882460f, -0.00938025f, -0.01142421f, 0.04942460f, 0.11465125f, 0.05187428f, 0.00411573f, 0.09623883f, 
    -0.23554242f, 0.25232661f, -0.12228708f, 0.21349962f, -0.03844624f, 0.17340118f, 0.19643454f, 0.04175346f, 
    -0.02883014f, 0.04963285f, -0.03103964f, 0.03513836f, 0.01015706f, -0.00489810f, 0.12949571f, 0.06655375f, 
    0.02587666f, 0.04295560f, -0.05414344f, -0.03330202f, 0.04826727f, -0.01149696f, -0.11970029f, -0.02848909f, 
    0.15444106f, -0.00016925f, 0.06973028f, -0.03594289f, -0.06599165f, 0.00185077f, 0.03035202f, -0.03728051f, 
    -0.04670858f, -0.00082624f, -0.00028928f, -0.05395332f, 0.13064951f, 0.29283619f, 0.15532105f, -0.32092044f, 
    -0.17163470f, 0.08364856f, 0.04167281f, 0.14344573f, -0.14015645f, 0.18885267f, -0.11535118f, -0.03365245f, 
    -0.08595589f, -0.21420997f, 0.17178938f, -0.01312651f, 0.03304938f, 0.02410370f, -0.09700362f, 0.12143467f, 
    0.11398699f, 0.10825774f, -0.19430459f, 0.05848978f, -0.11635519f, 0.21670009f, 0.17144275f, 0.13062862f, 
    -0.05266532f, 0.06546903f, -0.29189986f, -0.04308002f, -0.02844643f, -0.00887369f, -0.00799955f, -0.10575745f, 
    -0.16287594f, -0.08901080f, -0.15254599f, -0.23638153f, -0.10040475f, -0.18446743f, 0.10490660f, 0.06413577f, 
    -0.00630588f, -0.13451201f, -0.09269843f, 0.05458645f, 0.11624603f, -0.15642343f, -0.24551328f, -0.25332317f, 
    0.02242585f, 0.00387912f, -0.12333138f, -0.00947946f, -0.01092356f, -0.04613521f, -0.01097396f, 0.01864424f, 
    -0.10863536f, 0.18416217f, 0.06151559f, -0.16031325f, 0.12609391f, -0.00950056f, -0.11972346f, 0.20633954f, 
    -0.13982318f, 0.08951934f, 0.09319938f, 0.02234060f, -0.06543510f, 0.14059262f, -0.01053533f, -0.03337896f, 
    -0.02345353f, 0.08024374f, 0.01748672f, -0.13837354f, 0.07085031f, 0.10067753f, 0.03705064f, 0.15608296f, 
    0.20729551f, 0.28952155f, -0.05450447f, -0.36299866f, -0.18584968f, 0.31065568f, -0.01056556f, -0.00898106f, 
    0.02961392f, -0.02195450f, 0.03273987f, -0.13871183f, -0.01061944f, -0.15374450f, -0.04764770f, 0.01321640f, 
    0.36424127f, 0.16553940f, -0.05292001f, 0.00158278f, -0.04074183f, 0.12418416f, 0.02108535f, -0.04732598f, 
    -0.04789576f, -0.16593473f, 0.18179233f, -0.14516829f, 0.05706047f, 0.01696345f, 0.26433080f, 0.13725135f, 
    -0.05908981f, 0.05777367f, 0.00006426f, -0.28139555f, -0.14989294f, 0.03005121f, 0.08040414f, 0.12467755f, 
    0.02931327f, 0.15733422f, 0.05294728f, -0.10220087f, -0.05835074f, 0.00363922f, 0.06241642f, -0.00558658f, 
    -0.38149059f, -0.14842261f, -0.00368658f, 0.04292132f, -0.11319023f, -0.17881320f, 0.09365977f, 0.05289812f, 
    -0.06638470f, -0.05591427f, 0.10089254f, 0.08253539f, 0.20490989f, 0.27639550f, 0.02511526f, 0.05179970f, 
    -0.06515004f, 0.03452223f, -0.09941792f, 0.02140166f, -0.18204173f, -0.14699340f, 0.00874852f, -0.01841100f, 
    0.61710733f, 0.07156448f, -0.00318628f, -0.26440266f, -0.04280418f, 0.01448855f, 0.15499224f, -0.22856136f, 
    0.10815090f, 0.13293578f, 0.00412607f, -0.03295704f, 0.10816913f, 0.02912816f, -0.07456222f, 0.02503306f, 
    -0.03949391f, 0.00648907f, 0.08121168f, 0.12354983f, -0.04643650f, -0.14212714f, 0.22164376f, -0.19042552f, 
    -0.06953231f, 0.13870336f, -0.07575347f, 0.07001889f, -0.08094205f, 0.02016001f, -0.03628199f, -0.01772946f, 
    0.05519291f, -0.09413075f, -0.19312508f, 0.09816284f, -0.20018329f, -0.10903512f, -0.08732120f, 0.17950675f, 
    -0.03226597f, -0.14101499f, 0.02392359f, 0.08212091f, 0.01547228f, -0.14548571f, -0.00354326f, 0.00956403f, 
    -0.11151520f, 0.08041640f, -0.10764982f, -0.17879522f, 0.16738880f, -0.10203849f, 0.01751299f, -0.02990452f, 
    0.00511997f, -0.06938107f, 0.02735782f, 0.09687699f, 0.01607964f, -0.14641936f, 0.02322602f, 0.18206374f, 
    0.03561281f, 0.20987447f, -0.06378842f, 0.04838456f, 0.09792444f, -0.09972551f, 0.00782621f, -0.01759244f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.08285683f, -0.00712866f, -0.01524056f, 0.14454013f, 0.00219632f, -0.11743385f, 0.09204154f, 0.02408590f, 
    -0.02361766f, 0.04646904f, 0.04992222f, 0.06764255f, -0.04808959f, -0.03427940f, 0.08633216f, -0.04997275f, 
    -0.00357168f, 0.04177479f, -0.00418455f, -0.05222271f, 0.10857759f, 0.20667244f, -0.00239203f, -0.04933447f, 
    0.16892022f, -0.03421779f, 0.27129745f, 0.05635213f, 0.03844222f, 0.04484318f, 0.04081307f, 0.08562061f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.07484696f, 0.12374812f, 0.01451735f, 0.17361893f, -0.25686753f, -0.08209006f, 0.26039761f, -0.05689618f, 
    -0.08609223f, 0.13819365f, 0.26277032f, -0.36658669f, 0.42350370f, 0.09235995f, 0.27818090f, -0.12858340f, 
    0.03246647f, -0.07578910f, -0.00194774f, -0.08557680f, 0.21610019f, 0.12865622f, 0.26384962f, -0.12308144f, 
    -0.17907070f, 0.15593104f, -0.08196330f, -0.14724873f, -0.07922211f, -0.05378974f, 0.41804746f, -0.23577066f, 
    0.11868309f, -0.12527262f, 0.05495490f, -0.19651628f, -0.13756032f, -0.07476763f, -0.04503890f, -0.10741034f, 
    -0.06148271f, -0.05461105f, -0.18226416f, 0.06306369f, -0.17784944f, -0.04417539f, -0.20491408f, -0.05427888f, 
    -0.05426835f, -0.16514412f, 0.17023259f, 0.12992948f, -0.04879301f, -0.09795880f, 0.12353688f, 0.06553989f, 
    -0.06794934f, 0.00050113f, 0.09175343f, -0.13609369f, 0.05921209f, -0.03123783f, -0.11113814f, -0.14515369f, 
    0.16656612f, -0.12935038f, -0.08799679f, 0.27321395f, 0.25537810f, -0.02704745f, 0.48145232f, 0.07838517f, 
    0.10103642f, -0.16486299f, 0.10892165f, -0.15324326f, -0.12045525f, -0.24212025f, -0.11315603f, 0.00328556f, 
    0.15683635f, -0.06357530f, -0.04356618f, -0.42237869f, 0.13462022f, 0.44350126f, -0.00358930f, -0.07375376f, 
    0.39984277f, 0.07007264f, 0.27018678f, 0.17361426f, -0.02138858f, 0.12242476f, -0.01052957f, 0.29482481f, 
    -0.01104248f, -0.08134548f, -0.14148399f, -0.10084958f, 0.01133192f, 0.02278680f, -0.04265050f, -0.07671195f, 
    0.16781375f, -0.09086255f, 0.06572711f, -0.07362743f, -0.13819428f, -0.04052003f, 0.06993884f, 0.06598816f, 
    -0.03748032f, 0.08756498f, 0.14372075f, -0.15224700f, 0.04309271f, 0.11127239f, -0.11478936f, -0.05973426f, 
    0.05711788f, 0.07601571f, -0.15465949f, -0.05661879f, -0.08008560f, 0.14277197f, 0.04196341f, -0.12632060f, 
    -0.12618765f, -0.02554788f, -0.25574467f, 0.10797165f, 0.09560672f, -0.05065965f, -0.07304247f, 0.21009651f, 
    0.16177669f, -0.31974751f, -0.06776404f, 0.20306632f, 0.16096938f, -0.10509405f, 0.06899364f, 0.05435003f, 
    -0.05799901f, -0.08266021f, -0.05111660f, 0.12565666f, 0.30665436f, 0.25756216f, -0.23460427f, 0.12630866f, 
    0.32778087f, -0.01339669f, 0.13360973f, 0.17929584f, 0.27172366f, -0.31808454f, 0.21561322f, -0.04717222f, 
    0.02146642f, -0.12506022f, 0.23674256f, 0.35696626f, -0.07215741f, -0.12042578f, -0.58427924f, 0.16445300f, 
    0.08657629f, 0.18099993f, 0.03270173f, 0.32394001f, -0.31362909f, -0.14201294f, 0.23781148f, 0.10259503f, 
    -0.15857285f, 0.07462340f, -0.00891215f, -0.22344339f, 0.33658704f, 0.00054675f, -0.25103933f, 0.02808570f, 
    -0.21114518f, -0.10939518f, 0.19711360f, 0.10616908f, 0.43285665f, 0.31705993f, -0.03040760f, -0.18068513f, 
    -0.11290236f, 0.01761464f, -0.11007036f, 0.14365482f, 0.01346627f, -0.15339918f, 0.01315805f, -0.14467125f, 
    -0.07520058f, 0.12730655f, 0.01596064f, -0.04774795f, -0.14011039f, -0.03701944f, -0.26535901f, -0.05180320f, 
    -0.04283568f, 0.03565788f, -0.11080160f, 0.02684325f, 0.07209233f, -0.09957196f, -0.07452428f, 0.02257356f, 
    0.07088868f, -0.06432391f, 0.10896403f, -0.03856859f, 0.03162759f, -0.18265630f, -0.10987093f, -0.01352412f, 
    0.05524944f, 0.00815297f, 0.09628616f, 0.07426012f, -0.02735710f, -0.13074282f, 0.09573567f, -0.00723858f, 
    -0.00976262f, -0.01370857f, -0.08303223f, -0.16188280f, -0.02465343f, 0.08569894f, 0.10765307f, 0.00376774f, 
    0.12406186f, 0.07759434f, -0.11088846f, -0.14877442f, -0.08773749f, -0.10181640f, -0.13854383f, 0.08001010f, 
    -0.16944890f, -0.07589071f, -0.11029234f, -0.00791333f, -0.13299476f, 0.00394851f, -0.06444011f, -0.13179705f, 
    0.04850122f, 0.10209696f, -0.04050269f, -0.16369082f, -0.11440442f, -0.00127873f, -0.08545158f, -0.07917663f, 
    0.06092321f, -0.06398895f, -0.03059063f, -0.14636998f, -0.16422059f, 0.07542822f, -0.15285361f, 0.10126744f, 
    -0.05562025f, 0.09302437f, -0.11835092f, -0.01462321f, -0.09213716f, 0.07550795f, -0.04125797f, 0.10003515f, 
    -0.15285346f, 0.08426550f, -0.10532423f, -0.06818080f, -0.01894990f, 0.11082393f, -0.15139192f, -0.05604249f, 
    0.29337230f, 0.08853360f, 0.05551645f, 0.16772421f, -0.03556613f, 0.13920419f, 0.51884830f, 0.24902755f, 
    -0.12326121f, -0.23628421f, -0.09907213f, -0.03820492f, 0.01983025f, -0.03139542f, -0.15801419f, 0.09437834f, 
    -0.03931046f, -0.12032175f, 0.04020823f, -0.33253208f, -0.17411913f, -0.21567747f, 0.08384864f, -0.03861052f, 
    -0.15545437f, 0.05154784f, 0.27617928f, 0.04934779f, -0.27211922f, 0.18848674f, -0.06014765f, 0.37915635f, 
    0.23835187f, -0.10254832f, 0.18130882f, -0.06376509f, 0.16120999f, -0.07417028f, -0.26034144f, -0.02956482f, 
    -0.00747398f, -0.28543195f, -0.06897421f, -0.07232964f, -0.15232956f, -0.08878753f, 0.04483048f, -0.05380838f, 
    0.05117004f, 0.13728276f, -0.16082741f, 0.26725060f, 0.44230196f, 0.17750180f, -0.10923611f, -0.07012207f, 
    0.21533994f, -0.08439622f, 0.16325961f, 0.16316500f, 0.06517487f, 0.15620691f, -0.53363693f, 0.03771735f, 
    -0.05546939f, -0.03403183f, 0.07623721f, -0.33792198f, 0.18920803f, 0.12651497f, -0.15693480f, -0.18963107f, 
    -0.05260466f, -0.27490887f, 0.24073590f, 0.07714584f, -0.24646452f, 0.31739530f, 0.00169092f, -0.01963131f, 
    -0.07062995f, -0.17589517f, -0.05541054f, 0.43612301f, 0.19242495f, -0.09847912f, 0.04345369f, -0.15199566f, 
    0.19003260f, 0.04083211f, 0.19943920f, 0.45945045f, -0.04951765f, 0.46355933f, -0.51463562f, 0.03074856f, 
    -0.19725367f, -0.11855337f, -0.21030870f, 0.61562753f, 0.34704044f, 0.19921073f, 0.13626863f, -0.01544217f, 
    -0.16598834f, 0.21514264f, -0.28646508f, -0.28645846f, -0.00707353f, 0.09865972f, 0.01465901f, 0.06104208f, 
    0.07184208f, 0.05083857f, 0.18353750f, -0.02155584f, -0.22627333f, 0.07127079f, 0.26125836f, -0.03697998f, 
    -0.12917930f, 0.16395138f, 0.01730935f, 0.16301566f, 0.03877463f, -0.12948048f, 0.33838934f, -0.12682396f, 
    0.00313062f, 0.07554775f, -0.36441651f, 0.27341551f, -0.11062437f, -0.11512224f, 0.35569569f, -0.26414362f, 
    -0.01951434f, 0.41259310f, 0.08266956f, 0.03888188f, -0.18285422f, 0.06083575f, 0.13756247f, 0.02316939f, 
    -0.16387238f, 0.03443627f, 0.07512787f, -0.40794832f, 0.03532055f, 0.15196159f, 0.24816136f, -0.11630369f, 
    0.24845192f, 0.16208403f, 0.09315029f, -0.06129229f, -0.22238223f, -0.12566282f, 0.53729177f, -0.24096213f, 
    -0.08249941f, 0.02678895f, -0.11698616f, 0.00988925f, -0.06139297f, 0.43487242f, -0.23642863f, -0.65510166f, 
    -0.09744570f, 0.38620287f, -0.11263283f, -0.03036128f, -0.10101078f, 0.40889537f, 0.19564721f, -0.12381204f, 
    -0.11152872f, 0.13437805f, 0.04352932f, -0.03992582f, 0.14386326f, -0.16136658f, 0.03083987f, 0.15663403f, 
    0.12973718f, 0.16542718f, 0.12059297f, 0.33060861f, -0.41935474f, 0.18467043f, -0.19892162f, -0.25121665f, 
    0.02679983f, 0.12120304f, -0.26524159f, 0.33493555f, 0.19835934f, 0.32411885f, 0.39336202f, -0.32976726f, 
    -0.03537279f, -0.05505230f, -0.24752170f, -0.15828781f, -0.32387096f, 0.10803584f, -0.17854550f, -0.09159207f, 
    -0.02783984f, -0.03956016f, -0.02727709f, -0.26372385f, -0.18099099f, 0.21281418f, 0.12594494f, -0.16678955f, 
    0.01778864f, -0.07860713f, 0.16063918f, 0.26261288f, -0.46368897f, 0.31167150f, 0.08157682f, 0.22211388f, 
    0.27827099f, -0.19044378f, 0.57029825f, 0.09758025f, -0.17268220f, 0.24593076f, 0.15321767f, 0.26275668f, 
    -0.06696551f, 0.11269288f, -0.04750971f, -0.35288242f, 0.03083336f, 0.26392478f, 0.25831464f, 0.01904001f, 
    0.11630313f, -0.13315554f, -0.00720999f, 0.03231692f, 0.39074621f, 0.24075149f, 0.12563227f, 0.14359669f, 
    -0.20944604f, -0.09504565f, -0.08513993f, -0.37511343f, -0.02870229f, 0.02856917f, 0.17659320f, -0.05874195f, 
    0.28647783f, -0.00883565f, -0.18530597f, 0.39700007f, -0.28776050f, 0.12005881f, 0.23994187f, 0.26468694f, 
    -0.01158823f, 0.00788192f, -0.25521529f, 0.15194695f, -0.08766456f, 0.28594616f, 0.27872217f, 0.10611300f, 
    0.11794034f, -0.02089177f, -0.13864869f, 0.29109657f, -0.64751261f, -0.62564856f, -0.21262008f, 0.01461275f, 
    -0.47487813f, -0.11728298f, 0.28265217f, -0.06331242f, 0.18756299f, -0.02808808f, 0.18988597f, -0.18613121f, 
    0.15606548f, 0.14427619f, -0.09265183f, -0.03485455f, -0.22216138f, -0.12763579f, 0.15829538f, 0.27062142f, 
    0.03648031f, -0.03751763f, -0.05093832f, 0.22927414f, 0.01979153f, -0.11789276f, 0.06960035f, -0.16271347f, 
    0.02533139f, 0.06666642f, 0.03844428f, 0.30161634f, -0.15079316f, -0.45181528f, 0.22310293f, 0.12741704f, 
    -0.20936334f, 0.02951794f, 0.15036325f, -0.14168355f, -0.07818922f, -0.16818261f, 0.37460676f, -0.14162636f, 
    -0.25212842f, 0.00232553f, 0.06442527f, -0.33121997f, 0.07976905f, 0.10877569f, 0.08506957f, 0.29875541f, 
    -0.15088852f, 0.34785780f, 0.26305261f, -0.15814424f, 0.30223453f, 0.29512909f, 0.24341525f, -0.16546644f, 
    0.13024445f, -0.03148709f, -0.13296150f, 0.28493804f, -0.10151664f, -0.27098629f, 0.16473381f, -0.03621702f, 
    0.07586718f, -0.00369237f, 0.09043632f, 0.09435027f, 0.04363433f, -0.40868959f, -0.01666100f, -0.44611105f, 
    -0.12642954f, 0.03188682f, 0.09960960f, 0.16410027f, -0.11796804f, -0.15016340f, -0.06984270f, 0.07822835f, 
    0.04129862f, 0.06661364f, -0.11174425f, -0.15068983f, -0.06258807f, -0.14578192f, 0.04151608f, 0.14455414f, 
    0.05164571f, -0.06882681f, -0.06095690f, -0.09230010f, -0.08030553f, -0.13419318f, -0.15130594f, -0.03428105f, 
    -0.14237446f, 0.12032513f, -0.19088377f, 0.08496813f, 0.12629907f, 0.09813306f, -0.02346026f, -0.09630026f, 
    0.35884592f, -0.02622314f, -0.45322764f, -0.11762826f, 0.06945945f, -0.06115748f, 0.51633787f, 0.14104152f, 
    -0.09398646f, -0.01627881f, 0.09470900f, 0.27555200f, -0.18933958f, 0.15915614f, -0.03927321f, 0.02681264f, 
    0.02288384f, -0.14499941f, -0.04700176f, -0.15790579f, -0.38787612f, -0.24919568f, 0.08536393f, 0.02366607f, 
    0.00870449f, 0.09574584f, 0.27192414f, -0.08382698f, -0.11605486f, 0.04529652f, 0.18441899f, 0.16875474f, 
    -0.19319758f, 0.13701253f, -0.10247168f, 0.53276557f, -0.06519889f, 0.08098065f, -0.08633494f, 0.16772436f, 
    0.12659621f, 0.05753431f, 0.24623683f, 0.01867542f, -0.19666864f, -0.12253247f, 0.29643816f, 0.07295763f, 
    0.09290874f, 0.14415021f, 0.16806395f, -0.28801236f, -0.02899870f, 0.29096696f, -0.04646387f, -0.06216343f, 
    0.15718091f, -0.05730094f, 0.13601971f, -0.06932873f, 0.34132236f, -0.18887606f, 0.04120152f, -0.31438377f, 
    -0.04346643f, -0.16387714f, 0.00671637f, -0.35856819f, -0.02577515f, 0.05019152f, 0.35156375f, 0.26262861f, 
    0.02295224f, -0.21665911f, -0.11640994f, 0.21094280f, 0.26998606f, -0.01257239f, -0.01294156f, 0.15886150f, 
    -0.12143226f, -0.11409267f, 0.12785393f, 0.07287283f, 0.16026460f, 0.03679673f, 0.00238121f, 0.00675372f, 
    -0.01732155f, 0.15652385f, 0.04310969f, 0.01562342f, -0.13752298f, -0.23009641f, 0.10315892f, -0.06142402f, 
    0.25871924f, -0.05967078f, -0.23859380f, 0.13686770f, -0.24387516f, -0.08069292f, -0.25385651f, -0.20124371f, 
    -0.17445298f, -0.08554559f, -0.17368734f, 0.28319702f, -0.22980419f, -0.01003963f, 0.24990360f, 0.06198191f, 
    -0.04230292f, 0.01629370f, 0.18279773f, 0.33355284f, 0.09249903f, -0.14200622f, -0.12701225f, -0.05973264f, 
    -0.26776671f, 0.07324722f, 0.16577269f, 0.29537532f, -0.00604222f, 0.23300178f, 0.25274155f, -0.14977013f, 
    0.13171360f, 0.14032875f, 0.47485304f, -0.09261496f, 0.14340106f, 0.35089296f, 0.37431401f, 0.25240433f, 
    -0.14292473f, -0.22601211f, -0.01929466f, 0.17504537f, 0.16932264f, 0.23552841f, -0.08404222f, -0.03905029f, 
    0.10361568f, 0.15903176f, 0.08740935f, 0.27965388f, 0.16637710f, 0.24356918f, 0.21723507f, 0.08373006f, 
    0.15997787f, 0.09209558f, -0.14884125f, -0.26324296f, 0.03426613f, -0.22405382f, -0.00078191f, 0.27431455f, 
    0.15652291f, -0.02832144f, 0.35227045f, 0.13908549f, -0.13487531f, -0.45398322f, -0.08868995f, 0.24175881f, 
    0.02112204f, 0.16771340f, 0.03638776f, -0.30919275f, -0.23160684f, -0.48791680f, 0.20014980f, 0.12450346f, 
    0.07982583f, -0.14454885f, -0.09802689f, 0.26778540f, 0.17265883f, 0.10591771f, 0.10874251f, -0.08658048f, 
    -0.30027631f, 0.14829783f, -0.00633050f, 0.26827595f, 0.36064678f, 0.42131770f, -0.35852158f, 0.12246040f, 
    -0.10250145f, -0.05919914f, 0.48452997f, -0.16647360f, 0.23639646f, 0.52581620f, -0.28767097f, -0.26832089f, 
    0.17555016f, 0.06676208f, -0.09663976f, 0.07527234f, 0.06203872f, 0.47939178f, 0.19413319f, -0.04406642f, 
    -0.04104261f, -0.00622365f, 0.08754443f, 0.58504170f, 0.54350632f, 0.24599867f, 0.15512334f, -0.13960971f, 
    -0.11679322f, -0.16026479f, 0.00355526f, -0.04217425f, -0.14622404f, 0.15568151f, 0.28440899f, -0.08567159f, 
    -0.13551892f, 0.14212441f, -0.30191228f, 0.12614243f, 0.15554741f, -0.22321533f, -0.18767330f, 0.01416693f, 
    0.06686462f, -0.14932021f, -0.17260955f, 0.08401296f, 0.13317992f, 0.05843703f, -0.12751380f, -0.05338265f, 
    -0.13292456f, -0.15503658f, -0.03777852f, -0.10945613f, -0.14140527f, 0.07894521f, -0.13949895f, 0.03970511f, 
    0.00365798f, 0.11356976f, -0.00910852f, 0.04725794f, 0.00383861f, -0.15632394f, 0.12175489f, -0.06033216f, 
    0.00172106f, 0.02952372f, 0.25175548f, 0.61563003f, 0.31743154f, -0.06297843f, -0.07942092f, 0.27345717f, 
    0.02317515f, 0.12917022f, -0.00313180f, -0.10364197f, 0.26741278f, -0.31043804f, 0.06318316f, 0.06619581f, 
    -0.04771198f, 0.08498437f, 0.12302127f, -0.34268749f, -0.27637899f, 0.29444575f, 0.16295217f, 0.08832555f, 
    -0.16835588f, -0.13827650f, 0.02867614f, -0.21424185f, 0.19812524f, 0.01589597f, -0.03379070f, 0.28759292f, 
    0.39120406f, 0.06259897f, 0.20819311f, -0.15194492f, -0.35100120f, -0.29441881f, 0.27203175f, 0.32131934f, 
    -0.14595489f, 0.20486122f, 0.26733658f, 0.03978185f, -0.15789276f, 0.10976195f, 0.00826767f, 0.14350249f, 
    0.14535633f, 0.08895469f, -0.12017222f, -0.33658856f, 0.38496524f, -0.13045761f, 0.27436930f, 0.01764285f, 
    0.07700383f, 0.05643001f, 0.12360425f, -0.32074523f, 0.22323696f, -0.02729081f, 0.38019943f, 0.18353002f, 
    -0.11955498f, -0.02305943f, -0.37699220f, 0.19403954f, 0.12723558f, -0.09357633f, 0.16913345f, -0.16130084f, 
    0.15610836f, 0.29237166f, 0.02676596f, 0.00204083f, 0.03018798f, -0.32829043f, 0.03686201f, 0.10324966f, 
    -0.04205497f, 0.03744191f, -0.02961507f, -0.07962225f, 0.18331641f, 0.31193182f, -0.01886546f, -0.03149668f, 
    0.47744194f, 0.07256362f, 0.17176130f, 0.27335253f, 0.35673463f, -0.21125911f, 0.17682807f, -0.01705710f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00314268f, -0.20373669f, 0.16221079f, 0.04391580f, -0.05071044f, -0.02727197f, -0.15648745f, -0.14112808f, 
    0.08177198f, 0.15703224f, 0.09146553f, 0.05970693f, 0.12747270f, 0.06441493f, 0.13687557f, -0.06217603f, 
    -0.15464856f, 0.04444501f, -0.07875142f, -0.30501914f, 0.06855999f, -0.06197992f, 0.20582083f, 0.09771913f, 
    0.02109922f, 0.06481573f, -0.03164649f, 0.02029409f, 0.09179915f, 0.06965644f, -0.09527272f, 0.24949837f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.18952972f, -0.09899437f, -0.35107133f, -0.16068707f, 0.16924918f, -0.61841857f, -0.03921869f, 0.12908085f, 
    0.05951317f, -0.35009050f, 0.03829553f, 0.17207584f, 0.01078463f, -0.36858016f, -0.10219259f, -0.30273306f, 
    0.11055138f, -0.04361342f, 0.06143627f, 0.27806062f, 0.08352533f, -0.23573437f, -0.42966223f, 0.22183613f, 
    -0.14332259f, 0.16698045f, -0.28102452f, 0.25061080f, -0.14058039f, 0.02520569f, -0.25279546f, -0.16407005f, 
    0.11337255f, -0.00465852f, 0.24647380f, 0.08653259f, -0.12580507f, -0.28848970f, -0.07899565f, 0.14118654f, 
    0.02728304f, 0.28801066f, -0.20557642f, -0.00315745f, 0.13083124f, 0.03396164f, 0.03231641f, 0.27888027f, 
    0.18184461f, -0.75714570f, -0.32758608f, -0.15809901f, -0.04527371f, 0.09775382f, -0.10073537f, 0.19569670f, 
    -0.91641456f, 0.24129198f, 0.19953743f, 0.08541185f, -0.13379304f, 0.11185665f, 0.16456306f, -0.06750277f, 
    -0.56256580f, 0.02492951f, 0.10516527f, -0.15760157f, 0.20241041f, -0.18471467f, -0.09497567f, -0.01311341f, 
    -0.12790754f, 0.17932591f, -0.21030109f, -0.25142545f, 0.27003461f, 0.11470869f, -0.29842970f, 0.29613486f, 
    -0.14251019f, 0.34261265f, 0.13114086f, -0.41527402f, 0.02883872f, 0.10273824f, -0.12857427f, 0.10808856f, 
    0.34047866f, 0.13611774f, -0.45199609f, 0.08657429f, 0.16628689f, 0.12411111f, -0.27962750f, 0.15091914f, 
    0.22213928f, -0.20018852f, -0.53787953f, 0.09223928f, -0.17436440f, 0.03520978f, -0.22294091f, -0.05098219f, 
    -0.06682263f, -0.03267000f, -0.70227486f, 0.00068172f, 0.18171905f, 0.06312905f, 0.08988340f, 0.11792716f, 
    0.03869221f, 0.49262613f, 0.09636681f, -0.06222624f, -0.16688740f, 0.11525594f, 0.00429078f, -0.19967116f, 
    0.09150726f, -0.08558085f, -0.25983924f, 0.10627965f, -0.11637763f, -0.23157689f, -0.00866775f, -0.52595359f, 
    -0.51386482f, 0.08544672f, -0.12857394f, 0.11096745f, -0.03625461f, 0.09007689f, -0.17183453f, 0.09260660f, 
    -0.00062032f, -0.30299270f, -0.07698211f, 0.32600254f, 0.16820629f, -0.11182145f, 0.23997848f, 0.12906751f, 
    -0.20322768f, 0.17287992f, -0.44845861f, 0.04991820f, 0.16053842f, 0.00434356f, 0.02360009f, -0.17701539f, 
    -0.07682122f, 0.01031807f, -0.38397259f, 0.15210563f, -0.24572183f, 0.11822778f, -0.27414650f, -0.16842453f, 
    0.10895697f, 0.09288388f, 0.00826190f, 0.00950884f, 0.21005854f, 0.31855804f, 0.04739093f, 0.04236215f, 
    0.16095220f, -0.39553884f, 0.02065029f, 0.08192126f, -0.09354319f, 0.15537260f, 0.03039429f, -0.13510151f, 
    0.04961564f, -0.63886595f, -0.33774626f, -0.12338877f, -0.04346849f, -0.30363360f, 0.28401741f, -0.06778269f, 
    -0.07432602f, -0.04587595f, -0.07811242f, 0.17666800f, -0.15123115f, -0.19248298f, 0.14325841f, 0.06629446f, 
    -0.27184179f, -0.19499154f, 0.25883725f, 0.04120473f, 0.22249728f, 0.20406260f, 0.11042021f, 0.11545631f, 
    -0.14599463f, 0.28722030f, 0.07025800f, 0.10833494f, -0.13452424f, -0.24190465f, -0.63935566f, 0.01761309f, 
    -0.78251702f, 0.30337542f, -0.02736408f, -0.37632519f, 0.10424893f, 0.15479986f, 0.20847227f, -0.22911367f, 
    0.04278553f, -0.28310925f, 0.09402484f, -0.70453858f, -0.01218842f, 0.21821289f, -0.24196774f, 0.07989934f, 
    -0.17580028f, 0.05336300f, -0.15606789f, 0.05925343f, -0.38056186f, 0.25635886f, 0.07880598f, -0.16214986f, 
    -0.13069941f, 0.25345913f, 0.12680209f, 0.06878214f, -0.51076770f, -0.46486956f, -0.42710176f, -0.28376639f, 
    0.20445991f, 0.11223168f, 0.05068449f, -0.12126256f, -0.12579775f, -0.06333297f, -0.30655870f, -0.36783856f, 
    -0.04003363f, -0.04304431f, 0.45527568f, 0.02772844f, -0.24214324f, 0.14037704f, 0.18495348f, -0.34345633f, 
    0.17808490f, -0.00683096f, 0.06112628f, 0.05162636f, 0.13616695f, 0.23517932f, 0.12519948f, 0.02642881f, 
    0.04614710f, -0.27243999f, -0.42976278f, -0.72885543f, 0.14715996f, -0.00816869f, -0.77033955f, -0.59096587f, 
    0.18146533f, -0.06910959f, 0.04544894f, 0.04824147f, 0.12150350f, -0.16731369f, 0.23847799f, -0.04579173f, 
    -0.31779930f, 0.04766477f, 0.25412816f, -0.06284676f, -0.60265213f, 0.32023472f, 0.14986211f, 0.14209263f, 
    -0.62397045f, -0.02246496f, 0.24107528f, 0.03604981f, 0.03874496f, 0.04816989f, 0.04544457f, 0.10311986f, 
    0.10378961f, 0.04471032f, 0.26597095f, 0.36109644f, -0.50116175f, -0.26125115f, 0.22055200f, 0.13855742f, 
    -0.59540278f, -0.22181812f, -0.14091225f, -0.37376523f, 0.08152615f, -0.10613984f, -0.40492967f, -0.16186005f, 
    0.33806813f, -0.25171629f, 0.19481412f, -0.06834532f, -0.05059490f, -0.42471102f, -0.07747891f, 0.12557653f, 
    0.27162021f, -0.05682516f, 0.15242299f, -0.00031437f, -0.05921739f, -0.29135221f, -0.02786407f, 0.11579016f, 
    0.10620296f, -0.16627309f, -0.77308077f, -0.27809536f, 0.43628386f, 0.31735054f, 0.04252960f, 0.13397212f, 
    -0.24757361f, -0.12140861f, -0.31096119f, 0.25566095f, -0.01023614f, -0.15156379f, 0.30107099f, -0.15236777f, 
    -0.15705158f, -0.33920851f, -0.19831817f, 0.01588462f, -0.12886198f, 0.31254387f, -0.25947028f, 0.34615687f, 
    0.10721652f, -0.03001828f, 0.02750041f, 0.06626447f, 0.19478972f, -0.10324039f, -0.13848417f, 0.14408903f, 
    -0.07526253f, 0.10024361f, -0.28458968f, -0.07632492f, -0.55551744f, 0.41278380f, -0.09478605f, -0.23068534f, 
    -0.30642140f, 0.13341917f, 0.40513811f, 0.17551935f, -0.03815697f, 0.41809842f, -0.01458918f, 0.18928218f, 
    -0.02461068f, -0.14813599f, -0.47269502f, -0.41840973f, -0.28688589f, -0.38301137f, 0.33357170f, 0.24354562f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.11933838f, -0.06450331f, 0.06065416f, -0.16179074f, -0.20271456f, -0.10833819f, -0.03216160f, -0.05540917f, 
    0.06305735f, 0.25373420f, 0.18363193f, 0.14629593f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
