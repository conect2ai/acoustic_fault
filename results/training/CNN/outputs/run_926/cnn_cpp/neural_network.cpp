#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.19268689f, 0.30933300f, -0.68526262f, -0.48972422f, -0.34937978f, 0.50576985f, 0.20297818f, 0.26265043f, 
    0.36131203f, -0.40175003f, -0.37151873f, 0.02071355f, -0.20437361f, -0.11429668f, -0.44416773f, 0.12263273f, 
    -0.00951189f, -0.25676927f, -0.14699359f, -0.05971948f, 0.05174008f, -0.18586132f, 0.17094018f, -0.34881732f, 
    0.14219487f, -0.21799475f, -1.17912209f, -0.23694529f, 0.33858728f, 0.10875446f, -0.31061018f, 0.88724703f, 
    0.47734347f, -0.36112943f, 0.31400990f, 0.23230724f, 0.04248359f, -0.04049491f, 0.11579752f, 0.14872052f, 
    -0.11886425f, 0.16785833f, -0.08484604f, -0.01643716f, 0.00653494f, 0.16316618f, 0.02922557f, 0.11610503f, 
    0.00156969f, 0.24717884f, -0.98358494f, 0.40964729f, 0.68994981f, -0.65008622f, -0.59759438f, 0.45330450f, 
    0.42145303f, -0.40355679f, 0.32329091f, 0.03663059f, 0.27984127f, 0.33121172f, -0.07106601f, 0.04008862f, 
    0.16975500f, 0.03345002f, 0.04470759f, -0.22332183f, -0.00133458f, -0.13024993f, 0.21355726f, 0.18678735f, 
    0.23834194f, 0.25579986f, 0.08027910f, -0.48761454f, -0.38582394f, 0.16640425f, 0.58780974f, 0.66666001f, 
    0.47792473f, -0.33734897f, -0.65414548f, -0.14703725f, -0.53993201f, 0.17889072f, 0.44460723f, 0.21414946f, 
    0.27841929f, 0.12784667f, 0.11483599f, -0.09583083f, 0.02426608f, 0.36030227f, 0.26840559f, -0.02746996f, 
    0.20412202f, -0.28073561f, 0.15807149f, -0.16962640f, 0.04831975f, -0.59560978f, -0.01258125f, 0.43308514f, 
    -0.56240648f, -0.15211295f, -0.36945534f, -0.25933820f, 0.60700095f, -0.24710487f, -0.23202486f, -0.03989124f, 
    -0.05493411f, -0.11986511f, -0.27194759f, -0.09011994f, -0.14627802f, 0.32752135f, 0.22200264f, 0.04592127f, 
    0.42694560f, 0.27095115f, -0.08976518f, 0.25904685f, 0.08910473f, -0.53111225f, -0.56858659f, -0.71759188f, 
    -0.33199689f, 0.08114994f, 0.11740532f, -0.61500919f, -0.36196887f, -0.04139505f, 0.04933505f, -0.30349192f, 
    0.17020808f, 0.30190620f, 0.11112818f, -0.02121861f, 0.33850393f, 0.21134791f, 0.19398750f, 0.09902242f, 
    -0.10003959f, 0.14569694f, 0.05768124f, 0.28980896f, -0.25545651f, -0.35461923f, 0.87188268f, 0.34080625f, 
    0.39561895f, 0.89834285f, 0.60136968f, -0.02573150f, 0.03829632f, 0.14945549f, 0.08463095f, 0.16230449f, 
    -0.14264810f, -0.34717610f, 0.11563808f, -0.08282327f, 0.26559252f, -0.07119779f, -0.12894085f, -0.07917634f, 
    -0.32093450f, 0.20230320f, 0.05607616f, -0.09077124f, 0.11293103f, -0.25619400f, -0.09431792f, -0.06872872f, 
    0.15753698f, 0.04055589f, 0.74385887f, -0.00280834f, 0.42449686f, -0.10594154f, 0.18364941f, -0.39814994f, 
    -0.51908261f, -0.19428183f, -0.18146877f, -0.25208056f, -0.02386328f, -0.42126822f, -0.00319433f, 0.33463848f, 
    0.40044942f, 0.29270524f, -0.16689438f, -0.01934764f, -0.33238387f, -0.35221323f, 0.02337583f, -0.27659848f, 
    0.56600434f, 0.54823112f, 0.72267246f, 0.27258834f, 0.62488067f, -0.06621984f, -0.61309171f, -0.57963300f, 
    -0.56378931f, -0.46726680f, 0.29968780f, 0.35187724f, -0.00098335f, 0.23909567f, -0.00281662f, 0.42204958f, 
    -0.21156126f, -0.11491255f, -0.01218938f, -0.13666213f, -0.07065616f, 0.23260520f, 0.34164327f, -0.16374902f, 
    0.34538275f, 0.79189080f, 0.17695166f, 0.78438026f, 0.01796081f, -0.19118518f, 0.61928028f, -0.53522992f, 
    -0.31930774f, 0.05573853f, -0.01884919f, 0.52995485f, 0.48773003f, -0.00405389f, -0.24312975f, 0.09397877f, 
    0.25361094f, 0.20989528f, -0.05329543f, -0.06778031f, -0.02725650f, 0.22862156f, 0.16849913f, 0.25908604f, 
    0.16247469f, 0.22726259f, 0.68013626f, 0.10189954f, -0.73378158f, -0.84198439f, -0.46642780f, 0.09623630f, 
    -0.39891291f, -0.45563647f, -0.29352745f, 0.08928361f, 0.22626199f, 0.15304358f, 0.34370857f, 0.20670371f, 
    -0.07522880f, -0.17363070f, 0.13382095f, -0.10308739f, 0.19186534f, 0.39257315f, 0.11809380f, 0.10530376f, 
    0.28637120f, -0.05805763f, -0.00707134f, 0.35258198f, -0.65811038f, -0.56030077f, 1.01899004f, -0.03504653f, 
    0.23879518f, 0.15983744f, 0.34984818f, 0.17670102f, -0.27147347f, -0.01012458f, -0.22519116f, -0.14141084f, 
    0.29488152f, -0.13090783f, -0.19397345f, -0.10494711f, 0.13628080f, -0.42745778f, 0.35219145f, 0.11210930f, 
    0.15805700f, 0.27975225f, -0.19402209f, 0.12545225f, 0.62937814f, -0.01963716f, -0.33039418f, -0.43269733f, 
    0.90468341f, 0.65938812f, 0.16065900f, 0.49091354f, 0.41876769f, 0.37212917f, -0.38584408f, -0.06915069f, 
    -0.07504102f, -0.08990391f, -0.34767756f, -0.20402476f, 0.00113670f, -0.03912449f, -0.22149578f, -0.27195099f, 
    -0.09906840f, 0.13028972f, 0.17603478f, -0.02982345f, -0.11105898f, 0.83001459f, 0.69630700f, 0.56473154f, 
    -0.10535023f, -0.87973428f, -0.29583204f, -0.32862887f, 0.06482332f, 0.25826427f, 0.26005509f, 0.21930005f, 
    0.02066970f, 0.16345510f, 0.04505268f, 0.05655034f, -0.00422982f, 0.18633279f, 0.19599859f, -0.03372538f, 
    -0.05151139f, 0.28666613f, -0.11537895f, 0.13893002f, -0.03273742f, -0.07715825f, -0.00578028f, -0.53236008f, 
    -0.16279435f, -0.59102911f, 0.04660021f, -0.31641766f, -0.75483364f, -0.30025870f, 0.18660340f, -0.82063735f, 
    -0.32968277f, 0.01259371f, 0.20022875f, -0.12115615f, -0.00966263f, 0.04695152f, 0.01776285f, -0.15628657f, 
    0.26340973f, -0.28533104f, 0.13885637f, -0.01995843f, -0.20163533f, -0.04621693f, -0.01386150f, -0.81718820f, 
    -0.74448341f, -0.40765411f, -0.24363908f, 0.39110607f, -0.31332275f, 0.94510233f, 0.19677442f, 0.13150902f, 
    0.51572657f, -0.08291125f, -0.18477054f, 0.02293194f, -0.18682453f, 0.27110150f, 0.08549853f, -0.23202020f, 
    -0.03746389f, 0.00275838f, 0.00349105f, -0.07577389f, 0.22617930f, -0.09421276f, 0.30722430f, 0.16132173f, 
    -0.05149285f, -0.38181660f, 0.36522260f, -0.34856248f, -0.36247137f, 0.06099410f, -0.32221824f, 0.03759822f, 
    -0.70433348f, 0.15635933f, -0.04910888f, 0.17282976f, -0.25362465f, 0.16990134f, 0.40173066f, 0.31284040f, 
    -0.33843321f, 0.27168038f, -0.39287207f, -0.23658188f, -0.17978120f, -0.07353044f, -0.22287582f, 0.15168142f, 
    -0.02439623f, -0.85633701f, -0.28514910f, -0.36242527f, -0.31692523f, -0.58750987f, 0.48387420f, 0.62649608f, 
    -0.38965797f, 0.43057373f, 0.39313328f, -0.13177067f, -0.37041911f, 0.25533965f, 0.00466861f, 0.30663285f, 
    0.00652602f, 0.10502946f, 0.16314904f, 0.09774246f, -0.02403869f, -0.10193743f, -0.04316957f, -0.12633856f, 
    -0.08971269f, -0.01124631f, -0.50821018f, -0.01701986f, 0.59144390f, 0.39521438f, 0.03078520f, 0.69559795f, 
    -0.03791466f, 0.03893936f, -0.39786315f, 0.29592121f, 0.23029175f, -0.14648570f, 0.42543298f, 0.59103429f, 
    0.05191716f, -0.20869362f, 0.13610783f, -0.41934496f, -0.17536160f, 0.22000480f, -0.16471709f, 0.04630157f, 
    0.09251243f, -0.05551024f, -0.19331914f, -0.56883538f, 0.19595805f, -0.38726300f, 0.55429375f, 0.09029824f, 
    0.13798524f, -0.48817354f, -0.85470772f, 0.11284827f, 0.24256721f, 0.11172904f, -0.25715366f, 0.11917762f, 
    0.32244524f, -0.40792474f, -0.34226382f, -0.51124227f, -0.55271482f, -0.15203884f, -0.32405633f, 0.02791692f, 
    0.23631188f, 0.23975943f, 0.00140548f, 0.21050969f, 0.07158753f, -0.31245315f, -0.29119712f, 0.43220904f, 
    0.43612108f, 0.66955358f, 0.50492954f, 0.25677180f, 0.41077146f, 0.26463470f, 0.13417199f, 0.30511278f, 
    -0.52528393f, 0.14404537f, -0.34138566f, -0.34641835f, -0.22754304f, -0.39241472f, 0.17324448f, -0.00634221f, 
    0.01578371f, 0.07165032f, -0.23454089f, -0.16027118f, -0.20680933f, -0.57429236f, -0.66579479f, -0.10405540f, 
    0.76504833f, 0.30058393f, -0.36993173f, 0.38342732f, 0.05562762f, 0.24858338f, -0.46948820f, -0.16913106f, 
    0.16666371f, -0.17854901f, -0.34374002f, -0.24053834f, -0.25612947f, -0.00791986f, 0.08824083f, 0.19072014f, 
    -0.24565136f, -0.26152241f, 0.03288652f, -0.24588364f, -0.00703528f, -0.30469197f, -0.25436297f, -0.25240466f, 
    0.66475147f, 0.75372273f, 0.40033337f, 0.20487642f, -0.10871635f, -0.21656482f, 0.03816043f, 0.22182418f, 
    0.09201187f, -0.03872993f, -0.14232373f, -0.27830994f, -0.12514162f, -0.33676499f, 0.19957392f, -0.00153278f, 
    -0.30135861f, -0.32138854f, -0.26423612f, -0.13217884f, -0.05329383f, 0.35067582f, 0.24003027f, 0.71582389f, 
    -0.28034049f, -0.66487563f, -0.83901685f, -0.19180685f, 0.73126554f, -0.03972850f, 0.38710997f, 0.43156773f, 
    0.24306963f, -0.22740719f, 0.09216553f, -0.34086648f, -0.10271315f, 0.01283747f, 0.04067108f, 0.01848175f, 
    0.16199270f, 0.28357983f, 0.10594703f, 0.02898108f, 0.00612529f, -0.50632298f, 0.08029065f, 0.19348103f, 
    0.37264699f, -0.52231896f, -0.21571535f, 0.64297456f, 0.78691983f, -0.93743575f, -0.63552129f, -0.12489818f, 
    -0.48514172f, 0.32601067f, 0.23111099f, 0.30531216f, -0.22975993f, -0.08674694f, 0.08287759f, -0.00751767f, 
    0.08596894f, 0.09181844f, 0.24895881f, 0.06278045f, 0.00374425f, -0.12317376f, -0.14362410f, 0.15144397f, 
    -0.16584681f, 0.03547521f, -0.54713166f, -0.60266346f, -0.12230859f, -0.19245028f, 0.21935400f, 0.25453684f, 
    0.68879408f, 0.51525718f, -0.14927393f, 0.01360849f, -0.34636045f, -0.60234624f, -0.42157555f, 0.13266678f, 
    -0.03029894f, -0.12882864f, -0.28732210f, 0.09735493f, 0.11911723f, -0.09932711f, -0.18028346f, 0.22182983f, 
    -0.30774704f, -0.06905084f, -0.18096356f, -0.30153239f, -0.27888110f, -0.14983027f, -0.31606847f, -0.44557858f, 
    0.55219716f, 0.44493335f, -0.52368790f, -0.35186335f, 0.06380554f, 0.34025025f, -0.30414099f, -0.40753776f, 
    -0.33625370f, 0.04795123f, -0.14585611f, 0.19257188f, -0.00440634f, -0.00152220f, -0.07030614f, -0.29284158f, 
    0.14740871f, 0.03675339f, 0.20551372f, 0.97749317f, 0.40117708f, 0.27341422f, 0.93916196f, 0.73100263f, 
    0.33514392f, 0.40058696f, -0.36341852f, 0.54846734f, -0.12381888f, -0.11490583f, 0.03934297f, -0.14490016f, 
    0.00478543f, -0.29595003f, 0.12157963f, 0.20046528f, 0.00252267f, -0.07562644f, -0.05306942f, 0.00727566f, 
    0.20698889f, 0.18735787f, 0.03911391f, 0.14496365f, -0.43452498f, -0.43469396f, -0.16842480f, -0.42143041f, 
    -0.54583776f, -0.45001879f, 0.05882340f, 0.31134340f, 0.06005267f, 0.31925300f, -0.11589760f, 0.04547710f, 
    -0.26329899f, 0.06741017f, 0.09066435f, 0.14479396f, 0.19508889f, -0.30780223f, -0.23816843f, 0.38340938f, 
    -0.12491196f, 0.20926362f, -0.19982319f, -0.17733623f, -0.29890817f, -0.54581153f, -0.79580003f, -0.33760446f, 
    -0.41422015f, 0.04509495f, 0.27942014f, 0.19176960f, 0.03325550f, -0.51678115f, 0.35305148f, 0.01432724f, 
    0.02253899f, 0.27463019f, -0.14216764f, 0.50195950f, -0.54369038f, -0.17310973f, -0.15538953f, -0.37796682f, 
    -0.29175377f, 0.01692137f, -0.10883977f, -0.06416389f, -0.10324588f, -0.28205013f, -0.42632681f, 0.80782777f, 
    0.97261387f, -0.68465835f, 0.85645145f, 0.90454221f, 0.02056749f, 0.01985747f, -0.44293824f, -0.35995182f, 
    0.06237642f, 0.23188923f, 0.08608113f, 0.03255070f, -0.14980058f, -0.05229238f, 0.02780418f, -0.11202399f, 
    -0.11920192f, -0.02853670f, -0.03096612f, 0.05090393f, -0.03115011f, -0.07777418f, 0.02259193f, 1.10579240f, 
    0.43979281f, -0.80949849f, -0.05026988f, 0.02877552f, -0.17178348f, -0.13865961f, 0.09774816f, 0.32281011f, 
    0.09592102f, -0.29425213f, 0.31633592f, 0.35188398f, -0.14130646f, 0.18413047f, 0.06829128f, -0.55710036f, 
    0.09780108f, 0.23631732f, 0.17726123f, -0.10421257f, 0.02348150f, 0.04575244f, -0.13296232f, -0.11389004f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.05649720f, 0.26264200f, 0.15703370f, 0.09402515f, 0.04931964f, 0.35591707f, 0.06597666f, -0.04040530f, 
    0.07841745f, 0.26012403f, 0.29873326f, 0.15251046f, 0.08284159f, 0.09868889f, 0.18507361f, 0.09511319f, 
    0.13648009f, -0.12546426f, 0.27421093f, 0.09318990f, 0.07546603f, 0.04170312f, 0.27403736f, 0.09658521f, 
    0.27470121f, 0.01627029f, 0.07611758f, 0.35047171f, 0.24107906f, 0.09440152f, 0.12021066f, 0.28087035f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15543748f, 0.27274734f, -0.20337513f, 0.12136529f, 0.05440843f, 0.08471195f, 0.11405832f, -0.11452402f, 
    -0.08660632f, 0.09878511f, 0.10310591f, 0.12347917f, 0.31589779f, 0.07341861f, 0.09160943f, -0.01014793f, 
    -0.00908192f, 0.05720965f, 0.06469185f, -0.00333090f, 0.06568491f, -0.07779796f, 0.04282349f, 0.06258079f, 
    0.47536466f, 0.07744464f, 0.14970864f, 0.16493353f, 0.00192909f, 0.27652770f, -0.02397236f, 0.12268744f, 
    -0.06920606f, 0.10585225f, -0.06081480f, -0.09142259f, 0.11204358f, -0.32636443f, 0.29240134f, 0.04086528f, 
    0.04466716f, 0.11202300f, 0.01452466f, -0.10599176f, 0.05795574f, -0.12888964f, -0.08226549f, -0.25696576f, 
    -0.01345260f, 0.06423204f, 0.20819102f, -0.13030948f, 0.04700514f, 0.02769835f, 0.05517790f, -0.00620483f, 
    -0.07945484f, -0.06476180f, 0.02574155f, -0.00645329f, -0.00049206f, -0.05333963f, 0.03682897f, 0.00020800f, 
    -0.03600779f, -0.00144905f, -0.01215938f, 0.01181196f, 0.01978187f, -0.00602139f, -0.04897382f, -0.00253353f, 
    0.15161079f, 0.08644806f, 0.14858103f, -0.13644588f, 0.00157604f, 0.06566070f, -0.00776618f, 0.05833717f, 
    -0.01294291f, 0.08356194f, 0.13502008f, -0.09617080f, 0.07719965f, -0.13326323f, 0.21532403f, 0.03650269f, 
    -0.07847956f, 0.13236497f, 0.00973728f, 0.02288487f, 0.02840011f, 0.08801886f, 0.01130381f, -0.03205232f, 
    0.27188608f, -0.09617954f, -0.13548078f, 0.28605908f, -0.05817807f, -0.01182677f, -0.06860662f, -0.03498863f, 
    -0.03129410f, -0.05114762f, -0.09271215f, -0.12868160f, -0.02044115f, -0.18092301f, -0.12353797f, 0.13151924f, 
    0.00671966f, 0.00788133f, 0.04351758f, 0.00721217f, 0.01116907f, 0.05550909f, -0.11549344f, -0.15728743f, 
    -0.12179687f, -0.01747201f, -0.11674818f, 0.02911503f, -0.03165997f, -0.13472250f, -0.03491200f, -0.15675081f, 
    -0.02518398f, -0.08239519f, -0.03581445f, -0.05422665f, 0.16629241f, -0.18004753f, 0.12137175f, -0.10533465f, 
    -0.00703561f, -0.00850425f, -0.01802108f, -0.11924848f, 0.02656842f, -0.08821532f, 0.03078488f, -0.06129854f, 
    -0.09269694f, -0.12994409f, 0.10026650f, -0.12550452f, -0.01838918f, -0.04665544f, 0.12505209f, 0.01525760f, 
    -0.06722876f, 0.08270827f, -0.03354201f, 0.05474180f, -0.14441095f, 0.12032381f, -0.14735626f, 0.11178948f, 
    -0.05311006f, 0.04228584f, -0.01565330f, -0.06318685f, 0.00176893f, -0.09043180f, 0.05597547f, -0.15522894f, 
    -0.12078852f, -0.04662349f, 0.03039011f, 0.10344977f, 0.02426587f, -0.03839730f, -0.08210121f, -0.12068735f, 
    0.14881489f, 0.00563367f, -0.03111991f, -0.09755624f, -0.13484214f, 0.25150079f, 0.12880251f, 0.00639557f, 
    -0.07819872f, 0.01112991f, 0.02495632f, 0.10071310f, -0.04821644f, -0.09745235f, 0.04097857f, -0.00530805f, 
    -0.01354308f, 0.05855377f, -0.06175962f, -0.08350344f, 0.09201986f, -0.12332720f, 0.05232172f, 0.01975151f, 
    -0.03861256f, 0.10485622f, 0.03474855f, -0.07809514f, 0.37624574f, 0.14863443f, -0.01899325f, -0.10144623f, 
    -0.14312600f, 0.08377056f, 0.02642677f, 0.08844865f, -0.02986181f, -0.00794910f, -0.04437233f, 0.00700445f, 
    0.24285337f, -0.13971791f, 0.02581754f, -0.00623379f, -0.07771624f, 0.03528025f, 0.11645734f, 0.03521154f, 
    -0.01519381f, -0.05318927f, 0.06738272f, -0.04401584f, 0.25131330f, 0.08366057f, -0.08693146f, 0.02909944f, 
    0.05961368f, -0.00043272f, -0.15751012f, 0.00749482f, -0.03841214f, 0.10179282f, 0.15744770f, 0.15851961f, 
    0.10593054f, -0.32546741f, -0.02468225f, -0.07280894f, -0.05769992f, -0.00930413f, 0.07978629f, -0.05601851f, 
    0.08234271f, 0.03915695f, 0.20083873f, 0.07756415f, 0.08461786f, 0.09491422f, 0.04669398f, -0.35058981f, 
    0.06330834f, 0.08729161f, 0.00592063f, 0.04293799f, 0.13885134f, 0.18026777f, 0.04739732f, 0.04397682f, 
    0.12509985f, -0.33049539f, -0.07109566f, -0.01687524f, -0.03354100f, -0.01954088f, 0.04669811f, -0.02199753f, 
    -0.03099343f, 0.12247388f, -0.08255238f, 0.12238494f, -0.08774052f, -0.04604966f, -0.17797302f, 0.02459002f, 
    -0.06475125f, -0.00633693f, 0.12413558f, -0.08827730f, -0.04768183f, 0.00841703f, 0.04280951f, 0.00818393f, 
    0.40765586f, 0.23787469f, -0.01444324f, 0.07756388f, 0.04763092f, 0.16231397f, 0.03012478f, -0.10336648f, 
    -0.04811546f, -0.03464808f, -0.10811454f, -0.03889080f, -0.15705469f, 0.06898344f, -0.09394935f, -0.00996098f, 
    0.02944806f, -0.02743784f, 0.06000160f, -0.00655957f, 0.00709081f, -0.00468810f, 0.14207223f, 0.04335225f, 
    0.16651095f, 0.14115003f, 0.06656817f, -0.10584451f, 0.03038219f, 0.04856958f, 0.13729987f, -0.04574210f, 
    0.04632446f, 0.17417903f, -0.00924549f, -0.01886257f, 0.23781686f, -0.02064805f, 0.07275460f, -0.12538674f, 
    -0.02188147f, -0.03550428f, -0.00080563f, 0.00798494f, -0.08660354f, 0.05165734f, 0.04341649f, -0.10639294f, 
    0.05239405f, 0.07374131f, -0.02686611f, 0.05803452f, -0.05842448f, 0.06400248f, -0.06600886f, 0.15125437f, 
    0.13468628f, -0.04092582f, 0.05084683f, 0.05705330f, 0.14001083f, -0.12476195f, 0.12869135f, -0.17838486f, 
    -0.08745993f, 0.08455964f, -0.04142395f, 0.11263232f, -0.09032341f, 0.07942329f, 0.14460903f, 0.14638595f, 
    0.16688184f, -0.32288834f, 0.15914240f, 0.47567543f, -0.01918131f, 0.00312917f, 0.07588095f, -0.01565278f, 
    -0.00098316f, 0.07059389f, -0.02042006f, 0.06365876f, 0.12340461f, 0.13292810f, -0.08293992f, -0.01498820f, 
    -0.03309122f, 0.07137564f, 0.06322897f, 0.10823307f, 0.03987176f, -0.04810430f, -0.04292288f, 0.00504320f, 
    0.01024298f, 0.00563784f, 0.03460704f, 0.01129787f, -0.01430021f, -0.04412588f, -0.01458296f, 0.04128207f, 
    -0.05131970f, -0.02193650f, 0.04683338f, 0.03202685f, -0.00355668f, -0.02787855f, 0.01751357f, -0.04697698f, 
    -0.05423657f, -0.02218551f, 0.02577654f, -0.02327675f, -0.00319927f, -0.01436253f, 0.00051270f, 0.01116967f, 
    -0.00639153f, 0.02054666f, -0.00375821f, -0.01843775f, -0.02468839f, 0.00613911f, -0.00676544f, 0.00933293f, 
    -0.02143505f, -0.01200541f, -0.03981362f, -0.03927235f, 0.04588231f, -0.04398324f, 0.04015407f, -0.01185485f, 
    -0.05205135f, -0.02860360f, 0.00228897f, 0.01817567f, -0.02016322f, 0.02779260f, 0.02411705f, -0.02045071f, 
    -0.01055787f, -0.02804490f, -0.02931963f, 0.01013012f, -0.02718913f, 0.00764963f, 0.00285553f, 0.03611789f, 
    0.00397982f, 0.00701185f, 0.04125943f, -0.01053256f, -0.01282469f, -0.00654047f, 0.04112680f, -0.03174308f, 
    -0.01522483f, 0.04305789f, -0.03638094f, 0.01431766f, -0.04366960f, -0.00325043f, -0.04167952f, 0.03507680f, 
    -0.01755314f, -0.04916447f, -0.01436409f, -0.01316481f, -0.00169679f, 0.03412288f, 0.02567818f, -0.00435832f, 
    -0.03978261f, -0.04287369f, -0.00522697f, 0.03615729f, -0.04063625f, -0.02725449f, -0.02438169f, -0.01149078f, 
    0.04506648f, -0.00568277f, -0.00190481f, -0.02129683f, -0.02377305f, 0.03073785f, 0.02684398f, -0.04298433f, 
    0.01144911f, 0.01143439f, 0.01460268f, -0.00510272f, -0.01998562f, 0.00956884f, 0.03664722f, -0.00898416f, 
    -0.03603412f, 0.00843180f, -0.02749879f, -0.00471498f, -0.04240812f, -0.01716210f, -0.03222978f, 0.03405964f, 
    0.00077823f, 0.00563911f, 0.01404525f, -0.03909794f, 0.01150257f, 0.04324954f, -0.05286883f, -0.02340487f, 
    -0.03356955f, -0.05672751f, -0.03014867f, -0.03385242f, 0.02134825f, -0.02222786f, 0.02175024f, 0.02849810f, 
    -0.04695592f, -0.01624661f, -0.02794510f, 0.04295927f, -0.00876739f, 0.02492722f, 0.00056837f, 0.01809400f, 
    -0.01134276f, -0.02531775f, -0.01954622f, -0.01358634f, 0.00380572f, -0.01732628f, 0.00676095f, 0.01203160f, 
    -0.04754084f, 0.03395735f, 0.01114986f, -0.03408961f, 0.00141742f, 0.00205856f, 0.04521891f, 0.04047021f, 
    -0.04078675f, 0.03031481f, 0.00407565f, -0.03989065f, 0.02970482f, -0.04930552f, -0.03938593f, 0.00627878f, 
    0.00437736f, 0.03976271f, 0.02399066f, 0.04591766f, 0.04154780f, -0.04619580f, 0.01299786f, -0.02209777f, 
    0.01777256f, -0.05525308f, 0.02636589f, 0.02513040f, -0.02058717f, -0.02475136f, 0.01904009f, -0.04061467f, 
    0.00891118f, -0.00835970f, 0.00407327f, 0.03280580f, 0.01783648f, 0.01560604f, -0.01062041f, -0.05668878f, 
    -0.00762604f, -0.04184142f, -0.05041147f, 0.03286621f, 0.02735251f, 0.00570162f, 0.03195205f, 0.03020652f, 
    -0.02544620f, 0.04347422f, -0.01004977f, -0.02025567f, -0.03282079f, -0.00335609f, 0.02010113f, 0.04491481f, 
    -0.05612524f, 0.02670117f, -0.01207720f, 0.03067473f, 0.01921248f, 0.00600451f, 0.03660809f, -0.02258695f, 
    0.04859615f, 0.00948289f, 0.03040835f, -0.02408752f, -0.05434360f, -0.03466682f, 0.00425674f, 0.02268013f, 
    0.00633666f, 0.03977732f, -0.03944189f, 0.04271138f, -0.02557498f, -0.03745312f, -0.04274682f, -0.04421721f, 
    -0.03060892f, -0.02390351f, 0.02120509f, 0.02102683f, 0.01840153f, -0.05126889f, 0.00868557f, -0.04097641f, 
    -0.04498504f, -0.01130685f, -0.04973208f, 0.01544450f, 0.01628272f, 0.04467200f, -0.00074875f, -0.05185667f, 
    0.03343414f, 0.04676556f, -0.01182550f, -0.04991863f, -0.02556303f, -0.04856012f, -0.02797756f, 0.00683482f, 
    0.03174418f, -0.02678949f, 0.00279599f, -0.04813655f, 0.03107257f, -0.03291001f, -0.00455532f, 0.00235075f, 
    -0.04801790f, -0.00010043f, -0.04767468f, -0.00181587f, -0.04186789f, 0.00720230f, 0.03033194f, 0.02470018f, 
    -0.01228897f, 0.03531814f, 0.04056986f, -0.05668717f, -0.01789899f, -0.03651387f, -0.04534221f, 0.01422784f, 
    -0.03636178f, 0.02610004f, 0.04006973f, 0.00072870f, 0.02992727f, -0.00015287f, -0.04752897f, -0.03213846f, 
    -0.02540019f, -0.01234323f, -0.00291680f, -0.02891266f, 0.01929159f, 0.04221915f, 0.01976421f, 0.02472405f, 
    0.02712571f, 0.00941231f, 0.01942796f, -0.03838016f, 0.03998523f, -0.03928467f, 0.02539221f, 0.04704212f, 
    -0.03996125f, -0.03153372f, -0.00151562f, 0.02680087f, -0.02392213f, 0.03224034f, -0.00673818f, -0.02337261f, 
    -0.00758349f, 0.00486547f, -0.01399348f, -0.01564374f, 0.02704653f, -0.02453223f, -0.02577684f, -0.05195364f, 
    -0.03627211f, 0.03918440f, 0.00166703f, -0.03651275f, -0.03163403f, 0.02714508f, -0.01144230f, -0.05410421f, 
    0.00103074f, -0.00166893f, 0.00411363f, 0.03646535f, -0.00873762f, -0.03155467f, -0.02966211f, -0.04014694f, 
    0.03344952f, 0.00116561f, -0.00342824f, 0.03054445f, -0.03469501f, -0.05184929f, -0.03178907f, -0.04819956f, 
    -0.02193123f, 0.02553710f, -0.04508733f, -0.00176714f, 0.00652501f, -0.00798539f, -0.01860995f, -0.02628889f, 
    -0.04055622f, -0.03044496f, -0.02928082f, -0.01167730f, -0.04045972f, 0.02021935f, -0.01755107f, -0.00573549f, 
    0.01884713f, 0.00723995f, -0.02833779f, 0.03608719f, 0.01697860f, 0.02593441f, -0.05360374f, 0.00440012f, 
    0.00467343f, 0.00450242f, -0.00311854f, 0.03009060f, -0.05567066f, 0.00574134f, -0.04681589f, -0.02564899f, 
    -0.00935312f, -0.03448308f, 0.02604344f, 0.02482888f, 0.04440344f, -0.00089530f, 0.02034438f, 0.02184574f, 
    0.00319231f, -0.02126197f, -0.03592545f, -0.02564188f, -0.04483946f, 0.01882514f, -0.03062559f, -0.00316061f, 
    0.02938909f, -0.00426921f, 0.01853111f, 0.01939566f, -0.02079955f, -0.00738024f, -0.05536031f, -0.03850115f, 
    0.02600536f, 0.02990170f, -0.02394762f, -0.04063245f, -0.02362903f, -0.05480292f, 0.03985387f, 0.04197840f, 
    0.01522065f, -0.04637331f, 0.01353840f, 0.00046073f, -0.02989449f, -0.03519437f, 0.02040126f, 0.03151041f, 
    -0.03047026f, -0.02178657f, -0.04783680f, -0.05143867f, -0.01694910f, -0.05711057f, 0.03320507f, -0.01675847f, 
    -0.00012416f, 0.03997489f, -0.03305165f, -0.00305445f, -0.01176585f, 0.00527575f, 0.01192914f, -0.03325689f, 
    -0.01350590f, -0.04235520f, 0.02785595f, -0.00262460f, 0.02649393f, -0.00775924f, -0.02497048f, 0.01674942f, 
    -0.03464007f, 0.01613174f, 0.03244630f, -0.00361042f, 0.00044783f, 0.03007778f, -0.01333098f, -0.01499856f, 
    -0.00067011f, -0.02181889f, 0.01938594f, 0.00561672f, 0.02071458f, 0.00608858f, -0.05473730f, 0.03877863f, 
    -0.02509041f, 0.03333140f, -0.04489186f, -0.00739737f, 0.00905105f, -0.05065963f, 0.00085857f, -0.01592044f, 
    -0.02399237f, 0.01451337f, -0.03381643f, 0.05183506f, 0.00998300f, -0.05825495f, 0.03312596f, -0.00653799f, 
    0.01290447f, -0.02538325f, 0.02213460f, -0.00095730f, -0.05363245f, 0.02353947f, -0.04623542f, 0.01609933f, 
    -0.05580228f, -0.01050898f, 0.00352615f, -0.04513485f, -0.00315659f, 0.02850824f, -0.00048091f, -0.05220127f, 
    -0.02185559f, -0.01081934f, -0.04608404f, 0.03629198f, 0.03161710f, -0.00991213f, -0.05470549f, 0.01264784f, 
    -0.01484204f, 0.00798021f, -0.00853300f, 0.01130444f, -0.02419986f, -0.05348577f, 0.00361044f, -0.03499945f, 
    -0.01121156f, 0.03097961f, 0.03559908f, -0.03747432f, 0.02983177f, -0.01407759f, 0.01329248f, -0.05260014f, 
    -0.04327463f, -0.03374955f, -0.00924861f, -0.04190570f, -0.02855432f, -0.02926821f, 0.03702562f, -0.00570732f, 
    -0.02048843f, -0.03477162f, -0.02362322f, -0.03822875f, -0.03156654f, 0.03920869f, -0.03418999f, -0.00624039f, 
    -0.05674563f, 0.03645402f, -0.03213982f, 0.03910393f, 0.00862266f, -0.00046127f, -0.01270291f, 0.01401716f, 
    -0.04639466f, -0.03683147f, 0.02796329f, -0.00352358f, -0.02824781f, 0.00058492f, -0.00502204f, -0.05178870f, 
    -0.04418777f, 0.02210580f, -0.00082106f, -0.00689017f, -0.02930579f, 0.03734107f, 0.02350369f, 0.02309072f, 
    -0.03727096f, 0.02514615f, -0.04647592f, -0.02928521f, -0.05250296f, 0.03646295f, 0.00628535f, -0.00223729f, 
    -0.00238891f, 0.03800991f, 0.04021538f, -0.02841069f, -0.04800119f, 0.00131087f, -0.00706516f, -0.00645464f, 
    -0.00097802f, 0.00606590f, -0.00575003f, -0.01905223f, -0.03580487f, -0.05641557f, -0.04722144f, -0.01626425f, 
    -0.03991800f, 0.03797858f, -0.04948679f, 0.01550819f, -0.02543541f, -0.00121649f, -0.01434154f, -0.04473669f, 
    -0.04315295f, 0.00658506f, 0.00178342f, -0.01773691f, 0.01476546f, 0.00257092f, -0.01299700f, 0.00625638f, 
    0.01607303f, -0.00996516f, 0.00150442f, 0.03884757f, 0.03703291f, 0.03081596f, 0.01848063f, -0.02994287f, 
    0.00414625f, 0.01857534f, -0.02356802f, 0.01947849f, 0.02123211f, 0.03497214f, -0.02959242f, -0.00750303f, 
    -0.01306573f, -0.05767052f, 0.01765297f, -0.05484739f, 0.01421257f, 0.00887371f, 0.03980915f, -0.05363473f, 
    0.02383262f, 0.02750313f, -0.02286778f, -0.04889262f, 0.02197676f, 0.03176805f, 0.02522349f, 0.02558577f, 
    -0.04297622f, 0.03931572f, -0.00619860f, 0.03194028f, 0.03863794f, -0.02939825f, 0.02446927f, -0.01083684f, 
    -0.01009245f, -0.04650103f, -0.02731353f, -0.01199770f, -0.02733259f, -0.00637330f, -0.03479810f, 0.04513007f, 
    0.01082638f, 0.02393677f, -0.00690720f, -0.05604252f, 0.00240427f, -0.03574960f, -0.01588988f, 0.04287493f, 
    0.03125721f, 0.03981331f, -0.02084464f, -0.04969158f, 0.03858812f, -0.00676643f, 0.00130311f, 0.01510566f, 
    -0.00432473f, 0.02689113f, 0.03893886f, 0.02606968f, -0.01555319f, -0.00599739f, -0.03669525f, 0.01208808f, 
    -0.01061117f, -0.01269447f, 0.01274863f, 0.03801033f, -0.04223549f, -0.03578879f, -0.05447111f, -0.03387906f, 
    -0.03432029f, 0.00428698f, -0.01857460f, -0.00146683f, -0.03953493f, -0.01961405f, 0.04075733f, 0.03800642f, 
    -0.00601032f, 0.04138298f, -0.00546146f, -0.00982776f, -0.01580918f, -0.04647684f, 0.03764312f, 0.02089337f, 
    -0.05035810f, -0.01714471f, 0.01237103f, -0.00079628f, 0.00915631f, 0.02878022f, -0.03560445f, 0.01036684f, 
    -0.04223618f, 0.02623332f, -0.01273170f, 0.02710187f, -0.01903063f, -0.00755166f, -0.00002034f, -0.05110208f, 
    -0.03406653f, 0.02724817f, 0.03111769f, -0.00808285f, 0.02670245f, 0.01244995f, -0.02590078f, 0.04309808f, 
    -0.00330508f, 0.03294019f, -0.00172443f, 0.02235797f, 0.02980225f, -0.03399576f, -0.00515786f, -0.02134301f, 
    0.00133893f, -0.04706952f, 0.02294131f, -0.02812803f, -0.05412379f, 0.03772035f, -0.05402606f, -0.05046374f, 
    -0.05373327f, 0.00075272f, 0.02444355f, 0.01944064f, 0.00451942f, 0.02072509f, -0.02030701f, -0.01136878f, 
    -0.05322840f, -0.02671635f, -0.00392257f, -0.00516188f, -0.05489353f, -0.00739538f, 0.02561632f, 0.03315046f, 
    -0.04080183f, 0.03236957f, -0.02369841f, 0.01736235f, -0.02818949f, 0.03244420f, -0.01058868f, -0.04071972f, 
    -0.02426733f, 0.03430330f, -0.05662201f, 0.02117877f, -0.00244605f, -0.04340965f, -0.03261574f, 0.02529038f, 
    -0.02210409f, 0.02013105f, 0.02000059f, -0.04241358f, -0.05239630f, 0.00412845f, -0.04335971f, 0.00567212f, 
    -0.01539025f, 0.03665084f, -0.01902330f, 0.01328420f, 0.01166803f, -0.01104295f, -0.05521938f, 0.02646985f, 
    -0.27530915f, -0.24005209f, 0.05958159f, 0.05378073f, -0.14303726f, -0.00910652f, -0.06958482f, -0.03248166f, 
    -0.00095970f, 0.00083861f, 0.03866076f, -0.05884600f, 0.58100086f, -0.25216827f, -0.04720637f, 0.06311884f, 
    -0.00985208f, 0.02899818f, 0.09983922f, -0.09749656f, 0.02354622f, -0.00909311f, 0.06144958f, -0.07862574f, 
    -0.38853300f, -0.08888482f, -0.06680913f, 0.01402552f, 0.02090867f, -0.07548128f, -0.02633337f, 0.09265306f, 
    -0.07063141f, -0.08509400f, -0.03754168f, 0.02112349f, 0.29362813f, 0.01060957f, -0.16194774f, 0.00582388f, 
    0.08976883f, 0.01690456f, -0.02251100f, 0.00430603f, -0.08338643f, 0.04051542f, 0.02557404f, -0.05098093f, 
    -0.13789730f, -0.11935992f, 0.20171207f, -0.06540019f, -0.12928273f, -0.19571213f, 0.05619085f, -0.03724868f, 
    -0.01083621f, 0.00005774f, -0.02283868f, -0.01659089f, -0.10040118f, 0.16598396f, -0.01212695f, -0.17048888f, 
    -0.07115263f, -0.05640653f, -0.03575773f, 0.04032806f, 0.04982157f, 0.10596898f, 0.04060404f, 0.03362277f, 
    -0.20686409f, -0.07001851f, 0.23464914f, -0.08158610f, -0.08304061f, -0.02290998f, 0.00129267f, -0.06251542f, 
    0.02367166f, -0.05385038f, 0.11177683f, 0.10586473f, 0.17528068f, -0.15923178f, -0.02746944f, 0.12943964f, 
    0.00575207f, 0.01998022f, 0.04410186f, 0.01763294f, 0.01045926f, -0.07334776f, -0.09226944f, 0.00318542f, 
    -0.01653133f, -0.06236513f, -0.08330385f, -0.12027360f, 0.21455398f, 0.17023559f, 0.03985270f, -0.00863262f, 
    0.02137981f, -0.00133344f, -0.10811845f, 0.05143349f, -0.03641318f, -0.01553126f, -0.10074996f, 0.10262886f, 
    0.05435644f, 0.03036173f, 0.08951268f, 0.01702200f, -0.01621635f, 0.11969743f, -0.02296882f, -0.09327219f, 
    0.14678112f, 0.09411010f, 0.00331739f, 0.04853098f, -0.01863451f, 0.18810539f, -0.05202901f, 0.09104908f, 
    0.02728974f, 0.02336771f, 0.03809381f, -0.02197667f, 0.18895136f, -0.09543389f, 0.04613595f, 0.03313529f, 
    0.04043186f, -0.04198522f, 0.17268910f, -0.00348951f, 0.12796819f, -0.01283481f, 0.12985083f, 0.04881376f, 
    -0.22889160f, 0.01754725f, 0.07494502f, 0.05950186f, 0.00456178f, -0.02619893f, -0.14495996f, -0.03020329f, 
    0.04877056f, 0.03182553f, 0.04903305f, 0.08758356f, 0.05186061f, -0.12578879f, -0.04753592f, 0.26619190f, 
    0.06921960f, 0.06391379f, 0.11041312f, 0.01800171f, 0.04455828f, 0.03798985f, 0.03728983f, 0.06847785f, 
    0.03040821f, -0.06152161f, 0.03380045f, 0.01572022f, -0.09351186f, 0.02692820f, 0.09529217f, -0.08814868f, 
    0.04641274f, 0.07932116f, 0.01798238f, 0.18824831f, 0.32935327f, -0.18835430f, -0.05603895f, 0.09647091f, 
    0.01958246f, -0.05455105f, -0.01476625f, -0.00924170f, 0.08558105f, -0.01166594f, -0.06626575f, -0.00592266f, 
    0.11423843f, 0.12393791f, -0.00950906f, 0.11187072f, 0.05903083f, -0.06279813f, 0.03161507f, -0.02245192f, 
    0.09224460f, 0.08443225f, 0.08261731f, 0.08913033f, -0.28379476f, -0.11950597f, -0.07198965f, -0.22468844f, 
    -0.01940813f, -0.14242370f, 0.08597241f, 0.04038777f, -0.10425904f, -0.00546569f, -0.03058381f, 0.06182467f, 
    0.26469836f, 0.04317393f, 0.06850781f, 0.06313952f, 0.07835897f, 0.01122715f, 0.10749719f, -0.00625209f, 
    -0.02968924f, -0.03034583f, -0.03569699f, 0.02461629f, 0.01596807f, 0.11914990f, -0.10413046f, 0.09281729f, 
    0.12589966f, 0.05711336f, 0.10920015f, 0.03514726f, 0.05020013f, 0.08787099f, 0.00882425f, -0.03356997f, 
    0.23781680f, -0.00932047f, -0.02595232f, 0.05718371f, -0.15460974f, -0.00775653f, -0.11035205f, 0.11816244f, 
    -0.00625494f, 0.07694490f, -0.03469093f, -0.00887212f, 0.10260773f, -0.02177314f, 0.08025092f, 0.23334596f, 
    -0.00525338f, -0.02470262f, 0.05626142f, 0.06935690f, -0.04269614f, 0.06057640f, -0.00194787f, 0.04184878f, 
    0.04798200f, -0.02006058f, 0.15117580f, -0.01373737f, 0.07000564f, 0.03751921f, -0.02430729f, 0.02276267f, 
    0.05215057f, -0.00358357f, 0.09073980f, -0.04031299f, -0.11143794f, -0.01688963f, 0.00669919f, -0.11467802f, 
    -0.09926401f, 0.05819726f, 0.06727807f, 0.04913843f, -0.02064489f, -0.05627674f, -0.01772474f, -0.00992402f, 
    -0.04954720f, 0.21486677f, 0.14210701f, -0.11760025f, -0.05621741f, 0.15273461f, -0.03440748f, -0.00427756f, 
    -0.07902355f, 0.11732501f, -0.05077421f, 0.08931395f, 0.02489076f, -0.08543000f, 0.00290090f, -0.09281057f, 
    0.01235290f, -0.06184823f, 0.02485409f, -0.02190856f, 0.06026483f, 0.10301431f, -0.07435727f, 0.08820619f, 
    0.07519758f, -0.04244937f, -0.23547633f, -0.07070085f, -0.03154273f, -0.14711083f, -0.07000925f, 0.00933029f, 
    0.03352793f, -0.04069020f, -0.00636119f, 0.19072258f, -0.05607833f, -0.11279451f, 0.04037142f, -0.01951889f, 
    -0.02163034f, 0.00778653f, -0.00806453f, -0.07819337f, 0.03243296f, -0.10251901f, 0.10754350f, 0.02290654f, 
    -0.15875329f, 0.04621897f, -0.01466771f, -0.15014683f, -0.05060233f, -0.00839920f, 0.02626943f, 0.04150524f, 
    -0.00670985f, -0.04074401f, -0.06102563f, 0.00722626f, 0.39260557f, 0.11151309f, -0.08521434f, 0.03115564f, 
    -0.07835522f, 0.15225960f, -0.07000947f, 0.06150059f, -0.07325297f, -0.02290545f, -0.01224221f, 0.03880037f, 
    0.41408718f, -0.05452405f, -0.12284248f, 0.06012020f, -0.02590737f, -0.04066476f, -0.01108923f, 0.13752258f, 
    0.05467787f, 0.07689172f, -0.04401445f, 0.00571412f, 0.09564050f, -0.07562853f, 0.15327069f, 0.12590022f, 
    0.02667023f, 0.07237159f, 0.01273724f, 0.06354482f, 0.02791835f, -0.02043107f, -0.06869406f, 0.15221991f, 
    -0.04292414f, 0.11035296f, -0.04164514f, -0.14949073f, -0.05412855f, -0.15200333f, 0.03233073f, 0.21754996f, 
    -0.00521525f, -0.07239088f, 0.02095420f, -0.04098923f, 0.27265814f, -0.05040855f, 0.15329269f, 0.08397964f, 
    -0.08515313f, -0.01696648f, 0.00115403f, -0.07058332f, 0.03375370f, 0.04892454f, -0.01197858f, 0.09431282f, 
    0.19567579f, 0.08928937f, 0.04860327f, -0.16855477f, 0.06795669f, 0.07497536f, 0.06158697f, 0.00302105f, 
    0.18359114f, -0.02492748f, 0.08816037f, -0.01119076f, -0.00216114f, -0.13034846f, -0.05457538f, 0.07971115f, 
    0.02574888f, -0.16191635f, -0.03441331f, 0.03871894f, -0.09505058f, 0.03083923f, 0.00582003f, -0.09959622f, 
    -0.11711518f, -0.11597141f, -0.00444679f, 0.07799821f, -0.03222148f, -0.08772481f, 0.00555356f, 0.12849449f, 
    0.04270659f, 0.01157487f, -0.01694449f, 0.12086740f, -0.19560413f, -0.14315511f, 0.17883652f, -0.12319594f, 
    -0.11464275f, -0.09951580f, 0.06276447f, 0.05961695f, 0.09577627f, -0.05707023f, -0.00251581f, -0.02280917f, 
    0.22149046f, -0.14407207f, 0.02824048f, 0.52802944f, -0.04142825f, 0.07059916f, 0.01555318f, -0.06013967f, 
    -0.00304445f, 0.13128853f, -0.00099904f, -0.14025493f, -0.04424856f, -0.06757016f, -0.04064468f, 0.34170020f, 
    0.07082766f, -0.06204566f, 0.04804705f, -0.06060656f, -0.02456817f, -0.05952149f, 0.14297959f, 0.08001589f, 
    -0.07067427f, -0.10603268f, 0.00790858f, -0.05066193f, 0.05232798f, 0.07838678f, -0.05855425f, 0.02688183f, 
    0.02535595f, 0.02470735f, -0.03275584f, -0.15111092f, -0.01889095f, 0.05190127f, 0.11710875f, -0.14370750f, 
    0.00620510f, 0.09272758f, 0.02283637f, -0.02111110f, -0.00937862f, 0.04251476f, 0.00028123f, -0.04460649f, 
    -0.14806934f, 0.09679710f, 0.17552294f, -0.37799051f, -0.11773694f, 0.04745783f, 0.05453761f, 0.04872482f, 
    -0.06747728f, 0.00761631f, 0.07321467f, -0.01609028f, 0.13902649f, -0.02724326f, -0.06471993f, 0.26534623f, 
    -0.11563122f, 0.13445574f, -0.00840297f, 0.15110186f, -0.05113182f, 0.03305365f, -0.03844649f, -0.08984388f, 
    0.25537229f, 0.17340980f, 0.06648029f, -0.01587236f, 0.09658790f, 0.04947912f, -0.06400221f, 0.04562881f, 
    -0.09478553f, 0.06249115f, -0.02835095f, -0.03702781f, -0.03147081f, -0.03710126f, -0.24624874f, -0.15458007f, 
    -0.06136302f, -0.01829379f, 0.00243136f, 0.02769140f, -0.00583376f, 0.05300722f, 0.02275969f, -0.06161212f, 
    -0.47281277f, -0.22256549f, 0.13889661f, -0.28663194f, -0.09509988f, 0.00914291f, 0.04531092f, 0.03947425f, 
    0.11046265f, 0.12376410f, -0.02181538f, 0.02341986f, 0.23126239f, 0.05234451f, 0.06549060f, 0.06776997f, 
    -0.01557573f, -0.11023180f, -0.07023169f, -0.09192435f, 0.05565434f, 0.04837073f, -0.07122715f, 0.00909994f, 
    -0.16435236f, -0.00629436f, -0.07769988f, -0.12672989f, -0.02110370f, -0.04655969f, -0.05455053f, -0.11224639f, 
    -0.02956299f, 0.04903236f, -0.17961307f, 0.03789766f, 0.28266144f, 0.16559699f, 0.10324434f, -0.11673144f, 
    0.05678733f, -0.17460798f, 0.05953362f, 0.08441975f, 0.05090782f, -0.02396317f, 0.00773225f, 0.09195921f, 
    0.06156062f, 0.28109983f, -0.04385342f, 0.03709421f, -0.01406131f, -0.07122646f, -0.04854161f, -0.10558766f, 
    0.01297191f, 0.09261698f, 0.10754921f, -0.06708924f, -0.03232014f, 0.04803159f, -0.15406202f, -0.11131617f, 
    0.19827396f, 0.01889972f, -0.18906291f, 0.06054001f, 0.03201518f, 0.00319590f, -0.04621047f, -0.21442184f, 
    0.22162299f, 0.05714910f, 0.03494078f, 0.27067330f, 0.10551674f, 0.00318575f, -0.03983296f, -0.00334993f, 
    -0.02004782f, 0.00270339f, 0.05382906f, -0.05475010f, -0.07447264f, -0.25497666f, -0.01305545f, 0.21946834f, 
    -0.06770351f, -0.04405901f, 0.01739331f, -0.00235637f, -0.03024997f, 0.00590981f, -0.05155464f, -0.02330655f, 
    -0.18347129f, -0.00706448f, 0.05743313f, 0.25030380f, 0.02239636f, -0.01914709f, -0.05136725f, -0.06019344f, 
    -0.05145148f, -0.01435533f, 0.00326713f, -0.01189091f, 0.16977438f, 0.18569860f, 0.09842210f, -0.13742220f, 
    -0.03391866f, 0.00193149f, 0.02948190f, -0.02375656f, -0.06944464f, 0.02084061f, 0.04623330f, 0.16777311f, 
    -0.00298355f, -0.24919532f, -0.00508211f, 0.26224199f, -0.06431868f, -0.02961981f, -0.04044230f, 0.04687323f, 
    0.01522257f, -0.01314329f, 0.07004406f, -0.00357531f, 0.11333980f, 0.06484094f, 0.13620664f, 0.16050330f, 
    -0.11238775f, -0.00220453f, -0.01252247f, 0.12528516f, 0.01909080f, -0.01367630f, 0.08428406f, -0.10203672f, 
    -0.07781072f, 0.09318523f, 0.09399169f, -0.12863089f, -0.03455479f, -0.00473395f, 0.02301218f, -0.07743181f, 
    -0.07587296f, -0.06068276f, 0.01035040f, 0.15204448f, 0.29976797f, -0.11878575f, 0.06891021f, 0.42993227f, 
    -0.09334545f, -0.00627633f, -0.01292314f, 0.02017395f, -0.05193927f, -0.01119520f, 0.03942395f, -0.03431651f, 
    -0.06120562f, -0.09096161f, 0.07963225f, -0.11936739f, -0.05673730f, 0.09573518f, 0.01395306f, 0.08734266f, 
    -0.02609956f, -0.00054985f, 0.01925647f, -0.00933030f, 0.28877789f, 0.01501023f, 0.11410696f, -0.01618211f, 
    -0.03033882f, 0.02176128f, -0.10980790f, -0.01318491f, 0.04434821f, 0.05194113f, 0.02074459f, -0.08719099f, 
    0.26311216f, 0.09737667f, -0.04239461f, -0.21308018f, -0.01506137f, 0.00410848f, -0.03965710f, 0.00422750f, 
    -0.00660453f, 0.02492981f, 0.03017258f, -0.04305866f, 0.23026446f, 0.01400736f, 0.03097673f, -0.11989062f, 
    0.05325472f, -0.14111967f, -0.03938740f, 0.11456306f, 0.02545653f, 0.08424624f, -0.01268129f, -0.01967044f, 
    0.15972826f, 0.02500474f, -0.07179815f, -0.14474197f, 0.00238005f, 0.16275059f, 0.10957705f, -0.04620031f, 
    0.02316741f, 0.01048512f, -0.10568487f, 0.09380401f, -0.41790986f, 0.10931484f, -0.06480857f, -0.05833974f, 
    0.16139176f, -0.01132545f, -0.01954019f, 0.04287827f, 0.03233246f, 0.03475871f, -0.01519949f, 0.03728311f, 
    -0.17349200f, -0.02924313f, 0.16017902f, 0.12349094f, -0.05586467f, 0.00314360f, -0.07350047f, -0.03453555f, 
    -0.09732503f, 0.17618264f, 0.02568131f, 0.05302202f, 0.01540001f, 0.10507433f, 0.00564297f, -0.04358673f, 
    -0.03276611f, 0.09874883f, 0.00795529f, -0.07834517f, 0.03167053f, 0.00465298f, 0.04022638f, 0.03920468f, 
    0.15897225f, 0.13399623f, -0.15389504f, 0.18478087f, 0.13479199f, 0.15030365f, 0.08677743f, -0.03791845f, 
    -0.00675450f, 0.04456723f, -0.03350918f, -0.01513913f, 0.15871087f, -0.17115271f, -0.16369824f, -0.01189027f, 
    0.08151752f, 0.10105620f, 0.08832453f, 0.09785642f, -0.03409123f, 0.00712122f, 0.05868215f, 0.07531931f, 
    0.10482640f, 0.15432510f, 0.02706003f, -0.09858430f, -0.22147396f, -0.01076575f, 0.05830737f, 0.05802782f, 
    -0.06379738f, -0.01825556f, 0.00089330f, 0.10693074f, 0.11879110f, 0.17743786f, 0.10268946f, -0.05564138f, 
    0.00200047f, 0.03319632f, 0.04081919f, 0.05074241f, 0.09470141f, 0.08810582f, 0.01685616f, 0.03523550f, 
    0.04765547f, 0.19709967f, 0.17710526f, 0.15121093f, -0.12083188f, -0.07493833f, -0.06643123f, 0.06548622f, 
    -0.13570417f, -0.04706085f, 0.08926530f, 0.03228454f, -0.10379846f, -0.04413623f, 0.06537301f, 0.19805671f, 
    0.04923365f, 0.02361722f, 0.03320624f, 0.06599422f, -0.03252473f, -0.04539034f, 0.06865957f, -0.02903104f, 
    -0.05756834f, -0.23535711f, -0.05560658f, 0.20082684f, 0.05687734f, -0.07348636f, 0.14056124f, 0.01665153f, 
    0.03304337f, -0.05009511f, -0.07417792f, 0.01655113f, 0.00394695f, 0.30588642f, -0.06967110f, 0.02122004f, 
    0.05223708f, -0.03055580f, -0.09261101f, -0.05754200f, 0.02184071f, -0.00144961f, -0.00000639f, 0.07011768f, 
    -0.02784280f, -0.00634710f, 0.07149421f, -0.03833028f, 0.02465387f, 0.05722525f, 0.02911746f, 0.00096978f, 
    0.11440913f, -0.00442345f, -0.01850923f, -0.01333617f, -0.16853096f, 0.01644621f, 0.17038317f, 0.18930000f, 
    -0.06285776f, -0.05386117f, -0.01345473f, 0.03391458f, -0.00058217f, 0.04025838f, 0.06280563f, -0.03680228f, 
    0.23592874f, -0.09517301f, 0.18258323f, 0.27934361f, 0.17430036f, -0.03855662f, 0.08853074f, 0.04960205f, 
    0.00900729f, -0.08140640f, 0.07965937f, 0.07343243f, -0.23446177f, 0.07382192f, -0.12325461f, -0.20318766f, 
    0.15026966f, 0.08933302f, 0.11716071f, 0.02321693f, 0.01783429f, -0.02315623f, 0.00086419f, 0.05825856f, 
    -0.07618125f, 0.00906143f, 0.15231279f, 0.24485643f, 0.00025812f, -0.00722691f, -0.06383852f, 0.12216102f, 
    -0.04221578f, 0.02648454f, -0.00228000f, -0.02199348f, 0.01031508f, -0.12121451f, -0.23979272f, -0.18884757f, 
    -0.05254107f, 0.12592922f, 0.00986069f, -0.10290419f, 0.09479106f, -0.00979697f, 0.00956755f, 0.07407101f, 
    -0.22218338f, -0.17232923f, -0.01414535f, 0.10954298f, 0.01942046f, 0.07393029f, 0.08865846f, -0.05370424f, 
    0.00965369f, 0.01908262f, 0.04092462f, 0.02959083f, 0.20861696f, -0.00397078f, 0.17294207f, 0.23409751f, 
    -0.24413024f, -0.02436240f, 0.06653535f, 0.01024634f, -0.01025175f, -0.06952542f, 0.01000991f, 0.10693215f, 
    -0.17766404f, 0.09569921f, -0.06418103f, -0.08265427f, 0.06349819f, -0.05170023f, -0.02886957f, -0.03134073f, 
    0.01648859f, -0.03722897f, 0.13165787f, 0.08370729f, 0.02935664f, 0.33406389f, 0.01550260f, 0.00151064f, 
    0.14457664f, -0.03142170f, 0.06107372f, 0.18304226f, 0.04929347f, -0.03735903f, 0.06948934f, -0.03448540f, 
    -0.00003711f, 0.15658210f, -0.02534750f, 0.02234421f, 0.05175899f, 0.08061038f, 0.12685610f, -0.02515164f, 
    0.06386009f, -0.01123119f, -0.00401526f, 0.03444925f, 0.10286324f, -0.21993989f, -0.16776714f, -0.11933883f, 
    0.15476397f, 0.01065473f, 0.02700707f, -0.03842651f, 0.11790410f, 0.08216492f, 0.06223052f, 0.09537714f, 
    0.21039748f, -0.01801419f, 0.23697715f, 0.04791908f, -0.02329193f, 0.00030153f, -0.00829973f, -0.03050473f, 
    0.00610485f, -0.07223019f, -0.05947782f, 0.00915815f, 0.06082789f, -0.00168159f, -0.09507055f, -0.13028684f, 
    -0.04816448f, 0.01923574f, 0.03407071f, -0.19069216f, 0.00037557f, -0.02547439f, -0.10936037f, 0.00722022f, 
    -0.24208400f, -0.02403361f, 0.04995125f, 0.09032786f, 0.03709960f, 0.03895046f, 0.07597709f, 0.15200886f, 
    0.14648111f, 0.05991593f, 0.05531691f, -0.03385482f, -0.12694494f, 0.17024557f, 0.00309853f, -0.04751541f, 
    -0.08118056f, -0.01204898f, 0.09843351f, 0.13248631f, 0.01454234f, 0.09058698f, -0.04779617f, 0.01354411f, 
    -0.02650174f, -0.23998870f, -0.19171111f, 0.00865318f, 0.07026972f, 0.05771261f, 0.00513310f, -0.04300547f, 
    0.02252194f, 0.02503369f, 0.11700800f, 0.07093423f, -0.35491922f, -0.04330041f, -0.06104060f, -0.05892424f, 
    0.03587709f, -0.03042186f, -0.03433764f, -0.02894766f, 0.06415544f, 0.02068235f, 0.16681920f, 0.14132161f, 
    -0.42024168f, -0.03697117f, 0.24293278f, 0.08742022f, 0.06962546f, 0.06253522f, 0.04843996f, -0.08896037f, 
    0.04842950f, -0.11247889f, 0.04195659f, 0.04073713f, -0.01307360f, -0.15811439f, 0.10404560f, -0.04516323f, 
    -0.02482285f, 0.00029055f, -0.00445370f, -0.02745315f, -0.05952917f, -0.03727949f, 0.09344070f, 0.05736771f, 
    -0.11312877f, -0.20012027f, -0.04287288f, -0.08752207f, -0.01269247f, -0.00124463f, -0.15248129f, -0.14075221f, 
    0.00166244f, -0.08656706f, 0.04559177f, 0.17227665f, -0.28088573f, 0.10255890f, -0.06799032f, 0.05615845f, 
    0.02902145f, 0.01894167f, 0.08078083f, 0.09635685f, 0.01180719f, -0.02006745f, 0.06048690f, -0.04334237f, 
    -0.14632824f, -0.08657901f, -0.17280236f, 0.15074371f, -0.03863141f, 0.01786313f, 0.07575502f, 0.02255756f, 
    -0.06452705f, 0.03653152f, 0.00072363f, 0.05248858f, 0.03012407f, -0.09295195f, -0.05354711f, -0.02198099f, 
    0.03822454f, -0.02570354f, -0.04784575f, 0.09314817f, 0.09870046f, 0.08128699f, -0.00976328f, 0.04104086f, 
    -0.07291310f, -0.11126924f, 0.09872511f, -0.22120482f, -0.00710523f, -0.01866113f, 0.07454801f, -0.01227370f, 
    -0.00552644f, -0.14764413f, 0.08524095f, -0.17698243f, 0.03320711f, 0.12962981f, -0.02312469f, -0.11877798f, 
    0.02899305f, -0.02389426f, -0.03700304f, 0.09692632f, 0.01227204f, 0.06489465f, 0.03029406f, -0.00651839f, 
    0.12308588f, 0.11948208f, 0.18284324f, -0.05436521f, 0.03401121f, -0.12263447f, 0.04411220f, -0.00592782f, 
    0.10602977f, 0.06243885f, 0.05943389f, 0.06656767f, 0.14154671f, -0.00307143f, -0.03815883f, -0.16838259f, 
    -0.01875936f, -0.03813382f, -0.04267530f, 0.00236296f, -0.05913164f, 0.10824230f, -0.04363040f, -0.06088760f, 
    0.25089619f, 0.05872725f, -0.04224794f, -0.05905796f, 0.04203463f, 0.00315941f, 0.08291038f, 0.03521583f, 
    0.13344383f, -0.02494028f, -0.01915963f, 0.07829494f, 0.26306626f, 0.08107203f, 0.03456060f, -0.00740982f, 
    0.00386448f, 0.01791796f, 0.03582337f, 0.01405228f, 0.15876022f, 0.05010887f, -0.01135266f, 0.15717515f, 
    0.33806700f, -0.02991797f, -0.20274670f, 0.08720344f, 0.11728778f, 0.07393553f, -0.07077254f, 0.08490539f, 
    0.03786061f, 0.03879857f, -0.01701483f, 0.04694182f, 0.01450868f, -0.24697788f, 0.20936503f, -0.16057223f, 
    0.11285085f, -0.07888580f, 0.04902124f, -0.13090244f, 0.11196510f, 0.03729098f, 0.01774574f, 0.03395299f, 
    -0.12370054f, -0.14288965f, 0.02319172f, 0.01111773f, -0.00804560f, -0.10974604f, 0.05965815f, 0.02651831f, 
    0.03597948f, 0.04880300f, 0.10196061f, 0.03939615f, 0.43274578f, 0.19960870f, -0.01765623f, -0.03955349f, 
    0.16761646f, -0.00822981f, -0.08042367f, -0.00149790f, 0.02280571f, 0.04759382f, 0.04237121f, 0.09805164f, 
    -0.00309614f, 0.01064305f, -0.04810067f, -0.06164073f, 0.03361702f, 0.02880256f, 0.02607225f, 0.12118087f, 
    -0.03094720f, 0.03422593f, 0.02305899f, 0.03463336f, -0.21808818f, 0.01059895f, -0.00665130f, -0.06698291f, 
    -0.00874950f, 0.11202450f, 0.01554330f, 0.04550184f, -0.00946072f, -0.04208175f, 0.14247246f, -0.02369869f, 
    -0.09755848f, 0.03420757f, -0.08305959f, -0.02453142f, 0.07085362f, 0.01159299f, 0.22419013f, -0.01784155f, 
    0.05681102f, 0.07442693f, 0.23400679f, 0.15547639f, -0.10306080f, -0.31417039f, -0.06587758f, 0.04232961f, 
    -0.13626309f, 0.06809869f, -0.00256243f, -0.06205291f, -0.03711408f, 0.12282988f, -0.02795896f, -0.06725056f, 
    0.04293976f, -0.23984037f, 0.01186224f, 0.00064810f, -0.02823493f, -0.10493487f, 0.04083529f, 0.01548683f, 
    0.02156490f, -0.02615329f, 0.00879798f, 0.01223834f, -0.00948593f, -0.19200327f, 0.08928815f, 0.00759601f, 
    0.01826334f, 0.07869152f, 0.05481005f, 0.01104630f, 0.09193863f, 0.03258184f, -0.03541574f, -0.03529038f, 
    0.09546822f, -0.14658898f, 0.03301811f, 0.10252515f, -0.02339197f, -0.01681828f, -0.07369642f, 0.19255072f, 
    0.10701171f, 0.02398825f, -0.10610596f, 0.08558446f, -0.08300576f, 0.01066504f, -0.02096015f, -0.10451120f, 
    0.10604174f, -0.05273674f, -0.07125896f, 0.01583169f, 0.10721698f, -0.03266501f, 0.00517114f, -0.06031893f, 
    0.16958839f, -0.05277367f, 0.13717878f, -0.15403515f, 0.14306428f, -0.00899110f, -0.04935833f, 0.13242811f, 
    0.04457437f, 0.01826891f, -0.03848607f, 0.10491189f, -0.06857398f, -0.03589372f, -0.14497556f, -0.01901081f, 
    -0.10595353f, 0.02948779f, 0.02774432f, 0.04769423f, 0.05153012f, -0.07440017f, 0.01754656f, -0.18558033f, 
    -0.35492206f, 0.16553043f, -0.17138730f, -0.15839776f, 0.06225474f, -0.08332966f, 0.02576095f, 0.06408662f, 
    0.05161193f, 0.12972285f, -0.07916028f, 0.10492080f, -0.28096157f, -0.04570052f, 0.04044715f, -0.12421817f, 
    0.12186199f, -0.09682409f, -0.08514768f, 0.11631842f, -0.01051820f, 0.08186118f, 0.01238438f, 0.06874005f, 
    -0.23520218f, 0.01813766f, -0.28490812f, -0.04350204f, 0.02606781f, 0.04221404f, 0.09641089f, 0.01976882f, 
    -0.06724490f, -0.01439930f, -0.01913498f, 0.02403578f, 0.11669047f, 0.10826447f, 0.08060057f, 0.00135582f, 
    0.02840040f, 0.07265738f, -0.00054896f, 0.03112525f, 0.07178824f, 0.02961372f, 0.14333130f, 0.05686751f, 
    -0.19996899f, 0.06098784f, -0.00980065f, -0.10371834f, -0.01272879f, -0.03786533f, 0.05017628f, 0.02393648f, 
    0.07208350f, 0.09305625f, -0.00905948f, -0.03437895f, -0.17500822f, -0.08125138f, 0.03837558f, 0.01855429f, 
    0.03792070f, 0.07081483f, 0.12844515f, 0.01039936f, -0.02712950f, 0.00548194f, 0.01954565f, 0.09484759f, 
    -0.00989941f, 0.10558987f, -0.05279185f, 0.20072386f, -0.02665454f, -0.03256511f, 0.03036426f, 0.12603256f, 
    0.03890831f, 0.10215203f, 0.12405770f, 0.06302863f, -0.03617955f, 0.12979500f, -0.11693183f, 0.14679720f, 
    0.12560947f, 0.04587422f, -0.07992677f, -0.08880743f, 0.11102713f, 0.04383453f, -0.00227469f, 0.04907113f, 
    -0.00546286f, -0.03862005f, 0.04975379f, -0.04396337f, 0.00907699f, 0.02052336f, -0.04860768f, -0.01554122f, 
    0.00109870f, -0.04538563f, -0.02747234f, 0.01103523f, -0.01301948f, -0.03957513f, 0.00109071f, -0.02337795f, 
    0.02991571f, -0.00391350f, 0.01322439f, -0.02409148f, -0.00656739f, -0.02572601f, 0.03781475f, 0.04723973f, 
    -0.04472204f, 0.00201114f, -0.01676194f, 0.04277515f, -0.03739240f, -0.04529158f, -0.01458912f, -0.04070465f, 
    0.00594544f, 0.02895803f, -0.03267147f, 0.04227126f, 0.03643266f, 0.01873324f, -0.04349727f, -0.02590238f, 
    0.03781156f, 0.00132788f, -0.01027407f, -0.03136210f, 0.00866515f, 0.04254990f, 0.04808383f, -0.01765895f, 
    -0.01047274f, 0.03985615f, -0.03430722f, -0.02929157f, 0.03759132f, -0.02276466f, -0.03055207f, 0.01702514f, 
    0.01314132f, -0.00896035f, -0.03546923f, -0.01007138f, -0.03936298f, -0.04108575f, 0.03585033f, 0.02271955f, 
    -0.01347452f, -0.04166215f, -0.05226235f, 0.01311664f, -0.02867576f, -0.00196277f, -0.02991522f, 0.03492392f, 
    -0.02358677f, 0.02405114f, 0.01496512f, -0.04409129f, 0.05205969f, -0.04862265f, -0.05483132f, 0.03139356f, 
    -0.03287557f, -0.02067666f, -0.00388607f, 0.04862240f, -0.04720714f, -0.03884382f, -0.01562392f, -0.04215192f, 
    -0.00898632f, -0.01957235f, -0.04924268f, 0.00969307f, 0.02490937f, 0.00506320f, -0.01375216f, -0.04314264f, 
    0.04238686f, -0.03338120f, 0.00877520f, 0.02416681f, -0.00144993f, -0.04195238f, -0.03103758f, 0.01582016f, 
    0.00207887f, -0.04319656f, -0.00731729f, -0.04180298f, 0.04188983f, -0.03299216f, -0.03592264f, -0.00554465f, 
    -0.01898872f, 0.00450045f, 0.01759664f, 0.00457040f, -0.04762321f, 0.00501475f, -0.04121583f, 0.00954721f, 
    -0.04202195f, 0.01406106f, 0.02271157f, 0.04721708f, 0.04432859f, -0.04487569f, -0.00655892f, 0.04243591f, 
    -0.05339824f, -0.01743454f, 0.02379890f, -0.02483924f, -0.03484293f, -0.05081220f, 0.00363791f, 0.00946548f, 
    0.02277062f, -0.00671854f, 0.01274794f, -0.03088445f, -0.01440081f, 0.00563947f, -0.03090707f, 0.03471145f, 
    0.00630275f, -0.03555434f, 0.02531840f, -0.04719602f, 0.02641158f, 0.02593423f, 0.03241052f, 0.02461470f, 
    -0.04689778f, -0.05018178f, 0.01532535f, -0.02687576f, 0.03431742f, 0.02112120f, 0.00655328f, 0.00952544f, 
    -0.04581530f, -0.05487748f, -0.02380242f, 0.04006638f, -0.01978798f, -0.02553992f, -0.02756794f, -0.01898736f, 
    0.00267755f, 0.02177151f, 0.00167036f, 0.04067447f, -0.03282420f, -0.01502815f, 0.01236224f, 0.04515245f, 
    -0.01503609f, -0.04655784f, 0.03283052f, -0.05247027f, -0.02154541f, 0.01694041f, 0.00603171f, -0.02090138f, 
    -0.00968640f, 0.00428718f, 0.00892290f, -0.03302650f, 0.01515175f, 0.03386964f, 0.00492229f, 0.01538868f, 
    0.02058964f, 0.00955015f, 0.00662593f, -0.00099346f, -0.00517584f, 0.02795359f, 0.00916580f, 0.00340359f, 
    -0.03171066f, -0.00644634f, -0.03060075f, 0.04748899f, -0.02207067f, -0.02419174f, -0.04959029f, 0.04475328f, 
    -0.03602944f, -0.01983284f, -0.01300786f, -0.01452409f, -0.03986809f, -0.03008447f, -0.01446284f, 0.01999250f, 
    0.03327844f, -0.00326989f, -0.01066397f, 0.03415539f, -0.02403577f, 0.04003277f, 0.03268334f, -0.00448625f, 
    0.04377768f, -0.04941368f, -0.04187354f, -0.04349622f, -0.00233910f, 0.01249281f, 0.01296121f, 0.02452498f, 
    0.00991728f, -0.04288284f, -0.00048946f, -0.03009736f, -0.01373330f, -0.01126623f, -0.00160919f, -0.05102251f, 
    0.04223738f, 0.02616749f, -0.04968580f, 0.02507856f, -0.01685580f, 0.01692556f, -0.04813303f, -0.01990817f, 
    0.00589647f, -0.00220513f, 0.00703889f, -0.01065029f, 0.02640257f, 0.05000785f, 0.01318544f, -0.03893129f, 
    -0.03247998f, 0.00665614f, -0.04169100f, 0.00208459f, 0.03986046f, -0.04763252f, -0.04148832f, 0.04212565f, 
    -0.01272753f, -0.05156715f, -0.04075278f, 0.03086886f, 0.01109663f, -0.00410396f, -0.03006230f, 0.03130939f, 
    -0.02406340f, -0.00103012f, -0.02351288f, 0.02720958f, -0.01981060f, 0.04293598f, -0.01543875f, -0.04813883f, 
    0.00094623f, 0.03243750f, 0.00703736f, 0.00854765f, 0.02153310f, 0.03186172f, 0.00836035f, 0.03717291f, 
    0.03213899f, -0.04437895f, -0.00715907f, 0.04168591f, -0.03592505f, -0.04411775f, -0.04581341f, -0.05377736f, 
    0.01639008f, 0.04312582f, -0.00221525f, 0.00364402f, -0.02336524f, -0.03452674f, 0.01431433f, -0.00290982f, 
    0.00961470f, -0.03896589f, 0.03085329f, 0.01654947f, 0.04769707f, 0.01181522f, 0.04583839f, 0.01612087f, 
    -0.03104639f, -0.02009045f, -0.00622888f, -0.01772627f, 0.01575791f, -0.00730441f, -0.03221351f, -0.05210961f, 
    -0.02880816f, -0.03952123f, -0.02838777f, 0.02752369f, 0.04470070f, -0.02718899f, -0.03071495f, 0.00215187f, 
    -0.02533742f, -0.02473830f, 0.00231307f, -0.02465108f, -0.03218516f, -0.04637779f, -0.01631720f, 0.02016588f, 
    0.04378953f, -0.03819277f, 0.00245838f, 0.04908992f, -0.01933174f, -0.02290880f, 0.02594948f, 0.00943032f, 
    0.02074506f, -0.02955561f, -0.01604441f, -0.01371793f, 0.01512692f, -0.05553086f, -0.02080521f, -0.00883980f, 
    0.04307165f, -0.01662978f, -0.02361609f, 0.01181272f, 0.02158401f, 0.00752282f, -0.02639970f, -0.00144597f, 
    -0.04499454f, 0.02184415f, -0.02296674f, 0.04825657f, 0.01979196f, -0.05208303f, 0.00774157f, -0.04430177f, 
    -0.02100853f, -0.00770416f, -0.04328872f, 0.02528929f, 0.01603829f, -0.01940757f, -0.02631112f, 0.01865942f, 
    -0.02966428f, -0.03757193f, -0.02380442f, -0.00452901f, 0.01582390f, 0.02069733f, 0.01235189f, 0.03172787f, 
    -0.00649017f, -0.04799488f, -0.02354615f, -0.00507776f, 0.02938653f, -0.02912381f, -0.01255979f, -0.00915427f, 
    -0.02141304f, -0.04918219f, -0.05664789f, 0.00274979f, 0.03414775f, 0.03469364f, -0.03783086f, -0.02667505f, 
    0.03212637f, 0.01032417f, 0.00244889f, -0.03879098f, -0.05240841f, 0.02829343f, 0.02170821f, -0.03980479f, 
    -0.03843635f, -0.02331120f, -0.01248774f, -0.04124222f, 0.00195760f, 0.03373536f, 0.03839170f, 0.00884728f, 
    -0.01434371f, 0.03204535f, -0.00636366f, -0.03125594f, -0.02345613f, 0.02840763f, -0.02103411f, 0.01565349f, 
    0.01476557f, 0.00952576f, 0.02459702f, 0.03245426f, 0.02365309f, -0.02646415f, 0.02426910f, 0.00679601f, 
    -0.04881192f, 0.00349983f, 0.02101981f, -0.03800327f, 0.03727879f, 0.02079980f, 0.00242312f, -0.00102549f, 
    -0.02969623f, -0.02112904f, -0.02605777f, -0.02418974f, -0.01553428f, -0.02142710f, -0.00809554f, -0.05646776f, 
    -0.05403588f, 0.02536799f, 0.02846097f, -0.02271791f, -0.04240613f, 0.01303220f, -0.03288683f, 0.03515115f, 
    -0.00820887f, -0.01621903f, -0.04759561f, -0.04176215f, -0.02406287f, -0.02189372f, -0.03156392f, 0.00324655f, 
    0.01644305f, 0.02497477f, 0.04452200f, 0.01226733f, 0.02654990f, 0.02466019f, -0.04461482f, 0.00062435f, 
    -0.05684019f, -0.03762665f, -0.01867013f, 0.01028929f, -0.01694474f, 0.03059761f, -0.00385157f, -0.01508773f, 
    0.02891107f, 0.00022742f, 0.02120433f, 0.04540068f, -0.03650992f, 0.03698052f, -0.02993276f, -0.03101858f, 
    -0.02872418f, 0.00502321f, -0.00416298f, -0.02426549f, -0.04677444f, 0.00998092f, -0.04132726f, -0.00280730f, 
    0.00514206f, -0.01664579f, -0.03069105f, -0.04260206f, 0.02938820f, 0.01241290f, 0.01225211f, -0.02362577f, 
    0.02461745f, 0.01270299f, -0.03394281f, -0.00647243f, 0.04284740f, -0.00161442f, -0.03560831f, -0.02312433f, 
    -0.05184617f, -0.03057540f, 0.00660281f, 0.02372951f, 0.03410897f, 0.00947087f, 0.01492043f, 0.00569909f, 
    0.03924693f, 0.03837989f, 0.02102783f, -0.01709526f, -0.06011401f, 0.04373767f, 0.02640516f, 0.02240979f, 
    0.01342538f, -0.00279994f, -0.05226505f, -0.04392619f, -0.00713625f, -0.05495718f, -0.02877872f, 0.03538043f, 
    -0.01260153f, -0.00206697f, -0.00039889f, -0.06021956f, 0.03437480f, 0.00329168f, 0.00656677f, -0.04801089f, 
    -0.02286436f, 0.01030474f, -0.01906224f, -0.00486301f, -0.01814528f, -0.00166510f, -0.04557163f, -0.00821421f, 
    0.03324471f, -0.05123670f, -0.01723133f, 0.03129132f, -0.05069714f, 0.03717760f, 0.03694179f, 0.04315394f, 
    -0.06101746f, -0.04050816f, -0.03030914f, -0.04298595f, 0.03055621f, -0.03498869f, 0.01664187f, 0.00710240f, 
    -0.00803908f, -0.05586743f, -0.05409445f, -0.03323326f, -0.04822570f, 0.03229388f, -0.01185708f, -0.01195572f, 
    0.01699695f, 0.01386988f, -0.03075573f, -0.02040570f, -0.05021531f, 0.01256149f, -0.05306173f, 0.01809408f, 
    0.00864590f, -0.03617362f, -0.00736420f, -0.04880086f, -0.04590034f, 0.02423312f, -0.02090826f, -0.02924477f, 
    0.00725808f, 0.02286688f, -0.02940688f, -0.01901829f, -0.02402991f, -0.00051742f, -0.01000647f, -0.03447621f, 
    0.03770983f, -0.02909387f, -0.04806705f, 0.02266813f, 0.00506144f, -0.04360859f, 0.00260582f, 0.03986318f, 
    -0.00067420f, -0.05385944f, 0.02104577f, -0.02701562f, -0.06063305f, 0.00425664f, 0.00965720f, -0.01251938f, 
    0.03596845f, -0.04900002f, -0.02774317f, -0.00282551f, -0.03397936f, -0.00420352f, -0.05064901f, -0.01617389f, 
    0.04559473f, 0.02728554f, -0.00235900f, 0.02856798f, 0.00746086f, 0.00688520f, 0.03553142f, -0.04684724f, 
    0.03561452f, 0.01610470f, 0.04341016f, -0.00320139f, -0.05155399f, 0.00274289f, -0.03039431f, -0.01679640f, 
    0.03120656f, -0.00920570f, 0.00672108f, 0.01728836f, 0.00124338f, -0.02437343f, -0.01382768f, -0.05260935f, 
    -0.04831160f, 0.03334453f, -0.02257853f, -0.00696428f, -0.01935022f, -0.01098803f, -0.04681914f, -0.01555612f, 
    -0.01928856f, -0.05371783f, 0.03203379f, 0.03146562f, 0.00128649f, -0.03487894f, -0.02682227f, 0.00265031f, 
    -0.02040803f, -0.01634214f, -0.04039172f, -0.03641322f, 0.02454393f, -0.03333793f, 0.02803092f, -0.00382253f, 
    0.03218410f, 0.00091255f, 0.03792856f, -0.04089892f, -0.05282772f, 0.02554891f, 0.02926397f, -0.02293398f, 
    0.01809517f, 0.02418664f, -0.03289003f, -0.01715398f, -0.01357840f, -0.01233789f, -0.01903209f, 0.03692229f, 
    0.04233482f, -0.02839512f, -0.03169381f, -0.00407478f, 0.01515613f, -0.01230703f, -0.05082477f, 0.03443456f, 
    -0.02511766f, -0.04005881f, -0.05187531f, -0.00035817f, 0.00819002f, -0.03511009f, -0.03867927f, -0.02314004f, 
    -0.04928868f, 0.02958645f, -0.01093168f, 0.03922324f, 0.03258804f, -0.03146155f, -0.02064618f, 0.01760250f, 
    0.00091344f, -0.06118959f, 0.00752700f, 0.03755283f, -0.00439482f, -0.03284348f, -0.05638045f, -0.00961223f, 
    0.01514893f, 0.00261927f, -0.00134253f, 0.01272160f, -0.06078711f, 0.03154556f, -0.00102062f, -0.04787556f, 
    -0.03225011f, -0.01297951f, -0.04830295f, -0.05189688f, 0.02117569f, -0.02220389f, 0.01989426f, -0.05497194f, 
    0.02158163f, -0.04824330f, 0.02951995f, -0.01395181f, -0.02621005f, -0.03247115f, 0.03742629f, 0.03030456f, 
    0.03778032f, -0.04402810f, -0.02799535f, -0.00905305f, -0.02111919f, -0.01936150f, -0.04583084f, -0.01816388f, 
    0.00608744f, 0.01038679f, -0.05201466f, -0.04181271f, 0.00455624f, -0.04312184f, -0.04429640f, -0.00607355f, 
    -0.00747728f, 0.00707449f, -0.00529386f, 0.00366582f, -0.04560558f, -0.04093470f, 0.00864329f, -0.02534298f, 
    0.03042994f, 0.02796168f, -0.05869263f, 0.00988869f, -0.00792712f, -0.02258992f, -0.04091780f, 0.02365319f, 
    -0.03501873f, -0.01699450f, 0.04069075f, -0.01072867f, -0.05558261f, 0.00691030f, -0.04252318f, -0.06057377f, 
    -0.01581856f, -0.00051873f, -0.02516283f, 0.00375061f, 0.01719099f, 0.00827430f, 0.02314290f, 0.00991951f, 
    -0.03798708f, -0.05522949f, -0.02025603f, -0.00176511f, -0.02697246f, -0.01019272f, -0.00591421f, 0.02865011f, 
    -0.04206926f, 0.03462655f, -0.04481522f, -0.02446447f, 0.03960717f, 0.03125132f, 0.02753058f, -0.05498643f, 
    0.01319021f, 0.00454619f, -0.04592783f, 0.02396151f, -0.05936816f, 0.00028470f, -0.04058568f, -0.04107396f, 
    0.03650977f, 0.02039960f, -0.04910294f, 0.00929012f, -0.03310277f, 0.02948317f, -0.03403863f, -0.04036831f, 
    0.02758598f, 0.00916273f, 0.03219708f, -0.01576226f, 0.00337887f, -0.01431501f, -0.03993221f, -0.00099267f, 
    -0.00736483f, -0.01350462f, -0.01600529f, 0.02241790f, -0.00052547f, -0.02983398f, -0.01273033f, -0.04461007f, 
    -0.00435053f, -0.03012020f, 0.00872858f, -0.04530481f, -0.03038418f, -0.01482094f, -0.00262273f, -0.00267132f, 
    0.02221793f, -0.02506202f, -0.00826971f, -0.04686365f, -0.05591023f, 0.03327065f, -0.02185861f, -0.02347855f, 
    -0.00678331f, -0.01460485f, -0.05806377f, 0.01978027f, 0.00733336f, 0.02669588f, -0.02890439f, 0.03811788f, 
    -0.00046563f, -0.01625809f, 0.00965480f, -0.01835247f, 0.00254914f, 0.03890718f, 0.00952958f, 0.00178256f, 
    0.00243061f, 0.02244160f, -0.00617273f, -0.03188862f, 0.02065816f, -0.05193138f, 0.02294896f, -0.05454611f, 
    -0.01133287f, -0.03496237f, -0.02015842f, 0.01823774f, -0.01628863f, -0.01845662f, -0.02966592f, -0.04455230f, 
    -0.05061918f, -0.03549222f, -0.00901291f, 0.03915276f, 0.03140649f, 0.02436233f, -0.02317694f, 0.04385264f, 
    -0.00728491f, 0.02521558f, -0.05292419f, -0.04004198f, -0.04694547f, -0.02120690f, -0.00936128f, 0.01627767f, 
    -0.01225010f, -0.00501590f, 0.02705154f, 0.03176283f, 0.01881252f, -0.01412452f, 0.04066981f, -0.04973148f, 
    0.03734494f, -0.05349515f, 0.03330779f, 0.02944580f, 0.02920272f, -0.02412830f, 0.01496485f, -0.00482512f, 
    -0.01943396f, 0.02770570f, -0.04110942f, -0.03191132f, -0.01208208f, -0.04304629f, -0.02667286f, -0.02768987f, 
    0.01997384f, 0.03310695f, -0.02996619f, -0.02618686f, 0.00133485f, 0.00584886f, -0.05886335f, -0.01216004f, 
    -0.00357115f, 0.01180540f, 0.02447904f, -0.01389681f, 0.03375656f, 0.03844244f, -0.00428003f, 0.01612264f, 
    0.02105086f, 0.03002663f, -0.02069052f, -0.03155707f, -0.00525811f, -0.02139684f, -0.03210290f, -0.03915438f, 
    -0.00453082f, -0.02490698f, -0.02699942f, 0.00675722f, 0.01840601f, 0.00523783f, 0.03977766f, -0.02909699f, 
    0.02428302f, 0.01374574f, -0.03594366f, -0.02280570f, -0.00439269f, 0.02634474f, -0.03083133f, 0.02664144f, 
    0.01609292f, -0.00635666f, 0.02637157f, -0.02878999f, 0.01425832f, 0.03245329f, 0.00191582f, -0.03322544f, 
    -0.03409174f, -0.00751544f, -0.03346441f, -0.03059326f, 0.01104477f, 0.02745250f, 0.03106361f, -0.00561772f, 
    0.02009882f, -0.00374515f, -0.03561347f, 0.03098499f, 0.01052551f, -0.05093913f, -0.00087397f, 0.02210940f, 
    -0.02533733f, -0.02342594f, -0.05036978f, 0.02568999f, 0.00047018f, 0.00881832f, -0.02506847f, -0.05965580f, 
    -0.03303823f, -0.04321868f, 0.00153504f, -0.01956622f, -0.01168514f, 0.01787059f, -0.01066123f, -0.01837177f, 
    -0.00413601f, -0.03800007f, -0.01364921f, 0.00913497f, 0.01770709f, -0.01535743f, -0.05586891f, -0.02106825f, 
    -0.04439059f, 0.02328036f, -0.03057463f, 0.00590193f, 0.03427824f, 0.02254533f, -0.00405084f, -0.00807554f, 
    0.03354289f, -0.03627978f, -0.05102928f, -0.04796385f, -0.00965945f, 0.00888760f, -0.02098477f, -0.02620199f, 
    0.03975536f, -0.00255743f, 0.00937589f, -0.05284252f, 0.02053799f, 0.04031110f, 0.00955468f, 0.03579606f, 
    -0.05116040f, 0.04261554f, 0.00925913f, -0.04148974f, -0.05157115f, -0.02285402f, 0.01910010f, 0.02246204f, 
    0.01179904f, 0.00607921f, -0.04802925f, -0.01588294f, -0.02018764f, -0.02750502f, 0.03648306f, -0.04731791f, 
    -0.03262997f, 0.02987425f, 0.02558545f, -0.02985369f, 0.01524820f, 0.00424434f, -0.03012839f, -0.04140367f, 
    -0.04662401f, -0.03383886f, -0.00596914f, -0.03001540f, -0.03943072f, -0.03731044f, -0.05021765f, 0.03130934f, 
    -0.03653090f, 0.00455129f, -0.04402953f, -0.05686836f, -0.02798668f, 0.01490289f, -0.03753211f, 0.01445054f, 
    -0.01974819f, -0.05768127f, -0.00276634f, 0.03908036f, -0.01003601f, -0.02510326f, -0.03533148f, 0.00356552f, 
    -0.00581182f, -0.02737845f, -0.00368644f, -0.05204522f, -0.04959309f, -0.04842503f, 0.00462171f, -0.00186172f, 
    -0.05202816f, 0.00675317f, -0.02914704f, -0.05718697f, -0.01521369f, -0.00013788f, -0.01740632f, -0.05426314f, 
    -0.01059099f, -0.04361603f, 0.02464390f, -0.02351511f, 0.01874140f, -0.02421944f, -0.01898199f, 0.03700868f, 
    0.03512296f, -0.05057239f, -0.03593523f, -0.01573606f, 0.00429534f, -0.01202484f, -0.00139148f, -0.00176201f, 
    0.00184853f, 0.01243403f, 0.02571411f, -0.01501745f, -0.01501410f, 0.00372838f, 0.02781682f, -0.04165001f, 
    0.01709651f, 0.00897387f, 0.00150836f, -0.04937566f, -0.01769940f, 0.01008344f, 0.00318601f, 0.03162670f, 
    0.04428061f, 0.00740129f, -0.02395820f, -0.05675112f, 0.02925632f, -0.02167297f, 0.01733357f, 0.02998306f, 
    0.02949143f, 0.03762600f, 0.00383150f, -0.04753190f, -0.02791887f, -0.01392846f, -0.00366748f, -0.01127105f, 
    0.04740267f, -0.11700705f, -0.08148179f, -0.03270344f, 0.00819175f, -0.02498868f, -0.16359057f, -0.00189590f, 
    0.07246666f, -0.09557280f, -0.01034831f, 0.06087872f, -0.07192297f, 0.05196826f, -0.10823447f, 0.08610772f, 
    0.01151245f, 0.01120814f, 0.11608475f, 0.03254504f, 0.10497322f, -0.01604984f, 0.10850942f, 0.04128968f, 
    -0.14595266f, -0.12915611f, -0.15919505f, -0.03564202f, -0.11979715f, -0.01519519f, -0.04941773f, 0.00093206f, 
    -0.07179087f, 0.01778290f, -0.00038380f, 0.02683001f, 0.20679303f, -0.03862564f, -0.02774178f, -0.09801691f, 
    0.00361428f, 0.01599659f, -0.07631611f, -0.00347733f, 0.04497139f, -0.00769636f, 0.09781624f, 0.06729345f, 
    -0.33869180f, -0.03836103f, -0.02311760f, -0.02117705f, -0.03286431f, 0.06699781f, -0.00096739f, 0.11004350f, 
    0.08864401f, -0.01424648f, 0.08224744f, -0.01642825f, -0.05020462f, -0.04011427f, 0.05276118f, -0.15652259f, 
    0.09125824f, -0.06995621f, 0.07493740f, -0.04012253f, 0.04501546f, 0.06250726f, 0.01508648f, 0.01317591f, 
    0.19485691f, 0.03927710f, 0.11045723f, 0.16288039f, 0.07696018f, -0.06091656f, -0.01139697f, 0.07837743f, 
    -0.00020724f, 0.13392468f, 0.09570499f, 0.02153021f, -0.09048285f, -0.08362212f, -0.09297253f, -0.22803892f, 
    0.11880685f, 0.03297854f, -0.12691392f, 0.10161925f, -0.00911123f, -0.01999271f, -0.06679095f, -0.01093592f, 
    0.23893721f, 0.23364325f, 0.05739406f, -0.07499125f, 0.05501660f, 0.04368934f, 0.04051231f, 0.01608985f, 
    0.10344616f, -0.00035323f, 0.04727004f, 0.17269881f, -0.06646796f, 0.12582330f, 0.23405547f, 0.01190758f, 
    0.02061173f, 0.11775347f, 0.00756585f, 0.01175804f, 0.15817723f, -0.01602948f, 0.05211097f, 0.19375108f, 
    0.03326369f, -0.09164327f, -0.02224042f, -0.15784809f, 0.11067397f, 0.00392252f, 0.11404331f, -0.01453100f, 
    -0.03132489f, 0.07711649f, 0.15434024f, 0.04143644f, -0.18127142f, -0.24346170f, 0.04035636f, -0.01715851f, 
    -0.00367035f, -0.02664253f, 0.01802696f, -0.06764913f, 0.09803812f, 0.04622973f, 0.08114865f, 0.13429093f, 
    0.05850023f, -0.10933302f, 0.09950291f, 0.07551126f, 0.09448969f, -0.04103190f, 0.07502957f, 0.08586740f, 
    -0.03133235f, -0.13294600f, 0.05244128f, 0.10183578f, 0.07376339f, 0.15094081f, 0.11975262f, 0.07434218f, 
    0.05882586f, -0.08810464f, 0.08075830f, 0.04925288f, 0.04763412f, 0.08566643f, 0.04912447f, 0.13236105f, 
    -0.18734546f, -0.08095519f, -0.07985554f, -0.16838227f, 0.05658342f, 0.07629261f, -0.06939890f, 0.12583248f, 
    -0.01186696f, 0.05084779f, 0.04954377f, -0.01749251f, 0.13596721f, 0.03412139f, -0.02407378f, -0.10377381f, 
    0.00953289f, 0.07808252f, 0.01662986f, 0.07784535f, 0.03628857f, 0.03702342f, -0.01128737f, -0.00382564f, 
    -0.15523110f, 0.06709918f, -0.02076799f, -0.06320317f, -0.03643737f, 0.06879498f, -0.00907719f, 0.01594613f, 
    0.04240818f, 0.00060632f, 0.15990244f, 0.08054288f, 0.23414113f, -0.09864009f, 0.00786759f, 0.06421247f, 
    -0.14937051f, 0.00429390f, -0.05583560f, 0.01882599f, 0.01080932f, 0.21305004f, -0.04324898f, -0.07742152f, 
    0.00462662f, 0.01205443f, 0.08067238f, 0.06275471f, 0.01328182f, 0.00573135f, 0.05320332f, -0.02715992f, 
    -0.04919433f, 0.07564905f, 0.08898076f, 0.04871444f, 0.03215798f, -0.19225353f, 0.08496922f, 0.02781134f, 
    0.02272981f, 0.20281342f, -0.05740738f, 0.07232697f, 0.00280871f, 0.01438227f, -0.10887541f, -0.08993738f, 
    0.36620364f, -0.19418173f, 0.20155795f, 0.09359073f, 0.04622010f, -0.04118893f, -0.00996338f, 0.26864666f, 
    0.05984350f, 0.05050226f, -0.15993041f, 0.14014168f, 0.03586734f, 0.00130262f, -0.20582661f, -0.04186871f, 
    0.09574423f, 0.06213324f, -0.06825908f, -0.08257215f, -0.03853745f, -0.03038174f, -0.09511293f, -0.01366306f, 
    0.26555604f, 0.01439410f, 0.05264223f, 0.10932557f, -0.02457126f, 0.06666947f, 0.00287088f, 0.06661309f, 
    0.04397037f, -0.10183576f, 0.02652796f, 0.06720190f, -0.06406316f, -0.11452160f, 0.03916119f, 0.04325123f, 
    0.11704571f, 0.02813501f, 0.00691856f, 0.01224601f, 0.05750416f, -0.07634249f, 0.04246630f, -0.04706429f, 
    0.01075439f, -0.06941778f, -0.13293120f, -0.07681680f, 0.04991141f, -0.02833768f, -0.03832914f, 0.15778247f, 
    0.02642857f, 0.04654210f, -0.00769499f, 0.10085994f, -0.07330715f, 0.05251855f, 0.06700671f, 0.01419240f, 
    0.09036974f, -0.01315651f, -0.11730904f, 0.10254264f, 0.10667036f, 0.12427785f, -0.08603097f, 0.00678626f, 
    -0.10714743f, 0.07758573f, -0.23693652f, -0.12827970f, -0.02623923f, 0.01117241f, -0.01594104f, -0.06476045f, 
    0.05556166f, -0.01591529f, 0.06887090f, -0.01222617f, 0.34703702f, -0.13500841f, 0.03489239f, 0.12572166f, 
    0.13778946f, 0.10115755f, 0.06225745f, 0.09440082f, 0.07120491f, 0.04802658f, 0.09894690f, 0.05802769f, 
    -0.09363277f, 0.02154667f, -0.09828211f, -0.02101938f, -0.01531595f, -0.08631133f, 0.09832993f, 0.05036831f, 
    0.06176150f, 0.10212837f, -0.04003263f, 0.01272405f, -0.10219266f, 0.04049321f, 0.00138000f, 0.04839867f, 
    -0.01723849f, -0.02082868f, 0.03988887f, 0.10713640f, -0.00623777f, -0.04634240f, 0.00952065f, 0.02780319f, 
    -0.11885770f, 0.17644882f, -0.14750463f, 0.05157498f, -0.02576805f, 0.03577798f, 0.03833894f, -0.02961820f, 
    0.06967857f, 0.12076026f, -0.02209717f, 0.08694915f, -0.01089790f, -0.07399354f, -0.01019353f, 0.07913338f, 
    0.06058149f, -0.04254868f, 0.11279843f, -0.07633538f, -0.01949090f, -0.03349153f, 0.03806012f, -0.00443324f, 
    -0.11949083f, -0.01429331f, 0.04610283f, 0.04653029f, -0.10176965f, -0.00598703f, -0.03262306f, 0.04701657f, 
    -0.01946995f, 0.09136155f, 0.00879025f, 0.06188728f, 0.19183761f, -0.19518656f, 0.05318207f, 0.09038061f, 
    -0.00308010f, -0.00195621f, -0.04699622f, -0.05544975f, 0.02246406f, 0.01262813f, 0.07175291f, -0.06654444f, 
    0.14169788f, -0.07240962f, 0.09322198f, -0.06721900f, 0.03114462f, 0.12742424f, -0.07975136f, -0.01234723f, 
    -0.08859500f, 0.00397097f, 0.17468195f, -0.07962225f, 0.15154637f, 0.24390809f, -0.16841277f, 0.00072808f, 
    -0.04292085f, -0.02157939f, 0.08232425f, 0.07514018f, 0.10571002f, -0.15153666f, -0.14762512f, -0.22295548f, 
    -0.10060290f, 0.12454388f, 0.02263105f, -0.05599879f, -0.00189203f, -0.08443663f, 0.08091976f, -0.17154588f, 
    -0.10900340f, 0.10880374f, -0.07389677f, 0.15084191f, -0.13928922f, -0.17195983f, -0.05545152f, 0.01481057f, 
    -0.01306408f, 0.01970134f, -0.03734583f, 0.07555360f, -0.13820794f, -0.06246219f, -0.10854729f, 0.03694800f, 
    -0.18053547f, 0.10966765f, -0.05240100f, -0.05768853f, -0.09488029f, 0.09621086f, 0.00403717f, 0.15725932f, 
    -0.03591538f, -0.06681823f, -0.02123770f, 0.06463916f, 0.09947355f, 0.07970010f, -0.14655806f, -0.10017526f, 
    0.06625602f, 0.04549156f, 0.07599380f, 0.12412319f, 0.01536056f, 0.04396431f, -0.13031849f, 0.10790455f, 
    -0.06644806f, 0.27846950f, 0.02613967f, -0.41781023f, -0.03457061f, 0.04330141f, -0.03993851f, 0.06480789f, 
    -0.02879915f, -0.01201592f, -0.06028862f, -0.13072984f, 0.05028435f, -0.02038024f, -0.07848198f, -0.13264221f, 
    0.00561106f, 0.01718711f, 0.02723055f, 0.01505392f, -0.05620397f, -0.01124787f, 0.15233029f, -0.14804196f, 
    -0.25306681f, -0.19966500f, 0.05165020f, -0.03886808f, 0.07030495f, 0.13555793f, 0.09458957f, -0.07912156f, 
    -0.02084828f, -0.09412499f, 0.03379268f, -0.03090831f, 0.05940776f, 0.11753774f, 0.01526568f, 0.17943521f, 
    0.02966315f, 0.11378845f, -0.01434946f, 0.03392645f, -0.06636310f, -0.11507692f, 0.04184792f, 0.01459116f, 
    -0.18248825f, 0.15033515f, 0.09992806f, 0.15839785f, -0.00390343f, 0.16312550f, -0.02891577f, 0.07001135f, 
    -0.06891676f, 0.14758702f, 0.04912498f, 0.17272672f, -0.39592177f, -0.03098954f, 0.27724856f, 0.31101725f, 
    0.02289735f, 0.05337065f, 0.11572286f, -0.08828419f, 0.03723995f, 0.07893173f, -0.06103942f, -0.15480700f, 
    -0.18858093f, -0.07083680f, -0.06523231f, -0.17794316f, 0.02111659f, -0.02316946f, 0.08748721f, -0.08007431f, 
    0.06097997f, 0.01146783f, -0.02521632f, 0.05929634f, 0.07786962f, -0.20674960f, 0.01907847f, -0.06484079f, 
    -0.00450394f, -0.05066128f, -0.00348175f, 0.02431284f, 0.00130348f, -0.00700545f, 0.05064195f, 0.00748401f, 
    -0.06856836f, 0.10891215f, 0.01272119f, 0.03700118f, 0.01218037f, -0.05270411f, -0.02261716f, -0.05670087f, 
    -0.05346317f, 0.03600178f, 0.01192925f, -0.01001223f, 0.52125520f, -0.12857817f, -0.16360085f, -0.17425475f, 
    -0.08081426f, -0.05453630f, 0.03934737f, 0.02483363f, 0.05479199f, 0.06420562f, -0.11773990f, 0.16323133f, 
    0.17397740f, 0.10160317f, -0.06117171f, -0.06677178f, -0.00480621f, 0.05187012f, -0.00104696f, 0.11183906f, 
    0.08246427f, 0.00433218f, 0.01584449f, 0.06603471f, 0.20162037f, 0.08585983f, 0.09260969f, 0.05831992f, 
    -0.00210893f, -0.04813684f, -0.10637037f, 0.00454718f, 0.02180990f, 0.07133841f, 0.09225082f, 0.06923620f, 
    0.04992186f, -0.03354064f, 0.02919221f, 0.09182130f, 0.06173939f, 0.06352606f, 0.06784698f, 0.01229429f, 
    0.04064945f, 0.01905506f, 0.13570936f, 0.04196549f, 0.23861009f, -0.00300359f, -0.04751549f, 0.29108095f, 
    0.05034069f, 0.09316076f, 0.11446111f, 0.10999672f, 0.03988317f, -0.00370559f, -0.05402611f, 0.06765253f, 
    0.13357495f, -0.07735243f, -0.02319381f, 0.05649796f, -0.09032265f, -0.00365476f, 0.06076806f, 0.00143471f, 
    0.02533597f, 0.01258727f, 0.08440812f, 0.06562997f, -0.09341333f, 0.08074041f, -0.02163123f, 0.10238501f, 
    -0.00749700f, 0.00566804f, 0.12087448f, 0.03165905f, 0.02532914f, 0.02273736f, 0.04470286f, -0.01683094f, 
    0.33294389f, 0.11742583f, 0.25012264f, 0.00412073f, -0.04070183f, 0.10019974f, 0.02518214f, -0.05268410f, 
    0.06203325f, 0.00443886f, 0.05321790f, -0.08158255f, 0.03225414f, -0.00027366f, -0.03659395f, 0.00211999f, 
    -0.02189813f, -0.07308370f, 0.07552088f, -0.02370248f, 0.04010577f, -0.12174084f, 0.15723726f, 0.11549724f, 
    -0.10912845f, 0.03936707f, -0.00937825f, -0.05105903f, 0.05495390f, -0.04718786f, 0.00345149f, 0.00950649f, 
    0.01308277f, -0.02664794f, 0.09984440f, 0.00349376f, -0.18511648f, 0.16604932f, -0.02181165f, -0.16490732f, 
    0.04203712f, -0.02915933f, 0.02931231f, 0.09798043f, -0.03743460f, 0.05593206f, 0.04171356f, -0.04826243f, 
    -0.00176429f, -0.13674007f, -0.12891920f, -0.13389008f, -0.00396522f, 0.10043278f, 0.06649130f, 0.03098333f, 
    0.03607845f, -0.17741384f, 0.25069225f, 0.05078338f, 0.05966826f, 0.01497594f, 0.02672391f, -0.13568218f, 
    0.00598237f, 0.00225707f, -0.10151501f, 0.04835849f, 0.03200689f, 0.10600811f, 0.01736385f, 0.18272671f, 
    -0.14548302f, -0.09243660f, -0.10442486f, -0.08108793f, 0.02068977f, -0.00284632f, 0.02567915f, 0.02603997f, 
    0.11003253f, -0.12417822f, 0.06611685f, 0.18650775f, -0.31944299f, -0.04188395f, 0.21203236f, -0.00095051f, 
    -0.04767590f, 0.04917964f, 0.16788262f, 0.15638755f, 0.08874489f, -0.03147966f, 0.03948068f, 0.07594123f, 
    0.02690992f, -0.03733343f, -0.00637985f, 0.02346512f, -0.03023971f, -0.02747051f, -0.03192648f, 0.02576433f, 
    -0.05652831f, -0.02496023f, -0.04472870f, 0.01823111f, -0.01181526f, 0.01260102f, 0.01038800f, -0.05244628f, 
    0.01365947f, 0.01666433f, 0.02045870f, 0.04212371f, 0.02689083f, -0.00271344f, -0.01689038f, 0.01171861f, 
    0.03803870f, 0.00456214f, 0.02785199f, -0.02403646f, -0.04857460f, 0.02327564f, -0.04488968f, -0.01939636f, 
    -0.02612653f, -0.02750111f, -0.03573116f, -0.03700181f, -0.03812081f, 0.00955523f, -0.03834940f, -0.04205215f, 
    0.01609466f, -0.03464177f, 0.01586841f, -0.04110140f, -0.02567218f, 0.01291989f, -0.02929482f, -0.01383372f, 
    -0.00897237f, 0.03258307f, -0.02001679f, -0.00530042f, 0.02464158f, -0.03867771f, 0.03705822f, -0.00748014f, 
    0.04479286f, -0.01352097f, -0.02281936f, 0.00277605f, 0.02103907f, -0.04252334f, -0.00364465f, -0.01652980f, 
    -0.05458699f, 0.04144381f, 0.03976299f, -0.03152991f, -0.00893544f, 0.01011393f, -0.02460871f, 0.00771031f, 
    -0.00882413f, 0.01348137f, 0.00923302f, -0.00892336f, 0.01956240f, 0.03199835f, 0.00436904f, -0.03911484f, 
    -0.03490292f, -0.05386749f, -0.03567790f, -0.04867234f, 0.02108977f, 0.01927294f, 0.01558346f, -0.04343353f, 
    -0.04615347f, 0.01274431f, 0.02121468f, 0.02713581f, -0.04056257f, -0.01527802f, 0.03567364f, 0.02189061f, 
    -0.00048887f, -0.04573726f, -0.03238888f, -0.03442309f, 0.01410191f, 0.00957504f, 0.00036849f, -0.04047655f, 
    0.03651500f, 0.00731910f, -0.05334320f, 0.02205989f, -0.01207843f, 0.00830985f, 0.01575681f, 0.02423151f, 
    0.00475390f, 0.00459066f, 0.00296286f, 0.01028075f, -0.04005316f, -0.00539033f, -0.02062183f, -0.04765433f, 
    -0.03298717f, -0.00158162f, 0.03542859f, 0.04085112f, -0.04630607f, -0.01263138f, -0.00117881f, -0.02904806f, 
    0.02331500f, -0.04197860f, 0.01494222f, -0.03363099f, -0.02398503f, -0.00538758f, 0.03772081f, -0.03317985f, 
    -0.04845818f, -0.02223439f, -0.02221399f, 0.03874972f, -0.04994792f, -0.00088907f, -0.00905329f, -0.04780720f, 
    -0.00271112f, -0.03836642f, -0.02547956f, 0.01268725f, 0.00997932f, -0.01867787f, 0.01562741f, -0.00952348f, 
    0.00646034f, -0.04256821f, 0.01761359f, -0.05663472f, -0.02488277f, -0.02417069f, -0.01946218f, -0.03868563f, 
    -0.03216761f, -0.01266014f, 0.02520681f, 0.02476910f, 0.00109312f, -0.00079918f, 0.04018822f, 0.02756761f, 
    -0.00135594f, -0.03276826f, 0.03203694f, -0.01412571f, -0.00065500f, 0.00205394f, -0.00812034f, -0.02481077f, 
    -0.02840624f, 0.01902677f, -0.05625305f, -0.04516062f, 0.01505183f, -0.03592518f, 0.00389890f, -0.01080913f, 
    -0.01686006f, -0.01410531f, -0.03796941f, 0.02060101f, -0.02938182f, -0.01967742f, -0.02289525f, 0.04428912f, 
    0.01883108f, -0.00270551f, 0.02172432f, -0.02672971f, -0.05366465f, -0.05241477f, -0.05646032f, -0.02934039f, 
    -0.04480092f, -0.00241527f, 0.03309166f, -0.03971313f, -0.03155245f, -0.01171815f, 0.03999875f, -0.04536043f, 
    0.03766512f, 0.03856245f, 0.00693440f, 0.04188946f, -0.00973197f, -0.00853732f, -0.02359388f, 0.04478117f, 
    -0.00660757f, -0.03982603f, -0.01516937f, -0.03353240f, 0.01682487f, 0.03473372f, -0.00623377f, -0.00593420f, 
    -0.00308362f, 0.02219117f, -0.03954123f, 0.03221113f, -0.02378438f, -0.04843914f, -0.04709990f, -0.03982206f, 
    0.02483018f, -0.05408584f, -0.01650150f, -0.04264399f, -0.03528286f, -0.02285171f, 0.03029332f, -0.02635621f, 
    -0.01787357f, -0.00444182f, 0.04259606f, 0.02159715f, -0.02727737f, 0.01683048f, -0.04350696f, 0.04019783f, 
    0.02337213f, -0.02450005f, -0.01645929f, 0.00731867f, 0.00396677f, -0.04130360f, 0.02862689f, 0.03729367f, 
    -0.02727661f, -0.01757475f, -0.02873678f, -0.04723762f, 0.00112494f, 0.03568622f, -0.02866735f, 0.04497864f, 
    0.03371781f, -0.01563099f, -0.02336541f, 0.00730433f, 0.01979200f, 0.04031659f, 0.03026334f, 0.03526525f, 
    0.02260292f, 0.00408250f, -0.00976387f, 0.03871218f, 0.03305693f, 0.01739097f, 0.00382735f, 0.02178266f, 
    0.01696527f, -0.01683403f, -0.03229327f, 0.00028261f, -0.05189902f, -0.00613514f, -0.03218542f, -0.05361420f, 
    0.00001897f, -0.01640745f, -0.00669480f, 0.04331535f, -0.01618410f, 0.02356080f, 0.01294980f, 0.03059598f, 
    -0.02306156f, -0.03766607f, 0.01887910f, 0.02134969f, 0.01008607f, 0.00426200f, -0.04079570f, -0.05300350f, 
    0.02666241f, 0.00195869f, -0.04476366f, -0.04159269f, 0.02321407f, -0.03564077f, -0.03099716f, 0.02606457f, 
    0.00697451f, -0.03938457f, -0.03150316f, -0.00630984f, -0.00286740f, -0.03147527f, 0.01597278f, -0.00832847f, 
    -0.05119011f, 0.03973280f, -0.04738199f, -0.01474912f, 0.00247699f, -0.04895865f, -0.02912042f, 0.01587823f, 
    -0.05541614f, 0.01907943f, 0.00137949f, -0.04080755f, 0.03665685f, 0.03596153f, -0.05448231f, -0.05536987f, 
    0.03241203f, -0.05077255f, -0.02384400f, -0.02340321f, 0.00694472f, 0.01213395f, -0.03817327f, -0.04548993f, 
    -0.04113646f, 0.01032466f, -0.04017903f, 0.03132447f, -0.01880434f, 0.00990688f, 0.04496463f, -0.02695204f, 
    -0.04149449f, -0.00662600f, -0.04449758f, -0.05118694f, 0.00812122f, 0.04425771f, 0.01574375f, -0.02680277f, 
    -0.02098282f, 0.02676383f, 0.02633789f, 0.04212322f, -0.01220559f, 0.00701555f, -0.03364644f, -0.01737577f, 
    0.04047796f, 0.02057842f, -0.05247467f, 0.00010054f, 0.00665044f, 0.00243429f, -0.05018747f, -0.05317923f, 
    0.03035915f, 0.04172483f, -0.03843429f, 0.04193173f, 0.03907441f, 0.02302834f, 0.01928049f, 0.00637772f, 
    -0.21917154f, 0.04891966f, 0.17983098f, 0.16059716f, 0.11621888f, 0.01356993f, 0.03222946f, 0.06853966f, 
    -0.07273910f, 0.06579357f, 0.10430928f, 0.02541189f, -0.14580037f, 0.03033345f, -0.02624138f, 0.04980248f, 
    0.08469764f, -0.04074022f, -0.01602823f, -0.02602074f, -0.03655393f, 0.02268387f, -0.01268934f, -0.05995996f, 
    0.17946659f, 0.00141560f, 0.10602872f, -0.11078264f, 0.06823415f, 0.04448538f, 0.04937460f, 0.04613864f, 
    0.01123443f, -0.17880727f, 0.14774804f, 0.11407455f, -0.09597664f, 0.13941762f, 0.02232097f, 0.13264094f, 
    0.02038602f, -0.09327201f, 0.02156035f, 0.18583618f, 0.07873604f, -0.01648228f, -0.10536633f, 0.07395262f, 
    0.16410127f, 0.08316974f, 0.01720486f, -0.11300972f, 0.04743934f, -0.01455097f, -0.18999411f, 0.01917708f, 
    -0.02448902f, 0.07253727f, -0.00454787f, 0.02237723f, 0.08099775f, -0.06956442f, -0.13381062f, 0.21144700f, 
    0.02243143f, 0.14489923f, -0.02666630f, -0.06515410f, -0.00928428f, -0.07135420f, -0.04057375f, 0.02189946f, 
    -0.12227546f, -0.05090849f, -0.15353099f, -0.17861013f, 0.12462348f, -0.00251879f, -0.03967041f, -0.08565151f, 
    0.08168390f, -0.04935353f, -0.01967591f, 0.01411205f, -0.05919489f, 0.06818763f, -0.06315973f, -0.00050312f, 
    -0.00817974f, -0.06709959f, -0.01886302f, -0.09580766f, -0.08807340f, 0.14857452f, 0.10539345f, -0.02336394f, 
    0.05488195f, -0.13508743f, -0.15700330f, -0.04471948f, 0.08635170f, 0.06030731f, -0.04741334f, -0.06160820f, 
    0.02064743f, -0.01601461f, -0.03594472f, -0.12483285f, 0.52589089f, 0.06380183f, -0.01017835f, -0.16600762f, 
    0.10884825f, -0.00721501f, -0.06637979f, 0.05784241f, -0.04090700f, -0.06163080f, 0.02969510f, 0.03343535f, 
    -0.05171182f, 0.21185437f, 0.09600738f, 0.03644108f, -0.00833073f, -0.00084330f, -0.07176640f, 0.00143677f, 
    0.01469256f, 0.02572986f, -0.08667266f, 0.09650183f, 0.07930834f, 0.16996537f, 0.05388667f, -0.05435518f, 
    0.09145512f, 0.03069892f, 0.02837816f, 0.07333726f, -0.09503950f, 0.01746165f, -0.07421394f, -0.03765472f, 
    -0.08207572f, 0.19701537f, -0.20745170f, 0.08959460f, -0.02069303f, -0.01021349f, -0.04072048f, 0.01781069f, 
    0.05514242f, 0.12147050f, 0.05739647f, -0.05737657f, 0.32884917f, 0.11626149f, 0.05441228f, -0.22349539f, 
    0.06157672f, 0.20000474f, -0.03075513f, 0.01755261f, 0.04584193f, -0.04113090f, 0.01811539f, 0.01413461f, 
    0.02849963f, 0.12426756f, -0.11100245f, 0.01175588f, 0.03733501f, -0.01810492f, 0.05721702f, 0.00602601f, 
    0.05241916f, -0.03215261f, -0.07539958f, -0.03700312f, 0.02790087f, -0.13813628f, 0.01339510f, 0.17144331f, 
    -0.03531047f, -0.19563343f, 0.00050384f, 0.05236261f, -0.01462343f, 0.04323937f, 0.14774288f, -0.11047527f, 
    0.15768495f, -0.10204284f, -0.08116055f, -0.10686150f, 0.03904928f, 0.02308905f, 0.12931883f, 0.14442836f, 
    0.08733030f, -0.02116857f, 0.04953232f, -0.06196205f, -0.18751629f, -0.11866088f, -0.04260720f, 0.04646517f, 
    0.06666289f, -0.09324915f, -0.03427869f, 0.02903978f, 0.01173858f, -0.13236906f, 0.05958073f, 0.02758601f, 
    0.10745742f, 0.10131437f, -0.14787196f, -0.19969620f, -0.03088656f, 0.05894840f, -0.16623406f, 0.12029940f, 
    0.14657602f, -0.00967408f, 0.00613219f, 0.07503523f, -0.16351597f, -0.00166639f, 0.02158846f, -0.07481492f, 
    0.01409434f, -0.03739827f, 0.10391602f, -0.05513463f, 0.12698929f, -0.00375552f, -0.00663614f, 0.12707150f, 
    -0.36092430f, 0.21602887f, -0.02918953f, 0.00030742f, 0.09437349f, 0.10567429f, 0.13881791f, -0.07290991f, 
    0.02939346f, 0.05251263f, 0.09659217f, -0.01876182f, -0.21809243f, -0.01815937f, 0.12700221f, 0.06397648f, 
    -0.14154021f, -0.09619675f, 0.00131574f, -0.12279760f, 0.09734630f, 0.09539203f, 0.07289226f, 0.09497365f, 
    -0.06768611f, -0.00539804f, 0.04053408f, -0.06207580f, 0.13878120f, -0.08245856f, -0.03515133f, -0.03884808f, 
    -0.00449858f, 0.11237832f, -0.00609163f, 0.05057355f, -0.12816136f, 0.24989101f, 0.11043403f, 0.16150905f, 
    -0.11036330f, -0.04322640f, 0.08479431f, 0.11172713f, -0.06430664f, 0.08177727f, 0.00239197f, -0.00543314f, 
    -0.36985523f, 0.05452119f, -0.09987378f, 0.10270004f, 0.17597587f, -0.04163473f, 0.11072771f, 0.00239207f, 
    0.01309828f, -0.00469767f, 0.11685903f, -0.07281900f, -0.09967126f, 0.04592749f, -0.02958475f, 0.16912463f, 
    -0.00374933f, -0.00319620f, 0.01472018f, 0.09356920f, -0.04273025f, -0.04143130f, 0.22414726f, 0.06896293f, 
    -0.19045208f, 0.07733493f, 0.12124956f, 0.14530422f, 0.06008298f, 0.05096554f, 0.01715205f, 0.03326899f, 
    -0.04878232f, 0.01982947f, 0.05795879f, 0.00815831f, -0.14502335f, 0.03500723f, -0.11244200f, -0.10304828f, 
    0.06888235f, -0.04529970f, -0.08594747f, 0.00112290f, -0.05000664f, 0.00861818f, -0.05224706f, -0.03025842f, 
    0.06412721f, 0.04478679f, 0.14809410f, 0.00384683f, -0.03847824f, 0.08829510f, -0.07994536f, -0.00605030f, 
    0.07550568f, 0.00091866f, 0.04212898f, -0.06593116f, -0.05488731f, -0.10202259f, 0.00570878f, 0.01604195f, 
    0.06606814f, 0.02728515f, 0.11538336f, -0.06649385f, 0.17836311f, 0.07311409f, -0.03666745f, 0.02498802f, 
    0.06276804f, 0.05500023f, -0.01753548f, -0.03110908f, 0.00940570f, 0.00695944f, -0.06839322f, 0.04573371f, 
    0.02324261f, 0.00769680f, 0.12607285f, -0.02267754f, -0.22316246f, 0.33577859f, -0.12543519f, 0.12434080f, 
    0.14505796f, 0.14132531f, 0.04049696f, -0.00663273f, 0.12750837f, 0.04962425f, -0.00710790f, -0.13379236f, 
    -0.04485389f, 0.00836379f, -0.01649763f, -0.04184971f, 0.04794089f, -0.01081129f, -0.00869205f, -0.03855196f, 
    -0.17744757f, -0.06560587f, 0.08705399f, 0.05573661f, -0.30499354f, 0.23230532f, -0.03602102f, 0.08012225f, 
    0.08278585f, -0.01639233f, -0.04573564f, -0.00652957f, -0.03571180f, -0.02604331f, -0.03528813f, -0.04506711f, 
    0.45645699f, 0.05655077f, 0.03163923f, -0.04069846f, -0.01202458f, 0.13514154f, 0.01906281f, 0.10169475f, 
    0.02973367f, 0.01472502f, 0.07471417f, 0.09139466f, 0.12095136f, -0.11671578f, 0.31148487f, 0.27993900f, 
    0.11349804f, -0.01236428f, 0.10562702f, 0.02321562f, 0.11423481f, 0.04254229f, -0.01975017f, 0.02539715f, 
    0.08103556f, -0.08763266f, 0.04051256f, -0.22415227f, 0.01311198f, 0.05888071f, -0.25992361f, 0.02144983f, 
    0.02419663f, 0.04008234f, 0.11863347f, 0.03886447f, 0.26639619f, -0.12112540f, -0.08812812f, 0.13707997f, 
    -0.09783341f, 0.02433956f, -0.02162364f, -0.07316224f, 0.00559911f, -0.04572526f, -0.05377242f, 0.02088519f, 
    -0.03346907f, -0.20028605f, -0.23969829f, -0.01194893f, 0.26765066f, -0.08663290f, -0.00255742f, -0.04978316f, 
    0.13215464f, -0.04862148f, -0.01877719f, -0.09805110f, -0.17210384f, -0.10846201f, 0.03134677f, -0.01933804f, 
    -0.00787561f, -0.08688884f, -0.05710788f, -0.04272547f, -0.02766873f, 0.07109770f, 0.14218576f, 0.00827576f, 
    0.38461238f, -0.16659349f, -0.07354041f, 0.16057701f, 0.12206092f, -0.05027977f, -0.06952710f, -0.01217129f, 
    0.05329177f, -0.08476662f, 0.01288345f, -0.13053310f, 0.50538725f, -0.19770223f, 0.03476710f, -0.01967597f, 
    0.15344770f, -0.05421671f, 0.03452906f, 0.05121877f, 0.07676665f, -0.07694306f, -0.10879617f, 0.15261766f, 
    0.02602076f, 0.05906979f, 0.05653080f, -0.02657685f, -0.03956552f, -0.10728848f, -0.02681450f, -0.09369496f, 
    0.10067830f, -0.05536991f, -0.02051507f, 0.18699105f, 0.03825920f, -0.00438807f, 0.09612839f, 0.02373149f, 
    0.07995676f, -0.08004988f, 0.04351490f, -0.02220621f, 0.00535893f, 0.02062883f, -0.03503807f, -0.03185773f, 
    -0.15771341f, 0.05027216f, -0.11409661f, -0.02733824f, 0.06373988f, -0.08074278f, 0.10362665f, 0.01411283f, 
    0.02474382f, -0.00020844f, 0.02558601f, -0.15765069f, 0.33242393f, 0.11281081f, -0.09015992f, -0.15780377f, 
    0.09252200f, 0.12168408f, -0.14579950f, 0.00161895f, 0.01837394f, 0.04254393f, -0.04905828f, 0.08127227f, 
    -0.09623875f, 0.06667122f, 0.01322378f, 0.09034225f, 0.04194144f, -0.02149237f, -0.05880690f, 0.06508470f, 
    0.03646494f, -0.04174627f, 0.00947029f, -0.12538201f, -0.14868665f, 0.19471230f, -0.02489056f, 0.13206756f, 
    -0.14328824f, -0.23929128f, 0.00687218f, 0.15083687f, -0.02852330f, 0.04738386f, 0.01612672f, -0.13566735f, 
    0.15243161f, -0.14209002f, -0.09988362f, -0.13339704f, 0.06079458f, -0.06792323f, 0.24315649f, 0.07638811f, 
    0.02999629f, 0.14579482f, 0.10577295f, 0.03075605f, 0.34931454f, -0.15923162f, -0.04340373f, -0.01695767f, 
    -0.16793835f, -0.01832423f, -0.14306305f, -0.03073444f, -0.02593285f, -0.15160613f, -0.01405726f, -0.06036988f, 
    0.02481413f, -0.09593955f, -0.08357959f, 0.02478375f, 0.01099842f, 0.12413507f, -0.06954063f, 0.15181428f, 
    0.04325433f, -0.04844531f, 0.04356435f, -0.00304323f, 0.23658025f, -0.09966514f, -0.02634437f, 0.08073071f, 
    0.08639856f, 0.00354948f, 0.04910957f, -0.00415717f, 0.22029284f, 0.01249750f, 0.03217252f, 0.22051905f, 
    -0.14989938f, -0.11887931f, -0.05480732f, -0.05007121f, 0.01522288f, 0.02791289f, 0.17884773f, -0.00329390f, 
    0.05106352f, -0.02393915f, 0.00838958f, -0.05038971f, -0.30698228f, 0.15874326f, -0.02741330f, -0.03454668f, 
    -0.15837997f, -0.17318709f, -0.04682118f, -0.02646354f, 0.14096597f, 0.16055974f, 0.09657934f, 0.06803539f, 
    0.01557966f, -0.14929050f, -0.00174737f, 0.15446001f, 0.05676861f, -0.10705883f, 0.01169183f, 0.03479362f, 
    -0.12196890f, 0.14522989f, -0.04954417f, 0.06678979f, -0.17436098f, 0.13485456f, 0.04730298f, 0.10616507f, 
    -0.09296065f, -0.07010217f, 0.02932840f, -0.04185060f, -0.04205061f, -0.08052068f, -0.07455325f, 0.01450681f, 
    -0.10570114f, 0.08499977f, 0.03447270f, 0.20676781f, 0.24190219f, 0.04768618f, 0.08365478f, 0.00318015f, 
    -0.00873286f, 0.02633544f, 0.11326666f, -0.04699286f, -0.29217544f, -0.02773608f, -0.05833175f, 0.04461151f, 
    0.08147462f, -0.05941836f, 0.00621143f, 0.02776491f, -0.05049745f, -0.04968034f, 0.17104729f, 0.06987993f, 
    -0.42260703f, 0.34161076f, 0.00452344f, 0.03697848f, -0.04275110f, 0.05597233f, 0.08141425f, -0.02792300f, 
    0.01169795f, 0.06000491f, -0.01419714f, 0.01029842f, 0.09003314f, -0.34282336f, -0.10719980f, 0.01024358f, 
    0.14969631f, -0.09825829f, -0.00660722f, -0.05431626f, -0.01748067f, 0.04721457f, 0.02204746f, 0.02347127f, 
    0.09615545f, 0.12019236f, -0.00271764f, -0.11276075f, -0.19777298f, 0.04215107f, -0.08529898f, 0.08954931f, 
    0.04094213f, 0.02762376f, 0.02879195f, -0.02174680f, -0.02200061f, -0.17958979f, 0.04508747f, 0.00041808f, 
    0.03928782f, 0.02658524f, 0.08407542f, 0.04245379f, 0.14910588f, 0.10110017f, 0.02937383f, -0.05842380f, 
    0.00123437f, -0.16564441f, 0.19495904f, 0.16409747f, 0.06808458f, -0.01622678f, -0.06754269f, 0.07177664f, 
    0.05421150f, -0.03466865f, 0.13174163f, 0.02455088f, -0.10695545f, 0.27448255f, -0.21699829f, 0.11221026f, 
    0.15941764f, 0.07084909f, -0.03725865f, -0.10204494f, 0.13510743f, 0.09640054f, 0.00123705f, -0.14957874f, 
    0.00291479f, -0.02700671f, 0.02332251f, -0.04813641f, -0.04529282f, -0.04789974f, 0.01279943f, -0.01967329f, 
    -0.04526537f, 0.03973019f, -0.04918756f, -0.03048309f, 0.01287047f, -0.02179503f, -0.00402977f, -0.03635102f, 
    0.01005412f, 0.02926086f, -0.03302608f, 0.01282074f, 0.03577564f, 0.03073495f, -0.00713957f, -0.05571124f, 
    0.03929143f, -0.04561617f, 0.03754468f, 0.03427410f, -0.04735078f, -0.02380261f, -0.05337521f, 0.00345553f, 
    0.02181551f, -0.00269192f, -0.02275543f, 0.04106844f, -0.05472046f, 0.00698781f, 0.01548269f, -0.04009581f, 
    -0.02807729f, -0.00791596f, 0.02118808f, -0.04792329f, -0.03861828f, 0.03780574f, 0.04279445f, -0.03054783f, 
    0.02174090f, -0.01596127f, -0.05294774f, -0.03625799f, -0.04186979f, 0.04542344f, 0.00553805f, -0.04151571f, 
    0.02521198f, -0.05517792f, -0.04277363f, -0.00554389f, -0.02699011f, -0.02939801f, 0.00330207f, -0.04584692f, 
    -0.02522250f, -0.00372405f, -0.05249535f, -0.03520583f, -0.03261071f, -0.04632510f, -0.01080361f, -0.04739735f, 
    0.02665621f, -0.03301011f, 0.03847946f, -0.00134050f, -0.01384682f, -0.03042399f, 0.03525567f, 0.00423311f, 
    0.02816635f, -0.03501296f, 0.03792323f, 0.02875128f, -0.01817602f, -0.05444835f, 0.03676750f, 0.00536744f, 
    0.02337119f, 0.01154358f, -0.04369102f, 0.03629949f, -0.05213116f, -0.03606277f, 0.02485817f, -0.05745060f, 
    -0.04287014f, -0.03688764f, 0.03768012f, -0.00898591f, -0.01228488f, 0.00345695f, 0.02548466f, -0.05261134f, 
    0.03286041f, -0.02931154f, 0.03675805f, 0.02680368f, -0.04014190f, -0.02375199f, -0.04690268f, -0.01958578f, 
    0.01263744f, 0.02641225f, -0.00987884f, -0.05571938f, -0.03779082f, 0.01548831f, 0.03718477f, 0.02957362f, 
    0.02545146f, 0.04460728f, 0.02444499f, -0.04115611f, -0.04789774f, 0.00277740f, -0.02293228f, -0.00320649f, 
    0.00064118f, -0.05159895f, 0.00846066f, -0.03946780f, -0.03145945f, -0.05212019f, -0.01496091f, 0.04371921f, 
    0.03306462f, -0.03280438f, 0.03855990f, -0.01717039f, -0.05168867f, 0.03618237f, -0.03674354f, 0.02150886f, 
    -0.05546124f, -0.01782542f, -0.00131919f, 0.03628168f, -0.04551303f, -0.01102228f, -0.00342860f, 0.03124144f, 
    0.02133851f, -0.04874125f, -0.01971297f, -0.03746926f, -0.01970711f, -0.02082565f, -0.02910830f, 0.04351768f, 
    -0.05518942f, -0.02951973f, 0.01703944f, 0.01943158f, 0.01408115f, -0.01239027f, 0.03719516f, -0.01327468f, 
    -0.01092993f, -0.00276633f, 0.00764397f, 0.00364826f, -0.03081584f, -0.00570354f, 0.01469878f, 0.01409373f, 
    -0.03819530f, -0.00239966f, 0.03730565f, 0.00314062f, -0.04599505f, 0.00683020f, 0.01999017f, 0.00122628f, 
    0.00394442f, -0.00196351f, -0.00498815f, -0.03002078f, 0.02413901f, 0.02473667f, 0.03799059f, 0.04155346f, 
    -0.04666830f, -0.04483782f, -0.00475104f, 0.00575828f, 0.03573335f, 0.04020356f, -0.04855556f, 0.04327068f, 
    -0.04690190f, -0.05562590f, -0.04144805f, -0.04137504f, -0.01434723f, 0.00084175f, 0.00376792f, -0.03631835f, 
    -0.00693049f, 0.01975416f, -0.04774329f, -0.05488899f, -0.02344834f, -0.05751168f, 0.03257825f, 0.00606382f, 
    0.00513191f, 0.00869452f, 0.02629142f, 0.00831675f, 0.00248157f, 0.02399532f, -0.02585665f, -0.05519837f, 
    -0.04055574f, -0.02016951f, 0.02236203f, 0.02185015f, -0.01131780f, -0.01188457f, -0.00499783f, -0.02014910f, 
    0.01149620f, 0.02299653f, 0.01156016f, 0.01372615f, 0.02840784f, 0.01189753f, -0.04466758f, -0.05029443f, 
    -0.02587782f, -0.03832369f, 0.01622046f, 0.03684270f, 0.04138878f, -0.00793189f, 0.00924889f, -0.05408815f, 
    0.03120914f, 0.03562773f, -0.01241439f, -0.04235888f, -0.02218078f, 0.03456279f, -0.04703701f, 0.02929022f, 
    -0.01959865f, -0.01673196f, -0.01002901f, 0.04425943f, -0.00790636f, 0.00869037f, 0.03872499f, 0.01181716f, 
    -0.02103710f, 0.03697107f, 0.02996162f, -0.00791729f, -0.02622528f, 0.00353430f, 0.01368703f, 0.04386549f, 
    0.01267567f, -0.00324445f, -0.00903056f, 0.02073255f, -0.04140792f, -0.04610729f, -0.03719952f, -0.05298954f, 
    -0.02459450f, -0.03665092f, -0.05276997f, 0.01879751f, -0.00064684f, 0.00838351f, -0.03003579f, -0.00270131f, 
    -0.00464937f, 0.03373265f, -0.03645404f, -0.05060006f, -0.01327058f, -0.05045195f, 0.01189916f, -0.02493968f, 
    -0.03206067f, -0.02600771f, -0.05090844f, 0.03846001f, -0.05439579f, 0.02914676f, 0.03702246f, -0.05231613f, 
    -0.05434974f, 0.02590840f, -0.05057902f, -0.05732239f, -0.03146176f, -0.04753282f, -0.01568073f, 0.03582253f, 
    -0.01036739f, -0.00900329f, -0.01588616f, -0.04887428f, -0.01831238f, -0.04083630f, 0.01692301f, -0.05254763f, 
    -0.03267276f, -0.02690311f, 0.02890357f, 0.02086860f, -0.01022284f, 0.00086925f, -0.05320904f, -0.04155500f, 
    -0.00539703f, -0.05755555f, 0.03007702f, 0.04250297f, 0.03511912f, -0.02814320f, 0.04273369f, 0.02677932f, 
    0.03201289f, -0.05527667f, -0.03821297f, 0.00634113f, -0.03660309f, 0.03365147f, 0.02117044f, -0.00433787f, 
    0.03947531f, 0.02213461f, 0.00837981f, 0.00263735f, -0.03798629f, 0.01648165f, -0.04588159f, -0.03484890f, 
    0.03169344f, 0.03525776f, -0.05286383f, -0.02833065f, -0.02382258f, 0.02025351f, -0.02990782f, 0.01137487f, 
    -0.04909646f, 0.00827687f, 0.04054911f, 0.02392415f, -0.05822551f, 0.02986503f, 0.02859449f, 0.01399508f, 
    0.00963601f, -0.04600953f, 0.02897453f, -0.02443252f, 0.01013938f, -0.01750059f, 0.02272531f, -0.05282229f, 
    0.01536014f, -0.01197297f, 0.01879868f, -0.05611919f, 0.02332903f, -0.04748652f, -0.04737737f, -0.04931268f, 
    0.10712104f, 0.00871836f, 0.15056017f, -0.00917090f, 0.01725048f, 0.16163832f, 0.11419358f, -0.06011209f, 
    -0.10472044f, -0.01957867f, -0.15953434f, -0.07058138f, -0.24634962f, 0.00198775f, -0.09381802f, -0.09828891f, 
    0.12608463f, 0.01445012f, -0.07353295f, 0.12664296f, -0.02897942f, 0.06664165f, -0.12724657f, 0.02043483f, 
    -0.08152510f, 0.08230666f, 0.05621523f, -0.01207679f, -0.01069911f, -0.18666096f, -0.01055316f, 0.00057590f, 
    0.03275872f, 0.09178095f, 0.08020249f, 0.16677845f, 0.14795868f, 0.10620064f, 0.02663545f, -0.05584777f, 
    -0.01950123f, 0.00103242f, 0.01947800f, 0.07307529f, 0.07131962f, 0.13636595f, 0.14528082f, 0.24384259f, 
    0.24703343f, 0.03151794f, -0.01751288f, 0.14301962f, 0.03788453f, 0.10075343f, -0.08162625f, 0.04839692f, 
    0.14570944f, 0.18513784f, 0.04782594f, -0.01928354f, 0.21445574f, 0.00637775f, -0.22285713f, 0.04902395f, 
    0.12865017f, 0.04929245f, 0.08625536f, -0.03223430f, -0.00919198f, 0.04012425f, 0.09817830f, -0.01545844f, 
    -0.37100327f, -0.23065946f, -0.21671107f, -0.19511296f, 0.07091642f, -0.02215615f, -0.04847705f, -0.07043073f, 
    0.04956533f, -0.06476673f, -0.13653551f, 0.06317424f, -0.09729244f, 0.02440834f, 0.21950136f, -0.05909024f, 
    -0.01617979f, -0.04031113f, 0.04670743f, -0.06711262f, 0.01293972f, -0.01922788f, 0.09682824f, 0.03304913f, 
    -0.04647046f, -0.03475679f, 0.08832134f, 0.26651978f, -0.01316780f, 0.00241888f, 0.01784507f, 0.05920037f, 
    -0.02704969f, 0.01368267f, 0.14518316f, 0.16149078f, -0.17909077f, -0.09606358f, 0.03695899f, 0.20018294f, 
    0.11842125f, -0.08981460f, 0.08129907f, 0.09211027f, -0.01718367f, -0.05426252f, -0.02007223f, 0.17282984f, 
    -0.13253568f, 0.05255774f, -0.06171887f, 0.27221912f, -0.03968154f, -0.11495011f, -0.00730018f, 0.11322886f, 
    0.13049370f, 0.01239477f, -0.05873793f, 0.10408042f, -0.00917193f, 0.18166363f, -0.07436551f, -0.02148454f, 
    0.08495083f, -0.07266637f, -0.02377609f, 0.07188991f, 0.07741589f, 0.06932799f, -0.05726469f, 0.03660866f, 
    -0.00909494f, 0.07877430f, -0.05707889f, -0.03793937f, -0.07069245f, -0.05275246f, 0.09621969f, 0.06182248f, 
    0.03332854f, -0.08041627f, -0.10224175f, -0.08626410f, -0.18451205f, -0.16244185f, 0.08571875f, 0.03225151f, 
    -0.02669241f, 0.00276938f, 0.02610374f, -0.04168049f, -0.08330592f, 0.03338827f, 0.05387957f, 0.11177967f, 
    0.30232817f, 0.23697922f, 0.15369651f, 0.20889500f, 0.24424806f, 0.02610033f, 0.02025292f, 0.07177115f, 
    0.00752007f, 0.01508971f, 0.14081039f, 0.01517208f, -0.03272381f, 0.03763571f, -0.09880230f, 0.09808809f, 
    0.05711304f, 0.02048275f, 0.11734136f, 0.04516094f, -0.01341076f, 0.09622816f, -0.06125854f, -0.00884355f, 
    0.28395322f, -0.11199377f, 0.15700604f, 0.23352632f, 0.01281367f, 0.09405082f, -0.02333444f, 0.16848631f, 
    0.04851323f, -0.00995388f, 0.03610418f, 0.02835335f, -0.23964834f, 0.07827108f, -0.19539362f, 0.03225122f, 
    0.01235446f, 0.03355657f, -0.02523917f, -0.13582502f, -0.01580833f, -0.10861755f, 0.08415945f, -0.08533975f, 
    -0.36369216f, -0.06906871f, 0.00119652f, 0.12609614f, 0.15330254f, 0.02729065f, 0.02410806f, 0.02141689f, 
    -0.06557015f, -0.01654481f, -0.06580393f, 0.04921134f, 0.10456558f, 0.01455125f, 0.00842038f, 0.15016952f, 
    -0.08704877f, 0.00998932f, 0.21392433f, -0.00819901f, 0.11979990f, -0.06874546f, -0.04598714f, 0.05693282f, 
    -0.23700681f, 0.20096350f, -0.04432914f, -0.27676997f, 0.06727497f, -0.06982811f, -0.02407288f, -0.08688142f, 
    -0.04538650f, -0.11316043f, -0.08082350f, -0.04680965f, -0.09024031f, 0.31628087f, 0.17285490f, 0.02094979f, 
    -0.03239165f, -0.11720145f, -0.05960972f, 0.04051891f, -0.03328391f, -0.00349882f, 0.05764636f, -0.07879163f, 
    -0.22580218f, 0.24183062f, 0.02336650f, 0.01954934f, 0.04565532f, 0.05609153f, -0.00858469f, -0.02271785f, 
    0.04137956f, -0.03923706f, -0.04982558f, -0.14235641f, -0.06124421f, -0.10588646f, 0.07343822f, -0.00271421f, 
    0.02213370f, 0.08324520f, -0.07397775f, -0.03255527f, 0.07991862f, 0.05429905f, -0.04877350f, 0.10833450f, 
    -0.04247089f, 0.08423236f, 0.18434505f, -0.02566356f, 0.12189099f, 0.03010406f, 0.00510288f, -0.00421493f, 
    0.04440132f, 0.05351609f, 0.05605594f, -0.07065895f, 0.22577780f, -0.03294931f, -0.05102469f, -0.08967298f, 
    0.00566575f, 0.02537907f, 0.03789116f, -0.17316988f, -0.03372214f, 0.05349188f, -0.30164102f, -0.06784894f, 
    0.10738262f, -0.04406697f, 0.19545352f, 0.05356677f, 0.07053746f, 0.03648337f, -0.04238152f, 0.16565421f, 
    0.09598637f, -0.02704535f, -0.04197269f, 0.02791550f, -0.37684754f, -0.15998745f, -0.05729896f, -0.13603644f, 
    0.08573984f, -0.08782379f, 0.05281884f, -0.03246837f, 0.04968588f, 0.01803568f, -0.02304250f, 0.08928486f, 
    0.25915393f, -0.05369227f, 0.06893221f, -0.05826568f, 0.08128785f, -0.06885007f, -0.02448964f, -0.07315216f, 
    0.00211262f, 0.09837162f, -0.07585594f, -0.01515003f, -0.12570000f, 0.00524901f, -0.09429087f, 0.08925696f, 
    0.03377256f, -0.05341369f, 0.00076730f, -0.02308318f, 0.03228724f, -0.06482867f, -0.02194186f, -0.22498529f, 
    -0.35734376f, -0.07078929f, 0.22033477f, -0.10992008f, 0.11539542f, 0.00471768f, -0.02067548f, 0.04658400f, 
    0.05857350f, -0.10548391f, 0.06617799f, -0.06554747f, -0.18398562f, -0.19040440f, -0.08248860f, -0.02420684f, 
    0.02125641f, 0.09597420f, -0.07158261f, -0.07241990f, -0.09335844f, 0.04817086f, -0.01599155f, 0.00712004f, 
    0.01109885f, 0.03080817f, -0.02465603f, 0.03691624f, 0.00974312f, -0.01053649f, -0.02417244f, -0.00575993f, 
    0.01288846f, -0.02529873f, -0.02466334f, -0.03686208f, -0.05456856f, -0.04115478f, -0.05146811f, -0.00750872f, 
    0.03665450f, 0.02153000f, 0.00675320f, 0.01048092f, 0.01330834f, -0.00823248f, 0.02479075f, -0.02721188f, 
    0.01801452f, 0.03447863f, 0.03573784f, 0.03121500f, -0.02258465f, -0.01244732f, 0.00957513f, -0.00324644f, 
    0.00691855f, -0.02509096f, 0.01515750f, -0.05272675f, 0.00190688f, -0.03683939f, -0.04608779f, 0.01577605f, 
    -0.01340995f, 0.01857329f, 0.02028030f, -0.02716913f, 0.02101490f, 0.02287212f, -0.00375284f, -0.01886930f, 
    0.03666569f, 0.04459478f, -0.01041627f, -0.04304268f, -0.03168237f, -0.04647841f, -0.01637391f, -0.02356945f, 
    0.01213750f, 0.02924737f, -0.03169360f, 0.03893160f, 0.03140617f, 0.02851076f, 0.01290345f, -0.04760089f, 
    0.02316996f, 0.03288218f, -0.03461992f, -0.03827999f, -0.03514206f, -0.00788597f, 0.01844150f, 0.02290666f, 
    -0.04615905f, -0.00242016f, 0.03466826f, 0.02386383f, 0.01155774f, 0.03941383f, 0.00237518f, -0.02326253f, 
    0.02838183f, 0.00778324f, 0.03593865f, -0.03598767f, 0.03775411f, -0.03233325f, -0.00036135f, -0.00655679f, 
    -0.02317725f, -0.00491593f, -0.00718181f, 0.00237596f, 0.00671483f, -0.02350436f, 0.03842102f, -0.00078355f, 
    0.03415087f, -0.04653652f, 0.02981482f, 0.00179280f, -0.04026987f, -0.02665063f, 0.04716267f, -0.02360421f, 
    0.00740421f, 0.01377942f, -0.02115834f, -0.02196040f, -0.01434599f, -0.00165148f, 0.02592337f, -0.02722736f, 
    0.03687333f, 0.01955204f, 0.00651978f, -0.04888001f, 0.03457735f, 0.03309869f, -0.03143351f, 0.00368509f, 
    -0.05886444f, -0.05748985f, 0.03208765f, -0.02591351f, 0.01728617f, -0.04184303f, -0.03578183f, 0.03691979f, 
    0.01082980f, 0.01327480f, 0.03807354f, -0.04867959f, -0.04660130f, -0.02960118f, -0.03694952f, -0.05179591f, 
    -0.01816808f, -0.03469347f, -0.03000812f, 0.03177117f, -0.01839326f, 0.01392128f, -0.05434661f, -0.06195103f, 
    0.03525669f, -0.05291677f, -0.02310081f, -0.02414586f, -0.01107963f, -0.02209959f, -0.00790423f, -0.01085189f, 
    -0.03042495f, -0.05314412f, -0.01085566f, 0.01037741f, -0.01084612f, -0.01252693f, -0.04920410f, -0.01515786f, 
    0.01341271f, -0.02771199f, 0.01153956f, -0.01734653f, 0.00921182f, 0.01765294f, 0.03925279f, -0.02275575f, 
    -0.02455501f, 0.01953172f, 0.00103805f, 0.00349190f, 0.00033744f, -0.02766758f, 0.03858045f, 0.03450955f, 
    -0.01025158f, -0.04067076f, -0.04862431f, 0.01538840f, 0.05436822f, 0.03769736f, 0.01920247f, -0.00362613f, 
    0.04149376f, 0.00473666f, 0.03699867f, 0.00528087f, 0.00723948f, -0.05928491f, 0.00088985f, -0.04704744f, 
    -0.00454766f, 0.00454363f, -0.03420310f, 0.01593707f, 0.03414001f, -0.02790834f, -0.04211080f, -0.05541497f, 
    -0.02842624f, 0.00179447f, -0.04561463f, 0.01577471f, -0.00608838f, 0.01611062f, 0.00534335f, 0.00575545f, 
    -0.04513473f, -0.00934346f, -0.05777911f, -0.02310727f, 0.02202363f, 0.00670789f, -0.04901081f, -0.05359842f, 
    0.03953358f, -0.04124542f, -0.04944181f, -0.04583671f, -0.03092188f, 0.02473521f, -0.03326539f, -0.03387117f, 
    0.00058914f, 0.02695499f, -0.02517349f, -0.02029111f, 0.01528594f, -0.03723112f, -0.01395062f, -0.01039906f, 
    0.03680652f, -0.00368991f, 0.04145931f, 0.02158732f, 0.01251499f, 0.02551740f, 0.01881941f, -0.02992778f, 
    0.00378252f, 0.03378732f, -0.03338968f, -0.05688167f, -0.03122697f, 0.01027692f, 0.03924233f, 0.03680121f, 
    0.00206494f, -0.02471583f, -0.00748012f, -0.01026128f, -0.04660866f, 0.03267456f, -0.05297572f, -0.03752913f, 
    -0.05439221f, -0.04812252f, -0.03469199f, -0.02888820f, -0.05355825f, 0.02970830f, 0.03615395f, -0.04511003f, 
    0.00086790f, 0.01846924f, -0.01267733f, -0.03996431f, 0.02191854f, 0.02976070f, -0.03757185f, -0.03538030f, 
    0.02474961f, -0.01003272f, -0.01912907f, -0.04320187f, 0.03267383f, 0.02894006f, 0.03305373f, -0.03551149f, 
    -0.01568106f, 0.02100391f, -0.02367254f, -0.01757357f, 0.02411604f, -0.00136461f, 0.02116951f, 0.02140640f, 
    -0.03950485f, -0.02142422f, 0.03377598f, 0.00048922f, 0.03433245f, 0.01750248f, 0.00336549f, 0.01201625f, 
    -0.04949890f, -0.00386644f, -0.04049675f, -0.01176743f, -0.04093032f, -0.03640322f, -0.00981314f, 0.02157135f, 
    0.00293970f, -0.01573293f, -0.01293944f, -0.03506583f, -0.01237120f, 0.00967136f, -0.00265538f, -0.01568094f, 
    0.00360171f, -0.05401240f, 0.00048246f, 0.03369703f, -0.04642629f, 0.00102904f, -0.05199085f, 0.01143478f, 
    -0.02241773f, 0.03825817f, -0.00654048f, -0.04270347f, -0.00472984f, -0.01042552f, -0.02968044f, -0.02036702f, 
    0.01480258f, -0.02727884f, 0.01058598f, -0.04082220f, -0.01601101f, 0.03348836f, 0.04203051f, 0.02724163f, 
    -0.03337871f, -0.00376524f, 0.02703373f, 0.04606084f, 0.01877356f, -0.02232951f, 0.02482965f, -0.00940785f, 
    -0.04614205f, -0.04017280f, 0.02790538f, -0.01056239f, 0.03981597f, -0.04962825f, -0.02201539f, 0.03453625f, 
    -0.04653891f, -0.04535608f, -0.00559839f, -0.05880764f, -0.02657479f, -0.05349758f, 0.02791806f, -0.03226136f, 
    0.02571133f, -0.02382689f, 0.02900635f, -0.04956326f, -0.00340906f, 0.00214041f, -0.04839810f, -0.04439900f, 
    -0.04966428f, -0.05702838f, 0.01897239f, 0.03867304f, 0.00934546f, -0.03332250f, 0.03508550f, -0.04944336f, 
    -0.00101616f, 0.01009738f, -0.02500107f, -0.04676751f, -0.05557704f, -0.05254845f, -0.01937154f, -0.00361370f, 
    -0.11644612f, -0.15083551f, -0.08876520f, 0.03102131f, -0.04954180f, -0.11679278f, -0.01062283f, 0.12906331f, 
    0.04629843f, 0.07719803f, 0.14743969f, 0.04024504f, 0.14826635f, -0.00214193f, 0.07798347f, -0.01220936f, 
    -0.09439718f, -0.00325717f, 0.06455681f, -0.04324779f, -0.06243323f, 0.03157613f, 0.08846460f, -0.01199535f, 
    0.26851839f, 0.08185922f, -0.01320875f, -0.02898276f, 0.05360374f, 0.14653175f, -0.09741814f, 0.06293119f, 
    -0.00460317f, 0.01383710f, -0.10400975f, -0.14528012f, -0.13655370f, -0.11353941f, 0.11971894f, 0.09889834f, 
    0.09828473f, 0.09506633f, -0.07803132f, 0.09746534f, -0.06872595f, -0.11105145f, -0.07996210f, -0.22779380f, 
    0.13442200f, 0.05681204f, 0.08400067f, -0.15668386f, -0.02986234f, -0.05189858f, 0.14811841f, -0.00519552f, 
    -0.13199018f, -0.15425819f, -0.15062676f, 0.10174191f, 0.20454267f, 0.07955819f, 0.04371667f, -0.03669045f, 
    -0.10888536f, -0.00076139f, 0.07567344f, 0.09808484f, 0.07367507f, 0.03563408f, -0.04856662f, 0.00225959f, 
    0.17209435f, -0.10326633f, 0.10039469f, 0.21390958f, -0.06393309f, 0.04759960f, 0.13681433f, 0.04985832f, 
    -0.03075970f, 0.09034547f, 0.05905780f, 0.05388532f, 0.19550803f, -0.14593655f, -0.09562772f, 0.30774847f, 
    0.04469145f, 0.01773514f, 0.08683281f, 0.07097243f, -0.06791386f, 0.06850120f, 0.07539301f, 0.02424288f, 
    -0.11103302f, -0.35662904f, 0.11643837f, 0.08527225f, -0.03681960f, -0.06601579f, -0.08854942f, 0.00637644f, 
    0.16251092f, -0.07574573f, -0.06858545f, -0.16558772f, -0.15319312f, -0.20024249f, -0.09535617f, 0.02948149f, 
    -0.06866667f, -0.06976255f, 0.01238962f, -0.04624622f, -0.02426307f, 0.02376002f, -0.02673367f, -0.11004789f, 
    0.19825216f, -0.02056627f, -0.09945964f, -0.08239153f, -0.01823311f, 0.13486649f, 0.01244509f, 0.01916784f, 
    -0.05239214f, -0.00435825f, 0.04875768f, -0.00962985f, 0.35960549f, -0.06387977f, -0.03367347f, 0.00520572f, 
    0.01455936f, 0.02612381f, 0.06708027f, 0.02541065f, -0.01758296f, -0.06779326f, 0.12938462f, -0.11734886f, 
    -0.21748984f, -0.19281869f, -0.20165412f, 0.00665053f, 0.09880792f, -0.05154883f, 0.02467133f, -0.00020840f, 
    -0.06124509f, 0.16952530f, 0.05492150f, 0.08833124f, -0.22318524f, -0.24343172f, -0.22016163f, 0.02128758f, 
    -0.15107648f, -0.08407757f, 0.02552152f, -0.00652980f, 0.11964941f, 0.03589939f, -0.05710492f, 0.01847759f, 
    0.04843338f, -0.13929237f, 0.13211137f, -0.02516496f, -0.23096952f, 0.01363556f, 0.03803795f, -0.09728102f, 
    0.01240792f, 0.06358640f, -0.03468487f, 0.06252903f, -0.17415047f, 0.17543483f, -0.02029418f, 0.13569352f, 
    -0.12509237f, -0.05891184f, -0.07034180f, 0.02010161f, -0.02367464f, -0.19699660f, 0.01813458f, 0.05546926f, 
    0.10720161f, 0.08371546f, 0.01776036f, -0.08061107f, 0.10492940f, -0.04090751f, 0.03119013f, -0.07709464f, 
    0.04282331f, 0.00273093f, -0.05507444f, 0.10914353f, -0.07614584f, 0.17269944f, 0.12388506f, 0.01756975f, 
    -0.01269797f, -0.01888192f, 0.11726771f, 0.06164701f, -0.02481853f, -0.02743259f, -0.06366865f, 0.17974505f, 
    -0.03197017f, 0.09066893f, 0.06226155f, -0.05384182f, 0.01563941f, -0.07794809f, 0.00076061f, -0.02010120f, 
    0.05110856f, -0.01719818f, 0.05954574f, 0.04411372f, 0.14219864f, 0.29961234f, -0.09640224f, -0.19596505f, 
    0.22151682f, 0.05840068f, -0.12058548f, 0.01238822f, -0.00302749f, 0.06868614f, 0.14937794f, 0.08001402f, 
    0.08005311f, -0.01319161f, -0.12525150f, 0.20162643f, -0.07428534f, 0.17118657f, 0.08784319f, 0.11898195f, 
    0.01415595f, 0.05723949f, 0.11406244f, -0.00115687f, 0.06094291f, -0.12325808f, 0.11118909f, -0.04679113f, 
    0.10546377f, 0.09885339f, 0.17008194f, 0.15017416f, -0.04874418f, 0.13685295f, -0.01633264f, 0.07205942f, 
    -0.03157971f, -0.07467917f, 0.04261182f, -0.10656713f, -0.00795869f, -0.11740586f, -0.02483831f, -0.03255021f, 
    -0.00778197f, 0.09320962f, -0.03981113f, 0.04143732f, -0.10581133f, -0.13512141f, 0.01072031f, 0.08564267f, 
    -0.03626598f, -0.03290009f, 0.13289498f, -0.03943116f, -0.07908712f, 0.04113838f, 0.12623571f, -0.02624858f, 
    0.05920897f, -0.03385457f, 0.03918417f, 0.36793160f, 0.01694073f, 0.08635202f, -0.00638262f, -0.06985246f, 
    -0.05490847f, 0.02443110f, -0.01601800f, -0.11191203f, -0.20442006f, -0.20164515f, 0.11132114f, 0.02348530f, 
    -0.09253822f, 0.01425674f, 0.01027177f, 0.05947511f, 0.08903673f, -0.02351550f, 0.18723223f, 0.13572432f, 
    0.00861985f, 0.06192081f, 0.12305294f, -0.12229574f, 0.05383182f, -0.00222537f, 0.08303566f, -0.08413928f, 
    -0.12685978f, 0.08664883f, 0.01149919f, 0.06592526f, 0.22042398f, -0.04401662f, -0.03183778f, 0.08270016f, 
    -0.17941526f, 0.07145061f, -0.01714041f, 0.00334800f, -0.03539563f, -0.08509691f, 0.02232694f, -0.03281303f, 
    -0.04347872f, 0.13882518f, 0.06753658f, -0.00863749f, -0.16537842f, 0.06377048f, 0.02859023f, 0.08012445f, 
    0.05785769f, -0.03232467f, 0.15922904f, 0.01125976f, 0.42647392f, 0.02667079f, 0.02853270f, -0.02975980f, 
    -0.08633503f, 0.02157320f, -0.11945746f, 0.03086315f, -0.06031684f, 0.03882983f, -0.03533612f, 0.21109626f, 
    0.55305988f, 0.05266966f, -0.22347419f, -0.06675433f, -0.10151820f, -0.01682492f, -0.02069126f, 0.12848632f, 
    -0.02149722f, 0.10934821f, 0.06188611f, 0.00953822f, 0.25496629f, -0.08845728f, -0.11162607f, 0.06467021f, 
    0.00927746f, 0.09262925f, 0.04312817f, 0.12184527f, 0.04143824f, -0.07092682f, -0.09635156f, 0.06736563f, 
    0.06509249f, 0.11319442f, 0.12863095f, 0.14383844f, 0.13991275f, 0.19561370f, 0.04071812f, 0.01428367f, 
    0.00643582f, 0.02972354f, 0.02510278f, 0.02340563f, -0.31349805f, -0.06066082f, -0.03203635f, -0.07840206f, 
    0.13859853f, -0.06182911f, -0.07382435f, 0.02625466f, 0.01561720f, 0.06362257f, 0.00322561f, -0.02840272f, 
    0.01591050f, 0.05755425f, 0.19233446f, 0.18336439f, 0.09407645f, -0.09296311f, 0.14801534f, -0.06469207f, 
    -0.00158619f, 0.00454685f, 0.02592645f, 0.19359362f, -0.24796674f, -0.00771902f, -0.10082102f, -0.02214147f, 
    -0.00117377f, -0.08680280f, 0.05500024f, 0.00064886f, 0.13212731f, 0.06661778f, 0.06797876f, 0.12860051f, 
    0.31634906f, 0.05071377f, 0.16043700f, 0.01125750f, 0.12964123f, -0.03915663f, 0.02142663f, 0.00714044f, 
    -0.02381548f, 0.03684608f, 0.08932978f, -0.16967411f, -0.11496814f, -0.01270420f, -0.03507565f, 0.20478088f, 
    0.12777951f, 0.14363286f, -0.05997665f, 0.03386938f, -0.01986673f, 0.02515459f, 0.07184181f, 0.05146297f, 
    -0.09964707f, 0.12600549f, -0.04414026f, -0.21830200f, 0.07260165f, -0.04896066f, -0.01265645f, -0.10904615f, 
    -0.01111361f, -0.06439761f, -0.09734455f, 0.00877016f, 0.12384595f, 0.18371211f, 0.21757856f, -0.11578993f, 
    -0.07577558f, 0.01037562f, 0.02394513f, 0.01956448f, 0.02135253f, 0.09032570f, 0.11820426f, 0.02081944f, 
    -0.07177843f, 0.04753116f, -0.19386008f, 0.09143274f, 0.06178275f, 0.06829723f, 0.02882758f, -0.02420695f, 
    -0.06409489f, -0.04095092f, 0.04929279f, 0.09336319f, 0.33390996f, 0.11001737f, -0.10827398f, 0.09475293f, 
    0.11012976f, -0.01651749f, 0.01469558f, 0.02498727f, -0.02599490f, -0.10051111f, -0.04953146f, -0.00642322f, 
    -0.02907781f, 0.23518869f, -0.05811789f, 0.32288501f, -0.02014492f, -0.02687506f, -0.13037392f, 0.01531443f, 
    0.11687762f, 0.00122799f, -0.05064520f, 0.14042617f, -0.06213095f, 0.16307944f, 0.20467202f, -0.20633771f, 
    0.07685466f, -0.07227764f, -0.03475657f, -0.01889230f, 0.00435618f, 0.00462565f, -0.07637031f, 0.03599496f, 
    0.12141483f, 0.17933336f, 0.01243000f, -0.03465476f, -0.07464597f, 0.03481103f, -0.06470080f, -0.06340579f, 
    0.08889933f, -0.02396393f, -0.01509474f, -0.00640151f, 0.28953877f, 0.12294494f, 0.09520385f, -0.01760580f, 
    0.17831835f, 0.11787403f, -0.01002611f, 0.03738273f, -0.03734285f, -0.02567788f, 0.05844620f, 0.00383825f, 
    0.26782754f, 0.14688337f, -0.08208425f, 0.32423446f, 0.11642462f, -0.06598902f, 0.09122151f, 0.03079817f, 
    0.04326178f, -0.06086398f, 0.12222996f, 0.05291337f, -0.22289559f, -0.06762872f, 0.09265024f, 0.01851023f, 
    0.08178323f, 0.04031441f, 0.05248450f, -0.00591751f, 0.01760793f, 0.00190318f, 0.08143604f, -0.01423656f, 
    0.10675861f, 0.01327321f, 0.02673782f, 0.07651451f, 0.00751111f, 0.04432538f, 0.15191542f, 0.11651111f, 
    0.06751837f, -0.01705826f, 0.10718708f, -0.09106142f, -0.32809776f, -0.19429222f, 0.00971593f, 0.02282787f, 
    0.01531138f, 0.07842461f, -0.01678972f, -0.14299072f, 0.04782005f, 0.02163182f, 0.06739180f, -0.05238422f, 
    0.08956928f, -0.18743649f, -0.03771589f, -0.05077510f, -0.00279232f, 0.01718064f, -0.00088904f, 0.10202679f, 
    0.05347587f, 0.05714423f, -0.02168019f, 0.08067715f, -0.29123417f, -0.08047644f, 0.12110531f, 0.09377403f, 
    -0.11930917f, -0.16911259f, 0.20626283f, -0.02413876f, 0.01050820f, -0.03656485f, 0.01850781f, 0.05206332f, 
    -0.30885193f, 0.14387283f, -0.03321254f, -0.13068366f, 0.01922945f, -0.09156172f, -0.01264562f, -0.15976538f, 
    0.03106380f, -0.05772337f, 0.04965603f, 0.07805367f, -0.10386597f, 0.05241783f, 0.32119337f, 0.03811594f, 
    0.01016060f, -0.09968090f, 0.05856531f, 0.00053724f, 0.07560328f, 0.00323524f, 0.13954152f, 0.03286626f, 
    -0.06203005f, 0.04558080f, 0.04314673f, -0.08945512f, 0.12632565f, -0.04964509f, 0.02562594f, -0.07899756f, 
    -0.00849897f, -0.01729335f, 0.02771549f, -0.00315439f, 0.05085186f, 0.19250754f, -0.04873821f, 0.10032278f, 
    -0.06925865f, 0.08871230f, -0.06628944f, 0.10978646f, 0.06872137f, 0.02167575f, -0.06434633f, -0.00421376f, 
    -0.18086179f, 0.17963712f, -0.03733527f, -0.18703526f, 0.03334020f, -0.09605742f, 0.12018253f, -0.06188710f, 
    0.05384221f, -0.00245784f, -0.00624043f, -0.00478149f, -0.06828015f, 0.06777516f, -0.09849051f, -0.08853569f, 
    0.03432760f, 0.03646095f, 0.04692132f, -0.07233776f, -0.15176867f, 0.00517337f, -0.04566732f, 0.01077961f, 
    0.03887156f, -0.05300921f, 0.08236159f, 0.16703376f, 0.09680144f, 0.04985818f, 0.03825732f, 0.13132361f, 
    0.10462378f, 0.06429201f, -0.08363131f, 0.05934375f, -0.27939028f, 0.25936487f, 0.03173388f, -0.12231206f, 
    0.06780817f, -0.00953612f, -0.00497634f, -0.04295383f, 0.03704705f, 0.01103359f, -0.01908498f, 0.04574711f, 
    0.00084791f, -0.08939854f, 0.07298114f, 0.03526705f, 0.16641015f, 0.02246010f, -0.02549090f, -0.02699626f, 
    0.02299664f, -0.00056590f, -0.00959376f, 0.06006880f, -0.40553647f, -0.13207714f, -0.03146713f, 0.03275440f, 
    0.09705289f, 0.01041442f, 0.09891552f, -0.10731123f, 0.05905020f, 0.12387162f, 0.04308278f, -0.01569274f, 
    -0.21464817f, 0.02541485f, 0.16569406f, 0.16787803f, 0.11544515f, 0.01153460f, -0.00436167f, 0.02016005f, 
    -0.06234639f, -0.06377190f, 0.02140679f, -0.06449854f, -0.19419836f, 0.29846153f, -0.07813912f, 0.02557836f, 
    0.01661064f, 0.09091033f, -0.14091161f, -0.01628281f, -0.01578665f, 0.03483463f, 0.01602533f, -0.03408783f, 
    0.32249224f, 0.27577794f, 0.02296310f, 0.01163772f, 0.18823491f, 0.09283062f, 0.01225507f, -0.01000378f, 
    0.08203304f, -0.00332054f, -0.03289114f, -0.00083155f, -0.01838803f, 0.02868067f, 0.01421202f, -0.02052097f, 
    0.07737859f, 0.01514355f, -0.08838331f, 0.02324197f, 0.00605533f, 0.00330263f, -0.13295235f, 0.02306578f, 
    -0.05901417f, -0.07513344f, 0.16097941f, 0.06718046f, 0.03790085f, 0.01404677f, 0.06634288f, -0.03037808f, 
    0.11620744f, 0.04306312f, 0.11783744f, 0.13100871f, -0.16028647f, -0.11241091f, -0.00684782f, -0.08950694f, 
    -0.11863016f, -0.09729990f, 0.06503990f, -0.10266065f, -0.05385324f, 0.17615499f, 0.18715286f, 0.13530615f, 
    -0.03753049f, -0.05512994f, -0.15676011f, 0.26707658f, 0.05903512f, 0.08788181f, -0.03194474f, 0.06972089f, 
    0.14324537f, 0.12492049f, 0.00936707f, 0.00384100f, -0.28210938f, -0.11966900f, 0.23794144f, 0.07903828f, 
    0.12413158f, 0.04264321f, 0.05539894f, -0.12067982f, -0.07859033f, 0.04093476f, 0.00880260f, 0.01526701f, 
    0.16328280f, 0.07870261f, -0.07195110f, 0.13655537f, -0.01612248f, 0.05823712f, 0.00127259f, -0.00007091f, 
    -0.02207543f, 0.01760327f, -0.03875811f, -0.06341855f, -0.12382044f, 0.13719679f, 0.10327888f, -0.00102344f, 
    0.02965605f, 0.03416775f, -0.01381086f, -0.06174784f, 0.10939402f, -0.03764980f, 0.04491231f, -0.03312659f, 
    0.03820567f, 0.11886047f, -0.08882477f, -0.02941990f, -0.02183772f, 0.07869816f, 0.05600649f, -0.03228051f, 
    -0.15536426f, 0.00327982f, 0.09874873f, 0.14098260f, 0.08870164f, 0.22185858f, 0.11061384f, -0.04478340f, 
    -0.02983885f, 0.00212025f, 0.00946083f, 0.00366050f, -0.04526707f, -0.06171411f, -0.06244903f, 0.07187133f, 
    -0.11559465f, 0.16705225f, 0.28412011f, -0.11913988f, 0.01871631f, -0.15130140f, 0.00811265f, -0.03915556f, 
    -0.05397448f, 0.01569604f, 0.06718349f, 0.00516043f, -0.20259200f, 0.17081733f, -0.03564381f, 0.12076853f, 
    -0.08363601f, 0.14848234f, -0.22107534f, 0.09043118f, -0.08219247f, 0.12676017f, -0.10745268f, -0.05290480f, 
    0.44299906f, 0.29335406f, 0.20909405f, -0.03381375f, -0.03527997f, 0.16320227f, -0.02628699f, 0.00131571f, 
    0.07911336f, -0.08229365f, -0.02885749f, -0.11007248f, 0.23738641f, 0.31858212f, -0.00402944f, -0.08135729f, 
    -0.01596766f, -0.04402898f, 0.00868237f, 0.05488147f, -0.12024230f, -0.13228633f, 0.08970918f, -0.07165341f, 
    -0.14433886f, 0.13027965f, 0.07380267f, 0.10822318f, 0.18341613f, -0.01954302f, -0.01379639f, 0.04781706f, 
    0.14474821f, 0.08397222f, 0.04143542f, -0.07618147f, 0.14967898f, 0.02852170f, 0.15409960f, -0.17694175f, 
    0.14245707f, 0.03431700f, 0.07653853f, -0.10455831f, 0.03527607f, 0.12621118f, -0.12905534f, 0.04215708f, 
    -0.18100603f, -0.04164917f, 0.00946966f, 0.07880442f, 0.00120812f, 0.02553473f, -0.09201701f, -0.03018958f, 
    0.00856639f, -0.00294047f, -0.02957787f, -0.19868048f, 0.17509314f, 0.15979232f, 0.23001334f, 0.03012257f, 
    0.17513581f, 0.00680731f, -0.05852808f, -0.01099642f, 0.07676022f, 0.03230373f, 0.07687824f, -0.03664993f, 
    0.00300577f, -0.03811102f, -0.04018564f, 0.04945503f, -0.06771691f, 0.03695938f, -0.00647739f, -0.05948631f, 
    -0.04197115f, 0.04997665f, 0.05950601f, 0.02564703f, -0.35535747f, -0.15799625f, -0.03310335f, 0.04275098f, 
    -0.09774460f, -0.07345404f, 0.06313299f, -0.05459061f, -0.01020454f, 0.02275397f, 0.00366801f, -0.14737493f, 
    -0.08344908f, 0.07480936f, 0.15276758f, -0.12048656f, 0.15771279f, -0.03902219f, -0.08054155f, -0.12187102f, 
    0.01311170f, -0.01387253f, 0.02295109f, -0.02553191f, 0.03475044f, 0.00335010f, -0.04123106f, -0.02618471f, 
    -0.00190950f, -0.03056435f, 0.01705432f, -0.08072494f, 0.02078824f, -0.11397516f, 0.11731344f, -0.02364162f, 
    -0.15500766f, 0.02039412f, -0.10983109f, 0.27475911f, 0.00545214f, 0.15293489f, 0.05801665f, -0.07488793f, 
    -0.00946417f, -0.07257166f, -0.00900449f, -0.13839208f, 0.43003166f, 0.12318990f, 0.09919147f, -0.14002274f, 
    0.12446163f, 0.04134238f, -0.13362844f, 0.05861805f, 0.08285975f, 0.05415747f, -0.00276837f, 0.16481926f, 
    0.09169803f, -0.08289327f, -0.06990628f, -0.15453960f, -0.08823412f, -0.03035473f, 0.01005395f, 0.03909390f, 
    -0.08864646f, -0.08191455f, 0.09495602f, 0.06572220f, 0.30521494f, 0.30073124f, 0.03461095f, 0.05613493f, 
    0.08410226f, 0.05956489f, 0.05487231f, 0.01231919f, -0.10990962f, 0.03130509f, -0.14242022f, -0.14931044f, 
    0.13830756f, 0.04048694f, 0.11824089f, 0.10895674f, -0.03467500f, -0.00613738f, 0.00650764f, 0.02050005f, 
    0.15679544f, 0.00445606f, 0.05923739f, -0.06156215f, -0.00198174f, 0.03529496f, 0.07891936f, 0.12749712f, 
    0.05423971f, -0.05761544f, -0.00308006f, -0.10464770f, 0.01190198f, 0.07044940f, -0.10891926f, 0.03343694f, 
    0.06988399f, 0.01347147f, -0.02160344f, 0.15472426f, 0.15932992f, 0.02337868f, 0.03727517f, -0.08116300f, 
    -0.00957769f, 0.07134694f, -0.10411605f, 0.02053453f, -0.16456805f, -0.07349666f, 0.09836502f, 0.10792253f, 
    0.06165164f, -0.06263959f, 0.07522663f, -0.00495099f, 0.02862359f, 0.07951316f, 0.13856755f, -0.15333681f, 
    -0.40582007f, -0.07123093f, 0.31790316f, 0.02052242f, -0.02875180f, -0.02036671f, 0.08889385f, -0.12204458f, 
    -0.03343561f, -0.02649692f, -0.05251076f, -0.06794114f, 0.10135435f, 0.15216060f, 0.13876629f, -0.17125016f, 
    -0.02069531f, -0.16390648f, -0.04487628f, 0.00142947f, -0.09541759f, 0.06684875f, 0.01853365f, -0.06539088f, 
    0.02812145f, -0.02143305f, -0.04165355f, -0.00539709f, -0.01016938f, 0.01741822f, -0.03617702f, 0.03544705f, 
    0.03985864f, -0.04819418f, 0.04097982f, -0.05223177f, 0.01209862f, 0.03984145f, 0.02574638f, -0.01634938f, 
    -0.03483317f, -0.05169200f, 0.01869648f, 0.01999341f, 0.00367810f, 0.02671755f, -0.01053445f, -0.00712322f, 
    -0.01873067f, 0.02112349f, -0.05606529f, -0.05012083f, -0.04129457f, 0.01867577f, 0.04221737f, -0.01481259f, 
    0.03335804f, 0.03988403f, -0.04939743f, -0.01622753f, -0.03535343f, -0.00365306f, -0.00277588f, -0.00553198f, 
    0.02817884f, 0.03612651f, -0.05300906f, 0.02922006f, -0.04066353f, -0.01841033f, -0.04142738f, 0.01245017f, 
    0.02059021f, 0.04402386f, -0.03164425f, 0.03807066f, 0.02304547f, -0.04313682f, -0.02658112f, -0.04848164f, 
    -0.04595855f, 0.01669618f, 0.01325787f, -0.01715366f, 0.00372095f, 0.01615993f, -0.00970354f, -0.04264575f, 
    0.03451001f, 0.03964430f, 0.03542159f, -0.03055888f, -0.00810963f, -0.00133985f, 0.00204606f, 0.02098379f, 
    -0.02498426f, 0.01991828f, -0.04259795f, -0.04263670f, -0.00346579f, -0.01604438f, -0.02366983f, -0.01355560f, 
    0.02132612f, -0.04833287f, -0.05237276f, 0.00394435f, -0.01251453f, -0.04451042f, 0.03615072f, -0.00372922f, 
    -0.02188802f, -0.02501797f, -0.03135444f, 0.03886106f, 0.01228964f, 0.01220377f, 0.03040397f, -0.05381376f, 
    0.00847414f, -0.02428877f, 0.00458355f, 0.01533433f, -0.01363331f, -0.01430739f, -0.03021315f, 0.00079019f, 
    -0.02643174f, 0.02788983f, 0.02957142f, 0.02922551f, -0.00948374f, 0.01875351f, -0.03079497f, -0.03364710f, 
    0.03646056f, -0.05540355f, -0.04591865f, -0.04578627f, -0.01020598f, -0.01908556f, 0.04437722f, 0.03930196f, 
    0.04310462f, -0.04157566f, -0.00150540f, -0.02947945f, -0.03353727f, -0.00576929f, -0.04312860f, 0.03373854f, 
    0.02646050f, 0.00712329f, -0.02275094f, 0.00138794f, -0.01337403f, 0.00264534f, -0.04697412f, -0.00517794f, 
    0.03627729f, -0.05106017f, -0.05032258f, -0.02984778f, 0.02777175f, 0.00295184f, 0.02801807f, -0.03825394f, 
    -0.02979482f, 0.03802865f, -0.02035594f, -0.03900693f, -0.02846736f, 0.02512066f, 0.02504238f, -0.01900134f, 
    -0.05678682f, -0.02354497f, 0.03088939f, -0.03539870f, -0.00147991f, -0.00067639f, 0.02442957f, -0.00357413f, 
    -0.02378275f, -0.03485163f, -0.05062426f, 0.02631319f, -0.03807746f, 0.00264644f, 0.04000612f, -0.04149039f, 
    -0.01582662f, 0.00069319f, -0.01056753f, -0.05298356f, -0.05138777f, 0.03996379f, -0.04752812f, -0.04873621f, 
    0.00199913f, 0.01212190f, -0.04191622f, -0.03349008f, 0.01344588f, -0.00865151f, -0.02339661f, 0.00256823f, 
    -0.01371208f, -0.02820932f, -0.00182770f, 0.00230123f, 0.02073253f, 0.02234134f, -0.01443468f, -0.00759921f, 
    -0.02021252f, 0.00561247f, -0.04088410f, -0.05231696f, -0.02138139f, 0.02873944f, 0.02616310f, 0.04395068f, 
    -0.03123165f, -0.03089547f, -0.04513938f, -0.01288885f, 0.02377448f, -0.04297328f, -0.02954867f, -0.02453656f, 
    0.00881086f, 0.03388368f, -0.01504163f, 0.01160330f, 0.01058022f, -0.02442110f, -0.01789934f, -0.03587103f, 
    -0.02091183f, -0.03667237f, -0.00659562f, -0.03484883f, 0.00813412f, -0.05302993f, -0.01662904f, 0.02140731f, 
    0.00631777f, -0.05669045f, -0.01732787f, -0.05316150f, -0.04986729f, -0.00892438f, 0.01180462f, -0.00246514f, 
    -0.00958479f, -0.05069626f, 0.01920182f, 0.04186153f, -0.01759698f, -0.00593624f, 0.00592352f, 0.01028968f, 
    -0.03726172f, -0.00584735f, -0.04724452f, 0.01417522f, -0.04616101f, -0.02965526f, 0.03096256f, 0.01986694f, 
    0.02796186f, -0.00193568f, 0.01284831f, -0.01186361f, 0.00880350f, -0.04108333f, -0.01359351f, 0.00929000f, 
    0.02158097f, 0.01103766f, 0.02254732f, 0.01437896f, -0.04585591f, 0.02794619f, -0.01931604f, -0.02919817f, 
    -0.04215880f, -0.00063145f, -0.05236438f, -0.04405081f, 0.01535961f, -0.02789801f, -0.03277798f, 0.02958090f, 
    0.02065401f, 0.00841422f, -0.02025104f, -0.01260601f, -0.00989014f, 0.01062671f, 0.01688156f, -0.05166360f, 
    -0.01535249f, -0.05591631f, -0.01521156f, 0.01109434f, -0.04875057f, 0.03299614f, 0.04437169f, 0.01614296f, 
    -0.02826312f, 0.02498674f, 0.02107734f, 0.03404145f, -0.02075250f, 0.03572532f, -0.00674315f, 0.01368504f, 
    -0.04884966f, -0.02043702f, 0.00481539f, 0.03596635f, 0.00647703f, -0.03407857f, -0.00490261f, -0.04997274f, 
    -0.02220902f, 0.01758446f, 0.02440323f, 0.04213437f, -0.03701453f, -0.02128751f, 0.00161016f, 0.00468393f, 
    -0.00405146f, -0.04616777f, -0.02784913f, 0.03210997f, 0.01144004f, -0.02360236f, -0.02500749f, 0.01055571f, 
    -0.04876444f, -0.02021466f, -0.04975310f, 0.02849965f, -0.00271188f, -0.03848099f, 0.02175632f, 0.03795898f, 
    -0.02773898f, -0.03342899f, 0.01420454f, 0.02848766f, 0.02618795f, -0.01274381f, 0.04464328f, -0.04476929f, 
    0.03149709f, -0.02803006f, -0.04111493f, 0.00806041f, -0.04383195f, 0.01565013f, 0.00993142f, -0.01693716f, 
    0.00210095f, -0.00127864f, -0.03065296f, -0.04209044f, -0.00713807f, 0.02351951f, 0.03648871f, -0.00936695f, 
    -0.02685264f, -0.04700493f, 0.00410355f, 0.02269181f, 0.03766613f, -0.02953224f, -0.04846590f, 0.00477470f, 
    -0.00310268f, 0.00152018f, -0.03550269f, -0.03043547f, 0.01040015f, 0.01301015f, -0.00960215f, -0.02927935f, 
    0.02893863f, 0.02722736f, -0.02790685f, -0.00785235f, -0.02308867f, -0.03626034f, 0.03414835f, 0.02962176f, 
    -0.04265815f, -0.05313739f, 0.01404525f, 0.01524470f, -0.02395457f, -0.02291331f, 0.03653678f, -0.02428450f, 
    0.07557513f, 0.04267702f, 0.01347405f, -0.26034507f, 0.13731220f, 0.06791384f, 0.16770245f, 0.25179109f, 
    0.11853406f, 0.10726193f, 0.08159290f, 0.05450750f, -0.58106738f, 0.06865765f, -0.10319567f, -0.03743156f, 
    0.10706282f, -0.00348574f, -0.03863303f, 0.07618434f, -0.02396233f, 0.04806772f, -0.10244402f, 0.04114646f, 
    0.13953742f, 0.10493228f, -0.01559948f, -0.25041440f, 0.13876319f, -0.01942324f, 0.01027306f, -0.06324062f, 
    0.06055781f, 0.01830616f, -0.02907396f, 0.07093173f, -0.20617083f, 0.11270971f, 0.05493309f, -0.07896366f, 
    -0.02761127f, -0.00009756f, -0.03821528f, 0.05466726f, 0.10965876f, -0.07554291f, -0.09596470f, -0.03114277f, 
    0.28602824f, -0.21432823f, -0.26050398f, 0.18339090f, 0.04087847f, 0.15322587f, 0.09408305f, -0.00019476f, 
    -0.05698963f, 0.05538640f, -0.04526692f, 0.12060037f, 0.08560584f, -0.22453944f, 0.09579492f, 0.15505865f, 
    0.02954421f, 0.06866676f, 0.02925309f, 0.11409743f, 0.15064010f, 0.00980616f, -0.13615063f, 0.02104137f, 
    0.34702769f, -0.09811222f, -0.15663265f, 0.43823355f, 0.01710015f, -0.05994911f, -0.07444256f, -0.10023250f, 
    -0.04780936f, -0.11715712f, -0.03918340f, 0.06483560f, 0.03156816f, 0.10624757f, -0.04607040f, 0.01583713f, 
    0.11101987f, -0.12620415f, -0.00991057f, 0.12612014f, 0.01982014f, 0.09984251f, 0.03815184f, 0.11985990f, 
    -0.25681990f, 0.01483703f, 0.25006205f, 0.05204634f, -0.13224235f, -0.07750984f, -0.15594603f, -0.02060840f, 
    0.07135230f, 0.03491420f, -0.01191954f, -0.09059081f, -0.12294355f, -0.02558339f, 0.08226011f, -0.13415042f, 
    0.02497456f, 0.02869006f, -0.08860295f, -0.09332466f, 0.02665205f, -0.02944057f, 0.05131212f, 0.02968467f, 
    -0.17395888f, -0.05431147f, 0.23830470f, -0.07174502f, -0.03503528f, 0.06587721f, 0.17361461f, 0.00530616f, 
    -0.03594434f, -0.04804162f, -0.05036544f, 0.00714117f, 0.09018376f, 0.24191746f, -0.32290435f, 0.01225666f, 
    0.05475203f, 0.05332287f, 0.03583400f, 0.02193954f, -0.12620156f, -0.12253200f, -0.06398149f, 0.03455009f, 
    0.20375170f, -0.01779810f, -0.16728170f, -0.23217931f, 0.08380145f, 0.02478491f, 0.07983125f, 0.00770264f, 
    -0.07542313f, 0.01643799f, 0.05594063f, 0.02424555f, -0.01090562f, -0.30801252f, -0.08022708f, -0.12344506f, 
    -0.15376443f, 0.03842307f, 0.14388222f, -0.17583166f, 0.03524796f, 0.07879801f, -0.05594472f, 0.03628987f, 
    -0.04335648f, -0.13100259f, 0.04548485f, -0.06922717f, -0.07488877f, -0.02951321f, 0.13294081f, -0.05307863f, 
    -0.01796577f, 0.05421059f, 0.10847109f, 0.05772709f, -0.33869895f, 0.07559542f, -0.06710691f, -0.12943289f, 
    0.03656049f, -0.01458357f, -0.00776980f, 0.02855323f, -0.04653796f, -0.10878914f, 0.01526250f, 0.04996542f, 
    -0.03072098f, -0.22995082f, 0.10598078f, -0.09146929f, 0.10525997f, 0.01663421f, -0.07828416f, 0.08778784f, 
    0.09705798f, 0.01966205f, -0.07241653f, -0.04561222f, -0.00890647f, -0.03328255f, -0.05265886f, -0.18817258f, 
    0.17323697f, 0.14315569f, 0.06573449f, 0.08631147f, 0.10446772f, 0.06601274f, -0.08293974f, 0.19440113f, 
    -0.34504175f, 0.13490525f, -0.06855029f, -0.15349662f, 0.04475846f, 0.06663311f, -0.09668902f, 0.15000756f, 
    0.02300132f, -0.08548998f, -0.00489792f, 0.01463907f, -0.01145542f, 0.10068904f, 0.09932530f, 0.00869466f, 
    -0.00283359f, 0.03892015f, -0.03644996f, 0.08672356f, -0.02718352f, -0.05054981f, 0.07628538f, 0.06660711f, 
    -0.11902396f, 0.24669172f, -0.04634836f, 0.02674815f, 0.09837519f, 0.16143325f, 0.05002657f, -0.02155809f, 
    0.02090138f, -0.04917912f, 0.15014981f, -0.03657799f, -0.07241351f, 0.11997032f, 0.09251902f, 0.08579391f, 
    0.07321062f, -0.00767471f, 0.07161302f, 0.00954115f, 0.05135605f, 0.08122922f, 0.08888624f, 0.12607177f, 
    -0.14295653f, 0.12257919f, 0.05084690f, 0.17949319f, 0.06727682f, -0.12562513f, -0.19741693f, -0.08810026f, 
    -0.04663258f, -0.00187535f, 0.05612864f, 0.05186668f, -0.03532692f, -0.11802252f, 0.09938654f, -0.02284079f, 
    0.15005298f, 0.05354614f, 0.07670847f, 0.01904268f, 0.04753973f, 0.04277512f, 0.20614049f, 0.19067414f, 
    0.02730280f, -0.20279545f, 0.21080416f, 0.28927284f, -0.10631073f, -0.09556254f, -0.02144444f, -0.03851751f, 
    0.18777578f, 0.04424928f, 0.16732372f, -0.07822052f, 0.02436909f, -0.04757172f, -0.16354068f, 0.11433598f, 
    -0.00499745f, 0.20196928f, 0.15655161f, 0.00306162f, 0.05101437f, -0.17949994f, 0.19066055f, 0.12607756f, 
    -0.36561221f, 0.03743403f, 0.16508825f, -0.03959630f, 0.05961026f, 0.09817391f, -0.01544927f, 0.08967849f, 
    0.06716312f, 0.05886902f, 0.07085866f, 0.09695335f, 0.22873241f, -0.00498792f, -0.07046387f, 0.17178519f, 
    -0.02663846f, -0.14313069f, -0.13604467f, -0.06349637f, -0.03256221f, -0.10771696f, -0.01864442f, 0.01573315f, 
    0.11888913f, -0.16073242f, -0.08021447f, 0.04658314f, 0.05610588f, 0.16228424f, 0.07593161f, 0.02044785f, 
    0.02822601f, 0.01947547f, 0.14717352f, 0.07965326f, -0.21744141f, -0.06404774f, 0.04915430f, -0.23628281f, 
    0.19374405f, 0.06274349f, -0.03166293f, 0.05040090f, 0.02272215f, 0.12099176f, -0.07215183f, 0.03447425f, 
    -0.13076606f, 0.11362642f, -0.00186784f, -0.39924449f, 0.09902690f, -0.04668885f, -0.06191077f, -0.02490345f, 
    0.06525909f, -0.07217242f, 0.00058793f, 0.00353712f, 0.20137829f, -0.19541468f, -0.06882872f, -0.05508915f, 
    -0.13126217f, -0.01142033f, 0.08816773f, -0.03651955f, 0.01249478f, -0.01401199f, -0.01949325f, -0.10579402f, 
    -0.01078569f, -0.04637601f, -0.01733024f, 0.00147832f, 0.04239348f, 0.01054971f, -0.01423791f, -0.03725351f, 
    0.04391047f, 0.02362143f, 0.03072412f, -0.05061733f, 0.01346283f, -0.01968577f, 0.01030208f, 0.02009835f, 
    -0.03010232f, 0.02186940f, -0.02867087f, -0.04618277f, -0.05028195f, -0.02653834f, -0.00476646f, -0.00569212f, 
    -0.05492475f, -0.00591775f, 0.01117378f, -0.00713235f, 0.00569820f, 0.02419161f, 0.01665112f, -0.03994494f, 
    0.02757505f, -0.03863196f, 0.00143072f, -0.04721338f, 0.01496657f, -0.02271287f, -0.04787689f, 0.00660530f, 
    -0.00706945f, -0.02370981f, 0.01647046f, -0.00028382f, -0.04928024f, 0.01741413f, -0.04250892f, -0.04213158f, 
    -0.01601467f, -0.03602914f, -0.05450146f, 0.03274975f, 0.04089049f, -0.04301116f, 0.02654290f, 0.01758192f, 
    0.04329308f, -0.04404085f, -0.01458079f, -0.00257828f, 0.01231472f, 0.04216767f, -0.02521107f, 0.01206244f, 
    -0.03670585f, 0.03164399f, -0.03916330f, 0.04465934f, -0.01070423f, 0.02394555f, -0.04589811f, -0.04286832f, 
    -0.04301595f, 0.03129613f, 0.01655267f, -0.03638845f, -0.01561415f, -0.04711578f, -0.04742418f, -0.00397298f, 
    -0.05024103f, -0.01333672f, 0.04404755f, 0.04414235f, -0.03166217f, 0.01626180f, 0.03774669f, 0.04097520f, 
    -0.05505225f, 0.02394362f, -0.01825618f, 0.02498698f, -0.03675444f, 0.00829303f, 0.02849301f, -0.02870749f, 
    0.04055518f, -0.01097675f, 0.00008043f, -0.02598266f, -0.05192473f, -0.01411555f, -0.04176190f, 0.03733210f, 
    -0.00464006f, -0.05055137f, 0.03064458f, 0.03881839f, 0.02104324f, 0.01562068f, 0.01772896f, -0.02172641f, 
    -0.02049471f, -0.03972689f, -0.00873159f, -0.00922912f, 0.03673404f, -0.00394642f, -0.02019644f, 0.03188975f, 
    0.03714149f, -0.00318180f, -0.00300784f, 0.00956565f, -0.03711116f, 0.01775359f, -0.03938282f, 0.04159197f, 
    -0.03610194f, -0.04482314f, -0.00866351f, -0.02642033f, -0.04874883f, -0.03576563f, -0.04886745f, -0.04918302f, 
    0.01241618f, -0.00801942f, -0.04862842f, -0.00157877f, -0.02965956f, -0.05451255f, -0.02739939f, -0.02384847f, 
    0.03885430f, 0.03079327f, -0.03682254f, 0.02582906f, 0.01241487f, 0.01530538f, -0.00963889f, -0.02744061f, 
    0.01705170f, 0.00083405f, -0.04202427f, -0.03211287f, -0.00623264f, 0.00495493f, 0.01586657f, -0.02477934f, 
    0.01615359f, -0.02179322f, -0.03672844f, -0.04963505f, -0.01814399f, -0.05114379f, -0.03762755f, 0.03368304f, 
    -0.04315936f, 0.02550027f, -0.00962268f, -0.04144917f, 0.02180152f, 0.02224317f, -0.02071754f, 0.03472600f, 
    0.03745440f, 0.00536461f, -0.02676155f, -0.04278444f, 0.02942424f, -0.05243015f, -0.03319989f, 0.01866104f, 
    0.01712409f, -0.02317454f, 0.03935110f, -0.02420698f, -0.03379704f, 0.00949493f, -0.03470967f, -0.00964354f, 
    0.04069344f, 0.03238428f, -0.01638549f, -0.04969696f, 0.04061222f, 0.00684799f, -0.02405368f, -0.02203465f, 
    -0.05208901f, 0.00620867f, 0.01475203f, -0.00905360f, -0.04613375f, 0.02257566f, 0.00387212f, 0.02869730f, 
    -0.02998132f, 0.04291416f, -0.02225604f, 0.02955607f, -0.04329532f, 0.01686304f, 0.01068282f, 0.03720517f, 
    0.01027310f, -0.01101356f, -0.03124469f, -0.00326885f, -0.03519677f, -0.00870667f, 0.01837486f, -0.05186742f, 
    -0.04028639f, -0.04414615f, 0.00758374f, -0.03169079f, 0.01447485f, -0.00347116f, -0.01414483f, 0.03302737f, 
    0.01867148f, 0.01720395f, -0.02684833f, 0.00711550f, -0.00878807f, -0.01771956f, -0.04856740f, -0.01523256f, 
    -0.03674117f, 0.04227773f, -0.03317716f, -0.01347696f, 0.00056577f, -0.00221733f, 0.02350227f, -0.05102643f, 
    -0.02170798f, 0.04217071f, 0.03165856f, 0.01308148f, 0.01022186f, -0.02160921f, -0.05393282f, 0.00603255f, 
    -0.00540174f, -0.04572656f, 0.03067869f, 0.03879843f, 0.00193733f, 0.03400748f, -0.01367234f, 0.00075965f, 
    0.00445279f, -0.05045256f, -0.02894202f, 0.00397256f, -0.03754126f, 0.00887042f, -0.00698117f, -0.01323182f, 
    0.01855467f, 0.01111693f, -0.01320577f, -0.01902586f, -0.00474951f, -0.05429721f, -0.03459641f, -0.00454077f, 
    -0.04713799f, -0.03444649f, 0.04361107f, -0.00974278f, -0.03233470f, 0.01244803f, -0.02768852f, 0.03742973f, 
    -0.03642021f, -0.04477270f, -0.00226765f, -0.04904365f, -0.02388856f, -0.02681315f, -0.05169629f, -0.04021307f, 
    0.03093817f, 0.02351694f, 0.00952511f, 0.02533401f, 0.04110642f, -0.00614889f, 0.01358399f, 0.03499458f, 
    -0.05255829f, -0.02938074f, -0.02285874f, -0.02339975f, -0.05138936f, 0.00417574f, 0.02090443f, 0.02858371f, 
    -0.00079841f, -0.00845254f, -0.02861727f, 0.03488066f, -0.03570477f, -0.01228860f, 0.04545097f, 0.03896968f, 
    0.02882529f, -0.00623066f, 0.03713951f, -0.04841410f, 0.04196751f, -0.02643558f, 0.00268295f, 0.02606534f, 
    0.01029023f, -0.02561670f, 0.04561318f, -0.01377816f, -0.03163154f, -0.00954677f, -0.00636596f, -0.01687968f, 
    0.01844466f, 0.00659866f, -0.03239384f, -0.02689849f, -0.04524513f, 0.03906551f, 0.03236879f, -0.03899778f, 
    0.01065262f, 0.02921747f, -0.01706620f, -0.02216544f, -0.05359288f, 0.02513559f, -0.01617344f, -0.03706308f, 
    0.00769674f, -0.04534280f, -0.05551229f, 0.01512142f, 0.01383564f, 0.00401392f, 0.03509047f, 0.00797742f, 
    -0.04299184f, -0.01067232f, -0.05344529f, 0.00408112f, -0.00645191f, -0.00870783f, -0.03835537f, -0.02964388f, 
    -0.01922435f, -0.03974304f, -0.04837602f, 0.03607840f, -0.04327590f, -0.05177167f, -0.04970872f, -0.02878144f, 
    -0.03981165f, 0.03833215f, 0.00313182f, 0.04120187f, 0.01227689f, 0.00258324f, 0.02616269f, 0.04009435f, 
    -0.24448733f, -0.28247437f, 0.02968349f, -0.03025057f, -0.10780822f, -0.11014156f, -0.04390378f, -0.01161685f, 
    0.12720115f, -0.02926036f, 0.04407010f, 0.00945219f, 0.32078776f, -0.07979061f, -0.06822511f, 0.10891585f, 
    -0.00941775f, 0.01233907f, 0.05742162f, -0.06728701f, 0.03508285f, 0.04952265f, 0.10674154f, -0.02438563f, 
    -0.48786747f, -0.14055857f, -0.14597981f, 0.03350048f, 0.01970244f, 0.07951777f, -0.13236496f, -0.02452298f, 
    -0.08839487f, 0.06767407f, 0.02844336f, -0.13472164f, 0.35009617f, 0.21227276f, -0.13480474f, 0.04650011f, 
    0.03870343f, 0.04364209f, -0.08182035f, 0.00840857f, -0.08037470f, -0.11868919f, -0.09769207f, -0.10810711f, 
    -0.25703654f, 0.03600155f, -0.07389641f, -0.06674977f, -0.05589745f, -0.03220318f, 0.04185012f, -0.05675769f, 
    -0.08516618f, -0.02762699f, -0.01723930f, 0.05523806f, 0.17912687f, 0.15454037f, -0.04271628f, -0.14074215f, 
    -0.06983113f, -0.06042447f, 0.05977124f, 0.07167182f, -0.02551777f, 0.03233461f, 0.06975633f, -0.00717520f, 
    -0.11585625f, 0.04635029f, 0.09194702f, -0.22006907f, -0.06308341f, -0.00293729f, -0.04026924f, 0.05713952f, 
    0.11555874f, -0.04000044f, 0.13516141f, 0.19856519f, 0.01918598f, -0.05863200f, -0.14458749f, -0.07460328f, 
    0.12337119f, -0.00168128f, -0.04293315f, 0.07022991f, -0.05269944f, -0.06506748f, -0.17074673f, -0.18467271f, 
    0.17075393f, 0.18231526f, 0.05767402f, -0.22843981f, 0.07593890f, -0.09104405f, -0.03229154f, 0.03759811f, 
    0.05584067f, 0.01429075f, -0.04216379f, 0.01303313f, -0.15060082f, -0.01620780f, 0.03762682f, -0.03044530f, 
    0.04041452f, -0.03496869f, -0.03374479f, -0.01758266f, 0.06501501f, 0.06073343f, 0.06698378f, -0.02423366f, 
    0.15645008f, -0.16685894f, -0.09035975f, -0.05197491f, 0.17104651f, 0.14333247f, -0.00431377f, 0.12793617f, 
    -0.06565427f, 0.09780436f, 0.07987280f, -0.16446315f, 0.02647357f, -0.23068313f, 0.02452343f, 0.09272909f, 
    0.06486945f, 0.02942256f, 0.02247832f, 0.03140225f, 0.16653158f, -0.03115868f, 0.08701798f, 0.12101473f, 
    -0.27077553f, -0.12646456f, -0.04522959f, 0.01024690f, 0.15389009f, -0.05701417f, 0.04323225f, 0.11149727f, 
    -0.04173432f, 0.07166535f, 0.16753124f, 0.19102070f, -0.02038411f, -0.00550687f, 0.19300272f, 0.04888143f, 
    0.09777948f, -0.12121838f, 0.01407760f, -0.04316210f, 0.06279645f, 0.00742436f, 0.02456532f, 0.07160965f, 
    0.06193173f, 0.07446994f, -0.11061209f, -0.08564920f, -0.06740082f, 0.04840938f, 0.13024141f, 0.08618220f, 
    0.03114518f, 0.13317503f, -0.05110457f, 0.03666943f, 0.38059849f, -0.04040426f, -0.19906686f, -0.05916194f, 
    -0.01046640f, -0.00360733f, -0.08530553f, 0.19336069f, 0.05380372f, 0.00015416f, 0.06512006f, -0.00323558f, 
    -0.04287012f, 0.08603365f, -0.04185731f, 0.16798510f, 0.00753835f, 0.18239863f, -0.04236009f, 0.02315297f, 
    0.03916745f, -0.03763624f, 0.05169519f, 0.27894670f, 0.14173110f, -0.01412205f, -0.16854571f, 0.04772950f, 
    -0.11382513f, -0.08443909f, 0.09961553f, 0.10058153f, 0.01005421f, 0.06045043f, -0.17481308f, 0.00716328f, 
    0.06607398f, 0.13099761f, -0.01819895f, 0.06408124f, 0.05178089f, -0.03441893f, -0.01304015f, -0.11040508f, 
    0.05997664f, -0.00073325f, -0.07490657f, 0.11415034f, 0.19515812f, 0.03480803f, -0.09092662f, -0.02829836f, 
    0.04967469f, 0.09558881f, -0.03054036f, 0.05796036f, -0.04229951f, 0.10673077f, -0.06406742f, 0.09194772f, 
    0.20863755f, -0.15687107f, 0.06155920f, -0.01245793f, -0.01394173f, 0.09197861f, 0.07095865f, 0.19810405f, 
    0.04064143f, 0.01589596f, -0.09153547f, 0.10358366f, 0.15093862f, -0.04516191f, -0.11785357f, 0.09547814f, 
    0.05466077f, 0.02078018f, -0.04531149f, 0.07125577f, -0.05954385f, -0.03791281f, -0.06579454f, 0.00009629f, 
    0.25714132f, 0.05612248f, 0.00973493f, -0.14393975f, -0.01785962f, 0.05871502f, -0.05652771f, 0.19048853f, 
    0.00081733f, 0.01606634f, 0.10013288f, 0.09836421f, 0.02316551f, -0.24260317f, 0.01490360f, 0.00486246f, 
    0.04458082f, -0.02278761f, 0.13233058f, 0.03694298f, -0.09246956f, 0.00516863f, 0.02589509f, -0.16289873f, 
    0.00685570f, 0.05571052f, 0.01016493f, 0.02768051f, 0.00449350f, 0.09048660f, -0.05183531f, 0.15529867f, 
    0.02346235f, 0.05583266f, -0.09615116f, 0.06422305f, 0.04037751f, -0.18322131f, 0.00035160f, -0.02326948f, 
    0.10453539f, 0.01989333f, -0.04440929f, 0.13972367f, 0.07592842f, 0.01798794f, 0.02620272f, 0.09167229f, 
    -0.01955582f, 0.02184373f, -0.23825257f, 0.03533754f, -0.01801248f, -0.02374944f, -0.09620003f, -0.01999590f, 
    -0.00941204f, -0.13228628f, 0.13718060f, -0.10107990f, 0.07690234f, -0.02012624f, -0.00132571f, -0.17718843f, 
    -0.02597875f, 0.02911068f, -0.03073666f, 0.10738770f, 0.06635186f, 0.02418608f, 0.06218322f, -0.04711046f, 
    -0.06474557f, 0.14449890f, -0.10791750f, -0.13060626f, -0.09343592f, -0.03558079f, 0.07603937f, 0.01344025f, 
    0.01347158f, 0.00496612f, 0.12688351f, -0.01271417f, 0.34524724f, 0.11546269f, -0.05383522f, 0.11890823f, 
    -0.02398221f, 0.07986775f, -0.00137417f, 0.09199185f, -0.04156416f, -0.06576243f, 0.01760476f, 0.15908226f, 
    0.02899203f, 0.01907878f, -0.22739547f, -0.11552215f, -0.04187045f, 0.07443479f, 0.02223286f, 0.01509663f, 
    -0.00330177f, 0.05380906f, 0.04843632f, 0.07576637f, -0.07999662f, -0.15162872f, 0.16697986f, 0.19222479f, 
    0.07117891f, 0.03549663f, 0.18286207f, -0.00206372f, 0.11328632f, -0.00887756f, -0.03523346f, 0.07780354f, 
    0.19298641f, 0.18303937f, 0.10588021f, 0.09078514f, -0.10769773f, -0.05857025f, 0.03128974f, 0.00649303f, 
    -0.15924504f, 0.01267273f, 0.05057425f, 0.07625552f, 0.34773350f, -0.11085150f, 0.13526337f, -0.10550022f, 
    -0.09439404f, -0.07263067f, -0.00564935f, 0.02517921f, 0.11869793f, 0.09029527f, 0.14701603f, 0.06637550f, 
    0.66489869f, 0.22711810f, -0.00815905f, 0.09215546f, 0.06003341f, 0.12146816f, 0.12698351f, 0.00740092f, 
    -0.10764061f, 0.05035301f, 0.13728866f, 0.04222416f, 0.15439337f, -0.03327510f, 0.03732412f, -0.07139120f, 
    -0.06106061f, -0.01781562f, 0.03957717f, 0.01747476f, 0.14099978f, -0.10192067f, -0.08757736f, -0.06621480f, 
    0.07585742f, 0.14248030f, 0.36277324f, -0.12564962f, -0.02800772f, -0.01015804f, 0.01753642f, -0.12648922f, 
    -0.07182354f, 0.08639529f, 0.02085761f, 0.00174375f, -0.05547477f, 0.04382292f, -0.09335408f, 0.04324855f, 
    -0.04338326f, -0.04791954f, -0.00319388f, 0.03043014f, -0.06575906f, 0.06066640f, -0.06178328f, -0.07307568f, 
    -0.35162142f, 0.02157400f, -0.00551779f, -0.27382913f, 0.09028082f, -0.01787657f, -0.03959103f, -0.02338312f, 
    -0.04599015f, -0.02243230f, 0.01545410f, -0.05496639f, 0.02078792f, 0.04606063f, 0.14501610f, -0.00108016f, 
    -0.10617463f, 0.00941427f, 0.08239837f, 0.01796691f, -0.05599454f, -0.02932202f, 0.03676105f, -0.01253811f, 
    -0.04155608f, 0.10324678f, -0.23845387f, -0.16148040f, 0.03810583f, 0.06357279f, -0.07136419f, 0.03998572f, 
    0.05785915f, 0.01950455f, 0.05128373f, -0.07907968f, -0.19563161f, -0.07873701f, -0.12524214f, -0.02270735f, 
    0.12917261f, 0.02228146f, 0.08241582f, 0.00468724f, 0.04199389f, 0.09725719f, 0.09095696f, 0.05515628f, 
    -0.21809275f, 0.08443885f, -0.26069573f, 0.07518069f, -0.04787332f, 0.12496857f, -0.03307103f, -0.12149765f, 
    0.18170856f, -0.01966420f, 0.00075031f, 0.03695003f, 0.18662521f, -0.03336476f, 0.11261025f, -0.07414313f, 
    0.03226771f, 0.03276807f, 0.09588141f, 0.08788004f, 0.03702589f, -0.05342873f, -0.01063412f, -0.01137513f, 
    -0.12142514f, 0.02589820f, 0.01160823f, 0.07944028f, -0.10275653f, -0.04005054f, 0.10992336f, 0.06679639f, 
    -0.03887141f, 0.14347973f, -0.00609435f, 0.12140860f, -0.63664806f, -0.19196506f, 0.08170263f, 0.12314344f, 
    0.12533429f, 0.08516592f, 0.03903927f, -0.06382863f, -0.01861285f, 0.01335969f, -0.03194300f, -0.03812819f, 
    0.09524968f, 0.01653282f, -0.10072433f, -0.18738218f, 0.11371892f, -0.00183471f, -0.00005070f, 0.09847313f, 
    0.01774002f, 0.03431945f, 0.01065002f, -0.09309732f, 0.02696605f, -0.01068943f, 0.14217177f, 0.17969595f, 
    -0.07241222f, -0.01648881f, -0.04499150f, 0.00807380f, 0.06729580f, 0.03645130f, 0.13241947f, -0.00331077f, 
    0.01658236f, 0.03689378f, -0.05756160f, -0.00118788f, 0.03309787f, -0.07268690f, 0.07344218f, -0.09967644f, 
    0.06330892f, 0.09699301f, 0.00287462f, 0.01145986f, 0.38735819f, 0.08442939f, -0.08199586f, 0.03586413f, 
    -0.17935716f, 0.03024229f, 0.05537418f, 0.04612654f, -0.04195008f, 0.01347361f, 0.00234667f, -0.01700054f, 
    0.15985177f, -0.19997561f, -0.07673515f, -0.03487118f, 0.04465596f, 0.01384930f, 0.05283474f, 0.08026800f, 
    0.14778903f, 0.01241300f, 0.00460652f, -0.04036488f, 0.24224886f, -0.00336093f, 0.04622332f, 0.05726011f, 
    0.11452138f, -0.11057425f, -0.20710148f, 0.01506717f, 0.05550548f, 0.15795621f, 0.19124077f, 0.09804149f, 
    0.16687727f, -0.06250065f, 0.03515278f, -0.06748036f, -0.08726294f, -0.14743236f, 0.08661813f, 0.06482968f, 
    0.01552114f, 0.03104406f, 0.06639436f, 0.16161501f, 0.30310476f, -0.11102224f, 0.27472293f, 0.00977519f, 
    0.08323136f, -0.08996901f, 0.03969425f, 0.12582010f, 0.14210926f, -0.00612765f, -0.03414840f, -0.00865881f, 
    0.12423734f, -0.18557633f, -0.06437469f, -0.11436176f, 0.01572801f, -0.17311835f, -0.04776548f, -0.08601005f, 
    0.05163400f, 0.00071561f, 0.01185642f, 0.18332103f, -0.21048468f, 0.14353992f, -0.20216602f, 0.20289187f, 
    -0.15651199f, 0.02042286f, 0.16532844f, 0.05699996f, 0.03967284f, 0.04367132f, -0.02770860f, -0.09588372f, 
    0.36826488f, 0.30256876f, -0.00022540f, -0.05504330f, -0.03869100f, 0.03232186f, 0.03830870f, 0.01667675f, 
    0.02635879f, 0.05189191f, 0.00836486f, 0.00723349f, -0.03965014f, -0.09291665f, 0.03403277f, -0.02352139f, 
    -0.08746209f, -0.02774854f, 0.09545722f, 0.01072388f, 0.05357290f, -0.07749271f, 0.17728229f, 0.09860703f, 
    0.21239443f, -0.01363201f, 0.19956113f, -0.15893129f, 0.01429964f, 0.06866023f, 0.07883234f, -0.07775402f, 
    0.03486542f, 0.09688219f, 0.07174665f, 0.00803485f, -0.40984002f, 0.04956564f, -0.09063218f, -0.19068876f, 
    0.11689975f, 0.05300077f, 0.02448593f, -0.03734471f, -0.01547197f, 0.05037679f, 0.04322068f, -0.01194967f, 
    0.16149783f, 0.02913539f, 0.11836676f, -0.04967291f, -0.03170491f, 0.12560259f, 0.05576120f, 0.00383162f, 
    0.05079740f, -0.10794396f, 0.18657885f, 0.00918958f, 0.02203171f, -0.06154137f, 0.03203962f, -0.04388706f, 
    -0.04358745f, 0.02519902f, -0.00963107f, 0.04034608f, 0.03883138f, 0.10980422f, -0.01259331f, 0.13986078f, 
    -0.13488792f, -0.07387133f, -0.07814279f, -0.01347915f, 0.13951781f, -0.06728512f, -0.00093768f, 0.06145675f, 
    0.18551427f, -0.00365653f, 0.09052313f, 0.14986975f, -0.45768133f, -0.04313084f, -0.16870916f, 0.07689495f, 
    -0.01391313f, 0.31527954f, 0.08602767f, 0.03408219f, 0.13095362f, 0.00728305f, 0.07885426f, -0.02150687f, 
    -0.00289082f, 0.00718214f, 0.01613100f, -0.01199626f, 0.04050836f, -0.01957529f, -0.01138758f, -0.04559978f, 
    0.01947312f, -0.00756619f, -0.03402438f, -0.00109605f, 0.01781067f, 0.01265740f, -0.04513743f, 0.03253158f, 
    -0.04718671f, 0.00533236f, 0.03449972f, 0.02835437f, -0.01645422f, -0.01908212f, 0.00335141f, -0.00906657f, 
    -0.02421282f, -0.02082482f, 0.02591690f, 0.02526011f, -0.05016299f, -0.02797722f, 0.03358273f, -0.04498713f, 
    0.00825252f, -0.05212473f, -0.04292870f, 0.01628657f, 0.01328205f, 0.01295190f, 0.01669566f, -0.05305072f, 
    0.00197504f, 0.04171961f, 0.01833578f, -0.02161657f, 0.01951276f, -0.01251398f, 0.02364149f, 0.03776056f, 
    0.02446655f, -0.01913543f, 0.03744648f, -0.02082629f, -0.05260656f, 0.02154713f, -0.01143495f, -0.05286161f, 
    0.03154680f, -0.03024180f, 0.02607438f, 0.03574586f, -0.02633071f, -0.03394981f, 0.00370513f, -0.01545507f, 
    0.02268056f, -0.02931643f, 0.00962157f, -0.04930899f, -0.03699078f, -0.03752395f, 0.00280307f, -0.05687455f, 
    -0.04830762f, -0.05009381f, -0.02400483f, -0.00716210f, -0.04303434f, 0.03860765f, -0.04757649f, 0.04076659f, 
    -0.04139655f, -0.01095574f, 0.03554380f, 0.00592760f, -0.04883603f, 0.03366540f, 0.01425321f, 0.03945814f, 
    0.02815652f, 0.00252347f, -0.01395714f, -0.02739006f, 0.04275444f, -0.00534864f, -0.04139033f, -0.03919918f, 
    -0.00666806f, -0.05306645f, 0.02237390f, 0.02310861f, -0.04327977f, -0.00366132f, 0.02943591f, -0.03940911f, 
    -0.05186924f, 0.00564166f, -0.00536706f, 0.01168457f, -0.04243898f, -0.01839948f, 0.02619703f, -0.01771514f, 
    0.02967570f, 0.03966727f, -0.00544286f, 0.00225958f, 0.01153640f, 0.02111866f, 0.02041975f, -0.02706259f, 
    0.00172142f, -0.05106125f, 0.04474654f, -0.01353076f, -0.03170994f, -0.04249920f, 0.02269234f, -0.02767066f, 
    0.01720978f, 0.00007957f, -0.02529328f, 0.00145723f, 0.02461957f, 0.01333284f, 0.04053281f, 0.01300457f, 
    -0.03634064f, -0.00365767f, -0.05478768f, 0.01055322f, -0.01986027f, -0.02820698f, -0.03915818f, 0.02657249f, 
    0.04101175f, 0.01902441f, 0.03628324f, -0.03129121f, -0.01815403f, -0.02413610f, 0.02573992f, -0.05207128f, 
    -0.01072960f, -0.04722427f, -0.00554885f, -0.02811001f, 0.01435709f, 0.04521365f, 0.02209916f, 0.02735853f, 
    -0.01006185f, -0.01280219f, -0.05670989f, 0.04164170f, -0.04994042f, -0.03735391f, 0.00219928f, -0.02231034f, 
    0.02327497f, -0.04701167f, 0.02844669f, -0.01286006f, 0.01233092f, -0.01666143f, 0.01405175f, -0.02127851f, 
    0.02016253f, -0.05137157f, 0.03106320f, -0.05401388f, -0.00597521f, -0.01635239f, 0.01735491f, -0.04886953f, 
    -0.05057085f, 0.00306253f, 0.03082424f, -0.02763005f, 0.00608637f, -0.02328554f, 0.03064240f, 0.01508860f, 
    -0.04801605f, 0.00309486f, 0.01078439f, 0.01179157f, -0.03088433f, 0.04174121f, -0.05665254f, 0.00261032f, 
    0.01732631f, 0.03794025f, -0.00388595f, 0.03464705f, 0.00455029f, -0.00428209f, -0.02943421f, -0.00254332f, 
    0.01635382f, -0.00167389f, 0.03311677f, -0.00269262f, -0.03336627f, -0.02822872f, -0.03434590f, -0.05241410f, 
    -0.00188812f, -0.01244951f, -0.00678991f, 0.04121940f, -0.03577093f, -0.03994986f, 0.01584136f, -0.05115703f, 
    0.04451997f, -0.05348678f, 0.00610589f, -0.04922055f, 0.03971493f, -0.00992800f, -0.01750012f, 0.00437983f, 
    -0.02497964f, -0.00070242f, -0.05451226f, -0.05234082f, 0.03652371f, -0.01169982f, -0.02538781f, 0.01523425f, 
    0.00735470f, 0.02625881f, 0.01719900f, 0.02718317f, -0.01473643f, -0.00768055f, 0.00678159f, 0.00382501f, 
    0.02543394f, 0.03644308f, 0.03255948f, -0.00885837f, 0.01989559f, 0.02018666f, -0.04747647f, -0.05652789f, 
    -0.00386952f, -0.04276200f, 0.02596099f, -0.03014357f, 0.04050582f, -0.04332706f, 0.01613253f, 0.02084937f, 
    -0.02365976f, -0.02027327f, 0.00370227f, 0.00943886f, -0.04188037f, -0.02170704f, -0.03451074f, 0.00150811f, 
    -0.00926466f, 0.00266850f, 0.03033346f, -0.04989890f, -0.02598844f, -0.04851376f, -0.01128715f, 0.02838881f, 
    -0.04421962f, -0.03525965f, 0.02380571f, -0.05251438f, 0.01354067f, 0.04154937f, -0.02623184f, -0.03366406f, 
    -0.02639495f, -0.01566954f, -0.02877679f, -0.05533251f, -0.05174796f, 0.04260154f, -0.03757774f, 0.00738381f, 
    -0.03625331f, 0.02570754f, -0.05599366f, -0.04756011f, 0.01762665f, -0.04555043f, 0.02746112f, 0.00972421f, 
    0.03636907f, -0.01946598f, 0.01451805f, 0.01767745f, -0.04615448f, 0.02046242f, -0.01714380f, 0.01592287f, 
    0.04150535f, 0.02709262f, -0.00094912f, -0.04478198f, -0.03090939f, 0.03930598f, -0.00277321f, 0.03909376f, 
    0.03971045f, 0.03018747f, -0.04667658f, -0.01798062f, -0.04947373f, 0.02148702f, 0.00725388f, -0.01771771f, 
    -0.02159449f, -0.04414219f, 0.02196486f, 0.03077523f, -0.01930769f, 0.01255650f, 0.03423134f, 0.00813074f, 
    -0.00627561f, -0.05332197f, -0.04182122f, -0.04786720f, 0.02131904f, -0.04329007f, 0.01480212f, -0.02088322f, 
    -0.01182371f, -0.05232367f, -0.05680215f, -0.00958981f, -0.03130775f, -0.00430223f, -0.00784459f, -0.04137727f, 
    0.00055623f, 0.01744699f, 0.01990968f, -0.02444177f, 0.00384189f, 0.02719466f, -0.01524593f, -0.02073001f, 
    -0.01291310f, -0.03196218f, -0.05433604f, 0.01250724f, -0.05605549f, -0.03518867f, -0.01660995f, 0.00947354f, 
    -0.03007593f, 0.02973499f, -0.02993750f, 0.03917336f, -0.01222205f, 0.02904020f, -0.03062045f, -0.00079688f, 
    0.03035768f, -0.05407942f, 0.00637262f, 0.01612594f, -0.03124681f, -0.03405268f, -0.02386722f, -0.05020540f, 
    -0.10407423f, -0.01125357f, 0.09908594f, 0.01620851f, 0.10250594f, -0.01312102f, -0.07062931f, 0.05259446f, 
    -0.05207741f, -0.00654749f, 0.09440350f, 0.16549386f, 0.01800558f, -0.08789995f, -0.01760528f, 0.06898638f, 
    0.02230004f, -0.02571702f, -0.03422368f, -0.06160552f, -0.00649459f, -0.03191137f, 0.08250839f, -0.12453215f, 
    -0.12482011f, -0.27577502f, 0.06417710f, 0.05494709f, -0.02103819f, 0.14828345f, -0.04561681f, -0.03498862f, 
    -0.04673167f, -0.02864069f, 0.08999547f, 0.03036436f, -0.00601910f, 0.12935548f, -0.07555813f, 0.02119307f, 
    -0.00854971f, -0.09182367f, -0.01034659f, -0.05529271f, 0.05657532f, 0.04631476f, -0.06620476f, -0.07706191f, 
    -0.29767150f, 0.02814878f, -0.10015337f, -0.07574366f, 0.01428311f, -0.03794703f, -0.01408187f, -0.09570317f, 
    0.02229104f, -0.03854091f, -0.06310134f, 0.06622262f, -0.22424100f, -0.19246686f, 0.00630995f, -0.04171019f, 
    0.09825583f, 0.04646403f, 0.01551511f, -0.05071469f, -0.07612639f, -0.03860254f, -0.08392168f, 0.00674243f, 
    0.03488355f, 0.29439625f, 0.04917197f, -0.05457225f, -0.10249579f, -0.00961035f, -0.02066465f, 0.12490416f, 
    0.03606886f, -0.04495589f, 0.07340471f, 0.05111852f, 0.05984509f, 0.07000973f, -0.00980122f, -0.12015768f, 
    -0.02113234f, 0.02693730f, -0.12743074f, 0.00142829f, 0.04903995f, 0.11062542f, -0.10240129f, -0.04506269f, 
    0.31635034f, 0.31462333f, -0.11044305f, -0.32607645f, 0.04929769f, 0.03135166f, -0.06883042f, 0.05909047f, 
    -0.08785973f, 0.05340396f, -0.04276276f, 0.03785957f, 0.49639249f, 0.13684803f, 0.12413266f, -0.14309724f, 
    0.01101378f, 0.06326109f, -0.04359284f, 0.02145074f, -0.02538338f, 0.00212591f, 0.06175342f, -0.07487218f, 
    -0.10495461f, -0.03157402f, 0.04625019f, -0.04624196f, 0.16106747f, 0.01010422f, -0.02948369f, -0.07179779f, 
    -0.07115847f, -0.02984596f, -0.01742451f, 0.02539478f, -0.15758748f, -0.01974649f, 0.19857864f, 0.05919245f, 
    0.07367809f, 0.09422620f, -0.08552222f, -0.03947183f, -0.04790798f, -0.06281615f, 0.01406776f, -0.02164112f, 
    0.09313427f, 0.25028381f, 0.13786137f, 0.06773612f, 0.05149839f, 0.16445404f, 0.07731024f, 0.12121088f, 
    0.06289844f, 0.15259407f, 0.10050149f, 0.03062858f, 0.43788135f, 0.45625946f, 0.22846790f, 0.15349536f, 
    0.02066952f, -0.03346650f, -0.00160279f, 0.06436477f, 0.00791651f, -0.06899889f, 0.02010908f, -0.04365785f, 
    -0.21953163f, -0.05586928f, -0.20796095f, -0.08204675f, 0.06346520f, -0.07795411f, 0.04983397f, -0.05079050f, 
    0.16128322f, 0.05226247f, -0.05102702f, -0.08643358f, 0.07129663f, -0.18135957f, 0.08888039f, -0.22527424f, 
    0.06739257f, -0.01168870f, 0.02579706f, 0.10976424f, -0.04724963f, -0.04930168f, 0.03799629f, -0.08704537f, 
    -0.26395264f, -0.01075496f, -0.10541199f, -0.05001449f, -0.08850579f, 0.08522888f, 0.09967096f, 0.03114267f, 
    0.02167963f, 0.11610825f, 0.10832019f, -0.01102734f, 0.41702503f, -0.25666261f, -0.03472764f, -0.10606775f, 
    -0.04370390f, -0.02504205f, -0.07701982f, 0.01476482f, 0.02591268f, 0.11835790f, -0.09256210f, -0.04403442f, 
    0.30078527f, 0.06930822f, -0.01031991f, -0.07810061f, -0.07699241f, 0.07388563f, -0.07507025f, 0.01387154f, 
    0.02837591f, 0.04774770f, 0.07101539f, 0.10474464f, -0.30939907f, -0.19901422f, -0.00465801f, 0.01873926f, 
    0.06608203f, -0.09144428f, -0.01163912f, -0.03003129f, -0.03621769f, 0.16997413f, 0.01825636f, 0.14841883f, 
    0.00961236f, -0.12921461f, 0.06407752f, -0.03890267f, 0.11722180f, 0.07383012f, 0.01230111f, 0.06733343f, 
    0.13179253f, 0.06538035f, 0.09901670f, 0.12366154f, -0.02379649f, -0.04030090f, -0.08128784f, 0.04981725f, 
    0.00216424f, 0.05309148f, -0.02354706f, -0.06803244f, 0.13544831f, 0.01449515f, 0.08261324f, 0.15392834f, 
    0.15039754f, -0.10441106f, 0.01491819f, 0.02869625f, 0.06896641f, 0.00792162f, 0.02379805f, -0.02545925f, 
    -0.05417011f, 0.11330695f, 0.01542416f, 0.07536920f, 0.16021761f, 0.16335872f, -0.06842862f, -0.07196674f, 
    0.00965304f, -0.03921542f, 0.10193517f, 0.14885862f, -0.07722934f, -0.06816840f, -0.08124974f, -0.03609689f, 
    0.00550170f, 0.14233044f, -0.00088329f, -0.14478910f, -0.02927236f, 0.00919769f, -0.04602540f, 0.07766288f, 
    -0.09189936f, 0.06010926f, 0.03597293f, 0.02331032f, -0.06497741f, 0.09197897f, -0.03594770f, -0.07785760f, 
    0.10604370f, 0.00124792f, 0.02976768f, 0.19486818f, -0.03760179f, -0.03968308f, 0.15154533f, -0.03402364f, 
    -0.19645165f, 0.08750145f, -0.18100235f, 0.08732602f, -0.05006580f, 0.02454890f, 0.00503356f, 0.06043280f, 
    0.01616690f, -0.01118241f, 0.10762712f, -0.02565311f, 0.05426118f, 0.33122116f, 0.04381855f, -0.01135509f, 
    0.05976595f, 0.03351846f, -0.00480095f, 0.00711300f, -0.00971003f, 0.04434943f, -0.02171280f, -0.03215249f, 
    -0.31433091f, -0.00516978f, -0.16466278f, -0.04110044f, 0.00752183f, 0.03521952f, 0.02696525f, 0.06296600f, 
    0.06266271f, -0.06213342f, 0.11500575f, -0.04602895f, -0.20196933f, -0.11132358f, 0.07107376f, -0.09275804f, 
    0.09692224f, 0.07371543f, 0.07985765f, -0.03845794f, 0.03648183f, 0.13423674f, 0.12303615f, 0.11864381f, 
    -0.18943711f, -0.16267920f, 0.07556131f, 0.07306158f, -0.07476797f, 0.06847614f, 0.17660251f, -0.03291613f, 
    -0.05318481f, 0.09198312f, 0.08929954f, 0.10596363f, -0.27729943f, 0.48174235f, 0.15305965f, 0.06148394f, 
    0.07275763f, 0.01285508f, 0.15483227f, 0.07385766f, 0.06501051f, -0.02677025f, -0.03537678f, -0.02119762f, 
    -0.01228030f, 0.01435124f, 0.03235483f, 0.02527976f, -0.01454323f, -0.01528241f, 0.02619266f, -0.04486561f, 
    -0.03187881f, 0.02016978f, -0.01577740f, 0.02628875f, 0.00930400f, 0.01958157f, -0.00656162f, -0.01674345f, 
    -0.01294316f, -0.04825135f, -0.00195804f, -0.01278564f, -0.03245715f, 0.00332910f, 0.00321025f, 0.03056720f, 
    -0.00481534f, 0.02558198f, -0.01766601f, 0.02045316f, -0.00818373f, -0.02160586f, 0.02548543f, 0.03490008f, 
    0.04381973f, -0.01169959f, -0.03309573f, -0.04859134f, -0.00899893f, 0.03830110f, 0.02494941f, -0.03589817f, 
    -0.04266663f, -0.01947475f, -0.02899869f, -0.04731893f, -0.03517550f, -0.02845541f, -0.00161940f, -0.02841055f, 
    -0.03670797f, -0.02537186f, -0.00813993f, -0.02280559f, 0.00877725f, 0.03461915f, 0.03437128f, -0.02951489f, 
    -0.00247311f, -0.01496236f, -0.01311451f, -0.02139036f, 0.01179620f, -0.01437861f, 0.03361759f, 0.01337015f, 
    0.00269365f, -0.01417335f, 0.00984378f, -0.03916525f, 0.00645361f, 0.02102731f, 0.00109793f, 0.00687433f, 
    0.04373639f, 0.00047689f, -0.01525851f, 0.00690185f, 0.00508680f, -0.01990561f, -0.01585308f, -0.03802105f, 
    -0.01525359f, 0.01588125f, -0.04634874f, 0.03004273f, 0.00283250f, -0.04724819f, 0.04044375f, 0.02167761f, 
    -0.04125763f, -0.04677835f, 0.01602667f, -0.05077922f, -0.05075981f, -0.04877670f, -0.03745213f, -0.02142910f, 
    0.02908523f, -0.03914943f, 0.00626431f, 0.03938470f, -0.02960075f, -0.04563455f, 0.00324724f, 0.01928909f, 
    -0.03507923f, 0.00519367f, -0.04595826f, 0.04111225f, -0.01233187f, -0.02166983f, 0.02536829f, -0.05707204f, 
    -0.00078266f, -0.00774460f, -0.04443966f, -0.04246491f, -0.04430013f, 0.01208901f, -0.04431959f, 0.02484886f, 
    0.01769282f, 0.02065125f, 0.01752329f, -0.05637285f, -0.01380336f, -0.02522956f, -0.03495131f, -0.00356506f, 
    -0.01938369f, -0.04395643f, -0.03224888f, -0.03386701f, -0.03319009f, 0.02325125f, 0.04071608f, -0.03761297f, 
    0.00125336f, -0.03008540f, 0.03224884f, -0.00377558f, 0.00132829f, -0.04764002f, 0.01907094f, -0.04570673f, 
    -0.02039114f, 0.02598643f, -0.02599834f, -0.02171054f, -0.03031230f, 0.00579366f, -0.03820444f, 0.03777603f, 
    -0.03122757f, 0.03015360f, 0.02528812f, 0.01522954f, -0.04019696f, -0.01911729f, -0.01142291f, 0.03693955f, 
    -0.02055032f, -0.01989355f, -0.04273471f, 0.00586181f, -0.00334639f, -0.01277613f, 0.03603495f, -0.03783657f, 
    -0.01960335f, 0.01581393f, -0.00592059f, 0.02371500f, 0.01131618f, -0.00209848f, -0.01007702f, -0.04884619f, 
    0.00821669f, -0.05341901f, -0.00360700f, 0.02540615f, 0.00938462f, -0.02740106f, 0.03377115f, 0.04327028f, 
    0.00549435f, 0.04398460f, -0.03029663f, 0.03085791f, 0.00998727f, 0.01562409f, -0.00378094f, -0.04271565f, 
    -0.00497252f, -0.00341930f, 0.02551070f, 0.01196452f, -0.04437790f, -0.01477051f, -0.00458999f, 0.01478036f, 
    -0.05140326f, 0.02367585f, 0.00233691f, 0.03452509f, 0.00456995f, -0.04268512f, -0.00698974f, -0.02623991f, 
    0.04342854f, 0.03100571f, 0.00645813f, 0.03815330f, 0.01032679f, 0.03404805f, 0.01837398f, -0.00207525f, 
    -0.01237800f, 0.02866860f, -0.03615468f, 0.03711971f, -0.03630627f, -0.00332966f, 0.04331271f, -0.05210621f, 
    0.03250723f, 0.03880641f, -0.02685384f, 0.00469302f, 0.00292903f, -0.02873563f, -0.04274271f, -0.03843813f, 
    0.02581750f, 0.01010781f, -0.04564486f, 0.00250122f, 0.02478384f, -0.01642547f, -0.01913140f, -0.04390403f, 
    0.02973027f, -0.04419426f, -0.02321961f, -0.00972873f, -0.04479992f, -0.01476173f, 0.02338114f, 0.00599934f, 
    0.00468447f, -0.03917760f, -0.05482263f, 0.03706240f, 0.00786167f, -0.01508514f, -0.00850432f, -0.02085293f, 
    -0.02600600f, 0.02806507f, -0.02625422f, -0.04244443f, -0.05627915f, -0.01028591f, -0.04791669f, 0.02127273f, 
    -0.04905187f, -0.04863168f, 0.00850898f, -0.01809334f, -0.02853103f, -0.02001360f, 0.00159981f, -0.02954434f, 
    -0.04576749f, -0.04324025f, -0.03488849f, -0.02155782f, -0.00365576f, 0.02623866f, -0.00829136f, 0.02614402f, 
    0.00225594f, 0.04134121f, 0.00635371f, -0.04900190f, -0.05316561f, -0.02553458f, -0.01855676f, 0.02807981f, 
    -0.02700752f, 0.03161655f, 0.00764947f, -0.00616849f, -0.05342690f, -0.03033216f, -0.02914845f, 0.00611910f, 
    0.03821339f, 0.00771681f, -0.04606495f, 0.02497063f, -0.02429786f, -0.05234359f, -0.04965207f, -0.00780822f, 
    -0.03840949f, 0.01605860f, -0.05200815f, 0.00769917f, 0.04300477f, -0.04694390f, 0.00056246f, -0.03869628f, 
    -0.03742271f, 0.01623464f, -0.01771641f, 0.02478008f, 0.04069150f, -0.03586049f, 0.03358976f, -0.04809305f, 
    0.02182552f, 0.00883232f, -0.05071545f, -0.00166807f, 0.00915899f, 0.00224187f, 0.01148953f, 0.03250446f, 
    0.01184696f, -0.03517991f, -0.01277049f, 0.02376107f, 0.02723460f, -0.00371574f, -0.01508835f, -0.04258864f, 
    0.02319441f, -0.01589719f, -0.01209691f, 0.01717304f, -0.00164431f, -0.02171306f, -0.05036587f, -0.01471292f, 
    -0.05769641f, 0.00614179f, 0.01718934f, -0.04709513f, 0.02284885f, -0.01720519f, 0.02589249f, 0.01403373f, 
    -0.03961227f, 0.01473177f, -0.03022275f, 0.01678814f, 0.01559724f, 0.02767370f, -0.03607129f, 0.03792396f, 
    0.02877767f, -0.04517762f, 0.00508490f, 0.00809385f, -0.05258573f, -0.01624982f, -0.00291680f, -0.03651670f, 
    -0.05311554f, -0.01180044f, 0.03660524f, 0.00016973f, 0.03483587f, 0.02580284f, -0.01152267f, -0.01448742f, 
    0.02821895f, -0.02167159f, -0.02473029f, -0.02839750f, 0.04288261f, -0.04183124f, 0.00171981f, -0.02965011f, 
    0.15539628f, 0.03744124f, -0.01207005f, -0.18153077f, -0.04171339f, 0.05421172f, 0.04910438f, 0.03011413f, 
    0.06459071f, -0.09912859f, -0.09331580f, -0.06447305f, -0.03700993f, 0.07128634f, -0.07730777f, 0.00481994f, 
    0.01421046f, 0.02506902f, -0.01550002f, 0.03743768f, 0.02809093f, 0.04764144f, 0.01784351f, 0.05577019f, 
    -0.43451327f, 0.07053827f, -0.10216115f, 0.13319468f, 0.00070324f, 0.01697592f, -0.06613878f, 0.04677795f, 
    0.02222183f, 0.14038625f, -0.05027153f, -0.03673422f, 0.07343841f, 0.00841018f, -0.01508787f, -0.05373685f, 
    0.02166059f, 0.06022585f, -0.02949511f, -0.09045341f, -0.05729586f, 0.11126342f, 0.11969247f, 0.09689520f, 
    0.06721017f, 0.03125076f, -0.02943919f, 0.21692181f, 0.01298074f, 0.09331152f, 0.05322362f, 0.05507678f, 
    0.05775095f, -0.08644207f, 0.05043258f, -0.08119163f, 0.36945289f, 0.32679355f, 0.07693233f, -0.04629580f, 
    -0.01197419f, -0.09788547f, 0.20615599f, -0.03584307f, -0.03554576f, 0.12074985f, 0.15656486f, -0.00745044f, 
    0.13820785f, -0.13580693f, -0.11148196f, 0.04503702f, -0.09763959f, -0.07846085f, -0.01472791f, 0.01830002f, 
    -0.00527759f, 0.00342396f, -0.02789990f, 0.02231626f, -0.10304824f, -0.04621133f, 0.10124526f, 0.10259426f, 
    0.06394731f, 0.08940669f, -0.03383764f, -0.09428386f, 0.09400305f, -0.07230198f, -0.00920649f, -0.08066631f, 
    0.11120906f, -0.05952892f, 0.17583966f, 0.23670401f, -0.08373124f, -0.14267261f, 0.00359432f, 0.00349093f, 
    0.07729571f, 0.06328742f, 0.10084853f, 0.09676649f, -0.36140689f, -0.06136789f, 0.08320268f, 0.10562150f, 
    -0.03639135f, -0.06879190f, -0.01794540f, 0.04877320f, 0.10180175f, 0.02440234f, 0.03572620f, 0.10471629f, 
    0.14987317f, -0.04599823f, 0.00658888f, 0.01756141f, 0.06489273f, -0.03031004f, 0.05392083f, 0.10197697f, 
    -0.01741962f, 0.15319505f, 0.02320830f, -0.00555447f, 0.06392471f, -0.12795818f, -0.04683777f, 0.10796419f, 
    0.02184650f, -0.02051408f, -0.04386748f, 0.07608861f, 0.17090604f, 0.10583439f, 0.01904364f, 0.07842584f, 
    0.16807449f, -0.12867248f, 0.02216378f, -0.13814896f, 0.04905202f, -0.02409496f, 0.02110821f, 0.01562982f, 
    0.04256333f, -0.06940780f, 0.02281813f, -0.04804084f, -0.18414673f, 0.03037508f, -0.09215654f, -0.12859128f, 
    0.00952255f, -0.18511583f, -0.02261047f, -0.00335906f, -0.01720104f, 0.09027933f, 0.06422684f, 0.11807058f, 
    0.23551622f, 0.17536294f, 0.17743446f, 0.19798608f, -0.03693943f, 0.13660891f, 0.00848223f, 0.15258941f, 
    -0.01410189f, -0.01413701f, 0.02933109f, 0.00093370f, 0.07329745f, 0.20397902f, -0.11242969f, -0.15561883f, 
    0.04403712f, 0.05135154f, 0.04370930f, 0.02034540f, 0.00598961f, 0.12566365f, -0.07382073f, 0.00361454f, 
    0.05403322f, 0.07638398f, 0.13120353f, 0.27215192f, -0.00220319f, 0.09671350f, -0.08552142f, 0.03246799f, 
    0.00453971f, -0.09936176f, 0.01270351f, 0.17597750f, 0.13354862f, 0.26353973f, -0.02198620f, 0.08751601f, 
    0.02314796f, 0.06852773f, 0.00672525f, 0.06943560f, 0.00236876f, 0.06429155f, 0.06663613f, 0.02779282f, 
    -0.27447864f, -0.02856292f, 0.09380094f, 0.19879302f, 0.01615438f, -0.09982902f, 0.09011181f, -0.21338134f, 
    -0.04867987f, 0.02091735f, -0.02939305f, -0.04889017f, 0.22507267f, -0.00244311f, -0.10122512f, 0.07333548f, 
    0.00810730f, 0.13198614f, 0.10226623f, 0.08731499f, -0.09886184f, -0.03187240f, -0.15312305f, -0.11767084f, 
    0.18433708f, -0.05800555f, 0.04571018f, -0.09085931f, 0.03757013f, 0.03333113f, -0.05914916f, 0.10741007f, 
    0.04463396f, -0.02288080f, -0.16832229f, 0.07563856f, 0.07697123f, 0.06794275f, -0.14036672f, -0.06992561f, 
    0.06175061f, -0.06530656f, -0.01739857f, 0.06409404f, -0.16491202f, -0.08363593f, -0.01613100f, -0.10103378f, 
    -0.10562287f, 0.12185571f, -0.04494803f, -0.02882613f, -0.01514852f, 0.08201686f, -0.01330125f, 0.07720710f, 
    0.02752611f, -0.10827730f, -0.01848933f, -0.05929295f, 0.32628906f, -0.39421391f, -0.00868241f, -0.23284231f, 
    0.20224361f, 0.08954363f, -0.06004388f, -0.10776015f, 0.00556341f, 0.08054952f, 0.06274441f, -0.00601527f, 
    0.09845137f, -0.09864189f, -0.04100980f, 0.16454549f, -0.02457939f, -0.02046594f, -0.10331396f, 0.15004623f, 
    0.03287532f, -0.00993763f, 0.00035556f, 0.11766799f, 0.21738914f, -0.07972289f, 0.14905135f, -0.04833851f, 
    0.04384353f, 0.00953312f, -0.00977398f, -0.05943044f, 0.07608417f, 0.09289885f, -0.27492633f, -0.07158343f, 
    0.26297209f, 0.10896138f, 0.10679347f, 0.05145970f, -0.04578605f, 0.03259575f, -0.05877764f, 0.05018565f, 
    0.02681164f, -0.04067031f, 0.03790585f, -0.05044909f, 0.11227449f, -0.27119452f, -0.03047875f, 0.07212009f, 
    -0.09993886f, 0.05272276f, -0.02778255f, 0.01626874f, 0.01292728f, 0.04381627f, 0.10200039f, 0.05822885f, 
    0.11764760f, 0.14675356f, 0.00252383f, 0.03206466f, 0.02052312f, -0.10866121f, -0.00368418f, 0.04979356f, 
    0.00859714f, 0.11403421f, -0.06948882f, -0.04267864f, 0.25438139f, 0.12686390f, -0.04192640f, 0.22102115f, 
    -0.04858172f, -0.01997872f, 0.10788509f, 0.07447932f, -0.03306845f, -0.10692637f, 0.00583668f, -0.00604665f, 
    -0.10591038f, 0.02331235f, 0.10248044f, -0.13286538f, -0.06523871f, 0.11157385f, 0.05108789f, -0.08928488f, 
    0.05992913f, 0.00953448f, 0.03197457f, -0.04564286f, 0.20625868f, -0.29216865f, 0.12068202f, -0.01000395f, 
    0.11985154f, -0.09198342f, -0.06844396f, -0.00480331f, -0.05282046f, 0.01098869f, -0.01107068f, 0.05860935f, 
    0.02932833f, 0.04205709f, 0.00914529f, 0.04337004f, -0.04816382f, -0.05274056f, 0.04192084f, -0.00687826f, 
    -0.05053055f, 0.00875753f, -0.04117150f, -0.03647668f, -0.05453146f, 0.02288443f, 0.03953745f, -0.00201761f, 
    0.02839180f, -0.01696874f, -0.04674242f, 0.03109218f, 0.00456069f, 0.01613495f, -0.03817721f, 0.02301157f, 
    0.00165771f, -0.03805054f, 0.02155942f, -0.05772781f, -0.00526849f, -0.00722582f, 0.03629841f, -0.04719634f, 
    -0.02825801f, -0.05042526f, 0.04098519f, -0.05017952f, -0.03556335f, -0.02934343f, -0.04429659f, -0.01906327f, 
    -0.03768404f, -0.01601564f, 0.02234448f, 0.02341120f, 0.02737012f, 0.00906877f, 0.03064062f, -0.03213888f, 
    0.03419207f, 0.00030164f, 0.03632887f, -0.01409874f, -0.01509334f, -0.00110658f, 0.04051263f, -0.00716067f, 
    0.01853019f, 0.00793928f, -0.05118016f, -0.04336838f, -0.03318448f, -0.00436865f, 0.04394706f, -0.03286531f, 
    -0.04605542f, -0.01030746f, 0.02330676f, -0.03544012f, 0.03579567f, 0.03820847f, -0.01974595f, -0.03520715f, 
    -0.02225659f, 0.01019381f, -0.03343330f, 0.02902244f, -0.02255219f, -0.01203020f, 0.01642073f, -0.03789754f, 
    0.03373708f, -0.03885163f, 0.00857481f, -0.03889209f, -0.01976766f, 0.01833656f, 0.04421095f, -0.01180813f, 
    0.01342931f, 0.01279091f, -0.05842113f, -0.02754208f, 0.00107511f, -0.02021255f, -0.00209420f, -0.01097040f, 
    0.03206886f, 0.03315102f, -0.02977409f, -0.03336176f, -0.04335552f, 0.01221965f, -0.03831244f, 0.02523060f, 
    -0.01890851f, 0.03119250f, 0.04118842f, -0.02334876f, -0.05073394f, -0.03232155f, -0.01993161f, -0.01417813f, 
    -0.05501664f, -0.02492323f, 0.01972944f, -0.02707017f, -0.02830279f, 0.04012740f, 0.01421079f, 0.01084588f, 
    -0.05373402f, 0.02086941f, 0.03634220f, 0.01850007f, -0.02007508f, 0.03550844f, -0.02123867f, -0.03197449f, 
    -0.00012453f, -0.00929345f, 0.01749149f, -0.03775702f, -0.01592455f, 0.04569006f, 0.00365668f, 0.03773469f, 
    0.02362835f, -0.05053368f, -0.00223911f, 0.01161919f, 0.00866795f, -0.01761678f, -0.02283287f, -0.02144496f, 
    -0.04354892f, -0.03039573f, 0.01385244f, 0.03145869f, 0.00424123f, 0.01042124f, -0.02103821f, 0.02694711f, 
    0.02709910f, -0.03227323f, 0.02544431f, 0.00410923f, 0.00158462f, -0.03290885f, 0.00740697f, 0.01425573f, 
    0.02986806f, -0.02345519f, -0.00732433f, 0.02309270f, 0.00973571f, 0.03382177f, -0.03561007f, -0.05238702f, 
    -0.03783760f, -0.00420999f, 0.02873523f, -0.04809700f, 0.02869347f, -0.00888136f, -0.04717080f, 0.02422296f, 
    -0.01469740f, 0.01215965f, 0.01350814f, -0.04214446f, 0.05008971f, 0.04327031f, -0.04600018f, 0.02750608f, 
    -0.02693028f, -0.05656129f, -0.03011005f, -0.00534751f, 0.01969290f, -0.04180402f, 0.00556973f, 0.02312839f, 
    -0.01745522f, 0.02511805f, -0.02096843f, -0.01588110f, -0.06043607f, -0.02991485f, -0.01680222f, 0.03969581f, 
    -0.00201150f, 0.02104846f, 0.03182492f, 0.02618988f, 0.04811467f, -0.04227378f, -0.00516993f, 0.01995895f, 
    0.03230976f, -0.02363880f, -0.03900628f, -0.00918671f, -0.04828874f, 0.00965877f, 0.03228436f, -0.04569502f, 
    -0.04881746f, -0.04976822f, -0.00058616f, 0.01673783f, -0.01263232f, 0.00919150f, 0.02650918f, -0.03316745f, 
    0.00529361f, -0.04031358f, -0.02540060f, -0.05635765f, -0.03366667f, -0.00373888f, 0.02346358f, 0.02676180f, 
    0.02497958f, -0.02457796f, 0.00216139f, 0.02785745f, -0.04726914f, 0.00288282f, -0.05576065f, 0.02381419f, 
    -0.00568157f, -0.05578239f, -0.02333052f, 0.01392047f, -0.04951590f, -0.03380665f, 0.01149637f, -0.02383986f, 
    0.01726330f, -0.01518536f, -0.02375505f, 0.03060320f, -0.02397103f, -0.00789848f, -0.03601460f, 0.01025573f, 
    -0.05807205f, 0.03081774f, -0.04347817f, 0.03707417f, -0.02208575f, -0.02004979f, -0.00512234f, -0.02518364f, 
    -0.01777120f, 0.04501167f, -0.00519967f, 0.00105406f, 0.00418794f, -0.01519380f, -0.04901019f, -0.00652247f, 
    0.04159505f, -0.00042766f, -0.02707649f, -0.00268261f, 0.02188558f, -0.05721162f, -0.04950062f, -0.02286640f, 
    -0.04822822f, -0.00904028f, 0.00203052f, -0.01180001f, -0.02422817f, -0.00089117f, -0.04206692f, -0.05506166f, 
    -0.02082122f, -0.04587467f, -0.05147263f, 0.01050811f, -0.00175345f, -0.00661678f, -0.01101258f, 0.00894697f, 
    0.00527789f, -0.00252069f, -0.02235801f, 0.04220651f, 0.02915646f, 0.03683797f, -0.02301698f, 0.02442786f, 
    -0.04386506f, -0.04176511f, 0.01718383f, -0.02632190f, 0.04887422f, -0.01758362f, 0.04753067f, 0.04150517f, 
    -0.04047960f, 0.01022144f, 0.04742171f, -0.01157655f, 0.00032502f, 0.03425134f, -0.04831083f, 0.04214644f, 
    0.03049841f, -0.04328719f, 0.04230087f, -0.02801108f, -0.00233618f, -0.03041548f, -0.04063712f, -0.02156757f, 
    -0.00623371f, 0.02379197f, 0.03792579f, -0.03016995f, 0.02734479f, -0.00815471f, -0.04228001f, 0.00458314f, 
    0.03346974f, -0.04929022f, 0.02533101f, 0.03213816f, 0.00285826f, 0.00254101f, 0.00173183f, 0.03585889f, 
    0.01125062f, -0.00789434f, -0.05150823f, -0.02422446f, -0.03889748f, 0.01851524f, 0.01070658f, -0.04787991f, 
    -0.02148163f, 0.01416742f, -0.03622307f, -0.02971989f, -0.05133493f, 0.02057344f, -0.02761399f, 0.00417741f, 
    -0.04797439f, -0.01596332f, -0.03410594f, 0.00030615f, -0.05848636f, 0.01853716f, 0.04034859f, -0.00556874f, 
    -0.06130571f, -0.03769576f, 0.01983107f, -0.05508217f, -0.02015605f, 0.02709718f, -0.02419892f, 0.00817379f, 
    0.03247241f, 0.02161165f, -0.05316876f, -0.03906267f, 0.03474169f, 0.00257648f, -0.00015448f, -0.04032249f, 
    0.09512204f, 0.04664105f, -0.03852639f, -0.30323225f, -0.09977785f, 0.10450850f, 0.09726889f, -0.11118419f, 
    -0.12521686f, -0.08456124f, -0.22182605f, -0.08276488f, 0.04652537f, -0.05418745f, -0.06984885f, -0.04235319f, 
    0.07272863f, 0.00471065f, -0.05475492f, 0.08090886f, 0.08613309f, -0.00564343f, -0.05768737f, 0.03202913f, 
    -0.06954644f, 0.01560650f, 0.06110661f, 0.09176525f, -0.04251393f, -0.01049173f, 0.00881096f, 0.03251283f, 
    0.11599734f, 0.11964378f, 0.06127598f, 0.07698963f, 0.26197243f, -0.11374939f, 0.03242191f, 0.02063760f, 
    -0.09964854f, 0.07972095f, 0.09865391f, -0.11556605f, -0.01546573f, 0.08072846f, 0.19159055f, 0.13125144f, 
    0.09480157f, -0.15841176f, 0.21239056f, 0.15645067f, 0.05912274f, 0.00876638f, 0.06493197f, 0.08262804f, 
    0.17647110f, 0.05859268f, 0.04962541f, 0.04293640f, -0.01276641f, 0.03692401f, 0.00876800f, -0.07552267f, 
    -0.00575557f, -0.10378406f, 0.15165807f, -0.09123243f, -0.07778633f, 0.07865641f, 0.12104286f, -0.00249302f, 
    -0.08055548f, -0.26665905f, -0.04453736f, 0.20399581f, 0.02268607f, -0.08236259f, -0.06853560f, -0.01232133f, 
    0.06295145f, 0.06674816f, -0.07109188f, 0.01433920f, -0.01230878f, -0.17397480f, 0.13940863f, 0.03123414f, 
    -0.09424131f, -0.00668403f, 0.02375100f, -0.04827484f, 0.09703378f, -0.15139851f, 0.09538940f, -0.00395283f, 
    0.12663208f, 0.10406005f, -0.03201089f, 0.07045896f, -0.00520779f, 0.04659395f, 0.07461020f, 0.09718616f, 
    -0.03290109f, 0.04916892f, 0.07741884f, 0.11320086f, -0.20577027f, -0.15799047f, -0.01558868f, 0.28259811f, 
    0.08458374f, 0.03440553f, 0.11557777f, 0.03551897f, 0.08317667f, 0.06523666f, -0.04242017f, 0.12411559f, 
    -0.11025149f, 0.01562087f, -0.04830159f, -0.07225224f, -0.10725152f, 0.04992390f, 0.06392404f, -0.00497040f, 
    0.16187455f, -0.04942122f, 0.10093439f, 0.10895126f, 0.11536723f, 0.03799704f, 0.03692986f, 0.23520446f, 
    -0.02916298f, -0.02212639f, 0.00669986f, -0.04132823f, 0.11575552f, -0.00159456f, 0.00419917f, -0.01839013f, 
    0.06000302f, 0.08922755f, 0.18561597f, -0.07541819f, -0.01260160f, 0.00173924f, 0.02582167f, 0.02494365f, 
    0.05218980f, -0.03179609f, -0.04216002f, 0.02766271f, -0.27870762f, 0.01237350f, -0.08810206f, 0.17846604f, 
    0.09806918f, -0.04465165f, -0.09556346f, 0.03796661f, -0.04803795f, -0.01489367f, -0.00320318f, 0.09798206f, 
    -0.11093251f, -0.09305079f, 0.30484697f, 0.02372826f, 0.06744020f, 0.06484628f, -0.08596058f, -0.02606332f, 
    0.06881201f, 0.03495086f, 0.09884363f, -0.02005558f, -0.01472718f, 0.10305754f, -0.04503839f, 0.00109841f, 
    0.03529823f, 0.01926427f, 0.08978786f, -0.04924502f, -0.00381994f, 0.12411045f, -0.17094946f, -0.01934342f, 
    -0.00755484f, 0.08199952f, 0.08662590f, 0.15563892f, 0.03310478f, -0.00521845f, 0.00092338f, -0.11015236f, 
    -0.11422261f, 0.16570024f, -0.05191666f, -0.00649996f, 0.20870669f, 0.01451664f, -0.11233330f, -0.15846901f, 
    -0.16058582f, 0.07724157f, -0.09154362f, -0.09320309f, -0.01093077f, -0.12153360f, 0.05321890f, -0.02150973f, 
    -0.20510638f, -0.23811540f, 0.15242533f, 0.21352519f, 0.06688873f, 0.01688723f, 0.22021060f, -0.05913912f, 
    -0.00404516f, -0.09844859f, 0.06981099f, -0.03568166f, 0.26865882f, -0.00380111f, 0.07328597f, 0.27663177f, 
    -0.11887272f, 0.00409158f, 0.13890629f, 0.19266270f, 0.09334046f, -0.04575571f, 0.07127327f, -0.11313877f, 
    0.13560779f, -0.04634906f, -0.04112411f, -0.00512218f, 0.01019910f, -0.12787302f, -0.17605379f, 0.00095393f, 
    0.02554158f, 0.00674381f, -0.04410893f, 0.03289433f, -0.12028047f, 0.18620603f, -0.05562082f, 0.05889877f, 
    0.02123361f, -0.18977343f, -0.00775086f, 0.14540844f, 0.01023984f, -0.05118863f, -0.05641416f, -0.08117390f, 
    -0.12857527f, -0.08676647f, -0.05150637f, 0.31629422f, -0.01894828f, 0.03229852f, 0.08935200f, -0.01324705f, 
    -0.00187197f, -0.07267513f, -0.00171046f, -0.08035575f, 0.10999866f, -0.05682282f, -0.14107503f, -0.29883736f, 
    -0.03951393f, 0.16563620f, -0.08959585f, -0.07648270f, 0.04502228f, 0.03793785f, -0.00528122f, 0.16473328f, 
    0.25139794f, 0.09869561f, 0.21203220f, 0.06979492f, -0.06860954f, -0.04220536f, -0.00814718f, 0.05498373f, 
    -0.03335312f, -0.02247738f, -0.04734147f, 0.15848637f, 0.10139173f, -0.06728293f, -0.05930656f, -0.18271133f, 
    -0.00851348f, -0.06397312f, 0.12778066f, -0.10097832f, 0.02792084f, 0.04929546f, -0.24381603f, -0.06526887f, 
    -0.10396305f, 0.01726779f, 0.02950963f, -0.22730157f, 0.01609801f, -0.08501305f, 0.02819933f, 0.00160928f, 
    0.18437490f, 0.02900272f, -0.08747809f, 0.16663988f, -0.01611082f, -0.33198562f, -0.03565325f, 0.11785222f, 
    -0.03980580f, -0.05541047f, 0.10368748f, 0.03127095f, 0.10900398f, 0.05448093f, 0.07108020f, 0.05112161f, 
    0.00052613f, -0.20815313f, -0.13122191f, -0.23097368f, 0.04180186f, -0.05213526f, 0.13970099f, 0.01753453f, 
    0.00447923f, 0.05125766f, -0.06983250f, 0.04638088f, -0.07434919f, 0.00901247f, 0.01492592f, 0.00056299f, 
    -0.03663321f, -0.02865111f, -0.01846559f, 0.02981094f, -0.02570432f, -0.03049298f, 0.17972617f, -0.03195566f, 
    -0.37643641f, -0.06552435f, 0.26587194f, -0.02070423f, 0.09066802f, 0.03767926f, -0.04808356f, -0.02690554f, 
    0.20585984f, -0.01933426f, -0.06950009f, 0.04553240f, -0.10932384f, -0.32065436f, 0.03120764f, -0.14219934f, 
    -0.02802355f, -0.03452836f, -0.04727302f, 0.01681769f, 0.01061654f, 0.07149602f, 0.01577314f, 0.16717947f, 
    -0.11991115f, -0.20475695f, -0.13923575f, -0.14894293f, -0.00243965f, 0.05403668f, 0.06284912f, -0.00978779f, 
    0.12309733f, 0.03882197f, -0.08334852f, -0.01683613f, -0.22642221f, -0.00321670f, -0.02822988f, 0.11129384f, 
    0.00737294f, 0.06952113f, 0.07187145f, -0.01276382f, 0.03416448f, -0.00517263f, -0.00501630f, 0.07737339f, 
    -0.34383970f, -0.05814418f, 0.03383730f, -0.09305336f, 0.00483922f, -0.06619164f, -0.08992240f, 0.01870812f, 
    -0.01124735f, 0.08191966f, -0.14949161f, -0.01111059f, -0.09058238f, 0.01344006f, -0.00554770f, 0.02687743f, 
    0.00481787f, 0.16911429f, -0.01683483f, 0.00108703f, -0.06866206f, 0.07313686f, 0.04385482f, -0.01501744f, 
    -0.01245483f, -0.05637154f, -0.19287649f, 0.06477085f, 0.05052504f, 0.04209979f, 0.14641455f, 0.10071003f, 
    0.04638672f, -0.12552971f, -0.08441222f, 0.00027229f, 0.03044597f, -0.10410073f, 0.03601306f, -0.10321857f, 
    0.03161009f, 0.04521237f, 0.06508867f, 0.07029755f, 0.11270430f, -0.00149859f, 0.10218679f, 0.00819704f, 
    0.37057510f, 0.03965053f, 0.20268717f, 0.32262897f, -0.16086523f, 0.03569472f, 0.07858596f, 0.10857410f, 
    -0.01669367f, 0.12818538f, 0.07154261f, 0.08079790f, 0.16680823f, -0.07106888f, -0.16234197f, 0.10910378f, 
    0.09497920f, 0.04621897f, 0.06696212f, 0.11776454f, 0.07382298f, 0.05403545f, -0.09043438f, 0.18295193f, 
    -0.16952555f, 0.02400856f, 0.32185405f, 0.15492810f, -0.09888188f, 0.03647349f, -0.01266394f, 0.10201941f, 
    -0.00344406f, 0.00973817f, 0.02521457f, -0.02877419f, -0.22825465f, -0.02841777f, 0.12375265f, 0.15163676f, 
    -0.09066465f, 0.01573190f, 0.04439786f, 0.04099357f, 0.05881876f, -0.00636488f, -0.01624405f, -0.09434710f, 
    0.11003198f, -0.13683286f, 0.03325130f, -0.06473255f, -0.01156283f, -0.00240781f, 0.17109619f, 0.10158972f, 
    -0.16425200f, -0.00179573f, 0.09047197f, -0.02440163f, 0.02225574f, 0.12986058f, -0.14763428f, 0.08830078f, 
    0.05167117f, -0.01162748f, 0.06788678f, -0.11827920f, -0.01619934f, -0.00034205f, 0.11248083f, -0.03441543f, 
    0.03357564f, -0.14318077f, 0.09585752f, -0.02413613f, 0.07658245f, 0.06650642f, -0.05135005f, 0.00575908f, 
    0.06329802f, -0.05130018f, -0.00441067f, 0.06958597f, 0.09489042f, -0.11967488f, -0.07673968f, 0.09217171f, 
    -0.12197303f, -0.02048567f, 0.11142507f, 0.02250363f, 0.09767865f, 0.08259428f, 0.01524170f, -0.00430372f, 
    -0.08355223f, -0.21196499f, 0.19533996f, 0.05058938f, -0.06619387f, 0.01461660f, 0.01454360f, -0.05235116f, 
    -0.10736877f, 0.06708910f, 0.03184611f, 0.12875089f, -0.11085530f, 0.06180124f, -0.15368082f, -0.05390425f, 
    0.10478961f, 0.05985130f, 0.00708733f, 0.02217032f, 0.04190438f, -0.13655996f, -0.09745810f, 0.08609470f, 
    -0.01245650f, 0.08309566f, 0.13145405f, -0.06020660f, 0.06826601f, -0.02020617f, -0.14637899f, 0.02217791f, 
    -0.03162851f, 0.05160441f, -0.03576080f, 0.05161976f, -0.26305524f, -0.03532180f, -0.00015017f, -0.15002002f, 
    0.09414655f, 0.03456290f, 0.05467747f, -0.03288603f, 0.04899721f, 0.06605417f, 0.02310412f, 0.08872461f, 
    -0.17913052f, 0.14764282f, 0.10925775f, 0.01873316f, 0.01212140f, 0.00954737f, 0.04193790f, -0.06646401f, 
    -0.00646854f, 0.06234029f, -0.00411934f, 0.02423223f, 0.05397835f, 0.20021208f, 0.12405137f, 0.00133254f, 
    -0.02528706f, 0.10761608f, 0.06462795f, 0.07884195f, -0.11585003f, -0.12726179f, -0.03174343f, -0.06470674f, 
    0.04224897f, 0.10221506f, -0.05153485f, 0.15636839f, 0.04865646f, 0.11866699f, -0.02828508f, 0.10778596f, 
    -0.06115867f, 0.02990337f, 0.05331914f, -0.09551124f, -0.06584316f, 0.06746968f, -0.11219244f, 0.07751165f, 
    0.08526827f, 0.13672340f, 0.10016442f, 0.01125760f, -0.10214873f, 0.07696904f, 0.00766790f, 0.02339027f, 
    -0.02994699f, 0.11361864f, 0.07230151f, 0.04843067f, -0.03247911f, 0.08321747f, 0.08944640f, 0.05627506f, 
    0.07327443f, 0.00618432f, 0.01326573f, -0.05668660f, 0.03941723f, -0.15296015f, 0.05986166f, -0.16467223f, 
    0.16717511f, -0.06647347f, -0.07551570f, -0.10312802f, 0.04550304f, 0.01777661f, 0.14958289f, 0.11954106f, 
    -0.06856549f, -0.13023834f, 0.25274077f, 0.18229897f, -0.07050151f, 0.02329008f, -0.04153333f, -0.07773176f, 
    0.04809646f, -0.04037793f, -0.02430122f, 0.00287697f, 0.00413567f, -0.02575524f, 0.00435932f, -0.05721755f, 
    -0.03615881f, -0.00684962f, -0.09591199f, -0.06595822f, 0.04509161f, -0.01145177f, -0.08559436f, 0.03186796f, 
    -0.20164731f, 0.00660986f, -0.15803787f, 0.01417477f, 0.03122073f, -0.04982650f, 0.05864779f, 0.00792579f, 
    -0.01862689f, 0.00390817f, 0.00674040f, 0.10782001f, 0.40376407f, -0.02146831f, 0.09868531f, 0.24027519f, 
    -0.13183990f, 0.05954590f, 0.08244295f, 0.07510504f, 0.07471494f, -0.01882511f, 0.05316464f, 0.01966139f, 
    -0.09280425f, -0.10122683f, -0.08164549f, 0.00084855f, 0.03988035f, 0.02311543f, -0.01198535f, 0.05935740f, 
    0.01915376f, 0.04636345f, -0.05755439f, 0.04903234f, 0.06803813f, 0.15878206f, 0.03586803f, -0.05085987f, 
    0.00661026f, 0.02192372f, -0.09671842f, 0.06621107f, -0.06172145f, -0.08162938f, 0.00758146f, 0.02929126f, 
    0.26922294f, 0.14133927f, 0.01348286f, 0.00920156f, -0.07998746f, 0.03501717f, 0.09647361f, -0.01811352f, 
    -0.02159896f, -0.03202266f, -0.05209037f, 0.02499817f, 0.45441699f, -0.19024275f, 0.16244136f, -0.14183886f, 
    -0.07623985f, -0.15470117f, 0.00599732f, 0.00974919f, -0.12406020f, -0.06813974f, 0.02381495f, 0.07124685f, 
    -0.05841900f, -0.04798124f, -0.05175314f, 0.03348301f, -0.03386460f, -0.02468326f, -0.00681845f, -0.04320653f, 
    0.00698915f, -0.00681584f, -0.02592368f, 0.00372178f, -0.01429538f, 0.00592298f, 0.04976670f, 0.02937636f, 
    0.01087707f, -0.02153268f, -0.01842172f, 0.03554126f, -0.01175610f, -0.04850044f, -0.02574052f, 0.02140186f, 
    -0.00113572f, -0.03301324f, -0.00857354f, -0.02867598f, 0.04298892f, 0.01879090f, -0.00569983f, -0.01269703f, 
    -0.03632965f, -0.04806533f, -0.01098383f, -0.02088441f, -0.00325947f, 0.03514498f, 0.04121692f, -0.01406260f, 
    -0.04943379f, -0.04106961f, 0.04375061f, -0.03916233f, -0.00396205f, -0.03817021f, -0.04968092f, 0.01726157f, 
    -0.04974835f, 0.01982526f, 0.03339101f, -0.04314474f, -0.02634773f, 0.03807413f, 0.04008662f, -0.00164861f, 
    -0.04267755f, 0.01540199f, 0.03406870f, -0.00193664f, -0.01019431f, -0.03535764f, -0.04886547f, 0.00119624f, 
    -0.00758566f, -0.04058838f, -0.03758466f, 0.02216357f, -0.00732459f, -0.03683635f, 0.00048483f, 0.01885480f, 
    0.00482098f, 0.01001966f, 0.03742828f, -0.03079188f, -0.03731652f, -0.04975718f, -0.04729883f, 0.00671994f, 
    0.00975860f, 0.02114079f, 0.01398510f, -0.04575811f, 0.01329998f, -0.00899828f, 0.00757441f, 0.00380729f, 
    0.03306988f, -0.04888704f, -0.04507614f, -0.05593671f, 0.01163069f, 0.03993370f, -0.02363838f, -0.04658826f, 
    -0.00345523f, 0.00929315f, 0.02343197f, -0.04400944f, 0.04268324f, -0.04033456f, 0.02469805f, 0.03824624f, 
    -0.02821538f, 0.03368057f, -0.04234157f, -0.04705225f, 0.04265429f, -0.00022772f, -0.00696513f, 0.00986487f, 
    0.02556784f, 0.00754036f, 0.03778739f, 0.04633275f, -0.00739603f, 0.03164971f, 0.02916434f, -0.03593682f, 
    0.03293993f, 0.04618192f, -0.01634253f, -0.02861821f, 0.00836263f, -0.03347851f, -0.06003791f, -0.03884081f, 
    -0.05939127f, -0.03003387f, 0.01187009f, 0.02898293f, 0.01750165f, -0.04424400f, 0.00681830f, -0.02858135f, 
    0.01439164f, 0.02261010f, 0.00270977f, 0.04782061f, -0.01696684f, -0.03451465f, 0.04167209f, 0.00276980f, 
    0.02320135f, 0.02666721f, 0.04323702f, -0.03917224f, -0.02165318f, 0.01202429f, -0.02442407f, -0.03205439f, 
    -0.03236855f, -0.02654108f, 0.00689439f, 0.01002603f, 0.00696191f, 0.01039939f, 0.02032115f, 0.02034390f, 
    0.04212807f, -0.04557832f, -0.04523711f, -0.02885774f, -0.05183878f, -0.03639543f, 0.02347711f, -0.04596577f, 
    0.02336426f, 0.01227428f, -0.01159040f, -0.02512933f, -0.02902205f, 0.01984318f, 0.00914365f, 0.02133421f, 
    -0.01625947f, -0.03942462f, 0.05168296f, 0.04005561f, -0.01662464f, 0.04315969f, -0.02349214f, 0.02164584f, 
    -0.04878483f, 0.02143723f, 0.02189026f, -0.01120014f, 0.00795957f, 0.02716920f, 0.03686812f, -0.01460650f, 
    -0.05283403f, 0.03332026f, -0.03935480f, -0.02370006f, 0.02485947f, 0.00647795f, -0.01737993f, -0.04897001f, 
    -0.02172296f, -0.03297861f, -0.04575071f, 0.00136885f, -0.00967549f, -0.00479615f, -0.00587324f, 0.03444754f, 
    0.04142298f, -0.01886608f, -0.00765853f, -0.02895250f, -0.02231862f, -0.04301674f, -0.04123066f, 0.02664729f, 
    -0.03172224f, -0.00058198f, -0.01024331f, -0.00316755f, 0.00608160f, 0.03489612f, -0.01533642f, -0.00009139f, 
    -0.05205287f, -0.02788986f, -0.03247184f, -0.00494130f, 0.04129798f, -0.03056533f, -0.04165963f, -0.04050168f, 
    -0.05291336f, 0.04214485f, -0.00947120f, 0.02564161f, -0.04599715f, -0.05551824f, 0.04363989f, -0.00411093f, 
    -0.05552891f, -0.04772368f, 0.01617269f, 0.01495628f, 0.03317859f, -0.02608783f, 0.01419399f, -0.03880115f, 
    -0.04896932f, -0.05432563f, 0.01513351f, 0.04243493f, -0.04015280f, -0.02902145f, -0.04457664f, 0.00965384f, 
    -0.01880691f, -0.02998917f, -0.01735828f, 0.03438374f, 0.02090601f, 0.02647397f, -0.00404329f, 0.00346285f, 
    -0.04668263f, -0.00977692f, 0.00498661f, 0.02447352f, 0.00398680f, 0.01777157f, 0.03019065f, -0.03479962f, 
    -0.00576915f, -0.00821386f, -0.04339606f, -0.05834630f, -0.00619674f, 0.02727934f, 0.02060119f, 0.01227222f, 
    0.00692222f, 0.00089749f, 0.03111586f, -0.01890586f, -0.05744464f, 0.01768637f, -0.04034536f, -0.01214625f, 
    -0.03795720f, 0.04076092f, -0.03607170f, -0.01993557f, 0.00732002f, 0.01248853f, 0.04800970f, 0.04053142f, 
    0.04362551f, 0.02933829f, -0.02949419f, 0.01921331f, -0.04439759f, -0.02496525f, -0.02688906f, -0.01104726f, 
    0.03773415f, -0.00150736f, 0.00404828f, 0.03157328f, 0.03108255f, 0.00123270f, -0.04594094f, -0.00154156f, 
    -0.02450360f, -0.00662683f, -0.02736273f, 0.00221668f, -0.01904891f, 0.02679343f, 0.02282825f, 0.00999183f, 
    -0.00405265f, -0.05750556f, -0.01618265f, 0.04179559f, -0.04384044f, -0.00707589f, -0.05147109f, -0.03629186f, 
    -0.02700871f, -0.02330287f, -0.03856307f, 0.02995588f, -0.04633665f, -0.03159152f, -0.03161449f, -0.04085105f, 
    -0.00346848f, 0.03989721f, -0.04337413f, 0.04216317f, -0.02922003f, 0.03204821f, 0.03545343f, -0.03262915f, 
    0.00113062f, -0.02085769f, -0.04285872f, 0.01569078f, 0.03489606f, 0.04007418f, -0.01374655f, -0.01057092f, 
    -0.02406265f, 0.01060741f, 0.01593552f, -0.03847578f, 0.01184132f, -0.00780993f, -0.01500782f, -0.04530581f, 
    -0.05766758f, 0.01954986f, 0.03681983f, -0.00338640f, -0.03428243f, 0.01693433f, 0.02800030f, 0.01990744f, 
    0.00726692f, 0.02611520f, 0.02176708f, -0.00881460f, -0.03400654f, -0.01645406f, 0.02932298f, 0.03930477f, 
    0.03508623f, 0.03634997f, 0.02034996f, -0.04429839f, -0.04282458f, 0.03352156f, 0.02255289f, -0.00957249f, 
    -0.25650463f, -0.02335817f, 0.00233067f, -0.00457459f, -0.07978870f, 0.04578314f, 0.00072564f, -0.00764459f, 
    -0.07991533f, 0.02935648f, 0.00589979f, -0.12932403f, 0.24965660f, -0.21223067f, -0.03967607f, 0.11930786f, 
    -0.02389860f, 0.02858283f, 0.02059835f, -0.09636752f, 0.06243341f, 0.06308182f, -0.00291894f, -0.01234782f, 
    -0.05760799f, -0.11504227f, 0.22632420f, -0.03615230f, 0.04109212f, -0.03361610f, 0.10142322f, 0.10411504f, 
    0.12763733f, -0.11387465f, 0.12139681f, 0.14152254f, 0.24609178f, -0.09809303f, -0.13423660f, 0.06909847f, 
    -0.01541499f, -0.02001405f, 0.07179525f, 0.09695818f, 0.04965059f, 0.04277302f, -0.02056965f, -0.00367833f, 
    0.07876947f, -0.16710524f, 0.17590787f, -0.10300132f, 0.08813810f, -0.10290270f, -0.01083241f, 0.08641451f, 
    0.06781288f, 0.15285894f, -0.08210524f, 0.13424876f, -0.16833542f, -0.08479652f, -0.09565852f, -0.00034346f, 
    -0.00521974f, 0.03392790f, -0.03399781f, -0.03299540f, -0.05683007f, 0.04882064f, 0.00267254f, -0.01972665f, 
    -0.26464358f, -0.11119183f, -0.01687696f, 0.11114839f, -0.04023477f, -0.08489302f, -0.03313079f, -0.08402750f, 
    0.02708847f, 0.01067971f, -0.01593579f, -0.10260387f, 0.08614150f, -0.10896798f, 0.07023989f, 0.24088016f, 
    -0.02526072f, -0.06543561f, 0.05916056f, -0.07198028f, 0.01747375f, -0.15926471f, -0.02691856f, 0.02860357f, 
    0.08481593f, 0.01580889f, -0.23363000f, -0.17507206f, 0.13126956f, 0.15514298f, 0.02944705f, -0.02720628f, 
    0.03496994f, -0.00984135f, -0.16445725f, -0.16042635f, 0.29808414f, -0.13582154f, -0.11556077f, -0.03434432f, 
    0.13116901f, -0.05440998f, 0.06958466f, 0.05390296f, -0.12998320f, 0.02753549f, 0.05203873f, -0.10226699f, 
    -0.04407989f, 0.13047555f, 0.09123562f, -0.14503184f, -0.08238579f, 0.15352599f, -0.06667347f, 0.06057509f, 
    0.02850883f, 0.00820732f, -0.00074918f, 0.02950907f, 0.18956821f, 0.07785296f, 0.10068084f, 0.19025575f, 
    -0.01561931f, 0.06751090f, 0.05688488f, 0.06074431f, -0.01468049f, -0.03403963f, 0.00925031f, -0.00259041f, 
    -0.09679908f, 0.36425072f, 0.05069083f, -0.05113237f, -0.14351186f, -0.03102771f, -0.04586670f, 0.01796814f, 
    0.06313412f, 0.07627375f, -0.05489576f, -0.05853704f, 0.12001293f, 0.03438796f, -0.08275919f, 0.07716681f, 
    0.02987587f, 0.10217816f, -0.04207619f, 0.10506658f, -0.06977680f, 0.04774552f, 0.00526543f, 0.00850187f, 
    -0.13753614f, -0.03822350f, 0.16248548f, 0.04761264f, 0.06201254f, -0.02070997f, 0.01605703f, -0.11290875f, 
    0.10554159f, 0.09367582f, -0.00769065f, 0.06001798f, 0.29088306f, -0.17738052f, 0.03963377f, 0.12036911f, 
    -0.01416626f, -0.15004842f, -0.04605950f, -0.00661426f, 0.06415215f, 0.07900806f, -0.11156040f, -0.01823537f, 
    0.09566840f, -0.00568256f, -0.13164821f, 0.07890027f, 0.05177220f, -0.05344329f, -0.00671996f, -0.03519127f, 
    0.02440651f, 0.11082816f, 0.00713556f, -0.06166313f, -0.10466185f, -0.18824941f, -0.08299729f, -0.34109443f, 
    -0.05884365f, -0.11316702f, 0.02558226f, -0.00063410f, -0.01740642f, -0.04227642f, 0.01719017f, -0.00964850f, 
    0.15963459f, 0.08271507f, -0.00671578f, 0.05561488f, -0.01205490f, 0.06568348f, 0.02121978f, 0.04213648f, 
    0.07802600f, 0.02398944f, -0.00107956f, -0.00362561f, 0.04608604f, 0.15182936f, -0.05573773f, 0.11106709f, 
    0.05026980f, 0.03918967f, 0.12220233f, -0.01525304f, 0.15630652f, 0.04759577f, 0.08804554f, 0.01063089f, 
    0.04844804f, 0.10712619f, -0.08144020f, -0.00018120f, 0.03384778f, -0.10884757f, -0.11232320f, -0.12052479f, 
    -0.01449938f, 0.02006730f, 0.11245644f, -0.05232731f, -0.13041653f, 0.11835719f, 0.08619317f, 0.31521463f, 
    -0.07906450f, -0.17029603f, 0.01251331f, 0.08979286f, 0.05652107f, -0.01873702f, 0.00954424f, 0.06086618f, 
    -0.15272683f, -0.05624833f, 0.01822631f, 0.22462268f, 0.03013082f, -0.02956124f, -0.03621681f, -0.03483762f, 
    -0.06098374f, 0.10828337f, 0.05536648f, -0.04929120f, -0.01255899f, 0.17716444f, 0.06467459f, -0.06533998f, 
    -0.19627221f, 0.11908712f, 0.01591809f, 0.17219408f, -0.02498538f, 0.05345817f, -0.09538636f, 0.06366317f, 
    -0.04545231f, 0.14234102f, 0.23439570f, -0.03077300f, -0.01815149f, 0.05891455f, 0.04872588f, -0.03280177f, 
    -0.03150071f, 0.03959690f, 0.05925255f, 0.01805702f, 0.04939146f, -0.01247287f, -0.09630409f, -0.08938213f, 
    0.00019247f, -0.05260436f, 0.11970742f, -0.03447023f, -0.09127598f, 0.05237573f, -0.02673911f, -0.03203432f, 
    -0.16122982f, 0.08168889f, -0.03780511f, -0.05921653f, 0.03222889f, -0.11785021f, 0.05138465f, 0.03269264f, 
    0.08249530f, -0.04024950f, -0.02637808f, 0.09944183f, -0.19934750f, -0.16715501f, 0.00996547f, 0.04643927f, 
    0.03387957f, -0.02528772f, 0.04865297f, -0.12670992f, -0.08332972f, -0.02555752f, 0.01119011f, -0.05488374f, 
    -0.14685498f, -0.09742448f, -0.03890612f, -0.26093620f, 0.04671171f, -0.03113349f, 0.07755297f, 0.07171639f, 
    0.02428288f, -0.02632259f, -0.09098454f, 0.09022333f, 0.20801738f, -0.02171081f, 0.01814040f, -0.06211963f, 
    0.07046670f, 0.06295852f, -0.00358409f, -0.01211453f, 0.05319866f, 0.09949081f, 0.12637593f, -0.00333645f, 
    0.10960333f, -0.14053668f, 0.08947517f, -0.05809215f, 0.01837188f, -0.03284358f, -0.09436115f, 0.12354006f, 
    0.09373382f, -0.05005160f, 0.03585408f, -0.08561714f, -0.06929586f, 0.00232993f, 0.05020824f, -0.02794743f, 
    -0.01000672f, 0.02839349f, -0.04099617f, 0.12214026f, 0.07371005f, 0.14007400f, -0.00026996f, 0.07407828f, 
    0.13574784f, -0.01228715f, -0.13847013f, -0.03025860f, 0.04372378f, 0.05223776f, 0.10369042f, -0.09390434f, 
    0.07672007f, 0.06375588f, 0.06507589f, 0.17332570f, -0.43523961f, 0.20783117f, 0.03826117f, -0.06266008f, 
    0.04944443f, 0.01236663f, 0.03737608f, -0.01246072f, -0.03149226f, -0.04907461f, -0.02616601f, -0.03181444f, 
    0.28625533f, 0.12922579f, 0.12118463f, 0.12541212f, -0.01245987f, 0.10306972f, -0.01922188f, 0.09217249f, 
    -0.05548653f, 0.12113696f, -0.10455028f, -0.05366957f, -0.27018586f, -0.18324190f, 0.21462263f, 0.06322746f, 
    -0.02327100f, 0.09622572f, 0.02624746f, -0.07748878f, 0.06960962f, -0.09960140f, -0.17999609f, -0.09894900f, 
    0.28823185f, 0.10778342f, 0.06235683f, -0.04248147f, 0.11560988f, 0.07444823f, 0.10945125f, 0.03380644f, 
    -0.04725285f, -0.19100253f, -0.05327725f, -0.08095278f, 0.14451791f, -0.04343182f, 0.02187016f, 0.08894879f, 
    -0.00254825f, 0.06312659f, 0.00880456f, 0.11979210f, 0.06509841f, -0.04901529f, 0.03474858f, -0.02012596f, 
    0.48838171f, 0.10688904f, 0.12544641f, 0.05468370f, -0.14291348f, 0.06809845f, 0.03765721f, 0.04038013f, 
    0.01842072f, 0.05270681f, 0.06164786f, -0.03794995f, 0.22342375f, 0.08074477f, 0.04424434f, 0.02589555f, 
    -0.03870561f, 0.05601405f, 0.10968553f, 0.02823603f, 0.05635463f, 0.19585085f, 0.08944691f, 0.15595183f, 
    0.03845490f, -0.16381513f, 0.16533346f, 0.39805502f, -0.12309445f, -0.06344879f, -0.01192776f, 0.06605873f, 
    0.03184835f, -0.03197313f, -0.00465616f, -0.15323409f, 0.04187932f, -0.11283548f, 0.00909863f, 0.18651851f, 
    -0.10417999f, -0.01555713f, 0.02550146f, -0.01196365f, 0.02150821f, 0.03449943f, -0.03287567f, -0.14375156f, 
    0.13521065f, -0.06770396f, -0.10953019f, 0.07905446f, -0.02825561f, 0.01377340f, 0.03315119f, -0.01510902f, 
    -0.05097994f, -0.00281090f, -0.00545162f, 0.02207120f, 0.11512775f, 0.07571883f, -0.03586788f, -0.14548534f, 
    0.05372149f, -0.02372475f, -0.00670257f, -0.08323694f, -0.06118532f, -0.04554467f, 0.06740806f, -0.04900365f, 
    -0.03769509f, -0.26823398f, -0.04843516f, -0.06389435f, 0.05875396f, 0.00648391f, 0.08942435f, -0.05440804f, 
    -0.09055997f, 0.10119016f, -0.03089875f, -0.00648056f, 0.07375216f, -0.02173914f, -0.19992355f, -0.02174671f, 
    -0.06917965f, -0.06443913f, -0.00415534f, -0.05718251f, 0.04299293f, 0.02897233f, -0.05084539f, -0.05407493f, 
    0.15615879f, -0.11046740f, 0.09327593f, 0.15076125f, -0.09219298f, 0.00978716f, 0.05715113f, -0.01441944f, 
    -0.03152742f, -0.05630019f, -0.01091205f, 0.06193633f, -0.49144953f, 0.24675073f, -0.03238204f, -0.06439852f, 
    -0.00187987f, 0.08755185f, 0.07888239f, 0.08943367f, -0.04989723f, -0.23142678f, 0.04526456f, 0.03928951f, 
    0.05865375f, -0.00010270f, 0.04356918f, -0.06778852f, 0.07347167f, -0.02963695f, 0.07219746f, 0.07947947f, 
    -0.07966063f, 0.08220647f, 0.01474440f, 0.03788729f, -0.13395464f, 0.01627238f, -0.00576313f, -0.03364146f, 
    -0.02534401f, 0.15993509f, -0.01083104f, -0.04917338f, 0.06607713f, -0.00901375f, 0.07184182f, 0.13395685f, 
    -0.17777567f, -0.14588830f, 0.10047016f, -0.02102293f, 0.03507724f, -0.03181602f, 0.05773358f, 0.07991529f, 
    0.01953124f, 0.01876551f, 0.09278143f, -0.00104464f, 0.21048571f, 0.13750613f, 0.09719773f, -0.05166204f, 
    -0.03438067f, 0.01197301f, -0.02305003f, -0.01329416f, -0.03772283f, -0.03546666f, 0.06050955f, 0.13061415f, 
    -0.18789646f, -0.09612273f, -0.09385429f, 0.07653252f, -0.07416196f, 0.10676779f, 0.11253730f, -0.06052208f, 
    0.06217936f, 0.02019447f, 0.14902426f, 0.01856571f, -0.04434702f, 0.16799089f, 0.07129925f, -0.16139784f, 
    0.15048723f, 0.07539912f, 0.11515630f, 0.07252599f, 0.13042839f, 0.17450009f, 0.14772201f, -0.01366744f, 
    0.05099179f, -0.06277788f, 0.01063282f, -0.15016234f, 0.08693689f, -0.10284823f, 0.09159398f, 0.02533305f, 
    -0.02208536f, 0.07776393f, -0.11298241f, 0.08103152f, -0.04511916f, -0.17581327f, -0.11591250f, 0.01645764f, 
    0.06748283f, -0.10631078f, 0.06904254f, -0.10443728f, -0.05936965f, 0.02540885f, 0.06774084f, 0.11335150f, 
    0.05449260f, 0.02033914f, 0.03033169f, 0.17265928f, 0.01804106f, 0.01432366f, 0.05306037f, -0.09710318f, 
    0.09301293f, -0.07862274f, -0.13092674f, -0.06555699f, -0.25254387f, -0.08397989f, -0.07748511f, -0.00082932f, 
    0.01894497f, 0.03568884f, -0.03282664f, -0.06389263f, -0.01135988f, -0.05526517f, 0.11492081f, 0.07590124f, 
    -0.22535107f, 0.04216136f, 0.15686387f, 0.01725408f, 0.04594487f, 0.13238057f, 0.11988939f, 0.01566613f, 
    -0.07150400f, 0.09849079f, 0.01105497f, -0.02463904f, 0.33311382f, 0.16812868f, 0.10347986f, 0.04797504f, 
    -0.15113810f, 0.00599375f, -0.00445863f, 0.07241888f, 0.01207091f, 0.03535090f, -0.06436987f, -0.07679959f, 
    -0.03398890f, -0.01502278f, -0.01315355f, 0.07649036f, -0.04811631f, 0.09319088f, -0.00942721f, 0.10234584f, 
    0.09689196f, -0.02926896f, 0.07725486f, -0.00565553f, -0.15192643f, -0.11558640f, 0.06009557f, -0.04767266f, 
    0.01801424f, 0.06217309f, -0.01306506f, -0.02574641f, -0.09716823f, 0.02862757f, 0.07549767f, 0.19637297f, 
    0.10817835f, -0.00234581f, 0.09961587f, 0.26425946f, -0.04637755f, -0.02512878f, 0.02005391f, 0.03959204f, 
    -0.04640646f, 0.01717925f, -0.01259499f, 0.02343153f, 0.29397678f, 0.07528815f, -0.15974191f, 0.01968452f, 
    -0.03899738f, 0.04124577f, -0.08377901f, 0.02943777f, -0.07141216f, -0.06934927f, -0.06303546f, 0.04432553f, 
    -0.23942052f, -0.17157002f, 0.00976446f, 0.02275797f, 0.07407226f, -0.02403647f, -0.00874957f, 0.04034934f, 
    0.10891259f, 0.03174625f, 0.09384979f, -0.04886146f, -0.47787747f, 0.19456764f, -0.07992860f, 0.04531683f, 
    0.11043341f, -0.00984068f, 0.01220180f, 0.09171169f, -0.00836880f, 0.03169986f, 0.00377540f, -0.07012536f, 
    -0.27854508f, 0.08165752f, 0.01170374f, -0.02135307f, 0.02526568f, -0.14509675f, -0.01382282f, 0.06570043f, 
    0.02099189f, -0.08575238f, -0.13399881f, 0.14376482f, -0.22328462f, 0.05065753f, -0.03604797f, 0.08655047f, 
    0.07064144f, 0.03354316f, -0.04926655f, 0.16906525f, -0.02421459f, 0.07110611f, -0.03045048f, 0.11360614f, 
    0.33092961f, -0.03885949f, -0.06838010f, -0.04144013f, 0.10362720f, 0.03812474f, -0.00853418f, 0.09824073f, 
    -0.03301053f, -0.11000934f, 0.06523190f, -0.10341762f, 0.26929003f, 0.19577688f, -0.07154411f, 0.16272113f, 
    -0.00294300f, 0.13786505f, 0.02039547f, 0.15475105f, 0.14385989f, -0.00746514f, 0.08978882f, 0.03869364f, 
    0.17725392f, -0.00976872f, 0.07416546f, -0.02529145f, 0.03893036f, 0.01226568f, 0.04518363f, -0.07224361f, 
    0.08022378f, -0.04727884f, 0.00108526f, -0.01622364f, 0.07707269f, 0.03567750f, 0.02687481f, 0.07316788f, 
    0.02605372f, -0.07353099f, 0.10079829f, -0.02111008f, -0.08226784f, 0.11456266f, 0.07356358f, 0.05026077f, 
    -0.07750530f, -0.17547287f, 0.13717666f, 0.29787758f, 0.06136007f, 0.05057587f, 0.04043846f, 0.00097848f, 
    0.05530530f, -0.01635286f, 0.03896516f, -0.01517963f, 0.31562132f, 0.14478277f, 0.09488722f, 0.00995182f, 
    -0.00887108f, -0.00654876f, -0.02540315f, 0.01836652f, -0.00405387f, -0.05474335f, -0.06264877f, 0.07789221f, 
    0.43133470f, 0.13315383f, -0.06356846f, 0.21770577f, -0.04337237f, 0.04486918f, -0.08994078f, 0.17931563f, 
    0.00302174f, 0.02935633f, -0.01377333f, 0.11768586f, 0.04483787f, 0.06308009f, 0.01690491f, -0.18087436f, 
    0.08317444f, -0.15962318f, 0.12559207f, -0.03018242f, 0.04917771f, 0.05675591f, -0.00092451f, 0.03049835f, 
    -0.01782210f, -0.12399565f, -0.14686085f, -0.08213222f, 0.01749291f, -0.07844502f, -0.04555591f, -0.03103952f, 
    0.07597451f, -0.03559648f, 0.02722249f, -0.09659396f, 0.57372117f, -0.06276924f, -0.12731037f, -0.26769370f, 
    0.00492068f, 0.08310982f, -0.07015830f, 0.09826395f, 0.13204007f, 0.09414955f, -0.05105048f, 0.10527351f, 
    0.38995263f, 0.09879551f, 0.02575758f, 0.21659654f, -0.06192357f, 0.02098222f, 0.03187958f, 0.07222676f, 
    -0.12830815f, -0.00366339f, 0.04356958f, 0.11611018f, -0.24182737f, 0.06264579f, -0.12580228f, 0.14731821f, 
    0.04831870f, -0.06113338f, 0.04139440f, 0.03101694f, 0.02679670f, -0.07654160f, 0.11874310f, -0.05333236f, 
    0.29688248f, -0.03710026f, -0.07734338f, -0.04527663f, 0.04097845f, 0.05194984f, 0.17001410f, 0.13269433f, 
    0.06920642f, -0.05690030f, 0.15979815f, 0.14051582f, -0.68544781f, -0.22162735f, 0.05608639f, 0.05385510f, 
    0.05296710f, 0.05092929f, -0.03091541f, -0.06532886f, 0.03369868f, -0.01923802f, 0.04581195f, 0.05535340f, 
    -0.11967609f, 0.01732500f, 0.06191476f, -0.09872893f, 0.04482725f, -0.09548371f, -0.01679218f, 0.00114933f, 
    -0.02958466f, 0.03784920f, -0.07610863f, 0.08645936f, -0.18571748f, -0.00591405f, 0.11030484f, -0.10564362f, 
    -0.05868429f, 0.06480104f, 0.20019738f, -0.01468462f, 0.03291920f, -0.12004824f, -0.05297351f, -0.01257805f, 
    -0.23802933f, 0.20076491f, -0.03773395f, 0.07608308f, -0.00421453f, 0.10612356f, 0.06701524f, -0.03059488f, 
    -0.03609236f, 0.04946759f, -0.01961079f, -0.05514729f, -0.31110561f, 0.12037681f, 0.12175299f, -0.04968975f, 
    0.01186444f, -0.02003637f, 0.05509359f, -0.10971806f, -0.03750159f, 0.11754964f, 0.05591245f, 0.03962445f, 
    -0.10659300f, 0.20034705f, 0.16722089f, -0.07128520f, 0.22479364f, -0.01783090f, -0.04112468f, 0.09105358f, 
    0.04156089f, 0.01408446f, -0.03116252f, 0.01125034f, -0.05173340f, -0.03924479f, 0.05025811f, 0.03861059f, 
    0.02492378f, -0.03272782f, 0.01951829f, 0.03841449f, 0.00479108f, 0.01849589f, 0.03293996f, -0.00374461f, 
    -0.59773076f, -0.06968016f, -0.04896619f, 0.14895026f, 0.14629355f, -0.10407278f, 0.13912211f, -0.01333963f, 
    0.10409155f, 0.09539376f, -0.03696645f, -0.01756532f, -0.16719350f, -0.07218803f, -0.07317185f, -0.02161241f, 
    0.08649829f, 0.05043725f, 0.01159547f, -0.05686432f, -0.08377497f, 0.07044925f, -0.03562642f, 0.07997762f, 
    -0.27253300f, -0.06506301f, -0.08978825f, 0.19700369f, 0.02631276f, 0.01938758f, 0.09231187f, 0.06197516f, 
    -0.05264086f, 0.03442967f, -0.11567709f, 0.09574071f, 0.15391402f, 0.01851079f, -0.00443327f, 0.03214196f, 
    -0.03468379f, 0.06506430f, 0.01580300f, -0.05076464f, 0.00965762f, -0.02226144f, 0.01379615f, 0.08670148f, 
    -0.11282967f, 0.13240108f, 0.07954816f, 0.00225832f, 0.00472373f, 0.04862586f, -0.02077519f, -0.00224536f, 
    -0.02409304f, 0.15509945f, -0.10829303f, -0.07763547f, -0.16691896f, 0.07297021f, -0.09914863f, 0.01294717f, 
    0.08475059f, 0.06504957f, 0.14360134f, -0.12664515f, 0.01416086f, 0.02332849f, -0.03918864f, -0.05846201f, 
    0.25320676f, 0.19789302f, 0.02426095f, 0.00582783f, 0.04259507f, -0.01661259f, -0.01600846f, 0.05546804f, 
    -0.11508365f, 0.05047144f, 0.10477801f, -0.17977600f, 0.23248777f, 0.18069606f, -0.15890285f, 0.09892405f, 
    0.09352296f, 0.06432503f, -0.13086008f, -0.10477033f, -0.00627245f, 0.01404540f, -0.09018120f, -0.03697761f, 
    -0.00480985f, 0.04190204f, 0.00912471f, 0.03624463f, -0.01748548f, 0.02613818f, -0.01146222f, -0.01793301f, 
    0.02807851f, 0.00371831f, -0.00848426f, 0.02744244f, 0.01197204f, 0.00957390f, -0.01390822f, 0.03590078f, 
    0.03993254f, -0.00220283f, 0.00495885f, 0.03218273f, 0.02976188f, 0.03541235f, -0.05764060f, 0.01288646f, 
    0.03298469f, 0.03898305f, 0.02753380f, 0.02093733f, -0.01202951f, 0.00331918f, -0.03851479f, -0.05379359f, 
    0.04068447f, 0.02051360f, -0.03856345f, -0.04073657f, 0.00207380f, -0.01726866f, -0.05059655f, -0.00051109f, 
    0.04085364f, -0.00094361f, 0.01715404f, 0.02402312f, 0.02242430f, -0.00962238f, 0.00358301f, 0.01012228f, 
    -0.00609200f, -0.04104092f, -0.05149843f, -0.04603845f, 0.04150080f, 0.03870037f, 0.03533600f, 0.03054764f, 
    -0.00348830f, -0.04331111f, -0.01101961f, -0.04354000f, 0.01986651f, -0.00369700f, -0.05861885f, -0.04084151f, 
    -0.04216368f, 0.04204454f, 0.03923124f, -0.02571521f, 0.02473580f, -0.02052031f, -0.03063454f, -0.00578068f, 
    -0.03240646f, 0.04353960f, 0.02812842f, 0.02231389f, 0.04087296f, -0.00738618f, 0.01483570f, -0.00017295f, 
    -0.00024814f, -0.01893721f, -0.02053355f, -0.03462727f, 0.03935681f, 0.04098005f, 0.01112146f, -0.03360661f, 
    0.01550253f, 0.01386359f, -0.05709178f, -0.00757111f, -0.00991578f, -0.01624569f, -0.00295477f, 0.00948194f, 
    -0.02664446f, -0.02130538f, -0.04105740f, 0.04316206f, -0.01850841f, 0.03095239f, 0.00818020f, 0.03822615f, 
    -0.02997664f, -0.01350653f, -0.05552549f, -0.05292375f, -0.03151895f, 0.04320787f, -0.04126008f, 0.01271528f, 
    0.00141227f, 0.02737604f, -0.01362032f, 0.01356896f, -0.03229363f, 0.03684636f, -0.01357695f, -0.01957214f, 
    0.01793306f, -0.04319131f, 0.00576940f, 0.03346044f, -0.03436056f, 0.03680380f, -0.03177898f, -0.01911295f, 
    0.01556639f, -0.03134171f, 0.00465733f, -0.01161736f, -0.01393319f, 0.01418127f, -0.04525623f, 0.00162879f, 
    0.04092308f, -0.03019881f, -0.00208343f, -0.00059572f, -0.02392657f, 0.02137558f, -0.04451637f, -0.04082511f, 
    0.01958138f, -0.02923830f, 0.03363906f, 0.00138496f, 0.04423035f, -0.02752238f, -0.05266425f, 0.00256686f, 
    0.02472447f, -0.03049232f, -0.01717815f, -0.03318625f, 0.01884097f, -0.05175868f, -0.00907581f, -0.00928122f, 
    -0.03006769f, -0.04435633f, 0.03693896f, 0.00112000f, -0.00774954f, 0.03314069f, 0.00089009f, -0.04500296f, 
    -0.04266077f, 0.02167383f, -0.04564988f, -0.00841263f, 0.00786983f, -0.04591656f, 0.04489465f, 0.02160495f, 
    -0.02859814f, -0.04024754f, -0.00987645f, -0.04501367f, 0.03512114f, -0.03408857f, -0.04776290f, -0.03718880f, 
    -0.00790355f, -0.04034020f, -0.02641381f, -0.04664948f, -0.05437103f, 0.02061376f, 0.02891714f, 0.00595747f, 
    0.00278375f, 0.03272371f, -0.03574361f, 0.04630893f, -0.03065847f, 0.01472537f, 0.04469318f, -0.02445420f, 
    -0.03840081f, -0.04067897f, -0.03782311f, 0.03272703f, -0.03375878f, 0.00970736f, 0.04190864f, -0.04623840f, 
    0.00590964f, 0.00461483f, -0.03774880f, 0.03173841f, 0.02259151f, -0.04777286f, -0.01281066f, -0.02099869f, 
    -0.01719204f, -0.01836526f, -0.03784240f, -0.01164289f, -0.05737202f, -0.05176701f, -0.02096303f, 0.04396404f, 
    -0.01600378f, -0.01891612f, 0.01381375f, 0.01866714f, 0.01761551f, -0.02380330f, -0.01569357f, -0.01314617f, 
    0.04002570f, -0.04024290f, 0.03714519f, -0.04967179f, -0.01252930f, 0.00051514f, -0.03430460f, 0.01493165f, 
    0.01977418f, 0.00843890f, 0.03893354f, 0.00729276f, 0.04395828f, -0.04294140f, 0.03629624f, 0.01263331f, 
    0.02264962f, -0.04678517f, -0.03597157f, -0.00714799f, 0.02064101f, -0.02740192f, -0.03279121f, 0.00406775f, 
    -0.03792049f, -0.00556795f, -0.00114057f, -0.04159629f, 0.04257300f, -0.01735302f, -0.04397469f, 0.02615225f, 
    -0.03056934f, -0.03937816f, 0.01080178f, 0.00840250f, 0.02268524f, 0.03924883f, -0.02020429f, 0.01752223f, 
    -0.00360813f, -0.00293448f, -0.04206771f, -0.04183255f, 0.01994123f, -0.05829459f, -0.02696787f, -0.00367292f, 
    -0.02092775f, -0.03961191f, 0.00285142f, -0.00108510f, 0.01105110f, -0.04009027f, 0.03809623f, 0.03911722f, 
    -0.04742749f, -0.04391813f, 0.01299009f, -0.02134403f, 0.02085069f, 0.02250225f, -0.02941329f, -0.02526298f, 
    -0.00312789f, -0.03012535f, 0.02843092f, -0.00042251f, -0.02297793f, -0.04175891f, 0.02823324f, 0.00411310f, 
    0.00936335f, -0.04900921f, -0.01279107f, -0.02580926f, 0.03739114f, 0.04970134f, -0.00254617f, 0.00136238f, 
    -0.02355022f, 0.01820721f, -0.04687108f, -0.02702783f, -0.00008419f, 0.00506941f, -0.01483309f, 0.02069025f, 
    0.02456927f, -0.04493303f, -0.02708986f, -0.05208721f, -0.01557776f, -0.03573874f, 0.00006198f, -0.01349804f, 
    0.03425825f, 0.02244824f, 0.00532324f, -0.00011434f, -0.02928789f, -0.00759052f, 0.03685731f, -0.02718044f, 
    0.04864150f, -0.00547984f, 0.02886231f, -0.03330482f, -0.03589387f, 0.01462960f, -0.04379722f, 0.03390751f, 
    -0.05200574f, -0.04896898f, -0.00631391f, 0.00274642f, -0.02563568f, 0.02901091f, -0.03200569f, -0.04060992f, 
    -0.03901036f, 0.04147499f, -0.02210720f, 0.01100240f, 0.01568367f, 0.03952953f, 0.01035834f, -0.03780030f, 
    -0.00425858f, 0.02160127f, 0.04368355f, 0.03922536f, 0.02624320f, -0.02023068f, -0.04443625f, -0.01985578f, 
    0.02482333f, 0.04544310f, -0.00943562f, 0.00121245f, 0.01241976f, -0.00110930f, -0.04229651f, 0.03037320f, 
    -0.03770577f, -0.05644248f, -0.05361567f, -0.01615633f, -0.04896332f, -0.03022166f, -0.03268620f, 0.03551420f, 
    0.03049714f, 0.01070485f, -0.01676701f, 0.00079565f, -0.04879916f, -0.00231042f, -0.01305951f, -0.03647769f, 
    0.01235714f, 0.00993928f, -0.02192357f, -0.05545038f, 0.01491503f, 0.03931321f, -0.00213556f, 0.00926034f, 
    -0.00158286f, 0.01493686f, 0.02166202f, 0.03571957f, 0.00162688f, 0.00783781f, 0.02766014f, 0.02359086f, 
    0.00862009f, -0.01243712f, -0.01696693f, -0.04759428f, -0.04186743f, 0.00736761f, 0.04354532f, -0.02215550f, 
    -0.05972601f, 0.03675490f, 0.02984825f, 0.01339666f, -0.00358785f, 0.00680209f, 0.03861925f, 0.00389329f, 
    -0.02356002f, -0.03222045f, -0.05382298f, 0.01802921f, -0.05254719f, 0.04657745f, 0.00505885f, 0.00067100f, 
    0.00032400f, 0.00142165f, 0.02977629f, 0.04244468f, -0.03093486f, -0.03726282f, -0.04388120f, 0.00553780f, 
    -0.02841195f, 0.02795862f, 0.03875235f, -0.01210681f, -0.03547958f, -0.00617128f, 0.00854384f, -0.03954721f, 
    0.03877090f, 0.03602445f, -0.03871455f, -0.03526349f, -0.05168749f, 0.04118527f, -0.03056679f, -0.00770983f, 
    0.00218584f, -0.00101689f, 0.02491306f, -0.02662996f, 0.00232055f, -0.06026739f, -0.04091529f, 0.03817666f, 
    0.01937935f, -0.01790941f, -0.04117841f, 0.00077922f, 0.01705502f, 0.01921260f, 0.02964577f, -0.02038403f, 
    0.02005663f, 0.00706026f, 0.03240015f, 0.04024854f, -0.03495272f, 0.03194168f, -0.05247641f, -0.03016720f, 
    0.03036787f, 0.03838056f, 0.00981866f, 0.00632655f, -0.02887204f, 0.03742427f, 0.00570631f, -0.03486005f, 
    -0.01060141f, 0.01475666f, 0.00713714f, -0.00796183f, 0.02647797f, 0.01966089f, 0.02631387f, -0.04348448f, 
    -0.05305699f, -0.00389487f, -0.05208201f, -0.04224494f, -0.03538042f, 0.02062874f, -0.01278332f, 0.02707806f, 
    -0.02207052f, -0.03581423f, -0.04698221f, 0.01212297f, 0.03409087f, -0.03900751f, 0.01840044f, -0.02156823f, 
    0.03522048f, -0.03867320f, 0.03241960f, -0.04937947f, -0.00458328f, 0.00066507f, -0.03696604f, 0.02470887f, 
    -0.01892961f, 0.02326003f, 0.00323892f, 0.01423410f, -0.00088624f, -0.01812885f, 0.02048251f, -0.01023125f, 
    0.00981863f, -0.05646638f, -0.01395344f, -0.02342834f, -0.03528354f, -0.00042273f, -0.03103653f, -0.00241472f, 
    -0.03846936f, 0.04706861f, -0.02994703f, -0.03880109f, 0.03881059f, 0.00634556f, 0.00451664f, -0.03204369f, 
    0.00147238f, 0.04325195f, 0.02623685f, -0.05086067f, 0.04589850f, -0.00628454f, -0.00516571f, 0.04354368f, 
    -0.00498012f, 0.00468571f, 0.03212714f, 0.00455026f, -0.01184273f, -0.04464854f, -0.04868266f, -0.02244177f, 
    -0.04214151f, -0.01453886f, -0.02911830f, -0.00771863f, -0.01457153f, 0.01459001f, -0.00468788f, -0.00652358f, 
    0.03116938f, -0.00153263f, 0.05794570f, 0.04703569f, 0.02396603f, -0.03716047f, -0.00273710f, -0.00248150f, 
    0.02326112f, -0.03756690f, -0.02616735f, -0.00800285f, 0.00308259f, -0.01264655f, 0.00567909f, 0.00802246f, 
    -0.01331621f, 0.04110214f, 0.02133454f, -0.04511413f, 0.03518417f, 0.03897571f, 0.00891812f, 0.00270452f, 
    0.03333227f, -0.02860648f, 0.00126590f, -0.02246156f, -0.04898526f, -0.02871642f, -0.04153093f, -0.02231530f, 
    -0.04097416f, -0.05397170f, -0.04882736f, -0.03932186f, 0.00916079f, -0.04904512f, -0.05021862f, -0.00120194f, 
    -0.00421182f, 0.00134436f, 0.02055370f, -0.03150617f, -0.01734359f, -0.02856298f, -0.00139027f, 0.03049022f, 
    -0.01986084f, -0.01919997f, 0.02338074f, -0.00669041f, 0.00118887f, -0.04611129f, 0.00784895f, -0.03622406f, 
    -0.05297809f, -0.04511295f, 0.02349588f, -0.03975468f, -0.03392016f, -0.02158788f, -0.03615320f, 0.02922619f, 
    0.02171400f, -0.02959321f, -0.05217584f, 0.01434647f, 0.00226673f, -0.00138084f, -0.01277636f, -0.04058370f, 
    0.01195590f, -0.04561728f, 0.02305468f, -0.05121423f, 0.00600197f, 0.03556197f, -0.01415573f, -0.05413121f, 
    0.03364754f, -0.00876614f, -0.02725677f, -0.01616061f, 0.01623778f, -0.03265760f, -0.03576935f, -0.05203829f, 
    0.03098838f, 0.00412460f, -0.04881068f, 0.01424156f, -0.00196502f, 0.04024281f, 0.01368035f, 0.03583747f, 
    0.02967160f, -0.00957135f, -0.04653347f, 0.00646092f, -0.01143467f, -0.02835787f, 0.01082540f, -0.02343160f, 
    0.00313011f, -0.02028047f, -0.05936908f, -0.00275044f, -0.04467400f, 0.02410104f, -0.04990124f, -0.01842779f, 
    0.02986868f, 0.02016246f, 0.03875557f, 0.03202005f, 0.02225895f, -0.05603253f, 0.01862958f, -0.02192271f, 
    -0.01039121f, 0.01306646f, -0.04454128f, -0.03681365f, 0.04337032f, 0.00769887f, -0.03450724f, -0.02696870f, 
    -0.02118634f, -0.02380094f, -0.03995253f, 0.02239145f, -0.02656762f, 0.00254101f, 0.01523325f, -0.03058909f, 
    0.00719720f, 0.04090620f, -0.04015642f, 0.03581761f, -0.03020271f, 0.03150877f, 0.00919191f, 0.02690011f, 
    -0.01808580f, 0.04110751f, 0.01767854f, 0.04731718f, -0.00065075f, -0.01144947f, -0.00309003f, 0.00253803f, 
    -0.03911886f, -0.00732926f, -0.02186963f, -0.00763814f, 0.02491411f, -0.01102378f, 0.03264206f, -0.04095833f, 
    -0.05052006f, 0.03616459f, -0.00373897f, -0.01030672f, 0.02206013f, 0.02662648f, 0.01016705f, -0.03504869f, 
    0.02636381f, -0.01516402f, 0.01472601f, 0.04311529f, -0.02684288f, 0.02759589f, -0.04416886f, -0.01848847f, 
    -0.00112186f, -0.05105249f, 0.01874075f, -0.05577693f, 0.03351736f, 0.00425549f, -0.03501796f, -0.04044718f, 
    -0.03188121f, 0.00523448f, 0.00529611f, -0.01302336f, -0.01158347f, -0.03681574f, 0.02598124f, -0.00623414f, 
    0.00438018f, 0.03769056f, 0.03502825f, 0.01594826f, 0.01104956f, -0.05057644f, -0.03304997f, 0.00503950f, 
    0.02000081f, -0.04362598f, -0.03855665f, -0.03447070f, 0.01846104f, -0.04552345f, 0.03068458f, 0.00411674f, 
    -0.05113183f, -0.01123484f, -0.04922999f, -0.01166495f, -0.01496038f, -0.00794559f, -0.01187684f, 0.01149940f, 
    -0.02919822f, -0.03950552f, 0.01501750f, 0.01949882f, 0.03673868f, -0.01517840f, -0.03789492f, -0.05511378f, 
    -0.01732198f, 0.01623082f, -0.02774084f, -0.00966760f, 0.02220700f, 0.01650148f, -0.02247875f, -0.01053244f, 
    -0.03320114f, 0.00101741f, -0.01510556f, -0.04279966f, 0.01352330f, -0.00041675f, -0.03036123f, -0.02403155f, 
    -0.00210156f, -0.03080806f, -0.01089365f, 0.02773011f, -0.05261384f, -0.05359894f, 0.00591521f, -0.00106408f, 
    -0.05032951f, -0.04679048f, -0.04259789f, 0.01178917f, 0.03326135f, -0.05459587f, 0.00891458f, -0.02089089f, 
    -0.00684769f, 0.03348306f, 0.00096071f, -0.00964254f, -0.04970755f, -0.04690704f, -0.05509632f, -0.00186774f, 
    -0.02849711f, -0.01128827f, 0.03851828f, -0.00381040f, -0.03774840f, -0.02657608f, 0.00643435f, -0.02062730f, 
    -0.02588497f, -0.02319835f, -0.03210280f, -0.00744601f, 0.00481833f, -0.01733307f, -0.03558496f, 0.02874704f, 
    -0.03996678f, 0.03231157f, 0.02737221f, -0.04521888f, 0.00880229f, -0.04003397f, 0.04026841f, -0.03315823f, 
    -0.00626755f, -0.04678398f, -0.03913549f, -0.05396885f, 0.03567152f, 0.01144744f, -0.04383329f, -0.00251367f, 
    0.04015465f, 0.00827674f, 0.03404333f, 0.01536676f, -0.02210292f, 0.00145524f, -0.01320486f, 0.03651544f, 
    0.02803230f, 0.03403057f, -0.05588308f, 0.04178054f, -0.00951733f, -0.05373181f, 0.01953617f, -0.04452386f, 
    0.02771264f, 0.03758821f, 0.00667149f, 0.01794606f, 0.01772568f, -0.04754292f, 0.03816684f, 0.00803189f, 
    -0.01945516f, 0.01931275f, -0.05459994f, 0.03053927f, 0.02772392f, 0.02390481f, 0.02084409f, -0.05379850f, 
    -0.02395164f, 0.04291897f, 0.02161290f, -0.00605608f, -0.05680967f, -0.04862129f, 0.00184105f, -0.00997937f, 
    -0.04305602f, -0.02866673f, 0.01747860f, 0.00737318f, -0.03675779f, -0.04710177f, -0.01485651f, -0.01885573f, 
    0.00661519f, 0.00757782f, 0.04214981f, -0.04871434f, 0.00379035f, 0.03808411f, -0.03558674f, 0.01549149f, 
    -0.04981614f, -0.00119944f, -0.02171878f, 0.01038327f, -0.01306372f, 0.02315302f, -0.05253641f, -0.04755071f, 
    -0.01744428f, 0.04006806f, 0.04281052f, -0.02586018f, -0.03482686f, -0.00284387f, -0.00561399f, -0.02456882f, 
    -0.04224753f, -0.01950924f, -0.00477450f, -0.00827355f, 0.01202255f, 0.03386418f, 0.00097073f, 0.04020957f, 
    -0.02429335f, 0.00740216f, 0.04277125f, 0.04116803f, -0.03876100f, 0.04231508f, 0.04489941f, 0.00778294f, 
    -0.02070368f, 0.02273012f, 0.02643752f, -0.00781879f, -0.02477537f, 0.01473001f, -0.04040445f, -0.05044373f, 
    -0.02345163f, -0.04147464f, -0.03908186f, 0.03522484f, -0.02853505f, -0.05216832f, 0.02104088f, 0.01867122f, 
    -0.05471986f, 0.00712291f, -0.05699797f, -0.05535465f, -0.01637338f, 0.00207399f, -0.00703131f, -0.04464433f, 
    -0.05420145f, -0.02632733f, -0.01573301f, 0.00191290f, -0.05115902f, 0.03294965f, 0.02886197f, 0.03685218f, 
    0.03933296f, 0.01735372f, 0.01519529f, 0.04247041f, -0.01747160f, -0.01031830f, -0.02670727f, 0.02853119f, 
    -0.01046224f, -0.03134003f, -0.01999705f, 0.01856420f, -0.00286116f, 0.00622520f, 0.03605981f, 0.03085049f, 
    -0.04750239f, 0.04123375f, 0.00406699f, 0.02240082f, 0.01189089f, -0.05140258f, -0.03854726f, -0.00473159f, 
    -0.00135996f, 0.00516731f, -0.03529968f, -0.04926032f, 0.03669475f, -0.03447416f, 0.02054814f, -0.00530731f, 
    0.01587878f, -0.04311536f, -0.02566645f, -0.00528076f, 0.00981671f, -0.04066177f, -0.02885197f, 0.01894533f, 
    -0.02985786f, 0.04200797f, -0.04453221f, -0.04915616f, -0.05526503f, 0.03407025f, 0.02212173f, -0.01988390f, 
    -0.00291353f, -0.03842182f, 0.01649861f, -0.04130951f, 0.00163497f, -0.02596779f, -0.02841699f, 0.01957189f, 
    0.00351374f, 0.01675458f, -0.04789008f, -0.03754656f, 0.04470540f, -0.05139573f, -0.04055902f, 0.01947294f, 
    0.03883805f, 0.00826192f, 0.03319298f, 0.04178544f, 0.02113056f, -0.00529232f, -0.02541302f, -0.00608242f, 
    -0.04103747f, -0.01189479f, -0.03594755f, 0.04050004f, -0.03643756f, 0.03172364f, 0.01493555f, 0.00867954f, 
    -0.04022680f, 0.01237283f, 0.01253900f, -0.03001259f, -0.00167801f, 0.00590233f, 0.04372349f, -0.03565612f, 
    -0.04567034f, -0.01509542f, -0.03401802f, 0.02097148f, -0.03342877f, -0.04497541f, 0.04436458f, 0.00560336f, 
    -0.02626638f, 0.01460773f, -0.01319495f, -0.03073428f, 0.00593003f, 0.03363475f, -0.03587378f, 0.02097609f, 
    -0.00916787f, -0.04061123f, 0.03727650f, 0.03963251f, -0.04382897f, -0.04501141f, 0.00730242f, -0.03782070f, 
    0.00179809f, -0.04209803f, -0.04972505f, 0.01724371f, 0.03344335f, 0.02922516f, 0.01607978f, -0.04301431f, 
    0.01528005f, 0.01218812f, -0.01205347f, -0.03342310f, 0.04112785f, -0.02990709f, -0.02868317f, 0.02491180f, 
    0.01285020f, -0.02187542f, -0.00925590f, 0.02705447f, -0.00209530f, 0.01885690f, -0.04454538f, 0.02289669f, 
    -0.01355320f, -0.05236736f, -0.04992374f, -0.05127466f, -0.04559674f, 0.02919186f, -0.03619006f, 0.00020530f, 
    -0.02082058f, 0.01184631f, -0.05657648f, 0.01704665f, -0.02911380f, -0.05421995f, 0.02336382f, -0.01140145f, 
    -0.03466524f, -0.02290484f, -0.03543914f, -0.01572079f, 0.00248240f, -0.04033614f, 0.01351785f, -0.01948532f, 
    -0.04057550f, 0.02256040f, -0.01929830f, 0.00547163f, 0.01141868f, -0.01785712f, 0.01058171f, 0.03902396f, 
    0.00002583f, 0.00135416f, -0.05772322f, -0.05976200f, -0.02590681f, 0.00835611f, 0.03432782f, 0.03311022f, 
    0.02332332f, 0.01515680f, 0.02667017f, 0.02364142f, 0.03416734f, 0.03361100f, -0.04929664f, 0.00227909f, 
    -0.04099130f, -0.02765889f, 0.01552109f, -0.04364277f, -0.03626808f, 0.01895081f, -0.00822240f, 0.03838263f, 
    0.01966469f, 0.03185894f, -0.01018189f, 0.01084270f, -0.00246888f, -0.00762954f, 0.00237203f, -0.02784874f, 
    -0.02525766f, -0.05572620f, 0.00143042f, 0.03330765f, 0.01088586f, -0.03529912f, -0.05001719f, -0.02428204f, 
    -0.01967587f, 0.00321058f, -0.04845755f, -0.03538467f, -0.02038654f, -0.01818096f, -0.02090850f, -0.02246657f, 
    0.00050473f, 0.04266528f, 0.03160499f, -0.00158948f, 0.00326944f, -0.01285200f, -0.00688108f, -0.05836585f, 
    -0.03790209f, -0.02116316f, 0.02566967f, -0.03014273f, -0.01086570f, 0.03930628f, -0.04522122f, 0.04264935f, 
    -0.03211551f, 0.02537775f, 0.03363967f, -0.04137291f, 0.00081154f, -0.00221119f, -0.03717256f, -0.02726978f, 
    0.02356271f, 0.00669086f, -0.05184025f, -0.00279332f, -0.01007721f, -0.03124805f, 0.01368527f, 0.02073448f, 
    0.01433651f, -0.04092086f, 0.04212381f, -0.04071527f, -0.04453293f, -0.05065186f, -0.02679030f, 0.01254814f, 
    0.01632206f, -0.00815504f, 0.04738381f, 0.04154686f, -0.01748018f, -0.02970514f, 0.00908360f, -0.01983514f, 
    0.00684233f, -0.05089172f, 0.04392532f, 0.01580630f, -0.01676816f, 0.02950358f, -0.01238378f, 0.01962903f, 
    0.01318182f, 0.03170193f, -0.04364913f, 0.04015722f, 0.04162373f, -0.05554581f, -0.03224564f, -0.02357034f, 
    -0.01020808f, 0.00888408f, 0.04202780f, 0.00583221f, -0.03352272f, -0.00851667f, -0.03671419f, -0.00501636f, 
    -0.04045490f, -0.03939569f, -0.04901801f, 0.02659123f, -0.02076942f, -0.00413268f, 0.00231128f, -0.02355944f, 
    0.04313906f, 0.02036263f, -0.01727430f, -0.05287739f, -0.00978361f, 0.00662758f, -0.02004396f, 0.02328791f, 
    0.00155791f, -0.02231173f, -0.04399491f, -0.02267419f, -0.03478813f, 0.01574895f, 0.01648258f, -0.05083992f, 
    0.01852708f, -0.05491306f, -0.02805530f, -0.05113684f, 0.00857820f, -0.01220812f, -0.01059523f, 0.02670982f, 
    0.04438844f, -0.00369524f, -0.03474580f, -0.00102565f, -0.02803415f, -0.00782419f, -0.03320828f, -0.02232425f, 
    0.01335943f, -0.03903094f, 0.01206257f, 0.04223974f, 0.03642880f, -0.04857641f, 0.04542592f, -0.03739488f, 
    0.01448176f, -0.00687154f, -0.04609132f, 0.01956427f, 0.03038053f, 0.02291206f, 0.01604346f, 0.02546457f, 
    0.03062923f, 0.04573210f, -0.05237710f, 0.03691547f, 0.01696746f, -0.00778791f, -0.03913099f, 0.01634733f, 
    -0.02934166f, 0.04494343f, -0.04850464f, -0.00892719f, -0.04499531f, -0.02088830f, -0.00806723f, -0.03022055f, 
    -0.01612471f, -0.00055759f, 0.02277517f, -0.05086548f, 0.04013520f, -0.05242831f, -0.02532680f, 0.00529546f, 
    0.01968425f, -0.01615785f, -0.00438965f, -0.04915948f, 0.02990547f, 0.04571987f, -0.04160693f, 0.05259243f, 
    0.00625814f, -0.03307032f, 0.03889070f, 0.03032822f, -0.04933708f, 0.03909184f, -0.00523060f, -0.02954233f, 
    -0.03880949f, 0.01119461f, -0.04539960f, 0.04919352f, -0.02305414f, 0.04042903f, 0.04007357f, -0.02136419f, 
    -0.02894673f, 0.03147121f, -0.03940162f, 0.02676594f, 0.02282503f, 0.02858271f, 0.00274927f, 0.03956578f, 
    -0.00489143f, 0.03397156f, -0.02837419f, 0.01422733f, -0.05246808f, -0.00777362f, 0.03578482f, -0.00423362f, 
    0.02356070f, 0.01377498f, -0.05139771f, 0.00794395f, -0.03341842f, 0.00015201f, 0.02800846f, 0.01362742f, 
    0.02815976f, -0.04312382f, -0.01491831f, 0.04437320f, -0.03502622f, 0.02695338f, 0.05634544f, -0.00926299f, 
    -0.01930819f, -0.03582007f, -0.01378672f, -0.00601554f, -0.00900359f, 0.04549284f, 0.01685469f, -0.05177452f, 
    -0.04561413f, 0.02823166f, 0.00044925f, -0.01042082f, 0.00547856f, 0.03890449f, 0.04363462f, -0.04596954f, 
    -0.05715024f, -0.04850709f, -0.01287229f, 0.03335355f, 0.03126946f, -0.00906228f, 0.03734462f, 0.00520457f, 
    0.02022622f, -0.01214685f, 0.00450957f, -0.00171945f, -0.04049402f, 0.01791016f, -0.00478426f, 0.01210077f, 
    -0.03536230f, -0.03158588f, -0.04533088f, 0.03073765f, -0.03400550f, 0.04775407f, 0.04027617f, 0.00676425f, 
    -0.00073207f, -0.03469948f, -0.05507492f, -0.05121423f, 0.02573754f, 0.00486897f, -0.01456557f, 0.01193325f, 
    0.00241901f, -0.01701834f, 0.03871880f, -0.04988101f, -0.02784620f, -0.02366084f, 0.01842330f, 0.01552514f, 
    0.02370145f, 0.00205190f, 0.02057528f, -0.04393011f, 0.03677484f, -0.05408401f, -0.02953460f, 0.04320749f, 
    -0.05019120f, 0.02221684f, 0.00648501f, -0.02200330f, -0.05848222f, 0.03657091f, -0.05172686f, 0.00340823f, 
    -0.00731817f, -0.05688311f, 0.00194494f, -0.01143568f, 0.03923218f, 0.03210101f, 0.00595586f, -0.01899210f, 
    -0.00066395f, 0.02021824f, 0.00785478f, 0.01632068f, 0.00137781f, 0.04042967f, -0.04625058f, 0.03051596f, 
    0.03325042f, -0.01268197f, -0.03471503f, -0.00657383f, 0.01993044f, 0.05141027f, -0.00981518f, -0.00770786f, 
    -0.03878272f, 0.02521949f, -0.01824117f, -0.04369555f, 0.04750511f, -0.04046779f, 0.00823398f, -0.05260343f, 
    0.01548593f, 0.00275121f, 0.02237636f, -0.03729749f, 0.01417621f, -0.00670342f, -0.04165890f, 0.01495365f, 
    0.00928084f, -0.01213606f, 0.00504661f, 0.01669693f, -0.02499113f, -0.01700329f, 0.04440819f, 0.02823019f, 
    -0.03972502f, 0.00267861f, -0.02422123f, 0.02934187f, -0.02110423f, 0.03844243f, -0.04747648f, -0.02989773f, 
    0.00762192f, -0.00568309f, -0.03463887f, 0.01986395f, -0.04243084f, 0.02938007f, 0.03412727f, 0.03953087f, 
    0.03576655f, 0.03823723f, -0.00279479f, 0.03932040f, -0.05507607f, -0.05026142f, 0.01268536f, 0.03140980f, 
    -0.02723477f, 0.00505315f, -0.03528617f, 0.01692653f, -0.03240945f, 0.00400783f, 0.00214046f, 0.03946931f, 
    0.00284824f, -0.02667644f, 0.03541116f, 0.00985071f, -0.01598812f, 0.03144971f, -0.00369502f, 0.01517364f, 
    0.03131280f, 0.01318441f, -0.01552561f, -0.00777128f, -0.00707325f, 0.02705853f, -0.02113922f, -0.01157991f, 
    -0.02357237f, 0.02500373f, -0.00936522f, -0.00281570f, -0.05262418f, -0.05048070f, 0.00231778f, -0.02858703f, 
    -0.03737807f, 0.01964506f, 0.01123619f, -0.01146353f, -0.01321015f, -0.04047660f, -0.03809537f, -0.04741717f, 
    -0.03817463f, 0.03230018f, 0.02776693f, 0.02233909f, 0.04319256f, 0.02877375f, -0.03050419f, -0.04734807f, 
    -0.02382401f, -0.01892277f, 0.00232567f, 0.03547639f, -0.04469401f, -0.04258464f, -0.06000718f, -0.00097899f, 
    -0.00511242f, -0.04872603f, -0.00406914f, 0.02339504f, -0.04209290f, 0.03739155f, 0.02323968f, 0.02000210f, 
    0.04556372f, 0.01477819f, 0.01860438f, -0.04891910f, -0.01906945f, -0.02308575f, 0.00319775f, 0.04104494f, 
    -0.03101112f, 0.02267652f, -0.01889481f, 0.03886671f, -0.03540342f, -0.00284551f, -0.03480475f, 0.04114494f, 
    -0.02752632f, -0.02907502f, 0.02655913f, 0.02350154f, 0.03956883f, -0.04916440f, 0.03384405f, -0.04262969f, 
    -0.01241469f, -0.05647037f, -0.00322500f, -0.02194691f, -0.00089292f, 0.01297837f, 0.04265837f, -0.04667445f, 
    0.00504151f, -0.01887992f, 0.02620631f, -0.05245820f, -0.03869322f, 0.01679296f, -0.03797619f, 0.01730528f, 
    0.00108093f, 0.01553724f, -0.00401604f, -0.05833311f, 0.03910041f, -0.03219504f, -0.03423204f, 0.02757985f, 
    -0.01579669f, -0.01878228f, 0.03587123f, -0.03576392f, -0.04646855f, 0.02467212f, -0.05122269f, -0.05710402f, 
    -0.00149589f, -0.01958650f, 0.03042571f, 0.03359476f, -0.05137885f, 0.03082171f, 0.02972877f, -0.03921883f, 
    -0.02141128f, -0.04104989f, -0.05194345f, 0.03415592f, 0.00086874f, 0.03379245f, 0.03235171f, -0.05892348f, 
    -0.00677939f, -0.00171928f, 0.02184579f, -0.00255421f, 0.01891049f, -0.02784916f, 0.00097951f, 0.02269568f, 
    -0.03032026f, -0.04230221f, -0.05230271f, 0.03263608f, -0.02688692f, -0.05207201f, -0.04045094f, 0.03011599f, 
    -0.01233772f, -0.03823308f, -0.03560957f, 0.03642751f, -0.04677863f, 0.02600574f, 0.02774819f, -0.01791301f, 
    0.00774228f, 0.00135373f, -0.02029765f, -0.02736712f, 0.03135316f, -0.05616158f, 0.00383123f, 0.03274345f, 
    -0.02734840f, 0.01015812f, 0.03697887f, 0.02002060f, 0.03396352f, -0.05860269f, 0.03486814f, 0.00127859f, 
    0.04025314f, 0.00554531f, -0.05959162f, -0.02139168f, -0.00682513f, -0.03902104f, -0.01956582f, 0.04138527f, 
    0.03071236f, 0.02321183f, -0.05618011f, -0.00092198f, 0.02255247f, 0.02012102f, 0.02604904f, -0.03081811f, 
    -0.04342555f, 0.02490079f, -0.02492328f, 0.03956560f, 0.00210624f, -0.03255143f, -0.02374158f, -0.02162423f, 
    0.01667759f, 0.02594959f, -0.02678623f, 0.03106302f, -0.04524923f, -0.05877583f, 0.00581934f, 0.01737860f, 
    -0.04036505f, -0.00770378f, -0.02377346f, -0.02718661f, 0.00334728f, -0.03856214f, -0.02136892f, -0.05922261f, 
    -0.04088287f, 0.03153168f, 0.03691155f, 0.01380758f, 0.02436598f, -0.03451549f, -0.01714528f, -0.02073319f, 
    0.01697882f, 0.00284280f, -0.01671736f, 0.03300919f, 0.00338758f, -0.04456362f, 0.04016022f, -0.00498593f, 
    -0.00814692f, -0.03010566f, -0.01601396f, 0.04036384f, 0.00825229f, -0.05313261f, 0.02944639f, -0.03827543f, 
    0.02556485f, -0.04309449f, -0.03719613f, 0.00306281f, 0.03593115f, -0.04756357f, -0.00967199f, 0.04108340f, 
    -0.00795003f, -0.04924986f, -0.05834584f, -0.01120264f, -0.02595089f, 0.03644520f, -0.01500877f, 0.02050597f, 
    -0.02165178f, 0.03234902f, -0.03567204f, -0.02345095f, 0.03528531f, 0.03961875f, 0.01254994f, -0.05676896f, 
    -0.01294545f, 0.00869571f, -0.01387886f, -0.00598132f, -0.01184559f, 0.02742323f, -0.03188147f, -0.03156121f, 
    -0.04067142f, 0.03537638f, -0.03145389f, -0.05116459f, -0.02098133f, 0.03754112f, -0.03914496f, 0.00160823f, 
    -0.00885899f, -0.05131366f, -0.03898084f, -0.00570331f, -0.01438948f, -0.00653243f, -0.05081640f, -0.02424293f, 
    0.01160229f, -0.00571702f, -0.02049154f, 0.03946647f, -0.00397791f, 0.02840486f, 0.01245891f, 0.04400056f, 
    -0.00542661f, 0.02504075f, 0.01002812f, -0.04516879f, -0.05715083f, -0.02828257f, 0.00884715f, 0.03935412f, 
    -0.03410595f, -0.04569551f, -0.03902593f, 0.03669305f, -0.01866912f, -0.03140091f, -0.02993881f, -0.00011428f, 
    0.01612683f, 0.03936365f, -0.01897435f, 0.03656606f, 0.01878618f, 0.01432226f, -0.05264191f, 0.01437213f, 
    -0.02663540f, 0.01062047f, -0.02698850f, 0.01093695f, -0.04304520f, 0.01067209f, 0.00351735f, 0.01708087f, 
    -0.03471555f, -0.05184100f, -0.04230937f, -0.04427011f, -0.05310137f, 0.03603338f, -0.05980526f, 0.00255532f, 
    -0.01214509f, 0.00222774f, -0.02309377f, -0.02354665f, -0.04426815f, 0.02890238f, -0.01936011f, -0.01107762f, 
    -0.01864257f, -0.00358527f, 0.00149083f, -0.01213940f, 0.01254691f, -0.02402216f, -0.02404200f, 0.00512714f, 
    -0.05716738f, 0.00429152f, 0.01270481f, 0.03154991f, -0.00320904f, -0.02143897f, 0.00931903f, -0.05436100f, 
    0.00822185f, 0.03259904f, -0.04530742f, -0.02864655f, -0.01594752f, 0.03437077f, -0.02274898f, -0.02445838f, 
    0.01840765f, 0.02953793f, 0.03259251f, -0.03147255f, -0.03714734f, -0.03001389f, -0.04821239f, -0.03620568f, 
    0.01264641f, 0.02059343f, 0.04013565f, 0.03932280f, 0.02348308f, -0.03033876f, -0.04161206f, -0.02443180f, 
    -0.00730776f, -0.01785287f, -0.05017952f, 0.01417488f, 0.03961102f, 0.03708778f, -0.01245680f, -0.01738052f, 
    0.03242559f, -0.03624860f, -0.04986192f, -0.05825868f, 0.02836455f, 0.03879513f, -0.01958676f, -0.01709901f, 
    -0.00369855f, -0.03316014f, -0.04713357f, -0.04023460f, -0.01250869f, 0.03143517f, -0.00572136f, 0.02112703f, 
    -0.02199694f, 0.01636121f, -0.04314409f, 0.00489071f, 0.03513048f, -0.05511909f, 0.02258139f, -0.02350141f, 
    -0.02489476f, 0.04348354f, 0.04423011f, 0.01337701f, 0.02221671f, -0.01197938f, -0.02035523f, -0.05065252f, 
    -0.03242509f, 0.01560393f, 0.04587303f, -0.02692372f, -0.04282950f, -0.02694623f, -0.03383270f, 0.01828821f, 
    0.03376329f, -0.05748753f, -0.04059685f, 0.02954607f, 0.03923165f, 0.02325483f, -0.01022733f, 0.02720528f, 
    -0.05111133f, -0.05140545f, -0.01700194f, -0.00682446f, -0.00633866f, 0.03720066f, -0.03746084f, -0.05687953f, 
    -0.04989350f, 0.00703419f, 0.00137110f, 0.03669634f, 0.01576966f, -0.05389016f, 0.00577561f, 0.04435370f, 
    -0.04483922f, 0.02807658f, -0.03048694f, -0.05270914f, 0.02128941f, 0.00932522f, 0.01241141f, -0.02152059f, 
    -0.05364263f, 0.03109646f, 0.04265175f, -0.00782652f, 0.04064604f, -0.04553644f, -0.00815308f, 0.01526601f, 
    0.01266510f, 0.01443103f, 0.02614382f, -0.05710594f, -0.02377515f, -0.01144624f, -0.04124272f, -0.03855624f, 
    -0.00827385f, -0.02214172f, 0.02297881f, 0.00238402f, -0.02415248f, 0.00368411f, -0.01117803f, -0.03247685f, 
    -0.03263748f, -0.05145452f, -0.02317236f, -0.00941688f, -0.03785573f, -0.05074234f, -0.00096288f, 0.03087470f, 
    -0.02075035f, 0.04206725f, -0.05451258f, 0.01138545f, -0.00502937f, -0.05513392f, -0.04165053f, -0.01688677f, 
    -0.02229108f, 0.01383659f, -0.04831015f, 0.03796563f, 0.02746169f, -0.05563200f, 0.01914513f, 0.02706524f, 
    -0.05408184f, 0.04270351f, 0.02476764f, 0.01826796f, -0.02270048f, 0.02228537f, -0.01287381f, -0.01266430f, 
    -0.04288894f, -0.03672063f, 0.01457366f, -0.03029961f, -0.00788413f, 0.04035225f, -0.05487895f, -0.03679410f, 
    0.01754658f, 0.02670411f, -0.05320647f, 0.01807640f, -0.01136833f, 0.04221728f, -0.00911184f, -0.03605179f, 
    -0.03174467f, -0.01728423f, 0.00704961f, -0.02207384f, 0.03704527f, -0.01946067f, -0.05828971f, 0.01457475f, 
    0.03501162f, -0.02089108f, 0.01579386f, -0.05565646f, -0.01711407f, -0.03835639f, 0.03394172f, 0.03169338f, 
    0.03086616f, -0.05616365f, -0.02891151f, -0.01087676f, -0.04587818f, 0.04191690f, 0.02214800f, 0.04229286f, 
    -0.04106484f, -0.05024308f, -0.01474359f, -0.05592843f, -0.02702248f, -0.04567137f, 0.03487438f, -0.03372758f, 
    0.01653959f, -0.00065997f, 0.03170297f, -0.04313804f, -0.01135567f, -0.04157512f, 0.03171084f, -0.03332635f, 
    -0.03318167f, -0.00754198f, 0.02417280f, -0.02571766f, 0.01746779f, -0.05242388f, -0.04712262f, -0.01419552f, 
    -0.03279041f, 0.02608123f, -0.03799658f, -0.03958021f, 0.00599472f, -0.03147774f, -0.01190981f, -0.05610445f, 
    0.02731542f, -0.04740042f, 0.01685079f, -0.04648834f, 0.01919303f, 0.00404363f, -0.02218805f, 0.01699675f, 
    -0.03036281f, -0.01131076f, -0.05222385f, -0.04339940f, -0.02757908f, 0.02357016f, 0.02422763f, 0.04377000f, 
    0.01257891f, -0.02706893f, -0.02263533f, -0.01898914f, -0.04321647f, -0.05732838f, -0.04806132f, 0.01901856f, 
    0.03982495f, 0.04257905f, 0.01296691f, -0.05145023f, -0.01328681f, 0.04068480f, -0.02830630f, 0.03013167f, 
    -0.02486879f, -0.04718547f, 0.04372181f, 0.00202873f, 0.04527387f, -0.03764132f, -0.04385047f, -0.04357323f, 
    0.00118731f, -0.01464295f, 0.00739087f, 0.00468579f, -0.05250010f, -0.05329060f, -0.00791214f, -0.04606678f, 
    -0.04717190f, -0.03636754f, 0.02968202f, -0.03947045f, 0.00468922f, -0.02322324f, 0.00694185f, 0.00538960f, 
    -0.03861400f, -0.01672343f, 0.03882863f, 0.04025078f, -0.00294380f, 0.03217492f, -0.01773773f, -0.02717372f, 
    0.02422637f, -0.01222122f, 0.03229404f, -0.05257710f, 0.03971389f, -0.01586285f, 0.01992511f, -0.04213939f, 
    -0.02788179f, -0.00697242f, 0.01511370f, -0.02031231f, 0.03108867f, -0.05761387f, -0.00053371f, -0.00339997f, 
    0.04396799f, 0.02560896f, 0.04101033f, -0.01971585f, -0.04016784f, 0.02181720f, -0.03831883f, 0.00073085f, 
    -0.00338395f, 0.03895114f, -0.05504315f, -0.04524332f, -0.02516468f, -0.01796933f, 0.01838907f, 0.02853865f, 
    -0.03150525f, -0.01968865f, 0.01923317f, 0.04577363f, -0.03753491f, 0.04227140f, 0.02750762f, 0.02932051f, 
    -0.01716526f, 0.01670315f, 0.00694456f, 0.02412695f, -0.01843312f, -0.01474224f, -0.00781183f, 0.03863223f, 
    0.04219978f, -0.01802330f, 0.03774562f, -0.01450812f, 0.02677355f, -0.04221137f, 0.02947501f, 0.00922788f, 
    -0.04752706f, -0.02791005f, -0.04713427f, -0.04591405f, 0.03340498f, -0.05236175f, 0.02775448f, -0.02257570f, 
    -0.05328343f, -0.03833651f, 0.03167005f, -0.05483309f, -0.03028875f, -0.05152109f, -0.00340251f, 0.03582418f, 
    -0.01828444f, -0.05363192f, 0.02433450f, 0.00672995f, 0.00860197f, 0.02100540f, 0.02614209f, 0.00539773f, 
    -0.03880491f, -0.02408377f, -0.01891121f, 0.02108379f, -0.03223560f, 0.02177359f, 0.00446395f, -0.03911088f, 
    -0.02303885f, -0.04416192f, -0.05195420f, -0.05630394f, -0.02864761f, -0.01656072f, 0.01501820f, 0.01409318f, 
    -0.05591276f, -0.00703955f, -0.04475159f, -0.01319067f, -0.01434289f, 0.03233520f, -0.05920083f, -0.00993796f, 
    -0.02686323f, -0.03011038f, 0.01080493f, -0.04930696f, 0.03354212f, 0.00607901f, 0.01412261f, 0.03206946f, 
    0.00840895f, 0.01378978f, -0.00552418f, -0.05031964f, -0.04494401f, 0.02733086f, 0.03609582f, 0.04106409f, 
    0.00069136f, -0.05560789f, -0.02682356f, -0.05480264f, 0.00777910f, 0.03976155f, -0.01760630f, 0.03887331f, 
    0.02165186f, 0.03265595f, 0.00744705f, 0.00235470f, -0.02746827f, 0.00219694f, -0.01631186f, 0.03958694f, 
    -0.02807607f, -0.03411703f, 0.02850874f, -0.00801052f, -0.04547428f, 0.00364470f, 0.03978737f, -0.04852191f, 
    -0.04408859f, -0.00956768f, 0.01674911f, -0.00431014f, 0.00625737f, 0.03298737f, 0.03928260f, -0.03655808f, 
    -0.05147709f, -0.04404267f, -0.03342258f, -0.04847597f, -0.00619538f, 0.00538646f, -0.01242933f, 0.03180072f, 
    0.00860504f, 0.01434353f, -0.05473022f, -0.03318585f, -0.02151560f, 0.02428684f, -0.00928142f, -0.02853281f, 
    -0.03215001f, 0.00285672f, -0.01692387f, -0.03936995f, -0.04408851f, -0.03331919f, -0.05158144f, -0.04426107f, 
    0.02427595f, 0.03455061f, -0.03649334f, 0.00462330f, -0.01047151f, -0.02578393f, -0.03310490f, -0.03275275f, 
    0.04004176f, 0.01195777f, 0.00166921f, -0.04591928f, 0.00828043f, 0.00723801f, -0.00164979f, 0.00671244f, 
    0.03077816f, -0.03739132f, -0.01723048f, 0.02691637f, -0.02203460f, -0.01139802f, 0.03623820f, -0.03937820f, 
    -0.02815985f, -0.01896557f, 0.01489093f, 0.03303082f, -0.02995179f, 0.03217173f, -0.04360427f, 0.02047583f, 
    -0.03675548f, -0.03317516f, 0.02861144f, 0.03813601f, 0.04149210f, -0.05302782f, -0.01161453f, -0.02331006f, 
    -0.03535048f, -0.03194200f, 0.02234213f, -0.03992107f, -0.05603274f, 0.03099409f, 0.00320457f, -0.02102822f, 
    -0.00744730f, 0.03726182f, -0.04914465f, 0.01897380f, -0.03918829f, 0.03498909f, -0.01716581f, 0.04074801f, 
    -0.03147669f, -0.01997244f, 0.02925251f, -0.04461588f, -0.05703688f, -0.00635736f, 0.01607064f, -0.04904072f, 
    -0.03719117f, -0.01636181f, -0.01031414f, 0.01966399f, -0.02935632f, 0.03022887f, -0.03609107f, 0.01324697f, 
    -0.02662968f, -0.00716089f, 0.02082113f, -0.01479473f, 0.03432954f, 0.00563853f, 0.01416463f, -0.00089653f, 
    -0.04304135f, -0.05333663f, 0.03979727f, 0.01773223f, 0.04593102f, -0.02722370f, -0.05253129f, 0.01974786f, 
    0.02909099f, -0.01837734f, -0.05001586f, -0.02085222f, 0.01119536f, -0.03613107f, -0.03067820f, -0.03671608f, 
    0.00206360f, 0.00059079f, -0.03924594f, -0.03637291f, 0.00128326f, 0.03440861f, -0.04432847f, 0.02571861f, 
    -0.00821453f, -0.01956823f, 0.03818490f, -0.04810892f, 0.02487915f, -0.00025662f, 0.03150155f, 0.02134081f, 
    -0.00849704f, -0.03523535f, -0.04722553f, -0.05651554f, 0.01504446f, 0.01495462f, -0.03771007f, 0.00956733f, 
    0.03682975f, -0.02741176f, -0.04090196f, -0.01605278f, -0.01365941f, -0.01363668f, 0.02920988f, -0.03881275f, 
    -0.03233189f, 0.03053926f, 0.02597577f, -0.03317773f, 0.01509472f, -0.00091118f, 0.01404105f, -0.01956046f, 
    -0.04957922f, 0.04595779f, -0.01929322f, -0.01804515f, 0.00916691f, 0.00528636f, 0.01762565f, 0.03501797f, 
    0.02954620f, -0.04505945f, -0.00904918f, -0.02547140f, 0.00671959f, -0.01006806f, -0.00367242f, -0.03843926f, 
    -0.03481961f, -0.03652230f, -0.01870898f, -0.00712883f, -0.00445129f, 0.01754647f, 0.00438568f, -0.05056672f, 
    -0.05397993f, -0.03380141f, -0.02223346f, -0.05262866f, 0.04686503f, 0.04075424f, -0.03772023f, 0.02076739f, 
    -0.03253376f, 0.03850209f, -0.02796811f, -0.04340333f, -0.01488382f, -0.00455158f, 0.02772316f, -0.00938181f, 
    0.01286403f, -0.05362549f, 0.00965266f, 0.02792936f, -0.02236599f, -0.03430518f, -0.02636835f, 0.04570228f, 
    0.01670414f, -0.03925365f, -0.01109321f, -0.02850094f, 0.01729016f, -0.01387814f, -0.04582117f, -0.02616844f, 
    -0.02066841f, 0.03474355f, -0.00019150f, -0.03115134f, 0.00520717f, 0.02762428f, 0.01750459f, 0.04381777f, 
    0.00278466f, 0.04104263f, -0.03787865f, -0.01386422f, 0.02163471f, -0.02891320f, -0.04805880f, -0.02849792f, 
    -0.02350019f, -0.01647994f, 0.03985540f, -0.02052852f, 0.03619274f, -0.03341215f, 0.02078857f, -0.01286182f, 
    -0.04215223f, -0.02131245f, -0.03584771f, 0.00459986f, 0.00725377f, -0.00168608f, -0.00123629f, 0.01845733f, 
    0.03668408f, 0.03011751f, -0.01887477f, -0.00050196f, -0.02859245f, 0.01500887f, -0.05084145f, 0.03792606f, 
    0.02468514f, -0.05335782f, 0.04511745f, 0.04134588f, 0.03121231f, 0.03367211f, -0.00862883f, -0.00789104f, 
    -0.00430061f, -0.01103432f, 0.03865150f, 0.00984447f, 0.03173319f, 0.00639811f, -0.04283524f, -0.04580744f, 
    -0.01355551f, 0.03120341f, 0.00480653f, -0.04466094f, -0.03643018f, 0.02465807f, 0.02451521f, 0.03381053f, 
    0.03681966f, -0.03683644f, 0.02509455f, -0.00157054f, -0.01345663f, -0.04905659f, -0.02591977f, -0.02326050f, 
    0.02760642f, -0.04256060f, -0.02130545f, -0.01810891f, -0.01347342f, 0.01409246f, -0.00911338f, 0.00208506f, 
    0.02544341f, 0.01538171f, -0.02562697f, -0.00296725f, -0.00025373f, 0.00800607f, -0.02690440f, -0.01163229f, 
    0.01590027f, 0.04440745f, -0.01004835f, -0.01452628f, -0.00690589f, -0.01908137f, 0.00515307f, -0.01807977f, 
    -0.00735319f, 0.03097743f, 0.03742411f, 0.02602144f, 0.02705188f, 0.03248123f, -0.02194315f, -0.05028675f, 
    0.01492120f, 0.02298962f, -0.03956433f, -0.04231406f, 0.03630624f, -0.03288332f, 0.00354068f, -0.03792904f, 
    -0.07306284f, 0.07770005f, -0.01566783f, 0.05564638f, -0.07942943f, -0.07669745f, 0.15710512f, 0.19008547f, 
    0.01422422f, 0.12473166f, 0.05600347f, 0.01577664f, 0.11309239f, 0.04968312f, 0.11763769f, 0.06811144f, 
    -0.04651955f, -0.05495055f, 0.00259324f, -0.08151335f, -0.05554777f, 0.05275956f, -0.06502540f, 0.01738513f, 
    0.37125719f, 0.14307624f, 0.08813041f, -0.27755708f, 0.02614995f, 0.06054686f, -0.00032002f, 0.06952225f, 
    0.13940428f, -0.14359732f, 0.01470609f, -0.01042823f, -0.03759816f, 0.01278796f, 0.07218309f, 0.13251582f, 
    0.00976517f, -0.07243286f, -0.03246062f, 0.07904729f, -0.02880927f, -0.03182483f, -0.10494240f, -0.15071735f, 
    0.08726792f, 0.04468455f, -0.02091962f, -0.01178034f, -0.02117469f, -0.01152199f, -0.01485234f, 0.12281200f, 
    0.01436996f, 0.02328080f, -0.08881771f, 0.11572246f, -0.08210249f, -0.18924218f, 0.02893526f, 0.03579882f, 
    -0.17805167f, 0.00261252f, 0.00310725f, 0.10635277f, 0.04253306f, -0.14792646f, -0.05567789f, 0.09071494f, 
    0.09704062f, -0.17795439f, -0.09962528f, 0.36594194f, 0.00888369f, 0.14515013f, 0.03542363f, -0.04226254f, 
    0.06404224f, 0.04386725f, 0.01499195f, -0.06546467f, -0.09851218f, 0.04610142f, -0.07018016f, 0.24711764f, 
    0.05577562f, -0.05534548f, 0.08662098f, -0.04209829f, -0.02307408f, -0.03143578f, 0.09754809f, 0.04664531f, 
    -0.14044936f, -0.14409465f, 0.19213885f, 0.18888073f, -0.04014724f, -0.04917657f, -0.04632002f, -0.07590470f, 
    0.06376457f, 0.00272964f, -0.05144786f, -0.23127113f, 0.02617729f, -0.03703818f, 0.00344145f, -0.09252311f, 
    -0.04145316f, 0.03915501f, 0.00020845f, -0.02091041f, -0.04546776f, -0.07331321f, 0.03162572f, -0.08525998f, 
    -0.22332852f, 0.02618351f, 0.18067993f, -0.26060501f, -0.07380166f, 0.07654583f, 0.04189051f, 0.02908208f, 
    -0.09167453f, -0.07244948f, -0.01469035f, 0.02721430f, 0.11216088f, 0.11278830f, -0.19172385f, 0.16966182f, 
    -0.06357520f, 0.06825798f, -0.03242864f, 0.11747850f, -0.08861655f, 0.03735824f, -0.03620425f, -0.03281795f, 
    0.13755631f, 0.13627963f, -0.10305390f, -0.04635330f, 0.00351087f, 0.05743787f, -0.05419565f, -0.03895224f, 
    -0.10140278f, 0.11293715f, 0.04567559f, -0.10047428f, -0.11904739f, -0.16866629f, -0.12353852f, -0.12169907f, 
    -0.23169741f, 0.05925155f, -0.03195073f, 0.01308859f, -0.02631974f, -0.01238430f, 0.00001006f, -0.08618938f, 
    -0.15683240f, -0.09391551f, 0.03657991f, -0.05149663f, -0.08913340f, -0.04632641f, 0.06757870f, -0.12641077f, 
    0.00574748f, 0.05809700f, -0.08954190f, 0.01502310f, 0.05367219f, 0.00185046f, -0.04803849f, 0.07956304f, 
    -0.04364322f, -0.09745277f, -0.04113683f, -0.01829515f, -0.01945777f, -0.02676025f, -0.06763431f, 0.00864379f, 
    0.09904073f, -0.12089272f, -0.07011782f, -0.17052257f, 0.10080338f, -0.07611299f, -0.03268086f, -0.00894630f, 
    0.09555090f, 0.04536382f, -0.17446148f, -0.07216658f, -0.05868552f, 0.09672461f, 0.01897493f, -0.05543324f, 
    0.13005450f, -0.09381280f, 0.11533352f, 0.12578297f, 0.06946211f, -0.16827534f, -0.05971427f, 0.10045574f, 
    0.02782973f, 0.31246084f, -0.03802124f, -0.06443608f, 0.00264893f, 0.04159816f, -0.10438035f, 0.01997299f, 
    0.09646922f, 0.05956940f, 0.05443594f, -0.04010620f, 0.10198664f, 0.18477052f, -0.15014003f, -0.13563685f, 
    0.12857389f, 0.02560502f, -0.10374457f, -0.01366429f, 0.06895868f, 0.06009823f, 0.01080455f, 0.02491229f, 
    -0.00510442f, 0.18172510f, -0.03743226f, 0.13237986f, 0.14460598f, 0.06373633f, 0.06843407f, -0.02848680f, 
    -0.00030932f, 0.09269657f, 0.22759293f, -0.07582407f, -0.17377900f, -0.07396425f, 0.03175778f, 0.13876860f, 
    -0.07033546f, 0.01784608f, 0.07735647f, -0.01299178f, -0.01054117f, 0.08494041f, -0.04381857f, 0.05937628f, 
    -0.17875306f, -0.01387807f, -0.03089861f, 0.20927832f, 0.01533163f, -0.10140349f, -0.10935201f, -0.06880301f, 
    0.02532117f, 0.15459098f, 0.04669334f, -0.08950367f, -0.06444623f, 0.18327890f, 0.24852404f, 0.01237046f, 
    -0.00750779f, -0.02852518f, 0.01229638f, -0.00936016f, -0.03658770f, 0.09412432f, 0.09329563f, 0.16674165f, 
    0.00605394f, -0.17957941f, 0.14958009f, 0.33304283f, -0.03565999f, 0.00369917f, 0.01444880f, -0.04616415f, 
    0.05776484f, -0.00716114f, 0.16876601f, -0.11384313f, 0.07069190f, 0.06902707f, -0.00786364f, 0.15186773f, 
    -0.13502760f, 0.03078873f, -0.01121022f, -0.00062701f, 0.03706380f, -0.11286866f, 0.20386706f, -0.00118202f, 
    -0.07627902f, 0.08907660f, 0.17798123f, -0.00691915f, 0.04870035f, 0.02656314f, 0.10109819f, 0.06843945f, 
    -0.05470952f, -0.03061019f, 0.03115604f, 0.04533471f, 0.20308456f, -0.04832035f, 0.06812878f, 0.27107161f, 
    -0.06181194f, -0.06823593f, -0.02493247f, 0.03214779f, -0.07007833f, -0.02705963f, -0.00681753f, 0.04066205f, 
    0.02132170f, -0.07554908f, 0.05751656f, 0.02128179f, -0.10353918f, 0.08828328f, -0.00618881f, 0.08258284f, 
    0.02132169f, -0.05449668f, 0.00206348f, -0.02389346f, 0.24419086f, -0.04891336f, 0.04687711f, -0.14560346f, 
    0.00692083f, -0.04818479f, -0.08480288f, -0.03518239f, 0.07829880f, 0.03622336f, -0.03982764f, -0.03778449f, 
    0.33150494f, 0.08750620f, -0.01418140f, -0.13600954f, 0.00483993f, -0.01480205f, -0.08863825f, -0.03033718f, 
    -0.00376168f, 0.01552001f, -0.06112565f, -0.00859331f, 0.23693587f, 0.04305708f, 0.01879552f, -0.13178484f, 
    -0.07339593f, 0.00687752f, 0.00841080f, 0.07181951f, 0.04044986f, 0.07989980f, 0.01538761f, -0.00271281f, 
    -0.03841279f, -0.20201242f, 0.06407146f, 0.19365816f, 0.01321399f, 0.01060140f, 0.00681210f, 0.06579690f, 
    0.10356257f, 0.05477813f, 0.05322726f, 0.07096472f, 0.07382090f, -0.17748655f, 0.06339018f, -0.03574602f, 
    -0.05021668f, -0.00671348f, 0.05675527f, 0.05257352f, 0.00909704f, 0.01233859f, -0.01330762f, -0.04377153f, 
    0.19351035f, 0.10284686f, -0.21546607f, -0.15494040f, 0.05288951f, -0.24879947f, 0.09126966f, -0.03903851f, 
    -0.06131836f, -0.04344143f, -0.10161836f, 0.01560397f, -0.00464811f, 0.19370161f, -0.03047270f, -0.18592045f, 
    -0.08098987f, 0.02791584f, -0.08617279f, 0.07854839f, 0.03716655f, -0.03705776f, 0.05221700f, 0.08687571f, 
    -0.15937118f, -0.03091054f, 0.04389729f, 0.09255406f, -0.07519580f, 0.04890886f, 0.10850421f, 0.04183199f, 
    -0.04857933f, 0.06843032f, 0.07204884f, 0.05334752f, -0.36611974f, -0.05944541f, 0.07805179f, -0.00160424f, 
    0.06630235f, 0.04855605f, -0.04950109f, 0.02537505f, 0.16477725f, 0.08220424f, 0.03197476f, 0.05058337f, 
    -0.11680838f, 0.19031997f, 0.29917043f, 0.01361339f, 0.22582375f, 0.07243551f, -0.03625511f, -0.02807376f, 
    -0.10460228f, 0.03963011f, 0.04687576f, 0.02725638f, 0.11391319f, 0.13586831f, 0.09033225f, -0.24939503f, 
    0.04331741f, 0.00302884f, 0.03074483f, 0.24134225f, -0.03221072f, 0.03202507f, 0.00919996f, 0.10955741f, 
    -0.43548858f, 0.19089352f, 0.09276839f, -0.02147022f, 0.07613221f, 0.16317558f, 0.07069875f, -0.06757349f, 
    0.01378201f, -0.04989548f, 0.03932108f, 0.08156896f, -0.20748612f, 0.36395186f, -0.02157748f, 0.09465576f, 
    0.02957889f, 0.20214207f, -0.06244904f, -0.11307941f, 0.05842814f, 0.01771975f, 0.02104786f, 0.01593659f, 
    -0.16226444f, 0.04029099f, -0.02119610f, 0.26020235f, 0.04139142f, 0.08905186f, 0.06521448f, 0.09072078f, 
    0.11867467f, -0.00273856f, 0.03517771f, -0.03206584f, -0.23218015f, -0.00216989f, -0.07871845f, -0.25576180f, 
    0.07846171f, -0.05555951f, 0.10988642f, 0.04105848f, 0.09295058f, 0.00973133f, 0.01364123f, 0.15814640f, 
    -0.07061111f, -0.15765946f, 0.05545355f, 0.16256300f, -0.12181240f, -0.03197349f, 0.05548768f, -0.04081940f, 
    0.05511772f, -0.12709554f, -0.04709123f, 0.10401487f, -0.21362303f, -0.22201556f, 0.13870256f, 0.20659851f, 
    0.12088795f, 0.19517303f, 0.19487432f, -0.02561416f, 0.12834945f, 0.02563384f, -0.11179504f, -0.02311750f, 
    0.03502075f, -0.08516948f, -0.23073800f, -0.24004179f, 0.10476024f, 0.06172724f, -0.04901372f, 0.07045552f, 
    -0.12349787f, -0.04911559f, 0.08377078f, 0.09083138f, -0.16374138f, -0.24261889f, 0.05380394f, 0.17963858f, 
    -0.02823414f, 0.14123458f, 0.06412776f, -0.10515972f, 0.12517211f, -0.08577111f, 0.02828266f, 0.10085577f, 
    0.06542287f, -0.02446619f, 0.09027177f, -0.19236636f, -0.02155945f, -0.00673999f, -0.07720800f, 0.00577989f, 
    0.16914174f, 0.04624912f, 0.05589356f, -0.00025708f, -0.50739497f, -0.22996069f, 0.05382641f, 0.05552206f, 
    0.07278223f, -0.05081451f, 0.04451731f, -0.04652369f, -0.06035526f, 0.10439183f, 0.08750758f, -0.01391390f, 
    0.22996090f, 0.02127838f, -0.01104052f, -0.05470070f, 0.10712238f, 0.05300837f, -0.01717709f, 0.07469635f, 
    0.02461549f, 0.06862350f, -0.11123829f, -0.07894933f, -0.20775363f, -0.04839008f, 0.12447515f, 0.04253530f, 
    -0.07124026f, -0.06754380f, 0.01183325f, -0.04831055f, 0.03545815f, 0.03838716f, 0.04607021f, -0.08463945f, 
    0.12254062f, 0.12893353f, 0.08855309f, 0.13074037f, -0.12830669f, 0.00825629f, -0.07553951f, 0.16149205f, 
    -0.01164900f, -0.01721394f, -0.06213176f, -0.03013250f, 0.20448838f, -0.15557139f, 0.11906420f, -0.00303127f, 
    -0.03690774f, 0.11968880f, -0.00563015f, -0.01860288f, -0.06384560f, 0.01081111f, 0.03891575f, 0.04751786f, 
    0.22008288f, 0.10230284f, 0.15376315f, -0.02384836f, 0.04996688f, 0.06425983f, 0.01791056f, 0.09292430f, 
    0.21977970f, -0.03145064f, 0.01561076f, -0.04061024f, -0.40078518f, 0.27826604f, 0.00495373f, 0.33449221f, 
    -0.00055582f, -0.01329003f, 0.06639582f, 0.04847033f, 0.15110421f, -0.06810095f, 0.04613171f, -0.09323388f, 
    -0.08727194f, 0.01354369f, -0.01947739f, -0.24508913f, 0.04192541f, -0.00562710f, 0.08284051f, 0.00701513f, 
    0.14817919f, 0.07446751f, 0.04260738f, 0.05728312f, -0.05869983f, 0.04213190f, -0.04966846f, 0.18849424f, 
    -0.02108802f, 0.00705840f, -0.05714695f, 0.03744679f, 0.01424242f, -0.01202446f, -0.04742072f, 0.10166713f, 
    0.24711356f, -0.23585668f, -0.06774200f, -0.12092358f, 0.01851435f, -0.04646333f, 0.00766097f, -0.04494525f, 
    -0.07479531f, 0.06096906f, -0.00928979f, 0.15762983f, -0.03821158f, 0.27165252f, 0.16518003f, 0.00050025f, 
    0.22558659f, 0.10410294f, 0.09661943f, 0.01330289f, 0.12181395f, -0.01963895f, 0.02597961f, 0.03586380f, 
    0.09425703f, -0.06307413f, 0.14321621f, 0.17430325f, 0.13175203f, -0.00102368f, 0.11676438f, -0.08228359f, 
    -0.01286293f, 0.00648418f, -0.05575030f, 0.00320016f, -0.32766682f, 0.00931006f, -0.04747624f, -0.07369085f, 
    -0.01810625f, -0.10284172f, 0.02430172f, 0.15048032f, -0.03808850f, -0.06494532f, -0.09682191f, -0.01687946f, 
    0.27298981f, 0.32607242f, -0.19464192f, 0.03432773f, 0.14449959f, -0.14708093f, -0.06141453f, 0.12984259f, 
    -0.04461059f, 0.06172350f, -0.06862900f, 0.02047548f, -0.02346905f, -0.13728121f, -0.07099899f, 0.10051145f, 
    -0.15951332f, 0.16928382f, 0.02215693f, -0.12136149f, -0.07371272f, -0.02220335f, 0.07850080f, -0.09480686f, 
    0.01278219f, 0.04547807f, -0.04608712f, 0.02799093f, -0.01189119f, 0.00313635f, 0.02692169f, 0.01002053f, 
    -0.02038849f, 0.02766568f, 0.02948885f, -0.03465429f, -0.02640416f, 0.01000671f, -0.00599488f, 0.02424922f, 
    0.04238341f, -0.02081662f, -0.00164431f, -0.00705243f, -0.02269381f, 0.02680343f, -0.02540004f, -0.00877329f, 
    0.01204539f, 0.01625087f, 0.02194745f, 0.03443440f, -0.05035317f, 0.03402211f, -0.02345091f, 0.02293139f, 
    -0.04941572f, 0.03895065f, -0.00419408f, -0.01183106f, -0.02560859f, 0.03472779f, 0.04121013f, 0.01068790f, 
    0.03700404f, -0.03861830f, -0.04596737f, 0.01548170f, 0.04484576f, 0.00176229f, 0.00873024f, 0.04768300f, 
    0.01485719f, -0.00306071f, -0.04185849f, 0.02367360f, -0.03302114f, -0.01800462f, -0.03693108f, 0.00439253f, 
    -0.00265768f, -0.02244453f, -0.05147569f, -0.05079626f, -0.03223629f, 0.00066828f, 0.01003282f, -0.03624788f, 
    -0.03942673f, 0.01170798f, -0.00205496f, -0.04040131f, -0.01932157f, 0.02511875f, -0.05146236f, -0.05062291f, 
    0.03895308f, 0.00794503f, -0.01791478f, 0.05605908f, -0.02883969f, 0.03665755f, -0.04795715f, -0.01334535f, 
    0.03687805f, -0.00849547f, 0.01462142f, 0.00178573f, -0.05290909f, -0.03386764f, 0.02162324f, -0.05112929f, 
    0.01273904f, -0.00466181f, -0.01254921f, -0.00776732f, 0.04026056f, -0.01902676f, 0.04668250f, 0.00179555f, 
    0.01992752f, -0.03769884f, 0.01905548f, -0.01042191f, -0.03693096f, 0.03612091f, -0.05109033f, 0.02266695f, 
    0.01490405f, 0.02792278f, -0.00838135f, -0.02585728f, -0.00228328f, -0.05625831f, 0.02829451f, 0.03770617f, 
    -0.00329704f, 0.01118209f, 0.00562515f, 0.00033868f, -0.04607232f, 0.00468665f, -0.03748152f, 0.04438844f, 
    -0.00478518f, -0.04142432f, -0.01401922f, 0.01385704f, 0.03192513f, -0.03800860f, -0.00900126f, -0.02604666f, 
    -0.05045632f, -0.05334823f, 0.00626301f, 0.04844246f, -0.00032615f, 0.01546334f, -0.00338000f, -0.04898664f, 
    -0.03135938f, 0.00847447f, -0.02773130f, 0.02584367f, -0.04601595f, 0.03964869f, -0.00561454f, 0.01999490f, 
    -0.03315964f, 0.00933115f, -0.03060949f, 0.00275712f, 0.00374632f, 0.00652088f, 0.03187711f, -0.05171197f, 
    -0.04299216f, -0.04067953f, -0.01859669f, -0.01515153f, -0.05124642f, -0.00391295f, 0.02757798f, -0.01846155f, 
    -0.05563637f, 0.01607505f, -0.03283437f, 0.00078377f, -0.00537583f, 0.01279229f, -0.04280369f, 0.00531471f, 
    0.02797502f, -0.04812298f, -0.04988037f, 0.01128224f, 0.02731000f, -0.05436241f, -0.03403572f, 0.02397268f, 
    0.02132352f, -0.00372143f, -0.05236514f, -0.01993753f, -0.02409871f, 0.01832340f, 0.03879002f, -0.02952633f, 
    0.00475103f, 0.03367131f, 0.00091762f, 0.03960336f, -0.03724458f, 0.00615771f, 0.00848163f, -0.01206187f, 
    -0.02255858f, -0.00243991f, -0.05528300f, -0.04673577f, 0.01390094f, -0.02558810f, -0.02371508f, 0.02118896f, 
    -0.01539053f, -0.02393250f, 0.02807817f, 0.02485695f, -0.03558842f, 0.03131930f, 0.02559913f, 0.01343926f, 
    -0.03671237f, 0.04252744f, -0.01345448f, -0.03941941f, 0.03256499f, 0.01541241f, -0.04527582f, -0.01689376f, 
    0.00618668f, 0.04157957f, 0.01876528f, -0.02842907f, -0.03282282f, 0.01318106f, 0.03530199f, -0.01674172f, 
    -0.01194429f, -0.03635506f, -0.01175729f, 0.02951733f, 0.03320985f, -0.03538827f, -0.03721595f, -0.03408868f, 
    0.00975596f, 0.01956099f, -0.02781819f, -0.05090516f, 0.03168098f, 0.04660426f, 0.03333684f, 0.02185471f, 
    -0.01694553f, -0.03941047f, -0.02924480f, -0.04168643f, 0.00705649f, 0.02966736f, 0.04439019f, -0.03606733f, 
    -0.02984622f, 0.04120006f, -0.00222699f, -0.03512481f, 0.03391810f, 0.02015351f, -0.01019835f, -0.04931585f, 
    0.01115305f, -0.00124748f, -0.04944408f, -0.00908285f, -0.00477859f, -0.02499194f, -0.01977694f, 0.02501948f, 
    -0.01753319f, -0.01612614f, 0.00501701f, -0.04602964f, -0.04136583f, -0.04277926f, -0.00370319f, 0.00970251f, 
    0.00663050f, -0.01304807f, -0.02366981f, 0.00678152f, -0.00307124f, 0.01798005f, -0.02193851f, -0.01729170f, 
    0.00190302f, -0.02003324f, 0.01046784f, -0.04270948f, -0.01777893f, -0.01119220f, -0.04462717f, -0.02251988f, 
    0.00943192f, -0.05023855f, -0.05116293f, -0.03472616f, 0.01372871f, 0.00018598f, 0.00710299f, -0.01684140f, 
    0.03682823f, 0.02596630f, 0.02400933f, 0.01363316f, -0.03107139f, 0.01024955f, -0.00262192f, -0.04844826f, 
    -0.03959544f, 0.02381555f, -0.00816801f, -0.03589286f, -0.01085626f, -0.01213776f, 0.03282166f, -0.05607570f, 
    -0.00545728f, -0.01464084f, -0.03994220f, -0.02100070f, -0.02334870f, -0.02668119f, -0.00772310f, 0.00729132f, 
    -0.03300918f, -0.04746947f, 0.02858218f, 0.03534485f, 0.00352369f, 0.00821933f, 0.04532692f, 0.02501684f, 
    -0.05275444f, -0.04568634f, -0.01674180f, 0.02108578f, -0.00348523f, -0.03871085f, -0.03035574f, -0.03944188f, 
    -0.00379150f, 0.02865067f, -0.03027259f, 0.01091206f, 0.01581922f, -0.01279100f, -0.05589569f, -0.05771619f, 
    -0.02656917f, -0.03421122f, -0.01722203f, 0.01389184f, -0.02496155f, -0.01276067f, 0.03320319f, -0.03614939f, 
    0.03498251f, 0.01881799f, -0.03054060f, 0.00469115f, -0.01872265f, -0.05634203f, -0.03004519f, -0.02587529f, 
    -0.01542734f, -0.03687831f, 0.04533149f, 0.01168297f, 0.00076826f, -0.03649778f, -0.04442510f, -0.03813660f, 
    0.01979159f, -0.00594302f, 0.01407804f, -0.00771231f, -0.03412065f, 0.03306812f, -0.01086665f, -0.03669310f, 
    -0.00816248f, -0.03263074f, 0.01309427f, -0.02786818f, 0.00682204f, 0.03954975f, -0.05438203f, 0.02529080f, 
    -0.03219363f, 0.03322316f, -0.00077868f, -0.03030479f, 0.02477859f, -0.00790905f, 0.02176418f, -0.05079381f, 
    0.03550637f, -0.01723200f, 0.01552706f, 0.03655617f, 0.03182143f, 0.02048100f, 0.00213779f, 0.00716595f, 
    0.00556250f, -0.00564001f, -0.00469805f, -0.02959174f, -0.05978084f, -0.01540473f, -0.03073430f, 0.01138338f, 
    -0.00132330f, 0.02110450f, -0.05474085f, -0.02686866f, -0.03710623f, 0.00045868f, -0.00695789f, -0.06777564f, 
    -0.01706318f, -0.06320273f, -0.07755394f, -0.07875656f, -0.03385928f, -0.02326898f, -0.00153490f, -0.05708399f, 
    -0.04676761f, -0.06577209f, 0.00276603f, 0.05126497f, -0.07195905f, 0.02733085f, -0.03790117f, 0.01806791f, 
    -0.00659065f, -0.02482908f, 0.00756084f, -0.02603666f, -0.03865847f, 0.02485001f, 0.01053109f, 0.02782433f, 
    0.02708796f, -0.07591435f, -0.02617957f, -0.01630963f, -0.00526164f, -0.04104761f, -0.00252665f, -0.03610273f, 
    -0.05707154f, 0.03910468f, -0.02939853f, -0.04756872f, -0.05156718f, -0.00071712f, -0.05691890f, 0.01135708f, 
    -0.00443363f, 0.02698223f, -0.02010617f, 0.05430032f, -0.02852914f, -0.03867604f, 0.01495251f, -0.00844701f, 
    -0.06007270f, -0.04397734f, 0.01606630f, -0.03439599f, -0.02865699f, -0.00090702f, -0.00312347f, 0.01609768f, 
    -0.03080497f, -0.03080881f, -0.02722349f, -0.07330731f, -0.00450268f, -0.01128107f, -0.05098106f, -0.01268629f, 
    -0.07415249f, -0.03425337f, -0.03928497f, -0.02161445f, -0.04323024f, 0.00891441f, 0.03814626f, -0.03361484f, 
    -0.05106220f, -0.03671731f, -0.04437707f, -0.01357712f, 0.01227818f, -0.03152356f, -0.05856640f, -0.04339493f, 
    0.00758373f, -0.00658780f, 0.00816054f, -0.04119165f, -0.03338344f, -0.02665570f, -0.07511415f, -0.03036847f, 
    -0.07792675f, 0.00452690f, -0.02694998f, -0.05783565f, -0.01220670f, -0.05538797f, -0.03936641f, -0.01317154f, 
    0.02074034f, 0.02540064f, 0.00124318f, 0.00300851f, -0.01479616f, 0.01764261f, 0.00057023f, -0.03795185f, 
    -0.05714984f, 0.02333665f, -0.07021439f, 0.03660613f, -0.01708380f, -0.00052905f, 0.02004335f, 0.04515017f, 
    -0.04281652f, -0.00439837f, 0.05137489f, -0.05585839f, -0.03287951f, 0.00580239f, -0.07426775f, -0.01243457f, 
    -0.04905426f, 0.00380558f, -0.03246346f, 0.04039447f, -0.06745731f, 0.04455356f, -0.02805123f, 0.01851686f, 
    -0.00955380f, 0.02126873f, 0.05057661f, -0.02965000f, -0.02072094f, -0.09483078f, -0.02593870f, 0.02867260f, 
    -0.03359244f, -0.02827280f, 0.02148979f, -0.02918828f, -0.01898298f, -0.04251201f, 0.01796254f, 0.00355959f, 
    0.04807736f, -0.06814736f, -0.02750146f, -0.03775384f, 0.02927584f, 0.02460186f, 0.02886665f, -0.04599842f, 
    -0.04857279f, 0.00161410f, -0.04861558f, -0.00831214f, -0.01734571f, -0.03101979f, 0.00088397f, -0.02339473f, 
    0.01909451f, 0.00161532f, 0.00186447f, 0.00779143f, 0.03622858f, -0.01400438f, 0.03034128f, 0.02973182f, 
    -0.02699869f, 0.04474005f, 0.00894433f, 0.02073072f, 0.04105219f, 0.01679059f, -0.07420345f, -0.02102439f, 
    -0.03502771f, 0.03660415f, 0.01317593f, -0.06198243f, 0.04256837f, -0.03830718f, -0.00772900f, 0.03092427f, 
    0.02078820f, 0.01028088f, -0.02826645f, 0.02514204f, -0.01120761f, 0.00016178f, -0.07086457f, -0.01518751f, 
    -0.00458731f, -0.03526800f, -0.03973233f, -0.01823645f, -0.04582893f, -0.00147489f, 0.02154849f, 0.02362594f, 
    -0.01546262f, -0.02565585f, -0.01763107f, 0.05049969f, 0.05108816f, 0.02746117f, 0.02938765f, -0.02153173f, 
    -0.06966286f, 0.01929912f, 0.03250854f, -0.03408927f, -0.05959862f, 0.00143019f, -0.04819730f, -0.03413798f, 
    -0.04503577f, -0.02276294f, 0.02674260f, -0.04015386f, -0.00817310f, -0.02851992f, -0.02990395f, -0.06321780f, 
    0.01889156f, 0.01106925f, -0.00781933f, -0.00186367f, 0.03094791f, 0.05601091f, -0.00759887f, -0.01777361f, 
    0.00367630f, -0.04850258f, 0.00862458f, 0.01318460f, -0.04803433f, -0.07426981f, 0.00372693f, -0.00708540f, 
    -0.00643822f, -0.04835926f, -0.04482673f, -0.04510874f, -0.01243909f, -0.04145126f, -0.07394509f, -0.03347629f, 
    -0.02624998f, -0.02162853f, 0.00045348f, 0.00222772f, -0.02896163f, -0.00477751f, 0.00301813f, -0.03473572f, 
    -0.00190716f, -0.02101649f, 0.03622074f, -0.00623910f, 0.02296617f, -0.05704380f, -0.03615768f, -0.03847585f, 
    0.01569113f, -0.04494523f, 0.00641003f, 0.03251234f, -0.03900619f, 0.01234477f, -0.06422358f, -0.00579453f, 
    -0.03881721f, 0.02439072f, -0.00753485f, 0.04733218f, 0.00111541f, 0.04949157f, 0.01799928f, 0.04800636f, 
    0.01127265f, -0.03255499f, -0.05732693f, -0.04223653f, 0.01450912f, -0.04434328f, 0.04637839f, -0.00616210f, 
    -0.01823311f, 0.02263250f, 0.02159817f, -0.00809688f, 0.02964297f, -0.02435493f, -0.05356029f, 0.03495810f, 
    0.01846605f, -0.07073163f, -0.06216453f, 0.02853920f, -0.01770745f, -0.02789092f, -0.03474408f, 0.01641226f, 
    0.00168063f, -0.05183605f, 0.00338358f, 0.03014793f, -0.01434153f, 0.02882073f, -0.05731688f, 0.04155128f, 
    -0.06293039f, 0.00438873f, -0.00218451f, -0.02257065f, -0.03323248f, -0.05812413f, 0.02466011f, -0.05240974f, 
    0.00709563f, -0.03735780f, -0.01226857f, -0.00183719f, -0.00005665f, -0.04273318f, 0.03708498f, 0.02255270f, 
    -0.04063516f, 0.01206537f, -0.02721721f, -0.03696127f, 0.02903557f, 0.01768056f, -0.07309008f, -0.02971242f, 
    -0.02082953f, -0.02747124f, -0.02275933f, 0.00810052f, -0.03581217f, -0.00205777f, 0.00196299f, -0.04653105f, 
    -0.03351456f, -0.07867010f, -0.05907684f, -0.04909540f, -0.02650250f, -0.03492533f, 0.03435858f, 0.02379304f, 
    -0.10574748f, 0.08683089f, 0.22574130f, 0.25785536f, -0.05033850f, -0.08373849f, 0.01815227f, 0.10631942f, 
    0.02459097f, 0.14331828f, 0.21066305f, 0.03579175f, 0.36834967f, -0.13825230f, 0.04925502f, -0.00478821f, 
    -0.09540424f, 0.02030374f, -0.01239709f, -0.13076451f, -0.04209133f, 0.07886900f, 0.05407942f, -0.08845858f, 
    0.39022985f, 0.16785936f, -0.03098909f, -0.09333665f, 0.16240893f, 0.13266760f, -0.00598157f, -0.04198219f, 
    -0.09476658f, -0.09108131f, 0.05611766f, -0.05123197f, 0.02296633f, 0.30942687f, -0.00158139f, 0.06269799f, 
    0.09728707f, -0.02831330f, 0.00657328f, 0.16679937f, 0.05233192f, -0.20206934f, -0.14997458f, -0.19546181f, 
    0.13981755f, 0.17307715f, 0.14091121f, -0.14020501f, -0.02451365f, -0.01504187f, 0.05521449f, -0.17060399f, 
    -0.13426884f, 0.01098024f, -0.08974735f, 0.15845825f, 0.05253801f, -0.00396118f, -0.00559932f, 0.16144881f, 
    -0.06125260f, 0.07744371f, -0.08145097f, 0.00689687f, 0.01429964f, -0.10078952f, -0.17840502f, 0.03080659f, 
    -0.31344259f, 0.02648682f, -0.08484776f, -0.20205529f, 0.15723149f, 0.05330358f, -0.02855723f, 0.02275068f, 
    0.01701916f, -0.02495311f, 0.02281008f, 0.07501757f, 0.05644077f, 0.15165892f, -0.12815797f, 0.10461101f, 
    0.04560992f, -0.03742221f, 0.09284707f, 0.10245062f, -0.15540627f, 0.06448203f, -0.03269023f, 0.06101225f, 
    -0.19827344f, 0.02483716f, -0.01805946f, -0.21241206f, -0.00987405f, 0.02126240f, -0.08317294f, -0.04908668f, 
    0.07641725f, 0.03347065f, -0.06145894f, -0.18993674f, -0.00033013f, -0.02721374f, -0.08183128f, -0.21076280f, 
    -0.01964246f, 0.01612607f, -0.06137774f, -0.02075857f, -0.07522594f, 0.03497271f, 0.02812250f, -0.10970802f, 
    -0.20885496f, 0.08470869f, 0.02405711f, 0.07751709f, 0.06929523f, 0.06647795f, -0.00625486f, -0.08307385f, 
    -0.07474258f, -0.03581618f, -0.12032194f, -0.03412699f, 0.15197915f, 0.08291143f, -0.06701613f, 0.01119757f, 
    0.03565138f, 0.03575888f, 0.09059908f, 0.11537590f, -0.07364535f, -0.09858376f, -0.03391355f, -0.05108126f, 
    -0.19216478f, 0.03077916f, -0.12156072f, 0.14258346f, -0.03135454f, 0.01890575f, -0.06525964f, 0.04338969f, 
    -0.06508134f, 0.07778637f, 0.00859664f, 0.09640925f, -0.29788807f, -0.19181336f, 0.19895029f, 0.07022937f, 
    -0.01986397f, 0.09290104f, 0.10740456f, -0.11154114f, 0.03867374f, 0.03874058f, -0.09792218f, -0.04814596f, 
    0.14822748f, 0.11003073f, -0.20000097f, -0.08695517f, -0.11165281f, -0.05507853f, 0.06879728f, -0.06533420f, 
    -0.04539576f, -0.06071742f, -0.12499429f, -0.00902415f, 0.12531887f, -0.18384302f, 0.11342307f, 0.16741605f, 
    -0.03347426f, -0.02508632f, -0.06719427f, 0.02227818f, -0.05023773f, -0.03977735f, 0.11916582f, 0.04529122f, 
    0.09849112f, 0.01101032f, -0.04181844f, -0.12008300f, 0.01134884f, -0.01925863f, -0.00646285f, 0.01761015f, 
    0.10079917f, -0.01859788f, -0.03290082f, 0.03127757f, 0.11718488f, 0.13054620f, 0.05463804f, 0.14976342f, 
    0.10756738f, -0.01600287f, 0.14302137f, 0.14299954f, -0.00859443f, 0.02595746f, -0.04744245f, 0.04580718f, 
    0.13321269f, 0.14278224f, -0.17563240f, -0.13109355f, -0.01357860f, -0.01747555f, -0.14465176f, 0.10860566f, 
    0.11254143f, 0.03513018f, -0.00599303f, 0.07342221f, 0.01212377f, 0.13093430f, -0.08369871f, -0.14713718f, 
    0.11947838f, -0.05206961f, -0.19521865f, -0.06826260f, -0.02362705f, 0.15441510f, 0.05833802f, 0.12512675f, 
    -0.16566323f, 0.10136612f, -0.03855121f, 0.03497029f, 0.00561986f, 0.13824238f, 0.09332354f, 0.01486104f, 
    -0.06376422f, 0.03081590f, 0.06676961f, 0.07395308f, 0.18942820f, -0.16629976f, 0.19822386f, 0.16490749f, 
    -0.08352434f, 0.08165579f, 0.05782344f, 0.05910158f, -0.00091738f, 0.10755403f, 0.02595760f, 0.14257148f, 
    0.03759907f, -0.08745053f, -0.04003747f, -0.17005067f, -0.03091950f, -0.04345148f, -0.02941868f, -0.04663681f, 
    0.01067295f, 0.04246911f, 0.09191579f, 0.07139392f, -0.28041327f, 0.26121980f, 0.04743138f, 0.36764464f, 
    -0.07747333f, -0.07070074f, 0.13327405f, 0.13253559f, -0.05220413f, 0.05699201f, -0.00587815f, -0.05506973f, 
    0.07568179f, 0.00794252f, 0.02041407f, 0.06791092f, -0.04313870f, 0.04392755f, 0.02202230f, -0.06570239f, 
    0.07165985f, 0.05096593f, 0.03305697f, -0.19652329f, -0.04645106f, 0.04464586f, 0.02653568f, 0.19514136f, 
    -0.00889274f, 0.01509616f, -0.02546854f, 0.10622030f, 0.07456478f, -0.09661943f, 0.31944442f, 0.08587069f, 
    0.23362710f, -0.02603454f, 0.24449401f, 0.08667630f, 0.06559242f, 0.03642224f, -0.01314177f, -0.01006186f, 
    -0.12626690f, 0.04156407f, 0.10290247f, -0.15851156f, -0.27109712f, 0.22922400f, -0.10320275f, -0.24006298f, 
    0.11137792f, 0.08766188f, 0.02846142f, 0.05613124f, -0.07190605f, 0.02613364f, -0.03041224f, 0.00611640f, 
    0.17431507f, 0.06449357f, 0.15336898f, 0.12657748f, -0.00927972f, 0.17425598f, 0.05382038f, 0.06500831f, 
    -0.06727391f, -0.09275027f, 0.12018207f, 0.04943840f, 0.18892153f, 0.02369877f, -0.02002593f, -0.00864241f, 
    -0.01297077f, 0.01062354f, -0.01514251f, 0.01805496f, 0.03769455f, 0.08621660f, -0.13199404f, 0.12716959f, 
    0.15650132f, 0.01549242f, -0.28842092f, -0.15743151f, 0.03983098f, 0.04485817f, -0.02485923f, 0.04220283f, 
    0.01100669f, 0.03692463f, 0.01224603f, 0.05496141f, -0.25074449f, 0.10511942f, 0.03929003f, 0.10727513f, 
    -0.05082648f, 0.19372338f, 0.12224056f, 0.02173414f, 0.10441780f, 0.01986996f, -0.06020126f, -0.09077652f, 
    -0.02791825f, 0.01049937f, 0.00533947f, 0.04344034f, 0.04891997f, -0.00754893f, -0.04423504f, 0.04467391f, 
    0.01461864f, -0.03476566f, 0.04655348f, 0.00361659f, 0.03353215f, -0.02720928f, 0.03297951f, -0.02847627f, 
    -0.01331536f, -0.00160606f, 0.04658612f, 0.02819548f, -0.03926951f, 0.01973154f, 0.02356397f, -0.00725767f, 
    0.03288895f, -0.00924544f, -0.01279467f, -0.00928076f, -0.02839641f, 0.02201432f, 0.00846477f, -0.00002565f, 
    -0.04542940f, 0.02378360f, 0.03623005f, -0.05412916f, -0.00348755f, -0.05002847f, 0.03210109f, 0.01370723f, 
    0.01621583f, -0.04037940f, -0.04455354f, -0.01029488f, 0.05034189f, -0.02955303f, 0.03587335f, 0.04129818f, 
    0.00339320f, -0.01209276f, 0.03454340f, 0.00551895f, -0.05033759f, -0.00349667f, -0.02966459f, 0.00206241f, 
    0.03196013f, -0.02930140f, 0.02396558f, -0.05587551f, 0.01321396f, -0.03961937f, -0.00395520f, 0.04863740f, 
    0.03312151f, 0.02987602f, -0.01417777f, -0.04138435f, 0.02419462f, 0.00196072f, 0.00605417f, 0.02529029f, 
    -0.03408168f, -0.01909570f, 0.01937963f, -0.02665150f, -0.00597738f, 0.04091125f, 0.02348473f, -0.01632498f, 
    -0.04454646f, 0.03386752f, 0.02243967f, -0.05298683f, 0.04070468f, -0.03299357f, -0.01291152f, -0.00289714f, 
    -0.01137585f, -0.04356470f, -0.04918317f, -0.04388605f, -0.02799908f, 0.00336798f, -0.03177036f, 0.00349817f, 
    -0.03139957f, -0.01399281f, 0.05158852f, 0.03391836f, 0.01659047f, -0.05326099f, 0.03251895f, -0.01494687f, 
    -0.03830834f, 0.02933166f, -0.02894441f, -0.03034090f, -0.00602154f, -0.00809962f, 0.00295182f, -0.04556753f, 
    0.03877265f, -0.04525678f, -0.02478469f, -0.03155148f, -0.03839333f, -0.03292579f, -0.02654269f, -0.00161304f, 
    -0.00854930f, -0.02301777f, -0.03074681f, -0.00731639f, -0.04522730f, 0.00139868f, 0.00005419f, 0.00328576f, 
    -0.00776508f, -0.02379042f, 0.00632492f, -0.01199455f, -0.03329764f, -0.02908841f, -0.04150914f, 0.00421580f, 
    -0.01014822f, -0.00693031f, -0.01663743f, 0.03550085f, 0.03286314f, 0.03575492f, 0.01641547f, 0.03062955f, 
    -0.01821268f, 0.02856348f, -0.02071251f, -0.04682100f, -0.03074024f, -0.00216614f, -0.01187787f, 0.01795783f, 
    -0.03064042f, 0.03307109f, -0.02183786f, 0.04471758f, -0.01974591f, -0.00729675f, -0.01334889f, -0.02805748f, 
    -0.02272878f, 0.03849824f, -0.02035032f, -0.03917643f, 0.04337586f, -0.00536806f, -0.02519615f, -0.01887183f, 
    -0.02624914f, 0.00080925f, 0.00203408f, 0.01000727f, 0.00708765f, 0.02130817f, 0.04556462f, 0.04042613f, 
    -0.04976593f, -0.03899487f, 0.00613532f, 0.01991727f, 0.02643204f, -0.01146782f, 0.03946417f, -0.03466270f, 
    -0.03969502f, -0.00829273f, -0.03463064f, -0.01914030f, 0.01715709f, -0.02292215f, -0.02520853f, 0.04328075f, 
    -0.01019590f, -0.01729737f, -0.02106933f, -0.02246838f, 0.04458135f, -0.01756459f, 0.00825198f, -0.04380496f, 
    0.01471564f, -0.01821339f, 0.01562316f, -0.00410540f, -0.03807454f, 0.00740460f, -0.03484511f, -0.03166239f, 
    -0.05227519f, -0.04570422f, 0.04185955f, -0.04482873f, -0.00976366f, 0.02193191f, -0.03844329f, -0.01271416f, 
    0.00479673f, -0.04755000f, 0.01394546f, 0.03134898f, 0.03641662f, 0.02735296f, 0.02675206f, 0.00692415f, 
    -0.04345925f, -0.01515368f, -0.01800535f, 0.02222064f, 0.02375503f, -0.04579223f, -0.01486247f, 0.03750028f, 
    0.04580442f, -0.04199419f, 0.00985820f, 0.01626544f, -0.04948353f, -0.04098665f, -0.02541761f, -0.01975850f, 
    0.02994064f, 0.04616389f, 0.00409899f, 0.00611718f, 0.03604653f, 0.00237605f, -0.01003889f, 0.01971676f, 
    -0.05242007f, 0.04096422f, -0.01378932f, 0.01213482f, -0.04993026f, -0.00530164f, 0.03815682f, -0.05668295f, 
    0.04558193f, -0.02041950f, 0.02557123f, -0.04414394f, -0.03979355f, -0.01544589f, -0.00841198f, 0.02559301f, 
    0.02791646f, 0.03625119f, 0.03111342f, 0.01347587f, -0.00027148f, 0.02013716f, -0.05497433f, 0.01808801f, 
    0.04321532f, -0.00392761f, 0.00576956f, 0.00190979f, -0.01850536f, 0.00053885f, 0.02145015f, -0.04582464f, 
    0.00926133f, 0.04511613f, 0.00430802f, -0.03235934f, 0.00637483f, -0.00424665f, 0.03058501f, 0.02958451f, 
    0.03431030f, 0.02810781f, -0.04712257f, -0.01259794f, 0.02614492f, -0.03312038f, 0.04521222f, 0.01800820f, 
    0.03104607f, -0.04786047f, -0.02443065f, -0.00332530f, 0.00893084f, 0.05462210f, 0.01647346f, -0.03259913f, 
    0.04359901f, -0.01839915f, -0.03737390f, -0.04645592f, -0.03719876f, -0.02804070f, -0.03899771f, 0.04657843f, 
    -0.03870672f, -0.00202848f, -0.02451862f, -0.01232086f, -0.05579675f, -0.02721273f, 0.04561063f, -0.05051376f, 
    -0.02884280f, 0.00533296f, 0.03331586f, -0.00165709f, 0.01052050f, -0.05174439f, 0.00467883f, 0.03736543f, 
    -0.03930170f, -0.04206100f, -0.01184237f, 0.02036155f, 0.04439019f, -0.01819667f, -0.05179546f, 0.00452287f, 
    0.04270682f, -0.03272494f, 0.02848440f, -0.04677774f, 0.02978963f, -0.00456745f, 0.00308202f, -0.05086732f, 
    -0.04326451f, 0.01166654f, 0.03595018f, -0.02876341f, -0.03963535f, 0.01748865f, -0.05164449f, -0.00521939f, 
    0.04851915f, 0.01530986f, -0.04510297f, -0.02546108f, -0.02037847f, 0.00492875f, 0.00643672f, -0.00038859f, 
    0.02869639f, -0.03571920f, -0.01951093f, 0.04028041f, -0.03965530f, -0.04836341f, 0.00357761f, -0.03842028f, 
    0.00903238f, 0.01874041f, -0.03331428f, 0.05094182f, -0.01919699f, 0.00462672f, -0.05648621f, 0.04302202f, 
    0.00242967f, 0.02384209f, -0.04823831f, 0.00881411f, 0.04522926f, 0.00798646f, -0.03238160f, -0.04120002f, 
    0.18799351f, 0.10323186f, -0.17241454f, -0.22377157f, 0.05305388f, 0.03855856f, 0.13519421f, 0.06047828f, 
    0.12306525f, 0.01153338f, -0.13782710f, -0.00369123f, -0.06279697f, -0.06698876f, -0.06893805f, -0.04999270f, 
    0.09687261f, 0.06036082f, -0.03112525f, 0.02170820f, 0.00539844f, -0.02256608f, -0.05457013f, -0.01644975f, 
    -0.29664347f, -0.06547349f, 0.06524673f, -0.00725128f, -0.03037712f, -0.10220154f, 0.10608265f, -0.00624876f, 
    0.00795003f, 0.08396274f, -0.02029268f, 0.00591903f, -0.00659584f, -0.09844568f, 0.00092084f, -0.09940906f, 
    -0.07188100f, 0.09211855f, -0.05660738f, -0.12748313f, -0.00214935f, 0.17042354f, 0.17350379f, 0.08205306f, 
    -0.15558644f, -0.11514046f, -0.13284123f, 0.26178855f, 0.01142007f, 0.13073900f, 0.11395389f, 0.06220312f, 
    0.11028562f, -0.00912195f, -0.00751948f, 0.11897283f, -0.43998608f, -0.23007166f, 0.01563654f, -0.17410366f, 
    0.19167899f, 0.00945063f, 0.13502203f, 0.01796633f, 0.10639884f, 0.03225270f, 0.09551883f, -0.04787176f, 
    0.38353348f, 0.13779287f, 0.24922520f, 0.33310074f, -0.12148405f, 0.00606352f, -0.02468649f, -0.05950386f, 
    -0.02926782f, 0.07517286f, 0.02224233f, 0.07170320f, 0.07128273f, 0.05536109f, 0.14691071f, 0.07507800f, 
    -0.06375585f, -0.00820937f, -0.09630119f, 0.07076726f, 0.16627043f, -0.01210295f, 0.03342045f, 0.15625398f, 
    -0.04019489f, 0.27219591f, 0.21442367f, 0.21580169f, -0.16159099f, 0.00650855f, -0.00558558f, -0.07103211f, 
    -0.05480700f, 0.06375962f, 0.02457037f, 0.19253576f, -0.17257589f, 0.24737488f, 0.13646246f, 0.29640096f, 
    -0.00837569f, 0.03097462f, 0.03904348f, 0.00571921f, 0.04826980f, -0.03456347f, 0.07302333f, -0.00036735f, 
    -0.31851798f, -0.21142700f, 0.08111373f, -0.18732484f, 0.06171288f, -0.07893053f, 0.18852569f, 0.06281713f, 
    0.08082983f, -0.05086002f, 0.03990126f, -0.01503389f, -0.17754728f, 0.15347214f, -0.09772410f, 0.02543923f, 
    -0.01450358f, -0.04015187f, -0.13764250f, 0.00278699f, 0.00586410f, 0.08341298f, -0.03618833f, 0.06516616f, 
    0.32250744f, 0.09465692f, 0.22125852f, -0.13541925f, 0.09030720f, -0.03240642f, 0.03076232f, -0.00188175f, 
    0.10708861f, -0.05609505f, 0.00796508f, 0.10139548f, 0.00656231f, 0.24025425f, -0.00736677f, 0.09769569f, 
    -0.10334237f, -0.11262373f, 0.18074486f, 0.06623744f, 0.00917062f, -0.11700107f, 0.08988537f, 0.02703685f, 
    -0.31486818f, -0.23239513f, 0.03207320f, 0.00847599f, 0.08882943f, -0.01080670f, -0.07210463f, 0.01137281f, 
    0.03124751f, 0.08814362f, 0.05419349f, 0.04706017f, -0.11346932f, -0.03773856f, -0.20557609f, -0.22711101f, 
    0.14601268f, 0.14843647f, 0.09379005f, -0.02133938f, 0.05927024f, 0.10899079f, -0.17637376f, -0.01301540f, 
    -0.26971880f, -0.15681751f, -0.04334089f, -0.11741930f, -0.00466637f, 0.00535618f, -0.10694499f, 0.04308775f, 
    -0.03350447f, 0.11765944f, -0.06056453f, -0.06115150f, -0.24545456f, -0.14820632f, -0.09489048f, -0.25385836f, 
    0.10795584f, 0.07911574f, -0.03473612f, 0.08466655f, 0.04610116f, -0.02327408f, 0.08658160f, -0.08587048f, 
    -0.01051037f, 0.10631904f, 0.19367169f, 0.08050655f, -0.01998082f, 0.14898673f, 0.05979926f, -0.11154690f, 
    -0.10212003f, 0.11882162f, 0.05616320f, -0.09432133f, -0.18369985f, -0.08415560f, 0.10231483f, 0.14409715f, 
    -0.14837183f, 0.01142304f, 0.02599229f, 0.03017928f, -0.01259321f, 0.02429890f, 0.02837447f, -0.10359345f, 
    0.18009140f, 0.04443323f, 0.05976086f, -0.02697876f, 0.13082170f, -0.06782407f, -0.14963177f, -0.02492732f, 
    0.02967585f, 0.04571571f, 0.04627686f, -0.09009270f, -0.05250202f, -0.00417421f, -0.25926536f, -0.04813431f, 
    0.08374473f, 0.05496504f, 0.00842774f, 0.02913069f, -0.01737258f, -0.00726529f, 0.05195023f, 0.00866923f, 
    0.12861174f, 0.10454152f, 0.06951129f, 0.26900664f, -0.01600934f, 0.18506929f, 0.02430739f, -0.08196943f, 
    0.12856725f, 0.07594290f, 0.06182048f, -0.10613862f, 0.17019174f, -0.06883864f, -0.10458206f, -0.20420659f, 
    0.06987948f, -0.01103646f, 0.02902439f, 0.01034927f, 0.15966772f, -0.00413379f, -0.00907914f, 0.17871524f, 
    0.16795671f, -0.09995372f, 0.11351039f, -0.06096948f, -0.17020863f, 0.05039760f, 0.01610742f, -0.00470876f, 
    0.00279453f, -0.02676496f, 0.09940918f, 0.10174640f, 0.11480387f, 0.10145782f, -0.09855419f, -0.07923194f, 
    0.01665416f, -0.02677173f, 0.06126900f, 0.01891331f, 0.06332118f, 0.09289957f, -0.24036270f, -0.12841961f, 
    -0.12024714f, -0.18431610f, -0.18594863f, -0.00490244f, -0.04230871f, -0.01132130f, 0.01467050f, 0.04963451f, 
    0.10553715f, 0.00747059f, 0.05772391f, 0.04315810f, 0.34534279f, 0.16473088f, 0.16646464f, 0.31423178f, 
    -0.01089194f, -0.05887454f, 0.04264444f, -0.11901169f, 0.12820449f, 0.05593771f, 0.01319683f, 0.08814532f, 
    -0.25914839f, -0.23330019f, -0.29024366f, 0.11727296f, 0.09267158f, 0.00627195f, 0.08536390f, -0.02372678f, 
    -0.04571603f, 0.00637711f, -0.14250091f, -0.05273164f, -0.31662038f, -0.07770888f, -0.10404199f, -0.11848986f, 
    0.10681787f, -0.05616636f, -0.02557616f, 0.10391049f, -0.04518801f, -0.05819405f, 0.03323509f, -0.13682991f, 
    -0.05529226f, 0.17186061f, 0.28639856f, 0.13837273f, -0.01870786f, -0.01649352f, 0.01910665f, -0.04544370f, 
    -0.06342636f, 0.08613616f, -0.06944600f, 0.00650094f, 0.19695230f, -0.11199814f, 0.13423164f, -0.17029728f, 
    -0.02102321f, -0.18043974f, 0.15809701f, 0.12511663f, -0.11311741f, -0.01863168f, 0.03981467f, 0.03478891f, 
    0.28944013f, 0.20380478f, -0.00411290f, -0.10199116f, -0.01862438f, -0.02583831f, 0.05626902f, -0.08056699f, 
    -0.05061859f, -0.09165767f, -0.03503372f, -0.06220762f, -0.09135814f, 0.24011329f, 0.08821418f, -0.03836834f, 
    0.02362214f, 0.01841375f, 0.07912790f, 0.17934932f, 0.09382047f, 0.13053057f, 0.03566088f, 0.09064440f, 
    0.46226236f, 0.33521330f, -0.13569832f, 0.02744449f, 0.03198706f, -0.07081596f, 0.15123662f, 0.09546569f, 
    0.08025569f, 0.07037523f, -0.10751963f, 0.04564601f, -0.04702978f, -0.21281019f, 0.30588573f, -0.05926743f, 
    -0.09038473f, -0.03280392f, 0.02155612f, 0.00074127f, 0.07613201f, 0.02723662f, 0.09678034f, 0.15264271f, 
    0.14630029f, -0.04917727f, 0.20815744f, 0.11663479f, 0.04307009f, 0.16103289f, 0.01596793f, 0.16925578f, 
    0.05296691f, -0.08986316f, 0.18006581f, -0.09061144f, 0.23777796f, 0.19392718f, 0.06070588f, -0.02037799f, 
    -0.05549746f, -0.08958530f, 0.04993269f, 0.06995492f, 0.08782175f, 0.04170945f, 0.09395576f, -0.10411119f, 
    0.17019098f, -0.23974098f, -0.01145649f, 0.13391203f, 0.19177972f, -0.09411665f, -0.03833627f, -0.09264065f, 
    -0.02304816f, 0.10797972f, -0.04827586f, -0.14082442f, -0.10290204f, -0.06376086f, 0.16757214f, 0.05018545f, 
    -0.12897527f, -0.02489591f, -0.05452650f, -0.02311268f, -0.03416829f, -0.01452733f, 0.26346686f, -0.04398916f, 
    -0.00959839f, -0.18306379f, -0.03937335f, 0.44113836f, 0.08353907f, 0.00167221f, 0.05142686f, -0.04028563f, 
    0.08177715f, -0.05202601f, 0.14007089f, 0.14577581f, -0.23739354f, 0.02120381f, 0.04812017f, 0.15121843f, 
    0.02112176f, 0.03864909f, 0.00630297f, -0.07661141f, 0.17321678f, 0.04092719f, -0.05715621f, 0.19626279f, 
    0.09835763f, 0.14802955f, -0.16417316f, 0.00745726f, -0.05976630f, -0.05344734f, 0.07139052f, -0.11519184f, 
    0.13520381f, 0.04666463f, 0.11776757f, 0.12338804f, -0.00973088f, -0.22328345f, 0.08000091f, -0.16510056f, 
    -0.10351482f, -0.13875708f, 0.01798285f, 0.11009328f, 0.05618434f, 0.13383882f, -0.01874728f, 0.00194212f, 
    0.11506863f, -0.29918599f, -0.06629014f, -0.09298460f, 0.00210734f, -0.08884448f, 0.18897739f, -0.06716109f, 
    -0.07659326f, -0.07512352f, -0.04074691f, -0.07999258f, -0.14864217f, -0.17205189f, -0.19177571f, -0.33400130f, 
    0.15037988f, -0.07238242f, -0.10224023f, -0.03739117f, 0.07521575f, 0.00297133f, 0.06849839f, 0.13968463f, 
    0.09418489f, 0.07990267f, 0.06017657f, -0.01955183f, 0.00342679f, 0.13642286f, -0.14311768f, 0.16061720f, 
    -0.03410198f, -0.00449122f, 0.05953088f, -0.13628687f, -0.27665457f, 0.39165878f, 0.05997436f, 0.09978358f, 
    -0.11370236f, 0.11283746f, 0.07888385f, 0.07689310f, -0.00680490f, 0.01209412f, 0.04496508f, -0.00034792f, 
    0.11185030f, -0.04796134f, 0.01400200f, -0.02552760f, 0.11154797f, -0.05514664f, 0.13955107f, -0.02781935f, 
    0.05956373f, 0.03329706f, -0.02803542f, 0.06319175f, 0.09938762f, 0.18444213f, 0.05883082f, 0.21709494f, 
    -0.02540730f, 0.11811116f, 0.01822049f, 0.01129280f, 0.02177911f, 0.04628076f, 0.11840639f, -0.07531648f, 
    -0.14984038f, -0.21336836f, 0.07324691f, 0.11247721f, 0.04938786f, -0.02491255f, 0.01807854f, 0.03450639f, 
    -0.07909738f, 0.03746619f, 0.10537339f, -0.05704685f, 0.11895552f, -0.13048922f, 0.00833473f, -0.06635162f, 
    0.04169745f, 0.04223610f, -0.06803908f, 0.10836250f, 0.06371585f, 0.01262023f, -0.03662762f, -0.08609759f, 
    0.17735980f, -0.07811385f, 0.04035677f, 0.03734558f, -0.12117346f, -0.06557569f, -0.02313321f, 0.07669000f, 
    0.07719819f, -0.01565183f, -0.11402498f, 0.01208156f, -0.07249092f, -0.09137955f, 0.10616850f, -0.24075152f, 
    0.03637819f, -0.07027853f, -0.08256631f, -0.04560522f, -0.01642176f, 0.02761602f, 0.06409373f, -0.06498085f, 
    -0.06168269f, -0.04096605f, 0.03326665f, -0.01052944f, 0.02926359f, -0.03777863f, -0.01039941f, 0.01320233f, 
    0.05104111f, -0.01235298f, -0.11043866f, 0.01774910f, -0.16073413f, 0.01106753f, -0.07951879f, 0.14365675f, 
    -0.07017589f, 0.10870960f, -0.02289567f, -0.15316878f, 0.05300881f, -0.01789294f, 0.06405888f, 0.00157082f, 
    0.02500994f, 0.02692306f, -0.17565194f, 0.08876967f, 0.04642314f, -0.01292671f, 0.06607885f, 0.03214944f, 
    0.01296296f, 0.00288911f, -0.11870366f, 0.11372897f, -0.13756584f, -0.02172337f, 0.14166372f, 0.03831794f, 
    -0.03889447f, 0.07334427f, -0.01676036f, 0.01207832f, 0.06317511f, 0.13706706f, -0.14361498f, -0.01778621f, 
    0.22007595f, 0.03169180f, 0.20821032f, -0.08120766f, -0.01668958f, 0.08401261f, 0.09107268f, -0.16405137f, 
    -0.00454682f, 0.10098770f, -0.07162111f, 0.04551160f, 0.22874831f, -0.23184034f, -0.02212236f, 0.13092159f, 
    0.07613966f, -0.03651867f, -0.07147387f, -0.02493991f, 0.04867697f, -0.01510590f, 0.09673720f, 0.07401847f, 
    0.24460053f, 0.15096828f, 0.23928584f, 0.16440143f, -0.02377006f, -0.10419559f, -0.02743008f, 0.05556087f, 
    -0.02026269f, 0.09986968f, -0.07093436f, -0.06423301f, -0.12709874f, 0.01846679f, 0.07686018f, 0.09870961f, 
    -0.08187520f, 0.00218419f, 0.08697476f, 0.04978713f, -0.02817576f, -0.02666935f, -0.11504768f, -0.13433267f, 
    0.09461854f, 0.14817387f, 0.02295926f, 0.11420026f, 0.06573411f, -0.03838394f, -0.08541667f, -0.01647590f, 
    0.05009464f, 0.03286856f, 0.03123215f, -0.03559341f, -0.01512782f, -0.13987696f, -0.39016387f, 0.06006074f, 
    0.03763254f, 0.11122181f, -0.03977110f, -0.17157741f, -0.00057088f, 0.02559893f, 0.05803887f, -0.05847930f, 
    -0.02997169f, -0.04193311f, -0.04453319f, -0.00162421f, 0.02153080f, -0.02038589f, 0.01675433f, -0.01941205f, 
    0.03860513f, -0.04460264f, -0.03418519f, -0.01699855f, -0.02326388f, 0.03871318f, 0.03687248f, -0.02768723f, 
    -0.05385406f, 0.03857574f, -0.03918646f, 0.03459342f, 0.00321525f, -0.01944725f, -0.04947601f, -0.01747626f, 
    0.03845057f, 0.00601478f, -0.03409467f, -0.02195042f, 0.00736107f, -0.00501970f, -0.05100185f, 0.00444101f, 
    0.03296294f, -0.02655216f, 0.01951527f, -0.04500236f, -0.03234843f, -0.02798066f, 0.01069609f, 0.03419504f, 
    -0.03627999f, -0.03775107f, 0.01809443f, 0.04065536f, 0.03123801f, -0.04171098f, 0.03034016f, -0.02648026f, 
    -0.04980819f, -0.00415382f, 0.03034980f, 0.02114557f, -0.02262732f, -0.01821033f, -0.00954344f, -0.06132295f, 
    0.00924602f, 0.03529873f, 0.01553107f, -0.05876524f, -0.00548683f, 0.01688643f, 0.02295465f, -0.04024566f, 
    0.03760553f, 0.02227482f, 0.02679587f, -0.05047294f, -0.05487465f, 0.02626257f, 0.03436953f, -0.01265275f, 
    0.03501323f, -0.04273517f, -0.02107835f, -0.05165089f, -0.03442622f, -0.01999554f, -0.04140794f, 0.03073276f, 
    -0.05788857f, 0.03696758f, 0.03419071f, -0.02899425f, -0.02770725f, 0.01987510f, -0.01116075f, -0.03545735f, 
    -0.04367476f, 0.02388256f, -0.01896095f, 0.04147302f, -0.02046681f, 0.00443859f, 0.01425963f, 0.03293505f, 
    -0.02311580f, 0.01877249f, -0.04043739f, -0.00636129f, -0.03628503f, -0.02246298f, -0.00644945f, -0.03629989f, 
    -0.03149983f, -0.03638902f, -0.03312099f, -0.04749119f, -0.03313902f, 0.02779644f, 0.02348133f, -0.00970771f, 
    -0.02561692f, -0.04909474f, 0.02567258f, 0.04014576f, -0.04447548f, 0.01133062f, -0.02500109f, 0.02666149f, 
    -0.03352384f, -0.05029566f, -0.02193532f, 0.02159436f, -0.03014107f, 0.00465575f, 0.02191582f, 0.02472057f, 
    0.00032178f, -0.04269391f, 0.00755382f, -0.02689865f, -0.03290638f, -0.02233131f, 0.02284002f, 0.00156516f, 
    -0.03614559f, -0.05086970f, -0.05549468f, -0.03609997f, -0.00671890f, -0.04544695f, 0.01562723f, 0.00998303f, 
    0.00728692f, 0.03158473f, -0.03677131f, -0.00022479f, -0.00250584f, 0.00415166f, 0.00495168f, -0.03465306f, 
    -0.03924590f, -0.04302717f, 0.03523873f, 0.00632181f, -0.03572623f, -0.05070114f, 0.00622037f, -0.01332643f, 
    -0.03324283f, -0.03679053f, 0.01265083f, -0.00257064f, -0.00204980f, 0.00086342f, 0.00872666f, -0.01592772f, 
    -0.01818098f, -0.02533335f, -0.03497272f, 0.03877402f, -0.02820334f, 0.03248189f, -0.03962659f, 0.00530961f, 
    -0.06028111f, -0.03430912f, -0.02494322f, -0.04823048f, -0.01674492f, -0.02503644f, -0.04581089f, -0.02737532f, 
    -0.03220846f, 0.01979670f, -0.03467881f, -0.04740389f, -0.03061016f, -0.00997441f, -0.00662368f, 0.03856617f, 
    -0.03598947f, -0.03394663f, -0.03921889f, 0.01353054f, 0.03057311f, 0.03525551f, 0.02435184f, 0.02036826f, 
    -0.02744121f, -0.00027128f, 0.01934313f, -0.01641816f, 0.03661506f, -0.03649891f, -0.00181539f, -0.05462469f, 
    -0.00620847f, -0.05437429f, 0.00984802f, 0.04667999f, 0.02966074f, -0.01865899f, -0.00230076f, 0.02861706f, 
    0.02026738f, -0.01103337f, -0.05788422f, -0.00398812f, -0.01082362f, 0.03845252f, -0.04207974f, -0.02736376f, 
    0.01534010f, -0.04712458f, 0.00214812f, 0.02037547f, 0.00058637f, -0.05469024f, -0.01041800f, 0.01350797f, 
    -0.04488358f, -0.00617634f, 0.03904162f, 0.02351553f, -0.04727805f, -0.04807325f, 0.01545691f, -0.04108687f, 
    -0.05075482f, 0.01866944f, -0.04399386f, 0.01327060f, 0.02250618f, -0.00108037f, 0.02892224f, -0.01682790f, 
    -0.02429479f, -0.00154812f, -0.02611791f, -0.05894589f, 0.03091709f, 0.04518121f, 0.00488863f, 0.03720710f, 
    -0.03474493f, 0.03850295f, -0.05480141f, 0.03432213f, -0.01921683f, 0.01404504f, -0.00315675f, -0.03297072f, 
    0.03034704f, -0.05284395f, -0.01806446f, -0.03975863f, 0.01162688f, -0.04829763f, -0.05655770f, -0.00103176f, 
    -0.05052538f, -0.05067207f, -0.03976751f, -0.02118059f, 0.00169773f, 0.03539369f, -0.00111920f, 0.03762661f, 
    0.03992157f, -0.04702555f, 0.04795387f, -0.00630248f, 0.02919017f, 0.03568293f, -0.01152500f, -0.02815466f, 
    -0.00264889f, -0.00440823f, -0.00674809f, -0.02893752f, -0.02224310f, -0.04174575f, -0.02519140f, -0.01656761f, 
    0.03410060f, 0.01196390f, -0.03167078f, -0.00957035f, -0.03697551f, -0.05905110f, 0.02037279f, 0.02520109f, 
    0.02807196f, -0.04662931f, -0.02151822f, 0.01594562f, 0.01758565f, -0.02461199f, 0.01832407f, -0.01064146f, 
    -0.01066532f, -0.01602797f, 0.02810620f, -0.00241675f, 0.02850603f, 0.01872976f, -0.00127145f, -0.01142263f, 
    0.01327680f, -0.04334939f, -0.02110158f, 0.03537195f, 0.03192550f, 0.00113322f, -0.03157854f, 0.00411091f, 
    -0.01521713f, 0.02865498f, -0.02855940f, -0.04042856f, -0.01350677f, 0.03656893f, -0.01788066f, 0.01713540f, 
    -0.05568107f, -0.01772361f, -0.04973464f, -0.00084408f, -0.00197504f, -0.05296288f, 0.00493309f, 0.01863765f, 
    -0.05809269f, 0.00878291f, -0.03635758f, 0.01630189f, -0.00128168f, -0.04865723f, -0.03956901f, -0.02708849f, 
    0.03210194f, 0.01429826f, -0.02326400f, 0.00083593f, -0.05152523f, -0.03962990f, 0.00813121f, -0.05163302f, 
    -0.03252474f, -0.01596847f, -0.02111411f, 0.01290006f, 0.00429642f, -0.01148175f, -0.03704852f, -0.03724148f, 
    0.00271312f, 0.00785107f, 0.01293686f, 0.02238565f, 0.00896274f, -0.00422226f, 0.03834539f, -0.05568868f, 
    -0.04727342f, 0.02903857f, -0.04252482f, 0.02912273f, 0.01042948f, -0.01168248f, 0.00321625f, 0.02606119f, 
    -0.25601596f, -0.13562788f, 0.06927556f, 0.03755665f, -0.03969043f, -0.05141994f, -0.02413789f, 0.14589277f, 
    0.10997895f, -0.00061404f, 0.03501709f, -0.07550792f, 0.23808275f, 0.02872578f, -0.11919484f, 0.13610134f, 
    -0.00089206f, 0.06607402f, 0.00272819f, -0.01721129f, -0.05034281f, -0.02651187f, 0.08653954f, -0.00823552f, 
    -0.41424447f, -0.06763830f, -0.12648734f, -0.15815252f, -0.09315618f, -0.00117550f, -0.12414139f, 0.07805505f, 
    0.05453178f, -0.04500776f, 0.01772709f, -0.12797390f, 0.33548486f, 0.17183693f, 0.05361348f, 0.17913716f, 
    0.10719088f, 0.06301119f, -0.02360842f, 0.13656633f, -0.14438318f, -0.04454709f, -0.04629859f, 0.03264536f, 
    -0.16148898f, -0.02113676f, -0.17292370f, -0.02568446f, -0.09520458f, 0.00469849f, -0.13155925f, -0.02422909f, 
    0.02629297f, 0.13680437f, 0.00486869f, 0.05192634f, 0.35497773f, 0.15352732f, -0.20200394f, -0.00388047f, 
    -0.05368226f, 0.02445006f, -0.01404077f, 0.00400932f, 0.03975120f, 0.03190709f, 0.02292655f, 0.07473526f, 
    -0.24762882f, -0.23280759f, -0.17734520f, -0.20635363f, 0.12775791f, 0.02471250f, -0.00843451f, -0.02014173f, 
    0.17919309f, 0.00083609f, 0.14359477f, 0.15985273f, -0.08318762f, -0.07821752f, -0.10225867f, 0.05926738f, 
    0.17103559f, 0.02124036f, -0.12493152f, -0.08398362f, -0.10435159f, -0.07024536f, -0.05761067f, -0.10253257f, 
    0.08754718f, -0.10260937f, 0.08275650f, 0.05350643f, 0.14028792f, -0.05291073f, -0.02357936f, -0.07493256f, 
    0.00729389f, 0.00896264f, -0.00620031f, 0.02705125f, 0.00519320f, -0.15761967f, 0.06400585f, -0.06337007f, 
    0.01098361f, 0.02092697f, -0.03032777f, 0.00359845f, 0.04237277f, -0.03500523f, 0.06162165f, 0.00793963f, 
    0.11430609f, -0.07732681f, 0.12662528f, -0.04444182f, 0.10619968f, 0.01981093f, -0.00119410f, 0.11703051f, 
    -0.07991285f, 0.16336472f, 0.01150105f, -0.09977700f, 0.06152930f, -0.07293162f, -0.03525987f, -0.02740469f, 
    -0.00832671f, -0.04894137f, 0.05765118f, 0.13043539f, 0.10217725f, 0.08466513f, 0.11216968f, 0.14150359f, 
    -0.20888527f, -0.00236872f, -0.17075463f, 0.00999518f, 0.14910060f, -0.07979834f, -0.04098588f, 0.00418543f, 
    0.10986757f, 0.03743462f, 0.14425997f, 0.02056422f, -0.03855811f, -0.12389140f, 0.12194987f, -0.14437628f, 
    -0.10993361f, 0.02875387f, -0.00638748f, 0.02805039f, 0.03701971f, 0.01064564f, 0.02678315f, 0.13430706f, 
    0.07236324f, 0.23460585f, -0.01149504f, 0.06148767f, -0.05451165f, -0.00855750f, -0.02968378f, -0.02068521f, 
    0.03480146f, 0.12034348f, -0.05081860f, 0.06093762f, 0.40194124f, -0.05851064f, -0.15207991f, 0.08601314f, 
    -0.14241984f, -0.07508370f, 0.01022236f, 0.10725404f, 0.07809339f, 0.04182024f, -0.01135727f, -0.02524885f, 
    0.17571235f, -0.00900183f, 0.05518070f, 0.12020936f, -0.08217736f, 0.16245291f, -0.03390673f, 0.13618717f, 
    0.10023668f, -0.06847524f, 0.02882552f, 0.14211491f, -0.12297533f, 0.05938869f, -0.10853232f, 0.08516091f, 
    0.09797734f, -0.20054549f, 0.08486091f, 0.08069179f, -0.02008674f, -0.05149133f, -0.11956137f, 0.00468120f, 
    0.01474199f, 0.29025418f, 0.01772463f, -0.02066853f, 0.07853512f, 0.05375753f, -0.08182947f, -0.03856658f, 
    0.00882498f, 0.05418517f, -0.09704465f, 0.13196434f, 0.16029964f, 0.11155936f, -0.20967400f, -0.01811530f, 
    0.10707629f, 0.12616213f, 0.14363708f, 0.00800319f, 0.08351588f, 0.11162086f, -0.07113826f, 0.07078348f, 
    0.01841333f, 0.08566511f, -0.01537811f, -0.13488062f, 0.10486104f, 0.05323080f, 0.09351000f, -0.02002330f, 
    -0.00575091f, 0.05007309f, -0.07555809f, -0.04165078f, -0.02755060f, 0.12320521f, -0.02718418f, 0.19059138f, 
    -0.09270202f, -0.04615131f, -0.08611078f, -0.00886113f, -0.13269354f, 0.00697247f, -0.12044001f, -0.00917704f, 
    -0.03065157f, 0.19903381f, 0.04894226f, -0.12157206f, 0.00787374f, 0.06650973f, -0.08045746f, 0.05133954f, 
    0.00498714f, 0.07116918f, 0.16459046f, -0.01147575f, -0.03337073f, -0.12120141f, 0.19937629f, 0.08207739f, 
    0.08825783f, 0.03432291f, 0.07035774f, 0.00987862f, -0.06900839f, 0.03606559f, -0.03479759f, -0.12498830f, 
    -0.21441814f, -0.09071051f, 0.14273190f, 0.11323843f, 0.16255690f, 0.06245150f, -0.03581421f, 0.05346369f, 
    -0.03019882f, 0.04008219f, 0.06932364f, -0.00273876f, 0.11014210f, -0.02061534f, 0.03991083f, 0.02622299f, 
    0.06501243f, 0.07977948f, 0.04559452f, 0.10782031f, 0.02949053f, 0.12183313f, -0.04447534f, 0.10488450f, 
    0.09452841f, 0.14493191f, -0.09444957f, 0.17433703f, -0.02879130f, -0.09622869f, -0.03865455f, 0.00378894f, 
    0.01597546f, -0.16468374f, 0.05328824f, -0.02863269f, -0.03777192f, -0.25206244f, -0.10869902f, -0.15490843f, 
    0.09529570f, 0.00691792f, -0.00447108f, 0.00225021f, 0.05108894f, -0.00422015f, 0.01254545f, 0.10245407f, 
    0.18150616f, 0.21775213f, -0.04066594f, -0.03422922f, -0.10286414f, -0.01599882f, 0.03430065f, 0.08365343f, 
    -0.07938487f, 0.16478853f, -0.01116861f, -0.07593209f, 0.48788932f, 0.17108674f, -0.21069974f, 0.04737210f, 
    -0.02979127f, 0.07552057f, 0.07385001f, 0.07048051f, 0.07948057f, -0.12677301f, -0.10799658f, -0.09143648f, 
    0.18062720f, -0.05474083f, -0.19112605f, -0.14274815f, -0.02101193f, 0.09558373f, -0.01411043f, -0.03420950f, 
    -0.00709521f, 0.12977558f, 0.01010454f, -0.02470518f, 0.01722765f, -0.07915213f, 0.19339500f, 0.07154715f, 
    0.07238381f, 0.02393824f, 0.15311615f, -0.01447792f, 0.03292410f, 0.03256766f, -0.02340982f, 0.01556428f, 
    -0.03418868f, -0.03991412f, -0.05233542f, 0.01355183f, 0.00012942f, 0.02090660f, 0.01147739f, 0.03602877f, 
    -0.04198804f, 0.00178746f, -0.01446554f, -0.01792059f, -0.02915151f, -0.03791556f, -0.02800230f, 0.05153394f, 
    -0.03477526f, 0.01797901f, -0.03044195f, 0.03345153f, 0.00587205f, 0.00376513f, -0.01054693f, -0.04909178f, 
    -0.03565419f, 0.01110660f, -0.02536238f, -0.00796183f, -0.04695316f, -0.01013249f, 0.01791949f, -0.00745815f, 
    0.02230163f, 0.01263957f, -0.02118292f, -0.04164871f, -0.02061977f, -0.00053229f, 0.03552791f, -0.04889147f, 
    0.03860991f, 0.00391784f, -0.04220587f, -0.01757642f, 0.01688330f, 0.03589137f, -0.02251813f, -0.03940723f, 
    -0.05063067f, 0.03853991f, 0.03766667f, 0.03313348f, -0.04165726f, -0.03082320f, 0.01071402f, 0.01758351f, 
    0.03011487f, -0.02511983f, 0.00688814f, -0.01637177f, -0.00119185f, -0.04467379f, -0.02060129f, 0.03014482f, 
    -0.00785509f, -0.05468653f, -0.03165963f, 0.00629944f, 0.03969291f, -0.00080057f, -0.04612283f, 0.00649846f, 
    0.00970777f, -0.00300745f, -0.01076666f, -0.05161639f, -0.01898222f, 0.03376296f, 0.03022680f, 0.02079819f, 
    -0.03471851f, -0.00063048f, -0.01429572f, -0.04002091f, -0.05176491f, -0.04868129f, -0.02658490f, 0.01978486f, 
    -0.00644737f, -0.02715194f, 0.04041628f, 0.03667893f, -0.02524543f, -0.04979509f, 0.00694525f, 0.02867395f, 
    -0.05437098f, -0.05633242f, 0.03360137f, -0.01112796f, -0.02626459f, -0.01565716f, -0.05498787f, -0.04110680f, 
    0.02760515f, 0.01585747f, -0.01458531f, 0.01767042f, -0.01491271f, -0.00568852f, 0.00502380f, -0.04227545f, 
    -0.00888480f, 0.03840664f, -0.04127708f, -0.01355602f, -0.00688844f, -0.04761622f, 0.04863742f, -0.03155262f, 
    0.02490714f, -0.02652169f, 0.04264507f, -0.02032098f, -0.04159601f, 0.04089783f, -0.05130659f, 0.02956093f, 
    0.02340966f, -0.04016760f, 0.01194181f, 0.03566449f, -0.04682473f, -0.02528888f, 0.04130846f, -0.02969150f, 
    -0.02283475f, 0.03058607f, -0.03561913f, -0.01117536f, 0.04336087f, -0.01120287f, -0.02151349f, 0.03506320f, 
    0.01079288f, -0.04152075f, 0.04729201f, 0.03351066f, 0.03711182f, -0.02635805f, 0.02132486f, -0.04417181f, 
    0.02417584f, 0.00878016f, -0.04154572f, -0.05185499f, -0.05293917f, -0.05186494f, -0.03317976f, -0.02656175f, 
    -0.03942993f, 0.00678120f, 0.03861882f, 0.03116552f, -0.05469190f, -0.01098716f, 0.04012046f, -0.04085909f, 
    0.00247252f, 0.04262899f, -0.01340435f, 0.01756805f, 0.01705305f, -0.01210667f, -0.02990315f, -0.04747072f, 
    0.00265994f, -0.00459141f, -0.03837351f, -0.03410856f, -0.02639863f, -0.01319290f, -0.03459653f, 0.04756368f, 
    -0.01185956f, 0.00297410f, -0.02321228f, -0.05089148f, -0.01662362f, 0.00682913f, 0.02812994f, 0.01298851f, 
    0.04631764f, -0.04033888f, 0.00657189f, -0.05340067f, -0.01503786f, 0.04190010f, -0.00400485f, 0.00676279f, 
    0.00103873f, 0.03444745f, -0.01309704f, -0.01201481f, -0.04529858f, 0.03195075f, 0.01135272f, -0.03088558f, 
    0.01041642f, 0.04920235f, 0.04490741f, -0.03460525f, -0.01954075f, -0.03748317f, 0.03383096f, -0.02337273f, 
    -0.03885625f, -0.01866376f, -0.05431208f, -0.04569038f, -0.01324065f, -0.04254413f, -0.01984436f, 0.03415272f, 
    -0.00738557f, 0.01218059f, 0.03953126f, -0.03958222f, 0.02484000f, 0.00885781f, 0.01220404f, 0.01835818f, 
    -0.04803824f, 0.04178763f, -0.05554489f, -0.04385991f, 0.01368416f, -0.03794824f, -0.05141345f, -0.01012035f, 
    0.00323783f, 0.03798212f, -0.04348469f, -0.00910915f, 0.03692628f, 0.03574705f, -0.04537242f, -0.05095087f, 
    0.01492334f, -0.02935958f, -0.05504309f, 0.04340462f, 0.03986289f, -0.03237787f, -0.03255156f, -0.02936065f, 
    -0.02200596f, 0.02149329f, 0.01932743f, -0.04754239f, -0.04432898f, -0.00637053f, -0.03779698f, 0.02701187f, 
    -0.01927045f, 0.00546555f, 0.02374167f, -0.04317850f, 0.00052121f, -0.02986649f, 0.01548422f, -0.04366785f, 
    -0.03578468f, 0.04535978f, -0.00420288f, 0.00333331f, -0.01982258f, 0.00566194f, 0.02891641f, -0.03062270f, 
    -0.01414056f, 0.02070123f, 0.04028146f, 0.04265139f, 0.02532006f, 0.04068387f, 0.00430992f, -0.04095589f, 
    0.01909187f, -0.01917894f, 0.01344574f, 0.01550354f, -0.04877900f, -0.00700642f, 0.02647578f, 0.02659351f, 
    -0.03407168f, -0.00163211f, -0.01428010f, 0.04446796f, -0.05011719f, 0.01449109f, -0.02379810f, 0.01270330f, 
    0.02403099f, -0.01618257f, 0.01868291f, 0.04123947f, 0.03784097f, -0.02166242f, 0.01618999f, -0.03126128f, 
    0.01214598f, 0.03009549f, 0.01164580f, 0.03921002f, -0.04879077f, -0.04668856f, -0.05382062f, 0.01548174f, 
    -0.01598051f, 0.02567048f, -0.03940174f, 0.03547392f, 0.01801888f, -0.04353748f, 0.00008374f, -0.02158172f, 
    0.00380996f, 0.01953350f, 0.01138900f, -0.01344974f, -0.01397143f, -0.04410267f, -0.03522194f, -0.04248210f, 
    0.03034630f, 0.03332025f, 0.01740865f, 0.01136286f, 0.00400706f, 0.00579674f, -0.05282192f, -0.02216363f, 
    -0.03561646f, 0.00155094f, -0.02548778f, -0.00017054f, -0.03682827f, -0.01266380f, 0.02089556f, 0.04470656f, 
    -0.02328552f, 0.01457466f, -0.02080506f, -0.02857352f, 0.00104909f, 0.00464586f, -0.03083411f, 0.03266510f, 
    -0.01596732f, 0.03589039f, -0.04936697f, -0.04963548f, 0.00252760f, -0.05213983f, -0.00181593f, -0.01681610f, 
    -0.00242326f, 0.04379673f, 0.04592650f, 0.00169567f, -0.02730837f, 0.03760011f, -0.02609848f, -0.00711026f, 
    0.02084600f, -0.00751594f, 0.01643178f, 0.01447770f, -0.04123561f, -0.01698260f, 0.02661865f, -0.00621829f, 
    -0.02989607f, -0.03198196f, -0.01248173f, -0.00696186f, 0.01060823f, -0.01489821f, 0.01879968f, 0.01047532f, 
    0.04008586f, -0.00649994f, -0.00839191f, -0.04959610f, -0.01358034f, 0.00266364f, 0.01374912f, -0.00954962f, 
    -0.06252858f, 0.04091601f, -0.04282521f, -0.02908633f, -0.05505101f, -0.05273625f, -0.04643025f, -0.01086333f, 
    0.02319827f, 0.04199167f, -0.04158049f, 0.03461922f, -0.01046587f, -0.04628562f, -0.04876204f, -0.00051063f, 
    -0.04894957f, -0.01749791f, 0.04059985f, 0.01930763f, -0.04449761f, 0.02853981f, 0.02346453f, -0.01420547f, 
    -0.02135637f, -0.01408613f, 0.03649399f, 0.01874657f, 0.02733112f, 0.02729478f, -0.03490679f, 0.00367948f, 
    -0.01755890f, -0.00204843f, 0.03397316f, 0.03917494f, -0.05585926f, -0.01000345f, -0.00236756f, -0.00931100f, 
    0.00385712f, -0.02441149f, -0.05715596f, 0.01149090f, -0.01111464f, 0.03189048f, -0.01458211f, -0.02602951f, 
    0.00173431f, 0.04132085f, 0.04011763f, -0.03357571f, -0.05282795f, -0.01115821f, 0.03191082f, -0.01938588f, 
    0.02199375f, 0.03038424f, -0.01558719f, 0.01614414f, -0.04895275f, -0.04759079f, -0.00559309f, -0.02067221f, 
    -0.01460860f, 0.00236104f, -0.02362573f, -0.00005539f, -0.03208732f, -0.04377650f, -0.02693518f, -0.01601250f, 
    0.02222821f, -0.00071853f, 0.01212977f, -0.05338714f, -0.02688770f, -0.01791040f, -0.03460201f, -0.05043061f, 
    -0.03199746f, -0.04314180f, -0.05302609f, 0.00405849f, 0.01600642f, 0.03071902f, -0.03250917f, 0.03138773f, 
    0.03081335f, 0.03224451f, -0.05227447f, -0.02174986f, 0.00160975f, -0.03854479f, 0.03563065f, -0.04286505f, 
    0.01564117f, 0.00418867f, -0.00164859f, 0.01263941f, -0.05067835f, -0.01164594f, -0.02736530f, 0.03981817f, 
    -0.02728129f, 0.01259955f, -0.01915210f, 0.03433415f, 0.01506724f, -0.00402147f, -0.03447978f, 0.03179709f, 
    -0.05237726f, -0.00857553f, -0.05852631f, -0.03761040f, -0.05379886f, 0.01013303f, 0.01811517f, -0.04726767f, 
    0.04401897f, 0.02161599f, -0.05284005f, -0.04730768f, 0.02098696f, -0.00343700f, -0.05860071f, 0.00048633f, 
    0.03136660f, -0.04073029f, 0.02849195f, 0.04712090f, 0.02253619f, 0.02743336f, 0.02076066f, -0.01139244f, 
    -0.01233172f, -0.00122563f, -0.03778859f, -0.02940534f, -0.05424117f, -0.00748561f, -0.00850532f, -0.03557840f, 
    -0.05948748f, 0.02197584f, 0.03221396f, -0.02840358f, -0.02091066f, 0.02197888f, 0.04021773f, -0.00521747f, 
    0.03187070f, -0.05044448f, 0.03987762f, 0.02856162f, -0.00200408f, -0.04409365f, -0.02726339f, -0.02270233f, 
    0.03702495f, -0.02306125f, 0.03076126f, -0.03876097f, 0.02787581f, -0.03615656f, -0.04081960f, 0.00612540f, 
    -0.01200820f, 0.03413361f, -0.00502640f, -0.04054486f, 0.03700789f, 0.01268118f, 0.01256315f, -0.05858611f, 
    0.02095768f, 0.01024434f, 0.01714003f, -0.02874795f, -0.02195300f, 0.04561770f, 0.00991638f, 0.02508437f, 
    -0.00774723f, -0.04711840f, -0.00705047f, 0.01335060f, 0.04134002f, -0.01878441f, 0.01157702f, 0.02636019f, 
    -0.01320325f, 0.02027891f, -0.03851869f, -0.04687574f, -0.04362269f, 0.05008172f, -0.02955845f, -0.01774238f, 
    0.04049479f, 0.02237730f, -0.00592324f, -0.03826031f, -0.00719338f, 0.01420791f, -0.05518071f, -0.02417349f, 
    -0.03628295f, 0.03269455f, 0.03510310f, -0.00197952f, -0.00972753f, -0.00535866f, -0.02333709f, -0.02347264f, 
    -0.03751418f, 0.02716911f, -0.04026512f, 0.01846998f, -0.00952875f, -0.02146131f, -0.02015323f, -0.02335732f, 
    -0.02821250f, -0.00214589f, -0.02291144f, -0.03641386f, 0.03914825f, -0.01420185f, -0.03100229f, -0.00189716f, 
    0.04062321f, 0.01809519f, 0.01008602f, 0.00517220f, -0.05689701f, -0.00880473f, -0.03689728f, 0.03699911f, 
    0.02467524f, 0.00637007f, -0.01711441f, -0.02467002f, 0.03577867f, -0.01099753f, 0.03370005f, 0.00737328f, 
    -0.04414260f, -0.04892883f, -0.01199035f, 0.03709753f, 0.02064943f, -0.02774180f, -0.03148530f, -0.00683770f, 
    -0.04028956f, 0.03493619f, -0.02977819f, 0.00262582f, 0.03846143f, 0.03678294f, 0.01505577f, -0.01065315f, 
    -0.01461698f, 0.03679204f, 0.03463560f, -0.00842564f, 0.00193706f, -0.05226898f, -0.02226977f, 0.02983255f, 
    -0.03840993f, -0.04774060f, -0.01495200f, -0.00906172f, 0.01524880f, 0.04488026f, -0.01848603f, 0.03146818f, 
    -0.04418790f, 0.04264474f, -0.00439584f, 0.03425661f, -0.04495319f, 0.01505865f, -0.02260529f, -0.03987814f, 
    -0.04961020f, -0.04249486f, -0.01484490f, -0.03854620f, 0.01410280f, 0.02356709f, 0.02752825f, -0.04915166f, 
    0.03392416f, 0.01415380f, -0.04087721f, -0.06022799f, -0.05277607f, -0.00614634f, -0.00382849f, 0.04351726f, 
    -0.03711448f, -0.02880973f, -0.03724064f, -0.00694441f, -0.01751899f, -0.00823897f, -0.04399434f, -0.02154154f, 
    -0.04938792f, 0.02265388f, 0.02381701f, -0.00427643f, -0.03475379f, -0.02728490f, -0.05035685f, 0.01394839f, 
    0.01254057f, -0.00515591f, 0.01996657f, 0.03034793f, -0.04357903f, -0.00576559f, 0.01659209f, 0.01698594f, 
    -0.00024833f, -0.04216748f, -0.04935069f, -0.05300509f, -0.02569518f, -0.03264968f, -0.02288722f, -0.02904260f, 
    0.02880825f, -0.01126139f, -0.04379486f, -0.01755936f, 0.04340935f, -0.00467124f, 0.03878423f, 0.02975792f, 
    -0.02959431f, 0.02988697f, -0.02480734f, -0.02997236f, 0.00385088f, 0.00232581f, 0.03007482f, 0.03924715f, 
    -0.05937697f, -0.04320896f, -0.02634200f, 0.04168522f, 0.02362220f, -0.03169627f, -0.01436751f, 0.01255750f, 
    0.04196412f, -0.03697084f, 0.04524220f, -0.01755986f, -0.04594351f, 0.02110383f, 0.00418341f, -0.04983427f, 
    0.00083162f, -0.11804611f, -0.09166599f, -0.18069708f, -0.07702896f, -0.03788949f, -0.08711128f, -0.01540883f, 
    0.09623103f, -0.11149591f, -0.03623335f, -0.10419797f, 0.29929715f, 0.09519733f, 0.00149993f, 0.20289016f, 
    -0.05810275f, 0.06151113f, 0.03251142f, 0.06775472f, 0.03299853f, -0.01673840f, 0.05335454f, 0.04804040f, 
    -0.23118751f, -0.02874236f, -0.13444601f, -0.06065276f, -0.09731667f, 0.05926608f, -0.04441164f, 0.09264582f, 
    0.07322335f, 0.01301917f, -0.01231420f, 0.03117515f, 0.24838004f, -0.20969343f, 0.08901638f, 0.06828898f, 
    0.11628004f, 0.02866141f, -0.00711363f, -0.05138157f, -0.07667679f, 0.05441805f, 0.10686887f, 0.06384571f, 
    -0.25431624f, -0.16783065f, 0.05921596f, -0.03374151f, -0.09211731f, -0.05712855f, 0.00387922f, 0.17273454f, 
    0.13412042f, -0.03249891f, 0.03359671f, 0.01822918f, 0.06555757f, 0.14057888f, 0.07055416f, -0.10650219f, 
    -0.05154197f, -0.13106915f, 0.08525348f, -0.05103174f, 0.09959247f, 0.05804300f, 0.09976469f, -0.01375418f, 
    0.14534044f, -0.24782313f, 0.00599987f, 0.33667639f, 0.06029007f, -0.06313937f, 0.01232638f, -0.02296028f, 
    0.12261645f, 0.12714155f, -0.00069317f, -0.02939783f, -0.12256862f, -0.31291935f, -0.06906038f, 0.18615966f, 
    0.10713207f, -0.00535398f, -0.14451632f, -0.10263302f, -0.03532758f, -0.13135640f, 0.09830434f, -0.09944122f, 
    0.23273043f, -0.14603813f, 0.01534876f, 0.06161391f, 0.15770012f, 0.00964476f, 0.02863313f, 0.00910290f, 
    0.06695127f, 0.06667424f, -0.03971661f, 0.11463793f, 0.00255945f, -0.08702248f, 0.03848850f, -0.02508419f, 
    -0.00917479f, -0.02656568f, -0.01662283f, 0.01273907f, 0.08095437f, 0.02689249f, -0.04882135f, 0.15614119f, 
    0.23136167f, 0.12021005f, 0.08063094f, -0.32127810f, 0.02178690f, -0.00211328f, 0.06075510f, 0.02185624f, 
    -0.02740325f, 0.13588990f, 0.07812523f, 0.01565899f, -0.00311710f, -0.27705827f, -0.02088555f, 0.20454508f, 
    -0.11223719f, -0.00446017f, 0.02297170f, 0.08261132f, 0.16001046f, 0.15685581f, 0.07074312f, 0.02565562f, 
    0.12329855f, -0.07732964f, 0.03451878f, -0.03896008f, 0.02675124f, -0.04506142f, -0.00406253f, -0.02865973f, 
    0.02145448f, -0.03135971f, -0.02125975f, -0.05621016f, 0.15791400f, 0.08874512f, -0.24529135f, -0.17702782f, 
    0.07059342f, -0.08441634f, -0.03370998f, 0.08756045f, -0.03527730f, 0.05904762f, 0.00491713f, 0.11748367f, 
    -0.21010035f, 0.00729463f, 0.09221404f, -0.15887299f, -0.05918974f, 0.09520659f, -0.03210410f, -0.02189657f, 
    0.04875274f, 0.07656544f, 0.06030081f, -0.00308614f, 0.31783381f, 0.10118988f, -0.03169990f, 0.06580692f, 
    -0.01646478f, 0.02376491f, -0.03247068f, 0.01494036f, 0.03067956f, 0.13120347f, -0.11937886f, -0.03940096f, 
    0.01397493f, -0.01596335f, -0.03745833f, 0.00199273f, 0.05672834f, 0.01969149f, -0.02168455f, -0.03178089f, 
    -0.00550912f, -0.01901881f, 0.00615956f, 0.13233645f, 0.08663009f, 0.06734017f, 0.09084607f, -0.01419592f, 
    0.08010667f, -0.13596803f, 0.03266520f, 0.08835520f, -0.08820692f, 0.09107735f, -0.02034554f, -0.05748277f, 
    0.02087294f, 0.12284380f, 0.11873547f, 0.08461615f, 0.03475314f, 0.03262576f, 0.07661998f, -0.13735591f, 
    -0.01475371f, -0.02528812f, 0.04700493f, 0.00024898f, 0.04878069f, -0.03941563f, -0.16227190f, -0.04192635f, 
    0.17202710f, 0.19181599f, 0.00488689f, 0.05049237f, 0.07176058f, 0.01995759f, -0.10218944f, -0.09813553f, 
    0.35223973f, -0.10613254f, 0.07510661f, 0.02959949f, 0.04684660f, 0.00332645f, -0.11913295f, 0.16233800f, 
    -0.02176191f, -0.00730646f, -0.12408582f, -0.06942318f, -0.08543950f, -0.08910147f, -0.17368899f, 0.01646676f, 
    0.02545834f, -0.08676419f, -0.02340035f, -0.05669923f, -0.08725598f, -0.07673474f, -0.10519903f, -0.04744289f, 
    -0.04464454f, -0.03866872f, 0.06306293f, 0.19559291f, 0.01063427f, 0.06453148f, -0.00445933f, 0.00196000f, 
    0.01591529f, -0.02566331f, 0.02464605f, -0.00733973f, 0.09223646f, -0.05608419f, 0.11232682f, -0.16433249f, 
    -0.01383026f, 0.13550837f, -0.03087274f, -0.07094740f, 0.01213091f, -0.03133737f, 0.00476753f, -0.01388199f, 
    -0.05050453f, -0.05400302f, -0.04609941f, 0.10795493f, 0.03759243f, 0.03697403f, -0.03844284f, 0.14959425f, 
    -0.10035513f, 0.04273827f, 0.07068716f, 0.16674794f, 0.05274521f, -0.00096829f, 0.11097217f, 0.01584631f, 
    0.05048708f, -0.01830044f, -0.01292216f, 0.10094004f, 0.08963785f, 0.16593608f, -0.09849526f, -0.10006148f, 
    -0.03646960f, 0.22543384f, -0.16081008f, -0.13983136f, -0.04287343f, -0.05711582f, 0.01008842f, -0.14504164f, 
    0.00513372f, -0.11156770f, 0.02767597f, 0.03693568f, 0.35297781f, -0.38871542f, 0.06425368f, 0.28465265f, 
    0.03597544f, 0.00961589f, 0.01327784f, -0.07955223f, -0.01729507f, 0.03600976f, 0.12604095f, 0.09262878f, 
    0.02333211f, 0.09086797f, -0.01511105f, -0.06400493f, -0.09349278f, -0.14648154f, 0.07845056f, 0.08101147f, 
    0.04591689f, 0.15949628f, -0.17617890f, -0.05088321f, 0.34413290f, 0.05464724f, 0.09227694f, 0.07760222f, 
    -0.03535681f, 0.02888656f, 0.03068860f, 0.06890911f, -0.03039260f, -0.11877000f, 0.02039987f, -0.10326982f, 
    0.21510015f, 0.03207377f, -0.03416910f, -0.10737775f, -0.04251282f, 0.06108734f, -0.02868602f, 0.00453247f, 
    0.02452983f, 0.07787892f, -0.01277048f, -0.02154367f, 0.25079134f, -0.05218107f, -0.00345240f, -0.05650114f, 
    0.12289214f, -0.11442921f, 0.05685944f, 0.03197581f, 0.11075091f, 0.03859230f, 0.02918713f, -0.00497511f, 
    0.01482280f, -0.01674040f, 0.01134237f, 0.30549663f, 0.13418828f, 0.10212231f, 0.11326975f, 0.05634176f, 
    0.00361318f, 0.11402384f, 0.09788727f, 0.19490093f, -0.42362773f, 0.06043667f, -0.05167922f, -0.15717377f, 
    0.12501739f, -0.04069136f, 0.02257897f, 0.09475795f, -0.05106417f, -0.05994509f, -0.00771986f, -0.04018144f, 
    0.07168480f, 0.09019095f, 0.04705078f, 0.00137292f, 0.02762341f, -0.00953138f, -0.07105741f, -0.01659057f, 
    -0.11225443f, -0.04444044f, -0.08945723f, 0.03172626f, -0.14606196f, 0.18122937f, 0.13546348f, 0.05477637f, 
    0.01742901f, 0.04225868f, -0.00840857f, 0.00276056f, 0.01530271f, -0.01216384f, -0.07341721f, 0.08744077f, 
    0.11249694f, 0.17352913f, -0.15789303f, 0.04698434f, 0.10118311f, 0.13465361f, -0.09870794f, -0.07907108f, 
    -0.04057580f, -0.02063729f, 0.05384646f, 0.02426613f, 0.06772532f, -0.12542991f, -0.19657482f, 0.21680033f, 
    0.03304007f, 0.19845243f, -0.10132315f, 0.10521497f, -0.02796650f, -0.09420576f, 0.03382925f, 0.09422829f, 
    -0.02137476f, 0.17701927f, -0.07613623f, -0.35788396f, 0.05662571f, 0.10682257f, 0.03557712f, 0.10881577f, 
    0.08333757f, -0.06718353f, 0.04915695f, 0.13226452f, 0.04933940f, 0.19529158f, 0.08992856f, -0.21866030f, 
    -0.03093880f, 0.07420238f, 0.05434806f, 0.09440628f, 0.02543349f, 0.21769124f, -0.08671893f, 0.02176393f, 
    -0.03214108f, 0.06214167f, 0.14963201f, 0.18110861f, -0.07303350f, -0.03522607f, 0.01308537f, -0.01584579f, 
    -0.04446276f, -0.03033119f, 0.02052620f, -0.07795152f, 0.21280080f, 0.08956353f, -0.01751269f, 0.11213475f, 
    0.05606968f, 0.05648145f, -0.07131676f, 0.04411830f, -0.04700894f, -0.06986726f, 0.01544039f, -0.06341707f, 
    -0.08595483f, -0.10732511f, 0.07170995f, 0.35789064f, 0.03504262f, -0.05085267f, 0.04381876f, -0.00482833f, 
    0.01011977f, -0.00488416f, -0.11439522f, -0.03056018f, -0.18800317f, 0.19517210f, -0.01975206f, -0.30288965f, 
    0.16246319f, -0.05827260f, 0.02229871f, -0.11245472f, -0.03586337f, -0.00462017f, -0.01191987f, 0.06912421f, 
    -0.21882398f, -0.12091376f, -0.11614484f, 0.01489383f, 0.09046837f, 0.00831221f, 0.03602832f, -0.06166389f, 
    0.00927515f, 0.02890470f, -0.01235828f, -0.05494294f, 0.14244109f, 0.07147323f, 0.15510967f, -0.04265432f, 
    -0.10043960f, 0.14389375f, 0.08615325f, -0.03278301f, 0.00988740f, -0.03027072f, -0.04719561f, -0.08266041f, 
    0.31859928f, 0.14676331f, -0.16566788f, 0.32230148f, 0.11250075f, -0.04347193f, 0.02367395f, 0.00493900f, 
    -0.05203027f, -0.08092088f, 0.00543087f, 0.08327485f, -0.26226553f, -0.00564431f, -0.12613846f, -0.00414961f, 
    0.02967802f, 0.03124664f, 0.11777476f, 0.08301004f, -0.03455866f, -0.04118439f, 0.19725762f, -0.02198454f, 
    0.13866872f, -0.03400369f, 0.05057360f, -0.01447057f, -0.03996094f, 0.06733534f, 0.11484118f, 0.25061682f, 
    -0.00335481f, -0.02239607f, 0.13933527f, -0.03809870f, -0.37334239f, -0.07466539f, -0.03141657f, 0.12450653f, 
    0.02492338f, 0.09293935f, 0.02476811f, -0.03649334f, 0.05843451f, -0.07955614f, 0.01645413f, 0.04919053f, 
    -0.03083960f, 0.00784765f, -0.09001376f, -0.14052133f, -0.04860172f, 0.12801036f, -0.05284170f, 0.09068272f, 
    0.01886721f, 0.06684612f, -0.03160857f, 0.13600710f, -0.00583108f, -0.00220362f, 0.11596384f, 0.04983013f, 
    -0.18854429f, -0.08355808f, 0.08865496f, -0.11973918f, 0.03843753f, -0.00776067f, 0.05018388f, 0.25093374f, 
    -0.36594638f, 0.15980920f, -0.00992497f, -0.19326545f, 0.07821585f, 0.06813402f, 0.18830281f, -0.12901926f, 
    -0.00797555f, 0.02303299f, 0.07736949f, 0.08315144f, 0.04407839f, 0.14890632f, 0.03434195f, -0.10902439f, 
    -0.01665841f, 0.12656012f, -0.02819320f, -0.06148785f, 0.02937687f, 0.18748610f, 0.15841663f, 0.09021923f, 
    0.11555288f, 0.05393303f, 0.00491591f, -0.22608870f, 0.02196520f, 0.06259163f, 0.10907070f, -0.00128483f, 
    0.05878580f, 0.10845432f, 0.02828101f, -0.00390087f, -0.23625880f, -0.02269314f, -0.00698321f, 0.31605598f, 
    0.02550356f, -0.18505935f, 0.10319770f, 0.04628390f, 0.04897714f, 0.01363145f, 0.03054908f, 0.02128655f, 
    -0.09231588f, 0.04580328f, -0.05031436f, 0.02350461f, 0.19739228f, 0.02362019f, 0.09604213f, -0.08289741f, 
    0.06775745f, -0.00006015f, 0.00154914f, -0.10604236f, -0.12067976f, 0.12381236f, -0.16297966f, 0.02059363f, 
    0.04570045f, 0.04946427f, -0.02109982f, -0.04710928f, -0.11814680f, -0.07564972f, 0.13041623f, 0.13531393f, 
    -0.13721515f, -0.02996583f, 0.04553685f, 0.24786215f, 0.06550368f, 0.06491835f, 0.03826531f, 0.11836528f, 
    0.03608438f, 0.14278995f, 0.06035448f, -0.05729091f, -0.11309343f, 0.30340391f, -0.03567778f, -0.30043909f, 
    0.06703009f, -0.03746395f, 0.04000635f, 0.07857195f, -0.01162487f, 0.05591744f, -0.03799153f, -0.03138008f, 
    0.11735092f, 0.00056020f, 0.04276719f, 0.18120266f, 0.03169048f, 0.09392677f, -0.10782196f, -0.00285854f, 
    0.05638827f, 0.05612009f, 0.07540641f, -0.00049564f, -0.30312875f, -0.07747735f, -0.12420136f, -0.02046080f, 
    0.12102243f, -0.07786605f, 0.09717739f, -0.01170943f, 0.04735117f, 0.06119407f, 0.05838032f, 0.04578539f, 
    -0.03898591f, -0.03484715f, 0.11831061f, 0.28476879f, 0.06578901f, 0.05031319f, 0.01764548f, 0.03438562f, 
    -0.04986885f, 0.02614016f, 0.06173166f, 0.05158417f, -0.01120996f, 0.20823379f, -0.04744342f, 0.04891595f, 
    -0.07031121f, 0.09810136f, 0.07626481f, -0.07613330f, -0.02701784f, -0.04405270f, 0.06150438f, -0.09782523f, 
    -0.32828459f, -0.24960358f, 0.09824203f, -0.01657849f, 0.00656582f, -0.06671255f, -0.17982131f, -0.05425749f, 
    0.02882206f, -0.02924483f, -0.00480355f, 0.02955739f, 0.31679007f, -0.18487561f, -0.04960700f, 0.01348628f, 
    0.02409681f, 0.12370908f, -0.00203725f, -0.01468916f, 0.03100046f, 0.00637479f, 0.11793556f, -0.03372527f, 
    -0.39631024f, -0.22711715f, -0.05407926f, -0.01858728f, -0.08255208f, -0.09244721f, 0.08539209f, -0.10364258f, 
    -0.00574185f, -0.07212967f, 0.08018100f, 0.10300285f, 0.15344726f, 0.01158925f, -0.14660048f, -0.02974523f, 
    0.02334583f, 0.01346441f, 0.00620039f, -0.01518296f, 0.00571156f, 0.13203768f, 0.16618650f, 0.04929180f, 
    -0.27312425f, -0.20234139f, -0.04824559f, -0.00459722f, -0.00864749f, -0.02886720f, -0.04140132f, -0.03738938f, 
    0.02239179f, 0.03507658f, 0.02790147f, -0.08614594f, -0.26147267f, 0.04618935f, -0.02699356f, -0.04831038f, 
    0.07292878f, 0.01613589f, 0.04215629f, -0.04177971f, 0.03472983f, 0.09620793f, 0.09781228f, 0.02751654f, 
    -0.06820622f, 0.14721160f, 0.13229750f, -0.09421467f, 0.04879912f, -0.07337227f, -0.09168417f, -0.08275370f, 
    0.00370797f, -0.01500506f, -0.04292035f, 0.02155394f, 0.01434527f, -0.03592074f, 0.06034666f, -0.01629318f, 
    0.09421731f, 0.00890272f, -0.02640713f, -0.09956018f, -0.05002881f, -0.02105778f, -0.01253403f, -0.11438376f, 
    0.13471058f, 0.05562111f, -0.22528166f, -0.01728288f, 0.18278985f, 0.17283799f, 0.09724440f, -0.08887565f, 
    -0.01256071f, 0.05823017f, -0.00280756f, 0.21971011f, 0.16616616f, 0.10083006f, 0.08590176f, -0.00669632f, 
    0.08206410f, 0.05801376f, 0.09846943f, -0.02251628f, -0.00503260f, 0.03907685f, -0.01237031f, 0.04881633f, 
    0.03633642f, 0.12697840f, -0.05548180f, 0.03589299f, 0.05428208f, -0.04363878f, 0.00332376f, 0.12216163f, 
    0.11038759f, 0.10917109f, 0.05912873f, 0.07382587f, -0.17076567f, -0.04737649f, 0.15623677f, -0.00614432f, 
    0.08493271f, -0.00400052f, 0.02222214f, 0.07175455f, 0.14502615f, 0.04517045f, -0.00981214f, 0.05942035f, 
    -0.02094398f, 0.17101635f, -0.00434982f, -0.05863724f, -0.03826583f, -0.04940274f, -0.00898670f, 0.02437612f, 
    0.20246877f, 0.02404817f, 0.02893252f, 0.01989841f, 0.42601135f, 0.21596859f, 0.07922645f, -0.00878136f, 
    0.10067622f, 0.00967157f, 0.06849951f, -0.02088382f, 0.06512702f, 0.05124624f, 0.05092130f, 0.02271622f, 
    -0.05391133f, 0.05294171f, -0.03637849f, 0.14643189f, 0.07327606f, -0.02095558f, 0.01131588f, -0.03117628f, 
    0.05684964f, 0.04420181f, 0.02840927f, 0.06644745f, 0.21508853f, -0.26508436f, -0.08081527f, -0.07229403f, 
    0.07851078f, 0.09499860f, -0.05410763f, -0.00004498f, 0.16886047f, 0.12515113f, 0.08420590f, -0.01319963f, 
    0.00973646f, -0.07453734f, -0.08790399f, 0.16694134f, -0.10451869f, 0.08790079f, 0.01429807f, 0.00140835f, 
    0.02282749f, -0.06966659f, 0.10308518f, -0.00633176f, -0.42904678f, -0.24310207f, -0.12727867f, -0.07768174f, 
    -0.00938866f, -0.06727599f, -0.03714982f, -0.13021520f, -0.01653252f, 0.10254478f, 0.02669699f, -0.03989839f, 
    0.33504716f, 0.00895013f, 0.09253506f, -0.00847586f, -0.03787653f, 0.07373194f, 0.01559624f, -0.12071457f, 
    -0.02893045f, 0.11242124f, 0.00195949f, -0.01556083f, -0.13570713f, -0.10474488f, -0.03652182f, -0.01002008f, 
    0.01161742f, 0.02943239f, 0.17674857f, 0.00515743f, 0.02761160f, 0.12100232f, -0.07036420f, -0.05966445f, 
    0.12603985f, 0.00689527f, 0.04858293f, -0.08894749f, -0.02393343f, -0.10892285f, -0.23357138f, 0.06261511f, 
    0.01310211f, -0.03616037f, -0.05986020f, -0.02681998f, 0.00717184f, -0.12875861f, 0.00282277f, 0.02351769f, 
    0.01997133f, -0.01771079f, -0.09655549f, -0.12835211f, -0.01877725f, -0.11018655f, 0.02434426f, -0.00226941f, 
    0.01600843f, 0.03314980f, 0.07216623f, -0.06116477f, 0.14379396f, 0.14112835f, -0.08431394f, -0.05856115f, 
    -0.02581367f, 0.05846177f, 0.02609300f, -0.09011222f, -0.04581358f, 0.01604680f, -0.08413523f, -0.13854270f, 
    -0.01538301f, -0.04027846f, 0.01467733f, 0.12826546f, 0.15249290f, 0.05619738f, -0.07421816f, -0.04939629f, 
    -0.21466203f, 0.11732090f, -0.14736126f, -0.30540460f, 0.11871612f, 0.00483161f, 0.03656260f, 0.04978576f, 
    0.03952035f, 0.06091415f, 0.02947522f, 0.14633030f, 0.03406990f, -0.09895385f, -0.11682656f, -0.15102610f, 
    0.12867771f, -0.06078600f, -0.05151860f, 0.04461311f, -0.03928318f, 0.14809421f, -0.15372077f, -0.09722549f, 
    -0.03408240f, -0.19323963f, -0.17809273f, 0.01217167f, 0.03491370f, -0.04993365f, 0.03357586f, -0.06408107f, 
    0.13500661f, -0.20142305f, -0.04932376f, 0.06064643f, -0.00232046f, 0.03448814f, 0.10468313f, -0.05749827f, 
    0.10175327f, 0.03203238f, 0.00614727f, -0.07180545f, 0.08741754f, -0.04551379f, 0.02462642f, 0.06704446f, 
    -0.22873437f, -0.00502992f, -0.14021860f, -0.09286162f, 0.00683103f, -0.14520775f, -0.10627075f, 0.01176906f, 
    0.06781728f, 0.06144458f, -0.12865148f, -0.01262713f, 0.09401739f, -0.01879236f, -0.03387730f, -0.00527350f, 
    -0.07698123f, 0.04954213f, 0.07693293f, -0.01186236f, 0.05891953f, -0.04300104f, -0.00276526f, 0.02784591f, 
    0.12272584f, -0.05855531f, 0.06713179f, 0.16714351f, -0.01777849f, 0.06449869f, 0.00493021f, 0.03536461f, 
    -0.02467973f, 0.07370559f, -0.01792851f, -0.00197117f, -0.03075656f, 0.21595928f, 0.04292497f, 0.06952478f, 
    0.11699493f, 0.03032934f, -0.01385544f, -0.00913050f, 0.00252409f, 0.04278292f, 0.00359851f, -0.02524254f, 
    0.01974784f, 0.02280255f, -0.02950164f, -0.00206450f, 0.04149575f, -0.02206143f, -0.04568344f, 0.03467183f, 
    -0.02713544f, 0.00939617f, -0.04924686f, -0.01831904f, 0.02903555f, 0.04105273f, 0.04358329f, -0.05309278f, 
    0.01194958f, -0.03531245f, 0.03012514f, 0.01087029f, -0.02075568f, -0.01220651f, -0.03073120f, 0.02737658f, 
    -0.03015675f, -0.01759209f, -0.05364450f, 0.01560563f, 0.01918987f, 0.01418300f, -0.01519792f, -0.01098776f, 
    0.03276363f, 0.00814125f, 0.04289583f, -0.02858985f, -0.03539316f, -0.01636702f, -0.03432934f, 0.00004171f, 
    0.03410793f, 0.01550603f, -0.00314976f, -0.03258707f, -0.02531997f, 0.03356716f, 0.00352907f, 0.01871329f, 
    -0.04027119f, -0.04379182f, 0.03120140f, -0.04197319f, -0.00657591f, 0.04265550f, -0.04542589f, -0.00236435f, 
    0.03812455f, 0.03647316f, 0.01418804f, -0.01713878f, 0.03694760f, -0.00039833f, -0.04683111f, -0.02777236f, 
    -0.02618219f, 0.02915666f, -0.03420500f, 0.04165257f, 0.03857644f, 0.04771616f, -0.01444504f, 0.02864385f, 
    -0.04233022f, -0.00589671f, 0.02632516f, -0.05460131f, -0.02163183f, -0.00799779f, 0.01413261f, -0.05105180f, 
    0.04299067f, -0.03760216f, -0.04417176f, 0.00016662f, -0.00934679f, 0.01258919f, -0.00458226f, 0.00329231f, 
    -0.03307953f, 0.04667770f, 0.01899074f, -0.03249280f, -0.01286191f, 0.03655581f, -0.03984810f, 0.00861888f, 
    0.03561426f, 0.03009538f, -0.00301411f, -0.04994360f, 0.02893957f, 0.02095324f, -0.00035535f, 0.02149729f, 
    0.03788761f, -0.00354312f, 0.02871356f, 0.00069389f, 0.03981850f, 0.04915272f, -0.01760437f, -0.05283303f, 
    -0.02918122f, -0.02214736f, -0.01078282f, 0.04379080f, 0.02743829f, -0.03935835f, -0.01994505f, -0.02891079f, 
    0.03018517f, 0.00219561f, -0.01253687f, 0.03678067f, -0.04202913f, 0.04368965f, -0.00232305f, -0.05463085f, 
    -0.02291511f, 0.01566219f, -0.01588296f, -0.03382600f, -0.03227085f, 0.02257090f, -0.05400494f, -0.01770933f, 
    -0.01848586f, 0.02662979f, -0.02191856f, -0.00960433f, 0.02460372f, 0.02277402f, -0.04763585f, 0.03776455f, 
    -0.03676143f, 0.00737402f, -0.04825461f, -0.02904147f, -0.00813202f, -0.05197359f, 0.00955757f, -0.04001827f, 
    -0.02316780f, 0.04545504f, -0.02739335f, -0.05042898f, -0.00681355f, -0.02541535f, -0.04018326f, -0.03728501f, 
    0.00960148f, 0.02825727f, -0.02693782f, 0.01486763f, 0.02106998f, 0.02607076f, -0.02396713f, -0.02556775f, 
    -0.00632822f, 0.02905944f, -0.04934496f, -0.05213558f, -0.00152012f, 0.00560660f, -0.02848415f, -0.01653707f, 
    -0.05526416f, 0.04132781f, 0.02822733f, -0.01770535f, 0.01522334f, -0.01265341f, 0.03098096f, 0.03666770f, 
    -0.02055882f, -0.04822472f, -0.03313973f, 0.03000106f, -0.03054233f, 0.01170190f, -0.03038740f, -0.01482530f, 
    -0.02288601f, 0.00805975f, 0.00398566f, 0.02906421f, 0.01686876f, 0.03040907f, -0.00072575f, -0.05011428f, 
    -0.00942936f, -0.04553493f, -0.01094060f, -0.01371429f, -0.04867647f, -0.05375037f, -0.03733520f, -0.01591995f, 
    -0.02742879f, 0.03811539f, 0.02307736f, 0.03325998f, -0.04812218f, 0.01097657f, -0.02622734f, -0.00886544f, 
    -0.00197705f, 0.03395582f, -0.04225273f, -0.04942236f, -0.03951345f, 0.02541877f, -0.00520032f, 0.03013889f, 
    -0.04979222f, -0.02926129f, -0.00098449f, -0.03935251f, 0.03840209f, 0.01395922f, 0.01017021f, 0.02636245f, 
    -0.00612543f, -0.01863482f, -0.04996902f, -0.00733821f, 0.01524117f, 0.02241068f, -0.02759560f, 0.01804072f, 
    0.02338392f, 0.02101202f, 0.00012422f, -0.04424301f, -0.03360514f, 0.02766814f, 0.04300004f, -0.05442308f, 
    -0.05033896f, -0.02379947f, 0.03138676f, -0.00433349f, -0.02484080f, 0.03818480f, 0.00544147f, -0.02155446f, 
    -0.04226959f, -0.03276876f, -0.05831037f, 0.01297134f, -0.03544182f, -0.01625771f, -0.01614873f, 0.01797445f, 
    -0.05061519f, 0.03838332f, -0.00188733f, -0.02297226f, 0.04830698f, 0.02777411f, 0.04171321f, 0.01221276f, 
    -0.02841144f, 0.03421446f, -0.02541294f, -0.00660135f, -0.00983785f, 0.04432103f, 0.02165124f, 0.03689266f, 
    -0.04098811f, -0.04599670f, -0.00945450f, 0.01304843f, -0.00981827f, -0.01233740f, -0.04341301f, 0.01646281f, 
    0.02757782f, 0.04605554f, -0.04150728f, -0.05352350f, 0.00163909f, 0.00968197f, 0.02173339f, 0.03317477f, 
    -0.05167812f, -0.00349771f, -0.04276465f, 0.01669772f, -0.05668014f, 0.02457650f, -0.05259808f, -0.03819463f, 
    0.00181836f, -0.03395478f, 0.01252059f, 0.03680307f, -0.00775631f, -0.05513260f, -0.01785081f, 0.00004487f, 
    -0.00169332f, 0.04523969f, 0.00147184f, 0.00629853f, -0.00718162f, 0.01863055f, 0.03471465f, -0.04014196f, 
    -0.04996670f, -0.01292157f, -0.00723389f, -0.02623453f, -0.04395106f, 0.01520691f, 0.00063621f, 0.04067263f, 
    -0.01567897f, 0.02515837f, 0.03496563f, -0.02555588f, -0.03699657f, -0.00277543f, -0.01451373f, -0.01542878f, 
    -0.01647008f, -0.03369409f, -0.02871303f, -0.05073588f, 0.03657542f, 0.04115422f, -0.03881797f, 0.03807880f, 
    0.03433009f, -0.04184968f, 0.03699541f, 0.00452546f, 0.01620489f, -0.05706747f, 0.01893120f, 0.02775252f, 
    -0.00650044f, 0.01869141f, -0.00410911f, -0.03029160f, 0.04106414f, -0.03649469f, -0.00240630f, -0.02145790f, 
    -0.04022305f, 0.04831550f, -0.02741938f, 0.00666000f, -0.04989615f, -0.01651647f, -0.01380728f, -0.03824382f, 
    0.03222678f, -0.01038649f, 0.02450361f, 0.04734594f, -0.01760986f, 0.00503289f, -0.02631364f, 0.02777714f, 
    0.03533759f, 0.01391148f, 0.01183317f, -0.04611186f, -0.03999794f, -0.04641577f, -0.00348886f, -0.01582460f, 
    -0.05020164f, -0.11102773f, 0.09758458f, -0.18716374f, -0.03038597f, -0.04707631f, -0.04146286f, 0.11175388f, 
    0.02391934f, -0.06800023f, -0.02138612f, -0.05891899f, -0.24991478f, 0.03929517f, -0.11074964f, 0.13460942f, 
    0.01832564f, 0.04247843f, -0.06169514f, 0.02584390f, 0.00301899f, 0.04832916f, -0.01296263f, 0.12614933f, 
    -0.17315611f, 0.00346044f, -0.20812966f, -0.23765202f, 0.00216421f, 0.03298711f, -0.10540702f, -0.04754637f, 
    0.09975477f, 0.08046759f, 0.08296967f, 0.00180711f, -0.01322841f, 0.22093478f, -0.10665687f, -0.00787185f, 
    -0.02291740f, -0.07757966f, -0.04100775f, 0.12652513f, -0.03814765f, -0.01700805f, 0.02033493f, 0.05933325f, 
    -0.07448629f, 0.11021095f, -0.22631007f, 0.25256851f, 0.05076450f, 0.09320509f, -0.02804944f, 0.17413567f, 
    0.09641356f, 0.06842812f, 0.01114552f, 0.13800345f, 0.03020801f, -0.13990350f, 0.10757557f, 0.07349040f, 
    0.06597672f, 0.00367516f, 0.10119946f, -0.03229622f, 0.03497843f, -0.03770100f, -0.05227122f, 0.03208686f, 
    0.18197152f, 0.02009229f, -0.12941031f, 0.31707355f, -0.00836904f, -0.04148642f, -0.02489568f, 0.04372710f, 
    0.09559567f, 0.11369634f, -0.08994722f, 0.08636426f, -0.18885951f, 0.14941923f, -0.18981621f, -0.05565976f, 
    0.18119337f, -0.08064835f, -0.07426234f, -0.00348059f, -0.11192527f, 0.09070149f, -0.05745079f, -0.04102463f, 
    -0.06636891f, 0.18713099f, 0.26477188f, -0.07429951f, 0.02516375f, -0.09163796f, -0.04178986f, -0.02525467f, 
    0.09021569f, 0.06706329f, 0.01910284f, -0.04157829f, -0.11559013f, 0.14952466f, 0.26514930f, -0.21807913f, 
    0.00989237f, 0.01859409f, -0.04113973f, 0.02590828f, 0.02496060f, -0.08920988f, 0.10430675f, 0.04718924f, 
    -0.19977935f, -0.11697857f, 0.19562550f, -0.17507094f, 0.14450885f, 0.10943048f, 0.18870248f, 0.04640465f, 
    -0.07374387f, 0.01912411f, 0.06702353f, -0.00417337f, -0.02168816f, 0.11966528f, -0.20223694f, 0.20378895f, 
    -0.02724868f, 0.11591496f, -0.02270185f, 0.09433082f, 0.06675903f, 0.08998212f, 0.01517312f, 0.07630509f, 
    0.21982154f, 0.08134945f, 0.02146768f, 0.06739977f, 0.16935621f, -0.03244084f, 0.00488730f, 0.07999383f, 
    -0.00892617f, 0.02773867f, 0.05230140f, 0.01891307f, -0.16687958f, -0.05547009f, 0.10183322f, -0.11802260f, 
    -0.03623998f, -0.04431293f, 0.00706579f, -0.02083933f, -0.07614918f, 0.09920760f, -0.03675692f, 0.04552483f, 
    -0.17391321f, -0.09494633f, 0.01073605f, -0.17165278f, 0.02067527f, 0.02731229f, -0.02791018f, 0.15235665f, 
    -0.07902596f, -0.01064593f, -0.09631152f, -0.00848565f, 0.14009362f, 0.02046357f, -0.14216018f, -0.01973644f, 
    -0.06329809f, 0.00843730f, -0.03172535f, 0.04672395f, 0.07384378f, 0.07351753f, -0.08380805f, -0.01403138f, 
    -0.08733737f, -0.09720745f, 0.01802207f, -0.03041497f, -0.06065261f, 0.16620393f, -0.12302081f, -0.01537323f, 
    -0.00257746f, -0.10659029f, -0.02842225f, 0.11647966f, 0.26185900f, -0.00339150f, -0.00208896f, 0.02757910f, 
    0.07980146f, -0.00832689f, 0.05524188f, 0.06717867f, 0.14347711f, -0.00244729f, -0.01124312f, 0.04456102f, 
    -0.28197715f, 0.23937503f, -0.07960027f, 0.01808904f, 0.01463057f, -0.01895159f, -0.07641173f, -0.05625352f, 
    0.02803551f, 0.09545799f, 0.00377324f, 0.01674136f, 0.11021437f, -0.10576442f, 0.08011945f, -0.01304447f, 
    -0.02048448f, 0.09207049f, -0.06685684f, 0.04709219f, -0.01770675f, -0.05120175f, -0.12926112f, -0.18906085f, 
    0.09479926f, 0.10889398f, 0.01979833f, 0.19044104f, 0.15622675f, 0.09104402f, 0.08313545f, 0.14946777f, 
    0.01784866f, -0.00747860f, -0.09852486f, 0.07527333f, -0.03737116f, -0.01245586f, -0.26219824f, 0.21304189f, 
    -0.02464226f, -0.02548629f, -0.00189736f, -0.02442554f, -0.09484865f, -0.08501156f, -0.12114112f, 0.04720061f, 
    0.03891513f, 0.23831332f, -0.08485516f, 0.21863809f, -0.11475375f, -0.03791319f, -0.10310758f, 0.07060542f, 
    0.05255382f, -0.04498618f, 0.01677436f, -0.05490503f, 0.05998078f, -0.06838705f, 0.20349053f, 0.02082516f, 
    0.23593944f, -0.03630950f, -0.00529703f, 0.05832676f, -0.01094873f, 0.05663165f, 0.04776794f, 0.06198626f, 
    -0.09001816f, -0.35553387f, 0.02816718f, 0.17501731f, -0.04934923f, -0.09608679f, -0.02119132f, 0.01222287f, 
    0.08996901f, -0.07959240f, 0.06859599f, 0.08075149f, 0.13786691f, 0.02838860f, 0.05965399f, 0.21871722f, 
    -0.14738670f, 0.01181673f, -0.07854941f, 0.11456495f, 0.10713110f, -0.03236481f, 0.03952117f, -0.03380410f, 
    -0.15752842f, 0.06081747f, -0.01366992f, 0.01778938f, -0.03364206f, 0.03522354f, -0.01197039f, -0.04816400f, 
    0.03776637f, -0.05171932f, 0.10768522f, -0.01618275f, 0.25870711f, -0.00076427f, -0.08053683f, 0.19890182f, 
    -0.05326370f, -0.11516930f, 0.01331463f, 0.06995516f, 0.06746600f, 0.01117645f, 0.03343400f, 0.07193812f, 
    0.05950459f, -0.09860114f, -0.02746218f, 0.00250536f, -0.04860782f, 0.08148982f, -0.00855183f, 0.04945137f, 
    0.00906525f, 0.02280819f, 0.04381305f, -0.00602000f, -0.01651289f, 0.09888647f, -0.02576470f, 0.06793560f, 
    -0.01804262f, -0.14867041f, -0.02797125f, -0.01557749f, 0.03496465f, -0.01223104f, -0.08253429f, -0.09205669f, 
    -0.17697646f, 0.38133079f, -0.19275510f, -0.39240548f, 0.00905868f, 0.04389183f, -0.01057028f, -0.09866603f, 
    -0.01722791f, 0.04118437f, 0.08163547f, 0.02792219f, -0.04260692f, -0.21507186f, 0.12011498f, -0.08096462f, 
    0.03855088f, -0.08316680f, 0.08468801f, -0.01816452f, 0.00016666f, 0.04612221f, 0.05901520f, 0.01891234f, 
    0.02094194f, 0.05776621f, 0.20260634f, -0.04829530f, -0.08152302f, -0.01098919f, 0.04726043f, 0.16823772f, 
    0.06452594f, 0.02123704f, 0.08948424f, -0.05306320f, 0.27695966f, -0.25614578f, -0.01813920f, -0.03104825f, 
    0.05200290f, 0.04799865f, -0.06211015f, -0.05775447f, -0.02796320f, 0.12413137f, 0.02841624f, -0.07535163f, 
    0.00376692f, 0.16414694f, 0.03716175f, 0.06480966f, 0.16571426f, 0.04470491f, 0.04968708f, -0.04071227f, 
    0.00879830f, 0.04769062f, 0.12548406f, 0.01355642f, -0.00064423f, 0.27731809f, -0.18995295f, -0.05262945f, 
    -0.01874745f, -0.16771606f, 0.10577644f, 0.11633213f, 0.08750885f, -0.01349186f, 0.04296799f, -0.17294610f, 
    0.29292455f, 0.17660423f, 0.07125660f, 0.14504980f, 0.02377145f, 0.02495995f, 0.08395995f, -0.14406151f, 
    -0.03844134f, 0.13783084f, -0.08474336f, 0.05223495f, 0.08575093f, 0.18912479f, 0.07495732f, 0.10759809f, 
    -0.04082096f, -0.02578185f, 0.07199632f, 0.01389257f, -0.14279050f, 0.04271286f, -0.05845413f, -0.05535463f, 
    -0.34700173f, -0.04805775f, -0.29620788f, -0.11279835f, -0.10836782f, -0.02719489f, -0.04751857f, -0.11245526f, 
    0.02533658f, -0.12737295f, -0.11316773f, 0.09410980f, -0.01704383f, 0.18139066f, 0.00697392f, 0.21979229f, 
    0.01694087f, -0.06426103f, 0.01662527f, -0.03576368f, 0.02760807f, -0.04198937f, 0.05268593f, 0.09149127f, 
    -0.19282010f, 0.02115717f, 0.05645020f, -0.27448636f, 0.00188726f, -0.06516614f, -0.06306580f, 0.00876976f, 
    0.04838398f, 0.10116377f, 0.05789059f, 0.01087846f, -0.14863208f, 0.02193228f, -0.08082721f, -0.10445970f, 
    0.01461345f, -0.05154000f, 0.05600473f, 0.03118861f, -0.04704195f, 0.10507036f, 0.16557968f, 0.01781345f, 
    -0.06505854f, 0.12518483f, 0.03702153f, 0.08358449f, 0.02479455f, 0.06296413f, -0.09922982f, 0.01309020f, 
    0.06704624f, -0.02693891f, -0.01577180f, -0.06413610f, 0.16563179f, 0.12860841f, -0.03123912f, 0.20181465f, 
    -0.00516933f, 0.10926722f, -0.04933136f, 0.10050965f, -0.03725686f, -0.01564461f, -0.07322150f, 0.02952506f, 
    -0.00182637f, 0.18222971f, -0.16836710f, -0.00661636f, -0.02161722f, 0.14017484f, -0.06649929f, 0.06610344f, 
    0.05077224f, 0.09997853f, 0.12840289f, 0.03883367f, -0.26837999f, -0.12783930f, 0.13471198f, 0.11298835f, 
    0.00824090f, 0.03580847f, 0.05501760f, -0.02431612f, -0.02231155f, 0.05129848f, 0.02121555f, 0.01832775f, 
    0.14364541f, 0.16270769f, 0.11520887f, 0.06962433f, -0.02271236f, -0.08915068f, 0.14023119f, -0.04790187f, 
    0.02253908f, 0.00709108f, -0.06749660f, 0.07982320f, 0.25621960f, -0.16522501f, 0.06332373f, 0.14223170f, 
    0.11790366f, -0.03602838f, -0.03505015f, -0.02343028f, 0.01792478f, 0.08064797f, 0.03038913f, 0.02990376f, 
    0.06419927f, -0.00976820f, 0.04454047f, 0.20296825f, 0.03091352f, 0.05623696f, -0.11860004f, -0.12609415f, 
    -0.05151409f, 0.01013853f, -0.12540334f, 0.06476460f, 0.16854735f, 0.16770117f, -0.07274307f, 0.02065879f, 
    0.12279394f, -0.05436246f, 0.08906841f, 0.06738019f, 0.08104361f, -0.08369053f, -0.00729450f, 0.09871576f, 
    -0.05111072f, 0.01253054f, -0.18043542f, -0.00889709f, 0.08469090f, -0.05414774f, -0.04743259f, -0.04562590f, 
    0.06914968f, 0.09332276f, -0.03938973f, -0.05329460f, -0.04243405f, -0.03270180f, -0.00110857f, 0.08050235f, 
    0.00726459f, -0.13172549f, -0.11335504f, -0.06168042f, 0.01825045f, 0.04503619f, -0.01808849f, -0.00188451f, 
    -0.15774617f, 0.02895149f, -0.09788876f, -0.06635883f, 0.06508095f, 0.02983101f, 0.05859255f, 0.03213225f, 
    0.01313625f, -0.05111904f, 0.09609844f, 0.04750679f, 0.16698287f, -0.07226393f, 0.23961198f, 0.28801447f, 
    -0.01783045f, -0.12713265f, 0.02367937f, 0.07239888f, -0.00857328f, -0.01416612f, -0.00940308f, 0.07952300f, 
    -0.14681229f, 0.02151003f, -0.06734348f, -0.08795027f, -0.00443073f, -0.11629897f, -0.14199139f, -0.07912546f, 
    -0.06309961f, -0.02691918f, 0.09256531f, 0.06135548f, 0.15267903f, 0.10867619f, 0.00093995f, -0.08869112f, 
    0.00838553f, 0.09506112f, 0.10709716f, 0.16319795f, -0.02929535f, 0.13821979f, 0.00050775f, -0.05322812f, 
    0.16430864f, -0.06355967f, 0.16873172f, 0.12866187f, -0.04727222f, -0.12604494f, -0.01989784f, -0.06400890f, 
    0.02176628f, 0.04722583f, 0.09465559f, -0.00491254f, 0.27863535f, -0.12169928f, 0.08307512f, -0.05647495f, 
    -0.01699750f, -0.02424098f, 0.09167060f, -0.02450652f, 0.04750435f, -0.12672962f, 0.09937093f, 0.02316405f, 
    0.22474097f, -0.08485719f, 0.28913531f, 0.13854431f, 0.10936287f, 0.09074838f, -0.14000811f, 0.03156742f, 
    -0.01429860f, -0.06424810f, 0.01938760f, -0.08274122f, -0.43444231f, 0.21124008f, -0.18942221f, -0.16093983f, 
    -0.06889127f, -0.01591486f, -0.05647105f, -0.02299422f, -0.06574556f, -0.01327126f, -0.01795862f, -0.00158329f, 
    0.06632465f, -0.02519479f, 0.12142394f, 0.04173534f, 0.04316217f, 0.09286000f, 0.00655246f, -0.09928972f, 
    -0.04120009f, -0.15046698f, 0.14304286f, 0.09611789f, 0.12372144f, 0.05637220f, 0.00149614f, 0.07180965f, 
    0.05552952f, 0.05880597f, 0.10756474f, -0.06414764f, -0.02453054f, 0.05775918f, -0.08110022f, 0.05992386f, 
    -0.17616352f, 0.06122126f, -0.05346775f, -0.47016788f, 0.02627224f, 0.03973017f, -0.13807113f, 0.03107173f, 
    0.10103570f, -0.08319499f, 0.02335714f, 0.05211850f, -0.26871970f, -0.13122368f, 0.17090869f, 0.02959098f, 
    0.01513594f, 0.12161408f, -0.01050949f, 0.12900493f, 0.02783062f, -0.02231462f, -0.01209048f, 0.03770674f, 
    -0.00908411f, 0.03913551f, -0.03710802f, -0.04579135f, -0.00100591f, 0.03749686f, -0.02680105f, -0.01782981f, 
    -0.04332661f, 0.03859431f, 0.01384787f, -0.00583318f, -0.00597913f, 0.03395768f, 0.00940786f, -0.05320857f, 
    0.00466421f, 0.00509144f, -0.04488956f, 0.00369625f, 0.03944010f, -0.03653939f, 0.02677204f, -0.03332159f, 
    -0.00578330f, -0.00826340f, -0.05100511f, -0.02964532f, 0.01864424f, 0.00321108f, -0.03937485f, -0.00297799f, 
    -0.00100184f, -0.05102957f, -0.03596801f, -0.02077818f, 0.04277756f, 0.02094899f, -0.03846365f, -0.01816327f, 
    0.02043636f, 0.03708403f, 0.00023710f, -0.02484415f, 0.04109474f, 0.03404773f, -0.03892291f, -0.00467979f, 
    0.00875034f, -0.04237130f, -0.00111931f, 0.03652219f, 0.00943817f, 0.03334604f, -0.05266958f, -0.00957555f, 
    0.00563082f, 0.04576779f, -0.02225562f, -0.03987269f, -0.04030384f, 0.01020937f, -0.00702878f, -0.05469647f, 
    0.00030282f, 0.03296726f, -0.03200684f, -0.04253200f, -0.02809155f, -0.00035223f, -0.00381045f, -0.04180929f, 
    -0.04135518f, 0.00873314f, 0.03516789f, -0.01790571f, -0.01752549f, 0.01572217f, 0.03673809f, -0.02143170f, 
    0.00548732f, -0.03036289f, 0.01359912f, 0.00729488f, 0.00422807f, 0.00021608f, -0.05242793f, 0.03298809f, 
    0.04062752f, 0.01974813f, 0.02578351f, 0.01552559f, 0.00118065f, -0.01621794f, 0.01899285f, 0.03237613f, 
    0.02359990f, -0.02432597f, 0.03973492f, 0.03751123f, -0.04241852f, -0.05448185f, -0.03698241f, -0.01388713f, 
    -0.01276760f, -0.00254578f, -0.05470360f, -0.03070831f, -0.01378959f, 0.00785961f, -0.02066252f, 0.04281817f, 
    -0.00325454f, -0.01466724f, -0.02388528f, 0.00217939f, -0.02225464f, 0.00189367f, -0.03882539f, -0.02657911f, 
    -0.00432729f, 0.03907752f, 0.04371177f, -0.02949527f, -0.05615420f, -0.01136472f, -0.04771014f, 0.03777217f, 
    -0.01977770f, -0.01806576f, 0.02454240f, -0.04433251f, -0.03047604f, -0.04899231f, -0.03454007f, 0.03758212f, 
    0.04335430f, 0.03669572f, 0.02868422f, 0.04274479f, 0.04130364f, -0.04176896f, -0.02684688f, -0.02549565f, 
    0.04367763f, -0.01709828f, -0.05054931f, -0.03698645f, 0.00382616f, -0.03978643f, -0.04248729f, -0.05497902f, 
    -0.03479223f, -0.02627990f, -0.01102975f, 0.04429922f, 0.01122840f, -0.00829911f, 0.04121954f, -0.03712093f, 
    0.00340148f, -0.01958233f, 0.02534586f, -0.02893384f, -0.01722036f, -0.03398699f, -0.03694688f, -0.05547615f, 
    0.01269336f, 0.00761009f, 0.01642713f, 0.03853860f, -0.03412533f, -0.05032526f, -0.02399835f, -0.00772579f, 
    -0.04355794f, -0.00448709f, 0.02788803f, 0.03474618f, 0.01202632f, -0.04369260f, -0.02171762f, -0.00757664f, 
    0.00971247f, -0.03357373f, -0.02018072f, -0.01250757f, 0.01790633f, -0.03668893f, 0.01729517f, -0.03812749f, 
    0.01533565f, -0.01725122f, 0.02443895f, -0.02409856f, -0.03107362f, 0.00555872f, 0.03062088f, -0.00068923f, 
    0.02594071f, -0.01585635f, 0.01184639f, 0.01199097f, 0.02656440f, -0.00714353f, -0.05363394f, 0.03505547f, 
    -0.01088940f, -0.02264996f, -0.00764025f, -0.01585271f, 0.02368271f, -0.00119616f, 0.03590835f, -0.05622585f, 
    0.02930104f, 0.03128270f, -0.01084580f, -0.01398740f, 0.01234387f, -0.04106816f, -0.04955257f, -0.03659685f, 
    0.02355688f, 0.01652291f, -0.01855400f, 0.01705869f, -0.01302517f, -0.02707002f, -0.03975876f, 0.00281791f, 
    -0.00050803f, 0.01977825f, 0.01777269f, 0.03820906f, -0.01897274f, -0.01417736f, -0.01285800f, -0.03777323f, 
    -0.01937319f, 0.03813162f, 0.02245392f, 0.01722150f, -0.05871880f, 0.03044740f, -0.01425869f, -0.01596571f, 
    0.00650348f, -0.05162133f, -0.02342077f, -0.02982101f, 0.02487186f, -0.01153031f, 0.02001026f, -0.03522367f, 
    0.02449213f, 0.01049988f, 0.03453925f, -0.01218413f, -0.01706430f, 0.00790029f, -0.05165177f, -0.03538119f, 
    0.01734957f, -0.03868686f, 0.01990857f, 0.01330159f, -0.01429126f, -0.01892959f, 0.02613313f, 0.03730842f, 
    -0.01364458f, 0.03869460f, 0.00146154f, 0.01024590f, -0.05249695f, -0.02113815f, -0.02013672f, 0.02219287f, 
    -0.05158525f, -0.04341111f, -0.02453701f, -0.03460667f, -0.01809135f, 0.00063750f, 0.01743226f, -0.03386028f, 
    0.04072412f, -0.04565052f, 0.01197094f, -0.02450698f, -0.01891673f, -0.00569850f, 0.02334705f, 0.03406817f, 
    0.02003420f, 0.02850735f, -0.01874753f, 0.03761127f, 0.00514462f, -0.00146438f, -0.05662758f, 0.03814448f, 
    0.02792453f, -0.00662625f, 0.00110340f, -0.00944865f, 0.02741135f, 0.01099043f, -0.02271965f, 0.00668376f, 
    -0.02056520f, 0.01418893f, -0.02874513f, -0.03423340f, -0.05646180f, 0.02577609f, -0.01004889f, -0.00323686f, 
    0.03829284f, -0.05569428f, 0.03439941f, -0.05693514f, -0.05192573f, 0.05583144f, 0.01801651f, -0.01816880f, 
    -0.00031278f, 0.00634840f, 0.03290038f, 0.03221998f, -0.02720791f, -0.04273362f, -0.01230459f, -0.00701718f, 
    -0.04433031f, -0.02452908f, -0.05542700f, 0.00687762f, -0.02999522f, 0.00086111f, 0.00020182f, -0.02196695f, 
    0.01867374f, -0.00105386f, -0.05621395f, -0.05164295f, 0.01555945f, 0.03547527f, -0.02023978f, -0.00436559f, 
    -0.05207326f, -0.01507007f, -0.00250304f, -0.00517149f, -0.01029635f, 0.02540436f, 0.00155816f, -0.03210259f, 
    -0.00289244f, 0.04222957f, -0.02910772f, -0.04534876f, -0.01653752f, -0.05187014f, 0.01879467f, 0.03181672f, 
    0.00821188f, 0.03619766f, -0.04765010f, 0.04040179f, -0.04273405f, -0.03623824f, -0.00101641f, -0.05102674f, 
    -0.05538493f, 0.01448684f, -0.05733831f, -0.04136368f, -0.00148573f, -0.03170227f, 0.04337624f, -0.00624904f, 
    -0.01724263f, 0.01765461f, -0.04581065f, -0.00311383f, -0.02725293f, 0.03976780f, -0.02512884f, -0.01236594f, 
    -0.05272134f, 0.01157298f, 0.04300642f, -0.04671418f, -0.04394662f, -0.00818148f, -0.04166007f, -0.05571368f, 
    -0.01326718f, 0.04379599f, 0.01000875f, 0.02210119f, 0.00012953f, 0.00851994f, -0.04388710f, -0.03825767f, 
    0.01564160f, 0.03395331f, 0.02843180f, -0.04629420f, 0.03790606f, 0.03378003f, 0.00429953f, -0.05023676f, 
    0.01824446f, -0.00999855f, 0.00930918f, 0.03527611f, 0.02051763f, 0.01283313f, 0.01643827f, 0.00444316f, 
    0.01188099f, -0.02803261f, -0.01022437f, -0.03483815f, -0.04066952f, 0.03301172f, -0.03508167f, -0.02408692f, 
    0.04585618f, -0.01602384f, 0.03635957f, -0.01141548f, -0.01978826f, 0.01557314f, 0.02877245f, 0.02991195f, 
    0.01003929f, 0.03183910f, -0.02763997f, -0.04513249f, -0.03613548f, -0.02888335f, 0.00820006f, -0.04748043f, 
    -0.02005889f, -0.00168820f, 0.00291344f, -0.03809394f, 0.01086480f, -0.04300525f, 0.00786038f, -0.01937314f, 
    -0.04139939f, -0.00544818f, 0.00046766f, -0.03944438f, 0.01971756f, -0.03085612f, -0.00575921f, 0.03637333f, 
    0.03751857f, 0.03181013f, -0.00777192f, -0.00258365f, 0.04186362f, 0.02616035f, -0.01016089f, -0.01332344f, 
    0.04406495f, -0.05040024f, 0.00437887f, -0.05149003f, 0.00105798f, 0.01205938f, -0.03730053f, -0.01394968f, 
    -0.04211496f, -0.01132756f, -0.03552896f, 0.01217760f, -0.00628862f, 0.02783584f, -0.00716259f, 0.02039013f, 
    0.03536428f, 0.00360626f, 0.01697951f, -0.05302880f, -0.03792429f, 0.03467664f, -0.00292589f, -0.04359948f, 
    0.00481307f, -0.01811378f, -0.01077389f, 0.01648081f, -0.00665889f, 0.02418672f, -0.01752820f, 0.04394872f, 
    0.04005992f, 0.02677626f, -0.01114585f, 0.02564104f, -0.04482983f, 0.03226579f, -0.01749804f, 0.01578807f, 
    0.03278504f, -0.01765069f, -0.04448339f, 0.01392057f, 0.00490078f, 0.02139797f, -0.01219149f, -0.04654839f, 
    0.03738816f, 0.03506950f, 0.04354976f, 0.01654421f, -0.05643737f, -0.04853062f, 0.03210552f, -0.05688245f, 
    -0.00312741f, 0.03213198f, 0.02102984f, 0.03522016f, -0.05316606f, 0.00055966f, -0.04537321f, -0.00435279f, 
    -0.04703088f, 0.02312995f, 0.02014165f, -0.01339359f, -0.04544399f, 0.00397182f, -0.03553886f, -0.01502653f, 
    0.04356370f, -0.01544040f, -0.00401946f, 0.02030947f, -0.05588539f, -0.01768565f, -0.03570593f, -0.00777370f, 
    -0.04541479f, 0.00978654f, 0.01408669f, 0.00063452f, -0.00280540f, -0.04424371f, -0.00427175f, -0.05053748f, 
    -0.01412995f, -0.02819853f, -0.00237822f, 0.00024292f, -0.04873136f, 0.03276310f, -0.00863380f, -0.00420829f, 
    -0.01232733f, 0.01034896f, -0.05629184f, -0.02652879f, -0.03917009f, -0.02013520f, 0.00444381f, 0.03213866f, 
    -0.02391076f, -0.00459764f, 0.00020201f, 0.01949593f, -0.03755732f, -0.03730556f, -0.05119790f, -0.03597743f, 
    0.02267618f, -0.03149209f, -0.03412205f, 0.03231753f, -0.01373114f, -0.00009794f, 0.04063152f, 0.04076953f, 
    0.02733913f, 0.00703496f, -0.00818046f, 0.00031028f, -0.01145995f, -0.02892428f, -0.03523983f, 0.02720793f, 
    0.01938325f, -0.02635170f, 0.00171913f, 0.00948432f, -0.02146644f, -0.03746852f, -0.03812204f, 0.03111412f, 
    0.02024500f, -0.01253249f, 0.01074988f, -0.02391369f, 0.00790283f, 0.04198158f, -0.01504009f, -0.01145081f, 
    -0.01234936f, 0.03043387f, 0.02508746f, -0.02611081f, 0.00240047f, 0.02216392f, 0.04230844f, 0.01871827f, 
    -0.05064017f, -0.01355880f, -0.00843875f, -0.04099397f, 0.01402278f, -0.00622326f, -0.02730195f, 0.03475860f, 
    0.02576744f, 0.01895281f, -0.05561800f, -0.04377409f, -0.00472340f, 0.02769832f, -0.02441060f, -0.04710094f, 
    -0.04329397f, 0.02738850f, -0.03822893f, 0.02810755f, -0.00676051f, 0.02335976f, -0.00114033f, -0.04182145f, 
    0.00221579f, -0.02504505f, 0.00595665f, -0.04299146f, -0.04188948f, 0.01254655f, 0.04158648f, 0.00504454f, 
    0.03627370f, -0.05059807f, -0.05498642f, -0.05444636f, -0.00090066f, -0.05106464f, 0.02696856f, -0.04699355f, 
    -0.03957951f, 0.03734608f, 0.04019955f, -0.02685762f, 0.04530324f, -0.03810768f, -0.04312367f, 0.01901047f, 
    0.02249616f, -0.02998519f, 0.02153646f, -0.05568368f, 0.04204220f, -0.04930834f, 0.02723972f, -0.02633680f, 
    0.03793754f, -0.00780859f, 0.03116189f, -0.01491078f, 0.04814206f, -0.00336073f, 0.03815480f, -0.05048531f, 
    -0.01781705f, 0.01578620f, 0.02832172f, 0.02442700f, 0.00158556f, -0.04081466f, -0.05128679f, 0.02394097f, 
    -0.05037427f, -0.03924486f, -0.00443396f, -0.00029643f, 0.00202850f, 0.00314617f, -0.04163465f, -0.05439284f, 
    -0.02592246f, 0.00654122f, -0.04170151f, 0.02023848f, -0.04698033f, -0.03958397f, 0.02839684f, -0.01416253f, 
    -0.01707074f, -0.00283199f, -0.03920386f, 0.01292958f, 0.03197144f, -0.03327739f, 0.03434197f, -0.05397850f, 
    0.03598132f, -0.04619561f, -0.03168883f, 0.00986595f, -0.03670816f, 0.02762196f, -0.02840890f, -0.03417041f, 
    -0.03078256f, -0.04006085f, -0.04239717f, -0.05541104f, -0.00807531f, 0.02444660f, 0.01755245f, 0.01007031f, 
    -0.05358916f, -0.05442402f, -0.01351887f, -0.00307419f, 0.00214528f, 0.01464826f, -0.01324746f, 0.02562574f, 
    -0.03313338f, -0.01737429f, 0.03994397f, 0.01504074f, -0.03557280f, -0.05279833f, -0.00484136f, -0.03751373f, 
    -0.01943458f, 0.01036371f, -0.01670237f, -0.02080507f, -0.04280018f, -0.03427363f, 0.00329975f, 0.01310969f, 
    0.01094193f, 0.01744704f, -0.04527355f, 0.02102927f, 0.03756576f, 0.04348875f, -0.04000809f, 0.02223624f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00966008f, -0.01640995f, -0.05288062f, 0.03207140f, -0.04652937f, 0.05682611f, 0.07787623f, 0.00862925f, 
    0.04073118f, -0.02013684f, 0.01923573f, -0.01850633f, -0.05376903f, 0.04802530f, 0.01256711f, -0.04695371f, 
    0.03933892f, -0.00918870f, -0.06537548f, 0.03413741f, -0.00486471f, 0.01314769f, -0.03011402f, -0.04092627f, 
    0.12951270f, 0.03414998f, -0.02873123f, 0.01924182f, -0.05158760f, 0.02539305f, 0.02999814f, 0.03778888f, 
    0.03167346f, -0.00230182f, 0.02971318f, 0.00706477f, 0.09402061f, 0.03496656f, -0.00993564f, -0.02084481f, 
    -0.01912478f, -0.02591251f, 0.02281943f, -0.05103076f, -0.07593792f, 0.04825472f, 0.00919643f, -0.00228012f, 
    -0.04625237f, -0.04407331f, -0.01126082f, 0.03366711f, -0.04912122f, 0.04792766f, 0.01847965f, 0.03295951f, 
    0.05278096f, 0.04350217f, 0.12016290f, 0.03758893f, 0.00555922f, 0.02520158f, -0.00583895f, 0.00421622f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06224151f, -0.03224743f, 0.04803900f, -0.49627107f, 0.23522936f, 0.25847760f, -0.23137285f, 0.03071626f, 
    -0.06377187f, -0.08817957f, 0.05033542f, 0.16496919f, -0.01647106f, -0.26093507f, 0.08065959f, 0.06837504f, 
    -0.10911293f, -0.10917179f, -0.03987139f, -0.21565063f, 0.26405686f, -0.04550934f, 0.36257577f, -0.09887774f, 
    -0.17293476f, -0.12962948f, 0.10088024f, 0.16071214f, -0.09557116f, 0.05025147f, -0.00380029f, 0.24380699f, 
    0.09556465f, -0.08739702f, -0.04878698f, 0.12645714f, -0.25503561f, -0.06587080f, -0.00186227f, -0.00602976f, 
    0.00451948f, 0.08943328f, -0.07599017f, -0.01442483f, 0.11684114f, -0.50799668f, 0.03257497f, 0.04013224f, 
    -0.26457587f, 0.09387692f, 0.19164455f, -0.09676491f, -0.12995924f, -0.40183246f, 0.03245759f, 0.03902237f, 
    -0.03276518f, -0.16794504f, -0.45435563f, -0.11653284f, 0.26811162f, 0.10934874f, 0.02922353f, 0.02056787f, 
    -0.23350437f, 0.02833500f, 0.08456105f, 0.26062071f, 0.17873925f, -0.11338264f, 0.02765432f, 0.00987884f, 
    -0.11842959f, -0.04581394f, 0.15697122f, -0.23905939f, -0.04664093f, -0.38919652f, -0.45104715f, -0.12042601f, 
    -0.27504754f, 0.06359697f, 0.18189363f, -0.39577210f, 0.05098400f, 0.07946881f, -0.10478121f, -0.07658733f, 
    0.32589769f, -0.58929336f, -0.03406635f, -0.00558935f, -0.05699416f, 0.26198936f, -0.06139854f, -0.04617482f, 
    0.25377339f, -0.09282180f, -0.11300614f, -0.08592928f, 0.17429194f, 0.05759002f, -0.09024402f, -0.08796661f, 
    0.00532357f, 0.03284283f, -0.05438976f, 0.02687914f, -0.02505242f, -0.06397641f, 0.01343505f, -0.04779481f, 
    -0.28625515f, 0.00369317f, 0.26025054f, -0.06149987f, -0.03270986f, 0.24405527f, 0.06691942f, 0.04190208f, 
    0.26319867f, -0.28291818f, 0.28284812f, -0.07217336f, 0.16566041f, -0.11280029f, 0.04336037f, 0.04383670f, 
    0.32042003f, 0.07775865f, 0.09453145f, 0.03904616f, 0.25182316f, -0.46659848f, -0.42241469f, 0.03182213f, 
    -0.00760157f, -0.07492351f, 0.15307269f, 0.21691424f, -0.03349769f, -0.05181940f, 0.11123285f, -0.11210575f, 
    -0.35791272f, 0.03511877f, 0.04663205f, -0.58137429f, 0.09578406f, -0.00850687f, -0.21721397f, 0.09287090f, 
    0.08313826f, 0.16716412f, -0.03615870f, 0.14860164f, 0.10621423f, -0.29709628f, 0.04702069f, -0.25956690f, 
    -0.17367317f, -0.10327066f, 0.00519503f, -0.39260507f, -0.60731727f, 0.10163607f, -0.11081023f, 0.10783540f, 
    -0.03390098f, 0.11370037f, 0.06694742f, -0.04575717f, 0.22490565f, 0.21702380f, -0.06635936f, -0.04138349f, 
    0.31931269f, -0.06000403f, -0.04543715f, -0.06404084f, -0.04303342f, 0.23471361f, 0.01370095f, 0.06134713f, 
    0.12523258f, -0.04661745f, -0.04749519f, 0.07909316f, 0.06717757f, -0.19176660f, 0.03096596f, 0.02683826f, 
    0.19872530f, -0.04995367f, -0.04793815f, 0.34490740f, 0.08958206f, 0.02680201f, -0.27989310f, -0.08615121f, 
    0.08914427f, -0.09119594f, -0.32176903f, -0.06433260f, -0.10123353f, -0.00878655f, 0.19280107f, -0.09126016f, 
    0.16564050f, -0.03446714f, 0.39156845f, -0.10830695f, -0.39202017f, 0.08768336f, 0.08258243f, 0.05577170f, 
    -0.08755260f, 0.02033850f, -0.02320530f, -0.75325811f, -0.02500514f, -0.04875657f, 0.09579591f, 0.16237856f, 
    0.11168547f, 0.03376232f, 0.39360017f, 0.17645814f, 0.19039887f, -0.01632925f, 0.04040584f, -0.01835125f, 
    0.04977650f, -0.02060770f, -0.03938522f, 0.00479430f, 0.26380748f, -0.31164694f, -0.10485139f, -0.07113118f, 
    0.00176104f, -0.05464208f, -0.56754547f, -0.01106651f, 0.07029554f, 0.15754774f, 0.04253067f, 0.02267288f, 
    -0.00329755f, -0.02605116f, -0.17645453f, -0.07411861f, -0.50512701f, 0.02305153f, -0.00784006f, 0.10068428f, 
    -0.18912451f, -0.00369544f, -0.05478931f, -0.35084659f, -0.02635276f, 0.08687863f, 0.01246162f, 0.03006608f, 
    -0.02228833f, -0.11656384f, 0.04491844f, -0.09163016f, 0.03063172f, 0.01469616f, 0.03390303f, 0.07011081f, 
    0.00756359f, 0.05525360f, 0.16135788f, -0.04769108f, -0.24966411f, 0.09195306f, 0.44083443f, 0.00989776f, 
    -0.07841320f, -0.12556618f, -0.00761662f, -0.24572937f, 0.04324183f, -0.11860433f, 0.09657718f, -0.36361396f, 
    0.12906279f, -0.03963624f, -0.57144898f, 0.23933613f, 0.31617948f, -0.09054666f, 0.09101386f, -0.09709047f, 
    -0.08957418f, -0.00534578f, -0.12576631f, 0.09216770f, 0.08185868f, 0.35538539f, 0.00170800f, -0.09008976f, 
    0.07933921f, -0.03542082f, -0.08916213f, 0.11025156f, 0.11472764f, -0.07678001f, -0.12511949f, 0.03434230f, 
    -0.21048027f, 0.25352728f, -0.49500909f, 0.10040756f, 0.21248557f, -0.14140673f, 0.05515141f, -0.08952285f, 
    -0.05477304f, 0.10498919f, -0.08708540f, -0.10314857f, -0.37180638f, 0.27389997f, 0.01355817f, 0.05436183f, 
    -0.02269909f, -0.03319817f, 0.06633511f, -0.22887902f, -0.05563277f, -0.16923958f, -0.03162733f, -0.11773477f, 
    0.29915223f, 0.10786067f, -0.63488728f, 0.31201822f, 0.29800358f, -0.05307989f, -0.13564622f, -0.06304888f, 
    -0.20861229f, -0.31621462f, 0.03446916f, 0.04264004f, 0.08426610f, 0.00620033f, -0.00470943f, 0.16666184f, 
    0.04520946f, 0.08428490f, -0.05849806f, 0.00950556f, 0.16704053f, 0.08871673f, -0.01234113f, 0.10740516f, 
    -0.08577949f, 0.07445474f, -0.00489947f, -0.10548863f, -0.34999168f, 0.13893922f, -0.11667944f, 0.06726734f, 
    -0.59030628f, 0.11469950f, 0.30078623f, -0.02092374f, -0.07419003f, -0.18207820f, -0.10269713f, -0.10892713f, 
    -0.12182020f, 0.20710284f, 0.27577722f, 0.02098060f, -0.16322783f, -0.31351689f, 0.08602582f, 0.06010679f, 
    0.29956686f, 0.09451234f, 0.03004143f, 0.28191182f, -0.34414095f, 0.11283511f, 0.17755406f, 0.00032574f, 
    0.10441775f, 0.05070061f, 0.10264366f, 0.32872698f, -0.07093209f, -0.36491486f, -0.33310804f, -0.03932352f, 
    -0.36526340f, 0.04773258f, 0.17223285f, -0.03052091f, -0.27408406f, -0.08821245f, -0.46246475f, 0.02441822f, 
    0.25178933f, 0.34930792f, -0.00477522f, 0.20961159f, -0.09216523f, -0.21134609f, 0.03003619f, -0.01197948f, 
    -0.03326324f, 0.01639652f, -0.08952061f, 0.08762394f, -0.21666121f, 0.08395556f, -0.10138386f, -0.06613473f, 
    -0.05726472f, 0.11964869f, 0.00298946f, 0.10703040f, -0.53373623f, 0.23300372f, -0.08258711f, -0.04206060f, 
    0.08794083f, -0.03450422f, -0.05602121f, -0.16726840f, 0.09366982f, -0.34091938f, -0.03211583f, -0.11441775f, 
    -0.25127497f, 0.00384458f, 0.03990676f, 0.12479848f, -0.38060585f, 0.00354414f, 0.05908813f, -0.10355493f, 
    0.18767619f, -0.05307633f, -0.06161753f, -0.32706118f, 0.11350894f, -0.12006525f, -0.37794834f, -0.05899365f, 
    0.02620500f, 0.10809161f, -0.34100267f, -0.42515829f, -0.07061304f, 0.02830579f, -0.34022820f, 0.01756599f, 
    0.10617399f, 0.00997375f, 0.12087499f, 0.28215054f, 0.26604056f, -0.07107123f, -0.25657159f, 0.06938268f, 
    -0.33781537f, 0.26769614f, 0.00858337f, -0.18000197f, 0.09845853f, 0.10577439f, -0.06740161f, -0.30458191f, 
    -0.43123376f, -0.00128624f, -0.39651573f, 0.07420254f, 0.03187315f, -0.00972108f, 0.00124516f, 0.11029094f, 
    0.08381630f, 0.06033431f, -0.06019492f, 0.08007821f, 0.02795232f, -0.04513021f, 0.09773648f, -0.05512212f, 
    0.24962461f, 0.02128247f, -0.04322309f, 0.24766718f, -0.07545314f, -0.18107758f, 0.08374833f, -0.07102920f, 
    -0.18202299f, 0.05563527f, -0.12170949f, 0.09010685f, -0.44463176f, 0.31478494f, 0.05461676f, 0.03533554f, 
    -0.08723451f, 0.03537742f, -0.07142709f, 0.10070077f, 0.31888440f, -0.59647214f, 0.22994789f, 0.00049421f, 
    -0.07895587f, -0.07196694f, 0.12453002f, -0.35279533f, -0.05364462f, 0.08479740f, 0.20652294f, -0.05005527f, 
    -0.23298265f, -0.01388582f, -0.04623615f, 0.13175067f, 0.07432868f, -0.00176132f, -0.19631492f, -0.02927351f, 
    -0.44331369f, 0.06406143f, -0.07249956f, -0.00530567f, 0.01938136f, -0.28798720f, -0.07295431f, 0.15976420f, 
    -0.15551583f, 0.06939821f, 0.29118133f, -0.13737008f, 0.18603764f, -0.10227497f, -0.11270782f, 0.09397203f, 
    -0.10978189f, -0.01405357f, 0.02717797f, -0.01696724f, -0.00057247f, 0.27448452f, 0.09787631f, -0.00800828f, 
    -0.24492292f, -0.09797148f, -0.06641679f, 0.23876287f, -0.06231191f, -0.49970108f, 0.07919624f, 0.06246839f, 
    0.20917627f, -0.41863611f, 0.19363336f, -0.07210337f, -0.09869710f, -0.32072386f, -0.03426651f, -0.01650648f, 
    -0.49385470f, 0.08411003f, -0.10922723f, 0.10445428f, 0.07972164f, -0.04277226f, -0.08273645f, -0.04092861f, 
    -0.05942888f, -0.09039116f, -0.12018798f, 0.23422900f, -0.01772332f, 0.35918444f, -0.03253459f, 0.07345154f, 
    0.02031269f, 0.09588034f, -0.25665987f, 0.29257774f, 0.07750102f, -0.05797061f, 0.01209444f, 0.11303880f, 
    0.06343915f, -0.07983226f, 0.07057182f, 0.31409138f, -0.00564764f, -0.40353313f, -0.02158178f, -0.48015955f, 
    -0.18479469f, 0.09093153f, 0.32974285f, -0.30753615f, 0.16573291f, -0.06784772f, -0.01025998f, 0.04625834f, 
    -0.09512919f, -0.05599625f, 0.02834124f, 0.04571840f, 0.03154286f, 0.05463658f, -0.11279742f, 0.09451024f, 
    0.28052083f, -0.00236205f, -0.26729783f, -0.57516432f, 0.02130290f, 0.13337411f, 0.03009209f, 0.10630189f, 
    -0.28147367f, 0.14032958f, 0.24230497f, -0.02696156f, 0.04703254f, 0.32377455f, 0.05794346f, -0.07780154f, 
    -0.34300750f, -0.07847881f, -0.05351081f, 0.08467203f, -0.10597626f, 0.07186415f, -0.11162563f, -0.04437895f, 
    -0.02126285f, -0.07506726f, 0.11299373f, 0.08481538f, 0.00589354f, -0.19768922f, -0.04165383f, 0.02740406f, 
    0.36715299f, 0.11727758f, -0.23971644f, -0.18445446f, -0.16928551f, 0.03745191f, -0.44270536f, -0.05266709f, 
    0.30689430f, 0.28950331f, 0.05159775f, -0.40227669f, 0.05844979f, 0.23989412f, -0.01395735f, 0.35127544f, 
    -0.29949969f, -0.06177795f, 0.02403537f, -0.46215633f, -0.18306400f, 0.11985874f, 0.06591569f, 0.07882386f, 
    -0.11844034f, 0.09609937f, 0.06796931f, -0.05438052f, -0.27639624f, 0.01885769f, 0.05894082f, -0.10464556f, 
    0.00195097f, 0.00060152f, -0.54892969f, 0.09887058f, 0.01501270f, 0.29445979f, 0.10931509f, 0.07644613f, 
    0.06924494f, -0.23491539f, 0.01144439f, -0.08327552f, 0.24197288f, 0.26603583f, 0.10419418f, -0.00302699f, 
    0.23073350f, -0.01063207f, 0.07640185f, -0.16499355f, -0.30244258f, -0.05621845f, 0.33271933f, -0.07006710f, 
    -0.05310052f, 0.02125000f, 0.10998400f, -0.22367232f, 0.10857607f, 0.21679778f, 0.51986223f, -0.13016605f, 
    -0.09064541f, -0.06096959f, -0.00288152f, 0.05807535f, -0.16775551f, -0.03739069f, -0.47415781f, 0.10994758f, 
    0.20199071f, -0.05852325f, 0.08520882f, 0.27464199f, 0.06089419f, -0.01537973f, -0.12407138f, -0.19989198f, 
    -0.26747650f, -0.04260256f, -0.11761154f, 0.14138848f, 0.25207108f, 0.00451046f, -0.10691162f, -0.09324142f, 
    0.01182381f, -0.00763712f, 0.10280267f, 0.06393301f, -0.28327936f, -0.55687916f, -0.10763203f, -0.04247505f, 
    -0.14831604f, 0.04731608f, -0.62930429f, 0.05991436f, 0.00224489f, 0.15026456f, -0.09336630f, -0.10490140f, 
    0.06193308f, 0.16502210f, 0.09098230f, -0.05544272f, -0.23813169f, -0.28067368f, -0.00564994f, -0.02741143f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12774143f, 0.13031870f, -0.06932940f, 0.02950406f, -0.07208772f, -0.05367032f, 0.08203121f, -0.03103019f, 
    -0.03800601f, 0.01933624f, 0.12679900f, 0.09615464f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
