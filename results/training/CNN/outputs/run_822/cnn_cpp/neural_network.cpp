#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.38429448f, -0.67180961f, -0.56620836f, -0.15143654f, -0.08346092f, -0.70018548f, -0.23147219f, -0.15793088f, 
    -0.27518076f, -0.04588290f, 0.21017767f, 0.12486967f, -0.04242488f, 0.12167950f, 0.10826181f, -0.15708755f, 
    0.16276824f, -0.47579432f, 0.04558383f, -0.07504693f, 0.00343525f, 0.10651127f, 0.08465476f, 0.13982394f, 
    0.19426398f, 0.30925965f, 0.56681472f, 0.28591961f, 0.28765911f, 0.32648060f, -0.59374183f, -0.52740330f, 
    0.20776500f, -0.34001032f, 0.17512541f, 0.31773224f, -0.09297901f, 0.07136767f, 0.09710912f, 0.03748264f, 
    -0.30953136f, 0.22034530f, -0.03182318f, -0.11749879f, 0.25557980f, -0.08199500f, 0.27894115f, 0.06907052f, 
    0.25975421f, 0.02069425f, 0.65348750f, -0.37609312f, 0.21480225f, 0.83015752f, -0.13626505f, -0.02187461f, 
    -0.18637431f, 0.00401543f, 0.53737742f, -0.08727212f, -0.49193135f, -0.38432205f, 0.07457101f, 0.11978017f, 
    -0.14327934f, -0.02079627f, -0.19625267f, 0.02271026f, 0.05890325f, 0.23766986f, 0.10676445f, 0.29419929f, 
    0.14688422f, 0.04951062f, 0.12378836f, -0.08890611f, 0.43525213f, -0.59319192f, -0.45103228f, -0.14759210f, 
    -0.54376727f, -0.63655472f, 0.02921684f, -0.09707468f, -0.53862238f, -0.11773220f, 0.17437981f, 0.28751233f, 
    0.26571184f, -0.19673884f, 0.16657174f, -0.30922747f, 0.18657102f, 0.15685682f, 0.24717812f, -0.03454468f, 
    0.08977494f, 0.12814678f, -0.14130166f, 0.15731338f, -1.04667497f, -0.10770324f, 0.37310353f, 0.48867247f, 
    0.28803253f, 0.31745240f, -0.21901159f, 0.24836513f, -0.16617365f, -0.27883354f, 0.25957772f, -0.00561405f, 
    0.49482748f, 0.15311040f, -0.06824441f, -0.06537810f, -0.06738731f, -0.14566270f, -0.10639593f, 0.21308753f, 
    -0.09712806f, -0.14437251f, 0.03864030f, -0.11506155f, -0.02875590f, -0.26341709f, -0.55628413f, -0.27129656f, 
    -0.44326165f, -0.38965040f, -0.25237119f, 0.34133056f, 0.61274141f, 0.00551107f, 0.11341464f, -0.10366830f, 
    0.08055130f, -0.44999751f, -0.27697837f, 0.21041819f, 0.28641176f, -0.22173376f, 0.04809264f, -0.24201870f, 
    0.10088499f, -0.09865066f, -0.12291031f, -0.00870797f, 0.09587619f, -0.09107255f, -0.14587867f, 0.08562573f, 
    0.69774532f, 0.30719948f, 0.36077690f, -0.49942607f, 0.22816528f, -0.55696982f, -1.06646895f, -0.05761066f, 
    0.36521631f, 0.27701631f, 0.23065916f, 0.25713596f, -0.20862666f, 0.15561290f, -0.28292972f, 0.30148283f, 
    -0.04102316f, -0.10341426f, 0.09750564f, -0.02497838f, 0.03829030f, 0.03795009f, 0.03407578f, 1.15538979f, 
    0.43298340f, -0.28763083f, 0.59383053f, 0.40559366f, 0.14631198f, 0.13291210f, -0.07303163f, 0.52194923f, 
    -0.18922229f, -0.12024963f, 0.26686826f, -0.20011424f, 0.07217360f, -0.00410761f, -0.04778276f, -0.30022401f, 
    -0.29183435f, -0.18792890f, 0.19104879f, -0.13852839f, 0.07590776f, 0.23322706f, -0.03508588f, -0.26400241f, 
    -0.36694637f, -0.51641709f, -0.05882121f, 0.83588213f, 0.38081589f, 0.60342205f, 0.97636080f, -0.06310884f, 
    0.35271105f, 0.09368596f, -0.02654150f, -0.18881044f, 0.01181381f, 0.15909645f, -0.11750077f, -0.29796040f, 
    -0.29954913f, -0.13647410f, -0.07361609f, -0.12011243f, 0.06276155f, 0.32616770f, 0.13572863f, -0.07626096f, 
    -0.02499210f, -0.54916161f, -0.08084563f, 0.22734076f, -0.62514746f, -0.33416158f, 0.17783485f, -0.34928140f, 
    -0.02657093f, 0.38721794f, 0.50213218f, -0.12046555f, -0.12192933f, -0.11655033f, -0.05003261f, 0.01211130f, 
    -0.05674712f, -0.06189216f, 0.00907428f, 0.49899366f, -0.35882869f, 0.29997507f, 0.41593397f, 0.35702899f, 
    0.24427859f, 0.37066793f, -0.14971900f, -0.78046679f, -0.58210796f, 0.32416269f, 0.06908406f, -0.61824340f, 
    0.38844568f, -0.05258277f, -0.05810388f, 0.33116335f, 0.30530438f, 0.12228899f, 0.25152907f, -0.01554134f, 
    0.09700251f, -0.37916553f, 0.01169285f, 0.16223000f, -0.05690276f, 0.08145977f, 0.30349818f, 0.06554504f, 
    -0.08598074f, -0.01857774f, 0.10592630f, -0.35777175f, 0.83909196f, 0.43304834f, 0.57361645f, -0.80121648f, 
    -0.12210920f, -0.13135479f, -0.47578067f, -0.36162716f, -0.47742015f, 0.22102053f, 0.20044908f, -0.05795000f, 
    -0.09898477f, -0.15043104f, -0.13728756f, 0.02723797f, -0.00512175f, 0.20185512f, -0.14498328f, -0.21182707f, 
    -0.14747076f, -0.07878649f, -0.25391862f, -0.05077850f, 0.73432165f, 0.78042334f, 0.59038585f, 0.61233324f, 
    -0.26414424f, -0.20202860f, -0.02162672f, -0.35964411f, 0.36578971f, 0.07195959f, 0.64271355f, 0.00109499f, 
    -0.09698617f, -0.24061260f, -0.33531034f, -0.04378298f, -0.44089502f, 0.22904024f, -0.10728813f, -0.04897411f, 
    -0.12922969f, 0.33056548f, -0.01232807f, -0.03496432f, 0.09752569f, -0.36345583f, -0.61178863f, -0.47920662f, 
    -0.17533660f, -0.10037716f, 0.45830590f, 0.58309484f, 0.40314788f, -0.16263039f, -0.04591496f, -0.28334281f, 
    -0.15539438f, -0.14422797f, -0.29458269f, -0.04190601f, -0.24729857f, 0.25947842f, 0.18846902f, 0.16108087f, 
    -0.20532675f, 0.01452326f, -0.25903153f, 0.04709478f, 0.05412592f, 0.25920066f, -0.09230936f, -0.71246886f, 
    0.50964528f, 0.60842443f, -0.28811532f, -0.10061669f, 0.10514149f, 0.65064418f, -0.44908533f, -0.27154028f, 
    0.18253052f, -0.17614768f, -0.28062958f, 0.11040433f, -0.04713036f, 0.17254107f, 0.48032093f, 0.08186170f, 
    -0.09987475f, -0.00652604f, 0.25802350f, 0.08418681f, -0.24224494f, -0.05387718f, -0.19879742f, 0.64399713f, 
    -0.03217275f, -0.82694799f, -0.51620960f, 0.07726972f, 0.24916285f, -0.18961397f, 0.24589662f, 0.11788594f, 
    -0.39042205f, -0.40723130f, -0.18690450f, 0.34826642f, 0.00889355f, 0.01377730f, -0.25926793f, -0.16283774f, 
    -0.17194514f, -0.00257452f, 0.04420982f, 0.28576797f, 0.03831697f, 0.09019355f, -0.09268183f, -0.10614573f, 
    0.58252257f, 0.00098822f, -0.22280563f, 0.47112262f, 0.21478273f, 0.53390414f, 0.60725552f, -0.12426659f, 
    0.30916503f, 0.20837796f, -0.14329389f, -0.29924875f, 0.07504956f, -0.26234889f, -0.37725815f, 0.07250907f, 
    -0.07697880f, -0.31471160f, -0.13867311f, -0.19356246f, -0.21283136f, -0.18781152f, 0.04789057f, 0.26789275f, 
    0.19645762f, 0.51018435f, -0.39565241f, 0.57886976f, -0.23063233f, -0.34650084f, -0.62045765f, -0.07866597f, 
    0.08720692f, -0.11639783f, -0.41879722f, -0.21106468f, 0.19303247f, 0.35525185f, 0.18138292f, -0.12485211f, 
    -0.27796111f, 0.18622154f, 0.20648357f, 0.26356882f, 0.19380090f, -0.12896660f, 0.50428748f, -0.31289840f, 
    -0.18964587f, -0.14549083f, -0.27453455f, -0.76283282f, -0.54021478f, -0.47257221f, -0.31611863f, 0.29608485f, 
    -0.01501853f, 0.24578145f, 0.15365201f, 0.42989454f, 0.41535902f, -0.20828396f, 0.27609798f, -0.01079524f, 
    -0.13364390f, 0.17751907f, 0.37511739f, 0.12037943f, 0.35749194f, 0.00663006f, 0.03233873f, -0.36259127f, 
    -0.34802419f, 0.29139555f, 0.09719580f, 0.45510906f, -0.46199724f, 0.10517393f, -0.20388392f, -0.10947460f, 
    -0.31866786f, -0.27199832f, -0.62586075f, -0.15582193f, 0.08517793f, -0.36040634f, 0.22934099f, 0.01256387f, 
    -0.36564347f, -0.20395686f, -0.38054639f, -0.20310220f, 0.01361123f, -0.31778893f, -0.14918824f, 0.22331455f, 
    0.15976496f, -0.07748435f, -0.29676613f, 0.02896330f, -0.20865369f, 0.00014326f, 0.17192832f, 0.60326487f, 
    0.43482506f, 0.01030040f, -0.00201831f, -0.18295172f, 0.45094025f, -0.00120221f, 0.31109649f, 0.15682319f, 
    -0.42644474f, -0.39750123f, -0.26403782f, -0.18055794f, 0.02114751f, -0.31530714f, -0.07466442f, 0.04947514f, 
    0.26066363f, -0.12538254f, -0.08939312f, -0.18708301f, -0.06491214f, -0.21000853f, -0.41770083f, -0.33336803f, 
    -0.10076030f, 0.37735927f, -0.62931883f, -0.52982545f, -0.00965836f, -0.32100907f, 0.26987070f, -0.04232407f, 
    0.06108958f, -0.07031922f, -0.01658578f, -0.13815756f, 0.09266431f, 0.24556489f, 0.60404742f, 0.20973256f, 
    -0.41130534f, -0.09318028f, -0.32301089f, -0.01623435f, -0.07840681f, 0.35488486f, -0.31763300f, -0.55499870f, 
    -0.28905526f, -0.19888267f, 0.11231983f, 0.33144480f, -0.29127449f, 0.25311625f, 0.06104527f, -0.54623222f, 
    -0.12105401f, -0.10897713f, -0.27543259f, 0.02743356f, -0.20586912f, 0.30549258f, -0.05826994f, -0.21756972f, 
    0.30477536f, 0.31189403f, -0.15949781f, -0.11873773f, -0.02054955f, -0.21899648f, -0.13486345f, -0.18132497f, 
    0.69832349f, -0.19591898f, -0.48233384f, 0.26831982f, 0.82456911f, -0.44146222f, -0.66263252f, 0.31436574f, 
    -0.20889589f, 0.05421010f, 0.16468275f, 0.11185759f, 0.15900934f, -0.13259736f, -0.00394998f, -0.02015063f, 
    0.08464978f, 0.14040118f, 0.11369922f, 0.40205067f, 0.22328907f, -0.01311238f, -0.09419429f, -0.05330040f, 
    0.02533971f, -0.23209967f, -0.39468133f, -0.36788228f, 0.01036734f, 0.25838926f, -0.93254381f, -0.06217289f, 
    0.33408219f, -0.08135653f, -0.30481464f, -0.11553065f, 0.31543711f, 0.23170781f, -0.22178587f, 0.14294450f, 
    0.34559309f, 0.17940903f, -0.04569568f, -0.06447588f, -0.23314925f, -0.08191095f, 0.05920859f, 0.18987717f, 
    -0.18309343f, -1.00940871f, 0.60253382f, -0.00989532f, -0.70713049f, -0.09058620f, 0.25379211f, 0.68839324f, 
    0.33425048f, 0.29223874f, 0.41441610f, 0.25312719f, -0.11034936f, 0.09885564f, -0.38627842f, -0.21572973f, 
    0.29512173f, 0.14223370f, -0.08398260f, 0.02742929f, -0.11853431f, -0.00947761f, -0.11089041f, -0.10146700f, 
    -0.05161961f, -0.00110583f, 0.86822027f, 0.54679561f, -0.00694834f, -0.53105456f, -0.35382551f, -0.21489279f, 
    0.50677305f, -0.13255656f, 0.41945785f, 0.47564670f, -0.09313972f, 0.33920971f, -0.02318476f, -0.03414114f, 
    0.33211318f, 0.02036482f, 0.25195673f, 0.10994761f, -0.04717858f, 0.17576528f, -0.22552343f, 0.22175656f, 
    -0.16473304f, 0.01137491f, -0.09092713f, 0.31340966f, 0.63453853f, 0.03459070f, 0.50370640f, 0.06722021f, 
    0.17375053f, 0.42442304f, 0.14914374f, 0.24399059f, 0.35809797f, -0.09434905f, 0.26023760f, 0.27238211f, 
    -0.55423838f, -0.10663021f, 0.04823573f, 0.09070626f, -0.00395429f, 0.13187644f, 0.12423006f, -0.21285875f, 
    -0.21360333f, -0.31807500f, -0.04802043f, 0.20551707f, 0.67212743f, 0.26303965f, 0.17489025f, 0.82811564f, 
    0.52571583f, 0.43867511f, 0.32688123f, 0.16867299f, 0.13776931f, 0.15755834f, -0.39164752f, 0.06203146f, 
    -0.09878965f, 0.30851534f, 0.04631313f, -0.24884413f, -0.05804418f, 0.08507018f, -0.08767983f, -0.06826852f, 
    0.06425931f, -0.14120507f, -0.17373271f, -0.12300353f, -0.07475727f, 0.82205379f, 0.47800803f, 0.22649516f, 
    0.52724856f, 0.13785493f, -0.09664645f, -0.04722867f, -0.58646327f, -0.38913301f, 0.04981335f, -0.01090500f, 
    0.15087034f, 0.20074944f, 0.14850493f, 0.22281554f, 0.15967722f, 0.12234838f, 0.35464990f, -0.03371019f, 
    0.02066369f, 0.15160741f, -0.07334997f, 0.41837883f, 0.13921961f, 0.03721066f, -0.49046084f, -0.17471410f, 
    0.47223255f, -0.36250326f, -0.24267747f, 0.53649718f, 0.39526516f, 0.10246167f, 0.17863612f, -0.15445216f, 
    -0.25539705f, -0.26778129f, 0.13877255f, -0.00516707f, -0.34198233f, -0.16148184f, -0.32306993f, -0.20136234f, 
    -0.28064546f, 0.12270377f, -0.58916253f, 0.09675986f, -0.17430396f, 0.24342817f, -0.04573515f, 0.10440016f, 
    -0.25868472f, -0.09427635f, 0.29168859f, 0.39132336f, -0.31664142f, -0.75251907f, -0.51450628f, -0.41875836f, 
    -0.20083211f, -0.56805146f, 0.45959714f, 0.21798728f, 0.05074545f, -0.24684905f, 0.17520982f, -0.05822942f, 
    0.16377449f, 0.11958838f, -0.25494805f, 0.18663265f, 0.00641500f, 0.01269246f, -0.06220571f, 0.07452188f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01630505f, -0.05357527f, 0.16740409f, 0.21180710f, 0.03736588f, 0.18869050f, 0.10830723f, 0.28875059f, 
    0.14941575f, -0.10014797f, 0.13693629f, 0.00870913f, 0.05385489f, -0.00631348f, -0.02314000f, 0.04050066f, 
    0.08499881f, 0.26080322f, -0.05641740f, 0.07151292f, 0.10302047f, 0.25548753f, 0.05590179f, 0.20779228f, 
    0.25169027f, 0.02971847f, -0.00120136f, 0.24760193f, -0.03408831f, 0.25904149f, -0.01324176f, 0.18878238f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05054638f, 0.03930402f, 0.03931934f, -0.04454234f, -0.00848610f, -0.05609908f, 0.01055948f, -0.03815138f, 
    -0.05037453f, -0.04359303f, -0.03302114f, 0.01786426f, -0.02296833f, -0.00586151f, -0.03118340f, 0.03808375f, 
    -0.00214485f, 0.01930683f, 0.02031720f, -0.03442650f, 0.00352576f, -0.05773722f, -0.00618831f, -0.00547797f, 
    -0.03894525f, -0.02009073f, 0.00178742f, -0.00508810f, 0.03906972f, -0.00030029f, -0.04954179f, 0.02133872f, 
    -0.03822557f, 0.00404427f, 0.01671384f, 0.04071370f, -0.03557061f, 0.04019596f, -0.00541941f, -0.03849895f, 
    -0.03195649f, 0.03348729f, 0.04272385f, 0.00000284f, 0.00962758f, 0.00703522f, 0.04249493f, 0.01059152f, 
    -0.02472325f, 0.03632637f, 0.03096214f, 0.00082818f, 0.03655255f, 0.02676498f, 0.02151540f, -0.02891720f, 
    -0.05169307f, 0.02655107f, -0.01377808f, -0.03791120f, -0.01033308f, 0.02130295f, 0.02559132f, -0.03486733f, 
    0.03010941f, 0.03617514f, -0.00255525f, 0.01029047f, 0.02944496f, -0.04519580f, -0.02407223f, -0.02193875f, 
    -0.05108099f, -0.03342510f, 0.02144962f, 0.01972469f, 0.04192404f, -0.05374953f, -0.03137369f, 0.00382247f, 
    0.03261336f, -0.05641138f, -0.02282024f, -0.01259751f, -0.03184459f, 0.02044877f, 0.02858620f, -0.00880066f, 
    -0.05437673f, 0.03258425f, -0.02179323f, -0.00199479f, -0.04901717f, -0.04474387f, -0.05084083f, 0.02411811f, 
    -0.02110014f, -0.03101900f, -0.01662912f, 0.00473252f, -0.01873426f, 0.00528026f, 0.03876988f, 0.01214429f, 
    -0.01789906f, 0.02521602f, 0.01697353f, 0.02348569f, -0.01613814f, -0.02925735f, -0.01465209f, 0.01868200f, 
    0.01528080f, -0.01908710f, -0.02992802f, -0.03139815f, 0.01587573f, -0.05173373f, -0.00372254f, -0.04234692f, 
    -0.05105014f, -0.05182084f, 0.02139080f, -0.00609796f, -0.05592247f, 0.03484686f, -0.00162518f, -0.04876641f, 
    0.02008867f, -0.02073751f, -0.03318904f, 0.03451418f, -0.02428137f, 0.02458806f, -0.05715875f, -0.04071550f, 
    0.01577444f, 0.01789340f, 0.03145693f, -0.01590170f, -0.03759541f, -0.00887415f, 0.03384438f, 0.01641118f, 
    -0.02493994f, -0.03356508f, -0.01783627f, 0.04143015f, 0.01907633f, -0.02569749f, 0.02396161f, 0.00960947f, 
    -0.00930605f, 0.01788529f, 0.03830542f, 0.01400322f, -0.02566289f, 0.03224652f, -0.05369165f, -0.04576576f, 
    0.03470924f, 0.02568924f, 0.01830373f, -0.01693606f, -0.01464015f, -0.02836699f, -0.05492267f, -0.04098887f, 
    0.02054792f, 0.00897835f, -0.04431506f, -0.03773071f, 0.01070267f, -0.01306948f, -0.02453619f, -0.05669799f, 
    -0.05486457f, -0.03790003f, -0.03286448f, -0.02956883f, -0.04852253f, -0.01443020f, 0.01279150f, 0.00891016f, 
    -0.02112040f, 0.02314338f, -0.03532806f, -0.02839244f, -0.00995035f, -0.01644545f, -0.02978609f, 0.01149977f, 
    0.02248917f, 0.02550328f, 0.00526588f, -0.02281350f, -0.03749302f, -0.00283635f, -0.01416854f, -0.05415836f, 
    0.02440128f, 0.02333528f, 0.00184354f, 0.00267659f, -0.01040918f, 0.03253475f, 0.01582887f, -0.01882452f, 
    0.00940749f, -0.03914224f, -0.05369410f, 0.03539785f, 0.03833703f, -0.04992887f, -0.01341382f, 0.04197964f, 
    0.02835127f, 0.03032750f, -0.04987621f, 0.03400481f, -0.03177708f, -0.00305648f, -0.01443689f, -0.02532613f, 
    -0.00328574f, 0.04017424f, -0.01731826f, 0.03776070f, 0.02208727f, 0.03109362f, -0.05295391f, -0.00297511f, 
    -0.04524540f, 0.01018249f, 0.00097813f, -0.03159354f, -0.00445388f, -0.00813244f, 0.00214464f, 0.04006240f, 
    -0.03688876f, 0.00612814f, 0.03406994f, -0.03256449f, -0.01111471f, -0.05371813f, -0.04518259f, 0.01421777f, 
    0.03163553f, 0.00565663f, -0.04848177f, -0.03665220f, 0.02128051f, -0.00206284f, -0.03888076f, -0.04465731f, 
    0.00525216f, -0.05216366f, 0.00934058f, -0.00044919f, 0.03221679f, 0.01570284f, 0.01512456f, -0.01808910f, 
    0.02151369f, -0.02260947f, 0.01916624f, -0.03309091f, 0.03076888f, 0.03276559f, -0.01321609f, -0.04882989f, 
    0.04592764f, 0.02222027f, -0.00166647f, 0.01958647f, -0.00777763f, 0.03075232f, -0.02553442f, -0.02428448f, 
    -0.02943688f, 0.00305239f, -0.05583809f, -0.03632924f, 0.00558245f, -0.04222997f, -0.02068205f, 0.00064113f, 
    -0.02623970f, 0.01297290f, -0.04884401f, 0.01268358f, -0.05824066f, -0.03949869f, 0.04458721f, -0.03030547f, 
    -0.00293348f, -0.05120116f, -0.02913924f, -0.00916596f, -0.03141318f, 0.03521792f, 0.03026610f, -0.00733818f, 
    0.03253467f, -0.01351996f, 0.02045978f, 0.00807378f, 0.03596622f, 0.04100662f, -0.05558885f, 0.01896801f, 
    -0.00597692f, 0.01697501f, 0.02141648f, -0.01198686f, -0.04336656f, 0.02416209f, -0.04205539f, -0.00346854f, 
    -0.01984411f, 0.02673806f, -0.03988507f, -0.01697890f, 0.00815545f, -0.05335587f, 0.01107264f, -0.03081512f, 
    -0.05722686f, -0.04418604f, -0.05645932f, 0.01318536f, -0.02757231f, -0.00648360f, -0.05445611f, -0.00775946f, 
    0.04212803f, 0.01879616f, -0.00065036f, 0.03516136f, -0.01345988f, 0.02177739f, -0.05816839f, 0.01183601f, 
    -0.03359773f, -0.03923042f, 0.00926499f, -0.02888155f, -0.04569284f, -0.02569488f, -0.04703507f, -0.03373615f, 
    -0.02447820f, -0.02272618f, -0.00940732f, -0.03151849f, -0.03155009f, -0.05562148f, 0.00084896f, -0.02934762f, 
    0.02953523f, -0.00564262f, 0.01585663f, 0.03245003f, -0.02735155f, -0.02654395f, 0.00500855f, 0.01890389f, 
    -0.01508853f, -0.05752505f, 0.01528470f, -0.04969280f, -0.00005169f, -0.00126397f, 0.03455356f, 0.00637436f, 
    0.00126037f, -0.02994148f, 0.00739916f, -0.02003920f, 0.03347993f, 0.03517441f, 0.03679278f, 0.01929084f, 
    0.01789577f, -0.03499679f, -0.02437480f, -0.05312895f, 0.00037873f, -0.01281355f, -0.01123126f, -0.03560822f, 
    0.00043346f, -0.03476920f, -0.03195740f, -0.05316762f, -0.04618997f, -0.03615667f, 0.00997875f, -0.00026704f, 
    -0.04589697f, -0.01886585f, 0.02932691f, -0.01006267f, 0.00979440f, 0.01126441f, -0.00721226f, 0.03961172f, 
    -0.00868454f, 0.01108652f, -0.04171297f, -0.03022678f, 0.03943828f, -0.04058888f, 0.01354507f, -0.02485318f, 
    -0.04408931f, -0.02192913f, -0.04469074f, 0.03269520f, -0.02224026f, 0.03121338f, -0.01238909f, -0.00469743f, 
    0.00558629f, -0.00170710f, -0.02034065f, 0.04311834f, -0.05225841f, 0.04277863f, -0.05282637f, -0.02502365f, 
    0.01947069f, -0.02641215f, 0.02624649f, 0.04405741f, -0.00418898f, -0.04485735f, 0.02812537f, 0.04213170f, 
    0.01790727f, 0.01507117f, 0.01776225f, 0.03352944f, -0.01098422f, -0.04243576f, 0.02690543f, 0.00509297f, 
    0.01022770f, 0.00069061f, -0.04613284f, 0.03675191f, -0.00869663f, -0.00068700f, 0.03359041f, -0.04237672f, 
    -0.04261738f, -0.04031576f, -0.03531097f, -0.04847093f, 0.01131522f, -0.04296355f, -0.04865719f, 0.03098981f, 
    -0.05170759f, 0.00166892f, -0.05332970f, -0.01632448f, -0.02801079f, -0.00786863f, 0.02859355f, 0.04279517f, 
    -0.00557138f, 0.03319827f, -0.03972906f, -0.04939045f, 0.01410888f, 0.03068426f, 0.01470403f, 0.03817336f, 
    -0.00945606f, -0.03324875f, 0.00513525f, -0.02347302f, 0.02392230f, -0.00997168f, 0.02554264f, -0.04496276f, 
    -0.02480227f, -0.03047760f, 0.03591015f, -0.01290383f, -0.04178318f, 0.00232716f, 0.01433792f, -0.05588690f, 
    -0.04277562f, -0.00582554f, 0.04272386f, -0.02488657f, 0.02407495f, 0.02699106f, 0.03962338f, 0.00425707f, 
    -0.04621499f, 0.01684851f, -0.01596833f, -0.03918751f, -0.04398520f, -0.03366961f, -0.04874644f, -0.00925759f, 
    0.03543360f, -0.04694403f, 0.01524194f, 0.01198865f, 0.03295363f, -0.04391058f, 0.01373977f, 0.04082965f, 
    -0.05437740f, -0.02525753f, -0.03239012f, -0.01344873f, -0.00048131f, -0.04739519f, 0.03203381f, -0.04729469f, 
    0.04029978f, -0.03717348f, 0.00338869f, 0.01818777f, -0.03620882f, 0.03999871f, -0.04535113f, -0.01607167f, 
    0.03371710f, 0.01675230f, -0.02934955f, -0.05110807f, -0.03011357f, -0.00814103f, -0.03203953f, -0.03903996f, 
    -0.02664478f, -0.00872532f, -0.00111369f, -0.03440549f, 0.02081596f, -0.04276944f, 0.00365714f, -0.00842480f, 
    0.04026319f, 0.03102231f, -0.00925193f, -0.00096098f, -0.05214669f, -0.01890292f, 0.02876783f, -0.04176236f, 
    -0.03279613f, -0.03095923f, -0.02451397f, -0.05343664f, 0.03705110f, -0.03156851f, 0.02730379f, -0.05123174f, 
    -0.03924422f, 0.01883391f, -0.03222487f, -0.04436738f, -0.00941951f, 0.01220844f, 0.02970120f, -0.03302938f, 
    -0.03619532f, 0.03443714f, -0.00040047f, -0.01089261f, -0.01328314f, -0.04611180f, -0.00363129f, -0.05368169f, 
    -0.02697703f, -0.00859756f, -0.02194415f, -0.03930540f, -0.02499356f, 0.02662615f, -0.02569463f, 0.00397517f, 
    0.04394841f, -0.04693726f, 0.01259249f, -0.00607777f, -0.02909641f, 0.03821155f, -0.01461344f, -0.02821760f, 
    0.02478465f, 0.00865498f, 0.01126622f, 0.02760084f, 0.03205545f, 0.01284065f, -0.04350813f, -0.04284125f, 
    0.01330041f, -0.00843867f, -0.05357407f, -0.05332060f, 0.00588434f, -0.00457218f, 0.02475995f, 0.00642219f, 
    0.01238350f, -0.01550294f, -0.04452549f, -0.00384081f, 0.00566380f, -0.02110361f, 0.04363739f, -0.01864018f, 
    -0.03040307f, -0.01855807f, -0.02871578f, 0.00423670f, -0.01208927f, 0.04480155f, -0.00500099f, 0.00908841f, 
    -0.00291273f, 0.03479406f, -0.03032579f, 0.02474975f, -0.04456692f, 0.01577000f, -0.02421293f, 0.01568018f, 
    0.01101909f, -0.03597470f, 0.01095501f, -0.02243134f, 0.03176974f, -0.04636095f, 0.02164418f, 0.03864150f, 
    -0.02441651f, 0.01323458f, -0.00527532f, 0.04365272f, 0.01654864f, -0.01493449f, 0.01833444f, -0.01616561f, 
    -0.01178102f, 0.02673552f, -0.00839437f, 0.02442637f, -0.01389275f, -0.04314962f, 0.02341170f, -0.02609004f, 
    -0.02477697f, -0.00736476f, -0.04779850f, -0.00268552f, 0.04049017f, 0.00876971f, -0.04946218f, -0.04596579f, 
    -0.04585762f, -0.02215588f, -0.05392852f, 0.02274383f, -0.02015029f, 0.01213421f, 0.03053914f, -0.02982056f, 
    0.02240894f, -0.05040336f, -0.01332422f, -0.03716627f, 0.04097623f, -0.02212257f, -0.04156239f, -0.03092035f, 
    0.03163254f, -0.00535493f, 0.04303394f, -0.00262233f, -0.03786248f, -0.00308952f, -0.01041241f, 0.03347470f, 
    -0.02904038f, -0.05425205f, 0.02640882f, -0.04857988f, 0.01104310f, 0.04438583f, -0.02887458f, -0.02501079f, 
    -0.04064234f, -0.02225951f, 0.03164009f, -0.02257284f, 0.02891331f, 0.01690124f, -0.01170675f, 0.00910988f, 
    -0.04356411f, -0.04118621f, 0.00328513f, -0.04750764f, 0.03983084f, -0.03037654f, 0.00796723f, -0.03947249f, 
    0.04400249f, -0.04533014f, 0.02935364f, -0.03825836f, -0.02193125f, 0.00041894f, 0.03187326f, -0.02452906f, 
    0.02647028f, -0.00058561f, -0.02581633f, -0.01313232f, 0.01706214f, 0.01237930f, -0.03916351f, -0.04293212f, 
    0.00333168f, 0.01549236f, 0.01385314f, -0.01402439f, -0.05284836f, 0.02667452f, 0.01894922f, 0.00072721f, 
    -0.03355457f, -0.02251252f, -0.02503911f, 0.00037154f, 0.04416567f, -0.00706540f, -0.02745989f, -0.01845000f, 
    0.02608673f, -0.03051667f, -0.03612901f, -0.00426554f, 0.03370036f, -0.01596063f, -0.04176820f, -0.01078591f, 
    -0.05343134f, -0.03505879f, 0.04298409f, -0.01852838f, 0.01547926f, 0.02681611f, -0.01168346f, -0.00092169f, 
    -0.20167091f, -0.01388748f, 0.15264754f, 0.10008316f, 0.20353788f, -0.00133614f, 0.02912098f, 0.12637213f, 
    0.00895156f, -0.04804895f, -0.04283156f, 0.13021585f, -0.00692111f, 0.01480583f, 0.14944609f, 0.22080182f, 
    -0.18114224f, -0.10759816f, 0.00547670f, -0.00029135f, 0.03015639f, 0.04640263f, 0.05256172f, 0.07260656f, 
    0.05752973f, 0.12035130f, 0.01194460f, 0.28461298f, 0.05430420f, 0.04407716f, 0.12588833f, -0.04073101f, 
    0.04632517f, 0.07197881f, 0.01058547f, -0.09309836f, 0.05039297f, 0.26749778f, -0.04691790f, 0.18793005f, 
    -0.03464507f, -0.17224790f, -0.10868227f, -0.18352067f, -0.03546620f, -0.22690479f, -0.01029362f, 0.18329607f, 
    -0.42085657f, -0.49150231f, 0.10743356f, -0.16769433f, -0.07721405f, 0.12949601f, 0.06933746f, -0.07070377f, 
    0.01808057f, -0.04021351f, 0.01851164f, 0.04604013f, -0.22932523f, 0.00877963f, -0.03454673f, -0.06017220f, 
    0.12072396f, 0.12416220f, 0.03969758f, 0.00300579f, -0.01608441f, 0.13255116f, -0.17307577f, 0.03380137f, 
    0.03517896f, -0.31807840f, 0.21828525f, 0.24245849f, -0.24064000f, -0.07015033f, 0.05757068f, -0.05188304f, 
    -0.09191383f, -0.06121232f, 0.07208940f, 0.15597740f, 0.35023871f, 0.00406548f, 0.22427423f, 0.13425136f, 
    -0.01375302f, -0.03193884f, -0.02958294f, 0.00660056f, -0.12539853f, 0.04400153f, -0.10850323f, 0.01238795f, 
    -0.47409311f, 0.19445090f, 0.13693742f, -0.28100422f, 0.01503052f, 0.05040463f, 0.15612993f, 0.04902227f, 
    0.06092922f, 0.00345836f, 0.02838377f, -0.15830134f, 0.26015249f, 0.01583813f, -0.34349641f, 0.22664747f, 
    0.19386064f, 0.11334199f, 0.14156428f, 0.08323053f, 0.00650206f, -0.03262904f, -0.02478131f, -0.10421944f, 
    -0.39471415f, 0.10328803f, -0.01542960f, -0.13818170f, 0.00608457f, 0.05019490f, -0.12368622f, 0.11164609f, 
    0.12101346f, 0.04174940f, 0.03344848f, -0.07606308f, -0.12723641f, -0.04247772f, 0.23998837f, 0.08333670f, 
    -0.07472265f, 0.01295040f, 0.05049654f, 0.07205275f, 0.10864342f, 0.01373023f, -0.01015301f, 0.10028194f, 
    -0.01067751f, 0.08894596f, 0.01468428f, 0.22813416f, -0.02738740f, -0.06102782f, -0.01544409f, 0.01543655f, 
    0.02370033f, -0.19233307f, 0.09495608f, 0.01975129f, -0.31042087f, 0.41911003f, 0.12496700f, -0.20167626f, 
    0.16397761f, 0.14423285f, 0.02405099f, 0.07495978f, 0.08527573f, -0.09155949f, 0.01284750f, -0.03072575f, 
    -0.40312782f, 0.00778491f, -0.01421763f, 0.05809298f, -0.05035684f, -0.03330467f, -0.06219712f, 0.03284625f, 
    0.05373573f, 0.07427831f, -0.05537046f, 0.00118735f, 0.39441615f, -0.10496103f, -0.20544370f, -0.28071025f, 
    0.09816772f, 0.15852123f, 0.03173791f, -0.00525669f, 0.06058170f, -0.01031431f, 0.06031976f, -0.11596792f, 
    0.23186475f, 0.12067521f, 0.12242513f, -0.07248378f, -0.09072997f, 0.07752801f, 0.07748380f, 0.02577484f, 
    0.00371625f, -0.02811393f, -0.13606428f, -0.01380387f, -0.02513740f, -0.24720030f, 0.12376115f, 0.18522611f, 
    0.01078696f, -0.02324800f, -0.11195818f, -0.04670772f, 0.08759948f, -0.02485769f, 0.18545546f, -0.04319267f, 
    -0.22808395f, 0.05592124f, -0.21937084f, 0.13107617f, 0.24911761f, 0.17199577f, -0.10804532f, 0.03854617f, 
    0.12550183f, 0.01649715f, 0.08014651f, 0.09295954f, 0.13398580f, -0.23744990f, 0.14925708f, 0.26383111f, 
    0.07008989f, -0.06907638f, -0.03474314f, 0.06813795f, 0.00916700f, -0.09918101f, 0.00475148f, -0.14952956f, 
    0.13474910f, -0.04932209f, 0.14923185f, -0.19045192f, 0.04045140f, -0.05912094f, -0.02846335f, 0.06069816f, 
    0.10637292f, 0.02409566f, -0.07779833f, 0.01767019f, -0.07851630f, -0.17918412f, -0.03135468f, -0.04026949f, 
    0.10441708f, 0.10613669f, -0.22916587f, 0.08789489f, 0.10704119f, -0.05161916f, 0.02565957f, 0.05258118f, 
    -0.05110632f, 0.16587478f, 0.06192994f, -0.12349267f, 0.18443920f, -0.03803206f, 0.09699263f, -0.19194067f, 
    0.06125890f, 0.02733232f, -0.09548436f, -0.12839463f, -0.03426136f, -0.13502039f, -0.06282632f, 0.05117247f, 
    0.01739142f, -0.08873419f, 0.07657218f, -0.05453338f, -0.01438386f, 0.07853575f, -0.00821172f, 0.19124064f, 
    0.20096630f, -0.18849036f, 0.07400397f, -0.00247218f, 0.03855142f, 0.04216065f, 0.08795028f, -0.15826100f, 
    0.04214645f, -0.09809756f, 0.02805685f, -0.02177566f, 0.00217272f, 0.22780192f, 0.06772276f, 0.09807165f, 
    0.05361437f, 0.01016227f, 0.02787769f, -0.20335692f, 0.16049193f, 0.01407770f, 0.00040859f, 0.03777024f, 
    0.18322614f, 0.00205516f, -0.08048582f, -0.17918393f, -0.05163200f, -0.13143072f, -0.09046550f, -0.01089271f, 
    -0.09803918f, 0.02290915f, 0.01350599f, -0.00590156f, 0.10034211f, 0.16727966f, 0.19722325f, -0.06422250f, 
    -0.01152843f, -0.02232355f, 0.03262952f, 0.01299602f, -0.08914122f, -0.00692545f, 0.13683279f, 0.02171960f, 
    0.40353966f, 0.02193470f, 0.37449849f, 0.26866153f, -0.00828401f, 0.01537943f, -0.01081804f, 0.05422184f, 
    -0.10604834f, 0.01612540f, 0.02096546f, 0.02663502f, 0.21097560f, 0.15075880f, 0.26000917f, 0.14992082f, 
    -0.17550451f, -0.12945771f, 0.10234774f, 0.07101002f, 0.08066241f, 0.03765781f, 0.13545468f, 0.15121445f, 
    -0.06985160f, 0.18068592f, -0.06328015f, 0.11088004f, -0.02776138f, 0.09791704f, 0.12552494f, -0.20334812f, 
    -0.22984584f, -0.06779216f, -0.07917695f, -0.12452128f, 0.17766045f, -0.23081568f, 0.06460988f, 0.14639685f, 
    -0.01776952f, -0.11249746f, -0.02785082f, 0.01173536f, -0.05249771f, -0.02045654f, 0.21927930f, 0.13790613f, 
    -0.03648514f, -0.09395114f, -0.08383516f, 0.09385269f, 0.10111072f, 0.01896631f, 0.03410242f, -0.01382704f, 
    -0.02781941f, 0.10302973f, 0.13190843f, 0.04702910f, 0.22665551f, -0.03765858f, 0.11976682f, 0.03513029f, 
    0.01543652f, -0.11700948f, -0.00359594f, -0.03207168f, -0.04141835f, -0.06044210f, 0.15182838f, 0.13294439f, 
    0.11502801f, -0.09531704f, -0.07028054f, -0.11877029f, 0.03386721f, 0.01639697f, -0.05684425f, 0.01328085f, 
    -0.01881336f, 0.08464389f, 0.02576739f, 0.13293949f, -0.15506153f, -0.28517115f, 0.21127792f, 0.05977558f, 
    0.00628324f, 0.14139856f, 0.09895445f, 0.17278284f, -0.06844766f, 0.16020384f, 0.03152766f, 0.17717747f, 
    0.04947202f, 0.36945188f, -0.09430952f, 0.11137757f, 0.19475527f, 0.14984588f, -0.05097595f, 0.00368043f, 
    -0.07250255f, 0.04007346f, 0.02439803f, -0.03142470f, -0.01290891f, 0.01805374f, -0.28727567f, -0.11869180f, 
    0.12998512f, 0.00405438f, 0.10898733f, 0.08159637f, 0.02036086f, -0.01512960f, 0.03794934f, -0.03802613f, 
    0.23471439f, 0.29139146f, 0.03025044f, -0.15260667f, 0.09159735f, 0.09764829f, -0.02672271f, 0.04991489f, 
    -0.03523945f, 0.09009841f, -0.02634382f, 0.00293660f, 0.11208296f, 0.18515544f, 0.08599344f, -0.01973174f, 
    0.07026365f, 0.03697515f, 0.12602042f, -0.07090401f, 0.02360035f, 0.12583129f, 0.02377362f, 0.11370657f, 
    0.11385852f, -0.00746943f, -0.02023904f, 0.06851673f, 0.16944592f, 0.06980684f, 0.04487016f, -0.10295092f, 
    -0.06420390f, 0.05249827f, 0.02111682f, 0.08562544f, -0.38508761f, -0.14030835f, 0.00593473f, -0.16503160f, 
    0.03692162f, 0.04659508f, -0.12081362f, 0.01205001f, 0.08108317f, 0.04227300f, 0.05533627f, 0.11390500f, 
    0.13842432f, -0.25465962f, -0.17894551f, -0.01755930f, 0.27278638f, -0.01553800f, 0.10225730f, -0.00557413f, 
    -0.02931171f, -0.07302016f, 0.11825901f, 0.05702621f, 0.10229831f, 0.06427173f, -0.12503704f, 0.08328437f, 
    -0.03363362f, 0.19428009f, -0.09257023f, 0.01440832f, -0.03263674f, -0.02815240f, 0.14695354f, 0.09821109f, 
    0.54538167f, 0.04136541f, 0.13438861f, 0.12321912f, -0.09336536f, -0.04229429f, 0.09689233f, 0.07291210f, 
    -0.01173536f, -0.01023457f, 0.00579131f, 0.01459477f, 0.20970795f, -0.02923740f, -0.33457404f, 0.02623083f, 
    0.17617175f, 0.12018149f, -0.05808581f, -0.04168789f, 0.16270117f, -0.10011902f, 0.07148053f, -0.03806393f, 
    -0.01549681f, 0.18161151f, -0.22190535f, 0.22948991f, 0.00624800f, -0.07037324f, -0.08467263f, 0.00156774f, 
    0.05336552f, 0.03261182f, -0.07883863f, -0.02272469f, -0.11815581f, -0.16565375f, 0.33489433f, 0.06130812f, 
    0.06108714f, -0.17132285f, -0.01651745f, 0.10697470f, 0.13742758f, -0.06018975f, 0.01691197f, 0.10634866f, 
    0.11218572f, -0.01071329f, 0.06407588f, 0.03205553f, 0.16822952f, 0.05323547f, -0.00284446f, 0.00340046f, 
    0.19413270f, 0.20873447f, 0.06389655f, 0.00078654f, 0.01749186f, 0.10192102f, -0.04769141f, 0.15498886f, 
    0.01508648f, -0.02005543f, 0.04623563f, 0.02518027f, 0.06204355f, 0.01573844f, -0.05590520f, 0.07953062f, 
    0.20900002f, -0.14286773f, -0.05990893f, -0.20860393f, 0.08059836f, 0.02464873f, 0.14430761f, 0.10080268f, 
    0.06042517f, 0.01918977f, 0.01620555f, -0.00480069f, 0.07299904f, 0.10746542f, 0.01486649f, -0.08831995f, 
    0.12977630f, 0.07756229f, 0.13124810f, 0.10855380f, 0.02438401f, -0.05444802f, 0.10405212f, -0.02260573f, 
    -0.07278243f, 0.02852957f, -0.05956049f, 0.13931330f, 0.08594156f, 0.05762969f, 0.13105923f, 0.04282217f, 
    -0.02544098f, 0.06059111f, 0.00550178f, -0.01445618f, 0.11324259f, 0.12741074f, -0.08942120f, 0.04466230f, 
    0.08155092f, 0.06880749f, 0.14651915f, 0.02122986f, -0.08680081f, -0.06238709f, 0.05815864f, -0.05852026f, 
    0.19672908f, -0.00714187f, -0.19758788f, 0.21602567f, 0.06489211f, 0.15371375f, 0.03616102f, 0.11100268f, 
    -0.15015472f, 0.21807291f, -0.00423073f, 0.12486569f, -0.27249333f, -0.20448501f, 0.36627686f, -0.01028353f, 
    -0.00010361f, 0.06599890f, 0.02341525f, -0.01357182f, 0.03713548f, 0.02099949f, 0.00161851f, -0.10740380f, 
    -0.27123764f, -0.01290983f, 0.04444931f, -0.03225393f, 0.02272942f, -0.01891711f, 0.13382168f, 0.20748590f, 
    0.14872605f, -0.04663112f, 0.01338383f, 0.02366968f, -0.10970470f, -0.34654990f, -0.14052533f, -0.28369930f, 
    0.04095002f, 0.19217815f, -0.02842336f, 0.11887281f, 0.02477189f, 0.08776740f, -0.00948206f, -0.07987043f, 
    0.68799460f, 0.05669621f, 0.14271373f, -0.16410667f, 0.07917643f, -0.00269561f, 0.22926028f, 0.00235138f, 
    -0.11013050f, 0.08154634f, -0.12238392f, 0.03257075f, 0.37814939f, 0.09564438f, 0.08606285f, 0.08054382f, 
    0.01968040f, 0.15671150f, -0.00047302f, -0.03745290f, 0.05725888f, -0.00889689f, 0.09275821f, 0.05765462f, 
    0.01778895f, 0.28313649f, 0.06943477f, -0.07571544f, -0.01509214f, 0.07968479f, -0.01571001f, 0.00103640f, 
    0.17578095f, -0.06533424f, -0.02113887f, 0.11916512f, 0.31644994f, 0.18909837f, 0.07110051f, 0.02510953f, 
    0.09048338f, 0.08522719f, 0.06846073f, -0.04820705f, 0.00903825f, -0.07478277f, -0.07232577f, 0.05635007f, 
    -0.32674384f, -0.19864462f, 0.01705730f, 0.01572697f, 0.08595197f, 0.05498896f, -0.07370855f, 0.01746750f, 
    0.10882159f, 0.08918051f, 0.18214934f, 0.05722044f, -0.23830418f, 0.10415340f, -0.16184820f, -0.01785837f, 
    0.07788280f, 0.04054505f, 0.16070664f, 0.01419791f, 0.00097967f, 0.00253444f, 0.00254721f, 0.11083879f, 
    -0.03528260f, 0.01607546f, 0.00962239f, -0.00640755f, 0.03215038f, -0.04321568f, -0.02296626f, 0.00634028f, 
    0.00495344f, 0.03893306f, 0.03932676f, 0.03288761f, -0.05133663f, -0.03378445f, 0.02869214f, -0.04134234f, 
    -0.02973018f, -0.00597926f, 0.00325424f, -0.01561043f, 0.01138824f, 0.03475769f, 0.04513824f, 0.03064320f, 
    0.03791431f, -0.03296717f, -0.03651343f, 0.00112745f, -0.03669595f, -0.04608878f, 0.04314500f, 0.03097987f, 
    -0.00654484f, -0.02363866f, 0.02595212f, -0.02773421f, -0.03145460f, 0.00711237f, -0.03584385f, 0.00576493f, 
    -0.01333965f, -0.04100521f, 0.00780494f, 0.01140194f, -0.00366690f, 0.01835022f, 0.02471831f, -0.04855888f, 
    0.04052382f, -0.00260743f, 0.02592699f, -0.04132224f, 0.00706300f, -0.02583792f, -0.02813251f, -0.03081316f, 
    0.00648939f, 0.00564028f, 0.01738848f, 0.00682481f, -0.03864177f, -0.03239438f, 0.03406573f, -0.01123010f, 
    -0.03355004f, -0.04803286f, 0.02082207f, 0.00706143f, 0.04095141f, -0.04230719f, -0.00836697f, -0.04463142f, 
    0.00310596f, 0.04350674f, -0.01691767f, 0.03172227f, 0.04120957f, -0.05351450f, -0.05409761f, -0.03212224f, 
    0.01089329f, -0.02470434f, 0.00978080f, 0.00535904f, -0.00502625f, -0.03342548f, -0.04111930f, -0.02266505f, 
    -0.05553246f, 0.02033262f, -0.03682740f, -0.04235094f, -0.00029177f, -0.03545231f, 0.02641130f, -0.00720566f, 
    0.01483120f, -0.02688920f, -0.00696490f, -0.05094900f, -0.04303146f, 0.03864541f, -0.04823345f, -0.04968575f, 
    -0.04628245f, -0.00924524f, -0.01925121f, 0.01727782f, -0.01548735f, -0.01980587f, -0.02998840f, -0.05584171f, 
    -0.02906120f, 0.02322162f, -0.02898781f, 0.01269789f, 0.02795142f, -0.02108576f, -0.05508731f, 0.03996583f, 
    -0.01335334f, -0.02506425f, 0.02684269f, -0.04291331f, -0.03156450f, 0.01830373f, 0.01078632f, -0.00715466f, 
    -0.05334988f, 0.00546741f, 0.04307376f, -0.01763810f, 0.02002823f, -0.02493642f, -0.00753745f, -0.04306704f, 
    0.02521073f, 0.02751818f, -0.01909628f, 0.04122478f, 0.02232986f, -0.03488533f, 0.04143709f, 0.00295293f, 
    0.00837992f, -0.01460382f, -0.02899575f, 0.00643061f, -0.04636723f, -0.01262027f, -0.01091990f, -0.02988009f, 
    -0.01113138f, -0.03680775f, 0.03794845f, 0.01247534f, -0.03060598f, -0.01629814f, -0.03406141f, -0.00969440f, 
    0.03435604f, 0.01823245f, 0.03907479f, -0.01879442f, 0.03266761f, 0.03882651f, 0.02845064f, -0.01123656f, 
    0.04014613f, -0.02055539f, 0.03977421f, -0.04279139f, 0.04587606f, -0.02874980f, -0.04840912f, 0.01503419f, 
    -0.05315089f, -0.04786398f, -0.00164920f, -0.05368853f, -0.04876725f, -0.00932930f, 0.00553422f, -0.00367613f, 
    0.01353839f, -0.02876256f, -0.05146236f, 0.01243235f, 0.02320637f, -0.05588706f, 0.02093974f, -0.03268784f, 
    0.04240648f, -0.01126935f, 0.03336857f, -0.01325919f, -0.01418106f, 0.01965633f, 0.03992938f, 0.00536566f, 
    -0.01588088f, 0.00994130f, -0.04527608f, 0.04127462f, -0.01221319f, -0.02439778f, -0.02893286f, 0.01960122f, 
    0.02200042f, 0.00603364f, 0.01683325f, -0.02658232f, -0.00151835f, 0.03878069f, -0.04016117f, -0.05332301f, 
    0.02241217f, 0.01855953f, -0.04353259f, -0.01681774f, 0.03930916f, -0.04754737f, -0.00312606f, 0.04164094f, 
    0.00021824f, 0.00295804f, 0.02022486f, 0.04241366f, 0.03427391f, 0.00211894f, -0.03838640f, -0.04304121f, 
    0.00291792f, 0.03377042f, 0.00137448f, 0.03068235f, -0.04894086f, -0.05537057f, 0.04148434f, 0.00919929f, 
    -0.05189843f, -0.03901906f, 0.01477541f, 0.00602051f, -0.01882545f, 0.03887294f, -0.04735841f, 0.04532270f, 
    -0.05010402f, -0.01558020f, -0.05432686f, -0.02637270f, -0.02196998f, 0.03541532f, -0.04051929f, -0.01912405f, 
    0.04526865f, 0.02692819f, -0.04331730f, -0.05392079f, 0.03319046f, 0.00474320f, -0.03136237f, -0.01219401f, 
    -0.00315186f, -0.00507677f, -0.05523710f, 0.03450311f, -0.05599707f, -0.05598781f, -0.00076564f, -0.02085360f, 
    -0.01634608f, 0.02921071f, -0.02159572f, 0.02937876f, -0.04025869f, -0.02533009f, -0.04974132f, -0.04468634f, 
    -0.02536779f, -0.00399056f, -0.01006511f, 0.01806525f, -0.02341791f, -0.00007702f, 0.03865382f, -0.00455353f, 
    0.01283746f, 0.04271091f, 0.02597135f, -0.00467803f, 0.02860531f, -0.02038423f, -0.01796171f, 0.02442576f, 
    -0.02165751f, -0.01477706f, -0.05144806f, 0.00968915f, 0.02244391f, -0.02709557f, -0.05089574f, 0.02514703f, 
    -0.04749496f, -0.03970369f, 0.04031275f, 0.01510656f, -0.03117472f, -0.02799350f, 0.02991417f, -0.00182559f, 
    0.01244978f, -0.04286678f, -0.01614187f, -0.02097690f, 0.03969360f, -0.03536796f, -0.03290615f, 0.02230241f, 
    0.03341050f, 0.00665826f, 0.01842177f, -0.02007588f, -0.03383087f, -0.01508356f, 0.02931241f, 0.00887399f, 
    -0.01169443f, -0.05160368f, 0.03957524f, -0.00261333f, -0.03172629f, -0.00071179f, 0.00728910f, 0.01147626f, 
    0.02650359f, -0.05247099f, -0.03954561f, -0.04217771f, -0.03600595f, -0.00803978f, 0.00005611f, -0.01639000f, 
    -0.00279519f, 0.01175986f, -0.02544729f, -0.01076442f, -0.00810670f, 0.00139574f, -0.02671815f, -0.00643684f, 
    -0.05175711f, -0.02270309f, -0.01028184f, -0.05166372f, -0.04336449f, -0.00092651f, -0.01131351f, -0.00272193f, 
    -0.03843381f, 0.00016263f, -0.02325211f, 0.03742188f, -0.02550305f, 0.03121811f, 0.02317172f, 0.01454016f, 
    -0.02552930f, 0.00438661f, -0.02288487f, 0.01930391f, 0.01684454f, -0.02720630f, -0.02120502f, -0.04426153f, 
    0.04169621f, -0.01568826f, -0.04744658f, -0.03750357f, 0.01512660f, 0.04191221f, -0.00597558f, -0.00030694f, 
    0.22234154f, 0.18261123f, 0.06626488f, -0.08399552f, 0.00976600f, -0.10586867f, -0.13090439f, 0.04575099f, 
    0.02227261f, -0.05860559f, -0.06122201f, 0.11634717f, -0.16074887f, -0.16181956f, -0.23330541f, 0.17175032f, 
    0.14426050f, 0.15880416f, -0.00736109f, 0.00829655f, 0.01870990f, -0.00710316f, -0.04135593f, 0.00941290f, 
    -0.10807490f, 0.07140839f, 0.19702899f, -0.34699965f, -0.13434178f, -0.11461651f, 0.09692185f, 0.03876463f, 
    0.13785018f, 0.06518904f, 0.02387214f, 0.02215484f, 0.20722650f, 0.24256337f, -0.05154523f, 0.31119379f, 
    0.04184779f, -0.06434058f, -0.04118660f, -0.05410007f, 0.07439453f, 0.17762090f, -0.08046924f, -0.11993601f, 
    0.10027178f, 0.11348270f, 0.01648043f, -0.00327799f, -0.11731347f, -0.07451050f, 0.14508104f, 0.03890120f, 
    -0.12246975f, 0.14527743f, -0.07699369f, 0.06319418f, 0.31696323f, 0.10837313f, 0.14554836f, 0.22312154f, 
    -0.06066525f, 0.01210452f, 0.10061405f, 0.11287668f, -0.04718699f, 0.09004576f, -0.04380289f, 0.03039609f, 
    0.08548319f, -0.17095940f, 0.16079529f, 0.28185523f, 0.09990223f, 0.07138909f, 0.04630945f, 0.12123493f, 
    -0.02110748f, -0.09868404f, 0.05076547f, 0.01108867f, -0.16208854f, -0.16713721f, 0.09021518f, -0.03276950f, 
    0.01845959f, 0.07221258f, 0.07274466f, -0.02646410f, 0.14303829f, -0.01499077f, 0.00847115f, -0.04173703f, 
    0.04247224f, 0.03839918f, 0.01899385f, -0.19848146f, -0.01960531f, -0.08999279f, 0.11330158f, 0.15763216f, 
    0.03493008f, -0.01897759f, -0.04529397f, -0.09759955f, -0.02559453f, 0.23097692f, -0.07518549f, 0.10489118f, 
    0.10420192f, 0.13538325f, 0.07579324f, 0.07997084f, 0.00518907f, -0.11820504f, 0.04703010f, 0.03655117f, 
    0.27992165f, 0.15658972f, -0.01777663f, -0.04156300f, -0.20854139f, 0.07075152f, -0.04744961f, -0.06210849f, 
    0.05431847f, 0.02540599f, 0.09870447f, -0.01346349f, 0.00681713f, -0.37730089f, 0.03033752f, 0.35930741f, 
    0.09052713f, 0.08407176f, 0.06682459f, 0.02792627f, -0.00111174f, 0.01105849f, 0.06310689f, 0.03419911f, 
    -0.11029169f, -0.31327027f, -0.20343634f, -0.14952655f, 0.10808566f, 0.19907704f, -0.00444586f, -0.01526816f, 
    0.04543462f, -0.07073793f, 0.21861777f, -0.01649711f, 0.26116124f, 0.10453840f, 0.24005358f, 0.20266828f, 
    -0.20124564f, 0.05175562f, 0.11515087f, -0.03459246f, -0.10523321f, 0.14191942f, 0.03620448f, -0.25942424f, 
    -0.17526259f, -0.21591221f, 0.24612740f, -0.06054901f, -0.06080448f, -0.06198080f, 0.05841648f, -0.04561514f, 
    -0.03155841f, 0.14757584f, -0.05584968f, 0.03884034f, 0.36739179f, 0.21307881f, -0.06095714f, 0.25514731f, 
    -0.05017163f, 0.10044464f, -0.02713085f, 0.04134858f, 0.04247490f, 0.11460563f, 0.02884348f, -0.01043872f, 
    0.07421699f, 0.05383807f, -0.04243869f, -0.15242542f, 0.05656270f, -0.11085887f, 0.00906296f, -0.05858261f, 
    0.04828320f, -0.05859593f, -0.08218028f, -0.00160145f, -0.12037374f, 0.05521666f, 0.08634886f, 0.05493760f, 
    -0.00413324f, -0.03611786f, 0.01922831f, 0.08457646f, 0.05081520f, 0.13131882f, 0.04216841f, -0.03159778f, 
    0.09749061f, 0.25015631f, 0.04661204f, 0.22313827f, -0.09196818f, 0.00192518f, 0.02659112f, -0.08962899f, 
    0.00610151f, -0.08000278f, 0.04274720f, -0.02976528f, 0.07731108f, 0.17209929f, -0.03776303f, 0.27124941f, 
    0.04156031f, -0.01356330f, -0.06323989f, 0.15874465f, 0.05444911f, -0.04521021f, 0.11939164f, -0.19384696f, 
    -0.05358548f, -0.01130091f, -0.08257351f, -0.28179628f, 0.08213446f, 0.17377189f, -0.03764210f, 0.08134486f, 
    -0.02293832f, 0.03985340f, -0.00521650f, -0.02328459f, 0.01794596f, 0.19405918f, 0.01201863f, 0.01473574f, 
    -0.00290871f, 0.04057357f, 0.05441600f, -0.07458937f, -0.01836988f, -0.02634850f, 0.06951084f, -0.03359122f, 
    0.19168699f, 0.26871869f, 0.10457020f, 0.03725218f, 0.02274274f, 0.00446347f, -0.04411923f, 0.05458674f, 
    0.02532191f, 0.07580059f, -0.04699223f, -0.07161903f, 0.37727129f, 0.12945627f, -0.29069078f, 0.30021027f, 
    0.15820853f, 0.05810259f, -0.03888834f, 0.20114815f, -0.11190903f, 0.02707153f, -0.02933815f, -0.01409630f, 
    0.29913759f, 0.20776318f, -0.13788779f, 0.19302101f, 0.10712430f, 0.00779350f, -0.03235102f, -0.04550985f, 
    -0.01324056f, -0.04379865f, 0.01690736f, -0.11086329f, -0.39181635f, 0.37271479f, 0.05426954f, 0.20032550f, 
    0.10457174f, -0.06650274f, -0.06193003f, 0.00960900f, 0.05656441f, 0.08124250f, -0.08390069f, 0.03712010f, 
    -0.31114376f, -0.08379704f, -0.06970696f, 0.06856027f, -0.06751210f, 0.05462015f, -0.01294201f, -0.01399957f, 
    0.00730662f, -0.07886367f, -0.03978567f, -0.07538669f, -0.11491723f, 0.05315823f, 0.03823347f, -0.26063743f, 
    0.01617706f, -0.02719739f, -0.06184976f, 0.07336231f, -0.04174278f, -0.02570621f, 0.04271444f, 0.03386877f, 
    -0.06124708f, -0.14677332f, -0.11614359f, -0.27735528f, 0.04813046f, -0.04160216f, 0.01155740f, -0.02147891f, 
    -0.00471032f, -0.11898683f, 0.04438949f, -0.06149597f, -0.15910837f, -0.38652292f, -0.05686610f, 0.13894555f, 
    0.21944900f, 0.03692907f, 0.03968354f, 0.00193216f, 0.04471128f, -0.05811924f, 0.11292695f, 0.04621585f, 
    -0.09296419f, 0.24261089f, -0.01130582f, 0.20269187f, -0.07018250f, -0.06323645f, 0.00458749f, 0.01015950f, 
    0.13579190f, -0.09575720f, -0.00281754f, -0.07565302f, 0.25775224f, -0.00945826f, 0.00060142f, 0.13184065f, 
    0.14286089f, -0.03821163f, -0.03203754f, 0.01305002f, 0.02530021f, 0.04524012f, 0.08694160f, -0.08399907f, 
    -0.24756894f, 0.13667725f, -0.14951648f, 0.13856454f, -0.13631663f, -0.14612249f, 0.01181135f, -0.05315858f, 
    0.01102614f, 0.09346806f, 0.00837936f, -0.09672542f, 0.05182750f, -0.21040146f, -0.12124053f, -0.15367711f, 
    0.03572647f, 0.14934610f, -0.07318635f, -0.02355219f, -0.01014051f, -0.05400607f, -0.15047222f, -0.15066066f, 
    0.23637934f, 0.01022064f, -0.05211150f, 0.08802368f, 0.11701100f, 0.00600435f, -0.06487202f, -0.08354925f, 
    -0.08485017f, -0.05839645f, 0.00527276f, 0.06351345f, 0.20168506f, 0.16341990f, 0.13792861f, 0.07822635f, 
    -0.13150483f, 0.01961784f, 0.02925784f, 0.04631661f, 0.13540731f, -0.08380838f, -0.10339604f, -0.02010147f, 
    0.00630361f, -0.07103225f, 0.07383186f, -0.05390903f, 0.04340455f, 0.07367268f, -0.02287184f, 0.17499247f, 
    0.09048405f, 0.07448746f, 0.04121857f, -0.00084927f, -0.02348715f, -0.05773111f, 0.15379719f, -0.09621742f, 
    0.00083133f, 0.17954311f, -0.06240526f, 0.02441022f, 0.03656894f, 0.02271044f, 0.19076042f, 0.07718349f, 
    -0.34472018f, -0.04984082f, 0.12988997f, 0.00955084f, 0.06104550f, -0.05045641f, -0.07728620f, 0.02312532f, 
    0.15504253f, -0.01540085f, -0.07812174f, 0.04784203f, 0.07884172f, -0.09063873f, 0.00154327f, -0.17703509f, 
    -0.00099414f, 0.07571941f, -0.10340490f, 0.01350751f, 0.14630012f, -0.21793793f, 0.14236048f, -0.08513851f, 
    -0.12175146f, 0.03480026f, 0.00373953f, -0.06474904f, 0.03928985f, 0.01738484f, 0.05796849f, -0.02142162f, 
    0.01358424f, -0.06163538f, 0.11194225f, 0.06848527f, 0.24468194f, -0.07463628f, 0.00081758f, -0.33563066f, 
    0.03366395f, 0.01286663f, -0.02037724f, -0.06282877f, -0.05884055f, 0.05812749f, -0.07483623f, -0.10290594f, 
    -0.33001810f, 0.14490429f, -0.04588433f, 0.00714568f, -0.05812539f, -0.14925206f, 0.04732350f, -0.08674426f, 
    0.04713285f, -0.08192000f, -0.09452524f, -0.03804021f, 0.20303783f, 0.19951706f, 0.05794560f, 0.09031870f, 
    0.05943418f, 0.02958597f, 0.10695421f, 0.06637230f, -0.07115741f, 0.03695508f, -0.01012381f, 0.04146414f, 
    0.11166172f, 0.01119945f, -0.26484689f, -0.08912776f, -0.02133342f, 0.03968013f, -0.29710871f, -0.06504250f, 
    0.05765998f, 0.20243926f, -0.04692808f, -0.03410884f, -0.00734128f, -0.04603030f, 0.13884474f, -0.19873157f, 
    -0.01787930f, -0.02698166f, 0.16273177f, 0.15837018f, -0.03663129f, 0.08310974f, 0.04419392f, 0.15520884f, 
    0.03307268f, 0.09931296f, 0.27559298f, -0.05914896f, 0.03987532f, 0.08858687f, 0.06941307f, 0.00091575f, 
    -0.08180741f, 0.06143146f, -0.05037544f, 0.06611962f, 0.08280145f, 0.10002164f, -0.16294855f, 0.08946398f, 
    0.05278380f, 0.19693895f, 0.09909642f, 0.01237738f, -0.06671155f, 0.04631033f, 0.05511898f, 0.13939574f, 
    -0.25287724f, 0.07860033f, -0.14158292f, -0.11852238f, -0.03174607f, -0.02796035f, -0.03053934f, -0.00379482f, 
    0.05597748f, 0.05333394f, 0.12942171f, 0.00673219f, 0.01970079f, 0.25110203f, 0.06010504f, -0.09679094f, 
    0.08431783f, 0.08659831f, 0.04512470f, 0.00737342f, -0.00477091f, -0.05568127f, -0.04538532f, 0.04755500f, 
    0.14389327f, -0.09172060f, -0.13689114f, -0.19495291f, 0.07389396f, 0.00757352f, -0.09893283f, -0.01736964f, 
    -0.05371188f, -0.07522248f, -0.09277089f, -0.09316202f, 0.11969392f, 0.23814280f, -0.02042314f, 0.07414148f, 
    0.01126136f, -0.06439117f, 0.03848973f, -0.03568103f, 0.02250680f, 0.20962268f, 0.02513235f, 0.23621184f, 
    0.20371993f, 0.04624889f, 0.06145985f, -0.01737556f, 0.02526991f, -0.08854873f, 0.01540567f, 0.00432081f, 
    -0.00764438f, 0.20350124f, 0.15517165f, -0.01696769f, -0.12760481f, 0.07562280f, 0.13065833f, 0.02054931f, 
    0.04286917f, -0.08997094f, 0.05504350f, 0.06146358f, 0.17777145f, 0.13606124f, -0.03784886f, -0.10904761f, 
    -0.02764824f, -0.03406971f, 0.08806247f, -0.05780088f, -0.11908101f, 0.02745139f, 0.09651373f, 0.07491484f, 
    0.11609671f, -0.15659682f, 0.21753484f, 0.03562988f, 0.47328970f, 0.02845665f, 0.06304805f, 0.00219155f, 
    0.03504350f, -0.06695282f, -0.00126972f, -0.10115266f, 0.00490328f, -0.00077864f, -0.12272505f, 0.00890300f, 
    0.39358079f, -0.08409249f, -0.08882125f, 0.06880842f, -0.00456064f, 0.05538785f, 0.00419438f, 0.03972358f, 
    0.06214162f, 0.20187655f, -0.16111743f, 0.05134714f, -0.04325726f, 0.12867726f, 0.13316764f, -0.08889724f, 
    0.09766555f, 0.00922972f, 0.06753862f, 0.05503897f, 0.01110671f, -0.12064502f, -0.02479968f, 0.03871868f, 
    -0.35353097f, 0.02430818f, -0.07879262f, 0.08446896f, 0.09834110f, 0.02382977f, -0.19307835f, 0.06566630f, 
    0.08296644f, 0.03878805f, 0.09576622f, 0.05774981f, -0.29733327f, 0.00575857f, -0.11222769f, -0.13601083f, 
    -0.02516074f, -0.16282582f, -0.04863812f, 0.05125334f, 0.19718137f, 0.08713221f, -0.07013853f, 0.09415514f, 
    -0.06779075f, -0.11549328f, -0.17836179f, -0.00537374f, -0.11963098f, -0.14179915f, -0.00769597f, -0.08747644f, 
    0.00900012f, 0.03562978f, 0.07560226f, 0.05910429f, 0.10284898f, -0.02391295f, 0.00104581f, 0.06782731f, 
    0.07538638f, -0.08165263f, -0.04815161f, -0.04633811f, -0.04742565f, -0.03988156f, -0.01946099f, -0.05259841f, 
    0.09597117f, 0.03559411f, -0.04794557f, 0.05849166f, 0.07855944f, 0.05247342f, -0.02173961f, 0.20475602f, 
    0.02872281f, -0.02468645f, 0.03053106f, 0.13454172f, 0.24199526f, 0.08376991f, 0.09254003f, 0.20175968f, 
    -0.02878009f, 0.10133331f, -0.02312772f, 0.05996039f, 0.00616573f, -0.07658304f, -0.11952907f, 0.09093312f, 
    -0.03269761f, -0.05680625f, -0.04399679f, -0.04462847f, -0.02796126f, -0.02032018f, -0.04645029f, -0.04313379f, 
    -0.04337285f, -0.00387365f, 0.02527495f, 0.01933473f, 0.00985170f, -0.02450584f, 0.01929730f, -0.00753686f, 
    0.01776835f, 0.00756092f, -0.00734163f, 0.04094940f, -0.01732513f, -0.01226872f, 0.03988712f, -0.04398964f, 
    0.01018967f, 0.03264018f, -0.02633154f, 0.01823356f, -0.00461926f, 0.02064390f, -0.04263147f, -0.05145146f, 
    -0.04717708f, -0.01517386f, 0.00915876f, 0.01220033f, -0.03175759f, 0.00895939f, -0.04270017f, 0.00522148f, 
    0.03981989f, 0.00411747f, 0.03589772f, -0.05650881f, -0.04498484f, -0.05443166f, 0.00256895f, -0.02496756f, 
    -0.05554217f, 0.02176105f, -0.04551206f, -0.01831117f, 0.03267977f, 0.03655791f, 0.01320013f, 0.01041995f, 
    0.02848173f, -0.03497491f, -0.02120671f, 0.00986624f, -0.00869762f, -0.00267581f, -0.04757537f, -0.00568589f, 
    -0.00570768f, -0.02803738f, -0.02934839f, -0.03024612f, 0.03824171f, 0.01778840f, -0.01280912f, -0.03400068f, 
    0.01721086f, 0.04225744f, 0.03251969f, -0.00698639f, -0.03608756f, 0.03175806f, 0.03858722f, 0.04337622f, 
    -0.00714164f, 0.03308155f, 0.02222384f, 0.01319857f, -0.01002838f, -0.04661737f, 0.01635122f, -0.00790175f, 
    -0.02486100f, -0.02098312f, 0.01118152f, -0.02111457f, -0.01723773f, -0.04726634f, -0.05639051f, -0.01140424f, 
    0.03467330f, 0.00755202f, -0.01195063f, 0.00313054f, -0.01252640f, 0.01402197f, -0.00309970f, -0.01187024f, 
    -0.04698936f, -0.00344083f, 0.02049763f, 0.04208199f, 0.02503840f, -0.02352655f, -0.05299350f, 0.02648748f, 
    0.02647334f, 0.04186532f, 0.00635512f, -0.05603098f, 0.00967960f, -0.03961829f, 0.00469985f, -0.01961005f, 
    0.00751040f, -0.02844060f, 0.00973835f, -0.04832475f, 0.02321054f, -0.04920008f, 0.00575939f, 0.01657172f, 
    0.01094650f, -0.01974274f, -0.04266452f, 0.00321684f, -0.00961617f, 0.02258800f, 0.02785313f, 0.04038182f, 
    0.00455893f, -0.03901612f, 0.02828472f, -0.01486618f, -0.03550163f, -0.03776180f, 0.04244010f, -0.03432992f, 
    -0.01640779f, -0.02487146f, 0.02020246f, -0.03172031f, -0.01131769f, 0.01980089f, -0.05690886f, 0.04313054f, 
    -0.03467890f, 0.01734648f, -0.01718287f, 0.02145436f, -0.05715716f, 0.02474139f, 0.04170803f, -0.03834331f, 
    -0.03138883f, -0.04045315f, -0.04821878f, 0.03431436f, 0.02345541f, -0.01250353f, -0.00834374f, 0.00524640f, 
    -0.00765837f, -0.03075152f, 0.02320410f, -0.01566847f, 0.02770633f, 0.01361420f, -0.01720227f, 0.04102189f, 
    -0.00870495f, 0.03211430f, 0.00048656f, 0.00227658f, -0.01112453f, -0.01988296f, -0.01434593f, 0.01806887f, 
    -0.01529264f, -0.00405683f, 0.04195857f, 0.03980022f, 0.02342202f, -0.01540341f, 0.00923392f, -0.02198751f, 
    -0.00622163f, -0.00653573f, -0.05452958f, -0.02732028f, -0.02160451f, 0.02243427f, 0.03996377f, 0.01361965f, 
    -0.05387129f, -0.01617066f, -0.02403521f, -0.01573117f, 0.01458514f, -0.00035687f, -0.02548800f, 0.03864006f, 
    -0.01632456f, -0.01450926f, -0.03318032f, 0.02026589f, -0.03285726f, 0.02701468f, -0.02397188f, 0.02548201f, 
    -0.04764413f, -0.00212836f, 0.01994655f, 0.04198048f, 0.02320124f, 0.01840945f, -0.02962712f, 0.00695126f, 
    0.00122582f, -0.03824609f, -0.01124300f, 0.00412297f, 0.00186987f, 0.01075485f, -0.01097261f, -0.03574147f, 
    -0.01102486f, -0.01849425f, 0.00176042f, 0.01007739f, -0.01002777f, 0.03946321f, -0.03568094f, -0.00841536f, 
    -0.02535001f, 0.01238688f, 0.03819190f, 0.00322379f, -0.04624474f, -0.04268053f, 0.01051899f, 0.01350645f, 
    0.00958553f, -0.01922242f, -0.03454792f, 0.00278582f, -0.00892610f, 0.04233861f, 0.00203722f, -0.00082614f, 
    0.00619216f, -0.02685125f, 0.00146360f, -0.04767904f, -0.00849941f, 0.02267612f, 0.03318078f, -0.03668987f, 
    -0.03881035f, -0.01702056f, -0.01669947f, -0.05565157f, -0.02248928f, -0.04768802f, -0.05825564f, 0.01204049f, 
    0.02719108f, -0.01486477f, 0.01426825f, -0.00297590f, 0.00603543f, 0.03837692f, -0.03584728f, 0.02789612f, 
    0.03179303f, -0.00916173f, 0.02007302f, 0.03248488f, -0.00193473f, 0.04162988f, -0.01032245f, -0.03272502f, 
    -0.02471466f, -0.03166549f, -0.00862793f, 0.02192325f, -0.02966433f, 0.04244373f, -0.03192075f, 0.03576115f, 
    -0.03067246f, 0.03546429f, 0.02273804f, 0.02644488f, -0.01157324f, -0.04700234f, -0.01473531f, -0.03437748f, 
    0.03009839f, -0.03641064f, -0.01152738f, -0.00482123f, -0.00968740f, -0.04845599f, 0.01241538f, 0.03841740f, 
    0.02376561f, -0.03339771f, -0.02955387f, -0.05124472f, 0.04143567f, 0.02167953f, 0.04013900f, -0.04745928f, 
    -0.01587223f, -0.04578669f, 0.01462929f, 0.00326684f, -0.03104893f, -0.03431411f, -0.00046247f, -0.00067531f, 
    -0.04039243f, -0.01730222f, -0.03437047f, 0.04460440f, 0.04234601f, -0.05770536f, -0.04874874f, 0.01202416f, 
    0.01712321f, 0.02290146f, -0.00431398f, -0.00448404f, 0.01572614f, 0.02454218f, -0.03700933f, 0.02204487f, 
    0.01311691f, 0.00700436f, -0.05311247f, 0.00221826f, -0.00633515f, -0.00816758f, -0.01119947f, -0.05445188f, 
    -0.01865576f, -0.03251300f, -0.00635253f, 0.01635096f, -0.01571728f, -0.04254755f, -0.00033866f, -0.04679444f, 
    0.02824463f, -0.05180480f, 0.01641873f, 0.01023463f, 0.00312861f, 0.03101000f, -0.01341569f, 0.02818469f, 
    0.03827214f, 0.01690477f, 0.01145690f, -0.00608705f, -0.00027594f, -0.01504791f, -0.00310052f, -0.04461041f, 
    0.01529846f, 0.01859412f, -0.02065056f, 0.04903689f, -0.00153122f, -0.04095793f, 0.00405669f, -0.05565841f, 
    -0.30604351f, 0.09688157f, -0.19351619f, 0.05931935f, -0.01578683f, -0.01281835f, 0.16217674f, 0.04829914f, 
    0.06906242f, 0.13095987f, 0.08591835f, 0.03717729f, -0.10683416f, 0.02263491f, 0.00944682f, -0.18935065f, 
    0.13853420f, 0.09935232f, 0.09787776f, 0.04193549f, 0.11605219f, 0.16602528f, -0.06634230f, 0.04017286f, 
    -0.04662896f, -0.02632129f, 0.06344266f, -0.20837541f, 0.15343732f, 0.01627717f, 0.10897924f, 0.04025358f, 
    0.03353518f, -0.07351180f, -0.09212625f, 0.04841648f, 0.17006272f, -0.17053413f, 0.18828689f, 0.31350020f, 
    0.00893147f, 0.03564142f, 0.05243829f, 0.01233124f, 0.10581327f, -0.04948669f, -0.05414649f, 0.02678706f, 
    0.21699306f, -0.06780897f, -0.02247342f, -0.06143587f, 0.04012495f, -0.00785117f, 0.14222746f, 0.16746180f, 
    0.15443952f, 0.01494365f, 0.01039368f, 0.17535077f, -0.00831626f, -0.08635229f, -0.19463128f, -0.23677890f, 
    0.08519296f, 0.04098068f, -0.03834776f, -0.01760562f, -0.01283534f, -0.06605946f, 0.31043595f, -0.02988006f, 
    -0.04946779f, 0.32993612f, 0.22559030f, -0.12814642f, 0.09938782f, 0.04039900f, 0.00564589f, 0.21020082f, 
    0.07431479f, 0.03384854f, -0.13921414f, 0.11062939f, -0.44670001f, 0.25954396f, -0.02220356f, -0.27313659f, 
    0.03056983f, 0.11665851f, 0.09162498f, 0.00685248f, 0.23028047f, -0.06190128f, 0.20347051f, 0.10422570f, 
    0.02742918f, -0.19840014f, -0.13628571f, -0.12070060f, 0.13413993f, -0.04661003f, 0.07266557f, 0.05552605f, 
    0.01370907f, -0.03990968f, 0.19444254f, 0.07015175f, -0.12163503f, 0.06886969f, -0.05139857f, -0.26016608f, 
    -0.16430639f, 0.04007786f, 0.02335109f, -0.02227538f, -0.13223200f, -0.01867534f, 0.05192009f, 0.06158848f, 
    -0.19594614f, -0.03143173f, -0.08703786f, -0.08912527f, 0.10736334f, -0.12224482f, 0.10779934f, -0.01917929f, 
    -0.02805523f, 0.03866762f, 0.03134119f, -0.00305541f, 0.10140219f, 0.25413007f, 0.47566706f, 0.06227289f, 
    0.09763389f, 0.06292295f, 0.05873742f, 0.22311634f, 0.02977666f, 0.04499870f, 0.09405974f, 0.02224767f, 
    -0.30558822f, 0.21252234f, 0.07913797f, -0.12099233f, 0.05691421f, 0.13137585f, 0.03136717f, -0.10008702f, 
    0.19816257f, 0.18502267f, 0.01212060f, 0.05125349f, -0.00408870f, -0.32099989f, -0.28151295f, -0.09597789f, 
    -0.05245239f, 0.04979345f, 0.10505076f, 0.02501460f, -0.15044941f, 0.12964287f, -0.05135696f, -0.00318551f, 
    0.04774565f, -0.07724430f, 0.18170097f, -0.06418041f, 0.15340708f, 0.13060930f, 0.10081299f, 0.05017674f, 
    -0.03266951f, 0.02684417f, -0.01209653f, 0.21667115f, -0.18642925f, -0.10025962f, 0.04362228f, 0.24245088f, 
    0.05472645f, 0.04222252f, -0.10336377f, 0.11569075f, 0.12778991f, 0.02937182f, 0.10301509f, 0.05646636f, 
    -0.28926566f, 0.01723660f, -0.07718287f, -0.15737902f, -0.06109077f, 0.04288738f, 0.19330962f, -0.04341403f, 
    0.19258724f, -0.04203931f, 0.07674050f, -0.00429161f, -0.12918693f, 0.10322886f, 0.14888152f, 0.09564774f, 
    0.03290305f, 0.11561934f, 0.13646707f, 0.09426031f, -0.01769639f, 0.01204968f, 0.03445087f, 0.21644782f, 
    -0.03803616f, -0.23792072f, -0.21049650f, -0.35817751f, -0.03744357f, -0.03696851f, -0.11920724f, -0.04234350f, 
    -0.10879042f, -0.03817332f, 0.04736601f, -0.08389090f, -0.00588533f, 0.20740438f, -0.07366116f, 0.05685403f, 
    0.17025787f, 0.00099389f, 0.13507016f, 0.02520876f, -0.00584331f, 0.11900172f, -0.04136490f, 0.08972919f, 
    0.20030233f, 0.10840530f, 0.05453999f, -0.04362988f, 0.10837620f, -0.07767980f, 0.01607346f, 0.08781205f, 
    0.10956063f, 0.02572428f, 0.13331388f, 0.11873405f, 0.07960019f, 0.28151533f, -0.05477087f, -0.15350106f, 
    0.06760271f, 0.01957464f, 0.00843991f, -0.00085652f, 0.04584178f, -0.00498753f, -0.06946934f, 0.20339388f, 
    -0.02630781f, -0.14434551f, -0.15839751f, -0.08756943f, -0.00598771f, -0.10814313f, 0.08005875f, -0.06671338f, 
    0.02812302f, -0.01838682f, 0.06628902f, 0.06681882f, 0.35531878f, 0.01604448f, 0.06419950f, 0.12147243f, 
    0.02472199f, 0.17563935f, -0.00071659f, 0.09929651f, -0.02825339f, 0.04131420f, 0.02867967f, 0.07694127f, 
    0.11699351f, -0.15553151f, -0.00513032f, 0.00022634f, -0.04648359f, -0.00907014f, -0.12770766f, -0.11311039f, 
    0.10805485f, 0.07530094f, -0.07046738f, 0.03356230f, -0.10876545f, -0.38273591f, -0.13479741f, -0.07853434f, 
    0.04886580f, -0.03482632f, 0.14593153f, -0.00636177f, -0.16115195f, 0.06315108f, 0.05601651f, 0.06826778f, 
    -0.35796830f, 0.03319709f, 0.21782668f, 0.46904412f, 0.08220485f, 0.13956946f, 0.04400209f, 0.14476843f, 
    -0.01643921f, -0.02714982f, 0.17055650f, 0.02412534f, -0.26999262f, -0.06389327f, -0.01560657f, -0.08459146f, 
    0.08388317f, 0.06146880f, 0.07071464f, -0.01931556f, 0.09621508f, 0.03287068f, 0.02895674f, 0.15666251f, 
    -0.29606140f, 0.06035536f, 0.12117727f, -0.45262524f, -0.17266729f, -0.02090500f, 0.03945071f, 0.02076314f, 
    0.03470088f, -0.02941109f, 0.05652608f, 0.13864386f, -0.13896473f, 0.17672333f, 0.19926348f, -0.06617496f, 
    0.12789103f, 0.10126051f, -0.03338908f, 0.12214699f, 0.11623064f, 0.11901291f, -0.00359645f, 0.14759022f, 
    0.22046958f, -0.24877794f, -0.20708300f, 0.06731607f, -0.08498830f, 0.06869033f, 0.07051867f, 0.08612639f, 
    0.13967602f, 0.03742581f, 0.02434704f, 0.09656981f, 0.35576972f, 0.19364439f, -0.02549518f, -0.00097653f, 
    0.15115522f, 0.14016905f, 0.09985494f, 0.00285748f, 0.01360648f, 0.06571260f, 0.09373753f, 0.11231103f, 
    -0.04953530f, 0.00030777f, 0.03414839f, 0.03343252f, 0.02371161f, -0.00706671f, -0.04337572f, 0.00959014f, 
    0.04788504f, 0.01786045f, 0.02479387f, 0.00514770f, -0.04771342f, -0.01236333f, -0.05353877f, 0.04188611f, 
    -0.02694050f, -0.03263010f, 0.00378355f, 0.02573364f, -0.02425511f, -0.02690890f, 0.03366955f, -0.02753431f, 
    -0.02472708f, 0.01407047f, 0.00363373f, -0.03290111f, -0.03622082f, 0.02185974f, -0.03251282f, -0.04331058f, 
    -0.00463319f, 0.03666385f, -0.05983925f, 0.04203121f, 0.03285113f, 0.00123295f, 0.03588343f, 0.01361781f, 
    0.00030072f, -0.02669046f, 0.00465879f, -0.01033878f, -0.03264431f, -0.04978607f, -0.01244268f, 0.03707548f, 
    -0.04412137f, 0.02920645f, -0.02587170f, -0.02374119f, -0.04088262f, -0.05467911f, -0.01614415f, -0.00034682f, 
    0.02277644f, 0.03600924f, 0.04365234f, -0.03640839f, -0.01300854f, -0.02715607f, 0.02546053f, -0.00558353f, 
    0.03203557f, 0.03265130f, 0.02216494f, -0.01112728f, -0.04711112f, 0.01675692f, -0.00316681f, 0.00266467f, 
    -0.01972071f, 0.03326968f, 0.02778463f, -0.01440704f, 0.01797930f, -0.02346445f, 0.02557274f, -0.01661281f, 
    0.03329474f, -0.04680726f, -0.03126560f, -0.02025783f, -0.04784394f, -0.01111351f, 0.03783785f, -0.05156288f, 
    0.03271238f, -0.06422401f, 0.00415069f, -0.02377009f, -0.05793688f, -0.02479926f, -0.00593238f, -0.05049206f, 
    -0.04973588f, -0.01347555f, 0.03045114f, 0.00636133f, -0.04179239f, -0.04168684f, -0.03946724f, -0.03733458f, 
    0.01910039f, -0.02039774f, 0.03743995f, -0.00006742f, 0.00907517f, -0.04172563f, -0.05204602f, 0.00761456f, 
    -0.03301832f, 0.00995892f, 0.04508262f, -0.03908297f, -0.02263659f, -0.03430869f, 0.03021858f, -0.00837450f, 
    0.00035758f, -0.02636245f, 0.01368718f, 0.03558896f, -0.05414565f, -0.04145790f, -0.04701636f, 0.02563944f, 
    0.04528254f, -0.05440538f, -0.04914652f, -0.02379012f, 0.01744779f, 0.02480707f, -0.02400223f, 0.01659159f, 
    0.02597175f, -0.03514986f, 0.01456647f, -0.00566369f, 0.01743876f, -0.00870958f, -0.00636517f, -0.01742912f, 
    -0.01962208f, 0.02948045f, -0.04417638f, -0.03500604f, -0.01376945f, 0.03044441f, -0.03354235f, -0.04780970f, 
    -0.05823219f, -0.02036979f, -0.05482036f, -0.00369584f, 0.02938537f, 0.00853901f, 0.03294600f, -0.00700824f, 
    -0.06398987f, 0.01114008f, -0.03695828f, -0.04568621f, -0.05823343f, 0.02648375f, -0.00389483f, -0.02515901f, 
    -0.01358467f, -0.04233258f, 0.00172673f, -0.01818807f, 0.03215146f, -0.00002670f, 0.02870205f, 0.00947737f, 
    -0.01929199f, 0.00996335f, 0.03212941f, -0.04091167f, 0.01640938f, -0.00090195f, -0.02643167f, 0.02357535f, 
    -0.04869431f, -0.00562581f, -0.00114606f, -0.01428481f, -0.01942724f, -0.04983091f, 0.02887536f, 0.03892411f, 
    -0.02334897f, 0.04216304f, -0.05085691f, -0.02547293f, -0.06400807f, -0.01737585f, 0.02180344f, 0.02279985f, 
    -0.02564549f, 0.02974274f, 0.02105926f, -0.02198672f, 0.00244096f, -0.00526688f, -0.01978634f, 0.00713614f, 
    -0.00235438f, 0.02312383f, 0.00410963f, -0.01258703f, -0.03293023f, 0.00046058f, -0.03819406f, -0.05324049f, 
    0.02820318f, -0.03221795f, 0.00628568f, -0.01776282f, -0.00518790f, 0.00266602f, 0.03012364f, -0.04717688f, 
    -0.04044716f, 0.00534060f, -0.01631858f, 0.04209305f, 0.02347070f, -0.02890478f, 0.00826124f, 0.02360109f, 
    -0.05414859f, -0.02659983f, -0.01917516f, -0.00080611f, -0.04373983f, -0.02929462f, 0.03778844f, -0.05753357f, 
    -0.04937370f, 0.03545048f, -0.05587517f, 0.00176246f, -0.06170730f, -0.06156158f, 0.02585272f, 0.04472689f, 
    -0.02003987f, -0.04423793f, 0.03091296f, -0.04155860f, -0.02049002f, -0.03078565f, -0.01672421f, 0.02884643f, 
    -0.04829688f, 0.01797514f, 0.03759306f, -0.04437234f, -0.02258017f, 0.02021502f, -0.05106625f, 0.01280345f, 
    0.00198788f, 0.01308423f, 0.01330697f, -0.00689474f, -0.03861961f, 0.00184110f, 0.03436436f, 0.03964330f, 
    0.00004905f, -0.04502695f, -0.04574353f, -0.01552654f, 0.01904636f, -0.04379574f, -0.00407746f, -0.02593695f, 
    -0.03317744f, -0.00107798f, 0.04044015f, 0.03396515f, -0.00490125f, -0.06320594f, 0.03185229f, 0.03512159f, 
    -0.02968233f, 0.01604361f, 0.03405652f, 0.00553849f, -0.02743421f, 0.03405279f, -0.03004259f, 0.00640365f, 
    -0.06105291f, -0.05605527f, -0.01383581f, -0.02951551f, 0.00150897f, 0.03561943f, 0.01708491f, -0.02750715f, 
    0.03706923f, -0.05929019f, 0.00652365f, -0.01068744f, 0.01969635f, -0.03514346f, -0.01926258f, 0.03866861f, 
    0.01345915f, 0.01062885f, 0.01614225f, -0.03617858f, 0.00544779f, 0.02036642f, 0.00625390f, 0.03259152f, 
    0.01177693f, -0.05542937f, 0.03421353f, -0.02329262f, -0.05972306f, -0.04310682f, 0.04194000f, 0.01085389f, 
    -0.01828597f, -0.03256217f, -0.01525040f, 0.01977777f, 0.00178261f, -0.05476514f, -0.01368828f, -0.05921093f, 
    0.00981894f, 0.04153021f, -0.03063792f, -0.04791314f, -0.04143968f, 0.02993099f, -0.03357569f, -0.04101516f, 
    -0.00382891f, 0.01489426f, 0.02841323f, -0.01676756f, -0.04216035f, -0.01585682f, 0.04833649f, 0.01614783f, 
    -0.03683547f, 0.03948461f, 0.04101545f, -0.01255878f, 0.02171822f, 0.04625890f, -0.00539263f, -0.02471672f, 
    0.00363618f, 0.02309037f, -0.04977766f, 0.00393649f, -0.01524025f, 0.02455458f, -0.05159000f, -0.06014206f, 
    -0.06730612f, -0.01385964f, -0.04828056f, -0.06061579f, 0.03331500f, 0.01942872f, -0.03171241f, 0.03934227f, 
    -0.01048233f, 0.02223061f, 0.01428486f, 0.01022844f, 0.00236445f, -0.03653869f, 0.03720998f, -0.04664579f, 
    0.26314160f, 0.01004441f, 0.31523249f, -0.05130189f, 0.16125193f, 0.01972238f, -0.07926753f, 0.06763472f, 
    0.05032404f, -0.13914642f, -0.04020644f, 0.17752285f, -0.16624711f, 0.13700359f, -0.10121460f, -0.01816936f, 
    0.17873873f, 0.00061243f, 0.03606069f, -0.01216495f, -0.01846942f, 0.00162543f, 0.08636761f, 0.02586276f, 
    -0.06184458f, -0.26266679f, 0.07129494f, 0.10423556f, -0.14407751f, 0.02114094f, 0.06066449f, 0.00086885f, 
    0.09434648f, 0.18303029f, 0.11970688f, -0.06020709f, -0.03916331f, -0.06031710f, 0.01727021f, -0.13449767f, 
    0.08337381f, 0.07179927f, -0.03894722f, 0.12653308f, -0.04195819f, 0.11510280f, 0.02302606f, 0.18969734f, 
    0.16766617f, -0.19314747f, 0.12920134f, 0.02882257f, -0.00236354f, -0.02772925f, -0.04061287f, -0.09190875f, 
    -0.03253017f, -0.05787119f, 0.01005121f, -0.01228556f, 0.30854225f, -0.02660018f, 0.08325498f, 0.02288201f, 
    0.10803524f, 0.06477723f, 0.15875778f, 0.01598192f, 0.08377153f, 0.04573591f, -0.16287458f, 0.02544928f, 
    0.29948828f, 0.09284230f, -0.20218658f, -0.13805556f, 0.00490195f, 0.05149119f, 0.05543225f, -0.04004475f, 
    0.01130955f, 0.05485346f, 0.14283504f, -0.01932542f, -0.24581952f, -0.22548079f, 0.02476310f, 0.06971279f, 
    0.05889298f, -0.02727641f, -0.09964390f, -0.07848247f, -0.01566214f, 0.06132631f, -0.04279103f, -0.03093204f, 
    0.36149055f, -0.01789263f, 0.08311152f, 0.09272042f, -0.00129551f, -0.16614905f, -0.03937402f, 0.00996698f, 
    0.10967635f, 0.09122414f, -0.08459675f, -0.07452273f, -0.13625702f, -0.05092836f, 0.13074540f, 0.24677700f, 
    0.09050718f, 0.05878559f, 0.08297575f, -0.10445637f, 0.09194572f, -0.00835299f, 0.14775988f, 0.12779142f, 
    0.28167883f, 0.01024390f, 0.10254031f, 0.10504241f, -0.04587572f, 0.06809117f, -0.12045098f, -0.00356651f, 
    0.01630392f, 0.17118022f, 0.10488265f, -0.00489102f, -0.32589296f, 0.16565360f, 0.07030731f, 0.00243648f, 
    0.03846887f, -0.10939387f, -0.15788618f, -0.06328119f, 0.01447318f, 0.03505176f, 0.00828386f, 0.00115334f, 
    -0.36260200f, -0.17460622f, 0.00685101f, 0.05804661f, 0.20573890f, 0.10638268f, -0.07346878f, -0.00934721f, 
    -0.11839177f, -0.01517645f, 0.10520966f, 0.04464134f, 0.34445757f, 0.30713552f, 0.01884910f, -0.06210642f, 
    -0.15630050f, 0.10560615f, -0.09340503f, 0.01350805f, 0.13180798f, -0.04602382f, -0.14037353f, -0.03973807f, 
    0.18303825f, -0.04902926f, -0.20781069f, 0.15037332f, 0.08319636f, -0.20109718f, -0.03730845f, 0.09954531f, 
    0.06247537f, 0.01605320f, 0.12234160f, 0.06998755f, -0.09989072f, 0.25744116f, 0.21345939f, -0.14940856f, 
    -0.16471100f, 0.09256070f, 0.04160633f, 0.06077696f, 0.13964945f, 0.02277313f, -0.03750181f, 0.00480229f, 
    0.16366853f, -0.01441929f, -0.02896027f, -0.02578703f, -0.07822591f, 0.04259840f, 0.09938574f, -0.08051295f, 
    0.16533090f, -0.05059148f, -0.03372711f, 0.09286003f, 0.22974075f, -0.05805290f, 0.07661996f, -0.08771688f, 
    0.03402573f, 0.00835820f, -0.11080189f, 0.07284104f, 0.13567506f, 0.17668965f, 0.06901180f, 0.08804443f, 
    -0.05060839f, 0.21181372f, 0.21805447f, 0.00181587f, -0.07253315f, -0.02676746f, 0.19502801f, 0.01365044f, 
    0.02156240f, -0.07020216f, 0.10605474f, 0.09012378f, -0.04231377f, -0.10276417f, 0.23475619f, 0.10936219f, 
    0.00453454f, 0.12917046f, -0.00662540f, 0.03328400f, 0.07303231f, -0.07893970f, 0.02894012f, -0.23109257f, 
    -0.06503790f, -0.11968489f, 0.03858094f, 0.10798005f, 0.11778623f, -0.13396859f, -0.14029814f, 0.00341897f, 
    0.07037528f, -0.10204244f, -0.05576739f, 0.01065618f, 0.07785186f, -0.00564099f, 0.22978327f, -0.01911869f, 
    0.15197194f, 0.09932928f, -0.05061636f, -0.00873431f, -0.01926454f, -0.07201003f, 0.14476746f, 0.03109113f, 
    -0.08320334f, 0.06576316f, 0.28230444f, -0.10438772f, 0.05799189f, 0.01324694f, -0.00704004f, 0.05317159f, 
    -0.14251164f, 0.00874431f, -0.05594387f, 0.04440144f, -0.34290603f, 0.18993002f, 0.03640133f, -0.09587818f, 
    0.04035230f, -0.15144859f, 0.06802257f, 0.09934253f, 0.17915215f, 0.09866699f, 0.13290101f, 0.03993411f, 
    -0.38065931f, 0.18735747f, 0.18799619f, -0.15059197f, 0.15527812f, 0.04925860f, 0.15419701f, 0.09768669f, 
    -0.06160989f, -0.02630974f, 0.01236412f, -0.01452682f, 0.32986540f, 0.19130065f, 0.05113203f, 0.00751670f, 
    0.02493640f, -0.06234526f, -0.09258887f, 0.01398733f, -0.00022102f, -0.02690421f, -0.01260443f, 0.11231527f, 
    -0.05128015f, 0.07384433f, -0.26159421f, -0.02906751f, 0.04824855f, 0.24042588f, -0.09892453f, -0.10733718f, 
    0.08064182f, -0.02343695f, 0.00059945f, 0.11507703f, 0.12795785f, -0.00843457f, -0.05020543f, -0.03303024f, 
    0.09209587f, -0.01022417f, -0.12415305f, -0.15454276f, 0.08491986f, 0.03470612f, 0.07632722f, 0.16267408f, 
    -0.09053607f, -0.09260159f, 0.03042226f, 0.07573840f, -0.00547611f, -0.05764303f, -0.13960390f, -0.03469206f, 
    0.05156650f, -0.07789724f, 0.11684525f, 0.00821908f, -0.19058460f, -0.17474052f, -0.02836780f, 0.04405854f, 
    -0.02034067f, 0.03597492f, 0.12900510f, -0.00014095f, 0.08905452f, 0.12371337f, 0.11952642f, 0.02623201f, 
    0.14477327f, 0.07109137f, 0.19538562f, -0.17678493f, -0.12723430f, -0.04455462f, 0.03168168f, -0.09975312f, 
    -0.03573024f, 0.10298856f, 0.00135921f, -0.04852941f, 0.18596977f, 0.01172909f, -0.01221692f, -0.13308114f, 
    0.03448663f, -0.00329064f, 0.02889483f, 0.01710836f, -0.02701307f, 0.09972530f, 0.18018445f, -0.04031299f, 
    0.02803752f, -0.04879067f, 0.02525005f, -0.04018592f, 0.04079431f, 0.02782770f, -0.00830126f, 0.03586193f, 
    0.04035625f, -0.04938287f, -0.01512736f, -0.02465899f, 0.03429398f, -0.02043700f, 0.04416831f, 0.00452413f, 
    0.02588635f, -0.00415300f, 0.01513231f, 0.00958352f, 0.01906664f, 0.01745411f, 0.04595086f, -0.04089180f, 
    -0.00821576f, -0.02834729f, -0.05582648f, -0.01961417f, -0.03889002f, 0.03242882f, 0.03737623f, -0.02471374f, 
    -0.00934200f, 0.00920619f, 0.03430849f, -0.00368272f, -0.03732899f, -0.00823018f, 0.05224602f, -0.00770460f, 
    0.00345651f, -0.02568765f, 0.00741984f, -0.00995674f, -0.03780008f, -0.04440092f, 0.01100840f, -0.05025336f, 
    0.00545488f, 0.02314331f, -0.02898588f, 0.02778813f, -0.05222233f, 0.04228166f, -0.03215787f, -0.00490244f, 
    -0.00121247f, 0.04679779f, 0.00354503f, 0.02135205f, 0.01304308f, 0.03958095f, 0.01419264f, 0.04612418f, 
    -0.02254295f, -0.02019258f, -0.02130708f, 0.00721889f, 0.00073733f, 0.03636251f, -0.02392892f, 0.03445118f, 
    -0.03053192f, 0.02569907f, 0.03918555f, 0.03825955f, 0.04270168f, 0.03974945f, -0.01102024f, 0.03137959f, 
    0.02805892f, -0.05182905f, 0.00164481f, 0.03185366f, 0.00571050f, 0.02192045f, -0.04901427f, -0.00558654f, 
    -0.04582552f, 0.00992809f, 0.01937764f, -0.05477057f, -0.03285870f, -0.02976744f, 0.01517891f, -0.03113723f, 
    -0.02189481f, 0.03268472f, -0.00018268f, -0.01263429f, -0.04840837f, -0.01831471f, -0.04340170f, 0.00868076f, 
    -0.04013262f, 0.02717395f, 0.03568390f, -0.01063638f, -0.04593925f, 0.01402097f, -0.03818757f, -0.02483623f, 
    0.01693470f, -0.04714310f, -0.05450686f, 0.02659754f, 0.04343267f, 0.00305302f, 0.03257165f, -0.04978658f, 
    0.00853298f, 0.01320638f, 0.01317024f, 0.00067805f, -0.02524789f, -0.04514808f, 0.00005403f, -0.05785975f, 
    -0.00040334f, -0.00087909f, 0.04004698f, 0.02231649f, -0.03324470f, -0.02396347f, -0.04679113f, 0.02378085f, 
    0.04627489f, 0.03378816f, -0.03315840f, -0.02132716f, 0.00755405f, -0.01078341f, -0.02132192f, -0.04371057f, 
    0.01623807f, -0.04505654f, 0.03513416f, -0.01895280f, 0.03494212f, -0.04322325f, -0.01191570f, -0.05671263f, 
    -0.01278166f, 0.01735418f, -0.00230843f, -0.03078441f, 0.03564114f, -0.03021258f, 0.04103590f, 0.01623790f, 
    0.01550347f, 0.03510702f, -0.01929186f, 0.04468910f, 0.04464780f, -0.04451408f, -0.02428548f, 0.02924070f, 
    0.00334062f, 0.00473566f, 0.02329726f, 0.01610136f, -0.04130630f, 0.00868698f, 0.00997015f, 0.01156793f, 
    0.02307762f, 0.01422394f, -0.05453658f, -0.04037663f, 0.01441678f, -0.00862216f, -0.02034421f, 0.00904199f, 
    -0.03498287f, 0.04455350f, 0.00904930f, -0.00058776f, -0.03275754f, -0.01800612f, 0.01429957f, 0.02794405f, 
    0.03057734f, -0.04143376f, -0.00342864f, 0.02203024f, -0.03614026f, -0.02179312f, 0.00642567f, -0.03331024f, 
    0.03725632f, -0.02300739f, 0.02493599f, 0.01578988f, 0.01819413f, -0.02792883f, 0.03250898f, -0.03056803f, 
    0.04112208f, 0.01456854f, 0.02941754f, 0.04144149f, 0.03814339f, 0.03051316f, -0.06002058f, -0.04447547f, 
    0.02023462f, 0.00793563f, 0.00492787f, -0.00290304f, -0.03467084f, -0.01030723f, -0.04118233f, -0.04492560f, 
    -0.03388905f, 0.01931017f, -0.04512800f, 0.00127969f, 0.02626227f, -0.02669933f, -0.03487499f, -0.04844540f, 
    0.00408205f, 0.03758679f, 0.02620322f, 0.03627220f, -0.01615865f, 0.03650666f, 0.00880496f, 0.01751821f, 
    0.03860954f, -0.02348382f, -0.00176287f, 0.03615098f, 0.04205186f, -0.04696048f, -0.03202553f, -0.03260338f, 
    -0.05051376f, 0.03674496f, 0.00291609f, 0.00778749f, -0.01761830f, 0.01191505f, -0.01651942f, -0.02815620f, 
    -0.02724336f, 0.00893651f, -0.04813677f, -0.02201866f, 0.01218539f, 0.02841961f, -0.03887167f, -0.01469651f, 
    -0.02678771f, 0.05341294f, -0.04832054f, 0.03878164f, 0.04297315f, -0.05072422f, -0.03922459f, -0.03039761f, 
    0.02817972f, -0.02621939f, 0.01050506f, 0.00621081f, -0.02054809f, 0.03952782f, -0.02720060f, -0.05441771f, 
    0.04833528f, -0.01104706f, -0.05707718f, -0.05438709f, -0.03309396f, 0.01819273f, -0.00417240f, -0.05097723f, 
    0.01421049f, 0.01764210f, 0.04291351f, -0.05396659f, -0.02778418f, -0.00989193f, -0.04612325f, 0.02271868f, 
    0.03964357f, 0.00395223f, -0.02829764f, 0.01574131f, 0.02208406f, 0.02348820f, -0.02045575f, 0.02801860f, 
    0.03468319f, 0.03955186f, 0.03447442f, 0.00209540f, -0.01870061f, -0.04953619f, -0.03454515f, 0.03294662f, 
    -0.02022185f, -0.03710308f, -0.01279521f, -0.04664452f, 0.02428243f, 0.05313230f, 0.03364305f, -0.00653230f, 
    0.02865954f, 0.00801942f, -0.05249180f, 0.02645583f, -0.03995587f, -0.05553997f, 0.01579865f, 0.01026419f, 
    -0.02778289f, -0.03583804f, -0.01426215f, -0.03497690f, 0.01010014f, -0.02337730f, -0.00583179f, -0.02888128f, 
    -0.00824239f, 0.02737843f, 0.03632243f, -0.04174741f, -0.01153747f, 0.02948074f, -0.02440285f, -0.03429587f, 
    -0.00126302f, -0.05803650f, -0.00719063f, -0.05328302f, -0.04348620f, 0.01971246f, -0.00168154f, -0.00895334f, 
    0.01913288f, -0.04309831f, 0.02505719f, 0.02858092f, 0.02590586f, -0.01902917f, -0.01178492f, 0.02060635f, 
    0.00147294f, 0.02899329f, -0.05022239f, -0.05390866f, -0.01616275f, 0.04008960f, -0.01237916f, -0.03845659f, 
    -0.04155241f, 0.03570350f, -0.04826178f, -0.04736644f, -0.03557017f, -0.05491228f, -0.02754535f, -0.03931765f, 
    0.01231628f, -0.04302203f, 0.03822852f, -0.04018242f, 0.00188645f, -0.04924594f, 0.01843373f, 0.03560465f, 
    -0.04600343f, 0.08437457f, -0.03734023f, 0.10353932f, -0.03574117f, -0.00150703f, 0.05975264f, 0.05239118f, 
    -0.00813292f, 0.10351822f, 0.13506931f, -0.03652994f, -0.12175031f, -0.10753334f, 0.03552360f, -0.18522786f, 
    -0.06967130f, 0.11054832f, 0.04212758f, -0.11834311f, -0.06373718f, 0.04575104f, -0.09155966f, -0.10478345f, 
    0.07756640f, 0.10648596f, 0.11484056f, -0.08399156f, 0.11582717f, 0.05918734f, 0.05490043f, -0.01971586f, 
    -0.08832198f, -0.03951598f, -0.02527483f, 0.04080482f, 0.13215905f, -0.01235908f, 0.00321288f, 0.32592511f, 
    0.07099412f, -0.06914631f, 0.06177767f, -0.01089459f, 0.17113104f, -0.09772771f, -0.07311720f, -0.09250473f, 
    0.28601497f, -0.02331150f, -0.10007340f, 0.00407211f, 0.03345720f, -0.05042659f, 0.10381085f, 0.12301035f, 
    0.20178144f, 0.11040027f, 0.01105752f, -0.03781170f, 0.06506889f, -0.03838830f, -0.00996875f, 0.16393656f, 
    0.12138056f, 0.12735742f, 0.03190698f, 0.02883991f, 0.02492559f, -0.08030445f, 0.26730829f, 0.10865680f, 
    -0.18417169f, 0.05743780f, 0.25905201f, -0.10143770f, 0.07455895f, 0.02090225f, -0.08976735f, 0.06029165f, 
    0.03946888f, 0.01628900f, -0.19776787f, -0.01868597f, -0.21684718f, 0.32928410f, -0.02306064f, -0.11120928f, 
    -0.05162123f, 0.14050269f, 0.02191200f, -0.02366677f, 0.08565371f, -0.12743115f, 0.13345146f, 0.11317030f, 
    -0.08868297f, -0.01998165f, 0.00239868f, -0.20923787f, -0.09506282f, -0.02710542f, -0.04146364f, 0.02532015f, 
    0.06781986f, -0.13320403f, 0.10379731f, 0.01388162f, 0.23649254f, 0.04749161f, 0.00274135f, 0.01250215f, 
    0.06851786f, -0.10934573f, 0.06865691f, -0.05450829f, -0.20969699f, -0.11557037f, 0.10401499f, -0.00490575f, 
    -0.29875001f, -0.02429037f, 0.19356401f, -0.12812591f, -0.04385305f, -0.06427958f, 0.06708660f, -0.08933848f, 
    -0.02665523f, -0.03733594f, -0.08421300f, -0.01401468f, 0.07372724f, 0.06491458f, 0.43055898f, 0.05357159f, 
    0.18769416f, 0.04380020f, 0.11252996f, 0.14798370f, 0.03146100f, 0.04245164f, -0.02611818f, -0.01559994f, 
    -0.37645391f, 0.26402983f, 0.18081166f, -0.08002160f, -0.04226469f, 0.03884317f, 0.00488760f, -0.12158742f, 
    0.09151586f, 0.11465233f, -0.03201637f, 0.01976790f, -0.13535430f, -0.04504856f, 0.11637343f, 0.10517345f, 
    -0.00367440f, -0.10506433f, 0.15477906f, 0.18354726f, -0.13814725f, 0.20997049f, 0.04298038f, 0.15193756f, 
    0.45312622f, 0.03439167f, 0.16291715f, -0.12070958f, 0.05581973f, 0.12039789f, 0.11723202f, 0.15617195f, 
    -0.04781566f, 0.08483572f, 0.04567197f, 0.12738523f, 0.22063725f, 0.09708655f, -0.13169596f, 0.23391032f, 
    -0.02191297f, 0.18266957f, -0.03217401f, 0.12340797f, -0.01459046f, 0.02844368f, 0.13408200f, 0.14469253f, 
    -0.18504483f, 0.12224942f, -0.03781416f, -0.10229730f, -0.11816796f, -0.07740962f, 0.02613500f, 0.04959692f, 
    0.00797803f, 0.02505261f, 0.08689483f, 0.00379234f, 0.10790613f, 0.10816373f, 0.01250649f, 0.05786503f, 
    -0.05559785f, 0.07255048f, 0.20792650f, 0.03150026f, -0.13037230f, -0.09768016f, -0.14178105f, 0.09135780f, 
    -0.15553200f, -0.05602791f, -0.13034140f, 0.07834641f, 0.01899186f, 0.05735938f, -0.13187271f, 0.03939414f, 
    -0.07668369f, 0.02681223f, -0.04378765f, -0.11575418f, 0.03524109f, -0.01752905f, -0.00614852f, 0.00254905f, 
    -0.03427090f, 0.17672293f, 0.10977514f, -0.00558909f, -0.03539554f, 0.15201350f, -0.09321953f, 0.31847537f, 
    0.16565739f, 0.14507651f, 0.11886290f, 0.00008458f, -0.01891608f, 0.03642005f, 0.04608779f, -0.01938319f, 
    0.13091341f, 0.09093324f, 0.16706097f, 0.03896413f, 0.13434784f, -0.18098937f, 0.12544398f, 0.07047257f, 
    0.08234077f, 0.05831563f, 0.03931192f, 0.00746006f, 0.07603575f, 0.17012696f, -0.01719205f, 0.09491147f, 
    -0.00989582f, 0.01035022f, -0.04364201f, 0.16888112f, 0.08535159f, 0.02097811f, 0.06544731f, 0.05131624f, 
    0.15709825f, -0.04200366f, 0.16633756f, 0.03617026f, 0.12411665f, 0.20470555f, -0.01997085f, 0.09604508f, 
    0.03776458f, 0.11133895f, 0.04004409f, 0.03340228f, -0.16279615f, 0.02135158f, 0.00071593f, 0.03856457f, 
    0.18210888f, 0.09150263f, -0.03266503f, 0.21678631f, 0.03908119f, 0.02387559f, -0.00722148f, 0.02662284f, 
    0.12982979f, 0.10500199f, -0.02943595f, -0.00396311f, 0.06019735f, -0.07456214f, -0.02375268f, 0.11532879f, 
    0.05977799f, -0.08130287f, 0.23406117f, 0.01679286f, -0.05728633f, -0.00389132f, 0.11428061f, 0.09201892f, 
    -0.40744394f, -0.07419975f, 0.18987732f, 0.41821292f, -0.04034484f, 0.06164272f, 0.01240544f, 0.11260784f, 
    -0.01475743f, -0.13819923f, 0.06525344f, -0.03683703f, -0.23118703f, 0.02204058f, 0.08806722f, -0.03412316f, 
    -0.01241731f, -0.02712056f, 0.04774456f, 0.08361961f, 0.02142681f, 0.10410842f, -0.06073129f, -0.04866102f, 
    -0.07058960f, 0.18726254f, 0.04348860f, -0.16952707f, -0.03604124f, -0.03917125f, 0.12872329f, 0.01020943f, 
    -0.08716375f, 0.05812754f, 0.01003909f, 0.02459076f, -0.33131814f, 0.23021854f, 0.25058934f, 0.00917956f, 
    -0.00093405f, 0.16233502f, -0.14592078f, 0.04800492f, -0.03348518f, -0.01986326f, -0.12900022f, 0.00362052f, 
    0.39398414f, 0.14149162f, -0.06493814f, 0.20425987f, 0.09719924f, 0.08098622f, 0.11928433f, 0.20159373f, 
    0.15746340f, 0.11104243f, 0.06316876f, 0.26542518f, 0.04670500f, 0.13497253f, 0.14267573f, 0.04813502f, 
    -0.02568256f, 0.14904574f, -0.06754618f, -0.04111626f, 0.00031286f, 0.12324528f, 0.02790741f, 0.04437244f, 
    0.01648725f, -0.03701576f, 0.02229512f, -0.03146315f, -0.03928813f, 0.01442207f, -0.00782139f, 0.01654741f, 
    0.01673910f, 0.02966327f, 0.04170533f, -0.00217664f, 0.00115136f, 0.02135821f, -0.02525135f, -0.04459143f, 
    -0.00438552f, -0.03429861f, -0.05429603f, 0.01015610f, -0.02148679f, 0.00951556f, -0.03679534f, -0.00928751f, 
    -0.02153697f, -0.00403644f, -0.02710496f, -0.05257923f, -0.05381472f, 0.00183576f, -0.02824520f, -0.04366256f, 
    -0.00111042f, -0.01542278f, 0.02219504f, -0.03091756f, 0.01347662f, -0.03702604f, -0.04680260f, -0.00762693f, 
    0.00100544f, -0.01712170f, -0.02428258f, 0.02682139f, 0.02440950f, -0.04479276f, 0.00181594f, -0.05258268f, 
    -0.04869173f, 0.04537722f, 0.01432382f, -0.01232763f, 0.00715590f, 0.02922726f, 0.02528769f, -0.00948173f, 
    -0.04095228f, -0.01367181f, 0.01872149f, 0.01554955f, -0.04821415f, -0.00833032f, -0.01456653f, -0.03816660f, 
    0.04029195f, 0.01820741f, -0.02109057f, -0.05104734f, 0.02013118f, 0.01675631f, 0.00310540f, 0.02375350f, 
    0.01751439f, -0.02479588f, -0.01356507f, -0.01935554f, -0.02891581f, 0.02633992f, 0.00306995f, 0.01088077f, 
    -0.04392117f, 0.02953066f, -0.03484080f, 0.00396388f, 0.01339221f, 0.03222920f, -0.00213958f, 0.02643956f, 
    -0.03592941f, 0.04419632f, -0.03196983f, 0.00538141f, -0.05151920f, 0.00458932f, -0.02802921f, -0.02463360f, 
    -0.01976943f, -0.04662070f, 0.01853382f, -0.04929709f, 0.03833561f, 0.03261710f, -0.04236975f, 0.03913185f, 
    0.00004023f, -0.04485086f, 0.02990407f, -0.03727788f, -0.05489052f, -0.01156469f, 0.00371275f, 0.01180385f, 
    0.04066249f, -0.01784619f, 0.01896222f, 0.02873579f, 0.01438827f, 0.02674327f, -0.05286436f, -0.03905348f, 
    0.02187776f, -0.03180620f, -0.02155204f, 0.02520823f, 0.02587294f, -0.00696408f, 0.01102726f, 0.00757445f, 
    0.01237487f, -0.02000540f, 0.02624103f, 0.03012921f, 0.03412817f, -0.02355362f, -0.03449080f, -0.00875906f, 
    0.01802784f, -0.03393029f, 0.02749359f, -0.02549894f, 0.03883636f, 0.03501472f, 0.01105677f, -0.03975885f, 
    0.02574896f, -0.00676143f, 0.01243190f, 0.04050476f, 0.01356622f, -0.04777269f, 0.01654029f, -0.03721099f, 
    -0.02030348f, -0.01904305f, 0.01512425f, 0.04261180f, -0.00093344f, 0.02522350f, -0.01677489f, -0.05587502f, 
    -0.01880648f, 0.02350081f, -0.05530985f, -0.04077584f, -0.00589183f, 0.00383428f, 0.01623788f, 0.02646258f, 
    -0.03193585f, 0.03065147f, 0.03270712f, 0.03574224f, 0.03264477f, -0.05591227f, -0.03969885f, 0.03740229f, 
    -0.02325539f, -0.00856593f, 0.03859178f, 0.00814994f, -0.03970718f, 0.01019038f, -0.03711347f, 0.00599477f, 
    -0.00377695f, -0.04284142f, -0.03802355f, 0.04366991f, -0.01661567f, 0.00684210f, 0.00443356f, 0.01437611f, 
    0.03411764f, 0.03330161f, -0.02447207f, 0.04747589f, 0.02046363f, -0.05542900f, 0.03374616f, 0.02971276f, 
    -0.02809386f, -0.02295272f, 0.01808650f, -0.01237420f, -0.05109501f, -0.02557813f, -0.00776061f, -0.00947807f, 
    -0.00187882f, -0.02882566f, -0.05462188f, 0.00509556f, 0.04253155f, -0.00752014f, -0.05573727f, -0.04447045f, 
    -0.00501020f, -0.05479916f, 0.00929711f, 0.04381945f, -0.04208585f, -0.04795742f, -0.05542820f, -0.04925986f, 
    -0.04576225f, 0.02845309f, -0.04879858f, -0.03146997f, 0.02185245f, 0.02117928f, 0.01938637f, 0.03580506f, 
    -0.05139315f, -0.05524449f, -0.01304736f, 0.00988990f, 0.01681519f, -0.00259721f, 0.01007128f, 0.00580933f, 
    -0.02063076f, 0.03914157f, -0.01517109f, -0.05124597f, 0.00654851f, 0.02857294f, -0.00792671f, 0.02628382f, 
    0.03757908f, -0.01695446f, -0.04438131f, -0.01007503f, -0.02599977f, 0.03635672f, -0.01481593f, 0.02073429f, 
    0.02201286f, -0.02143035f, 0.02041107f, 0.00041201f, -0.05374501f, 0.01115504f, -0.04314947f, -0.04890750f, 
    -0.01684218f, -0.02677928f, -0.01873986f, 0.01379187f, -0.02678116f, -0.02832348f, -0.02692026f, -0.03452077f, 
    -0.05561875f, -0.05571910f, 0.00365365f, -0.03168818f, -0.01067837f, 0.00367925f, 0.01100511f, -0.04639606f, 
    0.01762040f, -0.04320092f, 0.03092117f, -0.01881573f, 0.04260603f, -0.05601488f, -0.00051814f, -0.05241252f, 
    0.02103646f, -0.03306047f, 0.04352706f, -0.04865192f, -0.04238260f, 0.02994989f, 0.02061828f, -0.00742994f, 
    -0.03665135f, -0.01652884f, -0.03340041f, 0.03092468f, 0.02232764f, 0.03905727f, -0.02606441f, -0.01472208f, 
    0.01960960f, 0.03597853f, -0.04605705f, 0.00269997f, -0.04652420f, -0.04069906f, -0.00792183f, -0.01706631f, 
    -0.00295826f, -0.00868058f, -0.01782585f, -0.03806268f, -0.04240474f, 0.01843510f, 0.00854298f, -0.00053210f, 
    0.03184487f, -0.03900976f, 0.00382089f, -0.04140997f, 0.02135572f, -0.01004620f, 0.00076217f, -0.04964470f, 
    0.02614819f, -0.00812866f, -0.02033518f, -0.02876353f, -0.00447130f, -0.01595399f, -0.03071588f, -0.05576370f, 
    0.04070178f, 0.02023904f, -0.04613279f, -0.02044609f, -0.01549879f, -0.02767058f, -0.02406105f, -0.04905581f, 
    -0.01198776f, -0.04160361f, -0.00313359f, -0.03255243f, -0.03951819f, 0.03906182f, -0.04090097f, 0.00635883f, 
    -0.03687154f, -0.02053881f, 0.03093451f, 0.03571729f, 0.04456680f, 0.02715377f, -0.00822931f, 0.00745884f, 
    0.02827245f, 0.01300326f, 0.03078657f, 0.02900144f, 0.02814605f, -0.01742592f, -0.03799778f, -0.00913976f, 
    -0.03433044f, -0.01227191f, -0.05042572f, -0.00711766f, -0.05324712f, -0.04532990f, -0.00273217f, -0.05615701f, 
    0.04006032f, -0.03937228f, 0.02095122f, 0.02845149f, -0.03656650f, -0.04971324f, 0.02681101f, -0.02972931f, 
    0.10221939f, 0.02860249f, -0.17005961f, -0.07855233f, -0.09749181f, 0.06546536f, 0.01282293f, -0.08450297f, 
    0.03347788f, 0.00874776f, 0.04924274f, -0.19475593f, 0.11942448f, -0.00006289f, -0.17613208f, -0.06460845f, 
    -0.05500754f, 0.07186948f, -0.02344886f, -0.06703229f, -0.01719819f, -0.01730106f, -0.06638481f, -0.13749725f, 
    0.03381599f, 0.22305077f, -0.02324639f, -0.23089300f, 0.10822947f, 0.01199343f, -0.11346989f, 0.07626852f, 
    -0.07159732f, -0.16733131f, -0.02217947f, 0.10684583f, -0.02983236f, 0.16315146f, -0.15130384f, 0.02017469f, 
    0.08153972f, 0.03418746f, 0.05125472f, 0.06673460f, 0.10658959f, 0.04577684f, 0.03391556f, -0.23610386f, 
    0.13569650f, 0.38074511f, -0.13314234f, 0.08266857f, 0.01812975f, 0.03091063f, 0.02855325f, 0.05339088f, 
    0.04098516f, 0.10789795f, 0.02081724f, 0.01494926f, 0.11008442f, 0.20269622f, 0.08896917f, 0.15117162f, 
    -0.14005263f, -0.00742941f, -0.10999019f, 0.11035885f, -0.01486716f, 0.00582752f, 0.24817230f, 0.05300337f, 
    0.12463795f, -0.04684512f, -0.15725213f, 0.09950384f, 0.07788344f, -0.07124983f, 0.03538973f, 0.11725654f, 
    0.00736198f, 0.02184070f, -0.07205261f, -0.04713364f, 0.01408472f, 0.14592095f, -0.11467319f, -0.09975543f, 
    -0.04939085f, 0.02222533f, 0.07131766f, 0.10777479f, 0.13783449f, -0.09797245f, 0.18571177f, -0.07989430f, 
    0.12653680f, -0.12994009f, 0.07190760f, -0.02641049f, 0.04158499f, 0.04073783f, -0.02395226f, -0.02480223f, 
    -0.06602943f, -0.07342430f, 0.06498665f, 0.16744161f, 0.14814284f, 0.09395234f, 0.07875570f, -0.03390201f, 
    -0.02329472f, 0.03689262f, -0.02014283f, 0.04066163f, -0.06911241f, 0.02370429f, -0.05061021f, 0.08567688f, 
    0.28475082f, 0.12573490f, 0.02109826f, 0.04843417f, 0.01055289f, -0.03077663f, 0.13956517f, 0.01124841f, 
    0.06583551f, -0.01038794f, -0.06876809f, -0.03065248f, 0.23274830f, -0.11768658f, -0.04995828f, 0.00221739f, 
    -0.08059157f, 0.00885745f, 0.03600758f, -0.08986475f, -0.06751806f, -0.04988797f, 0.03746041f, -0.08481146f, 
    0.26023382f, -0.00357205f, -0.00955296f, -0.33421037f, -0.09210981f, -0.05711059f, 0.01413326f, 0.05261007f, 
    0.01321005f, 0.10876734f, 0.03169030f, 0.01712801f, 0.00252691f, -0.17764927f, 0.25507286f, 0.19167255f, 
    -0.06778841f, -0.09108503f, 0.13415432f, 0.05807913f, -0.11853863f, 0.12731403f, 0.09048630f, 0.10634425f, 
    0.11326906f, 0.01141596f, 0.17386812f, -0.18506427f, -0.12150002f, 0.25356525f, 0.12316436f, -0.11126184f, 
    -0.04424665f, -0.00737087f, 0.02387592f, -0.04436586f, -0.01309691f, 0.21697745f, 0.00385417f, 0.24339887f, 
    0.03491377f, -0.11455298f, 0.08115256f, -0.08824667f, -0.06166327f, 0.06438443f, 0.01739574f, 0.16609469f, 
    -0.18155706f, -0.05219497f, 0.04247946f, -0.02605082f, 0.13675462f, -0.11671610f, -0.05992761f, 0.04513811f, 
    -0.08773713f, 0.14613007f, 0.07549422f, -0.14056410f, -0.09317812f, 0.25174057f, -0.11807068f, -0.04351139f, 
    -0.03156450f, -0.01209874f, 0.15994170f, -0.02402424f, -0.06399001f, -0.07002556f, -0.16556185f, -0.06453885f, 
    0.14455050f, -0.01423412f, 0.09819358f, 0.14941762f, 0.00569138f, 0.02707704f, -0.04781704f, 0.00164359f, 
    0.00516804f, -0.01406238f, -0.07996602f, -0.18202552f, 0.02609861f, 0.30067334f, -0.30894279f, -0.21584181f, 
    -0.04733384f, -0.07800294f, -0.05169460f, -0.10884584f, -0.02485259f, 0.15690242f, 0.03021989f, 0.25002551f, 
    -0.05520535f, 0.06835984f, -0.12935688f, -0.03330741f, -0.08299629f, 0.16267604f, 0.09567657f, 0.02998932f, 
    -0.01118685f, 0.03448582f, 0.08462082f, 0.03305463f, 0.20935865f, 0.05825169f, -0.03958966f, 0.16001374f, 
    -0.02706270f, -0.12451968f, 0.18225650f, 0.04635720f, -0.05611943f, 0.16232038f, -0.15965417f, -0.05257221f, 
    0.09821741f, 0.05511123f, -0.01665970f, 0.24024826f, -0.00859238f, 0.04365750f, -0.05489467f, 0.17272812f, 
    0.11108583f, -0.06801657f, 0.09287938f, -0.00990585f, 0.21460795f, 0.04325433f, -0.06181577f, 0.20828047f, 
    0.09162705f, 0.07517868f, -0.02769358f, -0.04800617f, -0.15130675f, -0.00410938f, -0.00294182f, -0.06465602f, 
    0.35675195f, 0.10952175f, -0.22652996f, 0.16132709f, -0.01947434f, 0.10330632f, -0.10557315f, 0.12069610f, 
    -0.12607436f, 0.04049640f, -0.05902868f, -0.04922875f, -0.01147729f, -0.00679543f, 0.09961110f, 0.04532671f, 
    0.00677051f, 0.09130351f, 0.11893323f, 0.11485216f, -0.06552601f, 0.04268096f, 0.01642621f, -0.05886309f, 
    -0.14113903f, 0.03495108f, 0.15011434f, 0.09594458f, 0.00039193f, -0.12283017f, 0.18506707f, 0.10237503f, 
    -0.05057524f, 0.07372479f, -0.05248031f, -0.06888020f, -0.17045446f, -0.09430394f, 0.01899109f, -0.05084404f, 
    -0.06331346f, -0.08177362f, 0.10693602f, 0.17341173f, -0.04603323f, -0.03811223f, -0.16710913f, -0.04616798f, 
    -0.12527451f, -0.07102574f, -0.23207293f, -0.17015558f, 0.01732093f, 0.00823236f, 0.12351711f, 0.04194057f, 
    0.00438480f, 0.05031070f, -0.08532609f, -0.09589550f, 0.04318367f, 0.02179958f, -0.12898636f, -0.09235889f, 
    0.11699671f, 0.01974333f, -0.17084438f, 0.02114206f, -0.06390686f, -0.04483208f, -0.12303425f, -0.05049801f, 
    0.04483145f, 0.23391327f, -0.02098143f, 0.09602132f, 0.14159673f, -0.00603709f, 0.00529347f, 0.12599677f, 
    0.09835670f, 0.02791171f, 0.03110508f, 0.11097076f, -0.25955364f, 0.11532703f, -0.01844302f, 0.05141507f, 
    0.00809685f, 0.08603019f, -0.06440797f, -0.03742202f, 0.05044881f, 0.05925077f, -0.18856171f, -0.07164304f, 
    0.01323343f, -0.01770239f, -0.04019498f, 0.03253134f, 0.03849325f, 0.05135640f, 0.03924100f, -0.02043064f, 
    -0.03311178f, 0.02867579f, -0.01723570f, -0.06050816f, 0.03601912f, 0.04416490f, -0.03883082f, -0.03300926f, 
    -0.05176738f, 0.03801176f, 0.02149099f, 0.02166310f, -0.03279690f, -0.04805944f, -0.04065990f, -0.03216154f, 
    -0.01704031f, -0.00686697f, -0.01529491f, -0.04739096f, -0.03728359f, -0.03518672f, 0.04842807f, 0.01570671f, 
    -0.02349561f, 0.04594326f, 0.01912287f, -0.01305155f, -0.04795596f, -0.01795955f, -0.01467093f, -0.01096164f, 
    0.02611338f, -0.04484652f, -0.04027459f, 0.01110789f, -0.05603759f, 0.04385445f, 0.03937725f, -0.05088175f, 
    0.04123193f, -0.00274475f, -0.04057196f, -0.02527206f, -0.02756978f, 0.00703020f, 0.00612796f, -0.02191410f, 
    0.04533625f, 0.01885558f, -0.02116255f, -0.02932190f, -0.01327551f, 0.01656880f, -0.04591862f, 0.03291148f, 
    0.03857750f, 0.05136437f, -0.00374692f, 0.01529997f, 0.01759818f, -0.03789767f, -0.05611253f, -0.01565454f, 
    0.00161458f, -0.02205435f, -0.01034861f, 0.03434173f, -0.04935095f, -0.03368540f, 0.01091909f, -0.04243112f, 
    -0.03553088f, -0.02530094f, 0.02200896f, -0.00083111f, -0.00154000f, -0.00975754f, 0.02979766f, 0.03515236f, 
    -0.04576111f, -0.01019627f, -0.03185565f, 0.00771046f, -0.01208046f, -0.01358413f, -0.03098575f, -0.02263490f, 
    -0.04440170f, 0.00573783f, -0.02566411f, 0.01274426f, 0.00558193f, 0.01716703f, 0.02797784f, -0.05551364f, 
    -0.00449884f, -0.00662910f, -0.02268775f, -0.01244725f, -0.01399251f, 0.04449885f, -0.04581651f, 0.04921294f, 
    -0.03461187f, -0.02895954f, 0.00323892f, -0.03434335f, 0.03499261f, -0.05557923f, 0.03885145f, 0.00331110f, 
    -0.00721551f, -0.02751449f, -0.01777883f, 0.02617672f, 0.02170768f, -0.04284699f, 0.02460174f, 0.01529503f, 
    -0.00098903f, 0.02338751f, -0.04087601f, 0.01219727f, -0.02874349f, 0.04967412f, -0.03958866f, 0.00481977f, 
    0.02924644f, -0.04809342f, -0.01040099f, 0.03137160f, -0.03030044f, 0.05160073f, 0.03132772f, -0.02679795f, 
    -0.00526556f, 0.00933527f, 0.01954237f, -0.05311107f, 0.02327118f, -0.02326893f, -0.00739492f, 0.04829630f, 
    0.03685090f, 0.02002695f, -0.03107072f, -0.03752889f, 0.03575944f, -0.02608667f, -0.00025907f, 0.03005203f, 
    0.02571441f, -0.00975890f, -0.00200524f, 0.02982106f, -0.04656202f, 0.00681596f, -0.02083861f, -0.00801462f, 
    0.00879670f, -0.00951373f, -0.04858954f, 0.01254660f, 0.01560856f, -0.02103351f, -0.01208645f, -0.02583118f, 
    -0.02816583f, 0.01167437f, 0.00619424f, 0.04424684f, -0.01811852f, 0.00369148f, -0.00401898f, -0.01349836f, 
    -0.01334091f, 0.01034296f, 0.03722686f, -0.03433959f, 0.00289077f, -0.03561702f, -0.01019595f, -0.02259828f, 
    -0.02490200f, -0.05118437f, 0.02977006f, 0.02422093f, -0.02012835f, 0.00805657f, -0.02582146f, -0.06079739f, 
    0.00543699f, -0.05625666f, -0.04750451f, -0.04465182f, -0.03476477f, -0.01438976f, -0.04865998f, -0.05558302f, 
    -0.03222703f, 0.02406900f, -0.04952966f, 0.00341405f, -0.03796440f, -0.00526238f, 0.04136437f, -0.04470379f, 
    0.04636712f, -0.02722322f, -0.04618913f, 0.01071840f, 0.04016852f, 0.03351431f, 0.03562906f, 0.04425058f, 
    0.01327095f, -0.01699478f, 0.02121693f, -0.01759121f, 0.00219259f, -0.01071794f, 0.03294118f, 0.03642245f, 
    0.03410813f, 0.03907946f, -0.00416480f, -0.03669944f, 0.00742620f, -0.05302931f, 0.04189726f, -0.03968900f, 
    -0.04482036f, -0.03719210f, 0.04415033f, 0.05434885f, 0.00529759f, 0.02053612f, -0.00081629f, -0.02160743f, 
    0.02107622f, -0.04515358f, 0.04785709f, -0.05261435f, -0.01889295f, 0.03135824f, 0.01056391f, -0.05559174f, 
    -0.02899518f, -0.00569601f, -0.02082361f, 0.02538318f, 0.02573597f, 0.04459651f, 0.00519558f, -0.00219384f, 
    0.01761047f, 0.01703373f, 0.01961529f, -0.00469375f, 0.00138702f, 0.03234009f, -0.00298760f, 0.04348547f, 
    -0.05658559f, -0.02878722f, 0.00710338f, -0.04662772f, -0.04920214f, 0.03149919f, 0.05059062f, -0.03499109f, 
    -0.04017075f, -0.05435756f, -0.05541872f, 0.00979406f, 0.00762236f, 0.03262955f, -0.05481129f, 0.04351245f, 
    -0.05398663f, 0.02021589f, -0.02421119f, -0.00712186f, 0.03779554f, -0.01165025f, 0.01013329f, 0.02227946f, 
    0.02989392f, 0.01616889f, 0.00431479f, 0.03302336f, 0.03728469f, 0.01379923f, -0.03121463f, -0.00699235f, 
    -0.00542100f, 0.01954889f, -0.01017010f, -0.03355874f, -0.01698919f, -0.02442412f, -0.03831214f, -0.03306898f, 
    0.00700171f, -0.00638415f, -0.05000668f, -0.05250442f, 0.03418964f, -0.01508566f, 0.01741234f, 0.04032088f, 
    -0.02517300f, 0.02000894f, 0.04834351f, 0.01945386f, 0.02640863f, 0.03061620f, -0.00665223f, -0.05553500f, 
    0.03668073f, -0.03589703f, -0.00219479f, -0.04916798f, -0.03011810f, 0.00657932f, -0.04342067f, 0.00075325f, 
    -0.00666283f, 0.00708207f, -0.00612530f, -0.01904821f, 0.02850354f, 0.04843617f, -0.00736094f, -0.03732714f, 
    -0.02882664f, -0.04140035f, -0.02473066f, -0.01728233f, 0.01984167f, 0.02077232f, 0.00318492f, 0.04503807f, 
    -0.02275485f, -0.00081109f, 0.01810836f, 0.01026484f, -0.00152002f, 0.02069882f, -0.02940603f, -0.04189892f, 
    -0.00857261f, 0.01993503f, -0.05105278f, 0.01274578f, -0.02628674f, -0.02372732f, -0.00412148f, 0.04023951f, 
    0.02218939f, 0.03851406f, 0.01996231f, 0.00907258f, 0.00624090f, -0.04634748f, -0.00211767f, 0.01586735f, 
    -0.01936796f, -0.04429331f, 0.01621304f, -0.03646710f, 0.00138308f, -0.03893993f, 0.01178022f, -0.01802953f, 
    0.03010738f, 0.09150482f, 0.04849384f, -0.11551460f, 0.06640080f, 0.00304333f, 0.04078593f, 0.08531060f, 
    0.05776564f, 0.00607925f, 0.00843041f, 0.07041003f, -0.08927756f, 0.05695811f, 0.13855693f, 0.26241329f, 
    0.13320333f, -0.08465420f, 0.05253117f, 0.05407053f, 0.08864133f, 0.00390079f, 0.00619547f, 0.11223304f, 
    -0.07332528f, -0.09367970f, 0.10431758f, 0.15258533f, -0.10118301f, -0.00667225f, 0.09070561f, 0.09385671f, 
    0.13532858f, 0.05652164f, 0.01555133f, -0.12626070f, -0.03838091f, -0.02995985f, 0.05209082f, -0.19127299f, 
    0.03088515f, 0.06022570f, 0.00504036f, 0.06067230f, -0.02472205f, 0.06132622f, 0.09147595f, 0.11048637f, 
    -0.08063721f, -0.02208136f, 0.11424503f, -0.01549233f, -0.10415462f, -0.02308287f, 0.04334229f, -0.06100815f, 
    -0.04985129f, -0.12967288f, 0.04146340f, -0.00606279f, 0.04605380f, -0.11965845f, -0.01392447f, -0.12601691f, 
    -0.03311850f, -0.00150240f, -0.00283558f, -0.09563987f, 0.07364783f, 0.07822682f, -0.14621507f, 0.02306817f, 
    -0.04576971f, 0.07449940f, 0.09023535f, 0.11219064f, 0.02870497f, 0.13691348f, -0.02646811f, 0.00768702f, 
    -0.01474920f, 0.01494229f, 0.19959535f, 0.02902731f, 0.11405585f, -0.28940168f, 0.16838314f, 0.22387098f, 
    0.00678220f, 0.02557426f, -0.01466306f, -0.01328356f, -0.07314564f, 0.19763502f, -0.15009540f, 0.08948249f, 
    0.26538435f, 0.03131244f, -0.02930168f, 0.16835396f, -0.05619289f, 0.03327691f, 0.07563806f, 0.03041143f, 
    0.00903175f, 0.02723800f, -0.06241660f, -0.00876393f, -0.16055591f, 0.05159400f, 0.04419127f, 0.06853482f, 
    -0.11546510f, 0.03330157f, 0.01358425f, 0.01236793f, 0.08158315f, -0.02117317f, 0.03416356f, -0.05554402f, 
    0.22213742f, 0.02893964f, -0.12798408f, 0.09483055f, -0.06589963f, 0.15765145f, 0.02466300f, 0.07461246f, 
    -0.02146679f, 0.00832065f, 0.12612686f, 0.03646137f, -0.08446383f, -0.12475546f, -0.02911767f, 0.08386769f, 
    0.06371612f, 0.03058334f, -0.02545449f, 0.03863885f, 0.08361126f, 0.01854370f, 0.03924626f, 0.07707813f, 
    0.08638752f, -0.16466454f, -0.05174739f, 0.33276364f, 0.08384766f, 0.01085282f, 0.07491566f, 0.05910135f, 
    0.05697669f, -0.11935680f, 0.09586621f, 0.03527708f, 0.15295647f, -0.02123438f, -0.23652616f, -0.11509407f, 
    -0.02689388f, 0.03463566f, -0.00247602f, -0.06893958f, 0.06466410f, -0.06840756f, -0.10942636f, -0.06856252f, 
    -0.41120240f, -0.11901481f, 0.05619968f, 0.17037274f, 0.09669162f, -0.08049729f, -0.04466954f, -0.03697744f, 
    0.04685264f, 0.03636410f, -0.09754472f, -0.00760531f, 0.01352313f, -0.27334163f, -0.00967899f, -0.25245941f, 
    -0.03852820f, -0.03350962f, 0.09740417f, 0.05412107f, 0.00358007f, 0.03276834f, -0.08040655f, -0.14049909f, 
    0.30450416f, -0.09541544f, 0.07635488f, 0.13840717f, -0.02599888f, 0.13080220f, 0.02095678f, -0.01567014f, 
    0.03963071f, -0.02534141f, -0.05433282f, 0.16983402f, -0.10003889f, -0.11433022f, 0.14434491f, 0.04533336f, 
    0.09631157f, 0.00151271f, -0.20302305f, 0.07887884f, 0.20911561f, 0.14306526f, 0.22490855f, 0.05374170f, 
    0.01827527f, -0.00893966f, 0.05002611f, -0.12047406f, -0.18459144f, -0.02384608f, 0.12866816f, -0.08261140f, 
    0.07819735f, 0.05429661f, 0.05767503f, 0.14689842f, -0.03476416f, -0.07217109f, 0.16259812f, 0.16159713f, 
    0.07074513f, -0.01819348f, -0.00505003f, 0.14060971f, 0.01647840f, -0.12909919f, 0.12701374f, -0.14393429f, 
    0.18219145f, -0.01017470f, 0.12931316f, 0.14201781f, 0.05315770f, -0.04675370f, -0.01651306f, -0.04884261f, 
    -0.12931097f, 0.00216242f, -0.06040452f, -0.01993646f, -0.10979362f, 0.20137914f, -0.00034258f, -0.11469828f, 
    0.01419903f, 0.10568513f, -0.12179057f, 0.05289245f, -0.08602452f, -0.19801326f, 0.01475192f, 0.06588450f, 
    -0.07897104f, -0.02485212f, -0.03944707f, -0.16107585f, -0.00473437f, -0.01768296f, 0.05774901f, 0.03755384f, 
    -0.10978891f, 0.17081669f, -0.12113125f, 0.09556744f, 0.10613818f, -0.13323987f, 0.01050880f, 0.02598724f, 
    -0.05534665f, -0.01595567f, -0.02598683f, 0.11774220f, 0.14555778f, 0.01292912f, -0.07151840f, 0.04458814f, 
    -0.22407535f, -0.05063630f, 0.10724056f, -0.07502072f, 0.00185881f, -0.08354482f, 0.12313505f, -0.00465349f, 
    -0.01425963f, -0.09902447f, 0.05791186f, 0.08390319f, -0.15877548f, 0.21634877f, -0.04960086f, 0.01723069f, 
    -0.03418383f, 0.00211375f, -0.11238275f, -0.04422838f, 0.14429377f, 0.07404882f, -0.09497666f, 0.01591565f, 
    0.27113453f, 0.04514134f, -0.11710183f, -0.11865318f, 0.04104337f, 0.06864695f, -0.10222860f, -0.01697507f, 
    -0.09578329f, 0.00946136f, 0.01397004f, 0.02042801f, 0.13439862f, 0.00103390f, 0.00521055f, 0.02601033f, 
    0.08314301f, 0.11123736f, -0.05637169f, -0.14579093f, -0.03685142f, -0.07563213f, 0.20222765f, 0.08385628f, 
    0.27669847f, -0.10037401f, 0.17242189f, 0.18941322f, -0.10330463f, 0.04657880f, -0.06849992f, 0.07549318f, 
    0.06420498f, -0.04264646f, 0.04986157f, 0.10254009f, 0.07306533f, -0.24721470f, 0.08688740f, 0.17927989f, 
    0.03689229f, 0.04690034f, 0.10489689f, -0.01476403f, 0.07544132f, -0.04925324f, 0.14473836f, 0.11607722f, 
    -0.16160725f, -0.09540612f, 0.03183967f, -0.09738240f, -0.19150710f, -0.00821223f, 0.01162685f, -0.11215045f, 
    -0.07382108f, -0.01093480f, 0.09208132f, -0.06009906f, 0.22236294f, -0.11372702f, 0.05424853f, 0.03377786f, 
    0.01919353f, 0.03336274f, 0.03848562f, 0.02429312f, 0.05893737f, -0.15311331f, 0.04677923f, 0.03444383f, 
    -0.03937953f, 0.00143742f, 0.00978125f, -0.03896140f, 0.02945968f, -0.02432758f, 0.02677129f, -0.02828726f, 
    0.03135542f, -0.03823825f, 0.03169506f, -0.03445435f, 0.01659781f, -0.04564319f, -0.00721630f, -0.05623009f, 
    0.02093237f, 0.01503254f, -0.01031428f, 0.03347507f, 0.00208074f, -0.03613057f, 0.02118990f, -0.02173904f, 
    -0.05225781f, -0.01010636f, -0.00142854f, -0.03398367f, -0.02408554f, 0.01676624f, 0.02803256f, -0.04650187f, 
    0.00999365f, -0.04976775f, 0.03093593f, 0.00930645f, -0.04225251f, 0.00805753f, 0.01965487f, -0.03222011f, 
    -0.04633597f, -0.04116167f, -0.02186255f, -0.02320786f, 0.03301924f, -0.01531173f, -0.03908932f, -0.03400736f, 
    -0.05293016f, -0.03282542f, -0.04332567f, -0.00566430f, 0.03808441f, -0.03279746f, -0.05783216f, 0.03298572f, 
    -0.05624981f, -0.02350619f, 0.03134822f, 0.02968694f, 0.00517462f, -0.00769764f, -0.02633798f, -0.02884725f, 
    0.04304812f, -0.03294867f, -0.03765223f, -0.00983168f, -0.03499070f, -0.00818925f, -0.05247624f, 0.03175685f, 
    -0.01007535f, -0.05587367f, 0.00039346f, -0.05263545f, -0.01619183f, -0.04311633f, -0.00311940f, 0.02050969f, 
    0.02066215f, 0.03121035f, -0.02270302f, -0.05119199f, -0.01474063f, -0.00804590f, -0.02752986f, 0.03505964f, 
    0.00663032f, -0.01394929f, -0.01216802f, -0.02063229f, 0.04065955f, -0.04526610f, -0.05574784f, 0.03822657f, 
    0.00768000f, -0.01038237f, 0.03650241f, 0.02693785f, -0.03838097f, 0.02183719f, -0.01506971f, 0.00287498f, 
    -0.00289454f, 0.04008785f, -0.00187702f, -0.03454182f, 0.01142585f, 0.00859209f, -0.00264480f, -0.03436601f, 
    0.01330224f, 0.02669910f, -0.00637530f, -0.04471842f, 0.03758373f, 0.04027848f, 0.02560949f, 0.00949531f, 
    0.00012231f, 0.03045000f, 0.02016210f, -0.02249429f, 0.02773753f, -0.05197624f, 0.00744606f, -0.05169370f, 
    -0.04689895f, -0.01484378f, -0.04417247f, -0.04706994f, -0.04868097f, 0.01024614f, 0.01078126f, -0.03989933f, 
    0.03863836f, -0.03615598f, -0.01976547f, -0.04549242f, -0.02253823f, -0.04177533f, -0.01838174f, -0.01346932f, 
    -0.02936797f, 0.01848313f, -0.01009034f, 0.02576238f, -0.03589462f, 0.00452240f, 0.02356009f, 0.00452618f, 
    -0.02035246f, 0.00838814f, 0.02319392f, 0.01152573f, 0.01275878f, 0.01950556f, 0.02881163f, -0.00157548f, 
    -0.01989598f, 0.04031124f, 0.03131936f, -0.04015291f, 0.03428168f, -0.01639857f, 0.04178213f, 0.00276095f, 
    0.01480388f, -0.02715235f, -0.04658650f, 0.03838222f, -0.02592229f, 0.01702940f, 0.01401845f, 0.01568953f, 
    -0.03462706f, -0.00266002f, 0.01677639f, -0.00645612f, -0.03697017f, -0.04610431f, -0.05014974f, -0.04175800f, 
    -0.01877683f, -0.00473229f, 0.04067703f, 0.00280055f, -0.00106684f, -0.01505549f, -0.05347700f, -0.01521272f, 
    0.01556746f, 0.00803126f, -0.05168109f, -0.01626713f, 0.00534237f, -0.05186449f, 0.01572523f, -0.01993116f, 
    -0.03767375f, -0.01009755f, 0.00432053f, -0.02476805f, -0.00656625f, 0.00601631f, 0.01821824f, 0.00933593f, 
    0.01724155f, -0.04353031f, -0.05409366f, 0.02096378f, 0.00167960f, 0.02594814f, 0.04193280f, 0.03723172f, 
    0.03290740f, -0.04799377f, -0.04803001f, -0.02984522f, 0.03573326f, -0.02471141f, 0.01137160f, 0.03779197f, 
    0.01172280f, -0.00072578f, 0.02317857f, 0.01481555f, -0.05057123f, -0.04883705f, 0.02167269f, 0.04321975f, 
    -0.04848684f, -0.00435422f, -0.03929218f, -0.01905699f, 0.04076736f, 0.02538113f, -0.04638406f, 0.02956028f, 
    0.03353692f, 0.01419271f, -0.01764603f, -0.02500951f, -0.00958352f, 0.01202951f, -0.03336244f, -0.01010360f, 
    0.01150608f, -0.02048091f, -0.04777232f, -0.00998277f, -0.02764256f, 0.01015688f, -0.00523460f, 0.01613062f, 
    -0.00815167f, -0.01187362f, -0.00737231f, -0.01703638f, -0.03824861f, 0.03157751f, -0.00418966f, -0.04038524f, 
    0.00464130f, -0.05724487f, 0.03283302f, -0.04826415f, 0.01369475f, 0.02508421f, 0.00270549f, -0.01808342f, 
    0.03106482f, -0.04764732f, 0.03187731f, -0.00515310f, -0.02535770f, -0.03381966f, 0.03922202f, -0.05391144f, 
    -0.04422417f, -0.05254494f, 0.00080182f, -0.02474535f, -0.02009174f, -0.05356768f, 0.03826810f, 0.00171880f, 
    0.00470123f, -0.02291554f, 0.04358070f, -0.03175576f, -0.01538833f, 0.00613834f, -0.01232054f, -0.05135697f, 
    0.02258287f, 0.01542140f, 0.02768913f, 0.00909782f, -0.00031309f, -0.01084836f, -0.01749931f, -0.05524609f, 
    0.03241304f, -0.00294490f, -0.03195200f, -0.02799733f, -0.05369129f, 0.01704274f, -0.01740927f, -0.03143469f, 
    -0.04218785f, 0.03842951f, 0.04205096f, 0.01897916f, 0.00974700f, 0.03263170f, -0.00977690f, -0.05632692f, 
    -0.03479345f, 0.03011822f, 0.01969864f, -0.03445478f, -0.05267320f, -0.02223968f, -0.04418050f, 0.03003757f, 
    0.04226858f, -0.01032112f, 0.04130082f, 0.02076479f, 0.00518918f, -0.02436779f, -0.02600446f, -0.03498643f, 
    -0.02910645f, -0.04240527f, -0.02678676f, 0.04166349f, -0.05090151f, 0.02049876f, -0.02177695f, -0.03801548f, 
    0.00468884f, -0.02935559f, -0.00131472f, -0.04697263f, 0.02112026f, -0.02687163f, -0.02977720f, -0.01452744f, 
    0.04467215f, -0.05137618f, 0.01026587f, -0.04175562f, 0.00638602f, -0.04976150f, -0.03633675f, -0.01892486f, 
    0.01221507f, -0.03756769f, 0.03913846f, 0.00678557f, -0.01180416f, -0.01904193f, 0.02718863f, 0.02509373f, 
    0.01681533f, 0.04126248f, 0.03415907f, -0.01310143f, 0.02439287f, -0.02141214f, -0.03816523f, -0.05570488f, 
    0.03550110f, -0.00804980f, 0.00495057f, 0.02636908f, -0.02397238f, -0.02634934f, -0.00599673f, -0.01005163f, 
    -0.34391379f, 0.23183201f, 0.11264136f, 0.02678088f, 0.00346426f, -0.28030005f, -0.09233532f, -0.03147129f, 
    -0.06272212f, -0.02873950f, -0.07147055f, 0.09332903f, 0.13334587f, -0.26380363f, -0.19361649f, 0.05802077f, 
    0.12175953f, 0.03393368f, -0.13057217f, 0.12244590f, 0.03519495f, -0.02322335f, 0.00518219f, 0.11756255f, 
    0.17541379f, 0.05466475f, 0.13565823f, -0.15556735f, 0.02800832f, -0.12742363f, 0.02809757f, 0.01264544f, 
    0.05610442f, 0.00314848f, 0.10378015f, -0.05615897f, 0.14194071f, 0.29987621f, -0.04657536f, 0.30898052f, 
    -0.12335745f, -0.02925201f, -0.11434839f, -0.18607455f, 0.02001842f, 0.08054785f, -0.09555931f, -0.00030690f, 
    -0.23115918f, -0.33552802f, 0.32404354f, 0.05091363f, -0.05987785f, 0.08862020f, 0.05976206f, -0.00481943f, 
    -0.07834435f, 0.13423236f, -0.00054445f, 0.19907071f, -0.07341404f, 0.12223130f, 0.10485636f, -0.07103646f, 
    0.07937963f, -0.02256783f, 0.14292809f, -0.01492248f, -0.06993057f, 0.16767132f, -0.17695433f, -0.05937167f, 
    0.18054688f, -0.29615328f, 0.05017297f, 0.45558658f, 0.08077689f, -0.14133792f, 0.00377922f, 0.06712276f, 
    -0.09130295f, -0.04707074f, 0.14116307f, 0.15337658f, 0.01700207f, -0.10006136f, -0.03545714f, 0.01867713f, 
    0.09309866f, 0.02183431f, 0.07785086f, -0.13514791f, 0.06711468f, -0.03961494f, 0.06844701f, -0.14595194f, 
    -0.35257295f, 0.14745529f, 0.22219001f, -0.15455204f, 0.12366442f, -0.10447350f, 0.14990886f, 0.14856361f, 
    0.08325215f, -0.06216167f, 0.04339651f, -0.07593834f, -0.16958609f, 0.00420803f, -0.01246597f, -0.02570950f, 
    0.03973246f, 0.15720566f, 0.06638282f, 0.10793633f, 0.06477825f, -0.15462923f, 0.12734342f, -0.02340834f, 
    -0.34290445f, 0.31448504f, -0.00120438f, -0.02592887f, 0.03915590f, -0.10998736f, 0.05308811f, -0.05802515f, 
    0.02634730f, 0.00581180f, 0.00839412f, -0.07959045f, 0.45495731f, -0.12611020f, 0.07764705f, 0.32982919f, 
    0.04820244f, -0.12655912f, 0.02228344f, -0.01765518f, 0.03385394f, -0.02554461f, 0.06429705f, 0.07955778f, 
    0.52448332f, -0.26991978f, -0.39322993f, -0.05202585f, 0.12907186f, 0.08285607f, -0.12391324f, -0.06512921f, 
    0.08823290f, -0.07184117f, 0.19045322f, -0.04158679f, 0.06587699f, 0.13973360f, 0.22232991f, -0.07667185f, 
    -0.05054217f, 0.13844624f, 0.18429868f, -0.02705685f, -0.10483486f, 0.07704718f, 0.09517460f, -0.22903638f, 
    -0.18918794f, -0.10507705f, 0.24480847f, -0.04983734f, 0.02915785f, -0.11917873f, -0.00537070f, 0.03397597f, 
    0.06795692f, -0.01139369f, -0.08428126f, 0.01779378f, 0.26025969f, 0.50529742f, 0.06475066f, 0.11052465f, 
    0.12844093f, 0.04188031f, -0.02140805f, 0.10159642f, 0.23556416f, 0.16743046f, 0.11192855f, 0.07197579f, 
    0.03131657f, 0.11391585f, 0.04486357f, -0.18744519f, 0.07497611f, -0.08343091f, 0.15426961f, -0.18780160f, 
    0.01110911f, 0.06446932f, -0.28046963f, -0.04742849f, -0.01944153f, 0.05498235f, 0.12464420f, 0.03815168f, 
    -0.03403109f, 0.02463194f, -0.11840196f, 0.10007206f, 0.07222851f, -0.09806239f, 0.05022050f, 0.00168968f, 
    0.08680176f, 0.06450170f, -0.15796776f, -0.03742857f, 0.02723499f, 0.12941414f, -0.06131962f, -0.07370165f, 
    0.09554621f, -0.13934985f, -0.01488733f, -0.01462376f, 0.17655288f, 0.23131604f, -0.11440980f, 0.21278691f, 
    0.26911917f, -0.12393913f, -0.09332017f, 0.02628616f, 0.06561921f, -0.00097614f, 0.03555455f, -0.17144096f, 
    -0.13358709f, -0.13301846f, 0.04890542f, -0.27325928f, 0.04605006f, 0.00276752f, -0.03364907f, 0.10170788f, 
    -0.00848537f, 0.23943132f, -0.03052082f, 0.02560156f, -0.23881760f, 0.18595581f, -0.02631760f, -0.14566207f, 
    0.00345645f, 0.06101163f, -0.01636823f, -0.07400464f, 0.11274856f, -0.03090456f, -0.04258144f, -0.03062246f, 
    0.03546529f, 0.15875657f, 0.20998074f, 0.12588283f, 0.05435351f, -0.03308076f, -0.01125201f, -0.14073436f, 
    -0.05944803f, 0.08390047f, 0.06171725f, -0.08191311f, 0.48808554f, 0.16465530f, 0.06985446f, 0.30547658f, 
    0.11324491f, -0.02716175f, 0.05568625f, 0.06985054f, 0.08041141f, -0.00308799f, -0.12236653f, 0.03051523f, 
    0.42524579f, -0.02449134f, -0.16623753f, -0.02858201f, 0.10162878f, -0.01415800f, -0.09278517f, 0.06118222f, 
    -0.01740676f, -0.02552535f, 0.01409922f, 0.04215119f, -0.44128770f, 0.13947958f, 0.15772970f, -0.01007099f, 
    0.00833535f, 0.05193700f, -0.09599164f, 0.03406930f, 0.01064164f, 0.09368758f, -0.06560151f, -0.01611937f, 
    0.25510010f, 0.12351651f, -0.34819332f, 0.02257880f, 0.02168318f, 0.00740223f, -0.03524138f, 0.03340607f, 
    0.02364426f, 0.11750288f, -0.04517065f, 0.07975703f, 0.05990966f, 0.10857153f, -0.03312419f, -0.22610232f, 
    0.08112624f, 0.00591794f, -0.06670232f, 0.01476764f, 0.03010665f, 0.04549314f, 0.08688591f, 0.14846498f, 
    -0.08552051f, -0.12502955f, -0.06409414f, -0.11955510f, 0.11656374f, 0.00542243f, -0.09896051f, -0.20386466f, 
    0.15633662f, -0.16466908f, 0.07237148f, -0.08834868f, 0.30847111f, -0.19493808f, -0.30435219f, 0.12609373f, 
    0.21492514f, -0.03769601f, 0.09845154f, -0.04797340f, -0.05261909f, -0.09723601f, 0.15491334f, 0.11194927f, 
    -0.25299984f, -0.19122240f, 0.19313921f, 0.17997995f, -0.02289809f, 0.03409462f, 0.06218597f, -0.01178956f, 
    0.06807790f, -0.18443258f, 0.08623526f, -0.15666178f, 0.02760582f, -0.11426531f, -0.30951124f, 0.17281134f, 
    0.02426279f, -0.10725936f, 0.06842898f, 0.00990674f, -0.01182124f, 0.02764705f, 0.06484055f, 0.16983868f, 
    0.02593679f, -0.09794720f, 0.07850311f, -0.13157384f, -0.02792518f, 0.05312220f, -0.08024597f, -0.17160568f, 
    0.06386718f, -0.07350789f, 0.06169062f, -0.01270610f, 0.13867620f, 0.14181787f, -0.13884704f, -0.23633215f, 
    0.07790314f, 0.07401091f, 0.03344112f, -0.03749651f, -0.10552581f, -0.08689918f, 0.12439092f, 0.02038003f, 
    -0.00315295f, -0.03824799f, -0.05254324f, -0.04540735f, 0.10134092f, -0.00826046f, -0.07655206f, -0.01467035f, 
    -0.12148256f, -0.10265401f, 0.11037258f, 0.04516352f, -0.37967014f, 0.06601325f, -0.10500626f, -0.05683534f, 
    0.07244989f, 0.01921995f, -0.04219697f, 0.04651627f, 0.00483319f, -0.01502007f, -0.02216006f, -0.04713689f, 
    0.38810670f, -0.03616332f, 0.09741939f, 0.12374055f, 0.07662608f, 0.06175638f, -0.02574601f, -0.09295066f, 
    0.03144474f, 0.03530101f, 0.00720689f, -0.03981240f, 0.10796394f, 0.19358990f, -0.12411112f, 0.06198196f, 
    -0.02816054f, -0.02106843f, 0.13767476f, 0.06275605f, -0.00242677f, 0.01082856f, 0.05402439f, -0.02961863f, 
    0.55214447f, -0.01116670f, -0.40952483f, -0.00516869f, 0.07622196f, -0.04042691f, 0.02802469f, -0.08469407f, 
    -0.00658568f, 0.03916706f, 0.00821026f, -0.03774425f, -0.30184814f, 0.28653494f, -0.20801207f, -0.06477603f, 
    0.08216286f, 0.07201538f, 0.04710755f, 0.00002962f, -0.03301611f, 0.00189898f, 0.17178762f, -0.07674523f, 
    0.15393782f, -0.14276603f, 0.32485178f, 0.05515634f, 0.10329924f, -0.12306134f, -0.07691057f, 0.05132564f, 
    0.08592447f, 0.05776758f, 0.03009514f, 0.05959700f, -0.12336768f, -0.03335340f, 0.16459619f, 0.24878925f, 
    0.10631824f, -0.00425785f, -0.00825192f, -0.11286670f, -0.09676189f, -0.01243592f, 0.18775325f, 0.17814824f, 
    0.28747702f, 0.05254001f, 0.26104182f, -0.06440998f, 0.03476476f, -0.02882549f, 0.11280421f, -0.01833175f, 
    -0.01202113f, 0.03503557f, -0.00204511f, 0.00765000f, 0.23495759f, 0.08655480f, 0.15969276f, 0.00322638f, 
    0.02200471f, -0.17877273f, -0.11304565f, -0.11607158f, -0.05590521f, -0.01045441f, -0.01194596f, 0.02365001f, 
    0.08138406f, 0.11159326f, 0.06854302f, 0.00372834f, 0.06575719f, 0.05569552f, 0.04413489f, -0.02330923f, 
    -0.16061886f, 0.01092689f, 0.10129159f, 0.08070472f, 0.12827747f, -0.12523794f, 0.19604093f, 0.12081416f, 
    -0.08693492f, 0.00226018f, -0.12690993f, -0.05035640f, -0.00874913f, 0.00321253f, -0.13360113f, 0.04860099f, 
    0.65868920f, 0.06253792f, -0.15521181f, -0.06148202f, 0.06368102f, -0.04748341f, -0.00487269f, 0.08704083f, 
    0.21630095f, -0.10285936f, 0.08429737f, -0.00331403f, -0.43887508f, 0.51567876f, 0.24332076f, 0.20090038f, 
    -0.07722759f, 0.03954014f, -0.00033547f, 0.01999626f, 0.11091745f, 0.05161081f, 0.02900515f, 0.12469389f, 
    0.04984831f, 0.00383020f, 0.14601365f, -0.00726031f, 0.10627220f, -0.16679990f, 0.08226593f, -0.08254909f, 
    -0.06859771f, 0.15165427f, -0.00053115f, 0.01366290f, 0.30853036f, 0.09646735f, -0.23264754f, -0.08720285f, 
    -0.12209266f, -0.04605073f, 0.09882578f, 0.02421578f, -0.02824043f, -0.11114072f, -0.09348860f, 0.03089068f, 
    -0.12501125f, 0.08017616f, 0.20054309f, 0.08639923f, -0.10966749f, 0.05397912f, 0.07179745f, 0.17391440f, 
    -0.10569422f, -0.02345204f, -0.10324312f, -0.11525080f, -0.16282481f, 0.07133761f, -0.21348731f, -0.26693779f, 
    0.01636381f, 0.08692767f, 0.09106836f, -0.21075660f, 0.03223957f, 0.12369904f, -0.01968166f, 0.10344981f, 
    -0.24704416f, -0.12649724f, -0.08594611f, 0.14144751f, -0.10427919f, 0.07575938f, -0.02244781f, -0.03444627f, 
    0.04659407f, -0.00008632f, -0.03098345f, 0.11401464f, 0.14078420f, -0.08401095f, -0.03837724f, 0.01123620f, 
    -0.04044109f, 0.03320550f, 0.08112849f, -0.16214831f, -0.04899864f, -0.01264524f, -0.08112066f, 0.03810221f, 
    -0.12745455f, -0.00644917f, 0.02336268f, 0.18330109f, -0.09193014f, 0.07995950f, -0.02667396f, 0.11329738f, 
    -0.18243477f, -0.02743407f, 0.03663632f, 0.03920840f, -0.46168223f, 0.12042024f, 0.18248297f, 0.01376191f, 
    0.02887239f, -0.01277348f, -0.01721110f, -0.05257064f, 0.02887361f, 0.05258515f, 0.09373698f, 0.01481486f, 
    -0.22002555f, 0.17230223f, 0.01613474f, -0.14566645f, 0.06782544f, -0.01623238f, -0.05222428f, 0.11599370f, 
    -0.08068330f, 0.03106015f, 0.01434676f, -0.02337578f, 0.43213600f, -0.27190176f, 0.12942411f, 0.19130628f, 
    -0.01478653f, 0.02247540f, -0.01500294f, 0.07791161f, -0.06767085f, -0.07549325f, 0.05826111f, 0.00673365f, 
    0.34174314f, 0.17045850f, -0.06554897f, 0.24344864f, 0.05232252f, 0.13632634f, 0.12347355f, 0.09847047f, 
    -0.02037917f, -0.04451399f, -0.07453088f, -0.00383377f, 0.19237678f, 0.06336696f, 0.03998514f, 0.08950073f, 
    0.05711661f, -0.05335690f, 0.02833411f, -0.05527077f, 0.09410662f, 0.09532338f, -0.08930355f, 0.10785189f, 
    -0.15800574f, 0.15712349f, 0.03256276f, -0.12470644f, 0.12879115f, 0.07283846f, 0.04275651f, -0.09684137f, 
    0.05318412f, 0.00246592f, -0.06979059f, 0.00638657f, -0.00165077f, 0.28099307f, -0.16191578f, -0.16730739f, 
    0.06021030f, 0.12940989f, 0.00743234f, 0.01957522f, -0.15234210f, 0.03545467f, -0.14408912f, -0.06319687f, 
    0.20172162f, -0.19709313f, 0.16310638f, 0.04840356f, 0.02666662f, -0.00965534f, -0.00160936f, 0.07083026f, 
    0.07121665f, 0.07094570f, 0.06554985f, -0.00411166f, -0.54129589f, 0.06010742f, -0.33467439f, -0.25703874f, 
    0.03682144f, -0.03983636f, -0.04310226f, -0.02764815f, -0.08992442f, 0.17351137f, -0.00081976f, -0.11440888f, 
    0.03276129f, 0.02994097f, -0.01976387f, 0.02198840f, 0.00350317f, -0.00627279f, -0.04014719f, -0.04717520f, 
    -0.03648154f, 0.01106907f, 0.01206293f, 0.01842515f, 0.00226038f, 0.05112608f, -0.04880877f, -0.00097387f, 
    -0.00315846f, -0.01735803f, -0.01569877f, -0.02465536f, -0.04091678f, -0.04246222f, 0.03696187f, -0.03060315f, 
    -0.04119945f, -0.04639548f, 0.00226556f, 0.00282115f, 0.01301799f, -0.00083957f, -0.04506127f, -0.00066324f, 
    -0.03548418f, -0.04780774f, -0.02167334f, -0.04770680f, 0.00854803f, 0.04021115f, -0.05567837f, -0.00698390f, 
    0.00535704f, 0.03670920f, -0.05730570f, -0.00653167f, -0.00450014f, -0.01243528f, 0.03240496f, 0.00684077f, 
    -0.03500072f, 0.02864351f, -0.05128576f, -0.03028055f, -0.01782555f, -0.01699501f, 0.00796009f, 0.01696539f, 
    0.01100107f, 0.03159318f, 0.03011166f, -0.02739281f, -0.02457249f, -0.00666908f, -0.02035518f, 0.00103182f, 
    0.04443024f, -0.01830040f, -0.00489115f, -0.03026168f, -0.04453871f, 0.02520894f, 0.03331001f, -0.00787162f, 
    0.01520707f, -0.04719761f, -0.02125100f, 0.04457672f, 0.00919541f, -0.01407286f, -0.03447855f, -0.02665579f, 
    -0.01331776f, 0.00918387f, -0.01817740f, -0.00994379f, 0.00634560f, 0.00710949f, 0.00159133f, 0.01293912f, 
    0.04520789f, 0.02269472f, 0.00879964f, -0.05279671f, 0.02466176f, -0.01433397f, 0.02390890f, 0.01042928f, 
    0.04586869f, -0.04372145f, 0.04276066f, -0.03176907f, -0.03943813f, -0.03994553f, 0.00434018f, 0.02644364f, 
    0.03881381f, 0.00937552f, -0.01123884f, -0.02672223f, -0.05256331f, 0.01495050f, -0.05501628f, 0.01686476f, 
    0.00520414f, 0.00401350f, 0.02626749f, 0.01405125f, -0.02836015f, -0.05287237f, 0.01978197f, -0.00274993f, 
    -0.00859382f, -0.01411964f, -0.00150583f, 0.00888749f, -0.02617392f, -0.03427143f, -0.03678685f, -0.04296108f, 
    0.04530556f, -0.04360386f, -0.05302165f, -0.00484228f, -0.03551115f, 0.02475066f, -0.02942700f, -0.02028933f, 
    0.03861107f, 0.01369062f, 0.04453461f, 0.03419866f, 0.03575445f, 0.02459385f, 0.00115335f, 0.03572733f, 
    -0.04802043f, 0.04071582f, 0.01109807f, -0.00634882f, -0.03039529f, 0.02549294f, 0.02541617f, 0.04308288f, 
    0.03800788f, 0.01753268f, -0.02935786f, -0.02343020f, -0.04685736f, -0.02839529f, -0.00946649f, -0.02394685f, 
    0.00714238f, 0.03463335f, -0.04387131f, 0.02544732f, 0.00701359f, 0.04724994f, 0.00040410f, 0.03168028f, 
    -0.00406824f, 0.02764130f, -0.03919721f, -0.00863207f, -0.01781495f, 0.03089054f, -0.00307227f, 0.04077776f, 
    0.02419897f, 0.04083650f, 0.01528980f, -0.02081685f, 0.00354791f, 0.01760712f, 0.02497041f, -0.03255847f, 
    -0.00407128f, -0.02861206f, -0.00898590f, -0.04174504f, -0.00135699f, 0.02799259f, -0.05087755f, 0.00201142f, 
    -0.01819578f, -0.04501781f, -0.01602141f, -0.03338463f, -0.00770329f, -0.02699930f, 0.04206464f, 0.02107779f, 
    0.03158870f, 0.01610577f, -0.02821972f, 0.03626440f, 0.00918848f, -0.02244223f, -0.00687369f, -0.01556035f, 
    -0.02283499f, -0.03238834f, -0.04415879f, 0.02708573f, 0.03394589f, -0.03311597f, -0.01684726f, -0.03238540f, 
    -0.04109814f, -0.02674264f, 0.03433616f, -0.01730250f, -0.05339580f, -0.03246195f, -0.01988406f, -0.03161422f, 
    -0.03731345f, 0.04124530f, -0.00060102f, -0.01315940f, -0.00639723f, -0.00704532f, 0.01806696f, -0.00518351f, 
    -0.03345842f, 0.04185585f, -0.01021547f, 0.00884913f, -0.04037570f, -0.03421452f, 0.00236441f, -0.04310096f, 
    0.01158319f, 0.01522545f, 0.03654582f, -0.05205822f, -0.01912660f, -0.04175557f, 0.04290694f, -0.04946169f, 
    0.01279793f, -0.03800672f, 0.01418219f, -0.02503749f, 0.02576416f, -0.03069220f, -0.04939672f, -0.00477068f, 
    0.00628310f, -0.03140301f, -0.01404840f, 0.00605004f, -0.00225949f, -0.04520929f, -0.04842073f, -0.04792022f, 
    -0.03935209f, 0.02922820f, 0.00549439f, 0.03330544f, -0.00648903f, 0.03042812f, 0.00723696f, -0.00901160f, 
    0.00146890f, -0.03643265f, -0.05024302f, -0.04221057f, -0.05240229f, 0.04797501f, 0.03119271f, -0.02685166f, 
    -0.03591374f, -0.03466579f, -0.01772253f, 0.00197008f, -0.00358536f, 0.01253700f, -0.04413973f, 0.00653640f, 
    0.01097626f, -0.02320680f, 0.03196169f, -0.02753036f, 0.02234958f, -0.03322721f, 0.04533511f, -0.05487296f, 
    -0.00059195f, 0.01812364f, -0.00513204f, -0.00049487f, -0.03240237f, -0.03839748f, 0.02979453f, 0.03254329f, 
    -0.04567162f, -0.02067797f, -0.01007832f, -0.00140544f, -0.04162294f, -0.02202329f, -0.01361603f, 0.03375731f, 
    0.01312517f, 0.01147781f, -0.01143497f, -0.00850526f, -0.03902226f, -0.02642755f, 0.02479953f, 0.00223273f, 
    0.02757706f, 0.00333917f, -0.05403237f, 0.05218151f, -0.01328361f, 0.04435749f, 0.01467432f, -0.04325267f, 
    0.01471415f, -0.02439836f, 0.00946102f, -0.01633926f, -0.03052973f, 0.00022390f, -0.01777004f, 0.03408109f, 
    -0.03545003f, 0.00698363f, -0.01508094f, -0.03454651f, -0.00541670f, 0.03304153f, 0.00025925f, 0.01646166f, 
    -0.00922960f, -0.05150181f, -0.00898499f, -0.02334202f, 0.00023916f, 0.00588495f, 0.00762848f, 0.04472532f, 
    -0.03367969f, -0.03876950f, 0.01352135f, -0.02317676f, 0.00539484f, -0.04815343f, -0.02720587f, 0.01321794f, 
    -0.03587980f, -0.05228567f, -0.01483667f, -0.01978527f, -0.01939357f, 0.01607112f, -0.01130168f, -0.01895926f, 
    0.01789792f, 0.03382025f, 0.01204453f, -0.04770162f, -0.04637982f, 0.00186928f, -0.05319795f, -0.01860081f, 
    0.01049317f, -0.00721844f, -0.01894722f, -0.01685936f, -0.03956189f, -0.00364517f, 0.02503610f, -0.02925992f, 
    -0.05911750f, 0.21626286f, -0.07237031f, -0.32006693f, 0.09776075f, 0.04662475f, 0.13517107f, 0.14850523f, 
    0.18713883f, -0.02243743f, 0.01663563f, 0.03847228f, -0.06977550f, 0.15022956f, 0.02227657f, 0.05724736f, 
    0.01431054f, -0.03912731f, -0.03391393f, 0.16551326f, 0.07873310f, 0.06581303f, -0.25318933f, -0.08859126f, 
    -0.12113211f, 0.02082187f, 0.20503515f, -0.06322486f, 0.09662656f, 0.06295045f, 0.06301664f, 0.17543536f, 
    -0.02414832f, -0.02879046f, -0.08262537f, -0.11216488f, -0.13308112f, 0.11112519f, -0.21807164f, 0.01076088f, 
    0.06763320f, -0.02962641f, -0.03112888f, 0.03698625f, 0.09348287f, -0.04099327f, 0.09250218f, 0.00159880f, 
    0.19487663f, -0.15086195f, 0.15187131f, -0.10987212f, -0.05711661f, -0.00801316f, 0.15543458f, -0.07092156f, 
    0.01405035f, -0.03037641f, 0.03902306f, 0.02174885f, -0.16106364f, 0.09968492f, 0.06948189f, -0.01895181f, 
    -0.09904585f, 0.01696092f, -0.10972386f, -0.03943307f, -0.00256495f, 0.07457206f, 0.25122142f, -0.00868874f, 
    0.28891090f, 0.01440872f, -0.22560266f, 0.08872343f, 0.00859991f, 0.00300647f, 0.06467392f, 0.00825239f, 
    0.02842234f, -0.05796429f, -0.05500564f, -0.05975850f, -0.12088377f, 0.04352224f, 0.04931087f, 0.12890500f, 
    0.06964533f, 0.01784477f, 0.05247137f, -0.01619850f, 0.00138722f, 0.06732778f, 0.02238443f, 0.00744199f, 
    0.38037789f, -0.43555778f, 0.09272158f, 0.08489580f, -0.08016295f, -0.00412272f, -0.08766428f, 0.02027975f, 
    -0.02695450f, 0.00818787f, -0.00716110f, 0.05664616f, -0.02277120f, 0.12844411f, 0.07256493f, 0.12510811f, 
    -0.24227454f, 0.07712031f, -0.06388583f, -0.05825651f, -0.21537182f, -0.16031992f, 0.05291011f, -0.15129250f, 
    0.28879309f, 0.18942745f, 0.00353843f, 0.01919399f, 0.04503809f, 0.12014864f, 0.11213142f, 0.04385662f, 
    -0.11247129f, -0.01783804f, 0.09268761f, -0.03651411f, 0.38732001f, -0.24951200f, 0.41586956f, -0.16124968f, 
    0.02049269f, -0.07011833f, 0.09571679f, 0.04066937f, 0.07550536f, 0.00826260f, -0.00765034f, 0.08810938f, 
    0.17116582f, 0.13953899f, 0.12456083f, 0.11340624f, 0.09716182f, 0.13870823f, 0.02321189f, 0.03367669f, 
    0.05115831f, 0.06801366f, 0.17649469f, 0.02860697f, -0.06817709f, -0.41624236f, -0.06190059f, -0.08103452f, 
    -0.19855040f, -0.11327446f, 0.06655809f, 0.00235885f, -0.13850318f, 0.14611857f, -0.06413808f, 0.10833769f, 
    -0.12302355f, -0.31011695f, 0.23289415f, -0.17559962f, 0.00772447f, 0.09014870f, 0.01722559f, 0.01847584f, 
    -0.03263701f, 0.01600546f, -0.09155199f, 0.13096100f, -0.07303987f, -0.10121819f, -0.21576375f, -0.11798236f, 
    0.00495521f, 0.01312248f, 0.12324160f, -0.15800782f, 0.07717005f, 0.00985675f, -0.04617621f, -0.07493725f, 
    0.23637322f, -0.17989358f, 0.11190743f, 0.05595035f, 0.00109242f, 0.02962002f, 0.18090194f, -0.12348415f, 
    -0.09414163f, 0.01348089f, 0.07805727f, 0.18459223f, -0.08000904f, -0.17439474f, -0.02017051f, 0.01677588f, 
    0.13165505f, 0.03562602f, -0.01878089f, -0.04266055f, 0.05910500f, -0.05515230f, 0.14415085f, 0.01860273f, 
    -0.25995207f, -0.04892176f, 0.13369590f, 0.13994281f, -0.17083979f, -0.12589255f, 0.02348078f, -0.09137005f, 
    -0.06215851f, 0.02761523f, -0.09655081f, -0.04367284f, -0.05616356f, 0.11270452f, -0.17829625f, -0.08268380f, 
    -0.00858830f, -0.03309533f, 0.05255306f, -0.07620817f, 0.07164714f, 0.06467372f, 0.04971375f, 0.09948336f, 
    0.33830091f, -0.02829727f, 0.10762411f, 0.12492547f, -0.08171763f, -0.04659585f, -0.00155213f, 0.14814745f, 
    -0.00721528f, -0.08077654f, 0.02123759f, 0.08433658f, -0.05287708f, 0.19963361f, -0.17056508f, -0.16104835f, 
    0.06290374f, 0.06042184f, -0.01940896f, -0.02013956f, -0.04608876f, -0.21322690f, -0.19508141f, 0.08927948f, 
    -0.37511870f, 0.08324158f, -0.02576103f, -0.22761606f, -0.01893064f, -0.10225058f, 0.05353471f, 0.08386720f, 
    -0.09515089f, -0.00903291f, -0.04847088f, 0.20982125f, 0.12505162f, -0.07530660f, -0.14298458f, 0.22847305f, 
    0.00786220f, 0.14280778f, -0.06601194f, -0.00786077f, 0.06390186f, -0.04097474f, 0.00502115f, 0.02505242f, 
    -0.01608263f, 0.06721886f, -0.02172362f, -0.09500623f, -0.07146803f, 0.01916196f, 0.04308675f, -0.01174461f, 
    0.01557186f, 0.07900037f, -0.09910803f, -0.04230047f, -0.01595514f, -0.03827228f, -0.13116777f, 0.30470589f, 
    -0.08840112f, -0.04591903f, 0.12374499f, -0.04011421f, -0.13746813f, 0.05817126f, 0.04538602f, -0.03290335f, 
    -0.16397674f, 0.27291921f, 0.01365635f, 0.33828005f, -0.02648405f, 0.02896271f, 0.00175861f, 0.05620714f, 
    -0.08847077f, -0.06508991f, 0.01215823f, -0.03670663f, -0.04146493f, 0.02819754f, 0.09965708f, 0.08051860f, 
    0.11405170f, 0.00692573f, 0.08212862f, -0.00500734f, -0.14589491f, -0.09201824f, 0.07920301f, -0.15368040f, 
    0.22939110f, -0.04464949f, 0.36898699f, -0.07700635f, -0.10480343f, -0.02475799f, 0.05515102f, 0.16768903f, 
    -0.06113794f, -0.01149100f, -0.05105245f, -0.00910899f, 0.20555489f, 0.09695921f, 0.05893987f, 0.04958462f, 
    0.13008024f, 0.08556267f, -0.08869880f, -0.01821214f, 0.10806163f, 0.12694024f, -0.13925314f, 0.02740826f, 
    0.16844814f, -0.16003972f, -0.15793630f, 0.02824167f, -0.05816927f, 0.11856259f, -0.01323103f, -0.08529454f, 
    0.10702392f, 0.07980740f, 0.16081995f, 0.21318169f, -0.08567838f, -0.00908360f, -0.02424267f, -0.10872001f, 
    0.13873298f, 0.06826264f, 0.06682564f, 0.04411499f, 0.04551226f, -0.13123642f, 0.04097512f, -0.05932339f, 
    -0.12577365f, -0.21324368f, -0.03462059f, 0.00839408f, 0.04683731f, -0.03570326f, -0.04762778f, -0.16864273f, 
    -0.00980639f, 0.06805800f, 0.07430756f, -0.08932850f, 0.22251450f, -0.00492963f, 0.17935611f, 0.21810651f, 
    -0.19046980f, -0.04279025f, -0.02944921f, -0.06169324f, -0.05799329f, -0.22318557f, 0.07977966f, -0.16477825f, 
    0.15141648f, 0.02772749f, -0.23918533f, 0.42741212f, -0.00154865f, 0.01598315f, -0.11200295f, 0.03432053f, 
    -0.13854589f, 0.03030291f, 0.17489114f, 0.07796317f, -0.12699006f, 0.04281779f, 0.02720305f, -0.41515595f, 
    -0.07971572f, 0.07133476f, -0.01298323f, 0.04377549f, 0.05573160f, -0.04090109f, 0.04640704f, 0.11148986f, 
    -0.09028032f, 0.14653130f, 0.22542849f, 0.07522903f, 0.09209341f, 0.08241791f, -0.13386188f, -0.06920664f, 
    0.04828775f, 0.11244801f, 0.06146081f, -0.11997442f, -0.08720624f, 0.00606487f, -0.02472210f, 0.04380837f, 
    0.08163468f, -0.00291309f, 0.07757906f, 0.03632938f, 0.08598082f, 0.04065759f, -0.10511165f, 0.11972737f, 
    -0.22121814f, 0.11355782f, 0.09401277f, 0.19184491f, 0.03847202f, -0.08253695f, 0.01819959f, -0.17463821f, 
    0.05577612f, 0.08906644f, -0.05222638f, -0.02565201f, 0.49560660f, -0.05924663f, -0.03488784f, 0.12720408f, 
    0.03523374f, -0.01770967f, -0.12339451f, 0.16122159f, 0.04214018f, -0.07590810f, 0.05777811f, -0.10041788f, 
    -0.07425715f, 0.19404927f, 0.03466641f, 0.21851875f, 0.00965923f, 0.06308711f, -0.05607349f, 0.07821894f, 
    0.08275849f, 0.02497785f, -0.03267543f, 0.16602704f, 0.34482762f, -0.19291411f, 0.21411961f, -0.17993964f, 
    -0.04573913f, -0.12578578f, -0.02153379f, -0.02473930f, 0.08059829f, 0.04822021f, -0.03147184f, 0.10191638f, 
    -0.18941769f, -0.01333406f, 0.03842081f, 0.09418139f, 0.07211877f, -0.04895632f, -0.00187543f, 0.02039970f, 
    -0.03258495f, -0.08440392f, -0.11057668f, 0.03873403f, 0.10032159f, 0.22956456f, -0.28082633f, -0.15107335f, 
    0.00628168f, 0.04361656f, -0.02683254f, 0.11761747f, 0.01161456f, 0.03521828f, -0.09932788f, 0.04900608f, 
    0.16485865f, 0.09362656f, -0.07406910f, 0.33644593f, -0.07507543f, -0.05443311f, -0.04054448f, 0.03325928f, 
    -0.01393013f, 0.12534593f, -0.06093007f, -0.10331067f, -0.20101373f, 0.01682097f, -0.00833153f, -0.27451563f, 
    0.09714825f, -0.05264949f, 0.06919884f, 0.18868536f, 0.22913069f, 0.04732826f, 0.00200749f, 0.27815008f, 
    0.08053432f, 0.20641829f, 0.05823395f, 0.17247362f, 0.04531668f, 0.04467148f, -0.05866207f, 0.08412013f, 
    0.07004087f, 0.02607532f, -0.02333574f, -0.01490689f, -0.09317897f, 0.02711769f, -0.07574206f, -0.28262761f, 
    -0.01024031f, -0.00341098f, 0.19183858f, 0.01986634f, -0.07225183f, 0.02952318f, -0.02255028f, 0.14539039f, 
    0.16374514f, -0.00780422f, -0.06629556f, 0.15968232f, -0.01588930f, -0.01213234f, 0.01177342f, 0.10245613f, 
    -0.07535905f, 0.19912092f, 0.15494812f, 0.13093029f, 0.17447688f, 0.26667130f, -0.13396175f, -0.08590907f, 
    -0.02298508f, 0.06864022f, 0.03209393f, -0.03188934f, -0.07153684f, -0.10422581f, -0.13183540f, -0.09955364f, 
    0.02628484f, -0.00354485f, 0.00418836f, -0.07846626f, 0.18043342f, 0.06561220f, 0.09238163f, 0.11706298f, 
    0.09568126f, 0.08445661f, -0.11593445f, 0.01518999f, 0.06484719f, -0.07688317f, 0.15492062f, -0.12918974f, 
    -0.08496710f, 0.03477982f, -0.05088110f, -0.13107035f, 0.09787088f, 0.15439150f, -0.01674932f, 0.16146021f, 
    0.00554005f, 0.02152815f, 0.18789577f, 0.27118224f, 0.03910452f, -0.07689318f, 0.10381375f, -0.10852437f, 
    -0.02184671f, 0.15523079f, 0.00303610f, 0.07710897f, -0.03835320f, -0.20143497f, 0.15030585f, 0.17087804f, 
    0.06770743f, -0.03902878f, 0.07098974f, 0.05815146f, 0.02875346f, 0.16005588f, -0.01803939f, 0.02792444f, 
    -0.22550438f, -0.19030212f, -0.03994486f, 0.03299858f, 0.00228176f, 0.04220603f, 0.05939376f, 0.08845706f, 
    0.18812992f, -0.02572954f, 0.20037808f, -0.03432123f, 0.05378858f, -0.01796732f, 0.24746931f, -0.25120163f, 
    -0.09175435f, -0.06154742f, -0.02954355f, -0.09809301f, 0.16459908f, -0.03065825f, -0.09603623f, -0.05731736f, 
    -0.28156880f, -0.19992781f, 0.10059185f, -0.02599072f, -0.04280761f, -0.00402460f, 0.07840698f, 0.12578662f, 
    0.09864709f, 0.06367976f, -0.03894394f, 0.14803609f, 0.38065064f, 0.21023400f, 0.10139323f, -0.11716828f, 
    -0.13879381f, 0.05968951f, -0.00690194f, 0.08908626f, 0.08247708f, -0.03730727f, 0.03265998f, -0.06899300f, 
    0.20137915f, 0.01367303f, -0.03468900f, -0.20937385f, -0.07198271f, 0.08892936f, 0.00374012f, 0.03739135f, 
    0.04850905f, 0.04118671f, -0.05467796f, 0.13757880f, 0.24857159f, -0.13248460f, -0.15762109f, 0.28582004f, 
    -0.09109260f, 0.00214257f, 0.07291997f, 0.05771507f, 0.05439025f, 0.05919395f, -0.04704902f, -0.00889803f, 
    0.25279814f, -0.04464026f, -0.08741613f, 0.46878216f, 0.10330609f, -0.01666739f, -0.01530258f, -0.03236888f, 
    0.07983343f, 0.14137074f, 0.13223830f, 0.08109482f, 0.17864938f, 0.07540101f, 0.05786274f, 0.18432036f, 
    -0.21077766f, -0.05060530f, -0.05669853f, -0.05155192f, -0.09533068f, -0.13955089f, 0.02663573f, 0.00998081f, 
    0.02587364f, -0.06443013f, 0.09960961f, -0.23615725f, 0.10879049f, -0.05209170f, 0.03580780f, 0.16339144f, 
    -0.09482294f, 0.06161292f, 0.10208975f, 0.04434074f, -0.16817005f, -0.03654245f, 0.14900120f, 0.12789671f, 
    -0.11581897f, 0.06558818f, -0.10762204f, -0.07865346f, 0.17329122f, 0.01069419f, -0.13676827f, 0.12335330f, 
    0.30374771f, 0.16210209f, -0.00644066f, -0.16908051f, 0.02459142f, 0.01068546f, 0.01545814f, 0.05275814f, 
    0.10911202f, -0.04153367f, 0.02219892f, 0.21883288f, 0.03306681f, 0.06012834f, -0.17772809f, 0.12214758f, 
    0.13847421f, 0.05189209f, -0.10195778f, 0.05359177f, 0.23503047f, 0.11714141f, -0.08143046f, -0.10119104f, 
    -0.47578081f, 0.07683608f, 0.17055012f, -0.19530615f, 0.06641099f, 0.04384493f, -0.03926212f, 0.07597627f, 
    0.20881312f, 0.10036906f, -0.02411977f, 0.08121654f, -0.02171504f, 0.27280954f, -0.20619932f, 0.12555197f, 
    0.12469606f, 0.06168240f, -0.01140776f, -0.10735189f, 0.02019697f, 0.15948431f, 0.08558119f, -0.10443345f, 
    0.07334208f, 0.30662963f, -0.06745620f, -0.36080346f, -0.02363535f, 0.03569176f, 0.02960854f, 0.15288244f, 
    -0.10837274f, 0.02077403f, 0.02450212f, 0.06419183f, -0.13865851f, 0.11203101f, 0.20887846f, 0.20425302f, 
    -0.16843367f, 0.05631852f, 0.02314055f, 0.23342024f, -0.00034472f, 0.04612955f, 0.15810567f, -0.01057488f, 
    0.42452773f, 0.11228608f, -0.35112503f, -0.02673147f, -0.01020632f, 0.06762607f, -0.01185285f, 0.08899474f, 
    0.05967652f, 0.00637572f, 0.24253376f, 0.12042700f, -0.15697709f, -0.24065739f, 0.01188119f, 0.07760819f, 
    0.15072718f, 0.00432801f, 0.12751667f, -0.08955842f, 0.17465018f, 0.14212407f, 0.05655027f, 0.04196295f, 
    0.37110806f, -0.34511939f, -0.16333130f, -0.15031387f, 0.14356193f, -0.01383516f, 0.02243210f, 0.19401547f, 
    0.10968585f, -0.04151128f, -0.09671338f, 0.14325728f, 0.10169399f, 0.03203546f, -0.09762174f, 0.36082825f, 
    -0.13885933f, 0.09601094f, -0.04869154f, 0.03110938f, -0.14420280f, 0.05409936f, 0.04250852f, 0.01998189f, 
    0.46620476f, 0.14364854f, 0.13517439f, 0.14300655f, 0.14112826f, 0.23384973f, 0.06403499f, 0.11381403f, 
    0.01162728f, 0.06481172f, 0.11409534f, 0.00463919f, 0.12895970f, -0.15677358f, 0.31208074f, -0.26867452f, 
    -0.15304840f, 0.12641773f, -0.13214555f, -0.22874901f, 0.16970295f, 0.09598249f, 0.16119643f, 0.02174902f, 
    0.29657930f, -0.08694628f, 0.06749704f, -0.44137752f, 0.21571715f, 0.16361707f, -0.05822253f, -0.07960488f, 
    0.21860719f, 0.12946954f, 0.24710852f, 0.12006645f, -0.21666740f, -0.18254244f, 0.21636005f, 0.16067496f, 
    -0.24234383f, -0.18040670f, -0.07879812f, -0.01245528f, -0.09427658f, 0.04252014f, 0.01437597f, -0.06182817f, 
    -0.37023962f, -0.18222590f, 0.07190031f, -0.32473114f, 0.02135014f, 0.02793013f, -0.17587441f, -0.00008848f, 
    -0.04287409f, 0.11708021f, -0.06503297f, 0.05916420f, -0.17057380f, 0.06056345f, -0.17403147f, -0.00348130f, 
    0.03057347f, 0.07837328f, 0.02831119f, -0.13676631f, 0.06524729f, -0.02485113f, 0.12464751f, -0.04380516f, 
    0.10067556f, -0.27325758f, -0.21102145f, -0.25271186f, 0.18120207f, -0.12122627f, 0.11052251f, -0.08233518f, 
    0.10149164f, -0.12527283f, 0.18235230f, 0.16046780f, -0.29549816f, 0.03377815f, -0.09540974f, -0.17389463f, 
    0.15210572f, 0.11229312f, 0.03820430f, 0.08214404f, 0.18577322f, 0.28244838f, 0.11670896f, -0.17596763f, 
    -0.11469044f, 0.19339170f, 0.23028013f, 0.46787998f, -0.02751997f, -0.14913169f, 0.02884274f, 0.11955457f, 
    -0.00347416f, -0.12078740f, -0.03136443f, -0.12910193f, -0.38534555f, 0.16052870f, -0.01759879f, 0.15755829f, 
    -0.09210491f, -0.05180157f, 0.01870826f, -0.06948373f, 0.17436852f, -0.09234008f, 0.26439565f, 0.01459044f, 
    0.36803234f, -0.04594211f, -0.12319225f, -0.19524884f, 0.20616972f, 0.03286852f, -0.09828273f, 0.21625611f, 
    0.02118071f, -0.04844689f, 0.06764040f, 0.17110027f, 0.13541514f, 0.18290909f, -0.10208046f, 0.19875698f, 
    0.00979663f, -0.14166006f, 0.11554898f, 0.13793631f, -0.08176710f, 0.07618029f, 0.11343883f, 0.01400263f, 
    -0.13216448f, 0.15161164f, 0.16092791f, -0.05204824f, -0.08126678f, -0.06453580f, -0.01288546f, 0.15686309f, 
    -0.04699670f, -0.13706346f, -0.15666163f, 0.04346064f, 0.04647988f, 0.04262721f, -0.28178915f, 0.34108415f, 
    0.16352066f, 0.05825735f, -0.00677188f, 0.02973670f, 0.11020046f, 0.04829694f, 0.16302826f, 0.02346988f, 
    0.08820187f, 0.13610180f, -0.22175838f, 0.20706698f, -0.01005593f, 0.09203210f, 0.05285426f, 0.06382453f, 
    -0.12304876f, -0.00518692f, 0.03269187f, -0.10572272f, 0.10319699f, 0.13287577f, -0.13202639f, 0.15693869f, 
    0.00685729f, -0.00217563f, 0.10561145f, 0.11583360f, -0.15332423f, 0.06768698f, 0.00757673f, -0.01799538f, 
    -0.48392203f, 0.04661002f, -0.00494269f, 0.25299108f, 0.03911186f, 0.07345905f, 0.18085338f, -0.19146876f, 
    0.13612871f, -0.04474091f, 0.07667044f, -0.09984253f, 0.01504521f, -0.07631765f, -0.01210052f, -0.19371311f, 
    0.26642051f, -0.00836968f, -0.07196381f, 0.02684664f, -0.03333190f, -0.05804164f, 0.11759260f, -0.01668010f, 
    0.08725188f, -0.14182614f, -0.11569510f, -0.29901367f, 0.21086882f, -0.08821708f, -0.05412764f, -0.00855755f, 
    -0.03931065f, 0.02039306f, 0.02032682f, 0.00830057f, 0.01984419f, 0.03268875f, 0.06350552f, 0.03306767f, 
    0.17815155f, 0.00851899f, 0.02371204f, -0.25537306f, 0.26114476f, 0.16846816f, 0.12083580f, 0.06312521f, 
    -0.00434564f, 0.24522057f, -0.18780121f, -0.12124891f, -0.03980594f, 0.11204472f, 0.09577931f, 0.00694534f, 
    0.07974901f, 0.05375535f, -0.00828886f, 0.02298010f, 0.02589439f, 0.13822842f, 0.10103272f, 0.03304682f, 
    0.06790027f, -0.00475282f, -0.02515950f, -0.05508940f, 0.23431501f, 0.12416463f, 0.17980398f, -0.10122429f, 
    -0.04345049f, 0.01233845f, -0.01125918f, -0.02176218f, -0.05052674f, -0.01092398f, 0.00123601f, -0.00822908f, 
    -0.02874789f, 0.02111056f, -0.03297326f, 0.04061662f, 0.03334477f, -0.03478568f, -0.03256341f, 0.00903332f, 
    0.00503080f, 0.00543784f, -0.00969751f, 0.01957433f, -0.02727778f, 0.03547811f, -0.02273830f, -0.04706739f, 
    -0.04215806f, 0.02016645f, 0.01604606f, 0.02839224f, 0.02338241f, 0.01133186f, 0.04353775f, 0.01947050f, 
    0.00905054f, -0.00081361f, 0.00690508f, 0.00947108f, -0.03237329f, -0.04014067f, 0.01999960f, 0.04012351f, 
    -0.02069958f, -0.04141896f, -0.04330545f, -0.05553069f, 0.04454696f, -0.01928785f, 0.01160073f, -0.02314577f, 
    -0.02894077f, 0.02555278f, 0.01134960f, 0.03867749f, -0.02733803f, -0.04694435f, -0.01787165f, 0.01899181f, 
    0.02720809f, 0.00793331f, 0.00999228f, -0.03045054f, -0.01149120f, -0.01867162f, -0.05171755f, 0.01800528f, 
    0.03529430f, -0.04150292f, -0.01683082f, 0.04250862f, -0.04517454f, 0.03296536f, 0.03225202f, 0.01902165f, 
    0.01976251f, -0.01417703f, 0.01022766f, -0.02378747f, -0.05036294f, -0.03862543f, -0.01168045f, 0.03957637f, 
    -0.03440182f, -0.02717103f, 0.02664246f, 0.04554412f, 0.02102700f, -0.05388548f, -0.02419567f, -0.04332868f, 
    0.04032360f, -0.00381921f, -0.02113188f, 0.03423464f, -0.01378941f, -0.00555299f, 0.03049249f, 0.03360823f, 
    -0.05225899f, -0.00607072f, 0.00286986f, -0.00150649f, 0.02206460f, -0.01758017f, -0.03365765f, -0.04135667f, 
    -0.05038808f, 0.02399721f, -0.02151428f, -0.00678555f, -0.05016999f, -0.04411421f, 0.00135311f, -0.00258972f, 
    -0.04495633f, 0.03237747f, -0.02176280f, -0.00062134f, -0.00209102f, -0.04447322f, 0.00422457f, 0.03825520f, 
    0.03158438f, 0.03549447f, 0.03438680f, -0.03781121f, -0.00692671f, 0.02869323f, -0.00600727f, -0.01430257f, 
    0.04021626f, -0.04378577f, 0.03050548f, 0.01217623f, -0.02177124f, -0.04052015f, -0.01307702f, 0.03292507f, 
    0.02145188f, -0.01861538f, -0.03703086f, -0.00340756f, -0.03617556f, 0.04555476f, 0.00696477f, -0.00489350f, 
    -0.00159884f, 0.00106141f, -0.00116857f, -0.05035101f, -0.03167892f, 0.02982876f, 0.02077146f, -0.01483884f, 
    -0.01445984f, -0.01586386f, 0.04088985f, -0.00644105f, 0.01920753f, -0.01341808f, 0.03575644f, 0.02267992f, 
    -0.03843589f, -0.01699779f, -0.04508356f, -0.02044593f, -0.04221483f, 0.00926636f, -0.04573424f, -0.04522175f, 
    -0.05424847f, 0.04022070f, -0.02813613f, 0.04332190f, 0.00969439f, -0.04878724f, -0.04197250f, -0.05550931f, 
    -0.03421844f, 0.04129870f, 0.02660199f, -0.01136040f, -0.04789446f, -0.02044880f, -0.04202726f, 0.03360362f, 
    -0.02782200f, 0.04086111f, -0.04472642f, -0.03917563f, -0.02823119f, 0.02922243f, -0.02229596f, -0.05852671f, 
    -0.03325399f, -0.05456411f, -0.03745300f, -0.01728754f, 0.03162043f, 0.01136816f, -0.02213911f, -0.03527297f, 
    -0.02101523f, 0.03620514f, -0.02508463f, -0.03351757f, -0.04374901f, 0.02162252f, -0.02535471f, 0.01742063f, 
    -0.05486052f, -0.01139129f, -0.05771178f, 0.00565307f, 0.04507172f, 0.02042906f, 0.02167569f, -0.02269234f, 
    -0.03926146f, -0.04525763f, -0.01488649f, -0.04640733f, 0.03284461f, 0.04374861f, 0.01763427f, -0.02336793f, 
    -0.00962808f, 0.02406398f, -0.00277425f, -0.04263218f, -0.01474071f, -0.02314456f, -0.03909974f, -0.00963398f, 
    0.03769234f, -0.03159965f, -0.04084003f, 0.02414225f, -0.01181851f, -0.00303635f, 0.04405015f, 0.04479217f, 
    0.01116633f, -0.04284802f, -0.01010059f, 0.03059040f, -0.02002463f, -0.05693616f, -0.04738303f, -0.02704798f, 
    0.00629726f, -0.01619831f, -0.03475079f, 0.00905153f, -0.05606428f, 0.03748969f, 0.01974991f, -0.01201475f, 
    0.01062894f, 0.00693380f, -0.02347339f, -0.02515776f, -0.05218852f, 0.01900758f, -0.00287794f, -0.00462813f, 
    -0.01343784f, 0.00788907f, -0.01531843f, 0.03586584f, -0.04278302f, -0.03531090f, -0.02680652f, -0.01278062f, 
    0.03852596f, 0.00787006f, 0.01565371f, 0.03568833f, -0.03265897f, -0.01253813f, -0.00919314f, 0.03472088f, 
    -0.02726315f, -0.04643009f, 0.03812727f, 0.04086412f, 0.03699683f, -0.03876922f, 0.04745309f, -0.01488936f, 
    0.03551185f, 0.04471420f, -0.00123990f, 0.01497429f, -0.03038169f, 0.02548897f, -0.00509143f, 0.00507267f, 
    -0.04722025f, -0.01391874f, -0.01302433f, -0.04175412f, -0.03621955f, 0.00944389f, -0.05339144f, -0.00935742f, 
    0.04081394f, 0.00330423f, -0.00541841f, -0.00027506f, -0.03226300f, -0.01229514f, 0.02558694f, -0.05030419f, 
    -0.01591431f, -0.03433819f, 0.01312792f, 0.02120689f, -0.04431460f, -0.00411538f, -0.01323996f, -0.05908706f, 
    -0.00669342f, 0.02285132f, 0.02104680f, 0.01171918f, -0.01931517f, -0.05541334f, -0.05269160f, -0.04147366f, 
    -0.04628021f, 0.03943752f, 0.01933652f, 0.04329145f, 0.04245464f, -0.03193068f, 0.00404559f, -0.00059880f, 
    0.00475965f, -0.02142967f, -0.04998336f, -0.00226089f, -0.00907461f, 0.02659884f, 0.01151567f, -0.01420934f, 
    -0.00199370f, 0.00284264f, 0.04106021f, 0.01954838f, -0.02139989f, 0.02297879f, -0.04405088f, 0.02960913f, 
    0.03494219f, 0.03935682f, 0.01060188f, 0.01196874f, -0.03867554f, 0.04386667f, 0.04271844f, 0.01617937f, 
    0.00721588f, -0.05341782f, -0.02188157f, 0.02017840f, 0.00918675f, -0.05669788f, 0.01021638f, 0.03552780f, 
    0.02316680f, 0.01815048f, -0.02470225f, 0.00239514f, -0.02503885f, -0.05936971f, -0.01512731f, -0.04796853f, 
    -0.01580573f, -0.03951005f, 0.01822159f, 0.02947289f, 0.03901855f, -0.01343391f, 0.03757646f, -0.04030386f, 
    0.00965758f, 0.02689725f, -0.02986463f, 0.01342436f, -0.04781900f, 0.00093507f, -0.00998906f, -0.01977038f, 
    -0.00793005f, 0.00598799f, -0.04546439f, 0.01954666f, -0.00379250f, -0.05701348f, -0.04974749f, 0.00845949f, 
    -0.04926304f, 0.00534702f, -0.02659544f, 0.02186072f, -0.01896159f, 0.00313386f, -0.05433546f, 0.03583978f, 
    -0.01141477f, -0.01995329f, 0.02728232f, 0.02217719f, -0.02728685f, -0.03172015f, 0.02999282f, 0.02114802f, 
    0.05544875f, 0.01641953f, -0.02794773f, -0.04917285f, -0.02242111f, 0.02819561f, -0.03566532f, 0.02496061f, 
    0.02949458f, -0.04709567f, 0.03104992f, -0.01721604f, 0.01710735f, 0.02489009f, -0.02633290f, 0.02107655f, 
    -0.03011877f, -0.00367938f, 0.01524120f, -0.00811156f, -0.02814697f, -0.00436930f, 0.01378110f, 0.04521696f, 
    -0.02156932f, 0.02392986f, -0.03320617f, 0.02200239f, -0.04444990f, -0.04804309f, -0.03996339f, -0.00586173f, 
    0.04334000f, -0.00874533f, -0.02032682f, -0.03722582f, 0.02740378f, 0.01393477f, 0.01895496f, -0.02993836f, 
    0.02193120f, 0.03681947f, 0.01748389f, -0.02192826f, -0.04290147f, -0.01053196f, -0.05367159f, 0.03632028f, 
    -0.01887840f, -0.04282662f, -0.00102188f, -0.00741614f, -0.01062497f, -0.04857462f, -0.05899825f, -0.04274654f, 
    -0.00598303f, -0.02473506f, -0.01611182f, -0.03920819f, 0.01406742f, -0.04800225f, 0.03594773f, -0.00057704f, 
    0.00745430f, 0.03543912f, -0.04696351f, -0.02297336f, 0.03168121f, -0.00292746f, -0.03115772f, -0.01546147f, 
    0.04103899f, -0.03859742f, -0.03614644f, 0.03222318f, -0.00761519f, -0.05237324f, -0.01849269f, 0.03237469f, 
    0.03107238f, -0.00306747f, -0.01110202f, 0.03978088f, 0.03682954f, 0.03284833f, 0.02066591f, 0.03032249f, 
    0.02522131f, -0.04531003f, -0.04714368f, -0.00208832f, 0.01885086f, -0.04165801f, 0.00642514f, 0.00568735f, 
    -0.01837678f, 0.02774180f, 0.03123015f, -0.05383977f, 0.01248110f, 0.01272744f, 0.03997745f, 0.04147425f, 
    -0.03098924f, -0.02912927f, -0.03514501f, 0.03969027f, -0.04679905f, 0.02097241f, 0.03633134f, 0.02169432f, 
    0.03729869f, -0.05543039f, 0.01743282f, -0.05464436f, 0.00037735f, 0.01017327f, -0.03846676f, 0.00102327f, 
    0.00885364f, -0.05245081f, 0.00513653f, -0.05952260f, -0.01929661f, 0.00907710f, -0.00238172f, 0.02032310f, 
    0.00163365f, -0.03859144f, -0.05240694f, -0.04562847f, 0.01861756f, 0.00176958f, 0.02389511f, -0.02092468f, 
    -0.00176661f, 0.01483832f, -0.04745820f, -0.03678628f, 0.01863671f, -0.04954276f, 0.02687903f, 0.02549129f, 
    0.00847985f, 0.02509059f, 0.03181367f, -0.03468483f, -0.03164088f, 0.03052459f, 0.03006046f, -0.01247713f, 
    0.01626155f, -0.00080670f, -0.05111575f, -0.05488526f, -0.03149808f, 0.01082422f, -0.02954589f, -0.01667460f, 
    0.01278842f, 0.00371687f, -0.02131572f, -0.04222273f, 0.01953936f, -0.02073247f, -0.00791319f, 0.01593059f, 
    -0.01724997f, 0.02481800f, 0.00776936f, -0.00194934f, -0.04111730f, -0.01021974f, 0.01921761f, -0.04557503f, 
    -0.02231317f, 0.03964249f, -0.01014729f, -0.01171404f, -0.02819315f, 0.02946767f, -0.02282844f, 0.02303970f, 
    -0.01988260f, -0.02232706f, 0.03475553f, -0.04009185f, -0.03065590f, 0.02963714f, 0.02227024f, 0.00155041f, 
    -0.02177032f, 0.03917988f, -0.03941935f, 0.03808593f, -0.01520430f, -0.00370715f, -0.03747756f, -0.04583231f, 
    -0.03828162f, -0.03743989f, 0.02858342f, -0.05655776f, -0.04380426f, 0.03857315f, 0.00239669f, -0.05628118f, 
    0.02420638f, 0.03115198f, -0.01796234f, -0.02753165f, -0.04180792f, 0.01394613f, 0.03180731f, 0.03971044f, 
    -0.00517389f, -0.02482976f, 0.04324767f, -0.03272050f, -0.04447467f, -0.01517875f, 0.02430546f, 0.02791617f, 
    -0.00611390f, -0.04992219f, -0.00426606f, 0.01208582f, -0.00651836f, -0.04282539f, 0.01640092f, -0.04649921f, 
    0.01884917f, -0.05237210f, 0.02568604f, -0.04933802f, 0.02648558f, -0.02150251f, 0.04308435f, 0.01444542f, 
    -0.02932294f, -0.03487710f, 0.00298991f, 0.01958856f, -0.01107872f, -0.03579374f, 0.00383024f, -0.05093785f, 
    0.03341529f, -0.04677920f, 0.01955258f, 0.03736608f, -0.02618418f, -0.03382260f, -0.03064286f, 0.00951220f, 
    -0.02867352f, 0.01606063f, 0.02012223f, 0.03895735f, -0.01505585f, -0.02456486f, -0.03418105f, -0.04166122f, 
    -0.01743623f, -0.01862209f, 0.01524117f, -0.05652645f, 0.01870478f, 0.00586052f, -0.00070647f, -0.03091307f, 
    0.01953427f, -0.00435404f, -0.03973577f, -0.03713111f, 0.03776539f, -0.01119008f, 0.01869962f, 0.00811039f, 
    -0.03189545f, -0.02636492f, 0.02308356f, 0.03067493f, -0.00512470f, 0.00314575f, -0.03784519f, 0.03157739f, 
    -0.01850596f, -0.00222580f, -0.00602492f, 0.02275227f, 0.02203383f, -0.01168529f, -0.02383754f, -0.04836968f, 
    -0.01232042f, -0.05167991f, -0.02351420f, 0.01788077f, 0.03464264f, 0.03826170f, -0.01295386f, 0.01181926f, 
    -0.05340644f, 0.01174442f, -0.00999355f, 0.01736654f, 0.02712099f, -0.04467035f, 0.03387895f, -0.04072578f, 
    0.03311125f, 0.03514813f, 0.04219236f, 0.03525496f, -0.02124848f, -0.01866791f, -0.03577263f, -0.05066537f, 
    -0.01251705f, 0.00084155f, -0.04479131f, 0.01740812f, -0.05113570f, 0.01627964f, -0.05341488f, 0.00504639f, 
    0.02783436f, 0.00138974f, -0.04625560f, -0.02610807f, 0.02233046f, 0.02873604f, -0.00048069f, -0.02463870f, 
    0.02049230f, 0.03416170f, -0.03553467f, 0.00960341f, 0.03217104f, -0.04997737f, -0.01968872f, -0.00920080f, 
    -0.01101059f, -0.04851735f, -0.03928345f, -0.05318859f, -0.01190838f, 0.00433257f, 0.01529521f, -0.04149137f, 
    0.15958247f, 0.02048357f, -0.03011728f, -0.09900025f, -0.12427939f, -0.06685838f, -0.02643809f, -0.11836762f, 
    -0.01240402f, 0.05667934f, -0.04594487f, -0.09713171f, 0.05348844f, -0.03442481f, -0.06276526f, 0.07522633f, 
    -0.03006567f, 0.11280975f, 0.02450432f, 0.00916456f, -0.01374854f, -0.09614583f, -0.04874028f, -0.10637087f, 
    0.06237640f, 0.02655552f, -0.02363297f, 0.19213349f, -0.04812526f, 0.01553156f, -0.03380657f, 0.02700301f, 
    0.01075622f, -0.03910150f, 0.08698258f, 0.09047423f, 0.12516052f, 0.10112034f, -0.02235918f, -0.26873082f, 
    0.00915459f, 0.04854635f, 0.03983567f, 0.05360515f, 0.19276421f, 0.11066442f, 0.07861039f, -0.10605045f, 
    -0.04079133f, 0.23696019f, 0.05586938f, 0.08846755f, 0.07086122f, 0.03762776f, -0.01455733f, 0.03586704f, 
    0.04859406f, 0.08836063f, 0.05702445f, -0.08838987f, 0.13699675f, 0.06269716f, 0.19294034f, 0.07228816f, 
    -0.12482841f, 0.02914052f, -0.05777724f, 0.03209813f, 0.04612663f, 0.07138635f, 0.06576239f, 0.09176437f, 
    -0.25521380f, 0.04784605f, 0.09827741f, 0.08959973f, 0.10645362f, 0.00951528f, 0.04702266f, -0.02721258f, 
    0.13018242f, 0.03800853f, -0.06723480f, -0.05094922f, 0.25238204f, -0.15860480f, -0.10646380f, 0.09208900f, 
    -0.09147569f, -0.00351615f, -0.08648495f, 0.13170718f, 0.10343152f, -0.02274360f, 0.03430356f, -0.13046959f, 
    0.13570516f, 0.10374134f, -0.00713530f, 0.17066696f, -0.07028697f, 0.07397243f, -0.02264371f, 0.03255500f, 
    0.03988293f, 0.03412001f, 0.09649267f, 0.13816579f, 0.27747890f, 0.11877154f, 0.12431953f, -0.15781333f, 
    -0.06474766f, 0.02713430f, 0.07238682f, 0.02960146f, 0.05713300f, 0.12463444f, -0.12482562f, 0.03851319f, 
    0.10785398f, 0.14629881f, -0.02842174f, 0.11695521f, -0.11353786f, 0.02134752f, 0.05716611f, 0.04157702f, 
    -0.03177138f, 0.04104047f, -0.03763788f, 0.07652212f, 0.03116595f, 0.05273028f, -0.30908534f, 0.03109140f, 
    0.03374961f, -0.03824185f, 0.03797402f, -0.04971929f, -0.05278708f, 0.02077477f, -0.01567558f, -0.00101009f, 
    0.06492421f, -0.11853813f, -0.23522478f, -0.01843735f, -0.09456208f, 0.02476557f, -0.08317886f, 0.07601328f, 
    0.02029441f, 0.14127822f, -0.13607326f, -0.00984796f, 0.04721747f, 0.03270561f, 0.30474228f, 0.01743707f, 
    -0.04944412f, -0.16680883f, 0.07341105f, 0.12011288f, -0.00007035f, 0.13675073f, 0.02195084f, 0.10722172f, 
    0.09855933f, 0.04215401f, 0.25492096f, 0.06432848f, -0.08055937f, 0.21518786f, 0.14890045f, -0.11856049f, 
    -0.07866190f, -0.02923103f, 0.06267466f, 0.00393835f, 0.06594884f, 0.07990313f, -0.08248648f, 0.01289522f, 
    -0.03509037f, -0.03121587f, 0.13040562f, -0.02753709f, -0.17734373f, 0.02855149f, -0.04395639f, 0.12961029f, 
    -0.04747776f, 0.00729606f, -0.07396643f, 0.13761020f, -0.01123527f, -0.04725900f, -0.09200732f, 0.10908481f, 
    -0.10981587f, 0.06447931f, 0.12934734f, -0.01417274f, -0.05754479f, 0.30351925f, 0.03277826f, -0.12138504f, 
    0.05102444f, 0.01904215f, 0.04575266f, -0.02340073f, -0.02598151f, -0.00492073f, -0.04296373f, -0.04162792f, 
    0.17551982f, 0.13547151f, 0.07786442f, -0.01430104f, -0.02409398f, -0.01906635f, 0.00927927f, -0.04540926f, 
    0.01701578f, 0.06414098f, -0.00994012f, 0.03027160f, 0.03099373f, 0.08756307f, 0.02288768f, -0.05868402f, 
    -0.03085295f, 0.05513065f, -0.10487736f, -0.05194348f, 0.01109522f, 0.11213724f, -0.02969271f, 0.09257876f, 
    -0.02786130f, 0.02077198f, -0.05929754f, 0.11957759f, -0.02482007f, 0.04286067f, 0.09603357f, -0.01708958f, 
    -0.10080267f, 0.14233874f, 0.06184319f, 0.00904606f, -0.02451372f, 0.00953944f, 0.17096241f, 0.13111880f, 
    -0.09162614f, -0.12510192f, 0.12290367f, 0.03989312f, 0.01059697f, 0.12529945f, -0.04815071f, -0.04266414f, 
    -0.10780387f, -0.07582844f, 0.11503965f, 0.09137985f, -0.10933938f, -0.00553810f, 0.00072315f, 0.10434713f, 
    0.16075391f, -0.13169469f, 0.14861354f, -0.04565428f, 0.36065289f, 0.14687826f, 0.01876667f, 0.01653702f, 
    0.02112286f, 0.02492143f, 0.06626786f, -0.09947443f, -0.04027465f, -0.02245753f, -0.00165046f, 0.00767221f, 
    0.07683793f, 0.10155841f, 0.01937817f, 0.07922351f, -0.04594176f, 0.09587785f, -0.01490047f, 0.09206712f, 
    -0.02535033f, 0.17305067f, 0.00591026f, 0.01714721f, 0.05399570f, 0.42208666f, 0.14915735f, -0.09137911f, 
    -0.10211087f, 0.02903727f, 0.00680590f, 0.14899869f, -0.00411107f, -0.08664565f, -0.00150059f, -0.04957478f, 
    -0.40583485f, 0.00517973f, -0.00251905f, -0.15147144f, 0.00749241f, 0.02651520f, -0.11927772f, 0.15066597f, 
    0.03784031f, 0.06184904f, -0.04262280f, 0.11992991f, -0.16755731f, -0.09328147f, -0.22280513f, 0.06499480f, 
    -0.04564342f, -0.08987464f, 0.04459664f, 0.11271410f, 0.04124479f, 0.10078690f, -0.18059903f, 0.03446856f, 
    0.00841498f, -0.19777876f, -0.29402211f, 0.19621649f, 0.00039358f, -0.03290289f, -0.00777866f, 0.03019387f, 
    0.01440965f, 0.08282047f, 0.03438346f, -0.04514313f, -0.02571393f, -0.26462552f, -0.14757875f, 0.01330421f, 
    0.00361879f, -0.04401916f, -0.15671477f, -0.03078866f, -0.05894621f, 0.02248374f, -0.04205147f, -0.07018760f, 
    0.06158938f, 0.20620458f, 0.08677950f, -0.06074391f, 0.03518560f, -0.12963432f, 0.02567184f, 0.20018055f, 
    0.05655895f, -0.03110244f, 0.01065303f, 0.07259648f, 0.09834081f, 0.01329751f, 0.18232472f, 0.16474099f, 
    0.00489759f, 0.09537074f, -0.14311284f, -0.02092674f, 0.06265248f, -0.07073378f, -0.21388933f, -0.01582610f, 
    -0.26847041f, -0.11493067f, 0.10791856f, 0.25315350f, -0.00780091f, 0.03847625f, -0.00598464f, 0.13464703f, 
    -0.14915431f, 0.00878465f, 0.05287078f, -0.03582247f, 0.04510570f, -0.34177226f, 0.18498696f, -0.11102100f, 
    -0.15316632f, -0.00127417f, -0.05846677f, -0.13304196f, 0.09604261f, -0.01171082f, -0.02356356f, -0.06658165f, 
    0.29678342f, 0.10558649f, -0.02360919f, 0.05070138f, 0.18963863f, 0.02527134f, -0.00672990f, -0.18125603f, 
    -0.08785473f, 0.00837845f, 0.02392949f, 0.03586106f, 0.09145213f, -0.01072423f, 0.07703556f, 0.28959337f, 
    -0.08655667f, -0.09467368f, -0.01395603f, -0.09840849f, 0.05959114f, -0.12335370f, 0.00034702f, 0.00617928f, 
    -0.11413938f, -0.24252087f, -0.09443441f, -0.07469065f, 0.13100320f, -0.02165823f, -0.03368621f, 0.09241725f, 
    0.08828020f, 0.03251859f, -0.08154737f, 0.05338242f, -0.16070844f, 0.08385076f, 0.00697047f, 0.17254826f, 
    0.17423360f, 0.10008255f, 0.15039109f, 0.07181496f, -0.07861867f, -0.01099314f, -0.04222985f, 0.01347540f, 
    -0.18429396f, -0.25452438f, 0.09505022f, -0.01790134f, -0.13557780f, -0.10576344f, 0.01761278f, -0.00925494f, 
    -0.01652096f, 0.02061529f, -0.02102396f, 0.08242660f, 0.02503109f, 0.39073151f, 0.01399110f, -0.06609471f, 
    0.01022696f, 0.07262013f, -0.00671458f, -0.02213458f, 0.01002236f, -0.02877828f, 0.05435057f, 0.04391991f, 
    -0.73357731f, 0.23631869f, 0.01811822f, -0.14810687f, 0.07297534f, 0.06256498f, 0.06204469f, 0.01047196f, 
    0.04000553f, -0.03864609f, -0.03688832f, -0.01524911f, 0.09999458f, -0.09899303f, -0.03011134f, 0.04650530f, 
    0.33257201f, -0.08025042f, 0.10700683f, 0.02380792f, 0.02393700f, -0.06413485f, 0.03212445f, 0.06234278f, 
    -0.62955189f, -0.07058927f, 0.11948655f, -0.11997421f, 0.00558719f, -0.12304308f, -0.03850072f, 0.01324966f, 
    0.07273486f, -0.01617777f, 0.00511703f, -0.05969932f, -0.00380188f, 0.05694507f, 0.14404355f, -0.01790945f, 
    0.09571044f, 0.06813353f, 0.02025352f, 0.02022296f, 0.08455023f, 0.04882395f, -0.00351839f, 0.00870796f, 
    -0.05213693f, 0.12151878f, 0.11190747f, -0.08231035f, -0.04907615f, -0.04117424f, -0.08818059f, -0.11314040f, 
    0.08105330f, -0.07385915f, -0.09380247f, 0.04827666f, -0.41190976f, 0.27406892f, 0.10133495f, 0.12185358f, 
    0.21213208f, 0.04369163f, 0.03675020f, 0.00388117f, -0.01893651f, -0.05439853f, 0.11801216f, 0.00273647f, 
    0.32061371f, 0.21835375f, -0.11585356f, -0.25725520f, -0.00450150f, -0.05979744f, -0.01483712f, 0.13511053f, 
    0.11633895f, 0.10415672f, 0.12039934f, -0.04088167f, 0.22112282f, 0.19916384f, -0.03820924f, 0.21781911f, 
    0.11373696f, 0.16882077f, -0.16592285f, 0.10765224f, 0.02754723f, 0.03217288f, 0.22038639f, 0.02177647f, 
    -0.18356043f, 0.41847721f, -0.05705710f, 0.04069400f, 0.04578611f, -0.07807177f, -0.03704374f, -0.01025820f, 
    0.05601404f, -0.01959391f, -0.05772541f, -0.10677576f, 0.36472175f, -0.18823095f, 0.06383181f, -0.01710810f, 
    -0.07977846f, 0.04752649f, 0.05965916f, -0.04349485f, -0.06270599f, -0.10015257f, -0.02201199f, 0.07374263f, 
    -0.18816707f, -0.00725620f, -0.06130531f, 0.28105980f, 0.32389939f, 0.12091217f, -0.11441819f, 0.16940726f, 
    0.02542365f, 0.01181520f, 0.03939320f, 0.03532900f, 0.06924874f, -0.12438896f, 0.04733803f, 0.07633828f, 
    -0.13130760f, 0.03872736f, 0.03807115f, 0.02807570f, -0.02316290f, -0.02290026f, -0.01184391f, 0.09713597f, 
    -0.26988295f, 0.02194839f, 0.11911178f, -0.12393727f, 0.02585639f, -0.00811766f, 0.04165300f, -0.00999484f, 
    0.12985566f, 0.05394523f, 0.01015195f, 0.06441569f, -0.12392869f, -0.25722617f, 0.01613691f, 0.08207748f, 
    -0.05837392f, -0.04244816f, -0.01535621f, 0.01316635f, 0.16282065f, 0.19325647f, 0.08611535f, -0.03123918f, 
    0.17461343f, -0.01927416f, 0.01805036f, 0.17975467f, 0.13755038f, 0.00299582f, 0.07507218f, -0.11376726f, 
    0.12884533f, -0.02127733f, 0.14612618f, -0.12103750f, -0.20482478f, 0.18242092f, 0.00705506f, -0.09264870f, 
    0.03337128f, 0.03059212f, 0.08797631f, -0.04875629f, -0.04819100f, 0.00472994f, -0.00676046f, 0.09113064f, 
    0.21325120f, -0.09455559f, -0.05649753f, 0.17050488f, 0.01229315f, -0.02565110f, -0.00671862f, -0.02121717f, 
    0.07906641f, -0.04596753f, 0.11932065f, -0.01368388f, 0.08987200f, -0.18089709f, 0.14605944f, 0.10938478f, 
    0.15607201f, 0.02887752f, 0.00530520f, -0.00966569f, 0.05655708f, 0.06948499f, 0.08719026f, 0.03829326f, 
    0.18757983f, 0.02310775f, 0.07891610f, -0.00991920f, 0.07923453f, -0.11302255f, 0.02460082f, -0.02934204f, 
    0.07585024f, 0.06757136f, -0.00329101f, -0.03324861f, 0.10332212f, 0.17357802f, 0.15818484f, -0.00255694f, 
    -0.01319611f, -0.03304550f, 0.04283546f, 0.01211428f, 0.10688703f, 0.17019121f, -0.04491616f, 0.02927340f, 
    -0.04050035f, 0.30933502f, -0.12419178f, 0.08596189f, 0.17975871f, 0.08403341f, 0.05231966f, -0.01562849f, 
    -0.01099420f, 0.15928814f, 0.02046210f, -0.03913939f, -0.09335755f, 0.33141315f, 0.02330493f, 0.01614057f, 
    -0.08722091f, 0.02459278f, 0.03917999f, 0.02813980f, -0.04029774f, -0.01068654f, -0.03974753f, -0.01987846f, 
    0.00784670f, 0.09862939f, 0.18733226f, 0.21194020f, 0.19273314f, 0.07923974f, 0.05919400f, 0.01733902f, 
    -0.11430547f, 0.00789097f, -0.02079183f, -0.02542670f, -0.26998386f, 0.01496523f, -0.00413616f, 0.14124504f, 
    -0.20359510f, -0.08132906f, 0.03544951f, 0.07591472f, -0.01011814f, 0.10582757f, -0.00524781f, 0.11260043f, 
    0.11177054f, -0.21075720f, -0.05008859f, 0.14030814f, 0.12549752f, 0.17530392f, 0.06134595f, -0.06096340f, 
    0.03117997f, 0.03374093f, 0.05218624f, 0.01600548f, 0.24814354f, 0.31764477f, 0.17170745f, 0.24905089f, 
    -0.06073403f, -0.08431935f, 0.00126502f, 0.12038510f, 0.02107821f, -0.00711436f, 0.15817128f, 0.08228263f, 
    -0.02384261f, 0.01794433f, -0.11523664f, 0.41442844f, -0.02090587f, 0.03888768f, 0.04427721f, 0.09705251f, 
    0.07553224f, 0.15051596f, 0.07253560f, 0.12423577f, -0.11489049f, -0.12686788f, 0.15582520f, -0.27261782f, 
    0.06441575f, 0.14566347f, 0.09910198f, 0.00983231f, -0.14108664f, 0.02408843f, 0.06780469f, 0.15399185f, 
    -0.44704032f, 0.24330249f, -0.01001869f, 0.07089064f, 0.08646249f, 0.23987515f, -0.05943413f, -0.01579703f, 
    -0.00361894f, -0.02365084f, 0.11510015f, -0.06141431f, -0.00700736f, 0.03467024f, -0.11803491f, -0.11139183f, 
    0.08115760f, 0.08655655f, 0.00233903f, 0.09807326f, 0.15660104f, 0.01693133f, -0.20771158f, 0.00969360f, 
    0.18333040f, 0.26931748f, -0.09703070f, -0.02170793f, -0.08579948f, 0.03306972f, 0.01727506f, 0.00566726f, 
    0.01225510f, 0.10100425f, 0.12589493f, 0.02955809f, 0.43924257f, -0.14636892f, 0.15811427f, 0.08987436f, 
    0.08784398f, -0.05625612f, 0.05023954f, 0.15371655f, -0.02359984f, 0.19779298f, -0.06648479f, 0.08461504f, 
    0.16574216f, 0.15393750f, -0.04817381f, 0.14468481f, 0.14964105f, 0.16828500f, 0.04099964f, 0.03858106f, 
    -0.06882633f, 0.14571376f, -0.00433741f, 0.12455065f, 0.11770204f, -0.08349863f, 0.00815618f, -0.02334167f, 
    0.06914942f, 0.03715977f, -0.01005240f, -0.00008548f, 0.16817114f, 0.14840060f, -0.14166032f, 0.08711433f, 
    0.18558259f, -0.08619233f, -0.20057209f, 0.21347751f, 0.21586308f, 0.16707788f, 0.08262761f, 0.14529249f, 
    0.08664092f, 0.02818525f, 0.10147553f, 0.10216501f, -0.21549025f, 0.22950016f, -0.23988262f, -0.14146087f, 
    -0.12157253f, 0.11097265f, -0.05003611f, -0.03369684f, 0.03618392f, 0.09417190f, 0.02965459f, 0.04632029f, 
    0.37947962f, 0.14769411f, 0.03308170f, 0.17966655f, -0.07208145f, -0.15313265f, 0.12732032f, 0.14952454f, 
    0.01036486f, 0.07657657f, -0.05728012f, 0.02853989f, 0.12813523f, 0.20421585f, -0.15592971f, -0.16621025f, 
    0.18446729f, 0.09619729f, -0.09120411f, 0.01484962f, 0.22354689f, -0.08137999f, 0.02383753f, 0.02891170f, 
    -0.37914401f, 0.29310140f, -0.23790866f, 0.30382609f, -0.00014962f, 0.03236130f, -0.11809763f, -0.07591609f, 
    0.06720538f, -0.05457916f, 0.07285255f, -0.09829678f, -0.12714167f, -0.27703327f, 0.19408762f, -0.30220827f, 
    0.06143710f, -0.10239381f, 0.13166125f, -0.01677118f, -0.02819250f, -0.04576093f, -0.04301880f, 0.02367586f, 
    0.16672754f, -0.05287987f, 0.13254954f, 0.20713639f, 0.18121111f, 0.18363963f, -0.03120988f, 0.21845685f, 
    0.03261277f, 0.12680399f, 0.13623528f, 0.04158842f, -0.09345528f, 0.10569708f, -0.03560537f, 0.13967136f, 
    0.10864723f, 0.02673007f, -0.07675443f, 0.03421734f, 0.05982557f, 0.18500635f, 0.06350476f, -0.09930691f, 
    0.37194982f, 0.01170703f, 0.04238958f, -0.09669763f, 0.20744334f, 0.01881680f, 0.19213969f, 0.07920453f, 
    0.11561199f, 0.09677121f, 0.07525826f, 0.12336987f, 0.03260784f, -0.14374354f, 0.27145320f, 0.07086293f, 
    0.07739813f, 0.00742385f, 0.06716289f, 0.05890070f, 0.03812538f, -0.05904714f, 0.04454510f, -0.12298704f, 
    0.08616677f, 0.01529062f, 0.01262358f, 0.15290275f, 0.03756091f, 0.06427330f, 0.11556625f, 0.05932570f, 
    -0.04258578f, 0.03192439f, -0.05306144f, 0.00220593f, 0.09644047f, 0.00020790f, -0.02356212f, 0.12248639f, 
    0.09744234f, 0.05479959f, 0.09628122f, 0.16945842f, -0.00040014f, 0.03564797f, 0.10173157f, 0.01053567f, 
    0.06705527f, -0.03858938f, -0.05975787f, -0.08180774f, 0.04833207f, 0.16793673f, 0.05241014f, -0.01284576f, 
    0.03338626f, 0.07548510f, -0.07891962f, 0.04970979f, -0.25795910f, -0.21286918f, 0.33725351f, -0.09497617f, 
    -0.07084791f, -0.02292415f, 0.13857670f, -0.08918379f, 0.17899999f, 0.12544821f, 0.07491192f, 0.03813014f, 
    -0.16647972f, -0.06863484f, 0.23067783f, -0.03437070f, 0.10120741f, 0.01479287f, 0.17412835f, 0.06710508f, 
    0.06793400f, -0.03830753f, 0.05293661f, 0.12251741f, 0.25403935f, -0.01353833f, 0.06455700f, -0.28817081f, 
    0.02588093f, 0.17689440f, 0.01283577f, 0.05738456f, 0.09308667f, -0.00143088f, -0.00502948f, -0.11158721f, 
    0.36086893f, -0.07908210f, 0.13170123f, -0.46014249f, 0.01212711f, -0.13061973f, 0.16125318f, -0.05651829f, 
    -0.03123327f, 0.20171748f, 0.02959916f, 0.04559176f, 0.31484148f, -0.00583462f, -0.04992120f, 0.12470888f, 
    -0.00806114f, 0.15479806f, 0.09284409f, 0.00169236f, 0.08481592f, -0.00631266f, 0.08849315f, 0.02401380f, 
    0.18749212f, -0.07448762f, 0.00586062f, 0.22439478f, 0.00745229f, 0.08056639f, -0.04634288f, 0.11311765f, 
    0.16182755f, 0.05668013f, 0.06322765f, 0.07679114f, 0.43148789f, 0.10260659f, 0.17841204f, 0.13803491f, 
    -0.06542539f, -0.04725459f, 0.15277064f, 0.04739704f, 0.10301455f, 0.07649151f, 0.13826868f, 0.12225075f, 
    -0.22195400f, 0.08439332f, 0.00918515f, -0.20187706f, 0.03337053f, 0.06713345f, 0.00259607f, 0.02024997f, 
    -0.13241191f, 0.02852002f, -0.06356142f, -0.10044398f, 0.01571765f, 0.00733543f, 0.18000390f, 0.06503540f, 
    0.11592694f, 0.06684058f, 0.03312377f, 0.08741530f, 0.06620152f, 0.03307020f, 0.02912515f, 0.10706618f, 
    -0.04886705f, 0.02203114f, -0.01103768f, 0.02295349f, 0.03217169f, 0.00217231f, -0.00564708f, 0.01867073f, 
    0.00226386f, -0.03163719f, 0.01711346f, 0.00368826f, -0.01545503f, -0.03908890f, 0.03702375f, -0.04939163f, 
    -0.05765694f, 0.00933642f, -0.00078230f, 0.02401712f, 0.01749985f, 0.00586660f, 0.01837258f, 0.03827207f, 
    -0.01055467f, -0.03826011f, 0.02182898f, -0.00369990f, -0.04189690f, -0.04467597f, 0.00694009f, 0.01725119f, 
    0.01949861f, -0.04221608f, -0.02399191f, 0.03429557f, 0.02234962f, 0.03517472f, -0.01092573f, -0.02807616f, 
    -0.01822726f, 0.01502250f, -0.05189615f, 0.00524456f, -0.04359436f, 0.05188179f, 0.03018461f, 0.00164707f, 
    0.02311604f, -0.01642948f, -0.03340621f, 0.03468616f, 0.02637748f, 0.01076244f, -0.00009130f, 0.02998522f, 
    -0.01458718f, 0.02577552f, 0.01122526f, 0.01181274f, 0.04252382f, -0.03299502f, 0.02710208f, -0.00267131f, 
    0.02629583f, -0.00827826f, -0.02260026f, -0.02491036f, 0.01213176f, -0.02257119f, -0.04650090f, -0.02959839f, 
    -0.04999758f, -0.00540253f, 0.01771002f, -0.04329920f, 0.02686015f, -0.04815989f, -0.00516682f, -0.00743588f, 
    -0.01045855f, -0.04312380f, 0.03510376f, 0.04302366f, -0.01951082f, -0.01096815f, -0.00606503f, 0.03675677f, 
    -0.02384304f, 0.03558340f, -0.03683014f, -0.05166308f, -0.02765073f, -0.03007581f, -0.01411143f, -0.02077782f, 
    -0.02804622f, -0.03374475f, 0.01441926f, 0.00381725f, 0.00630708f, 0.00726921f, -0.00072915f, 0.01096348f, 
    -0.02987788f, 0.00587532f, 0.01578281f, -0.03827287f, 0.01394427f, -0.01374841f, 0.02541611f, -0.00841998f, 
    0.00982787f, -0.03629897f, 0.04608531f, -0.01706054f, -0.01065225f, -0.00266252f, 0.02534499f, 0.04739228f, 
    -0.05037909f, 0.00024834f, -0.03405806f, -0.04439082f, -0.00203712f, -0.02242450f, 0.02902657f, -0.04107295f, 
    0.00506803f, -0.02964937f, -0.01253227f, 0.00137453f, 0.04288981f, -0.03902755f, -0.00822680f, -0.01735123f, 
    0.04005731f, -0.02262216f, 0.00329747f, -0.03754166f, -0.00269390f, 0.00402223f, 0.00000658f, -0.01274575f, 
    0.03582338f, -0.02775630f, 0.00887579f, -0.04668995f, 0.00696336f, -0.00810465f, 0.02317364f, -0.00139929f, 
    0.04560166f, 0.02215555f, -0.05132435f, -0.00389296f, -0.02198695f, -0.02673368f, 0.00436385f, 0.05217097f, 
    -0.02765547f, -0.05338225f, -0.02268877f, -0.02139463f, 0.00222489f, 0.03087883f, -0.00566226f, -0.05157423f, 
    -0.01996649f, -0.03520138f, -0.04243451f, 0.04360618f, -0.04094624f, -0.01029854f, 0.02300820f, 0.00317272f, 
    0.01723400f, -0.04981380f, 0.03058150f, -0.03197784f, -0.05723594f, -0.00216706f, 0.00972820f, 0.02620463f, 
    -0.00679523f, -0.00816458f, -0.02745049f, 0.00164138f, 0.03538147f, 0.01832261f, -0.00369073f, -0.05077787f, 
    -0.01531650f, 0.02311911f, -0.05045494f, -0.00702983f, 0.04239473f, 0.02550240f, 0.04199034f, -0.01327944f, 
    -0.02302675f, -0.04097807f, 0.00716699f, -0.03419308f, -0.00041183f, 0.00266135f, -0.05122081f, -0.05585717f, 
    0.02811561f, -0.03369819f, 0.01676842f, -0.04257050f, -0.04375986f, 0.04036546f, 0.01188425f, -0.00589830f, 
    -0.01363211f, -0.05634577f, -0.00249893f, -0.02947058f, -0.00687574f, -0.04617900f, 0.00111221f, 0.02984207f, 
    -0.03462967f, -0.00596104f, -0.00417823f, 0.00440124f, -0.03574374f, 0.00672305f, -0.00682734f, 0.02348718f, 
    0.03318419f, -0.00683318f, -0.03895500f, -0.03124944f, 0.00579077f, 0.02598959f, -0.00078420f, 0.02693424f, 
    0.04456883f, 0.04125845f, -0.03954458f, 0.03574174f, -0.02108964f, -0.03902340f, 0.01560903f, -0.04673483f, 
    -0.04740893f, -0.04537783f, 0.02989713f, -0.01817209f, 0.05202135f, -0.00888207f, -0.05190868f, -0.00364397f, 
    0.01830205f, -0.01314465f, 0.00660463f, 0.01891078f, -0.00682485f, 0.00522052f, 0.00064283f, 0.03625658f, 
    -0.02585560f, -0.00848323f, 0.02891294f, 0.02469900f, -0.00631284f, -0.04716940f, -0.01917889f, -0.02803758f, 
    -0.05221691f, 0.03273020f, -0.02365130f, -0.04366490f, -0.05407981f, -0.01347817f, 0.01443250f, 0.01175936f, 
    0.00065929f, 0.02441464f, 0.03339482f, -0.01762252f, -0.05648732f, 0.00549345f, -0.01294548f, -0.04244893f, 
    -0.04736203f, -0.02728017f, 0.00728451f, -0.02806524f, 0.02753860f, 0.02952873f, 0.02266174f, -0.04659859f, 
    0.03160321f, -0.03772662f, 0.03872178f, -0.04730454f, -0.01465813f, 0.02390951f, -0.00128440f, -0.00538078f, 
    0.00611643f, -0.04839250f, -0.05217272f, -0.05032183f, 0.03363280f, 0.00205131f, 0.02183225f, 0.02359456f, 
    -0.01998662f, -0.03584836f, 0.04037315f, 0.00054604f, -0.01854461f, 0.01362350f, -0.02547245f, -0.05935273f, 
    -0.02264605f, 0.03603595f, -0.05185590f, 0.00795621f, 0.00252793f, -0.04598959f, -0.05268316f, -0.01342343f, 
    0.01990101f, -0.01090425f, 0.03791435f, -0.05688491f, 0.03779089f, 0.02382403f, 0.00173474f, -0.00278688f, 
    -0.01007003f, -0.01889149f, -0.03240164f, 0.01300962f, -0.00708361f, 0.00416980f, 0.03797818f, -0.04990968f, 
    -0.05145019f, -0.02243214f, 0.00042845f, -0.03768319f, 0.03287163f, 0.00479993f, 0.02138099f, 0.00358245f, 
    0.02244604f, -0.03068575f, -0.03477089f, -0.03312783f, -0.01151898f, 0.01695528f, -0.01481299f, 0.00259314f, 
    0.03765827f, -0.03818512f, -0.03469211f, -0.04329659f, 0.02464001f, 0.00753064f, 0.04418702f, -0.02189263f, 
    -0.03273218f, -0.02964116f, 0.00715216f, -0.02013559f, 0.01358561f, -0.01318276f, -0.02279741f, -0.00054953f, 
    -0.02381645f, 0.02956437f, -0.01276214f, 0.02652648f, -0.04495150f, 0.02921800f, -0.05846168f, 0.00767126f, 
    0.01578306f, 0.02866998f, -0.01915005f, -0.03194381f, -0.01135246f, -0.03459443f, 0.02440933f, -0.00640628f, 
    -0.01696072f, -0.03856621f, 0.03950877f, 0.02181167f, -0.03669009f, -0.02143575f, 0.03571359f, -0.02361715f, 
    -0.03931415f, 0.04206078f, -0.05133331f, -0.03919132f, -0.00537272f, -0.03348961f, 0.01414782f, -0.02850883f, 
    -0.05720831f, -0.03448766f, 0.00677017f, 0.02865507f, -0.02360663f, -0.03105940f, -0.04476824f, 0.00311422f, 
    -0.01051934f, 0.00996358f, 0.04219614f, -0.04699329f, -0.02232795f, 0.03832074f, -0.04783851f, 0.03221786f, 
    -0.02063458f, 0.04448352f, -0.05530571f, -0.02452385f, -0.01555897f, -0.02356013f, -0.05608046f, 0.01051343f, 
    0.04172684f, -0.00604375f, 0.03200460f, -0.03438807f, -0.05396001f, 0.01926191f, 0.01435060f, 0.00847912f, 
    -0.02960112f, -0.02256913f, 0.04040319f, -0.03497085f, 0.02276044f, -0.02739816f, -0.00316566f, -0.04292663f, 
    -0.00237025f, 0.01596191f, -0.03113941f, 0.03409158f, -0.00379952f, -0.02481270f, -0.00718892f, -0.05188868f, 
    0.03466634f, -0.05193844f, -0.00108967f, -0.03861574f, -0.02608106f, -0.05859829f, -0.01916512f, 0.02324217f, 
    0.03921784f, -0.04448112f, 0.01861349f, -0.02617531f, -0.04503962f, 0.03051911f, 0.04318859f, 0.02787564f, 
    0.02835744f, -0.00164479f, 0.01070696f, -0.02813261f, 0.02908714f, -0.01755614f, 0.01130103f, -0.02616722f, 
    0.01825255f, 0.01762139f, -0.01583130f, -0.04312013f, -0.02260183f, 0.01089505f, -0.01422584f, -0.00195859f, 
    -0.05519168f, 0.02628518f, -0.00937015f, -0.00766823f, 0.00168229f, -0.02735921f, -0.04205401f, -0.01978775f, 
    -0.00551453f, -0.04709001f, -0.02861293f, -0.02506101f, 0.00708044f, 0.02667619f, 0.01185613f, -0.02261961f, 
    0.03733985f, 0.00096772f, -0.02637118f, -0.00305473f, -0.02185758f, 0.01659231f, 0.01124636f, -0.04504522f, 
    -0.00080892f, 0.03797645f, -0.01361207f, 0.02345201f, -0.05617836f, -0.00356367f, 0.03652180f, -0.00857569f, 
    -0.04315800f, -0.02803101f, 0.00772152f, -0.03509219f, 0.01007915f, 0.03317398f, -0.04817982f, 0.00904278f, 
    0.00150964f, -0.03314050f, -0.03338382f, -0.03062198f, -0.02235209f, -0.02268577f, -0.00776604f, -0.02283866f, 
    -0.05543067f, 0.00022209f, 0.04022414f, 0.04036191f, -0.01406491f, -0.05473206f, 0.00208314f, -0.03020325f, 
    -0.02306169f, -0.01838758f, -0.03254922f, -0.02988737f, 0.01237693f, 0.03873847f, 0.03268588f, 0.01129858f, 
    -0.02725868f, -0.04794633f, -0.01564425f, -0.05350246f, -0.00326278f, -0.01114572f, 0.00765811f, 0.03162929f, 
    -0.05237073f, -0.02056902f, -0.05190299f, -0.04710349f, -0.01441258f, 0.02982028f, 0.04325366f, -0.04157970f, 
    0.03130704f, 0.03828694f, 0.02126718f, -0.02913500f, 0.04143317f, -0.02160249f, -0.04303902f, -0.03163005f, 
    -0.05352684f, 0.02367912f, -0.02023980f, -0.05005123f, 0.04202682f, -0.00316009f, -0.04546727f, -0.00524396f, 
    -0.03244385f, -0.01290458f, 0.02046529f, -0.01815152f, 0.03535634f, -0.01844312f, 0.03549362f, -0.03996787f, 
    0.03769047f, 0.02684176f, -0.00864645f, 0.01214925f, 0.00340527f, -0.03908748f, -0.05054466f, -0.00477797f, 
    0.04242699f, 0.01949068f, 0.02145681f, -0.04405884f, -0.03630494f, -0.01872075f, 0.03588682f, -0.03138321f, 
    -0.02532773f, -0.00977167f, 0.03715025f, -0.03857140f, -0.05335780f, 0.04049055f, -0.00898110f, -0.04242093f, 
    0.01296241f, -0.04560608f, 0.00773220f, 0.03900041f, 0.01906665f, 0.04421794f, -0.02203476f, 0.04299915f, 
    -0.02890306f, 0.00562753f, -0.03223149f, -0.05222679f, 0.01583052f, 0.01744245f, -0.05788845f, -0.04200004f, 
    -0.01978542f, -0.04420484f, -0.00054070f, 0.01284475f, -0.03227262f, -0.05556939f, -0.02913666f, 0.03561268f, 
    -0.00538221f, -0.01492603f, 0.00647457f, 0.02695733f, -0.04027213f, -0.04500015f, -0.04043582f, 0.01216434f, 
    0.00378411f, -0.01159855f, 0.00598996f, -0.03657563f, 0.00787568f, 0.01518845f, 0.01167518f, -0.05338725f, 
    -0.01173290f, -0.01318509f, 0.01294200f, 0.00375637f, 0.02535442f, 0.04058628f, -0.04153600f, -0.03291398f, 
    0.02764028f, 0.01686089f, -0.03205908f, -0.05228433f, -0.02894598f, 0.03880127f, 0.04128413f, 0.02785286f, 
    -0.02910236f, 0.03876960f, 0.01838570f, 0.03628150f, -0.04945766f, -0.02061228f, -0.01763262f, -0.00190173f, 
    0.04228169f, -0.03199050f, 0.02280159f, -0.05674575f, -0.03543969f, -0.05025477f, -0.04717451f, 0.00347432f, 
    0.03438118f, -0.01115835f, 0.04416807f, 0.01569514f, -0.05491440f, -0.02853065f, -0.04077649f, 0.01736168f, 
    -0.01922158f, 0.00404286f, 0.02497644f, -0.00695035f, -0.05124352f, -0.00325048f, -0.00349614f, -0.00391214f, 
    0.02363729f, -0.02755259f, -0.01379103f, -0.03382565f, 0.04030483f, -0.02574441f, 0.03676609f, -0.01123136f, 
    0.02302112f, 0.01051477f, 0.02945638f, 0.00286939f, -0.04098806f, -0.00239999f, 0.03754451f, -0.01363461f, 
    -0.02510973f, -0.00326729f, -0.02705648f, 0.03871267f, -0.05456863f, -0.03247858f, -0.03829117f, 0.00741743f, 
    0.02146428f, 0.03864058f, 0.00106146f, -0.02985856f, -0.03488982f, -0.02372694f, 0.02793139f, 0.03563917f, 
    -0.04147829f, 0.02529014f, -0.00484382f, -0.05201806f, -0.03080777f, -0.03981003f, -0.02276757f, 0.02396697f, 
    0.03855112f, -0.02051529f, -0.00396271f, 0.03453927f, 0.01483225f, -0.05266578f, -0.01637872f, -0.05532559f, 
    -0.03225572f, 0.01510669f, 0.02409527f, 0.03410900f, -0.01287775f, 0.00193338f, 0.00537323f, 0.03075803f, 
    -0.00941606f, -0.04438935f, 0.01441491f, 0.03420654f, -0.05133167f, -0.00820138f, -0.03368201f, -0.03635265f, 
    0.27855301f, -0.08819400f, 0.03613134f, 0.14330857f, -0.07920055f, -0.03602791f, -0.07099819f, 0.03176421f, 
    -0.14086124f, 0.03099487f, 0.07934613f, -0.01650897f, -0.04146338f, -0.31296846f, 0.04872940f, 0.25392824f, 
    -0.11800967f, 0.01866712f, -0.02377563f, -0.11038258f, -0.03849896f, -0.12869987f, 0.05566744f, -0.03593975f, 
    0.07251312f, 0.09338713f, -0.05234607f, -0.00469046f, -0.08328472f, -0.02283332f, -0.00816823f, -0.04465370f, 
    0.09842829f, -0.00887857f, 0.13984780f, 0.14247732f, 0.16772299f, -0.09250134f, 0.04083434f, -0.06996156f, 
    -0.05816639f, 0.02415497f, 0.11194234f, 0.13052563f, 0.04939532f, 0.03222450f, 0.06236607f, -0.09195186f, 
    -0.00761557f, 0.50005817f, -0.15304030f, -0.02317794f, 0.04216511f, -0.06203857f, -0.08774853f, 0.06607646f, 
    0.01914092f, 0.02036543f, 0.03307131f, -0.08852283f, 0.12109140f, -0.12763461f, 0.13952817f, 0.23903811f, 
    0.00314826f, -0.00412827f, 0.04218853f, 0.06704408f, -0.04377492f, -0.01152012f, -0.06871230f, 0.07597233f, 
    -0.56270802f, 0.06901987f, 0.25271055f, -0.00925657f, 0.06020338f, 0.03160050f, -0.07191636f, 0.02228746f, 
    0.02703030f, -0.05098883f, -0.06657978f, -0.11040668f, 0.29857239f, 0.05762325f, 0.05079183f, 0.13007760f, 
    -0.02005419f, 0.00440903f, -0.00987004f, 0.09574435f, 0.05621685f, 0.05466660f, -0.06443784f, 0.03146258f, 
    -0.13103791f, 0.27158016f, -0.21098088f, 0.03799304f, -0.05266570f, 0.08443455f, -0.01905906f, -0.01171091f, 
    0.02519608f, -0.02487211f, 0.03528823f, -0.00958888f, 0.28300744f, -0.06424526f, 0.04952344f, -0.07816831f, 
    0.13857469f, -0.13654310f, 0.06738840f, 0.02439989f, 0.03346072f, 0.00119795f, -0.09253044f, 0.07729206f, 
    -0.05500459f, -0.06293174f, -0.07198136f, 0.02515869f, -0.06685212f, -0.01178235f, -0.09659096f, 0.01960803f, 
    0.03445784f, -0.05138938f, 0.01559076f, -0.03201370f, -0.27839798f, -0.19514944f, -0.29375833f, -0.05761429f, 
    0.10343774f, 0.21546413f, 0.06223681f, 0.05358889f, -0.03013324f, 0.01257843f, 0.00297860f, -0.04992716f, 
    -0.13746831f, -0.07383176f, 0.05990268f, 0.02834134f, -0.06598330f, -0.00834835f, 0.05820651f, 0.05364211f, 
    -0.01566629f, 0.08060765f, -0.10085802f, -0.04488629f, -0.06717874f, 0.03221361f, 0.06945419f, 0.26998934f, 
    0.09422652f, -0.15697156f, 0.03194300f, 0.12129255f, 0.07939679f, 0.00581327f, 0.16353634f, 0.06906270f, 
    0.06868028f, 0.10824567f, 0.00457772f, -0.09853649f, -0.06358780f, 0.09342493f, 0.04560735f, 0.04272108f, 
    -0.08111083f, 0.11396887f, -0.01493612f, -0.06645018f, 0.22199346f, -0.12530661f, -0.12904476f, 0.12910026f, 
    -0.05937082f, -0.05692450f, -0.04126795f, 0.00818171f, -0.19123420f, -0.00339009f, -0.01458522f, 0.06340295f, 
    -0.05607957f, 0.18087667f, -0.13069539f, 0.19243734f, 0.02898341f, -0.07257941f, -0.17426337f, 0.19974998f, 
    -0.01266717f, 0.03237727f, 0.07198478f, 0.02684031f, 0.10670096f, 0.07650332f, -0.02599788f, -0.06954995f, 
    -0.05696100f, 0.04164642f, 0.03847636f, -0.04357931f, -0.03393926f, -0.02430576f, -0.04547837f, -0.05385125f, 
    0.20005779f, 0.12085471f, 0.08446636f, 0.26969030f, 0.14517450f, 0.01742048f, 0.06758865f, 0.09734701f, 
    -0.00936097f, 0.04429215f, 0.04066430f, 0.03659965f, -0.04099439f, -0.09576775f, 0.05654927f, 0.00971826f, 
    -0.18684271f, 0.11149839f, -0.07308827f, 0.09151662f, -0.00083339f, -0.01260748f, 0.01637639f, 0.08084634f, 
    -0.16187480f, 0.10897445f, 0.08524834f, 0.10857889f, 0.10671812f, 0.12265471f, 0.07921003f, -0.09668373f, 
    0.00327422f, 0.06567451f, 0.02030012f, -0.11023665f, 0.08281293f, -0.14149819f, 0.14329377f, 0.27885771f, 
    -0.08881260f, -0.10969488f, 0.18244044f, 0.11770394f, 0.06379108f, 0.15458935f, 0.12669466f, -0.13320276f, 
    0.28570125f, -0.04534751f, -0.04785035f, 0.13659470f, 0.01247035f, -0.00668943f, -0.05230999f, 0.02989867f, 
    0.13814428f, 0.09365088f, 0.12625031f, -0.01166502f, 0.03682527f, 0.10656292f, -0.03649404f, -0.16043301f, 
    -0.01180161f, 0.01665361f, 0.03520764f, 0.00690259f, -0.01643239f, 0.01178754f, 0.02391511f, -0.04542588f, 
    -0.08710703f, -0.04256425f, -0.08731608f, 0.25949267f, -0.07139176f, -0.02533324f, 0.04506734f, 0.12861232f, 
    0.03373536f, 0.08475161f, 0.06496826f, 0.02127087f, -0.07830220f, 0.31518590f, 0.03024822f, -0.02834655f, 
    0.02585296f, 0.04726952f, -0.05359926f, 0.08076469f, 0.09982969f, 0.08713179f, 0.06736005f, 0.03759536f, 
    -0.04203893f, -0.24990696f, 0.14391698f, -0.13076444f, -0.00764058f, -0.01852547f, 0.01241548f, -0.08292489f, 
    0.08602613f, 0.06544413f, -0.05992309f, -0.03962087f, 0.02662893f, -0.05348723f, -0.08672681f, 0.07228704f, 
    -0.10898698f, 0.03416971f, 0.01901774f, 0.09711070f, 0.02145909f, 0.09804253f, -0.05849836f, -0.04035592f, 
    -0.00183804f, 0.07309759f, -0.27130100f, 0.29656199f, 0.13011123f, 0.03520786f, 0.06950288f, 0.02719824f, 
    0.03885245f, 0.10568015f, 0.03941663f, 0.00196914f, -0.23427837f, -0.16233055f, 0.08682097f, 0.10614572f, 
    -0.06974411f, 0.04263158f, -0.07190610f, -0.09726986f, 0.02068484f, -0.10200590f, -0.02008872f, -0.07194326f, 
    -0.06051837f, 0.32693177f, 0.07493976f, 0.04780483f, 0.15206574f, -0.14149727f, 0.00452129f, 0.16381057f, 
    -0.01318804f, 0.02368617f, -0.00842529f, -0.02414784f, -0.03966850f, 0.00923212f, 0.21091609f, 0.19883353f, 
    -0.07941874f, 0.07948927f, -0.05221747f, 0.00222362f, 0.06429807f, 0.00485196f, -0.13373199f, 0.00825283f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02585518f, 0.01477740f, -0.00111659f, 0.10012604f, -0.02852727f, 0.04006291f, 0.05496914f, -0.02817344f, 
    0.12313833f, -0.01736901f, 0.08888812f, -0.03762197f, 0.02172973f, -0.02342881f, -0.00476702f, 0.02926092f, 
    0.05339211f, -0.02050965f, 0.06981770f, -0.04135842f, 0.01964016f, 0.06934854f, 0.01196131f, 0.11841641f, 
    -0.01459976f, -0.03118331f, -0.01850673f, -0.01364603f, 0.03003901f, -0.00810899f, 0.01778602f, -0.01798689f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.13410409f, 0.05956928f, 0.11958554f, 0.06687918f, -0.09992620f, 0.31002003f, -0.06408405f, 0.17631973f, 
    0.38930628f, 0.05601499f, 0.42421281f, 0.10856353f, 0.15831576f, 0.03870783f, -0.34811664f, 0.15662917f, 
    0.17765915f, 0.16638507f, 0.03707198f, -0.25338870f, -0.10381185f, -0.04849710f, -0.25604290f, 0.14527394f, 
    0.02544934f, -0.01308482f, -0.23592025f, -0.34633705f, -0.03029944f, -0.14412953f, 0.06288200f, -0.27153373f, 
    0.05133228f, 0.13622616f, -0.06468760f, 0.06643946f, -0.06667884f, 0.19672135f, 0.17836882f, 0.14131847f, 
    -0.06058977f, -0.12739618f, 0.23134665f, -0.05328641f, -0.09188477f, 0.15611334f, -0.11399819f, 0.06604513f, 
    0.00572614f, -0.00443164f, 0.17431933f, -0.15939112f, -0.06283188f, -0.36325499f, -0.05474786f, -0.28275403f, 
    0.07392418f, -0.12986796f, 0.31569421f, -0.21736920f, 0.23283868f, -0.14248700f, -0.05056844f, 0.07085062f, 
    0.02921479f, -0.02268505f, -0.35878175f, 0.28142616f, -0.05109376f, 0.05691907f, -0.03652512f, -0.16305326f, 
    -0.13072042f, -0.05634304f, -0.25556985f, -0.10280999f, -0.21050455f, -0.11719051f, 0.27371460f, 0.04359990f, 
    0.04996722f, -0.15533555f, 0.06044213f, 0.00601872f, -0.10062278f, -0.24769147f, 0.08577465f, 0.00421884f, 
    -0.15973108f, 0.12393206f, 0.20317680f, 0.09751263f, 0.16249022f, 0.15740088f, -0.05038872f, 0.38957083f, 
    0.08764273f, -0.05872696f, -0.29680496f, 0.12286569f, -0.14280908f, -0.06864344f, -0.27849033f, -0.14318150f, 
    0.27721712f, -0.09779255f, 0.34572190f, -0.12418779f, 0.22989723f, 0.07009290f, 0.13061440f, -0.12005186f, 
    -0.35209960f, 0.00399674f, -0.19528288f, 0.68949342f, -0.10577649f, 0.32712349f, -0.12125814f, 0.23998895f, 
    -0.05012781f, -0.15307485f, -0.21262851f, 0.18995604f, 0.00003987f, -0.05053247f, 0.00620465f, -0.32298714f, 
    -0.05292314f, 0.04495560f, -0.15700850f, 0.02702932f, 0.17085591f, 0.07948796f, 0.03486918f, 0.03865993f, 
    0.03769361f, 0.15846840f, -0.05533320f, 0.12818654f, 0.07513989f, 0.01000895f, -0.06865216f, -0.16693215f, 
    -0.13299786f, -0.15259717f, -0.13321722f, -0.13065916f, -0.12069289f, -0.17660575f, 0.01826050f, -0.16495183f, 
    -0.15350261f, 0.02827375f, -0.05733012f, -0.00094409f, -0.16828410f, 0.00594888f, 0.15378192f, -0.03462148f, 
    0.02942411f, -0.11544896f, -0.36469331f, -0.09466446f, 0.03962116f, 0.01184921f, 0.43961695f, -0.13944504f, 
    0.44460937f, -0.10842540f, 0.08491863f, 0.09853581f, 0.37667853f, 0.09501039f, 0.30115175f, 0.02919813f, 
    0.01390137f, 0.09202361f, 0.25555411f, 0.42799482f, -0.16779962f, 0.19746250f, -0.13102710f, 0.01163182f, 
    0.15698107f, 0.16067475f, 0.25480357f, -0.10299793f, -0.14491870f, 0.10258973f, -0.07216345f, -0.21296656f, 
    0.02415203f, 0.12579434f, -0.16800275f, 0.30425486f, -0.07042743f, 0.02815517f, -0.18857202f, -0.15865912f, 
    -0.34846663f, -0.15594581f, 0.36076671f, 0.02181970f, -0.32270491f, 0.00440244f, -0.02201052f, 0.07199906f, 
    0.20389260f, -0.07754532f, 0.41906667f, 0.10695111f, -0.01278879f, -0.13729718f, 0.23439676f, 0.13368493f, 
    -0.10199028f, -0.08278468f, 0.08129080f, -0.36130366f, 0.28182530f, -0.14443423f, -0.16587767f, -0.15767628f, 
    0.11071980f, 0.09623072f, 0.22855629f, -0.11113138f, 0.15518832f, 0.29042685f, 0.76603121f, 0.15168154f, 
    0.46523592f, -0.10186201f, -0.44779009f, -0.09022388f, 0.02855185f, -0.08240387f, 0.29319432f, -0.15389834f, 
    -0.13916202f, 0.07442094f, 0.48270169f, -0.43993902f, -0.00680077f, 0.09233335f, -0.00717967f, 0.22211917f, 
    -0.15529938f, 0.12283447f, 0.14932655f, -0.10771740f, 0.06537899f, -0.02311776f, 0.02036779f, -0.19340147f, 
    0.02161354f, 0.06709226f, -0.33575711f, 0.09132296f, 0.00690829f, -0.33358860f, 0.34594756f, -0.04940685f, 
    0.09153192f, 0.04423824f, 0.22509162f, 0.04911981f, 0.26803389f, 0.08368689f, 0.03227361f, -0.00608903f, 
    -0.44663036f, 0.17066143f, -0.13268107f, 0.30756253f, 0.07617682f, -0.40790904f, 0.38172486f, -0.11292690f, 
    0.12475412f, 0.01732880f, 0.10648135f, 0.26961762f, -0.10085534f, -0.14277458f, -0.07043986f, 0.13425362f, 
    0.05961700f, 0.11798706f, -0.14386040f, 0.19116358f, -0.02088805f, 0.54098940f, -0.28346530f, 0.12581372f, 
    -0.17318261f, -0.13516089f, 0.25478432f, 0.11139286f, 0.23967421f, 0.03891392f, 0.43450838f, -0.10485068f, 
    -0.09589583f, 0.07981417f, 0.25948456f, 0.33753279f, -0.05750363f, 0.13763557f, -0.13092309f, 0.09271406f, 
    0.07781553f, 0.01668528f, -0.00847907f, -0.17619549f, -0.17837468f, 0.00198998f, 0.12704398f, 0.02832025f, 
    -0.11269044f, -0.09185636f, 0.32058537f, -0.08368763f, -0.00361436f, 0.05699777f, 0.64381474f, 0.00012796f, 
    -0.03056986f, 0.17651936f, -0.12555923f, -0.15238290f, 0.18998887f, -0.15434749f, 0.06037402f, 0.12123118f, 
    0.01753028f, 0.00363533f, 0.40246287f, -0.34579003f, -0.13206698f, -0.10205134f, 0.13823961f, -0.15075323f, 
    0.13263495f, -0.00622100f, 0.28616247f, 0.26382625f, -0.04218881f, -0.15520768f, -0.05494544f, 0.08653501f, 
    -0.12977313f, -0.11600620f, 0.46271309f, 0.32454494f, -0.03528574f, -0.13023378f, -0.29944730f, -0.04907313f, 
    -0.12571952f, 0.04158484f, -0.02376148f, -0.14147165f, -0.01947412f, 0.01941711f, -0.26572821f, -0.05401279f, 
    0.30977255f, 0.06205120f, 0.33205399f, 0.20746985f, 0.11485704f, 0.26359048f, 0.35978487f, -0.01207157f, 
    -0.07246742f, -0.05078937f, -0.32630908f, 0.07057550f, 0.08956683f, -0.11079918f, 0.08846548f, -0.20888656f, 
    0.10110821f, -0.13719450f, 0.03318511f, 0.21842681f, -0.04157096f, -0.23427892f, -0.17344582f, -0.16141967f, 
    0.19317193f, 0.10306194f, -0.26044959f, 0.02651077f, 0.40061346f, 0.00203306f, 0.12207728f, 0.10527861f, 
    0.14445026f, -0.02073115f, -0.58809590f, -0.17007755f, 0.10495704f, 0.27261853f, 0.16434179f, -0.09314176f, 
    -0.02229204f, -0.14812016f, 0.05972401f, -0.10101032f, 0.25527146f, 0.12585720f, -0.06571840f, 0.38921857f, 
    0.13739547f, -0.02037463f, 0.26089108f, 0.21197180f, 0.08353516f, -0.22648324f, -0.18690243f, 0.02069305f, 
    0.19605999f, 0.01940497f, -0.02519747f, -0.13527133f, 0.14018379f, -0.13700415f, -0.14624259f, 0.11692423f, 
    -0.18372558f, 0.12057682f, -0.34528098f, 0.04272272f, 0.02913038f, -0.46967173f, 0.04467889f, -0.02084632f, 
    0.05628395f, -0.13339709f, -0.36133793f, 0.52267653f, 0.31021199f, 0.00319302f, -0.12450250f, 0.11970551f, 
    -0.03988601f, -0.07977953f, -0.29617849f, 0.19119178f, 0.15156052f, 0.07706714f, 0.14470965f, -0.05400059f, 
    0.44843125f, 0.13399339f, -0.04714515f, -0.04642306f, 0.11946595f, -0.14001377f, -0.17990291f, -0.16344510f, 
    0.32803670f, 0.08946256f, 0.04050054f, -0.29730800f, -0.01945758f, 0.60143507f, -0.07027150f, 0.42633143f, 
    0.15851417f, -0.06313565f, -0.12723111f, -0.24226610f, -0.12680185f, 0.14403801f, 0.11650749f, -0.01828948f, 
    -0.12300774f, -0.01259887f, -0.05178278f, 0.02565015f, 0.03819826f, 0.15754470f, 0.03620740f, 0.00235979f, 
    -0.17488411f, 0.03929141f, -0.08378622f, -0.14726987f, -0.00322438f, -0.05773134f, -0.02572199f, -0.17109017f, 
    -0.12512496f, -0.06455275f, 0.14230244f, -0.15283550f, -0.10327069f, 0.04105646f, -0.19275533f, -0.06899486f, 
    0.16455016f, 0.14752500f, 0.03841958f, -0.03583599f, -0.01088031f, -0.08922449f, -0.05621363f, -0.18708082f, 
    0.16786799f, -0.12243857f, 0.01085128f, -0.12067662f, 0.05108272f, -0.02040639f, -0.07984594f, -0.07102983f, 
    0.09257707f, -0.13160835f, -0.08004460f, 0.14722654f, -0.10678329f, 0.00211836f, -0.12526144f, -0.08984903f, 
    -0.15687639f, -0.02853620f, -0.01079570f, -0.06051196f, -0.14734127f, 0.12714770f, -0.05446079f, 0.09868010f, 
    -0.15986960f, 0.17430831f, -0.13189188f, -0.02132972f, -0.15178485f, 0.16515051f, -0.10945564f, 0.03203201f, 
    0.12045948f, 0.02763673f, -0.15178797f, 0.05769344f, 0.14765726f, 0.18399468f, 0.15402567f, -0.00081469f, 
    -0.07838185f, 0.10637926f, 0.12442973f, 0.00288828f, -0.04569967f, 0.02647517f, 0.14630483f, -0.16223112f, 
    0.00177273f, 0.08993544f, -0.14099862f, -0.08135678f, -0.03015904f, 0.04757209f, -0.19887018f, 0.00955433f, 
    -0.06095332f, -0.04138614f, 0.07476235f, 0.19998248f, -0.07905108f, 0.09623671f, 0.14345275f, -0.10211345f, 
    0.13316391f, -0.07231136f, 0.08912340f, -0.19914550f, 0.11597127f, 0.23453821f, 0.21358329f, 0.05842149f, 
    -0.16133255f, 0.16084966f, 0.06176250f, 0.14432064f, 0.37650803f, 0.17106935f, 0.03496888f, -0.06090929f, 
    -0.24425544f, 0.15104419f, -0.23904726f, -0.40366772f, 0.17494752f, -0.25644234f, -0.19387570f, 0.29094708f, 
    -0.17886712f, -0.03011203f, 0.15511170f, 0.23186105f, -0.12829633f, 0.09650635f, 0.15507385f, 0.29625991f, 
    0.08015795f, -0.02062304f, -0.14963523f, -0.07463339f, -0.16149440f, 0.03432290f, -0.16405331f, 0.13555452f, 
    -0.20128757f, -0.14082366f, -0.08485424f, -0.13270374f, 0.04042876f, -0.14055955f, 0.05081509f, 0.11211496f, 
    0.03579598f, -0.12317839f, -0.07257277f, 0.02069485f, -0.02061691f, -0.04722464f, 0.11704990f, -0.14949848f, 
    -0.15896003f, -0.03795161f, -0.11983533f, 0.13649063f, 0.01776137f, -0.10268164f, -0.00059254f, -0.02003384f, 
    0.08758869f, 0.13493606f, -0.14640649f, 0.01017347f, -0.04174725f, -0.05034874f, 0.14375907f, -0.13751809f, 
    0.01730492f, -0.13067369f, 0.02757392f, -0.12972148f, -0.12768511f, -0.05673791f, -0.19767313f, -0.04134056f, 
    -0.14103726f, 0.12608409f, 0.13901430f, -0.01500743f, 0.05187830f, 0.00045544f, -0.19388747f, 0.09763111f, 
    0.12577896f, -0.11944773f, -0.11497289f, -0.11180645f, -0.02024247f, -0.13219476f, 0.17957883f, 0.08481754f, 
    -0.17074078f, -0.00054344f, -0.19955541f, 0.10922904f, -0.09607540f, 0.02193163f, 0.11975504f, 0.09339398f, 
    -0.09210133f, -0.07063553f, -0.36360195f, -0.07787098f, -0.02550539f, -0.08074375f, 0.49146798f, 0.02745942f, 
    -0.23203555f, 0.04383316f, -0.17577441f, -0.07160389f, -0.10519373f, -0.11952763f, 0.13733809f, 0.37456855f, 
    0.04935469f, 0.02197381f, 0.36627528f, -0.25729007f, 0.20506062f, 0.05477834f, -0.03210089f, 0.20658451f, 
    -0.08539091f, 0.06129289f, 0.11173926f, 0.12633325f, 0.06020453f, -0.19098336f, 0.04665713f, -0.08102268f, 
    -0.04758074f, -0.14777786f, 0.09465764f, -0.14122517f, 0.01697957f, 0.13456582f, -0.16692255f, -0.03988818f, 
    0.01428857f, -0.03654842f, -0.04667468f, 0.05444420f, 0.06771482f, -0.06365648f, -0.11659905f, -0.10978582f, 
    -0.00306310f, -0.13250788f, 0.03961119f, 0.06963588f, -0.13466685f, 0.07874535f, -0.06886774f, -0.01821827f, 
    -0.11043764f, 0.07174188f, 0.06198131f, -0.13637160f, 0.07739776f, 0.00241742f, -0.01193150f, 0.11914238f, 
    -0.17673537f, 0.00127166f, -0.09536980f, -0.15645960f, 0.11424560f, 0.13885868f, -0.00203396f, 0.07663020f, 
    0.12529089f, -0.14799033f, -0.10277239f, 0.00191568f, -0.02290203f, -0.05157080f, -0.11157058f, 0.03933142f, 
    -0.05180932f, 0.03002467f, -0.03180072f, -0.10873438f, 0.03994969f, 0.09344336f, 0.06732736f, -0.14494494f, 
    -0.12671834f, -0.17619202f, -0.21463312f, -0.20192207f, -0.11920366f, 0.46451589f, 0.07709453f, 0.11695603f, 
    0.11823552f, -0.06292982f, 0.25149623f, -0.14758627f, 0.23417282f, 0.09161089f, -0.02445073f, -0.04418642f, 
    -0.07347097f, -0.03569653f, 0.16670145f, -0.17638820f, -0.00368366f, -0.25523874f, -0.07815550f, 0.06323491f, 
    0.15984674f, 0.05546768f, 0.13704066f, 0.16330226f, -0.19806571f, -0.00841088f, -0.11712018f, 0.40845275f, 
    -0.04422186f, 0.01211513f, -0.13756649f, -0.00300695f, -0.13826974f, 0.06770249f, 0.09640081f, 0.00812096f, 
    0.09081049f, -0.02859071f, -0.17598779f, -0.12990402f, -0.15266569f, 0.13863091f, -0.00544741f, -0.14274240f, 
    -0.16050851f, 0.03826072f, -0.05541163f, -0.07252880f, -0.08155299f, -0.06633505f, -0.18352373f, -0.14138649f, 
    -0.06882597f, -0.12841414f, -0.17598447f, 0.06600922f, -0.10998170f, -0.01270040f, -0.15384874f, 0.07326972f, 
    0.00583016f, 0.12292644f, 0.31890440f, -0.27898657f, -0.02761310f, 0.18761751f, -0.15532462f, -0.13122289f, 
    -0.34713617f, -0.06903155f, 0.55195737f, 0.07248818f, -0.16775158f, -0.00928344f, -0.26426232f, 0.10073616f, 
    0.38731503f, -0.08630314f, -0.18952057f, -0.04011457f, -0.02804019f, 0.00350524f, 0.43078119f, 0.21990038f, 
    -0.11977338f, -0.08400097f, 0.49489230f, -0.23198250f, 0.21206698f, -0.15988171f, -0.16934435f, 0.31663686f, 
    0.00936251f, -0.07200709f, 0.14885531f, -0.18854187f, 0.07520908f, -0.01088805f, -0.15913674f, -0.09138578f, 
    -0.22081766f, 0.09765077f, 0.32443634f, -0.13046534f, -0.13436674f, -0.12747613f, 0.27356556f, -0.01740301f, 
    -0.02662874f, 0.06751642f, -0.11389606f, 0.17600225f, 0.05752129f, 0.54554170f, -0.11305386f, 0.49044687f, 
    0.10247266f, -0.03373560f, -0.08154006f, -0.00290468f, 0.11897456f, -0.00516915f, 0.02909564f, -0.10816253f, 
    -0.15553135f, -0.15191180f, 0.38684952f, -0.11530428f, -0.04747238f, -0.07325834f, 0.30892357f, 0.09533875f, 
    -0.08714228f, 0.04318366f, -0.23475006f, 0.15310158f, 0.31617221f, -0.08393964f, -0.05493840f, 0.04502237f, 
    -0.20945978f, 0.07069543f, 0.19502401f, -0.10497621f, -0.10153311f, 0.09833468f, 0.32014620f, -0.11837614f, 
    -0.08688323f, -0.02351931f, 0.12430491f, 0.50626343f, 0.04795332f, 0.12437957f, -0.05662519f, 0.04619089f, 
    0.15601932f, 0.00554990f, 0.39480832f, 0.04468305f, 0.13131551f, 0.30469519f, -0.06120474f, -0.13781098f, 
    -0.08172254f, 0.01560978f, -0.22389537f, -0.15435228f, 0.16444893f, 0.06466372f, 0.07538891f, -0.15297464f, 
    -0.20807187f, 0.10993740f, 0.50328428f, 0.11706549f, -0.05480057f, -0.23301038f, -0.26242578f, 0.16149080f, 
    -0.06161484f, -0.02060269f, -0.27808627f, 0.56969482f, -0.14643385f, -0.11991532f, -0.12375648f, 0.16871808f, 
    0.09218778f, 0.13190222f, 0.29615033f, 0.27356392f, -0.07388629f, -0.22339107f, -0.28787804f, 0.09900978f, 
    -0.07984932f, -0.13451341f, 0.46192330f, -0.16485007f, -0.26981699f, 0.15464956f, -0.46808749f, -0.04696615f, 
    0.25658107f, 0.07232028f, 0.16619766f, -0.13027219f, -0.14304626f, -0.24541397f, 0.04668272f, -0.05650833f, 
    0.10520984f, -0.00850102f, -0.19043106f, 0.28154302f, 0.35652411f, 0.14330237f, -0.14344557f, 0.04851418f, 
    0.17114019f, -0.05119091f, 0.03226609f, 0.11372823f, -0.14644426f, -0.12841654f, 0.03119866f, -0.11294433f, 
    0.08787210f, -0.12244795f, -0.06073875f, 0.06767930f, -0.18762618f, -0.00541024f, -0.09630744f, -0.06053418f, 
    0.04847128f, 0.00116418f, 0.13322507f, -0.09569671f, -0.14164618f, -0.14269274f, -0.09092884f, 0.09445470f, 
    0.09188948f, 0.12082207f, -0.07354457f, -0.14659017f, -0.18956375f, 0.01328416f, 0.11859832f, -0.16235641f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.27029130f, 0.14985141f, 0.16903353f, -0.08776769f, -0.14137526f, -0.04952221f, 0.17978129f, 0.20947701f, 
    -0.17105533f, 0.19577868f, -0.17878240f, 0.08114744f, 0.11051684f, 0.16264807f, 0.20569634f, -0.13246831f, 
    -0.04997870f, -0.02164665f, -0.11826911f, 0.07261839f, 0.08577789f, -0.00998814f, -0.11864815f, -0.07883175f, 
    0.23849416f, 0.03526048f, 0.10775894f, 0.10569261f, -0.13035674f, 0.19462395f, 0.11182848f, -0.05531240f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.49711359f, 0.32072017f, -0.07751768f, -0.34427816f, -0.00188348f, -0.16857551f, 0.03507552f, 0.04064164f, 
    0.41842940f, -0.71214044f, 0.30008802f, -0.03019591f, 0.06917074f, 0.20358936f, -0.51136798f, 0.10268144f, 
    0.08799297f, -0.03947893f, -0.18268085f, 0.07038075f, 0.03635126f, 0.14408508f, -0.06338440f, 0.01788196f, 
    -0.76133227f, -0.08332176f, 0.15830338f, -0.13062574f, 0.28946024f, -0.49182767f, 0.19327819f, -0.13777891f, 
    0.01704865f, 0.24185809f, 0.33340827f, -0.27083147f, 0.05812885f, -0.69215882f, 0.23388113f, -0.29848537f, 
    -0.74809521f, -0.08219590f, -0.15010346f, 0.29340288f, 0.26023400f, 0.15060635f, 0.01345054f, 0.14801960f, 
    0.01314914f, -0.11460604f, -0.09330773f, -0.08137827f, 0.14681688f, 0.00520906f, -0.03749928f, 0.03539420f, 
    0.04995904f, -0.07359022f, -0.06024690f, -0.05438808f, -0.24673519f, -0.27314204f, 0.30040026f, -0.09903594f, 
    -0.29139045f, -0.46797857f, 0.08607727f, 0.29455143f, -0.14817606f, 0.05353980f, 0.14340618f, -0.37481824f, 
    0.14796901f, 0.38137892f, -0.66742951f, -0.06686872f, 0.09359948f, -0.01991364f, -0.28396803f, -0.14461714f, 
    0.04272534f, 0.02106889f, -0.36046463f, 0.10837732f, 0.04107190f, 0.39346659f, 0.11431908f, -0.09372931f, 
    -0.25182053f, -0.07524365f, 0.16727619f, 0.27730486f, -0.43521792f, -0.45872599f, -0.22730300f, -0.08537236f, 
    0.05929891f, 0.16580726f, 0.21493773f, -0.84961689f, -0.09145145f, 0.25381824f, -0.05705994f, 0.25954401f, 
    0.24175979f, 0.04465733f, 0.26139435f, -0.36951330f, -0.06505931f, -0.65283990f, 0.11301547f, -0.14344378f, 
    0.07192117f, -0.10677946f, -0.13423316f, -0.12671600f, 0.09684851f, 0.06557968f, 0.05956344f, -0.11026814f, 
    0.22272933f, 0.13967873f, 0.04834575f, -0.70626229f, -0.05067957f, -0.24498507f, -0.32309529f, 0.08211318f, 
    -0.34552050f, -0.64841956f, -0.07024744f, -0.31699604f, -0.11215767f, -0.17431642f, -0.50172287f, 0.07898104f, 
    0.00350022f, -0.30911008f, 0.17595115f, -0.05339250f, 0.21425083f, 0.11027267f, 0.10499229f, 0.11760570f, 
    0.11771366f, -0.09879413f, 0.43359950f, 0.08495231f, 0.02344988f, 0.21806483f, -0.02515727f, -0.06649528f, 
    0.15495421f, -0.04283320f, -0.03259911f, 0.10889992f, 0.28934604f, 0.04334090f, -0.17600340f, -0.01290770f, 
    0.31085277f, -0.00448692f, -0.47053793f, -0.03843062f, -0.00922689f, -0.13362704f, -0.16287892f, 0.14406975f, 
    -0.30779442f, -0.13489813f, -0.03215499f, 0.30200687f, -0.16048999f, 0.35852644f, -0.07885826f, -0.09917683f, 
    0.13425551f, 0.13467194f, -0.61602783f, 0.07642482f, -0.08617194f, -0.55539101f, -0.13261886f, -0.09355892f, 
    -0.25598603f, 0.10690122f, -0.31363630f, -0.17353182f, 0.15379508f, 0.41346648f, 0.30342942f, 0.15454403f, 
    0.22943564f, -0.05459867f, -0.72295392f, 0.36520144f, 0.17200232f, 0.41663963f, -0.41373026f, 0.15925609f, 
    -0.20027722f, 0.00407552f, -0.08259645f, 0.04792321f, 0.26532134f, -0.12158993f, 0.29325104f, 0.14639680f, 
    0.06752291f, 0.04241312f, -0.56203735f, 0.10335110f, 0.05711566f, -0.21682169f, 0.09925204f, -0.04470447f, 
    -0.45122561f, 0.07806608f, -0.46422589f, 0.10774837f, 0.06041978f, -0.39001811f, -0.39653865f, 0.08535046f, 
    -0.20228292f, -0.08124340f, -0.09693220f, -0.24343474f, -0.01190870f, 0.00934060f, -0.37701374f, -0.04353021f, 
    -0.05566547f, 0.28719151f, 0.25399175f, -0.15002103f, -0.54676634f, -0.31938154f, -0.58306700f, -0.11770025f, 
    -0.00704877f, 0.09165147f, 0.39223817f, -0.01425710f, 0.05392008f, -0.15929517f, -0.05693570f, -0.14128743f, 
    0.25810915f, -0.01917264f, -0.11852007f, 0.04520777f, 0.20597973f, 0.44094229f, -0.27709472f, 0.04923265f, 
    -0.05095552f, -0.22071490f, -0.35282883f, 0.14123397f, 0.17305449f, -0.07979055f, 0.25596842f, -0.42683181f, 
    -0.11373772f, -0.04995691f, -0.13985522f, 0.29297796f, -0.53888071f, -0.45137185f, 0.04569352f, 0.03218816f, 
    -0.09829572f, -0.16821252f, -0.34958962f, -0.13572246f, 0.14749634f, -0.63731170f, -0.04872138f, -0.04283373f, 
    -0.22294025f, 0.03935845f, 0.42076695f, 0.40969792f, -0.05943342f, -0.12997267f, 0.25259495f, -0.11704944f, 
    -0.35358512f, -0.37163940f, 0.31446192f, 0.26782459f, 0.13620426f, 0.25469708f, -0.17019221f, -0.21534289f, 
    0.63569432f, 0.01253247f, -0.14083478f, -0.19593777f, 0.05780344f, 0.35117105f, -0.07379710f, -0.01299404f, 
    -0.05699114f, 0.02298800f, -0.26233840f, -0.06952274f, 0.08289803f, -0.00484175f, -0.12599711f, 0.00694077f, 
    0.10685267f, -0.11882537f, -0.69527549f, -0.34408778f, -0.05298166f, -0.04710337f, -0.00823975f, 0.07735251f, 
    0.54575634f, 0.15000257f, -0.16669072f, -0.07294220f, -0.05277213f, 0.10494085f, -0.02673764f, 0.02816710f, 
    -0.40716171f, -0.00053183f, -0.19461574f, -0.52614307f, -0.14235534f, -0.03447706f, 0.26353267f, 0.11676949f, 
    -0.00777989f, 0.06297662f, 0.29850045f, -0.09764760f, -0.13384573f, 0.13681073f, -0.16331740f, 0.15788420f, 
    0.17942455f, 0.09804162f, 0.09366775f, 0.23815699f, -0.73157358f, -0.29855582f, 0.05085352f, -0.13971151f, 
    -0.18727845f, -0.21403511f, 0.16872847f, -0.01510425f, 0.09724167f, 0.23005816f, 0.08960451f, 0.41892695f, 
    -0.47308394f, 0.08706185f, 0.09983188f, -0.00542300f, -0.36380798f, -0.35578069f, 0.12672994f, 0.13674150f, 
    0.17454909f, -0.11006676f, -0.57601815f, -0.12927644f, -0.04331468f, 0.40261126f, 0.02598306f, -0.02319787f, 
    -0.30274269f, 0.05757039f, -0.51341259f, 0.19512054f, -0.02847605f, 0.14713255f, -0.28912422f, 0.05447972f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.15622875f, 0.00693989f, -0.19971497f, -0.07670769f, -0.05644852f, -0.07229298f, 0.00472262f, -0.29127327f, 
    -0.11549442f, -0.03984667f, 0.20013012f, -0.13846053f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
