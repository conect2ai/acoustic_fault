#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.27199107f, -0.44942299f, -0.69666153f, -0.39710271f, -0.40398955f, -0.52641338f, -0.34546405f, 0.13963935f, 
    -0.02798976f, -0.56297362f, 0.36682427f, 0.34140900f, 0.04405067f, -0.35028619f, 0.14803107f, 0.26360953f, 
    0.07254474f, 0.09583041f, 0.16375305f, 0.03959816f, -0.13197179f, 0.02313138f, -0.13747413f, -0.00173310f, 
    0.00372039f, -0.34747753f, -0.09816843f, -0.48976961f, -0.18563789f, -0.38133180f, 0.01617558f, -0.51295745f, 
    -0.21897076f, 0.41267237f, -0.32734677f, 0.47045255f, 0.33151722f, 0.34029108f, 0.27097651f, 0.16975296f, 
    0.01764631f, 0.12183250f, -0.00028620f, -0.07658751f, 0.08889387f, -0.09939929f, 0.23705870f, -0.12846360f, 
    -0.14839970f, -0.02703298f, -0.46289060f, 0.25961101f, 0.13956252f, 0.39981741f, -0.22881112f, -0.52789909f, 
    -0.59964013f, -0.23733859f, 0.27157384f, 0.56473660f, 0.00972023f, -0.22199607f, 0.24001589f, 0.21591419f, 
    0.07029989f, -0.20072138f, 0.05228053f, 0.17983685f, -0.46642515f, 0.06782286f, 0.23642865f, 0.06245866f, 
    0.03499986f, -0.10485535f, -0.15352058f, 0.32774714f, 0.06944582f, -0.40960547f, -0.57678401f, 0.09460881f, 
    -0.03766213f, -0.20368919f, 0.39280394f, 0.01943364f, -0.13137132f, -0.19867350f, 0.13101868f, 0.15985107f, 
    0.13349557f, -0.05605955f, 0.05024321f, 0.02269148f, -0.03786739f, -0.25944772f, 0.09103661f, 0.27742031f, 
    -0.29339033f, -0.04090885f, 0.30676392f, -0.01249699f, 0.56928468f, -0.51843649f, -0.04595709f, -0.12244986f, 
    -0.44267586f, 0.05000180f, 0.05887132f, 0.04529141f, 0.28930673f, 0.22836965f, -0.29827967f, 0.31033108f, 
    0.21224312f, 0.01824572f, -0.24860819f, 0.07489166f, 0.09365903f, -0.11901522f, -0.04248749f, -0.27844179f, 
    -0.17201142f, -0.00629830f, 0.09698594f, 0.13461629f, 0.21166028f, -0.87178749f, -0.61724585f, -0.30213863f, 
    -0.76937127f, -0.60509652f, 0.50539428f, 0.08674520f, -0.53799969f, -0.42081162f, 0.03450079f, -0.29290837f, 
    -0.16453861f, -0.00398034f, 0.10153095f, -0.29230067f, -0.11668149f, -0.32010251f, -0.24189919f, -0.12331253f, 
    -0.16834669f, -0.24219559f, 0.13703281f, 0.03659184f, -0.05427172f, -0.02231503f, -0.89641064f, -0.29890850f, 
    0.33071658f, 0.15575816f, 0.37019369f, -0.00732638f, 0.26483801f, 0.12404104f, -0.10596246f, -0.23291001f, 
    -0.15796869f, 0.05944832f, 0.06779917f, -0.22145537f, -0.32586044f, 0.21860260f, -0.07222916f, -0.27827391f, 
    -0.06105560f, 0.21883291f, -0.26227382f, -0.21794230f, -0.31666738f, -0.21919534f, -0.29273281f, 1.54483116f, 
    -0.64497536f, -0.88687873f, -0.43412420f, -0.77844632f, 0.73214465f, 0.27238774f, 0.02653887f, 0.19307730f, 
    -0.11264322f, 0.11508524f, 0.01203075f, 0.10643614f, -0.05833595f, -0.02958286f, 0.16447344f, -0.14881948f, 
    0.05506220f, -0.00044713f, -0.34742016f, -0.12024537f, 0.02758196f, -0.03498124f, -0.15658216f, -0.23617916f, 
    -0.00892017f, -0.64298224f, -0.21807671f, -0.24549405f, -0.10836369f, -0.53422427f, -0.63083816f, 0.03861391f, 
    -0.16641848f, -0.03184145f, 0.12681904f, 0.61659396f, 0.15739976f, 0.29799008f, 0.24864298f, -0.11287773f, 
    -0.14320672f, -0.57795662f, -0.28566179f, 0.02176403f, 0.30958322f, 0.26318812f, 0.03818703f, -0.37318033f, 
    -0.30064034f, -0.95832026f, -0.13319114f, -0.47624657f, -0.34100932f, 0.10171443f, 0.01233821f, 0.25340024f, 
    0.06768128f, 0.50921589f, 0.48913920f, 0.23757325f, -0.05941330f, 0.17767368f, -0.16543145f, 0.25004700f, 
    0.10519131f, -0.19981989f, -0.05764846f, -0.15264307f, 0.02808973f, -0.11247046f, 0.12482593f, 0.15927143f, 
    0.02720831f, 0.00611380f, 0.16571094f, -0.68658394f, -0.74592894f, -0.52905560f, -0.53241330f, -0.06710120f, 
    0.46016848f, 0.35514450f, 0.13141951f, -0.04066715f, 0.19416764f, 0.12014960f, -0.10075522f, -0.03697138f, 
    -0.01032772f, 0.01251673f, -0.10235268f, 0.06651516f, 0.15833475f, 0.14521377f, -0.07827780f, 0.00462481f, 
    -0.09665420f, -0.20745072f, -0.32747003f, 0.39116013f, 0.31252512f, 0.04307557f, -0.06858037f, -0.22150953f, 
    0.34050423f, -0.22363444f, 0.07486526f, 0.13365699f, 0.03638959f, -0.00167354f, -0.25967675f, -0.28936893f, 
    -0.12870288f, -0.01080388f, 0.07975326f, -0.06407139f, 0.08043335f, -0.16251108f, 0.02080527f, -0.28172287f, 
    -0.22633636f, 0.02827139f, 0.17031905f, 0.15215398f, -0.02171265f, -0.13103342f, 0.27922434f, -0.16128176f, 
    0.24310040f, -0.52111942f, -0.50283474f, -0.23629989f, 0.24265601f, 0.20782727f, 0.06234753f, -0.05412522f, 
    0.19591634f, -0.24027278f, -0.09943744f, -0.05244578f, 0.11340504f, 0.06759122f, -0.11421908f, -0.17579798f, 
    0.10164835f, 0.24202922f, 0.21667184f, 0.09391094f, -0.00012169f, 0.48534182f, 0.87751979f, -0.55561316f, 
    -0.54387420f, -0.43942082f, -0.53602433f, 0.10460715f, 0.13703308f, 0.17568988f, 0.12118876f, 0.05127152f, 
    -0.24502674f, 0.38459650f, 0.29221979f, -0.11840700f, 0.15935476f, -0.17253406f, 0.33504358f, -0.11006080f, 
    -0.25155562f, -0.07604408f, 0.05061452f, -0.17983338f, -0.10693540f, 0.08713474f, 0.69077390f, 0.16399789f, 
    0.05465771f, -0.29675928f, 0.08041250f, -0.07365111f, 0.38280454f, 0.55034530f, -0.42507479f, -0.46029413f, 
    -0.43198368f, -0.09910514f, 0.42688906f, -0.30812809f, -0.13275686f, 0.01355160f, 0.04203715f, -0.26025432f, 
    -0.06087366f, 0.19579570f, -0.16323823f, -0.07383027f, 0.12209297f, 0.13308382f, 0.18735395f, -0.02901747f, 
    0.40942088f, 0.22228120f, -0.08818587f, -0.34376293f, 0.04278469f, 0.21744587f, -0.05889939f, -0.21071976f, 
    0.21527135f, -0.46836168f, 0.41798833f, 0.27891183f, -0.26213580f, 0.01123010f, 0.16610828f, -0.16155784f, 
    -0.07872052f, -0.14635649f, -0.11386191f, 0.24855445f, 0.29067656f, 0.22482598f, -0.29460123f, -0.12993577f, 
    -0.20570825f, 0.17695692f, 0.13739669f, 0.17614903f, -0.09468207f, 0.31320700f, 0.14438853f, 0.29367995f, 
    0.05480427f, 0.07878115f, -0.06922369f, -0.00169604f, 0.01587890f, 0.01031661f, 0.07235432f, -0.17586596f, 
    0.19079190f, 0.17569473f, -0.04482991f, 0.08194900f, 0.16766858f, -0.13836870f, 0.21727790f, 0.09113193f, 
    0.06575090f, -0.86479491f, -0.21861966f, 0.13283959f, -0.61399072f, -0.27104253f, -0.11572894f, 0.39006945f, 
    0.34911326f, 0.46908531f, 0.11463829f, 0.07800239f, -0.09368283f, 0.07278222f, -0.07863580f, 0.07987805f, 
    -0.26814082f, -0.08182342f, -0.19694237f, -0.15123414f, 0.17100629f, -0.15089977f, 0.28400823f, 0.38730091f, 
    0.07416791f, -0.06997837f, -0.66209829f, -0.35374966f, 0.06435134f, 0.36379227f, 0.19839492f, -0.04740119f, 
    0.07197283f, 0.09489693f, 0.42492503f, 0.31728637f, -0.06956118f, 0.13470042f, -0.05533089f, 0.28974429f, 
    -0.22249825f, -0.15888131f, 0.15300852f, 0.09829742f, -0.27703428f, -0.35238367f, -0.22565517f, 0.32276949f, 
    0.24382590f, 0.32651025f, -0.08419899f, -0.85684097f, 0.57100987f, -0.06177672f, -1.03487468f, -0.68531263f, 
    0.02280423f, 0.26580524f, 0.54098105f, 0.40109947f, 0.27692261f, -0.26846015f, 0.04592237f, -0.18654832f, 
    -0.28464133f, 0.10836394f, -0.08051647f, 0.25730085f, -0.14934810f, -0.20113724f, 0.27185950f, -0.04667018f, 
    -0.15192324f, -0.07860242f, -0.04174018f, -0.22947729f, -0.68918920f, 0.57310867f, -0.29470962f, 0.10498232f, 
    -0.35342288f, -0.37120974f, -0.38374081f, 0.29879904f, 0.60159594f, 0.58475250f, -0.07024091f, -0.30357859f, 
    0.05966853f, 0.26967740f, -0.36211443f, 0.08144195f, -0.20687179f, 0.14808841f, 0.29998240f, -0.03266799f, 
    -0.05464206f, 0.02492109f, 0.10528000f, -0.19963166f, -0.13477938f, 0.26195556f, 0.29878208f, 0.35318929f, 
    0.06826654f, -0.58795863f, 0.37968796f, 0.22012803f, -0.37502456f, -0.39466870f, -0.11427893f, 0.11554504f, 
    -0.32813525f, -0.16598804f, -0.11938521f, -0.03796318f, 0.18954310f, 0.30665502f, 0.15736453f, 0.05886925f, 
    0.01173728f, -0.23553011f, -0.21292715f, -0.02418697f, -0.13781488f, -0.06245234f, 0.38734075f, 0.34521326f, 
    -0.05026078f, -0.39235452f, -0.37292805f, 0.31817135f, -0.03539162f, 0.11351287f, -0.03988645f, 0.23820099f, 
    0.11644285f, 0.39058751f, -0.22809033f, -0.11183879f, -0.16863941f, 0.05663362f, -0.29528630f, 0.28091156f, 
    0.09464372f, -0.10305371f, -0.11162952f, 0.19454582f, -0.09630601f, -0.00863945f, 0.19637913f, -0.23713894f, 
    -0.18976894f, -0.51847225f, -0.40924656f, 0.05062517f, -0.55502766f, -0.69866246f, -0.66532183f, -0.71870697f, 
    -0.75700730f, 0.14227134f, 0.36015406f, 0.24234006f, 0.06807332f, 0.21812674f, -0.10038061f, -0.04481393f, 
    -0.25255126f, 0.06641161f, -0.03308392f, -0.16279629f, -0.00565812f, 0.05732816f, -0.01425157f, -0.18658772f, 
    -0.29784423f, -0.61981195f, -0.44274324f, 0.26591349f, 0.61235321f, -0.18429586f, -0.58665454f, -0.32548559f, 
    -0.45274505f, -0.31449890f, -0.08114499f, -0.23294449f, 0.35322672f, -0.17205773f, -0.35454178f, 0.25976056f, 
    -0.29773554f, -0.02463303f, -0.26669252f, 0.12434029f, -0.40389711f, -0.11955295f, -0.00051981f, 0.31560954f, 
    0.24795561f, 0.29175773f, -0.23851660f, -0.29624012f, -0.39289838f, 0.24823947f, -0.04871280f, 0.04748014f, 
    0.13313630f, -0.25440735f, 0.28607520f, -0.16158746f, -0.00005170f, 0.06311772f, 0.00267965f, 0.30420640f, 
    -0.27718434f, 0.03541993f, -0.16893181f, 0.20974922f, -0.25208840f, 0.23293401f, -0.43388176f, 0.14534010f, 
    0.20520559f, 0.26710528f, -0.91950953f, -0.58861589f, 0.19614741f, 0.61702001f, 0.36435908f, 0.39383215f, 
    -0.03326456f, -0.18038827f, 0.01187616f, 0.13746130f, 0.23460241f, 0.21310776f, 0.05081068f, 0.09635626f, 
    -0.18933271f, -0.33634466f, -0.23560031f, -0.15529263f, -0.24093841f, -0.28027987f, -0.35889608f, -0.22029848f, 
    -0.38850588f, -0.09003907f, -0.42698425f, 0.12394639f, -0.10376389f, -0.33035648f, 0.05248539f, -0.43680105f, 
    -0.48419800f, -0.31600931f, -0.14407749f, 0.09685972f, 0.27597076f, 0.10912185f, -0.24873999f, -0.31039622f, 
    -0.09661267f, -0.47921526f, -0.36184871f, -0.44921249f, 0.01843842f, 0.35191306f, -0.06735509f, -0.20830905f, 
    -0.10028490f, 0.06147442f, -0.15632437f, 0.16494158f, -0.75874090f, -0.96302271f, 0.27509844f, 0.19576938f, 
    0.15758164f, 0.28669274f, 0.33069161f, 0.05362409f, -0.08193660f, 0.18707183f, -0.11117899f, -0.41426069f, 
    -0.38495779f, 0.10947174f, 0.40230191f, -0.15919890f, -0.07832175f, -0.29184130f, -0.30043569f, -0.26166818f, 
    -0.06411498f, -0.35062766f, -0.00230088f, 0.19471046f, -0.39990148f, 0.63195634f, 0.31701872f, -0.38687745f, 
    -0.48133352f, -0.68667865f, 0.61364573f, 0.52235800f, -0.41596064f, -0.59405184f, -0.21270311f, 0.00273365f, 
    -0.34231785f, -0.17998871f, -0.09311951f, 0.21336959f, -0.38622031f, -0.29352835f, 0.21295434f, -0.08389594f, 
    -0.06258037f, -0.18950732f, 0.01574105f, -0.08050612f, 0.15767643f, 0.45523384f, 0.62585014f, 0.10391539f, 
    -0.23334755f, 0.42809772f, -0.56437927f, -0.05925354f, 0.34892526f, 0.01570949f, -0.20415616f, -0.22858809f, 
    -0.04876811f, -0.31344450f, -0.18234625f, -0.16414629f, 0.27563110f, -0.16181818f, -0.16280305f, -0.03408960f, 
    0.31881106f, -0.29366457f, -0.42401743f, -0.07625528f, -0.15233982f, -0.39981085f, -0.77146381f, -0.91503620f, 
    -0.59279841f, -0.46557564f, -0.10207649f, -0.08760448f, 0.75667381f, -0.41463682f, -0.07429815f, 0.55469310f, 
    0.25454256f, 0.54675639f, 0.26558802f, -0.11491466f, 0.14521442f, -0.32035115f, -0.33600155f, 0.07731699f, 
    -0.11209537f, -0.04821351f, -0.16067460f, 0.25475931f, 0.27636781f, -0.09545642f, 0.08263838f, -0.04063229f, 
    -0.62436080f, -0.75266850f, -0.70522565f, -0.21095945f, -0.37859106f, 0.35011590f, 0.15692459f, 0.16104190f, 
    0.12718651f, 0.49360752f, 0.07386674f, -0.00352923f, 0.21097925f, -0.09332571f, 0.12242391f, 0.02167579f, 
    0.21083765f, -0.16294171f, 0.00296266f, -0.18122399f, -0.14944106f, -0.23908275f, 0.12025972f, -0.19364163f, 
    0.05411552f, -0.24337411f, -0.29283708f, -0.39626878f, 0.39649326f, 0.01631850f, 0.42848194f, 0.43598324f, 
    0.35307869f, -0.21286789f, -0.21752714f, -0.14603069f, 0.04788201f, 0.07002556f, 0.22297135f, -0.08731733f, 
    0.26441324f, -0.19378999f, 0.03755153f, -0.26240149f, -0.18258420f, -0.06308144f, -0.03667288f, 0.21984592f, 
    0.07247587f, 0.08047102f, 0.65177053f, 0.05721347f, 0.09269173f, 0.06207658f, -0.71519858f, -0.32718366f, 
    0.25850347f, 0.12167690f, 0.05118413f, -0.34975517f, -0.17319959f, -0.25754035f, -0.21771495f, 0.02889680f, 
    0.00114540f, 0.07490492f, 0.29953414f, 0.12588811f, 0.11757574f, -0.25896338f, -0.23659153f, -0.12448861f, 
    -0.25821200f, -0.03195810f, -0.12741001f, 0.20339082f, 0.21021163f, -0.19220607f, 0.20551454f, 0.25478697f, 
    -0.02735116f, -0.25053024f, -0.14869067f, -0.29012233f, 0.25463060f, -0.06768829f, -0.17538632f, 0.18441470f, 
    0.11147722f, 0.26849824f, -0.13887492f, 0.12316925f, 0.07943615f, 0.03550299f, 0.14723346f, 0.20664813f, 
    0.18118769f, 0.06455480f, -0.22436646f, -0.12271407f, 0.36703551f, 0.32468534f, 0.32664555f, -0.23449591f, 
    -0.58772039f, -0.52227199f, 0.27633390f, 0.26650491f, 0.18823390f, -0.20726426f, -0.40035698f, -0.12656125f, 
    -0.30140322f, 0.08047146f, 0.39412564f, 0.60910565f, 0.06627668f, 0.00130421f, -0.13973168f, -0.25514621f, 
    -0.05396882f, -0.03990131f, -0.15111968f, -0.13131712f, -0.03824696f, -0.82978553f, -0.08739646f, -0.49401215f, 
    -0.25268963f, 0.06412174f, -0.15833391f, 0.36793822f, -0.45814207f, -0.71701169f, -0.35257235f, -0.26704612f, 
    -0.38369465f, -0.32223430f, -0.30746093f, -0.05662078f, -0.16823962f, -0.27322263f, -0.28644887f, 0.05255420f, 
    0.18031847f, 0.01623967f, -0.32213509f, 0.09933649f, -0.09890183f, -0.18958199f, -0.80616874f, -0.64599949f, 
    0.44405997f, 0.42004207f, 0.09439681f, 0.56152546f, 0.41726181f, -0.66348481f, -0.23817101f, 0.46045795f, 
    -0.17414159f, 0.36735383f, -0.34878418f, -0.35844654f, -0.11596192f, -0.12225962f, 0.30090836f, 0.08060645f, 
    -0.13341968f, 0.23241267f, -0.02063748f, -0.21523136f, -0.22721642f, 0.27377123f, 0.07874484f, -0.57468545f, 
    -0.36383587f, -0.20448770f, 0.21747363f, 0.42411697f, -0.36071563f, -0.13841403f, 0.17076267f, 0.39151782f, 
    -0.39902836f, -0.16390814f, 0.09503295f, 0.27541909f, 0.35994017f, -0.41956177f, -0.20599532f, 0.00788590f, 
    -0.22303770f, -0.32771987f, -0.01149326f, 0.22941443f, -0.13083126f, 0.23639372f, -0.05964062f, 0.21033181f, 
    0.45382550f, 1.00006378f, 0.56124407f, -0.55863255f, -0.03433410f, -0.52150512f, -0.42250815f, -0.16444084f, 
    0.03262804f, -0.11806523f, -0.14573725f, -0.02446467f, 0.14505285f, -0.11450379f, 0.04424834f, -0.25070634f, 
    0.10121750f, 0.04176306f, 0.24019718f, 0.04526412f, -0.11138855f, 0.15827732f, -0.27049264f, -0.09723208f, 
    0.02986543f, -0.49173683f, -0.65367019f, -0.58959728f, -0.51619166f, -0.11609808f, -0.02356804f, -0.14776792f, 
    0.40116456f, 0.26989007f, 0.04329701f, -0.00028593f, 0.12126584f, -0.08223105f, -0.02154953f, 0.39425716f, 
    -0.21580881f, -0.08072207f, -0.01709412f, -0.24445866f, -0.18849090f, -0.39005935f, 0.15444992f, 0.03866759f, 
    -0.13050529f, -0.21306609f, 0.22938058f, 0.77324605f, 0.17983063f, -0.30032524f, -0.02238921f, -0.52649301f, 
    -0.63366795f, 0.09409536f, -0.24173331f, -0.60198420f, 0.08152486f, 0.21102040f, -0.03723223f, 0.51094472f, 
    -0.05234533f, 0.19175559f, -0.13440470f, -0.20509560f, 0.18907699f, -0.14426810f, -0.18937179f, -0.03493991f, 
    0.18705158f, -0.06481662f, -0.06159352f, -0.61988479f, -0.43216738f, -0.65724981f, -0.45717421f, -0.06574214f, 
    -0.13044253f, 0.07426417f, -0.54880941f, -0.49545979f, -0.79318374f, 0.07367074f, 0.17518447f, 0.13524687f, 
    0.01812062f, -0.15586536f, 0.03010646f, -0.22273156f, 0.05552481f, 0.06214796f, 0.05053929f, 0.18624786f, 
    0.16928594f, 0.27334288f, 0.10100311f, 0.31984764f, 0.20683226f, -0.07441840f, -0.15182303f, -0.36004445f, 
    -0.35959366f, -0.37411556f, -0.49726447f, -0.23844667f, -0.25439444f, -0.15233627f, 0.34450921f, 0.06221442f, 
    0.17682293f, -0.19027102f, -0.38127294f, -0.26651004f, -0.17815633f, -0.29305077f, -0.32929003f, -0.55229509f, 
    0.04106671f, -0.09668950f, -0.01768469f, -0.06211598f, -0.23299815f, 0.26346055f, 0.04452481f, 0.12976547f, 
    0.13980234f, -0.02402436f, -0.61577612f, -0.53578347f, -0.53179729f, -0.68498123f, -0.66213709f, 0.67028862f, 
    -0.17341688f, 0.20278904f, 0.28742763f, 0.02543685f, -0.17625198f, 0.24341065f, -0.21291634f, -0.15725173f, 
    -0.41594610f, -0.30493176f, 0.01127530f, 0.10156838f, 0.31316346f, -0.25682506f, -0.55719662f, -0.62644994f, 
    -0.09565391f, 0.35920188f, -0.32314658f, 0.53839171f, -0.00428440f, -0.23065895f, -0.11646202f, -0.07926501f, 
    0.23758064f, -0.44371119f, -0.45211512f, 0.16513354f, -0.38797942f, 0.18840753f, 0.13543478f, -0.13297531f, 
    0.11591869f, 0.00743316f, -0.14524864f, -0.06469839f, -0.18491703f, 0.04165040f, -0.22910599f, -0.53888756f, 
    0.12656423f, 0.08215049f, -0.16351846f, 0.28129771f, -0.58068299f, -0.14007761f, 0.43589044f, 0.34783077f, 
    -0.13586296f, 0.03417535f, -0.40323433f, 0.67251182f, -0.34601733f, 0.02192101f, -0.23738703f, 0.10138410f, 
    -0.07012137f, -0.14754775f, -0.13816665f, 0.06417988f, 0.02959484f, -0.44786826f, 0.33090758f, 0.13436833f, 
    0.43674088f, 0.01310063f, -0.17593995f, 0.21558782f, -0.41279158f, -0.20417146f, -0.70254380f, -0.63236469f, 
    -0.39481628f, -0.67595983f, -0.05907366f, -0.08671627f, -0.22368436f, -0.02586619f, 0.13484447f, -0.16006993f, 
    0.14614794f, 0.20852941f, 0.00015872f, 0.14170794f, 0.08214265f, -0.18117115f, -0.17847855f, -0.29035589f, 
    0.29693383f, -0.46643794f, -0.54574668f, -0.23599032f, 0.00519720f, 0.09641881f, 0.52506614f, 0.56666219f, 
    -0.28873321f, -0.13759828f, 0.17101420f, 0.27743956f, -0.11331183f, -0.05350016f, -0.28363946f, -0.10864551f, 
    -0.11331194f, 0.16357937f, -0.16421723f, 0.24041335f, 0.15943027f, 0.11890595f, -0.29136336f, 0.06651799f, 
    0.10903987f, -0.36409041f, 0.80211663f, -0.90574020f, -0.06560827f, -0.13388002f, 0.68737048f, 0.34609532f, 
    -0.02345854f, -0.28604907f, -0.26836544f, -0.08555935f, -0.08869282f, 0.08471151f, 0.16823247f, -0.30905992f, 
    -0.03678889f, 0.12971260f, -0.03226458f, -0.16186289f, 0.04968768f, 0.14599919f, -0.14061020f, 0.08090135f, 
    0.03420092f, -0.10085641f, -0.28476700f, -0.35385680f, -0.69043958f, -0.63126504f, 0.04553671f, 0.48393849f, 
    -0.26331440f, -0.00713504f, 0.01203648f, -0.06882796f, -0.17625716f, -0.27727926f, -0.26118848f, 0.11788154f, 
    0.00760172f, 0.04834207f, 0.08633291f, -0.13842373f, 0.18835343f, 0.41493714f, 0.11674836f, 0.25912067f, 
    -0.23554386f, 0.14209966f, 0.19662486f, -0.11228123f, -1.16092992f, -0.38369089f, 0.52936774f, -0.61492354f, 
    0.11185372f, -0.38320690f, -0.27323437f, 0.57871807f, 0.41184697f, -0.00975183f, -0.43613374f, -0.24012247f, 
    -0.35211527f, 0.01675076f, 0.24596997f, 0.26041284f, -0.05516013f, -0.15322897f, 0.03250778f, -0.13338947f, 
    -0.21303672f, 0.00343154f, 0.01303125f, -0.09274413f, -0.34093857f, -1.08211279f, 0.27696419f, -0.13125733f, 
    -0.74182421f, -0.59063041f, 0.07915903f, 0.32646105f, -0.44922286f, -0.57306063f, 0.40218502f, -0.04687555f, 
    -0.34007576f, -0.07707071f, -0.21540290f, 0.03971425f, 0.11551081f, 0.21052912f, -0.02494399f, 0.05790773f, 
    -0.34816989f, -0.06150075f, -0.32599416f, -0.12701601f, -0.23983452f, -0.04565359f, 0.70559365f, 0.56243634f, 
    0.09274269f, -0.44822714f, -0.10470076f, -0.02899410f, 0.01631568f, -0.13181943f, -0.20795797f, 0.23470393f, 
    -0.28144994f, 0.23879398f, -0.25182918f, -0.26520753f, -0.08118133f, -0.04648077f, 0.00899674f, 0.13185790f, 
    -0.13604735f, 0.04239140f, -0.14518689f, 0.00413012f, -0.13277538f, 0.11825874f, -0.32319453f, 0.44326407f, 
    -0.18352814f, -0.13894805f, 0.08389635f, 0.17229736f, 0.21662343f, -0.64519346f, -0.46610823f, -0.10249394f, 
    -0.05203494f, -0.35539085f, -0.06818872f, -0.12813123f, 0.28861976f, 0.05060674f, 0.40589902f, -0.23947786f, 
    0.26246804f, -0.01575554f, 0.03448576f, -0.14832638f, -0.16988109f, -0.15107656f, -0.07256749f, -0.27514142f, 
    -0.39302000f, -0.09361531f, 0.09742191f, 0.10650521f, 0.33483306f, -0.68274313f, 0.03630634f, 0.49239433f, 
    0.44532654f, -0.43048123f, 0.49396843f, -0.41839612f, -0.20230542f, -0.38964748f, 0.11046299f, 0.07015755f, 
    -0.32775512f, 0.15805863f, -0.31895745f, 0.10365444f, -0.14347546f, -0.40484273f, 0.07344686f, 0.27867773f, 
    0.18302357f, 0.78466409f, -0.09249212f, 0.08346184f, 0.16631189f, 0.31764579f, 0.09735393f, 0.02780187f, 
    -0.05740790f, -0.39125839f, -0.31250316f, -0.31443205f, 0.04398583f, 0.41894561f, -0.42352861f, -0.10018393f, 
    0.05038943f, 0.15523784f, 0.00083450f, -0.09799538f, -0.17495245f, 0.06758073f, -0.30534816f, -0.09953405f, 
    0.01231351f, 0.20287350f, 0.46217209f, 0.19323282f, -0.05442271f, 0.24918558f, -0.29931957f, -0.00517142f, 
    0.26479313f, 0.08444586f, 0.30065298f, 0.09371072f, -0.20202577f, 0.36502308f, -0.16612975f, 0.12210537f, 
    -0.15295209f, -0.09713865f, -0.12580863f, 0.21805665f, -0.15902044f, -0.30237713f, -0.07749964f, 0.17288518f, 
    -0.23425010f, -0.05034200f, 0.14477141f, -0.11489559f, -0.32280493f, 0.11761753f, 0.24241196f, 0.21753079f, 
    0.65472496f, -0.24611834f, 0.20432401f, 0.43113816f, 0.28285307f, 0.18818007f, -0.12345571f, -0.11734448f, 
    0.22395602f, -0.02933374f, -0.21134828f, -0.13750938f, 0.13068138f, -0.18441272f, 0.02992648f, -0.07548115f, 
    0.14606917f, -0.12016325f, 0.14366807f, -0.02399019f, -0.20931479f, 0.09392148f, -0.65145993f, -0.75564867f, 
    -0.52616936f, 0.08855457f, 0.35698569f, 0.30091745f, 0.30881065f, 0.02852417f, 0.05129147f, -0.08104206f, 
    -0.04833459f, -0.41256678f, -0.46028730f, -0.12730046f, -0.47006178f, -0.33778605f, 0.17528322f, 0.22627650f, 
    0.20594762f, 0.01145066f, 0.15531483f, 0.05804936f, 0.35841039f, -0.27489644f, -0.49128714f, 0.07657702f, 
    0.50205541f, 0.12332675f, 0.07059628f, -0.33246461f, -0.18470848f, -0.07988401f, -0.00308449f, 0.45745566f, 
    -0.32220981f, -0.01927540f, -0.15855683f, 0.37828264f, 0.06837732f, -0.37195364f, 0.19878922f, 0.01256709f, 
    -0.06976292f, 0.19364940f, -0.17213696f, -0.22580421f, 0.08495953f, 0.44197428f, 0.37828991f, -0.23368677f, 
    -0.19879082f, -0.15408669f, -0.38769072f, -0.00982154f, -0.04782674f, 0.25979209f, -0.44911110f, 0.47469261f, 
    -0.42662740f, 0.52773112f, -0.28129828f, 0.16699432f, -0.41920403f, -0.04514562f, 0.30404189f, 0.10589275f, 
    0.11420906f, -0.11797519f, 0.14398059f, -0.10036213f, -0.23820129f, -0.07456625f, 0.21151803f, -0.33632737f, 
    -0.42460263f, -0.33930659f, -0.47362766f, -0.32767767f, -0.39925554f, -0.29778409f, -0.20806766f, 0.07275313f, 
    -0.31240338f, 0.10502411f, -0.07772677f, -0.25512767f, -0.37338978f, -0.09045855f, -0.48906314f, -0.28970206f, 
    -0.00560758f, -0.44546029f, -0.48987979f, 0.02833133f, 0.50403029f, 0.05174863f, 0.06766040f, 0.09086599f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.22803809f, 0.15382959f, 0.32390898f, 0.29920229f, 0.29677090f, -0.40738055f, -0.10466132f, 0.17714389f, 
    0.06348925f, 0.20413530f, 0.06943101f, 0.29453820f, 0.29386222f, 0.11849593f, 0.30849773f, 0.20312400f, 
    -0.25495526f, 0.12890461f, 0.12827161f, 0.06774047f, 0.20247538f, 0.07633851f, 0.30353653f, -0.30073777f, 
    -0.00876960f, 0.26887721f, 0.03838295f, 0.22860071f, -0.06819703f, 0.32507879f, 0.21516503f, 0.28827959f, 
    0.20778061f, 0.39982542f, -0.03884219f, 0.02617506f, 0.14333889f, -0.28866002f, 0.16613127f, 0.32108110f, 
    0.24703954f, -0.01127767f, 0.01935526f, -0.14399117f, 0.06034115f, 0.08578245f, 0.08696117f, 0.20062202f, 
    -0.13338427f, 0.09234825f, 0.13457547f, -0.03006393f, 0.16933553f, -0.05717778f, 0.21429648f, -0.20438324f, 
    0.17171010f, 0.10994918f, 0.19486968f, 0.36321512f, 0.14246063f, 0.23642237f, 0.15599854f, -0.38820612f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.32332250f, 0.15577808f, -0.11422351f, -0.14777182f, 0.12754415f, 0.02600485f, 0.01154898f, -0.05037500f, 
    0.01634835f, 0.07998370f, 0.01569017f, 0.01769309f, 0.26878944f, 0.08535797f, 0.01146895f, -0.05235027f, 
    -0.04842401f, 0.02371316f, -0.04033613f, -0.14544056f, 0.03313189f, 0.02018250f, 0.02037580f, 0.03029516f, 
    -0.17648064f, 0.10452279f, 0.24211532f, -0.31660846f, -0.19836837f, -0.09603892f, -0.00645699f, 0.01237596f, 
    -0.06310389f, -0.11851052f, -0.00020446f, -0.06102850f, 0.10039104f, -0.08717147f, -0.03729192f, 0.02880732f, 
    -0.02479190f, -0.10132945f, -0.10661978f, -0.18750399f, -0.13938282f, -0.02234017f, 0.01477239f, 0.00019252f, 
    -0.19254595f, -0.28186521f, -0.21414183f, -0.02848946f, -0.03317251f, -0.04055545f, 0.01716437f, -0.03733740f, 
    -0.23591253f, -0.15387627f, -0.03892020f, -0.01684069f, 0.24400337f, 0.09971609f, -0.17514512f, -0.08532064f, 
    0.08005626f, 0.14348786f, 0.09446496f, 0.02842435f, -0.03266708f, -0.07934675f, -0.02821640f, 0.00034191f, 
    0.26239419f, 0.02030233f, -0.04096380f, 0.00837649f, 0.02830801f, -0.05870606f, 0.02853803f, -0.02792327f, 
    -0.05994926f, -0.00148779f, 0.18341775f, 0.05301523f, 0.03313829f, -0.17065349f, -0.46305594f, 0.03366357f, 
    0.04436794f, -0.04865205f, -0.05323386f, -0.01710129f, -0.10313713f, 0.00458043f, -0.22215040f, 0.04859145f, 
    0.18824139f, 0.20850483f, -0.02998419f, -0.24080130f, -0.01924137f, -0.02503807f, 0.01093422f, 0.01953369f, 
    -0.09689195f, -0.02547124f, 0.03112128f, 0.04641055f, -0.17668654f, 0.11586764f, 0.07115542f, -0.07672727f, 
    0.02293370f, 0.10197802f, 0.09458400f, 0.03146863f, -0.02954786f, -0.00388338f, -0.05044108f, 0.03095454f, 
    0.29604092f, 0.02366599f, -0.12753431f, 0.06009769f, 0.15680709f, 0.06547062f, 0.03146575f, 0.02861797f, 
    -0.05947084f, 0.00124807f, -0.04433017f, 0.08983242f, -0.22305998f, -0.03185115f, -0.26566386f, -0.00301491f, 
    0.01935264f, -0.02452202f, 0.02816622f, -0.00040776f, -0.05287230f, 0.00987582f, -0.02230708f, -0.02425301f, 
    0.00458068f, 0.15245643f, 0.06871098f, -0.12482812f, -0.16873118f, 0.13642071f, -0.23062292f, -0.16714649f, 
    -0.03695209f, -0.10351170f, 0.00028870f, 0.00331383f, -0.11260156f, -0.19151327f, 0.03583078f, 0.13522802f, 
    0.02970728f, -0.14455566f, -0.03154446f, -0.15347663f, -0.11158589f, -0.09611574f, -0.01749845f, -0.01060115f, 
    -0.31555903f, -0.35401610f, -0.16064309f, 0.19523706f, -0.05176076f, -0.00179383f, 0.00834952f, 0.04992427f, 
    0.00039086f, 0.00926456f, 0.01399998f, -0.02753624f, -0.39940754f, -0.45784426f, 0.01098458f, -0.03528998f, 
    0.03339423f, 0.02370062f, 0.01921679f, -0.02619510f, -0.06341910f, 0.04980699f, 0.03149592f, -0.09810716f, 
    -0.00849310f, 0.05547366f, 0.03684931f, 0.02198236f, 0.00133335f, -0.00461352f, 0.03584357f, 0.04364458f, 
    -0.11135151f, 0.03023045f, 0.01018247f, -0.04098648f, -0.19105458f, -0.18982014f, 0.11232223f, -0.13861035f, 
    0.06844567f, 0.10151970f, -0.00318205f, 0.02796994f, -0.15602154f, -0.10722560f, -0.09633461f, 0.01677724f, 
    -0.17049055f, -0.00015462f, 0.15416914f, -0.20453462f, 0.03424289f, -0.00246310f, 0.02784268f, 0.00740115f, 
    -0.01789629f, -0.05539401f, -0.09267997f, -0.21697438f, -0.36067954f, -0.05870317f, 0.16601120f, 0.01000631f, 
    0.04898794f, 0.23509142f, -0.10927135f, 0.02308303f, -0.03684057f, 0.04226224f, 0.10569798f, -0.08166638f, 
    -0.55346483f, -0.00638411f, 0.20016572f, -0.05253160f, -0.02727237f, -0.11476101f, -0.09102917f, 0.08632436f, 
    0.09952023f, -0.08751766f, -0.05879733f, -0.00472173f, 0.00650569f, -0.07082148f, -0.37302366f, -0.16600841f, 
    -0.01221496f, -0.00236466f, -0.13052155f, -0.14547116f, -0.09885228f, -0.00507743f, 0.06355225f, 0.08050122f, 
    -0.12630409f, -0.32365420f, -0.14261775f, 0.00955557f, -0.02576211f, -0.03903423f, 0.01300577f, -0.03610393f, 
    -0.12953970f, -0.13667634f, -0.23749748f, -0.18880384f, 0.33025149f, 0.23940913f, -0.19618127f, -0.13617212f, 
    0.03917496f, -0.00723343f, 0.05728087f, 0.17438906f, -0.03737439f, 0.00145770f, -0.02561127f, -0.00296680f, 
    0.28926927f, 0.14244275f, -0.07451434f, -0.16107732f, 0.11917756f, -0.00976701f, 0.04926667f, 0.01476544f, 
    -0.03368393f, 0.01698660f, -0.00608181f, -0.02442610f, -0.07883000f, 0.15717700f, -0.04875879f, 0.02623832f, 
    0.02218352f, 0.01425731f, -0.13662182f, -0.28568035f, -0.09067925f, -0.10881963f, -0.07622153f, -0.05223726f, 
    0.02899758f, 0.06843584f, 0.01684629f, -0.10041586f, -0.01223321f, -0.01795086f, -0.00006708f, 0.05244881f, 
    -0.02912585f, -0.05427819f, 0.07686756f, 0.08099698f, 0.07402347f, 0.10032841f, 0.10027837f, -0.17816995f, 
    0.05107811f, -0.07526604f, -0.18477893f, 0.06826909f, -0.01114016f, -0.09087676f, -0.06853225f, -0.16448422f, 
    0.25600752f, -0.07362010f, -0.04144931f, -0.16002853f, 0.01782364f, -0.01740820f, 0.00380082f, -0.02695771f, 
    0.02154220f, -0.07443144f, 0.07426163f, 0.13563597f, 0.15390445f, -0.04930014f, -0.39737585f, 0.01478626f, 
    0.03646109f, -0.04865282f, -0.20554610f, -0.14477530f, -0.05638207f, -0.13720883f, -0.04069409f, 0.01204642f, 
    -0.09245307f, -0.33654082f, 0.03735784f, -0.09400640f, 0.00195281f, -0.03185888f, -0.11287283f, -0.04340024f, 
    -0.03397750f, -0.11633558f, 0.00375722f, 0.23082313f, 0.14220662f, 0.15040275f, 0.14113262f, -0.23887384f, 
    0.02487709f, 0.11041098f, 0.02104161f, 0.01785415f, 0.00449672f, 0.01902316f, 0.03558011f, -0.07875522f, 
    0.18139532f, 0.10200462f, -0.03543487f, -0.01418858f, 0.07523374f, 0.14446409f, 0.04895656f, -0.13966937f, 
    -0.00014730f, 0.09700713f, -0.06723005f, 0.02235253f, -0.05267627f, -0.16122074f, -0.18113554f, 0.10223563f, 
    -0.01534144f, -0.05536698f, -0.00048612f, -0.04373237f, -0.05031671f, -0.15754244f, -0.11998826f, -0.00697342f, 
    -0.04293593f, -0.10253125f, 0.23875043f, -0.18127874f, -0.02903337f, 0.05895310f, -0.13739410f, 0.04633002f, 
    -0.11142835f, 0.18856150f, 0.04532732f, 0.10133440f, -0.02127661f, 0.02978136f, 0.06358346f, 0.03462821f, 
    -0.18648714f, -0.28647459f, 0.04558152f, 0.02422188f, 0.00990278f, -0.04228562f, 0.00232708f, 0.04017877f, 
    -0.25006148f, -0.23368020f, 0.26411361f, 0.05149461f, -0.02420576f, 0.05297473f, -0.23134409f, 0.01698449f, 
    -0.16049710f, 0.08299753f, 0.06633980f, -0.08264214f, 0.30564320f, 0.17306483f, -0.07651065f, -0.01197659f, 
    0.07662358f, 0.09737666f, 0.06589312f, 0.02577486f, -0.11161404f, -0.05560925f, -0.07774794f, -0.03274740f, 
    0.42133412f, 0.24054165f, -0.03350434f, -0.38090515f, -0.11182362f, -0.05038147f, 0.14806877f, -0.00509873f, 
    -0.05210178f, -0.04915783f, -0.02456575f, -0.20855586f, 0.06907091f, 0.22220716f, 0.13319518f, -0.11861046f, 
    0.11436253f, 0.00861102f, -0.02527127f, -0.05334796f, -0.01370524f, -0.06756969f, -0.04872052f, -0.15517721f, 
    -0.20289984f, 0.01630335f, -0.14918198f, 0.16093816f, 0.08205079f, 0.01331763f, -0.17016098f, -0.09892382f, 
    0.01043730f, -0.01047657f, 0.04076707f, 0.01457198f, 0.19694857f, 0.06966637f, -0.02188940f, -0.12039433f, 
    0.06769193f, 0.09323467f, 0.01321542f, -0.17830795f, -0.02638443f, -0.05274191f, -0.06204356f, 0.08549272f, 
    0.16098659f, 0.06565963f, -0.25372711f, -0.09779886f, -0.28874403f, 0.00233849f, -0.06161273f, 0.17772624f, 
    0.04602063f, 0.11682285f, -0.03111003f, -0.01669355f, 0.29251507f, 0.17803040f, -0.25169072f, -0.10074552f, 
    0.12328777f, 0.03304340f, 0.05796690f, -0.00871894f, -0.01661330f, -0.05779021f, -0.00003435f, -0.02236657f, 
    0.17289418f, 0.11548501f, -0.09314433f, -0.09388064f, 0.03090313f, 0.06632150f, -0.05564484f, 0.00692386f, 
    -0.14641581f, -0.11555634f, -0.08601321f, 0.00562287f, 0.08228973f, 0.06621141f, -0.02912166f, -0.20578437f, 
    0.02032056f, 0.04831021f, -0.15232760f, 0.09091678f, -0.06105088f, 0.05538993f, 0.03228173f, 0.01654897f, 
    0.28071550f, 0.01812686f, -0.05262462f, -0.19515318f, 0.05503104f, 0.06381928f, 0.03905732f, 0.08002032f, 
    0.04013897f, 0.02537429f, -0.08189243f, -0.05580492f, -0.09837287f, 0.10030139f, 0.30169734f, -0.18993077f, 
    -0.01898655f, 0.03168954f, -0.05861124f, -0.04446090f, 0.02446064f, -0.13519385f, -0.13151613f, -0.10058407f, 
    0.14168915f, 0.08013853f, -0.09581535f, -0.21003732f, 0.03632449f, -0.04583485f, 0.13766921f, 0.11283378f, 
    0.02100808f, 0.01769236f, 0.01822295f, 0.02874005f, 0.27587968f, 0.03780726f, -0.23002693f, -0.00790939f, 
    -0.02172966f, 0.02324731f, 0.06733268f, -0.10728822f, 0.01180511f, -0.06568874f, 0.01663532f, 0.09326004f, 
    0.16422571f, -0.07740626f, -0.40873322f, 0.31393790f, -0.07168557f, -0.18714368f, -0.02612064f, -0.17446044f, 
    -0.12873568f, 0.08859450f, 0.06479710f, -0.01216587f, 0.32926273f, 0.11446635f, 0.05284368f, -0.06065599f, 
    0.13817382f, 0.03716664f, 0.14803870f, -0.06743779f, -0.05776428f, 0.01666405f, 0.01504423f, -0.01206271f, 
    0.08363070f, 0.06821219f, 0.16130628f, -0.14192486f, -0.04450936f, 0.19642332f, 0.07205113f, 0.00787552f, 
    -0.01093094f, 0.00623624f, 0.03904692f, 0.09049268f, 0.13863298f, 0.23679389f, -0.02261484f, -0.01408300f, 
    0.02077854f, 0.22453888f, -0.05208198f, 0.19694354f, -0.02551282f, -0.03638356f, -0.00304957f, -0.03481134f, 
    -0.57457948f, 0.04022348f, -0.45783880f, 0.21112183f, 0.03260556f, 0.00358144f, -0.03810167f, -0.00451321f, 
    -0.05058918f, -0.04406319f, -0.05275423f, -0.01316194f, 0.10337202f, 0.09324755f, -0.10163541f, -0.01430772f, 
    -0.06319468f, 0.05743212f, -0.04135356f, 0.01041630f, -0.07776206f, -0.02434399f, 0.06568133f, 0.01221595f, 
    -0.13656650f, -0.20366472f, 0.23402028f, -0.34792298f, -0.05194096f, 0.03998114f, 0.05031896f, 0.04475486f, 
    -0.06358413f, -0.05293024f, 0.02509251f, 0.04044398f, -0.36489558f, -0.20852566f, -0.30520380f, 0.13756673f, 
    -0.03414636f, -0.02103395f, -0.02551363f, 0.04683964f, -0.03026179f, 0.02469778f, 0.01526420f, 0.01921226f, 
    -0.26691413f, -0.58457285f, -0.49461916f, 0.06391046f, 0.02125309f, 0.02790889f, 0.01291495f, 0.02471720f, 
    -0.11167367f, 0.04046142f, -0.05407333f, -0.10873783f, -0.01373469f, -0.07608697f, 0.01445206f, 0.01452816f, 
    0.01399393f, 0.02870157f, 0.01610517f, 0.03699051f, -0.04525418f, 0.03282629f, -0.17621028f, -0.25327355f, 
    -0.02149203f, -0.11460182f, -0.12895317f, -0.03097348f, 0.10157367f, 0.02257369f, -0.05762736f, -0.04753166f, 
    0.02702740f, -0.11845332f, -0.01259144f, -0.15965489f, 0.02378980f, 0.01018409f, 0.06036023f, -0.21212588f, 
    -0.04585583f, -0.07787922f, 0.10732733f, -0.19001672f, -0.03769695f, -0.12304164f, 0.00136264f, -0.11806743f, 
    -0.10933377f, -0.15416557f, -0.19317465f, -0.03574013f, -0.01509800f, 0.06718371f, -0.04380693f, -0.04382683f, 
    -0.02878157f, 0.03392478f, 0.02574660f, -0.14113133f, 0.17172933f, 0.07959723f, 0.01979817f, -0.06753106f, 
    0.10666233f, 0.23177287f, -0.03200292f, -0.07330154f, -0.07320813f, -0.10726546f, -0.13132793f, -0.02326970f, 
    -0.08124960f, 0.13812405f, 0.04397057f, -0.05343562f, -0.33290163f, 0.14395238f, -0.17904204f, -0.25607941f, 
    -0.05318567f, -0.07079765f, -0.03098646f, 0.03221044f, -0.24922715f, -0.12974679f, -0.04567640f, -0.05946798f, 
    0.07827655f, 0.20087188f, 0.00215837f, 0.05146271f, -0.11687057f, 0.01777667f, 0.03392375f, 0.01867837f, 
    -0.67658323f, 0.13342538f, -0.06371994f, -0.20945424f, 0.15767029f, -0.07246719f, -0.07828235f, 0.10152192f, 
    -0.00896003f, -0.01387507f, 0.11020931f, -0.00280392f, 0.12584901f, -0.08445280f, 0.01397450f, 0.04360627f, 
    -0.07318354f, 0.18907352f, 0.18179812f, 0.03402085f, 0.07891962f, 0.06090837f, 0.04601891f, -0.00620076f, 
    0.29595736f, 0.03537824f, -0.09864363f, -0.09984680f, 0.05823553f, 0.00285344f, 0.03101319f, 0.01236590f, 
    0.08898985f, 0.12224352f, 0.03403164f, 0.01330717f, 0.32761067f, 0.23798963f, 0.30750993f, 0.32003143f, 
    -0.05293426f, 0.03713337f, 0.00970968f, 0.08393437f, 0.00146042f, -0.04384222f, 0.01082912f, 0.02736172f, 
    0.01741834f, -0.09121361f, -0.05488894f, -0.01691347f, -0.07993683f, 0.04930386f, 0.02590549f, -0.05950400f, 
    -0.04985042f, -0.16460994f, -0.04530086f, -0.25718549f, 0.66802329f, -0.06003718f, -0.12780558f, -0.23434716f, 
    -0.01258445f, -0.00203631f, -0.05088432f, -0.11660587f, 0.12776858f, -0.09248507f, -0.03458086f, 0.07869744f, 
    -0.35909295f, 0.06880473f, -0.17875239f, 0.03148061f, 0.04859527f, 0.04267417f, -0.10770502f, 0.12535574f, 
    -0.02212538f, 0.11067317f, -0.00549140f, 0.01995160f, -0.21794228f, 0.06964803f, -0.17538193f, -0.10710517f, 
    0.03411240f, 0.00205290f, -0.04405507f, 0.02598913f, -0.08378352f, 0.03920146f, 0.01561112f, -0.01025559f, 
    0.01203952f, -0.04089386f, -0.08631320f, -0.01771586f, -0.13483247f, 0.03211628f, -0.05757366f, -0.16182660f, 
    0.06377185f, -0.14361055f, 0.02780042f, -0.11676630f, 0.29240096f, 0.24590427f, 0.25148770f, 0.16561873f, 
    -0.03518061f, -0.01021772f, 0.02489026f, -0.00199558f, 0.07131068f, 0.04122595f, -0.03300323f, 0.06782358f, 
    -0.05664798f, 0.05771455f, -0.05395958f, 0.00729586f, 0.18154526f, -0.05546216f, 0.06547204f, 0.04078551f, 
    -0.06159534f, 0.01574183f, -0.05101429f, 0.00393740f, -0.11579376f, -0.21881787f, 0.05096547f, -0.09504665f, 
    0.06147496f, 0.17523353f, 0.03081572f, 0.06762810f, 0.19298881f, 0.18321741f, -0.15483838f, 0.10910885f, 
    0.57244331f, -0.06376913f, 0.11006527f, 0.29656354f, -0.07999782f, -0.07248352f, 0.07173770f, -0.07925555f, 
    -0.04947175f, -0.00002848f, -0.06119578f, 0.01453920f, 0.13284932f, -0.00118861f, 0.16584939f, 0.03081913f, 
    -0.06976232f, 0.04378669f, 0.04062945f, 0.10896164f, -0.08461207f, -0.04117116f, -0.01723506f, -0.08643460f, 
    0.01601605f, 0.00133533f, 0.03525237f, 0.01002514f, -0.01448297f, 0.01515144f, 0.06694397f, -0.06039722f, 
    -0.04196158f, -0.00607029f, 0.01063444f, -0.00038260f, -0.15231383f, 0.07409120f, -0.09617385f, -0.24366425f, 
    -0.00459118f, 0.00964432f, 0.01006694f, 0.02450772f, -0.13996425f, 0.10071094f, 0.00041458f, -0.05350275f, 
    -0.15634389f, 0.09776434f, 0.08304874f, -0.06981110f, -0.03682496f, -0.02885530f, 0.01640828f, 0.05476576f, 
    -0.12507214f, -0.07784029f, -0.19763260f, 0.16961192f, -0.26086536f, -0.03307222f, 0.15360433f, -0.17453451f, 
    0.02093655f, -0.00876359f, -0.24405651f, -0.17845471f, 0.09690379f, -0.02016294f, -0.14502025f, -0.24702965f, 
    -0.88955224f, 0.11093897f, 0.11062621f, -0.16397570f, -0.05768318f, 0.18104738f, -0.13295019f, -0.12534396f, 
    0.00096896f, -0.02769751f, 0.02210227f, -0.05054722f, 0.11239851f, -0.02764820f, 0.07381284f, -0.13087316f, 
    0.00969480f, -0.02284418f, -0.07980657f, 0.01445108f, 0.16958113f, 0.07326099f, -0.09945096f, 0.00341324f, 
    0.13767028f, 0.06333292f, 0.20795748f, -0.10056262f, -0.02379802f, -0.02197151f, 0.01190240f, 0.01179113f, 
    0.03169910f, 0.02997547f, 0.01050383f, -0.03865357f, 0.02657533f, -0.01566544f, 0.01989978f, 0.21182765f, 
    -0.14621259f, 0.03780165f, -0.08716082f, 0.04004424f, -0.06246401f, -0.01608080f, 0.02527643f, 0.09137546f, 
    -0.03676297f, -0.06483193f, -0.09887234f, 0.20975329f, -0.07992686f, 0.01171243f, 0.28050983f, -0.14190944f, 
    0.06804080f, 0.03344691f, -0.00591002f, -0.03878054f, 0.05487642f, -0.01437505f, -0.07107335f, 0.10175019f, 
    -0.01896677f, 0.20622137f, 0.11684506f, -0.00652273f, 0.12762643f, 0.01263060f, 0.07813238f, -0.09781400f, 
    0.18092558f, 0.02202738f, -0.19271900f, 0.01847599f, -0.08416327f, -0.04939852f, 0.01865554f, 0.00821314f, 
    -0.28765017f, -0.34187549f, -0.28221425f, -0.26953110f, -0.09988139f, 0.06457156f, -0.08828362f, -0.16515811f, 
    0.14823745f, 0.04767936f, 0.01612625f, -0.04483928f, 0.01026242f, -0.08933726f, 0.01806500f, -0.08354268f, 
    0.18603978f, -0.14233215f, 0.09129263f, -0.18876836f, -0.03248465f, -0.02140721f, 0.00106237f, -0.00979368f, 
    -0.12204430f, -0.11972523f, -0.12518159f, -0.44079167f, 0.38121101f, -0.27733585f, 0.19450013f, 0.00129186f, 
    -0.12025727f, 0.00748840f, 0.07537575f, 0.06491454f, 0.05543498f, 0.11214890f, -0.00987592f, -0.05322208f, 
    0.13029249f, -0.02402716f, 0.12289415f, -0.03470544f, -0.00556536f, -0.04748461f, -0.11907066f, -0.04326491f, 
    -0.07448971f, -0.14787140f, 0.20717625f, -0.23087265f, -0.24432676f, -0.08614193f, -0.40283325f, -0.13490087f, 
    -0.03756084f, -0.02146218f, -0.04670895f, 0.19681914f, -0.12517680f, 0.09792239f, 0.09589315f, -0.00691382f, 
    0.14723626f, 0.05111060f, -0.10301644f, -0.05409542f, 0.01757777f, 0.04102276f, 0.01234936f, -0.27431914f, 
    0.03585978f, 0.02207891f, 0.01907234f, -0.15225880f, 0.18550374f, -0.15934239f, 0.11624011f, 0.12057802f, 
    -0.05665829f, -0.02372380f, 0.05562594f, -0.01621233f, 0.04471369f, 0.03925466f, 0.10325561f, 0.05573065f, 
    0.27059415f, -0.16959769f, 0.08894184f, -0.21225183f, 0.01675663f, -0.08112332f, 0.00124813f, -0.22870713f, 
    -0.01368959f, -0.10836475f, -0.30670190f, 0.08738661f, -0.00579153f, 0.04737946f, -0.04055204f, 0.01583482f, 
    0.12432763f, -0.00189302f, -0.01008839f, 0.11366658f, -0.06736078f, -0.02814763f, 0.03281203f, -0.00722776f, 
    0.16001222f, -0.01736237f, 0.01797253f, -0.02629258f, 0.09669984f, -0.00870130f, 0.10938562f, -0.13095966f, 
    0.07386683f, 0.13167317f, -0.12062879f, 0.01772014f, 0.22932887f, -0.10153686f, 0.29503715f, -0.07024106f, 
    0.08416177f, -0.08904991f, -0.05574517f, -0.19987287f, -0.00905106f, 0.04262813f, 0.01799261f, 0.07979655f, 
    0.36880583f, 0.11304654f, -0.06977947f, -0.05993344f, -0.18454093f, 0.00684346f, 0.03490879f, -0.03509124f, 
    0.17394209f, -0.13263114f, -0.17463925f, 0.21348597f, -0.54320937f, -0.03862888f, -0.14555587f, 0.02400408f, 
    0.00910421f, 0.02275759f, 0.19110446f, -0.02852515f, -0.00728291f, -0.04676534f, 0.10619589f, 0.07804041f, 
    0.15617593f, -0.11689717f, 0.13172668f, -0.05606554f, 0.08235762f, -0.07340521f, -0.12337641f, -0.01057684f, 
    -0.02831440f, -0.00087274f, -0.04139536f, 0.02677107f, -0.27307540f, 0.18628047f, -0.05099514f, -0.06013397f, 
    0.05152133f, 0.12073685f, -0.03548595f, -0.02862185f, -0.09650589f, 0.08445109f, 0.02920727f, -0.05594347f, 
    0.10328533f, -0.20965847f, -0.07864440f, -0.17561840f, -0.12949270f, 0.06914756f, 0.10125922f, 0.08031675f, 
    -0.04543364f, -0.03053249f, 0.00622681f, 0.08595200f, 0.09146136f, 0.08496442f, 0.25828221f, 0.16207476f, 
    0.00606396f, 0.00803779f, 0.04311430f, 0.02661354f, -0.03204786f, -0.04452829f, -0.01125701f, 0.02839725f, 
    -0.09162503f, -0.22519885f, -0.10122564f, -0.06984024f, -0.08843140f, 0.07365463f, 0.00639097f, 0.23648719f, 
    0.00495203f, -0.01091776f, -0.06928982f, 0.13834228f, -0.01581738f, 0.08323327f, -0.26067993f, -0.34068647f, 
    -0.19482271f, -0.26915923f, 0.23466451f, 0.14441738f, -0.07245434f, 0.04534427f, -0.02365125f, 0.10430384f, 
    0.18584885f, -0.03860502f, 0.01865797f, -0.04817411f, 0.03446195f, -0.09029254f, 0.00360318f, -0.00940800f, 
    0.05632498f, -0.07292683f, -0.02643046f, -0.15371209f, -0.73579240f, -0.17207193f, -0.20735814f, 0.06947859f, 
    -0.00476850f, 0.14651410f, 0.04940617f, -0.07175034f, 0.17135911f, 0.21267302f, -0.14377788f, 0.01149997f, 
    0.04404221f, 0.05342624f, -0.18921238f, -0.39563885f, 0.02862024f, -0.27108636f, -0.11235492f, -0.25154358f, 
    -0.00054417f, 0.00187417f, 0.02044372f, 0.02878510f, 0.50380510f, -0.08844481f, -0.14901221f, 0.00658492f, 
    -0.16170049f, -0.01935350f, -0.02500903f, -0.00189409f, 0.00387641f, -0.11223058f, 0.00572073f, 0.04947434f, 
    0.22775482f, 0.03035215f, -0.40157646f, 0.15894657f, -0.10727480f, -0.11123950f, 0.05605290f, 0.23691367f, 
    -0.04820193f, 0.07209771f, -0.07654721f, 0.02296772f, -0.10149582f, 0.05410636f, 0.22929834f, 0.13045268f, 
    -0.04604472f, -0.04918399f, -0.02544932f, -0.13397530f, 0.00590739f, -0.06926298f, 0.01332158f, -0.07226816f, 
    -0.30199403f, 0.12658113f, 0.00865166f, -0.05193789f, 0.12349794f, -0.06281546f, -0.19747025f, -0.11920249f, 
    0.02984361f, 0.04134272f, 0.00344894f, -0.16185518f, 0.27550933f, -0.14150897f, 0.10176697f, -0.01560471f, 
    0.26774254f, 0.06022822f, -0.18500818f, -0.27550381f, 0.04856101f, 0.05873895f, -0.05925656f, -0.03297668f, 
    0.34797692f, 0.07430141f, 0.13919920f, 0.00481032f, 0.02640821f, -0.07131507f, 0.04777795f, 0.03108537f, 
    0.00686680f, 0.02864963f, -0.04284676f, 0.06049069f, 0.09706359f, 0.04125088f, -0.18181491f, -0.03814217f, 
    0.22604120f, -0.02926746f, -0.17009978f, 0.04359087f, 0.04964889f, -0.01546092f, 0.04882187f, -0.09092358f, 
    -0.57511538f, -0.05736743f, 0.09720256f, -0.18436308f, 0.03867855f, 0.01971467f, 0.06715830f, -0.18146953f, 
    0.01169634f, 0.12669094f, -0.07674640f, 0.05137820f, 0.56213647f, 0.19215918f, -0.03683837f, 0.10231087f, 
    -0.07464541f, -0.03326929f, -0.02635046f, -0.11513822f, 0.05103326f, -0.00885534f, 0.00398379f, 0.05157209f, 
    0.29705468f, 0.29274365f, 0.25141811f, -0.00919748f, -0.04324676f, 0.01986002f, 0.00979156f, 0.00244377f, 
    0.10141476f, 0.21252164f, -0.13652977f, 0.07922131f, 0.14161645f, 0.12975088f, -0.01754100f, 0.11496701f, 
    -0.07739437f, -0.02312962f, 0.01998600f, 0.00567491f, 0.02418964f, 0.06010748f, 0.00151783f, 0.01085991f, 
    0.08833947f, 0.12017622f, -0.07129325f, -0.26084751f, -0.01438558f, 0.09217647f, 0.05517565f, -0.05987930f, 
    -0.07806313f, 0.08261720f, -0.22857642f, 0.00627817f, -0.28162396f, 0.14490746f, -0.17817001f, 0.04290459f, 
    -0.04628440f, 0.11088805f, 0.01302204f, 0.04667456f, 0.06504506f, 0.03411991f, 0.07143301f, 0.01709691f, 
    0.45625976f, -0.09516623f, -0.08892926f, -0.32289773f, 0.06604553f, 0.08476961f, 0.07062479f, -0.31601337f, 
    0.07969852f, -0.25442743f, -0.07903392f, 0.08177323f, -0.00186498f, 0.26590979f, 0.05180245f, -0.01303773f, 
    -0.07838392f, 0.05158209f, -0.05708867f, 0.28132710f, -0.00956226f, 0.02769722f, -0.10235955f, -0.05093668f, 
    -0.39790606f, 0.10176494f, 0.02181309f, -0.16020271f, -0.05849604f, -0.10733105f, 0.12282977f, 0.01181147f, 
    -0.01084773f, -0.00767535f, -0.04946321f, 0.02276082f, 0.04548386f, 0.00142218f, -0.07031351f, 0.08935138f, 
    -0.06541649f, -0.12275847f, -0.12756278f, 0.00461383f, 0.08831893f, 0.05965741f, 0.01126039f, 0.03006414f, 
    0.05879309f, -0.01142369f, -0.00870472f, 0.10460316f, -0.00106977f, 0.01175317f, -0.11690172f, -0.08592615f, 
    0.07056084f, -0.02799360f, -0.01651659f, 0.01853079f, -0.08573728f, 0.04851639f, -0.04785516f, 0.12178361f, 
    -0.10799626f, -0.09453341f, 0.10998046f, -0.03050279f, -0.06520887f, 0.03229977f, -0.02842012f, -0.02092062f, 
    -0.11678296f, 0.14946163f, -0.06731081f, 0.00440925f, -0.04261429f, 0.00594582f, -0.01429802f, -0.00572455f, 
    -0.11465626f, -0.06102730f, 0.01423508f, 0.09720619f, -0.24050131f, -0.09442488f, 0.37336162f, 0.27375224f, 
    0.00896570f, -0.01937459f, -0.02063042f, 0.05076472f, 0.01095269f, -0.06108520f, -0.01056129f, -0.05462180f, 
    0.08480114f, -0.03863546f, -0.16948102f, 0.07118737f, -0.04716845f, 0.04316431f, -0.00759214f, 0.03877719f, 
    -0.02388179f, 0.13637069f, 0.04390761f, -0.01102721f, -0.53455448f, 0.49583212f, 0.22521101f, -0.17703603f, 
    -0.05950847f, -0.06648694f, 0.07004228f, -0.09498607f, -0.00460500f, 0.03204899f, 0.12113360f, 0.00778035f, 
    -0.07919143f, -0.17073652f, -0.35942033f, 0.20146213f, 0.02649967f, 0.02290203f, 0.04967982f, -0.08035737f, 
    -0.01776578f, 0.06058098f, -0.05699557f, 0.02202620f, 0.05343528f, 0.11420647f, 0.06694320f, 0.17461391f, 
    0.05639948f, 0.03835686f, 0.04027259f, 0.00561582f, -0.08324677f, 0.03000225f, -0.04004934f, 0.10997095f, 
    -0.09670178f, 0.18510510f, 0.20108344f, 0.06785784f, -0.08727797f, -0.04517132f, 0.12895593f, 0.10022449f, 
    0.10341607f, 0.08355068f, -0.01641510f, 0.01376600f, -0.26489443f, 0.09028450f, 0.02829303f, -0.27514634f, 
    0.03102042f, -0.02125939f, -0.02985420f, -0.01872319f, -0.01846661f, 0.08052513f, -0.08582698f, 0.03445625f, 
    -0.07548739f, -0.12657791f, -0.00923280f, 0.08216036f, 0.02340853f, 0.00412701f, -0.09191456f, 0.03159552f, 
    0.00216777f, 0.03962677f, 0.02547623f, 0.02606666f, -0.02843183f, 0.02693528f, 0.07342914f, -0.02470721f, 
    -0.00512865f, 0.00843508f, -0.10109967f, -0.12594397f, -0.10054548f, -0.08660182f, 0.10074589f, 0.02438196f, 
    0.10087234f, -0.13521579f, -0.25201949f, -0.12467723f, 0.03765104f, 0.00706813f, 0.04800513f, -0.06078367f, 
    -0.01986399f, 0.00269932f, -0.02363645f, -0.10853305f, 0.22724947f, -0.22638050f, 0.01032947f, -0.21123658f, 
    0.03672639f, -0.06911705f, -0.01500026f, 0.07574691f, 0.01280422f, -0.07710044f, 0.02819964f, 0.13651593f, 
    -0.06321479f, 0.01097760f, -0.03889253f, -0.07977219f, -0.04935328f, -0.04582656f, -0.02940363f, 0.07185806f, 
    -0.07538487f, -0.01130188f, -0.03926276f, -0.02596482f, 0.04748914f, 0.32880926f, 0.04201917f, 0.12134813f, 
    0.02425101f, 0.02143734f, 0.05679272f, -0.03730821f, 0.05698826f, -0.09556146f, -0.02419324f, -0.04049033f, 
    -0.11585165f, -0.26562691f, -0.09177676f, 0.10706102f, -0.03891337f, 0.00536845f, 0.03585420f, 0.00442836f, 
    0.00800568f, -0.23558795f, 0.09423652f, 0.01427918f, 0.39124218f, 0.46272573f, 0.08931910f, 0.26852345f, 
    -0.02229726f, 0.01672190f, 0.18580608f, -0.05540500f, 0.02735749f, 0.11564229f, -0.21005045f, 0.05842128f, 
    0.12435760f, 0.18383951f, -0.12043992f, 0.11225112f, 0.00033513f, 0.09925009f, -0.11117302f, -0.03322073f, 
    -0.02807021f, -0.05472261f, 0.08459599f, -0.04619393f, -0.06946325f, -0.02422044f, -0.01294848f, -0.41273123f, 
    0.07956646f, -0.02726498f, 0.02320419f, -0.11001068f, 0.01993438f, 0.11464962f, -0.12252500f, 0.08814362f, 
    0.02283622f, 0.12817414f, 0.05287069f, -0.05970060f, 0.05990427f, 0.01838833f, -0.06851566f, 0.06375804f, 
    -0.05171154f, -0.11106113f, 0.01304920f, -0.00254440f, -0.78649056f, -0.65911013f, -0.33785355f, -0.31012934f, 
    0.06704173f, -0.04992546f, -0.00070589f, -0.03101240f, -0.01648828f, -0.00103173f, -0.06045489f, -0.02023455f, 
    -0.11907560f, -0.14796765f, -0.40877149f, 0.11320263f, 0.02783244f, -0.04218642f, 0.10157833f, -0.03554817f, 
    -0.06816042f, 0.02630887f, 0.03616959f, -0.05969293f, -0.08861654f, 0.00046417f, 0.01772119f, 0.09154154f, 
    -0.09774545f, 0.14378072f, -0.07965662f, -0.09270666f, -0.04063062f, 0.02113404f, -0.03014074f, -0.06871272f, 
    0.07420516f, -0.01293634f, 0.00648751f, 0.03885827f, 0.01433350f, -0.04151934f, 0.00192349f, 0.03117868f, 
    -0.06845627f, 0.04351824f, 0.09502035f, -0.08831749f, -0.10321286f, 0.39139694f, 0.18393917f, -0.14530113f, 
    -0.00997737f, 0.18799695f, -0.03878972f, 0.00117023f, -0.04683767f, -0.04215170f, 0.03119865f, -0.02351282f, 
    0.07627072f, -0.07823905f, 0.42406887f, 0.10016702f, 0.02134922f, 0.03825494f, 0.02522945f, 0.00028924f, 
    0.07261375f, -0.03037972f, 0.00531893f, -0.03409564f, -0.16307786f, 0.06783319f, 0.15542717f, -0.26227862f, 
    -0.01370039f, 0.04281695f, -0.14063936f, -0.01845210f, -0.04349874f, -0.00718011f, -0.09443600f, -0.06431218f, 
    -0.11349773f, 0.03302363f, 0.13833091f, -0.04825239f, 0.01634317f, -0.02587480f, 0.03973711f, -0.05098850f, 
    0.13852857f, 0.20842005f, 0.07916306f, 0.08915345f, -0.03391466f, 0.23422098f, -0.05716651f, 0.17501548f, 
    0.04180228f, -0.04077405f, -0.02485815f, 0.16639768f, 0.09668358f, -0.13207433f, -0.14582650f, 0.08712480f, 
    0.09469546f, 0.10459350f, 0.26876411f, 0.26871318f, -0.07654966f, 0.01786486f, 0.13677949f, 0.02745597f, 
    0.04196668f, -0.01164328f, 0.05078717f, 0.08587626f, -0.01474854f, -0.16299640f, 0.13511601f, 0.00507355f, 
    0.01537661f, 0.03345015f, 0.10411923f, 0.01548680f, -0.00867212f, -0.08350103f, 0.07887308f, 0.04637499f, 
    -0.28974894f, 0.00980400f, -0.05792023f, -0.11115713f, 0.05927774f, 0.00629067f, 0.00183536f, -0.29490015f, 
    0.05161972f, 0.01866231f, 0.00450992f, 0.04937282f, -0.07574496f, -0.03797167f, -0.00318532f, 0.01872323f, 
    -0.05739313f, -0.06662066f, -0.00811324f, 0.00935420f, -0.00892210f, -0.02825044f, -0.03430109f, -0.00290701f, 
    -0.00295506f, -0.02422992f, -0.06675956f, -0.09229518f, -0.00395738f, 0.03239473f, -0.05679920f, -0.09856913f, 
    0.12964208f, 0.03231640f, -0.04091266f, 0.10126479f, -0.33095819f, -0.40858689f, 0.04920476f, -0.08330506f, 
    -0.00499654f, -0.13542406f, -0.05538691f, -0.00347661f, -0.02965485f, -0.03112091f, 0.02685845f, -0.16613795f, 
    0.05841791f, -0.06437204f, -0.06660472f, 0.00689682f, 0.08392260f, -0.02638344f, -0.10138389f, 0.05067599f, 
    0.01409523f, 0.12929997f, -0.04591639f, 0.00238398f, 0.18795943f, -0.05793282f, -0.19661357f, 0.05010022f, 
    -0.05706297f, 0.05590423f, 0.09599133f, 0.01489364f, -0.05035333f, 0.01305979f, -0.07312695f, -0.08226020f, 
    -0.18560809f, -0.11773791f, 0.41333869f, -0.36656716f, -0.04686241f, 0.00895933f, -0.07406678f, -0.05046290f, 
    -0.00213371f, -0.00770994f, -0.00526691f, -0.05541505f, -0.18385111f, 0.37257633f, 0.25587511f, 0.26925933f, 
    -0.04119390f, -0.01026830f, 0.05383863f, 0.09979405f, -0.12545225f, 0.11083733f, -0.03267818f, 0.02836173f, 
    -0.23486048f, -0.23848389f, 0.18285519f, -0.09475350f, 0.04397176f, -0.13015661f, -0.05739282f, -0.37398732f, 
    0.02958967f, -0.10141516f, -0.01027219f, 0.02737512f, -0.29077956f, -0.25990719f, -0.16832244f, -0.37272978f, 
    0.05022717f, -0.13398977f, 0.14491440f, 0.06107357f, 0.02612358f, -0.01815613f, 0.01720572f, -0.07580198f, 
    -0.16041134f, 0.04814879f, -0.12133989f, -0.10248006f, 0.05896463f, 0.01964715f, 0.03666125f, -0.15489992f, 
    0.06397866f, 0.02156853f, 0.05929569f, 0.08850303f, -0.56351286f, -0.12259644f, -0.03902630f, -0.23491542f, 
    -0.00411859f, -0.13971794f, 0.01375250f, -0.27983609f, 0.00514707f, -0.07377695f, -0.02307908f, 0.02497764f, 
    -0.20893885f, 0.05678543f, 0.38665852f, 0.06219659f, -0.00450053f, -0.08712327f, 0.00144527f, 0.04855005f, 
    0.02205414f, 0.01902429f, 0.07843032f, 0.13121621f, 0.14217500f, 0.02279052f, -0.39279649f, 0.07291646f, 
    -0.01204625f, 0.06438543f, 0.04801866f, -0.02501278f, -0.05260792f, 0.01246288f, -0.05792931f, 0.00491364f, 
    -0.73405969f, -0.10656009f, 0.04747334f, -0.22278883f, -0.06042528f, -0.03583248f, -0.19847412f, 0.02649991f, 
    0.00322291f, 0.02253210f, -0.06724964f, 0.00182883f, 0.00833044f, -0.31068385f, 0.16219972f, 0.03395061f, 
    0.00985590f, -0.06416060f, 0.11324553f, 0.15384136f, 0.15993519f, 0.07527107f, 0.07681967f, -0.04562742f, 
    0.02399682f, 0.04564788f, -0.25909871f, 0.15401959f, 0.06414495f, -0.00380860f, -0.05366104f, -0.12228728f, 
    0.03751049f, 0.02529832f, 0.00901001f, -0.05422248f, -0.15900874f, -0.11910620f, 0.12492374f, 0.18952623f, 
    0.05198751f, -0.13763151f, 0.11560156f, 0.08646006f, -0.03123306f, -0.01903780f, 0.07161519f, -0.09113848f, 
    0.18525821f, 0.25767145f, 0.03931711f, 0.24040735f, 0.00796777f, 0.00136285f, 0.02657486f, -0.00494171f, 
    -0.06500958f, -0.00139334f, 0.01182403f, -0.08649392f, 0.42869422f, -0.31907365f, 0.26359496f, 0.18960030f, 
    0.05596554f, 0.08203667f, -0.20524032f, -0.03076788f, 0.01444509f, 0.03394479f, 0.03930485f, 0.04550950f, 
    -0.07299708f, -0.14038680f, 0.32369149f, -0.39023885f, 0.03401889f, -0.03927713f, -0.02054970f, 0.07004727f, 
    -0.00409286f, 0.01843390f, -0.06616338f, 0.02137420f, -0.24577716f, 0.02829481f, 0.01807700f, -0.13942833f, 
    0.00618746f, -0.06210039f, -0.05419384f, -0.10759191f, -0.12819152f, 0.03685246f, 0.05840815f, -0.02191518f, 
    0.14095350f, -0.00202025f, -0.17661625f, -0.01542619f, 0.07483327f, -0.02726667f, 0.01002670f, -0.06629278f, 
    -0.02362096f, 0.07390148f, -0.09995245f, 0.08525866f, -0.11119532f, 0.10378916f, -0.10580146f, -0.10453307f, 
    -0.01426303f, -0.01787227f, 0.03758493f, 0.01714928f, -0.00931602f, -0.00360555f, 0.02766650f, -0.06333859f, 
    -0.29122186f, -0.10443243f, -0.04794114f, -0.07150800f, -0.00137293f, 0.00544132f, -0.05628568f, 0.00621163f, 
    0.01226269f, -0.11894444f, 0.14813094f, 0.11691000f, -0.15189545f, 0.01399734f, -0.05908028f, -0.00439489f, 
    0.05268295f, 0.04308609f, 0.03378415f, 0.09361581f, -0.11386153f, -0.03051247f, 0.04204980f, -0.06201652f, 
    -0.04152437f, 0.29736215f, 0.29844302f, 0.20985861f, 0.00346132f, 0.00634408f, -0.08449721f, 0.07906198f, 
    0.00853558f, -0.04421163f, -0.19031776f, -0.10343485f, -0.19644049f, 0.05814077f, -0.12703635f, 0.06399388f, 
    0.02605665f, 0.16064617f, -0.18296827f, 0.28861210f, -0.10198771f, 0.02426955f, 0.00379485f, 0.06161516f, 
    0.00279879f, 0.07339761f, -0.11149573f, -0.22390404f, -0.11848404f, 0.07701972f, -0.22343235f, -0.07386128f, 
    -0.00505017f, -0.00162417f, -0.06856450f, 0.18057059f, -0.43926868f, 0.05542437f, -0.13509727f, -0.18718055f, 
    -0.09012501f, 0.07843260f, -0.11492444f, -0.08828104f, -0.04565419f, -0.01816138f, -0.07345895f, 0.02282693f, 
    -0.01334269f, -0.24773908f, -0.09926055f, 0.09969553f, 0.10618140f, 0.03683148f, 0.01365501f, 0.00391045f, 
    0.10813098f, -0.07343160f, 0.09287788f, 0.01673888f, -0.04508598f, -0.19096066f, -0.16321450f, 0.07941773f, 
    0.07012817f, 0.08898333f, 0.05882507f, 0.17806789f, -0.02158012f, 0.04684969f, -0.05722867f, -0.12189288f, 
    0.06749906f, 0.08713859f, -0.06565469f, -0.40139312f, -0.03661637f, -0.08589627f, 0.00653942f, -0.07581693f, 
    -0.01960155f, 0.07203845f, -0.19998103f, -0.06191607f, -0.01067321f, -0.06547184f, -0.06873143f, 0.14068004f, 
    -0.03359426f, -0.10692508f, 0.06090625f, -0.01311226f, -0.06591003f, -0.07590655f, 0.00288633f, -0.12189814f, 
    -0.33578616f, -0.13570112f, 0.05877574f, 0.05916366f, -0.17027967f, 0.00198254f, -0.06513213f, -0.02176859f, 
    -0.07058564f, -0.01925924f, -0.06564002f, -0.11574320f, -0.02620138f, -0.11804625f, 0.01095258f, 0.20893750f, 
    0.02676901f, -0.03483018f, -0.02648101f, 0.05332639f, 0.01887137f, 0.04751306f, -0.03289487f, 0.02675656f, 
    0.00156573f, 0.32746923f, -0.10512678f, -0.32605127f, 0.06880993f, 0.06947633f, -0.04287982f, -0.08540481f, 
    -0.03763154f, -0.15565531f, -0.02954572f, 0.06654286f, -0.45324570f, 0.13967687f, 0.06420524f, 0.28553113f, 
    -0.03043629f, 0.11553008f, -0.01076033f, -0.08495751f, -0.01493290f, 0.00629064f, 0.16065970f, 0.08228885f, 
    -0.05747329f, -0.04898693f, -0.14317317f, 0.08787123f, 0.04261336f, 0.03969855f, -0.01700570f, 0.18510862f, 
    -0.05204010f, -0.04354282f, -0.03311572f, -0.07145551f, 0.47947687f, -0.10817999f, -0.10220546f, -0.07250892f, 
    0.16125570f, 0.02013599f, 0.05672692f, -0.18365423f, 0.01242332f, 0.02585943f, -0.03983054f, -0.00580806f, 
    -0.20068786f, 0.02828833f, 0.00577439f, 0.17743805f, 0.08372838f, -0.03630025f, 0.00450271f, -0.13491544f, 
    -0.09442756f, 0.02708855f, 0.01168084f, 0.04177542f, -0.37690172f, -0.23319386f, 0.03290567f, -0.15625499f, 
    0.00222810f, -0.04471832f, -0.02576602f, -0.05791419f, -0.09976888f, 0.13502340f, 0.07718340f, -0.05751936f, 
    0.10269315f, 0.00371770f, -0.06218830f, -0.08691014f, -0.02608294f, -0.11823229f, 0.01530615f, -0.08521840f, 
    -0.01271529f, -0.08069025f, -0.07049328f, -0.13854863f, -0.03278925f, 0.13618165f, 0.05645635f, 0.20428859f, 
    -0.20046903f, -0.01590951f, -0.05403475f, -0.04097516f, -0.13126093f, -0.09906005f, 0.23048700f, -0.16270038f, 
    -0.12847586f, 0.27648112f, 0.04755288f, 0.23865272f, 0.17864686f, -0.18934591f, -0.16854864f, -0.03426268f, 
    0.02050268f, -0.11281133f, 0.04052807f, -0.06177346f, -0.01853162f, 0.17161871f, -0.15546884f, -0.07165502f, 
    -0.13230598f, 0.09704492f, -0.16161591f, -0.06153659f, -0.09751876f, -0.15385546f, -0.17350784f, 0.13375148f, 
    -0.02675015f, -0.07490351f, -0.05234410f, -0.04916513f, 0.31931791f, 0.19322696f, 0.12508987f, -0.03276692f, 
    -0.35482159f, -0.04172016f, -0.15621872f, -0.12198303f, 0.55221069f, -0.07655390f, 0.05572255f, 0.15113097f, 
    0.17470442f, 0.04016905f, -0.04359756f, 0.02226610f, 0.05983984f, 0.03209791f, 0.02043473f, 0.05497064f, 
    0.16966499f, 0.03821199f, 0.06126875f, -0.26774350f, 0.08795954f, 0.17376234f, -0.00252070f, -0.00824654f, 
    -0.10037141f, -0.08609965f, -0.01741925f, 0.15252362f, 0.78171581f, -0.11634935f, 0.06543550f, 0.24894699f, 
    0.19102654f, -0.19013667f, 0.08403274f, -0.11392460f, -0.03365310f, -0.01573765f, -0.13204445f, 0.16162173f, 
    0.51476663f, -0.01435863f, -0.05967503f, 0.05590409f, -0.14861822f, 0.06327153f, -0.00528791f, -0.12508503f, 
    -0.05702009f, -0.17201430f, 0.18923919f, -0.03958684f, 0.00542238f, 0.08999372f, 0.48276863f, 0.28547853f, 
    -0.05767684f, -0.04464931f, 0.02652359f, -0.05287622f, 0.03505867f, 0.11710057f, 0.05374790f, 0.02747022f, 
    -0.15565650f, -0.02047536f, -0.31146300f, 0.29714242f, 0.05345643f, -0.03545239f, -0.23399188f, -0.09516161f, 
    -0.11846884f, -0.07841655f, 0.21635540f, -0.17219369f, 0.01879718f, -0.21769542f, 0.01921417f, 0.11384624f, 
    0.06910345f, 0.03132281f, 0.15976566f, 0.17434086f, -0.00628556f, -0.03507947f, -0.01638630f, -0.04827341f, 
    -0.08783985f, 0.04208490f, -0.16129638f, 0.14597091f, -0.01539514f, 0.12547043f, -0.10952716f, 0.08468482f, 
    -0.01366442f, -0.03512144f, 0.00006585f, -0.08320834f, -0.14436837f, 0.03183239f, -0.03304552f, 0.24210073f, 
    -0.00102588f, -0.11164451f, 0.15811263f, -0.28504229f, 0.04658096f, -0.03752011f, -0.03735977f, -0.00694974f, 
    -0.37119672f, 0.23434064f, -0.15056448f, -0.19563279f, 0.02748257f, 0.09315818f, -0.00999163f, 0.00943691f, 
    -0.07289707f, -0.08748199f, -0.00084737f, -0.09851787f, -0.12891389f, -0.00365712f, -0.03646991f, 0.05815845f, 
    -0.05208707f, -0.03063993f, -0.09093812f, -0.08178250f, -0.08433469f, -0.09865692f, -0.03003661f, -0.03117371f, 
    -0.29823026f, 0.30206186f, -0.03547496f, -0.11588268f, 0.05667684f, 0.08903394f, -0.03422149f, -0.11277940f, 
    -0.18793352f, 0.00709624f, 0.01931398f, -0.07257894f, -0.25055194f, -0.11174871f, 0.00690997f, 0.34569791f, 
    0.08292541f, -0.13843463f, -0.02910904f, -0.09989102f, 0.06487676f, -0.03929838f, 0.01133859f, -0.11120126f, 
    -0.24481161f, -0.08494940f, 0.00069838f, 0.17530274f, -0.00903594f, 0.04780798f, -0.07728566f, 0.09479917f, 
    0.07133123f, 0.18164633f, -0.08130042f, -0.01466940f, -0.04631642f, -0.08474385f, 0.06977562f, -0.01966544f, 
    0.20513469f, 0.10903226f, 0.01070032f, 0.09925885f, -0.06886358f, 0.07872891f, -0.09975483f, 0.06229783f, 
    -0.15007582f, -0.19771588f, -0.05637788f, 0.10248279f, 0.13197108f, 0.05321141f, 0.08431444f, -0.16522796f, 
    -0.03120728f, 0.04140279f, -0.03769872f, 0.03467257f, -0.19253194f, 0.17047532f, -0.21051946f, -0.19421197f, 
    0.11212279f, 0.10300594f, -0.03955344f, -0.00354285f, -0.24535885f, -0.07848067f, -0.01951992f, -0.07243864f, 
    -0.14018886f, -0.11905988f, 0.17042421f, 0.11982030f, -0.17212474f, -0.12904495f, 0.11979467f, 0.03020222f, 
    -0.05355153f, 0.16028824f, -0.13799365f, -0.02106177f, -0.19623286f, -0.21706049f, -0.14935327f, -0.00819342f, 
    0.00581991f, -0.09894005f, -0.18960778f, -0.23064664f, 0.10040171f, -0.06501283f, -0.03457372f, 0.13822375f, 
    0.15925533f, -0.03802428f, 0.20703699f, -0.08935405f, -0.16287030f, -0.09429536f, 0.13967727f, 0.08753283f, 
    -0.19113001f, -0.09852188f, 0.09944581f, -0.06220001f, 0.06602104f, -0.08691286f, -0.11579768f, 0.03531668f, 
    0.01751399f, 0.07062533f, 0.02470779f, -0.00568151f, -0.01823795f, -0.09948540f, -0.01236010f, 0.04036613f, 
    -0.51753300f, 0.55131954f, -0.08172823f, -0.23822248f, 0.05858059f, -0.01641949f, -0.02259995f, -0.09345245f, 
    -0.27302837f, 0.17914115f, -0.10195590f, -0.01383772f, -0.00292853f, -0.12941284f, -0.08390590f, -0.23820201f, 
    -0.00655362f, 0.00103039f, -0.05057322f, 0.06692299f, -0.11111157f, 0.08780529f, 0.01124048f, -0.07950781f, 
    -0.15494880f, -0.15575211f, 0.51585388f, -0.15743998f, -0.25983474f, -0.00821570f, -0.16148983f, -0.01664603f, 
    0.07301387f, 0.01929247f, -0.07793313f, -0.10482863f, 0.01693864f, -0.08497623f, -0.02485641f, 0.09495582f, 
    0.11827468f, -0.03249608f, 0.08558428f, 0.03379559f, 0.04275967f, 0.11342702f, -0.01056188f, 0.05672650f, 
    0.12340306f, -0.20469689f, 0.32868463f, 0.04141114f, 0.04710522f, 0.08824275f, -0.13113077f, 0.12535045f, 
    0.13010140f, -0.11419930f, 0.20038813f, -0.05486571f, -0.03457561f, -0.08769814f, -0.05479574f, 0.11827940f, 
    0.03375221f, 0.00650960f, -0.07029124f, 0.00846643f, 0.04291679f, -0.00064731f, 0.04532191f, -0.03221473f, 
    0.02415770f, 0.07292879f, -0.01342168f, 0.09684896f, -0.04024628f, 0.03704236f, 0.05159987f, 0.01892998f, 
    0.00937975f, 0.08426303f, 0.01656120f, -0.00044177f, 0.08561971f, -0.10916989f, 0.04327391f, 0.16045538f, 
    0.00656303f, -0.07006549f, 0.03019629f, 0.14066945f, 0.04380906f, 0.00884381f, 0.00913766f, 0.02111003f, 
    -0.17813534f, 0.15486507f, -0.03751388f, 0.04192870f, -0.02388441f, 0.04472981f, -0.01653177f, 0.00280203f, 
    -0.08204736f, 0.09642304f, 0.05521613f, 0.01681345f, 0.29323602f, 0.03345046f, -0.18544857f, -0.21482569f, 
    -0.08441839f, -0.17902099f, -0.02354788f, 0.05688564f, -0.04910063f, 0.13639565f, -0.00002674f, -0.11368608f, 
    -0.04789323f, -0.16788197f, 0.05948185f, 0.20773706f, -0.04259168f, 0.18390854f, -0.01935492f, 0.07853580f, 
    -0.00749038f, -0.04723803f, -0.15386942f, -0.02828678f, -0.14660940f, 0.21000525f, -0.05484866f, -0.23250715f, 
    0.35926670f, 0.13043959f, 0.11640409f, -0.19365661f, -0.07109314f, 0.06574310f, -0.04681066f, -0.04358084f, 
    -0.58301085f, 0.60143381f, -0.12201945f, 0.22815011f, 0.13116422f, -0.10985952f, 0.04540849f, -0.24769311f, 
    0.01140219f, -0.13593513f, 0.05299295f, -0.00049952f, -0.05041801f, 0.17182000f, -0.26635957f, -0.01491504f, 
    0.01611016f, -0.02134732f, -0.06678300f, -0.23201878f, 0.06118865f, 0.04540852f, 0.09667248f, -0.02821829f, 
    0.37500894f, 0.07102726f, -0.10839553f, -0.06254288f, 0.01677638f, 0.07835520f, -0.15194820f, -0.06992388f, 
    -0.11798942f, -0.09954064f, 0.00782396f, 0.15893790f, 0.19218183f, -0.21224928f, 0.04001977f, 0.14116971f, 
    0.12111118f, -0.01702110f, -0.01438325f, -0.16168916f, -0.00692794f, 0.07976282f, 0.09051292f, 0.08089428f, 
    -0.33504176f, -0.02468984f, 0.41599652f, -0.23032708f, -0.18225069f, -0.09888578f, -0.05150669f, -0.03950971f, 
    0.02111017f, 0.01815900f, -0.02782718f, 0.14025602f, -0.03174853f, -0.00967828f, -0.01242729f, 0.26272741f, 
    -0.08173147f, -0.03237540f, 0.10830360f, -0.02911841f, -0.02367583f, 0.13159277f, 0.10724323f, 0.04695178f, 
    0.12324357f, 0.04720288f, -0.10274935f, -0.32991257f, 0.00611277f, -0.06218795f, -0.07266652f, 0.02556435f, 
    -0.05781610f, 0.09570420f, -0.06008236f, -0.10721405f, -0.09264031f, 0.54694492f, 0.05965534f, 0.31208959f, 
    0.06064756f, -0.00928884f, 0.11013503f, -0.12846985f, -0.01865948f, 0.08101721f, -0.05282122f, 0.04868887f, 
    -0.39849520f, -0.07796617f, -0.02820904f, -0.04612139f, 0.07475398f, -0.14019278f, -0.06849492f, 0.04787450f, 
    -0.12856996f, 0.09102810f, 0.00647437f, 0.02472609f, -0.24250720f, -0.14230964f, -0.04766655f, -0.84141183f, 
    0.23938532f, 0.06305591f, -0.01856597f, 0.00090990f, -0.15072657f, -0.04374505f, -0.01807151f, -0.04481666f, 
    0.22750007f, -0.02228280f, 0.00042054f, 0.26422542f, 0.13552661f, 0.01287387f, -0.06781778f, 0.01768424f, 
    0.01218713f, 0.09977134f, 0.14959982f, 0.07017191f, -0.04248529f, 0.27703828f, -0.09365211f, -0.23690261f, 
    -0.13394634f, -0.10610916f, -0.19235492f, 0.02695335f, -0.04950291f, 0.02154206f, 0.10221341f, -0.15018322f, 
    -0.10840399f, -0.09838030f, -0.13415736f, 0.13993205f, -0.31425029f, -0.16209681f, 0.07111487f, -0.20214713f, 
    -0.12719662f, -0.05760362f, -0.00330424f, -0.09531050f, 0.10829261f, 0.00858847f, 0.05489634f, 0.14879145f, 
    -0.02574077f, -0.07932723f, 0.10549387f, -0.00103843f, -0.03792597f, 0.04087986f, -0.03651138f, -0.01697636f, 
    0.08695786f, 0.08291917f, 0.18326610f, 0.13815111f, -0.12941781f, -0.15174468f, 0.00060819f, 0.10923998f, 
    0.09360543f, 0.10465831f, 0.01618838f, 0.00628046f, 0.09087057f, 0.04767448f, 0.16719382f, 0.12738492f, 
    -0.02481752f, 0.01896413f, -0.10572609f, -0.02742524f, 0.18768990f, -0.09544154f, -0.00784322f, 0.00367245f, 
    -0.28207135f, -0.12805673f, -0.23357251f, 0.23820347f, -0.07958127f, 0.06778488f, -0.10245358f, -0.20889427f, 
    -0.04463125f, -0.05064668f, 0.04035370f, -0.04020145f, -0.03536210f, -0.03204505f, -0.03093381f, -0.02963844f, 
    -0.16742037f, -0.01731358f, -0.25885120f, -0.10562985f, 0.05259043f, 0.01560002f, -0.05812497f, -0.03557204f, 
    -0.11542344f, -0.08777307f, -0.12914464f, 0.03194014f, 0.06677046f, 0.00043266f, -0.04277855f, 0.01389906f, 
    -0.20383486f, -0.12821226f, 0.01189857f, -0.09700467f, -0.04796870f, 0.10497662f, 0.06753150f, 0.06313694f, 
    -0.04672049f, -0.09044457f, -0.04929602f, -0.05811657f, 0.05661131f, -0.02110493f, 0.05941445f, 0.01224135f, 
    -0.17165548f, -0.29594216f, 0.07555056f, 0.11588606f, -0.15697205f, -0.12791617f, 0.07906081f, 0.08770498f, 
    0.00799560f, 0.21184248f, 0.04900564f, 0.16635019f, 0.01469921f, -0.13527314f, 0.23908766f, 0.03553179f, 
    0.02729521f, -0.05622648f, -0.02356115f, -0.19440247f, 0.18532853f, -0.17687079f, -0.01213440f, 0.16891825f, 
    0.07706248f, 0.04556389f, 0.23939076f, 0.01564017f, -0.08346114f, 0.05865877f, 0.07915898f, -0.09034724f, 
    0.20645778f, 0.00273435f, 0.00148020f, 0.03501222f, 0.03388917f, -0.07790013f, -0.08047897f, 0.06965445f, 
    -0.03484428f, -0.00467368f, 0.01303127f, 0.07982782f, 0.03760589f, -0.13968933f, -0.04276818f, 0.05552018f, 
    -0.17693780f, 0.02725565f, 0.04556282f, 0.02219094f, -0.04404412f, -0.08801382f, -0.09007126f, -0.00840785f, 
    -0.02040449f, 0.01523981f, -0.08854114f, 0.06501140f, -0.26246381f, -0.00855937f, -0.12497760f, 0.03947106f, 
    0.06625096f, 0.00985897f, 0.00233394f, 0.02406180f, -0.04785137f, 0.01634968f, -0.05382056f, -0.05132461f, 
    -0.13986798f, 0.02886705f, 0.09590614f, -0.00109179f, -0.10667612f, 0.06179767f, -0.05815892f, -0.03380971f, 
    -0.00523097f, -0.05889814f, -0.00519893f, -0.12083333f, -0.14128479f, 0.04900860f, -0.09346469f, 0.09050612f, 
    0.00781372f, 0.08606325f, -0.19158812f, -0.12509786f, 0.03139925f, 0.03918107f, -0.01990237f, -0.00021120f, 
    -0.28443474f, 0.00805728f, -0.16126175f, -0.30525005f, 0.07860019f, 0.03666375f, 0.03271177f, 0.05076448f, 
    -0.01962790f, -0.05622367f, -0.06004674f, -0.15635957f, 0.25447679f, 0.00359649f, -0.30205935f, 0.00080584f, 
    0.05369153f, 0.00581566f, 0.02673280f, -0.04271679f, 0.11069011f, -0.02000005f, -0.00448281f, -0.29116583f, 
    0.08604369f, 0.10500977f, 0.04652110f, 0.11105639f, 0.08994115f, 0.05582963f, 0.07021526f, 0.07659084f, 
    0.13690509f, 0.01408664f, -0.04216738f, -0.01610762f, 0.03089995f, 0.08065071f, 0.10025974f, 0.05812177f, 
    -0.01852091f, -0.11020201f, 0.01048606f, -0.15554762f, 0.04658654f, -0.14860110f, -0.01279263f, 0.06706399f, 
    0.15937528f, -0.01054904f, -0.10416968f, 0.18311702f, -0.03752212f, 0.01809302f, 0.11140348f, 0.00872662f, 
    -0.18144217f, -0.07092807f, -0.13871005f, -0.24003711f, -0.15299824f, -0.11605484f, -0.11215203f, -0.06891420f, 
    -0.07396112f, -0.24434607f, -0.01580815f, 0.11483303f, -0.04172445f, -0.12731782f, 0.13809940f, 0.10971992f, 
    0.17460641f, -0.17567272f, -0.04556425f, -0.06329022f, 0.08760062f, -0.04157497f, 0.17780304f, 0.18247414f, 
    0.10754034f, 0.02133697f, -0.00573485f, 0.10094555f, 0.10813770f, 0.15124629f, -0.18394388f, 0.13884401f, 
    0.07803435f, -0.01816528f, 0.04562763f, 0.19878434f, -0.11257368f, 0.00997187f, -0.04006864f, 0.02898164f, 
    0.01146333f, -0.01260031f, -0.09120612f, -0.04696403f, 0.06612562f, -0.04568030f, 0.07927545f, -0.02356779f, 
    0.01868578f, -0.02083343f, -0.13632958f, -0.05920977f, 0.02938143f, 0.21133624f, 0.25786701f, 0.10831123f, 
    -0.01148401f, 0.02778710f, 0.01906717f, 0.12581323f, 0.04940767f, 0.03000925f, 0.00239460f, -0.00174952f, 
    -0.04352176f, 0.03243118f, 0.18945287f, -0.07344728f, 0.05896618f, 0.04638828f, -0.07329420f, 0.08402644f, 
    -0.14243552f, 0.01667423f, -0.00213383f, 0.02637050f, 0.07552776f, -0.13874100f, -0.03389378f, -0.02648411f, 
    -0.00792413f, 0.02074131f, -0.08621215f, 0.11644512f, -0.25876001f, -0.05093671f, -0.02915094f, -0.08175809f, 
    0.07296652f, -0.13544805f, -0.01189205f, 0.11781324f, 0.03631604f, -0.04042032f, 0.00763707f, -0.04793167f, 
    0.09482941f, 0.26854050f, 0.09218164f, 0.25790563f, -0.06686547f, 0.00372013f, 0.06093231f, 0.05287743f, 
    -0.01396624f, 0.04245990f, 0.02816933f, -0.00952692f, 0.07522728f, 0.01783043f, -0.01886146f, -0.04689923f, 
    -0.04263338f, -0.13356136f, -0.24212064f, 0.01350304f, -0.09290891f, -0.09134427f, 0.06902513f, -0.00385814f, 
    -0.01616967f, 0.05313662f, 0.00247797f, 0.18000299f, -0.18258938f, 0.18244772f, -0.02120560f, 0.02698004f, 
    0.08628489f, -0.06116784f, -0.09470148f, 0.08318317f, -0.09836593f, 0.05319231f, 0.05282311f, -0.10075692f, 
    -0.18228616f, 0.20876859f, -0.20737512f, 0.01929464f, -0.03134185f, -0.03618345f, 0.01944596f, -0.14897330f, 
    0.17528413f, 0.00983364f, -0.05382388f, 0.23058693f, 0.32692757f, 0.15796962f, 0.00463759f, 0.20978612f, 
    -0.03370938f, -0.01312565f, -0.00058881f, -0.12272059f, 0.09041470f, -0.10513398f, -0.24024782f, 0.04230671f, 
    0.07907745f, 0.08042801f, 0.04214756f, 0.03695525f, -0.10278946f, -0.06147552f, -0.01459235f, 0.03990218f, 
    -0.01384633f, -0.13621517f, -0.00947365f, 0.01192808f, 0.09116518f, -0.27499315f, 0.08664591f, 0.03216518f, 
    -0.03831324f, -0.02004421f, -0.02253987f, 0.00886316f, 0.03904978f, -0.10531382f, -0.05278587f, -0.13940470f, 
    0.01845775f, 0.19683543f, -0.19978392f, 0.03571514f, 0.05960053f, -0.00226657f, -0.03610433f, -0.02127115f, 
    0.00600156f, 0.00565249f, 0.05495936f, 0.03711744f, 0.06040830f, 0.00593537f, 0.07075272f, 0.11870239f, 
    -0.14833446f, 0.11684360f, -0.07333907f, 0.02148859f, 0.05712500f, -0.04152761f, 0.04108651f, -0.06618854f, 
    -0.04861567f, 0.31004789f, -0.34343019f, 0.02940998f, 0.09599900f, 0.01815669f, -0.12184747f, -0.17744735f, 
    -0.00363909f, 0.10055017f, -0.08675069f, 0.08444366f, -0.14332338f, 0.01792785f, 0.01197017f, 0.10342450f, 
    -0.04571999f, -0.02548902f, 0.03005989f, -0.04752651f, 0.00476431f, 0.01713346f, -0.02749971f, 0.09766787f, 
    0.04187791f, -0.58501059f, -0.04526419f, 0.09380720f, 0.01543136f, 0.09035885f, 0.10969835f, -0.25665095f, 
    -0.26093894f, -0.05758549f, -0.03791985f, -0.11449014f, 0.14380482f, -0.19180058f, 0.10966506f, 0.03864095f, 
    -0.14867496f, -0.00898872f, -0.23773882f, -0.04909734f, -0.15832360f, -0.09910355f, -0.10944768f, -0.08022302f, 
    0.27713656f, 0.21349223f, -0.11150011f, 0.20138831f, -0.09210090f, -0.00566971f, 0.09432053f, -0.23221321f, 
    0.06747911f, 0.00073546f, 0.06033856f, -0.04552446f, 0.01286640f, -0.03540017f, 0.11611284f, 0.15009499f, 
    -0.12121208f, -0.07642348f, -0.12673588f, -0.07312707f, 0.05162591f, -0.00979931f, 0.03434389f, 0.07874553f, 
    -0.06836276f, 0.21239321f, 0.13787968f, 0.26277083f, 0.08574574f, 0.13178471f, 0.04327923f, 0.04996423f, 
    0.06502312f, 0.01385092f, -0.00762220f, -0.05138527f, 0.13691011f, 0.07205334f, 0.11353163f, 0.15796228f, 
    -0.04809036f, -0.12278675f, -0.11274815f, 0.01046761f, 0.01333408f, 0.09437256f, 0.01263565f, 0.03672460f, 
    0.02273757f, 0.06142403f, 0.10944995f, 0.14948468f, 0.00213743f, -0.07084741f, -0.07242832f, -0.10475727f, 
    -0.00300228f, -0.04184551f, 0.11057625f, 0.03534540f, 0.02074252f, 0.32781032f, 0.24432638f, 0.27572551f, 
    -0.00439670f, 0.15701753f, -0.06436583f, 0.13958792f, -0.00653355f, -0.03601829f, -0.00684753f, -0.09437149f, 
    -0.08227284f, -0.11081113f, -0.01069907f, -0.06616087f, -0.03593854f, -0.09250052f, -0.07772659f, -0.03467437f, 
    -0.04060202f, 0.03550196f, -0.11128350f, 0.08525904f, -0.25735250f, -0.00154638f, 0.06158834f, -0.13772748f, 
    0.07026552f, -0.12417295f, -0.09107944f, -0.13015328f, -0.05618482f, -0.27052346f, -0.04833487f, -0.20081072f, 
    0.11537898f, 0.25258055f, 0.16572128f, 0.05421166f, 0.12018409f, 0.13966554f, 0.01495102f, 0.18837324f, 
    0.02298769f, -0.01869276f, -0.00688382f, -0.11452723f, -0.13381907f, -0.11354849f, 0.09699899f, 0.04436298f, 
    -0.13237558f, -0.06147752f, -0.04583114f, 0.02045644f, -0.16050896f, -0.09161302f, -0.12661660f, 0.05364081f, 
    0.14036617f, -0.25491953f, 0.41150969f, -0.39284366f, -0.08666442f, 0.03870004f, -0.04310829f, 0.00288796f, 
    -0.00868409f, -0.05142161f, -0.00339237f, 0.05787197f, -0.16285999f, -0.14141428f, 0.12095877f, 0.03542062f, 
    -0.22715661f, 0.08450441f, -0.20184033f, 0.02484426f, -0.01793586f, 0.00723250f, -0.04855159f, 0.02072946f, 
    -0.31754795f, -0.17646573f, -0.09905533f, 0.06617165f, -0.10958092f, -0.09874783f, 0.03371025f, -0.23217407f, 
    -0.13286002f, -0.01194368f, -0.02037523f, 0.09219881f, 0.05319471f, 0.01887574f, 0.01120599f, 0.13256684f, 
    -0.08181286f, -0.07686514f, 0.05914982f, -0.11310257f, 0.04282390f, 0.01536096f, 0.00410895f, 0.07946490f, 
    0.23405541f, -0.14875498f, -0.88163829f, 0.18594445f, 0.05262652f, 0.03735357f, -0.01109153f, -0.01681587f, 
    0.03339103f, 0.08641528f, 0.08904415f, -0.04077916f, 0.04274172f, 0.05449757f, 0.35755309f, 0.02140680f, 
    -0.02235732f, 0.16055304f, -0.06189905f, -0.02641570f, 0.08007527f, -0.02607945f, -0.14571257f, 0.06872598f, 
    -0.27935624f, 0.03228148f, 0.10907053f, 0.00701940f, -0.10496219f, -0.09652773f, -0.04098336f, 0.10536944f, 
    0.00206333f, -0.09131888f, 0.00743524f, -0.10410838f, 0.26210746f, -0.26472893f, 0.21228161f, -0.31291395f, 
    0.02984726f, 0.03433552f, -0.00585520f, 0.14911419f, 0.02383262f, 0.05987357f, 0.03474235f, -0.08808037f, 
    -0.08645367f, -0.24321015f, -0.12769528f, -0.13491893f, 0.08163156f, 0.03420852f, 0.06361090f, -0.01684132f, 
    -0.03954150f, 0.02772543f, 0.00945774f, -0.08493442f, 0.15279862f, 0.00973416f, -0.05582594f, 0.01879681f, 
    0.04009256f, -0.01571972f, 0.07405281f, 0.04425507f, -0.05441279f, -0.14035995f, -0.26312211f, -0.15660506f, 
    -0.11486192f, 0.01618762f, 0.04224228f, 0.06636508f, 0.06818859f, -0.04948683f, -0.16451636f, 0.08183959f, 
    0.02084057f, -0.03105357f, -0.16137670f, -0.16920172f, 0.03745874f, -0.11200401f, 0.11663894f, 0.04971484f, 
    -0.03549166f, -0.28713056f, -0.06010628f, -0.09203646f, -0.35878691f, -0.02568655f, -0.25384909f, -0.13583063f, 
    -0.18088417f, -0.11536282f, 0.02578444f, -0.05006813f, 0.13211702f, -0.15067193f, -0.12124469f, -0.08938596f, 
    0.07976794f, 0.03915004f, 0.01231419f, -0.25587258f, -0.04519122f, 0.03194585f, 0.16855052f, 0.09521454f, 
    0.09418967f, 0.01598741f, 0.09215745f, -0.05380085f, -0.00338100f, 0.03891918f, 0.03568632f, -0.01546376f, 
    0.09659545f, 0.03431021f, -0.03252940f, 0.08515785f, 0.26650387f, 0.05871919f, 0.12271468f, 0.07106610f, 
    -0.09210614f, -0.04482686f, 0.00177179f, 0.05918786f, 0.06892450f, 0.09723163f, -0.08120666f, -0.03136241f, 
    0.01338047f, -0.04058634f, 0.10170395f, -0.05389117f, -0.00960048f, -0.03869160f, -0.05086851f, -0.03132775f, 
    0.21567850f, -0.16180691f, 0.26822969f, 0.25936785f, -0.12389166f, -0.03721971f, -0.03013198f, 0.16216108f, 
    -0.00391957f, 0.06515813f, -0.09580819f, 0.01731724f, -0.02237923f, 0.05430327f, -0.11417861f, -0.17319758f, 
    0.20971985f, 0.00413983f, -0.11896855f, 0.09452228f, 0.08426324f, -0.02157000f, -0.09442630f, 0.08443768f, 
    0.07662413f, 0.00356136f, 0.11734512f, 0.00338498f, -0.06320793f, -0.04492401f, -0.07691374f, -0.00207257f, 
    0.31143990f, -0.06694829f, -0.02918470f, 0.08493919f, -0.24242945f, -0.01905661f, -0.04367375f, -0.36846232f, 
    0.15274583f, 0.01779932f, 0.06644075f, -0.13107689f, 0.00588006f, 0.02305019f, -0.00086515f, -0.00150781f, 
    -0.13262075f, 0.07178237f, 0.09098634f, 0.00953474f, 0.08696879f, -0.11249536f, -0.10912251f, 0.06677423f, 
    -0.00322541f, -0.10056713f, -0.20311950f, -0.06319301f, 0.04732605f, -0.00975792f, -0.17762481f, -0.37082872f, 
    0.01346083f, 0.08174968f, -0.00219336f, 0.10805152f, -0.01690461f, -0.08895639f, -0.03322454f, -0.39680469f, 
    0.23647162f, -0.15853031f, 0.12994176f, 0.08940458f, -0.00245378f, -0.04506753f, 0.11834867f, -0.02685070f, 
    -0.06229145f, -0.00681766f, 0.03629366f, -0.00460627f, -0.49700084f, -0.12305709f, -0.04351631f, -0.00464692f, 
    -0.08399724f, -0.05960327f, 0.03194240f, 0.00421183f, 0.07854091f, -0.06349524f, -0.00382254f, -0.01316495f, 
    0.18781687f, -0.02583297f, -0.25731066f, -0.18983839f, 0.11748815f, 0.04442447f, -0.11741620f, 0.07867195f, 
    -0.05976925f, 0.01669733f, 0.03093027f, 0.00435353f, 0.22770540f, -0.17581844f, -0.27106971f, -0.01476226f, 
    0.02341491f, 0.00931366f, -0.07778197f, 0.02493646f, 0.09467383f, -0.06371743f, 0.06163185f, 0.09783593f, 
    0.05432959f, 0.00973203f, 0.03288199f, 0.04621950f, -0.11565342f, -0.04016750f, 0.01461710f, -0.02859781f, 
    0.08642013f, 0.06845241f, 0.05406297f, -0.01563454f, 0.32285789f, 0.09822132f, -0.22022702f, 0.04854963f, 
    -0.03906402f, -0.06601227f, -0.01786669f, 0.03164588f, 0.11685347f, -0.12835158f, -0.18978599f, -0.01766405f, 
    -0.06894936f, -0.09148519f, -0.28070667f, 0.01888612f, -0.00274682f, 0.08391806f, -0.05993922f, -0.03346202f, 
    0.08919033f, 0.01197809f, 0.01748444f, 0.07743459f, -0.21233219f, -0.12151799f, -0.28546262f, 0.20607109f, 
    0.16408743f, -0.11002944f, 0.09392683f, 0.02392673f, 0.03816260f, 0.12196741f, 0.12956353f, 0.18045051f, 
    -0.00841614f, -0.11206986f, -0.05701110f, 0.00470020f, -0.11565309f, -0.01356783f, -0.16143923f, -0.05906277f, 
    0.11753383f, -0.16892254f, -0.07582346f, -0.01424281f, -0.29113284f, -0.35615560f, -0.30271974f, 0.18977028f, 
    -0.08550560f, -0.01875022f, 0.00687761f, -0.07149900f, 0.18812589f, 0.04586579f, -0.04954892f, 0.01185993f, 
    -0.04208564f, -0.35508206f, 0.16546082f, 0.17896776f, -0.11366527f, -0.06572991f, -0.08469229f, 0.02169186f, 
    0.19221942f, 0.00628943f, 0.22132081f, -0.04226390f, -0.33720163f, 0.08662318f, -0.41114870f, -0.03107512f, 
    0.06089426f, -0.07045714f, -0.02405290f, 0.14968483f, -0.06647622f, -0.05298930f, -0.06932349f, -0.06131075f, 
    0.00085788f, -0.22405218f, -0.01597940f, 0.12401235f, 0.02969040f, -0.29455060f, -0.03031631f, 0.12866831f, 
    -0.18347338f, 0.10775156f, -0.09620011f, -0.08965530f, -0.04310269f, 0.01752485f, -0.20426334f, -0.15257719f, 
    -0.01457791f, -0.04760726f, -0.04204497f, 0.04973696f, 0.04372213f, -0.15644173f, 0.08818773f, -0.07218554f, 
    -0.06592473f, 0.01434464f, -0.37181395f, -0.09607539f, -0.05218716f, 0.02197226f, -0.09991053f, -0.05016181f, 
    0.20412083f, -0.09426352f, 0.03423525f, 0.21876948f, 0.01427755f, 0.16431618f, 0.06851918f, -0.17718124f, 
    0.18171842f, -0.02408112f, -0.05469315f, -0.31321046f, 0.03846098f, -0.00558604f, -0.03435256f, -0.01815058f, 
    0.09986816f, 0.10618214f, 0.21771733f, -0.18596809f, 0.01705439f, 0.12828355f, 0.00013203f, -0.15857409f, 
    0.11618261f, -0.03730101f, -0.00930291f, 0.14139974f, -0.04112841f, -0.08947144f, 0.09977353f, -0.13166675f, 
    -0.01949429f, -0.12914482f, -0.06334607f, 0.21061687f, 0.10458689f, 0.05946894f, -0.08073885f, 0.07124380f, 
    0.00587585f, -0.00562904f, 0.14363711f, 0.02864940f, 0.03053638f, 0.00376324f, -0.00280225f, 0.00097154f, 
    0.06624597f, -0.10105195f, -0.05682654f, 0.01755446f, 0.28141454f, 0.07253068f, 0.02964048f, 0.14403205f, 
    -0.09846175f, -0.00489708f, 0.00142038f, 0.07790875f, 0.00701272f, 0.12269021f, -0.11229314f, 0.16892228f, 
    -0.10816213f, -0.03831917f, 0.07265762f, 0.10397265f, -0.00223270f, -0.01804275f, -0.00955933f, 0.08339784f, 
    0.08636195f, 0.03421646f, -0.34324798f, -0.14934464f, 0.01226354f, 0.19651277f, -0.34887040f, -0.43860510f, 
    0.05132163f, 0.02991273f, -0.03081041f, 0.01051585f, 0.09802896f, -0.02596246f, -0.03183411f, 0.10108195f, 
    0.28806731f, -0.01953813f, -0.13736425f, -0.12703533f, 0.07229348f, 0.04407901f, 0.02763677f, 0.07280544f, 
    -0.19454673f, -0.09235580f, -0.27817246f, -0.53625715f, -0.21194786f, -0.09486114f, 0.10181929f, -0.10488576f, 
    -0.05782827f, 0.06428675f, 0.01418868f, -0.14549984f, 0.12450409f, 0.00903995f, 0.20416664f, 0.02082152f, 
    -0.30079350f, -0.22632909f, -0.11208051f, -0.24488313f, 0.05970928f, -0.04354085f, -0.05162350f, 0.21354537f, 
    -0.02806590f, -0.11567542f, 0.00430909f, 0.00170501f, -0.07064728f, 0.18838847f, -0.19467649f, -0.14061417f, 
    0.01259229f, -0.02270799f, -0.08442207f, 0.03127614f, 0.10474224f, 0.00242768f, -0.05467459f, 0.00417138f, 
    0.15247902f, -0.01160217f, -0.34735242f, 0.08195763f, 0.00204159f, 0.06346396f, -0.17081462f, 0.08688017f, 
    -0.02541045f, -0.24807575f, 0.18524681f, -0.21720774f, 0.03406610f, -0.06176646f, -0.01680646f, -0.02987803f, 
    -0.10346978f, -0.03488769f, 0.06148033f, 0.04518189f, 0.00828178f, 0.08699644f, -0.05612633f, -0.03012356f, 
    -0.10939526f, -0.15930007f, -0.07607745f, 0.16030546f, 0.01901483f, 0.01109439f, -0.17008713f, 0.15409635f, 
    0.15444618f, -0.20382617f, 0.09159399f, -0.01907949f, -0.20685694f, 0.32939306f, 0.00684122f, -0.02280633f, 
    -0.01184896f, -0.04007022f, 0.00618686f, 0.18908642f, 0.05883228f, 0.08363235f, 0.02085999f, -0.04019549f, 
    -0.24585734f, -0.27015537f, 0.25747621f, -0.00538634f, 0.05135589f, -0.04234024f, -0.08343107f, 0.19789322f, 
    0.15454297f, -0.07782737f, 0.03661807f, -0.09306481f, 0.31572980f, 0.00526160f, 0.16867739f, 0.09632397f, 
    0.03392037f, 0.02114872f, 0.10249278f, -0.05628441f, 0.06715333f, 0.10859001f, -0.03857966f, 0.03898634f, 
    -0.21981110f, 0.04119870f, -0.27726072f, 0.24705179f, 0.13225967f, 0.05495575f, -0.04740024f, 0.04531075f, 
    -0.00702283f, -0.07120722f, -0.04607669f, -0.00048977f, 0.11162850f, -0.09074111f, -0.02834659f, -0.04649178f, 
    -0.07052393f, -0.04080975f, 0.00064594f, -0.04367198f, 0.09958483f, -0.19470212f, -0.03015878f, -0.20894328f, 
    -0.19597137f, 0.10143053f, -0.11387865f, 0.00675071f, 0.07672078f, -0.14350845f, 0.06084382f, -0.34643897f, 
    -0.07165913f, 0.15627159f, 0.00204137f, -0.03570790f, -0.10939216f, 0.22091198f, 0.01453323f, -0.11646377f, 
    0.10959630f, 0.25556898f, 0.22567806f, -0.05889662f, 0.04036578f, 0.01808973f, 0.03744222f, 0.06851468f, 
    0.14068174f, 0.10972433f, 0.11034404f, -0.06923991f, 0.04338243f, -0.03037898f, -0.05667067f, -0.01256262f, 
    0.00556469f, -0.08549565f, -0.05719232f, -0.12544592f, 0.12270977f, -0.03476470f, 0.11105178f, -0.15989341f, 
    0.14712176f, 0.09657473f, -0.04609046f, -0.28325212f, 0.00953521f, -0.10081410f, 0.00671607f, -0.01902324f, 
    -0.13027023f, 0.04618579f, 0.01048199f, -0.01005430f, -0.10375895f, 0.02354499f, 0.03530291f, -0.11408257f, 
    -0.06676453f, -0.06891186f, -0.02557610f, 0.07856990f, 0.20485625f, -0.07518258f, 0.00826670f, 0.23887199f, 
    -0.06762213f, 0.09795042f, -0.09134633f, 0.21824455f, -0.15170188f, -0.10458808f, 0.19544885f, 0.16514638f, 
    0.08303624f, -0.00599687f, 0.06160837f, 0.06899716f, -0.08550157f, 0.12607236f, -0.10898252f, 0.02753201f, 
    0.00177633f, 0.00395542f, 0.08991618f, 0.05379305f, -0.46118739f, 0.04041057f, -0.09478354f, -0.10760760f, 
    0.06421945f, 0.04653906f, 0.07052158f, 0.18494992f, 0.10538162f, 0.17853202f, -0.05258166f, -0.03220933f, 
    0.09350824f, 0.01055798f, 0.30083653f, -0.26454529f, -0.02855348f, 0.11590251f, -0.01432722f, -0.18733573f, 
    0.04420866f, 0.00501666f, -0.04175849f, -0.14409123f, 0.12875776f, 0.10922019f, -0.05988970f, -0.13398811f, 
    0.19355930f, -0.05194303f, 0.18952847f, 0.11164727f, 0.00057565f, 0.05280459f, 0.02261539f, 0.07927511f, 
    -0.05725347f, 0.00041693f, 0.10874075f, 0.01055163f, -0.08545783f, -0.07225029f, 0.07507522f, 0.11458317f, 
    0.10506766f, -0.03643616f, -0.17619200f, -0.09795061f, -0.48830685f, 0.30560547f, -0.00988402f, -0.18377145f, 
    -0.10276140f, -0.06986015f, 0.06274857f, 0.16276345f, -0.06984883f, -0.15296572f, 0.00307346f, 0.00210453f, 
    0.11938785f, 0.00667048f, -0.34655711f, 0.10500970f, 0.03904968f, 0.08688149f, -0.03080849f, 0.01116136f, 
    0.06777453f, -0.14264755f, 0.01201811f, -0.13444324f, -0.06396647f, 0.04496953f, 0.02812954f, -0.22444783f, 
    -0.05665333f, -0.21388961f, -0.06076815f, 0.00643828f, -0.03042789f, -0.06873029f, 0.04147616f, -0.10725518f, 
    0.34989700f, -0.07498453f, -0.09436960f, 0.41817877f, 0.04705849f, -0.04037121f, -0.10235267f, 0.04114527f, 
    0.05308237f, -0.10842502f, 0.08903655f, -0.01537636f, -0.21200880f, -0.33328044f, -0.07029767f, -0.03226344f, 
    0.05669995f, 0.06983516f, -0.04522816f, 0.01371276f, -0.01789031f, -0.02739171f, 0.00318914f, 0.02464719f, 
    0.06446388f, -0.34819925f, -0.20706390f, 0.16501939f, 0.01447720f, -0.05163715f, -0.02061250f, 0.04034054f, 
    0.11654688f, -0.29796576f, 0.06872137f, -0.02347329f, -0.10782788f, -0.15681542f, 0.02942681f, 0.04301253f, 
    -0.01706768f, -0.01157369f, -0.03459082f, -0.01791615f, 0.04452184f, -0.08716549f, 0.14691924f, 0.06693724f, 
    -0.06968962f, -0.07439872f, -0.17294732f, -0.02469797f, -0.09844314f, 0.08171805f, 0.05248710f, -0.08307063f, 
    0.01227333f, 0.12023045f, 0.13643599f, 0.28129941f, 0.31623068f, -0.14205064f, 0.08721139f, 0.01625907f, 
    0.10348436f, 0.11991718f, 0.23226398f, 0.04488053f, 0.13455379f, -0.05253164f, -0.04299163f, 0.24155080f, 
    -0.18662132f, 0.10183334f, -0.08489325f, 0.24496907f, -0.02124312f, -0.10093618f, -0.19956295f, 0.45550549f, 
    -0.10615869f, 0.11640644f, 0.13925575f, 0.15950367f, 0.12811951f, -0.06561007f, 0.02075044f, 0.00070045f, 
    -0.08192270f, -0.00941122f, 0.13078651f, -0.01462423f, 0.11852952f, -0.01406909f, 0.16247243f, -0.02970119f, 
    -0.48516569f, -0.07637673f, -0.32947722f, -0.36552134f, -0.41319439f, 0.01902959f, 0.00125712f, -0.19174606f, 
    0.02607754f, 0.01177215f, 0.00590982f, -0.07492872f, -0.11245760f, 0.12156600f, -0.08092163f, -0.15475591f, 
    -0.19709729f, -0.12576135f, -0.18438867f, -0.08569607f, 0.11972750f, -0.07407894f, 0.02168742f, -0.03677391f, 
    0.22426537f, -0.41732728f, -0.34765157f, 0.11430379f, -0.26900271f, 0.16288006f, 0.23048043f, 0.12130879f, 
    0.02625262f, 0.03227844f, -0.06539267f, 0.02671589f, 0.16635841f, 0.19503045f, -0.03934247f, -0.11009715f, 
    -0.01560395f, -0.09411805f, -0.08153874f, 0.05552483f, 0.02527615f, -0.02997871f, -0.09710947f, -0.03936426f, 
    0.09354030f, 0.14766540f, 0.00398319f, 0.10407259f, 0.09955826f, -0.14472716f, 0.06378958f, 0.06559937f, 
    -0.07058743f, -0.01474570f, -0.04680819f, -0.03604090f, -0.38665000f, -0.56836617f, -0.15121253f, -0.34000936f, 
    0.10305311f, -0.12690543f, -0.10661875f, -0.36343235f, -0.04979631f, 0.04790557f, -0.04272706f, 0.01821943f, 
    -0.07132295f, 0.00055001f, 0.05876293f, -0.10420556f, 0.04143354f, -0.06389306f, 0.14195707f, -0.05341579f, 
    0.17444535f, 0.12192742f, 0.11829218f, 0.06368372f, 0.26710850f, 0.55781609f, -0.23638685f, -0.06746439f, 
    0.08684390f, 0.05914907f, 0.07102024f, -0.10788136f, 0.12308005f, 0.04489589f, 0.02144428f, 0.09922608f, 
    -0.43817988f, 0.18421829f, 0.08929765f, -0.31689778f, -0.01620993f, 0.01554567f, -0.16056894f, -0.08442624f, 
    0.03797715f, -0.10513985f, 0.05628666f, 0.05238783f, -0.24810094f, 0.23305622f, 0.30110422f, 0.25160339f, 
    -0.04838632f, -0.06118057f, -0.14042057f, 0.15507294f, -0.14325522f, -0.00950274f, 0.19937442f, 0.01438410f, 
    -0.14012276f, 0.35993481f, 0.19429874f, -0.00327086f, -0.18127924f, 0.16352545f, -0.06184453f, -0.02660391f, 
    0.14027946f, 0.00930053f, 0.00979641f, 0.03671463f, 0.00409074f, -0.01869085f, 0.12924707f, -0.08542881f, 
    0.00278154f, 0.01367459f, -0.01772033f, -0.00340269f, -0.02499474f, -0.03342395f, -0.00185851f, -0.02311862f, 
    -0.00346034f, -0.19102713f, -0.33590958f, -0.03266617f, -0.10652775f, 0.03686550f, -0.07602945f, 0.14108139f, 
    -0.05608177f, 0.01418119f, -0.03968732f, -0.11559365f, 0.52356142f, 0.18094406f, -0.29534957f, -0.10120451f, 
    -0.07221846f, -0.08849765f, 0.08983046f, 0.26680094f, 0.13818431f, 0.09347349f, 0.04741278f, -0.01771478f, 
    -0.36748785f, -0.05249418f, 0.15438040f, -0.30538067f, 0.02186456f, 0.00701136f, -0.03156219f, -0.02032658f, 
    -0.01480641f, -0.01635389f, 0.01578984f, 0.08944289f, 0.07888412f, -0.06627999f, -0.06712954f, -0.16757101f, 
    0.04398166f, -0.00698511f, 0.04226675f, -0.04570743f, 0.01030541f, 0.07562388f, -0.01458084f, -0.04488746f, 
    -0.07443473f, -0.01834199f, -0.10086111f, 0.00844632f, -0.02988913f, -0.02246100f, -0.11493238f, -0.02499716f, 
    -0.24131672f, -0.07528631f, -0.11145958f, 0.05579388f, -0.19317050f, 0.06404756f, 0.16838180f, 0.32307306f, 
    -0.08860692f, -0.05489963f, -0.11452136f, 0.09282482f, -0.01055795f, -0.04935481f, 0.05615890f, 0.04953056f, 
    -0.00097093f, -0.07963882f, 0.00656381f, -0.04329684f, -0.09392908f, 0.00010840f, -0.03262619f, 0.08455887f, 
    -0.03603486f, 0.11768021f, -0.01402250f, -0.05866973f, 0.09380934f, -0.05799278f, 0.05090669f, 0.30990094f, 
    -0.09005211f, 0.08451070f, 0.02028134f, 0.09541100f, 0.15248059f, -0.10659929f, 0.11219145f, 0.04574859f, 
    0.07606363f, 0.02371904f, -0.07030806f, 0.12537320f, -0.16190684f, 0.12486263f, 0.09265748f, 0.22679728f, 
    0.02915111f, 0.04351177f, 0.02746689f, -0.06699883f, 0.06565803f, -0.14551950f, 0.02490635f, -0.08088195f, 
    0.05807156f, 0.08981045f, 0.04484076f, 0.06322718f, -0.07623765f, -0.01232317f, -0.02602839f, 0.07690784f, 
    0.21331988f, -0.03947665f, -0.10708887f, 0.08863558f, 0.05278721f, -0.03366926f, 0.01712934f, 0.00624909f, 
    0.04141146f, 0.05754314f, -0.06737371f, -0.12225389f, -0.61045140f, -0.50453430f, -0.46801263f, 0.27854827f, 
    -0.18189618f, -0.11436425f, -0.20075242f, -0.30904976f, -0.03693031f, -0.08461306f, -0.01892477f, -0.00436774f, 
    -0.27737314f, -0.42946520f, -0.21188970f, 0.31698054f, -0.17051396f, -0.22801039f, -0.14315465f, -0.06005126f, 
    -0.02185313f, 0.00415345f, -0.02109382f, 0.01660748f, 0.08081780f, 0.05586797f, -0.07265905f, -0.06364591f, 
    -0.06184506f, -0.13552009f, 0.06139414f, 0.22687361f, 0.04541638f, -0.04686732f, -0.00963133f, 0.00469186f, 
    -0.24914236f, 0.10880058f, 0.20499189f, -0.04597504f, -0.04811850f, 0.04759200f, -0.04262220f, 0.02821101f, 
    0.20085764f, 0.11038788f, 0.15869041f, 0.02910426f, -0.01314280f, -0.49751803f, -0.27391958f, 0.25098181f, 
    0.00652886f, -0.03211628f, 0.00836559f, 0.05863021f, -0.01400924f, 0.03739030f, 0.00435394f, 0.03616102f, 
    -0.04206549f, 0.04607506f, -0.22316219f, -0.24235800f, -0.01195579f, -0.00430844f, -0.02848904f, 0.04823750f, 
    -0.00401863f, 0.03428844f, 0.18790270f, 0.14087158f, 0.04153165f, -0.12240509f, 0.31533927f, -0.15383139f, 
    0.13990563f, -0.17470147f, 0.14428072f, -0.07685426f, -0.03336432f, -0.00178103f, 0.10371169f, -0.02327699f, 
    0.03475125f, 0.09403384f, 0.01934722f, 0.01458383f, 0.00544643f, 0.04361837f, 0.12350072f, 0.00834028f, 
    0.06892909f, -0.00029444f, 0.22078542f, 0.09608029f, -0.45028964f, 0.17041443f, 0.41576993f, 0.08673797f, 
    0.01200029f, -0.05809343f, -0.08868504f, -0.13824488f, -0.02373245f, -0.00177451f, -0.05067586f, -0.09043868f, 
    -0.49349216f, 0.34375748f, 0.27273318f, 0.13165319f, -0.03490591f, 0.02717168f, -0.02294073f, 0.08193931f, 
    -0.08055776f, 0.05654910f, 0.03926460f, 0.06926102f, -0.20323384f, 0.02815207f, 0.20305587f, -0.17299622f, 
    -0.01227889f, -0.01622226f, -0.05262001f, 0.08181165f, -0.10335201f, 0.15513802f, -0.04790919f, 0.05395153f, 
    0.16120455f, -0.00751443f, 0.10974240f, -0.17753489f, -0.03365885f, 0.00583482f, 0.24139619f, -0.20803292f, 
    0.13253188f, 0.05271176f, 0.08656920f, 0.13003372f, -0.01646207f, -0.15047958f, -0.02996601f, 0.10290077f, 
    -0.02507759f, 0.05136655f, -0.06589717f, 0.06140949f, -0.05030885f, -0.08443531f, -0.02358354f, 0.01226288f, 
    0.23456128f, -0.07096820f, 0.05753961f, -0.09199168f, -0.06536870f, 0.06795717f, 0.15484418f, -0.06271330f, 
    0.00670656f, 0.00454682f, 0.19357790f, -0.02590900f, -0.41585833f, -0.39344540f, -0.50193053f, 0.20203985f, 
    -0.14994773f, 0.10757115f, -0.01205155f, -0.11779808f, 0.00163866f, -0.03839444f, 0.03457280f, 0.00229913f, 
    -0.09958929f, -0.11413775f, 0.02218201f, 0.36123577f, 0.13894510f, -0.00695149f, -0.00919838f, 0.10425717f, 
    -0.04944408f, 0.06726482f, 0.08069777f, 0.08606820f, -0.24596761f, 0.07545855f, 0.18789238f, -0.25719312f, 
    -0.04573224f, -0.07321393f, -0.18498924f, 0.03988958f, -0.03865958f, 0.05708022f, -0.03249377f, 0.01140872f, 
    0.18904522f, -0.23510474f, -0.28635636f, -0.22325853f, -0.04385402f, 0.15476532f, 0.22192934f, 0.14389117f, 
    -0.08020394f, -0.00569671f, -0.00676788f, 0.09017131f, -0.23161300f, 0.34224832f, -0.03298647f, -0.06885432f, 
    -0.04360843f, 0.10923002f, -0.10435371f, 0.10673974f, -0.01789930f, 0.02314119f, 0.12678891f, 0.02868205f, 
    -0.00053028f, -0.13442488f, -0.35792041f, -0.46017322f, 0.06995381f, 0.03013450f, 0.06371446f, 0.06778198f, 
    -0.06933981f, 0.00337326f, 0.02558045f, -0.10280214f, -0.59617233f, -0.65667385f, -0.12483096f, 0.06646788f, 
    -0.24145438f, -0.36364958f, -0.21316680f, -0.47384691f, -0.04373447f, 0.00210061f, -0.08737739f, -0.01068430f, 
    0.11542321f, -0.28010747f, -0.12286784f, -0.38230115f, 0.17887485f, 0.00066393f, -0.09256675f, -0.00694240f, 
    0.00234063f, 0.18175481f, -0.02258572f, -0.08519512f, -0.17726065f, -0.61910397f, -0.06740521f, -0.36126021f, 
    -0.00976384f, 0.02277291f, -0.03128495f, -0.14345472f, 0.00669164f, 0.01727295f, -0.02934567f, 0.00356402f, 
    0.02297993f, -0.36480400f, 0.13565074f, -0.04032261f, 0.09291653f, 0.02369899f, 0.13542104f, -0.14401409f, 
    0.02959697f, 0.07966852f, 0.07745229f, -0.13318238f, 0.01355723f, 0.08237172f, -0.35633615f, -0.24783434f, 
    -0.01130238f, -0.09468707f, 0.17745873f, 0.02545546f, -0.07768372f, 0.09563103f, -0.02308997f, 0.07914760f, 
    -0.37018603f, -0.56603909f, -0.41125044f, 0.30696765f, 0.03361587f, 0.02908470f, 0.18544230f, -0.14846860f, 
    0.05432543f, -0.10015093f, -0.00403286f, 0.05322840f, -0.07538681f, -0.03230971f, 0.25139466f, 0.07718284f, 
    -0.01265580f, 0.13364422f, -0.01241886f, -0.12095249f, 0.03590501f, 0.02014528f, 0.07811939f, -0.10603437f, 
    -0.19072486f, -0.06754588f, 0.09628107f, 0.31806535f, 0.12740624f, 0.12996243f, 0.06946927f, 0.12775177f, 
    0.04930363f, -0.04373667f, 0.12550744f, -0.04461259f, -0.32395333f, -0.25234374f, -0.43355852f, 0.14305961f, 
    -0.19279896f, -0.01021573f, -0.10852171f, -0.05689921f, 0.03358295f, -0.00162828f, -0.05242719f, 0.07139585f, 
    -0.16970015f, -0.58241719f, -0.35734022f, -0.17502216f, -0.20819396f, 0.09555546f, -0.00294183f, 0.03779033f, 
    0.00547877f, 0.01350215f, 0.11120290f, -0.01091327f, -0.85109937f, -0.30580062f, 0.01372468f, -0.36785451f, 
    -0.23246120f, 0.01326831f, 0.25601420f, -0.00739723f, -0.03734717f, 0.05098175f, -0.00462345f, 0.05240329f, 
    0.01079759f, -0.15832858f, -0.11190514f, -0.13022342f, 0.01719885f, 0.06432210f, 0.01292127f, -0.03537529f, 
    0.02655079f, 0.07191803f, 0.03282433f, -0.02882315f, -0.09835333f, -0.26607648f, -0.29655242f, 0.24742135f, 
    -0.10127244f, 0.20113981f, 0.04610405f, 0.02591204f, 0.12889056f, 0.00786301f, 0.02040301f, 0.06858952f, 
    0.09968087f, -0.05403872f, -0.19791207f, -0.08117192f, -0.01872647f, 0.00108085f, -0.02526407f, 0.05300225f, 
    -0.12391391f, 0.05709819f, 0.14708479f, -0.05526690f, -0.38151085f, -0.36823967f, -0.14770772f, -0.08874130f, 
    0.00320202f, 0.00798517f, 0.01253247f, -0.00392018f, -0.04612929f, 0.06021259f, -0.07141919f, 0.02939835f, 
    0.04573636f, 0.06604055f, 0.07336973f, -0.01483045f, -0.02436239f, -0.04698210f, 0.10467152f, -0.00617288f, 
    -0.04498954f, 0.14762445f, 0.00712537f, 0.07098611f, -0.11811795f, -0.02882801f, 0.03243366f, -0.01407315f, 
    0.05253981f, -0.02394155f, -0.02654848f, 0.04124262f, 0.09991236f, -0.04022372f, 0.07606360f, 0.10515033f, 
    -0.17117707f, -0.07674868f, 0.16012175f, 0.45160639f, -0.06133845f, -0.22516455f, 0.03100974f, -0.00446370f, 
    -0.05503063f, 0.01438168f, -0.02462599f, -0.11948201f, -0.12896152f, -0.16019437f, 0.18440814f, 0.26592562f, 
    0.07726099f, -0.09492080f, 0.05705664f, -0.20568138f, -0.04241445f, -0.13132238f, -0.04448456f, -0.06599467f, 
    0.03406991f, 0.05902917f, 0.06286696f, 0.35338983f, -0.04223070f, -0.06604005f, 0.30993095f, -0.08951560f, 
    0.04725524f, 0.18466313f, -0.06739131f, -0.08052244f, -0.54820168f, -0.50548565f, -0.13281634f, -0.39219913f, 
    -0.08063976f, -0.16167776f, -0.01137859f, -0.19637574f, -0.05768552f, 0.02398589f, 0.00144421f, -0.06264533f, 
    -0.30097064f, -0.28934944f, -0.24411656f, 0.01518911f, 0.12303989f, -0.02566251f, 0.05978944f, 0.06359862f, 
    0.03104497f, 0.06349306f, 0.03037978f, -0.00415117f, -0.07089406f, -0.10566244f, -0.04358310f, -0.00388424f, 
    0.13072722f, -0.08452778f, 0.01025543f, -0.04739028f, -0.07142012f, 0.01703685f, 0.06063343f, 0.01493799f, 
    0.14107315f, -0.50079751f, -0.03294588f, 0.06220587f, -0.07687421f, -0.02729338f, -0.00757844f, -0.03473007f, 
    -0.01875680f, 0.05974159f, 0.06480546f, -0.04647673f, -0.16846785f, 0.03526939f, -0.08717946f, 0.04381659f, 
    -0.01011550f, -0.13770925f, 0.08299352f, -0.08336589f, -0.00655438f, 0.02860766f, -0.01038745f, 0.03976253f, 
    -0.06276302f, -0.09231648f, 0.04105707f, -0.07770491f, -0.10071755f, 0.10499328f, 0.02567779f, -0.00600856f, 
    0.02607580f, -0.02739409f, 0.07033460f, -0.11759593f, -0.15698579f, -0.24817243f, 0.00263585f, -0.16737029f, 
    0.05769869f, 0.03946067f, -0.05193979f, 0.20559591f, 0.02613739f, -0.02755393f, -0.00724367f, 0.05664000f, 
    0.20113587f, 0.13349389f, -0.18929140f, 0.12004964f, 0.02204739f, -0.10704356f, -0.06874690f, -0.04348895f, 
    0.10533739f, 0.01258556f, -0.01673789f, -0.07117308f, -0.05192225f, -0.33065075f, 0.32378823f, 0.03952823f, 
    -0.08949395f, -0.11350153f, 0.14862187f, 0.00026766f, -0.13970807f, 0.03400287f, 0.03413007f, -0.03535701f, 
    -0.32264701f, -0.15585953f, -0.16148724f, 0.16513869f, 0.12477227f, -0.04762093f, 0.05411304f, -0.04617814f, 
    -0.02726771f, -0.07521334f, 0.09415249f, 0.03646525f, 0.55199254f, -0.38997146f, -0.17974140f, -0.30503270f, 
    0.01643793f, -0.06470952f, 0.00209763f, -0.10944006f, 0.01559608f, 0.04640393f, 0.04430286f, -0.06552947f, 
    -0.40592170f, -0.16746013f, -0.08821223f, -0.04194172f, -0.02715515f, -0.15047099f, 0.18620843f, -0.11608821f, 
    -0.07278650f, -0.05503117f, -0.02957823f, 0.00739442f, -0.02657523f, 0.01056519f, 0.03918962f, -0.08087898f, 
    0.01563973f, 0.06502938f, -0.00011363f, 0.00027892f, -0.03322105f, -0.05936156f, 0.06997398f, -0.03786188f, 
    -0.01062939f, -0.12036129f, 0.06154268f, 0.10980634f, -0.13011175f, -0.03604743f, -0.35970244f, -0.04902355f, 
    0.06615160f, -0.00181693f, -0.00291186f, -0.01423139f, -0.18175115f, 0.10743172f, -0.02341840f, 0.09360269f, 
    -0.04389774f, 0.00087594f, 0.06693633f, -0.00704765f, -0.10409119f, 0.02846758f, 0.15884481f, -0.07923382f, 
    -0.15655684f, 0.14280920f, -0.18125498f, 0.06131354f, 0.03943462f, 0.02829359f, 0.06890057f, -0.01126328f, 
    0.03506680f, 0.03371953f, 0.02361001f, -0.04385323f, 0.01962041f, 0.11364552f, 0.08394568f, 0.10754155f, 
    0.00258500f, 0.01809261f, 0.04424693f, 0.03591149f, -0.01786800f, 0.08177442f, 0.02754441f, -0.06572133f, 
    0.03387331f, 0.01647498f, 0.01397339f, -0.09250324f, -0.01771144f, 0.07608514f, 0.05052003f, 0.02657842f, 
    0.02922244f, -0.01028312f, 0.07402780f, -0.04252816f, 0.24054030f, -0.06092841f, -0.18859871f, -0.25427002f, 
    0.01259923f, -0.07905104f, 0.00453619f, 0.01163551f, 0.00659462f, 0.02244948f, 0.07840160f, -0.01057677f, 
    0.20206450f, -0.00439108f, -0.06005984f, -0.27416906f, -0.00235118f, 0.10796887f, 0.01648784f, -0.00661104f, 
    -0.05673664f, 0.06732120f, 0.05108565f, -0.36580384f, 0.11848159f, -0.11694795f, -0.16656698f, 0.05220091f, 
    -0.01418392f, 0.10987548f, 0.12477863f, -0.05941971f, 0.03952403f, 0.01688915f, -0.13990071f, 0.07752477f, 
    0.39296421f, -0.10869760f, 0.00415982f, -0.07532551f, -0.10193498f, 0.04927702f, -0.16154297f, -0.15583655f, 
    -0.06865573f, -0.08517294f, 0.03630399f, -0.01330194f, 0.03773698f, 0.11467909f, -0.04147966f, 0.05929008f, 
    0.01153906f, 0.01413067f, -0.03095087f, 0.03560336f, -0.01296802f, -0.10890394f, 0.10786051f, 0.07631907f, 
    -0.05151220f, 0.01801871f, 0.09884375f, -0.01999791f, 0.03826782f, -0.00940373f, 0.04546457f, -0.06392130f, 
    0.05423011f, -0.07298160f, 0.01784831f, -0.04575677f, -0.34633446f, -0.19631584f, 0.12473432f, 0.28532696f, 
    0.17182273f, 0.12554073f, 0.08297010f, 0.14627866f, 0.01255023f, -0.03896970f, -0.03023513f, -0.03031935f, 
    -0.19645715f, -0.19321218f, 0.50145704f, -0.09244109f, -0.03724016f, 0.04793878f, 0.03719823f, 0.18084501f, 
    -0.07887336f, 0.00007223f, -0.03777167f, -0.01102067f, 0.00303567f, 0.00883046f, 0.04118660f, -0.03424020f, 
    -0.03100530f, -0.06211630f, -0.00322553f, -0.03183641f, -0.06541211f, 0.05715071f, -0.02778753f, -0.02281903f, 
    0.17559944f, -0.02443344f, 0.02673722f, -0.32983997f, 0.01066787f, 0.01478801f, 0.00569286f, -0.01471673f, 
    0.07160484f, 0.16649657f, 0.06444220f, -0.00744645f, -0.25808173f, -0.30535600f, -0.02167620f, 0.21744344f, 
    -0.17095521f, -0.03706746f, -0.11208677f, -0.05742989f, -0.04954129f, -0.07184404f, -0.05379966f, 0.04007382f, 
    0.26268473f, -0.33008468f, -0.12046220f, -0.22157907f, 0.02290011f, -0.04618985f, -0.07160642f, -0.01897320f, 
    0.08367995f, 0.16518420f, 0.09859331f, 0.11075987f, 0.09597182f, 0.45180938f, 0.46855721f, -0.19266991f, 
    -0.10811207f, 0.05600891f, 0.06593639f, -0.03971322f, -0.09866664f, -0.01981441f, -0.07770446f, -0.04692001f, 
    -0.01004420f, 0.04106221f, -0.06657925f, 0.03935859f, 0.01838436f, -0.06932490f, -0.05732528f, -0.04993742f, 
    -0.03889050f, -0.04367376f, -0.02308148f, 0.02240217f, 0.53951424f, -0.53724414f, -0.18958008f, -0.47381660f, 
    -0.06698204f, -0.02268340f, -0.03791006f, 0.09049010f, 0.04422893f, -0.01993647f, -0.03191278f, 0.06089316f, 
    0.40079561f, -0.60049260f, -0.18075341f, -0.22475687f, -0.11406507f, -0.07749224f, -0.07316750f, 0.04339686f, 
    0.09843200f, -0.02351556f, 0.00644659f, 0.02120856f, 0.05920889f, 0.09363537f, -0.08347819f, -0.09336120f, 
    0.00568971f, -0.00731862f, 0.05701615f, -0.07837093f, -0.03032243f, 0.07758016f, 0.00834411f, -0.04760956f, 
    -0.11524248f, 0.12285995f, 0.00991988f, 0.25225329f, -0.08873990f, 0.05465493f, 0.12493443f, 0.04321506f, 
    -0.18161945f, 0.02305215f, 0.04296672f, 0.06643656f, 0.00812578f, -0.00021592f, 0.07260370f, -0.05246954f, 
    -0.01666789f, -0.12992892f, -0.08273679f, -0.00576145f, 0.04263965f, 0.07014196f, 0.05475850f, -0.01525244f, 
    -0.01229575f, 0.13151923f, 0.01202561f, 0.12261674f, -0.01663722f, -0.02212898f, 0.00041240f, -0.10020789f, 
    -0.18660830f, 0.05098634f, -0.19540426f, 0.00825078f, -0.03274852f, -0.02907353f, 0.21216346f, -0.17430961f, 
    0.00725623f, -0.15801533f, -0.08268476f, 0.12157657f, -0.02565696f, -0.09613954f, -0.06642711f, 0.06183475f, 
    0.24317999f, -0.08137054f, 0.14391413f, -0.15858798f, 0.00805480f, 0.02271998f, -0.08794860f, 0.11471968f, 
    -0.08623011f, 0.10179237f, -0.01133153f, -0.18433042f, 0.17500685f, 0.03080050f, -0.01551786f, -0.00781313f, 
    0.03703910f, 0.02781759f, -0.00484177f, -0.00746613f, -0.00662853f, -0.01801049f, -0.05945378f, 0.01132568f, 
    -0.13041328f, 0.22081046f, -0.22398610f, -0.10829923f, -0.04859377f, 0.02427620f, -0.06870610f, 0.08754589f, 
    0.02020889f, 0.08206855f, 0.09476109f, 0.00601261f, 0.20389213f, -0.27658892f, -0.43535784f, -0.28765789f, 
    -0.09336699f, -0.17356040f, -0.01290270f, 0.07271063f, 0.12649828f, -0.06200059f, 0.03949043f, -0.03995345f, 
    -0.22335620f, 0.13909428f, -0.43235534f, 0.23697971f, -0.06406490f, -0.13749436f, 0.00184227f, 0.08850687f, 
    0.03453461f, -0.02608594f, 0.00613571f, -0.01560154f, -0.30635110f, -0.42296192f, -0.11648215f, -0.08364143f, 
    0.11298075f, -0.15593171f, -0.00258197f, 0.07549240f, 0.02980812f, 0.01830995f, 0.04746717f, 0.05402675f, 
    -0.41364101f, -0.07755952f, 0.00808502f, 0.36137986f, 0.06457309f, -0.02821367f, -0.05271060f, -0.07764845f, 
    -0.02098075f, -0.17389302f, 0.02107881f, -0.02210014f, -0.48601213f, 0.00807223f, 0.08922368f, 0.26363692f, 
    -0.00987789f, 0.02162020f, -0.03789528f, 0.00801152f, 0.09248228f, -0.04363329f, -0.03666731f, -0.05726678f, 
    0.07992015f, -0.61640197f, -0.01388122f, -0.27374882f, -0.09602819f, 0.06140645f, -0.02182395f, 0.16481440f, 
    -0.02194968f, -0.05121008f, -0.02551449f, -0.00669090f, 0.10984465f, 0.17539452f, -0.36225444f, 0.13517703f, 
    0.08349934f, -0.01820130f, -0.03014775f, -0.24185812f, -0.04605191f, -0.08102219f, -0.04273002f, 0.13476647f, 
    -0.31155738f, -0.06732179f, 0.44170764f, -0.09954347f, 0.02091914f, 0.03135021f, 0.12297204f, 0.08006825f, 
    -0.00390189f, -0.02863547f, 0.02412311f, 0.00362292f, 0.13502298f, 0.08864269f, 0.08841983f, -0.04459745f, 
    0.02066524f, -0.06293302f, -0.15068255f, 0.00005760f, -0.00767146f, -0.09485478f, 0.12059049f, -0.11612291f, 
    -0.15574026f, 0.02267809f, 0.09360071f, -0.09855118f, 0.02732398f, 0.07497275f, 0.08716716f, -0.04766370f, 
    0.06558046f, 0.02404299f, 0.03143342f, -0.05317847f, 0.18088752f, -0.28213459f, -0.27320176f, -0.23865815f, 
    -0.05517400f, -0.07108657f, -0.06525938f, 0.04818961f, 0.05394387f, 0.04096331f, 0.02468734f, -0.02969677f, 
    0.24301118f, -0.03539611f, -0.31970453f, 0.17524742f, 0.05642367f, -0.03240583f, -0.09918007f, 0.08775906f, 
    0.02370125f, 0.01391597f, -0.04084734f, 0.00567089f, -0.14346232f, -0.36435160f, 0.00849160f, -0.14657608f, 
    0.08033662f, 0.03520344f, 0.13998142f, 0.11391646f, 0.02474009f, -0.04556969f, -0.00159182f, -0.01929891f, 
    -0.11257600f, 0.09840592f, 0.04700850f, -0.05113673f, 0.03003613f, 0.02280165f, -0.00399770f, 0.01051721f, 
    0.03309438f, -0.02405816f, 0.07068586f, -0.01470263f, -0.11137550f, -0.14789627f, 0.31826958f, -0.24507369f, 
    0.05144766f, 0.16576792f, 0.10019751f, -0.01164335f, -0.10782737f, -0.00824666f, -0.00495847f, 0.09714600f, 
    0.00208067f, 0.05705044f, 0.04354516f, 0.04088729f, -0.12307428f, 0.01708578f, 0.00381610f, -0.11746086f, 
    -0.04707497f, 0.01099613f, -0.01844989f, -0.04382093f, 0.00919003f, 0.11047835f, -0.03022109f, -0.11216580f, 
    0.03755483f, -0.11582923f, -0.00097396f, 0.01386881f, -0.00347354f, -0.01641676f, -0.02156149f, -0.02604314f, 
    -0.00673513f, -0.03495962f, 0.04019801f, -0.05339624f, -0.01332700f, 0.01164408f, -0.04210240f, -0.02412045f, 
    0.05056965f, -0.18440171f, -0.11292890f, -0.18270001f, 0.08227549f, 0.01281928f, 0.03930410f, -0.21562256f, 
    0.01665423f, 0.04581274f, 0.00716530f, 0.00548551f, -0.10256199f, -0.07548837f, -0.23170184f, -0.24662817f, 
    -0.45431361f, -0.19639225f, -0.51299530f, -0.33103901f, -0.02687839f, -0.08075546f, 0.16777492f, 0.02377591f, 
    0.04455549f, -0.06265660f, -0.03518111f, 0.01922062f, 0.16307810f, -0.21184567f, 0.07940118f, -0.15202691f, 
    -0.11354778f, 0.11669281f, -0.01175576f, -0.05799365f, -0.03795753f, 0.08428558f, -0.06300391f, 0.01044706f, 
    -0.13695164f, 0.03443757f, 0.04226363f, -0.14939086f, 0.04923387f, 0.11065087f, 0.09241005f, -0.20282058f, 
    0.01242356f, 0.04245335f, -0.04466304f, 0.04889871f, -0.28926420f, -0.27660805f, -0.29491344f, 0.30600044f, 
    0.02608445f, 0.03371080f, -0.01111018f, 0.00871334f, -0.05409615f, -0.04576457f, -0.00779988f, 0.03543664f, 
    0.04048905f, -0.32187301f, -0.36376402f, 0.13581795f, -0.03691485f, -0.00442811f, -0.11562236f, 0.04846526f, 
    -0.03669684f, -0.09959139f, -0.07648268f, -0.04974578f, -0.05851790f, -0.15110220f, -0.08264351f, -0.05618671f, 
    -0.01156820f, -0.04631489f, -0.01308704f, 0.11264352f, -0.15356480f, -0.09226651f, -0.14552049f, -0.02182718f, 
    0.49014524f, 0.17961161f, -0.20631994f, -0.04488045f, 0.32013211f, -0.08442817f, -0.01595454f, -0.04811952f, 
    -0.09907398f, 0.10343014f, 0.05907370f, 0.14052938f, -0.13989122f, -0.10464568f, 0.01943227f, 0.09459208f, 
    0.03820550f, 0.02777919f, 0.07675368f, -0.04602787f, 0.00577113f, 0.03895862f, 0.12367468f, 0.06621674f, 
    0.00952859f, -0.03125190f, 0.08101853f, 0.18236275f, 0.04169669f, 0.03335234f, -0.01332149f, -0.06004637f, 
    0.08855094f, 0.18059178f, -0.02478113f, 0.15331349f, -0.15674822f, -0.40016535f, -0.38647029f, -0.09376339f, 
    -0.11304976f, 0.01787437f, 0.03857110f, -0.09282581f, -0.06169485f, 0.05529741f, 0.05381396f, 0.07555322f, 
    0.16828680f, 0.02937026f, -0.16581625f, -0.02796977f, 0.02004613f, 0.08543338f, 0.03323277f, 0.04163431f, 
    -0.00686418f, -0.05706827f, -0.09068581f, -0.24047172f, -0.61214846f, -0.06994074f, -0.13675451f, 0.32459426f, 
    0.04003753f, 0.11619677f, -0.14256291f, -0.04998909f, -0.07728390f, 0.14656451f, -0.08894061f, -0.00956678f, 
    0.28087634f, -0.43750292f, -0.33778691f, 0.00261484f, 0.00783206f, 0.15602022f, 0.05293701f, 0.11391526f, 
    -0.12396362f, 0.08669697f, 0.06409121f, -0.06849164f, -0.05200816f, -0.30796766f, -0.38386208f, -0.19034633f, 
    0.04059253f, 0.09093673f, 0.12406277f, 0.00931135f, 0.20197931f, 0.10421408f, -0.07085592f, -0.05900275f, 
    0.02295210f, -0.29794312f, 0.02745759f, 0.07231298f, 0.06792410f, 0.13918261f, 0.00328487f, 0.06844530f, 
    -0.01217552f, -0.09774579f, -0.02822218f, -0.18368778f, -0.30341932f, 0.11123371f, 0.11807410f, 0.06135454f, 
    0.01458910f, -0.12958446f, -0.00477074f, -0.03941388f, -0.03734953f, -0.01324622f, 0.00623196f, 0.02005897f, 
    0.13064128f, 0.02616542f, -0.08332717f, -0.01374549f, 0.15015954f, -0.18264025f, -0.05618116f, -0.00546436f, 
    0.02314023f, 0.15738273f, 0.11618390f, 0.16385657f, -0.45002401f, -0.06288977f, 0.08203015f, -0.02619736f, 
    0.02581762f, 0.04497481f, 0.00768091f, 0.09054489f, -0.11341191f, -0.19219004f, -0.07120175f, 0.14867491f, 
    -0.44643098f, -0.04827779f, 0.10287521f, 0.14326979f, -0.03432442f, -0.00949514f, -0.07010630f, -0.05753274f, 
    0.05149902f, 0.01141152f, 0.04761999f, 0.09351702f, -0.15237848f, 0.08540185f, 0.13349788f, 0.00739468f, 
    0.03752530f, 0.01691296f, -0.11204519f, -0.01106057f, -0.08409133f, 0.13640749f, -0.05157486f, 0.08386751f, 
    -0.08462032f, -0.01214027f, -0.05823301f, -0.07608221f, -0.07444172f, -0.08729658f, -0.02147039f, -0.05180058f, 
    0.09216353f, 0.03943969f, 0.09596945f, 0.13461868f, -0.18086413f, -0.16493173f, -0.13760932f, -0.03202104f, 
    -0.03123655f, 0.13861357f, 0.09103918f, 0.13523020f, 0.10136287f, 0.08339068f, 0.03185515f, 0.05599440f, 
    0.05687514f, 0.08872663f, -0.25327787f, -0.12100800f, 0.02696928f, -0.06151670f, 0.01375934f, -0.01383069f, 
    0.14409824f, 0.13721174f, 0.07101353f, 0.22006543f, -0.20321371f, -0.11521792f, 0.18321317f, 0.38291404f, 
    0.02912801f, 0.18947811f, -0.09607807f, 0.00173034f, -0.17804317f, -0.01784714f, 0.17923808f, -0.28093582f, 
    0.23894924f, 0.02232128f, -0.13215598f, -0.14655535f, 0.14053908f, 0.15409210f, -0.04086286f, 0.03798224f, 
    -0.02228510f, -0.01358435f, 0.01901334f, 0.07419639f, -0.35002717f, -0.03585655f, 0.06722216f, 0.11121276f, 
    -0.04522292f, -0.07311073f, -0.23270290f, -0.00599077f, -0.10661010f, -0.03481320f, -0.12447578f, -0.10302987f, 
    -0.25372782f, 0.00965003f, -0.00003250f, 0.05992699f, -0.03682780f, 0.00705566f, 0.00794367f, 0.03070407f, 
    -0.01940844f, 0.10789834f, 0.01271140f, 0.06551731f, -0.09359516f, -0.41034225f, -0.24944234f, -0.25723967f, 
    -0.16372240f, -0.05749857f, -0.01174661f, -0.00749910f, 0.05318317f, 0.00972610f, 0.04539188f, -0.01144956f, 
    0.34984833f, 0.13580441f, -0.20193084f, 0.02729545f, -0.13870116f, -0.17970741f, -0.06462111f, -0.11225051f, 
    0.11803330f, 0.00171014f, 0.04442276f, 0.04235967f, 0.02679633f, -0.18916970f, -0.03897847f, -0.01852714f, 
    0.07295080f, 0.03048430f, 0.03050557f, 0.04180891f, 0.11955927f, -0.01251643f, 0.16865732f, 0.08953178f, 
    0.01878438f, -0.17520797f, -0.20551209f, -0.15544455f, -0.05219577f, -0.01533274f, 0.00657975f, -0.05097287f, 
    -0.02890253f, -0.00944070f, -0.02793025f, -0.25283968f, 0.13964814f, -0.11114967f, -0.13485605f, 0.06144142f, 
    0.16236033f, 0.04822371f, 0.01419639f, 0.12545395f, 0.03889863f, -0.01564967f, 0.11765014f, 0.07694333f, 
    -0.13549051f, -0.11286478f, -0.10099921f, -0.16186310f, 0.01641781f, 0.02381302f, -0.00341652f, 0.01166163f, 
    0.06756569f, -0.07815529f, 0.04094059f, -0.08310573f, -0.50232720f, -0.34832460f, 0.16212735f, 0.32249627f, 
    0.02356979f, 0.01531695f, 0.19651929f, 0.02740522f, 0.02397268f, 0.01970438f, 0.18927878f, 0.16691057f, 
    -0.19902298f, 0.04546890f, 0.15098649f, 0.13597935f, 0.03891453f, 0.04125107f, 0.03059014f, -0.02245146f, 
    -0.11149412f, 0.06234062f, -0.24594338f, -0.17175718f, -0.21756300f, -0.37830955f, -0.43525967f, -0.10570226f, 
    0.01657757f, 0.04253162f, 0.22349177f, 0.06553975f, -0.01339701f, 0.03595779f, 0.03082671f, -0.02751048f, 
    -0.16924538f, -0.39845088f, -0.27487797f, 0.01063645f, 0.04952523f, 0.08073495f, 0.02263363f, 0.03567043f, 
    -0.01847737f, 0.05177672f, -0.08778483f, -0.10344035f, -0.06944709f, -0.12523815f, 0.00115217f, -0.07322720f, 
    -0.07984271f, 0.03949561f, 0.01604147f, 0.06630314f, 0.14442727f, 0.09101772f, -0.01477817f, 0.03131551f, 
    -0.39893457f, -0.03050013f, 0.16064730f, 0.27943811f, 0.00415940f, 0.10309855f, -0.14686657f, -0.22147024f, 
    0.07137370f, -0.03294371f, -0.01862201f, -0.16914037f, -0.14012578f, 0.01003436f, 0.01063456f, -0.03022636f, 
    0.04989180f, 0.04489274f, 0.06248677f, -0.11664280f, -0.03034190f, 0.06211498f, 0.06805106f, 0.08414360f, 
    -0.34426290f, -0.17010231f, 0.12780105f, 0.07389861f, 0.05745523f, -0.02256961f, -0.06314819f, 0.07869712f, 
    -0.11100720f, -0.07777280f, 0.06743842f, -0.18896824f, 0.23483147f, -0.07837801f, -0.38658404f, -0.40938860f, 
    -0.05347271f, -0.12862544f, -0.07554502f, -0.21767294f, 0.02291996f, -0.02828601f, 0.02215595f, -0.01866749f, 
    0.13812189f, 0.28723320f, -0.24913421f, 0.01548551f, -0.07327361f, -0.00008339f, -0.03233187f, 0.03302105f, 
    0.09855151f, -0.06335923f, 0.11422135f, 0.17903011f, 0.23901309f, -0.06275183f, -0.14668404f, -0.15461937f, 
    -0.00454324f, 0.06878554f, 0.10073723f, -0.06642731f, 0.06976480f, 0.10718640f, 0.10737049f, 0.09569758f, 
    -0.29663402f, 0.03460503f, 0.04410897f, 0.16836275f, 0.07111611f, -0.07115620f, 0.04240071f, 0.05217268f, 
    -0.15447424f, -0.12471616f, 0.02249156f, -0.05461424f, -0.06061241f, -0.32462415f, -0.29499677f, -0.07419610f, 
    0.14576712f, 0.13761269f, 0.08256091f, 0.14807846f, -0.13929182f, -0.12937211f, -0.11909043f, -0.04066744f, 
    -0.18757512f, -0.07729324f, 0.07288422f, -0.01285039f, 0.09036887f, -0.12364765f, -0.10122558f, 0.12900390f, 
    0.00833832f, -0.05508443f, 0.03220950f, 0.03666889f, -0.09685420f, -0.42035446f, -0.42114955f, 0.02904972f, 
    -0.20057607f, 0.13277973f, 0.08695525f, -0.08857410f, -0.01172113f, 0.07149164f, 0.02579416f, 0.07265159f, 
    -0.01862425f, -0.13707507f, -0.38127911f, -0.07657360f, -0.01857491f, 0.01791460f, 0.00677413f, 0.07474934f, 
    0.01674426f, 0.11131752f, 0.06628381f, -0.06283484f, 0.13136420f, 0.26089647f, -0.21012947f, -0.02725006f, 
    0.10015044f, -0.18875584f, -0.02774685f, -0.03282544f, 0.05508782f, 0.08646622f, -0.00384665f, -0.02296837f, 
    0.09099891f, 0.10224270f, -0.04060327f, -0.11754094f, 0.12368368f, 0.01610586f, 0.11891451f, 0.05423861f, 
    -0.05770520f, -0.02662947f, -0.14861996f, -0.20354185f, 0.41794223f, 0.02453689f, -0.11851984f, 0.11268499f, 
    0.17676328f, -0.03976247f, 0.16863334f, 0.01862702f, 0.14506532f, -0.02700986f, -0.02582258f, 0.00436730f, 
    -0.32098165f, 0.08423217f, 0.08549566f, 0.00379670f, 0.02760389f, 0.13982841f, -0.10783099f, -0.31145009f, 
    0.01293368f, 0.00580536f, 0.03617496f, 0.04623350f, 0.00819764f, 0.01086460f, -0.21165764f, -0.03749847f, 
    -0.07391249f, -0.05439676f, -0.02279394f, 0.03942996f, -0.00985400f, -0.23023884f, -0.00442751f, -0.18631032f, 
    0.20683359f, -0.06280927f, 0.00936754f, 0.04712736f, -0.03068133f, 0.14673734f, -0.06934491f, -0.05238304f, 
    0.02922303f, -0.06168590f, -0.17524756f, -0.05256996f, 0.32833827f, -0.11501928f, -0.37090525f, -0.23983353f, 
    0.02306183f, 0.13559595f, 0.17106298f, -0.10601049f, 0.04585024f, -0.11155001f, 0.00759845f, 0.01234142f, 
    0.13577558f, -0.10911175f, -0.29092485f, 0.07223501f, 0.18769249f, -0.03597433f, 0.10516889f, 0.20664501f, 
    0.07834557f, 0.04874502f, 0.02824710f, -0.05080197f, -0.14504419f, -0.19199979f, -0.32061583f, -0.19140881f, 
    -0.00100483f, -0.04235332f, -0.09777895f, -0.03966237f, -0.07632028f, -0.03424353f, -0.11617845f, -0.10614944f, 
    -0.58864266f, -0.09012056f, 0.12544577f, 0.06304522f, -0.06919317f, -0.07081556f, -0.15204863f, 0.02151362f, 
    -0.14953978f, -0.12765519f, -0.09991992f, -0.06786686f, 0.04975877f, -0.14144652f, 0.08027229f, -0.11503711f, 
    0.05649725f, -0.13553201f, 0.06349162f, -0.19082056f, 0.03837985f, -0.09935207f, -0.14611018f, -0.13467972f, 
    0.42258942f, 0.24118374f, 0.04647339f, -0.31860921f, -0.05412551f, 0.02851761f, -0.00538776f, 0.01249118f, 
    0.11257819f, -0.05818512f, 0.10869601f, 0.09581617f, -0.04662821f, -0.07198364f, 0.10564204f, 0.23925093f, 
    -0.15773180f, 0.03411999f, -0.07280958f, -0.19088458f, 0.01372144f, -0.02853980f, -0.03922615f, -0.02540391f, 
    -0.42500770f, 0.21108256f, -0.06961028f, 0.11808792f, 0.01775045f, -0.04285074f, -0.02046030f, -0.04464089f, 
    0.00854435f, 0.04710813f, -0.03425743f, 0.07366607f, -0.07649121f, -0.04404005f, -0.09523875f, -0.19878030f, 
    0.02412315f, 0.00055529f, 0.02390626f, -0.02316942f, 0.08601428f, 0.14554296f, 0.08328648f, 0.12931870f, 
    0.04132748f, -0.11902334f, 0.00879927f, 0.27696195f, -0.20137689f, -0.01894101f, 0.09862859f, -0.08334540f, 
    -0.07174774f, 0.05100653f, 0.23396015f, 0.01852495f, 0.29018357f, 0.01202794f, -0.08655947f, -0.10787173f, 
    -0.04782232f, -0.09715001f, -0.00252718f, -0.12762998f, 0.10901754f, 0.09838220f, 0.17327151f, 0.03335586f, 
    0.00294597f, -0.16099587f, -0.03712733f, 0.30314407f, 0.08867014f, 0.18615760f, 0.01624992f, 0.04359234f, 
    0.03011618f, 0.02943505f, -0.06248866f, 0.09471693f, -0.27311710f, -0.55262351f, -0.51167005f, -0.16129823f, 
    0.14704944f, -0.12281636f, -0.07693564f, 0.11688400f, 0.01635669f, 0.04515749f, -0.02325397f, 0.12107322f, 
    -0.25955665f, -0.15263031f, 0.30966642f, -0.14977580f, 0.17150232f, -0.18859383f, -0.03868353f, 0.13412388f, 
    -0.03584415f, -0.00968204f, 0.02734624f, -0.04029601f, 0.10779472f, 0.20325628f, 0.16408408f, -0.09023818f, 
    0.04779572f, -0.11430575f, 0.06014663f, 0.07518913f, -0.03337915f, 0.04556302f, 0.06875940f, -0.03642412f, 
    -0.00466257f, 0.32281938f, -0.16813371f, 0.00169158f, 0.04645270f, 0.08893249f, -0.13438992f, -0.19570218f, 
    0.15597424f, -0.01490823f, -0.12396497f, 0.01988223f, -0.03446427f, 0.14075983f, 0.08490428f, -0.16296503f, 
    0.02523413f, -0.21018672f, 0.00346652f, -0.17888296f, 0.00845997f, -0.06601404f, -0.04525036f, 0.00121953f, 
    0.03261742f, 0.05785457f, 0.22810328f, -0.18059339f, -0.08515608f, -0.09937842f, -0.11611035f, -0.02690067f, 
    -0.05810592f, 0.05617873f, -0.12286218f, -0.03713383f, -0.31346908f, -0.01406618f, -0.17790073f, -0.34636787f, 
    -0.36231780f, 0.17303862f, 0.06297794f, 0.16787206f, 0.12273265f, 0.00624339f, 0.00705936f, 0.02788652f, 
    -0.30026978f, 0.08244716f, 0.10267563f, 0.24335347f, 0.02659883f, 0.06914911f, -0.23153736f, 0.05770790f, 
    0.12305527f, 0.06790014f, 0.03042956f, 0.14170328f, 0.13177328f, -0.00268059f, 0.43486866f, -0.71417302f, 
    -0.08600464f, -0.11619653f, -0.06941795f, 0.07617563f, -0.05846408f, 0.10637642f, -0.00599798f, -0.01529798f, 
    0.10924685f, 0.32616889f, 0.11494627f, -0.02796454f, -0.07636787f, -0.17401220f, -0.03152817f, -0.11339609f, 
    0.09223469f, 0.03207077f, 0.04306032f, 0.03860919f, 0.06090817f, 0.15313926f, 0.33317012f, 0.10393457f, 
    0.05539952f, -0.08046646f, -0.06008225f, -0.25576794f, 0.05865256f, -0.07196457f, -0.06589055f, 0.04877286f, 
    0.02094034f, -0.02636502f, 0.19403702f, -0.16693881f, 0.08834828f, -0.13410263f, 0.06360646f, 0.04741718f, 
    0.06246207f, -0.06800741f, 0.09250290f, 0.08759215f, -0.09879062f, -0.10995833f, -0.22508648f, 0.03420313f, 
    0.02131081f, 0.06620324f, 0.09048139f, -0.00649715f, -0.11714415f, -0.04990646f, 0.05048353f, -0.08097083f, 
    0.03748235f, -0.00235658f, -0.17480516f, 0.04292718f, 0.10952616f, 0.00959992f, 0.19943041f, -0.05434379f, 
    0.00912119f, -0.09479391f, -0.10072173f, -0.04244164f, -0.44117481f, 0.46263433f, -0.10141957f, -0.25695261f, 
    -0.00761990f, -0.35133407f, 0.12256821f, -0.28499675f, 0.01367325f, 0.06097724f, -0.13069405f, 0.03028725f, 
    -0.43270412f, 0.05428526f, -0.03836044f, -0.12287628f, 0.13005571f, -0.04473751f, 0.07407860f, 0.00963290f, 
    -0.01774914f, -0.04285035f, -0.01233833f, -0.00716264f, -0.14030829f, -0.06370143f, -0.09345007f, 0.00315920f, 
    -0.02750051f, 0.10550416f, -0.02816542f, -0.14856473f, 0.14380015f, -0.02921939f, -0.11770742f, -0.10598869f, 
    0.06709561f, 0.07463567f, 0.05632984f, 0.08992099f, 0.13992824f, 0.11111083f, 0.20959917f, 0.04826742f, 
    0.12449286f, -0.07235362f, -0.02323006f, -0.01935049f, -0.13711552f, 0.20262232f, 0.06280824f, 0.00613960f, 
    0.13467696f, -0.26108429f, -0.09900763f, 0.00119031f, -0.10203831f, -0.20161371f, 0.03681293f, 0.03193091f, 
    0.11019529f, 0.06306735f, 0.06635412f, 0.38339490f, 0.09561069f, -0.09422218f, -0.05482435f, -0.02918119f, 
    0.11419054f, -0.05131663f, -0.06925476f, 0.02513531f, -0.35548931f, 0.17314376f, -0.08321673f, -0.37865049f, 
    -0.06624816f, -0.15619388f, -0.01838000f, -0.15634252f, -0.01333952f, -0.00338349f, 0.09805969f, 0.10767639f, 
    -0.31279069f, 0.10708895f, -0.13176508f, 0.11524548f, 0.06213644f, -0.03860748f, -0.05373947f, -0.34615105f, 
    0.10875626f, -0.06153859f, -0.09501619f, 0.07898822f, 0.01098415f, -0.27810982f, -0.09670614f, 0.06212113f, 
    -0.04956509f, 0.04246844f, 0.07971164f, 0.12300646f, 0.10735606f, 0.06684302f, 0.00502789f, 0.08565977f, 
    0.00055854f, 0.01367284f, 0.11861734f, -0.28002933f, 0.01179639f, -0.00218547f, 0.17605621f, -0.05789117f, 
    -0.07399735f, 0.15786634f, -0.15410538f, -0.06715652f, -0.18219042f, 0.02492990f, 0.14441773f, -0.23162647f, 
    -0.10533831f, -0.06205273f, 0.17275518f, 0.10992865f, 0.05340917f, 0.07806770f, 0.02765430f, 0.00888170f, 
    -0.43700349f, -0.19772938f, 0.07956968f, -0.19151072f, -0.00271011f, -0.10970907f, -0.08080470f, 0.19361317f, 
    0.02581487f, -0.00899004f, 0.04651817f, -0.04416328f, 0.11751564f, -0.07694972f, 0.15776272f, -0.17649220f, 
    0.11682604f, -0.20261468f, -0.03152232f, -0.13953333f, -0.18062262f, 0.03035595f, -0.03887176f, 0.01180471f, 
    0.06913590f, -0.08374740f, 0.17535099f, 0.30973524f, 0.00003112f, 0.02619423f, -0.07051963f, -0.12022718f, 
    -0.00558921f, 0.15269907f, 0.10048293f, 0.06282011f, 0.08567868f, -0.09005906f, 0.10647291f, -0.27802384f, 
    -0.19286077f, -0.04911505f, 0.08912388f, -0.02199702f, -0.07242008f, 0.09672949f, 0.04987160f, 0.01576236f, 
    0.02800272f, 0.11822816f, 0.07600163f, 0.45241809f, 0.01387103f, 0.03235174f, -0.05429318f, -0.06492738f, 
    -0.13937123f, -0.07634316f, 0.15293255f, 0.01157521f, 0.09466391f, -0.24134590f, -0.05922039f, -0.45705453f, 
    -0.20295161f, 0.01063506f, 0.06848575f, 0.07561418f, -0.02294717f, 0.01783618f, -0.04392214f, -0.00375814f, 
    0.06773788f, -0.13749902f, 0.07185371f, -0.16381286f, 0.02098235f, 0.04552099f, -0.03589769f, 0.15520598f, 
    -0.00709686f, 0.00610887f, 0.12349140f, 0.28767341f, 0.15159208f, 0.05351018f, 0.30752686f, -0.00705274f, 
    -0.01254264f, -0.04512011f, -0.20649654f, -0.20487115f, 0.04629223f, -0.03678421f, -0.03825852f, 0.05949666f, 
    0.32850167f, 0.07414871f, 0.18165509f, 0.01105428f, 0.00025077f, -0.12138423f, -0.24589074f, -0.08190033f, 
    0.03424804f, 0.05121315f, 0.03772130f, 0.07073654f, 0.14081100f, 0.16863567f, 0.06532600f, 0.21715601f, 
    0.05377459f, -0.03602516f, -0.14026397f, -0.00773122f, 0.01469668f, -0.02330097f, -0.00309774f, -0.11893798f, 
    -0.10991118f, 0.00360141f, -0.36311233f, -0.11175644f, 0.09411041f, -0.08723243f, 0.02376784f, 0.20751177f, 
    0.05637088f, 0.12296473f, -0.01241314f, 0.05609583f, 0.10564420f, -0.05243791f, -0.06830969f, -0.14868148f, 
    0.14916693f, 0.17675702f, 0.01084980f, -0.13158132f, 0.09529198f, 0.00122445f, -0.15112209f, 0.01958266f, 
    -0.15119483f, 0.20093460f, -0.32826427f, -0.04065886f, 0.02725892f, -0.06681449f, 0.06683327f, 0.09548876f, 
    0.03552905f, -0.00717491f, 0.10075919f, 0.02815714f, -0.39158222f, -0.03044625f, 0.32353744f, -0.22462031f, 
    0.00853990f, 0.04573306f, -0.04083340f, 0.10920736f, 0.14289738f, 0.00116570f, 0.08868439f, 0.03023354f, 
    -0.27372375f, -0.47339135f, -0.02730153f, -0.12174580f, -0.08406872f, 0.04076759f, -0.15134236f, -0.02086493f, 
    -0.01537988f, 0.01754350f, 0.03953090f, 0.09837478f, -0.17992137f, -0.04103845f, -0.07546650f, 0.36740318f, 
    0.09074832f, -0.26358914f, -0.11166443f, 0.06780076f, 0.00957856f, -0.19651884f, -0.01941653f, -0.04873144f, 
    -0.20105751f, 0.30522683f, -0.58576691f, 0.17975390f, 0.04972289f, -0.04436373f, 0.17991184f, 0.02720105f, 
    -0.02281501f, -0.03641747f, 0.00605502f, 0.00623465f, 0.13608564f, -0.20971811f, 0.21561915f, 0.09047563f, 
    0.08133192f, -0.14517587f, -0.00285590f, -0.12812306f, 0.03132520f, -0.03863938f, 0.05420571f, 0.10540230f, 
    0.10176224f, 0.39488465f, -0.73381084f, 0.05454028f, -0.01231301f, -0.08327581f, 0.17150207f, -0.00249863f, 
    0.13330959f, -0.05495695f, -0.03811363f, -0.03666972f, -0.40691704f, 0.02080061f, 0.16636160f, -0.40592298f, 
    -0.15987115f, -0.02848558f, -0.15085034f, 0.23494212f, -0.01474210f, -0.05140910f, 0.01655967f, -0.01844593f, 
    0.08290174f, 0.26358235f, 0.07789215f, -0.06673612f, -0.11391238f, 0.02172790f, 0.06683767f, -0.00777326f, 
    0.08998145f, 0.10936133f, -0.03914487f, -0.01846485f, 0.30131704f, -0.09161322f, -0.26279610f, 0.02804256f, 
    0.13397628f, 0.07012650f, 0.03782952f, 0.08927420f, -0.01740896f, 0.03419596f, -0.03686585f, -0.16058558f, 
    -0.15189788f, -0.01085053f, -0.11387681f, 0.16732641f, -0.04714019f, -0.01454972f, -0.15847400f, 0.05537431f, 
    0.13371412f, -0.04634544f, 0.03205837f, -0.07528790f, -0.44057837f, 0.10236508f, -0.57053167f, 0.11907745f, 
    -0.03069593f, -0.38836002f, -0.05406709f, -0.26411074f, 0.04792892f, -0.08739694f, -0.18367195f, -0.17061844f, 
    0.15637450f, 0.00449117f, -0.05384791f, -0.14039102f, -0.07850939f, -0.16269171f, 0.09831489f, 0.02318134f, 
    -0.03514203f, 0.08086974f, -0.00349911f, 0.00500278f, 0.04642694f, -0.01538189f, 0.22015120f, 0.06105834f, 
    0.04208736f, 0.01859439f, -0.38788792f, -0.02214447f, 0.13020234f, -0.13193795f, 0.01852918f, -0.00901282f, 
    0.08370667f, -0.46539727f, 0.13065192f, -0.40283686f, 0.14598447f, -0.05479225f, -0.11516221f, -0.04547034f, 
    0.12359793f, -0.03030388f, 0.02950210f, 0.06841063f, -0.26664761f, -0.35144871f, 0.25749904f, 0.11211690f, 
    0.01698193f, -0.18414722f, -0.07423279f, 0.13399115f, 0.00384513f, 0.00467329f, -0.01224861f, 0.02014197f, 
    -0.42960125f, 0.20780924f, -0.05045825f, 0.38851771f, 0.09150676f, -0.10243193f, -0.10856891f, -0.09563212f, 
    0.09997837f, -0.01246302f, 0.04054401f, 0.06402101f, -0.29121822f, 0.02720473f, -0.19825256f, -0.28593910f, 
    -0.05463707f, -0.07793119f, 0.03266546f, 0.05877505f, 0.13914141f, 0.08250547f, 0.10574849f, 0.03193909f, 
    -0.08333018f, -0.13309212f, -0.18726657f, -0.25195554f, 0.04194032f, 0.04173575f, 0.20527580f, -0.06017749f, 
    -0.02052331f, 0.05152832f, 0.00708308f, 0.06361383f, 0.31653425f, -0.19180472f, -0.08082917f, -0.24794979f, 
    0.09931190f, -0.07796630f, 0.16218713f, 0.00894180f, -0.02014569f, 0.07001231f, -0.05977364f, -0.03023764f, 
    -0.64391118f, 0.04907002f, 0.01836201f, 0.11076523f, 0.09994346f, -0.00410515f, -0.00727089f, 0.05451790f, 
    0.02055453f, -0.05522371f, 0.07067273f, -0.16170204f, -0.22498697f, -0.29314998f, -0.04952721f, -0.05693388f, 
    0.13333048f, 0.02591434f, 0.12575850f, 0.00106828f, -0.01865363f, -0.02473537f, -0.01440021f, -0.03341174f, 
    0.05200032f, -0.03743097f, -0.13124941f, -0.12719542f, -0.03996276f, 0.02317580f, -0.04415214f, -0.00984879f, 
    0.08034784f, 0.06040419f, -0.02826744f, -0.04752981f, 0.17502384f, 0.04235267f, 0.17684206f, 0.17998379f, 
    0.03855848f, -0.03266333f, -0.06108149f, -0.11789860f, 0.03303747f, -0.00580263f, -0.01389886f, -0.01846600f, 
    0.03442838f, 0.09335265f, 0.15554619f, -0.52362800f, 0.08797137f, -0.15949211f, 0.12290217f, -0.00774326f, 
    -0.05662918f, 0.02117136f, -0.02011085f, -0.05052439f, 0.13414556f, -0.29732940f, 0.04098064f, -0.13032748f, 
    0.05409190f, 0.01706707f, -0.03346553f, 0.01583195f, 0.00841480f, -0.06221168f, -0.01083194f, -0.13453193f, 
    0.15390286f, -0.05751777f, 0.05341811f, -0.42265332f, 0.07158267f, -0.02838253f, 0.07501160f, 0.05221270f, 
    0.01135989f, 0.02775720f, -0.14215825f, -0.08559995f, -0.02793832f, 0.04718416f, 0.13137940f, -0.19005156f, 
    0.01151280f, -0.16869789f, -0.04793544f, 0.05659226f, 0.09483329f, 0.07010610f, 0.03953082f, -0.05434431f, 
    -0.24801052f, -0.15304469f, -0.10062302f, 0.07772449f, -0.03593423f, 0.05872389f, -0.25240019f, 0.06409001f, 
    -0.05254914f, 0.09236199f, -0.09722607f, -0.01900383f, -0.14112598f, 0.08543520f, -0.15266430f, 0.06611437f, 
    -0.02160210f, 0.12656517f, 0.14634386f, -0.04468085f, -0.08256941f, 0.03958456f, -0.02313213f, 0.09769448f, 
    -0.23289806f, -0.03218960f, 0.15493503f, -0.04955301f, -0.05263325f, 0.10789030f, 0.17093803f, -0.03146015f, 
    -0.06784648f, 0.03190011f, 0.03209285f, 0.01791373f, -0.04022430f, -0.12469546f, 0.14615779f, 0.14859353f, 
    0.03242373f, 0.16672993f, -0.09090290f, 0.08329358f, 0.07433784f, 0.02535197f, 0.09739586f, -0.00728043f, 
    -0.23594296f, 0.15511650f, -0.00939729f, -0.02068874f, -0.00838985f, 0.04177120f, 0.02553810f, 0.09413404f, 
    -0.00105801f, 0.03468906f, 0.11728017f, 0.05253669f, 0.04001170f, -0.01595756f, -0.16320837f, -0.02717554f, 
    0.07093829f, -0.13567863f, -0.12557895f, 0.02659327f, 0.01962714f, 0.12995732f, -0.07113430f, -0.02964106f, 
    0.13433102f, -0.12909301f, 0.12280372f, -0.24547140f, -0.04024772f, 0.03684266f, -0.14218457f, 0.04072712f, 
    -0.19520384f, -0.15376359f, -0.43310252f, -0.14891890f, -0.08648947f, -0.08415492f, -0.11955041f, 0.27549258f, 
    0.11044215f, -0.20595266f, -0.05929918f, 0.15875088f, -0.06045010f, -0.01239051f, -0.23048343f, -0.10758406f, 
    -0.17998306f, -0.00167480f, 0.12013391f, 0.09994899f, 0.05740386f, -0.09990600f, 0.08549590f, 0.05855144f, 
    -0.08343378f, 0.02725569f, -0.02235231f, 0.02405003f, 0.11093003f, 0.06747121f, 0.15528226f, -0.07448613f, 
    -0.04257740f, -0.03584643f, 0.07860494f, 0.02376914f, -0.04376342f, 0.08325473f, 0.05393074f, -0.07090212f, 
    -0.16626383f, -0.21112129f, 0.02012921f, 0.13452198f, -0.00827175f, -0.05520276f, -0.03741545f, 0.02125740f, 
    -0.04743828f, 0.05630763f, -0.20206258f, -0.33584082f, 0.06418098f, -0.15269987f, -0.28459486f, 0.18498351f, 
    -0.14822459f, -0.04589568f, -0.11720829f, -0.11062934f, 0.06100425f, 0.04945111f, -0.07370993f, -0.00746906f, 
    -0.15242425f, -0.02011295f, 0.08827029f, 0.02207475f, -0.01005204f, -0.00631304f, 0.18361817f, 0.10925393f, 
    -0.00059836f, 0.07899776f, 0.10888068f, 0.22167195f, -0.04772331f, -0.22665238f, -0.03016784f, 0.27033710f, 
    -0.04290437f, -0.07623343f, 0.26251256f, -0.06938773f, -0.03883003f, -0.08671983f, -0.11033358f, 0.03277155f, 
    -0.03249740f, -0.24207544f, 0.13607439f, 0.04500823f, -0.19717295f, -0.04212765f, -0.09605234f, 0.24644864f, 
    0.05835460f, -0.12857330f, 0.03998436f, 0.13410893f, 0.01376803f, 0.11370891f, 0.19677515f, 0.04247998f, 
    -0.15884265f, 0.07601437f, -0.08848203f, 0.01197910f, -0.04825076f, -0.14345649f, 0.07094263f, 0.18649672f, 
    -0.05679023f, -0.22116917f, 0.04503913f, -0.11832903f, 0.10919345f, -0.14341967f, -0.14641459f, -0.03221963f, 
    0.12895638f, 0.16527319f, 0.07220230f, 0.01356490f, 0.31490076f, 0.09267992f, 0.31775963f, -0.19857548f, 
    -0.14505421f, -0.06613629f, 0.14005353f, 0.02795145f, -0.00888252f, 0.14038286f, 0.01544324f, -0.00067328f, 
    -0.18211821f, 0.40070316f, -0.22695516f, -0.35890955f, -0.02552421f, 0.00016891f, 0.02495556f, -0.19842114f, 
    -0.03652211f, 0.04833961f, 0.07963793f, 0.14553532f, 0.40716594f, -0.34169400f, 0.27243763f, -0.09586274f, 
    -0.13507159f, 0.07419115f, -0.03489273f, 0.01156635f, 0.02162572f, 0.14264165f, 0.02559777f, -0.40208921f, 
    -0.09892741f, 0.18803836f, 0.02380279f, -0.08797432f, -0.03585339f, -0.16865671f, 0.24739775f, 0.13097090f, 
    -0.00077817f, 0.10805938f, -0.38653845f, 0.01413715f, 0.11608150f, -0.31748462f, 0.11906661f, 0.17664789f, 
    -0.07964285f, 0.00440824f, -0.05216354f, -0.12708992f, -0.07522000f, -0.18537825f, -0.00324597f, -0.02135699f, 
    0.09459144f, 0.08298059f, 0.04392776f, 0.21113762f, -0.07928884f, 0.00053759f, 0.01830104f, 0.00864730f, 
    0.05275705f, -0.13780992f, 0.04735741f, 0.05641621f, -0.18151811f, -0.14139053f, -0.12536666f, 0.01870467f, 
    0.01100657f, 0.05133966f, -0.13232513f, -0.06009122f, 0.01436875f, 0.09959782f, 0.03994763f, -0.03348999f, 
    -0.28062749f, 0.04847239f, -0.14839819f, 0.15196627f, -0.02218721f, 0.05488408f, -0.03979923f, -0.03560895f, 
    0.00397957f, 0.06241048f, 0.12199150f, 0.10939613f, -0.05866507f, 0.22682323f, 0.09874151f, 0.02921872f, 
    -0.09948847f, 0.08804229f, -0.00955465f, 0.07357106f, 0.07834502f, 0.08605387f, 0.13956890f, 0.14975438f, 
    -0.18089882f, 0.18317084f, -0.14509089f, -0.21009532f, 0.02352502f, 0.05620202f, -0.02793284f, 0.03711992f, 
    0.02756595f, -0.26783162f, -0.42208225f, -0.22025061f, -0.04982561f, 0.02385527f, -0.07328395f, -0.06329510f, 
    0.03585612f, -0.06883048f, 0.13001028f, -0.08266933f, -0.00327325f, 0.08749583f, -0.11219619f, -0.04731209f, 
    -0.14838825f, 0.20438774f, -0.04340605f, -0.17505144f, -0.04781984f, 0.06591161f, 0.04573414f, 0.07983803f, 
    0.07067943f, -0.01297314f, -0.21012974f, -0.25194854f, 0.27625707f, 0.01637330f, 0.12832981f, 0.24576826f, 
    0.06064584f, 0.00245527f, 0.04619497f, -0.00914887f, 0.11070931f, -0.01190550f, -0.07653201f, 0.09421428f, 
    -0.07824274f, 0.11235291f, 0.12159479f, -0.11498176f, -0.08563402f, 0.08216140f, 0.00486500f, -0.03079804f, 
    -0.08761659f, -0.06408862f, -0.26232564f, -0.33241636f, -0.07077342f, 0.34435344f, -0.25181907f, -0.00415679f, 
    -0.02586840f, -0.05617424f, 0.07887412f, -0.06480486f, -0.22405724f, -0.01857443f, -0.02776731f, -0.07885469f, 
    -0.18174331f, 0.12176860f, 0.05919247f, 0.00587233f, 0.01436636f, -0.12051366f, -0.05266947f, 0.08966462f, 
    -0.07777168f, 0.06745450f, 0.02988673f, -0.17815493f, 0.07218366f, 0.19810480f, -0.06074413f, -0.05165993f, 
    -0.01959734f, 0.04983059f, 0.00717716f, 0.04004322f, 0.01525913f, 0.12804864f, 0.03255875f, 0.21115220f, 
    -0.08785823f, 0.10905089f, 0.16765387f, 0.05327342f, 0.07295774f, 0.13716465f, -0.11718439f, 0.05951032f, 
    -0.13738871f, -0.02199554f, 0.07453502f, -0.22766280f, -0.25240698f, 0.12896538f, -0.04562677f, -0.10486619f, 
    -0.08153810f, -0.12516886f, -0.02928355f, -0.13922064f, -0.12366021f, -0.08734193f, 0.09932908f, 0.02029241f, 
    -0.09195612f, -0.02890975f, 0.16044936f, -0.07536533f, -0.04989269f, -0.02408051f, 0.01053916f, 0.09686619f, 
    -0.21503113f, -0.10945009f, -0.16320857f, -0.11354371f, -0.03892823f, -0.19442280f, -0.17603205f, 0.05774100f, 
    -0.06096728f, 0.12437771f, -0.03308062f, -0.02511536f, 0.03150899f, 0.03687058f, -0.04199190f, -0.05502316f, 
    -0.36720163f, -0.08324373f, 0.09771940f, 0.17888778f, 0.07771670f, 0.03599136f, -0.00910658f, -0.08536847f, 
    -0.22760233f, 0.07915248f, 0.18137509f, -0.01123059f, -0.17128274f, 0.27836907f, 0.08438791f, 0.04959454f, 
    -0.07051773f, 0.11312959f, -0.01561605f, 0.09569334f, 0.08441059f, 0.11106298f, 0.13469106f, 0.05968498f, 
    -0.03116207f, -0.13725811f, -0.14721848f, -0.08287574f, -0.17752144f, -0.22346056f, 0.21355437f, -0.08625566f, 
    -0.10713218f, 0.19208935f, -0.11380199f, -0.06720451f, -0.12448868f, 0.10828602f, -0.05866032f, 0.01754092f, 
    -0.02839170f, -0.10274832f, -0.05239535f, 0.12050008f, -0.09493605f, 0.06652585f, -0.11446574f, -0.30191815f, 
    -0.10707726f, -0.11497593f, 0.10911436f, 0.01122283f, -0.04120637f, -0.09674861f, 0.13436186f, -0.18666205f, 
    -0.15220940f, 0.12774564f, -0.18011877f, -0.10733036f, -0.15105876f, -0.07428306f, 0.04403874f, 0.16436993f, 
    -0.10846466f, -0.02805173f, -0.07359191f, 0.20246343f, 0.04405573f, 0.10597174f, 0.07293991f, 0.06258495f, 
    -0.10096210f, -0.28237531f, -0.05825239f, 0.13128272f, 0.01046903f, -0.04169778f, -0.01334472f, 0.06213145f, 
    -0.03904289f, -0.04126986f, -0.10842412f, -0.03072738f, -0.11742973f, -0.27938825f, -0.23435690f, 0.23058717f, 
    -0.09668203f, 0.11130556f, -0.04622009f, -0.00129006f, -0.06661891f, 0.04331418f, -0.01448704f, -0.04955239f, 
    -0.01967130f, 0.21603128f, -0.23952095f, 0.05689205f, 0.07741155f, 0.16726427f, -0.06810999f, -0.15863441f, 
    -0.13837235f, 0.05769438f, -0.17339501f, -0.12007211f, 0.02895422f, -0.02730623f, 0.46571621f, 0.22117291f, 
    -0.21608892f, 0.16545893f, 0.14202419f, -0.05075040f, 0.12170292f, -0.04504628f, 0.13917802f, 0.13991238f, 
    -0.12248521f, 0.05589207f, -0.38222978f, -0.01945462f, 0.19114690f, -0.10476869f, -0.09677598f, -0.20650667f, 
    0.04081454f, -0.01099864f, 0.02898954f, 0.01282880f, -0.33643559f, 0.18275423f, 0.13553153f, 0.15975635f, 
    0.02444410f, -0.08176367f, -0.15595996f, -0.11687535f, -0.26057041f, 0.02022834f, -0.21219940f, -0.15519048f, 
    -0.36080575f, 0.22436477f, -0.24681835f, 0.10853734f, -0.01029661f, -0.02383110f, -0.01565824f, 0.32161647f, 
    0.00422595f, -0.11289696f, -0.15954557f, -0.10180020f, -0.39793497f, -0.04832130f, -0.10472432f, 0.10637517f, 
    -0.10054171f, 0.11594250f, -0.20084170f, 0.02748519f, -0.06687181f, 0.07483962f, 0.00064721f, 0.00214297f, 
    0.17260908f, 0.02021095f, 0.16643740f, 0.03068436f, -0.06715731f, 0.06014472f, 0.16962598f, 0.19998577f, 
    -0.03222172f, 0.03572739f, -0.15686956f, -0.10214095f, 0.16895044f, -0.12226875f, 0.07268548f, 0.04610613f, 
    -0.07005624f, -0.13699473f, 0.06511228f, 0.12135223f, -0.05426857f, 0.01555778f, -0.00297594f, -0.07015751f, 
    0.09030314f, 0.28981262f, 0.11804673f, 0.05895502f, -0.15654722f, -0.00467247f, -0.00620984f, 0.00657568f, 
    -0.08069672f, -0.01810883f, 0.06306268f, 0.03448148f, -0.02966453f, 0.04229508f, -0.33503586f, 0.12486695f, 
    -0.07262279f, 0.00045016f, 0.02669260f, -0.03248549f, 0.04366220f, -0.18700756f, -0.16597036f, 0.00629642f, 
    -0.10757976f, 0.11898789f, -0.08049548f, 0.17498186f, -0.05142859f, 0.06343781f, -0.09350356f, -0.02749840f, 
    -0.00319921f, -0.17292668f, 0.01323303f, 0.18686950f, -0.19738604f, -0.16046953f, -0.07472648f, 0.01545114f, 
    -0.11666974f, 0.00914275f, -0.20134215f, 0.13646527f, -0.00725020f, -0.10437809f, 0.12238123f, -0.01739312f, 
    -0.15944405f, 0.17676899f, 0.21028021f, -0.03287131f, 0.02221172f, -0.02015276f, -0.02783675f, -0.06042244f, 
    -0.00544663f, -0.10370408f, 0.17452292f, 0.05145409f, -0.21049371f, 0.10644366f, -0.14600822f, 0.03700255f, 
    -0.06593849f, -0.10263072f, 0.06412267f, -0.12019265f, -0.10573101f, 0.12022041f, 0.03514910f, -0.02666468f, 
    0.14235948f, -0.10292526f, 0.24231750f, -0.08698858f, -0.10635042f, 0.03301244f, 0.08090381f, 0.02508260f, 
    0.01666694f, -0.09074645f, 0.03968249f, 0.00416890f, -0.32286519f, 0.11445032f, 0.13331918f, 0.19098839f, 
    -0.06015918f, 0.13979018f, -0.11785203f, -0.08805568f, 0.10273183f, -0.02987145f, 0.07274230f, 0.05608263f, 
    -0.13846838f, 0.25712246f, 0.35523605f, 0.27640876f, 0.19356532f, 0.13559125f, -0.15568894f, -0.00791011f, 
    -0.01495297f, 0.00327374f, 0.13930789f, 0.01354360f, -0.15971088f, -0.10409516f, -0.16132544f, -0.08563013f, 
    -0.03332106f, 0.06714288f, 0.10653026f, -0.01749632f, 0.04904044f, -0.00150402f, 0.01928132f, 0.07524835f, 
    0.07582607f, -0.20494163f, 0.08584125f, -0.19301094f, -0.12382329f, -0.07519092f, 0.13265592f, -0.03076900f, 
    0.05733524f, 0.03633074f, -0.02030842f, -0.10739249f, 0.01095481f, -0.34733915f, 0.17782927f, 0.13675605f, 
    -0.03888192f, 0.00908896f, -0.09172890f, -0.05474062f, 0.04177456f, 0.00503562f, -0.12913896f, -0.12229620f, 
    0.08400592f, -0.07006530f, 0.16018173f, -0.04988717f, 0.12982646f, -0.03087247f, 0.01465971f, 0.01933154f, 
    0.08706573f, 0.11296149f, 0.12616448f, -0.05707091f, 0.00275448f, -0.27794290f, 0.17906059f, -0.00129994f, 
    0.00526240f, 0.14358582f, -0.01030845f, 0.11697787f, -0.12983482f, -0.06195848f, -0.03984258f, -0.12631683f, 
    -0.11556632f, 0.02839431f, 0.03228336f, 0.01370189f, 0.11704344f, 0.03794983f, 0.09011042f, 0.06612686f, 
    -0.17781818f, 0.08212657f, 0.02785179f, -0.06435226f, -0.01768966f, -0.06015708f, -0.20485467f, -0.10737554f, 
    -0.10672073f, -0.09649335f, 0.02406146f, -0.13316788f, 0.06058456f, 0.02117910f, -0.03650841f, -0.06867462f, 
    -0.14842196f, 0.01300828f, -0.00698333f, -0.12753463f, 0.15544708f, 0.11880839f, 0.08390156f, -0.10024976f, 
    -0.01023772f, 0.02903678f, 0.17020270f, 0.11440124f, -0.66541868f, -0.46197468f, 0.11264475f, 0.11689541f, 
    -0.10472171f, 0.11681434f, 0.02955723f, 0.20449284f, -0.13552088f, 0.00214489f, 0.06611080f, 0.01893470f, 
    -0.06180834f, -0.43179926f, -0.00031838f, -0.25791281f, -0.08930143f, -0.07387500f, -0.03906139f, -0.07378888f, 
    0.05471967f, 0.05036444f, 0.00452037f, 0.03176111f, -0.31028226f, -0.15176970f, 0.01738279f, -0.08656178f, 
    0.06865165f, -0.00289275f, -0.11125390f, 0.03413220f, -0.04608106f, -0.04137512f, 0.07632054f, -0.13028662f, 
    0.01022569f, -0.10619496f, -0.15731293f, 0.01716499f, -0.09287473f, 0.06656788f, 0.15943123f, -0.04334020f, 
    -0.06115863f, 0.06501788f, 0.00148995f, 0.00787368f, 0.17341998f, -0.04268289f, 0.06059140f, 0.00802765f, 
    -0.03077813f, 0.02131436f, -0.01575465f, 0.04240236f, -0.06540596f, -0.02930416f, -0.00311365f, -0.05233439f, 
    0.13811176f, 0.03633191f, 0.24032709f, -0.07320371f, 0.06166881f, 0.11706553f, 0.12255479f, 0.00310665f, 
    -0.14038293f, -0.04434389f, -0.02359974f, -0.21703282f, 0.33680344f, -0.27697650f, 0.35383663f, -0.02752204f, 
    0.13716561f, 0.18487091f, -0.13991801f, 0.16645105f, -0.13621685f, 0.05546427f, 0.01828695f, -0.02072694f, 
    0.39564762f, 0.21599633f, 0.25904414f, -0.28225246f, -0.09994612f, 0.04562644f, -0.14027968f, 0.09382980f, 
    -0.10036401f, 0.08699922f, -0.02147212f, 0.02762275f, -0.18267213f, 0.15571365f, 0.05208958f, -0.10991421f, 
    -0.09451933f, 0.10517509f, -0.02384847f, -0.16701551f, 0.00099470f, 0.01245992f, 0.11266127f, -0.08938587f, 
    -0.10787795f, -0.04551915f, -0.02865477f, -0.05733136f, 0.02064442f, -0.04910406f, 0.03185649f, 0.01184076f, 
    0.00232122f, 0.08672512f, -0.10424571f, -0.10080472f, -0.03740911f, -0.20261528f, 0.04877253f, -0.13810778f, 
    0.07685950f, 0.11398737f, 0.01266619f, -0.10542683f, -0.16534583f, -0.05738821f, -0.10247657f, -0.12317858f, 
    -0.28597111f, -0.13452162f, -0.21239705f, 0.14802311f, 0.11664465f, -0.11513171f, 0.00113600f, -0.01295824f, 
    -0.09219280f, 0.08881589f, 0.03864644f, -0.12458243f, -0.02440347f, 0.08885559f, 0.05382428f, -0.56176132f, 
    -0.00417554f, 0.01243664f, 0.08247054f, -0.01468701f, 0.03782154f, 0.07304274f, 0.01966493f, 0.05593289f, 
    0.28561020f, -0.44766748f, 0.07181114f, 0.01832145f, 0.10906986f, 0.01156201f, -0.01654250f, 0.04908906f, 
    0.05676151f, 0.23255651f, 0.12365232f, 0.06818487f, -0.22967535f, 0.14155374f, 0.01587089f, -0.05736688f, 
    -0.10789833f, 0.00646597f, 0.11911907f, -0.06909686f, 0.00833262f, 0.01667566f, 0.12936410f, -0.04402800f, 
    -0.02502732f, 0.01344151f, 0.13537388f, 0.10031934f, -0.01686572f, 0.03300370f, 0.03589768f, 0.05803541f, 
    -0.23966676f, -0.00180976f, 0.09446413f, 0.00392120f, -0.25549483f, -0.31380644f, 0.06312430f, -0.11808395f, 
    -0.17377928f, -0.05989004f, -0.22333384f, -0.18717003f, -0.04631695f, -0.01532591f, -0.07258254f, 0.02085640f, 
    -0.06097074f, -0.17908095f, 0.26571456f, 0.10809646f, -0.03548164f, -0.06272246f, -0.18894686f, 0.03689272f, 
    -0.06850400f, -0.05371390f, -0.03334802f, -0.03479821f, -0.12843001f, -0.03759424f, 0.03726324f, 0.09894117f, 
    0.08739698f, -0.06868431f, -0.01463677f, 0.00622015f, -0.16157046f, -0.05920140f, -0.16361715f, 0.08940113f, 
    -0.29401535f, -0.11288095f, -0.32328814f, 0.06852134f, 0.03062385f, -0.06887943f, -0.00455324f, -0.08013377f, 
    0.10643141f, -0.03026228f, 0.11826983f, 0.07073129f, 0.16480741f, -0.35361663f, -0.05012953f, 0.09698214f, 
    0.02270114f, -0.15741296f, 0.06982607f, -0.07245207f, -0.05404286f, 0.07327022f, 0.05143995f, 0.06540675f, 
    -0.29403007f, -0.08570279f, -0.23601319f, 0.04844075f, 0.10655364f, 0.01153690f, 0.10959815f, -0.07728075f, 
    0.01556337f, 0.05183818f, 0.09990455f, 0.22463666f, -0.48515370f, 0.15136628f, -0.12422445f, 0.09332457f, 
    0.02769714f, 0.14978030f, -0.00827800f, -0.02455614f, -0.14498909f, 0.07803428f, -0.03819374f, 0.00770691f, 
    0.02600287f, 0.16303088f, -0.14103794f, 0.10754778f, 0.04937496f, -0.03636760f, 0.12588657f, 0.10636479f, 
    0.17525883f, 0.09467304f, 0.14050017f, 0.12576889f, -0.16018778f, -0.23863006f, -0.02745039f, 0.39136437f, 
    -0.03334926f, -0.16443463f, 0.00963508f, -0.01139921f, -0.10565034f, -0.04378992f, -0.04026685f, -0.14729455f, 
    -0.23529652f, 0.18259288f, -0.22935671f, -0.14381438f, -0.02492642f, -0.09234881f, 0.04234792f, -0.02110287f, 
    -0.03578525f, 0.02919948f, 0.01195016f, -0.01414087f, -0.19335395f, 0.04104031f, -0.21818115f, 0.11155489f, 
    0.06469166f, -0.07183222f, -0.04380774f, 0.03253482f, -0.13336341f, -0.09154081f, -0.01420420f, -0.05947301f, 
    0.10028313f, 0.10067184f, -0.01395585f, 0.03922052f, -0.00461741f, -0.11868834f, 0.06715426f, 0.11179789f, 
    0.01421483f, -0.00017498f, -0.02667238f, 0.02540805f, 0.19011471f, 0.20679221f, 0.00099532f, -0.02540644f, 
    0.03715482f, 0.09423465f, 0.15113391f, 0.07979192f, 0.02004273f, -0.01644482f, -0.02825095f, -0.04034587f, 
    0.20904958f, 0.01995145f, 0.03770171f, -0.11517403f, 0.01390547f, -0.08527219f, 0.09900744f, 0.03481195f, 
    0.08395607f, -0.05406043f, 0.02932895f, 0.03780178f, -0.15315334f, -0.34702581f, -0.12135626f, 0.23396307f, 
    -0.13464367f, 0.03935559f, 0.10686099f, -0.15658957f, 0.00566770f, 0.09951587f, 0.00324709f, -0.00800994f, 
    -0.57746315f, 0.21115990f, -0.39696968f, 0.13886671f, 0.10137300f, -0.07736181f, 0.11159158f, -0.05414899f, 
    -0.00513408f, 0.04097511f, -0.02311813f, 0.00960067f, 0.05656027f, -0.16170216f, -0.04150738f, -0.06389507f, 
    0.11876839f, -0.06615481f, -0.19593431f, 0.11173363f, 0.12843332f, -0.00179328f, 0.01870698f, -0.09537712f, 
    0.40546089f, -0.02958020f, 0.53231186f, -0.13704231f, -0.00246458f, 0.00852984f, -0.09748755f, 0.05713958f, 
    -0.10995857f, 0.02948148f, 0.00051639f, 0.02358898f, -0.05949404f, -0.27299148f, 0.07394253f, -0.24239378f, 
    -0.10335384f, -0.02661537f, -0.10726672f, 0.05420124f, -0.00627012f, 0.01481685f, 0.03923827f, -0.02296779f, 
    0.56940305f, -0.39803612f, 0.55200982f, -0.26104435f, 0.04688512f, 0.14999989f, -0.47379619f, 0.14461678f, 
    -0.10461929f, -0.10237382f, 0.06124423f, 0.20158677f, -0.06162741f, -0.03834837f, -0.11940885f, 0.04027418f, 
    0.00309658f, -0.01962505f, -0.29737183f, -0.04438952f, -0.01501134f, -0.05408423f, -0.15575184f, -0.14324819f, 
    -0.39807600f, -0.32616296f, 0.10379306f, -0.07376740f, -0.18181261f, -0.07383589f, 0.03858469f, -0.09754371f, 
    0.04551469f, 0.09672317f, 0.10428939f, 0.09405407f, 0.19763300f, -0.01679827f, 0.18815254f, -0.04432223f, 
    -0.10999043f, 0.01272862f, -0.08367595f, -0.06582479f, -0.00037051f, 0.05304842f, 0.11893591f, 0.12880833f, 
    -0.00756656f, 0.08498529f, -0.05854097f, 0.25898844f, -0.01528098f, -0.03293490f, 0.09614992f, -0.01115296f, 
    -0.01565395f, 0.07348529f, 0.27369598f, 0.17394148f, 0.40173990f, -0.31774956f, 0.39801291f, -0.52223045f, 
    -0.01951129f, 0.01147992f, -0.19886304f, 0.21066754f, -0.07225335f, 0.02683707f, 0.09120147f, -0.08563382f, 
    0.10983983f, -0.13762072f, 0.13103946f, 0.16839820f, -0.01943799f, -0.25190783f, 0.01187140f, -0.04423710f, 
    0.02974764f, -0.00065753f, -0.01106271f, -0.05369514f, -0.39837739f, 0.05464758f, -0.33831942f, 0.10958032f, 
    0.07230241f, -0.07398936f, 0.10129975f, -0.08049024f, -0.11935701f, 0.04719517f, 0.06262477f, 0.09296149f, 
    -0.22853027f, 0.22510399f, -0.06009343f, -0.02678901f, -0.07115741f, 0.02006098f, 0.05747228f, 0.07514969f, 
    -0.15427443f, -0.01411018f, -0.03467523f, 0.16345231f, -0.00029730f, -0.07632574f, 0.01667126f, 0.01745947f, 
    0.09011347f, 0.02796508f, 0.06368800f, 0.05487059f, -0.06867025f, 0.04638873f, -0.01725403f, -0.04348728f, 
    0.26653114f, -0.24247783f, 0.41965321f, -0.29509366f, 0.02059535f, 0.02337304f, 0.07603192f, -0.11742009f, 
    -0.09636088f, 0.03768019f, 0.05835729f, 0.16722015f, -0.15317264f, 0.18589725f, -0.26181856f, -0.01489497f, 
    -0.19199562f, -0.00781870f, 0.01351565f, 0.02222089f, 0.08898187f, 0.12643526f, 0.02699448f, -0.04467938f, 
    0.11667130f, 0.04729801f, 0.18003434f, 0.14612240f, 0.03408981f, 0.06968007f, 0.00557945f, -0.03384914f, 
    -0.13345052f, 0.08794377f, 0.00542641f, 0.00193582f, 0.13672428f, -0.05605921f, 0.13897090f, 0.13723220f, 
    0.00680364f, -0.15078585f, -0.01444820f, 0.05067145f, -0.02496577f, 0.10660988f, 0.11278754f, 0.11721949f, 
    0.27342635f, -0.13545181f, 0.02118604f, -0.08468313f, 0.07288701f, 0.03767431f, -0.07988882f, 0.14498854f, 
    0.03110753f, 0.03131363f, -0.05264448f, -0.06964477f, 0.23924620f, 0.37653753f, 0.21970579f, -0.08831847f, 
    -0.02923308f, -0.01358700f, -0.03974526f, 0.04154161f, -0.09121769f, 0.12656076f, -0.04408739f, -0.02728365f, 
    0.09322993f, -0.03975019f, -0.03172143f, 0.18893030f, -0.09056673f, -0.03205156f, -0.01927853f, 0.05927958f, 
    -0.13159999f, 0.00705889f, 0.08162431f, -0.09632051f, -0.11204103f, -0.07736023f, -0.06122427f, 0.28437811f, 
    0.03183832f, -0.08304387f, 0.03254411f, -0.00469864f, 0.12844171f, -0.09330600f, 0.07125767f, 0.11192685f, 
    -0.13531522f, -0.02758426f, 0.00197822f, -0.34150985f, 0.20568217f, 0.02111303f, -0.16131593f, 0.12480804f, 
    -0.02245088f, -0.03869315f, 0.03019029f, -0.07368398f, -0.10826034f, 0.05749384f, -0.25141039f, 0.07737912f, 
    0.05824505f, -0.17472392f, 0.09616964f, 0.04435797f, 0.02721625f, -0.03222902f, 0.20272391f, -0.15978725f, 
    -0.14534077f, 0.20797227f, 0.15831788f, -0.02519983f, -0.00676380f, -0.16642889f, -0.01786400f, 0.08493793f, 
    -0.13752183f, -0.07177512f, -0.01744599f, -0.08985794f, -0.06359013f, -0.24047089f, -0.14822000f, -0.21645918f, 
    -0.09554583f, -0.16987951f, -0.26444325f, -0.15925638f, 0.05054520f, 0.06289638f, 0.05352869f, -0.05355029f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11463133f, 0.05205541f, 0.07048854f, -0.08780935f, -0.07170326f, 0.04587300f, 0.04577695f, -0.14641753f, 
    0.11451775f, -0.00277460f, 0.04778447f, -0.04079848f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
