#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.99157518f, 0.35043263f, 0.68917441f, -0.23330596f, 0.04354354f, 0.39338225f, -0.53710234f, 0.37583038f, 
    0.07235526f, 0.61876184f, 0.01535134f, -0.01480216f, -0.19575003f, 0.03284748f, -0.37769604f, 0.19933185f, 
    -0.25110260f, -0.04030418f, -0.23103571f, -0.23812206f, 0.49078909f, 0.26725358f, 0.17488806f, -0.14198293f, 
    0.22877102f, 0.47355846f, -1.05930662f, -0.37363663f, -0.50484890f, -0.58630127f, -0.08663371f, 0.83615458f, 
    0.70124483f, 0.42809537f, 0.02055555f, -0.15512809f, -0.24928424f, -0.51134831f, 0.00516680f, -0.12429032f, 
    0.03333979f, -0.00188226f, -0.00325157f, -0.02518976f, 0.06846817f, -0.05666170f, 0.07448842f, 0.12055591f, 
    0.08709599f, 0.07025588f, 0.95186937f, 0.13565262f, 0.13439915f, 0.42990825f, 0.32583085f, 0.71081692f, 
    -0.37275434f, -0.07298207f, 0.56548971f, 0.09632050f, -0.89129925f, -0.11252764f, -0.48448694f, 0.26018989f, 
    0.00553121f, -0.02984158f, -0.15413174f, -0.09866727f, 0.04767739f, 0.28823525f, -0.18931256f, 0.06009030f, 
    -0.12111364f, -0.02011544f, -0.07144079f, -0.57310277f, -0.78524041f, -0.22646637f, 0.44871742f, 0.03476577f, 
    -0.99863976f, -0.30646822f, -0.47794616f, -0.50171870f, -0.08308586f, -0.07937778f, 0.32501590f, 0.10290897f, 
    0.38094869f, -0.39187625f, 0.09644300f, 0.06229503f, 0.38115409f, -0.06427610f, -0.27058569f, -0.06024482f, 
    0.04720510f, -0.04803950f, 0.15316769f, 0.11365283f, 0.73687029f, 0.65115601f, 0.78305012f, 0.44613713f, 
    -0.87376493f, -0.47116950f, -0.79914910f, 0.41438013f, 0.13719553f, 0.23267901f, 0.36822382f, 0.16438520f, 
    -0.30836999f, 0.18475185f, -0.32272130f, -0.22297724f, 0.07959907f, 0.21386074f, -0.21161759f, -0.11986954f, 
    -0.26129857f, -0.27447215f, -0.14091533f, 0.09333751f, -0.04161150f, -0.04732765f, 0.62421227f, 0.62525475f, 
    -0.30583420f, -0.54233855f, -1.21451652f, 0.12402642f, -0.66786021f, -0.75910395f, -0.58670723f, 0.15656930f, 
    0.05694395f, -0.16789274f, -0.01543781f, -0.27082309f, 0.03786665f, -0.25200868f, -0.19173242f, -0.07246734f, 
    0.13165642f, 0.08169862f, 0.04505375f, 0.25564432f, -0.04067590f, -0.12496892f, 1.06386936f, -0.61321491f, 
    -0.65766817f, -0.90692824f, 0.53992903f, 0.67191112f, 0.14168909f, -0.20622298f, -0.22918175f, -0.03405878f, 
    -0.18743767f, 0.15893419f, 0.05524945f, 0.01450573f, -0.07306285f, -0.28854632f, -0.11069516f, -0.06624678f, 
    -0.11962292f, -0.20841417f, -0.00349644f, 0.14540504f, 0.15550588f, 0.08886337f, -0.16491883f, -0.78470290f, 
    -0.12820783f, 0.44548845f, 0.24692714f, 0.26773465f, 0.76833558f, 0.32084331f, -0.14019309f, 0.20759171f, 
    0.37016192f, 0.56626689f, 0.02226811f, 0.09012748f, 0.09894154f, 0.08137704f, 0.31251904f, 0.33829725f, 
    -0.38562509f, 0.19322033f, 0.00151762f, -0.10399046f, 0.01787524f, 0.27787161f, 0.33578798f, 0.34192419f, 
    -0.49539670f, -1.06786156f, -0.70788175f, -0.49397644f, 0.46484452f, 0.07252637f, 0.78445828f, -0.25707337f, 
    -0.14747772f, 0.69194967f, -0.02904365f, -0.23180629f, -0.18860501f, -0.03369627f, 0.08318981f, 0.15681970f, 
    0.08917466f, -0.00449626f, -0.12906356f, -0.11857890f, 0.07692746f, -0.07744513f, -0.22983749f, -0.23427142f, 
    0.02268482f, 0.56283802f, 0.98832613f, 0.64611024f, 0.09417114f, 0.61098415f, 0.13490114f, -0.83231044f, 
    -0.80114943f, -0.02954401f, -0.40801257f, 0.05744711f, 0.11803641f, 0.20036738f, 0.40327942f, -0.18257667f, 
    -0.01606832f, 0.30353266f, 0.05593687f, -0.06882662f, 0.09641036f, 0.01467495f, 0.17189047f, 0.16385287f, 
    -0.00782774f, 0.04017234f, 0.55319893f, 0.59613854f, -0.65579414f, -0.99078017f, -0.54777926f, 0.40676385f, 
    0.38543209f, -0.34088123f, -0.12918134f, 0.17869988f, 0.13790931f, 0.15624909f, 0.43822932f, 0.47408727f, 
    0.30301067f, 0.17527620f, -0.02810403f, 0.03394147f, 0.08757135f, 0.34600252f, 0.10097302f, 0.26253000f, 
    -0.03343788f, -0.12208975f, 0.12920210f, -0.55147129f, -0.58730388f, 0.12764835f, 0.56394094f, 0.49775517f, 
    0.65511447f, 0.92379743f, 0.53740776f, 0.41423726f, 0.35930765f, -0.08262430f, 0.02244033f, -0.00462462f, 
    0.16519941f, -0.10149028f, -0.24399304f, -0.10783184f, -0.10389437f, -0.16729836f, -0.36653367f, -0.30736771f, 
    -0.11695611f, -0.01094297f, -0.19492359f, -0.46354461f, -0.69750690f, -0.59413558f, -0.57713658f, -0.65584314f, 
    0.00315772f, -0.39981955f, -0.29287606f, 0.07275854f, 0.73272371f, -0.49862352f, -0.12371372f, -0.52560979f, 
    -0.11251449f, 0.16455483f, -0.16918793f, 0.38660896f, 0.07088283f, -0.39574650f, 0.02829933f, -0.16217715f, 
    -0.07295162f, 0.06629659f, 0.36468604f, -0.00911328f, 0.15232779f, 0.94512057f, 0.69048661f, 0.60648584f, 
    0.96301597f, 0.52995133f, -0.62491482f, 0.70846063f, -0.31227279f, 0.42077953f, 0.34284958f, -0.10762596f, 
    -0.17141350f, 0.17448315f, -0.02084095f, -0.07271144f, -0.10389036f, 0.11564650f, 0.07364382f, -0.08403022f, 
    0.09076592f, -0.07563042f, -0.12627965f, -0.22145130f, 0.14251462f, -0.07313839f, -1.02916443f, 0.70059294f, 
    -0.18519025f, -0.61699468f, -0.22219394f, 0.53387290f, 0.24707769f, -0.46484798f, 0.51956606f, 0.05267522f, 
    -0.20286898f, -0.31242654f, -0.41362104f, -0.01628717f, -0.24005663f, -0.32391268f, 0.06587190f, -0.17686488f, 
    -0.24824293f, -0.37239066f, -0.22240707f, -0.03510467f, -0.15403864f, -0.18964347f, -0.25805131f, -0.83953208f, 
    -0.76750702f, -0.46765554f, -0.44012782f, -0.35161316f, -0.35520607f, 0.32080311f, 0.77829570f, 0.07770926f, 
    0.22710185f, 0.60080177f, 0.02299573f, 0.18676558f, -0.36570933f, 0.20364220f, 0.14268607f, 0.00112050f, 
    0.30260023f, -0.04884288f, 0.22772881f, -0.14472736f, -0.12460755f, 0.00944696f, -0.06696414f, 0.01942561f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09818089f, 0.10591026f, 0.09963503f, 0.18789421f, 0.27906245f, 0.29950696f, 0.16458389f, 0.32536376f, 
    0.15711644f, 0.09489123f, 0.58182776f, 0.06098996f, 0.28557700f, 0.21251526f, 0.13880914f, 0.08702325f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.45872045f, -0.27376637f, 0.02971843f, -0.32618561f, 0.01550805f, -0.06580821f, 0.01592695f, -0.24218111f, 
    -0.17719069f, 0.11269670f, 0.09301510f, -0.00242751f, -0.04086794f, 0.17537349f, -0.27364472f, 0.10476281f, 
    -0.01965563f, 0.04598301f, 0.12622878f, 0.19212832f, -0.26134413f, -0.01545717f, 0.11430334f, 0.12007055f, 
    0.35483143f, 0.08490346f, -0.16612861f, 0.03427502f, 0.17906544f, 0.01394725f, 0.13758305f, -0.13127038f, 
    0.06197249f, -0.22770774f, 0.15851019f, 0.19843304f, -0.09940791f, -0.03072932f, -0.14911507f, 0.15180057f, 
    -0.03580723f, -0.13235743f, -0.20774758f, 0.01774321f, -0.08898572f, 0.24425724f, -0.16508445f, 0.00546267f, 
    0.38344678f, 0.07804485f, 0.00811571f, 0.06629618f, -0.09691944f, 0.27279139f, -0.00763616f, 0.04597710f, 
    -0.00307031f, 0.19457434f, 0.03355709f, -0.06551782f, 0.25891969f, -0.03996187f, 0.00784526f, 0.23901545f, 
    -0.24106368f, 0.11624665f, -0.26983222f, -0.08963646f, 0.01399191f, -0.14075096f, 0.08209229f, -0.00085682f, 
    0.09426246f, -0.05185749f, 0.00057268f, 0.20524070f, 0.06973679f, -0.11923637f, 0.06434157f, 0.01046475f, 
    -0.05107752f, 0.07435470f, 0.17826954f, 0.04654909f, 0.19094561f, -0.06114358f, 0.16633217f, -0.28166753f, 
    0.14714059f, 0.05576605f, -0.16966744f, 0.01102558f, -0.15898606f, 0.04193219f, 0.02046995f, -0.30782452f, 
    -0.01082269f, -0.08684352f, -0.09522935f, -0.05904873f, 0.17910257f, -0.00634497f, 0.18396910f, -0.04234800f, 
    -0.11311653f, -0.06963925f, 0.03234749f, -0.22557673f, 0.33366001f, 0.32082278f, 0.12241250f, 0.09149178f, 
    -0.06123551f, 0.01887190f, -0.11013751f, -0.18672699f, -0.00835256f, -0.24364406f, -0.10670831f, 0.04073895f, 
    -0.00698219f, -0.21062545f, 0.25254607f, -0.05026173f, 0.08476809f, 0.21942219f, 0.11141286f, 0.07655802f, 
    0.10026141f, -0.21998407f, -0.30725443f, -0.13921650f, -0.23491438f, -0.00988780f, -0.18047175f, -0.08882207f, 
    0.22471561f, 0.17483728f, 0.19056669f, 0.32592025f, -0.04718278f, -0.00671982f, 0.12646459f, 0.15698326f, 
    0.16210210f, 0.18615848f, -0.38758636f, 0.31505150f, -0.11311688f, -0.07914639f, -0.24586256f, 0.01597378f, 
    0.06675606f, -0.02648271f, 0.19754680f, -0.02157093f, 0.13783839f, 0.15272249f, 0.01760944f, -0.08234720f, 
    0.13129905f, -0.06473695f, 0.01729693f, 0.01908162f, 0.08472021f, 0.06948674f, -0.06147113f, 0.14845552f, 
    0.38416347f, -0.28207076f, -0.00162158f, -0.02588851f, -0.09463084f, 0.11932137f, 0.12670246f, 0.12571652f, 
    0.04315000f, 0.24007551f, 0.20306370f, 0.16155338f, 0.00562594f, 0.14754078f, -0.30903402f, 0.05437902f, 
    -0.06478221f, 0.01882904f, -0.05503089f, 0.11497860f, -0.09928761f, -0.06330752f, 0.00039830f, -0.28729048f, 
    -0.04923838f, -0.01225755f, -0.01583312f, 0.05504676f, 0.17187233f, 0.06134368f, -0.11894163f, 0.04731579f, 
    0.13465621f, 0.01413893f, -0.03029109f, 0.01142293f, -0.26282531f, 0.30759636f, 0.10648274f, 0.15310049f, 
    0.09182701f, 0.11584812f, 0.01145965f, -0.00143200f, -0.06049703f, -0.01861095f, -0.03488204f, 0.00165714f, 
    -0.14829554f, 0.08958038f, 0.22458538f, -0.22999354f, 0.11615144f, 0.05364933f, 0.02191986f, -0.14207041f, 
    -0.06625828f, -0.01324400f, 0.07154643f, -0.16971070f, 0.14992015f, 0.04993718f, -0.00568623f, -0.02579378f, 
    0.09148995f, 0.03998437f, -0.09887817f, -0.11530119f, 0.04911053f, 0.10355166f, 0.09842449f, 0.19379532f, 
    0.20951347f, 0.08021227f, 0.03984047f, -0.16394137f, 0.09768149f, 0.21155907f, -0.01894717f, 0.04788609f, 
    -0.06669805f, -0.01930203f, 0.09944811f, 0.00216304f, 0.12192272f, -0.35791650f, -0.00371601f, 0.20071015f, 
    -0.01731394f, -0.19359306f, 0.10276001f, -0.03162609f, 0.01489918f, 0.07831980f, -0.12476763f, -0.04797758f, 
    -0.10691870f, 0.07774176f, -0.14868493f, 0.12062123f, -0.03330189f, -0.10636412f, 0.03337275f, -0.01290218f, 
    0.28503209f, -0.01653029f, 0.09519316f, 0.12034298f, -0.03536990f, -0.02706718f, 0.12170236f, -0.07276721f, 
    -0.11046047f, -0.01508852f, 0.06520512f, 0.01084068f, -0.09465808f, -0.14335801f, -0.07743701f, 0.06875209f, 
    -0.33313569f, 0.08179843f, -0.13465481f, 0.00625873f, 0.04321282f, 0.08312438f, -0.10516266f, 0.00823320f, 
    0.06589303f, -0.07243592f, -0.11464497f, -0.10801609f, -0.10000996f, 0.07221420f, -0.05452986f, 0.36206993f, 
    0.00822867f, 0.15342548f, -0.08355772f, -0.00961486f, -0.11745659f, 0.02406580f, -0.02600240f, 0.11914673f, 
    0.16726701f, 0.19429561f, -0.17860405f, 0.27535939f, 0.00420609f, -0.04254406f, -0.08937413f, 0.04252265f, 
    0.06057481f, 0.01868337f, 0.16973428f, -0.06451716f, -0.04124219f, 0.02959566f, 0.03935499f, -0.18831897f, 
    -0.02338108f, -0.20748973f, 0.14630696f, -0.07365417f, -0.04474961f, -0.06248664f, 0.01434305f, 0.00425537f, 
    -0.08806127f, -0.09724631f, -0.06782730f, 0.07893056f, 0.10883664f, 0.10795797f, 0.10124961f, -0.05989547f, 
    0.01784474f, -0.07306261f, 0.03872833f, 0.00135710f, -0.04081384f, 0.03843478f, 0.15975022f, -0.16982254f, 
    0.19758616f, -0.01284523f, -0.03879676f, 0.00045954f, -0.07112938f, -0.01982497f, 0.01105245f, 0.02116628f, 
    -0.10518806f, -0.07032800f, 0.06289891f, 0.22631669f, 0.06773806f, 0.01779652f, -0.00152369f, -0.04411189f, 
    0.03442219f, 0.00746471f, 0.02473454f, 0.00571298f, -0.21166210f, 0.01283399f, 0.00867774f, 0.25051364f, 
    -0.00869342f, 0.05129357f, 0.16053979f, -0.16837995f, 0.02553784f, 0.15797184f, -0.06322496f, 0.00623159f, 
    0.06257822f, -0.18526487f, -0.31900463f, -0.27792570f, -0.08399014f, 0.04014561f, -0.03548458f, -0.19831157f, 
    -0.10557018f, -0.07073546f, -0.00106598f, -0.08247307f, 0.22299008f, 0.24189799f, 0.11825335f, 0.03077107f, 
    0.10581439f, 0.09546748f, 0.00935304f, 0.04655506f, 0.14417389f, 0.07000155f, -0.07197523f, 0.07654507f, 
    0.36553821f, -0.02103812f, 0.01041278f, -0.10063750f, 0.10047913f, 0.00425496f, -0.11013496f, -0.15187560f, 
    -0.07957424f, -0.06587398f, 0.03185661f, -0.09299755f, 0.25514257f, 0.17592731f, -0.23329240f, -0.18848327f, 
    0.02012933f, -0.07042796f, 0.16476434f, -0.03936525f, -0.03436531f, 0.12557437f, -0.08624736f, -0.10684901f, 
    0.14365961f, 0.01671217f, -0.02586926f, 0.04720267f, 0.10605522f, -0.20787212f, 0.12031612f, 0.03644881f, 
    -0.20375451f, -0.08002099f, 0.18853259f, 0.01266025f, 0.32944319f, -0.10072352f, -0.04705501f, 0.09105461f, 
    -0.01765762f, -0.05627153f, -0.08523413f, 0.03997039f, -0.19561684f, -0.18579012f, 0.03669671f, -0.09246606f, 
    0.02876286f, 0.30410394f, -0.23120193f, 0.25763795f, 0.07984930f, 0.04520518f, 0.05089406f, -0.22711883f, 
    0.04836331f, 0.07619820f, 0.07633850f, -0.13628846f, -0.21522474f, 0.07550682f, 0.08509677f, 0.06273749f, 
    -0.36689740f, -0.03615355f, -0.01807413f, -0.17012061f, 0.17230901f, 0.10907416f, 0.04732383f, 0.17531654f, 
    0.14160964f, 0.15077533f, 0.00868313f, 0.01504392f, 0.09030414f, 0.15283185f, 0.19988376f, -0.04464465f, 
    -0.01329476f, 0.14225005f, -0.02767736f, 0.04190968f, -0.20478530f, -0.20340261f, -0.19997497f, 0.01290363f, 
    0.09406748f, 0.11340198f, -0.11996148f, 0.02351898f, -0.18011153f, -0.12438142f, 0.18858194f, 0.06861906f, 
    -0.21152735f, -0.06870228f, 0.09838267f, 0.05035591f, -0.05873515f, 0.05646732f, -0.00580808f, 0.10643718f, 
    -0.03920043f, -0.17796087f, 0.05817876f, 0.09125572f, -0.01152851f, -0.00995342f, -0.02959052f, -0.06195790f, 
    -0.02142565f, -0.37546018f, -0.14708576f, -0.14052841f, -0.05458324f, 0.00272999f, -0.00998532f, -0.02347171f, 
    0.10605156f, 0.06855244f, 0.01356891f, 0.07155042f, 0.34061825f, 0.14512001f, 0.08809033f, -0.00193256f, 
    0.06138371f, -0.03376438f, 0.12581687f, -0.07833556f, -0.52038193f, -0.33151489f, -0.08791140f, 0.04697123f, 
    0.03373904f, -0.00601597f, 0.05739921f, -0.10767047f, -0.29622453f, 0.03822476f, -0.02999229f, 0.02337882f, 
    0.00293291f, -0.21009327f, -0.14743805f, 0.18671881f, 0.06753352f, 0.09233553f, -0.03375385f, 0.11539672f, 
    0.07884461f, -0.00731600f, 0.17939033f, -0.04292470f, 0.08959902f, -0.11379765f, 0.16610101f, 0.03997605f, 
    0.15170424f, 0.11114977f, 0.12860471f, 0.09700809f, 0.08610106f, 0.04023948f, -0.14218363f, -0.10400289f, 
    0.05526333f, 0.05902951f, -0.07825538f, -0.08133922f, 0.03263557f, -0.00893721f, -0.07340288f, 0.01623644f, 
    0.03814086f, -0.05038761f, 0.00443641f, 0.04522665f, 0.00372890f, -0.00569222f, 0.02413545f, 0.03170458f, 
    0.00723107f, 0.05273747f, -0.06079262f, 0.06134049f, 0.06221260f, 0.00760019f, -0.00748806f, -0.04551306f, 
    -0.01481428f, -0.06986433f, -0.03502407f, -0.02182691f, -0.03740236f, 0.01078728f, -0.05387157f, 0.03978336f, 
    -0.05926048f, -0.06239884f, -0.07397448f, -0.04104469f, -0.01094078f, -0.05398124f, 0.00151525f, -0.06418261f, 
    -0.06361540f, -0.05338775f, 0.04547612f, -0.07111691f, -0.04499539f, 0.02253431f, 0.04472983f, -0.05429336f, 
    -0.05216257f, -0.04519582f, -0.04087307f, -0.03705100f, 0.00416943f, 0.00374151f, -0.01928391f, -0.01582521f, 
    0.05858570f, -0.07664458f, -0.03726355f, -0.05832864f, -0.03108963f, 0.07042950f, -0.04170785f, 0.02631333f, 
    0.01203134f, -0.03744820f, -0.01973885f, 0.03688316f, -0.04431117f, -0.03155997f, 0.03565897f, 0.06885738f, 
    0.06377400f, -0.04770156f, 0.04463858f, -0.04960322f, -0.03328475f, 0.02322260f, 0.00079560f, -0.02127643f, 
    -0.00409610f, 0.08332345f, 0.04828038f, -0.04103749f, 0.05320524f, -0.06037398f, -0.02378671f, 0.05911100f, 
    -0.00542676f, -0.03129383f, -0.00640975f, -0.03237952f, -0.00631288f, 0.05764683f, 0.04453290f, -0.03925540f, 
    -0.04152184f, -0.03747264f, 0.05189060f, 0.04429350f, -0.03624729f, 0.01300941f, 0.00850849f, -0.01922954f, 
    0.04122772f, -0.03741769f, -0.02763977f, -0.06793724f, -0.03690629f, 0.03558571f, -0.07383721f, 0.00908281f, 
    0.03796771f, -0.05867764f, -0.01707303f, -0.06959550f, -0.00382611f, -0.04964947f, -0.00875989f, 0.06261441f, 
    -0.06443677f, -0.01717328f, 0.04889764f, 0.03758875f, -0.03758046f, -0.01128283f, -0.00660893f, -0.03831810f, 
    0.03970625f, -0.00750603f, -0.01000171f, -0.02306643f, -0.00136960f, -0.07605842f, 0.03666475f, -0.01662172f, 
    -0.03398244f, -0.05063360f, -0.07349347f, 0.03271012f, -0.05822434f, -0.02202892f, 0.05608802f, -0.03518201f, 
    0.01326675f, -0.00173127f, -0.01732480f, -0.04767721f, 0.03379703f, 0.00272640f, 0.05534948f, 0.03354427f, 
    -0.04368910f, -0.06227582f, -0.02421754f, 0.01192675f, -0.04987439f, 0.05032023f, -0.01458186f, -0.05415655f, 
    0.03878429f, 0.01045125f, -0.07282748f, 0.03841634f, -0.01237031f, 0.01970710f, 0.02952286f, 0.02002642f, 
    0.03923967f, -0.05872655f, -0.05474862f, -0.03093471f, 0.00869577f, -0.02675949f, -0.06010721f, 0.02796244f, 
    0.00357499f, -0.02368608f, 0.05301620f, 0.06101811f, 0.03433809f, -0.06818534f, -0.01643496f, -0.00316786f, 
    0.06538989f, -0.07978829f, -0.05896940f, 0.03486568f, 0.02383105f, 0.03184144f, 0.00571099f, 0.04117537f, 
    -0.23063159f, 0.12369575f, -0.07562286f, 0.19478166f, -0.07262506f, 0.16386084f, 0.08680789f, 0.03355809f, 
    -0.00631384f, 0.00685463f, 0.10579544f, 0.06518468f, 0.49820265f, -0.33549181f, -0.18723811f, 0.01070914f, 
    0.07710233f, -0.16949210f, -0.02874913f, 0.02729518f, 0.03738658f, -0.08133787f, -0.02156408f, 0.05788369f, 
    -0.27173832f, -0.06455275f, -0.05832959f, -0.05296142f, -0.09251653f, -0.05026497f, -0.04356929f, -0.01731817f, 
    -0.03290096f, 0.03390908f, 0.00046028f, -0.12077336f, 0.46606278f, 0.35479671f, -0.01427699f, -0.20090258f, 
    0.04506007f, 0.08596332f, 0.07951891f, -0.07444499f, 0.00120134f, -0.03498809f, 0.14363366f, -0.13171102f, 
    -0.20897208f, 0.15136971f, 0.05531615f, 0.21603762f, 0.10786613f, -0.03859854f, 0.05601344f, 0.05898590f, 
    0.02765497f, 0.03308559f, 0.06840805f, 0.04834837f, -0.04595669f, 0.46467668f, -0.10303620f, -0.11463231f, 
    0.18110807f, 0.19570810f, -0.06564969f, 0.03729659f, -0.00467712f, 0.10319000f, -0.01178481f, 0.11849374f, 
    -0.11036370f, 0.12334042f, 0.16227956f, 0.13936968f, -0.03353972f, 0.04481136f, -0.02220081f, 0.05441859f, 
    0.02078038f, -0.13821511f, -0.00115460f, 0.17159183f, 0.16602774f, -0.09593745f, -0.11163628f, 0.18915415f, 
    -0.03642070f, 0.05042811f, 0.09655845f, 0.17281817f, -0.01188917f, 0.06421496f, -0.02852153f, 0.01448322f, 
    0.53092849f, -0.24821503f, -0.16016355f, -0.09858063f, -0.06857996f, -0.01958650f, -0.05143185f, 0.03577005f, 
    0.09733461f, 0.13141510f, -0.09025591f, 0.04940886f, 0.24881758f, -0.07341375f, -0.18977247f, 0.06453654f, 
    0.14146802f, 0.08754923f, 0.06733514f, -0.09124672f, 0.01235973f, 0.10697654f, -0.05018943f, -0.07349259f, 
    0.04002507f, -0.03789641f, 0.02920812f, 0.05522600f, -0.05646658f, -0.03154159f, 0.15217249f, 0.06995988f, 
    -0.08181166f, 0.08620507f, 0.07618764f, 0.03260425f, 0.44606358f, -0.24509753f, 0.10161741f, -0.10604063f, 
    -0.12879337f, -0.08836484f, -0.16920063f, 0.11789669f, -0.01665456f, 0.04223620f, 0.05937194f, -0.07199208f, 
    -0.18182947f, -0.18284740f, 0.13826919f, 0.06299721f, -0.05449472f, 0.07702820f, -0.04210924f, -0.05810864f, 
    -0.08103558f, 0.12674101f, -0.05026294f, 0.14142720f, 0.00629647f, -0.04483001f, 0.00717278f, -0.15090372f, 
    0.17604695f, 0.06945699f, 0.01445689f, -0.05563807f, -0.03043782f, -0.00915688f, 0.01711113f, 0.21417896f, 
    -0.33725587f, 0.09897473f, -0.07615264f, -0.03642303f, 0.03120446f, -0.04374693f, -0.07420282f, -0.03686615f, 
    -0.00034975f, 0.02749764f, 0.07548608f, -0.00600575f, 0.16322814f, -0.26415968f, 0.06248795f, -0.05532935f, 
    -0.01847481f, 0.01399318f, -0.09804840f, 0.11840916f, 0.01140818f, -0.14973946f, -0.03893850f, -0.01473088f, 
    0.02477683f, 0.05935976f, 0.09325572f, -0.02457184f, 0.09724350f, -0.16782227f, 0.02133304f, 0.08927376f, 
    -0.03318437f, 0.23231854f, -0.05573604f, 0.16717952f, -0.36663756f, 0.49806380f, 0.16116168f, 0.17298947f, 
    -0.03929134f, -0.13385007f, 0.00402749f, -0.12186585f, 0.01224347f, 0.04587385f, -0.08713344f, 0.13962510f, 
    0.03852070f, -0.06653650f, -0.01480833f, 0.07872923f, 0.25753632f, -0.08979925f, -0.02468704f, -0.03373259f, 
    -0.17233786f, 0.23831657f, 0.18302704f, -0.19289926f, -0.09467631f, -0.37988308f, -0.08106609f, -0.02019295f, 
    -0.05078345f, 0.01926721f, -0.05605637f, -0.17637916f, -0.00207790f, 0.04614033f, -0.10401749f, 0.12562343f, 
    0.11135577f, 0.11000053f, -0.30827442f, -0.16022086f, -0.21689229f, 0.23734124f, 0.06130029f, 0.20621346f, 
    -0.02867517f, 0.15345964f, 0.17750107f, -0.16667041f, -0.31506309f, -0.03569367f, -0.31036064f, 0.10718631f, 
    -0.05466698f, -0.20037587f, -0.11487129f, -0.03582734f, -0.17314750f, -0.03127871f, -0.11583782f, -0.08554699f, 
    -0.23706238f, -0.02190147f, 0.21163873f, -0.03193369f, 0.02554645f, 0.12719709f, -0.00302818f, 0.09519551f, 
    -0.05745279f, 0.07289748f, 0.15206876f, 0.06555135f, 0.21885824f, 0.29177693f, 0.29898417f, -0.04457992f, 
    -0.07360713f, 0.12457719f, 0.09088234f, 0.01253824f, -0.00794229f, -0.03521054f, -0.06485838f, -0.11867303f, 
    -0.35243908f, 0.13676107f, 0.22168168f, 0.06842956f, -0.29409721f, 0.10865638f, -0.21406303f, -0.04839417f, 
    -0.10185601f, -0.02245260f, 0.06187471f, -0.06559643f, 0.21608090f, -0.03255882f, -0.00921084f, 0.17189255f, 
    0.14323804f, 0.18449149f, 0.04245082f, 0.05127690f, 0.00727669f, -0.00759120f, 0.04176706f, 0.32558459f, 
    -0.06536264f, 0.01012071f, 0.07391810f, -0.02488124f, -0.10171632f, -0.00746117f, -0.02152780f, -0.03480550f, 
    0.05404681f, 0.12887663f, 0.15342166f, 0.08802694f, -0.18516693f, 0.23651777f, 0.19670443f, 0.03288408f, 
    0.04806297f, -0.07922477f, 0.08784996f, -0.18738171f, 0.21122168f, -0.13306920f, 0.04720700f, -0.02700183f, 
    0.12947366f, 0.16644488f, -0.28485990f, 0.16793078f, -0.04518755f, -0.02149407f, 0.15337603f, -0.10968095f, 
    0.03839524f, -0.05628612f, -0.13043989f, -0.11278098f, 0.01324860f, 0.11161174f, 0.07868189f, -0.27491292f, 
    -0.14098050f, -0.01381701f, 0.02695039f, -0.07265927f, 0.00587617f, 0.16904294f, 0.14257860f, 0.03156710f, 
    0.52615178f, -0.06122622f, 0.06148722f, 0.12549120f, -0.01540289f, 0.02867887f, -0.14379865f, -0.23566410f, 
    -0.03745383f, 0.05774031f, -0.11529054f, -0.18223590f, -0.02388402f, 0.09143859f, 0.04719934f, 0.15976033f, 
    -0.18466191f, -0.21520780f, 0.10829526f, -0.07510537f, 0.05806577f, 0.04590394f, -0.10188105f, 0.06064536f, 
    0.05794987f, 0.01708900f, 0.05435654f, 0.04658197f, 0.03175816f, -0.01936463f, 0.00660009f, -0.03995512f, 
    -0.01350224f, -0.02580343f, -0.04730315f, -0.02061616f, -0.06656360f, -0.06775587f, -0.03421027f, -0.05159761f, 
    -0.05295184f, 0.00960066f, -0.02835578f, -0.00247015f, -0.07591023f, -0.03676479f, -0.01575946f, -0.04945400f, 
    -0.06054413f, -0.06079537f, -0.00544018f, 0.03171883f, 0.04837720f, -0.04782487f, -0.02382645f, -0.01162931f, 
    -0.01097309f, -0.03155951f, 0.01163695f, 0.06431624f, -0.01968127f, 0.01897923f, 0.05108792f, -0.02974296f, 
    0.02354095f, 0.01273760f, -0.07149866f, 0.05248579f, -0.07248625f, -0.06968300f, -0.00898413f, 0.01846652f, 
    0.04547644f, -0.06616596f, 0.00145322f, -0.05934567f, -0.00945615f, 0.03098899f, 0.02246338f, 0.00676319f, 
    -0.00396757f, -0.00323540f, 0.03469284f, 0.03064689f, 0.02087637f, 0.03480198f, -0.03126745f, -0.07582495f, 
    0.02940531f, -0.01864963f, 0.03370785f, 0.00285618f, -0.06349339f, -0.07257351f, -0.01377829f, 0.06036982f, 
    0.03417303f, -0.02024715f, -0.06518798f, -0.06232653f, -0.06220707f, -0.05388973f, 0.04614364f, 0.05149695f, 
    -0.04697797f, 0.05465490f, -0.05584886f, -0.03463833f, 0.00711732f, 0.00294280f, 0.00648517f, -0.02754096f, 
    -0.03749005f, -0.00167933f, 0.06053924f, -0.04627507f, -0.02850161f, -0.07639676f, 0.03506726f, 0.03378738f, 
    -0.05241301f, 0.06074305f, -0.00501876f, -0.06327999f, -0.07639628f, 0.02548157f, 0.00731366f, 0.01146885f, 
    0.04755358f, -0.01125022f, -0.06269750f, -0.04142329f, -0.05786768f, -0.05704305f, 0.02015524f, 0.03421460f, 
    -0.08444402f, -0.07841217f, -0.02583387f, -0.01090235f, -0.00306023f, 0.00023451f, 0.03317695f, -0.06658255f, 
    -0.01291262f, 0.05493172f, -0.05519810f, 0.05638635f, -0.06000697f, -0.07846631f, -0.02275592f, -0.02150289f, 
    -0.01649534f, 0.03222606f, 0.06404218f, -0.07396118f, -0.03309950f, -0.01096336f, -0.04278679f, -0.03003420f, 
    -0.03364143f, -0.04376411f, 0.05385583f, -0.03570906f, 0.04697722f, -0.06926157f, 0.01456088f, -0.00892279f, 
    0.04897226f, -0.02384465f, 0.00636734f, -0.05074167f, -0.01989630f, -0.00111809f, 0.01959550f, -0.04035920f, 
    0.05006884f, 0.02471036f, 0.01060753f, 0.03880365f, 0.03184709f, -0.01231342f, 0.04496991f, -0.08138592f, 
    0.05349305f, -0.01671337f, 0.01467501f, 0.05830312f, 0.02423027f, 0.04540843f, -0.05182090f, -0.06623770f, 
    0.06015681f, -0.01843072f, -0.04172546f, -0.06501350f, 0.02548465f, -0.05414015f, 0.00762427f, 0.04659751f, 
    -0.03578840f, -0.00265718f, 0.03573005f, -0.05349840f, -0.07622392f, -0.03480647f, -0.00442529f, -0.04501516f, 
    -0.01651646f, 0.00745107f, -0.01583883f, -0.05644664f, 0.03044270f, -0.05045000f, -0.01797072f, -0.00137888f, 
    -0.29881784f, -0.44494253f, -0.24153900f, -0.15263820f, 0.00974328f, -0.08847781f, -0.02642370f, -0.12412201f, 
    0.03334494f, -0.13133207f, -0.18385576f, 0.29686704f, -0.30506104f, -0.27127871f, 0.19606014f, 0.12689173f, 
    -0.11563294f, 0.20742588f, 0.26805255f, 0.02067023f, 0.06712959f, 0.04988545f, -0.01608327f, 0.08550764f, 
    -0.01104596f, -0.14756800f, -0.12620685f, 0.06967217f, 0.10848272f, -0.05415007f, -0.00652867f, -0.09347909f, 
    0.15340544f, -0.01678384f, 0.06563108f, 0.06932481f, 0.36036879f, 0.16112374f, 0.30239138f, 0.26338485f, 
    0.12419903f, 0.10799537f, -0.03765382f, -0.01988711f, 0.06705271f, 0.09750814f, 0.13135974f, 0.13922441f, 
    -0.33835137f, -0.31140658f, -0.09448225f, -0.01020401f, -0.21698160f, 0.27120325f, -0.05316321f, -0.00065957f, 
    0.00406835f, 0.16746190f, 0.04304484f, 0.16483523f, -0.24584623f, 0.20928517f, 0.30830291f, 0.08742896f, 
    0.03437624f, 0.06415306f, -0.01278782f, -0.20581602f, 0.05257698f, 0.07798679f, -0.04484662f, 0.03250637f, 
    -0.17266369f, -0.46386227f, -0.03284990f, -0.21357948f, -0.01517468f, -0.14720473f, 0.06635524f, 0.04387787f, 
    -0.12186130f, 0.00098768f, -0.10042959f, 0.09428104f, -0.10208975f, 0.21463855f, -0.02340866f, -0.25521392f, 
    0.13712035f, 0.03287688f, -0.24500909f, 0.11844382f, 0.16064419f, -0.01673491f, 0.08581419f, 0.11922954f, 
    -0.12669240f, 0.08488803f, 0.08374377f, 0.18419686f, 0.02671734f, -0.01604450f, 0.15906315f, 0.01618270f, 
    0.03551607f, 0.04003172f, -0.10296185f, -0.00755859f, -0.23476742f, -0.16048232f, 0.00207744f, 0.06719549f, 
    0.11677717f, 0.02459069f, -0.12507871f, -0.15082505f, 0.13624236f, 0.04232815f, 0.08082981f, 0.04905084f, 
    -0.12070586f, -0.10127841f, 0.01699685f, -0.11833743f, -0.02585997f, 0.00561408f, 0.03585864f, -0.00261138f, 
    0.03236933f, 0.15595663f, -0.00005587f, 0.15103714f, 0.09469525f, 0.50450301f, -0.18491903f, -0.19186758f, 
    -0.06731893f, -0.05094550f, -0.07124888f, 0.07076843f, 0.10764222f, 0.00062631f, -0.14690854f, -0.04712540f, 
    0.26424766f, -0.00680911f, -0.12409930f, 0.28405917f, 0.08282809f, 0.12834749f, 0.10857219f, 0.14989677f, 
    0.15533836f, 0.02159053f, 0.04578390f, -0.05083996f, -0.13473508f, -0.16244493f, -0.14810126f, 0.09225447f, 
    -0.04502020f, 0.06632349f, -0.25525731f, -0.09736655f, -0.04049560f, -0.00794208f, 0.05556465f, -0.01061874f, 
    0.36922979f, 0.28035980f, 0.01352687f, -0.00978984f, 0.08311013f, -0.02235785f, 0.16390680f, -0.04100318f, 
    -0.10069592f, 0.03492282f, -0.08946605f, -0.02819070f, 0.27637476f, 0.06734151f, 0.03863915f, -0.01734164f, 
    0.14555714f, 0.10065547f, 0.12569554f, 0.11325835f, -0.10382550f, -0.12519759f, 0.06069294f, 0.13354589f, 
    -0.07475877f, 0.05230362f, -0.06139641f, 0.04187296f, 0.03508862f, -0.04665890f, 0.02792307f, -0.03059724f, 
    0.05976189f, 0.00751126f, 0.04877469f, -0.02077328f, 0.04043032f, 0.04784882f, 0.00276041f, 0.02936731f, 
    -0.03605188f, 0.00964510f, -0.06019503f, 0.02651554f, -0.01163186f, -0.06871019f, 0.05473281f, 0.01719042f, 
    -0.05603809f, 0.02060079f, 0.03712535f, 0.01311984f, -0.05835603f, -0.06267367f, -0.05736851f, 0.02141624f, 
    0.03549808f, 0.00952626f, 0.05163251f, -0.01417904f, 0.05512297f, -0.03440277f, -0.02041139f, -0.02429706f, 
    -0.04681955f, -0.02499025f, -0.01872002f, 0.01348508f, -0.06203780f, 0.06874504f, -0.00863891f, -0.04698714f, 
    -0.03418307f, -0.05871662f, -0.02533126f, -0.06669567f, -0.01485455f, 0.02728806f, 0.04687959f, 0.00272661f, 
    -0.03499471f, 0.00705350f, 0.06317357f, -0.00123218f, -0.00056316f, 0.06216052f, -0.03639997f, 0.03973796f, 
    0.02032183f, -0.06941254f, -0.04390485f, -0.05995984f, 0.00684841f, 0.05506601f, -0.04731436f, 0.00022039f, 
    -0.04987068f, -0.01909614f, -0.06576870f, -0.06178411f, -0.06144220f, -0.04023267f, -0.01801116f, -0.02230152f, 
    0.04764449f, -0.00577505f, -0.00297260f, -0.03658184f, 0.06076770f, -0.07253879f, -0.05124178f, -0.02355278f, 
    0.01555583f, 0.05806540f, -0.01476190f, -0.03755913f, 0.00992818f, -0.02309386f, 0.00713491f, 0.00829890f, 
    -0.03765834f, -0.00814316f, 0.05692695f, 0.00292955f, 0.06128519f, -0.06553756f, -0.03902773f, 0.00816552f, 
    0.00313831f, -0.02813830f, 0.05923742f, -0.06436826f, -0.00325896f, -0.05535445f, -0.05280499f, -0.01512656f, 
    0.06425563f, 0.06970255f, 0.05756377f, -0.03841239f, -0.04194206f, -0.04715038f, 0.04971471f, -0.05520700f, 
    -0.03050142f, -0.07493860f, 0.01296951f, 0.04587605f, -0.02276702f, -0.00659513f, -0.04033419f, -0.01302017f, 
    0.06348608f, -0.04904058f, -0.06439645f, -0.06688277f, -0.02666976f, 0.05178909f, -0.00540331f, 0.01342632f, 
    -0.02208157f, -0.03340273f, -0.00270357f, 0.05440572f, -0.03509315f, 0.01306746f, 0.04956260f, 0.03611603f, 
    -0.03898270f, 0.04394845f, 0.05142204f, 0.03005068f, -0.02311540f, -0.00085114f, 0.02094983f, -0.06120470f, 
    -0.06337378f, -0.05332299f, 0.00450191f, 0.00009379f, -0.03919638f, 0.01268575f, -0.05271200f, -0.07709929f, 
    0.01374367f, 0.01381862f, -0.04194851f, 0.00983661f, -0.03559013f, -0.04338415f, -0.00553366f, -0.07619550f, 
    -0.02744531f, -0.05615274f, 0.05508703f, -0.01418504f, -0.07165845f, -0.07702742f, -0.01419020f, 0.00095067f, 
    0.03776635f, -0.02018530f, 0.00984713f, 0.03702322f, 0.04689439f, 0.00190917f, -0.03140437f, -0.05570558f, 
    -0.05093612f, -0.03418818f, -0.03086272f, -0.06570965f, 0.01083745f, 0.00769833f, 0.01087952f, 0.02281930f, 
    0.05762672f, -0.06084849f, 0.06454968f, -0.03460795f, 0.01624178f, -0.02414523f, 0.07049372f, 0.01371335f, 
    -0.03206122f, 0.06529348f, -0.04000768f, 0.05738781f, -0.03983371f, -0.05765792f, 0.01459773f, -0.02395009f, 
    -0.03910370f, 0.06042282f, -0.05236286f, 0.00854267f, 0.01611895f, 0.00432425f, -0.03159792f, 0.03527430f, 
    -0.00329063f, -0.07167379f, -0.07198501f, 0.00312377f, 0.00727705f, 0.05373753f, 0.02306901f, -0.06934270f, 
    0.05256415f, 0.05925633f, -0.01546517f, -0.05520554f, 0.01884194f, 0.00778263f, -0.06343047f, -0.05540435f, 
    0.02730153f, -0.07155417f, 0.04730256f, -0.01679140f, -0.02492432f, 0.04704076f, -0.06521567f, -0.01432330f, 
    0.07019503f, -0.02092906f, 0.04021163f, -0.04818869f, 0.05949400f, -0.06581675f, 0.01320416f, -0.00304098f, 
    -0.06629334f, 0.01016628f, 0.02104868f, -0.06017494f, 0.02592154f, -0.01350233f, -0.03085448f, -0.02586512f, 
    0.02356100f, 0.00396919f, 0.06182247f, -0.02401443f, 0.02242236f, 0.06219148f, -0.02081617f, -0.04811639f, 
    -0.02569097f, -0.02372049f, -0.02320266f, -0.01376405f, -0.03548957f, 0.00654849f, -0.04664288f, 0.02615339f, 
    0.03788637f, -0.02561354f, -0.04281479f, 0.03046482f, -0.07100560f, -0.00070924f, -0.03878040f, -0.06832061f, 
    -0.06171090f, -0.03637139f, 0.06635235f, 0.02341735f, -0.05870827f, 0.00199316f, 0.00187839f, -0.03000545f, 
    0.00273521f, 0.02325750f, -0.00313248f, -0.05371361f, -0.07008639f, 0.00305286f, 0.01780595f, 0.04381592f, 
    0.00993789f, 0.02552263f, 0.02624061f, 0.01270830f, -0.03364694f, -0.00243770f, -0.06618845f, 0.05491338f, 
    -0.00197791f, -0.02484066f, -0.03095865f, 0.02295492f, -0.00579636f, 0.00791252f, -0.05987272f, 0.01133027f, 
    -0.01363926f, 0.06323928f, 0.06468142f, -0.04424374f, -0.00925340f, -0.04958132f, -0.00461300f, 0.00502373f, 
    0.03981138f, -0.02891299f, -0.03069495f, -0.03055246f, -0.02910683f, 0.06350341f, -0.01522967f, 0.00853079f, 
    0.03391348f, 0.00442003f, 0.03448238f, -0.02380834f, 0.04625332f, -0.05140788f, 0.06940164f, -0.06364611f, 
    -0.03165288f, -0.03836637f, -0.02595192f, -0.05343575f, 0.06216368f, -0.03198241f, -0.04490764f, -0.02018683f, 
    -0.05523945f, -0.05181727f, -0.01198173f, 0.02086543f, -0.02820011f, -0.04370762f, -0.01513917f, 0.01884280f, 
    0.03082154f, -0.01494475f, -0.02052062f, -0.07204501f, -0.03791897f, -0.03778809f, -0.06393949f, 0.00720022f, 
    0.00803742f, -0.06012210f, -0.02651202f, 0.00532867f, 0.05114555f, 0.07104349f, 0.03604541f, -0.03994795f, 
    -0.06560523f, -0.01731513f, -0.06184478f, -0.04574854f, 0.01790423f, -0.01171045f, 0.03099367f, -0.01122633f, 
    0.02213785f, -0.03473707f, 0.06780474f, 0.03639238f, -0.05683606f, -0.02931144f, 0.01313062f, 0.06716287f, 
    0.02481695f, 0.05440636f, -0.30326420f, -0.04170573f, 0.05963944f, 0.01345898f, 0.15379235f, -0.07065277f, 
    -0.03269088f, 0.09874386f, 0.07896157f, 0.07571871f, 0.28155664f, 0.13244951f, 0.18060277f, 0.27419141f, 
    -0.08982331f, -0.10129066f, 0.05894947f, 0.22296430f, 0.09420383f, 0.07796663f, -0.19845468f, -0.04709234f, 
    -0.06913272f, -0.05656674f, -0.14150569f, -0.02668291f, 0.02761465f, -0.02155841f, -0.06730960f, -0.11969671f, 
    0.02237514f, 0.11526176f, -0.01894139f, -0.08608384f, 0.31051013f, 0.14458443f, 0.08960540f, -0.21419246f, 
    -0.00041679f, 0.00372065f, -0.09963747f, -0.19173114f, -0.03319051f, 0.07200462f, -0.00256356f, -0.12530403f, 
    0.01338758f, 0.20551480f, -0.17814094f, -0.08770926f, -0.10007427f, 0.07273349f, 0.04438571f, -0.00791719f, 
    -0.03809623f, 0.05426957f, 0.03555419f, -0.06266148f, 0.23998471f, 0.08891045f, -0.28306550f, -0.00247056f, 
    0.05442062f, 0.00465820f, -0.08177621f, -0.00181468f, 0.03179205f, 0.03331432f, 0.02666472f, 0.00477609f, 
    -0.25891134f, -0.07857585f, 0.15071300f, 0.16547479f, -0.15613347f, 0.05522645f, 0.18820699f, -0.07160901f, 
    0.08654990f, 0.06647637f, 0.00537592f, 0.10402035f, 0.22842087f, 0.05845335f, 0.23298542f, 0.05690486f, 
    -0.07129447f, 0.09564628f, 0.02290746f, 0.04444381f, -0.17376937f, -0.14523292f, -0.18334809f, 0.01650668f, 
    0.40738380f, 0.03332056f, 0.13780190f, 0.22596911f, -0.12154863f, 0.07196865f, -0.09105700f, 0.09134531f, 
    -0.01367777f, 0.07973096f, -0.17458121f, 0.00922137f, 0.27599126f, -0.07292975f, -0.41488990f, 0.26526484f, 
    0.25373757f, -0.00043941f, -0.00180197f, -0.11061276f, 0.03821353f, 0.06454621f, 0.18045206f, -0.09949230f, 
    0.06441950f, 0.19632874f, -0.03336617f, 0.05143668f, 0.01627411f, -0.11331341f, 0.02803454f, 0.08981643f, 
    -0.07759676f, 0.08849299f, 0.03882074f, -0.04771145f, 0.17095585f, -0.07826223f, 0.15580608f, -0.20920298f, 
    -0.07372895f, -0.08653007f, 0.01778578f, -0.08004056f, 0.03229225f, 0.04209063f, -0.07801356f, 0.04312064f, 
    -0.11615488f, 0.18708183f, 0.08558016f, 0.11258726f, -0.07837426f, 0.08198956f, -0.12904313f, -0.13754481f, 
    -0.06617755f, 0.08170296f, -0.03222070f, 0.04003365f, 0.05308719f, -0.09802727f, -0.29782790f, -0.21453038f, 
    0.20156473f, -0.09722389f, 0.07226528f, -0.12434223f, -0.17746785f, 0.04896751f, 0.00332609f, 0.05846546f, 
    -0.14679924f, 0.28737932f, -0.08962043f, 0.01309463f, 0.03685166f, 0.05805778f, -0.04753901f, -0.01394163f, 
    0.17093943f, 0.01072591f, 0.03002022f, -0.05215235f, 0.28077519f, 0.09864640f, 0.30797383f, 0.02592969f, 
    -0.21957655f, -0.03641442f, 0.08895685f, -0.00277939f, -0.03011641f, -0.10631889f, 0.01494366f, -0.08820406f, 
    0.16552781f, 0.03578424f, -0.09795728f, -0.13809352f, 0.18304619f, 0.12635085f, -0.11990852f, -0.08454667f, 
    -0.08301240f, 0.22148055f, 0.16195722f, 0.05365577f, -0.12249376f, 0.42192152f, 0.10899560f, 0.06977069f, 
    -0.05473443f, 0.05455160f, 0.09040825f, 0.26165450f, -0.00402832f, -0.08627716f, -0.02725255f, -0.09421892f, 
    -0.00926856f, 0.29978186f, 0.20101313f, -0.24604508f, 0.05621511f, 0.06329808f, -0.06813965f, 0.05854492f, 
    0.02744904f, 0.05698616f, 0.06483701f, -0.02720790f, -0.09265821f, -0.09790506f, 0.11884183f, -0.35726190f, 
    -0.03504244f, -0.05153467f, -0.03301042f, -0.05326950f, 0.05019075f, 0.09412612f, -0.09852345f, -0.00284821f, 
    0.23990774f, 0.13465583f, 0.06557392f, -0.28033814f, 0.27727425f, 0.11996343f, 0.04233573f, -0.08177174f, 
    0.13902175f, 0.10968720f, 0.00038465f, 0.06273548f, 0.50815696f, -0.42835516f, 0.01651962f, -0.04463963f, 
    -0.10762472f, -0.05036106f, -0.02886529f, -0.15041596f, 0.01725026f, 0.02758903f, 0.10925792f, -0.01031186f, 
    -0.28063676f, 0.40194741f, -0.20132856f, 0.38842443f, -0.05981205f, 0.03577818f, 0.05529527f, -0.05717524f, 
    0.13747624f, 0.20187904f, 0.09200037f, 0.03853196f, 0.14916155f, -0.08921641f, 0.05651328f, 0.03120708f, 
    0.09855675f, -0.08669384f, -0.04541999f, -0.02000256f, 0.00091809f, -0.02821841f, 0.11556662f, 0.05774320f, 
    -0.11340612f, 0.05305336f, 0.27816874f, 0.14987001f, 0.11756064f, 0.00342163f, 0.03718071f, -0.11369511f, 
    -0.05246563f, -0.09171107f, 0.18440434f, -0.00817813f, -0.10321404f, -0.01004730f, -0.31236717f, -0.06706237f, 
    0.21312074f, 0.07093997f, -0.12713446f, 0.03633093f, 0.12982701f, 0.13100946f, 0.06950010f, -0.11587667f, 
    0.07017503f, 0.32736117f, -0.10615765f, 0.15000269f, 0.07390601f, 0.12409712f, -0.10216611f, -0.13443907f, 
    0.07546174f, -0.12663943f, 0.12414106f, 0.00467593f, 0.00851376f, -0.11716043f, -0.00789887f, 0.09910506f, 
    -0.04074820f, -0.10156041f, 0.05307711f, -0.01592948f, 0.02413972f, 0.01105739f, 0.02714909f, -0.03024165f, 
    -0.06668270f, 0.17251371f, 0.01811492f, -0.06703143f, 0.06209753f, -0.05916835f, -0.08717040f, -0.07593666f, 
    0.05768710f, -0.11102288f, 0.19627859f, 0.03422973f, -0.01580665f, -0.02660484f, -0.08056723f, -0.04563128f, 
    0.23789321f, -0.03276934f, -0.15810300f, -0.06285961f, -0.08027041f, 0.04804265f, 0.03722373f, -0.02083159f, 
    -0.03769466f, -0.05053234f, -0.13377246f, 0.06888276f, 0.05404478f, -0.04336923f, -0.08104418f, 0.04012500f, 
    0.10310357f, 0.05883257f, 0.19875062f, 0.29960412f, -0.07496843f, 0.11864700f, 0.28013927f, 0.14155261f, 
    -0.01490531f, 0.02146957f, 0.01785106f, -0.14259067f, -0.15999065f, 0.19816743f, 0.05546666f, -0.14547794f, 
    -0.37085620f, -0.25407964f, -0.22081900f, 0.15695667f, 0.03475687f, 0.05506955f, -0.08068434f, 0.00671327f, 
    0.14891207f, 0.02252137f, 0.04767478f, 0.03864113f, 0.20320955f, -0.27585638f, 0.01711079f, 0.04035252f, 
    -0.08692113f, 0.07293625f, -0.09051485f, -0.03999376f, -0.01246489f, 0.07490298f, 0.04777411f, -0.06959900f, 
    -0.44278073f, -0.18956311f, 0.06803168f, -0.02638462f, -0.04595016f, 0.05239816f, 0.09384927f, -0.09358088f, 
    0.05744391f, 0.21294214f, 0.08608671f, -0.14311890f, 0.24576715f, 0.24777888f, 0.27020460f, 0.06446457f, 
    0.02765464f, -0.05260380f, -0.00327706f, 0.03380394f, 0.15446872f, -0.06631798f, 0.10301523f, -0.01554934f, 
    -0.05052735f, -0.25696048f, -0.16408704f, 0.16275641f, 0.21436989f, 0.02259398f, 0.00336322f, 0.00648712f, 
    0.02968897f, -0.17954375f, -0.13288528f, 0.19808564f, -0.06138032f, -0.01156328f, 0.28943536f, -0.04780420f, 
    0.15290761f, 0.10142917f, 0.00229209f, 0.04615085f, -0.01377688f, 0.06846067f, -0.15886818f, 0.09228634f, 
    0.16801929f, 0.21315819f, -0.00219179f, 0.11539704f, -0.17999053f, -0.09656286f, 0.00458099f, 0.03793380f, 
    0.16955137f, -0.12121109f, 0.07558662f, -0.08791253f, -0.08102186f, 0.20678969f, -0.18021221f, 0.02120951f, 
    -0.03492188f, -0.10659337f, 0.07508826f, -0.02392392f, 0.03539298f, -0.12201456f, -0.05659126f, 0.19340040f, 
    -0.01934858f, 0.20584308f, -0.00684847f, 0.19204763f, -0.09274027f, -0.12173834f, -0.02914906f, 0.00027417f, 
    0.15553252f, -0.00493761f, 0.09102996f, 0.02068773f, -0.23079093f, -0.49301228f, -0.17364502f, 0.05908134f, 
    0.10320517f, 0.03781338f, 0.00477683f, 0.09182445f, -0.04855357f, 0.06912389f, 0.19239363f, 0.01588022f, 
    0.07660379f, 0.13311563f, -0.17119446f, 0.17213441f, 0.08273204f, -0.01287031f, 0.02039197f, 0.09957788f, 
    0.07139343f, 0.02274636f, 0.15577795f, 0.08607641f, 0.05159816f, 0.00104158f, -0.03533273f, 0.06869862f, 
    -0.12710521f, -0.13502809f, -0.04281468f, -0.10019614f, -0.05840098f, -0.07707773f, -0.05263277f, -0.09836899f, 
    0.17777008f, 0.03992091f, 0.28894576f, 0.00615187f, -0.07527496f, 0.01644373f, 0.04023111f, -0.15778990f, 
    0.04021652f, 0.22566831f, 0.14711773f, -0.04157255f, -0.22241636f, -0.31022033f, -0.18709724f, 0.17793964f, 
    0.06035149f, 0.00649297f, -0.10881215f, -0.08201844f, -0.07120779f, 0.11341187f, 0.20372346f, 0.02382414f, 
    0.04455484f, 0.21518987f, -0.02931036f, 0.06467900f, -0.11819823f, -0.08248606f, -0.00904004f, 0.03818073f, 
    -0.07630830f, -0.13608129f, 0.05030760f, -0.03832487f, 0.22539993f, -0.13602500f, 0.20938829f, -0.18984690f, 
    0.02386218f, 0.04102303f, -0.09335193f, -0.00384927f, -0.05728368f, 0.07735214f, 0.03332188f, 0.10634642f, 
    0.01853724f, 0.04816588f, -0.01282251f, 0.03577123f, 0.02480431f, -0.07592211f, -0.00252524f, 0.04871558f, 
    -0.06528458f, 0.03648204f, 0.00622654f, -0.07239938f, 0.00138957f, 0.02664081f, 0.06030933f, 0.00048023f, 
    0.04864490f, -0.04510026f, -0.01632656f, -0.03168235f, -0.01265324f, -0.00352142f, 0.06131467f, 0.05791912f, 
    -0.02199601f, -0.05501628f, -0.07380151f, 0.04643210f, -0.03172970f, 0.03674563f, 0.05530855f, -0.03323804f, 
    -0.05454767f, 0.02699390f, 0.03733708f, 0.06155962f, 0.01993910f, 0.03953355f, -0.04250579f, 0.01185256f, 
    0.02850375f, -0.05524644f, -0.01269597f, -0.03252000f, -0.00655787f, -0.00398690f, 0.06483307f, -0.02456487f, 
    0.06123486f, -0.04624324f, 0.01523952f, -0.07516133f, 0.04070623f, -0.06512339f, -0.04891551f, -0.04214372f, 
    -0.01500458f, 0.02432990f, -0.00212598f, -0.04366278f, -0.01840798f, -0.04955867f, 0.02363877f, -0.05969325f, 
    -0.07800438f, 0.00477849f, -0.01771685f, -0.05481467f, -0.06230081f, 0.00317389f, -0.01057750f, -0.02140056f, 
    0.05318782f, -0.03064504f, -0.07650494f, -0.05602955f, -0.03724264f, 0.03852077f, -0.01785084f, -0.02020806f, 
    0.00164168f, -0.03318618f, 0.01992920f, 0.01682078f, -0.07380710f, 0.01441240f, 0.00267095f, 0.01681891f, 
    -0.07994754f, -0.06859002f, -0.07291006f, -0.05340566f, 0.03994599f, -0.04213584f, -0.04187408f, -0.02763363f, 
    -0.00008589f, -0.05413793f, 0.01713030f, 0.04541937f, 0.02448872f, 0.03454972f, 0.03631322f, -0.06948226f, 
    0.04964498f, -0.03116655f, -0.07667657f, 0.05829015f, -0.04054342f, -0.02787255f, 0.00979552f, -0.00829870f, 
    -0.01105142f, 0.02008992f, 0.05519056f, -0.05704850f, 0.00776749f, -0.02514942f, 0.04693875f, -0.01308797f, 
    0.03880956f, -0.04776209f, -0.07669563f, -0.05078503f, 0.05483937f, -0.06741877f, -0.02558069f, -0.01566311f, 
    -0.00792274f, -0.07732049f, -0.05455727f, 0.04271847f, -0.00825897f, -0.02955342f, -0.07434828f, -0.01908150f, 
    -0.01064976f, 0.00400830f, -0.05490790f, 0.02688733f, -0.03921962f, -0.03854202f, -0.03878511f, 0.04427595f, 
    -0.01144570f, -0.08771844f, 0.00543831f, -0.03219251f, -0.01918527f, -0.02418095f, -0.06884599f, -0.01787874f, 
    -0.03110894f, -0.04038844f, -0.01294245f, 0.04192975f, -0.07507947f, 0.00583492f, -0.06691407f, -0.02316490f, 
    0.03970514f, -0.04169537f, -0.07690348f, -0.02302822f, 0.00884875f, 0.00569752f, 0.05386101f, -0.06631766f, 
    0.04221246f, -0.07980361f, -0.08483391f, 0.02677272f, -0.05557075f, -0.03584104f, 0.02305102f, 0.03222236f, 
    -0.05112899f, -0.00693044f, 0.01521691f, -0.03314555f, 0.03714339f, 0.04442167f, 0.02907976f, -0.04854910f, 
    0.00460958f, 0.05319417f, 0.01127952f, -0.05689278f, -0.07419883f, 0.01671932f, -0.01286716f, 0.05093577f, 
    0.14263700f, -0.16265000f, -0.13762446f, -0.12953319f, -0.03856421f, 0.03719858f, -0.13706228f, -0.15531540f, 
    -0.14697972f, 0.15795669f, 0.02391944f, -0.06246891f, -0.24554858f, 0.09646615f, 0.20022888f, -0.07103571f, 
    -0.07474435f, -0.05364170f, 0.00289067f, 0.13630410f, -0.01401693f, -0.17536865f, 0.06210876f, -0.06066457f, 
    0.03955483f, 0.01017882f, -0.16796651f, 0.24798220f, 0.08986072f, -0.02093671f, -0.02401474f, 0.14869785f, 
    0.10354279f, -0.03796013f, 0.09698790f, 0.21544451f, -0.43501773f, -0.00272246f, 0.25005108f, -0.00439733f, 
    0.03137999f, -0.07995946f, 0.10246602f, 0.07130327f, 0.15972735f, -0.02318088f, -0.24072988f, -0.05053270f, 
    0.17020445f, -0.25526014f, -0.00457647f, 0.03869369f, 0.07678018f, -0.04157035f, 0.11817005f, -0.09683264f, 
    0.13424318f, 0.16712537f, -0.16994613f, 0.20551518f, -0.02562941f, 0.02976880f, 0.04062907f, -0.15027829f, 
    -0.03391723f, 0.07415733f, -0.00128529f, -0.09371005f, 0.03937371f, -0.00136063f, 0.06158228f, -0.04107986f, 
    -0.10779294f, 0.17537580f, -0.05320456f, 0.11749149f, 0.04333992f, 0.04348404f, -0.06373848f, 0.06479213f, 
    -0.11137265f, 0.09337501f, -0.10903839f, -0.02759761f, -0.00618981f, 0.04060898f, -0.02467285f, -0.10624007f, 
    0.15532747f, -0.00237616f, -0.13964082f, 0.07860752f, -0.06385294f, -0.03067491f, 0.10502654f, -0.03837445f, 
    -0.02388555f, 0.10225467f, 0.26576656f, 0.16831370f, -0.12089099f, -0.12730309f, 0.18127021f, 0.01408088f, 
    -0.03020237f, 0.05677715f, 0.14831640f, 0.01597727f, 0.08011310f, -0.07696521f, -0.01408992f, -0.09210168f, 
    -0.04569568f, -0.03316683f, -0.18037426f, 0.04809293f, 0.32654744f, -0.12266806f, 0.03779937f, -0.24515916f, 
    0.12043006f, 0.10117619f, 0.01553183f, 0.07715074f, 0.08741958f, 0.26971298f, -0.10466827f, -0.02539242f, 
    -0.00913655f, -0.20206040f, 0.00215528f, 0.16547921f, -0.18912463f, -0.09797543f, -0.05291992f, 0.32361552f, 
    0.04239255f, 0.21407166f, 0.08863950f, 0.08270363f, -0.03598891f, 0.12836188f, -0.03015084f, 0.05721040f, 
    0.20129107f, 0.20050760f, 0.06185826f, -0.02931705f, -0.06717433f, -0.17160563f, -0.05433114f, 0.01392985f, 
    0.10394733f, -0.09696735f, 0.15590101f, -0.10414669f, -0.00594903f, 0.05645724f, -0.16218221f, 0.34041870f, 
    -0.08795116f, -0.03737543f, -0.00739440f, 0.13150273f, -0.06620758f, 0.06062530f, 0.03847248f, -0.08053543f, 
    0.37857956f, 0.10005239f, -0.04097056f, -0.16328098f, -0.12326381f, 0.12744324f, 0.01157536f, 0.14924942f, 
    0.01498025f, 0.06652640f, 0.12127144f, 0.14376512f, 0.00207291f, 0.19305585f, 0.21682875f, -0.03179423f, 
    -0.01004467f, 0.03428698f, -0.12463293f, 0.04419240f, -0.01610602f, 0.00769686f, 0.19618356f, -0.15229763f, 
    -0.19118093f, 0.09847253f, 0.08524369f, 0.08639698f, -0.01913054f, 0.04780738f, -0.09496068f, -0.02184953f, 
    0.09029334f, -0.11522535f, 0.14988658f, 0.10384261f, -0.12028664f, 0.06161165f, 0.15256259f, 0.10562621f, 
    -0.02009317f, -0.04066925f, 0.06763805f, -0.02048508f, -0.05845587f, -0.07391536f, 0.03784983f, 0.06815195f, 
    -0.30557027f, 0.23152231f, 0.18526821f, -0.34295335f, 0.00437424f, 0.21871524f, 0.07518888f, -0.09809306f, 
    0.05728802f, -0.03100218f, -0.06501599f, 0.02119766f, 0.40927282f, -0.02711985f, -0.02606596f, -0.04147277f, 
    0.05630286f, 0.08636684f, 0.04642159f, 0.01373445f, 0.04352033f, 0.20062491f, 0.08592165f, -0.03041861f, 
    -0.25831291f, 0.20363787f, 0.18354157f, -0.17598726f, 0.12744603f, 0.10139094f, 0.00960712f, -0.03716162f, 
    -0.00469736f, 0.00666969f, -0.04095349f, 0.01813208f, 0.01879540f, -0.26978815f, 0.18972185f, -0.17759740f, 
    0.01532115f, 0.02327531f, 0.16398591f, -0.03250168f, -0.01246502f, 0.10918266f, -0.08836212f, 0.12260836f, 
    -0.18876630f, 0.03980415f, -0.15264520f, -0.09387540f, -0.00635691f, -0.13704783f, -0.06298205f, -0.03410483f, 
    0.36189842f, -0.01814323f, -0.03631922f, 0.11452767f, 0.29795814f, -0.17180064f, -0.10162845f, 0.04027848f, 
    0.02011931f, -0.13112791f, -0.02150228f, -0.01587943f, -0.05483971f, 0.10963625f, -0.04191252f, 0.07946856f, 
    -0.06896198f, -0.09926679f, 0.00321061f, 0.03430862f, 0.01535229f, 0.01129088f, 0.01443331f, 0.07154945f, 
    0.06101275f, -0.04898484f, 0.13209122f, 0.06559183f, -0.47036740f, 0.17404599f, 0.07212052f, 0.08149453f, 
    0.04850770f, 0.11347722f, -0.19009037f, -0.03677187f, -0.01465530f, 0.17817496f, -0.03202441f, 0.02268369f, 
    0.08542101f, 0.29678208f, -0.18845209f, 0.28781146f, 0.14273044f, -0.09551746f, 0.01124895f, 0.00972830f, 
    0.12947550f, 0.04603501f, 0.14583069f, -0.10606904f, 0.31102204f, -0.23371802f, 0.01952562f, -0.04108800f, 
    -0.10386389f, -0.19696717f, -0.06680992f, 0.09608208f, 0.03876568f, 0.04638707f, -0.05101846f, -0.01703879f, 
    -0.03844303f, -0.23299763f, -0.07634819f, -0.02509360f, 0.04017273f, 0.07138401f, -0.05892369f, 0.07431567f, 
    -0.05362722f, -0.12457410f, -0.04160347f, 0.07151012f, 0.11912637f, 0.22943026f, 0.25438854f, -0.22647297f, 
    0.31568742f, 0.02320809f, -0.11904928f, -0.09690049f, 0.09094273f, 0.03718783f, 0.02920231f, -0.05926630f, 
    -0.10559208f, 0.03001040f, -0.14352918f, 0.14160120f, 0.04981645f, -0.05279076f, 0.12183256f, -0.04779739f, 
    -0.03034922f, 0.18600982f, 0.13531065f, 0.06499027f, 0.00847242f, -0.06861396f, 0.08998462f, 0.25810677f, 
    0.14000677f, 0.11105370f, 0.08215105f, 0.07444932f, -0.07685298f, 0.01428651f, -0.08532517f, -0.02585354f, 
    -0.00145437f, -0.00147474f, -0.14885153f, -0.10809118f, -0.14047916f, -0.04522787f, -0.02195773f, -0.14522846f, 
    -0.21366318f, 0.25591514f, 0.11877768f, 0.00789678f, -0.13799512f, 0.31284592f, 0.11247007f, 0.16735502f, 
    -0.04859728f, -0.02166340f, 0.08261532f, 0.18288223f, -0.08935614f, -0.04291699f, 0.02790318f, 0.11729749f, 
    -0.07232547f, 0.26532614f, 0.03475044f, -0.04508227f, -0.02513841f, 0.01612106f, 0.11645374f, 0.15073892f, 
    0.01206127f, -0.12981123f, 0.08200691f, 0.07879311f, -0.15297151f, 0.10447446f, 0.28364554f, -0.11126585f, 
    0.04580323f, -0.05485507f, 0.01426041f, -0.00588642f, 0.04423441f, 0.08993726f, -0.22886321f, -0.04796527f, 
    0.14612116f, -0.10267654f, 0.05729890f, -0.14849432f, -0.01993799f, 0.07910705f, 0.11303159f, 0.12743551f, 
    0.11265533f, 0.18187451f, -0.12524645f, 0.02949372f, 0.12309799f, -0.10738060f, -0.08373681f, -0.09681742f, 
    0.01749654f, -0.02083815f, -0.06406201f, -0.11400778f, -0.01585354f, -0.09901194f, 0.06737120f, -0.09108925f, 
    -0.32256740f, 0.31927776f, -0.19593440f, 0.47846535f, 0.08874577f, 0.13811506f, -0.05515460f, -0.02888668f, 
    -0.01759388f, 0.15991911f, 0.00667007f, 0.02789968f, 0.18367344f, 0.00277870f, 0.00224316f, -0.14058584f, 
    0.14124313f, -0.00852006f, -0.10177593f, 0.10562422f, -0.08617458f, 0.01384873f, 0.09665366f, -0.26000392f, 
    -0.14586547f, -0.02867521f, 0.28731343f, 0.16285567f, 0.05242699f, -0.06777678f, 0.02401727f, -0.12504487f, 
    -0.14437726f, -0.01955692f, 0.16797589f, -0.00822563f, 0.13922320f, -0.08804374f, -0.20136391f, -0.05809588f, 
    0.11412638f, 0.08800112f, -0.15621126f, 0.04516105f, 0.04122601f, -0.02962888f, -0.05118335f, -0.24915642f, 
    -0.01839151f, 0.14987017f, 0.02681618f, 0.05232195f, -0.00905224f, 0.06624626f, -0.08691289f, 0.03850522f, 
    0.10739514f, -0.18502562f, -0.06836975f, 0.07548304f, -0.01485005f, -0.26319155f, 0.04710049f, 0.10776399f, 
    -0.03171385f, 0.06221715f, 0.05931127f, 0.10187867f, 0.01356253f, 0.04264791f, 0.05048021f, 0.16772148f, 
    0.11440403f, 0.26646224f, -0.15227333f, 0.15158373f, -0.14473556f, -0.06897957f, -0.14061040f, -0.02384409f, 
    0.05539055f, -0.08377504f, 0.19221433f, -0.05217626f, -0.16019630f, 0.11294536f, 0.03240557f, -0.16137835f, 
    -0.00326614f, -0.00595855f, 0.03456414f, 0.00824742f, -0.11660346f, 0.04743593f, 0.02522111f, -0.02932931f, 
    0.29074046f, 0.13689314f, 0.02547445f, 0.01207019f, -0.10390718f, 0.12699947f, 0.04169351f, 0.12038971f, 
    0.10845365f, 0.09102021f, 0.22198570f, 0.22343600f, 0.14914060f, 0.03538919f, 0.18163954f, 0.01781021f, 
    -0.08925295f, -0.01994558f, -0.09234108f, -0.03206430f, -0.01756789f, 0.14023294f, 0.10091189f, -0.13976747f, 
    -0.04010317f, -0.00460173f, -0.03859238f, -0.05891973f, 0.02893360f, 0.00582567f, -0.06825848f, -0.07850350f, 
    -0.03170178f, 0.00716511f, 0.02212686f, 0.04823096f, -0.07431921f, -0.03190875f, -0.08486492f, -0.05781830f, 
    -0.07037852f, 0.04933733f, 0.04088542f, -0.07876121f, 0.06409436f, 0.04629426f, 0.00093353f, 0.00988146f, 
    -0.01048145f, -0.04208917f, -0.00496573f, -0.06685816f, -0.06857406f, -0.01827066f, -0.04830993f, -0.02727042f, 
    0.02311296f, -0.02825774f, 0.01019113f, 0.04606601f, 0.01686844f, -0.05556402f, 0.05184216f, 0.00394106f, 
    0.05015523f, -0.02590515f, -0.04589729f, 0.01640022f, 0.01382085f, -0.01134002f, -0.01218155f, -0.00242631f, 
    -0.07224367f, -0.00720117f, -0.07169621f, -0.00556081f, -0.03875959f, 0.01475154f, -0.00417921f, -0.06155821f, 
    0.03346352f, -0.03842247f, -0.00383421f, -0.02192230f, 0.05832330f, -0.08402827f, 0.04876488f, -0.02024333f, 
    0.05714175f, -0.05077729f, 0.01988148f, 0.03384812f, -0.04684200f, -0.03465488f, 0.01689432f, -0.06269537f, 
    0.05441004f, 0.01309313f, 0.01840830f, -0.03867390f, -0.02585804f, -0.04464353f, -0.02334388f, -0.04686958f, 
    0.04745729f, 0.05112161f, 0.05641824f, -0.06985013f, 0.05944792f, -0.05506988f, 0.05816596f, -0.00638580f, 
    -0.03950976f, -0.06830847f, -0.04712245f, 0.00676052f, 0.01440898f, -0.04179706f, 0.05717171f, -0.03399299f, 
    0.02118835f, -0.05733105f, -0.02759321f, 0.04409828f, 0.05192723f, 0.02380363f, 0.04502558f, -0.00809872f, 
    -0.06465019f, 0.04846088f, -0.04955431f, -0.01026171f, 0.02524708f, 0.06591379f, -0.03334381f, -0.07656719f, 
    0.00002747f, 0.00995597f, 0.01228053f, -0.04177754f, -0.00903521f, 0.05153510f, -0.04513400f, -0.06624512f, 
    0.01578283f, -0.05722267f, -0.00721921f, -0.06726608f, 0.01680152f, -0.04591480f, 0.03507731f, 0.00655679f, 
    0.05102691f, -0.06012953f, 0.00219887f, 0.03243687f, 0.04891463f, 0.06944339f, -0.01397196f, -0.03996982f, 
    0.02059943f, 0.02229828f, -0.03556161f, 0.01702810f, -0.05954536f, -0.01110141f, 0.02433104f, 0.01243847f, 
    0.04821741f, 0.02400398f, -0.07707479f, 0.01184619f, -0.06228283f, -0.03903808f, 0.06208104f, -0.00587779f, 
    0.03751457f, -0.04098508f, 0.04396102f, -0.03499578f, -0.05177634f, 0.01396381f, 0.04065495f, -0.04561448f, 
    0.02000095f, -0.02338036f, 0.01444300f, 0.03569844f, 0.02183213f, -0.02343822f, -0.01368173f, 0.01321586f, 
    0.01299941f, -0.01115413f, 0.01787031f, -0.05563538f, -0.00728608f, 0.02664264f, 0.00557414f, -0.06098112f, 
    0.05458333f, 0.04619171f, 0.01712726f, 0.02670690f, 0.04343919f, -0.02206351f, 0.02945114f, 0.02752144f, 
    -0.04742875f, 0.05504104f, -0.04751924f, 0.03106687f, -0.05707802f, -0.06458525f, -0.04584099f, -0.03785889f, 
    -0.30411729f, -0.15562719f, -0.17041044f, 0.09281387f, -0.04727137f, -0.02010833f, -0.05259835f, -0.03473207f, 
    -0.06994161f, 0.19449912f, 0.05954060f, 0.12865257f, -0.02072792f, 0.24122547f, -0.30967912f, -0.14968474f, 
    -0.04562771f, 0.01790028f, 0.08592606f, 0.01137813f, -0.24560905f, 0.11729147f, 0.12480997f, 0.09539383f, 
    -0.26075065f, 0.02603285f, -0.07038125f, 0.02162872f, -0.06148782f, -0.10311265f, 0.14531769f, -0.11755206f, 
    0.16450916f, -0.15858297f, -0.03517541f, 0.00592373f, 0.16266565f, 0.10965338f, 0.03862600f, 0.08605987f, 
    0.16541807f, -0.04978241f, 0.00512961f, -0.10949027f, -0.21605760f, 0.01000078f, -0.11005617f, 0.03211165f, 
    0.20796318f, 0.11082654f, -0.10583705f, 0.17889406f, 0.10758070f, 0.28340617f, 0.13837105f, 0.07210932f, 
    0.02976295f, 0.00829202f, 0.06842722f, 0.02001278f, 0.05206658f, 0.03835637f, 0.33171573f, 0.36016676f, 
    0.02974496f, 0.13822462f, -0.06370797f, 0.08425913f, -0.06328589f, 0.02207669f, -0.08020941f, -0.03635344f, 
    -0.15071918f, 0.44565257f, 0.04396913f, 0.34382975f, -0.05891772f, 0.05326425f, 0.11907159f, 0.14021322f, 
    0.05344303f, 0.21323779f, 0.16698635f, 0.17317721f, 0.10748331f, 0.01042133f, -0.08711363f, -0.10164188f, 
    0.00079744f, 0.01699309f, 0.08644444f, -0.10661439f, 0.01734872f, -0.10161799f, 0.06514731f, -0.20658776f, 
    -0.33982134f, 0.06493711f, 0.04106285f, -0.11125665f, 0.01387867f, -0.00715755f, 0.18419255f, 0.04342268f, 
    0.06198296f, -0.10998702f, 0.09631909f, 0.07710643f, 0.15064196f, 0.10884634f, 0.03863432f, -0.15256944f, 
    0.00954850f, 0.04311718f, -0.11684566f, -0.01545845f, -0.18871251f, -0.25441271f, -0.18069984f, -0.01363843f, 
    -0.17838514f, 0.02513004f, -0.02664074f, 0.02947398f, -0.03893628f, 0.00267049f, 0.02288754f, 0.08586201f, 
    0.20334925f, 0.01630079f, -0.09482015f, -0.03515562f, -0.14242844f, 0.06951356f, 0.17430590f, -0.17647260f, 
    -0.01011123f, -0.08217648f, 0.09845845f, 0.00211114f, 0.19531628f, -0.06260637f, 0.03580900f, 0.04160003f, 
    0.08372682f, 0.24733211f, -0.13404527f, 0.14892229f, 0.00712006f, 0.01308277f, 0.00592894f, -0.20691341f, 
    -0.05029675f, 0.17595230f, 0.13074376f, -0.05401856f, -0.35452977f, -0.02367285f, -0.02244575f, -0.22464363f, 
    0.09086700f, -0.00925317f, 0.04296491f, -0.04585842f, -0.14239796f, 0.14535454f, -0.01317362f, 0.11511570f, 
    0.72318959f, 0.13747959f, 0.12378433f, 0.25881183f, 0.07052255f, 0.17123939f, 0.26021755f, 0.12022089f, 
    -0.14613292f, 0.10826255f, 0.17230676f, 0.26734722f, -0.10396208f, -0.07919827f, -0.21624015f, -0.28036293f, 
    -0.06179035f, 0.02831864f, 0.00391713f, -0.07954750f, -0.04706735f, 0.06981166f, 0.12634353f, -0.06509273f, 
    -0.13696967f, -0.09384883f, -0.21649677f, -0.26149395f, -0.01127121f, -0.08872624f, -0.06581509f, -0.09730613f, 
    -0.02668935f, -0.14448120f, 0.11948258f, 0.14165185f, -0.01852526f, -0.08049044f, 0.31949711f, 0.33234897f, 
    0.00829377f, 0.05517511f, -0.07644799f, 0.13318194f, -0.03543150f, 0.06120805f, 0.02839982f, 0.11286660f, 
    0.02913603f, 0.04315924f, -0.21379417f, -0.10588079f, -0.07834090f, 0.13080154f, 0.01800891f, -0.03566425f, 
    0.09723967f, -0.12102887f, 0.15789941f, 0.06326792f, 0.13475634f, 0.21633288f, 0.36033207f, 0.12707047f, 
    -0.01406081f, 0.11104136f, -0.04887912f, 0.05165659f, -0.10228670f, -0.26108134f, -0.22244669f, -0.05491051f, 
    0.13932250f, -0.34910306f, 0.05930144f, -0.20788164f, -0.06215015f, 0.08658547f, -0.07591309f, 0.00252014f, 
    0.04223906f, 0.05684010f, -0.01795672f, 0.03495694f, 0.15408038f, -0.02616267f, 0.32485375f, 0.05947988f, 
    -0.14273189f, 0.11780931f, -0.02852775f, -0.12629382f, -0.06956436f, -0.04200140f, -0.00877265f, -0.07731488f, 
    0.03584534f, -0.07065064f, -0.15560442f, 0.50959891f, -0.04021699f, 0.02737294f, -0.17515463f, 0.03095142f, 
    -0.07719796f, 0.01364754f, 0.11182489f, 0.06870098f, -0.20342092f, 0.07627441f, -0.21916065f, -0.17389788f, 
    0.24466065f, -0.06486007f, -0.04391764f, 0.10011768f, -0.07143823f, -0.12582657f, -0.06633221f, -0.19308648f, 
    -0.19467594f, 0.17992236f, 0.00633419f, 0.34595796f, -0.09452589f, -0.11257438f, 0.28274432f, 0.14703162f, 
    -0.14949541f, 0.02395940f, 0.14487131f, -0.08104098f, -0.26864159f, -0.08285884f, 0.00426164f, -0.05917654f, 
    0.08509420f, 0.05282084f, -0.14230531f, -0.09997930f, -0.15160103f, -0.02026744f, -0.12518823f, 0.02887395f, 
    0.11139075f, 0.11663050f, 0.24467176f, 0.25051007f, 0.02674737f, 0.21156375f, -0.17523316f, 0.14676131f, 
    -0.01140630f, -0.00750631f, -0.13344054f, -0.08091245f, -0.43241441f, -0.04244171f, -0.20214932f, -0.06856601f, 
    0.11693648f, -0.02679262f, -0.11302090f, 0.32748011f, 0.08039429f, -0.00591065f, 0.15003817f, 0.04870868f, 
    0.41485113f, 0.21525037f, 0.05356604f, 0.41868082f, 0.00000617f, -0.09671961f, -0.05868054f, 0.22255640f, 
    -0.14803314f, -0.04090448f, 0.07803522f, 0.14356425f, -0.18272553f, -0.15023710f, -0.10401203f, -0.24659322f, 
    0.01139928f, -0.03675954f, -0.00931982f, 0.07976560f, 0.12512042f, 0.00626239f, -0.14355527f, -0.06400660f, 
    -0.22061342f, 0.36736804f, 0.02538412f, 0.03402033f, -0.05112303f, -0.08122385f, 0.24548750f, 0.15881449f, 
    0.12530081f, 0.07263122f, 0.26272196f, 0.09369313f, 0.14562432f, 0.35817552f, 0.19368607f, 0.35613462f, 
    0.17568707f, 0.05216630f, 0.01912461f, 0.17543112f, -0.18600912f, -0.10792597f, 0.05089394f, -0.15960023f, 
    0.16601469f, 0.09582518f, 0.26879939f, -0.03956787f, -0.06473803f, 0.06745441f, 0.09342622f, -0.07161278f, 
    0.02584729f, -0.13683181f, 0.12589762f, 0.01075266f, 0.27979442f, -0.09735877f, 0.00474629f, -0.22882916f, 
    -0.03039072f, -0.07560874f, -0.04564905f, -0.03217721f, 0.10752110f, -0.02993177f, 0.16049640f, 0.02655356f, 
    0.31459028f, 0.02126418f, -0.10724742f, 0.09198262f, -0.03204140f, 0.01340539f, 0.01501960f, 0.13681568f, 
    0.07074631f, -0.06243565f, -0.09123971f, 0.16565137f, -0.04049774f, -0.33713174f, -0.11182099f, -0.05462503f, 
    -0.13581780f, 0.01785685f, 0.05937162f, 0.27731708f, 0.05046298f, -0.11213359f, -0.07686922f, -0.12815276f, 
    -0.30568752f, 0.00911047f, 0.16788989f, 0.05116369f, 0.02488196f, -0.18240435f, -0.06780521f, -0.13683592f, 
    -0.00162351f, 0.02356029f, -0.06906785f, 0.04054697f, -0.06186407f, -0.06438705f, -0.09225802f, -0.43483311f, 
    0.14665180f, 0.17062069f, 0.01138087f, 0.10527522f, 0.04987344f, -0.04409875f, 0.11268616f, 0.10208583f, 
    0.20751543f, -0.19503359f, 0.06159288f, -0.38324845f, 0.17867403f, -0.04360181f, -0.07327697f, -0.10993691f, 
    -0.13694257f, -0.06336756f, -0.05582821f, -0.18969673f, 0.21612337f, 0.05873359f, -0.01976181f, 0.21180280f, 
    -0.00012107f, 0.08357847f, -0.16549115f, -0.05244080f, 0.00410038f, 0.22919434f, 0.04277468f, 0.00059009f, 
    0.43777972f, -0.07881375f, 0.19405986f, -0.04416332f, -0.13268426f, 0.03280811f, 0.04436402f, -0.01417100f, 
    -0.05601298f, 0.14287908f, 0.15092906f, 0.14444068f, -0.29055211f, 0.24231556f, 0.08463450f, -0.39085186f, 
    -0.01330959f, -0.03208505f, 0.05324342f, -0.02463042f, 0.00593093f, 0.00513071f, -0.02015392f, -0.10272525f, 
    0.03510617f, 0.05404305f, 0.03450907f, -0.25233561f, -0.04625615f, 0.18719073f, 0.06497495f, 0.07086360f, 
    -0.18064864f, 0.02692068f, -0.13697749f, 0.09603854f, 0.39787841f, -0.00658212f, -0.01511099f, 0.26696503f, 
    -0.03847166f, 0.16847755f, -0.05782207f, 0.26391214f, 0.00789389f, 0.18447399f, 0.04745599f, 0.06312079f, 
    -0.04018926f, -0.00722844f, 0.00278086f, -0.12998432f, 0.00665082f, 0.00561596f, -0.04649968f, 0.22171593f, 
    -0.02761725f, 0.03757042f, -0.02978563f, -0.02141984f, 0.39003623f, 0.17467073f, 0.05838419f, 0.29817602f, 
    -0.00321805f, 0.13446499f, -0.06915404f, 0.03350987f, 0.10655227f, 0.01722822f, -0.10551038f, -0.17727044f, 
    -0.15290467f, 0.05751868f, -0.10906883f, -0.10801961f, 0.00533568f, -0.08675359f, 0.04040332f, -0.00518729f, 
    -0.00880427f, -0.00965976f, -0.07048944f, 0.06232146f, 0.34037057f, 0.17376116f, -0.10655978f, 0.13656729f, 
    -0.03773135f, 0.01388265f, 0.00219726f, 0.18039127f, 0.02838255f, 0.02555002f, 0.08560506f, 0.01237062f, 
    -0.07239525f, 0.00186232f, -0.09610068f, 0.17595732f, 0.00554309f, 0.10819764f, -0.00435224f, -0.02313358f, 
    0.16647197f, -0.00068027f, -0.00558588f, 0.09408353f, 0.13216738f, 0.08099217f, -0.09164749f, 0.09487754f, 
    -0.06668883f, 0.06330914f, -0.11200643f, -0.00213670f, 0.09212451f, -0.03965947f, -0.14342344f, -0.10567000f, 
    -0.37182286f, 0.14297539f, 0.12459506f, -0.01553793f, -0.00452066f, -0.05841900f, 0.00894652f, -0.03590919f, 
    -0.02200926f, 0.09860981f, 0.04412643f, -0.00027141f, -0.03469603f, 0.01830740f, 0.03775314f, 0.03284806f, 
    0.05090829f, -0.13666093f, -0.02474337f, 0.05832941f, -0.01984040f, 0.02612015f, 0.23157904f, 0.11156736f, 
    0.15655448f, 0.01126550f, 0.08931687f, 0.08332495f, 0.23814574f, 0.15259822f, -0.01004387f, -0.06326021f, 
    -0.03178672f, -0.00666155f, 0.06618483f, 0.12060522f, -0.21088590f, 0.09931006f, 0.20068444f, -0.20622732f, 
    0.17953511f, 0.09667168f, 0.14331497f, -0.06367085f, -0.00355653f, 0.11820430f, 0.00365038f, 0.19496472f, 
    -0.13336794f, 0.62415880f, -0.00220273f, 0.20883359f, -0.02890718f, 0.03459771f, -0.00796628f, 0.14123519f, 
    0.25369966f, -0.12923566f, 0.14684592f, 0.15123750f, -0.11539689f, 0.06121980f, -0.09375902f, 0.07373804f, 
    0.14713937f, 0.01399565f, 0.09944283f, 0.08862782f, 0.17848371f, -0.09538841f, 0.05139175f, 0.16087388f, 
    -0.30969658f, -0.07304834f, -0.14188115f, 0.00154295f, 0.14135565f, -0.10494275f, -0.19298738f, -0.08164667f, 
    0.13314156f, 0.07619293f, -0.02138087f, -0.12446844f, -0.05747695f, -0.19750117f, 0.15291780f, -0.08403505f, 
    0.16818890f, 0.13986579f, -0.05670847f, 0.10204571f, -0.03924625f, -0.06285317f, 0.00019295f, 0.08945216f, 
    0.06143267f, 0.15835196f, 0.03305293f, 0.06437004f, 0.02112782f, -0.01633497f, 0.04034600f, 0.00702708f, 
    0.17597814f, 0.03156425f, 0.16306806f, 0.15781763f, 0.04987385f, -0.04632124f, 0.04121163f, 0.10472492f, 
    -0.00240557f, -0.27432781f, -0.05572860f, -0.10035347f, 0.06455703f, -0.03818560f, -0.01784158f, -0.28273594f, 
    -0.25747511f, -0.41592070f, -0.00011229f, 0.15623683f, 0.02522979f, 0.13041039f, -0.00350759f, 0.04522410f, 
    -0.09839252f, 0.00898189f, -0.08787116f, -0.02473178f, -0.12093408f, -0.34564725f, 0.08021301f, -0.01883661f, 
    0.17126098f, 0.03546467f, -0.13848187f, -0.08228888f, 0.05801638f, 0.03771565f, 0.20678188f, 0.21059127f, 
    -0.09643552f, -0.24350132f, 0.00757279f, 0.07598273f, -0.03868547f, -0.10630972f, -0.08165228f, 0.03539414f, 
    0.10241430f, -0.11625204f, 0.04450532f, -0.07719965f, -0.25506780f, -0.40689498f, 0.06883361f, -0.05172287f, 
    -0.06099806f, 0.00638998f, -0.02772732f, -0.02415680f, 0.01120230f, -0.06705234f, -0.02677327f, 0.09013349f, 
    -0.08021410f, -0.06486911f, -0.07239660f, 0.05534551f, 0.00589336f, -0.01960742f, -0.04853459f, -0.05704872f, 
    -0.00556412f, -0.01905001f, 0.04856636f, 0.02109311f, 0.05216485f, 0.00494293f, 0.05524367f, -0.07520189f, 
    -0.03551390f, 0.01468585f, 0.02436625f, -0.06715746f, 0.00336413f, 0.00802502f, 0.00947631f, -0.00495913f, 
    -0.06265862f, -0.05004301f, -0.00622093f, -0.07778422f, 0.04075218f, 0.03816255f, 0.03040591f, -0.07259880f, 
    -0.03827389f, 0.05047911f, -0.01936648f, -0.00032823f, -0.01950494f, -0.05265316f, 0.02184449f, 0.01624143f, 
    -0.03100234f, 0.02473424f, -0.07411981f, -0.08205425f, -0.04145505f, 0.05078648f, 0.03658712f, -0.01228903f, 
    -0.02305455f, -0.02170660f, 0.01930264f, 0.05454826f, -0.00884843f, -0.00960957f, -0.04316894f, 0.02223953f, 
    -0.03446276f, 0.02790595f, 0.05720128f, -0.03520145f, -0.01048526f, 0.01738770f, -0.03003670f, 0.06951953f, 
    -0.06772154f, 0.00728194f, -0.03177816f, -0.06284481f, -0.01807731f, -0.05589996f, -0.05792810f, -0.06262758f, 
    -0.00861269f, -0.03274830f, 0.05389757f, -0.01908035f, 0.00316596f, -0.02402446f, -0.03581487f, 0.01628238f, 
    -0.04707219f, -0.00449500f, 0.03786134f, 0.02007120f, 0.03458562f, 0.01128033f, 0.05475939f, -0.02925476f, 
    0.03287295f, 0.03615699f, -0.00020042f, -0.04248089f, -0.00452939f, -0.04244937f, 0.04203738f, -0.02453724f, 
    0.01945846f, 0.03996299f, 0.05642174f, -0.06283560f, 0.00797392f, -0.07518598f, -0.01891597f, -0.05118353f, 
    0.04208404f, -0.05521241f, -0.06714130f, -0.07246662f, -0.03324068f, -0.05380781f, -0.03304897f, 0.02895912f, 
    0.05450239f, -0.03920661f, 0.05395979f, -0.01401067f, -0.00585766f, -0.07801268f, 0.01825313f, 0.01530469f, 
    -0.05790695f, -0.02089463f, -0.02589502f, -0.07116814f, -0.00221706f, 0.02593690f, -0.06511248f, -0.06061044f, 
    0.03418432f, 0.03981237f, -0.06148667f, -0.08380961f, -0.00304589f, 0.02903537f, -0.00352101f, 0.03609556f, 
    0.01457878f, 0.00839043f, -0.08212658f, -0.01960272f, -0.01592789f, 0.06564142f, -0.06731978f, -0.04389926f, 
    -0.06471402f, 0.03048663f, -0.04261475f, -0.00929846f, 0.00620230f, -0.06540937f, -0.06835562f, -0.06140010f, 
    0.03394428f, -0.05626211f, -0.01933502f, -0.07670645f, 0.00096992f, 0.05656755f, 0.00287331f, 0.04575944f, 
    -0.07330641f, 0.05353319f, -0.04260720f, 0.05134865f, -0.07093748f, -0.06052143f, -0.03848689f, -0.07406793f, 
    0.03464449f, -0.07029503f, -0.03027441f, 0.02535371f, -0.04455635f, 0.05340429f, -0.05772429f, -0.02304616f, 
    -0.02917535f, 0.06703799f, 0.04343881f, 0.05629537f, -0.01301564f, 0.00173414f, 0.01246875f, 0.04243958f, 
    -0.06148399f, 0.02757721f, -0.03055370f, -0.00050577f, 0.03175005f, 0.01933694f, 0.01049892f, -0.04931415f, 
    0.04361080f, 0.21716093f, 0.07773846f, -0.06083617f, -0.10952701f, 0.08958483f, 0.11569075f, -0.07641652f, 
    -0.17648843f, -0.08539388f, 0.18416671f, 0.06361546f, 0.08535400f, 0.08060008f, 0.02900103f, 0.18315160f, 
    0.03077875f, -0.06400079f, 0.05760016f, 0.05842577f, -0.13699944f, -0.14170872f, 0.27053383f, 0.14013740f, 
    -0.24378256f, 0.45689550f, 0.04536929f, -0.29634061f, 0.04418574f, 0.19875272f, 0.07552461f, 0.11460633f, 
    0.07249014f, -0.09679450f, -0.13676389f, 0.14369516f, 0.17737390f, 0.00041688f, 0.07266212f, -0.08539837f, 
    -0.06592402f, 0.06402072f, 0.00821727f, 0.02312212f, 0.02756483f, 0.11396034f, -0.13133045f, -0.14839230f, 
    0.06112148f, 0.15032774f, 0.30023152f, -0.21883984f, 0.07116457f, 0.14734134f, 0.04332612f, -0.06584847f, 
    0.16470985f, 0.17095257f, -0.01137898f, -0.08193038f, 0.24128556f, -0.35150403f, 0.08455811f, -0.14382456f, 
    0.05335731f, 0.18976448f, -0.06514686f, -0.12824349f, -0.00188820f, -0.02657579f, 0.06894185f, 0.06333616f, 
    -0.22870819f, 0.26281500f, -0.20914073f, 0.50315195f, 0.12951709f, 0.04185949f, -0.07024521f, -0.10844745f, 
    0.00917897f, -0.00967409f, -0.07517135f, -0.01364112f, 0.35430247f, -0.09276129f, -0.06509122f, -0.02610753f, 
    0.08253117f, -0.08976749f, 0.04220706f, 0.09736872f, -0.05056907f, 0.16693740f, -0.01455362f, -0.18156283f, 
    0.24185976f, -0.30170241f, 0.16056208f, -0.02209528f, 0.07472567f, -0.05227517f, 0.00564824f, -0.06480786f, 
    -0.04914050f, -0.08811616f, 0.12122913f, 0.11756508f, -0.21162327f, 0.26127905f, -0.10625790f, -0.25574458f, 
    0.06270324f, 0.04765236f, 0.04606149f, -0.07238835f, -0.04525829f, 0.08425508f, -0.02432778f, -0.13536684f, 
    0.00129730f, 0.09987650f, 0.17098367f, 0.12335283f, 0.02793746f, 0.07736830f, -0.01987007f, -0.08519284f, 
    -0.01352144f, -0.05649903f, -0.14001106f, -0.11473830f, 0.26171204f, -0.40569162f, -0.13383105f, -0.02231077f, 
    0.00299863f, -0.04453822f, -0.03582212f, 0.18633717f, 0.11987960f, 0.24735335f, 0.09449904f, 0.18219693f, 
    0.03883699f, 0.02977539f, -0.05707460f, 0.17710830f, -0.13235088f, 0.04402212f, -0.13229392f, 0.10878705f, 
    -0.01752025f, -0.07878764f, 0.19250000f, 0.11387755f, -0.13249232f, 0.12525070f, 0.23510195f, -0.29525480f, 
    0.09637422f, -0.05500713f, -0.06136903f, 0.05170029f, 0.01891793f, -0.04746023f, -0.13300957f, 0.04100575f, 
    -0.32860100f, -0.06370849f, -0.05319661f, 0.12290169f, -0.04344861f, 0.09849761f, -0.00096737f, 0.02055989f, 
    0.08153463f, 0.20169696f, 0.22443710f, 0.24648301f, 0.06175382f, 0.03100204f, -0.03949663f, 0.29695156f, 
    -0.05028907f, 0.04626604f, -0.03568275f, 0.11191864f, -0.02682326f, -0.03268435f, 0.07849382f, -0.23351832f, 
    0.19242208f, 0.11940031f, 0.18051291f, -0.06314255f, 0.00625559f, -0.05641908f, -0.07277692f, 0.20841412f, 
    0.03465654f, 0.04093806f, 0.14935862f, -0.01234665f, 0.01638377f, 0.12506895f, -0.11432947f, -0.02623356f, 
    0.08656474f, -0.23608415f, 0.13171621f, 0.06084693f, -0.00857214f, 0.10132985f, 0.08350155f, -0.01549553f, 
    -0.12792063f, -0.28253525f, 0.07069736f, 0.00155830f, 0.17087059f, -0.13109922f, 0.00712064f, 0.02305166f, 
    0.02770429f, 0.07984084f, 0.01409953f, -0.00596822f, -0.00539912f, 0.00279772f, -0.32713330f, -0.16149092f, 
    0.06534871f, -0.03078395f, 0.07942948f, 0.09100129f, -0.11227045f, -0.01868900f, 0.08626566f, 0.08059317f, 
    0.19983420f, 0.27130383f, 0.08366874f, 0.17344649f, 0.17274319f, -0.06595907f, -0.14743912f, 0.07573661f, 
    0.13701782f, 0.03526743f, 0.08757947f, 0.00761025f, 0.22160669f, 0.35434657f, -0.15128593f, -0.04787540f, 
    0.02200930f, 0.02284947f, 0.02198950f, 0.15336426f, 0.04733726f, -0.02787587f, 0.05081852f, 0.16709188f, 
    0.07987623f, -0.02814904f, 0.12341123f, -0.05940114f, -0.06257813f, -0.02882887f, 0.16901350f, 0.08615858f, 
    0.05693770f, 0.12219162f, 0.13016208f, 0.13047630f, 0.08919407f, -0.27029389f, 0.13518190f, 0.17121716f, 
    -0.09088193f, 0.21364875f, 0.07984282f, 0.02764524f, -0.02760551f, 0.07748730f, -0.00028074f, 0.14147486f, 
    0.29193443f, -0.01141079f, 0.04496929f, -0.12010416f, 0.15266284f, 0.13536872f, -0.03045904f, 0.12169771f, 
    0.09230805f, 0.07672691f, 0.09135659f, 0.04610103f, 0.31823012f, 0.32749417f, 0.03030192f, -0.01697724f, 
    -0.02845569f, 0.01739260f, 0.00013716f, 0.00839809f, 0.11381125f, 0.02160166f, -0.09970383f, 0.05524296f, 
    0.23513384f, -0.06043371f, -0.20040804f, 0.20559020f, 0.03482556f, 0.11656577f, 0.09067149f, -0.01615856f, 
    0.08469751f, -0.01677485f, 0.04144423f, 0.00201399f, 0.01900136f, -0.17590946f, -0.01002644f, -0.01801423f, 
    0.05516587f, -0.03133972f, 0.19214912f, 0.07481926f, 0.04941616f, -0.07055536f, 0.01875679f, 0.11974453f, 
    -0.20444779f, 0.07251284f, 0.00668169f, -0.25935403f, 0.06706977f, 0.02656072f, -0.02365838f, -0.15087949f, 
    0.13704348f, 0.10032111f, -0.01549033f, 0.05583982f, 0.21785703f, 0.06076692f, 0.02920915f, -0.14877830f, 
    0.11424581f, -0.02671500f, 0.02852608f, 0.01083132f, 0.05225454f, 0.02345121f, 0.13820519f, 0.17200904f, 
    0.21553765f, -0.33243358f, 0.11569872f, -0.01254975f, 0.06961021f, 0.15798911f, 0.09421460f, -0.02892204f, 
    -0.04119071f, 0.13787852f, -0.02546426f, -0.07259176f, -0.38637671f, 0.04958311f, -0.06139423f, -0.03585553f, 
    -0.19549537f, 0.05935114f, 0.02656437f, 0.04875580f, 0.15083976f, 0.09639291f, 0.08194020f, 0.02073914f, 
    0.05007657f, -0.06984594f, -0.05770492f, 0.01406743f, -0.03300307f, -0.04593680f, 0.05050531f, -0.06611928f, 
    -0.08237693f, -0.05717326f, -0.04478980f, 0.03929926f, -0.07670201f, 0.02832292f, -0.02832865f, 0.03702571f, 
    0.01125094f, -0.05353782f, 0.02114652f, -0.05596544f, -0.02901012f, 0.04039659f, -0.05252458f, 0.03609547f, 
    -0.04645995f, 0.00520021f, -0.06282041f, -0.02863811f, -0.01373771f, 0.00520820f, 0.06219164f, -0.00875220f, 
    0.02281416f, 0.04595240f, -0.02446631f, 0.00788508f, -0.05474381f, 0.02737251f, 0.02777756f, -0.05154568f, 
    0.04166020f, -0.01597822f, 0.02468619f, -0.05930519f, -0.03734352f, -0.04111283f, 0.01736542f, -0.02761134f, 
    -0.01966014f, -0.07676869f, 0.05440018f, -0.06282480f, 0.04637524f, -0.06810809f, -0.07182517f, -0.03137592f, 
    -0.08040833f, -0.06513924f, -0.00643668f, 0.03962595f, -0.00237957f, 0.00723628f, 0.03393526f, 0.04053886f, 
    0.03383340f, 0.04674472f, -0.03211353f, 0.00781419f, -0.08096007f, 0.02404808f, -0.01190584f, 0.02455507f, 
    -0.04939225f, 0.01952477f, -0.00125582f, -0.06192816f, 0.02801383f, 0.02873107f, 0.01740136f, 0.03452116f, 
    0.06054791f, 0.00062120f, -0.05505331f, -0.05250666f, -0.06981354f, 0.03723597f, 0.01979449f, 0.06013492f, 
    -0.04091279f, 0.01272901f, 0.04040039f, 0.03323528f, -0.01087171f, -0.03421566f, 0.04973936f, 0.00578510f, 
    -0.07850136f, 0.02059601f, -0.04065103f, -0.05131178f, -0.00341788f, 0.04194917f, 0.00956280f, -0.03506968f, 
    -0.00919751f, -0.05779799f, -0.06581458f, -0.05606823f, -0.03778792f, 0.02494882f, 0.02632594f, -0.00588105f, 
    0.02080125f, -0.05736836f, -0.05424381f, -0.04597937f, 0.05061167f, -0.03414949f, 0.02344842f, -0.06818019f, 
    -0.05604446f, -0.03901665f, -0.04573860f, -0.05985647f, 0.02050373f, 0.05970587f, -0.06192448f, -0.05208438f, 
    -0.07065440f, 0.04628921f, 0.02062413f, -0.06776561f, 0.01937401f, 0.07170500f, -0.04047572f, 0.01013816f, 
    0.04822917f, -0.05442093f, -0.01559070f, 0.03214543f, -0.04054144f, 0.05396086f, 0.06257477f, -0.02673014f, 
    -0.03141588f, 0.00040860f, -0.00345343f, 0.04212509f, -0.07203316f, 0.02977250f, 0.03477634f, -0.02192929f, 
    -0.05756317f, -0.02583910f, 0.01297692f, -0.02808945f, -0.01850122f, -0.04822904f, -0.00777668f, 0.00298959f, 
    0.01726170f, 0.05684333f, 0.00701721f, -0.01413848f, 0.05390486f, -0.07122570f, 0.04325392f, 0.03144877f, 
    0.05486354f, 0.00585048f, 0.00852741f, 0.04877313f, -0.03727440f, 0.05087640f, -0.07289450f, -0.03957761f, 
    -0.02508564f, 0.02456617f, 0.05428441f, 0.00284265f, 0.05090095f, -0.06514134f, -0.07715082f, -0.02333081f, 
    -0.05657158f, 0.02135726f, 0.04877118f, -0.08060768f, -0.05217048f, 0.03145097f, 0.02451562f, -0.01291510f, 
    -0.00665900f, -0.01761703f, -0.01116160f, -0.05186059f, -0.03506072f, 0.04992516f, 0.01662659f, 0.02750259f, 
    -0.02116507f, 0.00896575f, -0.06775031f, -0.03067552f, 0.06475833f, -0.04815890f, 0.02215074f, 0.02468630f, 
    -0.03695212f, -0.00589149f, 0.06588949f, 0.02520719f, -0.05202653f, 0.05455484f, 0.05676007f, 0.00862684f, 
    -0.00629975f, 0.06754293f, -0.07314368f, -0.02485639f, -0.01084657f, -0.07653752f, -0.00903169f, 0.04310801f, 
    0.02078662f, -0.03112085f, -0.05270639f, -0.04758353f, -0.02701956f, -0.02117870f, 0.00238752f, -0.03735275f, 
    -0.07328685f, 0.05090163f, -0.07184333f, -0.03407022f, 0.00235006f, -0.07178511f, 0.03249373f, 0.06554601f, 
    -0.04148511f, -0.00236294f, -0.06283829f, -0.07301445f, 0.05082360f, 0.04629346f, 0.05639002f, -0.03164325f, 
    0.06201374f, -0.02370673f, -0.06402916f, 0.06196162f, -0.03307610f, 0.04736203f, 0.04645038f, 0.00200739f, 
    -0.00544942f, 0.00274661f, 0.02872316f, 0.02309760f, -0.01159708f, -0.00464117f, -0.04202195f, -0.00688678f, 
    0.03117241f, -0.05684624f, -0.04105939f, -0.06040898f, 0.03811423f, 0.00434413f, -0.01537424f, -0.03217492f, 
    -0.05693929f, 0.04912750f, -0.03282159f, -0.06337037f, -0.06564573f, -0.05160307f, -0.00889217f, -0.05652113f, 
    -0.03639959f, -0.06468918f, 0.05255621f, -0.01452142f, -0.00058823f, -0.02366595f, 0.06095329f, -0.05845169f, 
    0.04724003f, -0.04735809f, 0.02110155f, -0.00434414f, 0.00140371f, -0.00811981f, -0.05735174f, -0.00863894f, 
    0.00708322f, -0.04341566f, 0.01842738f, 0.06365960f, 0.01769186f, -0.02519302f, 0.05835303f, 0.02160147f, 
    -0.06147999f, 0.03796107f, -0.02436673f, 0.05205363f, -0.06333327f, -0.04004014f, -0.05584292f, -0.01835397f, 
    0.03406149f, 0.06357074f, 0.00734091f, 0.00027189f, 0.05891072f, -0.01044047f, 0.00396700f, 0.00376930f, 
    -0.05191693f, -0.07360408f, -0.05588957f, -0.07332344f, 0.02304199f, -0.04319542f, -0.07529922f, 0.04528240f, 
    0.04211529f, -0.06930882f, 0.03066947f, -0.02673271f, -0.03825540f, -0.02670829f, -0.07088902f, 0.00320256f, 
    -0.01552688f, -0.06349266f, 0.00921157f, -0.05516925f, -0.02540213f, -0.05752901f, -0.05541642f, -0.01022246f, 
    -0.01748001f, -0.03480042f, -0.03655060f, 0.00572717f, -0.02409565f, 0.05639433f, 0.06567807f, -0.03376369f, 
    0.01474970f, -0.07066504f, 0.04981137f, -0.02005153f, -0.07320210f, -0.04182443f, -0.00852356f, -0.04100543f, 
    0.03321808f, -0.01459342f, 0.02772009f, -0.00757997f, -0.04547997f, -0.02224839f, -0.05352078f, -0.04754978f, 
    0.07106844f, -0.03690220f, 0.00507027f, 0.01411604f, 0.06375069f, 0.04033350f, 0.01703355f, 0.00600669f, 
    0.01936682f, 0.00176175f, -0.04913761f, -0.03838027f, -0.07694500f, 0.02068071f, 0.00941682f, -0.00133540f, 
    0.24287689f, -0.07645597f, 0.14956476f, -0.14676374f, 0.16817568f, -0.05399889f, -0.00619413f, 0.10907883f, 
    0.18978241f, -0.14737988f, -0.03315048f, 0.06517518f, -0.12067076f, -0.02209804f, 0.02491896f, -0.26744273f, 
    0.01249619f, 0.03284927f, 0.09140393f, -0.09314604f, 0.16948102f, 0.09947407f, 0.04428094f, -0.16275404f, 
    0.23397417f, -0.40628022f, 0.01366490f, -0.09864110f, 0.21069089f, 0.00583786f, -0.05695961f, -0.02406757f, 
    -0.01744026f, 0.02241078f, 0.00578180f, -0.00158230f, 0.08827007f, -0.06491192f, -0.29095498f, 0.02355530f, 
    0.01105151f, 0.04040432f, 0.02696659f, 0.12591720f, -0.01155126f, -0.10401984f, 0.19742462f, 0.19132446f, 
    0.06459676f, 0.28481323f, 0.03048164f, -0.09646346f, 0.12310507f, -0.23566134f, -0.17478995f, -0.21051496f, 
    -0.07692444f, -0.00393701f, 0.13041943f, 0.08500049f, 0.27262822f, -0.01316423f, 0.05030220f, 0.10238967f, 
    -0.07278655f, -0.11558518f, 0.07184469f, 0.00463570f, 0.14183626f, -0.00328292f, 0.02963061f, 0.14069696f, 
    0.33949873f, -0.52497876f, 0.23900424f, -0.29641655f, 0.06603932f, -0.14820017f, 0.02953247f, -0.03069746f, 
    0.02137989f, 0.03862824f, 0.13054387f, -0.12530966f, -0.11978203f, -0.07203326f, 0.13119608f, 0.21420333f, 
    -0.00040225f, 0.18802725f, 0.00195768f, -0.07294112f, -0.09699953f, 0.08723060f, -0.09143897f, 0.28687754f, 
    0.34494692f, 0.12403818f, -0.08402941f, -0.12063484f, 0.07588427f, 0.09079520f, 0.08113644f, 0.04884448f, 
    -0.03495234f, 0.13567865f, -0.08054857f, -0.10428330f, -0.06251125f, 0.06326674f, -0.02332925f, 0.01903808f, 
    -0.02180000f, -0.08509646f, 0.15560770f, -0.06029831f, -0.00957541f, 0.10083336f, 0.17104581f, 0.34198445f, 
    0.12047753f, -0.06644513f, -0.04899252f, -0.01564554f, 0.11153226f, 0.01372494f, 0.10764536f, 0.02839955f, 
    -0.04548652f, 0.17077985f, 0.12934910f, 0.04926294f, -0.07857987f, 0.40130675f, -0.05645153f, -0.12664698f, 
    0.02601247f, -0.01823426f, 0.01131999f, -0.08744058f, -0.09456576f, -0.07408053f, -0.13304903f, -0.11480300f, 
    -0.02088244f, 0.06038497f, 0.15192132f, -0.15605368f, 0.22490011f, 0.12549540f, 0.04042993f, 0.16136387f, 
    -0.04709372f, 0.10919954f, -0.05614263f, 0.06731549f, 0.29525164f, 0.04632599f, -0.09090893f, 0.09457405f, 
    0.09114702f, 0.04204587f, 0.03530613f, 0.08200340f, 0.08562532f, -0.10336687f, -0.07087035f, -0.07091801f, 
    -0.31905654f, -0.07038347f, 0.03140067f, 0.07233664f, 0.11210082f, -0.16711378f, 0.07767884f, -0.10701554f, 
    0.03253676f, 0.05228966f, -0.04487554f, -0.17781277f, 0.01709354f, 0.15970147f, 0.08914671f, 0.06926274f, 
    0.00678952f, 0.09617055f, 0.19819462f, -0.00809625f, 0.02798892f, 0.10968739f, -0.06949765f, 0.06877117f, 
    0.00448088f, 0.00372204f, 0.06169463f, -0.08109199f, -0.01331504f, -0.05299680f, 0.05634909f, 0.04553868f, 
    0.00832204f, -0.00199479f, 0.04881351f, -0.04003760f, -0.07053686f, 0.00360726f, -0.03805637f, -0.02162185f, 
    -0.07435355f, 0.03430286f, -0.00956880f, 0.04164463f, 0.03797058f, 0.05637885f, -0.02876137f, -0.06164851f, 
    0.04647409f, 0.01392660f, -0.06175416f, -0.08048383f, -0.04567742f, 0.01650314f, -0.00684113f, 0.03832591f, 
    0.02302964f, 0.01121270f, 0.01600464f, -0.02146613f, 0.01040098f, -0.01029027f, -0.00735193f, -0.03406503f, 
    0.03457192f, -0.06740501f, -0.06439712f, -0.03197699f, 0.03004664f, 0.04950489f, -0.01784911f, 0.05829968f, 
    0.01843323f, -0.01588989f, 0.04833233f, -0.00226940f, -0.03774798f, -0.05735913f, 0.03907506f, -0.03496160f, 
    -0.04181607f, 0.04403513f, -0.07575720f, -0.02111207f, -0.05639094f, 0.03023035f, 0.05861851f, 0.03942617f, 
    -0.04473668f, -0.01814179f, 0.02816240f, 0.02906207f, 0.02539105f, 0.00479359f, 0.06335691f, -0.05042988f, 
    -0.01272214f, 0.03734134f, -0.02145081f, -0.05183221f, 0.05792727f, 0.03006450f, 0.03206282f, -0.00790840f, 
    0.00387923f, -0.05900685f, -0.01424912f, -0.02303392f, 0.02946851f, 0.06398270f, -0.00932173f, -0.04584360f, 
    -0.05114233f, -0.06154336f, -0.05362928f, 0.00295278f, 0.03045367f, 0.04648118f, 0.01464377f, 0.03223077f, 
    -0.06179952f, -0.01980631f, 0.04391620f, 0.02762138f, 0.06200010f, -0.06135749f, 0.03543788f, 0.04841811f, 
    -0.03691146f, -0.03070192f, 0.02111268f, 0.00564315f, -0.04643152f, -0.01532724f, 0.00963148f, -0.03018395f, 
    -0.02854924f, 0.01191721f, -0.01384586f, 0.04323317f, -0.02852449f, 0.00069734f, -0.08342014f, 0.03660407f, 
    -0.01449799f, -0.06927846f, -0.06237176f, 0.00658131f, -0.02292733f, -0.03898590f, -0.07460643f, -0.06917817f, 
    0.00980075f, -0.04688578f, -0.08704364f, -0.06538214f, 0.04690306f, -0.03487406f, -0.03897506f, 0.06273402f, 
    -0.00998810f, 0.03421384f, 0.06157153f, -0.05234680f, -0.06236226f, 0.05743611f, -0.08071061f, 0.06010700f, 
    0.02341203f, -0.07138205f, -0.04846305f, 0.03236235f, -0.03375449f, -0.06797019f, 0.01350057f, -0.00401294f, 
    0.00563478f, 0.02513205f, -0.07996558f, -0.07685634f, -0.06008377f, -0.00919321f, -0.01266744f, -0.00448836f, 
    0.05514370f, 0.00877464f, 0.02269678f, 0.05846495f, -0.04759329f, -0.03069786f, 0.05240430f, 0.00647330f, 
    -0.08734640f, -0.00749400f, -0.07505839f, 0.02125748f, -0.06488236f, 0.02801856f, -0.02482085f, 0.03314887f, 
    0.00734401f, -0.07141080f, -0.02938717f, -0.06188622f, -0.03570072f, -0.04953872f, 0.00464640f, 0.01055208f, 
    0.04489785f, 0.02998025f, -0.03869371f, -0.00530543f, -0.02721235f, -0.04939301f, -0.00747064f, -0.07162789f, 
    -0.03129474f, 0.45945689f, 0.08190609f, 0.40707517f, -0.16093799f, 0.08272170f, -0.01239697f, 0.13051079f, 
    -0.03237849f, 0.03704330f, 0.31867489f, -0.10133361f, 0.22751179f, -0.37730274f, -0.11688835f, -0.10349464f, 
    0.08326637f, 0.15606672f, -0.06498042f, -0.12151904f, 0.00613561f, 0.03932137f, 0.10165758f, 0.17343487f, 
    0.34489161f, 0.25847599f, 0.11771194f, 0.24958646f, -0.27513221f, 0.08471782f, 0.11709312f, -0.02041200f, 
    0.09343018f, 0.02440812f, -0.00653313f, 0.06608134f, -0.18653020f, -0.02493512f, 0.11597545f, 0.09693952f, 
    0.16765837f, -0.01473283f, 0.05013621f, -0.10558135f, 0.05975462f, -0.13751562f, 0.01904465f, -0.02917920f, 
    -0.06332592f, -0.10867551f, -0.11525717f, 0.23044889f, -0.01403356f, -0.09757520f, 0.12429361f, 0.15045227f, 
    0.04576037f, -0.01812505f, -0.11799882f, 0.11859667f, -0.24199264f, -0.09842409f, -0.16280216f, 0.00849087f, 
    0.12724452f, 0.03188366f, 0.03669880f, 0.08500899f, -0.08257561f, 0.00082073f, 0.01954892f, 0.00540455f, 
    0.45008063f, 0.01781989f, 0.06152569f, -0.37848651f, 0.04185100f, 0.14124826f, -0.02686196f, 0.04127381f, 
    -0.14252517f, -0.00597086f, -0.01212812f, 0.13015048f, 0.04552429f, -0.02355060f, -0.04241090f, -0.04944649f, 
    -0.09840591f, -0.07756174f, 0.09931964f, 0.03271867f, 0.05343624f, -0.08863524f, -0.00529044f, -0.17503771f, 
    -0.33889619f, 0.07136220f, 0.02504501f, -0.12689118f, 0.00797054f, 0.19507237f, -0.11559704f, 0.11486135f, 
    0.07534192f, 0.08484019f, 0.04622783f, 0.10412524f, 0.11756437f, 0.15474953f, 0.15445583f, 0.19757397f, 
    -0.30236357f, -0.08315580f, 0.11145599f, -0.00504033f, -0.08715321f, -0.11459044f, -0.09462404f, -0.10272524f, 
    0.01558024f, 0.09699735f, -0.17496268f, 0.08102701f, 0.03437508f, 0.01878756f, 0.11842770f, -0.00702661f, 
    0.06013886f, 0.05651035f, -0.06435339f, -0.11225490f, 0.11485102f, -0.44859654f, 0.11939493f, 0.21028532f, 
    0.01497465f, 0.18797709f, 0.11704435f, 0.05350319f, 0.11144032f, 0.11098294f, 0.06173834f, 0.09049726f, 
    -0.14336596f, -0.06105715f, 0.16965942f, -0.17616254f, -0.09247993f, 0.00290011f, 0.11823789f, -0.11522885f, 
    0.02271762f, 0.08672887f, 0.00821748f, -0.00710944f, 0.38352048f, 0.45020714f, 0.21263760f, 0.23401347f, 
    -0.00551837f, -0.05134238f, 0.11268408f, -0.07853188f, 0.03808749f, 0.03457504f, 0.17389046f, -0.13565812f, 
    0.19286776f, 0.28836513f, 0.13825101f, 0.08229884f, 0.11397016f, 0.12906449f, 0.01658535f, 0.16423380f, 
    0.00410488f, 0.09240929f, -0.04749754f, 0.10158919f, -0.02048228f, -0.38104525f, -0.12410071f, -0.15243044f, 
    0.28969863f, -0.01713601f, -0.01756441f, 0.09621291f, 0.13577306f, 0.02608549f, 0.03854271f, 0.06661660f, 
    -0.11674293f, 0.10572455f, -0.18732858f, 0.03059164f, 0.16449609f, 0.15939611f, -0.01188886f, 0.10608046f, 
    0.01940496f, 0.12672541f, 0.11783272f, -0.00686316f, 0.24039501f, -0.17929144f, 0.05026118f, -0.11121394f, 
    0.07562061f, -0.03040222f, 0.11022226f, 0.03026964f, 0.01528702f, 0.04706824f, -0.28846261f, -0.18724629f, 
    -0.18661143f, -0.17077079f, -0.04038538f, -0.01147285f, -0.09083218f, 0.03908005f, -0.14799383f, -0.01695071f, 
    -0.04070684f, 0.15062515f, 0.13158895f, -0.10072657f, -0.10013188f, 0.12834495f, 0.03234379f, -0.24841674f, 
    0.06025501f, -0.04414336f, 0.07186323f, -0.09809880f, 0.03587124f, -0.12883133f, 0.02051602f, -0.02633444f, 
    0.13580503f, 0.07371853f, -0.28636143f, 0.04243197f, 0.28714135f, 0.00874458f, -0.02324346f, -0.03336516f, 
    0.01498658f, -0.08594881f, 0.12303089f, 0.15549158f, 0.12507856f, 0.18556575f, -0.01054700f, 0.12860815f, 
    0.08576393f, -0.01494626f, 0.03164843f, 0.13270752f, 0.04695605f, 0.06035282f, 0.10978791f, 0.01235038f, 
    0.09558743f, 0.13132523f, 0.03350223f, 0.19589736f, -0.06367567f, -0.04127350f, 0.11651030f, -0.01128009f, 
    0.23010378f, -0.04416403f, 0.17207843f, 0.02495789f, -0.07569184f, -0.00780091f, 0.12487546f, 0.21076739f, 
    -0.01456982f, 0.02061471f, 0.06953314f, 0.08393641f, 0.07412146f, -0.13370588f, 0.00195282f, 0.19168532f, 
    0.17172968f, 0.08188618f, -0.08465775f, 0.03562525f, -0.08194292f, -0.15012382f, 0.02034058f, 0.05887755f, 
    0.02786429f, 0.14196996f, -0.07508821f, -0.05841437f, 0.30556768f, -0.38256529f, -0.31549937f, 0.23974891f, 
    0.27082303f, 0.08785955f, 0.02590662f, -0.00738783f, 0.02722015f, 0.02620159f, 0.13011152f, 0.06500365f, 
    0.18163738f, 0.17181204f, -0.17088847f, 0.01805547f, 0.10619383f, -0.02205977f, -0.00047692f, 0.07599312f, 
    0.02127668f, 0.06202400f, 0.19597527f, 0.12800775f, -0.00915501f, -0.01138645f, -0.01067475f, -0.05142872f, 
    0.00157368f, -0.19160266f, -0.01520633f, -0.12087787f, -0.05641803f, 0.02146556f, 0.08053931f, -0.06235632f, 
    -0.12683415f, 0.14797720f, 0.37225813f, -0.08803196f, 0.07318363f, -0.00959670f, 0.12189390f, -0.24984258f, 
    0.00663436f, 0.09645868f, -0.02394019f, -0.03144314f, -0.02256940f, -0.22434239f, -0.30481315f, -0.06048315f, 
    0.26649404f, -0.04301260f, 0.01394429f, -0.06626468f, -0.06599796f, -0.00626978f, 0.03442213f, 0.11603103f, 
    -0.33137456f, 0.07638203f, 0.01207049f, 0.00861477f, -0.02279049f, -0.12737831f, -0.22835359f, -0.05198310f, 
    0.10014275f, -0.07485996f, 0.04591188f, -0.09420197f, -0.00373417f, -0.05274952f, 0.25417942f, -0.23707956f, 
    -0.08673100f, -0.02122196f, 0.02996525f, -0.03407472f, 0.06028414f, 0.02721274f, -0.10146627f, -0.02939416f, 
    0.05043392f, -0.03577750f, 0.01183104f, 0.02603270f, 0.01350157f, -0.06620802f, 0.03170533f, 0.04442030f, 
    0.04799093f, -0.05804271f, -0.05877173f, 0.06255765f, -0.08279122f, 0.01515432f, -0.04636696f, -0.05225195f, 
    -0.08301951f, -0.05109313f, 0.02811115f, -0.09075040f, -0.04940891f, 0.02230979f, 0.06504451f, 0.03768145f, 
    -0.06649625f, -0.06845251f, -0.06435445f, -0.06208594f, 0.05285015f, 0.06800291f, -0.04288107f, 0.02597176f, 
    0.02014877f, -0.04613457f, 0.03973870f, 0.01605579f, 0.04410302f, -0.06404493f, 0.01399809f, 0.00897374f, 
    -0.06778391f, -0.05089337f, -0.02059561f, 0.00631008f, -0.07158695f, -0.02052999f, 0.01158053f, 0.04658245f, 
    0.05541757f, 0.05569855f, -0.04218421f, -0.03683648f, -0.06596103f, -0.05682493f, 0.02820650f, -0.00379196f, 
    -0.02684395f, 0.04538431f, 0.02185604f, -0.00133924f, -0.02718026f, -0.05544065f, 0.01449760f, -0.05301166f, 
    -0.07030890f, -0.00320717f, -0.03197673f, -0.06082382f, 0.05987690f, -0.01874421f, -0.01973103f, 0.05451135f, 
    -0.07558848f, 0.04931837f, -0.02335878f, 0.01821181f, 0.00587082f, 0.04110822f, -0.01724195f, 0.00758490f, 
    -0.04229131f, -0.06304667f, -0.04891244f, 0.02598091f, -0.04180673f, -0.07314496f, 0.00477320f, 0.01333966f, 
    0.05083137f, -0.03687248f, 0.03061455f, -0.05161288f, -0.07744490f, 0.02081752f, -0.03962435f, 0.05017871f, 
    -0.04391586f, -0.07403640f, -0.07070658f, -0.05380405f, 0.04139215f, -0.06494868f, -0.00468824f, -0.01513547f, 
    -0.07228953f, 0.05484373f, -0.01190212f, -0.00330278f, -0.06329878f, -0.04178844f, -0.04461687f, -0.05256206f, 
    -0.07027936f, -0.01595840f, 0.04546723f, -0.01877407f, -0.00442278f, -0.04529126f, 0.00606400f, 0.00743932f, 
    -0.01766118f, 0.05108051f, 0.04766523f, -0.07479668f, -0.08209233f, -0.06380330f, -0.00961820f, -0.05178827f, 
    -0.04715421f, -0.10176622f, -0.00223672f, -0.05931189f, -0.02076244f, -0.00434017f, 0.04878332f, 0.01124206f, 
    -0.06454466f, -0.04866710f, -0.01290676f, -0.01969754f, -0.00250414f, -0.05368577f, -0.04438743f, 0.07335602f, 
    -0.04305001f, 0.06886730f, -0.00467341f, -0.03586295f, -0.07681984f, -0.07465012f, 0.00477697f, -0.08818677f, 
    -0.05062218f, 0.05919262f, 0.02079944f, 0.02332065f, 0.04890656f, 0.02965225f, -0.00405490f, -0.09553096f, 
    0.02629203f, -0.02272843f, 0.05276265f, -0.08039862f, -0.02733702f, -0.06891058f, -0.05802382f, -0.08232688f, 
    0.00583884f, -0.00032410f, 0.01803375f, -0.01295497f, -0.07516814f, 0.03604272f, 0.00939976f, 0.01815719f, 
    0.00283901f, -0.07590812f, -0.09055397f, -0.03739249f, -0.09584806f, -0.09345844f, 0.05314338f, -0.04522121f, 
    0.05637609f, -0.01704187f, 0.01307223f, -0.07666326f, 0.05983719f, 0.04448547f, -0.07537829f, -0.01251487f, 
    -0.18216105f, -0.33906457f, -0.06099979f, -0.22426194f, 0.08151291f, -0.03439374f, -0.02814252f, 0.07912343f, 
    0.08838353f, 0.08938103f, -0.14976582f, 0.17371994f, -0.22456567f, 0.22251993f, 0.18758377f, -0.11336445f, 
    0.01403292f, 0.18784118f, 0.12125642f, -0.04336939f, -0.06759495f, 0.14515351f, 0.02296722f, -0.09397896f, 
    -0.08412696f, -0.11292459f, -0.08151336f, -0.15345831f, 0.23352623f, 0.06807131f, 0.03383923f, -0.02803646f, 
    -0.04375693f, 0.03151995f, 0.01079749f, -0.02292914f, 0.04378986f, 0.04205594f, 0.06660412f, 0.20609063f, 
    0.09357558f, 0.05614395f, -0.01693454f, 0.03892933f, -0.11492511f, 0.06800243f, 0.01271923f, 0.18298902f, 
    0.01182736f, 0.05841538f, -0.09596202f, -0.23057815f, 0.08486565f, 0.15098886f, -0.13211687f, 0.00324556f, 
    0.04050922f, 0.00210295f, 0.13170980f, 0.00869900f, 0.23871721f, -0.28249615f, 0.33654985f, 0.34890708f, 
    -0.06005059f, -0.05545770f, -0.09934731f, -0.08619767f, 0.13410576f, 0.01133231f, -0.08567546f, -0.05396846f, 
    -0.16109234f, -0.11549825f, -0.05636311f, 0.07043689f, 0.11172873f, -0.10525616f, 0.16387734f, -0.02442446f, 
    0.05920324f, 0.12907498f, 0.14792764f, -0.08785806f, -0.21249653f, 0.17597154f, 0.04333165f, -0.12662554f, 
    0.12400994f, 0.11370075f, -0.01663774f, -0.17336921f, 0.03093121f, 0.11867879f, 0.17052241f, 0.17086607f, 
    -0.18086264f, 0.03479742f, 0.05324129f, 0.05118156f, 0.13576669f, 0.05883019f, 0.05829669f, -0.10700384f, 
    -0.00381228f, -0.08604437f, 0.01101506f, -0.16707806f, -0.35860038f, -0.09938756f, 0.11408776f, -0.13958409f, 
    0.02566969f, -0.12762687f, -0.02386218f, -0.01063551f, -0.02963590f, 0.13139738f, 0.12368237f, 0.26103461f, 
    -0.08929759f, -0.03212492f, 0.08972460f, 0.12559056f, 0.08974485f, 0.01552154f, 0.08731034f, -0.10850982f, 
    0.05721560f, 0.10621510f, 0.09162576f, -0.00032583f, -0.23500934f, 0.47708046f, -0.05628454f, -0.17713025f, 
    0.10681877f, -0.08867098f, 0.00926719f, -0.09346640f, 0.00710293f, -0.03850237f, -0.09527124f, 0.01319794f, 
    0.26374006f, 0.07831453f, -0.13529457f, 0.06740292f, 0.08639611f, 0.12521850f, 0.07705665f, 0.04872252f, 
    0.11839913f, -0.02764515f, -0.00183494f, -0.10222627f, -0.32670975f, -0.11775187f, 0.01165270f, -0.23339194f, 
    -0.10991816f, -0.06300700f, 0.01099441f, 0.05818193f, 0.07141470f, 0.11308227f, 0.03819222f, 0.03948697f, 
    -0.07256672f, -0.04795584f, 0.01745939f, 0.11252906f, 0.03676111f, 0.09772019f, 0.08593517f, -0.01212882f, 
    -0.00955976f, -0.15259486f, 0.02038619f, -0.12766294f, -0.09490183f, 0.30063349f, 0.01560074f, -0.00247290f, 
    0.05581111f, 0.00010686f, 0.18311535f, -0.08290301f, -0.02251990f, 0.05832260f, -0.03496968f, 0.03300208f, 
    0.00976989f, 0.04772452f, 0.00376185f, 0.04065060f, -0.00437916f, -0.05650645f, -0.00021824f, 0.01427182f, 
    0.00210087f, 0.04721670f, -0.06502026f, -0.02972414f, 0.00176820f, 0.03984592f, -0.05432795f, -0.00761218f, 
    -0.06317872f, 0.01182743f, -0.01024007f, -0.07834802f, -0.04393069f, -0.05411483f, 0.02137195f, -0.01744046f, 
    0.01370012f, 0.05777812f, -0.05271486f, -0.04306381f, -0.00929960f, -0.05258731f, 0.01066214f, 0.03051770f, 
    -0.05776307f, -0.00921413f, -0.07918392f, 0.02708544f, 0.00652427f, -0.03451432f, 0.03008030f, -0.00284019f, 
    -0.04203151f, 0.06166991f, 0.00154435f, -0.02090137f, -0.04065863f, -0.03012505f, 0.04284357f, -0.02491387f, 
    0.03065345f, -0.06801242f, 0.00264480f, 0.06155213f, 0.04161089f, -0.04231526f, -0.00107793f, -0.02740422f, 
    -0.06843100f, 0.03331488f, -0.06212253f, 0.04184619f, -0.02848423f, 0.03660483f, 0.01715670f, -0.06214180f, 
    -0.01751521f, -0.06107921f, 0.01831640f, 0.00096106f, 0.04639018f, 0.05955217f, -0.04880193f, 0.04658648f, 
    0.05333250f, -0.02964603f, 0.04068264f, 0.02071995f, 0.04491080f, 0.06089439f, -0.05900387f, 0.03466674f, 
    -0.01654213f, -0.01338930f, -0.02640089f, -0.05430457f, 0.00823679f, 0.00900991f, 0.02996681f, 0.02190036f, 
    -0.07524049f, 0.00031762f, -0.07285617f, 0.04260804f, -0.05521042f, -0.08033123f, -0.05254488f, -0.06648937f, 
    0.05793848f, -0.07096809f, 0.04778083f, -0.01242285f, -0.02972921f, -0.00134818f, -0.03427754f, -0.03771593f, 
    -0.02184972f, -0.04709874f, 0.00164571f, 0.01712293f, -0.02956841f, 0.03327749f, -0.02197290f, -0.04829874f, 
    -0.06941883f, -0.02481199f, 0.03733094f, 0.04422645f, -0.05375565f, 0.05105546f, -0.02537898f, -0.07636012f, 
    -0.03358736f, -0.02174714f, 0.05183467f, -0.03781398f, -0.06504153f, 0.06224688f, -0.00862381f, -0.04928408f, 
    0.04100027f, -0.01530894f, -0.03332203f, 0.02141963f, -0.05164279f, 0.05109875f, 0.03987934f, 0.00269684f, 
    -0.04106167f, 0.05891970f, -0.05401355f, 0.03756143f, -0.06300107f, 0.00901347f, 0.01663524f, -0.00692317f, 
    -0.00087606f, 0.05643915f, 0.03253509f, -0.00528205f, 0.00257666f, 0.04839991f, -0.05840048f, -0.05141885f, 
    -0.06225742f, -0.01260548f, 0.05366050f, -0.07471455f, -0.05415918f, -0.05253484f, 0.03653828f, -0.03812029f, 
    -0.04188596f, 0.02331396f, -0.04308902f, -0.05684720f, 0.00341198f, -0.00214484f, -0.08009727f, -0.04218523f, 
    -0.01877141f, -0.07112573f, 0.00009964f, -0.06549786f, 0.05713210f, 0.05081801f, 0.04851557f, 0.03263553f, 
    -0.01949436f, 0.03228220f, -0.07537989f, 0.05533440f, -0.05658985f, -0.03270630f, 0.00080802f, -0.03097575f, 
    0.00883137f, -0.04090269f, -0.02953569f, -0.06824013f, -0.07051558f, 0.04142506f, -0.04137069f, -0.07043159f, 
    -0.04931288f, 0.01652443f, -0.00784445f, 0.01066168f, -0.06307157f, -0.07086388f, -0.05546540f, -0.03119577f, 
    -0.05902012f, 0.06202037f, -0.00065501f, -0.06936953f, -0.00162715f, 0.04521751f, 0.05088560f, 0.01637143f, 
    -0.01611615f, -0.00189068f, -0.02275792f, -0.00371886f, -0.01498242f, -0.06223402f, 0.00371957f, 0.04484749f, 
    -0.00787224f, -0.07985945f, 0.01175384f, -0.01635610f, -0.01023866f, -0.08252002f, -0.07751346f, -0.00784389f, 
    -0.03189525f, 0.02404827f, -0.05580316f, 0.03206193f, 0.00105333f, -0.06850056f, 0.07949111f, 0.01774286f, 
    -0.03737599f, 0.00512016f, 0.04948464f, 0.00970097f, 0.03254807f, 0.06607037f, -0.10749754f, -0.04773597f, 
    -0.06578925f, -0.07945741f, 0.04087428f, -0.06013601f, -0.00728740f, 0.05352924f, 0.02818551f, -0.04009928f, 
    -0.04751661f, -0.03282971f, 0.01938843f, -0.04536500f, 0.03809144f, -0.04236417f, 0.00784287f, -0.09108142f, 
    -0.05295857f, -0.00252913f, 0.00664337f, 0.00577666f, -0.05184241f, -0.04672505f, -0.02371341f, -0.03839625f, 
    -0.06952025f, -0.03361320f, -0.01765966f, 0.05468030f, -0.03775377f, 0.06171385f, 0.02669774f, 0.00728268f, 
    -0.09887435f, 0.06700746f, 0.02723264f, 0.03244188f, 0.03701455f, 0.02147758f, 0.01630882f, -0.04816938f, 
    0.00551132f, 0.02041617f, -0.04288448f, -0.00096660f, -0.00457637f, -0.09127996f, -0.07954508f, 0.00357843f, 
    -0.05656048f, 0.00171468f, 0.06420904f, -0.04655755f, 0.02452700f, 0.06454505f, 0.03004625f, 0.04531161f, 
    -0.04262991f, -0.07307029f, -0.05930259f, 0.03556062f, -0.05034981f, -0.05227679f, -0.03654840f, 0.04955621f, 
    0.01372513f, 0.01722088f, -0.08248568f, -0.01812176f, -0.02296968f, -0.03549821f, -0.03815171f, 0.02959342f, 
    -0.05767636f, 0.02022753f, 0.02013725f, -0.09907285f, 0.06973322f, -0.00117202f, -0.07964201f, 0.04118901f, 
    -0.00620310f, -0.07229353f, -0.05609602f, 0.03034850f, -0.04109491f, -0.10930341f, -0.02868003f, -0.01572142f, 
    0.03585929f, -0.00951992f, -0.00098678f, -0.04525954f, -0.00621405f, 0.00945330f, -0.00905661f, -0.05709837f, 
    -0.00619655f, -0.05629422f, -0.04443099f, -0.04041031f, -0.01204586f, -0.01471050f, -0.06341168f, -0.08515005f, 
    -0.04430319f, -0.00895539f, 0.01471024f, -0.06189639f, -0.03100380f, -0.05620813f, -0.07899766f, 0.02407022f, 
    0.02587337f, -0.04408697f, -0.02027405f, 0.05098576f, 0.05906016f, -0.02766842f, -0.07595169f, 0.06308275f, 
    -0.06100835f, 0.02704104f, 0.00212752f, -0.06531396f, 0.01582922f, -0.02586993f, 0.01083828f, -0.06851507f, 
    -0.08627799f, 0.07366594f, -0.04574944f, 0.03785200f, -0.07862999f, -0.04152055f, -0.02689163f, 0.04012145f, 
    -0.06151361f, -0.07423308f, -0.06137819f, -0.00978683f, -0.05578475f, -0.07140715f, -0.07232168f, -0.02370739f, 
    0.04872513f, -0.07909609f, -0.13103414f, -0.02404652f, 0.09665956f, -0.12884806f, -0.10875090f, 0.01924389f, 
    0.11229220f, 0.00012712f, 0.05330062f, -0.01030040f, -0.18307096f, -0.15604788f, 0.19829611f, -0.06247555f, 
    -0.08977529f, 0.13512118f, 0.06064960f, -0.02052332f, 0.15552837f, 0.06498341f, 0.00668465f, -0.04320562f, 
    0.53480250f, -0.00316790f, -0.19581904f, 0.30665198f, -0.09547256f, -0.12367076f, -0.11059348f, 0.04483209f, 
    0.04266481f, -0.02753588f, 0.05305611f, 0.07502639f, -0.31137264f, -0.10682920f, 0.27096489f, 0.07109167f, 
    -0.00227638f, -0.02354435f, 0.07800745f, 0.05692711f, -0.00400018f, -0.11398236f, -0.09685647f, 0.05652886f, 
    0.12344206f, -0.36263388f, -0.29309294f, -0.17689726f, 0.04371528f, -0.12553164f, -0.13264225f, -0.04083236f, 
    0.02495437f, -0.02788162f, -0.00784440f, 0.22977403f, 0.08487448f, -0.19965568f, 0.08626185f, 0.23293342f, 
    0.03897918f, -0.04831543f, 0.02031723f, -0.04373628f, 0.09498631f, 0.01446561f, -0.00512448f, -0.12439243f, 
    0.41096056f, -0.18254232f, 0.02055452f, -0.15844068f, -0.00359320f, -0.00091735f, 0.05301365f, -0.00147466f, 
    -0.08073842f, 0.07800253f, -0.02975946f, -0.08505797f, -0.19209714f, 0.11104810f, 0.00484140f, -0.13587548f, 
    -0.02720427f, -0.04568446f, -0.09855811f, -0.14924392f, -0.08239689f, -0.14399691f, -0.03165143f, -0.09188624f, 
    -0.40256548f, 0.40508753f, 0.10906884f, 0.12002143f, -0.02871088f, 0.02340299f, -0.08325951f, 0.12264047f, 
    0.00577981f, 0.04241810f, 0.01437155f, -0.03264850f, -0.00673046f, -0.26800635f, 0.04649311f, 0.16487087f, 
    -0.16294238f, -0.23408765f, -0.12915288f, -0.01941148f, 0.06821027f, 0.04081771f, 0.05133209f, -0.10752779f, 
    0.08768126f, 0.16020103f, -0.17007528f, 0.05196244f, 0.00550650f, 0.07155672f, -0.02563940f, -0.07917412f, 
    0.10596135f, -0.00234427f, -0.01908216f, 0.12502295f, -0.30835450f, 0.33922789f, -0.03357365f, 0.06629468f, 
    -0.00820599f, 0.10150520f, 0.00173585f, -0.18661395f, 0.03605090f, 0.11373144f, 0.02909329f, 0.05309333f, 
    0.26037323f, 0.34302530f, 0.18430503f, -0.02894592f, 0.03907886f, -0.02312374f, 0.16231661f, 0.13619108f, 
    0.05077016f, 0.04688153f, 0.02581869f, -0.13780062f, 0.28415930f, 0.13496682f, -0.33268398f, 0.32325235f, 
    -0.09843802f, -0.03165417f, 0.02844032f, 0.07064059f, -0.04292623f, -0.07069615f, 0.06586025f, -0.16727391f, 
    0.32564574f, 0.45280501f, 0.08479461f, 0.12535870f, 0.04061696f, -0.04126970f, 0.15272050f, -0.05028621f, 
    0.12481678f, -0.01299434f, 0.11521591f, 0.11114930f, -0.01616314f, 0.23475154f, 0.25016594f, -0.06480182f, 
    0.25004092f, -0.00007887f, 0.01761578f, -0.09676225f, 0.12049663f, 0.16892254f, 0.06228006f, 0.07050637f, 
    -0.15490124f, 0.12942919f, 0.16828762f, -0.01021340f, 0.06493034f, 0.11308022f, -0.10716072f, 0.07515399f, 
    0.11715373f, -0.04228081f, 0.07560477f, 0.04407589f, 0.36272052f, 0.30955848f, -0.06081808f, -0.15189551f, 
    -0.00764957f, 0.09965053f, 0.12477801f, -0.06321291f, 0.12007039f, 0.08935350f, -0.11186901f, -0.01912330f, 
    -0.03696598f, -0.12310769f, 0.10193932f, -0.06339511f, -0.11407801f, -0.08247725f, -0.05717635f, -0.07541706f, 
    -0.09579929f, 0.18383165f, -0.05634469f, -0.03608542f, 0.24993113f, -0.17424773f, -0.05136249f, 0.02302834f, 
    0.08437840f, -0.15348931f, 0.13623619f, -0.02712904f, -0.01590584f, 0.04773610f, 0.19064833f, 0.17688012f, 
    -0.15527406f, 0.34432423f, -0.06640981f, 0.12406735f, 0.16160789f, -0.21489513f, -0.12402649f, -0.03587559f, 
    -0.15295407f, -0.03062192f, -0.12304156f, -0.03212383f, 0.20785610f, -0.18406445f, 0.05783046f, 0.20673235f, 
    -0.14844912f, -0.16286671f, -0.02891231f, -0.12841779f, 0.02126664f, -0.03991029f, -0.02440155f, 0.06121480f, 
    0.18822442f, 0.10479289f, 0.13236959f, -0.25092176f, -0.23341899f, -0.04389235f, 0.25235167f, 0.01364267f, 
    0.12167420f, 0.10860825f, 0.13538720f, -0.12730780f, 0.04290938f, -0.10231679f, 0.03154022f, 0.19217230f, 
    -0.08767636f, 0.03215418f, 0.11432716f, -0.14367265f, -0.01005211f, 0.05407956f, -0.02175268f, 0.15882772f, 
    -0.19664812f, 0.32279509f, 0.23938277f, -0.11834089f, 0.07686762f, 0.21873811f, -0.13656434f, 0.03895785f, 
    0.10897677f, 0.09630286f, 0.16592547f, 0.12297367f, -0.14077063f, 0.27736863f, 0.06236853f, -0.38732445f, 
    0.00251520f, -0.09246076f, 0.06686928f, -0.00094138f, -0.05642604f, 0.14768288f, -0.06512559f, 0.23534685f, 
    -0.22509772f, 0.19074951f, -0.14795440f, 0.08469886f, -0.09025243f, 0.08183131f, 0.19641615f, -0.18101966f, 
    0.08097902f, -0.01570562f, 0.17228729f, -0.01038784f, 0.11542858f, 0.03445316f, 0.19502354f, -0.12371577f, 
    0.07868310f, -0.01993602f, -0.00873747f, 0.09330076f, -0.06811207f, -0.22050104f, -0.16340038f, -0.04147074f, 
    -0.14472364f, 0.08397938f, 0.17402415f, -0.17206097f, 0.06690254f, 0.16929096f, 0.11766157f, -0.21252909f, 
    -0.09868653f, 0.02727553f, -0.06562389f, -0.16315572f, 0.02987547f, 0.01027663f, -0.02241543f, -0.13341509f, 
    -0.00472735f, -0.05657307f, -0.04574418f, -0.03297888f, -0.06657974f, -0.02569730f, 0.07571905f, -0.06797309f, 
    0.20108002f, 0.00002734f, 0.01842349f, 0.18286794f, 0.07429087f, 0.12744842f, 0.03517793f, -0.12032287f, 
    -0.15683350f, 0.01187895f, -0.09930465f, -0.22886120f, -0.03243759f, 0.08786942f, 0.09184865f, -0.09939488f, 
    0.22328980f, 0.03369999f, 0.07384194f, -0.14694075f, 0.04688002f, -0.05280478f, -0.13445210f, 0.15173021f, 
    -0.03228121f, 0.01772159f, -0.04821472f, 0.05229964f, -0.07395851f, -0.04635741f, -0.03821451f, -0.00966695f, 
    -0.00957656f, 0.01506041f, 0.01764870f, -0.01238622f, -0.00490949f, 0.04595547f, 0.00861193f, -0.07666603f, 
    0.04657156f, -0.06533035f, -0.02868821f, -0.03956934f, -0.03396838f, -0.05598496f, -0.03662205f, 0.04968850f, 
    -0.02137948f, -0.06178576f, 0.04898226f, 0.04518031f, 0.03749252f, -0.03612937f, 0.00880853f, 0.02864773f, 
    -0.04568341f, -0.02082038f, 0.04551144f, -0.00834834f, -0.02797815f, -0.05509083f, -0.01714784f, -0.06402798f, 
    -0.01807722f, -0.02164611f, -0.05830629f, 0.00718317f, -0.01035269f, -0.04778004f, -0.07238337f, 0.06115019f, 
    0.04763518f, -0.03997302f, -0.01855627f, 0.06467759f, -0.07979334f, 0.02945739f, -0.03219620f, -0.03707416f, 
    -0.03441566f, -0.06035482f, 0.00072785f, -0.00572639f, -0.02543341f, -0.04021095f, 0.01860321f, -0.00479740f, 
    -0.02073433f, 0.05555851f, 0.06792942f, -0.06682334f, -0.05111412f, -0.05843545f, -0.06341198f, -0.02610828f, 
    -0.07535958f, 0.06367576f, 0.04360086f, 0.06757086f, -0.06404298f, -0.00757829f, 0.04025247f, 0.05677785f, 
    -0.04397364f, 0.06599288f, -0.00919997f, 0.01844824f, -0.06941886f, -0.00486692f, 0.01776508f, 0.02176940f, 
    0.04914484f, -0.01416019f, -0.01476513f, -0.05457779f, -0.02381431f, -0.06606773f, 0.03930984f, 0.04878865f, 
    -0.05711747f, -0.06247133f, -0.05178097f, -0.07782800f, 0.00505552f, -0.01233012f, -0.05037683f, 0.05116395f, 
    0.00993316f, 0.01596132f, -0.03647611f, -0.02823966f, -0.06026288f, -0.06371651f, 0.01916526f, 0.03981960f, 
    -0.00928130f, 0.01103067f, 0.01121865f, 0.02304475f, 0.03695805f, -0.05932398f, -0.01111761f, 0.06130504f, 
    0.02859681f, -0.02106262f, -0.05595427f, -0.01600717f, 0.01226318f, 0.02639122f, -0.02786567f, -0.04499190f, 
    0.04164813f, -0.04684562f, 0.06198010f, -0.06007497f, -0.00195228f, 0.02803671f, -0.02626159f, -0.03240461f, 
    0.04788244f, -0.07362948f, -0.05278188f, 0.01772570f, -0.03792411f, -0.03999713f, 0.00592303f, 0.02699637f, 
    -0.07401976f, 0.03265288f, 0.02988785f, 0.04691515f, -0.01796602f, -0.03128243f, -0.06733494f, -0.03415454f, 
    0.04828623f, -0.05089290f, -0.00489735f, 0.01339850f, 0.01861944f, -0.06606712f, 0.02167535f, -0.07655747f, 
    -0.00009739f, -0.06089820f, 0.04508119f, 0.03048745f, 0.04504108f, -0.01326411f, -0.05297486f, 0.05846383f, 
    -0.01039838f, 0.04409880f, -0.02526918f, 0.01237115f, -0.04847119f, 0.04217216f, 0.01771850f, 0.05952447f, 
    -0.04260214f, 0.01376125f, -0.02609663f, 0.01446495f, -0.00273937f, 0.05959001f, 0.06184867f, -0.00261565f, 
    -0.06766164f, -0.06621968f, 0.05024413f, -0.00457800f, 0.06411257f, 0.00430567f, -0.02794791f, 0.04241028f, 
    -0.01349192f, 0.03417454f, -0.07448686f, 0.03680715f, 0.05702066f, 0.04732551f, -0.05178088f, -0.03506240f, 
    0.02496378f, 0.04905258f, 0.04505424f, 0.04521277f, 0.03391935f, 0.02915111f, -0.07011383f, -0.02287193f, 
    -0.07415190f, 0.01702025f, 0.04928013f, 0.02639101f, 0.01861490f, 0.03672283f, -0.05754558f, 0.05799513f, 
    0.00048950f, 0.00271280f, 0.01785436f, -0.01309490f, 0.04207091f, -0.07663345f, -0.05495204f, -0.01638877f, 
    -0.04252367f, -0.03957883f, -0.04919162f, -0.00869265f, 0.05378255f, -0.03088621f, 0.03524119f, -0.05667196f, 
    -0.06279082f, 0.01412949f, -0.01670595f, -0.01167115f, -0.00542834f, 0.03444361f, -0.04216990f, 0.05383478f, 
    0.02626627f, 0.04435825f, -0.02332499f, -0.00957314f, 0.02608565f, 0.06118335f, 0.03435599f, -0.02124607f, 
    0.01281107f, 0.02813521f, 0.05476170f, -0.04195401f, -0.05771042f, -0.00032280f, -0.04030124f, 0.01202303f, 
    -0.00959646f, 0.01270995f, -0.06330514f, 0.01899268f, -0.02864058f, 0.05683293f, 0.02986012f, 0.04733581f, 
    -0.01141107f, 0.06377784f, -0.04789630f, 0.04876846f, 0.02036213f, -0.00756795f, -0.00766643f, -0.05977779f, 
    -0.03068540f, -0.04056809f, -0.06030965f, -0.03902770f, -0.03694410f, 0.00325224f, -0.06342273f, 0.01041560f, 
    -0.03406344f, -0.01276182f, 0.02423661f, -0.07972419f, -0.00558323f, -0.00902182f, 0.05495106f, -0.04322863f, 
    0.04242638f, -0.03269742f, -0.05866808f, -0.01341356f, -0.02018465f, -0.00963904f, -0.04103820f, -0.03578931f, 
    -0.06553973f, -0.05710130f, 0.04834178f, -0.05982089f, 0.00080125f, -0.04372595f, 0.02591866f, -0.03782261f, 
    -0.01559405f, -0.01369879f, -0.00956598f, 0.03428578f, -0.01841954f, -0.02833624f, 0.06304869f, 0.00083293f, 
    -0.06536440f, 0.03607932f, 0.01085645f, 0.05218641f, -0.08449132f, -0.02055568f, -0.07395885f, -0.01746196f, 
    -0.01504364f, 0.02383289f, -0.05100955f, 0.03141897f, -0.07315790f, 0.02540573f, 0.03993824f, -0.06626245f, 
    0.04883089f, -0.05436749f, -0.07716255f, -0.04558244f, 0.00101230f, -0.04022884f, -0.05912407f, -0.02967519f, 
    -0.00486924f, -0.03834146f, 0.00594548f, 0.04001485f, -0.02075325f, 0.00178590f, 0.00613519f, -0.07284682f, 
    -0.07655262f, -0.07813542f, 0.00153380f, -0.04577359f, 0.00239908f, 0.05601558f, -0.01822181f, 0.00795161f, 
    -0.03804324f, -0.04123517f, 0.04536107f, -0.04644476f, 0.02671845f, -0.04617481f, -0.00816199f, 0.02319453f, 
    -0.03750842f, -0.00599146f, 0.00632241f, 0.05950202f, 0.00963271f, 0.02008284f, 0.02773485f, 0.00558809f, 
    -0.07952543f, -0.06293289f, -0.02014588f, -0.01830716f, 0.04329419f, -0.00270276f, -0.07154600f, -0.06065600f, 
    0.04297812f, 0.05869350f, 0.00335655f, 0.05947138f, -0.02883881f, -0.02618115f, 0.00849391f, 0.01302819f, 
    0.17788097f, -0.10409703f, 0.04144495f, -0.28198472f, 0.03000220f, -0.07224213f, 0.20120160f, -0.15814857f, 
    -0.14114405f, 0.09770580f, -0.08011489f, 0.08526494f, 0.43894583f, 0.16193038f, 0.06250355f, 0.08938307f, 
    -0.12007581f, -0.04773520f, 0.17488113f, 0.14726888f, 0.00195124f, 0.08954711f, -0.03568906f, 0.05845001f, 
    0.06870941f, -0.10497075f, -0.12722057f, 0.02968887f, 0.19435193f, -0.11074764f, -0.10164367f, 0.05358743f, 
    -0.04630964f, 0.06173443f, 0.00695037f, 0.00975941f, 0.45574123f, -0.17444156f, 0.11636483f, 0.02572118f, 
    -0.03955473f, -0.05162175f, 0.02162766f, 0.18002303f, -0.13570370f, -0.03290232f, -0.06067287f, -0.08002860f, 
    -0.17201439f, 0.03146152f, 0.09417691f, 0.06264959f, -0.10495130f, -0.16217026f, -0.04483249f, -0.07763463f, 
    0.01658964f, 0.09307130f, 0.02744147f, -0.15182593f, 0.13697858f, 0.20156737f, 0.10910405f, -0.01570497f, 
    0.00096005f, 0.16761486f, -0.18230715f, 0.00670591f, -0.02904458f, -0.04731061f, 0.07414399f, -0.07629509f, 
    -0.16483536f, 0.16458803f, 0.17227215f, 0.18803740f, -0.00394768f, 0.17288624f, -0.01681357f, 0.04688335f, 
    -0.13110314f, 0.14124642f, -0.01469287f, -0.05906456f, 0.20994408f, 0.17887154f, 0.09697774f, 0.06330911f, 
    0.06024839f, 0.08745176f, -0.08232857f, -0.01206359f, 0.08937433f, 0.19318740f, 0.15129574f, 0.09552678f, 
    0.39802742f, -0.03112721f, 0.29594824f, 0.13120447f, 0.05930807f, -0.01253885f, 0.02705319f, -0.07633062f, 
    -0.06863028f, 0.14423585f, 0.05245122f, 0.09457655f, -0.15965767f, 0.07575566f, -0.02629395f, -0.49696064f, 
    0.17487535f, -0.01767720f, 0.09422155f, -0.05544477f, 0.03030213f, 0.01699300f, 0.01079046f, -0.01412176f, 
    -0.22095180f, -0.04712806f, 0.23232330f, -0.28263983f, -0.08273178f, -0.00530794f, 0.14419425f, -0.08770826f, 
    -0.07980735f, -0.07986494f, -0.12745361f, 0.15574786f, 0.18334751f, 0.15230779f, 0.02107408f, 0.09416027f, 
    -0.08400253f, 0.02956434f, -0.16593577f, 0.07531845f, 0.03646589f, -0.06382749f, 0.00577204f, -0.05433073f, 
    -0.00053410f, 0.05024980f, 0.02472530f, 0.24869481f, 0.06417564f, 0.06917879f, -0.06249215f, 0.02997750f, 
    -0.03085961f, 0.09920321f, 0.06581744f, -0.06516767f, -0.12273474f, -0.34696576f, -0.20117392f, 0.01576218f, 
    -0.07128451f, 0.09121066f, 0.02703618f, -0.03845832f, 0.04905609f, 0.04594699f, -0.10556987f, 0.02800586f, 
    -0.00711685f, -0.04077652f, 0.03230887f, -0.01855680f, 0.10751904f, 0.09007592f, 0.03074611f, -0.00691497f, 
    0.00600583f, 0.01310079f, -0.05070230f, -0.08384847f, 0.34833094f, 0.19956382f, 0.20508081f, 0.02300190f, 
    -0.15778370f, -0.04214463f, 0.03069454f, 0.15620501f, 0.02911268f, -0.06380303f, 0.11255199f, -0.01635116f, 
    0.41042781f, 0.07862077f, -0.04992331f, -0.00843174f, -0.07039944f, 0.01092030f, 0.06006576f, 0.03642077f, 
    0.06372136f, -0.05327147f, -0.11309813f, 0.03918486f, -0.41417024f, 0.20801476f, -0.02489921f, 0.20872585f, 
    0.08426851f, -0.00203788f, -0.06191436f, 0.10093041f, -0.06137374f, 0.05330078f, 0.05022110f, 0.15608621f, 
    0.28608724f, 0.12838924f, 0.06335141f, 0.15469109f, 0.03015170f, -0.04498006f, -0.02815765f, 0.07413536f, 
    -0.03796055f, -0.01895975f, 0.10864063f, 0.01308094f, -0.24169204f, -0.07151001f, -0.05274892f, 0.31031871f, 
    -0.06451789f, 0.05333304f, -0.08126969f, 0.00199668f, -0.04286904f, 0.07908957f, 0.14464934f, 0.22966197f, 
    0.24279992f, -0.06540566f, 0.02604396f, -0.05381675f, -0.20322010f, 0.31264415f, 0.02924853f, 0.10697878f, 
    -0.02041591f, 0.06704260f, 0.13401359f, -0.05608789f, -0.36105773f, 0.08630270f, -0.14717263f, 0.00165806f, 
    -0.15623578f, -0.05390460f, 0.09514196f, -0.00586746f, 0.01280592f, 0.07313716f, 0.06820174f, -0.02035202f, 
    0.00593328f, -0.02962224f, 0.00769880f, -0.19680263f, 0.13001898f, -0.01140434f, -0.04259782f, 0.04208119f, 
    0.07418906f, 0.01454121f, -0.08426785f, 0.03901258f, -0.01291871f, -0.02767860f, 0.13359655f, -0.11579966f, 
    -0.10417979f, -0.02805816f, -0.08750998f, 0.08806466f, -0.06456789f, -0.13644439f, -0.12016770f, -0.16869482f, 
    -0.30529785f, -0.12456092f, -0.14033049f, -0.06675898f, 0.11999208f, 0.04907781f, -0.14484271f, 0.06314270f, 
    -0.00096308f, 0.05414713f, 0.01830238f, -0.06346533f, 0.22330943f, 0.17100851f, 0.24450953f, 0.37547687f, 
    -0.10293540f, 0.30064622f, 0.09142760f, -0.08770815f, 0.00480277f, -0.13280325f, -0.08453334f, 0.05073110f, 
    0.16592716f, -0.03605683f, 0.04674962f, -0.07082165f, 0.01021205f, 0.00475350f, 0.01612822f, -0.04769555f, 
    0.04183090f, 0.13933593f, 0.00911403f, -0.04664667f, -0.17488767f, 0.31973305f, 0.14308921f, 0.06745675f, 
    0.12581399f, -0.03663352f, 0.01129711f, -0.07827389f, 0.10173657f, -0.04167166f, 0.17570606f, 0.09619074f, 
    -0.01062520f, -0.14912304f, -0.24540927f, 0.26715919f, 0.03935865f, 0.08527473f, -0.04671692f, 0.30145377f, 
    0.00855360f, -0.06557063f, -0.00117504f, 0.17639074f, 0.37063327f, 0.10486286f, 0.17561629f, 0.08592424f, 
    -0.14230950f, -0.02642187f, 0.06609640f, -0.11182197f, 0.09146346f, -0.06009079f, 0.07941332f, -0.00194487f, 
    0.22294576f, -0.14496042f, 0.13446666f, 0.02461575f, 0.08065784f, 0.09111415f, 0.09789818f, -0.04096768f, 
    0.14150934f, 0.05955850f, -0.05415590f, 0.08425400f, -0.23485422f, -0.09245154f, -0.11891218f, 0.17298228f, 
    -0.04418484f, -0.02177212f, 0.03709748f, 0.21568108f, 0.01043445f, 0.07951269f, 0.02382787f, 0.02265258f, 
    -0.51659214f, -0.15242991f, 0.16437070f, 0.17847794f, -0.14101796f, 0.01866108f, 0.12120360f, -0.04215555f, 
    -0.10754612f, -0.00200846f, 0.12381070f, -0.01203250f, 0.10918142f, -0.15104733f, 0.08889712f, -0.01460403f, 
    -0.09899419f, 0.04086063f, 0.09244280f, -0.13101284f, 0.04159202f, -0.04390193f, 0.11577668f, 0.14803429f, 
    -0.21702644f, -0.12775461f, -0.16683583f, 0.08299327f, -0.04552577f, 0.00376863f, 0.11636887f, 0.10264958f, 
    0.02868748f, -0.04041035f, 0.02970500f, 0.20702296f, 0.37975153f, -0.05762097f, 0.22147943f, 0.33056298f, 
    0.18561684f, 0.12847754f, 0.04886850f, 0.07912028f, -0.05459496f, -0.01529635f, -0.12374495f, -0.12379223f, 
    -0.34935141f, -0.18328996f, -0.00554325f, 0.23255539f, -0.09150633f, -0.01883768f, 0.04145912f, 0.02608920f, 
    0.02153562f, 0.03129999f, -0.24342069f, -0.03373406f, -0.18316957f, 0.16169688f, 0.39652941f, 0.07842980f, 
    0.15108337f, 0.08158506f, -0.01349689f, 0.05279462f, -0.13617048f, -0.14097199f, -0.08786533f, -0.00017677f, 
    -0.02628921f, -0.05891427f, 0.06753870f, -0.20123184f, 0.01919978f, 0.09484381f, -0.02993345f, 0.03919755f, 
    -0.19220646f, 0.10955264f, -0.00913084f, 0.00127040f, 0.10064007f, 0.20471281f, -0.11794297f, -0.03119036f, 
    0.04560387f, -0.05138513f, 0.04488192f, 0.02366222f, 0.08786546f, 0.14317998f, 0.15974775f, -0.04115809f, 
    -0.15030925f, 0.16220681f, 0.14524487f, 0.04349599f, -0.05325351f, 0.04280128f, 0.20138389f, 0.04792250f, 
    -0.00708266f, 0.00557447f, 0.10432292f, 0.21004173f, -0.20455465f, 0.10933932f, 0.26363045f, -0.44483623f, 
    -0.13047329f, -0.05660683f, 0.11766781f, 0.09461840f, -0.04509361f, -0.00976051f, -0.18731181f, -0.04465855f, 
    -0.22320247f, -0.13198952f, 0.03171577f, -0.06440801f, -0.08547197f, 0.11087693f, 0.08241091f, 0.10101204f, 
    0.07313395f, -0.10504385f, -0.15223710f, 0.10017161f, 0.08871857f, -0.07840679f, -0.07900670f, 0.02512950f, 
    -0.04263739f, 0.17124139f, -0.04529538f, 0.21139376f, 0.02474672f, -0.06083497f, -0.04126380f, 0.09237771f, 
    0.22745326f, 0.12755556f, -0.09186226f, -0.03729465f, -0.14566566f, 0.05735385f, 0.15882896f, -0.05923504f, 
    0.13134940f, 0.11538398f, 0.01810526f, -0.09905933f, -0.36699468f, 0.05136503f, 0.10815779f, -0.01587430f, 
    -0.12796211f, 0.14405449f, 0.05658440f, 0.15842973f, -0.06809781f, 0.22046211f, 0.02792509f, 0.04242638f, 
    0.54844666f, 0.29187509f, 0.12373544f, 0.08895506f, -0.07178742f, 0.15837660f, 0.26295385f, 0.11288860f, 
    -0.34779066f, 0.05833742f, 0.04273013f, 0.15065946f, 0.23982374f, 0.11118967f, -0.15441032f, -0.01670790f, 
    0.17661454f, -0.02976525f, 0.07876215f, 0.00015672f, -0.01675549f, -0.08174768f, 0.04659334f, 0.15635589f, 
    -0.11574899f, -0.24240097f, -0.04947059f, 0.04233704f, 0.00588013f, -0.08050865f, 0.05618083f, 0.17266452f, 
    0.06745762f, 0.06544630f, -0.18650079f, -0.02251774f, -0.45412681f, -0.23448373f, 0.09144039f, -0.01108247f, 
    0.11347463f, 0.04048015f, -0.01928986f, 0.02100438f, -0.04547613f, 0.01989359f, 0.01859133f, 0.10833064f, 
    0.08637825f, -0.17342895f, -0.09764429f, 0.20557372f, -0.00317251f, 0.05616514f, 0.18467881f, -0.02421749f, 
    0.06387277f, -0.10948343f, 0.13055858f, -0.01764837f, -0.17672433f, 0.25662637f, 0.09019480f, 0.29448789f, 
    0.19517514f, 0.07098265f, 0.03399247f, -0.03096763f, -0.08263777f, 0.05120604f, -0.02251324f, 0.08231942f, 
    0.30486310f, -0.27047503f, -0.17494811f, 0.06149266f, -0.16869698f, 0.24911247f, 0.04140779f, 0.16242811f, 
    0.03491246f, -0.05925130f, 0.04573395f, -0.00800115f, -0.14248811f, 0.09219595f, 0.11342385f, 0.32660034f, 
    -0.11462429f, 0.02581159f, -0.01546843f, 0.09739985f, 0.02097307f, 0.01573052f, 0.00551811f, -0.05268612f, 
    0.22822252f, -0.45399883f, -0.05305901f, -0.03442505f, 0.11246242f, -0.09165108f, 0.11076842f, 0.10966078f, 
    -0.00120885f, -0.03179071f, 0.12257566f, -0.00805388f, -0.28616661f, 0.08674247f, 0.02378698f, -0.20746809f, 
    0.02710287f, 0.07275568f, -0.07882769f, 0.14659698f, -0.08168072f, -0.02528112f, -0.12905887f, -0.09449264f, 
    -0.11217387f, 0.19037671f, -0.32044667f, 0.00338705f, -0.03144858f, 0.05295740f, 0.10655673f, 0.16289888f, 
    -0.07817141f, -0.14166398f, -0.12237620f, -0.04055388f, 0.34443051f, -0.15294084f, 0.04853961f, 0.52941024f, 
    -0.18382241f, 0.01487615f, 0.07178293f, 0.14478326f, 0.01220654f, -0.05913505f, -0.00633490f, 0.15977134f, 
    0.11755346f, -0.24949470f, -0.02346928f, 0.01463670f, -0.02490783f, -0.00907980f, -0.14680958f, 0.01290752f, 
    0.03119591f, 0.08485754f, -0.03838394f, -0.07001384f, -0.50642198f, 0.42114085f, -0.02502324f, -0.18303658f, 
    0.22361816f, 0.06389780f, 0.02106558f, -0.00429103f, -0.06505662f, 0.06071564f, 0.16130762f, 0.06530639f, 
    0.34983826f, 0.23293021f, -0.13967691f, 0.08773906f, -0.06211754f, -0.13035044f, 0.17188050f, 0.10912620f, 
    0.15268643f, 0.06392950f, 0.03307894f, 0.07448196f, -0.17610116f, 0.11454073f, -0.02180800f, -0.04967893f, 
    -0.14706837f, 0.01373036f, 0.22380039f, 0.14078498f, -0.00304906f, 0.04900052f, 0.01359264f, -0.00895304f, 
    0.21351317f, 0.08322225f, 0.13155378f, 0.06617665f, -0.08092982f, 0.08572797f, -0.00035171f, 0.06891929f, 
    0.06822155f, -0.01243694f, 0.08425712f, 0.02567597f, -0.06411957f, 0.12175342f, -0.11241472f, -0.02617328f, 
    0.06648155f, 0.04038488f, 0.00542323f, -0.08484918f, 0.16671106f, 0.05106030f, 0.00324478f, 0.15759288f, 
    0.51891756f, 0.23717144f, 0.16251229f, 0.02908681f, 0.01444538f, 0.05515807f, 0.06870590f, 0.15437613f, 
    0.09901325f, -0.08411694f, -0.01561920f, -0.11303987f, 0.00355775f, -0.07334804f, -0.20895258f, -0.13378286f, 
    0.17564973f, 0.20108837f, -0.15589188f, 0.03010387f, 0.14732569f, 0.14850700f, 0.02784985f, 0.08904506f, 
    0.65420550f, 0.00748820f, 0.10195102f, 0.20587038f, -0.09342299f, -0.07731549f, -0.07202382f, 0.02603581f, 
    -0.00339843f, 0.10702920f, 0.01213326f, 0.01301329f, -0.53354424f, -0.14448155f, -0.23238502f, 0.09215905f, 
    0.06207736f, -0.01534220f, 0.12683780f, 0.02766603f, -0.00275118f, -0.13640645f, 0.12377054f, 0.09831560f, 
    0.45856902f, 0.01607099f, -0.05989264f, 0.14366095f, -0.03567832f, -0.05133957f, -0.07823697f, -0.01766722f, 
    0.01126085f, -0.13621365f, 0.09786270f, 0.12628002f, 0.03489661f, 0.04655205f, -0.36687538f, 0.24329901f, 
    0.00031450f, -0.13692179f, 0.13814588f, 0.22313993f, 0.21061915f, 0.07168676f, 0.17797759f, 0.08764587f, 
    0.41246849f, -0.13856106f, 0.14144264f, -0.25370592f, 0.06923884f, 0.01153206f, 0.01304627f, 0.10744476f, 
    -0.15667646f, -0.02965719f, 0.05389939f, -0.03154629f, -0.32768929f, -0.08067189f, 0.08634602f, 0.09263262f, 
    -0.09168440f, 0.18499829f, 0.10346416f, -0.14608702f, 0.06275538f, -0.01980738f, -0.11086544f, 0.11945035f, 
    -0.02813229f, 0.08407031f, -0.19616812f, -0.22102275f, 0.17812091f, 0.24217989f, -0.09094810f, 0.08309036f, 
    0.03463535f, 0.19928534f, -0.03137497f, -0.06906054f, 0.39060229f, 0.13098149f, 0.17292522f, 0.29078266f, 
    -0.19146714f, 0.07689448f, 0.13596648f, 0.06455398f, 0.02676738f, -0.10544124f, 0.16586177f, 0.10754161f, 
    0.10335990f, -0.04410481f, 0.10164417f, -0.16863929f, 0.13068534f, -0.02371623f, -0.02548966f, 0.08244982f, 
    -0.12202936f, 0.22007285f, 0.04859621f, 0.04886607f, -0.27506402f, 0.21779229f, 0.00261705f, 0.09034272f, 
    0.19852583f, 0.13187774f, 0.06273583f, -0.17591578f, -0.05290690f, 0.00137603f, 0.18126138f, 0.09005522f, 
    -0.19812845f, -0.08374412f, 0.16977590f, -0.10142224f, 0.17475489f, 0.06016052f, 0.16947584f, 0.18181561f, 
    0.00679735f, 0.00795007f, -0.01653707f, 0.07788538f, 0.47525230f, 0.11186573f, 0.03704767f, 0.37625271f, 
    -0.05385574f, 0.01513252f, 0.15094624f, -0.09028437f, 0.02874642f, -0.07369477f, -0.01377550f, -0.00069137f, 
    -0.37397498f, -0.16620366f, 0.16005503f, -0.06912757f, 0.14326943f, -0.00213420f, -0.08232633f, 0.03656555f, 
    0.10554563f, -0.05199880f, -0.03318916f, -0.18623139f, -0.12694967f, -0.19353655f, -0.12830417f, -0.03531860f, 
    0.07689688f, 0.09447814f, -0.00465896f, 0.09123790f, 0.22284232f, 0.00033068f, -0.03881552f, 0.19682503f, 
    0.02577800f, -0.02188635f, -0.01625586f, -0.04220212f, 0.03360784f, 0.01657073f, 0.01050379f, 0.02448344f, 
    0.01097372f, 0.00535337f, -0.06648809f, 0.03948834f, -0.04590622f, -0.01877179f, -0.05686595f, 0.02589475f, 
    0.03565019f, 0.00818969f, -0.05740834f, 0.06252334f, 0.02297605f, 0.02702349f, -0.00795064f, -0.05159755f, 
    -0.01231528f, -0.02544466f, -0.06083396f, 0.04149198f, -0.01718500f, -0.02765484f, 0.00609422f, 0.00499130f, 
    0.02480827f, -0.05330014f, -0.02577184f, 0.06972973f, -0.04486467f, -0.02118948f, 0.01863893f, 0.01280487f, 
    -0.04461207f, 0.04626825f, 0.01801536f, -0.04879907f, 0.01655929f, 0.03701881f, -0.00576542f, 0.01077363f, 
    0.01222286f, 0.06096140f, -0.03307468f, 0.04357488f, 0.01634913f, -0.00428987f, -0.01233915f, -0.04850034f, 
    -0.00733635f, 0.05517836f, -0.05182385f, -0.05459882f, 0.01769153f, -0.03816330f, -0.00363199f, -0.04743320f, 
    0.03575294f, 0.00203759f, 0.05517771f, -0.06037927f, -0.05553580f, 0.04879781f, -0.01847568f, -0.06616897f, 
    -0.04996398f, -0.02069247f, -0.02174979f, 0.03325981f, -0.04184657f, -0.05996250f, -0.05734508f, -0.05396211f, 
    -0.01784557f, -0.03662155f, 0.05165780f, -0.06063271f, 0.01518543f, 0.06022098f, 0.01197687f, -0.00162187f, 
    -0.00473962f, 0.00091752f, 0.02983790f, -0.03689083f, 0.01174255f, 0.06620479f, -0.05430365f, -0.05841922f, 
    -0.05134818f, 0.06398982f, 0.06202653f, -0.01020519f, 0.00919481f, 0.04416898f, -0.06709015f, 0.00044013f, 
    0.03743528f, 0.06433056f, -0.00678822f, -0.05802064f, -0.00014510f, -0.07474305f, 0.01333362f, 0.01428437f, 
    0.02234455f, 0.02059442f, -0.05465114f, 0.04012317f, -0.06245276f, -0.04594124f, -0.06592813f, -0.04898049f, 
    -0.03926406f, 0.04387681f, -0.06666746f, -0.01308852f, -0.02249125f, 0.02677256f, -0.00174627f, -0.03272186f, 
    0.05523882f, -0.06747922f, 0.01272908f, 0.06147834f, 0.01376532f, 0.01622874f, -0.06790160f, 0.01445585f, 
    0.01426130f, -0.06649108f, -0.02228767f, -0.05773842f, -0.02588408f, 0.00780783f, 0.00257154f, -0.07534363f, 
    0.01098423f, 0.01702735f, -0.03636780f, -0.05282535f, -0.03635081f, -0.00080933f, -0.05309232f, -0.00417719f, 
    -0.04166262f, -0.06709842f, 0.00852495f, -0.05326229f, -0.00574348f, -0.04678744f, -0.06299021f, -0.05329303f, 
    -0.04244868f, -0.07236072f, -0.01761776f, 0.03772838f, 0.00331393f, 0.04061963f, 0.03884115f, -0.00297488f, 
    0.00921387f, -0.05541571f, -0.03524583f, -0.02360385f, -0.02519600f, -0.00026624f, -0.04607458f, 0.02498394f, 
    -0.00458928f, 0.04830955f, 0.03931868f, -0.06668972f, 0.04708541f, 0.06354234f, 0.04612678f, 0.05242861f, 
    -0.04074800f, 0.02288534f, -0.02414407f, 0.01604460f, -0.06802944f, 0.06175463f, 0.03759038f, -0.04977022f, 
    0.41874629f, -0.25934005f, 0.12811956f, -0.34833124f, 0.03606300f, 0.10625796f, 0.02256488f, -0.20335919f, 
    -0.13753340f, 0.10726962f, -0.03487993f, -0.02724343f, 0.50730217f, 0.09135359f, -0.56223440f, -0.02913757f, 
    -0.15353689f, 0.07356205f, 0.12026248f, 0.02813986f, 0.09804431f, 0.08699659f, 0.07718553f, 0.15482758f, 
    0.26535696f, 0.16060480f, -0.04117385f, 0.08068449f, 0.03000537f, 0.00346444f, -0.05013544f, -0.13428371f, 
    -0.02845698f, 0.01955279f, 0.14237587f, 0.16901489f, -0.20669487f, -0.25896865f, 0.17557627f, 0.20926908f, 
    -0.09235010f, -0.11251888f, -0.11495980f, 0.02605689f, -0.04456037f, 0.10904430f, -0.09796944f, 0.00018102f, 
    0.14769760f, 0.04896641f, 0.03695405f, 0.25360340f, -0.04443790f, -0.04041874f, 0.04747020f, -0.15418321f, 
    -0.12994559f, 0.03639456f, 0.11143589f, -0.04314080f, -0.10146556f, 0.02462521f, -0.00819882f, 0.06749664f, 
    0.04650437f, 0.07343861f, -0.10153877f, -0.02974289f, 0.12909026f, -0.00240408f, 0.02140253f, 0.05045889f, 
    0.15244631f, 0.33673611f, 0.15070988f, 0.03795183f, -0.05062073f, 0.07437592f, -0.10969970f, 0.04021310f, 
    -0.12138935f, -0.00134754f, 0.04787282f, 0.02990423f, -0.01619957f, 0.18802610f, -0.02844701f, -0.16558126f, 
    0.11133860f, -0.06647842f, 0.05934456f, 0.01419563f, 0.02976999f, 0.09825362f, 0.18103762f, -0.06033741f, 
    -0.09135638f, -0.12227211f, 0.12518869f, -0.06563874f, 0.12163455f, 0.02259207f, -0.01568943f, -0.09225890f, 
    0.13553673f, 0.16542917f, 0.00639645f, 0.06334160f, -0.05329363f, 0.22570993f, 0.10345203f, -0.49425766f, 
    -0.00491807f, -0.01886129f, -0.10085873f, -0.03241527f, -0.05878069f, -0.11220239f, -0.05159977f, -0.11039551f, 
    -0.21516383f, -0.17782360f, 0.33391616f, -0.47023317f, 0.06722442f, -0.00922415f, -0.02480583f, 0.00248530f, 
    0.09660657f, -0.02967678f, -0.13242634f, 0.21617246f, 0.05568973f, 0.20159845f, -0.21296917f, 0.07477303f, 
    0.12842447f, 0.04306467f, -0.00086091f, -0.08283317f, 0.12760079f, 0.02039515f, 0.02497862f, -0.04990539f, 
    -0.06292994f, -0.03273014f, -0.14947325f, 0.30315182f, -0.03744175f, 0.14218567f, -0.00897928f, 0.07998275f, 
    0.01893922f, 0.05876091f, 0.16511796f, -0.01767210f, -0.04451336f, -0.30187431f, -0.10771181f, 0.16658255f, 
    -0.08897257f, 0.04195672f, 0.03855022f, -0.08652683f, 0.01183162f, -0.09647338f, 0.00862292f, -0.02905099f, 
    0.07472859f, -0.17913575f, 0.19311804f, -0.06939497f, 0.03065270f, 0.09153158f, -0.07589319f, 0.07770851f, 
    0.07195335f, 0.05394815f, -0.13281360f, -0.03180901f, 0.29824471f, -0.11469427f, -0.26764542f, -0.22562683f, 
    -0.10477769f, -0.00231448f, -0.01965467f, 0.11146123f, 0.22846827f, -0.03781549f, 0.03728820f, 0.09543619f, 
    -0.21314906f, 0.24377711f, 0.03628644f, 0.23178731f, -0.09841205f, 0.04515845f, -0.06420633f, -0.03216857f, 
    0.11363702f, -0.08947004f, 0.29485381f, 0.15231021f, -0.11829606f, -0.00723495f, 0.15775751f, 0.21714151f, 
    -0.10481613f, -0.05594847f, 0.04214000f, -0.01745107f, 0.02762700f, -0.13683692f, 0.16898382f, 0.17356731f, 
    -0.05529484f, 0.27732664f, 0.01688218f, -0.10142525f, -0.15851296f, 0.13398118f, 0.13588655f, 0.00035490f, 
    0.05599022f, 0.03337818f, 0.02808240f, -0.03048542f, 0.32411233f, -0.22501661f, 0.15801644f, 0.04047763f, 
    -0.03806169f, 0.09824113f, -0.07239349f, -0.06466793f, 0.07930636f, 0.11437502f, -0.02347537f, -0.08825211f, 
    -0.44868433f, -0.12877344f, 0.06705846f, -0.07256928f, -0.14456350f, 0.07601775f, 0.14342041f, 0.06094516f, 
    0.08308051f, 0.08493044f, -0.11888495f, -0.06217184f, -0.28091091f, -0.26369700f, 0.02084791f, -0.16227238f, 
    0.07523566f, -0.07363213f, 0.08687301f, -0.11358360f, -0.14393735f, -0.05721567f, -0.05717774f, -0.01335406f, 
    -0.07586592f, -0.18172897f, -0.11305033f, -0.41051364f, 0.06066104f, -0.05581947f, -0.06192176f, -0.16773063f, 
    -0.05830151f, -0.03092518f, -0.22589213f, 0.05009323f, 0.38153434f, -0.02612744f, 0.01681549f, -0.13946362f, 
    -0.08550386f, -0.03747369f, -0.12147082f, -0.04375104f, -0.12573537f, -0.09787054f, 0.00112648f, -0.11057474f, 
    -0.22593227f, 0.02004296f, 0.26623008f, 0.07401320f, -0.00337266f, 0.00132056f, -0.10192655f, 0.05283605f, 
    -0.00299222f, 0.02572164f, 0.06799496f, 0.15658401f, -0.25202712f, 0.23195030f, 0.12348142f, 0.12627171f, 
    0.02931200f, 0.03546973f, 0.00040950f, -0.13039535f, -0.09393790f, 0.17579333f, -0.05268530f, 0.01540895f, 
    0.02718198f, 0.27927747f, -0.18861130f, 0.17431132f, 0.01666353f, -0.02342246f, 0.02412700f, 0.02693329f, 
    0.05061679f, -0.10765716f, -0.07205055f, -0.16794926f, 0.38176233f, -0.27012324f, 0.02964675f, 0.03782810f, 
    -0.11806277f, 0.14793497f, 0.05861373f, 0.26428369f, 0.03029323f, 0.11101156f, 0.00549494f, 0.14220598f, 
    -0.06727381f, -0.14871179f, -0.04062891f, 0.03464189f, -0.09640215f, -0.02506019f, -0.15392520f, 0.04879970f, 
    -0.04377315f, -0.01316552f, 0.12425748f, 0.01965174f, 0.36729425f, 0.39716914f, 0.21387012f, 0.11067087f, 
    0.03530203f, 0.09628199f, -0.01313084f, -0.05763529f, -0.05303973f, 0.00287993f, 0.07073042f, -0.13820304f, 
    0.30049241f, 0.43270719f, -0.13002189f, 0.05635398f, -0.00249365f, 0.02365519f, 0.11065477f, -0.00452803f, 
    -0.01785763f, 0.13910024f, 0.00032518f, 0.15775810f, 0.27267578f, 0.05309565f, -0.06509628f, 0.29886171f, 
    0.12081961f, 0.11245710f, 0.02097383f, 0.06566556f, -0.13253605f, 0.07450569f, 0.06271730f, -0.06653092f, 
    0.13587794f, -0.10125238f, -0.02888551f, -0.20009251f, 0.17783901f, -0.04681247f, -0.01391983f, -0.07652181f, 
    0.07887063f, 0.04390280f, -0.19509107f, 0.09112065f, -0.07469120f, 0.35448715f, 0.07100420f, 0.12585486f, 
    -0.11937708f, 0.10577777f, 0.06890379f, 0.05653047f, 0.13764416f, 0.06253615f, -0.09236553f, -0.05710852f, 
    0.18508257f, 0.08315147f, -0.02839358f, 0.10249308f, 0.22882773f, -0.06398408f, -0.06263167f, -0.05989353f, 
    -0.15307488f, 0.06298075f, 0.07709914f, 0.04986145f, 0.02291418f, -0.30685499f, 0.02214879f, 0.35751450f, 
    -0.04572954f, -0.07821421f, -0.08273607f, 0.07808344f, -0.03708776f, 0.18123887f, 0.05190526f, 0.23075652f, 
    0.11387675f, -0.01912832f, -0.02880771f, -0.13861230f, -0.15687419f, 0.14197436f, 0.07460943f, 0.02671649f, 
    -0.05019931f, -0.02307363f, 0.16438998f, -0.00003556f, -0.29770866f, -0.10327755f, 0.15557419f, -0.04395794f, 
    -0.08454203f, -0.06537200f, 0.02647420f, -0.08169511f, 0.05181201f, -0.00678258f, -0.01281017f, -0.02151139f, 
    -0.37273982f, 0.45067078f, 0.12003236f, 0.15955469f, 0.05454773f, 0.05463989f, -0.08049218f, 0.12326892f, 
    0.05096970f, 0.11277037f, 0.00242098f, -0.03977553f, -0.02678054f, 0.25714284f, 0.07987098f, 0.04467365f, 
    0.14618501f, -0.04755591f, -0.00925945f, -0.10276569f, 0.19157936f, 0.02691119f, 0.19046074f, 0.11993285f, 
    -0.26636273f, -0.06182440f, 0.15794563f, 0.10080069f, 0.09793552f, 0.05424455f, -0.08220632f, -0.12282336f, 
    0.04032839f, 0.11291454f, 0.05445764f, -0.10769071f, -0.36461166f, 0.12199522f, 0.18202570f, -0.28325069f, 
    0.07180347f, 0.11383871f, 0.03657485f, 0.03268047f, -0.12397566f, -0.02642631f, 0.06440835f, 0.06615971f, 
    -0.29709721f, 0.11433101f, 0.43872139f, -0.29359618f, 0.00862196f, 0.02369234f, 0.02231850f, 0.01562130f, 
    0.10390368f, 0.08061979f, 0.11692670f, 0.22530527f, -0.00153699f, 0.58259708f, 0.03678993f, 0.13954416f, 
    0.05151509f, -0.05845903f, -0.06864849f, -0.08546497f, 0.12193350f, -0.08509895f, 0.04792471f, -0.19716386f, 
    -0.02223305f, -0.20281401f, -0.26123694f, 0.49264124f, 0.06160190f, 0.20010605f, 0.07124950f, 0.13224159f, 
    -0.06321153f, -0.05044068f, -0.07912478f, 0.06033581f, -0.14911196f, -0.35017031f, -0.07566208f, 0.10673723f, 
    -0.08143923f, 0.10722344f, -0.03824867f, 0.03923869f, 0.12972115f, -0.01468929f, -0.00807638f, 0.07655799f, 
    0.15464969f, -0.32156304f, 0.18080823f, -0.02780130f, 0.04298238f, -0.05769731f, 0.11088259f, -0.01075835f, 
    -0.04256581f, -0.15192272f, -0.03785403f, -0.05677789f, 0.27533099f, 0.00582649f, 0.02930725f, 0.17698549f, 
    -0.10664769f, -0.03681804f, 0.05926454f, 0.02705636f, -0.02010017f, -0.08743035f, -0.12304321f, 0.05140732f, 
    -0.04269484f, -0.00492843f, -0.04955853f, -0.05664140f, -0.03524655f, -0.02307109f, -0.02656483f, -0.05551010f, 
    -0.01917484f, -0.05999285f, -0.06119199f, -0.06685501f, 0.02407758f, -0.02198898f, 0.04841429f, 0.04730243f, 
    -0.04719761f, -0.05674449f, 0.00756515f, -0.06690475f, -0.01990672f, -0.06392170f, -0.03259963f, -0.04527440f, 
    0.02921738f, -0.00556682f, -0.03635118f, -0.05309996f, 0.02191932f, -0.01304969f, 0.01335841f, -0.08243918f, 
    0.00902261f, -0.08075520f, 0.06542696f, -0.03444773f, -0.00772009f, 0.00446395f, -0.04099458f, -0.03011763f, 
    -0.05688446f, -0.08613798f, -0.01329053f, 0.03217282f, -0.06494709f, 0.00587756f, -0.01858790f, 0.02846843f, 
    -0.01412630f, 0.06274346f, 0.00259444f, 0.00582387f, -0.02937058f, -0.01262712f, 0.06084655f, 0.04570245f, 
    0.02263621f, 0.01493192f, 0.01017333f, -0.05802726f, 0.01269781f, -0.05362636f, -0.07584512f, 0.03834172f, 
    -0.01421443f, -0.02137834f, -0.02676433f, -0.02181420f, -0.00601886f, -0.01896966f, 0.04877961f, -0.04620083f, 
    -0.04445085f, 0.00092671f, 0.04460502f, -0.01986153f, -0.00488443f, -0.00369910f, -0.05213733f, 0.05934874f, 
    0.00040667f, -0.04655200f, 0.00645370f, -0.03416601f, 0.06365431f, 0.04051055f, -0.07636642f, -0.08029441f, 
    0.06565550f, 0.04808002f, -0.01257744f, -0.07238891f, 0.06952565f, 0.01706651f, 0.04171169f, -0.02076959f, 
    -0.02520439f, -0.02714180f, -0.07909850f, 0.01830154f, 0.00358468f, 0.05698920f, -0.05177522f, 0.06457307f, 
    -0.02773754f, -0.07149024f, -0.06121656f, 0.01838693f, 0.01381977f, -0.05574150f, 0.04059914f, -0.00321403f, 
    -0.05423204f, 0.04197080f, -0.03568564f, 0.03112355f, -0.01932384f, -0.05893968f, -0.02369618f, 0.05305578f, 
    -0.00326062f, -0.05712375f, -0.04891969f, -0.06050224f, -0.02717541f, -0.00737399f, -0.02135570f, 0.04792289f, 
    -0.06040761f, 0.00011698f, -0.00749423f, 0.06161688f, 0.05335619f, -0.07543835f, -0.05484897f, 0.00844965f, 
    0.00194505f, -0.04053271f, 0.05259952f, -0.07191538f, -0.06726357f, -0.05493571f, 0.05972757f, -0.02248485f, 
    0.04516495f, 0.05373840f, 0.02112724f, -0.00196869f, 0.05838874f, 0.02488615f, 0.04805852f, 0.05803991f, 
    -0.05886839f, -0.00806415f, -0.06472399f, -0.05852720f, -0.03268620f, 0.07281138f, 0.03830251f, 0.04312678f, 
    -0.03123368f, -0.04755878f, -0.02500090f, 0.05403217f, -0.01358205f, -0.01812790f, 0.03259702f, -0.08102932f, 
    0.03620347f, -0.06446528f, 0.03510122f, -0.03980999f, 0.04980666f, -0.03768464f, -0.07034796f, 0.02667657f, 
    -0.05149972f, 0.00543637f, -0.06500445f, 0.02980416f, -0.03768122f, 0.01908449f, -0.07974153f, 0.01593177f, 
    -0.05441725f, 0.03240636f, -0.03588396f, -0.02298132f, -0.05898562f, 0.02639543f, 0.06445376f, 0.01669244f, 
    0.00607730f, -0.14217688f, -0.09964442f, -0.02798052f, -0.05270788f, -0.06821331f, 0.04009397f, 0.01146685f, 
    -0.04196906f, 0.02354408f, -0.00798110f, -0.06118612f, 0.19512247f, 0.00670405f, 0.04834382f, -0.02808492f, 
    0.11618158f, 0.02703341f, 0.00128157f, 0.01601825f, 0.00756633f, 0.10264230f, -0.10889123f, -0.07782327f, 
    -0.12788534f, -0.28015095f, -0.06177208f, -0.01553549f, -0.00936341f, -0.03860772f, 0.06437434f, -0.07452451f, 
    0.07685746f, -0.04801193f, -0.00162684f, -0.11108179f, -0.03554460f, 0.36158666f, 0.13874826f, 0.00666845f, 
    0.00420041f, -0.03232209f, -0.01536110f, 0.08486778f, -0.11695781f, -0.17741862f, 0.01088210f, 0.03640679f, 
    0.33691928f, -0.04471775f, -0.21138832f, -0.17340882f, -0.05895944f, 0.06781386f, -0.06099182f, 0.06794465f, 
    0.14758603f, -0.01685485f, -0.05531809f, 0.09383348f, 0.28034556f, 0.14515881f, 0.12948851f, 0.35344851f, 
    -0.11281755f, -0.02987354f, -0.13056527f, 0.02744151f, 0.06567216f, -0.01187750f, 0.07570570f, -0.09926958f, 
    0.28836158f, -0.26436588f, -0.10408618f, 0.26147395f, -0.03305824f, -0.12468598f, 0.04212510f, -0.11576481f, 
    0.07725030f, 0.02915669f, 0.12423582f, -0.17067873f, -0.15884706f, -0.02145346f, 0.06513640f, -0.09736527f, 
    0.09282123f, -0.01897355f, -0.00704578f, 0.12561122f, 0.02181750f, 0.06212427f, -0.10527924f, 0.05726639f, 
    0.40659207f, 0.33590043f, -0.11289490f, 0.16899651f, -0.17189245f, 0.07788884f, 0.25090140f, 0.03324841f, 
    -0.07382574f, -0.19095612f, -0.07478797f, -0.18703359f, 0.29776186f, -0.09149811f, -0.28937244f, 0.45192868f, 
    0.03734081f, -0.07144978f, 0.07441135f, 0.04001483f, -0.05132100f, 0.05482236f, 0.04489426f, 0.01582598f, 
    0.21245699f, -0.03659374f, -0.12945855f, 0.15242872f, -0.00375235f, -0.01446860f, -0.15140694f, -0.04226723f, 
    -0.01678994f, 0.07621247f, -0.10354090f, -0.10402968f, -0.18529151f, 0.18191144f, -0.05997932f, -0.11142071f, 
    0.07410108f, -0.03776113f, 0.05919654f, -0.00909860f, -0.13668332f, 0.08066608f, -0.02464140f, -0.06933577f, 
    0.24183957f, 0.33176520f, 0.32704553f, 0.10420533f, 0.02633885f, -0.04668602f, -0.07599335f, -0.09774032f, 
    0.03677757f, -0.01429426f, 0.04625846f, 0.00858258f, -0.16976483f, -0.10876582f, -0.32960662f, -0.17990564f, 
    0.12243829f, -0.03685598f, 0.04191592f, 0.09815636f, -0.02490861f, -0.09741265f, -0.23671249f, -0.15232128f, 
    -0.28155676f, 0.18222381f, 0.14617141f, 0.14172232f, -0.00286231f, 0.08440913f, -0.01041474f, -0.10704272f, 
    -0.04340036f, 0.04347681f, 0.17641628f, 0.01269308f, 0.03777257f, 0.28908572f, 0.26963499f, -0.01302312f, 
    0.00682569f, 0.09307720f, 0.13780156f, -0.19483675f, 0.04176578f, 0.01335146f, -0.02313404f, -0.06383441f, 
    -0.43882191f, -0.19865863f, -0.29157203f, -0.04895784f, -0.10754982f, -0.05589187f, -0.09586854f, -0.08250172f, 
    0.15216427f, 0.25903487f, -0.21854384f, 0.14143741f, 0.04113629f, 0.00353577f, -0.20953813f, 0.00791917f, 
    0.04255419f, 0.21415794f, 0.00368736f, 0.00657707f, 0.12250751f, 0.02961577f, 0.04906368f, -0.08932373f, 
    -0.10988532f, 0.00153714f, 0.04193608f, 0.15153430f, 0.01424335f, 0.01936763f, 0.04252366f, -0.05769858f, 
    0.03679473f, 0.07783472f, -0.23775451f, -0.10786135f, 0.40199199f, 0.52218622f, 0.31806451f, -0.01406266f, 
    0.10678388f, -0.00790834f, 0.12596646f, -0.10992350f, -0.08836644f, -0.11319175f, -0.02096631f, 0.03174489f, 
    0.10508214f, -0.05188810f, 0.11925966f, 0.30179510f, -0.09503583f, 0.00541487f, 0.14921653f, 0.05040535f, 
    -0.16781002f, -0.13744909f, -0.01116014f, -0.11504360f, 0.21964107f, 0.35053214f, 0.29855552f, 0.06423510f, 
    -0.12855968f, 0.00039451f, 0.08875787f, 0.14232644f, 0.01530910f, 0.09745317f, -0.06219238f, -0.07972955f, 
    -0.18650749f, 0.32676572f, 0.11544070f, 0.25501385f, 0.07355195f, 0.16067196f, -0.04717729f, 0.18543084f, 
    -0.07321906f, -0.06976245f, -0.10556540f, -0.09445118f, -0.39629057f, 0.07035430f, -0.09925079f, -0.11663622f, 
    -0.00341653f, -0.20498116f, -0.05224662f, 0.01766116f, 0.14320655f, -0.06902717f, -0.09422328f, 0.02619653f, 
    -0.12882213f, 0.26674798f, -0.22703382f, 0.01318782f, 0.31460506f, 0.12850307f, 0.09242311f, -0.08927365f, 
    -0.12281346f, -0.00431362f, -0.07868896f, 0.08838599f, 0.13758653f, -0.12113552f, 0.03242173f, 0.13771376f, 
    -0.10439248f, -0.06424513f, 0.02426372f, -0.08426882f, -0.11985324f, -0.07401171f, 0.04576262f, 0.06645606f, 
    -0.27797726f, -0.03589777f, -0.00723701f, -0.13576961f, -0.17496975f, -0.02571454f, -0.16707933f, 0.01175548f, 
    -0.09796794f, -0.10002363f, -0.16327065f, -0.04679988f, -0.18839760f, 0.48844069f, 0.08046108f, -0.04242652f, 
    0.10285607f, -0.10581604f, -0.09529192f, -0.08998141f, -0.09261519f, -0.03064304f, -0.01687281f, -0.06857730f, 
    0.09563849f, -0.00285549f, 0.19070117f, 0.11342565f, 0.27431056f, 0.06156938f, 0.04145135f, 0.06213468f, 
    0.02928302f, -0.08444229f, -0.14335294f, 0.05249564f, -0.56627190f, -0.46363127f, 0.11473553f, 0.29581913f, 
    -0.09046287f, 0.12748773f, -0.05689685f, -0.02053874f, -0.10985386f, -0.05309262f, 0.03693250f, 0.00905455f, 
    0.19393528f, 0.19448677f, 0.07999091f, -0.00938259f, 0.21694113f, 0.02734895f, 0.09981409f, 0.01442202f, 
    -0.15849644f, 0.06570183f, 0.01243537f, 0.04303275f, 0.11638749f, -0.24484521f, -0.10632391f, -0.04126318f, 
    0.18226929f, 0.03620057f, 0.11956875f, -0.07932661f, 0.19511120f, 0.11917800f, -0.07238819f, 0.05508397f, 
    -0.18587187f, 0.20465197f, 0.24074374f, 0.16980980f, 0.08779395f, 0.14115480f, -0.06764998f, 0.03816372f, 
    0.15933394f, -0.09014654f, 0.09628701f, 0.08329796f, -0.17242707f, -0.12703434f, -0.07377951f, -0.08652739f, 
    0.10353190f, 0.16969590f, -0.10504919f, -0.16872862f, -0.04487953f, -0.05799273f, 0.01437328f, 0.02402307f, 
    -0.15686825f, 0.12743860f, 0.14963891f, -0.26723006f, -0.13749270f, 0.10999332f, 0.06304540f, -0.01705518f, 
    0.09184775f, 0.04847167f, -0.09261844f, 0.12624787f, -0.09532925f, 0.00894674f, -0.07768265f, 0.07711088f, 
    0.03350157f, 0.07201166f, 0.05237953f, 0.17960002f, 0.01235484f, 0.05029986f, 0.09684564f, 0.13245492f, 
    -0.02298950f, 0.13828036f, 0.17693822f, -0.05055140f, 0.15497485f, 0.02635689f, -0.08655360f, -0.12591690f, 
    0.08782174f, -0.01152553f, -0.01461233f, 0.13844354f, -0.02578195f, -0.18157680f, 0.32122010f, 0.07768364f, 
    0.02495834f, -0.09045114f, 0.15853937f, -0.00119965f, 0.02852470f, 0.05981435f, 0.08405723f, 0.08620194f, 
    0.17224680f, 0.04036651f, -0.15344022f, -0.03779902f, 0.13924669f, -0.00959362f, -0.11858623f, 0.03934133f, 
    0.22452581f, -0.15729477f, 0.08367556f, 0.00370252f, -0.24679939f, -0.04953649f, -0.14247340f, 0.06223847f, 
    0.04206073f, -0.04836747f, 0.05711569f, -0.06567039f, 0.06384566f, 0.13626684f, 0.07154772f, 0.12934101f, 
    -0.34582013f, -0.05715852f, -0.24540266f, -0.16438945f, 0.20076744f, -0.09800159f, -0.02699593f, -0.02184812f, 
    0.08229438f, -0.01204542f, -0.02574280f, -0.12686801f, -0.28099427f, 0.11163056f, 0.29030299f, -0.08406815f, 
    -0.17591724f, -0.04064641f, -0.12997055f, 0.09802691f, -0.06712728f, 0.13872391f, -0.00617658f, 0.11212141f, 
    -0.00925932f, 0.05891042f, 0.01199521f, 0.18498777f, 0.17021643f, 0.07780672f, 0.10704714f, 0.02744652f, 
    0.07260052f, 0.06577724f, 0.13420351f, 0.00876287f, -0.18165745f, -0.05992639f, -0.11972595f, -0.01260649f, 
    0.03491141f, 0.02424262f, -0.00943823f, -0.03209109f, -0.02644766f, 0.05767258f, -0.05003334f, -0.06712003f, 
    -0.02032665f, -0.34713313f, 0.08300511f, -0.11406141f, 0.11694217f, 0.15230261f, 0.05330499f, 0.26600894f, 
    -0.15405264f, -0.06880075f, -0.06426837f, -0.01707947f, 0.03182662f, 0.13367930f, 0.39741364f, 0.03829015f, 
    0.11397408f, 0.09984973f, -0.14761443f, -0.01134322f, 0.24086009f, 0.06696193f, 0.06904533f, 0.10999908f, 
    -0.47358826f, -0.16412169f, 0.03044096f, 0.08481071f, -0.05385695f, -0.15033202f, 0.02862090f, 0.00380161f, 
    0.11178337f, -0.04709886f, 0.00110862f, -0.01364641f, -0.21871965f, -0.19642754f, -0.17690776f, 0.09856748f, 
    0.29970831f, 0.04358561f, 0.13364935f, 0.09818684f, -0.03218098f, 0.05656789f, -0.09652743f, 0.04190511f, 
    -0.04392559f, 0.03022724f, 0.01303514f, 0.04456635f, 0.00728007f, 0.04723547f, 0.05562861f, -0.02851815f, 
    -0.02434852f, 0.03165937f, 0.01132598f, -0.00113195f, -0.07699566f, 0.02242853f, 0.01870073f, -0.04265983f, 
    0.06002219f, 0.02446503f, -0.00076288f, -0.05865734f, -0.03712322f, -0.00428633f, 0.05325716f, 0.01025572f, 
    0.06543467f, 0.02828849f, 0.01132855f, -0.02875163f, 0.05990558f, 0.04486437f, 0.04307754f, 0.01171998f, 
    -0.02885488f, -0.06056879f, 0.02109196f, 0.05230404f, -0.02685387f, 0.05485061f, -0.01602460f, -0.06284495f, 
    -0.05208417f, -0.07658383f, -0.05639649f, 0.03838883f, -0.06816338f, 0.00491422f, 0.05636794f, -0.01514486f, 
    -0.04621528f, 0.05450746f, -0.02487819f, -0.03025718f, -0.04865671f, -0.01696479f, -0.03306700f, -0.03879175f, 
    0.02563849f, -0.07458255f, 0.06289670f, -0.04594789f, -0.01405144f, -0.01074168f, -0.02844445f, -0.03460943f, 
    -0.00590694f, -0.01273151f, -0.06499167f, -0.02589437f, -0.03573880f, -0.01375306f, -0.04752679f, 0.04547547f, 
    -0.07200578f, -0.00677627f, -0.03851744f, 0.04133463f, -0.01716746f, 0.00503075f, -0.05874890f, -0.03970918f, 
    -0.02135216f, 0.03207806f, -0.02425211f, 0.00262153f, -0.07150638f, -0.02460820f, 0.00305264f, -0.02102957f, 
    0.01291894f, 0.01260258f, -0.01230335f, -0.03524892f, -0.05886469f, -0.05898401f, 0.06232625f, -0.04819853f, 
    0.04425082f, 0.05716382f, -0.01442636f, 0.05496103f, 0.02399207f, -0.04618882f, 0.04915901f, 0.05513666f, 
    -0.02013058f, 0.02103374f, 0.06311700f, 0.03461100f, 0.00147113f, -0.00709941f, 0.05111761f, -0.02182703f, 
    -0.07355867f, -0.04324047f, -0.01846539f, -0.05807178f, -0.02834356f, -0.00128042f, -0.03057862f, 0.00538210f, 
    -0.02697967f, -0.01361907f, -0.04845382f, -0.05807255f, -0.06993400f, -0.03930898f, -0.03669826f, 0.06084444f, 
    -0.01208426f, -0.07370768f, -0.05413697f, 0.04244078f, -0.07255895f, 0.04677856f, -0.05434667f, 0.03568874f, 
    0.03434709f, -0.06111620f, -0.01303248f, -0.01173557f, -0.02537084f, -0.06709940f, 0.05856397f, 0.03592829f, 
    -0.05455663f, -0.07537536f, -0.01749281f, 0.05321870f, -0.04351107f, -0.02222895f, -0.01405332f, 0.05922680f, 
    -0.03318668f, 0.02098976f, 0.00224729f, -0.00794963f, -0.03711663f, 0.04501646f, 0.02285071f, -0.03471158f, 
    0.04619564f, -0.05751044f, 0.06165678f, 0.03551312f, 0.00966939f, -0.04703130f, -0.07278687f, -0.00748480f, 
    -0.06449654f, 0.02474492f, -0.01815107f, -0.03529436f, -0.03898255f, -0.01140488f, 0.02937663f, 0.04102882f, 
    -0.04379123f, 0.02092046f, -0.02829250f, -0.01314250f, -0.04379551f, -0.06903168f, -0.01802671f, 0.02485923f, 
    -0.03594039f, -0.00009260f, -0.07079018f, -0.07515886f, -0.05016998f, -0.03177295f, 0.04112365f, 0.02175919f, 
    -0.41000599f, -0.30082276f, -0.25076610f, 0.07048244f, -0.04619090f, -0.06955411f, 0.01369153f, 0.05479599f, 
    -0.01981541f, 0.04076653f, 0.05487211f, -0.03313686f, -0.26795080f, -0.34447849f, 0.11840768f, 0.20329617f, 
    -0.10021473f, -0.17110644f, 0.02312486f, 0.03131906f, 0.05519051f, 0.00576674f, 0.13360494f, 0.07949220f, 
    -0.33819339f, -0.17170186f, -0.10925276f, 0.00051943f, 0.03487150f, -0.08619252f, 0.08483031f, -0.02035694f, 
    0.21183875f, -0.00710071f, 0.05252090f, -0.07883764f, 0.40276396f, 0.31355643f, 0.18448269f, -0.00203396f, 
    0.01980218f, 0.09342626f, -0.09316748f, -0.03023630f, 0.06674613f, 0.05488532f, -0.11652848f, -0.01731161f, 
    -0.46475258f, -0.24486269f, -0.18914135f, 0.05583721f, -0.02119938f, 0.15914178f, 0.14362721f, 0.03946276f, 
    0.01082426f, 0.07747809f, -0.12530276f, 0.05583970f, -0.26231399f, 0.41752765f, 0.00300119f, -0.13102615f, 
    0.25230893f, 0.16174366f, 0.07068948f, 0.02943245f, -0.02364601f, 0.08776188f, 0.03065924f, -0.00193353f, 
    -0.15933691f, -0.30730292f, 0.00943922f, -0.15624785f, 0.12129655f, -0.09559447f, 0.11112593f, -0.00081825f, 
    -0.02928763f, 0.05126506f, -0.04842436f, 0.08118720f, 0.27989787f, 0.00066549f, 0.04780751f, -0.04859533f, 
    -0.03351860f, 0.04508985f, -0.10400867f, 0.06730736f, -0.04689582f, 0.00653712f, 0.07386414f, -0.00763823f, 
    0.28446561f, -0.01676090f, 0.05543626f, 0.21268652f, -0.15609337f, -0.10568913f, 0.01377830f, 0.10638083f, 
    -0.07595010f, 0.00191922f, 0.00888122f, 0.08409158f, 0.22995308f, -0.22683097f, -0.18996614f, 0.35885242f, 
    0.24485756f, 0.11610821f, 0.04724350f, -0.03881599f, 0.08270629f, 0.16393031f, -0.07903525f, -0.06357054f, 
    0.19974913f, -0.07726248f, -0.14169665f, 0.20317461f, -0.04472263f, 0.00797766f, -0.05581985f, 0.07793022f, 
    0.09979987f, -0.09446957f, 0.02230537f, -0.03581117f, 0.25610664f, -0.07489403f, -0.02505792f, -0.06390878f, 
    -0.27030614f, 0.05726914f, 0.10860822f, 0.17878088f, -0.02528367f, 0.18769424f, -0.12979878f, 0.01701996f, 
    0.24290378f, 0.13413480f, -0.05591118f, -0.09528386f, -0.15698263f, 0.02322410f, 0.04935749f, -0.08892586f, 
    0.05073725f, 0.09168018f, 0.16920139f, 0.00408364f, -0.02845696f, 0.05591397f, -0.16725211f, 0.13797635f, 
    0.08478168f, 0.01331146f, 0.01724177f, 0.00284698f, -0.19195130f, 0.07396942f, -0.04320534f, -0.17653155f, 
    0.46823370f, 0.53714466f, -0.18469854f, -0.08324024f, -0.11541141f, 0.08760112f, 0.04841689f, 0.11202532f, 
    -0.07181048f, 0.16560963f, -0.03657786f, 0.17388713f, 0.19293417f, 0.09101811f, 0.17562313f, 0.04133434f, 
    -0.10937892f, 0.02818005f, 0.08472031f, 0.03365625f, -0.15720987f, 0.03991301f, 0.05179221f, -0.04319171f, 
    0.08055053f, -0.44291222f, -0.09470177f, -0.09752145f, 0.07668195f, -0.14536175f, -0.09115422f, 0.02496323f, 
    0.09211437f, 0.06981316f, -0.12431860f, 0.06320243f, -0.39564261f, -0.05438288f, 0.08965106f, -0.04997842f, 
    0.01247155f, -0.07899079f, 0.01633896f, 0.07679709f, 0.06445483f, -0.09540915f, 0.07853969f, -0.12237893f, 
    -0.05519314f, -0.30075574f, -0.04545920f, 0.07555962f, 0.27591026f, -0.08170570f, 0.01240179f, 0.09324267f, 
    0.08467588f, -0.02532868f, 0.07352273f, 0.11770570f, -0.14590549f, 0.05390422f, -0.10167629f, 0.15687539f, 
    0.09001408f, 0.08154842f, -0.02249341f, 0.16644162f, 0.09503223f, 0.03099713f, -0.05770566f, 0.06661314f, 
    0.06282400f, -0.21839285f, -0.06032704f, 0.08618762f, 0.04470988f, 0.08634239f, -0.05139163f, 0.05227520f, 
    0.11265690f, 0.06498868f, 0.04183388f, 0.13040678f, -0.11688251f, 0.34845775f, 0.12903826f, -0.15196262f, 
    -0.06018007f, -0.00583379f, 0.04992446f, -0.07379520f, 0.05265358f, 0.03605304f, 0.07510130f, -0.02311093f, 
    -0.05216447f, -0.04118284f, 0.04046104f, -0.19597664f, 0.18676680f, -0.09217176f, 0.10688643f, -0.02054564f, 
    -0.03644606f, 0.01638939f, 0.04264173f, -0.03235997f, -0.13860258f, 0.01402920f, -0.07933928f, -0.05545656f, 
    0.09895366f, 0.00335239f, -0.08754565f, 0.08241475f, 0.04012596f, -0.01123147f, 0.09480491f, -0.01912957f, 
    0.06094961f, -0.04418845f, 0.06430881f, 0.03648696f, 0.01387492f, -0.08348569f, 0.18787560f, 0.05261632f, 
    0.04155184f, -0.06383914f, 0.01517737f, -0.02919187f, 0.11592314f, -0.07067849f, 0.04607983f, 0.04772687f, 
    -0.04749873f, -0.00517347f, -0.12195078f, -0.00494842f, 0.30421194f, 0.02025608f, -0.01068428f, 0.04778760f, 
    0.21060987f, -0.16702661f, -0.02819211f, 0.02278532f, 0.02700769f, 0.20537944f, -0.01903863f, -0.03632746f, 
    0.16983147f, -0.02912540f, -0.00050243f, 0.18167415f, -0.10894042f, 0.27727860f, -0.07653075f, 0.14449872f, 
    0.02353327f, 0.08868147f, 0.09403599f, 0.09911165f, 0.00893050f, 0.05302989f, -0.05762995f, -0.08454523f, 
    0.26532856f, 0.02927727f, -0.06428564f, -0.13677254f, -0.03029994f, -0.05814677f, 0.00668022f, 0.11928346f, 
    0.04636600f, -0.01443485f, -0.03305013f, -0.01877835f, 0.00828189f, -0.11888382f, -0.23162307f, 0.26299506f, 
    -0.06738713f, 0.06300300f, -0.01277290f, -0.00287415f, -0.00376306f, 0.10079604f, 0.11539891f, -0.09530095f, 
    0.48222530f, -0.15648200f, -0.04799879f, -0.16421032f, -0.07356198f, -0.02301214f, 0.15350913f, 0.05873648f, 
    0.00041889f, 0.05156869f, 0.02336926f, 0.06557450f, -0.12871377f, 0.12359916f, 0.09009114f, 0.07713097f, 
    -0.03841626f, 0.07242548f, 0.01456564f, -0.00488313f, 0.01181326f, 0.06164068f, 0.00792621f, -0.06866113f, 
    -0.23878095f, -0.02423742f, 0.20323093f, 0.06990189f, -0.00307926f, 0.10084262f, 0.07521167f, 0.16738085f, 
    -0.06594232f, -0.07120499f, 0.00431936f, 0.01047575f, 0.05993204f, -0.07999062f, -0.25408867f, -0.08356000f, 
    0.05742852f, -0.07008120f, 0.04800297f, -0.08417732f, -0.12245192f, -0.09120155f, 0.06161134f, -0.00988262f, 
    -0.59554458f, -0.22544245f, -0.13250370f, -0.22218890f, 0.02724413f, -0.07386397f, 0.12318724f, 0.10233768f, 
    0.10426435f, -0.11616215f, -0.14503673f, 0.03502203f, 0.08376727f, 0.23558027f, -0.11912188f, 0.11881343f, 
    0.20741953f, 0.02601402f, 0.24294317f, 0.06968254f, -0.06136812f, 0.00379096f, 0.06664655f, -0.01687268f, 
    0.20533353f, 0.17993523f, 0.22629599f, 0.17216823f, 0.21230447f, 0.09904486f, 0.03630707f, 0.08115240f, 
    0.05552257f, -0.00350390f, 0.01463852f, 0.04168331f, 0.17237233f, 0.26962489f, 0.23556039f, 0.08279976f, 
    0.14514974f, 0.27202180f, 0.01340583f, 0.10991271f, 0.10164159f, 0.06165988f, 0.02255898f, 0.16849537f, 
    0.10445859f, 0.12069851f, 0.05708488f, 0.31897959f, 0.10481251f, -0.00970170f, 0.04353257f, 0.13769081f, 
    0.24016105f, 0.09523375f, 0.17253485f, 0.14614652f, -0.13226132f, -0.17315574f, -0.13991940f, 0.09682835f, 
    0.11178160f, 0.10998286f, 0.08740573f, 0.12372617f, 0.02812430f, 0.09580357f, 0.14091247f, 0.05759173f, 
    0.19987245f, -0.07710476f, -0.28124011f, -0.06844602f, 0.06931719f, -0.00776556f, 0.17428412f, -0.03230473f, 
    0.02958523f, 0.03102296f, 0.09654954f, 0.12187406f, 0.11250961f, 0.20948644f, 0.02980801f, -0.34849530f, 
    0.07326134f, 0.02040824f, 0.01879741f, 0.11360823f, 0.07048947f, -0.05517795f, -0.19063738f, 0.03701783f, 
    -0.03377685f, -0.26127189f, 0.15897287f, 0.31254199f, -0.00051496f, 0.12459845f, 0.10350010f, 0.08291946f, 
    0.04244122f, 0.03066282f, -0.06204652f, 0.02467989f, -0.15474024f, -0.22789216f, -0.15492837f, -0.16417849f, 
    0.17745285f, -0.12626809f, 0.14276432f, 0.22110826f, 0.03972720f, 0.12266799f, 0.02732598f, 0.10017248f, 
    0.09267967f, -0.11858716f, -0.07814259f, -0.13079631f, 0.00592720f, -0.16094369f, 0.07482500f, 0.00636535f, 
    0.07594460f, 0.08497865f, 0.09179738f, -0.06803973f, -0.64069271f, -0.07862206f, 0.17148019f, -0.38387474f, 
    0.08073151f, 0.00938859f, 0.01584510f, 0.18044207f, 0.09908461f, 0.16328421f, 0.04460927f, 0.30571893f, 
    -0.08539901f, -0.25502923f, 0.09413107f, -0.04738751f, -0.09608111f, 0.07103546f, 0.08001903f, -0.01458675f, 
    -0.12113276f, 0.21969041f, 0.16422191f, 0.00326913f, -0.40091971f, 0.05277084f, -0.22641020f, -0.11774986f, 
    -0.02880674f, -0.03395096f, -0.03248255f, -0.05668347f, 0.09791044f, 0.03156348f, -0.02751955f, -0.04256274f, 
    0.02718955f, 0.00059921f, -0.02270000f, 0.03093694f, 0.05695269f, 0.11251561f, 0.19865651f, -0.13615899f, 
    -0.07363733f, -0.04729554f, -0.15516731f, 0.03601750f, 0.27780879f, -0.19275539f, 0.01218701f, -0.02257178f, 
    -0.01820654f, -0.06624744f, 0.03887041f, 0.04381678f, 0.02793993f, -0.03099911f, -0.07665632f, 0.13908589f, 
    -0.05533072f, 0.07484389f, -0.04075147f, 0.11022198f, 0.06512355f, -0.00517622f, 0.01969528f, 0.01816373f, 
    0.00298127f, 0.01879025f, 0.04784796f, 0.01864556f, -0.06711260f, -0.03901198f, 0.20919663f, -0.00922632f, 
    -0.08387181f, 0.00401499f, -0.08927060f, 0.14421758f, 0.12101250f, 0.03395601f, 0.11707208f, 0.08149476f, 
    -0.14062524f, -0.16673392f, 0.06810175f, 0.04246152f, -0.06570052f, 0.09279020f, 0.09117811f, -0.08682869f, 
    -0.02843910f, -0.04554772f, 0.09245339f, 0.11422300f, -0.48287204f, 0.13978389f, -0.18171662f, -0.23869424f, 
    0.12289018f, 0.08114106f, 0.21879067f, -0.00976226f, 0.09671624f, 0.05453603f, 0.03488690f, 0.11396310f, 
    -0.06512602f, 0.08557089f, 0.08746308f, -0.04855029f, 0.13379289f, -0.00207560f, -0.15417023f, 0.09950089f, 
    -0.09021047f, -0.09143037f, -0.02317596f, -0.08576552f, 0.10561347f, 0.20797579f, 0.02540381f, 0.16088891f, 
    0.14345783f, -0.14893432f, -0.14212656f, -0.02957517f, 0.07988414f, 0.04353112f, 0.05920475f, 0.01496141f, 
    0.28292581f, -0.13715927f, 0.02982196f, 0.08656467f, -0.00810125f, -0.20586957f, -0.06319563f, 0.03435407f, 
    0.06428263f, -0.00151003f, 0.02907807f, -0.14172459f, -0.03165140f, -0.32711485f, -0.02429197f, 0.05659160f, 
    0.25986868f, 0.10658064f, 0.02676357f, 0.01925162f, -0.09024677f, 0.04243551f, 0.17582490f, -0.11037066f, 
    0.10831532f, 0.14589398f, 0.20550980f, -0.34157544f, -0.12954319f, 0.00826652f, -0.04697049f, -0.01859660f, 
    0.09301180f, 0.13591295f, -0.02050584f, 0.09091017f, 0.35547903f, 0.23628223f, 0.01046847f, 0.15521879f, 
    -0.03766074f, -0.01875209f, -0.17217538f, 0.05298133f, -0.06927237f, 0.03635921f, -0.05814105f, -0.23216845f, 
    0.01516831f, -0.15127181f, 0.02295943f, 0.20695379f, -0.10534889f, -0.06269367f, -0.11986011f, 0.13551357f, 
    0.02907504f, 0.08066788f, -0.04642599f, 0.09502059f, 0.19730814f, -0.26766896f, -0.11161221f, 0.46102738f, 
    0.07379196f, 0.18286768f, 0.03378749f, -0.05165708f, 0.08606387f, -0.15392405f, -0.02934538f, 0.06174043f, 
    -0.25750226f, 0.12744124f, -0.19009006f, -0.29743308f, -0.03341899f, -0.19397895f, -0.09067835f, 0.16781627f, 
    0.05894744f, -0.03448916f, -0.10436865f, 0.00219394f, 0.49501619f, -0.09659853f, 0.13447757f, 0.01265584f, 
    0.03010525f, -0.14767593f, -0.05012879f, 0.18539661f, -0.12321295f, -0.04605167f, 0.08438177f, 0.06817945f, 
    -0.24355014f, 0.19879806f, 0.08017494f, 0.32657483f, -0.13932551f, 0.24791278f, 0.18821642f, 0.02649581f, 
    0.03936247f, -0.09689680f, 0.02438801f, 0.08401511f, 0.49608108f, -0.35620368f, -0.17541328f, -0.03299225f, 
    -0.00359554f, 0.01671535f, -0.05456439f, -0.23444752f, 0.00606399f, -0.04659631f, 0.01618630f, 0.15126124f, 
    -0.21897537f, 0.08027845f, 0.03620603f, 0.04543289f, -0.17424080f, 0.03967401f, 0.10105748f, -0.02244648f, 
    0.02127361f, 0.09120838f, -0.08959042f, -0.00565435f, 0.20050499f, 0.16594312f, 0.03518351f, 0.07034611f, 
    0.01643947f, 0.06615518f, 0.03382498f, -0.03949650f, 0.01783979f, 0.01693660f, 0.15499911f, 0.02141778f, 
    -0.13726601f, 0.11387673f, 0.06094613f, 0.16783193f, -0.03272724f, -0.01754530f, 0.07648905f, -0.02992130f, 
    -0.02343572f, -0.13438649f, 0.01174545f, 0.03398503f, -0.11022830f, -0.02983811f, 0.13243903f, 0.08290590f, 
    0.13735171f, 0.14840670f, -0.08884529f, 0.15642804f, -0.10572516f, -0.00473128f, 0.02066790f, 0.04603642f, 
    0.32270384f, 0.14411397f, 0.03108622f, 0.13629071f, 0.00868692f, 0.06376582f, -0.04562176f, 0.12427479f, 
    0.09140475f, -0.07153634f, -0.01185053f, 0.02544687f, -0.02409445f, 0.01159719f, -0.12371891f, 0.12393966f, 
    0.08052529f, -0.05457554f, 0.09178997f, 0.11970289f, 0.11676488f, 0.05748012f, 0.05194557f, -0.02008129f, 
    -0.03589425f, -0.00277865f, -0.26057178f, -0.20140655f, -0.00685090f, 0.01092725f, -0.00113933f, -0.03290056f, 
    0.08159571f, 0.01176957f, -0.12139183f, 0.09486379f, -0.18439773f, -0.02243639f, 0.15026544f, -0.13145553f, 
    -0.03279007f, -0.02815940f, 0.09387852f, 0.03996867f, -0.14235897f, 0.00959611f, -0.01835515f, 0.02262098f, 
    -0.10724445f, -0.12477236f, 0.19660628f, 0.08120632f, -0.01244853f, -0.05228592f, 0.08412094f, 0.11547452f, 
    -0.09482393f, 0.07669535f, 0.06086432f, -0.11792442f, 0.06908157f, -0.16042656f, 0.02658697f, -0.05748940f, 
    0.07436281f, 0.05978774f, -0.10114575f, -0.05328274f, -0.01735261f, 0.09225257f, 0.03695941f, 0.03949918f, 
    -0.12018710f, -0.22538939f, 0.09007867f, 0.04044188f, -0.04360305f, 0.08988865f, 0.11086940f, -0.04436903f, 
    -0.03592540f, 0.09963530f, -0.10531557f, 0.01525433f, -0.23398948f, 0.03475618f, 0.28257081f, -0.09303497f, 
    0.08759329f, 0.10754237f, 0.04888252f, -0.03291638f, 0.12582748f, 0.05981489f, 0.01641534f, 0.18234506f, 
    -0.36900964f, -0.09332356f, 0.11148537f, -0.02075429f, -0.01371201f, -0.00173783f, 0.00529164f, 0.01216240f, 
    0.01939187f, -0.00750872f, -0.04673101f, -0.05631242f, -0.04468205f, -0.30474019f, -0.12807246f, -0.11275519f, 
    0.15022071f, -0.01426010f, -0.08492669f, 0.01827004f, 0.11097969f, -0.18912812f, 0.01042977f, 0.16151315f, 
    0.00216652f, 0.04538788f, 0.03805194f, 0.00411054f, 0.00289963f, -0.02196658f, -0.07455538f, -0.00656719f, 
    0.01035038f, 0.05187551f, 0.06185788f, 0.04937303f, -0.01385306f, 0.03973228f, -0.04854980f, -0.01396269f, 
    -0.03316312f, 0.02391584f, 0.03266478f, -0.07194897f, -0.01237799f, 0.05441442f, -0.00859515f, -0.04344809f, 
    -0.02583752f, 0.00337424f, -0.05962873f, 0.01923874f, -0.05824255f, 0.02664453f, -0.02915025f, -0.07500226f, 
    -0.03952567f, -0.01703650f, 0.01475905f, -0.05781188f, -0.05818807f, 0.03256734f, -0.06596804f, -0.07511048f, 
    0.04937156f, 0.02358807f, -0.04366678f, -0.02292413f, -0.00897596f, -0.06323805f, 0.04592614f, -0.07827801f, 
    0.03708065f, -0.01082468f, -0.05269308f, -0.05438878f, -0.00331693f, -0.06536136f, -0.08217356f, -0.07059123f, 
    -0.06840225f, 0.04017612f, -0.03007045f, 0.00472775f, 0.01240240f, 0.03783577f, 0.00200113f, -0.06470243f, 
    0.01017933f, -0.04119455f, -0.08165066f, 0.04940486f, -0.07760697f, 0.01927651f, 0.05167399f, -0.01645309f, 
    -0.06843290f, 0.03853757f, -0.04287023f, -0.00043345f, -0.05387097f, 0.05696951f, -0.07108244f, -0.03512643f, 
    0.00707366f, 0.01927898f, 0.04257378f, -0.02562887f, 0.03384645f, 0.02197282f, 0.04715294f, -0.04365553f, 
    -0.02656813f, -0.07397251f, -0.03371186f, -0.06451406f, -0.01372464f, 0.05931211f, 0.00824602f, -0.01766139f, 
    -0.05428403f, -0.05291824f, 0.02019515f, -0.00369865f, 0.04294261f, 0.04074389f, -0.05369529f, 0.02479012f, 
    0.00482768f, -0.06159989f, 0.01749718f, -0.05138395f, 0.04182641f, -0.04488067f, -0.03572729f, -0.01235490f, 
    0.02062122f, -0.05085705f, 0.01922131f, 0.04681053f, 0.01627591f, -0.06085557f, 0.05869953f, 0.01546452f, 
    0.05259208f, 0.04472147f, 0.04408980f, 0.05913155f, -0.05299700f, 0.00542671f, 0.04283159f, -0.08020597f, 
    -0.00593487f, 0.05572052f, 0.06144027f, 0.02318730f, -0.01059825f, 0.00902434f, 0.00815156f, -0.04214333f, 
    0.03113470f, -0.05061273f, 0.06282277f, 0.06521009f, -0.00331746f, 0.05959265f, -0.02783054f, -0.00892445f, 
    0.02878888f, 0.02416612f, -0.07104214f, 0.01002018f, 0.05503659f, -0.03703024f, -0.06645421f, 0.01632220f, 
    0.02628811f, 0.01946629f, -0.02845342f, -0.04382789f, 0.04986634f, -0.01410565f, -0.02504402f, -0.05131580f, 
    0.06295527f, 0.01619216f, -0.02619649f, -0.01700547f, -0.01752415f, 0.00734134f, -0.07361162f, -0.04926874f, 
    -0.01613602f, -0.05789030f, 0.06010374f, 0.00813061f, -0.06279419f, 0.00098001f, -0.00484426f, -0.00740665f, 
    0.04147620f, 0.03301643f, -0.02860410f, -0.06180875f, -0.07323909f, 0.05888453f, 0.01152443f, -0.05615038f, 
    0.04223692f, -0.03090151f, -0.04488114f, -0.06694309f, -0.02919368f, -0.02301322f, -0.07031479f, 0.00123701f, 
    -0.06952536f, 0.05274002f, -0.01495593f, 0.10051821f, -0.09291076f, 0.08375550f, -0.07090102f, 0.00050953f, 
    -0.25842234f, 0.19969420f, 0.03743158f, -0.01599684f, -0.25993156f, 0.10300645f, 0.04968109f, 0.18882231f, 
    0.00888324f, 0.09112056f, -0.08978217f, 0.07126269f, -0.14239348f, -0.08784845f, 0.04292390f, 0.10760441f, 
    -0.34049079f, 0.41541451f, 0.00172241f, -0.13677046f, 0.03900141f, 0.12023556f, 0.20194322f, 0.08574196f, 
    0.09476358f, -0.17670247f, -0.06121430f, 0.11241968f, -0.26108745f, 0.12012580f, 0.28349414f, 0.03097862f, 
    -0.01728065f, 0.01761073f, 0.10538455f, -0.04698127f, 0.06970333f, 0.13290538f, -0.10495628f, 0.02855356f, 
    0.38474485f, -0.04026833f, 0.15667270f, -0.02107539f, 0.04395202f, 0.28917947f, 0.07538237f, 0.12796152f, 
    0.12198171f, 0.14944662f, -0.00609837f, 0.01119843f, 0.21489257f, -0.28022590f, 0.21151428f, 0.00173081f, 
    -0.04648175f, 0.14585544f, 0.02140573f, -0.04580333f, 0.00413559f, -0.06811412f, 0.04869654f, -0.02126866f, 
    -0.25431120f, 0.53027511f, -0.25903642f, 0.56929374f, 0.08516353f, 0.01047723f, -0.00298691f, 0.04930454f, 
    0.19559759f, 0.07556590f, 0.05480890f, 0.18328196f, 0.00268450f, 0.01683796f, -0.14453189f, -0.11974794f, 
    0.15821846f, -0.19260311f, -0.01956930f, 0.19555947f, 0.02738765f, -0.00814845f, 0.11489925f, -0.19027047f, 
    -0.31031960f, -0.09443802f, -0.17888153f, 0.11733147f, 0.06191994f, -0.03845447f, 0.19291364f, -0.04250884f, 
    -0.04714092f, -0.14035930f, 0.14731210f, -0.01743348f, -0.00633069f, 0.05430749f, -0.05146276f, -0.17547223f, 
    -0.01617330f, 0.01001821f, -0.09609284f, 0.12168987f, -0.02645792f, -0.12858950f, -0.09782129f, -0.10252246f, 
    0.01607434f, 0.05455269f, 0.21071525f, 0.30950978f, 0.13120927f, 0.15361796f, -0.16460802f, -0.01111555f, 
    0.06578357f, -0.09721908f, 0.03739552f, 0.00755444f, -0.13505535f, -0.28944856f, -0.09083416f, 0.13719340f, 
    0.08057278f, -0.06965975f, 0.10420182f, 0.13312696f, 0.13138306f, 0.08626434f, 0.13220644f, 0.08205764f, 
    0.20418489f, 0.00424732f, -0.14438601f, 0.10658738f, -0.09129000f, -0.22168185f, -0.00562725f, -0.05061821f, 
    0.00649960f, -0.01037769f, 0.23035604f, 0.06603880f, -0.39811781f, 0.01488224f, 0.20413539f, -0.24618550f, 
    0.12865122f, -0.03018897f, 0.01138991f, 0.14347073f, 0.06813364f, 0.04835122f, 0.02985108f, 0.04538551f, 
    0.08530135f, -0.18679833f, 0.08176822f, 0.18124284f, -0.21207237f, 0.16303404f, -0.02005456f, 0.08254432f, 
    0.05814626f, 0.12410235f, 0.23274809f, 0.35778233f, -0.18968524f, -0.07090305f, -0.03400696f, -0.02726401f, 
    -0.01702749f, -0.09169231f, -0.08824360f, -0.08077673f, -0.01102286f, 0.01493607f, 0.05187450f, -0.15417537f, 
    -0.06713871f, 0.01072691f, -0.08425127f, -0.04272320f, -0.02385669f, -0.02423137f, -0.03281577f, 0.01201057f, 
    -0.05884495f, 0.05450480f, 0.02489283f, -0.07290254f, -0.07983761f, 0.01828023f, -0.02597279f, -0.04730105f, 
    0.06361099f, -0.04405933f, -0.05751312f, -0.00535651f, -0.06885540f, -0.02463806f, -0.02716252f, 0.01881431f, 
    -0.01124578f, 0.03655764f, -0.04648596f, -0.01731443f, 0.04447529f, -0.07705817f, 0.02201314f, -0.05020568f, 
    0.03749767f, -0.04135624f, -0.08548530f, 0.00072387f, 0.04392961f, 0.02824734f, 0.03782482f, 0.01481940f, 
    0.04987533f, 0.04022607f, -0.01493441f, -0.03956954f, 0.04602044f, 0.04305867f, -0.01353962f, 0.05405118f, 
    -0.05806005f, 0.02233561f, -0.09829074f, -0.06488705f, -0.07470602f, 0.03675696f, -0.00241643f, -0.02932990f, 
    -0.05957469f, -0.07276072f, -0.03381056f, -0.03962595f, 0.03226493f, -0.03217138f, 0.02109760f, -0.03008047f, 
    -0.08298846f, -0.01595431f, -0.07992309f, -0.07186449f, -0.02555069f, 0.01907331f, 0.01605821f, 0.03902686f, 
    0.03995795f, -0.01217835f, 0.01459360f, 0.05589060f, 0.02247039f, -0.02971230f, -0.05253262f, -0.08109982f, 
    0.04546471f, -0.01432828f, 0.04245276f, 0.03139884f, 0.00080070f, -0.08534921f, -0.08948429f, 0.00503488f, 
    -0.02176536f, 0.01435266f, -0.02606073f, 0.01237093f, 0.03043496f, -0.00551999f, 0.04175212f, -0.04784976f, 
    0.02538485f, 0.04770426f, 0.03721115f, -0.04183815f, -0.06117275f, -0.01942306f, 0.02091215f, -0.07220397f, 
    0.01283538f, 0.01230296f, -0.06871030f, 0.04979412f, -0.02099863f, -0.08112214f, -0.07350120f, -0.06802204f, 
    0.00114879f, 0.04214019f, -0.05187115f, -0.04479397f, 0.02810062f, -0.07961521f, -0.04829840f, -0.08376601f, 
    0.02707495f, 0.03383073f, 0.00679785f, -0.07851589f, 0.02014592f, 0.01363168f, -0.08166870f, 0.01820901f, 
    0.03413154f, -0.05813934f, -0.01274332f, -0.00784145f, -0.07427286f, -0.04867047f, 0.03906728f, 0.05995655f, 
    -0.07225240f, -0.05811593f, -0.02413853f, -0.05721498f, -0.00348185f, -0.00600682f, 0.03474942f, 0.01460157f, 
    -0.04171832f, 0.03113952f, -0.02702684f, -0.02733984f, 0.04437959f, -0.06689170f, -0.02557767f, -0.06920304f, 
    -0.04757127f, 0.02621068f, 0.03880394f, -0.01278902f, 0.03801382f, -0.00154948f, -0.01429676f, -0.04510844f, 
    0.03147882f, -0.08227856f, 0.02281738f, -0.00681014f, -0.02412059f, -0.02080977f, -0.08164873f, 0.02522870f, 
    0.00224415f, -0.04311910f, -0.06782330f, 0.05734484f, -0.00169044f, 0.05166337f, -0.03265341f, 0.00175657f, 
    -0.03724578f, -0.03548509f, -0.03853629f, 0.02530284f, 0.04049444f, -0.00052759f, -0.04814284f, 0.03814549f, 
    -0.02485029f, 0.01174104f, -0.00814687f, -0.02135270f, -0.06216164f, 0.01875692f, 0.03737183f, -0.00264641f, 
    0.32102251f, 0.12701315f, 0.01162112f, -0.09527749f, 0.06969994f, 0.07714418f, 0.19779728f, 0.03181084f, 
    0.01518289f, -0.11782481f, -0.20452788f, 0.06442204f, 0.08657274f, -0.12185997f, -0.11562163f, 0.00837862f, 
    0.06212770f, -0.05177670f, -0.01430615f, 0.05679815f, 0.09036919f, 0.02361173f, -0.12009528f, 0.01395054f, 
    0.14416422f, -0.06972194f, -0.06185419f, 0.01676841f, 0.08305476f, -0.02060091f, -0.07674752f, 0.00836390f, 
    -0.11804645f, 0.04090497f, -0.06246399f, -0.06085892f, 0.04330799f, 0.08992441f, -0.29544497f, -0.01380468f, 
    -0.07101654f, 0.05942027f, -0.02900147f, 0.10379180f, -0.04849257f, 0.01389426f, 0.14989819f, 0.00495642f, 
    0.13252856f, 0.23759590f, 0.02834213f, -0.07632549f, 0.01727605f, 0.07184497f, -0.01396181f, -0.04155989f, 
    0.01055598f, -0.02420436f, 0.29603460f, 0.00145710f, -0.05909587f, 0.23157510f, -0.07036611f, -0.09117936f, 
    0.01770194f, 0.16820280f, 0.01489012f, 0.02086448f, 0.07015714f, 0.23587511f, 0.08792229f, 0.09167162f, 
    -0.01492040f, -0.09001978f, 0.09555789f, 0.07696332f, 0.00683077f, 0.04191415f, -0.09429917f, 0.05966063f, 
    -0.03389536f, -0.02639444f, 0.09752449f, 0.02060098f, -0.08353177f, -0.08094759f, 0.01407672f, 0.03116851f, 
    -0.03707287f, 0.05838902f, -0.00676457f, 0.09007826f, 0.05509498f, -0.03307510f, -0.08035266f, 0.08579962f, 
    0.47719207f, -0.32995209f, -0.26269662f, 0.00018185f, 0.11144105f, -0.00133749f, -0.01259814f, 0.04993981f, 
    -0.02394539f, 0.05995136f, -0.09816333f, -0.07851285f, 0.11978098f, 0.01362418f, 0.01181499f, 0.07790675f, 
    0.16682853f, 0.11676565f, 0.11101981f, -0.07330789f, -0.12535004f, -0.02580300f, 0.09963591f, 0.07103820f, 
    0.11353612f, -0.16874056f, 0.30811986f, -0.19087663f, 0.10887583f, -0.07800201f, 0.01862411f, 0.00597669f, 
    -0.17737706f, 0.19892722f, -0.01985238f, 0.00137688f, 0.13130815f, 0.12871903f, -0.05748271f, -0.07113934f, 
    0.10241982f, -0.03030509f, -0.08553897f, -0.16710998f, 0.02467760f, -0.06901641f, 0.05847883f, -0.01401703f, 
    -0.05176529f, -0.19937031f, 0.00801247f, 0.23525156f, 0.02233224f, 0.10288931f, 0.00568299f, 0.29067126f, 
    -0.08284625f, 0.14322649f, -0.13073291f, 0.14263028f, 0.13215028f, -0.14214574f, -0.03001130f, -0.14249724f, 
    0.06832030f, 0.04233190f, 0.00264061f, -0.04910000f, 0.11042468f, -0.02820949f, -0.06278973f, 0.21546514f, 
    -0.75168848f, -0.23444378f, 0.06155242f, -0.05403783f, 0.03737034f, -0.09086891f, -0.05898961f, -0.04564198f, 
    0.10529532f, -0.00283368f, 0.04757896f, -0.20641415f, 0.08249581f, -0.13658668f, -0.06773553f, 0.14725076f, 
    -0.13347918f, -0.04767519f, -0.06613492f, 0.14391793f, 0.02743171f, -0.13134515f, -0.01005358f, 0.02109883f, 
    0.18617721f, 0.18773487f, 0.07129328f, 0.11857700f, 0.14149244f, 0.03275528f, 0.04005809f, 0.15927775f, 
    0.19374345f, -0.13399273f, 0.04715979f, 0.02812461f, 0.18306282f, -0.24216726f, -0.12929130f, -0.17065442f, 
    0.07534724f, 0.00149697f, 0.03555869f, -0.04419847f, 0.15730824f, 0.10129146f, -0.11560024f, 0.01047381f, 
    0.19649106f, -0.17876734f, 0.09094748f, 0.11066545f, 0.04443583f, 0.01649075f, -0.04683330f, -0.02744553f, 
    0.06710730f, 0.18945006f, 0.05191753f, 0.01228304f, 0.11495598f, -0.06516853f, -0.16061698f, -0.04447453f, 
    0.05607562f, 0.13380671f, -0.03607776f, 0.02942599f, -0.01775832f, -0.08634453f, 0.20487937f, 0.11570524f, 
    -0.23435636f, 0.10862659f, -0.01691025f, 0.22107348f, -0.02189840f, -0.15448572f, -0.00144608f, -0.08762453f, 
    -0.11091836f, -0.13470495f, 0.06151200f, 0.04372472f, -0.23378572f, 0.36193600f, -0.11226793f, -0.07108401f, 
    0.08615753f, -0.03459796f, 0.10398874f, 0.10707626f, 0.09037554f, 0.08270957f, -0.01471279f, 0.12758334f, 
    0.22970180f, -0.20181237f, 0.33485287f, -0.42003277f, 0.02014959f, 0.02292331f, 0.02111531f, 0.05850239f, 
    -0.00795264f, -0.13763058f, 0.02450606f, 0.01644948f, 0.00440894f, -0.06842857f, 0.11178330f, 0.22325657f, 
    -0.00329670f, 0.14534733f, 0.04994090f, -0.06823320f, 0.06171335f, -0.03400677f, -0.08757656f, 0.24369270f, 
    0.27479538f, 0.04530579f, -0.12651651f, -0.19244085f, 0.05704322f, 0.07296338f, -0.10175098f, 0.06492541f, 
    0.10374390f, 0.16435914f, -0.17634895f, 0.00238434f, 0.09424605f, -0.04220253f, 0.14806248f, 0.28540063f, 
    0.03165832f, 0.02347465f, 0.11158369f, 0.03521129f, -0.00536537f, 0.12052488f, 0.10005651f, 0.19951053f, 
    0.16091774f, -0.05061307f, -0.06898443f, -0.06006949f, 0.04806766f, -0.12635417f, 0.22321735f, 0.02007086f, 
    -0.08342516f, 0.11060103f, 0.12000891f, 0.00243524f, 0.28512362f, 0.20604101f, 0.10431175f, 0.03194647f, 
    -0.00813732f, 0.02419303f, -0.07640963f, -0.12284840f, -0.01821631f, -0.01689313f, 0.00902166f, -0.15763189f, 
    -0.10137891f, -0.17479818f, 0.21660216f, -0.11892787f, 0.07435281f, 0.10917776f, 0.12564179f, 0.04892767f, 
    -0.02084997f, 0.15006155f, -0.14689291f, 0.11174677f, 0.40069222f, -0.03537498f, -0.07584260f, 0.29955620f, 
    0.07309182f, 0.07482779f, 0.08645993f, -0.08330206f, 0.10124246f, 0.02379007f, 0.05720406f, 0.01768052f, 
    -0.24863082f, 0.01538713f, 0.03182156f, -0.05656299f, 0.08586971f, -0.14038806f, -0.04353126f, -0.07739910f, 
    0.02614243f, -0.02505975f, -0.16312741f, -0.22757868f, 0.15566164f, -0.14181742f, -0.07908358f, -0.02030894f, 
    0.11165912f, 0.12775452f, 0.05272810f, 0.21896526f, 0.07842120f, -0.09643319f, 0.03278962f, 0.21752983f, 
    -0.03222485f, 0.02786496f, -0.00895870f, 0.04317843f, 0.04674344f, -0.07999630f, -0.04505603f, 0.03034398f, 
    -0.00523096f, -0.02783523f, -0.03605878f, 0.05491672f, 0.06565779f, 0.05899777f, 0.02380175f, -0.03142595f, 
    0.04591818f, -0.06474096f, -0.05169623f, 0.04575199f, 0.02968904f, -0.06073347f, -0.07021935f, -0.02146295f, 
    -0.02567684f, -0.03449642f, 0.04566512f, 0.04713304f, -0.00006927f, 0.02448154f, -0.06983133f, -0.03895364f, 
    -0.07409416f, 0.04397723f, 0.01563207f, -0.02299565f, 0.01825725f, -0.03965610f, -0.04703740f, 0.00842862f, 
    -0.00781475f, 0.00881136f, 0.05849671f, -0.01835405f, -0.03745189f, -0.00741047f, -0.07777980f, -0.06448464f, 
    0.02050556f, -0.03321935f, -0.07493654f, 0.01005179f, 0.03021042f, -0.07897303f, -0.05894828f, 0.05325894f, 
    -0.02272549f, -0.07268651f, 0.06219131f, -0.02891378f, 0.00601393f, -0.03701745f, -0.05531017f, -0.06970675f, 
    -0.03152675f, -0.06255597f, -0.06229895f, -0.00517615f, 0.03279063f, -0.03528553f, 0.02844694f, -0.03722571f, 
    -0.06164657f, -0.06819350f, -0.06088776f, 0.06304523f, 0.05930923f, 0.04274753f, 0.03793237f, 0.03650073f, 
    -0.04867483f, -0.05775760f, -0.03425710f, 0.06500424f, 0.02276306f, -0.01518614f, -0.01607955f, -0.04844223f, 
    -0.06056335f, 0.01757194f, -0.04244381f, 0.06377301f, -0.07774874f, -0.05678775f, -0.02677452f, -0.01148379f, 
    0.02654155f, 0.02627028f, -0.00160861f, -0.05203115f, -0.02113495f, -0.06571717f, 0.01554201f, -0.00010619f, 
    0.06023443f, 0.03434835f, 0.01695579f, 0.02222856f, 0.02387947f, 0.01117706f, -0.01597328f, -0.05331983f, 
    0.00119129f, -0.06667054f, 0.03378382f, 0.04025268f, -0.01577683f, 0.01035097f, 0.06016172f, -0.06363624f, 
    -0.01395871f, -0.04569012f, -0.07776137f, -0.02350937f, -0.02442731f, 0.01980290f, 0.03964292f, -0.04640145f, 
    0.00847999f, -0.04590128f, 0.01343775f, -0.05169936f, 0.01519363f, -0.02827008f, -0.01932977f, -0.04102327f, 
    0.04160788f, -0.00353090f, 0.03467972f, -0.06512155f, 0.04471286f, -0.01129326f, 0.06159837f, 0.05950585f, 
    -0.03686649f, 0.03888131f, 0.04513158f, -0.05673590f, -0.06675798f, -0.01428380f, 0.00427933f, 0.03157058f, 
    -0.05576957f, -0.04652645f, -0.06114084f, -0.00640425f, 0.02035158f, -0.06982380f, -0.03527923f, -0.02683400f, 
    0.06077245f, -0.01217835f, -0.04623562f, -0.01273312f, -0.07758453f, 0.03867916f, 0.05149397f, -0.02597888f, 
    0.04182535f, -0.00822754f, 0.05733160f, -0.04681401f, -0.01313912f, -0.05045516f, 0.05209412f, -0.03034093f, 
    -0.04552953f, -0.05403202f, -0.01069447f, 0.06154024f, -0.00623080f, -0.02456793f, 0.02040243f, -0.02306862f, 
    0.06257737f, 0.04770915f, -0.05588990f, 0.00658606f, -0.05961620f, 0.05522254f, -0.04671601f, -0.02543189f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08982319f, 0.09009935f, -0.08987191f, -0.04710326f, 0.13131268f, -0.05102857f, 0.03817143f, 0.13711299f, 
    0.05343914f, -0.03587454f, -0.00448883f, -0.01936432f, 0.04708597f, -0.07041457f, -0.02642320f, 0.03606819f, 
    -0.08136638f, -0.00081068f, 0.05966897f, 0.12801735f, 0.05305437f, 0.13283150f, -0.04569183f, 0.01502605f, 
    0.13646498f, -0.05705388f, -0.06748061f, 0.02766741f, -0.03689929f, 0.01453683f, 0.18030323f, -0.06872658f, 
    0.04501488f, -0.07452215f, -0.08930848f, -0.03432963f, -0.09182291f, 0.01115716f, -0.03635246f, -0.10476504f, 
    0.03347687f, -0.03647333f, 0.06873974f, 0.05265121f, 0.02904372f, -0.06997510f, -0.06617948f, 0.02597259f, 
    0.03204262f, 0.06437042f, -0.08549601f, 0.17977890f, 0.03181339f, 0.03472209f, 0.08893140f, 0.22537681f, 
    0.05968580f, 0.06454280f, -0.01078283f, -0.02216306f, 0.02113550f, 0.04674034f, 0.06080002f, -0.00799691f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.25479111f, -0.51242906f, -0.09007964f, 0.10387222f, -0.36931658f, 0.17427348f, -0.05691288f, 0.02880066f, 
    0.02911034f, -0.06641197f, -0.28399754f, -0.23202021f, -0.37601256f, 0.11610134f, 0.22590062f, -0.50882566f, 
    -0.07377580f, 0.08159371f, 0.13468701f, -0.57351011f, 0.20744643f, -0.27270874f, -0.07406212f, -0.44774991f, 
    0.16198698f, -0.07164589f, 0.10077327f, 0.13395065f, 0.06006256f, 0.05072507f, -0.33960915f, -0.01847706f, 
    0.11336154f, 0.10253412f, -0.09905560f, 0.23419458f, 0.30389747f, 0.06796747f, 0.05078327f, 0.30450010f, 
    0.03161885f, 0.24692619f, 0.00205782f, 0.18641807f, 0.03976937f, 0.53518319f, -0.16397317f, 0.28430879f, 
    -0.07333744f, -0.42183805f, -0.37478772f, -0.22589205f, 0.04153657f, -0.25816751f, 0.18406190f, -0.04587090f, 
    -0.22935131f, -0.17787918f, -0.11629684f, -0.36737472f, -0.04856104f, -0.16646485f, 0.04599105f, -0.11920333f, 
    -0.22016540f, -0.24535890f, 0.23339726f, 0.08834457f, 0.17328347f, -0.28712660f, 0.10302953f, -0.18928419f, 
    -0.09508760f, -0.03972273f, -0.08984329f, -0.38402224f, -0.08116257f, -0.05003406f, -0.14206342f, -0.04044325f, 
    -0.40258443f, -0.00653622f, -0.92873186f, 0.36010829f, 0.31667414f, -0.09124067f, -0.11891001f, -0.11180257f, 
    -0.00269059f, -0.11053974f, 0.06503134f, 0.25767118f, 0.12587778f, 0.14797588f, -0.01510717f, -0.10713844f, 
    -0.43630120f, 0.08629492f, -0.02621186f, 0.07733025f, -0.20639698f, 0.08533964f, 0.00011298f, -0.09037628f, 
    0.07041139f, -0.11733617f, 0.00575273f, 0.34589240f, 0.10258920f, 0.06065969f, 0.02050301f, -0.13861148f, 
    -0.09414573f, 0.17803140f, -0.72130656f, 0.25124651f, 0.08094439f, -0.11128976f, -0.10790130f, -0.14203869f, 
    0.28393438f, 0.22180179f, -0.02991227f, -0.50016981f, -0.01666908f, 0.36652848f, 0.33899736f, -0.05571977f, 
    0.11654112f, -0.02802593f, -0.03368649f, -0.09261606f, 0.31918335f, 0.24450934f, 0.08482298f, 0.22580829f, 
    -0.11106154f, 0.02908441f, 0.45579696f, 0.02089599f, -0.54510188f, 0.01156348f, -0.17184958f, 0.29163525f, 
    0.23815599f, -0.08260331f, -0.15115219f, -0.15807003f, 0.11214126f, -0.18437122f, 0.02555241f, 0.34627071f, 
    0.09415892f, 0.06003615f, -0.08484525f, -0.20558092f, -0.10444504f, -0.10423344f, -0.29198569f, -0.03569973f, 
    -0.38862774f, 0.03825836f, 0.07802276f, -0.63737673f, -0.15945563f, -0.03511605f, 0.03124256f, 0.35733289f, 
    0.16496512f, -0.01176248f, -0.43238503f, -0.30626369f, -0.04013030f, -0.04858894f, 0.42754325f, 0.08562403f, 
    -0.02983666f, -0.62126756f, -0.11157194f, -0.60536999f, 0.08770113f, 0.37916663f, -0.14334001f, -0.28282809f, 
    0.13361835f, -0.24049090f, -0.11862829f, -0.30550328f, -0.04272247f, 0.12649091f, 0.02836758f, 0.04495418f, 
    -0.02456655f, -0.31914464f, -0.23891468f, 0.07133245f, 0.20720270f, 0.24240132f, 0.06862274f, 0.25180572f, 
    -0.06505150f, -0.04423814f, 0.10445789f, -0.31891617f, 0.27834949f, 0.08227555f, 0.15702362f, -0.62167978f, 
    0.19994147f, -0.03390076f, 0.29518375f, 0.12236893f, -0.66732091f, 0.09183362f, 0.00231005f, -0.47916037f, 
    -0.15166327f, -0.00809545f, 0.10936672f, -0.49150518f, -0.00415812f, 0.01364842f, 0.16478212f, 0.00256475f, 
    -0.12227594f, 0.00103636f, 0.00881041f, 0.03886176f, -0.48478392f, 0.06486624f, 0.10562991f, -0.06265504f, 
    -0.10007837f, 0.16330762f, 0.36177292f, -0.14576776f, 0.11872233f, 0.14043848f, -0.28102836f, -0.06076571f, 
    -0.07140635f, 0.23363313f, 0.27058342f, -0.50347358f, -0.02584177f, 0.35186860f, 0.10681995f, 0.04588281f, 
    0.20204997f, 0.16186593f, 0.06638086f, 0.07293879f, -0.04567407f, -0.08992341f, -0.10981344f, 0.01484799f, 
    0.12821761f, 0.15155102f, -0.67499816f, 0.01973279f, -0.55226505f, 0.15380420f, 0.10572109f, 0.41929582f, 
    0.10712431f, 0.09261663f, -0.49288431f, 0.01323082f, -0.09950241f, -0.12790956f, 0.23762250f, 0.19469313f, 
    0.16551232f, 0.03241288f, -0.04404645f, 0.25875768f, 0.02252047f, -0.06378833f, -0.13758092f, -0.01355153f, 
    -0.09425487f, -0.02783166f, -0.00790538f, -0.15991449f, -0.06204715f, -0.00835714f, -0.56608886f, -0.11214036f, 
    0.20943913f, 0.01915685f, 0.02427602f, 0.18831086f, -0.38029277f, 0.06434292f, -0.11442962f, -0.37025517f, 
    0.21748024f, 0.09219055f, 0.21147886f, -0.08617933f, 0.00719910f, -0.18094470f, 0.27880269f, 0.11864378f, 
    0.05570694f, -0.14144406f, -0.06743547f, 0.17572685f, -0.01508932f, 0.10299764f, 0.28915367f, -0.09608622f, 
    0.06617722f, -0.28796649f, -0.00040256f, 0.19686037f, 0.07956276f, -0.34083152f, -0.25279734f, 0.09510054f, 
    -0.06115440f, 0.40030763f, -0.14039412f, 0.06192579f, -0.06032564f, 0.33045751f, -0.05163908f, -0.22490372f, 
    0.02922639f, -0.00621699f, -0.02661958f, -0.21191823f, -0.07976826f, -0.00668384f, -0.61697966f, 0.08251737f, 
    -0.36277992f, 0.00706121f, 0.17265086f, -0.80760521f, -0.40708345f, 0.27672046f, 0.04222796f, -0.24483152f, 
    0.13059649f, -0.03006593f, -0.06824008f, 0.11760973f, 0.00071567f, -0.01198092f, 0.09776513f, 0.04623774f, 
    0.17516553f, 0.05451125f, -0.06888319f, -0.26630482f, 0.15150672f, -0.09778861f, 0.06674856f, -0.34585816f, 
    0.23341274f, -0.16615371f, 0.19603303f, 0.20057827f, 0.09548724f, -0.13574682f, -0.15794617f, 0.17355691f, 
    0.02141581f, 0.25654444f, 0.45783499f, 0.21390621f, 0.07140892f, -0.43929380f, -0.15465158f, 0.14478068f, 
    -0.35811368f, 0.17196107f, 0.10250188f, -0.11167033f, 0.04031898f, 0.18075505f, 0.10027707f, -0.12362162f, 
    0.03062534f, 0.03379343f, -0.36659804f, 0.02420357f, 0.22316547f, -0.41640803f, -0.11686901f, -0.84628099f, 
    -0.04100607f, -0.03323562f, -0.13480349f, -0.01662453f, 0.27616209f, 0.06324414f, -0.02632419f, 0.31510815f, 
    0.09149090f, -0.03515119f, 0.19499384f, -0.30973554f, 0.04837734f, -0.01364969f, 0.03950625f, 0.26714155f, 
    0.16737443f, -0.03524576f, 0.02425938f, -0.26502135f, 0.07984652f, 0.29073265f, -0.08372128f, 0.07332886f, 
    -0.42636478f, 0.07184552f, -0.03345524f, -0.21220778f, 0.26222250f, 0.08426193f, -0.10870957f, -0.33717075f, 
    -0.15060411f, 0.23912254f, -0.18295410f, -0.08945698f, -0.04377664f, -0.37675858f, 0.32540345f, -0.69046271f, 
    0.02588414f, -0.32512754f, -0.79909950f, 0.21867944f, -0.11978734f, 0.16476254f, -0.24641649f, 0.27931046f, 
    -0.65867978f, 0.34227619f, 0.09969271f, 0.19880410f, -0.08360192f, -0.32221451f, -0.09520060f, -0.07013788f, 
    0.00218270f, 0.21818244f, 0.40159735f, 0.01301448f, -0.36702904f, 0.04832679f, -0.00192628f, 0.12341206f, 
    0.11245925f, 0.01096562f, 0.23662345f, 0.29379699f, 0.12170389f, -0.09204818f, -0.08187842f, 0.13368300f, 
    0.19641595f, -0.07412317f, 0.09217818f, 0.24432679f, -0.02492994f, -0.53376067f, -0.00219458f, 0.14807473f, 
    -0.33283007f, -0.08841440f, 0.08539634f, 0.03848362f, 0.11719828f, -0.06148873f, -0.00110266f, 0.04483324f, 
    0.32857120f, -0.00738176f, 0.09266088f, 0.22870390f, 0.22211663f, -0.05096803f, 0.03631305f, 0.08990512f, 
    -0.32783678f, 0.02398533f, -0.00416580f, -0.13831344f, -0.10854752f, 0.07450482f, 0.17014691f, 0.14379644f, 
    -0.07748114f, 0.22423270f, 0.11848029f, -0.17499354f, -0.03565332f, -0.18383671f, -0.62443298f, -0.54662144f, 
    -0.09216200f, -0.05651340f, -0.10839626f, -0.07514639f, 0.08841743f, -0.35175687f, -0.28684083f, -0.00686306f, 
    -0.84928554f, 0.19863421f, 0.21204823f, -0.10929646f, 0.04333517f, -0.03319255f, 0.00821965f, -0.25927550f, 
    0.02096130f, 0.08081019f, 0.12497102f, 0.41101724f, 0.25017259f, -0.09489599f, 0.17870769f, 0.16729197f, 
    0.08558217f, -0.13169676f, -0.22126050f, -0.56372362f, -0.11983074f, 0.45317745f, 0.07677303f, -0.32249272f, 
    0.09800070f, -0.10237917f, 0.07933294f, -0.04055147f, 0.06501443f, 0.07573687f, 0.32750791f, -0.02512156f, 
    -0.28461838f, -0.04420486f, -0.03648860f, 0.10546308f, 0.10791871f, 0.07114433f, -0.01281372f, -0.20810422f, 
    -0.01430091f, -0.61574376f, -0.52990407f, 0.14180392f, -0.06588354f, -0.39864504f, -0.00178324f, 0.07646910f, 
    -0.11133119f, -0.28172109f, -0.13605917f, 0.06553982f, -0.03742239f, -0.07970571f, -0.01415767f, -0.45616001f, 
    0.25928798f, -0.21555617f, -0.10094825f, -0.18819788f, -0.07752056f, -0.11202157f, 0.17239299f, -0.01283336f, 
    0.11118066f, -0.07490763f, 0.54425150f, -0.02126215f, 0.01814096f, -0.44815350f, 0.11214943f, -0.46754658f, 
    0.10844836f, 0.09325737f, -0.27107155f, 0.18326619f, -0.45626247f, 0.09980975f, 0.04317324f, 0.01735060f, 
    0.26369068f, -0.03128833f, 0.02214385f, 0.16174330f, -0.00942173f, 0.34035772f, 0.02431340f, 0.47607857f, 
    -0.04566478f, 0.01024226f, 0.02325806f, -0.39344722f, 0.02320431f, -0.15710707f, -0.28230831f, -0.00028863f, 
    0.06526022f, -0.00743586f, -0.02853373f, -0.63710791f, -0.31753349f, 0.05424654f, 0.09637425f, 0.24159037f, 
    -0.01240770f, -0.08115847f, -0.33230177f, -0.05351393f, -0.13273977f, 0.51300526f, -0.30627489f, 0.37320334f, 
    -0.04338809f, -0.39747551f, 0.27056289f, 0.17068915f, 0.07527949f, -0.75262338f, -0.23397078f, 0.23020683f, 
    0.11526047f, 0.25906393f, -0.01555619f, 0.44282490f, -0.11929857f, 0.24546687f, -0.35088432f, -0.10738615f, 
    -0.65920228f, -0.05117119f, 0.13127533f, -0.09588230f, 0.21382859f, -0.44109806f, 0.06151655f, 0.35460180f, 
    0.00667639f, -0.02542375f, -0.02599478f, -0.08792510f, 0.31553650f, 0.04038573f, -0.18212707f, 0.30102643f, 
    -0.32744491f, 0.07765769f, -0.03340865f, 0.06891322f, 0.04979314f, 0.25191495f, 0.09285717f, -0.10765479f, 
    -0.00738715f, 0.10307399f, -0.02759890f, 0.24013576f, 0.08989441f, -0.47785193f, 0.07463156f, -0.07762294f, 
    0.33611900f, -0.05907117f, -0.14248414f, -0.28526139f, 0.14793740f, -0.11907642f, 0.00887081f, 0.20881012f, 
    -0.59374648f, 0.18722528f, -0.19835331f, -0.49253783f, -0.03570103f, -0.43792540f, -0.19937192f, 0.15049361f, 
    0.06885745f, 0.10601007f, 0.07125882f, 0.31856963f, -0.12020908f, 0.20219459f, 0.12546650f, 0.29016805f, 
    0.12506975f, 0.16434318f, 0.09616493f, -0.23913755f, -0.09057351f, 0.06323048f, 0.08780563f, 0.03354400f, 
    0.29512766f, 0.11058604f, 0.27971160f, 0.10621717f, -0.09135640f, -0.01008660f, -0.06579863f, -0.50427306f, 
    0.09784006f, -0.07690465f, 0.16905424f, 0.31133795f, -0.32339308f, -0.01327479f, 0.21204387f, -0.17123851f, 
    0.19806053f, 0.04078753f, -0.05047864f, -0.04052995f, -0.14899385f, -0.42353666f, -0.09449479f, 0.09425513f, 
    0.28411117f, -0.01853885f, -0.02350111f, 0.28329098f, -0.06745483f, -0.26709449f, 0.18451247f, -0.03325453f, 
    0.17539239f, 0.09585320f, 0.03752580f, -0.03458141f, -0.32712677f, 0.09309533f, -0.08665013f, -0.15289105f, 
    -0.03007510f, -0.39408985f, 0.23699555f, 0.11044402f, -0.06991136f, -0.63237780f, -0.48232034f, -0.51462895f, 
    -0.10811232f, 0.40359068f, -0.62317580f, -0.23153560f, -0.10087017f, 0.07508353f, 0.20386082f, 0.24392709f, 
    -0.45673722f, -0.60175979f, 0.11945979f, 0.11710858f, -0.07388145f, 0.19443281f, -0.18704587f, -0.09668037f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05963451f, 0.15271488f, -0.13752362f, -0.11812536f, 0.08366888f, -0.07544822f, 0.07729261f, -0.06434761f, 
    0.04631089f, -0.04204221f, 0.00330989f, 0.16493757f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
