#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.20660868f, 0.13590340f, -0.61564201f, -0.56389391f, -0.24584587f, 0.70645142f, 1.00275314f, -0.28501239f, 
    -0.62350792f, -0.43924609f, 0.81706142f, 0.21883109f, -0.02353477f, -0.13125031f, -0.30268332f, -0.37672633f, 
    -0.14567220f, -0.48006645f, -0.30267543f, -0.05491468f, 0.54182124f, -0.39250320f, 0.03950037f, 0.42051911f, 
    0.53559512f, -0.87673455f, -0.91082412f, 0.12324020f, 1.66254997f, -0.24517767f, 1.33380628f, -0.71038961f, 
    -1.02119577f, -0.32820326f, -0.32020333f, 0.15010755f, 0.03711632f, -0.02574811f, 0.38082671f, -0.21499136f, 
    -0.25849956f, -0.21350071f, 0.14676017f, -0.12020207f, -0.25006792f, -0.31672686f, -0.09789982f, -0.18479857f, 
    -0.02928502f, -0.63209432f, -0.67796862f, -0.25726983f, 0.14824820f, 0.27062622f, 0.59866214f, 0.70603514f, 
    -0.15410806f, -0.12767211f, 0.70537323f, 0.80249405f, -0.21628265f, -0.26941615f, -0.03343578f, -0.37749803f, 
    -0.25476941f, 0.13431303f, -0.29298824f, -0.05207101f, -0.28347611f, 0.01363505f, -0.69676590f, -0.37202877f, 
    -0.00365121f, -0.33627838f, -0.52410638f, -1.68758500f, 0.54847914f, 0.91493148f, -0.00108224f, 0.28763372f, 
    -0.11855023f, -0.29399174f, 0.56481099f, 0.43218523f, -0.09135146f, -0.64577234f, -0.36808535f, 0.08120993f, 
    -0.06011434f, -0.15339625f, 0.42603642f, -0.14954472f, -0.15113246f, -0.14557117f, 0.11032001f, 0.11009101f, 
    -0.26663795f, 0.21231115f, 0.26566762f, -0.23951146f, 0.70366156f, -0.36957961f, 0.01720486f, 0.05309515f, 
    -0.03389681f, 0.36469024f, 0.12351172f, -0.20547031f, 0.31026837f, -0.18013838f, -0.27567691f, 0.05871575f, 
    -0.03711577f, -0.39553630f, 0.09698832f, -0.30599490f, -0.13177507f, 0.04749811f, -0.04650731f, -0.29746333f, 
    0.13202487f, 0.09353701f, 0.36129993f, 0.41649562f, 0.18543224f, -1.04924130f, 0.07374487f, -0.69362479f, 
    -0.80223233f, -0.14877389f, -0.47507876f, -0.47348526f, -0.49060762f, 0.00667051f, -0.10564480f, -0.55598170f, 
    -0.32560521f, 0.08438782f, -1.00886381f, 0.25888300f, 0.50357038f, 0.54948705f, 0.13910654f, 0.16564502f, 
    0.21181746f, 0.09335520f, 0.22453871f, -0.16989030f, -0.29684478f, -0.53575897f, -1.26362276f, -0.87744093f, 
    -0.53026247f, -0.87998605f, -1.43655932f, 1.03954434f, -0.04778211f, -0.35609990f, 0.08183903f, 0.62265235f, 
    0.08734918f, 0.04728656f, 0.08242763f, -0.20198894f, 0.14223972f, -0.17890806f, 0.31964087f, -0.09722633f, 
    -0.01741830f, 0.25116709f, 0.13035443f, 0.14813398f, 0.42690328f, 0.10040030f, 0.16014417f, 0.54061902f, 
    0.39823228f, 0.78226197f, 0.57275158f, -0.21750742f, 0.02326968f, -0.32296076f, -0.50099164f, -0.25686949f, 
    0.49499473f, 0.62977207f, -0.41161391f, -0.52227074f, 0.34956095f, -0.43125120f, -0.16235250f, -0.23110379f, 
    0.06200898f, 0.15078944f, 0.15130405f, 0.18478571f, -0.14132987f, -0.38247737f, 0.12804031f, 0.40602419f, 
    -0.55092132f, 0.80903637f, 0.31956509f, -0.47054935f, -0.10631109f, -0.46258891f, 0.12409651f, -0.40961915f, 
    0.42289659f, 1.03677750f, 0.27946460f, 0.09302341f, -0.09717001f, -0.76386189f, 0.18917227f, 0.03762493f, 
    0.00203143f, -0.24898195f, 0.19125499f, -0.22253370f, 0.02588322f, 0.03264846f, 0.33007675f, -0.10228874f, 
    0.06474296f, -1.53082883f, -1.01148796f, -0.61377901f, -0.06640846f, -0.18736459f, -0.56336159f, -0.44086400f, 
    -1.11690354f, -1.50606287f, -0.77732629f, -0.49443555f, -0.27772510f, -0.28063083f, -0.21319073f, -0.63325870f, 
    -0.12917525f, -0.39768872f, -0.24748449f, -0.05873415f, -0.16471873f, 0.10273716f, -0.01721213f, -0.04637304f, 
    0.04420400f, -0.06668580f, 0.81689346f, 0.35561159f, 0.66128802f, 0.10951958f, -0.31994477f, 0.14811984f, 
    -0.01649054f, 0.08992351f, 0.18952322f, -0.25386143f, 0.24522007f, -0.22571409f, -0.15154800f, 0.24480867f, 
    -0.27550188f, 0.34366530f, 0.44002122f, 0.06836137f, -0.32750848f, -0.34672606f, -0.36889544f, -0.14692700f, 
    -0.39985201f, -0.37282294f, -0.48115557f, 0.79262090f, -1.43226194f, 0.20879149f, 1.07988000f, 0.50757182f, 
    -1.31678867f, -1.18692303f, -1.32256675f, -0.67778724f, -0.17154312f, 0.41152838f, 0.20081855f, 0.16988955f, 
    0.20003213f, -0.10734099f, 0.14658965f, 0.64138383f, -0.11103593f, -0.21129282f, -0.43909270f, -0.04599142f, 
    0.02197297f, -0.10491648f, 0.12781845f, 0.06945066f, 0.32570511f, -0.27566046f, 0.33175245f, 0.94306451f, 
    1.05728221f, 0.17999573f, 0.21972185f, -0.13176082f, -0.02487413f, 0.14826016f, -0.04768663f, 0.20054352f, 
    0.33456534f, 0.25697869f, 0.53133637f, -0.32760698f, -0.30394718f, -0.06558974f, 0.24732524f, -0.51868993f, 
    0.13867825f, -0.06992397f, 0.12861590f, 0.33949175f, 0.00549408f, 0.16403112f, 0.19525169f, 0.79458278f, 
    -0.02533041f, -0.63274962f, -1.04516983f, -0.79756814f, -0.14873475f, 0.52717680f, 0.56392169f, -0.32160175f, 
    -0.45048168f, -0.32553610f, 1.10327673f, 0.00236944f, -0.29552525f, 0.03483763f, 0.07645575f, -0.17101860f, 
    0.00880097f, -0.02561442f, 0.23113813f, -0.27983788f, -0.51470029f, -0.09450562f, -1.20721662f, -0.63017017f, 
    -0.48243767f, -1.17207575f, -1.03138328f, 0.02371554f, 0.29481772f, 0.48024654f, 0.26839000f, 0.15625328f, 
    -0.41513568f, -0.48416680f, -0.35541213f, 0.44370168f, 0.27067587f, 0.06273299f, -0.17373209f, -0.13889840f, 
    -0.23835851f, -0.39070597f, -0.29961616f, -0.23504499f, 0.01736191f, -0.21806435f, -0.56653678f, -1.13094282f, 
    -1.98495638f, 0.18955597f, 0.33899477f, 1.27196622f, -0.41067556f, -0.06824252f, 0.22995707f, 0.20065400f, 
    0.12292973f, 0.12735845f, -0.51417750f, 0.00537933f, -0.15537564f, 0.67306775f, 0.00936768f, -0.13231808f, 
    0.24588330f, 0.09515389f, 0.12022856f, -0.10874863f, -0.28222373f, -0.04983179f, 0.36901799f, 0.21469788f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.71911871f, 0.41268179f, 0.90422344f, 0.57728630f, 0.55844527f, -0.26946256f, 0.00318231f, 0.34183973f, 
    0.67508662f, -0.53965598f, 0.36257681f, 0.64307630f, 0.31715909f, 0.52950382f, -0.11626277f, 0.44658113f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01099749f, -0.03571030f, -0.47758633f, -0.15100819f, -0.12279023f, -0.06585030f, -0.30171388f, -0.29730374f, 
    -0.29691336f, -0.40512863f, -0.37100202f, -0.28565416f, 0.68565178f, -0.14412370f, -0.21261039f, -0.41270438f, 
    -0.27696809f, -0.06083867f, -0.08760916f, -0.22782362f, -0.07991460f, -0.16514699f, -0.00345680f, 0.04187573f, 
    -0.49062002f, -0.02417450f, -0.29218033f, -0.04743481f, -0.01855674f, 0.04749218f, 0.19857448f, 0.10710206f, 
    -0.06839631f, 0.19308314f, 0.08888987f, -0.00571360f, -0.82207400f, 0.00279729f, 0.41582954f, -0.22916989f, 
    -0.10309042f, -0.03341058f, 0.06799403f, 0.20970954f, 0.11507688f, -0.01585032f, 0.03893970f, -0.04944520f, 
    -0.15474892f, -0.20814560f, -0.13457458f, -0.02521019f, 0.00352536f, 0.02286575f, -0.07366325f, 0.04100104f, 
    -0.10369670f, -0.07085454f, -0.01825899f, 0.00242119f, 0.20254505f, 0.45533711f, 0.02533596f, 0.04897257f, 
    0.00492087f, 0.45731622f, 0.11873656f, 0.07056788f, 0.06122463f, 0.13932836f, 0.07034337f, 0.05212494f, 
    0.48047951f, 0.14780867f, -0.17714986f, -0.27986607f, 0.07960240f, 0.29909989f, -0.01651749f, -0.09905423f, 
    0.06691499f, -0.02959933f, 0.02431461f, 0.09587187f, -0.44431755f, -0.39449638f, 0.07294567f, 0.34141210f, 
    0.09534430f, 0.05446704f, -0.00861996f, 0.07192003f, 0.07779147f, -0.01469289f, -0.00215536f, 0.06862985f, 
    -0.33245832f, -0.18734033f, 0.11945839f, -0.05841506f, -0.16770537f, -0.09154728f, -0.01365739f, 0.02100060f, 
    -0.14081593f, -0.32847720f, -0.25115868f, -0.21050070f, 0.78737634f, 0.46370059f, -0.15828452f, -0.54569936f, 
    0.16101114f, 0.08219305f, 0.27682832f, 0.10603479f, -0.08042993f, -0.09370170f, -0.08140308f, -0.17495169f, 
    -0.24333236f, -0.30822432f, 0.08000516f, 0.10485432f, 0.15397677f, 0.10014153f, -0.00443311f, 0.08954242f, 
    -0.13150492f, 0.21925233f, -0.16907556f, 0.10912616f, 0.14672971f, 0.32140517f, -0.07658350f, -0.72806937f, 
    -0.01784521f, -0.03786717f, -0.13331194f, -0.11121592f, 0.01592400f, 0.03864431f, -0.03568199f, 0.01059398f, 
    -0.23327044f, -0.02382600f, 0.15876067f, 0.08353655f, 0.12416610f, 0.10643590f, -0.04014630f, -0.05513441f, 
    -0.00183743f, 0.00724678f, -0.07705681f, -0.02890793f, -0.30976218f, 0.22136927f, 0.29843464f, -0.58194578f, 
    -0.15565011f, -0.13723485f, -0.18031298f, -0.31589216f, 0.08556651f, -0.19541283f, -0.06302039f, -0.17241791f, 
    0.10372564f, -0.03692528f, 0.01976218f, -0.07587188f, 0.22063217f, 0.38807762f, -0.28077856f, 0.08829350f, 
    -0.30052906f, 0.10803109f, 0.00143945f, 0.22307989f, 0.46298754f, 0.00792526f, 0.05922263f, -0.35811350f, 
    0.03414043f, -0.01802586f, 0.14671524f, -0.41659656f, 0.04853545f, -0.06268461f, -0.07609272f, 0.02993170f, 
    0.10148099f, -0.67868268f, -0.03331420f, -0.25014511f, 0.05227721f, -0.02001757f, 0.21323726f, 0.29318789f, 
    0.27033892f, -0.09889566f, 0.21327519f, 0.19507256f, 0.17126930f, -0.03446116f, -0.33303687f, -0.32915747f, 
    0.05147524f, -0.36773992f, 0.01337966f, 0.20670260f, 0.01856397f, -0.25916678f, -0.04063923f, -0.20708282f, 
    0.18657055f, 0.41903037f, -0.02221151f, 0.09354366f, -0.02313938f, 0.04651150f, -0.10058542f, -0.06218951f, 
    -0.42247513f, -0.20083861f, -0.19052389f, -0.03373802f, -0.61841500f, -0.25742382f, 0.11605816f, 0.04883174f, 
    -0.05946327f, 0.04479881f, 0.18622035f, -0.09086353f, 0.08940735f, 0.07833640f, -0.04283099f, -0.10243591f, 
    0.30418459f, 0.15370169f, 0.00205209f, 0.26794881f, -0.06391282f, 0.03729033f, 0.12786330f, -0.00303686f, 
    -0.02683522f, 0.06945056f, 0.00121960f, -0.03176937f, -0.35665157f, 0.03767810f, 0.05162923f, 0.10174677f, 
    0.21557544f, 0.06641757f, -0.38659802f, -0.23449782f, -0.14887808f, -0.10305464f, -0.21574712f, -0.04757209f, 
    0.38095224f, 0.53754508f, 0.17848833f, -0.35276672f, -0.01241857f, 0.14795734f, 0.02082469f, 0.00986288f, 
    -0.23950998f, 0.00054158f, 0.08189934f, -0.15216085f, 0.17293374f, 0.35448483f, -0.01715460f, 0.05183826f, 
    -0.07978984f, -0.12438674f, -0.12413338f, 0.08011819f, 0.00917160f, -0.04542155f, 0.09113207f, 0.01346492f, 
    -0.13652445f, 0.04589671f, 0.43819797f, -0.01270766f, 0.19339886f, 0.35090530f, -0.13407065f, -0.01228148f, 
    0.05852009f, 0.06889197f, 0.10786948f, 0.11745786f, 0.11172944f, -0.05126841f, 0.48163733f, 0.27169997f, 
    0.00426569f, -0.12109745f, 0.05992120f, -0.00959368f, 0.01266197f, 0.09606096f, 0.11134297f, -0.01030908f, 
    0.19308792f, 0.15256935f, 0.18530782f, 0.09782328f, -0.03019628f, -0.03459639f, -0.03434018f, 0.02166779f, 
    0.01814721f, 0.01368365f, -0.24065828f, 0.08415022f, -0.77533221f, 0.57342416f, -0.67553210f, -0.22056732f, 
    -0.20138694f, 0.01507930f, 0.06704111f, -0.04679624f, -0.11791837f, -0.05174123f, -0.00848786f, 0.13047348f, 
    0.14390776f, -0.01270915f, 0.11097112f, 0.21552788f, -0.18678644f, -0.12170567f, -0.04215342f, -0.01711124f, 
    -0.02088554f, -0.11572256f, 0.15309098f, -0.02927006f, -0.32248119f, 0.01165631f, -0.02751845f, -0.33739454f, 
    0.17036287f, 0.08426703f, -0.18330739f, 0.26251072f, 0.05752202f, -0.00820922f, 0.06583305f, -0.23460484f, 
    -0.02682634f, 0.07266460f, 0.08200380f, -0.12200209f, 0.28823751f, 0.18891914f, -0.33897811f, -0.22854236f, 
    0.04408946f, 0.00479618f, -0.03405744f, -0.20583265f, -0.45323172f, 0.21100561f, -0.05716553f, -0.03951177f, 
    -0.21191464f, -0.06522837f, 0.11232585f, 0.07463039f, 0.24003965f, -0.04309176f, 0.01726467f, -0.15661174f, 
    0.01120239f, -0.39851922f, -0.15100779f, -0.85494179f, 0.28932846f, -0.02480328f, -0.26756096f, 0.14220488f, 
    -0.04398071f, 0.15167452f, -0.22838712f, -0.06585054f, -0.12402388f, 0.56903011f, 0.19538045f, 0.04195421f, 
    0.08942060f, -0.45042118f, -0.02749794f, 0.07216426f, 0.04670317f, -0.02043095f, 0.05729041f, -0.12724473f, 
    -0.13904852f, -0.17878839f, -0.13031124f, 0.22617577f, -0.02672885f, 0.06029892f, 0.12011447f, -0.01206227f, 
    0.18413273f, 0.22946908f, 0.11965077f, 0.16434096f, 0.46447879f, 0.15722238f, -0.61050838f, 0.32611111f, 
    0.12121579f, 0.00153470f, 0.11783933f, -0.02696858f, -0.02442900f, 0.04719341f, -0.01273716f, -0.18936843f, 
    -0.44042522f, -0.00804650f, -0.15192993f, -0.16189821f, 0.00410776f, 0.06080921f, 0.11444156f, 0.00474652f, 
    -0.02890038f, 0.00394775f, 0.05211867f, -0.10215200f, -0.84342915f, -0.60793030f, -0.27008054f, 0.21438940f, 
    0.12832920f, -0.28427967f, -0.01850725f, -0.06257089f, 0.02418358f, 0.00381601f, -0.01009629f, -0.09286101f, 
    0.05551240f, 0.15644738f, 0.69953686f, 0.82315969f, -0.24427149f, 0.10835324f, 0.18075207f, 0.05400690f, 
    0.03584842f, 0.09248205f, -0.10587768f, -0.03177670f, -0.24747376f, 0.29566565f, -0.15533505f, -0.51496631f, 
    0.10197774f, 0.06372690f, 0.02975603f, 0.30131260f, -0.02762921f, -0.05947247f, 0.13058327f, -0.05838481f, 
    0.67361069f, -0.36903423f, 0.38859814f, -0.04021360f, 0.19242783f, -0.01017488f, -0.02097945f, 0.14305882f, 
    -0.03839586f, 0.17104129f, -0.21393259f, 0.23101468f, -0.99015385f, -0.92984486f, -0.23301290f, -0.34522682f, 
    -0.03157913f, -0.00460795f, 0.31868210f, 0.12307469f, -0.05613494f, -0.09226467f, -0.10250389f, -0.10384151f, 
    -0.14152500f, -0.04950408f, -0.18211910f, -0.18163398f, 0.00338828f, -0.05733472f, -0.00173396f, -0.01803474f, 
    0.00946621f, -0.17614488f, 0.14088838f, 0.39173645f, -0.94540638f, -0.48575640f, -0.39972338f, 0.05400847f, 
    -0.11196297f, -0.04882796f, -0.08493245f, -0.16861291f, 0.06863706f, -0.10735095f, 0.00406429f, 0.04396963f, 
    -0.21382396f, 0.19049948f, -0.32370213f, 0.22561465f, -0.27338693f, -0.04827820f, 0.07186958f, 0.14045852f, 
    -0.10754514f, -0.05024844f, 0.00908016f, -0.21775065f, -0.36562046f, 0.06093204f, -0.02728777f, 0.24177153f, 
    0.00226925f, -0.05890331f, -0.37723815f, -0.18962464f, 0.02390895f, -0.18199819f, 0.14852220f, 0.05945998f, 
    0.26437920f, 0.81687909f, 1.00756335f, 0.33457750f, -0.06701294f, 0.02130719f, 0.20509765f, -0.16145599f, 
    -0.10036440f, 0.05726188f, 0.14625201f, -0.14499664f, 0.21755373f, -0.08420923f, 0.02249667f, 0.30148953f, 
    0.10022177f, 0.13182671f, -0.23204368f, 0.11446305f, -0.16911694f, 0.12582049f, 0.00898521f, -0.06137685f, 
    -0.15065281f, 0.21899429f, -0.26385614f, 0.20755810f, 0.08320282f, 0.02005726f, 0.07169505f, 0.00749201f, 
    -0.16335358f, 0.13651630f, -0.01650523f, -0.07217156f, -0.30269477f, 0.57012731f, -0.01458469f, 0.40985703f, 
    -0.05298904f, 0.00375334f, 0.04514438f, 0.03678047f, -0.32683131f, -0.15711594f, -0.06354861f, 0.10428733f, 
    0.18038772f, 0.01461930f, -0.28107500f, -0.95207471f, 0.14415842f, 0.39630127f, 0.25077575f, 0.25465223f, 
    0.01097012f, -0.10617362f, -0.08444405f, -0.23022066f, 0.93778288f, 0.54877746f, 0.00455240f, -0.66951895f, 
    -0.09221913f, -0.03658690f, -0.14684682f, -0.11418987f, -0.22036669f, 0.04715012f, -0.07822018f, 0.19447786f, 
    -0.43885767f, 0.33887273f, 0.08332346f, 0.14378768f, 0.25664815f, -0.22645487f, 0.05575710f, -0.28976503f, 
    -0.21383764f, 0.00155932f, -0.03001431f, 0.10221022f, 0.54544222f, -0.33960310f, -0.17307650f, 0.07468106f, 
    -0.20215712f, -0.36462575f, -0.02037477f, -0.00190623f, -0.01631637f, 0.16778901f, -0.25510308f, 0.21660288f, 
    0.05581482f, -0.42586178f, 0.21492583f, 0.38555485f, 0.15958790f, -0.06868121f, 0.02621980f, -0.08308346f, 
    -0.02421358f, 0.07857336f, -0.05847717f, 0.24060565f, -0.05891326f, -0.05917073f, -0.10637264f, -0.18718651f, 
    -0.40856779f, -0.37537971f, 0.16772339f, -0.30285570f, 0.35172564f, 0.15206525f, -0.05223522f, -0.00891512f, 
    1.16481709f, -0.14001919f, -0.29372329f, -0.19965555f, -0.22161588f, 0.07338710f, -0.40227136f, -0.37714338f, 
    -0.00878391f, -0.19393337f, -0.39469829f, -0.08207265f, -0.31537381f, -0.05788220f, -0.27861932f, 0.26472339f, 
    0.05166891f, 0.21914339f, 0.13773529f, 0.04058793f, -0.13696450f, -0.02365164f, -0.11348568f, 0.00136534f, 
    -0.21408735f, 0.11483554f, 0.52871984f, -0.12433201f, -0.40228328f, -0.16272639f, -0.11833018f, -0.02633111f, 
    0.06155705f, 0.37571669f, 0.13510618f, 0.27084205f, 0.09219743f, -0.01818986f, -0.13642730f, 0.51497602f, 
    -0.04196246f, -0.12078979f, 0.15955605f, -0.00644423f, -0.04774312f, 0.18525057f, -0.06831950f, -0.13346082f, 
    -0.49714965f, 0.38960057f, 0.19483712f, -0.15566678f, 0.13852105f, -0.28574732f, 0.15116362f, -0.04162913f, 
    0.07283323f, -0.17885013f, -0.20052636f, 0.41979185f, 0.15524390f, -0.33169630f, 0.12180118f, -0.16068771f, 
    -0.09336730f, 0.12151840f, -0.20471333f, -0.13184127f, -0.13244957f, 0.01773708f, 0.04521686f, -0.13721904f, 
    0.38152510f, -0.31819546f, 0.10295302f, 0.50630683f, 0.14774992f, 0.04688211f, 0.14360704f, -0.10584135f, 
    -0.10732699f, -0.00381635f, 0.02513550f, 0.12881811f, -0.42420337f, 0.83863014f, -0.51385766f, -0.99285334f, 
    0.22683173f, -0.13558021f, -0.23474075f, -0.11554954f, -0.15361285f, -0.12949112f, -0.14391048f, 0.13687570f, 
    0.23811933f, 0.02031729f, -0.21042648f, 0.26290342f, -0.05495605f, -0.04275988f, -0.09099435f, -0.31533080f, 
    -0.24476424f, -0.29059964f, -0.16991413f, -0.20145184f, 0.26264068f, -0.55452234f, 0.18626085f, -0.19174883f, 
    0.10845590f, 0.00998803f, 0.09006230f, -0.21995623f, 0.08113725f, 0.21797085f, -0.10688598f, 0.12117801f, 
    -0.25172046f, -0.33942461f, -0.16190585f, -0.22393511f, 0.00438978f, -0.01734171f, 0.14984144f, 0.08118481f, 
    0.09758858f, 0.06975666f, 0.17375928f, 0.20001051f, -0.11582956f, -0.92221081f, -0.30647126f, -0.01973582f, 
    0.20237038f, 0.06385119f, 0.07002640f, -0.08008749f, 0.09309431f, -0.01752576f, 0.06050231f, -0.03705026f, 
    -0.05101591f, -0.27078775f, 0.07429455f, -0.03351898f, 0.23431087f, 0.05019552f, -0.01780297f, 0.05548115f, 
    -0.09281407f, -0.10377728f, -0.18304572f, -0.20027195f, -0.10473390f, -0.03415276f, 0.17301975f, 0.04404656f, 
    -0.04905301f, 0.03369039f, -0.13549256f, 0.04295056f, 0.19519031f, 0.00582046f, 0.04436691f, 0.01711910f, 
    0.18223453f, 0.38022694f, 0.14543772f, 0.22389026f, -0.04332006f, -0.24542500f, -0.09630983f, -0.10815047f, 
    0.17196639f, -0.10135692f, 0.05073476f, 0.09678809f, -0.07630112f, -0.09138011f, -0.05289161f, 0.48259547f, 
    0.16312918f, 0.09535435f, -0.10714923f, 0.12743369f, -0.05114416f, 0.03858890f, -0.12361261f, -0.02710368f, 
    -0.15620838f, 0.19824322f, -0.86520481f, 0.02306882f, 0.05838495f, -0.21971227f, 0.17685792f, 0.04542641f, 
    -0.14266945f, -0.39088127f, -0.03261808f, -0.13966396f, -0.00896108f, -0.13868643f, 0.23619141f, 0.14471528f, 
    -0.11786481f, 0.21335869f, 0.04880353f, 0.01674153f, -0.06337683f, 0.03570237f, -0.01037590f, 0.08335585f, 
    0.12817952f, -0.08186870f, -0.15824057f, 0.00009864f, 0.09603318f, 0.02881713f, -0.01142992f, -0.06176925f, 
    0.07175563f, -0.16872898f, -0.07910321f, -0.01061971f, 0.25111526f, 0.24519104f, 0.74158317f, 0.28412750f, 
    0.02697106f, 0.22712322f, -0.00001136f, 0.20874773f, 0.01252049f, -0.02172316f, -0.08614414f, -0.17211157f, 
    0.21808596f, -0.13572870f, 0.07087987f, 0.19548091f, 0.21274489f, 0.16343559f, 0.10277860f, 0.05810378f, 
    0.02681652f, -0.01307880f, -0.16112572f, 0.01462284f, -0.27006701f, -0.02581166f, -0.11742436f, 0.09448588f, 
    -0.29143980f, 0.04379852f, -0.21931314f, -0.33655626f, -0.14906481f, -0.01074129f, -0.19017819f, 0.11665004f, 
    -0.14472078f, 0.21711439f, 0.04167681f, 0.04192581f, -0.13790034f, -0.29392901f, 0.19877966f, -0.01716596f, 
    0.04565541f, -0.01125319f, 0.02575248f, 0.29595187f, -0.04983970f, -0.64490938f, -0.15560216f, 0.04233376f, 
    -0.23319988f, -0.05365831f, -0.13190742f, -0.23941800f, -0.28087574f, 0.01834324f, -0.12568888f, -0.04608866f, 
    -0.15556176f, 0.59364927f, -0.00041344f, -0.21326107f, 0.01975620f, 0.04990911f, -0.14162391f, -0.14922637f, 
    0.11343572f, 0.15452234f, -0.07449348f, 0.04704037f, -0.05810615f, 0.20233640f, 0.45337722f, 0.00366815f, 
    -0.14755760f, 0.15958597f, -0.06283064f, -0.17885932f, 0.09663454f, -0.16188374f, -0.25449595f, -0.22740532f, 
    -0.16020799f, -0.64391947f, 0.24824004f, 0.16418126f, -0.05115027f, -0.00207993f, -0.05212012f, 0.01391631f, 
    -0.08867307f, -0.30751035f, -0.18723528f, -0.10260394f, -0.40152821f, 0.12086228f, 0.44037583f, 0.45987007f, 
    -0.08875136f, -0.02302634f, -0.18693191f, 0.05071839f, -0.00895274f, -0.16377427f, -0.23729496f, -0.04519972f, 
    0.03503396f, -0.18561117f, -0.12099774f, -0.01046729f, -0.17748061f, 0.02832245f, -0.23774435f, -0.14191310f, 
    0.24057448f, 0.04769066f, 0.14326257f, 0.06019018f, -0.10313418f, 0.40872425f, 0.33264261f, -0.04919955f, 
    0.20906399f, -0.06157157f, 0.25908756f, 0.40618947f, -0.15955126f, 0.00370410f, 0.21182193f, 0.05050118f, 
    -0.58100587f, -0.34437782f, -0.28878400f, -0.28705877f, 0.09454466f, 0.03883155f, 0.00300378f, 0.16712292f, 
    0.19152278f, 0.04403538f, 0.03973916f, -0.07714275f, 0.06782603f, -0.02209765f, -0.16220632f, 0.15883686f, 
    0.18895721f, -0.08815201f, 0.01432632f, -0.00939111f, -0.13785416f, 0.09069199f, -0.04924479f, 0.16117667f, 
    -0.88758600f, 0.22807060f, -0.35299972f, 0.22252885f, 0.00722319f, -0.38880578f, -0.09249948f, 0.23523813f, 
    0.28873542f, 0.12704964f, 0.14117512f, 0.17311621f, -0.15017430f, 0.46570653f, 0.32701269f, -0.15205760f, 
    0.30841815f, -0.18725345f, -0.20819078f, -0.14079587f, 0.09825841f, 0.04376635f, 0.12639749f, 0.07698269f, 
    0.02593673f, -0.12508978f, -0.15405409f, 0.07364710f, -0.02066877f, 0.07764933f, -0.07427209f, -0.16452588f, 
    0.02100449f, -0.38199365f, 0.21851388f, -0.36051548f, 0.36489114f, -0.20241199f, 0.34924263f, -0.45041329f, 
    0.12412274f, 0.05722919f, -0.08111328f, 0.00048492f, 0.10917914f, -0.02882042f, 0.15310878f, 0.03914975f, 
    -0.15937258f, -0.27640250f, 0.26750940f, -0.08277316f, -0.11185682f, -0.11900881f, -0.05659662f, 0.02015537f, 
    -0.01425725f, 0.22089563f, 0.03450981f, 0.11650320f, 0.05271661f, -0.19914360f, 0.25404897f, 0.40281591f, 
    0.09221744f, -0.02588265f, 0.30579957f, 0.27031463f, -0.06539384f, 0.30395681f, -0.16499424f, -0.11371846f, 
    -0.31061319f, 0.00104674f, -0.45323667f, -0.33833262f, 0.04003781f, -0.11321311f, -0.18352547f, -0.05298931f, 
    0.21096368f, -0.15464544f, -0.42379555f, -0.44146639f, 0.18635605f, -0.42789400f, 0.37213421f, 0.07303100f, 
    0.08826123f, 0.04396859f, 0.09860925f, -0.09453088f, -0.01653399f, -0.09589873f, -0.16076288f, 0.08922724f, 
    -0.23364282f, -0.14994676f, 0.75579280f, -0.06824823f, 0.05935926f, -0.34522527f, 0.07274286f, -0.04882297f, 
    0.10853427f, 0.09845614f, 0.16071948f, 0.02824923f, -1.19707847f, -0.75359523f, -0.10326519f, 0.53383589f, 
    0.03100886f, 0.26094833f, 0.13150594f, -0.07909451f, 0.18353759f, 0.38825580f, 0.20589849f, 0.15073326f, 
    0.10761203f, 0.05223614f, 0.17529288f, 0.15126689f, -0.06297769f, -0.04548345f, -0.10686800f, 0.22598097f, 
    0.25804725f, 0.18475965f, 0.47091064f, 0.23730999f, 0.15100747f, -0.21040399f, -0.05484641f, -0.15105499f, 
    -0.08576229f, 0.17572005f, -0.22708948f, 0.09133977f, 0.03972273f, 0.16789950f, 0.14409974f, -0.00844618f, 
    -0.14895336f, -0.22423938f, 0.02550207f, -0.18076594f, 0.12371818f, 0.01998954f, 0.09589104f, -0.02679083f, 
    0.13791026f, 0.02666064f, -0.13184080f, -0.02762916f, -1.19309306f, -0.93743336f, -1.03692007f, -0.53498715f, 
    -0.33765700f, 0.18303934f, -0.00229166f, -0.18031022f, 0.04283972f, 0.01823272f, 0.11831720f, 0.07440082f, 
    -1.21336377f, 0.26167545f, 0.62520248f, 0.28390357f, -0.02779618f, -0.10960697f, -0.03616707f, -0.32542011f, 
    -0.00551077f, -0.09066828f, -0.00092263f, 0.02509448f, 0.02344353f, -0.02419114f, -0.54466772f, -0.08112334f, 
    0.24494609f, 0.07588068f, 0.07663009f, -0.21235752f, -0.00412970f, 0.00275365f, 0.00735797f, 0.01814632f, 
    0.55912298f, -0.62528795f, -0.06648052f, 0.49342167f, -0.14581755f, 0.04618650f, 0.16445126f, 0.22813077f, 
    0.03478370f, 0.24752046f, 0.10054890f, -0.62259787f, -1.02538133f, -1.51984990f, -0.98497617f, 0.44537669f, 
    -0.15139398f, -0.32726100f, -0.14775454f, -0.65184063f, -0.13282610f, -0.01222469f, -0.07451210f, -0.07745050f, 
    0.14931306f, -0.10383732f, -0.07137952f, -0.26205605f, 0.08600426f, 0.11781470f, 0.02855329f, 0.05492596f, 
    -0.06720833f, 0.41365021f, 0.11459605f, -0.25551781f, -0.58668518f, -1.36647892f, -1.07728541f, -0.00512870f, 
    -0.08878799f, 0.07077105f, -0.16797277f, -0.13803320f, 0.15046547f, 0.02670016f, -0.07679904f, -0.07804400f, 
    -0.44874677f, -0.21755117f, -0.20964774f, 0.15565954f, 0.15800649f, 0.20005558f, 0.04809094f, 0.00052146f, 
    -0.17319639f, -0.21004193f, -0.30302984f, -0.05800977f, 0.86610609f, -0.27435285f, -1.07068348f, 0.18035389f, 
    -0.13156109f, 0.09376738f, 0.44581497f, 0.13135138f, -0.01722192f, -0.25197387f, -0.08235873f, 0.05375510f, 
    -0.58070892f, 0.12409721f, 0.19417693f, -0.17228737f, -0.33841637f, 0.09569854f, 0.02040238f, -0.02017504f, 
    0.04565888f, 0.07829345f, 0.19243500f, 0.18170729f, -0.35134417f, -0.01759747f, 0.27323487f, 0.15478943f, 
    -0.26030880f, -0.30536273f, 0.06665073f, 0.47265381f, -0.04705221f, 0.04594697f, 0.11987540f, -0.02442190f, 
    -0.02479128f, 0.31633571f, 0.47747111f, 0.50245833f, -0.10565362f, 0.08497365f, 0.24536157f, -0.01734325f, 
    -0.26198408f, -0.19806953f, -0.07403373f, 0.01564215f, 0.21267019f, -0.90167075f, 0.67020029f, -0.79784173f, 
    -0.15495050f, 0.16420291f, -0.18505605f, 0.27664208f, -0.24754940f, 0.24667425f, 0.01120268f, 0.00239616f, 
    0.20269865f, 0.00243760f, 0.07143870f, -0.37425631f, 0.09296580f, 0.01062999f, -0.07160047f, -0.08370078f, 
    0.33256942f, -0.20844916f, -0.13175757f, -0.22832908f, 0.25910503f, 0.02406944f, -0.50133801f, -0.06530814f, 
    -0.07448117f, 0.04176681f, -0.09737944f, 0.10242600f, -0.10485103f, 0.15624449f, -0.12574835f, -0.02506123f, 
    0.08574086f, 0.16235262f, 0.16635893f, -0.17655522f, 0.01565024f, -0.00447583f, 0.01948810f, -0.07548068f, 
    0.09198295f, -0.01642262f, -0.08032078f, -0.19100516f, -0.13489246f, -0.36696047f, -0.44415838f, -0.35798135f, 
    0.23809552f, -0.02155676f, 0.21068476f, 0.02316461f, 0.02438922f, -0.04439133f, -0.09550738f, -0.00336655f, 
    0.63549435f, -0.88301200f, -1.08760893f, -0.97344208f, -0.04771504f, -0.10016038f, -0.00668253f, 0.10023291f, 
    0.11912954f, 0.01641956f, 0.06007985f, 0.03389715f, 0.14317530f, -0.08938891f, 0.08262203f, -0.33316436f, 
    -0.15802731f, 0.00230935f, -0.13073322f, -0.02396897f, 0.11173612f, 0.13906507f, 0.04381223f, -0.00823677f, 
    0.21379481f, -0.13051966f, 0.12607285f, -0.30666357f, -0.08315820f, 0.23613656f, -0.13294417f, -0.04395725f, 
    -0.18026283f, -0.18625975f, -0.25430664f, 0.00842116f, -0.02923236f, -0.85665619f, 0.42487961f, -0.05762456f, 
    0.12527026f, -0.27791810f, -0.03784487f, 0.35415617f, -0.01628947f, -0.09710922f, -0.16626073f, 0.06465176f, 
    0.12853450f, 0.07865378f, 0.22887030f, 0.07077763f, -0.00400520f, -0.05934671f, 0.00181770f, -0.02637945f, 
    0.10519642f, -0.27124795f, 0.00315522f, 0.19596629f, -0.89498872f, -1.34103096f, 1.03163373f, 0.14889689f, 
    -0.15687250f, -0.06034375f, 0.03764383f, -0.18640102f, 0.04717854f, -0.04614707f, -0.00445827f, 0.00545981f, 
    0.12230559f, 0.12244608f, 0.03696016f, -0.24207146f, 0.02750618f, 0.03300453f, 0.08134174f, -0.06387050f, 
    0.13526006f, 0.07538392f, -0.08490799f, -0.11594123f, -0.55024546f, -0.54210120f, -0.19688739f, 0.17961328f, 
    -0.36183447f, 0.06824569f, -0.08823948f, 0.05749093f, -0.12287727f, 0.01175508f, -0.02750431f, 0.08991561f, 
    0.87496680f, -0.92180580f, -1.19122040f, -0.78777963f, 0.13159204f, -0.14110154f, 0.33957395f, 0.07834197f, 
    0.03867501f, 0.06719646f, -0.13607228f, 0.10659913f, 0.96983498f, -0.42893749f, -0.37532720f, -0.51440918f, 
    -0.22017652f, -0.01234199f, -0.11372771f, -0.09935012f, -0.12572724f, 0.21313950f, 0.07464672f, -0.11375158f, 
    -0.32530805f, -0.19036554f, -0.05824173f, -0.04303307f, -0.40934193f, 0.19181688f, 0.20901766f, -0.13456547f, 
    0.32558125f, 0.14548278f, 0.29939187f, 0.16108523f, 0.27669275f, 0.29837355f, -0.46323833f, -0.68762630f, 
    0.01443624f, -0.17806919f, 0.07592411f, -0.04663365f, 0.01431088f, -0.02849657f, -0.12450164f, -0.08109812f, 
    0.24590696f, 0.10044102f, -0.28729150f, -0.33638373f, -0.15217778f, -0.21093763f, -0.00908491f, -0.06989920f, 
    0.01952410f, 0.11835088f, -0.41678691f, -0.17454961f, 0.81480241f, 0.38414234f, -0.23657365f, -0.33801538f, 
    -0.03415517f, -0.13800590f, -0.06710040f, -0.03517283f, 0.04078000f, -0.10519098f, -0.03793083f, 0.21781291f, 
    -0.17357886f, 0.05746407f, 0.15787619f, 0.05537593f, -0.14750534f, -0.14428809f, -0.10906378f, -0.00195829f, 
    0.11801164f, 0.22860709f, 0.23679131f, 0.33115301f, 0.22359954f, -0.49393195f, -0.39774621f, 0.26815999f, 
    -0.08850634f, 0.26527122f, -0.02475369f, -0.26311681f, -0.05234345f, -0.08591916f, -0.12951520f, -0.15179515f, 
    -0.61994696f, -1.52864075f, -0.98005199f, 0.40400255f, -0.02631650f, 0.06789487f, 0.26461139f, 0.13612413f, 
    -0.01139365f, -0.02513828f, 0.17277060f, 0.20805562f, -0.23790850f, 0.05484948f, 0.19886157f, -0.06749880f, 
    -0.11610326f, -0.24699844f, -0.01421862f, 0.00437163f, -0.05695570f, 0.01002462f, 0.30869809f, -0.01887791f, 
    0.27837968f, 0.07878760f, -0.04571620f, -0.02289256f, -0.05028176f, 0.05515901f, -0.04752119f, 0.17407332f, 
    0.01863201f, 0.19826713f, 0.48664641f, -0.01776685f, 0.45146391f, -0.41961172f, -0.74592197f, -0.73752582f, 
    -0.15374565f, -0.19864194f, -0.00064487f, -0.21827076f, 0.09970709f, 0.02505158f, 0.08449201f, 0.16633479f, 
    -0.49741966f, 0.17855124f, -0.06254604f, -0.15535058f, -0.07127280f, -0.09056818f, -0.19367671f, -0.06405044f, 
    -0.30897328f, -0.34289488f, -0.42207682f, -0.46405289f, 1.16501129f, -0.17146996f, -0.05062931f, 0.17932849f, 
    0.01985610f, -0.07957889f, -0.12523581f, -0.34981716f, 0.21546242f, 0.15872276f, -0.01580815f, -0.01233178f, 
    0.14562719f, -0.02102585f, 0.09274685f, -0.45261043f, -0.12101847f, -0.11865983f, 0.03157585f, -0.12114143f, 
    0.11151591f, 0.03851674f, 0.12158976f, 0.17786601f, 0.10721749f, 0.22762336f, -0.01415206f, -0.21549356f, 
    0.34955230f, -0.04395012f, 0.13034520f, 0.13103400f, -0.15322301f, -0.12348624f, 0.26157984f, -0.04667263f, 
    -0.60311693f, -1.00500488f, -0.97626793f, 0.03508255f, 0.18399684f, 0.26627702f, 0.17577186f, 0.32205826f, 
    -0.26466703f, -0.07130775f, -0.07070483f, -0.21413144f, 0.47847760f, 0.05921841f, -0.45364502f, -0.48704347f, 
    -0.26029867f, -0.22966585f, -0.06925564f, 0.23247983f, 0.20793234f, -0.05594538f, 0.02199963f, 0.09387925f, 
    0.07222303f, 0.31169176f, 0.24469866f, -0.23435029f, 0.01173350f, 0.02188827f, -0.18247397f, 0.02235856f, 
    -0.09658912f, 0.09435519f, -0.04414027f, -0.10188323f, 0.16291165f, -1.14198089f, 0.09730477f, -0.22493744f, 
    -0.41280532f, 0.22083706f, -0.20221488f, 0.00958629f, -0.13103120f, -0.00281499f, 0.00149720f, -0.03902003f, 
    0.11745004f, 0.00124429f, 0.24327600f, 0.45289680f, -0.06084052f, -0.01584768f, -0.00076526f, -0.30659780f, 
    0.19857636f, 0.49397588f, 0.04416772f, 0.15726244f, -0.92296696f, 0.52436018f, -0.46828258f, 0.64945012f, 
    0.07988694f, -0.05311185f, 0.01598167f, 0.00125210f, -0.11568876f, -0.17654723f, 0.12797739f, -0.07302028f, 
    0.11386104f, -0.54260033f, -0.03868780f, 0.10828321f, 0.09406210f, 0.02544702f, 0.03649351f, -0.09299658f, 
    -0.12666386f, -0.02760164f, 0.01486914f, -0.08309755f, -0.48783508f, 0.00794453f, 0.31201231f, 0.21121891f, 
    -0.24542065f, -0.23191753f, -0.10592506f, -0.09928264f, 0.18026926f, -0.02063959f, 0.03256055f, 0.15608196f, 
    -0.07945488f, 0.12524286f, 0.01966191f, -1.01047409f, -0.03688148f, -0.02791052f, -0.24001080f, -0.01484683f, 
    0.02192625f, -0.27038938f, 0.01527759f, 0.06642072f, -0.13441797f, -0.74602604f, -0.15335414f, -0.00213988f, 
    0.03809371f, 0.52482611f, 0.17643267f, -0.02587055f, -0.23429579f, -0.09490526f, -0.32187027f, -0.09770476f, 
    -0.59225494f, -0.00124053f, -0.18367299f, -0.13987030f, -0.30707434f, 0.07960891f, 0.06083874f, -0.44287166f, 
    0.06141361f, -0.18384108f, -0.18250559f, -0.02989475f, -0.73872405f, -0.38140735f, 0.14932069f, -0.09614692f, 
    -0.27930272f, 0.00982688f, -0.13401961f, 0.37182802f, 0.09733465f, 0.07079831f, 0.22465639f, 0.04048811f, 
    -0.12600365f, -0.07881044f, -0.42190653f, 0.15509938f, 0.21318159f, 0.11505660f, 0.27334553f, 0.23135541f, 
    0.15579665f, 0.10311571f, 0.23894811f, 0.03733860f, 0.26916653f, -0.56487674f, -0.58129722f, -0.25357521f, 
    0.22097757f, -0.12813693f, 0.27456430f, 0.16078649f, -0.10299352f, 0.02584871f, -0.07786258f, -0.14249317f, 
    0.15661132f, -0.76614428f, 0.39435026f, -0.08323339f, 0.51708317f, 0.14886996f, -0.03035728f, -0.11428539f, 
    -0.14419149f, 0.05691998f, 0.00463085f, 0.08880214f, 0.01436605f, 0.86915082f, -0.85412472f, -0.25667098f, 
    0.01659611f, -0.20471895f, -0.10744355f, -0.02752139f, 0.14363994f, -0.04609748f, 0.16227716f, 0.28035036f, 
    0.08749796f, 0.24233226f, -0.17891134f, 0.59980071f, -0.25923854f, -0.17829975f, -0.24169165f, -0.03901419f, 
    0.13346335f, -0.05985746f, 0.32376793f, 0.03695203f, -0.43688467f, 0.00028668f, 0.40677533f, 0.94512057f, 
    0.44074768f, 0.12266435f, -0.15840010f, -0.00775680f, -0.00625749f, -0.15708978f, 0.11747227f, -0.02187231f, 
    0.40333501f, -0.30717695f, 0.37494501f, 0.36629537f, -0.19812620f, -0.03628519f, 0.05047338f, 0.22519583f, 
    0.10831524f, -0.06644753f, 0.28241804f, 0.23889327f, -0.27524388f, 0.74966711f, -0.77533108f, 0.34297746f, 
    0.09265818f, 0.72773999f, 0.09500884f, -0.15337026f, -0.20319128f, -0.05661224f, -0.21186818f, 0.03264393f, 
    -0.22874306f, 0.28466678f, 0.07970751f, -0.07144348f, -0.06704838f, -0.12806000f, 0.10771573f, -0.08004204f, 
    -0.10237747f, -0.21952002f, -0.26540387f, -0.20475176f, 0.61010796f, -0.26964006f, 0.08136554f, -0.11744454f, 
    -0.39360005f, 0.06228876f, 0.02963344f, 0.15989165f, 0.06543507f, -0.15097085f, -0.19982758f, 0.20549922f, 
    -0.08484264f, 0.44463533f, 0.21611793f, -0.18151614f, -0.06087832f, -0.11052252f, -0.01827854f, 0.35049957f, 
    0.10932047f, 0.27366486f, 0.35489848f, 0.39613956f, 0.11540172f, -0.22567409f, 0.07115713f, 0.04509347f, 
    -0.13373184f, 0.04677386f, -0.61511749f, 0.14356831f, -0.14217085f, 0.11119330f, 0.04058315f, -0.25283849f, 
    -0.06543669f, 0.01622623f, -0.06987041f, 0.25131923f, -0.14880121f, -0.21130748f, -0.01588751f, 0.15547644f, 
    -0.31248042f, 0.22427456f, 0.14035940f, -0.06712628f, 0.08539321f, -0.00306143f, -0.33107162f, -0.10252302f, 
    -0.33025661f, 0.01391913f, -0.12243510f, -0.33140641f, 0.31273872f, 0.45034516f, -0.18575686f, -0.02146215f, 
    0.07218045f, 0.47170901f, 0.14612351f, -0.21891832f, -0.21736301f, -0.19843704f, 0.42001891f, 0.00656223f, 
    -0.23388773f, 0.02417838f, 0.19963537f, 0.17684104f, -0.37061599f, -0.37262392f, -1.07947612f, 0.25224775f, 
    -0.06222304f, 0.24393733f, -0.40357885f, 0.38601542f, 0.00564519f, 0.14976700f, 0.03567201f, -0.07254794f, 
    0.01713979f, 0.06530196f, -0.36432517f, -0.29270509f, -0.28225735f, -0.17924501f, -0.11133346f, 0.16984499f, 
    -0.76049745f, -0.13188095f, -0.48463318f, -0.42121336f, -0.87165856f, -0.20243414f, -0.37593767f, 0.35151193f, 
    0.09959171f, 0.17834130f, -0.12945972f, 0.38577351f, -0.11341871f, 0.21099648f, 0.00870911f, -0.02537536f, 
    -0.97167736f, 0.10654184f, -0.32000807f, -0.71800500f, -0.12973320f, 0.15118320f, -0.20610446f, -0.01183132f, 
    0.22535767f, 0.08308276f, 0.09640084f, 0.06634651f, -0.12310705f, 0.36053890f, -0.26730686f, -0.01872132f, 
    -0.12255478f, -0.36036199f, 0.30552641f, -0.03740048f, 0.00627524f, 0.02691783f, -0.35587114f, -0.04179208f, 
    0.38856667f, -0.15210685f, -0.04040122f, -0.05671939f, -0.01595821f, -0.46970028f, -0.03704248f, 0.37862459f, 
    0.05481057f, 0.09087241f, -0.40892196f, -0.61845428f, -1.03515637f, 0.55627364f, -0.02879380f, 0.02161063f, 
    -0.07392934f, 0.13984142f, 0.22320896f, 0.16066861f, -0.08034755f, 0.08322468f, 0.24383491f, 0.16328514f, 
    -0.64938188f, 0.08275407f, -0.46347311f, 0.23710318f, -0.07948387f, -0.14633882f, -0.13058640f, 0.21752430f, 
    -0.35334325f, -0.04300812f, -0.29180557f, -0.13582261f, -1.17057645f, -0.18016030f, -0.24200131f, 0.97588748f, 
    0.19822195f, -0.37697870f, 0.09488203f, 0.00942089f, 0.07153136f, -0.01218252f, 0.29543453f, 0.15156242f, 
    -0.20493795f, -0.20381108f, -0.38515264f, -0.00868285f, -0.03980121f, -0.11400539f, -0.02032075f, -0.10442924f, 
    0.10019720f, -0.16891706f, -0.08255234f, 0.03657449f, -0.11586693f, -0.56454754f, 0.10685354f, -0.53310210f, 
    0.13836561f, -0.08752690f, 0.17229079f, -0.22993112f, -0.14169405f, 0.13188103f, 0.08211214f, 0.06591588f, 
    0.05985222f, 0.10634712f, -0.16290838f, 0.05217145f, -0.06394963f, -0.07200991f, -0.11386270f, -0.06113913f, 
    -0.26791221f, -0.04912636f, -0.11583723f, -0.33375037f, 0.13757603f, -0.09619563f, 0.29922086f, -0.44635686f, 
    -0.18714949f, 0.01644366f, 0.41328558f, -0.08093990f, 0.16995467f, 0.14932632f, 0.02522360f, -0.13864006f, 
    -0.19023934f, 0.41874841f, -0.36002833f, -0.04714756f, 0.22666608f, -0.10351735f, 0.16345252f, -0.16932163f, 
    0.01904870f, 0.04994448f, -0.30230880f, -0.25265473f, 0.14720838f, 0.10003646f, 0.71277028f, 0.19896688f, 
    0.02079574f, -0.26095381f, 0.20110993f, -0.09436646f, -0.03530572f, -0.15827973f, 0.12244712f, -0.27317303f, 
    -0.32278079f, 0.34235159f, 0.03643587f, 0.03200899f, 0.18179488f, 0.07373317f, 0.03115746f, -0.14669102f, 
    -0.24988076f, 0.12745593f, -0.00140306f, -0.07682725f, -0.18633318f, -0.90916109f, -0.10877123f, 0.37201285f, 
    -0.40678647f, 0.08946994f, -0.13131249f, -0.47395104f, 0.03443927f, 0.01059585f, 0.16075666f, -0.09324949f, 
    0.11274008f, 0.01558272f, 0.27281088f, 0.12119082f, -0.19984801f, -0.12633476f, 0.11541042f, 0.09998222f, 
    0.03173368f, 0.17271571f, 0.29913720f, -0.15292986f, 0.39259994f, 0.13430524f, 0.02368286f, 0.16473421f, 
    -0.24996899f, -0.31507871f, 0.11319248f, 0.02443003f, -0.15392061f, -0.01114620f, 0.14801300f, -0.08777783f, 
    0.24878153f, 0.55769062f, -0.71039009f, -0.13458614f, 0.06005222f, 0.10261662f, 0.05708336f, 0.10921855f, 
    -0.02558354f, 0.17749120f, -0.18679313f, -0.13238724f, 0.69355744f, -1.11712396f, 0.98071694f, 0.26740742f, 
    0.47871816f, -0.07209927f, 0.29024678f, 0.25192663f, 0.18660936f, 0.14448175f, 0.16163822f, 0.08628487f, 
    -0.06751917f, -0.14217088f, 0.02051560f, -0.75454104f, -0.41050342f, -0.09937423f, 0.18326141f, 0.11650510f, 
    -0.01614565f, 0.15055168f, -0.06196012f, 0.13231423f, -0.35112068f, -0.28899470f, -0.17713423f, 0.15499757f, 
    0.40725616f, 0.33549020f, -0.01181988f, 0.15418257f, -0.01909651f, 0.06869222f, 0.17530932f, 0.16051559f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.34371409f, 0.12960091f, 0.18850635f, -0.17163791f, -0.08579139f, 0.05805174f, 0.06788881f, -0.20977634f, 
    0.00254935f, 0.02048431f, 0.09245748f, -0.11237369f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
