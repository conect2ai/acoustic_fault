#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.47625118f, -0.14346428f, 0.03939810f, -0.18318920f, -0.68849051f, -0.46290612f, -0.52730739f, -0.54608393f, 
    -0.35499689f, -0.53686881f, 0.31566444f, -0.31712306f, -0.19778818f, 0.46688268f, 0.20788988f, 0.16095431f, 
    -0.13971959f, -0.00462512f, -0.13620843f, -0.36168462f, -0.36813238f, -0.25263149f, -0.02453021f, -0.34437159f, 
    -0.03791540f, -0.39434332f, -0.24666451f, 0.12347738f, 0.55933672f, 0.18860996f, 0.05063495f, 0.54854387f, 
    -0.44566283f, -0.36178216f, -0.17238961f, -0.01045456f, 0.01893669f, 0.14313419f, 0.10546878f, -0.01277343f, 
    -0.15114531f, -0.06404149f, -0.19184256f, 0.01423434f, 0.34340152f, -0.06326366f, -0.15266128f, -0.00394636f, 
    0.04423843f, -0.09578490f, 0.03631326f, -0.24305864f, 0.28083482f, 0.28423071f, 0.19887264f, -0.50713617f, 
    -0.44942561f, 0.42001727f, 0.39681175f, -0.00359664f, 0.19871731f, 0.02335294f, -0.16484253f, -0.00356983f, 
    -0.27254966f, 0.19590496f, -0.05026213f, 0.22442244f, -0.17000908f, -0.38115388f, -0.11172938f, -0.05080963f, 
    -0.13715985f, -0.06441607f, -0.04631186f, -0.19066386f, 0.60968310f, 0.55664593f, 0.43864110f, 0.32273346f, 
    -0.61823207f, -0.43961531f, -0.38476428f, -0.12962116f, 0.06518035f, -0.60442257f, 0.10370252f, -0.19420558f, 
    0.01446922f, 0.02721407f, 0.11330125f, 0.26646802f, -0.29485488f, -0.05501533f, 0.33265564f, -0.06505013f, 
    0.06006922f, -0.10993744f, 0.16263682f, -0.16379985f, 0.41727608f, 0.41526544f, -0.69074655f, -0.78317451f, 
    -0.74339145f, 0.31985217f, -0.24694948f, -0.20205353f, 0.41311714f, 0.09677147f, 0.32832691f, 0.39179233f, 
    -0.04998535f, 0.23909116f, -0.08208453f, -0.00236882f, 0.06766757f, 0.03568291f, 0.01701720f, -0.17291626f, 
    0.15862203f, -0.09036031f, -0.03331215f, -0.08456670f, 0.18350671f, -0.92383820f, -0.19871739f, -0.55348659f, 
    -0.62774742f, -0.66530353f, 0.51315010f, 0.45632645f, 0.01338109f, 0.26845336f, 0.62175649f, 0.17512916f, 
    0.37310386f, -0.12457558f, -0.10303634f, -0.37591451f, -0.17590284f, 0.18031263f, -0.00458812f, 0.14699461f, 
    -0.09592106f, 0.06275865f, -0.16267852f, -0.13276130f, 0.03528155f, -0.34183863f, -0.42080581f, -0.00839960f, 
    -0.06216412f, 0.31709850f, 0.03824378f, 0.39011794f, -0.27539977f, 0.17841308f, 0.44859067f, 0.41871139f, 
    -0.08629002f, -0.11192688f, -0.22967654f, 0.12427706f, 0.20404246f, 0.11853635f, -0.26632786f, -0.14083309f, 
    0.17196836f, -0.13995080f, -0.05912977f, 0.03316484f, -0.07024223f, -0.09928842f, -0.20689547f, -1.12727106f, 
    0.71351296f, 0.63916767f, -0.30417684f, 0.15985821f, 0.47946054f, 0.46145532f, -0.10192531f, -0.16180454f, 
    -0.37039259f, -0.05665026f, -0.15113799f, 0.03616322f, -0.43313470f, -0.00148571f, 0.03374162f, -0.17136708f, 
    0.09524845f, 0.17273489f, 0.16654781f, 0.06206367f, -0.01797308f, 0.18544754f, -0.28647888f, -0.24274114f, 
    -0.14952767f, 0.15139024f, -0.18790947f, 0.24694823f, 0.07921625f, -0.43165734f, 0.09134655f, 0.23271835f, 
    -0.06595686f, 0.15840799f, 0.37267745f, -0.28842843f, -0.32132119f, 0.46670836f, -0.05319872f, 0.02708357f, 
    -0.12335849f, -0.20843142f, 0.02767848f, 0.14369406f, -0.31477910f, 0.30589530f, -0.16281766f, -0.03987906f, 
    0.30065334f, 0.07984592f, -0.15611233f, -0.63304991f, -0.22701456f, 0.81895620f, -0.56517184f, -0.49040985f, 
    0.95917380f, -0.34877139f, -0.37733805f, 0.16713928f, -0.18430260f, -0.06392527f, 0.19494548f, -0.36615914f, 
    0.27366459f, 0.15927288f, -0.38935047f, -0.05381159f, 0.04594512f, -0.30004266f, -0.02766361f, -0.03841965f, 
    -0.12813428f, 0.01466956f, -0.76251173f, -0.47816515f, -0.11671998f, -0.08408955f, 0.44171667f, 0.14618747f, 
    -0.47042865f, -0.62943798f, 0.40110847f, -0.39826706f, 0.13841179f, 0.27770334f, 0.18905070f, -0.11468095f, 
    -0.22893184f, 0.23418213f, -0.01986011f, 0.18033320f, -0.06975196f, 0.11734684f, 0.30111164f, -0.15235013f, 
    -0.08061104f, -0.20778711f, 0.32520205f, 0.23115706f, -0.90319222f, -0.08816508f, -0.07826591f, -0.56264639f, 
    -0.27161378f, -0.31637138f, -0.35679269f, -0.37115100f, -0.37960890f, 0.05848941f, 0.13723925f, -0.23159213f, 
    -0.32284015f, -0.53644186f, -0.01852140f, -0.13975483f, -0.10891657f, -0.26259184f, -0.23927528f, -0.34195298f, 
    0.17013216f, -0.05910177f, -0.21441565f, -0.32200730f, 0.05472461f, -0.26360974f, -0.16097748f, 0.21777304f, 
    -0.25018319f, 0.06923669f, 0.10049009f, -0.21381199f, -0.15468819f, 0.12464006f, 0.25593477f, -0.34631458f, 
    -0.07057824f, 0.23074009f, -0.16842619f, 0.22548531f, -0.22396666f, -0.41567934f, -0.04278393f, 0.15138115f, 
    -0.10038747f, 0.06299510f, 0.12217522f, 0.30998147f, 0.38167787f, -0.69027114f, -0.82441616f, -0.54350770f, 
    -0.00931828f, -0.15282935f, 0.12309691f, 0.41038427f, -0.07825523f, 0.19260040f, 0.86110264f, 0.18144353f, 
    -0.08043509f, 0.07194261f, 0.10637116f, 0.06003101f, 0.01640332f, 0.09329249f, -0.26577610f, -0.26262990f, 
    -0.04997408f, 0.11775577f, -0.14667542f, 0.35595700f, 0.06034436f, 0.14513728f, 0.30216578f, 0.07020372f, 
    0.03956499f, -0.02969681f, 0.38635695f, 0.07976960f, -0.46498907f, -0.38799796f, -0.00667713f, -0.24611491f, 
    0.00500612f, -0.16727281f, 0.02915180f, 0.34644151f, 0.03217848f, 0.04290107f, -0.21760957f, 0.04602572f, 
    -0.10234940f, -0.33050743f, 0.03165720f, 0.17783578f, 0.17081976f, 0.26764521f, 0.13870092f, -0.37498161f, 
    0.47270334f, 0.14202741f, -0.02674183f, -0.56167799f, -0.24785247f, -0.53880805f, -0.34906512f, -0.18477890f, 
    -0.71364969f, -0.29131255f, 0.30389547f, -0.24178870f, -0.37914833f, -0.21841066f, 0.03253138f, -0.31783298f, 
    -0.03063430f, -0.04331290f, -0.22972400f, 0.10550991f, 0.16130958f, -0.17775938f, -0.04885700f, -0.11002871f, 
    0.52129537f, -0.16135857f, -0.23206688f, 0.24232255f, -0.17996852f, 0.39560625f, 0.36966342f, 0.21316798f, 
    -0.35532284f, -0.61786574f, 0.08217055f, -0.12779385f, -0.02889798f, 0.03981447f, -0.04844728f, -0.06491128f, 
    -0.51810008f, 0.23878604f, 0.29863572f, 0.39484605f, 0.22472554f, -0.03268857f, 0.17253903f, -0.29665467f, 
    -0.62926567f, -0.80995709f, -0.27351764f, -0.91370094f, -0.42799321f, -0.44710711f, 0.48249349f, 0.69280833f, 
    -0.05421860f, -0.48870221f, 0.00213084f, 0.03133425f, -0.32110134f, -0.05138484f, -0.17813337f, 0.37287730f, 
    0.02184084f, 0.06144078f, -0.12781805f, 0.03123915f, -0.43041265f, -0.38998437f, -0.36956081f, 0.16974972f, 
    -0.00663550f, -0.04566234f, -0.04660914f, 0.46592841f, -0.59311193f, -0.56124985f, -0.41163164f, 0.23147953f, 
    0.03740099f, 0.63860446f, -0.34724411f, -0.49513349f, -0.09136108f, -0.14873980f, 0.30439433f, 0.02389269f, 
    -0.03566863f, -0.06622992f, -0.19779745f, -0.11909459f, -0.08918916f, -0.32524210f, 0.34844911f, 0.22690065f, 
    0.16343008f, 0.34846878f, -0.04581599f, -0.03305414f, 0.24604037f, 0.31830141f, 0.35434517f, 0.33151755f, 
    0.00786017f, 0.03047695f, -0.07078896f, 0.10455586f, -0.16183674f, -0.11266737f, -0.04625910f, 0.34461239f, 
    0.11580350f, 0.04865919f, -0.02268113f, -0.02023209f, 0.08000683f, -0.28874239f, 0.02234506f, 0.07731428f, 
    -0.18807703f, -0.01827570f, 0.13160701f, -0.18509589f, 0.41906413f, 0.48616490f, -0.34825671f, -0.02284116f, 
    0.38299575f, 0.06424649f, -0.25957707f, -0.06009491f, 0.04043816f, -0.64422154f, -0.05567222f, 0.18423520f, 
    0.03968092f, -0.00480705f, 0.16046664f, -0.10907360f, 0.33559349f, 0.04291511f, -0.15798859f, 0.10255915f, 
    -0.44549406f, 0.12902106f, 0.14853440f, 0.07078093f, -0.49120468f, -0.64402217f, -0.08791234f, -0.81353104f, 
    -0.65626496f, -0.23829012f, 0.48550305f, 0.34055516f, 0.02001278f, -0.03917797f, -0.09683214f, -0.29377371f, 
    0.08417726f, -0.30020833f, -0.30595285f, -0.32267472f, -0.23483522f, -0.47684294f, 0.00141610f, 0.31471303f, 
    0.01436747f, 0.25194755f, 0.19212668f, -0.40373600f, -0.15200710f, 0.31365442f, -0.36958739f, 0.47262540f, 
    0.12923808f, 0.69605839f, -0.46707848f, -0.69576132f, -0.74647468f, -0.07388128f, 0.31690314f, 0.67157960f, 
    0.27559477f, -0.08553261f, -0.15020375f, -0.04734480f, 0.32106251f, -0.21946734f, 0.20532240f, -0.05563365f, 
    -0.24616058f, -0.36059538f, 0.04093400f, 0.07268499f, 0.17236637f, 0.03377859f, -0.19893780f, -0.28314915f, 
    -0.15352486f, -0.23584287f, 0.33352908f, 0.48845989f, 0.24083407f, 0.40667444f, -0.46795434f, -0.24876939f, 
    0.21981438f, -0.25153220f, 0.46418017f, -0.47414199f, 0.20481157f, -0.17264844f, 0.01827935f, -0.28414917f, 
    0.04895375f, 0.00097043f, 0.19267200f, -0.36063534f, 0.27410692f, 0.12129769f, -0.29161659f, -0.14800733f, 
    0.43532580f, 0.25094381f, -0.21504653f, -0.38668510f, 0.01594734f, -0.27081621f, 0.00627897f, -0.03225400f, 
    0.10703943f, 0.07692685f, 0.17416069f, -0.32813630f, 0.28453389f, -0.29732990f, 0.20328793f, 0.18551368f, 
    0.29394177f, 0.08544446f, -0.30678177f, -0.01112014f, 0.15974514f, 0.15764354f, -0.45891398f, 0.25750166f, 
    -0.14264679f, 0.33607483f, 0.32832435f, -0.03018552f, 0.06657379f, 0.10104486f, -0.55809277f, -0.44947413f, 
    -0.19731461f, 0.62816006f, 0.23383550f, -0.18710083f, 0.05218568f, -0.00734586f, 0.01904058f, 0.00936734f, 
    -0.11505412f, 0.07895006f, -0.12609485f, -0.08708408f, -0.17130014f, -0.01471561f, -0.22207478f, -0.08589797f, 
    0.24691135f, -0.28057781f, 0.43081808f, -0.14049134f, -0.16735716f, 0.47001451f, 0.01318343f, 0.22175245f, 
    0.07367156f, -0.02362468f, -0.07900951f, 0.09357201f, 0.05721857f, 0.12792704f, -0.06559269f, -0.09307776f, 
    -0.12161334f, -0.04497641f, -0.16899891f, 0.24859720f, -0.07288257f, -0.14037316f, -0.06341901f, 0.18799387f, 
    0.14320700f, 0.39447874f, 0.15281621f, -0.53359210f, -0.19019285f, -0.54329258f, -0.39554811f, -0.27865449f, 
    0.55005896f, 0.13500661f, 0.42135096f, 0.03545269f, 0.47781089f, 0.14918281f, 0.46030393f, -0.09149122f, 
    0.17024887f, 0.04831795f, -0.50661576f, -0.21123819f, -0.13272898f, 0.09558164f, -0.09457482f, 0.02365452f, 
    -0.06400918f, 0.14192685f, 0.26915950f, 0.36992279f, 0.77389562f, -0.59768933f, -0.53222913f, 0.18575409f, 
    -0.18915227f, 0.78363258f, 0.27250195f, -0.18407100f, -0.03798510f, -0.32194111f, -0.18657687f, 0.19256395f, 
    -0.07656136f, -0.21899012f, -0.06459422f, -0.23385969f, 0.21079199f, 0.16441128f, -0.17386994f, -0.08843243f, 
    0.26793340f, -0.09814181f, -0.11613558f, 0.11513266f, 0.18906574f, -0.78805536f, -0.83660275f, -0.31013003f, 
    0.61656928f, 0.45041540f, -0.16281702f, -0.36893073f, -0.31811076f, -0.00564859f, -0.04520914f, 0.51981688f, 
    -0.42205504f, -0.13387927f, 0.68251038f, -0.07444078f, -0.01572431f, 0.09803753f, 0.32815078f, -0.14490813f, 
    0.05972872f, -0.12488230f, 0.09821877f, 0.23908454f, 0.13491374f, -0.21731240f, -0.07780226f, 0.01215044f, 
    -0.58376545f, -0.32840788f, -0.01641891f, -0.16836837f, 0.05943962f, -0.00810464f, -0.10955933f, -0.13353413f, 
    -0.64646798f, -0.61393708f, -0.13462152f, 0.29075795f, 0.04970736f, 0.38626757f, -0.28688067f, -0.24024321f, 
    -0.12887445f, -0.23385359f, -0.31031001f, -0.25351208f, -0.26452115f, -0.46178466f, -0.47280067f, 0.49819043f, 
    -0.31522653f, 0.25531939f, 0.13126238f, -0.05443329f, -0.24771683f, 0.56086117f, 0.06313965f, -0.52608436f, 
    -0.35430273f, 0.17453969f, 0.15318099f, 0.01926618f, -0.59852177f, 0.32600254f, -0.25429541f, 0.37253368f, 
    0.05298872f, 0.20562771f, -0.31192333f, 0.02351759f, -0.17615341f, -0.29213497f, -0.02209713f, 0.38149387f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05443178f, -0.04250113f, 0.23952469f, -0.01352600f, 0.17368901f, -0.01117383f, -0.16141003f, 0.00397778f, 
    0.31010899f, 0.06276146f, -0.02929311f, -0.13564405f, 0.07178638f, 0.18898498f, -0.19475357f, -0.15487045f, 
    0.29238656f, 0.11189163f, 0.08484530f, -0.17513596f, -0.22099298f, 0.02589309f, 0.08082826f, 0.18497708f, 
    0.21193129f, 0.26902911f, -0.07258555f, -0.05654188f, 0.22384079f, 0.09343898f, 0.17825085f, 0.12649108f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.09446631f, -0.18918368f, -0.16986515f, 0.01696335f, -0.00712157f, 0.06249607f, 0.18164252f, 0.09074061f, 
    0.04779039f, 0.02772827f, 0.06350789f, -0.04036529f, 0.15836467f, -0.02934901f, 0.14086831f, 0.08695232f, 
    -0.05024511f, 0.13252175f, 0.04082054f, -0.06567847f, -0.08787771f, -0.06037833f, 0.03509342f, -0.05937994f, 
    0.16023880f, 0.18734717f, 0.03942928f, 0.21049018f, 0.00207911f, 0.04532299f, 0.09466204f, -0.00973838f, 
    0.09513063f, 0.18976939f, 0.06703762f, 0.03882816f, 0.29714820f, -0.01244940f, -0.15439329f, 0.05833172f, 
    0.10928861f, -0.02548720f, 0.13183562f, -0.15720910f, -0.09922545f, -0.19161923f, 0.09030052f, -0.00434559f, 
    -0.11251040f, 0.17291984f, 0.14270453f, -0.21688507f, 0.02690011f, 0.03000185f, 0.06403269f, 0.09609055f, 
    -0.04021313f, 0.18755700f, -0.03566315f, -0.07827275f, -0.13478383f, -0.06537845f, 0.14165393f, -0.21002623f, 
    -0.07964037f, -0.07971135f, -0.13480693f, 0.02917932f, 0.04078047f, -0.02374600f, 0.06578340f, 0.09382024f, 
    0.14081687f, 0.23310739f, 0.15624353f, 0.13276686f, -0.00368199f, -0.00592300f, 0.02789441f, -0.03788801f, 
    0.02439937f, -0.01554779f, 0.05452541f, -0.05960732f, 0.01649763f, 0.06148769f, 0.30285019f, 0.37684849f, 
    -0.16570494f, 0.16902497f, 0.04050809f, 0.02947284f, 0.15303883f, 0.05032619f, 0.14220542f, -0.08909871f, 
    -0.01907056f, 0.22955528f, 0.14177832f, 0.15651438f, -0.04850587f, 0.06294743f, 0.08801290f, 0.00145640f, 
    -0.04538294f, -0.04315226f, 0.19899511f, 0.01283883f, -0.33063182f, -0.19360372f, -0.38360378f, -0.11441682f, 
    0.01896415f, -0.14074470f, 0.18352500f, 0.19095455f, -0.04948806f, 0.19915290f, 0.03668710f, -0.06109735f, 
    -0.22673234f, -0.25823703f, -0.22812374f, -0.28380913f, -0.10343145f, -0.12353741f, -0.00572613f, -0.00688114f, 
    -0.04072722f, -0.12527235f, -0.17249632f, -0.09186811f, 0.01883812f, -0.11475956f, -0.09789561f, -0.14072119f, 
    0.12066802f, 0.06785954f, 0.07470819f, 0.10234404f, 0.02825823f, 0.10847724f, 0.02997349f, -0.01560696f, 
    -0.06655937f, -0.00673265f, 0.11118432f, -0.13899975f, -0.01341207f, 0.02939355f, -0.04052717f, -0.04082777f, 
    -0.16036931f, -0.16022161f, -0.05392063f, -0.14099653f, 0.15909369f, 0.09355309f, 0.20769899f, 0.03197402f, 
    -0.13345404f, -0.03458944f, -0.15477918f, -0.02103884f, -0.09877846f, -0.10758765f, 0.02890792f, -0.10579778f, 
    0.08250640f, 0.01456209f, 0.16773492f, 0.08658966f, 0.02494977f, -0.08686808f, -0.02580325f, -0.18969023f, 
    -0.18677095f, -0.13648446f, -0.14157335f, -0.10879406f, -0.25400370f, -0.14320414f, -0.37574148f, -0.03538069f, 
    0.05207676f, -0.01153682f, 0.08747642f, 0.08875084f, -0.12543917f, -0.08090040f, 0.04997744f, -0.07218562f, 
    0.15246256f, 0.12116835f, 0.21574791f, 0.01316505f, -0.00077803f, 0.22174576f, -0.15315180f, 0.06652608f, 
    0.34442148f, -0.02823464f, 0.08689331f, 0.28062433f, -0.33226478f, -0.41275251f, -0.09253749f, -0.12076894f, 
    -0.07052675f, 0.08386945f, -0.19471481f, 0.06276063f, -0.01267316f, -0.16724400f, -0.10660651f, -0.00985998f, 
    -0.16973673f, -0.09629508f, -0.19965895f, -0.25035399f, 0.06413054f, -0.13606301f, 0.01555620f, -0.05178434f, 
    0.02194065f, -0.15377967f, -0.18369219f, -0.10412794f, 0.19508544f, 0.09528014f, 0.21715830f, 0.23352022f, 
    0.02935746f, 0.01785829f, 0.06349053f, 0.02238712f, 0.02734186f, 0.01376789f, 0.14333776f, 0.07341395f, 
    0.05935183f, 0.04442178f, 0.08385422f, 0.02806334f, 0.25022724f, 0.00708585f, 0.23216124f, 0.09796788f, 
    -0.02830737f, -0.11519338f, -0.13772538f, 0.02673184f, -0.21849945f, -0.25964195f, -0.15302424f, -0.22254264f, 
    -0.02553614f, -0.16920133f, 0.02913482f, 0.00831086f, -0.12557817f, -0.03440236f, 0.02812519f, 0.17441848f, 
    0.30414212f, 0.15591075f, 0.14718448f, 0.08421644f, -0.09918547f, 0.07683592f, 0.00434772f, -0.04758439f, 
    -0.01692657f, -0.18405631f, 0.01005832f, -0.20759375f, 0.11917097f, -0.02287929f, 0.23194049f, 0.09481502f, 
    0.04881556f, 0.13900329f, -0.03314276f, 0.04350241f, 0.11211839f, 0.09066147f, 0.11478304f, -0.03224731f, 
    0.10433961f, 0.17855173f, -0.03437775f, -0.04495797f, 0.18744425f, 0.09444275f, 0.11533580f, -0.05445543f, 
    0.08145000f, 0.04446957f, -0.11821910f, 0.01494461f, 0.36172196f, 0.16842523f, 0.12049486f, 0.16501623f, 
    -0.01091623f, -0.03246364f, 0.09242233f, -0.04119284f, -0.03248065f, -0.08081666f, 0.16100490f, 0.03753027f, 
    0.20152423f, 0.10001440f, 0.19623424f, 0.14001368f, 0.07729540f, 0.03424746f, -0.04815378f, 0.04561603f, 
    -0.04688166f, 0.04616627f, -0.09816088f, 0.05018845f, 0.02112859f, 0.06630834f, 0.25572824f, 0.01465384f, 
    -0.10630752f, -0.27267542f, -0.04840314f, -0.07305146f, -0.01649173f, -0.03234250f, -0.11316018f, -0.06158346f, 
    0.17099360f, -0.27619839f, 0.05907596f, 0.10257473f, 0.09035702f, -0.00664151f, -0.10517885f, -0.02869395f, 
    -0.03019151f, 0.03903950f, -0.06045032f, 0.23088931f, 0.08783169f, -0.27908659f, 0.00327938f, -0.06801892f, 
    0.05297744f, -0.14767434f, -0.13076928f, 0.16742827f, -0.12485889f, -0.19350308f, -0.01440395f, -0.20950972f, 
    -0.03697487f, -0.19862105f, -0.14002590f, -0.06433555f, 0.06821501f, 0.01531702f, 0.01696508f, 0.06543145f, 
    0.01911783f, 0.16575579f, 0.18358457f, 0.19966690f, 0.31386593f, -0.14640701f, 0.17909780f, -0.01604185f, 
    0.11702316f, 0.04351337f, 0.24574439f, -0.02248105f, 0.15974149f, 0.07152092f, -0.04754166f, 0.07289340f, 
    0.05684296f, 0.01062958f, 0.27311260f, 0.08210468f, -0.06575694f, -0.05449639f, -0.02838814f, 0.09865469f, 
    0.03922736f, 0.02513724f, 0.07182582f, -0.01564056f, -0.06915857f, 0.11840553f, -0.05124187f, 0.02152634f, 
    -0.00839709f, 0.02891393f, -0.00687934f, -0.11847185f, 0.06052757f, 0.02405074f, -0.03176814f, 0.03835768f, 
    -0.09434038f, -0.00915408f, 0.09108694f, -0.11270924f, -0.13117707f, 0.03265290f, -0.01099901f, -0.01743827f, 
    0.04507695f, 0.05629263f, 0.04065033f, 0.08454464f, 0.40583500f, 0.47597441f, 0.22168104f, -0.18691806f, 
    -0.06523483f, -0.25608656f, -0.01230728f, -0.13226117f, -0.04326507f, 0.07955126f, -0.02259650f, -0.06033555f, 
    -0.43779019f, -0.38701606f, 0.04629052f, 0.10132784f, 0.00638431f, 0.05499602f, 0.08084373f, 0.02543199f, 
    -0.07573619f, 0.10412115f, -0.08451965f, -0.14995570f, 0.30906454f, 0.02314216f, -0.27599072f, -0.07858831f, 
    0.07439945f, -0.02795421f, 0.03888310f, -0.02656584f, -0.01275341f, 0.00728281f, 0.11753775f, 0.05854651f, 
    -0.19766560f, -0.01922532f, -0.17332603f, -0.00387328f, -0.01261872f, -0.03585108f, 0.00131016f, -0.12290505f, 
    -0.08265997f, 0.04432578f, -0.03750946f, -0.05695866f, 0.23277698f, -0.17540877f, 0.08574349f, -0.11497988f, 
    -0.12454274f, 0.17482589f, 0.04674196f, -0.10166725f, 0.02083945f, 0.11164784f, -0.06717666f, 0.12678611f, 
    0.01243266f, -0.07753170f, 0.00674013f, -0.04095598f, -0.14188421f, 0.08029270f, 0.00789050f, -0.04545034f, 
    0.05929319f, 0.06144493f, 0.00098712f, -0.08863302f, 0.26820675f, -0.13385615f, 0.18698102f, 0.16753036f, 
    -0.05978454f, 0.16554581f, -0.05999414f, 0.08004687f, -0.08874243f, 0.03116077f, -0.04939795f, 0.02204502f, 
    0.01785959f, 0.25871766f, -0.13661878f, -0.00679661f, -0.03221149f, -0.00517106f, -0.05759817f, -0.09413083f, 
    -0.07096264f, -0.06629842f, -0.04887418f, -0.11883321f, -0.13015069f, 0.01007784f, -0.16323781f, 0.14526419f, 
    0.06730969f, -0.04386820f, -0.11054364f, 0.15884319f, -0.02058166f, 0.09350541f, 0.00502622f, 0.01979240f, 
    0.05348555f, 0.16763997f, -0.04231272f, -0.02044630f, 0.16462936f, 0.03124387f, -0.11618251f, 0.03661251f, 
    -0.00323216f, 0.02525576f, -0.01503284f, -0.03059879f, -0.10479166f, 0.33745521f, -0.15875609f, 0.00927880f, 
    0.10865781f, -0.04390513f, 0.08970717f, -0.05194767f, 0.01445040f, -0.03064516f, -0.01971493f, 0.02346110f, 
    0.20079991f, 0.07803615f, -0.05794210f, 0.01701632f, 0.06128072f, 0.01579169f, -0.06285080f, -0.07421676f, 
    -0.11800545f, 0.07582237f, 0.07249543f, 0.00877210f, 0.12441368f, -0.10845187f, 0.01891792f, 0.01433117f, 
    -0.03466782f, -0.04703864f, 0.01343813f, 0.14693765f, -0.02521010f, 0.00541538f, -0.05862207f, -0.00740551f, 
    0.08744684f, -0.03639354f, 0.08717944f, 0.05504190f, -0.14029536f, 0.05442248f, -0.04094611f, 0.11368088f, 
    0.02008424f, -0.03919599f, 0.03222190f, 0.00324916f, 0.27415439f, -0.01620335f, 0.02072107f, 0.28012198f, 
    0.13651320f, -0.00356791f, 0.01857847f, -0.03497128f, -0.03283113f, 0.04755043f, 0.04814697f, -0.01062118f, 
    0.19014171f, -0.12653100f, 0.19583349f, 0.26763898f, -0.04569577f, 0.12863337f, 0.03236347f, 0.11990684f, 
    -0.05791800f, 0.04276890f, 0.04176353f, 0.04115910f, 0.10107112f, 0.06326681f, 0.04204666f, -0.11109942f, 
    -0.03602346f, -0.09418053f, -0.05434124f, -0.11713933f, 0.16553931f, 0.18492469f, 0.03148143f, 0.10115371f, 
    0.07420602f, 0.04344154f, 0.02821793f, 0.02064760f, 0.01994508f, 0.11798666f, -0.19668050f, 0.06451309f, 
    -0.06806251f, 0.29592723f, -0.08638938f, 0.04555177f, 0.44826686f, 0.05182176f, 0.02776221f, 0.16729389f, 
    0.09614781f, 0.15813693f, -0.11487431f, 0.23337024f, -0.08555695f, 0.07455143f, 0.12173323f, -0.07547837f, 
    0.07977687f, 0.31228268f, 0.12314023f, -0.33504474f, 0.06920525f, -0.00196271f, 0.09992062f, -0.16279183f, 
    -0.08992558f, -0.06788000f, 0.12931639f, 0.00421063f, -0.07553007f, 0.27507678f, -0.31163955f, 0.06681884f, 
    -0.10860306f, 0.13585491f, -0.20178415f, -0.06052716f, -0.08865244f, 0.15493788f, 0.04674959f, 0.17049502f, 
    -0.02928715f, 0.00374608f, 0.13071139f, 0.01422889f, 0.06738480f, 0.07636096f, 0.11075301f, 0.02976262f, 
    -0.16287516f, 0.10841816f, 0.01341341f, -0.10202651f, 0.01708483f, -0.03979080f, 0.03322490f, 0.08234721f, 
    -0.05996169f, -0.06961571f, -0.08509139f, -0.08780288f, -0.01944971f, 0.00782757f, 0.00706567f, 0.07306793f, 
    0.00421286f, 0.12453630f, 0.00524298f, 0.08656258f, 0.07367088f, -0.09682236f, -0.08580037f, -0.06497111f, 
    -0.17246434f, 0.10754134f, 0.09049015f, -0.01978516f, 0.00650401f, 0.07479649f, -0.08263820f, -0.03413320f, 
    0.13262811f, -0.03872583f, 0.08305109f, 0.06542600f, -0.01576791f, 0.21358949f, 0.04731410f, -0.15772255f, 
    0.08667796f, 0.25408423f, -0.18368009f, 0.29614830f, 0.10599554f, 0.00112596f, -0.08958570f, 0.00791413f, 
    -0.09222691f, 0.07673874f, 0.02362869f, 0.10511833f, -0.02530411f, 0.36557552f, -0.16702588f, 0.10509089f, 
    -0.06302027f, 0.02660975f, 0.07878593f, -0.02238175f, -0.12603882f, -0.05070129f, -0.02560912f, -0.07747154f, 
    0.25093439f, 0.09621929f, 0.05989422f, 0.14949600f, 0.07840310f, 0.04736450f, -0.10480629f, 0.08089056f, 
    0.02929731f, 0.12138686f, 0.05863103f, 0.08843098f, -0.21188900f, 0.21852566f, 0.15334125f, 0.12538666f, 
    -0.19875766f, -0.02894346f, -0.00877214f, -0.04370773f, 0.08076384f, 0.07059997f, -0.06209187f, -0.08657899f, 
    -0.07271953f, 0.07331958f, -0.01329771f, 0.11603297f, -0.02659506f, -0.10436025f, -0.05313066f, 0.11785001f, 
    -0.01588184f, 0.05788083f, -0.09240690f, -0.04275364f, -0.08216731f, -0.11821408f, 0.11323947f, -0.06157686f, 
    -0.14049782f, 0.15721437f, -0.08173885f, -0.07285769f, 0.03152904f, 0.18666895f, -0.05135303f, -0.07568959f, 
    0.07660559f, 0.15258457f, -0.08662369f, 0.04355608f, 0.01302794f, 0.00735158f, -0.02745140f, -0.02259803f, 
    0.05113949f, -0.08930907f, 0.03338125f, -0.04406862f, 0.38307753f, -0.21821442f, -0.40702376f, -0.07347269f, 
    -0.07773484f, -0.10072171f, 0.12387153f, -0.02194096f, -0.07102329f, 0.05851315f, -0.00722244f, -0.07196728f, 
    -0.09636592f, 0.04648652f, 0.30001318f, -0.21905735f, -0.00071015f, -0.03839199f, 0.11943424f, 0.00666049f, 
    -0.03819851f, 0.01648624f, 0.01214632f, -0.00000441f, 0.16323568f, 0.13763666f, 0.00841542f, -0.27407554f, 
    -0.15074462f, -0.20634583f, -0.17538694f, 0.07357986f, 0.10984809f, -0.07934988f, -0.03053821f, -0.04353898f, 
    -0.03377904f, 0.10812972f, -0.03476779f, 0.07780677f, -0.07695322f, -0.08952280f, -0.09207912f, -0.07827468f, 
    0.00360449f, 0.05873664f, -0.05720808f, 0.00648773f, -0.03716128f, -0.37732899f, 0.12493288f, 0.03216714f, 
    -0.04299487f, 0.01451880f, 0.10831355f, 0.00906180f, 0.15087172f, -0.15565547f, -0.04327107f, -0.11886613f, 
    0.12981409f, 0.00264302f, 0.14427750f, 0.12321153f, -0.02230774f, 0.04376007f, 0.12176793f, 0.01301343f, 
    0.06383036f, 0.15090737f, -0.14386521f, -0.07295141f, -0.33762100f, 0.05683650f, 0.19290321f, 0.04493135f, 
    -0.01320311f, 0.12428373f, -0.04447733f, 0.09114930f, -0.03226518f, 0.09345572f, -0.06781442f, 0.07762135f, 
    -0.35718611f, -0.14198697f, 0.15811393f, 0.21728133f, 0.01124813f, 0.08163075f, -0.04319271f, 0.09340605f, 
    -0.10593926f, -0.11170956f, 0.05011066f, -0.05085019f, -0.14937246f, -0.02524085f, -0.01461567f, 0.05036499f, 
    -0.06217974f, 0.03053009f, -0.15546657f, 0.12957281f, 0.03984510f, 0.04843462f, 0.08090115f, -0.05688978f, 
    0.09109351f, -0.03834661f, -0.03383924f, -0.00623535f, -0.00880812f, 0.10100640f, 0.04363836f, 0.03931368f, 
    0.01283468f, 0.06404489f, -0.02941602f, 0.02552992f, 0.21333583f, 0.22148530f, 0.07198161f, 0.00939126f, 
    -0.07350554f, -0.20495465f, 0.01992294f, 0.03911269f, -0.10270169f, 0.01143704f, 0.08326091f, -0.06968988f, 
    0.07036281f, 0.01143601f, -0.09493367f, 0.06242144f, -0.14961088f, 0.00648927f, 0.10458148f, 0.07609954f, 
    -0.00802628f, -0.05441185f, -0.04487881f, -0.02680420f, -0.08587209f, -0.22735733f, -0.05110734f, 0.17028698f, 
    -0.07724886f, 0.01621668f, 0.06606971f, -0.03009256f, 0.04632100f, 0.07801241f, 0.06648596f, 0.06298495f, 
    0.04443598f, 0.04709516f, 0.24444027f, -0.15165097f, 0.05853601f, 0.08865557f, 0.00814383f, 0.16979867f, 
    0.04806004f, 0.08558295f, 0.14347894f, 0.17624821f, 0.02037678f, -0.00045508f, 0.21913882f, 0.15455842f, 
    -0.00221810f, -0.21403950f, -0.09674723f, 0.20455892f, 0.11057675f, 0.08757335f, 0.04334161f, 0.03327363f, 
    -0.03835579f, 0.01069889f, 0.30001232f, -0.18457310f, -0.02066269f, 0.00011183f, 0.06263129f, 0.22136244f, 
    -0.00245634f, 0.05833863f, 0.03342198f, -0.04297569f, -0.01524229f, 0.09017214f, -0.03683366f, -0.15530269f, 
    -0.04455895f, 0.04190244f, 0.03863551f, -0.08631328f, 0.05125619f, 0.01254774f, -0.06106027f, -0.05034756f, 
    0.13478881f, 0.02585560f, -0.10085002f, -0.19159664f, 0.12871556f, -0.03062181f, 0.05451241f, -0.06145485f, 
    -0.12591529f, 0.02954249f, 0.04137048f, -0.06099731f, -0.15907960f, -0.04479790f, 0.25697908f, -0.11483048f, 
    -0.00341880f, 0.04808811f, -0.06287218f, 0.16519552f, 0.11948240f, -0.05962909f, 0.01147337f, 0.01397331f, 
    -0.15918079f, 0.02558518f, -0.29868668f, 0.21541610f, -0.06612331f, 0.10623585f, 0.09411518f, -0.06562132f, 
    0.01173044f, -0.12983023f, 0.07640258f, 0.05702334f, -0.15652306f, -0.03761522f, 0.16420332f, 0.18678631f, 
    0.16690326f, 0.05185555f, 0.00808574f, -0.07117517f, 0.11995441f, 0.13595322f, 0.06372660f, 0.11833147f, 
    0.08329772f, 0.11552304f, 0.17703508f, 0.04599793f, 0.20360087f, 0.01356845f, 0.13760805f, 0.02515885f, 
    0.00297342f, 0.09161750f, -0.04943590f, 0.08385840f, 0.09745257f, 0.02700258f, -0.09944957f, 0.15239476f, 
    -0.06247798f, 0.01639946f, 0.01286292f, 0.00695521f, -0.01733495f, -0.01292874f, 0.02290207f, -0.05985829f, 
    0.05029933f, 0.06888513f, -0.11779206f, -0.06686998f, -0.14167243f, 0.04934691f, 0.05949905f, 0.02976555f, 
    -0.06868652f, -0.08187743f, 0.04675919f, -0.09015664f, 0.34934813f, 0.24999233f, 0.11779321f, -0.03537715f, 
    -0.08707169f, -0.07497774f, -0.05901410f, -0.00693269f, -0.11195445f, 0.15593244f, 0.12230563f, -0.01562391f, 
    0.14373030f, -0.12326701f, 0.17095040f, 0.03957756f, 0.16281070f, -0.02511840f, -0.03051346f, 0.19543552f, 
    -0.04559223f, 0.01381131f, 0.10719795f, 0.05527227f, -0.32714993f, 0.00154641f, -0.10928388f, 0.40945628f, 
    -0.14313254f, -0.03329372f, 0.18150790f, 0.12444311f, -0.12606524f, 0.10591123f, 0.04742268f, -0.01373804f, 
    -0.03830772f, 0.08987813f, 0.06891538f, -0.08854193f, 0.13093911f, -0.00813166f, 0.03344186f, 0.03950752f, 
    0.23330973f, 0.19953753f, 0.04189098f, -0.00654969f, 0.20790805f, 0.19723606f, 0.34211797f, -0.13346389f, 
    -0.03902870f, 0.04785939f, 0.03149355f, 0.09695482f, 0.08127545f, 0.06384028f, 0.05954739f, -0.04234742f, 
    0.00241187f, -0.03266898f, -0.02436119f, -0.05466987f, 0.00631945f, -0.01745241f, 0.00165191f, -0.00870864f, 
    0.02145105f, -0.04129501f, -0.07874882f, -0.01309920f, 0.00341652f, -0.00795908f, 0.02872750f, 0.02257156f, 
    -0.04807193f, -0.03048935f, -0.02965176f, -0.04533494f, 0.01291229f, -0.03187390f, 0.00373210f, -0.02779193f, 
    -0.04190682f, -0.02339014f, -0.02787915f, 0.02662124f, -0.06063172f, 0.01348567f, -0.03193099f, -0.05412972f, 
    -0.04252351f, -0.00653291f, 0.06026554f, -0.03074962f, -0.07508327f, -0.00554266f, 0.01046729f, 0.04667810f, 
    -0.06796658f, -0.02526642f, -0.03753624f, 0.01226302f, 0.00220543f, -0.02552173f, 0.02742417f, -0.05995870f, 
    -0.02132343f, 0.01176268f, -0.05439732f, -0.01357606f, -0.04520725f, 0.00175249f, 0.07759036f, 0.05442449f, 
    0.01341763f, -0.01601863f, -0.06803286f, -0.04711998f, 0.00869417f, -0.06493671f, -0.03352848f, -0.07588193f, 
    -0.10626680f, -0.02542661f, -0.00238460f, 0.03294083f, -0.00958824f, 0.02933912f, 0.00447409f, 0.04800815f, 
    -0.04450138f, 0.01013760f, -0.07855972f, 0.00325094f, -0.06360436f, -0.05332432f, -0.00414802f, -0.03303614f, 
    -0.04523310f, 0.03160283f, -0.02110522f, -0.01519467f, 0.02355096f, 0.07791410f, 0.04746525f, -0.05056190f, 
    -0.02462814f, -0.01291529f, -0.03329256f, 0.00181006f, 0.00324446f, -0.02048098f, -0.07488810f, -0.04340981f, 
    -0.05524581f, -0.00621292f, 0.01794750f, -0.02139744f, -0.03025017f, -0.00101391f, -0.00897262f, -0.05408499f, 
    -0.04125940f, 0.01223474f, -0.04012420f, 0.04811391f, 0.00238733f, 0.03266798f, 0.03627269f, -0.00914528f, 
    0.02224380f, -0.02257605f, 0.00244486f, 0.02955128f, -0.02714067f, 0.01016737f, 0.00877013f, 0.02480369f, 
    -0.00278439f, -0.04935319f, -0.01172979f, -0.07226226f, 0.04317610f, -0.03120436f, 0.03653543f, -0.02645218f, 
    -0.07499321f, -0.07075344f, 0.01530409f, -0.03581138f, -0.03136383f, -0.03284412f, -0.00660332f, -0.01070056f, 
    -0.03846989f, -0.00939853f, 0.03713738f, -0.00706933f, -0.02435124f, -0.03422528f, -0.00425328f, -0.00403557f, 
    0.03036119f, 0.02328477f, 0.00883052f, -0.00650581f, -0.00119243f, -0.02955075f, 0.00209879f, -0.08667684f, 
    -0.03883019f, 0.02209822f, 0.01521679f, 0.00474040f, 0.05936687f, 0.04323487f, -0.04977295f, -0.09145446f, 
    -0.00851955f, -0.03980983f, 0.02465321f, -0.02938738f, -0.03770933f, -0.03982179f, -0.01532952f, -0.03522467f, 
    0.00793093f, 0.02135453f, -0.06865303f, -0.01633438f, -0.04866508f, -0.08411606f, -0.03589934f, -0.03836814f, 
    0.01302839f, 0.02996827f, 0.00488737f, -0.01933062f, 0.02617975f, -0.03453458f, -0.01566850f, 0.01481268f, 
    -0.03894607f, 0.02277205f, 0.00044641f, -0.04120599f, -0.07449783f, -0.05517144f, -0.00586484f, 0.00460570f, 
    0.01784047f, -0.01051739f, 0.06673910f, -0.05660302f, 0.00722744f, -0.03913558f, -0.06705663f, 0.00426784f, 
    -0.05869198f, -0.01019875f, -0.05393061f, -0.06912241f, -0.03006476f, -0.05737525f, 0.01145772f, 0.01053774f, 
    -0.02565063f, -0.01787716f, -0.01596679f, -0.00879015f, -0.05413209f, 0.03959220f, -0.01811020f, -0.03263162f, 
    -0.02074481f, -0.03335955f, -0.09148228f, -0.04563286f, -0.05005624f, -0.03628157f, -0.08964168f, -0.04260423f, 
    -0.00545350f, 0.01917322f, -0.01707396f, -0.00780269f, 0.00426594f, 0.03814229f, -0.05464315f, 0.01929043f, 
    -0.00516796f, -0.01986624f, -0.03660680f, 0.01727828f, 0.01546726f, -0.01433840f, -0.02293940f, -0.03618803f, 
    -0.04816091f, 0.01850584f, -0.00525858f, -0.01947367f, -0.00217765f, -0.05227577f, -0.06263481f, -0.08650001f, 
    0.01181056f, -0.04575763f, 0.00335975f, -0.02779921f, 0.02205028f, -0.01876053f, -0.04823748f, -0.00856942f, 
    0.01667831f, 0.02271594f, 0.01315661f, -0.01249243f, 0.00327523f, -0.05755224f, 0.07085361f, -0.01649329f, 
    0.02871247f, -0.00731105f, -0.05333373f, 0.02525406f, -0.01393694f, -0.01629242f, -0.04557326f, 0.00970054f, 
    0.00565514f, -0.03763960f, 0.04185548f, 0.08239867f, 0.00418701f, 0.00283241f, 0.00526811f, -0.04759488f, 
    0.00344695f, 0.01491223f, -0.01170288f, 0.01858121f, 0.02582234f, -0.01831095f, -0.05870140f, -0.02631042f, 
    -0.02965588f, -0.05845632f, -0.06775795f, -0.00290095f, -0.02340521f, 0.03901202f, -0.02595172f, -0.07653920f, 
    0.01073188f, 0.00845092f, -0.00038570f, -0.00622640f, -0.01793270f, -0.00918274f, -0.07426536f, 0.05654636f, 
    -0.07642228f, -0.05809455f, -0.02373680f, -0.06447975f, -0.03307023f, -0.06391374f, 0.03983530f, 0.05666713f, 
    -0.00388771f, -0.04380631f, -0.01159787f, 0.03334938f, -0.03342959f, -0.05406077f, -0.01492543f, -0.04455554f, 
    -0.03938463f, -0.04945607f, 0.02219040f, 0.02049587f, -0.00598395f, 0.01066872f, -0.00013481f, -0.04724090f, 
    0.00608007f, 0.01629956f, 0.02671685f, -0.00289247f, 0.04535899f, 0.07188585f, -0.04949004f, -0.00427856f, 
    -0.07381619f, -0.03675580f, 0.05930817f, 0.02272949f, -0.02232430f, -0.01248872f, -0.07023849f, -0.01033683f, 
    -0.02149144f, 0.02632770f, 0.02575932f, 0.00042726f, -0.05379312f, -0.04279009f, -0.04255282f, -0.02152460f, 
    0.04451872f, 0.00920473f, 0.02238428f, -0.01165887f, -0.06420850f, -0.02143533f, -0.05355477f, 0.02424614f, 
    0.03082494f, -0.03469906f, 0.01542767f, -0.03561861f, -0.06525836f, -0.05367791f, -0.01300894f, -0.01440185f, 
    -0.02372044f, -0.04356083f, -0.04558269f, 0.01525508f, -0.03884188f, -0.02584806f, -0.01267869f, 0.05330018f, 
    -0.01383549f, -0.06651939f, -0.06552884f, -0.02173025f, -0.05327918f, -0.02019746f, 0.02102579f, 0.02425939f, 
    -0.00877314f, 0.06445306f, 0.20854808f, 0.06906463f, 0.00016858f, -0.01796846f, -0.08724867f, -0.00810373f, 
    0.02719158f, -0.03692156f, 0.01125666f, 0.14656162f, -0.10593045f, 0.12872483f, -0.10246397f, -0.01182054f, 
    0.02946132f, -0.06903742f, 0.02945141f, -0.00621258f, -0.00572287f, 0.20548695f, -0.10023392f, -0.09199616f, 
    -0.14209381f, -0.11105456f, -0.00471818f, -0.15274386f, -0.10233999f, 0.01162813f, -0.01074418f, 0.01553396f, 
    0.00543829f, -0.07425755f, 0.03055184f, 0.10181983f, 0.26905286f, 0.22409794f, 0.01236107f, -0.09684886f, 
    -0.13617611f, -0.07542985f, -0.01321784f, 0.02311838f, -0.05672150f, -0.02017224f, 0.00301660f, 0.03122024f, 
    -0.07563827f, -0.17541772f, -0.08395327f, 0.19294128f, 0.03600266f, 0.03085799f, -0.11003444f, -0.14854153f, 
    0.10164786f, 0.02375585f, -0.15317318f, -0.01817350f, 0.34151587f, 0.23508771f, -0.05916996f, 0.18265904f, 
    0.04170094f, -0.07878523f, 0.08721727f, -0.06761362f, -0.00641394f, -0.00237090f, 0.05423100f, 0.05710047f, 
    -0.15938073f, 0.07937940f, -0.17051278f, 0.04452264f, -0.04198136f, -0.04585425f, 0.07834332f, -0.01370601f, 
    -0.07806403f, 0.10401738f, -0.10657732f, -0.07818625f, 0.42578101f, -0.40756208f, -0.23917675f, -0.31211656f, 
    0.01326659f, 0.06994426f, 0.06702074f, -0.08953201f, -0.12512077f, 0.03350859f, 0.04653062f, -0.06201502f, 
    0.04407826f, -0.07156114f, -0.12725723f, -0.03594452f, -0.07739817f, 0.00327338f, -0.06119348f, 0.02762059f, 
    0.03326267f, -0.06894667f, -0.04925095f, -0.09095041f, 0.03394812f, 0.01927425f, 0.27389520f, 0.09527298f, 
    -0.12400964f, 0.24039975f, -0.09989414f, -0.02766087f, -0.04810943f, -0.05903200f, 0.09433167f, 0.02704679f, 
    -0.13296308f, -0.00187013f, -0.00363537f, 0.20820326f, -0.05493592f, -0.01515435f, -0.19999686f, -0.06620546f, 
    -0.10583197f, -0.06250953f, -0.00486235f, -0.09481316f, -0.17615721f, 0.00074620f, -0.08488261f, 0.19280842f, 
    -0.07058889f, -0.06926954f, -0.20598644f, 0.02475275f, -0.01100703f, -0.08231025f, 0.01672371f, 0.04764643f, 
    0.05483486f, 0.09121039f, -0.06113042f, 0.07448274f, 0.09908519f, -0.13138244f, -0.04154312f, -0.04576655f, 
    -0.16433015f, -0.06969924f, -0.07734811f, -0.03746676f, -0.05186101f, 0.24805063f, 0.00385915f, 0.15293676f, 
    0.04228598f, -0.02086924f, 0.15441333f, -0.10432784f, 0.03736651f, -0.04516931f, -0.04830517f, 0.00568114f, 
    0.03095538f, 0.11364343f, 0.00354861f, 0.08251067f, -0.08095200f, 0.11104953f, -0.01820866f, -0.06390207f, 
    -0.10177926f, -0.09319212f, 0.01356214f, -0.09752893f, 0.14699142f, -0.09020912f, 0.12976499f, -0.02709203f, 
    0.10054827f, -0.06957902f, -0.00299750f, 0.06249233f, -0.12000203f, -0.09858546f, -0.07879171f, -0.10575245f, 
    -0.09009732f, 0.11371340f, -0.04258832f, -0.01113652f, 0.09271197f, -0.18685889f, 0.05798670f, 0.04289887f, 
    0.09322593f, -0.00076035f, 0.04131055f, -0.10373590f, 0.06951677f, 0.09552368f, 0.38094604f, 0.38945749f, 
    0.06550031f, -0.15007699f, 0.00245735f, -0.17981349f, -0.10117909f, 0.11730246f, 0.08717569f, 0.08431072f, 
    0.16217247f, -0.06846905f, 0.41248477f, 0.14405252f, -0.11110764f, 0.00779753f, -0.00208635f, 0.07584046f, 
    -0.10641815f, -0.02467389f, -0.01524749f, -0.04317483f, -0.03485789f, 0.10179775f, -0.02356330f, -0.12924962f, 
    -0.05775606f, -0.08029081f, -0.00031625f, 0.00141091f, 0.05884747f, 0.12314931f, 0.04456403f, -0.01290665f, 
    0.06577397f, 0.07028540f, 0.04521666f, -0.02449014f, -0.12213238f, -0.11403193f, -0.11693297f, 0.21149655f, 
    -0.16214184f, 0.15087926f, 0.05591727f, 0.01029790f, 0.19339205f, 0.13168865f, 0.25438794f, 0.34533271f, 
    0.09468366f, 0.09325505f, -0.27373376f, 0.17845170f, 0.02372260f, -0.08635908f, -0.01383321f, -0.05478429f, 
    -0.52662367f, 0.08927932f, 0.03023717f, -0.23896486f, -0.01293029f, -0.03066166f, 0.11453966f, -0.08679455f, 
    -0.11448410f, -0.16244991f, -0.02651949f, 0.04385501f, -0.16758318f, 0.22019622f, -0.48605984f, 0.16843776f, 
    -0.07192145f, 0.04960047f, -0.12394911f, 0.07348532f, -0.02800703f, 0.02516612f, -0.06148733f, 0.09614268f, 
    0.08675857f, -0.02049187f, 0.16983467f, 0.04529986f, -0.08557332f, 0.01681262f, 0.05609647f, 0.12787405f, 
    -0.10797287f, 0.02734400f, -0.01000976f, -0.11065533f, -0.09854224f, -0.10119284f, -0.01193238f, 0.01300456f, 
    -0.16613543f, -0.05945103f, -0.01100104f, -0.05719355f, -0.04822142f, -0.01929368f, -0.07963970f, 0.01265574f, 
    -0.03067636f, 0.12371463f, -0.12088370f, 0.03303722f, 0.02906338f, -0.05437189f, 0.02144833f, 0.01340369f, 
    -0.21936323f, -0.03933912f, 0.04105864f, -0.14959452f, -0.11708243f, 0.11223537f, -0.08190629f, 0.00637818f, 
    0.02356774f, -0.02926973f, 0.06873270f, 0.04126654f, -0.05674173f, -0.00504344f, -0.09319178f, -0.11130223f, 
    -0.02368890f, 0.23866750f, -0.09468265f, 0.13840552f, 0.12326067f, -0.06705398f, -0.12313130f, 0.09650225f, 
    -0.09473756f, -0.08368435f, -0.02260690f, -0.14496991f, -0.24585634f, 0.26255193f, 0.08556885f, 0.21608704f, 
    -0.04932833f, -0.00087255f, -0.02145473f, -0.01622973f, -0.14411414f, -0.08885095f, 0.07995785f, -0.08281524f, 
    0.05891203f, 0.08780375f, 0.14973471f, 0.12516527f, -0.02894715f, -0.10910536f, -0.07188229f, -0.07180993f, 
    -0.13854986f, 0.14971654f, 0.18813814f, 0.22287060f, 0.12484726f, 0.20840944f, -0.14441222f, 0.12390209f, 
    -0.11417823f, -0.05787668f, -0.01018186f, 0.01495290f, 0.02765645f, 0.10345143f, -0.03189993f, -0.19405702f, 
    0.06266870f, -0.11074848f, 0.04434132f, 0.33200625f, -0.00744622f, 0.13214222f, 0.04517142f, 0.02030543f, 
    0.04015943f, 0.02356764f, 0.11226556f, -0.01761543f, -0.24147493f, -0.01166037f, -0.19290790f, 0.02537489f, 
    0.11699723f, -0.12943670f, 0.13384108f, -0.02507321f, 0.01579305f, 0.02734315f, -0.00004411f, 0.08628799f, 
    0.31206325f, -0.21247943f, 0.05104218f, -0.02065153f, 0.06621616f, -0.07070621f, 0.04090933f, -0.01821674f, 
    0.09590673f, 0.10303310f, 0.14558245f, 0.00085803f, 0.18346834f, 0.05687121f, 0.37215167f, 0.17297101f, 
    0.01641977f, 0.04362078f, 0.00882509f, 0.06568167f, -0.01461830f, -0.12337610f, -0.03326751f, -0.04342049f, 
    0.14533423f, -0.16275492f, -0.16992165f, 0.49234527f, -0.00790781f, 0.07379688f, -0.17074169f, 0.11187261f, 
    -0.06286794f, 0.03570317f, -0.06733970f, -0.10303225f, -0.49079457f, -0.11670251f, -0.15145260f, 0.15040036f, 
    0.22973180f, 0.13724208f, 0.16470875f, 0.14784783f, 0.07664134f, 0.20479409f, 0.14717385f, 0.17444214f, 
    0.00306261f, -0.24529313f, -0.08290591f, -0.25106892f, 0.10339633f, 0.07374916f, 0.14214423f, 0.14101402f, 
    0.28114536f, 0.03741535f, 0.09352151f, 0.19277267f, -0.20151573f, 0.45206496f, -0.01240658f, 0.01251617f, 
    -0.09839622f, 0.11210606f, 0.29948306f, 0.03518118f, 0.08672050f, 0.04572645f, 0.12032754f, 0.08456193f, 
    0.17399275f, 0.02290989f, 0.11639800f, -0.06241255f, -0.00019138f, -0.05655169f, -0.20416082f, 0.12713885f, 
    0.04671445f, -0.15773870f, 0.09644689f, -0.00942778f, 0.26492733f, 0.02827695f, 0.40003270f, -0.26568276f, 
    0.04213889f, -0.08676104f, -0.16870826f, 0.18630709f, 0.08257882f, -0.06516936f, 0.21819109f, -0.02166654f, 
    0.42723569f, -0.04525172f, 0.45875129f, -0.01220054f, 0.10611894f, 0.11598660f, 0.03130538f, -0.28520277f, 
    -0.19024098f, -0.11670242f, -0.13197960f, -0.24310283f, 0.18941520f, 0.08253527f, 0.14425449f, 0.11364821f, 
    0.08688743f, 0.03949069f, 0.18570863f, -0.08549636f, -0.02415146f, -0.02208769f, 0.13600361f, -0.06818648f, 
    -0.11773256f, -0.05467998f, 0.01693502f, 0.18218280f, 0.11532111f, -0.00019577f, -0.17573535f, -0.03144987f, 
    -0.11812708f, 0.00954273f, -0.26267579f, -0.06725579f, -0.31915155f, -0.02703497f, -0.16705583f, -0.02724354f, 
    0.20068395f, -0.03919532f, 0.06651134f, 0.06584466f, 0.03025475f, 0.08932692f, -0.12977690f, -0.03843970f, 
    0.15576537f, -0.01888207f, 0.21865155f, -0.05938718f, 0.14379857f, 0.26703769f, -0.15473054f, -0.12340150f, 
    -0.15508570f, -0.07122927f, -0.14983073f, -0.14216942f, 0.30904579f, 0.22423166f, 0.36478317f, 0.21176122f, 
    0.17100549f, -0.19119085f, 0.02913283f, -0.15105483f, 0.05760614f, -0.01603148f, -0.11120594f, -0.02559251f, 
    -0.34010744f, 0.09815942f, 0.06712422f, 0.10877651f, 0.06342607f, 0.19730963f, 0.08042002f, -0.04178511f, 
    0.12352818f, 0.03187147f, -0.13652194f, -0.02295041f, -0.13255025f, 0.11633783f, -0.44684082f, -0.06373572f, 
    -0.15120101f, -0.03343656f, -0.00666535f, 0.11559417f, -0.01979522f, -0.11468198f, 0.01135595f, 0.08761439f, 
    0.09980828f, 0.23249179f, -0.20177220f, -0.12741795f, 0.08565255f, 0.00755089f, -0.13827847f, 0.06364240f, 
    0.04988215f, -0.01002050f, -0.09579848f, -0.19418821f, 0.05458238f, -0.02177889f, -0.09488920f, -0.25556698f, 
    0.21618013f, 0.02721192f, 0.01001718f, 0.03114257f, -0.08889747f, 0.07074945f, 0.05950121f, 0.19243540f, 
    0.02300981f, -0.03399280f, 0.03075937f, 0.00425376f, -0.01634116f, 0.17592444f, -0.14961147f, 0.11435411f, 
    0.23277719f, -0.07879260f, 0.15776032f, -0.04422114f, -0.09050629f, -0.17420554f, -0.21213724f, -0.08956433f, 
    0.10060658f, 0.02665082f, 0.16860622f, -0.07067427f, -0.00889158f, 0.01923345f, 0.06859986f, 0.20057216f, 
    0.51794672f, 0.10309511f, 0.00871203f, 0.23925331f, 0.04461662f, -0.00612874f, 0.03506267f, -0.00073025f, 
    -0.09435269f, 0.07587961f, -0.07542332f, 0.00722521f, -0.08652838f, 0.13389809f, -0.10826413f, 0.05283603f, 
    0.07104200f, 0.18827255f, -0.06794328f, 0.02180641f, -0.03040355f, -0.11259414f, 0.14890909f, -0.06638856f, 
    0.09689686f, 0.04403907f, -0.02211223f, -0.13778177f, -0.03080398f, 0.04452113f, -0.07499354f, 0.20047905f, 
    -0.08522502f, 0.01195757f, -0.03670652f, -0.28222686f, 0.40114325f, -0.13399781f, -0.01962013f, -0.17053890f, 
    0.03497021f, 0.00689537f, -0.06340194f, 0.13499118f, -0.13280877f, 0.05056081f, -0.01105423f, 0.09110271f, 
    -0.14004205f, -0.06440796f, -0.17967238f, -0.06316505f, -0.01026857f, -0.01353018f, -0.06988199f, -0.06262333f, 
    -0.01406759f, -0.09559388f, -0.31310660f, -0.17172605f, -0.22154418f, -0.05739439f, -0.06118027f, 0.09884228f, 
    0.04012389f, -0.05612300f, -0.13189048f, -0.01035565f, 0.05011674f, -0.00558150f, -0.06574275f, 0.02859362f, 
    -0.56896925f, -0.06033706f, 0.06144865f, 0.17166020f, 0.05555126f, -0.04277849f, 0.07517570f, -0.02926853f, 
    -0.26393864f, -0.05272035f, -0.00808500f, 0.02088429f, 0.51215059f, -0.31922245f, 0.12200147f, -0.04676032f, 
    0.17899376f, 0.15587367f, -0.13510568f, -0.16481258f, 0.13529718f, -0.07432822f, -0.00131668f, -0.10623370f, 
    -0.06997060f, -0.04107172f, -0.08296175f, -0.10377573f, -0.05864055f, 0.01220963f, 0.07361952f, 0.20874512f, 
    0.08465811f, -0.03385059f, 0.18987912f, 0.15354301f, -0.06767657f, 0.31310382f, -0.16279761f, 0.08111501f, 
    0.12216921f, -0.08134788f, 0.10993093f, 0.14315192f, 0.01211639f, 0.13528022f, 0.03808536f, 0.01329321f, 
    0.04879928f, 0.03280516f, 0.00040887f, -0.03658993f, 0.02613172f, 0.00309208f, 0.02682148f, 0.03221492f, 
    0.01116361f, 0.04210992f, -0.01061370f, 0.00809995f, -0.09579634f, -0.03828629f, 0.04712794f, -0.01379979f, 
    -0.00713946f, -0.00327465f, 0.04174104f, 0.01798806f, -0.09700258f, 0.14183104f, 0.06928117f, 0.00348913f, 
    -0.14858347f, 0.14317070f, -0.10869480f, -0.08581577f, -0.00606787f, 0.05962203f, 0.04521114f, 0.02481015f, 
    0.01727101f, -0.04447626f, -0.01848189f, 0.07470308f, 0.06114554f, -0.14008637f, -0.42175281f, 0.18075900f, 
    -0.22317863f, 0.10897928f, 0.11661476f, 0.11938081f, -0.01829818f, 0.01983890f, 0.06653425f, -0.00711221f, 
    0.07531803f, 0.14358646f, 0.08380873f, -0.04544636f, 0.07669737f, -0.07282546f, -0.10093504f, -0.07421073f, 
    0.06887803f, 0.17986046f, 0.06153794f, 0.09142936f, 0.53261203f, 0.10840014f, 0.42648920f, 0.16499911f, 
    -0.00127219f, -0.07554802f, -0.10326535f, 0.03238437f, 0.07464828f, 0.04892431f, -0.21284088f, 0.11658974f, 
    0.20735426f, 0.28262469f, 0.00779325f, 0.08704636f, -0.07496699f, 0.06443336f, 0.00779650f, 0.00348363f, 
    -0.07255817f, -0.04795057f, -0.04217645f, -0.20089720f, 0.57751441f, -0.54810750f, -0.00006528f, 0.24873686f, 
    0.06966190f, 0.18103203f, -0.02253278f, -0.16312164f, 0.04334886f, -0.04977347f, 0.10767020f, -0.01532107f, 
    0.01146962f, -0.03687076f, -0.09940851f, -0.09720898f, -0.04919414f, -0.01504273f, 0.02629077f, -0.05473621f, 
    -0.11516960f, -0.02460452f, -0.03324903f, -0.07689898f, -0.25178942f, -0.00476824f, -0.14521135f, -0.04788279f, 
    0.02641723f, 0.02182802f, 0.00878814f, 0.04981308f, -0.15000814f, 0.01997383f, 0.15358528f, -0.09907877f, 
    -0.09447461f, -0.00123965f, -0.14667940f, 0.06735944f, -0.17355514f, -0.03216325f, -0.09345624f, 0.04503809f, 
    -0.06887148f, -0.01072387f, 0.02524617f, 0.02964782f, -0.23857829f, -0.13218220f, -0.10583429f, 0.10771775f, 
    -0.10209083f, -0.11234853f, -0.03916624f, 0.07740727f, -0.02182966f, -0.07019908f, -0.00499393f, -0.01298652f, 
    0.12117574f, 0.01438925f, -0.04156056f, -0.02546974f, -0.16763237f, 0.01100498f, 0.00295740f, 0.09061211f, 
    -0.07474829f, 0.00265690f, 0.01295315f, -0.09988077f, 0.42750731f, 0.17405252f, 0.14517552f, 0.05541056f, 
    0.02775007f, -0.00948613f, -0.06336536f, -0.05615917f, -0.02966617f, 0.01067816f, 0.14585565f, 0.10965200f, 
    -0.01479601f, -0.03214885f, -0.04919192f, 0.08589529f, -0.11866871f, -0.15982316f, 0.16443692f, 0.13097194f, 
    0.02760907f, -0.06618184f, 0.03273784f, -0.06343967f, -0.07640748f, -0.14652307f, -0.05599019f, 0.04749972f, 
    -0.01015999f, 0.10447545f, 0.02483893f, 0.03985618f, -0.09058350f, -0.13870066f, 0.02561370f, 0.00333319f, 
    -0.01961425f, 0.01692979f, 0.14984134f, -0.10423974f, 0.28983134f, -0.20729658f, -0.03358713f, 0.08499447f, 
    0.14967035f, 0.05583367f, 0.22724214f, -0.07177184f, 0.06283438f, -0.09641446f, 0.25930217f, 0.11640619f, 
    0.18933743f, -0.21077175f, 0.02135410f, -0.06384038f, -0.12349791f, 0.11135968f, 0.09294958f, 0.06296137f, 
    0.14349085f, 0.11124860f, 0.10952932f, 0.12196773f, 0.06560390f, 0.02593412f, 0.07627445f, 0.01991436f, 
    0.01678452f, 0.05500885f, 0.07307193f, 0.13080814f, -0.07096591f, 0.00275787f, -0.05264846f, 0.01623878f, 
    -0.00744769f, -0.04835340f, 0.01822682f, 0.06087778f, 0.15531126f, 0.02627300f, -0.13481025f, 0.04688931f, 
    0.06029391f, 0.01424049f, -0.04156942f, 0.01489177f, 0.11850325f, -0.24854782f, 0.00797228f, 0.04042282f, 
    0.04352526f, 0.02893109f, 0.06820716f, 0.02674601f, 0.04620683f, -0.06475899f, 0.15111901f, 0.08878787f, 
    -0.01241767f, -0.05716984f, -0.16652857f, 0.03988086f, -0.04858588f, -0.04505334f, -0.12224068f, -0.02211207f, 
    -0.29805928f, -0.30658418f, -0.16226727f, -0.16698836f, -0.11984339f, 0.19996265f, 0.01341940f, -0.08409178f, 
    0.04918074f, -0.11593982f, -0.02132103f, 0.14081897f, 0.11722647f, -0.12569070f, 0.11053833f, 0.00666920f, 
    0.06401075f, 0.01488022f, -0.05090949f, 0.02380662f, -0.15071337f, 0.08638048f, 0.07505019f, 0.06282838f, 
    0.02495231f, 0.06455901f, -0.02165432f, -0.09123277f, -0.00079864f, -0.09460183f, 0.12863545f, -0.12996735f, 
    0.06401585f, 0.12236201f, -0.06047296f, -0.14218986f, -0.42952561f, 0.18141912f, -0.16781305f, -0.10088753f, 
    -0.11821156f, -0.02222169f, 0.06978010f, -0.08822183f, 0.07353252f, -0.05892204f, -0.00651239f, -0.02341150f, 
    0.13117982f, 0.01576367f, 0.06026904f, -0.02172162f, 0.08780609f, 0.04597675f, 0.09445030f, 0.05139462f, 
    -0.04119085f, 0.02597560f, 0.00772609f, -0.00175923f, 0.36935347f, 0.19002679f, 0.04565243f, 0.06977227f, 
    0.02792098f, -0.11133447f, 0.03669372f, -0.02621306f, -0.12432375f, -0.11309531f, 0.08458620f, 0.14161326f, 
    0.24609952f, 0.06590888f, 0.20550115f, -0.16104361f, 0.23026882f, 0.08541123f, -0.04196727f, 0.05679410f, 
    -0.10343070f, 0.11597934f, -0.01183619f, 0.07651430f, -0.16722265f, 0.05346347f, -0.05014936f, 0.07568692f, 
    -0.03261774f, -0.04294565f, -0.18873900f, 0.16580610f, -0.12844603f, 0.04639932f, 0.06308619f, -0.00779575f, 
    -0.05928716f, 0.12007977f, 0.05500340f, 0.17461364f, -0.03524809f, -0.09503695f, 0.02942647f, -0.02642779f, 
    -0.14995913f, 0.14800055f, 0.07374617f, 0.29668561f, 0.20828167f, -0.22047755f, 0.04777233f, -0.10885551f, 
    -0.02512343f, 0.07445126f, 0.12188920f, 0.07371883f, 0.04466170f, 0.00372413f, -0.04716342f, -0.06535085f, 
    -0.03944238f, 0.02527385f, 0.03570094f, 0.01261269f, -0.02983681f, 0.03927060f, -0.01480606f, 0.00866270f, 
    0.04580252f, -0.01559968f, 0.02298235f, -0.04224912f, -0.01364259f, -0.05255485f, 0.00234750f, 0.01242637f, 
    0.03460911f, -0.00937508f, -0.04287458f, 0.03739088f, 0.02193294f, 0.01493058f, 0.02637851f, 0.03510507f, 
    0.04700666f, -0.03900364f, 0.00500881f, -0.03783779f, 0.04581212f, -0.04325538f, -0.03504336f, -0.05445141f, 
    0.03879741f, -0.03046569f, -0.01397315f, -0.03709826f, -0.03545936f, -0.02057347f, 0.03806604f, 0.01117849f, 
    0.04828161f, -0.03925032f, -0.03008770f, 0.01475962f, -0.00556675f, -0.01720053f, -0.00571119f, 0.00986418f, 
    0.01571624f, -0.02226441f, -0.04952292f, -0.03081594f, 0.01502338f, 0.00023086f, 0.01599553f, -0.04024199f, 
    -0.00958275f, -0.00834296f, 0.04286884f, -0.02372481f, -0.05272583f, -0.00779977f, 0.01007304f, 0.03084388f, 
    0.01835618f, 0.02456387f, 0.03308388f, 0.02035778f, -0.03260277f, 0.01911530f, 0.03457733f, -0.04356227f, 
    0.01068662f, -0.03300185f, -0.05037349f, 0.03903164f, 0.02143851f, -0.03220265f, 0.02162253f, -0.04731363f, 
    -0.01685318f, 0.04525302f, 0.02791469f, -0.04436079f, -0.04596745f, 0.00970251f, -0.02980943f, -0.02487734f, 
    -0.04761386f, 0.00980067f, 0.01507079f, 0.02946753f, -0.00937476f, -0.02210977f, 0.02688424f, 0.02985162f, 
    -0.05310182f, -0.05387459f, -0.02227569f, -0.04675905f, -0.00110090f, -0.00495167f, 0.01696560f, -0.03443494f, 
    -0.00205244f, 0.01883745f, -0.04451511f, -0.01756452f, 0.00871497f, -0.00553534f, -0.04138869f, 0.02391261f, 
    0.02311123f, -0.05300301f, 0.01290383f, 0.02281284f, -0.03444695f, 0.04158846f, -0.03588858f, -0.04832510f, 
    -0.04588295f, -0.04660437f, -0.04392496f, 0.02789260f, 0.00623247f, 0.04096152f, 0.04830039f, -0.01892936f, 
    0.02911649f, 0.01505870f, 0.03734986f, -0.04434964f, -0.05435095f, -0.02324612f, -0.04158747f, 0.01214196f, 
    0.00111580f, -0.04302447f, -0.04632668f, 0.02482058f, -0.03784252f, -0.05419499f, -0.04750657f, 0.04295801f, 
    0.02151343f, 0.00777288f, -0.05175380f, 0.00449098f, 0.00591483f, -0.02981597f, -0.03336264f, 0.01353096f, 
    -0.01763665f, 0.04149847f, 0.00836544f, 0.00688591f, -0.03158830f, 0.03312743f, 0.03424748f, 0.01550413f, 
    -0.04539563f, -0.01245139f, 0.03119849f, -0.03439223f, -0.03371984f, -0.01932011f, -0.02447302f, -0.00900120f, 
    -0.03158322f, -0.05288588f, -0.02984490f, 0.03492732f, -0.02932728f, -0.02828027f, -0.00973353f, 0.00288062f, 
    -0.03584104f, -0.02147752f, 0.00748889f, -0.01075707f, -0.02887108f, -0.03419179f, -0.05417620f, -0.00738220f, 
    0.03484697f, 0.04001043f, 0.02863538f, -0.00300381f, 0.03842159f, 0.03294122f, -0.00559840f, 0.00590879f, 
    -0.01004980f, -0.02767196f, 0.03338005f, 0.03689780f, -0.00220376f, -0.03073422f, -0.04259104f, 0.00408088f, 
    -0.01871487f, -0.03933650f, 0.00298929f, 0.01918764f, -0.02893998f, -0.01206223f, -0.04139377f, -0.00430324f, 
    -0.04305179f, -0.03696705f, -0.02669465f, -0.03350724f, 0.03293856f, -0.02386733f, -0.03141750f, 0.00528250f, 
    -0.03916601f, 0.01428726f, 0.01814176f, 0.04247140f, 0.02237571f, -0.00002704f, -0.03810204f, -0.04203108f, 
    -0.02712797f, -0.01692987f, -0.00204490f, -0.05159556f, 0.00504296f, 0.02064881f, 0.04068553f, -0.03473992f, 
    0.01353096f, 0.00689895f, -0.00119180f, -0.02633642f, 0.03582437f, 0.01914340f, 0.00522651f, 0.04339303f, 
    -0.04111513f, 0.00167514f, -0.04650110f, 0.02257109f, -0.03774893f, 0.01467530f, -0.00261403f, -0.00790678f, 
    -0.04841088f, -0.03978214f, 0.02552948f, -0.01722671f, 0.04512301f, 0.03957659f, -0.02768028f, -0.03461415f, 
    0.00472070f, -0.02768378f, 0.00497758f, 0.03125368f, 0.02805936f, -0.02517934f, -0.03829865f, -0.02586502f, 
    0.04246827f, 0.02162965f, -0.00803139f, 0.04088433f, -0.03344526f, -0.03252946f, -0.00558579f, 0.04105466f, 
    0.00882599f, 0.01503628f, -0.03719972f, 0.03104310f, -0.04869210f, -0.02667980f, 0.02749724f, 0.01615331f, 
    -0.05133438f, 0.00714949f, -0.03884525f, -0.02777445f, -0.04061009f, 0.02343925f, -0.02185887f, -0.00327450f, 
    -0.00285070f, -0.01415533f, 0.01101252f, 0.01969083f, -0.03516823f, -0.03051869f, -0.03681585f, -0.02526481f, 
    -0.03650710f, -0.04252966f, 0.02063756f, 0.00403394f, -0.04197530f, 0.01090846f, -0.03429173f, 0.00313361f, 
    -0.01682784f, -0.04699052f, 0.03158573f, -0.02210004f, 0.01145456f, -0.05128374f, 0.02981509f, 0.03136357f, 
    0.03030969f, 0.03020567f, -0.02419746f, -0.04854380f, -0.03030320f, 0.03450769f, 0.03016570f, -0.02290454f, 
    -0.02024143f, 0.02826282f, -0.01985743f, -0.02361486f, 0.04163129f, 0.00148489f, -0.00783332f, -0.03513173f, 
    -0.05053660f, -0.02815570f, 0.03729579f, -0.02427528f, 0.01123201f, -0.01097303f, 0.01781396f, -0.05070473f, 
    -0.01706226f, -0.05129218f, -0.02085990f, -0.04661524f, 0.00009851f, 0.00518891f, -0.01104447f, -0.02445559f, 
    0.00417738f, 0.04425344f, -0.00622241f, -0.03947688f, 0.01318379f, 0.01309838f, -0.01167975f, -0.00195640f, 
    -0.00586844f, -0.02244700f, 0.01382649f, -0.01983090f, 0.04549401f, 0.01827862f, -0.02198031f, 0.02735271f, 
    -0.03046711f, 0.00740458f, -0.00475340f, 0.00887320f, -0.02385545f, 0.00967676f, -0.04821374f, -0.04828949f, 
    -0.01819218f, 0.00908167f, 0.02535215f, -0.02349363f, 0.02914876f, 0.02124863f, -0.04532805f, -0.03446605f, 
    0.03392103f, -0.04424878f, 0.00771751f, 0.03298326f, -0.03569810f, -0.05212685f, 0.01385345f, -0.05459321f, 
    0.00171917f, 0.19219019f, 0.21662621f, 0.32141986f, -0.04299367f, 0.00489366f, -0.03343325f, 0.03206031f, 
    0.02987677f, -0.06928772f, -0.07964469f, -0.05000376f, -0.00998689f, 0.13524470f, -0.07486240f, -0.10668995f, 
    0.01187454f, -0.04701431f, 0.00617214f, -0.00940426f, 0.04034792f, -0.01253091f, -0.10026625f, 0.08455779f, 
    0.26638502f, -0.10010209f, 0.15800376f, 0.11196089f, -0.01682432f, -0.07552477f, -0.02857159f, -0.04265634f, 
    0.03407631f, -0.07190941f, 0.12847434f, 0.02710341f, 0.44264561f, 0.03798075f, 0.45315704f, 0.10505220f, 
    0.10995784f, -0.11015008f, 0.01429788f, -0.08380641f, 0.00753473f, 0.03441526f, 0.03582514f, 0.01370801f, 
    -0.29658559f, -0.22029646f, 0.07211530f, 0.05906178f, -0.05164007f, 0.14993392f, 0.05661954f, -0.00223428f, 
    -0.03399399f, 0.00119004f, -0.03795571f, 0.00146856f, -0.04586047f, -0.03442342f, -0.39043808f, -0.20132636f, 
    -0.08058459f, -0.15933430f, 0.03954077f, 0.16124482f, 0.05218016f, -0.13048975f, 0.16678250f, -0.04703731f, 
    -0.03455735f, -0.06911019f, -0.03367893f, -0.08975124f, 0.03745410f, -0.02427078f, -0.03895142f, -0.02488320f, 
    -0.02246297f, 0.02185541f, -0.14102644f, 0.07555594f, -0.16328090f, 0.04473627f, 0.12733160f, -0.09032360f, 
    0.00092299f, -0.04286646f, 0.06457844f, 0.08270209f, 0.00214675f, -0.10553290f, -0.14934491f, 0.02725990f, 
    0.20443973f, -0.09029853f, 0.02502968f, 0.06549049f, 0.02536683f, -0.02352790f, -0.04986424f, -0.07279983f, 
    0.07161676f, -0.01037902f, -0.02438050f, 0.05693030f, 0.05544220f, -0.01659708f, 0.34372306f, 0.08208966f, 
    -0.08565278f, 0.01852826f, -0.22552551f, -0.02759712f, 0.02077067f, -0.15049602f, -0.01135717f, 0.00804427f, 
    -0.08361292f, -0.26507285f, 0.31093735f, 0.11187589f, 0.16111413f, 0.12799202f, -0.00508510f, -0.02264366f, 
    -0.02514389f, -0.00198738f, -0.03643790f, -0.05294159f, -0.14962533f, 0.13548054f, 0.23685756f, 0.31577727f, 
    0.00770378f, 0.04635342f, 0.05242290f, 0.16775131f, 0.04210148f, 0.08048981f, 0.05006985f, 0.04788044f, 
    -0.05183022f, -0.05791845f, -0.03420044f, 0.02495860f, -0.01703551f, 0.29855508f, -0.08438630f, -0.01492961f, 
    0.10079239f, 0.08486097f, -0.09333710f, 0.15246366f, -0.05346166f, -0.16038419f, -0.23569763f, 0.10079421f, 
    0.01489438f, -0.14198296f, 0.07056416f, -0.00278596f, 0.04551610f, -0.04477437f, -0.11540724f, 0.01102564f, 
    0.12112268f, -0.01517681f, 0.15109232f, 0.02296730f, 0.02430873f, 0.12238708f, -0.12060019f, -0.00274288f, 
    0.03835173f, 0.06978969f, 0.06697398f, -0.03331757f, 0.08296018f, -0.15443362f, 0.28012878f, 0.29032764f, 
    0.10233163f, -0.18469852f, 0.03745251f, 0.06342109f, 0.04641835f, 0.02911517f, -0.10418666f, 0.03118258f, 
    -0.09256417f, 0.16197848f, 0.04800803f, -0.00681716f, -0.11081821f, 0.12705040f, -0.03933246f, 0.09817678f, 
    -0.13556546f, -0.00942548f, -0.05082532f, 0.09245925f, -0.01799748f, -0.00956952f, -0.12696846f, 0.21945409f, 
    -0.09252922f, -0.04863262f, 0.10050406f, 0.00036001f, 0.15938877f, 0.01575059f, -0.03983501f, 0.04144122f, 
    -0.02983952f, 0.10895187f, 0.17468032f, 0.09764996f, -0.07787792f, 0.06380237f, 0.02357906f, 0.23804666f, 
    0.07603592f, 0.02278971f, 0.00527109f, -0.01736571f, 0.20199655f, 0.13179801f, 0.10318314f, -0.20403440f, 
    0.04205548f, -0.00245855f, -0.04348077f, -0.02689277f, 0.04071161f, 0.10503982f, 0.11270680f, 0.01992785f, 
    0.16770852f, 0.08396020f, -0.01089069f, -0.00180396f, -0.01886822f, 0.18897788f, 0.04074415f, -0.01002468f, 
    -0.02939593f, 0.01250689f, 0.11942974f, -0.00420103f, -0.04771867f, -0.02569442f, 0.15028512f, 0.01666422f, 
    0.00931357f, 0.14848939f, -0.00039372f, 0.04128793f, 0.08291323f, -0.03815067f, 0.14933366f, 0.06577682f, 
    0.14598188f, 0.28938127f, 0.08625149f, 0.21469311f, 0.16365771f, -0.20749657f, -0.03686488f, -0.05538019f, 
    -0.04645266f, 0.03242254f, 0.09572443f, 0.06146348f, -0.12938151f, 0.12926531f, -0.04132034f, -0.01928766f, 
    -0.03382959f, -0.02597731f, -0.05750059f, -0.17842108f, 0.12384439f, -0.10463692f, 0.01524495f, 0.09594247f, 
    -0.09987330f, -0.05990686f, 0.13169734f, 0.00387910f, 0.12996376f, 0.17485707f, -0.08494609f, 0.03901443f, 
    -0.05503714f, -0.01152422f, -0.00495255f, 0.10365266f, 0.33093694f, -0.27486390f, 0.06004510f, 0.14361176f, 
    0.04159337f, 0.00845417f, -0.07398034f, -0.04443306f, 0.01019535f, 0.00090094f, 0.05517208f, -0.05964115f, 
    0.06415861f, 0.11007815f, -0.01565219f, 0.02479929f, -0.00129382f, 0.06297796f, -0.00148172f, 0.00563730f, 
    0.09102842f, 0.04696003f, 0.07352720f, -0.01244013f, 0.05355963f, -0.11823516f, -0.25307488f, -0.15620209f, 
    0.01144086f, 0.11293110f, -0.00211417f, 0.00253584f, 0.14377424f, 0.06407800f, -0.00611646f, -0.05749995f, 
    -0.25229219f, 0.05677599f, 0.17272945f, 0.24016903f, 0.00380636f, 0.05801127f, -0.06805307f, 0.12338474f, 
    -0.00389840f, -0.11223412f, 0.07750848f, -0.09418311f, 0.05678758f, -0.06471673f, -0.06659811f, 0.30148238f, 
    -0.10919459f, -0.02243309f, 0.04185791f, -0.01887170f, -0.01158656f, 0.04683893f, 0.07703723f, -0.02639923f, 
    -0.04997224f, 0.03868778f, 0.05591723f, -0.01129987f, 0.10954920f, -0.02450125f, -0.01693626f, 0.06198578f, 
    0.15043190f, 0.03230606f, -0.05756370f, -0.06426000f, -0.01511167f, 0.49344063f, 0.11116191f, 0.13468070f, 
    0.05406049f, -0.06853088f, -0.07825956f, 0.08033808f, -0.03085286f, 0.04086456f, 0.02296696f, -0.04600707f, 
    0.11689421f, 0.29203880f, 0.15387231f, -0.02621417f, 0.04770868f, 0.06357454f, -0.00117853f, 0.05980851f, 
    -0.05741071f, 0.01735174f, -0.02755583f, 0.05385516f, 0.42115846f, 0.00528975f, 0.06072357f, -0.16680042f, 
    -0.01246169f, -0.09436611f, -0.11857892f, 0.07461278f, 0.04950299f, 0.20122273f, 0.06405866f, -0.09868512f, 
    -0.18828206f, -0.11361490f, 0.16927831f, 0.22785287f, -0.05664794f, 0.04756571f, -0.04574148f, -0.00513705f, 
    -0.00212427f, -0.06284923f, 0.02741335f, -0.02158253f, -0.23064254f, -0.12170818f, 0.11562381f, -0.03040646f, 
    0.19162472f, -0.01952364f, 0.15241621f, 0.17437373f, -0.04767545f, -0.03581582f, -0.13138287f, -0.06480305f, 
    -0.10905933f, -0.08156043f, -0.04434400f, -0.43710256f, -0.08047427f, 0.03741168f, 0.06491447f, 0.03125778f, 
    0.01488182f, -0.03154231f, 0.15299349f, 0.10839445f, 0.26322365f, 0.15399964f, -0.12991670f, -0.21255593f, 
    -0.08441316f, -0.23407404f, -0.05518728f, 0.13402140f, 0.15775248f, -0.04944342f, 0.16445185f, 0.06444923f, 
    0.11475562f, 0.09980007f, 0.13498291f, 0.19254968f, -0.21577953f, -0.06275342f, -0.03435721f, 0.02105384f, 
    -0.02734141f, 0.05463686f, 0.05006798f, 0.02600616f, -0.03594081f, 0.14432697f, -0.26077074f, 0.08321955f, 
    0.06957835f, -0.09790237f, -0.04164715f, 0.22406793f, 0.05389672f, 0.04750639f, 0.11478700f, -0.06379478f, 
    -0.03928632f, -0.14581712f, -0.10572848f, 0.12046781f, 0.04074631f, 0.02955273f, -0.05406428f, -0.13693754f, 
    -0.03491232f, 0.08067271f, -0.21701339f, 0.09951018f, -0.06354552f, 0.18432112f, 0.05278474f, -0.01373126f, 
    0.10182123f, -0.00412542f, 0.06756853f, -0.13291618f, -0.13078460f, -0.00383545f, -0.08511961f, 0.18000402f, 
    0.17503515f, 0.11337437f, 0.15199517f, 0.10571018f, 0.13841243f, 0.16234903f, 0.05709544f, 0.22758813f, 
    0.07221885f, 0.09632473f, -0.06491575f, -0.03300517f, 0.39694062f, 0.31884390f, 0.24022938f, 0.01184634f, 
    0.06441688f, -0.03005580f, 0.01637399f, 0.16610390f, -0.00551810f, -0.12241708f, 0.02249535f, 0.09533972f, 
    -0.03499290f, -0.02231667f, 0.04550363f, -0.06131354f, -0.01615544f, 0.17371178f, 0.03247150f, 0.03485765f, 
    -0.01918405f, -0.15370189f, -0.17906380f, 0.10051546f, 0.30669060f, -0.14707235f, 0.21974106f, 0.14107570f, 
    -0.01563015f, -0.07467985f, -0.00084752f, 0.04226520f, 0.02574505f, -0.03207922f, -0.05636417f, 0.08467928f, 
    -0.04037071f, -0.04615670f, 0.09660472f, 0.02239051f, -0.01747649f, -0.02957075f, 0.19172898f, 0.05301356f, 
    -0.11660694f, -0.16142248f, -0.09418340f, -0.11253616f, 0.04523324f, 0.42209193f, 0.02094441f, 0.26970071f, 
    0.06254672f, -0.01103098f, -0.01344777f, 0.30005953f, 0.02068258f, -0.07605874f, 0.02639927f, -0.00393764f, 
    0.18524852f, -0.03745346f, -0.23337536f, -0.15479839f, -0.02967900f, -0.09517571f, 0.03003290f, 0.17633615f, 
    0.03313294f, 0.20878182f, 0.14727846f, 0.12729862f, 0.25870419f, 0.12976368f, 0.11380944f, -0.07993163f, 
    0.15632102f, 0.06745065f, 0.07068875f, -0.05095787f, 0.06721869f, -0.00117371f, -0.08976608f, 0.08520643f, 
    0.01684297f, 0.19686104f, 0.06089221f, 0.03035786f, 0.09023490f, 0.03685442f, 0.08440506f, -0.08286949f, 
    0.02734360f, -0.23528667f, -0.16797586f, -0.06525455f, -0.11444471f, 0.09422883f, 0.06034349f, 0.12818341f, 
    0.00366688f, -0.05283296f, 0.02022528f, 0.11384063f, -0.05301473f, -0.04512103f, 0.18869579f, -0.07610974f, 
    0.16288774f, -0.06487915f, -0.20022151f, -0.03530626f, 0.04357901f, 0.00375897f, 0.08940868f, -0.02648758f, 
    -0.14318159f, 0.08032436f, 0.03664041f, -0.02135014f, -0.10594710f, 0.35598779f, 0.04836017f, -0.09943948f, 
    0.03411359f, 0.10493824f, -0.05956402f, 0.07999508f, 0.09419274f, -0.10408922f, -0.16094819f, 0.06017477f, 
    -0.51004553f, -0.12563129f, 0.43570089f, 0.19843441f, 0.00817113f, -0.12529621f, -0.22528267f, -0.04418277f, 
    0.05584606f, -0.08000945f, -0.05528295f, -0.06842174f, 0.08613260f, -0.21266985f, 0.03928595f, -0.16038662f, 
    -0.08878417f, -0.07116410f, 0.16020876f, -0.06704543f, 0.12502365f, 0.00921317f, -0.16414531f, -0.06256437f, 
    -0.26933610f, -0.19344008f, 0.05194123f, -0.08495004f, 0.11047811f, 0.02733474f, -0.08237784f, -0.06175680f, 
    0.12130135f, -0.01461983f, 0.17360200f, 0.16797075f, -0.20755284f, -0.04948769f, 0.19030461f, 0.14451088f, 
    -0.03900826f, -0.02311716f, -0.04864489f, -0.11324258f, 0.06297117f, -0.05513752f, -0.08239524f, 0.04284501f, 
    0.08309481f, -0.09391493f, 0.07775122f, -0.00856401f, 0.04080198f, 0.06433807f, -0.10155754f, 0.10533851f, 
    -0.07333793f, -0.15393734f, -0.00167193f, -0.01485600f, 0.26430574f, -0.08698890f, -0.12352248f, -0.17649469f, 
    -0.14646769f, 0.06701952f, -0.06723765f, -0.08614758f, 0.07718802f, -0.01014857f, -0.16535394f, -0.07275850f, 
    0.34922332f, -0.05054082f, 0.00450378f, -0.13530433f, -0.12999798f, 0.04788496f, -0.07944091f, 0.01879212f, 
    0.05205815f, 0.00577325f, -0.10205720f, -0.16353960f, 0.31336176f, 0.00197142f, 0.39682084f, 0.08038127f, 
    0.02951032f, 0.03423911f, 0.10642451f, 0.07185137f, 0.02667230f, -0.02600094f, 0.14442049f, -0.12264308f, 
    0.00010042f, 0.12727514f, 0.07611292f, 0.02885619f, 0.02298122f, 0.04731300f, -0.06074044f, -0.09464206f, 
    0.07675214f, 0.05377778f, -0.10825515f, 0.03637760f, 0.09818450f, -0.22982997f, -0.05477576f, -0.00965833f, 
    0.29908788f, -0.00978575f, -0.08508658f, 0.20898522f, -0.04254399f, -0.07904187f, -0.01150786f, -0.10019217f, 
    0.00411785f, -0.04240652f, -0.05504565f, -0.05355181f, 0.00456308f, 0.02514636f, 0.02375050f, 0.03902372f, 
    0.03160962f, 0.02743549f, -0.02189335f, -0.04413967f, 0.04026712f, -0.05277806f, -0.00200679f, -0.03085207f, 
    -0.05510783f, -0.01385237f, 0.00042015f, -0.00621745f, 0.03185937f, 0.01238071f, 0.01680453f, 0.00604279f, 
    -0.05245411f, -0.03072001f, -0.02816983f, -0.03421732f, 0.01631336f, -0.01980268f, 0.03817866f, -0.01507774f, 
    -0.00598194f, -0.03847134f, -0.04338045f, -0.01931464f, -0.00129149f, -0.03722987f, -0.04881844f, -0.03771453f, 
    -0.00914283f, 0.03091661f, 0.00163630f, 0.02041179f, -0.06736922f, -0.00144410f, -0.05095459f, 0.04113781f, 
    0.03459146f, -0.05376100f, 0.01497396f, -0.04686676f, 0.01777676f, 0.01303808f, -0.03952213f, 0.00860083f, 
    0.00580126f, -0.01576317f, -0.02300726f, 0.03193228f, 0.01721298f, -0.03707099f, -0.00166045f, -0.03570136f, 
    -0.03565367f, -0.04299003f, -0.04213907f, 0.04297994f, 0.00929748f, -0.02026015f, 0.02119381f, 0.00065222f, 
    -0.03285825f, 0.04367476f, 0.00425967f, -0.04660071f, 0.00896295f, 0.01908118f, -0.03602779f, 0.03490000f, 
    0.02500240f, 0.00020209f, -0.01854979f, 0.02331199f, -0.03410075f, -0.04129225f, 0.01446829f, 0.03723059f, 
    0.02218734f, 0.00512116f, -0.04771076f, 0.00376561f, -0.03956269f, 0.02466800f, 0.00276596f, 0.03312171f, 
    0.00200522f, -0.05762954f, -0.03469754f, -0.02118113f, 0.00596797f, -0.01383048f, -0.04652514f, 0.02305063f, 
    -0.04916719f, 0.03924843f, 0.00732330f, -0.04819127f, -0.00528726f, -0.00821023f, 0.01899329f, 0.04017293f, 
    -0.00059002f, -0.01667010f, 0.00821799f, 0.03236847f, 0.02009399f, -0.05631056f, -0.04635675f, -0.02188181f, 
    0.01851652f, -0.00391767f, 0.02122259f, -0.04630010f, -0.05548335f, 0.01039007f, -0.01678145f, 0.00089286f, 
    -0.04126284f, -0.01153304f, -0.04518922f, -0.03973564f, -0.05399239f, 0.03576948f, -0.04348186f, 0.04490706f, 
    -0.01811209f, 0.03441762f, 0.00880244f, -0.00670022f, 0.00755564f, 0.02785048f, -0.04214831f, 0.00464951f, 
    0.02412618f, -0.04588110f, -0.01528082f, -0.04282575f, -0.02007606f, -0.01426249f, 0.01417160f, -0.01512745f, 
    0.00401070f, 0.01260362f, 0.02596780f, -0.03226420f, -0.00116683f, -0.04885245f, -0.03192350f, 0.03365060f, 
    -0.00713246f, -0.05538834f, -0.04285592f, -0.02729358f, 0.01227785f, 0.00378736f, -0.05421527f, 0.00157806f, 
    -0.01934219f, -0.04523475f, 0.01437392f, -0.00905719f, 0.02864361f, 0.04248923f, -0.01468200f, -0.04801793f, 
    -0.00786782f, 0.03647967f, 0.00586638f, 0.00401501f, -0.00580757f, -0.02761277f, -0.02545105f, 0.03004055f, 
    -0.00469830f, -0.02706772f, 0.03422837f, -0.04822214f, -0.05430223f, -0.01459495f, 0.03219455f, -0.03969640f, 
    -0.04684881f, -0.02628578f, 0.00811740f, -0.00535215f, -0.05139390f, -0.02098830f, 0.01445641f, -0.02778477f, 
    -0.01684700f, -0.03521625f, -0.02071625f, -0.03658967f, -0.05641297f, 0.04510341f, -0.02475767f, 0.01321819f, 
    0.02766361f, 0.00767039f, 0.01443456f, 0.03468203f, -0.00957939f, -0.04300655f, -0.02103275f, -0.01375467f, 
    -0.03164610f, 0.02021110f, -0.02750213f, -0.05020540f, -0.04782166f, -0.04604938f, 0.03540780f, 0.00960407f, 
    0.04321900f, -0.00890730f, -0.03418280f, 0.01905186f, -0.03384266f, -0.03343225f, -0.02711809f, -0.05974898f, 
    -0.04138457f, -0.00224880f, 0.02081043f, 0.00229542f, 0.00270855f, 0.01048692f, -0.03023449f, -0.03546498f, 
    -0.02800860f, -0.02020607f, -0.01976667f, 0.02661545f, -0.00053923f, 0.03424161f, -0.04180174f, -0.00934212f, 
    -0.01257884f, -0.02787290f, -0.05336334f, -0.02423449f, 0.00539141f, -0.03672586f, -0.00772570f, 0.00144988f, 
    -0.02239292f, 0.02610058f, -0.01531259f, -0.02277131f, -0.03170798f, 0.04325823f, 0.00210090f, 0.00516024f, 
    -0.02574527f, 0.00130858f, -0.02951839f, -0.01941502f, 0.04327132f, 0.03171569f, -0.04107804f, -0.00157669f, 
    -0.00638160f, -0.00611436f, -0.03770554f, -0.03096977f, 0.02339198f, -0.01263295f, -0.04625855f, 0.02183129f, 
    0.01725134f, -0.02993214f, -0.02278024f, -0.04715435f, -0.02375130f, 0.01008664f, 0.01323414f, -0.02588268f, 
    0.01599243f, 0.02599264f, -0.03351210f, -0.04524256f, -0.04855838f, -0.00014029f, -0.05908839f, 0.03611900f, 
    -0.05593277f, 0.02908383f, 0.01452744f, -0.01762752f, -0.03661974f, -0.03525613f, -0.04572628f, 0.02370615f, 
    -0.00056515f, 0.04354782f, -0.05259387f, 0.03596593f, -0.03370869f, 0.03883949f, 0.01491913f, -0.04121791f, 
    0.03268252f, 0.03386694f, -0.04295303f, -0.01279563f, -0.03157641f, -0.01560449f, -0.05284582f, 0.01254840f, 
    0.00143225f, -0.00441221f, 0.01220230f, 0.02965216f, 0.04126096f, -0.00998409f, 0.03767261f, 0.02523042f, 
    0.00691672f, -0.00877745f, -0.04931669f, 0.02144147f, 0.00786189f, 0.00626189f, -0.01856659f, 0.03701670f, 
    -0.03728148f, 0.00847525f, 0.02053685f, -0.00712467f, -0.04095759f, 0.03725257f, 0.03416555f, 0.01396391f, 
    -0.01236021f, 0.02973107f, -0.04586100f, -0.04823334f, -0.03035711f, -0.02563572f, -0.00042897f, -0.02264678f, 
    -0.04384246f, -0.04261506f, -0.05472353f, -0.03794913f, -0.02441001f, -0.01183595f, -0.05825121f, -0.00934886f, 
    -0.02639732f, -0.03051978f, 0.00035012f, 0.02016887f, 0.00421622f, -0.03368994f, -0.00303413f, -0.00407388f, 
    -0.01729362f, 0.00865819f, -0.01791976f, -0.01917478f, -0.02810754f, 0.02486165f, 0.00582965f, 0.00018770f, 
    0.01223222f, -0.04121476f, -0.03262603f, 0.01190943f, -0.04803386f, -0.02718236f, 0.02801056f, 0.00332944f, 
    0.01958239f, -0.06479497f, -0.03310065f, -0.04196304f, -0.05184690f, -0.04204190f, 0.01392656f, 0.01189670f, 
    -0.02409411f, -0.04594906f, -0.04063743f, -0.04695872f, -0.00382786f, 0.03581985f, 0.01256813f, -0.02813158f, 
    -0.03108807f, -0.04512422f, 0.02937178f, 0.04059181f, 0.01278762f, -0.00975622f, -0.02035740f, 0.03427024f, 
    -0.03137270f, 0.01487376f, 0.05023052f, 0.00100040f, -0.01041728f, 0.01362810f, 0.02821160f, 0.00034100f, 
    -0.01710229f, -0.04587875f, 0.02145060f, 0.01723745f, -0.00808265f, -0.04455725f, 0.01366064f, 0.03235751f, 
    -0.06437979f, -0.06474148f, -0.01921882f, -0.06371563f, -0.04395899f, -0.01154323f, 0.04403610f, 0.02106108f, 
    0.02749877f, 0.02167991f, 0.00116607f, 0.03953177f, -0.00527077f, 0.01447103f, -0.02390467f, 0.03017541f, 
    -0.03990299f, 0.02124892f, -0.03707958f, -0.04067281f, 0.02298957f, -0.02925910f, 0.00146095f, -0.02420133f, 
    -0.00437588f, -0.00263364f, -0.04305046f, -0.02613058f, -0.00185646f, -0.05366177f, -0.04429309f, -0.04737941f, 
    0.00635235f, 0.02273432f, -0.01449474f, -0.02983898f, -0.03647274f, -0.03700200f, -0.04420795f, 0.03632979f, 
    0.02134489f, -0.04262799f, 0.01493782f, -0.01029637f, 0.02208232f, -0.02878499f, -0.02562209f, 0.03378730f, 
    -0.03423866f, -0.03725367f, -0.01016226f, 0.02465276f, -0.01123416f, -0.04731256f, 0.03812123f, -0.00057739f, 
    -0.04680876f, -0.03907678f, -0.04897685f, 0.01374684f, -0.05699088f, -0.01851794f, 0.03112035f, 0.02835241f, 
    0.02807733f, -0.05696564f, 0.00798362f, -0.04563029f, -0.06206145f, 0.00035124f, -0.03269733f, -0.03595945f, 
    0.03109147f, -0.05343941f, -0.05369204f, 0.03965398f, -0.01660082f, -0.03042511f, -0.00143088f, -0.03974774f, 
    -0.03292519f, -0.01530762f, -0.01677703f, -0.00419686f, 0.03816297f, 0.01214258f, 0.03980685f, -0.03135465f, 
    -0.04908754f, -0.03489648f, 0.00477216f, -0.00409974f, -0.03490942f, -0.04874483f, 0.02059809f, 0.02482961f, 
    -0.02892727f, -0.06176851f, 0.01078691f, -0.01124977f, 0.00119147f, -0.06812973f, -0.00974113f, -0.04208683f, 
    -0.01773760f, -0.00302278f, 0.03447526f, 0.04306423f, 0.01997439f, -0.03543616f, 0.02299647f, 0.01716060f, 
    -0.05421594f, -0.04890237f, 0.01996349f, 0.03560792f, -0.00199824f, -0.04157902f, 0.02462549f, 0.00018928f, 
    -0.01981864f, -0.05445098f, 0.02221597f, 0.00973740f, -0.00463680f, -0.04851425f, 0.02117551f, 0.03147937f, 
    -0.00008939f, 0.03585652f, 0.05223406f, -0.02731013f, -0.03632868f, 0.00406973f, 0.00750373f, 0.02463930f, 
    -0.02032996f, 0.01408140f, 0.04388734f, -0.05589925f, -0.00511604f, -0.06474774f, -0.03230593f, -0.05911911f, 
    0.00239878f, -0.00195535f, 0.02642369f, -0.00225209f, -0.05504493f, 0.00297210f, -0.04398898f, 0.01430396f, 
    -0.02392438f, -0.00493884f, -0.03496730f, 0.03348197f, -0.00838421f, -0.00595992f, 0.03128319f, 0.01840470f, 
    -0.01406392f, 0.00822259f, -0.05659909f, 0.03542322f, 0.03021042f, 0.02366827f, -0.04360360f, 0.01603969f, 
    -0.01869111f, 0.00774500f, 0.03655837f, 0.03051851f, 0.01093974f, -0.05338892f, -0.00603673f, -0.03738763f, 
    -0.01818964f, 0.02414222f, -0.02348623f, 0.03885078f, -0.05221591f, -0.02088299f, -0.02947981f, 0.02012648f, 
    -0.03275222f, -0.04985946f, 0.02878089f, 0.01007641f, 0.04810134f, 0.05338177f, 0.03682378f, 0.01401904f, 
    0.04617896f, -0.03900251f, 0.00362714f, 0.01403967f, 0.00719731f, -0.03277264f, -0.02611143f, -0.02114840f, 
    0.02356104f, 0.03059511f, -0.04146397f, 0.05560271f, 0.04713017f, -0.03916351f, -0.03242885f, -0.00167610f, 
    0.02527140f, 0.02884392f, -0.02197555f, 0.00768453f, -0.04521576f, 0.00782012f, -0.02346973f, -0.01704074f, 
    -0.05470474f, -0.05121664f, 0.02074272f, -0.04517254f, 0.01549032f, -0.00206623f, 0.00190765f, -0.03109154f, 
    0.00030639f, -0.01086050f, -0.00744186f, -0.05884436f, 0.02115550f, -0.02433391f, -0.05328441f, -0.05023184f, 
    -0.03300506f, -0.04182642f, -0.02248910f, -0.01319174f, -0.00265080f, -0.01608534f, -0.00392731f, 0.00238455f, 
    -0.04552831f, -0.06704000f, -0.02654482f, 0.03719793f, -0.05362082f, -0.04893183f, -0.04494195f, -0.00662363f, 
    0.01291087f, 0.03585789f, -0.01522483f, 0.03665275f, 0.03658779f, -0.02895920f, -0.05841704f, 0.02619295f, 
    0.02123735f, 0.00181838f, 0.01108189f, 0.00691296f, 0.03542643f, -0.05477790f, -0.00882845f, -0.04315193f, 
    -0.01432207f, 0.04718443f, 0.00882425f, 0.04134507f, -0.02297386f, -0.01367505f, 0.03994533f, 0.03699073f, 
    0.00732196f, 0.00702819f, -0.00674495f, 0.05168122f, -0.02327036f, -0.06357796f, -0.00659464f, 0.00205743f, 
    0.03321979f, -0.04392065f, 0.03535860f, 0.01937357f, -0.00151293f, -0.02415229f, -0.01521455f, -0.01657326f, 
    -0.00449875f, -0.03659360f, -0.01564874f, -0.01101177f, 0.00842521f, -0.04780633f, -0.05761736f, 0.00036765f, 
    0.03260057f, 0.00348054f, -0.01336803f, 0.02340362f, 0.02347883f, 0.00978731f, -0.05466918f, -0.03247062f, 
    -0.05431090f, -0.03850057f, -0.05215139f, -0.00195767f, -0.04219747f, 0.02806200f, 0.00613976f, -0.02061487f, 
    0.00524729f, -0.03728482f, -0.02574836f, -0.03669180f, -0.05977323f, 0.00866498f, -0.02266952f, -0.03827220f, 
    -0.02834940f, 0.00883026f, -0.00709799f, -0.04781206f, -0.07074984f, -0.02755060f, -0.01603208f, 0.01648294f, 
    -0.02601599f, 0.01990365f, -0.04062260f, -0.06738969f, -0.04306936f, -0.01152824f, -0.00664787f, -0.04106312f, 
    0.01354750f, 0.01571782f, -0.00251784f, -0.02179205f, -0.05370743f, -0.06120832f, 0.01125890f, -0.00250941f, 
    0.00896859f, -0.04471484f, -0.02214786f, 0.04392170f, -0.03612787f, 0.01814616f, 0.02885624f, 0.03100580f, 
    -0.02960479f, -0.02956047f, 0.00306064f, 0.02394439f, -0.02237270f, -0.01389029f, 0.01374826f, 0.00075654f, 
    0.02989891f, -0.02280290f, -0.00776722f, 0.00625571f, -0.02221833f, 0.00534025f, -0.00497948f, 0.02709835f, 
    -0.05399936f, -0.02235542f, 0.00858093f, -0.01429387f, 0.03438552f, -0.04511724f, -0.01744001f, -0.01464055f, 
    -0.05518198f, -0.03264805f, 0.01801886f, 0.00593124f, -0.03040163f, -0.01703919f, -0.00217160f, -0.02635525f, 
    0.03649133f, 0.00349459f, 0.00910524f, -0.01638561f, 0.00441876f, -0.02040046f, -0.04383356f, -0.02998384f, 
    -0.03171921f, -0.00533234f, 0.03788941f, -0.03957119f, -0.03158952f, -0.00005428f, -0.03448508f, 0.00678019f, 
    0.03628036f, -0.01433139f, 0.00745100f, -0.01501080f, 0.00086856f, -0.01200948f, 0.00011547f, -0.05530446f, 
    -0.00218718f, 0.03829191f, -0.05389506f, 0.02087803f, -0.02072596f, 0.00431387f, -0.01436953f, -0.04949302f, 
    0.01269278f, -0.05551544f, -0.05493583f, 0.03344999f, 0.03196716f, 0.03114315f, 0.00687839f, 0.04038300f, 
    -0.02036783f, 0.04319546f, -0.05306760f, 0.03270766f, -0.00526731f, -0.01128475f, -0.00566062f, -0.03589988f, 
    -0.01927845f, -0.04804518f, -0.03856921f, 0.00202589f, -0.02273317f, -0.03424677f, -0.02832998f, -0.06128728f, 
    0.01566800f, -0.00023643f, 0.00939883f, -0.01214932f, -0.00729056f, 0.01401572f, -0.00661412f, 0.01430980f, 
    0.03752983f, 0.01749601f, -0.04860983f, 0.04136585f, 0.00770834f, 0.00732473f, -0.01335738f, -0.01389801f, 
    -0.02847871f, -0.02529084f, -0.03809389f, 0.00986899f, -0.04648533f, 0.02914543f, -0.02956441f, -0.04758862f, 
    -0.03242518f, -0.00852251f, 0.00339578f, -0.02532930f, -0.03792444f, 0.00279479f, -0.01186525f, -0.01169936f, 
    0.03213093f, -0.04607382f, -0.03574547f, -0.01127058f, -0.04441004f, 0.01010567f, -0.00256551f, -0.01867231f, 
    0.01009726f, 0.01596611f, -0.04423851f, -0.01653350f, 0.03435928f, 0.03450229f, -0.00097920f, -0.03609924f, 
    -0.01303363f, 0.00516825f, -0.01218448f, -0.05445022f, -0.03090909f, -0.03752226f, 0.01540802f, 0.01174205f, 
    -0.03569577f, -0.03844588f, 0.02363794f, 0.01887451f, 0.01413625f, 0.03500691f, 0.03889783f, 0.02476908f, 
    0.01058635f, 0.03368327f, -0.03712950f, 0.00139543f, 0.01770114f, -0.05709998f, 0.02148056f, 0.04292719f, 
    -0.01995946f, 0.03977369f, -0.05383607f, 0.00603063f, -0.04002964f, 0.01376327f, 0.00104888f, -0.00191007f, 
    -0.00633722f, 0.02531198f, 0.00285090f, 0.02835373f, -0.00934566f, 0.02860724f, -0.03593855f, 0.02244972f, 
    -0.05661136f, -0.00669676f, -0.00889428f, -0.00180733f, -0.01404662f, -0.04297452f, 0.01101966f, -0.02107621f, 
    -0.04900644f, -0.01002132f, -0.04776209f, 0.03108093f, -0.02653811f, 0.00660900f, -0.03167542f, -0.04964346f, 
    -0.04507029f, -0.01778635f, -0.04040366f, 0.00713214f, -0.02738427f, -0.04682793f, -0.00435383f, 0.03452598f, 
    0.03094712f, -0.04156319f, -0.05340946f, -0.05310139f, 0.03795563f, 0.01452379f, -0.02350420f, -0.05343426f, 
    -0.05341967f, 0.03796158f, -0.04888486f, 0.02719333f, 0.03277526f, 0.03120032f, 0.04376548f, -0.00893497f, 
    0.02140171f, -0.04216605f, 0.03857594f, -0.01119631f, -0.04509913f, -0.01751986f, 0.03834676f, -0.02927834f, 
    0.03626950f, -0.03695892f, 0.01886762f, -0.04692075f, 0.00013727f, 0.01242305f, 0.01360342f, -0.05864047f, 
    -0.02186372f, -0.03611805f, -0.01890818f, 0.01172274f, 0.02276391f, -0.01799492f, 0.04047485f, -0.01184513f, 
    -0.01334679f, 0.00747347f, 0.04561355f, -0.01173275f, -0.01092929f, -0.04102397f, 0.03424287f, 0.00351403f, 
    -0.02063837f, -0.03318361f, 0.04129264f, 0.00595423f, -0.02889837f, 0.00584681f, -0.04505627f, 0.02040269f, 
    -0.05330350f, -0.03420812f, 0.03926548f, -0.05405042f, 0.03934520f, 0.03057447f, 0.02660344f, 0.04514230f, 
    -0.01840089f, -0.04783622f, 0.00841798f, -0.03450372f, -0.00664278f, 0.04008025f, 0.00133830f, 0.03418591f, 
    0.02427325f, -0.02592900f, -0.01779858f, 0.02074606f, -0.03260228f, -0.05716453f, -0.04124134f, -0.03831654f, 
    0.00061294f, -0.00539256f, 0.01953728f, -0.01439342f, 0.04030807f, 0.00414988f, -0.03455942f, -0.05443003f, 
    0.02177851f, 0.01753253f, -0.01303276f, 0.00807480f, -0.05348026f, 0.02596324f, -0.01253240f, 0.00444727f, 
    -0.02401751f, 0.02032526f, -0.02417783f, -0.04741252f, -0.01400725f, -0.03391194f, -0.00848166f, -0.04557713f, 
    0.02142940f, 0.02492730f, -0.00593385f, -0.05097606f, -0.00242657f, -0.02270393f, 0.01137929f, -0.00032377f, 
    0.01402660f, 0.03959341f, 0.03146618f, -0.02585751f, -0.03362348f, 0.01719910f, 0.03591390f, -0.03331384f, 
    -0.02078248f, -0.04137125f, -0.04397794f, 0.04411162f, 0.01526494f, -0.02544262f, 0.02726917f, -0.01826592f, 
    -0.03933296f, -0.02961709f, 0.02875438f, 0.03137461f, -0.05582100f, -0.05757853f, 0.01530339f, 0.01663430f, 
    0.00831135f, -0.01981335f, -0.05293157f, 0.01300369f, -0.03822874f, -0.02322870f, 0.04283036f, -0.05619005f, 
    0.01100960f, -0.00838054f, 0.00301724f, -0.05557416f, -0.00297491f, -0.03520164f, -0.00387024f, 0.04998499f, 
    0.03831977f, -0.04075911f, 0.03221607f, 0.02119106f, -0.03769741f, 0.02009867f, 0.01825998f, -0.05385463f, 
    0.01083539f, -0.00223426f, -0.03765965f, -0.05215977f, -0.04550374f, -0.05564862f, -0.05565573f, -0.00785700f, 
    -0.05610611f, -0.03366607f, 0.00653930f, 0.02798286f, 0.02807171f, 0.02981385f, 0.00975834f, -0.01257749f, 
    -0.08220951f, -0.15651652f, -0.12885548f, -0.20269901f, 0.06190075f, 0.02412747f, 0.03651959f, -0.06593493f, 
    -0.04113723f, 0.00834935f, 0.07710756f, -0.03052892f, 0.05407710f, 0.05793973f, -0.02025801f, 0.01595421f, 
    -0.04011571f, 0.02361130f, -0.03361763f, -0.01678371f, 0.06396116f, 0.07679925f, 0.24870887f, -0.18219110f, 
    -0.23020694f, -0.07544662f, -0.06289215f, 0.10519399f, 0.00649537f, 0.02661662f, 0.03496718f, 0.18254331f, 
    -0.00132383f, 0.08977612f, 0.02895697f, -0.06620183f, -0.24585561f, 0.19604939f, 0.19512255f, -0.31491879f, 
    0.20270577f, -0.09676222f, 0.06629645f, 0.15107846f, -0.02861656f, 0.04956982f, -0.02501105f, 0.03389755f, 
    0.10271022f, -0.05857790f, 0.01946290f, 0.08724180f, 0.03539190f, 0.00828975f, -0.00479614f, 0.02080684f, 
    -0.12361100f, -0.15593606f, -0.01804545f, 0.01327849f, -0.10020192f, 0.19850898f, -0.00647764f, 0.10746724f, 
    0.07574856f, 0.12116387f, 0.02234613f, -0.05826578f, 0.05368253f, 0.14442685f, 0.18560095f, 0.00363065f, 
    -0.23023839f, 0.06200109f, 0.05932070f, 0.21906911f, 0.02615979f, 0.06048992f, 0.02722856f, 0.07258622f, 
    0.03379295f, 0.09899691f, 0.07299356f, 0.08099186f, -0.20414484f, 0.16918443f, -0.08081719f, -0.33610290f, 
    -0.10454405f, 0.03332973f, -0.01800492f, -0.00784007f, -0.03502480f, 0.02222353f, 0.03236794f, -0.00316913f, 
    -0.13041274f, -0.01299467f, 0.03009941f, 0.14453310f, -0.01659455f, 0.08422630f, 0.01863508f, 0.07746595f, 
    0.06808621f, 0.12601329f, 0.00075656f, 0.16840041f, 0.20850550f, -0.06082534f, 0.08918035f, 0.06610924f, 
    0.03197138f, 0.10940906f, 0.15540719f, 0.15637748f, 0.09675338f, -0.00496600f, -0.00720772f, 0.02464103f, 
    0.23976950f, 0.32125026f, -0.11489300f, 0.06342824f, 0.13488851f, 0.12021191f, 0.18951093f, 0.22834364f, 
    0.00789024f, -0.02561253f, 0.06270503f, 0.01192605f, 0.22861859f, -0.02628154f, -0.12247550f, -0.26959828f, 
    0.15941368f, 0.06845213f, -0.04202528f, 0.04670971f, -0.05406934f, -0.07064407f, -0.29278532f, -0.05040076f, 
    -0.06463113f, 0.04654325f, 0.03912563f, -0.00363700f, 0.12482775f, -0.15219338f, -0.00943628f, -0.05824670f, 
    0.01084874f, 0.06517333f, 0.01942909f, -0.00382874f, -0.39826858f, 0.17003156f, 0.22944729f, 0.21733519f, 
    0.01817823f, 0.10784272f, 0.16923453f, 0.03881399f, 0.09652685f, -0.02712198f, -0.21105511f, -0.00434084f, 
    -0.02574709f, 0.05614249f, -0.13850145f, -0.04963479f, 0.13000964f, 0.19513088f, -0.02455434f, -0.06368767f, 
    -0.00699589f, 0.07050239f, 0.03133411f, 0.06591668f, -0.02485311f, 0.19306129f, -0.17269579f, -0.22261707f, 
    0.00636273f, -0.00239183f, -0.12016081f, 0.07240184f, 0.00943567f, -0.04469737f, 0.03863649f, -0.02358600f, 
    0.10583685f, -0.22384591f, -0.24956211f, 0.07091380f, -0.02154563f, -0.18333291f, -0.01616344f, 0.08511336f, 
    0.17493637f, 0.05368231f, -0.08137453f, -0.02735518f, 0.08332753f, 0.08392475f, 0.12449544f, -0.10018568f, 
    -0.01843486f, 0.14540274f, -0.04215527f, 0.09728883f, -0.01026978f, -0.07915901f, -0.03622853f, 0.00589119f, 
    -0.00874241f, -0.29135624f, 0.04597794f, -0.07677349f, 0.01405933f, 0.07349396f, 0.00367761f, -0.23180011f, 
    -0.08945872f, -0.16427255f, -0.11445308f, -0.12233378f, -0.13268988f, -0.09605855f, -0.01944075f, -0.00203586f, 
    -0.02549792f, 0.01075822f, 0.04029816f, 0.07044721f, -0.06112400f, 0.00105074f, 0.10119583f, 0.05242616f, 
    -0.04784757f, 0.02062531f, -0.06281807f, 0.01564050f, -0.00421542f, -0.07793304f, -0.11003212f, -0.03235345f, 
    -0.07606057f, 0.03981654f, -0.15419193f, 0.03442178f, 0.08364457f, 0.09129385f, -0.04008056f, -0.04051786f, 
    0.10193592f, 0.03587832f, 0.18200111f, 0.02303812f, 0.04975243f, 0.00814203f, 0.07891186f, -0.02492256f, 
    -0.01292775f, 0.49649978f, 0.18765123f, 0.08820482f, 0.09666863f, 0.03646242f, 0.14321126f, 0.03655211f, 
    0.04189771f, 0.06389315f, 0.06579125f, 0.04085533f, -0.06555771f, 0.15380454f, -0.19592965f, 0.11128347f, 
    -0.07211244f, 0.06744148f, 0.12592915f, 0.09147406f, -0.04708069f, 0.10056562f, 0.07984248f, -0.16960594f, 
    -0.06213456f, 0.01743298f, 0.05380478f, 0.15075947f, -0.10940460f, 0.01379995f, -0.08799329f, 0.15771303f, 
    -0.18645647f, -0.12064387f, 0.14738974f, 0.10551175f, -0.08648983f, 0.19184846f, 0.13887750f, 0.14845274f, 
    0.03695691f, 0.02194084f, 0.08788760f, -0.01497792f, -0.03450383f, 0.05702293f, -0.04395277f, 0.08449959f, 
    -0.12030294f, -0.03333592f, -0.06623878f, 0.04920471f, -0.09314816f, -0.04663750f, -0.03654405f, 0.01440826f, 
    -0.00510316f, -0.02650045f, 0.13178349f, 0.10951587f, -0.37982273f, -0.01375577f, 0.18982404f, 0.14085495f, 
    -0.02511617f, 0.06557347f, 0.04894132f, 0.10549653f, -0.02554251f, 0.18498224f, -0.17225511f, -0.10050303f, 
    -0.12943909f, 0.08535001f, -0.36719641f, 0.12861018f, -0.18437801f, -0.09168299f, -0.08867227f, 0.01597897f, 
    -0.02063957f, -0.00112546f, 0.07596166f, -0.04109059f, 0.15145722f, 0.32954711f, 0.08175126f, 0.17158510f, 
    0.11782976f, 0.03787271f, 0.21810251f, -0.09696815f, 0.04071126f, -0.05166460f, 0.01164064f, 0.08162349f, 
    0.13705099f, -0.04717198f, -0.00375964f, -0.04691596f, 0.00312102f, 0.10466038f, -0.07109305f, -0.02852316f, 
    -0.03267656f, -0.10476176f, -0.07042029f, -0.10746772f, -0.03188780f, -0.29931790f, 0.10214113f, -0.00251077f, 
    0.01663409f, 0.08324099f, -0.00496276f, 0.07978562f, 0.10144814f, -0.01724248f, 0.09081452f, 0.01348878f, 
    -0.00059764f, -0.03825201f, -0.00172347f, -0.01863740f, 0.01611403f, 0.03460506f, -0.04582217f, 0.02308937f, 
    -0.03964299f, -0.04145680f, 0.04133714f, 0.03351539f, -0.03682527f, 0.03275064f, -0.01193978f, -0.01237602f, 
    0.02098497f, -0.02774958f, -0.01409570f, -0.03219259f, 0.02017729f, -0.00505145f, 0.03335201f, -0.05369034f, 
    -0.05032670f, 0.01918606f, 0.02363379f, 0.01033283f, -0.04606675f, -0.05171682f, 0.00259988f, -0.01372247f, 
    0.04322020f, -0.04936563f, -0.00096530f, 0.00796159f, -0.04248369f, 0.02591484f, -0.03720980f, 0.04166834f, 
    0.00796952f, -0.02917665f, -0.01094311f, -0.05269061f, -0.01010543f, 0.00913152f, 0.00705921f, 0.04968626f, 
    0.01921061f, 0.02812462f, -0.00825872f, 0.00606544f, -0.00361941f, -0.03794276f, -0.00629122f, -0.04682316f, 
    0.02137068f, -0.01335869f, -0.02807060f, 0.03712052f, 0.02056162f, -0.02461546f, -0.03284836f, 0.01387369f, 
    -0.01019164f, 0.03051204f, -0.00963801f, -0.01580444f, -0.01982848f, 0.00439685f, 0.01351249f, -0.05602080f, 
    -0.02414187f, 0.04170782f, 0.04471187f, 0.02325385f, -0.03774709f, -0.04694093f, -0.02988145f, -0.04959562f, 
    0.00945830f, 0.04002788f, -0.05052712f, -0.01619910f, -0.05510017f, -0.00138838f, -0.03674331f, 0.04330020f, 
    -0.01943264f, 0.00990170f, -0.01931954f, 0.03981158f, -0.05238221f, -0.03875405f, -0.02097509f, 0.02129356f, 
    -0.02801845f, 0.00484857f, 0.03319454f, -0.00280275f, -0.00505064f, -0.02657527f, -0.02993091f, -0.05364652f, 
    -0.04449359f, 0.00089258f, 0.02240415f, 0.03018647f, -0.02080569f, -0.05696706f, -0.01197520f, -0.04395398f, 
    0.03666179f, -0.03022395f, -0.04324257f, 0.03207349f, -0.03878597f, 0.00405140f, -0.03374809f, -0.03519690f, 
    0.01614010f, -0.04174555f, 0.02856380f, 0.00549447f, -0.04603107f, -0.04512293f, 0.04417656f, 0.00635121f, 
    -0.05566634f, -0.05596917f, -0.03606475f, -0.00085686f, -0.03095060f, -0.02504438f, -0.00785054f, 0.03204308f, 
    0.01915064f, 0.02267877f, 0.02924534f, -0.00313390f, -0.02153241f, 0.02451067f, 0.03506133f, -0.02445567f, 
    -0.01326361f, -0.04017727f, 0.03327031f, 0.04099811f, 0.03935215f, -0.04681787f, 0.03789324f, -0.01129907f, 
    -0.01699894f, 0.03748306f, -0.00303125f, -0.03812096f, 0.04354455f, 0.03894533f, 0.04296260f, -0.04773450f, 
    -0.00446271f, 0.04427274f, -0.05627597f, 0.00358438f, -0.02716829f, -0.04925890f, 0.04226700f, 0.03906849f, 
    0.00316631f, -0.05266793f, 0.02751189f, 0.00927452f, -0.00248897f, 0.02393267f, -0.01238659f, 0.03690643f, 
    0.03627894f, -0.01447111f, -0.04385706f, -0.02845545f, -0.04366135f, 0.04328181f, -0.05630730f, 0.03640944f, 
    -0.03463400f, -0.01779629f, 0.00079158f, -0.03262366f, -0.02156434f, -0.00578605f, 0.01257927f, -0.02420459f, 
    -0.02080506f, -0.03538466f, -0.01163240f, 0.02977913f, -0.02964716f, -0.00402981f, 0.03856812f, -0.03877847f, 
    0.04482493f, 0.00591897f, -0.05471578f, -0.01663917f, -0.05386773f, 0.02405478f, -0.03199314f, -0.01125153f, 
    -0.02334557f, -0.00279876f, 0.00684332f, -0.04863285f, 0.01490778f, 0.03291753f, 0.02541322f, 0.00914854f, 
    0.02514719f, -0.01220967f, 0.00472707f, -0.05408658f, -0.03924824f, 0.01404493f, -0.02268620f, -0.02205630f, 
    0.01152232f, -0.01778802f, -0.01261111f, 0.04491511f, 0.00130811f, 0.01401991f, 0.04330621f, 0.00751802f, 
    -0.02243094f, -0.04815873f, 0.01949329f, -0.00565053f, -0.04136679f, -0.05285440f, -0.02611209f, -0.05237501f, 
    -0.00757686f, 0.03915897f, 0.01684424f, -0.03985953f, 0.02678666f, -0.05154794f, -0.02196682f, -0.01135171f, 
    -0.02238348f, -0.02268374f, 0.00865387f, -0.03389715f, -0.00155195f, 0.01054540f, -0.04700845f, -0.04189513f, 
    0.03015690f, 0.02125182f, 0.00469756f, -0.05679111f, -0.02921746f, -0.00170769f, 0.00057452f, 0.00845249f, 
    -0.00238375f, -0.02978893f, 0.00884321f, -0.02794614f, 0.03964354f, 0.03496563f, 0.04399787f, -0.00032077f, 
    0.01407183f, -0.01355681f, 0.03097275f, 0.01227197f, -0.02554888f, -0.02134924f, -0.05576393f, -0.01951085f, 
    -0.03800795f, -0.03887456f, -0.01198265f, -0.03304287f, 0.00577461f, -0.02319455f, -0.00159931f, 0.00943045f, 
    0.03806515f, -0.04522562f, 0.01243203f, -0.00381083f, -0.00515136f, -0.03834432f, -0.02157217f, 0.03156204f, 
    -0.00488656f, -0.03031814f, 0.00771650f, 0.01586849f, 0.02655073f, -0.01823623f, -0.00189246f, 0.00785292f, 
    -0.03359445f, -0.01922189f, -0.03787181f, -0.05012292f, -0.03394271f, 0.01106948f, 0.00987406f, -0.00731689f, 
    -0.04086208f, 0.03696598f, 0.00181798f, -0.03690593f, -0.05518833f, 0.04263917f, 0.04385670f, 0.04467444f, 
    0.04456586f, -0.00488585f, 0.01434353f, 0.03047674f, 0.00235146f, 0.01423352f, -0.02852179f, -0.01751611f, 
    -0.04189251f, -0.02086300f, 0.02090880f, 0.03249507f, -0.04898216f, -0.01260568f, 0.01636466f, -0.03006089f, 
    -0.03623908f, 0.01342561f, -0.05154015f, 0.00283736f, 0.00310774f, -0.01308864f, -0.05260780f, 0.02711951f, 
    -0.03978087f, -0.00859694f, 0.00883726f, 0.00725748f, 0.02393581f, 0.04284601f, 0.01925621f, -0.05240107f, 
    0.02831605f, 0.00858604f, -0.01998836f, -0.02326414f, -0.01193307f, 0.02851195f, -0.00804849f, -0.04282574f, 
    0.03537855f, -0.03325014f, -0.02028208f, -0.03917188f, -0.02175440f, 0.00433461f, 0.03038814f, 0.03905713f, 
    -0.02965565f, -0.01849045f, -0.02068138f, -0.00050104f, 0.00642243f, -0.02594642f, 0.04118302f, 0.00374769f, 
    0.03245717f, -0.00040333f, 0.01082068f, -0.01687392f, -0.05090379f, -0.00950968f, 0.02100156f, -0.03898590f, 
    -0.18250082f, -0.14286748f, -0.01222016f, -0.17598417f, 0.12770137f, 0.11387905f, 0.04979520f, -0.13240559f, 
    0.05279720f, 0.03908404f, 0.04820684f, 0.06658962f, 0.12539692f, 0.08934584f, -0.06179204f, -0.05420289f, 
    -0.05096381f, -0.03976849f, 0.01271948f, -0.03012505f, -0.00766108f, 0.01691483f, 0.06448712f, -0.18734422f, 
    -0.00075850f, 0.12413061f, -0.00482861f, 0.01857941f, -0.02635283f, -0.06301954f, -0.05524215f, -0.02864818f, 
    0.01594405f, -0.04004382f, -0.13370506f, 0.03714316f, -0.21355216f, 0.13901524f, 0.01297467f, -0.22148769f, 
    -0.03975138f, -0.23319741f, -0.16119321f, -0.02653234f, -0.09469946f, 0.04434205f, -0.01019826f, 0.07412657f, 
    -0.12999198f, -0.13387190f, -0.10574765f, -0.16276576f, -0.04841395f, -0.05253740f, -0.03648283f, 0.04380735f, 
    0.03770976f, -0.00933266f, -0.01814016f, 0.13520665f, 0.27241984f, -0.06726309f, 0.02778484f, 0.04002782f, 
    -0.11906980f, 0.05711884f, -0.04342829f, 0.05959117f, -0.03304803f, -0.10357182f, -0.01516246f, -0.02636509f, 
    0.05508532f, -0.04824692f, 0.02023041f, -0.10303988f, 0.02802050f, 0.00531077f, -0.08701915f, -0.07635315f, 
    -0.17374121f, 0.00764077f, 0.17212906f, -0.06116642f, 0.32211015f, 0.23017803f, -0.01753407f, -0.33437034f, 
    -0.02747310f, -0.15803671f, -0.08084154f, 0.15052082f, -0.00454336f, 0.03882957f, 0.04159244f, -0.17563151f, 
    0.01992231f, 0.23394945f, -0.09520372f, -0.00749198f, -0.01008746f, 0.04825347f, -0.01116642f, -0.06637766f, 
    0.01847515f, 0.06114851f, 0.09976508f, 0.02887906f, -0.04854611f, 0.15295959f, -0.35750353f, 0.32275864f, 
    0.06452516f, 0.04736406f, 0.34119314f, -0.10422342f, 0.10388971f, 0.02979539f, -0.14723843f, 0.07492422f, 
    -0.05325853f, -0.00586566f, -0.20422895f, -0.12793751f, 0.06646402f, 0.02677229f, 0.05586394f, 0.33410326f, 
    0.06195413f, 0.01336543f, -0.07963453f, 0.05633397f, -0.08418706f, 0.08772451f, -0.14608663f, 0.01163378f, 
    -0.00676728f, 0.00215943f, 0.00545468f, -0.06912208f, -0.00033253f, 0.00819223f, -0.03198293f, 0.16006134f, 
    -0.13349965f, -0.05874813f, -0.06987403f, -0.16705708f, -0.02332875f, 0.06865553f, 0.14687431f, 0.02059497f, 
    0.14999776f, 0.13512470f, 0.20258649f, 0.09546238f, 0.22190617f, -0.29595792f, 0.08088470f, -0.12448562f, 
    -0.11873326f, 0.04589863f, 0.00150532f, -0.00951595f, 0.01602906f, 0.06764229f, 0.09404967f, -0.06966187f, 
    -0.26371479f, -0.10748427f, -0.10138162f, -0.14927626f, -0.14240299f, -0.18220668f, -0.00580883f, -0.11458953f, 
    -0.00523648f, -0.02669935f, 0.09230212f, 0.01695849f, -0.23838428f, -0.02958437f, -0.08401961f, -0.09997471f, 
    -0.02876928f, 0.10196631f, -0.26056519f, 0.12297466f, -0.03855217f, 0.04408615f, 0.07060147f, 0.14952043f, 
    0.14052112f, 0.01368921f, -0.12851779f, 0.08196443f, -0.05565332f, -0.07843095f, 0.16122979f, 0.17413224f, 
    0.07622388f, 0.02994311f, 0.16215937f, 0.00754602f, 0.12010858f, -0.06833565f, 0.30051988f, -0.06329665f, 
    0.17824821f, 0.15172255f, 0.14776620f, -0.02152018f, 0.08287635f, -0.00352864f, -0.01015604f, -0.11835915f, 
    -0.28343219f, -0.13982713f, 0.04253727f, 0.01574510f, 0.03878633f, 0.08279223f, 0.36277580f, 0.08518907f, 
    -0.03437474f, 0.06516434f, 0.09593550f, 0.09274847f, -0.04814075f, 0.03396809f, -0.04229366f, -0.01199722f, 
    -0.14926639f, -0.13894185f, -0.11566384f, -0.03997195f, -0.07107830f, -0.05232310f, -0.09497575f, -0.31729090f, 
    -0.21659979f, -0.02451192f, 0.03448341f, -0.09904785f, -0.03350659f, -0.09300477f, 0.04466857f, -0.01011715f, 
    -0.02762899f, -0.00533756f, -0.14315335f, 0.02570235f, 0.08055190f, 0.17425784f, -0.00318523f, 0.17418994f, 
    0.06069918f, -0.01051982f, 0.11352699f, 0.22831744f, -0.02161415f, 0.03746974f, 0.07788345f, 0.08065332f, 
    0.08373618f, -0.04573775f, 0.04809780f, -0.14306924f, 0.01112069f, 0.03517071f, -0.13882072f, 0.01989738f, 
    0.00523151f, -0.03512180f, -0.06756765f, -0.06664170f, 0.23788057f, 0.05373178f, -0.05462225f, -0.03310924f, 
    -0.02406768f, -0.09128702f, 0.07211757f, 0.07369489f, 0.15064840f, 0.14121059f, -0.09492380f, -0.01247391f, 
    -0.06697883f, -0.18520781f, -0.03065167f, 0.04479065f, 0.12952995f, -0.07497134f, 0.10745963f, 0.04517451f, 
    -0.03177740f, -0.00733576f, 0.14984410f, 0.08504125f, -0.13426234f, 0.20907627f, 0.24072881f, 0.00520863f, 
    0.02381199f, 0.00733159f, 0.07062779f, -0.05994821f, 0.07889602f, 0.01358468f, -0.08304337f, -0.09252883f, 
    -0.11833615f, -0.03488136f, -0.00480742f, -0.08570889f, -0.22417936f, -0.12401351f, -0.04053086f, -0.09947606f, 
    -0.01237238f, -0.01096315f, -0.01164230f, -0.01540385f, -0.09145476f, -0.26689786f, -0.08542072f, -0.17255886f, 
    -0.14459474f, -0.01738480f, 0.04052133f, -0.05591938f, 0.02671062f, 0.04504343f, 0.02432789f, 0.00174789f, 
    0.15202940f, 0.21416232f, 0.14002298f, -0.13322845f, -0.05789087f, -0.02846605f, 0.08252166f, 0.04674725f, 
    0.16007079f, 0.03669889f, 0.05045188f, 0.11517639f, -0.05445031f, 0.07020553f, -0.05943428f, -0.16697647f, 
    -0.00504741f, -0.01164253f, 0.15669864f, 0.19336435f, -0.06515506f, -0.06914324f, 0.03267166f, 0.00534826f, 
    0.18342844f, -0.06554735f, -0.07043282f, 0.16184893f, 0.15138260f, 0.06685620f, 0.11659116f, 0.06443550f, 
    -0.00656555f, -0.03219998f, -0.04843258f, -0.20314902f, 0.16970499f, -0.05652416f, 0.00343288f, 0.13526575f, 
    -0.06114985f, 0.07889619f, -0.00049669f, -0.11961864f, -0.04244897f, -0.04543903f, 0.02636711f, 0.07768171f, 
    0.06425693f, -0.02219284f, -0.11957753f, 0.01093934f, 0.07718562f, 0.02955579f, 0.03373172f, -0.03319492f, 
    0.12040216f, 0.01912873f, 0.03291365f, 0.00988991f, -0.13784508f, -0.05271410f, -0.06180076f, 0.05004766f, 
    -0.03811869f, -0.03144919f, -0.01946576f, -0.01123780f, 0.03851405f, -0.14882892f, 0.11768743f, 0.03968177f, 
    -0.01954427f, 0.07219020f, -0.09815119f, -0.07970033f, 0.01526141f, -0.02244622f, -0.06238804f, 0.08859552f, 
    -0.00094944f, -0.00436855f, 0.02565354f, 0.09588441f, -0.34968448f, -0.16483712f, 0.21878229f, 0.19285537f, 
    -0.11956566f, 0.24960917f, 0.02676470f, 0.08356415f, -0.02622875f, -0.10687826f, -0.02584009f, 0.02801856f, 
    0.20346405f, 0.08855580f, -0.27365550f, 0.29974684f, -0.02309469f, -0.06763569f, -0.08967482f, 0.10717122f, 
    0.07358918f, -0.08724512f, 0.00238257f, -0.03723096f, -0.22477637f, -0.00582569f, 0.17705005f, 0.36175710f, 
    0.18382002f, 0.12224033f, 0.06244842f, 0.12417386f, 0.00581256f, 0.11845605f, 0.04972509f, 0.02190766f, 
    -0.12518039f, -0.09841184f, -0.09178066f, -0.09948452f, 0.04549278f, 0.05295281f, 0.07778399f, 0.02820482f, 
    0.09497929f, 0.10341477f, 0.13071890f, 0.03525498f, 0.31752035f, 0.07075930f, 0.06334055f, 0.04919910f, 
    0.00000880f, -0.12109561f, 0.07960335f, -0.02931864f, -0.03047057f, 0.09523676f, -0.10670670f, 0.21106131f, 
    0.08449177f, 0.06831531f, 0.07506359f, -0.04959356f, -0.01719969f, -0.02481737f, 0.09849329f, 0.12268585f, 
    0.10564838f, 0.03704479f, 0.09560854f, 0.06770405f, 0.45802388f, -0.09702060f, 0.26699746f, -0.20350112f, 
    0.03637590f, 0.11788031f, -0.02360202f, 0.08269468f, 0.12415206f, -0.04236462f, 0.10631309f, -0.04942989f, 
    0.16152729f, 0.22038195f, -0.04497207f, -0.22941618f, 0.15739529f, 0.11824239f, 0.09522575f, -0.13710092f, 
    -0.02372468f, -0.04111879f, 0.02688301f, -0.01535781f, 0.14491932f, -0.16020246f, -0.16351797f, -0.11384254f, 
    0.21510166f, 0.14066432f, 0.00307689f, -0.10790219f, -0.09746432f, -0.05526332f, -0.03238787f, 0.02329815f, 
    -0.03452331f, 0.00064693f, -0.05583975f, 0.10969163f, 0.06918403f, -0.21727294f, 0.06204600f, -0.08214949f, 
    -0.06201972f, 0.02073302f, -0.02022340f, -0.05974850f, -0.28030652f, 0.17521341f, -0.00928996f, -0.02813806f, 
    -0.02943028f, -0.00722486f, 0.01616212f, 0.07733289f, 0.03386058f, 0.08677433f, 0.01679394f, 0.05986298f, 
    -0.18390019f, -0.09659491f, -0.25153482f, -0.09340461f, 0.11142801f, 0.17594698f, -0.03299148f, 0.01333786f, 
    -0.03779967f, 0.05050354f, -0.04378252f, 0.11961196f, 0.27510294f, 0.09910367f, 0.20102236f, -0.20977685f, 
    0.23502280f, 0.16998152f, 0.06283808f, -0.09051119f, -0.01370418f, -0.01752044f, 0.02102154f, 0.03228366f, 
    -0.17724241f, -0.15060501f, -0.08772652f, 0.25099635f, 0.11326153f, 0.06662887f, 0.12031858f, -0.16405150f, 
    -0.00424156f, -0.00302936f, -0.22525768f, -0.09697307f, -0.16309097f, 0.28639257f, -0.23859680f, -0.06636481f, 
    -0.13929923f, 0.12986036f, 0.11105987f, 0.10706934f, -0.07553755f, 0.02802776f, 0.03384853f, 0.03966641f, 
    0.36708048f, -0.07617784f, -0.19341914f, 0.18917803f, 0.11701146f, 0.06935311f, -0.14263262f, 0.05750420f, 
    -0.00271278f, -0.01404765f, -0.03795024f, 0.04146042f, -0.15891792f, -0.21133344f, -0.05831030f, -0.01761786f, 
    0.00196445f, -0.03313030f, -0.09621206f, -0.06560308f, -0.07336255f, -0.06523956f, -0.19224069f, -0.00673766f, 
    -0.30897599f, -0.08642699f, 0.04564681f, 0.11787221f, -0.11916371f, 0.02326762f, -0.03344584f, -0.10401080f, 
    -0.01613856f, -0.13776414f, 0.03307296f, -0.01894493f, 0.11012577f, -0.04269627f, -0.12989636f, 0.14349127f, 
    0.08282255f, 0.06341363f, 0.19987185f, -0.16216438f, -0.02373032f, 0.00536016f, 0.05079997f, -0.02236831f, 
    0.15203737f, 0.10545967f, -0.22034326f, -0.04194354f, 0.01139310f, 0.07942389f, 0.14171006f, 0.09637073f, 
    -0.17048535f, 0.03482766f, -0.02867098f, 0.16513890f, 0.01200009f, 0.15964423f, 0.03708713f, 0.08237339f, 
    -0.01589483f, -0.04945566f, -0.00280743f, 0.09915638f, -0.09300636f, 0.01725277f, 0.07508416f, 0.08869783f, 
    0.10912278f, -0.00447624f, -0.12562707f, 0.13437839f, -0.14997068f, 0.09330852f, -0.00430844f, 0.18285945f, 
    0.00517617f, -0.08729380f, 0.07066619f, -0.07311406f, 0.07542203f, 0.25524065f, -0.11569933f, -0.07764945f, 
    -0.04639573f, 0.03353399f, -0.00937580f, 0.07196929f, -0.11050008f, -0.01452356f, -0.02825605f, 0.04503154f, 
    -0.27557251f, -0.10220852f, -0.15475103f, 0.04864225f, -0.07629667f, -0.09197397f, -0.08389176f, -0.11936077f, 
    0.04860991f, -0.04544743f, -0.09861395f, 0.07237819f, -0.22826508f, 0.12958731f, 0.21046074f, 0.25881839f, 
    -0.09110233f, -0.12750259f, -0.04169247f, -0.08342062f, 0.13136612f, -0.02090598f, 0.06361665f, -0.00804121f, 
    -0.40219092f, 0.22972949f, -0.19525015f, 0.13003141f, 0.03662661f, 0.06572438f, -0.00105836f, -0.08964177f, 
    0.11144268f, 0.00177277f, 0.09406644f, -0.01115585f, 0.08333196f, 0.11057539f, -0.16988608f, -0.28658977f, 
    0.23894881f, 0.16968937f, -0.07833076f, -0.18955146f, 0.09010599f, -0.03991703f, -0.06142924f, 0.06538074f, 
    0.12201549f, -0.02290901f, 0.05054786f, -0.06276561f, -0.08337098f, 0.17016506f, 0.12057754f, 0.13443579f, 
    0.01830486f, -0.03020675f, 0.02702714f, 0.03835957f, -0.12414566f, -0.01386603f, -0.08222070f, 0.23715153f, 
    0.00264998f, 0.00708067f, 0.01957560f, 0.10682459f, 0.05241992f, 0.08930704f, 0.03380103f, 0.03728071f, 
    0.03824184f, 0.03452808f, -0.03416526f, 0.03573360f, 0.03657533f, 0.03413691f, -0.01781124f, -0.05900889f, 
    -0.03323135f, 0.03897022f, -0.04173683f, 0.01496828f, 0.03245011f, -0.02085478f, 0.02877371f, -0.05389882f, 
    0.02212298f, -0.04315104f, 0.02592739f, 0.01772858f, 0.00187313f, 0.02550049f, 0.03817862f, 0.01529769f, 
    0.02424753f, 0.03655004f, 0.02272327f, 0.02114082f, -0.03332899f, -0.01945606f, -0.03914103f, -0.01186214f, 
    -0.03681575f, 0.03332501f, -0.01834387f, 0.02220060f, -0.01419198f, -0.05681387f, -0.00669156f, 0.02103426f, 
    0.01504559f, -0.01267512f, -0.05316243f, -0.00742488f, 0.03854213f, 0.01828935f, -0.04021158f, -0.01659696f, 
    -0.00276909f, 0.01313133f, -0.04640191f, 0.04073177f, -0.03210307f, -0.04483929f, -0.02355592f, 0.03623549f, 
    -0.01300244f, -0.04318085f, 0.02937853f, -0.05559751f, 0.00667236f, -0.02489156f, -0.03113191f, -0.02485318f, 
    -0.00098598f, -0.04971581f, -0.01942447f, -0.05387286f, -0.02289172f, 0.01340367f, -0.05486768f, -0.02506232f, 
    -0.04062254f, 0.02838931f, -0.03450111f, -0.04197174f, 0.00253358f, 0.00671059f, -0.05297296f, 0.03192655f, 
    0.04657943f, -0.01804151f, 0.02271125f, -0.05006145f, 0.02337166f, 0.01562696f, 0.03378557f, 0.02441926f, 
    -0.04224290f, -0.05206480f, 0.02031639f, -0.04874031f, 0.03311448f, 0.04208143f, -0.00909891f, 0.02640716f, 
    -0.05669245f, 0.00573912f, -0.01079537f, -0.04763498f, 0.03691165f, -0.03632676f, 0.00044572f, -0.04602609f, 
    -0.00090793f, 0.02936299f, 0.01104227f, -0.02232171f, -0.02892091f, 0.03326679f, -0.04362837f, -0.05262802f, 
    0.03586037f, 0.01691642f, -0.01531292f, 0.02727757f, 0.01705882f, 0.00380251f, 0.02961146f, 0.02064862f, 
    -0.02743636f, -0.05041230f, -0.01735891f, 0.00295700f, -0.02961171f, 0.01403377f, 0.04097310f, -0.05299506f, 
    -0.05205876f, -0.01079543f, -0.03508961f, 0.03197091f, -0.00569320f, -0.03544045f, -0.01011509f, -0.05625784f, 
    0.03947753f, 0.03407838f, 0.00407944f, 0.03340027f, -0.00504603f, 0.00282455f, -0.03139401f, 0.00856276f, 
    -0.03674487f, 0.03826799f, 0.00935322f, -0.03798949f, 0.00882464f, -0.05483909f, -0.05479760f, -0.01283418f, 
    0.01941441f, 0.02796901f, -0.04051674f, 0.03475464f, 0.02014789f, -0.04731273f, 0.00670562f, -0.02079608f, 
    0.00593247f, -0.04392670f, -0.04687906f, -0.05749461f, 0.03816544f, -0.02458724f, 0.01803344f, -0.04158740f, 
    -0.00665632f, -0.03814072f, 0.04184927f, -0.05233916f, -0.01233391f, 0.01700567f, 0.03520319f, -0.04952553f, 
    -0.00738393f, -0.02998779f, -0.01677706f, -0.03131336f, -0.05207583f, 0.00086901f, 0.01304443f, -0.03396250f, 
    0.00060100f, 0.00702351f, -0.02926516f, 0.03123968f, -0.01397297f, 0.00427279f, -0.00376564f, -0.02515729f, 
    -0.04979546f, -0.04518522f, 0.02616312f, 0.00859750f, -0.00370240f, 0.00451626f, -0.00038336f, 0.03597252f, 
    0.03172341f, -0.03084563f, -0.00768261f, -0.03493005f, 0.02324512f, 0.02439598f, -0.05625340f, -0.01871737f, 
    -0.02479157f, -0.03182446f, -0.00234711f, -0.04824885f, 0.04053080f, 0.02060140f, -0.01275009f, 0.03186353f, 
    0.03181626f, 0.04097981f, 0.00191837f, 0.01106107f, -0.05271688f, -0.02625857f, 0.04157074f, -0.05784443f, 
    -0.01819574f, -0.03747221f, 0.02290277f, -0.01602048f, 0.01413288f, -0.05310123f, -0.00187917f, 0.02875738f, 
    0.02513034f, -0.03985092f, 0.03848879f, 0.03185046f, 0.03815089f, 0.00506411f, -0.00499156f, 0.00653303f, 
    -0.04047016f, 0.00348672f, -0.03255064f, 0.02935237f, 0.03200497f, -0.02717063f, -0.04530798f, 0.03519239f, 
    -0.03370113f, -0.03381497f, -0.04525609f, 0.01040884f, -0.05959368f, -0.05694752f, 0.02923479f, -0.01132205f, 
    -0.04149744f, -0.03853968f, -0.01888934f, 0.00176784f, 0.03676062f, -0.01473558f, -0.00371628f, -0.02475466f, 
    -0.04241949f, -0.05351845f, 0.01561745f, 0.03370436f, 0.01424103f, 0.00823410f, -0.01502681f, 0.00275034f, 
    0.02617811f, 0.00347258f, 0.00040794f, -0.01192231f, 0.00100080f, -0.00386338f, -0.04952937f, 0.01228916f, 
    -0.00980754f, -0.03676972f, 0.02231227f, -0.04568934f, -0.00645800f, 0.00182951f, -0.02497875f, -0.02756703f, 
    0.01965030f, -0.05543695f, -0.02098565f, -0.01847498f, -0.02257884f, 0.03226613f, -0.05619281f, -0.03257443f, 
    0.02696247f, -0.05952794f, -0.02382067f, -0.01934428f, -0.03189058f, 0.03053237f, -0.05255376f, -0.01144138f, 
    -0.00424659f, -0.03078521f, 0.02852912f, 0.02378492f, 0.00620879f, -0.03746384f, 0.00082685f, -0.05891677f, 
    -0.02686529f, 0.05079051f, -0.02736207f, -0.03532979f, -0.00523073f, -0.04092848f, 0.03508826f, -0.03721466f, 
    0.04115988f, -0.05227140f, -0.04880877f, 0.02528490f, -0.04002267f, -0.01140143f, 0.02752628f, -0.02049176f, 
    0.00710141f, 0.03786886f, -0.04174875f, -0.02489308f, -0.00948246f, -0.05394864f, 0.03210221f, -0.05639182f, 
    -0.02091470f, -0.00370150f, -0.02550323f, -0.03067388f, -0.04812728f, -0.00332135f, -0.06025807f, -0.03657143f, 
    -0.04614438f, -0.02955298f, 0.00046093f, -0.02308486f, 0.01247406f, -0.00230146f, -0.00095205f, -0.04308222f, 
    -0.00359882f, -0.05960185f, -0.00056101f, 0.02788279f, 0.03467666f, -0.00189494f, -0.05711306f, -0.04225881f, 
    0.03366132f, 0.01371092f, -0.04575925f, -0.01553564f, 0.01873150f, 0.03017752f, -0.02250934f, 0.03490022f, 
    -0.04051642f, -0.03744945f, -0.00113934f, -0.01239090f, -0.00828064f, -0.04414308f, 0.02754038f, 0.03755179f, 
    -0.04733413f, 0.01835683f, -0.01492818f, -0.03456333f, 0.02977638f, 0.02624701f, 0.00210010f, 0.01118204f, 
    0.14146213f, 0.14378777f, -0.12120283f, 0.00342936f, 0.05314565f, -0.20221248f, -0.08883131f, 0.15514834f, 
    -0.08662879f, -0.00750235f, -0.12227412f, -0.01640909f, -0.08075081f, -0.30880588f, 0.14679682f, -0.03323359f, 
    -0.05425004f, 0.09412038f, -0.03181247f, -0.08061448f, 0.07693612f, 0.01755450f, -0.07201722f, -0.09027163f, 
    0.04229559f, 0.19215827f, 0.09526590f, 0.13415352f, -0.02548791f, 0.04060740f, 0.09548866f, -0.10872900f, 
    0.05335609f, -0.13107231f, -0.03629973f, -0.02044667f, 0.10292746f, -0.23504208f, -0.28296608f, 0.11631650f, 
    0.08285590f, 0.09189396f, 0.08214152f, -0.06013701f, 0.02643267f, -0.08256357f, -0.02270924f, -0.12412205f, 
    0.10661981f, 0.00089625f, 0.23087069f, -0.23054874f, -0.06727742f, -0.07523322f, 0.03933016f, 0.01135843f, 
    -0.00837901f, 0.02613897f, 0.00039171f, -0.06819080f, -0.16013327f, 0.12837976f, -0.03523825f, -0.27544490f, 
    -0.08255313f, -0.07997495f, -0.17185816f, 0.06647606f, 0.02172257f, 0.09063214f, -0.00212524f, -0.09355166f, 
    -0.05700088f, 0.05003719f, 0.08328137f, 0.15297797f, -0.17275836f, -0.12021298f, 0.01362052f, -0.11542006f, 
    0.10264365f, 0.06833614f, -0.03123444f, 0.01519997f, -0.20668806f, -0.22054386f, 0.02244918f, 0.39667678f, 
    0.01033701f, 0.07481880f, 0.10995844f, 0.00547454f, 0.14687762f, -0.15269437f, -0.08118069f, -0.02410898f, 
    0.06489004f, 0.08792605f, 0.29099911f, 0.20061927f, -0.15602820f, -0.01365040f, 0.01399329f, 0.02012327f, 
    0.07457647f, 0.04677764f, -0.11447606f, -0.02588709f, -0.17403932f, -0.00110522f, 0.18570782f, -0.16026963f, 
    -0.00024786f, 0.11669946f, -0.11107945f, 0.14784145f, -0.09918983f, 0.02688135f, -0.06051153f, 0.08422210f, 
    0.00117125f, 0.06178769f, 0.31965575f, 0.17998415f, -0.06511541f, 0.09124567f, 0.15235811f, -0.13842003f, 
    -0.06238039f, -0.12287922f, 0.11839116f, -0.03795375f, 0.28348470f, 0.03337969f, 0.07349031f, -0.03351283f, 
    0.13991353f, 0.01245518f, -0.00912583f, 0.09316742f, -0.00863357f, -0.03786947f, 0.09593634f, 0.03294861f, 
    0.15662736f, -0.05752668f, -0.05568642f, 0.10199281f, 0.02546961f, 0.01437393f, 0.05099026f, 0.04623432f, 
    -0.01222626f, -0.11008079f, -0.09702650f, -0.00855506f, -0.10507675f, 0.26588693f, -0.02221198f, -0.01794346f, 
    -0.03583406f, -0.18156110f, -0.06221343f, 0.08718727f, -0.05377921f, 0.05831315f, 0.07840894f, -0.02458547f, 
    0.12629932f, 0.03544549f, -0.06761520f, -0.01249773f, -0.01332164f, 0.15224957f, -0.04143848f, 0.01349730f, 
    0.03485091f, 0.01065868f, -0.10857698f, -0.00545336f, 0.09882730f, 0.03558511f, 0.01922280f, 0.14236191f, 
    -0.03133043f, 0.05433737f, 0.08068717f, 0.05067360f, -0.00059676f, 0.02437864f, 0.12121269f, -0.03608052f, 
    0.08781501f, -0.11087545f, 0.09733964f, -0.08026109f, 0.05818752f, 0.08647729f, -0.05851158f, 0.01125861f, 
    -0.03925775f, 0.07652903f, -0.05071187f, 0.09917905f, 0.02870845f, 0.15723497f, -0.05139427f, -0.06252006f, 
    -0.07356124f, -0.03842106f, -0.04044675f, 0.32907727f, 0.04637242f, 0.03756837f, 0.00544422f, 0.02293286f, 
    0.13556679f, 0.02926383f, 0.08147296f, -0.14586821f, 0.01061333f, 0.02880896f, -0.07740383f, 0.12757002f, 
    -0.02332648f, 0.03758784f, -0.04349707f, -0.00329832f, 0.04378006f, -0.05774760f, 0.00184106f, -0.03790621f, 
    -0.01919298f, 0.08102557f, 0.02515009f, -0.06384576f, -0.07192489f, -0.18164626f, -0.00069561f, 0.00922176f, 
    0.21302454f, 0.06824504f, -0.22895426f, -0.16941863f, 0.14531215f, 0.07196420f, 0.11275995f, -0.13608798f, 
    -0.27737826f, -0.14323822f, -0.01016293f, -0.05480539f, -0.09123121f, 0.00645429f, 0.07040485f, -0.13138230f, 
    -0.03949608f, 0.01712203f, -0.01087364f, 0.05958500f, 0.04414812f, 0.02917750f, -0.07720192f, -0.00832046f, 
    -0.23187783f, 0.10556275f, -0.11069269f, 0.12772396f, -0.16849083f, 0.06944096f, 0.20374741f, 0.04250938f, 
    -0.01069304f, -0.07270692f, 0.12684450f, -0.02107556f, -0.11699671f, -0.06309890f, 0.41060591f, 0.33994293f, 
    0.05359918f, 0.04297839f, 0.04657715f, -0.07973615f, 0.09175467f, 0.10797784f, -0.01304485f, 0.11809619f, 
    0.18285248f, 0.09928385f, 0.04672464f, 0.03779005f, 0.07246658f, 0.03663215f, -0.05166326f, 0.02038448f, 
    -0.02461103f, -0.02017423f, -0.00478261f, 0.05330351f, 0.14704688f, 0.06518123f, -0.19290142f, 0.10661510f, 
    -0.04007878f, 0.10113817f, 0.01192509f, -0.00257571f, -0.08832901f, -0.07803236f, 0.05867284f, 0.03744071f, 
    0.15522704f, 0.01044319f, -0.13745059f, 0.05782054f, -0.09633757f, 0.02733771f, -0.02888529f, 0.03697107f, 
    0.04527729f, -0.09363127f, -0.11008015f, -0.05000271f, 0.14043911f, 0.31966251f, 0.13117181f, 0.01572023f, 
    -0.14365886f, -0.08627452f, -0.12476692f, 0.00915178f, 0.00000680f, 0.02707393f, 0.06240319f, 0.04752319f, 
    0.11814743f, -0.23546532f, -0.01411356f, 0.12655999f, -0.01123345f, -0.04774638f, -0.13237502f, 0.13155842f, 
    -0.04730089f, -0.05301863f, -0.00075114f, -0.04779230f, -0.04497927f, 0.11742619f, -0.02512244f, 0.12303049f, 
    -0.02803347f, -0.05075751f, 0.11096467f, -0.01871379f, 0.01917621f, 0.09381749f, -0.06989829f, 0.00841980f, 
    -0.07043628f, 0.07095423f, 0.07265543f, -0.13054711f, 0.01355888f, 0.00623136f, -0.03022811f, 0.01578905f, 
    0.16698489f, 0.01147780f, -0.07056033f, 0.03932935f, 0.26749972f, -0.07600434f, 0.21677680f, -0.19710241f, 
    0.07249717f, 0.07311160f, 0.15484966f, 0.13182494f, 0.08633233f, 0.03570233f, 0.12865576f, -0.15583937f, 
    0.13007104f, 0.17220618f, 0.03198582f, 0.11221157f, 0.04405040f, 0.00955835f, -0.02251980f, 0.03912416f, 
    -0.08405201f, -0.11934537f, -0.03846055f, -0.03192363f, -0.04187047f, -0.24353649f, -0.01279658f, -0.00804184f, 
    -0.02849267f, -0.05605752f, -0.03028826f, 0.03739736f, 0.07909516f, 0.03915355f, -0.00763181f, -0.01848195f, 
    0.08783951f, -0.14431998f, -0.04708484f, 0.12142601f, 0.01591461f, -0.06910995f, 0.04010207f, -0.01363640f, 
    -0.03380081f, -0.14106907f, 0.03424388f, -0.04332871f, -0.03739741f, -0.18236592f, 0.28852454f, 0.30779254f, 
    0.06646723f, 0.24452962f, 0.08792330f, 0.05495110f, -0.01511059f, -0.10487977f, -0.06707835f, -0.05503615f, 
    0.14552294f, 0.14624767f, -0.05977451f, 0.04166864f, -0.04025123f, 0.02032618f, -0.06442899f, -0.04171907f, 
    -0.06527398f, -0.04357743f, 0.04903974f, 0.00989120f, -0.39689931f, 0.11737375f, -0.04707645f, -0.00335812f, 
    0.03600354f, -0.04803027f, -0.00752109f, 0.16719408f, 0.04155980f, 0.09605139f, 0.07985888f, -0.09606157f, 
    -0.11783944f, -0.13575839f, 0.02744314f, -0.02356425f, -0.06947649f, 0.00168989f, 0.01272601f, 0.04040595f, 
    0.14412145f, 0.11288080f, -0.01560870f, 0.13617203f, -0.21503504f, 0.09704746f, -0.01039814f, 0.18752094f, 
    0.01448261f, -0.09985257f, 0.15043586f, 0.05608627f, 0.10762715f, -0.11518076f, -0.12648770f, -0.00137829f, 
    0.02973615f, -0.02681203f, 0.18931493f, 0.14503853f, -0.01700905f, -0.13913929f, -0.05368026f, 0.04069564f, 
    0.00587818f, 0.08395819f, -0.06470602f, 0.21039540f, 0.00005145f, 0.06138512f, 0.28407019f, -0.16083869f, 
    0.00071034f, 0.09627841f, -0.07553864f, 0.03974650f, 0.03369177f, -0.10233060f, 0.05608308f, 0.02976388f, 
    0.16933030f, 0.09450876f, 0.30825648f, 0.08568352f, 0.04806580f, 0.11066920f, 0.10577776f, -0.05596580f, 
    0.02843292f, 0.03244636f, 0.01010539f, 0.02642503f, 0.21131115f, -0.00606249f, 0.15078884f, -0.05648312f, 
    0.08426042f, 0.05627126f, 0.10967821f, 0.03020258f, -0.06097888f, -0.08228488f, 0.05736943f, 0.03621954f, 
    0.01663292f, -0.02371148f, -0.06826255f, 0.04411324f, -0.01495324f, -0.00299544f, -0.06491652f, -0.00747881f, 
    0.04671748f, 0.09489595f, -0.08460364f, 0.03499256f, -0.24806920f, 0.01640339f, 0.00291022f, 0.05235684f, 
    -0.07260776f, -0.00364815f, 0.05730048f, 0.14661074f, 0.00838378f, 0.00738521f, -0.01457918f, 0.02099977f, 
    -0.08170515f, -0.03056629f, 0.00188932f, 0.03095547f, 0.12272069f, 0.16487834f, -0.04660403f, 0.01471917f, 
    0.00217181f, 0.02498554f, -0.05543407f, 0.02856934f, 0.11156223f, 0.10884555f, 0.09081890f, 0.12827802f, 
    0.11279356f, 0.01346934f, 0.09797499f, 0.04664275f, 0.08689018f, -0.01348075f, 0.02975216f, -0.01158973f, 
    -0.07945866f, -0.11412759f, -0.01461103f, -0.04686520f, 0.01150884f, 0.09147817f, 0.04308647f, -0.05316043f, 
    -0.02269612f, 0.03149708f, -0.21468116f, -0.01243422f, -0.09369968f, 0.19162959f, -0.16542111f, -0.03749545f, 
    -0.13818850f, 0.13401300f, 0.10367656f, 0.25608549f, -0.05818455f, -0.04383069f, -0.19669741f, 0.06295513f, 
    0.11901223f, 0.00440232f, -0.09499153f, -0.12156375f, 0.02548498f, 0.03839384f, -0.16416571f, 0.10812084f, 
    0.13292189f, 0.02768899f, -0.13241325f, -0.07120595f, -0.14780204f, -0.14881259f, -0.10836967f, -0.10144066f, 
    0.11758323f, 0.04717940f, -0.03515747f, 0.04352134f, -0.12306733f, -0.16050452f, -0.01024219f, 0.02692995f, 
    -0.03207162f, 0.02322694f, -0.08903018f, -0.10290470f, 0.02246046f, 0.15026756f, 0.06598680f, -0.11869936f, 
    -0.08815981f, -0.17537487f, 0.09725205f, -0.06940525f, -0.19756782f, -0.00697164f, -0.05242817f, -0.12514862f, 
    -0.01384937f, 0.00274554f, 0.13845044f, -0.10692158f, -0.03454693f, -0.05925287f, -0.00280678f, 0.06552305f, 
    -0.10616587f, 0.12011945f, -0.10322116f, 0.35432920f, -0.01729471f, -0.03937263f, 0.05788641f, 0.02727517f, 
    -0.07980761f, 0.00367469f, -0.02318053f, 0.21995196f, -0.11554439f, -0.08086617f, 0.23399048f, -0.00152836f, 
    0.01598437f, -0.13085677f, 0.14860757f, -0.07142361f, 0.03113297f, -0.01444559f, 0.05834533f, -0.04400541f, 
    0.02919331f, 0.01192769f, -0.06262637f, -0.05379782f, -0.02660405f, 0.07260543f, -0.08867983f, 0.11935842f, 
    0.05124723f, -0.05178806f, 0.13883089f, 0.03300155f, 0.17611103f, 0.08321033f, -0.03732075f, 0.09660412f, 
    -0.02211277f, 0.10935520f, 0.02980668f, 0.05821181f, -0.14378141f, -0.05521925f, 0.00325101f, 0.02137355f, 
    -0.09286161f, -0.12958246f, -0.08721539f, -0.02800880f, 0.02697923f, -0.00493798f, -0.01735959f, -0.00578009f, 
    0.10988083f, -0.08823676f, -0.09259228f, 0.00352652f, -0.12892558f, 0.11516679f, 0.07888656f, 0.07140452f, 
    -0.06782144f, 0.01705614f, -0.12720180f, -0.07232819f, 0.14013690f, -0.06313393f, 0.02669158f, -0.00363825f, 
    -0.28206480f, -0.15100880f, -0.04708195f, 0.01445038f, -0.00930571f, 0.08739956f, -0.01530706f, 0.01774427f, 
    -0.01906846f, -0.03438054f, 0.02024478f, -0.01735470f, 0.23328085f, -0.08271895f, 0.04079272f, 0.10399678f, 
    0.01211778f, 0.01326127f, 0.08732304f, -0.08827508f, 0.06222055f, -0.01188197f, 0.00649523f, 0.05897187f, 
    -0.11283343f, 0.05595678f, 0.03628271f, -0.14409931f, -0.03790859f, 0.00582617f, 0.07650784f, 0.05003024f, 
    0.05772439f, -0.15143140f, -0.14916478f, -0.05166357f, 0.00818166f, -0.06245997f, 0.08515127f, -0.13411015f, 
    0.26114795f, -0.00079999f, -0.00573117f, 0.22604303f, -0.01341805f, -0.01580023f, 0.06877270f, -0.12599061f, 
    -0.08290888f, 0.05138584f, 0.24930662f, 0.06812570f, -0.01602123f, 0.15353869f, 0.04618422f, 0.03927030f, 
    0.08425305f, 0.18588279f, 0.19024751f, 0.15239333f, 0.37081948f, 0.04708258f, -0.18370560f, -0.07536276f, 
    0.06870446f, -0.12751260f, -0.03371297f, -0.05497648f, -0.16181293f, 0.06099776f, -0.04449783f, 0.12218458f, 
    -0.10293266f, -0.11209686f, -0.10628194f, 0.18293570f, -0.16145365f, 0.04833097f, -0.01349229f, 0.06132795f, 
    0.07761221f, 0.11676092f, 0.06807251f, 0.00181423f, 0.06377939f, 0.44856441f, 0.26848453f, -0.02107928f, 
    0.10223664f, -0.11867981f, -0.01649554f, 0.06077148f, 0.00438753f, 0.05022161f, -0.07401223f, -0.06195488f, 
    -0.29885244f, 0.06674460f, -0.06367630f, 0.03169059f, 0.02688360f, 0.05527273f, -0.04048551f, -0.04985515f, 
    -0.05664061f, -0.04068011f, 0.01684383f, 0.09229380f, 0.28617737f, 0.11974476f, 0.18900156f, 0.26367751f, 
    0.11092295f, -0.06557410f, 0.17930351f, -0.03254290f, 0.00403855f, -0.06236572f, 0.11705972f, 0.25824001f, 
    -0.10995802f, -0.09921432f, -0.21108322f, 0.10730223f, 0.09541231f, 0.00243397f, -0.03120894f, -0.09404013f, 
    -0.12241081f, 0.12636599f, 0.03840062f, 0.07634684f, 0.13254915f, 0.09275687f, -0.04616044f, -0.04844460f, 
    -0.01439160f, 0.02959949f, -0.10554972f, 0.01780496f, 0.01417093f, 0.20197974f, 0.05376639f, 0.09348319f, 
    -0.06953568f, -0.18944867f, -0.26119402f, -0.06659365f, 0.11086155f, 0.06053896f, -0.09430034f, -0.08596814f, 
    0.02402676f, -0.05829882f, -0.01057019f, 0.01005366f, 0.25127226f, -0.03365156f, -0.17519946f, 0.22181027f, 
    0.06419647f, -0.00934105f, 0.06972883f, -0.04912233f, 0.00523351f, -0.03158006f, 0.13392088f, -0.00324143f, 
    0.14218977f, -0.00963776f, -0.31269845f, -0.20848085f, 0.01213090f, -0.03043488f, -0.06549520f, 0.10428739f, 
    0.05411445f, -0.00023158f, -0.29618335f, 0.07832136f, -0.09395300f, 0.12506212f, 0.10758677f, 0.02676051f, 
    -0.11382339f, -0.03105704f, 0.11582346f, 0.10425224f, 0.07328381f, 0.06302826f, 0.00969595f, 0.07328075f, 
    -0.14410646f, -0.01404304f, 0.01781367f, -0.16528985f, -0.02755847f, 0.04599613f, -0.11776078f, 0.05233616f, 
    -0.07899358f, -0.13973302f, -0.12396556f, -0.12343384f, 0.23481244f, 0.05670028f, 0.25427574f, 0.27871406f, 
    0.01721561f, 0.08488231f, -0.14174634f, -0.18816207f, 0.01339793f, -0.02707287f, 0.02476034f, 0.09495485f, 
    -0.03797416f, -0.07528156f, 0.07942202f, -0.13081342f, 0.03277807f, -0.14354388f, 0.10114727f, 0.03725710f, 
    -0.15822932f, -0.26557869f, -0.16674389f, -0.40456578f, 0.15917076f, 0.12239277f, 0.03371431f, 0.01378312f, 
    0.01528117f, 0.01900552f, -0.02664921f, 0.14919385f, -0.08190579f, -0.02781917f, -0.13155024f, 0.02471530f, 
    -0.00135366f, -0.02346533f, -0.03115870f, -0.12309509f, -0.00922238f, -0.11770596f, 0.10402773f, 0.09414411f, 
    0.12201482f, 0.01437593f, 0.14021280f, 0.01661954f, 0.12368779f, -0.08591587f, 0.15007187f, 0.21818760f, 
    0.14717190f, 0.08623849f, 0.01364652f, -0.10281897f, -0.01362861f, -0.05838524f, 0.08837196f, 0.10311054f, 
    -0.01319559f, 0.05926243f, -0.04552327f, 0.10312951f, -0.07310732f, 0.08428039f, 0.00613058f, -0.09689172f, 
    0.05566977f, -0.01546879f, -0.00463405f, -0.05594654f, -0.09901043f, -0.05993247f, -0.07052813f, 0.08760839f, 
    0.14125846f, -0.17780988f, -0.06226020f, 0.00732156f, 0.05886056f, 0.12929021f, 0.15954641f, -0.07192663f, 
    -0.11507592f, -0.18055540f, -0.08869267f, 0.14281963f, -0.00764311f, -0.09392569f, -0.15174058f, -0.01105285f, 
    0.16466720f, 0.12506495f, -0.01005245f, 0.13938831f, 0.19599968f, 0.14057702f, 0.18348941f, 0.20715635f, 
    0.10103959f, 0.01958353f, -0.07624641f, 0.03245584f, -0.01725567f, -0.01374269f, 0.11036715f, 0.01986146f, 
    0.06174916f, 0.18996538f, 0.17448917f, -0.09160511f, 0.24666934f, -0.08139750f, -0.26467249f, -0.23682778f, 
    0.02904765f, -0.02888243f, -0.11860243f, 0.07041834f, 0.19225691f, -0.07742471f, -0.25153768f, -0.27315104f, 
    0.07815331f, -0.03291124f, -0.10601911f, -0.09529193f, 0.03214781f, -0.08522998f, -0.08948383f, -0.00098483f, 
    -0.25697273f, -0.16697691f, -0.07264782f, -0.19192058f, 0.01980672f, 0.09890890f, -0.03536447f, -0.10030144f, 
    0.07570676f, 0.05039072f, -0.04976834f, 0.02396770f, -0.18087660f, -0.05123902f, 0.11324161f, 0.20348054f, 
    0.01207480f, 0.03492689f, -0.01273591f, -0.07378772f, 0.08002613f, 0.06099383f, 0.00845344f, 0.06753170f, 
    -0.20916253f, -0.16437511f, 0.14809136f, -0.12067893f, 0.14963914f, -0.04825248f, -0.24841005f, -0.01711154f, 
    -0.24419795f, -0.07023779f, 0.04055776f, -0.23510224f, 0.00108540f, -0.06597070f, -0.05235401f, 0.00488357f, 
    0.23324965f, -0.05728387f, 0.00584530f, -0.11522274f, -0.16257040f, -0.04340650f, -0.10027154f, -0.00979214f, 
    0.02882031f, 0.03666592f, -0.03394021f, -0.06596137f, 0.07237589f, 0.06372964f, 0.05496480f, -0.08737838f, 
    -0.06479859f, -0.07370853f, -0.10325327f, -0.00976335f, 0.19870721f, -0.03204231f, 0.08968142f, -0.02267020f, 
    0.01118178f, -0.08542136f, -0.05024231f, 0.14644031f, -0.09529764f, -0.12051164f, 0.05757819f, -0.04073583f, 
    0.09436262f, -0.00768847f, 0.12355552f, 0.16889943f, 0.00634085f, -0.06467268f, -0.02234897f, 0.02951225f, 
    -0.04791493f, 0.13115118f, 0.15875559f, 0.16162981f, -0.31506166f, -0.10159674f, -0.17250793f, 0.12616219f, 
    0.00235970f, -0.10980000f, -0.00062077f, 0.04115779f, -0.07547908f, -0.04788822f, -0.17576706f, -0.06789941f, 
    0.05384891f, 0.01617989f, 0.01354038f, 0.00908839f, -0.05438222f, 0.03176534f, 0.04018887f, 0.02804387f, 
    -0.06787330f, -0.03490263f, -0.07841188f, -0.01340359f, -0.02501960f, -0.05022951f, -0.07498981f, 0.03025825f, 
    0.01332063f, -0.03402896f, -0.03666251f, -0.04211113f, -0.06080535f, -0.01007737f, 0.00471241f, -0.03319452f, 
    -0.01853845f, -0.03751910f, 0.02383105f, -0.04323590f, -0.03299279f, 0.04090481f, 0.01923940f, 0.00181321f, 
    -0.06223803f, 0.00334281f, -0.07217116f, 0.01429604f, -0.00746231f, -0.03970015f, -0.06976060f, -0.00100025f, 
    -0.07483664f, -0.04517487f, -0.03177634f, -0.05929216f, 0.00046379f, -0.05880957f, 0.02824828f, 0.01737645f, 
    -0.00843741f, -0.04632659f, 0.02025035f, 0.00730724f, -0.03260038f, -0.03178434f, -0.03085881f, -0.03271605f, 
    -0.06891078f, -0.04279009f, 0.01148098f, -0.00084704f, -0.01794364f, -0.04873018f, -0.01556409f, -0.02911553f, 
    -0.01189047f, -0.01231468f, -0.04945954f, 0.01212255f, -0.02568177f, -0.02906379f, 0.07785005f, -0.03026234f, 
    -0.05613151f, -0.04059083f, -0.00716397f, -0.01242841f, -0.01186319f, -0.04526283f, 0.00980082f, 0.02516976f, 
    -0.00334621f, 0.05625975f, 0.06425592f, 0.02096540f, 0.00462044f, 0.02301794f, 0.11015113f, 0.00403906f, 
    -0.05592555f, -0.00552325f, 0.01149360f, 0.03699628f, 0.01544931f, -0.04502080f, 0.01374999f, -0.07725523f, 
    -0.02644055f, -0.04456675f, -0.04629978f, -0.05820762f, -0.05100587f, -0.01580538f, 0.01173147f, -0.06566048f, 
    -0.01834550f, -0.04044302f, 0.00439864f, -0.08064295f, 0.01360238f, 0.04545059f, 0.04788437f, -0.03616603f, 
    -0.03529009f, 0.03596756f, 0.01520409f, 0.04963880f, -0.00856009f, -0.01009981f, -0.06294066f, -0.02860850f, 
    0.02964297f, -0.03801848f, -0.04662840f, 0.03870519f, 0.04628127f, 0.06536113f, 0.04485645f, 0.04099129f, 
    -0.05549163f, 0.02912168f, 0.02512427f, 0.01235973f, 0.02187506f, 0.00013632f, 0.06978206f, 0.03934120f, 
    0.02547350f, 0.00459696f, 0.02688616f, -0.06630123f, -0.00204819f, -0.05820963f, -0.04993892f, -0.05092307f, 
    0.03138271f, -0.00126357f, 0.00497248f, 0.00548690f, -0.02169180f, 0.04230794f, -0.01691333f, 0.04172368f, 
    0.03570789f, -0.03180027f, -0.04301812f, -0.06454475f, 0.02787202f, 0.01965781f, -0.01969028f, 0.03529215f, 
    -0.03309293f, -0.02839499f, -0.00831843f, -0.01640852f, -0.01519618f, -0.02960917f, -0.02185131f, -0.02481056f, 
    0.03628778f, 0.01236629f, 0.02091872f, -0.03703250f, 0.05497052f, -0.03140928f, 0.03186795f, -0.05719543f, 
    -0.03742938f, -0.00011101f, -0.04423365f, -0.01926189f, -0.02790073f, 0.06962430f, -0.02156414f, 0.04915661f, 
    -0.02890903f, -0.04106901f, 0.01731040f, -0.03336896f, -0.05476438f, -0.04960628f, -0.02963943f, 0.02251149f, 
    -0.02598683f, 0.00410460f, 0.00237723f, 0.00581949f, 0.03211844f, -0.01690634f, 0.00589849f, -0.05362235f, 
    0.05150488f, 0.02274255f, -0.03912476f, -0.04959924f, 0.05284600f, 0.02873038f, 0.00050995f, 0.00720496f, 
    -0.04998132f, -0.02468729f, -0.02931659f, -0.00967900f, -0.04164970f, 0.03571594f, -0.00262737f, -0.00275941f, 
    0.00673249f, 0.07764807f, 0.03198700f, 0.00671331f, 0.01084023f, -0.01259290f, -0.03570241f, 0.03051035f, 
    -0.05206785f, 0.01441200f, -0.03192887f, -0.04048570f, 0.03218759f, -0.01978470f, 0.02006425f, -0.03637033f, 
    -0.01978234f, 0.00791650f, 0.01403310f, -0.00928818f, -0.05121953f, -0.00034640f, -0.03482522f, -0.06289548f, 
    0.00739189f, 0.02464230f, -0.05792952f, -0.04692328f, 0.01210961f, 0.06261951f, -0.00093009f, 0.02242290f, 
    -0.07757852f, -0.07801345f, 0.01657258f, -0.06281014f, -0.01653336f, 0.07165214f, 0.04142770f, -0.02631250f, 
    0.01493613f, 0.05354295f, 0.03519734f, -0.00165882f, -0.02204266f, -0.00708381f, -0.01940892f, -0.00842680f, 
    0.06069966f, -0.05541512f, -0.00407564f, -0.01687778f, -0.04231831f, -0.05947639f, -0.05690171f, 0.03819126f, 
    -0.04471496f, -0.05344433f, -0.05974537f, -0.01782316f, 0.00100304f, 0.02760204f, -0.01277350f, 0.01730106f, 
    -0.00534823f, -0.05970332f, -0.05084426f, 0.01083551f, 0.04378461f, -0.01724844f, 0.01093803f, 0.04031860f, 
    0.00862743f, -0.03932821f, 0.01475988f, 0.02107443f, 0.01667033f, -0.02523704f, -0.04359064f, -0.01206745f, 
    0.02684294f, 0.00347569f, 0.00517178f, 0.00108864f, -0.06004045f, -0.03919270f, -0.03648647f, -0.05279227f, 
    -0.06487764f, -0.04859202f, -0.03003958f, -0.02920387f, -0.04258052f, 0.01428949f, -0.00407835f, -0.02119060f, 
    0.00442597f, -0.01771982f, -0.05263978f, -0.04700319f, -0.00559385f, -0.03059590f, -0.00628778f, -0.01643473f, 
    -0.01712738f, -0.01629530f, 0.02653600f, 0.01773680f, -0.06640191f, 0.06044953f, -0.04325810f, 0.02528822f, 
    0.01324755f, -0.05463864f, -0.03330017f, 0.02130813f, -0.01616394f, 0.06994149f, -0.01323725f, -0.03594244f, 
    -0.03242488f, 0.00348997f, 0.00218804f, 0.01893431f, 0.00848559f, -0.04598632f, -0.02635021f, 0.03541981f, 
    -0.04861123f, -0.04680702f, -0.06606104f, -0.04034949f, -0.05870955f, -0.02095495f, -0.00555524f, -0.00194722f, 
    0.00042855f, 0.03299123f, -0.01251711f, 0.02407061f, -0.04443924f, 0.03147561f, 0.03110198f, -0.02758924f, 
    0.04238312f, -0.03585203f, 0.04015109f, -0.00781659f, -0.02256234f, -0.02929410f, -0.06558433f, -0.03563034f, 
    -0.09113317f, -0.03028389f, -0.02931597f, 0.02684169f, 0.03934548f, -0.06195204f, 0.01652438f, 0.00059686f, 
    0.03204897f, 0.01462084f, -0.03381122f, 0.03167466f, 0.01898914f, -0.00610518f, -0.06643329f, -0.00850093f, 
    0.06220549f, 0.16950402f, -0.06686617f, 0.08804309f, -0.05314930f, -0.06104460f, -0.01796656f, 0.07757236f, 
    -0.03083217f, -0.04789897f, -0.07466213f, 0.04293480f, -0.17561252f, -0.36181015f, 0.16167362f, 0.06271117f, 
    0.08277959f, 0.04192356f, -0.12222120f, 0.15740119f, -0.00398892f, 0.10815283f, -0.07360294f, 0.04217842f, 
    0.05693984f, 0.04292371f, -0.13888663f, 0.23317575f, 0.01215921f, 0.02173313f, 0.06059320f, -0.06719714f, 
    0.05857726f, -0.02404630f, 0.12390333f, -0.07187735f, -0.05229323f, -0.50734067f, -0.17649335f, 0.37328738f, 
    0.00152717f, 0.27921838f, 0.22956303f, 0.17631361f, 0.05316334f, -0.09126392f, -0.01275354f, -0.15700646f, 
    0.29499799f, 0.44329911f, 0.20130385f, -0.11008802f, 0.09802653f, -0.05124939f, 0.05067300f, 0.03412475f, 
    0.14747539f, 0.01787302f, 0.14106868f, 0.03739692f, -0.35829380f, 0.18966341f, 0.25908935f, -0.01795627f, 
    0.01482008f, -0.09491272f, -0.04323313f, 0.08489916f, 0.11425769f, 0.07383648f, 0.09263545f, -0.01061503f, 
    -0.02908025f, -0.02764560f, -0.03936626f, 0.10684635f, -0.11967738f, -0.04013877f, 0.07020496f, 0.06524114f, 
    0.23126557f, 0.01992863f, 0.00885866f, 0.14251003f, -0.13238485f, -0.28456682f, 0.15316236f, 0.37717173f, 
    0.04354668f, 0.14312221f, 0.12872386f, -0.13878748f, 0.16662149f, -0.13733371f, -0.12567492f, 0.02163432f, 
    0.07055144f, -0.13804279f, 0.10100450f, 0.15766986f, 0.06302929f, -0.16268317f, 0.03163574f, 0.10731291f, 
    -0.02045099f, 0.01243508f, -0.15306987f, 0.06111075f, -0.24710870f, -0.03852880f, 0.32432070f, -0.27178398f, 
    0.00371309f, 0.01140237f, -0.10887343f, 0.09644512f, 0.00842259f, 0.02916603f, 0.10273480f, 0.04266718f, 
    -0.20117904f, -0.11791917f, 0.30256501f, 0.15588494f, 0.05281040f, 0.12337136f, 0.01775257f, -0.10261984f, 
    -0.07956280f, -0.00820122f, 0.07123246f, 0.00715624f, 0.03242927f, -0.11138113f, 0.12322800f, -0.05453546f, 
    -0.01755492f, 0.09339320f, 0.02558730f, 0.05712821f, 0.04496574f, -0.02859412f, 0.15990540f, 0.02316696f, 
    0.09864165f, -0.07529071f, -0.00632696f, 0.15132414f, -0.00261587f, -0.01175336f, -0.06361611f, 0.10737062f, 
    0.00796133f, -0.04013686f, -0.21537712f, 0.06716682f, -0.16356865f, 0.26543260f, 0.16454433f, 0.10673536f, 
    0.04475208f, -0.08468268f, -0.04893754f, 0.21054551f, -0.01516638f, 0.05611980f, 0.02193378f, 0.02809196f, 
    0.02776392f, -0.20232578f, -0.18624876f, 0.11462091f, 0.11660925f, 0.22751653f, 0.08690204f, 0.11835884f, 
    0.01801722f, -0.04556145f, -0.14470114f, -0.07416330f, -0.00393839f, -0.04117096f, 0.11334309f, 0.14379162f, 
    0.13948850f, 0.13035335f, 0.20429438f, -0.12538528f, 0.14203209f, -0.06885766f, 0.08193837f, 0.02138537f, 
    -0.14677347f, -0.03245571f, 0.19421691f, -0.16681997f, 0.07618903f, 0.17162856f, -0.00787465f, -0.05243470f, 
    0.18875648f, 0.08518755f, -0.20180731f, 0.08253922f, -0.17305140f, 0.19528136f, 0.01257705f, -0.02380428f, 
    -0.16334039f, 0.05404688f, 0.06077049f, 0.27836728f, -0.04234017f, 0.01781997f, -0.00940385f, 0.15354577f, 
    0.18462524f, 0.12837906f, 0.01888890f, -0.27253073f, -0.07217926f, -0.08176578f, -0.13253808f, 0.12364947f, 
    0.15796646f, 0.03478060f, -0.02908529f, -0.09314074f, -0.22507204f, -0.20970446f, -0.22592016f, -0.02615432f, 
    0.01965066f, 0.22945724f, -0.00243574f, 0.01022194f, -0.02229902f, -0.14560430f, -0.00503186f, 0.02602792f, 
    0.03695987f, -0.08990224f, -0.22690202f, -0.10446576f, 0.05885592f, 0.11390939f, 0.04396874f, -0.19215301f, 
    -0.05563370f, -0.22807105f, 0.11412083f, -0.07570650f, -0.24068366f, -0.05404351f, 0.13313302f, -0.17117798f, 
    -0.06099091f, -0.03329372f, 0.03895422f, -0.09129726f, 0.06640583f, 0.06404468f, -0.04746929f, 0.07368547f, 
    -0.23468538f, 0.00074468f, -0.33769131f, 0.41201887f, -0.11507212f, 0.05047482f, 0.10701209f, -0.03053716f, 
    -0.04389286f, 0.02352899f, -0.01965298f, 0.06370571f, -0.19741566f, -0.21731770f, 0.42998311f, 0.15669823f, 
    0.19949207f, -0.03483093f, 0.04053191f, -0.00203727f, 0.04627624f, -0.00703334f, 0.07526635f, 0.11713722f, 
    0.16666433f, 0.22126536f, -0.05964014f, -0.18617094f, -0.05029787f, 0.14621164f, 0.01944076f, 0.09257623f, 
    0.14581165f, 0.05388401f, 0.03400977f, 0.03673211f, 0.11398182f, -0.01583932f, -0.18763898f, 0.23300624f, 
    -0.08341117f, 0.07542638f, 0.04258084f, -0.00240940f, -0.07021113f, -0.04276520f, -0.00987411f, 0.01356693f, 
    -0.00225052f, -0.24948688f, -0.23404522f, -0.06048930f, 0.02825777f, 0.13100561f, -0.06238372f, 0.07598761f, 
    0.05324377f, -0.04949887f, -0.10411528f, -0.08241278f, 0.02866032f, 0.41314930f, 0.24073587f, 0.07765925f, 
    -0.10608180f, -0.12575939f, -0.18071043f, -0.10128423f, 0.06517636f, 0.05400071f, 0.05443361f, 0.06158442f, 
    -0.16365345f, -0.04951822f, 0.10777961f, -0.01556411f, 0.08934361f, 0.12899299f, -0.08428111f, 0.02745330f, 
    -0.10558750f, 0.00092730f, 0.10278313f, -0.09899983f, -0.10721230f, -0.14105561f, 0.06049332f, 0.25824177f, 
    0.04439658f, -0.04181780f, -0.05537396f, -0.01790881f, 0.01047898f, 0.05016689f, -0.02878474f, 0.03362673f, 
    -0.21236661f, 0.18055968f, 0.09759042f, -0.18624824f, -0.05380461f, 0.03204805f, 0.15601383f, 0.11032726f, 
    0.14018150f, 0.00710950f, -0.04127463f, 0.15209055f, 0.04824056f, 0.01927631f, 0.13042100f, -0.12721129f, 
    0.31117180f, 0.04759177f, 0.12976193f, 0.21368861f, 0.08333978f, -0.01015197f, 0.05688447f, -0.10940158f, 
    -0.05241209f, -0.02199360f, 0.04724698f, 0.15682183f, 0.01776229f, 0.18962163f, 0.02790252f, 0.01611332f, 
    -0.09283120f, -0.06006815f, 0.04788997f, -0.01883599f, -0.03755719f, -0.05104761f, 0.07525110f, -0.00729470f, 
    0.14112942f, -0.10144577f, -0.04360054f, 0.03357419f, -0.02204044f, -0.10359602f, -0.00686894f, 0.06776574f, 
    -0.05234659f, -0.05894499f, -0.06553025f, 0.02031045f, -0.02199268f, -0.03127619f, 0.02525892f, 0.07221842f, 
    0.01659399f, 0.05454849f, 0.10579340f, -0.08627269f, -0.11497195f, -0.05873383f, 0.32450855f, 0.25714996f, 
    -0.07114848f, 0.01087984f, 0.07538842f, 0.14321038f, 0.12731645f, -0.05703253f, -0.05136427f, -0.00403891f, 
    0.18296756f, 0.16276468f, -0.18940340f, 0.09249374f, 0.03268586f, 0.03186655f, -0.01120628f, -0.04936515f, 
    0.03885667f, -0.19293907f, 0.12038091f, -0.05776378f, -0.31409624f, -0.03257802f, 0.01186909f, 0.14623912f, 
    0.08548645f, 0.06285239f, 0.17111160f, -0.01938957f, 0.04678845f, 0.07374074f, 0.19730440f, 0.04607576f, 
    0.00027319f, -0.05953357f, -0.02562384f, 0.02688913f, 0.00022781f, 0.05193258f, 0.05736125f, 0.07966188f, 
    0.04340591f, -0.04529908f, -0.08941135f, -0.04960610f, 0.15340759f, 0.33485803f, -0.09286302f, 0.18605177f, 
    0.09819208f, -0.05031513f, -0.00557171f, 0.04244391f, 0.01311103f, -0.03092886f, -0.02362677f, 0.05425348f, 
    -0.10389754f, -0.17438030f, 0.02550265f, -0.13188772f, 0.11886631f, -0.14432719f, -0.03282158f, 0.01723813f, 
    0.04455734f, -0.11470248f, 0.00210995f, 0.14093575f, 0.26421866f, 0.11711172f, 0.09126737f, -0.11886123f, 
    0.08052742f, -0.05803262f, -0.06453518f, 0.02849410f, -0.06973527f, -0.19020371f, -0.06077650f, 0.06538478f, 
    0.21208443f, -0.02114605f, 0.13375889f, -0.09848211f, 0.18048957f, 0.13295703f, -0.02586414f, 0.01374768f, 
    0.03025101f, 0.02644801f, 0.00494271f, 0.00007223f, 0.15893413f, 0.13484871f, 0.18537578f, 0.10346891f, 
    0.08563945f, 0.01503245f, 0.21963081f, -0.00955070f, -0.03925024f, -0.14185916f, 0.08124848f, 0.08059355f, 
    -0.04824816f, -0.02223785f, 0.03409704f, 0.00793824f, -0.04305354f, 0.01294435f, -0.09656828f, -0.09063094f, 
    0.00287299f, -0.01044636f, -0.12053842f, 0.05304119f, -0.23980185f, -0.14387970f, 0.13442008f, 0.01640843f, 
    0.05640658f, 0.07529245f, 0.04955912f, 0.02607222f, 0.09824187f, 0.02469478f, -0.20948927f, 0.11868909f, 
    0.01071234f, -0.03685471f, 0.04394391f, 0.02252530f, 0.02368128f, 0.04450824f, -0.03684001f, -0.02007290f, 
    0.02582416f, -0.03855700f, -0.05513985f, -0.01899377f, 0.23498055f, 0.22370821f, 0.27935138f, 0.11336727f, 
    0.33201790f, 0.07549626f, 0.10927169f, 0.06515568f, -0.03778249f, -0.03274656f, -0.04146056f, -0.02340368f, 
    -0.01826850f, -0.10901229f, 0.02287729f, 0.01235657f, 0.01550881f, 0.00653776f, 0.11694209f, -0.24522150f, 
    -0.18493856f, -0.03534291f, -0.09082799f, -0.12018818f, -0.11253656f, 0.11261053f, -0.20520604f, -0.01789316f, 
    -0.05995663f, 0.06075585f, 0.01909615f, -0.08381785f, -0.18088603f, -0.14764871f, -0.04766387f, -0.00079215f, 
    0.15870060f, 0.18342352f, -0.17739551f, 0.12248106f, 0.05110160f, -0.02541442f, -0.07864761f, -0.32438534f, 
    0.13338535f, -0.01878507f, 0.06528078f, -0.08137731f, -0.04060952f, -0.05533429f, 0.02505295f, 0.04112039f, 
    0.00304499f, 0.07592355f, -0.03004742f, 0.00226145f, 0.00748785f, 0.00074486f, 0.05933419f, 0.04018966f, 
    0.02118182f, -0.00944067f, 0.10361653f, 0.11775942f, -0.13974279f, 0.02997909f, 0.00397596f, -0.16800295f, 
    0.20079766f, -0.09750740f, 0.03016197f, -0.01041439f, -0.07642558f, 0.08675598f, 0.00184149f, -0.01034358f, 
    0.05622698f, -0.00167613f, 0.06734587f, -0.10074996f, -0.05693140f, -0.04186028f, 0.03730498f, 0.04317094f, 
    -0.20589858f, -0.06112300f, 0.12947008f, 0.18281029f, -0.10453518f, -0.09790269f, -0.01541302f, 0.01495342f, 
    0.06408922f, 0.01511595f, -0.03960885f, 0.07367097f, 0.06072797f, -0.06065721f, 0.12449491f, -0.24414057f, 
    0.06451427f, -0.11095448f, -0.03621041f, -0.02292691f, -0.03137881f, -0.25624323f, -0.01197746f, -0.06524350f, 
    -0.03805242f, 0.03094980f, -0.08943161f, -0.01938374f, -0.27058879f, -0.06753383f, -0.16379385f, -0.03437018f, 
    0.09503011f, -0.01948311f, 0.00950201f, 0.05132783f, -0.05743765f, -0.00281829f, -0.00392464f, 0.01915130f, 
    -0.01884134f, 0.02704004f, 0.01842803f, -0.02048358f, -0.07000235f, 0.00629678f, -0.07951806f, 0.14338745f, 
    0.01657477f, -0.00410228f, 0.05489400f, 0.01560139f, 0.05865589f, 0.06785481f, -0.03082473f, -0.01723352f, 
    0.09999526f, -0.05673371f, -0.04954594f, -0.05748663f, -0.21800128f, -0.23062919f, 0.03371333f, 0.08775752f, 
    0.05693223f, 0.00815193f, -0.03961927f, -0.07964388f, 0.14692010f, -0.15191017f, -0.04947792f, 0.07519996f, 
    -0.18088336f, -0.00094444f, 0.07213812f, -0.05496143f, -0.01510953f, 0.06280378f, 0.03917915f, -0.10188949f, 
    -0.05752755f, 0.00621195f, 0.08840322f, -0.10059894f, 0.24312131f, -0.06456611f, 0.07939310f, -0.17636056f, 
    0.12374617f, 0.08624490f, -0.08113664f, -0.13512805f, 0.11101809f, -0.02709583f, -0.02825353f, 0.06845293f, 
    0.00696423f, 0.05848334f, 0.06220313f, -0.04212566f, -0.23627052f, -0.13561825f, -0.00632658f, -0.01317843f, 
    -0.17729758f, -0.21679342f, -0.18999381f, 0.09943253f, -0.21404597f, -0.09391466f, -0.22822693f, 0.05187525f, 
    0.18369383f, -0.05239712f, -0.15291406f, 0.26933390f, -0.05980886f, -0.04363666f, 0.06644695f, -0.03494839f, 
    -0.14718352f, -0.03998893f, -0.01629101f, -0.00835691f, 0.03023147f, 0.06793772f, 0.03582820f, -0.02117667f, 
    0.00854890f, -0.14113431f, -0.02044995f, 0.04521055f, 0.05015857f, 0.02447641f, -0.04020838f, -0.05418877f, 
    -0.02767021f, -0.03842712f, -0.04212429f, -0.00689435f, 0.14993535f, 0.08784580f, 0.11712027f, -0.07133365f, 
    -0.07497707f, -0.05746660f, -0.09334695f, 0.19854929f, 0.02721917f, -0.06062943f, -0.07639635f, -0.01460846f, 
    -0.00334714f, 0.00457531f, -0.00532728f, 0.11072677f, -0.17025939f, -0.13146023f, 0.18419637f, -0.03330696f, 
    0.02637433f, 0.02177403f, 0.00682526f, 0.07005969f, -0.04126663f, -0.10518988f, -0.04945529f, -0.00113528f, 
    -0.00306348f, 0.14418511f, -0.01175019f, -0.15257923f, -0.01128749f, 0.06940638f, 0.06928030f, 0.18803215f, 
    0.02250239f, 0.18009499f, 0.00626484f, -0.01894380f, -0.20596346f, -0.08154451f, 0.09046608f, 0.00209612f, 
    -0.12454416f, -0.02549923f, -0.09707745f, -0.00728549f, -0.09014461f, -0.06431065f, 0.04602636f, -0.09801994f, 
    -0.16369408f, -0.01250208f, -0.03481092f, -0.05467368f, -0.04698984f, -0.06693517f, -0.12966919f, -0.04981200f, 
    -0.04055671f, 0.07434483f, 0.26094452f, 0.03935441f, -0.23823258f, 0.12911348f, 0.34070545f, -0.11350739f, 
    -0.07888418f, -0.10972872f, -0.12126683f, 0.07473117f, 0.08566602f, 0.03412998f, -0.16357164f, -0.17839198f, 
    0.15484276f, 0.05179406f, 0.05149231f, 0.14745151f, 0.09147527f, 0.02962694f, 0.05100375f, -0.03493578f, 
    0.04836060f, 0.19492054f, 0.14839061f, 0.30787349f, 0.09850347f, 0.12464078f, -0.07386052f, 0.26621699f, 
    0.03563804f, -0.06730606f, 0.19516830f, 0.00457326f, 0.06841486f, -0.10741413f, -0.06659959f, 0.10981283f, 
    -0.28419223f, -0.04566653f, -0.08172416f, -0.08871079f, 0.39623290f, 0.10567700f, 0.15569429f, 0.33619839f, 
    -0.03519192f, -0.06710506f, -0.06324656f, 0.02970666f, 0.02858003f, 0.08040944f, 0.01580966f, 0.05161519f, 
    -0.00904553f, 0.15075399f, -0.02003847f, -0.02280183f, -0.07282015f, 0.00387702f, -0.09940663f, 0.06484748f, 
    -0.02970980f, -0.00467250f, -0.05255938f, -0.06267186f, 0.10053564f, 0.07685731f, 0.00802207f, -0.16901506f, 
    0.14293043f, 0.08461316f, 0.11617040f, 0.04933352f, -0.15827221f, -0.15470083f, 0.19627576f, 0.06590047f, 
    -0.04047029f, 0.15324426f, -0.07655863f, -0.01951093f, -0.01598821f, 0.11445763f, 0.10641935f, -0.04565383f, 
    -0.12971753f, -0.10509641f, -0.16350506f, -0.10724325f, 0.16424277f, 0.05435250f, 0.10527719f, -0.13271998f, 
    -0.08993957f, 0.04544919f, 0.06528196f, 0.05331495f, -0.15039736f, -0.10748615f, -0.05634835f, -0.14145285f, 
    0.01260080f, 0.20636918f, -0.02083693f, 0.05776735f, -0.04369532f, -0.06088784f, -0.10644275f, 0.01083896f, 
    0.15532371f, -0.10005821f, -0.17742518f, -0.02874115f, -0.07155979f, 0.06009603f, 0.04535707f, 0.14934465f, 
    0.16282418f, 0.12034884f, -0.07348669f, -0.05903351f, -0.02388964f, 0.06531962f, 0.16310503f, -0.02342815f, 
    0.03953838f, 0.17138621f, 0.10553035f, 0.10661925f, 0.07907965f, -0.07113797f, -0.10764296f, -0.07747482f, 
    -0.18775873f, -0.13520582f, -0.02554990f, -0.03344154f, 0.03804436f, 0.09220650f, 0.10597797f, 0.01535670f, 
    0.03690999f, -0.09362120f, -0.09366381f, -0.03236127f, -0.06151919f, -0.06873455f, 0.04531405f, 0.05979588f, 
    -0.06252275f, -0.08514833f, -0.05315711f, -0.00184947f, -0.00198661f, -0.07820027f, 0.07053998f, -0.06448066f, 
    -0.20392188f, -0.13630822f, 0.01558939f, -0.11532747f, 0.07434009f, -0.00934581f, 0.09600587f, -0.04529178f, 
    0.04353603f, 0.07245006f, -0.08923235f, 0.06085574f, -0.02028680f, 0.13416685f, 0.11851551f, 0.14698179f, 
    0.05676255f, 0.04438398f, 0.22930317f, 0.04251251f, -0.03640430f, 0.02171032f, 0.12130041f, 0.08360151f, 
    0.10496433f, 0.30851066f, -0.14316741f, 0.03913252f, 0.14904366f, -0.03411964f, -0.08206874f, -0.00676988f, 
    0.02588235f, 0.05645649f, 0.07589396f, 0.12781356f, 0.05963894f, 0.10766519f, -0.10635380f, 0.02613815f, 
    -0.09589949f, -0.11648059f, 0.08093750f, 0.07114669f, 0.05020267f, 0.12319041f, -0.07032739f, -0.05836786f, 
    0.00630670f, -0.02410791f, -0.06813531f, 0.04189476f, 0.20971350f, 0.12342654f, 0.18354976f, 0.28993025f, 
    -0.02315287f, -0.06652100f, 0.10827949f, 0.12308633f, 0.05781036f, 0.16296767f, 0.13484147f, 0.07716541f, 
    0.01506933f, -0.03224754f, 0.04828281f, -0.06008048f, 0.01108583f, -0.02450367f, 0.09450144f, -0.03722987f, 
    -0.09152944f, -0.07415996f, -0.00325974f, 0.03104839f, -0.09455651f, -0.05229783f, -0.10144202f, -0.12151117f, 
    0.01979343f, 0.03393338f, 0.04973016f, 0.04861096f, -0.21052039f, -0.01678843f, 0.10094748f, -0.05558419f, 
    -0.04930187f, -0.00972540f, 0.00471090f, -0.04237193f, 0.10522532f, 0.18759252f, 0.10041833f, -0.00628579f, 
    -0.02207470f, 0.27845553f, 0.00275300f, 0.04157134f, 0.02109405f, -0.03165245f, -0.00977306f, -0.01613196f, 
    0.04256653f, 0.05454680f, 0.10214856f, -0.00688858f, -0.17721735f, 0.04645269f, -0.01135143f, 0.18104637f, 
    0.11929316f, 0.01445521f, 0.29626849f, 0.10265146f, -0.05756652f, -0.17584795f, -0.03738775f, -0.07067497f, 
    0.10139637f, 0.06660701f, 0.02626210f, 0.03946269f, 0.02133597f, 0.08341135f, 0.02420068f, 0.08105870f, 
    0.06289630f, -0.05311184f, -0.17002751f, -0.32946283f, -0.07152934f, -0.31126201f, -0.03711563f, 0.18160526f, 
    0.09337950f, 0.12887746f, -0.07081006f, 0.05467166f, 0.04953969f, -0.02224123f, -0.08618616f, 0.23304830f, 
    -0.02482718f, -0.22406158f, -0.13270928f, -0.27096418f, 0.04157420f, -0.11460365f, 0.06591001f, -0.11044627f, 
    0.08718978f, -0.01055573f, 0.11431490f, 0.12977956f, -0.02171128f, 0.01262642f, -0.04462319f, 0.09693537f, 
    -0.01884772f, -0.03643323f, -0.01409266f, -0.02258421f, 0.05482908f, -0.02535490f, 0.18531960f, 0.00225142f, 
    0.15418063f, 0.10055753f, -0.03288660f, 0.06997154f, 0.06128484f, -0.00583532f, 0.00044174f, 0.00727940f, 
    0.01237884f, 0.11560285f, -0.04738041f, 0.02167474f, -0.08473970f, -0.01906356f, -0.19868749f, -0.21306983f, 
    0.23582643f, 0.10987841f, -0.02969592f, -0.03471752f, -0.10390913f, -0.02853475f, -0.05083137f, -0.03858434f, 
    -0.02642566f, 0.01531831f, 0.08085196f, -0.12716256f, -0.04711592f, -0.04667789f, -0.06914365f, 0.20819607f, 
    0.07593938f, 0.10675874f, -0.11019550f, -0.02812327f, -0.08743905f, 0.04375768f, 0.13066450f, 0.04370859f, 
    -0.15647432f, -0.02870815f, -0.03834508f, -0.12440188f, -0.12820800f, -0.01058953f, -0.03617708f, 0.19347981f, 
    0.03972047f, 0.05271042f, -0.05226227f, -0.01125144f, 0.03480456f, -0.02392985f, -0.07838365f, -0.06226055f, 
    0.17486554f, 0.10330374f, 0.39088675f, 0.13675722f, -0.34871122f, -0.06981869f, 0.22421542f, -0.22566910f, 
    -0.05913791f, 0.00866222f, -0.17794979f, 0.01330898f, -0.12720671f, 0.02617038f, 0.05129777f, 0.09438933f, 
    0.12397996f, 0.16702263f, 0.02714092f, 0.11862038f, 0.06349220f, -0.00584036f, -0.04581103f, 0.02445336f, 
    0.10113031f, 0.02404705f, 0.26168254f, -0.07273798f, -0.16296603f, -0.04040075f, -0.30648473f, 0.06442148f, 
    -0.06341390f, -0.13710232f, 0.21225195f, 0.01565211f, 0.12311174f, 0.13495730f, 0.14719568f, -0.07542691f, 
    -0.19472080f, -0.08690394f, -0.10219991f, 0.06638718f, 0.05799393f, -0.13408278f, 0.18132952f, 0.13292600f, 
    0.04764055f, 0.00149404f, -0.04445582f, 0.05553004f, -0.06253712f, 0.02781446f, -0.12285952f, -0.06243351f, 
    -0.13677442f, 0.07450489f, -0.11919367f, -0.23105560f, 0.07333904f, 0.15022415f, -0.04200665f, 0.04557474f, 
    -0.11019728f, -0.10313085f, -0.04222470f, -0.10358475f, 0.25269654f, -0.09125055f, 0.21537587f, 0.04826701f, 
    -0.00193745f, 0.02746563f, 0.12278207f, -0.05412187f, -0.05085731f, -0.04014229f, 0.00791338f, -0.04867316f, 
    -0.14606906f, 0.01633890f, -0.07262980f, -0.03044740f, 0.01445328f, 0.07760633f, 0.24716599f, -0.07592392f, 
    -0.10581810f, -0.15852146f, -0.05760298f, -0.13865533f, 0.13432544f, -0.05730381f, 0.08173670f, -0.02715301f, 
    0.00132771f, -0.00737495f, -0.00601745f, -0.05066518f, -0.29699621f, -0.26500219f, -0.31116328f, -0.30874038f, 
    -0.09906696f, -0.00352114f, -0.23290445f, -0.22495428f, 0.02351025f, 0.11943372f, 0.11410510f, 0.09463067f, 
    0.10748770f, 0.00713336f, 0.09345973f, -0.01768072f, -0.02535278f, 0.15448427f, -0.04371789f, 0.09669137f, 
    0.04528088f, -0.01902055f, 0.07810811f, 0.18556771f, -0.11699954f, -0.04659165f, 0.13024740f, -0.14169705f, 
    0.08468860f, 0.06706281f, -0.04846384f, 0.04063534f, 0.23831637f, 0.10636955f, 0.14153886f, -0.08494843f, 
    -0.29050362f, -0.19861870f, 0.08562379f, -0.14790449f, 0.01100645f, 0.08697876f, 0.04059261f, 0.28690779f, 
    -0.13481739f, 0.03398558f, -0.04337210f, 0.05058338f, 0.04381545f, 0.04639870f, 0.06095670f, 0.04869865f, 
    -0.00664911f, -0.03263690f, -0.06541553f, -0.03803021f, -0.01968654f, -0.04094233f, -0.13240866f, -0.04767736f, 
    -0.15292996f, -0.01114257f, 0.03088330f, -0.02227725f, 0.15376182f, 0.05885015f, 0.09934672f, 0.11431967f, 
    -0.07596346f, 0.03312776f, -0.19825491f, 0.04332023f, 0.01075902f, 0.03193550f, 0.06151173f, 0.06595312f, 
    -0.07035147f, -0.11434106f, 0.09398485f, 0.05977476f, -0.04743727f, 0.09674860f, -0.03144209f, 0.09227944f, 
    0.31010172f, 0.19846459f, -0.16159949f, -0.04732461f, -0.00158700f, 0.03099422f, -0.06741303f, -0.01748865f, 
    0.06726176f, 0.08243880f, 0.02374505f, -0.13637933f, 0.11617238f, 0.09290809f, -0.11257996f, 0.13163514f, 
    0.02613243f, 0.07754935f, -0.04638548f, 0.08430907f, 0.06833082f, 0.06494180f, 0.09868937f, 0.08017129f, 
    0.00406527f, -0.04118365f, 0.03587440f, 0.01349078f, 0.18317613f, 0.05293211f, 0.29640761f, 0.21488586f, 
    -0.03467382f, 0.03514853f, 0.00592746f, -0.02619871f, 0.35839587f, 0.12226664f, 0.12310737f, 0.05503709f, 
    0.09311677f, -0.06356466f, 0.08997358f, 0.01199538f, 0.00361468f, 0.06194281f, -0.03315589f, -0.04110141f, 
    -0.07779733f, 0.00497753f, -0.04036757f, 0.03184827f, -0.05928083f, -0.12716919f, -0.04020284f, 0.03145368f, 
    0.00123075f, 0.03753900f, -0.08125220f, 0.05819995f, -0.19527504f, 0.07923352f, 0.03007877f, 0.04120250f, 
    -0.10798624f, -0.08468532f, -0.02924711f, -0.03147271f, 0.03801353f, 0.07165015f, -0.04654931f, 0.12505530f, 
    0.08327001f, -0.10130303f, -0.03336201f, 0.05336310f, -0.00322055f, -0.19727193f, 0.02017777f, 0.01585208f, 
    0.04902923f, 0.04439353f, -0.04660695f, 0.05783853f, -0.24734385f, -0.19518153f, 0.01526792f, 0.00050568f, 
    0.13393347f, -0.03164017f, 0.20267008f, 0.16005626f, 0.08331683f, -0.12315442f, 0.07087483f, -0.08067404f, 
    0.10434132f, -0.09231535f, -0.02922341f, -0.00718505f, 0.28284186f, 0.21969028f, 0.02792560f, 0.05558584f, 
    0.09228681f, 0.17658190f, 0.17000662f, -0.11502700f, 0.21996839f, -0.10492834f, -0.11492164f, -0.02372381f, 
    -0.00322533f, 0.06314991f, 0.24350096f, -0.31219748f, 0.06695880f, -0.05503640f, -0.07446367f, 0.09404965f, 
    0.04498916f, 0.02982724f, -0.01282601f, -0.03902027f, -0.05158607f, -0.04931555f, 0.04032012f, 0.03355164f, 
    -0.03029587f, -0.04596638f, -0.03258947f, -0.03297865f, 0.01366368f, -0.04577286f, 0.01099314f, -0.04732933f, 
    0.00896752f, -0.00754465f, -0.03449889f, -0.00013296f, -0.04843985f, -0.00427542f, -0.03093106f, -0.01996141f, 
    0.00169947f, 0.04203459f, 0.00354074f, 0.01016301f, 0.01938786f, -0.03163043f, -0.03059672f, 0.01745432f, 
    0.01869532f, 0.03200180f, 0.01254477f, -0.03793815f, 0.01679668f, -0.02009655f, -0.04671360f, 0.01276090f, 
    -0.00057504f, 0.01642769f, -0.02234419f, 0.00994198f, 0.01047193f, -0.04342368f, -0.00888182f, -0.03305895f, 
    -0.02256228f, 0.03502711f, -0.03697145f, -0.03477089f, 0.03017235f, 0.00766681f, -0.05250302f, 0.03791348f, 
    0.00601966f, -0.04596548f, 0.02856798f, 0.02671433f, 0.04252913f, -0.00825211f, -0.02087472f, 0.02377781f, 
    0.01979080f, 0.00559059f, 0.00567584f, -0.00448789f, 0.04016220f, 0.01689536f, 0.03496545f, 0.01911254f, 
    0.01384854f, 0.01507518f, 0.03294162f, -0.02892916f, -0.03283406f, -0.03529546f, -0.03071458f, -0.05324157f, 
    -0.02018019f, -0.01121661f, 0.00851521f, 0.02790886f, -0.03764051f, -0.02852562f, -0.03940804f, -0.00658044f, 
    0.03702033f, -0.03085127f, -0.03042229f, -0.02791338f, -0.04364997f, 0.01616099f, 0.00942402f, -0.01627371f, 
    0.01000024f, -0.03435666f, 0.01802329f, -0.03984722f, 0.02443976f, -0.01064790f, -0.05301783f, -0.03519955f, 
    -0.00215503f, -0.05363650f, -0.00267013f, 0.03411034f, -0.00218879f, 0.03443335f, -0.00568972f, -0.00956490f, 
    -0.00124315f, 0.03978933f, -0.02063144f, -0.00199847f, -0.00395957f, -0.01230161f, 0.00400932f, -0.03889683f, 
    0.03749046f, 0.01962662f, 0.03409551f, 0.03424377f, 0.03124878f, -0.04921645f, -0.05238670f, -0.01564839f, 
    0.00963418f, 0.02002170f, 0.00913899f, -0.05561435f, 0.02210935f, -0.00724899f, -0.00840999f, -0.04024531f, 
    -0.01915092f, 0.03225864f, -0.05488265f, -0.05675618f, -0.03350984f, 0.02711683f, 0.03399464f, -0.01215897f, 
    -0.05284363f, 0.00670828f, 0.04423514f, 0.01366509f, -0.03134996f, -0.00649548f, -0.03635695f, -0.00211861f, 
    0.02772535f, -0.00850535f, 0.03423546f, 0.02640034f, -0.00858650f, -0.05647532f, -0.04942729f, -0.02523425f, 
    -0.05196295f, 0.04361061f, 0.04059006f, 0.00686262f, -0.05572129f, -0.04289031f, -0.05209731f, 0.03416620f, 
    -0.03859757f, -0.01791640f, -0.00709163f, -0.00056994f, -0.03100343f, -0.01213739f, 0.00237708f, 0.01301163f, 
    0.03406290f, 0.00586488f, 0.03431229f, 0.04102596f, 0.03923268f, 0.04421867f, 0.01820654f, 0.02382076f, 
    -0.01771537f, -0.01167743f, 0.02635866f, -0.03784699f, 0.03077178f, 0.04942144f, -0.04412876f, 0.04081567f, 
    0.00750657f, -0.01952422f, -0.01418533f, -0.02774772f, -0.04374126f, -0.03034078f, -0.02572834f, -0.04451511f, 
    -0.01864129f, -0.03575582f, 0.00351422f, 0.02550446f, -0.03785271f, 0.02220493f, -0.05505644f, -0.05055055f, 
    0.01238276f, -0.05555388f, -0.05161095f, -0.05652155f, -0.04069962f, 0.02985765f, -0.04018525f, -0.02767392f, 
    0.03577651f, 0.04008989f, -0.02146014f, 0.03392093f, 0.03527262f, -0.00305275f, 0.04274919f, -0.04754400f, 
    -0.05622638f, -0.00895219f, 0.03502199f, -0.01604818f, -0.02121705f, 0.01152743f, -0.02207913f, 0.01345036f, 
    0.00900077f, 0.01417437f, -0.03207460f, 0.02094621f, -0.04530524f, 0.02795063f, -0.03623133f, -0.01281249f, 
    0.01071011f, 0.03113442f, 0.01428302f, 0.04923682f, -0.05386374f, -0.00041292f, -0.04473043f, 0.01000200f, 
    0.04517412f, -0.00818955f, 0.04360474f, -0.01955297f, 0.01389783f, -0.02220110f, 0.02585150f, 0.02597144f, 
    -0.00781375f, -0.01363747f, -0.01505990f, -0.04903251f, -0.01594025f, 0.02781372f, -0.00355731f, -0.01984167f, 
    -0.00406784f, 0.03643506f, -0.03925950f, 0.04437200f, 0.03927394f, 0.01825104f, -0.03857354f, 0.04628539f, 
    -0.03199475f, -0.03351206f, -0.02944719f, -0.03104097f, 0.02346920f, 0.02908505f, -0.03313629f, -0.01848257f, 
    -0.05573443f, -0.04355518f, -0.04745699f, 0.01822425f, 0.01726106f, 0.03492371f, -0.02974177f, 0.02215058f, 
    -0.04468970f, -0.05092433f, -0.05602847f, 0.01394689f, 0.03766804f, 0.01226138f, -0.04757645f, -0.00411790f, 
    -0.02740250f, 0.02237824f, -0.05603163f, -0.05462264f, 0.00848513f, -0.04000160f, -0.00561573f, -0.00023445f, 
    -0.01789285f, -0.00887016f, 0.00154562f, -0.02811881f, -0.02230940f, -0.05653859f, -0.01757893f, -0.02051468f, 
    0.02641712f, -0.02096901f, -0.03816065f, -0.03662023f, -0.05284586f, -0.00879511f, -0.02570156f, 0.04947833f, 
    -0.03615863f, -0.00459839f, -0.03322437f, -0.03480803f, -0.05481802f, -0.05660983f, 0.04447915f, 0.02632313f, 
    0.04301665f, 0.04057752f, -0.01720130f, -0.04561844f, -0.04538720f, 0.01703297f, 0.00166538f, -0.04646447f, 
    -0.04796974f, -0.02370778f, -0.04427709f, 0.03814800f, 0.00218002f, 0.03652807f, 0.02102334f, -0.05679416f, 
    0.01178901f, 0.04862694f, 0.00067455f, 0.03243512f, -0.02180871f, -0.03132947f, -0.03568268f, 0.04445536f, 
    -0.01991276f, -0.05256443f, -0.03376734f, -0.04059750f, 0.00014368f, -0.02100976f, -0.02035265f, 0.01541559f, 
    0.02139094f, -0.02941458f, -0.00152426f, -0.03071387f, 0.03431756f, 0.01507923f, 0.00904191f, 0.00748218f, 
    -0.00875582f, -0.01320326f, -0.03429980f, -0.04624389f, -0.03664281f, -0.00423767f, -0.00856412f, -0.00202282f, 
    -0.04534469f, -0.00928275f, -0.04015442f, 0.02413081f, 0.02618172f, -0.02113754f, 0.01961800f, -0.02269947f, 
    0.05687104f, 0.14701878f, 0.22112925f, -0.01766289f, -0.07343671f, -0.02317746f, 0.04342792f, 0.09872335f, 
    -0.07165115f, 0.03703217f, 0.07433822f, 0.07945214f, 0.15252256f, -0.00489276f, -0.10483456f, -0.11698836f, 
    0.05196480f, -0.07667209f, -0.00869412f, 0.09887693f, -0.02019305f, 0.14378220f, 0.03100427f, -0.05497874f, 
    -0.29502216f, -0.20989670f, 0.15414301f, 0.34400386f, 0.00222946f, -0.01292292f, -0.05880604f, -0.10503744f, 
    0.04255495f, -0.04007661f, 0.00086618f, 0.02276826f, -0.00557209f, -0.01844389f, 0.18493509f, -0.15180150f, 
    0.02092728f, -0.26622608f, 0.05720394f, 0.02349805f, -0.03649931f, 0.04391618f, -0.03067146f, 0.04900355f, 
    -0.27580577f, -0.15845318f, 0.10486013f, -0.32654575f, 0.04135828f, 0.03534612f, 0.01277740f, 0.03071938f, 
    -0.00711203f, 0.11509723f, 0.03058118f, 0.01063649f, 0.12229315f, -0.01734225f, -0.08594585f, -0.29716054f, 
    -0.03444990f, 0.01135506f, -0.05097448f, -0.07487651f, 0.03758892f, -0.09577103f, 0.12971172f, 0.14390174f, 
    -0.27748793f, -0.11811834f, -0.00734422f, 0.04248416f, 0.00192429f, -0.02710384f, 0.04649032f, -0.06346332f, 
    -0.14084721f, -0.11953179f, 0.01265265f, 0.05201259f, -0.40240526f, 0.13674340f, -0.07706090f, -0.02249453f, 
    -0.06614131f, 0.21078494f, -0.07440423f, 0.15420134f, 0.14975461f, 0.06450533f, 0.04951185f, -0.04791354f, 
    -0.05861231f, -0.17756382f, -0.17038108f, 0.02166532f, 0.14724427f, 0.02794961f, -0.08518115f, -0.21554960f, 
    0.02871091f, 0.01537780f, -0.01243365f, 0.05938899f, 0.09779128f, 0.11967761f, 0.02929075f, 0.18385880f, 
    0.05393601f, -0.17178443f, -0.00397479f, -0.09392428f, -0.04939082f, 0.00328719f, -0.10115591f, 0.12045670f, 
    -0.11499982f, -0.04468582f, 0.09903218f, 0.03187605f, 0.27567145f, 0.09910817f, 0.01659857f, 0.14792462f, 
    0.10505217f, 0.04324675f, -0.14724481f, 0.02396007f, 0.12304284f, 0.38569504f, 0.27309635f, 0.19088036f, 
    -0.04914978f, 0.10518128f, 0.01136989f, 0.15179937f, 0.00835058f, 0.02458324f, 0.02124853f, 0.04738715f, 
    -0.00481132f, 0.06499404f, 0.03553495f, -0.05677962f, 0.07526740f, 0.17713004f, 0.03617655f, -0.01735096f, 
    0.13249113f, -0.16392837f, -0.06495355f, 0.05668483f, 0.06562919f, 0.02010455f, 0.29083169f, 0.06023981f, 
    0.15117763f, 0.02356372f, -0.11227158f, -0.08569333f, -0.02238773f, -0.02224698f, 0.00095437f, 0.02972633f, 
    0.14034708f, -0.01970748f, 0.08757000f, 0.05013062f, -0.01272276f, -0.02621078f, 0.24019356f, -0.08480790f, 
    -0.12217937f, -0.10468557f, -0.05515620f, -0.15969634f, 0.03330659f, 0.21825632f, -0.00077455f, 0.06578045f, 
    -0.05609148f, -0.10398597f, 0.01652974f, 0.16171916f, -0.01804572f, -0.02722287f, -0.07718927f, 0.08440416f, 
    0.21139260f, -0.00831790f, -0.23438554f, -0.22791603f, -0.04114648f, 0.04700905f, -0.04439669f, 0.23832159f, 
    0.10355284f, 0.19892794f, 0.17717570f, -0.00778564f, 0.25822377f, 0.15857370f, 0.20214173f, 0.06355005f, 
    0.12208141f, 0.01283188f, 0.01714190f, -0.10353649f, 0.00368475f, -0.04622853f, 0.02434990f, -0.01899110f, 
    0.10024385f, 0.28804758f, 0.08474471f, 0.13885778f, 0.11972645f, 0.01127568f, -0.00359762f, -0.05396971f, 
    0.06649654f, -0.10932846f, -0.00300899f, -0.12595160f, -0.12485006f, -0.15483633f, 0.00335756f, 0.02920683f, 
    0.03995630f, -0.08274622f, -0.00650296f, 0.00210705f, 0.05231222f, 0.01947633f, 0.18546800f, -0.03852645f, 
    0.27620322f, -0.15769684f, -0.21461165f, -0.15679291f, -0.01100693f, 0.09112671f, 0.03284062f, 0.00469644f, 
    -0.04759330f, 0.13780116f, 0.02688790f, 0.00802780f, 0.08484402f, 0.32775399f, 0.13627845f, 0.01306754f, 
    0.17796062f, 0.11912262f, 0.00432328f, 0.15136816f, 0.05952386f, -0.00235159f, 0.02908927f, 0.13110431f, 
    -0.27604142f, -0.06184638f, 0.33870965f, 0.05452738f, -0.00178253f, -0.14976674f, -0.20827298f, -0.09228404f, 
    0.07977954f, -0.04882431f, -0.05045069f, 0.04981111f, -0.14288954f, -0.06389533f, -0.30018917f, -0.25042024f, 
    -0.06163663f, 0.08836106f, 0.00006249f, 0.00976202f, 0.09919719f, -0.00226061f, -0.08733790f, 0.00474826f, 
    -0.08022852f, -0.05760483f, -0.01788181f, -0.20674343f, 0.05577063f, 0.06701443f, -0.10713246f, 0.01267311f, 
    0.07743735f, 0.11334635f, 0.08403894f, 0.16293269f, -0.13100201f, -0.23270752f, 0.17143258f, 0.26207322f, 
    -0.00994543f, -0.10744700f, 0.05333542f, -0.08382347f, 0.12103386f, 0.06570837f, -0.01613502f, 0.07784221f, 
    -0.03099369f, -0.15422666f, 0.04427357f, -0.12066612f, 0.01570483f, 0.06297634f, -0.08770951f, -0.05368734f, 
    -0.07489318f, 0.01184311f, -0.03822056f, -0.05890838f, -0.03766034f, -0.22956686f, -0.14165987f, -0.38501567f, 
    0.09652988f, 0.03554606f, -0.05770579f, -0.09265956f, -0.07100491f, 0.04955874f, -0.09047630f, -0.12091616f, 
    0.20817667f, 0.11654662f, -0.04230524f, -0.05160512f, -0.03861172f, 0.06877486f, -0.00577710f, 0.01048886f, 
    0.01854337f, 0.07109658f, -0.01909404f, -0.04492974f, 0.14903893f, 0.07003857f, 0.34363401f, 0.25670964f, 
    0.02991975f, 0.01990486f, 0.06078997f, 0.02884181f, -0.02290229f, -0.15012789f, 0.14859892f, -0.11779075f, 
    0.05328469f, 0.14473966f, 0.07854088f, 0.03653506f, 0.02211918f, -0.07027070f, -0.00053165f, 0.06786352f, 
    0.05378716f, 0.00709117f, 0.00410494f, 0.03035522f, -0.13847850f, -0.29450241f, -0.10455794f, 0.05127990f, 
    0.12058984f, -0.02331276f, -0.11612845f, 0.03287603f, -0.01176895f, -0.01560549f, 0.01550671f, 0.00694862f, 
    -0.02962901f, 0.02525369f, -0.07065304f, -0.05376438f, 0.02674268f, -0.04215338f, -0.04911153f, -0.01970908f, 
    -0.02937070f, -0.05340172f, -0.03657854f, -0.06454302f, -0.05826109f, -0.07110284f, -0.05000524f, -0.01346849f, 
    -0.01044491f, -0.04599117f, 0.01566949f, -0.02347861f, 0.02062429f, -0.02492897f, -0.04560524f, -0.05199285f, 
    -0.07074659f, -0.06885975f, -0.01864146f, 0.01409855f, -0.00309276f, -0.05438620f, -0.00927326f, -0.06792911f, 
    -0.01497111f, -0.00436756f, -0.03876363f, -0.03745622f, 0.00236940f, -0.05925787f, -0.02905092f, -0.03812974f, 
    0.02845286f, 0.03287203f, 0.00105824f, -0.07207385f, -0.03687986f, -0.01912553f, -0.03488895f, -0.01248536f, 
    -0.04556250f, 0.01474632f, -0.00166415f, 0.01969689f, -0.02293933f, -0.04721001f, -0.01994874f, -0.03466987f, 
    0.04341056f, -0.01192072f, -0.00817695f, 0.00443820f, -0.03242351f, -0.02986983f, -0.02240228f, -0.00267685f, 
    0.00009430f, -0.04060601f, -0.00582946f, -0.07234096f, 0.02927302f, -0.01836653f, -0.02876588f, -0.04213034f, 
    -0.03180195f, 0.02729736f, -0.06135660f, -0.02779530f, -0.01190236f, 0.00062394f, -0.05440272f, -0.02661063f, 
    -0.06247330f, -0.03286469f, -0.01213090f, 0.01624464f, -0.00231173f, 0.01092137f, -0.06700030f, -0.06114266f, 
    -0.04966418f, -0.04025849f, -0.00839834f, -0.03695371f, -0.00348682f, -0.00409956f, -0.02380781f, -0.03094477f, 
    -0.03358872f, -0.01472084f, -0.02613815f, -0.03614855f, 0.02504547f, -0.04672606f, -0.05112396f, -0.07340639f, 
    -0.03828125f, -0.05860901f, -0.01238536f, -0.03589648f, 0.01377563f, -0.03003047f, -0.06662480f, -0.03818042f, 
    -0.06403133f, 0.01391750f, -0.01313197f, -0.04545356f, 0.01675749f, -0.03921673f, -0.05874022f, -0.05110317f, 
    -0.01950246f, -0.06551898f, 0.02152865f, -0.02699985f, 0.00988862f, 0.02818305f, -0.01641231f, 0.05042093f, 
    -0.03671453f, -0.01016772f, -0.05925233f, -0.04361189f, 0.02480222f, -0.03434907f, 0.04180625f, -0.05010682f, 
    -0.05097711f, -0.03321256f, -0.03231293f, -0.01229995f, 0.00452180f, -0.02411618f, -0.02223790f, -0.06447942f, 
    0.02168271f, -0.04778507f, -0.05308228f, -0.06255606f, 0.02186988f, -0.04133616f, 0.00932710f, 0.01288486f, 
    -0.00675030f, -0.05770549f, 0.00981837f, 0.01898935f, -0.05658982f, 0.00132895f, -0.05358699f, -0.03074105f, 
    -0.01368898f, -0.06023950f, -0.00096233f, -0.00649852f, -0.01022186f, -0.04618869f, -0.03259998f, 0.01126657f, 
    -0.04930719f, -0.01715077f, -0.00704706f, -0.04981159f, -0.01041828f, -0.01631157f, -0.03675470f, -0.01484779f, 
    -0.01363817f, -0.01824597f, -0.05488197f, -0.01408428f, -0.01192488f, 0.03133334f, -0.01437510f, -0.01173612f, 
    0.00030382f, 0.02034277f, -0.02152211f, -0.07139017f, -0.03694271f, -0.04433444f, -0.04623283f, -0.04736036f, 
    0.02240436f, -0.02908532f, -0.04363319f, -0.06451005f, 0.00566430f, -0.05386804f, -0.01457617f, 0.02028490f, 
    -0.04932825f, -0.00904184f, -0.03654270f, -0.06596683f, -0.06480914f, -0.01675062f, -0.04736535f, 0.00492734f, 
    -0.01714826f, 0.02403767f, -0.03484993f, -0.01021766f, -0.04847497f, -0.02390523f, 0.02401956f, -0.01651331f, 
    -0.06466362f, -0.01475447f, -0.05548574f, 0.00948495f, 0.02742741f, -0.02275905f, -0.01331694f, -0.04362082f, 
    -0.06396535f, -0.04162264f, 0.02561306f, 0.00517663f, -0.06271081f, 0.02531940f, 0.01312864f, -0.00618369f, 
    0.00906860f, 0.01076248f, 0.00906537f, -0.02348910f, -0.02087716f, -0.04314976f, -0.03042988f, -0.05667501f, 
    -0.02605714f, -0.00258794f, -0.01586637f, -0.02741966f, -0.01438474f, 0.01862273f, -0.04331533f, -0.03655356f, 
    -0.00215975f, -0.00163603f, -0.05409350f, -0.06806282f, -0.02905862f, -0.02892759f, -0.04668826f, -0.05472982f, 
    0.02148428f, -0.00258135f, -0.01203934f, 0.01234821f, -0.06920993f, 0.02564560f, 0.00234620f, -0.00279359f, 
    -0.02504307f, -0.05693553f, -0.02428259f, -0.04910302f, -0.04027100f, -0.01750311f, -0.04263120f, 0.01825387f, 
    0.00033023f, 0.00338356f, -0.01176487f, -0.06182116f, -0.06595054f, -0.04897362f, -0.03485852f, -0.06077880f, 
    -0.03936578f, -0.02483583f, -0.03890047f, 0.01548891f, -0.02548905f, -0.06421594f, -0.04450037f, -0.06957906f, 
    -0.06883796f, -0.04361831f, 0.01973648f, 0.01439260f, 0.03921220f, -0.04474279f, -0.00899784f, -0.06906685f, 
    -0.01372468f, -0.02689986f, -0.05866468f, -0.04534784f, 0.02609646f, -0.01345574f, -0.02142457f, -0.00708667f, 
    -0.05569130f, -0.00842548f, 0.00298460f, 0.02201800f, 0.00174503f, -0.06710114f, 0.02226467f, -0.03929786f, 
    -0.03734140f, -0.05775763f, -0.06689939f, -0.01610950f, -0.04660153f, -0.02404189f, 0.00239902f, -0.02070426f, 
    -0.07089598f, 0.00209709f, -0.02524465f, 0.00672736f, -0.05021783f, -0.02851234f, -0.06516831f, -0.02569025f, 
    0.02107491f, 0.01236229f, -0.01907955f, -0.02078442f, -0.02152866f, -0.01517557f, 0.01822959f, -0.04026605f, 
    0.01161620f, -0.05694625f, -0.04032742f, -0.06747540f, 0.00907323f, -0.02407510f, -0.01022863f, 0.01456713f, 
    -0.05342983f, 0.00729084f, 0.01342133f, -0.02547009f, -0.00643024f, -0.05546839f, 0.01387765f, -0.04164456f, 
    -0.00535222f, -0.04936019f, -0.05272855f, 0.04766083f, 0.01124012f, -0.03875517f, -0.00784513f, 0.01837913f, 
    -0.03239837f, 0.00251898f, -0.05459687f, -0.02135488f, 0.00675217f, -0.00867966f, 0.00004917f, -0.03809788f, 
    0.02637229f, -0.01462236f, 0.04670070f, -0.01268202f, -0.03829233f, -0.02234464f, -0.01306085f, 0.01098770f, 
    -0.03116249f, -0.03122822f, -0.06706067f, -0.03833193f, -0.05693879f, -0.02471556f, -0.06462073f, -0.01839939f, 
    -0.18785821f, -0.00746991f, 0.02209417f, 0.20379950f, -0.06474937f, 0.06472799f, -0.00853356f, -0.16291852f, 
    0.01258104f, -0.16470203f, -0.03381980f, -0.00820340f, -0.07812419f, -0.05750858f, -0.14530094f, 0.04990904f, 
    0.04877794f, -0.11538766f, 0.05155331f, 0.01104903f, 0.02007991f, 0.05556651f, -0.06412753f, 0.06263065f, 
    0.45457593f, -0.17478114f, -0.29759693f, -0.06048274f, -0.01613034f, -0.09020034f, -0.08921989f, -0.04013990f, 
    0.14413765f, 0.00956895f, 0.04609483f, -0.05446826f, 0.15458935f, -0.19677235f, 0.20725664f, 0.25311270f, 
    -0.07336901f, -0.02642610f, 0.05910370f, 0.05917237f, 0.04004095f, -0.15468715f, -0.04560427f, -0.06979875f, 
    0.02123322f, 0.34039468f, -0.10517543f, 0.14795940f, 0.03788580f, 0.15948141f, 0.00586680f, 0.09685889f, 
    0.08991186f, 0.01234476f, -0.01650820f, 0.04144502f, -0.40419310f, 0.09507370f, 0.07533039f, 0.18940163f, 
    -0.02482629f, -0.08662413f, -0.00567478f, 0.09782381f, 0.05848191f, -0.08792812f, 0.08603144f, -0.00627404f, 
    -0.09203301f, -0.26418179f, -0.18799895f, -0.22967874f, 0.05276278f, -0.03485865f, -0.05661161f, 0.03509712f, 
    0.11682155f, 0.02909804f, 0.10767787f, 0.20673941f, -0.01677902f, 0.09611218f, 0.14517114f, -0.10741254f, 
    0.00058075f, -0.19373789f, 0.04761032f, -0.08148324f, 0.03295604f, -0.01750309f, -0.07360370f, 0.01811078f, 
    0.27201146f, 0.02935463f, -0.09303178f, -0.12216599f, 0.12959659f, -0.09484424f, -0.04284491f, 0.12271542f, 
    0.05610619f, -0.03810889f, 0.19584739f, 0.11241268f, -0.06094842f, 0.11491694f, 0.07027389f, 0.01692138f, 
    -0.03150878f, -0.00076078f, -0.04236000f, -0.12360824f, 0.11046907f, -0.17843316f, 0.11671807f, -0.06439195f, 
    -0.10027217f, -0.25673828f, 0.13644946f, 0.12194417f, 0.07573881f, -0.02264525f, -0.06942830f, -0.00764323f, 
    -0.04546455f, -0.06834918f, -0.11701171f, -0.02050404f, -0.17201552f, -0.00068072f, 0.18391536f, 0.10715518f, 
    -0.10268441f, 0.08178114f, 0.05897477f, -0.07534724f, -0.00990931f, -0.08094252f, -0.04645015f, 0.02850290f, 
    0.00869182f, -0.00991654f, 0.01101275f, 0.00865371f, -0.02552718f, -0.01492424f, -0.04445084f, -0.06541748f, 
    -0.01143641f, 0.02652114f, 0.04546941f, -0.01827440f, -0.01265585f, -0.23877281f, -0.01113612f, 0.05328331f, 
    -0.08241197f, 0.06097533f, 0.08469402f, 0.11686754f, 0.17406534f, -0.04453251f, 0.03827861f, -0.06469565f, 
    -0.07867672f, -0.04873256f, 0.08305956f, -0.16067661f, 0.14017190f, -0.01833773f, -0.03840072f, 0.01952501f, 
    -0.00350156f, 0.03053673f, 0.00154498f, 0.04122837f, 0.01607163f, -0.11490615f, 0.24813332f, 0.07444149f, 
    0.22842449f, 0.01216310f, 0.02512619f, -0.13213390f, 0.05278907f, -0.07301731f, -0.10562467f, -0.07433470f, 
    -0.28890997f, 0.03976433f, 0.04170740f, -0.01150648f, -0.06192730f, 0.08148793f, -0.02335318f, -0.09785310f, 
    0.01315165f, 0.00134356f, -0.10255159f, -0.03960761f, -0.22371799f, 0.02945499f, 0.01187232f, 0.02325176f, 
    -0.17982441f, 0.05210524f, 0.15733571f, 0.04417202f, -0.02048524f, -0.14857052f, -0.11751071f, -0.05138438f, 
    -0.12288613f, 0.07270709f, -0.09149165f, -0.08785683f, 0.04599236f, -0.03512529f, -0.10722377f, 0.08632182f, 
    0.02047444f, -0.00390537f, -0.04368443f, -0.07556295f, -0.01719978f, -0.01108434f, -0.02925940f, -0.06763908f, 
    -0.01106221f, -0.02464175f, -0.00590073f, 0.03051994f, 0.03113552f, -0.01904755f, 0.05888210f, 0.01995199f, 
    -0.05565872f, -0.02450084f, 0.10335486f, -0.09176467f, -0.04838189f, 0.04514091f, 0.04092091f, -0.04865023f, 
    0.05477215f, -0.14755945f, 0.02277298f, 0.03478028f, -0.29231700f, -0.08902650f, 0.17348666f, 0.13529977f, 
    -0.08681258f, -0.01986670f, 0.02703020f, -0.12727994f, -0.11197831f, -0.06477478f, -0.01630999f, 0.08290580f, 
    0.33111033f, 0.04263117f, -0.31501824f, 0.27163348f, 0.07909441f, -0.17652629f, -0.06583228f, -0.01374518f, 
    -0.00982493f, 0.10896969f, 0.05596956f, 0.09223299f, -0.03894822f, -0.16873074f, 0.04518138f, -0.03835572f, 
    -0.00409477f, -0.11448367f, -0.04354021f, -0.10001463f, 0.05409835f, -0.15345958f, 0.10356655f, 0.01328894f, 
    -0.00086619f, 0.02779175f, -0.04202162f, -0.00937030f, 0.08572001f, 0.13528234f, 0.13817893f, 0.17658003f, 
    0.10189754f, 0.08364534f, 0.08446119f, 0.09739529f, 0.41127902f, -0.07450528f, -0.01806744f, -0.04151211f, 
    -0.05158804f, -0.11624700f, -0.06177412f, 0.08854429f, -0.05607994f, -0.03054135f, -0.07578607f, -0.07136881f, 
    -0.12459499f, -0.09767505f, 0.01517247f, -0.08040023f, 0.00643643f, 0.00033650f, 0.05340952f, -0.03215179f, 
    0.18620567f, 0.04460989f, -0.01338375f, 0.01613201f, -0.11391062f, -0.01600110f, -0.02208168f, 0.03013347f, 
    -0.03510937f, 0.03463433f, 0.02473542f, -0.01131570f, 0.18441767f, 0.00067001f, 0.03230100f, 0.03723809f, 
    -0.34370217f, 0.03397293f, 0.22581215f, 0.01535070f, -0.01728058f, 0.08566338f, 0.12723795f, -0.10566460f, 
    0.02919664f, 0.07473534f, 0.01915091f, -0.04670082f, 0.04706039f, -0.27296382f, 0.04910567f, 0.09699281f, 
    0.01117518f, -0.01570130f, -0.03353754f, -0.00010393f, 0.00959087f, -0.12100910f, -0.06371816f, -0.05563973f, 
    -0.22021690f, -0.08443076f, -0.00810968f, -0.07655972f, 0.00378209f, 0.02600631f, 0.09201473f, 0.12260722f, 
    0.04148397f, -0.06431057f, -0.02108647f, -0.02280758f, 0.07018607f, 0.37683037f, -0.18382131f, 0.19705258f, 
    0.13726535f, 0.05151529f, -0.00081597f, 0.02565386f, -0.02352820f, 0.03749847f, -0.10074786f, -0.05022641f, 
    -0.30320081f, -0.16133969f, 0.17568769f, 0.08491639f, -0.07882617f, 0.16905569f, 0.13752308f, -0.12601151f, 
    0.05801890f, -0.02379814f, 0.00878610f, -0.03965351f, -0.17693214f, 0.39331973f, -0.29099566f, -0.02463409f, 
    -0.03660006f, -0.09378909f, 0.14390686f, -0.06923468f, -0.13800851f, -0.00514354f, -0.00652186f, 0.03721422f, 
    0.21557263f, -0.04864264f, -0.10813478f, -0.17673504f, -0.07134482f, -0.07153429f, -0.04741076f, 0.01202577f, 
    -0.02875928f, 0.12933806f, 0.15407632f, 0.03676220f, 0.22390693f, 0.37247735f, 0.18108442f, -0.14223598f, 
    -0.08432070f, -0.20270228f, -0.08217416f, 0.01454175f, -0.08251341f, 0.01522691f, -0.03951835f, 0.03047056f, 
    -0.36938936f, -0.05106048f, -0.10000645f, 0.43116194f, 0.02274558f, 0.09672483f, -0.07564011f, 0.03284700f, 
    0.01296516f, 0.04347957f, -0.08025621f, 0.04204747f, 0.37279403f, 0.09127210f, 0.08205657f, 0.23349352f, 
    0.02365846f, 0.02246387f, 0.15024161f, 0.08481026f, 0.10679725f, -0.02899733f, -0.00166614f, 0.12232866f, 
    0.03492307f, -0.08583272f, -0.28982303f, -0.24416165f, 0.23142657f, 0.08089513f, 0.01034595f, -0.04768287f, 
    -0.10295048f, 0.04890299f, -0.00942421f, 0.09475934f, 0.31636131f, 0.13504831f, 0.10057107f, -0.37007219f, 
    0.01259760f, -0.07078211f, 0.01155229f, 0.05866059f, -0.00217979f, 0.13872930f, 0.08329453f, 0.14953674f, 
    0.20225134f, 0.03104674f, -0.13091461f, -0.22161220f, 0.04722606f, 0.09383110f, -0.04941437f, 0.05384919f, 
    0.06924360f, -0.10371228f, 0.21660955f, -0.07419635f, 0.06971967f, -0.04825923f, -0.11713555f, 0.20773217f, 
    0.02998620f, 0.03762981f, 0.08526284f, -0.03843155f, 0.06079594f, 0.04815638f, 0.05841838f, -0.06289010f, 
    -0.14217681f, -0.18952607f, -0.16541031f, 0.03269033f, 0.00230864f, -0.02319040f, -0.11728417f, 0.12681089f, 
    -0.07833168f, 0.04632981f, -0.25637612f, -0.08358552f, -0.37124032f, -0.11017013f, -0.02529298f, 0.18437037f, 
    -0.16505019f, -0.02087229f, 0.05509831f, -0.07427544f, 0.11591686f, 0.02150806f, -0.08371726f, -0.11503980f, 
    -0.15239845f, 0.01737956f, -0.02644129f, -0.08268879f, 0.00666507f, -0.00409062f, -0.13081734f, -0.04483088f, 
    -0.03862685f, 0.06435386f, 0.16709353f, -0.03635045f, 0.13929188f, -0.13132852f, 0.07096133f, 0.06217745f, 
    0.08588282f, 0.11768261f, 0.06807637f, -0.05712038f, 0.09694212f, -0.06084837f, 0.03863555f, 0.05385757f, 
    -0.05169090f, -0.08121827f, 0.23954654f, -0.08086162f, -0.04781396f, -0.14190550f, -0.13418086f, -0.02262412f, 
    -0.19497958f, -0.05148870f, 0.11521710f, -0.04040889f, -0.09794789f, -0.19658937f, 0.10677044f, -0.02002215f, 
    0.04607097f, -0.03780182f, -0.04783870f, -0.03508037f, -0.02246956f, -0.04112537f, -0.18987797f, -0.05538136f, 
    -0.16063935f, 0.30692533f, 0.16152067f, 0.14797069f, -0.03116664f, 0.09217077f, -0.01703030f, 0.02273930f, 
    0.12403609f, -0.06962384f, 0.15736400f, -0.03717250f, -0.02151879f, -0.22293113f, 0.19059521f, 0.23396513f, 
    -0.00819911f, -0.06237004f, 0.04648845f, -0.12462581f, 0.03362155f, -0.06528423f, 0.08546602f, -0.08484759f, 
    -0.08396393f, -0.00121082f, 0.17334950f, 0.21535067f, 0.00941103f, -0.03519940f, 0.10878411f, 0.08335435f, 
    0.01273536f, 0.06765690f, 0.03046655f, 0.03583225f, 0.00849315f, 0.15320942f, -0.07435376f, -0.35446960f, 
    -0.19850396f, -0.37382808f, -0.09888985f, -0.06871863f, 0.07218902f, 0.10115446f, -0.00733005f, -0.08204058f, 
    -0.18720753f, -0.09622116f, 0.30655026f, 0.07073423f, -0.14603689f, -0.04338858f, -0.10895626f, 0.01807047f, 
    0.22344702f, 0.05831312f, -0.08369051f, 0.04267583f, -0.02657600f, -0.07920290f, 0.11948889f, 0.21222277f, 
    -0.02077173f, 0.03291728f, 0.03214865f, 0.15192550f, -0.02767764f, -0.01987784f, 0.16099143f, -0.07933179f, 
    0.57872760f, 0.13707951f, 0.05797943f, 0.08717060f, 0.20706321f, -0.08060732f, 0.03262110f, -0.12884116f, 
    0.04788726f, -0.06884978f, -0.07115835f, 0.00764992f, 0.11634896f, 0.24838455f, -0.34277058f, -0.14413933f, 
    0.03661048f, 0.01556832f, -0.16182058f, -0.01350383f, 0.09802361f, -0.09711243f, 0.14320789f, 0.00444490f, 
    -0.15835336f, -0.18235940f, 0.15896147f, 0.00955586f, 0.01198762f, 0.04629969f, 0.07191626f, 0.04393069f, 
    -0.07457781f, 0.12778747f, -0.11656114f, -0.05933432f, 0.16758299f, -0.12534907f, 0.20285992f, -0.03157383f, 
    0.00923273f, -0.10612521f, -0.05872338f, 0.02543036f, 0.06763291f, 0.11234543f, -0.07600353f, 0.06984145f, 
    -0.16676959f, -0.01589874f, 0.01887377f, -0.25415960f, -0.08228093f, -0.31995797f, -0.09765431f, -0.06950322f, 
    -0.30995193f, 0.00634124f, 0.06599037f, -0.16089483f, -0.07518606f, -0.19436368f, -0.13805857f, -0.04529132f, 
    0.14731163f, -0.04898310f, 0.07380931f, -0.01151893f, 0.00796820f, -0.00664280f, 0.03883805f, 0.06693743f, 
    -0.13741414f, 0.28116959f, 0.34644690f, 0.09030906f, 0.02568052f, 0.11056548f, 0.11037372f, 0.00221757f, 
    -0.04770776f, 0.11497133f, 0.00366601f, 0.09679094f, -0.00487061f, -0.07379992f, -0.09602512f, 0.13422091f, 
    -0.01310473f, 0.07592303f, 0.01252745f, 0.13194181f, -0.14286679f, -0.04023220f, 0.06483797f, -0.10508682f, 
    -0.02002319f, -0.11074468f, -0.01262457f, 0.16033041f, 0.01552008f, -0.06720091f, 0.06114248f, 0.00386241f, 
    -0.05546602f, 0.10223278f, 0.14900872f, 0.07553054f, -0.14180852f, 0.46673939f, 0.00579449f, 0.23607969f, 
    -0.18791947f, -0.00653329f, -0.06406838f, -0.05708052f, 0.00149956f, 0.11760093f, -0.14511135f, -0.02188654f, 
    -0.01238656f, 0.02349064f, -0.06520990f, 0.16504931f, 0.00915986f, 0.06363505f, 0.15194660f, 0.14680968f, 
    0.08809429f, 0.02134080f, -0.07260595f, -0.06404052f, -0.24749523f, -0.18590701f, 0.02468932f, -0.05684066f, 
    0.05677971f, 0.10421930f, 0.03004074f, 0.00829196f, -0.03769625f, 0.05793822f, -0.07991754f, 0.12792106f, 
    0.08794387f, 0.02450902f, -0.16246983f, -0.20063472f, -0.09709098f, 0.10379237f, 0.02845404f, -0.14746781f, 
    0.18259874f, 0.15862592f, 0.08507808f, 0.03741204f, 0.16530243f, -0.06055367f, -0.39186779f, 0.19295855f, 
    -0.07615563f, 0.22690821f, 0.16783923f, -0.13569008f, 0.05996148f, -0.06713699f, 0.10469320f, -0.13998730f, 
    0.09603719f, 0.37382284f, 0.18317379f, 0.18334727f, -0.05791156f, -0.11612444f, -0.02322363f, -0.12548259f, 
    0.16529113f, 0.01632451f, -0.08446394f, -0.06291305f, 0.14466342f, -0.04976851f, 0.26231563f, 0.30393189f, 
    0.05137932f, -0.01460482f, -0.03920716f, -0.13359989f, 0.06227774f, 0.12091447f, -0.09996416f, 0.18202181f, 
    0.20981400f, 0.05282619f, -0.12862070f, -0.21642396f, -0.09539734f, 0.08729124f, 0.00414991f, 0.06243345f, 
    0.26405644f, 0.06718615f, 0.07592941f, 0.01518331f, 0.37469003f, -0.44751820f, 0.21470153f, 0.36676291f, 
    0.01127603f, 0.05589755f, -0.07986587f, -0.06755152f, -0.04170401f, -0.02194295f, 0.03273247f, 0.17349103f, 
    -0.00234740f, -0.04758149f, -0.01918431f, -0.27632752f, 0.07896545f, -0.07412013f, 0.07694930f, 0.10464375f, 
    -0.07696503f, -0.09174108f, 0.08227906f, -0.24685229f, -0.18873520f, -0.00417889f, -0.06804491f, 0.01653251f, 
    0.14369237f, 0.06220757f, 0.01153587f, 0.14186177f, 0.06920674f, 0.06770706f, 0.17149414f, -0.12044038f, 
    -0.23326096f, -0.13129286f, -0.11585847f, 0.09722038f, -0.16594608f, -0.08468888f, -0.11735572f, -0.08382217f, 
    -0.01388192f, 0.01891266f, -0.16815369f, 0.05615104f, -0.25844216f, -0.10104157f, 0.05546893f, 0.14532562f, 
    -0.04314015f, 0.00617339f, 0.01823376f, -0.01171489f, 0.11110190f, 0.04222115f, 0.04384183f, -0.04484491f, 
    0.10852891f, -0.06683306f, -0.03445143f, -0.04028741f, -0.05893279f, -0.19067377f, -0.09743249f, -0.00534387f, 
    -0.30342788f, -0.25784495f, -0.05319999f, -0.51952708f, 0.25624251f, 0.08617847f, 0.00051987f, 0.09649530f, 
    -0.12330420f, -0.04386334f, -0.01434212f, -0.07246099f, 0.10156818f, -0.02117326f, 0.01428337f, 0.01340582f, 
    0.01058631f, -0.16802487f, 0.08284234f, 0.07279241f, 0.00529486f, -0.12164881f, -0.02720974f, 0.09352841f, 
    -0.02020678f, -0.19507825f, -0.15382569f, -0.21323988f, 0.09252695f, -0.15307884f, 0.09279395f, 0.18161406f, 
    0.03603058f, 0.12462498f, 0.27125978f, -0.00369177f, 0.01173670f, -0.03639441f, 0.00278337f, -0.05326263f, 
    -0.30029911f, 0.06711407f, 0.18419312f, 0.00007941f, 0.17117868f, 0.01456912f, -0.11746553f, -0.02757117f, 
    0.12746237f, -0.16092007f, -0.07739084f, -0.00960353f, -0.08602578f, -0.06225643f, -0.02418377f, 0.10197291f, 
    -0.03188555f, -0.03623623f, 0.01248199f, 0.05948585f, 0.06425155f, 0.05270085f, 0.10714560f, 0.04054634f, 
    -0.00768198f, 0.07379586f, -0.04472148f, 0.15494822f, 0.05386672f, -0.02115496f, 0.02847607f, 0.01206212f, 
    0.02181790f, -0.01441611f, 0.08116017f, -0.01998179f, -0.15283293f, -0.24395698f, -0.18090183f, 0.00853546f, 
    -0.03596897f, 0.18852134f, -0.03800416f, -0.18198870f, 0.00811152f, -0.07345116f, -0.11273086f, 0.20068206f, 
    -0.19730182f, -0.10051338f, 0.10251135f, 0.01495881f, 0.10860183f, -0.00386397f, -0.00346159f, -0.05309005f, 
    0.09521542f, -0.22846788f, 0.19489849f, 0.03960608f, -0.06313236f, -0.20048082f, 0.05233668f, 0.08748037f, 
    0.00151143f, -0.07485498f, -0.01971312f, -0.00416128f, -0.07766301f, -0.04014700f, -0.05394824f, 0.00296864f, 
    0.25685832f, -0.23684356f, -0.19371940f, 0.14153914f, -0.15216489f, 0.03101927f, 0.04707329f, -0.18562834f, 
    0.04365459f, 0.06429435f, 0.12122842f, 0.14779523f, 0.01953262f, -0.15489519f, 0.24867328f, -0.08129419f, 
    0.04071116f, 0.00877554f, -0.23688383f, 0.00468042f, 0.02938198f, -0.02483449f, 0.14664254f, 0.19464539f, 
    0.05826159f, 0.05956039f, -0.18289903f, -0.22700229f, -0.03900011f, -0.09296452f, 0.15061864f, -0.01274828f, 
    0.04462162f, 0.01880934f, -0.26285201f, -0.15064214f, -0.00762446f, 0.05565471f, -0.19225281f, -0.08267070f, 
    -0.09791514f, 0.04472775f, 0.00922477f, -0.04849769f, -0.07640868f, 0.07398810f, 0.05243944f, 0.07876518f, 
    0.11488642f, -0.13921116f, 0.01758053f, -0.07566044f, 0.06623812f, 0.05512715f, 0.04169067f, -0.20375295f, 
    -0.10425290f, -0.14381155f, -0.13129506f, -0.11048465f, 0.27956513f, 0.26856008f, 0.11157741f, 0.14486229f, 
    -0.07701602f, -0.20995225f, 0.05634157f, -0.06637168f, 0.08026255f, -0.01415367f, 0.11031866f, 0.09233148f, 
    0.10037480f, -0.21674408f, 0.25896600f, -0.04012205f, 0.08350631f, -0.01113415f, 0.12342878f, -0.10114201f, 
    -0.06904991f, 0.02554536f, 0.06385858f, 0.06454366f, -0.20185868f, -0.13399674f, -0.08745637f, -0.02884479f, 
    -0.02313996f, 0.03834057f, -0.20323648f, 0.13811451f, -0.06893969f, 0.01965785f, -0.06137516f, -0.00777727f, 
    -0.16052663f, 0.00292590f, -0.04896113f, 0.07220273f, 0.04490232f, 0.10171720f, 0.02058486f, 0.03758348f, 
    0.03213046f, 0.07083934f, 0.07837786f, 0.30225980f, 0.05946324f, 0.15614882f, 0.06241690f, -0.05789320f, 
    -0.08431109f, -0.04115288f, 0.13561471f, 0.02356987f, 0.00441232f, -0.03716788f, -0.13337474f, -0.17171098f, 
    0.04997942f, -0.08956605f, 0.02507106f, 0.13172032f, 0.03063996f, 0.19374435f, 0.04064144f, 0.02775001f, 
    0.05313135f, -0.15037732f, -0.04128906f, -0.06391638f, -0.02245826f, 0.10506274f, -0.11970406f, 0.08405416f, 
    0.04901567f, 0.00613278f, 0.01049116f, 0.01167711f, 0.12915583f, -0.01705885f, -0.05993873f, 0.04969498f, 
    -0.01720965f, -0.15233763f, 0.20787680f, -0.15089910f, 0.01040303f, -0.08021433f, -0.02754450f, -0.03674430f, 
    0.05626538f, 0.15171140f, -0.08815844f, 0.20449075f, -0.17892376f, 0.15240827f, 0.42662537f, -0.00192747f, 
    -0.14409940f, -0.28480327f, -0.19361214f, -0.17009927f, 0.03152968f, 0.04024198f, 0.03405621f, 0.02261783f, 
    -0.03155782f, -0.14207606f, -0.21925439f, 0.02225176f, 0.02415819f, 0.07755320f, 0.08102237f, 0.12816611f, 
    0.01562234f, -0.15077230f, -0.01181663f, -0.07819312f, -0.18123367f, -0.36727864f, -0.32373726f, -0.10575869f, 
    0.15037575f, 0.10331333f, 0.08843284f, 0.10700655f, -0.12299160f, -0.06961301f, 0.04897567f, 0.00539974f, 
    0.02846815f, -0.18702115f, 0.02743076f, -0.17737357f, 0.06225579f, -0.01268471f, -0.09756961f, 0.01042615f, 
    -0.01340688f, -0.07811183f, 0.08597283f, -0.04677654f, 0.21246646f, 0.50528741f, 0.19596675f, 0.03087508f, 
    -0.07197386f, -0.19761458f, -0.05060454f, 0.24768472f, 0.00359176f, 0.08383953f, 0.01836630f, -0.12687023f, 
    0.03095404f, 0.10980093f, 0.02244053f, -0.11842358f, -0.03025496f, -0.06481732f, 0.01754665f, -0.06243085f, 
    0.01847854f, 0.04406229f, -0.06115167f, -0.04440983f, 0.24848354f, 0.09436482f, -0.09127890f, 0.15881220f, 
    0.01401133f, 0.01928301f, 0.02467030f, -0.03376953f, 0.01162590f, -0.04370490f, -0.20541199f, -0.02520427f, 
    0.13274781f, 0.17563416f, -0.07187958f, -0.13543071f, 0.20577498f, 0.25477755f, 0.04454375f, 0.16413648f, 
    -0.04856316f, -0.01525824f, -0.05130807f, 0.00489930f, 0.07067150f, 0.13632171f, 0.00581516f, 0.25760895f, 
    0.06866685f, 0.01219464f, 0.08973873f, -0.04284954f, -0.00891036f, 0.05272735f, -0.12981433f, 0.05017139f, 
    -0.08455638f, 0.13903284f, -0.01891730f, 0.03917313f, 0.01956658f, -0.09216143f, 0.08165644f, -0.19172631f, 
    0.11548430f, 0.10915254f, 0.04215940f, 0.11871566f, 0.03306337f, -0.23004818f, -0.14507993f, -0.15603180f, 
    -0.01026751f, 0.01015385f, 0.06610917f, 0.13429184f, -0.11049962f, 0.02445330f, -0.07709246f, -0.18625811f, 
    -0.00068874f, 0.04969874f, 0.01646609f, -0.09394373f, -0.02314163f, 0.06743807f, -0.09851865f, -0.08451166f, 
    0.00004530f, -0.01886717f, 0.04877786f, 0.10269494f, 0.19002992f, -0.02970659f, 0.27095383f, 0.15073037f, 
    0.10435360f, 0.13677706f, 0.06849291f, 0.18500736f, 0.01535123f, 0.06722564f, -0.04476916f, -0.00785250f, 
    0.06248886f, 0.14172627f, -0.35175008f, 0.41679540f, -0.21040866f, 0.22000951f, 0.01981443f, -0.18350968f, 
    -0.05354323f, -0.01171034f, -0.10947261f, -0.19380067f, -0.03545332f, 0.05468741f, -0.21881185f, 0.02167428f, 
    0.16500558f, 0.19433244f, -0.00292435f, -0.10850771f, 0.22465421f, -0.02128640f, -0.06200967f, -0.08712318f, 
    0.10549919f, 0.06656452f, 0.02878098f, 0.32257852f, 0.21737330f, 0.00908294f, 0.14194877f, 0.08972232f, 
    0.04368797f, 0.05030151f, 0.02298090f, 0.12111931f, -0.04335087f, -0.10239911f, 0.06796518f, 0.01560406f, 
    -0.04791559f, -0.00289306f, -0.06638645f, -0.03561709f, -0.02863811f, 0.11831579f, 0.05757369f, 0.03104880f, 
    -0.14355721f, -0.02637167f, 0.13437098f, 0.02277010f, -0.08230972f, 0.28177792f, 0.07490044f, -0.05001111f, 
    0.01535898f, 0.03149582f, 0.14405480f, 0.02410816f, 0.14412971f, 0.09280178f, -0.11698192f, 0.15857002f, 
    0.08005023f, 0.08065431f, 0.17694704f, 0.00894277f, -0.07215732f, 0.02951774f, 0.07755813f, 0.09096167f, 
    0.23200828f, -0.08629464f, 0.24327445f, -0.18993279f, 0.05028291f, -0.06603362f, -0.03962271f, 0.16517045f, 
    -0.06038709f, 0.08677508f, 0.02929104f, -0.12545422f, -0.01026052f, 0.25249723f, -0.12171725f, -0.10444161f, 
    -0.12776288f, -0.01997364f, -0.02204409f, 0.08208612f, 0.12161829f, 0.13013153f, -0.13203333f, -0.07590804f, 
    -0.02983063f, -0.02976625f, -0.06064506f, 0.00070517f, -0.02279401f, 0.12746073f, -0.04635030f, -0.03407733f, 
    -0.06960295f, -0.08353573f, 0.01241688f, 0.04115340f, 0.07287603f, 0.02325026f, 0.15514164f, -0.23064893f, 
    -0.03953878f, -0.01246206f, -0.03688236f, 0.04675069f, 0.00636819f, 0.05065797f, 0.11724790f, -0.05814998f, 
    -0.00188820f, 0.10907173f, 0.01671509f, -0.03714595f, -0.13347359f, -0.02051475f, -0.03177603f, -0.10100719f, 
    0.07307138f, 0.04789940f, -0.03045589f, 0.17094049f, 0.02398588f, -0.07669875f, -0.19669335f, 0.01431480f, 
    -0.03622671f, -0.00195553f, -0.01855358f, -0.01593350f, 0.22109975f, 0.13701999f, 0.00749767f, -0.17419957f, 
    0.13299322f, 0.39925373f, -0.00342140f, 0.18645315f, -0.15326408f, -0.05091986f, 0.08817592f, -0.08985803f, 
    0.10947141f, 0.03478292f, -0.13095465f, 0.05691303f, 0.11195938f, 0.18860719f, -0.04254122f, -0.22462258f, 
    0.09537771f, 0.14453930f, 0.14656851f, -0.01204741f, -0.04336876f, -0.00861271f, 0.02532747f, -0.03688905f, 
    0.04621924f, -0.05403094f, -0.10869458f, 0.12706029f, 0.02051836f, 0.03358395f, -0.08239760f, -0.02702401f, 
    0.11340794f, -0.01769433f, -0.14823464f, -0.14688435f, 0.00041730f, 0.18643817f, -0.09878284f, 0.45263216f, 
    -0.08345879f, -0.10274468f, -0.01636506f, -0.30349231f, -0.07787661f, 0.08380718f, -0.08499915f, 0.27670389f, 
    0.05521699f, 0.14552176f, 0.01562778f, -0.12974238f, 0.08279206f, -0.04191811f, -0.01298914f, -0.21060109f, 
    0.00048077f, -0.06573500f, -0.01407492f, 0.06013109f, 0.10472605f, 0.01103099f, -0.15920115f, -0.07679541f, 
    -0.08991595f, -0.06514426f, 0.05316926f, -0.05059497f, -0.03518393f, 0.20740640f, -0.04538751f, -0.14783952f, 
    0.16332108f, -0.07274407f, 0.13074559f, 0.09293928f, 0.05471773f, 0.00011566f, 0.02222301f, 0.02896984f, 
    0.07074448f, 0.06004341f, -0.03920288f, 0.13593948f, -0.02955020f, 0.06002896f, -0.02009398f, -0.04867489f, 
    0.09814219f, 0.00403051f, -0.25048816f, -0.13180789f, -0.09919603f, 0.01359501f, -0.08092545f, 0.01244421f, 
    0.00805718f, -0.06123027f, -0.04038414f, -0.10848875f, -0.05069446f, 0.08187881f, -0.07945477f, 0.05345929f, 
    -0.01190933f, -0.04415564f, -0.17423935f, -0.06226809f, 0.02391481f, 0.14027372f, -0.19152741f, -0.04413480f, 
    -0.18716788f, -0.06341025f, 0.05891515f, 0.09665862f, 0.01439619f, -0.06320827f, 0.05712501f, -0.11037288f, 
    0.05167738f, -0.00580412f, -0.02257123f, 0.07005955f, 0.01353279f, -0.07620102f, -0.04501605f, 0.01568431f, 
    -0.03146402f, 0.06851877f, -0.02904147f, 0.13719551f, -0.12625352f, 0.09668642f, -0.33686200f, -0.09773344f, 
    -0.02506969f, -0.10231821f, 0.18098111f, 0.00434182f, -0.00658820f, 0.18366827f, 0.14826410f, -0.13250740f, 
    0.12790070f, 0.19814689f, -0.07506333f, 0.09331330f, 0.02308892f, 0.01518230f, -0.13953584f, 0.07389735f, 
    0.01732549f, -0.01977338f, -0.03370046f, -0.00820761f, -0.21162638f, 0.18063524f, -0.01445848f, 0.00031568f, 
    -0.05831344f, 0.15072607f, 0.19156525f, -0.12004013f, -0.01526279f, -0.11379519f, 0.14960606f, -0.01890531f, 
    0.11263915f, -0.07535492f, 0.17234981f, 0.21818902f, -0.10322057f, -0.04348855f, 0.01124937f, 0.06850484f, 
    -0.01156638f, 0.01749232f, 0.03138806f, -0.08796200f, 0.11887912f, 0.12290620f, 0.08992630f, -0.12160208f, 
    -0.03347278f, -0.05218123f, 0.02212590f, -0.11026419f, -0.03156748f, -0.08153890f, 0.04951343f, 0.13087690f, 
    -0.06162322f, -0.02577361f, -0.00343819f, 0.01656321f, 0.04837601f, -0.08706413f, 0.13066727f, -0.05716940f, 
    -0.12785298f, -0.08193855f, -0.04486026f, -0.06941105f, 0.11761784f, -0.14999536f, -0.11913482f, 0.06326713f, 
    -0.13458267f, -0.02190943f, -0.00614566f, -0.00926126f, -0.05466501f, -0.04562221f, 0.09029566f, -0.15848808f, 
    -0.08258812f, 0.03941001f, 0.11664295f, -0.03858038f, -0.08025807f, -0.05705192f, -0.03914971f, 0.02661073f, 
    -0.13227627f, -0.10014489f, -0.04738718f, -0.12779686f, -0.08496205f, 0.16967010f, 0.01632350f, 0.01586472f, 
    0.05672794f, -0.17226936f, -0.18399687f, 0.01005985f, -0.18114072f, -0.06974905f, -0.02020827f, -0.09060071f, 
    0.08059101f, 0.20868233f, -0.00049803f, -0.08359253f, 0.03609250f, -0.07204881f, 0.18551321f, -0.01064138f, 
    0.05768360f, 0.09425469f, 0.02206691f, 0.11645240f, -0.06000035f, 0.00071883f, 0.16262262f, -0.12929894f, 
    0.00286723f, -0.01803255f, 0.01759639f, -0.03015160f, -0.00929153f, -0.00559402f, -0.09647808f, -0.02652600f, 
    -0.19582134f, 0.06970166f, 0.12282065f, -0.21508168f, -0.01551134f, 0.00107012f, -0.00382174f, 0.11982550f, 
    -0.14878802f, 0.01777113f, -0.12380289f, -0.03666348f, 0.16178259f, 0.13722096f, 0.03438279f, 0.02372225f, 
    -0.02364099f, -0.16876915f, -0.10660601f, -0.01078159f, -0.10193592f, 0.06186560f, 0.02186437f, -0.10169622f, 
    0.05647412f, 0.08675611f, 0.00738382f, -0.07783253f, 0.09359018f, 0.02485398f, 0.12935175f, 0.03478047f, 
    -0.19540101f, -0.00284414f, -0.03767801f, -0.03741046f, -0.30851084f, 0.11947339f, 0.01763999f, 0.05055972f, 
    -0.03051404f, -0.09868923f, -0.06231218f, -0.01403264f, 0.06104730f, -0.02287051f, -0.10608988f, 0.01134697f, 
    -0.25353873f, -0.05252724f, 0.04429187f, 0.14300118f, 0.05058394f, -0.13506481f, -0.10426348f, 0.11908724f, 
    -0.06966309f, -0.13183619f, 0.07664346f, -0.10863347f, 0.14513658f, -0.06604062f, -0.16352910f, 0.15958692f, 
    0.02295166f, 0.02785929f, 0.14647636f, 0.04397158f, 0.25818512f, 0.12480757f, -0.10594746f, -0.12905522f, 
    0.02378053f, -0.08268634f, 0.10848276f, 0.00671361f, 0.16540755f, -0.07626217f, -0.00465093f, 0.12941912f, 
    -0.06193036f, -0.00917080f, -0.03797343f, -0.00083242f, 0.17424273f, -0.06613009f, 0.08184319f, 0.07517299f, 
    0.02369308f, 0.01383545f, 0.01228069f, 0.02535531f, 0.01054317f, 0.00865582f, 0.07191648f, 0.01731661f, 
    0.04815419f, 0.13794322f, 0.01064903f, -0.03921527f, -0.04684228f, -0.08128057f, -0.01523984f, 0.02483384f, 
    -0.11649812f, -0.12915277f, -0.11956102f, -0.15616146f, -0.10237203f, 0.07392491f, -0.19211763f, -0.03740647f, 
    -0.13254325f, -0.00689303f, -0.03817670f, -0.00845692f, -0.12336701f, -0.07665470f, -0.13386498f, -0.17180273f, 
    0.13235649f, -0.22420377f, 0.07422957f, -0.00218881f, -0.04942808f, -0.11952139f, 0.06575710f, 0.08790929f, 
    0.14389536f, -0.05674262f, -0.10650061f, -0.07930324f, 0.03943702f, -0.31368941f, 0.29390261f, -0.07933135f, 
    0.01139159f, -0.12184265f, 0.04540202f, -0.03306081f, -0.04835200f, -0.05249527f, 0.04860216f, -0.07664717f, 
    -0.15941796f, -0.10200468f, 0.07240488f, -0.02494735f, 0.07327531f, 0.02446186f, 0.02727828f, -0.04699258f, 
    0.00309293f, -0.00298535f, 0.08594315f, 0.00693793f, 0.40409070f, 0.06110947f, -0.11594936f, -0.17743012f, 
    0.06042723f, -0.07407999f, -0.00072974f, -0.16050944f, -0.01305763f, 0.07988872f, 0.00749374f, 0.01265855f, 
    -0.04021273f, -0.02455170f, 0.00043337f, 0.01648090f, 0.02454391f, 0.03310636f, 0.02046611f, -0.04381678f, 
    -0.01791188f, -0.03724913f, -0.03636336f, -0.03294073f, -0.00764173f, -0.04492424f, 0.01969139f, -0.02338884f, 
    0.00857720f, -0.05421456f, 0.02908717f, -0.00615882f, 0.02150161f, -0.03357420f, -0.03076687f, -0.02948284f, 
    -0.01544111f, -0.01793970f, -0.03872419f, -0.02853452f, -0.05425634f, -0.02160600f, 0.01527799f, 0.04410557f, 
    -0.02316142f, -0.04189301f, -0.05225635f, -0.04168881f, 0.04031716f, 0.01026729f, -0.02790189f, -0.00502026f, 
    0.01470979f, 0.00312609f, 0.02016178f, -0.03155008f, -0.00650999f, -0.03878210f, 0.03511531f, 0.02376970f, 
    0.00199644f, -0.04241185f, -0.00062595f, -0.03164908f, -0.04326229f, 0.04025364f, -0.02697897f, 0.01605074f, 
    -0.01765376f, 0.01755500f, -0.04250154f, -0.05473661f, -0.02975488f, 0.02991423f, -0.03774868f, 0.02975917f, 
    -0.00804344f, 0.00629467f, -0.00480308f, 0.02653964f, 0.04115593f, 0.00012835f, 0.03419025f, 0.00041393f, 
    0.02981778f, -0.04727582f, 0.03845004f, -0.04220553f, -0.03470322f, 0.03415786f, 0.01642190f, -0.02760738f, 
    -0.05423518f, -0.03562646f, -0.04518444f, 0.00748283f, -0.01590991f, 0.02660748f, -0.01977843f, 0.00772958f, 
    0.02804091f, -0.04539853f, -0.02894048f, 0.04485919f, -0.03151560f, -0.02403263f, 0.01760071f, 0.00919142f, 
    0.03989950f, 0.01220489f, -0.05626209f, -0.02874251f, -0.01288071f, 0.03466931f, -0.02532284f, -0.03646776f, 
    -0.00327387f, -0.05572085f, 0.00189570f, -0.05305802f, -0.02391791f, 0.01142523f, -0.04782190f, 0.02403308f, 
    0.01474986f, 0.00627790f, -0.01789078f, 0.01051991f, -0.04069611f, 0.02563576f, -0.00474935f, 0.00240608f, 
    0.03469476f, -0.01628066f, -0.05316076f, 0.00083492f, 0.02234675f, 0.01086608f, 0.00352382f, -0.03139164f, 
    -0.00284730f, 0.01610499f, 0.04434904f, -0.01167312f, -0.01212154f, -0.04016819f, -0.04308883f, 0.03829011f, 
    0.02654279f, -0.01284076f, -0.01786168f, -0.02963185f, 0.03606601f, -0.04640143f, 0.01214276f, 0.03685718f, 
    -0.01523758f, -0.04009405f, -0.00541840f, -0.01456024f, 0.01195629f, -0.00345198f, -0.04235397f, 0.02762419f, 
    0.04226745f, 0.02682802f, 0.00200832f, 0.00762622f, -0.00625931f, -0.02515472f, -0.02457221f, -0.02043950f, 
    0.04068173f, 0.04058855f, -0.05235686f, 0.03273880f, -0.03623146f, -0.00399996f, 0.02435214f, -0.05271718f, 
    0.03863630f, 0.03466690f, -0.02454814f, 0.00120439f, 0.03290348f, 0.00369669f, 0.04476033f, 0.03285540f, 
    -0.05619280f, -0.05064715f, -0.00305732f, -0.05336662f, -0.03209373f, 0.00414213f, -0.04963623f, -0.01373338f, 
    0.00932774f, -0.00374347f, -0.01640811f, 0.04295030f, 0.00724397f, 0.04103354f, -0.03868149f, -0.02216181f, 
    0.02367326f, 0.04214671f, -0.02792672f, 0.03110336f, -0.01329797f, 0.00735253f, 0.01911151f, 0.03307555f, 
    0.00877843f, -0.02838911f, -0.02711112f, 0.00472444f, 0.04405500f, 0.01291273f, 0.03632206f, 0.03847238f, 
    -0.00763449f, -0.05010230f, 0.03313106f, -0.05114597f, -0.03335090f, 0.02773564f, 0.03991825f, -0.00233967f, 
    -0.03605732f, -0.04683117f, 0.01134711f, -0.00491368f, -0.05097251f, -0.05671274f, -0.00024197f, 0.03489457f, 
    0.02689749f, 0.03495372f, -0.00225654f, -0.05250360f, -0.02015547f, -0.00881387f, -0.01712380f, 0.00322968f, 
    -0.04053358f, 0.02927746f, -0.04036731f, -0.00812547f, -0.02182765f, 0.00370725f, -0.03026189f, 0.01292358f, 
    -0.01322467f, 0.02519169f, 0.03758344f, 0.01385312f, 0.00717992f, -0.01475960f, -0.01441444f, 0.02005484f, 
    -0.00417878f, -0.04325456f, -0.02116865f, 0.02853845f, -0.05016557f, -0.04193309f, -0.02298042f, -0.02206615f, 
    -0.00643038f, -0.01079599f, 0.04193781f, -0.00496976f, 0.00031356f, 0.00800038f, 0.03348055f, -0.01588268f, 
    0.01838163f, 0.01845695f, 0.04451895f, 0.02202633f, -0.03655684f, -0.04114929f, -0.02216364f, -0.00212159f, 
    -0.00613298f, -0.03756572f, 0.00087045f, -0.04829326f, -0.05678715f, -0.02051166f, -0.01571046f, 0.00055978f, 
    -0.01181985f, -0.02031563f, 0.03645323f, -0.03851826f, -0.02655073f, -0.02429136f, -0.02979512f, -0.04717724f, 
    0.01158785f, 0.02302742f, -0.02836408f, -0.02627275f, -0.03205687f, -0.04168264f, 0.03797483f, -0.05203162f, 
    -0.01878433f, -0.01377492f, 0.02470797f, 0.02657636f, -0.01219273f, -0.04540547f, -0.03273463f, -0.00945394f, 
    0.00770519f, -0.05538863f, -0.05189424f, -0.03601398f, 0.00068363f, -0.03026399f, 0.02351224f, -0.00502368f, 
    0.02145305f, -0.04545566f, 0.00193105f, 0.04385562f, 0.04272377f, -0.02228224f, 0.03189710f, -0.03906053f, 
    0.04333184f, 0.02881777f, 0.04306778f, 0.03322176f, -0.02498567f, 0.03589716f, 0.04228315f, -0.02160931f, 
    -0.00053377f, -0.00058478f, -0.00632124f, 0.02428983f, 0.03639835f, -0.03069369f, -0.05106833f, 0.02860974f, 
    0.00176901f, 0.00116235f, 0.01918094f, 0.00585837f, -0.03574097f, -0.03759668f, -0.01283957f, -0.03525958f, 
    0.03899660f, 0.03863120f, -0.04794212f, -0.01947281f, -0.01460949f, -0.02975378f, -0.05131762f, 0.02387585f, 
    0.01051212f, 0.03291214f, -0.02111285f, -0.03118314f, -0.02935215f, -0.02678461f, 0.00245259f, 0.01260844f, 
    0.00311332f, -0.00082332f, -0.00535744f, -0.05426180f, -0.02528106f, -0.02877460f, -0.00248093f, -0.05170612f, 
    -0.02089322f, -0.01192737f, 0.03471946f, 0.01070958f, 0.02230425f, 0.01815027f, 0.02154797f, -0.01374590f, 
    -0.03385467f, 0.04401886f, 0.02577876f, -0.01412026f, -0.01567893f, -0.00883087f, -0.00496909f, 0.01818263f, 
    0.15856478f, -0.12019630f, 0.05957328f, 0.28681377f, -0.21158683f, -0.04131189f, 0.13066129f, 0.26968470f, 
    0.01032567f, 0.10358935f, 0.09223182f, 0.02189502f, 0.02517715f, 0.10177317f, 0.09122124f, 0.05588629f, 
    0.00283281f, 0.02921203f, -0.07500501f, -0.01458019f, -0.00922878f, -0.13179107f, 0.01032340f, 0.04672757f, 
    0.09064120f, 0.00775216f, 0.15757358f, 0.19949947f, 0.06958544f, 0.03944991f, 0.08511788f, 0.02956043f, 
    0.06265662f, 0.09230609f, 0.15789805f, -0.03419771f, 0.35020730f, 0.04578645f, -0.13380978f, -0.28831694f, 
    0.10203836f, 0.08748427f, 0.22538550f, 0.00913880f, -0.09050192f, -0.05485525f, -0.04122511f, -0.02989933f, 
    -0.21880643f, -0.19345552f, 0.14430849f, -0.18241628f, 0.00301534f, 0.03767715f, 0.05320290f, -0.05431197f, 
    -0.08516430f, 0.02245387f, -0.01347892f, -0.13143177f, 0.10027374f, -0.07789077f, -0.20083895f, -0.38876119f, 
    -0.06071077f, -0.15402909f, -0.11775634f, -0.07331300f, 0.07288540f, 0.09708702f, 0.16730094f, 0.05137299f, 
    0.15901417f, 0.20744537f, 0.01675304f, 0.17997071f, -0.00954866f, -0.01544361f, -0.04499862f, -0.13821636f, 
    0.06473789f, -0.03097532f, 0.01857259f, -0.02710115f, -0.15962844f, -0.09371904f, 0.39837319f, 0.23698948f, 
    -0.10954987f, 0.36481810f, 0.06312358f, -0.05644819f, 0.01276047f, -0.04610607f, 0.23621814f, 0.09920683f, 
    0.15119812f, -0.03311758f, 0.09142801f, 0.08762354f, 0.04711071f, 0.03422251f, -0.07857846f, -0.02222359f, 
    -0.11561485f, 0.04837046f, -0.01746563f, -0.07990462f, -0.01757345f, -0.21342291f, 0.10430738f, -0.28386492f, 
    0.04487181f, -0.09000079f, -0.09611481f, 0.22538936f, -0.01338292f, 0.15246542f, 0.01967134f, 0.07131108f, 
    -0.31268677f, -0.08504257f, 0.09228639f, -0.16723223f, 0.10009022f, -0.00012032f, 0.02015154f, 0.01469872f, 
    -0.07590608f, 0.00883945f, -0.11294584f, -0.18734236f, -0.15934542f, -0.04731007f, 0.00730686f, 0.18063629f, 
    0.04004392f, -0.03157395f, 0.08703251f, 0.17350739f, 0.04515665f, 0.14775087f, 0.17058669f, -0.05739395f, 
    -0.06150723f, -0.02210731f, -0.05889253f, 0.01133030f, 0.04828132f, 0.12547168f, -0.21557228f, 0.02024726f, 
    -0.09672109f, -0.20939003f, -0.24333552f, -0.16357648f, -0.20662150f, 0.22592191f, -0.13184035f, 0.03264584f, 
    -0.05993299f, -0.23566860f, -0.13194434f, -0.08079135f, -0.13509928f, -0.02871367f, -0.10639939f, -0.08104716f, 
    0.17367630f, -0.04264902f, 0.02646108f, 0.15419972f, 0.09815811f, 0.12184588f, -0.15467146f, -0.14224486f, 
    -0.19214928f, -0.12218145f, -0.11491955f, -0.17425428f, -0.06551484f, -0.19807376f, 0.00755617f, 0.00351300f, 
    -0.06544345f, -0.06303187f, 0.30854061f, 0.00598094f, -0.07020900f, 0.00768680f, -0.04491971f, 0.03933981f, 
    0.04607875f, 0.11707123f, 0.17372940f, 0.06881671f, -0.07524642f, 0.18977378f, -0.10745231f, 0.04775526f, 
    0.13379858f, 0.01034182f, 0.10858032f, 0.11309076f, -0.05672085f, -0.12479335f, -0.27336958f, 0.06281386f, 
    -0.07683612f, -0.07800881f, -0.16138437f, 0.06636003f, 0.01862478f, 0.08091462f, -0.00316731f, 0.01892727f, 
    0.03893323f, -0.07314313f, 0.06283800f, -0.05165928f, -0.19772102f, -0.00994141f, 0.03318762f, 0.08650487f, 
    -0.05570439f, -0.09103093f, -0.15411493f, -0.09329517f, 0.25095338f, 0.04171341f, 0.13127518f, 0.05701019f, 
    0.05606472f, 0.10415964f, 0.00831056f, -0.06248892f, 0.04375357f, -0.04108140f, 0.08614738f, 0.02081373f, 
    0.19918986f, 0.01936203f, -0.00445060f, 0.04415036f, 0.16288199f, 0.12113077f, 0.03932118f, 0.07719425f, 
    -0.15801258f, -0.08835862f, -0.10217760f, 0.00299514f, 0.08385441f, -0.24160258f, -0.16413608f, -0.35919270f, 
    0.00216638f, 0.00822721f, 0.01134132f, 0.15908851f, -0.03917199f, 0.02982427f, 0.05689941f, 0.17393148f, 
    0.20825894f, 0.30025244f, 0.14918563f, 0.04992583f, 0.05276188f, 0.01811425f, 0.08822799f, -0.09116180f, 
    0.05697569f, -0.08781527f, 0.02713508f, -0.03620075f, -0.07949006f, 0.28649089f, -0.05152033f, 0.10904603f, 
    0.02014804f, 0.26304638f, -0.18960011f, -0.02483663f, 0.07187851f, -0.02103596f, 0.04274678f, 0.00508068f, 
    0.12553625f, 0.08685675f, 0.06885077f, -0.10596547f, -0.00233722f, 0.06284402f, 0.04265837f, -0.01457352f, 
    -0.11308883f, -0.03117727f, -0.11750436f, -0.10399868f, 0.39830935f, 0.00662589f, -0.04246945f, 0.17473675f, 
    -0.04540497f, 0.04060288f, 0.04981082f, 0.01313772f, 0.02153619f, -0.00224700f, 0.02466219f, 0.05616189f, 
    0.16106282f, 0.11490335f, -0.00266964f, 0.11774646f, 0.03814808f, -0.01051605f, -0.03629990f, 0.01280161f, 
    -0.13110417f, -0.07117675f, -0.16624814f, -0.12803736f, 0.00888047f, 0.05488976f, 0.03486600f, -0.16136436f, 
    -0.09864391f, -0.19041277f, -0.17576565f, -0.05321365f, -0.14952350f, 0.01206578f, -0.22291523f, -0.07781424f, 
    0.05693813f, -0.03179046f, 0.04577030f, 0.23419991f, 0.04352175f, -0.09964291f, -0.07969824f, 0.04940278f, 
    -0.19142458f, -0.01332511f, -0.02737223f, -0.04141892f, -0.06605720f, 0.00440201f, -0.13875780f, 0.16984265f, 
    -0.03161583f, -0.08425129f, 0.00332924f, 0.04714116f, -0.01943158f, -0.06775176f, 0.04708939f, -0.13233112f, 
    0.10473201f, 0.01082287f, -0.02595735f, 0.10455737f, -0.01343286f, 0.00759035f, 0.02404091f, 0.08917366f, 
    0.06340418f, 0.23863220f, 0.19223942f, 0.25480035f, 0.02929993f, 0.04200925f, 0.14677490f, -0.04119450f, 
    0.03683097f, -0.05213553f, 0.21756883f, 0.07086091f, 0.01904486f, 0.02833048f, -0.03249142f, 0.06782972f, 
    -0.03537927f, -0.09263550f, 0.10012876f, -0.02351866f, 0.22575475f, 0.11169752f, -0.00747822f, 0.00124800f, 
    0.04822227f, -0.05977634f, -0.07582291f, 0.06379388f, -0.06153260f, 0.11736570f, -0.08752452f, 0.01343766f, 
    -0.00337422f, -0.02528035f, 0.00706279f, -0.07435994f, 0.06052486f, 0.09577112f, 0.18862207f, -0.07339286f, 
    -0.33542764f, 0.03966904f, 0.12787727f, -0.33270249f, -0.08834641f, -0.02964055f, -0.11289383f, 0.09498765f, 
    -0.05205731f, 0.07860483f, -0.06917012f, 0.18406624f, -0.23924772f, 0.22725020f, -0.01862349f, -0.07587404f, 
    -0.25994018f, -0.11502426f, -0.18706468f, -0.13312361f, -0.04039409f, 0.05463143f, -0.00915007f, 0.04805148f, 
    0.09103236f, -0.17190792f, -0.36167467f, 0.24404000f, 0.04075451f, 0.06623620f, -0.03350924f, -0.03975819f, 
    0.12084008f, -0.05980205f, -0.07748137f, 0.01034138f, 0.21150427f, 0.05531716f, -0.03009188f, 0.25592718f, 
    0.13396069f, 0.07516100f, 0.06879879f, 0.09477256f, -0.06903370f, 0.00269326f, -0.03330346f, -0.04701611f, 
    -0.12623754f, 0.01033745f, -0.19353503f, -0.04478912f, -0.05010802f, 0.03438283f, 0.01772947f, 0.07562398f, 
    -0.16568978f, 0.01981491f, 0.01277438f, -0.10417666f, 0.72331679f, -0.04601849f, -0.07390793f, -0.12134375f, 
    0.02131113f, -0.19651869f, 0.07056399f, -0.01657024f, -0.14591733f, 0.05113993f, 0.07788467f, 0.04394147f, 
    -0.04147996f, 0.16295689f, 0.01372273f, -0.13108562f, -0.12963654f, 0.01572311f, 0.03418800f, 0.02443656f, 
    0.02702729f, 0.09507760f, 0.02317961f, -0.02700558f, 0.19288553f, 0.08451037f, 0.00991481f, 0.15538235f, 
    -0.02954103f, 0.27415553f, 0.09382048f, 0.05194315f, 0.00770834f, 0.03200891f, 0.02386606f, 0.01841894f, 
    0.04341205f, 0.37720698f, -0.30177268f, -0.03108016f, 0.04999440f, 0.19308057f, -0.01473425f, 0.13657244f, 
    -0.01848579f, -0.03070776f, 0.05285475f, 0.05891775f, -0.00701559f, 0.00383102f, -0.21480560f, 0.07392523f, 
    0.22008026f, -0.02945833f, -0.04642384f, -0.04466890f, -0.04858213f, -0.12144621f, -0.08047765f, 0.14622149f, 
    0.07958324f, 0.18193309f, -0.01247795f, 0.06148974f, 0.05671687f, -0.17658269f, 0.02792189f, -0.13425267f, 
    -0.01948559f, 0.08290177f, 0.09968834f, 0.02274678f, 0.04130863f, 0.10597128f, -0.06708872f, -0.09126966f, 
    -0.00568574f, 0.06334153f, 0.13336278f, 0.15327151f, 0.02055483f, 0.01670234f, 0.03758708f, -0.08075286f, 
    -0.10641664f, 0.13349414f, -0.20143990f, 0.11238934f, -0.03517936f, 0.00649956f, -0.08195528f, -0.00651555f, 
    -0.07097284f, 0.03866986f, 0.05435731f, 0.08625777f, 0.15311822f, -0.05981839f, 0.18920736f, -0.09490550f, 
    0.21135800f, 0.27596945f, -0.01910065f, 0.19289935f, -0.15073350f, -0.00521519f, 0.03631285f, -0.03953196f, 
    -0.02905967f, 0.09387334f, -0.22123601f, 0.37177867f, 0.03894411f, -0.13535070f, 0.09324750f, -0.12140070f, 
    -0.01017026f, 0.00235415f, 0.02440790f, -0.18869896f, 0.16044410f, 0.09042393f, 0.21159162f, 0.20813620f, 
    0.29250261f, 0.16278280f, 0.03536650f, 0.03823366f, 0.03814079f, 0.17206661f, -0.02342109f, -0.00944903f, 
    0.28345540f, -0.07824422f, 0.33972737f, 0.34754318f, 0.10739862f, 0.13475011f, 0.15527321f, 0.09669995f, 
    -0.10656539f, 0.06751309f, 0.05010139f, 0.17933899f, -0.12865810f, -0.10481685f, 0.02550264f, 0.01835902f, 
    -0.22956438f, -0.20445262f, -0.07701437f, -0.06233622f, 0.08190670f, 0.14642000f, -0.06741376f, 0.04767471f, 
    -0.24541159f, 0.07256828f, 0.07845616f, 0.04062946f, -0.20618147f, -0.22926345f, -0.04810837f, 0.00477574f, 
    -0.13962193f, 0.21106601f, 0.04141665f, -0.01239901f, 0.26558828f, 0.14980049f, 0.03780533f, 0.40707070f, 
    0.12775174f, 0.00835712f, 0.05392423f, 0.11985619f, -0.01049264f, 0.04961553f, -0.06231178f, -0.02346633f, 
    -0.34554067f, -0.05828866f, 0.08629295f, -0.45725203f, -0.17704040f, 0.06098539f, 0.05611682f, 0.11661259f, 
    -0.04346296f, -0.04323256f, -0.00333147f, -0.11958323f, -0.05189553f, 0.32674491f, -0.11925668f, 0.04877271f, 
    -0.19223635f, -0.01531778f, 0.00881535f, 0.19731869f, -0.15685801f, 0.20512843f, 0.02842423f, 0.08544099f, 
    0.05814648f, -0.12313470f, 0.10984888f, 0.20446286f, -0.15458931f, 0.03429370f, 0.16850670f, 0.03064090f, 
    -0.11040786f, -0.01091437f, 0.08055779f, -0.07485385f, -0.28844327f, 0.21412629f, 0.02527167f, -0.15772323f, 
    -0.16593371f, 0.02035472f, -0.03396738f, 0.08804034f, 0.02025682f, 0.14846545f, 0.03750257f, 0.02278783f, 
    0.02748693f, 0.10239633f, -0.01981993f, 0.09690379f, -0.06943844f, -0.09745494f, -0.00308441f, -0.04984231f, 
    -0.07340927f, 0.03845851f, 0.05129349f, 0.14879557f, -0.03494259f, 0.12004759f, -0.01566425f, 0.14564216f, 
    -0.04176267f, 0.04585884f, 0.10365836f, 0.06875414f, 0.16966094f, 0.05861550f, 0.01008369f, -0.14702401f, 
    0.26019031f, 0.52149969f, -0.04191989f, 0.23815984f, 0.00630162f, 0.07483011f, -0.00869240f, 0.03032263f, 
    0.06894020f, 0.09370219f, 0.04446859f, 0.06145774f, -0.17961498f, 0.43554500f, -0.09769918f, -0.13704230f, 
    0.12371372f, 0.10118791f, 0.10048250f, -0.00787973f, -0.13802876f, -0.00342229f, -0.06379440f, 0.04709043f, 
    0.24727596f, 0.00076073f, 0.06871487f, 0.24911462f, 0.09581497f, 0.04472250f, 0.00431119f, 0.02132252f, 
    -0.05138739f, 0.01453510f, 0.03909605f, 0.06141023f, 0.08551022f, -0.01978414f, -0.02625071f, 0.19416429f, 
    -0.14731200f, -0.10161247f, 0.03497543f, -0.15904886f, 0.00229556f, 0.02540091f, 0.06510984f, 0.09065820f, 
    -0.01180323f, -0.04733227f, -0.00772692f, 0.01019990f, -0.00763376f, -0.02608607f, 0.00352907f, 0.03362899f, 
    0.03742851f, 0.00941668f, 0.01758977f, 0.04131306f, 0.03547719f, 0.02994864f, -0.03872934f, -0.03437492f, 
    -0.02813337f, -0.02590369f, 0.01043912f, 0.02945350f, -0.00672835f, -0.03103860f, -0.02641925f, -0.05554307f, 
    0.03104533f, -0.04112506f, -0.00799405f, -0.01615409f, 0.01514309f, 0.02026731f, 0.03318009f, 0.04031307f, 
    -0.04089919f, 0.01349731f, -0.02596572f, -0.01544245f, -0.05790054f, -0.05698998f, -0.05538896f, -0.05213429f, 
    -0.05271882f, 0.00200737f, 0.02831605f, 0.01333224f, -0.03263041f, 0.04075817f, 0.00184639f, -0.03739956f, 
    -0.01517089f, -0.02990454f, 0.00172157f, -0.03698262f, -0.00546146f, -0.02771806f, 0.03525873f, -0.01142567f, 
    -0.01713862f, -0.03868556f, 0.02115209f, 0.00142621f, -0.01485226f, 0.01263442f, -0.00199627f, -0.04253247f, 
    0.00780466f, -0.04834694f, 0.01388217f, -0.00660839f, -0.05641736f, -0.05331356f, 0.01827991f, -0.05153295f, 
    0.01355091f, -0.02399617f, -0.05699549f, 0.02246984f, 0.01278279f, -0.04913040f, -0.01034533f, 0.00411548f, 
    -0.04474033f, -0.01091739f, -0.04630223f, -0.02918633f, 0.03394017f, 0.02177142f, 0.03235633f, -0.01655501f, 
    0.02426491f, 0.03651774f, -0.01573975f, 0.02238463f, -0.03248237f, -0.03221272f, -0.03197496f, 0.02008839f, 
    0.00953137f, -0.03500446f, -0.04249501f, -0.04044365f, -0.01583840f, -0.05915182f, -0.00525243f, 0.01868306f, 
    -0.03282737f, -0.03655628f, 0.00850533f, -0.00243647f, -0.04434698f, 0.00185257f, 0.00834264f, 0.00651378f, 
    -0.02972945f, -0.04825348f, -0.03256741f, 0.02539037f, 0.00886574f, -0.05893895f, -0.01019369f, -0.02130155f, 
    -0.00180633f, -0.04290293f, -0.01814165f, 0.03354602f, 0.01624073f, 0.02297790f, -0.02254803f, 0.01956414f, 
    -0.03550687f, 0.01131256f, -0.03984097f, 0.04362122f, 0.01057873f, 0.03504813f, -0.02876360f, 0.00759546f, 
    -0.03727219f, 0.03752583f, -0.02296856f, 0.01210354f, 0.02956975f, -0.01401897f, -0.04645983f, 0.01919993f, 
    -0.01141285f, -0.04487079f, -0.04402218f, -0.01118392f, 0.01213394f, 0.00706463f, -0.02848659f, -0.05557727f, 
    -0.00813493f, 0.02081526f, 0.02399141f, -0.02025322f, -0.00421264f, -0.01964219f, -0.03461843f, -0.04334676f, 
    0.01383650f, 0.02994583f, -0.03538843f, 0.01333854f, 0.04018085f, 0.02061487f, -0.02347376f, -0.03037803f, 
    -0.02618565f, -0.00752397f, -0.03984338f, -0.05533860f, 0.03984230f, -0.03172597f, -0.02266317f, 0.02714740f, 
    0.02394501f, -0.02286643f, 0.03206734f, 0.00249905f, -0.00333020f, -0.01285555f, 0.04507895f, -0.02563542f, 
    -0.02215575f, 0.01894409f, 0.03774114f, -0.04512810f, 0.04088724f, 0.03372279f, -0.03058544f, -0.03161889f, 
    -0.04400627f, 0.03142846f, -0.05817407f, -0.01552362f, 0.00440139f, -0.01235907f, -0.05721211f, 0.00129723f, 
    -0.01965755f, 0.02806865f, 0.00897756f, 0.01228532f, -0.01435740f, -0.01277521f, 0.02046315f, 0.01524937f, 
    -0.05032158f, -0.01812111f, -0.02799352f, 0.04146344f, -0.01477000f, -0.00176259f, -0.02636481f, -0.00157485f, 
    -0.02396616f, -0.00664097f, -0.01727505f, 0.01005306f, 0.03979208f, -0.03800522f, -0.03366058f, -0.02052201f, 
    -0.02141200f, -0.01593148f, 0.04340865f, 0.01641927f, 0.03177927f, 0.00566099f, -0.01250133f, -0.01569658f, 
    0.02110589f, -0.00467967f, 0.00587504f, 0.03422716f, -0.02381846f, 0.01933071f, -0.01755038f, -0.02952604f, 
    0.00783442f, -0.05568904f, 0.01640566f, 0.03703548f, 0.00374887f, -0.05785393f, -0.00556706f, 0.00324658f, 
    -0.00267017f, 0.01018538f, 0.02448365f, -0.01947734f, 0.02038693f, -0.06065777f, 0.00143530f, 0.03519725f, 
    -0.05230268f, -0.03154257f, 0.01721997f, -0.04524177f, -0.00893094f, -0.05316996f, 0.02248515f, -0.03100744f, 
    0.00073105f, 0.01808943f, -0.00321600f, -0.02680349f, -0.04577002f, -0.02571963f, 0.01910060f, -0.00284994f, 
    0.00647496f, 0.03913220f, 0.01279816f, 0.01395241f, 0.01731529f, -0.01204800f, -0.00731918f, -0.01387669f, 
    0.00864748f, 0.00858417f, 0.00667565f, -0.00674775f, 0.01126666f, -0.00927937f, -0.00631610f, -0.00109263f, 
    -0.02214333f, -0.01913171f, -0.03918839f, -0.02072143f, 0.03182672f, 0.00767891f, 0.03512535f, 0.03389582f, 
    -0.00832597f, -0.00390312f, -0.05969731f, -0.02185434f, -0.02450853f, -0.03169574f, -0.04354024f, 0.02897494f, 
    -0.05003122f, -0.04583316f, -0.05522182f, 0.03377143f, 0.02814365f, -0.03220247f, -0.05842348f, 0.02925084f, 
    0.02509062f, 0.01906114f, 0.02492543f, 0.02322042f, -0.05933370f, 0.02022614f, -0.01796682f, -0.04201333f, 
    -0.01243563f, -0.03522914f, 0.01005894f, 0.01388461f, -0.03898772f, -0.00989328f, -0.05502297f, 0.02420955f, 
    -0.02554964f, -0.05229027f, -0.01086496f, 0.00033702f, -0.02719955f, 0.02111612f, -0.01905681f, -0.05182278f, 
    0.02935529f, -0.04850622f, 0.02155177f, -0.00606325f, -0.00432929f, -0.02534293f, -0.02474754f, -0.04781300f, 
    0.03494033f, -0.03003366f, -0.05070984f, -0.03101394f, 0.03387589f, 0.03933755f, 0.02507018f, -0.05122590f, 
    -0.01309771f, -0.02053298f, 0.00420856f, -0.04609746f, -0.03143254f, -0.01853754f, -0.03288383f, -0.04315959f, 
    0.03712416f, -0.00976597f, -0.01902712f, 0.00330598f, -0.02649238f, -0.03853589f, 0.01395779f, 0.00735384f, 
    0.01940616f, -0.01420404f, -0.03621092f, -0.05383953f, 0.02466976f, 0.03821087f, 0.00064973f, 0.02229906f, 
    -0.01692339f, 0.00590851f, -0.03892097f, -0.05424071f, 0.02186069f, 0.02761406f, 0.00076943f, -0.01908562f, 
    -0.15747976f, -0.34305328f, 0.04365912f, 0.07161806f, 0.07144178f, -0.03553586f, -0.01575023f, -0.16239324f, 
    0.14449550f, -0.07795174f, 0.12344170f, 0.03536235f, -0.19096459f, 0.03834614f, -0.08255117f, 0.14514062f, 
    0.02377977f, -0.07316973f, 0.08361071f, -0.01833872f, 0.17515829f, -0.10625422f, 0.02619109f, 0.03944309f, 
    0.21576533f, 0.11811098f, 0.01279139f, -0.03155907f, -0.00178747f, -0.06843664f, 0.02494060f, 0.08601418f, 
    -0.09620239f, 0.01858635f, -0.02064730f, -0.06914994f, 0.24315281f, 0.27574489f, 0.16876589f, 0.16273789f, 
    -0.13010903f, 0.03673442f, -0.08365124f, 0.11630154f, 0.01879438f, 0.02144185f, -0.05330987f, -0.00055883f, 
    0.08891143f, -0.10269863f, 0.01023642f, 0.15113544f, 0.06197453f, 0.04988233f, -0.07304844f, 0.12499802f, 
    0.09244829f, -0.13033830f, -0.00198942f, -0.11384549f, -0.61174387f, 0.15429457f, -0.15343708f, 0.13483796f, 
    -0.05119632f, 0.08343189f, 0.22379871f, -0.07792024f, -0.10519484f, -0.03521932f, 0.04434739f, 0.00316179f, 
    -0.19060443f, -0.07022871f, -0.08030614f, 0.00436883f, 0.04509807f, -0.06152781f, 0.08444873f, 0.05092819f, 
    0.21843752f, 0.06108117f, 0.04774599f, 0.17815657f, -0.35846463f, -0.03502535f, -0.05223193f, -0.06347208f, 
    0.05710747f, 0.08059276f, 0.20189893f, -0.20991665f, -0.00548337f, 0.15850978f, 0.06803006f, 0.20756111f, 
    0.04920737f, 0.05211206f, 0.00013803f, 0.02590524f, -0.00275317f, -0.06247622f, -0.04171761f, 0.20028347f, 
    0.17770106f, -0.19548082f, 0.24676484f, 0.04226232f, 0.13095434f, -0.07196653f, 0.30519962f, -0.13064958f, 
    -0.04800078f, 0.16904913f, -0.01630114f, 0.12798496f, 0.16028850f, -0.02492597f, 0.01198266f, -0.04826274f, 
    -0.05968773f, -0.09828573f, 0.21943150f, 0.27329448f, -0.03153374f, -0.14099570f, -0.02277960f, -0.21884356f, 
    -0.04985587f, -0.02798821f, -0.09212988f, -0.09378418f, 0.01309143f, -0.17406835f, -0.05862422f, -0.05295218f, 
    0.01137808f, 0.04229566f, -0.03185413f, -0.17390428f, 0.03264447f, 0.02918418f, -0.00187512f, 0.03712225f, 
    -0.05010768f, -0.04557201f, -0.03432114f, 0.09586520f, 0.20448440f, -0.06632464f, 0.06409105f, 0.07947103f, 
    -0.05709886f, -0.05309584f, -0.13335353f, 0.09461636f, -0.54461980f, 0.14522390f, -0.17744675f, 0.06799199f, 
    0.02030355f, 0.03130298f, 0.07577520f, 0.22137833f, 0.12214332f, 0.07518822f, -0.04562307f, 0.05227540f, 
    0.07018477f, -0.01735264f, 0.02969667f, 0.01174557f, 0.13697761f, 0.05896955f, -0.09928102f, 0.04705818f, 
    -0.01795408f, 0.03106190f, 0.03560643f, -0.00217018f, 0.04088936f, -0.21464893f, 0.00964361f, -0.06137629f, 
    0.19931403f, -0.21597406f, -0.13532475f, -0.29284093f, 0.03685629f, 0.08694653f, 0.05232776f, 0.06775369f, 
    0.01731944f, -0.01418837f, 0.13546948f, 0.14216805f, 0.05783739f, 0.14792027f, 0.02922706f, -0.18252638f, 
    -0.12382998f, 0.00060282f, 0.09585512f, 0.08402201f, -0.39493912f, 0.11684277f, -0.06901839f, 0.00799494f, 
    -0.17637944f, 0.06489888f, -0.00684156f, 0.13745755f, -0.25172147f, -0.02027910f, 0.01056084f, 0.04007537f, 
    -0.00949845f, -0.11258534f, 0.19908510f, -0.32481894f, -0.00120545f, 0.02586114f, -0.22139540f, 0.16086471f, 
    -0.11165047f, 0.04246434f, -0.07399084f, -0.07689224f, 0.14545301f, -0.02870872f, 0.11790732f, -0.03017129f, 
    -0.03083283f, 0.02393292f, 0.02328729f, 0.01991343f, 0.03082712f, 0.06960880f, -0.05349344f, 0.00573291f, 
    0.09973812f, 0.00640211f, 0.03791956f, 0.08300281f, -0.14409375f, 0.04070702f, 0.02243246f, 0.01681592f, 
    -0.03165888f, 0.04538825f, -0.12177636f, -0.00564643f, -0.19076191f, -0.15342511f, -0.04195881f, 0.07662095f, 
    0.01408963f, 0.04684610f, 0.08905613f, -0.09447215f, -0.08732950f, 0.01629599f, -0.00910655f, -0.02526332f, 
    0.19636975f, 0.23760429f, -0.19263652f, 0.03618715f, -0.04769022f, -0.04459406f, 0.18713318f, 0.02257683f, 
    -0.01546554f, 0.09466319f, 0.04529452f, -0.25579810f, -0.08165552f, 0.08815430f, -0.08199718f, 0.22010992f, 
    0.04066525f, 0.19137852f, -0.06854371f, 0.17658184f, 0.14537187f, -0.03046405f, 0.26634571f, 0.06651521f, 
    0.13322082f, 0.01925456f, 0.02321873f, 0.08909664f, 0.11837012f, -0.04999397f, -0.02776070f, 0.19950394f, 
    0.11530659f, 0.01015830f, 0.16113482f, -0.02826530f, 0.49169064f, -0.09136198f, 0.02665619f, 0.12089073f, 
    -0.01417461f, 0.00132650f, 0.04639376f, 0.14524680f, -0.05944517f, 0.03327719f, -0.09320537f, -0.00632457f, 
    -0.00503573f, 0.06720103f, -0.13085532f, 0.01963217f, -0.06140287f, -0.09748394f, 0.07421140f, 0.07829089f, 
    -0.04847945f, 0.00886448f, -0.08529697f, -0.07071821f, -0.52819467f, -0.10947514f, -0.12208104f, 0.02702647f, 
    0.07517920f, 0.04780409f, -0.05505549f, 0.09627570f, 0.10420310f, -0.08608447f, -0.02278551f, 0.12463405f, 
    -0.20202725f, -0.10963582f, -0.07582975f, 0.27251175f, -0.01311515f, 0.01360564f, 0.07717819f, 0.04931924f, 
    0.04353347f, 0.09719757f, 0.06958708f, -0.02382874f, -0.05865527f, -0.08504201f, 0.00780083f, 0.01852898f, 
    0.10983640f, -0.15388894f, 0.11292190f, -0.13373575f, 0.10150094f, -0.00595899f, -0.04201958f, -0.03892916f, 
    -0.11293088f, -0.19310568f, 0.04727784f, -0.08633850f, -0.08995340f, -0.04345500f, -0.02324372f, 0.17302464f, 
    0.01821181f, 0.07817458f, 0.20656760f, 0.09792195f, 0.07688421f, 0.26761708f, -0.05708627f, 0.01327250f, 
    -0.09669632f, 0.06860435f, 0.01988614f, -0.07976922f, 0.02941800f, 0.07588992f, 0.07892467f, 0.02015049f, 
    -0.03758196f, -0.11061884f, -0.12556595f, 0.16774599f, -0.07689108f, 0.17180562f, 0.10758241f, -0.01800258f, 
    -0.06818987f, -0.09030508f, 0.02227808f, 0.03260648f, -0.23849329f, -0.20571105f, -0.08366966f, 0.08774993f, 
    0.05356855f, -0.09579024f, -0.09680571f, 0.10820122f, -0.02770009f, -0.10407338f, -0.05258886f, 0.14833137f, 
    0.11871736f, -0.11041064f, -0.19261239f, 0.21954612f, 0.05082643f, -0.00304717f, -0.04234858f, 0.00673454f, 
    0.03163208f, 0.15563570f, 0.02609667f, -0.13881090f, -0.13653757f, -0.49815279f, -0.08201665f, 0.21472502f, 
    -0.12374347f, -0.00810603f, 0.13919516f, 0.08010987f, 0.04032052f, -0.09210825f, 0.06784326f, -0.01204447f, 
    0.09985308f, 0.27241889f, 0.00971431f, 0.00618198f, 0.03530053f, -0.02181849f, -0.08030001f, 0.10233545f, 
    0.04658963f, 0.11659118f, 0.08012369f, -0.00122239f, -0.47731924f, -0.17907231f, 0.22365542f, 0.07605970f, 
    0.09902041f, 0.05750741f, -0.12117354f, -0.14283098f, 0.01558270f, 0.15786014f, 0.10352013f, 0.01731887f, 
    -0.03780869f, -0.16243444f, 0.10128324f, -0.00138452f, -0.04946605f, -0.05615519f, -0.07861394f, 0.00883284f, 
    0.17162104f, -0.11153135f, 0.11037792f, 0.04415205f, -0.40342730f, -0.02685114f, 0.32378146f, 0.05183339f, 
    -0.13709545f, 0.04914882f, -0.04965527f, 0.10516024f, 0.06275375f, -0.08464421f, 0.04081189f, 0.00927636f, 
    0.07539556f, -0.21274640f, -0.04438282f, -0.09480271f, 0.07992949f, -0.23210801f, -0.00423780f, 0.06217336f, 
    -0.10791654f, -0.03180102f, 0.22133847f, 0.08302166f, 0.00043967f, -0.03203956f, -0.05829458f, -0.02205371f, 
    0.01908125f, -0.26621363f, 0.04808257f, -0.07859542f, -0.09441575f, -0.04855486f, 0.00697240f, -0.06997599f, 
    -0.30394301f, -0.21259660f, 0.07132499f, -0.10809942f, 0.17669894f, 0.07353773f, 0.10491902f, -0.15778278f, 
    -0.00598809f, -0.03058518f, -0.11590697f, 0.04971477f, -0.13322328f, 0.05526495f, 0.08042093f, 0.16700813f, 
    -0.08015399f, 0.06666911f, 0.10343955f, -0.11259600f, -0.02345902f, 0.08397399f, 0.09997135f, -0.05437281f, 
    -0.07128005f, -0.15116829f, -0.03216847f, -0.00992285f, -0.02700075f, -0.10529771f, -0.15155579f, -0.03644073f, 
    -0.01506400f, -0.08750974f, -0.01712881f, -0.01220431f, -0.07424544f, -0.10008509f, 0.10170075f, 0.00133238f, 
    0.03406577f, -0.06250347f, -0.17413172f, 0.11471719f, -0.01305295f, 0.04151754f, 0.06309558f, -0.13908473f, 
    -0.01033895f, -0.26125976f, -0.10995112f, -0.15355594f, 0.12520212f, -0.03928105f, 0.03698578f, -0.09896694f, 
    -0.03378036f, -0.12617780f, -0.03237266f, 0.03610347f, 0.07663412f, -0.15065770f, 0.07772034f, 0.00046078f, 
    0.00701171f, 0.06661586f, 0.12550819f, -0.16886622f, -0.01123496f, -0.01360456f, -0.03566891f, -0.00749484f, 
    -0.15686049f, -0.00096774f, -0.00140398f, 0.03155212f, 0.02601031f, 0.19905852f, -0.10837511f, -0.13657379f, 
    0.16033858f, -0.03777466f, -0.08507068f, -0.06626566f, -0.20516387f, 0.10898760f, -0.14138786f, -0.17407583f, 
    -0.12929809f, -0.00874204f, -0.02571904f, 0.05810742f, -0.03687030f, -0.08192452f, -0.00596253f, -0.07636883f, 
    -0.07691031f, 0.25007755f, -0.20848942f, -0.03305141f, 0.05726380f, -0.12154572f, -0.09906641f, -0.03636783f, 
    0.07922354f, 0.03971347f, 0.07236165f, -0.05967041f, -0.14857467f, -0.27949041f, -0.13979408f, 0.01100572f, 
    0.01112562f, 0.06424598f, 0.03389449f, -0.02169959f, 0.04102415f, -0.07818688f, -0.13873163f, 0.00641411f, 
    -0.13848320f, -0.17962939f, -0.06119210f, -0.14391340f, 0.01043543f, 0.09222851f, -0.06839354f, -0.10606529f, 
    0.18592232f, -0.13080172f, 0.01692509f, -0.03272515f, -0.17542291f, -0.02182265f, 0.06324349f, -0.07580235f, 
    0.02415114f, -0.09159330f, 0.09760921f, -0.19166183f, -0.07446538f, 0.06972977f, 0.02905983f, 0.22890197f, 
    0.48164690f, -0.15066037f, -0.29498434f, 0.22397935f, -0.12958540f, 0.06439895f, -0.14526719f, 0.06552725f, 
    0.04155402f, 0.07333481f, -0.04551672f, 0.00508867f, -0.19822223f, -0.07591915f, 0.19901799f, -0.09533305f, 
    0.02148022f, 0.06870979f, -0.11210044f, 0.03237112f, -0.04811625f, -0.07562211f, 0.07174974f, -0.02952192f, 
    0.04772972f, 0.19107622f, -0.22385514f, -0.24267195f, -0.09228555f, 0.17022669f, 0.04431287f, 0.03397193f, 
    0.08214132f, 0.04352451f, 0.02578392f, 0.00374387f, 0.20736569f, -0.12918897f, -0.17912546f, -0.02821856f, 
    -0.06905957f, -0.00471423f, 0.08903036f, 0.07551263f, 0.01007733f, 0.02858184f, -0.05939142f, -0.01253898f, 
    -0.05168154f, -0.28122610f, -0.05679270f, -0.12552528f, -0.02357743f, 0.06383499f, -0.10231425f, -0.12307526f, 
    0.08452500f, 0.00987133f, -0.13108949f, 0.06470833f, -0.09860888f, 0.06927795f, 0.18438353f, 0.05084536f, 
    -0.00692400f, -0.25000277f, -0.13135464f, -0.12759453f, 0.04350525f, 0.02730105f, 0.11394367f, 0.06435473f, 
    -0.25688270f, 0.11567464f, 0.14156519f, -0.17573963f, 0.03111319f, -0.07805841f, 0.02914477f, -0.07639210f, 
    -0.10477567f, 0.08089950f, 0.08744572f, 0.00313731f, -0.07349003f, -0.24229780f, -0.01126778f, -0.00153868f, 
    0.24434532f, 0.06553178f, -0.05933660f, -0.03420759f, 0.05229171f, -0.17934716f, -0.10438213f, 0.01631558f, 
    -0.07945725f, -0.00844663f, -0.12431093f, -0.06926492f, 0.02045660f, 0.01008304f, 0.13011117f, 0.12776704f, 
    0.00949378f, -0.06808058f, 0.03145112f, 0.00963223f, -0.07820579f, -0.14040117f, -0.12559682f, 0.11967895f, 
    0.01978854f, 0.09018221f, 0.10425397f, -0.04121657f, -0.06944285f, -0.04870947f, -0.07177418f, 0.24633767f, 
    -0.10064391f, -0.08845248f, -0.03099014f, 0.09155338f, 0.00569307f, -0.03080276f, -0.00348207f, -0.05660494f, 
    0.12362942f, 0.02323074f, 0.00945721f, 0.05247894f, -0.12459689f, 0.07023960f, 0.00718032f, 0.09450822f, 
    -0.03719280f, 0.06403145f, 0.02486456f, -0.09656915f, 0.06711034f, -0.09114178f, -0.02938121f, 0.04096954f, 
    0.23321438f, 0.22098161f, -0.11794661f, -0.13293795f, -0.06370000f, -0.00124204f, -0.07561149f, -0.04139095f, 
    0.07901249f, 0.08931321f, 0.00027340f, -0.03440455f, 0.35211280f, 0.02910749f, -0.20612504f, -0.15727091f, 
    -0.02049504f, -0.00134582f, -0.00037219f, -0.08237163f, -0.07091059f, 0.02573025f, -0.08906354f, -0.05515692f, 
    -0.12096976f, 0.07944009f, 0.09517423f, 0.00454659f, -0.05168602f, -0.06542781f, -0.00061198f, -0.01370408f, 
    0.06110876f, 0.12955496f, -0.07154669f, -0.02988116f, 0.05035813f, 0.01684210f, 0.13057247f, 0.04806253f, 
    -0.03918849f, -0.05073732f, -0.09507521f, -0.13263279f, 0.02671946f, -0.06840503f, -0.12851854f, 0.04998300f, 
    -0.10180626f, 0.07170486f, -0.17457424f, -0.05301703f, -0.03677777f, -0.00917603f, -0.06559500f, -0.12747543f, 
    0.05702616f, 0.08096933f, 0.09852068f, 0.09060636f, 0.13916837f, -0.45655993f, 0.37378544f, -0.12227295f, 
    -0.04614006f, 0.11323731f, -0.10143519f, -0.16452990f, -0.03388736f, 0.01240483f, -0.00203364f, 0.09899606f, 
    0.23089886f, 0.09275188f, -0.01712269f, -0.00274173f, 0.03537402f, 0.00135206f, 0.04075282f, 0.11467347f, 
    0.05401366f, -0.03178079f, 0.16609052f, -0.09673990f, -0.15306358f, -0.12166817f, 0.03657257f, 0.08765657f, 
    0.03219423f, 0.04570481f, -0.03787567f, 0.09531429f, 0.05855920f, 0.09057605f, 0.07261520f, 0.00137176f, 
    -0.35657093f, -0.24190822f, -0.07560138f, 0.12858273f, -0.01544364f, -0.10366230f, -0.03413323f, 0.03316378f, 
    -0.06461046f, 0.01280508f, -0.08671395f, -0.04817758f, -0.30883464f, -0.13743578f, -0.11214193f, 0.13935405f, 
    -0.14154308f, 0.00292997f, -0.17485380f, -0.05791475f, 0.12719287f, 0.14470176f, -0.03393441f, 0.04377889f, 
    0.00740540f, -0.02206729f, -0.05189117f, -0.10711377f, 0.05683431f, -0.03009543f, -0.01399520f, 0.01095891f, 
    -0.03630674f, 0.02476372f, 0.04500791f, -0.08929186f, -0.15144305f, 0.15905428f, -0.08074359f, 0.06243085f, 
    0.00413501f, -0.07136096f, 0.06665414f, -0.00467351f, 0.09754042f, 0.11731173f, 0.17982188f, -0.01685241f, 
    0.00729395f, -0.10445755f, -0.08702224f, -0.01722840f, 0.01070238f, -0.05334050f, -0.01366913f, -0.04164881f, 
    -0.00943485f, 0.00122126f, 0.00110153f, -0.07204022f, -0.11608664f, -0.41194072f, -0.00687562f, -0.04835522f, 
    -0.03548863f, 0.02190905f, 0.03727947f, -0.12327164f, 0.03290324f, 0.02050042f, -0.04686125f, 0.02857776f, 
    -0.01743145f, 0.07910755f, 0.18661664f, 0.09508630f, 0.07380512f, 0.18502617f, -0.05395152f, 0.07391347f, 
    0.07660443f, -0.03136986f, 0.13094078f, 0.07060675f, -0.10044782f, -0.02984888f, 0.18354222f, 0.15257010f, 
    0.00650503f, 0.02545816f, -0.01228528f, 0.06677219f, 0.18465729f, 0.17158239f, 0.09463384f, -0.04849599f, 
    -0.08608788f, -0.20686565f, 0.27667618f, 0.03239932f, -0.02911969f, 0.03340787f, 0.06962658f, 0.24459185f, 
    -0.02991429f, 0.02214026f, 0.02970259f, -0.03253319f, 0.05237452f, 0.04933353f, -0.05811722f, -0.13025783f, 
    -0.15769950f, -0.05601740f, -0.03367918f, -0.06006328f, -0.00121081f, -0.00256573f, -0.16544083f, -0.09927427f, 
    -0.02403615f, 0.00219119f, 0.05118525f, -0.09111242f, 0.00741490f, -0.06382222f, -0.02676476f, 0.06272500f, 
    -0.01829432f, 0.00889566f, -0.11966044f, 0.04167722f, -0.02454498f, -0.11235490f, 0.22537175f, 0.16880259f, 
    -0.04914007f, -0.01741007f, -0.04553289f, 0.14586906f, 0.02381774f, -0.00697216f, 0.08126853f, -0.00099010f, 
    0.31098905f, 0.28456557f, -0.32348284f, -0.08750797f, 0.02696858f, 0.01450130f, 0.02197524f, -0.02810175f, 
    0.00167272f, 0.08775279f, 0.02891317f, -0.06860835f, -0.09496891f, 0.17794114f, -0.11039447f, 0.17639306f, 
    -0.01976046f, 0.01958812f, -0.09124900f, 0.08288117f, 0.07060397f, 0.03203766f, 0.09042771f, 0.28091756f, 
    0.04326453f, 0.00190001f, 0.04245595f, 0.08202396f, 0.14733073f, 0.06332257f, 0.30262586f, 0.15842067f, 
    -0.07333767f, 0.05696332f, -0.04882767f, -0.05336193f, 0.29388958f, 0.09347061f, -0.01153068f, 0.11925040f, 
    -0.04270720f, -0.00885562f, -0.02675446f, -0.06677250f, -0.00021794f, 0.03279247f, -0.00432780f, -0.03023677f, 
    -0.03042046f, -0.02145762f, -0.07376987f, -0.06574193f, -0.01492529f, -0.12356382f, -0.02457350f, -0.02435616f, 
    -0.05205137f, 0.01736436f, 0.00569756f, -0.00389224f, -0.10882559f, 0.05978723f, 0.00607519f, 0.00854125f, 
    0.03087778f, -0.01410303f, -0.04466115f, -0.00473929f, 0.13451573f, 0.17609622f, 0.10015628f, 0.11404979f, 
    0.01754847f, 0.15665340f, 0.12122384f, 0.17489064f, 0.15327030f, -0.03831496f, -0.01280427f, 0.05213693f, 
    0.02163051f, 0.05866726f, 0.01333897f, 0.11587455f, -0.40770963f, 0.01810244f, -0.19866347f, 0.27654013f, 
    -0.03599232f, 0.00639846f, 0.09379804f, 0.06941237f, -0.05417060f, -0.08049414f, 0.04518229f, -0.03938670f, 
    -0.01219592f, -0.00502380f, -0.04635582f, 0.03665657f, 0.14639509f, 0.08241802f, 0.07366747f, 0.06700262f, 
    0.02757468f, 0.20073776f, 0.13521035f, 0.03590706f, 0.06710437f, 0.29703298f, 0.14532436f, 0.18674618f, 
    -0.23945233f, 0.10341418f, 0.16490221f, -0.06406798f, 0.05172712f, -0.03019079f, -0.07533580f, 0.05972579f, 
    0.27566028f, 0.18642053f, 0.12446819f, -0.05825302f, -0.01745673f, -0.14396036f, 0.00869993f, 0.02759630f, 
    -0.18627661f, 0.07865766f, -0.01442340f, 0.08705565f, -0.01798565f, -0.38508436f, 0.15967567f, -0.27349964f, 
    -0.02771939f, 0.01469477f, -0.09102842f, -0.07819536f, 0.12863593f, -0.04230317f, 0.02973790f, 0.00271057f, 
    -0.41001946f, -0.25384170f, 0.04191819f, 0.03578492f, 0.06596859f, 0.08329836f, 0.00200841f, -0.14079805f, 
    -0.05087827f, -0.07388008f, -0.12223896f, -0.04056231f, -0.34145817f, -0.27120933f, -0.36528683f, -0.16858973f, 
    0.30186066f, -0.04998487f, -0.09174897f, 0.06529239f, 0.00685289f, -0.01123449f, -0.01997275f, -0.05299038f, 
    0.12122973f, -0.45774356f, 0.14951724f, -0.32140458f, -0.10210875f, -0.12641512f, 0.08091536f, -0.01107127f, 
    -0.00026029f, 0.02018736f, 0.07150067f, -0.02177017f, 0.00948949f, 0.06552789f, -0.19820698f, -0.19336411f, 
    -0.06161208f, 0.03888875f, -0.01838861f, -0.02334808f, -0.01036250f, 0.11183034f, 0.02608998f, -0.08321061f, 
    -0.27568501f, -0.22596380f, 0.08437438f, 0.02147875f, -0.25493342f, -0.18166861f, -0.05048224f, -0.08680303f, 
    0.05034830f, 0.15394615f, -0.01117695f, 0.16952179f, -0.50918990f, 0.00432114f, -0.26202393f, 0.08484085f, 
    -0.08485824f, 0.03551592f, 0.03617660f, 0.11531958f, 0.15552776f, -0.00923153f, -0.00025010f, 0.02488148f, 
    -0.21601640f, -0.09678122f, 0.02661142f, 0.13630457f, -0.04470178f, -0.01352845f, 0.06166694f, -0.03870035f, 
    0.00636952f, -0.04741173f, -0.17224619f, 0.20574768f, 0.08095229f, 0.17366473f, 0.04868734f, 0.00785241f, 
    -0.00773467f, -0.03677972f, 0.07760143f, 0.00869223f, -0.03942327f, 0.02037141f, -0.06044078f, 0.00725113f, 
    0.23292252f, 0.28924951f, 0.21904314f, 0.23103969f, -0.02639350f, 0.01624737f, 0.22047704f, 0.07284578f, 
    0.11126592f, 0.00557523f, 0.16397588f, -0.01461624f, 0.46139547f, 0.16539462f, 0.20058766f, -0.02355609f, 
    0.10274484f, -0.01356696f, 0.05106032f, -0.01808194f, -0.08126398f, -0.07181621f, 0.05349934f, 0.05345732f, 
    0.09100001f, -0.01682314f, 0.06313332f, 0.08725949f, 0.11396042f, 0.04628028f, 0.16656074f, 0.06696144f, 
    0.02411989f, 0.01659364f, -0.08149188f, 0.11226515f, 0.02108284f, 0.11335786f, 0.05566187f, -0.07424007f, 
    0.00983414f, 0.01347672f, -0.04605556f, 0.09064251f, 0.06288262f, 0.09664264f, 0.10375881f, 0.03158129f, 
    -0.02083199f, 0.03725366f, -0.19946328f, -0.12786272f, -0.02039977f, 0.13994695f, 0.01240506f, -0.10377166f, 
    0.10944819f, 0.11223652f, 0.00514942f, 0.10804015f, 0.03340921f, 0.28240576f, -0.09652568f, 0.18861479f, 
    -0.07695637f, 0.01644450f, -0.10079189f, 0.02034398f, -0.00668215f, -0.06303919f, 0.12759513f, 0.02192497f, 
    0.20478354f, -0.22841591f, -0.23434164f, -0.09041431f, -0.04331988f, -0.11143702f, -0.05584246f, 0.15325609f, 
    -0.10131068f, 0.17913368f, 0.05989128f, 0.05692583f, 0.27532992f, 0.25113350f, 0.00360135f, -0.04066665f, 
    0.06699783f, 0.11619047f, 0.02451306f, 0.09124797f, 0.03227953f, -0.11264734f, -0.05147585f, -0.02839930f, 
    0.04728736f, 0.20481060f, 0.02987027f, -0.05581548f, 0.07250664f, 0.13436212f, 0.08742635f, -0.06309260f, 
    -0.13918528f, -0.07386432f, -0.12438674f, 0.01501476f, -0.48085141f, -0.70544696f, -0.17297462f, -0.09414583f, 
    0.09129866f, 0.20482513f, -0.25913671f, -0.07860406f, -0.14870648f, -0.09278284f, -0.01073921f, 0.05118502f, 
    -0.08244994f, -0.11577957f, -0.54015088f, -0.36652622f, 0.13534334f, 0.03392104f, 0.12782779f, 0.01346914f, 
    -0.10362831f, 0.00732507f, -0.09989808f, -0.13996778f, 0.09396643f, 0.26804563f, -0.01445716f, -0.06404626f, 
    0.03390713f, 0.07546096f, 0.07520067f, -0.06726193f, 0.01433113f, 0.02507765f, -0.09539616f, -0.03834604f, 
    -0.35598227f, -0.19465266f, 0.17530958f, -0.15200441f, -0.14201070f, 0.06982561f, -0.09372044f, 0.09350337f, 
    0.04240384f, 0.06099746f, 0.09545162f, 0.03689399f, -0.06068630f, -0.28311560f, 0.05923307f, 0.06178367f, 
    -0.05030078f, -0.01438408f, 0.17303325f, 0.08502258f, 0.17740294f, 0.14142711f, -0.14602853f, -0.07971931f, 
    -0.03062280f, -0.11725610f, -0.08656601f, 0.03281237f, 0.02158086f, 0.01154472f, -0.10486820f, 0.05956307f, 
    0.05903255f, -0.00531720f, 0.15141515f, 0.06101898f, -0.21082450f, -0.17944534f, -0.18274309f, -0.09661997f, 
    -0.00770337f, -0.07693275f, -0.02644040f, -0.09992602f, 0.08344465f, -0.16277112f, 0.12458049f, -0.06874463f, 
    -0.18660662f, -0.30629200f, -0.14615315f, -0.11157256f, -0.18599384f, 0.14062466f, -0.03597717f, 0.17718488f, 
    0.12658390f, 0.08316492f, 0.05912434f, 0.16457620f, 0.04728071f, -0.01221436f, -0.04291520f, -0.06793982f, 
    -0.16871491f, 0.18112589f, -0.03155808f, 0.03977753f, 0.09252171f, 0.01032544f, -0.01773588f, 0.09639850f, 
    0.27742702f, -0.30383983f, -0.08305471f, -0.01568547f, -0.13173422f, -0.07352826f, -0.08686770f, 0.12304684f, 
    0.16374061f, -0.08935475f, -0.01579271f, -0.05110793f, 0.21812998f, 0.16987556f, 0.22204025f, 0.01552858f, 
    -0.03585616f, 0.06931504f, 0.10375249f, -0.02201321f, 0.18842144f, 0.01683505f, -0.13607375f, -0.02802904f, 
    0.09361126f, 0.08953480f, 0.09238705f, 0.09632375f, 0.10709677f, 0.09489238f, 0.04202386f, 0.06718161f, 
    0.04410182f, 0.01846210f, -0.07944842f, -0.04272329f, 0.07153396f, -0.41369855f, -0.07897874f, -0.35416093f, 
    0.04963214f, -0.00999106f, 0.03835506f, 0.05121509f, -0.03340226f, -0.06518414f, 0.19054754f, 0.11770935f, 
    -0.00062645f, -0.05215466f, -0.01389008f, -0.01086903f, -0.00570699f, -0.04590266f, 0.04039872f, -0.03728284f, 
    0.02372181f, 0.01549050f, -0.01389719f, -0.04591041f, 0.02459403f, -0.03080237f, -0.05426105f, -0.03049389f, 
    0.03001721f, -0.02438532f, -0.03660832f, -0.01194998f, 0.01772397f, 0.03942762f, -0.02315716f, 0.03961512f, 
    -0.01593399f, -0.02541472f, -0.03270375f, 0.04460325f, -0.00773323f, -0.04826786f, -0.01569245f, -0.01455537f, 
    -0.00593839f, 0.02764188f, -0.02578993f, -0.04578518f, 0.03544822f, 0.03085957f, -0.02868241f, -0.02024305f, 
    -0.03132203f, -0.05099270f, 0.02948290f, 0.02963412f, 0.02648523f, -0.02523308f, -0.04478522f, -0.03580027f, 
    0.00908613f, 0.03578571f, -0.03330096f, -0.03765444f, 0.03814359f, -0.00367119f, 0.02995169f, -0.03582192f, 
    -0.03935783f, -0.04663929f, -0.03579213f, 0.02087426f, -0.04130620f, 0.00697794f, -0.04964887f, 0.02046149f, 
    -0.00847777f, -0.05443818f, 0.04335342f, 0.03824422f, -0.02988953f, -0.02505866f, -0.03927534f, 0.01695499f, 
    -0.04732033f, 0.04100623f, -0.02768171f, 0.00480720f, 0.02373562f, 0.01607567f, -0.02703753f, 0.03013377f, 
    -0.01599807f, 0.02813460f, -0.00585776f, -0.01054317f, -0.00522525f, -0.00915784f, 0.02736421f, -0.00313449f, 
    0.00073648f, 0.01217761f, -0.04287024f, -0.03500247f, 0.01624693f, -0.04090623f, -0.01768890f, 0.02492358f, 
    0.01976974f, 0.00425556f, -0.04398782f, 0.00211462f, 0.00010261f, -0.00185640f, -0.02362887f, -0.01363631f, 
    -0.04299575f, -0.02500641f, -0.05158118f, 0.00452278f, 0.03628260f, -0.01454555f, 0.01729069f, -0.00741322f, 
    -0.02488620f, -0.01556247f, -0.03052245f, -0.03819145f, 0.03160068f, -0.04713230f, -0.00595655f, -0.02279280f, 
    -0.04234121f, -0.00570129f, 0.02165096f, 0.02644885f, -0.01458509f, 0.00845583f, -0.05078517f, 0.04257429f, 
    0.01786176f, -0.01353332f, 0.01246501f, -0.00125773f, -0.01171798f, 0.01750040f, 0.02722818f, -0.00744669f, 
    -0.05075700f, -0.03599836f, -0.01767947f, 0.02917289f, -0.04582747f, -0.05014714f, -0.01876106f, -0.03639166f, 
    -0.01646167f, 0.04234456f, -0.02751827f, 0.03239048f, 0.01245918f, 0.00138322f, -0.03561721f, -0.00035520f, 
    0.02480779f, 0.01846897f, -0.00062938f, 0.00490287f, 0.00417616f, 0.02200680f, 0.00636543f, -0.04975445f, 
    -0.04839109f, 0.03588806f, 0.04045131f, -0.01663354f, -0.00638908f, 0.00056557f, -0.00572910f, -0.04915734f, 
    -0.02216128f, 0.01832208f, -0.04712390f, 0.04289867f, -0.01128944f, -0.05117241f, 0.04160941f, 0.01567966f, 
    -0.04859518f, -0.04347225f, -0.02361509f, -0.02602453f, -0.01709804f, 0.03973019f, -0.02062079f, 0.01104583f, 
    -0.04139245f, -0.01303972f, 0.01675217f, 0.02615555f, 0.00799764f, 0.04516744f, -0.01982690f, -0.00736023f, 
    0.03471182f, 0.02566996f, 0.03176508f, 0.00035575f, 0.03776905f, 0.04588780f, -0.00713185f, -0.02756054f, 
    0.03748945f, -0.04070724f, 0.01075689f, -0.00186121f, 0.03619688f, -0.01651295f, 0.03485682f, -0.02937404f, 
    -0.00505422f, 0.00527787f, 0.04968638f, -0.02908456f, 0.03034334f, 0.01277729f, 0.01622324f, 0.00165798f, 
    -0.02559424f, -0.02023795f, -0.00467564f, 0.00005417f, -0.03598675f, 0.02661089f, 0.01116311f, -0.00103404f, 
    0.00981180f, -0.03913316f, -0.02049007f, -0.05698857f, 0.00980594f, 0.00497252f, -0.05328516f, -0.05286583f, 
    0.00856972f, 0.05051658f, -0.01715625f, 0.02209429f, -0.00660552f, -0.01190324f, 0.04349245f, -0.03711383f, 
    -0.02206289f, -0.05621879f, -0.01014648f, -0.04073753f, 0.03967249f, -0.04592302f, 0.03881362f, 0.01984340f, 
    -0.05204706f, -0.03013138f, 0.01814946f, -0.00031194f, -0.02509120f, 0.02994825f, 0.02514576f, 0.00765734f, 
    -0.00664958f, 0.03052380f, -0.03420367f, -0.05082508f, -0.05097299f, -0.02101198f, -0.01894816f, 0.03794165f, 
    0.03163870f, 0.04439337f, -0.04568794f, 0.00622297f, 0.02574331f, -0.01272363f, 0.02498245f, -0.04390559f, 
    0.02769091f, 0.02893509f, -0.04460152f, -0.02529896f, 0.03954087f, 0.02892895f, 0.01692349f, -0.05410551f, 
    0.03965399f, -0.03193871f, 0.01402986f, -0.00569185f, 0.00926862f, 0.00191196f, -0.05133459f, 0.01006060f, 
    -0.01896563f, -0.02846912f, 0.04721855f, 0.03795274f, -0.01474318f, 0.03492210f, -0.04164026f, -0.02773394f, 
    0.02079560f, 0.01469826f, 0.02128990f, -0.03705286f, -0.00306542f, -0.03433595f, 0.03003300f, 0.02032401f, 
    -0.02017011f, -0.01391031f, -0.02799145f, -0.01476868f, 0.00903302f, 0.04700051f, 0.03545638f, -0.02092583f, 
    -0.02634973f, -0.02220609f, -0.02071018f, -0.02102649f, -0.03098335f, -0.03328696f, 0.00121812f, -0.02640887f, 
    -0.01157074f, -0.01729962f, -0.03067257f, -0.04399679f, 0.03134282f, 0.05556919f, -0.03609012f, 0.02588775f, 
    -0.00891579f, -0.01266163f, 0.02799873f, -0.01570610f, -0.03821474f, 0.00816432f, -0.00512335f, 0.03750144f, 
    0.00482989f, 0.03994108f, -0.05076017f, -0.04461160f, -0.05459606f, 0.02107273f, -0.03527791f, 0.01009035f, 
    0.03057226f, -0.04154672f, -0.04100522f, -0.04124112f, -0.00863431f, -0.03458343f, -0.01335186f, 0.01558752f, 
    0.01505730f, -0.04293707f, -0.03410171f, -0.03248806f, -0.00963813f, -0.04710338f, -0.04921073f, 0.03380644f, 
    0.00197309f, -0.03971230f, 0.01705788f, 0.03077992f, -0.03551212f, -0.03338915f, 0.02380526f, -0.01061591f, 
    -0.00021363f, -0.00428809f, 0.04216690f, -0.02194040f, -0.01700054f, 0.03352914f, 0.03156333f, 0.00566046f, 
    0.00148433f, -0.00641962f, 0.00670686f, -0.04959759f, -0.04162800f, -0.03278946f, 0.03421203f, 0.01513714f, 
    -0.06807540f, -0.03847961f, 0.05487303f, 0.17926072f, 0.13214414f, 0.09985619f, 0.02530529f, 0.03767321f, 
    -0.00675210f, -0.00820882f, -0.06394967f, -0.05152117f, -0.02232645f, 0.04578118f, -0.05525313f, -0.06111318f, 
    -0.05396550f, 0.07277730f, 0.04457627f, -0.06229148f, 0.11215008f, -0.00020132f, -0.10564254f, 0.05262165f, 
    0.15575881f, 0.21572325f, -0.01253115f, -0.27191859f, 0.00363592f, 0.00286280f, -0.08737750f, -0.06539504f, 
    -0.02405968f, -0.17510866f, -0.13909715f, 0.07788444f, 0.23353410f, 0.15618807f, -0.10202693f, 0.12277599f, 
    -0.10652661f, -0.14531995f, -0.13580787f, -0.18611878f, -0.01622029f, 0.09204451f, -0.04502024f, -0.07567799f, 
    -0.15154064f, -0.10384756f, -0.01058440f, 0.18101232f, 0.01791368f, -0.03195017f, 0.18816088f, 0.09592777f, 
    0.04336357f, 0.05343594f, 0.00577290f, -0.01246512f, 0.26822662f, -0.09045342f, -0.17292964f, 0.00008311f, 
    0.01425193f, -0.02601116f, 0.02250865f, 0.29698336f, -0.05457097f, -0.03537913f, -0.18719147f, -0.08952554f, 
    0.14128168f, -0.02599623f, -0.02594065f, -0.21808045f, 0.09063154f, -0.01492848f, -0.01325929f, -0.08788158f, 
    -0.04881952f, 0.01211012f, -0.09992621f, -0.02980097f, 0.53915155f, 0.05275137f, -0.06012771f, 0.10392542f, 
    0.00397214f, -0.04020182f, 0.12774393f, -0.03516464f, -0.14550675f, 0.14536098f, -0.10562152f, 0.02501816f, 
    0.18017712f, 0.21769406f, 0.00744560f, -0.03014230f, -0.04139553f, 0.06843118f, 0.07401642f, -0.06034857f, 
    0.05338080f, 0.01465285f, -0.03172188f, -0.13544722f, 0.16738887f, -0.02383153f, -0.06216367f, 0.14393921f, 
    -0.00967811f, 0.20210458f, 0.08918690f, 0.06330807f, -0.02890665f, 0.03258890f, -0.06073320f, -0.01520192f, 
    0.17159995f, 0.07383905f, -0.10322538f, 0.00075408f, -0.22250228f, 0.00834958f, -0.08376384f, -0.10252307f, 
    -0.04541600f, -0.11888258f, -0.02853311f, -0.01372888f, -0.28698897f, -0.23224388f, -0.24542868f, 0.19460060f, 
    -0.03035942f, -0.07374361f, -0.03541802f, -0.08841962f, -0.00760192f, -0.07617582f, -0.05242808f, 0.08263086f, 
    0.08924866f, 0.04298755f, -0.08877071f, -0.02663835f, -0.04454431f, 0.16286168f, 0.06024002f, -0.12904736f, 
    0.01714461f, 0.09465607f, 0.03961882f, 0.03265068f, 0.39001480f, -0.04273872f, -0.51254672f, -0.32970828f, 
    -0.05719066f, -0.04006332f, 0.07849210f, 0.07066274f, 0.11282658f, 0.11719162f, 0.10230429f, -0.02322073f, 
    0.03767042f, 0.04017549f, 0.02704691f, -0.05046241f, -0.05066556f, -0.13683477f, -0.12030561f, 0.08054178f, 
    0.06915193f, 0.09886128f, -0.01969754f, 0.05771604f, 0.06532241f, -0.23208933f, 0.18495880f, 0.12718138f, 
    -0.03725804f, 0.11859491f, -0.05874584f, 0.04429770f, -0.02242781f, 0.07478058f, -0.08265653f, -0.02821809f, 
    -0.03101166f, 0.04733165f, 0.16036673f, 0.12489098f, -0.06391710f, 0.02240108f, 0.11913321f, 0.03811711f, 
    -0.24225350f, 0.08369061f, 0.07875740f, 0.03090825f, 0.08051103f, -0.14715809f, -0.19338489f, 0.25663269f, 
    0.09248331f, 0.01752194f, 0.06723817f, 0.19906965f, -0.08351248f, 0.06864988f, -0.02367635f, -0.07881003f, 
    -0.00036830f, -0.00106639f, 0.05200807f, 0.36033824f, 0.00114987f, 0.01578435f, 0.15219589f, 0.24787588f, 
    -0.15593977f, 0.05991628f, 0.04105968f, 0.14086835f, 0.06808854f, 0.13076554f, 0.04555974f, -0.07598394f, 
    0.04750677f, -0.02958732f, -0.01951448f, -0.08172299f, 0.09087404f, 0.01501072f, -0.11103104f, 0.00242804f, 
    -0.04439865f, 0.00771506f, 0.01608121f, 0.02371315f, -0.11202195f, 0.10652351f, -0.05444925f, 0.00231643f, 
    0.12416079f, -0.05449611f, 0.11549072f, -0.07803096f, 0.27518284f, -0.22527152f, -0.12385468f, 0.15676385f, 
    -0.02784654f, 0.03841364f, 0.07444242f, 0.06133211f, -0.10987221f, -0.12453797f, 0.03034825f, -0.07528009f, 
    0.42420992f, -0.04006303f, -0.05377248f, -0.16609478f, 0.08104908f, -0.00891662f, 0.05333803f, -0.01984868f, 
    -0.06013829f, 0.05363196f, 0.07961292f, 0.10264385f, 0.04405973f, 0.05299737f, -0.01304578f, 0.00681154f, 
    -0.05811597f, -0.02399240f, 0.06348701f, -0.15101469f, 0.00430464f, 0.07935763f, 0.07774559f, 0.07606556f, 
    -0.00135235f, 0.00881618f, 0.05475234f, 0.12909089f, 0.11226135f, 0.08801612f, 0.09218942f, -0.01730890f, 
    0.03249875f, 0.05379505f, 0.04420716f, -0.04507636f, 0.02133053f, 0.12087617f, -0.02256777f, -0.27321494f, 
    -0.02168606f, -0.07078096f, -0.13225108f, -0.02928940f, 0.01832556f, -0.00566876f, -0.01169913f, -0.02666816f, 
    0.03783733f, 0.10989277f, 0.07391531f, -0.06614599f, 0.02728120f, 0.08292101f, 0.08680297f, -0.07010947f, 
    0.12786551f, 0.08597334f, 0.04884692f, 0.05657207f, 0.34295058f, -0.06589944f, -0.32326657f, -0.08579378f, 
    0.05235464f, 0.00318317f, 0.07948272f, 0.03994888f, 0.10222244f, 0.01861185f, 0.16796881f, 0.03026413f, 
    -0.10063569f, 0.10757818f, 0.19298601f, 0.18072802f, 0.05993041f, 0.17911099f, 0.17931104f, -0.02889194f, 
    0.01149869f, 0.00587577f, 0.06732833f, 0.07522004f, 0.16366965f, 0.25676742f, -0.37461939f, -0.18106639f, 
    -0.08140260f, 0.06069729f, -0.04751227f, -0.01400824f, -0.10864259f, 0.04773271f, -0.12738231f, 0.06514121f, 
    0.05132465f, -0.06188321f, -0.02606927f, 0.14838700f, 0.00497074f, -0.03980290f, 0.07648069f, 0.16542920f, 
    0.08722291f, 0.02275742f, -0.02083585f, -0.08303894f, -0.01127694f, 0.56022787f, 0.33173037f, 0.28748995f, 
    -0.37705854f, 0.11204704f, 0.08248232f, -0.08087599f, -0.01399854f, 0.01634982f, 0.05811086f, -0.04405034f, 
    -0.26843739f, -0.30314034f, -0.16570312f, -0.05803189f, 0.08880025f, 0.07013498f, 0.20580888f, -0.01463483f, 
    -0.00828680f, 0.01449245f, 0.04419889f, 0.00936727f, -0.05431759f, 0.04422968f, -0.07963855f, -0.05926669f, 
    -0.04156466f, -0.00431549f, -0.10202709f, -0.03189918f, -0.06454321f, -0.03200632f, -0.02999905f, -0.10397911f, 
    0.15869926f, 0.04417875f, -0.14458728f, 0.25272003f, 0.01682548f, -0.10402043f, -0.01731802f, 0.02515212f, 
    0.00973833f, 0.01071641f, 0.11203811f, -0.08883435f, -0.10572764f, -0.20618229f, -0.06923710f, -0.10659005f, 
    0.18914206f, -0.07547843f, 0.09035200f, 0.09087716f, -0.06228676f, -0.07628768f, -0.02847524f, -0.04667250f, 
    -0.00494129f, 0.06333541f, 0.01492764f, -0.18669355f, -0.14506862f, -0.06130324f, 0.02406933f, 0.16649948f, 
    -0.06238753f, 0.15636580f, 0.06147891f, 0.11293506f, 0.01310129f, 0.12394258f, 0.17398348f, 0.05646133f, 
    -0.15462711f, -0.05365757f, -0.09830526f, 0.03028701f, 0.07592015f, 0.03658224f, 0.20665520f, 0.11497884f, 
    -0.07454044f, -0.04529328f, 0.07293507f, -0.01242003f, -0.03015219f, -0.04823086f, -0.10945444f, -0.14555587f, 
    0.13752221f, -0.00093042f, 0.25888962f, 0.11027230f, -0.36145574f, 0.43268946f, 0.03250967f, -0.13261780f, 
    -0.08512038f, 0.13202474f, -0.08430286f, 0.04863996f, 0.11043776f, 0.02127259f, 0.03007119f, -0.05893993f, 
    0.24784736f, 0.04355744f, -0.05824053f, 0.19879410f, 0.12616281f, 0.00572366f, 0.03492806f, -0.04801849f, 
    0.09943535f, -0.00577529f, 0.03000833f, 0.07014075f, -0.02693825f, -0.06206755f, -0.01499911f, 0.08782212f, 
    0.11548863f, -0.16252887f, 0.32163721f, 0.14542881f, 0.02270170f, 0.03896318f, -0.12030177f, 0.04898307f, 
    -0.13509530f, -0.20515630f, 0.00542551f, -0.19428478f, 0.17676677f, 0.03194492f, 0.08917463f, 0.25428191f, 
    -0.00007340f, -0.00108168f, -0.02877188f, -0.01814761f, -0.12322290f, -0.07081319f, -0.09986786f, -0.14558744f, 
    -0.04989089f, 0.06789047f, 0.08886349f, 0.05226879f, -0.05322692f, -0.00848554f, -0.00289434f, -0.05063190f, 
    -0.08292994f, -0.04432523f, 0.02417305f, -0.13790354f, 0.09425508f, 0.12898110f, 0.11689975f, 0.08362398f, 
    0.02045944f, 0.01243920f, -0.00987532f, 0.10092052f, 0.06255861f, 0.02003095f, 0.28754884f, 0.11981405f, 
    -0.09901322f, -0.04223913f, -0.13035505f, -0.00773443f, 0.07662608f, 0.14192691f, 0.13744070f, -0.04724681f, 
    -0.12921214f, -0.20701811f, -0.05309661f, -0.16193520f, 0.03901972f, 0.08689155f, 0.09929186f, -0.01984010f, 
    -0.02825342f, -0.03749759f, -0.07792612f, -0.07126527f, -0.31449255f, -0.00786227f, -0.23793508f, -0.16677201f, 
    -0.00045757f, 0.03178612f, -0.10213634f, 0.05462620f, 0.05174565f, 0.03876887f, -0.03687492f, 0.10885248f, 
    0.01487378f, -0.08942308f, 0.05377073f, -0.08491088f, 0.03361918f, 0.11089707f, 0.20206283f, 0.15090773f, 
    0.15991943f, 0.16934250f, 0.12617667f, 0.09490125f, -0.01964839f, -0.05490411f, 0.07865952f, -0.18997858f, 
    -0.11241733f, -0.12371700f, 0.01382702f, 0.17995335f, 0.01209930f, -0.10822381f, 0.13574469f, 0.02965169f, 
    -0.12617563f, 0.12456124f, -0.08934303f, -0.30945033f, -0.03180816f, 0.02636594f, 0.20619871f, 0.11771687f, 
    -0.02383989f, -0.04452816f, -0.00423234f, 0.00495800f, -0.09207311f, -0.03086334f, -0.09031538f, -0.04268869f, 
    -0.11294214f, -0.08766825f, -0.02469387f, -0.08646087f, -0.11155687f, -0.12400825f, -0.10522291f, -0.27204910f, 
    -0.14123555f, -0.12795489f, -0.08938084f, -0.11567035f, 0.07471211f, 0.21117513f, -0.03232781f, -0.04010172f, 
    0.01266783f, -0.06609584f, -0.23136008f, -0.02154554f, -0.17873408f, 0.00303681f, 0.08779495f, -0.08220936f, 
    -0.03598252f, -0.06606092f, 0.16193971f, 0.01896713f, -0.01864458f, 0.00066971f, 0.02809400f, 0.19476856f, 
    0.51827210f, 0.04646184f, 0.02998523f, 0.40585950f, 0.09592032f, 0.10284843f, -0.10363572f, -0.00335038f, 
    0.15148403f, 0.06887061f, -0.07039908f, -0.06890826f, 0.10433595f, 0.06703798f, 0.02580360f, 0.08897161f, 
    0.04694442f, 0.08648444f, 0.01790162f, 0.01745499f, 0.02106595f, -0.06450485f, 0.12338533f, -0.12563524f, 
    -0.01048880f, -0.00659411f, -0.06198565f, -0.10442226f, 0.07643046f, 0.10380381f, 0.07354828f, 0.17276937f, 
    0.07597142f, 0.09770510f, 0.11559498f, 0.15558708f, 0.33634633f, -0.03641658f, 0.21113423f, 0.20261370f, 
    0.09036958f, -0.04676151f, 0.01528658f, -0.04250123f, -0.03753069f, -0.03004754f, -0.09244680f, -0.01143708f, 
    -0.20174760f, -0.16863820f, -0.13716908f, -0.20762026f, -0.10606726f, -0.02826445f, -0.05165098f, -0.03926279f, 
    -0.04510072f, -0.06039816f, -0.05781001f, -0.03624329f, 0.00711577f, 0.04516305f, 0.25451267f, -0.10654008f, 
    -0.08708218f, -0.08082995f, -0.12174818f, -0.05347229f, 0.00168952f, 0.09112028f, 0.16119155f, 0.12005499f, 
    -0.26457256f, -0.04087296f, 0.16035050f, 0.00109344f, -0.00458441f, 0.00007544f, -0.00569676f, 0.05214798f, 
    -0.02775344f, 0.03895865f, 0.00730907f, 0.07370753f, 0.06224727f, -0.33175293f, 0.03008509f, 0.05914549f, 
    0.17815286f, -0.02480789f, 0.07329887f, -0.00062784f, 0.12317815f, -0.08414413f, 0.01280224f, -0.04316152f, 
    0.02154843f, -0.12559927f, -0.15350147f, -0.09536294f, 0.04250664f, 0.04596432f, 0.23168743f, 0.03659504f, 
    0.12115613f, -0.03640497f, 0.01355519f, 0.02914492f, -0.15696470f, 0.00675947f, 0.00780600f, 0.19277227f, 
    0.15122184f, 0.19592786f, -0.02319281f, 0.21619229f, 0.04024495f, 0.02342787f, 0.02557984f, 0.09737356f, 
    -0.01695040f, 0.12922433f, 0.06120757f, 0.03246853f, 0.04908900f, -0.05795727f, 0.00525117f, -0.17523162f, 
    0.01921961f, -0.16456091f, -0.12463556f, 0.02495406f, -0.07740145f, -0.05235798f, -0.09701125f, -0.01323510f, 
    -0.05013926f, -0.07992651f, 0.05050103f, 0.02264551f, 0.09185690f, 0.18101831f, 0.06712586f, -0.08106242f, 
    0.21660119f, -0.08372393f, -0.04799398f, 0.20453323f, -0.00823736f, 0.02909762f, -0.02342778f, -0.01568984f, 
    0.17411256f, -0.04385952f, -0.04131277f, 0.02274277f, 0.15695941f, -0.17830279f, -0.12666962f, 0.02317776f, 
    -0.00024902f, -0.14685187f, -0.09451690f, 0.02670142f, -0.06301634f, -0.05014944f, -0.08277509f, -0.01684861f, 
    0.20160991f, 0.19741143f, -0.04922431f, -0.24990886f, 0.01519601f, 0.06531560f, -0.02041957f, 0.11879126f, 
    0.14978850f, -0.03456542f, 0.08272745f, 0.01117634f, -0.15429184f, 0.20909242f, -0.01869845f, -0.10410669f, 
    -0.23881555f, -0.16292250f, -0.03116064f, -0.01325442f, 0.06919716f, -0.11318139f, 0.01734869f, -0.04608152f, 
    -0.16688372f, -0.08708039f, -0.03877151f, 0.12294433f, -0.03615239f, -0.09577379f, -0.09062808f, -0.00200226f, 
    0.02281400f, 0.09142791f, 0.04598095f, 0.08766630f, -0.26604015f, -0.01792359f, -0.21413460f, -0.07283362f, 
    0.00681485f, -0.19923335f, 0.08175224f, 0.03210215f, 0.18653157f, -0.01638853f, 0.09908746f, -0.21331353f, 
    0.14853394f, 0.16947111f, -0.05668623f, 0.14713307f, 0.02553570f, -0.05741377f, -0.10674230f, 0.22200637f, 
    0.13369487f, 0.00867278f, 0.01179177f, 0.16042669f, -0.28864416f, 0.18627797f, 0.10937173f, 0.01689503f, 
    -0.03816304f, 0.07037414f, 0.09237675f, -0.04531195f, 0.01564172f, -0.05023989f, 0.02304505f, 0.11420340f, 
    -0.24416555f, -0.32116392f, 0.23168209f, 0.28833285f, 0.02506535f, 0.09628384f, 0.04722572f, 0.16592968f, 
    -0.12779658f, -0.07167508f, -0.08760881f, -0.00453656f, 0.01044329f, 0.06280363f, 0.12516071f, -0.05836000f, 
    -0.07374398f, 0.10800382f, -0.06423048f, -0.09528225f, -0.02931977f, -0.12442055f, 0.09168389f, 0.14284511f, 
    0.07375915f, -0.05531789f, -0.01638605f, 0.01216864f, 0.06192945f, -0.02217404f, 0.12954664f, 0.02588202f, 
    -0.05161120f, -0.03906674f, -0.02649849f, 0.11786636f, -0.03302698f, -0.11081404f, 0.04563579f, 0.06693508f, 
    -0.13272364f, -0.06394219f, 0.02016482f, 0.16054392f, -0.00864536f, 0.07898793f, 0.12560803f, -0.01789331f, 
    -0.05833107f, 0.05701087f, 0.04278819f, -0.08958764f, -0.02325653f, -0.02014852f, -0.02654083f, 0.01677782f, 
    -0.00622066f, -0.14084639f, -0.07703344f, -0.04553905f, -0.13298616f, -0.03960952f, -0.01222458f, 0.05152127f, 
    0.15110847f, -0.05843068f, -0.05500911f, -0.09607652f, -0.00828496f, -0.02176778f, -0.00793685f, -0.02956481f, 
    0.10496128f, 0.28592378f, 0.06399248f, -0.16061606f, 0.12727179f, -0.00973979f, -0.04055879f, 0.00815731f, 
    0.04135696f, 0.17461279f, 0.19549972f, -0.01537829f, -0.17843290f, 0.12151226f, 0.34969226f, -0.06213732f, 
    -0.01168937f, -0.07011346f, 0.02237033f, 0.16738981f, 0.12779804f, 0.04865929f, -0.12581789f, -0.06149747f, 
    -0.11836294f, 0.09451801f, 0.12867542f, -0.33777887f, 0.05097464f, 0.01286219f, 0.02739804f, 0.08719067f, 
    -0.11861752f, 0.00401412f, -0.09469687f, -0.04286189f, 0.00106613f, 0.05507822f, -0.07486920f, -0.07475971f, 
    -0.15710448f, -0.14455037f, -0.03449158f, -0.01769544f, -0.01064645f, -0.05348352f, -0.01078370f, -0.10026081f, 
    0.05893464f, 0.11069084f, 0.01404046f, -0.19676620f, 0.00637317f, -0.15952587f, 0.11376817f, -0.17556532f, 
    -0.15874508f, -0.05296310f, -0.00692786f, 0.01914072f, -0.33239055f, 0.17908333f, 0.14557427f, -0.02789405f, 
    -0.02534824f, -0.05756594f, 0.05822290f, 0.10784402f, 0.05445598f, -0.05578710f, -0.08258485f, 0.06563180f, 
    -0.37165642f, -0.06024743f, -0.26661545f, 0.36267060f, -0.10083181f, -0.17147222f, -0.01029702f, 0.13946602f, 
    0.08178277f, -0.01351620f, 0.09083410f, -0.12414391f, 0.04592423f, -0.23095372f, 0.04455737f, 0.18088295f, 
    0.08137387f, 0.03403132f, 0.05408297f, 0.12754245f, 0.25333986f, 0.07850257f, -0.00638206f, 0.00306815f, 
    0.17079616f, -0.05246871f, 0.19253275f, -0.01206036f, 0.17358974f, -0.02646793f, 0.03868089f, 0.14173231f, 
    0.02463117f, 0.01111425f, 0.03089079f, 0.06204595f, 0.34135398f, -0.07175336f, 0.08438495f, 0.21985489f, 
    0.01175147f, -0.00920774f, 0.02187466f, 0.07346045f, 0.04577906f, 0.05412625f, 0.05517294f, 0.01277966f, 
    0.05244117f, 0.08552080f, -0.11497697f, -0.06104073f, -0.13836694f, -0.09339213f, 0.02019426f, 0.04336681f, 
    -0.04918746f, -0.11928256f, -0.10495415f, -0.19287905f, -0.20342384f, -0.02253439f, -0.10752752f, -0.14493364f, 
    -0.08634144f, -0.03672599f, -0.11853296f, 0.06500482f, -0.02473952f, 0.04061151f, 0.02695205f, 0.10575914f, 
    0.17045802f, -0.09182168f, 0.26140213f, -0.06684238f, -0.06749031f, -0.01394063f, 0.10401615f, 0.10322769f, 
    0.14688380f, 0.08830294f, 0.01066458f, -0.07190681f, -0.27387038f, -0.26619759f, 0.14452000f, 0.09414590f, 
    -0.03588923f, -0.16301130f, 0.21076371f, 0.06442298f, 0.09293482f, 0.00126367f, 0.07125934f, -0.07770076f, 
    -0.19100516f, -0.01411937f, 0.09432986f, -0.03972990f, 0.03795980f, -0.02740817f, 0.05027865f, 0.11477324f, 
    0.12827873f, -0.02524654f, -0.03017418f, 0.02043155f, 0.44532472f, 0.05744242f, -0.03883128f, -0.14179222f, 
    0.14595076f, 0.10421705f, -0.05613565f, -0.06529116f, -0.00496730f, 0.00196041f, 0.07519043f, 0.04155148f, 
    0.15754026f, -0.19228260f, -0.05087050f, 0.00869173f, 0.17768878f, 0.05910417f, -0.03359459f, -0.00586079f, 
    0.03668969f, -0.02313885f, 0.12360558f, -0.19240874f, 0.00786299f, 0.05791185f, 0.08351749f, 0.11573738f, 
    0.05787674f, -0.08728559f, -0.00583617f, 0.01536187f, -0.03816058f, 0.06762483f, 0.21751598f, 0.00177548f, 
    0.01182923f, 0.02416887f, 0.16445296f, 0.18896529f, 0.00723356f, 0.03803167f, 0.04865932f, 0.02554583f, 
    0.07738217f, 0.20059562f, -0.05904806f, 0.17871764f, 0.16181897f, 0.20212033f, 0.20326556f, 0.13257405f, 
    -0.09617467f, 0.00453600f, 0.07238343f, -0.01560454f, -0.05511312f, -0.08153023f, -0.00962102f, 0.00561935f, 
    -0.01698518f, -0.13454734f, -0.03452138f, -0.03881564f, -0.03843154f, 0.02159268f, -0.01203077f, 0.08702148f, 
    -0.02940422f, -0.11537360f, -0.02454013f, -0.03284542f, -0.26396498f, -0.39605176f, -0.59601182f, -0.32306397f, 
    -0.06965112f, -0.08974927f, -0.12309539f, -0.12154645f, -0.03078226f, -0.12195215f, 0.16988496f, -0.03081162f, 
    0.01119324f, 0.10588484f, 0.01027311f, 0.05771421f, -0.06118565f, 0.04357734f, -0.01262169f, 0.05188911f, 
    -0.08529902f, -0.04941176f, -0.03901062f, -0.05175671f, 0.27529740f, 0.05610549f, 0.21030870f, 0.13524133f, 
    -0.07181627f, 0.05709445f, 0.02899408f, 0.04329523f, 0.04125013f, -0.03394172f, 0.16549335f, -0.03427174f, 
    0.09499715f, 0.14923820f, 0.18639839f, 0.17662212f, 0.03920225f, -0.03053993f, 0.00382411f, 0.06182738f, 
    0.00630232f, 0.10574851f, 0.14817990f, -0.04855832f, -0.16654097f, -0.35663322f, -0.14750914f, -0.33587337f, 
    -0.03422422f, 0.20540552f, -0.09812417f, 0.23630106f, 0.13104507f, -0.01853200f, -0.00118428f, -0.06366626f, 
    -0.43111789f, -0.09926929f, -0.24233724f, -0.18383598f, 0.10872445f, 0.08508979f, 0.08066235f, 0.07750573f, 
    0.00846244f, 0.02573419f, -0.09779076f, 0.02238687f, -0.17330319f, -0.31072876f, -0.09772657f, 0.01699646f, 
    0.20344390f, 0.14949197f, -0.06711903f, 0.09856388f, -0.01133252f, 0.04555627f, -0.22472385f, -0.02836738f, 
    0.00469590f, 0.06174964f, 0.01963528f, 0.01479491f, 0.17206901f, -0.14368887f, -0.00699460f, 0.03174341f, 
    0.00812002f, -0.00251100f, -0.05427200f, -0.01530858f, -0.17000124f, -0.05912477f, -0.34720770f, -0.20974177f, 
    -0.09728079f, -0.04583156f, 0.03863788f, 0.06088412f, -0.04464935f, -0.07882757f, -0.12992577f, 0.00966965f, 
    0.09383301f, -0.03572626f, 0.04321038f, 0.02731539f, 0.08197854f, 0.00160272f, -0.01347069f, -0.05778608f, 
    -0.05382302f, -0.10289466f, -0.03293777f, 0.00775226f, 0.20839530f, -0.40409559f, 0.01995617f, -0.31690234f, 
    0.27326623f, 0.06857172f, 0.16627195f, -0.09515276f, -0.10860012f, -0.02953212f, -0.05766768f, -0.12508705f, 
    0.08503570f, 0.11434711f, -0.00970734f, 0.13189487f, 0.14137594f, -0.00769466f, -0.03111793f, 0.00440422f, 
    0.24653995f, 0.05136868f, 0.05630969f, -0.11226097f, -0.63073808f, -0.08597188f, -0.68243742f, -0.24102725f, 
    -0.08023990f, -0.08480307f, -0.11227793f, -0.06384055f, 0.15969783f, 0.01843000f, -0.23963054f, -0.12801513f, 
    0.11397745f, -0.55335033f, -0.09089170f, -0.14784572f, -0.01286512f, 0.04034147f, -0.04422395f, 0.18315516f, 
    -0.07895708f, -0.00352090f, -0.06367445f, -0.05942624f, 0.03954586f, 0.02540030f, 0.12274171f, 0.19160545f, 
    -0.05591097f, -0.01900510f, 0.01436336f, 0.01775316f, -0.00572284f, 0.02750837f, 0.01028674f, 0.01594353f, 
    0.04624121f, 0.09951435f, 0.05091898f, 0.09334517f, 0.05116468f, -0.15029116f, 0.05935243f, 0.01175209f, 
    -0.10020870f, 0.02035233f, 0.00324711f, 0.03362631f, -0.43758726f, -0.71896356f, -0.55393904f, -0.35747224f, 
    0.06849401f, -0.15730885f, -0.04071880f, 0.16055153f, -0.08311293f, 0.03991349f, -0.12302034f, -0.04696861f, 
    -0.30503595f, 0.17390019f, 0.23575719f, -0.08321445f, -0.12515390f, 0.12414779f, 0.05474488f, 0.04197162f, 
    -0.00904254f, -0.02469334f, -0.11616259f, 0.02227249f, 0.05159447f, 0.20493244f, 0.09460138f, 0.22167340f, 
    -0.06960359f, 0.21004385f, -0.03776660f, 0.10676923f, -0.00365819f, 0.05517124f, 0.12432094f, 0.00634859f, 
    0.11388762f, 0.03689198f, 0.05490006f, 0.00969799f, 0.04346945f, 0.10329081f, 0.03195429f, 0.11018120f, 
    -0.07027067f, -0.08147728f, 0.05794105f, -0.02809579f, 0.29143953f, 0.12822378f, 0.18526778f, 0.21533138f, 
    -0.05725921f, -0.02803582f, 0.00299983f, 0.06863903f, 0.05920582f, 0.05526129f, 0.00338108f, 0.14825660f, 
    0.13853037f, 0.10077789f, 0.03606907f, 0.14183050f, -0.01747787f, -0.03516027f, 0.03083052f, 0.01447672f, 
    -0.10152407f, -0.00020975f, 0.00560010f, 0.01137779f, -0.10482233f, 0.00921222f, 0.03532001f, -0.00624431f, 
    -0.14741744f, -0.04779441f, -0.00635549f, 0.08082858f, 0.09086757f, 0.03696167f, -0.13476869f, -0.06552109f, 
    0.34804583f, 0.01167475f, -0.13695280f, 0.18501860f, 0.14238691f, 0.01296540f, -0.16786906f, 0.07186758f, 
    0.01702357f, 0.03599502f, 0.04337153f, 0.12744372f, -0.47558233f, 0.11272008f, -0.14638464f, -0.25764534f, 
    -0.03444380f, -0.06737323f, 0.07743595f, 0.11996744f, 0.00561626f, -0.11279518f, 0.03355106f, -0.07909890f, 
    0.15493904f, -0.00814083f, 0.12938656f, -0.10476836f, 0.18011318f, 0.19402532f, -0.17611876f, -0.08102027f, 
    -0.16907668f, 0.10990760f, 0.02908533f, 0.10460864f, 0.30581141f, -0.10204000f, -0.02437642f, 0.04047640f, 
    0.11880496f, -0.06652184f, 0.19054055f, -0.20830779f, 0.07787130f, 0.05380077f, -0.06838807f, 0.09053381f, 
    0.00679222f, 0.01432142f, -0.03589284f, -0.03483648f, 0.00248693f, -0.01101233f, -0.02234680f, -0.03645805f, 
    0.03116952f, -0.05166417f, -0.04940089f, -0.01351470f, -0.06147144f, -0.00396142f, -0.04870396f, 0.00175525f, 
    0.01323934f, -0.03396820f, 0.00434041f, 0.00518768f, -0.03277976f, -0.00138538f, -0.05031265f, 0.01360243f, 
    -0.06682430f, -0.00170700f, -0.05719784f, -0.06676628f, -0.05303530f, 0.02216310f, 0.00282863f, -0.01837749f, 
    0.00929811f, -0.05745460f, -0.07615332f, -0.03457874f, 0.01315869f, -0.02700499f, -0.05365417f, -0.04384038f, 
    -0.03926571f, -0.02030546f, 0.01386280f, 0.02309119f, -0.01218997f, 0.02698511f, -0.00029494f, -0.00592597f, 
    0.00160264f, 0.01423732f, 0.01166836f, 0.00197461f, -0.02805532f, 0.00942772f, 0.00931996f, 0.01147682f, 
    0.00514124f, 0.00638026f, -0.06440525f, -0.06314678f, 0.01231998f, -0.01218545f, 0.05931368f, 0.01296739f, 
    0.02190960f, -0.05216774f, 0.01632251f, 0.03668236f, -0.06173917f, -0.04282219f, -0.01089347f, -0.00092226f, 
    -0.03166801f, 0.00069155f, -0.07373454f, -0.03529874f, 0.00563888f, -0.02423452f, 0.03970113f, 0.02048519f, 
    -0.05844664f, -0.02766996f, -0.06447806f, -0.00925932f, -0.00887336f, 0.03380026f, 0.00661672f, -0.06707939f, 
    0.01733399f, -0.03011302f, -0.05077444f, -0.02138307f, -0.06206323f, 0.01337607f, -0.01661011f, -0.08103109f, 
    -0.06979431f, -0.01814206f, 0.01844654f, -0.01084363f, 0.00226730f, -0.02079443f, -0.01342966f, -0.06754898f, 
    -0.07268048f, -0.02716914f, -0.01872125f, -0.06874359f, -0.05973627f, 0.02172223f, -0.02487681f, -0.04610759f, 
    -0.05801482f, -0.06152543f, -0.00342134f, -0.08849055f, -0.01179140f, 0.00837491f, -0.04686191f, 0.02142023f, 
    0.01174608f, -0.06993326f, 0.00816685f, -0.00273089f, -0.03559314f, -0.05173557f, -0.07687978f, -0.05470467f, 
    -0.04069968f, 0.01487737f, 0.02413934f, -0.02658181f, -0.06090540f, -0.03502341f, -0.01644615f, -0.04136166f, 
    -0.00288939f, -0.04593881f, 0.00023466f, -0.03826409f, -0.00001033f, 0.01050543f, -0.04248715f, -0.04102036f, 
    0.04054613f, -0.04788439f, 0.00417051f, -0.00630993f, 0.03382620f, -0.04246144f, -0.01870044f, -0.02750100f, 
    -0.02566372f, -0.00620930f, 0.03011125f, -0.00421893f, -0.03196944f, 0.02590725f, 0.02205691f, -0.03220877f, 
    -0.04787743f, -0.02997623f, 0.00903516f, 0.03710191f, -0.02304161f, -0.01586011f, -0.05665277f, -0.05409830f, 
    -0.02306586f, -0.01049968f, 0.04158355f, 0.03718458f, 0.01773701f, 0.03494405f, 0.02722206f, -0.03448448f, 
    0.00078701f, -0.05750041f, 0.00151564f, -0.04857667f, -0.03265073f, -0.05183727f, -0.01460208f, -0.00337415f, 
    -0.00670872f, 0.00507608f, 0.02410313f, -0.01771745f, -0.01422025f, -0.04051482f, -0.01937866f, -0.00063665f, 
    -0.01941787f, 0.03093212f, -0.06253775f, -0.03151640f, -0.02246871f, -0.00241436f, -0.04625139f, -0.07179901f, 
    -0.06260902f, -0.06813102f, -0.03877443f, -0.06434775f, -0.03535593f, 0.01778836f, 0.00187516f, 0.01791366f, 
    0.01628241f, -0.01638196f, -0.01834983f, 0.00452051f, -0.08100840f, -0.08341394f, 0.01392448f, -0.02722181f, 
    -0.06239084f, 0.00051492f, 0.02701486f, 0.00952067f, -0.02286270f, -0.03242935f, -0.06276143f, -0.02545652f, 
    -0.04882965f, -0.05339019f, -0.05620676f, -0.04275095f, 0.00541159f, 0.01668518f, -0.04802379f, -0.04597031f, 
    0.03662724f, 0.03360674f, 0.01085050f, 0.04272046f, -0.02728036f, 0.02666667f, 0.01002154f, 0.04127392f, 
    -0.01565039f, 0.00284169f, -0.00465530f, 0.03064224f, -0.02135093f, 0.02276067f, 0.02009430f, -0.03228131f, 
    -0.01157770f, -0.04542085f, 0.02457700f, 0.00204657f, -0.00052365f, 0.01111821f, 0.04810840f, -0.02474264f, 
    0.00864535f, 0.00092617f, -0.02346494f, -0.04789082f, -0.01564835f, -0.02238348f, -0.00467671f, 0.01250069f, 
    -0.04086407f, -0.04554990f, -0.01327421f, 0.04244890f, -0.00770633f, -0.03968078f, -0.04859705f, -0.05836384f, 
    0.02096454f, 0.01825191f, -0.06490888f, 0.02054984f, 0.02338038f, -0.04817447f, 0.02797294f, -0.01048218f, 
    0.00904338f, -0.02601463f, -0.05896149f, -0.01798234f, 0.00112551f, 0.00390839f, 0.00337398f, -0.00800462f, 
    -0.04347299f, 0.01603371f, 0.02334217f, -0.02508002f, 0.01364201f, -0.04603747f, 0.00130974f, -0.06307173f, 
    -0.02275516f, -0.03785714f, -0.01649827f, 0.00770604f, -0.01087150f, -0.08087859f, -0.06482109f, 0.00529184f, 
    0.00586584f, 0.00261346f, -0.06573206f, 0.00846250f, 0.03066334f, 0.00288861f, -0.00456145f, -0.08518231f, 
    -0.02461798f, 0.03127475f, -0.03807671f, -0.01384850f, 0.04396787f, 0.01763625f, -0.00114654f, -0.00439485f, 
    -0.00355444f, 0.02478468f, -0.02012688f, -0.04115117f, 0.04298678f, 0.03902952f, -0.04402002f, -0.01077603f, 
    0.03040291f, -0.03413577f, -0.00672822f, 0.03329628f, 0.01736550f, -0.02421594f, -0.01699837f, 0.00995176f, 
    -0.07237191f, -0.03443106f, 0.02451731f, 0.01540629f, 0.01500813f, -0.00249222f, -0.00561091f, -0.00827346f, 
    0.00412222f, -0.03915443f, -0.03448841f, 0.01931326f, -0.00803237f, -0.04831539f, -0.00244972f, -0.00879469f, 
    -0.07589094f, -0.04498025f, 0.00405849f, -0.00792757f, -0.02724386f, 0.02847300f, 0.00048762f, -0.02273503f, 
    0.01618719f, 0.00083813f, 0.02255751f, 0.00370176f, -0.02528186f, -0.00336489f, -0.01893054f, -0.02058963f, 
    -0.05171265f, -0.06416428f, 0.01262710f, -0.05867700f, 0.02123725f, -0.04059744f, -0.05654133f, -0.07701597f, 
    -0.06121074f, -0.02334413f, -0.02595068f, -0.06497826f, -0.04566714f, -0.02692540f, -0.05289475f, -0.05595749f, 
    -0.05204768f, -0.22326444f, -0.00280264f, 0.02459369f, -0.00652304f, 0.08748166f, 0.04720802f, -0.11591610f, 
    0.04177276f, -0.03662893f, 0.04440680f, -0.01373155f, -0.07480440f, 0.17530790f, -0.00739065f, 0.10715608f, 
    0.00620228f, -0.06698540f, -0.07375663f, 0.00908553f, 0.08810109f, -0.05612490f, 0.16625562f, 0.01431715f, 
    0.00690971f, 0.02874745f, 0.05228755f, 0.12725885f, -0.01648716f, -0.02820769f, -0.02552249f, 0.03291135f, 
    -0.01144597f, 0.10105278f, 0.01758268f, -0.00419836f, -0.17431937f, 0.07622658f, 0.39033443f, -0.05853264f, 
    -0.01640984f, -0.08432535f, -0.02050115f, -0.06596609f, -0.05761933f, -0.00646761f, -0.01364401f, 0.05531677f, 
    -0.02634911f, -0.10899977f, -0.17013690f, 0.03453627f, -0.08841742f, -0.04094332f, 0.01648912f, 0.16060440f, 
    -0.04654460f, -0.01558205f, 0.04155382f, 0.05876194f, -0.24620956f, -0.21109013f, -0.11645433f, -0.04881542f, 
    -0.00672905f, 0.02145257f, 0.03638570f, -0.01252131f, -0.04954081f, -0.02802092f, 0.13821638f, -0.03845513f, 
    -0.16528879f, -0.07487033f, -0.08813311f, -0.09384267f, -0.00856164f, 0.00755204f, -0.03181739f, -0.08425020f, 
    0.04235812f, 0.00820731f, 0.14118327f, 0.04206692f, -0.02735171f, 0.40146658f, 0.40706366f, -0.27064410f, 
    -0.01229872f, -0.09736143f, -0.09108059f, 0.10751180f, 0.03438864f, 0.01924154f, 0.00611912f, -0.04518086f, 
    0.23941547f, 0.06099501f, 0.00670893f, 0.13471077f, 0.08409213f, 0.04651643f, 0.01993704f, -0.01459416f, 
    0.04423033f, 0.07678515f, 0.15007047f, 0.22442320f, 0.28708643f, 0.03322272f, 0.11051302f, 0.12430990f, 
    0.00056537f, 0.03473018f, 0.04419224f, 0.02671922f, 0.07314740f, 0.04391289f, -0.10376265f, 0.12326344f, 
    -0.16791597f, -0.04279869f, -0.10106898f, -0.25030500f, 0.29408881f, 0.13495539f, 0.06828032f, 0.16985513f, 
    -0.00888819f, 0.00010598f, -0.00886837f, 0.01155188f, -0.04470672f, 0.03373612f, -0.05014806f, 0.06291370f, 
    0.04329280f, 0.09078167f, 0.02136578f, -0.02432351f, -0.00317319f, 0.03265416f, -0.09936828f, 0.01218382f, 
    -0.16994582f, -0.05164121f, -0.07738020f, -0.00174871f, 0.17182362f, -0.01976712f, -0.03636305f, -0.11419415f, 
    0.22201513f, 0.12611654f, 0.02530729f, 0.19827497f, -0.31765908f, -0.11589592f, 0.05724054f, -0.06141252f, 
    -0.04226796f, -0.01438658f, -0.02299087f, 0.04906204f, -0.00743995f, 0.14467648f, -0.00515039f, 0.04007877f, 
    -0.14559662f, -0.07554618f, -0.11741082f, -0.12619182f, 0.07721017f, 0.11974497f, -0.10227066f, -0.16033913f, 
    0.00749042f, 0.03296164f, 0.07831015f, 0.10704745f, -0.01080011f, -0.07436307f, 0.05492747f, -0.12743185f, 
    0.02530326f, 0.11490391f, -0.00528858f, 0.01263431f, 0.03759719f, 0.01432763f, -0.04628769f, 0.12568921f, 
    0.00707492f, 0.02904688f, -0.15243521f, 0.22229478f, -0.13382696f, 0.18357927f, 0.09168412f, -0.00010233f, 
    0.07820674f, -0.00917935f, -0.09424880f, -0.09242769f, -0.08652134f, 0.12277265f, -0.04398921f, 0.04428729f, 
    -0.04546050f, 0.05202439f, 0.09130944f, -0.00771537f, 0.09342538f, -0.02236533f, -0.05183868f, -0.01937888f, 
    -0.06241646f, -0.07369976f, -0.04072771f, 0.10817203f, 0.03249208f, 0.06838217f, 0.06213581f, 0.08751432f, 
    0.04921103f, 0.00041059f, 0.02888048f, -0.01084854f, -0.04456929f, -0.00131542f, 0.07101078f, 0.01685169f, 
    -0.10476451f, -0.06753866f, -0.10779019f, -0.07580782f, -0.05783603f, -0.00928076f, 0.04406450f, -0.09112358f, 
    -0.28445131f, -0.09057663f, 0.13253060f, 0.03018248f, -0.08649654f, 0.13594371f, 0.05652383f, -0.00899013f, 
    0.06642380f, -0.00125412f, -0.12661342f, 0.07210394f, 0.15626198f, 0.07424610f, -0.05278312f, 0.10835962f, 
    0.05866577f, 0.05352834f, 0.18973598f, 0.03969861f, -0.05019207f, 0.13738622f, 0.13199666f, 0.06282917f, 
    0.34613094f, 0.22610277f, 0.07199971f, -0.09323957f, 0.10367016f, -0.00014361f, -0.09725015f, 0.08616867f, 
    -0.01301814f, 0.17700051f, -0.06195477f, -0.01949711f, -0.02462571f, 0.42525637f, -0.08290906f, 0.06198151f, 
    -0.00430912f, 0.03269225f, -0.04469195f, 0.11021111f, 0.03516363f, 0.04779152f, 0.02300047f, 0.08131870f, 
    0.04476722f, 0.02384051f, -0.08323269f, 0.05095072f, -0.05841089f, 0.15682459f, 0.07859772f, 0.16334704f, 
    -0.08448656f, -0.09080315f, 0.17969859f, 0.13090211f, 0.28409740f, 0.15898800f, 0.21796544f, 0.13771047f, 
    -0.02879025f, 0.02572477f, 0.01764354f, 0.00133435f, -0.00293470f, 0.09182425f, -0.00829585f, 0.01207778f, 
    -0.22740057f, -0.06538032f, 0.00704482f, 0.06564149f, -0.12539452f, -0.13297451f, -0.05647925f, -0.08596443f, 
    0.05708372f, 0.08416764f, 0.04361015f, 0.06087679f, -0.31400371f, -0.18468849f, 0.07921863f, 0.00085665f, 
    -0.11093143f, 0.02003323f, -0.02915815f, 0.01338222f, 0.09076761f, 0.08261473f, 0.02842189f, -0.01154005f, 
    -0.30991215f, 0.40752193f, -0.09044931f, 0.16991073f, -0.06636586f, -0.09290914f, -0.03480360f, -0.08343809f, 
    0.11941861f, 0.11252366f, 0.06342141f, 0.01115446f, -0.06912902f, 0.05464834f, -0.08716817f, -0.06356406f, 
    0.19972038f, 0.09123486f, 0.10099152f, -0.05040884f, 0.10553260f, -0.11514839f, 0.04648464f, 0.05922711f, 
    0.13565102f, -0.05826199f, -0.02319259f, 0.02674320f, 0.01137785f, 0.13433169f, 0.03829269f, 0.03970672f, 
    -0.01319254f, -0.05841010f, -0.10954344f, -0.13132864f, -0.16779636f, 0.01141567f, -0.03073852f, 0.40615314f, 
    0.02920621f, 0.00120262f, -0.07465738f, -0.05015722f, -0.00780286f, 0.09568125f, -0.00980651f, 0.28398272f, 
    0.02526172f, -0.03142467f, 0.00131102f, -0.00276681f, 0.00195665f, -0.04919377f, -0.02919894f, -0.01394276f, 
    -0.01151394f, -0.02425572f, -0.04386484f, -0.02899036f, 0.03033106f, -0.05071729f, 0.04105037f, -0.05334253f, 
    0.01006550f, -0.03907272f, 0.03939761f, -0.03279930f, 0.02438295f, -0.03223584f, 0.03520648f, -0.03053512f, 
    -0.02183073f, -0.02583868f, 0.03261082f, -0.01844820f, -0.01320504f, 0.00987229f, 0.01177679f, -0.02296563f, 
    -0.02161295f, 0.02698945f, -0.03491385f, 0.00228282f, -0.04458743f, 0.01808760f, -0.03602438f, 0.01220448f, 
    -0.00785350f, -0.00398783f, -0.00449105f, 0.02205093f, -0.01677508f, -0.01834154f, -0.02671974f, -0.00779399f, 
    -0.02109784f, 0.02526576f, -0.04812897f, -0.01452476f, 0.03430403f, -0.04697547f, -0.03038289f, 0.04134347f, 
    0.00586103f, -0.03236330f, 0.05138940f, -0.01576744f, -0.01231075f, -0.04179692f, 0.00482451f, -0.01481902f, 
    -0.03127454f, -0.00728157f, 0.01551182f, -0.03592424f, -0.04900707f, -0.04307383f, -0.00040074f, -0.00636748f, 
    -0.04835255f, -0.04093594f, -0.02545879f, 0.04154341f, 0.00691249f, -0.02534269f, -0.04542488f, 0.03803607f, 
    0.03765450f, 0.02572351f, -0.03302985f, -0.01007661f, -0.03837065f, 0.02753231f, 0.03748964f, -0.00594633f, 
    -0.03115839f, -0.04947113f, 0.02424658f, -0.03253669f, -0.04494314f, -0.01104663f, -0.03563773f, -0.02477819f, 
    -0.04624114f, -0.05268971f, -0.05198371f, -0.03857890f, 0.03649186f, 0.01599939f, -0.02349636f, -0.02029156f, 
    -0.03001283f, 0.04662986f, -0.00552345f, -0.01581272f, -0.00739777f, 0.03621889f, -0.02652927f, 0.04263849f, 
    -0.04808919f, -0.02822312f, 0.00095347f, 0.02355570f, 0.01977865f, -0.01024248f, -0.01334611f, -0.00626725f, 
    -0.03257280f, -0.01444015f, -0.04506250f, -0.00189647f, -0.00837244f, 0.02202310f, 0.04110568f, -0.00173971f, 
    -0.00274570f, -0.02172627f, -0.01417792f, -0.04170329f, 0.04019092f, 0.02745788f, -0.04608626f, -0.04410490f, 
    -0.05319980f, -0.02061033f, -0.01768136f, -0.02532656f, -0.00800695f, -0.04250357f, 0.02694966f, -0.04809113f, 
    -0.02879016f, 0.02080603f, -0.04278735f, -0.04947352f, 0.03917809f, -0.02880087f, 0.04636886f, 0.00394531f, 
    -0.01692702f, 0.01919969f, 0.03767173f, 0.01066826f, -0.03159122f, -0.05014083f, -0.00896165f, -0.04677761f, 
    -0.02059422f, 0.04623338f, -0.00131854f, 0.04761862f, -0.04138661f, -0.02434143f, -0.02000892f, 0.00320230f, 
    -0.01168206f, 0.03271870f, -0.00189325f, -0.02293527f, 0.01020900f, 0.03010871f, 0.01296256f, -0.01140812f, 
    -0.00854599f, -0.04212257f, -0.00753091f, -0.00791281f, 0.04087618f, -0.01431163f, -0.02668175f, 0.00694516f, 
    -0.04595309f, -0.04815612f, -0.01150929f, -0.00052446f, 0.00575551f, -0.04423057f, 0.02442209f, 0.00797521f, 
    0.04267203f, 0.00644072f, 0.03896138f, -0.01430203f, 0.00490635f, 0.00913857f, 0.01647869f, -0.03840016f, 
    -0.01335898f, -0.04030238f, 0.03103644f, 0.04055715f, 0.02468253f, -0.05136295f, -0.02632665f, 0.02596675f, 
    -0.00828008f, 0.00294538f, 0.03970132f, -0.04384639f, -0.04185688f, -0.05390761f, -0.03855962f, 0.00425320f, 
    0.00434354f, 0.01498820f, 0.02445502f, -0.01750302f, 0.00257464f, -0.01939665f, 0.03990325f, 0.01608940f, 
    -0.04109879f, 0.04076204f, -0.02649337f, -0.02108368f, 0.01785617f, 0.00047371f, -0.00868170f, -0.01643392f, 
    -0.03544373f, 0.02638786f, 0.03469942f, 0.03403306f, -0.00639856f, -0.04156670f, 0.00264620f, -0.04676896f, 
    -0.05013277f, -0.02016914f, -0.05269095f, 0.00550919f, 0.04169359f, -0.01043718f, 0.00402941f, 0.03650170f, 
    -0.03362467f, 0.01603222f, -0.04522554f, 0.04231346f, -0.04218702f, 0.03750670f, 0.04100998f, 0.04750043f, 
    0.00907930f, 0.00994318f, -0.00412940f, -0.04893547f, 0.02051095f, -0.03783188f, -0.00330538f, 0.03953913f, 
    -0.04945656f, 0.01046607f, -0.00815384f, -0.02357840f, 0.02113982f, -0.05487419f, 0.02027136f, 0.02934242f, 
    0.03745324f, -0.01984018f, 0.03349598f, 0.02958689f, 0.03996890f, 0.01713989f, -0.01506417f, -0.01694413f, 
    0.03609165f, -0.00868586f, -0.04655309f, -0.03141338f, -0.00134768f, -0.01362103f, 0.03260619f, 0.02699342f, 
    0.01329497f, 0.00600714f, -0.04395930f, 0.00306356f, 0.03787003f, -0.03861840f, -0.04573298f, -0.04817226f, 
    0.04446931f, -0.04660989f, 0.02157980f, -0.04656163f, 0.02782714f, -0.01765475f, 0.03792511f, 0.03317547f, 
    -0.00396956f, 0.00903661f, -0.01840031f, 0.01427413f, 0.03257637f, -0.01870335f, 0.00979393f, -0.00657852f, 
    0.04027141f, -0.01929220f, 0.01316488f, 0.01855223f, 0.04729867f, -0.00096768f, -0.01771262f, -0.01364354f, 
    -0.03072164f, 0.04575126f, -0.01233329f, -0.01811954f, -0.04919658f, 0.04300328f, -0.03646551f, 0.01095481f, 
    -0.04738616f, -0.04266009f, -0.02330293f, 0.03962060f, -0.04844891f, -0.04916877f, 0.00658117f, 0.02080244f, 
    -0.00471663f, -0.02578630f, 0.01365667f, 0.02946161f, -0.00605110f, -0.04597943f, -0.02227214f, 0.03845844f, 
    -0.03211235f, 0.04008391f, 0.00295083f, 0.02279321f, 0.00015109f, 0.03491395f, -0.00320602f, 0.04227518f, 
    0.03716573f, 0.03125506f, -0.03817168f, -0.04839106f, 0.00453916f, -0.03299916f, -0.01458195f, 0.02290557f, 
    -0.02238536f, 0.03632241f, -0.00436000f, 0.02884475f, 0.02421578f, 0.03926935f, 0.02221524f, -0.04727032f, 
    -0.05434509f, 0.00352717f, -0.03943080f, -0.01960898f, 0.03316652f, -0.02427778f, -0.05087972f, 0.00017326f, 
    0.04732519f, 0.01203063f, 0.04164098f, -0.01185568f, -0.01613747f, 0.03697536f, -0.03404611f, -0.01735582f, 
    0.04439082f, 0.09159910f, -0.06978702f, -0.03148990f, 0.01254590f, 0.08400971f, 0.05025698f, 0.07613987f, 
    0.25895625f, 0.21030891f, 0.15564977f, 0.06712832f, 0.12423024f, -0.07366230f, 0.02286645f, -0.18832271f, 
    0.06914936f, -0.05578725f, -0.01259455f, 0.19478427f, 0.02238857f, 0.24892165f, -0.01447850f, -0.01438258f, 
    0.01420238f, -0.02864671f, -0.04162428f, 0.02301358f, -0.12401313f, 0.06860404f, 0.00471477f, -0.01161272f, 
    -0.01094213f, 0.13359119f, 0.20745225f, -0.01820647f, -0.31703761f, 0.19097321f, -0.01132415f, 0.26830277f, 
    0.19422743f, 0.25898069f, -0.01398000f, -0.02364587f, -0.04219758f, -0.27620381f, -0.09505769f, -0.13568316f, 
    0.35018039f, 0.28499711f, -0.21898685f, 0.15750423f, -0.21600710f, -0.05836552f, -0.05131646f, -0.10916749f, 
    0.13917522f, 0.01278080f, -0.08395697f, 0.08860993f, 0.23795098f, 0.17772438f, 0.47339866f, 0.35929802f, 
    -0.02963595f, -0.12948613f, 0.01530504f, -0.00399837f, 0.16672587f, 0.15610181f, 0.06708584f, 0.28098178f, 
    0.25934801f, -0.18426017f, -0.03297269f, -0.05030238f, -0.26220328f, -0.08160704f, 0.03013278f, -0.01004860f, 
    0.21656889f, 0.09478489f, 0.08837524f, 0.17358929f, 0.42996526f, 0.26503283f, -0.23415706f, 0.16932614f, 
    -0.20066679f, -0.10594598f, -0.01388760f, 0.03902197f, 0.16633412f, 0.12362374f, 0.17310071f, 0.26938432f, 
    -0.16198549f, -0.02350248f, -0.00106751f, -0.04266964f, 0.05562760f, -0.01664941f, -0.16199724f, -0.09489249f, 
    -0.02200804f, 0.00659297f, -0.15077910f, -0.15393125f, 0.14998853f, 0.06840768f, -0.01315519f, -0.08249211f, 
    0.14723876f, -0.00334029f, 0.08839490f, 0.14138421f, -0.00768903f, 0.11626093f, 0.21202050f, -0.11189689f, 
    0.35643703f, 0.12627919f, -0.14952168f, -0.29237273f, -0.12165983f, 0.06137438f, -0.11196497f, -0.02564060f, 
    -0.10962278f, -0.12646036f, -0.11894105f, -0.32007891f, 0.08381668f, -0.00690488f, -0.00422093f, -0.09384471f, 
    0.11783656f, -0.08586896f, 0.16323520f, 0.00939849f, -0.03127534f, -0.00126224f, 0.13057558f, 0.02571759f, 
    -0.12954177f, -0.05388093f, -0.00179034f, -0.05745758f, 0.09669538f, -0.08990990f, -0.11887491f, 0.06496336f, 
    -0.45802796f, -0.40078014f, -0.41093391f, -0.52242184f, 0.36066326f, 0.16371451f, 0.32252985f, 0.20732604f, 
    -0.15574896f, -0.07907106f, -0.01963264f, 0.02088187f, 0.08513528f, -0.08024678f, -0.09543901f, 0.06705438f, 
    -0.23826376f, -0.02079724f, 0.31736037f, 0.07330754f, 0.24397217f, 0.03888641f, 0.03945034f, 0.00158200f, 
    -0.48384017f, -0.44780734f, -0.32547730f, -0.55356193f, 0.02307568f, 0.33800358f, 0.01605928f, 0.05946755f, 
    0.12932265f, 0.05071310f, 0.02335675f, 0.10410733f, 0.01145492f, -0.13133676f, -0.07300010f, -0.15788692f, 
    -0.32883573f, 0.02479858f, -0.01609842f, -0.08538280f, 0.16249292f, -0.10596854f, 0.23674130f, 0.07181250f, 
    0.28089020f, -0.13527244f, -0.20180413f, 0.11679696f, 0.25653094f, -0.04444545f, 0.06610747f, 0.06962853f, 
    -0.17587772f, 0.08140866f, 0.05372412f, 0.00104651f, 0.09595193f, -0.01675337f, 0.20495681f, 0.21090071f, 
    0.07025769f, 0.16420761f, -0.29833245f, -0.08905039f, 0.06644306f, 0.00840666f, 0.12993447f, -0.14136818f, 
    0.01909305f, -0.08092024f, -0.17004217f, -0.25508758f, -0.16965272f, -0.02184478f, -0.27326420f, -0.04633481f, 
    0.26499084f, -0.01145933f, -0.11830490f, 0.01864186f, -0.18566769f, 0.03021166f, 0.05057399f, 0.24776618f, 
    -0.09779107f, 0.04312868f, -0.09159085f, 0.18157557f, 0.07863455f, -0.07942791f, -0.01618796f, 0.03528684f, 
    0.07600912f, -0.23325661f, 0.03347128f, -0.06636897f, 0.08678923f, 0.01545399f, -0.04817348f, 0.02846978f, 
    0.03476810f, 0.00229989f, 0.01592995f, 0.05703536f, 0.03077816f, -0.03399669f, -0.12856783f, -0.01431897f, 
    0.17085138f, -0.27081141f, 0.18635030f, 0.26323494f, -0.08410864f, 0.13757211f, -0.09211627f, -0.24288608f, 
    -0.03696692f, -0.16025928f, -0.03817436f, 0.12613063f, 0.25499278f, -0.13657135f, 0.33158144f, -0.16966029f, 
    -0.04199918f, -0.01038870f, 0.09875444f, -0.02082053f, 0.09426779f, -0.05445877f, 0.15207243f, -0.06305651f, 
    -0.22406538f, -0.09338053f, -0.19561619f, -0.27346775f, 0.14851770f, 0.04204144f, -0.04577880f, -0.01974541f, 
    0.06527420f, -0.06012749f, -0.17551994f, -0.14288747f, -0.28818363f, 0.05129015f, 0.11859408f, 0.06349251f, 
    -0.02933596f, 0.03149137f, -0.11207648f, -0.09837385f, -0.01978991f, 0.02816271f, 0.00920094f, 0.17544203f, 
    0.01223442f, -0.12265292f, 0.26844400f, -0.12618437f, 0.14615372f, 0.05621817f, -0.20874912f, -0.08848483f, 
    -0.37645537f, -0.50162995f, -0.40712219f, -0.37245446f, 0.45207343f, 0.21500418f, 0.32452768f, 0.22212592f, 
    -0.22043045f, -0.16886257f, -0.02719313f, -0.14647348f, -0.04275884f, -0.08071943f, -0.20900713f, -0.07906080f, 
    -0.18704447f, -0.22862606f, 0.09395745f, -0.15827176f, -0.02236184f, 0.00448836f, 0.01348773f, -0.17893405f, 
    -0.14646941f, -0.20537670f, -0.22228597f, -0.12833104f, 0.28531694f, -0.08770756f, 0.05672858f, -0.17109631f, 
    0.00884242f, 0.07812399f, -0.17149591f, 0.08135417f, -0.01012778f, -0.06375379f, -0.12072691f, -0.06249253f, 
    0.00595046f, -0.01309434f, -0.04989767f, 0.09769372f, -0.06148081f, 0.09683179f, 0.13526572f, 0.01128464f, 
    0.15488864f, 0.13640764f, 0.26434997f, 0.35722366f, -0.08779694f, 0.00613522f, 0.11221699f, -0.14631064f, 
    0.11451145f, -0.06394209f, 0.01133069f, 0.20982711f, -0.01953604f, 0.02263685f, -0.05974741f, -0.19601849f, 
    -0.12861693f, -0.07811334f, 0.05479290f, 0.06685523f, -0.13086620f, 0.09570113f, 0.15513308f, 0.14205746f, 
    0.00122341f, 0.05686849f, 0.06919391f, -0.08765917f, -0.09862321f, 0.35076195f, -0.08303871f, -0.05832172f, 
    0.02684984f, 0.14271040f, 0.06514940f, -0.00492703f, -0.02716332f, -0.04496329f, -0.05043314f, 0.04557060f, 
    -0.02441381f, 0.02853771f, 0.21268934f, 0.00351048f, -0.02381247f, -0.04829117f, -0.02428007f, 0.05940834f, 
    -0.23661575f, 0.09727922f, 0.07256591f, -0.05318011f, 0.17953737f, 0.28900126f, 0.01070396f, -0.20347100f, 
    0.10304618f, -0.14297673f, -0.04107902f, -0.09903679f, -0.12137687f, 0.20982771f, 0.01847006f, -0.02674797f, 
    -0.38844281f, -0.26257068f, 0.21076259f, 0.07718676f, -0.08918408f, -0.02932500f, 0.11846853f, -0.26856613f, 
    0.01039823f, 0.09934629f, -0.08618604f, -0.02485928f, 0.51018125f, -0.04334598f, 0.01183735f, -0.04339507f, 
    0.09214539f, 0.18296698f, -0.02348335f, -0.10220718f, 0.02314878f, 0.09191180f, 0.10642380f, 0.14059959f, 
    0.14349043f, -0.06083536f, 0.03151773f, -0.06419315f, 0.02396625f, -0.06039609f, -0.08982879f, -0.31745261f, 
    -0.05402660f, -0.09092132f, 0.08643949f, -0.02785838f, 0.31680149f, 0.05096278f, 0.00430206f, -0.06238188f, 
    -0.20230353f, 0.33979067f, -0.13225012f, 0.01658753f, -0.00347716f, 0.07180921f, 0.03528706f, 0.18223841f, 
    0.00888575f, -0.14629249f, -0.00153243f, 0.02705105f, -0.06724557f, 0.06591059f, 0.06412971f, -0.27928105f, 
    -0.04968686f, -0.08114661f, -0.00853100f, -0.21466771f, 0.12927227f, -0.12800518f, 0.08758026f, 0.18502188f, 
    0.07756457f, 0.05165115f, 0.11880881f, 0.18238287f, -0.03822188f, 0.18583335f, -0.01163908f, -0.04448081f, 
    0.00404453f, 0.01973664f, -0.09219684f, -0.18105280f, -0.09586227f, -0.04768033f, -0.01571537f, 0.12377255f, 
    -0.06946743f, -0.12876545f, -0.10630329f, -0.29841688f, -0.32460526f, -0.06992508f, -0.14285736f, 0.15319572f, 
    0.01185389f, 0.03858549f, 0.06481070f, 0.12323522f, -0.02780908f, 0.21724774f, -0.09616365f, -0.17499845f, 
    -0.12790918f, 0.01092772f, 0.00797183f, -0.08395690f, -0.03964728f, 0.04947172f, -0.08040417f, 0.10766076f, 
    -0.01718310f, -0.17790787f, -0.07022379f, -0.12150083f, 0.16996978f, 0.03402399f, 0.00065118f, 0.01221482f, 
    0.10404082f, -0.20133460f, 0.06605458f, -0.16777499f, 0.04508640f, -0.04985384f, -0.02073408f, 0.00423836f, 
    0.15542455f, 0.13664797f, 0.26194146f, 0.19032720f, 0.00064204f, -0.02717264f, -0.07262392f, -0.14856017f, 
    -0.24127907f, -0.08717466f, 0.01049438f, -0.26989698f, -0.12175079f, -0.07267299f, 0.06246115f, 0.10438947f, 
    -0.06976686f, -0.00788674f, 0.08619838f, 0.09959534f, -0.13999274f, 0.12037462f, -0.16871907f, -0.03706651f, 
    -0.09609351f, 0.12090135f, -0.08450922f, 0.00236754f, -0.11686204f, 0.12022166f, 0.05211088f, 0.08223931f, 
    0.04337557f, -0.15164393f, 0.08269931f, -0.04330942f, 0.20815653f, -0.14953917f, 0.05381806f, 0.12230597f, 
    0.07043861f, -0.01179070f, 0.06015554f, -0.04835635f, -0.02640124f, 0.05852117f, 0.21780603f, 0.08950718f, 
    -0.06043319f, 0.07054694f, 0.04595509f, 0.16704939f, 0.00841806f, 0.10071364f, 0.12864712f, -0.03427040f, 
    -0.05740728f, 0.09258813f, -0.03752074f, -0.02738436f, 0.08974423f, 0.15966758f, -0.12714195f, -0.28758520f, 
    0.03913125f, -0.11767112f, -0.06732379f, 0.05539260f, -0.01186336f, 0.05196706f, 0.00654720f, 0.06132400f, 
    0.19141884f, 0.10743629f, -0.12775396f, 0.03538366f, -0.05272990f, 0.20740300f, -0.11141501f, 0.30862975f, 
    0.00429500f, 0.06298102f, -0.13612060f, -0.14279985f, 0.16385932f, -0.14641260f, 0.00179866f, 0.08273515f, 
    0.05268744f, 0.16832921f, 0.02490542f, 0.17881069f, -0.03108447f, 0.06769798f, 0.12674302f, -0.07265278f, 
    0.35045588f, -0.07704009f, 0.34366754f, -0.00215982f, -0.07345936f, 0.03921269f, -0.05767441f, -0.19536453f, 
    -0.08037463f, -0.03128523f, -0.06253141f, -0.01798135f, -0.03232858f, 0.30012438f, -0.23392379f, 0.05286313f, 
    -0.02297162f, 0.15449080f, -0.17948405f, 0.00655387f, 0.03467021f, -0.04054458f, 0.07940122f, 0.15757136f, 
    -0.07789977f, -0.06494944f, 0.13958080f, -0.17855275f, -0.07403465f, -0.04699654f, 0.10264706f, -0.07740302f, 
    -0.13730429f, 0.05375657f, -0.17049249f, -0.17899756f, 0.01700906f, -0.07749379f, 0.13592216f, 0.05937226f, 
    -0.06042767f, -0.06878991f, -0.11687846f, -0.07479362f, 0.01542059f, 0.02398641f, -0.01522043f, -0.07932600f, 
    0.11390766f, 0.05465396f, 0.02742103f, -0.21530880f, 0.08784918f, -0.13010007f, -0.11394989f, -0.16276154f, 
    -0.32646477f, -0.00911770f, -0.04780627f, -0.22357187f, 0.12707499f, -0.25238127f, -0.03934551f, -0.20829682f, 
    0.11154248f, -0.04016665f, -0.02679163f, 0.05762680f, -0.02614320f, 0.06728762f, -0.04500900f, 0.02906526f, 
    -0.09564059f, 0.17693898f, 0.12844537f, 0.06019838f, -0.12111999f, 0.09530199f, 0.00186032f, -0.04101550f, 
    -0.34881565f, 0.01301507f, -0.09108422f, -0.01568736f, 0.11202334f, 0.08058775f, -0.08879444f, 0.14827265f, 
    -0.04829374f, -0.01744841f, -0.11235473f, 0.09077913f, -0.10265071f, 0.02052979f, 0.07110129f, -0.12320209f, 
    0.07058983f, -0.01186860f, -0.07364748f, 0.18817836f, -0.08528613f, 0.00038403f, 0.10482679f, 0.02619121f, 
    -0.03483000f, 0.10946085f, 0.15707377f, 0.08204652f, -0.12063705f, 0.37619063f, 0.11070152f, 0.07409403f, 
    -0.11020358f, -0.08302758f, 0.06840708f, 0.08095880f, 0.07590152f, 0.02735686f, -0.09984671f, -0.02205640f, 
    0.44963491f, 0.29778516f, 0.18965331f, -0.08414161f, -0.05736052f, -0.14764243f, 0.01342894f, 0.20824912f, 
    -0.02257704f, 0.13709509f, 0.00436814f, 0.07922124f, 0.14008726f, -0.34756076f, 0.05262507f, -0.02819745f, 
    -0.03308355f, -0.01922986f, 0.05506876f, -0.09908959f, -0.03109440f, -0.05137240f, -0.02716286f, 0.10017108f, 
    -0.23138641f, -0.14328197f, -0.05847878f, 0.03241084f, 0.03174448f, 0.05277315f, -0.02049435f, -0.04750627f, 
    0.09617891f, 0.04050507f, -0.02140507f, -0.01254425f, 0.09303765f, 0.09647667f, -0.29230729f, -0.03533366f, 
    0.18102197f, 0.01909605f, 0.02993694f, -0.01169656f, 0.09138937f, -0.00470849f, -0.02650535f, -0.07375693f, 
    -0.08872347f, -0.19132917f, 0.27931094f, -0.31024694f, -0.05874411f, -0.00514532f, -0.00783557f, 0.01295808f, 
    -0.02275492f, 0.03677138f, -0.13478179f, -0.16963945f, 0.24997216f, 0.15345679f, -0.10074531f, -0.08814309f, 
    0.01574910f, 0.07642515f, 0.09390809f, -0.04583526f, 0.02227078f, 0.04724816f, -0.04160647f, 0.21136411f, 
    -0.06561561f, -0.10524703f, -0.01555589f, 0.03485300f, 0.04959176f, -0.08428440f, 0.04445298f, 0.02979816f, 
    0.07004704f, 0.00177023f, 0.05499546f, 0.02431773f, -0.43299893f, -0.18721119f, -0.13469122f, 0.38961798f, 
    -0.01501456f, 0.11127681f, -0.12182886f, -0.08231951f, 0.00373334f, 0.10611497f, 0.06671111f, 0.19810151f, 
    -0.38030300f, -0.34010914f, -0.03078275f, -0.11710946f, -0.03702076f, -0.03883876f, -0.10761138f, -0.05662801f, 
    -0.04030810f, -0.10507495f, -0.07447999f, -0.16979516f, 0.06361155f, 0.01230951f, 0.03687292f, -0.07746438f, 
    0.00998689f, -0.11937764f, -0.01082552f, -0.01830913f, -0.04995535f, 0.03091211f, 0.09702994f, -0.07640520f, 
    0.26030397f, 0.25942671f, 0.18227008f, 0.22903608f, -0.23248452f, -0.19846678f, 0.02173042f, -0.25873217f, 
    0.05951992f, -0.01195087f, -0.05850798f, -0.12723060f, 0.26856598f, 0.15448827f, 0.17909390f, -0.12676595f, 
    0.01178554f, -0.01153524f, 0.03565001f, 0.06948018f, -0.02478942f, 0.03300489f, 0.13138132f, 0.07006366f, 
    0.04823579f, -0.10064282f, 0.06319965f, -0.01963920f, 0.13238144f, 0.10820836f, -0.12489928f, 0.12611566f, 
    -0.13948591f, -0.25399122f, -0.00999195f, -0.26494855f, 0.27107269f, 0.37827468f, 0.06611402f, 0.16845664f, 
    0.07096930f, 0.04153093f, -0.10439547f, -0.05808891f, 0.03767065f, -0.07442550f, 0.10213652f, -0.01053645f, 
    0.14564726f, -0.05496499f, 0.04319031f, 0.00328117f, 0.05447737f, -0.04823135f, -0.01433883f, 0.07486785f, 
    0.02749902f, -0.13337518f, -0.10011990f, -0.19816245f, 0.07417925f, 0.30743292f, -0.20964311f, 0.12346305f, 
    -0.16085871f, -0.03652810f, 0.03755908f, 0.07542531f, -0.07446384f, -0.03802993f, 0.00956546f, -0.06341990f, 
    0.14702564f, -0.07240574f, 0.11257184f, -0.20059137f, 0.00002938f, -0.01456619f, -0.11929765f, 0.07640321f, 
    0.05694728f, -0.11227419f, 0.10678471f, 0.17090264f, 0.30431309f, -0.01023342f, -0.10963336f, 0.11116900f, 
    0.10657743f, 0.12271518f, -0.08800732f, -0.06750904f, -0.00589454f, -0.15372300f, 0.03219694f, 0.05865513f, 
    0.13497466f, 0.17573966f, -0.00425342f, 0.03431521f, 0.06961836f, 0.03467308f, -0.11496264f, -0.00220967f, 
    -0.17480777f, -0.05861948f, -0.08638659f, 0.00616640f, 0.01733814f, -0.18889819f, -0.08551633f, 0.03102763f, 
    0.20655248f, 0.19310364f, 0.06705537f, -0.05723894f, 0.06341890f, 0.03974468f, 0.02858751f, 0.20856923f, 
    0.23059127f, -0.01595318f, -0.24145970f, 0.05106130f, 0.19498923f, 0.13172781f, -0.06281054f, 0.09277247f, 
    0.05154986f, 0.05488003f, -0.10676385f, -0.01117330f, 0.32757515f, 0.12461732f, -0.06448980f, -0.02883467f, 
    0.00592425f, 0.14528847f, -0.07015939f, -0.00097423f, -0.04061595f, -0.06265982f, -0.02164458f, -0.07928935f, 
    -0.04729613f, 0.00494097f, 0.28275472f, -0.13344598f, 0.04365560f, -0.00903528f, -0.06688321f, -0.16891015f, 
    -0.04165329f, -0.10950294f, 0.10052746f, -0.00846476f, -0.03563838f, -0.32861283f, -0.11979961f, -0.04559510f, 
    -0.07293367f, 0.09321408f, -0.12178560f, -0.01185758f, 0.12087005f, 0.06639127f, -0.11203046f, -0.04626617f, 
    -0.02094134f, -0.03936190f, -0.07505977f, -0.22594696f, 0.03688883f, -0.03891808f, -0.01526033f, -0.20075631f, 
    0.00640227f, 0.02518958f, -0.25412285f, -0.14974417f, -0.11484777f, -0.23331012f, -0.17753610f, -0.04223472f, 
    0.11158703f, -0.04485752f, -0.07549486f, -0.15409884f, -0.01495296f, -0.09676311f, 0.03277345f, 0.05872525f, 
    0.06781773f, -0.03769055f, 0.00874226f, 0.07445367f, 0.16406116f, 0.08446863f, -0.02718312f, 0.10868534f, 
    -0.14592923f, -0.01167891f, -0.10194102f, -0.14522319f, 0.23279585f, 0.10214334f, 0.04428487f, 0.01805301f, 
    0.06348872f, -0.00035326f, 0.02458119f, 0.01420051f, -0.04126397f, -0.07995295f, -0.13066876f, 0.04911349f, 
    0.48830193f, -0.35808557f, -0.11902644f, -0.03652545f, 0.03524344f, -0.04892804f, -0.02911856f, -0.08067675f, 
    -0.17454062f, -0.06426588f, -0.08879722f, 0.03738919f, 0.32989568f, 0.06201032f, 0.30485389f, -0.01652216f, 
    -0.05123899f, -0.10446339f, -0.00203626f, 0.03648839f, -0.04444874f, -0.08847032f, -0.02050976f, -0.17834052f, 
    0.01088049f, 0.15612587f, 0.16725314f, 0.11057404f, 0.07266390f, 0.07243800f, -0.06176686f, 0.03087788f, 
    0.01440525f, 0.15500611f, 0.17120159f, 0.22318517f, 0.01494673f, -0.32151309f, -0.12130724f, -0.37312818f, 
    -0.08452936f, -0.09757170f, 0.17029220f, -0.04541729f, -0.02786966f, -0.02738502f, -0.11607911f, -0.07157857f, 
    0.07592984f, 0.05966726f, -0.10164632f, -0.03517194f, -0.06402557f, 0.04751373f, 0.07228611f, 0.19076040f, 
    -0.09981911f, -0.01757658f, -0.06505355f, -0.10788312f, 0.09525019f, -0.00387889f, -0.02430229f, -0.00161100f, 
    -0.04668497f, -0.12089626f, -0.08877616f, -0.02018817f, -0.05874229f, 0.10910099f, 0.00846248f, -0.10665444f, 
    0.01539741f, 0.01016172f, 0.10808659f, 0.06562450f, 0.00734649f, -0.04617536f, -0.03275281f, -0.02926829f, 
    0.07478586f, -0.05269079f, 0.08501662f, 0.09973601f, 0.11307414f, 0.15459625f, 0.06782601f, -0.06672563f, 
    0.03767062f, -0.07269773f, 0.05843137f, -0.06376895f, -0.05853669f, -0.13583180f, -0.05113100f, 0.03237122f, 
    -0.17355312f, -0.02531051f, 0.05616440f, -0.09487063f, -0.01697143f, -0.06365689f, -0.04839704f, 0.02474182f, 
    -0.10684567f, 0.12632871f, -0.06479679f, -0.06148832f, 0.28159112f, -0.07185104f, -0.18024056f, -0.19831839f, 
    -0.05211608f, -0.13924584f, -0.21024397f, -0.05033427f, 0.27833146f, -0.08449319f, 0.05464754f, 0.06610708f, 
    0.08537955f, 0.17452201f, 0.05881393f, 0.08235008f, -0.08452585f, 0.00572355f, -0.02909238f, 0.00653805f, 
    -0.26151085f, -0.13633609f, -0.17559221f, -0.17695937f, 0.14620422f, 0.06178093f, 0.16646154f, 0.22798824f, 
    -0.08941728f, -0.00287276f, -0.02379672f, 0.00282690f, -0.15342210f, -0.12614915f, -0.03745766f, -0.21033141f, 
    -0.00283324f, -0.07467699f, 0.04740123f, 0.01864015f, -0.00955624f, -0.00692866f, -0.00269023f, -0.12803262f, 
    -0.14982647f, 0.11007851f, -0.05241120f, 0.13311945f, -0.40198264f, -0.31330431f, -0.36961654f, -0.03210549f, 
    0.04731209f, -0.08005183f, -0.01182097f, -0.12060143f, -0.13654394f, -0.13469319f, -0.05481286f, -0.09567184f, 
    0.03431603f, 0.00549760f, -0.09624080f, -0.24981180f, 0.06662178f, -0.07930090f, -0.05759284f, -0.00982781f, 
    -0.02504060f, -0.00073162f, -0.07940835f, -0.02056552f, -0.02904536f, -0.29183149f, -0.36184952f, -0.17688827f, 
    0.05019414f, -0.08968500f, 0.17213349f, 0.27006540f, -0.02167843f, -0.00478314f, -0.02701809f, -0.02160166f, 
    -0.01636552f, -0.01789736f, -0.04304134f, 0.02665278f, -0.01744828f, 0.17599817f, -0.15006733f, -0.04235189f, 
    -0.02894558f, -0.07997359f, 0.02809790f, 0.02010769f, 0.23159344f, -0.14134559f, 0.06653271f, -0.00416269f, 
    -0.03134303f, 0.02233800f, -0.11812871f, -0.07345160f, -0.05462240f, -0.16433649f, -0.05204921f, -0.01209404f, 
    -0.03060091f, 0.01708825f, 0.05617196f, 0.14042541f, 0.04125451f, -0.04925293f, 0.02951596f, -0.12247277f, 
    -0.08497671f, -0.11614437f, -0.01290394f, -0.03563806f, -0.16373233f, -0.10233507f, -0.38655660f, 0.18703817f, 
    -0.02109102f, 0.09026031f, 0.13844149f, 0.25651005f, -0.08650273f, -0.09454009f, -0.06904924f, -0.15053020f, 
    0.13156147f, -0.02029032f, 0.07840249f, -0.12917422f, 0.02094539f, -0.06944098f, -0.09166783f, 0.15563336f, 
    0.23792535f, 0.03343405f, -0.11419286f, -0.03513957f, -0.02176804f, -0.59217083f, -0.43092629f, -0.35247976f, 
    0.05937572f, -0.01523411f, -0.06522963f, -0.19240747f, 0.16686176f, -0.08141716f, -0.14153005f, 0.01657622f, 
    -0.09618475f, -0.27979314f, -0.13266400f, 0.15238720f, 0.03507351f, 0.09827980f, 0.10901266f, 0.02160267f, 
    0.08444255f, -0.08541805f, -0.08179421f, -0.06282645f, 0.03738382f, 0.06806705f, 0.11346877f, 0.04491843f, 
    0.01263407f, 0.01565490f, -0.05064741f, -0.00932717f, 0.00164494f, -0.00886779f, 0.13083398f, 0.01396709f, 
    0.04926535f, -0.03098504f, -0.04818692f, 0.04364711f, 0.12422415f, -0.09926434f, 0.05237345f, -0.01080146f, 
    -0.06447820f, 0.06550114f, -0.01782754f, 0.00749008f, -0.23856027f, -0.54404020f, -0.41945899f, -0.45429856f, 
    -0.02332597f, 0.02915335f, -0.16647643f, 0.15118526f, -0.03761476f, -0.05109366f, -0.05934920f, 0.07015850f, 
    -0.15825109f, 0.15955043f, 0.14724092f, -0.08673891f, 0.08798390f, -0.04942621f, -0.07103161f, -0.05158498f, 
    0.02202108f, -0.16222917f, -0.02692315f, 0.13723509f, 0.17946613f, -0.05129988f, -0.01920578f, -0.06667468f, 
    -0.05597545f, -0.00775905f, -0.10011943f, -0.14427860f, -0.12591952f, 0.06211544f, -0.14336316f, -0.06599238f, 
    -0.16076581f, -0.07649449f, -0.07526202f, -0.07181103f, 0.03078082f, 0.03706253f, 0.01381191f, 0.00353985f, 
    -0.08341335f, -0.01154410f, -0.10667118f, -0.03560096f, 0.00163089f, 0.21922702f, 0.01359428f, 0.05616855f, 
    -0.02826387f, -0.07225771f, 0.02644724f, -0.11065354f, 0.05142582f, -0.11521021f, -0.05790988f, 0.11221679f, 
    0.04795217f, 0.03338926f, 0.11471725f, 0.02082405f, 0.01325109f, 0.01852041f, -0.03456669f, -0.02193162f, 
    -0.09078564f, -0.10886736f, 0.01194734f, -0.06393357f, 0.16302451f, 0.13826010f, 0.11341243f, -0.04599671f, 
    -0.07990092f, -0.02057316f, -0.02769464f, -0.01759374f, -0.04029408f, 0.04162159f, -0.04956988f, 0.00164983f, 
    0.25847286f, -0.16811445f, 0.01859563f, 0.03322987f, 0.12671645f, 0.06930250f, -0.25587711f, -0.09059528f, 
    0.00485208f, 0.03595660f, 0.05489459f, -0.02521008f, 0.08465346f, -0.01091707f, -0.13860123f, 0.02291794f, 
    0.07866634f, -0.03596333f, -0.05199123f, 0.16099755f, -0.09985307f, -0.08233457f, 0.06216150f, -0.04255776f, 
    -0.01263851f, -0.05182391f, -0.10892687f, -0.00840045f, 0.09065944f, -0.02805333f, -0.03496793f, -0.16238603f, 
    -0.02248757f, 0.08656611f, 0.05060841f, 0.04004233f, 0.21313700f, -0.23963529f, 0.01024968f, 0.06280477f, 
    -0.00247660f, 0.00983386f, 0.02086886f, 0.07294206f, -0.02178360f, -0.02080468f, -0.12434223f, -0.11733331f, 
    0.30140281f, 0.27739078f, 0.03300632f, -0.00886148f, -0.03381263f, -0.25707904f, -0.04166581f, 0.19373183f, 
    -0.02737215f, 0.05342423f, -0.13488756f, -0.09584899f, 0.09552535f, -0.12891248f, 0.10479448f, -0.15338750f, 
    -0.01972678f, 0.05086433f, -0.06163533f, 0.00099702f, 0.06232651f, 0.01877487f, -0.02256057f, 0.07645892f, 
    -0.25623798f, -0.08790793f, -0.04881542f, -0.06991121f, -0.03664571f, 0.04820155f, 0.06261585f, -0.12439099f, 
    0.03242603f, -0.05318391f, -0.06144347f, 0.00804972f, -0.15058464f, -0.25745350f, -0.38163525f, -0.03105169f, 
    0.18185221f, 0.06976886f, 0.11824461f, 0.05474354f, 0.04636168f, 0.00062477f, 0.01114929f, -0.12658896f, 
    -0.19743106f, 0.04092044f, 0.39069882f, -0.34555519f, 0.03088788f, -0.10070404f, 0.06469315f, -0.04233402f, 
    -0.02098946f, 0.12436920f, 0.10099199f, -0.00549876f, 0.20443410f, 0.01666055f, 0.17171954f, -0.11725879f, 
    -0.03860217f, -0.03668002f, -0.14022361f, -0.07539437f, 0.00873230f, -0.19249821f, -0.00652209f, -0.10246100f, 
    -0.15795633f, 0.06943455f, -0.02724765f, 0.02219376f, -0.12606035f, 0.00909321f, -0.02643395f, -0.08270147f, 
    -0.10226672f, -0.00883136f, -0.08342129f, -0.09460139f, -0.28955275f, -0.46978983f, 0.13095690f, 0.23505676f, 
    -0.05952181f, 0.03711604f, -0.06267448f, -0.01357571f, 0.05801740f, -0.13052128f, -0.12424836f, -0.07618597f, 
    -0.22941603f, -0.14434065f, 0.06402274f, -0.01468848f, 0.05495102f, 0.01642489f, 0.03014654f, -0.08248059f, 
    -0.02091825f, 0.09660060f, -0.15604222f, -0.00830606f, -0.23013434f, 0.08147675f, -0.09561332f, 0.13847810f, 
    0.07404696f, -0.05176927f, -0.06769049f, -0.04906026f, -0.10647053f, 0.10062517f, -0.07882405f, 0.10661260f, 
    -0.23081550f, 0.00852049f, -0.02199987f, 0.33391112f, -0.05109419f, -0.00225616f, 0.12990820f, 0.07288308f, 
    0.09816370f, 0.01132494f, -0.02028339f, 0.08604565f, 0.12215997f, 0.17980416f, 0.19488069f, 0.03507804f, 
    0.03065316f, -0.12236936f, 0.01910529f, 0.20952019f, 0.03212598f, -0.01530978f, 0.00355549f, -0.04998666f, 
    0.11950657f, -0.11486591f, -0.03181810f, -0.00524315f, 0.02461250f, 0.19283344f, -0.05020858f, 0.12444961f, 
    0.16904072f, -0.00271699f, 0.10408297f, 0.05164324f, 0.21032563f, 0.17720391f, 0.28255895f, 0.24702880f, 
    0.01597871f, -0.02398375f, -0.08038320f, 0.04023693f, -0.09104469f, -0.07681514f, 0.04137115f, 0.06393064f, 
    -0.02223583f, -0.17758822f, -0.12944792f, 0.02293380f, 0.10864382f, 0.04920619f, 0.13641177f, 0.05679613f, 
    0.02185417f, 0.05316811f, 0.00990961f, 0.04141202f, 0.09184755f, 0.03551675f, -0.18211146f, 0.29571545f, 
    -0.08741597f, 0.09840044f, 0.19427419f, 0.17384230f, 0.02837392f, -0.00093255f, 0.03295147f, -0.11143087f, 
    0.09645704f, -0.16315666f, 0.10507239f, -0.24569082f, -0.08704578f, -0.06214914f, -0.15605682f, 0.20052430f, 
    0.03669003f, -0.01684291f, 0.13059017f, -0.01329067f, 0.25103799f, 0.07757957f, 0.10416514f, 0.16717382f, 
    0.17045061f, -0.02535302f, 0.01811379f, 0.12074310f, 0.11974615f, -0.02831046f, -0.01970785f, -0.04115987f, 
    0.10060702f, 0.10366779f, 0.22357100f, 0.11712570f, 0.09565751f, 0.14192593f, 0.09114561f, 0.03032282f, 
    -0.05302609f, -0.01533407f, -0.00727126f, -0.03020382f, -0.19998568f, -0.19653010f, -0.12717922f, -0.03308427f, 
    0.05284731f, 0.12108243f, -0.02895371f, -0.08286300f, 0.04010880f, -0.13156056f, 0.02625618f, 0.06476121f, 
    0.08078866f, -0.15869084f, -0.23270282f, -0.14144106f, 0.17400536f, -0.06785157f, 0.07173343f, -0.10498393f, 
    -0.06528947f, 0.01320472f, 0.06242826f, -0.03312614f, 0.16210461f, 0.19260782f, 0.22693455f, 0.01208015f, 
    -0.02080186f, 0.04349002f, -0.05710091f, 0.09457691f, 0.02796571f, -0.04698922f, -0.05715309f, -0.09921533f, 
    -0.32612413f, -0.05105781f, -0.05981941f, -0.16696209f, -0.02100716f, 0.02436488f, -0.02182721f, -0.16875368f, 
    0.08443978f, -0.01039605f, 0.04191306f, 0.04265570f, -0.06511614f, -0.14534378f, 0.12943901f, -0.17260177f, 
    -0.07245789f, -0.03707723f, -0.14156385f, -0.00785833f, 0.04762330f, 0.10605214f, -0.15412244f, 0.15899433f, 
    -0.05724908f, -0.03847494f, -0.04038388f, -0.13370326f, 0.01215044f, 0.04807290f, 0.11026388f, -0.10029361f, 
    0.00509896f, 0.04970233f, -0.00575676f, 0.11105432f, -0.34986851f, -0.17096606f, -0.15302283f, 0.05002549f, 
    0.04927398f, 0.05133767f, -0.02357431f, -0.15037481f, 0.01224514f, -0.10251085f, 0.03059137f, -0.10621377f, 
    0.03278939f, -0.16472919f, 0.04940673f, -0.07381706f, 0.01845739f, 0.15597199f, -0.02392117f, -0.00884707f, 
    -0.02268098f, -0.01323384f, -0.01150135f, 0.12964322f, 0.25112504f, 0.09124430f, 0.09127200f, -0.04120820f, 
    0.05015022f, 0.01962653f, -0.00393709f, 0.05555901f, 0.03072124f, 0.08231483f, 0.09512180f, 0.05598965f, 
    0.58300096f, -0.16384992f, 0.06940582f, -0.07949104f, -0.06733625f, 0.10307530f, -0.05794629f, 0.10275690f, 
    -0.01407988f, -0.09036785f, 0.00972086f, 0.08099026f, -0.18779102f, 0.19382504f, 0.21259797f, 0.19243643f, 
    -0.08074358f, -0.06292373f, 0.12804452f, 0.23784348f, -0.04348793f, -0.03560633f, -0.04328122f, -0.03945656f, 
    0.09615807f, 0.23977725f, 0.15750645f, -0.03869485f, 0.15541090f, -0.02976066f, -0.11160818f, -0.10252837f, 
    0.11661860f, 0.11058816f, -0.10805465f, -0.01324758f, -0.03258810f, -0.28595078f, 0.03775286f, -0.19709302f, 
    0.06854040f, 0.06919472f, 0.06669670f, 0.07143189f, -0.01937504f, -0.07248314f, -0.03478595f, -0.07202128f, 
    -0.02171116f, 0.03157441f, -0.02914768f, 0.03451046f, 0.01708863f, -0.04822903f, -0.03126642f, 0.01382002f, 
    -0.01071921f, 0.03587014f, 0.02564212f, -0.00646932f, 0.02482190f, -0.05323359f, -0.01687300f, 0.02059032f, 
    -0.03262603f, -0.05290174f, -0.01027839f, -0.02477823f, -0.03734039f, -0.03194558f, 0.00070756f, -0.05103432f, 
    -0.02928921f, 0.00495778f, -0.01217273f, -0.05129118f, 0.04287124f, -0.03118292f, 0.03228232f, -0.05196718f, 
    0.01516394f, -0.04416106f, 0.03899586f, 0.00242558f, -0.03385746f, 0.00288487f, -0.01136384f, 0.01343476f, 
    -0.03690178f, 0.03829304f, -0.05538251f, -0.02946644f, -0.01042731f, -0.03685560f, -0.03097897f, 0.02015321f, 
    -0.00681100f, -0.01444164f, -0.03126965f, -0.00593759f, -0.03554146f, -0.02786246f, -0.05780535f, 0.00993125f, 
    -0.04974657f, -0.05536015f, -0.02684453f, -0.00645597f, 0.02172645f, -0.01706329f, -0.04863157f, -0.04358322f, 
    -0.05030727f, -0.02694250f, -0.00293482f, -0.02175241f, -0.03336226f, 0.01859078f, -0.01595479f, 0.01340554f, 
    0.01624786f, -0.04455711f, -0.00645587f, 0.03613843f, -0.01385242f, 0.02281128f, -0.01308321f, -0.01032273f, 
    0.02902049f, -0.01445072f, -0.04936725f, 0.00844807f, -0.00646275f, -0.05890208f, -0.04215718f, 0.03672484f, 
    0.01038034f, 0.03688635f, -0.00793696f, 0.02007739f, -0.02803067f, -0.06189366f, -0.05633504f, 0.00317424f, 
    -0.04630291f, 0.02606186f, 0.02724969f, -0.00645826f, -0.03170631f, 0.01893025f, 0.02555257f, -0.02734575f, 
    -0.01200086f, -0.00789565f, 0.01504736f, 0.03996626f, 0.02696967f, 0.02136883f, -0.02377024f, -0.01374638f, 
    -0.01862601f, -0.02452248f, -0.04936083f, -0.02725409f, -0.03726589f, -0.03943863f, -0.04163632f, 0.02820638f, 
    0.00241100f, -0.05085362f, -0.03846492f, -0.00017395f, 0.01242563f, 0.03434132f, -0.02350283f, 0.03760756f, 
    0.02790844f, 0.02927049f, -0.04375648f, -0.03062275f, 0.01998911f, -0.04972985f, 0.01389065f, 0.03000127f, 
    0.03462857f, -0.02554182f, -0.02569419f, -0.05834656f, 0.00904177f, 0.00083276f, 0.03698201f, 0.02057237f, 
    -0.03555383f, 0.02937379f, 0.02510869f, -0.05643493f, 0.00601355f, 0.03518195f, 0.03922412f, 0.02091608f, 
    -0.02800832f, -0.00080400f, -0.01214372f, -0.04576107f, -0.04234397f, -0.00133489f, -0.05302834f, 0.00240915f, 
    -0.03673444f, -0.03886363f, 0.02807915f, -0.01029536f, 0.03734263f, 0.03776135f, -0.05383280f, -0.02254979f, 
    -0.00239652f, -0.00147159f, -0.00002133f, -0.02268033f, 0.02449270f, 0.02917406f, 0.04187331f, 0.02407650f, 
    0.01095369f, -0.02143815f, 0.00335584f, -0.02034652f, -0.04225529f, -0.01229782f, 0.03718504f, 0.00523968f, 
    -0.03501377f, 0.00486540f, -0.00747521f, -0.00133335f, -0.06005276f, -0.00022766f, -0.04056706f, 0.02915113f, 
    0.01300746f, -0.04559432f, -0.02059037f, 0.01142431f, 0.03161793f, -0.02337759f, -0.00537062f, 0.00607599f, 
    -0.01421097f, -0.01566948f, -0.05211443f, -0.05128669f, 0.01781375f, 0.03494894f, -0.01852785f, 0.03002105f, 
    0.02888536f, 0.00332333f, 0.04122017f, 0.03847237f, 0.03799157f, -0.00765714f, -0.02008050f, -0.05939612f, 
    0.03213388f, -0.03315730f, -0.02802410f, -0.00076228f, 0.02158314f, -0.03795379f, 0.03373374f, -0.04799441f, 
    -0.00409983f, 0.03063066f, -0.02116155f, -0.00673487f, -0.02697597f, -0.01400438f, 0.02160899f, -0.03027739f, 
    0.02250168f, -0.04091670f, -0.02311535f, 0.03750319f, -0.03219790f, -0.04806659f, -0.00198281f, -0.04553771f, 
    -0.01919061f, 0.03847814f, 0.02691161f, -0.03411113f, 0.01111423f, 0.01574439f, -0.05224432f, -0.01232702f, 
    -0.00279409f, 0.01751698f, -0.04587983f, -0.01148746f, -0.02218798f, 0.03700641f, -0.01840701f, -0.05899361f, 
    0.03146145f, -0.05695711f, -0.04345515f, 0.02410495f, -0.02356851f, -0.01264785f, -0.00623840f, -0.02532819f, 
    -0.04259099f, -0.01512370f, 0.04076526f, -0.01581717f, 0.01061485f, 0.01936360f, 0.03250715f, 0.03501341f, 
    -0.02605821f, -0.05576837f, 0.02745701f, -0.01123082f, -0.04612556f, -0.01168804f, 0.03564738f, -0.00257604f, 
    -0.04657181f, -0.01282140f, 0.00813457f, -0.02243952f, -0.01079508f, -0.01319665f, -0.01535283f, -0.05007438f, 
    0.01560759f, -0.03794583f, -0.05769159f, 0.04117097f, -0.01049830f, 0.03229485f, 0.03638649f, -0.00094672f, 
    0.03144863f, -0.02193174f, -0.00458801f, 0.03472837f, 0.02149006f, -0.04897859f, -0.03975572f, 0.00416520f, 
    -0.05091457f, 0.00239100f, 0.02973205f, -0.00698199f, -0.03581891f, 0.00225105f, 0.03931322f, -0.04428302f, 
    -0.03605329f, -0.00153022f, 0.01181374f, 0.02493767f, -0.01676624f, 0.04332298f, 0.02385302f, 0.01162030f, 
    0.00393109f, -0.01146768f, -0.00257351f, -0.03751040f, 0.03201080f, -0.00092826f, -0.02495625f, -0.03057502f, 
    0.02671599f, -0.04502125f, -0.01527611f, -0.03855681f, 0.01349167f, 0.00827320f, -0.02546435f, 0.02125650f, 
    -0.00543368f, -0.00326227f, -0.05969435f, -0.03316202f, -0.05734595f, -0.01961662f, 0.01318043f, -0.05697126f, 
    0.04450682f, 0.01073817f, 0.04357214f, 0.00156369f, -0.01647036f, 0.00355505f, -0.00463035f, -0.01509749f, 
    0.01097693f, 0.01244569f, -0.05683833f, -0.01840528f, 0.03385706f, 0.02913312f, -0.00198317f, -0.04825550f, 
    0.01232579f, -0.03777586f, 0.02863080f, -0.03638579f, 0.01892169f, -0.02720807f, 0.03436208f, 0.03413723f, 
    -0.00363883f, -0.05596833f, -0.01802013f, -0.04426963f, 0.01730596f, -0.01312740f, 0.03733809f, 0.04004411f, 
    0.01876458f, 0.01796296f, -0.01734635f, 0.03654530f, -0.00728970f, -0.00858569f, -0.00916444f, 0.01638627f, 
    0.16047482f, 0.23958148f, 0.00168051f, 0.05861663f, 0.02393880f, -0.05899359f, 0.03352683f, 0.21082143f, 
    0.00326728f, 0.06265048f, 0.01816804f, -0.04920395f, 0.14901301f, -0.17193559f, 0.14949088f, -0.08608123f, 
    -0.00261628f, -0.05567101f, -0.02626960f, 0.01936665f, 0.09495848f, -0.12425750f, -0.00005397f, 0.10704516f, 
    -0.09058280f, -0.00433417f, -0.01572095f, 0.04826427f, 0.00828771f, 0.01528526f, 0.07940437f, -0.11371405f, 
    0.17432292f, -0.05668731f, 0.06053682f, 0.00082908f, -0.08983490f, -0.00536186f, 0.22721174f, 0.17731786f, 
    0.08581992f, -0.17930792f, 0.02618357f, 0.02592665f, 0.10914579f, -0.05406406f, -0.05488687f, -0.04014057f, 
    -0.05134202f, -0.00178965f, 0.12709796f, -0.01783764f, -0.05338622f, 0.06282254f, 0.19790454f, 0.07121947f, 
    -0.26935992f, -0.08191513f, 0.07493281f, -0.04015287f, -0.08388584f, -0.10296368f, -0.16901694f, -0.17714633f, 
    0.02989892f, 0.05132250f, -0.00675873f, 0.03491194f, -0.08230825f, -0.11700357f, 0.00621133f, -0.16149986f, 
    -0.16301320f, -0.11156075f, 0.05775513f, -0.03357229f, -0.11357807f, -0.01484207f, 0.05368898f, -0.03659188f, 
    -0.02064973f, 0.02405315f, 0.01501314f, 0.00151113f, -0.26451594f, -0.10804304f, 0.09372708f, 0.17925489f, 
    0.00905546f, -0.15398622f, -0.10108817f, 0.03608904f, 0.06353981f, -0.09801207f, -0.17994554f, 0.14256740f, 
    -0.11755399f, -0.10913710f, 0.09636337f, -0.05723009f, -0.02620321f, -0.01127642f, 0.04130342f, -0.02571425f, 
    0.11831030f, 0.11950579f, 0.03227597f, 0.19327232f, 0.11745688f, -0.00111908f, 0.03716527f, 0.06849308f, 
    0.07456627f, -0.07763551f, -0.10365248f, -0.02132926f, 0.04745519f, -0.04755065f, -0.01163243f, 0.04007428f, 
    0.21584107f, 0.17539738f, -0.02252971f, -0.02824181f, 0.04668343f, 0.02262058f, 0.18547593f, 0.00310996f, 
    0.07343622f, -0.06374629f, 0.01711851f, 0.09843381f, 0.34742892f, 0.07151128f, 0.15038225f, -0.11852457f, 
    0.12684192f, 0.03426736f, 0.12635070f, 0.12735701f, 0.10966933f, 0.07396919f, 0.16143207f, 0.02546843f, 
    0.02246231f, 0.00070031f, 0.04345855f, 0.01777595f, -0.08632368f, 0.19396931f, -0.11040806f, 0.01619207f, 
    0.15099789f, -0.01365864f, 0.06023174f, 0.05744919f, -0.17157538f, -0.08430614f, 0.07405241f, 0.13904199f, 
    -0.06204582f, 0.05688661f, 0.05090376f, 0.18727183f, 0.11013487f, -0.18119508f, -0.20553005f, -0.06979309f, 
    0.06714797f, -0.07944737f, -0.07192013f, -0.03371232f, 0.10421644f, -0.02072742f, -0.04646936f, -0.04246592f, 
    0.08612388f, 0.12689066f, 0.05288020f, 0.12349870f, 0.10249429f, 0.16213124f, 0.02764519f, 0.13330288f, 
    -0.16239540f, 0.10169054f, 0.04560671f, 0.15120456f, 0.08143727f, 0.07921679f, 0.08935010f, 0.03230463f, 
    0.00354855f, -0.23805648f, 0.04856699f, -0.06632023f, -0.18974063f, 0.10053793f, -0.03788867f, 0.03277795f, 
    -0.08962688f, -0.04149283f, -0.20386414f, 0.01624282f, 0.13047300f, -0.04485690f, -0.21531649f, 0.08046620f, 
    0.01165105f, 0.29295850f, 0.03813604f, 0.14851791f, 0.11603049f, -0.13379581f, -0.14129724f, 0.01146689f, 
    -0.06610180f, -0.05946292f, -0.08799788f, 0.01534775f, 0.01426106f, 0.09624469f, -0.05364650f, -0.18788944f, 
    0.05271035f, 0.06676319f, -0.03768042f, -0.05288346f, -0.12408302f, -0.08803390f, 0.00756524f, -0.04243728f, 
    0.09675016f, 0.13372721f, -0.01048842f, 0.00749524f, -0.01155038f, -0.09756535f, 0.06666841f, 0.00733052f, 
    -0.06550260f, -0.08860783f, -0.02690545f, -0.05160657f, -0.02110786f, 0.08862832f, 0.00681670f, -0.07894343f, 
    0.05506876f, -0.07998390f, -0.04586083f, 0.01229195f, 0.11045415f, -0.02236322f, -0.02093259f, -0.08630501f, 
    -0.06617070f, 0.10874914f, 0.08506782f, 0.06161917f, -0.04155361f, 0.07462228f, 0.10650125f, -0.08020587f, 
    0.04363505f, 0.22831297f, -0.02556519f, 0.06209993f, 0.05625246f, -0.12245473f, -0.02391972f, -0.01951632f, 
    0.10018405f, 0.10926446f, 0.13956800f, 0.24865194f, 0.02407089f, -0.11465350f, 0.28681037f, -0.17087641f, 
    -0.04989245f, -0.07391692f, 0.00308781f, -0.09390640f, -0.01831242f, -0.02782099f, -0.04818998f, 0.05266842f, 
    -0.11296683f, 0.04695988f, -0.09816609f, -0.04761436f, 0.08862853f, 0.09683719f, -0.11428931f, -0.13387749f, 
    -0.03020868f, -0.09407181f, 0.11674877f, 0.19287822f, -0.15973628f, 0.07610351f, -0.08364329f, 0.03408738f, 
    0.14724790f, 0.05790770f, 0.00642065f, -0.01675379f, 0.02736574f, -0.08717141f, 0.13316083f, 0.12066238f, 
    -0.01884818f, -0.13499391f, 0.02538229f, 0.04199151f, -0.06601368f, -0.01435265f, -0.01329535f, -0.04446434f, 
    0.10490233f, 0.12845397f, 0.09046327f, 0.20617558f, 0.02284018f, -0.18865351f, 0.11101847f, -0.05059423f, 
    -0.10747115f, 0.09410621f, 0.01386958f, 0.02829424f, 0.18003219f, 0.08405304f, -0.04874819f, -0.13220625f, 
    0.11156279f, -0.19169454f, -0.13971621f, 0.05191387f, -0.12459937f, 0.06684507f, -0.16768868f, -0.11810979f, 
    0.00672917f, -0.04111165f, 0.16174504f, 0.02907887f, 0.27904648f, 0.24093951f, -0.02776168f, 0.08939858f, 
    -0.05420421f, -0.03865274f, 0.13966875f, 0.08644115f, 0.11096124f, -0.04237894f, -0.07391446f, 0.10344153f, 
    0.00553715f, 0.07261246f, -0.01357399f, -0.05154469f, 0.16150019f, 0.16892163f, -0.00924182f, 0.00116964f, 
    0.15257376f, -0.08383628f, -0.21990117f, -0.21077354f, -0.06758790f, -0.31013286f, 0.07935881f, -0.08048466f, 
    0.02649488f, 0.02947115f, -0.07736108f, 0.16424806f, 0.00307707f, -0.03095097f, 0.08686122f, -0.10534739f, 
    0.28070647f, 0.28437421f, -0.03224362f, 0.09167790f, -0.02757959f, 0.04160455f, 0.07931737f, 0.13084006f, 
    -0.07405066f, 0.01766100f, -0.06957795f, -0.04256801f, 0.10575546f, -0.17746887f, 0.14253317f, -0.06819370f, 
    0.10145534f, -0.01360034f, -0.06141789f, 0.13115811f, 0.06459689f, -0.00240565f, -0.10510567f, 0.10960235f, 
    0.15955396f, -0.05817891f, 0.08447387f, 0.35898387f, 0.11321088f, 0.08385769f, 0.05360424f, -0.09101780f, 
    0.05081155f, 0.06909195f, 0.13688509f, 0.04226913f, -0.14587379f, -0.25102118f, -0.13120723f, 0.20633173f, 
    -0.01107869f, 0.07289785f, -0.04923643f, -0.07137018f, 0.07071702f, -0.02840056f, 0.15473783f, 0.08756206f, 
    0.07306542f, 0.16753022f, -0.09937196f, -0.39423817f, 0.01790937f, -0.01836845f, 0.05475241f, 0.06269038f, 
    0.15621105f, 0.05633107f, 0.11550847f, 0.02191791f, -0.11332309f, -0.11010398f, 0.02679813f, -0.32607704f, 
    -0.10470746f, -0.04120316f, -0.00973441f, -0.05089162f, 0.01386683f, -0.07216760f, 0.07537109f, 0.02196507f, 
    0.22628228f, -0.12079413f, 0.20933649f, 0.04222410f, 0.01139894f, 0.00642660f, -0.11730279f, 0.02467241f, 
    0.07494236f, -0.07140677f, 0.03743130f, 0.06939881f, -0.43612111f, 0.14795353f, 0.08269393f, 0.46187642f, 
    0.11304400f, -0.01513087f, -0.08074155f, 0.23783740f, 0.19624473f, -0.08412485f, 0.09307680f, -0.08949108f, 
    -0.03373181f, -0.16844538f, 0.10536928f, -0.00468882f, 0.14159635f, -0.11492287f, -0.09363216f, 0.00873146f, 
    -0.09364875f, -0.03761425f, -0.00219286f, 0.13877399f, -0.25185379f, 0.21291444f, -0.14964376f, -0.09729399f, 
    0.09381694f, -0.24840295f, 0.14180788f, -0.16753973f, -0.04392979f, -0.01786043f, -0.00789286f, -0.02568749f, 
    -0.16230367f, -0.20212997f, 0.18519786f, -0.04817952f, 0.06977946f, 0.08750821f, 0.11558481f, -0.01089388f, 
    0.10354131f, 0.11658305f, 0.05881224f, 0.07149249f, 0.32828298f, 0.23118395f, 0.39958760f, 0.09178443f, 
    0.04368432f, 0.03933065f, 0.17791581f, -0.04044325f, -0.00457217f, -0.02270571f, 0.24271207f, 0.05654490f, 
    -0.01232404f, -0.09600885f, 0.08763684f, 0.05093551f, -0.02949517f, 0.07846779f, 0.06916255f, 0.07984372f, 
    0.03031566f, -0.11753781f, -0.01499918f, 0.02235792f, 0.32726669f, -0.19221872f, 0.13978684f, -0.07607426f, 
    -0.02700561f, -0.02979242f, -0.17438494f, -0.03768420f, -0.02382156f, 0.16707262f, 0.14242528f, 0.07620221f, 
    0.11638267f, 0.03756567f, 0.14532612f, 0.07242054f, -0.01719313f, -0.03632122f, 0.03907626f, 0.01531391f, 
    0.06258579f, -0.13186347f, -0.07818724f, -0.03706692f, -0.01410631f, 0.25232226f, -0.01400720f, 0.33411494f, 
    0.00204686f, 0.05767445f, 0.15933350f, 0.00971680f, -0.03512867f, -0.00390354f, 0.05858821f, 0.04259914f, 
    0.19568026f, 0.21452205f, 0.03351784f, -0.12449751f, -0.02692830f, 0.26268891f, 0.04671452f, -0.08145623f, 
    -0.08100968f, -0.03772516f, -0.07101640f, 0.06680170f, -0.00330700f, 0.08508649f, -0.09651886f, -0.26923847f, 
    0.01298557f, 0.00777137f, -0.00805670f, 0.00765968f, 0.16556442f, 0.03548415f, -0.04596324f, -0.02641515f, 
    -0.00696390f, 0.42262951f, -0.20892951f, -0.20629899f, 0.19325919f, -0.01729946f, 0.06853530f, -0.03991669f, 
    0.21817413f, 0.18288863f, 0.04852867f, 0.05440784f, 0.06846324f, -0.02930208f, 0.01161643f, 0.23395142f, 
    0.03035453f, 0.00900344f, -0.03339822f, -0.05586464f, 0.04263526f, -0.12930122f, 0.10645559f, -0.04974888f, 
    0.12129451f, 0.00948936f, -0.10101947f, -0.05007971f, 0.13332215f, 0.12231945f, 0.19950032f, -0.03472737f, 
    0.13696170f, -0.09513467f, 0.15305075f, -0.02702654f, -0.20573340f, 0.16005793f, -0.06171294f, -0.22693647f, 
    -0.05950535f, 0.00314584f, 0.03073929f, -0.04837851f, 0.06262349f, 0.06229118f, -0.07190382f, 0.10850268f, 
    -0.10311343f, -0.40210781f, -0.07713174f, 0.34418476f, -0.08720794f, -0.03626898f, -0.15243889f, 0.19827016f, 
    0.04390153f, -0.05681509f, 0.03117367f, 0.01303241f, 0.18461730f, -0.40263978f, 0.49448013f, -0.23327304f, 
    0.16031519f, -0.03388305f, -0.00590701f, 0.07625913f, 0.23736964f, -0.02849883f, -0.15346196f, -0.03559444f, 
    0.05379327f, 0.05483556f, -0.11912096f, -0.19113198f, 0.15828088f, -0.01077592f, -0.01707477f, -0.11813638f, 
    0.21322866f, -0.06003736f, -0.09499244f, 0.07240858f, 0.00612156f, -0.19017611f, -0.05559879f, 0.10708620f, 
    0.04300955f, 0.08123877f, -0.00727439f, 0.01457539f, 0.09080074f, 0.06650891f, 0.16343138f, 0.05331032f, 
    0.14187494f, -0.02012108f, 0.15204775f, 0.09189555f, 0.01680032f, 0.05092410f, 0.00873244f, 0.01332100f, 
    -0.01517343f, -0.06763678f, -0.05553849f, -0.03940059f, 0.26277480f, 0.10181428f, -0.02534823f, -0.09463979f, 
    -0.04754231f, -0.05493417f, -0.07385106f, -0.07288792f, 0.08043828f, -0.06201434f, 0.17105983f, 0.07109683f, 
    0.47203252f, -0.33486682f, 0.22737272f, -0.21751231f, -0.00032349f, 0.05646395f, 0.14736505f, 0.04729133f, 
    0.13229658f, 0.05866954f, -0.03484368f, 0.05091342f, -0.06084799f, -0.43268403f, 0.18280126f, -0.21964505f, 
    0.16556691f, -0.06073246f, 0.07915945f, 0.10778160f, 0.03906867f, 0.03791610f, 0.01983908f, -0.03557347f, 
    -0.15671505f, 0.06036551f, 0.01143063f, -0.02927589f, 0.03872800f, -0.02057194f, -0.09555229f, -0.07378855f, 
    0.00404083f, -0.02294801f, -0.05296612f, 0.05934973f, 0.23744938f, -0.22167267f, -0.11840235f, -0.17219488f, 
    0.22452684f, -0.06247203f, -0.10576050f, -0.07714977f, -0.01205569f, 0.01357290f, -0.06899475f, 0.10359987f, 
    -0.23850007f, 0.04256593f, -0.00638706f, 0.18825699f, -0.01993615f, 0.09951172f, 0.07364050f, 0.02162478f, 
    0.19025348f, -0.00784608f, 0.02584123f, -0.03996166f, -0.37937701f, -0.16187876f, -0.09940143f, -0.03942467f, 
    0.04285594f, 0.09622129f, -0.00477415f, 0.22405291f, -0.05549172f, 0.10940739f, -0.06326704f, 0.03006342f, 
    0.06873527f, -0.05172924f, -0.33808246f, -0.06535323f, -0.02589836f, -0.06324636f, 0.01020494f, 0.00828760f, 
    0.22955179f, 0.16606376f, 0.25469786f, 0.06342722f, 0.10479317f, -0.13301009f, -0.13410252f, 0.43448383f, 
    -0.14244172f, 0.12736326f, 0.04855599f, -0.03064457f, 0.00462220f, -0.10864273f, 0.03110764f, -0.11288776f, 
    0.20045912f, 0.57394582f, 0.00407689f, 0.34274387f, 0.02440287f, -0.01245001f, -0.00649983f, 0.03710161f, 
    0.13898546f, -0.03091836f, -0.12813169f, 0.04663165f, 0.03430754f, 0.21387132f, 0.53597337f, 0.33549812f, 
    -0.01209032f, -0.12624578f, 0.01399283f, 0.03384513f, 0.10273654f, 0.10698434f, 0.01158100f, 0.14507794f, 
    0.02895328f, -0.12172952f, -0.33028349f, -0.12257595f, -0.08767164f, 0.11071214f, 0.06546349f, 0.10037407f, 
    0.10797797f, -0.01611368f, 0.03595230f, 0.14310916f, 0.26959664f, -0.29880628f, 0.24402922f, 0.09374612f, 
    -0.00372541f, -0.07783826f, 0.02562121f, -0.15388450f, 0.10492950f, -0.02074114f, 0.09457886f, 0.08707703f, 
    0.05411343f, 0.00234552f, -0.08412682f, -0.09122008f, 0.00396135f, -0.08685375f, -0.06236423f, 0.14692388f, 
    0.01174075f, 0.00829522f, 0.04150397f, -0.16712141f, -0.19689649f, -0.02632276f, 0.00163062f, 0.05136335f, 
    0.05161106f, 0.02337124f, -0.03756878f, 0.11969912f, 0.07249633f, 0.12989739f, 0.17219280f, -0.03567297f, 
    -0.24254951f, -0.25637648f, -0.14711538f, 0.10306058f, -0.07294736f, -0.06542742f, -0.13038222f, -0.03053381f, 
    -0.20971993f, -0.00146522f, -0.19510759f, 0.01175553f, -0.34176540f, -0.19381925f, 0.02833415f, 0.13874727f, 
    -0.08198232f, 0.07019837f, 0.08385904f, 0.03292337f, 0.15711088f, 0.05225817f, 0.07355639f, -0.08771916f, 
    0.03143876f, -0.01465752f, -0.01153948f, 0.05647992f, -0.05981962f, -0.10626477f, -0.21981616f, -0.04465349f, 
    -0.19760318f, -0.12509722f, -0.08750810f, -0.22856133f, 0.11464348f, 0.09908784f, 0.22630535f, 0.21470946f, 
    -0.12816654f, -0.07335231f, 0.05276889f, 0.13501438f, 0.07241665f, -0.11190489f, -0.03904955f, 0.02968548f, 
    -0.05257181f, -0.17992693f, 0.14837618f, 0.08394384f, 0.08202073f, -0.09288128f, -0.01419537f, 0.05480826f, 
    -0.21811803f, -0.18120790f, -0.10391043f, -0.17598233f, -0.07263883f, -0.23796077f, 0.11094863f, 0.08381911f, 
    0.14499728f, 0.10332857f, 0.09774771f, -0.05942476f, 0.07754435f, -0.02302416f, -0.05743255f, -0.06061182f, 
    -0.41404250f, 0.12027715f, 0.34548858f, 0.01133745f, 0.17512101f, 0.13643011f, 0.10069386f, -0.04492747f, 
    0.26330915f, -0.12892169f, -0.02747596f, 0.04934471f, -0.11814008f, -0.00723210f, 0.26296064f, 0.21066903f, 
    -0.14001735f, 0.03032520f, 0.12227719f, 0.15608427f, -0.00416620f, 0.01908521f, 0.12013610f, 0.01559990f, 
    -0.05264308f, 0.04344239f, 0.00422167f, -0.03915487f, 0.00842810f, -0.04951527f, 0.03283458f, -0.03931835f, 
    0.01523654f, -0.02223610f, 0.03500981f, -0.10643281f, -0.30437613f, -0.23048915f, -0.38555363f, -0.18420777f, 
    -0.03775529f, -0.01688849f, 0.02765905f, -0.07810847f, 0.02875209f, -0.01255997f, -0.05647768f, 0.04821612f, 
    -0.20535032f, -0.06203992f, 0.15860434f, -0.01394867f, -0.02863726f, -0.16207065f, -0.01649760f, -0.07173403f, 
    0.06148220f, -0.25504220f, 0.23006694f, 0.03851679f, -0.19694911f, -0.16699561f, 0.27555916f, 0.09734445f, 
    -0.01666634f, -0.08086809f, -0.11059292f, 0.00111332f, 0.00604258f, -0.04765230f, 0.04232635f, 0.03398301f, 
    0.20716229f, -0.15421450f, -0.47581834f, 0.31453875f, -0.03116018f, 0.07927487f, 0.08066845f, -0.16092718f, 
    0.03683200f, 0.02745811f, 0.00907372f, 0.14205460f, 0.02368881f, -0.19943146f, 0.30615944f, -0.05405138f, 
    0.12114968f, -0.07002586f, -0.13815618f, 0.04130776f, -0.02610018f, -0.06694576f, 0.21782275f, 0.19244821f, 
    0.04521076f, 0.14934684f, -0.05183568f, -0.12375673f, -0.00467132f, 0.04145829f, 0.20859049f, 0.07422260f, 
    -0.01390536f, 0.03638059f, -0.19750606f, -0.03525727f, -0.03482011f, -0.00340829f, -0.10683955f, 0.12096045f, 
    -0.09581701f, 0.08637073f, -0.01557942f, 0.02999298f, -0.09675486f, 0.08532398f, 0.08351371f, 0.10201187f, 
    -0.01237907f, -0.24550912f, -0.10760341f, -0.15848628f, -0.00070587f, -0.00252335f, -0.04674090f, -0.19515567f, 
    -0.12014034f, -0.19342127f, -0.03933247f, -0.16693090f, 0.19609115f, 0.30952996f, 0.19087490f, 0.19221821f, 
    -0.09025808f, -0.18212438f, -0.12017138f, -0.06513306f, 0.01380651f, 0.01160210f, 0.04913824f, 0.05455846f, 
    -0.24000552f, 0.06751371f, 0.36427391f, -0.01223207f, 0.05420306f, 0.12934650f, 0.06150324f, -0.05527814f, 
    -0.07461457f, 0.02254798f, 0.04695874f, -0.02429412f, -0.28141892f, -0.28055960f, -0.09150207f, 0.12703636f, 
    -0.02469280f, 0.01003364f, -0.25132895f, 0.12882723f, -0.12282956f, -0.05161697f, -0.05830132f, -0.02589793f, 
    -0.13379768f, -0.02051996f, 0.03586605f, -0.00703505f, -0.02744554f, -0.00166279f, 0.16583578f, 0.11572597f, 
    0.13046569f, 0.08976135f, 0.14344777f, 0.28245896f, -0.06654069f, 0.34077254f, 0.09929275f, 0.09096899f, 
    -0.03869944f, 0.07388188f, 0.06206228f, 0.14636825f, 0.03175926f, 0.09941927f, -0.09450711f, -0.20254987f, 
    -0.05822110f, -0.01956976f, 0.01062712f, -0.00715496f, -0.03005175f, -0.02048711f, 0.03910292f, -0.03532208f, 
    0.02298639f, -0.01328255f, 0.02381377f, -0.02260635f, 0.00595343f, -0.08197686f, -0.01550857f, 0.01086111f, 
    -0.00531229f, -0.05900700f, -0.02969765f, -0.00951941f, 0.01756665f, -0.03994051f, -0.01240162f, -0.07084886f, 
    -0.04968563f, -0.01624184f, 0.01867677f, -0.01010201f, -0.04562692f, -0.07917970f, -0.00101126f, -0.06619509f, 
    0.00060859f, -0.02861474f, 0.00021948f, -0.00826077f, -0.05681701f, -0.05272171f, -0.01462778f, -0.07425290f, 
    -0.04749171f, 0.00286786f, -0.06643457f, 0.00255987f, -0.03822258f, 0.01719001f, -0.03348725f, -0.02695425f, 
    -0.06529836f, -0.05225465f, 0.01724013f, 0.01523387f, -0.03278442f, -0.05777138f, -0.07893609f, -0.00887991f, 
    -0.03807946f, 0.00826102f, -0.04889430f, -0.01043486f, -0.05041436f, -0.05321170f, 0.00178275f, -0.07629964f, 
    -0.07843117f, 0.01382254f, -0.06229522f, -0.00620475f, 0.04407646f, 0.00922865f, -0.04850775f, -0.01944307f, 
    0.01198774f, -0.06705048f, -0.05317035f, -0.05938274f, -0.08095095f, -0.06114717f, 0.01614445f, -0.04458389f, 
    0.00250403f, -0.02034770f, -0.00395467f, -0.01249791f, -0.03316886f, -0.01607487f, -0.02399428f, -0.02151848f, 
    -0.07698489f, -0.06736875f, -0.04676634f, -0.05296239f, -0.02784585f, 0.03216611f, -0.08203777f, -0.05354148f, 
    -0.05964934f, -0.06879253f, -0.07202782f, -0.06203539f, 0.01345847f, -0.04233586f, -0.03616012f, -0.04748318f, 
    -0.07323492f, -0.05035498f, -0.00255242f, -0.05655948f, -0.01043021f, 0.02739905f, -0.02734198f, 0.02848439f, 
    0.04236048f, 0.01472909f, -0.03997734f, -0.03284476f, -0.01828897f, 0.02544635f, 0.04488762f, -0.04376284f, 
    -0.00871632f, -0.05400056f, -0.03318436f, -0.01545501f, 0.03566197f, 0.02557676f, 0.02978181f, -0.04251252f, 
    -0.02004958f, 0.01337471f, -0.06705243f, -0.06922385f, -0.01947860f, 0.03571533f, -0.02228423f, 0.02909871f, 
    0.01107787f, -0.01704327f, -0.02325265f, 0.03696822f, -0.02128370f, 0.00575397f, 0.04668629f, -0.01838891f, 
    -0.07861529f, -0.01345937f, -0.07827166f, -0.03959139f, -0.03468933f, -0.05827342f, -0.01333183f, -0.00854401f, 
    0.01424503f, -0.04395027f, -0.03897043f, -0.02253543f, -0.02444054f, -0.04666000f, -0.04829731f, -0.02760136f, 
    0.01227183f, 0.01674013f, -0.00461814f, -0.00768205f, -0.04933563f, -0.07146944f, -0.06830792f, -0.06281757f, 
    -0.02382340f, 0.00045148f, -0.07355350f, -0.04264166f, -0.01409726f, -0.02233287f, 0.00407971f, -0.00040413f, 
    -0.01099976f, 0.00916639f, -0.02427634f, -0.06376846f, -0.04485831f, -0.04708933f, -0.02604268f, 0.02602554f, 
    0.05083197f, -0.00179140f, -0.00105221f, -0.00550891f, 0.03865420f, -0.03327240f, 0.02319821f, -0.02148534f, 
    -0.06901078f, -0.01638428f, -0.04911474f, 0.03098737f, 0.00537182f, 0.00645576f, 0.04935279f, -0.05938419f, 
    -0.06004582f, -0.03506819f, -0.07249665f, -0.01743825f, -0.00848887f, -0.01926716f, 0.02165567f, -0.03964378f, 
    -0.00607278f, -0.05969649f, -0.01725721f, -0.04509072f, -0.02640611f, 0.02334178f, -0.00417907f, -0.03226902f, 
    -0.07567622f, -0.06809647f, -0.01835417f, -0.02521489f, -0.03101098f, 0.01351299f, 0.00346640f, 0.01841206f, 
    0.00095085f, -0.03448514f, -0.02673274f, -0.07285833f, -0.03159313f, -0.02116290f, 0.01738965f, -0.06033409f, 
    -0.05201197f, -0.06030281f, -0.03183897f, -0.00310218f, -0.06593680f, -0.05119445f, -0.07454647f, -0.02749298f, 
    0.00330315f, -0.07604375f, -0.07908443f, 0.00149225f, -0.01971865f, 0.00395236f, -0.05501214f, -0.02226930f, 
    -0.05659636f, -0.01759708f, -0.06625050f, -0.02120885f, -0.05538156f, -0.03890893f, 0.02132786f, 0.04240439f, 
    -0.04277735f, -0.03066717f, 0.04596058f, -0.01880563f, -0.04175745f, 0.04993489f, 0.01815701f, 0.03025695f, 
    -0.03019029f, 0.01611463f, -0.07407919f, -0.02461785f, 0.01658999f, -0.05240880f, -0.06937431f, -0.01597105f, 
    -0.06312331f, -0.02580311f, -0.07011531f, -0.05229862f, -0.02924341f, -0.07949810f, -0.03832709f, -0.04153471f, 
    0.01115818f, -0.03246182f, -0.04638867f, -0.02808891f, -0.01056549f, -0.05230794f, -0.03579207f, -0.01317118f, 
    -0.02041928f, -0.05975206f, -0.03504080f, 0.01678108f, -0.08218680f, 0.01950590f, -0.04147989f, -0.05880674f, 
    -0.02640080f, -0.04056365f, 0.00883290f, 0.00256291f, -0.00977190f, -0.01190384f, -0.02537858f, 0.01064812f, 
    0.01298280f, -0.02869713f, -0.04980915f, -0.04775624f, -0.06619705f, -0.00896403f, 0.01271873f, -0.05070802f, 
    -0.06329226f, -0.05971593f, -0.06414258f, -0.05235858f, -0.05099759f, -0.00286492f, -0.07616074f, -0.02444723f, 
    -0.05192746f, -0.03267515f, -0.00631829f, -0.02116068f, 0.01978919f, -0.00484994f, -0.06777065f, 0.00966308f, 
    -0.07070899f, -0.00342173f, -0.02420672f, -0.04785836f, -0.04568269f, -0.04611851f, -0.06102942f, 0.00894135f, 
    -0.05194190f, -0.06375284f, -0.07616089f, -0.03817906f, -0.05938889f, -0.05086160f, -0.06634333f, -0.05125374f, 
    -0.02084329f, -0.04126956f, -0.04193276f, -0.05396010f, -0.02792957f, -0.01347200f, 0.00862586f, -0.01487804f, 
    -0.00170131f, -0.02144874f, 0.01904628f, -0.04145239f, 0.01520898f, -0.00056554f, -0.02055738f, 0.00860148f, 
    0.03861709f, -0.02597388f, 0.01390143f, -0.03627967f, 0.00771242f, 0.02390339f, -0.00569572f, -0.03132023f, 
    -0.03212979f, 0.04134521f, -0.03652217f, -0.02644258f, -0.01615653f, -0.03482004f, 0.01238851f, 0.03493957f, 
    -0.02867495f, -0.02921998f, -0.07495149f, -0.02042203f, -0.03473496f, -0.02080639f, 0.00938037f, -0.06799742f, 
    -0.05115823f, -0.03914435f, -0.02681077f, 0.00018996f, 0.03626267f, 0.03745993f, -0.03397165f, 0.02299689f, 
    -0.01304785f, -0.03261641f, 0.03799783f, -0.02216483f, 0.03034054f, 0.02494441f, -0.00819278f, -0.02396189f, 
    -0.04854091f, -0.03449494f, -0.00895170f, 0.01155710f, 0.03564434f, -0.01711441f, -0.04579022f, 0.02135667f, 
    0.02656145f, -0.04372136f, -0.00757338f, 0.00779015f, 0.00361745f, 0.01372137f, 0.03848838f, 0.03963858f, 
    -0.00614623f, -0.05339977f, -0.04875221f, -0.02737510f, -0.03410548f, -0.00274336f, -0.00844132f, 0.00694344f, 
    0.01682452f, -0.03176497f, 0.02569021f, -0.03053361f, 0.01720705f, -0.04135124f, 0.03679794f, 0.03142351f, 
    -0.02676238f, 0.02898278f, -0.02337379f, -0.02500989f, -0.02720648f, -0.00192247f, -0.03014411f, 0.00503869f, 
    -0.05025389f, -0.01788194f, -0.05202292f, 0.00197799f, -0.00641799f, -0.01438619f, -0.03034011f, 0.00787170f, 
    -0.03496949f, 0.00110767f, -0.03622780f, -0.03439233f, 0.00483882f, 0.00065610f, 0.01693180f, 0.01893269f, 
    -0.01870357f, 0.02167322f, -0.01063449f, -0.02948399f, 0.03707226f, -0.01035080f, -0.02669952f, 0.02220382f, 
    0.01266926f, -0.00673558f, -0.00535734f, -0.02057160f, 0.03754340f, 0.02876719f, -0.01256173f, -0.04255877f, 
    0.04219202f, -0.01107211f, 0.03486495f, 0.02287774f, 0.00143416f, -0.04948204f, -0.03780291f, -0.01641611f, 
    -0.05416916f, -0.05140718f, -0.01397215f, 0.02128731f, -0.00964134f, 0.01639485f, -0.04357979f, 0.00271343f, 
    -0.01589109f, -0.04559704f, -0.00803057f, -0.03636355f, -0.05166920f, -0.02525193f, -0.01482627f, -0.01557192f, 
    -0.02804969f, -0.01764788f, 0.03001774f, 0.03607490f, -0.01999671f, -0.01416705f, -0.02456072f, -0.02636220f, 
    0.03536194f, -0.00742562f, -0.01058824f, -0.01152564f, -0.00834659f, -0.02702186f, -0.04815806f, 0.03356349f, 
    -0.04630197f, -0.04441337f, 0.00838957f, 0.01911999f, -0.05027555f, 0.04340477f, -0.01991780f, 0.04268301f, 
    0.00663921f, 0.02265540f, -0.00091988f, -0.01158248f, -0.01705344f, -0.02127009f, 0.01396749f, 0.04113468f, 
    -0.01078387f, 0.02482454f, -0.01722620f, -0.03406878f, -0.02520516f, 0.03790809f, 0.02739728f, -0.00252176f, 
    0.00282102f, 0.03637508f, 0.02212900f, -0.01952546f, -0.02194727f, -0.04136430f, -0.01245410f, -0.03755205f, 
    0.00032090f, 0.03175538f, -0.04456744f, -0.00615786f, -0.01204366f, -0.01675973f, 0.01367615f, 0.00965823f, 
    -0.00311263f, 0.03492354f, 0.00794774f, -0.00175265f, 0.04105001f, -0.05488661f, -0.02087098f, -0.01721922f, 
    -0.05336987f, 0.04322945f, -0.03250100f, -0.05226646f, -0.00749243f, -0.01146604f, -0.03330221f, -0.04576575f, 
    0.00787457f, 0.00328008f, -0.00258346f, 0.02745055f, -0.02079913f, -0.01387470f, -0.02751364f, 0.00719047f, 
    0.01892966f, -0.04171282f, -0.03217496f, -0.02267853f, 0.03274990f, -0.03594273f, -0.03363367f, 0.01688251f, 
    -0.02840557f, 0.01982847f, 0.04210029f, 0.03077331f, -0.04350201f, 0.02435414f, -0.02064128f, 0.02463343f, 
    0.04293029f, 0.01749205f, 0.01998590f, 0.01613063f, 0.02043800f, 0.01323176f, -0.01336579f, 0.01003196f, 
    -0.03571927f, -0.03618523f, 0.04236583f, 0.00287723f, -0.04536316f, 0.03178183f, -0.03693063f, -0.03861218f, 
    0.03478049f, -0.00456433f, 0.01410620f, -0.00406536f, -0.04849732f, 0.02403173f, 0.04254708f, -0.02915789f, 
    -0.03825790f, -0.04537183f, -0.04546481f, -0.03903944f, -0.02270883f, -0.00110298f, -0.03725878f, -0.00383820f, 
    -0.00405742f, 0.03571290f, -0.02671251f, 0.03994633f, -0.02683672f, -0.00612860f, 0.01762662f, -0.04094507f, 
    0.00548480f, 0.02353210f, -0.02093431f, 0.02291517f, -0.00827876f, 0.03553244f, -0.00042165f, -0.04070992f, 
    0.00045618f, -0.00913597f, -0.00671017f, 0.00772509f, -0.05547927f, -0.04087196f, -0.04738347f, -0.02235213f, 
    -0.01614621f, -0.04896616f, -0.00594869f, 0.03273160f, -0.00032405f, 0.04323043f, -0.01777490f, 0.00006818f, 
    -0.00071051f, -0.00529236f, -0.04471300f, 0.04245567f, -0.02894113f, -0.01988679f, -0.02387887f, -0.02320783f, 
    -0.05368397f, -0.01385730f, -0.04426768f, 0.03728142f, -0.04834158f, 0.01625338f, -0.02816763f, 0.00564834f, 
    0.00483472f, -0.00869384f, -0.05289501f, 0.00302362f, -0.03171967f, -0.05174805f, -0.01825922f, 0.00820328f, 
    -0.05544358f, -0.03216220f, -0.00311147f, -0.05091839f, 0.00037069f, -0.01479820f, 0.04392733f, -0.01003742f, 
    -0.04583490f, -0.02040627f, 0.03228723f, 0.00424068f, 0.00034383f, -0.02038488f, -0.00510398f, 0.01225377f, 
    -0.02740955f, -0.03465469f, -0.02884090f, -0.00528789f, -0.03335243f, -0.00647549f, 0.01098718f, -0.04981442f, 
    -0.03369793f, -0.02753096f, 0.02494720f, 0.00251887f, 0.01100813f, 0.04054412f, -0.00343813f, -0.03804249f, 
    -0.00863859f, -0.01932161f, 0.04485824f, 0.00585865f, 0.03680756f, -0.01812922f, 0.03583847f, -0.03738314f, 
    -0.02440558f, 0.03180032f, 0.03920145f, -0.05515721f, -0.00812337f, -0.02003016f, -0.03888731f, 0.04263059f, 
    -0.01799035f, 0.03462337f, -0.02821464f, 0.02242246f, 0.03850022f, 0.02589274f, 0.03087452f, -0.01620098f, 
    -0.00969517f, -0.05505309f, 0.02143248f, 0.04257604f, -0.01603146f, -0.01442779f, 0.02313284f, -0.03937092f, 
    -0.05069060f, 0.01644848f, 0.04555224f, -0.00840995f, 0.03636638f, -0.01593346f, -0.05590709f, -0.01585232f, 
    0.01711066f, -0.02277802f, 0.03595470f, -0.04414657f, -0.00277894f, -0.00662987f, 0.04510791f, -0.01445769f, 
    -0.02019475f, -0.01476369f, -0.01256874f, 0.04505339f, -0.00641040f, -0.05493698f, 0.00019812f, -0.00742770f, 
    -0.02980944f, -0.04386806f, -0.05472650f, -0.05904395f, -0.02944472f, -0.04507509f, 0.01517694f, -0.04760472f, 
    -0.00745749f, -0.05083881f, -0.04740646f, -0.07704616f, 0.03742094f, 0.03602211f, -0.02812962f, -0.05045490f, 
    0.00023338f, -0.00499258f, 0.01810871f, -0.07715822f, 0.00492127f, 0.04064727f, 0.01362033f, -0.00755724f, 
    -0.01898626f, -0.10032793f, -0.05868933f, -0.11596039f, -0.05883572f, 0.00233263f, -0.03771590f, -0.03720932f, 
    -0.10317891f, -0.07288512f, -0.15261978f, -0.16730945f, -0.14343050f, -0.03765360f, -0.03107144f, -0.02546060f, 
    -0.03921378f, -0.05308800f, 0.00182858f, -0.07330748f, -0.02348313f, -0.00423103f, -0.05671637f, -0.07133655f, 
    -0.01303547f, 0.02129665f, -0.01509073f, 0.01627833f, -0.01668451f, 0.02510234f, -0.00377047f, 0.00220396f, 
    0.07624699f, 0.01012049f, -0.04665354f, -0.00708491f, -0.00873848f, -0.02336886f, -0.05267521f, -0.04167998f, 
    0.00595777f, -0.05569997f, 0.02297767f, 0.02635307f, -0.12134546f, -0.13200362f, -0.08006056f, -0.08526749f, 
    0.02799779f, -0.02614092f, -0.03881174f, -0.00389308f, 0.01292356f, 0.02248458f, -0.04194498f, -0.01235383f, 
    0.07643092f, -0.03858596f, 0.04558376f, 0.04277086f, -0.07990005f, -0.11259009f, 0.03892904f, 0.02097723f, 
    -0.05349399f, -0.00663354f, -0.00131146f, -0.15074480f, -0.07372192f, -0.08088313f, -0.09031113f, -0.12586868f, 
    -0.02531100f, -0.03725531f, -0.03782168f, 0.01075038f, -0.04707913f, -0.03595471f, 0.00300079f, -0.03396910f, 
    0.04534057f, -0.01433873f, -0.02881441f, 0.01832250f, -0.08699923f, -0.02294918f, -0.06820908f, -0.08708329f, 
    -0.10226920f, -0.08939110f, -0.12768598f, -0.12332850f, -0.05928883f, 0.00690576f, -0.06740702f, -0.08174881f, 
    -0.01173657f, -0.05598740f, 0.00294191f, 0.02293710f, -0.04152184f, -0.04943379f, -0.09993552f, -0.07787643f, 
    -0.00484372f, -0.03784984f, -0.01155232f, -0.09698954f, -0.07348437f, -0.11891475f, -0.09957471f, -0.03834185f, 
    -0.05807808f, -0.03617360f, 0.00939353f, -0.01858816f, 0.01262471f, -0.04517382f, 0.01432928f, 0.00780190f, 
    0.01645157f, -0.04527883f, 0.01730800f, -0.02063604f, 0.04666326f, 0.05396073f, -0.03513879f, -0.03595050f, 
    0.02334734f, 0.00903210f, 0.00786323f, 0.02557173f, -0.01602185f, -0.09020334f, -0.10547157f, -0.03452618f, 
    0.03071771f, -0.02030778f, 0.00551689f, 0.06018595f, -0.00545154f, -0.08304090f, -0.12166408f, -0.17538379f, 
    0.04654372f, 0.02518080f, -0.02799614f, -0.04020073f, 0.04785323f, 0.02639010f, -0.06085208f, -0.00638947f, 
    0.03976949f, 0.01358328f, 0.01418113f, 0.04248667f, -0.04633020f, -0.05703629f, -0.04824321f, -0.01294900f, 
    -0.02146716f, -0.09728140f, -0.04086508f, 0.00243378f, -0.02630823f, 0.00244145f, -0.07395168f, -0.05800202f, 
    -0.03380806f, -0.08674048f, -0.00403753f, -0.10273775f, -0.15754434f, -0.08417957f, 0.00687259f, -0.05316529f, 
    -0.12900531f, -0.04944395f, -0.08226384f, -0.03575759f, -0.05192596f, -0.10094988f, -0.05268303f, -0.04831337f, 
    -0.08017943f, -0.06706428f, 0.02237212f, 0.03149161f, -0.09471371f, -0.07643741f, -0.05722743f, -0.04319424f, 
    -0.09638298f, -0.13681844f, -0.07708935f, -0.05134683f, -0.15697427f, -0.03244462f, -0.07599845f, -0.13159932f, 
    -0.09055945f, -0.08066306f, -0.06586535f, -0.04467415f, 0.04061578f, 0.00156998f, -0.05506844f, -0.02227681f, 
    -0.04614699f, 0.01278786f, -0.02125342f, 0.03438825f, 0.02592696f, -0.02458544f, -0.05206299f, 0.05533645f, 
    0.01536868f, -0.04166260f, -0.01802466f, -0.02478500f, -0.04555682f, 0.07293133f, -0.05108467f, 0.03000721f, 
    0.02480324f, 0.01261119f, 0.00891823f, -0.06557880f, 0.01958569f, -0.02178389f, -0.04963569f, -0.03135195f, 
    -0.05929906f, -0.10441229f, -0.09030196f, -0.02076253f, -0.07121377f, -0.02032020f, -0.06997035f, -0.04767268f, 
    -0.11906184f, -0.10500199f, -0.04841638f, -0.00942209f, -0.01961826f, -0.05079978f, -0.02297790f, -0.01038455f, 
    -0.04667340f, 0.00650203f, 0.03154615f, -0.06102630f, -0.02016357f, -0.08508141f, -0.05731227f, 0.01384541f, 
    0.02071206f, -0.02529705f, -0.01570062f, -0.00604009f, -0.03117380f, -0.10253802f, 0.00787857f, -0.00862748f, 
    -0.05118117f, -0.02527188f, -0.01167628f, -0.02271119f, 0.04514209f, 0.06985270f, 0.05866922f, 0.03773142f, 
    -0.02237550f, -0.01125013f, 0.03738335f, 0.02378237f, -0.09793612f, -0.01623831f, -0.12270930f, -0.14822079f, 
    -0.05158135f, -0.01517743f, -0.04239871f, -0.05528249f, -0.04519292f, -0.05831778f, -0.09029072f, -0.08274122f, 
    -0.05948953f, 0.01711790f, -0.03341070f, -0.02598914f, -0.01827450f, -0.04413140f, -0.02919566f, 0.04128942f, 
    -0.00046739f, -0.01112590f, -0.01703615f, -0.00989365f, 0.04618709f, 0.03991861f, -0.08013212f, 0.01142330f, 
    0.01059485f, 0.00451485f, 0.05957630f, 0.06087383f, 0.03969939f, -0.00969082f, -0.03353876f, -0.04387638f, 
    -0.12892389f, 0.01492388f, 0.02831123f, -0.04956482f, -0.01801223f, -0.03802363f, -0.02777205f, -0.07076588f, 
    -0.02124143f, 0.00583927f, -0.05747697f, -0.04450062f, -0.04912398f, -0.05591586f, 0.05899777f, -0.01955941f, 
    -0.17536613f, -0.08435185f, -0.10953214f, -0.14960672f, 0.01495619f, -0.11108026f, -0.03313022f, -0.03328594f, 
    -0.12364463f, -0.10868141f, -0.01845388f, -0.08640742f, -0.05079322f, 0.00253850f, -0.03898600f, -0.00610693f, 
    -0.01004844f, -0.08033232f, 0.01547594f, 0.00313319f, -0.10833050f, 0.07943323f, 0.05575285f, -0.12596783f, 
    -0.04584183f, -0.05948171f, -0.00670300f, -0.07295837f, -0.04362643f, -0.06940810f, -0.12669720f, -0.13362987f, 
    -0.11380569f, -0.04213829f, 0.06175733f, -0.15138099f, 0.06034989f, -0.07456130f, -0.03438695f, -0.02697632f, 
    0.13928242f, -0.02127782f, -0.05164356f, -0.00553542f, 0.03902682f, 0.03647565f, -0.02851033f, 0.02358861f, 
    -0.06773952f, 0.06229984f, -0.07702530f, -0.05530798f, 0.14284812f, -0.02980217f, 0.09252591f, 0.00312259f, 
    -0.16077656f, 0.21462835f, -0.05953268f, -0.10018700f, -0.05776716f, -0.00781653f, -0.04362618f, 0.06730527f, 
    0.03912770f, 0.03952474f, 0.05164525f, -0.01382546f, 0.18908463f, 0.41810066f, -0.06129961f, -0.14286956f, 
    -0.03937905f, -0.17702311f, -0.15063663f, -0.07285065f, -0.08945042f, 0.03912602f, -0.08325393f, -0.01008448f, 
    -0.15188396f, -0.07958409f, 0.12300342f, -0.11922886f, -0.03526011f, -0.01309991f, 0.11376849f, 0.00819268f, 
    0.05556239f, 0.05320519f, -0.06273394f, -0.08334814f, 0.34213084f, 0.05527292f, 0.09887709f, -0.02657006f, 
    -0.05205041f, -0.03063511f, -0.01270837f, -0.11200604f, -0.12353610f, -0.12332328f, -0.03206845f, -0.00633955f, 
    -0.18043824f, 0.05750911f, -0.14117239f, 0.02929306f, 0.00150816f, -0.07521499f, -0.09178500f, -0.10927860f, 
    -0.08788159f, 0.09551042f, 0.05799799f, -0.04147371f, 0.38727617f, -0.20604075f, 0.16782525f, -0.20565936f, 
    -0.11657389f, 0.00105803f, -0.10058994f, -0.08510640f, -0.00848859f, 0.04108172f, -0.05257030f, 0.01552112f, 
    0.01998948f, 0.09134733f, -0.00876503f, 0.03795692f, -0.02776084f, 0.13422817f, 0.04431861f, -0.01912912f, 
    0.10364705f, 0.01628993f, 0.14224865f, 0.01243874f, -0.02319693f, -0.02539097f, -0.06799922f, 0.26346239f, 
    0.03164649f, 0.10009904f, 0.03490168f, 0.05738946f, 0.05662142f, 0.17931636f, -0.00106307f, 0.10448459f, 
    -0.26863566f, 0.04419079f, -0.35935089f, 0.03069873f, -0.02759975f, -0.07152512f, 0.01898052f, 0.12772103f, 
    -0.03379900f, -0.05940229f, -0.05600223f, -0.08327714f, -0.27954319f, -0.13514432f, -0.25459212f, -0.06124932f, 
    -0.06087185f, 0.03470488f, -0.18963879f, 0.09434190f, 0.02739421f, 0.08755810f, -0.05335391f, 0.09295649f, 
    -0.00209216f, 0.03927241f, -0.09282961f, -0.11731454f, 0.16162616f, 0.05156135f, -0.03261346f, 0.00271533f, 
    0.02019978f, -0.04249958f, 0.07644153f, 0.03730074f, -0.03349898f, 0.18329711f, 0.09180492f, 0.02297347f, 
    -0.02510491f, 0.00332185f, 0.08317012f, -0.09132495f, 0.06068837f, 0.02202359f, 0.05838833f, -0.00791597f, 
    -0.06164096f, -0.03339561f, -0.17771301f, 0.03034246f, 0.09611916f, -0.04660580f, -0.10426584f, -0.04917549f, 
    -0.08276604f, -0.06067245f, 0.04364467f, -0.06175519f, -0.10354851f, -0.29675469f, -0.19772352f, -0.23298937f, 
    -0.13710193f, 0.08766643f, -0.07729413f, 0.10308099f, -0.03516312f, 0.01254817f, -0.07807188f, 0.02915548f, 
    0.16819039f, -0.03044565f, 0.06730879f, -0.06655706f, 0.00786801f, -0.00222989f, 0.07180288f, 0.15712552f, 
    0.03936612f, -0.08694641f, 0.06958760f, 0.06968737f, 0.18484236f, -0.10892437f, 0.40878773f, 0.29657018f, 
    0.23220566f, 0.06497005f, 0.00161311f, 0.07017758f, 0.10826977f, 0.12147384f, 0.06173041f, -0.09309757f, 
    -0.09514814f, -0.31796953f, 0.31084129f, 0.09116273f, -0.03742570f, 0.06286138f, 0.13427803f, 0.09963302f, 
    -0.14132355f, 0.02745087f, -0.06280869f, 0.01135080f, 0.02476866f, -0.01654338f, -0.04777934f, -0.02155896f, 
    -0.09956107f, -0.08763999f, -0.09320978f, -0.03712366f, 0.08831994f, 0.04492426f, -0.01777029f, -0.04186621f, 
    -0.02378035f, -0.00416243f, 0.03848726f, -0.00957901f, 0.03340734f, -0.17250749f, -0.02071959f, 0.04268484f, 
    -0.01358308f, 0.12964152f, -0.23326720f, 0.03881799f, 0.26855049f, 0.08007038f, 0.14736630f, 0.23525833f, 
    0.06900842f, 0.08212312f, -0.11163268f, 0.22657457f, -0.04047330f, 0.00762396f, 0.09118513f, -0.18431523f, 
    -0.02763205f, 0.26904896f, 0.01243410f, -0.26250684f, -0.00271589f, -0.00871215f, 0.06152570f, -0.07531986f, 
    -0.02343745f, -0.09249770f, 0.09466664f, -0.01099990f, 0.08285415f, 0.18839556f, -0.13720340f, 0.11298850f, 
    -0.07860190f, 0.00447267f, -0.06687691f, 0.06347474f, 0.05874316f, 0.06439712f, -0.08725102f, 0.24461009f, 
    0.04897812f, -0.04902341f, 0.10284448f, 0.15429746f, 0.10927168f, 0.04246179f, 0.24019009f, 0.06908695f, 
    -0.13776918f, 0.06651039f, -0.10240229f, 0.09724526f, -0.10825570f, 0.18433595f, 0.12881772f, 0.17323737f, 
    0.02576078f, -0.07878281f, -0.00377487f, -0.08783091f, -0.03502853f, -0.04281086f, 0.01134560f, 0.02427427f, 
    -0.03485299f, 0.08989849f, -0.01544645f, 0.03060287f, -0.02555398f, -0.11613103f, -0.09049972f, -0.08675732f, 
    -0.18319033f, 0.05474368f, 0.01658075f, 0.06049266f, -0.04883719f, -0.00578769f, 0.06352260f, -0.01592251f, 
    -0.00428414f, -0.03188874f, 0.05997299f, 0.08718501f, 0.01506180f, 0.12976673f, 0.02018815f, -0.02507094f, 
    0.24568000f, 0.17330967f, -0.10925759f, 0.24096780f, 0.15639633f, -0.03664213f, -0.06918556f, 0.03792937f, 
    -0.00306559f, -0.02445303f, -0.03664098f, 0.12247658f, -0.39638728f, 0.31637430f, -0.12150668f, 0.12716010f, 
    -0.06459624f, -0.01693882f, 0.19031210f, 0.18045552f, -0.15650161f, -0.10775093f, -0.08386476f, -0.07887965f, 
    0.26008815f, -0.00820880f, 0.10940886f, 0.07570448f, 0.09868674f, 0.03074888f, -0.04170404f, 0.02227480f, 
    -0.00611488f, 0.24015523f, 0.08881754f, -0.01728853f, -0.01633289f, 0.03690014f, 0.10381159f, 0.12386482f, 
    -0.23454317f, 0.06218126f, -0.02115580f, -0.11835708f, 0.00431739f, 0.00769231f, -0.10995659f, 0.04012446f, 
    0.24059120f, 0.15750436f, 0.04414725f, 0.04912104f, 0.13438286f, 0.05600119f, 0.15861806f, 0.27215499f, 
    -0.08021001f, 0.01648153f, 0.02072588f, -0.09903242f, 0.25984609f, 0.03361642f, 0.13822067f, -0.24283578f, 
    -0.14114453f, -0.13726935f, -0.03895286f, -0.06742318f, 0.09167705f, -0.08449545f, 0.00111966f, -0.01963904f, 
    0.07889131f, 0.12773345f, 0.13553141f, 0.01467983f, 0.02809976f, -0.08620127f, -0.04459375f, -0.16277111f, 
    -0.08801706f, -0.11848479f, -0.04862049f, 0.03814837f, -0.07706948f, 0.02834206f, 0.19632395f, 0.07716740f, 
    0.11859809f, -0.08669634f, 0.03373742f, -0.05141675f, -0.07386391f, -0.10911471f, -0.09743956f, -0.04445724f, 
    -0.26932701f, -0.42645699f, -0.16134658f, -0.20646118f, -0.09837402f, -0.02349174f, 0.11545644f, -0.06609526f, 
    -0.13292670f, 0.12184092f, 0.08122202f, 0.01676580f, 0.11999437f, -0.31362382f, -0.28419527f, -0.21353932f, 
    -0.00954298f, 0.14384779f, -0.07721923f, 0.10629775f, 0.04421302f, 0.03769397f, -0.01854914f, 0.03674018f, 
    0.20854491f, -0.10527053f, 0.25158113f, -0.21246423f, -0.11980594f, -0.05020467f, -0.13701324f, -0.15680268f, 
    -0.04932699f, 0.00208171f, 0.08171171f, 0.10358145f, 0.16176447f, 0.34512943f, -0.07704927f, 0.20675215f, 
    -0.07756552f, -0.09902218f, -0.07616900f, 0.23107275f, -0.05336521f, -0.03630142f, -0.16664317f, -0.02587716f, 
    -0.05072672f, 0.18323909f, 0.14157157f, -0.05643997f, -0.09094571f, 0.05154263f, 0.05441003f, -0.17426868f, 
    -0.00699438f, 0.13189346f, -0.08144405f, 0.16228899f, 0.22852348f, 0.13405178f, -0.34632483f, 0.22316188f, 
    0.08876808f, -0.04487634f, 0.30192438f, -0.00758806f, -0.08668279f, -0.06185661f, -0.05856893f, 0.07386240f, 
    0.39678404f, 0.30458722f, -0.11183392f, -0.39258528f, -0.02222751f, 0.14321584f, 0.18531924f, 0.11120262f, 
    0.07008541f, -0.04943569f, 0.08565751f, 0.05534471f, 0.40026399f, 0.12144785f, 0.07042871f, 0.00933480f, 
    0.16303885f, -0.03815104f, 0.22362150f, 0.11115041f, -0.04232848f, -0.03137911f, 0.00388644f, 0.06400376f, 
    0.00544016f, -0.08975103f, -0.11235369f, -0.16286029f, 0.01654315f, 0.18290932f, -0.01863244f, -0.07402600f, 
    0.13257635f, 0.08132583f, 0.09670204f, 0.00664870f, 0.32515603f, -0.39568788f, -0.27394488f, -0.22835556f, 
    -0.04243272f, 0.12079247f, -0.04702830f, -0.12000677f, 0.14944690f, 0.02977479f, 0.10380257f, -0.04550741f, 
    -0.09317863f, -0.01861777f, 0.07652958f, -0.08551731f, 0.08358259f, -0.06935430f, -0.02695584f, 0.00406849f, 
    0.06650696f, 0.10636928f, 0.00826581f, 0.08694156f, 0.01931682f, 0.32012093f, 0.03310728f, 0.19642340f, 
    -0.12629220f, 0.17962757f, -0.03735921f, 0.27687079f, 0.05512153f, -0.00954570f, 0.04347293f, -0.03544268f, 
    0.16264042f, -0.09567496f, -0.21711832f, -0.06055631f, -0.11426977f, -0.14013401f, 0.07210439f, 0.26461378f, 
    -0.01397099f, 0.11917023f, -0.07230785f, 0.09489782f, 0.27130026f, -0.15835105f, -0.42544222f, -0.21734002f, 
    0.13681059f, 0.06453882f, 0.12488761f, -0.00016512f, 0.19417453f, -0.04429278f, -0.07065985f, 0.01988352f, 
    -0.19674546f, 0.01007091f, -0.38864550f, 0.32355490f, 0.25133216f, 0.11974473f, 0.20004305f, 0.07663541f, 
    -0.01483561f, 0.03725470f, -0.00379016f, 0.12707478f, 0.00307427f, 0.05221602f, 0.10392347f, 0.14013135f, 
    -0.05318108f, 0.00065194f, -0.05370683f, -0.04528428f, -0.06757479f, -0.19498719f, -0.01159438f, 0.02517039f, 
    -0.15703076f, -0.06915915f, -0.12030461f, -0.12271159f, 0.12745243f, 0.05792750f, 0.07695232f, -0.05844162f, 
    0.01153973f, 0.04519129f, -0.08714012f, -0.16312042f, 0.25280115f, 0.01059834f, -0.37405893f, -0.17602506f, 
    0.01218161f, 0.09911523f, 0.24085338f, 0.03524343f, -0.03622360f, 0.00184729f, 0.08823905f, 0.07331158f, 
    0.34582278f, -0.07981232f, 0.37482980f, 0.05252836f, 0.00749979f, 0.10251916f, -0.14092378f, -0.08225214f, 
    -0.00898618f, -0.05582657f, 0.01144761f, 0.20357682f, 0.32554534f, 0.01460511f, 0.17760776f, -0.21117336f, 
    -0.21628776f, -0.14742467f, 0.08431860f, -0.16912702f, 0.03848392f, 0.09401596f, -0.12187573f, -0.09861213f, 
    -0.40980923f, -0.15639074f, -0.20975581f, -0.01783300f, 0.15625951f, 0.01227579f, -0.03193640f, -0.15591946f, 
    0.01071009f, -0.07618905f, 0.15318134f, 0.03372464f, -0.06656620f, 0.21732265f, 0.11110325f, -0.09771591f, 
    0.10790179f, -0.05113522f, -0.04282088f, -0.12516211f, 0.06183229f, -0.13119945f, 0.06222129f, 0.01244891f, 
    0.02558482f, -0.06230185f, 0.21634820f, -0.05114895f, 0.03507487f, 0.02605632f, -0.03618998f, -0.03573326f, 
    0.18124726f, 0.10693561f, 0.14355864f, 0.18685660f, 0.30359310f, -0.30453098f, -0.16316487f, -0.16891830f, 
    -0.15582953f, 0.16355130f, 0.05793794f, -0.05777033f, 0.19948329f, 0.07738001f, 0.10136870f, 0.01988188f, 
    0.15370075f, -0.18198521f, 0.12217448f, -0.10207866f, -0.09126316f, -0.02049350f, 0.05448031f, -0.08012079f, 
    0.07191432f, 0.03764618f, 0.06742372f, 0.04632735f, 0.54634404f, 0.11391568f, -0.12530312f, -0.38765082f, 
    0.14824870f, 0.14802605f, 0.13453180f, 0.16569234f, -0.02058746f, -0.11967506f, -0.04029597f, 0.10880242f, 
    0.15753537f, -0.02267220f, -0.15628287f, 0.15500090f, 0.06811326f, 0.08328096f, 0.11728794f, 0.07981538f, 
    0.13793570f, -0.07179189f, -0.19425175f, -0.22482720f, 0.14726515f, -0.16700689f, 0.15153421f, 0.04339020f, 
    0.07874834f, -0.03340814f, 0.05113783f, 0.07939837f, -0.08417898f, -0.13747557f, 0.00811642f, 0.02860554f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.20259839f, 0.00864205f, 0.10831850f, 0.00665965f, -0.04283839f, -0.08414324f, -0.02462880f, -0.05458413f, 
    0.03876505f, 0.04919136f, -0.00845790f, -0.05014177f, 0.01877812f, 0.07033656f, -0.04539812f, 0.10310881f, 
    0.04590236f, 0.02247353f, 0.04687395f, 0.04573400f, 0.03182056f, 0.01100628f, 0.10125461f, -0.11920008f, 
    0.18968821f, 0.19574830f, -0.02275045f, 0.06202564f, 0.00004269f, 0.10580358f, 0.06294563f, -0.03651204f, 
    0.01335272f, 0.08245678f, -0.01598419f, -0.01140897f, 0.01513428f, 0.03325082f, 0.09747483f, 0.05394227f, 
    0.16177143f, -0.02551956f, -0.01694725f, -0.03241669f, 0.18767160f, 0.13972336f, 0.18713102f, -0.05798264f, 
    0.14183533f, 0.03944033f, -0.04435896f, -0.02440449f, -0.04171645f, 0.04447933f, 0.06257495f, -0.00948393f, 
    0.00918467f, 0.07756556f, 0.08852297f, -0.04551322f, -0.04885363f, -0.06086311f, 0.16654173f, 0.01622121f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.15727577f, 0.04320882f, -0.39045507f, -0.01670806f, 0.05672839f, 0.10475959f, -0.02840557f, 0.10027675f, 
    -0.21335721f, 0.17456669f, 0.04540319f, -0.11057696f, -0.08682784f, 0.16738075f, 0.00506103f, -0.11644353f, 
    0.12392802f, -0.10470465f, -0.03446080f, 0.07332303f, 0.11927975f, -0.05593869f, -0.28446263f, 0.10145459f, 
    -0.22886762f, -0.24978654f, 0.02989579f, 0.06128481f, -0.02691278f, -0.47340271f, -0.46703646f, -0.37463513f, 
    0.06466547f, 0.02947196f, 0.11098218f, -0.42529008f, 0.18022622f, 0.01022646f, 0.01920003f, -0.33609995f, 
    -0.43163165f, 0.28280249f, 0.03798732f, -0.07167915f, -0.08026834f, -0.36060709f, 0.02872459f, 0.02400988f, 
    -0.03735872f, -0.01117091f, 0.30645904f, 0.02490938f, 0.29443109f, -0.01057668f, -0.02532391f, -0.07142205f, 
    0.01390952f, -0.15657142f, -0.50308073f, -0.15523183f, -0.09111583f, 0.02850031f, -0.16212800f, 0.24987805f, 
    0.40859881f, 0.13704851f, -0.00550034f, -0.00973918f, 0.09859279f, -0.86107355f, 0.06238245f, -0.11110830f, 
    0.01250171f, 0.14405623f, 0.06272484f, 0.01355863f, -0.06490134f, 0.02866148f, 0.06943041f, 0.13528986f, 
    -0.19806635f, 0.04702469f, 0.06684517f, -0.13610996f, -0.05611901f, -0.00018148f, -0.30975112f, -0.14664581f, 
    0.10573500f, 0.07528460f, 0.08574376f, 0.20216358f, -0.11504737f, -0.20144756f, -0.08910022f, -0.20725708f, 
    0.08704941f, 0.16228747f, 0.06930951f, 0.27808961f, 0.16579349f, -0.05094254f, -0.08382594f, -0.42715690f, 
    0.11243981f, 0.27657196f, -0.13251695f, -0.05608397f, -0.11529671f, 0.20660309f, 0.35230774f, 0.04749529f, 
    0.04214998f, 0.12799798f, -0.78981596f, -0.17794408f, 0.22345635f, 0.07848563f, 0.19379777f, -0.10563920f, 
    -0.02843214f, 0.05802952f, -0.57928878f, -0.01966598f, 0.04950497f, -0.09209055f, 0.28066048f, 0.02258016f, 
    -0.12713271f, -0.08352875f, -0.02825082f, -0.00363736f, 0.16653967f, -0.46756828f, 0.11008588f, -0.05434986f, 
    -0.11627918f, 0.15363313f, -0.09968804f, -0.00177268f, -0.13162626f, 0.14698018f, 0.04989746f, 0.19884343f, 
    -0.11259430f, -0.00242575f, -0.21417676f, -0.08400082f, 0.34038708f, -0.11046928f, -0.08828907f, 0.03808438f, 
    0.16145086f, 0.05440290f, 0.02594406f, 0.12043023f, -0.01641623f, 0.14432847f, 0.36733675f, -0.12408528f, 
    -0.22545518f, 0.11164929f, 0.04302918f, -0.46583849f, -0.01904492f, -0.10737086f, -0.10151935f, -0.18381660f, 
    0.01796792f, -0.85719264f, 0.05537169f, -0.24340105f, 0.19372898f, 0.25050005f, -0.12619109f, 0.06894323f, 
    0.08142387f, 0.04722117f, 0.22294879f, -0.04799519f, -0.59278792f, 0.11669207f, -0.04681158f, 0.06538088f, 
    -0.06151497f, -0.07288039f, 0.32758638f, 0.07387133f, -0.08171052f, -0.03940318f, 0.26283586f, -0.49185085f, 
    -0.39379585f, 0.24932991f, -0.30849957f, -0.04157398f, 0.21458027f, 0.09960718f, 0.11581144f, -0.06363220f, 
    0.09489567f, -0.09834821f, -0.00053393f, 0.09758937f, -0.04694848f, -0.14038303f, -0.11687799f, -0.04663476f, 
    0.10231628f, -0.08397862f, -0.56954497f, -0.21934435f, 0.23750393f, -0.03326607f, -0.30478895f, 0.10275707f, 
    -0.10853206f, -0.16792560f, -0.12994972f, 0.10595868f, 0.08698136f, 0.03762254f, 0.39380142f, 0.17597264f, 
    0.22205724f, -0.45483705f, 0.01661711f, 0.18279023f, 0.21102737f, -0.01039129f, -0.49487421f, 0.12863302f, 
    0.07287337f, -0.34011748f, -0.10693202f, 0.14170009f, -0.12139405f, -0.37724581f, -0.02026246f, -0.01587635f, 
    0.18958671f, -0.03196977f, -0.02751477f, 0.24603355f, -0.09942593f, -0.16844763f, -0.08230366f, -0.11092801f, 
    -0.14034911f, -0.29474756f, 0.11294531f, -0.01303938f, -0.06386311f, -0.02173987f, 0.04674086f, -0.11223701f, 
    -0.55432588f, -0.05164390f, -0.05989648f, -0.14619677f, 0.11253915f, 0.08977725f, 0.15586480f, -0.07903006f, 
    0.11369267f, 0.09357955f, 0.05114805f, -0.05374125f, -0.09583727f, -0.16258392f, -0.08614817f, -0.30453151f, 
    0.04459924f, 0.11050691f, 0.13455373f, 0.20627409f, 0.07330623f, -0.02191062f, 0.27997041f, 0.11880966f, 
    -0.29746348f, -0.24077673f, -0.02865987f, -0.03797139f, -0.01246529f, 0.10445174f, -0.17188218f, 0.33685222f, 
    -0.10553509f, 0.11738323f, 0.10953613f, -0.27904958f, 0.01813563f, 0.10631267f, 0.02553644f, -0.14441720f, 
    -0.07935026f, -0.03007556f, 0.01802835f, 0.03908406f, -0.61673230f, 0.01772866f, 0.15613379f, 0.13758120f, 
    -0.32903826f, -0.06238221f, 0.21706830f, -0.22835776f, 0.23409225f, 0.05162239f, 0.10814939f, 0.11425793f, 
    0.02835983f, 0.12799884f, 0.22363757f, -0.07993652f, -0.12239685f, -0.04391429f, -0.23208433f, -0.17124203f, 
    -0.19985801f, -0.22985913f, -0.09772268f, -0.01899757f, -0.28042382f, 0.14417709f, -0.28065422f, -0.11386087f, 
    0.13479961f, 0.19220421f, -0.01885984f, -0.11970843f, 0.04068746f, 0.02791700f, -0.02326226f, 0.01030897f, 
    0.04939161f, -0.01779292f, 0.14724553f, 0.28936762f, -0.16737168f, 0.05327873f, 0.16403319f, 0.16408597f, 
    0.23441878f, -0.03113986f, 0.05363789f, 0.20899881f, 0.00314079f, 0.20224544f, -0.38403282f, -0.44541872f, 
    0.12054636f, 0.07817268f, -0.00038326f, -0.22227761f, -0.06904578f, 0.08234616f, -0.03446591f, 0.34182712f, 
    -0.14841059f, 0.22422534f, 0.05123837f, -0.23107858f, 0.12013384f, 0.19333571f, -0.18986639f, 0.00866801f, 
    0.18742065f, 0.01810424f, -0.35104322f, -0.58209550f, -0.20561071f, -0.09767644f, 0.02704877f, -0.10366131f, 
    0.10777170f, 0.24820490f, -0.30838662f, 0.09152763f, -0.06689300f, -0.13490765f, -0.40095955f, 0.13149695f, 
    0.08929455f, -0.50237405f, -0.02546080f, -0.00346564f, -0.20714444f, 0.21394074f, 0.13478541f, 0.06533796f, 
    -0.38276592f, -0.57692486f, -0.01807160f, -0.01593329f, 0.04018617f, -0.16932319f, -0.03210783f, -0.09517866f, 
    0.19954096f, -0.00866987f, 0.11643461f, 0.03111864f, -0.37964329f, 0.04390745f, 0.27181599f, -0.02599484f, 
    -0.00220581f, 0.15297164f, -0.04783867f, -0.67412221f, -0.07345048f, 0.21035954f, -0.04188825f, 0.36901522f, 
    -0.12118895f, -0.00130306f, 0.07542782f, -0.06410065f, -0.02794063f, 0.07943817f, 0.12070371f, 0.39014974f, 
    0.18182753f, -0.58775252f, -0.13776784f, -0.15450162f, 0.10514114f, 0.18398161f, -0.09975975f, 0.05191655f, 
    -0.01738588f, 0.05251457f, 0.03830130f, -0.33556166f, -0.27523628f, -0.25835460f, -0.35618046f, -0.11732847f, 
    -0.36433485f, 0.18037875f, 0.33024958f, -0.10864338f, -0.11304160f, -0.08284196f, -0.10210085f, -0.61796314f, 
    0.05469186f, -0.24792458f, 0.16585566f, 0.05939847f, -0.20845416f, 0.22093736f, 0.15732813f, -0.11750986f, 
    0.13589068f, 0.13339812f, -0.08459105f, 0.00868464f, 0.03239971f, -0.37737733f, -0.03986124f, 0.19458795f, 
    -0.44655791f, 0.03063671f, 0.02425547f, -0.13930072f, -0.38724622f, 0.06995668f, -0.34509668f, -0.06449195f, 
    -0.29591233f, -0.16038567f, -0.04969864f, -0.06052967f, -0.09463181f, -0.01119354f, 0.24498914f, 0.09654235f, 
    0.07603122f, 0.16468871f, 0.04908549f, 0.00288349f, -0.05352530f, -0.01768279f, -0.19197537f, -0.09150418f, 
    -0.03478464f, -0.57350433f, -0.00957486f, 0.25547907f, 0.08356131f, 0.19792297f, -0.23723511f, 0.08278180f, 
    -0.24021509f, 0.06962181f, 0.14119737f, 0.39296538f, -0.44909510f, 0.04799943f, -0.34848651f, -0.03751237f, 
    -0.22645657f, 0.20362677f, -0.13038824f, 0.11570085f, -0.08257039f, -0.05934536f, -0.41097501f, 0.36710557f, 
    0.03096779f, 0.08754181f, -0.15616792f, -0.01764429f, -0.36409420f, -0.01285519f, -0.22064486f, -0.00497305f, 
    0.13139719f, -0.66913760f, -0.05907178f, -0.04309058f, 0.01079450f, 0.06988657f, -0.12988244f, 0.23332028f, 
    0.12118270f, 0.03074555f, -0.27259025f, 0.01413912f, 0.10801171f, -0.04977248f, -0.63545728f, -0.10904899f, 
    0.22091997f, 0.22790533f, -0.03218279f, -0.61714053f, -0.06979098f, 0.25452712f, 0.29822588f, -0.19218367f, 
    0.09270570f, 0.00581535f, -0.03917226f, -0.32802331f, 0.00893067f, 0.01316650f, 0.02240853f, 0.02590565f, 
    0.17934875f, -0.40333393f, -0.03957721f, 0.26999009f, 0.14718698f, -0.09858955f, -0.17056791f, -0.09661468f, 
    0.19830124f, 0.08524758f, -0.35938159f, -0.42899168f, -0.50867122f, -0.06108509f, -0.35559601f, 0.08897400f, 
    0.18693553f, -0.29149050f, -0.18776225f, -0.09252242f, -0.02182911f, 0.04730050f, 0.18696779f, 0.38895503f, 
    0.29120165f, -0.06528365f, 0.15606146f, -0.09304198f, -0.40319762f, -0.24506730f, 0.20197588f, 0.09944940f, 
    -0.15591280f, -0.05739916f, 0.00025285f, -0.12623723f, -0.10243808f, -0.11136306f, -0.01305179f, -0.17551948f, 
    -0.33693269f, 0.08870892f, 0.16328646f, -0.12811615f, 0.11196611f, -0.01621988f, 0.17723922f, -0.25819498f, 
    -0.05020404f, 0.07387958f, 0.10071655f, 0.25876004f, -0.05525923f, -0.18029547f, -0.19913541f, 0.20715344f, 
    -0.44603246f, -0.22384419f, 0.10199472f, 0.22903612f, -0.57214850f, -0.09186125f, -0.36993721f, 0.18972908f, 
    0.06076396f, 0.01710118f, -0.02432721f, -0.29426023f, 0.15871958f, -0.05634580f, -0.26771697f, -0.00773938f, 
    -0.24818039f, -0.06260201f, 0.09085952f, 0.09103096f, 0.48816273f, 0.22798130f, 0.32616764f, 0.03383676f, 
    0.11243451f, 0.27026528f, 0.09134492f, -0.02466175f, 0.06036046f, -0.07542669f, 0.02855183f, -0.18826793f, 
    -0.54247153f, 0.21386600f, 0.30254227f, -0.05845928f, 0.15832719f, -0.47838727f, 0.10941762f, 0.09634526f, 
    0.06676444f, -0.19472340f, -0.00287392f, 0.04347480f, -0.11146029f, 0.00377008f, 0.10629272f, -0.03767552f, 
    0.13571270f, -0.05999457f, 0.36791143f, 0.12873206f, -0.59390867f, -0.14261703f, 0.18823944f, -0.31665376f, 
    0.05539614f, -0.18210334f, -0.10688286f, -0.28763777f, -0.08951031f, -0.21265927f, -0.22481279f, 0.05250338f, 
    0.00598596f, -0.51708901f, 0.02743641f, -0.09749635f, 0.26566541f, 0.00108673f, -0.58618790f, -0.27435768f, 
    0.18467444f, -0.10734446f, 0.05150013f, 0.22451873f, -0.13945909f, -0.12814657f, -0.24086212f, 0.02857055f, 
    0.07801364f, -0.06448849f, -0.42527816f, 0.11205222f, -0.60087895f, -0.42302799f, 0.11184371f, -0.05378094f, 
    0.07652775f, -0.55049849f, -0.00529603f, -0.02490504f, 0.02920167f, 0.06871123f, 0.31301439f, -0.02068004f, 
    -0.05515680f, 0.31675747f, 0.11467528f, -0.04005108f, 0.28642145f, 0.43600550f, -0.40260497f, 0.10349292f, 
    0.40226129f, -0.21245803f, 0.10256151f, -0.08567110f, -0.00822409f, 0.05639292f, 0.08539628f, -0.21578799f, 
    -0.06930432f, -0.10869912f, 0.13079369f, 0.10143944f, -0.15587673f, 0.07691245f, -0.01215333f, -0.20600860f, 
    -0.13851298f, 0.03232877f, -0.01913761f, 0.14156882f, 0.00122726f, 0.04983331f, 0.17668219f, -0.47311988f, 
    -0.11630779f, 0.14841409f, 0.06509849f, 0.33991605f, -0.24181348f, -0.05820774f, 0.38032469f, -0.23410597f, 
    0.18349685f, -0.50362700f, -0.05377724f, -0.07732564f, 0.09794457f, 0.17451108f, 0.00007059f, 0.03652418f, 
    0.09094904f, 0.03432618f, -0.43060204f, 0.23333503f, 0.13174881f, -0.21301755f, -0.31841862f, -0.04878839f, 
    -0.24800074f, -0.32161233f, -0.19663765f, -0.03505239f, -0.03684399f, -0.04112822f, 0.04701496f, -0.50928831f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07986266f, -0.00044098f, 0.23657969f, -0.07309150f, -0.17175727f, 0.11368324f, -0.04079641f, 0.06142226f, 
    0.03519757f, -0.06491313f, 0.11229741f, -0.09681229f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
