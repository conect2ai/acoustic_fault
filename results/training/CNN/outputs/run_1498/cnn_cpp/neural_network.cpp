#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.45533875f, -0.46936506f, 0.00645838f, -0.17086411f, -0.02397970f, -0.01615456f, 0.02282734f, 0.19088468f, 
    -0.10608121f, 0.10816491f, -0.28178895f, -0.35874012f, 0.50025702f, -0.30034348f, 0.11015383f, -0.35217226f, 
    -0.27136946f, 0.28413075f, 0.34944287f, -0.24909185f, -0.14397816f, 0.16014816f, -0.00316761f, 0.06435393f, 
    0.26096594f, 0.42449436f, 0.01029548f, -0.11858253f, -0.24596895f, 0.54295862f, -0.32215214f, -0.12296616f, 
    -0.29205570f, -0.21530409f, -0.02335614f, 0.15709950f, 0.06178961f, -0.12204651f, 0.11682188f, 0.25607648f, 
    0.21327716f, 0.40178561f, -0.07923434f, -0.18469563f, -0.05241115f, -0.33928111f, 0.18468393f, 0.12044016f, 
    0.13400848f, -0.00554293f, 0.29743290f, 0.16241311f, -0.36115912f, -0.33202130f, -0.18821411f, -0.08044863f, 
    -0.26544422f, 0.33296376f, 0.08799817f, -0.00023441f, 0.19513236f, 0.00254080f, 0.11473032f, -0.15636119f, 
    0.17332500f, -0.27614608f, -0.13799995f, -0.05711195f, 0.22564283f, -0.27631885f, 0.06959607f, 0.17931819f, 
    0.14831862f, -0.03350731f, 0.35403129f, 0.21063837f, 0.54787701f, 0.56785196f, -0.27602357f, 0.12899360f, 
    -0.32008082f, -0.07009688f, 0.34183607f, -0.09936462f, -0.44146955f, -0.38821614f, 0.09375419f, 0.08185657f, 
    -0.00197078f, -0.08071557f, -0.05613649f, -0.17836291f, -0.05417891f, 0.17736320f, 0.01745981f, -0.10880495f, 
    0.26273757f, -0.15613939f, -0.13978761f, 0.05765390f, 0.35919422f, -0.69912189f, -0.17373139f, 0.18674266f, 
    0.31159273f, 0.45210528f, 0.37697968f, 0.24460544f, -0.38831040f, 0.12411175f, -0.43542129f, -0.29400477f, 
    0.27516678f, -0.25796625f, -0.33110774f, 0.17982738f, 0.21889706f, -0.07881913f, -0.24593800f, -0.31608936f, 
    -0.06864567f, -0.03531132f, -0.22991489f, -0.29406768f, -0.26326588f, -0.08988686f, -1.22265208f, -0.41868499f, 
    -0.21977845f, 0.68233043f, -0.33762807f, -0.01073820f, 0.31581292f, 0.26706034f, -0.19648048f, 0.20688072f, 
    -0.08943853f, 0.21473803f, -0.11576402f, 0.27498674f, -0.03807943f, 0.01512753f, -0.10019312f, -0.02822270f, 
    0.02484527f, -0.12958959f, -0.33668447f, -0.04537960f, -0.05476905f, 0.17734930f, 0.18178272f, 0.14363067f, 
    0.18729983f, 0.07308759f, 0.20057498f, 0.36663005f, 0.27988753f, -0.22328782f, -0.21006992f, -0.22070496f, 
    0.39143050f, -0.12733932f, -0.04376526f, -0.25462148f, 0.02446920f, -0.36330807f, 0.06857074f, 0.10846824f, 
    -0.05885895f, -0.27994591f, 0.35704869f, 0.05691185f, -0.30006573f, -0.07355837f, -0.09983070f, -0.10773311f, 
    0.50226671f, 0.40220883f, 0.20098759f, 0.00157131f, -0.16792054f, -0.59427595f, -0.41573524f, 0.13734651f, 
    0.16304561f, -0.05285738f, -0.25707206f, -0.23237076f, -0.06909634f, 0.40389201f, 0.28012204f, 0.03942297f, 
    0.12415319f, 0.12310102f, -0.23856357f, -0.07070755f, -0.00109741f, -0.23367099f, 0.08514322f, -0.39237159f, 
    0.23299037f, 0.61229753f, -0.26369789f, -0.57517093f, -0.16345730f, -0.14545023f, -0.22013929f, 0.21806522f, 
    0.11326724f, -0.25265348f, 0.26913419f, 0.19140534f, 0.13688554f, -0.20683715f, -0.02252218f, -0.09273175f, 
    -0.12492047f, -0.23300804f, -0.39542657f, -0.52335471f, -0.03084844f, -0.21641392f, -0.24240123f, -0.43079552f, 
    -0.59951091f, -0.46999457f, 0.59886450f, -0.62697810f, -0.85349852f, -0.16521707f, 0.29170680f, -0.11207120f, 
    -0.25749239f, -0.69462925f, 0.66106784f, -0.11068080f, 0.22597098f, 0.21757372f, 0.12656282f, -0.14393847f, 
    0.19584903f, -0.00982738f, -0.04809339f, 0.07018549f, -0.27454212f, 0.16638947f, 0.13883695f, -0.21453840f, 
    0.07673112f, 0.26269069f, -0.97653210f, -0.63203019f, -0.46475342f, -0.32726237f, -0.30289045f, 0.57261670f, 
    0.51036572f, 0.09385837f, 0.31999367f, 0.53976166f, -0.02086433f, 0.12337810f, -0.20749755f, 0.14146802f, 
    -0.18964294f, -0.17421514f, 0.11896960f, -0.30929804f, -0.15180607f, -0.03677097f, -0.14114667f, -0.11831086f, 
    0.05239612f, 0.13441798f, -0.10696138f, -1.00380135f, -0.35971889f, -0.44870448f, -0.29248759f, -0.53574908f, 
    0.19021207f, 0.28150332f, 0.21357124f, 0.18719661f, 0.32657382f, 0.05952285f, 0.13563897f, 0.22136143f, 
    -0.02261212f, 0.05353869f, -0.02900664f, 0.00546506f, -0.10086920f, 0.29378355f, 0.23228075f, -0.01649522f, 
    0.26219556f, 0.14840099f, -0.16678776f, -0.22099149f, -0.49218383f, -0.20046578f, -0.06828220f, -0.43893966f, 
    0.23585974f, 0.17322274f, 0.52302408f, 0.54488760f, 0.06984773f, -0.58613062f, -0.42673525f, 0.01349157f, 
    -0.26052374f, -0.10892475f, 0.46016669f, -0.13113771f, -0.15236524f, -0.26734042f, -0.23590606f, 0.02854653f, 
    -0.22910979f, -0.13922791f, 0.18220715f, 0.07318138f, -0.31869742f, -0.10812718f, 0.31619638f, 0.28408879f, 
    -0.08287959f, -0.06107358f, 0.29802984f, 0.51720214f, 0.26169205f, 0.08828937f, -0.18146713f, 0.14363115f, 
    -0.02268736f, 0.09329482f, 0.16626008f, -0.25208041f, 0.17986943f, -0.12300976f, -0.00804528f, -0.17128453f, 
    0.07639726f, -0.15710610f, 0.24263258f, -0.00946418f, -0.11835046f, 0.11631283f, -0.11334056f, -0.06913555f, 
    -0.10229957f, 0.12527205f, 0.08331838f, -0.22221366f, 0.13665433f, 0.15379532f, 0.16269098f, 0.35537910f, 
    -0.06624807f, 0.16218731f, -0.20587732f, -0.07666907f, 0.38642010f, -0.15663373f, -0.17366053f, -0.09663592f, 
    -0.18491583f, 0.20891014f, 0.01498832f, -0.04823319f, 0.11716347f, 0.28643471f, -0.21299982f, -1.01001000f, 
    -0.78579205f, -0.54679906f, 0.38646576f, -0.06715014f, 0.88290763f, 0.59529310f, -0.50042629f, -0.43656725f, 
    -0.00702247f, -0.29191962f, 0.09712447f, 0.03870744f, -0.33203971f, -0.14106269f, 0.22839475f, 0.02879161f, 
    -0.15765256f, -0.10064054f, 0.26506415f, 0.13788252f, -0.15748484f, -0.21461664f, 0.13507636f, -0.34725073f, 
    -0.02819245f, -0.51194441f, -0.64089078f, -0.55613339f, -0.52474856f, -0.43230408f, -0.21719341f, -0.52068955f, 
    -0.30343068f, -0.39230731f, 0.03023882f, 0.18996857f, 0.25391912f, -0.17757182f, -0.23039025f, -0.30577138f, 
    -0.37454888f, -0.09092515f, 0.05093428f, -0.04270478f, -0.26797226f, -0.23681083f, -0.23241037f, -0.18978181f, 
    -0.45420045f, 0.06348642f, 0.63075757f, 0.29977924f, -0.31590575f, 0.03442474f, -0.22703306f, -0.51532543f, 
    -0.38585937f, -0.03323141f, -0.31929123f, 0.03765881f, 0.14007020f, 0.05220531f, -0.01065158f, 0.02015630f, 
    0.19475450f, 0.17523178f, 0.41784883f, -0.07497357f, 0.12777141f, 0.22351503f, 0.00054303f, -0.28659266f, 
    0.21625133f, -0.18403167f, -0.19170713f, -0.13946626f, -0.06182846f, 0.01989340f, 0.41732860f, -0.44876656f, 
    -0.22005536f, 0.37745342f, -0.07517213f, -0.11347663f, 0.05714393f, 0.17351729f, 0.22289398f, -0.23033956f, 
    -0.11417338f, -0.22901496f, 0.13275069f, 0.26025933f, -0.07521137f, -0.38935861f, -0.19548357f, 0.14822344f, 
    0.19395649f, 0.22671470f, 0.13038221f, -0.02738087f, 0.31612563f, -0.55318856f, -0.30487558f, -0.66804779f, 
    -0.51508063f, -0.45089993f, -0.37364617f, 0.09437095f, 0.46532816f, 0.13416414f, 0.03482984f, 0.05117471f, 
    0.26364687f, 0.40204525f, 0.03904990f, -0.07604106f, -0.10603580f, -0.42751825f, -0.33864382f, -0.14647716f, 
    0.12244116f, -0.29535154f, -0.17411384f, -0.33657965f, 0.39070398f, -0.48265019f, 0.19742922f, 0.42448875f, 
    -0.52423757f, -0.68651879f, -0.45099530f, -0.53399175f, -0.38500139f, -0.62399274f, 0.65164930f, -0.28336969f, 
    -0.09270643f, 0.30199111f, 0.29057223f, -0.14693959f, -0.01061295f, 0.08026541f, 0.19761495f, -0.48010653f, 
    -0.21817030f, -0.14341530f, 0.00908340f, 0.33492389f, 0.20368151f, -0.50774330f, -0.03213695f, 0.63919955f, 
    0.35504207f, -0.47990027f, -0.09674317f, -0.33487007f, 0.32615450f, -0.36629343f, -0.29758075f, -0.15055463f, 
    -0.35633308f, -0.03095101f, -0.13031180f, 0.11188992f, -0.11796572f, 0.03567901f, 0.13203351f, -0.04298806f, 
    0.50776148f, 0.09222056f, 0.06906962f, -0.09036286f, -0.16005963f, -0.10091275f, 0.36588478f, -0.98311818f, 
    -0.77643830f, 0.39998904f, -0.01872290f, 0.55009782f, 0.69405109f, 0.44062340f, -0.26045042f, -0.39544183f, 
    -0.04892132f, 0.26283082f, 0.06832904f, 0.04809435f, 0.16207702f, 0.01289158f, -0.20852841f, -0.08761909f, 
    -0.19861326f, -0.11292211f, 0.07071852f, -0.09541556f, 0.08584694f, 0.22301155f, 0.05422899f, 0.70300651f, 
    0.64541048f, 0.03903449f, -0.05710889f, -0.61300737f, 0.03063921f, -0.34610924f, -0.25378832f, 0.14201666f, 
    -0.10334495f, -0.12698761f, 0.08119912f, 0.17895606f, 0.19464654f, 0.02647621f, -0.39071530f, -0.19906080f, 
    0.08317757f, 0.00514043f, 0.19100797f, 0.24543919f, 0.04678961f, -0.12746046f, -0.15788472f, -0.04590501f, 
    0.51895475f, 0.00479602f, -0.39877683f, 0.19657367f, -0.16546354f, 0.42631891f, 0.22424109f, 0.16882870f, 
    0.08399070f, 0.29940870f, -0.19500773f, 0.27905902f, -0.37674168f, -0.33583596f, -0.12315923f, -0.03946814f, 
    0.13092136f, 0.17207409f, -0.12130241f, -0.29402426f, -0.06778182f, 0.07759716f, 0.06028138f, -0.07184927f, 
    -0.04513523f, 0.03584966f, -0.29120854f, -0.70012534f, -0.18773092f, 0.21951090f, -0.44018552f, -0.07353590f, 
    -0.00997928f, -1.09741533f, -0.96296674f, -0.31365025f, -0.51327968f, -0.29616094f, 0.10911099f, -0.14086805f, 
    -0.21208780f, -0.30273318f, -0.15878415f, -0.27526259f, 0.02068405f, 0.17953603f, -0.14909473f, -0.08399773f, 
    0.11226465f, -0.31186971f, -0.48274165f, -0.25734890f, -0.00434371f, 0.31975010f, 0.07713201f, -0.15541881f, 
    -0.38220730f, -0.18019515f, 0.30244839f, -0.59309971f, -0.16115601f, -0.50124168f, -0.12634943f, 0.00484176f, 
    -0.19585919f, -0.27621835f, -0.25306907f, -0.17108950f, -0.20239471f, 0.31941670f, 0.04603257f, 0.16183007f, 
    -0.09057669f, -0.15881008f, -0.12382168f, 1.05554128f, 0.65578198f, 0.14828673f, -0.76149964f, -0.99397421f, 
    0.54363394f, 0.07216424f, 0.26336721f, -0.45723224f, -0.23901054f, -0.25395215f, -0.00891959f, -0.01527612f, 
    0.27518237f, -0.28148723f, 0.38765562f, -0.19834228f, -0.18066999f, -0.05559822f, -0.09790555f, 0.18663806f, 
    0.01029466f, -0.27193671f, 0.19812639f, 0.00503290f, -0.06468487f, 0.27071062f, 0.24430427f, -0.46678829f, 
    -0.25960341f, 0.13567768f, 0.35042715f, 0.17880629f, -0.34337103f, -0.24920009f, -0.08976220f, 0.54290694f, 
    -0.40962476f, -0.05734948f, 0.24090017f, 0.17190713f, 0.29814804f, -0.12789601f, -0.16581045f, -0.29711416f, 
    -0.09687026f, -0.20900187f, 0.04370042f, 0.13498494f, 0.23171932f, -0.30888969f, -0.16485488f, -0.13670857f, 
    0.04858216f, -0.10237743f, -0.09434260f, 0.02206393f, -0.37558597f, 0.27048054f, -0.25840777f, -0.11673430f, 
    0.53955853f, -0.19434309f, 0.64956141f, -0.16733916f, -0.22520594f, -0.09454850f, -0.45986795f, -0.01216577f, 
    -0.27754262f, 0.20913728f, -0.06981141f, 0.01801461f, 0.30107442f, -0.09365692f, -0.60035276f, -0.31530103f, 
    -0.49201271f, 0.40187895f, 0.71377158f, 0.37316090f, -0.19845913f, -0.21875294f, 0.29717574f, 0.63884860f, 
    -0.30631968f, -0.37557128f, -0.47106445f, -0.09216051f, -0.12555060f, 0.19438347f, 0.11302336f, -0.25920075f, 
    0.46002075f, 0.10274758f, -0.09674760f, -0.39653566f, 0.12244528f, -0.28020683f, -0.35386607f, -0.75021404f, 
    0.61491561f, -0.37700832f, -0.35894027f, 0.10859854f, -0.72086990f, -0.37978345f, -0.23070185f, -0.04730170f, 
    -0.44363469f, -0.03597387f, 0.25074202f, -0.28533006f, -0.25787091f, -0.37474212f, -0.09570054f, -0.12240693f, 
    -0.16051906f, -0.51003176f, -0.06934024f, -0.22776406f, 0.05478457f, -0.02961350f, 0.06215360f, 0.28416625f, 
    -0.70873421f, 0.26700336f, -0.28851885f, 0.23282976f, 0.21791968f, 0.11162083f, -0.40583324f, 0.06378276f, 
    0.30904227f, 0.15278192f, 0.00410372f, -0.03004734f, -0.30827951f, -0.07643931f, 0.24447255f, -0.09760468f, 
    -0.14063960f, -0.06584293f, -0.17593651f, -0.01785284f, 0.08863693f, 0.10403141f, 0.38522813f, 0.17783996f, 
    0.05690220f, -0.33205429f, -0.20486602f, -0.15430227f, -0.11246474f, 0.28929532f, 0.06659196f, -0.07364933f, 
    -0.28240472f, -0.03936138f, 0.17956463f, 0.23607382f, 0.46746060f, 0.04252716f, 0.16431656f, -0.41931799f, 
    -0.00114469f, 0.08440220f, 0.06262776f, -0.23989007f, -0.38584322f, -0.02784024f, 0.42136234f, 0.24438702f, 
    0.03651671f, 0.25448197f, 0.61440837f, 0.31790486f, -0.15063247f, -0.02288608f, -0.42051223f, 0.16193490f, 
    0.07315156f, 0.12228677f, -0.04827064f, 0.07663313f, -0.06548943f, 0.27811351f, -0.24820527f, -0.28841132f, 
    0.04028280f, 0.19132352f, -0.18491450f, 0.22481719f, -0.28047159f, 0.05051366f, -0.07171880f, 0.00882322f, 
    -0.09649785f, -0.01570991f, 0.07848526f, -0.82341403f, -0.48979563f, 0.51079899f, 0.35906702f, 0.11617639f, 
    0.17276844f, -0.31249517f, 0.27743977f, -0.33496875f, 0.37610847f, 0.08785435f, 0.18311088f, 0.36587778f, 
    -0.18488514f, -0.50489038f, -0.22821067f, -0.12574275f, -0.14738198f, 0.16249992f, 0.09458244f, -0.16032705f, 
    -0.31009707f, 0.01178281f, 0.00228938f, -0.04823456f, -0.60536307f, -0.83250189f, 0.44024456f, 0.66124839f, 
    -0.03717986f, -0.64774489f, 0.30873063f, -0.61685759f, -0.53785831f, -0.08398982f, -0.09827761f, -0.33075979f, 
    -0.06078281f, -0.17393090f, -0.05742655f, -0.03584404f, -0.59589577f, 0.17293772f, 0.25347570f, -0.26987657f, 
    0.17779522f, -0.16830371f, -0.10426937f, -0.05404640f, 0.36911997f, -0.85774857f, -0.36682966f, -0.55720907f, 
    -0.61288738f, -0.26275930f, -0.04528328f, 0.06269031f, -0.37572065f, -0.29452300f, -0.05601093f, -0.17340028f, 
    -0.43500081f, -0.26477614f, -0.56707639f, -0.29650176f, 0.28375256f, 0.14081582f, -0.20307761f, 0.11915544f, 
    0.07196426f, -0.01006375f, -0.11166341f, -0.00721224f, -0.05863911f, -0.12001605f, -0.01895164f, 0.53343737f, 
    0.40499863f, -0.14830744f, 0.28846961f, -0.22133663f, -0.37396756f, -0.14213885f, 0.32858154f, 0.30181244f, 
    0.22519353f, -0.09751199f, -0.25911689f, 0.27895123f, -0.15125808f, 0.02644665f, -0.17153341f, -0.13450989f, 
    -0.00498154f, 0.06946392f, 0.10539982f, -0.14570008f, -0.19855894f, 0.21966989f, -0.25830290f, 0.70454156f, 
    -0.72060651f, -0.84290206f, -0.47683731f, -0.29945588f, 0.40540841f, 0.28647652f, 0.54303402f, -0.11973722f, 
    0.10327139f, 0.08850957f, 0.27809867f, 0.16413480f, -0.42488772f, -0.12717599f, -0.06462411f, 0.06079937f, 
    0.10273536f, -0.23549668f, 0.36057582f, -0.01700922f, -0.20168392f, 0.06090771f, 0.32701582f, -0.23035234f, 
    -0.30134141f, -0.30218595f, -0.45482272f, -0.74870205f, -0.50971365f, 0.47535884f, 0.00203604f, 0.02812230f, 
    0.10854094f, 0.07573258f, 0.21202458f, -0.19012716f, -0.17527303f, 0.03659499f, 0.24782629f, -0.48326594f, 
    -0.09884506f, -0.25789043f, -0.50736803f, -0.34317642f, 0.13555060f, -0.01204239f, 0.14205799f, 0.34732926f, 
    0.27798501f, 0.10502960f, 0.28299451f, 0.22358491f, 0.16449744f, 0.06938562f, 0.26001406f, -0.03806603f, 
    -0.25882602f, -0.12262170f, -0.14281631f, 0.13802023f, 0.24781224f, 0.09677479f, -0.02666261f, 0.11763502f, 
    0.11678295f, -0.02458097f, 0.10482661f, 0.20067824f, -0.16809313f, 0.09892634f, 0.10676474f, -0.21133012f, 
    0.15142642f, 0.22887287f, -0.26419967f, -0.39458278f, -0.80010468f, -0.68822867f, -0.70211941f, 0.56866050f, 
    0.26815063f, 0.27475616f, -0.08865001f, -0.18453784f, -0.08721308f, -0.08617612f, 0.08551757f, 0.06633200f, 
    -0.04347287f, 0.06949975f, -0.02323528f, -0.02589515f, -0.06223698f, -0.08337506f, -0.16591905f, -0.01346609f, 
    0.11535396f, -0.16296569f, -0.26445064f, -0.25716519f, -0.34170803f, -0.00737276f, -0.11352056f, 0.14803684f, 
    0.11878463f, 0.10221961f, -0.65056145f, -0.57096344f, -0.40835410f, -0.30460754f, -0.07884641f, 0.13341579f, 
    -0.35603353f, 0.03943546f, 0.09975889f, -0.12845528f, -0.06729316f, 0.27862719f, -0.16794454f, -0.11878221f, 
    0.14490452f, 0.13629843f, 0.20920646f, 0.24706608f, -0.15903705f, -0.06204933f, -0.33424336f, -0.53530133f, 
    -0.48717096f, 0.32280985f, 0.15591790f, 0.00407030f, 0.27284452f, 0.37687182f, 0.04505377f, 0.43380359f, 
    0.05828429f, -0.26317921f, -0.15843706f, -0.19281049f, 0.02153785f, -0.06547274f, -0.02185092f, 0.23919296f, 
    0.07210772f, -0.04887317f, 0.08976309f, 0.14859962f, -0.13851917f, 0.43885589f, -0.76280671f, -0.52273154f, 
    0.13086107f, 0.54277992f, 0.15873924f, 0.18493120f, 0.16843781f, -0.14397910f, -0.00832644f, -0.03261493f, 
    -0.34126800f, -0.08765803f, -0.24733922f, 0.09491701f, 0.24020432f, -0.11798093f, 0.00812170f, -0.04340030f, 
    -0.44656274f, -0.28218955f, -0.34249049f, -0.29766610f, -0.37570718f, -0.48035783f, -0.54626590f, 0.05910844f, 
    -0.31950364f, -0.58203620f, -0.35193110f, -0.09871422f, 0.29019755f, 0.19667970f, 0.25292012f, 0.06690422f, 
    0.18222161f, 0.23731038f, -0.05961713f, 0.22701751f, 0.08814151f, 0.12534994f, 0.21895951f, -0.17336163f, 
    0.09643477f, -0.23130955f, -0.21889219f, -0.27701205f, -0.03711728f, -0.06580199f, -0.24120457f, -0.18983628f, 
    -0.20838991f, -0.13804531f, 0.18392116f, 0.15959391f, -0.02296782f, -0.28091049f, 0.23155777f, 0.35777768f, 
    0.43291250f, -0.06860643f, 0.15335308f, -0.26677638f, 0.08157211f, -0.13614519f, -0.04160027f, -0.11883820f, 
    0.33726025f, 0.16260825f, -0.14835878f, 0.34855044f, 0.09641922f, 0.31389061f, 0.03307493f, -0.00591014f, 
    0.50569856f, 0.14979200f, -0.53519595f, -0.22774559f, -0.15095608f, 0.27407113f, -0.11941635f, 0.10276523f, 
    0.00109955f, 0.16802897f, -0.24582194f, 0.36448234f, 0.01868998f, -0.29742560f, 0.14250374f, 0.02982666f, 
    -0.31990609f, 0.16989407f, -0.16090663f, -0.37665635f, -0.08672836f, 0.25990474f, 0.24093981f, 0.12683439f, 
    0.13812624f, -0.82568765f, -0.78347510f, 0.19217347f, 0.04422733f, 0.53065282f, 0.70392501f, 0.15137193f, 
    -0.17062280f, 0.02931040f, 0.15621606f, -0.23834537f, -0.01152272f, 0.15121488f, -0.06362271f, -0.06104263f, 
    -0.01497941f, 0.05937432f, -0.13044868f, 0.17451452f, 0.00030868f, 0.14807548f, -0.09217816f, -0.17602661f, 
    0.13890024f, 0.28494596f, -0.36111137f, 0.19048645f, 0.34228018f, -0.15685336f, -0.67472535f, 0.61958897f, 
    0.10998352f, -0.50999433f, 0.04385300f, 0.52489638f, -0.12972572f, 0.05137318f, -0.03402763f, -0.23044585f, 
    0.19071434f, 0.00595029f, 0.04480886f, -0.19070958f, 0.04353905f, -0.42419550f, -0.45243800f, 0.29252842f, 
    -0.07436688f, 0.22411019f, -0.35313100f, 0.10772976f, -0.18256368f, 0.13474861f, -0.18077734f, 0.24579538f, 
    0.45051637f, -0.31559497f, -0.17630178f, -0.46886450f, 0.31448060f, -0.10638374f, -0.03578674f, -0.08370305f, 
    0.17045243f, -0.21845202f, 0.20468707f, 0.03825667f, 0.14897585f, 0.00808857f, -0.37083921f, -0.34011397f, 
    0.09161137f, 0.13503666f, 0.19367550f, 0.01720742f, 0.20473889f, -0.58874911f, 0.53621805f, 0.90909213f, 
    0.14132804f, -0.43745685f, -0.59321874f, -0.12341412f, -0.28120708f, -0.23906766f, 0.11491166f, 0.04255813f, 
    -0.09598263f, 0.01145458f, 0.05863647f, -0.21752140f, -0.02397110f, 0.04477966f, -0.17687470f, 0.18401594f, 
    -0.17243682f, 0.20667702f, -0.25948393f, 0.04392307f, -0.19604009f, 0.18356015f, -0.16981392f, 0.13202119f, 
    0.24580093f, -0.50303710f, 0.46817774f, -0.07087425f, -0.00428101f, 0.03136798f, 0.12423040f, 0.02169701f, 
    0.44535333f, -0.35835254f, -0.33682331f, -0.26471889f, 0.34746790f, -0.27169612f, -0.19734040f, -0.03767909f, 
    -0.17265624f, -0.09079453f, -0.08615802f, 0.05679474f, 0.17995711f, 0.30966839f, -0.23019850f, -0.48488116f, 
    -0.09979749f, -0.56358939f, -0.48193598f, 0.52884740f, 0.09461515f, 0.12344692f, -0.27397600f, -0.20875618f, 
    0.00212631f, 0.40553004f, -0.37894633f, 0.42812964f, -0.58956611f, -0.27068770f, 0.00845603f, -0.02081540f, 
    0.41914713f, 0.10110445f, 0.00356863f, 0.21374109f, 0.27325532f, -0.36868569f, -0.48812369f, -0.63587767f, 
    -0.58617985f, -0.04313765f, -0.12134731f, 0.60701531f, -0.35058314f, -0.35630918f, -0.00921548f, -0.32653654f, 
    -0.51539111f, 0.15890041f, 0.14691819f, 0.34466049f, 0.05146944f, -0.25628313f, -0.20949912f, 0.21849087f, 
    -0.19152856f, 0.34466916f, 0.19716495f, 0.20215315f, -0.16346577f, -0.34594545f, 0.34107381f, -0.03356515f, 
    0.69246083f, -0.37171102f, 0.09984474f, 0.39510778f, -0.44254953f, 0.15461060f, 0.36162370f, 0.23106615f, 
    -0.43790141f, -0.23441358f, -0.08967283f, 0.03708405f, -0.11494960f, -0.18006942f, -0.08399782f, -0.08445263f, 
    -0.14199148f, 0.04932258f, -0.05889620f, 0.15592678f, -0.13152283f, -0.20295157f, 0.05513177f, 0.21577543f, 
    -0.08735880f, 0.52160937f, 0.61085922f, 0.44499072f, -0.25651816f, 0.17752925f, -0.20001039f, -0.18613349f, 
    -0.13752081f, -0.18330887f, -0.42854500f, -0.04920971f, 0.44320154f, 0.08195718f, -0.26020208f, -0.02297617f, 
    -0.00984727f, 0.12889193f, 0.07647122f, -0.29014862f, 0.19693483f, -0.31453606f, 0.00635197f, -0.00370765f, 
    0.06510203f, -0.18220711f, 0.65957224f, -0.00553782f, -0.76606035f, -0.44179088f, 0.14850314f, -0.11921398f, 
    -0.10705290f, 0.45747095f, -0.03187064f, 0.27085456f, -0.27659354f, 0.13801134f, 0.15624313f, -0.33615351f, 
    -0.25768414f, 0.13718937f, 0.13058615f, 0.21973208f, 0.01263908f, -0.22728395f, 0.17347263f, -0.19763254f, 
    -0.30717561f, 0.19428250f, 0.27229574f, -1.48415935f, 0.81127840f, 0.18307343f, -0.67348379f, 0.43745536f, 
    -0.25859284f, -0.28191420f, 0.81188685f, 0.13493146f, 0.10853152f, -0.08710490f, -0.20037420f, -0.00927148f, 
    -0.34494078f, 0.16801535f, 0.13297929f, -0.03391756f, -0.10660022f, 0.12525995f, 0.00785465f, -0.00539209f, 
    0.02259260f, 0.29120147f, -0.16805944f, -0.18668382f, -0.49927598f, -0.28259614f, -0.59321243f, -0.31324193f, 
    -0.43854052f, -0.46824893f, -0.40134543f, -0.51047438f, -0.45477071f, -0.17918421f, -0.01661609f, 0.02404901f, 
    0.13555028f, 0.09168898f, -0.02326093f, -0.03068639f, 0.02467242f, 0.11233860f, -0.05047313f, -0.15230231f, 
    0.00701155f, 0.26624456f, 0.28209189f, 0.29922110f, 0.15878980f, -0.76296878f, -0.19792300f, -0.76580811f, 
    -0.81389582f, -0.10119028f, 0.18419494f, -0.05748535f, -0.08021206f, 0.08893353f, 0.07150576f, -0.49942753f, 
    -0.56942779f, -0.47522196f, -0.15071669f, -0.33604142f, -0.21523251f, -0.30170289f, -0.07104729f, 0.05962108f, 
    -0.40065172f, -0.06200069f, 0.08482621f, -0.12486159f, 0.12905172f, -0.01702466f, 0.04483180f, 0.82101756f, 
    0.63542283f, -0.42701513f, -0.29394686f, -0.62062395f, 0.11455341f, -0.36169478f, -0.34426633f, -0.65482503f, 
    0.03628323f, -0.14227749f, -0.30355245f, -0.27965465f, 0.31834173f, 0.23022674f, -0.15876412f, 0.16160758f, 
    0.28361011f, 0.16582134f, 0.09524929f, -0.05566008f, -0.27749902f, -0.03248847f, -0.24622868f, -0.66230464f, 
    0.42812642f, -0.10431609f, -0.95658261f, -0.07777635f, -0.22215639f, -0.15539879f, -0.24866456f, -0.43366900f, 
    -0.58307642f, 0.32316530f, 0.42149410f, -0.22016330f, -0.09787787f, -0.14531840f, -0.29309291f, -0.31016511f, 
    -0.43539527f, -0.22190502f, -0.23134758f, 0.12276392f, 0.00024594f, -0.09381870f, 0.10649284f, -0.30360195f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14913778f, 0.21595150f, 0.15286173f, 0.31868786f, 0.16972254f, 0.31350183f, 0.11726283f, 0.12113199f, 
    -0.13366084f, -0.03887031f, 0.08227961f, -0.17606334f, 0.05397503f, -0.00186425f, 0.44305310f, -0.00953498f, 
    -0.25511962f, 0.06103637f, 0.23259456f, 0.02458704f, 0.11450602f, 0.22882770f, 0.29660869f, 0.44101220f, 
    0.18767017f, -0.21032792f, 0.06181134f, 0.30459747f, 0.49913001f, 0.24215169f, -0.03529662f, 0.13673928f, 
    0.19031405f, 0.25263137f, 0.30458379f, 0.12958236f, 0.27764809f, -0.40767056f, 0.06848969f, 0.36338091f, 
    0.00368200f, 0.15977068f, -0.07119899f, 0.33169156f, 0.01232831f, 0.20234671f, 0.05190027f, 0.03290939f, 
    0.19381514f, 0.21706776f, 0.15912038f, 0.24498914f, 0.10786615f, 0.17840283f, 0.26179478f, 0.09569199f, 
    0.44279426f, 0.05523920f, 0.17708026f, 0.23499677f, -0.18482512f, -0.36617878f, -0.02017538f, 0.07948615f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.27755138f, -0.12895274f, -0.00238996f, 0.13824730f, -0.02220664f, 0.02184675f, -0.03926073f, -0.01849604f, 
    0.10856195f, -0.10319671f, -0.19303149f, 0.03911909f, 0.02938457f, 0.14390175f, -0.10475579f, -0.03749914f, 
    -0.00308435f, -0.15499322f, -0.14415884f, -0.23635678f, -0.06755549f, -0.02941789f, -0.00743112f, -0.04876995f, 
    0.02395102f, -0.11389064f, -0.06538894f, 0.05016845f, 0.04676247f, -0.14633092f, -0.07308441f, -0.09687144f, 
    -0.08383317f, -0.08110232f, -0.12181638f, -0.11639532f, -0.49237320f, -0.30411425f, -0.02540769f, 0.27730349f, 
    0.05660299f, 0.01824221f, -0.00562223f, 0.04785888f, -0.01039201f, 0.03456105f, 0.04143929f, -0.00662215f, 
    0.17994784f, -0.29587105f, -0.14873077f, 0.14867662f, 0.02255446f, -0.03911289f, 0.03815187f, -0.02460210f, 
    0.18234403f, 0.17779475f, 0.01526150f, 0.07070372f, 0.13213409f, -0.01788611f, 0.03937891f, -0.09379258f, 
    0.04831999f, 0.07271921f, 0.06108842f, -0.09177890f, -0.06297512f, -0.03999481f, -0.05015911f, -0.06300186f, 
    -0.11621547f, -0.25127888f, -0.03124229f, 0.16116367f, -0.01252848f, -0.01678102f, 0.01722953f, 0.01262137f, 
    -0.00903748f, -0.05773985f, -0.01433425f, 0.07074823f, -0.27351651f, 0.22578616f, 0.11519138f, -0.16284463f, 
    0.01885962f, -0.13113239f, -0.13923043f, -0.14028990f, 0.02185118f, -0.12442639f, -0.02119807f, 0.05668316f, 
    0.04777658f, -0.19496106f, -0.22660045f, 0.05564944f, -0.03441134f, 0.02447186f, -0.02215544f, -0.00618715f, 
    -0.01798527f, 0.05863784f, 0.00334823f, 0.15942885f, 0.18339960f, 0.15847345f, -0.27514857f, -0.00651331f, 
    0.03380555f, 0.19688745f, -0.00525708f, -0.19551127f, -0.05121453f, -0.03921064f, 0.00945461f, 0.05221081f, 
    0.19317579f, -0.01498945f, -0.12665339f, -0.01124535f, 0.11606850f, 0.12201649f, 0.06700831f, -0.01985998f, 
    -0.08132258f, 0.15624404f, -0.10540246f, -0.06555448f, 0.24506481f, 0.11939641f, 0.03757824f, -0.03478764f, 
    0.14869106f, 0.13669650f, 0.06903585f, -0.08646566f, -0.02583999f, 0.05381970f, -0.00457733f, 0.08396112f, 
    0.11313677f, -0.20682776f, -0.08513252f, 0.00085081f, 0.01943153f, 0.02310245f, 0.02172126f, -0.01978419f, 
    -0.02725753f, -0.10850330f, 0.17326660f, 0.09454048f, -0.03701352f, -0.10087389f, -0.03905870f, 0.06640704f, 
    -0.00786117f, 0.03330935f, 0.05458760f, 0.04890419f, -0.01969602f, -0.21817370f, -0.12983307f, -0.01250952f, 
    -0.24152224f, -0.08193986f, 0.03239052f, 0.04260083f, -0.03229069f, -0.01976828f, 0.04022888f, 0.02066056f, 
    -0.10395712f, -0.22234905f, -0.17175026f, -0.08663151f, 0.43885335f, 0.15372644f, -0.16193146f, -0.12592885f, 
    0.05273573f, 0.06910659f, 0.12377747f, -0.17114571f, -0.04379807f, -0.05291358f, 0.07881771f, -0.02708021f, 
    0.23935820f, 0.15446277f, 0.00031780f, -0.07804748f, 0.14164031f, 0.00365076f, 0.06204062f, 0.03035666f, 
    -0.09301630f, -0.13333930f, -0.12173685f, 0.00684986f, 0.03565363f, 0.09407461f, -0.11215326f, 0.04851259f, 
    0.10033686f, -0.05800061f, -0.28844404f, 0.06712804f, 0.07530873f, -0.02113285f, 0.01752339f, 0.02363889f, 
    -0.04939048f, 0.12373406f, 0.02065994f, -0.16451368f, 0.01789671f, 0.09049856f, -0.03315426f, -0.15969650f, 
    -0.02393508f, -0.07782841f, -0.01145630f, -0.00782286f, 0.21742749f, 0.08766667f, 0.02663942f, -0.13136314f, 
    -0.06158460f, -0.03041986f, -0.21235329f, -0.18679386f, -0.07446016f, -0.06837130f, -0.01042511f, 0.04259297f, 
    0.03550948f, -0.02657426f, -0.00122614f, -0.33929116f, 0.11916322f, -0.02303495f, -0.06190595f, -0.12634546f, 
    0.01420260f, 0.09697262f, -0.01761844f, 0.04668601f, 0.10319823f, 0.01575478f, 0.03493129f, -0.26709145f, 
    -0.03699508f, -0.02379940f, -0.02693656f, -0.01196260f, 0.02559220f, 0.01325022f, -0.06321626f, -0.02545822f, 
    0.04070909f, -0.10897036f, -0.27776811f, 0.05361783f, 0.06425814f, 0.00756121f, 0.04587736f, -0.12049187f, 
    -0.12343263f, -0.11861772f, -0.16477688f, -0.02624679f, -0.10785667f, -0.51124549f, -0.27312484f, -0.06488881f, 
    -0.00109079f, -0.01583509f, -0.11903125f, 0.00547175f, -0.04049306f, -0.04665527f, -0.02204783f, -0.01090080f, 
    -0.18560435f, -0.14021191f, -0.28963202f, 0.09770366f, 0.04203076f, -0.00286874f, 0.01142052f, 0.01709189f, 
    0.02005785f, 0.10699873f, -0.10429341f, -0.02185910f, 0.30406758f, -0.04151158f, -0.01772222f, -0.09873506f, 
    0.16596945f, 0.01418089f, 0.02366949f, 0.04549988f, -0.04305969f, -0.01228760f, -0.04814536f, -0.11537275f, 
    0.24860080f, 0.11596575f, 0.10371379f, -0.09445155f, -0.06903554f, -0.00208712f, 0.04596760f, 0.03560525f, 
    -0.06853048f, -0.00845749f, -0.03652450f, -0.14006707f, -0.10191760f, -0.77033734f, -0.36777627f, 0.20802368f, 
    0.04161244f, 0.02741263f, -0.06181180f, -0.11427528f, -0.04716189f, -0.13038205f, -0.14141966f, -0.06247210f, 
    0.02407236f, -0.28393990f, -0.06840504f, -0.05146162f, -0.04372197f, -0.06580738f, -0.13612750f, -0.03013100f, 
    -0.15689145f, -0.05943844f, 0.12409150f, -0.16116169f, 0.03227548f, 0.08443160f, -0.17691772f, -0.22969508f, 
    0.04848304f, -0.03972093f, 0.01209019f, 0.03373687f, 0.01703177f, -0.05372085f, -0.14241846f, -0.05148968f, 
    0.13089669f, 0.22350845f, 0.10032264f, -0.08327862f, 0.03825073f, 0.03716327f, 0.15342721f, -0.09717328f, 
    0.17686558f, 0.08698709f, 0.03931966f, -0.00117623f, 0.05705202f, 0.18085109f, -0.07994405f, -0.12472867f, 
    0.01829410f, 0.06219849f, -0.03470251f, 0.00526535f, -0.04654142f, -0.07868931f, -0.11953580f, -0.03696845f, 
    -0.09706541f, 0.02804985f, 0.12647343f, -0.04835183f, -0.05668690f, 0.00823680f, 0.02251678f, -0.00741615f, 
    -0.06454672f, -0.04259753f, -0.02258602f, -0.07650966f, 0.04536786f, 0.16871548f, -0.04055671f, 0.00664478f, 
    -0.02969463f, 0.13416028f, 0.01122528f, -0.27309000f, -0.04485986f, -0.18464009f, -0.01627388f, -0.04201810f, 
    -0.51781124f, -0.29519385f, -0.15948166f, 0.06923700f, -0.02011666f, 0.01884973f, -0.02860234f, -0.02120583f, 
    -0.17417006f, -0.05847320f, -0.05458806f, -0.05873657f, 0.26821041f, -0.00385943f, 0.17903374f, -0.16123767f, 
    -0.10689303f, -0.02256958f, 0.05810500f, 0.00425110f, 0.10510522f, -0.05953081f, 0.03473812f, 0.06388777f, 
    0.41670254f, 0.17710207f, 0.04740669f, -0.34418648f, 0.04121844f, -0.11362948f, 0.21423604f, 0.02020910f, 
    -0.04692261f, -0.12910281f, -0.05964660f, -0.04875889f, 0.21529217f, 0.21084765f, 0.02140997f, 0.02629171f, 
    0.12103542f, 0.21712743f, 0.09028097f, 0.11911139f, -0.00929508f, 0.01820725f, 0.02822875f, -0.04328116f, 
    -0.34105855f, 0.00423892f, 0.05347915f, 0.00572659f, 0.00836854f, 0.04164491f, 0.04252769f, 0.07547928f, 
    -0.00976724f, 0.00877946f, -0.04951986f, 0.05384531f, 0.30104050f, 0.02613713f, -0.30709544f, 0.04542827f, 
    0.14707308f, 0.00284329f, -0.04483620f, -0.03670023f, -0.03562883f, -0.00114232f, -0.03501463f, 0.01827477f, 
    0.17714883f, -0.05448977f, -0.10819197f, -0.08828765f, 0.00307832f, 0.15077303f, -0.16865072f, -0.21118414f, 
    -0.13692114f, -0.16158612f, -0.01344551f, -0.04129565f, -0.05696328f, -0.04778185f, 0.04290057f, 0.03608766f, 
    -0.21777858f, -0.07060467f, -0.05487897f, -0.00920138f, -0.08448878f, -0.02569239f, -0.02200009f, -0.03812946f, 
    0.19976589f, -0.06932777f, -0.25902981f, -0.03525847f, 0.06009414f, 0.20788938f, 0.02405382f, 0.01253312f, 
    -0.03261230f, 0.04097776f, 0.05197191f, 0.06714344f, 0.20230608f, 0.12551172f, -0.26914006f, -0.15797533f, 
    0.04886442f, -0.06782284f, 0.01943084f, -0.04842666f, -0.08242296f, -0.01566912f, -0.02030575f, 0.00032524f, 
    0.11038653f, -0.14346454f, -0.00909962f, 0.02303536f, 0.08685699f, 0.08678257f, -0.01152075f, -0.02479119f, 
    0.01055714f, 0.04094840f, 0.07017304f, 0.01467758f, 0.01034329f, -0.26784098f, -0.14345624f, 0.11275452f, 
    -0.04388244f, 0.01289524f, 0.01471777f, -0.01887146f, 0.03737959f, 0.06797763f, -0.03561510f, 0.09828069f, 
    0.12294067f, -0.02819123f, 0.06320617f, 0.11092205f, 0.08985601f, 0.11879985f, -0.05414928f, 0.04049560f, 
    0.02837709f, 0.10755390f, -0.00765572f, -0.01488912f, -0.02802510f, 0.05464938f, 0.12576328f, -0.00209715f, 
    -0.19219425f, -0.02499572f, -0.08462061f, -0.04848960f, 0.01029450f, -0.10739520f, -0.05899294f, -0.06784799f, 
    -0.20998961f, -0.26623377f, -0.60008729f, 0.20629576f, 0.01027064f, 0.05491553f, -0.00991506f, -0.03605456f, 
    -0.04932031f, -0.24202918f, -0.16634247f, -0.07430097f, 0.24432306f, 0.16076323f, 0.01479266f, -0.10151844f, 
    -0.13954127f, 0.03476521f, 0.12027890f, -0.03377521f, -0.03127566f, -0.08535161f, -0.07177966f, -0.14836022f, 
    0.10118379f, -0.20047282f, -0.14266071f, 0.00413924f, -0.04584577f, -0.03050708f, -0.00244433f, -0.04589973f, 
    -0.07849040f, 0.05196880f, 0.00039337f, 0.19548549f, 0.05270986f, 0.02882365f, -0.19681004f, -0.08317786f, 
    -0.17523056f, -0.06694972f, 0.03120487f, -0.03226227f, -0.09192540f, -0.12901224f, 0.04715610f, -0.02246291f, 
    -0.08389207f, -0.07235718f, 0.16237783f, -0.27183416f, -0.09169658f, 0.05052302f, -0.10275046f, -0.11185697f, 
    -0.00577020f, 0.01155794f, 0.01156791f, 0.01824334f, -0.39942712f, -0.50361335f, -0.07646372f, -0.09742368f, 
    -0.05851215f, 0.00949981f, 0.09133773f, 0.06134576f, -0.15634005f, -0.05312588f, -0.02465991f, -0.07878027f, 
    0.21506450f, -0.06877402f, -0.20635642f, -0.19662665f, -0.03768948f, 0.08592691f, 0.14660163f, 0.15658838f, 
    0.01363637f, 0.01733667f, -0.06163327f, 0.03345540f, 0.31474200f, 0.25033388f, -0.04851418f, -0.08870100f, 
    0.05154600f, -0.11330505f, 0.07487268f, 0.05702178f, -0.01583532f, -0.07646804f, -0.01682847f, 0.02067962f, 
    0.03100044f, -0.60223395f, -0.08083104f, -0.11166093f, 0.00703514f, -0.00175229f, 0.02788135f, -0.02310028f, 
    -0.02348017f, -0.00670882f, 0.06036714f, 0.03694806f, 0.00767530f, -0.03386964f, -0.28817487f, 0.12371788f, 
    0.10724012f, -0.07257301f, -0.17089206f, -0.00359330f, -0.01593229f, 0.01226423f, 0.01305751f, 0.05129413f, 
    -0.28306988f, 0.08427949f, -0.57772601f, 0.01878762f, -0.09400996f, 0.06345724f, 0.03480758f, 0.02549145f, 
    -0.05245087f, -0.11268575f, 0.08844716f, 0.08546869f, -0.52357626f, 0.14767654f, 0.16578852f, -0.12082051f, 
    -0.27506813f, 0.09797738f, -0.03306464f, 0.02763051f, -0.03609592f, -0.03135116f, 0.01686705f, -0.03132873f, 
    0.25239661f, 0.15282674f, -0.01518216f, -0.16564748f, 0.10350111f, 0.01003191f, -0.04146210f, -0.06760273f, 
    -0.03566660f, -0.01043381f, -0.01149311f, 0.01659458f, 0.12682036f, 0.19879881f, 0.06593698f, -0.06938177f, 
    0.06769619f, 0.19929260f, 0.03744919f, 0.07578600f, -0.06109129f, -0.08975212f, -0.04245216f, -0.03442879f, 
    -0.04511007f, 0.12416413f, -0.13274916f, -0.01998134f, -0.04916335f, 0.17105463f, -0.01525015f, -0.15097299f, 
    0.05344868f, 0.03315922f, 0.02999342f, 0.06352574f, 0.17893906f, 0.12222894f, -0.16471130f, -0.04130651f, 
    -0.01685520f, 0.08571532f, -0.01261510f, 0.11138127f, -0.04998403f, -0.06031478f, -0.08143178f, -0.10662596f, 
    0.15560585f, 0.18420327f, 0.01982061f, -0.02925083f, -0.04348027f, 0.07441309f, 0.01338383f, -0.04133330f, 
    0.00000168f, 0.07748039f, 0.02393791f, -0.10063117f, 0.06731781f, -0.02051711f, -0.11634058f, -0.00588195f, 
    -0.00631101f, -0.05770496f, 0.20649914f, 0.05946741f, -0.06449424f, 0.13476253f, -0.05046231f, 0.07175128f, 
    0.06188208f, 0.00384864f, 0.01135698f, -0.04823401f, 0.07499738f, 0.15137598f, 0.03051595f, 0.01495543f, 
    -0.04909315f, 0.10195412f, -0.05736817f, -0.05228547f, 0.43244493f, 0.12677397f, 0.11030757f, -0.00991646f, 
    -0.03586848f, -0.03783954f, -0.01468213f, -0.04070652f, -0.01607809f, 0.01474440f, 0.03895097f, 0.03506957f, 
    0.33402598f, -0.16769379f, 0.11640359f, 0.20844042f, 0.02110583f, 0.01839141f, -0.02882680f, 0.02702196f, 
    -0.02897063f, -0.34971184f, -0.06593706f, 0.00938361f, -0.26864308f, -0.00322562f, -0.12790149f, 0.06883436f, 
    -0.01869627f, 0.01208836f, 0.09318127f, -0.18577290f, 0.07413909f, -0.02765811f, 0.04704385f, -0.03717157f, 
    0.25717160f, 0.18924610f, 0.14491287f, 0.21069311f, -0.03196483f, -0.03155280f, -0.04440876f, 0.03299505f, 
    0.02936113f, -0.04452224f, -0.00102159f, 0.07444243f, -0.14604948f, -0.02421215f, 0.04350173f, 0.04344820f, 
    0.05027571f, 0.04322992f, -0.02216388f, 0.09258278f, -0.04234618f, -0.00953412f, 0.05147122f, -0.03058992f, 
    -0.18834005f, -0.36060467f, 0.10083186f, -0.27448520f, -0.04766415f, -0.03052698f, -0.03248874f, 0.11136944f, 
    -0.19059372f, -0.24885409f, -0.43420762f, -0.16598281f, -0.01136524f, -0.25125647f, 0.15957753f, 0.17349440f, 
    -0.01836397f, 0.14846610f, -0.14956544f, -0.04286235f, -0.03346072f, -0.05041600f, -0.03041106f, -0.05320666f, 
    0.39135903f, -0.03753692f, -0.29022515f, -0.18294303f, -0.06685273f, 0.01341049f, 0.00949739f, -0.08920205f, 
    0.04194497f, -0.02797729f, 0.06365854f, -0.10041094f, -0.20132080f, 0.15963225f, -0.08503147f, -0.00771077f, 
    0.02482444f, 0.10073245f, -0.03597302f, -0.20573513f, -0.15575081f, 0.01806308f, 0.00203899f, -0.08049628f, 
    -0.40083396f, -0.34002337f, 0.28325644f, -0.06287441f, 0.06123655f, -0.04039353f, -0.06881351f, -0.10836593f, 
    -0.01371319f, 0.04951091f, 0.01192709f, -0.40453130f, 0.09726280f, 0.02248066f, 0.06501850f, 0.08930653f, 
    -0.04260089f, -0.03832046f, -0.04343509f, -0.06808671f, 0.02239156f, -0.00887677f, 0.06008225f, -0.00726975f, 
    0.03610340f, 0.06175360f, 0.10165342f, 0.00711425f, 0.01285701f, -0.01849231f, -0.04175314f, 0.02955966f, 
    0.04631184f, 0.11076396f, 0.00809336f, 0.07341608f, 0.27547067f, -0.07144839f, 0.12311024f, -0.02971381f, 
    -0.08086202f, -0.02992279f, 0.08119808f, 0.00823578f, 0.14199729f, -0.11783383f, -0.06363714f, -0.03733086f, 
    0.16265237f, 0.08271090f, 0.03134398f, 0.12522450f, -0.05689332f, 0.06798317f, -0.03664057f, 0.00897673f, 
    0.00435850f, -0.00711693f, 0.03390823f, 0.05148808f, -0.06816512f, -0.09600550f, 0.03635036f, -0.01357331f, 
    -0.03092163f, -0.02379936f, 0.08855671f, -0.13233143f, -0.10057765f, 0.07590274f, -0.01203441f, 0.01894658f, 
    -0.31406355f, 0.03591642f, -0.07116659f, -0.06343290f, 0.03513080f, 0.07037155f, 0.10660690f, 0.02323000f, 
    0.00061604f, 0.06366899f, -0.05800980f, 0.06489396f, -0.40448102f, -0.08862678f, 0.06159983f, -0.17257863f, 
    0.16905864f, 0.07431958f, -0.14553358f, 0.01564832f, 0.10130337f, 0.07051349f, 0.03616851f, -0.10801594f, 
    -0.23377100f, 0.05388748f, -0.09004994f, -0.49136665f, -0.31168327f, 0.03208827f, 0.06183400f, -0.01551651f, 
    -0.06704340f, -0.03336905f, -0.00244664f, 0.07102320f, -0.23065193f, 0.00073392f, -0.10092635f, -0.49403977f, 
    0.01621031f, -0.20674676f, -0.18979949f, -0.03127456f, -0.01678751f, -0.04333257f, 0.05456632f, -0.04151979f, 
    0.41235554f, -0.31619316f, 0.00018362f, 0.07021072f, -0.08817191f, 0.01677779f, 0.03172373f, -0.12277105f, 
    0.09238325f, 0.15174520f, 0.10691071f, 0.05237340f, 0.12309387f, 0.04868156f, 0.02646126f, -0.13836163f, 
    0.04669486f, -0.16195756f, -0.11644379f, 0.04989620f, 0.01510040f, 0.02399934f, 0.04330496f, 0.04940972f, 
    0.40469232f, 0.08871289f, 0.17608726f, 0.04888696f, -0.07753029f, 0.01357887f, -0.01120884f, 0.01161726f, 
    0.00526639f, 0.03685217f, -0.15297692f, 0.08447953f, 0.11198393f, -0.07113851f, 0.39139637f, -0.09945557f, 
    -0.03538223f, 0.00105799f, 0.09740163f, -0.24238968f, -0.03591217f, 0.01543081f, 0.04478270f, -0.03656772f, 
    -0.29855409f, -0.01905352f, -0.16272022f, -0.18585432f, 0.05758355f, -0.35459119f, 0.13686873f, -0.04012882f, 
    0.07309254f, 0.00142463f, 0.01308037f, -0.11770024f, 0.80271918f, -0.37243304f, 0.05449229f, -0.12576741f, 
    -0.02287205f, -0.11093505f, 0.12566958f, -0.10017318f, 0.01812963f, -0.11444086f, -0.02200216f, 0.06844660f, 
    0.13700089f, -0.27980563f, 0.10590243f, 0.07263766f, -0.04443610f, 0.07523964f, 0.07237257f, -0.04989873f, 
    0.24565366f, 0.16024134f, -0.13047996f, -0.06438269f, -0.38607576f, -0.45445684f, -0.19412717f, -0.15607078f, 
    -0.12690838f, -0.04410116f, 0.04946152f, 0.12046202f, 0.10704075f, -0.26552039f, 0.05293569f, -0.00606691f, 
    -0.16530995f, 0.20831662f, -0.15469845f, 0.14977509f, -0.00810025f, 0.06579108f, -0.13487393f, -0.07308830f, 
    0.09527110f, -0.05160888f, -0.06384993f, -0.03631767f, -0.21674125f, -0.12728409f, -0.16236979f, 0.07838451f, 
    0.08615020f, 0.14296000f, -0.20608871f, -0.12092095f, -0.04464158f, 0.01915820f, -0.07229050f, 0.14817742f, 
    -0.17094873f, 0.05765488f, 0.01664551f, 0.07022450f, 0.18571742f, 0.04563498f, 0.00873051f, 0.02901299f, 
    -0.07709420f, -0.02946648f, 0.02238307f, -0.02902034f, -0.14247864f, -0.03861928f, -0.08922789f, 0.07558054f, 
    0.11636141f, 0.01583178f, 0.15130542f, 0.09272650f, -0.06185626f, 0.06395490f, -0.07089837f, 0.09638316f, 
    0.33460474f, -0.05988219f, 0.20778547f, -0.06052168f, -0.06846090f, -0.01374481f, 0.05886693f, -0.00091857f, 
    0.07472458f, -0.06209726f, -0.11587048f, 0.10281789f, 0.16709396f, 0.03210060f, -0.08366127f, -0.08133065f, 
    0.00729974f, 0.05355104f, 0.04309364f, -0.06296699f, -0.04166652f, -0.31662077f, -0.24653956f, -0.05666394f, 
    -0.29776001f, -0.13115312f, 0.02648756f, -0.39178056f, -0.04263364f, 0.12596117f, -0.03735466f, -0.12666325f, 
    0.12730463f, 0.02267331f, 0.13369282f, -0.17627713f, 0.42802659f, 0.20589210f, 0.21707475f, 0.13988909f, 
    -0.04078886f, -0.02163126f, -0.09230803f, -0.34893036f, -0.02215375f, -0.00963331f, -0.08718493f, -0.10703014f, 
    0.07123244f, 0.15524288f, 0.03412369f, 0.14192858f, -0.00724932f, -0.03571622f, -0.02434767f, -0.01656540f, 
    0.11171186f, 0.01815465f, 0.03856971f, -0.08111816f, 0.51956946f, -0.24048214f, -0.18680476f, -0.09849872f, 
    -0.00475490f, -0.06209973f, 0.16662090f, -0.05437616f, 0.16739766f, -0.06920496f, -0.11635387f, 0.01789742f, 
    -0.09725086f, -0.01007285f, 0.10513680f, -0.30345920f, 0.03394106f, 0.12451594f, 0.19753860f, 0.25156334f, 
    0.02142407f, 0.03823960f, 0.09980521f, -0.14923003f, 0.06942258f, 0.03458710f, -0.00565351f, 0.01419977f, 
    0.05150948f, -0.05129150f, 0.01496320f, -0.00706121f, -0.04614637f, -0.06418914f, 0.01633774f, 0.06192448f, 
    0.09180421f, 0.01909227f, 0.12917368f, 0.04007787f, -0.03241901f, 0.04388181f, -0.03703902f, -0.16674808f, 
    -0.01936706f, 0.04503362f, -0.00905612f, -0.01239365f, 0.04344903f, -0.11858255f, 0.02589954f, 0.14244455f, 
    -0.03607096f, 0.13403049f, 0.22779538f, 0.04357880f, 0.02341176f, 0.00675223f, 0.02898700f, -0.02075875f, 
    0.04069648f, -0.00719712f, -0.09066111f, -0.13393752f, -0.00917958f, -0.03292594f, 0.06308004f, -0.02941868f, 
    -0.07093182f, -0.05574877f, -0.13217734f, 0.02344085f, 0.14773463f, -0.09702889f, -0.01100041f, 0.11158301f, 
    0.01424493f, 0.02416914f, -0.03380064f, -0.03055770f, -0.16498691f, -0.19578829f, -0.13786647f, -0.21508826f, 
    -0.11015254f, -0.14225659f, -0.03399919f, -0.04395862f, 0.01237674f, 0.01352996f, -0.01239847f, -0.03830957f, 
    0.18155539f, 0.05401735f, 0.06134174f, 0.06834126f, -0.04207348f, 0.04977793f, 0.02576008f, -0.03049312f, 
    0.06762902f, 0.17282364f, 0.00667828f, 0.03610757f, -0.18788502f, -0.08440474f, -0.01452168f, -0.06652616f, 
    0.27676767f, 0.05448874f, 0.13459498f, -0.05181486f, -0.03624957f, -0.00502196f, 0.02096885f, -0.01816130f, 
    -0.07816776f, 0.07531258f, -0.15734290f, -0.14487597f, 0.02736446f, -0.03559614f, -0.05002151f, 0.06845269f, 
    -0.00950660f, -0.01659141f, 0.05132026f, -0.00492028f, 0.10952310f, -0.04612052f, 0.05502139f, -0.02505786f, 
    -0.00812858f, 0.16118108f, 0.17368196f, -0.16757259f, 0.04693018f, 0.00553169f, 0.06060157f, -0.00665396f, 
    -0.39276788f, -0.11289919f, 0.09358726f, -0.23078530f, 0.07129227f, -0.01243931f, -0.18235011f, 0.22676200f, 
    0.08751060f, -0.11741817f, 0.04369464f, 0.04050758f, -0.00869825f, 0.08648949f, -0.01031181f, 0.03139141f, 
    -0.23046990f, 0.21777146f, -0.43672296f, -0.35424498f, -0.08020393f, -0.13816099f, -0.07928545f, 0.16195409f, 
    -0.07611267f, -0.04359702f, 0.00005284f, 0.04782332f, 0.45112279f, 0.17640570f, 0.04610400f, -0.07921304f, 
    -0.03165149f, 0.02749296f, -0.02190542f, 0.04657186f, 0.00871479f, 0.05105873f, 0.04627563f, 0.02798051f, 
    -0.00291958f, -0.03528442f, -0.21167353f, -0.07416847f, -0.09038617f, -0.04269836f, 0.05457843f, -0.05501054f, 
    -0.01448934f, -0.04376287f, -0.06620406f, 0.05180556f, -0.25183699f, -0.02356297f, -0.09331241f, 0.21445492f, 
    0.08499537f, 0.01882706f, 0.12679832f, -0.25747594f, -0.05447964f, 0.00607443f, 0.03424408f, 0.05742817f, 
    0.60795218f, -0.01935295f, 0.17755768f, 0.13746630f, -0.06367172f, -0.05853374f, 0.00479922f, 0.00116471f, 
    0.04568870f, -0.02047996f, 0.02503363f, 0.09607284f, 0.20138869f, -0.03050835f, 0.07488564f, -0.01357902f, 
    0.04009922f, -0.16955887f, -0.06075088f, -0.06475130f, 0.01056425f, 0.03819839f, -0.06862160f, 0.04459433f, 
    0.42916542f, 0.02498770f, 0.09481241f, -0.09564327f, 0.02263458f, 0.02490679f, 0.02591014f, -0.08114608f, 
    0.06420679f, -0.04346735f, -0.04196360f, 0.00916234f, -0.62170768f, -0.13600828f, -0.04459824f, -0.09752623f, 
    0.23573548f, 0.02976209f, -0.10235054f, 0.12213539f, -0.02105331f, 0.10778928f, -0.03935100f, 0.00775483f, 
    0.07745530f, 0.16112427f, 0.21764633f, 0.22779712f, -0.03205712f, 0.03561664f, -0.07231798f, -0.02337618f, 
    -0.04363235f, 0.02022032f, -0.01076760f, -0.03443072f, 0.26179823f, 0.30241460f, 0.25684422f, 0.10856263f, 
    -0.01149520f, -0.07451413f, 0.11245188f, 0.09163200f, 0.00521752f, 0.02190152f, -0.02563207f, -0.19797504f, 
    0.15700281f, -0.14294644f, -0.04979738f, -0.50174195f, -0.16576305f, -0.03326916f, -0.04612169f, -0.05695681f, 
    -0.00977783f, -0.00215185f, -0.04924037f, -0.01365229f, -0.00821942f, -0.27795577f, 0.04332811f, 0.13853388f, 
    0.04313335f, 0.11188586f, -0.13570301f, 0.33960196f, -0.06740420f, 0.01227201f, -0.06890666f, 0.10548104f, 
    -0.26990855f, 0.12143917f, -0.04287451f, -0.13407186f, -0.03197392f, 0.08749742f, -0.03791030f, -0.05511363f, 
    0.01697053f, -0.05828371f, 0.17489147f, -0.30355918f, -0.09314398f, -0.11560345f, 0.05505192f, 0.10408295f, 
    -0.14477640f, -0.08438682f, -0.10941868f, -0.11081911f, 0.04401850f, -0.01468019f, -0.03668321f, 0.03384337f, 
    -0.26170960f, 0.07316474f, -0.02887001f, 0.00615104f, -0.02429718f, 0.11114007f, -0.07845384f, -0.04274713f, 
    0.01375784f, -0.02314644f, -0.06446508f, -0.02072591f, 0.17085354f, 0.00427161f, 0.08493557f, -0.06031174f, 
    -0.02862501f, 0.00864767f, -0.02102858f, 0.03247645f, -0.02093596f, -0.00923347f, 0.00739465f, -0.00947254f, 
    -0.01044264f, -0.13186689f, -0.00330247f, 0.03085825f, -0.02919005f, 0.00890276f, -0.05786247f, -0.01445298f, 
    0.11238191f, 0.05754113f, 0.10916797f, -0.05049302f, 0.04310171f, 0.05900407f, 0.02580510f, 0.06475209f, 
    -0.04575121f, 0.02728043f, 0.00003645f, 0.10064013f, 0.00370952f, 0.14806482f, 0.05791474f, 0.01181181f, 
    0.11108851f, 0.02996852f, -0.10896988f, -0.31649572f, 0.04048242f, -0.06251157f, -0.06513643f, 0.14076482f, 
    0.00280369f, 0.04944631f, 0.04525915f, 0.00163685f, -0.15944400f, -0.02277792f, 0.05501563f, 0.01877719f, 
    -0.00304389f, 0.06263561f, -0.09214287f, -0.07242563f, -0.00987122f, -0.01259709f, 0.00501421f, 0.01595303f, 
    -0.08524843f, 0.04312043f, -0.03922751f, 0.06770097f, 0.00748123f, -0.00931588f, -0.00371617f, -0.12919679f, 
    0.07906384f, 0.11048730f, -0.04407477f, 0.18579212f, 0.36938310f, -0.53526008f, 0.04169340f, 0.11392046f, 
    0.03107034f, 0.11820235f, 0.04083695f, 0.04794616f, 0.00806851f, -0.08460288f, -0.00284582f, 0.01952242f, 
    -0.03822910f, 0.22127108f, 0.51606977f, 0.22815022f, -0.04552685f, -0.00427501f, 0.06012649f, 0.05082116f, 
    -0.02698896f, -0.12483275f, 0.00151566f, 0.06472050f, 0.01622326f, 0.17998067f, 0.26387659f, 0.22858593f, 
    -0.05154929f, -0.16151500f, 0.11418231f, 0.12203997f, 0.01665010f, 0.00985886f, 0.05885119f, -0.03991590f, 
    0.17549495f, -0.00461339f, 0.35121438f, 0.10329039f, -0.03864865f, -0.00167747f, 0.07999974f, -0.00017801f, 
    0.02987890f, 0.09055980f, -0.17504360f, 0.04034090f, 0.02653389f, -0.16118135f, -0.09313907f, -0.01801206f, 
    0.00318713f, 0.01927270f, -0.00585404f, 0.03633430f, 0.00815141f, -0.06591877f, 0.13264146f, 0.03132940f, 
    0.06868418f, -0.07440338f, 0.10510972f, 0.08381841f, 0.00991132f, 0.01187424f, 0.04150197f, 0.03391761f, 
    0.05264305f, 0.17288470f, -0.13327548f, 0.02724477f, 0.13836522f, -0.31177980f, 0.53499675f, 0.31094128f, 
    0.10324232f, -0.25038037f, 0.03107376f, 0.13810790f, 0.05227983f, 0.08917283f, 0.06565114f, -0.00385467f, 
    -0.44998381f, -0.02061222f, -0.09715855f, -0.09216814f, -0.08540126f, -0.00828863f, 0.04183780f, -0.09783017f, 
    -0.01910264f, 0.02427861f, 0.04437556f, -0.01808365f, -0.08951304f, -0.09258590f, 0.11924667f, -0.09536167f, 
    0.09333593f, -0.19319616f, -0.14406826f, 0.08555035f, -0.02191054f, 0.01544423f, 0.05175581f, -0.02880068f, 
    -0.03658963f, 0.00440341f, -0.10748321f, 0.10187961f, -0.05991693f, -0.00529079f, 0.06471444f, -0.19523050f, 
    -0.01860240f, -0.00022035f, 0.00921861f, 0.00127005f, -0.04398526f, -0.11313109f, -0.00140635f, 0.11446086f, 
    -0.05480517f, 0.05412569f, 0.03320650f, -0.14195922f, 0.09268158f, -0.04450095f, 0.00658948f, 0.14091361f, 
    -0.95020986f, -0.16149166f, -0.31105873f, -0.10379711f, 0.07202863f, -0.00686740f, -0.01917756f, -0.15940152f, 
    0.04676486f, -0.04336513f, 0.05534547f, 0.03119183f, 0.25470161f, 0.23062384f, -0.22180249f, -0.17762135f, 
    0.04000523f, -0.04185088f, -0.05340097f, -0.03737535f, -0.01343794f, 0.03167360f, 0.00863733f, -0.01441616f, 
    -0.01363145f, -0.11698161f, 0.36424071f, -0.06489784f, -0.05105756f, -0.05028166f, 0.06191269f, 0.03745320f, 
    -0.00208111f, -0.11287939f, -0.05328893f, -0.03907274f, -0.32367891f, 0.18515728f, 0.28916568f, -0.26472208f, 
    0.05191268f, -0.00881865f, -0.25903526f, -0.06563295f, 0.04694079f, -0.00614649f, 0.00779348f, 0.07302454f, 
    -0.34476805f, -0.10386434f, 0.05236447f, -0.08808145f, 0.04626866f, -0.04037305f, -0.02759050f, -0.01234298f, 
    0.01758725f, 0.03076598f, -0.01887510f, 0.09499644f, -0.53500342f, -0.30256864f, -0.15494977f, -0.13128175f, 
    -0.06424847f, -0.11984950f, 0.11118856f, -0.06656048f, -0.02240435f, 0.00695563f, -0.03901665f, 0.02773481f, 
    -0.42947882f, 0.18435812f, -0.29430589f, -0.08407209f, 0.06578439f, 0.09381044f, -0.04426747f, -0.07627220f, 
    -0.01788320f, -0.00540197f, -0.01823941f, 0.00068659f, -0.21862251f, 0.08449200f, 0.09732591f, -0.58160710f, 
    -0.07673863f, -0.00590704f, -0.18786995f, 0.06153204f, 0.01073320f, 0.01163285f, -0.01848789f, 0.02443203f, 
    0.14517038f, -0.19962838f, 0.11867654f, 0.00157376f, 0.03863417f, -0.04184099f, -0.02119371f, -0.07721715f, 
    -0.01508500f, 0.04024196f, -0.17081721f, 0.11422791f, 0.11464711f, -0.11162023f, -0.21948196f, -0.03536352f, 
    0.00141529f, -0.08728962f, 0.04689375f, 0.01208756f, -0.05566664f, -0.05736471f, -0.14961834f, 0.07413859f, 
    -0.07273997f, -0.26946023f, -0.12101043f, 0.13050538f, -0.00751309f, 0.00956139f, -0.03092304f, 0.15024155f, 
    0.06643680f, -0.03435424f, 0.03424786f, 0.02255124f, 0.12815551f, 0.02926574f, -0.40324566f, -0.13485208f, 
    0.19001071f, 0.10579961f, -0.09953546f, -0.13533166f, -0.01653815f, -0.03109647f, -0.03792413f, 0.02535482f, 
    0.04760703f, -0.10584369f, -0.09085732f, 0.03623968f, 0.10723678f, -0.01456875f, -0.00233823f, -0.00903991f, 
    -0.05359851f, -0.02282149f, -0.09302666f, 0.05311451f, 0.03776712f, -0.23066959f, -0.04493352f, 0.01613142f, 
    0.04085174f, 0.01318241f, -0.03608599f, -0.00451738f, 0.04102160f, -0.15234374f, -0.02894764f, 0.01600704f, 
    -0.22235978f, 0.11119530f, 0.09550803f, -0.17339636f, -0.00361729f, 0.00063264f, -0.05735238f, 0.04220531f, 
    -0.01174161f, 0.13581869f, -0.11982899f, 0.05517792f, 0.26887807f, -0.04447233f, -0.13381197f, 0.12991416f, 
    0.02397051f, -0.02131747f, -0.02064852f, -0.00554773f, -0.01855288f, -0.09662633f, 0.18063939f, -0.05899182f, 
    0.14871867f, 0.35751516f, -0.06811543f, 0.00281992f, 0.12289350f, 0.03060079f, -0.14806010f, 0.18247588f, 
    -0.06182435f, -0.05380017f, 0.09941360f, -0.06902499f, -0.52179563f, -0.11560187f, 0.20624873f, 0.13359459f, 
    -0.04486526f, -0.08567829f, 0.10430754f, 0.03016340f, 0.00110293f, -0.00291767f, -0.02644193f, 0.02694565f, 
    -0.11216477f, -0.09886838f, 0.03752381f, 0.01962557f, -0.00105241f, -0.01193197f, 0.04214999f, 0.07780879f, 
    -0.02526665f, -0.03371257f, -0.02937474f, 0.11275272f, -0.06409986f, 0.19019166f, 0.29491246f, 0.10106959f, 
    -0.08767544f, -0.18545572f, 0.11629602f, -0.18966489f, 0.06023110f, 0.06111074f, -0.06799057f, -0.08120559f, 
    -0.05829587f, 0.16846193f, 0.36568019f, 0.22335801f, -0.02675789f, -0.00476050f, 0.02789861f, 0.08246721f, 
    -0.11408769f, -0.09138702f, -0.09910922f, 0.03889248f, -0.12124199f, -0.01813737f, 0.01635260f, -0.03404159f, 
    -0.04813221f, 0.02489161f, -0.12581591f, 0.13614306f, -0.02361591f, -0.09374867f, 0.08620454f, -0.04926759f, 
    -0.17955473f, 0.23304749f, 0.50636536f, 0.09745010f, -0.03494128f, -0.13462538f, 0.24041978f, -0.06107331f, 
    0.02740541f, -0.00892760f, 0.02353073f, -0.01569642f, -0.07144596f, -0.08770707f, -0.05659629f, -0.13022448f, 
    -0.00260249f, 0.00083060f, 0.02302470f, 0.17171574f, -0.03085652f, -0.03065383f, 0.01603321f, -0.02255143f, 
    0.09690899f, 0.21159968f, 0.02011786f, 0.15139630f, -0.02622445f, -0.08656893f, 0.01960443f, -0.02418390f, 
    0.02061280f, 0.11097551f, -0.07688595f, -0.02475234f, 0.03307208f, -0.00505334f, 0.16720572f, -0.00555603f, 
    0.00815344f, -0.02045325f, -0.00393280f, 0.03576575f, 0.15395720f, 0.19419491f, 0.20280609f, 0.12317967f, 
    0.15399419f, 0.10978358f, 0.13287565f, 0.06841422f, -0.02496190f, -0.01199790f, 0.11622304f, -0.17620412f, 
    -0.09349287f, 0.05786353f, -0.03693881f, 0.16030250f, -0.02958202f, -0.00472227f, -0.04337286f, 0.08234359f, 
    0.08726326f, 0.02232954f, -0.00909495f, -0.06205225f, -0.05821520f, -0.00700305f, 0.06388176f, -0.06192831f, 
    -0.04281349f, -0.11283208f, 0.07980283f, -0.03080703f, 0.05723017f, 0.04087636f, -0.02553598f, -0.04134989f, 
    -0.01449094f, 0.07724773f, -0.11903747f, 0.06333045f, -0.01831118f, -0.09317718f, 0.07770489f, 0.20681137f, 
    0.04117608f, -0.01516648f, -0.02124644f, 0.12926607f, 0.00560523f, 0.05579617f, 0.01411518f, 0.02165505f, 
    0.27809808f, -0.14462639f, 0.33196318f, 0.06712240f, 0.10270848f, -0.05438210f, -0.09662360f, -0.01788886f, 
    -0.12723929f, 0.03001451f, 0.09570374f, 0.13763040f, -0.10600397f, -0.14647080f, 0.10464627f, -0.01294061f, 
    0.05119346f, -0.05068389f, 0.02048574f, 0.03291288f, 0.00896668f, -0.12661731f, 0.12069745f, -0.08587208f, 
    -0.50579655f, 0.36223766f, -0.23146158f, 0.09422506f, -0.14601468f, -0.11841438f, -0.11149091f, -0.03405803f, 
    0.01389518f, 0.01596642f, -0.02211864f, -0.00766494f, -0.14580999f, 0.15646656f, -0.25822231f, -0.39491761f, 
    -0.03660990f, -0.04828543f, -0.03509360f, 0.00566222f, 0.06630964f, -0.12960897f, -0.15560283f, 0.06414509f, 
    -0.04825086f, 0.06321035f, 0.21393673f, 0.03863046f, 0.04122695f, -0.02457452f, 0.13111617f, 0.14296806f, 
    0.04166540f, -0.05167331f, 0.02236882f, -0.06788767f, -0.09658397f, -0.18134524f, -0.43773806f, -0.03195236f, 
    0.06965721f, 0.03184279f, 0.20833351f, 0.18273070f, 0.02400639f, -0.00606813f, 0.06016698f, -0.03811841f, 
    -0.24965861f, 0.14333718f, -0.27343383f, -0.13122529f, -0.03199307f, -0.05218937f, 0.00334099f, 0.02110462f, 
    -0.02153978f, 0.02317360f, 0.02006245f, -0.01204835f, -0.15338960f, -0.10266199f, 0.16597788f, -0.37520936f, 
    -0.07369311f, -0.04669880f, -0.04550714f, -0.02534612f, -0.02081433f, 0.01280658f, -0.05024333f, -0.01630482f, 
    -0.12184837f, 0.08777456f, 0.20181978f, 0.07795339f, -0.09217001f, 0.01183288f, 0.00726576f, -0.09492476f, 
    -0.02744974f, 0.06799548f, 0.10962842f, -0.09095386f, 0.20583527f, 0.09713523f, -0.20019689f, -0.00402189f, 
    0.18224859f, -0.01065278f, 0.09071723f, -0.11601575f, -0.08195385f, -0.01345868f, -0.03538738f, 0.04980226f, 
    -0.41528875f, -0.44047242f, -0.21781191f, -0.18433937f, -0.06432042f, -0.06328323f, 0.07180108f, -0.06300203f, 
    -0.00021737f, -0.07087894f, -0.01889781f, -0.00310109f, -0.40702215f, 0.14987022f, 0.39221776f, 0.28944266f, 
    -0.05425593f, 0.02891203f, -0.04572838f, 0.02474977f, -0.04696938f, -0.05580188f, 0.00076378f, -0.28196499f, 
    -0.11947791f, -0.18177806f, 0.14600752f, -0.43096378f, 0.01049026f, -0.15726659f, -0.31888479f, -0.07006597f, 
    -0.05317598f, 0.00504223f, -0.03917876f, 0.00425033f, 0.08556183f, 0.00854075f, -0.21183354f, -0.42765355f, 
    0.15648845f, -0.06536935f, -0.07034881f, -0.02072567f, 0.00668917f, -0.05099680f, -0.16339259f, -0.00638969f, 
    -0.56426048f, 0.30232796f, -0.21738775f, 0.00345222f, 0.19331184f, -0.04522750f, -0.16856615f, -0.11917748f, 
    0.17948474f, -0.05209123f, 0.12510899f, -0.14922938f, -0.08484042f, -0.26875183f, 0.15204217f, 0.16032225f, 
    -0.05294196f, -0.03891654f, -0.04472837f, 0.02994499f, -0.12432171f, -0.01982348f, -0.03215829f, -0.06047528f, 
    -0.09996562f, 0.07655191f, -0.01353534f, 0.20536453f, 0.01030590f, 0.02486791f, -0.16002655f, -0.16287528f, 
    -0.03392151f, -0.00217611f, 0.11375607f, -0.06764178f, 0.15017070f, -0.23601151f, 0.50833577f, -0.18336134f, 
    -0.29211932f, 0.11310861f, -0.22811647f, -0.01997107f, -0.01939830f, -0.08255756f, 0.19165896f, -0.01524278f, 
    -0.23518871f, 0.54662383f, -0.31973779f, -0.17274259f, 0.04429553f, 0.11146471f, 0.08720126f, -0.00570168f, 
    -0.09007408f, -0.16570303f, -0.07123237f, -0.04084126f, -0.16781203f, 0.32043052f, -0.29278809f, -0.23285551f, 
    0.03151365f, -0.01269914f, -0.00716829f, -0.08472727f, -0.03368208f, 0.08811671f, -0.12512790f, -0.06379379f, 
    -0.22953135f, 0.24581385f, -0.09115541f, 0.01822489f, -0.06775947f, 0.05715461f, -0.02033904f, -0.14233962f, 
    -0.03011901f, 0.06371947f, 0.04486338f, 0.12060597f, 0.11437035f, -0.10874378f, 0.21512520f, 0.02102137f, 
    -0.22222169f, -0.00660562f, 0.09134760f, -0.03904643f, 0.01845143f, 0.15844689f, 0.04481663f, 0.02381113f, 
    -0.00741966f, 0.08146006f, 0.13539483f, 0.07938953f, 0.05424251f, -0.04454127f, 0.01444998f, 0.04920504f, 
    -0.07260317f, 0.12312487f, -0.06639718f, 0.14501517f, 0.06509164f, -0.10034086f, -0.23379752f, 0.28790227f, 
    0.05661650f, -0.07800735f, -0.01123677f, -0.27240786f, -0.14092503f, 0.04991532f, 0.07511371f, -0.05260405f, 
    0.06594627f, -0.14063579f, -0.08575760f, 0.02105678f, 0.15993576f, 0.13124366f, 0.13129453f, 0.00088094f, 
    -0.10773789f, -0.01613857f, -0.05265280f, 0.04020661f, 0.27898210f, -0.22084792f, 0.05931924f, 0.11398458f, 
    0.09531082f, 0.04329957f, 0.00372089f, -0.02558863f, -0.03508519f, 0.02000491f, 0.08705108f, 0.11018997f, 
    0.21445575f, 0.12658705f, -0.13310994f, 0.12952428f, 0.08389685f, -0.03503619f, 0.00201097f, -0.00424891f, 
    -0.17628056f, -0.05542963f, -0.04258724f, 0.02434342f, -0.25829870f, -0.20991220f, -0.12452653f, 0.04384866f, 
    0.09298754f, 0.09547859f, -0.07523329f, -0.00509471f, -0.08544984f, 0.00783867f, 0.09076805f, -0.19406247f, 
    -0.02285805f, 0.04050859f, -0.12940758f, -0.35772017f, 0.09446886f, -0.06280023f, -0.01824772f, -0.17226592f, 
    -0.04989875f, 0.04543089f, -0.08342641f, -0.03937135f, -0.31863865f, 0.37564880f, -0.14864159f, -0.04483708f, 
    0.11211820f, 0.09255986f, -0.02761690f, -0.00066099f, -0.10372859f, 0.10786135f, -0.08846460f, 0.13669364f, 
    -0.12066554f, -0.07016777f, -0.10483374f, 0.12663543f, 0.05114048f, 0.00359028f, 0.07329607f, 0.07881951f, 
    0.00895639f, 0.06423061f, 0.04970209f, 0.02152679f, 0.07731029f, -0.16039148f, 0.43921289f, -0.06033973f, 
    -0.09863287f, 0.05452630f, 0.05414748f, -0.08342646f, 0.05495799f, 0.11249054f, -0.11300603f, 0.05210772f, 
    0.12810531f, 0.11543471f, -0.04569412f, 0.00560899f, -0.02109089f, -0.12810849f, 0.05996777f, -0.09686974f, 
    0.01735531f, 0.01979428f, -0.04198400f, 0.04275529f, 0.00064679f, -0.05525235f, -0.03719036f, 0.10865135f, 
    0.10607084f, 0.09283993f, -0.00567061f, 0.21071327f, 0.06382235f, 0.00441532f, -0.04744641f, 0.05671347f, 
    -0.05400993f, -0.18831366f, -0.03338300f, 0.20436244f, -0.00148378f, 0.06164245f, 0.03650915f, 0.12154043f, 
    -0.10155602f, -0.04030390f, 0.02391780f, -0.05960995f, 0.07874905f, 0.02697138f, 0.05246207f, 0.09036194f, 
    0.00105221f, -0.11724836f, -0.05233312f, -0.04756981f, -0.03592577f, 0.12400275f, -0.06650748f, -0.06463918f, 
    -0.15132217f, 0.58184469f, -0.05598302f, -0.02610721f, 0.12138932f, -0.02546794f, 0.02934059f, -0.08424526f, 
    -0.15686047f, -0.03425591f, 0.08097236f, -0.07503784f, -0.41006836f, -0.10307456f, 0.23775710f, -0.07256560f, 
    -0.09441054f, 0.04463329f, -0.13956228f, -0.09401356f, -0.09974160f, -0.11313067f, -0.21834928f, -0.05329562f, 
    -0.15951329f, -0.08428128f, -0.09005228f, -0.09038777f, 0.20080943f, 0.09033978f, 0.07852562f, 0.11136474f, 
    -0.09035537f, 0.15016936f, 0.01954352f, 0.01592766f, -0.01103218f, -0.02209564f, -0.10342940f, 0.21066575f, 
    0.01695853f, 0.07797980f, 0.07004463f, 0.05684637f, -0.04414621f, -0.02882032f, -0.06388047f, -0.09521007f, 
    -0.03124139f, -0.08134346f, -0.04867816f, -0.03672570f, 0.02128857f, 0.00663186f, -0.00959276f, 0.15947095f, 
    -0.14872029f, 0.02342020f, 0.00760864f, -0.14818050f, -0.40058932f, 0.22435611f, 0.37745652f, 0.31996059f, 
    -0.10831931f, -0.04776787f, -0.01573095f, 0.03925353f, 0.08647259f, 0.07098647f, 0.18576397f, -0.03808050f, 
    -0.13668747f, -0.10101819f, -0.18414678f, 0.15704884f, 0.06597523f, -0.22469667f, -0.09624336f, -0.09060216f, 
    -0.12338338f, -0.10506578f, -0.14035672f, -0.09449652f, 0.01314021f, -0.10342954f, -0.13928880f, 0.02716675f, 
    -0.00845598f, -0.06165233f, 0.02435081f, 0.16183411f, -0.06974425f, -0.02196250f, -0.02618435f, 0.01887549f, 
    0.36620399f, 0.36740103f, -0.32826397f, -0.45597878f, 0.03972224f, 0.04737528f, 0.05335211f, 0.04477671f, 
    -0.02925723f, 0.06776828f, 0.08484408f, 0.06303402f, 0.20592995f, -0.07060006f, 0.13138786f, -0.12208346f, 
    0.05787958f, 0.02408259f, 0.01825350f, 0.04556532f, -0.13369901f, -0.06638215f, -0.00942310f, -0.15928979f, 
    0.27469251f, 0.14318362f, 0.02831724f, -0.25906485f, 0.10936262f, -0.08415987f, -0.14063515f, -0.05125600f, 
    0.06718101f, -0.03425432f, 0.08624212f, -0.01657777f, 0.14144717f, -0.07394218f, -0.20903213f, 0.00389818f, 
    -0.05879041f, -0.10334844f, -0.02851734f, -0.00891350f, 0.11065252f, 0.16071293f, -0.12666780f, 0.00681930f, 
    -0.35569414f, -0.27659601f, 0.04928807f, 0.10094643f, 0.00752668f, -0.01310566f, -0.03979186f, -0.02808990f, 
    -0.01562963f, 0.10924666f, 0.15076892f, -0.15315147f, -0.42404640f, 0.15337983f, -0.38734117f, -0.28724158f, 
    -0.12584804f, 0.00289383f, -0.01420035f, -0.15019231f, -0.01095962f, -0.09769162f, -0.09622587f, -0.11440018f, 
    -0.27862427f, 0.16064446f, -0.17454265f, 0.24685682f, 0.03560693f, -0.09259985f, -0.08402992f, -0.11086380f, 
    -0.13185376f, -0.03773871f, 0.06911099f, -0.02831808f, 0.11158857f, -0.13472769f, -0.07708344f, 0.06583326f, 
    0.01619205f, -0.07194326f, -0.03141485f, 0.00161789f, 0.00447645f, 0.01551998f, -0.03296898f, 0.02712517f, 
    -0.13455224f, -0.09023919f, -0.31056422f, -0.37403712f, -0.30136171f, -0.04632779f, -0.10559564f, -0.07729068f, 
    0.18854217f, -0.01286251f, 0.02521606f, -0.08370727f, -0.40614057f, 0.23368332f, -0.13073893f, 0.11839552f, 
    -0.00754202f, 0.03531707f, 0.23394784f, -0.08921997f, 0.08859008f, 0.03867740f, -0.04715369f, 0.13082053f, 
    0.06192566f, -0.06643257f, 0.08554820f, 0.22244480f, 0.08585990f, -0.00420020f, 0.02441888f, 0.07754285f, 
    0.02828338f, 0.04307675f, -0.05345037f, 0.18131009f, -0.18185253f, -0.10258754f, -0.17015284f, -0.09094320f, 
    0.00559198f, -0.14233683f, -0.06448312f, -0.00601432f, -0.06720015f, -0.10104676f, -0.13677964f, -0.11101709f, 
    -0.00280394f, -0.15728989f, 0.04157389f, 0.26986668f, 0.04936018f, -0.04738986f, 0.01423999f, -0.09182583f, 
    0.09560602f, -0.00346442f, 0.03376953f, 0.10494338f, -0.11239742f, 0.03277956f, -0.10332754f, 0.16702396f, 
    0.04165509f, -0.01546367f, -0.13673617f, -0.05232314f, -0.08592699f, -0.12249830f, -0.09246685f, 0.00414683f, 
    0.04913428f, -0.20414248f, -0.07788675f, 0.17423569f, 0.05272605f, 0.00806928f, -0.01921251f, -0.03241057f, 
    0.05035548f, 0.01514350f, -0.06860150f, 0.17704393f, -0.10550849f, 0.50221676f, -0.34077659f, -0.01200567f, 
    -0.00157294f, -0.00944125f, -0.01387279f, -0.15060182f, -0.03493842f, 0.09298932f, 0.00715172f, 0.00713210f, 
    0.19733557f, -0.16231170f, -0.00665615f, 0.19766994f, 0.05709935f, 0.09653444f, 0.09743863f, -0.15347362f, 
    -0.02420150f, -0.02244226f, 0.01787294f, 0.06306531f, 0.14328586f, 0.09683109f, 0.05962199f, -0.38925311f, 
    -0.00025801f, 0.01025521f, 0.08066288f, -0.06175131f, -0.02650966f, 0.00123497f, 0.01479504f, -0.01535444f, 
    -0.20964885f, 0.04940898f, -0.02470254f, 0.17237520f, -0.00915904f, -0.06690606f, -0.22508900f, -0.14650446f, 
    0.11415572f, 0.03632738f, 0.17858727f, -0.07056852f, -0.62391663f, 0.48924893f, -0.07705662f, -0.52416223f, 
    0.34741366f, 0.00755385f, -0.09309932f, -0.03092101f, -0.35288855f, -0.02860152f, -0.07120367f, -0.03349569f, 
    -0.10420140f, 0.03161551f, 0.25573340f, 0.11897364f, -0.04064975f, 0.19826381f, 0.06574702f, 0.16823986f, 
    -0.07971115f, -0.36729443f, -0.05925849f, 0.00483921f, -0.16808656f, 0.05196925f, -0.12781845f, -0.14603466f, 
    -0.05460602f, -0.10009120f, -0.05409699f, -0.13453101f, -0.24884802f, -0.05137656f, 0.01695705f, -0.06377379f, 
    -0.11374578f, -0.00135593f, -0.05391024f, 0.24310698f, -0.04837673f, -0.13884170f, -0.04204608f, 0.11686397f, 
    -0.02013918f, 0.09932467f, -0.01315612f, 0.20353438f, -0.14175223f, 0.09542830f, 0.21823347f, 0.03260589f, 
    0.06088575f, -0.01883287f, -0.07081866f, -0.18233366f, 0.01272047f, 0.03662142f, 0.03990201f, -0.04265787f, 
    -0.13255978f, -0.07038356f, -0.02033969f, 0.20564491f, 0.02541831f, 0.08248937f, -0.06251618f, 0.00561982f, 
    0.05420721f, -0.10293955f, 0.05053271f, 0.02643919f, -0.18691431f, 0.09466790f, -0.13538617f, -0.09609284f, 
    0.06619126f, 0.07330519f, -0.01169350f, -0.11982969f, -0.12293366f, -0.09232455f, 0.00996550f, 0.02796660f, 
    -0.75863779f, 0.32841790f, -0.15945186f, 0.27945465f, -0.02585528f, -0.19777733f, 0.03466064f, -0.07810929f, 
    0.01043025f, -0.05554491f, -0.03715099f, -0.08697461f, -0.21346863f, 0.00319466f, 0.57878232f, 0.04339571f, 
    -0.17153738f, -0.29315683f, 0.00174880f, 0.06879313f, 0.17974289f, 0.13965347f, -0.00064282f, 0.12401721f, 
    0.24370240f, 0.13242944f, -0.25108665f, 0.22716382f, -0.01823345f, -0.06898765f, 0.11117280f, -0.22257367f, 
    -0.09697558f, -0.03103086f, -0.05220870f, -0.07569178f, 1.14235556f, -0.04326359f, -0.30566743f, -0.18622613f, 
    0.07846940f, -0.09026621f, -0.06406837f, -0.19702770f, -0.06813881f, -0.00804238f, -0.02120571f, 0.16527672f, 
    0.04666645f, -0.14366105f, -0.09405719f, 0.15710457f, 0.00677104f, 0.07419822f, 0.01963958f, -0.08779221f, 
    -0.04880652f, 0.01170849f, -0.13793434f, -0.01302416f, 0.32231814f, -0.15830120f, -0.06435832f, 0.19734974f, 
    0.08066256f, 0.00052971f, -0.03605223f, -0.07102091f, 0.03823680f, 0.01069121f, 0.11292752f, 0.09071838f, 
    0.17948273f, -0.29626444f, 0.32847399f, 0.12843198f, -0.16487782f, 0.08826572f, 0.11974449f, 0.03411533f, 
    0.07505365f, -0.05789059f, 0.02176772f, -0.02883874f, 0.11468437f, -0.05979244f, 0.05971764f, 0.08732368f, 
    0.03258825f, -0.06405395f, 0.10348914f, 0.03892023f, -0.05410493f, 0.03686148f, 0.00151913f, -0.01169893f, 
    -0.21973073f, -0.12268814f, -0.08212566f, -0.22571468f, -0.01798577f, -0.02536718f, 0.05531695f, 0.01057227f, 
    -0.31172866f, -0.16531737f, -0.11480753f, -0.18030702f, 0.05950511f, 0.10702366f, 0.03521621f, 0.02087400f, 
    -0.18752961f, 0.10554112f, 0.15234368f, 0.15468012f, 0.02089678f, -0.10653841f, -0.03808840f, -0.05761432f, 
    -0.03367056f, 0.03831984f, 0.06688429f, -0.00804995f, 0.00427438f, -0.00104899f, 0.07057974f, 0.06456080f, 
    0.01047761f, -0.16455221f, -0.08961485f, -0.06997430f, 0.14274524f, 0.04651040f, -0.37422881f, 0.04466505f, 
    0.05797902f, -0.01198031f, 0.09026783f, 0.02994035f, 0.07414258f, -0.05835040f, -0.03257199f, -0.03863529f, 
    -0.11834154f, -0.43324494f, 0.01324507f, -0.35147610f, 0.01433575f, 0.02524757f, -0.00839918f, -0.07712979f, 
    0.04416387f, -0.03708148f, 0.04479526f, 0.10165411f, 0.02987662f, -0.22246793f, 0.09290776f, 0.03248823f, 
    -0.08575654f, -0.01332414f, -0.11586569f, -0.08344418f, 0.02321162f, -0.09511870f, -0.02971253f, 0.06064834f, 
    0.10282754f, -0.51055795f, -0.17531668f, -0.05186950f, 0.15928648f, 0.00040321f, 0.03709920f, -0.08527422f, 
    0.03734195f, -0.02026631f, 0.00101475f, -0.14797623f, 0.17565651f, 0.12015958f, -0.21542612f, 0.21398392f, 
    -0.02414749f, -0.08969323f, -0.14674878f, -0.19031708f, -0.00172395f, 0.01899587f, -0.03097373f, 0.03562659f, 
    0.08917037f, 0.15338568f, 0.03419589f, 0.18695673f, 0.02527259f, -0.01981845f, 0.05540284f, -0.09799141f, 
    0.19682179f, -0.09467483f, 0.27147865f, 0.14569597f, 0.07928641f, 0.14912409f, 0.09706664f, 0.00191402f, 
    -0.11948066f, -0.05598009f, -0.05396920f, 0.06624861f, 0.09063919f, 0.01172021f, 0.03015243f, 0.00744460f, 
    0.13360117f, 0.19177093f, 0.15258446f, 0.07583221f, -0.05090610f, -0.05339477f, 0.03799171f, 0.06435917f, 
    0.02430181f, -0.10033982f, -0.04303949f, 0.03717405f, 0.00993742f, 0.07722844f, 0.11477432f, -0.00120812f, 
    -0.14261973f, -0.15505913f, -0.07139532f, -0.00133341f, 0.08399464f, 0.01435029f, -0.04973163f, 0.06391624f, 
    -0.26186556f, -0.15266298f, -0.06806003f, -0.03095472f, -0.08791075f, -0.04686244f, -0.03555425f, -0.01783599f, 
    0.04651079f, 0.01301505f, -0.00955925f, 0.00235050f, 0.12559666f, 0.03245372f, 0.02366807f, -0.11032952f, 
    0.08447281f, 0.03822095f, 0.04523082f, 0.01103447f, -0.11570726f, -0.20768361f, 0.00632281f, -0.21477635f, 
    0.01352806f, 0.02856421f, -0.08545648f, -0.12473447f, 0.01333594f, 0.02290747f, -0.01093469f, 0.00550335f, 
    -0.12368060f, -0.11308372f, -0.13738199f, -0.04805549f, 0.08643858f, -0.39830050f, 0.13402168f, 0.05577698f, 
    -0.12027539f, -0.00339242f, 0.03503023f, -0.10971273f, -0.05282707f, -0.05436547f, 0.01718874f, 0.05091533f, 
    0.02296419f, 0.03750974f, 0.15512820f, 0.08423337f, -0.06723321f, 0.04852699f, 0.03916549f, 0.08947147f, 
    0.12565663f, 0.10417229f, 0.08195559f, 0.13063814f, 0.09388005f, 0.13722688f, -0.05377722f, 0.22204596f, 
    0.02736419f, 0.14037409f, 0.01096889f, 0.00255001f, 0.10245461f, -0.11338128f, -0.06457362f, -0.00793105f, 
    -0.02376833f, -0.14472584f, 0.14537483f, -0.05317325f, -0.08573624f, -0.06905656f, -0.07303766f, -0.02333713f, 
    -0.09022498f, -0.19209230f, -0.07253598f, -0.16137294f, 0.09440508f, 0.10277330f, 0.10683946f, 0.21102723f, 
    -0.00889391f, 0.13499714f, -0.01663150f, -0.14691558f, 0.11948852f, 0.03650530f, -0.01010382f, 0.05849466f, 
    0.14827608f, 0.24495545f, 0.20696259f, 0.25800467f, -0.02851403f, -0.10609151f, -0.00788009f, 0.21039478f, 
    -0.09811532f, -0.05626027f, -0.18010643f, -0.09839325f, -0.00942710f, 0.00502585f, -0.01102577f, 0.17958935f, 
    -0.13645695f, 0.08531083f, -0.05283295f, -0.05517813f, 0.01387988f, -0.11007026f, -0.00638753f, 0.00201618f, 
    0.21181022f, -0.53625345f, -0.02423833f, -0.05494190f, -0.05226417f, -0.03242402f, -0.06167479f, -0.00894198f, 
    0.16207287f, -0.06804866f, -0.00787849f, 0.02414376f, -0.08703087f, -0.08108985f, -0.13586719f, 0.13007076f, 
    0.05795508f, 0.05813151f, 0.01667345f, -0.02510604f, 0.02927941f, -0.00169706f, -0.00729714f, -0.08076932f, 
    -0.12328322f, 0.04682467f, -0.12775695f, -0.24687111f, 0.07705650f, 0.08796406f, 0.05211084f, 0.06964281f, 
    0.04366048f, -0.17447723f, -0.09219130f, 0.09132073f, -0.10716006f, 0.14140525f, 0.08089924f, 0.03885998f, 
    -0.09296695f, 0.09213132f, -0.01303885f, 0.04943216f, 0.00287213f, -0.01606446f, -0.00671213f, 0.04713087f, 
    -0.04268448f, -0.09733906f, 0.05545907f, 0.03607371f, 0.03494889f, 0.11799404f, 0.02482821f, -0.06228686f, 
    0.00060441f, -0.02906586f, -0.08856484f, 0.11939113f, -0.07763243f, 0.23622450f, -0.51752049f, -0.02382310f, 
    0.15936774f, 0.03082745f, -0.20345828f, -0.00629738f, 0.00587793f, 0.02234191f, -0.11157948f, -0.02688910f, 
    0.10828940f, 0.07905840f, -0.29598224f, 0.06312960f, 0.07278899f, -0.01601968f, 0.01510095f, -0.14575969f, 
    -0.33855987f, -0.08259553f, 0.12415734f, -0.22473730f, 0.12111078f, 0.12344235f, 0.10564674f, 0.17090254f, 
    -0.11906163f, 0.06739666f, -0.13737553f, -0.10314603f, -0.12042625f, -0.06796987f, -0.19166733f, -0.03560473f, 
    -0.35178593f, -0.31575790f, 0.12934302f, 0.01849673f, -0.05125840f, 0.04620938f, 0.07578248f, 0.04109408f, 
    -0.24988395f, 0.08497757f, -0.08136957f, 0.05577908f, -0.03282977f, 0.05870868f, 0.06951126f, 0.19804224f, 
    0.03476528f, -0.14857134f, -0.03275364f, 0.05479117f, -0.06223190f, -0.06044745f, 0.03478322f, -0.08725236f, 
    0.07405820f, -0.07371680f, -0.10169753f, 0.05764664f, 0.05327755f, -0.00424720f, 0.06107526f, 0.03491955f, 
    -0.02904881f, -0.13665046f, -0.12593600f, 0.05268298f, 0.07554834f, 0.06360941f, -0.00681449f, 0.02255849f, 
    0.05073386f, -0.01620466f, -0.03256680f, -0.12519963f, 0.06995491f, -0.13015237f, -0.00408449f, -0.11662135f, 
    -0.04909610f, 0.14562947f, -0.21500927f, -0.11061909f, 0.11068474f, 0.00010027f, 0.08574107f, 0.01755613f, 
    -0.02655525f, 0.12765694f, -0.00395837f, -0.03533174f, -0.10253228f, -0.16993047f, -0.09758417f, 0.00182106f, 
    0.04113440f, -0.11616131f, 0.07137870f, 0.04270445f, -0.25979632f, 0.24525583f, 0.05042473f, 0.09847692f, 
    -0.01627743f, -0.07768130f, 0.09845573f, 0.01196072f, -0.07249189f, 0.04279573f, -0.02816954f, -0.15786435f, 
    -0.11499141f, 0.05319690f, -0.08366908f, 0.00337364f, -0.23315215f, -0.12193648f, -0.03629901f, 0.07031465f, 
    -0.00728260f, 0.02366688f, 0.00992107f, 0.05092720f, 0.02490203f, 0.03464669f, 0.02664895f, 0.01991368f, 
    0.01151241f, -0.16960700f, -0.05617313f, 0.03427665f, 0.04466597f, 0.07679878f, -0.01275032f, 0.06479575f, 
    0.02582545f, 0.05151209f, -0.01385886f, 0.08400790f, -0.08640446f, -0.12742054f, 0.11699286f, 0.01621817f, 
    -0.03921729f, -0.12663889f, -0.15776274f, -0.04151537f, -0.11828209f, -0.09204158f, -0.04301002f, 0.10147363f, 
    0.11047414f, 0.22290201f, 0.14742233f, 0.22461982f, -0.07133595f, -0.17336810f, 0.00594768f, -0.06790368f, 
    -0.14091291f, 0.00036830f, -0.08665841f, 0.00249171f, 0.11445374f, 0.05063553f, 0.00707052f, 0.06179620f, 
    0.20316644f, 0.00852429f, 0.03256368f, 0.02094220f, -0.00099693f, 0.01874777f, -0.03556399f, 0.01932419f, 
    -0.08398592f, 0.10825217f, 0.20872067f, 0.06489696f, -0.10768475f, -0.08871231f, -0.00133445f, 0.00701880f, 
    -0.02743096f, -0.01158526f, -0.01920547f, -0.03965580f, 0.01415922f, -0.01227775f, 0.12854752f, 0.08732135f, 
    -0.04921874f, 0.05229195f, -0.01084541f, -0.09795131f, -0.03079162f, 0.03933129f, 0.02006673f, -0.07031848f, 
    0.02510543f, 0.15913643f, -0.04172162f, 0.06119728f, 0.01186286f, -0.04888358f, -0.08864613f, -0.00087013f, 
    0.02493688f, -0.09736665f, -0.04671135f, -0.01494318f, -0.12559943f, -0.18886319f, 0.02387707f, -0.21589190f, 
    -0.05269777f, -0.00928309f, -0.04846139f, -0.02991622f, 0.15059848f, 0.05632934f, 0.04333921f, 0.26732272f, 
    0.00057801f, 0.08464633f, -0.00196667f, 0.07318898f, -0.01911048f, -0.08201044f, 0.08265298f, -0.00996670f, 
    -0.04399355f, -0.12113661f, 0.02833973f, 0.07778873f, 0.06884467f, 0.09113260f, -0.05199297f, 0.03425967f, 
    0.06675392f, -0.05236768f, 0.09362981f, 0.02391250f, 0.17303964f, 0.03933030f, -0.17893231f, 0.03733762f, 
    -0.17513995f, -0.09914920f, -0.14413771f, 0.07180908f, 0.04169650f, -0.03825570f, 0.04320687f, 0.00104213f, 
    -0.07054017f, -0.11790236f, 0.00844068f, 0.04506883f, 0.18459505f, -0.26970333f, -0.05742388f, 0.07873694f, 
    -0.18884797f, -0.05715492f, 0.01084088f, -0.07816745f, -0.13249943f, -0.06157866f, 0.02583622f, -0.21799737f, 
    0.09772383f, 0.03131777f, -0.65282333f, 0.04465496f, 0.01763442f, -0.05739230f, 0.01530214f, -0.15508050f, 
    0.02445761f, -0.03265979f, -0.04842461f, -0.03064281f, -0.06881327f, -0.03731398f, 0.09154733f, 0.12155920f, 
    -0.01518185f, 0.12905872f, 0.04916820f, -0.06172143f, -0.02953862f, 0.04446061f, -0.06324773f, -0.04407530f, 
    0.08649027f, 0.04957798f, 0.40691629f, 0.10326127f, -0.05542595f, 0.01368148f, 0.01208667f, -0.00306054f, 
    -0.01220287f, -0.02704471f, 0.06340548f, -0.02574620f, 0.01354773f, -0.10607939f, -0.48395362f, 0.22108163f, 
    0.08407129f, 0.06020305f, 0.07300806f, 0.00201109f, -0.17398354f, -0.02817149f, -0.13053671f, -0.21129231f, 
    0.02064090f, 0.05606842f, 0.18851838f, 0.03186510f, 0.10063156f, -0.20796359f, -0.05975243f, -0.17252189f, 
    0.04902541f, -0.04830162f, -0.00232012f, -0.02706102f, 0.08326280f, -0.12165118f, 0.19853653f, 0.10363353f, 
    -0.02738318f, -0.12214296f, -0.10164510f, 0.03679255f, 0.02259054f, 0.07333560f, -0.10116781f, 0.02251331f, 
    -0.26723430f, -0.04602523f, -0.07884508f, -0.45014429f, 0.10632475f, 0.06316710f, -0.00563075f, 0.09089424f, 
    -0.06971000f, 0.01896098f, -0.03839801f, -0.09553711f, 0.16998117f, 0.13394111f, -0.13418722f, 0.22355232f, 
    -0.01138923f, 0.12508106f, 0.07501476f, -0.08382103f, 0.05980651f, -0.00301587f, 0.04447461f, -0.06599845f, 
    -0.37308526f, -0.31417695f, 0.03799904f, -0.21424827f, -0.03982592f, 0.06122775f, -0.10224837f, 0.05984285f, 
    0.03994591f, 0.06002946f, -0.12332851f, -0.30343112f, -0.02508070f, -0.41223773f, -0.09072537f, 0.04486206f, 
    0.06547085f, -0.05875431f, -0.10256653f, -0.06428330f, 0.09841541f, -0.10771863f, -0.00827375f, -0.10654125f, 
    0.07153239f, 0.14133742f, 0.15583235f, 0.13636161f, -0.10629018f, -0.06655589f, 0.04022500f, 0.14605030f, 
    0.04616550f, -0.02194485f, 0.01735188f, -0.00475941f, -0.22873142f, -0.05625291f, -0.04751864f, 0.09191699f, 
    0.05380649f, 0.01427025f, -0.06040180f, 0.00953235f, -0.05006016f, -0.00336618f, 0.00890596f, 0.04851193f, 
    0.16368431f, 0.36490873f, -0.18048096f, 0.40798393f, 0.31199214f, 0.11664733f, -0.04727700f, 0.02780950f, 
    0.05574653f, 0.01705942f, -0.03198342f, 0.02299454f, 0.11975148f, 0.09600725f, 0.08185769f, 0.18995084f, 
    0.10000309f, -0.13585293f, -0.02938446f, -0.12186419f, 0.05813279f, 0.00941925f, 0.02531643f, 0.00543010f, 
    0.29334944f, -0.33304435f, -0.02150004f, 0.21601145f, -0.03402025f, -0.09209055f, -0.09772018f, -0.02564748f, 
    0.18950464f, 0.18307531f, -0.05208666f, 0.16913849f, -0.22130533f, 0.00826674f, 0.04497248f, -0.18975113f, 
    0.13284704f, 0.05167941f, -0.04285300f, -0.11648196f, 0.05431213f, -0.07187875f, 0.09899921f, 0.07726155f, 
    0.02139049f, -0.11334442f, 0.02516374f, 0.00222042f, -0.20662326f, 0.05324866f, -0.14683078f, -0.07063454f, 
    0.04598380f, 0.08820210f, 0.11306889f, 0.07441674f, -0.47077996f, -0.22970320f, -0.33985969f, 0.25126696f, 
    0.05709574f, 0.07681416f, -0.03054289f, 0.03262876f, -0.06323943f, 0.05608815f, -0.02312517f, 0.01741116f, 
    -0.04423235f, 0.06918514f, 0.13921987f, -0.06943606f, -0.00198728f, -0.04442004f, -0.02164025f, -0.01970970f, 
    -0.16743873f, -0.08071331f, -0.16424647f, -0.23481794f, 0.30610257f, -0.14571743f, 0.04012333f, -0.08913703f, 
    0.02310670f, -0.12895493f, 0.00443490f, 0.22549702f, -0.10925306f, -0.06532812f, -0.06078205f, 0.08751645f, 
    -0.10843331f, -0.13803834f, -0.28575552f, -0.16923705f, -0.02914566f, -0.03794696f, -0.07303380f, 0.01809225f, 
    -0.02850275f, -0.06651023f, -0.01204930f, 0.03498615f, -0.16921900f, -0.14170067f, 0.11707039f, -0.03275889f, 
    0.04079867f, -0.02844949f, 0.07208969f, 0.13895121f, 0.04422881f, 0.02735924f, 0.01936978f, -0.04010720f, 
    0.01542549f, -0.00529634f, -0.09396634f, -0.10104033f, 0.02108883f, -0.01113863f, -0.01540641f, -0.04271160f, 
    0.09200833f, -0.16937964f, 0.04309307f, -0.27967647f, -0.27658135f, 0.23407075f, 0.00294968f, -0.35279819f, 
    0.13559327f, -0.10665500f, -0.00496345f, 0.14847913f, -0.03416749f, 0.00480115f, -0.01229428f, 0.01091857f, 
    -0.71290714f, -0.29298076f, -0.18129034f, -0.13880903f, 0.01007743f, -0.01744406f, -0.05414538f, -0.03580504f, 
    0.11618043f, 0.04483649f, -0.02047406f, -0.02077530f, -0.38336000f, -0.16375354f, -0.28653643f, -0.07505748f, 
    0.04395187f, 0.02970453f, 0.03524703f, 0.10910425f, 0.07774765f, 0.05703679f, -0.01929195f, -0.05943448f, 
    0.30856353f, 0.22221701f, -0.23890455f, -0.07667007f, -0.01184555f, -0.05857891f, -0.03652783f, 0.06175243f, 
    -0.00933946f, -0.05266575f, -0.18548690f, -0.05444171f, -0.00433889f, -0.02891148f, -0.12495116f, 0.07374532f, 
    0.02692023f, -0.02503939f, -0.03720438f, -0.02821562f, 0.12695254f, 0.10598195f, -0.14317089f, 0.21379125f, 
    -0.02134267f, -0.13253491f, -0.08211824f, 0.22456041f, 0.01441950f, -0.05961651f, -0.04320455f, 0.05106227f, 
    0.08439013f, 0.02284972f, 0.17951648f, -0.02737436f, -0.40414089f, 0.25259137f, 0.03682268f, -0.17353970f, 
    0.09134424f, -0.21362357f, -0.09842736f, -0.00632065f, -0.00030201f, 0.08476902f, -0.01794219f, -0.14638801f, 
    0.01735669f, 0.10949261f, 0.06192163f, -0.07691342f, 0.05178789f, 0.02010260f, -0.21273196f, -0.19345631f, 
    -0.00976027f, -0.09344881f, 0.01542299f, -0.09610708f, 0.01540916f, 0.01922511f, -0.04603027f, -0.20961648f, 
    -0.02716987f, -0.06155071f, -0.08668887f, 0.25263488f, -0.00645088f, 0.05230598f, 0.09032112f, -0.08868398f, 
    0.24661505f, -0.01872364f, 0.10272997f, 0.09839480f, 0.08418035f, 0.13445970f, 0.01171511f, -0.02561484f, 
    0.07850882f, 0.00358283f, 0.02732034f, 0.01374600f, 0.10007043f, -0.06980167f, 0.09715892f, 0.05144038f, 
    -0.06656735f, -0.11232291f, 0.04551204f, 0.11555868f, -0.20173880f, -0.04083274f, -0.07694905f, -0.19338866f, 
    0.25951356f, 0.05325050f, 0.11545531f, 0.01816586f, 0.12445032f, 0.12567340f, -0.04207448f, -0.19484171f, 
    0.01743914f, -0.04062918f, -0.02096069f, 0.02538555f, 0.00333945f, -0.01975306f, -0.00111718f, 0.36105594f, 
    0.07087038f, 0.03861668f, 0.21430017f, 0.17914917f, -0.01892741f, 0.08247812f, 0.03487289f, -0.00998565f, 
    -0.24727768f, 0.08171377f, -0.09232223f, -0.10528880f, 0.07101773f, -0.02908857f, 0.00388624f, 0.01320167f, 
    -0.01408934f, 0.02737902f, -0.16770171f, -0.05347019f, 0.20663525f, -0.13723549f, -0.35710108f, 0.24918012f, 
    -0.06398968f, 0.11881864f, 0.16651312f, -0.14947319f, 0.02103750f, -0.03012903f, -0.00605600f, -0.05510587f, 
    0.11560027f, -0.02266611f, -0.25497764f, -0.07166991f, 0.00546996f, 0.00413662f, -0.07425310f, -0.01292361f, 
    0.09875799f, -0.19695266f, 0.09084134f, -0.19268785f, 0.10270855f, 0.23489036f, -0.10410416f, -0.04408194f, 
    0.10030378f, -0.18678604f, -0.13479911f, 0.26321706f, 0.04578516f, 0.06972691f, -0.00456019f, 0.02696498f, 
    0.18119347f, 0.11794747f, 0.17857715f, 0.31341651f, -0.15744404f, 0.01942447f, -0.10618126f, 0.09358630f, 
    0.05882689f, 0.05890670f, 0.01373835f, 0.03180819f, -0.06049700f, 0.11842705f, -0.60162967f, -0.34609020f, 
    0.09357882f, 0.03734781f, -0.10903757f, 0.00192389f, 0.05073084f, -0.08661758f, -0.04981665f, -0.06108253f, 
    -0.12577234f, 0.33589292f, -0.08652827f, -0.12736633f, 0.04801734f, -0.01469120f, -0.05213450f, 0.15571000f, 
    0.06109099f, -0.04590760f, 0.01618520f, 0.33199292f, 0.13319860f, 0.16982922f, 0.12178018f, -0.02397109f, 
    0.06478626f, 0.08280760f, 0.07019247f, -0.18002106f, -0.08938044f, 0.26032338f, 0.07616396f, -0.00594427f, 
    -0.31239131f, -0.35746104f, 0.28881440f, -0.17724834f, -0.01024708f, -0.16690455f, 0.09022772f, 0.11827168f, 
    -0.29173890f, -0.25392482f, -0.23164579f, -0.17602488f, 0.05510561f, 0.26066801f, 0.13287680f, 0.07397144f, 
    -0.07947848f, 0.06457175f, 0.15257467f, 0.00820929f, 0.07941458f, -0.00271492f, 0.00106145f, 0.09514002f, 
    -0.20111707f, -0.04337297f, 0.08561640f, 0.04451354f, -0.38263109f, 0.02543734f, -0.06337205f, -0.05387512f, 
    0.08954788f, 0.09493666f, 0.01149030f, 0.09377677f, 0.02591406f, 0.06959444f, 0.19362095f, -0.14603372f, 
    -0.13603260f, 0.05705437f, 0.01096401f, -0.00125773f, 0.10785230f, -0.03187314f, 0.14190577f, -0.06306286f, 
    0.14602710f, 0.00885791f, -0.44857842f, -0.03440410f, 0.04852880f, -0.03020180f, -0.02784302f, 0.01234801f, 
    0.09164745f, -0.10281014f, 0.09837702f, 0.01008806f, -0.12223618f, -0.11896839f, 0.14822832f, 0.19187054f, 
    0.01814142f, -0.02189536f, -0.08352418f, 0.03950056f, 0.11643456f, -0.04112202f, 0.13066082f, -0.09193217f, 
    0.16688049f, 0.13156627f, 0.19612880f, 0.12550277f, 0.18287694f, 0.06477246f, 0.10329058f, 0.21552250f, 
    0.00532495f, 0.01801860f, -0.02915275f, 0.15553920f, -0.18840766f, 0.17740685f, 0.08713058f, -0.07427609f, 
    -0.01432095f, -0.06871340f, 0.01498473f, 0.08773678f, 0.00485612f, 0.01145420f, 0.01742062f, 0.12947486f, 
    -0.29673138f, 0.00624252f, 0.06696364f, 0.03045067f, 0.01677932f, -0.05294494f, -0.00633986f, 0.00845636f, 
    -0.12946537f, -0.02818244f, -0.00920977f, 0.02859035f, -0.07603414f, -0.19278680f, -0.25613388f, -0.13665041f, 
    0.00059063f, 0.14252692f, -0.15736978f, 0.04518412f, -0.10519835f, -0.00619314f, 0.13620655f, -0.07913215f, 
    -0.09814700f, -0.12027653f, -0.21136898f, -0.16784281f, 0.03496917f, 0.03320367f, -0.13390556f, -0.12910488f, 
    0.25692880f, 0.02627177f, 0.00321844f, -0.07192119f, -0.06709106f, -0.04346032f, -0.08670200f, -0.01764040f, 
    -0.02109041f, 0.15330864f, 0.08832591f, 0.02609571f, 0.08905038f, 0.10340709f, 0.00636587f, 0.06854227f, 
    -0.06464130f, 0.10610626f, -0.33756578f, -0.34223258f, 0.11374886f, -0.01425102f, -0.08561388f, 0.10359802f, 
    -0.03086775f, -0.09991277f, 0.00037359f, -0.07398561f, 0.02355192f, 0.18748032f, 0.11403566f, -0.16661559f, 
    0.09481467f, 0.00601441f, 0.02809812f, 0.03258559f, 0.05224622f, 0.08683198f, -0.01667955f, 0.08508102f, 
    -0.26780760f, -0.34992900f, -0.20127258f, -0.15007454f, -0.02415152f, 0.09193571f, -0.04287164f, 0.01586360f, 
    0.04342944f, 0.02581976f, 0.18556975f, 0.01279345f, 0.00444288f, -0.02143088f, 0.11613337f, -0.13411397f, 
    -0.05513338f, -0.08089451f, 0.04695736f, 0.01555341f, -0.19938588f, -0.36174661f, -0.24928978f, -0.31198218f, 
    -0.05331609f, 0.08813268f, -0.15712579f, -0.10713363f, -0.01241030f, -0.01063741f, 0.01277817f, 0.10019049f, 
    -0.10210092f, -0.07390102f, -0.08677277f, -0.23145160f, -0.06900080f, -0.15790288f, 0.02116643f, 0.06481526f, 
    -0.16723555f, -0.23729320f, -0.11971581f, -0.01672474f, 0.12412792f, 0.04347149f, 0.08117402f, 0.10168175f, 
    0.12534954f, 0.07687759f, -0.09528445f, -0.26867583f, -0.00334312f, 0.06177610f, -0.04260186f, -0.01464513f, 
    0.16993162f, -0.02483306f, 0.11364920f, 0.13211535f, -0.22655465f, -0.07632504f, 0.13213465f, -0.05190471f, 
    0.02175727f, -0.00462821f, -0.06494275f, -0.01074637f, 0.13315292f, 0.14198637f, -0.04946595f, 0.22102678f, 
    -0.22117305f, -0.36020318f, -0.16861744f, -0.25100294f, -0.06648051f, 0.01471344f, -0.01274125f, 0.18216175f, 
    0.37147456f, 0.16108888f, -0.09475909f, -0.02454758f, 0.06489612f, 0.08385920f, 0.08777899f, -0.27108914f, 
    0.05595183f, 0.08244424f, -0.05003639f, -0.02653160f, 0.03501625f, -0.09870438f, 0.03763387f, 0.11259332f, 
    0.24238494f, -0.24622466f, 0.17744298f, 0.21859047f, 0.25369716f, 0.15698978f, 0.06794172f, -0.12458429f, 
    0.05111334f, -0.01328012f, -0.04699733f, -0.12735663f, -0.00310709f, -0.21593061f, -0.08553343f, -0.16482452f, 
    0.04434752f, -0.13944523f, -0.04501956f, -0.01646521f, 0.20593268f, -0.13165136f, -0.12296857f, 0.23309246f, 
    0.00070847f, 0.11870866f, 0.03801068f, -0.02200303f, 0.04057607f, 0.04213495f, -0.01382987f, 0.02496336f, 
    -0.03300967f, 0.19900821f, 0.15589717f, -0.15439521f, 0.18111053f, 0.18161781f, 0.17065141f, -0.14204440f, 
    -0.04216868f, 0.23851776f, -0.06293499f, 0.12897483f, 0.00406964f, 0.10349118f, 0.03860913f, 0.02645914f, 
    0.12372527f, -0.16264333f, -0.25348574f, 0.17255448f, 0.08249583f, 0.04843281f, -0.07506293f, 0.03408856f, 
    0.05875131f, -0.01566324f, -0.09397755f, -0.02360515f, -0.16261515f, 0.00447609f, -0.16593482f, 0.01617811f, 
    0.03198841f, 0.16857734f, -0.10513150f, -0.04216423f, -0.03698835f, -0.10735858f, 0.10194158f, -0.10195278f, 
    0.01146870f, -0.06574235f, 0.01484498f, -0.00056024f, 0.04452657f, -0.01717776f, -0.18663821f, 0.06708463f, 
    0.00168976f, -0.15267301f, -0.06271518f, 0.36251745f, -0.58941913f, 0.55617374f, 0.13451263f, 0.14520513f, 
    -0.15765543f, -0.13755637f, 0.10058147f, 0.10447053f, 0.06190459f, 0.04651720f, 0.03041467f, -0.05109620f, 
    -0.01840242f, 0.01340207f, 0.07351397f, -0.08192142f, 0.19475198f, 0.14432955f, 0.19017245f, 0.05336436f, 
    0.05463615f, 0.04132622f, 0.02422035f, 0.05632630f, -0.26100752f, 0.07749268f, -0.02283902f, -0.28024596f, 
    -0.08425398f, -0.22354856f, -0.04780334f, -0.03273635f, 0.02546870f, -0.01585208f, 0.02087200f, 0.06644309f, 
    -0.26405844f, 0.11882018f, -0.11381815f, -0.05342834f, 0.07405908f, -0.16160107f, 0.13448635f, 0.28372175f, 
    -0.06874195f, 0.05777109f, 0.00738480f, 0.00115700f, -0.13048677f, 0.28354436f, -0.06002115f, -0.19917215f, 
    -0.07972180f, 0.03071765f, -0.00304165f, -0.19202414f, 0.00500203f, 0.01020041f, 0.08154713f, -0.04807647f, 
    -0.08090513f, 0.20141158f, -0.08395216f, 0.08269221f, -0.00634702f, -0.03941545f, 0.01651991f, 0.12625577f, 
    0.10088720f, 0.03361728f, -0.15936156f, 0.29511020f, 0.01582956f, -0.02341582f, -0.06319013f, -0.01124306f, 
    -0.10912371f, 0.03946118f, -0.07519218f, 0.00355773f, 0.00638269f, -0.10352311f, -0.03276555f, -0.07124641f, 
    0.25604367f, 0.09021144f, -0.08011585f, 0.02503391f, -0.11207096f, -0.17981966f, 0.05517221f, 0.07014797f, 
    0.01059031f, -0.02147797f, -0.04293603f, -0.07699737f, -0.24588428f, -0.03530923f, 0.00778582f, -0.25776619f, 
    0.01992005f, 0.07508644f, 0.08985940f, -0.10915585f, -0.08596659f, -0.02187741f, -0.04486757f, 0.06928466f, 
    -0.03354546f, 0.03570750f, 0.07282208f, -0.20740160f, -0.02813559f, 0.03892548f, 0.02681259f, 0.05456030f, 
    0.04077391f, 0.20237407f, 0.00098673f, 0.14122190f, -0.21191044f, 0.26494324f, -0.00735406f, -0.02195374f, 
    -0.16142590f, -0.03724083f, 0.01792125f, 0.19589700f, -0.01844092f, 0.00136015f, 0.07805558f, -0.04507878f, 
    -0.00502999f, -0.07295881f, -0.00975975f, -0.10906881f, 0.06398829f, 0.04772005f, 0.08265568f, 0.01447287f, 
    -0.04069438f, 0.00295473f, -0.02728039f, 0.01166090f, 0.01822994f, -0.32550186f, -0.25675607f, 0.04119436f, 
    -0.07276042f, 0.20696099f, 0.06949514f, 0.10583698f, -0.01909344f, -0.04644907f, -0.02312428f, -0.00785063f, 
    0.37563732f, 0.11431468f, -0.05703477f, -0.32092729f, -0.01471535f, 0.00027147f, 0.04502238f, 0.08521287f, 
    0.09752948f, 0.11246394f, 0.14280424f, -0.03291444f, -0.31941849f, -0.45776695f, -0.11452367f, -0.21732025f, 
    0.05189891f, -0.16388091f, -0.07244658f, 0.05194404f, -0.05093939f, 0.07897350f, -0.03805448f, -0.03778000f, 
    -0.46146771f, 0.14030196f, 0.47163102f, 0.24718180f, -0.07127144f, 0.02669163f, -0.06289889f, 0.09080195f, 
    -0.14259426f, 0.05189421f, 0.09379297f, 0.03003062f, -0.55129498f, 0.12858780f, 0.20984703f, -0.00193244f, 
    -0.16118403f, 0.12678844f, -0.10533424f, 0.05295852f, -0.02564645f, -0.04079627f, -0.05248331f, 0.11464349f, 
    -0.17091623f, -0.16399176f, 0.10822605f, -0.21145055f, -0.03998449f, 0.02929214f, 0.05825456f, 0.08003252f, 
    0.07331085f, 0.09920528f, 0.18324968f, 0.05142599f, 0.00438566f, -0.00343311f, 0.06524603f, -0.06080389f, 
    0.00870179f, -0.00819886f, -0.02689365f, -0.01627107f, -0.02574847f, -0.02849352f, 0.02902430f, 0.02548342f, 
    0.05150114f, 0.02620191f, -0.14186025f, 0.10058048f, -0.02600748f, 0.02761090f, -0.00438397f, 0.09361193f, 
    0.03855859f, -0.08233076f, 0.13897942f, 0.05208793f, -0.21997994f, -0.27785781f, 0.19857424f, 0.17639673f, 
    0.01703580f, -0.01577727f, 0.21993394f, -0.22999574f, 0.02773685f, 0.14829674f, -0.00727487f, 0.00690866f, 
    -0.53154045f, -0.55555928f, -0.12758495f, -0.05295437f, -0.15931383f, 0.12730761f, -0.03294634f, -0.24019259f, 
    -0.02859355f, 0.04148740f, -0.10197844f, 0.07044001f, -0.02163677f, -0.20599574f, -0.21139385f, -0.05680461f, 
    -0.07225047f, 0.13163769f, 0.03856897f, -0.10954519f, 0.12489024f, -0.06026250f, -0.03804364f, 0.01676464f, 
    -0.05177558f, -0.07457707f, -0.14356425f, -0.16560414f, -0.05823889f, -0.09866810f, -0.07602135f, 0.14048645f, 
    -0.05261134f, 0.01648070f, -0.05350731f, 0.00690422f, 0.40518752f, -0.18054180f, -0.42483807f, -0.04410838f, 
    -0.10487021f, 0.03593514f, 0.04634977f, 0.12177393f, 0.11032104f, 0.02764259f, 0.07868353f, -0.03550702f, 
    -0.04998093f, -0.64225674f, -0.30431926f, -0.37923402f, -0.04209339f, -0.01794989f, -0.05926288f, -0.23022929f, 
    0.04040004f, -0.01580353f, 0.01087602f, 0.02999125f, -0.35544673f, -0.30182409f, -0.07667527f, 0.47220141f, 
    0.00160957f, 0.09982646f, 0.11054835f, -0.35773769f, -0.04463838f, -0.03331321f, 0.09025913f, 0.06037614f, 
    -0.35236046f, 0.40108076f, 0.20956741f, -0.07282980f, -0.06267773f, -0.01306683f, -0.07252542f, 0.04448220f, 
    -0.09694442f, 0.05123976f, 0.13213073f, 0.04533665f, 0.34239376f, -0.08422086f, -0.11406852f, -0.04551850f, 
    -0.04816978f, -0.03409035f, 0.25076467f, 0.01231004f, 0.06935383f, -0.08837563f, -0.03095573f, 0.07147954f, 
    -0.19032970f, 0.08437613f, -0.20695430f, 0.12522078f, 0.03943675f, 0.00919323f, -0.05591682f, 0.00933814f, 
    -0.08956162f, 0.13914320f, 0.14517285f, 0.06534095f, -0.42699730f, -0.61371094f, 0.08266596f, 0.11230361f, 
    0.06968786f, -0.03633008f, -0.10959465f, -0.17768569f, -0.04774583f, -0.02654065f, 0.01503586f, 0.06421345f, 
    -0.16060095f, -0.13192926f, -0.37240124f, 0.08120717f, 0.01837876f, 0.12220746f, 0.00182521f, -0.22423033f, 
    -0.07013478f, -0.00307175f, 0.07468797f, 0.10320175f, 0.66615522f, 0.18284130f, 0.25057289f, -0.56795198f, 
    0.07797301f, -0.01299997f, 0.16581689f, -0.01440840f, -0.00273513f, 0.09436361f, 0.08911110f, -0.21892917f, 
    0.21122500f, -0.04539651f, 0.21977496f, -0.01163027f, -0.04396206f, -0.05746277f, 0.00994252f, -0.05642110f, 
    -0.03748385f, -0.10371860f, 0.18230228f, -0.08872519f, -0.07303789f, 0.19820754f, 0.46453139f, 0.10528513f, 
    0.12595636f, -0.03541882f, -0.12449562f, -0.03237708f, 0.04102984f, 0.12839596f, 0.06033183f, 0.02489760f, 
    0.08173700f, -0.09947854f, -0.06561011f, 0.08870711f, 0.03123685f, 0.08246741f, -0.05293833f, 0.21190575f, 
    0.12096463f, 0.07255670f, 0.22328852f, 0.08257861f, -0.62725592f, -0.43117037f, -0.44450846f, -0.59180331f, 
    -0.14628021f, -0.09419031f, -0.16563269f, 0.07854629f, -0.05136381f, -0.01229960f, 0.07015850f, -0.17483109f, 
    -0.09171695f, -0.06708095f, -0.16138947f, 0.11829107f, -0.09597383f, -0.08912953f, -0.08571462f, 0.06789406f, 
    -0.06879690f, -0.05230147f, 0.07387602f, -0.17022233f, -0.10875983f, -0.13504575f, 0.14353217f, -0.00257324f, 
    -0.15908125f, -0.30087757f, -0.15245996f, 0.09819411f, -0.03889993f, 0.04288539f, -0.10840896f, -0.13887899f, 
    0.14217141f, 0.04551918f, -0.04420847f, -0.02404054f, 0.03742506f, -0.03152642f, 0.08868361f, -0.06183298f, 
    -0.01334213f, 0.08175359f, -0.01917784f, -0.11604476f, 0.02345494f, 0.15569498f, 0.25318322f, 0.03434034f, 
    -0.03383340f, 0.01594210f, 0.03975877f, 0.02807707f, 0.18741579f, 0.21264268f, 0.06379995f, 0.11526083f, 
    -0.13484608f, -0.70401108f, -0.42327258f, 0.07870730f, -0.09844264f, -0.08190624f, 0.14331695f, -0.20761509f, 
    -0.02072073f, 0.00429783f, -0.04557139f, 0.13048452f, -0.28121248f, -0.52764803f, -0.40617421f, 0.00358006f, 
    -0.12621143f, -0.03876299f, -0.06310705f, -0.07923527f, -0.00628653f, -0.00545742f, -0.00849209f, -0.01638798f, 
    0.09400836f, -0.09734450f, -0.21674559f, -0.03990263f, -0.01021426f, 0.02260228f, -0.01027007f, 0.04305025f, 
    -0.04066718f, -0.03135313f, 0.04817846f, -0.16684043f, -0.10524431f, 0.57741320f, 0.02576279f, 0.16193880f, 
    -0.13687840f, 0.07476246f, -0.16963157f, 0.20418866f, 0.03936158f, -0.07969970f, -0.06062564f, -0.02461988f, 
    -0.39698881f, 0.15152627f, 0.08936333f, 0.06244253f, 0.04116451f, -0.14887013f, 0.04558757f, 0.01713448f, 
    0.02084894f, -0.03592831f, 0.19946729f, 0.03796951f, 0.02883891f, -0.15939105f, 0.00682009f, 0.01351912f, 
    -0.00144536f, -0.00610937f, 0.00633981f, -0.07346695f, 0.00005916f, -0.08477810f, -0.09468555f, -0.05879157f, 
    -0.46621415f, 0.28172278f, 0.05420433f, -0.08499581f, -0.05408911f, 0.05444508f, 0.12853307f, -0.02970651f, 
    0.03631696f, 0.02019703f, -0.01965527f, 0.05528351f, -0.27808833f, -0.50123322f, -0.25766671f, 0.22811274f, 
    0.04259053f, -0.20591046f, -0.11543608f, -0.22782934f, -0.04495652f, -0.03771979f, -0.03214453f, -0.01382548f, 
    0.00476786f, 0.12255161f, 0.15342793f, 0.25531602f, 0.00943641f, -0.03100277f, -0.21889012f, 0.04706744f, 
    -0.00124565f, -0.06412028f, -0.08622061f, 0.02645269f, -0.06618413f, 0.22757961f, -0.08196781f, -0.01607920f, 
    0.02208862f, -0.00125139f, -0.02371339f, 0.06014090f, 0.17444056f, 0.11610690f, 0.18766837f, -0.00484097f, 
    -0.03861834f, 0.11288583f, 0.19784805f, 0.01725656f, -0.07917556f, 0.01072507f, -0.02098138f, 0.03667808f, 
    -0.00210029f, -0.01318897f, 0.02170261f, -0.06395505f, -0.04039955f, -0.04056673f, -0.13019872f, 0.08420528f, 
    -0.01375006f, -0.15435542f, -0.06180488f, 0.02859575f, 0.01710461f, 0.04336179f, -0.11432417f, -0.06157417f, 
    0.09806895f, 0.02150821f, -0.05095479f, -0.06523060f, 0.11164902f, -0.07381480f, -0.02787497f, 0.08383000f, 
    -0.01976024f, 0.13264582f, 0.01663597f, -0.04880055f, -0.09105438f, 0.00983220f, 0.23319674f, 0.01650377f, 
    -0.00319273f, -0.16211280f, 0.11206495f, 0.09061303f, 0.03340416f, 0.12280746f, -0.08017161f, 0.03512920f, 
    0.21192905f, -0.06464494f, 0.28106529f, 0.12149315f, -0.01751437f, 0.00209056f, -0.03706708f, 0.00040581f, 
    0.07503068f, 0.07572830f, 0.14925238f, 0.06407484f, 0.05788364f, -0.09153598f, -0.01484912f, 0.02065755f, 
    0.04524983f, 0.04777450f, -0.07487407f, 0.15642479f, -0.04348897f, 0.06675950f, -0.15253170f, 0.00319291f, 
    -0.39812353f, -0.36701950f, -0.23545943f, 0.22771427f, 0.01055538f, 0.21898784f, 0.17374191f, -0.15714620f, 
    0.00419337f, 0.00833124f, 0.06564794f, 0.06383551f, 0.11922854f, -0.17257863f, 0.00113100f, 0.20838031f, 
    0.08230637f, -0.06139277f, -0.02458563f, -0.02488381f, 0.01227022f, 0.07741352f, 0.16415437f, -0.25724044f, 
    -0.44366410f, -0.13243107f, 0.60579479f, 0.23711266f, -0.05129093f, 0.16902302f, -0.06520261f, -0.24968709f, 
    -0.03209566f, 0.00525368f, -0.02323598f, 0.00007396f, -0.49505457f, -0.35579383f, -0.03957089f, 0.15677473f, 
    -0.17914139f, -0.09445462f, -0.14757940f, -0.23923428f, -0.02861131f, 0.07905670f, -0.01783766f, -0.01903158f, 
    -0.16088225f, 0.05717697f, 0.06664902f, -0.07100377f, 0.03573694f, 0.02623454f, 0.02357856f, -0.07839395f, 
    0.02719039f, -0.01787238f, -0.00836106f, 0.00417589f, 0.00814998f, -0.29089448f, -0.06940027f, -0.30468002f, 
    -0.03787661f, 0.08836299f, 0.12071893f, 0.02799827f, 0.00520896f, -0.06506058f, -0.00479097f, 0.06792954f, 
    -0.00858355f, -0.00764596f, -0.56607491f, -0.15043192f, -0.00382806f, -0.03430459f, 0.11708287f, 0.12642719f, 
    0.06494756f, 0.20748174f, -0.04693133f, -0.13941118f, 0.21853031f, -0.01877577f, -0.03262753f, 0.26535124f, 
    0.01075392f, 0.07428338f, 0.21775356f, 0.15418220f, 0.01354575f, -0.00742852f, 0.18950988f, -0.06224246f, 
    -0.49816033f, -0.55662572f, -0.51114380f, -0.36486733f, -0.21942267f, -0.21806470f, -0.22508477f, -0.24634233f, 
    -0.01439391f, 0.00845659f, -0.06612498f, -0.06752095f, -0.24278554f, -0.59822255f, -0.55691731f, -0.15408604f, 
    -0.30474094f, -0.09658028f, -0.00598527f, -0.04075484f, -0.03502442f, -0.03303808f, 0.00388907f, 0.10515081f, 
    -0.13156621f, -0.37739253f, -0.05707942f, 0.10992534f, -0.13835831f, -0.03180110f, 0.14837715f, -0.24238165f, 
    0.00208695f, -0.03545311f, 0.04977002f, 0.08966611f, -0.62043500f, -0.52046072f, 0.22463292f, -0.35936037f, 
    -0.02012946f, 0.03601708f, -0.11222766f, -0.34826365f, 0.00505504f, -0.03649998f, 0.00545373f, -0.11658299f, 
    -0.04083148f, -0.07355124f, -0.01097650f, -0.14667088f, 0.02583502f, 0.06383783f, 0.03660999f, -0.04983479f, 
    0.00980764f, -0.06839251f, 0.08415147f, -0.08410825f, -0.14450389f, 0.00976369f, 0.04469953f, 0.02736321f, 
    0.02222176f, -0.10036826f, -0.13857190f, -0.09453373f, 0.02574612f, -0.01490440f, 0.01721823f, -0.05658754f, 
    -0.02081187f, -0.00059180f, -0.05286041f, 0.02380690f, -0.00399199f, -0.10399278f, -0.01317910f, -0.06235772f, 
    -0.03870961f, -0.02821812f, 0.01414799f, 0.02511021f, -0.02520235f, 0.10423333f, -0.21525134f, 0.01479674f, 
    -0.01104754f, -0.03681295f, -0.03437778f, -0.03422586f, 0.07340860f, 0.07771170f, 0.02032311f, -0.01206990f, 
    -0.00607972f, -0.06221685f, -0.06312095f, 0.03357926f, 0.05817775f, -0.02427689f, -0.03304376f, -0.06627187f, 
    0.02764137f, 0.12788887f, 0.04362763f, -0.12757562f, 0.20976280f, -0.16495694f, -0.15325266f, -0.09394447f, 
    -0.05194842f, 0.03843672f, 0.02151015f, -0.05048371f, -0.00350934f, 0.15065455f, -0.02200668f, -0.00506611f, 
    -0.00867374f, 0.09312143f, 0.11146553f, -0.14432456f, -0.01343956f, -0.00640458f, -0.02376421f, 0.02235863f, 
    0.01528325f, -0.01068896f, -0.05385078f, -0.07578618f, 0.07461228f, -0.01391862f, 0.02500477f, -0.07661433f, 
    -0.01613611f, -0.01079984f, -0.04545132f, -0.04047096f, -0.02495627f, -0.02598156f, -0.01198106f, 0.03795905f, 
    0.12457003f, 0.06734379f, -0.12357672f, 0.26418707f, -0.00803770f, -0.02507856f, 0.03983829f, -0.00738326f, 
    0.08920362f, 0.10470762f, 0.05087648f, -0.12798174f, -0.33165687f, -0.37669280f, -0.09283464f, -0.07432148f, 
    0.10622493f, -0.03826907f, 0.18971580f, -0.13127501f, 0.10200543f, 0.05490435f, -0.01039411f, 0.02249745f, 
    0.61576623f, -0.59985954f, -0.67747295f, -0.44887459f, -0.01138968f, -0.05983732f, -0.13240857f, 0.04189125f, 
    0.18533784f, 0.09450790f, -0.03131674f, -0.05877544f, 0.73363233f, -0.36751592f, -0.08622966f, -0.18996179f, 
    0.13048717f, -0.21604547f, -0.21199766f, 0.04430732f, 0.08933707f, -0.06013954f, 0.09338756f, 0.04444404f, 
    0.00400216f, 0.08473686f, -0.35911593f, 0.16597076f, 0.03470298f, 0.00513982f, -0.03169169f, -0.01293700f, 
    0.11630955f, -0.00389205f, 0.04067310f, -0.01017414f, 0.03993961f, 0.15681964f, -0.03867649f, -0.04924809f, 
    -0.01476352f, -0.01577892f, 0.02023084f, 0.01866838f, -0.00086452f, -0.16934919f, -0.16521287f, -0.20571974f, 
    0.13278887f, -0.15628214f, -0.08198842f, -0.17933239f, -0.00137827f, -0.06233706f, -0.01132267f, -0.08881723f, 
    -0.14674793f, -0.02280032f, -0.14071956f, -0.10481499f, 0.51419210f, -0.41004813f, 0.03855982f, -0.26958615f, 
    -0.17277333f, 0.11624810f, 0.09572561f, 0.31686860f, -0.01024388f, -0.03751742f, 0.02500639f, 0.02346160f, 
    -0.27169177f, -0.24386412f, -0.06208741f, -0.02308298f, -0.03738495f, 0.00934404f, 0.09938616f, 0.07220024f, 
    -0.08842374f, -0.12086321f, -0.08277582f, -0.03188533f, -0.08098745f, 0.04774436f, -0.04025729f, 0.02661098f, 
    -0.01017443f, 0.00060828f, 0.03564183f, 0.02631518f, -0.03532434f, -0.06553672f, 0.08346448f, 0.08089280f, 
    -0.01438593f, 0.00693019f, -0.07103346f, 0.21757691f, -0.04723787f, -0.04797468f, -0.02729903f, 0.01026167f, 
    0.01350706f, -0.06590854f, 0.05159571f, -0.09495275f, -0.32942876f, -0.27887651f, -0.28708339f, 0.24266919f, 
    -0.05022549f, 0.02370833f, 0.02111765f, -0.03020138f, 0.03217256f, -0.11745530f, 0.03135424f, -0.14030942f, 
    -0.41110238f, -0.13069266f, 0.08136877f, 0.26092303f, -0.01571382f, 0.10761616f, -0.07226294f, 0.03899766f, 
    -0.05320997f, 0.00487755f, -0.07899836f, -0.03189270f, -0.03417940f, 0.17585976f, -0.26651579f, 0.05928765f, 
    -0.00294959f, 0.05231878f, -0.03630211f, -0.01350896f, 0.02172289f, -0.02088786f, -0.01136795f, 0.07123455f, 
    0.03008942f, 0.13492952f, -0.12209098f, -0.13171153f, 0.03376503f, -0.01814390f, 0.08574038f, 0.02210518f, 
    -0.10494561f, 0.04533178f, 0.07347851f, 0.00639369f, -0.15802163f, 0.16373622f, -0.02870672f, -0.04651311f, 
    -0.13822320f, -0.00392310f, -0.00256650f, 0.00644765f, 0.00541809f, 0.06386393f, 0.12633699f, 0.00474917f, 
    -0.00374952f, -0.04607178f, 0.18667835f, -0.03118759f, 0.03053939f, 0.02717100f, 0.04845582f, 0.02316968f, 
    0.06502111f, -0.12035184f, 0.08921000f, -0.20756443f, -0.29744175f, 0.56162441f, 0.11607759f, 0.19630989f, 
    0.08703268f, -0.07973838f, 0.09937453f, 0.03965216f, -0.01572046f, -0.02147186f, -0.06533149f, -0.01299899f, 
    -0.05263500f, 0.12124471f, 0.13005017f, 0.01622052f, -0.03845167f, -0.03016560f, -0.13160948f, -0.02311788f, 
    -0.10506555f, 0.03457931f, -0.05206207f, -0.01617227f, -0.46010306f, 0.37362966f, -0.13257980f, 0.43597475f, 
    -0.09150440f, 0.06710610f, 0.10743208f, 0.01323869f, -0.06012588f, -0.00619053f, -0.13058454f, 0.13510133f, 
    -0.14906622f, 0.19183040f, -0.05072488f, 0.04174764f, 0.00971968f, -0.00587020f, 0.05051073f, 0.01794619f, 
    -0.15642449f, -0.02941272f, 0.01458425f, -0.06262279f, -0.19189669f, -0.05278940f, 0.00213551f, 0.06237527f, 
    0.07708098f, -0.07033517f, -0.05050766f, -0.01026414f, -0.10221485f, 0.02506798f, -0.00130066f, -0.04495044f, 
    0.34776160f, -0.07736508f, 0.12637581f, -0.20577310f, 0.07060135f, -0.04241416f, -0.07413918f, -0.05853082f, 
    0.04705065f, 0.02969310f, 0.04946702f, -0.05959326f, -0.26781768f, 0.03718974f, -0.50829744f, 0.63636637f, 
    -0.11081846f, -0.27703115f, 0.01973208f, -0.03844466f, 0.00712342f, -0.05395778f, -0.01947217f, -0.08378742f, 
    0.24703181f, 0.02009678f, 0.07615773f, -0.10782017f, -0.03741553f, -0.02347485f, 0.04934725f, 0.00006306f, 
    0.02288376f, 0.01322888f, -0.03225677f, -0.09343927f, 0.07800975f, -0.12719347f, 0.13553250f, 0.06429423f, 
    -0.02857061f, 0.04945450f, -0.07528549f, 0.06261285f, -0.02645608f, -0.02759049f, 0.08619687f, 0.02157653f, 
    -0.01279029f, 0.08940352f, 0.15240215f, 0.00025845f, 0.06499662f, -0.00147127f, -0.00720024f, -0.04908311f, 
    -0.01681060f, -0.07622417f, 0.08410513f, -0.02864297f, 0.09078607f, 0.14235330f, -0.09227514f, -0.08787130f, 
    0.03012365f, 0.04701093f, -0.08938716f, -0.01558066f, -0.06752913f, 0.11449842f, -0.09516504f, -0.02016899f, 
    -0.18666680f, -0.50015575f, 0.13247024f, 0.17965613f, 0.03634330f, -0.20955493f, 0.00470858f, 0.04733353f, 
    0.01842389f, -0.03506263f, -0.07558370f, -0.06105297f, -0.14470254f, -0.19007811f, -0.23791155f, -0.25236979f, 
    0.09386305f, -0.05630778f, -0.04241828f, 0.22121908f, 0.03968639f, -0.04064279f, -0.03759993f, -0.01136944f, 
    0.07678185f, 0.00785626f, 0.04627471f, -0.16250104f, -0.00305050f, -0.02076532f, -0.07976853f, -0.01214024f, 
    0.05699853f, 0.04620369f, -0.00340275f, -0.04745498f, -0.56315172f, -0.08333537f, -0.19064423f, -0.05254848f, 
    -0.15435208f, -0.23870844f, 0.11644838f, -0.13350552f, -0.04944750f, -0.03033373f, -0.02265729f, -0.01133979f, 
    -0.03000155f, -0.29487413f, -0.36148414f, -0.31618103f, -0.00768057f, -0.01074551f, -0.03346997f, 0.00250393f, 
    0.06492619f, 0.04853221f, 0.03598275f, 0.12520540f, -0.03560377f, 0.05270859f, 0.02976201f, -0.08777541f, 
    -0.03849176f, 0.01593336f, 0.00060159f, 0.01778791f, -0.05914186f, 0.05189237f, 0.01058026f, -0.02251550f, 
    -0.43894914f, -0.26591861f, -0.29353264f, -0.14385559f, 0.06457631f, -0.07446606f, 0.09209686f, 0.06714230f, 
    0.07785359f, 0.01454781f, -0.00083356f, 0.05655418f, -0.39602649f, -0.28656888f, 0.26245841f, -0.13520777f, 
    -0.09669444f, -0.13264892f, -0.18437719f, 0.02538818f, 0.02408974f, -0.02680826f, 0.00009945f, -0.04198403f, 
    0.11900964f, -0.03328352f, -0.05365855f, -0.05641872f, -0.16806154f, -0.03738132f, 0.03476471f, 0.05505675f, 
    0.07015026f, -0.04349580f, 0.00587202f, 0.02062565f, 0.08999457f, -0.20067020f, -0.06363314f, -0.00559378f, 
    0.03360047f, -0.15587695f, 0.05857382f, -0.08802558f, 0.08569764f, 0.14065015f, 0.13311277f, -0.10818990f, 
    0.20403801f, -0.13993233f, -0.09387664f, -0.07193135f, 0.05279999f, 0.03269784f, 0.03829402f, -0.02166386f, 
    0.14128290f, -0.03384116f, -0.10232158f, -0.03251653f, 0.12232629f, -0.02215324f, -0.06144585f, -0.13015954f, 
    -0.01792944f, -0.03751937f, 0.01394873f, 0.00760124f, 0.01475911f, -0.00701740f, -0.01384219f, -0.08455350f, 
    -0.04364458f, 0.04965470f, 0.13173813f, -0.03735292f, -0.04229461f, 0.01354213f, 0.08403318f, -0.02483190f, 
    -0.00237723f, -0.18604831f, 0.13935125f, -0.08293665f, 0.25001237f, 0.09055550f, 0.00716275f, -0.17163438f, 
    -0.03772431f, 0.12416299f, -0.11022112f, 0.03943353f, -0.07188690f, 0.05294760f, -0.06756011f, -0.08826002f, 
    0.13985245f, 0.04682933f, 0.18850231f, 0.10975985f, -0.03856389f, 0.06462140f, -0.02889264f, -0.03645380f, 
    -0.00201607f, -0.02947861f, -0.01475755f, 0.01082217f, 0.08624469f, -0.01423437f, 0.08954468f, -0.11593395f, 
    -0.02744338f, -0.00005391f, -0.01561998f, -0.05671877f, -0.01800472f, -0.03824326f, -0.01309433f, 0.00285976f, 
    -0.01283760f, -0.33998421f, -0.09067058f, -0.06726918f, -0.15058321f, 0.01541406f, 0.16173676f, 0.01163311f, 
    0.04919468f, 0.05692976f, 0.04580070f, -0.03075321f, -0.01043033f, 0.02011310f, 0.20514087f, -0.13787593f, 
    0.01492369f, 0.05749834f, -0.04082497f, 0.00848724f, 0.04418403f, -0.09981086f, -0.02691264f, -0.23748046f, 
    -0.48577601f, -0.02355097f, -0.26096562f, -0.23809175f, 0.03004639f, -0.01155978f, -0.03427778f, 0.03068190f, 
    0.03388869f, -0.08345002f, 0.00128585f, 0.00188611f, 0.04124597f, -0.40465400f, -0.20677452f, 0.06623478f, 
    0.06201026f, 0.00488788f, -0.13513967f, 0.13118364f, -0.03156454f, -0.04793883f, -0.08012399f, 0.06743357f, 
    0.01566427f, 0.14875381f, -0.03823016f, 0.01548985f, -0.00017641f, 0.06178777f, 0.05487221f, -0.03516500f, 
    -0.00936333f, 0.03343345f, 0.05781842f, -0.10069402f, -0.10640836f, 0.14794399f, -0.03492435f, 0.01906073f, 
    -0.03125583f, -0.05897976f, 0.02675604f, 0.13611358f, 0.00696920f, -0.00641016f, 0.07285642f, -0.03543159f, 
    -0.19958997f, -0.09641578f, 0.00998547f, 0.10090955f, -0.03180270f, 0.03656342f, 0.09292225f, -0.00223362f, 
    -0.01306429f, 0.07976387f, -0.04824324f, 0.08471140f, 0.62791318f, 0.07373457f, -0.28749099f, 0.18971264f, 
    0.00510741f, -0.11605562f, 0.07089743f, -0.20935237f, -0.02167650f, -0.07590147f, 0.00080507f, 0.02525675f, 
    -0.27143037f, -0.30066642f, -0.14798379f, 0.10986124f, 0.00376566f, -0.04020400f, -0.09475578f, -0.06350940f, 
    0.03042391f, -0.00866330f, 0.04000122f, -0.01880883f, -0.19647790f, -0.27161938f, -0.27023154f, -0.20980707f, 
    0.03883062f, 0.04425289f, 0.07024979f, 0.03878438f, 0.00182931f, -0.03386091f, -0.05963712f, 0.03133861f, 
    -0.18486036f, 0.26481992f, -0.26838592f, 0.07028851f, 0.11831980f, 0.07430490f, 0.11051781f, -0.03308903f, 
    -0.04850672f, -0.00528719f, 0.04881031f, 0.03871655f, -0.27329952f, 0.14714248f, -0.35954347f, 0.73206240f, 
    0.17063086f, -0.07130075f, 0.06361192f, -0.07365669f, 0.02587290f, -0.07309195f, 0.00546295f, 0.04791371f, 
    0.22378355f, -0.13627674f, -0.13811141f, 0.14443542f, 0.04065396f, -0.07743543f, 0.04190878f, -0.02180994f, 
    0.07462353f, -0.01478778f, -0.04723719f, 0.26766005f, -0.06114087f, -0.03419477f, 0.01685425f, 0.02539849f, 
    0.03050963f, -0.09921891f, -0.00204606f, -0.01278941f, 0.11176545f, 0.08356141f, 0.02965729f, 0.01443490f, 
    -0.16160184f, -0.02063186f, -0.00668950f, 0.01252059f, 0.06672730f, -0.02938276f, 0.05485667f, 0.04849055f, 
    0.01943029f, 0.06137734f, 0.12056636f, 0.16569123f, -0.16365734f, 0.08139374f, 0.15455286f, 0.06026668f, 
    -0.02041392f, -0.04807599f, -0.07594658f, -0.03061144f, -0.04295025f, -0.03214593f, 0.01300095f, 0.00516632f, 
    0.09589288f, 0.00177621f, 0.03236642f, 0.01265984f, -0.06474023f, 0.01922496f, -0.02301689f, -0.07298774f, 
    0.01315524f, 0.01638172f, -0.07809169f, -0.18949606f, 0.20078447f, -0.15830465f, -0.20240891f, -0.10889231f, 
    -0.02794630f, -0.03156338f, -0.00369430f, 0.07352452f, 0.01894258f, -0.13861842f, -0.04145208f, 0.00084035f, 
    -0.17194512f, 0.07264945f, 0.05631292f, -0.03076403f, -0.10180233f, -0.12857687f, 0.03873434f, -0.04996132f, 
    -0.09103469f, 0.06039997f, 0.07353391f, -0.06465184f, -0.04059943f, -0.10824195f, 0.15011111f, -0.11156310f, 
    0.10988350f, -0.12787035f, -0.01529086f, -0.07661857f, -0.11474382f, -0.05483818f, -0.06772731f, -0.15025735f, 
    -0.31906226f, 0.11240336f, -0.02712758f, -0.01956818f, 0.02232816f, 0.00769378f, -0.01338599f, 0.03561616f, 
    -0.26326862f, 0.02439383f, -0.27578419f, -0.45790058f, -0.38202688f, -0.71392751f, -0.40743950f, 0.18419714f, 
    0.05908796f, 0.07215255f, -0.00773261f, 0.02657332f, -0.12762587f, 0.07621722f, -0.00862156f, -0.01280248f, 
    -0.33311108f, -0.20720808f, -0.12452497f, 0.11314429f, -0.12944862f, 0.08718703f, 0.02102277f, 0.06423391f, 
    0.04428066f, 0.09858724f, 0.03679679f, 0.02722225f, -0.20326883f, -0.32353669f, -0.32205459f, -0.08891338f, 
    -0.19787595f, 0.09869541f, 0.14214583f, 0.19025111f, -0.03859786f, -0.04908751f, -0.00224587f, -0.11892561f, 
    -0.06112512f, -0.26379234f, -0.04854753f, -0.05169911f, -0.05289651f, 0.03709629f, 0.01391205f, 0.11815603f, 
    0.04573936f, 0.07856441f, 0.17353511f, -0.04701957f, -0.11985573f, 0.07030366f, -0.04454782f, -0.06659733f, 
    -0.08987817f, -0.00220820f, -0.04860802f, -0.03206797f, 0.00272098f, 0.14977030f, -0.01137875f, 0.03179211f, 
    0.01520492f, -0.04223089f, 0.04586940f, -0.14607957f, -0.03489893f, 0.08355387f, -0.00062417f, 0.03704738f, 
    0.10168414f, -0.08893694f, 0.08981138f, 0.06090706f, 0.16002370f, 0.05920510f, -0.69297624f, 0.04046015f, 
    -0.06495694f, 0.05418610f, 0.25458542f, -0.07601555f, -0.07192018f, -0.22561529f, -0.03451562f, -0.10881006f, 
    -0.07966022f, -0.35689130f, -0.32568565f, -0.31049538f, -0.04720818f, -0.03850712f, -0.05400142f, -0.06167937f, 
    -0.08530089f, -0.10898268f, -0.02718537f, -0.06542709f, -0.12638976f, 0.05125091f, 0.05351894f, 0.03630006f, 
    0.02958558f, -0.03062460f, -0.05653577f, -0.02142454f, 0.00587144f, -0.02272055f, -0.11140038f, -0.02445232f, 
    0.14203909f, 0.01576977f, -0.13561694f, 0.03504170f, 0.01828638f, -0.04568997f, -0.02146838f, 0.08726110f, 
    0.13425463f, 0.12316207f, 0.10468210f, 0.16197725f, -0.20329002f, -0.32725456f, -0.13290511f, -0.39671490f, 
    0.09537885f, 0.05220406f, 0.12148498f, 0.09217553f, -0.22344752f, -0.13461812f, -0.06593866f, -0.19120280f, 
    0.30677551f, 0.10552557f, 0.02862767f, -0.10743015f, 0.05956538f, -0.18268478f, 0.01959010f, 0.10576147f, 
    0.19157922f, 0.03109219f, 0.12152093f, 0.04598361f, 0.13292544f, 0.17388460f, 0.00087007f, 0.05344576f, 
    0.10583498f, 0.07033555f, 0.02459815f, -0.02854987f, -0.04002505f, -0.01527295f, -0.01392136f, 0.02130727f, 
    -0.18547636f, -0.29832268f, -0.09664989f, -0.16868486f, -0.12682900f, 0.08501051f, 0.04493557f, -0.00149914f, 
    0.09705890f, 0.04443981f, 0.06814231f, 0.04062294f, -0.27948073f, 0.12825561f, 0.09644477f, 0.07190178f, 
    0.11971196f, 0.08133955f, -0.15292817f, 0.03189881f, -0.07840279f, 0.03448433f, 0.06213427f, 0.05538908f, 
    -0.40892580f, 0.08744206f, 0.11133101f, 0.10598791f, -0.05778364f, -0.02800083f, -0.04334863f, -0.07478680f, 
    0.09082734f, 0.23325162f, -0.09884368f, 0.14752685f, -0.03168158f, -0.13186929f, -0.38983521f, -0.06415366f, 
    -0.13119057f, -0.16610807f, -0.05660593f, -0.29652274f, 0.03552947f, -0.02695330f, 0.06807663f, 0.07737629f, 
    0.37561086f, -0.03763856f, 0.00428175f, -0.15829009f, 0.06302343f, -0.02597206f, -0.06382013f, -0.01399862f, 
    0.01458928f, 0.01852274f, 0.02745192f, 0.05435229f, -0.85239559f, -0.16898613f, 0.31495148f, 0.31749135f, 
    0.00625406f, -0.08478198f, -0.34097224f, -0.00934401f, 0.00269978f, 0.02131661f, 0.14398684f, -0.04740729f, 
    -0.32786012f, -0.05907280f, 0.12669878f, 0.11716013f, 0.01788268f, 0.07286114f, -0.06888562f, 0.18389381f, 
    0.21429922f, 0.00691092f, -0.05495695f, 0.07989252f, 0.22196232f, -0.04268019f, 0.00469234f, -0.16339494f, 
    -0.02593756f, 0.13527098f, 0.05532870f, 0.04715673f, 0.14706133f, 0.03760271f, 0.08124203f, -0.00116799f, 
    0.23013173f, 0.03334700f, -0.17462690f, -0.40043795f, -0.04513367f, -0.12687182f, 0.02647224f, -0.13752754f, 
    0.15674622f, 0.02271468f, -0.04024381f, -0.16147442f, 0.24575080f, -0.45728418f, -0.33967954f, -0.28340462f, 
    -0.05501107f, -0.11179503f, 0.12251322f, -0.09255838f, 0.13223010f, 0.05304896f, 0.02625245f, 0.06911136f, 
    0.19238214f, -0.01875880f, -0.00892464f, -0.15799342f, 0.00068616f, 0.04111200f, -0.09057008f, -0.09535857f, 
    0.06107028f, 0.07389665f, 0.12718132f, 0.12569290f, -0.06936085f, -0.08060297f, -0.13475579f, -0.01980593f, 
    0.06096250f, -0.04523297f, -0.01932842f, 0.06466409f, 0.00657640f, 0.15410250f, -0.01877140f, 0.09637012f, 
    -0.45366517f, 0.03827050f, 0.13847797f, 0.07227134f, -0.05730227f, -0.00588554f, -0.09198915f, 0.00483652f, 
    -0.14074373f, 0.05625395f, -0.02220142f, 0.00392378f, 0.22736068f, -0.13870746f, -0.21553516f, 0.01470855f, 
    0.05085426f, -0.04750991f, 0.01499929f, -0.02463601f, 0.01009159f, 0.02559621f, 0.14398402f, 0.01231905f, 
    0.48152766f, 0.10128196f, -0.07650804f, -0.08975344f, -0.09731396f, 0.07634093f, -0.09503141f, 0.08553417f, 
    0.05119161f, 0.07136977f, 0.02138843f, 0.08797780f, 0.12244110f, -0.28425232f, -0.36217919f, -0.24299510f, 
    -0.13104215f, 0.05892226f, 0.07028069f, -0.19292815f, -0.04111693f, -0.03937423f, 0.00123803f, -0.04495750f, 
    0.16968840f, 0.05062898f, -0.04198697f, -0.18498607f, 0.05324351f, -0.08940661f, -0.00515207f, -0.04149253f, 
    -0.11472984f, 0.03527214f, 0.02740064f, 0.01965942f, -0.21740402f, -0.23761903f, 0.07854497f, 0.18805385f, 
    -0.06488333f, 0.06050016f, 0.11809761f, 0.02718558f, 0.08387363f, -0.07116371f, 0.15737739f, -0.01726411f, 
    -0.38482523f, -0.30290335f, -0.15832900f, 0.02756228f, 0.14264221f, 0.23103632f, 0.07873420f, 0.07878651f, 
    0.04411408f, 0.03840449f, 0.14407526f, 0.09558567f, -0.04139186f, -0.02342198f, 0.04054681f, -0.03356522f, 
    -0.07223196f, -0.04419386f, -0.05851877f, -0.00622879f, 0.05634852f, 0.05847583f, 0.05241739f, 0.03784396f, 
    0.02525476f, -0.34373519f, -0.16641432f, 0.17818391f, -0.02037490f, 0.12308894f, 0.06266924f, 0.01360408f, 
    -0.12883586f, -0.00584678f, -0.00822716f, 0.04396946f, 0.07094339f, -0.14035860f, -0.06290113f, -0.01310455f, 
    -0.06490134f, -0.00058640f, 0.00802495f, -0.00189933f, 0.06148325f, 0.01806254f, -0.03736155f, 0.07508317f, 
    -0.19983803f, -0.06868729f, -0.04533395f, 0.24170695f, -0.06535241f, 0.09023044f, 0.09654098f, 0.07032020f, 
    0.03699682f, -0.07533733f, 0.05249701f, -0.04753441f, 0.18097194f, -0.13381340f, 0.01690651f, -0.05427912f, 
    -0.04355171f, -0.01121771f, -0.02257442f, -0.01506436f, -0.06030573f, -0.15700023f, -0.14538218f, -0.34077537f, 
    -0.17247380f, -0.17899334f, -0.03946484f, -0.04490493f, -0.00040461f, 0.08925586f, 0.01007402f, 0.07386205f, 
    -0.20974237f, -0.06689742f, -0.12818070f, -0.20983045f, 0.00736419f, -0.00747678f, -0.11454457f, -0.04635792f, 
    0.04108756f, 0.00253239f, -0.02580611f, 0.00851879f, 0.04923636f, 0.02122752f, 0.09561621f, 0.10024316f, 
    -0.37111387f, -0.19616650f, 0.16553472f, 0.04880944f, 0.05298487f, -0.01360809f, -0.00110952f, -0.00609928f, 
    0.05769372f, 0.11610454f, 0.02190853f, 0.14389944f, 0.03051720f, 0.01759824f, -0.21564719f, -0.12362761f, 
    -0.06133594f, -0.12395039f, 0.02077134f, 0.05500888f, 0.14823319f, 0.03418210f, 0.11928283f, 0.08164065f, 
    -0.33292714f, -0.00573732f, 0.07926334f, 0.51512736f, 0.01233043f, 0.04059995f, -0.02218754f, 0.09350386f, 
    0.01050946f, 0.22602309f, -0.24637392f, -0.13983843f, -0.00525810f, 0.01907486f, 0.12480529f, 0.08827315f, 
    -0.00699836f, -0.04366825f, -0.08952309f, 0.03061758f, 0.08758385f, 0.07113931f, 0.00784913f, 0.04442685f, 
    0.50599533f, 0.20130934f, -0.01892362f, -0.08847979f, 0.06402838f, 0.09977427f, -0.09194896f, -0.25614753f, 
    -0.03782301f, 0.04899037f, -0.03976626f, -0.08601934f, -0.24094839f, 0.09581656f, 0.11472774f, 0.21728814f, 
    -0.01619279f, -0.07753934f, -0.08471227f, 0.02542115f, 0.04685148f, 0.11666837f, 0.10472328f, 0.03011674f, 
    0.17064732f, -0.20770054f, -0.03461111f, 0.28388974f, 0.11436582f, 0.12074024f, -0.02575702f, 0.21748608f, 
    -0.06962185f, -0.06213462f, -0.05564032f, -0.04565206f, 0.28337827f, -0.00113484f, -0.35727060f, -0.02711044f, 
    -0.08519206f, -0.14592065f, 0.21196289f, -0.10575092f, 0.06188454f, -0.04540759f, 0.09212595f, 0.01479446f, 
    -0.14454220f, 0.07736417f, 0.15631376f, 0.03474879f, -0.16752167f, -0.05914097f, -0.08456709f, -0.06104895f, 
    0.02503844f, -0.01725157f, 0.05113932f, 0.04465426f, -0.30333245f, -0.00868229f, -0.01256721f, 0.09018335f, 
    0.01661621f, -0.03499715f, -0.11274789f, 0.01804424f, -0.00386810f, -0.03781344f, -0.08767692f, -0.06545909f, 
    -0.11583312f, -0.24337091f, -0.09290146f, 0.04585243f, 0.10387764f, -0.04829362f, 0.07099427f, -0.16727518f, 
    0.12895185f, -0.03872932f, 0.12760660f, 0.16824259f, 0.25182059f, -0.07056226f, -0.12758149f, -0.04722262f, 
    -0.01302217f, -0.01333724f, -0.01182540f, 0.10005403f, -0.01151258f, 0.01853675f, 0.05405265f, -0.01606289f, 
    -0.24060810f, -0.41879070f, -0.30666131f, -0.00202092f, 0.15744661f, -0.04136467f, 0.06291515f, 0.15654518f, 
    -0.03566732f, 0.01315159f, 0.04099905f, 0.05216550f, -0.13867313f, -0.33721912f, -0.23240370f, 0.08646028f, 
    0.11770294f, -0.01109937f, 0.00631336f, 0.08644537f, 0.00765248f, 0.02998349f, 0.05233769f, -0.02141176f, 
    -0.14504279f, -0.16093160f, 0.22868808f, 0.10740018f, 0.05373667f, 0.12643625f, -0.26257864f, -0.09358062f, 
    -0.06108898f, -0.01613087f, -0.02830360f, -0.03355107f, -0.24013758f, -0.36665878f, -0.36446100f, -0.11038402f, 
    -0.15700532f, 0.03039817f, 0.16907054f, -0.00304349f, -0.00626844f, 0.10347473f, 0.05823965f, -0.02073285f, 
    0.26674896f, -0.34080347f, -0.13124152f, -0.23865484f, 0.04051044f, -0.14304608f, 0.00113045f, -0.14050032f, 
    -0.21551715f, -0.15674965f, -0.16208829f, 0.11849930f, 0.16037254f, -0.22278570f, -0.01591052f, -0.13044065f, 
    0.27913067f, -0.16900901f, 0.06460945f, 0.05527972f, -0.00077380f, -0.06890655f, -0.12231012f, -0.12005313f, 
    0.00506129f, 0.12036470f, 0.07811293f, -0.18004940f, 0.15183544f, -0.25658369f, 0.15721171f, -0.05342294f, 
    -0.08585052f, -0.04278271f, -0.08828086f, -0.01887571f, -0.40424749f, -0.11871640f, -0.14568920f, 0.11193443f, 
    0.11531139f, 0.06398924f, 0.10852326f, 0.11972424f, 0.01748514f, -0.07928886f, 0.07576767f, 0.03892100f, 
    0.04503078f, -0.12787122f, -0.02784541f, 0.19682914f, 0.09120102f, -0.02081922f, -0.07494151f, 0.03992718f, 
    0.13335034f, 0.19301870f, 0.09393858f, 0.12248018f, -0.05464581f, -0.10016228f, 0.39940950f, 0.29258028f, 
    0.29393569f, -0.21606281f, -0.00439224f, -0.12294422f, 0.08352607f, -0.02704182f, -0.04672685f, 0.08323069f, 
    -0.02507023f, -0.30011642f, 0.18381119f, 0.06791035f, -0.10749633f, 0.06866209f, 0.05801480f, -0.11702304f, 
    0.07922419f, 0.11178388f, -0.03764603f, -0.04631002f, 0.16116203f, -0.20110972f, -0.32915094f, 0.01592775f, 
    0.06025023f, 0.11482529f, 0.10797086f, -0.06158030f, 0.10724664f, -0.05409575f, -0.02496256f, 0.04195948f, 
    -0.26645926f, 0.27405378f, 0.16703840f, -0.04122771f, -0.01693348f, 0.00369599f, 0.01740110f, -0.03602786f, 
    0.09396178f, 0.12877150f, 0.07948909f, 0.11775485f, -0.12711284f, 0.41483480f, 0.31663257f, -0.50294793f, 
    -0.29016617f, -0.01414844f, 0.05269597f, -0.20349003f, 0.05066732f, 0.07568295f, -0.02197999f, 0.02550966f, 
    0.23227811f, 0.27981701f, 0.07836317f, 0.24312073f, -0.06647957f, -0.08138856f, -0.18742408f, -0.08214711f, 
    0.00325378f, -0.08002783f, 0.02825430f, 0.03961172f, -0.25184420f, 0.06210889f, -0.02479699f, -0.20076235f, 
    -0.01379615f, -0.16210803f, -0.14187814f, -0.18433329f, 0.11530406f, -0.17146307f, 0.07576381f, 0.04531281f, 
    -0.18228680f, 0.28767055f, 0.00926025f, 0.24588796f, 0.13618547f, -0.03901259f, -0.08497079f, -0.06292056f, 
    -0.06680133f, -0.04275416f, 0.05277013f, 0.15477076f, -0.18815751f, 0.12860617f, 0.10788233f, 0.16219756f, 
    0.01449567f, -0.06475911f, -0.02102796f, 0.03944694f, 0.12196618f, 0.13509698f, 0.04049213f, -0.01353614f, 
    0.00570152f, 0.10862006f, 0.17247120f, 0.06552990f, 0.08966811f, -0.05744894f, -0.01174893f, -0.09042907f, 
    -0.03274894f, -0.17695349f, 0.08145566f, 0.05546919f, -0.46052951f, 0.06790487f, -0.23298314f, -0.17578396f, 
    -0.31059811f, 0.09698514f, -0.45294523f, 0.25000590f, 0.12014826f, -0.10752934f, 0.09646229f, 0.10657868f, 
    0.00691119f, 0.20918900f, 0.32137442f, -0.28052592f, -0.05691482f, -0.07542747f, 0.12209985f, 0.24054290f, 
    0.01873475f, 0.04622583f, 0.05957055f, 0.01215569f, -0.04016585f, 0.38037735f, -0.37585244f, 0.18578102f, 
    0.06500448f, 0.05773129f, 0.07134406f, -0.13624908f, -0.10140007f, 0.05004092f, -0.15031250f, -0.11799564f, 
    -0.18959963f, -0.16092147f, -0.06006589f, 0.13637124f, 0.19213565f, -0.15879670f, 0.05780620f, 0.07244040f, 
    -0.06680568f, -0.18304506f, -0.09202918f, -0.16149645f, 0.12597755f, 0.38560379f, 0.26414067f, -0.15499853f, 
    -0.17399940f, -0.12813716f, 0.02905500f, -0.10617380f, 0.04227705f, 0.06380459f, 0.03555436f, 0.09922560f, 
    0.33980626f, -0.18553208f, -0.10643085f, -0.09394227f, 0.10806552f, -0.06430276f, -0.00572880f, 0.18848409f, 
    -0.03846844f, 0.01805063f, -0.08172801f, -0.14433816f, -0.15737462f, 0.01894139f, -0.23394226f, -0.25123981f, 
    -0.07570976f, -0.06278231f, -0.08902913f, 0.14157617f, 0.07413338f, -0.04052709f, -0.00122321f, 0.10160080f, 
    0.12872007f, -0.00701260f, 0.09137382f, 0.22235481f, 0.15047871f, -0.10617273f, -0.21238378f, -0.01939203f, 
    -0.16989493f, -0.03000314f, -0.02133546f, 0.05113428f, 0.00892458f, 0.48982164f, -0.41464913f, -0.13667074f, 
    0.00121737f, 0.09877890f, 0.15769073f, 0.05139171f, 0.01379923f, -0.00669752f, -0.12949182f, 0.02310142f, 
    0.23964883f, -0.22511502f, 0.11804742f, -0.25434887f, -0.10979432f, -0.01016447f, 0.02536141f, 0.05158835f, 
    -0.03636365f, 0.07834912f, 0.11082532f, -0.05449791f, -0.12133469f, -0.11211988f, -0.17418614f, -0.04512632f, 
    0.02870181f, 0.04920353f, 0.07060394f, 0.17518950f, 0.02186851f, 0.07676493f, 0.06770840f, -0.05246694f, 
    -0.27233979f, -0.19700214f, 0.01047823f, 0.07680549f, 0.10174591f, -0.00062240f, 0.02667839f, 0.12105124f, 
    0.06143386f, 0.00245210f, 0.05345160f, 0.06920655f, -0.57318640f, 0.20431623f, -0.28203884f, -0.38537273f, 
    -0.04904141f, -0.20416415f, 0.24133714f, 0.02217852f, 0.05508222f, 0.05834035f, -0.13458568f, 0.09682235f, 
    -0.19495249f, 0.13261573f, -0.02870752f, -0.24293713f, -0.04477778f, -0.03882939f, -0.07088575f, 0.18451457f, 
    0.04971018f, 0.11022735f, -0.13419889f, -0.14552417f, 0.06592394f, 0.09411847f, -0.15794444f, 0.00345673f, 
    0.02754950f, -0.10721821f, 0.03008588f, 0.05107893f, 0.03260326f, -0.09585694f, 0.03644693f, 0.01199959f, 
    0.01661518f, -0.13398854f, 0.24370499f, 0.25464946f, 0.00332049f, 0.02736703f, -0.15833232f, -0.21060401f, 
    0.16057611f, -0.01634016f, 0.03940475f, 0.09015279f, -0.76873147f, -0.12018558f, 0.07688480f, -0.04066763f, 
    0.03766835f, -0.24356851f, 0.24214306f, -0.00074284f, 0.05085018f, 0.10287590f, 0.08730502f, -0.03944163f, 
    -0.11002535f, 0.06332806f, 0.14160269f, 0.07666656f, 0.15998727f, 0.07154422f, 0.05352162f, -0.10714438f, 
    0.10966753f, -0.13731477f, -0.04283646f, -0.01255168f, 0.09467027f, 0.00412359f, 0.10238589f, 0.07676611f, 
    0.10022444f, -0.03626581f, -0.08301079f, 0.05793492f, -0.01070849f, 0.00115524f, -0.00555972f, -0.04347114f, 
    -0.04373525f, -0.10764769f, -0.01132912f, -0.15062605f, 0.00632678f, 0.06775792f, 0.05162637f, 0.13180037f, 
    0.01902427f, -0.01727933f, 0.06557067f, -0.06693525f, -0.22706589f, -0.22798440f, -0.05205635f, 0.15536684f, 
    -0.08812512f, 0.03817707f, -0.05883493f, -0.06649219f, -0.11211157f, 0.04693987f, -0.00579182f, 0.01215820f, 
    -0.53496146f, -0.58128673f, -0.16752492f, -0.24505429f, -0.00889739f, 0.09617881f, -0.19446823f, 0.18133593f, 
    0.02480594f, 0.03343453f, -0.00971065f, -0.08913761f, -0.14413644f, 0.05456859f, 0.15060352f, -0.19261135f, 
    -0.08631936f, -0.07445841f, -0.09095397f, 0.03774301f, 0.04831127f, 0.06355169f, 0.08236098f, -0.02348039f, 
    -0.32451162f, -0.04805342f, -0.36375657f, 0.12669118f, 0.01513563f, 0.04684462f, 0.12843019f, -0.27807605f, 
    0.06902573f, -0.03629959f, -0.03826448f, 0.11257021f, 0.16446440f, -0.03237830f, 0.49126232f, -0.42905375f, 
    0.23897004f, -0.05284677f, -0.00176884f, -0.02129320f, -0.04878104f, -0.00441597f, 0.04704593f, 0.10467079f, 
    0.34368238f, 0.11802408f, 0.09001249f, -0.43762419f, -0.14359649f, -0.08103234f, -0.13665181f, -0.00817195f, 
    -0.17073849f, -0.01276746f, 0.05145348f, -0.01844913f, 0.07641350f, -0.09370219f, -0.00704207f, 0.05677419f, 
    -0.03089056f, 0.08376615f, 0.09654982f, 0.00298021f, 0.04419562f, 0.11110675f, -0.07121184f, -0.06735210f, 
    0.19679166f, -0.03384259f, -0.18828538f, -0.40037659f, -0.13695925f, -0.10032372f, -0.08881036f, 0.11356662f, 
    0.05303831f, -0.01024593f, 0.05266845f, 0.01256440f, -0.09461974f, -0.24063824f, 0.13600942f, -0.19086792f, 
    -0.15131466f, 0.09756974f, -0.22167842f, 0.23766778f, 0.01101842f, -0.04251012f, -0.07108048f, 0.01532634f, 
    0.08154595f, 0.29419959f, 0.46002209f, -0.50736868f, 0.00546973f, -0.01451512f, -0.01322873f, -0.15357020f, 
    -0.05242738f, -0.03258693f, 0.03458348f, 0.14814287f, 0.10913929f, -0.15739466f, 0.22820200f, 0.12714320f, 
    0.06067025f, 0.01269535f, 0.00200431f, -0.01484850f, -0.02393709f, 0.19515112f, -0.00795519f, 0.15740962f, 
    0.02034639f, 0.11978290f, 0.09826931f, 0.09620389f, -0.03515159f, -0.12362171f, -0.10899399f, -0.10393726f, 
    0.03450350f, 0.08097411f, 0.18056393f, 0.04299736f, 0.15178680f, -0.03217390f, 0.16269687f, 0.14602989f, 
    0.00916088f, 0.19211029f, 0.16535468f, -0.05173002f, 0.19290352f, -0.10690162f, -0.09982703f, 0.07295131f, 
    0.11669984f, 0.01267527f, 0.22145748f, -0.26232320f, -0.00112084f, -0.18605189f, 0.03868966f, -0.05726860f, 
    -0.00844152f, -0.04033482f, -0.15212862f, -0.07716261f, -0.00769213f, -0.11015861f, 0.05013975f, 0.18065599f, 
    -0.04172590f, 0.10263208f, -0.22695562f, -0.05106231f, 0.09584571f, -0.10193346f, -0.02946036f, -0.07764065f, 
    0.05165977f, -0.10816592f, -0.38349649f, -0.27971593f, -0.20258954f, 0.16364244f, -0.09401445f, -0.03113909f, 
    0.06564795f, -0.07503716f, 0.05366715f, 0.07233321f, 0.00495786f, -0.48150998f, -0.01155592f, -0.05236453f, 
    0.06976037f, 0.03789399f, 0.00083314f, -0.03844069f, 0.12179703f, 0.00619236f, -0.01244488f, -0.13284120f, 
    0.27731472f, -0.36988774f, -0.34324023f, -0.09214501f, 0.02801821f, 0.08882818f, 0.02655671f, 0.09428918f, 
    -0.03183607f, 0.01949281f, 0.00298101f, -0.05517422f, -0.22678915f, -0.17911071f, 0.00744945f, -0.16479857f, 
    -0.16141656f, 0.09375854f, 0.00203149f, -0.03744567f, 0.02840121f, 0.14417952f, 0.01060997f, -0.14787680f, 
    -0.12942624f, -0.07795026f, -0.22160602f, -0.41271549f, -0.03243237f, -0.02723791f, -0.16024949f, 0.09809973f, 
    0.14441578f, -0.13013516f, -0.01622536f, 0.07061834f, -0.54646969f, -0.12782685f, 0.05894583f, 0.06385703f, 
    0.06725587f, -0.29686701f, 0.03835781f, 0.19278833f, -0.07798521f, -0.08688751f, -0.02085929f, -0.03211685f, 
    -0.08665464f, -0.23825552f, 0.00401355f, -0.11035793f, 0.08268730f, 0.10542078f, -0.05847281f, 0.10278487f, 
    -0.09743927f, -0.04029544f, 0.00433673f, 0.03486963f, -0.06820539f, -0.14077166f, -0.52810252f, 0.07879426f, 
    0.18007159f, 0.10878485f, 0.23646608f, 0.24752338f, 0.02733066f, -0.16692866f, -0.03101172f, -0.09260650f, 
    0.12134674f, 0.10126045f, 0.54644263f, -0.29029047f, 0.15608211f, -0.30704316f, 0.09250775f, -0.05282734f, 
    -0.16732650f, -0.00622066f, -0.14815168f, -0.14734071f, -1.07215464f, 0.08653680f, -0.13553192f, 0.23478067f, 
    -0.08465121f, -0.01417093f, -0.12841721f, -0.28208601f, 0.08776041f, -0.01144713f, -0.03017699f, -0.01108549f, 
    -0.09419430f, 0.06001557f, 0.01605079f, -0.06026312f, -0.08609201f, -0.17456783f, -0.01051568f, 0.27289447f, 
    0.02283499f, -0.00538784f, -0.01773491f, 0.02397932f, 0.26659003f, -0.16018161f, 0.12326589f, 0.17203806f, 
    0.08325285f, -0.01854743f, -0.04693691f, -0.13480775f, 0.02609373f, 0.05217061f, 0.06046306f, 0.05582615f, 
    -0.16970871f, 0.04963265f, -0.34398240f, -0.21372810f, -0.04912215f, 0.04937802f, 0.05733059f, 0.05048797f, 
    -0.01475162f, -0.04363017f, -0.10928265f, -0.00832102f, -0.41122624f, 0.38175422f, 0.08241278f, -0.21850334f, 
    -0.11381138f, -0.11189894f, 0.12381083f, 0.03710691f, 0.06280725f, 0.06501506f, -0.01883016f, 0.00703920f, 
    -0.32691127f, 0.14227615f, 0.37864637f, 0.19421239f, -0.02379639f, -0.04725210f, 0.11645439f, 0.22883090f, 
    0.01567508f, 0.09907348f, 0.20113218f, 0.22618569f, -0.25177050f, 0.09261780f, -0.06791821f, 0.09298842f, 
    0.01871862f, 0.07072118f, 0.00345787f, 0.02697489f, -0.04774624f, 0.08683913f, 0.05678155f, 0.07334489f, 
    0.03037499f, -0.04099202f, 0.09887706f, 0.15878206f, -0.10648976f, -0.01059009f, 0.15620820f, -0.07878376f, 
    0.09281114f, -0.01086491f, 0.16876166f, 0.16640651f, -0.07832737f, -0.27981231f, 0.00741503f, -0.07914859f, 
    -0.26939654f, -0.09608141f, 0.14109799f, -0.04395473f, -0.06169147f, 0.02583775f, -0.10019808f, -0.04598397f, 
    -0.21682923f, 0.00518364f, -0.02950416f, 0.06147828f, -0.11506893f, -0.15250528f, -0.10989712f, 0.00322911f, 
    -0.15055493f, -0.19842455f, -0.12554266f, -0.09104489f, -0.48958287f, 0.29879728f, -0.08831143f, 0.10952196f, 
    -0.03652046f, 0.20752081f, -0.09278522f, 0.14789073f, 0.02110311f, -0.13896120f, 0.07163581f, -0.07101986f, 
    0.03408772f, -0.05961510f, 0.02760367f, 0.11306244f, -0.16068085f, -0.05083910f, -0.00460846f, -0.01548163f, 
    0.04313268f, -0.05021885f, -0.02231889f, -0.11911399f, -0.03671963f, -0.10181862f, -0.15320760f, -0.15058605f, 
    -0.07025373f, -0.05394422f, 0.12271896f, -0.14375891f, -0.04468374f, -0.09648556f, -0.27119517f, -0.04595422f, 
    0.06984106f, -0.08930085f, -0.12451055f, 0.06912190f, 0.05755773f, -0.07949892f, 0.01954971f, -0.00285146f, 
    -0.29951367f, -0.31901950f, -0.42124265f, -0.35350409f, 0.25027999f, 0.15487248f, 0.22709817f, 0.04791579f, 
    -0.04013262f, 0.03254117f, 0.27138329f, 0.11619146f, -0.02659493f, -0.05318119f, 0.10933389f, 0.02431845f, 
    -0.05665095f, 0.17138352f, -0.01264584f, -0.19033878f, 0.16147134f, -0.09555482f, -0.09277354f, -0.01761118f, 
    -0.05672742f, 0.14489830f, 0.13830899f, -0.23221058f, 0.15161338f, -0.21486247f, 0.12783554f, -0.27302495f, 
    0.01196816f, -0.07670598f, -0.06055498f, 0.09854990f, -0.25711086f, 0.14641836f, -0.01276311f, -0.20220308f, 
    0.22752613f, 0.10936528f, -0.02407627f, -0.03101918f, 0.06494882f, 0.00743092f, -0.03278735f, 0.04170005f, 
    0.09821318f, 0.06880265f, -0.20167591f, 0.02291332f, 0.24211380f, -0.03992559f, 0.03198231f, -0.31284741f, 
    -0.04378012f, -0.03701257f, 0.05671087f, -0.03581223f, -0.05250834f, -0.03229063f, -0.17552674f, 0.11640217f, 
    -0.20163941f, 0.19024785f, 0.14127474f, -0.20165475f, -0.01978713f, 0.11691080f, -0.01329080f, 0.02958488f, 
    -0.01613470f, 0.10186534f, 0.07556071f, 0.03146712f, -0.22198337f, -0.28579691f, -0.13226715f, 0.01302628f, 
    0.13737646f, 0.21342760f, -0.34984300f, -0.01377060f, -0.17376755f, 0.06363987f, -0.10261650f, -0.12286548f, 
    -0.06126374f, -0.18655576f, -0.08058103f, 0.03323241f, 0.03630799f, 0.00115704f, -0.15399405f, -0.05270951f, 
    0.06338419f, 0.07736826f, -0.13240711f, -0.16002633f, -0.08407813f, -0.33084550f, -0.02351433f, -0.18437406f, 
    -0.01611428f, -0.09007861f, 0.08626916f, -0.27686051f, -0.00785047f, -0.08231699f, 0.08243574f, 0.03334119f, 
    -0.12490911f, -0.03066295f, 0.10259949f, 0.00613647f, -0.11099869f, 0.04987408f, -0.06999654f, -0.05662993f, 
    0.11001538f, 0.00487207f, 0.06945948f, 0.17545238f, -0.19402136f, -0.00570545f, -0.30324337f, -0.10051032f, 
    0.05148917f, -0.08868614f, 0.22586241f, -0.10250645f, -0.13547710f, -0.13919416f, -0.19149020f, -0.14454857f, 
    -0.25087842f, -0.01715004f, -0.12044211f, 0.19910678f, 0.00020907f, -0.02704693f, -0.13476974f, -0.03960569f, 
    0.05384760f, 0.11890393f, 0.03261051f, -0.00613731f, -0.01462812f, -0.32470936f, 0.26818502f, -0.02000192f, 
    -0.10830891f, 0.13140306f, -0.02276710f, 0.10506309f, -0.16763529f, -0.05143058f, -0.06887083f, 0.01327765f, 
    -0.00676372f, 0.28072631f, -0.00991765f, 0.01263589f, 0.06770765f, 0.11442726f, -0.22526014f, 0.09697591f, 
    0.07663474f, 0.13181850f, 0.04721572f, 0.21052723f, -0.01482397f, -0.00287627f, -0.06663905f, 0.18306428f, 
    0.02778966f, -0.08608124f, 0.11510577f, -0.07631195f, -0.01047412f, 0.07053956f, 0.13917850f, -0.09917600f, 
    -0.24148029f, 0.22901101f, -0.07329157f, 0.07584840f, -0.01216249f, -0.05061141f, -0.02588876f, -0.06575722f, 
    0.00164788f, -0.07135362f, -0.02864362f, 0.05577403f, -0.11974350f, -0.23108350f, -0.34755504f, 0.07837342f, 
    -0.07816853f, 0.13025297f, -0.14106369f, 0.04606249f, 0.12625298f, 0.05628038f, 0.01346028f, 0.01575466f, 
    -0.10048676f, 0.11662846f, -0.11676382f, -0.12092360f, -0.10429081f, 0.03992486f, 0.08679093f, -0.06897952f, 
    -0.04956200f, 0.04627176f, -0.10442723f, -0.01261151f, 0.13551669f, -0.35570660f, 0.14239909f, 0.35696009f, 
    -0.09512974f, 0.04684981f, -0.09575576f, 0.03579249f, -0.13442498f, -0.07335141f, -0.19664530f, 0.00426870f, 
    0.19873577f, -0.15468177f, 0.21066988f, -0.03483970f, -0.02644956f, -0.00695307f, 0.10770015f, 0.10822299f, 
    0.01682692f, 0.06899633f, 0.13028191f, 0.03319029f, -0.16468248f, 0.34572244f, 0.31654003f, -0.01434279f, 
    0.09825743f, 0.04314284f, -0.05947819f, -0.03916008f, 0.01207269f, 0.11750153f, 0.22069073f, -0.09465031f, 
    -0.48139715f, 0.14559342f, -0.25996667f, -0.21932968f, -0.07779524f, 0.06905971f, -0.03136771f, -0.31801435f, 
    -0.09926917f, 0.00239257f, -0.27393448f, -0.30652326f, 0.08344723f, -0.12375973f, 0.42182598f, -0.05709557f, 
    -0.12178279f, -0.01986382f, 0.21087943f, 0.18295571f, 0.03678434f, 0.12660570f, 0.20390570f, -0.00873461f, 
    0.01264101f, 0.05839181f, -0.04418675f, -0.15837003f, -0.12756012f, 0.02655790f, 0.17821808f, 0.06801998f, 
    0.05573431f, 0.14169796f, 0.05900118f, 0.09614904f, -0.11904354f, 0.24813946f, -0.02020789f, -0.03090427f, 
    -0.01983769f, 0.02012599f, 0.10499649f, -0.03760466f, -0.05438442f, 0.16955458f, 0.09527374f, 0.18487605f, 
    -0.07259518f, 0.00148443f, 0.03681427f, 0.05312622f, -0.05446175f, 0.00041531f, -0.03519751f, -0.03444266f, 
    0.00376860f, -0.16441113f, 0.09407972f, 0.07197623f, -0.23103663f, 0.12869635f, 0.31006429f, 0.11377683f, 
    0.00235149f, 0.07445101f, -0.12845057f, -0.01117906f, 0.07196688f, -0.23829380f, -0.28308555f, -0.01677664f, 
    -0.34521025f, -0.23312703f, 0.15915778f, 0.15612301f, -0.16063310f, 0.11199691f, -0.12859716f, 0.05566372f, 
    0.02259130f, -0.01250031f, 0.03913829f, -0.00987838f, -0.06515431f, -0.43931764f, -0.14618617f, 0.05510305f, 
    -0.04094233f, 0.01254944f, -0.16913836f, 0.02090691f, -0.02324849f, 0.04254932f, 0.08227603f, -0.11555681f, 
    -0.14759645f, 0.05753750f, -0.09198533f, -0.36353666f, -0.37782434f, 0.03326834f, 0.00010856f, -0.12994990f, 
    -0.00975860f, 0.10968777f, -0.10498206f, -0.05159543f, -0.23450628f, 0.20695329f, 0.13669102f, 0.11639657f, 
    -0.05125865f, 0.01947002f, -0.25499535f, 0.17297025f, -0.02384494f, 0.03182528f, -0.01542174f, -0.03592515f, 
    0.21105668f, 0.14962184f, -0.26917216f, 0.11239199f, 0.07555068f, -0.02024921f, -0.01058951f, -0.07222984f, 
    -0.05703919f, 0.08309931f, -0.08023478f, -0.03790938f, -0.10924783f, -0.27084339f, -0.07641840f, -0.15524277f, 
    -0.07336035f, -0.01524629f, 0.04597080f, -0.10470051f, 0.08056473f, 0.01063364f, 0.04263329f, -0.02820899f, 
    0.16168800f, -0.39570716f, -0.02288860f, 0.16822554f, 0.03787732f, -0.19796112f, -0.12174644f, 0.01313198f, 
    -0.05982340f, 0.08016466f, -0.06551263f, -0.11782324f, -0.00844488f, -0.03737127f, 0.18555258f, 0.18315645f, 
    -0.06837127f, 0.03316729f, 0.07620522f, 0.11071630f, 0.04776199f, 0.03216342f, 0.13364767f, 0.09167814f, 
    -0.04885053f, -0.04785721f, 0.16342683f, 0.02968917f, -0.01487583f, 0.00092404f, -0.01982072f, 0.01382622f, 
    -0.11183877f, 0.00883504f, 0.06887767f, -0.17600480f, -0.34876689f, 0.29559958f, -0.11455437f, 0.01323510f, 
    0.02248519f, 0.06804023f, -0.06545813f, 0.05958654f, 0.00057947f, -0.27720079f, -0.27110380f, -0.21312341f, 
    0.11992770f, -0.02660909f, 0.09320971f, -0.09289645f, 0.00088512f, -0.14109547f, -0.04690270f, 0.18241903f, 
    -0.02317408f, 0.08479051f, -0.16513029f, -0.28867072f, -0.37326241f, 0.21215340f, 0.00317206f, -0.09810020f, 
    -0.10971831f, -0.02436702f, 0.02545794f, 0.04427426f, -0.01231794f, 0.00430690f, 0.07309861f, 0.04992329f, 
    0.01621946f, 0.21977738f, 0.00951996f, 0.17038770f, 0.02184040f, 0.04592711f, 0.06861620f, -0.09922122f, 
    -0.05165266f, 0.03102116f, 0.12826872f, 0.19655304f, -0.02230636f, -0.02263290f, -0.03498534f, 0.15910414f, 
    0.00975518f, -0.03811719f, 0.11267304f, -0.04147397f, 0.00423631f, 0.00320207f, 0.10857844f, -0.01035338f, 
    0.06048367f, 0.08046701f, 0.08556021f, 0.12403785f, 0.05550077f, 0.13972330f, 0.01167044f, -0.01703280f, 
    -0.12116539f, 0.05188463f, -0.14302817f, -0.10866324f, -0.07408928f, 0.21017143f, 0.03142755f, 0.28899217f, 
    -0.06537677f, 0.19428974f, 0.12656495f, 0.00820169f, -0.06092028f, 0.03917952f, -0.00568077f, 0.13806023f, 
    -0.28381646f, -0.02636757f, -0.04166185f, -0.04707059f, -0.09754301f, 0.03604352f, -0.00202772f, 0.08613123f, 
    -0.04268825f, 0.05986032f, -0.01505813f, -0.04233341f, 0.08926402f, -0.10420897f, -0.08104379f, -0.03806597f, 
    -0.08760364f, 0.06063708f, -0.13392588f, -0.15831329f, 0.05237753f, -0.25990981f, 0.09648122f, 0.08538043f, 
    0.10863058f, 0.15032932f, 0.14336197f, 0.18748164f, 0.07511694f, -0.23534581f, 0.10323674f, -0.07602049f, 
    -0.15839937f, 0.06958545f, -0.13831933f, -0.07530815f, -0.37525022f, -0.20682324f, 0.08654984f, 0.06536019f, 
    -0.07039025f, 0.16498017f, -0.09480648f, -0.02559296f, 0.00347687f, 0.02829831f, 0.11874960f, -0.05323821f, 
    -0.03689860f, -0.12894137f, 0.19156188f, -0.04250100f, -0.02054259f, 0.08636368f, -0.24782754f, 0.07768854f, 
    0.04656398f, 0.02583486f, 0.01515142f, 0.06390495f, -0.19897005f, -0.30687630f, 0.13368151f, -0.03892121f, 
    -0.21109144f, -0.38492972f, 0.11947724f, -0.03387845f, -0.09519912f, 0.02700579f, 0.01620020f, -0.08391458f, 
    -0.04358643f, 0.18679728f, 0.04739812f, 0.17510745f, -0.06934317f, 0.07997005f, -0.07605232f, 0.10358034f, 
    0.01486071f, -0.23837775f, 0.14276432f, 0.00799036f, 0.61859286f, -0.42305461f, 0.31013927f, 0.12527144f, 
    -0.18493512f, 0.00618635f, 0.10252075f, 0.16146135f, -0.18528803f, 0.01536996f, -0.14119297f, 0.07726809f, 
    -0.21789192f, -0.06730557f, -0.11653180f, 0.01762129f, -0.11627175f, 0.04048518f, 0.09209953f, 0.06594232f, 
    -0.01181482f, 0.08504108f, 0.09968722f, 0.12478700f, 0.01112740f, -0.05518894f, -0.40701836f, -0.14726606f, 
    -0.17178978f, 0.10562943f, 0.12736575f, -0.00157198f, 0.00285910f, 0.06938633f, -0.15230167f, -0.15834908f, 
    0.07088769f, -0.29973170f, 0.29669484f, -0.02940723f, -0.04081548f, -0.04724892f, -0.06449404f, -0.19573048f, 
    -0.10198881f, -0.02102350f, -0.01291133f, -0.05750411f, 0.21793965f, -0.52923989f, 0.35712123f, -0.00063979f, 
    -0.14748672f, 0.01064139f, 0.12598586f, 0.00181751f, 0.05401104f, 0.02591466f, 0.18190546f, -0.02294841f, 
    -0.02286001f, 0.09578386f, 0.33398348f, -0.02049223f, -0.01968338f, -0.07784957f, 0.03174864f, 0.03527204f, 
    -0.17608997f, 0.02869529f, 0.14190556f, -0.20412169f, 0.34495080f, 0.04160318f, -0.00903448f, 0.00939753f, 
    -0.02901215f, 0.23137936f, -0.20211205f, 0.08276600f, -0.04063318f, -0.09806896f, 0.00964617f, -0.15200619f, 
    0.15731773f, -0.02393111f, 0.09270332f, -0.07457411f, 0.01734248f, -0.01517855f, -0.08208845f, 0.15306838f, 
    -0.11081766f, -0.10116882f, -0.03203484f, -0.07155640f, 0.43903527f, 0.04202017f, 0.18451913f, -0.33723086f, 
    -0.03113715f, 0.04425070f, -0.07079951f, 0.05962970f, -0.06760537f, -0.05016845f, -0.01352559f, -0.01847324f, 
    -0.28443694f, 0.36295798f, -0.06514893f, -0.00778725f, 0.03344700f, -0.02733974f, 0.01898638f, 0.10111701f, 
    -0.08170468f, 0.01333758f, 0.09590710f, 0.06749284f, -0.23308156f, -0.29941612f, 0.02633377f, -0.01698256f, 
    0.12602022f, 0.00212691f, -0.11346926f, -0.02612129f, 0.14888172f, 0.09007602f, 0.16020718f, -0.03012438f, 
    -0.22829801f, 0.28561643f, -0.10012004f, 0.01146548f, -0.03323309f, 0.02964610f, 0.03623037f, -0.10205470f, 
    -0.02136141f, 0.04232492f, 0.04120588f, 0.04708679f, 0.39038691f, 0.30695271f, -0.05444993f, -0.09390067f, 
    0.10065858f, -0.12060156f, 0.04147476f, 0.16370045f, -0.08727989f, 0.09131300f, 0.01449115f, 0.01842462f, 
    -0.06936926f, -0.07418700f, 0.09300009f, -0.18317594f, -0.00354014f, 0.10713322f, -0.09999776f, 0.04520716f, 
    -0.16975828f, 0.12833275f, 0.12840161f, 0.04233893f, -0.40330786f, 0.57212341f, 0.09342523f, -0.18026754f, 
    0.05860317f, -0.06377371f, 0.05798056f, 0.11239529f, 0.06574035f, 0.00746295f, -0.08855090f, -0.06581297f, 
    -0.49943936f, 0.04366527f, -0.44190031f, -0.24767233f, 0.09358341f, -0.11067242f, 0.01192045f, -0.07408739f, 
    -0.08512909f, -0.02729702f, -0.05984147f, 0.00664215f, 0.05308961f, 0.09271915f, -0.13329463f, -0.03128371f, 
    -0.07090665f, -0.02191951f, 0.10819905f, -0.10938971f, 0.02958703f, 0.00431674f, -0.06887135f, -0.21964024f, 
    -0.15866664f, 0.03159498f, 0.23658325f, -0.09912720f, 0.02931478f, 0.03894259f, 0.02689346f, -0.06115709f, 
    -0.14182143f, -0.08503038f, 0.06881142f, 0.14598879f, -0.12983236f, -0.15052910f, 0.04983824f, -0.14338183f, 
    -0.00599865f, 0.03118644f, -0.01235790f, 0.03179292f, -0.04356570f, 0.10209296f, 0.13342737f, -0.04221887f, 
    -0.01183957f, 0.12519796f, -0.21129520f, 0.11412728f, 0.00723609f, 0.00694260f, 0.04790252f, 0.00671657f, 
    -0.00656866f, 0.05765176f, -0.11742957f, 0.06707221f, -0.43831196f, 0.05250426f, -0.17440236f, 0.39909017f, 
    0.11841679f, -0.05755297f, 0.14600711f, 0.05593489f, -0.01113542f, -0.02699286f, -0.03441275f, 0.06648783f, 
    -0.11833499f, -0.31918585f, -0.17174153f, 0.01052407f, -0.14219281f, -0.12106688f, -0.03297814f, 0.04630166f, 
    0.03960491f, 0.15364307f, -0.02750638f, -0.05587844f, 0.26305109f, -0.13444012f, 0.25655204f, 0.01283281f, 
    -0.06732942f, -0.13155508f, 0.03208086f, 0.05860215f, -0.06624021f, 0.10538822f, -0.10005859f, 0.01441218f, 
    0.18793279f, 0.04969244f, 0.09762547f, -0.11414892f, -0.08518408f, 0.12372230f, -0.20336615f, 0.19138035f, 
    -0.00670899f, 0.00102367f, 0.01501394f, -0.25288704f, -0.43197197f, -0.15422277f, -0.16630436f, -0.30101973f, 
    0.02971954f, -0.14264175f, -0.07686333f, -0.05188995f, 0.07901458f, 0.18981531f, 0.02689261f, 0.08893597f, 
    -0.07136919f, 0.01092792f, -0.01773886f, 0.46262699f, -0.01812951f, -0.09974518f, 0.02021099f, -0.12338841f, 
    0.15166178f, -0.02210416f, 0.10422634f, 0.03063812f, 0.01983337f, 0.04151806f, 0.49002105f, -0.31284133f, 
    0.16147287f, 0.01035193f, 0.14639255f, 0.04561591f, 0.09567886f, -0.01437729f, 0.03654965f, 0.07397996f, 
    -0.65075684f, 0.05475921f, -0.32781044f, 0.27157360f, 0.01108628f, -0.14384077f, 0.02240199f, 0.31699294f, 
    -0.19849189f, -0.12277152f, -0.06651567f, -0.07841808f, 0.25588396f, -0.12889107f, 0.44143283f, 0.10598413f, 
    0.07681807f, 0.02163818f, -0.04151337f, -0.01570782f, -0.06060278f, 0.07749017f, -0.02555834f, 0.14241074f, 
    -0.30572265f, -0.04562943f, -0.25725627f, 0.27184173f, -0.04834679f, -0.02695447f, -0.06114100f, -0.03894872f, 
    -0.23899470f, 0.01018590f, 0.08768319f, 0.00849870f, -0.19234426f, -0.31501883f, 0.31710616f, -0.12832998f, 
    -0.35691127f, 0.12975895f, -0.09150542f, -0.09955718f, 0.07675864f, -0.03332764f, 0.04551669f, -0.05606569f, 
    0.10926436f, -0.51488268f, 0.33963725f, -0.00871509f, 0.08817803f, -0.03638243f, -0.06715450f, 0.06341721f, 
    0.05183054f, -0.03807295f, -0.02770189f, 0.02068245f, -0.03534594f, -0.34037790f, 0.53184998f, -0.23997696f, 
    -0.04630952f, 0.12569770f, -0.00291463f, 0.10466091f, -0.07721793f, 0.04078604f, 0.19079891f, 0.19272563f, 
    -0.20835604f, 0.20921600f, -0.07183445f, -0.10229838f, -0.09004758f, 0.10151885f, 0.03965252f, -0.06836176f, 
    -0.06206384f, -0.03785590f, 0.07030049f, 0.06415004f, -0.22891998f, -0.35348275f, -0.10751572f, 0.19666778f, 
    0.10214925f, 0.01060110f, 0.02822691f, 0.14210807f, 0.09213912f, 0.03424321f, -0.13491370f, 0.11939929f, 
    -0.07016257f, 0.18512101f, -0.45373091f, 0.27952588f, 0.03950663f, -0.01776443f, 0.09002437f, -0.07644913f, 
    0.01802828f, 0.09274068f, 0.18045111f, 0.13112025f, -0.03795534f, -0.60996473f, -0.01400778f, -0.06202745f, 
    -0.01055241f, -0.12599237f, -0.23370503f, 0.17080498f, -0.07239296f, 0.09127717f, -0.08227315f, -0.01202148f, 
    -0.05757433f, -0.07666723f, -0.04180371f, -0.08641147f, 0.03323347f, 0.06501801f, -0.20195819f, 0.08881723f, 
    -0.06166775f, -0.10210312f, -0.12134619f, -0.09779135f, -0.16887489f, 0.07703014f, -0.17987819f, -0.00507952f, 
    -0.05819268f, 0.13796663f, -0.01031005f, 0.10884411f, 0.01276946f, -0.09833967f, -0.04973673f, -0.36791864f, 
    -0.06752614f, -0.01218216f, -0.03775809f, 0.22745836f, -0.02455235f, 0.01717354f, -0.03210602f, 0.05338008f, 
    -0.05947790f, 0.05791219f, 0.00708075f, 0.05388746f, -0.16767670f, -0.08102804f, -0.00033688f, -0.21329066f, 
    0.16828635f, -0.05919660f, 0.09395321f, -0.09816272f, 0.03701347f, 0.00346757f, 0.03549588f, 0.07687480f, 
    -0.25873041f, -0.50707251f, -0.43707031f, 0.32718220f, -0.02876882f, -0.32848454f, 0.14611828f, -0.13112843f, 
    -0.00895424f, 0.07017069f, 0.10762852f, 0.04187313f, -0.00735398f, -0.05291744f, -0.08543928f, -0.03383033f, 
    -0.07873391f, 0.15465945f, 0.08115953f, -0.09535973f, -0.01134844f, 0.05418472f, 0.03565535f, -0.08348899f, 
    0.38305849f, -0.14018013f, 0.24245520f, -0.07966147f, 0.00983409f, 0.07222615f, 0.13441029f, 0.06757600f, 
    -0.13597310f, -0.00505595f, -0.03858016f, 0.07329039f, -0.46585572f, 0.00262154f, -0.07913665f, 0.05147388f, 
    -0.12293410f, 0.04794896f, 0.02058204f, 0.14704670f, -0.16549684f, 0.16777429f, -0.01668680f, -0.09796800f, 
    -0.32726780f, 0.02543786f, -0.06816992f, -0.12016810f, -0.04609962f, -0.22002734f, 0.02420777f, -0.09326414f, 
    -0.14561775f, -0.04848086f, -0.18435256f, 0.01352024f, 0.07710718f, 0.19096957f, -0.00461572f, -0.07227865f, 
    0.00326774f, 0.05781175f, -0.02112645f, -0.01179087f, -0.12842211f, 0.08333072f, -0.03316080f, 0.00351676f, 
    -0.05164703f, 0.11558643f, 0.15580261f, -0.03464993f, -0.20533054f, -0.02929886f, -0.02626944f, 0.03844687f, 
    -0.00418181f, 0.05341862f, -0.03232466f, -0.08803642f, -0.14174224f, 0.09821755f, 0.01363154f, 0.09008694f, 
    0.00198918f, -0.00686052f, -0.00625223f, -0.24636030f, -0.02447352f, -0.10831366f, -0.10364911f, -0.08979959f, 
    -0.05785970f, -0.01040896f, -0.01845954f, -0.16974843f, -0.00175943f, -0.01179591f, 0.08129603f, 0.01017999f, 
    -0.02416048f, 0.13931395f, -0.05568923f, -0.12457427f, -0.29438266f, 0.05519161f, -0.20445144f, 0.11088552f, 
    -0.01341460f, 0.11774895f, 0.04304257f, 0.14417671f, 0.00761192f, 0.22859998f, 0.16717559f, 0.22752798f, 
    -0.10710758f, -0.05638505f, -0.15690430f, -0.26175034f, -0.20785496f, -0.04156050f, -0.09916262f, -0.09373359f, 
    0.01434262f, 0.02219456f, 0.02002966f, -0.02585738f, -0.07172412f, -0.13825287f, -0.03765490f, 0.10867030f, 
    0.09656917f, 0.04635708f, 0.01685464f, -0.02299714f, -0.05701528f, -0.02226499f, 0.04325176f, -0.14335014f, 
    -0.11711708f, 0.01407317f, 0.00145916f, 0.18003193f, -0.09697952f, 0.05798773f, -0.15562092f, 0.08047917f, 
    -0.17512254f, 0.07642546f, -0.10101145f, -0.08793472f, -0.46554342f, 0.02714803f, -0.33907938f, 0.17575020f, 
    0.19774391f, 0.04882431f, 0.14678878f, -0.10819666f, -0.18406817f, -0.06936009f, -0.01994726f, 0.09734096f, 
    -0.48135707f, 0.48318389f, -0.13321018f, -0.01138791f, 0.07397886f, -0.07180271f, 0.06962838f, -0.10394074f, 
    0.09348626f, 0.02718180f, 0.07493326f, 0.13916160f, -0.06968695f, 0.25836113f, -0.00298912f, -0.04025771f, 
    -0.07239681f, -0.06642528f, 0.14338407f, -0.04661187f, -0.10433743f, -0.02366237f, -0.00066008f, -0.11478581f, 
    0.12133837f, 0.29969755f, 0.20149602f, -0.09642148f, -0.01534186f, -0.22111416f, -0.00950189f, 0.23210065f, 
    0.03136365f, 0.01825271f, 0.01180758f, 0.07712249f, -0.25666049f, 0.18043479f, -0.15610836f, 0.16191034f, 
    0.11091861f, -0.02559021f, 0.07224952f, -0.05976094f, -0.18201861f, 0.17250465f, -0.02155435f, 0.04265786f, 
    0.15312323f, -0.06053136f, -0.02076441f, 0.02414084f, -0.07073203f, 0.07600436f, 0.04193535f, -0.09181130f, 
    -0.01757300f, -0.01155090f, 0.07767746f, 0.07658586f, 0.19750743f, -0.30517444f, 0.37006825f, -0.09671041f, 
    -0.06450655f, 0.15262058f, -0.22362518f, -0.12231255f, -0.03442233f, -0.02479308f, -0.02519939f, -0.01843260f, 
    -0.07612722f, 0.11721693f, -0.05753906f, 0.05400921f, -0.05096297f, -0.09689893f, 0.04574930f, 0.17307115f, 
    -0.07388878f, 0.03093014f, -0.05680752f, -0.01922589f, 0.44279081f, 0.14454171f, 0.18131045f, 0.05994153f, 
    -0.09763576f, 0.13060462f, -0.07443737f, 0.04615504f, -0.10504586f, 0.13724491f, 0.03256178f, -0.03110473f, 
    -0.05851677f, 0.06601626f, 0.31767350f, 0.20036784f, 0.06667728f, 0.01908483f, -0.16267109f, 0.21729229f, 
    -0.25873369f, 0.16101941f, -0.01052609f, -0.12107495f, 0.06649507f, -0.22734761f, 0.40942341f, -0.63986742f, 
    0.18987997f, 0.32702565f, -0.06735411f, -0.05231284f, -0.05046954f, -0.01145622f, 0.04498922f, 0.03732763f, 
    0.00067641f, 0.00379235f, -0.00897083f, -0.18157510f, 0.00279141f, -0.13282226f, -0.18465608f, -0.14610879f, 
    0.01359500f, 0.01016802f, -0.13571985f, -0.21950287f, 0.08288357f, -0.15594789f, -0.11051055f, -0.47702059f, 
    0.09404339f, 0.08189084f, 0.05902116f, -0.04583120f, -0.01917329f, 0.03311460f, 0.08660598f, 0.05775587f, 
    0.17661260f, 0.27556288f, 0.13413538f, -0.08095883f, -0.05667698f, -0.06596749f, -0.15256742f, 0.11184566f, 
    0.02677805f, 0.02005054f, 0.03945544f, 0.02809063f, -0.38022974f, -0.36195078f, 0.12489306f, -0.15709682f, 
    -0.10391969f, -0.06569706f, -0.08577862f, 0.02852221f, -0.00415257f, 0.07080327f, -0.10129643f, 0.01983782f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14648856f, 0.10326304f, 0.05706519f, -0.09903824f, -0.05716114f, 0.09276015f, 0.03761005f, -0.10663798f, 
    0.02281654f, -0.00363254f, -0.00674969f, -0.01592846f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
