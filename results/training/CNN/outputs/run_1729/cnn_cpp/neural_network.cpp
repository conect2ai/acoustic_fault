#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.43733805f, 0.08892238f, 0.07426717f, -0.86339706f, -0.79740947f, -0.65712821f, -0.33483309f, 1.13062859f, 
    -0.64597046f, -0.81884229f, -0.16617593f, 0.51223898f, 0.37075534f, 0.50178683f, 1.00946915f, -0.04077597f, 
    -0.36318517f, 1.19603813f, -2.17459178f, 1.30818141f, -1.42656207f, 0.12779298f, 0.16740270f, -0.05163386f, 
    0.19450277f, 0.39427203f, 0.07857688f, 0.84103274f, 0.05065100f, 0.93947679f, 0.48473552f, -0.79482216f, 
    0.05874277f, 0.20047577f, 0.20619375f, 0.60848421f, -0.29714665f, -0.32724667f, -0.29524207f, -0.85850376f, 
    -1.08330679f, -1.19692564f, 0.58781189f, 0.91640276f, 0.95408088f, 0.81213403f, -0.73455155f, 0.40326333f, 
    -0.50968337f, -0.27801943f, 0.59777963f, 0.66876554f, -0.23212382f, -0.64446360f, 0.12903334f, 0.21012679f, 
    0.62606180f, 0.28382677f, 0.35976532f, 0.57104200f, -0.21450688f, -1.11489451f, -0.89392102f, 1.41299701f, 
    1.15509319f, -1.19161713f, -0.40256482f, 0.09842777f, -0.18625993f, -0.40543902f, 0.59321588f, -0.08686277f, 
    -0.93288922f, -0.03788020f, -0.57776314f, -0.77783382f, -0.55536157f, -0.45155418f, -0.50482774f, -0.85612494f, 
    -0.71168172f, 0.40652156f, 0.96668929f, 0.44752949f, -0.31845298f, 0.52700126f, 0.82882887f, -0.28678584f, 
    1.02702379f, -0.86091810f, 0.39440128f, 0.15249786f, 0.37967783f, 0.32814255f, 0.88241392f, -0.02380836f, 
    -0.00979192f, 0.62809676f, 0.94640368f, 0.81313223f, -0.01808508f, 0.34930694f, -1.43249059f, -1.00134540f, 
    -1.29324126f, 0.79544824f, -0.53436184f, -0.31105283f, -1.66372907f, -1.02615738f, -0.35113221f, -0.21452802f, 
    0.02796124f, -1.42965639f, -0.38367748f, -0.53817862f, 0.00428477f, -1.16577363f, -0.47066116f, -0.29140601f, 
    0.53956240f, -0.38431534f, 1.42284739f, -0.64149314f, -0.49948189f, -0.69758976f, 0.42638803f, 0.72570723f, 
    0.68105590f, 0.67228073f, -1.17232215f, -1.06327665f, 0.04340111f, 0.22738473f, -0.25152901f, 0.99475282f, 
    -1.14029527f, -1.25246513f, 0.19964176f, 1.55879307f, 0.92164534f, 0.11574361f, -0.15999955f, -0.27003598f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.83497983f, -0.03000223f, 0.58596855f, 0.75598872f, 0.15913282f, 0.54268682f, 0.32788408f, 0.68402582f, 
    0.61627138f, 0.20686226f, 0.94160253f, 0.11785085f, -0.43650401f, 0.62672126f, 0.32051840f, 0.65315008f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.00912867f, 0.19337633f, 0.00525974f, -0.26042068f, -0.05680355f, -0.09988269f, -0.10661665f, 0.05525917f, 
    0.05027578f, 0.35309902f, -0.11711316f, -0.53382987f, -0.10164218f, -0.02900317f, -0.10341044f, 0.02498309f, 
    0.12703045f, 0.25437975f, 1.13222098f, -0.48987103f, -0.25691611f, -0.13509564f, 0.18674286f, 0.22817530f, 
    -0.04852009f, -0.00069737f, -0.00997157f, -0.11096860f, -0.12704946f, -0.02763153f, -0.01353745f, -0.00189003f, 
    -0.08809813f, 0.06566003f, -0.07735098f, 0.00281674f, -0.17640059f, -0.57529843f, 0.09393984f, -0.23786792f, 
    -0.03967980f, -0.22658809f, -0.06621528f, -0.00147179f, 0.17529003f, -0.14649726f, -0.39259002f, -0.77035308f, 
    -0.04835345f, 0.04506056f, 0.05544862f, 0.42755547f, 0.19573483f, -0.05915365f, 0.05993892f, 0.01635522f, 
    -0.01486673f, -0.05083089f, 0.01409604f, -0.09840868f, 0.12318602f, 0.10651854f, -0.12853338f, 0.10850976f, 
    0.36679909f, 0.26414564f, 0.02475965f, -0.06470422f, 0.20838302f, -0.05541489f, 0.08217441f, 0.11571065f, 
    0.12326784f, -0.13569263f, 0.17819160f, -0.10209343f, -0.21796611f, 0.23698962f, -0.05985139f, 0.25915447f, 
    0.12161262f, -0.21379001f, 0.02769395f, 0.04763813f, -0.03887436f, -0.09540569f, -0.05034377f, -0.18020314f, 
    0.09530787f, 0.09154740f, -0.12826318f, 0.17714222f, -0.00954843f, -0.33631209f, -0.14439377f, 0.00222857f, 
    0.11785877f, 0.08236390f, 0.11866855f, -0.54717225f, -0.43937236f, 0.48065594f, -0.00706883f, 0.03527331f, 
    -0.17558609f, 0.02472858f, -0.07617144f, 0.15886383f, 0.20982558f, -0.25177005f, 0.44263861f, 0.04527024f, 
    -0.03691461f, -0.29570171f, -0.21486439f, -0.05402262f, 0.04290274f, 0.11458825f, -0.14045385f, -0.20860846f, 
    0.29791987f, 0.06517395f, 0.14563324f, -0.24476841f, 0.03875623f, -0.03070730f, -0.03223139f, -0.01790407f, 
    0.25953925f, -0.07970808f, 0.08963586f, -0.18041013f, 0.02812369f, 0.00595734f, -0.06088704f, 0.04649996f, 
    0.14014605f, -0.08050817f, 0.11630519f, -0.22833528f, 0.07191023f, 0.21161990f, 0.19597995f, 0.14972946f, 
    -0.25805345f, -0.03402006f, 0.10118414f, 0.11447217f, 0.28048050f, 0.26470077f, 0.25882643f, 0.18754467f, 
    0.07328990f, -0.17948042f, -0.31148082f, 0.11602143f, 0.16944820f, -0.39330348f, -0.03418103f, 0.07561289f, 
    -0.33988118f, 0.14491178f, -1.05380893f, 0.96167147f, 0.53053004f, 0.38223195f, -0.02737379f, -0.26538983f, 
    0.11617486f, 0.21642244f, 0.08723234f, -0.05179912f, -0.03446366f, 0.51668644f, -0.12213562f, -0.03187726f, 
    0.07114368f, 0.13077329f, -0.09966313f, 0.09323557f, -0.13179329f, 0.13866694f, -0.34802818f, -0.02329761f, 
    0.06487082f, -0.14708126f, 0.28492031f, 0.14718978f, 0.19388111f, 0.18489027f, 0.12358841f, 0.17403457f, 
    -0.05893530f, -0.05923526f, -0.00697834f, -0.37918410f, -0.01121753f, -0.26594427f, -0.17152877f, -0.15262356f, 
    -0.10157662f, -0.03073386f, -0.30818787f, 0.16253689f, -0.40175664f, -0.21096197f, -0.27456000f, 0.20437354f, 
    -0.04872839f, 0.08189164f, 0.14103320f, 0.43616727f, 0.11084121f, 0.00585673f, 0.11445237f, 0.35756454f, 
    -0.01198302f, -0.00298712f, -0.17895338f, -0.03216168f, -0.07315677f, 0.11621700f, 0.09990351f, -0.25256857f, 
    -0.18050852f, 0.06286098f, -0.20775020f, 0.04081466f, -0.25954220f, 0.13079759f, 0.07329178f, 0.02171773f, 
    0.18332714f, -0.08953868f, -0.07328457f, -0.09600832f, -0.02400519f, 0.06144202f, 0.13482815f, 0.08002873f, 
    0.32991949f, 0.30889463f, 0.32178897f, 0.30953652f, -0.12840404f, -0.59782660f, 0.24563934f, 0.02497404f, 
    0.14760797f, 0.11176722f, 0.20961745f, 0.08177412f, -0.39714828f, -0.22820450f, -0.28551212f, -0.06312551f, 
    -0.16717522f, -0.00442662f, 0.11152942f, 0.00723336f, 0.05265153f, -0.21162459f, 0.08164827f, -0.01057823f, 
    -0.25505620f, -0.00855880f, -0.06766207f, -0.38438061f, 0.06129422f, -0.19659424f, -0.01883763f, -0.03216342f, 
    0.26013100f, 0.11861043f, 0.16038656f, -0.02582146f, 0.19406413f, 0.10508811f, -0.00104808f, 0.04870177f, 
    -0.21354407f, -0.28636277f, 0.12696293f, -0.00836714f, 0.32686913f, -0.08824083f, 0.13946691f, -0.10503950f, 
    0.05085171f, 0.09067586f, 0.68186259f, 0.07065131f, -0.05824835f, -0.13040704f, -0.13302901f, 0.10419068f, 
    0.44189522f, -0.26953349f, -0.13799447f, 0.04697277f, -0.13073677f, -0.20841089f, -0.07462218f, 0.03250138f, 
    0.04238502f, 0.18089919f, -0.11276033f, 0.37404111f, 0.27872401f, -0.24805491f, 0.28575736f, 0.40381151f, 
    -0.01907321f, 0.11125466f, 0.17407094f, 0.01586474f, -0.23364255f, -0.04100700f, -0.11804667f, -0.01487487f, 
    0.05412993f, 0.20219412f, 0.10390861f, 0.07069010f, -0.50875890f, -0.45775068f, -0.21584910f, -0.16501445f, 
    0.03468524f, -0.45822677f, 0.05725767f, 0.05853554f, 0.08547530f, 0.25820088f, -0.21881209f, 0.29142532f, 
    0.10685270f, -0.34023035f, 0.15327948f, 0.14091031f, -0.13573796f, 0.51786292f, -0.01869276f, 0.02006922f, 
    -0.09150498f, -0.20882849f, -0.23925795f, -0.32188311f, 0.14147130f, -0.03591953f, 0.05348825f, 0.81488532f, 
    -0.12583116f, 0.27036855f, 0.00456858f, 0.07096912f, -0.03663959f, 0.00360937f, 0.20448947f, 0.27195367f, 
    -0.19171381f, 0.09574105f, 0.12777175f, 0.12015660f, 0.15182018f, 0.19718701f, 0.27005744f, 0.06060576f, 
    -0.11093381f, -0.49558857f, -0.30513167f, 0.09245717f, -0.27131543f, -0.37754661f, -0.02663720f, -0.05916032f, 
    0.26858535f, 0.31979582f, -0.40030754f, -0.33197749f, -0.12383705f, -0.50702310f, 0.05178006f, -0.05825684f, 
    0.23211023f, 0.16833062f, 0.08509072f, -0.51097691f, 0.03999734f, -0.43957523f, -0.19988286f, -0.29373088f, 
    0.03862949f, 0.01923977f, 0.11194696f, -0.02357500f, -0.77719784f, 0.19791016f, 0.37457550f, -0.13356881f, 
    -0.22741738f, -0.35802323f, -0.18163182f, 0.20292176f, -0.19130489f, -0.22295663f, 0.11546949f, 0.32052821f, 
    0.32615617f, 0.01340027f, 0.21769828f, -0.06271169f, 0.08218009f, -0.05517075f, -0.57892072f, -0.19917488f, 
    -0.25026214f, -0.18386054f, -0.17043993f, -0.14315613f, 0.19554375f, 0.11423122f, 0.28949353f, 0.17785402f, 
    0.51003259f, 0.04489202f, -0.10919087f, 0.22485161f, -0.31343788f, 0.19201516f, -0.10975083f, 0.04338138f, 
    -0.01767689f, -0.03654749f, -0.03615297f, 0.00838937f, -0.06007769f, 0.04244265f, -0.07634883f, 0.03797954f, 
    -0.00417633f, 0.06819843f, 0.04143215f, 0.01479919f, 0.03641871f, 0.05156742f, 0.00972234f, 0.08092485f, 
    0.06936927f, -0.06709182f, -0.08397415f, 0.05051774f, 0.04275889f, -0.05518673f, -0.01919783f, -0.08594169f, 
    -0.07076459f, 0.00360639f, -0.01583252f, -0.00997827f, 0.06410553f, -0.05879367f, -0.09154495f, 0.04074464f, 
    0.04089082f, 0.02894514f, 0.01858946f, -0.03173635f, -0.07046320f, -0.04352578f, 0.03611070f, -0.00053381f, 
    0.01466529f, -0.00995397f, -0.00301438f, -0.00412984f, 0.02847013f, -0.06248166f, 0.05934841f, -0.02935829f, 
    -0.05047069f, -0.04364013f, -0.02744572f, 0.04342116f, 0.00828359f, -0.09472067f, -0.03076257f, -0.08434092f, 
    -0.00011658f, -0.00069278f, -0.07295536f, 0.05044762f, 0.07378639f, 0.04886894f, 0.05961103f, 0.06548049f, 
    -0.06955592f, -0.06956466f, -0.09580725f, -0.07900032f, -0.06197886f, -0.04326179f, -0.03589800f, 0.01508599f, 
    0.01473008f, -0.03139760f, -0.07403095f, 0.03048486f, -0.05972660f, -0.06670438f, 0.01394316f, 0.04175836f, 
    0.01177224f, 0.00618769f, 0.05159725f, -0.08054481f, -0.06759012f, -0.08350238f, 0.05291646f, 0.06533182f, 
    -0.02804040f, -0.06319983f, 0.06823545f, 0.00119536f, -0.05140551f, -0.05325039f, -0.03380777f, -0.06544825f, 
    -0.05715310f, -0.07400524f, 0.03829552f, 0.06464669f, 0.05719825f, -0.02497036f, 0.06058277f, -0.09346141f, 
    0.02119903f, -0.03535324f, -0.00827087f, -0.03640045f, -0.00745988f, -0.07396157f, -0.09076803f, -0.00852099f, 
    0.05878302f, -0.01525010f, -0.02896705f, -0.08899178f, 0.05839582f, -0.04912995f, 0.05471188f, 0.03969596f, 
    0.01658017f, 0.03314875f, 0.05788752f, -0.03297327f, -0.07395694f, -0.05406925f, 0.06067229f, 0.05996736f, 
    -0.07461497f, 0.03690762f, 0.04467773f, -0.04851060f, 0.03286787f, -0.03652407f, 0.03587210f, -0.05174857f, 
    0.07071962f, -0.04742628f, -0.01392944f, 0.02471415f, -0.06058311f, 0.00375248f, -0.09161672f, 0.02228893f, 
    0.22748773f, -0.48428950f, 0.15981701f, 0.18529803f, 0.20033483f, 0.24409612f, 0.08291562f, 0.04582810f, 
    0.04860948f, 0.04943693f, -0.08530112f, -0.06775817f, 0.18636212f, 0.15866905f, -0.09886377f, 0.34906322f, 
    -0.19956288f, -0.20756209f, 0.40072924f, -0.12015884f, -0.31372824f, -0.04181031f, 0.06661239f, 0.03173533f, 
    0.14161128f, -0.02850164f, 0.17502873f, 0.07841673f, -0.08749442f, -0.01696957f, 0.08284179f, 0.02870045f, 
    0.06311876f, 0.21873608f, 0.27286422f, 0.29470810f, -0.06492205f, -0.09764373f, 0.26234180f, -0.09858424f, 
    0.02884176f, 0.14895420f, 0.00711451f, 0.07487822f, 0.14395352f, 0.39259380f, 0.48360959f, -0.29123065f, 
    -0.04315793f, 0.23910144f, -0.19213670f, 0.25458521f, 0.49242395f, -0.15589821f, -0.18423139f, -0.07137413f, 
    -0.19598587f, -0.26995987f, 0.05165192f, -0.19081661f, -0.15411226f, -0.04480179f, 0.00434188f, -0.33343914f, 
    -0.06682749f, 0.14438482f, 0.01241421f, -0.00856859f, 0.23653360f, 0.10807379f, 0.19187175f, 0.30387303f, 
    -0.03380042f, -0.09209447f, -0.33098659f, 0.14841795f, 0.05747761f, 0.10555373f, 0.15116197f, 0.23108958f, 
    0.15552871f, -0.04297967f, 0.14067025f, 0.00310588f, -0.19457866f, -0.12171885f, -0.06235009f, 0.06794249f, 
    -0.44610697f, 0.07488274f, -0.00504904f, 0.12238178f, 0.11072821f, 0.12479091f, -0.12390065f, 0.20809734f, 
    0.30012634f, -0.08351096f, 0.19460587f, -0.16461262f, -0.24355289f, -0.15393049f, -0.01708959f, 0.07963710f, 
    0.23674718f, -0.03965118f, 0.18230392f, -0.01976147f, -0.20665587f, -0.16263892f, -0.47000289f, 0.00866555f, 
    0.02584217f, -0.11700541f, -0.17681846f, -0.00312464f, -0.22197960f, 0.26042053f, -0.28537688f, 0.04207681f, 
    0.22035347f, 0.04200102f, -0.00368022f, 0.10129271f, 0.43530172f, -0.11375336f, -0.30746397f, -0.13970520f, 
    0.14122549f, 0.02869209f, -0.14727065f, 0.13627639f, -0.03708562f, 0.02433544f, -0.07241777f, 0.14424078f, 
    0.03637492f, 0.13100043f, 0.07014695f, 0.27193975f, 0.01262536f, -0.19665103f, -0.18843623f, 0.06088410f, 
    0.07909160f, -0.04630958f, 0.30027753f, -0.05326479f, 0.19178107f, 0.01287604f, -0.02194873f, 0.08188196f, 
    0.05779240f, -0.69074667f, -0.74126232f, -0.30068526f, 0.21000130f, 0.12803005f, -0.06014045f, 0.15804380f, 
    0.05057130f, 0.34733844f, -0.44950259f, 0.23997481f, -0.43614489f, 0.14498724f, -0.10057413f, 0.41866401f, 
    -0.08059796f, 0.11266138f, 0.00324296f, -0.27470836f, -0.65139854f, -0.56265163f, -0.25737491f, 0.19792277f, 
    0.06986503f, -0.12068544f, 0.14370014f, 0.13020349f, 0.31686759f, 0.29717961f, 0.62032217f, -0.37960452f, 
    0.00858188f, -0.09219465f, 0.14219651f, 0.00254390f, 0.35671380f, 0.17508653f, -0.33954468f, 0.01612052f, 
    0.21562099f, 0.04918655f, 0.09689216f, -0.30324963f, 0.24112941f, 0.10366035f, 0.21749452f, -0.02805300f, 
    0.17517045f, 0.17837934f, -0.19620852f, 0.02186217f, 0.23437662f, -0.04505009f, -0.10542567f, -0.13487709f, 
    -0.84909964f, -1.21851718f, 0.12765278f, -0.18221824f, 0.08173168f, 0.21896724f, 0.16515136f, -0.16430084f, 
    0.26398993f, 0.37147442f, 0.52436674f, 0.13285220f, -0.00229433f, 0.14028208f, 0.07427631f, -0.05804537f, 
    -0.25297877f, 0.07742349f, -0.72874045f, -0.54072416f, 0.21606049f, -0.15562838f, 0.14573662f, -0.09908051f, 
    -0.01041182f, -0.04096214f, -0.07370111f, -0.41257885f, -0.36171666f, 0.11803568f, 0.14491126f, 0.15463008f, 
    0.24209929f, 0.01919393f, 0.18193364f, -0.22722471f, 0.03495070f, 0.06919859f, -0.00747961f, 0.03395306f, 
    -0.07343953f, -0.08964358f, -0.01356422f, 0.12722680f, 1.14263272f, 0.32958484f, 0.25821206f, -0.09486980f, 
    -0.22381902f, 0.13610552f, 0.21476698f, -0.10372487f, -0.01423521f, -0.09425677f, 0.01489297f, 0.25932682f, 
    0.07997236f, -0.01335756f, -0.07369675f, 0.25115529f, 0.23343892f, -0.20049369f, -0.46249619f, -0.51297563f, 
    -0.77793527f, 0.00006585f, 0.01427701f, -0.03267767f, -0.07001984f, 0.10160202f, 0.06516322f, 0.78143752f, 
    -0.80365366f, -0.50710827f, -0.01243040f, -0.18656555f, 0.08165152f, 0.11340922f, 0.22641461f, -0.00097768f, 
    0.00161845f, -0.03213287f, 0.01756175f, -0.00503400f, 0.00485880f, -0.06025264f, -0.09109358f, -0.04377805f, 
    0.04525982f, 0.01298753f, 0.06224978f, -0.01460221f, -0.09981337f, -0.06509039f, -0.07190018f, -0.02416337f, 
    -0.03911182f, 0.00344112f, 0.00588013f, -0.04024851f, -0.09410400f, -0.02221009f, -0.07103010f, 0.01835468f, 
    -0.03785554f, 0.03866407f, 0.00002470f, 0.04298473f, -0.08546796f, -0.05823824f, -0.00047379f, 0.03626496f, 
    -0.05476344f, -0.04856296f, -0.02557168f, -0.03039604f, -0.04719157f, -0.08381469f, -0.09011085f, -0.07783138f, 
    -0.01396720f, -0.02598845f, -0.09004428f, 0.06216800f, -0.09041978f, 0.03507714f, -0.05798979f, -0.04528367f, 
    -0.06061300f, -0.08861181f, -0.00156487f, -0.01760956f, 0.00275701f, -0.02544604f, -0.06077303f, 0.01887724f, 
    0.05570339f, 0.04806951f, -0.04645488f, 0.05569994f, 0.01224594f, 0.06773397f, -0.00834069f, -0.02806976f, 
    -0.06279626f, 0.02733088f, 0.03231096f, 0.01434056f, 0.06196844f, 0.02483650f, 0.05157492f, 0.02111405f, 
    -0.04749832f, 0.02081252f, 0.04822699f, -0.06432338f, 0.04283815f, 0.05459850f, 0.04419945f, -0.01378478f, 
    0.00836148f, 0.02283892f, -0.00211625f, 0.02694246f, -0.03908034f, -0.06224278f, 0.02391242f, -0.05282804f, 
    -0.07341286f, 0.05300751f, -0.02214935f, -0.02214947f, -0.02025483f, -0.00911519f, -0.04756887f, -0.03631807f, 
    0.02417952f, 0.04082434f, -0.04592054f, 0.04646488f, -0.01624257f, -0.06458055f, -0.00993161f, -0.04209023f, 
    -0.08528271f, -0.04289696f, -0.03696477f, 0.03795807f, 0.02496764f, -0.08199994f, 0.02199371f, -0.08330932f, 
    0.06469140f, -0.07313101f, 0.03761056f, 0.03661854f, 0.02029986f, 0.04795420f, 0.06258487f, 0.00993172f, 
    -0.01662253f, 0.01016305f, 0.02932237f, -0.02745554f, -0.03405718f, 0.06457619f, -0.03633254f, -0.07047082f, 
    -0.06641955f, 0.03770082f, -0.05875871f, -0.03210184f, -0.04671780f, -0.04601351f, 0.04551272f, -0.03126526f, 
    -0.03651594f, -0.00997006f, -0.09707632f, 0.00604638f, 0.03582393f, 0.02011995f, -0.06776229f, 0.04349136f, 
    0.24078062f, -0.08386347f, -0.40758467f, 0.13105421f, -0.06800810f, 0.20003398f, 0.04757128f, 0.10068429f, 
    -0.10987766f, 0.30800223f, 0.02011549f, -0.30300736f, 0.05542596f, 0.10632312f, 0.20095678f, 0.07191861f, 
    0.04525206f, -0.00654820f, 1.27701235f, -0.06368860f, 0.03817519f, -0.04214118f, -0.10395844f, 0.05586832f, 
    0.02098721f, -0.04987464f, 0.06796793f, -0.31863788f, 0.08994071f, 0.03761611f, 0.08703718f, -0.05752258f, 
    -0.04216227f, 0.02899898f, 0.20694093f, 0.22721712f, -0.03659497f, -0.30474371f, -0.03495901f, 0.28019530f, 
    0.07948481f, 0.02210882f, 0.18196021f, 0.12755214f, 0.15818617f, 0.22053571f, 0.11483633f, -0.05206101f, 
    0.12647824f, -0.10170762f, 0.14951944f, -0.31083873f, 0.00678676f, -0.02309151f, -0.16159964f, -0.06601936f, 
    0.22084390f, 0.09106340f, -0.05820232f, -0.16696312f, 0.00106398f, -0.54588217f, -0.82709342f, -0.36421755f, 
    0.14789768f, 0.13890053f, 0.16986921f, -0.23850012f, 0.22249645f, -0.24579906f, -0.06020406f, 0.06079933f, 
    0.22153677f, 0.06146041f, -0.25588098f, -0.01488188f, -0.00575064f, -0.08236036f, 0.03343638f, 0.05819378f, 
    -0.33505139f, -0.10805321f, -0.08025538f, 0.39762327f, 0.15067792f, -0.25926477f, 0.04497327f, 0.05026518f, 
    -0.29765409f, -0.00202193f, -0.11744750f, 0.16338457f, 0.17084706f, -0.00044217f, -0.25468269f, -0.15683958f, 
    0.05604963f, 0.13587113f, 0.15545502f, -0.96789759f, 0.12081692f, 0.34018207f, 0.05902270f, 0.10812585f, 
    0.15384543f, 0.05913876f, 0.15154020f, 0.01863434f, 0.28616086f, -0.05033380f, 0.45845243f, -0.13656503f, 
    -0.06480481f, -0.04988733f, 0.08815180f, 0.02919652f, -0.17132410f, 0.21101762f, 0.04653405f, -0.12547468f, 
    0.22255205f, 0.05920643f, -0.20895021f, -0.20259716f, -0.24944368f, -0.21177179f, -0.42026520f, -0.11035704f, 
    0.26584312f, -0.04824591f, 0.21282376f, 0.03371856f, 0.00397172f, 0.21773349f, -0.09660865f, 0.33716458f, 
    0.04943432f, 0.11556773f, -0.14992096f, 0.04536123f, 0.00150996f, -0.20358318f, -0.11345682f, 0.08674747f, 
    -0.03381932f, 0.16509703f, 0.07433677f, 0.37899923f, 0.18132307f, 0.14036727f, 0.11166389f, -0.25720572f, 
    -0.02950530f, 0.19901006f, -0.15257134f, -0.55289119f, 0.25857508f, 0.18183360f, 0.22573896f, -0.13485771f, 
    -0.40029001f, -0.15158087f, 0.18952751f, -0.21269320f, -0.12969382f, 0.03716189f, 0.02859923f, -0.15835910f, 
    0.25166804f, -0.13316727f, 0.00396844f, 0.30224323f, 0.27532378f, 0.07299677f, 0.00453621f, -0.01230454f, 
    -0.05644263f, 0.22239649f, 0.02229493f, -0.34239787f, -0.20719077f, -0.00765183f, -0.00848590f, 0.36012170f, 
    0.07741355f, -0.06168077f, -0.18896247f, -0.51032215f, -0.46385616f, -0.18649270f, -0.00017758f, -0.21338642f, 
    0.10062699f, -0.01605164f, -0.11534495f, 0.30880719f, 0.11484747f, 0.21176110f, 0.16921932f, 0.05323952f, 
    -0.48816755f, 0.17463464f, 0.21471444f, 0.13606992f, 0.42206368f, 0.12922964f, -0.07365459f, -0.22603461f, 
    0.40286076f, -0.04314482f, 0.01096570f, -0.12987956f, 0.03759234f, 0.23428020f, 0.17810266f, -0.06262767f, 
    0.00591860f, 0.09457621f, 0.47372141f, 0.12523271f, -0.04734894f, 0.22612931f, 0.05533884f, -0.00343201f, 
    0.27099964f, 0.26175439f, 0.19632903f, -0.31088328f, -0.04726141f, 0.05629015f, 0.15307726f, -0.00289548f, 
    0.14780205f, -0.02283563f, -0.00470396f, 0.20228289f, 0.08449702f, 0.13751793f, 0.11257211f, 0.16657558f, 
    -0.20900851f, -0.09799844f, -0.62748796f, 0.00591914f, 0.63062316f, -0.14679019f, 0.35514581f, 0.16671920f, 
    -0.16329251f, 0.17881541f, 0.10631767f, -0.03976871f, -0.07817425f, -0.26427633f, 0.07859978f, -0.08222192f, 
    0.13615775f, 0.27580592f, -0.13277383f, -0.07679828f, 0.22085951f, -0.20501488f, -0.25793290f, 0.02694931f, 
    0.03398898f, 0.01476205f, 0.28807405f, 0.29497337f, 0.30529472f, 0.40233773f, 0.47315815f, 0.35509440f, 
    -0.24385805f, -0.00413425f, 0.00249805f, 0.26670709f, 0.19131975f, 0.00686789f, -0.15696777f, -0.83225763f, 
    -0.07898339f, 0.12441724f, 0.15090157f, 0.23447782f, 0.32939726f, 0.03569126f, 0.08766025f, 0.05177053f, 
    0.02611586f, 0.05888296f, 0.01440691f, -0.01981295f, -0.01463742f, -0.06433488f, -0.07148492f, 0.03135723f, 
    -0.08003437f, 0.00478126f, -0.00657475f, 0.02992428f, -0.11293411f, -0.08539738f, -0.04511647f, -0.01990589f, 
    -0.00117636f, -0.05583297f, -0.02495185f, -0.07562488f, -0.01071367f, -0.02307926f, -0.07303493f, -0.04847573f, 
    -0.11285245f, -0.10404152f, 0.03746896f, -0.09507963f, -0.01252818f, 0.04777081f, 0.03538807f, -0.06852075f, 
    0.02358888f, 0.03363711f, -0.02001490f, -0.00269757f, -0.02024418f, -0.01984304f, 0.03244537f, -0.07275665f, 
    -0.03356095f, 0.00689410f, -0.00995524f, -0.05089739f, -0.06504918f, 0.04323217f, -0.09345412f, 0.04020407f, 
    -0.01564771f, -0.06379985f, -0.06859235f, -0.06745494f, -0.01912633f, 0.01858959f, 0.02271868f, -0.05738440f, 
    0.01967854f, 0.04184422f, 0.02722462f, -0.01749614f, -0.04208277f, -0.00141792f, 0.02064363f, -0.04795903f, 
    -0.04095709f, -0.06602103f, -0.01094064f, -0.04667714f, -0.11098657f, -0.07459808f, -0.00315311f, -0.00040852f, 
    -0.02598038f, -0.01769725f, -0.02305314f, 0.02208826f, -0.07215739f, -0.07790849f, 0.01635329f, 0.07772999f, 
    -0.01595824f, -0.00908293f, -0.04556791f, -0.10926047f, 0.01015106f, 0.00134187f, -0.07182081f, -0.09110568f, 
    0.01553370f, -0.03373735f, -0.10622679f, 0.00956477f, -0.10389017f, -0.02023911f, 0.03313662f, -0.05191666f, 
    -0.06382094f, -0.06808972f, 0.03732833f, -0.09071882f, -0.04711030f, -0.06411235f, 0.00544146f, -0.10252222f, 
    0.00982655f, 0.05805246f, -0.03126009f, -0.03222740f, -0.05525179f, -0.03946155f, 0.01206075f, -0.08229522f, 
    -0.05923765f, 0.05639100f, 0.02630227f, -0.01658715f, 0.05319292f, -0.00167364f, -0.05728558f, -0.09129439f, 
    -0.01932945f, 0.05807003f, 0.04589771f, -0.04276095f, -0.04856422f, -0.03615591f, 0.05029561f, -0.08337449f, 
    0.03798470f, 0.03166867f, -0.04369350f, -0.02767851f, -0.07937595f, -0.06958807f, -0.09661207f, 0.03236125f, 
    -0.01010609f, -0.00369777f, 0.01558886f, 0.03312727f, -0.05834780f, -0.00603584f, 0.01147998f, -0.04333748f, 
    -0.43758434f, -0.14598775f, 0.44823834f, -0.08350712f, -0.09012557f, 0.00700259f, 0.14400619f, 0.16251014f, 
    0.26949093f, -0.10623843f, 0.06852029f, -0.25848985f, 0.29468805f, -0.19206259f, -0.18390314f, 0.01115212f, 
    0.15493713f, 0.07245082f, -0.25510982f, -0.82444227f, -0.81558508f, -0.07727430f, 0.10348039f, 0.15510568f, 
    0.14181869f, 0.16552870f, -0.24132758f, 0.32846671f, 0.06047418f, -0.16559541f, 0.03495073f, 0.17270051f, 
    -0.22555619f, 0.18563749f, -0.06688087f, -0.06970551f, -0.88140500f, -0.05802054f, 0.09660427f, -0.19609751f, 
    -0.01198212f, -0.39375672f, 0.27833429f, -0.04071941f, 0.00759204f, 0.04473475f, 0.04587320f, 0.86645478f, 
    -0.20529334f, -0.05704678f, 0.20055333f, -0.16027707f, 0.09239402f, 0.11459255f, -0.04152393f, -0.14044407f, 
    0.02003919f, -0.12507054f, 0.02720002f, -0.39068314f, 0.01941064f, -0.21494664f, 0.25928769f, 0.15045282f, 
    -0.19069484f, 0.55977696f, -0.02573353f, 0.07759126f, 0.32797644f, 0.14909436f, 0.06583761f, 0.11085176f, 
    -0.08041813f, -0.14278485f, -0.32769984f, -0.30086559f, -0.09502292f, 0.10382617f, 0.13767304f, -0.09413244f, 
    -0.15621315f, 0.03248936f, 0.19425112f, 0.48723409f, -0.13905261f, -0.21270213f, -0.26690966f, -0.04246765f, 
    0.16634446f, 0.07911123f, 0.18742879f, 0.18080053f, 0.00111141f, -0.10981759f, 0.02847487f, -0.01275566f, 
    0.07120921f, -0.12732767f, -0.03914077f, 0.05825593f, -0.01478652f, 0.11489493f, -0.26491341f, -0.07391546f, 
    -0.01196285f, -0.11225797f, 0.14063282f, -0.02902236f, 0.70305037f, 0.26684237f, -0.00086700f, -0.31788555f, 
    0.10363872f, -0.24818285f, 0.04845704f, -0.02659453f, 0.08717576f, -0.13405578f, 0.87031317f, -0.24007939f, 
    0.20221047f, 0.08003312f, -0.00600933f, -0.18923008f, -0.23621553f, 0.21052049f, 0.00546743f, 0.23827443f, 
    0.19416547f, 0.04210646f, -0.04926614f, -0.22924595f, 0.25335690f, 0.22913520f, 0.13619247f, -0.34550124f, 
    -0.74673676f, -0.20042887f, 0.02326160f, -0.17918774f, 0.16369143f, 0.09755914f, 0.04858159f, 0.21229604f, 
    0.27948472f, 0.93736529f, 0.48699149f, -0.08311290f, 0.14436744f, 0.00364906f, -0.05756434f, 0.17906134f, 
    -0.14822641f, -0.39514825f, 0.58189559f, -0.10814361f, -0.32798597f, -0.07818202f, -0.25210255f, -0.05550668f, 
    0.11021157f, 0.19727208f, -0.02163840f, -0.22974718f, 0.07441965f, -0.05519033f, 0.30509448f, 0.12736972f, 
    -0.00682680f, 0.07954408f, -0.06494582f, -0.45311576f, -0.44210190f, -0.34456924f, 0.08142394f, 0.19566368f, 
    0.02713576f, 0.18343455f, -0.12030584f, -0.18865226f, 0.29644865f, 0.42283979f, 0.28200671f, 0.11649607f, 
    -0.04159866f, 0.15538514f, 0.25133440f, 0.05123965f, 0.06498630f, -0.81178957f, -0.53011268f, -0.44133317f, 
    -0.12159832f, -0.00180612f, 0.29712525f, 0.22872101f, 0.16956609f, -0.19370194f, -0.30385262f, -0.22956692f, 
    -0.43924636f, 0.08331645f, 0.03176230f, -0.06884765f, 0.15370822f, -0.24536145f, 0.10227797f, -0.39009091f, 
    -0.57294852f, -0.27562284f, 0.02232776f, -0.07895348f, -0.07434069f, -0.12137420f, 0.21196334f, 0.05119376f, 
    -0.15063451f, -0.23461811f, 0.21265379f, 0.10522925f, -0.01584670f, -0.00823139f, 0.14116944f, -0.06612515f, 
    0.19077219f, -0.48510063f, 0.58038408f, 0.11078873f, 0.07208063f, 0.01383941f, 0.04828880f, 0.27814206f, 
    0.14869970f, 0.12220053f, -0.22933431f, -0.00954560f, -0.09290158f, -0.12865435f, -0.07933459f, -0.03902106f, 
    0.17568803f, -0.18385018f, 0.09575117f, 0.19477734f, -0.62192947f, 0.74777979f, 0.00397711f, 0.11858535f, 
    0.24844973f, -0.13701972f, 0.02890156f, 0.12514332f, -0.47243327f, -0.07694271f, 0.39966828f, -0.09260765f, 
    -0.36055100f, -0.33660686f, 0.19451335f, 0.01330639f, -0.03892577f, -0.54632884f, 0.49433157f, 0.18718679f, 
    -0.08926857f, -0.07545394f, -0.23843686f, 0.21548657f, -0.04921175f, -0.06778559f, -0.53837204f, -0.41129133f, 
    0.23574612f, 0.00476514f, 0.03596816f, -0.25112307f, -0.06154411f, 0.04670913f, 0.03366316f, -0.46745318f, 
    0.32183424f, 0.15089305f, -0.09013996f, -0.22366624f, 0.03747525f, 0.03692592f, 0.14502558f, 0.02203056f, 
    0.36838788f, 0.33069214f, -0.31511641f, -0.01629733f, -0.24810368f, -0.00118626f, 0.01884780f, -0.00049824f, 
    0.07915471f, 0.05365295f, 0.22398901f, 0.06119494f, -0.39760953f, -0.66639131f, -0.38932452f, -0.17782983f, 
    -0.07591964f, -0.01506508f, 0.07147191f, -0.21888748f, -0.60173362f, -0.08498228f, 0.22612029f, 0.12463093f, 
    0.05940593f, 0.08376300f, -0.06081939f, -0.34680828f, -0.06689149f, 0.21865831f, 0.20143248f, 0.15354034f, 
    0.35855743f, 0.61507994f, -0.03562123f, 0.08669934f, 0.64151996f, 0.26072630f, 0.15800342f, -0.17110963f, 
    -0.06290203f, 0.11473377f, -0.04747061f, -0.06287267f, 0.19094376f, -0.48688293f, -0.16238245f, -0.03026360f, 
    -0.09196860f, -0.08009209f, -0.08466186f, 0.26110575f, -0.26718956f, 0.03386679f, -0.01706604f, 0.06970613f, 
    0.01509466f, -0.01056815f, 0.10842500f, -0.10144929f, 0.09910725f, -0.32143596f, 0.18669747f, -0.47629356f, 
    0.31528920f, 0.32856289f, -0.12597728f, 0.01909877f, -0.00369458f, -0.11145089f, -0.16710657f, 0.45852318f, 
    0.46859181f, -0.15966485f, -0.19169258f, 0.10204226f, 0.06992362f, -0.08719048f, -0.16146538f, -0.00489037f, 
    -0.19645676f, 0.00746928f, 0.29927534f, 0.27932295f, 0.18646587f, 0.15543461f, -0.18314347f, 0.10290357f, 
    0.07110392f, 0.04717713f, 0.04492682f, 0.07889800f, 0.20904969f, 0.12296463f, -0.06310035f, -0.04947028f, 
    0.19001962f, -0.04431656f, 0.09903681f, 0.39547062f, -0.23224628f, -0.08461688f, -0.34024638f, 0.00612754f, 
    0.17717209f, 0.14732645f, -0.01044209f, 0.19345100f, 0.79093385f, -0.01544790f, -0.18507864f, 0.26635981f, 
    0.17160979f, -0.23970984f, 0.06478231f, 0.07000732f, -0.12340388f, 0.35779083f, 0.12575392f, -0.10531817f, 
    0.05883822f, -0.07950590f, -0.24609648f, 0.10284246f, -0.18561220f, -0.28897661f, -0.53510457f, 0.12902926f, 
    0.58233750f, -0.16734183f, 0.11434296f, 0.01900852f, 0.03508096f, 0.07654112f, 0.03610963f, 0.45708951f, 
    -0.30385303f, 0.28905678f, -0.24165176f, -0.57444572f, -0.50752610f, -0.01494356f, -0.17322829f, -0.12570409f, 
    0.27292845f, -0.05607451f, 0.19933769f, 0.22658041f, 0.09459347f, 0.12737885f, 0.22487020f, 0.14125930f, 
    -0.11443467f, -0.13851376f, -0.58258021f, -0.23124146f, 0.00977523f, 0.01534529f, -0.06822561f, 0.11453605f, 
    -0.31886145f, 0.06831689f, -0.55713063f, -1.30749166f, -0.82897693f, 0.09898904f, 0.33326674f, 0.01654751f, 
    0.22273751f, 0.09692628f, -0.04602852f, 0.29358312f, 0.36771742f, 0.01135090f, -0.21880010f, -0.12364678f, 
    -0.18812340f, 0.07880282f, 0.10407508f, 0.04266149f, -0.20855729f, -0.06234373f, 0.19056788f, 0.00008469f, 
    -0.10664928f, -0.18896468f, -0.07061221f, 0.09757061f, 0.09579302f, 0.64129150f, 0.25782579f, 0.08598484f, 
    -0.08835285f, 0.07995963f, 0.06765744f, 0.14992382f, 0.16663630f, 0.20887287f, 0.20770702f, 0.30691192f, 
    0.24985231f, -0.13882171f, -0.21323130f, -0.01805562f, 0.09241470f, 0.30639267f, 0.16699961f, -0.34731355f, 
    0.36388597f, -0.13368385f, 0.17553358f, 0.06797577f, 0.03843355f, -0.06246290f, 0.06723107f, 0.19377285f, 
    0.11215004f, -0.41179094f, -0.31954265f, -0.04314087f, 0.08444606f, 0.12397037f, 0.20577180f, -0.04732748f, 
    0.13466257f, 0.20973147f, 0.46257293f, 0.14690697f, 0.05727799f, -0.18314865f, -0.16478923f, -0.04029086f, 
    -0.28160349f, 0.18333787f, 0.25622746f, 0.32003662f, 0.21103881f, 0.00978812f, -0.00939942f, 0.03030598f, 
    0.21366002f, -0.18274690f, 0.03685218f, 0.00678636f, 0.39495778f, -0.05548422f, -0.33228192f, 0.20612828f, 
    -0.02382326f, -0.15728787f, -0.14410916f, -0.07251148f, 0.19422287f, -0.85073459f, -0.97730482f, -0.34197074f, 
    -0.28382441f, -0.00176165f, 0.03207015f, -0.10644573f, -0.15053862f, -0.46287099f, -0.60625535f, -0.16631311f, 
    -0.02414030f, 0.04358603f, 0.02730547f, 0.23866130f, 0.01995085f, -0.02586636f, 0.06371658f, 0.56564462f, 
    0.03444018f, -0.00245185f, -0.33350247f, -0.14124388f, 0.09691026f, -0.01399941f, 0.02938235f, -0.53994828f, 
    0.01238845f, -0.30897760f, 0.18599160f, 0.01815363f, -0.10589277f, -0.12762049f, -0.04167562f, -0.08040325f, 
    -0.03117867f, -0.01301383f, 0.11027757f, -0.31726149f, -0.27862599f, -0.28214669f, -0.05690788f, -0.03863328f, 
    0.35601887f, -0.08313348f, 0.19093013f, 0.00566112f, -0.16151786f, -0.08697978f, -0.20025147f, 0.00021130f, 
    0.00752610f, 0.05226313f, -0.48318711f, -0.19780727f, -0.08072666f, -0.04579298f, 0.02219684f, 0.20489052f, 
    0.08320959f, 0.08955980f, 0.16879189f, 0.11102722f, 0.19813778f, 0.08719449f, -0.09741231f, 0.14336412f, 
    -0.08236115f, -0.04138294f, 0.06448081f, -0.06992411f, 0.12377936f, -0.00919099f, 0.07315613f, -0.19779710f, 
    0.07767267f, -0.20064859f, 0.01227280f, -0.04727932f, -0.15179273f, -0.08299559f, 0.16983703f, 0.56459045f, 
    -0.12935142f, -0.08112749f, 0.30540937f, 0.03348761f, 0.27840969f, 0.11168946f, 0.12885208f, 0.17336468f, 
    -0.05407430f, 0.08477614f, 0.03559120f, -0.09298193f, 0.03993780f, 0.32152131f, 0.02630080f, 0.52849889f, 
    0.16484801f, 0.18478660f, 0.34403971f, -0.13616230f, -0.05519802f, 0.06086132f, 0.05323448f, 0.29801238f, 
    0.07866901f, 0.26112777f, 0.34060508f, 0.27240875f, 0.04292435f, 0.16332892f, -0.02150539f, 0.08278763f, 
    0.19884184f, 0.15859349f, -0.09481515f, 0.33811694f, 0.24374451f, 0.03772990f, -0.12930873f, 0.27201071f, 
    -0.04343513f, -0.02309014f, 0.10995357f, 0.11768586f, -0.09975697f, 0.17397824f, 0.01105074f, -0.10241115f, 
    0.03766367f, 0.26089552f, -0.01644207f, -0.15801170f, -0.32676029f, -0.04130709f, -0.14240441f, -0.33420387f, 
    -0.01557196f, -0.21743095f, -0.20583966f, -0.10384223f, -0.32317477f, 0.06821701f, 0.66320693f, 0.28037351f, 
    -0.07528906f, -0.48223633f, 0.05247550f, 0.13176571f, 0.07796001f, -0.14735627f, 0.28340486f, -0.20111479f, 
    0.12623152f, -0.06827245f, -0.13621695f, 0.05145895f, -0.07345080f, 0.16625609f, 0.12731259f, -0.00959760f, 
    0.38638756f, 0.08860828f, -0.21932538f, -0.18717192f, 0.06606616f, 0.12788205f, 0.08513790f, 0.32370576f, 
    -0.45872137f, 0.11029364f, -0.14491710f, -0.14130996f, 0.06773616f, -0.11108639f, 0.09375953f, -0.02356963f, 
    -0.62541991f, -0.70602793f, -0.17515287f, -0.01305893f, -0.10040129f, -0.03266159f, -0.20242187f, -0.04581373f, 
    -0.06274708f, -0.11218595f, 0.15192173f, -0.13338266f, -0.41239935f, -0.16980962f, -0.16351333f, 0.05885564f, 
    0.22412305f, -0.01858560f, 0.23598252f, 0.49470994f, 0.01914364f, -0.09039190f, 0.06201701f, -0.00177235f, 
    0.23087814f, -0.13194385f, 0.05282553f, 0.10043210f, 0.21819681f, 0.44429380f, 0.09845226f, -0.02818225f, 
    0.14144702f, -0.08184440f, 0.05662802f, -0.13256288f, -0.29694164f, -0.17686622f, -0.38368288f, -0.07435918f, 
    0.07608740f, -0.02581206f, 0.07227708f, -0.27136487f, -0.20442989f, 0.20029992f, 0.01116716f, -0.19782951f, 
    0.22087845f, 0.35472918f, 0.23266453f, 0.12939902f, 0.26338953f, 0.02231219f, 0.16325158f, 0.00971968f, 
    0.22884503f, 0.10994829f, 0.11237443f, -0.26456535f, 0.22953868f, 0.04126632f, 0.50226462f, 0.28588578f, 
    0.09634653f, -0.15571710f, 0.19301538f, -0.06698865f, 0.20308091f, 0.14287449f, -0.01538146f, 0.17171974f, 
    -0.09893189f, -0.43823007f, -0.83837152f, 0.08714479f, 0.13413464f, -0.07599647f, -0.19011518f, -0.03059852f, 
    0.24643943f, 0.10882877f, -0.15936610f, 0.05624118f, 0.05389564f, -0.04896457f, -0.11846064f, 0.01109916f, 
    -0.09257866f, -0.01050560f, 0.08609215f, -0.02034041f, 0.11986107f, -0.10685592f, -0.07965439f, -0.03632245f, 
    -0.13538796f, 0.15694077f, 0.11509013f, -0.73127234f, -0.55056065f, -0.10198440f, 0.24834964f, 0.24921563f, 
    -0.01867614f, 0.17177141f, -0.09303151f, -0.07085565f, 0.12599762f, 0.31051880f, 0.81261462f, 0.04025775f, 
    -0.10609692f, -0.50380927f, -0.17245378f, -0.01723005f, 0.17934886f, -0.41208044f, -0.22961229f, -0.10201087f, 
    0.14823210f, 0.10307869f, 0.00371437f, -0.08810887f, 0.30614188f, 0.27276522f, 0.06049137f, -0.55885851f, 
    0.31668061f, 0.05899910f, 0.09582792f, 0.12988494f, 0.23015073f, -0.04361390f, 0.18912305f, 0.13507879f, 
    0.10756350f, 0.09380334f, -0.15578850f, -0.20445320f, -0.02558019f, 0.10531174f, -0.20797533f, -0.10789543f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.19088796f, 0.34260550f, 0.55426085f, 0.01027554f, 0.46024010f, 0.16220950f, -0.00395381f, -0.07859802f, 
    -0.12873927f, -0.04763533f, 0.01893321f, -0.01340268f, -0.02103406f, 0.37420443f, 0.64314044f, 0.03578719f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.60714781f, -0.11616903f, -0.55911225f, 0.11318078f, -0.31799114f, 0.77923340f, -0.21914385f, -0.02918934f, 
    0.04084410f, 0.19864750f, -0.03773774f, -0.23373620f, 0.62884831f, -0.40855730f, -0.50109160f, 0.31904289f, 
    -0.78040743f, 0.03798207f, 0.18037450f, -0.05596555f, 0.30242610f, 0.45210531f, 0.08071013f, 0.16280974f, 
    -0.48597178f, -0.05837135f, -0.10371286f, -0.12252929f, -0.06234866f, 0.56035560f, 0.21107432f, 0.23245467f, 
    0.57252192f, -0.43874675f, 0.97965962f, 0.15204965f, -0.04170290f, -0.73668444f, 0.04378407f, 0.34954205f, 
    0.17821749f, -0.08373722f, -1.35257316f, -0.21478847f, -0.34318307f, -0.21929021f, 0.15419255f, 0.23722520f, 
    0.84325111f, -0.77385902f, -0.42559135f, -0.05511941f, 0.26022264f, -0.08165742f, -0.13169065f, 0.11726356f, 
    0.25735140f, -0.00880486f, -0.18713388f, 0.01702705f, 0.73107564f, -0.83404207f, 0.08007238f, -0.78461802f, 
    -0.51750082f, -0.00924651f, -0.62767255f, 0.11265046f, -0.46499676f, 0.27445596f, 0.22854485f, -0.12314077f, 
    0.15697818f, -0.03110008f, 0.23113279f, 0.86385918f, -0.16973171f, -0.13796026f, 0.21451016f, 0.34448123f, 
    -0.22172843f, 0.53500062f, 0.11859529f, 0.02775658f, -0.42053840f, 0.28151041f, -0.05293889f, 0.13338694f, 
    -0.08423380f, 0.22133677f, 0.03332741f, -0.02384172f, -0.15287903f, 0.14393649f, 0.28947470f, -0.18048525f, 
    -0.01412568f, 0.33525151f, 0.09362303f, -0.02955399f, 0.03805361f, -1.50742245f, -0.18674509f, -0.61414576f, 
    0.41249534f, -0.21251379f, -0.48514453f, -1.29554749f, -0.77053529f, -0.36772123f, 0.06596331f, 0.58315963f, 
    1.07758343f, -0.47459003f, -0.31075281f, -0.11357227f, -0.00167864f, -0.15569949f, -0.22457105f, 0.65188360f, 
    -0.12161254f, -0.06924197f, 0.37597638f, -0.24976440f, -0.14318381f, 0.49836704f, -0.32402503f, 0.25390017f, 
    0.12297085f, 0.50156456f, -0.01676100f, -0.00428446f, 0.46852279f, -0.18206215f, -0.14130428f, 0.31657863f, 
    -0.28720519f, -0.11756994f, 0.17835042f, -0.02615713f, 0.00251894f, 0.96606976f, -0.66637236f, -0.66451812f, 
    -0.40218323f, 0.09199180f, -0.59361178f, 0.12105997f, 0.22705305f, -0.41456154f, -0.22061099f, -0.91764867f, 
    0.58572096f, -0.03470363f, -0.79039496f, 0.05968885f, 0.05303863f, -0.06119008f, 0.31591693f, -0.34467283f, 
    0.24370241f, 0.52662903f, 0.60238785f, 0.18807870f, -0.18089439f, -0.74195778f, -0.01689617f, 0.19247375f, 
    -0.46962398f, -0.06145336f, 0.01854922f, 0.88572884f, 0.30400553f, -1.02821839f, -0.10457507f, -0.08608403f, 
    -0.54707044f, -0.10563548f, -0.00862146f, 0.21265167f, 0.18139200f, -0.54473764f, 0.10704830f, -0.22547552f, 
    -0.01701819f, 0.18670619f, 1.05255246f, -0.27142560f, -0.40214655f, -0.19793166f, 0.59561813f, -0.60546607f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.41483295f, 0.12894765f, 0.15259029f, 0.08366791f, -0.43543836f, 0.06295220f, -0.11984487f, -0.76430494f, 
    0.13803756f, 0.43211067f, -0.19764328f, 0.27674571f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
