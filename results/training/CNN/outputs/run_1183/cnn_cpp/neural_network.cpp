#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.38968816f, -0.24859844f, -0.36935484f, -0.27929625f, -0.11993044f, 0.06828272f, -0.33971527f, -0.29141271f, 
    -0.48499578f, -0.62893301f, 0.01416840f, 0.13382335f, -0.18809323f, -0.12624077f, -0.29523376f, -0.02731634f, 
    -0.29851624f, -0.24980074f, -0.52234912f, -0.27978301f, -0.50999892f, 0.12066767f, 0.16533472f, 0.23734109f, 
    -0.04864128f, 0.37319714f, 0.64903057f, -0.05888220f, -0.35060623f, 0.19801942f, 0.03357624f, -0.58320498f, 
    -0.20780799f, 0.52057904f, -0.40229347f, 0.06057706f, 0.19980748f, -0.36531815f, -0.03864603f, 0.10721732f, 
    -0.22660188f, 0.34884456f, 0.08560936f, -0.09176679f, 0.02372411f, -0.23183627f, 0.25674596f, 0.20464309f, 
    -0.22215518f, -0.24080676f, 0.37203771f, 0.25691065f, 0.07768596f, 0.04206001f, -0.40450957f, -0.58626050f, 
    0.07491358f, 0.25902599f, -0.00179266f, -0.08132751f, -0.26427948f, -0.48963848f, 0.59718841f, -0.27384230f, 
    -0.06867258f, -0.07026132f, 0.31640220f, 0.12039093f, 0.06699927f, -0.01075984f, 0.18910767f, -0.16039829f, 
    -0.19684675f, 0.15414032f, -0.05089719f, 0.37506941f, 0.13414314f, 0.32573822f, 0.01430661f, 0.11968582f, 
    -0.01537452f, 0.17569269f, -0.10139395f, 0.24253763f, 0.13061573f, 0.10085096f, 0.07959740f, 0.29200241f, 
    0.12451720f, -0.16749881f, 0.08549041f, -0.34488907f, 0.17973016f, 0.16524871f, -0.23622827f, -0.29377139f, 
    -0.05479458f, 0.23217125f, 0.07973540f, 0.30925378f, 0.10459895f, 0.37489724f, -0.42468101f, -0.03776161f, 
    0.20214123f, 0.11645897f, 0.33375075f, -0.10761247f, -0.09742172f, 0.22735424f, -0.30449089f, 0.11933507f, 
    0.14654537f, -0.05941942f, -0.09537349f, 0.49695906f, -0.32762760f, 0.12206951f, -0.24869829f, -0.21119018f, 
    -0.09261473f, 0.17922930f, -0.11408838f, -0.15329239f, 0.06365994f, -0.29327977f, -0.08735342f, -0.18681280f, 
    0.04603521f, -0.37851828f, -0.38031980f, 0.18003148f, -0.53190374f, -0.14202330f, -0.67098886f, 0.41159749f, 
    -0.25480336f, 0.40813762f, -0.17655142f, 0.02591609f, 0.16677965f, 0.21526608f, -0.13147332f, 0.01921118f, 
    -0.12126587f, -0.17467658f, -0.26458827f, -0.16816457f, 0.04132975f, 0.27751103f, -0.57997632f, -0.01964873f, 
    0.57510811f, 0.33622709f, 0.35629219f, -0.29670176f, -0.65911919f, -0.29759100f, -0.07613324f, 0.28285527f, 
    -0.18940102f, -0.18016864f, -0.20235060f, -0.02868872f, 0.38106647f, -0.03258157f, -0.42408749f, 0.48805228f, 
    -0.03428237f, -0.06082500f, -0.14298375f, -0.13741140f, -0.04796358f, 0.32686418f, 0.20608206f, -0.08205148f, 
    0.24352248f, 0.01102894f, -0.14939724f, -0.42155507f, -0.64121717f, -0.19450927f, -0.20617682f, -0.24341853f, 
    -0.25504744f, 0.10696676f, -0.19720881f, 0.43520248f, -0.31531787f, 0.27025971f, 0.03806351f, 0.04792127f, 
    0.11638425f, -0.00523392f, 0.13079458f, 0.07434364f, 0.21025400f, -0.06201582f, -0.14685357f, -0.07262541f, 
    -0.52929509f, 0.58076173f, 0.06493380f, -0.39184693f, -0.01304489f, -0.08631507f, 0.17946270f, 0.38179877f, 
    0.03432300f, -0.33665162f, 0.08323126f, -0.11673556f, 0.33054930f, 0.03558006f, -0.43625689f, 0.36090043f, 
    -0.10120381f, -0.18022902f, 0.08856834f, -0.03020195f, 0.15324841f, -0.04329367f, 0.25918999f, -0.14245087f, 
    0.13301221f, -0.04272505f, -0.15467696f, -0.50163430f, -0.02593582f, -0.13282478f, -0.40702894f, -0.27303028f, 
    0.13615189f, 0.22400174f, -0.16653885f, 0.47347081f, 0.13393770f, -0.01797279f, -0.35838822f, -0.04097078f, 
    0.15209827f, 0.21588458f, -0.08196893f, -0.32852569f, 0.01081180f, 0.10124285f, -0.26206937f, 0.18159275f, 
    -0.10079165f, -0.29901046f, -0.26770800f, -1.01740682f, -0.17793453f, 0.76243037f, 0.85303068f, 0.25701487f, 
    1.03979373f, -0.49650958f, -0.47988170f, -0.56648088f, -0.24124585f, -0.05052060f, 0.01906377f, -0.05862822f, 
    -0.21963425f, -0.24290052f, -0.05379875f, 0.43683171f, 0.57426161f, 0.05938032f, 0.07778606f, -0.24495739f, 
    -0.08873095f, -0.05988785f, -0.09225086f, -0.94577605f, 0.44762686f, -0.04080564f, -0.57062924f, -0.39468476f, 
    0.11099108f, 0.30289143f, -0.04013272f, -0.07861067f, 0.65196681f, -0.29925862f, -0.08605976f, -0.25413114f, 
    -0.15967837f, 0.34139210f, 0.17924064f, -0.13008627f, -0.20323405f, -0.19710931f, 0.06189953f, -0.03665561f, 
    0.18632826f, 0.25951287f, -0.20891888f, -0.11852408f, 0.94711149f, -0.28944319f, -0.13281731f, -0.28417808f, 
    0.17817891f, 0.38493550f, -0.21094717f, -0.48669732f, -0.61365098f, -0.33573893f, 0.03769462f, -0.10219067f, 
    -0.07169600f, -0.16477929f, 0.47040480f, -0.13461307f, 0.13935369f, 0.03592506f, -0.33636412f, 0.00350963f, 
    -0.40039304f, -0.40464649f, 0.02658416f, 0.23133922f, -0.41083649f, 0.49172649f, -0.43820018f, -0.53624952f, 
    -0.20961700f, -0.20751643f, 0.02180386f, 0.21492283f, 0.18393837f, 0.26347622f, 0.42938712f, -0.33898702f, 
    0.35359260f, -0.42121691f, -0.17335549f, 0.33237162f, 0.00597736f, 0.36524048f, -0.29504025f, 0.03417706f, 
    -0.05549129f, 0.17255382f, -0.11660182f, -0.30342153f, -0.09031280f, 0.29422346f, -0.41193432f, -0.21222743f, 
    0.31955695f, -0.02779734f, 0.21435960f, 0.45788524f, 0.39658570f, -0.11188373f, -0.45659879f, -0.13903497f, 
    0.47817650f, -0.31513485f, -0.22326188f, -0.12371759f, -0.11034173f, -0.15709713f, -0.05984115f, -0.31577286f, 
    0.00847083f, 0.19820566f, 0.06287659f, -0.24510932f, 0.21581371f, 0.21250859f, -0.09884705f, -0.39043579f, 
    -0.49699083f, 0.32033366f, 0.15511641f, -0.45633158f, -0.05502142f, 0.18233745f, -0.61110073f, -0.03374763f, 
    -0.36581504f, 0.02541005f, -0.34444201f, 0.14004502f, -0.06223129f, -0.27725300f, 0.23654708f, -0.17300205f, 
    -0.22772905f, -0.08307949f, 0.10529756f, -0.10835517f, -0.19342512f, -0.24176155f, -0.12132844f, -0.25452140f, 
    -0.71891719f, -0.60557562f, -0.38052881f, 0.39282435f, 0.34028274f, 0.27301234f, 0.10500389f, 0.26561928f, 
    0.61232203f, 0.43483132f, 0.09092633f, 0.08154755f, -0.34508035f, 0.06653310f, 0.12102760f, -0.19326314f, 
    0.13935581f, -0.05954631f, -0.17427625f, -0.14490013f, 0.09595498f, -0.06273632f, -0.10858427f, 0.16166097f, 
    -0.04905161f, 0.34181911f, 0.84735495f, 0.03124492f, -0.18039864f, -0.05224137f, -0.08872700f, -0.38622615f, 
    -0.26443410f, 0.15549354f, -0.48115301f, -0.15910505f, 0.22227320f, 0.00574882f, 0.23691104f, -0.23985232f, 
    -0.09820436f, -0.01993211f, -0.08153940f, 0.13443282f, 0.00849812f, 0.33709374f, -0.02077422f, -0.28743505f, 
    -0.07134987f, 0.00985542f, -0.42182556f, -0.51435381f, 0.19989653f, 0.29937297f, 0.30240822f, -0.14085235f, 
    0.15286691f, -0.32343191f, -0.05781611f, -0.01138197f, -0.08081549f, -0.20782222f, 0.21473254f, -0.30645090f, 
    0.34549883f, -0.10964084f, 0.07290296f, 0.09882239f, 0.07596805f, 0.14279200f, 0.19226162f, 0.11501568f, 
    0.01738750f, 0.08629750f, 0.33774358f, 0.39217412f, 0.17912668f, 0.28273106f, 0.17190456f, 0.27096990f, 
    0.06297112f, 0.09340147f, 0.10951868f, 0.03168683f, 0.13194330f, 0.18974741f, 0.26170141f, -0.04207282f, 
    -0.32558843f, -0.15055707f, -0.00499564f, 0.10182930f, -0.11006867f, -0.04050673f, 0.11167766f, -0.06865768f, 
    0.03276106f, 0.07318829f, 0.18758044f, -0.19286610f, 0.47447729f, 0.46874392f, 0.32182726f, 0.02396182f, 
    0.25414801f, -0.20610775f, -0.51821625f, -0.08888420f, 0.55757225f, -0.14646813f, 0.21264319f, -0.10960270f, 
    -0.06699399f, 0.07604033f, -0.05240278f, 0.17496738f, -0.06598113f, 0.14629842f, -0.24006055f, 0.09492056f, 
    0.04781758f, -0.11427841f, -0.22064908f, 0.31380433f, 0.10355887f, 0.32476404f, 0.37140325f, 0.41672152f, 
    -0.03109966f, -0.05716563f, -0.22875817f, 0.02410314f, 0.13963281f, 0.02975500f, 0.10378975f, 0.40319911f, 
    0.08417354f, -0.01199730f, -0.36893004f, 0.01497594f, -0.13544261f, 0.30511141f, -0.01367363f, 0.06827830f, 
    -0.30535725f, -0.02260572f, -0.16510111f, -0.44454956f, -0.22399071f, -0.38401264f, -0.47596011f, -0.46679354f, 
    -0.42059925f, -0.37761068f, -0.12976372f, 0.54747295f, 0.50798929f, -0.28770629f, -0.56811655f, 0.11959315f, 
    -0.30375534f, -0.20116548f, -0.03570025f, -0.05710526f, -0.28832978f, -0.05002927f, 0.09587549f, 0.09683502f, 
    -0.18513912f, 0.23738673f, 0.05298531f, -0.13023061f, -0.00313341f, -0.07276750f, -0.09441667f, -0.56111169f, 
    -0.45795009f, -0.13644616f, 0.05574733f, 0.64837790f, -0.00772733f, 0.02991186f, -0.52635133f, -0.21243198f, 
    0.42376503f, -0.12791528f, 0.00873726f, -0.07817034f, 0.47950721f, -0.38959125f, -0.14079149f, 0.16981119f, 
    -0.05967798f, -0.25570151f, 0.01267065f, 0.34190089f, 0.17959134f, 0.20394000f, 0.11804615f, 0.07693943f, 
    0.14129525f, -0.35757175f, -0.38703412f, -0.72559375f, -0.78390980f, 0.79331017f, 0.07043295f, 0.11648689f, 
    0.24560405f, 0.11991447f, 0.29126891f, 0.09171006f, -0.12443156f, -0.36909994f, 0.06838387f, -0.44055915f, 
    0.05659385f, 0.09118844f, 0.28435120f, -0.44441533f, 0.02081634f, -0.05285295f, 0.17577158f, 0.21257991f, 
    0.37781128f, -0.28712121f, 0.48552504f, 0.40942094f, -0.17786634f, 0.18334624f, -0.03567382f, -0.29286191f, 
    0.21311857f, -0.04494426f, -0.16816239f, -0.09829599f, -0.30309251f, 0.32089287f, -0.15586017f, -0.31458354f, 
    0.32138783f, -0.19103259f, 0.02290730f, -0.25901794f, 0.30665901f, -0.11219842f, 0.09632553f, 0.10181042f, 
    -0.09544774f, -0.25742239f, -0.51163799f, 0.16494592f, -0.21486039f, -0.30708116f, -0.14150941f, 0.06605476f, 
    -0.28669119f, -0.14983931f, 0.00032584f, -0.67107326f, 0.05650363f, 0.42499372f, -0.07396156f, -0.28335074f, 
    0.39126512f, -0.07711258f, 0.01511269f, -0.26770699f, -0.19321051f, -0.00361391f, 0.04455935f, 0.09225706f, 
    0.17873546f, -0.06529853f, 0.28099659f, -0.42381677f, -0.23902282f, -0.69113129f, -0.58840996f, -0.26685515f, 
    0.12304701f, 0.28425923f, 0.29650280f, -0.17050013f, 0.03206759f, -0.52290785f, -0.45609242f, -0.47400141f, 
    -0.08465450f, 0.40833759f, 0.04181058f, 0.00175020f, 0.09543733f, 0.05074857f, -0.29649344f, 0.00840482f, 
    0.09333060f, -0.16356489f, -0.22267589f, -0.39297324f, -0.29880881f, -0.29933503f, 0.07508876f, -0.29860526f, 
    -0.28331587f, 0.11804536f, -0.25103202f, -0.16319242f, -0.36054125f, -0.26378703f, -0.26528117f, -0.03457848f, 
    0.02637443f, -0.00177009f, 0.15393732f, 0.01971084f, -0.15544987f, 0.17691681f, 0.09612215f, -0.12079626f, 
    0.03884663f, 0.13927288f, -0.13412416f, 0.20804118f, 0.39175412f, -0.56598681f, 0.11987624f, 0.31657937f, 
    0.04377281f, 0.17546080f, -0.52777904f, -0.51008481f, -0.12746774f, -0.20385376f, -0.00480010f, 0.36696932f, 
    -0.12166286f, -0.14264159f, 0.18392484f, -0.24284197f, 0.09389175f, -0.46826720f, 0.15869260f, -0.28315726f, 
    -0.41054130f, -0.05893028f, -0.00442330f, -0.19975150f, -0.22752975f, -0.50914639f, 0.88141161f, -0.07629983f, 
    -0.56244737f, 0.19118075f, -0.58782756f, 0.23822646f, 0.01737661f, -0.22335425f, 0.41271207f, 0.32913017f, 
    0.26118380f, 0.21115580f, -0.22373280f, 0.15802225f, 0.19121327f, -0.13161291f, 0.00322251f, 0.24588799f, 
    -0.04779730f, -0.09482020f, -0.09292238f, 0.08631996f, 0.10141333f, 0.21357633f, -0.14266722f, -0.02844171f, 
    -0.34012315f, -0.44544438f, -0.34243923f, -0.13249785f, 0.02754926f, -0.03887911f, -0.30954331f, -0.61283028f, 
    -0.14177282f, 0.35003498f, -0.04784111f, 0.17341202f, 0.44784659f, 0.09841446f, 0.08411601f, -0.33465597f, 
    0.07030699f, -0.01095772f, -0.04435124f, -0.21962933f, -0.03991251f, 0.31304467f, 0.05947990f, 0.08359165f, 
    0.16110048f, -0.02410815f, -0.35206094f, -0.42056212f, 0.29343063f, 0.29033813f, 0.28056636f, -0.52692068f, 
    -0.44621518f, 0.18194930f, 0.15020573f, -0.20190135f, -0.40497193f, -0.30819824f, 0.24126478f, -0.16477737f, 
    0.10925175f, -0.19426204f, -0.33822215f, -0.50856322f, 0.08999340f, -0.27463242f, -0.25050244f, -0.26528648f, 
    -0.47422865f, -0.83146262f, -0.68816257f, -0.48990273f, -0.11895826f, 0.01347414f, 0.08262233f, 0.17219560f, 
    0.36881915f, 0.41524637f, 0.53203946f, 0.28196785f, 0.27925882f, 0.06331228f, 0.30287844f, 0.13152698f, 
    -0.12819797f, -0.22854343f, -0.04656541f, -0.21065158f, -0.27950644f, -0.11467469f, 0.03796859f, 0.02593077f, 
    0.04331434f, 0.07918429f, 0.53280544f, -0.34452108f, 0.01143528f, -0.74175620f, -0.95474899f, 0.26166350f, 
    -0.00475503f, 0.28959987f, 0.23202628f, -0.08266590f, 0.01321683f, 0.09060745f, 0.28627554f, -0.15490052f, 
    0.01170281f, 0.07756163f, -0.19003204f, 0.25693044f, 0.23915687f, -0.11372969f, 0.14733939f, -0.25645533f, 
    -0.15358326f, -0.23907772f, -0.28937048f, -0.57558149f, -0.14013527f, -0.09533545f, -0.19415343f, -0.07537450f, 
    -0.21931557f, -0.37758780f, -0.51866728f, -0.32008559f, 0.31760809f, 0.15180324f, -0.18987440f, 0.07204002f, 
    -0.37377700f, 0.28179029f, 0.07254988f, 0.26650792f, 0.08465394f, 0.24330586f, 0.15205908f, -0.00888960f, 
    -0.00393819f, -0.14561373f, -0.06818427f, -0.28029719f, 0.55745822f, -0.10908725f, -0.15181342f, -0.39083168f, 
    -0.62125474f, 0.39532250f, 0.36323008f, -0.03247955f, -0.18308669f, -0.30236050f, 0.07352252f, 0.48796201f, 
    -0.42616862f, 0.06154894f, -0.26331228f, -0.35675114f, 0.04925267f, -0.17507693f, 0.04097820f, -0.19503222f, 
    0.13741122f, -0.21350586f, 0.06677659f, 0.25221688f, 0.30209965f, -0.63229626f, 0.46204773f, -0.12243111f, 
    -0.34213436f, -0.22069328f, -0.28818077f, -0.02525555f, -0.08450062f, -0.12213288f, -0.20900686f, -0.04731970f, 
    -0.05676851f, 0.22094826f, -0.47321519f, -0.24329506f, 0.48032749f, -0.04143611f, -0.19900878f, -0.22660631f, 
    -0.10867254f, -0.15047742f, 0.16711777f, -0.02400160f, 0.07765859f, 0.47997370f, -0.32047951f, -0.50733948f, 
    -0.71720117f, 0.06469397f, 0.64453626f, -0.00736564f, -0.00613599f, 0.44689134f, 0.22522707f, 0.12786996f, 
    -0.35203537f, -0.49942034f, -0.23279086f, 0.18585767f, -0.27152953f, 0.32556754f, 0.28407270f, 0.03483628f, 
    0.22304691f, 0.29436633f, -0.30455872f, -0.20599428f, -0.24207658f, -0.26147270f, -0.30846217f, -0.50030267f, 
    -0.34451041f, 0.04082163f, 0.19302152f, 0.04623044f, -0.24391402f, -0.62645274f, -0.68060029f, -0.20958222f, 
    0.17883213f, 0.08790822f, 0.31023881f, 0.34389845f, -0.16413051f, 0.08576629f, -0.13401453f, -0.13466097f, 
    -0.25054157f, -0.42559820f, -0.19717623f, -0.05813492f, -0.37924352f, -0.14400426f, -0.16182609f, 0.09505539f, 
    0.10197850f, -0.27745393f, 0.00810714f, -0.10664243f, -0.55526179f, -0.41765952f, -0.22013049f, 0.81276989f, 
    -0.44087467f, 0.13893178f, 0.39115536f, 0.20781913f, -0.02711993f, -0.35765237f, -0.27149123f, 0.04947119f, 
    0.39680281f, -0.30509430f, -0.42985746f, 0.16393834f, 0.02807399f, -0.04587355f, -0.27686164f, 0.00548196f, 
    0.12118864f, 0.43758076f, 0.57333100f, 0.01383280f, -0.05558255f, -0.44876686f, -0.51563454f, -0.08107732f, 
    -0.10707171f, 0.46306247f, 0.12642433f, 0.17447504f, -0.12565070f, -0.30299044f, 0.30175143f, -0.12893297f, 
    0.07674214f, -0.16593771f, 0.03899802f, -0.25983375f, 0.22160922f, 0.14633362f, -0.04752358f, -0.11253711f, 
    -0.26276714f, 0.13309327f, 0.79008323f, 0.83193868f, 0.58124143f, -0.55363548f, -0.50554025f, 0.10654366f, 
    -0.42985898f, 0.19425614f, -0.48668116f, -0.40945783f, -0.01923968f, 0.04088969f, -0.17789429f, 0.19793686f, 
    0.12709621f, -0.23842613f, 0.04718110f, -0.17752643f, -0.13747403f, 0.27758670f, 0.09132780f, -0.07839686f, 
    -0.06349963f, -0.10250303f, -0.27782986f, 0.55662882f, -0.02534224f, 0.24180500f, -0.27247891f, -0.61732000f, 
    -0.07132906f, -0.13193665f, 0.07088538f, 0.10212324f, 0.38830113f, -0.34391317f, 0.47340304f, -0.32724294f, 
    0.03290377f, 0.25799814f, -0.15427753f, 0.33627966f, -0.36019129f, -0.00659066f, 0.09723216f, 0.08828519f, 
    -0.09288351f, 0.06031053f, -0.10830430f, 0.20439453f, -0.78852916f, 0.04206474f, -0.03781438f, -0.00760901f, 
    -0.43164295f, 0.41010433f, -0.26557654f, -0.13046490f, 0.78844512f, 0.31256244f, -0.49375942f, 0.05266694f, 
    0.24438296f, -0.05398101f, -0.28187776f, 0.21291621f, -0.17049903f, -0.05416438f, -0.76543307f, -0.16784295f, 
    0.12017312f, 0.41333857f, 0.23951544f, 0.11689173f, -0.20094711f, 0.47298589f, -0.06685782f, 0.38744605f, 
    0.30510607f, -0.06416174f, -0.36106598f, -0.19506659f, -0.19886158f, -0.35281676f, 0.10217297f, 0.20612305f, 
    -0.33241013f, 0.23538342f, 0.22641131f, 0.09462684f, -0.04772132f, 0.07324287f, -0.41256452f, -0.28496850f, 
    0.27964261f, 0.32379541f, 0.08462270f, 0.11275304f, 0.16129272f, 0.07674274f, -0.10507190f, -0.58226013f, 
    -0.05471284f, 0.61651206f, -0.14291856f, -0.05404824f, -0.17059253f, -0.06818715f, -0.22656137f, -0.01492101f, 
    -0.10449968f, -0.12753296f, -0.06934826f, -0.16581856f, 0.29193631f, -0.09807743f, 0.11451185f, -0.16167350f, 
    -0.15899907f, 0.00557301f, 0.17905416f, 0.00036535f, 0.18026704f, 0.00815365f, -0.16761678f, -0.64151740f, 
    -0.36162397f, -0.05456534f, 0.46655864f, 0.60869974f, 0.04161507f, 0.11801522f, 0.28295636f, -0.03007499f, 
    0.15486452f, 0.13690804f, 0.32244977f, -0.28977475f, 0.39136884f, -0.45756662f, 0.03008180f, 0.15251105f, 
    -0.19960570f, -0.07669446f, -0.14505073f, -0.03008685f, 0.30997998f, 0.21703660f, 0.13821554f, -0.14944936f, 
    -0.80924034f, -0.38488829f, 0.00281455f, -0.20561509f, -0.30404878f, 0.04666796f, 0.25244355f, -0.06586020f, 
    -0.06250351f, 0.22291569f, -0.23650917f, -0.08823825f, -0.37277839f, -0.38908333f, -0.35559103f, -0.11812373f, 
    0.43466395f, -0.05050208f, 0.01927309f, 0.02084277f, 0.10473927f, 0.04701775f, -0.14309977f, -0.11204207f, 
    -0.05324227f, -0.63954276f, -0.36888385f, -0.40696031f, -0.16702609f, 0.02672328f, -0.19963102f, -0.28450871f, 
    0.21874660f, 0.17517397f, 0.37827575f, -0.03585035f, 0.23283072f, -0.19687548f, 0.06340689f, -0.23442927f, 
    -0.04117524f, -0.13956885f, -0.24351503f, -0.24885672f, -0.12904319f, -0.33289617f, -0.08931612f, -0.01211806f, 
    -0.18601775f, -0.41449639f, 0.36802816f, 0.16607662f, -0.57265538f, -0.51136369f, -0.31278455f, 0.43941012f, 
    -0.27907771f, 0.36227766f, -0.43310121f, -0.25086677f, 0.31457126f, 0.32638094f, 0.47300079f, -0.05222360f, 
    -0.27142549f, -0.26925766f, -0.38831380f, -0.09261560f, -0.06126713f, -0.17950301f, 0.02953704f, 0.31832704f, 
    -0.20577109f, 0.16797847f, 0.15513578f, 0.64013839f, -0.82676619f, -0.33521107f, 0.68920255f, 0.31683391f, 
    -0.26841965f, 0.37027892f, 0.13211770f, -0.42340899f, -0.33211866f, -0.09410229f, 0.17991580f, 0.36675796f, 
    -0.13127646f, -0.11235784f, 0.18436238f, -0.21459024f, -0.33210456f, 0.21789089f, 0.15622713f, -0.31597695f, 
    0.12418326f, 0.15260519f, 0.27322158f, -0.19008519f, 0.66611040f, 0.29761481f, -0.52005786f, 0.16300295f, 
    0.40492788f, -0.29334575f, -0.41709384f, -0.17051746f, 0.26138705f, 0.12367785f, 0.18923171f, -0.08933140f, 
    0.13815048f, -0.31973439f, -0.31768951f, 0.15508978f, 0.13135259f, -0.10957701f, -0.04454311f, -0.36529756f, 
    -0.08006278f, -0.01153498f, 0.11163232f, 0.07234606f, -0.29254419f, 0.14715683f, 0.08535162f, -0.00031091f, 
    0.00793058f, -0.04123448f, -0.02908471f, 0.21654315f, 0.11333073f, 0.14946118f, -0.20107652f, 0.22944465f, 
    -0.24242146f, -0.29639956f, -0.09909303f, 0.01606935f, 0.24303368f, -0.08411193f, 0.08532381f, -0.08922658f, 
    -0.14067782f, -0.26191887f, 0.05956746f, 0.19792332f, -0.05865454f, -0.10216779f, 0.73832881f, -0.12786201f, 
    -0.14463194f, 0.15449849f, 0.03148337f, 0.49835315f, 0.13780920f, 0.09374267f, -0.04341658f, 0.25612199f, 
    -0.28130710f, 0.38518900f, -0.36791712f, -0.12711541f, -0.10083537f, 0.18877566f, -0.07047997f, 0.04343918f, 
    0.02523040f, -0.22211909f, -0.01793307f, 0.23315340f, -0.31322905f, -0.20919764f, 0.04784412f, 0.34305385f, 
    0.62348807f, -0.28005755f, -0.21997309f, 0.03005808f, -0.37697187f, -0.08197555f, 0.47920236f, 0.03647498f, 
    0.03097336f, -0.04689877f, 0.03470225f, 0.20389470f, 0.01123743f, -0.14923221f, -0.18784758f, -0.09513686f, 
    -0.12018304f, 0.07107817f, 0.10122053f, -0.15586142f, 0.04686416f, -0.32364070f, -0.33179086f, -0.29377607f, 
    -0.01413171f, 0.03428099f, -0.23192063f, 0.01366041f, -0.36042717f, -0.25311604f, -0.02329416f, -0.43388653f, 
    -0.07217769f, -0.00135488f, 0.63513249f, -0.19222844f, 0.18502074f, -0.14475843f, -0.26574051f, -0.06083081f, 
    -0.05098783f, 0.43654740f, -0.20283583f, -0.24063638f, 0.07975558f, -0.30592641f, -0.00583079f, -0.04062228f, 
    0.41224250f, 0.26160383f, -0.14706844f, -0.02165618f, -0.28382406f, 0.17742163f, 0.22199810f, 0.10023808f, 
    -0.08547385f, 0.04330352f, 0.20995688f, 0.33168560f, -0.38079920f, 0.10540026f, 0.03188473f, -0.07369659f, 
    -0.27243596f, -0.07282919f, -0.04953862f, -0.05481249f, -0.22756983f, 0.18535773f, 0.28336594f, 0.19343252f, 
    0.23498036f, 0.07793155f, -0.46770683f, 0.26756895f, 0.09984691f, 0.05465585f, 0.13019156f, -0.01756878f, 
    0.05257330f, 0.07830595f, -0.03514094f, 0.00694669f, 0.18737404f, -0.09778982f, 0.16932859f, -0.33943060f, 
    0.09702534f, -0.05227083f, 0.08959019f, -0.27047411f, -0.29292619f, 0.08193552f, 0.05837575f, -0.03646534f, 
    0.10136548f, 0.29070574f, 0.16606840f, 0.09666472f, -0.69349551f, -0.81631821f, -0.62414098f, -0.66676497f, 
    0.60849595f, 0.66087937f, 0.39391842f, 0.21886154f, 0.23475115f, 0.25521374f, 0.44005463f, 0.29329935f, 
    0.08180590f, -0.22584592f, -0.17410831f, -0.21061561f, 0.00560280f, -0.04400866f, -0.00894445f, -0.12590720f, 
    -0.09604071f, 0.21622871f, 0.30390090f, -0.12328802f, -0.07373869f, 0.37221164f, 0.04645750f, 0.10778347f, 
    -0.08691335f, -0.22304951f, -0.26845160f, -0.03125817f, 0.27013445f, 0.40840581f, -0.32527456f, 0.21915245f, 
    -0.21140529f, -0.18748726f, -0.18483813f, 0.10687843f, 0.07662278f, -0.32916984f, 0.00428592f, 0.35437807f, 
    -0.26255876f, -0.12872235f, 0.08723655f, 0.01396469f, 0.05467182f, 0.20047946f, 0.29564458f, 0.23863901f, 
    0.26307771f, 0.10824868f, 0.34846309f, 0.03492306f, 0.02439945f, 0.39944974f, 0.01867413f, -0.22174259f, 
    -0.04655281f, -0.07767033f, -0.06556691f, -0.13480161f, 0.08066358f, 0.20899738f, -0.08915743f, 0.01859199f, 
    -0.11683159f, -0.06532320f, 0.10287711f, 0.01576642f, -0.26944816f, -0.21709976f, -0.08881363f, 0.29113558f, 
    0.04163951f, 0.06313689f, 0.08257689f, 0.09177561f, 0.14019154f, -0.34330782f, 0.27793220f, 0.19711642f, 
    -0.23719205f, -0.30764878f, -0.31763688f, 0.15392257f, -0.10844614f, 0.46002838f, 0.27766135f, 0.07516013f, 
    -0.30292538f, -0.01527775f, -0.26195574f, 0.24060278f, -0.08117532f, -0.11523134f, -0.38311264f, 0.43117863f, 
    1.20436490f, -0.26394022f, -0.86161268f, 0.14890513f, 0.54298747f, -0.62895352f, 0.07848155f, -0.49367359f, 
    -0.69969314f, -0.38350159f, 0.37145811f, 0.06054260f, 0.09155753f, 0.06177621f, 0.01056299f, -0.12912133f, 
    -0.06507573f, -0.12098376f, -0.02370618f, -0.13802011f, 0.18587120f, -0.18850748f, 0.20917305f, 0.11227868f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.18045291f, 0.05141927f, -0.07344602f, -0.16910136f, 0.19847244f, -0.22369240f, -0.04925839f, -0.02670800f, 
    -0.02120029f, -0.24132597f, 0.20036094f, 0.21315673f, -0.08975925f, 0.12884291f, 0.05401050f, -0.24341007f, 
    0.00290325f, 0.20265798f, 0.05704109f, -0.31324497f, 0.19064151f, 0.07851325f, -0.20600593f, 0.00297432f, 
    0.31215632f, 0.01038017f, -0.23289199f, -0.23814531f, -0.20379306f, -0.10032754f, 0.00708153f, -0.11002664f, 
    -0.09868178f, 0.10792203f, 0.16771710f, -0.28929105f, 0.32494336f, 0.22106357f, -0.25122511f, -0.10617892f, 
    0.19128975f, 0.20203820f, 0.15870130f, 0.30965224f, -0.07260612f, 0.02577987f, 0.25164199f, 0.25275242f, 
    0.06009714f, -0.07862978f, 0.11104418f, 0.17581668f, 0.33159837f, 0.10445140f, -0.03329542f, -0.02286932f, 
    0.12266664f, -0.06693549f, 0.19775915f, 0.07864619f, 0.12826960f, -0.31658810f, -0.01599620f, 0.11405945f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01076581f, -0.01432798f, -0.00844343f, 0.03028161f, 0.00955090f, 0.02904357f, -0.01961162f, -0.02554570f, 
    0.03106786f, 0.01286580f, 0.00984503f, -0.00038984f, -0.00273151f, -0.03606941f, 0.00670611f, 0.01710142f, 
    -0.03306574f, 0.01947052f, 0.02041687f, 0.02583628f, -0.02295744f, 0.01791289f, 0.00655017f, -0.03101984f, 
    0.00156522f, -0.02785346f, -0.03478951f, -0.01758904f, 0.00157394f, 0.02096438f, -0.02237445f, -0.03177609f, 
    0.00523558f, 0.02380263f, -0.02218281f, -0.02191349f, -0.01511565f, 0.00830792f, -0.00443196f, -0.02655844f, 
    0.02769154f, 0.00882818f, 0.02649287f, 0.01323570f, -0.02844699f, 0.00116171f, 0.00217295f, -0.00492695f, 
    -0.00641197f, -0.01225637f, 0.02663605f, 0.00549790f, 0.01398268f, -0.00420802f, 0.02781886f, -0.03980200f, 
    -0.01423840f, 0.02294936f, -0.03065144f, -0.02216922f, 0.02411439f, -0.03158047f, 0.00499399f, 0.01553014f, 
    -0.01294256f, 0.02330988f, 0.02305394f, 0.02964077f, -0.00072249f, 0.02202647f, 0.02940886f, 0.00845939f, 
    -0.02555127f, -0.04101370f, -0.04112906f, -0.01676484f, 0.00955958f, -0.00302877f, -0.03598297f, -0.03455507f, 
    0.00241698f, 0.01625949f, 0.00950219f, -0.01558012f, 0.02922712f, -0.02666306f, -0.00054098f, -0.01938957f, 
    -0.00180304f, -0.01269547f, 0.01143437f, -0.04050626f, -0.00596782f, 0.00167282f, -0.02327243f, -0.03239806f, 
    -0.01321705f, -0.03689684f, -0.01316022f, 0.00411699f, 0.02298235f, -0.00051013f, -0.03214074f, 0.00470554f, 
    -0.01261268f, 0.00265760f, 0.00163060f, 0.01180831f, -0.01589063f, 0.01768720f, 0.02877422f, -0.03326180f, 
    0.01183897f, -0.01772984f, -0.01150803f, -0.03026846f, 0.01509506f, 0.02805612f, 0.03316900f, -0.01220044f, 
    -0.02491985f, 0.02609209f, 0.00167635f, -0.01688093f, 0.01369417f, -0.03080011f, -0.03232414f, 0.00887315f, 
    -0.03954303f, 0.01251382f, 0.01614999f, -0.02216788f, 0.02822071f, -0.00196811f, -0.00395332f, 0.00791166f, 
    -0.04095982f, -0.03587054f, -0.00336619f, 0.02820925f, 0.01208884f, 0.01997735f, -0.02823956f, -0.01723609f, 
    0.03099900f, -0.00867416f, -0.02845127f, 0.01658525f, -0.02961264f, -0.03387595f, 0.03082635f, -0.03268339f, 
    0.00030155f, 0.00672445f, -0.02176175f, -0.03441358f, -0.02442646f, 0.02504690f, 0.00339065f, 0.02611944f, 
    0.02002707f, 0.00111666f, -0.02470484f, -0.03586404f, 0.02538639f, -0.03693452f, 0.01890034f, -0.04045866f, 
    -0.00205606f, 0.01291015f, 0.02763254f, 0.01529131f, 0.01729071f, -0.00828136f, 0.00763806f, -0.00155042f, 
    -0.02912378f, 0.01296256f, -0.00647228f, -0.00275445f, 0.00734145f, -0.01743754f, 0.02597678f, -0.01090583f, 
    0.01016465f, 0.00956216f, 0.02578891f, -0.02029830f, -0.02610094f, -0.02689511f, -0.01998293f, -0.00818909f, 
    -0.02123222f, -0.02451599f, -0.00343150f, 0.01467337f, -0.00665802f, -0.03482363f, -0.02278508f, -0.00580557f, 
    0.01457173f, -0.00770069f, -0.00115488f, -0.03445539f, 0.02892222f, -0.03296359f, 0.02241627f, 0.02727992f, 
    -0.03100175f, -0.00353393f, 0.00439015f, -0.02643914f, -0.01204047f, -0.00838938f, 0.01626932f, -0.00324592f, 
    -0.04062141f, -0.03214365f, 0.01789630f, 0.01843558f, -0.02846499f, -0.00945321f, 0.00172208f, 0.00038544f, 
    -0.00447900f, -0.02342658f, 0.01833670f, 0.00273821f, 0.02451267f, 0.00972186f, 0.01757457f, 0.01082607f, 
    0.00647909f, 0.01272577f, -0.02321176f, -0.03721553f, -0.01945586f, 0.01405482f, -0.03069075f, -0.00497332f, 
    -0.01067334f, -0.02214538f, -0.02419192f, -0.03521235f, -0.04201498f, 0.01781660f, -0.01438371f, -0.04084375f, 
    0.02740411f, 0.01730424f, 0.02305069f, -0.03714000f, 0.01922367f, 0.00670153f, -0.03069323f, -0.02090839f, 
    -0.02513053f, -0.00809048f, 0.02830789f, -0.01045569f, -0.01877099f, -0.02342098f, -0.03423526f, 0.01755450f, 
    0.01688614f, 0.02856053f, -0.01127972f, 0.01120936f, -0.01067955f, 0.00754821f, 0.01361194f, 0.02050405f, 
    -0.03001572f, 0.01772667f, -0.03255180f, -0.01792457f, 0.01547888f, 0.00803020f, -0.01415681f, 0.00097597f, 
    -0.02217317f, -0.01990568f, 0.02999308f, -0.03037887f, -0.03793636f, 0.02257239f, -0.02548165f, 0.02973850f, 
    -0.02777513f, -0.01964046f, 0.01230319f, 0.00864226f, -0.01235996f, -0.03750751f, -0.03550097f, -0.00468068f, 
    0.00818959f, 0.02735855f, -0.01081144f, -0.04045738f, 0.00698781f, -0.02987236f, -0.03868084f, -0.01644446f, 
    -0.01722812f, 0.02435005f, -0.03211843f, 0.02331203f, -0.03314544f, -0.02135356f, -0.03459966f, -0.01412152f, 
    -0.01416055f, 0.00787486f, -0.01103096f, -0.00374179f, -0.00128853f, 0.01527758f, -0.01536860f, -0.02635823f, 
    -0.01206811f, -0.01546117f, -0.00177759f, 0.03171258f, -0.03254877f, 0.03021832f, -0.02815185f, -0.02565010f, 
    -0.02635794f, -0.01411284f, 0.00806135f, -0.02547596f, -0.02420238f, -0.01530277f, 0.01668950f, 0.01508245f, 
    0.00015592f, -0.04186003f, -0.00782293f, 0.02594190f, -0.00965359f, -0.00927584f, -0.02569110f, -0.00716706f, 
    0.01116015f, -0.00744703f, 0.01876695f, -0.01936211f, -0.02318823f, -0.01466430f, 0.03143751f, 0.03169214f, 
    0.01491438f, -0.00360313f, -0.03519031f, 0.02581885f, -0.00503660f, 0.03163197f, -0.00979580f, -0.03461808f, 
    -0.00912751f, -0.03043824f, -0.02617456f, -0.03594340f, -0.01744586f, -0.03860629f, 0.02115465f, -0.00265195f, 
    -0.02301512f, -0.00020683f, -0.03030240f, 0.00391441f, 0.00592469f, -0.00016589f, 0.02674700f, 0.02971795f, 
    0.01561011f, 0.01354406f, -0.00086842f, -0.01935026f, -0.00812582f, -0.00820336f, 0.01200168f, -0.02197114f, 
    0.03113437f, 0.01382725f, 0.00258121f, 0.00035542f, -0.02355337f, 0.00932929f, 0.03123692f, -0.01269788f, 
    -0.02853003f, -0.00696574f, 0.02794865f, -0.01010055f, -0.00716567f, 0.02940528f, -0.03269066f, 0.00521169f, 
    0.01244981f, -0.00053457f, 0.00145402f, 0.01633000f, 0.03596850f, -0.02107007f, 0.02001820f, -0.02252790f, 
    -0.02467441f, 0.03058613f, -0.04182992f, -0.03807843f, -0.00314373f, -0.02846411f, 0.00095808f, -0.02138991f, 
    -0.01698774f, 0.00149572f, -0.02783303f, -0.00713407f, -0.01135741f, 0.02692936f, -0.03729627f, -0.02022799f, 
    0.00801222f, -0.04023204f, -0.02375611f, -0.01619140f, 0.02454230f, -0.01143729f, -0.02919927f, 0.01212914f, 
    0.00296527f, 0.00012390f, 0.00206383f, 0.00068468f, -0.00398111f, -0.03652113f, 0.00611409f, 0.03402444f, 
    0.00635882f, 0.01519377f, -0.01203228f, -0.00407307f, 0.01501392f, -0.02823951f, 0.01755492f, 0.01723885f, 
    0.00137091f, 0.02213340f, 0.01924806f, 0.01648719f, -0.00297811f, -0.01496857f, 0.03148798f, -0.01931405f, 
    -0.01310640f, 0.02831266f, -0.02424110f, 0.00676512f, 0.01013428f, 0.01378949f, 0.00501354f, -0.03802736f, 
    -0.01612910f, 0.03155844f, -0.01328513f, -0.04147495f, -0.01056825f, -0.02254065f, 0.02005964f, 0.00745557f, 
    0.02335441f, -0.00454400f, -0.01967590f, 0.00368688f, -0.03364763f, 0.00620549f, -0.00614017f, -0.02857116f, 
    -0.00954870f, -0.00084961f, 0.02766377f, -0.03000600f, -0.01865238f, -0.02093548f, -0.02318283f, 0.01133812f, 
    -0.03380662f, 0.00267262f, -0.00522089f, -0.03541187f, -0.03704887f, -0.00621352f, 0.02900258f, -0.02219379f, 
    0.02912000f, -0.00178207f, -0.01561072f, -0.01830791f, 0.02965830f, -0.01157750f, -0.01708298f, -0.01364413f, 
    -0.02887350f, 0.00561681f, -0.00390908f, 0.01158699f, 0.02783582f, -0.02723486f, -0.01332381f, -0.01481613f, 
    0.02554789f, -0.00923760f, -0.02078266f, -0.00874084f, -0.02685440f, 0.01485421f, -0.00594748f, 0.00127830f, 
    -0.01672679f, -0.00822934f, 0.00169077f, 0.02410736f, 0.01267712f, 0.00890559f, -0.01484822f, 0.02633339f, 
    -0.00304763f, -0.03356339f, -0.01069887f, 0.01419864f, -0.04014740f, -0.01489213f, 0.02474780f, -0.01867092f, 
    -0.01853954f, 0.03187408f, 0.01507881f, -0.02387149f, 0.02624889f, 0.01067065f, 0.02103944f, -0.02585926f, 
    -0.03636051f, -0.02952083f, 0.00817296f, -0.02031301f, -0.03892933f, 0.00858921f, 0.01733842f, -0.03805610f, 
    -0.01177325f, -0.03141635f, -0.01400483f, -0.00845007f, -0.00485408f, -0.03901158f, 0.01119746f, -0.01855746f, 
    0.01666905f, -0.03168172f, 0.02622278f, -0.01023853f, 0.00152687f, 0.01185698f, -0.02106812f, 0.00688019f, 
    -0.04185053f, -0.01003894f, -0.00911733f, 0.00451824f, -0.03354847f, 0.01994699f, 0.00639894f, 0.01366739f, 
    0.02368569f, -0.01652439f, -0.02682146f, -0.01527761f, 0.02885584f, -0.00917960f, 0.01581402f, -0.01164398f, 
    -0.01785771f, -0.00724196f, -0.02671477f, 0.00911663f, -0.01396958f, -0.01673561f, 0.02464558f, -0.00653522f, 
    -0.02380405f, 0.03115001f, 0.02060270f, 0.01492796f, -0.00343373f, 0.01119621f, -0.00998462f, -0.01603870f, 
    -0.02365659f, -0.03183534f, 0.01973509f, 0.02857730f, -0.02808814f, -0.00641944f, 0.00927299f, -0.00646537f, 
    -0.02198447f, -0.04175079f, -0.02309470f, 0.00150156f, -0.00248362f, -0.03641409f, -0.00992155f, -0.03546367f, 
    0.00546563f, -0.03399285f, -0.00195544f, -0.02574598f, -0.01231088f, -0.00505228f, 0.01836119f, -0.03830291f, 
    0.02128110f, 0.03397889f, -0.03108898f, 0.03281594f, -0.00428197f, -0.00923310f, 0.01532539f, -0.02762778f, 
    0.01811947f, 0.00436429f, -0.01149651f, -0.00833763f, 0.00792037f, -0.02862894f, -0.02690211f, -0.01979630f, 
    -0.01023151f, -0.01900680f, 0.01616613f, -0.01136082f, -0.01033994f, -0.03022034f, 0.02055979f, 0.00787835f, 
    -0.00451644f, -0.02360107f, 0.00058938f, -0.00950657f, 0.02587710f, 0.00332568f, -0.01211447f, 0.01931903f, 
    -0.03082174f, -0.02943745f, -0.01086257f, -0.00063902f, 0.00509058f, -0.03532269f, -0.02331525f, -0.03316962f, 
    0.01611962f, -0.01791943f, -0.03459733f, -0.01774439f, -0.04050291f, -0.01092968f, -0.00566412f, -0.03715293f, 
    -0.03493089f, -0.02464666f, -0.03962738f, -0.01936223f, 0.02656071f, 0.02754050f, -0.00983686f, 0.02130163f, 
    0.01451457f, -0.01812379f, 0.02846608f, 0.00039151f, 0.01113413f, 0.00022684f, -0.03577015f, 0.00040130f, 
    -0.02847039f, 0.01493573f, -0.01757137f, 0.00647248f, 0.01932830f, -0.00454396f, 0.02054447f, -0.02214338f, 
    -0.03454087f, -0.01117056f, -0.01305262f, 0.01282636f, -0.02703596f, 0.01390034f, 0.01273889f, -0.01857996f, 
    -0.02625616f, 0.02405446f, -0.00164600f, -0.00520271f, -0.03277201f, -0.01717113f, 0.01821747f, -0.02769001f, 
    0.01363293f, 0.00760231f, 0.01031957f, -0.03073210f, 0.01266132f, -0.01016356f, -0.00682518f, -0.01159196f, 
    0.00469550f, 0.00635972f, -0.03802312f, -0.01965402f, 0.00012284f, 0.00201879f, 0.01881216f, 0.02640958f, 
    -0.03407720f, -0.00820863f, 0.01422452f, 0.01491979f, -0.00830219f, 0.02282990f, 0.03029781f, 0.00756634f, 
    0.02895117f, 0.01500515f, -0.02072320f, 0.01261731f, 0.01083837f, 0.02990137f, -0.02658125f, -0.00450938f, 
    -0.04051918f, -0.03720590f, 0.02022181f, -0.04195935f, -0.02168185f, -0.02783429f, 0.02657727f, 0.02109816f, 
    -0.02034729f, -0.02383653f, -0.03519415f, 0.00585998f, -0.01187452f, 0.02000663f, -0.02354883f, -0.03668083f, 
    -0.02379998f, -0.00096531f, 0.00609011f, 0.02305432f, -0.00619590f, 0.01370373f, 0.01916376f, -0.02626580f, 
    0.03093737f, -0.02724093f, -0.11617848f, -0.05305671f, 0.02199106f, 0.06087887f, 0.17187998f, 0.07714137f, 
    -0.09041189f, 0.02892204f, 0.00758672f, 0.23048672f, -0.38536912f, 0.06863303f, 0.22922541f, -0.11732655f, 
    0.11582221f, 0.02105554f, -0.13225536f, 0.15684670f, -0.08749221f, 0.18790315f, -0.02431446f, 0.00391224f, 
    0.06039322f, -0.15186749f, 0.13542552f, 0.35996872f, 0.13617028f, 0.09804232f, -0.16924015f, 0.02032505f, 
    -0.07640903f, -0.00696097f, 0.16226442f, -0.04218691f, -0.15224679f, -0.13006081f, -0.07434401f, -0.04174193f, 
    -0.07499175f, -0.02536414f, -0.00994399f, -0.00362603f, 0.02869825f, 0.06732348f, 0.07276478f, 0.28332248f, 
    -0.11241616f, 0.03957550f, -0.12295497f, 0.03824062f, -0.05226332f, 0.07995781f, 0.08060620f, -0.09162302f, 
    -0.02064773f, -0.20027892f, -0.07048891f, 0.15168968f, 0.20730032f, 0.01172669f, 0.08202671f, -0.09222281f, 
    0.10024235f, 0.19807853f, -0.19528438f, -0.12429667f, 0.01316123f, -0.01792504f, 0.09492311f, 0.08799681f, 
    0.36647779f, 0.30626115f, 0.40674353f, -0.10794779f, 0.16489196f, -0.12841277f, -0.21858199f, -0.06955473f, 
    0.13153748f, 0.06708917f, 0.04977616f, 0.06137542f, 0.07496823f, -0.12219941f, 0.18519691f, 0.09825868f, 
    0.11227940f, 0.07477772f, 0.09649807f, 0.34869030f, -0.10690270f, 0.07479771f, 0.06521825f, 0.06454506f, 
    0.00886135f, -0.01167896f, -0.07255999f, 0.05140907f, 0.11271801f, 0.07795297f, 0.19475916f, -0.06417854f, 
    -0.10685267f, 0.26858196f, -0.00179038f, 0.12918673f, 0.21011999f, -0.05352225f, -0.16110225f, -0.05006263f, 
    0.12863392f, 0.06622947f, -0.02010452f, 0.06549580f, -0.07845213f, 0.01330043f, -0.04269251f, -0.11036430f, 
    0.32777852f, 0.56636518f, -0.26410022f, -0.07483574f, -0.16600582f, -0.09916718f, 0.28786474f, -0.10640582f, 
    -0.05534847f, 0.01600117f, -0.00269456f, 0.00400183f, 0.06324508f, 0.01876370f, 0.06333447f, 0.09160548f, 
    0.11363356f, 0.06019982f, 0.10414428f, 0.11786247f, -0.13311458f, 0.05116887f, -0.00255859f, -0.01570711f, 
    -0.05119137f, 0.25509763f, -0.13084464f, 0.03457760f, -0.04125894f, -0.03607240f, -0.00707399f, 0.03207494f, 
    0.04888929f, 0.04590680f, 0.01813979f, -0.01507921f, -0.21033067f, -0.07642017f, 0.01530584f, 0.00043633f, 
    0.20538686f, 0.03883797f, 0.06916961f, -0.09908302f, 0.09975261f, -0.17787303f, 0.13638064f, 0.06980255f, 
    0.10856780f, 0.10370769f, -0.05838865f, -0.08486418f, -0.01212652f, -0.12682988f, -0.00571845f, 0.28767177f, 
    0.22150338f, -0.02184670f, -0.09261500f, 0.30128494f, 0.22584572f, 0.10847904f, 0.17170846f, -0.13095436f, 
    -0.01175268f, -0.06766016f, -0.05230017f, -0.02889177f, -0.04883894f, 0.01709591f, 0.07245631f, -0.12135323f, 
    -0.22052008f, -0.18023077f, -0.05977667f, -0.23987587f, 0.04231096f, 0.00048478f, 0.06725650f, 0.05437425f, 
    0.06500558f, 0.02457574f, 0.06940947f, -0.15637141f, 0.06100317f, -0.13640139f, 0.15664363f, 0.11428367f, 
    -0.02787214f, 0.18458274f, 0.04543785f, -0.08757869f, -0.09978309f, -0.00205651f, -0.02233149f, 0.01016378f, 
    -0.03245293f, 0.15810193f, 0.06794673f, -0.05662640f, 0.09086347f, 0.03456547f, 0.14330266f, -0.03299408f, 
    0.07684041f, 0.13227746f, 0.07032765f, 0.08749699f, -0.12147237f, -0.01561667f, -0.06850004f, -0.04082715f, 
    -0.04119383f, 0.02040893f, -0.03633635f, -0.02935164f, -0.06070792f, -0.05336579f, 0.10866885f, 0.01224974f, 
    -0.19738065f, 0.04565093f, 0.09863948f, -0.07259541f, 0.03429729f, -0.07788701f, -0.06153614f, 0.05080633f, 
    -0.02038150f, 0.06144876f, 0.07305013f, 0.14140743f, -0.18517824f, -0.02625829f, -0.00943692f, 0.06116975f, 
    -0.02987230f, -0.08647608f, -0.13538302f, 0.01662050f, -0.17199905f, -0.26250580f, -0.16463211f, -0.28273857f, 
    0.28913209f, 0.31807715f, -0.17000075f, -0.04808738f, 0.15254726f, 0.06325808f, 0.06601075f, -0.01193698f, 
    -0.05195104f, -0.00409947f, -0.02317927f, -0.11557918f, 0.04495812f, 0.26403108f, -0.02042324f, -0.14061037f, 
    0.13248259f, -0.06542253f, 0.22836269f, 0.08200582f, 0.09064050f, 0.17618018f, 0.09514143f, 0.17003392f, 
    -0.05857315f, -0.17034948f, -0.18342791f, 0.21205892f, 0.11407002f, 0.29163706f, -0.05510149f, -0.00084518f, 
    0.10316484f, 0.02023774f, 0.14369249f, 0.04304932f, -0.12093645f, -0.09681001f, 0.08590052f, 0.02146647f, 
    0.00250312f, -0.18900925f, 0.12011883f, -0.03926105f, -0.01679233f, -0.00246626f, -0.09944987f, 0.03289627f, 
    0.19844872f, 0.08242676f, 0.14210150f, 0.15828671f, 0.03977848f, 0.21623932f, 0.00251574f, 0.06709925f, 
    0.00964839f, 0.11154584f, 0.01768481f, 0.01926625f, 0.25183019f, 0.34948733f, 0.00648516f, -0.04464884f, 
    0.03737646f, -0.16070862f, 0.02389253f, 0.08268389f, -0.01064959f, 0.00312278f, -0.09582978f, -0.05726386f, 
    0.24991293f, 0.15793532f, 0.11273512f, 0.09512549f, 0.28424999f, 0.11815503f, 0.00987130f, 0.06328432f, 
    0.06823325f, 0.01203224f, -0.00691958f, 0.07438984f, 0.05447250f, 0.16013050f, 0.14322607f, -0.08515811f, 
    0.02603453f, -0.07217593f, -0.01372890f, 0.05926284f, 0.01815401f, 0.07835051f, -0.11458534f, -0.06124607f, 
    -0.28756219f, -0.13603912f, -0.11701259f, 0.01252029f, -0.04756770f, 0.04665859f, -0.01441125f, 0.09746040f, 
    0.11565639f, 0.14922310f, 0.07449020f, -0.06792391f, 0.08856104f, 0.08546664f, -0.16900590f, 0.05875198f, 
    0.25005093f, 0.15599628f, 0.07058175f, -0.03732328f, 0.16936873f, -0.02018548f, 0.02700855f, -0.00210863f, 
    -0.04530556f, 0.31006125f, 0.01303100f, -0.08648737f, -0.07541528f, 0.03376177f, 0.06943585f, -0.08191014f, 
    0.07317930f, -0.02250637f, -0.30217403f, -0.34507766f, -0.11575425f, -0.09018732f, -0.26039091f, -0.21360825f, 
    0.10287098f, 0.09975569f, 0.07374533f, 0.09954115f, 0.06781123f, -0.01458421f, -0.08713216f, -0.22396712f, 
    0.07413660f, -0.28884274f, -0.15169886f, 0.24851544f, 0.20112230f, 0.07660709f, -0.03020496f, 0.27861515f, 
    0.02353694f, -0.16278352f, -0.00946253f, -0.17612609f, 0.14706096f, 0.31286180f, 0.24831744f, -0.20656025f, 
    0.19723597f, -0.08680204f, 0.18254779f, 0.25800037f, -0.08407500f, -0.02517434f, 0.00710993f, -0.11603954f, 
    -0.11762833f, 0.02026488f, 0.02157003f, 0.17964743f, -0.09017000f, 0.07361054f, 0.05429967f, 0.02204796f, 
    0.24466617f, -0.09576741f, 0.12597023f, 0.16088705f, 0.26792678f, 0.01045040f, 0.07859443f, 0.04049281f, 
    0.09808066f, 0.22564080f, 0.10185794f, -0.02098517f, -0.00088002f, -0.02664620f, 0.08832007f, 0.15353052f, 
    0.21784429f, 0.13664865f, -0.03119342f, -0.06918273f, -0.11095984f, 0.03776462f, 0.09537384f, -0.12290835f, 
    -0.02454459f, -0.10932552f, -0.18997088f, -0.21252622f, 0.22632965f, 0.19845302f, 0.00816562f, -0.20381853f, 
    0.05456476f, -0.02187963f, 0.08586135f, 0.12171263f, 0.09288638f, -0.01642554f, -0.05455068f, 0.04426929f, 
    0.15739308f, -0.17758954f, -0.04375647f, 0.15358946f, 0.12222377f, 0.11376588f, -0.16564721f, 0.05240203f, 
    -0.04068900f, 0.00637880f, 0.04321024f, 0.10905426f, -0.18154323f, -0.01553517f, 0.15564223f, 0.03092610f, 
    0.08646572f, 0.05941936f, -0.01723364f, -0.00219965f, -0.05453895f, 0.02274908f, 0.09520696f, 0.03479095f, 
    -0.30211729f, -0.32070184f, 0.19696902f, 0.25185061f, 0.16027676f, 0.01318518f, -0.07194611f, -0.06075619f, 
    -0.03820059f, -0.04885247f, 0.00176738f, -0.05077761f, -0.24916402f, -0.02610465f, 0.05643101f, 0.31887242f, 
    -0.07083878f, 0.06996289f, -0.03726356f, -0.01256180f, 0.06717696f, 0.05727625f, 0.21151716f, 0.17873420f, 
    0.07458822f, -0.08115402f, 0.13875732f, 0.02616354f, 0.12951955f, 0.01387224f, -0.00788868f, -0.08102611f, 
    -0.04409583f, 0.32047611f, 0.07642833f, 0.28004187f, -0.24460718f, 0.04642490f, 0.05189918f, 0.00254664f, 
    0.07261321f, -0.06312161f, 0.11701624f, 0.00611294f, -0.00040846f, 0.14627208f, 0.04075896f, 0.16175687f, 
    0.10892189f, 0.19917867f, 0.09240577f, -0.01052853f, 0.11806041f, 0.23323208f, 0.12769318f, 0.20950899f, 
    0.09914418f, 0.14430028f, 0.02210911f, 0.10447479f, -0.08980580f, 0.16068628f, -0.10096893f, -0.30713347f, 
    -0.06869867f, -0.11098071f, 0.11539149f, -0.07170625f, 0.09057178f, 0.15660481f, 0.17329210f, 0.21208963f, 
    0.22085015f, 0.18110782f, 0.02848378f, -0.11982499f, 0.07137641f, 0.01592413f, 0.06451213f, 0.11158642f, 
    -0.10832324f, -0.00579605f, 0.05899958f, 0.04207927f, -0.08136818f, -0.06771020f, -0.08756763f, -0.21966000f, 
    0.16128618f, 0.02434225f, 0.10537791f, 0.07031156f, -0.00611004f, -0.05963871f, -0.07338364f, -0.16486515f, 
    0.12961003f, -0.20703855f, -0.19317620f, 0.23298325f, 0.05675278f, 0.19494821f, 0.02418447f, -0.12315084f, 
    -0.09330315f, 0.00349400f, 0.13312213f, -0.10668886f, -0.01916055f, 0.20986183f, -0.14195018f, 0.28430393f, 
    -0.01170992f, 0.12326073f, 0.13168105f, -0.21073715f, 0.03480677f, 0.06159703f, 0.00778199f, 0.01724626f, 
    0.00212800f, 0.20391451f, 0.09393472f, 0.22051029f, 0.01407941f, 0.03639852f, -0.02201238f, -0.01305315f, 
    -0.06042698f, -0.05604529f, -0.03302379f, 0.17295700f, 0.16038950f, 0.05066146f, -0.05130671f, 0.12889802f, 
    -0.05445617f, -0.00541805f, -0.07240373f, 0.01026469f, -0.00637786f, -0.02937311f, -0.06595266f, 0.22804622f, 
    -0.42431927f, 0.05247164f, -0.07274847f, 0.04848767f, -0.10458405f, -0.04450620f, -0.05761500f, -0.06945724f, 
    -0.04119056f, -0.00675790f, -0.05270839f, 0.03890897f, 0.04707722f, -0.18552774f, 0.03669180f, 0.06366363f, 
    -0.01822204f, 0.03656298f, -0.10650442f, -0.04989985f, -0.16681710f, -0.11214262f, -0.17786962f, -0.29204729f, 
    0.10421547f, 0.06925089f, 0.02821368f, 0.15691493f, 0.12945506f, 0.13651487f, 0.07091032f, -0.00832321f, 
    -0.00652340f, 0.01420511f, 0.18038100f, 0.19699153f, -0.15483922f, 0.00985050f, -0.12396264f, 0.04131247f, 
    -0.12225061f, 0.12199596f, -0.00509501f, -0.04390564f, 0.04436551f, 0.04559613f, 0.15648302f, 0.31233847f, 
    -0.01076040f, -0.02303272f, 0.07635438f, -0.07899270f, 0.02129875f, -0.03916321f, 0.06024689f, -0.00991469f, 
    0.07041880f, 0.10352226f, 0.19139069f, 0.15783319f, -0.13740382f, -0.36090672f, -0.33635274f, 0.12167242f, 
    0.10178976f, 0.33197930f, 0.08449656f, 0.06590334f, 0.20756121f, 0.12130027f, 0.01896883f, -0.12206539f, 
    -0.02249430f, 0.18476678f, 0.16229363f, -0.02131659f, -0.02189680f, -0.08672672f, -0.07223517f, -0.03030555f, 
    0.09151991f, -0.06499008f, 0.01585547f, -0.03610322f, -0.24199943f, -0.11666689f, -0.05581677f, -0.00592306f, 
    -0.00598292f, -0.08910399f, -0.04878624f, -0.12808353f, -0.11878238f, 0.05864351f, 0.00001177f, -0.07855830f, 
    -0.30569062f, -0.04463755f, 0.19800061f, 0.02866357f, -0.04841515f, -0.02607774f, -0.07548800f, -0.07320176f, 
    -0.19749866f, -0.06673916f, -0.14539100f, -0.08310828f, 0.00184894f, -0.26802072f, 0.21134150f, 0.20525074f, 
    0.08351137f, 0.17112792f, 0.12411782f, 0.08781666f, -0.08072449f, -0.04600224f, 0.08374345f, 0.12387019f, 
    -0.03270907f, 0.01029001f, -0.00001866f, 0.01138954f, -0.03085601f, 0.03393240f, -0.01706148f, -0.03330430f, 
    -0.01604477f, 0.00580620f, -0.00546310f, -0.02586818f, -0.03234696f, -0.02456103f, 0.00160248f, -0.02245205f, 
    0.02265405f, 0.02487627f, 0.02086451f, -0.00222736f, 0.02120368f, -0.00732148f, -0.03326958f, 0.00002110f, 
    0.01803060f, 0.00255202f, -0.03277085f, -0.03416767f, -0.02426216f, -0.03974349f, 0.02867865f, -0.02464750f, 
    0.02213201f, -0.00045505f, -0.03257847f, 0.01101006f, 0.00604129f, -0.00391123f, 0.02221832f, -0.01816389f, 
    0.01190016f, -0.02990879f, -0.03933113f, 0.01147512f, 0.01630544f, -0.03225680f, -0.03093527f, 0.02364118f, 
    0.01514763f, -0.04123016f, 0.01052028f, -0.03746865f, -0.03342474f, 0.00115634f, 0.01070151f, -0.02493586f, 
    0.00360926f, 0.01803774f, -0.03780666f, -0.03311190f, 0.00907716f, 0.00661316f, 0.02287018f, 0.02000034f, 
    -0.03271456f, 0.00168795f, -0.00812231f, -0.00167611f, -0.00564357f, -0.01444916f, -0.02566401f, -0.03070482f, 
    -0.02054560f, -0.02027120f, -0.00638994f, 0.00083707f, -0.01533205f, 0.01211905f, -0.02422233f, -0.01245694f, 
    -0.02500230f, -0.02043160f, -0.03138377f, -0.00503408f, -0.03140176f, -0.03775455f, 0.01695264f, 0.01756812f, 
    0.01774393f, -0.03699100f, -0.00117781f, 0.02652059f, 0.01596943f, 0.02369649f, 0.02940609f, -0.03574749f, 
    -0.01127421f, 0.02103125f, 0.00357789f, 0.02354049f, -0.04149578f, 0.00963170f, -0.00277995f, 0.01129148f, 
    -0.00082309f, -0.03513217f, 0.01723441f, 0.01832347f, -0.02236418f, 0.00962950f, -0.02251570f, 0.02604885f, 
    -0.02438278f, 0.00862130f, 0.00318917f, -0.01856969f, -0.03599561f, 0.01909180f, -0.01274046f, 0.00178008f, 
    0.02609050f, -0.03599567f, 0.01680816f, -0.03979067f, -0.03833283f, 0.00207803f, 0.02888527f, -0.03671419f, 
    0.02540845f, -0.01003840f, 0.01899047f, -0.03881940f, -0.00735328f, 0.01036657f, 0.01363418f, 0.00467946f, 
    -0.04166909f, -0.00574021f, 0.00442869f, 0.02007379f, 0.01592451f, 0.01646624f, -0.04208183f, -0.03397815f, 
    0.02502275f, -0.03073887f, -0.02010342f, 0.03358011f, 0.00928193f, -0.02629512f, 0.01516975f, 0.01975235f, 
    0.01785811f, 0.00496569f, 0.00467930f, 0.03188921f, -0.01129149f, -0.04025196f, -0.02419780f, 0.00545650f, 
    -0.03339106f, -0.03541915f, 0.00178909f, -0.03257014f, -0.03933906f, 0.02122627f, 0.01942655f, -0.04131701f, 
    0.01326746f, -0.01366753f, 0.01007493f, 0.01129877f, -0.00400881f, 0.01931627f, -0.00593486f, -0.02601597f, 
    -0.00527060f, -0.00225026f, -0.00194865f, -0.01634131f, -0.03495753f, -0.01923724f, -0.01945021f, -0.03379882f, 
    0.01636189f, -0.03577060f, -0.01174156f, 0.00104678f, 0.00499062f, -0.01834121f, 0.00603122f, -0.01535995f, 
    0.03466459f, 0.02330048f, -0.03260539f, 0.02624423f, 0.00570431f, -0.03397912f, -0.01295870f, 0.01343556f, 
    -0.03226260f, -0.03842915f, 0.00582932f, -0.00220602f, -0.01529434f, 0.02679967f, -0.02688825f, -0.02183410f, 
    -0.02217215f, -0.03844264f, -0.01782017f, 0.02558004f, -0.00068865f, 0.02566411f, -0.02540729f, -0.03773391f, 
    0.00421469f, -0.02762394f, -0.03242033f, -0.03372136f, -0.01396524f, -0.03780355f, 0.02029870f, -0.02164021f, 
    -0.02269355f, 0.00225608f, -0.03858409f, 0.02070082f, -0.00787180f, -0.01452562f, -0.01212389f, -0.00564047f, 
    -0.03978909f, -0.01911622f, 0.00996000f, 0.01141359f, 0.00845516f, -0.03628679f, -0.01568326f, 0.01577028f, 
    -0.03101207f, -0.01707317f, -0.03428542f, -0.02976354f, -0.00241140f, 0.01530867f, -0.00050343f, -0.01344248f, 
    0.02773314f, 0.02306653f, 0.02850442f, -0.01067733f, -0.00886701f, -0.00840696f, 0.01075162f, 0.02863071f, 
    -0.00490124f, 0.00745408f, 0.01021133f, -0.02874250f, -0.01158224f, -0.03984130f, -0.02604473f, 0.00441272f, 
    -0.02273739f, 0.01713776f, -0.03471660f, -0.02457253f, -0.00998073f, 0.00415268f, -0.00372181f, 0.02702384f, 
    -0.03889376f, 0.01654059f, 0.01375474f, -0.02066470f, -0.03618921f, -0.03884948f, -0.02298654f, 0.02440157f, 
    -0.00632031f, -0.00723312f, 0.02311034f, -0.00766095f, -0.01725820f, 0.00131144f, 0.01728357f, -0.01397428f, 
    -0.01563404f, 0.01540543f, -0.03646701f, -0.02088581f, -0.01233745f, -0.02920789f, 0.00585520f, 0.01573042f, 
    0.02096724f, -0.00402558f, -0.01570862f, 0.00633317f, -0.01377040f, 0.02576817f, -0.02543559f, -0.00313570f, 
    0.00357741f, 0.02581818f, -0.00740136f, -0.01972199f, 0.01038343f, -0.00175258f, 0.00236153f, -0.01616417f, 
    0.00420103f, 0.02759750f, 0.00086289f, -0.03368680f, -0.00564628f, -0.01518412f, -0.02840725f, 0.03030983f, 
    -0.02669566f, -0.01799988f, -0.02854128f, 0.02666532f, 0.00165408f, -0.00813005f, -0.02108680f, -0.02414535f, 
    0.02445736f, -0.01250232f, -0.00722114f, 0.02226578f, -0.01737010f, -0.01255241f, -0.00907417f, 0.01500528f, 
    -0.03897447f, -0.03278724f, -0.03469814f, 0.01439927f, 0.00542258f, -0.03350772f, 0.01298508f, -0.02840680f, 
    -0.01429390f, -0.02278804f, -0.03290353f, -0.03280880f, 0.00636542f, 0.03070699f, -0.00721557f, -0.00679298f, 
    0.03176998f, 0.02915244f, 0.02561809f, 0.03254395f, 0.03084821f, 0.01836594f, -0.00438951f, -0.03282211f, 
    -0.01316748f, -0.04120705f, -0.01517683f, 0.01969293f, -0.00318791f, -0.02895519f, -0.02519380f, 0.02598343f, 
    -0.00108425f, -0.01612534f, 0.01117516f, -0.03057563f, 0.02996431f, -0.02363963f, -0.03954647f, 0.02641862f, 
    -0.03389411f, -0.00907628f, 0.01815995f, 0.00391453f, 0.02588065f, -0.03754548f, 0.02876071f, -0.03200414f, 
    0.03306324f, 0.02628480f, 0.00369889f, -0.01154990f, -0.00934960f, 0.02351468f, -0.02588405f, 0.01769865f, 
    -0.01460879f, -0.02999014f, -0.00828269f, 0.03209366f, -0.01771833f, -0.00822533f, 0.02622756f, 0.01694689f, 
    0.01783189f, -0.01867748f, 0.02558222f, -0.02688713f, -0.01453720f, 0.01895543f, -0.01515937f, 0.02111501f, 
    -0.00831904f, 0.00409809f, -0.04009739f, -0.00893050f, -0.02426234f, -0.02149931f, -0.00819046f, -0.02847975f, 
    0.00119391f, 0.01863163f, 0.00796562f, -0.01646512f, 0.00094720f, 0.02678762f, 0.02211025f, 0.01062015f, 
    -0.01714520f, -0.02062174f, -0.01678780f, -0.03482672f, 0.02812792f, -0.00861479f, 0.03101726f, 0.02480052f, 
    0.00030792f, 0.01317082f, -0.02308718f, -0.00773126f, 0.02749557f, -0.00715333f, -0.03127938f, -0.03601827f, 
    0.01355349f, -0.03236699f, -0.00251913f, 0.00149375f, 0.03499413f, -0.02224029f, 0.00251696f, -0.03402487f, 
    -0.02863750f, -0.03241122f, -0.00741471f, 0.03575661f, -0.02350838f, 0.00403509f, 0.02026111f, 0.01930367f, 
    0.03308085f, 0.00204555f, 0.01174422f, -0.01920927f, 0.03034481f, 0.02287378f, -0.01065683f, 0.02965548f, 
    -0.01913740f, -0.00687895f, 0.03056061f, -0.03232441f, -0.02037445f, -0.00522610f, 0.03116699f, -0.02744121f, 
    -0.02143917f, 0.03539586f, -0.03508153f, -0.00792964f, -0.00010043f, -0.02645041f, 0.02514504f, 0.00036086f, 
    -0.01405620f, -0.02882848f, -0.02060804f, 0.01445868f, 0.01493662f, -0.02769155f, -0.01100430f, 0.00969637f, 
    -0.01344225f, -0.01607252f, 0.01427723f, -0.02736352f, -0.02193389f, -0.01365595f, -0.02978204f, -0.01338586f, 
    0.01028909f, -0.03375340f, -0.03881270f, -0.02853991f, -0.04207493f, -0.00209808f, -0.02926860f, -0.00341486f, 
    0.02427168f, 0.01949707f, 0.02924905f, 0.00008819f, -0.00616172f, 0.01758434f, -0.04021501f, 0.02304745f, 
    -0.01266325f, 0.02171369f, 0.00922212f, 0.02051008f, -0.00904214f, 0.02001044f, 0.01623938f, 0.02665214f, 
    -0.01228617f, 0.01023732f, -0.02344931f, -0.02351682f, -0.01024004f, 0.00628899f, 0.01670329f, 0.01974277f, 
    0.00393987f, -0.04081311f, 0.01935302f, 0.02640833f, -0.02984150f, 0.02460674f, -0.02167782f, -0.02928464f, 
    -0.04141178f, -0.01482101f, 0.02914813f, 0.02768520f, -0.02214810f, -0.03342031f, -0.01746014f, 0.01347594f, 
    0.02051207f, 0.00341963f, 0.01188784f, -0.03320706f, 0.00992117f, 0.01275062f, -0.01225450f, -0.02153227f, 
    -0.02800297f, -0.03301802f, -0.01978956f, -0.02381009f, -0.01108800f, -0.03922381f, -0.03360260f, -0.02214726f, 
    -0.01590188f, 0.01048065f, -0.01588761f, -0.02855928f, -0.03122999f, 0.01379461f, -0.02548077f, -0.02649563f, 
    -0.04147755f, -0.02536741f, -0.00171792f, -0.03656714f, 0.02281318f, 0.00423107f, 0.02452049f, 0.02403623f, 
    -0.03364586f, -0.03330504f, -0.01083434f, 0.00277544f, -0.02810461f, -0.01151216f, 0.01527024f, 0.00543148f, 
    0.00591845f, -0.03482554f, 0.00455757f, -0.02061171f, 0.00925175f, -0.00981329f, 0.02741310f, -0.03347474f, 
    0.01472239f, -0.00269623f, 0.03037591f, -0.00232928f, -0.00014479f, -0.02831503f, 0.00639133f, 0.00763564f, 
    -0.00543265f, -0.03031701f, -0.01147603f, 0.01827641f, -0.00975780f, 0.02993916f, 0.00196790f, -0.02451679f, 
    0.02873296f, 0.02600409f, -0.01887240f, -0.01247158f, -0.03997832f, -0.03492648f, -0.02524736f, -0.02313165f, 
    -0.01758182f, -0.01794177f, 0.01159547f, 0.01766213f, 0.01881295f, -0.00022406f, 0.01363613f, -0.00624950f, 
    -0.01329945f, -0.01764457f, -0.02608166f, 0.00515697f, -0.00589051f, 0.02719888f, 0.00706011f, 0.02703479f, 
    -0.00277687f, -0.01031351f, -0.03268114f, -0.02163419f, 0.01813537f, 0.01813870f, -0.03648664f, -0.01249385f, 
    -0.00133143f, -0.01489961f, -0.02995294f, 0.02983468f, -0.03506400f, -0.03182941f, -0.03052551f, -0.01247597f, 
    0.00388319f, 0.00603180f, 0.02324984f, -0.00591009f, 0.00766465f, -0.02483722f, -0.00662214f, -0.02093162f, 
    -0.00669296f, -0.02010904f, -0.01059974f, -0.03543914f, -0.01239972f, -0.02981215f, -0.01098689f, -0.03730164f, 
    -0.02872911f, 0.03269979f, -0.03394853f, -0.02531261f, 0.01057678f, 0.02996996f, 0.00062297f, -0.02905735f, 
    0.01828817f, 0.00653680f, -0.00414079f, -0.00620099f, 0.00651701f, 0.03480570f, 0.01215457f, -0.00063174f, 
    -0.00905832f, -0.01423414f, -0.02665523f, 0.01994068f, 0.01385711f, 0.02347820f, -0.00576598f, 0.00981354f, 
    -0.03656879f, -0.00988451f, 0.00194287f, -0.02528337f, -0.02372707f, 0.01975290f, 0.01195147f, -0.01166076f, 
    -0.02534276f, -0.04142582f, 0.02010138f, 0.02024587f, 0.01206615f, -0.03770347f, 0.02064140f, 0.01223072f, 
    0.02334126f, -0.00753502f, 0.00885907f, 0.01343589f, -0.03102687f, -0.02559161f, 0.00082795f, 0.01284419f, 
    -0.01314744f, 0.01358829f, 0.02392973f, -0.00814985f, -0.01773711f, -0.02225594f, 0.01594638f, -0.02538667f, 
    0.01132415f, -0.02084646f, -0.01926085f, 0.01555951f, -0.03593935f, -0.00295310f, -0.00583549f, -0.02007754f, 
    -0.02596307f, -0.03864511f, -0.02908402f, -0.00609977f, 0.00937303f, 0.03002146f, -0.01419191f, 0.02512538f, 
    0.01241428f, -0.02934993f, 0.00575284f, -0.02712716f, 0.00036468f, -0.02672612f, 0.01395801f, 0.02672262f, 
    -0.01106812f, 0.00401955f, -0.03822108f, -0.02897660f, -0.02273424f, 0.01916962f, 0.02371619f, 0.02348175f, 
    -0.04004275f, 0.02234554f, 0.01984776f, 0.00007589f, -0.02255771f, 0.01985084f, 0.00311869f, -0.03967152f, 
    0.01823361f, -0.02310572f, -0.01410767f, -0.01621207f, -0.02487227f, -0.04122631f, -0.02974448f, -0.03160356f, 
    0.22483540f, 0.05837781f, -0.05347940f, -0.08806336f, 0.02117741f, 0.05025756f, -0.11397862f, -0.05640084f, 
    0.06517937f, -0.02525835f, -0.01399708f, -0.13895051f, 0.22204301f, -0.05755225f, -0.42340106f, -0.00290505f, 
    -0.06157804f, -0.09631848f, 0.19561552f, -0.08593097f, 0.02878262f, -0.05902312f, 0.10341934f, -0.06909380f, 
    -0.10416110f, 0.18170469f, -0.14719059f, -0.33173102f, 0.02404063f, -0.07618809f, 0.03478510f, 0.07355736f, 
    -0.01137224f, 0.02361465f, 0.01950107f, 0.03449393f, -0.07539189f, -0.00653811f, -0.02482891f, 0.09690697f, 
    0.06121141f, -0.01701540f, 0.05498123f, 0.06023056f, 0.06828723f, -0.00986417f, 0.05275450f, -0.00134624f, 
    0.00324671f, -0.08017805f, 0.15439740f, -0.05718238f, 0.09910817f, -0.05036420f, 0.04372032f, 0.03873406f, 
    0.08735442f, 0.13949716f, 0.03880055f, -0.06131510f, -0.02621076f, 0.16100389f, -0.11118317f, -0.06911094f, 
    -0.00909799f, -0.09814009f, 0.23083481f, 0.05344125f, -0.01478895f, -0.01969823f, -0.08240201f, -0.00323724f, 
    -0.37489241f, -0.13129124f, -0.14996049f, 0.06734052f, -0.02256099f, 0.09472791f, 0.24400952f, 0.08912119f, 
    -0.02914291f, -0.07626053f, 0.04891063f, 0.04830720f, 0.07031553f, 0.32889113f, -0.02675999f, -0.00957037f, 
    0.01298374f, -0.05017736f, -0.02610341f, -0.09926683f, 0.09486069f, 0.02875864f, -0.02502104f, 0.04246836f, 
    -0.14366707f, 0.07721360f, -0.03180423f, 0.05015134f, -0.02891689f, -0.05818848f, -0.07529164f, 0.02104477f, 
    0.13802712f, -0.17070851f, 0.10243543f, -0.03500385f, -0.11828423f, 0.18416630f, 0.15723984f, -0.04692340f, 
    0.02939718f, -0.06351303f, -0.11718409f, 0.00167446f, -0.04251336f, 0.03953422f, 0.14040396f, -0.05758170f, 
    -0.03660044f, -0.66743225f, 0.37513477f, -0.13192283f, 0.04313032f, 0.09702844f, -0.17833406f, 0.14082585f, 
    0.15133013f, -0.01665011f, -0.05729739f, -0.04352280f, -0.35892639f, 0.10969297f, -0.00561861f, -0.15254146f, 
    -0.02568877f, 0.03292650f, 0.06112567f, 0.02534636f, 0.16225819f, 0.07874479f, -0.04643363f, -0.02647445f, 
    0.25409549f, -0.27474609f, 0.09897735f, -0.24723715f, 0.05218336f, 0.04015115f, -0.08102116f, -0.08121126f, 
    -0.04990692f, -0.08005906f, -0.00983834f, -0.11762442f, 0.18541589f, 0.02116212f, 0.34847486f, -0.05303875f, 
    -0.06910568f, 0.02893144f, -0.13356665f, 0.12487315f, -0.04405529f, 0.18594597f, 0.04818487f, -0.14070053f, 
    -0.00043980f, -0.14583413f, 0.13793926f, 0.10379714f, 0.00758594f, 0.09533860f, -0.00661766f, -0.12175204f, 
    -0.12898143f, -0.04067444f, 0.04408344f, -0.19854218f, -0.00993024f, 0.02309849f, -0.16587055f, -0.04568164f, 
    0.00561587f, 0.02051484f, 0.10697963f, 0.12707888f, -0.00758947f, -0.01671167f, -0.07300758f, 0.04434977f, 
    0.04668390f, 0.17092215f, 0.28437924f, 0.44886857f, -0.06056512f, -0.04373188f, -0.01175525f, -0.00828876f, 
    0.04907009f, 0.00088531f, -0.01982720f, 0.00674340f, -0.05305717f, 0.12081715f, -0.45998484f, 0.04108135f, 
    0.01651260f, -0.04547964f, 0.10310178f, 0.04594225f, 0.04329804f, 0.00726148f, 0.01646023f, 0.00964293f, 
    0.06010958f, -0.11926449f, 0.01136033f, 0.07267338f, -0.04312058f, 0.05388096f, -0.00158663f, 0.04729934f, 
    0.05814554f, -0.01888923f, -0.02458305f, 0.04278186f, -0.04773796f, -0.18628667f, -0.05772168f, 0.00049473f, 
    0.02733190f, 0.04551205f, 0.05840537f, 0.05538446f, 0.07147155f, 0.00925329f, 0.04416711f, 0.03376904f, 
    -0.05989628f, -0.09692486f, -0.19787890f, 0.04665686f, -0.03043478f, 0.05451372f, 0.07298704f, 0.01222395f, 
    0.04015483f, -0.06186101f, -0.01388115f, -0.01271960f, 0.00472767f, 0.01456008f, -0.04301337f, -0.01630824f, 
    0.04314111f, 0.08453006f, 0.11170669f, 0.07081190f, 0.09398015f, 0.13969490f, 0.18053213f, 0.22334851f, 
    -0.03454124f, -0.15343510f, 0.09729006f, -0.07573848f, -0.07214984f, 0.05900438f, -0.10961471f, 0.06020028f, 
    0.08862620f, -0.02353420f, 0.02896191f, 0.06567127f, 0.12266789f, -0.17823118f, 0.28026587f, 0.08004646f, 
    -0.00805170f, 0.04504025f, -0.01638877f, -0.04531686f, 0.04924148f, -0.16873713f, 0.04766713f, -0.05306931f, 
    0.22237740f, 0.14306264f, 0.19671440f, -0.33221871f, 0.04515126f, -0.04692208f, 0.02205860f, -0.05162349f, 
    -0.01217489f, 0.07523648f, -0.02626916f, 0.04932889f, -0.22575043f, 0.07673345f, -0.15832545f, 0.15259662f, 
    0.01020270f, 0.14366266f, -0.06410354f, 0.11532587f, 0.07203943f, 0.00098761f, 0.03309799f, 0.07554544f, 
    -0.04103502f, 0.08356147f, -0.10068665f, -0.12970206f, -0.01725069f, -0.13511704f, 0.01718403f, -0.04590592f, 
    0.02140104f, -0.06979494f, -0.00442842f, -0.02200173f, -0.13671006f, -0.13253964f, 0.09987795f, 0.01852581f, 
    0.10120594f, 0.13082580f, -0.03802330f, 0.01299611f, 0.01526372f, -0.07156637f, 0.03819991f, 0.02307842f, 
    0.06613376f, 0.15770379f, 0.01967368f, -0.08334973f, -0.13143177f, -0.03532188f, 0.04945516f, -0.08093762f, 
    -0.01107970f, -0.00749594f, 0.07306109f, -0.02482176f, -0.09825668f, 0.06580652f, -0.02639910f, 0.14540711f, 
    -0.01421528f, 0.05868356f, 0.04273481f, -0.10247903f, 0.00863793f, -0.09845879f, -0.01447796f, 0.04124085f, 
    0.18135932f, 0.02883285f, 0.13710417f, -0.10379810f, 0.01983814f, -0.04904903f, -0.00859907f, -0.02574055f, 
    -0.04654399f, -0.05321759f, -0.00145108f, 0.03473064f, 0.15397948f, 0.09070996f, 0.20025907f, -0.09177690f, 
    -0.12634866f, -0.08906683f, -0.03712045f, 0.04680829f, -0.04355869f, 0.02228604f, -0.01800054f, 0.03943779f, 
    0.15106320f, -0.20465046f, 0.13787384f, -0.08618962f, 0.05060654f, -0.08080568f, -0.07597098f, -0.01224199f, 
    -0.06915728f, -0.02302023f, 0.13839085f, 0.21253158f, 0.04928468f, 0.21326877f, 0.36857960f, 0.32430682f, 
    -0.03833985f, -0.05739322f, -0.04006046f, -0.02291406f, -0.06255358f, -0.00381338f, 0.04210885f, 0.13977912f, 
    -0.04519206f, 0.21035624f, 0.18228628f, -0.21555355f, -0.03191228f, -0.05459320f, -0.11530552f, -0.11707520f, 
    -0.00049089f, 0.14383444f, -0.01842412f, -0.00591207f, 0.06934793f, 0.03908489f, -0.00222176f, 0.13082430f, 
    -0.07751998f, 0.11269292f, -0.07175063f, -0.00556594f, 0.05510498f, 0.01424369f, 0.01799979f, 0.09118302f, 
    0.19120499f, -0.03005400f, 0.00008925f, -0.25222841f, 0.14852053f, 0.11614809f, -0.04047199f, -0.09437807f, 
    -0.06064943f, 0.07426219f, 0.01811780f, -0.11867952f, -0.19666544f, 0.27392754f, -0.11239087f, -0.09020061f, 
    0.03842217f, 0.01107378f, -0.00932078f, -0.00230590f, 0.05652102f, -0.01983752f, -0.08056810f, -0.06444182f, 
    -0.25785536f, -0.03792166f, 0.24442098f, 0.23155886f, 0.13320233f, -0.06403075f, -0.06152621f, 0.06096616f, 
    0.02805113f, -0.01225557f, 0.18560877f, 0.20000686f, 0.01334768f, -0.02041332f, 0.07615162f, 0.08765068f, 
    -0.06945811f, 0.05521153f, -0.07147201f, -0.06530083f, -0.04086878f, 0.00642708f, 0.06060757f, -0.02967151f, 
    0.02040024f, 0.25273472f, 0.02007521f, -0.18893839f, 0.02738195f, 0.01818773f, 0.14755645f, 0.03159148f, 
    -0.02825817f, 0.02927758f, 0.06544130f, -0.18826552f, -0.05067239f, 0.07143747f, -0.24859475f, -0.05575207f, 
    0.00020944f, 0.03628732f, 0.00477770f, 0.02384000f, 0.09075008f, -0.01760615f, -0.08647903f, 0.09960277f, 
    0.15362324f, 0.14917089f, -0.51946253f, -0.15383482f, -0.06945837f, -0.00422103f, -0.01410780f, -0.01352432f, 
    0.01702674f, 0.05852489f, 0.01699168f, 0.02330640f, 0.16749494f, 0.02666444f, 0.02142356f, -0.26863107f, 
    0.10806648f, -0.04671237f, -0.02874108f, 0.09144522f, 0.01204264f, -0.07641210f, -0.07710373f, -0.16401204f, 
    -0.17329875f, 0.22256218f, -0.19379196f, 0.08439673f, 0.00448470f, -0.03112188f, 0.04247403f, 0.13826786f, 
    0.06733226f, -0.19293408f, 0.05262797f, -0.05397627f, 0.12003406f, -0.09999529f, -0.03548221f, -0.00015802f, 
    -0.03650939f, 0.13106564f, -0.15070401f, 0.13439581f, 0.06836767f, -0.03929150f, -0.00987078f, -0.09621941f, 
    0.15613933f, -0.10724834f, 0.00541343f, -0.05060514f, 0.01017421f, -0.08007130f, 0.04854460f, -0.00183584f, 
    0.03170739f, -0.10321664f, -0.03428774f, -0.02343764f, -0.02292355f, -0.29566607f, 0.11983377f, 0.39984092f, 
    0.03729699f, 0.14102033f, 0.00872121f, 0.08200081f, 0.02982343f, -0.02138354f, -0.08285013f, -0.06117230f, 
    -0.08373604f, 0.01673388f, 0.00138083f, 0.04815799f, 0.03472212f, -0.00114696f, -0.01673711f, 0.00939236f, 
    0.04978325f, -0.02907215f, -0.08587599f, 0.05342939f, 0.00286161f, 0.06413902f, 0.09464126f, 0.22209935f, 
    -0.12420813f, -0.01941246f, -0.04826994f, -0.02557421f, 0.12866190f, 0.05862270f, 0.06741864f, 0.16319554f, 
    0.05736498f, 0.25040624f, 0.06134698f, -0.32473820f, 0.02295981f, -0.03893702f, -0.04437204f, -0.06157577f, 
    0.07682283f, -0.02937690f, -0.07752957f, 0.09961652f, 0.32769176f, -0.29071465f, 0.22378550f, -0.33476755f, 
    0.10715853f, -0.06037034f, -0.16271967f, 0.03565734f, 0.04046917f, 0.08300696f, 0.06226788f, 0.09312562f, 
    0.04084310f, -0.19341648f, -0.11852561f, -0.12107058f, 0.02072452f, -0.05830954f, 0.05232926f, -0.00626795f, 
    0.07568073f, -0.06478425f, 0.10768431f, -0.02331243f, -0.12856281f, 0.00975666f, -0.05134036f, -0.00160963f, 
    -0.01992925f, 0.04530335f, 0.09891540f, 0.01918083f, 0.04973759f, 0.06844830f, 0.03684418f, -0.08994028f, 
    0.19582351f, -0.21317613f, 0.06163260f, -0.18089557f, 0.04784715f, 0.06432381f, 0.01041945f, 0.08942581f, 
    0.02233738f, -0.03210991f, 0.07557005f, -0.03506566f, -0.16899605f, 0.08468249f, -0.04860461f, -0.06584925f, 
    0.05907190f, -0.06669445f, 0.09039904f, 0.06142851f, 0.09249221f, 0.08899759f, 0.12862092f, 0.18235604f, 
    0.04096729f, 0.11284525f, -0.01102137f, -0.16025114f, -0.05821169f, -0.10239165f, 0.03197934f, 0.02032325f, 
    0.05749942f, 0.01403363f, -0.12669808f, -0.04951347f, 0.06401858f, -0.08033559f, 0.07682916f, -0.00981136f, 
    0.13989218f, -0.07551638f, 0.06904387f, 0.08981360f, 0.00957046f, -0.02051321f, -0.02340379f, -0.07607859f, 
    -0.08694007f, -0.01600660f, -0.03747236f, 0.13143763f, 0.03021826f, 0.13643035f, 0.03913017f, 0.01569556f, 
    -0.00520594f, -0.04333533f, -0.04637250f, 0.10599197f, 0.26099652f, 0.19074537f, 0.35246810f, -0.09720544f, 
    0.01408341f, -0.18309230f, -0.14227626f, -0.11980513f, -0.16896422f, -0.15855466f, 0.05583192f, 0.17833336f, 
    -0.15018030f, -0.23874162f, -0.15011264f, 0.10980830f, 0.09978835f, 0.10732011f, 0.05819779f, -0.00406560f, 
    -0.06591112f, 0.05286789f, 0.00808839f, 0.06111839f, 0.03496857f, -0.00895740f, -0.08218413f, 0.11486204f, 
    0.05707612f, 0.04157247f, 0.09645739f, 0.08507030f, 0.12447089f, 0.00607789f, 0.09933108f, 0.07702503f, 
    0.07725400f, 0.08735637f, -0.19251269f, -0.00783039f, 0.12015941f, 0.00735308f, 0.12154597f, 0.10516594f, 
    0.13553672f, 0.07509291f, 0.17174672f, 0.08152971f, -0.02151637f, 0.17756601f, -0.50578207f, -0.11040440f, 
    -0.13256399f, -0.03404115f, -0.14571917f, -0.09046805f, 0.09987319f, 0.02878396f, -0.00132734f, -0.10187967f, 
    0.02754998f, -0.02603079f, -0.17147392f, 0.16290145f, 0.03599492f, 0.08186170f, 0.09907909f, 0.26762041f, 
    -0.13103913f, 0.06726783f, -0.10552798f, 0.14880432f, -0.21348470f, -0.14455007f, 0.29456061f, 0.14141642f, 
    0.04025596f, 0.02285866f, -0.10321644f, 0.09042396f, -0.03968033f, 0.11470548f, -0.27701744f, 0.08680306f, 
    -0.11932708f, -0.00807311f, 0.12324160f, -0.00670142f, -0.21480125f, 0.01567283f, -0.05107559f, -0.11676382f, 
    -0.05990656f, 0.14709878f, -0.05364510f, 0.05846867f, -0.05120451f, 0.04182161f, 0.07496253f, -0.08860274f, 
    -0.10234719f, 0.02221766f, -0.21484950f, -0.20281066f, -0.00731346f, 0.05870310f, 0.13748819f, -0.23279317f, 
    -0.09536030f, 0.03945844f, 0.17738776f, 0.25289854f, -0.12615409f, 0.04004983f, 0.02139529f, -0.08487901f, 
    -0.06593847f, -0.08283331f, -0.05062978f, 0.06694870f, 0.11698820f, -0.03670720f, -0.03925248f, -0.24572501f, 
    0.14874503f, -0.01852456f, 0.16047457f, 0.09672039f, -0.11274218f, 0.01056313f, 0.00806131f, -0.15738772f, 
    -0.15804997f, 0.29364842f, -0.08233939f, -0.30364695f, -0.09253638f, -0.13580683f, -0.23427223f, 0.05997414f, 
    -0.09307336f, 0.03398933f, 0.07404561f, -0.17079839f, 0.13873711f, -0.09663855f, -0.06504611f, -0.07666706f, 
    -0.09663722f, 0.01755323f, -0.04548544f, -0.01018505f, -0.03508302f, -0.00650478f, -0.03176342f, -0.02649589f, 
    -0.12050715f, -0.17880812f, 0.15436548f, -0.04426111f, -0.13475236f, -0.00535824f, 0.08837099f, -0.08539462f, 
    0.04800720f, 0.09598977f, 0.05597454f, 0.10973515f, -0.04780394f, 0.00011858f, -0.00084933f, 0.07254740f, 
    0.17902999f, 0.04622936f, 0.17679290f, -0.11842554f, 0.05116424f, 0.03384656f, -0.05832504f, 0.20458990f, 
    0.33047003f, 0.14888473f, -0.21498366f, -0.10546125f, 0.11181273f, -0.04387485f, 0.07520968f, 0.01218864f, 
    0.17002927f, -0.07817702f, 0.17204854f, -0.00114179f, 0.32522476f, 0.00838136f, 0.23280354f, 0.14498590f, 
    0.03365352f, 0.21537015f, -0.21955183f, -0.00621242f, -0.05025908f, 0.04784359f, 0.04307486f, 0.13010105f, 
    0.08453723f, -0.14107405f, 0.01157023f, 0.09213712f, -0.00751397f, 0.01399124f, -0.04414368f, -0.16558957f, 
    0.09277618f, 0.13206838f, -0.07658218f, -0.06524685f, 0.37522426f, 0.16260152f, -0.01990692f, 0.10160335f, 
    -0.00675553f, 0.20137230f, -0.03203547f, -0.09061836f, 0.03470995f, 0.24677889f, -0.05757800f, 0.07852812f, 
    0.38801813f, -0.22704880f, 0.13739686f, -0.25505239f, 0.04667168f, -0.08206271f, 0.12055605f, 0.05095177f, 
    -0.06467532f, 0.20002589f, 0.12657818f, 0.13004495f, 0.22889343f, 0.14704750f, -0.03009440f, -0.14207877f, 
    0.08551977f, 0.02407738f, 0.10624284f, 0.11432929f, -0.09634954f, -0.00066886f, 0.04493476f, -0.06837234f, 
    0.12413520f, 0.13329382f, 0.14395310f, 0.05076635f, -0.04094652f, -0.08091790f, -0.07264773f, -0.04688938f, 
    -0.07462303f, -0.04088985f, -0.15950280f, -0.03415041f, -0.07242905f, -0.00813022f, 0.20712395f, -0.10529212f, 
    -0.06476683f, -0.17989028f, -0.27929905f, 0.07247765f, 0.01833394f, -0.11254318f, 0.14412615f, 0.11288373f, 
    -0.09383338f, 0.15545884f, -0.14668483f, -0.13030669f, -0.05191030f, -0.00856246f, 0.08891688f, 0.09036548f, 
    0.15356062f, 0.09737531f, -0.00098322f, 0.03215113f, 0.03558312f, -0.12755479f, 0.03304587f, 0.04488152f, 
    -0.15434501f, -0.18444815f, -0.00577949f, -0.22244507f, 0.03212179f, -0.01491362f, -0.06375856f, 0.20106933f, 
    -0.01349371f, 0.09928006f, 0.23121241f, 0.17961581f, -0.12997288f, -0.20212017f, -0.12811229f, -0.16439646f, 
    0.06953662f, 0.07339805f, 0.08787372f, 0.22584787f, -0.27930456f, 0.02394513f, 0.35133049f, 0.05021239f, 
    -0.16835120f, -0.02633398f, -0.15924010f, -0.16818435f, -0.01001343f, -0.12814528f, -0.02064920f, 0.08141731f, 
    0.49257347f, 0.08219948f, 0.19347124f, 0.13844590f, 0.13219452f, 0.14250404f, 0.10086016f, -0.03121871f, 
    0.08044543f, -0.06796295f, -0.00047309f, -0.12273724f, 0.12223592f, 0.03977886f, -0.16166049f, -0.01535297f, 
    0.05301762f, -0.08892595f, 0.20294517f, 0.06515659f, 0.06994499f, -0.15853947f, 0.04787194f, 0.00102207f, 
    0.21194795f, 0.20055522f, 0.14259438f, -0.13329621f, 0.19752504f, 0.12030135f, 0.03622257f, 0.08591098f, 
    -0.06880204f, 0.04952398f, -0.00412328f, -0.05046710f, -0.20916107f, -0.04497594f, 0.09344185f, -0.11542448f, 
    0.03967304f, -0.23217040f, -0.01500111f, 0.00817072f, -0.06705256f, 0.19126284f, -0.08115841f, -0.09184786f, 
    0.12525405f, 0.03176709f, 0.08739963f, 0.07650254f, -0.00691515f, 0.15685114f, -0.08593577f, 0.19291162f, 
    -0.18460222f, 0.04184649f, -0.07350970f, -0.08565030f, 0.24464038f, 0.14389285f, 0.38027132f, 0.34039113f, 
    0.18733792f, 0.19360258f, -0.00219081f, -0.01647411f, -0.05607484f, 0.01822126f, -0.04156210f, -0.16889784f, 
    0.13185915f, 0.09425508f, 0.12128745f, 0.13373037f, -0.09648833f, 0.08748795f, -0.05004338f, 0.17342554f, 
    -0.08626817f, -0.07825053f, 0.00594378f, -0.14640519f, 0.04288764f, 0.11092459f, -0.06247781f, -0.04774985f, 
    0.05616092f, 0.08362788f, -0.03707742f, 0.18723075f, -0.08536506f, 0.04908291f, 0.00603369f, -0.21246700f, 
    -0.19587100f, -0.06879088f, 0.07217796f, -0.16112700f, -0.07870252f, -0.16127111f, -0.12371274f, 0.09198381f, 
    0.13466376f, 0.12572359f, 0.05276546f, 0.04423496f, 0.11499999f, -0.02198819f, -0.05018440f, 0.03202563f, 
    0.04954326f, 0.07544542f, 0.16684392f, 0.09118587f, -0.01017482f, 0.09139605f, 0.12350913f, -0.14125472f, 
    0.20351079f, -0.07700205f, 0.22695516f, 0.05848204f, -0.02145781f, 0.02863174f, -0.13476853f, -0.08134685f, 
    0.05773126f, -0.00326513f, -0.02250389f, 0.00084662f, 0.01805627f, -0.04747448f, -0.18282326f, -0.05416555f, 
    0.04823982f, 0.09901965f, 0.05245570f, -0.00303103f, -0.08626213f, -0.01823940f, -0.01491159f, 0.05074858f, 
    -0.09320536f, -0.04327285f, 0.12064786f, 0.00449916f, -0.01532391f, 0.12159756f, 0.11672652f, -0.09998874f, 
    0.00516893f, 0.08873219f, 0.17597732f, 0.08750507f, 0.17935643f, 0.07705770f, -0.06942039f, 0.09369966f, 
    0.09599523f, 0.16313221f, -0.05704735f, -0.00801312f, -0.00696597f, -0.07085760f, -0.15021436f, -0.17473692f, 
    0.18553759f, -0.11715985f, -0.06530227f, -0.10065703f, 0.05351581f, 0.02695386f, 0.06522765f, 0.14415395f, 
    0.02823851f, 0.11975102f, -0.09231239f, 0.03190082f, 0.16729611f, 0.16700454f, -0.02493214f, 0.09328327f, 
    0.06571582f, 0.21381153f, -0.02019229f, -0.06341116f, -0.06718700f, 0.05362068f, -0.10144861f, 0.11828566f, 
    -0.03681847f, 0.06107516f, -0.11186425f, 0.45345142f, 0.06965013f, 0.03959213f, 0.13813573f, -0.12202866f, 
    0.01048406f, -0.15078202f, -0.03715515f, 0.14840345f, 0.10514809f, 0.15784675f, -0.17620344f, -0.00723060f, 
    0.01029600f, 0.16851214f, 0.05665966f, 0.13162148f, -0.02020607f, -0.07408904f, -0.09571768f, 0.02173242f, 
    0.09960172f, 0.04251297f, -0.19849749f, -0.01757946f, 0.15269463f, 0.16737041f, 0.08183031f, -0.03594640f, 
    0.07785860f, 0.02258025f, -0.14842135f, 0.22916061f, -0.23706937f, -0.08300196f, 0.39441711f, -0.11511000f, 
    -0.04972173f, 0.08408587f, -0.12756635f, 0.03716500f, 0.14196056f, -0.04336454f, -0.08053919f, 0.15212590f, 
    -0.06780245f, -0.38763648f, 0.17655282f, -0.31999570f, -0.05108896f, -0.17690614f, -0.06222827f, 0.00100980f, 
    0.12142437f, 0.12003884f, 0.00521700f, 0.02344811f, 0.08745529f, 0.08168427f, 0.18790857f, -0.26237637f, 
    -0.04968403f, 0.18481129f, -0.02702988f, -0.10067829f, -0.05369492f, 0.19126627f, -0.10640366f, 0.07598639f, 
    -0.07978244f, 0.32104358f, 0.03561417f, 0.19643338f, -0.12667552f, 0.14897135f, 0.01172035f, 0.10778371f, 
    -0.15957375f, 0.03460415f, 0.12193399f, 0.04462681f, -0.20286155f, 0.18915260f, -0.07167191f, -0.08695064f, 
    -0.00953083f, -0.20335181f, 0.16309972f, -0.10007834f, -0.03498811f, 0.00120269f, 0.27107286f, 0.12556490f, 
    0.02164624f, 0.07868098f, 0.15787607f, 0.01583596f, 0.08682158f, 0.00186838f, 0.14733168f, 0.06166168f, 
    -0.03281729f, -0.00460331f, 0.06973989f, -0.04888590f, -0.05608625f, -0.11092041f, -0.26901424f, -0.02388072f, 
    -0.03932184f, 0.00380846f, 0.02765596f, 0.04953699f, -0.04156205f, -0.01663168f, -0.13187452f, 0.33208257f, 
    0.35230222f, 0.23757371f, 0.12496855f, 0.00115761f, 0.09297841f, 0.12249308f, -0.01604483f, 0.05180665f, 
    -0.02787975f, -0.04856564f, -0.21323793f, -0.03993996f, 0.07853189f, 0.07115642f, -0.08679541f, 0.09383184f, 
    0.01635449f, 0.07888779f, -0.00042671f, -0.00367994f, -0.04616922f, 0.10920422f, -0.00729318f, 0.10478158f, 
    -0.00859610f, -0.19345388f, -0.15141331f, 0.04882650f, 0.05759217f, 0.03311227f, -0.01457676f, 0.11768017f, 
    0.09047846f, 0.15247276f, -0.10735217f, 0.05170297f, 0.21957828f, 0.20593083f, -0.24166349f, 0.21960883f, 
    -0.00821960f, -0.04303210f, 0.16338621f, 0.07402364f, -0.17443910f, 0.11402586f, 0.09065275f, 0.00758558f, 
    -0.58298588f, 0.04716682f, 0.26598606f, 0.41034675f, -0.05073024f, -0.14184110f, -0.01957617f, -0.23201486f, 
    0.03641415f, 0.02381773f, 0.07541658f, 0.13736849f, 0.00950427f, -0.05266749f, 0.08680864f, 0.01142047f, 
    -0.08308998f, -0.06957559f, -0.07891395f, -0.10375008f, -0.04263512f, 0.16772981f, 0.01255638f, 0.20294881f, 
    0.34414807f, -0.01861398f, -0.03445267f, -0.11849094f, -0.15253596f, -0.08102049f, -0.12834372f, -0.08871862f, 
    -0.09001669f, 0.17829640f, -0.06978478f, 0.13437079f, -0.23264694f, 0.01222003f, 0.23996460f, 0.15965830f, 
    -0.12384285f, -0.05086350f, -0.15684012f, -0.07209828f, 0.02025295f, 0.01758193f, -0.06064136f, 0.13443409f, 
    -0.07327904f, 0.07621162f, -0.00692933f, -0.26993507f, 0.12983105f, 0.06299920f, -0.05378744f, 0.08562563f, 
    0.08525840f, -0.02655172f, 0.11310174f, -0.02087360f, -0.00596648f, 0.04623607f, 0.05248089f, 0.14594880f, 
    -0.14695235f, -0.04599508f, 0.00666640f, 0.08214737f, 0.15770577f, -0.05234156f, 0.13723582f, -0.07030585f, 
    -0.03648766f, -0.01809061f, 0.01007411f, 0.01825321f, 0.08796405f, 0.01460209f, 0.12093469f, -0.04270848f, 
    0.00517773f, 0.18149494f, 0.06917955f, 0.21852817f, 0.39805657f, 0.01069901f, -0.16709642f, -0.10799630f, 
    0.03181301f, 0.03608773f, 0.16036496f, 0.02928777f, -0.04106655f, 0.05823769f, 0.05043141f, 0.05420758f, 
    -0.27993426f, 0.14336342f, 0.07154882f, -0.20184359f, 0.00187248f, 0.07807401f, -0.09509980f, -0.04077109f, 
    0.09903676f, -0.04232890f, -0.14754921f, 0.01879887f, -0.14791586f, -0.04462646f, -0.05739413f, 0.00187419f, 
    -0.05771274f, -0.15753393f, -0.12942092f, -0.05590071f, -0.19347519f, 0.09907582f, 0.15684314f, 0.07306354f, 
    -0.32031694f, 0.04568240f, 0.03675183f, 0.03376396f, 0.06508871f, -0.16225287f, -0.00242978f, -0.00757386f, 
    0.04806964f, 0.23239130f, -0.10536629f, -0.00672454f, 0.16943818f, -0.31822145f, -0.10469353f, 0.22729844f, 
    0.00390163f, -0.14162771f, 0.08504221f, 0.03049293f, -0.04973791f, 0.01330527f, -0.18961889f, 0.15097223f, 
    -0.15348519f, -0.09102353f, 0.11610858f, -0.00278396f, 0.03327870f, 0.01201553f, -0.00173906f, -0.14543076f, 
    0.00872126f, -0.03002816f, 0.12105960f, -0.12094597f, 0.15535183f, 0.07411990f, 0.09982415f, -0.04429027f, 
    -0.12443952f, 0.13330960f, -0.05325810f, -0.13837375f, 0.15517817f, -0.09310189f, 0.17752984f, 0.17019679f, 
    0.06633571f, 0.00418091f, -0.22888054f, -0.07674146f, 0.02958124f, 0.05726089f, 0.20208356f, -0.03742479f, 
    -0.05242246f, 0.06814305f, -0.06151339f, -0.03311818f, 0.00530821f, -0.12198304f, -0.05314853f, 0.00330886f, 
    -0.02918909f, -0.02516742f, 0.06209999f, 0.10439462f, -0.11253081f, -0.09086134f, -0.05588963f, -0.07807690f, 
    0.29215157f, -0.04061534f, -0.03294197f, -0.26985997f, -0.00158315f, 0.02772828f, -0.12666121f, 0.10167622f, 
    0.02314887f, 0.18030031f, 0.17516637f, -0.02491667f, -0.09160361f, -0.13879322f, 0.00529766f, 0.19398987f, 
    -0.01767273f, 0.05805798f, -0.10577486f, -0.06036895f, 0.02966234f, 0.05063640f, 0.00366816f, 0.00161405f, 
    0.16101877f, -0.20880924f, -0.03737523f, 0.48936385f, -0.04251096f, 0.15827280f, 0.12319862f, -0.06496779f, 
    -0.10089121f, -0.04472273f, -0.04459499f, -0.08295204f, -0.15621948f, -0.14175676f, -0.03929916f, 0.04077174f, 
    0.11648150f, 0.03507226f, 0.05810397f, -0.12616336f, 0.06468347f, -0.11886626f, -0.04265890f, -0.05981667f, 
    0.37151432f, -0.09507781f, -0.08170735f, -0.08207932f, 0.07582970f, 0.01758210f, -0.11471530f, 0.02997798f, 
    0.03728803f, 0.15443495f, -0.03633831f, -0.11360947f, 0.01345823f, -0.03604459f, -0.14018850f, 0.03384517f, 
    -0.02624160f, 0.01619929f, -0.04648158f, 0.04393833f, 0.05534740f, 0.04885792f, -0.16447292f, 0.02027797f, 
    -0.35179093f, 0.38339800f, 0.06978530f, 0.30995956f, 0.06225565f, 0.15529001f, -0.03128390f, -0.07914554f, 
    -0.12353498f, 0.12309323f, -0.10616251f, -0.00280940f, 0.47760355f, -0.07345407f, 0.03164876f, 0.22080959f, 
    0.07470820f, -0.12292127f, 0.27114210f, 0.17235844f, 0.04138022f, -0.05775456f, 0.08378574f, 0.15496652f, 
    -0.40061164f, 0.09168849f, -0.02119952f, 0.26602915f, 0.03562897f, -0.01308931f, 0.11789619f, 0.06448951f, 
    0.06017707f, 0.03847587f, 0.07814133f, 0.18123089f, -0.17359050f, 0.27838382f, 0.23206501f, 0.19990577f, 
    0.03953227f, 0.05044921f, 0.09214444f, 0.20213391f, 0.02652646f, -0.02242311f, 0.03311528f, 0.08175322f, 
    -0.17786735f, 0.41399229f, 0.11253334f, 0.01012703f, 0.09263443f, 0.08805250f, -0.05256655f, -0.02581884f, 
    -0.15366228f, -0.00736852f, 0.10764275f, -0.01003096f, -0.27608773f, -0.09046729f, 0.03639871f, 0.29041520f, 
    -0.04496553f, 0.08209799f, -0.07447121f, -0.17862906f, 0.13002145f, 0.01883969f, 0.09039291f, 0.14638126f, 
    -0.17997620f, 0.14244154f, -0.02333112f, -0.07585504f, 0.15338096f, 0.12805949f, 0.02152301f, 0.17663975f, 
    -0.02601616f, 0.09692182f, 0.08747558f, 0.06232051f, -0.04770322f, -0.12758367f, 0.38433892f, -0.04862993f, 
    0.17283908f, 0.31217074f, 0.20547526f, -0.05303991f, 0.03263704f, 0.11297747f, -0.07845186f, -0.11163064f, 
    -0.11874117f, -0.01572529f, 0.01802878f, 0.05401180f, 0.11803409f, 0.06962518f, -0.17060137f, -0.02397515f, 
    -0.25024325f, -0.13554819f, 0.03055654f, -0.08324261f, -0.15645862f, -0.18146060f, -0.10910546f, -0.13328062f, 
    -0.06381177f, 0.02148077f, -0.06694614f, 0.01881822f, 0.03719489f, 0.10736958f, -0.07071111f, -0.09874701f, 
    -0.09172150f, -0.10261279f, -0.14514972f, -0.10185549f, -0.12124673f, 0.10436115f, 0.03508995f, 0.09064475f, 
    -0.08191811f, 0.01959308f, -0.01769877f, -0.18406200f, 0.20494144f, -0.09079531f, -0.28958380f, -0.18587820f, 
    -0.09707157f, -0.06558469f, 0.05562213f, -0.04731277f, 0.22284935f, 0.32872209f, 0.06884200f, 0.13001534f, 
    -0.37436181f, -0.12653239f, -0.09589100f, 0.15492551f, -0.06663625f, -0.13884105f, -0.04851241f, -0.03987369f, 
    -0.14153147f, 0.16415899f, -0.03149332f, 0.13331710f, -0.08336415f, 0.01731391f, -0.11353830f, -0.02370635f, 
    -0.03892470f, 0.07294991f, -0.19660501f, 0.01965573f, -0.12019788f, 0.16750599f, -0.06181640f, -0.02122644f, 
    -0.15393139f, 0.16623488f, 0.12630285f, 0.36547768f, 0.04070175f, -0.07466365f, 0.03826852f, -0.04492463f, 
    0.02328523f, 0.07774444f, 0.05216560f, 0.04998157f, 0.50873774f, -0.11598837f, 0.13858083f, -0.01810628f, 
    -0.16624323f, 0.15477951f, -0.04810736f, 0.00658935f, 0.16956376f, -0.13303690f, 0.17392427f, 0.08310995f, 
    0.01430419f, -0.26783663f, 0.02152246f, -0.03962151f, 0.08745094f, -0.02601816f, 0.17020318f, -0.07883225f, 
    0.12644786f, -0.07832368f, -0.03213359f, 0.03529400f, -0.10060600f, -0.22203836f, -0.24486528f, 0.05412994f, 
    -0.14489152f, 0.00168009f, 0.02805801f, -0.04312180f, 0.06050894f, -0.01739213f, 0.08812210f, 0.15711434f, 
    -0.20359190f, -0.23661722f, -0.05891426f, 0.09026232f, 0.05505962f, -0.08228943f, 0.02104447f, -0.13338341f, 
    -0.02774479f, -0.07938898f, -0.03073341f, -0.06815276f, 0.10824496f, -0.03487811f, -0.05729291f, 0.02615750f, 
    0.01378436f, -0.01482129f, 0.00540593f, -0.15393899f, 0.01578353f, 0.04948257f, 0.25527203f, 0.33207613f, 
    -0.05044604f, 0.34722134f, -0.21750452f, 0.10831218f, 0.00342703f, 0.12503454f, 0.09619661f, -0.18308666f, 
    0.04338311f, -0.03593961f, -0.05382573f, 0.09637640f, -0.17424819f, -0.04011979f, -0.04536438f, 0.13643639f, 
    -0.02555069f, 0.01662594f, -0.09422779f, -0.09808424f, -0.00715256f, -0.07346136f, 0.07112187f, 0.05676119f, 
    -0.06706934f, 0.04120855f, -0.14912434f, 0.05893002f, 0.05038055f, -0.07029707f, 0.05839678f, 0.03420358f, 
    0.01939696f, 0.14818266f, 0.10063348f, 0.20668375f, -0.15565997f, 0.23611552f, 0.21538249f, 0.15312839f, 
    -0.07527454f, -0.10211863f, -0.01693554f, 0.10256709f, 0.04655338f, 0.11670139f, 0.12374074f, -0.01809596f, 
    -0.04268058f, 0.38177702f, -0.09868708f, 0.42030704f, 0.07077153f, -0.04476900f, 0.07378702f, 0.07591785f, 
    0.00429933f, -0.06371386f, 0.07095988f, 0.14734453f, -0.08834901f, -0.30004880f, -0.06825897f, 0.03890914f, 
    -0.02744590f, -0.06671519f, 0.01948987f, -0.10437450f, -0.03866822f, 0.00677698f, 0.03894861f, 0.16749665f, 
    -0.19937083f, 0.28202376f, 0.19139652f, 0.20713393f, 0.03167970f, -0.02550008f, -0.04134433f, -0.15575776f, 
    -0.01720340f, 0.04889177f, 0.09389317f, -0.00153681f, 0.10031517f, -0.24173121f, 0.02170977f, 0.03715113f, 
    -0.01002383f, -0.14501278f, 0.02065716f, 0.01312571f, 0.01505207f, -0.06904129f, -0.08981617f, -0.13583364f, 
    0.20925149f, 0.16527753f, -0.01856374f, -0.37049708f, -0.04116657f, 0.08935434f, -0.00317694f, 0.23337738f, 
    -0.16328867f, 0.08046867f, 0.08404979f, -0.04868717f, -0.09835948f, -0.10075004f, -0.08773819f, -0.00528471f, 
    0.01708562f, 0.00515785f, -0.02293552f, 0.01949883f, 0.05792169f, 0.14916657f, 0.06175921f, 0.09393100f, 
    -0.04229233f, 0.02275020f, 0.02945266f, 0.16430332f, -0.05815666f, -0.05178117f, -0.08590417f, 0.04616730f, 
    -0.01944028f, 0.06336115f, -0.12704921f, 0.05214995f, 0.06147122f, 0.14710280f, -0.21650031f, 0.02087488f, 
    -0.07385076f, -0.06781337f, 0.01657453f, -0.06349143f, -0.04072608f, 0.02735783f, 0.01869646f, -0.08772144f, 
    -0.00718141f, 0.03921818f, 0.45207745f, 0.29730356f, 0.14893515f, 0.12680526f, -0.03128637f, -0.25079352f, 
    -0.03877162f, -0.01955025f, -0.05177368f, 0.06010171f, -0.07568237f, 0.06317954f, -0.20336236f, 0.26824757f, 
    -0.02477032f, -0.03577817f, 0.00467662f, -0.01693572f, 0.04028570f, 0.04689954f, 0.04093200f, 0.13813600f, 
    0.37924469f, -0.12951946f, 0.09985452f, 0.16287589f, 0.03823117f, -0.04816604f, 0.07849094f, -0.02710552f, 
    0.12892371f, 0.09394631f, -0.23171599f, 0.15739387f, 0.07029413f, -0.23765282f, -0.03025671f, 0.18761335f, 
    0.25108305f, 0.13135701f, -0.04932479f, 0.04752306f, -0.10630980f, -0.07941682f, -0.19613163f, -0.18914831f, 
    -0.08226522f, -0.01160482f, -0.17923710f, 0.11542537f, -0.11593824f, 0.04151833f, -0.09469414f, 0.00254358f, 
    0.00324548f, -0.01846353f, -0.08471525f, 0.05126750f, -0.01789483f, 0.27356836f, 0.10076996f, -0.35799620f, 
    0.05919303f, -0.06825875f, -0.20446749f, 0.03764773f, -0.04540246f, -0.03085431f, 0.13716179f, -0.05804736f, 
    -0.18243568f, -0.17492431f, 0.03385146f, 0.11760675f, 0.00787270f, 0.03436585f, -0.00570435f, -0.08802994f, 
    -0.09904063f, 0.07502764f, 0.11168929f, 0.08041652f, 0.02204698f, 0.10500448f, 0.14869814f, 0.09194211f, 
    -0.05196502f, -0.06606813f, -0.02061563f, 0.02729903f, 0.01616296f, 0.10450752f, 0.06495164f, 0.13663594f, 
    -0.01869258f, 0.25399023f, 0.10031546f, 0.23495217f, -0.01787808f, -0.00097961f, 0.04427699f, -0.05706926f, 
    0.00703103f, 0.08327321f, 0.13428439f, -0.08703101f, -0.44773135f, 0.08014639f, 0.02027473f, 0.28312978f, 
    0.05361979f, 0.04048186f, -0.11780164f, 0.01161396f, 0.10326380f, -0.21870567f, -0.12225271f, -0.09740088f, 
    0.13086782f, -0.03564490f, -0.10262387f, -0.02016886f, -0.12429635f, 0.08562744f, -0.02216696f, 0.13949537f, 
    -0.02137851f, 0.06693241f, 0.04527984f, -0.08626424f, -0.06359375f, 0.11911871f, -0.01977316f, -0.02797028f, 
    0.04293418f, 0.06396826f, -0.02220699f, 0.02480793f, 0.03808974f, -0.01657243f, -0.00150742f, -0.04114347f, 
    -0.40878439f, 0.06323896f, -0.17887402f, -0.04341065f, 0.10123129f, 0.03583430f, -0.00148188f, 0.11286100f, 
    0.12190153f, -0.02841036f, 0.05869459f, 0.08748576f, 0.35782763f, 0.14114176f, -0.21253394f, -0.08849842f, 
    -0.07645766f, 0.03947397f, 0.07330831f, -0.11328971f, 0.16105852f, 0.07596061f, 0.08159322f, -0.00095855f, 
    -0.02494167f, -0.09669541f, -0.05412288f, 0.17221881f, 0.01992508f, 0.08866151f, 0.15424784f, -0.02656282f, 
    -0.06322400f, 0.06360945f, -0.05986066f, -0.09485052f, 0.00405903f, 0.05698094f, -0.08767903f, -0.03296783f, 
    0.15552868f, -0.09185659f, -0.01690701f, -0.10355072f, -0.06664459f, 0.01306052f, -0.11345529f, 0.00449503f, 
    0.15059397f, -0.02830878f, 0.11930668f, -0.00569384f, 0.02513544f, -0.09936942f, -0.10189936f, 0.08553010f, 
    -0.10734617f, -0.13838916f, -0.03399882f, -0.16549888f, -0.34026748f, 0.47538644f, 0.43062353f, 0.34050375f, 
    -0.06078758f, -0.05748086f, -0.06756087f, -0.01899280f, 0.13746609f, 0.00497049f, 0.03417460f, -0.05855982f, 
    0.22635134f, -0.05403095f, -0.09063328f, 0.03791520f, -0.15966320f, -0.05344963f, -0.03342205f, 0.07393773f, 
    -0.04995890f, 0.07900593f, 0.12291495f, 0.02822385f, -0.18126635f, -0.03694357f, -0.10703932f, -0.24702866f, 
    -0.06701664f, 0.08731602f, 0.01640839f, 0.02509996f, 0.10428457f, -0.09886204f, 0.00080624f, -0.11134333f, 
    0.30391923f, 0.10010992f, 0.02739360f, -0.13637851f, -0.24902971f, 0.16000105f, 0.00466615f, 0.12416402f, 
    0.00526792f, -0.05951740f, 0.19320159f, 0.02460195f, -0.02016113f, -0.07617915f, 0.51487952f, -0.17842166f, 
    0.25340596f, 0.10002773f, -0.08170863f, -0.15031074f, 0.04385294f, 0.04933343f, 0.06160235f, 0.07047227f, 
    0.02583260f, -0.00031195f, -0.00418427f, -0.00906767f, -0.01446043f, -0.00642047f, -0.03501406f, 0.02399457f, 
    0.02229675f, 0.02913876f, -0.01097369f, -0.00510449f, -0.03714210f, -0.01920249f, -0.03148686f, 0.02214774f, 
    0.00412387f, -0.01038127f, -0.00681434f, -0.00387517f, -0.04098265f, -0.01327776f, -0.01412647f, 0.02084823f, 
    0.00513537f, -0.02309862f, -0.04023101f, -0.00881409f, 0.00399353f, 0.00024501f, -0.00953327f, 0.02143949f, 
    0.00466504f, 0.00936139f, -0.00084639f, -0.00112165f, 0.01768316f, -0.02028566f, 0.00953858f, 0.01250019f, 
    0.01352736f, 0.02977357f, -0.01738109f, -0.02995741f, -0.01828080f, -0.02235107f, -0.04073355f, -0.03099060f, 
    0.00870850f, 0.00652515f, -0.02675925f, 0.02999381f, -0.00727115f, -0.02919067f, 0.00898765f, -0.03008146f, 
    -0.01556170f, -0.02346247f, -0.03161262f, -0.03311671f, -0.03860694f, -0.04173569f, -0.03418120f, -0.04179962f, 
    0.01234476f, -0.00813421f, 0.02063526f, -0.02455039f, 0.00098203f, -0.03301714f, 0.02346391f, 0.00729942f, 
    0.00462775f, 0.00369707f, -0.02321252f, 0.01406223f, -0.02632737f, -0.02692666f, -0.01397590f, 0.02491952f, 
    -0.03262385f, -0.01803596f, -0.01875099f, -0.02649701f, -0.02948938f, 0.01281673f, -0.03331404f, 0.02434015f, 
    -0.01990075f, -0.03759271f, -0.03779598f, -0.02963807f, -0.02908445f, 0.00140061f, -0.04066009f, -0.00569583f, 
    -0.02105210f, 0.01686396f, -0.03213391f, 0.01768557f, 0.00359465f, 0.02405376f, -0.01613979f, -0.00898274f, 
    -0.02720860f, -0.00608191f, -0.00714249f, -0.01833600f, -0.02397605f, 0.01856397f, 0.02418432f, -0.02484418f, 
    -0.03306496f, -0.00258515f, -0.01343632f, 0.03651927f, -0.01127225f, 0.00065665f, 0.02951987f, -0.01862302f, 
    -0.01975990f, -0.01894754f, 0.00412950f, 0.02595364f, 0.01713402f, -0.03706243f, -0.00513718f, -0.01234936f, 
    0.00496693f, 0.01008628f, 0.02369278f, -0.02340546f, -0.02984719f, 0.01889694f, -0.00494726f, -0.02343806f, 
    -0.03795736f, 0.01305934f, 0.00349203f, -0.00099198f, -0.00057494f, -0.00291189f, 0.02925903f, -0.01741137f, 
    0.01601065f, -0.03828136f, -0.02511604f, -0.02394629f, -0.02420669f, -0.02432517f, 0.01714022f, -0.03151955f, 
    -0.01165802f, -0.03488839f, 0.02874813f, -0.00972232f, 0.01698227f, -0.02794708f, 0.01927358f, 0.01909817f, 
    0.00944695f, -0.02496567f, 0.02053813f, 0.02798648f, -0.02658975f, -0.02464686f, -0.03923390f, -0.01623807f, 
    0.01607130f, -0.04107275f, -0.00537391f, -0.04011987f, -0.01696010f, 0.01564136f, -0.03307327f, -0.00820191f, 
    -0.03390147f, 0.01039530f, 0.02954875f, -0.03270832f, -0.01386107f, -0.04160550f, -0.00588580f, -0.01528316f, 
    0.00303550f, -0.02012748f, 0.00412733f, 0.02186617f, -0.03197019f, -0.04140151f, -0.00069195f, 0.01291249f, 
    -0.04005350f, -0.02759968f, -0.01299573f, -0.00089070f, 0.02742294f, 0.00056322f, 0.01291963f, 0.02826080f, 
    -0.02376238f, 0.01741495f, -0.00170986f, -0.01875764f, -0.00006511f, 0.00356108f, -0.01118289f, -0.02839275f, 
    0.01134269f, -0.02339090f, -0.03535892f, 0.01272566f, -0.03038191f, -0.02397605f, 0.02775991f, 0.01541927f, 
    -0.00734744f, -0.00546122f, 0.02582967f, -0.02149092f, 0.02383978f, 0.00645923f, -0.01332061f, 0.01655326f, 
    -0.01310219f, -0.00124820f, 0.01881167f, -0.01013475f, -0.02590588f, -0.02774807f, 0.01013797f, -0.01025019f, 
    -0.00806430f, -0.02529775f, -0.02385074f, 0.01177442f, -0.03068628f, 0.00458901f, 0.01874924f, 0.01992232f, 
    0.00476808f, 0.02016447f, -0.01007451f, -0.03316578f, 0.01761159f, -0.01600190f, -0.00504350f, -0.01125491f, 
    -0.00782023f, 0.02447204f, -0.03641822f, -0.02655823f, 0.00824887f, -0.03720327f, -0.00624593f, 0.00809913f, 
    0.02244573f, -0.02630769f, -0.00934010f, 0.02712104f, -0.01348740f, -0.02760539f, 0.00496959f, 0.02496504f, 
    0.01716913f, 0.00465667f, -0.02061003f, -0.01666502f, 0.03002426f, -0.03798830f, -0.00063127f, 0.02143021f, 
    -0.03679893f, 0.01309734f, 0.01945573f, 0.01419569f, 0.02418832f, -0.02839288f, 0.00231057f, 0.00644137f, 
    -0.00679242f, -0.00053287f, 0.01129417f, -0.00291835f, -0.03377292f, -0.03275125f, -0.00456253f, -0.02416668f, 
    0.02830681f, 0.00831284f, -0.03255782f, 0.02099361f, -0.03426097f, -0.04068037f, 0.02005500f, -0.03612744f, 
    -0.00014837f, -0.04153400f, 0.00814719f, 0.02989016f, -0.01672066f, -0.00877739f, -0.01969324f, 0.02775871f, 
    -0.00607394f, -0.02142720f, 0.02763274f, 0.01819298f, -0.02699672f, -0.02865206f, 0.02468117f, 0.01702294f, 
    0.00970586f, 0.01487513f, 0.01391499f, -0.04173683f, -0.03922080f, -0.02963908f, -0.00747252f, 0.00587180f, 
    -0.01804451f, 0.00739826f, 0.02515038f, -0.03155920f, 0.00237109f, -0.03937804f, 0.01597282f, -0.02628644f, 
    -0.02347494f, -0.02105993f, -0.02694446f, -0.01311875f, -0.01814873f, 0.02347616f, 0.02109928f, 0.01172406f, 
    -0.03745610f, -0.03212994f, 0.01884551f, -0.00736546f, 0.01407920f, -0.02501435f, 0.00512445f, 0.02484977f, 
    0.01904729f, 0.02639253f, -0.02765541f, 0.02410708f, -0.02923023f, -0.01049175f, -0.00117361f, -0.03360505f, 
    0.00843809f, -0.02360741f, -0.02088111f, 0.01491497f, -0.02153792f, -0.01398304f, 0.01458301f, 0.02215441f, 
    0.02455261f, -0.04101922f, 0.01939119f, 0.01428097f, 0.00364539f, -0.03855857f, -0.03828362f, -0.00954785f, 
    0.01319386f, -0.04157467f, -0.03436016f, 0.00415647f, 0.01619699f, -0.00014125f, 0.02120548f, 0.02812181f, 
    -0.02463603f, -0.01869005f, -0.00816326f, -0.02421067f, 0.02724382f, -0.02548357f, -0.02602788f, -0.04000602f, 
    -0.02995380f, 0.00068306f, 0.01906479f, -0.00659113f, -0.03182065f, 0.01067773f, 0.02626226f, -0.00774401f, 
    -0.02513253f, -0.01821690f, -0.03549119f, -0.00077855f, -0.03913254f, 0.01957333f, 0.01869889f, -0.01521600f, 
    0.00194756f, -0.01357680f, 0.02252100f, -0.02774960f, -0.00804763f, 0.01628341f, -0.03843069f, -0.02648063f, 
    0.02839329f, 0.00783986f, -0.00554733f, -0.01046913f, 0.00801917f, -0.02569110f, -0.00124651f, 0.01749619f, 
    0.00212458f, -0.02187959f, 0.02135934f, 0.00898900f, 0.00575858f, -0.00784365f, 0.02581109f, -0.03601860f, 
    -0.00395023f, -0.01278655f, -0.01216826f, 0.00314882f, -0.02959419f, -0.01945424f, -0.03859259f, 0.02652214f, 
    -0.03162289f, -0.03600812f, -0.03847936f, 0.01554165f, 0.00295913f, -0.01677282f, -0.00625785f, -0.03416813f, 
    -0.02818485f, -0.00439617f, 0.01921188f, -0.03225409f, 0.01293623f, 0.01248639f, -0.02791849f, 0.00586373f, 
    0.00202303f, -0.00432465f, 0.02097812f, -0.01845990f, 0.00721881f, 0.02024913f, 0.01737249f, -0.03599671f, 
    -0.00467179f, -0.02885319f, -0.01768884f, 0.01565097f, 0.00593882f, -0.00858127f, -0.04077248f, -0.03287582f, 
    0.02444399f, -0.02886137f, 0.02932013f, -0.00350159f, 0.01097380f, -0.01964560f, -0.02725089f, -0.00259716f, 
    0.00805346f, 0.02852263f, -0.00050912f, -0.00072339f, 0.02121125f, -0.00512984f, -0.03779789f, 0.03007882f, 
    -0.00918507f, -0.03561479f, -0.01510429f, 0.01433731f, -0.00738695f, -0.02482215f, -0.02310757f, -0.03807058f, 
    0.00697012f, 0.01144921f, -0.00709875f, 0.02956671f, 0.02252229f, -0.03658390f, 0.02929579f, -0.01874752f, 
    -0.00839606f, -0.00613907f, 0.01817179f, -0.01876502f, -0.02110963f, 0.00453818f, -0.00392305f, 0.00134520f, 
    -0.03449534f, -0.02226036f, 0.01884023f, 0.00309983f, 0.01409392f, -0.01827499f, -0.03544628f, -0.01587416f, 
    -0.04009533f, -0.02456609f, -0.01423860f, 0.01812706f, 0.02514516f, 0.02488126f, 0.00975194f, 0.02529365f, 
    -0.02055192f, -0.02664410f, -0.02959171f, 0.00199048f, 0.00152640f, -0.00880128f, -0.03292983f, 0.01258523f, 
    -0.03198969f, -0.03860382f, 0.00901024f, 0.00780224f, 0.02364314f, 0.02365253f, -0.01852451f, 0.02426048f, 
    -0.03134258f, -0.03656968f, -0.00864625f, 0.00883564f, 0.01930421f, -0.03052738f, 0.02302341f, 0.00192990f, 
    -0.02976049f, -0.01318329f, -0.03350557f, 0.00188785f, -0.03204692f, 0.00861715f, 0.00509793f, 0.00929298f, 
    0.00059694f, -0.03818532f, -0.01211162f, -0.02120299f, -0.01832658f, -0.04189847f, -0.01172554f, 0.02188301f, 
    -0.02737095f, -0.03540768f, -0.02569616f, 0.02283813f, 0.02849112f, -0.03373487f, 0.02277405f, 0.00651808f, 
    0.02031055f, 0.00298452f, 0.01974282f, 0.01633197f, 0.00462571f, -0.01971193f, 0.02290418f, 0.01635341f, 
    -0.01849183f, 0.01397649f, 0.01404390f, -0.00392385f, -0.03319654f, 0.01558927f, -0.00704831f, -0.02710715f, 
    -0.00085352f, -0.04101317f, -0.04094205f, 0.02447643f, 0.02386239f, 0.02823152f, -0.02621366f, -0.02912917f, 
    -0.00225942f, -0.02313022f, -0.03119450f, 0.02301407f, 0.01021088f, 0.01933864f, -0.00735681f, 0.00600600f, 
    -0.02865129f, -0.00323848f, 0.01873254f, -0.02852507f, -0.00882131f, -0.02644954f, 0.00007990f, -0.01145328f, 
    -0.01513258f, -0.03042846f, 0.02610829f, -0.03748923f, -0.00817643f, -0.02698614f, -0.03317320f, -0.02804529f, 
    0.01196337f, -0.03366932f, 0.01819303f, 0.02663626f, 0.02388911f, -0.01090314f, -0.01794817f, -0.00731248f, 
    -0.04095928f, 0.02348877f, -0.02171846f, 0.01664717f, 0.00595841f, -0.01913466f, -0.02324650f, -0.02868099f, 
    0.02620753f, -0.01841298f, -0.03015554f, 0.01520786f, -0.03259015f, -0.00018506f, -0.01531176f, -0.02947011f, 
    -0.04161403f, 0.02216761f, 0.00056255f, -0.02374360f, -0.01831379f, -0.03454252f, 0.01916357f, 0.00046189f, 
    0.00101292f, 0.02123769f, -0.01764431f, 0.01045392f, 0.00472931f, 0.01884154f, -0.01064937f, -0.00254584f, 
    0.01293383f, -0.00703226f, 0.01278687f, -0.02614348f, 0.02318742f, 0.01136386f, 0.01943921f, -0.00465739f, 
    0.02020342f, -0.01188171f, -0.00900687f, 0.00414706f, 0.00585415f, 0.01403117f, 0.01004292f, -0.00117745f, 
    0.00313150f, -0.01693163f, -0.03456679f, -0.02767953f, -0.00558200f, 0.02135166f, 0.02054485f, -0.00332841f, 
    -0.03548077f, 0.01855570f, -0.03245168f, -0.01438910f, -0.01892196f, 0.01184010f, 0.02442305f, 0.00079574f, 
    -0.00159099f, -0.00143445f, -0.01733295f, 0.02970695f, -0.01533615f, -0.02640847f, 0.02843487f, 0.00634611f, 
    -0.01680373f, 0.02866190f, -0.00938380f, -0.03911703f, -0.03738169f, -0.03131382f, -0.04078766f, 0.02246700f, 
    -0.04051991f, -0.00637727f, 0.02997559f, -0.00453470f, 0.00505590f, 0.00266613f, -0.03100199f, -0.03047663f, 
    -0.00521543f, 0.00436998f, 0.01979003f, -0.01647096f, -0.02846808f, 0.01584264f, 0.01017413f, 0.02345590f, 
    0.02170083f, -0.02035031f, -0.00283743f, 0.01641219f, 0.02706763f, -0.01813185f, 0.00134575f, 0.00428137f, 
    0.00513272f, -0.00209669f, 0.01260635f, -0.02854099f, -0.00448022f, -0.03583620f, 0.02537096f, 0.01274460f, 
    0.02957834f, -0.04116165f, 0.01988899f, -0.03672186f, -0.03876175f, 0.02999222f, -0.03186773f, -0.00627057f, 
    -0.04087818f, -0.00231305f, 0.02497515f, 0.01884779f, 0.02593778f, -0.02233158f, -0.03261684f, 0.01791017f, 
    -0.03160012f, -0.02570684f, 0.00781569f, -0.02088326f, -0.02401048f, -0.00030111f, -0.00358227f, -0.03288776f, 
    -0.02104578f, -0.00463585f, -0.03019045f, -0.03105527f, -0.04124629f, -0.03102833f, -0.00796669f, 0.01073472f, 
    0.01206483f, 0.01886255f, 0.25382102f, -0.03687657f, 0.05287503f, 0.01456893f, -0.03779284f, 0.09899665f, 
    -0.00208758f, -0.01821373f, -0.01687824f, 0.18823899f, 0.18519819f, 0.34857404f, -0.06218305f, -0.03928965f, 
    0.15148585f, -0.20984986f, 0.06368889f, 0.15059185f, -0.11711543f, 0.11953568f, 0.21358038f, -0.00939183f, 
    0.06081083f, -0.24411821f, 0.05734293f, 0.28496906f, 0.13609241f, 0.08341382f, -0.17310864f, 0.06663588f, 
    0.03190155f, -0.18383738f, 0.16704851f, -0.00678810f, 0.14446996f, 0.15044783f, 0.05340058f, 0.05994649f, 
    -0.07953321f, -0.03391511f, 0.04461457f, 0.02852935f, 0.21212511f, 0.12161697f, 0.02751891f, 0.30299470f, 
    0.12015032f, 0.20234579f, 0.20722382f, -0.04412695f, -0.03351786f, 0.04717642f, 0.10144566f, -0.02869497f, 
    0.21955958f, -0.14872253f, -0.08725493f, 0.18262783f, 0.06783643f, 0.29960799f, 0.36145160f, 0.24661222f, 
    -0.09671910f, 0.11191599f, -0.07570405f, -0.20085728f, -0.01184607f, -0.03928518f, 0.08710521f, 0.10726900f, 
    -0.13463213f, -0.22483705f, -0.03086627f, 0.11115383f, 0.04489401f, 0.01567199f, 0.00995462f, 0.11035576f, 
    0.09301940f, 0.00482024f, 0.01061352f, 0.09102254f, -0.13028166f, -0.05918426f, 0.22803125f, 0.07189836f, 
    -0.03975452f, 0.04722516f, -0.03363531f, 0.10796688f, -0.12737432f, 0.04623893f, 0.02550734f, 0.01718266f, 
    0.10023578f, 0.04928164f, 0.06195263f, -0.03648110f, 0.08680108f, 0.04398882f, 0.26461592f, 0.07400379f, 
    -0.07289388f, -0.11219298f, -0.15474401f, 0.22765450f, -0.13238990f, 0.05777849f, 0.10189098f, 0.15990260f, 
    -0.09047966f, -0.02948322f, -0.15856107f, 0.09266574f, -0.12328880f, -0.13813199f, 0.16914088f, -0.07598943f, 
    -0.04458334f, -0.25346354f, 0.06530806f, -0.13245466f, -0.05987079f, 0.10257048f, 0.02910400f, 0.07885011f, 
    -0.13120863f, 0.00189229f, 0.06319068f, -0.03563486f, -0.41052690f, 0.20752783f, -0.01636878f, -0.20157050f, 
    -0.12263403f, -0.13279320f, 0.08374774f, 0.16317591f, -0.10201639f, 0.06654893f, 0.07577507f, -0.16227880f, 
    0.15601489f, 0.38430637f, 0.04613719f, -0.24695253f, 0.08183318f, 0.01915768f, -0.07142409f, 0.18025866f, 
    0.03236013f, -0.04739128f, 0.04804891f, -0.08815445f, -0.03324794f, -0.14040990f, -0.09281716f, -0.10138789f, 
    -0.00037107f, -0.07307713f, -0.12589437f, 0.17756255f, 0.20269525f, -0.27185905f, 0.19787282f, -0.08899654f, 
    0.09410247f, -0.17121522f, -0.13473479f, 0.29382464f, 0.06611756f, 0.02714390f, 0.07226937f, -0.02704881f, 
    0.24508597f, 0.05572373f, -0.22313072f, -0.00470769f, 0.10170469f, 0.00727606f, 0.13530773f, -0.03516006f, 
    -0.05705192f, 0.05586394f, 0.01630271f, -0.02756950f, -0.05376030f, -0.03298617f, -0.00112608f, -0.13331699f, 
    -0.29182628f, -0.15386415f, -0.16654922f, -0.08438797f, -0.12099672f, -0.10542671f, -0.14318404f, -0.04192937f, 
    0.15562607f, -0.12158487f, 0.03620611f, -0.07118633f, 0.32689577f, 0.15619782f, -0.22754788f, 0.10872121f, 
    -0.08179045f, -0.07843088f, 0.12780838f, -0.01651986f, -0.03160160f, 0.03270222f, 0.00417773f, -0.03412751f, 
    0.00027699f, -0.06361903f, 0.05801721f, 0.09756611f, -0.08487424f, 0.02573352f, 0.11784352f, 0.02996456f, 
    -0.10845366f, 0.04241917f, 0.09660977f, 0.01878173f, 0.14854714f, 0.16952842f, 0.14772423f, 0.09311078f, 
    0.01774027f, 0.02265204f, -0.05921827f, 0.02161942f, 0.09224908f, 0.02807232f, 0.03954547f, -0.13881731f, 
    0.21064143f, 0.24168089f, 0.07056828f, 0.07725953f, 0.05567523f, -0.00131050f, -0.01678622f, 0.05564772f, 
    0.08671874f, 0.04822468f, 0.05781025f, -0.00335223f, 0.12231582f, 0.04966251f, -0.01331880f, -0.03261609f, 
    0.12475953f, -0.08025885f, 0.05048790f, 0.02894040f, -0.15131827f, -0.21896107f, -0.06223910f, -0.28511146f, 
    -0.12906501f, 0.08964427f, 0.11279825f, -0.02747231f, -0.05039263f, -0.04288209f, -0.01185955f, -0.10451721f, 
    -0.19189698f, -0.07110967f, -0.07275476f, -0.15494934f, -0.18726349f, 0.18315287f, 0.04296954f, 0.02479084f, 
    -0.20862590f, 0.08895788f, 0.12302280f, 0.13472219f, -0.15670146f, 0.11273190f, 0.05584832f, 0.05317260f, 
    0.00284722f, -0.04165589f, -0.14759527f, 0.11358221f, -0.11442382f, 0.01084176f, 0.05409044f, 0.08875114f, 
    0.07061621f, -0.05868404f, 0.03107090f, -0.11750166f, 0.09401074f, -0.02335977f, 0.00648647f, 0.05848423f, 
    -0.04182775f, -0.04281836f, 0.08502737f, -0.11265511f, 0.01733183f, -0.03295093f, -0.14166068f, 0.00590231f, 
    -0.01667709f, 0.33972436f, 0.26890182f, 0.13407478f, -0.10538703f, -0.09923264f, 0.04177259f, 0.03761828f, 
    -0.10431180f, 0.10250681f, 0.09453158f, 0.06407605f, -0.20541523f, 0.27772066f, -0.04474834f, -0.21640106f, 
    -0.12971275f, -0.08359942f, -0.17772995f, -0.03933100f, -0.03952463f, 0.04153823f, -0.14752370f, -0.15303783f, 
    0.00406367f, 0.05709272f, 0.02011567f, 0.05897430f, 0.10503639f, 0.10644206f, 0.16083193f, -0.00818270f, 
    0.03302639f, 0.06641581f, 0.02005029f, -0.00530053f, -0.05203190f, 0.10297484f, 0.17486002f, 0.00804636f, 
    0.08685047f, 0.02243608f, 0.10563111f, -0.03835450f, 0.07058734f, -0.03672617f, -0.12346286f, -0.17065164f, 
    0.17393205f, 0.02161637f, -0.08344692f, -0.04708527f, 0.13363926f, 0.09351635f, 0.11460798f, 0.06394108f, 
    -0.07177075f, -0.06829610f, 0.06129076f, -0.16423260f, 0.04185034f, 0.11684690f, 0.17274626f, 0.03593782f, 
    0.04833605f, -0.10731117f, -0.06881075f, 0.06341693f, -0.04817534f, 0.08338548f, -0.04166717f, 0.09139141f, 
    -0.01003263f, 0.23530562f, 0.06277584f, -0.16428177f, 0.00673288f, 0.05952882f, 0.06386098f, 0.14726725f, 
    0.06970951f, -0.25750804f, -0.19549836f, -0.26111329f, -0.25795731f, -0.08411329f, -0.27982792f, -0.33181009f, 
    -0.05739713f, -0.00549602f, -0.02227662f, 0.05514846f, 0.05812655f, -0.14563422f, 0.03058298f, -0.20607325f, 
    0.23340106f, -0.13525693f, -0.09922376f, -0.23523083f, 0.05640528f, -0.09755466f, -0.13050811f, 0.06879426f, 
    -0.00481782f, -0.11682548f, -0.18548948f, -0.20756744f, -0.28295925f, 0.13603614f, 0.13872521f, 0.02682318f, 
    -0.02942246f, -0.18699484f, 0.03755521f, 0.15027627f, -0.19128181f, -0.03505630f, 0.03972797f, -0.17561767f, 
    0.24679631f, -0.10198224f, 0.17666118f, -0.02350824f, 0.03647714f, 0.14017960f, -0.00276169f, 0.13217030f, 
    0.21333256f, -0.12165107f, 0.17017432f, 0.02299666f, -0.01339415f, -0.02644530f, 0.22153956f, 0.03582342f, 
    0.07759356f, 0.19271991f, 0.22334899f, 0.06138269f, -0.02268181f, -0.08656949f, 0.03533059f, 0.13692829f, 
    -0.54903603f, -0.10269596f, 0.08405764f, -0.29057348f, -0.27020979f, 0.16815902f, -0.23961745f, -0.08376423f, 
    -0.14223164f, -0.11932969f, -0.25908414f, -0.32342583f, -0.09581724f, 0.15281925f, 0.22673263f, 0.08410202f, 
    0.04864089f, 0.02594580f, 0.09124342f, -0.08144990f, 0.00097572f, -0.02215474f, 0.21325052f, 0.07002605f, 
    0.13230465f, -0.18704145f, 0.36641237f, 0.12949853f, 0.07705666f, 0.12722063f, -0.09471826f, -0.07605673f, 
    -0.00224038f, -0.10009816f, 0.23602872f, -0.03043157f, 0.36339235f, 0.13087669f, -0.05130149f, 0.19701695f, 
    0.04544376f, -0.12748438f, 0.19240338f, 0.02987691f, 0.03356893f, 0.09196991f, 0.17283031f, 0.11681711f, 
    0.30639818f, -0.15026771f, -0.17150322f, 0.19669847f, -0.03529584f, 0.00170656f, 0.01162501f, 0.09839413f, 
    0.02056681f, 0.03993785f, 0.06041905f, -0.15817821f, 0.19587868f, 0.06702811f, 0.03411929f, 0.18016960f, 
    0.12870586f, -0.11130354f, 0.07870111f, 0.22111805f, 0.24127382f, 0.16926956f, 0.24847344f, -0.06453358f, 
    -0.32227692f, -0.06527512f, -0.02228063f, -0.09420177f, -0.18260029f, -0.12036602f, 0.05000269f, -0.05045952f, 
    -0.12498385f, -0.03518273f, 0.24287641f, -0.20981503f, 0.06483595f, -0.00295639f, 0.07051863f, 0.01393119f, 
    -0.06152715f, 0.06323742f, -0.07164253f, 0.12088114f, -0.08015168f, 0.07605094f, 0.05738760f, 0.06257166f, 
    -0.07902220f, 0.07752459f, 0.10925808f, 0.08524399f, -0.04353374f, 0.21209271f, 0.10192191f, 0.26373202f, 
    0.00328827f, 0.07145686f, 0.14880370f, 0.11150933f, -0.02387150f, 0.10214559f, 0.32188335f, 0.27616316f, 
    -0.04352799f, -0.01072697f, 0.04861910f, -0.06661583f, 0.05469745f, 0.12827356f, 0.20062898f, 0.06276792f, 
    -0.17475678f, -0.04104842f, 0.06831009f, 0.09620810f, -0.07615041f, -0.01292102f, -0.02965132f, -0.05386647f, 
    -0.09779398f, -0.11034337f, 0.01094195f, -0.13519959f, -0.15320756f, 0.04244642f, 0.10435316f, -0.16877159f, 
    0.02573311f, -0.00813757f, -0.00540348f, 0.16418414f, -0.02266765f, -0.26054600f, -0.05115172f, -0.27802840f, 
    0.22516967f, -0.32451802f, 0.21866447f, -0.02470636f, -0.10154244f, 0.13123003f, 0.01694364f, -0.06367642f, 
    -0.05006173f, -0.16316669f, 0.01105306f, 0.15627617f, 0.20883565f, -0.17439181f, 0.15118156f, -0.17597884f, 
    -0.19546984f, 0.26057535f, 0.06212717f, 0.15076318f, 0.00875931f, 0.04628202f, 0.06277696f, 0.07066213f, 
    0.45628580f, 0.15327758f, -0.15514323f, -0.15685861f, -0.01118625f, 0.00390247f, -0.01238964f, 0.16003290f, 
    0.03598982f, -0.01874723f, 0.02485533f, 0.03892066f, 0.33064663f, 0.06294996f, 0.01338615f, 0.10664555f, 
    -0.00074366f, -0.03376898f, -0.03624319f, -0.05412100f, 0.18056974f, -0.03951418f, -0.02907229f, -0.04199658f, 
    0.23958363f, 0.35551316f, 0.04240564f, 0.15403028f, -0.06936976f, -0.03032654f, -0.03154204f, -0.04029788f, 
    0.11948631f, -0.09587120f, -0.09151296f, -0.02331925f, 0.08104817f, -0.03972628f, 0.00566462f, -0.09028281f, 
    0.04905587f, 0.01770029f, 0.07917189f, 0.06352561f, -0.06196377f, -0.10777445f, -0.08828510f, -0.07816920f, 
    0.02969039f, 0.01900101f, 0.10585608f, 0.31572220f, 0.02454755f, 0.02736307f, 0.06499410f, -0.10449643f, 
    0.03415662f, -0.15982129f, -0.07163993f, 0.17403795f, 0.16156971f, 0.13593067f, -0.01991772f, 0.00565048f, 
    -0.10396376f, -0.00604848f, 0.03821048f, 0.08543222f, 0.06812688f, -0.06696928f, -0.07030500f, 0.11280475f, 
    0.03424959f, 0.01786887f, 0.02849252f, 0.10038950f, -0.02037073f, 0.13745825f, 0.01047557f, 0.00731737f, 
    0.08956022f, -0.08966751f, 0.09978373f, 0.11107034f, 0.12383973f, -0.36265957f, -0.17925839f, -0.25569910f, 
    -0.10267658f, -0.00700211f, -0.15522766f, -0.06579416f, 0.07083879f, -0.03122491f, -0.08565155f, -0.12720594f, 
    0.16142400f, 0.05606265f, 0.16337709f, 0.19822779f, -0.01579243f, -0.10040396f, 0.04661694f, -0.05120614f, 
    0.13147770f, 0.07349441f, 0.12482304f, -0.03729897f, 0.22347298f, 0.20412262f, 0.11144125f, 0.11405247f, 
    -0.03978910f, -0.05601853f, -0.10314696f, -0.12000250f, 0.09448227f, 0.03444223f, -0.03821256f, -0.00697918f, 
    0.06250408f, -0.02636433f, 0.10035791f, -0.01625477f, -0.07332201f, -0.03585374f, -0.07428481f, -0.11451354f, 
    0.07835673f, -0.11392563f, -0.00646725f, -0.00847377f, 0.27750808f, -0.07205561f, -0.13945210f, 0.11425123f, 
    -0.01520375f, 0.08069285f, 0.09618304f, 0.03064839f, 0.03390181f, -0.00047717f, 0.17232808f, 0.04221706f, 
    0.00123290f, -0.01643330f, -0.04227730f, -0.01703803f, -0.02966376f, 0.01880021f, 0.01838468f, 0.01223052f, 
    -0.02481173f, 0.00325009f, -0.00448583f, 0.02390670f, 0.00783443f, 0.02210139f, 0.01412978f, 0.00793718f, 
    -0.02582323f, -0.03893749f, -0.03893930f, 0.01821402f, -0.02933648f, -0.00907256f, -0.02924904f, 0.01416381f, 
    -0.02421051f, -0.00310692f, -0.00268232f, -0.02657991f, -0.01176010f, 0.00902774f, -0.03737338f, -0.04055410f, 
    0.00413930f, 0.00736950f, -0.02611056f, -0.03089610f, -0.03160078f, -0.02838360f, 0.00086103f, 0.02990625f, 
    0.00627950f, 0.01969657f, -0.01162304f, 0.02113184f, 0.00230972f, 0.02092736f, -0.03668296f, 0.01488394f, 
    -0.00387937f, -0.03934698f, 0.01246817f, -0.01201760f, -0.00455183f, -0.03439825f, -0.00476370f, 0.01027458f, 
    0.01048745f, -0.02949035f, -0.03681723f, -0.01474903f, -0.00551144f, 0.00902338f, 0.01920208f, -0.04186436f, 
    0.01960313f, -0.01919650f, 0.01028562f, -0.03079942f, -0.03827979f, 0.02373068f, -0.02093145f, 0.02523329f, 
    0.02986407f, 0.00995786f, 0.00487829f, -0.00931018f, -0.01426249f, -0.02350446f, -0.00041093f, -0.02336784f, 
    -0.01230673f, -0.02664604f, 0.00138464f, -0.02200169f, 0.01483796f, 0.02106424f, -0.02635649f, -0.01927744f, 
    0.00096346f, -0.01542136f, 0.01864089f, -0.02406683f, 0.02262146f, -0.03663231f, -0.02219209f, -0.03452178f, 
    -0.00701818f, -0.00498180f, -0.00312245f, -0.02248496f, 0.02801021f, -0.02044860f, -0.01595244f, 0.02598677f, 
    -0.04508546f, -0.02268770f, -0.02839399f, -0.03681448f, -0.02819349f, -0.00274554f, -0.01218442f, -0.01151288f, 
    0.01114113f, -0.00491377f, 0.01772812f, 0.01485319f, -0.00713632f, -0.02602893f, 0.00863050f, 0.00349636f, 
    -0.04503598f, -0.03473423f, -0.00969043f, -0.02046186f, 0.01810045f, 0.00369570f, -0.00349743f, -0.00540796f, 
    -0.02822587f, -0.03308319f, 0.01010393f, -0.01403020f, 0.02466943f, -0.00429681f, -0.02481921f, 0.02013211f, 
    -0.03548546f, 0.01898101f, -0.03094293f, -0.01577852f, -0.02408747f, 0.00248319f, 0.00518192f, -0.01874243f, 
    0.00743940f, -0.01531632f, -0.00075495f, -0.00254405f, -0.02761702f, -0.00669199f, -0.01613671f, 0.00070458f, 
    -0.02124563f, 0.02643131f, -0.03468769f, 0.00353787f, 0.01435521f, 0.03102036f, 0.02840189f, -0.03772820f, 
    -0.01805190f, 0.01439944f, -0.00262945f, -0.01634945f, 0.01891676f, -0.03078735f, -0.01069868f, -0.02211242f, 
    0.02649317f, 0.01682430f, -0.04084248f, 0.00038230f, -0.04555311f, -0.04051407f, -0.02696750f, -0.01489328f, 
    -0.02610667f, 0.01431897f, 0.01641629f, 0.00940864f, -0.03647055f, -0.01103298f, 0.01635169f, -0.00465452f, 
    -0.01477649f, -0.00903435f, -0.01435170f, -0.03751041f, -0.02223998f, -0.02505937f, 0.02750678f, -0.03242854f, 
    -0.03211993f, -0.00026694f, -0.04321279f, -0.03836858f, -0.00129689f, -0.04424862f, 0.02597208f, -0.03791775f, 
    -0.02070422f, 0.00678016f, -0.00532629f, -0.02129382f, -0.00979597f, -0.02487122f, 0.01944053f, -0.03002848f, 
    0.01248565f, 0.01358675f, -0.04462864f, -0.02401327f, -0.03871002f, 0.01621810f, 0.00911805f, 0.01795445f, 
    0.00284191f, -0.03932746f, 0.02537193f, 0.02720907f, -0.02275810f, 0.03014367f, -0.01810413f, -0.04383356f, 
    0.01433555f, -0.02867388f, -0.01458834f, -0.00961134f, -0.03115211f, 0.02658990f, 0.02016350f, 0.00937733f, 
    -0.00993997f, -0.03760785f, 0.01791460f, -0.01692662f, -0.00050048f, 0.02322330f, -0.01001550f, 0.01940635f, 
    -0.01510724f, 0.01720299f, 0.00923092f, -0.02560319f, 0.02243789f, 0.01993352f, -0.00851139f, -0.00944075f, 
    0.01239210f, -0.00995993f, -0.01675432f, 0.01506673f, -0.01297347f, 0.01581215f, -0.02008201f, 0.01559395f, 
    -0.03065171f, -0.03689661f, -0.00838389f, -0.03222672f, -0.01501277f, -0.03308131f, -0.01460431f, -0.03482417f, 
    -0.02888911f, -0.02543563f, -0.02164753f, -0.02820507f, -0.00688032f, -0.04418133f, -0.02614664f, -0.03759080f, 
    0.02630311f, -0.03288556f, 0.01570439f, 0.00798767f, 0.02924874f, -0.03747839f, 0.02332239f, 0.01185128f, 
    -0.03776617f, -0.00071213f, -0.01891604f, 0.01238483f, -0.03866224f, -0.03628204f, 0.00815206f, -0.04445621f, 
    0.02451771f, -0.03130588f, 0.02439647f, -0.01566017f, -0.00595330f, -0.01996179f, 0.01584160f, 0.01282979f, 
    -0.02111724f, -0.03306363f, -0.00178542f, 0.01049841f, -0.03339517f, -0.04137197f, -0.03591626f, -0.00387510f, 
    0.01027850f, -0.01345194f, -0.00233332f, -0.00585971f, 0.01762983f, -0.03386313f, -0.00880406f, 0.00898808f, 
    -0.02989065f, -0.03346172f, -0.04244215f, 0.02097213f, -0.03739478f, 0.02253230f, -0.00657043f, 0.00049475f, 
    -0.02343998f, 0.01045642f, 0.02660794f, -0.02020544f, -0.00540706f, -0.00696600f, 0.00586042f, 0.00558596f, 
    0.01037888f, 0.00862197f, 0.01260136f, -0.04030515f, 0.02513878f, 0.01261261f, 0.00231166f, 0.02597539f, 
    0.00241588f, 0.01982862f, -0.01606378f, 0.02033027f, -0.02493140f, -0.02357417f, -0.04274550f, 0.01849131f, 
    0.03260653f, -0.00583427f, -0.03414862f, 0.02220529f, -0.00390188f, 0.00463590f, -0.02404874f, -0.01089427f, 
    -0.03673894f, -0.03363484f, -0.03901225f, -0.02266195f, -0.02509967f, -0.02232644f, -0.04294037f, 0.02347517f, 
    0.00027827f, 0.01214710f, -0.02465042f, -0.00139673f, -0.02200129f, -0.01425233f, -0.00675384f, -0.04093444f, 
    -0.00081102f, 0.02527406f, 0.01291734f, -0.02096083f, -0.04183556f, -0.00841318f, 0.00609640f, -0.01607237f, 
    -0.02877322f, -0.03613119f, 0.01896661f, -0.04301943f, -0.00990146f, -0.03998332f, 0.01773396f, -0.00717699f, 
    -0.01217803f, 0.02163924f, 0.00386779f, -0.03799862f, 0.01116090f, -0.01208725f, 0.02356018f, -0.01559169f, 
    -0.01421293f, 0.02327804f, -0.03563546f, -0.02549968f, 0.01940047f, -0.01079257f, -0.02833983f, 0.01032926f, 
    -0.02459452f, -0.02872141f, -0.00358508f, -0.04331447f, -0.03402116f, 0.00246028f, -0.01738512f, 0.02330175f, 
    0.01891063f, -0.03323660f, -0.01867093f, 0.00837179f, -0.00952947f, -0.01611158f, 0.01753475f, 0.01156545f, 
    -0.01354044f, 0.00373949f, 0.00302167f, 0.00178224f, -0.00573441f, -0.01893789f, -0.04033473f, -0.03060832f, 
    -0.01727237f, -0.03468778f, -0.04371683f, -0.01331054f, 0.01898701f, -0.00284942f, -0.00249668f, -0.03893218f, 
    -0.01355124f, -0.01035328f, -0.04335677f, 0.02515846f, -0.02007975f, -0.01650247f, -0.03176316f, -0.02983286f, 
    -0.01852521f, -0.03321069f, 0.02159349f, -0.00388310f, 0.01038630f, 0.00359517f, 0.01621238f, -0.03862983f, 
    -0.01824043f, -0.03297282f, -0.03797556f, 0.01876636f, -0.00945290f, -0.01886818f, -0.03531542f, -0.02238057f, 
    -0.02404993f, 0.02743123f, 0.02556042f, -0.02149558f, -0.04058956f, -0.01073264f, 0.01818141f, 0.01431769f, 
    0.00405649f, -0.03744683f, -0.00108548f, -0.01173048f, 0.00418855f, -0.02483037f, -0.04090781f, -0.01816551f, 
    -0.04219606f, 0.00080639f, 0.00160217f, 0.02184203f, -0.03508490f, 0.00954444f, 0.01532167f, -0.01821642f, 
    -0.02744098f, -0.01082271f, 0.01420335f, -0.00115156f, -0.00297935f, -0.02690959f, -0.00759183f, -0.04422860f, 
    -0.02991710f, 0.00084934f, 0.01614748f, 0.00865513f, 0.02363066f, -0.02268869f, -0.00239078f, 0.00887856f, 
    0.00437912f, -0.00248369f, 0.02113321f, -0.03808542f, -0.00058308f, 0.02306951f, -0.02068000f, -0.00654184f, 
    -0.02672926f, -0.02945743f, -0.00595638f, -0.02098050f, 0.02666875f, 0.02480731f, -0.00767291f, 0.01230682f, 
    -0.00011138f, 0.02984440f, -0.00471814f, -0.00351097f, 0.01828948f, -0.01663978f, -0.02562112f, -0.01570071f, 
    -0.01153094f, -0.03427139f, -0.00981585f, -0.00994956f, -0.00551726f, 0.02930634f, 0.02068783f, -0.03192465f, 
    0.02627915f, 0.01532462f, -0.00828843f, -0.02761264f, -0.03121510f, -0.02849709f, 0.01761045f, 0.01019509f, 
    -0.03475938f, 0.02250867f, -0.02188936f, -0.02054784f, -0.01926997f, 0.02169561f, -0.02046229f, -0.00579744f, 
    0.01414540f, -0.00359056f, 0.01701588f, -0.00438703f, 0.00072675f, -0.01175824f, -0.00863787f, -0.01803152f, 
    0.02172206f, 0.01350334f, 0.00869155f, 0.00889105f, 0.02303517f, -0.01554662f, 0.00165887f, -0.01692635f, 
    -0.00617067f, 0.02451059f, -0.03074840f, 0.01088204f, 0.01892168f, -0.00295804f, 0.01210915f, -0.03535481f, 
    0.01699934f, -0.00313355f, -0.00865344f, -0.00282332f, -0.04526057f, -0.00103039f, -0.00192563f, 0.01170955f, 
    -0.02917854f, -0.02575232f, 0.00453503f, 0.01878956f, -0.03866397f, 0.00993950f, -0.01751051f, -0.01300131f, 
    -0.03333565f, 0.01049782f, -0.03793589f, -0.00034514f, 0.00840354f, -0.01656962f, 0.00285126f, 0.01694547f, 
    -0.03816022f, -0.02841272f, -0.01343097f, -0.01849487f, -0.00239562f, -0.04031752f, -0.02757999f, 0.01536864f, 
    -0.04328015f, -0.02818886f, -0.01698013f, 0.02462570f, -0.02153345f, -0.03616675f, 0.00425376f, -0.01548251f, 
    0.00151314f, -0.03843679f, 0.01750971f, 0.00731980f, -0.00165477f, 0.00643120f, -0.03058355f, 0.01316389f, 
    -0.00136278f, -0.04271875f, -0.01397123f, 0.00188365f, -0.00613838f, -0.01230772f, -0.02166623f, 0.02563290f, 
    -0.02352544f, -0.01685867f, -0.03811670f, 0.00613834f, -0.01711410f, -0.00488038f, -0.00124004f, 0.01499820f, 
    -0.00399402f, -0.02736303f, 0.02592799f, -0.00652808f, -0.03135826f, -0.00762103f, -0.00099177f, -0.03656767f, 
    -0.00925447f, 0.01931354f, 0.01547801f, 0.00448155f, 0.00939453f, -0.00958312f, -0.01320592f, -0.03890898f, 
    -0.03866461f, -0.03279787f, -0.01279579f, -0.03415993f, -0.01138435f, -0.02438000f, -0.00602385f, -0.02738145f, 
    0.01966249f, 0.00226243f, -0.02606896f, 0.02822760f, 0.02160145f, 0.03288938f, -0.02602363f, -0.01556956f, 
    0.02104130f, 0.01934101f, -0.04317506f, -0.03059697f, 0.00982262f, -0.02954531f, -0.03852653f, 0.00069641f, 
    0.00664700f, -0.01388366f, -0.01031842f, -0.02179651f, -0.01867358f, 0.00260946f, 0.01524044f, -0.04260615f, 
    -0.01340980f, 0.01099700f, -0.02347259f, -0.02210242f, 0.02442035f, -0.01280380f, -0.02065962f, 0.01331801f, 
    0.00656796f, 0.00646426f, 0.02032945f, -0.01208434f, -0.02842529f, 0.01620214f, 0.00489074f, -0.02997709f, 
    0.01432068f, 0.01709491f, 0.01081601f, 0.02751631f, 0.02436089f, 0.00874971f, -0.01803850f, 0.01690177f, 
    0.01959341f, -0.00171561f, 0.00605946f, -0.01190695f, 0.00502176f, -0.03524090f, -0.00690938f, -0.00804734f, 
    -0.01620466f, 0.01477579f, 0.00897103f, 0.00741449f, -0.00067416f, 0.01923105f, -0.01817932f, 0.00380522f, 
    -0.01221555f, 0.00809527f, -0.03403987f, -0.00586450f, 0.00355507f, -0.00547575f, -0.02619162f, -0.04358499f, 
    -0.02957775f, 0.00128904f, -0.01296094f, 0.02368081f, -0.00158652f, -0.04447861f, 0.01802596f, -0.00053368f, 
    -0.03969034f, -0.01261989f, 0.00239654f, 0.00621483f, -0.01546891f, -0.01265218f, -0.01265737f, -0.00332212f, 
    0.00788590f, 0.00795215f, -0.03899858f, 0.00527154f, -0.01963990f, 0.01496450f, 0.00511461f, 0.00417327f, 
    0.01087001f, 0.02802874f, -0.01609697f, -0.02301969f, 0.02349441f, 0.00375746f, 0.02366329f, -0.01974818f, 
    -0.02834737f, -0.03524347f, -0.00771312f, 0.00213035f, -0.01075784f, -0.01429259f, 0.00554725f, -0.03171071f, 
    0.00767940f, -0.00685055f, -0.03542681f, 0.02697856f, -0.00905936f, 0.00814436f, -0.02854231f, -0.03256813f, 
    0.02046114f, 0.02124793f, -0.00117001f, 0.02482393f, -0.00638616f, -0.03084505f, 0.00430524f, -0.02874890f, 
    0.02221658f, -0.02151870f, 0.00951712f, 0.02972634f, 0.01653137f, -0.02315467f, 0.00653954f, -0.03690656f, 
    0.01164729f, 0.00576298f, -0.00869972f, -0.01048467f, 0.00428110f, 0.01960805f, 0.01297060f, -0.00917519f, 
    -0.00005517f, 0.02198965f, -0.03855090f, -0.02215190f, -0.00015569f, 0.00280922f, -0.04105068f, 0.00400642f, 
    0.00785286f, 0.02513625f, -0.00757607f, -0.02959551f, 0.00936363f, -0.00205217f, 0.03795717f, 0.01363802f, 
    -0.01180183f, 0.02216711f, -0.02547646f, -0.02451130f, -0.03143631f, -0.01763958f, 0.00205412f, -0.01994300f, 
    -0.00131985f, -0.00864417f, 0.00827654f, 0.01813171f, 0.01110391f, -0.01917526f, -0.03066170f, -0.02577409f, 
    0.01108624f, 0.01052014f, -0.01827928f, -0.00881983f, -0.02595087f, 0.04060031f, 0.03237800f, 0.02765194f, 
    0.01560145f, 0.01744361f, -0.02556441f, -0.02484731f, -0.02470598f, 0.02012556f, -0.01424397f, -0.00914775f, 
    -0.03526855f, -0.01791182f, 0.00531109f, -0.02172096f, -0.01618800f, 0.00007237f, -0.02317260f, 0.01542835f, 
    -0.01619642f, 0.00464520f, 0.00304426f, 0.02560060f, 0.00202916f, 0.00995623f, 0.01015150f, 0.01813384f, 
    0.02035899f, 0.01373223f, 0.01906891f, 0.00865827f, 0.01952169f, 0.02657659f, 0.01446035f, -0.01419802f, 
    0.00711007f, -0.01046774f, -0.02739083f, 0.01537745f, 0.01499573f, 0.02129428f, 0.01294806f, -0.01971817f, 
    -0.00296468f, 0.00596788f, -0.02157441f, 0.01602492f, 0.00414797f, -0.03255129f, 0.00947899f, 0.02163535f, 
    0.01503921f, 0.00933440f, 0.00996430f, -0.00503311f, 0.02209065f, 0.00592356f, -0.02761473f, -0.01918085f, 
    -0.04103997f, -0.02339892f, 0.02971656f, -0.02480541f, -0.03483503f, -0.01148965f, -0.02871757f, 0.01974485f, 
    0.00056559f, 0.01688937f, -0.02149935f, -0.02924542f, 0.02769022f, -0.02304175f, -0.03885204f, -0.02935608f, 
    -0.01885529f, 0.00333579f, -0.02224573f, 0.02453862f, -0.03614639f, -0.01195880f, -0.00254000f, -0.03512852f, 
    -0.01086745f, -0.01201894f, 0.02545659f, 0.02947546f, 0.01952992f, 0.00165028f, 0.00946158f, -0.03672862f, 
    0.02426016f, 0.00174709f, -0.01534227f, -0.00063601f, -0.02347551f, 0.02753918f, 0.01533354f, -0.02441814f, 
    0.01390833f, 0.00057092f, 0.01816341f, 0.00556739f, -0.04109085f, 0.03146094f, -0.00901433f, 0.01466920f, 
    -0.00220560f, 0.01091114f, -0.02656956f, -0.02790440f, -0.01074276f, 0.00849425f, 0.02168445f, -0.00422663f, 
    0.01932996f, -0.03762862f, -0.03799740f, 0.02255044f, 0.02042805f, -0.01406253f, -0.00485599f, -0.04017851f, 
    -0.02794563f, -0.03406625f, -0.03980581f, 0.00228318f, -0.02639004f, -0.00297491f, -0.00943999f, -0.01594200f, 
    -0.03221858f, 0.00422127f, -0.00365481f, -0.04012903f, -0.02915165f, 0.00002849f, -0.02612863f, -0.02322180f, 
    0.02984192f, -0.03361369f, -0.04089420f, 0.01086565f, 0.00353676f, -0.01794297f, 0.02634835f, -0.01056021f, 
    -0.00761934f, 0.01692811f, -0.03031064f, -0.03360151f, 0.03227214f, -0.02885510f, -0.00027050f, 0.02648631f, 
    0.04035403f, 0.00527517f, 0.02655163f, 0.02310412f, -0.00994549f, -0.04189953f, -0.01090163f, 0.00432364f, 
    -0.00068901f, -0.02205194f, 0.00807883f, -0.01464965f, -0.00215779f, 0.00971727f, 0.01444534f, 0.01776377f, 
    -0.01921136f, -0.01545241f, 0.00193519f, 0.03420809f, 0.00643774f, 0.03522871f, -0.00946751f, -0.03566355f, 
    0.00628247f, -0.00831233f, 0.01309601f, 0.02779315f, -0.01349060f, 0.00758261f, 0.02563209f, 0.02073985f, 
    0.01994226f, 0.02279572f, -0.02271004f, 0.02869911f, -0.03910803f, -0.03974077f, 0.01454892f, 0.02590271f, 
    0.02689209f, -0.01656786f, -0.00055838f, 0.00486598f, 0.01621058f, 0.03923771f, -0.00475719f, 0.00140203f, 
    -0.00176938f, -0.03941421f, 0.01543699f, -0.03622388f, 0.01309622f, -0.00081686f, -0.01111563f, -0.00369969f, 
    0.02399793f, 0.00713642f, 0.00464415f, 0.00187261f, -0.02525581f, -0.01553811f, 0.00250502f, 0.00548809f, 
    0.00984744f, 0.01596032f, 0.02709490f, -0.00791542f, -0.01613186f, -0.02545502f, 0.02052907f, 0.01125689f, 
    -0.01897695f, -0.03673932f, 0.00622335f, 0.01286875f, 0.02592140f, -0.01662228f, -0.00737453f, -0.03082112f, 
    -0.01067624f, -0.00425727f, -0.03741854f, -0.02381328f, 0.00457921f, 0.02897602f, -0.01727200f, 0.01389286f, 
    -0.02783480f, -0.00354484f, 0.00953360f, -0.01826780f, -0.02993855f, 0.01882232f, 0.02244455f, -0.01909266f, 
    -0.04190551f, -0.02553377f, -0.02276596f, 0.00451162f, 0.00138254f, -0.02931054f, -0.00075085f, -0.00166980f, 
    -0.03013374f, 0.00950380f, 0.02306604f, -0.02492851f, 0.01225783f, -0.00780862f, -0.02471785f, -0.02615037f, 
    -0.01157117f, 0.00746650f, -0.02374204f, 0.02251438f, 0.01385013f, 0.00211224f, -0.00149204f, 0.02390563f, 
    0.02489525f, -0.00756099f, -0.00405317f, 0.02593876f, -0.01646115f, -0.00650355f, -0.03414891f, -0.01008126f, 
    -0.02110557f, 0.02752904f, -0.00576256f, -0.01481182f, 0.00719282f, -0.02935566f, -0.03338807f, -0.03805118f, 
    -0.02070236f, 0.00661304f, 0.00129137f, 0.03330195f, -0.01625197f, 0.02565651f, 0.02499595f, -0.01087378f, 
    -0.02961635f, 0.03656491f, 0.01704535f, 0.03269276f, -0.01347956f, 0.01941741f, -0.02230274f, 0.00091744f, 
    -0.01519126f, -0.02183972f, -0.00344293f, 0.00452773f, 0.00778841f, 0.02263775f, 0.01715232f, 0.00909456f, 
    -0.02668967f, 0.00628778f, -0.00005135f, 0.00984267f, 0.00143925f, -0.01003173f, -0.02611751f, 0.02397887f, 
    0.01172244f, 0.00762678f, -0.01713741f, -0.01173148f, 0.00192939f, 0.02199158f, -0.03988676f, 0.00686098f, 
    0.02449073f, -0.01487739f, -0.02953708f, 0.02808470f, 0.00976574f, 0.02045025f, -0.00617969f, -0.01325250f, 
    -0.01366071f, 0.00292278f, 0.02637511f, -0.00965038f, -0.03253845f, 0.02985795f, -0.00609385f, -0.01391825f, 
    -0.01981636f, -0.02791985f, -0.03968206f, -0.03838153f, 0.02620618f, -0.02418682f, -0.01579338f, 0.00353520f, 
    -0.03712799f, -0.00940532f, -0.01079665f, 0.02146221f, -0.03031057f, -0.01642335f, 0.00514492f, -0.02368114f, 
    -0.03597546f, -0.02572146f, 0.02035910f, -0.00130645f, -0.03821865f, 0.00377564f, -0.04071821f, -0.00558731f, 
    -0.03421783f, -0.02150484f, -0.02339058f, -0.02853788f, 0.00794127f, -0.02090761f, -0.00072221f, -0.02334086f, 
    -0.03863721f, -0.00854538f, 0.00302550f, -0.03428796f, -0.00901748f, 0.00389265f, 0.00929802f, -0.03674488f, 
    0.02260218f, 0.01022902f, -0.02133596f, 0.03005004f, 0.01994256f, -0.02846119f, 0.01852049f, -0.02914687f, 
    -0.00967184f, 0.02175099f, -0.01757362f, -0.04143801f, -0.00389078f, -0.03380540f, -0.03539244f, 0.02378890f, 
    -0.03417839f, 0.01185811f, 0.00713249f, 0.00287156f, 0.01821085f, -0.00594856f, 0.00731930f, -0.00882043f, 
    -0.01122368f, 0.01395919f, 0.01142557f, 0.01269895f, -0.03569382f, 0.02193430f, 0.01630091f, -0.00184903f, 
    0.02542087f, -0.02232743f, -0.02717529f, 0.02537205f, 0.00872755f, -0.02457866f, -0.02490084f, 0.01915498f, 
    -0.00797182f, -0.02677666f, -0.01225628f, 0.00572919f, 0.04005906f, 0.04096156f, -0.01473382f, -0.00231823f, 
    0.03397842f, 0.02320775f, -0.03822286f, -0.03299343f, 0.02763778f, -0.00942534f, -0.00497004f, 0.02693500f, 
    0.01941840f, 0.01294809f, 0.03742457f, 0.00507905f, 0.02036599f, -0.00607481f, 0.01409615f, -0.02092220f, 
    0.03782657f, 0.03564723f, 0.01353515f, 0.02324001f, 0.00752167f, 0.01049170f, -0.01238331f, -0.02228735f, 
    -0.01878645f, -0.02790250f, 0.01808126f, -0.02697393f, -0.02957498f, -0.03756152f, 0.02189649f, -0.01737391f, 
    -0.01285723f, -0.02091569f, -0.00538432f, -0.00790925f, 0.03601852f, 0.01240080f, 0.02069925f, -0.01448921f, 
    -0.02969938f, 0.01889446f, -0.01729748f, -0.02552218f, 0.04150252f, 0.00965697f, -0.04066942f, -0.03449413f, 
    -0.01215967f, -0.03322493f, -0.01607437f, -0.03260965f, -0.02056715f, -0.00779580f, -0.03334854f, 0.02118974f, 
    -0.01407669f, -0.01487747f, -0.04142398f, -0.03426310f, -0.02691854f, -0.02042134f, 0.02034082f, 0.00073597f, 
    0.02975742f, -0.00941502f, 0.01070955f, 0.01552160f, 0.03501341f, 0.02886643f, -0.02647534f, 0.01410779f, 
    -0.02633075f, 0.02942437f, 0.02237504f, 0.02674378f, -0.01679559f, 0.00655628f, 0.01031770f, -0.03009389f, 
    -0.02965607f, -0.00158264f, -0.04138704f, 0.02502192f, -0.03240285f, -0.04196072f, 0.00486011f, 0.00082607f, 
    -0.02118699f, 0.02216451f, -0.00979514f, 0.02577122f, 0.02059975f, 0.01084638f, -0.00770055f, -0.03634316f, 
    -0.00002421f, -0.00826751f, 0.02692524f, 0.00178605f, 0.03799082f, -0.01090499f, 0.00329689f, -0.03384172f, 
    0.01147668f, 0.04055650f, -0.00700255f, -0.01973118f, 0.02169468f, 0.01400712f, -0.02442952f, -0.01723593f, 
    -0.03365338f, 0.01479502f, 0.00111567f, -0.00860240f, -0.02292112f, -0.00874763f, -0.03965488f, -0.04169886f, 
    0.00694110f, -0.00340478f, -0.01216723f, 0.02365901f, -0.00255130f, 0.00026065f, 0.00991075f, -0.02669734f, 
    -0.00163479f, 0.01291749f, -0.02422160f, -0.02417635f, -0.01189834f, 0.00109736f, -0.00729357f, 0.02113937f, 
    -0.02157668f, -0.01308886f, -0.02438280f, 0.00260928f, 0.02061567f, -0.00488663f, -0.02618562f, 0.02629449f, 
    0.02879051f, 0.02470609f, -0.00675400f, -0.02867514f, -0.02712747f, 0.03460601f, 0.00302403f, 0.02187050f, 
    -0.00671707f, -0.01553609f, -0.02350292f, 0.00322015f, 0.00353688f, -0.00109475f, -0.04155717f, -0.04059735f, 
    -0.02623528f, -0.02914416f, 0.00350212f, 0.00465626f, -0.03199231f, -0.03281576f, -0.00275042f, -0.03425133f, 
    0.00733320f, -0.00855358f, 0.00824115f, -0.03695866f, 0.02236973f, -0.03745056f, 0.01838547f, 0.00866323f, 
    0.00049018f, -0.00522176f, 0.01183141f, 0.01942215f, 0.01253122f, -0.02166113f, 0.00921367f, -0.02843118f, 
    0.01096543f, -0.01360822f, -0.02285264f, -0.02360144f, -0.01138733f, 0.02965196f, -0.00130054f, -0.01026472f, 
    -0.00534598f, -0.03192418f, -0.03398436f, -0.00615758f, 0.01115278f, -0.02720994f, 0.01138263f, -0.03975355f, 
    -0.01568909f, -0.02459492f, -0.03661346f, 0.02423349f, -0.04185546f, -0.02034033f, -0.04080027f, -0.01587527f, 
    -0.00144105f, -0.00847571f, 0.02733272f, -0.03819839f, -0.01898438f, -0.01329423f, -0.01675085f, -0.01626502f, 
    -0.04059988f, 0.00770081f, -0.00704673f, 0.00186951f, -0.00859307f, -0.02705422f, 0.00676054f, 0.03543585f, 
    -0.02299656f, -0.03290383f, -0.01499261f, -0.03334540f, 0.02263205f, 0.00328664f, -0.04175096f, -0.02529030f, 
    -0.03109090f, -0.01979147f, -0.03225454f, -0.03901232f, 0.02409655f, 0.02462067f, -0.02523975f, 0.00932714f, 
    0.00821236f, -0.04176207f, -0.03520120f, 0.00221492f, -0.03039892f, 0.02137078f, 0.02298585f, 0.02789259f, 
    -0.01472821f, -0.03851180f, -0.03016439f, -0.03984702f, -0.02555577f, 0.02148848f, -0.02820329f, 0.02709608f, 
    -0.02082817f, -0.01889695f, 0.01117444f, -0.03147184f, 0.01986042f, 0.00703833f, -0.01926264f, -0.00139327f, 
    0.02541957f, 0.00420313f, -0.01840090f, -0.03088335f, 0.00455838f, -0.00183686f, 0.02927089f, 0.01282866f, 
    0.02593213f, -0.03191512f, -0.02542586f, -0.03582390f, -0.02029998f, -0.03361518f, 0.00962200f, 0.01440376f, 
    0.01705882f, 0.00758551f, -0.01483119f, 0.02323457f, 0.01256757f, 0.02029657f, -0.01228229f, -0.03010758f, 
    -0.03322430f, -0.02764554f, -0.02908009f, -0.00965229f, 0.00379242f, -0.03633492f, -0.03985471f, -0.03131913f, 
    -0.03025650f, 0.00780873f, -0.01337016f, 0.01602678f, -0.03021345f, 0.01380895f, -0.03717003f, -0.03057484f, 
    -0.00473662f, 0.02556863f, 0.01484542f, -0.01469372f, -0.00220774f, 0.00711419f, -0.02116763f, -0.03123331f, 
    0.01725044f, -0.02604221f, 0.00962820f, 0.00918628f, -0.02692352f, -0.04146319f, 0.02071917f, -0.03044379f, 
    0.00723276f, 0.03002126f, 0.00389039f, -0.00359981f, -0.04042361f, -0.03327845f, -0.03497734f, -0.03936530f, 
    -0.01629384f, 0.01616143f, -0.01377172f, 0.00094516f, -0.03571700f, 0.01722977f, -0.02962946f, -0.03970022f, 
    -0.03106798f, 0.02184188f, -0.00264075f, -0.02124113f, -0.00400871f, 0.01105716f, -0.02184022f, 0.02951466f, 
    0.01170017f, -0.03101246f, -0.03065328f, 0.02278549f, 0.00600516f, -0.03609360f, 0.02046912f, -0.04034860f, 
    0.01051317f, -0.02580302f, 0.02131077f, 0.01934444f, 0.02376453f, 0.01297643f, 0.01153674f, 0.02977867f, 
    -0.04082606f, -0.01870373f, -0.00614047f, -0.00547214f, -0.01657899f, 0.01651415f, 0.00086836f, 0.02930937f, 
    -0.00936032f, 0.00173807f, 0.00415805f, -0.02246512f, -0.02675959f, 0.00947540f, -0.02828827f, -0.00515532f, 
    0.00507045f, -0.03533410f, 0.01320108f, 0.00478147f, 0.02368471f, -0.02400517f, 0.00145121f, -0.02884941f, 
    0.01587056f, -0.02109022f, 0.01138679f, 0.02093843f, -0.02568041f, 0.02356220f, 0.01387736f, 0.00283869f, 
    0.00371322f, -0.04014347f, -0.02001756f, 0.00648315f, 0.02327443f, 0.01787548f, 0.02953557f, 0.02453499f, 
    -0.01548395f, 0.02071651f, 0.00083892f, -0.03380539f, 0.00745513f, -0.04005850f, -0.03509320f, -0.02816752f, 
    0.01458412f, -0.03149712f, -0.01782100f, 0.02959001f, 0.01176462f, -0.02651813f, -0.00363751f, -0.00057076f, 
    -0.01484095f, -0.01116839f, -0.03000138f, 0.01987520f, -0.01005229f, -0.00950970f, -0.01169658f, -0.01011233f, 
    0.02925894f, -0.01235792f, -0.00126643f, 0.00393077f, -0.01075711f, 0.02018775f, -0.01539275f, 0.02626326f, 
    -0.02054780f, 0.00030491f, -0.02957668f, 0.02590616f, -0.01226377f, 0.00214309f, -0.02820507f, -0.01795187f, 
    0.02543145f, -0.02025044f, 0.01882915f, 0.00168652f, 0.02251537f, -0.01761339f, -0.03711093f, -0.00376012f, 
    -0.00755893f, -0.01037331f, 0.01586049f, -0.01378909f, -0.00802542f, -0.04157356f, 0.00709994f, -0.00140518f, 
    -0.02160253f, 0.00846095f, 0.00149480f, 0.01029680f, -0.02609294f, -0.03437704f, 0.02731100f, 0.02055604f, 
    -0.02404655f, 0.00468009f, -0.04062751f, 0.01215851f, -0.00715658f, 0.02731256f, -0.00094965f, -0.03399155f, 
    0.01392976f, 0.02858099f, -0.00184505f, 0.03001214f, -0.02304149f, -0.01622660f, 0.02041451f, -0.02422132f, 
    -0.03024940f, -0.02720659f, -0.00761038f, -0.01442862f, 0.02270766f, -0.02921910f, 0.02188723f, -0.03981752f, 
    0.01472509f, -0.03054453f, 0.00735053f, 0.02218268f, -0.02489124f, -0.01110805f, -0.00765325f, 0.01318975f, 
    0.01029905f, -0.02034831f, -0.00519172f, -0.00470035f, 0.00632701f, -0.03801306f, 0.01664576f, 0.00011930f, 
    -0.00736487f, 0.00058650f, 0.01597697f, -0.02006577f, -0.01199376f, 0.00103607f, -0.01094373f, -0.03444938f, 
    0.02156381f, 0.02435536f, 0.01567959f, 0.01193591f, -0.03229657f, -0.03760090f, -0.03603469f, 0.01662868f, 
    -0.01850867f, 0.01783238f, -0.01420250f, 0.00706396f, -0.01178560f, -0.00996610f, 0.00595389f, -0.02388775f, 
    0.02104082f, -0.04105775f, -0.04107276f, -0.00287702f, -0.01602142f, -0.01404967f, -0.02182555f, -0.03755414f, 
    0.02684366f, 0.02149040f, 0.02083156f, -0.03917232f, -0.01473985f, -0.01498565f, 0.01912336f, -0.00305708f, 
    -0.01729332f, -0.01041555f, 0.02361346f, 0.00825841f, -0.04037352f, -0.02398393f, -0.01088891f, -0.00327031f, 
    -0.01074027f, -0.02581901f, -0.01944076f, -0.03895971f, -0.04159624f, -0.00370834f, 0.02918125f, -0.01122001f, 
    0.00174260f, 0.02018329f, 0.00554651f, -0.01795346f, 0.01328846f, -0.03192340f, 0.00675650f, -0.01572764f, 
    -0.00525638f, -0.00115641f, -0.01415725f, 0.01460070f, -0.04073174f, -0.01593084f, -0.02572257f, -0.03025122f, 
    0.00586961f, -0.04019331f, -0.00843009f, 0.01273610f, 0.01745676f, -0.01637912f, -0.02322266f, -0.03464717f, 
    0.01039664f, -0.04146218f, 0.01746432f, -0.01953777f, 0.01624721f, 0.00093078f, -0.01708150f, 0.00153312f, 
    0.01152938f, 0.00063606f, -0.01931608f, -0.02505208f, -0.02366232f, -0.00134822f, -0.02056402f, -0.01870161f, 
    -0.01122431f, 0.00716639f, -0.00747169f, 0.01274198f, -0.02969857f, -0.03309043f, -0.04198562f, 0.01166937f, 
    -0.03484986f, 0.01381396f, 0.00186128f, -0.02420754f, 0.02770225f, 0.00948223f, 0.02378615f, -0.03636554f, 
    -0.00593616f, -0.00229703f, -0.01663503f, 0.00926700f, -0.02678563f, -0.00964066f, 0.01552608f, -0.02305504f, 
    0.02038893f, -0.02033826f, 0.00372206f, -0.03490235f, -0.01262711f, -0.01925760f, -0.00634940f, 0.02747122f, 
    0.00397354f, 0.01251938f, -0.00908417f, 0.00496158f, -0.02282210f, -0.00644057f, -0.03487464f, 0.01386836f, 
    -0.04035098f, -0.02928261f, 0.01412739f, -0.02374773f, -0.02184679f, -0.03661826f, -0.03435706f, 0.00075009f, 
    -0.02913590f, -0.03771492f, 0.00850819f, 0.01182394f, -0.00501567f, 0.01629194f, -0.03047726f, -0.00437842f, 
    -0.01567983f, -0.00445224f, 0.02532918f, -0.00792934f, -0.00511636f, 0.00744875f, -0.03282141f, -0.00908762f, 
    0.01166160f, -0.01044577f, 0.01932203f, -0.00948367f, -0.02132932f, -0.02950156f, 0.02131027f, -0.02567976f, 
    0.01076035f, -0.03999530f, 0.00333300f, -0.01944006f, -0.00024222f, 0.01557872f, -0.01303737f, -0.03074439f, 
    0.03006209f, -0.03550722f, -0.02489270f, -0.00196967f, -0.01508281f, -0.02507165f, -0.01916165f, -0.02234937f, 
    -0.02094397f, -0.01724924f, -0.04112544f, -0.04102981f, 0.02882374f, -0.01866801f, -0.03969723f, 0.00089982f, 
    0.01244851f, 0.00116027f, -0.01484201f, -0.01744633f, -0.00443355f, -0.01757142f, -0.00486112f, -0.00870539f, 
    0.02349705f, 0.02200362f, -0.03894181f, -0.01294148f, -0.00830669f, -0.01399343f, -0.00713048f, -0.02577116f, 
    -0.01582036f, -0.04132718f, -0.01747337f, -0.02976940f, -0.02975141f, -0.03614050f, 0.00340189f, -0.03693631f, 
    0.01270105f, -0.00071860f, 0.01735916f, -0.03295175f, 0.00118316f, -0.00098767f, -0.03986161f, -0.00591487f, 
    -0.00974106f, 0.02398087f, -0.01637397f, -0.04144723f, -0.01362877f, 0.00986650f, -0.02791614f, 0.00828909f, 
    0.02563454f, 0.02775712f, -0.00659361f, 0.00632993f, 0.00058495f, -0.01581613f, 0.00578243f, -0.00290631f, 
    -0.00320624f, 0.02513065f, -0.03972239f, 0.01878002f, 0.00061973f, -0.03234089f, 0.02377983f, -0.00390823f, 
    0.01347969f, 0.01478941f, -0.01864239f, -0.02172670f, -0.02445052f, -0.02981970f, -0.00962176f, 0.02037567f, 
    -0.03247625f, -0.01437839f, -0.04013366f, -0.00676545f, 0.01454269f, -0.03555436f, 0.00433196f, -0.01898058f, 
    -0.03227541f, 0.00774056f, 0.02710162f, -0.02333756f, -0.03268915f, -0.02669412f, -0.00431956f, -0.01627669f, 
    0.01651317f, 0.02419922f, -0.03627923f, -0.02297960f, -0.01497748f, -0.04182829f, -0.00643897f, -0.01497894f, 
    -0.02685350f, -0.01164949f, -0.00716667f, -0.03542389f, 0.00810045f, 0.01465543f, 0.00281075f, -0.02975206f, 
    0.00165306f, -0.02203872f, -0.01638001f, 0.00784118f, -0.02793049f, -0.03921836f, -0.00253187f, 0.01525363f, 
    0.01521999f, -0.02079498f, -0.02893946f, 0.01454412f, 0.02016843f, 0.01724283f, -0.01981555f, -0.03722198f, 
    -0.01125688f, -0.02508174f, 0.02735583f, -0.03988329f, -0.01925023f, -0.01817362f, 0.00756178f, 0.01255595f, 
    -0.02452258f, -0.02183754f, -0.01156688f, 0.00063414f, 0.02124753f, 0.00981109f, -0.02939136f, -0.00031761f, 
    -0.02866475f, 0.00952154f, -0.00218477f, -0.03756422f, 0.00872234f, -0.04092847f, 0.00111236f, -0.00982672f, 
    -0.02917965f, -0.00619575f, 0.00677819f, -0.00036574f, -0.02437730f, 0.01394038f, -0.01356762f, 0.00769691f, 
    0.01861224f, -0.01737780f, 0.00439045f, -0.01084614f, 0.01032858f, 0.00999798f, -0.02269282f, -0.02757889f, 
    -0.01362018f, 0.02251280f, 0.01978235f, 0.00418288f, -0.01553355f, 0.00398678f, 0.00395395f, -0.01673467f, 
    -0.02206986f, -0.02841900f, -0.02658449f, -0.01812422f, 0.01677473f, -0.01517386f, -0.02389602f, -0.00509168f, 
    -0.02881705f, 0.00181279f, 0.00611954f, 0.01930348f, 0.01198841f, -0.02231137f, -0.04056950f, -0.03564378f, 
    0.01498108f, -0.00341505f, 0.01817145f, -0.01304449f, -0.03237996f, -0.04163935f, -0.00609681f, -0.02350263f, 
    0.02492251f, 0.01452831f, -0.00842541f, -0.01120795f, -0.02078097f, -0.02737361f, -0.00151149f, -0.01059428f, 
    -0.02452688f, -0.00925428f, 0.01378416f, -0.03616460f, -0.02020259f, 0.02410639f, -0.01850604f, -0.01833868f, 
    0.00585233f, -0.01644843f, 0.00942918f, 0.02549260f, 0.02848394f, -0.00083871f, 0.00758250f, 0.00144922f, 
    -0.01631993f, -0.02005191f, 0.02108840f, 0.02826846f, 0.02626481f, 0.01275916f, -0.01172382f, -0.03184915f, 
    -0.03345387f, -0.03455369f, -0.00302148f, -0.03282957f, -0.00145494f, 0.01677264f, -0.02938942f, 0.00539651f, 
    -0.01931085f, 0.00000787f, -0.02527123f, -0.02524282f, -0.03881279f, 0.01381012f, -0.01822725f, -0.04034584f, 
    -0.02016853f, 0.00178739f, -0.00812427f, -0.00248813f, 0.02005059f, 0.00024265f, -0.00534461f, 0.02428171f, 
    -0.03330106f, -0.01766917f, -0.00450567f, 0.00616598f, -0.02975145f, -0.03431942f, 0.02149811f, -0.01508818f, 
    0.01469925f, 0.00881892f, -0.02398158f, 0.01282241f, 0.02832017f, 0.00637390f, 0.00087272f, 0.02102500f, 
    0.00795130f, 0.02939970f, -0.01561482f, -0.01279620f, -0.03102411f, -0.01202513f, 0.00496912f, -0.02862990f, 
    -0.01387127f, 0.02322040f, -0.02759493f, -0.01293008f, -0.03963881f, 0.01542652f, -0.02047093f, 0.02026919f, 
    0.02357864f, -0.03736322f, 0.01639448f, -0.03304830f, -0.01084379f, 0.01073249f, 0.00890367f, -0.03116300f, 
    -0.01716760f, -0.03265927f, 0.00377697f, -0.00048273f, -0.00691263f, -0.03165399f, 0.01740247f, 0.00656906f, 
    -0.02563318f, -0.01634656f, -0.02211476f, -0.03336612f, 0.00867588f, -0.03781111f, 0.00719694f, -0.01397708f, 
    0.00254051f, 0.02472234f, 0.00991173f, 0.01754573f, -0.02521459f, 0.01759334f, -0.01921490f, 0.00283646f, 
    0.00098180f, -0.03719718f, 0.02333794f, 0.02472978f, -0.00516080f, -0.02638773f, -0.01293644f, -0.01804933f, 
    -0.01231415f, 0.00698094f, -0.00078146f, -0.02084260f, 0.00984610f, 0.02494541f, 0.00213391f, 0.00537056f, 
    -0.02604359f, 0.02170284f, 0.01482994f, 0.00949578f, -0.01211100f, 0.00878383f, 0.00189483f, -0.03055861f, 
    -0.02857373f, 0.00080369f, -0.03445468f, -0.02567960f, 0.00772111f, -0.04001749f, 0.02441630f, -0.01889519f, 
    -0.16686176f, 0.04715157f, 0.15159902f, -0.13559662f, 0.05564446f, 0.06967981f, 0.07223330f, -0.11871982f, 
    -0.02097660f, -0.02977684f, 0.09897324f, -0.10037903f, -0.12306511f, 0.03154116f, 0.19307014f, -0.15378676f, 
    -0.08554241f, 0.14273503f, -0.07634290f, 0.00791533f, 0.25158861f, -0.06836666f, 0.15381221f, 0.00281975f, 
    0.11277819f, 0.04734264f, -0.25933340f, 0.10381618f, 0.21975718f, 0.03078166f, 0.14025149f, 0.04535494f, 
    0.08695310f, -0.00821946f, 0.10293585f, -0.00193069f, -0.11269804f, 0.02268665f, 0.00049471f, -0.11562925f, 
    0.02974644f, -0.24426071f, -0.02514127f, 0.00963884f, -0.04018507f, -0.05090108f, -0.05153217f, 0.09636454f, 
    0.06149713f, -0.07053579f, -0.14691538f, -0.09191754f, 0.09400658f, -0.02764499f, -0.08134411f, -0.03013120f, 
    0.17608005f, 0.21918644f, 0.09389346f, 0.03193098f, -0.08787115f, -0.13434409f, -0.14799248f, 0.05563536f, 
    0.07217199f, 0.03257578f, -0.07685529f, -0.09546059f, 0.07181703f, -0.12384090f, -0.10852927f, 0.07568145f, 
    0.70766306f, 0.10478479f, 0.44749266f, 0.16115868f, 0.22710717f, -0.12495022f, -0.01012291f, -0.01334360f, 
    0.05256648f, -0.04033596f, 0.00317316f, 0.00492394f, -0.10343652f, -0.05189799f, -0.15260838f, 0.02075935f, 
    0.19846722f, 0.01734180f, 0.12997124f, 0.07993871f, -0.03096794f, -0.06746894f, 0.01543530f, -0.09642325f, 
    -0.02301463f, 0.11324865f, -0.23771302f, 0.08943322f, 0.21223773f, 0.00043942f, -0.09033498f, -0.01872304f, 
    -0.02591245f, 0.14461786f, -0.10287428f, 0.04674561f, 0.19613282f, -0.12319006f, -0.05456977f, -0.07173724f, 
    0.03677368f, 0.11124668f, 0.17692366f, 0.06369341f, -0.03056157f, -0.01629264f, -0.07890681f, -0.10299987f, 
    0.07651424f, 0.57870555f, -0.13374183f, 0.08686791f, -0.01725110f, -0.05668151f, 0.18557526f, 0.09489836f, 
    -0.12385444f, 0.18090083f, 0.06043385f, 0.01267903f, 0.08905237f, -0.17488192f, -0.14771803f, 0.31129399f, 
    0.11727042f, 0.02238313f, 0.15642536f, 0.00830197f, 0.01119429f, -0.01123028f, 0.01322471f, 0.05796279f, 
    -0.22179914f, -0.17895696f, 0.15459427f, 0.00627514f, 0.02948098f, 0.11169472f, 0.11923784f, 0.12720218f, 
    -0.06410611f, -0.09231281f, 0.03575699f, 0.06257240f, -0.24245495f, -0.28645611f, 0.03984718f, 0.03589911f, 
    0.10526891f, -0.06036593f, 0.17012461f, 0.00062684f, -0.07502878f, -0.12496729f, 0.00779284f, 0.23159242f, 
    -0.09353618f, 0.32257193f, -0.15367347f, -0.01293765f, -0.01486768f, 0.17351615f, -0.10284545f, 0.19882339f, 
    0.23888256f, -0.00049134f, 0.13795774f, -0.03232449f, -0.21102770f, -0.07447195f, 0.12470627f, 0.27590361f, 
    -0.06591635f, 0.00116739f, -0.00767555f, -0.02352321f, 0.18658753f, -0.02984342f, 0.11454394f, 0.09818882f, 
    0.17728950f, -0.43076554f, -0.06011826f, -0.27701703f, 0.09936625f, 0.16070944f, 0.04149374f, 0.00464705f, 
    0.06384569f, 0.07113770f, 0.17228431f, 0.09399001f, -0.06928574f, -0.00122409f, 0.29802921f, 0.03880261f, 
    0.08387697f, 0.14560729f, -0.04683690f, 0.02521782f, -0.09316444f, 0.06881922f, -0.10006592f, 0.09253208f, 
    0.07650402f, -0.06178957f, 0.02036537f, -0.03237196f, 0.08534423f, 0.02211805f, -0.06672727f, 0.00303881f, 
    -0.13115926f, -0.08388793f, -0.11634006f, -0.08436885f, -0.11265282f, 0.14062922f, 0.06803361f, -0.15980387f, 
    -0.13172708f, 0.08450972f, -0.11003114f, 0.04392638f, -0.01758118f, -0.04817963f, 0.01249310f, -0.01946474f, 
    -0.09310331f, -0.05372854f, 0.20346856f, -0.24618535f, -0.02876861f, -0.10513565f, -0.04948828f, 0.10157639f, 
    -0.12084205f, -0.09626465f, -0.06671330f, -0.12883937f, -0.02873411f, -0.01418026f, -0.01907111f, -0.02224670f, 
    -0.00705801f, 0.13891135f, -0.08229112f, -0.01991977f, 0.07673248f, 0.10357621f, -0.02302592f, -0.03670980f, 
    -0.22797023f, 0.08365510f, 0.02859230f, -0.00839962f, -0.02256827f, -0.05379559f, 0.05201951f, 0.30024949f, 
    -0.20463751f, -0.07597305f, -0.07120609f, 0.15149647f, 0.19857383f, -0.24373341f, 0.11656439f, -0.14314687f, 
    0.11972225f, 0.00600691f, -0.08942653f, 0.07844676f, 0.04250707f, -0.01874849f, -0.13968401f, -0.00168908f, 
    -0.33333284f, -0.18439698f, -0.06646506f, 0.20179336f, -0.03239096f, 0.07960806f, 0.04936862f, 0.09404884f, 
    -0.01639108f, -0.08171762f, 0.12854010f, 0.01298149f, 0.04446656f, 0.23163511f, 0.02131757f, -0.05964790f, 
    -0.01091309f, 0.00135099f, 0.02962743f, -0.00576632f, 0.15012102f, -0.04891055f, 0.14026156f, 0.03651728f, 
    -0.25062424f, -0.15577857f, -0.11481952f, -0.02782512f, 0.10019136f, 0.00462896f, 0.11463395f, -0.18248586f, 
    0.13848376f, -0.05239823f, -0.11965197f, 0.01640817f, 0.00914119f, -0.01040667f, -0.14036068f, -0.02541686f, 
    -0.00938911f, -0.18298298f, 0.12269463f, 0.20153505f, -0.08509976f, -0.13453473f, -0.00980202f, 0.10959552f, 
    -0.09269596f, -0.09040193f, 0.02646205f, -0.13543727f, 0.17688954f, 0.03796308f, -0.08430175f, 0.00755927f, 
    -0.06669642f, -0.12374947f, -0.06511598f, 0.16830701f, 0.07951865f, -0.06795751f, 0.17371494f, 0.11689337f, 
    0.04306886f, -0.00392113f, 0.03743625f, -0.09406879f, 0.14793660f, -0.05780687f, 0.12985381f, 0.16402046f, 
    -0.28546411f, -0.15361601f, -0.03827774f, -0.11070500f, -0.00543225f, -0.05814131f, 0.01587973f, 0.00343748f, 
    -0.02568266f, 0.02468779f, 0.07758847f, 0.01243652f, -0.21914075f, -0.18140492f, 0.00633405f, -0.09398872f, 
    0.07774698f, 0.16332047f, -0.08136661f, -0.02933548f, -0.10120381f, -0.14782953f, -0.08385602f, -0.04162973f, 
    -0.21010987f, 0.00093100f, 0.09219036f, 0.00011823f, -0.07751834f, -0.04609906f, 0.05855405f, 0.02108327f, 
    0.03001668f, 0.12596761f, 0.02758921f, -0.04958904f, 0.16096033f, -0.16319197f, 0.02404685f, -0.01934305f, 
    -0.03046883f, -0.04029595f, -0.02520353f, 0.08198792f, 0.07233712f, 0.06685828f, 0.07380828f, 0.05784390f, 
    -0.07932509f, 0.14750776f, -0.19643985f, 0.20273891f, 0.03694319f, 0.07557976f, 0.08510777f, 0.25084338f, 
    -0.08167694f, 0.02577189f, 0.13473739f, 0.04732030f, -0.09380925f, -0.22793861f, 0.04182183f, -0.07541155f, 
    0.07475130f, -0.04832110f, 0.13774322f, 0.14762451f, -0.02024628f, -0.07004638f, -0.01412394f, 0.00955845f, 
    -0.31426436f, 0.29496038f, 0.07299806f, 0.19062692f, -0.02043164f, 0.04463219f, 0.07362129f, -0.10664083f, 
    0.01419321f, 0.16352722f, -0.03086075f, 0.07326371f, -0.06875036f, 0.01641710f, 0.06743027f, 0.11210810f, 
    0.07254628f, -0.11950504f, -0.02481207f, 0.11698902f, 0.08873343f, -0.04397132f, 0.00513021f, -0.02020404f, 
    0.34362778f, -0.05224097f, -0.17637716f, -0.16788584f, 0.11104938f, -0.13475105f, 0.15606649f, 0.16920170f, 
    0.01159880f, -0.05761296f, 0.10335022f, -0.09609539f, 0.05560354f, -0.32759982f, 0.10199419f, 0.04561955f, 
    0.08954732f, -0.14309871f, -0.02359018f, 0.00853078f, 0.09720314f, -0.01547467f, 0.06934665f, -0.01643603f, 
    0.01662947f, 0.15134045f, -0.17505316f, 0.18343626f, -0.06423943f, -0.00171762f, 0.06584763f, 0.05721505f, 
    -0.08959141f, -0.00104165f, 0.00712203f, 0.01477706f, 0.06800018f, 0.11485814f, 0.00597000f, 0.06112871f, 
    0.03633092f, 0.03557012f, -0.08923166f, -0.12479552f, -0.07400230f, 0.01615914f, 0.10123201f, 0.00508185f, 
    -0.33453420f, 0.44605505f, 0.13352263f, 0.10368390f, 0.13463344f, 0.04250444f, -0.09686948f, 0.02865405f, 
    -0.01324517f, -0.07330702f, -0.02938012f, 0.03742772f, -0.17849930f, 0.10109343f, -0.14111976f, 0.35783529f, 
    0.02567213f, -0.03872786f, -0.05907231f, -0.01810457f, 0.12272621f, -0.00425977f, -0.00584396f, 0.21938264f, 
    0.30401132f, -0.41996095f, -0.04602459f, 0.00977146f, 0.17734778f, 0.02874418f, -0.06801980f, -0.23491092f, 
    0.17963111f, 0.17609568f, -0.10812528f, 0.21182030f, -0.01443113f, -0.02178631f, 0.03026961f, 0.05565690f, 
    0.09673280f, -0.07820930f, -0.08501118f, -0.09881809f, 0.03954236f, -0.05784383f, -0.27112374f, 0.05076713f, 
    0.15996024f, -0.10371426f, -0.05640140f, 0.16688903f, 0.03983645f, 0.03265961f, 0.00566563f, -0.04640098f, 
    0.11945537f, 0.08646969f, -0.11278123f, 0.05429722f, 0.18903644f, 0.07460240f, -0.17026076f, -0.18950020f, 
    0.00217597f, 0.02585283f, -0.04438042f, 0.01415567f, 0.08137032f, 0.01403662f, 0.05374855f, -0.20638929f, 
    -0.09807955f, -0.01492279f, 0.06532805f, 0.14133701f, 0.05786595f, -0.02108194f, 0.05153393f, 0.19845369f, 
    -0.02166845f, 0.06130951f, 0.14377333f, 0.22871798f, 0.11473122f, -0.18169872f, 0.00246303f, 0.07449956f, 
    0.10898785f, 0.01035456f, 0.09463407f, -0.00043824f, 0.14108628f, -0.01599026f, 0.11767697f, 0.02433210f, 
    -0.43517938f, 0.21149077f, -0.03314729f, -0.10940014f, -0.00321289f, 0.01819066f, 0.05665608f, 0.19481905f, 
    -0.02080565f, 0.09513440f, 0.13542309f, -0.16095851f, -0.15633439f, 0.11652225f, 0.08105669f, 0.26876721f, 
    0.19767131f, -0.03153732f, 0.17272183f, 0.00019976f, 0.22204372f, 0.05782006f, -0.20799786f, -0.11216787f, 
    0.49726939f, 0.04578282f, 0.09099422f, -0.16239676f, 0.07744763f, 0.12988140f, 0.00547714f, 0.12794012f, 
    0.04612732f, -0.01603733f, -0.03303340f, -0.03307034f, 0.09047494f, 0.11169923f, -0.03718982f, 0.02306240f, 
    -0.00031484f, -0.01008218f, -0.02270786f, -0.01397682f, 0.01316274f, -0.07157233f, 0.11630742f, -0.00415583f, 
    -0.47725222f, -0.10084528f, 0.18111689f, 0.07515215f, -0.06883937f, -0.05644860f, 0.01981946f, -0.01037146f, 
    0.20814717f, 0.02006038f, 0.07925899f, -0.03672105f, 0.14073427f, -0.12120225f, -0.17822388f, 0.04816270f, 
    0.02719483f, 0.14446858f, 0.02364502f, -0.00136536f, -0.01079691f, 0.05946969f, 0.03269844f, -0.03627202f, 
    0.01630970f, 0.01387543f, 0.20309113f, 0.25070041f, 0.04696967f, -0.03478694f, 0.06038589f, 0.09658285f, 
    -0.09039532f, 0.03133325f, 0.01652801f, 0.00328886f, -0.04573169f, -0.11418434f, -0.00764837f, -0.26353034f, 
    -0.04026314f, -0.05562814f, -0.15678780f, -0.28843600f, -0.04171523f, 0.07014830f, 0.10577772f, 0.06162720f, 
    0.13256918f, 0.12727541f, -0.15089528f, -0.14431609f, -0.09410010f, -0.08762928f, -0.15532382f, 0.03549356f, 
    0.06702465f, -0.00694155f, 0.03083492f, -0.11820380f, -0.53497821f, -0.03351515f, 0.05474536f, 0.06855475f, 
    -0.12344449f, 0.08437973f, 0.14236657f, 0.15743032f, 0.07505202f, 0.03785205f, 0.07457272f, -0.04886624f, 
    0.35518780f, 0.02782332f, 0.02452088f, 0.07338536f, -0.10590760f, -0.08256813f, -0.08402636f, -0.04078401f, 
    0.03415447f, 0.03426094f, -0.04010327f, 0.17824127f, -0.05996583f, -0.05223295f, 0.09542990f, -0.19423649f, 
    -0.12067757f, -0.12877737f, -0.07453942f, 0.01067172f, 0.15805054f, -0.09161127f, -0.06885818f, -0.05303917f, 
    0.07007443f, -0.16142136f, -0.03190720f, 0.03730123f, -0.07720120f, 0.04327397f, -0.03576021f, -0.10432185f, 
    0.06106042f, -0.21158864f, 0.21215457f, -0.06656730f, -0.27725479f, 0.42728731f, 0.44275323f, -0.29875967f, 
    0.06760177f, 0.12376191f, -0.05008979f, 0.17966922f, 0.01085539f, -0.04769894f, 0.05046237f, 0.00528167f, 
    -0.03769802f, 0.01282552f, 0.02665504f, -0.00148970f, -0.00220379f, 0.01031379f, 0.01809483f, -0.01891765f, 
    -0.02924301f, -0.01215533f, -0.01350338f, -0.02852413f, -0.00082010f, 0.01437669f, 0.02539345f, -0.01027465f, 
    0.03116601f, 0.01997404f, -0.01080973f, -0.00535213f, 0.01041369f, -0.01599619f, 0.02093142f, -0.03895772f, 
    -0.00530973f, -0.02265047f, 0.02657410f, -0.02885994f, 0.01331293f, 0.00441391f, 0.01345640f, 0.01651503f, 
    -0.02970369f, 0.01887768f, 0.03321074f, 0.02949988f, 0.03451099f, -0.02259273f, 0.02843583f, -0.01774418f, 
    0.01357005f, -0.01041105f, -0.03089148f, -0.00839980f, -0.02957099f, 0.01094894f, -0.01044997f, -0.02520836f, 
    -0.01457698f, 0.00924330f, 0.00001034f, -0.01159571f, 0.02168988f, -0.01250873f, 0.02047747f, 0.00508349f, 
    0.01556456f, -0.02295144f, 0.03071605f, -0.02291919f, -0.02297580f, -0.03332642f, -0.02819020f, -0.03351974f, 
    0.02125489f, -0.03324370f, 0.01037371f, -0.02341315f, -0.02905528f, -0.02707278f, 0.02910379f, -0.00544720f, 
    -0.01998031f, -0.03283683f, 0.00651155f, 0.02098787f, -0.02695189f, 0.01971149f, -0.03295659f, 0.02496598f, 
    -0.02584144f, -0.02147046f, -0.01013194f, -0.02407802f, -0.01422139f, 0.01784029f, -0.01283978f, -0.00123857f, 
    -0.03074929f, -0.00954074f, 0.00091967f, 0.02819428f, -0.01072238f, -0.00185872f, 0.03699100f, -0.01805340f, 
    -0.02472723f, -0.00154644f, -0.04199516f, 0.02306185f, -0.01925547f, -0.00655045f, 0.03111437f, -0.00770865f, 
    0.03334993f, -0.00981680f, 0.02441207f, 0.02963660f, 0.02281184f, -0.03973982f, 0.02531637f, -0.03574679f, 
    0.01562903f, -0.02698780f, 0.02570823f, 0.02472698f, -0.02664391f, 0.01113241f, -0.00816309f, 0.02770334f, 
    -0.00934832f, 0.00977561f, 0.03125814f, -0.02546367f, 0.01626638f, 0.00912912f, -0.03718698f, -0.02372883f, 
    0.00574556f, -0.00150944f, -0.00390529f, 0.02131436f, 0.02898359f, 0.01595549f, 0.02288337f, -0.04189358f, 
    -0.03369766f, -0.00484263f, -0.02178399f, 0.02405545f, -0.00222226f, 0.02388308f, -0.01877136f, 0.02880571f, 
    -0.03692623f, -0.01679512f, 0.00682999f, -0.03821137f, -0.03364166f, 0.00066942f, 0.00270823f, 0.02016962f, 
    0.03175762f, -0.01869725f, -0.03386720f, 0.00926672f, -0.00811058f, -0.03366985f, 0.01478493f, 0.01456884f, 
    0.03307269f, -0.02786136f, 0.00879261f, -0.03837838f, -0.01566779f, 0.00614068f, 0.02092968f, -0.00610434f, 
    0.02503469f, 0.01435800f, -0.01959463f, 0.00447993f, -0.03137902f, -0.02786221f, 0.00834551f, 0.02135251f, 
    -0.01812333f, -0.02894890f, 0.00429560f, 0.02178378f, -0.04117767f, 0.01722890f, -0.00671370f, -0.03314474f, 
    -0.01401381f, -0.02113033f, -0.01755946f, -0.02418609f, -0.02893443f, 0.00708379f, -0.01559440f, -0.03543800f, 
    -0.01547075f, 0.01632221f, -0.02787943f, 0.02704357f, -0.02080132f, -0.03810019f, 0.01034867f, -0.00644267f, 
    0.00534704f, -0.01908599f, 0.03370595f, -0.01849770f, 0.03263291f, -0.01454371f, -0.03012318f, -0.02291506f, 
    0.01649837f, 0.02626166f, -0.01370761f, 0.00745737f, -0.01997280f, 0.01719447f, 0.01722078f, 0.02527091f, 
    -0.01467677f, -0.02037645f, -0.03216736f, -0.02914447f, 0.02224463f, -0.00924816f, -0.01052727f, 0.02095740f, 
    0.03065705f, 0.03168460f, -0.01897837f, -0.01249334f, 0.00949408f, -0.02380579f, 0.03464099f, -0.01813304f, 
    0.03088599f, -0.03105702f, 0.00442789f, 0.00644592f, -0.00328259f, 0.01963411f, -0.00815417f, -0.01311369f, 
    0.02488646f, -0.02813604f, -0.02196718f, 0.00927775f, -0.01526422f, -0.03095084f, 0.00312956f, -0.02662569f, 
    0.03215408f, 0.00876299f, -0.01483291f, -0.03366338f, -0.01129954f, -0.01503480f, 0.01179254f, 0.01706617f, 
    -0.00382689f, -0.01849082f, 0.01919752f, 0.01571978f, -0.03666463f, -0.03217597f, -0.00046705f, 0.01120021f, 
    0.00053169f, -0.02373270f, -0.03004957f, -0.03236086f, -0.02486422f, 0.01965479f, 0.00593422f, -0.00274894f, 
    -0.03849322f, -0.03963865f, 0.03178605f, 0.01161069f, -0.02349277f, -0.03892423f, -0.02247022f, 0.01153474f, 
    -0.00197562f, 0.02280923f, 0.02916664f, 0.02385473f, -0.02060350f, -0.03581538f, -0.03122103f, -0.00828295f, 
    0.02215874f, 0.00098439f, 0.01467685f, -0.01222312f, -0.00750062f, -0.01822450f, 0.03348070f, 0.02452208f, 
    0.03146557f, -0.01794535f, -0.02592922f, 0.01899069f, -0.02281658f, 0.03607761f, -0.03592625f, -0.01330216f, 
    -0.03422711f, -0.00745453f, 0.01506716f, -0.03691161f, -0.01670207f, -0.01304973f, 0.00563969f, 0.02780767f, 
    -0.01354252f, 0.02569241f, -0.02625645f, -0.03429937f, -0.01031769f, 0.02193047f, 0.00068923f, 0.02031593f, 
    0.00423556f, 0.00258328f, -0.00227805f, 0.01122029f, 0.00931247f, 0.02145030f, -0.00096847f, -0.03432576f, 
    -0.03157328f, -0.03148264f, -0.02436559f, -0.00175870f, -0.03822778f, -0.00119315f, -0.02503205f, -0.00704223f, 
    -0.03151340f, -0.00897728f, -0.00565270f, -0.00209674f, 0.00973058f, -0.02337513f, 0.01918113f, -0.01054166f, 
    -0.02764449f, -0.00855530f, -0.03547151f, 0.02781900f, 0.02481087f, -0.00848154f, 0.01437286f, -0.04081742f, 
    0.01458730f, -0.03319417f, 0.01446262f, 0.02095952f, 0.01562820f, -0.02948562f, -0.01027275f, 0.02583430f, 
    0.00748440f, -0.02762887f, -0.00849961f, -0.00258735f, -0.00531336f, 0.01718524f, -0.00704336f, -0.02074532f, 
    0.03277883f, -0.02190672f, 0.02089548f, -0.02718775f, -0.01995176f, -0.01490533f, -0.01860421f, 0.00647955f, 
    0.01524178f, 0.04110045f, 0.00451493f, -0.01980977f, -0.02667979f, -0.00608340f, 0.00115950f, -0.00765117f, 
    0.00344695f, -0.00318038f, 0.01807359f, 0.02676373f, -0.00013135f, 0.00538869f, -0.01999109f, -0.00560278f, 
    -0.01666591f, -0.00446979f, 0.01101181f, -0.03702411f, -0.01476861f, -0.03280292f, -0.03969234f, -0.02417568f, 
    -0.03137021f, -0.03697256f, -0.00353678f, 0.03166210f, 0.03181648f, 0.01330896f, -0.03554846f, 0.02586869f, 
    -0.00948710f, 0.02251831f, 0.00052778f, 0.01084939f, -0.03793075f, -0.00153773f, -0.01631569f, 0.00444780f, 
    -0.02142776f, 0.03286839f, -0.00032652f, -0.03653176f, -0.03447533f, 0.01116593f, -0.02473379f, -0.03982744f, 
    -0.01096050f, -0.03308103f, -0.02487202f, 0.00950672f, -0.02109528f, -0.00707942f, 0.00944370f, 0.02888917f, 
    -0.01565630f, -0.00176566f, 0.02556576f, -0.01083166f, -0.02330830f, -0.03532604f, 0.02856628f, 0.00801528f, 
    -0.03160448f, -0.03860723f, -0.00232009f, -0.02542179f, -0.01057788f, -0.01255962f, 0.00435422f, 0.03254427f, 
    -0.03363785f, -0.02982141f, -0.02071932f, 0.00398806f, -0.01709997f, -0.01340442f, 0.01697866f, 0.01481688f, 
    -0.02327941f, -0.02113042f, 0.00124470f, 0.01134777f, -0.03005155f, 0.02098587f, 0.00445902f, 0.03605093f, 
    0.01965387f, 0.01484188f, -0.03830146f, 0.00254976f, -0.01036308f, 0.02727220f, 0.02363172f, 0.00130323f, 
    0.01019941f, -0.01644380f, -0.03006846f, -0.02729479f, 0.02639912f, 0.02893233f, -0.03722492f, -0.02175938f, 
    0.00870018f, 0.02811215f, -0.03714959f, 0.00104165f, -0.03040937f, 0.02175703f, -0.02000380f, 0.00139056f, 
    0.01178138f, -0.02361933f, -0.02188648f, -0.00548836f, 0.00517482f, -0.02109471f, 0.01040588f, 0.03234659f, 
    -0.01191840f, 0.00525434f, 0.01970127f, -0.01206874f, 0.00477676f, -0.02871368f, -0.00397993f, -0.01946272f, 
    -0.01072326f, -0.02774786f, 0.01988267f, 0.01937780f, 0.00874776f, 0.00446074f, -0.02588762f, -0.02925834f, 
    -0.03291504f, 0.00766832f, -0.00533270f, -0.01577378f, -0.00630274f, -0.00113082f, 0.02275341f, -0.00692880f, 
    -0.02610363f, 0.01321950f, -0.03853579f, 0.02446848f, -0.01362422f, -0.03003358f, -0.01602840f, -0.03702506f, 
    0.02956589f, -0.01151043f, 0.02817573f, -0.00120749f, -0.01972500f, -0.03370586f, 0.00970488f, 0.01658811f, 
    0.02821726f, 0.01549677f, -0.00800073f, -0.01019380f, -0.03661375f, 0.02791273f, 0.01367720f, -0.02742080f, 
    0.03813011f, -0.02854450f, 0.03154581f, -0.03092043f, 0.03323505f, -0.03233642f, -0.04012250f, -0.02867107f, 
    -0.03734412f, -0.03077011f, 0.00221767f, -0.03305702f, 0.02831794f, -0.03209094f, -0.01511187f, -0.02761826f, 
    0.02090586f, 0.01548678f, -0.02864174f, 0.01155004f, 0.01769567f, 0.00949931f, 0.00816481f, 0.00354304f, 
    0.01983959f, 0.02476325f, 0.00342065f, -0.01703373f, 0.00170619f, 0.00582020f, -0.00340382f, -0.00440298f, 
    -0.00262592f, 0.02413792f, 0.01202739f, 0.02224287f, 0.01454446f, 0.02524487f, -0.02880348f, -0.01388651f, 
    0.02635791f, 0.02042391f, 0.02132213f, -0.02927691f, -0.00314238f, 0.02457067f, -0.01604944f, -0.01480556f, 
    0.00753227f, 0.02378424f, -0.02374354f, -0.01099564f, 0.00760075f, 0.01897188f, 0.01465730f, -0.00622106f, 
    0.01138278f, 0.03794737f, 0.01734991f, -0.01563995f, -0.01094884f, 0.01010575f, -0.03285260f, -0.00697908f, 
    0.01382439f, 0.02823265f, -0.00580632f, -0.00139439f, -0.01218849f, -0.01058759f, -0.00061684f, -0.01180948f, 
    0.01634497f, -0.00235373f, -0.03220810f, -0.01726590f, 0.02469738f, -0.00002493f, -0.01745878f, 0.02744258f, 
    0.00720072f, -0.01572479f, -0.02368943f, -0.02630089f, 0.01545222f, -0.01798843f, -0.02955022f, 0.00963557f, 
    0.02011344f, 0.01424620f, -0.02586843f, -0.00171024f, 0.02092381f, 0.02142250f, -0.01893702f, 0.01005259f, 
    0.00695427f, -0.03015640f, 0.01997648f, -0.03098487f, -0.01426695f, -0.00741787f, 0.02131942f, -0.02529423f, 
    0.02770755f, -0.01319114f, 0.01357340f, 0.01434221f, -0.01814036f, 0.02428757f, -0.01814182f, 0.02397378f, 
    -0.01378153f, 0.03002072f, -0.02518010f, 0.03195547f, 0.01003372f, -0.02531041f, 0.00463320f, -0.00520353f, 
    -0.00075889f, -0.02411163f, -0.02304043f, 0.00871088f, 0.03360450f, -0.02322829f, 0.01110860f, -0.03503403f, 
    0.01573720f, -0.00351720f, 0.02149951f, 0.01151802f, 0.01575483f, 0.00288955f, 0.02624869f, -0.02097974f, 
    -0.02569452f, 0.00851866f, 0.00010893f, 0.00595218f, -0.03677281f, 0.02347036f, -0.02427475f, -0.00571609f, 
    -0.03173915f, 0.03404698f, 0.03445739f, -0.00222527f, 0.01724219f, 0.01171447f, -0.01482712f, 0.01523254f, 
    -0.01716160f, -0.02287803f, -0.03015875f, -0.00719838f, 0.00305618f, -0.03349312f, -0.00019059f, -0.02869409f, 
    0.03188529f, 0.01908972f, -0.02607404f, -0.02659252f, -0.01338256f, -0.02560905f, 0.02112716f, -0.04116283f, 
    0.01379368f, 0.01389527f, 0.01146644f, 0.01755713f, 0.01808127f, -0.02638851f, -0.01760984f, 0.01900580f, 
    0.01854336f, -0.03486297f, 0.03437350f, 0.00458128f, -0.01362706f, -0.02777805f, 0.00842755f, -0.01891971f, 
    -0.01926523f, -0.02290226f, -0.03815651f, -0.00305926f, -0.02933525f, 0.03412900f, 0.03616293f, 0.01854562f, 
    -0.00388462f, 0.02326288f, 0.00191982f, 0.02440978f, 0.02960963f, 0.03168812f, -0.01772441f, 0.00485108f, 
    -0.02900481f, -0.02207249f, -0.03113114f, 0.01610889f, -0.02654458f, 0.02716879f, -0.00958224f, 0.02189338f, 
    -0.01326697f, -0.03735396f, 0.02156229f, 0.01980424f, 0.01833108f, 0.02368641f, -0.02072112f, -0.00300771f, 
    -0.03559916f, 0.03549773f, -0.00495631f, -0.01786378f, 0.00159384f, 0.02488022f, -0.01676960f, 0.02679695f, 
    0.00341227f, -0.02366110f, -0.00586692f, 0.01708004f, -0.03292446f, -0.01640388f, -0.01720683f, -0.03487703f, 
    0.00729612f, -0.02346971f, -0.02753057f, -0.01554644f, -0.02185970f, -0.02289341f, -0.01695149f, 0.02393183f, 
    -0.01601760f, 0.00674372f, 0.02232094f, -0.03887532f, -0.02625910f, 0.01901893f, 0.00474270f, -0.04121060f, 
    -0.00917963f, -0.01531926f, -0.03040405f, -0.02407118f, -0.01445556f, 0.02652804f, -0.03091375f, 0.02404987f, 
    -0.04158952f, -0.01575331f, -0.00877517f, 0.00480244f, -0.03318391f, 0.00296916f, -0.00653695f, -0.01833444f, 
    0.00124110f, -0.00355858f, -0.03920668f, -0.00308349f, -0.00053255f, -0.03638324f, -0.01779544f, 0.01977702f, 
    -0.00722027f, -0.04172098f, -0.01467064f, -0.03449878f, -0.03604430f, -0.01955149f, -0.03170776f, -0.01296171f, 
    -0.03679628f, -0.00446636f, -0.00357466f, -0.02903094f, 0.00564326f, 0.02753346f, -0.04130026f, -0.03868458f, 
    -0.04090281f, 0.02318748f, -0.03725619f, 0.01721726f, 0.00301737f, -0.01231527f, -0.03533311f, 0.01584707f, 
    0.02013323f, -0.02376654f, -0.00649873f, -0.00954898f, -0.03029910f, -0.02761959f, 0.02297531f, -0.01477202f, 
    0.02533681f, 0.03299445f, -0.00950538f, 0.03554663f, -0.00761925f, -0.03951268f, 0.02212225f, 0.01308102f, 
    0.00881899f, -0.01274703f, 0.00101777f, -0.00429906f, -0.01939712f, -0.02538269f, 0.02329718f, 0.01666841f, 
    -0.01769937f, -0.02800455f, -0.03047106f, -0.01303539f, -0.01426863f, 0.01175385f, -0.01405787f, 0.01305666f, 
    0.02192563f, 0.02093160f, 0.00284147f, 0.00374330f, -0.02238284f, 0.00547656f, 0.02672009f, -0.00448035f, 
    -0.02593648f, 0.01444127f, 0.01578343f, 0.02898903f, 0.00657892f, -0.00175877f, 0.01941590f, -0.03905526f, 
    0.02483654f, 0.00157389f, -0.00024936f, 0.02387862f, -0.03318687f, 0.00769440f, -0.04087688f, 0.01493990f, 
    -0.00921141f, 0.01898964f, 0.01785897f, -0.03249102f, -0.02482441f, -0.00037557f, -0.01910044f, -0.01766925f, 
    -0.02869339f, 0.01131747f, 0.01350662f, -0.03305438f, -0.01914823f, -0.00014107f, -0.00221061f, -0.03748078f, 
    -0.01173508f, 0.02373888f, 0.03524742f, -0.03506066f, -0.03099837f, -0.00365607f, -0.01656130f, 0.01024092f, 
    -0.01994671f, 0.02924791f, 0.00529932f, -0.03220644f, -0.01747197f, -0.02600290f, -0.00431306f, -0.02592396f, 
    -0.00092863f, 0.02493405f, -0.01667994f, 0.01791018f, -0.00413093f, 0.00774816f, -0.00864405f, 0.02314954f, 
    -0.00749081f, -0.00254727f, 0.00930742f, -0.01811552f, -0.00334095f, -0.04038634f, 0.00219917f, -0.01063572f, 
    -0.00515155f, 0.00822746f, 0.01096384f, 0.02117543f, -0.00422088f, 0.02107441f, -0.03618240f, 0.01451319f, 
    0.02824855f, -0.02161980f, -0.03428239f, -0.01458188f, -0.00587419f, 0.01382331f, 0.02096215f, 0.02295833f, 
    -0.01820090f, 0.02733799f, 0.01114659f, -0.02575379f, -0.02314313f, -0.00110015f, -0.01400744f, -0.01569118f, 
    0.01536904f, 0.00441130f, 0.00935064f, 0.01871550f, -0.01421073f, -0.00215799f, 0.01747282f, -0.04083356f, 
    0.02635641f, -0.03084744f, -0.03652057f, -0.04006819f, -0.02983672f, 0.00225447f, 0.01241752f, -0.00442993f, 
    -0.00807592f, -0.00277222f, -0.02131529f, 0.02079346f, 0.00330218f, -0.02095618f, -0.03319551f, 0.02716422f, 
    -0.01965331f, -0.00716159f, 0.01263328f, -0.03538775f, -0.01330675f, 0.02419367f, -0.04056588f, -0.02090748f, 
    0.00339330f, -0.00578753f, -0.01947020f, -0.01722921f, 0.00121608f, -0.01067270f, 0.01890390f, 0.02885646f, 
    -0.02573101f, -0.00623195f, 0.00977208f, 0.00588725f, -0.00925014f, -0.03857187f, 0.02745434f, -0.00675529f, 
    -0.02056185f, 0.01549529f, -0.03777449f, 0.02322969f, -0.02291420f, -0.01774436f, 0.00372835f, 0.02172684f, 
    -0.01682553f, -0.02800856f, -0.03909831f, -0.02557662f, -0.02906224f, -0.02100706f, -0.03975875f, -0.00320318f, 
    0.01946073f, 0.00432819f, -0.03951902f, 0.02685853f, 0.01573179f, -0.00003364f, -0.02346238f, -0.02868055f, 
    -0.00627766f, 0.01118060f, -0.01939728f, 0.00894870f, 0.02584144f, 0.01496789f, -0.03630428f, -0.04100000f, 
    0.01693036f, -0.01972516f, 0.02491898f, -0.02562692f, 0.02692703f, 0.00248538f, -0.02893621f, 0.01242971f, 
    -0.02508637f, -0.03054176f, -0.03736077f, -0.00833026f, 0.00960417f, 0.02810692f, -0.02115412f, -0.02620270f, 
    0.01964145f, 0.01103819f, 0.02220637f, -0.04033806f, -0.01216712f, -0.03369394f, -0.01891860f, -0.00621751f, 
    0.02717631f, -0.02728834f, -0.02178635f, 0.00514148f, 0.00155241f, -0.00590587f, 0.01803877f, 0.00643551f, 
    -0.02125532f, 0.01734203f, -0.02905568f, 0.01605620f, -0.03381200f, -0.00328640f, 0.01354365f, 0.00104487f, 
    -0.01139300f, 0.02969277f, 0.02391406f, 0.01535865f, -0.01781270f, 0.00271165f, -0.03824794f, -0.00009505f, 
    -0.00564155f, -0.03585304f, -0.01012348f, -0.01587030f, 0.03004272f, 0.01621464f, 0.01758116f, -0.01378484f, 
    0.00237609f, -0.03111101f, 0.01161832f, 0.01724778f, 0.00328890f, 0.01987973f, 0.01928484f, 0.02425394f, 
    0.02487659f, -0.01271231f, -0.01852510f, -0.03435747f, 0.01060480f, -0.02296647f, -0.02143012f, -0.03821812f, 
    -0.00144495f, -0.02869891f, -0.02542693f, 0.01821951f, -0.00523138f, 0.00002444f, -0.00430845f, -0.02908901f, 
    0.00066673f, 0.01109296f, -0.01644887f, -0.00554960f, 0.00950405f, -0.04099210f, 0.00002823f, -0.00489466f, 
    0.01826452f, 0.02335799f, -0.03997917f, -0.03433695f, -0.02700471f, 0.01971434f, -0.02253241f, 0.02338448f, 
    -0.03180206f, -0.00288118f, -0.03636587f, 0.00637605f, 0.00568237f, 0.02777014f, 0.00686024f, 0.01276074f, 
    -0.02918831f, -0.01795813f, 0.01090709f, 0.02370886f, 0.02519083f, -0.01741623f, -0.00216944f, 0.00023238f, 
    -0.00625490f, 0.02342354f, -0.00301902f, -0.00648731f, -0.04051092f, -0.03739654f, 0.00042813f, 0.00598013f, 
    -0.01096423f, -0.01455224f, 0.02680591f, 0.00964880f, -0.00688380f, 0.00776504f, -0.04032035f, -0.02030388f, 
    0.02149027f, 0.00874141f, 0.00259125f, -0.03452057f, 0.02704551f, -0.00927247f, -0.02592817f, -0.02327321f, 
    -0.01700935f, -0.00782098f, 0.00116758f, -0.02615102f, -0.00870592f, 0.01985338f, -0.03234747f, 0.01207207f, 
    -0.03030347f, -0.00726204f, -0.02556321f, -0.00590577f, 0.02795334f, 0.01861868f, -0.01734157f, 0.02514016f, 
    -0.00460333f, 0.01393089f, 0.00952490f, -0.00099299f, 0.00382961f, -0.01845936f, -0.03759579f, 0.00656201f, 
    -0.02950886f, -0.00997788f, -0.02112357f, -0.02673685f, 0.00333448f, -0.03425988f, -0.00915602f, -0.02127733f, 
    0.01031756f, -0.00602788f, -0.02432266f, -0.01779526f, -0.01224710f, -0.03405437f, -0.00257016f, -0.02758848f, 
    -0.01523562f, -0.00296618f, -0.02438188f, 0.00933518f, -0.01910559f, -0.00249681f, -0.02431793f, -0.03406428f, 
    -0.02248940f, -0.00816929f, -0.03805176f, -0.03573075f, 0.02239690f, 0.02041208f, -0.00852043f, 0.00233316f, 
    0.01189533f, 0.02803364f, -0.02719913f, -0.02623527f, -0.03223699f, 0.02821453f, 0.01825839f, 0.00559748f, 
    -0.04185411f, 0.02961797f, -0.00860800f, -0.02808763f, 0.02984898f, -0.04152372f, 0.02256962f, 0.00755358f, 
    -0.02380957f, 0.01180162f, -0.02779776f, 0.01947671f, 0.00997893f, -0.00456486f, -0.03979136f, -0.03926974f, 
    -0.01212937f, -0.02444890f, -0.02076179f, -0.01749320f, 0.02014086f, -0.00128634f, 0.01105248f, -0.03184408f, 
    -0.00734842f, -0.02796725f, -0.01474637f, 0.00707694f, -0.03011408f, -0.01464942f, -0.02334818f, 0.00771996f, 
    0.01437131f, 0.01281847f, 0.00962519f, -0.00050423f, -0.00626230f, -0.01390707f, -0.01649487f, -0.00200420f, 
    0.01465040f, 0.02131089f, -0.00843434f, -0.02265080f, 0.01839255f, -0.01945538f, 0.01672806f, -0.01870250f, 
    0.00361637f, 0.01925124f, -0.01877842f, 0.00961560f, -0.04162960f, -0.01727462f, -0.00482366f, -0.03510616f, 
    -0.00489819f, 0.03057113f, 0.01464938f, -0.02379754f, -0.03740552f, -0.02543497f, -0.03802106f, -0.01299961f, 
    -0.02114860f, -0.02413688f, -0.02525518f, 0.02379226f, -0.03424751f, -0.00217072f, 0.01280169f, -0.00160195f, 
    0.01870221f, 0.02592809f, -0.03453816f, -0.03397389f, 0.01145177f, 0.00212644f, -0.03295030f, 0.01436076f, 
    -0.01592017f, -0.00648159f, -0.01115499f, 0.02282582f, 0.00365522f, 0.00977013f, 0.01654672f, 0.00485839f, 
    -0.02433809f, -0.00974898f, -0.03833315f, -0.01572272f, -0.01599367f, -0.04076615f, 0.01969459f, 0.00444763f, 
    0.02380924f, 0.02663597f, 0.01428629f, -0.02576568f, -0.02451728f, 0.00668290f, -0.02408080f, -0.02760230f, 
    0.02117589f, -0.02681045f, -0.03183388f, -0.01341894f, -0.02179778f, -0.00190853f, -0.00215559f, -0.02304596f, 
    -0.01487734f, -0.00390471f, 0.01577975f, 0.00614554f, -0.02189015f, -0.00745189f, 0.00625021f, 0.00284251f, 
    0.01545146f, 0.02724849f, 0.00662224f, -0.02025356f, 0.00454670f, -0.01543891f, -0.01458684f, -0.01263369f, 
    0.01714946f, 0.02062063f, 0.00502134f, -0.02877678f, -0.03766516f, -0.00140486f, 0.01473871f, 0.01414893f, 
    0.00178656f, -0.00218366f, 0.02463375f, 0.00576169f, -0.02407625f, -0.02159807f, -0.01007619f, 0.00969526f, 
    0.01065917f, 0.00819400f, 0.01121399f, -0.01248374f, -0.02868736f, -0.02913371f, 0.02804543f, -0.02541432f, 
    0.01856097f, -0.00409702f, -0.02610832f, 0.00947731f, -0.04145942f, -0.03909225f, -0.01138218f, -0.01420089f, 
    -0.02870543f, -0.04163921f, -0.03624596f, 0.00322804f, 0.00541330f, -0.03722772f, 0.01222878f, -0.02155679f, 
    -0.03369118f, -0.00936911f, -0.03093446f, 0.02314495f, 0.00042679f, -0.00564585f, -0.04009145f, -0.00555135f, 
    -0.04018130f, 0.00423783f, -0.00618235f, 0.01250735f, -0.01404342f, 0.02667584f, -0.03117691f, 0.00786571f, 
    -0.03445944f, 0.02305390f, 0.02493437f, 0.00198586f, -0.02642879f, 0.02373742f, -0.02159036f, -0.02734322f, 
    0.02682727f, -0.01317432f, 0.02056601f, -0.02976751f, -0.02413151f, -0.01170212f, 0.00872801f, 0.02849329f, 
    -0.01559689f, -0.01965035f, -0.00554709f, -0.01057185f, -0.01763074f, -0.01657946f, 0.00197983f, -0.03066264f, 
    -0.02109455f, 0.00749738f, 0.00701934f, -0.03907375f, 0.00535304f, 0.00750691f, -0.03205952f, -0.01262569f, 
    0.00527598f, 0.02023190f, 0.02712503f, -0.00458279f, 0.00098395f, -0.02047743f, -0.02680590f, -0.01887531f, 
    -0.03548092f, 0.01469561f, -0.00117772f, 0.01681943f, -0.00423715f, 0.00665757f, 0.00882781f, 0.01316221f, 
    -0.00721435f, -0.01016271f, 0.02147965f, 0.01414116f, 0.02748671f, -0.00267378f, -0.01135046f, 0.00382589f, 
    -0.00215395f, 0.02732125f, -0.02911637f, -0.00533929f, 0.00674088f, 0.02652123f, -0.02258032f, 0.03169394f, 
    -0.03966881f, -0.01625288f, -0.03412571f, 0.01022481f, 0.01518027f, -0.03073590f, 0.02394389f, 0.01236398f, 
    0.02465451f, 0.01585389f, -0.01834794f, -0.00936855f, -0.02578439f, 0.02156944f, -0.04083145f, -0.01371817f, 
    0.00400475f, -0.02084242f, 0.02084959f, -0.02999328f, 0.02505680f, -0.02464829f, 0.01694685f, -0.02209941f, 
    -0.02253846f, -0.01527484f, -0.01867742f, 0.01427091f, -0.03546598f, -0.00257406f, 0.01928512f, -0.02419432f, 
    0.02509535f, 0.00823523f, 0.01343650f, -0.03258979f, 0.02046098f, -0.03087682f, -0.00038373f, -0.02750725f, 
    -0.02513830f, -0.04412091f, -0.01625449f, -0.01531141f, 0.01987963f, -0.03381774f, 0.02516466f, -0.00785585f, 
    0.01866992f, 0.01006108f, 0.00238873f, -0.02146803f, 0.00185840f, 0.00488021f, 0.02509068f, 0.02266360f, 
    -0.03918978f, -0.02728385f, 0.00003809f, -0.01729965f, 0.01281953f, -0.01304463f, 0.00448329f, 0.01721961f, 
    0.02638752f, -0.01125340f, -0.01484438f, -0.01205225f, 0.00963220f, -0.03266904f, 0.00649711f, -0.02280685f, 
    -0.01993378f, 0.00884641f, -0.00277200f, 0.00458507f, -0.00879339f, -0.00583846f, -0.03679707f, -0.02358581f, 
    0.00142579f, -0.00348688f, 0.00418147f, -0.02022024f, 0.02424069f, 0.03597660f, -0.00014820f, -0.02386926f, 
    -0.02435778f, 0.00024143f, 0.01033401f, -0.00818569f, -0.01688606f, -0.01834759f, 0.01446171f, 0.00699897f, 
    -0.02061320f, 0.02673923f, -0.01922993f, 0.02982991f, -0.04322417f, 0.01497615f, -0.01064450f, -0.03185405f, 
    -0.03132476f, 0.00553072f, -0.01588937f, -0.00982042f, -0.01037564f, 0.01329223f, -0.03417508f, -0.00993173f, 
    -0.01083027f, -0.02827292f, -0.02700413f, -0.00900143f, -0.01984393f, -0.00528488f, 0.01209121f, 0.01548688f, 
    0.02398466f, 0.01741124f, 0.01908596f, -0.00965721f, -0.00183472f, 0.01712729f, 0.00910115f, -0.03586555f, 
    -0.00338800f, -0.00927848f, 0.00715970f, 0.00652503f, -0.02062889f, 0.03117948f, -0.01316122f, 0.02261055f, 
    0.01205464f, -0.03923211f, 0.01357442f, -0.00541318f, -0.00508835f, 0.01431129f, -0.02548000f, -0.00099976f, 
    0.01498444f, 0.00885261f, -0.00774801f, -0.02118220f, -0.01980866f, -0.01863906f, 0.00282339f, -0.00411835f, 
    0.01809812f, 0.01835843f, 0.01937762f, -0.02747049f, -0.03286123f, 0.00478636f, -0.01796792f, 0.01990356f, 
    0.01877730f, -0.04345467f, -0.03300296f, 0.01753367f, -0.01709884f, -0.04122125f, -0.02556287f, 0.00938558f, 
    -0.01878133f, -0.01902305f, 0.01689769f, -0.01387356f, -0.02669068f, -0.03490536f, -0.01363511f, 0.00032790f, 
    -0.00670798f, 0.01154349f, -0.01954656f, -0.01660364f, -0.01330765f, -0.04129428f, 0.00330094f, 0.00155222f, 
    -0.00803051f, -0.03302277f, -0.02733507f, 0.01902206f, -0.02990911f, 0.02208926f, -0.00892921f, -0.01109672f, 
    0.02299369f, -0.00210740f, -0.02925141f, -0.02622601f, -0.01108804f, -0.02930774f, 0.00445399f, 0.01204433f, 
    0.01741425f, -0.00354960f, -0.00922317f, -0.01980294f, 0.00093983f, -0.00739748f, -0.02594466f, -0.00656712f, 
    -0.00847747f, -0.00329690f, -0.02371973f, -0.02660756f, 0.00990957f, -0.03063468f, 0.00291320f, -0.00619198f, 
    -0.03884378f, -0.01884424f, 0.01724114f, 0.01726333f, -0.03366921f, -0.02749648f, 0.00091970f, -0.00774416f, 
    -0.02385902f, -0.01752661f, -0.02740804f, -0.02986893f, -0.03395452f, 0.00358227f, 0.01140229f, 0.01193012f, 
    0.01143681f, -0.03081280f, -0.04376031f, -0.03684467f, -0.03136506f, 0.01807238f, 0.02663771f, -0.03995024f, 
    0.02470915f, -0.00530732f, -0.01352450f, -0.00426421f, -0.03857782f, -0.03251749f, -0.02864400f, 0.01550069f, 
    -0.00279520f, 0.01512646f, -0.00530429f, 0.01778002f, 0.02028245f, -0.00284525f, 0.02241017f, 0.02119576f, 
    -0.00506111f, 0.03107315f, -0.00361637f, -0.03383873f, 0.01430473f, -0.02234413f, 0.02412463f, -0.00757150f, 
    0.01993963f, -0.02994388f, -0.00526842f, 0.01652606f, -0.01072224f, -0.03298776f, 0.01293877f, -0.03773201f, 
    -0.00257928f, -0.03514851f, -0.01960548f, -0.00384854f, -0.00481530f, 0.02475506f, 0.01960260f, -0.00694400f, 
    0.01391691f, -0.02370141f, -0.03944295f, 0.00809718f, -0.01468176f, -0.03419064f, 0.00341031f, 0.00460260f, 
    0.01355950f, 0.02411202f, -0.01725862f, 0.02568235f, 0.02254362f, -0.00634235f, 0.01141697f, -0.02694965f, 
    -0.00669210f, 0.01775745f, 0.01016142f, -0.03086983f, 0.02961265f, -0.02864623f, 0.01770735f, -0.01617788f, 
    -0.03656072f, 0.02842303f, 0.00683010f, 0.02659078f, -0.00908039f, 0.01586140f, 0.01156103f, -0.01028188f, 
    -0.02786441f, -0.02947061f, 0.00916160f, 0.01999581f, 0.00946994f, 0.02839287f, 0.01366984f, -0.00837426f, 
    0.00124661f, 0.00475718f, -0.03699346f, 0.00919652f, -0.02452895f, 0.02673523f, -0.01342644f, -0.02402390f, 
    -0.03936691f, -0.04041585f, -0.02338241f, 0.02944245f, -0.03187050f, 0.00240484f, -0.03879951f, 0.02516403f, 
    -0.02799150f, -0.01817103f, -0.00150448f, 0.01944418f, -0.02530424f, 0.00095975f, -0.03264846f, 0.01369444f, 
    -0.01608358f, -0.02793064f, -0.03108935f, 0.02038690f, -0.00802717f, 0.02926095f, -0.00060627f, -0.02558827f, 
    0.00964715f, -0.02011830f, -0.00690110f, -0.01524397f, 0.01787982f, 0.02302624f, 0.00468384f, 0.00633815f, 
    -0.01451349f, -0.02129871f, -0.03444770f, 0.02249420f, -0.01508105f, 0.00653958f, 0.00318574f, -0.00599178f, 
    -0.03732117f, -0.02444890f, 0.02155871f, 0.02642833f, -0.00315597f, 0.01730335f, 0.02995065f, -0.02606941f, 
    0.01538834f, 0.01424991f, -0.00161293f, 0.00882366f, 0.01900587f, -0.02507969f, -0.01039338f, -0.02999070f, 
    -0.03879041f, -0.00303704f, -0.00185555f, -0.02872646f, -0.02299637f, -0.02843561f, -0.01089650f, 0.00450136f, 
    -0.01123071f, -0.04205862f, -0.01841235f, -0.02958678f, 0.01504577f, 0.00754641f, 0.01907863f, -0.03450551f, 
    -0.03170143f, 0.01250287f, 0.01691991f, 0.00206940f, 0.02111079f, 0.02840277f, -0.03299090f, -0.01351876f, 
    0.00464603f, -0.03652469f, -0.03566250f, -0.02716014f, -0.01066509f, -0.01167798f, 0.01063027f, 0.02037045f, 
    -0.03659952f, 0.00694936f, 0.02373226f, -0.00619091f, -0.01692335f, -0.01312755f, 0.02100744f, -0.01151364f, 
    0.00218395f, -0.00430131f, 0.01483483f, 0.01282891f, -0.03695904f, -0.01899450f, 0.00978771f, -0.02927954f, 
    -0.03797486f, 0.01677000f, -0.01995112f, -0.01318859f, -0.02804185f, 0.00336232f, -0.00886223f, 0.00511780f, 
    0.00246387f, -0.03119994f, -0.02555949f, 0.01139773f, 0.00611138f, -0.00086930f, -0.03222796f, -0.02080782f, 
    -0.03823809f, 0.01207107f, 0.02827144f, -0.02482886f, 0.01585575f, -0.01908209f, 0.00942958f, -0.03699089f, 
    0.01010985f, -0.00343458f, -0.02328419f, 0.01617219f, 0.02165399f, -0.04188155f, -0.00874318f, -0.03614799f, 
    0.00780527f, -0.01231005f, -0.04035883f, -0.00514922f, 0.01470989f, 0.00443802f, -0.02631437f, -0.04039348f, 
    -0.03931637f, -0.00425138f, -0.02959332f, 0.01918599f, 0.01454097f, -0.03344648f, 0.02238664f, 0.02060425f, 
    -0.02476464f, 0.02333093f, -0.00883111f, 0.03006790f, -0.00615378f, -0.03728562f, 0.02055700f, 0.01674185f, 
    -0.00870370f, -0.00888082f, -0.03827021f, -0.00098359f, -0.03731426f, 0.02367017f, 0.01417317f, 0.00998037f, 
    -0.03748067f, 0.02405221f, -0.03201502f, -0.01933921f, -0.02447394f, -0.02968570f, 0.00484883f, -0.03483761f, 
    -0.01549677f, -0.01335133f, -0.04018085f, 0.00510049f, -0.02979178f, -0.03049381f, -0.00289599f, -0.00260008f, 
    0.00452841f, -0.02203257f, -0.00309659f, -0.00378144f, -0.04302396f, -0.01000611f, -0.04243106f, 0.00432315f, 
    -0.03023109f, -0.02971041f, -0.03115702f, -0.01808815f, -0.04003580f, -0.02031867f, -0.01757646f, -0.03497434f, 
    -0.03988769f, 0.00282704f, -0.03780210f, -0.03549286f, -0.02075458f, 0.01213413f, -0.00601644f, 0.02689876f, 
    -0.01447710f, -0.00396083f, -0.02994029f, -0.00212095f, -0.00895616f, 0.02038229f, 0.00896230f, -0.03509692f, 
    -0.00297335f, -0.04346123f, -0.04138046f, 0.02591228f, -0.03579539f, -0.01234148f, 0.01312474f, -0.01551491f, 
    0.00749122f, 0.00541325f, 0.02125384f, -0.03803122f, 0.01437666f, 0.03142260f, 0.02410429f, -0.02962345f, 
    0.02885764f, -0.00824372f, 0.01606855f, -0.00335558f, -0.02724912f, -0.03944327f, 0.02103147f, -0.03480389f, 
    -0.03412622f, -0.02523567f, 0.00619506f, 0.01638314f, -0.02471406f, -0.04035863f, 0.01373659f, -0.00535946f, 
    0.00137188f, -0.00494270f, 0.01281145f, -0.01749547f, -0.00048640f, 0.02641117f, 0.00673162f, 0.00684760f, 
    0.01258945f, -0.02113783f, -0.02424549f, -0.00867462f, 0.01381307f, -0.01051130f, 0.03090819f, 0.00816789f, 
    -0.02066701f, -0.02142769f, -0.01133599f, -0.00182038f, 0.00904620f, 0.00315752f, 0.02255910f, -0.01917782f, 
    0.00470542f, -0.01469582f, -0.00589062f, 0.01214410f, 0.02273555f, 0.00562326f, 0.00457725f, 0.02513216f, 
    0.02243397f, -0.02799231f, -0.01160819f, -0.03008961f, 0.01849594f, 0.03318559f, -0.02877874f, 0.00225421f, 
    -0.00138238f, 0.00917876f, 0.02637479f, -0.04075055f, 0.01078427f, -0.00874748f, 0.00359925f, 0.00694428f, 
    -0.02251186f, -0.04014959f, -0.01346597f, -0.02619067f, -0.04181626f, 0.02365111f, 0.01581155f, 0.02432794f, 
    0.02086436f, 0.02515683f, -0.04267843f, -0.03866554f, 0.01965887f, 0.00725178f, 0.01522828f, -0.03200433f, 
    0.02668963f, -0.02783198f, 0.03142820f, -0.00895223f, -0.02580149f, -0.01609891f, -0.03165180f, 0.01770813f, 
    -0.00856409f, -0.01553178f, -0.03441867f, -0.00132406f, 0.03096776f, -0.02796277f, 0.00931551f, 0.01062947f, 
    -0.02160941f, -0.04017099f, 0.00327959f, -0.04000501f, -0.02283777f, -0.00276289f, 0.00172941f, -0.03410114f, 
    0.00406934f, -0.02370171f, 0.01789235f, -0.00578231f, 0.02665686f, -0.01212344f, 0.01390393f, -0.04171910f, 
    -0.02975177f, -0.02617743f, -0.01560461f, -0.01005280f, 0.00390000f, 0.00646777f, -0.02680877f, 0.02324599f, 
    0.00694097f, 0.00980886f, -0.03029064f, -0.02277130f, -0.04293413f, 0.02404627f, 0.00915829f, 0.02952673f, 
    -0.03561450f, 0.01425398f, -0.01047814f, 0.03018534f, 0.02395037f, -0.01844732f, -0.03028577f, -0.02643223f, 
    0.01984567f, -0.01293385f, 0.03278076f, -0.00620119f, -0.03437634f, -0.02257904f, -0.02992687f, 0.01090373f, 
    -0.04266772f, 0.00629203f, 0.01181700f, 0.02176434f, -0.01214927f, 0.01314214f, -0.00577097f, -0.02041594f, 
    0.01106820f, 0.02914407f, -0.01901197f, 0.02146204f, -0.00220786f, 0.01593617f, -0.00583095f, -0.02223061f, 
    0.01615246f, 0.02924730f, -0.01023748f, -0.02304936f, -0.01294833f, 0.02238422f, 0.01995266f, -0.02656060f, 
    -0.03456195f, 0.00521762f, -0.03876377f, -0.02803284f, 0.02546901f, 0.00454387f, -0.02653254f, -0.01710587f, 
    -0.00714870f, -0.02094136f, 0.01298717f, -0.01059271f, -0.02572950f, 0.02751720f, 0.00250387f, -0.00409769f, 
    -0.01452556f, -0.00427176f, -0.01101932f, -0.03088927f, -0.04398234f, -0.01561261f, 0.01668661f, -0.03532342f, 
    0.02867926f, -0.02655780f, 0.01351698f, 0.02696127f, -0.02292771f, -0.00156603f, 0.02099383f, -0.01446003f, 
    -0.00232880f, 0.01312595f, -0.00041689f, -0.03155738f, 0.00912367f, -0.03416323f, -0.04100392f, 0.02900456f, 
    -0.02535345f, 0.00917265f, -0.00100935f, -0.01933623f, 0.02323325f, -0.03015814f, -0.02939622f, -0.02967350f, 
    -0.03194683f, -0.04006629f, 0.02434738f, -0.03661490f, 0.00559731f, -0.01843155f, -0.01105255f, 0.02288967f, 
    0.01383727f, -0.02964743f, -0.03575453f, -0.02352055f, 0.02467561f, 0.02467668f, -0.00842599f, 0.01138517f, 
    -0.02965745f, -0.03564805f, -0.00176632f, 0.00120595f, -0.01678728f, 0.02401312f, -0.01077934f, -0.01369590f, 
    0.00211200f, 0.02432634f, -0.02040990f, 0.01061855f, -0.03548501f, 0.01592842f, -0.04118688f, -0.01051043f, 
    0.00997477f, 0.01926132f, 0.00998342f, 0.02778334f, 0.01319146f, 0.02892372f, -0.02479131f, 0.01750013f, 
    -0.02607691f, -0.01977346f, 0.02369517f, -0.01034485f, -0.03064284f, -0.02049888f, -0.03916881f, -0.00205621f, 
    -0.02766526f, 0.02073750f, -0.04074895f, -0.01991349f, 0.02599334f, -0.00117827f, 0.01143704f, 0.00111479f, 
    0.00519203f, 0.01169872f, -0.01094680f, 0.01033182f, 0.01800497f, 0.02179675f, -0.02859500f, 0.01405891f, 
    -0.00944290f, 0.02074347f, -0.03696970f, -0.01389104f, -0.03290746f, 0.00070953f, 0.01451382f, -0.02539634f, 
    -0.03562430f, 0.02272954f, -0.02391697f, -0.03027402f, 0.01236082f, 0.02077718f, 0.01325774f, 0.00621010f, 
    -0.00081768f, 0.01062367f, 0.02467003f, -0.03868496f, -0.03326568f, 0.00970751f, -0.02848040f, 0.03066719f, 
    0.01206838f, -0.00451214f, 0.02063698f, -0.03762067f, 0.00833896f, 0.03855856f, 0.02844390f, 0.02942986f, 
    -0.01368037f, -0.01374793f, -0.03059471f, 0.00493978f, -0.01179968f, 0.02821090f, 0.02338107f, 0.02458119f, 
    -0.00950936f, 0.00440165f, -0.03298487f, -0.02086914f, -0.02431359f, 0.00312824f, -0.01898637f, 0.00483657f, 
    0.02204525f, -0.02550346f, -0.01938744f, -0.01413984f, 0.02502088f, 0.03618995f, 0.00104205f, 0.01835158f, 
    -0.00285430f, 0.00063735f, -0.01521212f, 0.00078627f, -0.00608553f, -0.02461515f, -0.00960603f, 0.01842725f, 
    0.00434182f, 0.01503671f, -0.02341384f, -0.02545771f, -0.03996477f, 0.01014881f, -0.03534548f, -0.00908145f, 
    -0.00029723f, -0.02478193f, -0.03417988f, -0.00834067f, -0.01183583f, -0.02344982f, -0.00546148f, -0.03232292f, 
    -0.00441911f, 0.03161518f, -0.03412161f, 0.02959944f, -0.00080568f, 0.02475682f, 0.01811401f, -0.00502502f, 
    0.00338037f, -0.02436193f, 0.00856401f, 0.02946182f, -0.00112966f, 0.00345623f, -0.01643446f, -0.00234820f, 
    0.01730213f, -0.02236749f, 0.02170733f, 0.01367408f, -0.03487684f, 0.01765555f, 0.01172943f, 0.01975694f, 
    -0.00820899f, -0.00505334f, 0.02821905f, -0.00866923f, -0.03123080f, 0.00072219f, -0.02730459f, -0.00862473f, 
    -0.01593057f, 0.01106211f, 0.01130622f, 0.00311782f, -0.01164102f, -0.01164556f, 0.01072244f, -0.01037585f, 
    -0.02861136f, -0.01230595f, -0.03646522f, -0.03396824f, -0.00842787f, 0.00577882f, -0.03405845f, -0.01208696f, 
    0.00698191f, -0.03901463f, 0.00170596f, -0.02514607f, 0.01929109f, 0.00171049f, -0.01267385f, -0.02346696f, 
    -0.01715441f, 0.00016404f, -0.00592108f, 0.02600452f, -0.00024218f, 0.03008332f, 0.00660521f, -0.03690398f, 
    0.00269804f, 0.01885733f, -0.03269871f, -0.02060900f, -0.01156260f, 0.02742606f, -0.02838043f, 0.01075326f, 
    0.00448524f, -0.00897595f, -0.00197768f, 0.00820290f, -0.00664402f, -0.04031925f, -0.01234573f, -0.01316709f, 
    -0.00690044f, 0.01938265f, -0.01918571f, 0.01948192f, 0.04295629f, -0.00932368f, -0.03798385f, -0.00525980f, 
    -0.00888888f, -0.02548647f, 0.03079788f, -0.03241153f, -0.00653448f, -0.01405710f, -0.01463691f, -0.01640484f, 
    -0.03578491f, -0.02343975f, -0.02287288f, 0.03043847f, -0.00167641f, 0.01055799f, 0.01741858f, 0.01057705f, 
    -0.00095783f, -0.01188429f, -0.01723024f, -0.03944921f, -0.00397814f, 0.01211165f, -0.02048750f, -0.00173607f, 
    0.02734582f, 0.00835627f, 0.02987956f, 0.00741857f, 0.02040717f, 0.00774127f, 0.02657191f, 0.00953630f, 
    0.02733273f, -0.02285284f, 0.02507457f, -0.03914232f, 0.02275944f, -0.03104765f, -0.00143292f, 0.02491383f, 
    0.01934491f, -0.02190950f, -0.00368030f, -0.03273979f, -0.01674748f, 0.01355210f, 0.00221791f, -0.02591797f, 
    -0.01729624f, 0.00705798f, -0.02095770f, 0.02665747f, 0.02976797f, -0.00301564f, -0.01062050f, -0.02929179f, 
    0.02823809f, 0.00355084f, 0.02970336f, -0.03942446f, -0.01505438f, -0.00631207f, 0.03100594f, -0.02673599f, 
    0.02116862f, 0.03481900f, 0.02638622f, -0.01399275f, 0.02542216f, 0.01697943f, 0.00985788f, -0.01978328f, 
    0.00710928f, 0.00422175f, 0.03439529f, -0.00238959f, 0.00674248f, -0.00748802f, 0.01788750f, -0.02154166f, 
    -0.00758540f, -0.03766631f, -0.03570320f, 0.01412229f, -0.01555458f, -0.02339305f, 0.00913983f, 0.02287313f, 
    -0.03938976f, -0.02120832f, 0.02254093f, 0.03012491f, 0.03190505f, -0.01722260f, -0.01331418f, -0.00137638f, 
    0.01319680f, -0.02619156f, 0.00757970f, 0.03109929f, -0.01777193f, -0.03570826f, 0.00216409f, 0.01973072f, 
    -0.02844842f, -0.01743377f, 0.02504852f, 0.01787855f, -0.01816572f, -0.01675128f, -0.01267820f, 0.01280327f, 
    0.00812799f, 0.01960701f, 0.00531452f, 0.01927980f, -0.02304831f, 0.01276334f, 0.01144341f, -0.03274678f, 
    -0.03039075f, 0.02377542f, -0.00405482f, 0.00351429f, 0.02240037f, -0.02950693f, -0.00425063f, -0.03401940f, 
    0.03155005f, -0.03637077f, 0.00882238f, -0.03578848f, -0.00403509f, -0.00558659f, 0.01424957f, -0.00500212f, 
    -0.01373028f, -0.00279415f, 0.03120760f, 0.00574604f, 0.03867534f, 0.01842209f, 0.00452290f, 0.02106182f, 
    -0.00006304f, -0.01978753f, -0.01093062f, 0.00163649f, 0.00566342f, -0.00116048f, 0.01547695f, 0.01362522f, 
    -0.01015158f, -0.01915978f, -0.02933198f, -0.03021722f, -0.00446428f, 0.00853338f, 0.00511642f, -0.03705513f, 
    -0.03625580f, 0.00746897f, -0.01502177f, -0.00655029f, 0.00793654f, 0.01873686f, -0.02918007f, -0.02175228f, 
    0.02094428f, 0.01578793f, 0.02395244f, -0.03375072f, 0.01028755f, -0.01933658f, -0.00581431f, 0.03103117f, 
    -0.02373445f, 0.02956988f, 0.02090418f, 0.01267217f, -0.03742221f, -0.02753156f, -0.03401770f, 0.00446170f, 
    -0.00244158f, 0.01668620f, 0.00491306f, -0.02430647f, -0.02118775f, 0.02027351f, 0.01041804f, -0.01895360f, 
    -0.01956226f, -0.01675208f, -0.03662037f, 0.02516726f, 0.01077727f, -0.03337170f, 0.02350033f, -0.03409731f, 
    -0.02387484f, 0.01601785f, -0.00881647f, -0.03235940f, -0.02959432f, 0.02225654f, 0.01946387f, -0.02083242f, 
    0.03165961f, 0.02060309f, -0.00894854f, -0.01630125f, -0.03716132f, 0.00058736f, -0.03054409f, -0.02796142f, 
    0.00736406f, 0.00646765f, 0.01526321f, 0.02093810f, 0.03255380f, -0.01727401f, 0.03023337f, -0.00686921f, 
    0.03337427f, -0.00428787f, -0.03119950f, 0.01565011f, -0.00235192f, 0.00929383f, -0.03053399f, 0.03235441f, 
    -0.02431013f, 0.02419969f, -0.01499612f, -0.01227713f, -0.00557882f, 0.01999895f, 0.02580334f, -0.01093449f, 
    -0.03331543f, 0.02473121f, 0.00605824f, -0.01550934f, -0.03313836f, -0.01722182f, 0.02387506f, -0.02733981f, 
    0.02527840f, -0.00802236f, -0.00439677f, 0.00366099f, 0.02083709f, 0.01657062f, -0.03273051f, -0.00670077f, 
    -0.00577915f, 0.01659804f, -0.03571368f, -0.02261045f, -0.02901723f, 0.03023026f, 0.03050170f, -0.00813085f, 
    0.02761282f, 0.02818139f, 0.00333880f, -0.03626168f, 0.00227064f, 0.01492731f, -0.02063083f, 0.02668670f, 
    -0.03146893f, -0.01033626f, -0.03588406f, -0.04129178f, 0.02412127f, -0.03791681f, 0.00144354f, 0.02693823f, 
    0.01498176f, 0.00373144f, -0.00852238f, 0.00456035f, -0.03431998f, 0.00304760f, -0.01125424f, -0.03110518f, 
    -0.00626190f, -0.00591492f, 0.02958819f, 0.02618556f, -0.03674227f, -0.00390918f, -0.03309716f, 0.00177277f, 
    -0.01070061f, -0.02808277f, -0.02835054f, -0.01115476f, 0.00548082f, -0.00102812f, 0.02894285f, -0.01240288f, 
    -0.00321381f, -0.02303407f, 0.02234790f, 0.00683659f, 0.00156579f, -0.04110732f, -0.03343033f, -0.00972895f, 
    -0.01906912f, 0.02006748f, -0.03698459f, 0.01030884f, 0.00855422f, -0.03485784f, -0.03141317f, 0.01563545f, 
    -0.00319121f, -0.02628100f, 0.01233305f, -0.02751578f, -0.03066264f, -0.01725496f, -0.01814843f, -0.00365854f, 
    -0.03718783f, 0.00975541f, -0.02903723f, -0.01914374f, 0.01602826f, -0.02915180f, 0.01653114f, 0.03672747f, 
    0.01387109f, 0.00575847f, -0.01611469f, -0.02943726f, 0.01088247f, 0.01750970f, 0.01050984f, 0.02238477f, 
    0.01126232f, -0.00823052f, 0.02572684f, 0.00226163f, 0.01056586f, -0.03221988f, -0.01248205f, 0.01961801f, 
    -0.01585815f, -0.01559816f, -0.03198151f, -0.01618533f, 0.02972792f, -0.03411438f, -0.03062226f, 0.01473149f, 
    -0.00037879f, -0.02948974f, 0.03003842f, -0.02535437f, 0.01386007f, -0.04112716f, -0.03798046f, -0.03130228f, 
    -0.00292285f, 0.01155765f, -0.02581906f, 0.02060218f, 0.03187261f, 0.00365499f, -0.01088267f, 0.01433418f, 
    -0.02913679f, 0.02657913f, -0.01641748f, -0.00352696f, 0.01787383f, 0.00531458f, 0.00613862f, -0.01348498f, 
    -0.00533869f, -0.00013771f, 0.02868885f, 0.00441085f, -0.02075903f, -0.02314303f, -0.01347522f, 0.01742751f, 
    0.00711690f, -0.03348719f, -0.00936215f, -0.00086163f, -0.02508598f, -0.03686580f, 0.01386109f, -0.01980510f, 
    -0.00953176f, -0.02825002f, 0.01393511f, 0.03864649f, 0.00065167f, -0.02244106f, -0.01712262f, 0.01388573f, 
    -0.02213676f, -0.02637962f, 0.00467082f, -0.00144107f, 0.01068457f, 0.02208779f, 0.02277131f, 0.02445907f, 
    0.00103628f, 0.01144319f, 0.02258996f, -0.02662413f, 0.00718927f, -0.03930935f, 0.02498110f, 0.01492848f, 
    -0.01561137f, -0.00273365f, 0.00342376f, -0.02094938f, -0.02361541f, -0.01835818f, 0.01214302f, -0.03825386f, 
    -0.01308394f, 0.01645797f, -0.02193455f, 0.03072400f, -0.03176083f, 0.02013151f, -0.01788956f, -0.00204038f, 
    0.02514865f, -0.02878337f, 0.00977334f, 0.02365945f, -0.02106908f, 0.02164709f, 0.00194663f, -0.02251473f, 
    0.00722667f, 0.00598872f, 0.01347961f, -0.03368303f, 0.02956258f, -0.02660354f, 0.01449408f, -0.00545308f, 
    0.02864253f, -0.00189254f, 0.01592750f, -0.01547500f, -0.02739836f, -0.01500077f, 0.00014330f, -0.03764968f, 
    0.00210337f, 0.02306327f, 0.02485915f, -0.03651368f, -0.01824565f, -0.03955822f, 0.00114005f, -0.03401901f, 
    -0.00953631f, -0.03027003f, -0.02110678f, -0.00116141f, -0.00447360f, -0.03248133f, 0.02608906f, -0.00473408f, 
    -0.01038485f, -0.00972846f, -0.00487515f, 0.00223166f, -0.00854774f, -0.02143047f, -0.02361972f, -0.02540737f, 
    0.02058861f, 0.02863409f, -0.00119911f, 0.01092377f, -0.03497322f, -0.01012369f, 0.01145478f, -0.00035047f, 
    -0.01886969f, -0.03178584f, -0.03618221f, 0.01248577f, 0.01516875f, -0.02071587f, 0.01460119f, -0.03260496f, 
    -0.00122540f, -0.03563348f, -0.01767087f, -0.00799358f, 0.01585136f, 0.01219372f, 0.01557606f, 0.03153250f, 
    0.00819480f, 0.00766947f, -0.02017387f, 0.01020581f, -0.02292326f, -0.01307089f, 0.01541433f, 0.01000078f, 
    -0.02394278f, -0.00490525f, 0.01541807f, -0.02544373f, -0.00480146f, 0.03136096f, 0.02138839f, -0.00257967f, 
    0.00202573f, 0.00958746f, 0.02598925f, -0.01979131f, 0.03271932f, 0.01697793f, -0.01705282f, 0.02982270f, 
    0.00443941f, 0.01889513f, -0.00536255f, -0.03943810f, -0.00374218f, -0.02483694f, 0.01158889f, 0.01427255f, 
    -0.03988961f, -0.00407471f, 0.02794971f, 0.01440394f, -0.02627312f, -0.00062104f, 0.01864052f, 0.02977803f, 
    -0.03802817f, 0.00265630f, 0.00697890f, -0.03576755f, 0.00496321f, -0.01704995f, 0.01644033f, 0.03041556f, 
    0.01953891f, 0.00021949f, -0.01935334f, -0.00514193f, -0.03521556f, -0.03653025f, -0.00660606f, 0.02104152f, 
    0.17950219f, 0.11015283f, 0.19463301f, 0.25864354f, 0.10581862f, 0.02855559f, 0.04940721f, 0.14420117f, 
    0.04338318f, -0.06487612f, 0.12446732f, -0.06902993f, 0.05999115f, 0.02538161f, -0.36047038f, 0.22359833f, 
    -0.13022995f, -0.02346222f, -0.05458257f, -0.22421309f, 0.02102173f, -0.16963114f, 0.09783820f, 0.03370585f, 
    -0.17630641f, 0.02632772f, 0.04665316f, -0.13785252f, 0.03568581f, 0.04231492f, 0.00394326f, 0.10722826f, 
    0.10756488f, 0.14372720f, -0.11535931f, -0.09377129f, -0.16935593f, -0.19199216f, -0.22548762f, 0.02185585f, 
    0.04666129f, 0.08485381f, -0.02853763f, 0.02002073f, 0.01413504f, 0.00218734f, 0.02507831f, -0.20647584f, 
    -0.10915856f, -0.23938142f, -0.09667935f, -0.02753135f, 0.03036315f, -0.01888837f, -0.12036680f, 0.05572073f, 
    0.11035000f, -0.05181688f, 0.21970762f, -0.04809970f, 0.20427856f, 0.32048601f, 0.10483274f, 0.27961174f, 
    0.02486703f, -0.02392509f, 0.04466773f, 0.28188318f, -0.06180299f, 0.12298335f, 0.00165967f, 0.01020103f, 
    -0.20367093f, -0.05058221f, -0.01002887f, 0.13875398f, -0.01507689f, 0.02330617f, -0.05594925f, -0.00030047f, 
    -0.14603317f, 0.06823943f, -0.13073300f, -0.09987427f, 0.03835816f, 0.22198264f, 0.24691337f, 0.16227703f, 
    0.07023491f, 0.00228645f, -0.06758720f, -0.01758908f, 0.27963749f, 0.06474808f, -0.04192568f, 0.00792906f, 
    0.14676024f, 0.08537396f, -0.11973248f, -0.11338571f, 0.06084809f, 0.07947583f, -0.10542209f, 0.03450456f, 
    0.10069610f, -0.07771165f, -0.09808271f, -0.22854187f, 0.13971171f, 0.18919803f, 0.19574288f, 0.15378827f, 
    0.12740706f, -0.04327376f, -0.16619055f, 0.03114917f, 0.04816546f, -0.01585508f, 0.13053793f, 0.19275828f, 
    0.03689642f, -0.31747180f, 0.34843317f, 0.00279880f, 0.06127116f, 0.11176709f, -0.14679953f, 0.10901890f, 
    0.01584797f, -0.02185892f, -0.23792540f, 0.01198293f, 0.09896532f, 0.09435473f, 0.01221455f, 0.00729382f, 
    -0.02853542f, 0.01511683f, 0.21566044f, -0.00619728f, 0.08287036f, -0.15410793f, -0.02171041f, 0.20021033f, 
    0.18905158f, 0.21237619f, 0.11250411f, 0.09893784f, 0.05749983f, 0.11486113f, -0.09453782f, 0.10693980f, 
    0.01685994f, 0.00796765f, 0.02724329f, 0.08374445f, 0.01170813f, 0.00307094f, 0.17599653f, -0.12632272f, 
    -0.15560387f, 0.02520394f, -0.18491925f, 0.13872495f, -0.07886857f, -0.10761411f, -0.05485475f, -0.00439983f, 
    -0.01971475f, 0.15092571f, -0.03807020f, 0.21629997f, 0.09227838f, -0.04192213f, 0.08294746f, -0.09661558f, 
    -0.33288637f, -0.04409791f, -0.16382623f, -0.20142327f, 0.05324683f, 0.16245688f, -0.02100473f, 0.00101459f, 
    0.03683414f, -0.01658013f, 0.09352425f, 0.06345836f, 0.04275697f, 0.13675246f, -0.04399079f, 0.14708918f, 
    0.17912193f, 0.10399631f, 0.06001151f, 0.17146988f, -0.00722251f, 0.02825980f, 0.08493829f, 0.07181895f, 
    0.04940840f, 0.04733206f, -0.10194346f, 0.09936804f, -0.07509834f, 0.16340405f, -0.20908172f, 0.08944331f, 
    0.01031743f, 0.00852900f, 0.04006817f, 0.06407788f, 0.13612138f, -0.02770302f, -0.04167374f, -0.10054224f, 
    0.03768434f, 0.00998122f, 0.02927008f, 0.01596641f, 0.04815746f, -0.05045796f, -0.01632042f, -0.16944563f, 
    -0.00304851f, 0.05868298f, -0.13377105f, -0.09876462f, -0.20829840f, -0.39103362f, -0.26619336f, -0.08789364f, 
    0.14058942f, 0.09323023f, 0.03673136f, 0.07866281f, 0.13708496f, 0.05061173f, -0.02324602f, 0.10360309f, 
    -0.11972868f, -0.25868294f, -0.33830911f, 0.05306963f, -0.05818054f, 0.11543079f, -0.05759079f, 0.01267435f, 
    0.04261239f, -0.07660210f, 0.00644061f, -0.10492393f, -0.05775442f, -0.05032024f, -0.25381944f, 0.03200775f, 
    0.08518187f, -0.07924102f, 0.07459815f, -0.11257359f, 0.16943049f, 0.10412280f, 0.13031729f, 0.20835844f, 
    -0.15516943f, -0.08923548f, 0.01488202f, 0.10858782f, -0.08919105f, -0.00399776f, -0.18415047f, 0.00944564f, 
    0.05754188f, -0.00304406f, 0.02767971f, 0.03219852f, 0.20391364f, 0.18288402f, -0.03533207f, 0.05968605f, 
    -0.14447971f, 0.07410301f, -0.09356794f, -0.22854196f, 0.03408730f, 0.06642336f, -0.00445939f, -0.14136976f, 
    0.18662214f, 0.26257876f, 0.15724736f, 0.02448776f, 0.09100240f, 0.02125894f, -0.04446965f, 0.02340518f, 
    -0.14126024f, -0.02783498f, 0.01016847f, 0.04358971f, 0.06530932f, -0.03838922f, -0.06577642f, 0.11062058f, 
    -0.17630097f, 0.08027132f, -0.13506879f, 0.01394502f, 0.11557575f, -0.20486924f, 0.05082659f, 0.00767692f, 
    0.27104694f, 0.09549400f, 0.10036023f, 0.21980159f, 0.02279061f, -0.05176927f, 0.24675567f, 0.18363059f, 
    0.09139562f, -0.14051504f, -0.03518474f, 0.08959062f, -0.17735025f, -0.16280359f, 0.03610043f, 0.09844396f, 
    0.04333239f, 0.16662931f, -0.02971039f, 0.04485606f, 0.10500493f, -0.09392941f, -0.00203546f, 0.21962054f, 
    0.09882163f, 0.11911508f, 0.06748635f, 0.22891700f, -0.14362137f, -0.04521821f, 0.06591803f, 0.14866845f, 
    0.03110692f, 0.00175381f, 0.03200652f, -0.11663044f, 0.04890161f, 0.16231294f, 0.02297078f, 0.17774120f, 
    0.07046966f, 0.08453584f, 0.04890383f, -0.06619080f, 0.02439085f, -0.06560140f, 0.14856280f, 0.23210889f, 
    -0.08093893f, -0.07896528f, 0.06287877f, -0.20886028f, 0.03848236f, 0.04323749f, 0.06134099f, -0.14664854f, 
    0.00559522f, 0.03044903f, -0.01315050f, 0.13076888f, 0.16654873f, 0.19002672f, 0.14960411f, 0.24449447f, 
    -0.10020396f, -0.09267430f, 0.00944681f, 0.20508441f, 0.10666518f, 0.03721689f, -0.08162656f, -0.01539468f, 
    0.05933539f, 0.01127558f, -0.05703811f, 0.17034635f, 0.13187811f, -0.03452753f, -0.02194972f, 0.09334906f, 
    0.05735310f, -0.07461573f, 0.00999826f, 0.28316569f, 0.28436995f, 0.03834733f, 0.11930990f, 0.25770307f, 
    0.09137506f, -0.00825505f, 0.06953536f, -0.03570538f, 0.03831230f, -0.03064170f, -0.01529750f, 0.12368886f, 
    -0.21523964f, 0.08360220f, 0.28186730f, 0.04192574f, 0.11364858f, -0.16230515f, 0.08911737f, -0.08720082f, 
    0.00707901f, -0.02824006f, 0.04514207f, 0.18269694f, 0.07885954f, 0.13070537f, 0.09515338f, 0.41778493f, 
    -0.02849209f, -0.07440468f, -0.07035052f, -0.09963585f, 0.11902594f, 0.06324662f, 0.04221744f, 0.12254752f, 
    0.03593077f, 0.02752168f, -0.03325991f, 0.06340729f, 0.08141485f, 0.04269836f, -0.06623478f, 0.10270599f, 
    -0.12352616f, -0.01368909f, -0.04687244f, -0.12862070f, 0.09916953f, 0.10100488f, -0.01612423f, 0.10052863f, 
    0.03363591f, -0.01953400f, 0.05681833f, 0.05971210f, 0.07114753f, -0.00344760f, -0.00749548f, -0.05437287f, 
    -0.15102726f, -0.04773587f, 0.30313495f, 0.07313718f, -0.13454679f, 0.12483677f, -0.08467930f, 0.04184742f, 
    0.00085367f, 0.16166958f, 0.02758616f, 0.17322417f, 0.09048862f, 0.17190003f, 0.14777058f, 0.15127158f, 
    0.04923748f, 0.12628444f, 0.02909204f, -0.02091141f, -0.09695859f, 0.12726960f, -0.02778919f, 0.18148763f, 
    0.07434830f, 0.05384113f, 0.20659649f, 0.05219136f, 0.10141817f, 0.03905920f, -0.07688354f, 0.07268500f, 
    0.01610899f, -0.10040908f, -0.04361383f, -0.00170608f, -0.46617329f, -0.08686309f, -0.31413132f, -0.01410252f, 
    -0.08949868f, 0.08483333f, -0.15039490f, -0.07617132f, 0.03247188f, -0.11429962f, -0.13468118f, 0.08317015f, 
    -0.16810536f, 0.37092716f, -0.30636737f, 0.33358243f, -0.00922846f, 0.14009994f, -0.00340879f, -0.16490985f, 
    0.04171247f, 0.06251499f, 0.00343943f, -0.07319579f, -0.25544688f, -0.15880617f, -0.01338741f, -0.36281779f, 
    -0.00761992f, 0.02499143f, -0.16063081f, -0.08887850f, 0.01253147f, -0.00702746f, -0.08294269f, -0.04089454f, 
    0.26405624f, 0.05592068f, -0.05952974f, 0.21159765f, -0.00080771f, 0.03333079f, 0.09654125f, -0.08062588f, 
    0.04613774f, -0.25477615f, -0.06260578f, 0.06090392f, -0.00216168f, -0.22518435f, 0.00710538f, 0.14225742f, 
    0.05389921f, 0.12866595f, -0.08217119f, 0.17754258f, -0.04286392f, -0.05852308f, -0.02905950f, -0.27900013f, 
    0.11896031f, -0.02826509f, 0.08315060f, -0.01515906f, -0.04590705f, -0.04707332f, 0.04676629f, 0.02323155f, 
    -0.01625369f, -0.09687279f, -0.07866567f, -0.00836472f, 0.05824253f, -0.00775709f, 0.09836657f, 0.09827324f, 
    -0.02554497f, 0.03480399f, -0.14760804f, -0.15184914f, -0.00463311f, 0.04207465f, -0.03046226f, 0.08457220f, 
    -0.01150292f, -0.06263348f, 0.01346904f, 0.01588396f, -0.00993283f, -0.04226979f, 0.00655316f, -0.06839302f, 
    0.04584941f, -0.00456797f, -0.04426087f, -0.01570105f, 0.01018239f, 0.00525563f, 0.12574486f, 0.20945811f, 
    0.05340410f, 0.00941344f, 0.04626051f, 0.02198586f, 0.05843432f, 0.02140328f, -0.00190333f, 0.17900155f, 
    0.19825526f, 0.16051723f, 0.13269560f, 0.20263872f, -0.03703356f, 0.11094008f, -0.01599426f, 0.00081755f, 
    0.06258857f, -0.06653200f, -0.00039626f, -0.03119734f, 0.24037908f, -0.24567291f, 0.21746632f, -0.31904817f, 
    -0.02210263f, -0.02712607f, -0.17122459f, 0.08740574f, -0.09812229f, -0.07844517f, -0.03445449f, 0.00190210f, 
    -0.15943643f, -0.13054432f, 0.09216391f, 0.04235423f, -0.17160061f, -0.01540743f, -0.12967125f, -0.00889637f, 
    -0.02308726f, -0.07743155f, 0.10161989f, -0.02809718f, -0.26565930f, 0.01589437f, -0.18135858f, -0.01372309f, 
    0.07519022f, -0.00104569f, 0.02581120f, -0.00789583f, 0.05247356f, 0.08622316f, -0.05081034f, -0.08478961f, 
    -0.05743765f, -0.17882043f, -0.07827503f, -0.25754544f, 0.10402395f, 0.08731641f, 0.06408222f, 0.11018355f, 
    0.09281925f, 0.06654985f, 0.04193344f, 0.04636941f, -0.23392986f, 0.10496923f, -0.11589121f, -0.11256068f, 
    0.00680533f, -0.01281118f, 0.00257021f, -0.17309394f, 0.19565958f, 0.00999459f, 0.10559463f, 0.19456890f, 
    0.06112660f, 0.15575880f, 0.08960976f, 0.18630113f, -0.19873728f, 0.12238753f, -0.09375057f, 0.07184384f, 
    -0.00950079f, 0.05139304f, -0.05153684f, -0.18411796f, 0.13785674f, -0.00713709f, -0.00590981f, 0.01622335f, 
    0.25433233f, 0.11996259f, -0.01354568f, 0.02668367f, -0.04245859f, -0.04952419f, -0.14460939f, -0.18337995f, 
    -0.06063848f, -0.03937616f, -0.13669568f, 0.07063462f, 0.09175354f, 0.00615733f, -0.07881282f, -0.09379509f, 
    -0.07443244f, -0.13506174f, -0.12843871f, -0.16834362f, 0.34310254f, 0.11167251f, 0.21223973f, 0.14288041f, 
    0.11170314f, -0.11652921f, 0.04265051f, 0.01639635f, -0.00289956f, -0.10680877f, -0.05942369f, 0.11676863f, 
    -0.24940152f, -0.49389583f, -0.31591871f, -0.07711740f, 0.03526679f, 0.03894648f, 0.03060427f, 0.02451817f, 
    0.00385047f, 0.04188732f, 0.01206056f, -0.07105828f, -0.26483428f, -0.23436205f, -0.38068134f, 0.06316845f, 
    0.09968337f, 0.09854489f, 0.14342575f, 0.08194952f, 0.27113438f, 0.09198826f, 0.06166244f, 0.04808407f, 
    -0.13823394f, 0.01343507f, -0.16136928f, -0.05889520f, 0.05544211f, -0.07845759f, -0.01856297f, -0.10183736f, 
    0.11048280f, 0.06833670f, 0.00524646f, 0.08017552f, -0.05836944f, 0.23219289f, -0.21484798f, 0.30892906f, 
    -0.07389073f, 0.08958307f, -0.02552445f, -0.00473612f, -0.00067890f, 0.03382720f, 0.06459208f, -0.21959582f, 
    -0.03459422f, 0.02051556f, -0.02662286f, 0.00552730f, 0.01563056f, -0.02892353f, -0.04117915f, -0.04013114f, 
    0.01508235f, 0.01339294f, -0.03570190f, -0.03724706f, 0.00043119f, 0.01971640f, -0.00986141f, 0.02744106f, 
    0.00329542f, 0.00314612f, -0.01860693f, 0.02410325f, -0.00690701f, 0.01567547f, 0.01226722f, -0.01517904f, 
    0.00108748f, -0.01464318f, 0.02788180f, 0.00097550f, -0.01145834f, -0.03188738f, -0.04172359f, -0.00488774f, 
    0.02123162f, -0.01719347f, 0.02361999f, -0.02858025f, -0.02680251f, -0.01372167f, -0.03383953f, -0.03741552f, 
    -0.02662452f, -0.03098772f, -0.03823680f, -0.00426844f, -0.00839260f, -0.00817613f, -0.03930013f, 0.02363673f, 
    -0.02212661f, -0.01950385f, -0.02269885f, -0.02862000f, -0.00666880f, -0.00948521f, 0.01704549f, -0.02198294f, 
    -0.01946219f, 0.02707202f, -0.03519776f, 0.00313168f, 0.02750009f, 0.01897258f, -0.02089995f, -0.00166837f, 
    0.01970931f, 0.02152906f, -0.01710030f, -0.01505818f, -0.00141932f, 0.00880090f, -0.01646347f, -0.04049804f, 
    -0.00165490f, -0.00419243f, -0.04144460f, 0.01296538f, 0.02041286f, 0.00167685f, -0.02105903f, -0.03803053f, 
    -0.02637505f, -0.01865143f, -0.01356015f, -0.03016575f, -0.02840185f, -0.03317602f, -0.03680704f, 0.02084253f, 
    -0.03436721f, 0.01346127f, -0.04141907f, 0.02448653f, -0.02287130f, -0.00545129f, -0.01663024f, -0.00690518f, 
    -0.00540868f, 0.01292992f, 0.02301777f, -0.00428715f, -0.01908191f, -0.01833653f, -0.01123150f, 0.01197116f, 
    0.02936729f, -0.00510086f, -0.00005772f, -0.01155496f, 0.01941427f, -0.03437832f, 0.01654294f, 0.00792735f, 
    -0.01750647f, 0.02815283f, -0.00770235f, -0.02408786f, -0.00437476f, 0.00343834f, -0.04068380f, -0.01678128f, 
    -0.01904053f, -0.03122709f, -0.00186222f, 0.00842820f, 0.01205159f, 0.00700484f, -0.02953003f, 0.01974572f, 
    -0.00733363f, 0.01782362f, 0.02718755f, 0.02936521f, 0.01044811f, -0.04186297f, -0.03601562f, -0.00528542f, 
    -0.01642357f, -0.03984199f, -0.02441637f, -0.01794943f, -0.04013213f, 0.00576894f, -0.00439154f, -0.00621434f, 
    0.01663177f, -0.02007977f, 0.02897669f, -0.00746930f, -0.00900336f, 0.01607320f, -0.03803659f, -0.01184120f, 
    0.00435721f, -0.00783802f, -0.00912371f, -0.02607704f, 0.01170359f, 0.00835115f, 0.00344512f, -0.03534308f, 
    0.02618839f, -0.03166846f, -0.03042414f, -0.01236690f, 0.02394815f, -0.00769503f, -0.01720309f, -0.00316313f, 
    0.02164300f, 0.01401929f, 0.01461538f, 0.00345342f, -0.03026356f, -0.03555801f, 0.02729028f, -0.00783523f, 
    0.01668853f, 0.02097407f, -0.02927256f, -0.01094699f, 0.02669430f, -0.01537113f, -0.03073828f, -0.02105551f, 
    -0.03000012f, -0.02423815f, 0.02220687f, 0.02762635f, -0.02703955f, -0.02302697f, 0.00029992f, -0.03376541f, 
    0.02961144f, -0.00628600f, -0.02527927f, -0.02389500f, -0.02608305f, -0.01661408f, 0.00601314f, -0.02465085f, 
    -0.01759496f, -0.03119019f, 0.01920195f, -0.01552307f, 0.00349421f, 0.00276416f, 0.01866844f, -0.03752173f, 
    0.01885748f, 0.01642652f, -0.02646963f, 0.00851169f, -0.01051564f, -0.01933460f, -0.00817507f, 0.02652361f, 
    0.02399086f, 0.00162048f, 0.02404513f, 0.00398130f, 0.01816814f, 0.02577740f, 0.00423205f, -0.03183190f, 
    0.02945702f, -0.00942442f, 0.01813583f, 0.01408585f, -0.04120253f, -0.01026528f, 0.01286774f, 0.00570042f, 
    -0.00941915f, 0.02470764f, -0.00999046f, -0.03135179f, -0.02152457f, 0.01583018f, 0.01569411f, 0.01325239f, 
    -0.01962734f, 0.02747790f, -0.01995192f, 0.00039153f, 0.01443563f, -0.02515411f, 0.00686848f, -0.01028398f, 
    -0.03434038f, 0.00267845f, -0.03593805f, -0.03675842f, -0.04107662f, 0.02378352f, 0.02683028f, -0.01426482f, 
    0.02672752f, 0.01133594f, -0.02732667f, -0.01643719f, 0.00880994f, -0.04188494f, -0.03157865f, -0.02049466f, 
    0.01602316f, -0.00902819f, -0.01965397f, 0.02269731f, -0.04057674f, 0.01918121f, -0.01148686f, -0.02253426f, 
    0.00371013f, -0.01859874f, -0.00081179f, -0.02938920f, -0.00090619f, -0.02447522f, 0.01658070f, -0.02366102f, 
    0.02776848f, 0.02751555f, -0.02594117f, 0.00576441f, 0.01972109f, 0.00750888f, -0.03613773f, -0.02938968f, 
    -0.00111057f, 0.01399914f, 0.01035074f, 0.00607849f, -0.00114090f, 0.00260285f, -0.03424580f, 0.00086678f, 
    -0.04095933f, 0.01467719f, 0.01463235f, 0.01251697f, -0.01110275f, -0.01883088f, -0.02753694f, 0.01178458f, 
    -0.01431084f, -0.02162521f, 0.02696827f, -0.01303344f, 0.00488069f, -0.01147328f, 0.00774473f, -0.02845551f, 
    -0.01500170f, 0.00133959f, -0.02395931f, 0.02510790f, -0.01410473f, 0.01792056f, -0.03616339f, 0.01734108f, 
    -0.01378392f, 0.02787657f, -0.02334412f, -0.00130686f, -0.01110068f, 0.00805425f, 0.02027467f, -0.01461794f, 
    -0.03712625f, 0.00859069f, -0.04208072f, 0.00448841f, 0.02522402f, 0.02972786f, -0.01389126f, -0.01879302f, 
    0.01590144f, -0.01142752f, -0.03275708f, 0.01830148f, 0.00503229f, 0.03446994f, 0.02415336f, -0.03192499f, 
    -0.03843749f, 0.03381162f, 0.00503804f, -0.03349910f, -0.01702110f, 0.01228744f, 0.01911750f, -0.00331493f, 
    0.02305437f, 0.01227754f, 0.02430605f, -0.00411246f, 0.01245263f, -0.01519437f, -0.03278469f, -0.03012275f, 
    -0.02546586f, -0.03227492f, -0.00783451f, -0.01501983f, -0.00631494f, -0.02031633f, -0.03687052f, 0.02544355f, 
    -0.01057923f, -0.03500487f, -0.00900491f, -0.03986211f, -0.02605639f, -0.00534192f, 0.02147266f, 0.02473420f, 
    -0.03803286f, 0.01249008f, 0.01376211f, 0.00810459f, -0.02889119f, -0.03975362f, -0.00408795f, -0.03409128f, 
    -0.02645239f, 0.00363584f, -0.03803517f, 0.01849342f, -0.03264604f, -0.02564472f, -0.03178344f, -0.01180959f, 
    0.01317448f, 0.00584440f, -0.01269550f, 0.02605218f, 0.00396169f, -0.00423372f, -0.03729639f, -0.04159445f, 
    -0.01863990f, 0.01618664f, -0.00562192f, -0.01218748f, -0.00538597f, 0.02842453f, 0.00742816f, 0.01534655f, 
    0.01848093f, -0.03949927f, -0.01791362f, -0.01968003f, -0.00786332f, -0.01974307f, 0.01842030f, 0.01694074f, 
    -0.03588932f, -0.00908061f, 0.02839569f, -0.01264750f, -0.01121713f, 0.01644126f, -0.02097574f, 0.01298912f, 
    -0.02780859f, -0.00352752f, -0.00890282f, -0.01564945f, -0.02783488f, -0.00039199f, -0.01825944f, 0.00284774f, 
    -0.00484587f, -0.02488423f, -0.03809493f, 0.00401786f, -0.03531560f, 0.01432944f, 0.00647464f, 0.02606893f, 
    -0.00706041f, -0.03437072f, -0.03262341f, -0.02207728f, 0.01248326f, -0.00465917f, -0.02592420f, -0.00105216f, 
    -0.02095439f, -0.04188399f, -0.01336100f, -0.03637107f, -0.01603825f, -0.00630495f, -0.03441554f, -0.02612186f, 
    0.02194572f, -0.01203182f, -0.02987348f, -0.02344490f, -0.01438360f, 0.01636791f, 0.00743186f, -0.00047433f, 
    0.00809930f, -0.03068577f, -0.02244481f, -0.03714051f, 0.00707116f, 0.01069892f, 0.02633690f, 0.02025965f, 
    -0.02541018f, -0.01344953f, 0.01089206f, -0.00862009f, 0.00441988f, 0.00695942f, -0.00438845f, 0.01977939f, 
    0.00797814f, -0.01348262f, -0.00910833f, -0.00306765f, -0.03267759f, -0.04166732f, -0.01039622f, 0.01461826f, 
    0.01699584f, 0.01146531f, -0.04120394f, -0.02476870f, 0.00932129f, 0.00980845f, 0.02797359f, -0.00511294f, 
    -0.03926248f, -0.03611795f, -0.02431656f, -0.04037642f, -0.01253507f, -0.03893489f, -0.02049877f, 0.02610690f, 
    -0.04191704f, -0.02810958f, 0.02037551f, 0.02053069f, 0.00634302f, 0.01254691f, -0.03943085f, -0.00742849f, 
    -0.04041431f, -0.04079007f, 0.02202381f, 0.00790876f, -0.01243859f, -0.02548830f, 0.00768021f, 0.00087122f, 
    0.02137973f, 0.02639448f, -0.02808714f, -0.02113411f, -0.03260653f, -0.02201500f, 0.00181759f, 0.02025628f, 
    -0.03254123f, -0.02888182f, -0.02944138f, -0.02589360f, -0.02715920f, 0.01475591f, -0.00165090f, -0.01035022f, 
    -0.04199552f, -0.02503518f, 0.01673164f, -0.03575807f, -0.04132460f, -0.00643367f, -0.02762039f, 0.01953308f, 
    0.02083508f, 0.02323788f, 0.00351596f, 0.01930938f, 0.02475191f, -0.00416347f, -0.01287804f, -0.01727386f, 
    0.02493129f, 0.02432516f, 0.02003476f, -0.02843610f, 0.01266509f, -0.01336515f, -0.03670724f, 0.00895587f, 
    0.02358474f, 0.00491803f, -0.00705878f, -0.00264516f, -0.00645179f, 0.01292851f, -0.02994903f, 0.01543457f, 
    0.00014256f, -0.01618030f, -0.00624176f, -0.03077736f, -0.02995674f, -0.01835425f, -0.00740045f, -0.00769196f, 
    -0.02760778f, 0.02749377f, -0.01558259f, -0.03123436f, -0.01486771f, -0.02489624f, -0.01437147f, 0.02563574f, 
    -0.02901827f, 0.00616626f, -0.00661329f, -0.03032799f, -0.00360770f, -0.02297067f, -0.02511574f, -0.00858988f, 
    0.00893063f, 0.00749328f, -0.00025048f, 0.01543012f, -0.01774960f, 0.02494874f, 0.00276011f, -0.03374218f, 
    0.00629538f, 0.02253222f, 0.02047248f, -0.03332321f, -0.02166132f, -0.01821499f, -0.00013955f, -0.01723719f, 
    0.02028692f, -0.04189939f, -0.01679843f, -0.03464433f, -0.01865894f, 0.00110598f, -0.01525240f, 0.00427831f, 
    -0.01380168f, 0.00254645f, -0.02451627f, -0.00819444f, 0.02593436f, 0.00168020f, -0.04099829f, -0.03824146f, 
    0.00192850f, -0.03336855f, 0.02700339f, -0.01594020f, -0.03883945f, 0.02662182f, -0.02016613f, -0.00547804f, 
    -0.01807473f, -0.02631352f, -0.01221399f, 0.01665718f, 0.01708830f, 0.00762448f, -0.01818340f, 0.02286509f, 
    -0.02417012f, 0.00911736f, 0.01187729f, -0.04179232f, -0.01174098f, 0.01534887f, 0.02472575f, -0.02184420f, 
    -0.03270080f, 0.00028852f, -0.03944142f, -0.02697773f, 0.01089892f, 0.02058669f, 0.02113934f, -0.00207603f, 
    -0.04148435f, 0.02701805f, -0.00297063f, -0.00588433f, 0.00716683f, 0.00453184f, 0.01459546f, 0.02442649f, 
    -0.02212670f, -0.04091585f, 0.02204036f, 0.00327835f, 0.00179133f, -0.03027958f, 0.03001217f, -0.00494128f, 
    -0.03671345f, -0.03112639f, -0.03582248f, -0.03596420f, 0.00447817f, -0.01008982f, -0.03814209f, 0.02174284f, 
    -0.03001987f, 0.00035619f, -0.01785478f, -0.01915678f, 0.00429817f, -0.00380180f, 0.01674456f, -0.03026466f, 
    -0.03760832f, 0.02422251f, 0.00154336f, -0.02024034f, -0.02498485f, -0.00515776f, -0.01938955f, -0.01780367f, 
    0.02584662f, 0.02079207f, 0.01859587f, -0.00873147f, 0.02454116f, 0.01117731f, -0.01848439f, -0.01358925f, 
    -0.00866496f, 0.02063546f, 0.01746780f, -0.03728621f, -0.00121340f, -0.01547915f, -0.03798826f, 0.02082896f, 
    0.02898569f, 0.02049444f, -0.00826132f, -0.00499223f, 0.01654206f, 0.02558511f, 0.01985942f, 0.01926036f, 
    -0.03425797f, -0.00571912f, 0.01571426f, 0.02898895f, -0.01937637f, -0.00436994f, -0.00506664f, -0.02534908f, 
    -0.04195889f, -0.01941760f, 0.02913253f, -0.00455488f, -0.00621910f, 0.00583091f, 0.00430774f, -0.00967755f, 
    0.00206172f, -0.02327447f, 0.00853536f, -0.02957674f, -0.03857768f, -0.00706380f, 0.02615090f, -0.02004430f, 
    -0.02408342f, 0.01985878f, -0.02044911f, -0.01686222f, 0.02030657f, 0.02455312f, 0.00145215f, -0.04052689f, 
    0.02303830f, 0.00295765f, 0.00674315f, -0.01321163f, -0.02922121f, 0.00458429f, -0.04151032f, 0.00803504f, 
    0.02483236f, 0.01218964f, -0.01854723f, 0.00406210f, 0.01393736f, -0.02143316f, -0.00582679f, 0.02988681f, 
    -0.24225709f, -0.12352219f, 0.26645687f, 0.15105872f, -0.03868263f, -0.04780348f, 0.05475437f, 0.14410771f, 
    0.02503998f, 0.07414925f, 0.11490759f, 0.07377469f, -0.11939606f, 0.08276780f, 0.13267680f, -0.10400936f, 
    -0.01281883f, -0.15977511f, 0.24192883f, -0.00377329f, -0.12089553f, 0.03310452f, 0.11639531f, 0.15287721f, 
    -0.17031811f, 0.06257988f, -0.18423219f, 0.14753491f, -0.00544502f, 0.10655958f, 0.18832208f, -0.00865586f, 
    -0.04335747f, -0.03625385f, 0.04132643f, 0.02370612f, -0.28168234f, -0.20105848f, -0.15099382f, -0.18256930f, 
    -0.17776881f, 0.03903310f, -0.03713319f, 0.02822998f, 0.03493056f, 0.05842832f, 0.05706304f, -0.21198311f, 
    0.13596852f, 0.07382253f, 0.15005855f, -0.12644652f, -0.03770175f, -0.03980530f, -0.00033249f, -0.08814129f, 
    -0.17032184f, -0.07386094f, 0.05402037f, 0.10535286f, -0.18678759f, -0.15194052f, 0.24729605f, 0.21090327f, 
    -0.10545024f, -0.03464736f, -0.05180031f, 0.01710952f, -0.00080260f, 0.11807709f, 0.04343114f, -0.11871421f, 
    -0.24701059f, -0.24857984f, -0.32676664f, 0.20529677f, -0.01455350f, 0.17856736f, 0.08062243f, -0.02759461f, 
    0.00320567f, 0.07838417f, 0.03924552f, -0.03730923f, -0.11458418f, -0.14468886f, 0.14149863f, 0.19413692f, 
    -0.00528541f, 0.11754874f, -0.08157671f, -0.07563489f, 0.00698901f, -0.05041510f, 0.00011538f, 0.10549694f, 
    0.35717410f, -0.08954502f, -0.00554024f, -0.01046851f, -0.25994438f, 0.06537580f, -0.00166988f, -0.02851583f, 
    0.05967380f, -0.00768302f, 0.05291058f, 0.05054957f, -0.26407105f, -0.05717537f, -0.09214427f, 0.33155006f, 
    -0.13681161f, -0.01450472f, -0.06451070f, 0.00587874f, 0.08684394f, -0.06544649f, -0.15248103f, 0.05604880f, 
    -0.36011928f, -0.02068768f, 0.11419204f, 0.16107704f, 0.09270814f, 0.22379535f, -0.20328519f, -0.12457761f, 
    0.04250890f, -0.16592363f, 0.13306215f, -0.04852161f, 0.53842616f, -0.04790014f, 0.15817952f, 0.03183773f, 
    0.09336533f, 0.02405673f, 0.00190016f, 0.03413042f, -0.10314149f, -0.03475910f, 0.12349767f, 0.09342229f, 
    -0.04615116f, 0.21517448f, 0.15025058f, 0.11782279f, 0.10712578f, 0.07238845f, 0.02849968f, 0.13933240f, 
    -0.00853380f, -0.07647221f, -0.00395519f, 0.07851770f, 0.16116120f, 0.21556170f, 0.09683439f, 0.10673536f, 
    -0.03439300f, 0.10422105f, -0.03304259f, -0.16922832f, 0.14342107f, 0.03937519f, 0.10325388f, -0.07968017f, 
    0.36184174f, -0.08781402f, 0.21134910f, -0.01531899f, 0.03021643f, 0.05964243f, 0.04197344f, -0.03716550f, 
    -0.10026661f, 0.12870641f, 0.12739512f, -0.00578366f, -0.22922572f, -0.10788912f, 0.09357588f, 0.15221369f, 
    0.00395688f, 0.08065175f, -0.00707204f, -0.00106800f, 0.04757262f, 0.00032096f, -0.02697945f, -0.04862272f, 
    0.27504772f, 0.38231996f, -0.10170269f, -0.25600791f, -0.06408071f, 0.09439854f, -0.07293180f, -0.05093770f, 
    -0.13111430f, -0.04533777f, -0.01515187f, -0.02499941f, -0.21321271f, -0.04947087f, 0.14735617f, -0.20033467f, 
    0.00318611f, -0.16242449f, 0.11824951f, 0.05447256f, 0.03054884f, 0.06200660f, 0.06957459f, -0.03707460f, 
    -0.16351350f, 0.03807968f, -0.00181292f, -0.03961454f, 0.01955562f, -0.00772899f, -0.07757109f, 0.14923160f, 
    0.05075030f, 0.01888976f, 0.19026260f, 0.02786618f, -0.16871510f, -0.11456390f, -0.00159411f, -0.22128043f, 
    -0.19260150f, -0.20656830f, -0.00003918f, -0.05516088f, 0.01337454f, 0.04945690f, -0.18542573f, -0.08368141f, 
    -0.26670685f, 0.03669266f, -0.27751902f, -0.25294498f, -0.12370535f, -0.12387187f, 0.02344861f, -0.13115031f, 
    0.05324543f, 0.08307561f, 0.04567736f, 0.02622734f, 0.10620300f, 0.03089937f, 0.05205520f, -0.13007380f, 
    -0.12161925f, -0.14234239f, 0.03080503f, -0.08676644f, -0.01664145f, 0.15890172f, -0.15941517f, -0.01202770f, 
    -0.13075396f, -0.22790256f, 0.14900540f, 0.07260417f, -0.00324424f, -0.06354401f, -0.07521104f, -0.05880751f, 
    -0.03349711f, -0.02356817f, -0.06572842f, -0.13970922f, -0.12916939f, 0.07063492f, -0.11037105f, 0.08756627f, 
    -0.19847907f, 0.18108113f, 0.04715532f, 0.07629132f, -0.07305923f, 0.20885728f, 0.04292348f, 0.09704968f, 
    0.13886006f, 0.18851478f, 0.15714243f, 0.26690623f, 0.06452307f, -0.04703151f, 0.14586549f, 0.08471457f, 
    0.02378007f, 0.07805686f, -0.09057888f, 0.09129202f, 0.44362140f, -0.09574007f, -0.14602947f, -0.07493959f, 
    -0.19045748f, -0.16313089f, -0.07990550f, -0.03598748f, 0.05443338f, -0.09516118f, -0.05688144f, 0.01933967f, 
    -0.02278305f, -0.09081433f, 0.16884522f, 0.10396000f, -0.08528938f, -0.04629305f, 0.15482526f, 0.26025674f, 
    -0.07747444f, 0.07898777f, 0.08005846f, 0.00938793f, -0.10379639f, -0.14187005f, -0.08165135f, 0.16270627f, 
    0.00083664f, 0.09862260f, -0.02014915f, -0.12933123f, 0.07982024f, 0.08788412f, -0.00447142f, 0.00518902f, 
    -0.18509631f, -0.12901182f, 0.17754477f, 0.40042102f, -0.12874754f, -0.00388204f, -0.01665819f, 0.06127082f, 
    0.12026867f, 0.05699751f, 0.06993159f, -0.03775337f, 0.04748665f, -0.07179116f, -0.30750403f, 0.03629224f, 
    0.06128676f, 0.05692353f, 0.08065166f, -0.01711267f, -0.01456710f, 0.22765635f, 0.00430833f, -0.07335130f, 
    0.09708658f, 0.16919342f, -0.13675751f, -0.11079082f, -0.06771078f, 0.08889119f, 0.02405691f, -0.12353338f, 
    0.10165679f, -0.01546620f, 0.17589827f, 0.13274279f, -0.09895431f, -0.17304741f, 0.08904024f, 0.24665228f, 
    -0.15888019f, 0.01846954f, 0.08207944f, 0.19669071f, 0.07037540f, 0.01871252f, 0.11088350f, 0.07848974f, 
    0.11824773f, -0.07458173f, 0.03069019f, 0.04471710f, 0.07289339f, 0.05354256f, -0.01903708f, 0.04314861f, 
    -0.12884343f, -0.01818625f, -0.09918330f, -0.06330606f, 0.18097000f, 0.19169706f, -0.01680348f, -0.05675717f, 
    0.01017472f, 0.07631557f, 0.01830924f, 0.00791072f, 0.01977648f, -0.04612524f, -0.02246049f, -0.00957310f, 
    0.08142038f, 0.10438585f, 0.08520424f, 0.26947564f, 0.05737104f, 0.01599879f, 0.12748650f, 0.07498857f, 
    -0.02201601f, -0.11593543f, -0.15107442f, -0.04814235f, -0.20495489f, -0.21777296f, -0.00895368f, 0.21903920f, 
    -0.11055139f, -0.15091936f, -0.21063289f, -0.13917358f, -0.00645207f, 0.02220655f, -0.02101072f, 0.03987376f, 
    0.22278887f, 0.04698213f, 0.37288952f, 0.14821430f, -0.00771412f, -0.01040524f, 0.01949102f, 0.17145191f, 
    0.04570581f, 0.03700302f, 0.09129149f, -0.03167790f, 0.16326533f, -0.29270336f, 0.12958679f, 0.12163584f, 
    -0.13018411f, 0.09307867f, 0.08165870f, -0.02710255f, 0.01107282f, 0.06021033f, -0.06075177f, -0.03490745f, 
    -0.10048883f, 0.20083864f, -0.19691923f, -0.00250535f, -0.08678222f, 0.15032679f, -0.05597937f, 0.03189358f, 
    0.00223852f, 0.03663208f, -0.15745685f, -0.22620776f, -0.27843332f, -0.05229403f, -0.11071635f, 0.08936114f, 
    0.05441352f, 0.14069639f, 0.12430399f, 0.15685800f, -0.08245592f, 0.03226128f, -0.02117606f, 0.00449904f, 
    -0.22318698f, -0.24737841f, 0.10754220f, 0.12689440f, -0.02538037f, 0.05848809f, -0.08786558f, -0.06176466f, 
    0.18091099f, -0.07660907f, -0.18060672f, 0.03958128f, -0.29317123f, 0.27055371f, -0.16049206f, -0.31327009f, 
    0.01072755f, -0.11397099f, 0.04178844f, 0.03386448f, 0.06102210f, -0.01030019f, 0.02604124f, -0.00842384f, 
    -0.06551205f, -0.37390363f, 0.15158397f, 0.06746698f, 0.07565434f, -0.17223056f, 0.08536647f, 0.02087844f, 
    -0.02723584f, -0.04739937f, -0.01979494f, -0.04532666f, 0.06230364f, 0.15749140f, 0.02056442f, -0.10561647f, 
    0.01718915f, -0.02463990f, 0.03111364f, -0.13202326f, -0.03922832f, 0.13365832f, 0.15602078f, -0.06462003f, 
    0.24946104f, 0.28764683f, 0.02863160f, 0.13314833f, -0.25872421f, 0.20598105f, 0.12650762f, 0.06072943f, 
    -0.18159935f, -0.00146441f, 0.02124884f, 0.00709630f, -0.12486538f, -0.16976555f, -0.18032041f, -0.01058603f, 
    -0.01745277f, -0.01212224f, 0.02715451f, 0.01139868f, -0.11130662f, 0.12518997f, 0.16939208f, 0.04856047f, 
    -0.26734525f, 0.14197594f, 0.00137095f, 0.20851314f, -0.12291776f, 0.04492063f, -0.03061702f, 0.02794529f, 
    -0.08001392f, 0.04008085f, 0.11004846f, 0.03356486f, 0.09115859f, 0.19445875f, -0.09569696f, -0.23177394f, 
    -0.22790894f, 0.11316223f, -0.01985830f, -0.01724440f, -0.02041896f, 0.11317378f, 0.11833419f, 0.18692631f, 
    -0.09599090f, -0.19744606f, -0.02538862f, 0.09541020f, -0.08674780f, -0.00102657f, -0.11384700f, -0.11940466f, 
    0.03161144f, -0.00863256f, -0.07240929f, -0.13797273f, 0.04444084f, 0.07817243f, 0.02388665f, 0.04997411f, 
    -0.03375681f, 0.03874797f, -0.02754857f, 0.10937165f, -0.13012385f, -0.04107819f, -0.19717743f, -0.16060755f, 
    0.12159243f, -0.09584755f, 0.17051218f, 0.30724517f, 0.09851661f, -0.02247985f, 0.09883410f, -0.00067724f, 
    -0.03698485f, -0.03216545f, 0.04232958f, 0.15239130f, -0.37883788f, -0.00283979f, -0.08506944f, 0.22452347f, 
    -0.07332859f, 0.19604906f, -0.14492576f, 0.07215241f, -0.13666898f, -0.05297100f, 0.19714135f, 0.05903246f, 
    -0.34325168f, 0.06535467f, -0.33368355f, 0.08014745f, -0.06234540f, -0.10890474f, 0.01181591f, -0.05860847f, 
    0.04330723f, 0.14456606f, -0.00578415f, -0.05221481f, -0.10973766f, 0.13047203f, 0.32141048f, -0.06544671f, 
    -0.02715783f, -0.07540045f, 0.02153520f, -0.08148237f, -0.03929021f, 0.09098179f, 0.02991566f, 0.02646271f, 
    0.18770115f, 0.18023448f, 0.06894185f, -0.11822179f, 0.05701799f, -0.07173498f, -0.13145344f, -0.16527592f, 
    -0.16738838f, 0.01908894f, 0.00895500f, 0.16352631f, -0.05520127f, 0.27761731f, 0.08209721f, -0.02823674f, 
    -0.01605749f, -0.19431749f, 0.11680941f, -0.07505237f, 0.05780920f, -0.04586818f, -0.05750197f, 0.00278323f, 
    -0.21213968f, -0.12401298f, -0.05835960f, 0.16930291f, -0.07619255f, -0.06360237f, 0.07717951f, 0.04325094f, 
    0.08915665f, -0.00478888f, -0.06234774f, -0.00940514f, 0.08252054f, 0.12059112f, 0.06110027f, 0.04968061f, 
    0.05201959f, -0.04120295f, 0.09748862f, 0.10776483f, 0.07972089f, 0.11932935f, 0.05776795f, 0.02227383f, 
    0.15156765f, -0.01642457f, -0.01547949f, 0.02170009f, -0.02032606f, -0.04656421f, 0.08332943f, 0.08244599f, 
    0.15366784f, 0.04092439f, 0.07366265f, 0.06995322f, 0.30152473f, 0.17101005f, 0.30407390f, 0.10006317f, 
    -0.03487748f, -0.03278044f, -0.03732404f, 0.02745475f, 0.09091022f, 0.07834703f, 0.09962972f, 0.16970198f, 
    0.02415136f, 0.19703037f, -0.07289547f, -0.29527918f, -0.14058308f, 0.02697893f, 0.03265026f, -0.06770159f, 
    0.02456052f, -0.01645518f, 0.11682326f, -0.06822793f, -0.15102914f, 0.17339247f, -0.08177605f, -0.23447458f, 
    -0.15711981f, -0.16100252f, -0.09707452f, -0.12658602f, -0.15876669f, -0.12714739f, -0.09196540f, 0.03569532f, 
    0.14830054f, 0.30499586f, 0.10195869f, -0.17567766f, -0.15359859f, -0.09212884f, -0.06177715f, -0.04451287f, 
    -0.12773398f, -0.07715162f, -0.05999444f, -0.00345169f, 0.00287137f, -0.34802353f, 0.46791461f, 0.16027975f, 
    0.10726878f, -0.21182564f, 0.15975991f, 0.04180067f, -0.00521133f, -0.03382475f, 0.09284573f, 0.10243775f, 
    0.01067168f, 0.01940222f, -0.02456978f, 0.03399676f, 0.01532282f, -0.01607835f, -0.03175262f, -0.03542302f, 
    0.02752984f, -0.03162616f, -0.02542691f, -0.02127596f, -0.03577588f, 0.02714822f, 0.01435706f, 0.02572700f, 
    -0.00248239f, 0.02626388f, -0.00211248f, 0.00605683f, 0.00838948f, -0.02278139f, 0.02156075f, -0.02770071f, 
    -0.01383188f, -0.02531320f, 0.03395120f, -0.01471965f, 0.02669770f, -0.00663076f, -0.00683580f, -0.00056033f, 
    0.00729241f, 0.01566410f, -0.02745022f, -0.03716002f, 0.00035678f, 0.00394490f, 0.00471958f, -0.01144285f, 
    0.02181848f, -0.01092255f, 0.02609091f, 0.00304151f, 0.00099220f, 0.01632538f, -0.01794879f, -0.02321293f, 
    0.01448304f, 0.01277762f, -0.03153067f, 0.02893141f, -0.01446299f, -0.01425258f, -0.04183356f, -0.03923836f, 
    -0.01148693f, -0.00456536f, -0.03734904f, 0.01658504f, -0.00899385f, -0.02182464f, -0.00070812f, 0.00740212f, 
    -0.03795604f, -0.00233984f, 0.02016329f, -0.00271279f, -0.02957322f, 0.04104449f, -0.00577189f, 0.02502815f, 
    -0.03617604f, -0.02814693f, -0.00213942f, 0.00698547f, -0.03529330f, -0.00574104f, -0.02338060f, -0.02576968f, 
    0.00401972f, -0.00423307f, -0.02689148f, -0.03695158f, 0.01432083f, 0.01199248f, -0.02079385f, -0.01095754f, 
    -0.01965312f, -0.01297238f, 0.01806384f, -0.00218141f, -0.02733120f, 0.00275549f, 0.02270666f, 0.00844123f, 
    -0.03247622f, -0.03597977f, -0.04000523f, 0.01945491f, -0.01422338f, -0.02275531f, -0.02336226f, -0.02923239f, 
    -0.03851616f, -0.03905733f, -0.00346680f, -0.01202037f, -0.03537025f, -0.01066643f, 0.00188656f, -0.01752517f, 
    -0.02493780f, -0.03375435f, 0.01829158f, 0.02880907f, 0.00055276f, 0.00631695f, 0.02158582f, 0.02241770f, 
    -0.03454670f, -0.01141858f, 0.01322106f, -0.03393674f, -0.04229054f, -0.03644295f, 0.01721863f, -0.01218034f, 
    -0.01148942f, -0.02529338f, 0.02888168f, -0.01439806f, -0.03748317f, 0.02472897f, 0.02872283f, 0.01067464f, 
    -0.04130674f, -0.03909910f, 0.02173130f, -0.00934625f, 0.01842017f, -0.02169390f, -0.03462885f, 0.02896022f, 
    -0.02897692f, -0.03260569f, -0.03091566f, 0.01722279f, -0.00465278f, 0.01187099f, -0.00385194f, -0.01293692f, 
    -0.04152478f, 0.00758831f, 0.02512324f, -0.02860925f, 0.01369530f, -0.00571349f, 0.00453014f, -0.01750328f, 
    -0.02625631f, 0.02428259f, 0.00823182f, -0.02801068f, 0.01732228f, 0.00850119f, 0.02763922f, 0.00325467f, 
    0.00100670f, 0.01799203f, 0.01020688f, 0.00080335f, -0.03231137f, -0.01977280f, -0.02006523f, -0.03273423f, 
    -0.01097373f, -0.00397232f, 0.01479844f, -0.04065346f, -0.00369840f, -0.00672806f, -0.04252748f, 0.02117037f, 
    -0.00480955f, -0.00216895f, 0.01727682f, 0.00443271f, -0.03683209f, -0.00644818f, -0.04135374f, -0.01328893f, 
    -0.00433140f, 0.01319982f, -0.02464710f, -0.02169713f, -0.02105092f, -0.00257539f, 0.00420978f, 0.00313503f, 
    0.00518803f, -0.00313644f, -0.03062736f, -0.00940251f, 0.02143825f, -0.00868324f, -0.01357465f, 0.02471852f, 
    -0.03107485f, 0.01063343f, -0.02947612f, 0.02940496f, -0.04040354f, -0.03629700f, -0.00412187f, -0.03530000f, 
    0.00848470f, 0.01067524f, 0.01448001f, -0.02655829f, -0.01459165f, -0.02611260f, 0.02006938f, -0.01704635f, 
    0.00328533f, 0.01055031f, -0.02971661f, 0.02400989f, -0.02892651f, 0.00180448f, -0.00415636f, 0.01551887f, 
    0.02812942f, 0.01921222f, 0.01588020f, 0.02245425f, 0.02593005f, -0.04058019f, 0.02213997f, -0.02856305f, 
    -0.00327855f, -0.02356877f, -0.02850117f, 0.01064597f, -0.01421548f, -0.01052721f, -0.00660967f, 0.00002410f, 
    0.00249848f, -0.02064626f, -0.03852933f, 0.00522011f, -0.01537865f, 0.00182611f, -0.03612015f, 0.01988886f, 
    -0.03065547f, -0.04082270f, 0.01148516f, -0.01090668f, -0.02559706f, -0.00431879f, 0.00270124f, -0.01876806f, 
    0.02596582f, 0.02191182f, -0.00542057f, -0.00331404f, 0.00498205f, -0.03726589f, 0.01158978f, -0.03828629f, 
    0.01309894f, -0.01268366f, -0.03214181f, -0.00375632f, 0.01704531f, 0.01041562f, -0.02714529f, -0.02055600f, 
    -0.03951722f, -0.01449393f, -0.00397152f, 0.01533741f, -0.00757995f, -0.03000316f, -0.00996505f, -0.03228546f, 
    -0.02936356f, -0.03377567f, -0.03271889f, -0.01882623f, -0.02715505f, 0.00192034f, -0.00592664f, -0.01095859f, 
    -0.00790504f, -0.02406659f, -0.02625295f, 0.00766635f, -0.00414166f, 0.02478026f, 0.02937745f, -0.03398404f, 
    -0.01683505f, -0.01645678f, 0.02586976f, -0.01764092f, 0.00628193f, 0.02017916f, -0.03233293f, 0.00135354f, 
    0.01428312f, -0.01192753f, -0.02586033f, 0.02206382f, -0.02833000f, -0.00479789f, -0.03591511f, -0.02020849f, 
    0.01640288f, -0.04005463f, 0.00517757f, 0.02386959f, -0.03915869f, 0.01711415f, 0.01283026f, -0.03343889f, 
    -0.02161439f, -0.03582006f, -0.00937224f, 0.01820953f, -0.02303495f, 0.00776970f, -0.02907969f, -0.00332551f, 
    -0.01193221f, -0.01903224f, -0.03128564f, -0.01267124f, -0.03674877f, -0.03583040f, 0.01551721f, 0.01377930f, 
    -0.00629360f, -0.03762248f, -0.01234850f, 0.00023400f, -0.01041441f, 0.00376464f, 0.01220135f, 0.01824198f, 
    0.02621517f, -0.00942913f, -0.03906555f, -0.04154856f, -0.02863612f, -0.02731242f, 0.00194996f, -0.01078836f, 
    -0.00585633f, -0.00329779f, 0.00840552f, -0.00067791f, 0.00370053f, -0.03439685f, -0.00194392f, -0.03666919f, 
    0.00479540f, -0.01656918f, 0.01976775f, 0.02943020f, 0.02865377f, -0.02573430f, 0.02756325f, 0.02021752f, 
    0.01795426f, -0.00616936f, -0.01132622f, -0.04178561f, 0.01437003f, 0.02098169f, -0.00137669f, -0.03833734f, 
    0.02256720f, 0.00721090f, 0.01359602f, 0.00396466f, -0.00736763f, -0.00223015f, 0.01486495f, 0.02301599f, 
    -0.01413424f, 0.00410590f, -0.00065908f, 0.00456157f, -0.00631584f, 0.00920798f, -0.01438235f, -0.02232866f, 
    0.00171609f, -0.00666866f, -0.02068608f, -0.01085071f, -0.00887706f, -0.01909135f, -0.01062120f, 0.00893837f, 
    -0.00225191f, 0.01647648f, 0.01708557f, 0.02889767f, 0.00548687f, -0.02424713f, -0.00657580f, -0.00903430f, 
    0.01719237f, 0.02904803f, -0.00888697f, 0.00760226f, 0.02704086f, 0.00593391f, -0.03780492f, 0.02124825f, 
    0.00618701f, 0.01149708f, 0.01036079f, -0.01148664f, 0.00242709f, -0.01474938f, -0.00122038f, -0.03498553f, 
    -0.00717507f, -0.01276715f, -0.03643660f, -0.01375120f, -0.01907396f, -0.00872363f, -0.00254890f, -0.00708356f, 
    0.02496252f, -0.00416656f, 0.00986167f, 0.01558985f, -0.01332214f, 0.00515464f, 0.00757398f, 0.01223458f, 
    -0.01419992f, -0.01563393f, 0.01184613f, -0.00736890f, -0.00070197f, -0.04032122f, 0.00362485f, -0.00183200f, 
    -0.02139682f, 0.02009878f, -0.03920621f, -0.01702103f, 0.02586454f, -0.01880573f, -0.03782089f, -0.00043338f, 
    0.02046731f, -0.01825355f, -0.02908605f, -0.04225397f, -0.02709980f, 0.02257014f, 0.00576712f, 0.00806196f, 
    0.00422044f, 0.01528748f, 0.02725465f, -0.02659107f, -0.03051911f, -0.00424908f, -0.01598851f, -0.03706648f, 
    0.00012355f, -0.03341078f, 0.00958432f, -0.00683998f, 0.02555305f, -0.00607110f, 0.02122536f, 0.01245960f, 
    -0.02277517f, 0.00913077f, -0.01470956f, -0.02079931f, 0.02738716f, 0.01752546f, -0.02963945f, 0.02962321f, 
    -0.01697431f, -0.03250624f, 0.02965320f, 0.00754797f, -0.00768930f, -0.04183622f, 0.01222973f, 0.00069591f, 
    -0.02669265f, 0.00677342f, 0.01108951f, -0.01513611f, -0.01928770f, 0.00713527f, -0.02413417f, -0.03505540f, 
    -0.00099876f, -0.03587923f, -0.02696410f, 0.01236876f, 0.01030872f, 0.01856674f, -0.01352655f, 0.00187410f, 
    -0.01195870f, -0.02810599f, -0.03244766f, -0.03267600f, 0.02629093f, 0.01565717f, 0.00221864f, 0.01981797f, 
    0.00973240f, -0.01097151f, -0.03381825f, 0.02536751f, -0.03786397f, 0.00724468f, -0.01185829f, -0.01760905f, 
    -0.03728686f, -0.01804563f, -0.03807443f, -0.03454049f, -0.01853454f, 0.02186143f, -0.03235779f, -0.00766514f, 
    0.00325355f, -0.01027680f, -0.03857723f, 0.00768485f, -0.00554251f, 0.02062530f, -0.02747528f, 0.02321934f, 
    0.00137373f, -0.03254990f, 0.00849704f, -0.01577755f, 0.00051032f, -0.00704084f, -0.03791841f, 0.01075245f, 
    -0.00161239f, 0.02513302f, 0.02005801f, 0.00986254f, -0.03293114f, 0.00728105f, -0.03304567f, -0.02578005f, 
    0.02000736f, -0.03562531f, -0.02651115f, 0.02695411f, -0.00047033f, 0.02940330f, 0.02301116f, -0.00199763f, 
    -0.01244622f, 0.01566547f, -0.03971492f, 0.01549265f, 0.00144909f, 0.02772357f, -0.02325185f, 0.02184067f, 
    -0.02614257f, -0.04180495f, -0.03415455f, 0.02237379f, -0.03008064f, 0.00449196f, -0.02918630f, -0.03265845f, 
    -0.01614655f, -0.03731850f, 0.02731264f, -0.02035603f, 0.01242176f, -0.03121614f, -0.03885438f, -0.00984765f, 
    0.03502465f, 0.02404986f, -0.01724695f, 0.00325974f, 0.01647655f, -0.00631129f, -0.03390946f, 0.01719928f, 
    0.02105945f, 0.01916353f, -0.02445573f, 0.02670110f, -0.01078096f, 0.01433360f, 0.02645397f, 0.00672516f, 
    -0.01640984f, -0.00458074f, 0.02484763f, 0.01251154f, 0.02670933f, -0.01314660f, -0.01941038f, -0.01829369f, 
    0.02507157f, -0.03170659f, -0.03032045f, -0.01857843f, -0.03254749f, 0.00127683f, 0.00568487f, 0.02563522f, 
    -0.03677298f, 0.02812134f, 0.01043733f, 0.02187932f, 0.01803792f, -0.02973724f, -0.01765067f, -0.00299936f, 
    -0.01219884f, 0.00533814f, -0.00223879f, -0.02037774f, -0.03955769f, -0.00823095f, -0.02830991f, -0.04228370f, 
    0.02769639f, 0.00751776f, -0.01718649f, -0.03808526f, 0.02477117f, -0.04205409f, 0.00194330f, 0.02481840f, 
    0.00226038f, -0.00209920f, -0.02014569f, 0.02516618f, -0.02165974f, -0.00307030f, -0.02250237f, 0.00185780f, 
    0.00172123f, -0.01315971f, 0.02806844f, 0.01024610f, 0.00746403f, -0.01915114f, -0.02683101f, -0.02625675f, 
    0.00300888f, -0.01848879f, 0.02326334f, 0.01936180f, -0.00416971f, 0.02956185f, 0.00987705f, -0.03159900f, 
    0.02149010f, -0.03131213f, -0.00811135f, -0.01677598f, 0.02366501f, -0.03353972f, 0.01360798f, 0.02859735f, 
    -0.03161563f, -0.00842695f, 0.00770862f, 0.01379191f, 0.01143639f, -0.03721711f, 0.01826413f, -0.00824907f, 
    -0.00031879f, 0.02500218f, -0.03586484f, 0.00710793f, 0.02900396f, -0.03471971f, 0.02559275f, -0.00700320f, 
    -0.02155983f, -0.00829010f, 0.01114256f, -0.03669276f, -0.00695929f, 0.01029175f, -0.01150549f, 0.00508982f, 
    0.00082170f, -0.03744315f, 0.01758819f, -0.00281826f, -0.00962762f, 0.00406746f, -0.03195146f, -0.03122568f, 
    0.00972408f, -0.00459835f, -0.02531619f, -0.02670760f, -0.01105776f, -0.00236794f, -0.00834638f, -0.00000312f, 
    0.01551865f, 0.02680240f, 0.01492417f, -0.00449434f, 0.02630888f, 0.01249165f, -0.01983448f, 0.00767382f, 
    -0.01396775f, -0.04008704f, 0.02193151f, -0.00076159f, 0.02847256f, 0.01901052f, 0.02631966f, -0.03463921f, 
    -0.01932426f, -0.02478285f, -0.01299670f, 0.01594766f, 0.01998853f, 0.02249014f, 0.02127200f, 0.01409561f, 
    0.00766490f, 0.02871756f, 0.00141379f, -0.00693748f, -0.02207804f, -0.03557135f, -0.02013198f, -0.00663811f, 
    -0.01102570f, -0.00875542f, 0.02065766f, -0.03440149f, -0.00107671f, -0.02353409f, 0.01878686f, -0.02659520f, 
    -0.02957392f, -0.00875990f, -0.00946779f, -0.00027254f, 0.01490657f, 0.01157725f, -0.03722384f, -0.02033231f, 
    -0.00280924f, 0.01331025f, -0.00931377f, -0.02628916f, -0.01059377f, -0.01306618f, -0.04192815f, 0.01215554f, 
    -0.01355477f, -0.02356741f, -0.02960635f, -0.02690465f, 0.00249590f, 0.01035477f, 0.01591724f, 0.01669667f, 
    -0.01069010f, -0.00262534f, -0.02783204f, -0.03782794f, 0.00546155f, -0.01206725f, -0.03248104f, -0.03967263f, 
    -0.02906921f, -0.00262479f, -0.01336038f, -0.00257902f, 0.01236503f, 0.00144803f, 0.02917067f, -0.03313228f, 
    -0.03213283f, -0.01732765f, -0.00736686f, -0.00624939f, -0.01643088f, -0.02604338f, 0.00121977f, 0.01595622f, 
    -0.02412043f, 0.00793223f, -0.02598491f, 0.00108741f, 0.00083423f, -0.01218222f, -0.02681334f, 0.01325268f, 
    -0.02206709f, -0.01635917f, -0.00727667f, -0.01352772f, -0.00122299f, 0.00348688f, 0.02033502f, -0.01508347f, 
    -0.00579441f, 0.02617961f, -0.03717949f, 0.01049792f, 0.02770743f, 0.02873288f, -0.01201378f, -0.00705293f, 
    -0.00558404f, -0.02824692f, 0.01311743f, 0.01894303f, 0.01368125f, -0.02761498f, -0.03391858f, -0.04075414f, 
    -0.04205803f, -0.01025303f, -0.01880081f, 0.02924819f, -0.02422875f, 0.02098328f, -0.01518808f, -0.01992450f, 
    -0.02280935f, 0.01773182f, 0.00071920f, -0.02169185f, 0.00052962f, 0.02446585f, 0.01481715f, 0.01861763f, 
    -0.03969565f, -0.01194420f, -0.00671876f, -0.02617709f, -0.00143195f, -0.01057812f, -0.03182184f, 0.01761804f, 
    0.02063982f, -0.00986103f, -0.04035966f, 0.01836113f, -0.02843581f, -0.01851729f, -0.02886116f, -0.02180699f, 
    -0.02351469f, -0.01746331f, -0.03735751f, 0.01810965f, -0.00764623f, -0.00218992f, -0.02389476f, 0.02372118f, 
    -0.00827469f, -0.01946967f, -0.01211142f, 0.01339951f, -0.03457414f, -0.00396583f, -0.00851389f, 0.00892677f, 
    -0.00394725f, -0.00184631f, -0.00859802f, -0.00157991f, 0.00049765f, -0.00404716f, -0.03947090f, 0.00796259f, 
    -0.02645934f, -0.00394932f, -0.03229043f, 0.00527527f, 0.02030918f, -0.01881580f, -0.02961702f, 0.00985091f, 
    0.01008359f, -0.00346599f, -0.01135913f, -0.00028885f, 0.02447174f, 0.02621921f, 0.01074694f, -0.02371083f, 
    -0.00461837f, -0.03783312f, 0.01629660f, -0.04031926f, -0.03503574f, -0.02969878f, 0.01103029f, -0.01244069f, 
    0.01664698f, 0.01394942f, -0.01131202f, -0.02594355f, 0.01221331f, -0.02368367f, 0.00594542f, -0.02227258f, 
    -0.03094528f, -0.01978116f, -0.01312590f, 0.01321764f, 0.01357628f, 0.01372939f, -0.03349781f, -0.01038208f, 
    0.01185130f, 0.01057565f, 0.00042829f, 0.00201769f, -0.04015418f, 0.01227413f, -0.03802992f, 0.00391554f, 
    -0.02415901f, -0.00855449f, -0.03000851f, -0.02878198f, -0.01826753f, 0.02759694f, 0.02762991f, -0.03390108f, 
    -0.02232246f, -0.02093909f, 0.01743678f, 0.01463746f, 0.00219137f, -0.00166437f, 0.01375938f, -0.00680760f, 
    0.01211253f, -0.02020830f, -0.01423956f, 0.00156902f, -0.03760185f, -0.03054793f, 0.00777062f, -0.01395242f, 
    -0.03909009f, 0.02245439f, -0.00301675f, -0.02449502f, 0.01927206f, -0.02889051f, -0.02855312f, -0.02362765f, 
    -0.00629752f, -0.01551561f, 0.00723087f, 0.00207394f, -0.04049744f, 0.01598733f, -0.03604917f, -0.02297799f, 
    0.01106026f, -0.02959644f, -0.01085958f, -0.00177313f, -0.02007791f, 0.01219007f, -0.01975602f, 0.02041046f, 
    -0.03035015f, -0.00678148f, 0.00122843f, 0.02007628f, -0.02033341f, 0.02790946f, 0.01045775f, 0.00708791f, 
    -0.03593633f, -0.00675476f, -0.02083696f, 0.01190880f, 0.00497566f, -0.00422995f, -0.01103724f, -0.04181173f, 
    -0.03827758f, 0.02463968f, -0.03820184f, 0.00501044f, -0.00811171f, -0.00331484f, -0.00925476f, 0.01085862f, 
    -0.02674889f, 0.02405984f, -0.00764374f, 0.01417513f, 0.03159195f, 0.02946325f, 0.01735308f, -0.00341542f, 
    -0.03345408f, 0.01279870f, -0.03633870f, 0.02689860f, 0.01048526f, 0.01852829f, 0.00894752f, 0.00045730f, 
    -0.01774513f, -0.00163127f, -0.01676329f, 0.01253893f, 0.00943581f, 0.02024029f, -0.04009024f, -0.01183632f, 
    -0.02162945f, 0.01910590f, -0.00376419f, -0.02972615f, -0.00819661f, 0.00928654f, -0.00279214f, -0.01374260f, 
    -0.02356983f, -0.01439581f, -0.03718732f, 0.00575495f, 0.02953553f, 0.00010560f, 0.01321772f, -0.03696450f, 
    -0.01330127f, -0.01068459f, -0.03314721f, -0.02709456f, 0.02251962f, -0.02339983f, 0.02694565f, -0.00777383f, 
    -0.02576153f, -0.02395881f, 0.00725615f, -0.01072082f, 0.02725671f, -0.03235511f, -0.00649593f, -0.00785471f, 
    0.03389636f, 0.01692616f, -0.01365884f, -0.00039240f, 0.00383627f, 0.02644312f, -0.03494888f, -0.00765648f, 
    -0.03722486f, 0.00327200f, 0.02998558f, -0.01827531f, -0.04160837f, -0.00249690f, -0.03261823f, 0.01363919f, 
    -0.02757680f, 0.01055706f, 0.02302705f, 0.00608704f, 0.02192586f, 0.00592470f, -0.00747395f, -0.03687456f, 
    -0.00866286f, 0.00958335f, -0.03757140f, -0.01137525f, -0.04094793f, 0.01661421f, -0.00147693f, -0.00826819f, 
    0.00916238f, -0.00039735f, -0.02871902f, -0.03419285f, -0.03503430f, -0.00187902f, -0.03781116f, -0.02564487f, 
    -0.02616108f, -0.03248644f, 0.02041614f, 0.02480100f, -0.02933481f, 0.01112064f, 0.02893915f, -0.00448618f, 
    0.02326272f, 0.01860348f, -0.03864959f, 0.02302074f, -0.00855276f, -0.02647454f, -0.03822148f, 0.01855780f, 
    0.00617265f, 0.01850784f, 0.01961300f, -0.00324897f, -0.00866334f, -0.01134066f, -0.00985044f, 0.04140211f, 
    -0.00195262f, -0.01378387f, -0.02581896f, 0.02973988f, -0.01859593f, -0.02759781f, 0.01625750f, 0.00277728f, 
    0.02475331f, -0.00635751f, 0.01273321f, -0.01213767f, -0.01811924f, 0.02252396f, -0.01379954f, -0.00473444f, 
    0.01750596f, -0.03422904f, 0.00973667f, 0.01433415f, -0.03252877f, -0.03451796f, 0.02035186f, 0.00589691f, 
    -0.00736591f, -0.02316216f, -0.03030618f, -0.02274098f, -0.01755855f, -0.01428069f, -0.00783622f, 0.02848506f, 
    0.01553987f, -0.00409360f, -0.00750276f, -0.01254177f, 0.02554939f, -0.03755847f, 0.00704399f, -0.03479620f, 
    0.00672618f, 0.00307874f, 0.01640302f, -0.03365933f, -0.00937476f, 0.00958525f, -0.03738711f, 0.01327233f, 
    0.00043311f, -0.02529710f, -0.02878555f, 0.00452632f, 0.01247067f, 0.02097786f, -0.02595737f, 0.02762880f, 
    -0.02034966f, 0.01125115f, 0.00728787f, -0.01563892f, 0.02620446f, 0.02486955f, 0.02439469f, 0.00235715f, 
    0.00640812f, -0.02185757f, 0.00361258f, -0.03331853f, -0.01202369f, -0.00288270f, -0.00819027f, 0.00503994f, 
    -0.02779398f, -0.01655275f, -0.01847653f, 0.00729039f, -0.01792629f, -0.03030596f, 0.02565682f, 0.01801545f, 
    0.00736510f, 0.01872625f, 0.01046725f, 0.02305906f, -0.03051798f, 0.00888201f, -0.03471159f, -0.00786347f, 
    0.00448037f, -0.00735231f, -0.01417720f, 0.02882895f, 0.00621741f, -0.03304805f, -0.02305775f, -0.01039948f, 
    0.02700793f, -0.03733585f, -0.01441571f, -0.00219939f, -0.02396987f, 0.02305109f, 0.01281034f, 0.01111927f, 
    -0.01152972f, 0.01875596f, 0.03462949f, 0.01560352f, 0.01666871f, -0.04196054f, 0.00399507f, 0.00176603f, 
    -0.01145815f, -0.01386407f, -0.00707317f, -0.02829223f, -0.02352529f, -0.01948777f, -0.00968475f, -0.02974153f, 
    -0.01585803f, -0.02194550f, 0.02977538f, 0.02074042f, -0.02010153f, -0.02347054f, -0.02547318f, 0.00567320f, 
    0.03986489f, -0.03568805f, 0.01471811f, -0.01079979f, -0.00083405f, 0.01615114f, -0.03433974f, 0.02856738f, 
    0.02849017f, 0.00230788f, 0.01138959f, -0.04091005f, -0.02160351f, -0.01965846f, -0.01160673f, 0.02839701f, 
    0.01441542f, -0.01602650f, 0.01534748f, -0.02012570f, -0.02374860f, -0.00363372f, -0.03574556f, 0.02751100f, 
    -0.01061684f, -0.01067449f, 0.00599578f, -0.03474914f, 0.01655350f, -0.00893139f, 0.02697931f, -0.02222992f, 
    0.01928415f, -0.01738275f, -0.03331156f, 0.00066712f, -0.00466470f, -0.00113448f, -0.00148375f, -0.01431437f, 
    -0.01893991f, -0.01801343f, -0.02871865f, -0.01622622f, -0.03191448f, 0.01370871f, 0.02131957f, -0.01366160f, 
    0.00183927f, -0.00369879f, -0.02278010f, -0.02695441f, -0.01120524f, -0.02536122f, 0.01117990f, -0.01623065f, 
    -0.04017011f, -0.00620304f, -0.01639936f, 0.00425701f, 0.01364179f, -0.00780609f, 0.00424731f, 0.01193524f, 
    0.01158969f, -0.00307468f, -0.02151886f, -0.02443041f, 0.02347016f, 0.02402617f, -0.03463077f, -0.00369670f, 
    0.02534856f, -0.00885388f, 0.00690618f, 0.01711463f, -0.01202111f, -0.01373381f, -0.01469778f, 0.02414880f, 
    -0.00593707f, 0.01599007f, -0.00161770f, -0.01793220f, 0.02558884f, -0.01918488f, -0.02826828f, 0.02820305f, 
    0.00516585f, 0.00054834f, -0.02329235f, -0.03113348f, 0.00938206f, 0.02271591f, -0.03293241f, -0.03480416f, 
    -0.00218019f, -0.00913432f, -0.01362644f, -0.01103711f, -0.01436936f, -0.01261525f, -0.01075321f, 0.02193958f, 
    0.00849354f, 0.00888615f, 0.04026429f, 0.02581471f, 0.01375751f, -0.04190937f, 0.02318215f, 0.01441731f, 
    0.00915189f, -0.01827641f, 0.02167134f, -0.03512991f, 0.02843983f, -0.00881790f, 0.02472515f, -0.00816536f, 
    -0.04077710f, -0.01394138f, 0.01831111f, -0.00473560f, -0.03435422f, 0.02898419f, 0.01397357f, -0.02214861f, 
    -0.03193165f, -0.00134491f, -0.01370241f, 0.00927325f, -0.03328392f, -0.00537400f, -0.02735743f, -0.02432557f, 
    -0.00714080f, 0.01107848f, -0.03401673f, 0.01988928f, -0.00066442f, -0.02406585f, 0.02396344f, 0.00651235f, 
    -0.02687140f, -0.02246292f, -0.00011059f, -0.00163397f, -0.01852178f, 0.02684326f, 0.01815505f, -0.03812338f, 
    -0.03895122f, -0.00989492f, -0.04081138f, -0.02833633f, -0.01054927f, -0.02506839f, -0.00542097f, -0.03179762f, 
    0.01761723f, -0.03964161f, -0.00569311f, -0.02448439f, -0.00643114f, 0.01158518f, 0.00705989f, -0.01540548f, 
    -0.02835736f, 0.00158566f, -0.03050279f, -0.01301528f, -0.02706445f, -0.03726581f, -0.00413265f, -0.00929600f, 
    0.01554787f, -0.02711456f, -0.02811371f, -0.01806186f, 0.02099216f, -0.02841596f, -0.00530475f, 0.02613679f, 
    -0.03220928f, -0.02174505f, 0.01322956f, -0.01241999f, -0.01841186f, 0.02165287f, 0.01490436f, 0.01688263f, 
    -0.03617880f, -0.02842820f, -0.01806113f, -0.02599957f, -0.03060309f, 0.01611933f, 0.02691455f, -0.03759470f, 
    -0.00992345f, 0.01912297f, -0.00965142f, -0.02003283f, -0.00270632f, -0.03382856f, 0.02863457f, 0.01069645f, 
    -0.03360521f, -0.02979207f, -0.00681277f, 0.02071016f, -0.01185004f, 0.03546225f, -0.03591604f, 0.00491093f, 
    -0.02581092f, -0.00993768f, 0.02361629f, -0.03998091f, -0.02974318f, 0.01152691f, -0.02375058f, 0.00188106f, 
    -0.02562870f, 0.01433949f, 0.00973751f, 0.00963749f, 0.02034172f, 0.01336979f, -0.00408006f, -0.04043581f, 
    0.02732780f, 0.03005098f, -0.03986470f, -0.02101915f, -0.00824695f, 0.01558707f, 0.01896350f, 0.01715764f, 
    -0.00580907f, -0.00812078f, 0.00441185f, -0.00087918f, 0.01910990f, -0.03078975f, 0.02802188f, -0.00752069f, 
    0.00891133f, -0.02664199f, 0.00364000f, -0.00251567f, -0.01068990f, 0.01442041f, -0.03266462f, -0.03389237f, 
    -0.00919655f, -0.00542305f, 0.02221559f, 0.02480086f, -0.00064287f, -0.02991327f, -0.03507137f, 0.00183493f, 
    0.16648525f, 0.25557220f, 0.19448997f, 0.24723718f, 0.12102167f, -0.02889039f, 0.10055421f, 0.09499458f, 
    0.00627684f, -0.08805864f, 0.01063776f, -0.04613635f, -0.06405865f, 0.22634414f, -0.15349239f, -0.09038956f, 
    -0.06328493f, 0.03490483f, 0.07561786f, 0.07762267f, 0.06798418f, -0.04206856f, 0.14701061f, -0.17645277f, 
    -0.01903126f, 0.09198329f, -0.39586329f, 0.07981725f, 0.03387281f, 0.03229760f, 0.00912843f, -0.11031395f, 
    0.02335272f, -0.02293664f, 0.01054796f, 0.04500245f, 0.00355431f, 0.03287133f, -0.06717596f, -0.05644686f, 
    0.01944425f, -0.03901186f, -0.04554614f, -0.04463240f, 0.00797879f, -0.07684153f, 0.04568236f, 0.04578776f, 
    -0.00016759f, 0.11434349f, 0.13264757f, 0.04777379f, 0.02925420f, -0.09634192f, 0.11369987f, -0.11046880f, 
    0.07334869f, 0.17319718f, -0.02428251f, -0.12835747f, -0.37517300f, 0.18162949f, -0.12682457f, -0.20536552f, 
    0.05216188f, -0.12448788f, 0.06581865f, 0.25362927f, -0.00626353f, 0.13737564f, -0.14028862f, -0.03595489f, 
    -0.25505498f, -0.23249811f, 0.17265867f, 0.02696436f, 0.01643980f, -0.06114684f, -0.00716332f, 0.05797799f, 
    -0.07582114f, 0.00564189f, 0.02187021f, 0.01938703f, 0.14834139f, 0.22783533f, -0.29167679f, 0.08005158f, 
    0.03216275f, -0.08973500f, 0.02588539f, -0.03002732f, -0.02155153f, -0.04812496f, 0.04180823f, 0.00441361f, 
    -0.09449695f, 0.18950984f, -0.13192663f, 0.15808696f, -0.08986086f, 0.03080204f, 0.00129897f, -0.08381987f, 
    -0.09529117f, -0.04804313f, 0.12848113f, -0.00166883f, 0.05654209f, 0.15964589f, 0.18178427f, -0.16257916f, 
    0.02850910f, 0.19432840f, -0.05638204f, -0.00520437f, 0.03590225f, -0.05586099f, 0.05051529f, 0.00197551f, 
    0.18248965f, -0.34704041f, 0.25567451f, -0.05163271f, 0.05362098f, -0.03478407f, -0.06292226f, 0.03193597f, 
    0.11611168f, -0.03217718f, 0.04389508f, 0.01973417f, -0.01439434f, -0.23783423f, -0.23953088f, -0.37397921f, 
    -0.01572486f, -0.00214125f, 0.04763374f, -0.01167744f, -0.06439930f, 0.01791589f, 0.06973781f, -0.12410821f, 
    0.49824816f, -0.17895256f, 0.07159150f, -0.06164386f, 0.06399108f, 0.27765611f, 0.08895315f, 0.18330801f, 
    0.04085123f, -0.08165452f, 0.15100580f, 0.00023131f, 0.13372181f, -0.17867945f, -0.05591759f, -0.06071519f, 
    -0.02208781f, -0.07134009f, 0.06873734f, -0.06888340f, -0.02890510f, 0.11036006f, 0.12435782f, -0.20001651f, 
    0.30817661f, -0.14000651f, 0.11584557f, 0.03954689f, -0.11744352f, 0.16886975f, 0.03652081f, -0.06949615f, 
    0.05171217f, -0.03716972f, -0.00355594f, -0.20047045f, -0.08092047f, 0.06425033f, -0.01355749f, -0.12650518f, 
    0.06656642f, 0.06028695f, 0.16806196f, 0.17032142f, -0.00598110f, 0.04959662f, -0.08943953f, -0.01874826f, 
    0.63686550f, 0.31287819f, 0.22516033f, -0.18662532f, -0.04439032f, 0.03582548f, -0.12793462f, -0.12700884f, 
    0.02059166f, -0.00825369f, 0.13383791f, 0.03100585f, -0.12471377f, 0.26335680f, -0.31813195f, 0.15052661f, 
    0.01310540f, -0.09005539f, 0.21495476f, -0.05645252f, 0.04407774f, 0.08314934f, 0.08642741f, -0.03550941f, 
    0.06884627f, -0.14103740f, 0.01016634f, -0.17786227f, -0.16274276f, -0.18465455f, -0.07990278f, 0.03532289f, 
    -0.02923615f, -0.03743492f, -0.05691729f, -0.06071723f, 0.07894860f, 0.13756812f, 0.06336251f, -0.05749522f, 
    -0.00557845f, -0.07887798f, -0.02181277f, -0.02381693f, 0.15260360f, -0.00810764f, 0.00182771f, -0.01847053f, 
    0.03393724f, 0.01998862f, -0.11266872f, -0.02610650f, 0.00724557f, -0.03898372f, -0.01056042f, -0.10686442f, 
    0.06898175f, -0.02480588f, 0.03952368f, -0.02323274f, 0.02124934f, 0.07007543f, 0.06754198f, 0.03994720f, 
    0.00676509f, 0.03956051f, 0.20378603f, 0.02126510f, 0.17151555f, 0.12036453f, 0.12378152f, 0.11734000f, 
    -0.06563985f, -0.49633810f, -0.31334355f, -0.62655067f, 0.08592344f, 0.03924854f, -0.03773654f, 0.15973407f, 
    -0.00607391f, -0.12390212f, -0.04551193f, 0.07564502f, 0.22017643f, -0.19346407f, 0.19976567f, -0.17704928f, 
    0.00468270f, 0.28497741f, -0.10878053f, 0.12411798f, -0.16896243f, 0.06831673f, -0.04898421f, 0.01315233f, 
    0.03221630f, -0.61351347f, -0.17672992f, -0.18614659f, 0.04990964f, 0.01203375f, 0.08152490f, 0.22176118f, 
    0.17657103f, 0.07742318f, 0.05843360f, 0.02916683f, 0.07757651f, 0.16456935f, -0.14328164f, 0.27325246f, 
    0.02311338f, 0.10193899f, -0.13009876f, 0.04209814f, 0.08278809f, 0.06841232f, 0.03432566f, 0.04113618f, 
    -0.38032892f, -0.06593058f, -0.28297934f, 0.09286822f, -0.03909114f, -0.11379613f, 0.13182162f, 0.18087377f, 
    0.00566739f, -0.00779877f, 0.09585950f, -0.08377394f, -0.04098512f, -0.36060822f, -0.80121642f, -0.19990811f, 
    0.19264512f, 0.07604365f, 0.09194101f, -0.03468432f, -0.07627580f, -0.10365654f, -0.06885838f, 0.10746586f, 
    -0.09993898f, -0.25521743f, -0.23268440f, -0.11320586f, -0.07486584f, -0.01787332f, -0.04947570f, 0.05582838f, 
    0.00191937f, -0.04396677f, -0.00234439f, -0.01110378f, -0.10516307f, 0.06496821f, -0.08329493f, 0.02269092f, 
    -0.15122817f, 0.13714130f, 0.21290362f, 0.00808659f, 0.09729026f, 0.24410944f, -0.09536348f, -0.11404850f, 
    0.18107580f, -0.05865599f, 0.13570365f, -0.28032744f, 0.01686947f, -0.00424307f, -0.14996456f, -0.01094730f, 
    -0.04473253f, -0.08542214f, 0.06009284f, -0.11606526f, -0.04110966f, -0.14482962f, 0.05888209f, -0.19952546f, 
    0.04028396f, -0.00890556f, 0.05874069f, 0.13701873f, -0.09945566f, 0.09233467f, -0.01049491f, -0.03721164f, 
    0.32713491f, -0.26575771f, 0.07576517f, 0.17102531f, -0.05481631f, -0.06174545f, 0.03324842f, -0.03035448f, 
    0.04152955f, -0.06396364f, 0.15928154f, -0.10553114f, 0.52111322f, -0.08390040f, 0.15587662f, -0.13016057f, 
    -0.01334420f, -0.07717133f, -0.02271081f, -0.11136325f, 0.18756135f, -0.02598522f, -0.08152147f, 0.09572636f, 
    -0.01155708f, 0.06784696f, -0.03586036f, -0.15932286f, -0.16473654f, 0.04421528f, 0.03314880f, 0.06748100f, 
    0.08184954f, -0.02509832f, 0.00845274f, -0.00263566f, 0.07138154f, 0.13531168f, -0.13525683f, -0.13099989f, 
    -0.00297486f, 0.08873595f, -0.12229745f, -0.03631024f, 0.03398993f, -0.02343754f, -0.03471990f, 0.02586874f, 
    0.21152358f, -0.15333222f, 0.05449399f, 0.08146824f, 0.15535322f, -0.00812694f, 0.12022125f, 0.00006598f, 
    0.00663778f, 0.17020784f, 0.17400323f, -0.04323870f, -0.63019770f, -0.15288220f, -0.20527107f, 0.06001029f, 
    0.01650930f, -0.00257603f, 0.10822867f, 0.06298067f, -0.01103578f, 0.01114633f, 0.00982176f, -0.02609659f, 
    -0.01892519f, -0.10989757f, -0.03161599f, 0.05618989f, -0.13338277f, -0.04843124f, 0.19771352f, 0.02861231f, 
    -0.10414547f, -0.02387553f, -0.21367593f, 0.11825276f, -0.02381607f, -0.10735798f, 0.16925533f, 0.06985687f, 
    -0.00991488f, 0.07456506f, 0.15502296f, 0.13684525f, 0.09762888f, 0.10157292f, 0.03847110f, -0.15022305f, 
    -0.70914096f, -0.22632664f, -0.26471350f, 0.04374791f, -0.02814322f, -0.03664742f, 0.01310221f, 0.07343532f, 
    0.05231827f, 0.07911845f, 0.06532702f, -0.10420260f, 0.15944706f, 0.26805785f, -0.20400305f, -0.08633716f, 
    -0.04150433f, 0.11170071f, 0.03734501f, -0.04490829f, 0.00518788f, -0.01509913f, 0.07187881f, -0.05671934f, 
    0.09106631f, 0.29975787f, -0.26552454f, 0.20784146f, -0.15951633f, 0.17475085f, 0.14799298f, 0.32956696f, 
    -0.03915173f, -0.03047460f, 0.17808382f, -0.06973242f, 0.06207882f, 0.01536089f, 0.05930590f, -0.10970767f, 
    -0.09740455f, -0.00543528f, 0.05008127f, -0.04693798f, 0.04154718f, -0.11275260f, 0.06444505f, -0.15078545f, 
    0.25683025f, 0.13669550f, -0.26298973f, -0.65436095f, -0.15389903f, 0.22503297f, 0.03952942f, 0.09692248f, 
    -0.07395317f, 0.14407891f, 0.13832808f, -0.03284853f, -0.09192997f, -0.07136349f, 0.02779602f, 0.04098390f, 
    0.03418452f, -0.01802313f, -0.00249798f, -0.08030289f, -0.02499079f, -0.05013169f, 0.04237875f, -0.10725544f, 
    -0.11275008f, -0.16310635f, -0.21953091f, -0.17208908f, 0.14351873f, -0.02224887f, -0.08029454f, -0.06569885f, 
    -0.05539308f, -0.00657419f, 0.07859013f, -0.05902717f, 0.24989162f, 0.05796157f, 0.09195703f, 0.09129794f, 
    0.04967431f, 0.17582239f, -0.00543911f, -0.01878398f, 0.03091318f, 0.12272805f, -0.18980519f, -0.07307190f, 
    -0.05203252f, -0.34408876f, -0.37985742f, -0.11587676f, 0.01367508f, -0.13730516f, -0.16906705f, 0.09792120f, 
    0.01671080f, -0.02696401f, -0.02661051f, 0.06220378f, 0.27186087f, -0.13838048f, 0.03110810f, -0.14259538f, 
    -0.07666698f, -0.08806679f, -0.10908040f, 0.00329773f, 0.10630188f, -0.05506549f, -0.00454103f, -0.03450627f, 
    -0.30531001f, 0.28401732f, -0.09561218f, 0.10745820f, 0.10423791f, -0.08795352f, 0.17561206f, 0.03506229f, 
    0.06178457f, 0.15399092f, 0.04793542f, 0.12111705f, -0.18662706f, -0.01132134f, 0.03705766f, -0.02282617f, 
    0.22121961f, -0.00442434f, 0.08549859f, 0.01611609f, 0.01766420f, 0.00024017f, 0.05883493f, 0.05623294f, 
    0.03824078f, 0.14074020f, -0.19745275f, -0.13538291f, 0.05254645f, -0.08026449f, -0.00069024f, -0.09045334f, 
    0.17312671f, 0.08187564f, -0.04361765f, -0.01861387f, 0.08367797f, 0.20904621f, 0.29220864f, -0.03913784f, 
    0.00861764f, -0.00232487f, -0.01172974f, -0.02876039f, 0.00635045f, 0.05119642f, 0.04324222f, -0.03790540f, 
    0.26814210f, 0.06521229f, 0.27771232f, -0.07750619f, 0.06206553f, -0.07294212f, 0.10749196f, -0.12877344f, 
    0.13470533f, 0.08458174f, 0.00330358f, -0.00294603f, -0.10326593f, 0.20899682f, -0.12632099f, 0.04317768f, 
    0.01292519f, -0.04279824f, 0.17898285f, 0.05639543f, 0.05370281f, 0.14004263f, 0.09151781f, 0.07022423f, 
    0.02448084f, -0.09129141f, 0.08915395f, -0.02581728f, -0.10600781f, -0.07180391f, 0.02105257f, 0.06475128f, 
    0.05353078f, 0.08193629f, -0.09613039f, -0.02071343f, 0.11504484f, 0.00819506f, 0.18979165f, 0.05766478f, 
    0.12254985f, 0.01492178f, -0.00035353f, 0.01952515f, 0.02252246f, -0.03145066f, -0.13907906f, -0.09207179f, 
    0.01920853f, 0.14414752f, 0.03005939f, 0.13897486f, -0.09691437f, -0.06722508f, 0.03598177f, -0.13915743f, 
    0.00336530f, -0.04535528f, -0.04186687f, 0.01795233f, 0.41826862f, -0.10303702f, 0.05833140f, -0.14558205f, 
    -0.00102601f, -0.09667346f, -0.08959347f, -0.05163154f, -0.01098275f, 0.08414038f, 0.19049081f, 0.17980108f, 
    0.16356546f, 0.17794588f, 0.04032728f, -0.07681737f, -0.00408241f, 0.09604916f, 0.03321412f, -0.11334232f, 
    -0.00347445f, -0.02119826f, 0.07765754f, 0.02696654f, 0.21415150f, 0.22188145f, 0.19740598f, -0.01788528f, 
    -0.02966354f, -0.02523220f, -0.04648467f, 0.00975754f, 0.06246206f, 0.06115068f, 0.08992450f, 0.09949277f, 
    0.21343246f, 0.06728137f, 0.16187130f, -0.05411550f, -0.02920151f, -0.00538271f, -0.01496049f, 0.05751465f, 
    0.04110967f, 0.01672463f, -0.01684013f, 0.10488059f, -0.06508188f, 0.52787328f, 0.03380399f, 0.28976211f, 
    -0.15839025f, -0.22822018f, 0.25493193f, -0.01054154f, -0.00045235f, -0.21286114f, 0.11812338f, -0.08918703f, 
    0.01360952f, 0.02199245f, -0.01276579f, 0.00001551f, 0.02154495f, -0.03882841f, -0.00759874f, -0.03279404f, 
    0.00380458f, -0.02203715f, -0.03041326f, -0.00886773f, 0.02739456f, -0.02597722f, -0.02932569f, 0.01969092f, 
    0.01475872f, -0.03238119f, -0.02416922f, -0.02960462f, -0.01835323f, 0.02492712f, 0.01988919f, 0.01621236f, 
    0.02751318f, -0.02338160f, 0.00392819f, -0.02184699f, 0.00679274f, 0.00893634f, 0.02072899f, 0.01226882f, 
    -0.00210958f, 0.00497538f, -0.03243331f, -0.02061225f, 0.02397453f, -0.03016062f, -0.01889887f, 0.00243147f, 
    -0.00550125f, -0.03392216f, -0.02642590f, 0.00502958f, 0.02137032f, -0.00612443f, 0.01561419f, -0.04232282f, 
    -0.02665459f, -0.02558250f, -0.02457833f, -0.01308134f, 0.00014875f, -0.03800771f, 0.01424870f, -0.00581122f, 
    -0.01959866f, -0.03298835f, -0.01457477f, -0.02915523f, 0.02010065f, -0.00485578f, 0.02350077f, -0.02825818f, 
    -0.01775416f, 0.02294599f, 0.01932668f, -0.01274189f, 0.00884188f, -0.03509150f, -0.01816039f, 0.01956068f, 
    0.00919138f, -0.04336758f, 0.02462792f, 0.02107128f, 0.03299752f, -0.03271452f, 0.00655835f, 0.02762187f, 
    0.02599386f, -0.01075919f, 0.00743651f, -0.03202826f, -0.03264327f, 0.01169019f, -0.00721270f, -0.03940666f, 
    0.02120791f, -0.03916708f, 0.00031768f, -0.02890755f, -0.02160809f, -0.01823744f, 0.02909826f, -0.00221188f, 
    0.02479698f, 0.01640599f, -0.02012636f, -0.02450808f, 0.00783109f, -0.03300931f, -0.02962132f, 0.01231589f, 
    0.02766080f, -0.01439061f, -0.02565665f, -0.00819736f, 0.01244568f, -0.01774212f, -0.02902961f, -0.02155569f, 
    -0.04078612f, -0.01302770f, 0.01673390f, -0.02980991f, 0.00498762f, -0.00084833f, -0.04031697f, -0.03858957f, 
    -0.02900442f, -0.02589133f, -0.04101020f, -0.01027453f, -0.02927011f, 0.00585513f, -0.00774221f, -0.01027228f, 
    0.01133107f, -0.02720232f, 0.00676282f, 0.00182825f, -0.03679111f, -0.03111013f, -0.02761110f, 0.02414918f, 
    -0.01192981f, -0.02124972f, -0.02591406f, -0.03458931f, 0.01325468f, -0.02084168f, -0.03519731f, -0.01457388f, 
    -0.00446866f, 0.01437987f, -0.01166093f, -0.03342732f, 0.00026408f, 0.00077616f, -0.01007439f, -0.00166159f, 
    -0.01714914f, 0.02745773f, 0.02835706f, -0.01749645f, 0.02837570f, 0.01149986f, 0.00373952f, -0.03227934f, 
    0.00582058f, -0.00847342f, -0.03198186f, -0.03216705f, -0.03725007f, 0.02079717f, -0.01578595f, -0.02733630f, 
    -0.01557327f, 0.01040182f, -0.02027855f, 0.01443933f, 0.02695985f, 0.01025634f, 0.02251420f, -0.01951472f, 
    -0.03718816f, 0.00530278f, 0.00192518f, -0.01925048f, -0.01009038f, 0.01442659f, -0.01305838f, -0.03588123f, 
    0.01333732f, -0.01974051f, -0.01983702f, 0.02704155f, 0.01792287f, -0.01880860f, 0.00501548f, -0.03758806f, 
    -0.01115004f, -0.01097156f, -0.00853336f, -0.03652974f, 0.02288255f, -0.02757651f, -0.02525785f, 0.02206267f, 
    0.01464124f, -0.00574825f, 0.01993274f, -0.03551498f, -0.00446026f, -0.00935639f, 0.02204509f, -0.01857467f, 
    0.02722615f, -0.02980990f, 0.01650505f, 0.02522565f, 0.02169145f, -0.03737880f, -0.03935806f, 0.02622070f, 
    0.01022039f, 0.00540202f, -0.02024213f, 0.00672374f, 0.00880970f, -0.01349659f, -0.03879659f, -0.01740434f, 
    0.01377373f, -0.04181350f, -0.04226839f, 0.01789855f, 0.02481585f, -0.03064705f, 0.00590647f, 0.00682598f, 
    -0.00490087f, -0.01016176f, 0.01096187f, 0.02172198f, -0.03186033f, -0.03465572f, -0.04237586f, 0.01132970f, 
    0.02739351f, 0.00239158f, 0.02743142f, 0.02279507f, -0.00926654f, -0.01444358f, 0.02143281f, 0.00592047f, 
    -0.01404594f, -0.01848903f, -0.02288782f, 0.02272548f, -0.00123874f, 0.00529816f, -0.01273704f, -0.03066820f, 
    -0.03558176f, 0.01638200f, 0.02500091f, -0.03460283f, -0.02509204f, -0.02448725f, 0.01803742f, -0.00782102f, 
    0.00054400f, -0.03863870f, 0.01519798f, -0.03468687f, -0.00406720f, -0.01243005f, -0.01154935f, 0.01330769f, 
    0.00070345f, 0.02002612f, 0.02350542f, -0.01524588f, 0.01657782f, -0.03873255f, -0.03620045f, -0.04202437f, 
    0.02272986f, -0.00174348f, -0.03575911f, -0.00971833f, -0.01107350f, 0.00439127f, 0.00217977f, 0.00903347f, 
    0.00376784f, 0.02735306f, 0.00950644f, -0.00418175f, 0.02660015f, 0.00295339f, -0.01482849f, -0.01972129f, 
    -0.00682704f, -0.00878649f, 0.02704920f, 0.01046206f, 0.01155191f, -0.01509838f, -0.02255348f, 0.01379099f, 
    -0.03203828f, -0.00384111f, -0.02369574f, 0.00804997f, 0.00634530f, 0.00666673f, -0.03723548f, 0.01934977f, 
    -0.03601994f, -0.02305924f, -0.03433584f, -0.00740432f, 0.01544940f, -0.04257645f, -0.03131386f, -0.03158799f, 
    0.02983616f, 0.02282532f, 0.00882299f, 0.00192743f, -0.01160018f, -0.02891151f, 0.02416784f, 0.02334948f, 
    -0.00949644f, 0.02841329f, -0.00061591f, 0.02005023f, -0.02154484f, -0.02041008f, 0.00133648f, -0.01513721f, 
    -0.00849766f, -0.03804341f, -0.03162979f, -0.01643578f, -0.00279041f, -0.00236197f, 0.00340581f, -0.03741213f, 
    0.01110256f, 0.02880339f, -0.02006316f, -0.01187430f, -0.02439303f, 0.02347011f, 0.01946165f, -0.02287123f, 
    -0.03827852f, -0.01201468f, -0.00157177f, -0.02111205f, 0.02992563f, 0.02521338f, -0.02190751f, 0.00323574f, 
    -0.03334873f, -0.00288174f, 0.02079448f, -0.03230567f, -0.01219102f, 0.01470832f, -0.02596188f, 0.01825486f, 
    0.00308343f, -0.03017524f, -0.01514370f, -0.00823427f, 0.01269947f, -0.00698027f, 0.00975920f, -0.03266424f, 
    0.02260429f, -0.01892733f, 0.00990483f, 0.02176215f, -0.01190224f, 0.02112747f, -0.03449216f, -0.01310792f, 
    -0.03935428f, 0.01032917f, -0.02140608f, -0.00428457f, -0.02913167f, -0.02129096f, -0.01084878f, -0.02527816f, 
    -0.00758117f, -0.03572165f, 0.00455258f, -0.02981390f, -0.04163744f, -0.02920859f, 0.02622018f, 0.00166495f, 
    0.00005346f, 0.01309132f, 0.00669789f, 0.00700644f, -0.02227495f, 0.02756917f, -0.04131081f, -0.03810536f, 
    -0.01442960f, -0.04304336f, 0.02094845f, -0.01703073f, 0.01890103f, -0.04078707f, 0.01441128f, -0.01501789f, 
    0.02551091f, -0.03547062f, -0.01556333f, -0.03767353f, -0.04219091f, -0.02842672f, -0.00584133f, 0.01456674f, 
    -0.03874325f, 0.02811029f, -0.00670622f, 0.02719899f, 0.01499307f, -0.01394545f, -0.00096981f, 0.01483210f, 
    0.00683573f, 0.00958247f, -0.01517532f, 0.01402812f, 0.02313421f, 0.00246573f, -0.02386201f, -0.03587218f, 
    0.01119302f, -0.01133005f, -0.00936206f, -0.03572214f, -0.01810715f, -0.02044776f, -0.02314437f, -0.02717170f, 
    0.01296454f, 0.00864848f, -0.00968315f, -0.04013424f, 0.01050931f, -0.01826307f, -0.04092243f, -0.00697188f, 
    0.00476756f, -0.03894856f, 0.01440630f, -0.03947953f, -0.01822702f, 0.01638716f, 0.02395968f, 0.00882510f, 
    0.01838178f, -0.02274674f, -0.00325937f, 0.01678404f, 0.00563294f, -0.02706936f, -0.00689535f, 0.01327478f, 
    0.01461755f, -0.03091248f, -0.01134967f, 0.02307004f, -0.00020637f, 0.02406899f, -0.02606811f, -0.01056767f, 
    -0.01338343f, 0.01730925f, -0.02471321f, -0.03415116f, 0.01086970f, -0.04088524f, -0.03892003f, -0.03152438f, 
    -0.01996515f, 0.01993311f, -0.00046508f, -0.01433866f, 0.01969290f, -0.01363290f, -0.01124202f, -0.03633310f, 
    0.00503422f, 0.01933741f, 0.01232063f, -0.02643702f, -0.04262778f, -0.02944329f, -0.01253701f, 0.00416930f, 
    -0.01838956f, -0.01001589f, -0.00529069f, -0.03682363f, 0.02251549f, -0.00881912f, -0.01002885f, -0.01833925f, 
    0.00824618f, -0.01482755f, -0.00804650f, 0.00521406f, -0.02102080f, -0.01556115f, -0.03304452f, 0.02765044f, 
    -0.01351889f, -0.01047668f, -0.02435640f, -0.00234066f, 0.00677571f, 0.00336345f, -0.03484252f, 0.02485763f, 
    -0.01768349f, 0.00190605f, 0.01536238f, -0.03881474f, 0.01478434f, 0.02567645f, 0.02244845f, 0.01925516f, 
    -0.01381917f, 0.00593089f, -0.02911025f, 0.02782504f, -0.02053474f, -0.02801859f, -0.01750725f, -0.01792706f, 
    0.01156193f, -0.00872573f, 0.01540779f, 0.00307647f, -0.02777412f, -0.00105022f, -0.01516184f, -0.03378121f, 
    -0.03342160f, -0.01285722f, 0.00705264f, 0.02628718f, -0.04036988f, -0.02140837f, -0.00473036f, -0.01539753f, 
    0.00395415f, 0.01860909f, -0.01723763f, 0.01647246f, 0.00103348f, -0.00262726f, -0.03705012f, -0.00297409f, 
    -0.00555504f, 0.00730534f, -0.00577559f, 0.00716524f, -0.01418300f, -0.00863803f, 0.00941933f, -0.02129156f, 
    0.00883398f, -0.00832441f, -0.02220370f, 0.00137710f, -0.03140476f, -0.03395022f, 0.01993008f, -0.00768559f, 
    -0.03124555f, -0.00981768f, -0.00108357f, 0.01479728f, 0.01446649f, -0.03961965f, 0.00469168f, -0.00899359f, 
    0.00885730f, -0.00490320f, -0.02879268f, 0.01267609f, -0.02467955f, 0.00836424f, 0.01764111f, 0.01821248f, 
    -0.02125965f, 0.01375512f, -0.03424742f, -0.01043541f, 0.02724728f, -0.00489362f, -0.03086492f, 0.00124914f, 
    -0.01515765f, 0.01301484f, 0.02351840f, 0.00082735f, -0.02953624f, -0.02770755f, -0.02924465f, 0.02734736f, 
    -0.02520445f, -0.03372059f, 0.00759774f, -0.04232431f, -0.01716413f, -0.04037098f, -0.01932990f, -0.01731623f, 
    -0.04234956f, -0.02077017f, -0.01424912f, 0.00523638f, -0.01439681f, 0.01843822f, 0.00778982f, 0.02567620f, 
    0.01850089f, -0.02439847f, 0.02433140f, -0.03644364f, -0.03259962f, -0.00429586f, -0.03684018f, -0.03219914f, 
    -0.00353634f, 0.02310621f, 0.00309643f, 0.02360552f, 0.00565398f, 0.00021740f, 0.00746927f, 0.02502519f, 
    -0.02202283f, -0.02427968f, 0.01084375f, 0.01842034f, -0.01856243f, -0.03815151f, -0.03942407f, 0.02642107f, 
    -0.00016377f, 0.01388987f, -0.00817174f, -0.00936743f, 0.02212158f, -0.00289471f, -0.03316861f, 0.01978339f, 
    -0.03575091f, 0.02343779f, 0.01245323f, -0.04170937f, 0.00710077f, -0.01413456f, 0.01541195f, 0.00793856f, 
    -0.02546521f, -0.00473288f, -0.00705579f, 0.01353579f, -0.00697940f, -0.01009924f, -0.01287290f, 0.01177289f, 
    -0.02836008f, 0.02827311f, -0.00146634f, -0.01072011f, 0.01592217f, -0.01132609f, -0.03073359f, -0.00380431f, 
    0.02607414f, -0.00653424f, -0.00462642f, 0.01633880f, -0.03794861f, -0.00050710f, -0.02425269f, -0.01797150f, 
    0.00294663f, 0.00519787f, -0.02226174f, -0.03297539f, 0.01111842f, -0.04144041f, 0.02226582f, -0.01649035f, 
    0.00898475f, -0.01918328f, 0.01250519f, 0.00745149f, -0.02941353f, 0.02456178f, 0.02827662f, 0.02240656f, 
    0.00017886f, -0.02707808f, -0.00349205f, -0.02623589f, 0.02694563f, -0.02501174f, 0.03991168f, -0.03407883f, 
    0.00713130f, 0.00877266f, 0.00567744f, -0.00755160f, 0.01165138f, -0.00357106f, -0.03145385f, -0.03955887f, 
    -0.02126703f, -0.03312949f, -0.02835756f, -0.02460564f, 0.01384293f, 0.01584621f, -0.00535694f, -0.00492101f, 
    0.02264064f, -0.00648356f, 0.02337069f, -0.00380019f, 0.00539426f, -0.02785868f, -0.03216784f, -0.01426511f, 
    -0.01772040f, 0.00671975f, 0.02520814f, 0.00232650f, 0.00049295f, 0.00351632f, -0.00137628f, -0.03557523f, 
    -0.01185518f, -0.03878986f, -0.00894843f, -0.01316363f, 0.00239190f, 0.00055762f, -0.02795813f, -0.01382209f, 
    -0.01858761f, 0.01328705f, -0.03267825f, -0.02464375f, -0.03919040f, -0.01517869f, 0.01560011f, -0.03211279f, 
    0.14859097f, -0.01354521f, -0.03783841f, 0.27818200f, 0.00290869f, -0.12370358f, -0.03785151f, 0.16741267f, 
    -0.04169906f, 0.08987619f, -0.02169503f, 0.06126212f, 0.44251651f, 0.12029479f, -0.02483826f, 0.33417171f, 
    -0.02026152f, 0.06714186f, -0.13023761f, 0.13908248f, -0.18251976f, -0.04944717f, -0.02326734f, -0.00836188f, 
    0.13047308f, -0.03165642f, 0.60100192f, -0.08234518f, -0.17551942f, -0.03444322f, 0.04287226f, 0.10331365f, 
    -0.03715406f, 0.13427421f, -0.26627806f, -0.05348360f, 0.31030071f, 0.08251665f, 0.07341959f, -0.00039031f, 
    -0.01812533f, 0.13719258f, 0.06278948f, -0.02140159f, -0.15409680f, 0.08435535f, -0.08325990f, -0.22907095f, 
    -0.06990807f, 0.10148259f, 0.01354308f, 0.16167839f, -0.08780555f, 0.04335519f, -0.10938852f, 0.13786626f, 
    -0.00513963f, 0.17292441f, 0.11362308f, 0.03018060f, 0.13062367f, 0.07651123f, 0.24080499f, 0.14659625f, 
    -0.04327458f, -0.13078490f, 0.08931724f, 0.27623659f, 0.03522269f, 0.00120274f, -0.02239123f, -0.09327599f, 
    0.09996526f, 0.13906351f, -0.26590276f, -0.02950285f, -0.15091629f, -0.05162672f, 0.08761048f, -0.12608071f, 
    -0.06896711f, 0.06897096f, -0.03462646f, -0.20863931f, 0.28951693f, 0.21544515f, 0.22704023f, -0.15244776f, 
    -0.15702343f, 0.00834057f, -0.02274817f, -0.00954364f, 0.01169737f, -0.07539988f, -0.05707423f, -0.01455930f, 
    -0.01004123f, -0.07068411f, 0.26072547f, -0.07796615f, -0.09294277f, 0.03377158f, -0.07316273f, 0.03981670f, 
    0.02272180f, -0.08407553f, -0.04669026f, -0.16513610f, 0.06975339f, -0.03546993f, 0.11058609f, 0.00956371f, 
    -0.11309868f, -0.00465424f, 0.14928845f, 0.13042669f, 0.17709123f, 0.13212141f, 0.19294201f, 0.00347422f, 
    -0.22653766f, -0.05683311f, 0.09630194f, 0.31283876f, 0.13557468f, 0.34693819f, 0.08141604f, -0.04097757f, 
    0.09563912f, -0.00904708f, -0.10475319f, 0.21826616f, -0.16416422f, 0.21799524f, -0.19275600f, -0.29444563f, 
    -0.15249920f, -0.02179890f, 0.00283491f, -0.04562495f, 0.04114025f, -0.10997191f, -0.01576513f, 0.00881332f, 
    0.08565309f, 0.29675823f, -0.05573228f, 0.26680639f, -0.13684483f, -0.11881080f, 0.25917083f, 0.14160198f, 
    0.15130131f, 0.13218257f, 0.10858414f, 0.15348789f, -0.09679075f, 0.40558109f, -0.36914092f, -0.03189451f, 
    -0.05265670f, 0.01714242f, 0.10041367f, 0.15090328f, 0.04468837f, -0.00539300f, -0.04462267f, -0.04982295f, 
    -0.25133410f, 0.03294907f, -0.06395328f, 0.16261390f, -0.05366406f, -0.03906978f, 0.23282091f, -0.26296496f, 
    -0.13292208f, 0.07311339f, 0.23567779f, 0.10232499f, 0.15501504f, 0.00683727f, 0.00689919f, -0.03237668f, 
    0.24788556f, 0.04045929f, 0.02423965f, 0.12424706f, 0.08700256f, 0.08657480f, 0.11055850f, 0.11153479f, 
    -0.23055291f, 0.26890725f, -0.18974704f, 0.07363416f, 0.00447823f, 0.01764077f, 0.06217652f, -0.01529307f, 
    0.02986373f, -0.02177555f, 0.08125865f, 0.25167996f, 0.32069978f, 0.07570178f, 0.28209996f, 0.06120290f, 
    0.05928029f, -0.04438439f, -0.06027938f, -0.00580706f, 0.00261147f, -0.06702029f, -0.05211337f, -0.00011429f, 
    -0.16317636f, 0.09779638f, -0.04517785f, 0.00659122f, 0.00576434f, 0.04373779f, 0.06470320f, -0.13365327f, 
    -0.16809665f, -0.15196195f, -0.08131551f, -0.18246552f, 0.15229617f, 0.09442074f, -0.00512021f, 0.12773989f, 
    -0.09263963f, -0.01110559f, 0.03547573f, 0.02739471f, -0.06841506f, 0.19272819f, 0.02860884f, 0.06920341f, 
    0.45373288f, 0.07805938f, 0.05115383f, 0.08747231f, -0.01752962f, 0.06229132f, -0.05046951f, 0.04628164f, 
    -0.04127733f, 0.05589632f, -0.08762459f, -0.08036722f, 0.12962414f, -0.08643563f, 0.02389992f, -0.01242792f, 
    -0.07488865f, 0.07917176f, 0.07999717f, 0.03781135f, 0.09669358f, 0.13799937f, 0.11956115f, 0.30472922f, 
    0.14923605f, 0.09540391f, -0.27325708f, 0.17523412f, -0.01827596f, 0.02751813f, 0.13593924f, -0.22369999f, 
    -0.04846025f, 0.03970078f, 0.09294048f, -0.06446041f, -0.37396199f, 0.30488893f, -0.21023470f, 0.15468003f, 
    0.10900421f, 0.16964346f, 0.07024046f, -0.23965612f, -0.09955353f, -0.18496506f, -0.09693294f, -0.22546937f, 
    0.01206654f, 0.05212592f, -0.11672401f, 0.01028504f, -0.03388827f, -0.13912597f, -0.00324490f, 0.01084169f, 
    -0.26269099f, 0.02472171f, -0.20669782f, -0.08552691f, 0.22129135f, -0.07620233f, 0.26392987f, -0.12203858f, 
    -0.06605339f, 0.05762157f, 0.03586302f, 0.03426967f, -0.12937419f, 0.13066210f, 0.06897471f, 0.10189376f, 
    0.27447444f, -0.02068173f, -0.02043081f, -0.14334314f, -0.06291662f, -0.09803630f, -0.12380830f, 0.08250856f, 
    -0.00393272f, -0.14184389f, -0.08318938f, -0.09960181f, 0.18286610f, -0.07408108f, -0.12422016f, -0.01078391f, 
    -0.11896731f, 0.09146196f, 0.06560187f, -0.03566751f, -0.15099020f, 0.04964687f, 0.03300662f, 0.20301016f, 
    0.20317961f, 0.07695420f, -0.14484480f, -0.02588797f, -0.21574949f, -0.16669956f, 0.11874413f, 0.01641813f, 
    -0.10332467f, -0.09316954f, -0.13776201f, -0.13336387f, 0.05307167f, -0.10345308f, 0.01830445f, -0.05266532f, 
    0.04771271f, 0.03499576f, -0.13744889f, 0.14353697f, -0.04910292f, 0.05778179f, 0.27474326f, 0.12242428f, 
    0.14807151f, -0.08593772f, -0.02070612f, 0.29396144f, -0.11505234f, 0.02159663f, 0.02941211f, 0.08278447f, 
    -0.05222443f, 0.03363115f, -0.04464581f, -0.01974631f, 0.25921822f, 0.18972550f, -0.11823700f, 0.10572039f, 
    -0.00460696f, -0.17426644f, 0.02626587f, 0.18814932f, -0.05339611f, 0.01200192f, -0.12421285f, -0.07639325f, 
    -0.11912730f, 0.16537726f, -0.44367021f, 0.26057124f, -0.01428336f, 0.11107587f, -0.02965167f, 0.01087883f, 
    0.08499690f, -0.04864177f, 0.31443280f, 0.19822843f, -0.07839777f, -0.07250819f, -0.19686541f, -0.06823698f, 
    -0.00124747f, -0.05356502f, -0.00091904f, -0.08474237f, 0.00350414f, 0.14132166f, 0.01131945f, 0.04228409f, 
    -0.04777141f, -0.36425573f, 0.13832466f, -0.08197211f, -0.00826843f, -0.00944462f, 0.19843984f, -0.17904328f, 
    0.07754955f, 0.11600027f, -0.06318409f, 0.11196339f, 0.23096442f, 0.26159245f, -0.19380844f, -0.15221269f, 
    -0.06232012f, -0.11680674f, 0.09099384f, -0.17041922f, 0.07396138f, -0.01407335f, 0.01030672f, -0.03481525f, 
    -0.03993272f, -0.16866231f, -0.21820016f, 0.09455676f, 0.04615417f, -0.05909724f, 0.07067934f, 0.22387066f, 
    -0.22418410f, -0.01968733f, -0.06207816f, 0.03371561f, -0.03354703f, -0.09832399f, 0.03787787f, -0.17671308f, 
    -0.16551837f, -0.13929215f, -0.13391629f, 0.01505477f, 0.00441401f, 0.02823843f, 0.04027951f, -0.06551405f, 
    -0.03774029f, 0.01743311f, -0.07684607f, -0.21021007f, 0.19987155f, 0.36650026f, -0.11433310f, 0.12116974f, 
    0.05666566f, 0.15938264f, 0.21391802f, 0.25381634f, -0.15109830f, 0.21883190f, -0.14258674f, 0.08276331f, 
    0.11488955f, -0.02564606f, -0.01801614f, -0.07645275f, 0.01102374f, 0.17402360f, 0.13363028f, 0.09003150f, 
    -0.01928765f, -0.06432979f, 0.35334486f, -0.20719291f, -0.08712795f, -0.04082625f, 0.09713049f, 0.11092326f, 
    0.04846112f, 0.11587406f, 0.15155439f, 0.05488764f, 0.29563469f, -0.26400679f, 0.32446235f, 0.03829121f, 
    0.03842898f, 0.02800469f, 0.11024453f, 0.07120468f, -0.02634376f, -0.08871975f, -0.08363087f, -0.14112693f, 
    0.55448812f, 0.07097711f, 0.50283760f, 0.01631399f, -0.06680375f, -0.08091765f, 0.12226915f, -0.02841319f, 
    -0.06534913f, -0.00315470f, 0.11534906f, 0.18011133f, 0.17818551f, -0.07201862f, 0.04624641f, -0.06105657f, 
    0.00547920f, 0.10777120f, 0.06105895f, -0.02456110f, 0.00504831f, 0.03616180f, -0.07105576f, -0.06054367f, 
    -0.19689143f, -0.03432762f, 0.36856067f, -0.26063949f, 0.05190656f, 0.02147786f, -0.12159027f, 0.03530110f, 
    0.02119356f, -0.02241151f, 0.02076685f, -0.33066094f, 0.22932193f, 0.10486555f, 0.10422061f, -0.05768079f, 
    0.00262530f, 0.06103368f, 0.11184511f, 0.03704723f, -0.12321547f, -0.19449079f, -0.05445020f, -0.19252449f, 
    -0.15166153f, 0.06337847f, -0.04655303f, -0.16432412f, -0.02015716f, -0.10241710f, -0.01441964f, 0.03255658f, 
    -0.05559159f, -0.20752238f, -0.01503473f, -0.14156747f, -0.23404665f, 0.05104963f, 0.10725043f, 0.21152140f, 
    0.14801842f, 0.28169268f, -0.00046430f, 0.00824274f, -0.08130965f, -0.09149626f, 0.04007387f, 0.00718747f, 
    0.12153738f, 0.00107937f, -0.13949406f, -0.12156544f, 0.00019160f, 0.12275783f, 0.04156695f, -0.11412475f, 
    -0.04748053f, 0.06725425f, 0.08843612f, 0.00573925f, 0.06098694f, 0.03307281f, -0.09885893f, -0.15832312f, 
    0.09247232f, 0.08991791f, -0.13713586f, -0.05557235f, -0.00779463f, 0.03200207f, 0.21703708f, 0.12769483f, 
    0.10955288f, -0.28202003f, 0.08577906f, 0.03966657f, -0.14162554f, -0.12635840f, 0.01997214f, 0.11629416f, 
    0.02449215f, 0.23708269f, -0.09266319f, -0.01916868f, 0.31074512f, 0.22333422f, 0.05496835f, -0.09893158f, 
    -0.14317289f, -0.05064404f, 0.08948033f, 0.43907839f, -0.10919916f, -0.03704423f, -0.05791086f, 0.01230581f, 
    0.08352746f, 0.18604963f, 0.11020686f, 0.25250840f, -0.06874672f, 0.05548273f, -0.11257971f, 0.18981534f, 
    -0.17539218f, 0.16423045f, 0.06346120f, 0.09673574f, 0.00976607f, -0.05933540f, -0.00089792f, 0.15093057f, 
    -0.07175726f, -0.00454475f, 0.00186152f, -0.00707707f, -0.04176964f, 0.15185221f, 0.19363979f, 0.01890348f, 
    0.07734081f, 0.07829251f, -0.31705227f, 0.15390067f, -0.05735641f, 0.01725988f, -0.02087053f, 0.09455995f, 
    0.03743124f, 0.24923734f, 0.05264936f, 0.03134893f, 0.02147847f, -0.10974001f, 0.15636592f, -0.11454213f, 
    0.08156253f, 0.16228135f, -0.05332068f, 0.04435329f, -0.01113427f, 0.08111316f, 0.15748343f, 0.20645092f, 
    0.01236165f, -0.04892601f, -0.10264649f, 0.15380158f, -0.05712723f, 0.09993070f, 0.02817554f, -0.00685161f, 
    -0.07654671f, 0.09374943f, -0.06195591f, -0.16308548f, -0.05427032f, 0.11027209f, -0.02216191f, 0.23952922f, 
    -0.00503102f, 0.00437031f, -0.01110067f, 0.02147899f, -0.18961841f, -0.11465865f, -0.10017795f, -0.20621857f, 
    -0.02227508f, -0.04689818f, 0.13746616f, -0.02705273f, -0.01838314f, 0.03698438f, 0.08382869f, 0.02552078f, 
    -0.12226126f, 0.04538204f, -0.17505658f, -0.22255570f, 0.23399697f, -0.08220167f, -0.23272777f, 0.01137026f, 
    -0.01805962f, -0.09100849f, -0.02328668f, 0.08367471f, -0.10400698f, 0.13673620f, -0.09895523f, -0.05709160f, 
    0.14436519f, 0.09703614f, 0.02735628f, 0.02337314f, 0.07254397f, 0.02236845f, 0.00509075f, 0.00318906f, 
    0.01035011f, 0.14816009f, 0.18404455f, 0.02699631f, 0.16626273f, -0.05250995f, -0.13077870f, 0.09728615f, 
    -0.05129183f, 0.05017700f, 0.02979217f, 0.04021311f, -0.01454079f, 0.19127037f, 0.09854555f, 0.13613339f, 
    0.05950829f, 0.00114252f, -0.00584105f, 0.10297117f, -0.06772379f, 0.01018790f, 0.04586190f, 0.11699152f, 
    0.01925716f, 0.35500598f, 0.11803968f, 0.13942468f, 0.39584583f, -0.15341377f, 0.02953971f, 0.26810476f, 
    -0.14174674f, 0.00378221f, 0.04157323f, 0.12904678f, -0.11698838f, 0.18735977f, 0.02126656f, 0.06775571f, 
    -0.02197925f, -0.02322828f, -0.02080744f, -0.03505065f, -0.02965147f, -0.00253435f, 0.00674730f, 0.00911033f, 
    0.01209116f, 0.01570148f, 0.03056458f, 0.02623330f, 0.01285445f, -0.02370387f, -0.03725169f, 0.02916784f, 
    -0.01597938f, 0.01122316f, 0.03062997f, 0.02553929f, -0.01711795f, -0.00727852f, -0.03023391f, 0.00263655f, 
    -0.02902419f, -0.02938739f, -0.00619501f, -0.03837326f, -0.01398435f, -0.00009646f, -0.03590738f, -0.01959015f, 
    -0.01760107f, -0.00078961f, -0.01351927f, 0.01308624f, -0.00785478f, -0.03853800f, 0.02149784f, 0.02058125f, 
    -0.00594098f, 0.00718716f, -0.02940547f, 0.02496544f, -0.01684624f, -0.03841037f, 0.01217983f, -0.01870010f, 
    -0.00543809f, -0.03101086f, -0.02003138f, -0.01243062f, -0.01938061f, -0.02917687f, 0.02036008f, 0.00309252f, 
    -0.00076881f, -0.03143965f, -0.03635239f, -0.01911373f, -0.01192722f, -0.02968569f, -0.01225125f, 0.01985890f, 
    -0.03552306f, 0.02916516f, -0.02981107f, -0.03553644f, -0.01823410f, -0.00467701f, -0.03533066f, -0.02428396f, 
    -0.01986409f, -0.00234377f, -0.03508032f, 0.02467391f, 0.00821151f, -0.01332427f, 0.00677995f, -0.00841164f, 
    -0.02850448f, -0.02549737f, -0.03736551f, -0.02473019f, -0.00759588f, 0.01457870f, 0.00846990f, 0.02551246f, 
    -0.00161861f, -0.01099819f, 0.02591741f, 0.02102153f, -0.00355181f, 0.01430879f, 0.02037513f, 0.01015309f, 
    -0.02839079f, -0.02598542f, -0.03322482f, -0.01020888f, 0.01372663f, 0.01706186f, -0.02019722f, -0.03912359f, 
    -0.03465057f, 0.00672487f, 0.01714672f, 0.00801427f, -0.00639653f, -0.02863931f, -0.02698196f, 0.01814172f, 
    -0.03363426f, 0.00120865f, -0.03475440f, 0.01780335f, -0.02605398f, 0.00686298f, -0.01649448f, -0.01099842f, 
    0.00272341f, -0.03521548f, -0.00059594f, -0.03032798f, -0.03084417f, -0.02185911f, 0.02734951f, -0.02585029f, 
    0.01585698f, -0.01585443f, 0.02943899f, 0.01139771f, 0.02795310f, -0.01851058f, 0.02579699f, 0.01321651f, 
    0.01832415f, 0.00859448f, -0.02625905f, -0.03851193f, -0.02748693f, -0.04184944f, 0.00544151f, 0.01101767f, 
    -0.00554821f, -0.01201702f, 0.01185824f, 0.01353334f, -0.02023508f, -0.02411517f, -0.01173407f, 0.02771363f, 
    -0.00650780f, 0.02913176f, -0.02490620f, -0.00964098f, -0.01043301f, 0.00468962f, -0.03851413f, 0.01046778f, 
    -0.02960314f, -0.00553874f, 0.00215067f, -0.02455162f, -0.00031482f, 0.01019358f, 0.00688052f, -0.01117479f, 
    -0.04094161f, -0.00649295f, -0.02734522f, -0.02847959f, -0.01859019f, -0.01297005f, 0.02240653f, -0.03483715f, 
    -0.03638120f, 0.02710092f, 0.02908633f, -0.02260998f, -0.00268156f, -0.01795265f, 0.01054819f, -0.02097832f, 
    0.00131091f, -0.02114546f, 0.00832409f, 0.03446354f, 0.02254416f, 0.01243404f, 0.02158094f, -0.00532813f, 
    -0.02225165f, -0.03041741f, -0.02271209f, 0.01073843f, -0.02493508f, 0.00795966f, 0.01472173f, 0.02218681f, 
    -0.01844558f, -0.02563079f, 0.00585572f, -0.04129545f, -0.03751872f, 0.00053385f, 0.02373734f, -0.02611969f, 
    0.02181109f, 0.02847736f, 0.00494481f, -0.00521129f, 0.02368198f, 0.01914302f, -0.03598122f, -0.03072823f, 
    -0.01380398f, -0.02883398f, -0.00141451f, 0.02083800f, -0.01304598f, -0.01524174f, -0.02318605f, -0.01894323f, 
    -0.00504283f, -0.01774743f, -0.01277127f, -0.01199342f, 0.02976020f, 0.02872512f, -0.02463151f, -0.03093124f, 
    0.02702753f, -0.02457450f, -0.00070326f, -0.03782033f, 0.00559690f, 0.02823237f, -0.02951579f, 0.01285896f, 
    0.00568677f, -0.00874095f, 0.01028301f, 0.02521913f, -0.02873910f, -0.00451147f, -0.03680801f, -0.03645848f, 
    0.02279215f, -0.00325956f, 0.02424502f, 0.00088316f, 0.02892648f, 0.01322629f, -0.01444345f, -0.03892971f, 
    0.02955572f, 0.00047879f, -0.03159052f, 0.00475339f, -0.04122356f, 0.02206675f, 0.00073638f, -0.01975270f, 
    -0.02636239f, -0.03028999f, 0.01895986f, 0.02694683f, 0.01087384f, 0.00591917f, 0.02023054f, -0.03463567f, 
    -0.03366818f, -0.02257663f, -0.03940432f, -0.01917052f, 0.00688744f, -0.00230078f, -0.02466206f, -0.00891258f, 
    -0.01998396f, 0.02351847f, -0.00571400f, 0.01822771f, 0.02995155f, 0.01184179f, -0.01706427f, -0.00970109f, 
    0.02927877f, -0.00860529f, -0.00464349f, -0.00200963f, 0.00286912f, -0.02940983f, -0.02602695f, -0.03099929f, 
    -0.03232151f, 0.00174747f, -0.02044240f, 0.01326975f, -0.00639111f, -0.01275420f, -0.02769400f, -0.01153728f, 
    -0.02112907f, -0.03151884f, -0.02037710f, -0.00581551f, -0.00098201f, -0.02841812f, 0.02473994f, 0.00497043f, 
    -0.01534480f, -0.02042843f, -0.00267918f, -0.02205324f, -0.02562381f, -0.02679804f, -0.03737488f, 0.00058959f, 
    -0.03653031f, -0.01675992f, -0.03352140f, -0.02904966f, -0.03534320f, -0.01090967f, 0.02403317f, -0.02181138f, 
    0.01047188f, -0.02254635f, -0.04159833f, -0.01702173f, -0.02814038f, -0.01172394f, -0.03551872f, 0.00538638f, 
    -0.02526755f, 0.02955541f, -0.03860625f, 0.00413973f, -0.00189728f, -0.03625466f, 0.02721903f, 0.01427975f, 
    -0.02016344f, 0.03008250f, -0.03556481f, -0.01328200f, 0.01027067f, -0.01711116f, -0.01692384f, -0.01795279f, 
    -0.03395894f, 0.00672577f, -0.02886448f, 0.02125859f, -0.01837898f, -0.00998149f, -0.02491134f, 0.02936292f, 
    -0.00444565f, 0.01065538f, -0.00499918f, 0.01735129f, -0.02691527f, -0.03754717f, -0.01356379f, 0.01781899f, 
    -0.03362159f, -0.03003991f, -0.02565345f, 0.02757433f, -0.02002693f, 0.02967372f, 0.01745508f, -0.00425577f, 
    -0.02625086f, 0.00536139f, -0.00342310f, 0.01022211f, -0.03984943f, 0.01832861f, 0.01844251f, 0.02848850f, 
    -0.02598551f, -0.00483867f, -0.00433884f, 0.00628401f, -0.01917191f, 0.00176293f, -0.03007795f, 0.02946290f, 
    -0.00907136f, -0.00842910f, -0.01679236f, -0.02997579f, -0.00162540f, -0.00262370f, -0.04140443f, -0.02135786f, 
    -0.03928157f, 0.01544669f, 0.01431651f, 0.02850444f, 0.01289319f, -0.02789620f, 0.01311910f, -0.00626731f, 
    -0.03679078f, -0.01095762f, -0.03529142f, -0.00772015f, 0.01965618f, 0.00997672f, 0.01750249f, 0.00934875f, 
    0.00301176f, -0.01741297f, 0.00158416f, 0.02805385f, -0.00134536f, 0.01907831f, -0.01354878f, -0.02687657f, 
    -0.02797750f, -0.00210107f, 0.02443936f, 0.01131719f, -0.01901129f, -0.02204209f, -0.00916665f, 0.00814532f, 
    0.01543112f, 0.00178544f, 0.02893412f, -0.04178086f, -0.03467949f, -0.02160702f, -0.03731646f, 0.00005780f, 
    -0.01279443f, 0.00137586f, -0.00693384f, -0.01411029f, 0.02326970f, -0.04122970f, 0.01374837f, -0.03078747f, 
    0.01977275f, -0.03003296f, -0.03685455f, 0.00665020f, -0.00427480f, -0.00068453f, 0.01668141f, 0.02882712f, 
    0.01958805f, -0.02454101f, 0.00924020f, 0.01834700f, -0.03384662f, -0.01913273f, -0.04117655f, -0.00295433f, 
    -0.04186407f, -0.03220450f, -0.02307314f, 0.02435658f, -0.00094530f, 0.00719109f, -0.02819155f, -0.00682080f, 
    0.01731170f, 0.01963530f, -0.01011136f, -0.03778641f, -0.00048608f, 0.00008430f, -0.01237356f, 0.01184493f, 
    -0.02847442f, -0.01911475f, 0.01742954f, -0.03677283f, -0.00104444f, -0.04024066f, -0.01204213f, -0.01306866f, 
    -0.01284736f, -0.01041289f, -0.02919245f, 0.00515851f, -0.03944343f, 0.00456703f, -0.02261036f, -0.02150757f, 
    0.01473801f, 0.00846951f, -0.02906889f, -0.03204929f, -0.01889131f, 0.02291055f, -0.01204616f, -0.01759138f, 
    0.02014857f, -0.03357477f, -0.03018743f, 0.02916820f, 0.01262559f, -0.01408908f, -0.03359874f, 0.03373586f, 
    -0.03013199f, -0.00995386f, 0.00486667f, 0.02307650f, -0.01801458f, -0.03457135f, -0.02157843f, 0.02349106f, 
    0.01335837f, 0.01607011f, -0.02785265f, 0.00952636f, 0.01587732f, 0.01408934f, -0.01244416f, 0.02610067f, 
    0.02350652f, -0.03729763f, -0.02181233f, -0.03591199f, -0.04128275f, -0.01850097f, -0.01317691f, -0.02856208f, 
    -0.01100651f, -0.00173191f, -0.03321827f, -0.00613383f, -0.00940179f, -0.01307806f, -0.01189863f, 0.03011208f, 
    0.01033294f, -0.01770174f, 0.01966337f, -0.01730599f, 0.00532510f, -0.01594050f, -0.02484445f, -0.01921966f, 
    0.00791094f, 0.02402651f, -0.00450820f, 0.00630701f, -0.01846405f, 0.00048727f, 0.01644515f, -0.02394844f, 
    0.01200602f, 0.00934706f, 0.01218496f, -0.01796158f, 0.01706916f, -0.03279359f, -0.02389489f, -0.03262975f, 
    -0.01023554f, -0.01832001f, -0.02119287f, 0.01187693f, 0.02455176f, 0.02354672f, -0.00213051f, -0.02326890f, 
    0.00580776f, -0.02444553f, -0.01690128f, -0.02652633f, 0.00913846f, -0.01649133f, 0.00408776f, -0.03133514f, 
    0.01457059f, -0.01878266f, -0.03434755f, -0.03124647f, -0.03979826f, 0.01784767f, -0.03614924f, -0.00358678f, 
    0.02957926f, 0.00310517f, 0.01139344f, -0.02884626f, -0.03927587f, -0.01217476f, 0.02770408f, -0.00117626f, 
    -0.03675132f, 0.00250142f, 0.02646064f, -0.02845734f, 0.02978610f, -0.01987020f, -0.00754093f, 0.01620688f, 
    -0.03357535f, 0.00737602f, -0.01443997f, 0.00154513f, -0.02252246f, 0.02361946f, 0.02315856f, -0.00287816f, 
    -0.02749171f, -0.01436748f, 0.02413099f, -0.03650706f, 0.02819124f, 0.02587116f, 0.01182896f, -0.02057788f, 
    -0.02302904f, -0.01111320f, 0.02877383f, -0.01693443f, 0.00851779f, -0.01440643f, -0.04120404f, 0.01052427f, 
    -0.02181222f, -0.02707114f, 0.01415434f, -0.04145015f, -0.04036577f, -0.00096507f, 0.00700097f, -0.02753664f, 
    0.01542353f, 0.02598441f, 0.01834545f, -0.03184396f, -0.02775140f, -0.02042208f, 0.00694361f, -0.03127195f, 
    -0.02041757f, -0.00115695f, -0.00900644f, -0.00714886f, 0.01837431f, 0.02056865f, -0.00218229f, 0.00353044f, 
    0.00394112f, -0.00968431f, -0.02781787f, 0.00834491f, -0.02103497f, -0.03610226f, -0.03955715f, 0.01876485f, 
    0.01599435f, -0.01237142f, -0.01337247f, 0.01833001f, -0.01577961f, -0.02291325f, -0.04028186f, -0.00035085f, 
    -0.01438297f, -0.01477583f, -0.00431275f, 0.02163804f, 0.02868384f, 0.00158118f, -0.00118335f, 0.02008033f, 
    -0.02109518f, -0.01242921f, 0.00221194f, 0.01657659f, 0.02329780f, -0.02034496f, 0.01094433f, -0.04083990f, 
    -0.01795077f, -0.01590017f, 0.00278513f, -0.01892217f, -0.03644836f, 0.03310734f, 0.00583862f, -0.01705052f, 
    -0.01501307f, -0.00957157f, 0.02294976f, -0.01240071f, -0.04110810f, -0.03615172f, -0.01262063f, -0.03871245f, 
    0.02125390f, -0.01841748f, -0.01634886f, -0.03061523f, -0.02012965f, -0.01588915f, 0.01513034f, -0.00020449f, 
    0.01563630f, 0.00180424f, -0.03735367f, 0.02163166f, 0.00865852f, -0.04082244f, 0.01537048f, -0.03944977f, 
    0.00783108f, 0.02402000f, -0.01201690f, -0.03666349f, 0.01613545f, -0.00541918f, 0.02397132f, 0.00184586f, 
    -0.01885024f, -0.03549287f, -0.03985342f, -0.00018492f, 0.02095955f, -0.02370313f, 0.02865851f, -0.03638835f, 
    0.00909436f, 0.00375998f, -0.01815153f, 0.02849625f, 0.01441027f, -0.03552207f, -0.03250773f, -0.01971509f, 
    -0.01015421f, -0.03247121f, 0.00478992f, -0.02836551f, 0.01737222f, 0.01420471f, 0.01839373f, 0.00297758f, 
    -0.02597147f, -0.03171319f, -0.01046584f, 0.00963627f, 0.01526822f, -0.01903500f, -0.02733215f, 0.00135842f, 
    0.01307191f, 0.02711648f, -0.02585034f, -0.01612090f, -0.02687373f, -0.02345940f, -0.01190450f, -0.03846041f, 
    -0.02177148f, -0.03924641f, -0.03832861f, -0.01715576f, 0.02146636f, -0.02549502f, 0.02431902f, 0.02372592f, 
    -0.03963879f, 0.00524766f, -0.01765922f, -0.00910966f, 0.00887971f, -0.00536789f, -0.01889506f, -0.02290322f, 
    0.01597016f, 0.02144326f, 0.00797277f, -0.02622570f, -0.04022687f, -0.00884993f, -0.01152234f, 0.00655548f, 
    -0.01388369f, -0.02310987f, 0.00840819f, -0.00882737f, -0.02642311f, 0.02702508f, -0.01797711f, -0.04013930f, 
    0.02291375f, -0.01023207f, -0.00449325f, -0.00546260f, 0.00626266f, -0.04134575f, -0.03974277f, 0.01326794f, 
    0.02709934f, -0.00445479f, 0.02475101f, -0.02522338f, -0.00411764f, 0.00816118f, -0.01718347f, -0.02892902f, 
    -0.04155966f, 0.00429608f, -0.03115983f, 0.00390854f, -0.03970237f, 0.00427616f, 0.01690199f, -0.01717774f, 
    -0.03394199f, -0.01430769f, 0.01385441f, 0.00639541f, 0.01968230f, -0.04129492f, -0.02490070f, -0.00737869f, 
    -0.02333740f, -0.00614996f, -0.02645606f, 0.01262660f, -0.01840693f, -0.01205067f, 0.02518310f, -0.01856630f, 
    -0.01940547f, -0.00844898f, -0.00938487f, 0.01091375f, -0.03467164f, -0.01107332f, 0.00042730f, 0.00387917f, 
    0.01755858f, 0.01206739f, 0.00017406f, -0.04113780f, 0.01012499f, -0.01474475f, -0.00313950f, -0.01559578f, 
    -0.02489234f, 0.00023107f, -0.01676485f, 0.02737142f, -0.01296000f, 0.02521727f, -0.00758394f, -0.03756599f, 
    -0.01115310f, -0.00384675f, -0.01529937f, 0.01983845f, 0.02558790f, -0.02206386f, 0.02933089f, -0.03862628f, 
    0.00106238f, -0.03865565f, -0.03804541f, -0.03366723f, -0.02848219f, -0.03341064f, 0.02510267f, 0.01565574f, 
    -0.03743899f, 0.02878737f, -0.03770102f, -0.02564899f, 0.00403080f, -0.00843489f, 0.00029858f, -0.01647848f, 
    0.01979245f, -0.03154251f, 0.00234672f, -0.03291610f, -0.03385945f, -0.00819692f, -0.03881089f, 0.01310849f, 
    0.02464032f, -0.02683624f, -0.00866954f, 0.01517801f, -0.01179360f, 0.01163564f, -0.02369988f, 0.02784360f, 
    0.00103289f, 0.00306061f, -0.00735438f, -0.03247789f, -0.04173378f, -0.00772049f, -0.02657110f, 0.02035643f, 
    -0.00424199f, -0.03926644f, -0.01836837f, 0.01809507f, 0.00670670f, -0.01903119f, 0.00347456f, 0.00155717f, 
    0.00649467f, 0.01920003f, -0.01210137f, 0.02594468f, -0.00221311f, -0.02540733f, 0.01530962f, -0.03333082f, 
    0.00611789f, -0.02646448f, -0.03803075f, -0.00526755f, 0.00009570f, -0.00667030f, 0.01177216f, -0.03714055f, 
    -0.00201024f, -0.00805830f, 0.02314463f, -0.00970621f, 0.02090001f, 0.02073972f, 0.00157588f, -0.02519847f, 
    -0.03780201f, 0.02007274f, -0.00886163f, -0.01795292f, -0.02808120f, -0.00749443f, 0.02229860f, -0.00163545f, 
    0.02228444f, -0.00024682f, 0.02996382f, -0.01641057f, 0.02705246f, -0.00895433f, 0.00932105f, 0.01841549f, 
    -0.03565327f, 0.00490941f, 0.01974076f, 0.00638142f, 0.00224728f, -0.00638866f, -0.00931480f, -0.02178480f, 
    0.01087509f, -0.01252720f, -0.00705051f, -0.00532889f, 0.00852615f, -0.01016090f, -0.03936264f, -0.04185835f, 
    -0.02294233f, -0.02402890f, 0.01244750f, -0.02195503f, 0.01200008f, 0.00738561f, 0.00373358f, -0.03038118f, 
    0.00102137f, -0.01862758f, 0.00394511f, -0.00969275f, 0.02571828f, -0.02400074f, -0.04094502f, 0.00129853f, 
    -0.04124143f, -0.00308082f, -0.03604826f, 0.00533127f, -0.02331901f, -0.02828031f, 0.02943784f, 0.00767040f, 
    -0.01180163f, -0.03454618f, -0.00100387f, -0.02850227f, 0.02404764f, -0.01276589f, 0.00882252f, -0.01784733f, 
    -0.03568082f, 0.02056780f, 0.00312638f, -0.00259275f, -0.02248653f, -0.02623385f, -0.03619021f, 0.01752483f, 
    -0.01683269f, -0.03809781f, 0.01989895f, -0.01900648f, -0.01161780f, 0.02411127f, -0.01959774f, 0.00498454f, 
    0.02430210f, -0.00908214f, -0.02470767f, -0.00785453f, -0.02025814f, 0.02720416f, 0.01310371f, -0.03752369f, 
    0.01566640f, 0.01032111f, 0.02395920f, 0.02297295f, -0.03750310f, -0.04175254f, -0.03145198f, -0.02763091f, 
    0.01639698f, -0.00977450f, -0.02510741f, -0.03312626f, 0.01020244f, -0.00910996f, -0.03078691f, 0.01020589f, 
    -0.02604915f, 0.00606177f, 0.02913273f, 0.02328578f, -0.02158959f, 0.01104658f, 0.00697375f, 0.02081978f, 
    0.00532845f, -0.00238022f, -0.03121727f, 0.01422428f, -0.01891525f, 0.02058028f, -0.00304940f, -0.02436283f, 
    -0.00098008f, -0.01505718f, -0.01096086f, -0.00608260f, 0.01310040f, -0.01895966f, 0.00010307f, -0.00269790f, 
    -0.01644666f, 0.00981167f, 0.01341207f, -0.00256300f, -0.02806490f, 0.01642388f, -0.00954807f, -0.01410720f, 
    0.03002771f, 0.00003407f, -0.01386676f, -0.01209979f, 0.02911633f, -0.02020672f, -0.02817476f, -0.01027260f, 
    -0.01809856f, 0.00162647f, -0.02432857f, -0.01493632f, 0.02974028f, 0.00215038f, 0.02284902f, -0.00395033f, 
    0.01790706f, -0.03268693f, 0.02231352f, 0.02946116f, 0.00900016f, -0.01052255f, -0.03421997f, -0.01141529f, 
    0.01403204f, 0.00894284f, 0.00475481f, -0.01191626f, -0.00535289f, 0.01045676f, -0.02414348f, 0.02246401f, 
    0.00121740f, -0.00849882f, -0.02345196f, 0.02454929f, -0.00899953f, 0.01213793f, -0.02967841f, 0.02889841f, 
    0.00481310f, 0.01673690f, -0.02907592f, -0.03870526f, -0.00399277f, -0.03150473f, 0.00896669f, -0.03175212f, 
    -0.00085926f, -0.00619355f, -0.00832590f, 0.01138555f, 0.02530162f, 0.01423010f, 0.02130706f, -0.02108991f, 
    0.02235885f, -0.00495087f, 0.00521703f, 0.00916017f, 0.02087836f, 0.00071221f, 0.02922591f, 0.01173776f, 
    -0.03180091f, -0.03576213f, 0.00977322f, -0.00869356f, -0.01796229f, -0.04197307f, 0.00922343f, 0.00431586f, 
    -0.04131993f, -0.02992636f, 0.02326104f, -0.02367102f, -0.00394099f, -0.02052637f, 0.00512049f, -0.03656755f, 
    0.00669293f, 0.00821276f, 0.01577043f, -0.02570210f, -0.03319167f, -0.00193980f, -0.03508284f, -0.03987293f, 
    0.00292077f, -0.02030659f, -0.03270440f, 0.02922340f, -0.01467605f, -0.01723786f, -0.00063560f, -0.00991549f, 
    0.02264686f, 0.01815533f, -0.03338878f, 0.01472212f, -0.01053097f, 0.01224375f, -0.02618436f, -0.02812261f, 
    -0.03836925f, 0.01800054f, 0.02397210f, 0.00268864f, -0.01610340f, -0.02816623f, -0.02075247f, -0.01044245f, 
    -0.00687472f, -0.01829691f, 0.01979486f, 0.00818531f, 0.00025389f, 0.02756580f, 0.01595274f, 0.01566195f, 
    -0.02237497f, -0.02514696f, -0.04204251f, -0.03517986f, -0.01931169f, 0.00843341f, 0.00760116f, -0.02885175f, 
    0.00848279f, -0.01532902f, 0.02191603f, 0.01981393f, -0.00907471f, 0.01144548f, -0.00952920f, 0.01493369f, 
    -0.03425512f, -0.02678012f, -0.03354191f, 0.00006194f, -0.04069285f, -0.00307629f, -0.02625399f, -0.02806642f, 
    0.01447238f, -0.02237992f, -0.00445025f, -0.00597543f, -0.01295515f, 0.02943127f, 0.02406726f, -0.01065734f, 
    0.00081793f, 0.02234071f, 0.00875926f, 0.00931844f, 0.02110161f, 0.02955956f, 0.02793548f, -0.03293136f, 
    0.00553709f, 0.02599709f, -0.00092327f, 0.02125854f, -0.02399028f, 0.02800620f, 0.00990785f, 0.00226721f, 
    -0.03334975f, -0.04030491f, 0.01437447f, -0.02697331f, -0.03546027f, -0.00974060f, -0.02489035f, -0.01409750f, 
    0.00034394f, 0.01099688f, 0.02559326f, 0.00235100f, 0.02238848f, -0.02020776f, -0.03607587f, 0.00863239f, 
    -0.01071085f, -0.01914962f, -0.02108642f, -0.00528856f, -0.01766750f, -0.00896460f, -0.03639738f, -0.02597741f, 
    0.02198822f, -0.01350128f, 0.02240713f, -0.02464042f, 0.01042198f, 0.01840129f, 0.00047583f, -0.00037088f, 
    -0.01216053f, 0.02726757f, 0.02487961f, -0.03366635f, -0.02197584f, -0.03225619f, -0.02637517f, 0.02400841f, 
    -0.04112797f, 0.00944100f, -0.01845112f, -0.02341619f, -0.02664055f, 0.01529683f, 0.00611229f, 0.02600469f, 
    0.00779811f, -0.01551876f, -0.02990112f, 0.01169788f, -0.02316819f, -0.03271645f, -0.03443751f, 0.00393071f, 
    -0.01015174f, -0.03413536f, -0.01834354f, -0.03674407f, 0.01187928f, -0.03534031f, 0.00342231f, -0.04096289f, 
    0.01725212f, 0.01959990f, -0.01833691f, -0.00516277f, 0.02121754f, 0.02483288f, 0.02007359f, 0.01507889f, 
    0.01667384f, -0.00246043f, -0.03446463f, 0.01526751f, 0.02628161f, 0.00750099f, -0.03314081f, -0.03081503f, 
    0.01643088f, -0.02618394f, -0.01479300f, 0.02324373f, 0.02172207f, -0.00528236f, 0.02914239f, -0.02140687f, 
    -0.03070639f, -0.01080290f, -0.02858513f, -0.00738746f, 0.01920633f, 0.01317362f, -0.02338525f, -0.03861276f, 
    0.00932315f, -0.00682638f, -0.03688156f, -0.01138141f, 0.00043359f, -0.03969199f, 0.00055274f, 0.02846281f, 
    -0.01803165f, 0.01589122f, 0.02357445f, -0.00572164f, -0.00288457f, -0.03427407f, -0.02538054f, -0.03900804f, 
    -0.02500743f, 0.01461258f, -0.00821410f, 0.02579503f, 0.01324013f, -0.02491417f, -0.03521731f, -0.01602598f, 
    0.00239249f, -0.02812093f, -0.01328699f, -0.02301860f, -0.01004477f, 0.00551185f, -0.00373180f, -0.02885784f, 
    0.02305348f, -0.01573909f, -0.01982229f, 0.01923224f, -0.00499901f, 0.00330761f, 0.02476607f, 0.02877676f, 
    -0.01150490f, 0.01110315f, -0.01812035f, 0.02464671f, 0.01276176f, -0.03274778f, -0.02320127f, -0.01522571f, 
    0.01123818f, -0.01299863f, 0.01753135f, -0.01843092f, -0.01637945f, 0.00659796f, -0.01774548f, -0.02327591f, 
    -0.02201115f, -0.00272417f, 0.01463015f, -0.00848948f, -0.03101585f, -0.00673587f, -0.01440923f, -0.03152781f, 
    0.02666819f, -0.02229312f, 0.00497055f, -0.01186086f, -0.03445712f, 0.01668701f, -0.01805958f, -0.02725623f, 
    0.00934007f, -0.00658864f, 0.01823608f, -0.02446851f, -0.02111247f, 0.01307840f, -0.00599801f, 0.01224288f, 
    0.00834900f, -0.02728254f, -0.00468906f, 0.01488453f, 0.02595608f, 0.00692594f, 0.02863126f, 0.00197895f, 
    0.02797731f, 0.00157267f, -0.00355737f, 0.02029520f, 0.00687937f, -0.01328121f, -0.02434671f, -0.00716570f, 
    -0.01287931f, 0.01936841f, -0.00207811f, 0.00845010f, -0.03524895f, -0.02235668f, -0.02697381f, -0.04003147f, 
    -0.02951918f, -0.02602107f, 0.02893670f, -0.03382979f, 0.02415338f, -0.03735569f, 0.01457331f, 0.01184184f, 
    0.00473958f, -0.01781891f, -0.03560589f, 0.02125755f, 0.02123131f, 0.00772627f, -0.03036405f, -0.03330227f, 
    0.02897177f, -0.01465833f, -0.00080974f, 0.01468305f, -0.00821809f, 0.01972400f, -0.01138895f, -0.02031772f, 
    0.01373679f, -0.00667968f, 0.00293278f, 0.00422231f, -0.00737869f, -0.02970306f, -0.01779907f, -0.02260858f, 
    -0.02181939f, 0.01895801f, 0.00987693f, 0.00929276f, -0.00700782f, 0.01542595f, -0.02576256f, -0.02632843f, 
    0.00224009f, -0.03299560f, -0.02599088f, -0.01628613f, -0.03234788f, -0.04159438f, 0.01544408f, 0.02613682f, 
    -0.02632517f, -0.04156148f, 0.02326718f, 0.01952585f, -0.01037476f, 0.02595203f, -0.03058788f, 0.00655604f, 
    0.01629175f, -0.02486333f, -0.02879293f, -0.02901420f, 0.02742173f, 0.01249230f, 0.02047910f, 0.01299210f, 
    0.00629993f, 0.02892380f, 0.02110764f, -0.03065457f, -0.00391371f, -0.03622042f, -0.02395351f, -0.00876861f, 
    -0.00190010f, -0.02270308f, 0.01006115f, 0.02767552f, 0.00309746f, -0.03317098f, -0.01978279f, -0.02542269f, 
    -0.02709117f, -0.01368340f, 0.00410469f, -0.03886703f, -0.02526543f, -0.00302772f, -0.01274271f, 0.01621128f, 
    0.00991610f, -0.03943251f, -0.02553426f, 0.00932910f, -0.04300575f, 0.02342484f, -0.02774918f, 0.01776741f, 
    0.02856707f, 0.01077699f, 0.00274126f, 0.02717362f, -0.02803406f, -0.03087265f, -0.03781159f, -0.00390747f, 
    -0.02882907f, -0.00839633f, 0.00658285f, 0.00377639f, 0.02587730f, -0.00170429f, 0.00688995f, 0.00152613f, 
    0.02814605f, -0.00984859f, 0.03487688f, -0.01475887f, -0.02880577f, 0.02317030f, -0.01575020f, -0.01725239f, 
    -0.03567300f, 0.01577292f, -0.00926542f, 0.03727502f, -0.03928059f, 0.02286046f, -0.02163303f, 0.01793157f, 
    0.01657502f, 0.03133075f, -0.02835079f, -0.02836178f, -0.01478398f, 0.00296948f, -0.01146715f, -0.02516371f, 
    0.00696674f, -0.00957259f, 0.02599104f, -0.00006775f, -0.01799725f, -0.01283934f, -0.02666316f, 0.01483041f, 
    -0.00490538f, -0.02132171f, -0.03595623f, 0.01963990f, -0.00586489f, -0.00927260f, 0.02058920f, -0.02730706f, 
    -0.03856128f, -0.02863463f, 0.02572710f, 0.00292783f, -0.01523002f, 0.02669132f, -0.02009331f, 0.00250921f, 
    0.00636993f, -0.02785082f, 0.00291256f, -0.02300147f, -0.03216146f, 0.03333011f, -0.00311518f, -0.02576018f, 
    -0.01658329f, -0.02218784f, -0.04157540f, 0.02167816f, 0.01186015f, -0.03613042f, 0.01099594f, 0.03363261f, 
    -0.04216299f, -0.02170281f, -0.02747414f, 0.02657767f, 0.00804453f, 0.02631302f, -0.01710475f, -0.01801456f, 
    -0.03074173f, 0.01613286f, -0.02625757f, -0.01595134f, -0.00005912f, -0.02800971f, -0.02471313f, -0.02329973f, 
    -0.03393060f, 0.00613936f, -0.01068579f, -0.00929288f, 0.00373417f, -0.00011430f, -0.00648772f, -0.02321208f, 
    -0.03293137f, -0.02785825f, 0.01536380f, -0.00123805f, 0.00341209f, 0.00774159f, 0.02238560f, -0.03648581f, 
    0.01561170f, -0.02973417f, -0.00780763f, 0.02113979f, -0.00938134f, -0.01269656f, -0.01658790f, 0.00459992f, 
    -0.02115955f, -0.02665863f, -0.01749926f, 0.01056647f, 0.02058883f, -0.00413103f, -0.02482513f, -0.02551776f, 
    0.00679256f, 0.02762987f, 0.00486560f, -0.01998036f, -0.00172298f, -0.02852897f, -0.01073943f, 0.02176902f, 
    0.02998122f, -0.02475001f, -0.03752860f, -0.00659354f, 0.01252398f, -0.03458970f, 0.02731680f, -0.03473741f, 
    -0.03390522f, -0.03884801f, 0.03281621f, 0.00131252f, -0.04232498f, 0.00178438f, 0.01371859f, -0.02184238f, 
    -0.02651480f, -0.02386324f, 0.01778984f, 0.02301652f, -0.00135404f, -0.03045797f, -0.04162144f, -0.01869634f, 
    0.00376666f, 0.02548117f, -0.02219115f, 0.01052756f, -0.01250025f, -0.03695772f, -0.00564880f, 0.00335491f, 
    0.02167840f, 0.00594701f, 0.00698973f, -0.02277945f, 0.01253426f, -0.03757697f, 0.02353550f, -0.01635995f, 
    0.02744954f, -0.02706828f, 0.00276566f, 0.00098309f, 0.01993508f, -0.01994122f, 0.00553011f, -0.01163159f, 
    0.01745478f, 0.00364750f, -0.00181771f, 0.01801386f, 0.00840916f, -0.02645814f, 0.00443872f, -0.02613622f, 
    -0.02702150f, 0.03098845f, -0.04094804f, 0.02381956f, -0.03046033f, -0.00617110f, 0.02746466f, 0.01351792f, 
    -0.04267926f, -0.00694730f, 0.02509012f, -0.03359759f, 0.00645365f, -0.00135638f, -0.00498906f, -0.00824759f, 
    -0.03065797f, 0.02401493f, -0.01692436f, 0.00031018f, -0.01003247f, 0.00348935f, -0.00710050f, -0.00911339f, 
    -0.02720822f, -0.00993996f, 0.01395366f, -0.00249194f, 0.01677609f, -0.02656228f, -0.01775069f, 0.00709762f, 
    -0.00744794f, -0.04226997f, -0.01374757f, 0.00339859f, 0.02276463f, 0.01279113f, -0.01124356f, -0.02836069f, 
    -0.00393885f, 0.00445429f, 0.01731922f, 0.01989512f, 0.02165575f, -0.00137857f, -0.02002422f, 0.02494708f, 
    -0.02687200f, 0.00721347f, -0.02812155f, -0.02815257f, -0.01902720f, 0.02060489f, 0.01362865f, 0.01351085f, 
    -0.03139106f, -0.03911684f, -0.01316648f, -0.03140519f, -0.02156392f, 0.00707552f, -0.01109970f, -0.04185805f, 
    0.00778817f, 0.01920425f, 0.00404949f, 0.00818753f, 0.01380629f, 0.00601672f, 0.01425534f, 0.01790160f, 
    0.00802119f, -0.01236312f, 0.01758761f, -0.02540699f, -0.01076612f, -0.03920296f, -0.00517378f, 0.02659624f, 
    0.00672994f, 0.00722903f, -0.01474178f, -0.02994257f, 0.02592834f, -0.04202071f, -0.04035400f, 0.01779357f, 
    -0.02225433f, -0.03527383f, 0.01569116f, -0.03897340f, -0.03166265f, -0.01006502f, -0.01483815f, 0.02587506f, 
    0.02520085f, -0.00573594f, 0.02106649f, -0.04025600f, -0.03983608f, 0.00859438f, 0.02596648f, -0.03087568f, 
    -0.02182773f, 0.01148427f, -0.04171345f, 0.02266453f, -0.01928649f, -0.00156418f, -0.04061772f, 0.02505329f, 
    -0.01014610f, -0.03396539f, 0.00286925f, -0.00991347f, -0.00142466f, 0.00336834f, -0.01518420f, -0.02598479f, 
    0.02011394f, 0.01617760f, -0.00338349f, 0.01743023f, 0.01971990f, -0.01420142f, -0.00014822f, 0.01043939f, 
    -0.02253520f, -0.02655297f, -0.04062674f, 0.02032769f, -0.01134632f, 0.02452842f, 0.00284279f, -0.01829544f, 
    -0.01719938f, -0.00721548f, -0.03573621f, -0.00845105f, -0.03698419f, -0.03676527f, 0.00435135f, 0.02388688f, 
    -0.00600268f, 0.02421395f, -0.01556376f, -0.03327877f, -0.01501770f, -0.01595952f, -0.00404641f, 0.02332561f, 
    -0.03294790f, -0.01098424f, 0.02238125f, -0.02329196f, -0.02434912f, -0.00754063f, 0.00876861f, -0.04115128f, 
    0.01919415f, -0.02583338f, -0.03125058f, 0.01923362f, 0.00493895f, -0.03319754f, -0.01786841f, -0.03281488f, 
    0.00200979f, -0.00611790f, 0.02113009f, 0.02091044f, -0.02555813f, -0.00933409f, 0.00970194f, -0.02109047f, 
    -0.00671370f, -0.01888655f, 0.00957700f, -0.00874763f, -0.00124810f, -0.04310782f, 0.00161047f, -0.00173837f, 
    -0.00046453f, 0.01735543f, -0.01405430f, -0.03580273f, -0.03551590f, 0.02593247f, -0.00642944f, 0.02169893f, 
    -0.02407144f, 0.02744082f, 0.01815686f, -0.03932826f, 0.01302457f, -0.02432339f, -0.00283744f, -0.01605520f, 
    -0.03283181f, 0.00919032f, -0.00448933f, -0.00145050f, 0.00739367f, -0.03593934f, -0.00167753f, 0.01012991f, 
    0.00676341f, 0.00050260f, 0.00096772f, -0.02117245f, 0.01790767f, -0.00458366f, 0.00783020f, -0.00960292f, 
    -0.03670172f, -0.01738733f, -0.02488033f, 0.00829475f, 0.00899793f, 0.01878243f, -0.00212171f, 0.03309172f, 
    0.01615334f, 0.01763880f, -0.02367964f, -0.03376275f, -0.00055018f, 0.02377822f, -0.00972483f, 0.00318926f, 
    0.02283741f, -0.00021657f, 0.02277410f, -0.01736762f, -0.01209717f, -0.01966015f, -0.03343147f, -0.03774510f, 
    -0.00831986f, -0.03506644f, -0.02064874f, 0.02847392f, -0.03601751f, -0.04446020f, -0.00052617f, 0.00447449f, 
    -0.00549870f, -0.02588887f, -0.02672004f, 0.01434852f, 0.00868612f, 0.01440132f, -0.04063488f, 0.01818683f, 
    -0.01588379f, -0.00569862f, -0.02063199f, -0.01948910f, -0.04176626f, -0.00361981f, -0.02812442f, 0.02851600f, 
    0.00799251f, -0.04026349f, 0.00593549f, 0.01135079f, 0.02260823f, -0.01579863f, 0.00293032f, 0.00432877f, 
    -0.03087822f, -0.01854038f, -0.02854209f, -0.03029259f, -0.00226185f, 0.01886270f, -0.00505261f, 0.01717793f, 
    -0.02492405f, -0.01735266f, -0.04240585f, 0.00662889f, -0.04425732f, -0.04326748f, -0.02383467f, 0.00294687f, 
    0.01834437f, -0.01814672f, -0.03867298f, 0.00559137f, -0.03637870f, -0.00161993f, -0.00836358f, -0.01127406f, 
    -0.01116566f, -0.02800192f, -0.00278357f, 0.00419795f, 0.02460613f, -0.01956904f, -0.01345932f, -0.02344018f, 
    -0.02058427f, -0.04017511f, 0.01989437f, -0.02124546f, -0.01408292f, -0.03711681f, -0.02434673f, -0.03924970f, 
    -0.00878298f, -0.02070427f, -0.03582680f, 0.00341650f, 0.00364763f, 0.01747944f, -0.01887355f, -0.02150483f, 
    -0.01579962f, -0.01533062f, -0.03255143f, 0.00798770f, -0.02392568f, -0.00727709f, -0.04025828f, -0.02431389f, 
    0.00033685f, -0.00983599f, -0.03223387f, 0.01571226f, 0.01432077f, 0.02331338f, 0.02582936f, -0.02971827f, 
    -0.02501206f, 0.02439681f, 0.01074449f, 0.02649595f, -0.03002901f, -0.03106873f, -0.03357653f, 0.04111579f, 
    -0.00439306f, -0.03166850f, -0.00862917f, -0.00777346f, 0.02682587f, 0.00811538f, -0.02495838f, 0.04040660f, 
    0.01564904f, -0.00028515f, 0.01754780f, -0.02581876f, 0.02153460f, -0.02709972f, 0.01379808f, -0.01826092f, 
    -0.00768044f, -0.02934858f, 0.01345970f, -0.01855463f, -0.02825717f, -0.01575783f, -0.00210446f, 0.00090339f, 
    0.00327017f, 0.03135062f, -0.01177195f, 0.00928019f, -0.00539683f, -0.00881227f, -0.03113366f, -0.03984646f, 
    0.02004668f, 0.02668837f, -0.02884223f, 0.02524072f, 0.01750150f, 0.02092189f, -0.04299468f, -0.04070931f, 
    0.00489131f, 0.01149532f, 0.01371714f, 0.01634515f, -0.01813612f, -0.04092227f, -0.02505334f, 0.02588940f, 
    0.01326288f, 0.00881987f, -0.03821701f, 0.01010346f, -0.00612543f, -0.01835266f, -0.04042446f, 0.02134145f, 
    -0.00806366f, -0.03848993f, -0.02634330f, -0.02796326f, 0.00134799f, -0.02572489f, -0.01744387f, -0.03708893f, 
    0.01637851f, 0.02142881f, -0.01941923f, 0.00418762f, 0.02190638f, -0.00657512f, 0.00588307f, -0.00898676f, 
    -0.03048855f, 0.01736844f, -0.01116776f, -0.02193628f, -0.03212153f, 0.01343613f, 0.01214322f, -0.02675525f, 
    -0.01184252f, -0.02894674f, -0.00091840f, -0.04240847f, -0.02799872f, 0.01573359f, 0.02194120f, -0.00638346f, 
    0.00338154f, -0.04029759f, -0.00077554f, 0.02227851f, 0.00518060f, 0.01057546f, -0.00954080f, -0.01533687f, 
    -0.02661692f, 0.00025594f, 0.02827972f, -0.04406679f, -0.03093082f, 0.00387701f, -0.01304240f, 0.00573098f, 
    -0.04097349f, -0.02695881f, 0.00177201f, -0.01849591f, -0.02745519f, 0.02425036f, 0.01944696f, 0.02024725f, 
    -0.03440784f, 0.01268377f, 0.02244924f, 0.01975792f, -0.01583183f, -0.01311817f, -0.04270846f, 0.02158036f, 
    -0.00525213f, 0.00685706f, 0.01727197f, 0.01964995f, 0.00491462f, -0.00240515f, -0.02842142f, -0.01911315f, 
    -0.00658359f, -0.04100922f, -0.01047967f, -0.02104370f, 0.00221439f, 0.02868168f, 0.02426969f, -0.02853677f, 
    -0.01107484f, -0.02429881f, 0.01226084f, 0.01679677f, -0.00688511f, -0.00665557f, -0.03449826f, -0.02525837f, 
    0.02787300f, 0.00913554f, -0.04139035f, -0.04194399f, -0.00024876f, 0.01803190f, 0.02460296f, -0.00867829f, 
    0.00475945f, -0.03269763f, -0.03541598f, -0.04324935f, -0.01659266f, 0.00272112f, 0.01728935f, 0.01306164f, 
    -0.03590989f, -0.00370173f, 0.01847343f, -0.00001006f, 0.00091989f, -0.02420310f, 0.02519920f, 0.00706884f, 
    0.02734269f, 0.02022683f, -0.03152012f, -0.03175532f, 0.00011314f, -0.01139032f, -0.00603649f, -0.00552621f, 
    0.00077895f, -0.03748875f, -0.00122834f, -0.01331605f, 0.02021019f, -0.00754115f, -0.01960013f, -0.03736091f, 
    -0.03626528f, -0.04320626f, -0.00679582f, 0.01172468f, -0.03241442f, 0.02248822f, -0.01816207f, -0.03635535f, 
    -0.03720327f, 0.02662704f, 0.00875737f, -0.00461263f, 0.02266254f, -0.03047755f, -0.02885366f, 0.00777283f, 
    -0.00833217f, -0.02281187f, -0.04027221f, -0.01509618f, -0.03619039f, -0.00996637f, 0.01735159f, -0.00848842f, 
    -0.00173839f, -0.01730118f, -0.01638989f, -0.01497608f, 0.00195878f, -0.00853673f, -0.00991204f, -0.03173568f, 
    -0.00608750f, -0.03875766f, 0.01860851f, 0.01875432f, -0.04083688f, 0.02292617f, 0.00583882f, -0.03938748f, 
    -0.01252609f, -0.03167743f, -0.01225499f, 0.00467275f, -0.02535462f, -0.00012219f, -0.03364616f, 0.00062975f, 
    0.01138731f, 0.01638502f, -0.03288294f, -0.03563835f, -0.02709673f, -0.02075545f, 0.02194181f, -0.03433349f, 
    -0.02769484f, -0.00714168f, -0.03029103f, -0.00074703f, 0.01492615f, -0.04161735f, 0.02137835f, 0.00208439f, 
    -0.00931612f, -0.03936039f, 0.00710232f, -0.02603678f, 0.01457749f, 0.02305443f, -0.02082915f, -0.03084791f, 
    0.02195454f, 0.00952981f, -0.02930178f, -0.01583105f, -0.02611468f, -0.01986015f, 0.02854091f, 0.00121781f, 
    -0.04199547f, -0.03217310f, 0.00122927f, 0.02983893f, 0.01428259f, -0.00882874f, 0.00167560f, -0.01003820f, 
    0.02065974f, -0.02853409f, 0.01038582f, 0.02391669f, -0.00248653f, -0.03598777f, 0.01036619f, -0.03403754f, 
    0.00515083f, 0.00101951f, 0.00243198f, -0.00047713f, 0.02342308f, 0.03862796f, 0.00540779f, 0.00462506f, 
    -0.01190508f, -0.00681987f, 0.01430871f, -0.04152666f, 0.00417583f, 0.02000083f, -0.01840758f, 0.00762106f, 
    -0.03117966f, 0.01431801f, 0.01147707f, -0.01858746f, 0.01442222f, -0.01576135f, -0.02778539f, 0.02587332f, 
    -0.00773162f, 0.02802884f, 0.02578786f, 0.01798074f, 0.01825537f, 0.00658113f, 0.02611970f, -0.02791436f, 
    -0.00484207f, 0.01609820f, -0.00439449f, -0.03764702f, -0.02790171f, -0.01948132f, 0.02294676f, 0.02710131f, 
    -0.03370004f, 0.00486337f, 0.00885969f, -0.01287159f, 0.00142630f, -0.00714211f, -0.00335256f, -0.04129346f, 
    -0.03478916f, 0.02333582f, -0.03977876f, -0.00031767f, -0.00501047f, 0.02791983f, 0.00317410f, -0.03423091f, 
    0.00599338f, -0.03852930f, -0.00289179f, -0.00980562f, -0.02979907f, -0.03861891f, 0.01949527f, -0.00435736f, 
    -0.00357274f, 0.00455813f, -0.00590414f, -0.02127471f, -0.01681772f, -0.03854158f, -0.01496197f, -0.00964832f, 
    -0.01312316f, 0.02288098f, 0.02218399f, -0.01452913f, -0.02559117f, 0.02379518f, -0.03769185f, 0.02762108f, 
    -0.00562260f, -0.01664003f, -0.04125617f, -0.03697165f, -0.02473793f, 0.01431709f, -0.00743339f, -0.02615266f, 
    -0.04178588f, -0.04149639f, 0.00943285f, 0.00022051f, -0.04054524f, 0.01039178f, -0.02082497f, -0.03141616f, 
    -0.02685494f, 0.02233426f, -0.03570884f, -0.01748577f, 0.01263029f, 0.02785214f, -0.03183459f, 0.01122317f, 
    0.02940108f, -0.03763322f, -0.03252562f, -0.03442131f, -0.00239987f, -0.00772808f, 0.00142295f, -0.00057277f, 
    -0.03230789f, -0.00838157f, 0.00796787f, 0.02517357f, -0.01151124f, -0.01584308f, 0.01897866f, -0.02065917f, 
    -0.02237206f, 0.02935289f, 0.00006158f, 0.00398615f, -0.04205729f, -0.03514500f, 0.02281320f, -0.00056887f, 
    0.01887500f, -0.01885178f, -0.00936524f, -0.03156335f, -0.00562263f, -0.01909822f, 0.00186191f, -0.01767302f, 
    0.02392444f, -0.01184319f, -0.01760927f, -0.02283532f, -0.02832044f, 0.01613919f, 0.02925265f, -0.01994882f, 
    -0.03709653f, 0.00630536f, -0.02414727f, -0.03779430f, -0.01773483f, 0.02230731f, 0.01639897f, -0.01871440f, 
    -0.03658577f, -0.03285874f, -0.00222380f, 0.02326747f, 0.01476930f, -0.03197825f, -0.03494120f, 0.00983349f, 
    0.00252561f, 0.02653059f, -0.01085951f, 0.02850523f, -0.02346518f, 0.01753411f, -0.02737638f, -0.03022433f, 
    -0.03101075f, -0.04068091f, -0.00541190f, -0.03423382f, 0.01424866f, 0.01493985f, 0.03177556f, -0.02248893f, 
    0.01081468f, 0.02700844f, -0.03496855f, -0.02681607f, 0.01274662f, 0.02957645f, -0.03075039f, -0.01456955f, 
    0.01946479f, -0.04070034f, 0.01110625f, -0.00250281f, -0.03920558f, -0.00351919f, -0.03156370f, 0.00605048f, 
    -0.00445585f, -0.02730790f, -0.03950861f, -0.00627084f, -0.03735949f, -0.02924518f, -0.02183474f, -0.03444815f, 
    -0.01407050f, -0.02708876f, 0.00215999f, 0.01734509f, 0.00267344f, -0.00721576f, 0.02437902f, 0.00434376f, 
    -0.01796414f, -0.00038680f, 0.00235942f, -0.02602348f, -0.01188224f, 0.00653621f, -0.03410322f, -0.00156704f, 
    0.00981604f, -0.00456854f, -0.01365452f, 0.00101000f, -0.02425925f, 0.01383702f, 0.01691299f, 0.02205740f, 
    -0.00782109f, -0.03212237f, -0.03367837f, -0.00531666f, -0.01426068f, -0.00031928f, -0.00258211f, 0.00283120f, 
    -0.02319166f, 0.01390012f, 0.02300042f, 0.00820720f, -0.02168768f, -0.03247542f, -0.03608854f, 0.02611547f, 
    0.00432842f, -0.00217748f, 0.02563241f, -0.00949751f, -0.01689544f, 0.02235078f, -0.00376540f, 0.01610512f, 
    0.01948638f, 0.02143297f, 0.01901018f, 0.00004565f, 0.00682707f, -0.01624082f, -0.03411263f, -0.01731120f, 
    0.01655566f, -0.01843299f, 0.00716917f, -0.02933217f, -0.01140876f, 0.01425521f, 0.00389491f, 0.01676100f, 
    0.02390909f, 0.00571865f, -0.00049179f, 0.00541917f, 0.02228081f, 0.02632634f, 0.01535988f, 0.01722733f, 
    -0.03815160f, -0.01139891f, 0.01869601f, -0.00482089f, 0.00104205f, 0.00049336f, 0.02661334f, -0.01013122f, 
    0.00050809f, -0.02589705f, 0.02746611f, 0.00682549f, -0.03785057f, 0.00785189f, -0.01599334f, 0.01386190f, 
    -0.00312294f, 0.02215048f, -0.03141934f, 0.02688588f, -0.02305415f, 0.00759237f, -0.04038439f, -0.02170706f, 
    -0.03466850f, -0.01561325f, 0.00776959f, 0.02589224f, 0.01314473f, -0.02657981f, 0.01874938f, -0.02804886f, 
    -0.03738842f, -0.02604707f, -0.01432212f, 0.01716170f, 0.00096885f, -0.00935026f, 0.01030417f, -0.02533653f, 
    -0.02551072f, 0.00382326f, 0.00428360f, -0.02828102f, -0.03657486f, -0.01507745f, -0.00005089f, -0.03955930f, 
    -0.01735204f, 0.01973827f, 0.02626586f, -0.01196625f, -0.01181037f, 0.02302013f, -0.03140599f, -0.01113545f, 
    0.02735377f, 0.01629531f, -0.00640137f, -0.02767037f, 0.01099688f, 0.00131233f, -0.01750770f, -0.02605215f, 
    -0.00713432f, -0.01749709f, 0.00690417f, 0.00877728f, 0.02317658f, -0.02866717f, -0.00345344f, 0.00957679f, 
    0.00831098f, -0.01682365f, -0.00276915f, -0.02260848f, -0.02751286f, 0.02969838f, -0.03841745f, -0.01611201f, 
    0.02404047f, -0.03265408f, 0.01908839f, -0.02260309f, 0.00342019f, -0.03285997f, -0.02407704f, -0.02910715f, 
    -0.00575759f, -0.00109855f, 0.01482914f, 0.00137558f, 0.01608381f, -0.03102490f, 0.02642870f, -0.04168398f, 
    0.00816566f, -0.00761138f, 0.01848314f, -0.03542727f, 0.01137761f, -0.01733031f, 0.02997062f, -0.00484418f, 
    0.02472759f, 0.01270856f, 0.00362212f, -0.01119115f, 0.00325669f, -0.02862814f, -0.04156211f, -0.02292797f, 
    0.00226830f, 0.01948743f, 0.02844373f, -0.03959079f, -0.03869078f, -0.03200180f, 0.01791040f, 0.00098393f, 
    -0.03947513f, 0.01496853f, 0.00349538f, 0.01877902f, -0.03684534f, -0.03241113f, -0.00200440f, -0.02955829f, 
    -0.00651069f, 0.01435133f, 0.00535799f, 0.00081015f, 0.02028673f, -0.00900741f, -0.02178427f, -0.02434362f, 
    -0.00018043f, -0.04191834f, -0.03032817f, 0.01335298f, 0.01953979f, 0.01623917f, -0.03170792f, -0.02899682f, 
    -0.03513044f, -0.02439237f, 0.01338904f, 0.01492742f, -0.00430713f, 0.01814094f, 0.00232168f, -0.00521736f, 
    -0.01370328f, 0.02184076f, -0.00786499f, 0.00981503f, -0.02204901f, 0.00472961f, -0.00555970f, 0.00546914f, 
    0.01705158f, 0.02811420f, 0.02784370f, -0.00994477f, -0.03273288f, 0.01953197f, -0.02227094f, 0.01930161f, 
    -0.04114300f, 0.02028778f, -0.02229043f, -0.02023102f, -0.02680059f, 0.00140304f, -0.02434664f, -0.00169307f, 
    -0.00885558f, -0.03184046f, -0.02815031f, 0.01826689f, 0.00380546f, 0.02194559f, 0.01629313f, 0.02233351f, 
    0.02026080f, -0.00669231f, -0.03676395f, 0.02760578f, -0.03190254f, 0.00502271f, 0.01380177f, 0.02719421f, 
    -0.03858870f, -0.03501948f, 0.01979428f, -0.03411197f, -0.02492265f, -0.00112181f, -0.02348358f, 0.00891354f, 
    -0.02692656f, 0.02218713f, -0.01114971f, -0.02297161f, -0.02226633f, -0.02991822f, 0.01009970f, -0.03945919f, 
    -0.02033976f, -0.01367599f, -0.01793953f, 0.01774065f, 0.01060911f, 0.02529918f, -0.02843213f, 0.00256056f, 
    -0.03800804f, -0.01287221f, 0.00060502f, 0.02476373f, 0.00863859f, -0.02408855f, -0.02166496f, 0.02879151f, 
    0.01517181f, -0.03406698f, 0.02847130f, 0.03002634f, 0.02732962f, 0.00728504f, -0.01699946f, -0.02425406f, 
    -0.04127271f, -0.03448790f, 0.01803314f, -0.03361813f, -0.03829621f, 0.00786167f, 0.02366080f, -0.03917400f, 
    -0.01633118f, -0.00355615f, 0.00056512f, -0.02109736f, 0.00925663f, 0.00489248f, 0.00821334f, -0.02579473f, 
    -0.02684000f, -0.03381491f, -0.01301346f, 0.00586456f, 0.00600085f, -0.02739388f, 0.01678418f, -0.02338185f, 
    0.02121730f, 0.00915149f, 0.00242433f, 0.01544227f, -0.02696116f, 0.00505644f, -0.01471005f, 0.01302156f, 
    0.01287022f, -0.03718866f, -0.02269281f, -0.04148047f, -0.03969916f, 0.01725873f, 0.02010010f, -0.00234978f, 
    -0.00922676f, -0.01815418f, 0.01111411f, -0.00701571f, 0.01467513f, 0.01455565f, -0.02593960f, 0.02501634f, 
    -0.00739771f, 0.02121994f, -0.03577367f, 0.01183366f, -0.00133813f, 0.02085400f, -0.02586568f, -0.04166154f, 
    -0.01346153f, -0.03200951f, 0.02833537f, -0.03962569f, -0.02771198f, -0.03678459f, -0.03716090f, -0.02122323f, 
    0.00484654f, 0.00487784f, 0.02333918f, 0.02044268f, 0.02481358f, -0.01548884f, 0.01277393f, -0.01822996f, 
    0.02425173f, 0.00438725f, 0.02467448f, 0.00379954f, 0.02369263f, -0.00691203f, -0.02557405f, -0.03269262f, 
    -0.02915365f, 0.00170282f, 0.01013113f, -0.02544710f, -0.03120368f, 0.00954975f, 0.00317210f, 0.00228233f, 
    0.01292667f, -0.03933818f, 0.02435974f, 0.01188254f, 0.02185769f, -0.02394260f, 0.01365789f, -0.00236508f, 
    0.02431972f, -0.02557457f, -0.01924573f, -0.04147053f, -0.01494969f, -0.02991461f, -0.01675995f, -0.02584772f, 
    0.00415863f, -0.02868290f, -0.04097097f, -0.00796259f, -0.00582818f, -0.00821155f, -0.00122794f, -0.03547527f, 
    0.01259118f, -0.01532274f, -0.03504593f, -0.02217925f, -0.00238537f, -0.01560156f, -0.01930360f, -0.03549618f, 
    -0.01205582f, -0.00522417f, 0.01754555f, -0.03770037f, -0.00001823f, 0.02020016f, 0.02224420f, -0.00097366f, 
    -0.01477339f, -0.02442208f, 0.01490746f, 0.03909940f, -0.01830381f, 0.02227532f, -0.03336111f, 0.02858596f, 
    -0.02843021f, 0.00220245f, 0.02693721f, -0.01280850f, 0.00662160f, -0.02180946f, -0.02696395f, -0.01226735f, 
    -0.01527575f, -0.03424315f, -0.04113505f, 0.00466925f, -0.03875973f, 0.00789897f, 0.01895311f, -0.01395688f, 
    -0.01752387f, -0.03420826f, 0.02607455f, -0.03668536f, 0.02946879f, 0.00600438f, -0.00121223f, -0.01602856f, 
    0.02785731f, 0.02925384f, -0.00341343f, -0.00104160f, 0.00648191f, -0.01623904f, -0.03304565f, -0.03079417f, 
    0.02726203f, -0.03631227f, 0.01437219f, 0.00002316f, -0.02032013f, -0.04057328f, -0.00222180f, 0.01961814f, 
    0.02017035f, -0.02075275f, -0.01686991f, 0.01098803f, 0.00635250f, -0.00278396f, 0.02670703f, -0.03375819f, 
    -0.03390883f, 0.01314055f, 0.02261637f, 0.02054578f, 0.02364927f, 0.01472543f, 0.00143506f, -0.03475082f, 
    -0.02127961f, -0.02638382f, 0.02371759f, -0.01330085f, 0.02243534f, 0.01374913f, -0.00466728f, -0.02912293f, 
    0.01479852f, -0.03051917f, -0.01561350f, -0.02281962f, -0.02192367f, -0.01180251f, -0.02054394f, 0.01573657f, 
    0.35624328f, 0.41416109f, 0.18910635f, 0.07852005f, 0.00550055f, 0.08412675f, 0.10621164f, 0.00814251f, 
    0.01684762f, -0.09576658f, 0.01487983f, -0.01874940f, 0.09047239f, -0.19889601f, -0.33380327f, -0.05197083f, 
    -0.02389554f, 0.02654578f, 0.13866314f, -0.03454730f, 0.02826338f, -0.05087930f, 0.14781369f, -0.10140727f, 
    -0.09860545f, 0.01217621f, -0.27262729f, -0.37621269f, 0.26604614f, -0.01098234f, 0.01670193f, 0.14159442f, 
    -0.02569761f, 0.08707909f, 0.19609323f, -0.15266876f, -0.19345725f, -0.15803193f, -0.10425343f, 0.04697430f, 
    0.01222272f, -0.01797641f, 0.06080223f, -0.04327764f, 0.09954684f, -0.00236028f, -0.01248104f, 0.18536630f, 
    0.12373395f, -0.08289976f, -0.12944415f, 0.01583685f, 0.03506877f, -0.11602655f, 0.03085777f, -0.02753610f, 
    0.15718515f, -0.03319237f, 0.10896221f, 0.06788187f, 0.20910621f, 0.52667212f, 0.09761277f, 0.19064711f, 
    0.09393651f, 0.16114078f, 0.08081299f, 0.21787630f, 0.00578320f, -0.01182044f, -0.04005522f, 0.17223707f, 
    -0.53924763f, -0.22296068f, 0.35250783f, 0.11311384f, 0.12734604f, 0.11282338f, 0.04320280f, -0.08001709f, 
    -0.08866473f, 0.02402878f, -0.22986773f, 0.03602203f, 0.06497186f, 0.36059296f, 0.05910708f, 0.08943353f, 
    0.18274276f, 0.01227459f, 0.09726273f, 0.12208884f, 0.06213038f, 0.07369117f, 0.05289256f, -0.01504225f, 
    -0.36926299f, 0.25543100f, -0.29905722f, 0.09378544f, 0.09965608f, 0.04893606f, 0.01855005f, 0.03722704f, 
    0.07089794f, -0.07772393f, 0.02070835f, -0.01194165f, 0.20139468f, 0.19643518f, 0.19494925f, 0.06814762f, 
    0.19059940f, 0.06403636f, -0.10052980f, 0.11116495f, -0.03697562f, -0.02321507f, 0.23346803f, 0.02084620f, 
    -0.11220686f, -0.26894432f, 0.33302012f, -0.31830111f, -0.02832734f, 0.03046532f, -0.00845297f, 0.25890568f, 
    0.18281183f, 0.22251052f, -0.22323339f, 0.01329803f, -0.21598585f, 0.23915760f, 0.01082225f, -0.04702987f, 
    0.08180244f, -0.01090435f, 0.12978962f, -0.02646644f, 0.16976804f, -0.09558274f, -0.11946867f, 0.10699060f, 
    0.45040870f, 0.09823907f, 0.08273993f, -0.11307544f, 0.03445015f, 0.20577483f, 0.03867251f, 0.09240349f, 
    -0.11455456f, 0.08527995f, 0.01189667f, 0.03454130f, 0.08362730f, -0.32848144f, 0.26293755f, -0.22684371f, 
    -0.00719802f, -0.21937655f, -0.07131897f, -0.11064178f, 0.06413791f, -0.05483561f, 0.02498885f, -0.01513050f, 
    -0.17017464f, 0.14532971f, 0.12184364f, 0.28955099f, -0.02484299f, -0.07532287f, -0.12593801f, -0.00668823f, 
    0.01548919f, -0.09812940f, -0.23356523f, -0.05444575f, 0.01714808f, 0.20456639f, 0.09905043f, -0.00963274f, 
    -0.01452575f, -0.01477891f, 0.08122298f, 0.14958514f, 0.08235630f, 0.16929625f, -0.03212509f, 0.13639593f, 
    0.09603436f, -0.02185035f, 0.35504004f, 0.38722932f, -0.10500719f, -0.16273189f, -0.17809850f, -0.21942259f, 
    0.06680965f, 0.10830910f, 0.06463170f, 0.09334911f, 0.03860018f, 0.11570773f, -0.44872198f, 0.19806384f, 
    0.07460935f, 0.10860680f, 0.23502472f, 0.02856375f, 0.02440299f, 0.04558299f, -0.08823452f, -0.08373673f, 
    -0.02650486f, -0.24086545f, 0.12517303f, -0.17957346f, 0.06610656f, 0.06061076f, 0.07862034f, 0.00352207f, 
    0.09167787f, -0.04851558f, -0.24249779f, -0.17776908f, -0.10558745f, -0.25791693f, -0.16396110f, 0.04814802f, 
    0.29673854f, 0.10045647f, -0.00982036f, 0.03466749f, 0.14774337f, -0.01881808f, 0.14975697f, 0.07403918f, 
    -0.31538555f, -0.34179384f, -0.32885453f, 0.10146693f, -0.01411341f, 0.20517494f, 0.09905767f, -0.10734583f, 
    -0.07787655f, -0.13873895f, -0.03162013f, -0.15836872f, -0.07721750f, -0.13552883f, -0.19736111f, 0.07713926f, 
    0.12279635f, 0.06048531f, 0.06848872f, 0.06894287f, 0.29167998f, 0.04537191f, 0.24937122f, 0.16188410f, 
    -0.21559411f, 0.13247159f, 0.14721391f, -0.18074916f, 0.06202585f, 0.03088146f, -0.15320373f, 0.22900310f, 
    0.21151829f, 0.12027220f, -0.07529611f, 0.10408434f, 0.09396999f, 0.00233177f, 0.41733921f, -0.01047280f, 
    0.07573544f, 0.14009923f, 0.01197848f, 0.11957610f, 0.01969402f, -0.19572851f, -0.06692661f, -0.18073863f, 
    0.19531113f, 0.11170349f, 0.17288773f, -0.32778421f, -0.08105684f, 0.10841941f, 0.01975236f, -0.07852922f, 
    0.08471210f, 0.00768294f, 0.06875404f, 0.01666684f, -0.42025688f, -0.05708117f, -0.23968834f, 0.22373059f, 
    0.04323161f, 0.13855219f, -0.05819424f, 0.03761987f, 0.11132310f, -0.09873090f, 0.14574690f, 0.07945106f, 
    0.20958671f, 0.38718906f, 0.09439645f, 0.06609047f, 0.07454532f, 0.11543952f, 0.25782934f, 0.10858375f, 
    0.01234735f, -0.05767057f, -0.02197340f, 0.01876791f, -0.12469486f, 0.15013801f, 0.12937769f, 0.09492785f, 
    0.25273705f, -0.07867627f, 0.02241302f, 0.16329244f, 0.10435952f, -0.20277368f, -0.05137110f, 0.05464231f, 
    0.10971715f, 0.24265110f, 0.09789901f, 0.01803685f, 0.08653613f, 0.11428426f, 0.11741866f, 0.11932559f, 
    -0.06080014f, -0.02315797f, -0.03299792f, 0.03341495f, -0.17262204f, 0.22033004f, 0.27344823f, 0.30305913f, 
    -0.01828294f, 0.07630320f, 0.05705022f, -0.02048425f, 0.17169586f, -0.04524354f, -0.06910650f, 0.12769572f, 
    0.26491922f, -0.21631080f, 0.23380581f, -0.42554620f, -0.04178596f, 0.10034757f, -0.13073187f, -0.22065301f, 
    0.02524948f, 0.10332430f, 0.10664112f, -0.02741545f, 0.13635366f, 0.34932855f, 0.24368891f, -0.08965556f, 
    -0.00006619f, 0.05200019f, 0.14707659f, 0.05436298f, -0.02344749f, -0.10293594f, -0.11295221f, -0.02249044f, 
    0.08211839f, 0.06790607f, 0.15385455f, 0.05002337f, 0.12727693f, 0.00048080f, 0.08324718f, 0.11865713f, 
    0.06820185f, -0.02911800f, -0.00396980f, 0.15740561f, 0.22583532f, 0.04803530f, 0.32418761f, 0.29189593f, 
    -0.06972662f, -0.10144425f, -0.06947610f, -0.13930455f, 0.10710245f, 0.00898251f, -0.02986906f, 0.12860036f, 
    -0.06227040f, 0.02727148f, 0.11096762f, -0.39441547f, -0.06515117f, -0.11841410f, -0.06658217f, 0.05291900f, 
    0.17386121f, 0.11261485f, 0.12006872f, 0.02002892f, 0.02528759f, 0.12720074f, 0.30950132f, 0.19246589f, 
    0.06744957f, 0.00217353f, 0.02989376f, 0.18622003f, 0.09183992f, 0.02741757f, 0.09575361f, 0.17104080f, 
    0.21391101f, 0.17247397f, 0.03966063f, -0.21663593f, 0.03960255f, -0.00881936f, 0.05055794f, 0.01659807f, 
    0.06527068f, 0.10039766f, 0.06429725f, -0.02034819f, -0.00770780f, 0.35160726f, 0.09918924f, 0.20694391f, 
    0.18841994f, 0.07573254f, 0.12062443f, 0.13705039f, 0.03202486f, -0.12004826f, 0.01783011f, 0.14313750f, 
    -0.19923280f, -0.03865063f, 0.21397395f, 0.14149207f, -0.03342539f, -0.03671321f, -0.02535971f, -0.07953320f, 
    0.15976903f, 0.08733753f, -0.01695887f, 0.21478517f, 0.19911689f, 0.20705175f, 0.38296020f, 0.23143840f, 
    -0.06306656f, 0.08143889f, -0.03856692f, 0.04814707f, 0.11724754f, 0.10865761f, 0.03154265f, 0.15716314f, 
    0.14757675f, 0.25400808f, 0.16890267f, 0.17861259f, 0.09571729f, 0.01605823f, -0.05182377f, 0.05671261f, 
    -0.16307846f, 0.06137008f, 0.14047383f, 0.02811827f, -0.01302424f, -0.22955987f, -0.38581803f, 0.10250450f, 
    -0.02079370f, 0.01779615f, 0.05798819f, -0.05753154f, 0.06599006f, 0.07400554f, -0.03458020f, 0.03703711f, 
    -0.03103706f, 0.37289631f, -0.51124233f, 0.21238250f, -0.00325205f, 0.07067817f, 0.14932126f, 0.05184481f, 
    -0.11390243f, -0.00367916f, -0.05544632f, -0.03404328f, -0.06356397f, -0.21438354f, -0.08242386f, -0.29384628f, 
    -0.07222038f, -0.01573619f, -0.01712634f, -0.08048481f, 0.16508751f, -0.12660190f, -0.01115752f, 0.00028731f, 
    0.05544433f, 0.00705091f, -0.09427183f, 0.03280456f, 0.09026799f, 0.07686104f, -0.10276432f, -0.13039565f, 
    0.06886867f, -0.18255146f, -0.00715959f, 0.08779736f, -0.12454252f, -0.21550469f, -0.04848150f, -0.04218710f, 
    0.13396989f, 0.15110393f, -0.05165533f, 0.23845869f, 0.00909023f, -0.06532732f, -0.20283051f, -0.20031770f, 
    0.17834163f, 0.02460407f, 0.17764249f, 0.00735339f, 0.12065344f, 0.04917914f, 0.08939497f, 0.13375224f, 
    0.00516364f, -0.02876505f, -0.08664978f, 0.01701782f, -0.05471599f, -0.07067219f, 0.22855914f, 0.33847833f, 
    0.12224377f, -0.08003165f, -0.08949506f, -0.03456639f, 0.07057689f, -0.00211670f, 0.08226189f, -0.06885353f, 
    -0.19272146f, 0.00470857f, 0.12869599f, 0.09804140f, 0.06580371f, -0.11068972f, 0.07366578f, 0.13826466f, 
    0.07868195f, -0.02142578f, 0.06742247f, 0.06237242f, 0.00192862f, -0.07056223f, 0.17373519f, 0.20427339f, 
    0.01276401f, -0.03604608f, 0.00880970f, -0.07075286f, 0.21369167f, 0.03977605f, 0.04417868f, 0.14911494f, 
    0.30256352f, 0.47132415f, 0.22284316f, 0.00370552f, -0.05998039f, -0.03671439f, -0.00406993f, 0.00999034f, 
    0.11659099f, -0.14420038f, 0.05523934f, 0.00338871f, 0.14404343f, -0.06239823f, 0.17570791f, -0.38372251f, 
    0.21146256f, -0.05379636f, 0.06128213f, -0.02408619f, 0.08771230f, -0.05122498f, 0.01889396f, -0.06502322f, 
    0.15117566f, -0.15980519f, -0.01978749f, -0.00808957f, 0.07586092f, 0.08028379f, -0.02229082f, -0.07856329f, 
    0.00638573f, -0.16347006f, 0.02700891f, 0.06472632f, 0.05586529f, -0.13683186f, -0.07007368f, 0.12511562f, 
    0.07002212f, -0.04011531f, 0.05845749f, -0.06116655f, 0.01166680f, 0.03909543f, -0.09172174f, -0.01221929f, 
    0.15136522f, -0.28258348f, 0.09630886f, -0.20636261f, 0.02632423f, -0.10046735f, -0.03158372f, 0.06770527f, 
    0.15707642f, -0.10727989f, 0.13575016f, -0.07807241f, -0.02466219f, -0.03509566f, -0.20663124f, 0.01242337f, 
    0.07595502f, -0.03970620f, 0.14367296f, -0.09525853f, 0.13682044f, 0.11805206f, 0.18650216f, 0.02333047f, 
    0.30011216f, 0.29983246f, 0.26547953f, 0.21316591f, -0.14679481f, 0.05394752f, 0.05336085f, 0.05336013f, 
    -0.06474929f, 0.03368611f, -0.06471245f, 0.05080219f, -0.01167127f, -0.17374831f, 0.10583572f, -0.09085240f, 
    0.09105241f, 0.08610221f, -0.06451178f, -0.10368981f, -0.14103264f, -0.18143117f, -0.19384786f, -0.15885942f, 
    -0.20529914f, 0.02532421f, -0.15501580f, 0.13563956f, -0.02019943f, 0.07062717f, -0.09039709f, -0.12105193f, 
    -0.02782185f, -0.04358599f, -0.15285529f, -0.06942406f, 0.22221427f, 0.09115292f, 0.10966963f, -0.24549966f, 
    0.02540162f, -0.10425552f, -0.12576345f, -0.09920317f, 0.04707415f, 0.03207492f, -0.02044796f, 0.06630211f, 
    -0.11688223f, -0.39272815f, -0.18627582f, 0.21109959f, 0.07189376f, -0.08816075f, -0.01487025f, -0.08193205f, 
    -0.00539351f, -0.09479346f, 0.06632111f, -0.04170464f, 0.07806116f, -0.23462351f, -0.14889404f, 0.13716759f, 
    0.01318940f, 0.06897770f, 0.04335640f, -0.02163062f, 0.20466775f, -0.03234779f, 0.10801846f, 0.07419993f, 
    0.02559522f, -0.21356313f, -0.16710679f, 0.09549942f, 0.14704405f, 0.10769961f, -0.00820536f, -0.11655939f, 
    0.03636417f, -0.00687850f, 0.17436688f, 0.12701051f, 0.01934171f, 0.56072217f, -0.33420283f, 0.02930313f, 
    -0.06377631f, 0.12143055f, 0.21362780f, -0.14396189f, -0.06316969f, -0.20814143f, -0.01887690f, -0.17284876f, 
    0.04114909f, -0.02915289f, 0.00334811f, 0.01114283f, -0.02119676f, 0.01324145f, 0.02094349f, 0.01120712f, 
    0.00732153f, 0.03051549f, -0.00064180f, 0.01768695f, 0.01690956f, -0.00716840f, 0.02565763f, 0.01966774f, 
    0.02570989f, -0.00598109f, -0.02962654f, 0.01587540f, -0.01037845f, 0.00375190f, 0.02977538f, -0.04215753f, 
    -0.01219454f, -0.03013754f, -0.03473778f, 0.01236805f, 0.02645009f, 0.00051336f, 0.02593170f, 0.00691994f, 
    -0.03581198f, -0.00799941f, 0.02947799f, -0.02586945f, -0.03442281f, -0.00395173f, 0.02838949f, -0.04247952f, 
    -0.00542419f, 0.00406794f, -0.01849958f, -0.00917113f, 0.00006576f, -0.01699051f, -0.04412661f, -0.01190919f, 
    -0.02939658f, 0.01578653f, 0.01669201f, 0.01151474f, 0.00444380f, 0.02694568f, -0.01352886f, -0.00600630f, 
    -0.00126523f, 0.02708457f, -0.02786282f, -0.01666154f, 0.03034840f, 0.01458565f, -0.00819812f, -0.00196527f, 
    -0.00505917f, -0.03367542f, 0.01743030f, -0.01433642f, 0.00895372f, 0.02247562f, 0.02888717f, -0.00836964f, 
    -0.00504339f, 0.00414378f, 0.00295816f, -0.03936200f, 0.01872618f, -0.01777402f, 0.02834240f, 0.02512496f, 
    -0.03735990f, -0.01642922f, -0.02748209f, 0.00542831f, -0.02948538f, 0.03179819f, -0.00512436f, 0.01754356f, 
    -0.00507027f, -0.00543650f, -0.01529362f, 0.01053339f, -0.02969509f, -0.03052827f, -0.02971313f, 0.02092168f, 
    -0.03810449f, 0.03037333f, -0.00792347f, -0.01356533f, 0.00552237f, -0.03273991f, -0.03763841f, -0.03394676f, 
    -0.02013309f, 0.01907128f, 0.02107012f, 0.00935073f, -0.00074282f, -0.02867146f, -0.01129280f, 0.01961539f, 
    -0.00066000f, -0.01412890f, 0.00308127f, -0.01627729f, 0.00556748f, 0.01790836f, -0.02680243f, -0.03079771f, 
    -0.03552650f, 0.02221149f, -0.04185902f, -0.02003892f, 0.00251068f, 0.02369775f, 0.01886091f, 0.02119686f, 
    -0.03214510f, -0.01762829f, 0.02858706f, -0.03567028f, 0.02318986f, 0.01099023f, -0.03110782f, -0.01975237f, 
    -0.03844852f, 0.01262358f, 0.01626546f, -0.00139388f, 0.00230868f, 0.00489061f, 0.01366786f, -0.03022700f, 
    0.01277644f, -0.01123518f, 0.00850696f, 0.01301891f, -0.01455984f, 0.01358589f, 0.00234553f, -0.03873404f, 
    -0.03856846f, -0.01380224f, -0.02466578f, -0.00933984f, 0.02213523f, -0.00540669f, -0.01147153f, -0.03646537f, 
    -0.02932283f, 0.02157091f, -0.02270476f, -0.03110038f, -0.03129607f, -0.00300985f, -0.02028069f, -0.00816920f, 
    -0.03982553f, -0.00820184f, 0.00003512f, 0.00894689f, -0.02789977f, 0.00071491f, 0.00262051f, -0.03772293f, 
    -0.00460371f, -0.01608492f, 0.02657130f, -0.01555389f, -0.00438412f, -0.02342426f, 0.00745817f, -0.00511927f, 
    -0.01277248f, -0.03288049f, -0.02570996f, 0.00811507f, 0.03036533f, 0.00379061f, -0.00666401f, 0.01081084f, 
    -0.00367004f, -0.02185588f, 0.01677593f, -0.00177121f, -0.03709684f, 0.02863762f, -0.01201432f, -0.00459550f, 
    0.00188167f, 0.00233809f, -0.00561822f, 0.00751765f, -0.03543032f, -0.03400174f, 0.00642079f, -0.03099747f, 
    0.01576644f, 0.01138817f, 0.02170285f, 0.01395053f, -0.01013735f, 0.00257954f, -0.01854247f, 0.01156932f, 
    0.01095563f, 0.00012067f, 0.00807114f, 0.00921605f, 0.00750896f, 0.01591943f, -0.00300229f, 0.01763770f, 
    -0.03004877f, -0.04340399f, 0.01283562f, -0.01969593f, -0.04418902f, -0.04104755f, -0.00594981f, -0.02162245f, 
    -0.03667630f, -0.02805037f, -0.01902078f, 0.01555162f, 0.01517314f, 0.02361235f, -0.02154815f, 0.02737929f, 
    -0.02866871f, -0.01604450f, 0.00727822f, -0.04291546f, 0.01012079f, -0.00624715f, -0.02273836f, 0.00694827f, 
    -0.02682822f, -0.01954082f, -0.02428582f, 0.02701893f, -0.00948847f, 0.01829220f, -0.04267568f, 0.01980776f, 
    -0.02295719f, -0.02227167f, 0.01356326f, -0.00907245f, 0.00781137f, 0.02927098f, 0.02530809f, -0.00160268f, 
    -0.02703058f, 0.02902786f, 0.02475596f, -0.01296007f, -0.03133882f, -0.01301777f, -0.01848462f, -0.01832621f, 
    0.02028364f, 0.02053164f, 0.00291502f, -0.02821695f, -0.00284126f, 0.03310730f, 0.01728564f, -0.02593834f, 
    -0.02767362f, 0.01895499f, -0.01722744f, -0.00917239f, -0.02964758f, -0.00345367f, 0.01233234f, -0.01041957f, 
    -0.00386926f, 0.00241856f, -0.00803969f, 0.01827261f, -0.00757762f, 0.02547975f, -0.01780510f, 0.02777288f, 
    -0.03468769f, -0.01803585f, 0.00744357f, 0.00468552f, 0.02489566f, -0.02723313f, -0.02611177f, -0.00357068f, 
    0.02162625f, 0.00012718f, -0.02606392f, -0.01038457f, -0.03552688f, 0.00986153f, -0.04098970f, -0.02030144f, 
    0.02405598f, 0.02904781f, -0.01920063f, 0.00491833f, -0.01294863f, 0.02410244f, 0.00207446f, 0.01153463f, 
    0.02680429f, -0.03366582f, -0.01710998f, 0.00642380f, 0.02834495f, 0.03644320f, -0.01068755f, -0.00900924f, 
    -0.00629663f, 0.02325342f, -0.01227467f, -0.00370202f, 0.00637462f, 0.03016553f, 0.01760682f, -0.02661357f, 
    -0.01732462f, 0.01032653f, 0.01892928f, -0.03718533f, -0.03556776f, 0.02470449f, 0.02810970f, -0.00799072f, 
    -0.00397088f, -0.02922852f, 0.00709425f, -0.02149953f, 0.01547787f, 0.02861439f, 0.00842967f, -0.01242324f, 
    -0.03769467f, -0.03315710f, -0.01730032f, 0.00594901f, -0.00802027f, -0.03376308f, -0.01671900f, -0.02980853f, 
    -0.03134852f, -0.03595623f, -0.04457765f, 0.01997745f, 0.02778331f, -0.03127807f, 0.00949414f, -0.00825842f, 
    -0.03805630f, -0.00606150f, -0.03631618f, -0.04051794f, -0.00549264f, -0.00086125f, -0.02471263f, 0.03220253f, 
    -0.02805707f, 0.00545515f, -0.02252514f, -0.03290562f, 0.00431232f, 0.00992583f, 0.00136500f, -0.03142814f, 
    0.03307612f, 0.01601164f, -0.03677304f, -0.02477286f, 0.02059204f, 0.02025146f, 0.01077351f, -0.03303038f, 
    0.02489800f, -0.02948981f, 0.00417198f, -0.01525496f, -0.02727626f, 0.00600262f, -0.02843053f, -0.03284138f, 
    0.01481063f, 0.01741443f, 0.02964420f, -0.01986221f, 0.02402232f, 0.02539808f, 0.02387794f, 0.02722535f, 
    0.00255116f, 0.00492830f, 0.01148639f, 0.00026029f, 0.01899851f, -0.01724876f, 0.01088391f, -0.01503683f, 
    -0.02686527f, -0.01436330f, 0.01228398f, -0.02425182f, 0.00884060f, -0.01852121f, -0.00091680f, 0.01462903f, 
    -0.01759405f, -0.02677213f, -0.01703416f, 0.02512554f, -0.00653625f, 0.02890981f, 0.02577307f, -0.00812002f, 
    0.00118289f, 0.01892586f, -0.02905143f, 0.00885067f, -0.02542019f, -0.00534122f, 0.01981350f, 0.01954581f, 
    -0.01194287f, 0.00380134f, -0.00209038f, -0.01912824f, 0.03034792f, 0.00059890f, -0.00843514f, 0.01264167f, 
    0.00645184f, 0.00737116f, -0.03839710f, 0.01547325f, -0.02635201f, -0.02744370f, -0.04057947f, -0.01773962f, 
    -0.02172999f, -0.02618380f, -0.01522124f, 0.00565324f, 0.00027014f, 0.00732870f, -0.01815554f, 0.01269022f, 
    -0.03302517f, 0.02010787f, -0.03651824f, 0.01709735f, 0.03244726f, 0.01082123f, 0.02486454f, -0.02572359f, 
    0.02747111f, -0.02167885f, 0.00255447f, 0.02820016f, 0.02041390f, -0.01969689f, 0.02707306f, -0.03191382f, 
    0.02428292f, 0.02082562f, 0.00787572f, 0.00062704f, -0.01845574f, -0.02541027f, 0.01057901f, -0.00970195f, 
    -0.00468749f, -0.02267851f, -0.02040065f, -0.02625942f, -0.03205832f, -0.01839632f, 0.02329105f, 0.01845401f, 
    0.00197314f, -0.00368159f, -0.03652183f, 0.02064196f, 0.02126822f, -0.03274059f, -0.02511138f, -0.02395322f, 
    -0.02963319f, -0.01578142f, -0.00076976f, -0.00887987f, 0.02326191f, -0.03238056f, 0.00626529f, -0.02766224f, 
    0.00319493f, -0.02763655f, -0.00012519f, 0.00319292f, -0.04083659f, -0.01578964f, -0.02900330f, -0.02593686f, 
    -0.03649449f, -0.04476769f, -0.01062612f, 0.01094595f, -0.00611447f, -0.02086872f, -0.03885140f, 0.00966055f, 
    0.02628192f, 0.02238474f, -0.00478197f, -0.01617532f, 0.02566041f, 0.02602911f, 0.00385681f, 0.01577015f, 
    -0.01192977f, -0.01818191f, 0.03060107f, -0.02479100f, -0.00281325f, 0.01393887f, -0.00908806f, -0.02131504f, 
    -0.02502298f, -0.00933843f, -0.02429777f, -0.01413099f, 0.01637858f, -0.00079947f, -0.00602904f, 0.00820316f, 
    -0.00841071f, -0.01432040f, -0.03331885f, 0.02872009f, -0.01485610f, 0.02439079f, 0.03017193f, -0.03169129f, 
    0.01638171f, 0.02725570f, 0.01293407f, 0.02710024f, 0.01361446f, -0.00667638f, 0.00631519f, 0.02429318f, 
    -0.02655271f, -0.01844559f, -0.01149059f, -0.03685172f, 0.00143660f, -0.04026574f, 0.01500572f, 0.00437271f, 
    0.02108322f, 0.03645257f, -0.00900469f, -0.01559915f, 0.02126956f, 0.01909080f, 0.00051088f, -0.03975922f, 
    0.00875615f, -0.02192555f, -0.01848317f, 0.02790598f, -0.01061989f, 0.00404160f, -0.03297166f, 0.02352677f, 
    -0.00966244f, -0.02797091f, -0.00491627f, -0.04158529f, -0.02972349f, -0.00856637f, -0.02078380f, -0.00692800f, 
    -0.00962266f, -0.00512856f, -0.02120548f, 0.00408552f, 0.00446027f, 0.00375583f, 0.02683808f, -0.01924804f, 
    0.01403400f, 0.01700237f, 0.01859677f, -0.02369782f, -0.02096585f, -0.02595283f, 0.00313570f, -0.02744605f, 
    -0.00055258f, -0.02409632f, -0.01971896f, -0.00746353f, 0.01222401f, -0.02589629f, -0.00820571f, -0.01995308f, 
    -0.03556822f, -0.01744840f, 0.01687900f, -0.02534638f, -0.00825785f, -0.02492457f, -0.03592557f, 0.01707848f, 
    -0.00838739f, -0.02489957f, -0.04074164f, -0.01616789f, -0.00858285f, -0.02452718f, 0.01970643f, 0.02096913f, 
    -0.04207621f, 0.01470955f, 0.02285145f, 0.00863507f, -0.03752837f, -0.03187702f, 0.02819096f, -0.03349839f, 
    0.00364377f, -0.01139622f, -0.02136475f, -0.04456445f, -0.00904591f, -0.02146756f, 0.02081994f, -0.03956348f, 
    -0.00454143f, 0.00226383f, 0.01891175f, -0.00424518f, -0.04130477f, 0.02363356f, -0.02616458f, -0.03387747f, 
    -0.03745895f, -0.01182205f, 0.00408582f, 0.00367229f, 0.01343265f, 0.01358856f, 0.01094014f, 0.02534441f, 
    -0.00581149f, -0.02192286f, -0.02044498f, -0.02784130f, 0.01958382f, -0.00660436f, 0.02664861f, -0.01579500f, 
    -0.04071359f, -0.02034001f, -0.02541737f, -0.00221324f, 0.00529785f, -0.01423093f, 0.00441368f, 0.02214654f, 
    -0.04436931f, 0.01274748f, -0.03885723f, -0.00146585f, 0.01176284f, -0.00091969f, -0.00521342f, 0.01253342f, 
    0.00503550f, -0.03548103f, 0.00880915f, -0.03528883f, -0.03253639f, -0.00128230f, 0.00629188f, 0.02565409f, 
    -0.01482312f, -0.03941510f, 0.00308600f, -0.01383519f, 0.01283102f, 0.01048502f, -0.03305543f, -0.01667732f, 
    0.02197413f, -0.00787618f, -0.02283351f, -0.03933176f, -0.01636503f, 0.01449977f, 0.02733057f, 0.00827150f, 
    -0.02248430f, -0.02511031f, 0.01855351f, -0.01130828f, -0.01792604f, -0.01367298f, -0.03313550f, 0.00402157f, 
    -0.02966066f, 0.00809067f, -0.03303751f, -0.03443161f, -0.00300458f, -0.01074256f, -0.02701217f, -0.01708902f, 
    -0.02083062f, -0.01152423f, -0.03468161f, -0.02702626f, -0.03459505f, -0.01206078f, -0.02662161f, -0.03551921f, 
    -0.01153068f, 0.01033497f, 0.01231106f, 0.02091756f, -0.02268793f, -0.00921009f, 0.01215132f, -0.03880753f, 
    -0.00758408f, -0.02841437f, -0.02746384f, 0.02653336f, -0.03116804f, 0.01508581f, 0.00711103f, -0.02611013f, 
    0.02017023f, -0.00533077f, 0.02367801f, 0.00094624f, 0.00979258f, 0.00897825f, -0.00694956f, 0.03129962f, 
    -0.26708707f, -0.17627922f, -0.11790601f, -0.32368547f, -0.20333827f, 0.03366604f, -0.02483337f, -0.18551137f, 
    0.19921426f, 0.14311169f, 0.05019158f, 0.03046389f, 0.07967315f, -0.17809747f, 0.33457512f, -0.12264903f, 
    0.17927761f, 0.03693341f, 0.02277353f, 0.15487871f, 0.06684234f, 0.02973437f, -0.11889501f, 0.20043051f, 
    0.15032224f, -0.02201061f, -0.19705698f, -0.10270783f, 0.01204860f, 0.09072425f, 0.28066805f, 0.01088314f, 
    -0.03145205f, -0.08758911f, -0.05049913f, 0.03040944f, -0.01225005f, -0.02345312f, 0.02252145f, -0.06416430f, 
    -0.12357257f, -0.05031415f, -0.05719960f, -0.03563798f, 0.09162093f, 0.00153162f, -0.08747166f, -0.00134366f, 
    0.43342867f, 0.06121511f, 0.20275874f, -0.03769443f, -0.03209613f, -0.03086579f, 0.02071970f, 0.00267975f, 
    0.14906327f, 0.24272044f, -0.01948773f, 0.35375953f, -0.27742362f, -0.31702518f, -0.13975577f, -0.18582214f, 
    -0.11253167f, 0.05546866f, 0.05259806f, -0.53697962f, 0.07605808f, -0.03782113f, 0.05945228f, 0.00110158f, 
    0.07026673f, -0.14618063f, -0.22518167f, 0.13476875f, 0.07786129f, 0.18057355f, 0.06559386f, 0.13524297f, 
    -0.01954363f, 0.02365481f, -0.02306091f, 0.00637661f, -0.15094210f, -0.22160962f, -0.18379186f, -0.12766021f, 
    0.02726058f, -0.00198033f, 0.00838620f, -0.04559581f, -0.06637859f, -0.01817665f, -0.03359367f, 0.00638834f, 
    -0.09416106f, -0.12798119f, 0.02921930f, -0.05173808f, 0.27577525f, -0.03791068f, 0.28699923f, 0.08315399f, 
    0.03754069f, 0.16757190f, -0.06684362f, 0.13939568f, -0.52086157f, -0.02390001f, 0.08832754f, 0.11456513f, 
    -0.16954723f, -0.05764692f, 0.19436641f, -0.17768729f, 0.17868672f, 0.06164098f, -0.15718207f, -0.02924717f, 
    -0.12405305f, 0.03864084f, -0.12222306f, 0.11567803f, 0.18347856f, 0.15985350f, 0.24124953f, 0.25525182f, 
    0.16978785f, 0.22498380f, 0.12924781f, 0.01257015f, -0.34734619f, 0.04524015f, 0.21581389f, 0.15278611f, 
    0.17770550f, 0.13625188f, -0.14261547f, 0.21526518f, 0.19219099f, 0.05024919f, 0.10615432f, 0.02618234f, 
    -0.17639500f, -0.26891771f, 0.08297051f, -0.24882621f, 0.01578688f, 0.04178992f, 0.07647470f, -0.17631155f, 
    0.16198118f, -0.01551212f, -0.07687946f, 0.06269498f, 0.50650287f, 0.29510230f, 0.07959250f, 0.08318753f, 
    0.00936006f, 0.11076640f, -0.01764373f, 0.00336624f, 0.34009966f, -0.06393282f, -0.10261898f, 0.26640049f, 
    0.04745924f, -0.13972981f, 0.06041933f, 0.02272161f, 0.31345469f, -0.17743707f, -0.06285372f, 0.08317510f, 
    0.20339637f, 0.07513665f, 0.19563538f, 0.14780124f, -0.18918788f, -0.23508100f, -0.02133687f, 0.12055375f, 
    0.05454516f, 0.03354758f, -0.10703151f, -0.17081040f, 0.05148641f, 0.03230307f, 0.05881197f, -0.03388374f, 
    -0.46593896f, -0.11670139f, 0.16739219f, 0.25976619f, -0.11493896f, -0.06657445f, -0.04727332f, -0.05070153f, 
    0.15184708f, -0.00915532f, 0.09137007f, 0.20760871f, 0.22293615f, -0.06878339f, 0.30493796f, -0.20392598f, 
    0.10893583f, 0.24440886f, -0.13489527f, 0.12436944f, 0.02484711f, -0.08194026f, 0.09136762f, 0.13676468f, 
    -0.20069687f, -0.17221899f, -0.12952960f, 0.06819923f, 0.19836576f, 0.39693803f, 0.13309301f, 0.32163081f, 
    0.02150158f, -0.04397427f, -0.00548054f, 0.08116742f, -0.00547814f, -0.05331570f, 0.04489898f, 0.05293722f, 
    -0.10437617f, -0.08177118f, -0.08859946f, -0.06094131f, -0.04191200f, -0.08202194f, -0.04989326f, -0.07150346f, 
    0.03488261f, 0.08339746f, 0.14891568f, 0.00176605f, 0.04171851f, -0.04835287f, 0.08434667f, 0.02145324f, 
    -0.01139497f, 0.00481458f, -0.05375481f, -0.00949824f, 0.19780216f, 0.01712680f, 0.09578945f, -0.08728200f, 
    -0.00952827f, -0.03353994f, -0.05712946f, -0.01272857f, 0.10811268f, 0.15264262f, -0.04482697f, 0.00053410f, 
    -0.10792406f, -0.13988191f, 0.45008206f, 0.04803785f, -0.15888228f, -0.01204393f, -0.00001837f, -0.12307602f, 
    0.07018074f, 0.06308139f, -0.00498748f, -0.07346617f, -0.28902408f, -0.41121587f, 0.03874316f, 0.15046683f, 
    0.04080356f, -0.03293363f, 0.22700474f, 0.29537857f, 0.03379581f, -0.11257433f, 0.07457279f, 0.03441641f, 
    -0.00123052f, 0.33960217f, 0.19638374f, 0.14204158f, 0.05064546f, 0.01374845f, 0.20074153f, 0.28114510f, 
    0.05111490f, -0.07107582f, 0.05787503f, -0.08305487f, 0.03452111f, 0.07249921f, -0.00283796f, -0.10840964f, 
    0.05485513f, 0.00194582f, 0.03780264f, -0.01141388f, -0.10112872f, 0.00274959f, 0.06973562f, -0.04032933f, 
    -0.45507684f, 0.03099591f, 0.02225342f, -0.10974643f, -0.00950256f, -0.02238605f, -0.14476645f, -0.25487202f, 
    -0.07436855f, 0.02545008f, -0.08930220f, 0.09087336f, -0.20271279f, 0.05368464f, 0.28510928f, -0.00056438f, 
    -0.07321493f, -0.12241364f, -0.16078247f, -0.06340476f, 0.11795320f, 0.04214114f, 0.01815071f, -0.23691563f, 
    -0.30845031f, -0.17783827f, -0.01798132f, -0.19650736f, 0.06616108f, 0.02057275f, -0.06196051f, -0.21136124f, 
    -0.02038933f, 0.02733113f, -0.02512347f, -0.01257295f, -0.19282478f, -0.31132790f, -0.10365531f, -0.12955673f, 
    0.21602841f, -0.01002801f, 0.10431080f, 0.25739697f, 0.03083627f, 0.12094402f, 0.01740007f, -0.07382780f, 
    -0.00964728f, 0.22823761f, 0.02069454f, -0.02591169f, -0.01674761f, -0.09876372f, -0.03153894f, -0.03808775f, 
    0.36511207f, 0.16184376f, 0.04393264f, 0.10939195f, -0.22276118f, -0.20775959f, 0.23391348f, -0.15581243f, 
    0.00046380f, 0.07601006f, -0.03152641f, -0.12069859f, 0.05853660f, -0.04558763f, 0.02990185f, -0.07044176f, 
    -0.17521144f, -0.13012917f, 0.22641063f, -0.32087138f, 0.13766369f, 0.15005428f, 0.14259075f, 0.14666121f, 
    -0.00253820f, 0.12701215f, 0.00416939f, -0.03069043f, -0.48250866f, 0.25149772f, 0.29243129f, 0.11795451f, 
    -0.13582809f, -0.02918293f, -0.04379846f, -0.03221215f, -0.00399138f, 0.04343467f, 0.13530754f, 0.09645268f, 
    0.24926992f, 0.29262480f, -0.05977817f, -0.18016024f, -0.06214501f, 0.13000272f, 0.05792678f, 0.09746223f, 
    0.12067858f, 0.25707135f, 0.03072734f, 0.10514910f, -0.42804673f, -0.37853217f, -0.07145391f, -0.05531560f, 
    -0.16303365f, -0.01465865f, 0.03759969f, 0.03701329f, -0.02829831f, 0.02874948f, 0.00363744f, -0.07355350f, 
    0.17576802f, 0.06733003f, 0.27177331f, -0.12301803f, 0.02166503f, 0.01722738f, 0.09532128f, 0.23430820f, 
    0.27469817f, 0.01929664f, -0.04659579f, 0.09991814f, -0.12610438f, -0.02110946f, 0.04014679f, -0.09397379f, 
    0.06284505f, 0.09321997f, 0.04391522f, -0.08032652f, 0.04066861f, 0.06318977f, -0.00138225f, 0.06383377f, 
    -0.34273672f, -0.11318167f, -0.12462443f, 0.10625304f, 0.02976922f, -0.21607670f, -0.01062897f, 0.04627557f, 
    0.27714276f, -0.07717915f, -0.00890551f, -0.09684072f, -0.24364614f, -0.39935279f, -0.19117363f, 0.00429086f, 
    0.01550212f, 0.03613187f, 0.18663096f, 0.17654926f, 0.07134844f, 0.01710605f, -0.04987422f, -0.04676431f, 
    0.00598004f, 0.07502969f, -0.04707951f, 0.04062172f, 0.04842632f, 0.15001634f, 0.29530022f, -0.17396097f, 
    0.14083257f, -0.01257407f, 0.05665793f, 0.03620332f, 0.36589697f, 0.21495751f, 0.09216516f, 0.06123917f, 
    0.08237757f, -0.08720247f, 0.16452156f, 0.05351424f, 0.05093486f, 0.08995360f, -0.05116513f, 0.08187237f, 
    0.32261947f, -0.21879612f, 0.30063546f, -0.64063984f, 0.13080297f, 0.12660322f, 0.10397144f, 0.00730107f, 
    0.14359520f, -0.05525872f, 0.00379450f, 0.20180696f, 0.37442964f, 0.24290606f, -0.04455434f, 0.08754365f, 
    0.18454255f, -0.01781330f, 0.18483938f, 0.13616219f, 0.14257261f, 0.15757181f, -0.12320685f, 0.35905510f, 
    -0.59837246f, 0.12267314f, -0.19019015f, 0.28486159f, 0.14814311f, 0.01489731f, -0.14216334f, 0.03043519f, 
    -0.00912393f, -0.03167181f, -0.04295011f, 0.02116092f, 0.05016977f, -0.01933108f, -0.17509525f, -0.10332511f, 
    0.08053459f, -0.00042043f, 0.22866368f, -0.11794696f, -0.01027230f, -0.06038718f, 0.06377006f, 0.07888384f, 
    -0.15188937f, -0.08636085f, -0.00554117f, 0.12238692f, -0.04323417f, 0.03894862f, 0.06026939f, 0.08018018f, 
    0.06304593f, -0.02017821f, 0.09476148f, 0.00664188f, -0.23341069f, -0.35312542f, 0.00329932f, 0.19555424f, 
    0.07738397f, -0.07840391f, 0.01311982f, 0.03428463f, 0.00502001f, 0.01094019f, 0.07031316f, 0.12642382f, 
    -0.20686673f, 0.03718718f, 0.18827179f, 0.22253244f, 0.00929306f, 0.07178430f, -0.00476204f, -0.10806368f, 
    0.01626139f, 0.00258197f, 0.13248427f, -0.01472157f, -0.26379713f, 0.19767338f, 0.08369762f, 0.13876648f, 
    0.00495001f, 0.03348162f, 0.00104342f, 0.08983190f, -0.04143523f, 0.00296412f, 0.09295442f, 0.00184173f, 
    -0.10992676f, -0.04579516f, 0.22231963f, -0.36789227f, -0.04361797f, -0.04522749f, -0.02531368f, 0.11577485f, 
    0.19554199f, -0.05712811f, -0.26126119f, 0.09354863f, 0.13493918f, 0.17754647f, -0.07305495f, 0.09775806f, 
    -0.00257113f, 0.27987921f, 0.19997868f, 0.27094766f, 0.06743533f, -0.01960652f, 0.09850052f, 0.10479280f, 
    0.35656345f, 0.00850038f, 0.15392771f, 0.03351054f, 0.04058783f, 0.02313546f, 0.04760135f, 0.04757516f, 
    0.06683159f, 0.10925023f, -0.03699983f, -0.01631902f, 0.25027260f, 0.14204036f, 0.05643464f, 0.13802995f, 
    0.00446718f, -0.05529251f, -0.01619767f, -0.04969220f, 0.00762804f, 0.01859693f, 0.06671321f, 0.04113446f, 
    0.22414282f, 0.03895334f, -0.05291124f, -0.01628207f, -0.14979382f, -0.09025305f, -0.13901420f, -0.09218927f, 
    0.03152085f, -0.03002563f, 0.03999890f, 0.10445374f, 0.25338265f, 0.04279999f, 0.07850052f, -0.01200261f, 
    -0.03459992f, 0.01725090f, -0.03713914f, 0.04843229f, 0.07427588f, 0.15035307f, -0.01970645f, 0.04558996f, 
    -0.21556948f, -0.11275662f, -0.06099241f, -0.19588359f, 0.27288327f, -0.09551252f, 0.17314665f, -0.07508526f, 
    0.00197206f, 0.07549252f, 0.07468214f, 0.11873780f, -0.07861841f, -0.15854923f, -0.12308216f, -0.07365278f, 
    -0.04957180f, -0.20522027f, -0.07248183f, 0.03885522f, -0.01358633f, -0.02225401f, 0.00122797f, 0.05012213f, 
    -0.10291393f, -0.09426124f, 0.03120356f, 0.04471571f, 0.11738741f, 0.00848991f, 0.01902896f, 0.01985569f, 
    0.07196902f, -0.01058092f, 0.17880304f, 0.02420027f, -0.17783578f, 0.59394115f, 0.39156899f, -0.10892527f, 
    -0.20286995f, -0.09302837f, -0.03350912f, -0.20157309f, 0.05452598f, 0.04166419f, -0.01678708f, -0.03080950f, 
    0.26684788f, 0.18423690f, 0.15352698f, 0.27529645f, -0.02536455f, -0.02362838f, -0.05824937f, 0.05270972f, 
    0.01059555f, 0.09507158f, -0.00210877f, 0.01201390f, -0.02793393f, -0.00359394f, 0.08137926f, -0.00344939f, 
    -0.12165070f, -0.09231608f, -0.14519627f, -0.15114760f, -0.11642716f, -0.21965194f, -0.12166487f, -0.02081944f, 
    0.09078979f, -0.17760192f, -0.07169059f, 0.11603289f, 0.03375152f, 0.01753351f, -0.12757926f, -0.05017648f, 
    0.14529608f, 0.00446331f, 0.22571242f, -0.05061442f, 0.22431007f, -0.35479444f, 0.13774098f, -0.45338923f, 
    0.13742401f, 0.15035692f, -0.14115617f, 0.03470889f, 0.05904948f, 0.01940755f, -0.07662555f, 0.23167230f, 
    -0.02227974f, -0.01328618f, -0.02144479f, -0.02650841f, -0.00212945f, -0.00339008f, -0.01445446f, 0.00592443f, 
    0.00706706f, -0.00398951f, -0.01819742f, -0.02155709f, -0.00939364f, 0.02167436f, 0.02538881f, 0.02519759f, 
    -0.02451372f, 0.02722929f, 0.02608345f, -0.03890002f, 0.03848494f, 0.00457307f, 0.00483164f, -0.01049699f, 
    0.01415553f, -0.02041224f, 0.02006640f, -0.01101311f, -0.02537473f, -0.03008220f, -0.02507682f, -0.03276303f, 
    -0.00750131f, 0.01199337f, -0.03962797f, -0.00617521f, -0.01301145f, -0.03034115f, -0.01924370f, 0.00189271f, 
    -0.01826394f, -0.04382812f, -0.04139663f, -0.03095108f, -0.00314393f, 0.00057584f, 0.00122746f, -0.00510518f, 
    -0.03717929f, -0.03337914f, -0.00677698f, 0.02698386f, -0.02814338f, 0.01021424f, 0.02391046f, -0.02441141f, 
    -0.00277465f, 0.02389486f, 0.02619002f, 0.02460664f, -0.02311538f, -0.01070181f, -0.00015033f, -0.02516147f, 
    0.00069322f, 0.02630111f, -0.01999317f, -0.01095692f, -0.00424471f, 0.03002906f, -0.02882862f, -0.00358944f, 
    0.00794933f, 0.01408221f, 0.02713601f, 0.01103747f, -0.04002339f, -0.01119610f, -0.00949836f, -0.02207951f, 
    -0.01300694f, 0.02725761f, -0.01081580f, 0.00679052f, 0.01372378f, 0.00514865f, -0.02000129f, 0.01800633f, 
    -0.03310202f, 0.00887989f, -0.01275502f, 0.00150947f, -0.01945560f, -0.00118973f, 0.01841849f, -0.02421692f, 
    0.00131163f, -0.00612368f, 0.00966656f, -0.04431217f, -0.02228439f, -0.02813043f, -0.02835570f, -0.03981060f, 
    -0.03524369f, 0.02566931f, -0.01462698f, -0.00083179f, -0.02399153f, -0.03546416f, 0.02888127f, -0.00014355f, 
    -0.00239385f, 0.01262931f, -0.00600739f, -0.03404798f, -0.03147835f, 0.00854155f, -0.03287176f, 0.01045141f, 
    -0.04322785f, 0.00607069f, -0.02256510f, -0.04160057f, -0.01745175f, -0.02488079f, 0.01577526f, -0.02226160f, 
    0.02278856f, 0.01435469f, 0.00537046f, 0.01337325f, 0.00974769f, 0.00159762f, -0.00817342f, 0.03148060f, 
    0.01472123f, -0.00336587f, 0.00579064f, 0.00404440f, -0.02179523f, 0.02000477f, 0.02006357f, 0.00705855f, 
    -0.03649248f, 0.00434999f, 0.00598822f, -0.01357544f, 0.02174867f, -0.02400983f, -0.03429995f, 0.01036053f, 
    -0.02389298f, -0.02035251f, 0.02158621f, -0.04017258f, 0.01322402f, -0.02196139f, 0.00320091f, -0.01660253f, 
    0.00735863f, -0.02088727f, -0.02611102f, -0.01128883f, 0.01206099f, -0.00651383f, -0.02292019f, -0.00516441f, 
    -0.02509104f, -0.02504715f, -0.03333120f, -0.03003967f, 0.00822087f, -0.01291392f, 0.01469530f, -0.02223321f, 
    0.01102078f, -0.01697928f, -0.03689205f, 0.00786869f, -0.00447977f, 0.01554410f, -0.00019055f, 0.01791895f, 
    0.00509634f, -0.01950854f, -0.02048355f, 0.02266494f, -0.02355871f, -0.00598804f, -0.03020207f, -0.03364875f, 
    0.02629519f, -0.03543591f, 0.02514590f, 0.00105105f, 0.02058878f, 0.01534187f, -0.03052435f, 0.02662983f, 
    0.00445502f, -0.00313856f, 0.01590293f, -0.01996719f, 0.00924325f, 0.01010385f, -0.03285641f, -0.00447989f, 
    -0.01729747f, 0.00073923f, 0.00050891f, -0.01418796f, -0.03865637f, 0.00934250f, 0.01013708f, -0.03881071f, 
    0.00563915f, -0.04060074f, -0.02631276f, -0.00825461f, -0.02584759f, 0.01977893f, -0.03526114f, -0.01978058f, 
    0.00072183f, -0.00481695f, 0.02286489f, -0.04057940f, -0.02802738f, -0.03685238f, 0.01571083f, 0.00663873f, 
    0.02673174f, -0.00029334f, 0.01853847f, -0.03891230f, 0.00217817f, 0.02273717f, 0.00933829f, -0.01565612f, 
    -0.00588214f, -0.02347357f, -0.02481242f, -0.02716186f, -0.02397195f, -0.01532649f, 0.00718343f, 0.01420864f, 
    0.01914452f, -0.03298683f, -0.04311205f, 0.01977801f, 0.02104223f, -0.03146524f, 0.02748526f, 0.01913319f, 
    0.01329666f, 0.02681225f, -0.04460486f, -0.03997771f, -0.03629229f, -0.00344241f, -0.02594617f, -0.02983018f, 
    -0.03323413f, -0.02078810f, 0.00767809f, 0.02671812f, 0.01229262f, 0.02642706f, 0.02648748f, -0.00248984f, 
    0.00892103f, 0.01115453f, -0.00261685f, 0.02066242f, 0.00402160f, -0.02782510f, 0.01032209f, -0.00958031f, 
    -0.04147531f, 0.01585184f, 0.01743000f, 0.01911324f, -0.02953641f, 0.01179545f, 0.01320336f, -0.01678915f, 
    0.00040264f, -0.01703574f, 0.02661395f, -0.01468627f, -0.00584107f, -0.02528739f, -0.03494369f, -0.02626320f, 
    -0.04281539f, 0.00016357f, 0.02721428f, -0.00087184f, 0.00555456f, -0.01510770f, 0.00738076f, 0.02084276f, 
    0.00525692f, -0.01837723f, 0.02151778f, -0.00399194f, -0.02238767f, 0.02742135f, -0.00551604f, -0.02087085f, 
    0.01001696f, 0.03619906f, -0.03448556f, -0.03534547f, -0.01212446f, 0.01765394f, -0.01990935f, 0.00829174f, 
    0.01220877f, 0.00368566f, 0.02571476f, -0.00420233f, -0.03602123f, 0.00595318f, -0.02221676f, 0.03173276f, 
    0.00791485f, -0.01838623f, -0.01452191f, 0.00532711f, -0.00030720f, -0.03769632f, -0.00145920f, 0.02151679f, 
    -0.00419562f, 0.03535787f, 0.01388748f, 0.01768419f, 0.03031913f, -0.03036850f, -0.02147050f, -0.00435239f, 
    0.01981127f, 0.02158300f, -0.02919359f, 0.01908357f, -0.03369894f, 0.00102636f, -0.03280795f, -0.00901026f, 
    -0.02241330f, -0.02077613f, 0.00306766f, 0.02789918f, -0.00327798f, 0.00974358f, 0.01627047f, -0.00702170f, 
    -0.00956268f, -0.02736721f, -0.00427232f, 0.02445675f, -0.00094415f, -0.01037544f, -0.01439244f, -0.00322512f, 
    -0.01095769f, -0.01239164f, 0.01153476f, 0.01897850f, -0.03532921f, -0.02128250f, -0.00984821f, 0.00764774f, 
    0.00514558f, 0.00149820f, 0.00826264f, -0.03222668f, 0.02414979f, -0.01561904f, -0.00799580f, 0.01740530f, 
    0.01584768f, 0.04031501f, -0.00190133f, -0.00773782f, -0.02340780f, 0.00463305f, 0.02746672f, -0.02136659f, 
    -0.01060149f, -0.01914013f, -0.01511674f, 0.00529883f, 0.01575302f, 0.01243838f, -0.02182237f, 0.00014391f, 
    -0.00882039f, -0.02416171f, -0.00818733f, -0.01245544f, -0.02770088f, -0.00074674f, 0.00877194f, -0.00312688f, 
    -0.04352641f, 0.01661347f, -0.03684371f, -0.04283017f, 0.00154339f, -0.03536974f, -0.00339271f, 0.00741432f, 
    -0.03515221f, 0.00706263f, -0.03102676f, 0.00940796f, 0.01110341f, -0.01784512f, -0.03416224f, -0.03058524f, 
    -0.01654314f, -0.02407785f, -0.01289513f, -0.00577654f, -0.01526039f, -0.01703795f, 0.01243643f, -0.02935842f, 
    0.03294434f, 0.01715658f, 0.00630644f, -0.01387995f, 0.00491905f, 0.00892681f, -0.01784906f, -0.03790585f, 
    0.00729443f, 0.01969883f, -0.00213296f, -0.04003293f, 0.03222253f, 0.00627144f, 0.02376297f, -0.01434194f, 
    0.02858936f, 0.03308856f, 0.01191499f, -0.03578919f, -0.02864534f, 0.00227922f, -0.03465679f, -0.00779241f, 
    -0.00121595f, -0.02415078f, 0.02592684f, -0.02635077f, 0.01925632f, -0.03020150f, -0.00012666f, -0.00594876f, 
    -0.03874413f, 0.03156229f, 0.00441583f, -0.03160586f, -0.03255107f, 0.01640444f, 0.00173653f, 0.00590870f, 
    -0.02293147f, -0.00670028f, 0.01047174f, 0.01544763f, 0.00537528f, 0.02040142f, -0.02383039f, -0.02387762f, 
    -0.02887707f, 0.01236996f, 0.01304709f, 0.00129888f, -0.03072176f, -0.00096398f, -0.01819485f, 0.01821332f, 
    -0.03735171f, 0.00320485f, 0.02378337f, 0.02137761f, 0.01249490f, -0.00205906f, -0.04334490f, 0.02255509f, 
    -0.03839046f, -0.00737759f, -0.00525443f, -0.00911111f, -0.01005407f, 0.00710854f, -0.02767869f, 0.01615440f, 
    -0.03325241f, -0.04019303f, -0.01590363f, -0.00561906f, -0.01024153f, -0.02561958f, -0.03939634f, 0.00252912f, 
    0.02545157f, 0.01373205f, 0.00883624f, -0.02996996f, -0.01484663f, -0.01896412f, 0.00055659f, 0.00376699f, 
    -0.00854951f, 0.00340002f, -0.03394532f, 0.01459330f, -0.02128027f, -0.00905362f, -0.03821945f, -0.02354881f, 
    0.01692338f, -0.03353089f, -0.00176832f, -0.02435204f, 0.02219735f, -0.02602192f, -0.01700520f, 0.01904491f, 
    -0.00234481f, 0.01989663f, 0.02223965f, 0.02671235f, -0.02541925f, 0.01751915f, 0.01131719f, 0.00627444f, 
    -0.00892032f, 0.01804380f, -0.01678508f, -0.01422688f, -0.01056032f, -0.03745474f, -0.03331128f, -0.01741141f, 
    -0.00573139f, 0.02276712f, -0.04000849f, -0.02501193f, -0.02640241f, 0.02547492f, -0.03276847f, -0.01305122f, 
    0.01807148f, -0.01580873f, -0.00885446f, -0.04253464f, 0.00004576f, 0.02408328f, -0.00907010f, -0.03076442f, 
    -0.00383953f, 0.02519252f, 0.02382564f, -0.01376710f, -0.02644821f, -0.01226258f, -0.00276016f, 0.01257262f, 
    -0.03854939f, -0.03616135f, 0.03731587f, 0.00864083f, -0.01362550f, -0.00852351f, -0.01275369f, -0.01900659f, 
    0.02139431f, -0.03448794f, 0.00515745f, -0.00051797f, -0.02800488f, 0.02034388f, -0.01235511f, 0.02758072f, 
    0.01664364f, -0.04244159f, -0.03012956f, -0.00087328f, 0.00749847f, -0.02281367f, -0.01764150f, -0.01334555f, 
    -0.00068598f, -0.01183206f, -0.00253029f, -0.00479062f, -0.03317351f, -0.00981551f, 0.02645292f, -0.01725158f, 
    0.01384680f, -0.02370405f, -0.00328891f, 0.00366344f, 0.02749864f, -0.00298660f, 0.01637297f, -0.00285237f, 
    -0.00759436f, 0.01184208f, 0.02857198f, 0.01650048f, -0.00084886f, 0.02726632f, 0.01593905f, 0.00025483f, 
    -0.03295526f, -0.02924104f, 0.02501096f, -0.03877265f, 0.01696153f, 0.00734149f, -0.01443893f, -0.01203857f, 
    -0.04025419f, -0.01908632f, 0.02312370f, 0.00015615f, 0.02118894f, -0.01995574f, 0.02014159f, -0.00710576f, 
    0.01178999f, -0.00021413f, -0.03524994f, -0.00069315f, 0.00772401f, -0.03680697f, -0.01533685f, -0.00822722f, 
    -0.01303002f, -0.01474048f, 0.00655924f, 0.00621619f, 0.01246555f, -0.00161041f, 0.00833583f, 0.00207100f, 
    0.01567075f, -0.02009232f, -0.00839832f, -0.00742099f, 0.00292585f, 0.00584991f, -0.01740756f, -0.03607394f, 
    0.02673625f, 0.02419146f, -0.02740963f, 0.00869854f, 0.01071879f, -0.04306933f, 0.03061076f, -0.01019950f, 
    0.02068059f, -0.03647643f, -0.03508510f, -0.00880759f, -0.03100690f, -0.03118133f, 0.01473604f, -0.01454599f, 
    0.02831071f, -0.03116564f, 0.02237355f, 0.00480880f, 0.01439575f, 0.01221652f, -0.00624701f, -0.00885149f, 
    -0.03100151f, -0.00025558f, -0.00233148f, 0.01858039f, 0.01998059f, 0.00323124f, 0.00241416f, -0.01766833f, 
    -0.02985832f, -0.01666656f, -0.03367877f, 0.00009988f, -0.01240651f, -0.02730267f, -0.04022436f, -0.03043254f, 
    -0.00521888f, 0.00228957f, 0.01993733f, -0.03335556f, -0.02535617f, 0.01011960f, -0.00642370f, 0.00728878f, 
    -0.00843243f, -0.00091596f, 0.00756844f, 0.02081485f, -0.01879142f, 0.02217447f, -0.02792774f, -0.02511651f, 
    -0.04150137f, -0.00877463f, -0.03184589f, -0.01271741f, -0.04130638f, -0.01990726f, -0.04132172f, -0.04464660f, 
    0.00344687f, 0.00785429f, 0.00547562f, 0.01066612f, 0.00432094f, -0.01685257f, 0.00281518f, -0.03933631f, 
    0.01885574f, -0.00873425f, -0.00611370f, 0.00476909f, -0.02720252f, -0.03531965f, -0.03828468f, -0.00765624f, 
    -0.00967145f, -0.00526009f, -0.03338639f, -0.02500012f, 0.01963307f, 0.01982208f, 0.00233334f, -0.00187192f, 
    -0.01748935f, -0.01761505f, 0.01476555f, 0.02725555f, -0.01141933f, -0.00311475f, -0.02480503f, -0.02962148f, 
    -0.00993410f, -0.03233561f, 0.00979760f, 0.00860969f, 0.01439808f, -0.01998373f, 0.00022152f, -0.00028744f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02787113f, 0.03809426f, 0.01467506f, 0.00713738f, 0.05847596f, 0.07232255f, -0.03717628f, 0.12191053f, 
    -0.01034130f, 0.02535347f, 0.02074984f, 0.05225895f, -0.03144593f, -0.02980719f, -0.02780625f, 0.01554907f, 
    -0.02421233f, -0.02811823f, 0.02972234f, 0.02931229f, -0.02162765f, 0.00555278f, 0.01937078f, -0.01152385f, 
    0.00451462f, 0.01594387f, -0.01493230f, -0.04126094f, 0.02243170f, 0.03047849f, 0.26823726f, -0.03894488f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.06932431f, 0.00404160f, -0.13325413f, 0.27743864f, 0.42468712f, -0.04857857f, -0.14341925f, -0.28751832f, 
    0.05449050f, 0.10911756f, 0.00345799f, 0.12102442f, -0.16038276f, -0.00136826f, -0.18243773f, 0.08705968f, 
    0.21651471f, -0.05529597f, 0.00932840f, -0.13621172f, 0.12762970f, -0.19515277f, 0.01735033f, -0.28260046f, 
    0.14854844f, -0.10598233f, 0.00475610f, 0.07449304f, 0.23001675f, 0.02362676f, -0.08695235f, -0.16738962f, 
    -0.10048840f, 0.13163227f, 0.16313259f, -0.26148736f, 0.31154999f, -0.31230935f, -0.12699111f, -0.12535667f, 
    0.16644843f, -0.00043718f, 0.06594888f, -0.50622588f, -0.13029978f, -0.00383536f, -0.08457293f, 0.13268271f, 
    -0.15641578f, 0.04292535f, 0.20374666f, 0.01561233f, 0.16585293f, 0.00749077f, -0.03973303f, 0.14207129f, 
    -0.12576593f, -0.02093117f, 0.16038571f, -0.13851738f, 0.08384902f, -0.13496587f, 0.01033107f, -0.11363145f, 
    -0.12157355f, -0.15018192f, -0.17459460f, -0.06798319f, -0.33152458f, 0.36069703f, -0.15350316f, -0.34326357f, 
    -0.14670660f, 0.07697151f, -0.01192678f, 0.31007782f, -0.02342430f, 0.15806362f, -0.11613002f, -0.00619931f, 
    0.15475383f, -0.16205069f, -0.06555176f, -0.00146068f, -0.03490881f, 0.04586374f, -0.03619928f, 0.23367514f, 
    -0.17111534f, -0.08924630f, -0.06538401f, 0.16494688f, 0.39301899f, 0.17242181f, -0.09104500f, 0.05203359f, 
    -0.10533972f, 0.29241318f, -0.05082707f, -0.34206527f, 0.03273275f, 0.06602002f, -0.08496798f, 0.04184123f, 
    0.00755803f, 0.00113145f, -0.09112389f, 0.26531586f, 0.07653358f, -0.17856696f, -0.03498360f, -0.09558588f, 
    0.03372450f, -0.04385005f, -0.40596634f, 0.09297412f, 0.05722936f, -0.48244029f, -0.15591863f, 0.17580144f, 
    -0.09277768f, -0.15464631f, 0.04900770f, 0.02600977f, 0.05506876f, -0.09372779f, 0.07067056f, -0.14011411f, 
    -0.07970683f, -0.20860893f, -0.16563922f, 0.22726473f, 0.05179740f, 0.13779199f, -0.02495337f, -0.37361804f, 
    0.10433705f, -0.01607525f, -0.11442097f, -0.01766768f, 0.06475889f, 0.11275709f, 0.08546490f, -0.11060742f, 
    0.09356130f, -0.12938102f, 0.37823254f, -0.07263592f, -0.00874235f, 0.11628014f, -0.10975418f, -0.24272682f, 
    0.03124424f, -0.04645666f, 0.09780613f, 0.13567685f, 0.08363285f, -0.07881154f, 0.34805012f, -0.13453767f, 
    -0.02893499f, -0.14279287f, 0.05869467f, -0.15986608f, 0.32892486f, -0.16962492f, -0.04901103f, 0.02666886f, 
    -0.04120126f, -0.05860142f, 0.17633045f, -0.13552494f, -0.09214268f, -0.01968500f, -0.03763315f, 0.01900167f, 
    -0.02143303f, 0.14070620f, 0.08612922f, -0.02102293f, -0.13519876f, 0.22197959f, 0.06168166f, 0.04642354f, 
    0.09423099f, -0.16018093f, 0.04878670f, -0.11897279f, -0.02269451f, -0.05318690f, 0.09759836f, -0.15733941f, 
    -0.05379589f, 0.08253841f, -0.16406491f, -0.07842118f, 0.10798333f, -0.24487956f, 0.17240314f, 0.23988518f, 
    0.10413413f, 0.10081732f, 0.11726031f, -0.27581108f, -0.15114819f, -0.16763678f, 0.15934724f, -0.10606752f, 
    -0.13613275f, -0.01128775f, 0.15837936f, -0.10617559f, 0.04728674f, -0.18913786f, -0.00707724f, 0.42910329f, 
    0.03199979f, -0.14990596f, -0.02167846f, 0.07904404f, -0.26496804f, -0.05443109f, 0.23226689f, -0.04049874f, 
    -0.01514132f, -0.07606074f, -0.11268529f, -0.01010435f, -0.23276708f, 0.24535796f, 0.04456447f, -0.09582403f, 
    0.12737358f, 0.10644823f, -0.15171702f, -0.04607524f, -0.04822392f, 0.17206228f, -0.13067028f, -0.17469591f, 
    0.27249196f, -0.14110649f, 0.07271297f, 0.09439258f, -0.15589514f, 0.02168770f, -0.16717950f, -0.24450642f, 
    -0.08627599f, 0.09875278f, -0.07784219f, -0.00017990f, -0.22710973f, -0.11091963f, 0.01876889f, -0.08554516f, 
    -0.15249436f, 0.07719924f, -0.03673068f, 0.21233070f, -0.17332236f, -0.26387227f, -0.03329468f, 0.08919616f, 
    -0.12037127f, 0.01596678f, -0.06970263f, 0.15583093f, 0.16623175f, 0.13567892f, 0.09721377f, 0.10480612f, 
    -0.10158957f, -0.15415584f, -0.27308378f, -0.15328589f, -0.08056720f, 0.47242773f, 0.10848282f, -0.06411182f, 
    0.10294791f, 0.03799019f, 0.15353595f, 0.13831003f, 0.31296432f, -0.02803518f, 0.29071996f, -0.09407572f, 
    -0.12051227f, -0.22200835f, -0.05151293f, 0.24231137f, 0.10581066f, 0.45777920f, -0.13420956f, -0.23456088f, 
    0.06175184f, 0.02294862f, 0.13380419f, -0.18287984f, -0.10681899f, -0.06869590f, 0.11520889f, -0.10517504f, 
    0.17706671f, -0.10755847f, 0.10398521f, 0.14406049f, 0.13979772f, -0.26809043f, 0.03323455f, 0.35578921f, 
    -0.07948708f, 0.07211557f, -0.00532278f, 0.03385621f, 0.07485940f, -0.03619611f, 0.12352603f, 0.08122075f, 
    0.18262878f, 0.14119336f, 0.17718908f, 0.02867299f, 0.27717942f, -0.27026168f, 0.03736130f, 0.08462805f, 
    0.00718699f, -0.07309311f, 0.13598719f, -0.23600490f, 0.11732100f, 0.10877766f, 0.02935475f, -0.00837962f, 
    0.23946351f, 0.16269319f, -0.19180556f, -0.08866708f, -0.06078217f, 0.04564207f, 0.03656650f, 0.02780727f, 
    0.12644763f, 0.05320650f, -0.17687330f, 0.00180256f, 0.20263052f, 0.08999018f, -0.01173096f, 0.05538656f, 
    0.02547962f, -0.31694755f, 0.01253690f, 0.13984144f, 0.10490636f, -0.00419034f, -0.14294356f, -0.12508747f, 
    0.11974991f, 0.02341295f, 0.06348734f, 0.08371373f, 0.02232099f, -0.12434123f, 0.17274675f, -0.09731600f, 
    0.22287956f, 0.15767419f, -0.09448490f, 0.01349298f, 0.13453345f, -0.30471998f, -0.09923171f, -0.08097497f, 
    0.06210389f, -0.09806576f, -0.08661485f, -0.05537429f, 0.18837109f, -0.07386255f, 0.25132540f, -0.05413207f, 
    0.14815012f, 0.20038426f, -0.08872654f, -0.32903150f, 0.26672098f, 0.08485479f, -0.07337008f, -0.35689235f, 
    0.02540873f, -0.01599701f, 0.05176043f, 0.46803692f, 0.05434839f, 0.14472926f, -0.05265257f, 0.12255809f, 
    -0.12261485f, 0.08063344f, -0.04339597f, 0.03964805f, 0.07914165f, -0.09312983f, 0.16701441f, 0.02418629f, 
    -0.11214452f, 0.01156259f, -0.13296449f, 0.02153767f, -0.26418534f, -0.07956966f, 0.21778919f, -0.00671608f, 
    0.16013502f, 0.26621994f, 0.16289754f, -0.30829936f, -0.19451031f, 0.20970562f, -0.08974108f, 0.19218509f, 
    -0.06139377f, -0.16180213f, -0.12190609f, 0.38517502f, 0.10247856f, 0.15776302f, 0.17873508f, -0.01163692f, 
    -0.17351405f, -0.13757430f, 0.30230334f, -0.03114185f, -0.15391766f, 0.12685162f, -0.06788985f, -0.31850135f, 
    -0.08988910f, -0.10028235f, -0.14130433f, -0.11875898f, 0.17763600f, 0.10324662f, 0.11365689f, 0.03208968f, 
    0.08407991f, 0.20779762f, -0.10078034f, -0.46481687f, 0.32902443f, 0.00875767f, 0.06389074f, -0.11885086f, 
    -0.12750590f, 0.12483201f, -0.09499589f, -0.14893913f, -0.02806832f, -0.05464359f, 0.12180389f, 0.12298137f, 
    -0.05255561f, 0.09520016f, 0.28634015f, 0.09315410f, 0.04390466f, 0.19115119f, 0.12052292f, -0.16937378f, 
    0.04553699f, -0.09407879f, 0.09848239f, 0.09478354f, 0.00524055f, 0.14779837f, 0.15232955f, 0.04413810f, 
    0.05067134f, 0.28606790f, -0.13486271f, 0.12658943f, 0.08384307f, -0.20016922f, -0.01901383f, 0.20695972f, 
    -0.13397153f, 0.11051574f, 0.14606844f, 0.08300126f, 0.15189254f, 0.03645064f, 0.13930243f, -0.14985406f, 
    -0.20626879f, -0.09941847f, 0.14482048f, 0.01263529f, -0.07412568f, 0.12757295f, -0.01638294f, -0.25620681f, 
    -0.03079727f, -0.12628067f, 0.13479185f, 0.17673604f, -0.46946755f, 0.02239589f, -0.07427325f, -0.08806048f, 
    0.17668544f, -0.01500515f, 0.00648760f, 0.02731376f, -0.06653623f, -0.25213975f, 0.12512498f, 0.32460767f, 
    0.09651966f, 0.13284604f, -0.16404487f, 0.11980137f, 0.10644561f, 0.12930757f, 0.02059112f, -0.06902041f, 
    0.11317638f, 0.04184739f, 0.02329247f, -0.05683561f, -0.08306906f, 0.33085114f, 0.17311339f, -0.10014392f, 
    0.15377171f, 0.01821857f, -0.08424236f, -0.06149109f, -0.13346609f, -0.00481042f, -0.10100883f, -0.00948844f, 
    -0.12702808f, 0.11330481f, 0.17337209f, -0.15046689f, 0.27995214f, 0.21095398f, 0.00827110f, -0.75303370f, 
    -0.02370016f, -0.01688593f, -0.00223395f, 0.09753938f, -0.00235812f, 0.15008286f, 0.05478254f, 0.10001282f, 
    0.02586182f, 0.05490850f, -0.14861399f, -0.00657814f, -0.15440777f, 0.49649182f, -0.18211553f, 0.14476858f, 
    -0.04155005f, -0.00591307f, 0.15309414f, 0.10784913f, 0.11012232f, 0.00441563f, -0.26284316f, 0.00121360f, 
    0.14232241f, 0.28358746f, 0.09322060f, -0.03449026f, 0.16775055f, 0.13888572f, -0.12452550f, 0.09383588f, 
    -0.15777092f, -0.00216996f, -0.14237183f, -0.21762320f, 0.03685372f, 0.06969480f, 0.11053274f, 0.10685993f, 
    0.33446929f, -0.06044396f, 0.25841936f, 0.02426207f, -0.00699624f, -0.28179950f, -0.13111006f, -0.09204256f, 
    -0.06315217f, 0.10558228f, 0.12274429f, 0.08010160f, 0.22855432f, -0.05299814f, -0.17000808f, -0.09739107f, 
    0.09314606f, 0.24391870f, -0.10255096f, -0.45649305f, 0.04303591f, 0.33178443f, 0.02011087f, 0.09510960f, 
    0.12327269f, 0.10400523f, -0.09359112f, 0.25419396f, 0.08563782f, -0.16974340f, 0.13723384f, 0.15741998f, 
    -0.15088384f, 0.16822027f, 0.46780658f, -0.16642512f, -0.08458205f, 0.15155773f, -0.01721098f, -0.16259897f, 
    0.12395348f, -0.02985935f, 0.10861585f, -0.09831303f, -0.15187053f, 0.10785110f, 0.08786280f, 0.12750398f, 
    0.14398952f, 0.13728866f, -0.02039052f, -0.19690989f, 0.29092753f, -0.26338014f, -0.00546161f, 0.07708455f, 
    0.03702265f, 0.14188060f, 0.01601789f, -0.27864462f, 0.01814841f, -0.04110118f, -0.00180427f, -0.09297638f, 
    0.06333223f, -0.05130278f, 0.03781404f, 0.16087826f, -0.04208691f, -0.13660108f, 0.14238398f, 0.01968012f, 
    -0.02568370f, 0.13455516f, 0.08774658f, 0.14041828f, 0.19229591f, -0.13628714f, -0.10262241f, -0.04142041f, 
    0.14563517f, 0.21700585f, 0.04483801f, 0.02335645f, 0.04590423f, -0.02106310f, 0.08968340f, -0.02578915f, 
    -0.06028977f, -0.10234393f, -0.01142494f, 0.29213521f, 0.13135004f, -0.17315173f, 0.10114405f, -0.11620440f, 
    -0.24277067f, 0.08409004f, -0.44580346f, 0.10134983f, 0.07427736f, -0.42578435f, -0.12041634f, 0.29248631f, 
    0.01065871f, 0.02241219f, -0.04528805f, 0.11809397f, 0.00441339f, 0.03601459f, 0.26564571f, 0.17207465f, 
    -0.13718034f, -0.02229634f, -0.07588195f, 0.08465695f, -0.10334065f, 0.33982617f, 0.07714744f, 0.13805601f, 
    -0.01021399f, 0.16472489f, 0.00925371f, -0.21177694f, 0.05039426f, -0.16734485f, -0.05430833f, -0.08250318f, 
    0.21830438f, 0.00582340f, -0.00898421f, -0.11848614f, 0.10215284f, 0.04073996f, -0.06938929f, -0.22859670f, 
    0.03060066f, -0.06710824f, -0.01568678f, -0.04871755f, 0.19427320f, -0.16904998f, 0.16739666f, 0.10205691f, 
    0.07183664f, -0.21663302f, 0.04421842f, 0.03048751f, -0.09225781f, -0.12306462f, 0.08367252f, -0.24215861f, 
    0.09518546f, -0.04586842f, -0.12446791f, 0.05187432f, -0.03353573f, 0.14599046f, 0.09907319f, 0.14862496f, 
    -0.11069760f, 0.04293490f, -0.12252154f, 0.15775520f, 0.09281619f, 0.04552300f, -0.10144155f, -0.02367989f, 
    -0.07490432f, 0.16675961f, -0.18036012f, -0.02982086f, 0.10414746f, 0.13839066f, -0.20908311f, 0.16188036f, 
    0.00624722f, -0.29441866f, -0.08243949f, -0.06295230f, -0.07360696f, 0.27796283f, -0.13901100f, 0.05355207f, 
    0.04399037f, 0.07738369f, 0.11504856f, 0.15822326f, 0.06803428f, 0.07694150f, -0.08872167f, 0.09426591f, 
    0.14116843f, 0.13804296f, 0.22480491f, 0.03382393f, 0.12711589f, 0.22814053f, 0.15653163f, 0.47732070f, 
    -0.18097901f, 0.00918430f, 0.11533004f, -0.10120872f, -0.08574590f, 0.14015037f, -0.00778471f, 0.15376630f, 
    0.01939981f, 0.15485303f, 0.02569529f, -0.05736912f, 0.13334382f, -0.35367426f, 0.01923444f, 0.08584697f, 
    -0.09444991f, -0.12521806f, 0.15923561f, 0.00104598f, -0.07450444f, 0.10133009f, -0.06255775f, -0.10030068f, 
    0.10203896f, 0.05688791f, -0.32374236f, 0.00766185f, -0.06338474f, 0.31103331f, -0.00004322f, 0.32467592f, 
    -0.08139276f, 0.09940609f, -0.08225736f, 0.03536068f, 0.26333374f, 0.17970116f, -0.08933073f, -0.02267890f, 
    -0.06507587f, -0.19305848f, 0.05329242f, 0.04976260f, 0.09243934f, -0.24144284f, -0.09602129f, 0.06125265f, 
    0.10921032f, -0.15128122f, 0.12149052f, 0.19001213f, 0.12315849f, -0.04408204f, -0.03833710f, -0.00173620f, 
    0.01502869f, 0.11447084f, 0.47763428f, -0.15995646f, 0.06644979f, 0.37201655f, -0.04316864f, -0.22726887f, 
    -0.11383846f, 0.13609146f, 0.07237709f, 0.04624896f, 0.21625082f, -0.00021447f, -0.02971874f, 0.11122616f, 
    0.14478838f, 0.17971690f, 0.05351034f, -0.34201753f, -0.18896089f, 0.44627210f, 0.09011918f, 0.01286413f, 
    -0.01540758f, 0.00827171f, -0.14486445f, -0.00696524f, -0.15016870f, 0.04931501f, -0.09734724f, 0.05837179f, 
    0.23005579f, 0.10455052f, 0.41223860f, 0.13035095f, 0.00182366f, -0.31189296f, -0.00797774f, 0.20834067f, 
    0.12069419f, -0.01762600f, -0.12333026f, 0.04424538f, -0.04117760f, -0.10287081f, -0.12142278f, 0.00986773f, 
    0.07185262f, -0.04541382f, -0.03770159f, -0.03545986f, -0.22520314f, 0.15927468f, -0.14103460f, -0.13475628f, 
    0.14338513f, -0.17399603f, -0.11348873f, -0.14207689f, 0.10996433f, 0.16297096f, 0.08163939f, 0.16844824f, 
    -0.18913065f, -0.15214278f, 0.13453443f, 0.13906793f, -0.14539017f, 0.12194796f, -0.06422589f, -0.02921777f, 
    0.09374907f, -0.14302132f, -0.14681485f, -0.00667149f, -0.04818117f, -0.04400466f, 0.12211131f, 0.16658473f, 
    -0.00824053f, 0.07309620f, -0.07783811f, -0.21202509f, 0.12404697f, -0.15229087f, 0.14768186f, 0.04256859f, 
    -0.05655553f, -0.15811357f, 0.06210317f, -0.06380896f, 0.13955799f, -0.08302360f, 0.04318869f, 0.13665658f, 
    0.01187035f, 0.11282159f, -0.16595040f, 0.05666324f, -0.13654213f, 0.15250716f, 0.03928578f, -0.00150309f, 
    -0.00440454f, 0.00659954f, 0.14072636f, -0.09241712f, 0.15351462f, 0.08240097f, -0.18719237f, -0.00480421f, 
    0.14910574f, -0.20371573f, 0.03142315f, -0.06551169f, 0.12970886f, 0.01414223f, -0.12327678f, -0.06272544f, 
    -0.17141165f, -0.11420766f, 0.11068691f, 0.09961859f, -0.01881168f, 0.10446151f, -0.06594967f, 0.09227087f, 
    -0.18064699f, 0.14515692f, -0.12382038f, 0.16776372f, -0.08942591f, -0.08137592f, -0.00964013f, -0.06831968f, 
    0.06603260f, -0.00959220f, 0.09922953f, -0.11022790f, -0.14531867f, -0.06908400f, -0.00462257f, 0.03458480f, 
    -0.04087029f, 0.17659989f, -0.03789720f, 0.08258533f, 0.07253343f, -0.27672732f, -0.16809143f, -0.23229170f, 
    -0.02034941f, -0.13641414f, -0.08211631f, -0.10168893f, 0.15288010f, -0.07709040f, 0.07924645f, 0.15970483f, 
    0.31850925f, -0.10639719f, -0.08542519f, 0.04327084f, 0.09817474f, 0.34710264f, 0.14659783f, 0.17464909f, 
    0.01256928f, 0.16828938f, 0.11752109f, 0.07813734f, 0.29077172f, 0.05833382f, -0.24843717f, 0.08869375f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.12271808f, -0.19984670f, -0.00709421f, -0.00737129f, 0.20136048f, 0.11473633f, 0.21689139f, -0.09740485f, 
    0.18615630f, 0.07051057f, -0.04364317f, 0.18575232f, 0.17912611f, -0.02476852f, 0.12640336f, -0.08108014f, 
    -0.02790437f, -0.10396005f, 0.10849275f, 0.12898196f, -0.05537085f, 0.27998498f, 0.24729396f, 0.10584410f, 
    -0.05455229f, 0.19038081f, 0.11730631f, -0.20057201f, 0.00710127f, -0.17166497f, 0.01708503f, -0.19568148f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.10000250f, 0.31486443f, -0.22587754f, -0.00096614f, -0.37396875f, -0.41667044f, -0.10647180f, -0.44891542f, 
    -0.10919645f, 0.13974391f, 0.21920462f, -0.27585629f, -0.16634844f, -0.54588139f, -0.08557418f, 0.24267587f, 
    -0.13690680f, 0.39842838f, 0.06131334f, -0.47201669f, 0.16978358f, -0.12184168f, -0.22660615f, 0.13213144f, 
    -0.43182078f, 0.27273297f, -0.31506112f, -0.18903127f, 0.05825293f, -0.01421910f, -0.15432821f, 0.29285988f, 
    0.20530556f, 0.44737244f, -0.76078987f, -0.19500409f, -0.09184463f, 0.34888160f, 0.29569134f, -0.06532872f, 
    0.06532121f, -0.11474989f, 0.16185956f, -0.06440406f, -0.10737773f, -0.18784758f, 0.25904486f, -0.13713372f, 
    -0.06227085f, -0.60101098f, 0.09100124f, -0.11634484f, 0.17881732f, -0.03138769f, -0.04043452f, 0.12915224f, 
    0.32247737f, 0.23539732f, 0.05049954f, -0.32959953f, -0.16088282f, -0.27104035f, 0.08691794f, 0.03316878f, 
    0.19774644f, -0.42514563f, -0.07629085f, -0.01184356f, 0.14220728f, -0.02948917f, -0.19949414f, -0.16150008f, 
    -0.21068424f, 0.34459099f, 0.15754101f, 0.37375376f, 0.28024590f, 0.06139537f, 0.15561594f, 0.07467311f, 
    0.09049074f, -0.28740585f, 0.02282503f, -0.04390848f, -0.58898079f, 0.07526136f, 0.03247430f, -0.01052826f, 
    -0.19991325f, -0.57946706f, -0.02496483f, -0.11486160f, -0.17422137f, -0.21574898f, 0.06690058f, -0.57747126f, 
    0.00291587f, -0.08939660f, 0.17281307f, -0.00880782f, -0.28313008f, -0.51848590f, -0.27051735f, -0.09360269f, 
    -0.62365520f, 0.11040552f, -0.08196623f, -0.28365278f, 0.26283818f, 0.05992487f, 0.19319245f, 0.24662215f, 
    -0.06243773f, 0.25312692f, 0.18403217f, 0.06138813f, 0.05026199f, -0.19111758f, -0.12082690f, 0.03813969f, 
    -0.00302477f, -0.05351838f, -0.17758182f, 0.16944019f, -0.12811734f, -0.17057779f, 0.00450228f, -0.10191087f, 
    -0.04749982f, -0.57913339f, 0.16402458f, -0.03527596f, -0.12909298f, -0.49656716f, 0.02905852f, 0.39521199f, 
    -0.21955624f, 0.08090036f, 0.18765147f, 0.12515581f, -0.63059551f, -0.14461288f, -0.25144216f, 0.01655616f, 
    0.21756582f, -0.14953470f, 0.11158755f, -0.25068435f, 0.01414599f, -0.37168112f, 0.27100942f, -0.00358946f, 
    0.04556120f, 0.07368299f, -0.08243381f, 0.18477848f, 0.07059778f, -0.14825390f, -0.00410059f, 0.19840018f, 
    -0.00881446f, -0.38943738f, -0.04407334f, 0.17906436f, -0.33582976f, -0.62904882f, -0.21461004f, -0.05452201f, 
    0.28172651f, -0.26332292f, 0.08686931f, -0.08461095f, -0.15558149f, 0.28685892f, 0.08331957f, -0.40924096f, 
    -0.14700806f, -0.60015166f, 0.08495443f, -0.01324109f, 0.06504402f, 0.13548906f, 0.18949994f, 0.12676893f, 
    -0.63514864f, 0.24962904f, 0.01955377f, -0.15744179f, -0.10184531f, -0.03986706f, -0.14554988f, 0.03511888f, 
    -0.90573150f, -0.22878543f, 0.27999482f, -0.56191921f, 0.18262674f, -0.13817079f, -0.00024408f, 0.01292928f, 
    0.08739001f, 0.27910876f, -0.30809462f, 0.07517473f, -0.14143424f, 0.05978933f, -0.24690375f, -0.04674719f, 
    -0.07529993f, -0.25862131f, -0.63248724f, 0.17057800f, -0.17626218f, 0.00731324f, 0.27688989f, 0.07061121f, 
    0.22948180f, -0.58272052f, -0.24819486f, -0.11546074f, 0.05494960f, -0.10743143f, 0.12103282f, -0.67377651f, 
    -0.20581581f, -0.49444041f, 0.26454473f, -0.38630491f, -0.22008605f, -0.01333033f, -0.20794950f, -0.11092690f, 
    0.18960589f, -0.61057103f, -0.17805116f, -0.03735219f, -0.07506407f, 0.18848325f, -0.11787281f, 0.07233304f, 
    0.20544083f, 0.25568229f, -0.27280354f, 0.09238677f, -0.27164677f, -0.32159674f, -0.22269680f, -0.04543929f, 
    -0.04030193f, 0.01420551f, 0.37515771f, -0.29088888f, -0.13298592f, -0.13183370f, -0.16685264f, 0.16272339f, 
    -0.51514870f, -0.42979205f, -0.39542091f, 0.17390911f, 0.17352381f, -0.22401686f, 0.10044251f, 0.04465132f, 
    -0.18750407f, -0.52499342f, -0.01963464f, -0.30116224f, 0.54062074f, 0.16717792f, 0.07521642f, 0.21179087f, 
    -0.09705380f, 0.03695631f, -0.18382770f, 0.35022581f, -0.25228763f, -0.04578388f, -0.40222436f, -0.16488600f, 
    -0.24919462f, -0.00329491f, -0.12108075f, 0.06219496f, 0.04198598f, 0.10273343f, 0.01031390f, -0.50196403f, 
    -0.09683955f, -0.41389900f, 0.21983391f, -0.31467715f, 0.21637960f, 0.05895139f, -0.04161271f, 0.03933397f, 
    0.17796423f, 0.17140904f, 0.05039744f, 0.21813451f, -0.65715182f, -0.14552240f, -0.53726143f, -0.40978673f, 
    -0.30881396f, 0.04717333f, -0.09225652f, -0.31687677f, -0.59621847f, -0.23642141f, -0.04119257f, 0.07409786f, 
    0.05219125f, 0.12998131f, 0.30143395f, -0.38543668f, -0.03448185f, -0.43956390f, -0.08735763f, 0.02094522f, 
    -0.60601890f, 0.23224503f, -0.38690564f, -0.08061530f, -0.24477334f, -0.43440354f, 0.25017047f, -0.14487118f, 
    -0.31837335f, 0.07642420f, 0.00318422f, -0.52288049f, -0.37453374f, 0.14978823f, 0.20990802f, -0.40640759f, 
    -0.44304219f, -1.13920963f, 0.25548542f, 0.28228465f, 0.18027398f, -0.26919806f, 0.13720825f, 0.13059033f, 
    0.03702688f, -0.06099360f, 0.10469218f, 0.37442341f, -0.03835306f, -0.08734810f, -0.18207189f, -0.16926676f, 
    -0.42446187f, 0.16149196f, 0.10812969f, 0.36556306f, -0.33440399f, -0.24449322f, 0.36992568f, -0.17847204f, 
    -0.07745560f, 0.14696139f, -0.17195866f, 0.03864553f, 0.27737144f, -0.15894818f, -0.47536391f, -0.51763928f, 
    -0.63731050f, -0.41448283f, -0.11569232f, -0.04919723f, -0.16156864f, 0.37108326f, -0.28917432f, -0.12388319f, 
    0.23732342f, 0.01762651f, -0.57484078f, 0.20054030f, -0.03828923f, -0.06684932f, 0.06804670f, -0.18763909f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.15662502f, 0.22235030f, -0.01460245f, 0.00598461f, 0.01975993f, 0.22365214f, 0.15730245f, -0.20087330f, 
    0.09376994f, 0.10764930f, -0.01835988f, 0.21869156f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
