#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.50899720f, -0.70654649f, -0.60834616f, -0.28701934f, -0.52086973f, -0.15506276f, -0.21074156f, -0.17773265f, 
    -0.25311053f, -0.54687780f, -0.72190887f, -0.24013306f, 0.62414682f, -0.13029543f, 0.63803679f, -0.19070196f, 
    -0.30235755f, -0.08373028f, 0.17339897f, 0.88130456f, -0.60745114f, 0.12433558f, -0.31561780f, -0.45432049f, 
    -0.03020915f, 0.02307134f, -0.03448425f, 0.15147020f, -0.20456417f, 0.22359315f, 0.74143946f, -0.15656120f, 
    0.13543703f, -0.63205326f, -0.52075458f, -0.56460935f, -0.25130162f, 0.24042387f, 0.02057230f, -0.68327361f, 
    -0.38937533f, 0.05702348f, 0.36016801f, 0.00849367f, 0.48401260f, 0.36735129f, -0.70194054f, 0.46988234f, 
    -0.63064605f, -0.59505266f, 0.37261659f, -0.06032532f, -0.15994394f, 0.03077122f, 0.54666466f, 0.45008606f, 
    0.33749065f, 0.01167517f, -0.64225280f, 0.45411751f, -0.39742550f, 0.19510274f, 0.05655785f, -0.91599268f, 
    0.36451444f, -0.28535539f, 0.34426367f, 0.28366616f, -0.54517752f, 0.01266865f, 0.02735906f, -0.11612659f, 
    -0.68315321f, -0.24290124f, 0.55365944f, 0.41995251f, 0.34455997f, 0.29688448f, 0.33434334f, 0.21988834f, 
    -0.03142056f, 0.91475838f, 0.73377055f, 0.35663337f, -0.54306024f, 0.01100728f, -0.21075580f, 0.26809755f, 
    -0.06197857f, -0.02177662f, 0.66358536f, -0.12284729f, -0.26975051f, -0.66072172f, -0.44665375f, -0.66102391f, 
    -0.13636929f, -0.35172603f, 0.22733559f, 0.77962124f, 0.59386885f, 0.71392262f, 0.37589708f, 0.16903353f, 
    0.15190314f, 0.02387711f, 0.21876334f, 0.09774030f, -0.13871199f, -0.56670457f, -0.03308111f, -0.56330597f, 
    0.56659776f, -0.70535558f, 0.26426810f, 0.34688213f, -0.37119797f, -0.73700827f, 0.13115749f, -0.66423118f, 
    0.08326362f, -0.32508487f, -0.00925901f, 0.18091771f, 0.41823485f, 0.04135759f, 0.83265430f, -0.31918707f, 
    0.25112209f, 0.84637326f, 0.42931357f, 0.16267972f, -0.00806146f, 0.15754244f, -0.02350325f, -0.32954332f, 
    -0.61758482f, -0.69157737f, -0.31970575f, 0.41568109f, 0.64843953f, 0.02010477f, 0.15301962f, 0.37130946f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.37225178f, 0.08041035f, -0.25688049f, -0.20832519f, 0.01475293f, 0.20732243f, -0.04764760f, 0.18253225f, 
    -0.39634341f, 0.01643754f, -0.00440196f, -0.01617791f, 0.09682290f, 0.14404055f, -0.00645729f, -0.19573839f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.01068231f, -0.18325387f, 0.29740998f, 0.15863995f, 0.02833524f, -0.22202584f, 0.07798284f, -0.16684334f, 
    0.13266136f, 0.01743409f, -0.09736840f, 0.09017803f, 0.02592283f, 0.23171601f, -0.01971841f, -0.06358230f, 
    0.02506389f, -0.00664115f, -0.03039964f, 0.01205357f, -0.08707977f, -0.11689136f, -0.05808115f, 0.07247934f, 
    -0.06201069f, -0.05904264f, 0.03158155f, -0.05377609f, -0.35849231f, 0.17424254f, -0.09458973f, 0.04491774f, 
    0.18928699f, -0.05749638f, -0.07168077f, -0.08469883f, 0.15394825f, -0.34076253f, -0.05348251f, -0.12805186f, 
    0.01560090f, -0.05122207f, -0.01955993f, -0.05397191f, -0.10066246f, -0.21769767f, -0.17934050f, -0.02254121f, 
    -0.20822163f, 0.00141700f, -0.01965806f, 0.11629502f, 0.05554445f, -0.10025743f, 0.15196514f, -0.03342732f, 
    0.21870343f, 0.13548149f, -0.10510311f, -0.03975806f, -0.04460930f, -0.07069708f, -0.03998263f, 0.14678478f, 
    0.05820325f, -0.12909517f, -0.00175880f, 0.05017970f, 0.08654307f, 0.15753090f, 0.13075979f, -0.15725482f, 
    -0.01668968f, 0.09746499f, -0.23313400f, 0.04224204f, -0.16491607f, 0.21970120f, -0.03358399f, 0.00623504f, 
    -0.04849887f, -0.54050261f, 0.19386074f, 0.24885291f, -0.05295825f, 0.23295349f, -0.22433168f, 0.10048167f, 
    -0.07009642f, 0.11274774f, -0.04284485f, 0.04574374f, -0.11070886f, -0.04214704f, -0.11971737f, -0.09011441f, 
    0.07510754f, 0.24443275f, 0.12140736f, -0.02915112f, -0.09968051f, 0.29080912f, 0.15515983f, -0.24454711f, 
    0.30907622f, 0.01974422f, 0.19686343f, 0.08544751f, 0.20533022f, 0.16006072f, 0.11549744f, -0.06217242f, 
    -0.13196000f, 0.05842030f, -0.02282756f, -0.09199107f, -0.15394418f, 0.15701085f, 0.11432838f, -0.07831650f, 
    0.12505154f, -0.05080367f, -0.00848611f, -0.01465485f, 0.19212984f, 0.02849893f, -0.26218787f, -0.10114868f, 
    -0.16116932f, 0.10907041f, 0.00446219f, -0.08381180f, 0.03523991f, 0.01450999f, -0.18020846f, 0.12358499f, 
    0.10154037f, -0.04866537f, 0.03728488f, 0.03612235f, 0.01449259f, 0.16360921f, -0.02221092f, -0.07866733f, 
    0.15816633f, 0.32037577f, 0.17101684f, 0.12849630f, 0.02671478f, -0.18449247f, 0.16668019f, 0.13287790f, 
    -0.09745028f, 0.38858274f, 0.13109061f, 0.27943844f, 0.00611240f, 0.21016885f, -0.01560055f, -0.08207610f, 
    -0.04886126f, 0.21298444f, 0.07332060f, 0.35508507f, -0.05323176f, -0.04812997f, -0.38602695f, 0.12625563f, 
    -0.08517457f, 0.01281965f, 0.00721237f, 0.31257442f, 0.13475890f, 0.02135774f, 0.05283414f, 0.30258799f, 
    0.01091963f, 0.12030116f, -0.09022804f, -0.03118219f, -0.28457952f, -0.33597121f, 0.08229408f, -0.04550766f, 
    -0.19046547f, 0.02596235f, 0.00149393f, -0.00512082f, 0.00200221f, 0.10621272f, -0.06816912f, -0.32097065f, 
    -0.19945954f, -0.05087191f, 0.02708585f, -0.05113288f, 0.00007027f, -0.07941960f, 0.40310001f, -0.27593458f, 
    0.05605311f, -0.03354258f, -0.15834546f, 0.03430998f, 0.02166057f, 0.03523185f, -0.16393690f, 0.04965248f, 
    0.05733602f, -0.17243887f, -0.12185477f, 0.04138902f, -0.02392578f, 0.09098831f, 0.12877627f, -0.04405541f, 
    0.24312918f, 0.19808641f, 0.38015988f, 0.23758738f, -0.07717352f, 0.04544315f, 0.11934056f, -0.06229731f, 
    0.13124979f, -0.09884097f, 0.00397867f, -0.10618832f, -0.07638156f, -0.04230461f, -0.20045020f, -0.10394639f, 
    -0.08548677f, -0.00792932f, 0.11112072f, -0.02455467f, -0.07878033f, -0.34000689f, -0.20390044f, 0.02564207f, 
    -0.17001967f, -0.17842357f, -0.06873382f, 0.08010583f, -0.11186837f, -0.01777800f, -0.00375382f, 0.10804314f, 
    -0.05997035f, -0.06758931f, -0.06506611f, -0.01443626f, 0.02170373f, 0.09114563f, -0.02001990f, 0.09917216f, 
    -0.06986365f, -0.04218066f, 0.07564529f, -0.14614932f, -0.30190936f, 0.00153815f, -0.31624413f, 0.19621229f, 
    0.05547494f, 0.02261840f, -0.00663843f, -0.00860716f, -0.02681360f, 0.03898804f, -0.02895948f, -0.21309461f, 
    -0.08398625f, 0.07868537f, 0.02769011f, -0.05013582f, 0.07156493f, 0.05128447f, -0.01832675f, 0.15058550f, 
    0.16041222f, -0.21953033f, 0.07769459f, 0.10172340f, -0.06586911f, 0.09608488f, 0.01101299f, -0.14851207f, 
    -0.56706303f, -0.15367605f, 0.13336441f, -0.07944247f, -0.15145469f, -0.04223238f, 0.03302274f, 0.04365364f, 
    0.06909953f, 0.14884084f, 0.43696019f, -0.45313469f, 0.23183848f, 0.07264742f, 0.16465437f, 0.04512943f, 
    -0.16331045f, -0.10514829f, 0.16100091f, -0.07250724f, 0.09402252f, -0.15585449f, 0.08752104f, -0.25010833f, 
    -0.19281581f, -0.17356718f, -0.07899038f, -0.00774893f, -0.08103582f, 0.24277189f, 0.20745806f, 0.10059383f, 
    -0.23350810f, 0.31038758f, 0.18782583f, -0.05535499f, -0.11915337f, -0.16792980f, -0.00004603f, -0.08071553f, 
    -0.13500455f, 0.12351918f, -0.20610379f, 0.11002874f, 0.11312710f, -0.20211884f, -0.09678325f, 0.04472834f, 
    -0.13485071f, 0.16227691f, -0.01553461f, 0.00316546f, 0.23612854f, 0.08308253f, 0.16659990f, 0.12675557f, 
    0.20272064f, -0.06442213f, -0.20222239f, 0.09261125f, 0.05296971f, 0.14104304f, 0.09210273f, 0.42223334f, 
    -0.18627015f, -0.01889855f, 0.07438551f, -0.06444354f, -0.08255417f, 0.02759247f, 0.04279197f, 0.11958522f, 
    -0.65135974f, -0.07093851f, 0.04377478f, -0.14218177f, 0.23009486f, -0.09255577f, -0.11011863f, -0.11224099f, 
    0.04560868f, 0.27122688f, 0.21221595f, -0.03540179f, -0.02433914f, -0.14801946f, 0.03819955f, 0.00161833f, 
    -0.08152620f, 0.07642628f, 0.14933866f, -0.33115983f, 0.14090306f, -0.00099863f, 0.13438344f, 0.05360616f, 
    0.00126395f, -0.08910469f, 0.25325313f, -0.05578142f, 0.18751241f, 0.24952391f, -0.06929429f, 0.13931477f, 
    0.02103074f, -0.03458128f, 0.04902424f, -0.12924342f, -0.11347129f, -0.45933393f, -0.06169923f, 0.07365013f, 
    0.08971331f, -0.09626135f, -0.12339973f, 0.06018859f, -0.14089671f, -0.09334491f, -0.15701178f, -0.27743340f, 
    0.11837387f, 0.12083355f, -0.09571772f, 0.01765936f, -0.11687457f, 0.00724133f, 0.49779078f, -0.19792990f, 
    -0.16437860f, -0.36650708f, 0.11457772f, 0.08114395f, 0.07144394f, 0.09316794f, -0.03396211f, 0.13537920f, 
    -0.05252096f, -0.51342773f, 0.15458974f, 0.09754469f, -0.06650069f, 0.04878035f, 0.02450186f, 0.04876142f, 
    -0.05213579f, -0.16999194f, 0.01842735f, -0.23202375f, 0.10820106f, 0.12976962f, -0.06296479f, -0.02049894f, 
    0.09650820f, 0.22139463f, 0.25806209f, 0.11270574f, -0.01651889f, 0.17385657f, 0.12943839f, -0.06064396f, 
    0.16456939f, 0.11574981f, 0.21840999f, -0.14389452f, 0.15610576f, -0.14420304f, -0.02654423f, -0.11949759f, 
    -0.04150258f, -0.12988201f, 0.05260942f, -0.29943922f, -0.35749713f, -0.20817374f, 0.17003904f, 0.11932809f, 
    -0.00675762f, -0.20196198f, -0.00309173f, -0.23883626f, 0.17649433f, -0.02231500f, -0.16362254f, 0.02405536f, 
    -0.01933994f, -0.02754766f, 0.06400014f, 0.00166183f, 0.09561958f, -0.07174464f, 0.02776082f, -0.18554775f, 
    -0.14490359f, -0.02547958f, 0.29096037f, -0.03968098f, 0.15059538f, 0.03883395f, -0.04108429f, -0.30374897f, 
    -0.13650496f, 0.22386241f, 0.01306985f, 0.12113649f, -0.00966313f, -0.07318450f, 0.12641825f, 0.05827427f, 
    0.11840291f, 0.09100146f, -0.11871535f, -0.18991221f, -0.06539771f, -0.07047363f, 0.00163031f, 0.11838312f, 
    -0.11859523f, 0.02539692f, 0.02099089f, -0.06414618f, -0.03433707f, -0.04818331f, 0.05523537f, 0.20795368f, 
    -0.02019192f, 0.08598170f, -0.17483826f, 0.17366610f, 0.24268407f, 0.03514099f, 0.01121813f, 0.11318125f, 
    -0.09043097f, -0.12559845f, 0.36655027f, -0.11121891f, 0.27622992f, 0.21288909f, -0.06203934f, -0.11611651f, 
    0.01445969f, -0.07297249f, 0.08674219f, -0.38885939f, -0.42904106f, -0.18427888f, 0.04473202f, 0.10218797f, 
    0.17815608f, 0.04235401f, -0.15755850f, -0.06710207f, 0.00832030f, 0.03551621f, -0.04428414f, -0.01329736f, 
    -0.04116420f, -0.04390734f, 0.14258654f, 0.07327373f, -0.16769426f, 0.04347929f, -0.07540803f, 0.08058407f, 
    0.12233902f, 0.15113804f, -0.06101887f, 0.00339616f, -0.07169947f, -0.14312555f, -0.49549696f, -0.12409449f, 
    -0.17049052f, 0.13388850f, 0.07008813f, -0.01309120f, 0.23153968f, -0.01650713f, 0.02587160f, 0.19967049f, 
    -0.08058473f, 0.11671773f, -0.25353229f, -0.06522202f, -0.30698395f, -0.05720645f, 0.18701917f, -0.09062771f, 
    -0.10035022f, -0.07431042f, 0.30309337f, -0.16455418f, -0.03198263f, -0.01547018f, -0.09832450f, -0.01854024f, 
    -0.01348278f, 0.24726819f, -0.01556219f, 0.14765732f, -0.18868314f, -0.16546674f, 0.11658042f, 0.08345252f, 
    -0.07645917f, 0.06504868f, 0.31625408f, 0.11434817f, -0.23875378f, -0.31645095f, 0.10214632f, 0.15957397f, 
    -0.04773417f, 0.01556783f, 0.09508537f, 0.19717219f, 0.16250305f, -0.06834896f, -0.04866423f, -0.19459917f, 
    0.03857534f, 0.02438533f, 0.01747104f, 0.06586830f, -0.08322164f, 0.00425723f, -0.21670888f, 0.14800705f, 
    0.10038139f, -0.09153975f, -0.16645002f, 0.08305687f, -0.03905970f, 0.13855343f, -0.02603847f, -0.06209064f, 
    0.03189544f, 0.22887377f, -0.02688268f, 0.05493723f, 0.17967191f, -0.15319964f, -0.02107768f, -0.11050680f, 
    -0.25778306f, -0.06606069f, 0.11644928f, -0.15851383f, -0.06785583f, -0.17145546f, -0.22628161f, 0.22381181f, 
    0.04632914f, -0.03335122f, 0.01548388f, 0.08500266f, 0.00872029f, -0.05805049f, 0.01282959f, 0.14430045f, 
    -0.08425220f, 0.20271419f, -0.07060797f, 0.03155666f, 0.07037719f, 0.06759817f, 0.15974712f, -0.04746921f, 
    -0.01885310f, -0.30044612f, -0.00680503f, 0.01546362f, -0.08273158f, -0.00459057f, 0.10626409f, 0.01065141f, 
    -0.04641097f, 0.03498290f, 0.29179424f, 0.32744414f, -0.06273078f, 0.18354565f, 0.00407891f, -0.03975888f, 
    0.01488106f, 0.08200397f, 0.17596366f, -0.15780416f, -0.06822242f, -0.10869519f, -0.05358580f, 0.00340212f, 
    0.10746392f, 0.07099451f, 0.07898515f, -0.43389553f, -0.35181376f, 0.22487964f, 0.16713557f, 0.20616998f, 
    -0.12716845f, -0.03376002f, -0.08201085f, -0.04763436f, 0.07233698f, 0.14301673f, -0.21587685f, -0.06308249f, 
    -0.02616107f, 0.13939865f, 0.07066352f, -0.06558109f, 0.21560542f, 0.06609969f, -0.23530424f, 0.22973429f, 
    -0.07789655f, 0.17422104f, 0.17425303f, -0.01260680f, -0.18587331f, 0.18691096f, -0.21698284f, -0.24903545f, 
    -0.05631045f, 0.17836601f, -0.12794447f, -0.07535016f, -0.01913212f, 0.11403739f, -0.03278043f, -0.06954911f, 
    -0.07375034f, -0.06154620f, 0.22616737f, 0.01977788f, 0.08145736f, 0.02800032f, 0.19919200f, -0.01375450f, 
    -0.06086919f, 0.08984378f, -0.40045273f, -0.03465057f, -0.05288111f, 0.18618163f, 0.04801607f, -0.08943062f, 
    0.10239401f, -0.04369425f, -0.07048260f, 0.08698075f, -0.20343415f, 0.05018806f, -0.15463792f, -0.08373526f, 
    -0.10745187f, -0.03075212f, -0.03705422f, 0.28287870f, -0.13219014f, -0.09316923f, -0.07558264f, -0.18385997f, 
    -0.07574300f, 0.12570548f, 0.14401643f, 0.07626247f, -0.03887616f, 0.15463042f, -0.05332294f, 0.23582245f, 
    0.03578820f, 0.16290672f, -0.01920308f, 0.13650694f, 0.01045845f, -0.01830331f, 0.08036348f, -0.05609872f, 
    -0.01570137f, 0.13339630f, 0.11270812f, -0.03991231f, 0.11192632f, 0.19201012f, -0.21478203f, 0.10876178f, 
    0.14547743f, 0.09374508f, 0.09388751f, -0.01618621f, 0.09545016f, 0.06551071f, 0.06007738f, -0.79727709f, 
    -0.12413806f, 0.11098178f, 0.39170182f, -0.02638243f, 0.01998004f, -0.01110480f, -0.11827333f, 0.00963306f, 
    -0.28608811f, -0.33544570f, -0.17617925f, -0.10159026f, 0.06398243f, -0.11284293f, -0.00497732f, -0.25653532f, 
    0.14785028f, -0.00686641f, 0.24304245f, 0.07198392f, 0.07761856f, -0.10424184f, -0.15035643f, -0.08011545f, 
    0.02965013f, -0.02972597f, 0.19312294f, -0.16627601f, -0.21320936f, -0.07514688f, -0.13282582f, 0.07010535f, 
    0.11669870f, 0.08572168f, 0.18589820f, -0.04653579f, 0.45020553f, -0.04859113f, 0.12473272f, 0.02817190f, 
    -0.14638898f, 0.01045510f, 0.04974327f, -0.08399304f, -0.17793651f, -0.06134753f, -0.29980820f, 0.15275677f, 
    0.11542294f, -0.00939133f, -0.20381455f, -0.12207890f, 0.06670942f, -0.51508898f, 0.05964545f, 0.54205298f, 
    -0.02434397f, 0.05670944f, 0.02935989f, 0.15164037f, 0.03809875f, 0.00834388f, 0.40015709f, -0.30434787f, 
    0.11622962f, -0.06066994f, 0.03196619f, 0.09821225f, 0.17255716f, 0.00850225f, 0.01467286f, -0.40554258f, 
    -0.37222615f, 0.15353842f, 0.02812345f, -0.06577073f, 0.19573015f, 0.02146391f, -0.11111622f, -0.05448783f, 
    0.31183502f, 0.29075447f, 0.08449202f, 0.13307793f, -0.13712452f, 0.24232186f, -0.11140426f, 0.09594759f, 
    -0.13488048f, 0.09080528f, 0.14907466f, 0.10671497f, 0.13691048f, 0.10348356f, 0.04169802f, 0.26659372f, 
    0.16657375f, -0.02767462f, 0.03968212f, -0.01369139f, -0.01259921f, -0.25362509f, 0.07693374f, 0.08918431f, 
    -0.06427173f, -0.00002991f, -0.30901399f, -0.12200422f, 0.00991866f, -0.03806272f, 0.10933794f, 0.15671839f, 
    -0.00106779f, -0.10333888f, 0.06239503f, -0.03443195f, -0.18115006f, -0.33461213f, -0.05917704f, -0.06765510f, 
    -0.12718779f, 0.05507108f, -0.03381537f, -0.10439598f, -0.20549251f, 0.29507622f, -0.03875909f, -0.09725203f, 
    -0.10600970f, 0.05775004f, -0.17358029f, -0.25652331f, -0.11537364f, 0.10004300f, 0.30201405f, -0.17898552f, 
    -0.11219258f, -0.00937231f, -0.01343463f, 0.01841314f, -0.02965001f, 0.15377025f, 0.13027367f, 0.20430048f, 
    0.25025505f, 0.18599947f, 0.25390187f, 0.03810792f, 0.14886652f, -0.10363799f, 0.06973743f, -0.09486277f, 
    -0.03978495f, 0.00885999f, 0.00582060f, -0.08397502f, -0.14313838f, 0.01977544f, 0.00814048f, -0.00212890f, 
    -0.05491466f, -0.14064282f, -0.39572236f, -0.00984079f, -0.21018882f, 0.06201156f, 0.09441932f, -0.03658380f, 
    -0.12741059f, 0.06248754f, 0.28978261f, -0.19958071f, 0.05480734f, -0.01766090f, 0.08378945f, 0.20403209f, 
    -0.27992731f, -0.01397873f, -0.25406608f, -0.16197477f, -0.04778802f, 0.01377606f, -0.16822675f, 0.00355813f, 
    0.08453748f, 0.13157555f, 0.06780642f, 0.07479801f, 0.15605289f, 0.15256119f, 0.13556676f, 0.10676788f, 
    -0.10333567f, -0.04775886f, 0.06578189f, 0.04117092f, -0.02383902f, 0.20350438f, 0.20859982f, -0.06628666f, 
    0.11123830f, 0.22431402f, -0.02350884f, 0.11969846f, 0.07468347f, -0.15271407f, 0.01461414f, -0.14340861f, 
    0.06139354f, 0.06543796f, -0.03658180f, -0.19373907f, 0.09261541f, 0.09526190f, 0.02608999f, 0.05271878f, 
    0.16370089f, -0.06068544f, -0.03966812f, -0.00541900f, -0.06199112f, -0.03381620f, -0.01897900f, 0.02549377f, 
    -0.06535364f, 0.22984512f, -0.53192300f, -0.08861380f, -0.12138534f, 0.07931627f, -0.00249378f, -0.00093756f, 
    0.08400220f, -0.24516249f, -0.07176074f, -0.06648958f, -0.07657556f, -0.07281708f, -0.02401292f, -0.12246168f, 
    -0.07718411f, -0.03628296f, 0.34977496f, -0.11587980f, -0.06672793f, 0.00043114f, 0.10404798f, 0.09299354f, 
    -0.01377851f, 0.06075155f, 0.09201795f, -0.38458088f, 0.02922161f, -0.11241567f, 0.11198385f, 0.17866631f, 
    -0.05710172f, 0.01045499f, -0.05004766f, -0.18597017f, -0.04189575f, 0.06247828f, 0.00196448f, 0.08261324f, 
    0.07715654f, -0.14410388f, 0.01583940f, 0.05779684f, 0.00637806f, 0.16080447f, 0.15692827f, 0.16061354f, 
    0.05171337f, 0.04694573f, -0.13602526f, 0.02755939f, 0.08512454f, -0.09610992f, 0.25666758f, 0.06254853f, 
    0.10761533f, 0.07396027f, 0.25441313f, 0.01656132f, 0.01791547f, -0.02668340f, 0.11788014f, -0.14502467f, 
    -0.18679936f, -0.20073685f, -0.00249110f, -0.11658159f, -0.01798768f, -0.01781971f, 0.05002559f, 0.10663062f, 
    -0.33479574f, -0.27751800f, -0.13664243f, 0.13857825f, -0.23149604f, 0.06081412f, -0.03997687f, 0.07324391f, 
    -0.08823008f, 0.67228764f, -0.08883572f, 0.07413834f, 0.12703562f, -0.04310011f, -0.09585176f, 0.13552347f, 
    -0.08082982f, -0.01161103f, 0.23099522f, 0.02981111f, -0.10054899f, 0.26352379f, -0.10731664f, 0.19718975f, 
    -0.21404427f, -0.09340832f, -0.01965350f, 0.47379756f, 0.27054211f, 0.11029635f, -0.21238029f, -0.18269859f, 
    -0.03368700f, -0.01374388f, -0.04112114f, -0.15578410f, 0.21507153f, 0.13952152f, -0.35094473f, -0.16752079f, 
    0.10959106f, 0.00210629f, 0.00869617f, -0.11491221f, 0.03212935f, -0.03344740f, 0.12514643f, 0.04817257f, 
    -0.11445113f, 0.02050815f, -0.04876057f, -0.08458831f, -0.13709398f, -0.09095423f, -0.41558960f, -0.07285707f, 
    0.05641455f, 0.05786115f, 0.06979185f, 0.03757864f, -0.15654913f, 0.03430380f, 0.06135088f, 0.03113976f, 
    0.05210269f, 0.18355642f, 0.02181517f, 0.19119732f, 0.14010046f, -0.09259254f, 0.11706863f, -0.04642580f, 
    -0.05590064f, 0.01789124f, -0.06181195f, -0.06287921f, 0.03738945f, 0.02353170f, 0.07112294f, -0.04710088f, 
    -0.03603268f, -0.03881494f, -0.03938027f, 0.01681857f, -0.03272086f, 0.00586663f, 0.03514871f, -0.01529658f, 
    -0.04062377f, -0.08172924f, -0.01575742f, -0.00067542f, 0.01504461f, -0.05172496f, 0.03740261f, 0.02353242f, 
    -0.07378311f, -0.03236965f, -0.07576451f, 0.02128975f, -0.06604825f, 0.06510763f, 0.01748971f, 0.00978648f, 
    -0.04216722f, 0.03493878f, 0.03902831f, -0.05196417f, -0.04784425f, 0.06310061f, 0.05830116f, -0.06180117f, 
    -0.04480878f, -0.05972341f, 0.02414695f, 0.00512396f, 0.05820854f, -0.04118394f, -0.00404567f, -0.05975000f, 
    0.00590351f, 0.06147670f, -0.02832588f, -0.01065140f, -0.06344577f, -0.07809671f, -0.08062518f, -0.00990934f, 
    -0.07455964f, -0.00825839f, 0.07302465f, 0.03298863f, -0.05008634f, 0.02931818f, 0.00370515f, 0.06392453f, 
    0.02934525f, 0.01606889f, 0.00546018f, 0.01895185f, -0.08647072f, -0.03177475f, -0.03778685f, -0.02116757f, 
    0.00276083f, -0.06276421f, -0.06744725f, -0.05771253f, -0.06434143f, 0.01992062f, -0.04948604f, 0.02555978f, 
    -0.06317058f, 0.06191778f, 0.07399838f, 0.04982841f, 0.04540091f, -0.06407505f, -0.08497567f, -0.05271810f, 
    -0.05517469f, -0.02123842f, 0.05663442f, 0.02530281f, -0.06965436f, 0.06922749f, -0.01729210f, 0.01545096f, 
    -0.01867722f, -0.00599824f, 0.02152601f, -0.02159066f, 0.02550234f, -0.08684925f, 0.01494692f, 0.07297683f, 
    0.02754573f, 0.02054375f, -0.03820976f, -0.02682719f, -0.06324447f, -0.01551928f, -0.03273991f, -0.08266414f, 
    -0.00281214f, -0.04408125f, 0.01458226f, -0.05889735f, -0.06337326f, 0.07387636f, -0.07999342f, -0.00964914f, 
    0.04482384f, -0.00687217f, -0.03216017f, -0.01622120f, -0.06971440f, -0.08282416f, -0.02947014f, -0.08856947f, 
    -0.01469210f, 0.02807772f, -0.06811441f, 0.03529007f, -0.00700237f, -0.07367016f, -0.02646262f, 0.07790767f, 
    -0.02801863f, -0.04069589f, -0.08504190f, -0.07543401f, -0.06397811f, 0.00985499f, 0.05684687f, 0.00285090f, 
    -0.04667404f, 0.00897052f, -0.02631262f, 0.02179617f, -0.05842283f, -0.02789139f, -0.03291506f, 0.02092538f, 
    0.02650255f, -0.06483791f, 0.05787359f, 0.07608844f, -0.04020977f, 0.07768773f, -0.07724853f, -0.04673691f, 
    -0.06581441f, -0.08756331f, -0.06417512f, 0.06954759f, -0.06869566f, -0.03837942f, -0.04761158f, -0.07520959f, 
    -0.08505134f, -0.06114646f, -0.06966562f, 0.03001328f, -0.07473949f, 0.05267491f, -0.05830954f, -0.04148513f, 
    -0.00094327f, -0.05223867f, -0.08110758f, 0.02743725f, 0.00295717f, -0.02313969f, -0.01749934f, 0.00868163f, 
    -0.08706132f, 0.02389680f, 0.04382529f, 0.00482621f, -0.06125200f, -0.03429475f, 0.03695688f, -0.07131166f, 
    0.00655188f, -0.08364348f, -0.01950520f, 0.04606876f, -0.08279913f, -0.08171207f, -0.00718833f, -0.00788990f, 
    -0.01196720f, -0.01737058f, -0.06896669f, 0.04149006f, -0.00979395f, -0.02917826f, -0.05068915f, -0.02875553f, 
    -0.05045854f, 0.07366000f, 0.03291234f, -0.00666697f, -0.08364816f, -0.01848631f, -0.06048837f, 0.01881075f, 
    0.06379309f, 0.06754000f, 0.00131381f, 0.07454558f, 0.05787621f, -0.07897202f, -0.03478486f, -0.05334246f, 
    0.04238064f, -0.04858876f, 0.03908238f, 0.04360883f, -0.02687291f, -0.04417990f, -0.03014269f, -0.02479395f, 
    -0.07140753f, 0.06984882f, 0.04287705f, 0.03301980f, -0.04202330f, 0.03902023f, -0.05276735f, 0.00781812f, 
    0.00969907f, -0.04946598f, 0.02672780f, 0.05044238f, -0.08785383f, 0.00469651f, 0.04788065f, 0.06357057f, 
    0.03152164f, 0.05281140f, 0.05764572f, -0.07535567f, -0.02519657f, -0.01802430f, 0.06668478f, 0.05921058f, 
    0.05186814f, -0.05905164f, 0.04112897f, -0.05353836f, 0.03315769f, -0.00579755f, 0.02163909f, -0.01048575f, 
    0.04104758f, 0.04096676f, -0.07929615f, 0.01297284f, -0.02513952f, -0.04590418f, 0.04050699f, 0.00350051f, 
    0.01213980f, -0.05025397f, 0.03945140f, -0.07130710f, -0.05824869f, 0.06606423f, -0.06548712f, 0.07319281f, 
    -0.01236083f, -0.07423013f, -0.08850398f, -0.04986209f, -0.06658545f, -0.05459585f, 0.03186998f, -0.00174586f, 
    -0.19710924f, 0.40955067f, -0.00686325f, 0.01950314f, -0.10008477f, -0.06661316f, -0.15340051f, -0.04942765f, 
    0.02713973f, 0.01334578f, 0.35784602f, -0.04590246f, 0.03099605f, 0.04448164f, -0.01678567f, 0.02211037f, 
    -0.06673013f, -0.09745900f, -0.07281396f, -0.48256382f, -0.27567738f, -0.22806375f, 0.01935115f, -0.00815737f, 
    -0.04204158f, -0.11401824f, 0.14911917f, 0.30046389f, -0.00767053f, -0.12390468f, 0.07230552f, 0.30110493f, 
    -0.06928734f, 0.10623162f, 0.23869298f, -0.06086779f, -0.13902934f, -0.09527092f, -0.25050569f, -0.08463813f, 
    -0.17002898f, 0.04271593f, 0.07414789f, -0.06340362f, 0.00811788f, -0.59400362f, 0.14389285f, 0.21327297f, 
    0.13553619f, 0.06576528f, -0.05083407f, 0.06536480f, -0.04516483f, 0.05973851f, -0.12648259f, -0.05664646f, 
    -0.00093096f, 0.11122323f, -0.07396901f, 0.04862259f, 0.07080571f, -0.10436449f, 0.23378703f, -0.46617588f, 
    -0.27333170f, -0.25834960f, -0.08824202f, 0.01866521f, 0.09830738f, -0.02020776f, 0.10246187f, -0.06775460f, 
    -0.22899728f, 0.03295647f, -0.13135846f, -0.11469968f, 0.21257906f, -0.22750984f, -0.06467001f, -0.05645993f, 
    0.05579872f, 0.00484479f, -0.21686272f, 0.02277395f, 0.01848803f, -0.18528891f, 0.09556478f, 0.06198496f, 
    -0.09855895f, -0.02265990f, 0.20292433f, -0.55010700f, -0.04132805f, 0.07514457f, 0.02443539f, 0.12348889f, 
    0.16866304f, -0.17771386f, 0.06930500f, -0.04693514f, 0.06478462f, 0.17234448f, 0.09851927f, 0.03266761f, 
    -0.07412042f, -0.05067538f, -0.05858640f, 0.05172905f, 0.26537570f, -0.36493143f, -0.30993873f, 0.11662520f, 
    0.08621322f, 0.00003260f, 0.05366022f, -0.03877254f, 0.05306482f, 0.01580243f, 0.05341911f, -0.41992840f, 
    0.02765744f, 0.09567149f, 0.06486169f, 0.04505327f, 0.00885289f, 0.20762414f, 0.27996698f, 0.02464737f, 
    0.14965510f, -0.02114900f, 0.07347029f, -0.04866911f, -0.07087534f, 0.15996920f, -0.02122916f, 0.28011537f, 
    0.15273951f, 0.20937438f, -0.09690854f, -0.11220941f, -0.09971274f, 0.02625103f, 0.05741398f, -0.00030541f, 
    0.05028486f, 0.05988558f, -0.02743715f, 0.03018435f, 0.08269674f, -0.16663457f, -0.09536911f, 0.22720660f, 
    0.00758720f, 0.02264023f, -0.01993344f, -0.25039148f, 0.25674829f, 0.25496548f, -0.00304879f, -0.12659688f, 
    -0.18822847f, -0.14104150f, 0.22283916f, -0.01769802f, 0.20942841f, 0.20121959f, -0.21139085f, -0.28699294f, 
    0.14593714f, -0.18620804f, 0.00099311f, -0.08342698f, -0.00688325f, 0.23176001f, -0.15394919f, -0.02303066f, 
    0.03898167f, 0.00784545f, -0.13972925f, -0.14411011f, -0.01928523f, 0.14217857f, -0.01641296f, -0.03686013f, 
    0.19307126f, 0.10248623f, 0.15196152f, 0.04523677f, -0.14925840f, -0.35200956f, -0.18232347f, -0.27104330f, 
    0.03039400f, -0.17503917f, 0.15571341f, 0.06930820f, -0.00515776f, 0.14770773f, 0.00755083f, 0.22766778f, 
    -0.09799196f, 0.23014006f, -0.08242748f, -0.05771468f, 0.16931342f, 0.07479845f, 0.09394737f, -0.26448515f, 
    0.14095646f, 0.01837510f, -0.11016051f, 0.01227378f, -0.11043801f, -0.15779510f, -0.08907386f, 0.16599226f, 
    -0.52994812f, -0.27929711f, 0.05025226f, 0.16485997f, 0.14992629f, -0.12715945f, 0.00598340f, 0.05373162f, 
    0.12463677f, 0.33802119f, 0.34604415f, 0.06130598f, 0.08164244f, -0.03907659f, 0.09366740f, 0.15229987f, 
    -0.03877412f, 0.15378982f, 0.09579048f, 0.31881049f, -0.24847275f, 0.00881741f, -0.26814809f, -0.03642260f, 
    0.07721160f, -0.00563905f, 0.20303299f, -0.03046016f, -0.03531285f, 0.08621973f, 0.14681225f, 0.07761254f, 
    0.07845496f, 0.12434863f, -0.16637295f, 0.13728507f, -0.18486771f, 0.12181761f, -0.25854176f, -0.09024731f, 
    0.01201135f, 0.04990414f, -0.08818290f, 0.19777994f, -0.11021708f, -0.13040203f, 0.04442145f, -0.06365181f, 
    0.14201033f, -0.11770340f, 0.21300524f, 0.09894367f, 0.20240027f, -0.00588450f, -0.44141179f, -0.03306167f, 
    -0.03714012f, 0.19024225f, 0.09977505f, 0.12214586f, 0.07666803f, -0.00356801f, -0.12750289f, -0.32405075f, 
    -0.17990369f, -0.10455801f, 0.21872362f, -0.00004370f, -0.05271295f, 0.20694183f, -0.20200694f, -0.13662279f, 
    -0.12098876f, 0.17523257f, -0.08549947f, 0.02634002f, -0.04049876f, -0.07349997f, 0.03321023f, -0.20213279f, 
    -0.18376541f, 0.28578833f, 0.16670431f, -0.10705591f, -0.01009176f, 0.13435742f, 0.00019212f, -0.10108969f, 
    0.21657915f, -0.00188492f, 0.52424383f, -0.19361250f, -0.02695555f, 0.06363317f, -0.02454004f, 0.01246584f, 
    -0.15807168f, 0.01637590f, -0.02603978f, -0.04521861f, -0.04479135f, 0.06883342f, 0.03219724f, -0.00183405f, 
    -0.09804166f, 0.17220268f, -0.06909970f, -0.03586412f, -0.00542294f, -0.04988175f, 0.00519507f, -0.13750577f, 
    0.07145352f, 0.13286304f, 0.08237957f, 0.11685356f, 0.34727240f, -0.13282996f, 0.01880591f, 0.17978932f, 
    -0.04219861f, 0.05953929f, 0.00521983f, 0.00128563f, 0.06831674f, 0.07032817f, -0.14255838f, -0.80072546f, 
    -0.02189855f, 0.00229665f, 0.05814318f, -0.06986514f, 0.04751615f, -0.09833176f, -0.04805727f, 0.48302299f, 
    0.02377634f, -0.09667807f, -0.02454269f, 0.03992787f, -0.02821387f, 0.02460452f, -0.05572706f, -0.11531354f, 
    -0.31002769f, 0.07700203f, 0.14066930f, -0.30056500f, -0.37944987f, -0.20115080f, 0.15390955f, 0.06082624f, 
    0.07319716f, -0.27800709f, -0.27827522f, 0.00213390f, 0.09762881f, 0.14856292f, 0.06549501f, -0.05722363f, 
    -0.03123352f, -0.03269649f, 0.32741204f, 0.38262203f, -0.17297818f, -0.12105799f, -0.01868572f, 0.09441413f, 
    -0.01829902f, -0.15236263f, 0.01291092f, -0.70481986f, -0.42756942f, 0.01618508f, -0.00771050f, 0.14956045f, 
    0.12425227f, -0.05635899f, 0.09325533f, 0.07149675f, -0.17595103f, 0.10661494f, 0.06152399f, 0.11162534f, 
    0.08657538f, -0.07756843f, -0.10391901f, -0.13164544f, 0.00306202f, -0.05433257f, -0.07972712f, -0.04942560f, 
    -0.07807251f, 0.01097243f, 0.14400303f, -0.07948470f, 0.00612537f, 0.07882914f, 0.07782897f, 0.08414767f, 
    -0.18974158f, 0.01120021f, 0.16399266f, -0.08229519f, -0.02602962f, 0.14751601f, -0.00641295f, 0.04849488f, 
    -0.02972975f, 0.07842421f, 0.11330087f, -0.11515286f, -0.08787116f, 0.02288508f, 0.09834015f, 0.05377300f, 
    0.01687624f, 0.04763902f, -0.04950188f, 0.06587540f, -0.18502936f, -0.13175692f, -0.00754533f, -0.00450061f, 
    -0.02130454f, 0.04200447f, 0.21045852f, 0.21556926f, -0.17585187f, -0.00312219f, -0.28554723f, 0.08779685f, 
    0.10165535f, -0.22748648f, -0.03522009f, -0.22400451f, -0.24752630f, 0.11066972f, -0.02947506f, 0.08101957f, 
    -0.01972201f, 0.03387101f, -0.18964954f, -0.10100564f, 0.09879991f, 0.20272796f, -0.19896598f, -0.03527796f, 
    -0.23255976f, -0.09844851f, 0.12054276f, -0.04131950f, 0.25912026f, 0.03460159f, -0.32845926f, 0.14392032f, 
    0.06385644f, 0.01677106f, -0.02786843f, 0.10081957f, -0.05327232f, 0.24203795f, 0.26158139f, -0.36853519f, 
    0.25033140f, -0.10619553f, 0.01540749f, -0.00284080f, 0.17014761f, 0.06150052f, 0.22617124f, 0.04446377f, 
    -0.02950179f, 0.02666223f, 0.12574892f, -0.19567890f, 0.00460965f, 0.07388256f, 0.20316099f, -0.17184721f, 
    -0.07097302f, -0.06133102f, 0.09663070f, -0.00752517f, -0.03945590f, -0.01727454f, -0.10650309f, -0.17581373f, 
    0.00615694f, -0.08115181f, -0.03531974f, -0.23605828f, 0.26869231f, 0.08034006f, -0.06859859f, -0.03376446f, 
    0.19933106f, 0.09548349f, -0.15945387f, 0.03602365f, 0.02266937f, 0.02751078f, 0.16734749f, -0.20742302f, 
    0.09184807f, 0.06677950f, -0.03663116f, 0.05318261f, 0.17647029f, 0.16079110f, 0.18798561f, 0.02395272f, 
    0.00465516f, -0.09594417f, -0.11828303f, 0.29485521f, -0.07380230f, -0.06830849f, 0.11845385f, -0.13741601f, 
    -0.32603449f, 0.07672786f, 0.15348592f, 0.29373330f, -0.08768619f, -0.03266799f, 0.16085944f, -0.10251826f, 
    0.07309558f, 0.01124072f, 0.07631503f, -0.07713412f, -0.02805443f, 0.06968260f, 0.03826889f, -0.18384822f, 
    0.10428102f, -0.11918242f, -0.08769342f, 0.06054838f, 0.13731082f, 0.13079910f, 0.26996779f, 0.03548529f, 
    0.20163178f, 0.06669812f, -0.11433768f, -0.21146713f, 0.07036213f, -0.00247135f, 0.16145930f, 0.17142166f, 
    0.12306602f, 0.16719092f, 0.03826496f, -0.18098259f, -0.03787779f, 0.05860222f, -0.11861666f, 0.15101756f, 
    -0.26890016f, -0.43104291f, 0.29436710f, -0.09189011f, 0.11916091f, 0.12797768f, 0.02678573f, -0.03830269f, 
    0.10387676f, 0.22285427f, 0.25085327f, 0.11235400f, 0.05141193f, -0.02668494f, -0.09545898f, -0.09548330f, 
    0.00646130f, 0.15876938f, -0.03380308f, -0.60463166f, -0.17075081f, 0.04683981f, 0.08556656f, -0.00781180f, 
    -0.29196224f, 0.02913284f, -0.30607194f, 0.10293657f, 0.10776060f, 0.02712363f, 0.00684338f, 0.05722135f, 
    -0.03568343f, 0.04020474f, -0.05008657f, -0.19267642f, -0.01319998f, 0.14315329f, -0.27060100f, 0.03060684f, 
    0.06580408f, -0.14250451f, -0.04380153f, -0.06487265f, -0.04633193f, 0.03906321f, 0.15631914f, -0.01750765f, 
    0.14706868f, -0.04093352f, -0.04229434f, 0.05992191f, 0.02936202f, 0.11786827f, -0.46288255f, -0.04676231f, 
    -0.18438138f, 0.01346624f, 0.05381506f, 0.20971748f, -0.06052671f, 0.19727719f, 0.04550099f, 0.31054500f, 
    -0.06184150f, -0.17686383f, -0.03114763f, 0.01581395f, -0.04158532f, -0.03047726f, -0.02071070f, 0.07400029f, 
    0.35419706f, -0.01766499f, 0.02411212f, -0.09148865f, -0.21106747f, 0.00528017f, 0.03868458f, 0.11764333f, 
    -0.19323438f, -0.08458806f, 0.32640967f, -0.09737591f, -0.01833687f, 0.07541618f, -0.00056859f, 0.00986120f, 
    -0.04527544f, -0.14248560f, -0.06228253f, -0.06293822f, -0.02547015f, 0.02332671f, 0.15826762f, 0.07740921f, 
    -0.16252893f, 0.05039817f, -0.00159963f, -0.14649594f, -0.11809557f, -0.20482127f, -0.08301258f, 0.16756175f, 
    0.07080176f, -0.01834404f, 0.07113182f, 0.18843715f, 0.31591460f, -0.07428830f, -0.14480598f, 0.15919258f, 
    -0.04844599f, -0.02719002f, 0.03410839f, -0.04079943f, -0.05092696f, -0.15848118f, 0.03233000f, 0.06603714f, 
    -0.01148054f, -0.11551037f, -0.13051975f, 0.04760373f, 0.17963910f, -0.01961959f, -0.15439174f, -0.10483120f, 
    0.15291917f, -0.05500627f, -0.09736483f, 0.03017714f, 0.06667281f, 0.08976805f, -0.01426422f, 0.58023632f, 
    0.00726382f, 0.05896601f, -0.23189376f, 0.06115562f, -0.10592262f, 0.02358441f, -0.00188223f, 0.00616100f, 
    -0.21808633f, 0.02424264f, -0.46490738f, 0.06515688f, 0.04668837f, -0.03486116f, 0.06253513f, -0.20609036f, 
    0.02926363f, 0.15681475f, -0.31623048f, -0.16542996f, 0.01829138f, 0.14720738f, 0.21362351f, -0.04579593f, 
    0.00578180f, 0.20538382f, 0.35153690f, -0.05897089f, 0.19920622f, -0.03490929f, -0.08596771f, -0.10294977f, 
    -0.11540566f, 0.00003919f, -0.11499870f, 0.10643715f, 0.16445839f, -0.17015392f, 0.22365153f, -0.01279179f, 
    0.18204868f, -0.12931660f, -0.16300997f, -0.04106138f, -0.01687587f, 0.06445624f, 0.02272870f, -0.02889754f, 
    -0.02344840f, -0.00651618f, 0.00910003f, 0.15484905f, -0.08596601f, 0.02088387f, -0.12721209f, 0.12675504f, 
    0.02672089f, -0.00578481f, 0.16273957f, 0.12234988f, 0.01497890f, -0.11995552f, -0.03365166f, 0.07736421f, 
    0.08257087f, -0.05434987f, 0.06860294f, 0.01777859f, 0.15891831f, 0.08493396f, -0.00211282f, 0.27084553f, 
    0.13809407f, 0.04013690f, -0.22534168f, -0.29836485f, 0.00219431f, 0.09230679f, 0.03106654f, 0.10347175f, 
    0.31408724f, -0.07303684f, -0.19184744f, -0.01989639f, -0.09659638f, 0.01095439f, -0.20293862f, -0.05697936f, 
    -0.14133528f, -0.27192897f, 0.28393015f, -0.00273034f, -0.03203978f, -0.00775527f, -0.12599273f, 0.02122808f, 
    -0.10172582f, -0.08935530f, 0.03118122f, -0.08444386f, -0.04725423f, 0.05494761f, -0.12792020f, -0.27791986f, 
    0.16958943f, 0.16483033f, 0.03627430f, -0.38816947f, 0.12721586f, -0.19271860f, 0.11653577f, 0.05481214f, 
    0.16764086f, 0.05977483f, -0.03268256f, -0.10879955f, 0.04998413f, -0.20381455f, -0.34949079f, 0.02725556f, 
    0.15444562f, -0.09601389f, 0.06078324f, 0.19601615f, -0.06456124f, 0.14054933f, 0.13498251f, 0.24064018f, 
    -0.12584968f, 0.16349760f, 0.18384936f, -0.06424300f, -0.05684306f, 0.04317005f, -0.05823999f, 0.16919738f, 
    -0.02171111f, 0.13951783f, 0.08189056f, 0.15094456f, -0.05128895f, 0.00821764f, -0.14866528f, 0.01636004f, 
    -0.23394263f, 0.21255407f, 0.06360309f, -0.12025744f, 0.14415519f, -0.13679595f, 0.06229613f, -0.08841416f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.03663061f, -0.33419821f, 0.19490720f, 0.17106770f, 0.21768826f, 0.15394031f, -0.06669687f, -0.11290968f, 
    -0.00857800f, 0.02712045f, 0.08761781f, 0.22630090f, 0.03409139f, -0.01668843f, 0.07422178f, 0.23487020f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04501630f, -0.30798006f, 0.07043127f, 0.25710648f, -0.43167090f, -0.01947233f, 0.10591479f, 0.41125250f, 
    0.00437113f, -0.21075261f, 0.54497188f, 0.13407929f, -0.13890354f, 0.31690356f, 0.15693288f, -0.38001031f, 
    0.43134621f, -0.04418917f, 0.01370452f, 0.33927476f, -0.07012359f, -0.24018972f, -0.26135737f, -0.06011320f, 
    0.24105711f, 0.13258578f, 0.01724091f, 0.34724408f, 0.48509729f, -0.26962927f, -0.04106098f, 0.16017786f, 
    -0.10498220f, -0.11791154f, 0.33581614f, -0.30585986f, -0.07517157f, 0.11700170f, 0.48015025f, 0.12883666f, 
    0.14026684f, 0.06062418f, 0.11651908f, 0.45852077f, -0.45035702f, -0.11712231f, 0.10529085f, 0.10854891f, 
    0.27550730f, 0.35102561f, 0.38471434f, -0.41012973f, 0.30386096f, 0.07191033f, 0.18289624f, -0.54921728f, 
    0.11419761f, -0.14270067f, -0.03853219f, -0.21500376f, -0.05994786f, 0.07142539f, 0.16184373f, -0.08390561f, 
    -0.20294693f, 0.03487725f, 0.43216893f, -0.29328564f, 0.06286594f, 0.31509736f, 0.32530746f, -0.37519500f, 
    -0.08768917f, 0.16757798f, -0.02007431f, 0.37709624f, -0.21563467f, -0.08225422f, -0.12084480f, -0.18998997f, 
    0.17344417f, 0.40053067f, 0.65197712f, -0.26894331f, 0.13007103f, 0.37581345f, 0.25191805f, -0.13091120f, 
    0.19161989f, 0.13553083f, -0.48429057f, -0.26542369f, 0.13090657f, -0.03103513f, -0.26258174f, -0.07088850f, 
    0.42565209f, -0.02373025f, -0.00938312f, -0.05575578f, 0.13968810f, -0.12920856f, 0.06196740f, 0.26654598f, 
    -0.11537746f, -0.06353372f, -0.39378569f, 0.26129797f, 0.28827035f, -0.41409549f, -0.05597506f, 0.46626458f, 
    -0.29840183f, 0.20905074f, -0.17078614f, -0.09053095f, 0.03302117f, 0.23936588f, -0.32879466f, 0.27449808f, 
    0.07275626f, -0.20069352f, -0.09547120f, -0.41151154f, -0.71052933f, 0.38906232f, 0.19768214f, 0.28298092f, 
    0.08857156f, -0.72393507f, -0.00150683f, 0.24059005f, 0.20087221f, -0.26775420f, 0.16656868f, 0.18463735f, 
    -0.10162228f, 0.07211106f, 0.54891747f, -0.34654558f, -0.36858681f, 0.38238621f, 0.53184038f, -0.04152687f, 
    0.45045087f, -0.52190322f, -0.28456563f, 0.23728047f, 0.19578420f, -0.16508339f, 0.03825913f, 0.07632666f, 
    0.21878853f, -0.05614298f, -0.16703470f, 0.15116087f, 0.33944488f, -0.27704260f, 0.20246580f, 0.15241760f, 
    0.41547126f, -0.17645480f, 0.41909316f, -0.18867147f, 0.48821655f, -0.19398604f, -0.05612326f, -0.32229322f, 
    0.00789847f, -0.23849837f, -0.39380038f, 0.29409030f, 0.24861874f, -0.31363761f, -0.22756639f, 0.50654978f, 
    0.42591459f, 0.02384749f, 0.06925351f, -0.20734961f, 0.17881468f, 0.09214515f, 0.27735072f, -0.36212021f, 
    0.14551610f, 0.24988239f, -0.35674858f, -0.03100914f, -0.44516420f, -0.01677332f, -0.20500410f, 0.23940791f, 
    0.27440271f, -0.65697938f, 0.15365486f, 0.23935509f, -0.09341799f, -0.12323835f, 0.00365176f, -0.36196133f, 
    0.16329710f, -0.04959851f, 0.52243012f, -0.14100419f, 0.37916839f, 0.45215040f, 0.14423700f, -0.14135727f, 
    0.34730911f, -0.09457964f, -0.37443659f, 0.60407901f, 0.38452584f, -0.26710045f, -0.32223403f, -0.21751966f, 
    -0.21540600f, 0.12386391f, -0.43772098f, 0.20704599f, -0.03939765f, 0.13511452f, 0.38776118f, 0.42802119f, 
    0.41304928f, -0.61405843f, 0.31948569f, 0.14762187f, 0.20573741f, -0.27859560f, 0.08293120f, 0.02602070f, 
    0.23607418f, 0.01684578f, 0.15878643f, 0.00675305f, -0.43270028f, -0.29315037f, 0.27806839f, 0.12236047f, 
    0.17130321f, 0.21751426f, 0.28645426f, 0.13056746f, 0.23440874f, -0.05674297f, -0.25368160f, -0.23358929f, 
    -0.10873627f, 0.17137939f, -0.47839120f, 0.05487235f, -0.12097199f, -0.02200421f, 0.41125050f, 0.04797681f, 
    0.27674553f, 0.00547413f, 0.08237483f, -0.06509590f, 0.45328435f, -0.15047720f, -0.06645618f, -0.19697252f, 
    -0.16927797f, 0.04683785f, -0.17290317f, -0.23475416f, 0.17429177f, -0.11509065f, 0.43366987f, 0.40248165f, 
    -0.06286220f, 0.41309580f, -0.20426071f, -0.03611057f, -0.15951250f, -0.12509416f, 0.19501632f, 0.38616359f, 
    0.11509851f, -0.19988570f, -0.57473922f, 0.49276242f, -0.45556515f, 0.01775577f, -0.10373964f, 0.26148108f, 
    -0.06850779f, -0.26882896f, -0.02192505f, 0.11157624f, 0.07260457f, -0.08018572f, -0.27628371f, -0.01663764f, 
    0.00067443f, 0.00469464f, -0.23621351f, -0.24505444f, 0.04824981f, -0.11256423f, 0.14890353f, -0.08085510f, 
    0.09219479f, 0.52776772f, 0.23116149f, 0.02505836f, 0.41507989f, -0.02382406f, 0.36542735f, -0.74515623f, 
    0.05788863f, -0.04429859f, -0.56114721f, -0.21034898f, 0.13152471f, 0.15684722f, 0.14757235f, -0.44206119f, 
    -0.14141321f, -0.43353069f, -0.17875303f, 0.04433205f, 0.13652290f, 0.33256945f, -0.18933868f, 0.57547414f, 
    0.02990291f, -0.22029395f, 0.09223922f, -0.29878163f, 0.46149385f, 0.01275971f, 0.37386060f, -0.12684128f, 
    0.25669935f, -0.10563175f, -0.25454062f, 0.43239209f, -0.09261046f, 0.07028644f, 0.35197502f, 0.37166986f, 
    -0.24846911f, -0.14360690f, 0.76645839f, 0.00955638f, -0.05324212f, 0.07249439f, -0.31067711f, -0.12437725f, 
    -0.14286950f, -0.30514207f, -0.11767569f, 0.34843707f, -0.47150734f, 0.12113031f, 0.23730265f, 0.33232394f, 
    -0.08563355f, -0.22385311f, 0.75734937f, 0.16364409f, 0.19286966f, 0.15279432f, 0.05686678f, -0.25089550f, 
    -0.28614095f, -0.06119305f, 0.15580940f, -0.20836630f, -0.05180391f, 0.41324052f, 0.13089213f, 0.12031545f, 
    0.23807092f, 0.21455243f, 0.40302634f, 0.24542955f, 0.10812328f, 0.19096488f, -0.44325709f, -0.52439594f, 
    -0.02018767f, -0.17593661f, -0.26153183f, -0.19558188f, -0.34047797f, 0.00665450f, 0.36854997f, -0.04153900f, 
    0.11923406f, -0.10360256f, 0.58862758f, 0.24504361f, -0.40449488f, 0.43898818f, -0.01488066f, 0.02955834f, 
    0.24414118f, -0.24160099f, -0.20729141f, 0.60182995f, -0.18502878f, -0.27551034f, 0.33894792f, 0.51760274f, 
    -0.03615680f, -0.16662201f, -0.28522003f, 0.24304746f, -0.02829769f, -0.12680395f, 0.35128120f, 0.07565103f, 
    0.07885636f, 0.16224599f, -0.34118244f, 0.58435380f, -0.27829260f, -0.25222796f, -0.22820187f, 0.12929896f, 
    0.15097253f, -0.14112416f, 0.33210155f, 0.09026984f, 0.41262355f, 0.34879169f, -0.03710910f, 0.13337468f, 
    -0.20995504f, 0.16264246f, 0.26934543f, 0.25216737f, -0.02317832f, -0.22840744f, -0.02145337f, 0.00666794f, 
    -0.23257801f, -0.15732765f, 0.62026721f, -0.19299781f, -0.25113168f, 0.01492544f, 0.46413773f, -0.40981895f, 
    0.04035932f, -0.06177235f, 0.44443437f, -0.42310548f, -0.26165065f, 0.53147477f, 0.09484947f, 0.24539015f, 
    -0.23467483f, -0.07218543f, -0.02881495f, 0.33857352f, 0.09412137f, -0.11704274f, -0.51908243f, -0.29811326f, 
    0.03661840f, 0.44392356f, 0.49882978f, -0.42469311f, 0.21561705f, 0.35608369f, 0.21209249f, -0.52354103f, 
    -0.06747384f, 0.17084303f, -0.15532222f, -0.16890170f, 0.28726929f, -0.16238426f, 0.20101853f, -0.25637150f, 
    -0.39783219f, 0.20060396f, 0.40613395f, 0.22014353f, 0.15493414f, -0.34236723f, -0.13506736f, 0.24800079f, 
    -0.05555341f, -0.03012077f, -0.47112009f, -0.25674585f, 0.09204303f, -0.20390412f, -0.12516569f, 0.29229739f, 
    0.42324898f, 0.29276124f, -0.48627782f, 0.33186251f, 0.31047454f, -0.22530895f, -0.13799897f, -0.38540071f, 
    -0.04676116f, 0.08935956f, 0.08935371f, -0.19444069f, 0.21108173f, 0.26620826f, 0.21542482f, 0.35676724f, 
    -0.23039374f, 0.49951723f, 0.16409105f, 0.37961566f, 0.19687247f, -0.11226720f, -0.37075350f, 0.27042058f, 
    -0.16842449f, -0.12231460f, -0.52192241f, 0.10055792f, -0.35588351f, -0.05994521f, 0.47614199f, 0.27314267f, 
    0.16853136f, -0.30198082f, -0.49873421f, 0.13705891f, 0.24756770f, -0.03084413f, -0.16445933f, 0.70528483f, 
    0.12763011f, -0.03133875f, -0.11596413f, -0.02176711f, 0.23581648f, -0.08920595f, 0.38302144f, 0.23015431f, 
    -0.57601529f, -0.14712833f, -0.13831195f, -0.12370268f, 0.59552318f, 0.12754209f, -0.46378192f, 0.62086052f, 
    0.22793905f, 0.19961290f, -0.38091573f, 0.28595224f, 0.16134585f, -0.09542730f, -0.09799688f, 0.28394508f, 
    0.20018397f, -0.31483072f, 0.07667933f, -0.18893372f, 0.01846832f, 0.30295703f, 0.13104257f, 0.43711954f, 
    -0.06296480f, 0.14290413f, 0.63010371f, -0.19070260f, 0.24119569f, 0.04742919f, 0.26192084f, -0.24769109f, 
    0.16437827f, -0.32890874f, 0.04353973f, -0.05819424f, -0.09594154f, -0.04954827f, 0.52188653f, 0.01742219f, 
    0.12158168f, -0.14415981f, 0.55648845f, 0.33538333f, -0.00666609f, -0.21995379f, -0.32873988f, 0.12353952f, 
    0.41982767f, -0.58887845f, -0.06556336f, -0.58152026f, -0.30267411f, -0.22581638f, -0.23320550f, 0.30727580f, 
    0.03627920f, 0.04110613f, 0.33372080f, 0.48630121f, 0.19907646f, 0.15224323f, -0.18944257f, -0.12852390f, 
    -0.32398131f, -0.67401958f, -0.11130165f, 0.39585006f, -0.04036834f, -0.03593742f, -0.02451703f, 0.14342523f, 
    -0.09925248f, -0.17351668f, -0.53941196f, 0.12224917f, 0.15474382f, 0.17055559f, 0.21377487f, 0.38836956f, 
    0.17488755f, 0.31125879f, -0.43768540f, -0.00417644f, 0.19581778f, 0.08016448f, -0.07442569f, 0.13635170f, 
    0.08600071f, -0.13656312f, -0.23453401f, -0.27968997f, 0.08850437f, 0.03977682f, 0.63033563f, 0.01310583f, 
    0.02344235f, 0.38708252f, -0.21185790f, 0.60396874f, 0.20804451f, -0.26058227f, 0.03295911f, 0.01850613f, 
    0.16787924f, -0.12087108f, 0.15625504f, 0.07916502f, 0.45803890f, -0.07659025f, -0.32741678f, 0.29726660f, 
    -0.17163222f, 0.01917668f, -0.15692224f, 0.15123272f, -0.31683600f, 0.02526993f, 0.07800171f, -0.14979184f, 
    0.19246140f, -0.19818403f, 0.20284502f, -0.24388489f, -0.26723635f, 0.15911987f, -0.35668629f, -0.05579785f, 
    -0.41979194f, -0.43531981f, -0.03387269f, 0.42711934f, -0.22826535f, -0.12277680f, 0.20129339f, 0.13817312f, 
    -0.09317538f, -0.11717719f, -0.16075307f, 0.36030197f, -0.15886015f, 0.11180360f, 0.11462891f, 0.15449800f, 
    0.46521139f, 0.28864640f, -0.44903532f, 0.52015758f, 0.19232993f, 0.23118921f, 0.19515562f, -0.59556144f, 
    0.05482882f, -0.10653404f, 0.17173032f, -0.27402094f, 0.33653075f, -0.13577352f, 0.00137174f, -0.14401910f, 
    -0.04912538f, 0.20810473f, -0.21821770f, -0.07414812f, 0.22609751f, 0.35341403f, 0.17184982f, -0.73781288f, 
    -0.06117398f, -0.12777470f, -0.50486076f, -0.12473464f, 0.12303901f, 0.08701497f, -0.24102274f, 0.46483913f, 
    -0.21302404f, 0.15593350f, 0.06082968f, 0.17149742f, -0.05806993f, -0.18916236f, 0.39934948f, -0.00907117f, 
    0.10105439f, -0.03424361f, 0.63382524f, 0.24673012f, -0.25738257f, 0.33512896f, -0.33525550f, -0.32129148f, 
    -0.23679569f, 0.55777144f, -0.02523762f, 0.30396342f, -0.05935068f, 0.14907241f, -0.25405580f, -0.39947429f, 
    0.02914509f, -0.17792186f, 0.05968475f, 0.15719086f, -0.15825699f, 0.42390868f, 0.11750196f, -0.17562103f, 
    0.12848434f, 0.17132743f, -0.04985628f, 0.40098792f, -0.24299221f, -0.04773339f, -0.11845063f, 0.53853506f, 
    -0.17352296f, 0.08355741f, 0.18733910f, 0.30711070f, 0.18784952f, -0.24425714f, -0.36534470f, 0.30668351f, 
    -0.09322115f, 0.62648940f, -0.26495409f, -0.26148129f, 0.03600557f, -0.29489473f, 0.33227855f, -0.06055942f, 
    0.07998395f, 0.06214257f, 0.26898232f, -0.21107891f, 0.50218207f, -0.31922454f, 0.31335619f, -0.06383140f, 
    0.19730552f, -0.33682039f, 0.18275934f, 0.36087298f, -0.32431599f, -0.16504627f, 0.37519085f, 0.31583226f, 
    0.20861584f, -0.18970926f, -0.16008680f, 0.35581774f, 0.30501840f, -0.39542836f, -0.03610260f, 0.13051426f, 
    0.00177670f, -0.40911210f, -0.11908336f, 0.43942589f, -0.29154193f, 0.31911731f, 0.09291437f, 0.52281141f, 
    -0.05965850f, -0.04572009f, 0.08270857f, 0.39083660f, -0.15927488f, -0.16580686f, -0.31221837f, 0.17110442f, 
    -0.04660008f, 0.08132292f, 0.26288438f, 0.31581807f, -0.01940347f, -0.25350428f, 0.33537894f, 0.45388481f, 
    -0.11808111f, 0.01291544f, -0.21810246f, 0.22797829f, 0.30232617f, -0.48392212f, -0.01049398f, 0.31960443f, 
    0.39618737f, -0.47182447f, 0.39966628f, 0.19984150f, -0.20956138f, -0.20763059f, 0.45509091f, 0.10189158f, 
    0.06742151f, 0.19602403f, 0.57448316f, 0.02016846f, 0.25503212f, -0.26512972f, -0.10065133f, -0.11284386f, 
    -0.05349616f, -0.13329995f, -0.17912626f, -0.05931892f, -0.23363380f, 0.11568154f, -0.13843834f, 0.06629474f, 
    -0.14086971f, -0.20114055f, 0.10865480f, -0.23698802f, -0.19434628f, -0.24692103f, 0.12018047f, -0.00192615f, 
    -0.28888729f, 0.32310155f, 0.35246316f, 0.04948939f, -0.15334108f, 0.15246047f, 0.14506327f, -0.31520706f, 
    -0.03801773f, 0.13542986f, 0.42830238f, 0.12907054f, -0.32373706f, 0.43207815f, -0.31885377f, -0.41130579f, 
    -0.23005615f, -0.56359160f, -0.41094041f, 0.52270120f, -0.03118430f, -0.06655190f, 0.16086295f, 0.18383799f, 
    -0.02577949f, 0.11481375f, 0.40129569f, 0.29710242f, -0.25571197f, 0.28687316f, 0.34355021f, 0.13854095f, 
    -0.49672025f, 0.39796317f, 0.26027760f, -0.31959301f, 0.37559482f, 0.08740066f, -0.03526701f, 0.01150817f, 
    -0.07968265f, 0.11474544f, -0.36279452f, 0.42416012f, -0.52836388f, -0.18593237f, -0.09234867f, 0.42478609f, 
    -0.14230493f, -0.48634201f, -0.11201105f, -0.10818033f, -0.09122166f, 0.16047192f, 0.06161539f, -0.30261457f, 
    -0.05515696f, 0.09157849f, 0.00693912f, 0.28178695f, -0.23215793f, 0.57277822f, 0.02452222f, -0.03547880f, 
    0.14523239f, 0.20128383f, 0.01950188f, 0.02375136f, -0.11847979f, -0.08992954f, -0.25811014f, -0.21241559f, 
    0.15746367f, 0.09441775f, 0.55613494f, 0.24409111f, 0.44172639f, -0.19753850f, 0.00150406f, 0.02483309f, 
    0.51181060f, 0.04388844f, -0.21846254f, -0.11513223f, 0.09226058f, -0.09434179f, 0.30601090f, 0.01095926f, 
    0.24715990f, -0.07348570f, 0.59009296f, -0.01173427f, -0.90481049f, 0.20885646f, 0.24407135f, 0.01092277f, 
    -0.01515482f, -0.64379138f, -0.09602901f, 0.13327903f, 0.02989338f, -0.20301118f, 0.29640943f, 0.41668770f, 
    -0.10140900f, 0.01335547f, 0.49462157f, 0.26723433f, 0.09447667f, -0.20739838f, 0.36645052f, -0.07568611f, 
    0.23479074f, -0.08812193f, -0.69545496f, -0.22952068f, 0.04446954f, 0.13404919f, 0.10068906f, 0.60567790f, 
    -0.20127344f, -0.17414814f, 0.37081581f, 0.02526543f, -0.05960202f, 0.30277255f, -0.21945533f, -0.37409806f, 
    -0.19997758f, 0.16815950f, -0.22741346f, -0.12254517f, -0.22526842f, 0.43586913f, 0.19749327f, -0.08220492f, 
    -0.02721809f, 0.01433330f, 0.55082458f, -0.32163832f, 0.01573094f, 0.16200557f, 0.33196154f, -0.24956928f, 
    0.17863266f, 0.11668283f, -0.13128126f, -0.27648637f, -0.00207814f, 0.36928260f, -0.02870308f, 0.11617141f, 
    0.18743308f, 0.20165551f, -0.01981390f, 0.43789923f, -0.37059548f, 0.26976395f, -0.41832319f, 0.14620106f, 
    0.19103745f, -0.25567186f, -0.07418495f, -0.15588796f, -0.21952707f, -0.05304926f, 0.08525054f, -0.62404466f, 
    -0.01603999f, -0.24181554f, 0.13983743f, -0.14127713f, 0.41861784f, -0.14500616f, -0.54009169f, 0.49258813f, 
    0.07531763f, 0.12336057f, -0.04447379f, -0.15200448f, -0.10528564f, -0.06209495f, -0.03784649f, 0.08173851f, 
    -0.16279888f, -0.01824263f, -0.01000843f, -0.04824712f, -0.02894824f, -0.23595563f, -0.01030737f, -0.17082819f, 
    -0.07775888f, -0.06718063f, -0.14074084f, -0.01316149f, 0.02062907f, -0.25136420f, -0.21433288f, -0.03309983f, 
    0.23454681f, 0.17912164f, -0.07711637f, -0.06988031f, 0.07906067f, -0.11567162f, -0.16853279f, 0.13872580f, 
    -0.40595379f, -0.57612216f, -0.24121544f, 0.03278358f, 0.24676979f, -0.20890358f, 0.25800660f, 0.24431698f, 
    -0.03836623f, 0.06963861f, -0.20466371f, 0.41191426f, 0.17763600f, -0.44147256f, 0.20049430f, 0.11115967f, 
    0.40589571f, -0.57146853f, -0.40489733f, 0.53704035f, -0.32659197f, -0.21189059f, 0.08355352f, -0.36705256f, 
    0.04030892f, 0.09749143f, 0.22481595f, 0.34871298f, -0.03741218f, 0.20082113f, 0.11758585f, -0.09936805f, 
    -0.22520189f, 0.28105471f, 0.38440990f, -0.50519401f, -0.33539870f, 0.39458492f, 0.38887173f, 0.42883402f, 
    -0.22667049f, 0.02389473f, -0.07052136f, 0.00752420f, -0.16853452f, 0.19965154f, -0.47234997f, -0.36147207f, 
    0.28904182f, 0.63658476f, -0.38780385f, -0.07370459f, -0.26781556f, -0.64035010f, 0.11374875f, -0.42308235f, 
    -0.02660018f, -0.02253842f, 0.99196112f, 0.17105688f, -0.12539183f, 0.12008012f, 0.46619180f, -0.02843947f, 
    -0.04879556f, -0.06444545f, 0.24275261f, -0.07385674f, 0.08293733f, -0.15457869f, 0.04396466f, -0.00678704f, 
    0.10787784f, 0.19368833f, -0.09089506f, -0.02897151f, 0.55338478f, 0.29975772f, -0.27540606f, -0.28730831f, 
    -0.10719868f, -0.21790226f, -0.30772936f, 0.37684011f, -0.32847485f, 0.29076129f, 0.18998964f, -0.04695377f, 
    -0.24065739f, -0.19948754f, 0.28022894f, 0.09594303f, 0.41408977f, 0.30031928f, -0.16350132f, 0.07331708f, 
    -0.20033081f, -0.06650216f, 0.40654102f, -0.38821259f, 0.05749220f, 0.08724838f, -0.03753157f, -0.51074129f, 
    0.11809168f, 0.21142676f, 0.19359490f, 0.34144619f, -0.02423204f, 0.39511693f, -0.25780404f, -0.05748852f, 
    -0.38465324f, -0.28788880f, 0.29556474f, -0.01367826f, -0.24740638f, 0.37381738f, 0.22866072f, 0.01219624f, 
    -0.06805661f, 0.16393563f, -0.14669110f, -0.09138902f, -0.36325979f, 0.33216140f, -0.06754737f, 0.16093574f, 
    0.01993053f, 0.40849924f, 0.10404426f, -0.08199044f, 0.47421956f, -0.08708770f, 0.26630470f, 0.56361508f, 
    -0.15912955f, 0.04204969f, -0.19054787f, 0.01147392f, 0.22267361f, -0.48800519f, -0.55397236f, 0.16480744f, 
    -0.36372766f, 0.46846527f, -0.27004465f, 0.32940033f, -0.09190495f, -0.19071987f, 0.56300795f, -0.23865461f, 
    0.02670738f, -0.08963650f, -0.73710871f, 0.13619746f, 0.09041370f, 0.13946922f, -0.04425168f, -0.30448478f, 
    0.05349632f, 0.38940158f, 0.52292740f, -0.29166588f, 0.13904831f, 0.15356334f, 0.35504603f, -0.70235169f, 
    0.03517571f, 0.21048602f, -0.27224010f, 0.22093832f, -0.15970795f, -0.10361072f, 0.01173985f, -0.25241193f, 
    0.07974858f, -0.49235433f, -0.13258000f, -0.26319629f, 0.06999941f, 0.35992664f, 0.04151268f, 0.23360728f, 
    0.02422854f, -0.05768204f, 0.09349486f, 0.08492312f, -0.23601778f, -0.11096560f, 0.07242308f, 0.49239734f, 
    -0.09025563f, -0.19294375f, -0.80836648f, -0.11895175f, 0.51453388f, 0.25295967f, 0.02924025f, 0.01376344f, 
    -0.07278615f, 0.23339607f, 0.02450791f, 0.10068195f, 0.16381423f, -0.25335792f, 0.12628241f, 0.29663566f, 
    0.23959550f, 0.47785446f, 0.11425329f, -0.00703457f, 0.33866352f, -0.23929702f, 0.05839054f, -0.27624655f, 
    -0.12499271f, 0.05575770f, -0.20003203f, 0.37870395f, -0.17576705f, -0.11317705f, -0.47421917f, 0.33564502f, 
    -0.24909039f, 0.23930214f, 0.25802109f, -0.30594999f, 0.04514036f, 0.41736406f, -0.11068472f, -0.02520430f, 
    0.19946060f, 0.15296391f, -0.40076461f, 0.42790884f, -0.09135954f, -0.31721404f, 0.10832998f, 0.41989920f, 
    0.16555606f, 0.40574586f, -0.34897161f, 0.46958050f, 0.34593901f, 0.19571869f, 0.14125805f, -0.09264478f, 
    -0.00140577f, -0.08034601f, -0.36515602f, 0.19689600f, 0.50582767f, -0.23610374f, -0.21457566f, 0.13305534f, 
    0.27936444f, 0.28232715f, -0.42550740f, 0.26131779f, -0.09610022f, -0.03614643f, 0.18988313f, 0.44272581f, 
    -0.02404970f, 0.17535852f, 0.12931190f, -0.11982243f, 0.29564393f, -0.01215751f, -0.03776493f, 0.26466268f, 
    0.06246448f, 0.49319589f, 0.27968517f, 0.18810718f, 0.39274508f, -0.01569711f, 0.04424811f, 0.15398380f, 
    -0.21640879f, 0.16816902f, -0.49617478f, 0.03772988f, 0.48257011f, -0.14247866f, -0.36074397f, 0.14700420f, 
    -0.40029469f, -0.16542427f, -0.12769727f, -0.14840558f, -0.16695692f, 0.29378998f, -0.02792619f, 0.34471607f, 
    -0.11336029f, -0.04253557f, 0.36204654f, 0.05670897f, -0.22362509f, 0.35548589f, 0.35013095f, -0.00093326f, 
    -0.00906653f, 0.04380623f, 0.29825848f, -0.03958158f, -0.22295444f, -0.14210938f, 0.04872487f, 0.15819505f, 
    0.11928767f, 0.04742917f, 0.14228174f, -0.34128326f, -0.00556498f, 0.32667109f, -0.18151511f, -0.00850902f, 
    -0.23033974f, -0.69891334f, 0.28022772f, 0.01082208f, -0.45982233f, -0.03750251f, -0.36513540f, 0.41755286f, 
    0.11835399f, 0.22422208f, 0.61640429f, -0.17639086f, -0.26885366f, 0.06889470f, 0.46889696f, 0.31636563f, 
    -0.44533741f, -0.18049109f, -0.04592328f, 0.04722391f, 0.34546906f, 0.56314188f, -0.11958896f, -0.38799393f, 
    0.23603645f, 0.20495158f, -0.53213608f, 0.01740035f, -0.24798407f, 0.13906641f, -0.28035346f, -0.14251453f, 
    0.34879261f, 0.75398219f, 0.50191987f, -0.33430988f, 0.32743958f, -0.03809957f, 0.00669327f, -0.43393669f, 
    -0.10501882f, -0.10314775f, -0.15058938f, 0.14271484f, -0.37435344f, 0.18895018f, 0.16033679f, -0.01581667f, 
    0.19473587f, 0.24052858f, -0.25499034f, -0.31627533f, 0.31545681f, 0.49604976f, -0.25070670f, -0.14384322f, 
    -0.14020750f, 0.23936167f, -0.36934409f, -0.10480521f, -0.38003999f, 0.03985836f, 0.18020625f, 0.20496441f, 
    -0.19853424f, -0.01007927f, 0.13795702f, -0.25839064f, -0.24156667f, 0.44416642f, 0.02401926f, 0.33478069f, 
    0.08494063f, 0.12585565f, 0.26300782f, 0.32126522f, -0.11965340f, 0.30620378f, -0.04797541f, -0.10048404f, 
    -0.66444528f, -0.38498357f, 0.00789732f, 0.08214621f, -0.08212499f, 0.37062934f, -0.06996372f, 0.30422351f, 
    -0.05978824f, -0.23110369f, 0.33999673f, -0.11504459f, 0.14244649f, 0.33031899f, 0.01945774f, -0.27876639f, 
    -0.21039440f, -0.23664440f, -0.13928539f, 0.03620520f, -0.03558531f, -0.04529006f, -0.02372673f, 0.00373323f, 
    0.11478865f, -0.17470849f, 0.18702704f, -0.23419911f, -0.22988896f, 0.07227916f, -0.08913486f, -0.01101268f, 
    0.34799206f, 0.06377492f, -0.05010519f, 0.47716650f, 0.38754025f, -0.48471865f, -0.16755344f, -0.20934483f, 
    0.11890797f, 0.09535421f, 0.10049916f, 0.03582763f, -0.00783082f, 0.07796124f, 0.21255064f, 0.12230008f, 
    -0.30859336f, -0.03338495f, -0.03481308f, -0.20608130f, -0.02796034f, -0.05231589f, -0.12571009f, -0.05597538f, 
    0.03350478f, -0.00021362f, -0.21381842f, -0.06619225f, -0.17541026f, -0.22362812f, 0.13646497f, 0.15372966f, 
    0.26068178f, 0.01831213f, -0.56999564f, 0.55125248f, -0.10747435f, 0.02040750f, -0.17188229f, 0.12242077f, 
    0.04312862f, -0.22354993f, -0.03017203f, -0.28725958f, 0.32405490f, 0.13211919f, 0.51267421f, 0.16629913f, 
    -0.15552771f, 0.25039566f, -0.08255513f, -0.34750086f, 0.35731205f, 0.26286745f, -0.12977865f, 0.06863236f, 
    -0.02831116f, -0.20267509f, -0.52033138f, 0.04890803f, 0.20908511f, -0.40621823f, 0.04937024f, 0.55703789f, 
    0.45372230f, 0.39555633f, 0.05780854f, -0.14853050f, 0.41465545f, -0.08459271f, 0.17489208f, -0.14058289f, 
    0.02034882f, 0.02966138f, 0.23072830f, -0.34684402f, 0.40060383f, -0.14815804f, 0.39429268f, -0.32133338f, 
    0.23481888f, -0.53163332f, 0.30292869f, 0.14825274f, 0.38519791f, -0.02557887f, -0.14575696f, -0.23055436f, 
    -0.19045348f, -0.19990885f, -0.39949450f, -0.08315625f, -0.12190269f, -0.10374058f, 0.22236039f, 0.46432224f, 
    -0.06953982f, 0.02916166f, -0.11035189f, 0.06864464f, -0.04397184f, -0.15968359f, -0.24816298f, 0.09207428f, 
    -0.20245138f, 0.16134021f, -0.06139371f, -0.12630361f, 0.01544961f, -0.11391613f, 0.11510181f, -0.11456901f, 
    -0.10303302f, -0.40292442f, 0.41245258f, 0.07004017f, -0.00055280f, 0.32248965f, -0.29889771f, 0.47008681f, 
    -0.17108351f, 0.01214859f, 0.16052906f, -0.25471866f, -0.08366879f, 0.08071818f, 0.50743502f, -0.21807532f, 
    0.40652400f, 0.44291005f, 0.23626091f, 0.00793948f, 0.11066227f, 0.07812200f, 0.21375537f, -0.38663673f, 
    -0.18516108f, -0.14768574f, -0.22829162f, -0.00717953f, 0.03228603f, 0.05502385f, -0.31077033f, -0.08457378f, 
    0.65776950f, -0.10670523f, 0.19846849f, 0.15868936f, 0.47102916f, -0.14348854f, 0.32709152f, -0.40345851f, 
    -0.07450745f, 0.04678187f, 0.21591255f, -0.24959742f, 0.15877274f, -0.20144777f, 0.00602232f, -0.31505948f, 
    0.44735950f, -0.10902800f, -0.50363785f, -0.26610142f, 0.11262526f, 0.35477379f, -0.17854810f, -0.01371663f, 
    -0.18760249f, -0.05953851f, -0.40505168f, 0.39838728f, 0.14516199f, -0.25523862f, -0.06516488f, 0.18128812f, 
    0.35023713f, -0.87238783f, 0.38599268f, -0.22535491f, 0.09871283f, -0.27592960f, 0.31841519f, -0.06016444f, 
    0.10786852f, 0.18735157f, 0.33751881f, 0.01207564f, 0.35149983f, -0.04285364f, 0.30546203f, 0.08291018f, 
    -0.25477299f, 0.45381424f, 0.00103237f, 0.06827641f, 0.04134287f, -0.24671382f, -0.45539743f, 0.09618430f, 
    -0.20408729f, 0.03271443f, -0.45135736f, -0.04640814f, 0.00117363f, 0.34606594f, 0.27993420f, 0.14904436f, 
    0.04518663f, 0.40312910f, -0.57433581f, -0.01991718f, 0.45267880f, -0.62715942f, 0.28064159f, -0.52148354f, 
    -0.01268217f, 0.01442164f, 0.19218534f, -0.19730009f, 0.58776927f, 0.15896869f, -0.02870543f, -0.03981964f, 
    -0.78342700f, 0.14552058f, -0.02211224f, -0.15476714f, -0.30976090f, 0.39566621f, 0.00349376f, 0.26101324f, 
    -0.12698412f, -0.01908795f, 0.09760414f, 0.04344209f, 0.01670166f, 0.33549023f, -0.04004853f, -0.09403692f, 
    0.25780249f, 0.66057837f, -0.08301534f, 0.23027065f, 0.01760709f, 0.05473356f, 0.37161082f, 0.52641189f, 
    -0.18865031f, 0.18515736f, -0.29056513f, -0.00594023f, -0.02954518f, -0.44987535f, -0.03946399f, -0.70545381f, 
    -0.12965657f, 0.41746497f, -0.04805332f, 0.23492727f, -0.33878359f, 0.33302003f, -0.21192911f, 0.04853065f, 
    -0.20593216f, 0.22386146f, 0.23868263f, 0.14830697f, 0.26482770f, 0.06945203f, -0.62200183f, 0.20159578f, 
    -0.35617340f, 0.66374624f, 0.28889728f, 0.24958402f, 0.22963199f, -0.31067550f, -0.09208686f, 0.40271476f, 
    -0.07339996f, 0.23813930f, 0.23636620f, -0.19232634f, -0.32245979f, 0.23123462f, -0.49020648f, 0.19942825f, 
    0.36864164f, -0.45540577f, -0.13331860f, -0.18217394f, 0.11308742f, 0.22064680f, -0.14478071f, 0.12740019f, 
    0.23867419f, -0.14941193f, -0.09364624f, 0.18170165f, 0.53425843f, -0.37142509f, -0.10110670f, 0.45290583f, 
    0.01646621f, -0.01013109f, 0.03382215f, -0.06622006f, -0.21471640f, -0.12149774f, -0.30780742f, -0.27324313f, 
    -0.05551210f, -0.12956125f, 0.09485366f, -0.26777562f, 0.04046132f, 0.10185923f, 0.06349700f, -0.01365617f, 
    -0.21277042f, -0.16031657f, 0.33055469f, 0.16679655f, 0.19686882f, -0.29022714f, -0.04131421f, -0.17831175f, 
    0.15101485f, -0.16751415f, -0.43871248f, 0.37600249f, -0.26182359f, -0.15675832f, 0.20816804f, 0.60573816f, 
    -0.02953801f, 0.72032756f, 0.23651342f, 0.01123089f, -0.07454800f, 0.31830570f, 0.26955947f, -0.00454963f, 
    -0.13773049f, -0.23368789f, -0.15654065f, 0.08605570f, -0.02314567f, 0.07299795f, -0.54446602f, -0.15729761f, 
    0.47209957f, -0.34676290f, 0.31742060f, -0.31665218f, 0.15818414f, 0.43171206f, -0.01634412f, -0.16838883f, 
    -0.00162181f, 0.01091725f, -0.53437275f, 0.20975591f, 0.48896292f, -0.41140246f, -0.28469718f, 0.01316709f, 
    0.07193732f, 0.28986508f, 0.58208007f, -0.40591946f, 0.15067071f, 0.16000089f, 0.36167482f, -0.05902985f, 
    -0.11723867f, 0.00704876f, -0.05043954f, 0.30143455f, -0.01352025f, -0.35593230f, -0.30274293f, 0.25229970f, 
    0.25843826f, 0.25255039f, -0.18651624f, 0.38467515f, -0.06749782f, 0.16483602f, -0.08039267f, 0.43159258f, 
    -0.03004225f, -0.22314347f, -0.41691086f, 0.31040597f, 0.10197216f, -0.47555092f, 0.03912605f, 0.36301124f, 
    -0.00198047f, -0.73105276f, -0.54518896f, 0.35406011f, 0.46655342f, -0.38072258f, -0.18805937f, 0.39204916f, 
    -0.05809334f, 0.09340391f, -0.48026159f, 0.19917431f, 0.38238502f, 0.13554381f, 0.31869656f, 0.11639943f, 
    -0.10664780f, -0.08758745f, -0.16620144f, -0.29219958f, 0.19728363f, 0.50927705f, -0.05737595f, 0.48672122f, 
    -0.16833919f, 0.09589815f, -0.88452154f, 0.12983471f, -0.25844815f, -0.35868752f, -0.08220849f, 0.45566261f, 
    0.02457984f, 0.28095222f, 0.28000212f, 0.03272987f, -0.49718213f, -0.13795732f, 0.34802097f, -0.46517488f, 
    -0.22128467f, 0.23419854f, 0.59437162f, 0.27724308f, -0.15596402f, 0.27629381f, -0.10373026f, -0.16385919f, 
    0.06168905f, -0.28233910f, 0.16577832f, -0.39602762f, -0.22814606f, 0.46090877f, 0.07733870f, 0.00396829f, 
    -0.17626120f, 0.21282566f, 0.18767370f, 0.37388119f, -0.10843714f, 0.31111011f, 0.01231324f, -0.38489261f, 
    0.12289029f, -0.23779388f, -0.28455749f, -0.39887285f, 0.12185972f, 0.33379120f, -0.22453466f, 0.06666671f, 
    0.24645737f, 0.24653526f, 0.48917559f, 0.14090540f, -0.21905653f, 0.23970605f, 0.21150818f, 0.26222003f, 
    -0.00913101f, 0.30277672f, 0.39129743f, 0.08933631f, -0.25007719f, -0.22108440f, -0.08105505f, 0.27665967f, 
    -0.18789062f, -0.00990286f, -0.32407621f, 0.07083355f, -0.43692601f, 0.05468364f, 0.56936735f, -0.02805977f, 
    -0.14247814f, -0.08641046f, -0.01366158f, -0.15537618f, -0.13883325f, -0.07926713f, -0.26891693f, 0.17653671f, 
    -0.03118950f, 0.09229559f, -0.06202329f, 0.00754239f, 0.19704385f, 0.03727184f, -0.07771478f, -0.22136159f, 
    -0.07224166f, -0.10326618f, 0.09641546f, 0.30671561f, -0.28792807f, -0.21781099f, 0.02066437f, 0.24003457f, 
    -0.04401134f, 0.15434505f, -0.15717638f, 0.24598639f, -0.08451421f, 0.17460011f, 0.04529787f, 0.05485833f, 
    -0.04211735f, -0.02049174f, 0.13099012f, -0.44339576f, 0.12809958f, 0.72096914f, -0.20162220f, -0.26590073f, 
    0.01059853f, -0.03406441f, 0.26405072f, 0.15256327f, 0.00820139f, 0.04192794f, -0.07647616f, -0.09690117f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.16785561f, -0.11242726f, -0.13578883f, -0.03082349f, 0.57640451f, -0.36008704f, 0.00751520f, 0.05603706f, 
    0.21440196f, 0.16512237f, 0.56610888f, 0.37926352f, 0.11274707f, 0.07763545f, 0.20077881f, 0.36555853f, 
    0.27498484f, -0.15114704f, -0.22303569f, -0.21470651f, 0.22670875f, -0.02681871f, -0.14492886f, -0.32229909f, 
    0.44698265f, -0.02291779f, -0.19857815f, 0.35438314f, -0.15924679f, 0.12306535f, 0.25007468f, 0.48530415f, 
    -0.05672547f, 0.02194644f, 0.14174679f, -0.28156304f, 0.09295643f, -0.28879896f, 0.26279142f, 0.14827666f, 
    -0.07245012f, -0.28318816f, 0.33524129f, 0.11196318f, 0.52675122f, -0.06963693f, 0.09730764f, -0.30592036f, 
    -0.44053245f, -0.44200817f, -0.00892327f, -0.47599781f, -0.03498413f, -0.09308137f, 0.21148489f, 0.02498298f, 
    0.54921526f, 0.51225179f, -0.22918637f, 0.07206626f, 0.09131064f, 0.13695209f, 0.45845857f, 0.16392760f, 
    0.23773693f, 0.01312071f, -0.11193318f, 0.02294884f, 0.44142109f, 0.06749365f, -0.67947376f, -0.02305573f, 
    0.03618737f, 0.38682538f, 0.30409932f, -0.21714193f, 0.13363570f, -0.01094435f, 0.04258337f, 0.57307017f, 
    0.45937151f, 0.52859330f, 0.31497535f, 0.18057574f, -0.36741120f, 0.39087963f, -0.08834008f, 0.24240862f, 
    0.11238614f, 0.00048505f, 0.15345281f, -0.09178372f, 0.20188610f, -0.17560004f, 0.12620682f, -0.21035108f, 
    -0.05490416f, 0.16860031f, -0.04096137f, 0.53406799f, -0.21986753f, -0.08926386f, 0.06385407f, -0.05853353f, 
    0.01316997f, -0.33476454f, 0.30281633f, -0.43078306f, 0.40021402f, -0.41086054f, 0.13822767f, -0.33226925f, 
    0.08018629f, -0.30571902f, 0.75832433f, 0.30115885f, 0.09858849f, -0.22857125f, 0.07033755f, 0.37952414f, 
    0.49012092f, -0.13553235f, -0.09329305f, 0.27696282f, 0.08894545f, -0.14830899f, 0.03959171f, 0.46554852f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.42515454f, 0.05339165f, -0.12527104f, 0.38952291f, 0.21555272f, 0.30561712f, -0.05196139f, 0.13565852f, 
    -0.04773837f, -0.05542047f, 0.30074942f, 0.05142293f, 0.14395759f, -0.10829145f, 0.33506751f, 0.29197854f, 
    0.09302919f, -0.31393433f, -0.03949738f, 0.41280648f, -0.24691761f, -0.54167396f, -0.99071878f, 0.01481297f, 
    -0.24780539f, -0.39507946f, -0.19850297f, 0.16951574f, 0.06824007f, 0.33998010f, 0.09199990f, -0.02970136f, 
    0.06579796f, -0.12907565f, -0.54117054f, -0.37992948f, -0.16634651f, -0.04543506f, -0.09352342f, -0.27422795f, 
    -0.17908451f, 0.01174406f, -0.08665726f, -0.10014057f, 0.00178977f, -0.05631516f, 0.17164148f, -0.47796029f, 
    -0.50342596f, -0.17251323f, -0.84948254f, -0.09566180f, 0.09632526f, -0.00885100f, 0.18654151f, -0.36577040f, 
    0.16064028f, -0.04400061f, -0.14166906f, -0.05598872f, -0.20371264f, 0.54876643f, -0.36614290f, -0.07232630f, 
    -0.16881490f, 0.03513834f, 0.00546347f, 0.10198734f, -0.18352197f, 0.27376279f, -1.07557094f, 0.31728116f, 
    -0.36675301f, 0.18560804f, -0.04080095f, 0.02332485f, -0.16594352f, 0.44874755f, -0.39681411f, 0.03612824f, 
    0.25095490f, 0.07705007f, -0.17527868f, -0.49031860f, 0.11687743f, -0.22234005f, 0.07629183f, -0.41001242f, 
    -1.12965226f, 0.47903416f, -0.29467303f, -0.20746286f, -0.51051074f, 0.07884589f, 0.10548867f, -0.14342341f, 
    -0.05978969f, -0.07656542f, 0.13391788f, 0.14717811f, 0.07879496f, -0.16865614f, 0.23597866f, 0.05657156f, 
    -0.41185451f, 0.28433487f, 0.33953828f, -0.69758976f, -0.26945755f, -0.35327366f, 0.05648762f, 0.48994333f, 
    -0.09583784f, -0.02893365f, 0.19047998f, 0.18475662f, 0.17706192f, 0.19296095f, -0.35935193f, 0.16233383f, 
    -0.89360130f, 0.12564501f, -0.08338024f, -0.15220399f, 0.28558674f, -0.00276115f, -0.01023553f, -0.06246489f, 
    0.20571184f, -0.73595792f, 0.17110768f, 0.17670751f, 0.12769315f, 0.10046041f, -0.26795051f, -0.83751100f, 
    0.26478863f, -0.26677239f, -0.20544407f, 0.01947841f, 0.21314317f, -0.50755084f, 0.20255266f, -0.23830135f, 
    -0.17539011f, -0.25132266f, 0.02626343f, -0.21966165f, -0.03171884f, 0.12204888f, 0.12433895f, 0.12146349f, 
    0.13470364f, -0.11343341f, -0.19576076f, 0.35295132f, 0.17338744f, 0.15015793f, -0.75984246f, -0.33813778f, 
    -0.34449923f, -0.45148265f, -0.59995997f, 0.29246166f, 0.19059478f, -0.49392888f, -0.09174249f, 0.05065713f, 
    -0.24321550f, 0.08485460f, 0.02119778f, -0.01861434f, -0.47688222f, 0.20445117f, -0.12643909f, -0.25729692f, 
    0.70529330f, -0.05215354f, 0.03725892f, -0.06357873f, 0.35995477f, -0.02696576f, 0.17222050f, 0.01687074f, 
    -0.18102130f, 0.04985475f, -0.27135414f, 0.36732718f, 0.17664662f, -0.08526043f, 0.19480644f, -0.07950578f, 
    0.06674443f, 0.01976638f, 0.06671894f, -1.19620848f, -0.00017712f, 0.22937636f, 0.10370900f, -0.07808419f, 
    -0.03374970f, 0.09224112f, 0.07363567f, -0.15172222f, 0.36814141f, 0.05954152f, 0.20566121f, -1.16797876f, 
    -0.37442896f, -0.07336735f, -0.49572954f, -0.18412399f, -0.40714079f, 0.06720833f, 0.04916153f, 0.57513148f, 
    -1.10118067f, 0.02678658f, -0.37484691f, 0.02657082f, 0.01365832f, -0.05635017f, -0.22857040f, -0.13240013f, 
    -0.16660567f, -0.45373952f, 0.12796608f, -0.04666473f, 0.05909960f, 0.07379334f, -0.08224250f, 0.01929669f, 
    -0.35444468f, 0.33162293f, -0.41193616f, 0.13512145f, -0.00172439f, 0.50283921f, -0.16135213f, -0.08920767f, 
    -0.09479346f, -0.03516997f, -0.12415305f, 0.00555202f, -0.10832892f, 0.15925039f, -0.44856945f, -0.40398633f, 
    -0.03435872f, 0.27063727f, 0.07165729f, 0.10687552f, -0.09223544f, 0.08119465f, 0.04686248f, -0.02666907f, 
    0.13028489f, -0.53563893f, 0.01119887f, -0.09697048f, -0.09933733f, -0.18835592f, -0.17346281f, 0.47610343f, 
    0.44506353f, 0.09054928f, -0.38959953f, -0.15422159f, -0.10868225f, 0.14215027f, 0.21915166f, 0.20854229f, 
    0.10991266f, -0.02249682f, -0.03695215f, -0.50802839f, 0.18194768f, -0.40019268f, -0.31567261f, -0.08308340f, 
    -0.02350416f, 0.16582283f, -0.30113387f, 0.23028450f, -0.13456294f, -0.12001450f, 0.06447923f, -0.05336723f, 
    0.34095332f, 0.31287855f, 0.05343903f, -0.06117438f, -0.60997492f, -0.30965814f, 0.15080842f, 0.68848324f, 
    -0.65267861f, -0.01102555f, 0.14686975f, -0.50629866f, -0.37460271f, -0.31459799f, 0.02809995f, -0.49918848f, 
    -0.44553080f, -0.16528615f, -0.19101314f, -0.09621239f, -0.36577529f, -0.03609069f, 0.00936129f, 0.16041693f, 
    0.01445716f, 0.05442051f, -0.32767633f, 0.17952275f, 0.15116297f, -0.25690475f, 0.07043356f, -0.13102074f, 
    -0.19654615f, -0.08779947f, 0.06942438f, 0.06108071f, -0.22700261f, -0.06981602f, -0.72669750f, -0.11525188f, 
    -0.36951929f, -0.13506018f, 0.16858380f, -1.01202798f, -1.34412086f, -0.30786735f, 0.13953993f, 0.49092379f, 
    -0.87705594f, 0.00953505f, -0.18176474f, -0.14239077f, -0.74648529f, 0.21878694f, 0.34059578f, 0.31173581f, 
    0.32913274f, 0.06665285f, 0.28203288f, -0.00701611f, 0.06155571f, 0.00208766f, -0.05864251f, -0.02892662f, 
    0.31147161f, -0.08164161f, -0.39565834f, 0.11563615f, -0.08612469f, 0.30485409f, -0.42451203f, -0.88803214f, 
    0.11155491f, -0.03333753f, 0.28799033f, -0.61030459f, -0.00558989f, -0.13251142f, -0.85711432f, -0.13924146f, 
    -0.21930413f, -0.04968338f, 0.13380939f, -0.56992346f, -0.58096957f, -0.34853062f, 0.07441797f, 0.25012234f, 
    -0.00259971f, -0.20073977f, -0.03083863f, 0.15472040f, 0.45261994f, -0.08361993f, 0.09943004f, -0.07757521f, 
    0.01809835f, 0.29171532f, -0.83372718f, -0.21651527f, -0.69237638f, -0.12438272f, 0.16684172f, -0.41440088f, 
    0.07044544f, 0.18818261f, 0.14766298f, -0.35610172f, 0.20334335f, 0.06258555f, 0.04734910f, -0.08157172f, 
    0.14456996f, -0.91296762f, -0.02277015f, -0.05654933f, 0.21286823f, 0.10773901f, -0.09293883f, -0.06484385f, 
    -0.56114572f, 0.13272491f, 0.19767147f, -0.60823882f, -0.44199592f, -0.10765602f, 0.02948519f, 0.12107684f, 
    -0.10826980f, 0.22555709f, -0.04618783f, 0.11151986f, -0.05898249f, -1.10134399f, 0.10131942f, -0.11677302f, 
    0.23295841f, -0.00911527f, -0.10616877f, 0.17486849f, 0.00451217f, -0.35946983f, -0.46689931f, 0.21818221f, 
    0.20690814f, 0.21967989f, -0.04444672f, 0.17812073f, 0.23066472f, -0.05666969f, -0.15529485f, -0.04245832f, 
    -0.93309623f, -0.43380189f, -0.40835264f, -1.04705763f, 0.13340828f, -0.27687383f, -0.51685524f, -0.86015850f, 
    -0.15655090f, 0.00528751f, -0.00302740f, -0.03204040f, -0.01291255f, -0.44750720f, -0.59626788f, 0.22222517f, 
    0.08733562f, -0.75171417f, -0.32291234f, 0.28701857f, -0.38038379f, -0.53058487f, -0.36154130f, 0.38100478f, 
    -0.05190248f, -0.37398046f, 0.18525171f, 0.08558031f, 0.25160706f, -0.43110394f, 0.26896963f, 0.42236599f, 
    -0.35654899f, -0.66086811f, -0.78202379f, -0.38410345f, -0.26738593f, -0.03887805f, 0.10776646f, -0.03632229f, 
    0.20370257f, 0.22273922f, 0.16192335f, 0.07769307f, -0.08461165f, -0.40373254f, -0.00091923f, 0.11355804f, 
    -0.31496236f, 0.32401460f, -0.08990838f, 0.39170447f, -0.81407285f, -0.36684093f, 0.02010252f, -0.30235934f, 
    0.37529403f, 0.03842157f, -0.15180281f, -0.26446351f, 0.22567500f, -0.35684988f, 0.16289859f, 0.23349397f, 
    -0.91783756f, -0.43367630f, -0.41431257f, -0.84657538f, 0.00923710f, -0.06267626f, 0.02547590f, -1.12301302f, 
    -0.18438305f, 0.13216460f, -0.03408631f, 0.10845360f, 0.06659964f, -0.12629674f, 0.01127895f, 0.26858974f, 
    0.13128266f, 0.18067676f, 0.13992673f, 0.23283249f, 0.05085429f, 0.10754818f, 0.16881250f, 0.02114611f, 
    0.16511501f, -0.12926388f, 0.05774844f, -0.11906607f, -0.05042706f, 0.11049879f, -0.16054033f, -0.34476185f, 
    0.03139608f, -0.08904163f, -0.20747980f, -0.27839583f, -0.51844072f, -0.00821805f, 0.49423614f, 0.23644742f, 
    -0.18665589f, 0.04481155f, 0.06383058f, 0.04662776f, 0.09158202f, -0.86627299f, -0.12491859f, -0.05176972f, 
    -0.03798484f, 0.04868969f, -0.12049562f, 0.19168599f, 0.11396284f, -0.17018130f, -0.16006628f, -0.24284640f, 
    -1.12164342f, -0.08996845f, -0.15003581f, -0.19969843f, 0.06268083f, -0.00241392f, -0.38180426f, -0.03424864f, 
    0.07097414f, 0.01278123f, 0.15424423f, 0.50723785f, 0.02726456f, 0.37559953f, 0.03089970f, 0.03141544f, 
    -0.48030275f, -0.02920195f, -0.04034512f, -0.35852340f, 0.39062300f, -0.58310765f, -0.40036312f, -0.16896726f, 
    -0.10065313f, 0.05622459f, -0.13193706f, 0.04183843f, -0.22414730f, 0.04816880f, 0.08548329f, 0.28786737f, 
    0.22751325f, 0.03356550f, 0.03118657f, 0.01764595f, -0.18762758f, -0.06888903f, 0.16286653f, -0.41727158f, 
    -0.08575815f, 0.09568439f, 0.31859159f, -0.16776577f, -0.09548209f, -0.06637920f, 0.09392606f, -0.06483398f, 
    -0.06636820f, 0.14442566f, 0.08689610f, 0.14997561f, -0.08503487f, -0.30306855f, 0.09188608f, 0.10670207f, 
    0.64023548f, 0.04197727f, -0.18235314f, -0.98060906f, -0.38559228f, 0.57016122f, -0.19592261f, 0.43430433f, 
    0.10938414f, 0.03655318f, -0.02645111f, -0.04332675f, 0.15860087f, -0.03805829f, -0.00202323f, -0.01127189f, 
    0.25882602f, -0.19036429f, -0.02731778f, 0.15028271f, -0.51794934f, 0.00782889f, -0.20520210f, 0.07772737f, 
    -0.03890994f, 0.07420048f, 0.07845115f, -0.12110048f, 0.20555295f, 0.04614501f, 0.01033057f, 0.12622084f, 
    -0.31788054f, -0.15944490f, -0.01556501f, 0.14790694f, 0.03201779f, -0.14743593f, -0.25758061f, -0.02993065f, 
    -0.15971489f, 0.20238319f, 0.02094589f, 0.17129081f, -0.42328903f, -0.00700248f, -0.14197637f, 0.09766351f, 
    0.16765396f, -0.07561380f, -0.22377962f, -0.98403674f, 0.24609186f, 0.00756389f, -0.50214881f, -0.31580195f, 
    -0.20536920f, -1.04501188f, -0.35330638f, -0.24820410f, 0.22075500f, 0.23340587f, 0.01658527f, -0.30932835f, 
    -0.08596966f, 0.05721534f, 0.06471057f, -0.29717192f, 0.10748656f, 0.12991942f, 0.02665706f, 0.01998223f, 
    -0.31232527f, 0.05397454f, 0.18636614f, -0.06712332f, 0.04866648f, -0.00904583f, 0.16229904f, -0.01881565f, 
    0.11004228f, 0.18773982f, 0.25918537f, -0.06589108f, -0.06109674f, -0.55180919f, -0.08604383f, 0.14006841f, 
    0.07556230f, 0.03136044f, 0.02905170f, -0.21260613f, 0.00132787f, 0.21965788f, 0.61712223f, 0.00126562f, 
    0.12485127f, 0.19835925f, 0.14217283f, 0.03914027f, 0.11064114f, 0.24023816f, -0.01631514f, -0.89904869f, 
    0.07151479f, 0.08996488f, 0.03404210f, -0.15679678f, -0.10015723f, -0.01759662f, -0.28481960f, -0.12599827f, 
    0.05235612f, -0.00081568f, -0.28348804f, 0.04205274f, 0.04104877f, 0.01067472f, -0.13874696f, -0.05916421f, 
    -0.32995924f, -0.19924235f, 0.09272683f, -0.06177704f, -0.05638370f, -0.22083434f, 0.11760123f, 0.05075598f, 
    -0.77861607f, -0.13951974f, -0.14384669f, 0.08875655f, 0.13058123f, 0.06758258f, 0.11854924f, -0.56217331f, 
    -0.04903125f, 0.06005065f, 0.08991779f, 0.17840955f, 0.24771161f, 0.19429947f, 0.07089952f, -0.56061000f, 
    0.09685603f, 0.22179666f, 0.13376106f, -0.11111099f, -0.14020431f, -0.05897800f, 0.04330425f, 0.14035761f, 
    0.07545918f, -0.06623057f, 0.16982944f, -0.37952068f, 0.03949505f, 0.06150914f, 0.29691669f, -0.56805551f, 
    -0.34540209f, 0.18278101f, 0.04857579f, 0.04702001f, -0.32393956f, -0.17663257f, 0.08941671f, 0.01051082f, 
    -0.08587436f, 0.29245695f, 0.03123866f, -0.68594241f, 0.07042494f, -0.07459931f, -0.09102089f, -0.03831877f, 
    -0.15604736f, 0.15332690f, -0.49066678f, -0.35026145f, 0.20179357f, -0.05985373f, 0.37912109f, -0.84790635f, 
    0.02043312f, 0.12385670f, 0.24513431f, 0.15886445f, 0.19883785f, 0.69261521f, 0.09253848f, -1.21107638f, 
    -0.06956946f, -0.04808728f, 0.09709519f, -0.17404042f, -0.22407553f, -0.32289538f, -0.26381955f, 0.32052433f, 
    0.60856378f, 0.46252242f, 0.26867089f, 0.31951571f, 0.18943694f, 0.05587251f, -0.61809725f, -0.02799318f, 
    0.03753955f, -0.15055777f, 0.44739425f, -0.10915605f, 0.20542610f, 0.07647227f, -0.35714942f, 0.05142021f, 
    0.73021346f, 0.06750894f, -0.09257914f, -0.07589874f, -0.79297578f, 0.00753671f, 0.29019019f, -0.29906934f, 
    -0.06035469f, -0.17423822f, -0.03649478f, 0.35277557f, -1.15500498f, 0.00177868f, 0.14618987f, -0.18115243f, 
    -0.11541212f, 0.18862443f, 0.04035186f, -0.02690589f, 0.15785968f, -0.01844866f, -0.19365175f, -0.33112207f, 
    -0.43376037f, -0.18557614f, -0.31282029f, -0.02454296f, -0.08167350f, 0.00137007f, -0.35345274f, -0.06982372f, 
    -0.58544779f, 0.28395730f, -0.44081920f, 0.02908831f, -0.05902192f, 0.05489398f, -0.04440878f, -0.38594568f, 
    0.32006717f, 0.15349346f, -0.40380192f, 0.32211930f, -0.18136498f, -0.50094569f, -0.09849124f, -0.08052373f, 
    0.25808102f, -0.00598741f, 0.03538921f, -0.00772292f, 0.30485711f, 0.19944629f, 0.34078544f, -0.04067199f, 
    0.31699482f, -0.22489318f, 0.09675930f, -0.07483957f, 0.17392792f, -0.05808150f, 0.05123296f, -0.12880625f, 
    -0.10144530f, 0.02851881f, -0.19254558f, 0.18402693f, -0.34146821f, 0.25020671f, 0.05196689f, 0.03167279f, 
    -0.33855826f, -0.13552868f, -0.17052168f, -0.04801353f, -0.28275630f, -0.10478991f, -0.11845820f, 0.05091010f, 
    0.08821332f, -0.10480999f, 0.03409472f, 0.24305768f, -0.38624597f, 0.05364032f, -0.30310449f, -0.21056664f, 
    -0.50048679f, 0.05759481f, 0.05655131f, -0.13588701f, -0.17222016f, 0.17639963f, -0.14334075f, 0.13760027f, 
    0.08479613f, -0.19506052f, -0.58522505f, -0.07838198f, -0.17373703f, -0.70612794f, -0.49935290f, 0.28577098f, 
    0.11199328f, -0.06121743f, -0.38596532f, 0.12793632f, 0.12850845f, -0.03883640f, -0.01352882f, 0.21118174f, 
    0.23175450f, -0.05922252f, -0.30552331f, 0.05742661f, -0.08381516f, 0.04712817f, -0.14088190f, -0.40468726f, 
    -0.10122511f, -0.59418416f, -0.02140661f, -0.08727289f, -0.34450600f, -0.30228835f, -0.01317635f, -0.04193084f, 
    -0.25359431f, -0.05328465f, -0.05517711f, -0.13658860f, -0.23557335f, 0.04482429f, -0.62290859f, -0.13687384f, 
    -0.03741853f, -0.49987403f, -0.32284552f, 0.14122039f, -0.04506315f, 0.13720371f, -0.43128771f, 0.05035957f, 
    0.00635217f, -0.19264655f, 0.13910675f, 0.18372734f, 0.25636849f, -0.21609114f, -0.08943494f, 0.28876472f, 
    -0.02251233f, 0.25807407f, 0.46361867f, -0.04682240f, -0.64006281f, -0.03316443f, 0.02503870f, -0.05144919f, 
    0.11666688f, -0.09566324f, 0.19059040f, -0.42592031f, 0.02451276f, 0.52321219f, 0.20166980f, 0.08642752f, 
    -0.81383789f, -0.13818172f, -0.10250913f, 0.22304238f, -0.11741351f, 0.33773318f, 0.14103381f, 0.30784437f, 
    -1.01179135f, 0.02496263f, -0.53110558f, 0.15949738f, -0.94675761f, 0.07122398f, 0.01094328f, -0.47968429f, 
    -0.35106346f, 0.01266830f, -0.05484216f, -0.16308275f, 0.11905378f, -0.02801452f, -0.14210315f, 0.21611571f, 
    0.35698262f, 0.18135013f, -0.12268195f, -0.22238915f, 0.03239403f, -0.17858054f, -0.83618218f, 0.17155509f, 
    0.00189765f, -0.52176243f, -1.03381157f, -0.68157798f, 0.21055128f, -0.59740853f, -0.80082428f, -0.58305836f, 
    -0.77371800f, -0.31012964f, 0.00288094f, 0.07690950f, 0.32557172f, 0.32836396f, 0.38408059f, 0.41872364f, 
    0.16624616f, -0.33850962f, 0.22528899f, 0.09363504f, 0.22834186f, -0.12885399f, 0.18776122f, -0.21538608f, 
    -0.42731982f, -0.08490141f, 0.14472187f, 0.39625382f, -0.02172984f, 0.22931102f, -0.14594711f, -0.29382953f, 
    0.00825018f, -0.07696000f, -0.05598142f, -0.01104367f, -1.23949695f, 0.30013219f, 0.26838970f, 0.09617490f, 
    -0.58760291f, -0.31114128f, 0.14119813f, -0.49239469f, -0.04603298f, -0.00139830f, 0.37776545f, 0.14506543f, 
    -0.70432329f, 0.14966273f, 0.20470071f, 0.00727211f, 0.01312929f, 0.68239981f, 0.38388783f, 0.20266068f, 
    -0.13910677f, -0.07991239f, -0.05321169f, -0.10851386f, -0.08128887f, 0.29204714f, 0.11838764f, 0.24103859f, 
    0.26503545f, 0.13110024f, 0.07180027f, -0.53370804f, -0.25330311f, -0.23214123f, -0.10913371f, -0.06278642f, 
    -0.58762258f, -0.23529306f, -0.19222653f, 0.00636174f, -0.14541565f, 0.19375753f, 0.20923753f, -0.15155216f, 
    -0.29531235f, -0.29466805f, -0.40203151f, 0.22814596f, 0.26927540f, -0.03949374f, -0.41581491f, -0.09439157f, 
    -0.11105943f, -1.07168365f, -0.07618215f, -1.16293740f, 0.01452205f, 0.03984843f, -0.17291917f, -0.13324134f, 
    -0.09929651f, -0.22040886f, -0.08683431f, -0.14770405f, 0.27439079f, -0.35093132f, 0.29872689f, 0.04874808f, 
    -0.07114467f, -0.04043845f, -1.04653001f, 0.12200911f, -0.30319142f, -0.31134209f, -0.48232403f, -0.12712421f, 
    -0.29784653f, 0.25899452f, 0.30318007f, 0.23406400f, -0.37198207f, -0.00952197f, -0.01653801f, 0.22402392f, 
    -0.49073794f, -0.08589601f, -0.12232934f, 0.07370064f, 0.20537728f, 0.14788841f, -0.08538020f, -0.33560991f, 
    -0.47737715f, -0.24758218f, 0.06407153f, 0.00443533f, -0.36014819f, -0.14717045f, -0.40997741f, 0.01890735f, 
    0.02454658f, -0.03250530f, 0.00005435f, 0.23100540f, 0.28550142f, -0.34297585f, -0.38549459f, 0.13381036f, 
    -0.15272324f, -0.51121646f, 0.00175633f, 0.11789423f, 0.16399395f, 0.15958460f, -0.44494668f, 0.09284240f, 
    0.07032342f, -0.03075912f, 0.40234688f, -0.14933859f, -0.28823408f, 0.00404477f, 0.01526188f, 0.03884642f, 
    0.06067528f, -0.01334741f, -0.08794993f, 0.37172744f, 0.51106453f, -0.32991749f, 0.06486567f, -0.01935595f, 
    0.07695242f, -0.51480943f, -0.04967525f, -0.16545784f, -0.76359278f, -0.08906142f, 0.03812295f, -0.27801338f, 
    0.34581476f, 0.00166182f, -0.62229514f, -0.74078703f, -0.32210389f, -1.01325250f, 0.17639694f, 0.16827697f, 
    0.17682448f, -0.04870095f, 0.01616807f, -1.04636848f, -0.52346277f, 0.04701867f, 0.78611135f, 0.00724620f, 
    -0.03440578f, 0.12438893f, 0.09498470f, -0.13660100f, -0.26254249f, -0.00016014f, 0.11842468f, 0.11165555f, 
    0.01517159f, 0.26672712f, 0.20419317f, -0.02269884f, 0.07215762f, 0.03037730f, -0.28733525f, -0.09019159f, 
    0.71266443f, 0.00081370f, 0.29784295f, 0.03646745f, 0.15919247f, 0.01368507f, -0.25496045f, -0.08120082f, 
    0.06407803f, 0.34702158f, 0.14109415f, 0.05226459f, 0.02306134f, 0.21386141f, 0.00408063f, -0.09645776f, 
    0.35111061f, -0.58024454f, 0.24829154f, -0.49660221f, 0.30009755f, -0.53012317f, 0.24319500f, -0.24094178f, 
    0.09822971f, -0.08901206f, 0.08486284f, 0.22654004f, 0.26807848f, 0.08226021f, 0.08150879f, -0.27959341f, 
    0.39878571f, -0.46879435f, 0.00906075f, 0.12900177f, -0.13393396f, 0.01558541f, -0.19373438f, 0.26041928f, 
    0.09781486f, 0.04476762f, -0.63130993f, -0.38458452f, -0.52241665f, -0.61588687f, -0.08462939f, -0.52651191f, 
    0.23776758f, 0.21242851f, -0.12321502f, 0.12930615f, 0.24673235f, 0.25941807f, 0.07096367f, 0.09824655f, 
    0.11629148f, -0.34302211f, 0.03812055f, -0.04014578f, 0.24808367f, -0.01599032f, 0.00965957f, -0.42412776f, 
    -0.01708536f, 0.16389546f, 0.28317147f, 0.58650810f, -0.72010940f, -0.32221577f, -0.36638954f, 0.34675100f, 
    0.04974736f, 0.27353188f, -0.14637491f, -0.02445276f, -0.19268714f, 0.59222436f, 0.22501372f, 0.13231568f, 
    0.09217163f, -0.06559850f, 0.15858887f, 0.19436292f, 0.44474271f, -0.11803961f, 0.17733440f, -0.02295577f, 
    -0.56749547f, -0.09857206f, -0.06753588f, -0.13663587f, -0.11385216f, -0.07172299f, -0.57848489f, 0.26775092f, 
    -1.27626765f, 0.07629257f, -0.05419434f, -0.26751304f, 0.08520790f, -0.25874552f, 0.32318401f, -0.23759604f, 
    0.19691300f, -0.03219835f, -0.02139340f, 0.00993239f, 0.35984552f, -0.80239213f, -1.01330996f, -0.03684514f, 
    0.23558944f, -0.47349644f, -0.16945650f, -0.39228868f, 0.48662844f, -0.44100711f, 0.02038410f, -0.01000141f, 
    -0.01980520f, -0.29930505f, 0.15842023f, 0.14311673f, -0.31614235f, 0.04167579f, -0.74257636f, 0.48572555f, 
    -1.12446666f, -0.60909027f, -0.48987725f, -0.28491175f, 0.05980660f, 0.03295202f, 0.21094216f, -0.06950527f, 
    0.36370915f, -0.24355249f, -0.15256460f, 0.11482614f, -0.04814266f, 0.16126160f, -0.11001967f, -0.19176088f, 
    -0.13004772f, -0.06096732f, 0.26348817f, 0.04699468f, 0.10137014f, -0.84492373f, -0.07399728f, -1.37851584f, 
    0.00645741f, 0.03333199f, 0.05505289f, -0.27398050f, -0.83049285f, -0.95675212f, 0.01641693f, 0.37514406f, 
    -0.90707773f, -0.10503458f, -0.26692906f, 0.07859328f, 0.00730061f, 0.07181675f, 0.05993788f, -0.67696971f, 
    0.01055243f, 0.17967302f, -0.01116163f, -0.70564771f, -0.13346776f, -0.70024306f, 0.01166439f, -0.21254635f, 
    -0.12211657f, 0.04729627f, -0.05830246f, -0.31114152f, -0.15792440f, 0.17087780f, 0.02678624f, -0.09067633f, 
    -0.18860805f, 0.39049411f, -0.08279175f, -0.57840794f, -0.44517699f, 0.21832855f, 0.07700293f, -0.03643660f, 
    0.04797207f, 0.14890988f, 0.24166767f, -0.05249516f, -0.36522815f, -0.73955810f, -0.01486839f, 0.04258817f, 
    0.15774398f, -0.00862046f, 0.30552924f, -0.65722346f, 0.14128827f, -0.75104195f, 0.08355221f, -0.22388405f, 
    0.25040558f, -0.01388806f, 0.21030866f, -0.22092287f, -0.50257272f, 0.33884069f, 0.03256311f, 0.39531174f, 
    0.03798225f, 0.16640212f, 0.35292241f, 0.13926443f, 0.02860140f, -0.08087008f, 0.23906282f, 0.21455397f, 
    0.40876019f, 0.00764805f, 0.38899949f, -0.04739988f, 0.13832255f, 0.23329309f, -0.39180967f, 0.12689176f, 
    -0.12827143f, -0.01426070f, -0.04288411f, 0.69085419f, 0.20577900f, -0.61496603f, 0.66152436f, -0.20264401f, 
    0.01476645f, 0.04439283f, -0.07313424f, 0.13145743f, -0.09491675f, -0.48067898f, -0.02714597f, 0.21426360f, 
    0.20625435f, 0.01608163f, 0.12741391f, 0.03847745f, -0.09045298f, -0.05813496f, -0.31231010f, -0.63786680f, 
    0.13372312f, -0.20780732f, -0.49446630f, -0.11987387f, -0.11003790f, 0.05656132f, 0.13724136f, -0.06653426f, 
    -0.02390620f, -0.01975496f, -0.38970071f, -0.06713214f, -0.06812693f, -0.62043554f, -0.14544386f, -0.51401633f, 
    0.03549638f, -0.34308100f, 0.00179964f, -0.46108565f, -0.10112676f, 0.08317448f, 0.25864625f, 0.35286570f, 
    -0.11993094f, -0.03217536f, 0.24883337f, -0.02767039f, -0.72082430f, -0.12327728f, 0.14497231f, 0.08778499f, 
    0.23972566f, 0.25143149f, -0.19578193f, -0.11896581f, 0.05542792f, 0.06488133f, 0.18320605f, -0.51596755f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.09224760f, -0.00434353f, 0.03203429f, -0.23715398f, 0.19001889f, 0.08434001f, -0.30295953f, -0.33285668f, 
    -0.15610825f, 0.16127726f, 0.19452603f, 0.06823307f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
