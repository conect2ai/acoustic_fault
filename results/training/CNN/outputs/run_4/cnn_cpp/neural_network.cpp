#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.52452832f, -1.88773322f, -0.05720599f, 1.01873469f, 0.65130949f, 1.10057425f, -0.23181210f, -0.22656776f, 
    -0.26413122f, 0.17145638f, 1.47464645f, -0.93516648f, -1.23762643f, -1.10682702f, -0.70870310f, 0.51014000f, 
    -0.28972560f, 0.05533255f, -0.93685085f, -0.25619304f, 0.87388551f, -1.95716703f, 0.68246329f, 0.90609628f, 
    -0.37255374f, 0.33061886f, -0.64463550f, 1.21133661f, -1.06287074f, -1.47717524f, -1.07902765f, 0.67120290f, 
    0.11421981f, -0.19383223f, 0.26823854f, 0.04506233f, -0.66555476f, -1.37423086f, -0.15457073f, -0.85062420f, 
    -0.36199933f, 0.50114900f, 0.14835814f, -0.38725626f, 0.42875376f, -0.83830339f, -1.60322845f, -0.16033183f, 
    0.95336509f, 1.54272163f, -0.17966096f, -0.44375774f, 0.17880996f, 0.02488445f, 1.26123285f, -1.46548367f, 
    -0.58679348f, 0.39933038f, -0.39025262f, -0.81657213f, -0.06379302f, -0.53690147f, -0.82744420f, -0.38864639f, 
    -1.10730207f, -0.52178800f, -0.92935306f, -1.56123960f, -0.96365154f, 0.33997464f, 0.98778903f, -0.07234166f, 
    -1.32684827f, -1.39641368f, -0.65205324f, -0.10839707f, -1.01505256f, -0.18784913f, -0.19259407f, -0.37393191f, 
    -0.53152013f, -0.98718178f, -0.95228738f, -1.57075393f, -1.20123982f, 0.48661399f, 0.59662759f, 0.44240558f, 
    -0.07143628f, 0.22316226f, 1.25876379f, 1.10892642f, -1.44294155f, 0.92324525f, -0.19353914f, -0.74147147f, 
    0.14300784f, 0.35796165f, 0.45246771f, 1.77336907f, 1.17635095f, 1.34437978f, -1.01424050f, -1.38993168f, 
    0.15944129f, 0.56604236f, 0.23636268f, -0.34744367f, -1.35149026f, 1.12698197f, -0.68637323f, 0.44137499f, 
    -0.25453067f, 0.34976223f, 0.62588066f, -0.85487151f, 0.81513733f, -1.24428701f, -0.25120270f, -1.00316513f, 
    0.21855249f, 1.04204869f, -0.49279135f, -0.58863348f, -0.88281423f, -0.53867936f, 0.54921472f, 1.42932856f, 
    1.13522446f, 0.82291526f, 0.91837609f, 1.05150819f, -0.64759284f, -0.01304722f, -0.06499004f, 2.00115585f, 
    1.02673709f, 0.05585726f, 0.20931347f, 0.30673876f, -0.79883999f, -0.39193359f, -0.33495194f, -0.28961173f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18420914f, 0.32458809f, 0.12028723f, 0.32245240f, 0.42788014f, 0.22299448f, 0.31353641f, 0.46392977f, 
    -0.05261390f, 0.37932655f, 0.15612435f, 0.17743655f, 0.18867576f, -0.24762671f, 0.36780459f, 0.06876064f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.08110121f, 0.15815705f, 0.04761052f, -0.25061864f, -0.50672746f, 0.14082721f, 0.16650878f, 0.08013840f, 
    0.16108884f, -0.15118060f, 0.03697018f, -0.08455022f, 0.00616451f, -0.01368807f, -0.12949386f, 0.17446482f, 
    0.10521206f, 0.08640370f, 0.04322909f, 0.07089177f, 0.11859482f, -0.07973954f, 0.27111471f, 0.05979990f, 
    0.25432456f, -0.07267140f, -0.18783839f, 0.07092472f, -0.20208889f, 0.11738066f, 0.01637333f, -0.11365753f, 
    0.15080392f, -0.02642181f, 0.02066138f, -0.00056048f, -0.08553042f, 0.02336662f, 0.02014611f, -0.22850299f, 
    -0.28757408f, -0.05323869f, -0.05657923f, 0.10894219f, 0.09185901f, -0.23061077f, -0.01219407f, -0.03999279f, 
    0.15270242f, 0.01614990f, 0.16095151f, 0.12059281f, 0.28593689f, 0.03001883f, -0.04718206f, -0.02894993f, 
    -0.18160307f, -0.06435502f, 0.04165875f, -0.05594200f, -0.21377705f, -0.43537888f, 0.04670030f, 0.19638065f, 
    0.02410050f, -0.13543756f, -0.04833857f, -0.01351835f, -0.06305764f, 0.03983485f, -0.09445144f, 0.13337938f, 
    0.19221203f, -0.18978383f, -0.08540227f, 0.01419411f, -0.13105638f, -0.20674238f, -0.12645091f, -0.03526180f, 
    -0.18574040f, -0.20809451f, -0.14465502f, 0.24000743f, -0.27933803f, 0.11143335f, -0.09733900f, -0.06335168f, 
    0.13865800f, 0.07663768f, -0.03163091f, -0.04456279f, -0.19888967f, -0.12305871f, 0.00544653f, -0.17926405f, 
    0.03754146f, -0.06876346f, 0.06114624f, -0.13104902f, -0.41637138f, 0.43968394f, 0.43976876f, -0.01785157f, 
    -0.56027174f, -0.00581395f, -0.07269591f, 0.14562115f, 0.02787655f, -0.11526554f, -0.01243865f, 0.00505397f, 
    -0.12062689f, -0.00547015f, -0.06844172f, 0.06274609f, 0.08128352f, 0.04817466f, 0.03732541f, 0.02738603f, 
    0.18149172f, -0.56525832f, 0.25862288f, 0.46715650f, -0.06870467f, -0.06266265f, -0.07382551f, 0.05388093f, 
    -0.23164944f, -0.06252215f, -0.07477113f, 0.01894944f, 0.07449900f, -0.19403800f, -0.04234713f, -0.06898361f, 
    0.07483567f, -0.02569349f, 0.03337474f, -0.07266600f, -0.23795208f, -1.02791238f, 0.21635719f, 0.29180756f, 
    -0.14259946f, -0.03071995f, -0.04055379f, 0.09515041f, -0.03067514f, 0.09629836f, -0.19223949f, 0.03521698f, 
    0.04635834f, -0.16008520f, 0.01105389f, 0.13962658f, 0.05611202f, 0.01328662f, 0.12932470f, 0.00299111f, 
    -0.21282396f, -0.43263239f, -0.47649398f, 0.09435741f, -0.36614874f, 0.06228248f, 0.02009831f, 0.03947027f, 
    0.02875568f, 0.07230587f, -0.00401954f, -0.16233784f, -0.06765424f, 0.04893260f, 0.02111112f, 0.18516971f, 
    -0.11877211f, 0.02584525f, 0.04813308f, 0.12736039f, -0.50308299f, 0.46429378f, -0.43121374f, 0.03891186f, 
    -0.24789019f, -0.06216120f, -0.06295288f, -0.00242870f, 0.07490109f, 0.04270427f, 0.06217040f, -0.05182408f, 
    -0.08774348f, 0.11001369f, 0.05996070f, -0.08759714f, -0.20524977f, 0.09510393f, 0.05703537f, -0.10228607f, 
    0.12336818f, -0.24505775f, 0.05611946f, -0.15686890f, 0.53617460f, -0.41838425f, -0.08128363f, 0.12467927f, 
    0.08219920f, -0.06606387f, -0.09179211f, -0.07280456f, 0.11165249f, 0.08791515f, -0.15290083f, 0.15925117f, 
    -0.13310444f, 0.18107228f, -0.10914242f, -0.07796992f, 0.26030481f, 0.02896572f, -0.02863012f, -0.31019554f, 
    0.23141909f, -0.27831861f, -0.32553431f, -0.16293909f, 0.08641698f, -0.05043403f, -0.06964527f, -0.03404478f, 
    0.07425830f, -0.08152109f, 0.11165856f, -0.01510913f, -0.02376503f, 0.01876230f, 0.14228263f, 0.12768164f, 
    0.80293846f, -0.21428980f, 0.10991707f, -0.18388586f, -0.15035166f, -0.30037540f, 0.04844553f, -0.13325197f, 
    -0.03829381f, -0.19452064f, 0.03820569f, -0.04854843f, -0.04722879f, 0.09118024f, 0.32339332f, -0.08397479f, 
    -0.16384168f, 0.04879840f, -0.21574980f, -0.29571453f, 0.87881082f, 0.25012189f, 0.17563701f, -0.12596463f, 
    -0.29993123f, 0.15316550f, 0.27289572f, -0.06677525f, 0.12822430f, -0.04181990f, 0.06560364f, 0.16354434f, 
    -0.10878989f, -0.01757347f, 0.10900211f, -0.09477571f, 0.06230415f, -0.00148922f, -0.08936758f, -0.03137605f, 
    -0.13807875f, -0.02448132f, 0.16234051f, -0.18913998f, 0.27746350f, -0.13019551f, -0.11736449f, 0.06655642f, 
    -0.06414289f, -0.01222544f, 0.13591783f, 0.02975965f, -0.04519394f, -0.05390756f, 0.00002195f, -0.02906709f, 
    0.04904668f, -0.13518101f, -0.12053466f, 0.08252130f, 0.33125845f, 0.06074676f, -0.02646543f, 0.02511637f, 
    0.43824214f, -0.05635843f, -0.22338787f, 0.02689031f, 0.23500249f, 0.01817470f, 0.05848695f, 0.11476166f, 
    -0.04694062f, -0.06502984f, -0.03601284f, 0.06252884f, -0.03015970f, -0.04586875f, 0.11667629f, 0.02604245f, 
    0.20157193f, 0.12947425f, -0.18988353f, 0.07396675f, -0.40239373f, -0.10608453f, 0.14774761f, -0.02873646f, 
    -0.15951969f, 0.19830649f, 0.20344707f, 0.09803140f, -0.02846104f, -0.04144256f, -0.02516939f, 0.08516677f, 
    0.12606297f, -0.03562691f, 0.04783700f, 0.03634376f, -0.11067890f, -0.34390754f, -0.53981799f, -0.50941956f, 
    -0.00955509f, -0.07665441f, -0.05186212f, 0.00301509f, 0.00055278f, -0.13157594f, 0.07727924f, 0.01830549f, 
    0.00516913f, 0.14884527f, 0.05431047f, -0.14449926f, -0.19427140f, -0.15544370f, 0.02469712f, 0.05683818f, 
    -0.78953713f, 0.17737447f, -0.19101140f, -0.23122388f, 0.08068101f, -0.00927217f, 0.14084966f, -0.19575459f, 
    -0.01791627f, -0.17690501f, 0.06641914f, -0.00349040f, -0.16199096f, -0.09384065f, -0.27988487f, -0.03682262f, 
    -0.23535196f, 0.12235180f, -0.08640084f, 0.09408110f, 0.38765943f, -0.93864572f, -0.02271396f, -0.02332019f, 
    -0.07092022f, -0.17539783f, -0.01430516f, -0.20063214f, -0.00223370f, 0.04162937f, -0.01081740f, 0.00515342f, 
    -0.10607020f, 0.15242335f, 0.03568994f, 0.05639185f, -0.00789516f, 0.16395999f, -0.02183861f, 0.02818881f, 
    -0.06207005f, -0.07837577f, 0.10589378f, 0.02383287f, -0.18120433f, -0.11625323f, -0.02964854f, 0.10984521f, 
    0.11129782f, 0.06773533f, -0.05502907f, -0.11886038f, -0.05883266f, 0.02728019f, -0.11548360f, 0.08269502f, 
    -0.03475347f, -0.05244137f, 0.02879228f, -0.13727102f, 0.42608148f, -0.19626375f, -0.29989272f, 0.00177565f, 
    -0.33233368f, -0.02277875f, -0.02225568f, -0.07377801f, -0.08584338f, 0.06366678f, 0.01049353f, 0.12466695f, 
    0.05081123f, -0.06200849f, -0.07835021f, 0.14063965f, 0.02726506f, -0.00416408f, -0.11663038f, 0.16250737f, 
    0.28265649f, -0.21438032f, -0.14761281f, -0.45303759f, -0.03655560f, 0.05618793f, 0.13683806f, -0.18046428f, 
    -0.17167242f, -0.03994233f, 0.05414410f, -0.10920885f, -0.03269009f, 0.07920271f, -0.14488521f, 0.03088471f, 
    0.02399222f, -0.17031316f, 0.02163945f, 0.08925853f, -0.23930971f, -0.03144155f, 0.06967346f, -0.08063163f, 
    -0.10665721f, 0.11101911f, -0.10457665f, 0.07432779f, 0.11007323f, -0.04496066f, -0.13161302f, -0.02941454f, 
    0.12892057f, 0.17702648f, -0.01597583f, 0.05112131f, 0.02288712f, -0.25271261f, -0.11014231f, 0.03655575f, 
    0.10778872f, 0.10090755f, 0.22177044f, 0.22513671f, -0.17196274f, 0.17116240f, -0.11918346f, -0.01569531f, 
    0.21088941f, 0.09683265f, -0.13846104f, 0.02886256f, 0.11757118f, 0.12311500f, -0.12305303f, -0.13056889f, 
    0.24559399f, -0.24522458f, -0.24177465f, -0.38502213f, 0.43122268f, -0.23944555f, -0.01683603f, 0.10664144f, 
    -0.03611870f, -0.00777223f, 0.09890915f, 0.03320693f, 0.13892280f, 0.09391296f, 0.03517616f, -0.16027978f, 
    0.20243169f, 0.01277692f, 0.09415754f, 0.04774839f, 0.03974232f, 0.11273298f, -0.25349021f, 0.00091082f, 
    0.10942116f, -0.67229944f, 0.19764087f, -0.31720710f, 0.01749615f, 0.03279372f, -0.27999008f, 0.06301070f, 
    -0.04282514f, 0.15038761f, -0.04125990f, 0.14530250f, -0.02715687f, -0.10726316f, 0.14931570f, 0.00668947f, 
    0.02530349f, -0.37859848f, 0.06167046f, -0.19648451f, 0.18120022f, 0.24991396f, 0.10967581f, 0.19620267f, 
    0.13465750f, -0.10632743f, -0.17750779f, 0.13899209f, 0.04800082f, 0.07475712f, 0.00727902f, 0.01876188f, 
    0.04161369f, 0.21461253f, -0.12987769f, 0.11650356f, -0.08435648f, -0.03623288f, -0.17024088f, -0.06643915f, 
    -0.14390646f, 0.21463802f, 0.07063898f, -0.02083680f, 0.42750454f, 0.14818609f, 0.09862077f, 0.25873131f, 
    -0.12846065f, 0.10087083f, 0.03516601f, -0.12193286f, -0.03056078f, -0.14691237f, 0.11928695f, 0.13890190f, 
    -0.03385168f, -0.04618133f, 0.21083476f, 0.17920521f, -0.39746076f, -0.32069269f, -0.42890075f, -0.13979512f, 
    -0.20469199f, 0.09616555f, -0.21818870f, -0.14923674f, 0.05740374f, 0.15907501f, 0.15935335f, 0.18413661f, 
    -0.09946113f, -0.30603588f, 0.20505278f, -0.15195040f, 0.02218697f, -0.10005315f, -0.00435722f, -0.06888014f, 
    0.51292962f, 0.52657586f, 0.06786207f, 0.07379208f, 0.46800262f, -0.01079409f, 0.09616469f, 0.04047260f, 
    -0.08988824f, 0.20195332f, -0.01853938f, 0.11567365f, -0.03514315f, -0.00289526f, -0.00259040f, 0.03295456f, 
    0.04423965f, 0.23451504f, -0.02513784f, -0.06475109f, 0.46953911f, -0.16198558f, 0.24372172f, -0.05878517f, 
    0.15223300f, -0.10106768f, -0.10562819f, -0.09927435f, 0.00442042f, -0.14903174f, -0.09756002f, -0.18762664f, 
    -0.10868544f, -0.01568038f, -0.02937985f, -0.01411275f, 0.00289829f, -0.07835647f, -0.04775155f, -0.04081497f, 
    0.07789876f, 0.15146239f, 0.42172867f, 0.14745264f, 0.38194183f, -0.15557238f, -0.22815487f, -0.28259498f, 
    0.05395189f, -0.05772094f, 0.09943090f, -0.00140271f, -0.07228583f, -0.03587119f, 0.14425275f, -0.08334872f, 
    -0.02830591f, -0.22811614f, 0.01509058f, 0.06326205f, -0.20491810f, 0.04328878f, -0.20398578f, -0.22054015f, 
    -0.18760549f, 0.14496319f, 0.06300786f, 0.17702217f, -0.18029267f, 0.04629642f, -0.06699145f, 0.09572959f, 
    -0.07605728f, -0.13758913f, -0.01357542f, -0.02183649f, -0.03546820f, 0.18276402f, -0.00331277f, -0.07714063f, 
    0.54492515f, 0.01930862f, -0.57790726f, 0.02279697f, -0.26140597f, -0.12456247f, 0.01028946f, 0.14344470f, 
    0.10251330f, -0.04006526f, -0.13653716f, 0.02150533f, -0.04177417f, -0.00585631f, -0.02881251f, 0.05325170f, 
    -0.07825327f, -0.28390408f, 0.00503482f, -0.14007592f, 0.61485785f, 0.03476602f, -0.10467052f, -0.14600517f, 
    -0.44223908f, -0.15245247f, -0.11999013f, 0.26193154f, 0.04363786f, 0.08555321f, -0.12300923f, -0.04454481f, 
    -0.15439677f, -0.03116691f, 0.06948374f, 0.04778573f, -0.05004662f, 0.01614376f, 0.05642036f, 0.01646525f, 
    0.74856639f, -0.35787940f, -0.11592320f, 0.07156564f, -0.30733344f, -0.39317554f, 0.13927363f, -0.25850722f, 
    -0.11895209f, 0.07375892f, 0.14205833f, -0.08851716f, 0.03192395f, -0.08272532f, -0.06736301f, 0.01870088f, 
    -0.03235661f, 0.01766187f, 0.10824403f, 0.01524137f, 0.60731053f, -0.34330902f, 0.49672553f, -0.00887450f, 
    0.42806530f, -0.18114510f, -0.10172794f, -0.15866078f, 0.18275748f, 0.12215085f, 0.23867778f, 0.01171949f, 
    -0.16424944f, 0.05562755f, -0.02816205f, 0.16990291f, -0.13720281f, 0.01342038f, 0.02676476f, 0.04319090f, 
    -0.62541008f, -0.41300714f, -0.19961132f, -0.10315178f, -0.28932855f, 0.01482831f, -0.09532550f, -0.07575340f, 
    0.14360999f, 0.19095452f, 0.02777944f, 0.05015669f, -0.11381064f, -0.05451972f, -0.11384785f, 0.12165162f, 
    -0.03392085f, 0.02427555f, 0.13219105f, -0.07785016f, 0.02092463f, -0.30269623f, 0.19469647f, -0.27376693f, 
    -0.42909059f, 0.19109316f, 0.08621179f, -0.17551060f, 0.04561679f, -0.00288466f, 0.13050619f, 0.01443579f, 
    0.10563575f, -0.15523778f, -0.01259339f, -0.08483545f, 0.07541177f, 0.21310878f, 0.08569687f, -0.11629120f, 
    -0.65765530f, -0.47330296f, -0.07829680f, -0.07343934f, -0.34294349f, -0.15204120f, 0.16833916f, -0.21303755f, 
    -0.11412455f, -0.21470571f, 0.03380748f, 0.06106064f, 0.09644780f, -0.04136042f, -0.00317847f, -0.04153010f, 
    -0.11315547f, 0.06269775f, 0.13491529f, 0.02504023f, 0.65344548f, -0.46761617f, -0.19542128f, 0.18025550f, 
    -0.17128235f, -0.16616432f, 0.21870576f, -0.14971304f, -0.09738914f, -0.00578520f, -0.14493550f, -0.05672812f, 
    0.08978145f, 0.07468694f, -0.06296336f, 0.05508726f, -0.10745948f, -0.04708047f, 0.01240175f, 0.00205914f, 
    0.38243237f, -0.49186471f, 0.03565090f, -0.38527110f, -0.39488617f, 0.25321829f, -0.29384506f, 0.27231678f, 
    -0.23294660f, 0.09069139f, -0.14052576f, 0.00918331f, 0.01337522f, -0.14714733f, -0.06387026f, 0.14558010f, 
    -0.15593572f, 0.05786860f, 0.10774378f, 0.07703445f, -0.42674077f, 0.41887957f, -0.15350395f, -0.26427805f, 
    0.18237948f, 0.09916765f, 0.24710034f, 0.18453535f, 0.03456106f, -0.26058245f, -0.12250604f, 0.05240478f, 
    -0.00993237f, -0.04851487f, -0.11682719f, -0.05813252f, 0.05431151f, -0.06332124f, -0.13996866f, -0.04050593f, 
    0.11641870f, 0.23679027f, 0.15432549f, -0.07198621f, -0.00584379f, -0.00131247f, 0.16142207f, -0.09232870f, 
    -0.12423421f, 0.14608559f, -0.09402958f, 0.09102844f, -0.03560323f, 0.15406582f, 0.07481372f, -0.06249357f, 
    -0.12763514f, 0.04569233f, -0.01501580f, -0.03116947f, 0.43689761f, -0.06475462f, -0.19185932f, -0.06498007f, 
    0.28162515f, 0.08498313f, -0.00314294f, -0.19373742f, 0.10118005f, 0.05517910f, 0.06234402f, -0.01904702f, 
    -0.07834253f, 0.02272463f, 0.07036046f, 0.06859139f, -0.05399005f, 0.05826470f, -0.11427926f, -0.14788769f, 
    0.06939800f, -0.13372779f, -0.20988657f, -0.08928240f, -0.09214643f, 0.08457718f, -0.02831987f, 0.04036690f, 
    0.07636277f, 0.03497121f, -0.13589787f, 0.04936937f, 0.02032347f, 0.13661838f, 0.01905999f, -0.17372577f, 
    -0.20013510f, -0.07392687f, -0.19387619f, -0.00019004f, 0.07864489f, -0.22101341f, -0.02900805f, -0.38319710f, 
    0.01657838f, 0.24483095f, -0.08637361f, 0.18110663f, -0.00978625f, 0.03575536f, -0.10345867f, 0.13539930f, 
    0.00616322f, -0.07054213f, -0.05947595f, 0.00164082f, 0.11359210f, 0.18368824f, -0.13610364f, -0.08786462f, 
    0.37280777f, -0.26983964f, -0.06379757f, -0.14490715f, -0.32135966f, -0.03067965f, -0.13440754f, 0.07417278f, 
    -0.19004904f, 0.02970760f, -0.15385053f, 0.05406405f, 0.06825806f, -0.17008278f, 0.14490482f, -0.08026100f, 
    -0.06980971f, 0.04016073f, -0.14101423f, 0.03652999f, 0.41209957f, 0.37341884f, -0.01751743f, 0.19889064f, 
    0.34747991f, 0.24048088f, 0.30575570f, 0.03676116f, 0.12369441f, 0.15137699f, 0.11136324f, -0.01974097f, 
    -0.17057531f, -0.22955003f, -0.09749902f, -0.03233221f, -0.00564717f, 0.09599771f, 0.01368965f, -0.06286739f, 
    -0.44521913f, 0.50904959f, 0.34843868f, 0.13816324f, 0.07407682f, 0.15547396f, 0.04330872f, 0.04800558f, 
    -0.06910027f, -0.25761482f, -0.02131267f, -0.12312509f, -0.07305486f, 0.02045873f, 0.07332293f, -0.00249666f, 
    0.13038585f, -0.18986043f, 0.31206030f, 0.04653891f, -0.01708698f, 0.01636076f, 0.16871990f, 0.20464176f, 
    -0.06251026f, -0.04014755f, -0.19726321f, 0.00027656f, 0.09435294f, 0.12929742f, 0.14547493f, 0.17620173f, 
    -0.07592407f, 0.04647239f, -0.01893044f, 0.07562409f, -0.05599747f, -0.09323808f, 0.00303710f, 0.16654110f, 
    0.21874166f, 0.04127691f, 0.06998992f, 0.07677170f, -0.06352486f, -0.01704563f, -0.20165008f, -0.03961913f, 
    -0.09880110f, -0.03211671f, -0.17533043f, -0.03718662f, 0.03841476f, 0.08548452f, 0.00961290f, -0.00510280f, 
    0.06881010f, 0.08526075f, -0.04971353f, 0.13602194f, -0.25438035f, -0.10765778f, -0.06003013f, -0.02947709f, 
    -0.16689487f, -0.01470264f, -0.31568262f, -0.00321496f, 0.10510033f, -0.03078625f, -0.07310747f, -0.07174172f, 
    0.04241907f, 0.00988190f, 0.13210127f, -0.11356006f, -0.07068778f, -0.11290058f, 0.13272133f, 0.05551333f, 
    0.04373387f, 0.13782112f, 0.32588613f, 0.14216746f, 0.09744576f, -0.09632927f, 0.22333767f, -0.06116220f, 
    0.12694216f, 0.10119482f, 0.06953486f, 0.14948849f, -0.18609618f, -0.04282240f, 0.16007274f, -0.01177871f, 
    -0.03880681f, 0.00737224f, 0.03499083f, -0.09614922f, 0.14741269f, 0.39873829f, 0.00986204f, 0.26297179f, 
    -0.05289246f, 0.02310160f, 0.18960330f, -0.06798603f, -0.01047810f, 0.03934513f, -0.06004560f, -0.03064886f, 
    -0.11246461f, -0.10072885f, -0.02667309f, -0.04405225f, 0.04262871f, 0.18059474f, -0.02503018f, -0.01239757f, 
    0.20602614f, 0.04056551f, -0.00344482f, 0.06634066f, -0.07599397f, -0.32170779f, -0.21751887f, 0.04204409f, 
    0.05606101f, 0.08765693f, -0.05533351f, -0.09827229f, 0.11184336f, -0.06941335f, 0.08355144f, -0.03418205f, 
    0.03487996f, 0.09735681f, 0.02750025f, -0.00123271f, -0.10559608f, -0.00820260f, -0.12310667f, -0.00792741f, 
    -0.04198763f, -0.04199003f, -0.23993266f, 0.13599263f, -0.10283873f, -0.06398756f, -0.03304547f, 0.04472911f, 
    -0.07965006f, 0.00687631f, 0.12225672f, 0.06934720f, 0.00224670f, 0.03212678f, 0.12945302f, -0.13788442f, 
    0.20440592f, 0.13685593f, -0.28718740f, 0.16540223f, -0.01780573f, -0.28300908f, -0.17714170f, -0.03994712f, 
    0.19459008f, -0.02335776f, -0.03260178f, -0.05587597f, -0.14076029f, -0.11931278f, 0.01379157f, -0.15996672f, 
    0.00487204f, 0.15342492f, -0.16413468f, 0.06811026f, -0.14897509f, -0.87852621f, -0.53752881f, 0.35167974f, 
    0.42797145f, -0.06523108f, 0.19171035f, 0.08805841f, -0.02266607f, -0.18088309f, 0.01595892f, 0.13192299f, 
    -0.05966131f, -0.15947083f, 0.00256547f, -0.11055665f, -0.02259213f, 0.05238106f, -0.03138255f, -0.19644111f, 
    0.23346813f, 0.47422680f, -0.32116219f, -0.21246690f, -0.33066720f, -0.06415316f, 0.08935689f, 0.01159246f, 
    0.11573444f, 0.03049469f, -0.01557040f, -0.16954584f, -0.10206155f, 0.08421720f, -0.09922545f, -0.02135067f, 
    -0.06013818f, 0.09871764f, -0.01261347f, -0.00240465f, -0.35919115f, 0.28301194f, -0.13794209f, 0.11234032f, 
    -0.06326278f, -0.15694407f, -0.40306738f, 0.22813784f, 0.11656332f, -0.05717732f, -0.04020726f, -0.15492839f, 
    -0.03676696f, -0.07162264f, -0.09673063f, 0.01413843f, 0.06210765f, 0.02272951f, 0.17858769f, -0.03519741f, 
    -0.79930383f, -1.26454914f, -0.21189687f, -0.28986976f, -0.45289853f, -0.33974272f, -0.19460425f, -0.00806597f, 
    0.14349462f, -0.11208375f, -0.17438175f, -0.01801535f, 0.02181161f, 0.05641191f, 0.04491517f, 0.19756313f, 
    0.05675092f, -0.03666398f, 0.14558268f, 0.16871166f, -0.35367450f, -0.58031809f, -0.35022613f, -0.21985722f, 
    0.04846368f, -0.07553843f, 0.02987373f, -0.04980435f, -0.02842542f, 0.07918514f, -0.07930126f, -0.06694116f, 
    0.03305974f, 0.14103173f, -0.03826372f, 0.07700570f, 0.06669341f, -0.14943917f, -0.07769637f, -0.02742437f, 
    -0.84927142f, -0.03948481f, -0.22662640f, 0.16368100f, 0.32071128f, 0.04369480f, -0.08087917f, 0.09172221f, 
    0.05271154f, 0.10371091f, 0.04034210f, 0.03464445f, -0.00756414f, 0.08498093f, 0.10689075f, 0.01763651f, 
    0.05864072f, -0.07701370f, 0.01298952f, -0.09358955f, -0.05755883f, -0.25942627f, 0.02932420f, 0.18943375f, 
    -0.20842433f, -0.04462154f, -0.00719535f, 0.00908705f, -0.24107136f, -0.10035363f, -0.08109404f, 0.17580086f, 
    -0.09690476f, -0.08325382f, 0.14348558f, 0.00389464f, -0.00270854f, 0.22787999f, 0.00755511f, 0.10362298f, 
    -0.35310969f, 0.12333708f, 0.02174516f, 0.05367575f, 0.13152948f, -0.04741177f, -0.03793069f, 0.14975704f, 
    -0.08001519f, 0.02371022f, -0.04606600f, -0.04139015f, -0.04585896f, 0.00840089f, 0.04168039f, -0.12164603f, 
    0.19643693f, -0.10870699f, -0.01485534f, -0.15925884f, 0.02415414f, 0.50044745f, -0.05154540f, -0.20677757f, 
    -0.28554884f, 0.02351190f, 0.03731443f, -0.03010832f, 0.06322427f, -0.08115564f, -0.04359878f, -0.00373067f, 
    0.13431253f, -0.04067286f, -0.01722086f, 0.10266472f, -0.09404251f, -0.04598967f, 0.06056095f, -0.17014839f, 
    -0.13786526f, 0.01875380f, -0.15422513f, 0.02538112f, 0.17653123f, 0.06933620f, -0.08302455f, -0.11506984f, 
    0.15497908f, -0.05120087f, 0.12969266f, 0.12481932f, -0.00132711f, 0.02789081f, -0.04333659f, -0.01706239f, 
    0.02115017f, 0.09022962f, 0.10879412f, 0.06872853f, -0.90580261f, 0.26931134f, -0.13042712f, -0.11652523f, 
    0.18976092f, 0.00926970f, -0.00943032f, -0.06773894f, 0.09487015f, -0.01497890f, -0.07023220f, 0.10062581f, 
    -0.20127305f, 0.13785669f, 0.10341080f, -0.02041320f, 0.00970134f, 0.21227440f, 0.07863123f, -0.13611102f, 
    -0.21605651f, 0.54341805f, 0.03593607f, 0.08092874f, -0.38813859f, -0.08355866f, -0.12052675f, 0.12702918f, 
    0.11276938f, -0.04479392f, -0.09571326f, -0.07160766f, -0.17985651f, 0.06333824f, 0.07858633f, 0.02723536f, 
    -0.09810796f, 0.15456454f, -0.03753147f, 0.20156699f, -0.10264123f, -0.14075594f, -0.03912167f, 0.27295482f, 
    -0.03188742f, 0.09409950f, 0.20481135f, 0.06726539f, 0.00987974f, -0.00121219f, 0.12297338f, 0.09171650f, 
    0.00954322f, -0.10201421f, -0.01966022f, -0.18958509f, -0.07756722f, 0.02604465f, -0.08395629f, 0.05889634f, 
    -0.00249365f, -0.19000898f, -0.11724550f, -0.09317379f, 0.45528391f, 0.03926381f, 0.12565133f, -0.18251899f, 
    0.23253052f, 0.05574849f, 0.26730746f, -0.09978380f, -0.00739959f, -0.08671314f, -0.01632315f, 0.00709788f, 
    0.03994305f, 0.02519111f, 0.14791197f, 0.15051877f, 0.02247178f, 0.11607517f, -0.16662738f, 0.13459995f, 
    0.17698012f, 0.20005593f, 0.09530792f, 0.05445646f, -0.03333550f, 0.15791337f, -0.04950367f, 0.08471193f, 
    0.01635308f, -0.02773840f, -0.06048301f, -0.02279577f, -0.03356431f, 0.08898477f, 0.10273947f, -0.15407057f, 
    -0.19925147f, -0.14146057f, -0.46238184f, 0.12255318f, -0.48621249f, -0.10898644f, 0.08997880f, 0.07914127f, 
    -0.05188159f, 0.00358245f, -0.09689505f, -0.20050883f, -0.00350877f, 0.03902882f, 0.08561677f, -0.17278717f, 
    0.16408278f, -0.08836498f, -0.01335500f, -0.02057464f, -0.36163431f, -0.79880285f, 0.39289874f, 0.24489577f, 
    0.14987881f, -0.17333977f, 0.04008730f, -0.06660095f, -0.20265836f, 0.05451366f, 0.23297693f, -0.03837187f, 
    -0.08207289f, -0.17991221f, -0.00556855f, -0.02126571f, 0.01590100f, -0.10095451f, -0.00642029f, 0.02229862f, 
    0.16836579f, 0.30303922f, -0.21353406f, 0.04206881f, -0.01971347f, 0.15687458f, -0.10817499f, -0.08684326f, 
    0.00318819f, -0.29105714f, -0.06831072f, 0.12693709f, 0.07419691f, -0.10595082f, -0.30771375f, -0.12100820f, 
    0.05541569f, -0.41319558f, -0.01583852f, 0.08721985f, -0.21507947f, -0.37229416f, -0.04233180f, -0.22576208f, 
    0.07261448f, -0.22483672f, 0.10739046f, -0.06681369f, -0.08554006f, 0.00231658f, -0.12980558f, -0.12985896f, 
    0.29892641f, 0.16567545f, -0.01366838f, -0.09974962f, 0.07857580f, 0.03063754f, 0.35127035f, 0.06297633f, 
    0.07523784f, 0.07249869f, -0.02454604f, 0.08937948f, -0.01352863f, -0.03659548f, -0.22961637f, 0.10245387f, 
    0.18892384f, 0.05810116f, 0.06311289f, -0.01890421f, 0.09447718f, 0.00421950f, 0.10710039f, 0.06849986f, 
    0.09202712f, -0.13011870f, 0.02880307f, 0.02572962f, 0.08624984f, 0.21225236f, 0.37579471f, 0.02991721f, 
    -0.37807781f, -0.10311285f, -0.08212904f, 0.06522925f, 0.07303386f, 0.08574527f, 0.12239862f, -0.05797173f, 
    0.04830549f, -0.00972145f, -0.10870131f, -0.09000497f, -0.00427009f, -0.08265537f, -0.11026178f, 0.07973323f, 
    -0.52781534f, 0.12062859f, -0.24115188f, -0.15316020f, -0.07936423f, 0.05872301f, -0.04360171f, 0.12476130f, 
    -0.11579010f, -0.24675384f, 0.00246848f, 0.06117204f, -0.06039193f, -0.15074717f, -0.03010364f, 0.09576552f, 
    0.05337592f, 0.07879359f, 0.14537047f, 0.02427448f, 0.17057344f, 0.03016972f, 0.30529857f, 0.53920764f, 
    -0.13923863f, -0.17181261f, -0.13194436f, -0.13687323f, 0.22677025f, 0.06382417f, -0.19747971f, -0.22587860f, 
    -0.08880269f, 0.22974320f, 0.00759325f, 0.09806963f, 0.13360755f, -0.33507708f, -0.12138210f, 0.03440715f, 
    0.46252018f, 0.13740872f, -0.22423308f, -0.04507251f, -0.28651395f, -0.02654340f, -0.09930201f, 0.09101329f, 
    0.10821298f, 0.06558381f, -0.04508709f, 0.08705519f, -0.11897828f, -0.12955520f, -0.01311892f, -0.15768187f, 
    -0.18311174f, 0.09721567f, -0.02317511f, -0.02910760f, -0.46226475f, -0.34251815f, 0.01980724f, 0.03774330f, 
    0.10628843f, -0.00448457f, -0.20039889f, 0.08007751f, -0.07477874f, 0.03570502f, 0.07563241f, -0.12082651f, 
    -0.00404496f, -0.02583214f, 0.00664667f, -0.18758027f, 0.00901225f, 0.00654587f, -0.01442185f, -0.06085915f, 
    -0.46987888f, -0.27771288f, -0.27982694f, -0.09613422f, 0.04092125f, 0.18459353f, 0.14229110f, 0.00425842f, 
    -0.04549620f, -0.23221697f, -0.07403178f, 0.06457718f, 0.06885006f, 0.11651971f, -0.04911578f, 0.05892219f, 
    -0.02311162f, 0.05900078f, -0.23961264f, 0.12717953f, -0.57651591f, 0.30706415f, -0.45864239f, -0.19696873f, 
    -0.12468862f, 0.11621448f, 0.05326166f, 0.06427828f, -0.12620415f, -0.18513395f, 0.03419341f, -0.15531582f, 
    0.07470246f, -0.17318654f, 0.05790328f, 0.15722665f, 0.09949545f, -0.16329964f, 0.26211566f, -0.02050944f, 
    -0.29711887f, -0.08428820f, -0.41200766f, 0.19472633f, 0.17361128f, 0.16527423f, 0.08866508f, -0.10352092f, 
    0.03252081f, -0.00425126f, 0.07487854f, 0.20860179f, 0.15257786f, 0.06529423f, -0.08480385f, -0.16128664f, 
    -0.17723277f, -0.00028810f, -0.03979982f, -0.36445525f, -0.03982877f, -0.02246246f, -0.24515930f, 0.09224866f, 
    0.28254688f, -0.06330841f, -0.10485709f, -0.12809901f, 0.13010103f, 0.13870512f, 0.07253868f, 0.00518000f, 
    0.09518155f, 0.24808714f, 0.13157576f, 0.01107597f, 0.18351609f, -0.08478440f, -0.27727929f, -0.01331417f, 
    -0.31963110f, 0.18998623f, -0.40513176f, -0.02609235f, -0.06988994f, 0.27301824f, 0.09485246f, 0.20734845f, 
    -0.22785819f, 0.21335126f, 0.06481903f, 0.09256293f, 0.06004298f, -0.14399338f, 0.04757282f, -0.15170917f, 
    -0.04756935f, 0.00230145f, -0.10999004f, -0.04961605f, -0.96077299f, -0.11422220f, -0.21594730f, -0.38224593f, 
    0.10499918f, 0.16588075f, -0.14154252f, -0.13386865f, 0.05921364f, -0.09484278f, 0.06492336f, 0.02214800f, 
    -0.16191751f, 0.04224434f, -0.19449328f, -0.01092904f, 0.04789250f, -0.14420667f, -0.22098640f, 0.08642621f, 
    -0.14113156f, 0.29452771f, 0.17358384f, -0.04498429f, 0.01705327f, -0.05866563f, 0.01432192f, 0.02263362f, 
    -0.14396203f, 0.18291806f, 0.06732815f, -0.11353835f, -0.09386048f, -0.12335315f, -0.17990594f, 0.00192414f, 
    0.06524140f, -0.21135730f, 0.22517531f, 0.08186290f, 0.16487473f, 0.09679844f, -0.00575554f, 0.29660210f, 
    -0.00309927f, -0.20489065f, 0.03449495f, -0.04045359f, 0.09286205f, 0.09700242f, -0.06324956f, -0.15101498f, 
    0.08167697f, 0.22191934f, 0.23502584f, 0.02485964f, 0.08886100f, 0.16630782f, 0.13384181f, -0.03407571f, 
    -0.67344469f, -0.13887015f, 0.17713606f, 0.15489972f, -0.03566903f, -0.00807825f, -0.14512759f, -0.00168466f, 
    -0.17184037f, 0.21592161f, 0.08115161f, -0.00150219f, -0.02101736f, -0.04678177f, -0.20529671f, 0.07192804f, 
    0.11323941f, 0.01555569f, -0.04947056f, 0.16141231f, -0.11242546f, 0.59265405f, 0.05786084f, -0.06620670f, 
    -0.05188588f, 0.02211524f, 0.10551029f, 0.41687584f, -0.03593287f, 0.00266477f, 0.24181019f, -0.08585194f, 
    -0.14521369f, -0.14747834f, -0.10991867f, -0.02188799f, -0.02949586f, 0.02649391f, -0.19779284f, 0.12401196f, 
    0.06027048f, 0.15914463f, 0.37055516f, 0.18784563f, -0.17191300f, 0.05765419f, 0.10835665f, -0.06828608f, 
    -0.06623589f, -0.03227944f, 0.21470267f, 0.04752406f, -0.00430520f, 0.03176122f, -0.01691582f, 0.02452637f, 
    -0.14470293f, 0.11983039f, 0.20471652f, -0.04124039f, 0.08360076f, -0.26452351f, -0.09341069f, 0.12586676f, 
    0.50335318f, 0.06265603f, -0.01199964f, 0.01748595f, -0.13544765f, 0.01638588f, -0.08252716f, 0.05126055f, 
    0.13179882f, 0.06657068f, 0.12188929f, -0.11077918f, -0.04485306f, 0.00295163f, 0.09439265f, 0.01233264f, 
    0.00783996f, -0.88370544f, 0.03613040f, -0.33468872f, 0.16091828f, -0.05060364f, -0.03238425f, -0.00403670f, 
    0.01047731f, 0.02148097f, -0.19743910f, 0.15467064f, 0.03393346f, 0.12175555f, 0.07132966f, -0.17221588f, 
    -0.07328273f, -0.11228015f, -0.22112420f, -0.07562932f, -0.22475159f, 0.23521923f, -0.07199398f, 0.04033768f, 
    -0.17874314f, 0.15429221f, -0.09027110f, 0.01361780f, -0.08000559f, 0.13799857f, 0.01185967f, 0.03349775f, 
    -0.09846365f, -0.04133997f, -0.13961847f, 0.09785722f, 0.03591995f, 0.04752504f, -0.01293816f, 0.13308077f, 
    0.58195430f, -0.48823184f, 0.10110258f, -0.10209221f, -0.18556547f, 0.17737889f, 0.09906039f, 0.08839790f, 
    -0.24702361f, -0.05896211f, -0.08911126f, -0.09426858f, 0.02411875f, -0.00418243f, 0.07156100f, 0.19538285f, 
    0.06611487f, 0.12341503f, 0.14309467f, 0.07025301f, 0.07391824f, -0.34564418f, 0.18383817f, -0.04981129f, 
    0.43998760f, 0.06188673f, 0.06681576f, 0.03833611f, 0.00422726f, -0.12893938f, -0.05846195f, -0.22329827f, 
    0.07822029f, 0.05471787f, -0.22484833f, 0.06816020f, 0.06444222f, 0.04950619f, 0.22351080f, 0.12670439f, 
    -0.10161655f, 0.05432113f, -0.02202532f, -0.31431302f, -0.10567709f, -0.02324716f, 0.01652535f, 0.11818401f, 
    -0.03624726f, 0.14197573f, 0.18341435f, -0.06961250f, 0.05345031f, -0.03348159f, 0.12858744f, -0.20164183f, 
    -0.18250482f, 0.03630535f, 0.15141605f, -0.03841676f, 0.65232104f, -0.85615861f, -0.23813139f, -0.21986777f, 
    -0.07396140f, -0.00900890f, 0.13277844f, -0.02224846f, -0.03593740f, -0.05427643f, 0.12055375f, 0.17045295f, 
    0.08534351f, 0.24557297f, 0.02825541f, 0.00141755f, 0.06901231f, -0.05572709f, -0.20525616f, 0.09468868f, 
    0.24704708f, 0.09076113f, -0.56734836f, -0.54741240f, 0.55064785f, -0.07402084f, -0.13676189f, 0.11108723f, 
    0.10562532f, -0.14167231f, -0.03020808f, -0.03318109f, 0.04640871f, -0.04770573f, -0.15107553f, 0.18052226f, 
    -0.02047998f, 0.21056858f, 0.07915419f, 0.33707392f, 0.14942043f, 0.02463176f, -0.14509280f, -0.36686900f, 
    -0.01321351f, 0.08833840f, -0.01478215f, 0.00555215f, -0.16207819f, -0.14690362f, -0.02056384f, -0.12697934f, 
    -0.09256586f, -0.04923060f, 0.00039982f, -0.02394939f, -0.06350080f, 0.23182724f, 0.00082682f, -0.10050274f, 
    -0.61784333f, 0.20704657f, 0.02183600f, -0.69885832f, -0.08461730f, -0.09718356f, -0.21252383f, -0.12789342f, 
    0.02135503f, -0.13813783f, -0.11606533f, 0.07382844f, -0.17566954f, -0.04235801f, 0.09940497f, 0.18695620f, 
    -0.06411605f, 0.04003412f, 0.11707554f, 0.12264466f, -0.32272264f, 0.14564517f, -0.08471817f, -0.20103939f, 
    0.30023858f, -0.05496635f, 0.02624272f, 0.16861194f, -0.18231453f, -0.01499604f, 0.03848486f, -0.15356365f, 
    0.04475699f, -0.07777144f, -0.02796315f, -0.05992379f, -0.01278105f, -0.13431051f, 0.13794142f, 0.31283247f, 
    0.30827028f, -0.04712291f, -0.17155781f, 0.49528527f, -0.20786545f, -0.04233234f, 0.24584536f, -0.26933387f, 
    0.17981005f, 0.00899525f, 0.09577269f, 0.13136818f, -0.13424997f, 0.02383400f, -0.02379945f, -0.05659554f, 
    0.07225642f, 0.22722508f, -0.22045505f, -0.02692884f, -0.33125636f, 0.60030627f, 0.08583734f, -0.01955411f, 
    -0.29243881f, -0.04031663f, 0.01929520f, 0.09143634f, 0.02486635f, -0.03034298f, -0.09803458f, 0.05576804f, 
    -0.10572132f, -0.10288053f, -0.19615684f, -0.03488212f, 0.03696147f, -0.15012662f, 0.12455069f, 0.01784044f, 
    -0.13637798f, -0.11922819f, 0.11900336f, 0.28202698f, 0.01303341f, -0.27414018f, -0.05334387f, -0.04279148f, 
    0.00040666f, 0.05055745f, -0.04020359f, -0.12871756f, -0.00759230f, 0.30772394f, 0.04544783f, -0.07732370f, 
    -0.09992131f, -0.06298891f, 0.11179404f, -0.11785171f, 0.21847259f, -0.27903378f, 0.03021641f, -0.09322120f, 
    0.19252171f, -0.09890777f, 0.04450470f, -0.21024460f, 0.06948535f, 0.00194982f, -0.01739217f, -0.05619533f, 
    -0.01207782f, 0.09327310f, -0.01460306f, 0.22746523f, -0.00327969f, 0.00085091f, -0.05523634f, 0.03438502f, 
    -0.24699500f, 0.32532698f, -0.03686890f, 0.45741689f, -0.22990425f, -0.14103466f, -0.12343865f, 0.09652241f, 
    0.11209904f, 0.10611698f, -0.17617802f, 0.02388821f, -0.10212522f, 0.14386421f, 0.03160391f, 0.06311151f, 
    -0.09356145f, -0.21359389f, -0.20292951f, -0.13777882f, -0.55738318f, 0.30238357f, -0.10144599f, 0.10027200f, 
    -0.53972834f, -0.01171698f, 0.09973899f, 0.13728754f, 0.12372416f, 0.02838953f, 0.04211127f, -0.05681533f, 
    0.21744767f, 0.03150424f, -0.00083163f, 0.01067270f, -0.09883500f, 0.01816580f, 0.06238577f, -0.02524865f, 
    0.03405336f, -0.05873553f, 0.28830388f, 0.19939184f, 0.12093344f, 0.02020149f, 0.12246265f, -0.08761927f, 
    0.10837026f, -0.15852827f, -0.10560228f, -0.03262578f, 0.00754255f, 0.02423678f, -0.00445356f, 0.00207968f, 
    -0.04382594f, 0.01803620f, 0.03304117f, -0.01349723f, -0.33298025f, 0.08215901f, -0.00135607f, -0.09612587f, 
    0.28307590f, 0.07047315f, -0.12637088f, -0.34363297f, -0.01004289f, -0.08485672f, -0.00132681f, -0.03468964f, 
    0.13172887f, -0.05056851f, -0.11270615f, -0.17037889f, -0.11702408f, -0.04046120f, 0.04447420f, 0.03731781f, 
    0.48207241f, -0.63340306f, 0.16045108f, -0.03385450f, 0.07987393f, 0.15224941f, 0.06350355f, -0.01856424f, 
    -0.06167118f, 0.12570861f, -0.15016156f, -0.02744271f, -0.11564932f, 0.10519715f, -0.06293809f, -0.09239785f, 
    0.08105980f, -0.07847776f, -0.12475362f, -0.14878277f, 0.23895971f, 0.26527610f, 0.28240120f, -0.20588665f, 
    0.40665111f, -0.18119976f, 0.22257881f, -0.06840801f, 0.00394081f, 0.01743999f, -0.02913654f, -0.00215602f, 
    -0.17983480f, -0.10937900f, 0.02047821f, -0.02408354f, -0.01573541f, 0.12727535f, 0.00220599f, -0.10497011f, 
    0.24415389f, 0.12469972f, 0.19888693f, -0.01582233f, 0.30315638f, 0.02178796f, -0.00988749f, -0.18447015f, 
    -0.09588870f, -0.01197926f, 0.01103559f, -0.00624809f, -0.06460910f, -0.08682853f, -0.02012231f, -0.04473049f, 
    0.10629457f, -0.00949854f, 0.11889210f, -0.18920439f, -0.05079440f, 0.30143458f, 0.44246024f, 0.04128380f, 
    0.20078522f, 0.15776628f, 0.22026786f, 0.02146230f, 0.01793469f, -0.10735157f, -0.04482684f, 0.02108555f, 
    -0.02497820f, -0.04492505f, -0.11919025f, -0.06263718f, 0.02411916f, 0.02921876f, 0.03323450f, 0.00629658f, 
    -0.03997070f, 0.10632194f, 0.03083641f, 0.26599196f, 0.37252378f, -0.28373742f, 0.01973092f, -0.22916473f, 
    -0.17989783f, 0.00105722f, -0.19596456f, -0.01587090f, -0.14522326f, -0.22903840f, -0.08658087f, 0.14323474f, 
    0.09206615f, 0.09166837f, -0.17267039f, -0.02806346f, 0.14960773f, 0.09300698f, -0.02771703f, -0.02150659f, 
    0.21060762f, -0.18165794f, 0.00346856f, -0.03176537f, -0.21889232f, -0.14104991f, -0.19637257f, -0.00253096f, 
    -0.02370577f, -0.02839019f, -0.06116427f, -0.26118955f, -0.11083287f, 0.07682164f, 0.08056429f, -0.13068226f, 
    0.01835204f, 0.26595846f, 0.25062829f, 0.29239443f, 0.29057798f, 0.28605333f, 0.28521350f, -0.08030650f, 
    -0.11340610f, -0.00340955f, -0.09585270f, 0.06981390f, -0.09477808f, -0.19122386f, -0.24671458f, 0.10477645f, 
    0.05587661f, -0.15863447f, 0.06809958f, 0.10924844f, 0.31370795f, -0.04293441f, 0.38479131f, -0.16904332f, 
    0.08529422f, 0.04510997f, 0.02237613f, -0.10954830f, -0.05229699f, 0.08438579f, -0.11929311f, 0.09165630f, 
    -0.05412770f, -0.03778811f, -0.08589059f, -0.01355010f, -0.11397787f, 0.03859683f, 0.26241952f, -0.11668792f, 
    -0.34400985f, 0.42463604f, 0.06245718f, -0.11796648f, 0.02477064f, -0.13437895f, 0.06362085f, -0.19681641f, 
    0.04617080f, -0.09176236f, -0.01060756f, 0.07857844f, 0.02003212f, -0.17924961f, -0.10501532f, 0.07094120f, 
    -0.02916788f, 0.17807844f, 0.04463308f, -0.08727808f, -0.58794200f, -0.22156636f, -0.62257242f, -0.25066334f, 
    -0.13298190f, 0.02156166f, -0.15061793f, -0.05754608f, -0.08095701f, -0.19195697f, -0.19704840f, -0.07403178f, 
    0.06352575f, -0.10313675f, -0.05126766f, -0.09199595f, 0.03522538f, -0.04769702f, -0.05323532f, 0.15350007f, 
    -0.61319584f, 0.00219524f, 0.07299253f, 0.11932192f, -0.33001432f, 0.12314474f, -0.11458284f, -0.13729346f, 
    0.15495513f, 0.02327689f, -0.04723747f, -0.09377012f, -0.08757284f, -0.03046073f, 0.07519734f, -0.10123286f, 
    -0.27429512f, 0.06650695f, -0.05066872f, -0.09833163f, -0.19663431f, 0.16498402f, 0.29822341f, 0.03357874f, 
    0.27234200f, 0.25898138f, 0.16761911f, 0.09627990f, 0.12447888f, 0.03910571f, -0.05874853f, 0.00564560f, 
    0.12196598f, 0.10768691f, -0.25068140f, 0.09111334f, -0.08105896f, -0.13177851f, 0.12670261f, -0.04375836f, 
    -0.02206891f, -0.11513823f, 0.01470755f, -0.25823236f, -0.29123908f, -0.09816104f, -0.28485212f, -0.02664338f, 
    -0.13575985f, -0.21516529f, 0.14576717f, 0.01109980f, -0.24432385f, -0.08966565f, -0.43007258f, 0.02576000f, 
    -0.12773497f, -0.02245357f, -0.18675558f, 0.02092369f, -0.24385150f, 0.05935488f, -0.23091412f, 0.04424545f, 
    -0.11796915f, -0.19994296f, 0.06884702f, 0.04429167f, -0.02498529f, -0.02318049f, -0.21980247f, 0.01211943f, 
    0.12947859f, -0.08825164f, -0.11897815f, 0.01451009f, -0.05655140f, -0.10111151f, -0.01541246f, -0.16181585f, 
    -0.06861373f, 0.01837342f, 0.33430916f, 0.06667307f, 0.36060143f, -0.24942183f, -0.14366056f, -0.06341759f, 
    -0.11298293f, -0.08583125f, -0.02515006f, -0.13536839f, 0.00780257f, -0.33810237f, 0.05952920f, -0.04056158f, 
    -0.00534336f, 0.06776848f, 0.14677557f, 0.11860005f, -0.25748962f, -0.00066805f, -0.74621725f, -0.55758816f, 
    -0.40256065f, 0.26854184f, -0.13861707f, -0.29211682f, 0.13410479f, -0.06701791f, 0.14698547f, 0.07875214f, 
    0.13837332f, 0.05601873f, 0.13585846f, 0.19352596f, -0.13160910f, -0.25357610f, 0.10352815f, 0.00071265f, 
    -0.08926862f, -0.09050199f, 0.06226553f, 0.03525047f, 0.08158054f, 0.10297170f, 0.10433104f, 0.07019632f, 
    0.01052782f, 0.02011310f, 0.00926889f, 0.06513328f, -0.22510557f, 0.04800263f, -0.00942314f, -0.05975390f, 
    0.00253632f, -0.03786200f, -0.11299007f, -0.17313519f, -0.12294754f, 0.60589933f, -0.36050719f, -0.25038451f, 
    -0.29623002f, -0.11840013f, -0.04055536f, -0.00013477f, -0.00363349f, -0.03008667f, 0.13986386f, -0.07500660f, 
    -0.06643464f, 0.01546247f, 0.09703576f, -0.04710836f, 0.06332230f, -0.30023283f, 0.13266212f, 0.19799669f, 
    -0.58319777f, -0.23762935f, 0.33347830f, -0.23553942f, 0.05255171f, 0.02603702f, -0.07876566f, 0.05963522f, 
    -0.01374089f, -0.22466393f, -0.01609576f, -0.03541270f, 0.13541903f, 0.03897047f, 0.02527024f, -0.05092344f, 
    0.10440605f, 0.08358367f, -0.39518538f, -0.10828827f, 0.06698228f, -0.30587754f, 0.25429693f, 0.07390404f, 
    0.20164475f, -0.40261918f, -0.12567958f, -0.06885001f, -0.18010710f, 0.06578046f, 0.05875134f, -0.18967055f, 
    -0.12114424f, -0.14861296f, 0.08856556f, 0.12389157f, -0.17468670f, -0.19121625f, 0.17206727f, 0.06433361f, 
    -0.21390416f, 0.10273459f, 0.37702054f, -0.02151314f, -0.18234017f, -0.07772650f, -0.05017925f, -0.09289946f, 
    -0.01838655f, -0.07545426f, 0.14066872f, 0.01029173f, 0.11286057f, -0.01347115f, -0.10150201f, -0.18426947f, 
    0.12464199f, -0.03266061f, -0.04581693f, -0.18610857f, -0.15980896f, 0.00606428f, 0.12828708f, -0.37628904f, 
    -0.26882076f, -0.25444663f, -0.08627158f, -0.01271692f, 0.10575731f, -0.23434378f, 0.00661067f, 0.15010726f, 
    -0.03176253f, 0.12046441f, -0.01436870f, 0.19696184f, 0.02126152f, -0.20979980f, -0.22228222f, 0.25956348f, 
    -0.30210277f, -0.26152319f, 0.54996693f, -0.56083190f, -0.11424734f, 0.04755196f, 0.09290490f, -0.11796715f, 
    -0.23268241f, -0.04211876f, 0.02801483f, 0.14363070f, -0.20940588f, -0.01671903f, -0.00127067f, -0.27018863f, 
    0.16666013f, 0.19486706f, -0.51760262f, -0.12564492f, -0.38261935f, -0.04652299f, 0.30460584f, -0.03267021f, 
    0.00537867f, -0.01300155f, -0.04025247f, 0.01708084f, -0.16397327f, -0.09808998f, 0.07617819f, -0.12371600f, 
    -0.00737636f, 0.21911150f, 0.03569964f, 0.07742224f, -0.08107615f, -0.10875614f, -0.20514251f, 0.04963149f, 
    -0.00370982f, 0.08838836f, -0.11276536f, 0.12615475f, -0.18315035f, -0.06592828f, 0.13233589f, -0.19565015f, 
    -0.06863026f, -0.11373524f, 0.23135121f, 0.03823369f, 0.12061839f, 0.04019212f, 0.26289228f, -0.00942421f, 
    0.01032105f, -0.00838217f, 0.27285686f, -0.00764828f, -0.12095167f, -0.06887225f, -0.23345412f, -0.05094821f, 
    0.17449126f, 0.22824398f, 0.17105912f, -0.12355987f, -0.04382300f, -0.02687335f, 0.06424809f, 0.07101313f, 
    0.09137993f, 0.14575155f, -0.06605785f, -0.11691549f, 0.23286605f, 0.24158195f, 0.02364774f, -0.11515844f, 
    0.02657979f, 0.19030961f, -0.14904074f, -0.11500159f, -0.13011986f, 0.05009778f, -0.06961778f, -0.32880157f, 
    0.02363218f, 0.06639332f, -0.07311843f, 0.14401591f, 0.12204666f, 0.00290215f, -0.07059372f, -0.11774945f, 
    0.13117084f, -0.12738594f, 0.06405081f, -0.02822188f, 0.10494132f, -0.10475265f, -0.00476346f, -0.13902502f, 
    -0.01883437f, 0.07335637f, -0.12316612f, -0.05938387f, -0.40002340f, 0.22518797f, 0.13442914f, -0.04625602f, 
    -0.29959774f, 0.09006787f, 0.07917052f, -0.04738169f, -0.17610446f, 0.03102472f, -0.10795057f, -0.01335487f, 
    0.46453527f, 0.45106041f, -0.04632442f, 0.07904682f, 0.30021694f, 0.03861959f, 0.10255230f, -0.32745564f, 
    -0.01836642f, -0.09555895f, 0.04061123f, 0.04233439f, -0.09020600f, -0.11259428f, -0.01597414f, -0.19259413f, 
    0.11571439f, 0.06265479f, 0.18545474f, 0.02486582f, 0.10011835f, -0.14857456f, 0.03213166f, 0.23196948f, 
    0.11967757f, -0.00390852f, 0.14407824f, -0.18984915f, -0.17053588f, -0.08621214f, 0.10596064f, -0.01853195f, 
    0.10424341f, -0.00669730f, 0.20474778f, -0.23772377f, 0.04693526f, -0.03137987f, 0.15526561f, -0.09987311f, 
    0.88011181f, 0.17322695f, -0.15743735f, -0.14410925f, 0.05256563f, 0.18982448f, -0.11478049f, -0.10985618f, 
    0.03538501f, -0.00483389f, 0.00687144f, 0.01432391f, 0.12018957f, 0.24350390f, 0.00912623f, -0.00789960f, 
    -0.10269123f, -0.00201732f, -0.05176745f, -0.02640463f, -0.05772288f, -0.30657712f, 0.23293176f, -0.29072544f, 
    -0.03610173f, -0.20457736f, 0.08103950f, 0.05089372f, 0.13789353f, -0.06507820f, -0.03478339f, -0.13382617f, 
    0.10335090f, -0.09738689f, -0.17218649f, -0.22472362f, 0.08178499f, 0.10117015f, 0.09614666f, -0.06438990f, 
    0.20543315f, -0.73237097f, 0.37196630f, 0.13710327f, -0.11583720f, -0.02317089f, 0.08794773f, -0.16008197f, 
    -0.06399953f, -0.00413746f, 0.08305939f, -0.08820269f, 0.23785207f, -0.03287435f, 0.18315470f, 0.00173135f, 
    0.17025766f, -0.03518815f, 0.04036678f, 0.03574207f, -0.97315156f, 0.36202335f, -0.38282093f, 0.18195334f, 
    -0.38553762f, 0.12390239f, 0.04761906f, -0.11076153f, -0.08798069f, 0.08362175f, 0.04487285f, 0.01174526f, 
    -0.08173209f, 0.16671076f, 0.22681272f, 0.04504560f, -0.15058309f, 0.09112030f, -0.17285371f, -0.10570058f, 
    0.34574565f, 0.17949404f, -0.19621405f, 0.10940868f, 0.07537343f, -0.04734679f, 0.04456488f, -0.00119997f, 
    0.03122041f, 0.00821165f, -0.28483099f, 0.12915827f, -0.08665530f, 0.00146580f, 0.02910537f, 0.29342818f, 
    0.01799638f, 0.02410717f, 0.11222136f, 0.21959481f, -0.18720043f, -0.43702999f, -0.03366674f, 0.19126132f, 
    0.24530819f, 0.12998444f, -0.23781531f, -0.14717646f, -0.10775231f, 0.22906864f, -0.08318532f, 0.01797434f, 
    0.03004115f, 0.10996907f, -0.07637277f, -0.08066253f, -0.15807350f, -0.06526416f, -0.07202986f, -0.06074903f, 
    0.16129072f, 0.22607863f, -0.19625042f, -0.10136490f, -0.32129833f, 0.09503172f, 0.08689031f, 0.05286430f, 
    0.03779895f, 0.13151252f, -0.13364308f, -0.10054135f, 0.22370400f, 0.13486490f, 0.19113904f, 0.18004337f, 
    0.21045408f, -0.14443052f, -0.32512563f, -0.10440663f, -0.22584522f, 0.02177777f, -0.17067963f, 0.09852274f, 
    0.11283741f, -0.11159417f, 0.05780494f, 0.04127583f, -0.11002713f, -0.04698919f, 0.17127863f, -0.06931882f, 
    -0.30959085f, -0.19093861f, -0.09609423f, 0.03426436f, -0.06816044f, -0.04821185f, 0.20008425f, 0.03270669f, 
    0.18814170f, -0.13709542f, -0.38008669f, 0.37207630f, -0.10264337f, -0.14431010f, 0.14659302f, 0.02080546f, 
    -0.10422278f, 0.11390367f, -0.14189805f, 0.02748765f, -0.04845306f, 0.08645038f, 0.13224709f, 0.08766259f, 
    -0.17699414f, 0.11461049f, -0.01015002f, 0.02257676f, 0.16087614f, -0.55224526f, 0.02547480f, 0.29796633f, 
    -0.13064019f, -0.12162486f, -0.00606618f, -0.18152286f, 0.12328395f, 0.03982432f, -0.09817400f, 0.15838934f, 
    -0.09886175f, -0.08018855f, -0.01695174f, -0.17497058f, 0.04250478f, 0.09267055f, 0.09590538f, -0.01953500f, 
    -0.70359766f, 0.46990374f, 0.52835089f, -0.13658626f, 0.14247164f, 0.10927784f, 0.13515618f, 0.14482638f, 
    -0.06034846f, 0.11440456f, 0.01106761f, -0.00409550f, 0.21798070f, -0.02409104f, -0.00651088f, 0.05440567f, 
    -0.09017909f, 0.23680632f, -0.25408480f, 0.17823012f, 0.23282325f, -0.22935411f, 0.32386196f, -0.29238737f, 
    -1.02185392f, 0.05442243f, 0.11463980f, 0.19106612f, -0.22020316f, -0.00060070f, -0.08241482f, -0.01216196f, 
    -0.07817651f, -0.12138130f, -0.08999198f, -0.03200655f, -0.00951751f, -0.12459932f, 0.10893889f, 0.00575820f, 
    0.05736380f, -0.48611885f, -0.10493030f, -0.38114983f, -0.21042609f, -0.06566647f, 0.12285522f, 0.22022928f, 
    0.26872846f, -0.15694189f, 0.02491836f, 0.04360074f, 0.00194434f, -0.08952682f, 0.16119854f, 0.09423691f, 
    0.03431993f, 0.32797796f, -0.03386610f, -0.03642089f, -0.11969087f, -0.36196837f, -0.16438720f, 0.30745032f, 
    0.14719842f, 0.09661357f, 0.09939539f, -0.11495409f, -0.03560226f, -0.02747884f, -0.25211230f, -0.04358993f, 
    -0.01727560f, 0.17406602f, -0.02157956f, 0.10337081f, 0.11378212f, 0.11431206f, 0.00177791f, 0.20443355f, 
    0.06880252f, -0.47781378f, 0.05921147f, -0.10082834f, -0.12411763f, 0.08861639f, 0.09350787f, 0.02740827f, 
    -0.01549025f, -0.53298146f, 0.00821144f, -0.01857387f, -0.08857530f, 0.09462632f, -0.03241330f, 0.00415418f, 
    -0.01315326f, -0.25718018f, -0.10355365f, -0.06762854f, -0.55892074f, 0.27602625f, 0.06315036f, 0.05508782f, 
    -0.20856521f, 0.10595379f, 0.14478935f, -0.14936291f, -0.13870400f, -0.08547985f, -0.15156659f, 0.10224978f, 
    -0.12759335f, -0.01222096f, 0.07932179f, 0.14635848f, 0.01659627f, 0.25222737f, -0.02207381f, 0.07559113f, 
    0.32738212f, 0.20699224f, -0.06685615f, 0.05063468f, 0.00303998f, -0.19911839f, -0.08361159f, 0.08242113f, 
    0.06103619f, -0.04139173f, -0.07494946f, 0.02160879f, -0.03099249f, -0.08231604f, 0.06825496f, -0.10400804f, 
    0.02649706f, 0.20942473f, 0.05329951f, 0.03423906f, 0.23718315f, 0.18169105f, 0.34633785f, 0.23535515f, 
    0.17176433f, 0.23180123f, 0.10762272f, 0.22118698f, 0.04649173f, -0.01852677f, -0.10395544f, 0.07493521f, 
    0.11104139f, 0.08912349f, 0.23888688f, -0.01811351f, 0.07292780f, -0.37682229f, -0.14291729f, -0.03864973f, 
    -0.21318671f, -0.03509531f, -0.17439754f, -0.05107907f, 0.32945573f, -0.05425412f, 0.19348420f, -0.07731876f, 
    -0.01164386f, -0.13511600f, -0.08585484f, 0.09002159f, -0.02718977f, -0.00947035f, -0.07737923f, 0.12642875f, 
    -0.05439226f, 0.03522361f, -0.44194758f, 0.10812072f, -0.15599677f, -0.44638783f, -0.10765261f, 0.03093499f, 
    0.22856377f, -0.08427322f, 0.25058413f, 0.10258070f, -0.04108431f, -0.14260964f, 0.03322060f, -0.20596862f, 
    0.00154520f, 0.02564453f, 0.12819061f, -0.11375570f, 0.15490542f, -0.08223600f, 0.03985795f, -0.00625499f, 
    0.10064753f, 0.15742263f, -0.04661102f, -0.17594784f, -0.16958067f, -0.02024230f, 0.06411093f, 0.16751787f, 
    -0.07940070f, 0.07412704f, -0.01630567f, 0.07114959f, 0.10176430f, 0.13843250f, 0.03978031f, -0.00617302f, 
    0.07463422f, -0.16297199f, -0.29213110f, 0.14053960f, 0.56487876f, 0.28644869f, -0.44920206f, 0.21098699f, 
    -0.22540697f, -0.22491455f, -0.17866598f, 0.10864477f, 0.02509498f, -0.23053513f, -0.08770088f, -0.05854158f, 
    0.10206839f, -0.27598143f, -0.07860409f, 0.00187383f, 0.06413747f, 0.12461814f, -0.03563949f, 0.02793109f, 
    -0.18429199f, -0.29455149f, 0.21319133f, 0.14977485f, -0.20138912f, 0.01858650f, 0.00414370f, 0.01113222f, 
    0.09294134f, 0.09003410f, 0.05906571f, 0.05299179f, 0.12908410f, -0.04278002f, 0.10138574f, -0.16334142f, 
    -0.11176063f, -0.25971976f, 0.07564589f, 0.00916409f, 0.53295302f, 0.33125094f, 0.24744101f, -0.23181306f, 
    0.04158071f, 0.08332570f, -0.05441539f, 0.24591313f, 0.14968796f, 0.09097829f, -0.06733320f, -0.12695612f, 
    0.01498210f, 0.06319346f, -0.07843599f, 0.09798675f, 0.35791656f, -0.27079734f, -0.00103856f, 0.07768200f, 
    0.28481847f, -0.04678926f, 0.04709658f, -0.14676811f, -0.20833963f, -0.04494694f, -0.15503454f, 0.09193218f, 
    -0.07839698f, 0.08210459f, -0.06813593f, 0.04156423f, -0.11931826f, 0.03232972f, -0.24957041f, 0.01159476f, 
    -0.23130290f, -0.30823740f, -0.21922174f, -0.15367471f, 0.22297826f, 0.08560856f, 0.11389073f, 0.15139054f, 
    -0.08151331f, -0.02381177f, 0.03795345f, -0.09942033f, 0.09377688f, -0.03901000f, -0.11900575f, 0.20982930f, 
    0.05906244f, 0.06712181f, 0.03662284f, -0.07723083f, 0.03196397f, -0.02710735f, -0.30388951f, 0.04507280f, 
    -0.43795702f, -0.66798091f, -0.31114885f, -0.11410789f, 0.36459115f, 0.05203310f, 0.13231762f, 0.08018442f, 
    -0.01175426f, -0.13744411f, 0.18683793f, 0.04387204f, 0.10454742f, 0.09320342f, 0.12475522f, 0.23016958f, 
    0.02447323f, -0.06946164f, 0.27624264f, 0.09729095f, -1.16485262f, -0.39259493f, -0.09719380f, -0.34556395f, 
    -0.36969191f, 0.23023747f, -0.03353889f, -0.05991623f, -0.09786244f, 0.20050575f, -0.00357442f, 0.07917652f, 
    -0.01480511f, 0.42104182f, 0.08763783f, 0.22620609f, 0.01187275f, 0.01734388f, -0.22669336f, 0.02345345f, 
    -0.07007637f, -0.07046205f, -0.25605655f, 0.00137802f, 0.22416598f, 0.06326720f, 0.03514026f, 0.05690055f, 
    0.04049622f, 0.07445213f, 0.17562683f, 0.03159052f, 0.04001186f, -0.08126190f, 0.24517800f, 0.10947940f, 
    0.11403491f, 0.26706669f, 0.18070106f, 0.05786400f, 0.54907441f, -0.22008812f, -0.23779994f, 0.31266725f, 
    -0.03730329f, -0.22541723f, -0.20299859f, -0.15639278f, -0.09546194f, -0.12636821f, -0.01463904f, 0.19100879f, 
    -0.21715707f, -0.12784402f, -0.10066583f, -0.14182110f, -0.09217712f, -0.29328865f, -0.21077220f, -0.33586070f, 
    -0.88561106f, -0.51806581f, -0.29275057f, -0.33032760f, -0.12679963f, 0.07251275f, 0.11171628f, -0.34281403f, 
    -0.05386127f, 0.01327434f, 0.07307909f, -0.17454265f, -0.10835603f, -0.17372699f, 0.07699407f, -0.07262852f, 
    -0.03808274f, 0.25465447f, 0.10750626f, 0.07982627f, -1.31358790f, -0.93019080f, -0.00054798f, -0.11806014f, 
    -0.52746105f, -0.03069176f, -0.05431196f, -0.14120379f, -0.14233671f, 0.01723556f, 0.17185511f, 0.12120883f, 
    -0.05369896f, 0.01617186f, -0.08710740f, -0.05240394f, -0.14708948f, 0.01266195f, -0.09642447f, -0.05168571f, 
    -0.47470242f, -0.00106787f, 0.15316579f, -0.06815269f, 0.01653709f, -0.06086431f, 0.07306930f, 0.01601772f, 
    -0.01684854f, 0.04237482f, -0.00223712f, -0.16487668f, 0.02150799f, 0.05231060f, -0.14002962f, -0.06408605f, 
    -0.17770025f, 0.01102833f, -0.13514166f, -0.07015070f, 0.27143648f, 0.23749657f, -0.40066579f, -0.11612289f, 
    0.22347924f, 0.04428051f, 0.13808957f, -0.03544139f, 0.05501575f, -0.09874389f, 0.19100200f, 0.14675850f, 
    0.05272532f, -0.06165071f, -0.06483725f, 0.10376970f, 0.16156293f, -0.02836633f, 0.00254499f, 0.15975715f, 
    -0.46891001f, 0.54529816f, -0.24888557f, -0.29301661f, 0.16781259f, -0.20749743f, -0.28226012f, -0.00732383f, 
    0.23623677f, 0.13572741f, 0.05005954f, 0.10426432f, -0.08181378f, 0.10366727f, 0.14011818f, 0.15294048f, 
    0.13266806f, -0.02672832f, -0.06111426f, 0.07382223f, -0.52193105f, 0.34584752f, -0.01476615f, 0.08840086f, 
    0.03205945f, 0.45162183f, -0.09570290f, 0.13086425f, 0.13660623f, -0.03785774f, 0.08321744f, 0.23205616f, 
    0.04130963f, -0.02832553f, 0.14126040f, -0.11806735f, 0.26584959f, -0.04428253f, -0.14649583f, -0.11601406f, 
    -0.29973561f, 0.41925117f, 0.06121139f, -0.12587833f, 0.20145042f, -0.21947005f, -0.18752679f, -0.00785248f, 
    -0.39056009f, 0.07366383f, 0.21034093f, 0.00056633f, 0.08798125f, -0.08994071f, 0.07308625f, -0.05991939f, 
    0.01182221f, -0.00457785f, 0.03543479f, 0.04104778f, -0.25871006f, -0.03441928f, 0.07560968f, 0.12757924f, 
    0.03446641f, -0.08869781f, 0.19003659f, 0.14001091f, 0.10306539f, 0.11685174f, -0.25419790f, -0.13665894f, 
    0.04667886f, -0.08011510f, 0.02064447f, -0.00659758f, -0.09913906f, -0.04650248f, -0.23085652f, 0.02115860f, 
    -0.02411480f, -0.39616868f, 0.07233646f, 0.08252420f, 0.31932166f, 0.11037051f, -0.29244938f, 0.07643210f, 
    -0.05448139f, 0.00190687f, -0.07230819f, 0.06182593f, -0.08675010f, 0.03948909f, 0.08692998f, -0.18971789f, 
    0.05007328f, -0.02625330f, 0.13109399f, 0.02553716f, -0.19493860f, 0.08493249f, -0.18036275f, -0.22141138f, 
    0.11608010f, 0.09399541f, -0.12792812f, 0.07165705f, 0.06249595f, 0.05160915f, -0.01715837f, 0.03257715f, 
    -0.13680154f, -0.09139316f, 0.12476819f, 0.08551841f, -0.29554614f, 0.08634261f, 0.25551695f, -0.04295253f, 
    0.49403945f, 0.18344297f, 0.03458089f, -0.29390869f, 0.05060000f, -0.50681871f, -0.19455501f, 0.08701997f, 
    -0.10624812f, -0.42070872f, 0.11335651f, -0.02146623f, -0.04353769f, 0.09398524f, -0.04009754f, 0.02959650f, 
    -0.16805106f, -0.04599077f, 0.06977591f, 0.19362050f, -0.33785000f, 0.35731444f, 0.04453521f, -0.19332474f, 
    -0.22237159f, -0.17519388f, -0.24996646f, 0.04549992f, -0.33458123f, -0.16550729f, -0.02059560f, 0.03566040f, 
    -0.07121968f, -0.20858285f, 0.01497604f, 0.05181255f, 0.11405784f, 0.04877877f, 0.15227938f, -0.08871995f, 
    0.25458893f, -0.08588689f, -0.18445985f, 0.20014466f, 0.05570759f, 0.41514379f, -0.04305020f, 0.03347139f, 
    -0.05212962f, -0.12397657f, 0.08209916f, 0.05685142f, 0.16615695f, 0.10506444f, -0.05954979f, 0.00153990f, 
    -0.00318892f, -0.15733671f, -0.37750280f, 0.09497715f, 0.90335572f, 0.34707040f, -0.54414678f, -0.34117317f, 
    0.07635306f, 0.19490771f, 0.01483885f, -0.00073606f, 0.20711708f, -0.09336150f, 0.13410202f, 0.01452893f, 
    0.05273311f, 0.05365554f, 0.11852586f, 0.03476156f, -0.09238853f, -0.16763437f, -0.03392709f, 0.15614857f, 
    -0.03616980f, -0.51133251f, -0.06009582f, 0.05924819f, 0.09536582f, 0.00509361f, 0.09998211f, -0.26445299f, 
    0.09014941f, 0.02937719f, 0.04057212f, 0.05765827f, -0.06748738f, -0.09299259f, -0.13760529f, 0.03614874f, 
    -0.08294256f, 0.13351922f, 0.06946335f, -0.24413450f, 0.13210204f, -0.14460588f, 0.17476642f, 0.10203972f, 
    -0.14337854f, -0.07176669f, -0.05904738f, -0.02733112f, -0.23785600f, -0.39529511f, -0.52276802f, -0.01283680f, 
    0.06843248f, 0.03852945f, -0.03092242f, 0.04195904f, -0.09568035f, -0.04445381f, -0.08411377f, -0.22464508f, 
    -0.23963608f, -0.48781642f, -0.22563842f, -0.30984259f, -0.61916095f, 0.12102426f, 0.21671973f, 0.04703830f, 
    0.04903303f, 0.15328138f, -0.13284113f, -0.08345164f, 0.08426837f, -0.11426338f, -0.02781993f, -0.27991080f, 
    0.06314895f, -0.05151078f, -0.20581244f, 0.00551131f, 0.37138727f, 0.24999334f, -0.55305153f, 0.16030009f, 
    -0.34599912f, -0.06897558f, 0.00095161f, 0.08528935f, -0.03869654f, 0.00361538f, 0.00907255f, 0.13129003f, 
    -0.08932254f, -0.03528333f, 0.06066309f, -0.02498554f, 0.11183546f, 0.02697136f, -0.07128593f, 0.11898232f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18810165f, 0.07725053f, -0.07221676f, -0.02154375f, 0.04200524f, -0.00926207f, 0.04147809f, -0.16364457f, 
    -0.05691567f, -0.02177583f, 0.17130871f, 0.02302141f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
