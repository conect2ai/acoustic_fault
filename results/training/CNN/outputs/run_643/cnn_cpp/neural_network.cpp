#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.60849440f, 0.62264025f, -0.12818553f, 0.35242364f, 0.49254575f, -0.07617485f, -0.64700657f, -0.76567775f, 
    -0.51295567f, 0.01271806f, 0.22608337f, 0.13605471f, -0.03243231f, 0.13502114f, -0.04188088f, -0.12905663f, 
    -0.08589468f, 0.45343071f, 0.01468605f, 0.00506426f, 0.01136193f, -0.07602025f, -0.19370592f, -0.15771526f, 
    0.17075987f, 0.23299584f, -0.86673719f, 0.26027334f, 0.42489249f, 0.27678290f, 0.56524259f, 0.10299418f, 
    0.48699859f, -0.18731153f, -0.52160811f, -0.16485977f, -0.35286966f, -0.26978254f, 0.25192004f, -0.04365739f, 
    -0.08505577f, 0.03428194f, -0.18723905f, 0.22079590f, -0.14240550f, -0.18933439f, 0.01574644f, -0.14048041f, 
    -0.17097567f, 0.00779669f, 0.91344708f, -0.08281457f, 0.20699850f, 0.77187729f, 0.32907364f, -0.10438178f, 
    -0.49473211f, 0.26602408f, 0.01283180f, -0.25426590f, -0.03981178f, 0.13012716f, 0.22583346f, -0.10345755f, 
    0.11745445f, -0.02182450f, 0.00076105f, 0.26391423f, 0.34560436f, 0.33657771f, -0.13726284f, -0.14688581f, 
    0.03039397f, -0.16192961f, 0.10540905f, -0.05307363f, -0.32494530f, -0.07976794f, 0.14668928f, -0.21513478f, 
    -0.45168081f, -0.49841049f, -0.36387736f, -0.31089562f, -0.33267775f, 0.15256421f, 0.18681662f, 0.25005749f, 
    0.12481197f, 0.24659488f, -0.01289747f, 0.30053607f, -0.09435422f, 0.26624000f, 0.16798687f, 0.15400401f, 
    -0.19341397f, -0.22221984f, 0.33093983f, 0.35155180f, -0.28231350f, 0.29510036f, 0.61217159f, 0.40191033f, 
    -0.17852682f, 0.22525692f, 0.04382553f, 0.21240675f, 0.22581950f, 0.20874351f, 0.13101871f, -0.20243037f, 
    0.16643178f, 0.21265569f, -0.11350320f, 0.19997939f, 0.06523301f, -0.10590623f, 0.08382964f, -0.05637094f, 
    -0.10601924f, 0.29582629f, -0.15465897f, 0.33061737f, -0.16437942f, 0.39530322f, 0.38670719f, 0.09182467f, 
    0.66435015f, 0.17001107f, 0.21799859f, 0.43701473f, 0.29061407f, 0.26434603f, 0.34151244f, -0.39378843f, 
    -0.25197867f, 0.25351441f, -0.22234930f, -0.23166265f, -0.04394045f, 0.10696455f, -0.17760637f, -0.24641688f, 
    -0.04298341f, -0.07534790f, -0.15631278f, -0.19744763f, 0.31150401f, -0.16184542f, 0.03563853f, 0.81361616f, 
    0.58818638f, 0.13542891f, -0.20015012f, -0.16867958f, 0.14756824f, 0.29529575f, -0.21531363f, 0.42730555f, 
    -0.27231613f, 0.23497576f, -0.24431957f, -0.01671630f, -0.18008003f, 0.21905786f, -0.06233639f, 0.04203748f, 
    -0.06778987f, -0.16471714f, 0.07556545f, 0.04589379f, 0.04813921f, 0.01453633f, 0.04006780f, 0.07431435f, 
    -0.65218502f, 0.13263418f, 0.66368353f, -0.31150544f, -0.50581121f, 0.77439338f, -0.25586367f, 0.00287249f, 
    0.52547562f, 0.35114163f, 0.12664323f, -0.29111466f, 0.22337259f, -0.20609067f, -0.28607345f, -0.10313733f, 
    -0.06101692f, 0.09840040f, 0.16484390f, 0.01805500f, -0.03769255f, 0.23506539f, -0.03554707f, -0.17713039f, 
    0.03667248f, -0.64413512f, -0.17895730f, -0.34748188f, -0.32532367f, -0.16841707f, -0.09743506f, -0.50529724f, 
    -0.11763009f, 0.05544019f, -0.37434506f, 0.19317745f, 0.19306391f, 0.24872386f, -0.41572323f, -0.01187113f, 
    0.02582663f, 0.21647502f, 0.20237520f, -0.18475284f, 0.07456780f, 0.04903853f, -0.48803654f, -0.30692899f, 
    0.29103464f, 0.26403823f, -0.17561440f, -0.58041394f, -0.65148324f, -0.08825811f, 0.31255251f, -0.11423676f, 
    0.26815787f, 0.06999744f, -0.14103954f, -0.55663443f, -0.07362138f, -0.26983368f, 0.06059113f, -0.00593896f, 
    0.20199555f, -0.06564704f, 0.10886495f, 0.32892701f, 0.00336133f, -0.04256133f, -0.11578819f, -0.30343026f, 
    -0.09086223f, 0.26232910f, -0.72794878f, 0.28771910f, 0.42603439f, -0.10265591f, -0.01928551f, -0.26666692f, 
    0.26094669f, -0.18408068f, -0.40032440f, -0.04275444f, 0.27756190f, 0.04325388f, 0.07208679f, 0.04037744f, 
    -0.00828261f, 0.30524549f, 0.01120114f, 0.24317259f, -0.11221197f, 0.21689951f, -0.26986292f, -0.06299367f, 
    -0.30955017f, -0.17670064f, 0.22759290f, -0.40678132f, -0.56669831f, 0.27518284f, -0.07795703f, -0.12753887f, 
    0.11025399f, -0.44083545f, 0.64733440f, 0.13994445f, -0.37701911f, -0.04699694f, -0.17387447f, -0.37812430f, 
    -0.10765193f, -0.13390517f, 0.25661153f, 0.10674690f, -0.28030685f, -0.08696665f, -0.12611832f, 0.07066502f, 
    0.30896291f, 0.43283767f, 0.20664114f, 0.04134702f, 0.45778471f, 0.29821765f, 0.39588886f, 0.81783652f, 
    0.28451177f, 0.08680709f, 0.07998078f, -0.25264379f, 0.19191943f, 0.08321070f, -0.29404482f, 0.21156478f, 
    0.34598801f, -0.37299144f, -0.29142818f, -0.10754042f, -0.06775692f, -0.19956583f, -0.07154980f, 0.14161298f, 
    -0.19670977f, -0.05208175f, 0.16030855f, -0.18886170f, -0.01657240f, 0.24126409f, -0.05651795f, 0.33198950f, 
    0.72738421f, 0.21945985f, -0.24182311f, 0.42118719f, 0.01646556f, 0.36909026f, -0.02423194f, 0.11081979f, 
    0.19736859f, 0.30218840f, 0.25060019f, -0.09796520f, -0.06713967f, 0.03683227f, 0.12511551f, -0.24998802f, 
    -0.02144953f, -0.27763873f, -0.30808792f, -0.27424106f, 0.17583698f, -0.17131057f, 0.35876164f, -0.61616075f, 
    0.35756814f, -0.10177961f, 0.14536616f, 0.78991258f, 0.05977768f, -0.59669954f, -0.33659285f, -0.33124495f, 
    0.17720532f, 0.19733572f, -0.03022190f, 0.06625308f, 0.12487788f, 0.06714451f, 0.02427964f, -0.56499910f, 
    -0.19399169f, -0.20929250f, 0.14503019f, -0.12318911f, 0.15975399f, -0.07965608f, 0.29758525f, 0.75914317f, 
    0.59329969f, 0.18527986f, -0.41056460f, 0.01427168f, 0.03477893f, -0.52152425f, 0.22574848f, -0.31146055f, 
    -0.17282990f, 0.23703903f, 0.55978972f, -0.08572178f, 0.05469928f, 0.08122605f, 0.28982285f, 0.00400624f, 
    0.21916097f, 0.17191561f, 0.11149457f, 0.04576465f, 0.09578750f, -0.27354079f, 0.16485073f, -0.08377714f, 
    0.81366867f, 0.76397192f, -0.48969111f, -0.55307835f, -0.72651595f, 0.07213107f, 0.18497477f, -0.05657227f, 
    0.15170990f, 0.37926924f, 0.24297880f, 0.06520351f, 0.00375168f, -0.02519422f, 0.19592306f, 0.09708647f, 
    0.02089844f, 0.15412173f, -0.10830696f, 0.14737800f, 0.38448539f, -0.16459939f, 0.00015022f, -0.09144990f, 
    0.05520354f, -0.03372110f, 0.46384621f, -0.58359253f, 0.19669628f, -0.11718954f, -0.11444006f, -0.47125620f, 
    -0.01689041f, 0.10652372f, -0.32335114f, -0.49252504f, -0.19827603f, 0.01253273f, 0.33479011f, -0.25849053f, 
    -0.05918802f, 0.24400797f, 0.14516076f, 0.22033331f, 0.09029277f, 0.12573946f, 0.02995598f, 0.01794051f, 
    0.04937484f, -0.40005443f, -0.63400769f, 0.61599278f, 0.04502057f, 0.12282674f, 0.46994022f, -0.28652564f, 
    0.52409059f, 0.42980722f, 0.00641473f, 0.31294206f, -0.36233479f, -0.23328607f, -0.01959109f, -0.16310866f, 
    0.02426530f, -0.05204330f, -0.04490422f, -0.11385372f, 0.06548256f, -0.02145120f, 0.32358772f, 0.25453177f, 
    -0.06482911f, 0.23688780f, 0.13819318f, -0.18709490f, 0.40718770f, 0.77730101f, -0.65142453f, -0.33628500f, 
    0.31930104f, 0.18120891f, 0.14150254f, -0.04843239f, -0.42098305f, 0.08191928f, 0.37301373f, -0.19676474f, 
    -0.03111046f, -0.40126005f, -0.42106616f, -0.13619602f, -0.25570667f, -0.26639277f, -0.20914246f, 0.08499292f, 
    -0.04519719f, -0.04967030f, 0.13036978f, -0.22754112f, -0.69070983f, 0.05604004f, 0.47739428f, -0.50300741f, 
    0.50129384f, 0.53917587f, -0.06284197f, 0.21157534f, 0.23342852f, 0.44630596f, 0.01365638f, -0.11812024f, 
    0.13268338f, -0.24859776f, -0.13292608f, 0.23453438f, 0.17500788f, 0.15839446f, 0.17842373f, -0.12306809f, 
    -0.15879627f, 0.21717416f, 0.36870676f, -0.09513747f, -0.16935392f, -0.49020287f, 0.19530991f, -0.35903168f, 
    -0.36139798f, -0.05111849f, -0.14267129f, -0.22006062f, -0.22578564f, -0.03024480f, 0.35800877f, -0.31246403f, 
    -0.27979758f, 0.15051815f, 0.31370068f, 0.04731765f, 0.47627485f, -0.03146635f, 0.37975734f, -0.24137102f, 
    -0.18861128f, -0.35828725f, -0.22977482f, -0.07086027f, -0.35396278f, -0.16967885f, -0.41979864f, -0.72064453f, 
    -0.69250804f, -0.20906034f, 0.36346251f, 0.16974600f, 0.79010063f, -0.14491367f, 0.47438473f, 0.17395796f, 
    0.15810157f, -0.27675793f, 0.00029298f, -0.02883809f, -0.20011079f, -0.09698012f, 0.03193981f, -0.09726805f, 
    -0.19854254f, -0.36117572f, -0.25924695f, -0.25225639f, -0.07222386f, -0.07820772f, 0.16804801f, -0.07317100f, 
    -0.06782431f, -0.27262521f, -0.62422824f, -0.38711149f, 0.06128810f, -0.09323519f, 0.20303437f, 0.41175136f, 
    0.09648138f, -0.01483869f, 0.14948782f, -0.21685782f, -0.25259495f, -0.12728375f, -0.19612511f, -0.00824647f, 
    -0.32080483f, 0.31467065f, -0.52158469f, -0.29500160f, -0.14242849f, 0.40062258f, 0.23868990f, 0.36181352f, 
    -0.12116233f, -0.55425233f, -0.59145766f, -0.46511924f, 0.09455165f, 0.23619415f, 0.51460093f, 0.22681224f, 
    0.52983946f, 0.51258922f, -0.29943743f, -0.14254907f, -0.35057074f, -0.18542832f, 0.09407675f, -0.02273911f, 
    -0.05812655f, 0.13094629f, 0.10417432f, -0.00517842f, -0.03359170f, -0.02340995f, 0.12395086f, -0.19518004f, 
    -0.11449487f, -0.52823544f, 0.18175749f, -0.18370289f, -0.32769302f, -0.22134924f, 0.32641721f, 0.64684862f, 
    -0.07664020f, 0.31879917f, 0.40458697f, -0.15444602f, 0.11114212f, -0.12944357f, -0.26745123f, -0.45163560f, 
    -0.05824495f, 0.30640179f, 0.09686995f, 0.06987772f, -0.17683586f, -0.10345559f, -0.18478718f, -0.37401733f, 
    -0.08204342f, -0.26532608f, -0.37157792f, -0.02882716f, 0.63651335f, 0.31389219f, 0.35499689f, 0.59071302f, 
    0.26477796f, -0.06076927f, -0.23504065f, -0.19292800f, 0.29185721f, 0.17800790f, 0.32811573f, 0.29279906f, 
    0.09674432f, -0.20143421f, -0.17602561f, -0.02779152f, -0.16291140f, 0.07539724f, -0.36261570f, 0.28257999f, 
    -0.00250266f, 0.03869805f, 0.17768490f, -0.26517895f, -0.45101550f, -0.31840596f, -0.40241134f, -0.24989317f, 
    -0.24919792f, -0.46337301f, -0.29516175f, 0.04839512f, -0.35143104f, -0.39971662f, 0.26087603f, 0.11187228f, 
    -0.18519740f, 0.09613162f, 0.03999520f, 0.25475642f, -0.01576192f, 0.22434409f, 0.09890991f, 0.08365097f, 
    0.21058539f, 0.06356747f, -0.16980796f, -0.13483191f, -0.02032749f, 0.56955266f, -0.72501564f, 0.17047656f, 
    -0.08701105f, -0.04704645f, -0.65757006f, -0.31180534f, -0.06163518f, -0.27564719f, -0.09285963f, 0.09714520f, 
    0.30059487f, 0.20451245f, 0.06914035f, 0.20057978f, -0.23572443f, 0.13488276f, 0.10222926f, -0.06020929f, 
    0.08106058f, 0.07454072f, -0.02306427f, 0.10496593f, 0.08235350f, -0.40650254f, -0.11221620f, -0.28504515f, 
    -0.28786063f, -0.15377612f, 0.72888571f, 0.83399916f, 0.23772177f, 0.33410120f, 0.30502161f, 0.21173941f, 
    0.25936842f, 0.41368955f, 0.10663909f, 0.12829632f, -0.22160800f, -0.27143532f, -0.13001743f, 0.11510428f, 
    -0.12051882f, -0.10341524f, -0.14347395f, 0.10352118f, -0.10480953f, -0.14242627f, 0.54643023f, 0.11726614f, 
    0.10932100f, 0.34925115f, 0.35409895f, 0.14930554f, 0.04688530f, 0.05269566f, -0.04903100f, 0.31571415f, 
    0.10218766f, 0.41761357f, 0.01936674f, -0.19308241f, 0.15306410f, 0.16520651f, -0.34118173f, -0.05017143f, 
    0.01078743f, 0.05719550f, 0.10531354f, -0.31326199f, 0.23688738f, 0.16632189f, 0.13655257f, -0.27060401f, 
    -0.47052681f, -0.51051533f, -0.21206570f, -0.33972126f, -0.29538167f, 0.61585885f, 0.47812298f, -0.60016328f, 
    0.23238540f, 0.02132177f, -0.18918633f, -0.15905479f, -0.25251651f, 0.16055869f, -0.18124348f, -0.02352108f, 
    0.00259004f, 0.12634155f, -0.08560146f, -0.02517050f, 0.05214653f, 0.25287750f, -0.20001088f, 0.03355473f, 
    0.06550661f, -0.18126136f, 0.71086240f, 0.24618091f, -0.01549185f, -0.71747178f, 0.12594506f, -0.17207797f, 
    -0.25887033f, -0.38263386f, 0.22043292f, -0.20639180f, -0.57440841f, 0.07547457f, -0.07161223f, 0.12579708f, 
    -0.11323254f, -0.48026028f, -0.17527297f, -0.16708685f, -0.06022423f, 0.05820146f, 0.06526326f, 0.08858505f, 
    0.10601456f, -0.45534444f, 0.02995239f, 0.09463304f, -0.01896156f, -0.01650515f, -0.77999109f, 0.13457197f, 
    0.19955395f, -0.53828263f, -0.13597801f, 0.22308725f, 0.31330690f, -0.13943492f, 0.20755704f, 0.15527090f, 
    -0.06613003f, -0.17990178f, -0.09389783f, -0.40453893f, -0.36859506f, 0.03336262f, 0.25144050f, -0.03889607f, 
    0.05498842f, 0.05274331f, 0.49898541f, 0.44304436f, 0.36574900f, 0.52788562f, 0.34700879f, 0.25597504f, 
    -0.00278477f, -0.35047290f, -0.14185742f, -0.33583730f, 0.13080554f, 0.33764610f, -0.00076354f, 0.20899664f, 
    -0.30639204f, 0.29755512f, -0.09271690f, -0.19314994f, 0.20584853f, -0.35491186f, 0.28307670f, 0.42584106f, 
    0.01177208f, -0.09987840f, 0.13210866f, -0.44681448f, 0.83074445f, 0.32731089f, 0.33775967f, -0.31412840f, 
    0.15012749f, 0.60694826f, -0.21865676f, 0.22025783f, -0.02220857f, 0.07735559f, -0.11829001f, 0.30412295f, 
    -0.29795957f, 0.18655767f, 0.11322948f, 0.04423072f, 0.24242781f, 0.03617824f, -0.08379907f, 0.05859979f, 
    0.02760320f, 0.13410793f, 0.32200980f, 0.04417556f, 0.38676292f, -0.29613310f, 0.54605186f, 0.16050658f, 
    0.19803147f, 0.30953500f, 0.41187093f, -0.08105864f, -0.31035304f, -0.55970961f, 0.09214882f, 0.26641965f, 
    0.25655833f, 0.18229111f, 0.08754780f, 0.25288311f, 0.35701269f, 0.30933157f, 0.14661486f, -0.25056735f, 
    0.03387786f, -0.25335541f, 0.12522490f, -0.00664445f, 0.24856104f, 0.50561231f, 0.13769436f, -0.34312150f, 
    0.74766326f, 0.02127898f, -0.21919324f, -0.37250602f, 0.24770780f, 0.01850430f, -0.27031103f, 0.19264078f, 
    0.06092155f, 0.04349314f, -0.03104863f, 0.17940226f, 0.40937480f, 0.32805809f, -0.26190546f, -0.16685486f, 
    -0.03323523f, 0.18237408f, -0.13338089f, -0.19687922f, 0.35375366f, -0.28851810f, -0.44275996f, -0.30060637f, 
    0.30294126f, 0.40610608f, -0.87526071f, -0.27477425f, -0.15358536f, 0.31198263f, -0.47201258f, 0.15559140f, 
    -0.09983273f, 0.01536976f, -0.25606748f, 0.11954658f, 0.26346868f, -0.10399294f, -0.08966550f, 0.21745107f, 
    0.00673477f, -0.54150361f, 0.23624845f, 0.07345503f, -0.18053339f, 0.15813842f, -0.11643149f, -0.01301868f, 
    -0.63393283f, -0.51351237f, -0.31477430f, 0.27250323f, -0.36304080f, 0.72439462f, -0.24190700f, -0.60310823f, 
    0.03232516f, -0.18749017f, 0.03489141f, -0.01527009f, 0.21034040f, 0.14523093f, -0.26448625f, 0.04074077f, 
    0.12431254f, -0.17066234f, -0.18250740f, 0.03117358f, -0.23716834f, 0.10390162f, -0.03897122f, -0.12898605f, 
    -0.43973419f, -0.63005030f, -0.45072424f, -0.25245899f, -0.28807169f, 0.16129461f, -0.24823688f, 0.01372787f, 
    0.50447911f, 0.02770500f, 0.03700193f, 0.06734142f, -0.13103859f, -0.16857430f, -0.22537324f, 0.28795663f, 
    0.26144132f, 0.13142061f, -0.07011827f, 0.23882936f, -0.16228226f, -0.03076792f, 0.04816779f, 0.26811171f, 
    0.17320026f, 0.61560380f, -0.16017933f, 0.29553947f, 0.62428474f, -0.10504593f, 0.07632115f, -0.37070572f, 
    -0.22919831f, 0.29866061f, 0.37788531f, 0.27147201f, -0.26596296f, 0.06856768f, 0.00294602f, -0.38222799f, 
    -0.06626368f, -0.28040570f, 0.23238859f, -0.14228408f, -0.21375635f, -0.10345476f, 0.12737271f, 0.19906446f, 
    -0.13474639f, -0.29432133f, 0.57935733f, -0.49285373f, -0.56331247f, -0.43473950f, 0.15957828f, -0.00128555f, 
    0.20650387f, 0.04129621f, -0.44186577f, -0.12045743f, -0.30924228f, 0.15248531f, 0.10023065f, 0.03968148f, 
    -0.47098914f, 0.14144066f, -0.19831477f, 0.12291171f, 0.23022059f, 0.00889667f, 0.36059877f, -0.03296072f, 
    -0.17668414f, 0.18254425f, -0.03530038f, -0.70250094f, 0.25874740f, -0.07651750f, -0.56409234f, -0.44403484f, 
    0.30758476f, -0.38027036f, -0.63638049f, -0.08239077f, 0.08839635f, -0.10827327f, -0.10141990f, -0.03835932f, 
    0.25233820f, -0.01361457f, -0.14997968f, 0.09847629f, -0.21939684f, 0.01164311f, 0.28455225f, 0.20612401f, 
    0.12448034f, 0.23706016f, 0.06560086f, -0.00508782f, -0.40736905f, -0.39312521f, 0.06891706f, -0.11375339f, 
    -0.16156714f, -0.62306309f, -0.48774105f, -0.12428129f, 0.42185783f, -0.27690244f, 0.41707942f, -0.07871863f, 
    -0.05223779f, 0.17976820f, -0.08947111f, 0.23539135f, 0.17893559f, -0.08706839f, -0.02201339f, -0.13630173f, 
    0.21917725f, -0.25672442f, 0.15696657f, 0.05379658f, 0.25434250f, -0.74627018f, -0.20537156f, 0.12184066f, 
    0.25865111f, 0.53497422f, -0.44457978f, 0.15363391f, -0.51251334f, -0.70460272f, -0.25529420f, 0.25543603f, 
    0.41293469f, 0.11421929f, -0.23242077f, -0.22883518f, -0.00678096f, -0.18267266f, 0.15387319f, -0.20408374f, 
    0.14313787f, -0.05080875f, -0.00003161f, 0.21092954f, 0.24108438f, 0.00765577f, 0.24697337f, 0.56950527f, 
    0.35934424f, -0.42850846f, 0.06196702f, 0.18082850f, 0.00334739f, -0.03606772f, -0.62418634f, -0.52449530f, 
    0.21962121f, -0.08654237f, 0.04810373f, 0.49085647f, -0.10408819f, -0.19335279f, 0.37704352f, 0.02774705f, 
    -0.30542788f, -0.35042205f, -0.07145894f, -0.13553622f, 0.50270033f, 0.24790980f, -0.07193886f, -0.51490492f, 
    -0.67970169f, -0.28261092f, -0.09451218f, -0.53716111f, -0.09734555f, 0.19409116f, 0.32492825f, 0.05998158f, 
    0.41443536f, 0.29262674f, -0.13111672f, -0.11347164f, 0.31536642f, -0.18303776f, 0.02594914f, 0.21327150f, 
    0.29092079f, -0.03647925f, -0.14924005f, -0.03973764f, 0.09520891f, -0.28781694f, -0.30120149f, -0.06070620f, 
    0.08997433f, 0.27064669f, -0.64775866f, -0.51447475f, -0.09767795f, 0.20499982f, -0.38726762f, 0.15019280f, 
    0.38200164f, -0.34751084f, -0.38220349f, -0.22307657f, 0.06373140f, 0.29902193f, -0.09557632f, -0.17094930f, 
    0.15438852f, 0.16784784f, -0.14234863f, -0.12608849f, -0.13558245f, 0.13345802f, -0.11463831f, 0.29026479f, 
    -0.11540906f, 0.80263674f, 0.08568957f, 0.39830586f, 0.78497791f, 0.56558371f, 0.14657100f, 0.21671453f, 
    0.14356072f, -0.36910146f, 0.13196844f, -0.30360574f, -0.27991125f, -0.33223253f, -0.03654007f, -0.05607306f, 
    -0.22918321f, -0.17312844f, 0.11479199f, 0.24955976f, -0.05339213f, 0.16207336f, 0.23099865f, -0.12170444f, 
    -0.11686595f, -0.02273201f, 0.21191403f, -0.06353984f, 0.51430428f, 0.19846171f, -0.23923227f, 0.14357291f, 
    -0.60136181f, -0.34897766f, -0.06679388f, -0.02776537f, -0.29768130f, -0.10792106f, 0.01143051f, -0.09216242f, 
    -0.31376061f, -0.02209576f, 0.33050469f, 0.10887142f, -0.36633143f, -0.37599280f, 0.03457053f, -0.15944164f, 
    0.06175455f, 0.42498088f, 0.01689011f, -0.52097315f, 0.69664389f, 0.23728547f, -0.21055053f, 0.24012652f, 
    0.10994379f, 0.42713994f, 0.23866031f, -0.00552332f, 0.40817860f, 0.11633453f, -0.10586372f, -0.18017827f, 
    -0.43507057f, 0.16655067f, -0.23861946f, 0.03660097f, -0.06059812f, -0.10628359f, -0.17088744f, -0.07077564f, 
    0.14257070f, 0.36266389f, 0.22629920f, 0.24755450f, -0.64898217f, 0.23839508f, -0.53198451f, -0.15911524f, 
    0.45076069f, -0.60052019f, 0.16081636f, 0.55870503f, -0.18555436f, -0.19772498f, -0.17407337f, -0.14312169f, 
    0.20259942f, -0.32000494f, 0.09962023f, 0.31285936f, 0.31026664f, 0.27056372f, 0.15287159f, -0.44888464f, 
    -0.07357001f, -0.05181603f, 0.07838793f, 0.16269097f, 0.18790394f, -0.15520917f, 0.34823254f, -0.06075172f, 
    -0.37413514f, 0.11722067f, -0.48262671f, 0.40475038f, 0.52430898f, 0.08526982f, -0.28981385f, -0.08660434f, 
    0.31925705f, -0.45588982f, -0.13401632f, 0.13770980f, 0.12062532f, -0.33747119f, -0.02308172f, -0.07574251f, 
    0.13531193f, -0.28004944f, -0.10759156f, -0.12599182f, 0.01759522f, -0.25690901f, -0.39616463f, 0.88791859f, 
    -0.16048609f, -0.50165671f, -0.17094727f, 0.06596189f, -0.29299629f, -0.04410591f, -0.06485942f, -0.03730151f, 
    0.22125340f, -0.10550406f, 0.19745265f, 0.10812122f, 0.02670466f, 0.27467680f, -0.06750661f, 0.02038228f, 
    0.13949578f, 0.24672794f, 0.09600636f, 0.18397732f, 0.20165807f, -0.28941041f, 0.41778883f, 0.03774848f, 
    -0.52951324f, -0.49074861f, -0.12787494f, 0.37164533f, -0.31479964f, -0.72630781f, -0.18979824f, 0.49427873f, 
    -0.04453785f, 0.06890588f, -0.09121013f, 0.11830156f, 0.33922434f, -0.20935485f, -0.15017605f, 0.12587127f, 
    0.01547334f, -0.07208358f, -0.22874767f, 0.05368841f, 0.08188166f, 0.07771345f, 0.02092225f, -0.10505176f, 
    0.30419561f, 0.47362533f, 0.66074830f, 0.45335525f, -0.22647567f, 0.17982566f, -0.13563086f, -0.36884880f, 
    -0.08117358f, 0.54863960f, 0.29784727f, -0.02699082f, -0.01677253f, 0.16460364f, 0.02066160f, -0.09245027f, 
    -0.23829524f, 0.02871859f, 0.01661307f, -0.01698399f, 0.07190733f, 0.02625855f, -0.04480954f, 0.34520492f, 
    -0.08486613f, 0.16383775f, 0.77169371f, 0.31508958f, 0.29081917f, -0.29704925f, -0.08471164f, 0.35238159f, 
    -0.48224524f, 0.09641047f, -0.01140258f, 0.21195200f, -0.23972668f, 0.10300925f, -0.14990629f, -0.22657587f, 
    -0.16683778f, -0.07434525f, 0.40905410f, -0.03351924f, -0.37988758f, -0.20578009f, -0.05260958f, -0.07280814f, 
    0.09357874f, 0.21007115f, 0.14009427f, -0.18789421f, 0.35536042f, 0.18403542f, 0.17132017f, -0.22949551f, 
    -0.31634018f, -0.51168555f, -0.54596072f, -0.13971993f, -0.09174078f, 0.38997880f, -0.01163829f, 0.32413557f, 
    -0.15288647f, 0.18416776f, -0.20419218f, 0.20416926f, -0.11766657f, 0.32800850f, 0.06927361f, 0.10789274f, 
    -0.01456825f, -0.07169261f, -0.09055412f, -0.11318479f, 0.58220601f, 0.00086271f, -0.83288825f, 0.72953165f, 
    -0.39422610f, -0.16416842f, -0.18199582f, -0.27285904f, -0.20730110f, 0.06332412f, 0.31136951f, -0.03880033f, 
    -0.13021813f, -0.34019619f, 0.00918662f, 0.12177753f, -0.44687623f, -0.32494420f, 0.11031780f, -0.16048814f, 
    0.09468010f, 0.07059916f, -0.11357316f, 0.00884295f, 0.05798474f, 0.10033569f, 0.36114952f, 0.50367343f, 
    0.50564814f, 0.39328292f, -0.10017839f, 0.37174097f, 0.09393902f, 0.24545334f, 0.11930229f, -0.05566704f, 
    -0.24439695f, -0.11494765f, -0.21798338f, 0.22293359f, -0.03896497f, -0.15420309f, -0.01799707f, -0.32432002f, 
    0.25873679f, 0.00522098f, 0.13344111f, 0.08007590f, -0.22853978f, 0.56871581f, 0.56493270f, 0.52792585f, 
    0.23838548f, 0.14421919f, 0.01943286f, -0.16780673f, -0.28448018f, -0.10004994f, 0.18238181f, -0.31122723f, 
    -0.12497394f, -0.01678006f, 0.21578623f, 0.06931928f, -0.16453911f, 0.38266104f, 0.15952881f, -0.15991516f, 
    -0.18634692f, -0.08113733f, -0.08775401f, -0.43557426f, -0.35181367f, 0.06302989f, 0.03457877f, -0.41866028f, 
    -0.53359723f, -0.40385637f, -0.56200874f, 0.34125459f, 0.61135793f, 0.04604898f, 0.20904857f, 0.25754994f, 
    0.06607104f, -0.10165958f, 0.14824823f, 0.24655405f, -0.03473962f, -0.28324357f, -0.00482111f, 0.10711972f, 
    -0.26345512f, -0.18133499f, 0.15606071f, -0.04281003f, 0.25419784f, 0.01637205f, 0.01285280f, -0.15684651f, 
    -0.07078134f, -0.13152660f, -0.38899773f, -0.29192343f, -0.56045520f, -0.05457361f, 0.29829213f, -0.03358348f, 
    0.17866457f, 0.30687413f, 0.04653942f, 0.26804650f, 0.20369112f, 0.31288275f, -0.30711111f, 0.00602099f, 
    -0.19461070f, -0.02911544f, 0.14459580f, 0.03947433f, 0.13002545f, 0.13983458f, -0.00019261f, -0.01316401f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00263644f, 0.00261956f, 0.18134788f, 0.21408355f, 0.24983995f, 0.10408036f, 0.11551639f, 0.07488962f, 
    -0.03305399f, 0.21616726f, 0.07067454f, 0.05271936f, 0.11841118f, -0.01436218f, 0.26726136f, 0.17235234f, 
    0.26862448f, 0.20104852f, 0.07341889f, 0.19768113f, 0.24554749f, 0.06083581f, 0.08585224f, 0.06335594f, 
    0.06216286f, -0.15510748f, 0.01715840f, 0.22218260f, 0.08796849f, -0.23545937f, 0.19275984f, 0.24133526f, 
    0.17818573f, 0.24246731f, 0.17635299f, 0.08723921f, -0.03976306f, 0.13569666f, 0.13737236f, 0.04054839f, 
    0.25637385f, -0.00312287f, 0.06725276f, 0.08245645f, 0.10169832f, -0.03393934f, 0.07813651f, 0.17083178f, 
    0.18397017f, -0.07833432f, 0.14641206f, 0.05568928f, 0.11697655f, 0.06516620f, 0.09160763f, 0.28339499f, 
    0.00147436f, 0.22377688f, 0.05955320f, 0.27933654f, 0.17839552f, 0.13502751f, 0.22221576f, 0.18582480f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01260575f, -0.03561299f, -0.00685011f, 0.01933198f, -0.03368154f, -0.03932760f, 0.01724055f, 0.01201760f, 
    0.02965062f, -0.00273714f, -0.01566820f, -0.04014861f, -0.01862656f, -0.01738426f, 0.03506136f, 0.00668492f, 
    -0.00585230f, 0.01608098f, 0.03732103f, 0.00868751f, -0.02226664f, -0.02746443f, 0.01794145f, 0.02016958f, 
    0.02961742f, -0.03549251f, 0.02169997f, -0.01097384f, -0.01518568f, 0.00842668f, -0.00959028f, 0.02219558f, 
    -0.03846776f, -0.02575844f, 0.01134766f, -0.01479484f, 0.00538064f, -0.01498764f, -0.00267916f, 0.02593447f, 
    -0.01683787f, 0.00905734f, -0.02837348f, -0.02202556f, -0.01013102f, 0.00846650f, -0.03780430f, -0.02057325f, 
    -0.00633326f, 0.03413496f, 0.03171103f, -0.01795844f, 0.02486887f, -0.00950220f, -0.03836461f, 0.00355307f, 
    -0.02817263f, 0.02460220f, 0.03338266f, -0.02240242f, -0.04155766f, -0.01596923f, 0.02825539f, -0.02117010f, 
    0.01409567f, -0.03107216f, 0.02208054f, -0.00338965f, 0.00336281f, -0.03337670f, 0.00058706f, -0.03595068f, 
    0.01517412f, 0.02503844f, -0.02633276f, 0.02621462f, -0.00593186f, 0.03836944f, 0.00729660f, 0.02908167f, 
    0.01126038f, -0.03008397f, 0.02819791f, 0.01413537f, 0.00499388f, -0.01740314f, 0.00778616f, -0.01352646f, 
    -0.02857457f, -0.02344796f, 0.00549702f, -0.00136918f, -0.00992493f, -0.02666807f, 0.02916588f, -0.00005253f, 
    0.02259518f, -0.03668928f, -0.03595209f, 0.01259463f, 0.02646488f, -0.03361392f, -0.01324292f, -0.00592342f, 
    0.00447255f, -0.02403542f, 0.02085178f, 0.02130945f, 0.01316276f, -0.03703173f, -0.01314530f, 0.02946945f, 
    -0.01816680f, 0.00566788f, 0.01749011f, 0.00679768f, -0.01332317f, -0.03395501f, 0.02738274f, 0.02067005f, 
    -0.01117760f, 0.03798177f, 0.02429092f, -0.01913700f, 0.02146257f, 0.00299047f, 0.01266928f, -0.02858207f, 
    -0.00377029f, 0.02248439f, 0.02086856f, 0.01471299f, 0.00741522f, -0.03083538f, 0.02189619f, 0.03456330f, 
    -0.01691705f, 0.02676734f, -0.02707492f, -0.02491231f, -0.02166308f, 0.01564490f, 0.02326708f, -0.03060970f, 
    -0.01911749f, -0.00653266f, -0.01751967f, -0.00573076f, -0.01850645f, -0.02633993f, -0.00438688f, -0.01931978f, 
    -0.03706754f, -0.00855810f, -0.02364367f, -0.01297683f, -0.00494854f, -0.00802341f, -0.01642027f, 0.01499890f, 
    0.02832206f, 0.01681806f, 0.00580427f, -0.01717952f, 0.01753261f, -0.03914315f, -0.00641020f, 0.00706522f, 
    0.01467724f, 0.01934173f, -0.00079951f, -0.00168100f, -0.04099124f, -0.00578745f, 0.01990505f, 0.00126782f, 
    0.03417309f, -0.00260527f, -0.01079770f, -0.02665308f, -0.01158710f, 0.00272299f, 0.01774693f, -0.02945871f, 
    0.01568245f, 0.01868837f, 0.00913744f, 0.02318993f, 0.04177485f, 0.01082259f, -0.01510993f, -0.00988170f, 
    0.01176588f, -0.01283647f, 0.01597327f, -0.03670001f, -0.00990658f, -0.02254279f, -0.03277065f, -0.02730383f, 
    0.01375293f, -0.01352047f, -0.02421404f, 0.00487462f, -0.00027925f, -0.00290948f, -0.01124925f, -0.02700517f, 
    -0.01285453f, -0.02588007f, 0.00815335f, 0.00346264f, 0.02594492f, 0.00957257f, -0.02783206f, 0.00345077f, 
    -0.02191265f, -0.01712189f, 0.02966924f, 0.00363718f, 0.00405606f, -0.00724979f, -0.02941845f, 0.03853538f, 
    -0.03447497f, -0.04099841f, 0.02032852f, -0.00358064f, -0.03120564f, -0.00144503f, -0.01658926f, 0.01626791f, 
    -0.04101833f, 0.00534987f, -0.00603742f, -0.00110082f, -0.03249795f, -0.00923464f, -0.04197421f, -0.01495067f, 
    -0.01287483f, -0.03535708f, -0.03805193f, -0.03910361f, 0.01588063f, -0.03376376f, 0.02106772f, 0.02657995f, 
    -0.01514393f, -0.00116877f, -0.02341912f, -0.00604605f, 0.03002833f, 0.01156246f, -0.02873204f, -0.03258581f, 
    -0.02047319f, -0.03079588f, 0.02844415f, 0.02656785f, 0.02981305f, -0.03887674f, -0.03994928f, 0.00190857f, 
    0.00192231f, 0.02902248f, -0.03595518f, -0.01872369f, 0.02158978f, -0.01026568f, -0.01358659f, -0.00594792f, 
    -0.00108840f, -0.01462879f, -0.00925715f, -0.02869034f, -0.00567292f, -0.03718127f, -0.01557648f, -0.01413977f, 
    -0.02447787f, -0.01469428f, -0.00700735f, -0.02423247f, -0.00149663f, -0.02903271f, 0.02222265f, -0.00830289f, 
    0.01866117f, 0.01707072f, -0.03923479f, -0.00771531f, -0.00497728f, -0.02197340f, -0.02686535f, -0.00389378f, 
    -0.02998076f, -0.00826447f, 0.01036738f, -0.03418443f, -0.00721398f, 0.02358699f, -0.01286369f, 0.00640675f, 
    0.02577052f, -0.03290796f, -0.00501311f, -0.04092672f, 0.01926750f, -0.02823133f, 0.00915442f, 0.02439699f, 
    0.01398179f, -0.02764709f, -0.00093488f, -0.02809402f, -0.02900947f, -0.01610475f, -0.00668096f, -0.00381034f, 
    0.01765106f, -0.02995294f, -0.01188616f, 0.00853575f, 0.02167545f, 0.00092559f, -0.02049010f, 0.00204735f, 
    -0.01844436f, -0.03314121f, 0.02702570f, -0.02216222f, 0.01504544f, -0.01014290f, 0.01294036f, -0.02137344f, 
    -0.01901070f, 0.00962963f, -0.02536030f, 0.02198057f, -0.02543606f, -0.01783123f, -0.01771851f, -0.01730161f, 
    -0.00715274f, 0.00389598f, -0.02827755f, 0.02087256f, 0.01809042f, 0.01068248f, -0.02809497f, -0.02664899f, 
    -0.00163183f, -0.02950279f, -0.02443662f, -0.00126245f, -0.00328734f, -0.02907424f, -0.01176657f, 0.00881030f, 
    -0.01319863f, -0.03042731f, -0.00381669f, -0.01778026f, 0.03502778f, -0.00659581f, 0.04206093f, -0.00171257f, 
    0.01723452f, 0.00724714f, -0.00468925f, -0.01628986f, 0.02547375f, -0.03055286f, 0.02859179f, 0.01380818f, 
    -0.01010567f, 0.00345959f, 0.00990327f, -0.03727255f, 0.02043120f, 0.01576393f, -0.03349316f, -0.02826681f, 
    0.00535287f, -0.00213473f, -0.03191165f, 0.00690394f, -0.00740938f, 0.02710285f, -0.01518613f, 0.02253781f, 
    0.02146623f, 0.01409977f, -0.03426833f, 0.00154150f, -0.02490545f, -0.03752034f, -0.02763360f, 0.01309457f, 
    -0.03370363f, 0.02445947f, 0.01326861f, -0.03973885f, -0.04006666f, 0.01179513f, 0.02594616f, -0.02811763f, 
    0.01653399f, -0.02248334f, -0.02338848f, 0.02852009f, 0.02948606f, 0.01603516f, 0.01457477f, 0.02662097f, 
    -0.01508156f, -0.00605865f, -0.02137888f, 0.00696912f, -0.02445632f, -0.02672082f, -0.01000721f, -0.02481131f, 
    0.00745306f, 0.01788949f, -0.02550895f, -0.00431823f, -0.03025133f, 0.02096806f, 0.02127962f, 0.00810151f, 
    -0.01006235f, -0.03548132f, 0.01441801f, 0.02370010f, -0.00891404f, 0.00796377f, -0.03919484f, -0.04122967f, 
    -0.00476264f, -0.01917378f, 0.02077072f, -0.02393418f, -0.02418859f, -0.00582460f, 0.01178692f, 0.00633722f, 
    0.01572730f, -0.01704093f, 0.01522557f, -0.03041828f, -0.01792985f, -0.00299371f, -0.04132066f, -0.00212052f, 
    -0.03186113f, 0.02848983f, -0.03565920f, 0.02415280f, -0.00574622f, -0.03241924f, -0.02232885f, -0.02161066f, 
    -0.04172516f, -0.02943607f, -0.04058006f, -0.01476009f, 0.03760450f, 0.02347857f, 0.02249047f, -0.03828726f, 
    0.00942234f, 0.01865693f, 0.02107220f, -0.02828033f, 0.00133174f, 0.00416437f, 0.01072198f, -0.00779068f, 
    -0.02108034f, 0.00787123f, 0.02444017f, -0.02081091f, 0.01377345f, -0.04203305f, -0.01074045f, -0.00327611f, 
    0.02447657f, 0.00806900f, 0.02286106f, -0.03019524f, 0.03789887f, -0.01209737f, -0.01329636f, -0.01334371f, 
    0.00695348f, -0.02534001f, -0.00030753f, -0.02804906f, 0.01690745f, 0.00522904f, -0.03117882f, -0.00898844f, 
    -0.01980801f, -0.02919117f, 0.00039491f, 0.02788904f, -0.00602257f, 0.00747400f, -0.01231779f, -0.02658967f, 
    -0.02940141f, -0.01678269f, 0.03374595f, -0.01876850f, 0.00788704f, -0.02692061f, 0.02267814f, -0.03523679f, 
    -0.00882639f, -0.00017878f, 0.02774594f, 0.01048139f, 0.02134559f, 0.02042618f, -0.02732276f, -0.00624819f, 
    0.00954903f, 0.02231507f, -0.00685853f, 0.02095275f, -0.01326855f, -0.01639100f, -0.03023424f, -0.01474224f, 
    -0.01826341f, 0.01241944f, -0.01074922f, -0.00785362f, -0.00752785f, 0.00345405f, -0.02690876f, 0.03035621f, 
    0.02318346f, -0.02325340f, -0.02715889f, -0.01768763f, 0.01639983f, -0.00108985f, 0.00354353f, 0.00221328f, 
    -0.03663857f, -0.03434975f, -0.03079559f, -0.00551950f, -0.01808511f, -0.00676314f, 0.02666718f, 0.00964531f, 
    0.00822987f, -0.03158199f, 0.02970766f, 0.01194902f, 0.00697340f, 0.02783736f, -0.02129525f, 0.01286985f, 
    -0.01956735f, -0.03251561f, 0.01753514f, -0.02143081f, -0.02778406f, 0.01921395f, 0.01898148f, -0.01729116f, 
    -0.00061475f, 0.00937884f, 0.01072495f, -0.03279135f, -0.00395036f, 0.02390187f, 0.00479493f, 0.02469021f, 
    0.03185828f, 0.01516836f, 0.01286505f, -0.00329975f, -0.01258728f, 0.01442793f, -0.03494948f, -0.04084324f, 
    0.02615527f, -0.02717219f, -0.02073398f, 0.03204890f, -0.03170316f, -0.02772749f, 0.01559102f, -0.01968544f, 
    -0.00376417f, -0.01996145f, -0.04045462f, 0.02616714f, -0.03367218f, -0.03513157f, -0.02662253f, 0.00645931f, 
    -0.02701656f, 0.02292051f, -0.02788695f, -0.02341049f, -0.01335211f, -0.01894366f, -0.02186011f, 0.01610572f, 
    0.00543177f, -0.02319397f, -0.01472642f, 0.01570394f, 0.00227813f, 0.01059097f, 0.02757251f, -0.02322530f, 
    0.01296534f, -0.04022115f, 0.00476861f, -0.00819634f, 0.00790507f, 0.00917436f, 0.00127723f, 0.01996350f, 
    0.00851642f, 0.01347944f, 0.00833630f, -0.03516002f, 0.02718409f, -0.02454177f, -0.02984149f, 0.00796279f, 
    0.00646809f, 0.02456626f, 0.02273456f, 0.02807054f, -0.01754598f, -0.00806854f, -0.02655184f, 0.01482099f, 
    -0.02729068f, -0.00003585f, -0.03471804f, 0.02057375f, -0.01283031f, 0.01897757f, 0.01926640f, -0.01526829f, 
    0.00033736f, -0.02481279f, 0.00694368f, -0.01591682f, 0.00653103f, 0.02828079f, -0.02140692f, 0.02766546f, 
    -0.03068494f, -0.01385949f, -0.00453988f, -0.01733641f, -0.02940841f, -0.02552565f, 0.00173222f, 0.03403585f, 
    -0.00491826f, -0.00764799f, 0.03048302f, -0.02504482f, -0.00533598f, -0.03637972f, 0.02745602f, 0.02962382f, 
    0.00572228f, 0.00399612f, -0.02043918f, 0.01627632f, -0.02815789f, -0.00268329f, 0.00135232f, -0.01221293f, 
    -0.04203136f, 0.02670138f, 0.02968263f, 0.01432274f, 0.00293449f, -0.04162157f, 0.01628267f, -0.03252096f, 
    -0.00054555f, 0.01529287f, -0.00246039f, 0.00234210f, -0.00639571f, -0.03892055f, -0.00622591f, 0.01609392f, 
    -0.03805516f, -0.00343700f, -0.00475663f, 0.03553442f, 0.02412975f, -0.03954138f, -0.01200410f, -0.01436484f, 
    -0.01039686f, 0.00432238f, 0.01310409f, -0.01525269f, -0.01500441f, 0.01952381f, -0.02827386f, -0.01562690f, 
    -0.02467092f, -0.02131319f, 0.00159718f, -0.03531105f, 0.01001348f, -0.03143054f, 0.02538892f, -0.03240028f, 
    0.01767082f, -0.01964488f, 0.01279593f, -0.03990660f, 0.00400095f, -0.03976725f, 0.02290145f, 0.00213756f, 
    0.02561390f, -0.03874683f, -0.02186477f, 0.01738784f, 0.02374776f, 0.01916842f, 0.00116096f, 0.01007451f, 
    0.01717586f, -0.04074837f, -0.00670503f, 0.00255003f, -0.03358992f, -0.04104462f, -0.01166919f, -0.01020907f, 
    0.03015354f, -0.00810573f, -0.04172299f, 0.02479494f, -0.03714418f, -0.03058238f, -0.02964479f, 0.01827371f, 
    -0.03841472f, 0.01144452f, -0.00320241f, -0.00088773f, 0.02787963f, -0.01757105f, 0.01139278f, 0.01181871f, 
    0.05036454f, 0.11378932f, -0.11985356f, -0.15609562f, 0.07518683f, -0.06458085f, -0.02040453f, -0.03739149f, 
    0.01935072f, -0.01463306f, -0.03835023f, -0.02061181f, 0.40386167f, -0.11207709f, -0.06831568f, 0.03833310f, 
    0.11119935f, 0.02993273f, 0.07665222f, 0.03103299f, -0.07561318f, 0.00203125f, -0.00153322f, 0.14994363f, 
    -0.16611947f, 0.02391124f, -0.11959470f, -0.10643173f, 0.01330114f, -0.03894226f, 0.00548956f, -0.01617195f, 
    -0.08901288f, -0.05823775f, 0.02825059f, 0.07462154f, -0.16165380f, 0.04531758f, -0.04746771f, 0.00030999f, 
    0.03977617f, -0.02445665f, -0.01497220f, -0.01540054f, -0.12433750f, 0.05170415f, 0.13183080f, 0.11826713f, 
    0.02182291f, 0.11458571f, 0.13108635f, -0.04705403f, 0.09236044f, 0.02171653f, 0.03234066f, -0.05149182f, 
    -0.00156245f, 0.06285170f, 0.12364550f, 0.08026696f, -0.00329602f, 0.08111215f, 0.06038098f, -0.11012859f, 
    0.00985876f, 0.05402445f, 0.04282128f, -0.06235128f, 0.05758287f, 0.03589753f, -0.01545083f, -0.04414894f, 
    0.34031686f, -0.11858720f, 0.03196486f, -0.06691668f, 0.06084903f, 0.09004682f, 0.02982511f, 0.01773465f, 
    0.02619897f, 0.06852971f, 0.13282034f, 0.00235509f, -0.38612509f, -0.00885294f, 0.00853839f, -0.13604924f, 
    0.06449748f, -0.11942527f, 0.04542558f, -0.03383701f, 0.04949979f, -0.12986791f, 0.00917618f, -0.06027774f, 
    0.16359840f, 0.12300629f, -0.02598731f, -0.08534444f, 0.06901539f, 0.00011987f, -0.04966903f, 0.15323247f, 
    -0.02389584f, 0.16770139f, 0.03724973f, 0.08307569f, 0.08417308f, -0.03950029f, 0.07605531f, 0.05473896f, 
    -0.00957325f, 0.05728268f, 0.00193692f, 0.09023005f, 0.00891930f, 0.06271230f, 0.06613911f, 0.07500388f, 
    -0.12054851f, -0.14158565f, 0.08652965f, 0.08836670f, -0.04693628f, -0.05539918f, -0.21386731f, 0.06513575f, 
    0.11910348f, 0.00512134f, 0.03454697f, 0.05859875f, 0.28979522f, 0.04153103f, -0.05286852f, 0.08147959f, 
    0.18671501f, -0.14584345f, -0.00177337f, 0.09338910f, -0.00439285f, 0.06047665f, 0.02058006f, -0.08194584f, 
    -0.00577206f, 0.02300601f, 0.03984869f, -0.23018935f, 0.05348103f, 0.03859561f, 0.14963405f, -0.04051148f, 
    -0.05844413f, -0.03143337f, -0.04235984f, -0.00832045f, -0.12956989f, 0.09029410f, 0.18086423f, -0.14102831f, 
    0.08827430f, -0.00974020f, 0.00979028f, -0.07505228f, -0.00877560f, -0.09101854f, -0.02179578f, 0.10093236f, 
    0.13305533f, 0.09459253f, -0.15169458f, 0.16865669f, 0.04618600f, 0.03376482f, 0.07011066f, 0.12649789f, 
    -0.02421871f, 0.02684116f, 0.08040282f, 0.04304606f, 0.40212402f, 0.00887850f, 0.06819328f, 0.09596226f, 
    0.07370643f, -0.01031535f, 0.07174189f, 0.05883631f, -0.13656931f, 0.07172753f, 0.09473627f, -0.07522622f, 
    0.28675449f, 0.07822797f, 0.21559611f, 0.08628128f, 0.01109236f, 0.00807110f, 0.04370771f, 0.05274376f, 
    -0.01889306f, 0.04013956f, 0.05992026f, 0.10488691f, -0.00983112f, -0.14862892f, -0.03315673f, -0.01130714f, 
    -0.07437945f, 0.01440861f, 0.04066161f, 0.04166010f, -0.00294313f, 0.09568343f, -0.06724559f, 0.03851991f, 
    0.10226414f, -0.30647466f, 0.04704153f, -0.14699668f, 0.10161867f, -0.00247757f, 0.03996550f, 0.19052468f, 
    0.05123607f, 0.03079792f, 0.18423568f, -0.00328297f, -0.14580147f, -0.21444495f, 0.06425070f, 0.05327975f, 
    -0.07677631f, 0.03771694f, -0.14851925f, -0.00373839f, 0.03261476f, -0.04473519f, 0.08369706f, 0.01551741f, 
    -0.23075017f, -0.20431460f, 0.06324729f, -0.06456639f, 0.08568119f, 0.08238877f, 0.05447903f, 0.05283947f, 
    0.00686312f, 0.05681452f, -0.02321324f, 0.06975416f, -0.01835254f, -0.13089369f, -0.00026106f, -0.07204453f, 
    -0.08434495f, 0.13568887f, 0.00466135f, 0.10629915f, -0.05165173f, -0.07269242f, 0.02973878f, 0.09469902f, 
    -0.02393168f, -0.29767528f, -0.21444950f, -0.01616650f, 0.20181899f, -0.01145612f, -0.07410127f, 0.01712351f, 
    0.03191895f, 0.16892467f, -0.02892287f, -0.00917175f, -0.23667276f, -0.08519148f, -0.03537730f, 0.00658617f, 
    0.10505027f, -0.06553816f, -0.09735433f, 0.11487617f, 0.01797737f, 0.06195443f, -0.02449538f, 0.01910182f, 
    0.02260526f, -0.30598930f, -0.15137243f, -0.26233995f, 0.12264931f, -0.05329995f, -0.18868411f, 0.06556519f, 
    0.09928568f, 0.00483693f, 0.00596152f, -0.07120008f, -0.31459811f, -0.36729845f, -0.10002264f, -0.19605136f, 
    0.11633983f, 0.08212880f, -0.12614778f, 0.00766560f, 0.10827234f, -0.01164479f, -0.02134969f, 0.01671017f, 
    0.04075706f, 0.13349873f, -0.01906239f, 0.03165995f, -0.09280856f, 0.08767518f, -0.00212292f, 0.10948593f, 
    -0.01986065f, -0.02835496f, 0.00772150f, 0.07246866f, -0.01920733f, -0.06017511f, -0.10183927f, 0.10827403f, 
    -0.12176017f, 0.03534812f, 0.07803810f, -0.11711629f, -0.01665959f, 0.04108305f, 0.00910334f, 0.05728214f, 
    -0.13362670f, -0.18275909f, 0.09835497f, 0.14522658f, -0.09511566f, 0.04819861f, 0.13058402f, 0.14517891f, 
    -0.16108055f, 0.00342169f, -0.01004504f, -0.09513030f, -0.33381924f, -0.28314230f, -0.08174951f, -0.09299215f, 
    0.04858041f, 0.08715948f, -0.05320048f, -0.01919414f, -0.03760119f, -0.00295641f, -0.08304993f, -0.06966662f, 
    -0.07582027f, 0.22524406f, 0.10941578f, 0.00423064f, 0.00547008f, 0.07629725f, 0.07607529f, -0.04750739f, 
    0.07679296f, 0.01958120f, -0.01978768f, 0.02164246f, 0.01956191f, -0.15938917f, -0.35520396f, -0.05437100f, 
    0.04790615f, 0.02496444f, -0.04561640f, 0.01382889f, 0.01012835f, 0.02615354f, 0.03571096f, -0.03239039f, 
    0.01958151f, -0.08871276f, 0.04442115f, -0.14049704f, -0.00150806f, 0.12704398f, -0.03714260f, 0.08193489f, 
    0.00022094f, 0.03771296f, 0.02972449f, 0.03513689f, -0.03305807f, -0.10091612f, -0.05664052f, 0.06210129f, 
    -0.08792250f, -0.01571463f, 0.01117695f, 0.15844363f, 0.02840049f, -0.02975231f, -0.01780139f, -0.06964700f, 
    -0.00611576f, 0.09951980f, 0.06996945f, -0.16603225f, 0.07452290f, 0.06541658f, 0.04937536f, -0.03195535f, 
    -0.01674066f, 0.04134002f, -0.03730855f, 0.06236933f, -0.06205679f, -0.11480808f, 0.20143546f, 0.11455533f, 
    0.05835989f, 0.00139695f, -0.04474966f, 0.01089016f, 0.02949519f, -0.08814748f, -0.07831070f, 0.09538253f, 
    0.21883221f, 0.17329305f, 0.02619896f, 0.11815823f, 0.10076168f, -0.01515309f, 0.02586686f, 0.08021484f, 
    0.08404519f, -0.04445906f, 0.02566930f, 0.07544800f, -0.17936276f, 0.11653508f, -0.00865260f, -0.12702291f, 
    -0.03148922f, -0.06692526f, 0.02373169f, 0.01362187f, 0.06969404f, -0.05673485f, 0.00001314f, 0.05091497f, 
    -0.07723421f, 0.17861226f, -0.06749801f, 0.24226061f, -0.08309650f, -0.04317314f, 0.00328081f, -0.02463909f, 
    -0.08002006f, -0.00225447f, 0.06590588f, 0.03069214f, 0.06419965f, -0.09528101f, -0.11471810f, 0.22548658f, 
    0.03551936f, 0.08039754f, 0.02055862f, 0.12500785f, 0.12207416f, -0.03471756f, 0.07378094f, 0.00138534f, 
    0.05150704f, -0.19616371f, -0.18835193f, -0.06561399f, 0.10731892f, 0.01668541f, 0.05879643f, 0.08788090f, 
    0.02423881f, 0.04826911f, 0.00315539f, 0.00288239f, 0.17823891f, 0.19815017f, 0.10984164f, -0.20024978f, 
    -0.00599097f, -0.12926042f, 0.06967086f, 0.00368924f, 0.18293315f, -0.02346176f, 0.00088291f, 0.08445490f, 
    0.21161249f, 0.11911869f, -0.03517545f, 0.14021190f, 0.03144708f, 0.04324467f, 0.03096168f, 0.06143616f, 
    0.07098554f, 0.00481087f, -0.07314364f, 0.06649764f, -0.47985521f, -0.20797901f, -0.00494504f, 0.10743991f, 
    -0.11394005f, 0.04244562f, -0.07755318f, 0.08090001f, -0.06864538f, 0.00753705f, -0.01566922f, 0.02586756f, 
    0.08236540f, 0.01482334f, 0.02298149f, 0.01421108f, 0.04071059f, 0.00632081f, 0.09525852f, 0.00951769f, 
    0.00502492f, -0.08964051f, 0.04864797f, 0.05612338f, -0.00035626f, 0.08392967f, -0.20086139f, 0.02896043f, 
    -0.04499737f, 0.05801982f, -0.02555249f, 0.05165045f, -0.00437266f, -0.04172308f, 0.08817715f, -0.03970056f, 
    0.23050848f, -0.17065021f, 0.06468327f, 0.29128820f, -0.03177611f, 0.11885964f, -0.00445612f, 0.07918356f, 
    -0.04815079f, -0.13259603f, 0.00047042f, 0.05045360f, 0.00923734f, -0.06670048f, -0.30375788f, -0.04741471f, 
    0.04057360f, -0.06392400f, 0.01571927f, -0.08148265f, 0.10918057f, 0.05232068f, 0.03642853f, 0.01466948f, 
    -0.13969268f, -0.16497141f, 0.18029775f, 0.14327469f, 0.04636271f, -0.03023775f, -0.07362003f, 0.21908024f, 
    0.08988775f, 0.03657050f, 0.09453623f, 0.01730408f, -0.26653266f, 0.00296806f, -0.07007081f, -0.13632521f, 
    0.04666716f, 0.04263357f, 0.06024724f, 0.05443450f, -0.08136141f, -0.03086645f, -0.05251847f, 0.04804160f, 
    0.21154101f, 0.07752352f, -0.03942296f, -0.07986420f, 0.04791838f, 0.01822016f, -0.09821565f, -0.00434684f, 
    0.06580538f, -0.03545754f, 0.14127754f, -0.24483642f, -0.13382596f, -0.22690167f, 0.05371876f, -0.04739581f, 
    0.00098775f, 0.07393477f, 0.05019526f, 0.00819662f, 0.05074730f, 0.05796525f, 0.11339159f, -0.11372824f, 
    0.24111566f, -0.01735063f, -0.17900890f, 0.12659664f, 0.06468986f, 0.12866829f, 0.05634316f, 0.16363101f, 
    -0.09449760f, -0.05928469f, 0.03302425f, -0.01633134f, 0.03500625f, -0.20389469f, 0.02925389f, 0.09760024f, 
    0.10334370f, -0.01493284f, -0.11302849f, 0.17400837f, 0.13585024f, 0.07336457f, 0.01917884f, -0.08528648f, 
    -0.04091429f, -0.43468273f, 0.23181722f, 0.11764468f, -0.09228047f, 0.08443058f, 0.03809587f, -0.06607411f, 
    -0.05093559f, 0.02339876f, -0.03344962f, 0.03236048f, 0.11623046f, -0.01246039f, -0.14424847f, 0.07927752f, 
    -0.08170570f, -0.11204526f, 0.05479806f, 0.07553621f, 0.02644390f, 0.03666420f, 0.11796387f, 0.09253743f, 
    0.21802089f, 0.01702581f, 0.13545404f, -0.02897202f, -0.02228312f, 0.01391109f, 0.05347764f, -0.02207271f, 
    0.00185710f, 0.00606429f, 0.00880303f, -0.07474859f, 0.16652995f, -0.03651871f, 0.14368795f, 0.06894576f, 
    0.03462835f, 0.05264041f, 0.04329916f, 0.03408161f, -0.02742905f, -0.02383078f, 0.01873746f, 0.04294685f, 
    0.02726700f, 0.06388903f, -0.12536000f, -0.07006000f, 0.10311254f, -0.08869426f, -0.00727482f, 0.11265782f, 
    0.03404031f, 0.09993566f, -0.01752634f, 0.15928252f, 0.03973320f, -0.16221289f, 0.00878290f, 0.25059938f, 
    0.02682956f, 0.06347363f, 0.05516047f, 0.01148069f, -0.00467291f, 0.03025486f, 0.10366156f, 0.08207799f, 
    0.02167984f, 0.20065261f, -0.02614078f, -0.11736068f, 0.05264841f, 0.04869773f, -0.02590118f, 0.03737627f, 
    0.02837765f, 0.01072630f, 0.01417985f, 0.08007763f, 0.30303669f, 0.11445900f, 0.01873747f, -0.10533576f, 
    -0.05618924f, 0.03531583f, -0.02477307f, 0.00795353f, 0.01748093f, -0.10314877f, -0.04323133f, -0.01212997f, 
    -0.13614282f, -0.29578871f, -0.15914936f, 0.05288937f, 0.20962361f, 0.04055514f, -0.11508854f, 0.01959864f, 
    0.05472916f, -0.01751566f, 0.07914402f, -0.01676536f, -0.03596396f, -0.03611344f, 0.03193354f, -0.00863559f, 
    -0.00940532f, -0.06278337f, 0.00254396f, 0.05229760f, -0.01353537f, 0.02375067f, -0.00804644f, -0.09567037f, 
    0.44110149f, 0.10748275f, 0.10570934f, -0.12321576f, -0.07971294f, -0.12629156f, 0.01589361f, 0.02919183f, 
    0.12267790f, 0.11511251f, 0.05073549f, -0.00566447f, 0.14803697f, -0.10517530f, 0.00792535f, 0.09698409f, 
    0.02255768f, 0.07039206f, 0.00491343f, 0.03878799f, 0.01928994f, 0.11959095f, 0.02484357f, 0.00323412f, 
    0.07958645f, 0.02569636f, 0.08729576f, 0.12332026f, -0.07589066f, -0.03190090f, -0.10049962f, 0.07271055f, 
    0.00347495f, -0.01164960f, 0.03647742f, 0.09747100f, -0.19787422f, 0.00015536f, -0.06391191f, 0.05149338f, 
    0.01170817f, 0.08260849f, 0.02200658f, 0.06039535f, -0.01704381f, 0.08850855f, 0.10181278f, 0.08411486f, 
    0.10647985f, 0.07588902f, 0.05141146f, 0.09307078f, -0.06294742f, 0.01965065f, 0.03622362f, -0.03419071f, 
    -0.04310612f, 0.09144221f, 0.11418432f, 0.04713928f, 0.16882639f, 0.11791186f, 0.08084632f, 0.05124345f, 
    -0.02016714f, 0.05780572f, 0.01661738f, -0.01824518f, 0.03046096f, 0.04382468f, 0.11501453f, 0.05494130f, 
    0.24467172f, 0.24307448f, 0.07731298f, -0.06325430f, -0.05132786f, 0.03823544f, -0.01239460f, -0.05678330f, 
    0.02098883f, 0.01791108f, 0.13729322f, -0.07747414f, 0.21742097f, -0.18580352f, -0.17920315f, 0.19749151f, 
    0.01239681f, -0.09097438f, 0.05372515f, -0.05975569f, 0.00592974f, -0.06186240f, 0.10497494f, 0.03756219f, 
    0.06834976f, 0.05521629f, -0.02355275f, -0.03117637f, 0.00074397f, 0.03966445f, 0.02585848f, 0.00693248f, 
    0.02218212f, 0.09743766f, 0.04734703f, -0.06320185f, 0.12471706f, -0.01528730f, -0.04014366f, -0.18054262f, 
    0.09602203f, 0.01581711f, -0.01604192f, -0.00804133f, -0.00092679f, 0.03283188f, -0.03157275f, 0.01189565f, 
    -0.09810590f, -0.15269166f, 0.03304499f, 0.03524607f, -0.09537412f, 0.04774241f, 0.00597298f, -0.03630849f, 
    0.00701441f, -0.00149154f, 0.08470345f, -0.03608701f, -0.20513412f, 0.08687078f, -0.00924287f, -0.05668181f, 
    0.03158744f, -0.12545033f, 0.04625569f, -0.08414387f, 0.05008159f, 0.06589817f, 0.04752675f, -0.01868912f, 
    0.25609821f, 0.09590229f, 0.02580576f, 0.03654407f, -0.09292505f, -0.03745503f, 0.02342976f, -0.03954519f, 
    0.00028945f, 0.00059743f, 0.08031763f, 0.07325231f, 0.28283814f, 0.03403314f, 0.05952791f, -0.01812660f, 
    -0.02242500f, 0.05896112f, -0.04356264f, -0.01587807f, 0.09795799f, -0.08522864f, 0.07485521f, 0.00901836f, 
    0.12760733f, -0.17741887f, 0.12167652f, -0.00752116f, -0.02806179f, 0.03440927f, 0.11854652f, 0.06433228f, 
    -0.04804972f, 0.00977197f, 0.08515462f, 0.03046590f, 0.43322390f, 0.21440266f, 0.23080510f, -0.08111168f, 
    0.02309734f, 0.00453923f, 0.00715129f, -0.00629963f, -0.01299071f, 0.09325363f, 0.01579786f, 0.12558232f, 
    0.29540494f, 0.07645907f, 0.11882295f, -0.06007976f, 0.06867577f, 0.00818081f, 0.07525560f, 0.01046344f, 
    -0.03902228f, 0.06116843f, 0.06154871f, 0.07373612f, -0.21493112f, -0.01243158f, 0.05094529f, 0.01641031f, 
    0.02788561f, -0.01000437f, -0.08018836f, 0.09525466f, 0.00855509f, 0.04849667f, -0.05108465f, -0.03679834f, 
    0.08573691f, 0.03080722f, 0.02139555f, 0.01653497f, 0.08191179f, 0.11127208f, -0.01132818f, 0.06178383f, 
    0.06595795f, 0.10594269f, 0.08169191f, 0.09848537f, -0.29572707f, -0.05260564f, -0.04724197f, 0.08762991f, 
    -0.18695068f, 0.04855279f, -0.01773462f, -0.04888307f, 0.05731785f, -0.01615000f, 0.03366098f, -0.08952249f, 
    -0.11378546f, -0.23508008f, 0.08826673f, -0.04129488f, 0.01787374f, 0.11336762f, 0.06235888f, -0.00484369f, 
    -0.03259318f, 0.08504595f, -0.05353580f, -0.00324303f, -0.03633055f, -0.05835319f, -0.00853788f, -0.09851175f, 
    -0.04603529f, 0.06163917f, 0.01802794f, -0.02309780f, -0.01010142f, 0.07521810f, -0.05865852f, -0.04685529f, 
    0.17706867f, -0.13270007f, -0.06273916f, -0.13773476f, 0.17267075f, 0.11534781f, -0.10677435f, 0.06387044f, 
    0.03601027f, 0.11458904f, -0.11687666f, 0.08506286f, -0.18028612f, -0.04447568f, -0.03184761f, -0.10859011f, 
    0.05887219f, -0.07935784f, -0.04681103f, 0.00382261f, -0.04293508f, 0.00473096f, 0.05408171f, 0.00609185f, 
    0.18281472f, -0.13255808f, -0.02290994f, -0.24737968f, 0.18258861f, 0.04683973f, -0.00641517f, 0.12758049f, 
    0.09262455f, 0.01743415f, -0.05375794f, 0.01028683f, 0.09949295f, -0.13349853f, -0.09544218f, -0.11840882f, 
    0.06043122f, 0.04894415f, 0.00522162f, -0.01567919f, 0.10763702f, 0.04435404f, -0.08818943f, -0.05599845f, 
    0.12266282f, -0.03150596f, 0.04702727f, 0.14253488f, -0.10296120f, 0.09932281f, 0.08541593f, 0.03012085f, 
    0.03570255f, 0.05751522f, 0.05014576f, -0.09799953f, -0.10751656f, -0.07579658f, -0.00056314f, -0.01287593f, 
    0.07373396f, 0.04899149f, 0.06504322f, -0.06774572f, -0.07899802f, 0.01192574f, 0.05930144f, 0.05885620f, 
    -0.13916925f, -0.01276050f, 0.08471586f, 0.10452014f, -0.03547223f, 0.06612378f, 0.00523676f, 0.02916628f, 
    -0.05152127f, 0.10220741f, -0.05084966f, 0.04781308f, -0.11743415f, -0.30073303f, -0.05952393f, -0.07280604f, 
    0.06149616f, 0.07166690f, 0.05978261f, 0.02884128f, -0.01393809f, 0.03539889f, -0.15498592f, -0.04525689f, 
    0.22833237f, 0.09044646f, 0.16283570f, 0.09015284f, -0.09761948f, 0.02484712f, 0.01484811f, 0.05054568f, 
    0.09330332f, 0.09838053f, -0.01145521f, 0.06731947f, -0.04263699f, -0.04353487f, -0.13525186f, -0.02307399f, 
    0.07304926f, 0.01439154f, 0.01410240f, 0.05658184f, 0.00202007f, -0.05612626f, 0.00445284f, -0.02627692f, 
    0.18076856f, -0.05316160f, -0.18641415f, -0.01027735f, -0.06443598f, 0.01835098f, 0.01092439f, 0.01689140f, 
    0.03339399f, -0.01970824f, -0.01079865f, 0.05640613f, -0.18523644f, 0.06335115f, -0.15294231f, 0.01650350f, 
    -0.04981151f, 0.10340720f, -0.03953135f, 0.09559908f, 0.02554326f, -0.04594068f, 0.02595746f, -0.08932599f, 
    0.27450562f, 0.03739707f, 0.12867624f, -0.02159305f, 0.01851873f, 0.09727601f, 0.03060103f, 0.03303375f, 
    0.03679717f, 0.07912848f, -0.03766751f, 0.03795227f, 0.34774011f, 0.00099101f, 0.11287327f, 0.12818010f, 
    -0.09484634f, -0.03351999f, -0.02507437f, -0.04573783f, 0.02634759f, 0.01666584f, 0.01793617f, 0.05168892f, 
    0.15648045f, 0.07401497f, -0.02323166f, 0.05649984f, 0.00563702f, 0.01406576f, 0.01698146f, -0.05289553f, 
    0.17990652f, 0.04557582f, 0.06107183f, 0.02505084f, -0.14525899f, 0.03735749f, 0.07928403f, 0.06749453f, 
    -0.02069030f, 0.06077661f, -0.09284788f, 0.08837271f, -0.02487680f, 0.02434381f, -0.02009046f, 0.11831912f, 
    -0.31275445f, 0.13662058f, -0.16445972f, 0.32450011f, -0.14665307f, 0.03999790f, -0.06819797f, -0.01399908f, 
    -0.06788325f, 0.06025255f, -0.01085057f, -0.00180936f, 0.04558256f, -0.03519389f, -0.09799845f, -0.09862299f, 
    0.00837893f, -0.04260225f, -0.00509183f, 0.05458472f, -0.00152520f, -0.02646447f, 0.02584434f, -0.02012874f, 
    0.04333773f, -0.05469645f, -0.10098907f, -0.14307314f, 0.10631791f, 0.05371624f, 0.11415182f, 0.04287264f, 
    0.01648156f, 0.01280575f, -0.04211094f, 0.07061419f, 0.17585513f, -0.01653731f, 0.11942343f, 0.07093938f, 
    -0.00880457f, -0.08360890f, -0.01282433f, 0.01961437f, 0.06670516f, 0.12155378f, 0.04718903f, 0.08351991f, 
    0.05682266f, -0.04914001f, -0.03906678f, -0.13020205f, 0.08181741f, -0.00039410f, 0.03756744f, 0.08984584f, 
    0.08649424f, -0.01507759f, -0.06107269f, 0.10607484f, -0.26385617f, -0.16659239f, 0.04632461f, -0.00613401f, 
    0.03008605f, 0.08971486f, 0.02713531f, -0.01147463f, -0.02806365f, 0.06269832f, 0.04169090f, -0.05117056f, 
    -0.12228683f, -0.00866360f, -0.06483858f, -0.01682182f, 0.15999125f, 0.11518478f, -0.00380148f, 0.09797471f, 
    -0.00632624f, 0.00847676f, 0.04997980f, 0.10151839f, 0.06600463f, -0.03788875f, -0.27923945f, -0.01449868f, 
    0.03547703f, 0.04585353f, -0.00196935f, -0.01258584f, 0.00259597f, -0.09775200f, 0.12750316f, -0.02853060f, 
    0.14389561f, 0.15095052f, -0.11245681f, -0.00824769f, 0.00084241f, 0.04601811f, 0.10709532f, -0.10693372f, 
    -0.02060583f, 0.06957971f, -0.00676891f, 0.00865411f, -0.09029190f, -0.04652160f, -0.11737955f, 0.01842244f, 
    0.06066423f, 0.04668781f, 0.08659308f, 0.03688252f, 0.10337661f, 0.06496937f, 0.00086035f, 0.00644735f, 
    -0.18550794f, -0.17953654f, 0.09473796f, -0.05141801f, 0.06931687f, -0.04524960f, 0.05078128f, 0.01978965f, 
    0.02397182f, -0.01694537f, 0.02581243f, -0.08366884f, 0.30301669f, 0.11308318f, 0.11629493f, 0.10815383f, 
    -0.13713516f, 0.00751644f, 0.00966498f, 0.08362283f, -0.00255897f, 0.03215669f, -0.04253741f, 0.09251738f, 
    0.13476254f, 0.15291233f, -0.01773325f, 0.02733198f, -0.05023117f, 0.03702500f, 0.07085972f, -0.00569213f, 
    -0.00237819f, -0.05015830f, 0.08466962f, -0.11493322f, 0.07880214f, -0.04804841f, 0.07171433f, -0.00847280f, 
    -0.14392300f, 0.01068486f, 0.09467388f, -0.03374903f, -0.01943058f, 0.09248263f, 0.14476164f, 0.06244412f, 
    -0.05958443f, 0.07436546f, -0.07859368f, -0.05438851f, 0.14477788f, 0.21183407f, -0.06058399f, 0.08968781f, 
    -0.04419679f, -0.04589919f, 0.00305179f, 0.05034157f, -0.16499025f, 0.07107727f, -0.05098863f, -0.12216581f, 
    0.11187837f, 0.01720502f, -0.05227486f, 0.01120109f, 0.08334552f, 0.05649514f, 0.01409623f, -0.01746845f, 
    0.04582236f, -0.21771364f, 0.10343543f, 0.02346843f, -0.00764206f, 0.07722110f, -0.00619598f, -0.10715486f, 
    0.00122611f, -0.00120823f, 0.08312394f, 0.04074041f, 0.00409835f, -0.06146477f, 0.08264089f, 0.01863809f, 
    0.15220946f, -0.02605475f, 0.10539619f, 0.10679523f, -0.06422763f, -0.00906429f, 0.06086875f, 0.01781438f, 
    0.36978862f, 0.12461762f, 0.02988264f, 0.06918315f, -0.10016781f, -0.12697379f, 0.04927558f, 0.00036081f, 
    -0.01433273f, 0.03706872f, 0.02588312f, 0.01837758f, 0.38800582f, 0.11006290f, 0.07067639f, 0.06312897f, 
    -0.00355378f, -0.03718668f, 0.01851904f, -0.00341445f, 0.03101935f, -0.05950136f, -0.01525937f, 0.09633545f, 
    0.15140060f, -0.06085105f, -0.12272760f, -0.06675091f, -0.03309991f, -0.04514040f, 0.08239958f, 0.04444013f, 
    -0.00032772f, -0.01081924f, 0.00818623f, 0.01946041f, -0.05839621f, 0.09773154f, 0.10997458f, -0.17514729f, 
    -0.03281222f, 0.04222194f, 0.08933946f, 0.01413509f, 0.04928154f, 0.01543269f, 0.11175328f, 0.00317693f, 
    0.12167720f, 0.07988657f, 0.15627885f, 0.04212999f, -0.02160912f, 0.06901602f, 0.02818910f, 0.07728299f, 
    0.00950710f, -0.01807288f, 0.03530924f, 0.05815560f, 0.38866663f, 0.30656129f, 0.08060213f, -0.07420519f, 
    -0.06073980f, -0.07532755f, -0.00190734f, 0.00183067f, 0.10959838f, -0.06481145f, 0.07254504f, -0.04956903f, 
    0.01502193f, -0.21125597f, -0.12208248f, -0.18658227f, 0.21630682f, 0.08516414f, 0.05302287f, 0.00939496f, 
    -0.04764375f, -0.04186118f, 0.03853109f, 0.05844814f, -0.22385415f, -0.01185203f, -0.01027368f, 0.04519074f, 
    0.10456825f, 0.06144114f, 0.10278440f, 0.11931881f, 0.02520991f, -0.01788900f, 0.01477916f, -0.02681504f, 
    0.15910654f, -0.11216781f, 0.07191525f, -0.03677512f, 0.08370043f, 0.01498602f, 0.02587484f, -0.00135709f, 
    0.09640717f, 0.00737536f, 0.05154724f, -0.08348119f, -0.00346100f, -0.07239967f, 0.00446811f, 0.10190122f, 
    -0.03336015f, -0.01943201f, -0.06888074f, 0.13417764f, 0.05112265f, 0.11608122f, 0.03322815f, -0.09402610f, 
    -0.19239275f, -0.02090709f, 0.14884609f, 0.19369172f, 0.06414170f, -0.01913950f, -0.01015919f, 0.03589108f, 
    0.07500757f, 0.05822572f, 0.02830859f, 0.02152706f, 0.09328468f, 0.02692275f, -0.08856671f, -0.10546645f, 
    0.01756884f, 0.11014673f, -0.00325281f, 0.09371239f, 0.02010528f, 0.10212764f, 0.01244119f, 0.02722754f, 
    0.01052692f, 0.03584224f, -0.00917153f, 0.07197460f, 0.04344962f, 0.07160487f, 0.02769149f, 0.00895349f, 
    -0.01215430f, 0.05877664f, 0.03601171f, 0.02502943f, 0.16958423f, -0.06031369f, 0.01319735f, 0.11501519f, 
    0.03814360f, 0.05340011f, 0.07991830f, 0.03945800f, -0.01558128f, 0.00098129f, 0.14210516f, 0.09558866f, 
    -0.00902185f, 0.12192359f, -0.09138314f, -0.04311914f, 0.06564496f, 0.06477004f, -0.02413576f, 0.01580651f, 
    -0.03921990f, -0.04560435f, 0.01514624f, -0.05254336f, 0.30850843f, -0.13230512f, 0.04114039f, 0.16869204f, 
    0.01368450f, 0.08656041f, 0.04335556f, -0.02945114f, 0.02871784f, 0.01782693f, 0.11487586f, 0.07537018f, 
    -0.07337758f, 0.01013753f, 0.04611652f, -0.02037710f, -0.09908534f, 0.04827437f, -0.04087900f, -0.05876853f, 
    0.00955933f, -0.03272706f, 0.15016526f, -0.10466842f, -0.12599035f, -0.03108763f, -0.05664956f, -0.02893448f, 
    -0.03547384f, -0.01299344f, 0.00441610f, 0.05666295f, -0.04422639f, 0.05052298f, -0.02152278f, -0.05069651f, 
    0.04509325f, 0.04810879f, -0.10198995f, -0.16695617f, -0.03384614f, 0.08027253f, 0.06790619f, 0.00513520f, 
    -0.07947265f, 0.01558131f, 0.03664007f, -0.00405138f, -0.12506981f, 0.02190076f, 0.06115515f, -0.19870076f, 
    -0.12987909f, -0.02172431f, 0.01569293f, -0.05904082f, 0.08013792f, 0.01238752f, 0.00516241f, 0.09967082f, 
    0.13471806f, -0.08382735f, 0.03455869f, 0.14099492f, 0.05200062f, 0.02945609f, 0.04433267f, -0.01345370f, 
    0.02231681f, 0.02334586f, 0.09838108f, -0.03251442f, 0.13064548f, -0.01328609f, 0.03430234f, 0.14422271f, 
    0.06991832f, 0.01016761f, -0.06947090f, -0.01789166f, 0.04732770f, -0.02119947f, -0.00634742f, 0.02120473f, 
    0.19937634f, -0.06260012f, 0.04999056f, -0.06009876f, 0.05944519f, -0.04825577f, 0.09748296f, -0.03407659f, 
    0.02915268f, -0.06171535f, -0.06536154f, -0.03783103f, 0.13139530f, 0.01281638f, 0.08642136f, -0.11129047f, 
    0.11144490f, -0.02987088f, 0.03668888f, 0.02275555f, 0.05574894f, 0.11517791f, 0.05309668f, 0.13616577f, 
    0.12069189f, -0.05373081f, 0.07544065f, -0.04549054f, -0.02092061f, -0.00999962f, 0.05201394f, 0.02780429f, 
    0.04974642f, 0.03878361f, 0.03545178f, 0.06362084f, -0.28750786f, -0.19322178f, -0.07939385f, -0.08852918f, 
    0.07221851f, 0.03800198f, 0.02583495f, 0.14191525f, 0.05395935f, -0.00272148f, -0.00386196f, -0.06311695f, 
    0.12914009f, 0.12371456f, -0.15647991f, 0.04712911f, 0.06094531f, 0.01388852f, -0.00280811f, -0.04427211f, 
    0.02906146f, 0.13988398f, 0.07140578f, 0.10588378f, 0.02901839f, 0.09575482f, -0.06253996f, -0.08910365f, 
    -0.01825581f, -0.03117326f, -0.00367879f, 0.02758535f, -0.00165797f, 0.04935616f, 0.02795386f, -0.09350543f, 
    0.11066669f, 0.05920573f, 0.01435210f, 0.13515358f, 0.00425854f, 0.02108614f, 0.00121578f, 0.11867067f, 
    -0.00827101f, 0.08931874f, 0.00531422f, 0.05437235f, -0.03385610f, 0.10874150f, -0.07036692f, 0.00910951f, 
    -0.02043186f, -0.06805646f, -0.03629283f, -0.08707990f, -0.03573642f, 0.01758146f, 0.00594727f, 0.03612237f, 
    0.30594420f, -0.19207314f, 0.01155416f, 0.05308710f, 0.01375235f, 0.02946333f, -0.13313144f, 0.10696556f, 
    0.03807050f, 0.01030121f, 0.00988466f, 0.12625839f, -0.13287772f, -0.07732493f, 0.08918361f, -0.07213206f, 
    -0.06537594f, -0.03920528f, -0.08225111f, 0.07852423f, 0.04193702f, -0.06268814f, 0.11354900f, 0.05990888f, 
    0.25253087f, -0.01452612f, 0.02591646f, 0.14512259f, -0.03410286f, -0.00330535f, 0.03861393f, 0.15425096f, 
    0.08607347f, 0.07497686f, -0.05033347f, 0.04419789f, 0.03963809f, -0.12359282f, -0.11757809f, 0.03483926f, 
    -0.09999287f, -0.16135931f, -0.05409328f, -0.02640913f, 0.00770375f, -0.01058886f, 0.04315803f, -0.07584927f, 
    0.15726244f, 0.07650837f, -0.08176062f, 0.11885830f, 0.01185671f, 0.02676261f, -0.01824413f, 0.03280243f, 
    0.13903099f, 0.05023941f, 0.02472651f, -0.03431173f, -0.06631823f, -0.02245220f, -0.00705888f, -0.13136350f, 
    -0.00739938f, 0.01293390f, 0.03367587f, -0.01224768f, -0.02239147f, 0.02899464f, 0.02519124f, 0.02501515f, 
    -0.09064639f, -0.23008476f, -0.14394383f, -0.10292882f, 0.05973211f, 0.08471537f, 0.01276627f, 0.06092549f, 
    0.10425682f, 0.08496401f, -0.00927812f, -0.01480788f, 0.25551325f, -0.00940190f, 0.09599354f, 0.13037100f, 
    -0.02837827f, -0.00739940f, 0.02820177f, 0.06906758f, -0.14373080f, -0.00715982f, -0.01223987f, -0.06143720f, 
    0.10737900f, -0.04315964f, 0.06507249f, 0.16330031f, 0.08544654f, 0.00044934f, 0.05112585f, 0.02602391f, 
    -0.06363457f, 0.10575944f, -0.01240717f, 0.08277609f, 0.24564381f, 0.01886547f, -0.04295152f, 0.10081875f, 
    -0.09407630f, -0.02247878f, -0.07869813f, -0.00667959f, 0.05736648f, 0.02039898f, 0.01033905f, 0.07780904f, 
    -0.12316629f, 0.13698302f, -0.10893854f, -0.01340402f, 0.10527714f, 0.09601653f, -0.01491784f, -0.00102460f, 
    0.07996656f, 0.00389142f, 0.02686158f, 0.01386430f, 0.07641921f, 0.20090890f, -0.10097426f, -0.13188140f, 
    0.08981816f, 0.15295982f, -0.01968190f, 0.05191224f, 0.13382007f, 0.02693386f, 0.01601226f, -0.00726153f, 
    0.13478194f, -0.09420452f, 0.05123448f, 0.04498856f, 0.06933846f, 0.07165269f, 0.00941795f, 0.01180123f, 
    0.04330426f, 0.05154262f, 0.01498234f, -0.06299029f, 0.09242854f, -0.08677796f, -0.17423238f, -0.00447170f, 
    -0.08373694f, 0.03802959f, 0.00168597f, -0.04177964f, 0.01053763f, -0.01912761f, 0.08802494f, 0.05430972f, 
    -0.06612224f, -0.04446084f, -0.12285157f, -0.07012141f, -0.03651783f, 0.07499917f, 0.02151123f, 0.04745937f, 
    -0.00052878f, -0.02079484f, -0.02171764f, 0.00141453f, -0.14645316f, -0.14604153f, -0.06429409f, 0.09669318f, 
    -0.03319128f, -0.00794188f, -0.00541651f, 0.09936393f, 0.01358786f, 0.02987361f, -0.04769640f, 0.20188335f, 
    -0.12017778f, -0.02706935f, -0.00439855f, 0.03206068f, -0.08019324f, 0.06990949f, -0.04806397f, 0.02833070f, 
    -0.04612145f, 0.05021797f, 0.02220829f, 0.09307852f, 0.40186372f, 0.02399825f, -0.12768570f, -0.07187624f, 
    -0.08883087f, -0.07748512f, 0.03043557f, 0.01973899f, -0.03166244f, 0.04836838f, -0.04803531f, 0.00521527f, 
    0.00592195f, -0.10955665f, 0.17583168f, 0.00986942f, -0.04166170f, -0.00749231f, 0.02956059f, 0.02885918f, 
    -0.01870447f, -0.03739744f, -0.02403895f, 0.14489709f, -0.02375064f, -0.10268126f, 0.22550045f, 0.08161798f, 
    0.00410630f, -0.02316619f, 0.07735799f, 0.04725054f, 0.04770266f, 0.10778018f, 0.04799520f, 0.04295550f, 
    -0.01066508f, 0.03316781f, -0.05215587f, -0.11345711f, -0.03658586f, 0.03154584f, 0.03945585f, 0.00760379f, 
    0.04823382f, -0.03631341f, 0.00688983f, 0.08553274f, -0.04233512f, -0.00738633f, 0.06990566f, -0.15076935f, 
    -0.02356137f, -0.04498276f, 0.05459008f, -0.03535409f, 0.02464022f, 0.10307001f, 0.05439585f, -0.02798043f, 
    0.07570138f, -0.04020761f, 0.00257586f, -0.09273430f, 0.08839336f, 0.16368836f, -0.00608544f, 0.14193764f, 
    -0.05633600f, -0.01325957f, 0.00319930f, 0.01111949f, 0.20074284f, 0.22932668f, -0.23095316f, -0.08219391f, 
    0.04094063f, 0.03855773f, 0.04280241f, -0.02699311f, -0.08871216f, -0.03049873f, 0.09188969f, -0.02637107f, 
    -0.02618216f, 0.29593372f, -0.22443520f, -0.25048986f, 0.11044370f, -0.04852991f, 0.05267084f, -0.00126974f, 
    0.00887511f, 0.04338897f, -0.03094307f, -0.03959838f, 0.11014494f, -0.00817773f, 0.16813262f, 0.04600812f, 
    -0.02770598f, -0.05314360f, 0.03640570f, 0.09556543f, -0.04700885f, 0.12080875f, 0.05879438f, 0.01170089f, 
    -0.26091462f, -0.09087417f, -0.01449472f, -0.10616569f, -0.01027256f, -0.00946686f, 0.03641605f, 0.03135676f, 
    -0.01645657f, 0.03080168f, 0.04983238f, -0.08371156f, -0.03069185f, 0.00250393f, 0.02954476f, 0.19830590f, 
    0.08372445f, 0.02432909f, 0.01442281f, 0.06832492f, 0.06341403f, 0.03570279f, -0.03871540f, 0.00268862f, 
    -0.12370098f, 0.04861503f, 0.19328955f, -0.04937071f, -0.05685777f, 0.09872165f, 0.09952038f, -0.00352998f, 
    0.09923188f, -0.01018752f, 0.11576283f, 0.06208535f, 0.13522297f, 0.13500182f, -0.02857197f, 0.04943408f, 
    -0.02320105f, 0.03928404f, 0.01615545f, 0.05452400f, 0.03349098f, 0.05763919f, 0.10181203f, 0.05190422f, 
    0.16516864f, 0.03371778f, -0.11007562f, -0.10718798f, -0.06442165f, 0.08403055f, 0.02927216f, -0.06038592f, 
    0.00286181f, 0.03068265f, 0.08593264f, -0.01746923f, -0.04973860f, 0.09170089f, -0.07412533f, -0.12565622f, 
    0.00508583f, -0.00321140f, 0.04835373f, -0.00899964f, -0.04361163f, -0.00327908f, -0.05050191f, 0.03796195f, 
    -0.00729969f, 0.18714827f, -0.18770514f, -0.13493189f, 0.12198621f, 0.10564889f, 0.04711142f, -0.00001117f, 
    0.05858519f, 0.05014399f, 0.06320089f, 0.06371120f, -0.08462448f, -0.02484079f, 0.11102215f, 0.09223066f, 
    0.05692179f, 0.01759273f, 0.00059991f, 0.09830529f, 0.02926237f, -0.04908875f, -0.00062943f, 0.05818609f, 
    -0.01035837f, 0.06993048f, 0.14704426f, 0.08713416f, -0.02331026f, -0.01714816f, 0.03338510f, 0.01486213f, 
    0.01765596f, 0.03405671f, 0.03670998f, 0.05298370f, 0.15392417f, -0.07089267f, 0.00484214f, -0.01062540f, 
    0.06132353f, 0.08481699f, 0.03655259f, 0.04130603f, 0.03161341f, -0.08731087f, 0.06122508f, 0.00694448f, 
    -0.03252242f, 0.01789115f, -0.08542942f, -0.15422232f, 0.04705699f, 0.00180546f, 0.01285048f, 0.03359600f, 
    0.05176243f, -0.05164067f, 0.00919013f, -0.12835152f, 0.08777970f, 0.19439130f, -0.10324623f, -0.34366125f, 
    0.06119429f, 0.09558640f, 0.08540235f, -0.00593078f, 0.10027389f, 0.13022715f, 0.05197660f, 0.03518191f, 
    0.10832456f, -0.03545521f, 0.03184927f, 0.06806245f, 0.02941129f, 0.01292525f, -0.04216038f, 0.03056365f, 
    0.03163609f, 0.08511776f, 0.01233150f, -0.01163518f, -0.07799006f, 0.01447195f, -0.01450641f, 0.02774874f, 
    0.07244372f, 0.06030340f, 0.01833447f, 0.03653605f, 0.12530103f, -0.03913207f, 0.06125946f, -0.00767658f, 
    0.26474541f, -0.03980561f, 0.16910677f, -0.03889204f, -0.02456186f, -0.03786183f, 0.07982719f, 0.00964267f, 
    -0.03420825f, -0.02049907f, 0.08401470f, 0.04262375f, 0.11541861f, 0.11320825f, 0.05258473f, -0.03235255f, 
    0.04390253f, 0.13118143f, 0.07204163f, 0.10894385f, 0.02927873f, 0.07691054f, 0.02604099f, -0.06308470f, 
    0.01260662f, -0.01684153f, -0.01395594f, -0.01380528f, 0.02328949f, -0.03278562f, -0.00763244f, -0.00392706f, 
    0.00073364f, 0.01328936f, -0.03485303f, 0.00716430f, -0.01311104f, 0.00916194f, 0.00299497f, -0.00911653f, 
    -0.00390401f, 0.02173027f, -0.03199206f, -0.00974298f, 0.02209213f, -0.01575693f, 0.02705726f, 0.02824537f, 
    -0.00556807f, -0.01387037f, 0.01848566f, -0.02980038f, 0.02555211f, 0.01153863f, -0.01376992f, -0.03540709f, 
    -0.03543909f, -0.03620913f, 0.00669107f, 0.02121640f, -0.02304612f, -0.02321170f, -0.03662204f, -0.03114190f, 
    -0.02830249f, -0.00332083f, -0.00667875f, 0.01472064f, -0.01092316f, -0.04019477f, -0.00996347f, 0.01851386f, 
    0.02008807f, 0.03477639f, -0.02983867f, -0.03055011f, 0.00312978f, -0.00730501f, 0.02870370f, -0.03692598f, 
    -0.04059150f, 0.02991963f, -0.03347556f, 0.00152796f, 0.02858103f, 0.02834064f, 0.01880723f, 0.02953130f, 
    -0.02000189f, -0.01181031f, -0.01777698f, 0.00713217f, -0.01595991f, -0.01425574f, -0.02755397f, 0.01041221f, 
    0.01951711f, -0.03812311f, 0.01895694f, 0.02620141f, -0.03109018f, -0.00546013f, -0.01838095f, -0.01510399f, 
    -0.02229209f, -0.00989786f, -0.03803806f, -0.03176871f, -0.03424738f, -0.00111177f, -0.03584085f, 0.02450765f, 
    0.00270456f, 0.02133114f, -0.01651732f, -0.02995211f, 0.01030715f, -0.00901227f, 0.00046849f, -0.01094605f, 
    -0.00396587f, -0.02387487f, -0.02128050f, -0.04080718f, -0.02121086f, 0.03519922f, 0.02533710f, 0.01100256f, 
    -0.00820602f, -0.00866518f, 0.00827233f, 0.00540506f, -0.02734766f, -0.00408350f, 0.02290835f, -0.03737331f, 
    0.00540318f, -0.03826279f, 0.02792325f, -0.04061631f, 0.02430171f, 0.00148604f, 0.01503517f, 0.03684679f, 
    -0.01579947f, -0.03419723f, -0.03595400f, -0.00260599f, 0.03675339f, -0.02799255f, -0.03714624f, 0.01736035f, 
    0.02027628f, -0.02172038f, 0.02139281f, 0.02410346f, -0.01238964f, 0.02459259f, -0.03551074f, -0.00151100f, 
    0.02295176f, -0.00240136f, 0.01219088f, -0.03807206f, -0.01697640f, 0.01799872f, -0.00551703f, 0.01599693f, 
    0.00929637f, 0.02798054f, 0.01267191f, 0.02236377f, 0.00964672f, 0.00360980f, -0.01260704f, -0.00579171f, 
    -0.03400919f, -0.02016520f, -0.00141312f, -0.03846116f, -0.02766571f, 0.00697151f, -0.00742657f, -0.03513568f, 
    0.01633974f, -0.01369133f, -0.03372702f, 0.02515011f, -0.01888302f, -0.01865491f, -0.03313183f, 0.00953502f, 
    -0.00696202f, 0.01348187f, 0.01321715f, -0.03000793f, -0.02046745f, -0.04124463f, -0.02700978f, -0.03718481f, 
    0.00787108f, -0.02731428f, 0.00932538f, 0.01149538f, 0.02071579f, -0.02435705f, -0.00184158f, -0.00817178f, 
    0.02260362f, 0.01668148f, 0.03561093f, 0.00943886f, 0.00564581f, 0.00025250f, 0.01759838f, 0.01288541f, 
    0.02146488f, -0.01581455f, -0.01728009f, -0.02580379f, -0.02961099f, -0.00554703f, 0.02847976f, -0.03370782f, 
    0.01916223f, 0.01807984f, -0.02180771f, -0.02113678f, 0.01652949f, 0.01226006f, 0.00310428f, -0.04260715f, 
    0.01932020f, 0.00560712f, 0.01198702f, 0.02936173f, -0.04181981f, 0.01528295f, 0.00967463f, 0.00000441f, 
    -0.03035952f, -0.03412813f, -0.00638475f, 0.01571679f, -0.03614907f, 0.00604201f, 0.01129815f, -0.03555400f, 
    -0.01232393f, -0.02005749f, 0.03226147f, -0.02694787f, 0.02379159f, 0.01497324f, -0.01316655f, -0.01140367f, 
    0.01764189f, -0.03615597f, 0.00775463f, 0.01091761f, -0.01280959f, -0.00442938f, -0.01208462f, -0.00050925f, 
    -0.03846201f, 0.03275956f, -0.00605058f, -0.00100344f, -0.01804166f, -0.03917628f, -0.03393915f, -0.00841431f, 
    -0.03115956f, 0.01230773f, -0.03241851f, -0.04211440f, -0.00348248f, -0.00754389f, -0.01419300f, -0.00933392f, 
    0.01774199f, 0.00421017f, -0.04118959f, 0.02526317f, -0.02856662f, -0.00439323f, 0.00440331f, -0.00086219f, 
    -0.02544200f, 0.00803530f, 0.00134777f, 0.01299956f, 0.00394083f, -0.00781968f, 0.00097553f, 0.01122429f, 
    -0.00330397f, 0.01509507f, -0.03703505f, 0.00471698f, 0.02841824f, 0.01913451f, -0.01573051f, -0.03479626f, 
    -0.02066039f, -0.03126818f, -0.01933562f, -0.03307213f, -0.01584712f, -0.02620673f, 0.01992549f, 0.01668140f, 
    -0.01414210f, -0.02867005f, -0.02691148f, -0.03526357f, 0.02642554f, 0.00802622f, -0.04160552f, 0.02149833f, 
    -0.01062652f, 0.00319739f, 0.02152085f, -0.02527926f, -0.01711882f, -0.00413023f, 0.03031753f, -0.02021660f, 
    -0.00032975f, -0.03069605f, -0.01735925f, -0.01665921f, 0.00809404f, 0.01798276f, 0.02212461f, -0.01029639f, 
    0.01412071f, 0.03710322f, 0.00300864f, -0.00463268f, -0.04421921f, -0.02019588f, 0.00037181f, -0.02952160f, 
    0.02288178f, -0.03593171f, 0.02366428f, -0.02325771f, 0.01759640f, -0.02838871f, 0.01644157f, -0.01023861f, 
    -0.03166828f, -0.02123963f, -0.03198925f, 0.02060260f, -0.03589373f, 0.00948988f, 0.00445485f, -0.03836134f, 
    -0.00944794f, 0.02918234f, -0.03607751f, 0.00883798f, -0.02854127f, -0.03548418f, 0.00573352f, 0.00446062f, 
    -0.00668720f, -0.03575883f, 0.01704299f, -0.03896812f, -0.02702330f, 0.02901394f, -0.03143393f, 0.02041390f, 
    -0.01790962f, 0.02075475f, -0.02726100f, -0.03147614f, -0.03869935f, -0.01353771f, 0.03087747f, -0.03446204f, 
    0.02934999f, -0.00613484f, -0.03988710f, 0.01275759f, 0.02573758f, 0.02303181f, -0.00167140f, -0.02707099f, 
    -0.02533143f, -0.00530461f, 0.01189830f, 0.02217958f, -0.00194305f, -0.02769886f, 0.01200559f, -0.00773415f, 
    -0.01946877f, -0.00718617f, -0.00814972f, 0.01448536f, -0.02815995f, 0.01695243f, -0.04404896f, -0.03900797f, 
    -0.00441654f, -0.03685745f, -0.04069183f, -0.00093415f, -0.03222772f, -0.00061949f, 0.01791953f, 0.02547630f, 
    0.00808873f, -0.02114969f, -0.04292070f, 0.02362890f, 0.00491228f, 0.00513497f, 0.02840338f, 0.01504457f, 
    -0.03175003f, -0.03970316f, 0.00908238f, 0.02636607f, -0.01967130f, 0.00633047f, 0.01975254f, 0.01513667f, 
    0.02338522f, 0.00587394f, -0.02826212f, 0.00831518f, 0.00793806f, 0.01492148f, 0.01479109f, 0.00770358f, 
    -0.00475011f, -0.02522479f, 0.01943677f, 0.02214793f, 0.03062707f, 0.02450475f, 0.02395631f, -0.03598473f, 
    -0.01651224f, -0.04454909f, 0.01132255f, -0.04150456f, 0.00097514f, 0.01290931f, -0.01701212f, 0.02711861f, 
    0.00555654f, -0.00169650f, -0.03080148f, 0.02819042f, 0.00581699f, 0.02772161f, 0.00865747f, -0.01099332f, 
    -0.00698633f, 0.02489145f, 0.00527446f, -0.01162071f, -0.02026458f, 0.00671521f, 0.00533307f, 0.02132363f, 
    0.01910250f, 0.00472987f, -0.02921716f, 0.01107252f, 0.01757939f, -0.04128193f, 0.02652620f, 0.00835989f, 
    -0.01752688f, 0.01430755f, -0.01300210f, -0.03087772f, -0.03531797f, -0.03731322f, -0.01379026f, 0.01142146f, 
    -0.01880542f, -0.03259961f, -0.02766961f, -0.01946023f, 0.02502519f, -0.02903414f, 0.02525684f, 0.00888074f, 
    0.02726600f, -0.03875032f, -0.03044352f, 0.00932155f, 0.01521650f, -0.03206362f, 0.02231763f, -0.02458465f, 
    -0.02261175f, -0.00993484f, -0.04342371f, -0.01605934f, -0.01878445f, 0.01730523f, -0.03805996f, -0.03841524f, 
    -0.03756737f, -0.01556467f, 0.02338634f, -0.03275745f, -0.01851190f, 0.03467637f, -0.03555170f, 0.00928685f, 
    0.01436028f, -0.01234990f, -0.00400324f, 0.01228508f, -0.00425174f, -0.02747745f, 0.00367131f, -0.00066443f, 
    -0.01721088f, 0.00204798f, 0.01304174f, -0.00856152f, -0.03074677f, 0.02166958f, -0.02721400f, -0.00018729f, 
    0.02017071f, -0.00398246f, 0.02779287f, 0.00724902f, -0.00511955f, -0.03464025f, 0.01351490f, -0.02536353f, 
    0.01156249f, 0.01453191f, 0.03249820f, 0.01685720f, 0.03845668f, -0.00664505f, -0.04016429f, 0.00156273f, 
    -0.00793557f, 0.01795575f, -0.00802124f, 0.01644950f, 0.01387673f, 0.00165706f, -0.03583962f, -0.00106740f, 
    -0.00891467f, 0.00106269f, 0.00023517f, -0.00498101f, 0.00186759f, -0.02308339f, 0.00857660f, -0.00661207f, 
    -0.01677986f, 0.01579642f, -0.01984757f, -0.01584285f, -0.02460916f, -0.01376871f, -0.03747008f, -0.03493842f, 
    -0.01313820f, -0.02162451f, 0.03272701f, -0.02789534f, 0.01651338f, -0.02159916f, 0.01291452f, 0.01024269f, 
    0.01516290f, 0.01887535f, 0.00703381f, 0.02910588f, -0.04154428f, 0.00308376f, 0.00827837f, 0.02321299f, 
    0.02062373f, -0.01581796f, -0.02450561f, -0.01246704f, -0.03423877f, -0.00622602f, 0.03439670f, -0.00502887f, 
    0.00319989f, 0.01262749f, 0.02198683f, 0.00992238f, -0.02464482f, -0.03163984f, -0.02838334f, 0.01090051f, 
    -0.01457477f, 0.00781539f, 0.01951740f, -0.03123545f, 0.02739042f, 0.01807379f, 0.03818056f, -0.01221402f, 
    0.00274498f, -0.04495264f, 0.00923655f, 0.00818910f, -0.00950712f, -0.02784412f, -0.02197523f, -0.03654015f, 
    0.02459958f, -0.01453033f, -0.00840979f, -0.02030282f, 0.00412440f, 0.01146527f, 0.00832208f, -0.00662036f, 
    -0.03626017f, -0.03513741f, 0.01535902f, -0.03567522f, 0.01275569f, 0.02855572f, 0.01115808f, -0.01035794f, 
    -0.02710891f, -0.01603531f, -0.04415046f, -0.03627785f, -0.01646466f, 0.00265573f, 0.02434297f, 0.00134294f, 
    0.03238237f, 0.01248613f, 0.00842546f, 0.00867296f, -0.03081910f, 0.01720061f, 0.01733591f, -0.00589431f, 
    0.01200198f, -0.03049821f, 0.01465772f, -0.03545945f, 0.01474503f, 0.00705116f, -0.00237043f, -0.00002595f, 
    -0.03789329f, -0.00294919f, 0.00506793f, -0.02318907f, 0.02209014f, 0.00788731f, 0.01626398f, -0.03852722f, 
    0.01008114f, 0.03296003f, 0.02636056f, -0.01313550f, -0.02529242f, -0.00354422f, 0.00685463f, -0.00148141f, 
    -0.03701231f, -0.03087565f, -0.01313617f, -0.00603513f, -0.03095747f, -0.00516654f, -0.01376481f, -0.02424628f, 
    0.00063986f, -0.04298055f, 0.02721509f, 0.02639207f, -0.03126797f, -0.01315750f, -0.02578070f, 0.01187946f, 
    -0.03396032f, 0.02168984f, 0.00661104f, 0.01087618f, -0.02740120f, -0.02505425f, 0.01159124f, -0.03452222f, 
    0.00819111f, -0.00844988f, -0.02987872f, -0.02956645f, 0.02489904f, 0.01218612f, 0.01643087f, 0.00120672f, 
    -0.02693536f, 0.00280684f, -0.01211527f, -0.02869611f, -0.02957419f, -0.04395762f, -0.02177551f, -0.02936878f, 
    -0.04154369f, -0.03697808f, -0.01366351f, 0.01363909f, -0.00553091f, 0.03466134f, -0.01896174f, -0.00317772f, 
    0.00523412f, -0.00783838f, 0.02657870f, 0.01108843f, -0.03227925f, 0.01868093f, 0.00311217f, 0.00035665f, 
    -0.02950940f, -0.02939177f, -0.03959563f, -0.04085518f, 0.00920859f, -0.01833146f, -0.00637520f, 0.01948058f, 
    0.01945793f, 0.02276570f, -0.02289034f, 0.02196888f, 0.02435606f, -0.02293839f, -0.03320939f, -0.04256771f, 
    0.02788107f, 0.00828774f, -0.03456022f, 0.01245410f, -0.00093102f, 0.02235408f, 0.00635385f, -0.03533795f, 
    -0.01478686f, 0.01386120f, 0.02398339f, -0.01545984f, -0.00495359f, -0.02614442f, -0.01732760f, -0.03583232f, 
    -0.00657650f, -0.03795403f, -0.03301730f, 0.00612917f, 0.01923047f, 0.01306301f, 0.03838097f, 0.01983600f, 
    -0.04048428f, 0.02106593f, -0.03844038f, 0.02644905f, 0.00258655f, 0.01566550f, 0.00350272f, -0.04242509f, 
    -0.01354979f, 0.00278769f, 0.02110061f, 0.02609104f, -0.00069101f, -0.00888757f, 0.01690487f, -0.01836584f, 
    -0.53572017f, 0.07283578f, 0.04289131f, -0.19833593f, 0.00478460f, 0.02403720f, -0.02890025f, 0.06625806f, 
    -0.12473158f, -0.08814400f, -0.01798287f, -0.03143636f, 0.17295869f, 0.00909944f, -0.07681384f, -0.06508179f, 
    -0.04257490f, 0.04459092f, 0.10778416f, -0.01292115f, -0.01950277f, 0.09235118f, -0.17117383f, 0.04620977f, 
    -0.21227689f, 0.22512320f, 0.06004998f, -0.16288041f, -0.06446321f, 0.01981379f, -0.02594718f, -0.08767372f, 
    -0.06335471f, 0.08961664f, 0.03189084f, 0.00586908f, 0.07607885f, 0.05164909f, -0.00823004f, 0.03384770f, 
    -0.01665117f, 0.08638190f, -0.03633582f, 0.10695886f, -0.11758181f, 0.03138496f, 0.11362768f, 0.15426512f, 
    0.10308560f, 0.14357209f, 0.12028515f, 0.01503827f, 0.05158867f, -0.05993032f, -0.02531567f, -0.03088383f, 
    -0.04479161f, 0.01690881f, -0.00289953f, -0.06534851f, 0.14776377f, 0.20472403f, 0.35280198f, 0.04713748f, 
    -0.02726181f, 0.10844333f, -0.02844654f, 0.06535252f, -0.00874814f, 0.12609352f, -0.04492645f, -0.07724540f, 
    0.17295143f, 0.02442790f, 0.05599447f, 0.03030218f, 0.01084949f, 0.06891955f, 0.11854510f, 0.03431700f, 
    0.00268592f, 0.04570793f, 0.08412688f, 0.00295806f, -0.14041561f, -0.00060381f, 0.12389299f, -0.24684459f, 
    -0.14670877f, -0.09096987f, 0.05678921f, -0.13210717f, -0.12414003f, -0.07841239f, -0.07213048f, -0.12830259f, 
    0.22959755f, 0.12095629f, 0.11056079f, 0.07882485f, 0.09844419f, -0.02635590f, 0.01479396f, 0.16810514f, 
    -0.04313513f, 0.15396856f, 0.10417714f, -0.00039455f, 0.11220375f, 0.09092054f, 0.06317031f, 0.08989374f, 
    0.03580280f, 0.07104164f, 0.03121229f, 0.07033622f, 0.06644585f, 0.01171745f, 0.05783361f, 0.02432636f, 
    0.19326968f, -0.01420808f, -0.00612669f, 0.08561063f, 0.10505962f, 0.01583550f, -0.13821346f, -0.03347404f, 
    0.08765104f, 0.04512718f, -0.05783574f, 0.04449338f, 0.18998118f, -0.06317704f, -0.07011911f, 0.00094238f, 
    0.19376369f, -0.06595079f, 0.11428264f, 0.06097848f, -0.04072297f, 0.04345300f, -0.14316382f, -0.01692113f, 
    -0.19503462f, 0.14815339f, 0.31627020f, -0.14533365f, -0.03812705f, 0.05435131f, 0.05686940f, 0.01580936f, 
    -0.17429490f, -0.00483083f, 0.03105160f, -0.08313765f, -0.04965157f, 0.15977295f, 0.27553019f, 0.02435464f, 
    0.03284971f, 0.00396875f, 0.03690931f, 0.03671877f, -0.17427260f, -0.06593840f, 0.05538431f, 0.03742604f, 
    -0.14441715f, 0.20563062f, -0.10551300f, -0.19324791f, 0.03301629f, 0.03303728f, -0.04329357f, 0.04255967f, 
    -0.13174096f, -0.03951972f, -0.09168535f, -0.10165168f, -0.19205528f, -0.07950051f, -0.07677113f, 0.05481687f, 
    -0.06035419f, -0.01548399f, -0.00898664f, -0.06476946f, -0.08032458f, -0.02210036f, 0.06335470f, -0.04424603f, 
    0.07499511f, -0.12471279f, -0.13796896f, 0.16667426f, -0.02043738f, -0.00186424f, 0.04010561f, -0.04346726f, 
    -0.06014557f, -0.04300264f, 0.05670844f, -0.09664558f, -0.02528545f, -0.09156436f, -0.00445733f, -0.05547906f, 
    -0.03888538f, -0.01179968f, 0.10763012f, -0.00825408f, 0.02487829f, 0.05222290f, -0.00857164f, -0.02058711f, 
    0.23127364f, -0.05940553f, 0.06703766f, 0.11751624f, -0.10249842f, 0.00874635f, 0.11805676f, -0.04537363f, 
    -0.04625694f, -0.05826429f, 0.14602099f, -0.12350052f, 0.17280795f, -0.22651623f, -0.09628894f, 0.12342716f, 
    -0.02752903f, -0.03456501f, -0.05926437f, 0.03973906f, -0.11520120f, -0.12136049f, 0.03144487f, 0.09434973f, 
    -0.00597566f, 0.08636118f, -0.15768848f, -0.03656744f, 0.08058498f, 0.00882851f, 0.04285873f, -0.12722532f, 
    -0.00384127f, 0.11537123f, -0.00981991f, 0.14745912f, -0.01361807f, 0.01298476f, 0.23948126f, 0.10149653f, 
    0.13258958f, 0.10293974f, 0.04830053f, 0.03634885f, -0.17591886f, -0.08069696f, 0.01200964f, -0.02280057f, 
    -0.18141508f, -0.21107501f, -0.09026064f, -0.01234426f, 0.01617930f, 0.11927767f, -0.19037105f, -0.01403676f, 
    0.03736288f, 0.01671000f, 0.04124073f, 0.03474632f, 0.01294578f, 0.10590016f, -0.12731160f, 0.10713973f, 
    0.11196946f, 0.05322773f, 0.03452200f, 0.07103609f, -0.02987730f, -0.04882820f, 0.05069390f, 0.04543347f, 
    -0.09157738f, -0.13797012f, -0.00694087f, 0.05616169f, 0.05701637f, 0.05182548f, -0.19166566f, -0.04064298f, 
    0.08469625f, -0.03379150f, 0.02575560f, 0.01644924f, -0.13647075f, -0.06107780f, -0.01066282f, 0.19875167f, 
    0.27983290f, -0.08346776f, -0.03012892f, -0.06511299f, 0.12019454f, 0.11962312f, 0.07668477f, 0.03037096f, 
    0.03203045f, 0.21618435f, 0.04229511f, -0.11671221f, -0.12636913f, -0.05222072f, -0.02896603f, 0.07092801f, 
    -0.07570166f, 0.03862561f, -0.02173779f, -0.01039156f, 0.17508999f, 0.05391877f, 0.02104795f, 0.14744420f, 
    0.13719676f, 0.12852164f, 0.21751246f, 0.05799511f, -0.00151644f, 0.04542375f, 0.01824866f, 0.05421368f, 
    -0.42142862f, -0.12786677f, 0.06192935f, 0.02452647f, -0.09209754f, 0.03167257f, 0.00825732f, 0.01734272f, 
    -0.04766724f, -0.09384391f, 0.02624392f, -0.00211237f, -0.17204157f, 0.01549387f, -0.04076494f, 0.03505404f, 
    -0.12990385f, -0.11843351f, 0.14808163f, -0.03917280f, 0.00756931f, 0.07180074f, -0.03478321f, -0.03519378f, 
    -0.15564710f, 0.34001163f, 0.21478796f, -0.07243021f, -0.07974277f, -0.02698155f, 0.04303727f, -0.04096122f, 
    -0.01712351f, -0.05846473f, 0.01572412f, 0.01569575f, 0.08203867f, 0.12050507f, -0.12351038f, 0.04837798f, 
    0.00001007f, 0.04088511f, -0.03799054f, -0.00336384f, -0.05096010f, -0.01149398f, 0.04820609f, 0.00597676f, 
    -0.02195110f, -0.15890047f, 0.17713733f, -0.17869057f, -0.07910054f, 0.02778092f, 0.02616506f, 0.07609487f, 
    -0.13687846f, 0.09617247f, -0.02973463f, -0.01373852f, 0.20700002f, -0.26438159f, 0.01137001f, 0.00454128f, 
    -0.05123558f, 0.06103995f, 0.11094724f, 0.09794071f, -0.04717043f, -0.07612780f, -0.01137895f, -0.00071614f, 
    -0.33363464f, 0.30310810f, 0.20597242f, 0.00597842f, -0.00078820f, -0.01654569f, 0.05782015f, 0.00539941f, 
    0.01386797f, 0.03293330f, 0.06283112f, 0.07205353f, -0.30647561f, -0.05814578f, 0.14347929f, 0.14687990f, 
    0.08156404f, -0.12485243f, -0.01247494f, -0.02130595f, 0.12083811f, 0.03760635f, -0.02339604f, 0.04013462f, 
    0.13541754f, 0.28511328f, 0.08473374f, -0.12896311f, -0.05219297f, 0.02708662f, -0.03004307f, 0.06748183f, 
    0.01501965f, -0.12203345f, 0.01036926f, -0.15187813f, -0.12780158f, 0.19101706f, -0.03661796f, -0.14517869f, 
    -0.16034967f, 0.01279704f, -0.06960264f, -0.00435837f, 0.02942091f, 0.05736588f, -0.05115493f, -0.02749116f, 
    0.25405818f, 0.03509657f, 0.02723132f, 0.04282985f, 0.15721257f, -0.04626710f, 0.07698292f, 0.11032733f, 
    -0.11282071f, -0.04065337f, -0.05808755f, -0.13859436f, 0.14904976f, 0.03340669f, 0.05458444f, -0.10196194f, 
    0.06236012f, 0.06012134f, -0.02649618f, 0.11422528f, -0.00784870f, -0.06395995f, -0.04415984f, 0.03845528f, 
    -0.01798045f, 0.06826766f, 0.00542148f, 0.14621052f, 0.10683505f, 0.06950750f, 0.03120756f, 0.05509662f, 
    0.05180765f, 0.08579450f, 0.03688397f, 0.05453119f, -0.11520244f, 0.22456683f, 0.26064649f, -0.33506516f, 
    -0.20020857f, -0.07292315f, 0.03517819f, -0.11795001f, 0.01264776f, -0.10578445f, 0.05022380f, 0.10138700f, 
    0.37078458f, 0.03438786f, 0.10420544f, 0.07735522f, -0.00589844f, 0.05607034f, -0.10245657f, 0.04064866f, 
    0.01399127f, -0.01226039f, 0.03122116f, -0.05024201f, -0.18291537f, 0.11916617f, 0.08214544f, 0.33489260f, 
    0.04601384f, 0.01616587f, 0.10331496f, 0.07707141f, -0.08633894f, 0.08047480f, 0.01621541f, -0.01314844f, 
    0.13468228f, -0.11566285f, 0.02811704f, 0.05252498f, 0.04834064f, 0.02702056f, 0.10022014f, 0.01012778f, 
    -0.10075284f, -0.06338425f, 0.04431750f, 0.11538863f, 0.26645312f, -0.21206145f, 0.06881311f, -0.09746104f, 
    -0.06020921f, 0.02407832f, 0.02197576f, 0.02262452f, -0.03662032f, 0.01052459f, 0.08125883f, 0.00354165f, 
    0.02319466f, -0.14618638f, -0.00322152f, 0.31658775f, 0.06772937f, 0.04347065f, 0.00969916f, 0.14812632f, 
    -0.00371654f, 0.01891684f, 0.07030483f, 0.09031855f, 0.05662401f, 0.16332288f, -0.08358151f, 0.27060816f, 
    0.08767933f, -0.06239076f, 0.02419373f, 0.00717441f, 0.00397211f, 0.01093561f, 0.10031576f, 0.02912018f, 
    0.09939504f, 0.07177023f, -0.07377922f, 0.11532461f, 0.01619304f, 0.00499497f, -0.02580245f, 0.10390194f, 
    -0.00051150f, -0.09798817f, 0.11514382f, -0.04221941f, -0.07540244f, 0.33626392f, 0.19003703f, -0.07981582f, 
    0.03424150f, 0.04684262f, 0.10864057f, 0.03048086f, -0.01039445f, 0.05633097f, -0.07270724f, 0.03965388f, 
    0.00983916f, 0.16747482f, 0.03365494f, -0.11957830f, -0.04674518f, -0.00092016f, -0.12284525f, 0.00647983f, 
    0.05408378f, -0.04050945f, 0.18709286f, -0.06393828f, -0.01340695f, 0.11765189f, -0.06527117f, 0.21820925f, 
    -0.06851607f, -0.09098413f, 0.04253491f, -0.04126003f, 0.01540771f, -0.07272275f, 0.17123875f, 0.01265914f, 
    0.37696874f, -0.25455928f, -0.05276068f, 0.00001488f, 0.04292425f, 0.11672791f, 0.07200932f, 0.07365121f, 
    0.05291555f, -0.07869577f, 0.10641821f, 0.05039680f, 0.30416834f, -0.17755473f, 0.01025383f, 0.26102003f, 
    0.04387129f, -0.05459486f, -0.03149629f, -0.09565240f, 0.00462870f, 0.04323181f, -0.00673951f, -0.01275723f, 
    -0.26137692f, -0.28964126f, 0.01617979f, 0.18022947f, 0.00492786f, 0.07504573f, 0.05913897f, -0.11996493f, 
    -0.11091617f, 0.03157724f, 0.02723757f, -0.01560134f, -0.07658696f, -0.01463101f, -0.13043800f, -0.08851618f, 
    -0.06965018f, -0.06250031f, -0.02543103f, -0.02132575f, -0.01952591f, -0.06959683f, -0.00478574f, -0.03643540f, 
    -0.26506677f, 0.13228743f, 0.24808918f, -0.15076578f, -0.08223173f, 0.05678196f, -0.04365322f, 0.02813431f, 
    -0.09499339f, 0.00929032f, 0.00807429f, -0.08944270f, -0.27293783f, 0.03348670f, 0.18536809f, 0.04097703f, 
    0.01612860f, -0.07454196f, 0.05164570f, 0.08466177f, -0.01725242f, -0.10918233f, 0.05932381f, -0.04463218f, 
    -0.09682083f, -0.11189064f, -0.01923260f, -0.10447412f, -0.05683794f, -0.08021922f, -0.00358973f, -0.09366063f, 
    -0.00015755f, 0.11327803f, 0.03589654f, 0.09129419f, -0.05324700f, -0.09221490f, 0.03283472f, 0.17976564f, 
    -0.00749858f, -0.03869476f, 0.03397650f, -0.18384261f, -0.12422810f, -0.10488297f, 0.01021739f, 0.01953536f, 
    0.10856148f, 0.21954799f, 0.08926017f, 0.01029986f, 0.00499290f, -0.03694533f, 0.05468914f, 0.01313200f, 
    0.03994646f, -0.01421229f, -0.01162206f, 0.08551042f, -0.07469840f, 0.14398305f, 0.25789678f, -0.00204158f, 
    -0.02737256f, 0.05703559f, 0.04056574f, 0.05747911f, -0.16519704f, 0.00656850f, 0.03813709f, -0.10248035f, 
    -0.22316091f, 0.03164988f, -0.06277420f, 0.17230228f, 0.05813840f, 0.10163149f, -0.04883712f, 0.06232204f, 
    0.15805987f, 0.03550186f, 0.05899373f, 0.00122702f, 0.03424246f, -0.02742190f, 0.05061278f, 0.05384636f, 
    0.00054752f, -0.09546273f, 0.11116323f, 0.00836719f, -0.00387744f, -0.09372870f, -0.15280646f, -0.03947489f, 
    0.30181107f, -0.03579262f, -0.16252492f, 0.19648719f, -0.05452682f, 0.08169213f, 0.00780167f, 0.00010100f, 
    0.10834502f, -0.01165940f, 0.07011586f, 0.17876211f, -0.18072875f, -0.19643474f, 0.20102894f, -0.17237835f, 
    -0.00816345f, 0.05701949f, -0.00069490f, -0.04936911f, 0.07894292f, 0.06938823f, 0.02383792f, 0.09275625f, 
    0.13905017f, -0.00786291f, 0.13265458f, -0.10230620f, -0.01102725f, 0.02387902f, 0.01361831f, 0.05809054f, 
    0.08839515f, -0.00268789f, 0.03298163f, 0.05567645f, 0.01741308f, -0.07132959f, 0.09777867f, 0.12161026f, 
    -0.01278169f, -0.10531042f, -0.01098256f, 0.01063321f, 0.11200836f, 0.02070321f, 0.01647491f, 0.00267512f, 
    -0.06575347f, -0.20750597f, 0.02160194f, -0.11663643f, 0.01253005f, -0.06036157f, -0.03066373f, 0.12272766f, 
    0.05499133f, 0.06367907f, -0.00890027f, 0.02656311f, -0.11211878f, 0.06396055f, 0.02914811f, -0.19350089f, 
    -0.02135195f, -0.13704032f, -0.06840148f, 0.04373508f, 0.02782864f, 0.03034373f, -0.06782763f, -0.02845634f, 
    -0.16001490f, 0.21618420f, 0.04950702f, -0.01344878f, -0.07578462f, -0.03100579f, -0.02785457f, 0.14312926f, 
    0.12472298f, 0.04722672f, -0.01635377f, 0.01451860f, 0.06029989f, 0.10248508f, -0.07222672f, -0.06850146f, 
    0.16413380f, -0.03013487f, -0.03994559f, 0.10181445f, -0.03380062f, -0.01915677f, 0.01771864f, -0.01688585f, 
    0.11576355f, -0.01228940f, -0.12547572f, 0.23930186f, -0.09880748f, -0.06362505f, 0.00922261f, -0.12031821f, 
    0.08796553f, -0.10372978f, 0.06960740f, -0.08588220f, 0.12078046f, -0.08344754f, -0.10413459f, 0.09892625f, 
    0.02663158f, 0.07635120f, 0.06506772f, -0.10499543f, 0.03621669f, -0.04636151f, 0.04113577f, -0.08179598f, 
    0.01427737f, 0.13101156f, 0.07542155f, 0.04724241f, -0.12643664f, 0.02758060f, 0.07568204f, 0.01646201f, 
    -0.07137626f, 0.04398161f, 0.12609708f, -0.03785424f, -0.29536283f, -0.10532656f, 0.02278686f, -0.03526009f, 
    0.01017240f, 0.05913058f, 0.09083665f, -0.02755418f, 0.02560770f, -0.00403608f, -0.01724358f, 0.00915308f, 
    0.06780606f, 0.06548253f, 0.08345982f, -0.10296271f, -0.01066129f, -0.11551707f, -0.03911001f, 0.01263485f, 
    0.13262892f, 0.00735890f, 0.07529468f, 0.11624918f, -0.04322082f, -0.03237642f, 0.08814856f, -0.17153963f, 
    -0.00729255f, -0.02807389f, 0.03586016f, 0.02764971f, -0.02707226f, 0.11694941f, 0.00885968f, -0.00733891f, 
    -0.04297367f, -0.13880418f, 0.05661407f, 0.15205072f, -0.06839327f, 0.03567196f, 0.10795382f, -0.05835424f, 
    0.08937608f, 0.12550694f, -0.02879458f, 0.03768216f, -0.06343603f, -0.07318154f, -0.15598053f, 0.25280738f, 
    0.07209694f, 0.07093707f, -0.09018635f, 0.02285419f, 0.14021921f, -0.00293568f, -0.04607886f, 0.03295534f, 
    -0.08033054f, -0.01941979f, -0.19774987f, 0.29901275f, 0.12664466f, 0.05867857f, -0.03654199f, -0.00961957f, 
    0.05789334f, 0.04194377f, -0.01794652f, -0.06448784f, 0.29788116f, 0.23216322f, 0.10385452f, 0.20350826f, 
    -0.00171818f, 0.03863865f, 0.01644477f, -0.05244474f, 0.02538998f, 0.09306058f, 0.11660565f, 0.01665086f, 
    -0.36359683f, 0.27837142f, 0.08280243f, -0.01898973f, -0.00510601f, 0.02262066f, -0.01847176f, 0.18962370f, 
    0.07476855f, -0.01780350f, -0.05117561f, 0.01810633f, -0.22085211f, -0.04833794f, -0.09084985f, 0.25412041f, 
    0.06786396f, 0.07095792f, -0.05020545f, 0.07413038f, 0.02598459f, 0.03307351f, -0.05971891f, -0.07961317f, 
    -0.13994771f, 0.06256158f, -0.06743474f, 0.01197668f, -0.02121953f, -0.03984253f, 0.10014509f, 0.06448691f, 
    0.00122247f, -0.01512791f, -0.00912771f, -0.07376653f, 0.11891660f, 0.13005795f, -0.01691523f, 0.06510054f, 
    -0.06678314f, 0.02684830f, 0.00870503f, -0.02316797f, 0.02410533f, 0.02526377f, 0.02368421f, -0.06490880f, 
    -0.04852031f, 0.08155846f, -0.09634814f, -0.09374376f, -0.01064271f, 0.04998225f, 0.22551218f, -0.07536899f, 
    0.01929328f, -0.09527762f, 0.05729818f, 0.00414280f, 0.10490258f, 0.05591535f, -0.13628356f, 0.07337712f, 
    -0.01665372f, 0.21532859f, 0.03003748f, -0.21864501f, 0.08336657f, 0.05881726f, -0.01258185f, 0.01273758f, 
    -0.11685842f, 0.01888435f, -0.13147317f, -0.12346578f, 0.01636623f, -0.03488496f, 0.07425698f, -0.12725469f, 
    -0.05754298f, 0.05502443f, 0.01886567f, -0.01465696f, -0.22110029f, 0.16825855f, -0.14067702f, 0.01688880f, 
    -0.06143375f, 0.00608548f, 0.07545281f, -0.09902503f, -0.02447137f, -0.02043916f, 0.01524738f, -0.00228544f, 
    -0.13156387f, -0.27560622f, 0.21000578f, 0.07700889f, 0.03261966f, 0.06470094f, 0.10272434f, 0.03906728f, 
    0.02878909f, -0.00225763f, 0.04937963f, -0.04456042f, 0.22441746f, 0.13939750f, -0.01498710f, 0.06229945f, 
    0.06037886f, 0.00074861f, -0.06693359f, 0.05248994f, -0.05611093f, 0.07439480f, 0.03935674f, 0.05245398f, 
    0.42583284f, 0.16331975f, -0.03981920f, 0.42537269f, 0.00688344f, -0.00514013f, -0.05888975f, -0.03755518f, 
    0.15029299f, -0.04430355f, -0.02628822f, 0.10871979f, -0.33333808f, -0.12725239f, -0.14472775f, -0.04483391f, 
    0.04260227f, 0.06925824f, 0.17648470f, 0.06020517f, 0.06962486f, -0.01326995f, 0.00179775f, 0.06182101f, 
    0.02315137f, -0.10793452f, 0.06145082f, -0.07952493f, -0.01125023f, -0.07252262f, 0.00195671f, 0.06478830f, 
    0.13063009f, 0.03067301f, -0.06633123f, 0.10955080f, -0.22213981f, -0.00238941f, 0.05466471f, 0.00407133f, 
    0.09983566f, 0.07405433f, 0.10958866f, -0.06478286f, 0.01038514f, -0.00350087f, -0.03096422f, -0.04293107f, 
    0.09809772f, 0.15413728f, 0.18007046f, 0.01593209f, 0.06630808f, -0.01048576f, 0.08736850f, 0.06526158f, 
    -0.03445614f, -0.01877042f, -0.05312132f, 0.07779394f, -0.17177150f, 0.20815617f, 0.14403307f, 0.03282615f, 
    -0.03261402f, -0.07320308f, 0.04863147f, -0.00984513f, -0.11225462f, 0.01356275f, 0.03854151f, 0.09832364f, 
    0.14625323f, -0.14280608f, 0.06317139f, 0.01263958f, -0.04117243f, 0.03224783f, -0.03642978f, 0.05767491f, 
    0.03657895f, -0.03715242f, 0.04781013f, 0.10996077f, -0.12409684f, 0.04860006f, 0.07044563f, 0.06108187f, 
    0.04498162f, -0.10725295f, -0.06562953f, 0.03595863f, 0.09411970f, 0.11389752f, 0.04770352f, -0.01099444f, 
    -0.18833481f, -0.16602199f, 0.19209342f, 0.17781064f, -0.00274540f, 0.05477968f, -0.05332106f, -0.11956625f, 
    0.02725597f, 0.08418852f, 0.15267271f, -0.00457574f, 0.16288699f, 0.02036457f, 0.15663646f, 0.00386241f, 
    0.06973428f, 0.06455037f, 0.05223015f, 0.02539632f, -0.05620126f, 0.04278797f, 0.01675749f, -0.06070631f, 
    -0.01145400f, 0.04131107f, 0.13735254f, -0.04156766f, -0.00352119f, 0.00617949f, -0.04744411f, 0.09629285f, 
    -0.03092520f, -0.05492753f, 0.08294102f, 0.04519301f, -0.15982741f, -0.03321987f, 0.03669677f, 0.11911581f, 
    0.14265428f, 0.03392540f, 0.08349714f, -0.02311940f, -0.06724189f, 0.03502268f, 0.11284518f, 0.12953721f, 
    0.08755563f, 0.15013528f, -0.01047735f, -0.01818354f, 0.00387158f, -0.02153494f, -0.01125095f, -0.09949499f, 
    0.03839594f, 0.03490620f, -0.09520672f, -0.10582113f, 0.05226104f, -0.15868621f, -0.07408310f, 0.04312938f, 
    0.14884564f, -0.02421099f, -0.04787068f, 0.01459624f, 0.15212594f, -0.03824417f, 0.08604701f, 0.05546364f, 
    0.05677079f, 0.00180505f, -0.09423018f, 0.08408290f, 0.09507455f, -0.02072972f, 0.04749518f, -0.01339109f, 
    0.04670426f, -0.05310196f, 0.01572592f, -0.05530844f, 0.33077523f, -0.00972136f, -0.10856464f, 0.24309745f, 
    0.02549858f, 0.01607685f, 0.09673911f, 0.01575629f, 0.02328045f, 0.03499167f, -0.05300051f, 0.02286060f, 
    -0.01172235f, 0.18131317f, 0.13346940f, -0.17821394f, 0.06774843f, -0.04562605f, -0.00838854f, -0.02902724f, 
    -0.04002012f, -0.02498936f, -0.00189017f, 0.02419650f, -0.03191096f, 0.18027833f, 0.14627521f, 0.01869903f, 
    0.07858183f, 0.05155775f, 0.12371799f, 0.00035978f, -0.01743858f, -0.05408413f, -0.01648068f, 0.08351170f, 
    -0.00878806f, -0.18011124f, 0.19225849f, 0.22100745f, -0.08285877f, -0.06009548f, -0.01363096f, -0.14608726f, 
    0.04702748f, 0.08007243f, -0.00690789f, -0.02636955f, -0.10657406f, 0.10571620f, 0.00333523f, -0.08538168f, 
    0.01454882f, 0.17110984f, -0.04060909f, -0.07617041f, -0.06423614f, -0.02293175f, -0.03968170f, -0.06327040f, 
    0.40354627f, -0.05141225f, -0.16636148f, 0.19750631f, 0.03348834f, 0.04390586f, -0.01952638f, -0.15229392f, 
    0.01317666f, 0.01125053f, 0.04269921f, -0.04748068f, 0.19575414f, -0.02990456f, 0.25661168f, -0.26848292f, 
    -0.10858443f, -0.03360453f, -0.04918441f, -0.06016367f, 0.08492030f, 0.09801336f, 0.03744068f, 0.09694681f, 
    0.11969490f, -0.02049371f, -0.03468166f, 0.07073727f, -0.02679904f, -0.04251978f, -0.01621382f, 0.06126826f, 
    0.06703554f, 0.08280215f, -0.07735576f, 0.09169959f, -0.29203391f, 0.03290575f, -0.03223822f, 0.01932840f, 
    -0.01265008f, -0.01027876f, 0.04751357f, 0.08211529f, -0.00105386f, -0.00468665f, -0.03922035f, -0.12925105f, 
    -0.41112378f, 0.26220191f, 0.22862048f, 0.02316445f, -0.03307822f, 0.01134430f, 0.06514315f, -0.05513300f, 
    -0.01964966f, -0.02243271f, -0.08244519f, 0.03784095f, -0.13257326f, 0.01055027f, 0.06290753f, 0.00000818f, 
    0.05156056f, 0.06857666f, 0.11581729f, -0.03484817f, -0.00365478f, 0.04117866f, -0.04697711f, 0.09687626f, 
    0.22202174f, -0.01022876f, -0.07201295f, 0.40804356f, 0.01711619f, -0.02874182f, -0.00230684f, 0.03320780f, 
    0.05222977f, 0.07337748f, -0.05655517f, -0.03342476f, 0.24857371f, 0.14978538f, -0.03004733f, -0.19797742f, 
    0.07824330f, -0.03749381f, -0.00323341f, -0.07831464f, -0.01214849f, 0.09729216f, 0.02603182f, -0.01027549f, 
    0.18395121f, -0.18721104f, -0.06119908f, 0.08516895f, 0.17095196f, -0.07611991f, -0.07087035f, 0.04142764f, 
    0.09221743f, 0.03930809f, 0.02916823f, 0.04252224f, 0.01275361f, 0.01735931f, 0.01092321f, 0.04494746f, 
    0.00527966f, -0.07704934f, -0.01371916f, -0.06691844f, 0.18996894f, 0.04768435f, 0.00681799f, 0.08237258f, 
    0.14009842f, -0.10058743f, 0.09359661f, 0.26588476f, 0.08662592f, 0.07172901f, 0.06323191f, 0.03194273f, 
    0.00570037f, -0.08123855f, 0.17319161f, 0.08569160f, 0.04146903f, 0.02019827f, 0.07726914f, 0.41119951f, 
    -0.01883316f, -0.03525243f, 0.03277463f, 0.06672483f, 0.10463751f, -0.05179127f, -0.05296114f, 0.02067246f, 
    -0.02013330f, -0.08616219f, 0.06437825f, -0.16576783f, -0.06961250f, 0.00446078f, 0.05921631f, 0.17080602f, 
    0.01211735f, 0.02154968f, -0.01808700f, 0.08498137f, 0.10681057f, 0.04308572f, 0.02748342f, 0.07378521f, 
    0.00281543f, -0.03804262f, 0.00517016f, 0.01699108f, 0.12552278f, 0.10397460f, 0.06053383f, 0.02196890f, 
    -0.09854156f, -0.00411864f, -0.27868059f, -0.01122081f, -0.00766006f, 0.03608428f, 0.08339085f, -0.08009459f, 
    -0.05756764f, 0.01117747f, 0.04769674f, -0.05486579f, -0.04909069f, 0.16165383f, -0.02785315f, 0.01123407f, 
    0.02108795f, 0.08575369f, 0.01605082f, -0.04704200f, 0.04760809f, 0.04998205f, -0.01015802f, 0.04503143f, 
    -0.01510626f, -0.15889862f, -0.26603535f, 0.12164301f, 0.07044215f, 0.12650536f, 0.03295366f, -0.02827449f, 
    -0.13390902f, -0.13143390f, 0.09971583f, 0.13560785f, -0.29107904f, 0.06505550f, 0.22619447f, -0.01807733f, 
    0.03425965f, 0.03452577f, -0.04543052f, -0.10575879f, -0.03891860f, -0.06602822f, -0.03444463f, 0.02539722f, 
    -0.13239466f, -0.01864025f, -0.07713121f, -0.16166911f, 0.10036633f, 0.00911482f, 0.01643140f, -0.05916546f, 
    -0.00139569f, -0.00127255f, 0.05231288f, 0.07334987f, 0.20352769f, 0.07508390f, 0.01679787f, 0.03093909f, 
    -0.02949809f, -0.15031527f, -0.00505668f, -0.05453652f, -0.04419405f, 0.06136233f, 0.08290996f, 0.17183581f, 
    -0.11602142f, -0.07096018f, -0.00605544f, -0.19219856f, 0.02532754f, 0.07416694f, -0.00464117f, 0.03937737f, 
    0.09109470f, 0.02149097f, -0.00492733f, 0.05505396f, 0.05247945f, 0.04512654f, 0.01255112f, -0.26342991f, 
    0.03789870f, -0.16669387f, -0.08506496f, -0.10386570f, -0.00525341f, -0.01696106f, -0.15937026f, -0.14738217f, 
    0.02832890f, -0.07531185f, -0.15668668f, -0.12909813f, -0.04957671f, 0.02212624f, -0.10559472f, 0.05848367f, 
    0.11009859f, 0.08097078f, -0.05897378f, 0.05018726f, -0.00932483f, 0.16175839f, 0.03714496f, -0.13636655f, 
    0.17104487f, -0.05287554f, -0.05859525f, 0.17242500f, 0.10517935f, -0.03640711f, -0.05581191f, -0.04700419f, 
    -0.04376284f, 0.07199932f, -0.12332361f, 0.16828354f, 0.04852889f, 0.05128399f, -0.01510361f, 0.05503095f, 
    0.11407594f, -0.20241185f, 0.11944138f, -0.06317659f, 0.07300147f, 0.10397813f, 0.08528688f, 0.10769632f, 
    0.00858414f, 0.21989819f, -0.02956830f, -0.03814047f, -0.05032654f, 0.04767926f, 0.12653653f, -0.00869012f, 
    0.05553757f, 0.13384011f, 0.09968945f, 0.19138931f, -0.00351958f, -0.05564219f, -0.11814054f, 0.04665893f, 
    -0.08982004f, 0.06723259f, 0.07418753f, 0.13811240f, -0.17401400f, 0.02130299f, -0.00858719f, 0.16620143f, 
    0.14259610f, 0.13660839f, 0.20643777f, 0.10133900f, 0.02359706f, 0.01263900f, -0.10050510f, -0.01245913f, 
    -0.10618117f, -0.14515908f, 0.04283607f, -0.18249404f, 0.17651699f, -0.04104298f, -0.03338451f, -0.02861361f, 
    0.05928170f, 0.01581563f, -0.00204606f, 0.03633025f, -0.17981593f, -0.03099476f, 0.04217671f, -0.18225086f, 
    0.07993516f, -0.02676161f, 0.00715252f, 0.02676165f, -0.08266670f, 0.05616895f, 0.02023741f, -0.02749270f, 
    -0.07660256f, -0.05704114f, -0.08663636f, 0.34505600f, 0.00973076f, 0.07367419f, -0.00003830f, 0.02681049f, 
    0.15808980f, 0.07650016f, -0.12506549f, 0.04995984f, -0.24579675f, -0.04599015f, -0.08931675f, 0.17826092f, 
    0.11329740f, -0.07118031f, -0.02222601f, 0.05737776f, -0.06783164f, -0.09342028f, 0.00754652f, 0.05615560f, 
    -0.10199609f, 0.17466393f, -0.09486320f, 0.00398472f, 0.03143803f, 0.05869964f, -0.07521506f, -0.08081862f, 
    -0.00636375f, 0.09604816f, -0.05063574f, -0.00181086f, 0.19663684f, 0.12955248f, 0.00959356f, 0.05437277f, 
    0.03004294f, 0.06193311f, -0.03819709f, 0.00493326f, -0.07472852f, 0.09000921f, 0.03455703f, -0.00711620f, 
    -0.31152827f, 0.06916913f, 0.03177449f, -0.09032454f, -0.00027831f, 0.00999479f, -0.08179066f, 0.15349261f, 
    0.09506588f, 0.01594041f, 0.03840443f, -0.08086878f, -0.12750524f, -0.07562562f, 0.08488167f, 0.12545530f, 
    0.10298127f, -0.10141652f, -0.08170692f, 0.08463179f, -0.00117482f, -0.05295916f, -0.12723053f, -0.12944518f, 
    -0.07896098f, 0.11019359f, 0.04233484f, 0.05655776f, -0.04028986f, -0.11253469f, 0.05911198f, -0.05748619f, 
    0.12237541f, -0.05515663f, 0.11339366f, 0.03811786f, 0.01772219f, 0.05480758f, -0.01001015f, 0.01779672f, 
    0.04315047f, 0.04361188f, -0.03767837f, -0.12697020f, -0.04555626f, -0.11386593f, 0.11788359f, -0.07949992f, 
    -0.03307547f, 0.16783975f, 0.00719099f, -0.02068391f, -0.01845698f, 0.02601058f, 0.22486205f, -0.10528094f, 
    -0.06351990f, -0.09946471f, -0.01718845f, -0.14396033f, 0.21671037f, 0.06516529f, -0.03132911f, 0.21195637f, 
    0.00700071f, 0.20593354f, 0.07004907f, -0.13883430f, 0.09144852f, -0.04373453f, -0.09283662f, 0.05138942f, 
    0.09522813f, 0.13291390f, -0.13900261f, -0.02289375f, -0.03626224f, -0.00299140f, 0.03803912f, -0.14995253f, 
    -0.04140030f, -0.01438594f, -0.03380317f, -0.08601091f, -0.02190598f, 0.35842443f, -0.05402638f, -0.11075540f, 
    0.03015500f, -0.06735680f, -0.08674150f, -0.18141328f, -0.07074755f, -0.23864581f, -0.00141718f, -0.07222164f, 
    -0.11366816f, -0.11238072f, 0.23236804f, -0.02874782f, 0.09566242f, 0.10573029f, 0.01557025f, -0.00241634f, 
    -0.06226494f, 0.02913956f, -0.04550610f, 0.08720684f, 0.17293170f, 0.06930023f, -0.08326546f, 0.14990456f, 
    0.09483414f, 0.01490680f, -0.07431243f, 0.08555758f, 0.08355135f, 0.05873031f, -0.01556695f, 0.03895033f, 
    0.16793364f, 0.19792403f, -0.05341334f, 0.11169412f, 0.00062390f, -0.01006701f, 0.00657419f, 0.01426270f, 
    -0.03036376f, 0.03282293f, 0.11448021f, 0.06524043f, -0.24240975f, 0.11463770f, -0.01385763f, -0.11314365f, 
    0.00272398f, -0.09857751f, 0.06217458f, 0.06173172f, 0.01027886f, -0.09530626f, 0.21628219f, 0.03457061f, 
    -0.04962214f, -0.08919215f, -0.02904085f, -0.25126484f, 0.11661986f, 0.03100706f, 0.02077353f, -0.08531816f, 
    0.11240810f, -0.05967980f, -0.01902232f, 0.01599345f, 0.05057827f, 0.11032436f, -0.00788800f, 0.07085373f, 
    0.09752464f, 0.00850940f, 0.10923719f, 0.00227930f, 0.01092549f, 0.15143803f, -0.01648408f, -0.09738196f, 
    0.12549002f, 0.04402740f, 0.03651102f, 0.08015350f, 0.10596363f, 0.03359330f, 0.02168379f, 0.11083140f, 
    -0.01269727f, -0.06296824f, -0.07551628f, 0.07126369f, 0.21852347f, 0.08484909f, 0.10620664f, 0.07801979f, 
    0.01205366f, -0.16464329f, -0.00133050f, 0.06560756f, -0.00341994f, 0.04947061f, -0.07558714f, 0.06925058f, 
    -0.02976240f, -0.21796118f, -0.06266125f, 0.03345212f, 0.01422244f, 0.00003703f, 0.07796735f, -0.09194063f, 
    0.01355053f, -0.10015935f, 0.08997812f, 0.14342153f, -0.34586790f, -0.00278857f, 0.04594364f, -0.05072619f, 
    0.14102753f, -0.00480546f, -0.08910293f, 0.04370053f, 0.07301234f, -0.02753201f, 0.03603828f, 0.00419629f, 
    -0.17612301f, -0.09813473f, 0.23118709f, 0.23960131f, 0.00621223f, 0.03591329f, -0.02224713f, -0.03788101f, 
    -0.04214550f, -0.03219351f, 0.11774095f, 0.10738192f, 0.02745512f, -0.00174328f, 0.01544400f, -0.23370388f, 
    0.10620514f, -0.04440185f, -0.00272649f, -0.02377999f, -0.06741590f, -0.11754394f, -0.03994900f, -0.03980001f, 
    0.33382308f, 0.07892161f, 0.06492157f, -0.01646074f, 0.09054163f, -0.01778310f, 0.00025065f, 0.15976760f, 
    0.09223791f, -0.05580483f, 0.11134180f, -0.07553620f, 0.03240564f, -0.03251337f, 0.04066557f, 0.10048661f, 
    0.07041154f, 0.06464140f, 0.07039051f, 0.02490044f, -0.03003917f, -0.07003344f, 0.16500430f, -0.00354990f, 
    0.08439699f, 0.20109336f, 0.08446774f, 0.21200953f, 0.08328822f, 0.04052700f, 0.07924975f, -0.06593500f, 
    0.05296063f, 0.04183843f, -0.09037606f, -0.06239260f, -0.02519473f, -0.10683148f, -0.15144065f, -0.17370972f, 
    0.21822090f, -0.08523781f, -0.08451518f, 0.02669576f, 0.12111260f, -0.14891189f, 0.06269924f, -0.05796633f, 
    0.04227099f, 0.03529194f, 0.15181248f, 0.14512737f, 0.03332417f, -0.00896061f, -0.00571861f, 0.02693526f, 
    0.05504173f, -0.04447429f, 0.02471987f, -0.16093335f, -0.12381208f, 0.03772173f, -0.01868437f, 0.33732581f, 
    0.04856642f, -0.00396765f, 0.05837953f, -0.04028811f, 0.08135469f, -0.03669096f, -0.07601041f, 0.03134974f, 
    0.05510129f, 0.03955785f, 0.13453779f, -0.13687347f, 0.04270658f, 0.01974922f, 0.06207434f, 0.00624560f, 
    -0.02022433f, -0.09155917f, 0.01659731f, 0.10408761f, 0.13690369f, 0.03353564f, 0.09019462f, 0.09570216f, 
    0.02075367f, -0.08879507f, 0.13655019f, 0.00480209f, -0.04867899f, 0.07519558f, -0.00438816f, 0.11482609f, 
    -0.14460219f, -0.20768362f, 0.22276309f, 0.35334110f, -0.13174711f, 0.00892483f, 0.00400215f, 0.02112222f, 
    0.08582975f, -0.07464658f, 0.03666398f, -0.03151631f, -0.02351945f, 0.10552271f, -0.08505489f, -0.03273543f, 
    0.14614871f, 0.10416466f, -0.04320307f, -0.15927695f, -0.00928430f, -0.07581487f, -0.00918265f, 0.01416528f, 
    0.20737623f, 0.23357581f, -0.05026994f, 0.18404777f, 0.07693985f, 0.07865814f, -0.06209638f, -0.09881218f, 
    -0.03024932f, -0.01420236f, 0.05300523f, -0.03828964f, -0.24066675f, -0.14998008f, -0.00683011f, -0.31379053f, 
    0.03940534f, 0.03526537f, -0.04194406f, -0.13263603f, 0.04760993f, -0.06665267f, 0.03868686f, -0.08734663f, 
    0.09164812f, -0.08041023f, -0.03948813f, 0.08654450f, 0.14792337f, -0.02508668f, -0.11291399f, 0.04562539f, 
    0.01079736f, -0.04294440f, -0.05779086f, -0.08890577f, -0.30930719f, -0.01747112f, -0.04903955f, -0.10188130f, 
    0.05308110f, 0.06299839f, -0.02424901f, 0.04052794f, 0.07209287f, 0.01040786f, -0.11705014f, -0.15920757f, 
    -0.18786566f, 0.02205793f, 0.13005017f, 0.17733209f, -0.00472248f, 0.08113063f, 0.05131538f, -0.05148468f, 
    0.03121752f, 0.04976155f, 0.00144051f, 0.08323469f, 0.32048348f, -0.01191003f, -0.01561973f, 0.14337634f, 
    -0.02608545f, -0.04677568f, -0.00080776f, -0.05826792f, -0.00001790f, 0.06244829f, -0.17260979f, 0.09366357f, 
    -0.13620442f, 0.10996295f, 0.01010658f, 0.27177921f, 0.12421539f, -0.08249800f, 0.03147831f, -0.07511991f, 
    -0.05475650f, 0.09204610f, -0.04639749f, 0.07972103f, 0.12916033f, 0.04276761f, -0.11867528f, -0.09934689f, 
    0.09151986f, 0.02043194f, -0.05959814f, -0.11065893f, 0.05458802f, 0.04784374f, 0.02553526f, -0.04902430f, 
    0.21633659f, -0.17392147f, -0.13829172f, -0.04542826f, 0.10317491f, 0.05302968f, -0.06998844f, -0.05685732f, 
    0.09019136f, 0.00516912f, -0.02469749f, 0.03528548f, -0.14323400f, -0.12099098f, -0.02507278f, 0.02263512f, 
    -0.02104810f, -0.00849988f, -0.07079954f, -0.05434179f, -0.03203027f, -0.00498410f, 0.05001279f, -0.02672136f, 
    0.15441103f, -0.06684954f, -0.00934008f, 0.20601614f, -0.00599397f, -0.00495913f, -0.02616919f, 0.03617698f, 
    -0.00197313f, 0.02297451f, 0.10042679f, 0.18356745f, 0.14297050f, -0.12761071f, 0.11917541f, 0.47404814f, 
    0.08865253f, -0.08439970f, 0.00889482f, 0.05309948f, 0.05168900f, -0.10084800f, -0.15433723f, 0.08153199f, 
    -0.02681307f, -0.09331529f, -0.01136572f, -0.21140572f, 0.06633487f, 0.04605159f, -0.01871249f, -0.01625193f, 
    0.00288649f, 0.08276415f, -0.14404376f, 0.09670309f, 0.01276204f, -0.19733036f, 0.00463563f, 0.01358798f, 
    0.05766253f, 0.08096586f, -0.00522988f, -0.06124225f, -0.08197331f, -0.02752086f, -0.02139639f, 0.04608123f, 
    -0.01567530f, 0.12702030f, -0.09787614f, 0.12130982f, -0.08112030f, -0.00098725f, 0.05911878f, -0.00825330f, 
    0.09871377f, 0.02818472f, 0.03948829f, -0.05014110f, 0.11503036f, 0.13312040f, 0.13845311f, 0.05104783f, 
    0.09754058f, 0.01224977f, -0.02549911f, -0.08115695f, 0.02084810f, 0.11883283f, 0.06292286f, 0.06273408f, 
    0.10386014f, -0.11705559f, 0.06077062f, 0.05548316f, -0.03364845f, 0.00837231f, 0.03276111f, -0.02121180f, 
    -0.04860875f, -0.04591411f, 0.04550563f, 0.08135975f, -0.23156683f, 0.05241664f, 0.16837895f, 0.23956314f, 
    -0.10392163f, 0.14130494f, -0.17814600f, 0.01033862f, 0.02479589f, 0.09300245f, -0.12031194f, -0.10593855f, 
    -0.09831940f, -0.03598897f, 0.09147488f, 0.12202147f, -0.04833815f, 0.02607442f, -0.00011383f, -0.03807532f, 
    -0.01906554f, 0.14598759f, 0.12980756f, 0.14681517f, 0.10450654f, 0.07222039f, -0.05714541f, -0.00992622f, 
    -0.05441796f, 0.06025299f, -0.06146792f, -0.00130397f, -0.01905994f, 0.21809994f, 0.15023324f, 0.15567894f, 
    0.01520446f, 0.07396227f, 0.05512739f, 0.09417336f, -0.05546995f, 0.04635468f, 0.00835672f, -0.07269566f, 
    0.00483053f, 0.04664332f, 0.09831537f, 0.05337610f, 0.29035941f, 0.14066489f, 0.09532557f, 0.08304965f, 
    -0.04252321f, 0.05585031f, -0.00285104f, -0.06460342f, -0.10194955f, -0.05651418f, -0.00863640f, -0.00925212f, 
    0.01118130f, 0.17647728f, -0.06372934f, -0.01922324f, -0.01128588f, 0.01473352f, -0.05782750f, 0.02061841f, 
    0.05526931f, -0.02971864f, -0.02399552f, -0.03816101f, 0.34009060f, -0.20019135f, -0.04289224f, 0.13327499f, 
    -0.02757292f, -0.07730849f, 0.00038466f, 0.03746953f, -0.01673504f, -0.09078177f, 0.06371306f, -0.04105010f, 
    -0.08229062f, -0.00531841f, -0.11592499f, 0.10879631f, -0.02122727f, 0.06609833f, -0.03637939f, 0.04608758f, 
    0.06263224f, -0.06487164f, 0.24996309f, -0.07132486f, 0.01701479f, 0.00374339f, -0.02489333f, -0.23006096f, 
    0.04280983f, 0.16848345f, -0.06106788f, -0.01124390f, 0.00541701f, 0.07683684f, 0.07615555f, 0.00294730f, 
    -0.10619175f, 0.08711337f, -0.02147621f, -0.04367920f, -0.02004026f, 0.06390010f, -0.04811886f, -0.07060226f, 
    -0.09252878f, 0.07390988f, 0.13792647f, 0.06946182f, -0.38967049f, -0.07403720f, 0.03995899f, -0.05237163f, 
    -0.03453092f, -0.01341466f, 0.14998025f, -0.11758593f, 0.13428085f, 0.07318416f, -0.08751939f, -0.03309864f, 
    0.16194630f, -0.08882613f, 0.09001183f, 0.10425408f, -0.02703882f, 0.01806300f, 0.10447685f, -0.07065157f, 
    -0.08567830f, 0.08919646f, 0.03565704f, -0.00022706f, 0.18574286f, 0.05344051f, 0.06303713f, 0.11059748f, 
    0.02681214f, 0.05498833f, -0.03856703f, -0.04999870f, -0.00062412f, -0.10014363f, 0.01583827f, -0.02832320f, 
    0.02142982f, -0.12346707f, 0.08947147f, 0.10647529f, -0.03669055f, 0.06828912f, 0.04040722f, 0.00619013f, 
    0.00176226f, -0.04600180f, -0.05978152f, -0.00202460f, -0.03474844f, 0.08576903f, 0.08044289f, -0.01158475f, 
    0.04000549f, -0.06688234f, -0.00414169f, -0.06036950f, -0.07098717f, 0.13418637f, 0.03816048f, 0.29718813f, 
    0.14834198f, -0.04268320f, -0.08467219f, -0.24128419f, -0.00420243f, -0.03331974f, -0.03643405f, -0.02339842f, 
    0.00829621f, 0.06029973f, 0.03645278f, 0.09606579f, -0.25988328f, -0.17553380f, -0.08421789f, -0.04193203f, 
    -0.05721482f, -0.03675968f, -0.03116521f, 0.13586569f, -0.02942268f, 0.04686728f, 0.04240648f, -0.03767736f, 
    -0.05571908f, 0.21391410f, -0.09260848f, 0.02154398f, 0.04352440f, 0.10916656f, -0.07502751f, 0.04568665f, 
    0.13466565f, 0.13000774f, 0.12739736f, 0.02192838f, -0.27143848f, 0.05544296f, -0.07311334f, 0.04382816f, 
    -0.05987221f, -0.07497368f, -0.05555051f, 0.06082887f, 0.00396806f, -0.06011054f, -0.04506560f, -0.24749726f, 
    -0.08638184f, 0.05860793f, 0.10094340f, 0.08720098f, -0.01839712f, -0.08664639f, 0.02063191f, -0.07378437f, 
    0.04335526f, 0.02712383f, 0.05711153f, 0.03465098f, -0.04792175f, 0.08340951f, -0.06625778f, -0.18680607f, 
    0.00863381f, -0.02528195f, -0.06236774f, -0.12966612f, -0.06313730f, -0.03244124f, 0.07916674f, -0.10314225f, 
    0.19919153f, -0.03237407f, -0.09830733f, -0.13272873f, 0.01656852f, 0.06979900f, -0.12174720f, -0.02226027f, 
    -0.01810462f, 0.04498565f, -0.13536707f, 0.01389156f, -0.05237288f, -0.09852762f, -0.02666635f, -0.09920821f, 
    0.06059576f, 0.00535383f, 0.00110561f, -0.01902944f, 0.02225618f, -0.22355248f, -0.02830745f, 0.06710255f, 
    0.36866251f, -0.03380256f, 0.00636457f, -0.18766965f, 0.02578953f, -0.02041168f, -0.00240925f, -0.00321801f, 
    0.07533422f, 0.09304477f, -0.13385653f, -0.02992804f, 0.05342390f, 0.23164913f, -0.18766940f, -0.09047908f, 
    0.08161303f, -0.15269782f, -0.14807142f, -0.17238827f, 0.09574860f, -0.08768415f, -0.01072258f, -0.12813987f, 
    0.02459704f, 0.01993673f, 0.20680165f, 0.07300982f, -0.11702042f, 0.13663311f, 0.01746832f, -0.03944075f, 
    -0.01907238f, -0.00854153f, -0.00054462f, -0.08998729f, -0.11909951f, -0.18182625f, -0.03608039f, -0.03950970f, 
    0.02461338f, 0.00788146f, 0.09077881f, -0.00468934f, -0.05985231f, 0.05916554f, 0.03481862f, 0.07105182f, 
    -0.06515748f, -0.00957991f, -0.04331425f, -0.07999788f, -0.03854719f, 0.04295348f, 0.01043939f, -0.03354314f, 
    0.03274209f, 0.07725489f, 0.08031071f, 0.08823158f, 0.08726116f, 0.04953998f, 0.01249679f, -0.12874882f, 
    -0.13359840f, -0.12739815f, 0.11438330f, 0.04879665f, -0.10922444f, 0.00462242f, 0.03015832f, -0.06639425f, 
    0.11849073f, -0.03462321f, 0.22941078f, 0.08765517f, -0.03695097f, 0.08987073f, 0.05432887f, 0.02445120f, 
    0.02726086f, 0.10338589f, -0.05458554f, 0.11256538f, 0.28831697f, 0.07362179f, -0.10462548f, -0.04214438f, 
    -0.03630659f, -0.01914452f, -0.02610119f, 0.00205729f, 0.06845353f, 0.06379183f, -0.10578801f, -0.10458194f, 
    -0.02941824f, 0.08373550f, -0.10332260f, 0.07625409f, 0.03533506f, 0.09981833f, -0.02692990f, 0.03101073f, 
    0.01133444f, -0.03501505f, -0.10749393f, -0.02288737f, 0.10476206f, 0.18917859f, -0.00329713f, -0.02773368f, 
    0.02347298f, 0.10761087f, -0.05823898f, 0.06869510f, 0.02485535f, 0.01268630f, -0.08034948f, -0.07237064f, 
    -0.01265569f, -0.09342651f, 0.14222610f, 0.17022365f, 0.03231817f, 0.09222607f, 0.06464492f, 0.01509603f, 
    0.00452807f, 0.01059720f, 0.05207872f, 0.13840085f, -0.15166561f, 0.06654615f, -0.01201989f, 0.06707156f, 
    0.00443477f, -0.01987130f, -0.03992594f, -0.06326774f, 0.11912569f, -0.03863597f, 0.10613842f, 0.09905446f, 
    -0.02959188f, 0.04528380f, 0.19087289f, 0.20684792f, -0.06089079f, 0.10855545f, -0.00108339f, -0.05693826f, 
    0.11793942f, -0.05788583f, 0.08997229f, 0.07352639f, -0.04380515f, -0.07761906f, 0.00096953f, 0.04582777f, 
    -0.07429667f, 0.03898237f, -0.06992093f, 0.06022920f, -0.08139274f, -0.00450884f, -0.05332889f, 0.20394017f, 
    -0.03437985f, 0.05278474f, -0.18129292f, 0.22133690f, -0.03225765f, 0.04987814f, -0.16377448f, 0.11099936f, 
    0.04400802f, -0.01718942f, -0.02713402f, -0.11133589f, 0.32630482f, -0.09049867f, -0.06744859f, -0.22898477f, 
    -0.09907455f, 0.00241450f, -0.01688164f, 0.05910122f, -0.09974597f, -0.00580062f, 0.01215296f, -0.11067905f, 
    -0.09872307f, -0.01275776f, 0.11682175f, -0.03426806f, 0.07502746f, 0.02087642f, 0.12980522f, -0.09895205f, 
    0.16412382f, 0.02778479f, -0.06414035f, 0.06795904f, -0.07778824f, -0.13096412f, 0.06455927f, 0.04565705f, 
    0.05131115f, -0.12917221f, 0.00660301f, -0.04066078f, 0.08573683f, -0.07817158f, 0.06410439f, -0.04913455f, 
    0.10607024f, -0.18833555f, 0.15971491f, -0.18518063f, 0.06973515f, -0.02757987f, 0.00130029f, 0.06789914f, 
    0.12846702f, -0.08548027f, -0.00096090f, -0.04638128f, -0.35025355f, -0.01775399f, 0.05518278f, 0.10308446f, 
    0.05716363f, -0.12117266f, 0.11059571f, -0.16679421f, 0.01062850f, 0.10422792f, 0.05204786f, -0.05728322f, 
    -0.03474681f, -0.00237247f, 0.06415050f, -0.08158936f, 0.13109596f, 0.19468704f, -0.11035343f, 0.07504450f, 
    -0.12628624f, -0.07291521f, 0.01633547f, 0.12732518f, 0.25039324f, -0.00593415f, -0.13003699f, -0.16352606f, 
    0.04459858f, -0.02166395f, -0.01267927f, -0.08621402f, -0.02153539f, 0.03927181f, 0.15489934f, 0.08549783f, 
    -0.19704954f, 0.20759843f, -0.02524130f, 0.17573678f, 0.04881436f, -0.06313642f, 0.11504101f, -0.05575656f, 
    0.04076948f, 0.01017217f, -0.01163252f, -0.02620810f, -0.02059094f, 0.07671301f, -0.01202155f, 0.11087291f, 
    0.09803772f, -0.03226162f, -0.01856960f, -0.01280504f, 0.02623486f, 0.02285011f, 0.01658796f, 0.06118358f, 
    -0.24664859f, -0.08014005f, -0.03666039f, -0.18234386f, -0.05537139f, -0.00334921f, -0.04419945f, -0.00089140f, 
    -0.01372337f, -0.01657697f, 0.02929179f, -0.10580698f, 0.11396717f, 0.07914830f, 0.22698553f, 0.19359140f, 
    -0.11993599f, -0.00963187f, -0.08927508f, 0.02020041f, 0.09861629f, 0.03242354f, -0.00506639f, -0.01205683f, 
    -0.17366035f, 0.07310294f, 0.03169622f, 0.09729217f, 0.01870023f, 0.09116718f, 0.03152814f, -0.05327803f, 
    0.09266969f, -0.12056465f, 0.07830293f, -0.10772191f, 0.01150881f, 0.15926939f, 0.04661136f, -0.00105440f, 
    -0.07104100f, 0.02727302f, 0.11456811f, 0.02384171f, 0.07267001f, 0.01875743f, 0.07621273f, -0.00604651f, 
    -0.00825675f, -0.00768759f, 0.04298088f, -0.12947503f, 0.08181246f, 0.21901605f, -0.11083326f, -0.00138278f, 
    0.05013299f, -0.04394302f, 0.08900474f, 0.10183264f, 0.08021618f, 0.06346301f, -0.08611223f, -0.07505913f, 
    0.02859997f, -0.02156935f, -0.11210258f, -0.04583969f, -0.02109730f, 0.06143965f, -0.18351892f, 0.07097360f, 
    -0.26759815f, 0.19305846f, -0.08524612f, -0.04934745f, 0.15174042f, 0.00416291f, -0.00988241f, -0.12615362f, 
    0.05375648f, 0.15863979f, 0.09432156f, 0.12407256f, -0.14314446f, -0.12811428f, 0.04681325f, -0.16215138f, 
    0.14955907f, 0.03015525f, 0.01708372f, -0.04088425f, -0.02731630f, -0.06808709f, 0.03781821f, -0.03463864f, 
    0.09267504f, -0.01044054f, 0.05249612f, 0.04001283f, 0.00170522f, -0.02616621f, 0.10761537f, -0.00120019f, 
    -0.07571777f, 0.00846393f, 0.00049359f, 0.00114780f, 0.02223946f, -0.00644585f, 0.02799604f, 0.11676794f, 
    -0.02558352f, 0.01250918f, 0.05875207f, -0.02846960f, -0.08708643f, -0.22894657f, 0.06178325f, -0.00510230f, 
    0.17127445f, -0.09351581f, -0.01020802f, 0.03880109f, -0.04893556f, -0.03667517f, 0.06126541f, 0.00478996f, 
    -0.02133159f, -0.00064536f, 0.20256995f, 0.06847066f, 0.06354729f, 0.17057206f, 0.17289457f, -0.15482143f, 
    0.07641824f, -0.05691870f, 0.09310637f, -0.08156422f, 0.07522121f, 0.01121475f, -0.13335758f, 0.03788108f, 
    0.06209020f, 0.05625301f, 0.13020179f, 0.12000915f, 0.03314176f, -0.03674209f, -0.10228653f, 0.01030140f, 
    0.04279377f, 0.02065070f, -0.06869654f, 0.12978636f, 0.09315486f, 0.00672997f, 0.07392003f, 0.08638576f, 
    0.05422743f, 0.05366826f, -0.03815629f, -0.00600404f, -0.03534624f, -0.17561153f, 0.03191143f, 0.03565158f, 
    0.22067720f, -0.03682945f, -0.07084400f, -0.12399013f, 0.03544851f, -0.00256119f, 0.14793347f, 0.09489658f, 
    -0.00506201f, -0.02009521f, 0.07854404f, -0.04352738f, 0.02239873f, -0.01019351f, 0.01028756f, 0.00328764f, 
    0.06454273f, 0.09640389f, 0.10461504f, 0.03693017f, -0.00284919f, 0.07418356f, 0.07308819f, -0.02326148f, 
    -0.04603796f, 0.10531524f, 0.24973223f, 0.14444308f, 0.07558846f, 0.04488698f, 0.03398803f, 0.01565023f, 
    0.03284413f, 0.12728733f, 0.00188074f, 0.02784325f, 0.07569693f, 0.22068974f, -0.05534301f, -0.10204144f, 
    0.23225477f, -0.00361601f, 0.08000852f, 0.08669281f, 0.10893901f, 0.03245732f, 0.11207967f, 0.15328036f, 
    0.17973171f, 0.13527885f, 0.00820576f, 0.13010801f, 0.07868435f, 0.03954948f, 0.04290489f, 0.00277104f, 
    0.09713821f, -0.05922351f, 0.00788992f, -0.01657484f, 0.10818683f, 0.07802000f, 0.13873374f, 0.10648935f, 
    0.16726375f, 0.05595604f, 0.05865178f, 0.00271672f, 0.06084326f, -0.06345958f, -0.02810066f, -0.04387658f, 
    -0.06724688f, 0.12573306f, -0.08739825f, -0.01939744f, 0.12670256f, 0.10962130f, 0.00658840f, 0.09566087f, 
    0.10741742f, 0.02165653f, 0.03759162f, 0.04736045f, -0.11153904f, -0.05742504f, -0.11623137f, -0.03218945f, 
    0.09429550f, 0.05662703f, -0.00111721f, 0.07986859f, 0.06261338f, 0.11113700f, 0.11694336f, 0.12174527f, 
    -0.08644679f, -0.09381197f, 0.10862202f, 0.08221044f, 0.05480399f, 0.07830482f, 0.07545673f, 0.04212995f, 
    0.08205245f, 0.11181085f, 0.06384813f, 0.24776559f, -0.40531936f, 0.20929287f, 0.05602248f, -0.07245442f, 
    0.08993180f, 0.25743616f, 0.04690420f, 0.08976611f, 0.09981993f, 0.20033479f, -0.00662578f, 0.03961596f, 
    -0.02369926f, -0.00118850f, 0.00725265f, 0.09139498f, 0.07047745f, -0.01746243f, 0.05810732f, 0.08613811f, 
    0.02607009f, 0.06922524f, -0.19472256f, 0.09533101f, -0.04999064f, -0.02048831f, 0.16098151f, 0.22127731f, 
    0.07120314f, -0.10793766f, 0.20984192f, 0.14230828f, 0.06682065f, 0.08200374f, 0.01263337f, 0.05246426f, 
    0.00637832f, 0.10454549f, -0.02586084f, 0.02704971f, 0.16828452f, 0.07283404f, 0.11454559f, 0.12749952f, 
    0.10829929f, 0.07298294f, -0.00092881f, 0.00729076f, 0.32314256f, 0.07579213f, -0.06008953f, 0.15247723f, 
    0.07581220f, 0.15429226f, -0.10429692f, 0.10862976f, -0.02248902f, 0.02522801f, 0.17102689f, 0.06266659f, 
    -0.07962127f, 0.11220310f, -0.00794475f, 0.02434297f, 0.10053189f, 0.09515917f, -0.01310341f, 0.07303825f, 
    0.09788264f, 0.04315428f, 0.02289802f, 0.12772644f, -0.12989749f, 0.08534575f, -0.14057341f, -0.00754925f, 
    0.06671762f, 0.02470420f, 0.08488362f, 0.11980961f, 0.09258530f, 0.16250513f, -0.01617600f, 0.04133971f, 
    -0.05274822f, 0.23050548f, 0.14761263f, -0.04286880f, 0.23111515f, 0.01584938f, -0.06503329f, 0.05263119f, 
    0.12782258f, 0.04289934f, 0.13139430f, 0.04789849f, -0.23619816f, -0.18647076f, 0.12228347f, 0.06817476f, 
    -0.06189023f, 0.08801250f, 0.09795616f, -0.02554492f, 0.09227574f, -0.03956331f, 0.08143944f, -0.19072998f, 
    -0.22754897f, -0.25181481f, 0.21778025f, -0.00018827f, -0.02435227f, 0.06348725f, 0.12746969f, 0.06424323f, 
    0.04022594f, -0.00087664f, -0.03287236f, -0.07196643f, 0.31874350f, 0.17349678f, 0.10124035f, 0.18090887f, 
    0.06326887f, 0.08870944f, 0.11488787f, -0.06316137f, 0.09305146f, 0.02351629f, -0.00076407f, 0.18329041f, 
    0.20141193f, -0.02921653f, -0.01426729f, 0.01285602f, -0.01966491f, 0.03470085f, 0.08029184f, -0.01395491f, 
    -0.01196186f, -0.02759564f, 0.01242702f, 0.09875800f, 0.13989873f, 0.16812727f, 0.20546860f, -0.16405638f, 
    0.09671468f, 0.17155704f, 0.11909160f, 0.03688364f, 0.03722504f, 0.15147993f, 0.13172485f, 0.28194195f, 
    0.23179473f, 0.21813308f, -0.09936576f, -0.12302036f, 0.10743292f, 0.05530273f, -0.03800625f, 0.13131936f, 
    0.10465642f, 0.04477204f, 0.04356466f, 0.03320993f, 0.15575889f, -0.09692437f, -0.03668851f, 0.20828676f, 
    0.03475404f, 0.07964446f, 0.23026651f, 0.18189110f, 0.18262555f, 0.10225992f, 0.04911039f, 0.08688623f, 
    -0.10007346f, 0.11049088f, 0.01635867f, 0.07620273f, 0.05154932f, -0.03568735f, 0.22136314f, 0.14770739f, 
    0.07668978f, 0.03755682f, 0.19604056f, 0.02818974f, 0.14201203f, -0.05790804f, 0.08106655f, 0.14227135f, 
    0.03128498f, 0.05992502f, 0.07504921f, 0.16054486f, 0.03088281f, 0.22125715f, 0.14209890f, 0.06266756f, 
    -0.14767492f, 0.00624548f, 0.01682784f, 0.13990164f, 0.06223094f, 0.02335220f, 0.20381688f, 0.12413222f, 
    -0.03789699f, -0.00606155f, 0.16471417f, 0.11431420f, 0.00964525f, 0.00865570f, 0.20600012f, 0.07652746f, 
    0.00523272f, 0.19280957f, 0.19973412f, 0.28448927f, -0.02135298f, 0.15367910f, 0.05407989f, 0.09841298f, 
    -0.16311228f, 0.28803906f, -0.05822537f, -0.16456114f, 0.14573283f, -0.08489278f, -0.05515009f, 0.06429296f, 
    0.05132630f, 0.03671909f, 0.01394593f, 0.15402924f, 0.04810039f, 0.04750456f, 0.02477993f, 0.17047715f, 
    0.08532148f, 0.11348022f, 0.07893019f, 0.06351695f, 0.10358270f, -0.01467216f, 0.01060889f, -0.02726343f, 
    0.22646432f, 0.04267065f, 0.10389966f, -0.00551993f, 0.07300523f, 0.04066633f, 0.12601085f, -0.01682941f, 
    0.08236999f, -0.07182164f, 0.06139179f, 0.05425747f, 0.18450668f, 0.24567705f, -0.04080644f, -0.03202948f, 
    0.13942231f, 0.14041920f, -0.02370302f, 0.06877112f, 0.11379458f, 0.05657202f, 0.04497901f, 0.10324350f, 
    -0.07558067f, 0.01653608f, -0.07219319f, -0.05116348f, 0.02713786f, -0.00320743f, 0.00546105f, 0.01687056f, 
    0.03814737f, 0.02195597f, 0.10366353f, 0.01934398f, -0.15295970f, -0.05823717f, 0.07928219f, 0.11695062f, 
    0.06573740f, 0.11659354f, 0.09404724f, 0.11564155f, 0.05710687f, 0.00182543f, 0.10125787f, 0.19931279f, 
    -0.01019662f, 0.18043613f, 0.25410542f, 0.23065636f, 0.05530395f, 0.01674242f, -0.01828366f, -0.02908839f, 
    0.09771511f, 0.14485656f, 0.22486071f, 0.02557499f, 0.00808936f, -0.02225680f, 0.08029571f, 0.11489154f, 
    0.11561800f, -0.01894481f, 0.09769887f, 0.03043120f, 0.04646181f, 0.12068485f, 0.15394060f, 0.11260809f, 
    -0.06649302f, 0.16423029f, 0.03027583f, 0.05719207f, -0.01938623f, -0.04070681f, -0.02982202f, -0.02284031f, 
    0.07960969f, 0.07477114f, 0.08277061f, 0.03939438f, -0.11931933f, 0.12275226f, -0.01272930f, -0.12897749f, 
    0.11858125f, 0.15895416f, 0.05924136f, 0.07155249f, -0.02465574f, 0.16160643f, -0.03571378f, 0.03856434f, 
    -0.00820384f, 0.09064016f, 0.06245938f, -0.13961735f, 0.06678542f, 0.02677893f, 0.04515165f, 0.10465483f, 
    -0.06231378f, 0.12706524f, -0.02866296f, 0.03095903f, 0.26182076f, 0.10420498f, 0.02432097f, 0.13011575f, 
    0.06048284f, 0.02667369f, 0.15097764f, -0.03273734f, 0.11640993f, 0.08747631f, 0.15728894f, -0.07133193f, 
    0.15847436f, -0.12547269f, -0.01516926f, -0.12582138f, 0.12073331f, 0.11070473f, 0.07856399f, 0.02785576f, 
    0.15571040f, 0.01027213f, 0.01199196f, 0.11228406f, -0.18711635f, -0.05263671f, 0.09337790f, 0.18793118f, 
    0.18668447f, 0.05046537f, 0.03706271f, 0.09419826f, 0.14776427f, 0.10705010f, 0.02257904f, 0.04484197f, 
    0.04171606f, -0.00673124f, -0.07151183f, 0.18502311f, 0.08493431f, 0.09167685f, 0.00874089f, 0.13633759f, 
    0.03637439f, 0.08458770f, 0.17719917f, -0.07214294f, -0.04618207f, 0.11856489f, -0.11672411f, 0.00565037f, 
    -0.02119946f, 0.21725729f, 0.07851239f, -0.00643376f, 0.03878949f, 0.09929179f, -0.01104981f, 0.13688219f, 
    -0.07919697f, 0.04260375f, 0.07976272f, 0.23356293f, 0.07342128f, 0.03219611f, 0.06401782f, -0.02600361f, 
    -0.01391438f, 0.11302553f, 0.09945428f, 0.02285142f, 0.37448385f, -0.02471545f, -0.04446916f, -0.01168039f, 
    0.05763252f, 0.15589432f, 0.00372606f, 0.10104827f, 0.08438836f, -0.06294600f, 0.05310837f, 0.16351482f, 
    0.17980132f, 0.13753630f, -0.10583452f, 0.19765210f, -0.01060511f, -0.03478349f, 0.13847589f, 0.00708818f, 
    0.20996320f, 0.07705858f, 0.05177353f, -0.06754128f, -0.14369224f, 0.13834335f, 0.40403748f, 0.15955117f, 
    0.06666623f, -0.03845846f, -0.04910131f, 0.11877304f, 0.18427801f, 0.12729323f, -0.05620391f, 0.06426179f, 
    -0.01776325f, 0.02335441f, 0.21685961f, -0.05291392f, 0.02403065f, 0.13793734f, -0.05699356f, 0.08696026f, 
    0.04782927f, 0.06092422f, 0.11434956f, 0.08901769f, 0.09397063f, -0.02984767f, -0.03556992f, -0.05993414f, 
    -0.02748162f, 0.14100422f, 0.12314402f, 0.20012821f, 0.09409995f, -0.01079209f, -0.00070255f, 0.01868198f, 
    0.13331094f, 0.03779981f, -0.02658823f, 0.09515413f, 0.05172430f, 0.10115127f, 0.13766521f, 0.02372250f, 
    0.06369708f, 0.13418156f, 0.02621634f, 0.22996037f, -0.01109217f, 0.04538854f, -0.05635322f, -0.05396151f, 
    0.14606775f, 0.03365616f, 0.04734267f, -0.06557816f, 0.04599736f, 0.00955354f, 0.09825065f, 0.15542713f, 
    0.07360028f, 0.02502572f, 0.11701063f, 0.15500295f, 0.06106412f, 0.05757238f, 0.01495511f, 0.04180329f, 
    0.03044551f, 0.17065589f, 0.04547900f, 0.21757632f, 0.09548574f, -0.03338280f, -0.02832798f, -0.08590937f, 
    0.13195664f, 0.00522641f, -0.06268104f, 0.08172925f, 0.08875793f, 0.09468067f, 0.00062960f, 0.16021566f, 
    0.17913042f, 0.02109880f, -0.05517276f, 0.18614802f, 0.03313313f, -0.17381202f, 0.12024142f, 0.16787685f, 
    0.08137147f, 0.16009097f, 0.05271130f, -0.02882998f, 0.08738466f, 0.02509810f, 0.13508648f, 0.13209729f, 
    -0.04326067f, 0.10733216f, 0.13792339f, 0.14357443f, 0.08499936f, 0.05390122f, 0.25045469f, 0.03562632f, 
    0.17628784f, -0.05480728f, 0.06553872f, -0.03597943f, -0.04133097f, -0.03857255f, 0.02884600f, 0.18709166f, 
    0.05497431f, -0.10597809f, -0.04349183f, -0.06716016f, 0.09150827f, -0.02620159f, -0.15936831f, 0.21039921f, 
    0.06343488f, 0.05649950f, 0.09120868f, 0.08475630f, 0.17197804f, 0.08739620f, -0.00725978f, 0.09988756f, 
    -0.22900692f, 0.03116111f, 0.09095924f, -0.02430908f, 0.04001293f, 0.15862183f, -0.07577179f, 0.06544539f, 
    0.02300044f, 0.04540790f, 0.06909002f, 0.10942878f, -0.22304055f, 0.10120910f, 0.09867874f, -0.10417244f, 
    -0.02130945f, 0.09873046f, -0.00325432f, 0.05374105f, 0.05368727f, 0.29648468f, 0.06038240f, 0.09089360f, 
    -0.00537861f, 0.17465927f, 0.25805548f, 0.14877285f, 0.10931165f, 0.07797242f, -0.01894565f, 0.04614340f, 
    0.06144540f, 0.16764916f, -0.00144410f, 0.04085936f, 0.10626657f, -0.02791832f, -0.01559375f, 0.04801982f, 
    0.04075288f, 0.01159845f, -0.01973960f, 0.07064730f, -0.01177870f, 0.13049993f, 0.10536468f, 0.05924270f, 
    -0.09489103f, 0.02570123f, -0.14641981f, -0.04820832f, 0.06432260f, 0.06925894f, 0.02329818f, -0.04168550f, 
    0.07827863f, 0.07104560f, 0.20658623f, 0.01684526f, -0.08060723f, -0.01699735f, 0.12064562f, 0.02180198f, 
    0.05211725f, 0.06987960f, 0.03853549f, -0.02119036f, -0.01649988f, 0.18174572f, 0.05354889f, 0.11587155f, 
    -0.05684820f, 0.07575883f, 0.08647851f, 0.09900823f, 0.04050826f, 0.05257716f, 0.11400733f, 0.11607054f, 
    0.05869881f, 0.06265742f, -0.00048426f, 0.05318033f, 0.10314010f, -0.01942822f, -0.08728079f, 0.03109602f, 
    0.06227178f, -0.01167874f, 0.02853689f, -0.01142972f, 0.04177569f, -0.00671514f, 0.00797846f, 0.06875278f, 
    -0.03390514f, 0.00632908f, 0.01211813f, -0.02157983f, -0.00081593f, -0.02217430f, -0.00399364f, 0.00247236f, 
    0.02470872f, -0.00945391f, -0.03620329f, 0.00760454f, 0.00452095f, -0.03576193f, -0.01461363f, -0.04329959f, 
    0.02061938f, 0.00816213f, 0.01548557f, 0.00470510f, 0.00670972f, -0.02362609f, -0.00994017f, 0.00395847f, 
    -0.04443559f, -0.03757207f, -0.00723787f, -0.01018759f, 0.02001455f, 0.00706813f, -0.02707391f, -0.03439586f, 
    -0.00856956f, 0.00188601f, -0.01995625f, -0.03501519f, -0.02453246f, 0.01347675f, 0.01976404f, -0.00719179f, 
    0.00213005f, 0.01474138f, 0.00269812f, -0.00851030f, -0.00765412f, -0.01837112f, -0.02669313f, 0.00213417f, 
    0.01392627f, 0.01931843f, 0.03296160f, -0.02143725f, 0.00835885f, -0.04092081f, -0.02419436f, -0.01868263f, 
    -0.00893675f, 0.01293514f, -0.03968262f, -0.00607210f, 0.00133660f, -0.02708164f, 0.00647647f, -0.00695807f, 
    -0.03443628f, 0.02587326f, 0.00051084f, 0.02564499f, -0.00587938f, -0.00394552f, 0.01560940f, 0.00871949f, 
    0.01991818f, 0.02292386f, 0.00119684f, 0.02348876f, -0.02362666f, -0.03226751f, -0.03058793f, -0.02643746f, 
    -0.03695278f, -0.01587315f, -0.03313574f, 0.01267833f, -0.02040133f, 0.02155680f, 0.01014436f, -0.00740484f, 
    0.02230433f, 0.01274954f, 0.01779769f, -0.03849023f, -0.02715113f, 0.02352935f, 0.00305350f, 0.01453469f, 
    -0.00029523f, 0.01596028f, -0.03999741f, -0.00258546f, 0.00761716f, 0.01949594f, -0.01948786f, -0.03421652f, 
    -0.00102100f, 0.01329107f, 0.02443287f, -0.03533955f, -0.01675060f, -0.01187585f, -0.02603153f, -0.01112724f, 
    -0.00321796f, -0.01261496f, 0.00109033f, -0.02235013f, -0.01587715f, 0.02082821f, -0.03515217f, -0.03437400f, 
    -0.00338326f, -0.01940418f, -0.03554186f, -0.02185834f, -0.00829982f, 0.02214880f, 0.00218471f, -0.02072069f, 
    -0.03440925f, -0.01096086f, -0.02472387f, 0.02153932f, 0.01253218f, 0.01174806f, 0.02635602f, 0.02287616f, 
    -0.03062410f, -0.03368513f, 0.00123782f, -0.02658427f, -0.01242802f, -0.02517286f, 0.02027201f, -0.00875943f, 
    0.00577238f, -0.01286488f, -0.03292174f, 0.00007755f, -0.03618873f, -0.02675014f, 0.01684307f, 0.00106694f, 
    0.00975687f, -0.02576963f, 0.00653512f, -0.01659894f, -0.02750638f, -0.03176260f, 0.01863183f, 0.01678578f, 
    0.00886635f, 0.00401903f, 0.01039591f, -0.00334574f, 0.00788198f, 0.02480930f, -0.00645501f, -0.03493285f, 
    -0.02478966f, -0.00814004f, 0.02550370f, 0.02086113f, -0.00882568f, -0.00482944f, -0.02419303f, -0.02433502f, 
    -0.00117505f, 0.01248765f, 0.00532682f, -0.04079665f, 0.02436048f, -0.02297240f, 0.02601574f, -0.03226336f, 
    0.01049302f, -0.02240491f, -0.01180700f, 0.00818060f, 0.01388679f, 0.00228426f, 0.01216169f, -0.00491205f, 
    0.01767707f, -0.03623080f, 0.00816056f, -0.02262969f, 0.01796740f, -0.01292719f, -0.03614634f, -0.03459214f, 
    0.00813846f, -0.03266713f, 0.00731868f, -0.02152709f, 0.02103431f, -0.02335832f, 0.01818945f, -0.01378966f, 
    0.01950741f, 0.01318761f, 0.01571443f, 0.02049133f, -0.00676433f, 0.01365958f, -0.02368747f, 0.00162638f, 
    -0.02889400f, 0.01378692f, -0.01552084f, -0.02733553f, -0.02476697f, -0.01456443f, -0.02161955f, 0.01143111f, 
    -0.02224423f, -0.02647440f, -0.04102322f, 0.01687195f, -0.03370469f, 0.01348465f, 0.00919269f, 0.02354399f, 
    0.00202389f, -0.02556558f, 0.00425105f, 0.00342965f, 0.00371249f, -0.00342699f, 0.01839252f, -0.04165856f, 
    0.02644375f, -0.02519777f, -0.02968026f, 0.00255840f, -0.00131291f, -0.04093289f, -0.01687107f, -0.03893142f, 
    -0.00232435f, -0.04479503f, 0.01302784f, -0.02432945f, -0.02727393f, -0.01655331f, 0.01217724f, -0.01198417f, 
    0.00814232f, 0.01301370f, -0.03836414f, -0.00015105f, 0.01263122f, -0.01107798f, 0.00839201f, 0.01715776f, 
    -0.04407933f, -0.04187075f, -0.01093654f, -0.01147489f, -0.04035403f, -0.00953790f, -0.00622332f, -0.00735170f, 
    -0.02982272f, 0.01951141f, 0.01228975f, -0.01358080f, -0.01123821f, -0.03246589f, -0.02070199f, 0.01272381f, 
    0.00427423f, -0.01840478f, -0.02899029f, -0.00457324f, -0.00110515f, -0.01502420f, -0.00231202f, -0.03836811f, 
    0.02623453f, 0.01706802f, 0.01278816f, -0.03703234f, 0.01515372f, -0.01090736f, -0.04155079f, -0.02597545f, 
    -0.01474972f, 0.01428927f, -0.00968812f, 0.00101368f, -0.03582881f, 0.00307933f, 0.02252776f, -0.01438477f, 
    -0.03556444f, -0.03351479f, 0.01612264f, -0.00010799f, -0.01298555f, 0.00584947f, 0.01299425f, -0.02553075f, 
    0.01568167f, -0.02535480f, 0.00637176f, -0.02209801f, 0.01167946f, -0.02009836f, -0.02733251f, -0.01912451f, 
    0.01957099f, -0.03628117f, -0.00540766f, 0.00558630f, -0.03794886f, -0.02672072f, 0.00962183f, -0.03078787f, 
    -0.01754813f, 0.00837227f, 0.01549616f, 0.02026716f, 0.00458474f, 0.01591919f, -0.02110274f, -0.00608805f, 
    -0.04541407f, -0.02446399f, -0.00526051f, 0.02644430f, 0.01317727f, 0.01490375f, 0.02092744f, -0.03008615f, 
    0.00786314f, 0.00658635f, -0.03602158f, -0.03639241f, 0.01565766f, -0.00597250f, -0.00410118f, -0.01925142f, 
    0.00998194f, 0.00666848f, 0.02584892f, -0.02533477f, 0.00302162f, -0.00448635f, -0.02117522f, 0.03739752f, 
    -0.01798069f, 0.00588667f, 0.02658061f, 0.01593935f, -0.03147024f, 0.00434308f, -0.01305746f, 0.01382706f, 
    0.02530915f, -0.04476070f, -0.03778121f, -0.03154232f, -0.01558871f, -0.01037072f, 0.02181380f, 0.02175026f, 
    -0.03172234f, -0.03536847f, -0.00658640f, -0.03062681f, -0.02995113f, 0.01492692f, -0.02831645f, -0.03782988f, 
    -0.02697004f, -0.01670151f, -0.00114935f, -0.03825079f, -0.04375242f, -0.03291938f, -0.01260796f, -0.01863635f, 
    -0.04051275f, 0.02411627f, 0.02594285f, -0.03604603f, 0.00586496f, -0.00316139f, 0.01506392f, -0.02096315f, 
    0.00961650f, -0.01120894f, -0.01536326f, -0.01047377f, -0.00871233f, 0.00490262f, 0.01602007f, 0.02100090f, 
    -0.00987659f, -0.03457328f, -0.02722275f, -0.02326191f, -0.04014657f, 0.02027032f, -0.00681871f, -0.04261304f, 
    0.00827554f, 0.02808548f, -0.04052130f, 0.00920230f, 0.02521196f, -0.02474817f, -0.00000843f, -0.01165863f, 
    -0.01320936f, 0.01895333f, -0.03836168f, 0.01528126f, -0.02546819f, 0.01399855f, 0.00758685f, -0.00826260f, 
    -0.03226642f, -0.00436177f, -0.03532054f, -0.02833325f, -0.01708687f, -0.01113761f, -0.00153230f, -0.04145647f, 
    -0.03062702f, -0.01541484f, 0.02980388f, -0.03067226f, 0.02253168f, 0.01717480f, 0.01738173f, -0.01783651f, 
    0.00461443f, -0.02543092f, -0.01543652f, 0.01511891f, 0.00844765f, 0.02367844f, -0.04360452f, -0.02176918f, 
    -0.01192543f, 0.00310440f, -0.00546530f, 0.02313375f, 0.00465924f, 0.00284511f, -0.02743067f, 0.01288778f, 
    -0.02613845f, -0.00707077f, -0.04133892f, -0.01366098f, 0.01576820f, -0.01016060f, 0.00424334f, -0.04080857f, 
    -0.01295813f, -0.04331804f, 0.02633741f, -0.00432109f, -0.03617994f, 0.01297300f, -0.04064038f, 0.01386783f, 
    0.01497143f, 0.00815145f, 0.02026878f, 0.00009270f, -0.00359363f, 0.02195371f, 0.01939080f, 0.00771664f, 
    -0.02423635f, -0.02240074f, 0.00027693f, -0.00544992f, 0.02334347f, -0.01899283f, 0.00060756f, 0.01555643f, 
    0.00240595f, -0.04325528f, -0.04366890f, -0.03039973f, 0.00886388f, -0.02567100f, -0.01572436f, 0.01518511f, 
    0.01286749f, -0.00354947f, -0.02026715f, 0.01660201f, -0.00224358f, 0.01389283f, -0.01538851f, -0.02770488f, 
    0.01958084f, -0.00151041f, 0.00103477f, -0.04515108f, -0.02811933f, -0.00860128f, 0.00230933f, 0.01619680f, 
    -0.04453567f, 0.00266450f, 0.02388559f, 0.02024936f, -0.00471672f, -0.00249826f, -0.01360481f, -0.04248052f, 
    0.01686510f, 0.01503573f, 0.01837843f, -0.01171173f, -0.03355954f, 0.02219021f, -0.02107047f, -0.01671830f, 
    0.00796777f, 0.00616550f, 0.00618487f, 0.01950072f, -0.00034204f, -0.02302549f, 0.02492687f, 0.02340127f, 
    -0.00802287f, -0.02484069f, 0.00776007f, 0.01128352f, 0.03009028f, -0.02627566f, -0.03539265f, -0.03145795f, 
    -0.01570599f, -0.00407909f, 0.00290245f, -0.00793237f, -0.02146848f, -0.02772735f, -0.00747173f, -0.00007556f, 
    0.02366439f, 0.00781354f, -0.04360444f, 0.02559971f, 0.00273035f, 0.01684580f, 0.00870093f, 0.01360497f, 
    -0.03768122f, 0.02527734f, -0.01685698f, -0.01480252f, 0.00397473f, -0.01869757f, 0.01458682f, 0.01356905f, 
    -0.02816345f, -0.03726470f, -0.02042938f, -0.02605066f, 0.00374721f, 0.01872999f, -0.00450026f, -0.04597698f, 
    -0.02886884f, -0.02262881f, -0.03513147f, 0.01616021f, -0.01550150f, -0.00116334f, 0.02483611f, 0.01834818f, 
    -0.01307922f, -0.03288487f, -0.01927114f, 0.03896294f, 0.00312476f, -0.03868758f, 0.00808545f, 0.00062757f, 
    -0.01376831f, 0.02941155f, -0.00899527f, -0.03928532f, 0.00307376f, -0.01181426f, 0.00979378f, 0.01564695f, 
    -0.03621929f, -0.02558065f, 0.01155231f, -0.02176581f, 0.00479896f, 0.02243203f, 0.01559842f, -0.03124469f, 
    -0.02879859f, 0.01908901f, 0.02084887f, 0.01022062f, -0.03795302f, 0.02470835f, 0.01675134f, -0.03137019f, 
    0.02042679f, -0.03160271f, -0.03013305f, 0.00875299f, -0.01133920f, -0.01435492f, 0.01672793f, -0.02086062f, 
    0.00576535f, -0.03190919f, 0.02730840f, -0.02496846f, -0.02431691f, 0.01765525f, 0.01076998f, 0.02082252f, 
    -0.02359940f, 0.02836095f, -0.01697494f, -0.00910182f, -0.03816849f, -0.00148670f, -0.00349123f, 0.01717987f, 
    -0.02611724f, 0.01685636f, -0.03001782f, -0.01663562f, 0.02957623f, -0.01867993f, -0.00007943f, -0.00560319f, 
    -0.04008087f, 0.02235287f, 0.01945472f, -0.02410318f, 0.02579996f, 0.01013174f, -0.01815603f, -0.02117375f, 
    -0.00989818f, -0.02386026f, 0.02237070f, 0.01217626f, 0.00723014f, 0.01588621f, -0.02825693f, -0.01400521f, 
    -0.00351397f, 0.00546519f, -0.02197382f, 0.02558979f, -0.03088878f, 0.00517296f, 0.00627068f, -0.01938068f, 
    0.00032788f, -0.03291745f, -0.01195418f, 0.01334338f, 0.02249525f, 0.00016607f, -0.01257203f, 0.02967516f, 
    0.02079922f, -0.03321578f, -0.01107180f, -0.00729578f, -0.04369354f, -0.03268073f, -0.02090302f, -0.01454323f, 
    0.01741405f, 0.02447048f, 0.01001478f, 0.00103985f, 0.00157344f, 0.00339759f, -0.03139627f, -0.02011247f, 
    -0.00942965f, -0.03827105f, 0.00971210f, 0.02142739f, 0.00227940f, -0.01283095f, -0.03851517f, 0.00595546f, 
    0.01942001f, 0.02346477f, 0.01523693f, -0.02967602f, -0.01613257f, -0.03265240f, -0.04441194f, -0.00596403f, 
    -0.04382797f, 0.02359417f, 0.00861795f, 0.01790845f, -0.03446991f, -0.02782847f, 0.02035273f, -0.03347886f, 
    -0.01082933f, -0.02099916f, -0.02045388f, -0.03404199f, -0.00696812f, 0.01936036f, 0.02464825f, 0.02047004f, 
    -0.00667554f, -0.01851190f, -0.02698698f, -0.01431938f, -0.00105047f, 0.01162811f, -0.02505261f, -0.02241685f, 
    0.01649146f, 0.00208886f, 0.01156600f, -0.00399016f, 0.00713766f, -0.00121146f, 0.02220057f, -0.00731668f, 
    -0.00805920f, -0.00122508f, -0.02178634f, -0.03342555f, -0.01217898f, -0.04190288f, 0.00585716f, -0.02479087f, 
    -0.01497424f, 0.01785556f, 0.01776193f, -0.00454665f, -0.01558726f, 0.02475094f, 0.00183647f, 0.02679073f, 
    -0.03054352f, -0.00142403f, -0.00317176f, 0.01353637f, -0.01755268f, 0.01311449f, -0.02316688f, -0.02749686f, 
    -0.04173177f, 0.02281759f, -0.04077343f, -0.00351602f, -0.01163825f, 0.01816982f, 0.02006030f, -0.00768502f, 
    -0.03368246f, 0.01554596f, 0.01185992f, -0.04007656f, 0.03572708f, -0.00601547f, 0.02922164f, -0.02110879f, 
    0.00273169f, 0.01009559f, -0.03693664f, 0.01237381f, 0.00963128f, -0.00094541f, 0.01212457f, 0.00739425f, 
    -0.01635639f, -0.02113020f, -0.01282009f, -0.02269555f, 0.03204923f, 0.03708116f, 0.01959469f, 0.02191227f, 
    0.02439737f, -0.02603752f, -0.00128175f, -0.03830317f, -0.00098363f, 0.02201043f, 0.02072635f, -0.01969382f, 
    -0.01094738f, 0.00995889f, -0.03485507f, -0.00478732f, 0.01943260f, -0.03043567f, -0.01794924f, -0.03187140f, 
    0.00467599f, 0.00855166f, -0.03157914f, 0.01607761f, 0.02550769f, -0.02233380f, -0.03373300f, 0.01894254f, 
    0.02916872f, -0.01496814f, -0.00965538f, 0.02377356f, -0.01176127f, 0.02246821f, 0.01111414f, 0.00112007f, 
    -0.01965959f, -0.04056481f, 0.01871433f, -0.00604886f, -0.01782739f, -0.00671387f, -0.01802933f, -0.01035854f, 
    -0.00980318f, -0.03848805f, -0.01232314f, -0.01305460f, -0.03267853f, -0.01928254f, -0.01185306f, -0.00075656f, 
    -0.00827699f, -0.02749523f, 0.01592244f, -0.03660009f, -0.01874061f, 0.01401647f, 0.02080058f, 0.00022579f, 
    0.02814141f, -0.02751231f, 0.02112518f, -0.01014749f, 0.03694469f, 0.01495142f, 0.01602595f, -0.03086337f, 
    -0.01754776f, 0.02128020f, 0.00816800f, 0.03014903f, -0.01397345f, -0.01647848f, -0.01728004f, -0.00755530f, 
    0.02651815f, 0.01808807f, 0.03317435f, -0.01126601f, -0.03762046f, -0.02619988f, 0.00724516f, 0.01512149f, 
    0.00089147f, -0.00854203f, 0.00851296f, -0.02190484f, 0.01175147f, 0.01628828f, 0.00606249f, 0.01009685f, 
    0.01878575f, 0.02110552f, 0.02746576f, 0.00695422f, -0.01726676f, -0.02228757f, -0.00338060f, 0.00598689f, 
    0.02868216f, 0.04081918f, -0.01405459f, 0.01432197f, -0.00065117f, -0.02368739f, -0.01964460f, -0.03819202f, 
    0.02759327f, 0.02483386f, 0.00779237f, -0.03062635f, -0.00317452f, -0.03233951f, -0.03554422f, -0.01454088f, 
    0.01585397f, -0.02814055f, -0.02079371f, -0.03551554f, -0.02320115f, -0.00942218f, 0.00368226f, 0.02897322f, 
    -0.01528481f, 0.02957005f, 0.03079480f, 0.03629958f, 0.02861520f, 0.02786679f, 0.02037234f, -0.03066301f, 
    -0.00284068f, 0.00782492f, -0.01138362f, -0.01959893f, -0.04206536f, 0.01482501f, 0.01100071f, -0.00421525f, 
    -0.00549830f, -0.00215998f, 0.01187832f, -0.03370582f, 0.00998264f, -0.00495330f, -0.00948549f, -0.00387139f, 
    -0.00402499f, -0.02021749f, -0.03146556f, 0.02111617f, -0.00143243f, 0.00831694f, 0.00527393f, 0.02133296f, 
    -0.03224179f, -0.01752628f, -0.03306350f, -0.04018642f, -0.03091029f, -0.00309330f, -0.01525247f, -0.00326802f, 
    0.00091209f, -0.01483123f, -0.03805909f, 0.02856152f, 0.01817687f, -0.01591352f, 0.02481256f, -0.00162090f, 
    0.02552685f, 0.02344848f, -0.01940861f, 0.01553621f, -0.03023418f, -0.02108374f, -0.00197604f, -0.01906961f, 
    0.02858536f, 0.00188049f, -0.03097506f, 0.03310716f, -0.02314039f, 0.00935959f, 0.01030591f, -0.03007221f, 
    -0.00215406f, -0.03996414f, -0.00580024f, 0.01254302f, 0.04197624f, -0.03842179f, 0.01826965f, -0.02235051f, 
    -0.01777322f, 0.01463318f, -0.01433031f, -0.00483059f, 0.00440284f, 0.02743567f, -0.03339934f, -0.01140697f, 
    -0.04007441f, -0.03941613f, -0.02440162f, 0.00162170f, 0.03651594f, -0.01601088f, -0.00359130f, 0.02069498f, 
    -0.00946476f, -0.01526168f, -0.02708085f, 0.01736803f, -0.00919223f, 0.01794428f, 0.03488012f, 0.01011483f, 
    -0.00027494f, -0.02492479f, 0.01406907f, -0.01878715f, -0.01099445f, 0.02659739f, -0.00719708f, -0.01090025f, 
    0.00806259f, -0.02778469f, 0.02385633f, 0.02786154f, -0.03118358f, 0.00876827f, -0.02408307f, -0.01239112f, 
    -0.00830261f, 0.02528245f, 0.01574709f, -0.03065932f, 0.04151466f, 0.02846610f, 0.01812469f, 0.00799248f, 
    -0.02683656f, -0.00503497f, -0.01137635f, -0.03306037f, -0.01027088f, 0.01551037f, -0.00533501f, 0.02537442f, 
    0.02851216f, 0.00442193f, 0.00958174f, -0.02949676f, -0.03958749f, 0.00675177f, 0.01142118f, -0.02457579f, 
    -0.01819437f, -0.01573037f, -0.00617772f, -0.01069465f, -0.03858660f, 0.02817196f, 0.02644871f, -0.02944421f, 
    0.00871518f, -0.02664458f, -0.00706863f, -0.00759283f, -0.03561736f, 0.03071963f, 0.01151928f, -0.02658808f, 
    0.01246376f, -0.03958287f, 0.01192276f, 0.02772809f, -0.03229244f, -0.03800792f, -0.03378814f, -0.01545198f, 
    -0.00810970f, 0.03088375f, -0.02821561f, -0.00422161f, -0.00520913f, 0.00147016f, 0.03607171f, 0.00632422f, 
    -0.01098967f, -0.00093556f, -0.02828520f, -0.00211226f, 0.02109987f, -0.00490747f, 0.01097733f, -0.00543853f, 
    -0.00171357f, -0.00745844f, 0.03493637f, -0.03569049f, -0.03538898f, -0.02327375f, -0.04084360f, -0.01240477f, 
    -0.00156758f, 0.02166899f, -0.03184756f, 0.02950939f, -0.01935720f, -0.00177507f, 0.01245776f, 0.03517390f, 
    -0.00003092f, -0.03473641f, 0.02501398f, -0.01621855f, -0.00046600f, -0.00108074f, 0.01548145f, -0.00515671f, 
    -0.04133578f, -0.02677667f, -0.01413742f, -0.00529718f, 0.00568919f, -0.01072186f, -0.00924069f, 0.01782479f, 
    -0.02334627f, 0.00530147f, -0.03396112f, 0.01662875f, 0.00850977f, 0.03115903f, 0.03299895f, -0.02338430f, 
    0.01276817f, -0.01755705f, -0.01646853f, -0.02082462f, -0.02084740f, 0.01234598f, -0.02586247f, -0.00794834f, 
    -0.01073324f, 0.02586300f, -0.01156630f, 0.00095271f, 0.00302879f, 0.02231625f, -0.03329576f, -0.03767806f, 
    -0.00240382f, -0.02542617f, 0.03165200f, -0.02129941f, -0.02961015f, 0.01235724f, 0.02656367f, 0.02585696f, 
    -0.01314559f, 0.01949947f, -0.02640058f, -0.00791653f, -0.02866710f, -0.01189952f, -0.02215347f, 0.00175356f, 
    0.01270116f, -0.03016128f, -0.01756999f, -0.00207124f, -0.02544424f, -0.00355616f, -0.00973071f, 0.01085753f, 
    0.01549925f, -0.00127916f, 0.01488579f, -0.03026846f, 0.00980767f, -0.01115709f, -0.03214995f, -0.01214785f, 
    0.01332636f, 0.00731207f, -0.03945322f, -0.03575413f, 0.01188382f, 0.00741234f, -0.03141171f, -0.01026447f, 
    0.00890521f, 0.02022577f, -0.01265082f, -0.00365910f, 0.00342236f, -0.02075165f, -0.00174530f, 0.00682675f, 
    0.03212767f, -0.00409059f, -0.00388700f, 0.01638642f, 0.00033651f, 0.02049872f, 0.00120869f, 0.01527910f, 
    -0.01876398f, 0.01471815f, 0.00804267f, -0.00662622f, 0.01818971f, 0.00837448f, -0.02226542f, -0.00790711f, 
    -0.00762156f, -0.02840085f, -0.01010454f, 0.02152338f, -0.03471876f, -0.04014929f, 0.00419672f, 0.00571246f, 
    -0.02533615f, -0.01544357f, 0.02392321f, -0.00899947f, 0.00524696f, -0.02493032f, -0.01948234f, 0.03993069f, 
    -0.00651305f, -0.00204995f, 0.01325323f, -0.03270865f, -0.04012308f, 0.02188609f, -0.03709383f, -0.02569598f, 
    0.02986706f, -0.01103888f, -0.04193155f, -0.03369392f, -0.01568480f, -0.01160502f, -0.01274679f, 0.00302927f, 
    -0.00049052f, 0.03796731f, -0.01695566f, 0.02545963f, -0.01232617f, 0.02700333f, 0.00274642f, -0.02443644f, 
    0.00645120f, 0.01319170f, 0.02529328f, -0.00148938f, 0.01208789f, -0.01327091f, -0.03471403f, 0.00410024f, 
    -0.02195960f, -0.00474883f, -0.01661772f, 0.01183657f, -0.03717375f, -0.02595988f, -0.02110461f, -0.04007233f, 
    0.02993059f, 0.02679430f, 0.01132714f, -0.00698365f, 0.00130742f, -0.01104766f, 0.00506151f, 0.01584242f, 
    0.02336557f, 0.02435865f, -0.02433593f, -0.04111728f, -0.03491647f, 0.02225707f, -0.00058381f, 0.01248098f, 
    0.00515000f, -0.03961330f, 0.00864834f, 0.01019573f, 0.01165911f, -0.01593801f, -0.03878183f, -0.01405763f, 
    -0.00360814f, -0.01393992f, -0.00970426f, -0.03789589f, -0.02846448f, 0.00302116f, -0.03800764f, 0.02876853f, 
    0.01516351f, -0.01208899f, 0.02009714f, -0.01087266f, 0.01098272f, 0.02433185f, 0.00253483f, -0.02056551f, 
    -0.00930522f, -0.03592260f, -0.02237957f, -0.02573802f, 0.02588085f, 0.01061205f, -0.04101738f, 0.01525039f, 
    -0.01970631f, 0.02484698f, 0.02384858f, 0.03020849f, 0.02488464f, 0.00892283f, -0.00265357f, -0.01126435f, 
    0.01344354f, 0.02534551f, -0.00751881f, -0.01169580f, -0.00035978f, -0.04077352f, -0.01995399f, -0.03667326f, 
    -0.01320533f, -0.01864517f, -0.04032398f, -0.04144727f, -0.02938209f, 0.01057193f, -0.00014814f, -0.03927468f, 
    -0.00901167f, 0.02778308f, -0.01195364f, 0.01517226f, -0.00641837f, 0.00092745f, -0.01735818f, 0.01410133f, 
    0.01804202f, -0.04079699f, 0.02574968f, -0.00924636f, 0.02240337f, 0.02207522f, 0.00912741f, 0.02839450f, 
    -0.01277256f, -0.00796489f, 0.01872722f, -0.01026332f, 0.01322119f, 0.01310054f, 0.02556712f, 0.00026518f, 
    -0.02206489f, 0.02660710f, 0.02377453f, -0.00830866f, -0.00531097f, 0.00960905f, -0.03770513f, 0.00112972f, 
    0.02970978f, -0.02089679f, -0.02307521f, 0.00825363f, -0.01926688f, 0.01584396f, -0.01872907f, -0.00569591f, 
    0.01287287f, -0.02159317f, -0.01184158f, -0.03932795f, -0.00383349f, -0.02576493f, 0.01427288f, 0.01464534f, 
    -0.03518303f, -0.00146009f, 0.01071967f, -0.03799623f, 0.02539184f, -0.01640035f, -0.03490467f, -0.03137038f, 
    0.02187350f, 0.00828401f, -0.00333681f, -0.01993647f, 0.01326976f, -0.00218515f, -0.00438950f, -0.00077005f, 
    0.00178929f, 0.00200920f, -0.02529271f, -0.00805167f, -0.01834223f, 0.03825490f, -0.03214178f, -0.03504033f, 
    -0.01886908f, 0.02918110f, 0.01452142f, -0.00400454f, 0.02601098f, -0.02129899f, 0.01815469f, -0.02525482f, 
    0.01744960f, -0.00690081f, 0.02767697f, -0.02077685f, -0.00906062f, 0.03712683f, -0.00974980f, 0.02716545f, 
    0.01290635f, 0.00183245f, 0.00742553f, 0.00133192f, 0.00963909f, 0.00577300f, -0.03122631f, 0.01467472f, 
    0.01528516f, -0.01405319f, -0.01025371f, -0.00198011f, -0.02357495f, 0.01507976f, -0.00036013f, -0.00485453f, 
    0.01303239f, -0.01512772f, -0.00377934f, 0.01776311f, -0.00147873f, 0.02899991f, -0.01510906f, -0.01301211f, 
    0.02402183f, -0.03877624f, 0.01792937f, 0.02157770f, 0.02340202f, -0.01796625f, -0.00190411f, 0.02650283f, 
    -0.01804670f, 0.01360808f, -0.03782642f, -0.01505496f, -0.01106254f, -0.01829173f, -0.01024139f, 0.02684114f, 
    0.00693799f, 0.02718498f, -0.02046513f, 0.03953371f, 0.01348685f, 0.01518639f, -0.03107003f, -0.01041823f, 
    -0.00723293f, -0.00858529f, 0.02560539f, 0.02889820f, 0.01507153f, -0.01855529f, -0.00953620f, -0.02814325f, 
    -0.00685162f, -0.00070517f, -0.01811169f, -0.03760693f, -0.03888023f, 0.02882498f, 0.02296651f, -0.03429295f, 
    -0.03588628f, -0.01285322f, 0.00891128f, -0.00324502f, -0.03842643f, 0.01577021f, 0.01811177f, -0.00850169f, 
    0.00255815f, 0.02851110f, 0.01162816f, 0.00289169f, 0.02694757f, 0.03474526f, 0.00776757f, -0.02049277f, 
    0.00277507f, 0.02197936f, -0.04123110f, -0.02242850f, -0.00790969f, 0.00757902f, -0.01911994f, -0.03894120f, 
    0.00945673f, 0.02922622f, -0.03708765f, 0.00324536f, 0.02112347f, -0.00463051f, 0.01010436f, 0.01016063f, 
    0.01279356f, 0.01537995f, 0.01769178f, -0.03188430f, 0.01351732f, -0.01709243f, 0.00865251f, 0.00369231f, 
    -0.00493337f, -0.02839568f, -0.04022367f, 0.02770760f, -0.03661123f, -0.01224178f, 0.01336234f, -0.00861945f, 
    -0.00616894f, -0.00835584f, 0.02763066f, 0.01691042f, 0.03140159f, -0.03331698f, 0.01098378f, -0.04272461f, 
    -0.00142695f, -0.01989955f, 0.01562177f, -0.02694151f, -0.01895578f, -0.00392183f, -0.01140073f, 0.02623181f, 
    -0.01772195f, 0.02590856f, -0.02771683f, 0.02364684f, -0.04260435f, 0.02518956f, -0.01096770f, 0.00517793f, 
    0.02782958f, -0.00385499f, -0.01116042f, 0.01825526f, 0.02109019f, 0.02028508f, 0.00503062f, -0.03882128f, 
    -0.02651776f, -0.01576101f, 0.02629394f, 0.02168057f, -0.00303590f, 0.01211890f, 0.01234461f, -0.02375340f, 
    -0.00747414f, 0.00940930f, 0.00886205f, 0.00246383f, 0.01020651f, 0.01204320f, -0.03977659f, 0.01925925f, 
    0.02083469f, -0.03049634f, -0.02591229f, -0.01174926f, 0.02332149f, 0.00546077f, 0.00923761f, 0.02625920f, 
    -0.02327360f, -0.02301511f, 0.01659072f, -0.01001074f, -0.03094605f, 0.00766225f, 0.01856434f, 0.00392919f, 
    -0.02105042f, 0.01167383f, -0.02591003f, -0.02427174f, -0.00601139f, 0.00410910f, -0.04160735f, -0.00574873f, 
    -0.00290311f, -0.02176291f, -0.01109208f, -0.01637517f, 0.01834198f, 0.01127834f, -0.04420602f, -0.00741621f, 
    0.00382299f, -0.01761585f, -0.00172900f, -0.01362373f, 0.00430262f, 0.00753077f, 0.02051363f, -0.04015141f, 
    -0.00846636f, 0.02174172f, -0.01831486f, -0.00871583f, 0.00718654f, 0.02223744f, 0.02416456f, -0.04173649f, 
    0.02021152f, 0.00015346f, -0.00208699f, -0.00025305f, 0.00793199f, -0.02522023f, -0.03025954f, -0.00542306f, 
    -0.00470992f, 0.00969958f, -0.03684568f, 0.02744565f, 0.01012038f, -0.01885397f, -0.01112089f, -0.03010819f, 
    0.01204778f, -0.00647414f, 0.02736406f, 0.00982181f, 0.02465085f, -0.00974237f, -0.03802469f, 0.02716160f, 
    0.00130514f, -0.02952643f, -0.01723866f, -0.03160547f, -0.00771276f, -0.04311122f, 0.00361921f, -0.02878503f, 
    -0.01728108f, -0.00614408f, 0.01653251f, -0.01711478f, 0.02734200f, 0.01294181f, 0.00656738f, -0.04106741f, 
    0.01034742f, 0.01845626f, -0.00409449f, -0.01419531f, -0.01826264f, -0.01176881f, 0.01469849f, -0.00804036f, 
    -0.02943727f, -0.01416422f, 0.00817641f, -0.02943097f, -0.02010960f, -0.02574559f, 0.01438292f, 0.01374515f, 
    -0.02772974f, 0.00395996f, -0.02939762f, -0.02714410f, -0.03110423f, -0.03736520f, 0.01227205f, -0.01849442f, 
    -0.00162009f, -0.03543866f, 0.00508021f, -0.00680388f, -0.01784544f, -0.03958108f, -0.00136893f, -0.00330784f, 
    0.01147697f, 0.00094005f, 0.00209631f, 0.01899000f, 0.00196248f, -0.02260045f, -0.00719617f, -0.01716782f, 
    0.00942182f, -0.00956600f, 0.01700332f, 0.01725733f, -0.00820987f, -0.03474408f, 0.01155936f, -0.02292579f, 
    0.01677593f, -0.01756658f, -0.02918624f, 0.02330728f, 0.01819104f, -0.00541388f, -0.00520532f, -0.00598357f, 
    -0.01253630f, -0.01912269f, -0.02031321f, -0.03526442f, 0.02468603f, 0.00077953f, -0.01091918f, 0.00765016f, 
    0.02310294f, 0.02242278f, 0.00625236f, -0.01160570f, 0.00223619f, 0.00475466f, -0.02598980f, -0.02389358f, 
    -0.00396544f, 0.02152798f, -0.03834078f, -0.01170118f, 0.02265799f, 0.02523342f, 0.02685249f, -0.02845747f, 
    -0.00976876f, -0.02587540f, 0.00584600f, -0.02895345f, 0.00066902f, -0.04052662f, -0.01062489f, -0.00455872f, 
    0.02649040f, 0.01177144f, -0.00140166f, 0.02170200f, 0.00794997f, -0.00510115f, 0.00318033f, -0.04135075f, 
    -0.00637843f, -0.04387226f, -0.04166368f, -0.01032525f, -0.00941161f, 0.00929144f, 0.01405476f, 0.00412762f, 
    0.00485922f, 0.03311130f, 0.02963691f, -0.04323487f, -0.00083189f, 0.00724016f, -0.02731629f, 0.00895155f, 
    -0.01796466f, -0.03621118f, -0.03769354f, -0.02902081f, 0.00977929f, 0.02526975f, -0.04125346f, 0.02255974f, 
    -0.00201451f, -0.03018635f, -0.02120693f, -0.04163589f, 0.01907536f, 0.00117140f, 0.02889610f, -0.02398149f, 
    0.01900695f, -0.02929970f, 0.02135959f, -0.00494209f, -0.00242655f, 0.02430963f, -0.03277906f, -0.00951738f, 
    -0.03674658f, 0.00786136f, 0.03004385f, -0.02107065f, 0.00716990f, -0.00132930f, -0.04082854f, 0.00024955f, 
    0.00698371f, -0.03497696f, 0.02490520f, -0.04195775f, -0.00276584f, -0.03359582f, 0.01058156f, 0.00304934f, 
    -0.01890416f, -0.02681535f, -0.00220204f, -0.01420613f, 0.01354774f, -0.03533869f, -0.03736503f, 0.02125067f, 
    0.00239783f, -0.04320798f, -0.01562569f, 0.02279639f, 0.01289912f, 0.00669297f, 0.00204850f, -0.02365928f, 
    -0.04384261f, -0.00666266f, -0.00451904f, 0.02043032f, 0.00216091f, -0.01893415f, 0.01237060f, -0.02656218f, 
    0.02383720f, -0.02977183f, -0.02069770f, -0.00963127f, -0.02483147f, -0.04121849f, 0.01411166f, -0.00274768f, 
    -0.01320766f, 0.02258702f, 0.02168180f, -0.01715734f, 0.00212539f, 0.02241737f, -0.02038267f, 0.02695023f, 
    0.01237143f, -0.01085870f, -0.03013444f, -0.03817435f, -0.01997343f, -0.02004403f, -0.00252599f, 0.00260132f, 
    0.01850911f, -0.03876523f, -0.00540135f, 0.02682952f, -0.03050776f, -0.02691105f, -0.03157458f, -0.03718895f, 
    -0.00675057f, -0.04114610f, 0.01566751f, -0.03919458f, -0.01969497f, 0.01780112f, 0.00860487f, -0.04000830f, 
    -0.01289544f, -0.03698261f, 0.01197131f, 0.01640406f, -0.03070209f, -0.01188661f, -0.03562288f, -0.02143686f, 
    0.02337234f, 0.00696784f, -0.00103704f, -0.03145453f, 0.02683742f, 0.01029888f, 0.01708585f, -0.00897632f, 
    -0.00668463f, -0.04277815f, 0.01279904f, -0.03443606f, 0.00488225f, 0.01751625f, 0.01842702f, -0.00033415f, 
    -0.01559290f, 0.01747568f, 0.00349703f, -0.03861178f, 0.00488385f, -0.00984780f, -0.02301350f, -0.03454232f, 
    0.01093987f, -0.02043405f, -0.02890759f, -0.01117568f, -0.03578056f, 0.01850269f, -0.03505513f, -0.02197577f, 
    -0.02627935f, -0.01508136f, 0.02384489f, 0.02731763f, -0.01164069f, -0.01388947f, -0.04053232f, -0.02113234f, 
    -0.02850476f, -0.01535478f, -0.03088769f, 0.00682422f, 0.00273761f, -0.02340371f, -0.02970605f, 0.02515758f, 
    -0.04241884f, 0.01415311f, 0.01649380f, -0.03278696f, -0.00646495f, 0.01590572f, 0.02610219f, -0.00442856f, 
    0.02268681f, -0.03995623f, 0.02238207f, 0.01144449f, -0.00087517f, -0.03660236f, 0.00689257f, -0.03930520f, 
    -0.03906577f, -0.02069628f, -0.00977268f, -0.02215406f, -0.01961391f, -0.04383171f, -0.03408112f, 0.00415656f, 
    0.00599413f, -0.03995132f, -0.01250550f, -0.01690678f, -0.02739068f, -0.04082300f, -0.00832112f, 0.02761516f, 
    0.02886272f, -0.02951005f, 0.02465041f, 0.00587845f, -0.02450019f, 0.00375811f, -0.01471620f, -0.01787879f, 
    0.01663719f, -0.00817776f, 0.00056356f, -0.04263269f, 0.01433928f, -0.01608748f, 0.00720686f, -0.03456005f, 
    0.01764889f, 0.02463833f, -0.02263923f, -0.01710793f, -0.03625469f, 0.00119968f, -0.00213719f, -0.02782990f, 
    -0.02556509f, 0.00792094f, -0.03620069f, -0.03862435f, -0.02839928f, 0.00951111f, -0.00105683f, 0.00708879f, 
    -0.04091581f, -0.00157350f, 0.00183687f, -0.00008302f, -0.01407812f, -0.03682934f, -0.00992489f, -0.04199450f, 
    -0.03908193f, -0.00958406f, 0.00253074f, -0.00549303f, -0.02333818f, 0.00191124f, 0.03170045f, -0.01158715f, 
    -0.00830508f, -0.03251435f, -0.03154111f, 0.00954323f, -0.01502175f, 0.00387320f, 0.01446304f, -0.00717403f, 
    0.00560100f, -0.01323491f, 0.01514689f, -0.03780953f, -0.03632197f, 0.00911769f, 0.02484914f, -0.03674550f, 
    0.01774412f, -0.01512147f, -0.03403609f, 0.01283668f, 0.00982270f, -0.03527632f, -0.02666944f, -0.01303036f, 
    -0.02836288f, -0.01999800f, -0.04083439f, 0.01576254f, -0.00352391f, -0.02705817f, 0.00561947f, 0.01679977f, 
    0.02732641f, 0.00929265f, -0.01325112f, -0.02490066f, 0.00059079f, -0.02914714f, 0.01000556f, -0.01600627f, 
    0.01894144f, -0.03362585f, 0.02167930f, -0.01784547f, -0.03852024f, -0.03181137f, -0.04133403f, 0.02520321f, 
    -0.04276599f, -0.00577617f, 0.02057873f, -0.01507010f, -0.01582946f, 0.01465814f, -0.02390074f, 0.00207861f, 
    -0.00086935f, 0.00133073f, -0.02467778f, -0.04138754f, 0.00163970f, 0.01261096f, -0.00718991f, 0.01916246f, 
    -0.03300259f, -0.03289651f, 0.00250805f, -0.01415895f, 0.02751994f, -0.01548691f, -0.00717149f, 0.00903081f, 
    -0.00401200f, 0.01437765f, -0.03879279f, 0.01166687f, -0.02751415f, 0.01030103f, 0.01366979f, 0.02699614f, 
    -0.00775666f, -0.03561208f, -0.02238774f, -0.03108873f, -0.00843262f, -0.04168724f, -0.02601923f, 0.00705556f, 
    -0.01444083f, -0.03114516f, -0.03272190f, 0.00333326f, -0.00114554f, -0.04251690f, -0.01083861f, 0.00599992f, 
    -0.04040958f, -0.01777109f, 0.01941628f, 0.00433058f, -0.00068782f, -0.03899257f, 0.02464874f, -0.00120431f, 
    -0.00179608f, -0.02886326f, -0.02990766f, -0.00389603f, -0.00025464f, 0.00073290f, -0.02232045f, 0.01696554f, 
    0.00760209f, 0.02132578f, -0.00111391f, -0.01185905f, -0.03466437f, 0.02216724f, -0.03683599f, -0.04256228f, 
    0.02330145f, -0.01934253f, -0.02428066f, 0.00462335f, 0.02521881f, -0.03583569f, -0.03882044f, -0.01547092f, 
    -0.03455858f, -0.02189333f, -0.04381067f, 0.02418382f, -0.03265217f, -0.00453971f, -0.00197810f, 0.02250689f, 
    -0.02545317f, -0.02804297f, -0.00025813f, -0.00228139f, -0.03241028f, 0.01487736f, -0.00801045f, -0.04366260f, 
    -0.02492316f, 0.01572164f, 0.01349247f, -0.02611083f, -0.02136915f, 0.02385273f, 0.02034867f, -0.01457254f, 
    0.00022892f, 0.00941668f, -0.00912827f, -0.01654793f, -0.02926551f, -0.01833442f, 0.01612149f, -0.02519699f, 
    0.01715832f, -0.01491802f, 0.00632709f, -0.02128396f, -0.01319227f, 0.01180729f, -0.01991167f, 0.01659417f, 
    0.01736861f, -0.00498494f, -0.02675087f, 0.01935474f, 0.00280948f, -0.00232887f, -0.02482554f, -0.02141034f, 
    -0.03335306f, 0.00682091f, 0.02399326f, 0.01913215f, 0.01684971f, -0.03290280f, -0.02534794f, -0.01358244f, 
    -0.03706939f, 0.01031217f, 0.01043635f, -0.03217488f, 0.02474935f, 0.02212638f, -0.00854399f, -0.01115657f, 
    -0.03075840f, 0.00178831f, -0.01797059f, 0.00894441f, 0.02472357f, -0.01441393f, -0.02465816f, -0.02189263f, 
    -0.00590338f, -0.00312932f, 0.02578399f, -0.04336726f, 0.01196635f, -0.01750458f, -0.00479176f, 0.00238254f, 
    -0.00823084f, 0.00814562f, 0.02659325f, 0.00430858f, 0.01275992f, 0.01912663f, 0.01451059f, -0.02873850f, 
    0.00667511f, 0.01378412f, -0.04278997f, -0.03978467f, -0.00574608f, -0.01174062f, -0.04082990f, 0.00727587f, 
    0.01220049f, 0.01123019f, -0.03965292f, 0.01149989f, -0.03508964f, -0.01017026f, -0.02286313f, 0.02639857f, 
    -0.00008201f, 0.01108601f, -0.01857160f, 0.00494146f, -0.01728366f, -0.00572148f, 0.02181514f, 0.02226466f, 
    -0.00568701f, 0.00809475f, 0.02019181f, 0.00949394f, -0.00983559f, -0.02012034f, -0.03483076f, 0.00902817f, 
    0.02570231f, -0.02405944f, -0.03642396f, 0.02477796f, 0.01587936f, -0.03184452f, -0.02797853f, 0.00809953f, 
    -0.03201962f, -0.02748114f, -0.00564838f, -0.04214135f, -0.00393434f, -0.00890333f, 0.00601267f, -0.03881231f, 
    -0.01355567f, 0.03116401f, 0.01306902f, 0.01832251f, 0.01694705f, 0.00610206f, 0.03044297f, 0.00430796f, 
    -0.02710477f, -0.01512285f, -0.04111556f, 0.03182200f, -0.00695686f, 0.02165557f, -0.02629301f, 0.00045002f, 
    -0.02902793f, -0.00111838f, 0.02787753f, 0.00401562f, 0.02470315f, 0.01596249f, 0.02232671f, -0.00724874f, 
    -0.03916348f, 0.00786501f, 0.00501958f, 0.02970184f, -0.01855167f, 0.02371284f, -0.04030818f, -0.00147547f, 
    -0.00336284f, 0.01841920f, -0.01816252f, -0.03546931f, 0.01575478f, -0.01698665f, 0.02226318f, -0.00515630f, 
    -0.00036220f, 0.02528578f, -0.01982500f, -0.04130867f, -0.03761376f, -0.03820901f, 0.00290928f, 0.02551703f, 
    -0.03002997f, 0.00145507f, -0.01132597f, 0.01134781f, 0.02926956f, 0.02772532f, 0.02174502f, -0.00557662f, 
    0.00836014f, 0.00649568f, -0.02465072f, -0.03999962f, -0.01696135f, -0.00440497f, 0.00674348f, -0.00730342f, 
    0.00619545f, -0.03112253f, -0.01445682f, -0.00739029f, 0.00136335f, -0.00825451f, -0.03196700f, -0.01990627f, 
    0.00309384f, -0.00617581f, 0.00154015f, -0.00822005f, -0.02392601f, 0.00423877f, 0.02649280f, 0.01107115f, 
    -0.00728555f, -0.02313513f, -0.03936079f, 0.02809194f, -0.02690896f, -0.02984359f, -0.04034650f, -0.03353936f, 
    0.02354447f, 0.01788672f, -0.04069797f, -0.01792860f, -0.03481330f, 0.02909033f, -0.03825181f, 0.01404139f, 
    0.00309136f, -0.03415338f, 0.01090102f, 0.02517936f, -0.00128493f, -0.02499381f, -0.00901675f, -0.03365184f, 
    -0.00231230f, 0.01826398f, 0.01037533f, -0.01683463f, -0.02524108f, -0.02169245f, 0.00666868f, 0.01740005f, 
    -0.02370093f, 0.00520265f, -0.03952062f, 0.01085312f, -0.03655782f, 0.02351474f, -0.02494356f, -0.02231370f, 
    -0.02467920f, 0.02008275f, -0.00261999f, 0.00787965f, 0.00546540f, -0.01153982f, 0.02703126f, -0.03265350f, 
    0.00288353f, -0.03337588f, 0.02549473f, 0.00480484f, 0.00351948f, 0.01767473f, -0.02141550f, -0.00977442f, 
    -0.00956833f, -0.02474580f, -0.04072008f, -0.02471177f, 0.02643440f, 0.01777165f, -0.02416469f, -0.02786761f, 
    -0.00231954f, -0.03318347f, 0.00162399f, -0.01606279f, -0.01226045f, 0.02166248f, -0.01023594f, 0.01082440f, 
    0.00326185f, -0.00563006f, -0.01280634f, -0.03028156f, -0.03523940f, -0.00608685f, 0.00108173f, 0.02010018f, 
    -0.01387576f, -0.02219302f, 0.00073137f, 0.02362427f, -0.01078271f, -0.01913367f, -0.02631840f, 0.02532910f, 
    -0.01763504f, -0.01747969f, -0.02297473f, -0.01541172f, 0.02820622f, -0.01875190f, -0.03418368f, -0.00364978f, 
    0.01259068f, -0.00030061f, 0.01155580f, -0.01289454f, 0.00902699f, -0.02090143f, 0.02302047f, -0.02456925f, 
    0.01930174f, -0.00019382f, 0.00486999f, -0.01821254f, -0.00652590f, 0.00975066f, -0.02155688f, -0.02166003f, 
    -0.00478520f, 0.01945405f, 0.02759064f, -0.03000039f, -0.01407889f, 0.00987670f, -0.00069416f, -0.03421222f, 
    0.00498104f, 0.02711099f, 0.00005991f, -0.02289904f, -0.00453669f, -0.04061309f, -0.01643871f, 0.00548437f, 
    0.03003995f, -0.03041565f, 0.02643333f, -0.03149581f, -0.03382095f, 0.00501593f, -0.00660427f, -0.02698523f, 
    0.01407275f, -0.02338768f, -0.01323782f, -0.02535631f, 0.00245113f, -0.00759307f, -0.00542532f, 0.02747329f, 
    -0.03834164f, 0.01902788f, 0.01818497f, -0.03608075f, -0.02427764f, -0.02429624f, -0.04132124f, 0.00723410f, 
    -0.01976985f, -0.01890537f, 0.02706141f, -0.00485013f, -0.03047322f, 0.01874016f, -0.01406329f, -0.02133760f, 
    0.00848862f, 0.01140608f, -0.03239361f, 0.01720178f, -0.02601334f, -0.02709900f, 0.01654311f, 0.01686437f, 
    -0.00290701f, 0.02652935f, 0.01090901f, -0.01631097f, 0.02399589f, 0.01706063f, -0.01547875f, 0.02257796f, 
    -0.02339776f, -0.03213343f, 0.01278169f, -0.00924120f, 0.02580201f, -0.02964055f, 0.00915297f, 0.02299882f, 
    0.00770215f, 0.01971805f, 0.01105056f, -0.04069085f, 0.01616662f, -0.02943228f, 0.02294606f, -0.03030859f, 
    -0.00217977f, 0.00529580f, 0.01136260f, -0.00796500f, -0.03635255f, -0.01968426f, -0.02104721f, 0.01061839f, 
    -0.01018063f, -0.04121160f, 0.00338799f, -0.02374132f, 0.02740991f, -0.01298572f, 0.02288417f, 0.02925814f, 
    0.01016566f, 0.00774961f, 0.00050740f, -0.00408569f, -0.01544667f, 0.01202167f, 0.01669789f, -0.03047491f, 
    -0.02035337f, 0.01281620f, -0.01405821f, -0.01078443f, -0.01982346f, 0.00077142f, -0.03685233f, 0.00766943f, 
    0.00552027f, -0.03374029f, -0.03870973f, -0.01528426f, 0.01585150f, -0.02258450f, 0.01489604f, -0.02005267f, 
    -0.01059764f, 0.02167960f, 0.02099475f, -0.02194073f, 0.00150175f, 0.00478628f, -0.01026577f, -0.00158083f, 
    0.01325818f, 0.01308074f, -0.01622007f, -0.00162714f, -0.01878163f, -0.00825292f, 0.01010608f, -0.02835154f, 
    0.01994067f, -0.03077363f, -0.03825629f, -0.04105196f, 0.00144809f, 0.00595265f, -0.00291494f, -0.03179011f, 
    -0.02433765f, -0.00422630f, -0.01498637f, 0.00119483f, 0.00561018f, -0.03132146f, -0.03091131f, -0.02226086f, 
    0.02490012f, 0.02692319f, -0.02221496f, -0.00762513f, -0.01165327f, -0.02614440f, -0.01166826f, -0.03727045f, 
    0.00861401f, 0.02759116f, 0.02661647f, -0.03568118f, 0.02976140f, -0.03879391f, -0.01696351f, -0.02326012f, 
    0.00755642f, 0.00579480f, 0.00170877f, -0.03476394f, 0.03004033f, -0.01238414f, -0.03658573f, -0.02216210f, 
    -0.02586992f, -0.03947012f, -0.02089732f, -0.02278997f, 0.00131534f, -0.00407838f, -0.03028172f, -0.02098162f, 
    -0.01301269f, -0.00069012f, -0.01241338f, -0.03253777f, -0.02622523f, -0.03510475f, -0.01058731f, -0.03215801f, 
    -0.03173752f, -0.03603130f, 0.00966580f, 0.02181675f, -0.02065529f, -0.03652773f, -0.00966310f, -0.00828691f, 
    0.01750464f, -0.03674630f, -0.02085219f, 0.00482327f, 0.00638179f, -0.01965868f, -0.00729721f, 0.01550278f, 
    -0.02114687f, 0.01043243f, 0.02314737f, -0.01544647f, -0.02620525f, -0.02786906f, -0.02628735f, -0.04046559f, 
    0.00980131f, -0.00947641f, -0.00654105f, 0.00236033f, 0.00571965f, -0.00890663f, -0.03508707f, 0.01494766f, 
    0.02351788f, 0.00427924f, 0.01889773f, -0.00012880f, -0.03383981f, -0.03665712f, -0.00012249f, -0.01245649f, 
    0.00924236f, -0.02665423f, -0.01679658f, -0.03641266f, 0.02113486f, -0.02505689f, -0.01292474f, -0.00512873f, 
    -0.01395472f, -0.00818988f, -0.02808928f, -0.03468597f, 0.02543952f, -0.01048883f, -0.00515229f, -0.00649572f, 
    -0.02338187f, -0.03804370f, -0.00817182f, 0.03023571f, -0.03120327f, 0.00791095f, -0.00147080f, 0.02245973f, 
    -0.03078649f, -0.00564829f, 0.01154551f, 0.02370227f, -0.00682589f, 0.02894396f, -0.02176727f, -0.02644383f, 
    -0.03676327f, 0.02071842f, -0.03302616f, -0.01524787f, -0.00741357f, 0.02347769f, -0.00618832f, 0.01109542f, 
    -0.02137043f, -0.00827502f, -0.03227257f, -0.02054472f, 0.02632094f, -0.02380794f, -0.01118920f, -0.02216762f, 
    0.00096384f, -0.03729789f, 0.02751481f, -0.02128435f, 0.00513275f, -0.02952974f, 0.00560358f, 0.00791558f, 
    0.00657761f, -0.00333380f, 0.01250377f, 0.00418677f, -0.02433035f, -0.01210802f, -0.03421903f, -0.00703825f, 
    0.02758818f, -0.00893765f, -0.02933032f, -0.02842207f, -0.03611249f, 0.00211111f, 0.00261276f, -0.02191846f, 
    -0.02552159f, 0.02839154f, -0.03695092f, 0.02496396f, 0.02264167f, 0.02231917f, 0.00086519f, 0.02700131f, 
    0.02884514f, -0.01732735f, -0.01812763f, -0.03325362f, 0.00937284f, -0.03663059f, 0.00570201f, -0.01482990f, 
    0.00553859f, -0.03767476f, 0.00660033f, -0.03322904f, -0.01386312f, -0.02010852f, -0.00847773f, 0.00674340f, 
    0.02289692f, -0.03230162f, -0.02337740f, 0.02699667f, -0.02559746f, 0.03045016f, -0.00477309f, -0.01096353f, 
    -0.03076941f, 0.02238551f, -0.01099409f, 0.00726103f, 0.01835719f, 0.00882845f, 0.00992752f, -0.02837304f, 
    0.00088526f, -0.02030163f, -0.01139204f, 0.00359014f, 0.01172900f, 0.00214315f, -0.00588769f, -0.03943346f, 
    0.02200645f, -0.00740887f, 0.02883516f, -0.03527034f, 0.00581554f, -0.03742301f, -0.00312702f, 0.01144568f, 
    -0.00650308f, -0.01882976f, 0.00987138f, -0.00467852f, -0.02090004f, -0.01717065f, 0.01471026f, -0.03245931f, 
    -0.02638319f, -0.00449670f, 0.00532667f, -0.01567581f, -0.03685843f, -0.01580413f, -0.00142770f, -0.02952756f, 
    -0.01900358f, -0.02348837f, -0.02693368f, 0.02574902f, -0.01532330f, 0.02853440f, -0.01480340f, -0.01061707f, 
    0.02779205f, 0.02807026f, 0.02509904f, 0.00518601f, 0.02114897f, -0.01439974f, 0.01300835f, -0.03395243f, 
    -0.04135305f, 0.01304432f, -0.00305636f, -0.01654919f, -0.01519165f, -0.03485069f, -0.02155079f, -0.02181355f, 
    0.00329048f, -0.03779571f, -0.02106247f, 0.01051318f, 0.02533023f, -0.02086768f, -0.02198301f, -0.03106501f, 
    -0.04123648f, 0.02802169f, -0.00617076f, 0.02740330f, 0.02247634f, -0.01676743f, -0.01546227f, 0.02507935f, 
    -0.01047470f, 0.02686319f, -0.00143847f, -0.01513114f, 0.02656612f, -0.02949032f, 0.02053702f, 0.02886991f, 
    0.02679205f, -0.02561259f, -0.02282917f, 0.01556526f, -0.02502837f, -0.03811323f, 0.00936048f, 0.02759279f, 
    -0.03535777f, -0.01394179f, 0.01116287f, -0.03957419f, 0.00444536f, 0.00274716f, -0.00399836f, -0.03994716f, 
    0.01252398f, -0.01377764f, -0.01754982f, -0.00899701f, -0.00556692f, -0.02340993f, 0.01863812f, -0.02722273f, 
    -0.02573791f, -0.00700581f, 0.02696920f, -0.03709009f, 0.02246850f, 0.02669614f, -0.03657338f, 0.02888601f, 
    0.00878493f, 0.02076497f, -0.00282261f, 0.02796023f, 0.01952456f, -0.03441252f, 0.02949740f, 0.02597964f, 
    0.00068005f, -0.03650782f, -0.01339985f, 0.00623107f, 0.00160275f, -0.00784248f, -0.02235558f, 0.00460989f, 
    0.00260349f, 0.01978365f, 0.02759351f, -0.02228252f, 0.01952318f, -0.01305592f, 0.02264660f, -0.04152468f, 
    -0.01957255f, -0.02591031f, 0.00758040f, -0.02544929f, 0.00877192f, 0.02139474f, -0.03488354f, -0.02243114f, 
    0.01789674f, 0.01386998f, -0.03587521f, 0.00501741f, -0.01009528f, -0.04105668f, 0.00276424f, -0.00127873f, 
    -0.01159668f, 0.01390866f, 0.01699848f, -0.03028712f, -0.00448975f, -0.00583447f, 0.02283605f, -0.02918488f, 
    -0.01027531f, -0.01781096f, -0.02180640f, -0.02592245f, 0.00641505f, -0.01749423f, -0.04157456f, 0.01629192f, 
    0.00930481f, -0.02011424f, -0.03101227f, -0.01596267f, 0.01142510f, -0.01061105f, -0.01052070f, 0.00555357f, 
    0.02237022f, -0.00334638f, -0.01214120f, 0.02271481f, 0.01461949f, -0.01933700f, 0.01817133f, -0.02489438f, 
    0.01832581f, 0.00058047f, -0.03399244f, -0.01055512f, -0.03377977f, 0.01271581f, -0.01338050f, -0.01340020f, 
    -0.03145930f, 0.00677881f, -0.00553164f, -0.00585547f, -0.01575806f, 0.00984751f, 0.00001701f, 0.00638819f, 
    -0.04027192f, -0.04126635f, 0.01310693f, -0.02589613f, 0.00940985f, 0.01410508f, -0.04128395f, -0.00209960f, 
    0.02154732f, 0.01319405f, -0.01439930f, 0.02240374f, -0.02967510f, -0.03817225f, 0.00090734f, 0.01629312f, 
    0.00794628f, -0.02829245f, -0.03584904f, -0.03133561f, 0.02434662f, 0.02943977f, 0.02317291f, -0.01613993f, 
    -0.02303588f, -0.03638583f, -0.03484161f, -0.03956019f, -0.02934659f, -0.01718034f, 0.00063617f, 0.00344663f, 
    -0.12467255f, -0.09647113f, -0.14954650f, -0.15717652f, 0.08350178f, -0.14230652f, 0.03197758f, -0.06590717f, 
    -0.03814139f, 0.06574545f, -0.03874960f, -0.06717934f, -0.10655645f, -0.23029479f, 0.13673283f, 0.10931039f, 
    0.02546182f, 0.00943461f, 0.03287047f, 0.14724629f, -0.02199350f, 0.02398355f, -0.00623158f, -0.10260879f, 
    -0.33185926f, 0.07528439f, -0.09178817f, 0.03703331f, 0.03911419f, -0.07726130f, -0.09085807f, 0.08764722f, 
    0.02117597f, 0.01505020f, 0.00892116f, -0.01850547f, 0.14608945f, 0.12329073f, -0.00577343f, -0.02408766f, 
    0.03469060f, 0.06607789f, -0.08579230f, 0.00740706f, -0.04369127f, 0.00434123f, 0.03129599f, 0.06411878f, 
    -0.07238837f, 0.05695353f, -0.00454929f, -0.03726030f, 0.01629571f, 0.09568628f, -0.08895650f, -0.08768099f, 
    -0.04419404f, 0.07612459f, 0.05426104f, 0.05129624f, -0.10890647f, -0.09062868f, -0.11781704f, -0.19021350f, 
    0.10948975f, 0.04253028f, 0.03818392f, 0.08862839f, 0.08847076f, -0.03922528f, -0.05522064f, -0.06162477f, 
    0.28099349f, -0.02889559f, -0.11679599f, -0.17515095f, 0.04987030f, 0.07235318f, -0.05609873f, -0.03426583f, 
    -0.02062420f, -0.07496177f, 0.06712844f, -0.03255485f, 0.29160562f, 0.08585615f, 0.05501324f, -0.00018407f, 
    0.05834159f, 0.03444906f, 0.06552507f, 0.08512102f, -0.02148497f, -0.03425259f, -0.08084767f, 0.13731275f, 
    0.11629460f, 0.10896887f, -0.01762122f, -0.02707027f, -0.08006132f, 0.06693150f, 0.08951990f, 0.08545472f, 
    -0.04709745f, -0.05542840f, -0.10586818f, -0.14936951f, 0.10145839f, 0.13940060f, 0.09240148f, 0.19701706f, 
    -0.03806794f, -0.01272722f, 0.00053508f, 0.06223399f, -0.16337097f, 0.02436405f, -0.10227643f, 0.03985918f, 
    0.18593179f, 0.17504966f, 0.04144978f, 0.19538513f, -0.02220551f, 0.00598036f, -0.06043155f, 0.05812693f, 
    -0.10276429f, 0.00490707f, -0.00063084f, 0.04830033f, 0.04796185f, 0.16736789f, 0.09333362f, 0.07116187f, 
    0.04224855f, 0.05754579f, -0.12559505f, 0.02998280f, 0.01625405f, -0.01301265f, 0.09114812f, -0.02646218f, 
    -0.12414858f, -0.06238106f, -0.08630720f, -0.13429859f, 0.04160561f, 0.07233226f, -0.03459932f, -0.03556660f, 
    0.00468338f, -0.07798823f, 0.02957895f, -0.04743518f, -0.17644076f, -0.06627554f, -0.03746501f, -0.09321501f, 
    0.10921593f, 0.00044654f, -0.04688676f, 0.04695683f, -0.09091089f, -0.02438157f, -0.13457379f, -0.08916233f, 
    0.01364644f, -0.12349759f, -0.09849820f, 0.02607571f, 0.11118716f, -0.10564058f, 0.05203094f, -0.01988195f, 
    0.01476994f, 0.00556428f, -0.06879024f, -0.04496476f, -0.09762763f, -0.06659964f, 0.07353146f, -0.09954413f, 
    0.15544781f, -0.06818458f, 0.02550234f, -0.02895759f, -0.04514503f, 0.05017278f, 0.05665622f, -0.04812652f, 
    0.08407807f, 0.06656042f, 0.10038525f, -0.07224733f, 0.00620421f, -0.01592601f, 0.06194539f, -0.04512041f, 
    0.08660780f, 0.07251927f, -0.00182552f, 0.04748399f, -0.08695330f, 0.01114193f, 0.03172823f, 0.01560831f, 
    -0.00018780f, 0.07179546f, -0.09606650f, 0.07607695f, -0.00746523f, -0.08091085f, -0.00778069f, -0.05104839f, 
    -0.02140477f, -0.15933998f, -0.17529666f, -0.04210697f, 0.06003695f, -0.00876408f, -0.04452125f, 0.05250594f, 
    0.06320045f, 0.01735591f, 0.05028958f, 0.09247576f, -0.07318765f, -0.14718077f, -0.02115858f, -0.12605751f, 
    -0.04432058f, 0.08023802f, -0.04672296f, 0.06629129f, -0.01986286f, -0.04763680f, 0.06824803f, -0.07881156f, 
    -0.09212890f, 0.13099438f, 0.01198309f, 0.04490276f, -0.02884255f, 0.07893715f, -0.07546584f, -0.00074558f, 
    -0.02102459f, 0.11296346f, -0.02054590f, -0.00320401f, 0.09451418f, 0.12186635f, 0.01912832f, 0.10861909f, 
    -0.01760223f, 0.05942942f, 0.07578152f, -0.07207292f, -0.05827308f, -0.16206354f, -0.00198679f, 0.06163837f, 
    0.16844258f, -0.02190663f, 0.14894739f, 0.11075404f, 0.08107767f, -0.01101791f, 0.02706803f, 0.14197709f, 
    -0.04405502f, 0.01661880f, -0.02496912f, 0.02296236f, -0.00757296f, 0.19036663f, 0.13879685f, 0.14925365f, 
    0.04636002f, -0.01038956f, -0.05883603f, 0.09674700f, -0.06988202f, -0.02220612f, 0.02050767f, -0.04026034f, 
    0.15876000f, 0.00995358f, 0.08872315f, 0.26311499f, 0.04588153f, -0.05445796f, 0.06426597f, 0.08822917f, 
    -0.02928758f, -0.02180261f, -0.01503437f, 0.02144947f, 0.02124902f, 0.11642763f, 0.00997677f, 0.04699124f, 
    -0.01384735f, -0.11029774f, 0.05477260f, -0.02526631f, -0.09462462f, -0.05058570f, -0.01210778f, -0.09162038f, 
    -0.05138537f, 0.04863516f, -0.17789064f, -0.05777887f, -0.03241154f, -0.01785681f, 0.00908546f, 0.00284815f, 
    0.02526875f, 0.02603093f, -0.03449729f, 0.06650645f, 0.22381443f, 0.11936766f, 0.00320698f, 0.03089252f, 
    0.04164403f, 0.02028901f, 0.14116208f, -0.13115016f, -0.04790568f, -0.01778957f, -0.01335362f, -0.12834731f, 
    -0.22603320f, -0.03029668f, -0.08471044f, -0.08906670f, 0.06013535f, -0.03238079f, 0.03745313f, 0.02716817f, 
    -0.03638263f, 0.07390087f, 0.00958431f, -0.01640187f, 0.20911974f, 0.14806584f, 0.12036319f, 0.05235601f, 
    0.05379782f, 0.00888719f, 0.02833923f, 0.12108130f, -0.01761892f, -0.02300790f, -0.01800054f, -0.09145242f, 
    -0.00543297f, 0.11065752f, -0.07332084f, -0.00996435f, 0.10627913f, -0.00763367f, 0.00674748f, -0.00302988f, 
    0.01477586f, -0.03685175f, 0.03222159f, -0.03963682f, 0.34425974f, 0.17753731f, 0.09247986f, 0.21320558f, 
    -0.07317303f, 0.03483443f, -0.01610262f, 0.02743861f, -0.03267267f, 0.04359408f, 0.03076168f, 0.00232491f, 
    0.25238675f, -0.02138837f, -0.01283331f, -0.06082428f, -0.06183235f, -0.03097560f, -0.03814368f, 0.03408131f, 
    -0.00579247f, 0.04530551f, 0.03048914f, 0.05398871f, 0.15378571f, 0.04298022f, -0.11007398f, -0.04973083f, 
    -0.00099650f, 0.04405497f, 0.01135679f, -0.00397474f, -0.03923393f, -0.01599233f, -0.04935545f, -0.05309613f, 
    -0.03918783f, 0.00265335f, -0.11897016f, -0.12024152f, -0.08210025f, -0.03927290f, -0.00428702f, -0.09669404f, 
    0.03577560f, 0.06248594f, 0.01667653f, -0.08419734f, -0.07474434f, -0.17804217f, -0.12053403f, -0.04587959f, 
    -0.07586173f, 0.03098027f, -0.01707496f, 0.04758804f, -0.08112068f, -0.04883068f, -0.01254899f, 0.04034637f, 
    -0.08284578f, -0.11275849f, -0.03780815f, -0.01977046f, -0.04999414f, -0.04263083f, 0.02369231f, 0.06156365f, 
    -0.06588718f, -0.01500059f, -0.05693159f, -0.04413477f, -0.16368659f, 0.03899142f, -0.11316797f, -0.13890401f, 
    0.00633969f, 0.03593342f, -0.08601858f, 0.09944895f, 0.01542079f, -0.01096626f, -0.04342369f, 0.04332329f, 
    0.14388454f, 0.10494333f, -0.03510342f, 0.24744512f, -0.01350846f, 0.10169565f, -0.00425577f, -0.05435640f, 
    -0.01204198f, 0.03337435f, -0.05276913f, 0.05150079f, 0.39317206f, -0.05528648f, 0.01596226f, 0.03892769f, 
    -0.01150014f, 0.01734450f, 0.11849686f, 0.11772989f, -0.05283980f, -0.07912261f, -0.01929908f, -0.09491290f, 
    0.23275162f, 0.16576281f, 0.15222697f, 0.18051226f, 0.07775612f, 0.01448689f, 0.03054170f, 0.07268720f, 
    -0.04717727f, -0.03744600f, 0.01127229f, -0.04384469f, 0.00162917f, 0.06839025f, -0.01176348f, -0.23255864f, 
    0.07084767f, -0.08596016f, 0.07322574f, 0.00108313f, -0.00635822f, -0.04580099f, 0.00875204f, -0.04943103f, 
    0.13352881f, 0.10578924f, 0.12949777f, 0.13668603f, -0.07652462f, 0.02116618f, 0.03278677f, -0.12294169f, 
    -0.03668076f, -0.01161125f, -0.06734256f, -0.02154611f, -0.07691083f, 0.07373320f, 0.02996499f, 0.23660465f, 
    -0.02204839f, 0.05608713f, -0.09411342f, -0.04105710f, 0.03184491f, 0.00179573f, -0.01431995f, 0.02451593f, 
    0.20187506f, -0.03649349f, 0.08238888f, -0.09974193f, -0.01475933f, 0.12688532f, 0.06958117f, 0.09162975f, 
    -0.05567582f, -0.04419012f, -0.00277801f, 0.03437207f, 0.24070632f, -0.00775811f, -0.32422119f, 0.01384791f, 
    -0.08944015f, -0.07851059f, -0.01914173f, 0.00679001f, -0.22582345f, 0.03850922f, 0.15308994f, -0.03955478f, 
    -0.12338524f, 0.01632753f, -0.17961024f, -0.08253060f, 0.04760144f, 0.00782452f, -0.04318391f, 0.00020562f, 
    0.01018468f, 0.02207658f, 0.05463076f, 0.04787230f, 0.22239023f, 0.25732040f, 0.11068877f, 0.25090623f, 
    0.05640117f, -0.00236701f, 0.08947532f, -0.00822942f, -0.03518877f, 0.07267982f, -0.03300841f, -0.03604191f, 
    0.04251633f, 0.12969865f, -0.03006009f, 0.12268173f, 0.07711083f, 0.09931255f, -0.04595547f, 0.04082142f, 
    -0.08760433f, 0.02400961f, 0.11330137f, -0.02578476f, -0.22176117f, -0.11772533f, -0.14403145f, -0.08088571f, 
    0.05226589f, 0.06904149f, 0.04890371f, -0.01222367f, -0.00954150f, -0.06462994f, -0.06690985f, -0.03844625f, 
    0.04291788f, 0.04826811f, 0.04719429f, -0.07493543f, -0.06723114f, 0.06241490f, -0.03572913f, -0.04906845f, 
    -0.05116739f, -0.01504857f, 0.13840416f, -0.10655311f, -0.02065495f, -0.07036793f, -0.04022973f, -0.00410822f, 
    -0.07142222f, 0.12133843f, -0.02888710f, 0.07058789f, -0.05794564f, 0.07290161f, 0.08792590f, -0.06757418f, 
    0.32005402f, 0.03369772f, 0.00706721f, 0.15058763f, -0.03965956f, 0.05878789f, -0.06382038f, 0.01496552f, 
    -0.08645806f, 0.06203907f, 0.03390535f, -0.04196534f, 0.13420884f, -0.03339985f, -0.03514018f, 0.05207083f, 
    -0.10013420f, 0.06403024f, -0.07726785f, 0.08842847f, -0.05558934f, 0.03761994f, 0.00305719f, -0.19099538f, 
    -0.13304858f, -0.06795740f, -0.03627447f, 0.13716562f, 0.07702996f, 0.03337617f, 0.00173850f, -0.08523856f, 
    -0.04668621f, -0.03697713f, -0.10067395f, 0.06805208f, 0.19812253f, -0.06816444f, -0.13660038f, 0.05271921f, 
    0.06675132f, 0.07279608f, 0.10272083f, 0.12602386f, 0.01267213f, -0.02270539f, 0.00703997f, -0.02813323f, 
    0.04460651f, -0.03457202f, 0.09151508f, -0.06981068f, -0.00658644f, -0.00545834f, -0.05884555f, 0.03067662f, 
    -0.01671097f, 0.02542384f, -0.05941648f, 0.05596596f, -0.00459256f, -0.12164784f, -0.01903564f, -0.17801182f, 
    -0.09943610f, -0.03598198f, -0.04667220f, 0.00130786f, -0.02772611f, 0.06580630f, 0.02548169f, 0.01599086f, 
    0.01903825f, -0.02118925f, -0.12250613f, -0.03557702f, -0.02587214f, -0.07372698f, -0.06967069f, 0.05174185f, 
    0.03583410f, 0.01912303f, -0.05373364f, -0.03702101f, 0.14920603f, -0.11643063f, -0.14724284f, 0.20275177f, 
    -0.00913544f, 0.00557591f, 0.07123402f, -0.03841930f, -0.04192282f, 0.01353520f, 0.10304910f, -0.02554012f, 
    0.01153804f, -0.04350290f, -0.15276791f, -0.20441426f, 0.12949608f, 0.07564817f, -0.10425929f, -0.06324983f, 
    -0.05943064f, 0.01764823f, 0.08858304f, -0.08811038f, -0.05669543f, -0.03189396f, -0.05592083f, -0.18518408f, 
    -0.02740388f, -0.00130129f, 0.05486204f, -0.00416744f, -0.03527226f, -0.00318989f, -0.04728486f, -0.06455999f, 
    0.17502278f, 0.13638341f, 0.13320224f, 0.15952204f, -0.01555488f, 0.04870297f, -0.05023467f, -0.02276644f, 
    0.09945174f, -0.09702724f, -0.00078969f, 0.01193819f, 0.18670446f, 0.11841948f, 0.10629024f, 0.03817125f, 
    -0.02520279f, 0.08948220f, 0.00908413f, -0.03718073f, -0.03434465f, -0.00630666f, -0.05767541f, -0.06997813f, 
    -0.00357416f, -0.01736765f, 0.03249924f, -0.03013718f, 0.00540022f, -0.02499035f, -0.04031228f, 0.00244926f, 
    0.01410435f, -0.03346800f, -0.00960894f, -0.02321393f, 0.01387336f, 0.02881065f, 0.00377900f, -0.01163372f, 
    0.01225504f, -0.02248762f, -0.01123357f, 0.00355915f, -0.01389737f, -0.01458992f, -0.03830868f, 0.01524989f, 
    -0.01094996f, -0.03152282f, -0.02417035f, -0.02737302f, 0.01066775f, -0.03496698f, 0.00098972f, -0.01492383f, 
    -0.00244822f, -0.03465955f, -0.01671781f, 0.03265579f, 0.01091108f, -0.03740872f, 0.00167951f, 0.02863346f, 
    -0.01403570f, -0.02186721f, 0.00089613f, 0.00488694f, 0.00431023f, -0.01501586f, 0.01310085f, 0.02719028f, 
    0.02009017f, 0.00104048f, 0.01058388f, 0.02253327f, 0.00731850f, -0.02561286f, 0.01239475f, 0.01188732f, 
    0.00369379f, -0.01141706f, -0.02479396f, -0.02293637f, 0.03093119f, 0.01641736f, -0.03338198f, 0.00523188f, 
    0.02313974f, -0.01395808f, -0.03609334f, -0.00224175f, -0.01710751f, -0.04441513f, -0.00593318f, -0.00070414f, 
    -0.02138190f, 0.01644022f, 0.00623950f, 0.02280900f, -0.03051200f, -0.01498291f, -0.00489303f, 0.02023073f, 
    -0.02398423f, 0.01336031f, 0.00416843f, -0.00387592f, -0.00268315f, 0.00732043f, 0.01269121f, -0.02827439f, 
    -0.02564035f, 0.01916689f, 0.02088910f, -0.02215509f, 0.02885957f, -0.00941920f, -0.02710553f, 0.00295607f, 
    -0.00537205f, -0.00987790f, 0.00898885f, -0.02260125f, -0.02900021f, 0.01382876f, -0.00404999f, -0.01205797f, 
    -0.00751509f, -0.01386078f, -0.02010484f, -0.02685912f, 0.01904346f, -0.04311000f, -0.02936339f, -0.03083277f, 
    0.01299209f, -0.00794461f, -0.01392258f, -0.03185081f, 0.03277527f, -0.02924291f, -0.02992253f, -0.00151807f, 
    -0.02310129f, -0.00406994f, 0.02021372f, 0.00993517f, -0.03444863f, -0.01247971f, -0.01230374f, -0.00967945f, 
    0.00757974f, -0.03368295f, 0.02335533f, -0.03642051f, 0.03024492f, -0.02318249f, 0.01454744f, 0.00722724f, 
    -0.02608340f, 0.02037880f, -0.01643785f, -0.03758390f, 0.02621498f, 0.01115291f, -0.01630984f, -0.01466648f, 
    -0.02276299f, -0.02396977f, 0.02938459f, 0.01712465f, -0.02317569f, -0.03831544f, 0.00256502f, -0.00304956f, 
    0.01533318f, -0.03338537f, -0.04179087f, -0.03494859f, -0.00463526f, -0.02430416f, 0.02665437f, 0.00927897f, 
    -0.00437019f, -0.00999849f, -0.00765789f, 0.00733505f, 0.01573225f, -0.04472249f, -0.00328744f, -0.00203487f, 
    -0.00799708f, 0.02076539f, 0.01691630f, 0.02418140f, -0.03282307f, -0.00687582f, -0.01034374f, 0.00892558f, 
    0.01689513f, -0.02178497f, -0.00081990f, 0.01460467f, -0.02218352f, -0.02130658f, -0.01034763f, -0.00309406f, 
    -0.01800715f, -0.03632861f, -0.01045046f, 0.01769547f, 0.02041114f, 0.02442586f, -0.04480758f, -0.02514513f, 
    -0.04552894f, -0.00858185f, 0.01727385f, 0.02125142f, -0.02709898f, -0.01037858f, -0.02585138f, 0.00281530f, 
    -0.03454375f, 0.02759321f, 0.00874275f, -0.04500459f, -0.02907015f, -0.01553139f, -0.00086968f, -0.01064270f, 
    0.01492076f, -0.02308293f, -0.00009463f, -0.01728999f, -0.02981923f, -0.01934262f, 0.00230059f, -0.01681835f, 
    0.01308669f, -0.01212662f, 0.00047566f, 0.02080747f, 0.01284520f, -0.02113236f, 0.00100310f, 0.00807667f, 
    -0.03341832f, 0.01253908f, 0.01514128f, 0.03441221f, 0.00966156f, 0.02469141f, 0.01852554f, -0.00452565f, 
    0.02461453f, 0.01633325f, -0.02879743f, -0.03826797f, -0.00913501f, -0.00506562f, 0.00016577f, -0.04596493f, 
    -0.01886180f, 0.01501353f, 0.01331152f, -0.03588432f, -0.01122870f, -0.00014904f, -0.01764307f, -0.00696156f, 
    -0.03133899f, -0.03609074f, -0.01293006f, -0.01677178f, -0.00587202f, -0.00416131f, 0.00074540f, 0.00056070f, 
    0.01429964f, -0.02471457f, 0.01925015f, 0.00407022f, -0.00998638f, -0.02499551f, 0.00147941f, 0.01871368f, 
    -0.00336816f, 0.02047868f, 0.01176910f, 0.00102288f, -0.02530180f, -0.00918378f, -0.01455779f, -0.04071495f, 
    -0.03059730f, -0.04049575f, -0.00637684f, 0.02432488f, 0.02272439f, -0.00620128f, 0.00911610f, 0.01773320f, 
    -0.03566681f, -0.02380290f, 0.03772524f, -0.03040413f, -0.00587452f, -0.00003991f, 0.01117702f, 0.01896802f, 
    -0.02198056f, -0.03897101f, -0.00579029f, 0.02709522f, 0.03368664f, -0.03889446f, -0.00729069f, 0.00230674f, 
    -0.03438732f, 0.01988134f, -0.01789186f, 0.01784805f, 0.01797899f, -0.00679548f, 0.03400105f, -0.00437410f, 
    -0.01064577f, -0.01178668f, 0.00625451f, -0.00862818f, -0.01864315f, -0.01384313f, 0.01581131f, -0.01545956f, 
    -0.01319973f, 0.02899819f, -0.01001139f, 0.00904397f, -0.03944477f, -0.01209535f, 0.00844480f, 0.02573784f, 
    -0.01342879f, -0.02933754f, -0.04013853f, -0.01783436f, -0.03302755f, -0.04046534f, -0.03467858f, 0.01814293f, 
    -0.00574649f, 0.00777241f, -0.03418799f, 0.00185982f, 0.00530791f, -0.01336940f, -0.01220861f, -0.00498774f, 
    -0.02446988f, -0.04614356f, -0.01449332f, -0.00650849f, -0.04315853f, 0.00252749f, -0.02559437f, 0.01046089f, 
    0.01618281f, -0.00961616f, -0.01523130f, -0.00750741f, 0.00539027f, -0.03083073f, 0.01332989f, -0.03083364f, 
    0.01876086f, -0.01986431f, -0.01325329f, 0.00969125f, -0.01352340f, -0.01622151f, 0.00243307f, -0.01367758f, 
    -0.00962729f, 0.02822841f, -0.02929634f, -0.01147474f, -0.01850558f, 0.00686102f, -0.00579318f, 0.00142459f, 
    0.01377461f, -0.01998531f, -0.03589785f, 0.00018308f, -0.03365147f, -0.00654601f, -0.02977434f, -0.03257968f, 
    -0.02407951f, 0.00096254f, -0.03692732f, -0.03032638f, -0.00865794f, -0.00208995f, 0.02337049f, -0.00144849f, 
    0.00705878f, 0.03171849f, -0.03612226f, -0.01343901f, 0.01656155f, -0.04444397f, -0.01691140f, -0.01264874f, 
    -0.00556878f, -0.03781631f, 0.00950668f, -0.02571890f, -0.03038966f, -0.02042421f, -0.03522640f, 0.03555438f, 
    0.02219385f, 0.03083142f, 0.01880818f, -0.00752187f, -0.02184510f, -0.01781095f, 0.02039802f, -0.04525395f, 
    -0.00216461f, 0.00375915f, -0.03674224f, 0.02531304f, -0.02639825f, 0.01361075f, -0.02242547f, 0.01602039f, 
    0.02323449f, -0.00004206f, 0.00252962f, -0.03428243f, 0.00755770f, 0.03073429f, -0.00845986f, 0.01051282f, 
    -0.01497305f, -0.01491976f, -0.02758399f, -0.01458805f, -0.04041147f, 0.00220813f, 0.00235235f, 0.01439120f, 
    0.01419811f, 0.01690025f, 0.00559534f, 0.01358183f, 0.00298025f, -0.03465393f, 0.00694838f, -0.03348122f, 
    0.01100193f, -0.03831234f, 0.02155753f, -0.02920560f, -0.02449544f, -0.00642862f, -0.01426880f, 0.02501599f, 
    -0.00253820f, 0.00141818f, 0.01502283f, -0.01314370f, -0.03665478f, 0.02849882f, -0.00040930f, -0.00118328f, 
    -0.01894179f, -0.00099158f, -0.04174458f, -0.02821280f, -0.01928958f, -0.00434676f, -0.03335805f, 0.00320488f, 
    -0.04659453f, 0.02160028f, -0.01955280f, -0.03643795f, 0.01040705f, -0.01560504f, -0.00380590f, 0.01932393f, 
    0.00125762f, -0.00389013f, -0.02503242f, 0.01457742f, 0.02066829f, -0.01739219f, -0.02011438f, -0.02856877f, 
    -0.04409664f, -0.00585225f, -0.02002656f, 0.00513226f, 0.01843961f, -0.01928691f, 0.01090781f, -0.04369764f, 
    0.02104482f, 0.01047193f, -0.03094946f, -0.02992585f, 0.01784296f, -0.03406657f, -0.01511140f, -0.01073913f, 
    -0.01858483f, 0.00506068f, -0.01564172f, 0.01765250f, 0.02672363f, -0.01177696f, -0.00915534f, -0.01886405f, 
    0.00281814f, 0.01858042f, -0.03758074f, -0.03843689f, 0.03379397f, 0.00164353f, 0.00834020f, -0.01423313f, 
    -0.03026703f, 0.01302601f, -0.02838064f, -0.00962536f, -0.03424665f, 0.01099525f, 0.00509734f, 0.02779103f, 
    0.02032411f, -0.04296244f, -0.03688886f, 0.01315848f, 0.02052993f, -0.03025566f, 0.00672203f, 0.01659796f, 
    0.02413438f, -0.01764982f, -0.03787190f, -0.02144509f, 0.00857004f, 0.02059565f, -0.03062134f, -0.02719972f, 
    0.00557175f, -0.00916546f, -0.02166281f, -0.00389391f, -0.03865784f, -0.04287149f, -0.00028500f, 0.00706648f, 
    -0.03907570f, -0.03832538f, 0.01834124f, -0.04476240f, 0.02833729f, 0.00411726f, 0.00949752f, -0.00231716f, 
    0.01959261f, -0.03670550f, 0.01621094f, -0.02030565f, -0.02705773f, 0.01740916f, 0.00029116f, -0.00600597f, 
    0.02841345f, 0.00025268f, -0.04459406f, -0.01426082f, 0.01040001f, 0.00530171f, 0.00970169f, -0.01190053f, 
    -0.01913506f, -0.03528922f, 0.00330340f, -0.00258768f, 0.01984448f, 0.00088659f, -0.03086950f, 0.00347931f, 
    -0.02505620f, 0.00988339f, -0.03361224f, -0.00476471f, 0.00184982f, -0.02504911f, -0.01547594f, -0.02784686f, 
    0.02556610f, -0.00214920f, -0.00510242f, 0.01596213f, 0.02790342f, -0.01853903f, 0.02620823f, 0.02761286f, 
    0.00518970f, -0.04518773f, -0.02703041f, -0.00678949f, -0.04181745f, 0.03581557f, 0.01014164f, -0.03122708f, 
    0.01714147f, -0.02964463f, 0.01530731f, 0.00927900f, -0.03482936f, -0.01037052f, -0.02380682f, -0.03660723f, 
    0.00599124f, 0.01968846f, -0.04121868f, 0.02890458f, -0.03789074f, 0.00982153f, 0.01705506f, 0.00519044f, 
    -0.01839110f, -0.01481412f, -0.02171426f, -0.02462579f, -0.02045666f, 0.02015786f, 0.01224449f, -0.01122616f, 
    -0.01486412f, -0.04120573f, -0.01464048f, 0.01965102f, -0.02127892f, -0.03768008f, -0.04252367f, -0.03403864f, 
    0.02289271f, 0.00759175f, 0.02096440f, 0.02726201f, 0.01373943f, 0.00859671f, -0.00017471f, 0.00088336f, 
    -0.02632564f, 0.00524025f, 0.00952955f, 0.03107928f, 0.02319735f, -0.03217501f, -0.01588009f, -0.03996193f, 
    -0.01103868f, 0.00281682f, 0.00207110f, 0.02131816f, -0.02210237f, 0.01258596f, -0.02690460f, 0.01822287f, 
    -0.02901391f, 0.01366134f, -0.02405466f, -0.04423892f, 0.01599632f, 0.02134837f, -0.03567006f, 0.02314037f, 
    -0.02707827f, -0.03596283f, 0.01398021f, -0.00639273f, 0.00539035f, 0.02250399f, -0.03108799f, 0.01369477f, 
    0.01971500f, 0.01602633f, 0.01963757f, 0.00814552f, 0.01950367f, 0.00974355f, 0.00057319f, -0.01433143f, 
    0.00410601f, 0.02445108f, 0.03320767f, 0.01459450f, -0.01361162f, 0.00660985f, -0.00417699f, 0.00042494f, 
    -0.00424318f, -0.00840604f, 0.00647618f, -0.03122605f, 0.01369205f, -0.00374594f, 0.01536479f, -0.00333370f, 
    -0.00381951f, -0.01034744f, -0.00453017f, 0.00320813f, 0.02194721f, -0.00431759f, 0.00328998f, -0.03506082f, 
    0.02411508f, -0.02893707f, 0.02909261f, 0.02488419f, -0.03372573f, 0.00997640f, 0.00281155f, 0.01651982f, 
    -0.02942378f, 0.02260337f, -0.00950048f, 0.02390582f, -0.03276922f, -0.02465519f, -0.02993502f, -0.04394043f, 
    0.01912010f, 0.01038285f, -0.02673762f, 0.01850938f, -0.01372156f, -0.03344919f, 0.01651050f, -0.02896792f, 
    0.01528690f, 0.01514131f, 0.02420520f, -0.00838464f, -0.01517094f, 0.02517185f, 0.02558956f, 0.01890302f, 
    -0.02342225f, -0.01547730f, -0.03652061f, -0.02343571f, -0.03249388f, -0.02113707f, -0.01271776f, 0.02269254f, 
    -0.03301108f, -0.04446981f, 0.01972149f, -0.00855272f, -0.04600202f, -0.00775052f, -0.01406880f, 0.01947676f, 
    0.01653000f, 0.02945787f, -0.02130687f, -0.03733858f, -0.01624939f, -0.00914735f, -0.02987756f, -0.03972209f, 
    -0.03274092f, -0.03551023f, -0.03738948f, 0.00116183f, -0.00241726f, 0.02980522f, 0.02716574f, -0.02173421f, 
    -0.00068305f, 0.00772276f, -0.03437176f, -0.01195886f, 0.00440625f, -0.01541572f, -0.02646736f, 0.02185536f, 
    -0.02665757f, -0.00591350f, 0.02328717f, 0.00669300f, 0.00196153f, 0.00590399f, 0.00687565f, 0.02443178f, 
    -0.00320942f, -0.01261240f, -0.00135322f, 0.01972736f, -0.03481888f, -0.00635486f, 0.00502589f, -0.02732816f, 
    0.01593617f, -0.01651829f, -0.04235126f, 0.00372937f, 0.01067651f, -0.03844621f, -0.04134417f, 0.01835370f, 
    0.00817174f, -0.01692391f, 0.00815366f, 0.01180142f, 0.02520636f, -0.01836695f, 0.02161277f, 0.01545028f, 
    -0.00025967f, -0.03468637f, 0.01721971f, -0.00869230f, 0.02251007f, -0.03077656f, 0.02251599f, 0.02110159f, 
    0.01617904f, 0.01556642f, -0.03969266f, -0.03296814f, -0.01670619f, 0.00100090f, -0.02377715f, -0.02929315f, 
    -0.02464330f, 0.00350692f, -0.04007155f, 0.02648978f, -0.02065033f, 0.00946168f, -0.01452891f, -0.00187325f, 
    -0.00338132f, 0.02823283f, -0.00378515f, 0.00775048f, -0.01770731f, 0.02112508f, -0.03626838f, 0.02532185f, 
    0.00316592f, -0.02169350f, 0.00022037f, 0.02648191f, -0.00547762f, 0.02460679f, 0.00005510f, -0.01931509f, 
    0.00214120f, -0.00942789f, -0.03514627f, -0.04115315f, -0.03033534f, -0.01505269f, -0.03554930f, -0.02018151f, 
    -0.01107905f, 0.01727759f, 0.01444471f, 0.03152088f, -0.01562785f, -0.01183092f, 0.00064505f, 0.00026739f, 
    -0.00583111f, -0.01546845f, 0.00591801f, -0.04048321f, -0.02062254f, -0.01491567f, 0.00967649f, 0.01312360f, 
    0.01562007f, 0.02171508f, -0.03622528f, 0.00988907f, -0.01253113f, 0.02597933f, 0.02074049f, 0.01184509f, 
    0.00259986f, 0.01753194f, 0.01492517f, -0.01530969f, -0.03585602f, 0.02324711f, -0.03313009f, -0.01494513f, 
    0.01705050f, 0.00154987f, -0.02981043f, -0.00033634f, 0.00271881f, -0.03650935f, -0.03434414f, -0.02306844f, 
    0.02517471f, 0.00807203f, -0.01593898f, 0.01268776f, -0.03670651f, -0.01651768f, -0.03650885f, 0.01472467f, 
    -0.01931937f, -0.03908032f, -0.03200388f, 0.01739763f, 0.00461054f, 0.01781082f, -0.03047436f, -0.03823895f, 
    0.01449083f, 0.01970886f, -0.02862157f, 0.00891185f, 0.00213956f, 0.00496924f, 0.00230578f, 0.02456492f, 
    0.02262181f, -0.01427265f, -0.03373025f, -0.04175089f, -0.02307316f, 0.01989674f, -0.01077258f, 0.00072548f, 
    0.01120306f, 0.00940351f, -0.02990834f, -0.00780383f, 0.03000621f, -0.02037978f, -0.01235077f, -0.03750181f, 
    0.00932576f, -0.03183416f, 0.01682757f, -0.03636882f, -0.00203174f, 0.02091378f, 0.02281366f, -0.00270212f, 
    -0.02995802f, -0.01774702f, 0.02624517f, 0.01464524f, -0.01930282f, 0.00861188f, 0.01760981f, -0.04091020f, 
    -0.01571755f, -0.00772600f, 0.00265120f, 0.00042866f, -0.03931319f, -0.03350122f, -0.03687769f, -0.01469982f, 
    -0.01022194f, 0.02585820f, -0.03524043f, 0.02478548f, -0.02232220f, -0.00099639f, 0.01531886f, 0.00926747f, 
    -0.04017121f, -0.02214922f, -0.03556590f, 0.01340174f, 0.01156910f, -0.00187924f, -0.01264347f, 0.02383343f, 
    -0.03760594f, 0.01487966f, 0.01523049f, -0.00643330f, -0.00686709f, 0.02726414f, -0.03486821f, 0.02228198f, 
    -0.02294926f, -0.00643093f, 0.00586276f, 0.00443292f, 0.02534161f, -0.02523135f, -0.02009315f, -0.01104512f, 
    -0.03588033f, -0.00583137f, -0.02806579f, -0.03393205f, -0.03852194f, -0.01784045f, 0.01133508f, -0.03223800f, 
    -0.02840493f, -0.01001246f, 0.01078994f, -0.00911775f, -0.03163748f, -0.01722227f, 0.01745221f, -0.01399852f, 
    -0.03943661f, -0.00411236f, -0.02673091f, 0.00427595f, -0.01040001f, 0.01507095f, -0.02993435f, 0.02643859f, 
    0.00908857f, -0.02174544f, 0.00121792f, 0.02458361f, -0.03826588f, -0.02055408f, -0.01488076f, 0.01076987f, 
    -0.03707582f, 0.02858583f, 0.01328405f, 0.01299298f, -0.00830920f, -0.03027415f, 0.01407932f, 0.01933648f, 
    -0.01518018f, 0.01517912f, -0.00038141f, -0.00431562f, -0.01463123f, -0.03498912f, -0.02013606f, -0.01687634f, 
    0.00849605f, 0.02455652f, 0.00214242f, 0.02362737f, -0.00413500f, 0.01810374f, -0.02825101f, -0.02253570f, 
    -0.03143967f, -0.01886036f, -0.02723807f, 0.01433975f, -0.04123192f, -0.01494454f, -0.03641925f, 0.01667982f, 
    0.02758384f, -0.00004554f, -0.03191887f, 0.02707238f, -0.00161379f, 0.00991460f, -0.03885493f, 0.02118580f, 
    -0.00120786f, -0.00718265f, 0.02865575f, -0.01584420f, 0.01323839f, -0.01209483f, 0.02720073f, -0.02170039f, 
    -0.03499521f, 0.01621693f, 0.00090567f, -0.01420590f, -0.03357740f, -0.00719183f, 0.01748245f, -0.02754826f, 
    0.00257570f, 0.00185811f, -0.02030287f, -0.01407302f, -0.02915014f, -0.03223613f, -0.03885829f, -0.00008381f, 
    -0.02252178f, -0.00991150f, -0.00849889f, 0.01517149f, -0.03365140f, 0.00781735f, -0.01541483f, 0.00621082f, 
    0.02372314f, 0.00431196f, 0.00923377f, 0.01483347f, 0.02535458f, 0.01080396f, 0.02205571f, -0.01174835f, 
    0.02464948f, -0.00827653f, -0.02573822f, -0.03802552f, -0.01582110f, 0.02320809f, 0.02473791f, -0.00669016f, 
    -0.00479119f, -0.02341855f, -0.03692341f, -0.03893790f, 0.02848104f, 0.02232583f, 0.01087896f, -0.03327711f, 
    -0.04527416f, 0.01694086f, -0.01575070f, 0.02980505f, -0.01106106f, -0.02878941f, 0.01303363f, 0.01141751f, 
    -0.03458679f, 0.00549666f, -0.01629019f, 0.00666288f, -0.03618564f, -0.02262299f, -0.02891723f, -0.00122225f, 
    -0.03307234f, 0.02062049f, -0.02234381f, -0.04106134f, -0.00407643f, 0.00203203f, 0.00517478f, -0.02896469f, 
    -0.01215931f, 0.02427948f, -0.00895600f, 0.02479694f, -0.00490642f, 0.02904279f, 0.01609166f, 0.02470078f, 
    -0.00527360f, 0.01390592f, 0.01605413f, -0.03632422f, -0.00398789f, -0.02191812f, -0.03228866f, 0.01023321f, 
    -0.00509885f, 0.00589966f, 0.02263179f, 0.02601805f, -0.01776325f, 0.02214258f, -0.00235959f, 0.01389967f, 
    0.00778001f, -0.01900739f, 0.01051022f, -0.03604548f, -0.02466073f, -0.00561789f, -0.03431211f, 0.02755524f, 
    -0.02704939f, -0.03426583f, -0.02507426f, -0.02196335f, -0.01513095f, -0.03700652f, 0.02395502f, -0.00902888f, 
    -0.01669934f, 0.01394463f, -0.04209230f, 0.02108860f, 0.00524967f, 0.01534030f, -0.04385034f, -0.00638415f, 
    0.02022733f, -0.03482696f, -0.04279867f, 0.00599752f, -0.00100133f, -0.02300937f, -0.04276690f, -0.01462779f, 
    -0.02892049f, -0.04429543f, -0.03743476f, -0.01719725f, -0.01550774f, -0.01222993f, -0.03201851f, 0.01123541f, 
    0.00120341f, -0.03056969f, -0.00442125f, 0.02669855f, 0.00506599f, 0.01439820f, 0.00894080f, 0.02226607f, 
    -0.01769767f, 0.01698082f, -0.00709460f, -0.02936265f, -0.04106541f, -0.01811148f, -0.01378850f, -0.03974209f, 
    0.00294454f, -0.02826385f, -0.01240123f, -0.01624868f, -0.01390866f, 0.03213929f, 0.02530555f, -0.04044827f, 
    0.01118719f, -0.02707179f, -0.02107280f, -0.01576792f, -0.02231384f, 0.02241257f, 0.00424268f, -0.03513353f, 
    -0.02032646f, -0.04132091f, 0.00477924f, -0.02854694f, 0.02266465f, 0.02052787f, 0.01018672f, -0.00032036f, 
    -0.00223813f, -0.01363281f, -0.00652959f, -0.03280804f, -0.00644382f, -0.03897933f, 0.00521926f, -0.00452786f, 
    0.01214695f, -0.00520820f, -0.02781552f, 0.00355738f, 0.00692668f, 0.02195975f, -0.02009044f, -0.04158013f, 
    -0.00768863f, 0.00161800f, -0.03150285f, -0.01755719f, -0.01374998f, 0.01195504f, -0.02634391f, -0.00420950f, 
    -0.01402334f, 0.00592093f, 0.02205632f, -0.02902287f, -0.03792165f, -0.02438472f, -0.01429788f, 0.00095697f, 
    -0.01095074f, 0.01634220f, 0.00320902f, -0.03184505f, -0.00476914f, -0.02416272f, 0.00381663f, -0.00527754f, 
    -0.01597224f, -0.03067601f, -0.01753086f, 0.00498937f, 0.01948501f, -0.00631412f, 0.01933727f, 0.00025970f, 
    0.00596693f, 0.00303418f, -0.01666084f, -0.02412589f, -0.01487456f, -0.00529955f, -0.04077617f, -0.00790329f, 
    0.00704757f, 0.00670144f, -0.00283605f, -0.00081502f, -0.00925131f, -0.03980947f, -0.01241317f, 0.00966679f, 
    -0.00566013f, 0.02737831f, -0.03740620f, 0.02643670f, -0.00208506f, 0.01991057f, -0.01946656f, -0.01413053f, 
    0.01518210f, 0.00585823f, -0.01258795f, -0.02736979f, -0.02723936f, -0.01879555f, -0.03629882f, 0.02120563f, 
    0.02315061f, 0.00755247f, 0.00589045f, -0.01909131f, 0.00405455f, 0.02650940f, -0.00126663f, 0.00540234f, 
    -0.03542592f, 0.01081162f, 0.00802790f, -0.00183451f, -0.00256753f, -0.01757792f, -0.01561509f, -0.02607188f, 
    0.01697264f, 0.01014982f, -0.03110882f, -0.00447208f, 0.00777524f, -0.02947435f, -0.03729513f, 0.00117374f, 
    0.00777272f, -0.00854142f, -0.02267910f, 0.00485334f, -0.04538507f, 0.01619628f, -0.00721133f, 0.00329827f, 
    -0.03679243f, -0.03819531f, 0.02263903f, 0.01766087f, -0.02701587f, -0.01418990f, -0.01485708f, 0.00694950f, 
    -0.02899271f, -0.02970664f, -0.01624606f, 0.01583666f, 0.01974176f, -0.00672486f, -0.02636000f, 0.02506902f, 
    0.00770614f, 0.03021888f, -0.03094436f, -0.00911776f, -0.01141762f, 0.00415988f, -0.02367854f, -0.04325267f, 
    0.00498654f, -0.02256003f, -0.03249544f, 0.00927487f, -0.02931577f, 0.00751487f, 0.00848832f, 0.02173754f, 
    -0.01482458f, 0.01246617f, -0.00277876f, -0.01060034f, -0.01452368f, 0.01398113f, 0.01103469f, -0.01545330f, 
    -0.01839173f, 0.00959132f, -0.03447346f, -0.01832470f, 0.01057540f, -0.01377762f, -0.04013630f, -0.00344784f, 
    0.00142143f, -0.00583368f, -0.03538172f, 0.02157000f, -0.04205364f, 0.02269020f, 0.00360590f, 0.02444378f, 
    0.01893350f, 0.01491678f, -0.03404948f, -0.02481094f, 0.02207265f, 0.01475777f, -0.03052522f, 0.00796214f, 
    -0.04278212f, -0.01763087f, -0.00586868f, 0.00107172f, -0.03782239f, 0.00348837f, 0.02541478f, 0.02658946f, 
    0.02333560f, 0.02126307f, -0.03824974f, 0.02748924f, 0.02097485f, 0.01048464f, 0.02153497f, -0.01747810f, 
    -0.00250904f, -0.02323005f, -0.01324764f, 0.00078820f, -0.01300346f, 0.01069786f, -0.00799005f, -0.00163588f, 
    -0.01667842f, -0.03063519f, 0.02355447f, -0.01341547f, -0.01510239f, -0.00734239f, -0.03714674f, -0.03727307f, 
    0.01448933f, -0.00400489f, 0.01631240f, -0.02884923f, -0.01575035f, 0.02169693f, -0.02956910f, -0.01884763f, 
    0.01781095f, -0.02206529f, 0.00643257f, -0.02499600f, 0.01274330f, -0.03356835f, -0.00276159f, 0.01531574f, 
    0.02143314f, 0.00796070f, -0.03533490f, -0.03492923f, 0.00227165f, 0.01945824f, -0.03156001f, -0.04514755f, 
    -0.01393043f, 0.03073618f, -0.04304336f, -0.01706226f, -0.04267243f, -0.02216941f, -0.00711751f, 0.02053488f, 
    0.02388038f, -0.02908148f, 0.01855292f, -0.03899534f, -0.00991622f, -0.04055212f, 0.00575665f, -0.03079848f, 
    -0.04089693f, 0.00329045f, -0.03272101f, -0.01169032f, -0.02285711f, -0.02388918f, -0.01564291f, -0.01158853f, 
    -0.02378401f, -0.01184013f, 0.01171363f, 0.02436173f, -0.02341922f, -0.00003395f, 0.01955115f, 0.02391867f, 
    0.00020876f, -0.02929575f, -0.03234862f, 0.02743137f, 0.00035719f, 0.01660645f, -0.00422940f, -0.02671285f, 
    -0.01045781f, 0.02281715f, -0.03554910f, -0.02224075f, -0.03337738f, 0.02530873f, -0.02085715f, 0.02453475f, 
    -0.04442722f, 0.02772992f, -0.01298796f, -0.04369950f, -0.01314414f, -0.01907453f, -0.01380717f, -0.00820646f, 
    -0.01809188f, -0.01731262f, 0.03159766f, 0.00804954f, -0.03989929f, 0.00938846f, 0.00757738f, 0.01593617f, 
    -0.03545683f, -0.00307675f, 0.00441686f, 0.02704358f, 0.02580085f, -0.00307443f, 0.01950845f, 0.02567900f, 
    -0.02752393f, 0.00603528f, -0.00021266f, -0.01522014f, -0.00128927f, -0.02698856f, 0.02991090f, 0.02753719f, 
    0.02055090f, -0.00889141f, -0.01555801f, -0.03903356f, 0.00680403f, 0.02581411f, 0.00317690f, -0.00372135f, 
    0.01825240f, 0.01611682f, -0.01341206f, 0.00068979f, -0.02349670f, -0.03473861f, -0.01092500f, -0.01087199f, 
    0.01129916f, 0.01812773f, 0.01102793f, -0.01427283f, -0.02894577f, -0.01161913f, -0.01824910f, -0.01247634f, 
    0.01815677f, -0.01801316f, 0.02678706f, -0.02497458f, 0.01516303f, 0.02189274f, -0.00587777f, -0.03494705f, 
    -0.03555404f, 0.00691774f, -0.04261475f, -0.00705916f, -0.01802017f, -0.03303163f, -0.00000823f, -0.03603625f, 
    0.02383276f, 0.01105499f, -0.01721910f, -0.03540512f, 0.00872435f, -0.00752869f, 0.00664999f, 0.02503683f, 
    -0.03366690f, 0.01205381f, -0.00309110f, -0.03200583f, 0.00184666f, -0.00845784f, -0.01793403f, -0.01296653f, 
    -0.02488046f, -0.01691219f, -0.00746883f, 0.02512940f, 0.02171741f, -0.02077807f, -0.02968524f, 0.00894769f, 
    -0.00344523f, -0.01382874f, -0.00660506f, -0.00586466f, -0.02680907f, 0.01501651f, -0.01292457f, 0.01571511f, 
    -0.02187868f, -0.00016737f, 0.02137896f, 0.00908402f, 0.01941869f, -0.01654342f, -0.01655327f, -0.01894129f, 
    -0.03236227f, -0.00365796f, -0.03454369f, -0.00659585f, -0.02219045f, -0.00627624f, -0.01630562f, 0.02645320f, 
    0.00611368f, 0.00614700f, 0.03471037f, -0.02840599f, -0.01160139f, 0.01459728f, -0.01841985f, 0.00300544f, 
    -0.00005503f, -0.01180707f, 0.02794428f, 0.01445112f, -0.02449761f, -0.01077734f, -0.01761191f, 0.02345199f, 
    0.01498789f, 0.01945610f, -0.00731337f, -0.03935475f, 0.01482609f, 0.01367967f, 0.00989620f, 0.01773326f, 
    -0.01544608f, 0.02551931f, 0.00908455f, 0.01188919f, -0.04106331f, -0.00911333f, 0.03034212f, -0.00177891f, 
    0.00961951f, -0.01718005f, -0.01785274f, -0.00560711f, -0.01394222f, 0.01605202f, 0.00011051f, -0.00385291f, 
    0.02565658f, -0.01215700f, -0.00783148f, -0.03267604f, -0.03735791f, 0.00327037f, -0.04166881f, 0.02248198f, 
    0.02053560f, 0.00371017f, -0.02574022f, -0.03455666f, -0.01234967f, 0.02719608f, -0.02787337f, 0.00383158f, 
    0.00008095f, 0.00099265f, -0.01987707f, 0.02114002f, 0.00035434f, 0.02662958f, 0.02715533f, 0.00372926f, 
    -0.02442044f, -0.00305949f, 0.00174088f, -0.04141547f, 0.01834808f, -0.03195997f, -0.02213330f, -0.02467229f, 
    -0.01697084f, -0.00531469f, 0.00008565f, -0.02102699f, -0.03318748f, 0.01095239f, 0.00376998f, 0.02257489f, 
    0.00691427f, -0.04179495f, 0.01976326f, 0.01742475f, -0.03848257f, -0.00172631f, -0.00138581f, 0.02416592f, 
    0.02299929f, -0.03259455f, 0.00714166f, 0.00061644f, -0.02453278f, -0.00070295f, -0.00109201f, -0.00974569f, 
    -0.01488399f, -0.01156772f, 0.01460979f, -0.02768315f, 0.00056449f, -0.03242254f, -0.00209519f, -0.01283312f, 
    -0.00874342f, 0.01105494f, -0.00948582f, 0.01775080f, 0.02234558f, 0.00758722f, 0.02392193f, -0.02080309f, 
    0.00873168f, -0.00319469f, -0.01683578f, -0.02926448f, -0.01053132f, -0.02815656f, -0.01480537f, -0.02041296f, 
    0.01034522f, 0.02665089f, 0.01892713f, 0.00515895f, -0.02774118f, 0.01198010f, 0.01984332f, 0.00631765f, 
    -0.02838631f, 0.00798552f, 0.00025177f, 0.02524802f, -0.03509620f, -0.01176613f, -0.04277295f, -0.04337269f, 
    -0.01618600f, -0.02163385f, 0.02522998f, -0.01997151f, -0.00022664f, 0.00709906f, -0.01620893f, -0.03152256f, 
    -0.02482344f, 0.00826017f, -0.03696255f, -0.04018564f, 0.01876351f, -0.01237966f, -0.00247087f, 0.00529310f, 
    -0.01199500f, 0.01679753f, -0.03439624f, 0.01815861f, -0.01133033f, -0.02412475f, -0.02918087f, 0.02300691f, 
    -0.02048911f, -0.01070262f, 0.00863388f, -0.02686644f, 0.00611955f, -0.01729246f, -0.00172339f, -0.04129292f, 
    0.02151643f, 0.02134626f, -0.00530927f, 0.00998855f, 0.02892272f, 0.01591574f, -0.01844209f, -0.02513636f, 
    0.01834395f, 0.01122895f, -0.01042954f, -0.02646308f, -0.01917143f, -0.00282433f, -0.00347278f, 0.00886906f, 
    -0.02795926f, 0.02862049f, 0.00907700f, 0.02160952f, -0.03459215f, 0.00324059f, -0.01115268f, -0.03682360f, 
    -0.01827511f, -0.02297947f, 0.02730273f, -0.03733280f, 0.01913471f, -0.02345496f, -0.00896901f, 0.00328115f, 
    -0.03287823f, -0.03180160f, 0.00254429f, -0.03612303f, -0.01097475f, -0.01157411f, 0.01748883f, 0.01702925f, 
    -0.02086569f, 0.01711349f, -0.01841761f, -0.01049778f, 0.00123007f, -0.04309899f, -0.04546620f, -0.00284978f, 
    -0.00572877f, 0.02233059f, 0.01383094f, -0.01489131f, 0.02192581f, -0.03503444f, -0.02322499f, -0.01117319f, 
    0.02782302f, 0.00247791f, -0.00857876f, -0.00852065f, -0.02838574f, 0.01012672f, 0.00523445f, -0.03832977f, 
    -0.01042386f, -0.02718760f, -0.03039948f, 0.02781406f, 0.02762330f, 0.00372817f, 0.02585982f, 0.01919278f, 
    -0.03210204f, 0.02204349f, 0.01064316f, -0.01052552f, 0.00438994f, -0.03849315f, -0.02636703f, -0.03936237f, 
    -0.00345678f, -0.03134122f, -0.02862611f, 0.02645394f, 0.00578501f, -0.04345654f, -0.01630925f, 0.02563349f, 
    0.01076823f, -0.04174124f, 0.00988004f, 0.02679181f, 0.01605055f, 0.02207102f, -0.00171941f, -0.00638615f, 
    -0.03588035f, -0.02057924f, -0.01605406f, 0.02849390f, 0.01843732f, -0.02925725f, 0.00217862f, -0.03469898f, 
    0.01107157f, -0.01742028f, -0.00048007f, -0.02508492f, -0.01078967f, 0.02161064f, -0.03017986f, -0.02046815f, 
    -0.03693143f, -0.00592664f, 0.02478940f, 0.01628244f, 0.00606610f, -0.00481572f, 0.00435675f, 0.02733144f, 
    -0.01443167f, 0.02472517f, -0.00728812f, 0.02423239f, 0.02575559f, -0.03665495f, 0.01921933f, 0.00223129f, 
    0.00951168f, -0.03604146f, -0.04217047f, 0.01118258f, 0.02083494f, 0.00737644f, 0.00280268f, -0.01834844f, 
    -0.01905474f, -0.02735713f, 0.02390089f, 0.00068472f, -0.02221625f, 0.02767034f, 0.01205319f, -0.02841668f, 
    -0.00196390f, 0.02870041f, -0.02669428f, 0.00188066f, -0.02282633f, -0.00108348f, -0.02647142f, 0.01862688f, 
    -0.01716099f, 0.00858948f, -0.02263823f, -0.00012968f, 0.02594174f, -0.00631537f, 0.01915834f, 0.00303668f, 
    -0.00966644f, -0.02190086f, -0.04232709f, 0.01061176f, -0.02495355f, -0.02243160f, -0.00048991f, -0.04031931f, 
    -0.03123500f, 0.01937233f, 0.01374237f, -0.02569110f, -0.04100574f, -0.01043907f, 0.01943752f, -0.01786110f, 
    0.01773553f, 0.01071144f, -0.02872189f, -0.02717213f, 0.00204321f, 0.03246760f, -0.02417462f, -0.04339622f, 
    0.00315547f, -0.03420019f, -0.03080379f, 0.01472271f, -0.02982818f, -0.00570492f, 0.00399382f, -0.03034970f, 
    -0.02033862f, 0.00720299f, -0.00533804f, -0.00950400f, -0.00241849f, -0.00753314f, 0.02760850f, -0.04149541f, 
    0.01293821f, -0.00445783f, 0.00695726f, 0.01626419f, -0.04092746f, -0.01537183f, 0.00483464f, 0.02932615f, 
    -0.00416747f, -0.01693572f, -0.00065965f, 0.01734729f, -0.02240501f, 0.00350717f, -0.04380408f, -0.02122067f, 
    -0.02732284f, -0.00958352f, -0.01488155f, -0.03042882f, -0.02571093f, -0.00704396f, 0.01691581f, -0.01892789f, 
    0.02128676f, -0.02799274f, -0.04009257f, -0.03842683f, -0.03761772f, -0.01404042f, -0.02370804f, -0.02266650f, 
    0.02589939f, -0.01922181f, -0.04080341f, -0.00518970f, 0.00323761f, -0.00328211f, -0.03075858f, 0.03700210f, 
    -0.02497652f, 0.00727385f, -0.01557346f, -0.00173549f, -0.02682857f, -0.03367291f, -0.04087311f, 0.00717103f, 
    0.01656565f, -0.01439930f, -0.00542451f, -0.00481699f, 0.01574343f, -0.04501233f, -0.01008748f, -0.02620561f, 
    -0.00580376f, -0.01519942f, -0.00047065f, -0.01978370f, 0.00468089f, 0.00333658f, -0.01874819f, 0.01825656f, 
    0.02669812f, 0.01121111f, -0.02280874f, 0.02512849f, 0.01754161f, -0.02445201f, 0.03085450f, -0.00662686f, 
    0.02355879f, -0.01632477f, -0.01335671f, -0.04238906f, 0.01112175f, -0.02902782f, -0.00382108f, 0.01684206f, 
    -0.04331240f, -0.00616329f, -0.00383457f, -0.03070804f, -0.00159627f, -0.01997197f, -0.01909410f, -0.02503135f, 
    -0.03357702f, -0.02293202f, 0.01264990f, -0.03783996f, -0.03185032f, 0.01747213f, 0.00648895f, -0.01938391f, 
    -0.02049491f, 0.00211836f, -0.03919387f, -0.01092542f, 0.01756115f, -0.01464861f, 0.01858403f, -0.01220363f, 
    -0.04060807f, -0.02244581f, -0.01615818f, 0.02619325f, -0.00651146f, -0.02298691f, 0.00299634f, 0.01344598f, 
    -0.00870041f, 0.01268548f, -0.03325468f, -0.01329800f, 0.00400937f, -0.02266021f, -0.02246301f, 0.00505400f, 
    -0.03090667f, -0.02627822f, -0.01258321f, 0.02519320f, 0.01727355f, -0.02317912f, -0.00621299f, -0.03948695f, 
    0.01878078f, 0.00725398f, -0.02287008f, -0.02013085f, 0.00934128f, 0.00276255f, -0.04243822f, -0.04446274f, 
    0.00313997f, -0.03855408f, -0.02550613f, 0.01855658f, 0.00320731f, 0.00139969f, -0.00060358f, 0.01120973f, 
    0.01314632f, 0.04571111f, -0.01222688f, -0.02396368f, -0.01648381f, -0.02166826f, -0.01566119f, -0.03177134f, 
    -0.02107484f, -0.00799359f, 0.01461415f, -0.02612278f, 0.01964637f, 0.01131542f, -0.02050390f, 0.00069876f, 
    -0.03197725f, -0.04296141f, 0.02575914f, -0.03216605f, -0.02263216f, 0.01457996f, 0.01817994f, -0.00411901f, 
    0.00399277f, -0.03662133f, 0.01621392f, -0.00863457f, -0.01728205f, -0.00474243f, 0.00469401f, -0.00661317f, 
    0.00380547f, -0.02975158f, 0.01499397f, 0.02147932f, 0.02588482f, 0.01429863f, -0.02224370f, -0.00236136f, 
    0.01519379f, -0.04375717f, 0.01487107f, -0.01646440f, 0.01112552f, 0.02766875f, -0.04202612f, -0.02589621f, 
    0.02677484f, 0.01458980f, 0.01554436f, -0.03150677f, 0.02149089f, 0.02582779f, -0.03287837f, 0.00231032f, 
    -0.03954865f, 0.01148820f, -0.01806813f, -0.03761679f, 0.02066533f, -0.00424659f, 0.01733777f, -0.02328778f, 
    -0.01523514f, 0.01047719f, -0.01079566f, -0.03126836f, 0.02222639f, -0.00015336f, 0.00471225f, -0.02538289f, 
    -0.03904980f, -0.03230019f, -0.03281394f, -0.02637484f, 0.00674643f, 0.02058168f, -0.00483237f, -0.04394699f, 
    -0.03486843f, 0.00516666f, -0.00615935f, 0.02471804f, 0.02089277f, -0.00276603f, -0.01785986f, 0.01345910f, 
    0.00732542f, 0.01189964f, -0.00532915f, -0.00580980f, 0.01323740f, 0.02247613f, -0.01752583f, -0.01703207f, 
    -0.00805057f, 0.01977316f, 0.02225633f, -0.00092324f, -0.02665743f, -0.01717055f, -0.00844598f, 0.00475402f, 
    -0.01599613f, -0.02469579f, 0.01505659f, 0.02454507f, -0.02313507f, -0.01127483f, 0.02489583f, -0.02495879f, 
    0.01458314f, 0.00972900f, 0.02096084f, 0.01517324f, -0.01557299f, -0.02436236f, 0.02565210f, -0.02204415f, 
    0.00963968f, -0.02693230f, 0.00606432f, -0.03558426f, -0.04064015f, -0.02899119f, -0.04067351f, -0.03071765f, 
    -0.02304930f, 0.02028217f, -0.03028547f, 0.01334290f, 0.02588074f, 0.02613137f, -0.01989697f, 0.02693848f, 
    0.02540743f, -0.00970297f, 0.01979856f, -0.01306629f, 0.00534784f, -0.02893299f, -0.02003289f, -0.01575146f, 
    0.01492694f, -0.03423754f, -0.04886438f, 0.02477906f, 0.01180322f, -0.02583971f, 0.02574020f, -0.02488158f, 
    -0.00205003f, 0.03089224f, -0.00607983f, 0.00476742f, -0.00487781f, -0.02380429f, 0.02714527f, 0.01680616f, 
    -0.00113312f, -0.00869415f, 0.01003297f, 0.01029202f, -0.02103953f, -0.00310305f, 0.01345035f, -0.01013142f, 
    -0.01359285f, -0.04063275f, -0.01200454f, 0.01945575f, -0.01765426f, -0.00157623f, 0.01442048f, 0.00731711f, 
    -0.00040545f, -0.04117780f, 0.01457133f, 0.02645099f, -0.01144645f, -0.03495613f, -0.01146588f, -0.00815572f, 
    0.00314911f, 0.02034718f, -0.01273761f, -0.03008824f, 0.01338362f, 0.03013401f, -0.03298009f, -0.03454458f, 
    0.00740186f, -0.03374192f, -0.04054568f, -0.04364067f, -0.04425602f, -0.03515690f, 0.00568619f, -0.03170554f, 
    -0.04564142f, 0.00322482f, -0.00603142f, -0.00654261f, -0.02871288f, 0.01108819f, 0.03034694f, 0.02789271f, 
    -0.01671769f, -0.03095993f, -0.00170698f, -0.03347048f, -0.00861501f, 0.00319726f, -0.00422070f, -0.03123822f, 
    -0.01005045f, -0.03743258f, -0.03882833f, 0.02012818f, -0.00407898f, 0.00354662f, -0.00614747f, -0.03502800f, 
    0.01788578f, -0.00509127f, -0.03053804f, -0.02037876f, 0.00441019f, 0.03032556f, 0.01806673f, 0.02155374f, 
    0.02665172f, 0.00827400f, 0.00505466f, 0.00370392f, -0.02514529f, -0.00589706f, -0.03556807f, 0.00442052f, 
    -0.00852342f, 0.01329858f, -0.01484912f, 0.01077811f, -0.02672856f, -0.00320966f, -0.00940911f, -0.02997538f, 
    -0.01768712f, -0.02003629f, 0.02311956f, -0.03170725f, -0.00988549f, 0.00842757f, 0.00612866f, 0.00864886f, 
    -0.03626349f, 0.02277630f, 0.01713548f, -0.03749739f, -0.01661077f, -0.00334008f, 0.01176036f, -0.04399813f, 
    0.01954176f, 0.01795847f, -0.00382794f, -0.00217129f, -0.00112070f, -0.00784507f, 0.00607388f, 0.01916376f, 
    0.01661956f, 0.02998789f, -0.00152609f, -0.00928082f, -0.03329200f, -0.03191301f, 0.01952261f, 0.03261789f, 
    -0.01534658f, -0.00432563f, 0.00669849f, 0.01773634f, -0.03134534f, 0.00665752f, 0.01823130f, -0.02447090f, 
    -0.01491511f, 0.01534907f, 0.02416027f, -0.01902000f, 0.01940649f, -0.04082208f, 0.02473335f, 0.00921362f, 
    -0.04504624f, -0.03898277f, 0.02078745f, -0.02759467f, 0.01178546f, -0.00483362f, -0.03540548f, 0.03031652f, 
    -0.04815552f, 0.01320471f, 0.01356312f, -0.00456917f, -0.01271229f, -0.03309419f, -0.03546551f, 0.02704370f, 
    -0.02434663f, -0.01898885f, 0.02386340f, 0.03295143f, -0.01391463f, 0.01958510f, -0.00137554f, 0.01754662f, 
    0.01037076f, 0.01298031f, -0.00946993f, -0.04345211f, 0.03306449f, 0.01713793f, -0.03500572f, 0.01023223f, 
    0.00399749f, -0.02323893f, -0.01190386f, 0.02922652f, -0.01126531f, 0.00283980f, 0.02267142f, -0.00630637f, 
    -0.02349121f, -0.03365106f, 0.01401167f, 0.01794659f, -0.01007331f, -0.02236208f, 0.00501431f, 0.01753098f, 
    0.03306016f, 0.01947036f, -0.03037300f, -0.02841268f, -0.00708520f, -0.03494808f, -0.01900215f, -0.03572640f, 
    0.01295506f, -0.02483311f, -0.00623906f, -0.03561381f, 0.01127795f, 0.00834232f, -0.01166609f, 0.03160320f, 
    0.02679699f, -0.03887463f, -0.00528414f, 0.02627478f, 0.01823889f, -0.02246713f, 0.00768944f, 0.00237122f, 
    -0.03116326f, -0.03230160f, 0.02312302f, 0.00571868f, -0.04255963f, -0.02130009f, 0.02564882f, -0.03373983f, 
    0.02021562f, 0.00083797f, 0.00251572f, 0.02139972f, -0.00917749f, 0.01703002f, 0.01719410f, -0.03566461f, 
    0.01739997f, -0.01178006f, 0.01616043f, -0.02329001f, 0.00256881f, 0.00618486f, 0.00344299f, -0.03531137f, 
    -0.01087471f, -0.01016423f, -0.00182139f, -0.02451722f, 0.02419494f, -0.00158253f, -0.02307709f, -0.02315636f, 
    -0.02625394f, -0.03811007f, 0.02444193f, 0.01605137f, 0.01808571f, 0.01089214f, 0.01310387f, 0.01708257f, 
    0.01311681f, -0.03220333f, -0.03711074f, 0.00471763f, 0.01751899f, 0.00162009f, -0.00193341f, -0.00716028f, 
    0.01068407f, -0.00682127f, -0.00794756f, 0.01756357f, -0.01982685f, 0.02027282f, -0.01954617f, -0.00432873f, 
    -0.00592051f, 0.00047694f, 0.03085180f, -0.01636214f, -0.01167885f, -0.01444084f, -0.02173725f, 0.01588641f, 
    0.01026971f, -0.02843976f, -0.02106880f, -0.03627039f, 0.01913594f, -0.00776779f, 0.02971750f, 0.00087565f, 
    -0.02732925f, 0.00711008f, -0.02974136f, -0.01324603f, 0.01399722f, -0.02789318f, -0.03736058f, 0.01803150f, 
    -0.02275890f, -0.02915717f, 0.01541822f, 0.01865194f, -0.00965817f, 0.01878121f, -0.03635325f, -0.01832930f, 
    -0.04288120f, -0.00551607f, 0.01702806f, -0.01260459f, -0.00637499f, -0.03829788f, 0.00050532f, -0.03644419f, 
    -0.01418022f, -0.00299667f, -0.01633400f, -0.00672320f, -0.03029239f, 0.00880744f, 0.02993997f, 0.00410002f, 
    -0.03591898f, 0.01729350f, -0.02337505f, -0.01930984f, -0.03425935f, -0.01727257f, 0.00998310f, -0.00006397f, 
    -0.00302478f, -0.01521988f, -0.02771241f, -0.03436068f, -0.02362088f, -0.02912950f, -0.01164777f, -0.02735187f, 
    -0.03845558f, 0.03357701f, -0.01819154f, 0.02341308f, -0.00068377f, 0.02607832f, -0.02074864f, -0.02559601f, 
    -0.02652585f, -0.03609211f, -0.03975297f, -0.00425602f, -0.00710619f, 0.00203683f, 0.02996010f, 0.03254908f, 
    0.02374684f, -0.03108642f, 0.02636744f, 0.00600091f, 0.01102329f, 0.00114832f, -0.00796722f, -0.02081132f, 
    -0.02719331f, -0.01782836f, -0.00288625f, 0.02311868f, -0.02970303f, 0.02840094f, -0.03491141f, 0.00356869f, 
    0.00823561f, -0.00525907f, 0.00314994f, -0.01635313f, -0.03418746f, -0.03515052f, 0.00261401f, -0.00714422f, 
    -0.01407440f, 0.01679470f, -0.04153644f, -0.02838379f, 0.01566730f, -0.02991778f, 0.03598066f, -0.02995099f, 
    -0.02435738f, 0.02768197f, 0.00372461f, 0.02015456f, 0.01594117f, 0.00048037f, -0.02029723f, -0.03585867f, 
    -0.01023327f, -0.00810592f, 0.00172652f, -0.02882182f, -0.03720937f, 0.01633704f, -0.00130592f, -0.02595690f, 
    0.01593520f, -0.01811094f, 0.01217655f, 0.01773026f, 0.00179572f, -0.01726657f, 0.01843800f, 0.01145726f, 
    0.01946902f, 0.01735118f, 0.02867739f, -0.00489012f, 0.00091762f, 0.01931435f, 0.01893644f, -0.01341384f, 
    -0.03393877f, -0.01027948f, 0.02216946f, -0.00447800f, 0.00756198f, -0.00893130f, -0.01863015f, -0.03342450f, 
    -0.00277963f, 0.00072642f, -0.03361620f, 0.02571474f, -0.02914598f, -0.00060775f, 0.02898700f, 0.02925571f, 
    -0.03699445f, -0.03139267f, -0.02015323f, -0.03717469f, 0.02565009f, 0.01285137f, 0.00886967f, 0.01832055f, 
    -0.02789514f, -0.01974474f, -0.04001689f, -0.02083827f, 0.02205421f, -0.01966176f, -0.01913003f, -0.01053953f, 
    -0.04211743f, 0.03405247f, 0.01330421f, 0.02170802f, 0.00980687f, 0.02722398f, -0.03289986f, -0.03659987f, 
    -0.02306490f, -0.00578237f, -0.02496974f, -0.03690784f, -0.02395656f, -0.02930504f, 0.00366202f, -0.01925409f, 
    0.01656431f, -0.00541257f, -0.01271638f, -0.00420134f, 0.00081142f, 0.02119400f, -0.03027979f, 0.02891250f, 
    -0.02014088f, 0.02404380f, -0.04461818f, 0.01077823f, -0.00376147f, 0.01994381f, -0.02822774f, 0.02003719f, 
    -0.01835081f, 0.02614141f, 0.01595929f, -0.01356198f, -0.00367839f, -0.00107452f, 0.01449760f, 0.01119533f, 
    0.03486014f, -0.00913037f, -0.00272627f, 0.01681441f, -0.01702560f, 0.00038387f, -0.01588969f, -0.00298065f, 
    -0.01690210f, -0.03391857f, 0.02703978f, 0.01828072f, 0.00628387f, -0.04512179f, -0.01771288f, -0.03963630f, 
    -0.01809420f, -0.01522185f, -0.01583281f, -0.00155687f, -0.00307185f, 0.02196085f, -0.03127257f, -0.00491207f, 
    -0.00578062f, -0.02587115f, 0.00753580f, 0.00900157f, -0.01788919f, -0.03451576f, -0.00772809f, 0.00007097f, 
    -0.02597182f, -0.03585690f, -0.00150260f, -0.02175490f, -0.01342373f, -0.03841953f, 0.02657938f, -0.02345802f, 
    -0.02444573f, -0.02699541f, -0.03673237f, -0.02511934f, -0.02135442f, 0.00633674f, 0.00954611f, -0.00660618f, 
    -0.00120058f, -0.02457469f, -0.01923965f, 0.02860016f, 0.02730223f, -0.03966708f, -0.03550858f, -0.00968300f, 
    -0.02569671f, -0.02898935f, -0.02759827f, 0.02017190f, 0.02657546f, -0.01023974f, 0.02338265f, 0.00747718f, 
    -0.02533353f, -0.02788240f, 0.00691526f, 0.01541516f, -0.02484898f, -0.00710514f, -0.02363102f, 0.01537153f, 
    -0.01511758f, -0.04317716f, -0.04305146f, -0.01925467f, 0.01092561f, 0.02676265f, 0.02202226f, 0.00606785f, 
    -0.01111553f, 0.00178909f, 0.03559726f, -0.00369917f, -0.02311166f, 0.02710925f, -0.00749313f, -0.01741872f, 
    0.02043375f, 0.01818840f, -0.03396225f, -0.01889191f, -0.01814643f, -0.03819685f, -0.00354032f, 0.02289136f, 
    -0.02192220f, -0.01692454f, 0.02862443f, 0.02448444f, 0.01768340f, -0.03351307f, -0.01398500f, -0.03099978f, 
    -0.00409467f, 0.01544507f, -0.02349344f, -0.00632441f, 0.01386262f, 0.01253097f, 0.01824029f, 0.02680692f, 
    -0.01665855f, -0.00682529f, 0.02850251f, -0.03658692f, -0.02512083f, 0.01056140f, -0.02244607f, -0.03518714f, 
    -0.00636748f, -0.02538400f, 0.00104088f, 0.00703202f, 0.01733828f, 0.03020573f, -0.03749716f, -0.03071475f, 
    -0.03373648f, -0.01977887f, 0.00563380f, -0.01825509f, -0.00313780f, -0.03091981f, 0.00811342f, -0.00286845f, 
    -0.04276320f, -0.02711106f, 0.01744694f, 0.02419872f, 0.02201578f, 0.01530282f, -0.01868746f, 0.01901892f, 
    -0.04032391f, -0.02787133f, 0.01555123f, 0.02406377f, 0.02726443f, -0.02651944f, 0.00153870f, -0.00353875f, 
    -0.03226386f, -0.03748683f, 0.03162405f, -0.01557703f, 0.00062255f, 0.01509288f, 0.01867337f, -0.03460007f, 
    -0.02144741f, 0.00127434f, 0.02066687f, -0.00559358f, -0.01785216f, -0.02999876f, -0.03619137f, -0.01296795f, 
    -0.02069951f, -0.01266745f, 0.01670173f, -0.02247292f, 0.02203449f, -0.01704476f, -0.01709690f, -0.02469574f, 
    -0.03571542f, 0.00960473f, -0.00326808f, -0.03938619f, 0.01537242f, 0.01476806f, -0.03962199f, -0.03021912f, 
    -0.00484166f, -0.00533674f, -0.00983009f, 0.03137443f, 0.00027419f, -0.03386913f, -0.01280515f, 0.01330137f, 
    0.01868642f, -0.00140075f, 0.02055796f, -0.03136846f, 0.00157089f, -0.02319073f, -0.01862279f, 0.02210730f, 
    -0.04141172f, 0.01163068f, -0.00989737f, -0.00684018f, -0.01423152f, -0.02679291f, 0.00960095f, 0.00451683f, 
    0.01650410f, 0.02755811f, -0.03339329f, -0.02387518f, 0.02388699f, -0.02961190f, 0.00131507f, -0.03757048f, 
    -0.01737246f, 0.01749221f, -0.03347458f, 0.02584591f, 0.02253595f, -0.04938526f, 0.00323237f, 0.01113558f, 
    0.01188960f, -0.02272920f, 0.02939380f, -0.00144762f, 0.01927391f, -0.03756403f, -0.03461194f, -0.00677901f, 
    -0.02348607f, 0.02562337f, -0.03294580f, 0.02563454f, -0.02646791f, -0.03429973f, 0.01698756f, 0.00741217f, 
    -0.04349467f, -0.02765503f, -0.02330489f, 0.01849149f, 0.02040349f, -0.01440819f, 0.01399405f, 0.02851703f, 
    0.02107919f, 0.01233264f, -0.00808168f, -0.02883228f, 0.00144541f, -0.01494596f, -0.03064067f, 0.00421435f, 
    -0.02712634f, -0.00731485f, -0.01191382f, -0.03524375f, -0.02572589f, 0.00320205f, 0.02490068f, -0.00245845f, 
    -0.01312036f, -0.02385968f, -0.00842820f, -0.02317273f, -0.03804872f, -0.03236732f, -0.01753519f, 0.01953716f, 
    0.04184416f, -0.20866534f, -0.13885878f, 0.01357659f, 0.11786936f, 0.01881834f, -0.06425384f, -0.01699653f, 
    -0.00551409f, -0.13224980f, 0.05744771f, -0.02608099f, -0.04332322f, -0.02145601f, 0.03735792f, 0.16822189f, 
    -0.09441254f, 0.02729660f, -0.02322459f, 0.12120999f, -0.00630166f, 0.08744434f, -0.02422249f, -0.02167236f, 
    -0.17038445f, -0.25769842f, 0.04804393f, 0.06522262f, 0.03403274f, -0.04196135f, 0.00562960f, -0.00665615f, 
    0.06558063f, 0.10218247f, 0.09982641f, 0.05845783f, 0.12030748f, 0.10806762f, -0.00611969f, -0.09666017f, 
    0.05932612f, 0.05820200f, 0.02177791f, 0.04545216f, -0.05033285f, 0.13122007f, 0.03306717f, 0.00895680f, 
    -0.15007646f, -0.15800883f, -0.05358844f, -0.02635986f, 0.10160988f, 0.01313938f, -0.03807929f, -0.07856118f, 
    0.01440838f, -0.01322867f, 0.06754906f, 0.07927864f, 0.09267076f, -0.19167249f, -0.13231671f, 0.06921374f, 
    0.06213550f, -0.04825342f, -0.02058054f, 0.01824915f, 0.01680255f, -0.09834471f, 0.07988037f, 0.04192708f, 
    -0.22672543f, -0.06509478f, -0.07735803f, -0.07140692f, 0.09514529f, 0.02820321f, -0.11205016f, -0.04287478f, 
    0.03952584f, -0.04799990f, 0.04160177f, 0.05254703f, 0.18131544f, -0.03351210f, -0.01987743f, 0.19088072f, 
    0.12238685f, -0.01817322f, -0.01529219f, -0.00376950f, 0.00074245f, -0.04047725f, 0.05146156f, 0.07886072f, 
    0.01860038f, 0.01652046f, 0.07020183f, 0.00387554f, -0.14609125f, -0.03913370f, 0.01782924f, 0.04476434f, 
    0.00570351f, -0.17385174f, 0.24737859f, -0.01957288f, 0.00181043f, -0.04872714f, 0.06530657f, -0.06056225f, 
    -0.05842613f, 0.11442418f, -0.01739648f, 0.03463857f, -0.07644784f, 0.04104783f, 0.04845997f, -0.09063197f, 
    -0.10584299f, 0.20361169f, 0.02669090f, -0.12181906f, 0.00389915f, 0.02798464f, 0.00187913f, 0.01947097f, 
    -0.11573705f, 0.06086297f, 0.13183537f, 0.05660670f, -0.08017898f, -0.05861783f, 0.08837465f, -0.15952197f, 
    -0.09103645f, -0.03742078f, 0.09828112f, -0.03745840f, 0.07599867f, 0.09478576f, -0.04258481f, 0.07355883f, 
    -0.00119960f, -0.33144468f, -0.10565384f, 0.10030761f, 0.08137219f, -0.06174924f, -0.00510946f, -0.04164003f, 
    0.03408052f, 0.04776203f, 0.05454874f, 0.00336381f, -0.02540921f, -0.20506795f, 0.02339344f, 0.07604548f, 
    0.10299649f, -0.04173642f, -0.14460237f, 0.01335706f, 0.03339057f, -0.05585220f, 0.03342323f, 0.01542367f, 
    0.08849348f, 0.02960123f, -0.02971185f, 0.13510308f, 0.03052635f, -0.01857104f, 0.07649314f, -0.01033455f, 
    -0.00939588f, -0.03185501f, -0.13214210f, 0.00535419f, 0.07891246f, -0.15343416f, -0.15281011f, 0.00068082f, 
    0.14062282f, 0.03696774f, -0.02610964f, 0.03582229f, 0.01659796f, 0.12148865f, -0.02765531f, 0.17355479f, 
    0.13479808f, -0.03613050f, 0.02946497f, -0.09252167f, 0.01613295f, 0.06457078f, -0.04218965f, 0.06068322f, 
    0.09816865f, 0.08808377f, -0.01611911f, 0.17255932f, -0.10520367f, -0.24108554f, -0.07436878f, -0.04630360f, 
    0.00219222f, 0.06363960f, 0.01309839f, 0.19644170f, 0.02155950f, 0.01421359f, 0.03630925f, -0.01625043f, 
    -0.20125325f, 0.04962108f, -0.10685577f, -0.08781738f, 0.05914934f, 0.03225972f, -0.04675156f, 0.07793205f, 
    0.12648122f, 0.12053601f, 0.05837868f, 0.06249474f, -0.03533496f, 0.07444793f, -0.05530586f, -0.02850382f, 
    0.06573171f, -0.11435346f, -0.03342962f, 0.11133517f, 0.05934947f, -0.04478327f, -0.03729839f, -0.12067492f, 
    -0.06364781f, 0.10233068f, 0.07870718f, 0.10379588f, 0.02447988f, -0.10588010f, -0.01935102f, 0.05021429f, 
    0.07216680f, 0.07461876f, 0.01805430f, 0.04552329f, -0.04790820f, 0.13288049f, 0.00745595f, -0.00241402f, 
    -0.13715434f, -0.08479620f, -0.00733934f, -0.15848824f, -0.11765353f, -0.02978615f, 0.10774994f, -0.02588646f, 
    0.30270723f, 0.00408618f, -0.11009576f, 0.11865971f, -0.04338995f, -0.04516585f, -0.03090926f, 0.08488360f, 
    -0.02615310f, -0.03736512f, -0.08547393f, -0.03770729f, -0.00983689f, -0.04271083f, 0.11797532f, -0.05674701f, 
    -0.07355237f, -0.04350488f, -0.02356483f, -0.01319509f, 0.12799993f, -0.16843757f, 0.02535048f, 0.07190390f, 
    0.25559881f, 0.01354783f, -0.03335344f, 0.05868333f, -0.05846201f, -0.00158892f, 0.03630647f, 0.02640124f, 
    -0.03617927f, 0.12036602f, -0.04722899f, -0.10456074f, -0.25553751f, 0.07570329f, -0.20166345f, -0.01931624f, 
    -0.07875744f, -0.16623171f, -0.11097395f, -0.14192894f, -0.09025698f, -0.17220715f, 0.03861639f, -0.10406002f, 
    -0.02748418f, -0.04206694f, -0.06189280f, -0.01837576f, 0.09173515f, 0.00569232f, -0.00367418f, 0.00683165f, 
    0.06733761f, -0.01879182f, -0.04531969f, -0.08508804f, 0.05918816f, -0.01011985f, 0.06367376f, -0.12561660f, 
    -0.02629902f, 0.00729907f, 0.05736367f, 0.02290048f, -0.05810984f, 0.03315226f, 0.05091891f, 0.10020727f, 
    0.17798959f, -0.18391834f, -0.15430705f, 0.00955981f, 0.03188326f, 0.07519532f, 0.06371899f, 0.06985348f, 
    0.10472806f, 0.06239535f, -0.02644123f, -0.04541184f, 0.14991038f, 0.02128668f, 0.00293859f, 0.02141990f, 
    -0.11514180f, -0.11667988f, -0.01123944f, 0.06884733f, -0.09116663f, -0.09071703f, 0.08907447f, -0.04111021f, 
    -0.01154161f, -0.16150646f, -0.00407491f, 0.07464844f, 0.12566960f, 0.02793665f, -0.01470073f, 0.00946488f, 
    0.01386694f, 0.09766947f, -0.00446273f, 0.09816901f, 0.36440966f, 0.01913341f, 0.01579168f, 0.03567959f, 
    -0.13253672f, 0.04857862f, 0.00585964f, 0.02942100f, 0.05209865f, 0.08706138f, -0.06243116f, -0.04358817f, 
    -0.29817027f, 0.18565318f, 0.02752812f, 0.03688946f, 0.08029500f, 0.08991133f, -0.00902158f, 0.04703130f, 
    -0.00754182f, -0.06277527f, 0.00591169f, 0.04518219f, -0.03544872f, 0.17852607f, 0.05048174f, -0.08760227f, 
    0.11733088f, 0.08435640f, -0.04676473f, 0.09382626f, 0.09669523f, 0.00685676f, -0.10421474f, 0.00144020f, 
    0.00811981f, -0.32388455f, -0.00320692f, 0.09706862f, 0.07169935f, 0.06920640f, -0.01561361f, 0.01243388f, 
    0.07356457f, -0.00841892f, 0.01585707f, 0.00112774f, -0.17350617f, -0.07199386f, -0.18790743f, -0.07722341f, 
    0.01430399f, 0.05489570f, -0.07858772f, 0.00895192f, 0.08264880f, -0.13015814f, 0.12829070f, 0.06345464f, 
    -0.17877880f, -0.10796390f, -0.05764643f, 0.08476723f, 0.03946406f, 0.06251474f, -0.05029806f, 0.03008291f, 
    0.08040828f, -0.05199443f, -0.02579540f, 0.03103791f, -0.03326241f, -0.26695767f, -0.08160652f, 0.09168305f, 
    -0.02886507f, -0.06449221f, 0.03381206f, 0.03426546f, -0.04379892f, 0.01991610f, -0.07469562f, 0.27697635f, 
    -0.07872774f, 0.00070312f, 0.12463116f, 0.03542266f, -0.06410357f, 0.07639791f, -0.01688480f, 0.03810700f, 
    -0.02359824f, -0.01311626f, 0.06492915f, 0.15127432f, 0.31047392f, 0.03474972f, -0.03742280f, 0.10896899f, 
    -0.11892688f, 0.02326179f, 0.05253668f, 0.07505965f, 0.00369804f, 0.05318592f, -0.03664707f, -0.08474948f, 
    0.04865700f, 0.01277654f, 0.17243426f, -0.09637334f, -0.03876407f, -0.05510025f, 0.04895709f, -0.05870781f, 
    0.02879075f, -0.06991751f, -0.04574651f, 0.09200352f, -0.02690384f, -0.22441451f, 0.14366953f, 0.08050406f, 
    0.14102623f, -0.11150915f, 0.03960987f, -0.02283913f, 0.11759852f, -0.06935308f, 0.10851275f, -0.03894795f, 
    0.09099020f, 0.03460078f, 0.00623252f, 0.01127912f, -0.05633313f, 0.07110024f, -0.01311023f, -0.02062878f, 
    0.08769371f, -0.09153716f, 0.06320479f, 0.03021360f, -0.06980882f, 0.09041563f, 0.09592867f, 0.03246270f, 
    -0.02934988f, -0.08682515f, 0.10783917f, 0.00816127f, 0.01340112f, 0.07572424f, 0.03628993f, -0.03236440f, 
    0.04110082f, 0.07034360f, 0.18315907f, -0.15935646f, 0.09496152f, 0.15363182f, 0.02526850f, 0.07503305f, 
    -0.17331630f, -0.00511547f, 0.01784308f, 0.04910124f, 0.05894329f, 0.34979966f, -0.04744556f, -0.17734516f, 
    0.02899231f, 0.00776444f, 0.05226791f, -0.03527781f, -0.11828679f, 0.00719243f, 0.01925898f, 0.02233142f, 
    -0.14059505f, 0.13762726f, -0.09951261f, -0.09269874f, 0.09547871f, -0.06827419f, 0.07845489f, 0.03821085f, 
    0.01359125f, -0.00236023f, 0.01305074f, -0.04025213f, 0.08357680f, 0.05056999f, 0.17046554f, -0.06356157f, 
    -0.06690642f, -0.07398082f, -0.00024912f, -0.04280611f, -0.13372925f, 0.10354198f, 0.05743086f, 0.05189884f, 
    -0.07980333f, -0.19862393f, 0.03829578f, -0.08230815f, -0.09720629f, 0.08397446f, -0.03033172f, 0.08718657f, 
    -0.04302224f, 0.05758119f, 0.02795912f, -0.01683553f, -0.14156917f, -0.26060614f, -0.02444956f, 0.11808501f, 
    -0.03170636f, -0.05766240f, -0.06050246f, 0.00383294f, 0.03269661f, 0.00573058f, 0.07236457f, -0.09125662f, 
    -0.15098681f, -0.09537322f, 0.10206993f, 0.00355818f, -0.01929891f, 0.04155200f, 0.02844295f, 0.00693096f, 
    0.07618544f, -0.09524592f, 0.09726731f, 0.05929036f, -0.17237708f, 0.12089553f, -0.06891058f, -0.10714543f, 
    0.01375118f, 0.04571401f, -0.01473509f, 0.06713785f, 0.08415731f, 0.06169244f, 0.07489727f, -0.05785488f, 
    0.07101788f, 0.05605798f, 0.12318478f, -0.07592966f, -0.04505393f, 0.08748524f, 0.09751766f, -0.02416730f, 
    -0.00956597f, 0.03004387f, 0.03783511f, 0.01054336f, -0.02584588f, 0.05410714f, 0.02322497f, -0.04791663f, 
    -0.00989845f, 0.04315686f, 0.04762172f, -0.01802301f, 0.00559676f, 0.01974448f, -0.14597495f, 0.11690903f, 
    -0.02713228f, 0.22441259f, -0.13307045f, -0.10497811f, 0.20148611f, 0.02306041f, 0.02007849f, 0.06011233f, 
    0.11152088f, 0.15769318f, 0.00945754f, 0.06731800f, 0.07978497f, -0.01243970f, 0.12337758f, 0.02922369f, 
    0.04863013f, 0.02516033f, 0.04293594f, 0.08271021f, -0.00556583f, -0.06286986f, 0.07957210f, -0.04228021f, 
    -0.17068574f, -0.14686814f, 0.01270795f, 0.08412024f, 0.10116531f, -0.05227669f, 0.01614261f, -0.02060658f, 
    0.06697811f, -0.06116967f, 0.05034954f, 0.04230841f, -0.04730001f, -0.19960724f, -0.08372225f, 0.05828397f, 
    0.04992286f, 0.07502425f, 0.01829723f, 0.02404072f, 0.07148176f, -0.08320653f, 0.09415940f, 0.06119169f, 
    0.04118935f, -0.01704487f, 0.02882892f, -0.08052199f, 0.06214396f, 0.01773542f, 0.04533309f, 0.05278663f, 
    0.01774348f, -0.09895744f, 0.08502086f, 0.00169687f, 0.19749758f, 0.15261361f, 0.00311488f, -0.14534599f, 
    0.07061199f, 0.05372853f, 0.07443140f, 0.05994149f, 0.11010306f, 0.12445025f, -0.05385916f, 0.10693779f, 
    -0.02190210f, -0.10380812f, -0.03851410f, 0.05504781f, 0.07906719f, -0.10185855f, -0.06330772f, 0.07001396f, 
    -0.07353610f, 0.04080749f, -0.01729375f, 0.05716626f, -0.12758553f, -0.28105047f, -0.09039509f, 0.06036124f, 
    0.08931273f, 0.07751913f, -0.11045317f, -0.00943316f, -0.00344487f, -0.13508286f, 0.01724531f, 0.05440755f, 
    0.29293096f, 0.01748290f, -0.01890341f, 0.00964196f, -0.09962977f, -0.03025859f, 0.05789533f, 0.02267246f, 
    0.04364952f, 0.02693519f, 0.10830427f, 0.00008343f, 0.19446707f, 0.05464106f, 0.09286750f, -0.09621901f, 
    0.00120351f, 0.09539543f, 0.04944640f, 0.04198186f, 0.05276162f, 0.13438377f, 0.07729720f, -0.02679010f, 
    -0.00764386f, 0.01615867f, -0.02189942f, 0.01520312f, -0.02508410f, 0.01834588f, -0.03030075f, -0.02613883f, 
    0.02331112f, -0.02326065f, 0.02243847f, -0.03774761f, -0.01784298f, -0.02219043f, 0.01076281f, 0.00804141f, 
    -0.00671427f, 0.02809068f, 0.01037089f, -0.01253472f, 0.02476331f, 0.02317227f, 0.00594767f, -0.00597212f, 
    -0.01842201f, -0.00383818f, 0.02427988f, 0.00001494f, 0.02539950f, -0.00461802f, 0.00967154f, 0.01468746f, 
    0.03191784f, -0.02003852f, -0.01573510f, -0.00298103f, 0.01592666f, -0.03711120f, -0.01800707f, -0.00823098f, 
    -0.00539156f, -0.02027306f, -0.01916198f, 0.01989498f, -0.02495896f, 0.02431600f, -0.02463260f, -0.00843334f, 
    -0.02858960f, 0.00747224f, -0.02261726f, 0.01211417f, -0.02410518f, -0.02654971f, -0.01693390f, 0.02728627f, 
    -0.01823623f, 0.02162130f, -0.01890345f, 0.02276556f, -0.03623940f, -0.00705818f, 0.00603831f, -0.01942737f, 
    0.02600063f, 0.02509760f, -0.02782397f, -0.02180903f, -0.03920693f, 0.01076858f, -0.02627430f, -0.02559993f, 
    -0.00157628f, -0.03906555f, 0.01559440f, -0.01740865f, -0.02953979f, -0.03758373f, 0.01892400f, -0.01202152f, 
    -0.01268050f, -0.00662209f, -0.02188174f, -0.00040399f, 0.01944851f, -0.00733361f, -0.01992941f, 0.02655170f, 
    0.02842256f, -0.03144134f, 0.02250271f, -0.03149663f, -0.00587214f, 0.02048432f, -0.03158256f, 0.03093117f, 
    0.00849695f, 0.00099603f, -0.03915769f, -0.03916115f, 0.01786108f, 0.01602076f, 0.00775441f, 0.02281558f, 
    -0.01696007f, -0.03491468f, -0.02617160f, 0.02462295f, 0.01203641f, -0.04169637f, -0.02617395f, -0.00591585f, 
    0.02475696f, -0.02748505f, -0.00440827f, 0.01982905f, 0.01398305f, 0.00203545f, -0.01954954f, -0.00845506f, 
    0.00422651f, -0.00264432f, -0.01981373f, 0.01300570f, -0.02741919f, 0.01629179f, 0.02252422f, -0.02996346f, 
    -0.03463840f, -0.01126363f, 0.03400765f, 0.01994392f, 0.02228989f, -0.01850009f, -0.00921492f, 0.00237356f, 
    -0.01343385f, 0.01684337f, -0.02502159f, 0.03016124f, 0.00403857f, 0.02520488f, 0.01950128f, -0.02868838f, 
    -0.01882854f, -0.03057051f, 0.01240055f, -0.00862645f, -0.01837604f, -0.02086497f, 0.02595611f, -0.03352844f, 
    -0.00307128f, 0.00022775f, -0.02794323f, 0.01241359f, -0.01834822f, 0.01335283f, 0.02028464f, -0.01762150f, 
    -0.00400377f, 0.00877760f, 0.02133588f, -0.01535215f, -0.03546784f, -0.01643195f, -0.01541484f, -0.03524227f, 
    0.00489498f, 0.02077357f, 0.01590754f, -0.03505997f, -0.01648372f, -0.03618406f, 0.02998129f, 0.00529798f, 
    0.01941221f, -0.03321208f, 0.02113559f, -0.00216683f, -0.02858637f, -0.00455796f, -0.03916051f, 0.02420352f, 
    -0.00988860f, -0.03525956f, -0.02314716f, -0.03080496f, 0.03133287f, 0.02630739f, 0.02855720f, -0.00102278f, 
    0.01211071f, 0.00479504f, 0.02615990f, -0.00841222f, 0.02945785f, 0.00676071f, -0.02832450f, 0.00387966f, 
    0.02876071f, 0.01148192f, -0.01532788f, -0.00573064f, -0.02420628f, -0.03277264f, 0.00794591f, 0.01715345f, 
    -0.00651019f, -0.00646858f, -0.00675191f, -0.01143935f, 0.02009446f, 0.03650192f, 0.01035800f, -0.03221033f, 
    0.03440981f, -0.03359249f, 0.02667369f, -0.02825417f, -0.00094579f, 0.01286540f, -0.01599808f, -0.00807305f, 
    -0.01990791f, -0.01307669f, -0.02646594f, -0.02439318f, -0.02752122f, 0.00911920f, 0.00606327f, -0.02854406f, 
    -0.02208595f, 0.01781488f, -0.03470051f, 0.02573668f, 0.02457799f, -0.03986522f, -0.01711397f, -0.03723046f, 
    0.00410146f, -0.01349547f, -0.02462120f, -0.00314548f, -0.02890624f, -0.03671532f, -0.03274447f, -0.02035618f, 
    0.01376190f, -0.01283001f, 0.02521416f, -0.01864080f, 0.02611334f, -0.01495476f, -0.03531905f, -0.01129880f, 
    -0.01603739f, -0.03198854f, 0.01404322f, -0.00327718f, -0.04064514f, 0.03512334f, 0.01151509f, 0.00558758f, 
    0.00320839f, -0.01806516f, -0.00380936f, -0.02019369f, -0.00693794f, -0.03265388f, -0.01899164f, 0.02949309f, 
    0.02532005f, 0.02665789f, -0.01420698f, 0.00287230f, -0.00429952f, -0.01329217f, 0.03250901f, 0.02416947f, 
    0.02292506f, -0.02064307f, 0.03417551f, -0.02169501f, -0.01018365f, -0.02986949f, 0.00536099f, -0.03530852f, 
    0.02224746f, 0.02339096f, 0.01807466f, 0.01952763f, 0.00714569f, -0.01499752f, 0.01971672f, 0.01690100f, 
    0.00583747f, 0.01367792f, 0.03142341f, -0.02124518f, -0.04142075f, -0.01481900f, -0.01307902f, -0.03107809f, 
    0.02149349f, 0.03037099f, 0.02542518f, -0.01739987f, -0.01208812f, 0.02813980f, 0.01304025f, 0.02237234f, 
    -0.01792368f, -0.03857205f, 0.00379174f, 0.01400365f, 0.01583007f, -0.00745381f, -0.01343613f, -0.00193621f, 
    0.02203925f, 0.01818464f, 0.02019271f, -0.01614934f, -0.01196808f, -0.00283711f, -0.01945894f, 0.00473500f, 
    -0.01443788f, 0.01712966f, -0.02112873f, -0.01503077f, 0.02084581f, -0.01267420f, -0.01444812f, 0.00087574f, 
    -0.02626974f, 0.02997466f, 0.00135705f, -0.02010012f, -0.03201968f, 0.02818608f, -0.01864773f, -0.01616294f, 
    -0.00374233f, 0.00796361f, 0.02224636f, -0.02383803f, -0.01724479f, -0.02362444f, -0.02766265f, 0.01767808f, 
    0.03326242f, -0.01641328f, -0.01299924f, -0.01045438f, 0.00050746f, 0.01839907f, -0.01713558f, -0.00166289f, 
    -0.01831022f, 0.01267786f, 0.02735139f, -0.01052256f, -0.02527818f, 0.02653738f, 0.01180957f, 0.02601023f, 
    -0.01831901f, -0.03553697f, -0.02742948f, -0.02455324f, -0.00343917f, 0.00352316f, -0.01921132f, 0.03016268f, 
    -0.01728527f, 0.02155185f, 0.03108912f, -0.02389700f, 0.00204834f, 0.02107388f, -0.00071025f, -0.01785546f, 
    0.00587050f, 0.01347420f, -0.04005880f, 0.00895308f, -0.00033662f, 0.00064834f, -0.00965597f, -0.03000108f, 
    0.00722878f, -0.02361343f, -0.01070939f, -0.02237383f, -0.03057298f, 0.01210995f, -0.03223728f, 0.02261819f, 
    0.00255382f, 0.01423143f, -0.01586193f, 0.01586481f, 0.01564237f, -0.01547408f, 0.03159308f, -0.01969861f, 
    0.01166468f, -0.00079816f, -0.03213404f, -0.03020253f, 0.00270038f, -0.00607709f, 0.02376126f, 0.02997994f, 
    -0.01444849f, -0.02985658f, 0.02862392f, -0.01545662f, -0.00762464f, 0.02501701f, 0.02406126f, -0.03245096f, 
    0.01727642f, 0.02844106f, -0.03974126f, 0.00175144f, -0.04012541f, -0.00765830f, -0.01854453f, -0.01743501f, 
    0.01985787f, -0.00002914f, 0.02088686f, 0.00602498f, -0.01260620f, -0.03471641f, 0.01644178f, -0.00552680f, 
    -0.03275268f, 0.01202812f, -0.01678207f, -0.00717665f, -0.01138128f, 0.01480725f, -0.01008027f, -0.02295052f, 
    -0.03952744f, 0.01742308f, 0.00526884f, -0.01272601f, -0.00253063f, 0.02676038f, -0.00401389f, -0.02364944f, 
    0.00190593f, -0.02530537f, -0.00222589f, -0.02750244f, 0.01365635f, -0.00930895f, 0.02708673f, -0.02502913f, 
    -0.00453840f, 0.00086143f, -0.03928907f, -0.03418486f, -0.03015524f, -0.03038558f, 0.00355569f, 0.01007787f, 
    0.03096743f, -0.02843910f, -0.02798879f, -0.03370523f, 0.01526944f, -0.00799307f, -0.03180071f, -0.00862049f, 
    0.00204349f, -0.03748472f, 0.00892442f, 0.02114818f, -0.03827882f, -0.02551330f, -0.01204970f, -0.00763420f, 
    -0.03250744f, 0.00210459f, 0.01823532f, 0.02077005f, -0.00045372f, 0.01129136f, -0.03383830f, -0.02049223f, 
    -0.02795373f, 0.02913980f, -0.01001977f, 0.00424438f, 0.01511056f, -0.03733572f, 0.00834906f, -0.00488043f, 
    0.01242522f, -0.02358459f, 0.00123148f, -0.03185382f, -0.04011072f, 0.00893300f, 0.01493215f, -0.03099632f, 
    0.01637361f, -0.01738871f, -0.02728532f, -0.00166926f, 0.04368141f, -0.01781472f, 0.02655857f, -0.00976447f, 
    -0.01942078f, -0.03672069f, 0.03093841f, -0.03873807f, 0.00330490f, 0.02604968f, 0.01319616f, -0.00293384f, 
    -0.01282061f, 0.01995652f, 0.01413280f, 0.01984347f, 0.00825479f, -0.00092455f, 0.00167403f, 0.02727864f, 
    -0.00575033f, 0.02133664f, -0.02502796f, -0.03477973f, -0.04036598f, 0.03341668f, 0.00599444f, 0.01240482f, 
    0.01973302f, -0.00624408f, 0.00708918f, 0.02665941f, -0.00647781f, -0.02121364f, 0.00166120f, 0.02323264f, 
    -0.03009064f, -0.03073362f, 0.01081123f, 0.02700874f, 0.01765117f, -0.01689145f, -0.00950842f, 0.02129264f, 
    0.01362090f, 0.02441683f, 0.02303491f, 0.01112948f, 0.01820717f, 0.01344998f, -0.00184667f, -0.02721317f, 
    0.03595781f, 0.01762320f, -0.04117053f, -0.01490771f, -0.03291966f, -0.02199249f, -0.02374846f, 0.02000844f, 
    -0.03384641f, -0.02531424f, 0.02339915f, 0.00505587f, -0.01711105f, 0.00097970f, 0.00739504f, 0.02165260f, 
    0.02907423f, 0.00547569f, -0.02052898f, -0.01789989f, -0.00073016f, 0.00206759f, 0.03068510f, 0.03118844f, 
    0.00418309f, -0.02863246f, -0.01949758f, -0.02454889f, 0.03071098f, -0.00836192f, -0.01258771f, 0.01186415f, 
    -0.02675236f, -0.02515375f, -0.01997529f, -0.01300805f, -0.00587996f, -0.01437582f, 0.01497561f, -0.00979396f, 
    -0.00017377f, 0.00243834f, 0.01073906f, 0.01834823f, -0.02898682f, 0.00746389f, -0.01733184f, -0.02484787f, 
    -0.02885344f, 0.01891984f, -0.01572861f, -0.00685828f, -0.01551972f, 0.00796398f, -0.01483817f, -0.00517537f, 
    0.00614844f, 0.02798873f, -0.03450349f, -0.02927048f, -0.00547680f, 0.00093360f, -0.01379978f, -0.00106475f, 
    -0.02130409f, 0.02570027f, -0.02864468f, 0.02457237f, 0.01956446f, -0.00614722f, -0.03983944f, -0.01427728f, 
    -0.00551130f, 0.02056516f, 0.02980117f, -0.01491466f, 0.01315975f, 0.00576668f, -0.03049258f, 0.02486829f, 
    -0.02689505f, -0.00169017f, -0.00862736f, 0.03049094f, -0.01319091f, 0.02939893f, 0.03265264f, 0.01643679f, 
    -0.01724423f, -0.01602474f, 0.04041421f, 0.02748247f, -0.02459708f, 0.01419592f, -0.03512751f, 0.00336019f, 
    0.00996727f, 0.00229642f, -0.00185476f, -0.02066548f, 0.01066855f, -0.01303391f, 0.00785291f, 0.01726822f, 
    -0.00280650f, 0.00058713f, 0.02878985f, 0.01167460f, 0.00823961f, -0.01036580f, -0.00467594f, -0.02420132f, 
    0.00399489f, -0.02226532f, -0.04133619f, 0.01257856f, 0.00648411f, 0.02196181f, 0.00691413f, 0.02515136f, 
    -0.00278097f, -0.01403603f, 0.00599826f, 0.03561349f, 0.02756836f, 0.01571129f, -0.00347429f, 0.00207116f, 
    0.02420270f, 0.00514281f, 0.02985036f, 0.00063581f, -0.03488760f, -0.03168446f, -0.02155293f, 0.03309820f, 
    0.00819643f, 0.01322461f, -0.03242325f, 0.02171627f, 0.02378478f, -0.03089839f, 0.02183230f, -0.02919949f, 
    -0.02129348f, -0.03429269f, -0.00712530f, -0.02814559f, -0.00912234f, 0.02290361f, 0.02585472f, -0.03556207f, 
    -0.00333529f, 0.01880253f, 0.02433428f, 0.02530168f, 0.02812713f, 0.00387611f, -0.01670401f, -0.00498373f, 
    0.00827699f, -0.01202376f, 0.01485149f, -0.01590150f, -0.01493756f, -0.02163060f, 0.01484511f, 0.00025957f, 
    -0.02962457f, -0.03541784f, 0.02284325f, 0.03284971f, 0.01002968f, 0.01217416f, 0.02321039f, 0.00092530f, 
    -0.03144338f, 0.01544112f, 0.01292666f, -0.02584630f, -0.02335552f, 0.02788017f, 0.00754801f, 0.00060415f, 
    -0.00067112f, 0.01497907f, -0.00283618f, 0.00197815f, -0.01145124f, 0.01015078f, 0.00468723f, -0.03222514f, 
    0.01598606f, -0.03250448f, -0.00754501f, -0.02572159f, 0.02874562f, 0.01812980f, 0.00155308f, -0.02457262f, 
    0.03060184f, -0.03373495f, -0.02881670f, 0.00213147f, -0.03419460f, 0.00198557f, -0.02978465f, 0.01810878f, 
    -0.01660876f, 0.01595337f, -0.00737518f, -0.00548012f, -0.02696270f, 0.02529153f, 0.01346666f, 0.02599645f, 
    0.02177300f, 0.01913462f, -0.01360738f, -0.02256170f, -0.01119138f, -0.02054138f, -0.00158634f, -0.02237204f, 
    -0.02400288f, 0.00835109f, 0.03477499f, -0.00502331f, -0.00810035f, 0.02982471f, 0.01510535f, 0.02708478f, 
    -0.03339234f, -0.01785273f, -0.01353814f, -0.01395405f, -0.03922397f, -0.03446873f, -0.02433039f, 0.02908538f, 
    0.00329903f, -0.00090194f, 0.02612501f, -0.02349846f, 0.02525738f, 0.01728986f, 0.02926250f, -0.03222643f, 
    0.00599828f, -0.01955758f, 0.02946089f, -0.01791598f, -0.03394593f, -0.03989490f, -0.00946720f, 0.03143764f, 
    0.00824752f, -0.00513360f, 0.02157606f, -0.02666555f, -0.00217567f, 0.01716848f, 0.00032878f, -0.00795760f, 
    0.00889447f, 0.03272377f, 0.02336091f, 0.01126282f, -0.02684014f, -0.01840528f, 0.01422064f, -0.01365169f, 
    -0.02281589f, 0.02808573f, 0.00012026f, -0.01747273f, -0.01266493f, -0.02976074f, -0.00689727f, -0.01478473f, 
    -0.01701805f, 0.01236591f, -0.04282451f, 0.00762082f, 0.02536510f, -0.00330859f, -0.02448660f, -0.03768817f, 
    0.01597686f, 0.01503541f, -0.00085123f, -0.01239942f, 0.00534736f, -0.00493757f, 0.00085878f, 0.01482899f, 
    -0.03871650f, -0.03486387f, 0.03171834f, 0.01873251f, -0.02077307f, 0.01005272f, -0.03124616f, -0.03223643f, 
    -0.00182537f, 0.01478484f, -0.02913928f, -0.03973921f, 0.00861692f, 0.01679789f, -0.01662296f, 0.02565584f, 
    -0.01356043f, 0.00218854f, -0.00250564f, 0.02906815f, -0.03857370f, -0.01099979f, 0.00244986f, -0.03922002f, 
    -0.03166293f, -0.02094447f, -0.02579212f, 0.00031421f, 0.01065785f, 0.01946736f, 0.01143365f, -0.03505602f, 
    0.02685624f, -0.02655473f, -0.03641776f, 0.03069383f, 0.00398452f, 0.00452828f, 0.01162802f, -0.00214401f, 
    -0.00473111f, -0.02635834f, -0.02320857f, 0.02398260f, 0.01569824f, 0.01061412f, 0.01267942f, -0.04136848f, 
    -0.01211819f, -0.00703782f, -0.03054710f, 0.02536565f, -0.03904523f, -0.01415459f, -0.01640026f, 0.01876711f, 
    0.01830249f, -0.04042963f, -0.02388858f, -0.00801689f, 0.01268835f, -0.01227299f, -0.02092795f, -0.04027954f, 
    0.01894754f, -0.01393830f, 0.02260925f, 0.02828846f, -0.03176453f, 0.00096416f, -0.01449683f, -0.01170594f, 
    0.01919087f, 0.03061144f, -0.03629795f, -0.02810478f, -0.01661355f, -0.01507423f, -0.02298206f, -0.03540748f, 
    -0.00877671f, -0.02546558f, -0.00785739f, -0.02376142f, 0.03219780f, -0.01439091f, -0.00011934f, -0.03601930f, 
    -0.03021412f, -0.02073804f, 0.01155495f, -0.02036501f, -0.01858000f, -0.03091392f, -0.03853877f, -0.01906228f, 
    0.01795648f, -0.02833417f, -0.00740987f, -0.03232419f, 0.01386587f, 0.00494154f, -0.01873193f, 0.00205114f, 
    -0.01961134f, 0.00663997f, -0.01803098f, 0.02661177f, 0.01277494f, 0.02770290f, -0.02569999f, 0.00481552f, 
    -0.01829696f, 0.00024497f, 0.02767042f, -0.01040502f, -0.02647998f, -0.00779657f, 0.02226189f, -0.02465306f, 
    -0.02444325f, -0.03410602f, 0.00622617f, 0.01362087f, -0.01824651f, 0.02366446f, 0.00604015f, -0.02574437f, 
    -0.03567619f, 0.01237025f, 0.01274120f, -0.00970900f, 0.00634533f, 0.01373082f, -0.03551077f, -0.04056708f, 
    -0.00829292f, -0.03109584f, -0.02089541f, 0.03198173f, -0.02627090f, -0.02970665f, -0.00033279f, -0.02674640f, 
    -0.02432289f, -0.01550086f, -0.03490038f, -0.03416396f, 0.00286347f, -0.02183726f, 0.01862342f, 0.02800797f, 
    0.02243355f, 0.00514697f, -0.03503663f, -0.01658516f, 0.02693882f, 0.03578793f, -0.01895041f, 0.02749713f, 
    -0.02803913f, -0.00051190f, -0.02235279f, -0.02737481f, -0.03892592f, 0.00020247f, -0.02881005f, 0.02299871f, 
    0.03025869f, -0.02555513f, 0.02632491f, 0.02946307f, 0.02604093f, 0.02147286f, 0.03435890f, -0.01542547f, 
    0.02994301f, -0.02245621f, -0.01214051f, 0.01563093f, 0.00131874f, 0.02713620f, 0.02977311f, -0.00953127f, 
    -0.00762378f, 0.01700961f, 0.00169383f, -0.02346399f, -0.03577799f, -0.03236694f, 0.00959345f, -0.03508386f, 
    0.00944064f, -0.01212568f, 0.03233978f, 0.02513428f, 0.02135091f, -0.00245916f, 0.03349508f, -0.00830648f, 
    -0.00891106f, -0.02607113f, 0.00238480f, -0.02427322f, -0.01952250f, -0.01914091f, 0.03187399f, 0.01872096f, 
    -0.00477721f, -0.03259982f, -0.01751822f, 0.00403079f, -0.01546031f, -0.03464245f, 0.03069390f, 0.02815713f, 
    0.03107756f, 0.00051036f, -0.02408645f, 0.01465994f, -0.03499390f, -0.03457597f, 0.00762762f, -0.00633785f, 
    -0.02123707f, -0.00404127f, -0.00163371f, 0.02034176f, -0.03705380f, -0.00552379f, -0.03466626f, 0.00241450f, 
    -0.02999957f, 0.01223946f, -0.03230578f, 0.02826736f, -0.01759318f, -0.00946556f, -0.02804638f, 0.02221224f, 
    0.01779807f, -0.02618855f, -0.02042336f, -0.01288831f, -0.01989347f, 0.03238622f, -0.00717115f, 0.00110728f, 
    -0.02149170f, 0.02479869f, 0.01206685f, -0.03980851f, -0.02670567f, -0.01699183f, 0.02029836f, 0.01963053f, 
    0.01523182f, 0.01479737f, -0.02270505f, 0.03385989f, 0.02595017f, -0.02321454f, 0.00632108f, -0.01245425f, 
    0.00656630f, 0.00657635f, 0.01147414f, -0.01910575f, 0.00293697f, -0.02648439f, 0.01112706f, 0.02885289f, 
    -0.03810055f, 0.00275580f, 0.00480719f, 0.01296823f, 0.02687967f, 0.02079163f, -0.02802624f, 0.02600000f, 
    -0.02712652f, -0.02249473f, -0.02122024f, 0.00813408f, 0.01756480f, 0.01842695f, 0.01326548f, -0.03223099f, 
    0.01771431f, -0.02319273f, -0.03834051f, 0.00278288f, -0.02270394f, -0.03730216f, 0.00315067f, 0.02136413f, 
    -0.03280954f, 0.01627525f, 0.02144220f, 0.00230945f, 0.02889887f, -0.02324868f, -0.00764936f, -0.02185640f, 
    0.01360284f, -0.01481530f, -0.02097493f, -0.00811357f, 0.00795867f, -0.03590126f, -0.02949875f, 0.01417297f, 
    0.00414800f, -0.01637654f, -0.00071678f, 0.01147373f, 0.00810841f, -0.01385480f, -0.03293933f, 0.00129680f, 
    0.01306651f, 0.01619261f, -0.02660336f, 0.02346197f, -0.01496544f, -0.03381603f, -0.03244304f, -0.01510609f, 
    -0.02612954f, 0.01575567f, 0.02028787f, 0.01966380f, -0.02526827f, -0.00184305f, -0.00428385f, -0.02147961f, 
    0.00358093f, 0.03043691f, 0.02958062f, -0.02173876f, -0.01631906f, -0.00002118f, -0.02414923f, -0.00970549f, 
    0.00287129f, 0.01854558f, 0.01294336f, -0.03501476f, 0.00973427f, 0.01439268f, -0.01012748f, -0.02348783f, 
    0.02570446f, 0.02633855f, 0.02461607f, 0.00434649f, 0.00191036f, -0.02597021f, 0.02651294f, -0.01086931f, 
    0.00354438f, -0.03105067f, 0.01291938f, 0.02092138f, 0.00983741f, -0.01687136f, -0.03314305f, 0.00848230f, 
    -0.01272635f, -0.03707737f, -0.02324699f, -0.02801601f, 0.01580982f, 0.00919299f, -0.00350830f, 0.01309281f, 
    0.00409309f, -0.00491002f, 0.00050444f, -0.02051754f, -0.01163344f, -0.00239798f, -0.00443598f, -0.01958469f, 
    0.02702724f, -0.02987545f, -0.00809213f, 0.00256591f, 0.02185431f, 0.01817339f, 0.02324012f, 0.00653019f, 
    0.00140124f, 0.00004792f, -0.02287310f, 0.02295340f, -0.00614227f, 0.00154762f, -0.01279057f, -0.03191908f, 
    0.00557298f, -0.01151355f, 0.01372268f, -0.01471487f, -0.02783000f, 0.00672967f, 0.02461463f, -0.01396262f, 
    0.03141584f, -0.00207706f, -0.01741428f, -0.01095264f, -0.00914211f, -0.02925506f, -0.01565470f, -0.03824872f, 
    -0.01289276f, -0.02584750f, 0.02852980f, -0.00276634f, -0.02474660f, -0.03322791f, 0.02855790f, -0.03512954f, 
    0.00635175f, -0.01555714f, 0.01919209f, -0.00448825f, -0.02946378f, 0.02955724f, 0.02789819f, -0.00418718f, 
    -0.02337453f, -0.03356335f, 0.01259588f, 0.01488308f, 0.00432867f, -0.02539457f, -0.01097067f, -0.03485675f, 
    0.00462623f, 0.02050534f, -0.03785775f, 0.02544321f, 0.02913737f, -0.00115382f, -0.00474733f, 0.02021375f, 
    0.00784388f, 0.02121350f, -0.03703810f, -0.02793775f, -0.01993526f, -0.03066672f, 0.01708199f, 0.00366792f, 
    0.00584756f, 0.00655234f, -0.02236884f, 0.02981522f, 0.00137617f, 0.01103866f, -0.00120374f, 0.01918635f, 
    0.00013654f, 0.00755500f, -0.03192862f, 0.01020611f, -0.02016452f, 0.03228941f, 0.00835687f, 0.00558451f, 
    -0.02504297f, -0.02050402f, -0.01085081f, -0.03839122f, 0.01795948f, -0.03638645f, -0.01084570f, -0.01683850f, 
    -0.01819869f, 0.01043301f, 0.02900519f, -0.02575421f, 0.01598311f, -0.01079982f, -0.00409932f, -0.03324635f, 
    -0.02100933f, -0.00201420f, 0.00069173f, 0.01899067f, 0.02651352f, -0.02426787f, 0.00402289f, 0.01642210f, 
    0.01102130f, 0.02852485f, -0.01959367f, -0.01882329f, 0.02050780f, 0.02776387f, 0.00146884f, 0.00033292f, 
    -0.02853551f, 0.00956707f, 0.00487248f, -0.00555388f, -0.01698087f, 0.01916887f, -0.01811321f, -0.03789277f, 
    0.02826286f, 0.00616851f, -0.02105127f, -0.02327243f, -0.00280518f, 0.00380958f, -0.00453362f, 0.03037090f, 
    -0.02672065f, 0.03396783f, -0.02498947f, 0.01156408f, 0.01254599f, -0.00027494f, -0.03196795f, 0.01712205f, 
    0.00045254f, -0.02098440f, -0.03863551f, -0.01732440f, -0.00057752f, -0.02798445f, 0.00207490f, 0.02778476f, 
    0.01138731f, 0.01720402f, -0.01795858f, 0.01067148f, 0.02159169f, -0.03302922f, -0.01326890f, 0.02580960f, 
    0.02827449f, -0.01467025f, -0.01286473f, 0.01700330f, -0.02536496f, 0.02091144f, -0.00259905f, 0.02768276f, 
    -0.03273161f, -0.00107350f, -0.01016260f, -0.03702735f, -0.03644356f, 0.00300447f, -0.03052731f, -0.00320918f, 
    -0.01665327f, -0.02900774f, -0.03408475f, -0.00292865f, 0.02988483f, -0.03706016f, 0.00764737f, 0.01230936f, 
    -0.02722254f, -0.01420246f, -0.02765206f, -0.01454688f, -0.00341371f, -0.03998632f, -0.01926229f, -0.00668348f, 
    -0.01705172f, 0.00805491f, -0.01008529f, -0.01054336f, -0.00257218f, 0.01215044f, -0.03510845f, -0.02954495f, 
    -0.02904225f, -0.01090785f, 0.03470038f, 0.00600156f, -0.00641484f, 0.00841438f, 0.01816847f, 0.01135710f, 
    -0.00347354f, -0.01474975f, 0.03041612f, 0.02238173f, 0.02968744f, 0.01596138f, 0.00108596f, 0.01370267f, 
    0.00945114f, 0.02269886f, -0.03944386f, -0.02299353f, 0.01546954f, -0.03231159f, -0.03402693f, -0.01334953f, 
    0.03199452f, 0.02873499f, -0.03522085f, 0.03182008f, -0.02409797f, 0.01135968f, -0.01734996f, -0.03346742f, 
    0.00044617f, 0.00078529f, 0.00217886f, 0.02476325f, 0.01750858f, 0.01732847f, -0.01077152f, -0.01879644f, 
    0.00233820f, -0.00077051f, 0.02367280f, 0.01477228f, 0.00807905f, 0.02421247f, -0.03836303f, 0.02052175f, 
    -0.00863362f, -0.03271882f, 0.02879871f, 0.01578013f, -0.01493827f, -0.03262072f, 0.00234050f, -0.03773720f, 
    0.02989567f, -0.01067217f, -0.00964332f, 0.01883527f, 0.02742487f, 0.03383903f, -0.02636937f, -0.02606038f, 
    0.00930191f, -0.02699675f, -0.02232831f, 0.00526068f, 0.02055765f, -0.01617511f, 0.00150046f, -0.03121052f, 
    -0.00478685f, -0.02883900f, 0.02439583f, -0.02416533f, 0.02137693f, 0.02911485f, 0.02011884f, -0.01417838f, 
    0.00041227f, -0.02653035f, -0.02860178f, 0.01644496f, -0.02847483f, -0.03272795f, 0.01812741f, -0.00994318f, 
    0.16494519f, 0.23358518f, -0.09169734f, -0.16268235f, 0.09176577f, -0.05020092f, 0.08913790f, -0.03429596f, 
    -0.02235157f, 0.10247277f, -0.05639908f, -0.07674248f, 0.21739343f, -0.40233943f, 0.19465531f, 0.07014035f, 
    -0.03524047f, 0.00604219f, 0.01138714f, -0.01433412f, -0.05877437f, 0.02099823f, 0.08737333f, 0.02945279f, 
    -0.03528586f, 0.12362174f, -0.00307634f, -0.22763063f, 0.03389946f, 0.02814034f, 0.03333418f, 0.04239468f, 
    -0.05205806f, -0.07122585f, -0.05896345f, -0.10433979f, 0.00342578f, -0.01064549f, -0.11028527f, -0.02836275f, 
    -0.03777337f, -0.06553649f, 0.05731338f, 0.00056455f, 0.05288418f, -0.13784665f, -0.07360414f, -0.08354887f, 
    0.05831904f, 0.01708214f, -0.00568867f, -0.01803779f, -0.00642474f, 0.03313386f, 0.05899740f, -0.03142357f, 
    -0.04208220f, 0.05208427f, 0.04497704f, 0.07146200f, -0.27189165f, -0.02686672f, -0.08337984f, -0.17277037f, 
    0.06028247f, 0.02669534f, 0.09189716f, -0.02072948f, 0.09954295f, 0.01318379f, -0.01805011f, -0.02589269f, 
    0.13789833f, 0.02423180f, -0.05562361f, -0.07008351f, 0.07617333f, 0.06675104f, 0.02021834f, -0.10123416f, 
    -0.08608125f, -0.04378123f, 0.06879736f, -0.05046898f, 0.51504499f, 0.09732428f, 0.01858706f, -0.00750074f, 
    -0.02236166f, -0.00134879f, 0.07775761f, -0.02283355f, 0.09527210f, 0.02763694f, 0.05364497f, 0.14065553f, 
    0.05866323f, 0.03313938f, -0.07753634f, -0.23242228f, -0.05329990f, 0.01799410f, 0.15705739f, -0.01406824f, 
    -0.00308351f, 0.05844515f, -0.26343673f, -0.03444466f, 0.15804267f, 0.11080637f, 0.05470549f, -0.01630110f, 
    -0.05506508f, -0.01510440f, 0.00830631f, 0.03912501f, -0.02164237f, 0.02585118f, -0.07320139f, 0.06669766f, 
    0.19828652f, 0.04713418f, 0.01613878f, 0.21842611f, 0.00678557f, -0.13742320f, -0.00015620f, 0.03166091f, 
    0.00941415f, -0.11092389f, 0.00109897f, -0.15402618f, 0.00744477f, 0.19142003f, 0.00482080f, 0.25469255f, 
    0.01247470f, -0.03443569f, 0.02189276f, 0.01735270f, -0.05697260f, -0.04916563f, 0.15586035f, 0.02941595f, 
    -0.02830924f, 0.09280252f, -0.06556387f, -0.17399225f, 0.03257265f, 0.08557002f, -0.04115878f, -0.07268716f, 
    0.05906519f, -0.04476545f, 0.02713743f, 0.05727321f, 0.01677238f, 0.00305382f, 0.08898588f, -0.27480587f, 
    0.03493247f, 0.00090049f, 0.02391036f, -0.03902214f, 0.05909089f, 0.07700916f, -0.02163521f, 0.04463307f, 
    0.11472172f, -0.28546008f, -0.21747738f, 0.11370105f, -0.05369596f, -0.02581147f, 0.05064718f, 0.05075229f, 
    0.00329665f, 0.10862717f, 0.07179185f, -0.04662437f, 0.06112851f, 0.09649579f, 0.01606684f, -0.05791670f, 
    0.05931712f, 0.01376266f, 0.06886802f, 0.13031274f, -0.06106572f, -0.03478803f, -0.02988373f, -0.05814475f, 
    -0.15042296f, 0.28913924f, 0.10860612f, 0.04423339f, 0.09654266f, -0.00391106f, 0.06634230f, 0.12033872f, 
    0.06279133f, -0.00199111f, 0.08002533f, 0.05685191f, -0.04387166f, 0.24738775f, 0.10609576f, 0.08069796f, 
    0.07901745f, 0.05109638f, -0.09962601f, -0.07962009f, -0.04651642f, 0.03066718f, 0.04309557f, -0.02483262f, 
    -0.04982637f, -0.24951905f, -0.01894853f, -0.11128926f, 0.10469065f, -0.07851181f, -0.01497056f, -0.02046990f, 
    -0.08284081f, 0.02422785f, -0.02983386f, 0.07746517f, -0.11141624f, -0.14177310f, -0.00763269f, 0.11303846f, 
    -0.01237154f, 0.11270336f, -0.05068606f, 0.03636573f, 0.04280332f, 0.02145121f, -0.02989614f, 0.13773353f, 
    -0.17668433f, -0.14214624f, 0.07777464f, 0.16603583f, -0.03011847f, 0.08279199f, 0.02864162f, -0.00078706f, 
    -0.09058284f, 0.01190052f, 0.01894317f, -0.00584729f, -0.07653251f, 0.07452946f, -0.14984283f, -0.00370457f, 
    0.10556214f, 0.05250314f, 0.00517712f, 0.05736075f, 0.01192992f, -0.03953813f, -0.14034703f, 0.04650302f, 
    0.28646591f, 0.07104865f, 0.28997979f, -0.02124534f, -0.09383702f, -0.02900299f, 0.05423750f, 0.09377800f, 
    0.06689448f, 0.07332199f, 0.04004968f, 0.01266885f, 0.01642409f, 0.22530419f, 0.10718731f, 0.00158169f, 
    -0.05878218f, 0.00269356f, -0.03002088f, -0.06440149f, 0.09949578f, 0.21171249f, 0.01212169f, -0.11688528f, 
    0.08121537f, 0.10246705f, 0.03019362f, -0.11451711f, -0.07665911f, 0.01484325f, 0.02192624f, 0.01545117f, 
    -0.02181001f, 0.03886357f, 0.03669331f, 0.00091361f, 0.21992263f, -0.00146375f, -0.04019000f, -0.10039594f, 
    -0.09860936f, 0.09828776f, 0.08051988f, 0.01075969f, -0.10783935f, 0.00717086f, -0.02930087f, 0.05150754f, 
    0.28642079f, -0.16071059f, -0.02904721f, 0.12478848f, 0.03750851f, -0.03457562f, -0.02843011f, -0.05769696f, 
    0.09113704f, 0.12856805f, -0.02203566f, -0.04413150f, 0.06301945f, 0.06110490f, -0.07065770f, -0.06637602f, 
    -0.05398902f, -0.09750458f, -0.03176250f, -0.11652400f, -0.01924624f, -0.07281589f, -0.04773983f, -0.13539587f, 
    -0.02223684f, 0.08812564f, 0.05924783f, -0.03051466f, 0.17174986f, -0.05123702f, -0.01785526f, 0.09268454f, 
    -0.15883856f, 0.08456408f, -0.09752987f, -0.00786647f, 0.17177851f, -0.13356143f, 0.06705041f, -0.04982803f, 
    0.01771308f, -0.00601264f, -0.13047490f, 0.07889903f, 0.06082973f, 0.02329154f, -0.09287591f, 0.04207725f, 
    0.04436280f, 0.15049893f, 0.00793376f, -0.02544681f, -0.06698138f, 0.01381303f, -0.01489301f, -0.02606304f, 
    0.01818923f, -0.00801196f, 0.12973265f, -0.06881313f, 0.33702606f, 0.03856168f, 0.10749274f, 0.01997229f, 
    0.07856956f, -0.06393006f, 0.05512016f, -0.03664650f, 0.01084413f, 0.02367671f, 0.07548847f, 0.04013279f, 
    0.42554507f, -0.09017662f, -0.16676159f, 0.01350951f, 0.02502635f, -0.09666790f, 0.02256676f, 0.03596385f, 
    -0.03403237f, 0.02573100f, 0.08888005f, 0.05108948f, 0.16616277f, -0.03740137f, -0.08316394f, 0.01095748f, 
    -0.04627622f, 0.01710636f, 0.04198948f, 0.01958190f, -0.01767989f, 0.03417381f, -0.01354144f, -0.07529192f, 
    0.11571348f, 0.02428970f, -0.21862262f, -0.25337401f, 0.06712655f, 0.03481821f, -0.05790592f, -0.02880388f, 
    -0.12628770f, -0.01430565f, 0.04234604f, -0.13686067f, 0.41173553f, -0.04863400f, 0.13414359f, 0.06911765f, 
    -0.04101159f, -0.05660599f, 0.00100117f, 0.03799528f, -0.14079888f, 0.02828976f, -0.04932242f, 0.07152335f, 
    -0.03354073f, -0.25824523f, -0.14658488f, 0.00709388f, -0.08243163f, -0.12967694f, 0.04915594f, 0.00997549f, 
    -0.04414124f, 0.09359263f, -0.03385508f, -0.04210751f, -0.04231948f, 0.14125659f, 0.00603978f, -0.11236078f, 
    0.10968231f, 0.11015128f, 0.01388412f, 0.02889281f, 0.03196396f, -0.08112822f, 0.08599480f, -0.15438239f, 
    0.15992358f, 0.20476651f, -0.05481030f, 0.23030952f, 0.09852980f, -0.06398854f, 0.15257294f, -0.13316131f, 
    -0.01238283f, 0.11856648f, 0.11640817f, 0.09022444f, 0.22929400f, -0.03951995f, -0.02718598f, 0.01928421f, 
    -0.11659963f, 0.00591282f, 0.03122087f, -0.09078500f, 0.02435737f, 0.06228561f, 0.01445895f, 0.08323355f, 
    0.20207565f, 0.09724189f, -0.04568449f, -0.06753428f, -0.09371293f, -0.05537520f, 0.05261611f, 0.04617940f, 
    -0.08959114f, 0.02368204f, -0.02826382f, -0.12754110f, 0.20461288f, 0.13352402f, -0.04310065f, 0.05092572f, 
    -0.03624483f, 0.13380159f, 0.02037067f, 0.06353878f, -0.11609863f, 0.12225886f, -0.05636639f, 0.00670374f, 
    -0.04252309f, 0.14921026f, 0.02658464f, -0.00339129f, -0.11453738f, 0.00572170f, 0.08509876f, 0.06466969f, 
    -0.09107117f, 0.07982428f, -0.04798320f, 0.07195053f, -0.06054525f, 0.09158539f, -0.08234660f, 0.00354369f, 
    0.00520741f, 0.05051241f, -0.14443634f, 0.11826409f, -0.00081930f, -0.06799594f, 0.07144781f, 0.02673134f, 
    -0.03177561f, -0.02949566f, -0.02157819f, -0.11274463f, -0.06437591f, -0.02394648f, -0.01294227f, -0.09664060f, 
    0.06374604f, 0.01513675f, 0.00528500f, -0.03678520f, 0.22929636f, -0.14546476f, -0.20741777f, 0.22897363f, 
    -0.01625548f, 0.04801160f, -0.02982216f, 0.00872578f, -0.05358142f, -0.06200227f, 0.00645055f, -0.13462196f, 
    -0.04309417f, -0.13875662f, -0.03134995f, -0.08032472f, 0.12885103f, 0.01402080f, -0.09214024f, -0.03193606f, 
    -0.03552612f, 0.02535578f, -0.11826133f, 0.02758694f, 0.12466395f, 0.11104100f, -0.06057780f, -0.04372127f, 
    -0.04227024f, 0.01415574f, 0.07124498f, -0.06411608f, 0.02365601f, -0.03546903f, -0.01715254f, -0.02871925f, 
    0.01524686f, 0.27679837f, 0.15918739f, 0.15700519f, 0.17392951f, 0.05355386f, -0.02736117f, 0.03777457f, 
    0.05964126f, 0.02830692f, -0.00063671f, 0.06346370f, -0.26149994f, -0.26080954f, -0.16106337f, -0.17353633f, 
    -0.00184334f, 0.00476753f, 0.01636668f, -0.09607381f, -0.08545489f, -0.12760220f, 0.00311354f, 0.02412400f, 
    0.03458684f, -0.01457578f, -0.11830553f, 0.00415670f, 0.05953731f, -0.01641976f, 0.06887664f, -0.01580694f, 
    -0.11377561f, 0.07547454f, -0.02278046f, -0.05300574f, -0.03231001f, -0.19772950f, 0.12242814f, 0.00909972f, 
    0.01393376f, -0.01652930f, -0.05191775f, 0.01713616f, -0.11210597f, 0.02792841f, 0.04671105f, 0.01669709f, 
    -0.00185852f, 0.05723664f, 0.02274102f, 0.15489557f, 0.04881302f, -0.03976719f, -0.01276361f, 0.02187170f, 
    -0.04715798f, 0.07838275f, -0.05915609f, 0.04233178f, 0.00801355f, 0.01378854f, 0.03174722f, -0.02063830f, 
    0.11498223f, 0.06938807f, -0.01400564f, 0.17844300f, 0.06074557f, -0.06587356f, 0.14017175f, -0.11552701f, 
    0.06974092f, -0.00780415f, 0.11633221f, 0.05195215f, -0.04825443f, 0.02146203f, 0.02525474f, -0.01397393f, 
    -0.06469483f, -0.06755362f, -0.09144805f, -0.02964529f, 0.18663289f, 0.08613521f, 0.07204808f, -0.06000212f, 
    0.01817474f, 0.01856801f, 0.08105653f, 0.04296833f, -0.01336782f, 0.07032277f, 0.00062916f, 0.02534180f, 
    0.33010483f, 0.13304076f, -0.06928163f, -0.02961624f, 0.04305328f, -0.05441396f, 0.08279828f, -0.07546419f, 
    0.03427763f, 0.09264918f, -0.00187920f, 0.04247290f, 0.21852525f, 0.08099777f, -0.01917205f, -0.08282494f, 
    0.04230765f, -0.04547725f, -0.00549581f, 0.01531990f, -0.03371981f, 0.13698657f, -0.07665198f, 0.06482586f, 
    0.06929713f, 0.09122641f, -0.15326640f, -0.02646877f, 0.02332569f, 0.01803212f, 0.02453575f, 0.05933472f, 
    -0.10745785f, -0.10238309f, -0.10951793f, -0.09693737f, -0.00004925f, -0.21242665f, -0.10631365f, 0.27221549f, 
    0.11520907f, 0.10896520f, -0.05541089f, 0.09841447f, 0.06537600f, -0.03856809f, 0.16026604f, -0.03195377f, 
    -0.08949759f, 0.02655620f, -0.03673720f, -0.16304396f, -0.05686525f, 0.09095840f, -0.01777729f, -0.10093451f, 
    -0.09282013f, -0.01449454f, 0.11707378f, -0.03091645f, 0.01862682f, 0.17417271f, -0.17083965f, -0.13876821f, 
    -0.00051250f, -0.02670788f, 0.05596513f, 0.01293702f, 0.02448644f, 0.04145092f, -0.05119848f, -0.00435714f, 
    0.14172611f, 0.11943329f, 0.03606987f, -0.08007328f, -0.07499799f, 0.02222051f, -0.07992844f, -0.11088336f, 
    0.08224547f, -0.00047785f, -0.06006600f, 0.05567350f, -0.10514869f, 0.19943231f, 0.05677918f, -0.02167659f, 
    -0.11705616f, 0.07144260f, -0.07451908f, -0.00929082f, -0.01622303f, -0.03652384f, 0.03066955f, 0.05724528f, 
    -0.01512009f, -0.00366176f, -0.01187336f, 0.00298606f, 0.01695380f, -0.01881067f, 0.01206169f, 0.04271363f, 
    -0.02616425f, -0.02722351f, -0.03586100f, -0.03915309f, -0.01405811f, 0.01506197f, -0.01085623f, 0.01519014f, 
    0.01140714f, -0.02745857f, 0.01257852f, 0.01588933f, -0.04008450f, -0.01591829f, -0.00914582f, 0.02126964f, 
    -0.03094145f, 0.01050636f, -0.03036778f, 0.01916410f, -0.00847783f, 0.02491760f, -0.01713757f, -0.00418670f, 
    0.01705800f, 0.00831399f, -0.00650338f, 0.00742676f, -0.03937108f, -0.01501658f, 0.02432075f, 0.02140963f, 
    -0.04421167f, 0.00417685f, -0.00266690f, -0.03744991f, -0.00445525f, 0.00166575f, -0.02069704f, -0.02798784f, 
    -0.02432065f, 0.00036291f, -0.02193096f, 0.00628654f, 0.00760799f, -0.02182643f, -0.02878830f, 0.01231392f, 
    -0.03477704f, -0.02582109f, -0.02874580f, 0.01328661f, -0.02106461f, -0.02032212f, -0.00986345f, -0.02239280f, 
    0.02892337f, -0.03051012f, 0.00272989f, 0.02987337f, -0.03108568f, -0.04306953f, -0.02763027f, -0.02936091f, 
    -0.03645745f, 0.01457913f, 0.00223566f, 0.01678045f, 0.02136333f, 0.02342178f, 0.01316643f, -0.02989606f, 
    -0.01668691f, 0.00103897f, -0.00297717f, -0.00308172f, 0.01699940f, 0.00243013f, 0.02607640f, 0.00665538f, 
    -0.01469584f, 0.02203911f, -0.04193358f, -0.02105928f, 0.01998525f, 0.02407900f, 0.01344851f, -0.00042454f, 
    -0.01087440f, 0.02068826f, -0.02391491f, -0.04075053f, -0.01158332f, -0.00565727f, 0.01184324f, -0.02384018f, 
    -0.04078931f, -0.00902087f, 0.01463940f, -0.03222955f, -0.00922720f, 0.01898896f, 0.01362187f, 0.01936701f, 
    0.00174247f, -0.02670912f, 0.00395066f, 0.02107609f, -0.01790419f, -0.02815836f, 0.01507621f, 0.00989718f, 
    -0.02461648f, 0.01362215f, 0.00620124f, -0.01090404f, -0.02063403f, -0.03394318f, -0.02799728f, 0.01442506f, 
    -0.00435339f, 0.00916291f, 0.00151422f, -0.00572792f, -0.00251421f, -0.00443671f, 0.00684054f, -0.02678360f, 
    0.01202763f, -0.04305554f, -0.03795965f, 0.00486114f, 0.01211363f, -0.02377322f, -0.04284965f, -0.03632496f, 
    0.01136683f, 0.01094181f, -0.00113636f, -0.00951774f, -0.03178790f, -0.02814382f, 0.00680447f, -0.00541363f, 
    -0.04146253f, -0.03055110f, -0.02278384f, 0.01744607f, 0.00758331f, -0.00725470f, -0.02459317f, 0.01276913f, 
    -0.00001362f, -0.02120468f, -0.02399795f, -0.03907784f, -0.00098705f, 0.02270659f, 0.02562931f, -0.03840720f, 
    -0.00962432f, 0.02586135f, 0.00434181f, -0.01953541f, 0.00637180f, -0.00547989f, -0.01717974f, -0.01555886f, 
    -0.03492637f, 0.00977730f, -0.02557031f, -0.03991998f, 0.01204202f, -0.02896830f, -0.04220866f, 0.03936676f, 
    0.00692153f, -0.00206227f, -0.01133329f, 0.01229936f, -0.00154683f, 0.00367622f, -0.02573242f, -0.01097077f, 
    -0.02885742f, -0.02854541f, -0.04210729f, -0.00797400f, -0.01437558f, -0.03562398f, -0.00198373f, 0.01808642f, 
    -0.01157754f, -0.02044172f, -0.01720525f, 0.01088971f, 0.03021611f, -0.02881625f, -0.02690143f, -0.00869853f, 
    -0.02642733f, -0.01339089f, -0.04384833f, -0.02390883f, 0.01995761f, 0.00390585f, -0.00219558f, -0.02632226f, 
    0.03933780f, 0.01821991f, -0.03731004f, -0.00109372f, -0.01622845f, 0.01115591f, -0.00719397f, -0.00880860f, 
    0.02353258f, 0.00087172f, -0.01805614f, -0.01665984f, -0.01691735f, -0.02199684f, -0.03335410f, 0.02614883f, 
    0.00783372f, 0.02336653f, -0.02206678f, -0.00651346f, 0.01105350f, -0.01099564f, -0.03715452f, 0.00913624f, 
    -0.02421947f, -0.03843244f, 0.01364724f, -0.01754565f, 0.01878974f, 0.01159975f, 0.02736805f, -0.04281906f, 
    -0.04403998f, -0.01953415f, -0.00617767f, -0.01974646f, 0.00215066f, 0.01885017f, -0.01147729f, 0.02267200f, 
    -0.03307213f, 0.02188369f, -0.03332424f, -0.03810985f, -0.04140136f, 0.02176184f, -0.02891567f, 0.01808929f, 
    -0.01447092f, -0.00517161f, -0.00294348f, 0.02766648f, -0.02945701f, 0.02204001f, 0.00236856f, 0.01300299f, 
    -0.00786991f, 0.02135513f, 0.00880797f, -0.01842752f, 0.00767619f, -0.03553228f, -0.01888552f, -0.03421799f, 
    -0.04071736f, -0.02941098f, -0.02801602f, 0.00789657f, -0.00113898f, 0.00795269f, -0.02039745f, 0.00516572f, 
    -0.01949442f, 0.01014927f, -0.00960876f, -0.00172188f, 0.02567511f, -0.01528997f, 0.00444461f, 0.01506787f, 
    -0.03766058f, 0.00755450f, -0.00488533f, -0.03124580f, -0.03808783f, 0.00125469f, -0.02633343f, -0.03108297f, 
    0.00310347f, -0.02941362f, -0.03592441f, -0.03089709f, 0.00859202f, -0.03681158f, 0.00413882f, -0.03511640f, 
    0.00453278f, 0.02217633f, 0.01355380f, -0.03744742f, -0.01263548f, 0.02345166f, 0.01883818f, 0.02364008f, 
    -0.00732308f, -0.03386093f, -0.00252505f, -0.01381882f, -0.03031710f, -0.00256098f, 0.00673971f, -0.01071642f, 
    -0.01377885f, -0.02521593f, -0.01379232f, -0.00360799f, -0.03109222f, 0.00011526f, -0.00110533f, -0.01341224f, 
    0.01976372f, -0.01171369f, 0.02365338f, 0.02014321f, 0.02135313f, -0.02573466f, -0.00962512f, 0.02955663f, 
    -0.00323196f, 0.01823019f, -0.02857786f, 0.02237526f, -0.00418821f, -0.02809314f, -0.01840867f, 0.01129815f, 
    -0.04255285f, 0.01887823f, -0.02404254f, -0.03899730f, 0.02385500f, -0.00131123f, 0.02877583f, 0.02554244f, 
    0.01730484f, 0.00829274f, -0.03097510f, -0.01113363f, -0.01265076f, 0.00309269f, -0.01202684f, 0.01911395f, 
    -0.02652986f, -0.01247956f, 0.00539451f, -0.03658310f, 0.01087653f, 0.02374438f, 0.00960067f, -0.03381312f, 
    -0.01593266f, 0.00270147f, -0.01251146f, -0.04067243f, 0.00636607f, -0.01838787f, -0.02532738f, -0.02023545f, 
    -0.02873783f, -0.02433333f, -0.01331880f, 0.02488167f, -0.02670417f, 0.01208305f, 0.00949979f, 0.01621764f, 
    -0.04259930f, -0.04076273f, -0.02258133f, 0.02427042f, -0.01358171f, 0.01245314f, -0.01262132f, 0.00931908f, 
    0.00548790f, -0.04114402f, -0.00810602f, -0.00214480f, 0.01176971f, -0.02751263f, 0.02575265f, 0.00035537f, 
    -0.00686998f, -0.02667717f, -0.02747707f, 0.00578870f, 0.01850565f, -0.02185986f, -0.00144066f, -0.02017310f, 
    0.02188483f, 0.02710964f, 0.00078449f, -0.02345281f, 0.01088789f, -0.00167225f, -0.02379846f, 0.01532816f, 
    -0.03158615f, -0.03698472f, 0.01647790f, 0.00233836f, 0.02731756f, 0.00825859f, -0.01721002f, 0.01378970f, 
    0.02623681f, 0.02630687f, 0.00735181f, 0.02478350f, -0.03265617f, 0.01663207f, -0.02952301f, -0.03714531f, 
    -0.02466937f, -0.03271922f, -0.01493764f, -0.01052337f, 0.01824844f, 0.01206401f, -0.01242699f, 0.02307879f, 
    -0.02018905f, 0.00502290f, 0.00159371f, -0.03584671f, -0.03553385f, -0.00032775f, 0.00660200f, 0.01956933f, 
    -0.00809402f, 0.00333652f, -0.01422642f, -0.01499403f, 0.00246345f, -0.02832587f, -0.02139600f, 0.02409660f, 
    -0.00133287f, -0.01693370f, 0.02718217f, -0.03770526f, -0.01205515f, -0.03062653f, 0.01783698f, -0.01102073f, 
    0.01235432f, 0.00848094f, -0.02056887f, 0.01716084f, 0.01035355f, -0.02842420f, 0.02741415f, 0.00929117f, 
    0.00908653f, 0.01559427f, 0.00147093f, 0.02637073f, -0.04163456f, -0.00174773f, 0.02001428f, -0.00017291f, 
    -0.03658643f, 0.01625671f, -0.03279477f, -0.00521646f, -0.02183852f, -0.02012575f, 0.02741113f, -0.01154721f, 
    -0.02582152f, 0.02622399f, 0.00854798f, -0.01147241f, -0.01116866f, -0.01951590f, 0.00094969f, -0.01563880f, 
    0.01083460f, 0.00730702f, 0.00413136f, -0.03477656f, -0.00658833f, 0.00903885f, -0.01104836f, 0.02332831f, 
    0.00692203f, 0.00913506f, -0.04195698f, -0.01039897f, -0.00924971f, 0.01925862f, 0.02700835f, -0.00259696f, 
    -0.03549306f, 0.00812451f, -0.03644607f, -0.00501405f, -0.03083294f, 0.02127010f, -0.00504435f, 0.01197522f, 
    0.01082937f, 0.00616317f, 0.00261474f, -0.02852791f, -0.00865892f, -0.01804064f, 0.02561561f, 0.02661496f, 
    0.02488649f, 0.00455747f, 0.02565425f, 0.00630771f, 0.00590759f, -0.03646985f, -0.00280088f, -0.03882463f, 
    -0.00664320f, -0.00984798f, -0.02885556f, 0.02049122f, -0.02803213f, 0.00768284f, 0.02781182f, 0.01693296f, 
    -0.04247438f, 0.01875751f, 0.01942875f, -0.03430109f, -0.02322325f, 0.02488195f, -0.03555978f, -0.00585979f, 
    -0.03520714f, 0.01686699f, -0.04003862f, 0.00133736f, -0.03588238f, 0.01206963f, 0.00281757f, -0.03496920f, 
    -0.04037235f, 0.02046960f, -0.00500092f, 0.00096569f, -0.00033675f, 0.02474420f, 0.00688480f, 0.00447527f, 
    -0.02949902f, 0.00480506f, -0.02895488f, -0.04017669f, -0.02040346f, -0.02703053f, -0.01959233f, -0.01442841f, 
    -0.01771099f, -0.00030391f, -0.02516529f, -0.00953135f, -0.00105577f, 0.02206817f, -0.03285743f, -0.02574831f, 
    0.01946399f, -0.04066288f, 0.00518663f, 0.00211920f, -0.00109121f, -0.04056352f, 0.02285170f, 0.01080653f, 
    -0.03775362f, 0.01847940f, -0.02070953f, -0.03939264f, -0.01722613f, 0.01755043f, -0.01079890f, -0.03353508f, 
    -0.00657851f, -0.03491516f, -0.01748507f, -0.03089010f, -0.01274193f, 0.00014586f, -0.03301428f, -0.02397798f, 
    -0.03642749f, -0.00178910f, -0.02860842f, -0.04041160f, 0.01820637f, 0.01668447f, -0.00616391f, -0.01436158f, 
    -0.02543458f, 0.00506034f, 0.01453767f, 0.01688481f, -0.00757671f, 0.00689895f, 0.01614694f, -0.00256736f, 
    -0.02720511f, 0.00856603f, 0.00075099f, 0.01586729f, -0.04226891f, -0.03492909f, -0.00540569f, -0.03810463f, 
    0.02540091f, 0.02289276f, -0.03627104f, -0.01934725f, 0.01222753f, -0.00447350f, -0.00254182f, 0.01156995f, 
    0.00786910f, -0.02758182f, 0.01462025f, 0.00342116f, 0.02401915f, -0.03102435f, 0.00600226f, 0.01886835f, 
    0.02391234f, -0.03072619f, 0.01679835f, 0.01524095f, -0.03108699f, -0.01157617f, 0.01851751f, -0.04214805f, 
    0.02443159f, -0.00702791f, 0.00683928f, 0.00300902f, 0.00636381f, -0.02004112f, -0.01614737f, -0.02085340f, 
    -0.03048732f, 0.01124999f, 0.01694030f, -0.01510465f, -0.01541965f, -0.01501723f, -0.01932102f, -0.01695305f, 
    -0.02223819f, 0.00544491f, 0.02001525f, -0.03619364f, 0.02572867f, -0.00922386f, -0.04120279f, -0.04221558f, 
    0.00716770f, -0.00750325f, -0.04077179f, -0.00498200f, -0.03652849f, -0.02325509f, -0.01126915f, 0.02486570f, 
    -0.02692219f, 0.00550642f, -0.04294820f, -0.02652194f, -0.03579014f, -0.00760128f, -0.03013410f, 0.01019335f, 
    -0.02207197f, -0.01530196f, -0.02920800f, 0.01826464f, -0.01213981f, 0.00734790f, -0.03133306f, 0.02443994f, 
    -0.04034986f, -0.03917036f, -0.00569034f, 0.02775290f, 0.01258536f, -0.03827797f, 0.00675335f, -0.03224200f, 
    -0.02952109f, -0.03867218f, -0.01828311f, -0.03792398f, -0.01268046f, 0.01356481f, 0.00358771f, 0.01605035f, 
    0.01530906f, -0.01834075f, 0.01529217f, -0.00194650f, 0.00229421f, -0.00702021f, 0.01624360f, -0.03187271f, 
    -0.00267894f, -0.02801731f, -0.00235696f, -0.00240444f, -0.01378741f, -0.02674162f, -0.03000569f, 0.02075528f, 
    0.00817656f, 0.00673107f, -0.03814721f, 0.00121073f, -0.04408165f, -0.02926833f, -0.01455008f, -0.02116284f, 
    -0.01521302f, -0.02644051f, -0.04249005f, 0.01797031f, -0.01091215f, -0.00997397f, -0.03799680f, 0.01873315f, 
    0.01243073f, 0.02375595f, 0.01383802f, 0.00483456f, -0.02431433f, 0.00344679f, 0.00673207f, 0.00831177f, 
    -0.04056528f, 0.01615332f, 0.04091794f, 0.02111594f, -0.02508324f, -0.02701026f, 0.01478059f, 0.00053140f, 
    -0.00190890f, -0.02191518f, -0.02516395f, 0.00564337f, -0.01494612f, 0.02309891f, -0.02391102f, -0.00091730f, 
    -0.02449906f, 0.01464980f, -0.03114032f, 0.02203265f, 0.01880811f, 0.02360093f, -0.00912197f, 0.03383106f, 
    0.00507732f, 0.02456428f, -0.03995100f, -0.01802924f, 0.00983915f, -0.00341737f, 0.02841070f, 0.00659060f, 
    -0.00195702f, 0.00539447f, 0.00275218f, 0.01169629f, 0.01924089f, -0.04175723f, 0.01963224f, -0.03305223f, 
    -0.00035327f, -0.01190238f, 0.01263576f, -0.03520757f, 0.01586174f, 0.00571944f, -0.03086530f, -0.00214288f, 
    -0.00558238f, 0.02152401f, -0.02047157f, -0.03801234f, 0.01342780f, -0.01834358f, 0.02353000f, -0.03705557f, 
    0.01391076f, 0.00441435f, -0.00553827f, 0.02139918f, -0.00842295f, -0.02972066f, -0.00078303f, 0.01600523f, 
    -0.00478421f, -0.02616342f, -0.03097667f, -0.03247286f, 0.00182801f, -0.03633428f, -0.00073765f, -0.01860810f, 
    0.01429887f, -0.00718450f, 0.01224071f, 0.00844909f, -0.01079657f, -0.02824583f, -0.00542301f, -0.01442581f, 
    0.01943581f, 0.02408914f, -0.02079155f, -0.01801723f, -0.03005340f, -0.01876392f, -0.02915725f, 0.00099149f, 
    0.00656233f, 0.01469979f, -0.00128693f, -0.01172769f, -0.01521437f, -0.01291800f, -0.02749573f, -0.00393039f, 
    -0.04205793f, 0.02568884f, -0.03903195f, 0.02357363f, 0.01700460f, -0.00665825f, 0.02080953f, 0.01919679f, 
    -0.00675150f, -0.03731302f, -0.00476048f, 0.01724217f, -0.00845148f, 0.02391468f, 0.02436497f, 0.01746825f, 
    0.01299743f, -0.00618926f, 0.02136737f, 0.01766919f, -0.01357149f, 0.00306146f, 0.00835323f, -0.02587612f, 
    -0.01808280f, -0.02275975f, 0.02280674f, -0.03114034f, 0.01522452f, -0.01111853f, -0.00881196f, 0.00658089f, 
    -0.02915123f, 0.02030111f, -0.00167292f, 0.00849547f, -0.01867469f, 0.02053019f, 0.02839552f, -0.02021958f, 
    -0.02202020f, 0.00889242f, -0.00428358f, 0.01060769f, 0.02051347f, -0.03089965f, 0.01639759f, 0.00058722f, 
    -0.02531876f, 0.00697956f, -0.03066270f, -0.03547961f, -0.03832259f, -0.03654260f, -0.00290027f, -0.02025506f, 
    -0.02027943f, -0.03181000f, 0.03379595f, -0.02568009f, -0.01434650f, -0.01012400f, -0.03562896f, -0.00112025f, 
    -0.02643428f, 0.01240604f, 0.01675096f, -0.01210353f, -0.02502742f, -0.02773808f, -0.00342850f, 0.02496753f, 
    -0.01824046f, 0.02070225f, 0.03300676f, 0.00713801f, -0.02041789f, -0.03134220f, -0.02439309f, 0.02239100f, 
    0.01256314f, 0.01395355f, -0.01328566f, -0.03768848f, 0.01945431f, 0.02863161f, 0.00161185f, 0.01113312f, 
    0.01597219f, -0.03786483f, 0.02795403f, 0.02413149f, -0.03689275f, 0.01835845f, -0.00701020f, 0.03243895f, 
    0.02163321f, 0.02466368f, 0.02609878f, 0.00918606f, 0.02718059f, -0.00989961f, -0.01194283f, -0.03892308f, 
    -0.02397845f, 0.02188025f, 0.01711069f, 0.00966519f, 0.01626825f, 0.00273612f, 0.00789422f, -0.02482397f, 
    -0.02258612f, -0.04175232f, -0.00939316f, -0.01688270f, 0.02659888f, -0.02162830f, -0.03860331f, 0.00146288f, 
    0.01721792f, 0.01814329f, 0.03684340f, -0.03373731f, -0.03994435f, 0.00365095f, -0.02627376f, -0.02700857f, 
    0.00521436f, 0.01511058f, 0.01967667f, -0.01310500f, 0.00504410f, 0.01253886f, -0.02505515f, 0.00922860f, 
    -0.02159064f, -0.01499878f, -0.01504792f, -0.01062335f, 0.01611360f, -0.01036934f, 0.01092297f, 0.03235317f, 
    -0.02815714f, 0.01405952f, -0.03128864f, -0.02171713f, -0.00726181f, 0.00011973f, -0.00479802f, 0.00496215f, 
    -0.00548196f, -0.00272810f, 0.00315827f, 0.00833518f, -0.01001903f, -0.03159539f, 0.00982224f, 0.00851122f, 
    -0.00547414f, 0.02535294f, 0.01265769f, 0.02472195f, 0.00518142f, -0.00625875f, 0.01565438f, -0.01365555f, 
    -0.00041105f, 0.00924650f, 0.02817238f, -0.00078166f, -0.00651409f, 0.01040201f, -0.00695655f, 0.02224656f, 
    0.00133643f, 0.00071115f, 0.03010604f, 0.01676349f, -0.03526266f, 0.00970306f, -0.00320199f, -0.03444989f, 
    -0.01438776f, -0.00704894f, -0.01334485f, -0.00987237f, -0.00516483f, -0.00924002f, -0.02669520f, 0.02393149f, 
    0.03209668f, 0.01920011f, -0.02885022f, 0.01506173f, -0.02840726f, 0.02580904f, -0.01015044f, -0.02899024f, 
    -0.01809090f, 0.02248435f, -0.01141414f, -0.02406387f, -0.04025342f, -0.02637123f, -0.01056669f, 0.02578438f, 
    0.01474832f, -0.01479760f, 0.00818807f, -0.01772112f, 0.02590410f, 0.02709039f, -0.00454132f, -0.02779457f, 
    -0.00764009f, 0.00487422f, 0.01462376f, 0.00664691f, 0.02144719f, -0.00983001f, 0.00926282f, -0.03832100f, 
    -0.02725046f, 0.02338238f, 0.01746478f, -0.03440681f, -0.03783247f, -0.02538975f, -0.03362860f, 0.02764693f, 
    0.00658217f, -0.03205990f, -0.00347233f, -0.01978721f, 0.02185989f, -0.03438902f, -0.00947527f, -0.02664440f, 
    0.01601560f, -0.01891613f, -0.01792551f, 0.01688865f, 0.01369667f, 0.02311120f, -0.02266974f, 0.01276724f, 
    -0.02176166f, -0.03831023f, -0.00252235f, 0.01859431f, 0.02814255f, -0.00714584f, -0.02362265f, 0.01181213f, 
    -0.04196862f, -0.02700245f, -0.01056809f, 0.00884261f, -0.03227350f, -0.03896120f, 0.00879448f, 0.02287409f, 
    -0.02585290f, -0.02548224f, 0.01859536f, -0.03777533f, -0.03058477f, 0.01098901f, -0.00276680f, 0.01697114f, 
    -0.02213610f, 0.00526559f, 0.00947531f, -0.03232235f, -0.00604171f, 0.00801160f, -0.03064241f, 0.00714496f, 
    -0.03608251f, -0.00112908f, 0.02238896f, -0.03319366f, 0.03472963f, 0.01795581f, -0.02485532f, -0.00876012f, 
    -0.01480615f, -0.04121299f, -0.01592530f, 0.01214352f, 0.03062948f, 0.01814500f, -0.01474455f, -0.02901091f, 
    -0.00571935f, -0.00904582f, 0.01563231f, 0.01561294f, 0.00550626f, 0.00112953f, 0.02370420f, 0.02226573f, 
    -0.03004531f, 0.00362164f, -0.00481742f, 0.00332143f, -0.03685257f, -0.03409061f, -0.04020752f, -0.02767419f, 
    -0.01906329f, -0.01735047f, 0.01620655f, -0.00238654f, 0.01972644f, 0.01906327f, 0.02477319f, -0.01242935f, 
    0.01090961f, -0.00993124f, 0.02957770f, 0.01212205f, -0.01722822f, -0.02973029f, 0.01325673f, 0.00082970f, 
    -0.04189182f, -0.00832778f, -0.03093335f, -0.01481986f, -0.01823740f, 0.01659970f, 0.00760335f, 0.01407691f, 
    0.01823612f, 0.01852290f, -0.00051722f, -0.02847233f, 0.02995895f, 0.00892897f, -0.01162354f, 0.00199405f, 
    -0.03600717f, 0.00526363f, -0.00153004f, 0.01698123f, 0.01727147f, -0.03699076f, -0.01458343f, -0.03971220f, 
    -0.01729435f, 0.00753920f, 0.02986577f, -0.00175196f, -0.03615182f, 0.01562031f, -0.02573448f, -0.01943618f, 
    -0.03851274f, 0.00819517f, 0.00003493f, -0.04225555f, 0.02637053f, 0.02907320f, 0.01041711f, -0.00092850f, 
    -0.00335220f, 0.01998569f, -0.02434540f, 0.00166510f, -0.00146092f, -0.01366413f, -0.03175071f, -0.02044732f, 
    0.01914541f, -0.01686606f, 0.00228599f, -0.03470345f, -0.01118575f, 0.00643454f, -0.02062157f, -0.01783547f, 
    0.02054035f, -0.03486310f, -0.01448937f, -0.02871633f, 0.00461206f, -0.02921639f, -0.00432790f, -0.02890704f, 
    -0.02744096f, -0.03479318f, -0.02640932f, -0.02272596f, 0.01507121f, -0.01059981f, -0.01868276f, 0.01505196f, 
    -0.01667287f, -0.01685556f, 0.00895288f, -0.02673825f, 0.00068372f, -0.02372469f, 0.01169051f, 0.00751509f, 
    0.00858074f, -0.00855388f, -0.00418233f, 0.01031156f, -0.00123950f, -0.02576338f, -0.02469976f, 0.02559788f, 
    0.02010729f, -0.02540946f, 0.00913944f, -0.03205878f, 0.00651716f, -0.00329037f, 0.00563352f, -0.02810987f, 
    0.02047016f, -0.04017777f, 0.02674129f, -0.03162228f, 0.02519668f, 0.02658165f, -0.03342069f, -0.03779424f, 
    0.01902456f, -0.00856364f, 0.02901949f, -0.00428229f, -0.00938132f, -0.01183828f, 0.00485451f, 0.03334051f, 
    -0.00853863f, -0.02993904f, -0.03544794f, -0.01060260f, 0.00425929f, -0.04073380f, -0.01612767f, 0.01659573f, 
    0.00029396f, -0.01237854f, -0.01905797f, -0.02700519f, -0.00310027f, 0.00915291f, -0.01290361f, 0.03541110f, 
    0.02118547f, -0.03702320f, 0.01438285f, 0.01744814f, 0.00087882f, -0.04254056f, 0.01818577f, 0.02253421f, 
    0.01007669f, -0.02879057f, 0.00119564f, -0.00322379f, -0.03713200f, 0.01330554f, -0.02610174f, 0.00256540f, 
    0.02836589f, 0.01488668f, -0.02914430f, 0.01515650f, -0.03340863f, 0.02492357f, -0.03167225f, -0.04209793f, 
    0.01106548f, -0.03735799f, -0.03042754f, -0.03852517f, 0.02409557f, -0.03803251f, -0.01854639f, 0.01645010f, 
    -0.02526643f, -0.03982140f, -0.00526971f, 0.00291320f, 0.02763013f, 0.02586003f, -0.03322747f, 0.02810157f, 
    -0.03586294f, -0.03530189f, -0.00106810f, -0.00406894f, -0.02396991f, -0.02520614f, -0.03009933f, -0.03617181f, 
    -0.03131513f, 0.02109388f, -0.03351736f, -0.03135476f, 0.00045099f, -0.02719613f, -0.02530462f, 0.01263338f, 
    -0.01974654f, -0.03577182f, 0.00819005f, 0.01850602f, 0.00132622f, -0.00129497f, 0.03980992f, 0.00125555f, 
    0.02506590f, -0.03009554f, 0.00135575f, -0.03666123f, 0.00918338f, 0.02448433f, -0.03335981f, 0.01274144f, 
    0.02299969f, 0.00121166f, -0.02916761f, -0.00699703f, 0.01922050f, 0.00725614f, 0.01044992f, -0.03982527f, 
    -0.02040554f, -0.03084282f, 0.02672362f, -0.02477893f, 0.00551596f, -0.00831638f, -0.00779538f, -0.02799729f, 
    -0.01113750f, -0.01140600f, -0.00224206f, 0.02502638f, 0.02623360f, -0.01088869f, -0.00255642f, 0.03111871f, 
    0.01132376f, 0.01258735f, 0.02427672f, 0.00580497f, -0.00575717f, -0.02378003f, 0.01116424f, 0.00461669f, 
    0.03158661f, -0.01908285f, -0.02912306f, -0.03406814f, 0.02216571f, -0.01425170f, -0.03402288f, 0.00779584f, 
    0.02160673f, 0.02581510f, -0.01039768f, -0.01404903f, -0.00965834f, 0.01805413f, 0.00134119f, 0.02389821f, 
    -0.03679756f, -0.02835213f, -0.01862755f, -0.03879312f, 0.02418139f, -0.01211673f, 0.02718561f, 0.01499356f, 
    -0.00611032f, -0.01357956f, 0.02692448f, -0.03406527f, -0.00573205f, 0.01918066f, -0.00528312f, -0.03839229f, 
    0.01311246f, -0.02133881f, -0.01163625f, -0.00962883f, 0.01394130f, 0.01660100f, 0.03206435f, 0.00798047f, 
    -0.00394508f, 0.00106320f, -0.03937365f, -0.03918444f, -0.02821776f, -0.02536395f, -0.02961288f, 0.00644658f, 
    0.03050413f, -0.02268651f, 0.01478414f, 0.00099511f, -0.02088017f, -0.01779128f, -0.00433618f, -0.01061396f, 
    -0.03800270f, -0.00652105f, -0.02145474f, -0.02800345f, -0.00273901f, 0.02396410f, -0.02260730f, 0.00823495f, 
    -0.02924556f, -0.00887744f, -0.00152959f, -0.03468324f, -0.03466523f, 0.02215867f, -0.02519690f, 0.01061363f, 
    -0.02291032f, 0.02377073f, -0.02601216f, 0.01697046f, 0.00038851f, 0.02695948f, 0.01623018f, 0.02309495f, 
    -0.01865789f, 0.01041798f, -0.01911921f, 0.00839136f, -0.03105916f, -0.00888375f, 0.00221573f, -0.01374944f, 
    0.02083403f, 0.03006405f, 0.01394926f, 0.02831025f, -0.00252343f, 0.01237382f, 0.02453017f, 0.00293955f, 
    -0.01482653f, -0.02147743f, 0.02291178f, -0.01445549f, -0.03573823f, 0.02648697f, -0.00027031f, -0.04034509f, 
    0.02972279f, 0.02276925f, 0.00957460f, -0.00362825f, 0.02173145f, 0.00850119f, 0.02726301f, -0.02301120f, 
    0.11907534f, 0.06369363f, 0.08363092f, 0.08198821f, -0.14358938f, 0.08166400f, 0.02207240f, 0.07523639f, 
    0.04785606f, -0.03798851f, 0.01913005f, 0.04752317f, 0.01549289f, 0.15301135f, -0.04567744f, 0.05515797f, 
    -0.15831293f, 0.07951036f, 0.01499960f, -0.07748407f, 0.05618721f, -0.03595313f, 0.04521216f, 0.03151140f, 
    0.41340342f, -0.10312674f, 0.06097794f, 0.05161902f, -0.03889082f, 0.02432288f, 0.00316659f, 0.00928047f, 
    -0.02389015f, -0.04355660f, 0.00100293f, 0.06312590f, -0.11496907f, -0.08824152f, 0.13048190f, 0.14610830f, 
    0.00711713f, -0.04351892f, 0.09526249f, -0.04124418f, 0.09859481f, 0.04640692f, -0.01842304f, -0.00452931f, 
    -0.02110670f, -0.09670062f, 0.02802650f, 0.12074260f, -0.05369852f, -0.11241990f, 0.07658523f, 0.02854920f, 
    -0.01168723f, -0.04641313f, -0.02227308f, -0.06924668f, 0.04194688f, 0.11871319f, 0.04274162f, 0.18717816f, 
    -0.11382873f, -0.05140035f, 0.00925211f, -0.01350136f, -0.05314936f, -0.03548238f, 0.02380312f, -0.04839240f, 
    -0.21471956f, 0.06948409f, 0.12507747f, 0.22453925f, -0.05567033f, -0.16246198f, 0.02877433f, 0.03542116f, 
    0.02684026f, 0.05378197f, -0.09252124f, 0.01944452f, -0.14353272f, -0.00706782f, -0.15805060f, 0.19662470f, 
    -0.11483541f, -0.09983108f, -0.04599877f, -0.02607132f, -0.02119158f, 0.02302643f, 0.04209711f, -0.07237551f, 
    0.01595901f, -0.03526798f, 0.14922607f, 0.07386056f, 0.06621229f, 0.03714817f, 0.10878423f, -0.03779651f, 
    0.07710461f, 0.05775018f, -0.01166713f, 0.13766871f, 0.17005588f, 0.02667385f, -0.02905609f, -0.20092840f, 
    0.10424184f, 0.05774514f, 0.00152812f, -0.03631783f, 0.09260242f, -0.00451847f, 0.06655158f, 0.05714606f, 
    -0.16039218f, -0.06003604f, 0.17231335f, -0.06410026f, 0.02720754f, 0.05484528f, 0.10860677f, -0.07536457f, 
    0.02974747f, 0.02435391f, 0.08124202f, 0.00078008f, -0.14859678f, -0.10975820f, 0.05494517f, 0.09433874f, 
    -0.02923466f, 0.01625938f, 0.11651434f, -0.02301577f, 0.08711456f, -0.03694374f, -0.02175729f, -0.06620019f, 
    0.17707315f, 0.11238153f, 0.01976470f, 0.19954844f, -0.03100481f, -0.05316706f, 0.05237133f, 0.08598230f, 
    -0.04431819f, 0.07924204f, -0.04719044f, 0.01387366f, 0.21697968f, -0.04889008f, -0.07564522f, 0.14242946f, 
    -0.06755849f, 0.00148162f, 0.09825432f, -0.03126411f, 0.09478459f, -0.01006288f, 0.07474889f, 0.03734851f, 
    -0.05019249f, 0.07006603f, 0.12540619f, 0.05163993f, -0.08128135f, 0.05015638f, -0.01893093f, 0.04819462f, 
    -0.10895195f, 0.03461788f, 0.06139079f, 0.03246135f, 0.15998711f, 0.07411170f, -0.00815618f, 0.01222018f, 
    -0.09641023f, 0.06915543f, -0.07447305f, 0.06768579f, 0.06213026f, 0.02336450f, -0.11468150f, 0.04297466f, 
    0.10558853f, 0.01724632f, -0.19313286f, -0.06103864f, 0.03206983f, 0.08478545f, -0.08908530f, 0.03245316f, 
    -0.02441331f, -0.03826591f, -0.03277256f, 0.00005969f, 0.11155349f, 0.09507572f, 0.10418564f, 0.09046659f, 
    -0.03469290f, -0.02930518f, -0.01951220f, -0.01520274f, -0.00012103f, -0.01304963f, 0.02280740f, 0.10941775f, 
    -0.13181780f, 0.18789893f, 0.21362469f, 0.05667457f, -0.07787044f, 0.02235991f, 0.00256265f, -0.05095537f, 
    0.02644457f, -0.06422538f, -0.13141505f, -0.05535628f, -0.08007366f, 0.15178815f, 0.06043140f, 0.22089076f, 
    0.02065342f, -0.01833274f, 0.03640031f, -0.02183541f, 0.01049435f, 0.00253236f, -0.04134250f, 0.00667443f, 
    -0.04404268f, -0.08304363f, 0.04583625f, -0.11139510f, 0.08060138f, 0.02844281f, 0.02265263f, -0.08849311f, 
    0.03017194f, -0.05217452f, 0.01578879f, -0.09397800f, 0.00603017f, 0.04076007f, 0.16896571f, -0.06231940f, 
    -0.02254309f, 0.04728783f, -0.02928677f, 0.02015987f, 0.12549706f, 0.18220209f, 0.05902333f, -0.02084547f, 
    -0.13581994f, 0.33479476f, -0.03728093f, -0.13150950f, 0.04653127f, 0.10980698f, 0.06876545f, -0.14194986f, 
    -0.00413659f, 0.04115038f, -0.01599860f, -0.05116782f, 0.14947656f, 0.03169398f, -0.05470353f, -0.02890527f, 
    -0.00982583f, -0.01946894f, 0.13549511f, 0.00838356f, 0.00490382f, -0.03420031f, -0.04454650f, 0.02641216f, 
    -0.01351701f, 0.18571366f, 0.07271667f, -0.15951267f, 0.08154885f, 0.05337954f, -0.00974381f, -0.10433514f, 
    0.00495098f, 0.03781681f, -0.00104319f, 0.04603467f, 0.11004814f, 0.28210616f, 0.10111401f, 0.01633433f, 
    0.16442320f, 0.10206358f, 0.01173753f, 0.01902151f, 0.16003811f, 0.03999473f, -0.08165736f, 0.04180780f, 
    -0.12434451f, -0.20668782f, 0.10561521f, 0.01634984f, -0.05079985f, -0.00134149f, 0.10167590f, -0.05590513f, 
    -0.08999134f, 0.02183497f, 0.05079360f, -0.05011621f, -0.08219872f, -0.01994049f, 0.18798466f, 0.08749066f, 
    0.00180339f, 0.02424329f, -0.01631794f, 0.16850276f, -0.06315156f, 0.04094288f, 0.07712297f, 0.14135589f, 
    0.14123978f, 0.22347257f, 0.13679484f, 0.09919754f, -0.11190668f, 0.01983686f, -0.08758930f, -0.02228720f, 
    0.04137430f, -0.01610767f, 0.00104562f, 0.07483575f, -0.17770965f, 0.02607697f, -0.02987743f, -0.04571173f, 
    -0.00011346f, 0.01717008f, 0.04346002f, -0.14146285f, 0.14769129f, 0.04904773f, 0.03627713f, 0.10129121f, 
    0.05450325f, -0.12556921f, 0.02968821f, 0.03960393f, -0.07796768f, 0.00170754f, -0.07814940f, 0.04719866f, 
    0.01201707f, -0.06128135f, -0.06626515f, 0.01453434f, -0.25127509f, 0.05463814f, 0.19345436f, -0.15034418f, 
    0.06245598f, 0.03283989f, 0.08195357f, -0.01433194f, 0.02809862f, -0.01416127f, -0.03392939f, 0.01330910f, 
    -0.05269426f, -0.04869396f, 0.00659234f, 0.14438245f, -0.04511518f, -0.05227618f, 0.06141064f, -0.06842698f, 
    -0.01940339f, -0.04153452f, 0.00075082f, -0.03140434f, -0.18479829f, 0.02873699f, 0.15477659f, 0.16121888f, 
    0.06108522f, -0.10226671f, 0.00078902f, -0.02635203f, -0.02055822f, -0.04253314f, 0.03630016f, 0.07590287f, 
    0.12255414f, -0.06339169f, 0.05086054f, 0.15274316f, -0.01061809f, 0.06650142f, -0.08557951f, 0.13815369f, 
    -0.05948466f, -0.01235174f, -0.08738612f, 0.01155785f, 0.11184473f, 0.17364262f, 0.04036221f, 0.06370189f, 
    0.04887544f, -0.07479441f, 0.00588476f, -0.08319632f, 0.01466455f, 0.03283798f, 0.06608433f, 0.00274400f, 
    0.04655910f, 0.05553680f, 0.06820620f, 0.09273129f, 0.04855435f, 0.00093829f, -0.03660376f, -0.03461965f, 
    0.08004924f, 0.08037277f, 0.09415256f, 0.05725113f, 0.25974575f, -0.10488724f, 0.12233949f, 0.16993913f, 
    0.00475736f, 0.01809668f, 0.04055842f, -0.08875059f, -0.02952423f, 0.05406073f, 0.04055795f, -0.02207145f, 
    -0.12636203f, 0.00170157f, 0.13396277f, 0.06716029f, 0.04078051f, -0.03668618f, -0.06221687f, 0.01607622f, 
    -0.00194670f, -0.04960776f, -0.05410271f, 0.01403633f, -0.35857439f, 0.10004512f, 0.19938038f, -0.00431336f, 
    0.05597113f, 0.03867367f, -0.05868244f, -0.02401835f, 0.00406379f, 0.03169800f, 0.06445113f, 0.02393647f, 
    -0.04803097f, 0.07114220f, -0.07022564f, -0.13683663f, 0.08605932f, 0.01527816f, 0.06502907f, -0.02210370f, 
    0.09828439f, 0.07516536f, -0.02818999f, 0.00929514f, 0.14388201f, -0.03641492f, -0.13572839f, 0.30164155f, 
    0.01901602f, 0.05990916f, -0.06800249f, -0.02557366f, 0.03293462f, -0.04212699f, -0.02506629f, -0.04016217f, 
    0.08287358f, -0.09807447f, 0.07344637f, -0.11455011f, 0.05637462f, 0.02078592f, 0.05448631f, 0.10862999f, 
    0.01297351f, 0.00054901f, 0.05427427f, 0.02798693f, 0.15816988f, 0.11852992f, 0.15505086f, -0.07889339f, 
    0.11517740f, -0.05438057f, 0.10227544f, 0.03249588f, -0.01376511f, 0.03629948f, 0.02624513f, 0.00901117f, 
    -0.13629305f, 0.07442755f, 0.06809048f, 0.18023115f, 0.00612133f, -0.11994938f, -0.03942817f, -0.01709251f, 
    0.03254880f, 0.00265249f, 0.05321680f, -0.03106246f, -0.33878514f, -0.19956286f, 0.22355072f, -0.05513748f, 
    0.12142623f, 0.03179529f, 0.02215727f, 0.01999503f, 0.09564020f, -0.02245996f, -0.07807895f, 0.06456020f, 
    0.09875052f, 0.04706721f, 0.12160322f, 0.05985839f, -0.03784326f, -0.03334199f, 0.01846047f, -0.03659502f, 
    0.02079355f, 0.04212430f, 0.01172571f, -0.06989050f, -0.12819047f, 0.01060324f, 0.03808360f, -0.03570564f, 
    0.05913900f, 0.06169722f, -0.03901289f, -0.00909760f, 0.08704280f, -0.00774907f, -0.04388563f, 0.03048683f, 
    0.22991510f, -0.06255906f, 0.04983357f, -0.15265109f, -0.07449080f, -0.04534206f, 0.08164428f, -0.04322214f, 
    -0.00334851f, 0.03542806f, -0.06933996f, 0.05418719f, 0.42963371f, 0.05883535f, 0.23784600f, 0.20819756f, 
    -0.21536666f, 0.03288073f, -0.00855125f, 0.05886570f, 0.00897159f, 0.04958037f, 0.08586457f, -0.01278505f, 
    0.03261681f, -0.03835951f, -0.06990540f, 0.20552729f, 0.04595953f, -0.04935437f, 0.17050245f, 0.09439636f, 
    0.01180611f, -0.01510209f, -0.11378753f, 0.03198284f, -0.02374818f, 0.07743202f, 0.15771593f, -0.01690812f, 
    0.01400769f, -0.07927097f, 0.05847473f, -0.05901375f, 0.06340539f, -0.03382306f, -0.06031819f, 0.01953735f, 
    -0.30572644f, 0.09834339f, 0.16815785f, -0.10368200f, 0.07520074f, 0.04711613f, -0.01197330f, 0.02601174f, 
    -0.00510415f, 0.00920284f, -0.06469636f, 0.05584111f, -0.17436741f, 0.12138519f, 0.04999486f, -0.09309342f, 
    0.05055417f, 0.00219830f, 0.06244313f, -0.07143436f, 0.02811987f, 0.05262744f, -0.03697712f, 0.16778459f, 
    0.07476297f, 0.05228445f, 0.05457706f, -0.11021144f, -0.03168013f, -0.01692580f, -0.03888965f, 0.02928256f, 
    0.05111333f, 0.03772600f, 0.04922746f, -0.02024842f, -0.01460841f, 0.13124120f, 0.16398032f, -0.04061612f, 
    0.00951649f, 0.05521205f, 0.04777016f, -0.05197974f, -0.08498634f, 0.02043620f, 0.07944523f, -0.06095570f, 
    -0.01278923f, -0.04344725f, -0.18058701f, -0.00486707f, 0.01203637f, -0.11112572f, 0.05873740f, -0.03471252f, 
    -0.00181129f, -0.00021266f, 0.09553372f, -0.03656175f, 0.03774263f, 0.13375178f, -0.10877542f, 0.19399817f, 
    -0.02902838f, 0.01864780f, -0.01333233f, 0.05963852f, -0.03397140f, 0.00073476f, -0.03191835f, -0.05712939f, 
    0.06453135f, -0.04658026f, 0.09583296f, 0.12413478f, 0.02207693f, 0.13406359f, 0.06402723f, -0.02455278f, 
    -0.03777156f, -0.01691074f, 0.08847392f, 0.07341338f, -0.13171135f, 0.13799061f, 0.19819228f, -0.10234548f, 
    -0.04123928f, 0.01887446f, -0.05458403f, 0.11774697f, -0.02084430f, -0.02118012f, -0.03278283f, -0.02096750f, 
    -0.02621824f, -0.02066460f, 0.16416442f, 0.15922795f, -0.12972756f, 0.03429822f, 0.07497910f, 0.05097901f, 
    0.00402466f, -0.01255113f, -0.07765420f, -0.02658466f, 0.17205976f, 0.05893848f, 0.01580183f, 0.12212201f, 
    -0.00451594f, -0.04488395f, 0.02539929f, 0.04711341f, -0.02604515f, -0.01088097f, 0.02959339f, 0.00698303f, 
    -0.02797485f, 0.09597055f, -0.13929316f, -0.10923149f, 0.00397840f, 0.03841184f, 0.04068981f, 0.00337143f, 
    -0.06978577f, 0.02525738f, -0.09271768f, 0.06621816f, -0.15876421f, -0.11580057f, -0.00876378f, 0.06684051f, 
    0.00181931f, -0.05266079f, -0.00803186f, -0.01270656f, 0.02788707f, 0.02771537f, 0.04758414f, 0.13086481f, 
    0.01798394f, -0.02859459f, -0.01929849f, -0.01729354f, -0.01303162f, 0.00544295f, -0.02217548f, -0.02261347f, 
    0.02546591f, -0.03764496f, 0.00504014f, -0.01061817f, 0.00300447f, -0.00308683f, -0.02652473f, -0.00598056f, 
    0.02713444f, 0.00391883f, 0.01323634f, -0.02948877f, -0.01354758f, 0.01747080f, 0.01649522f, 0.02661142f, 
    0.02137795f, -0.01365294f, 0.01181624f, -0.03756560f, -0.02085369f, 0.02557828f, -0.01083844f, -0.02233123f, 
    0.02631069f, -0.03214660f, -0.01655304f, -0.03962705f, 0.02164064f, -0.02345529f, 0.00576085f, 0.02272032f, 
    -0.03619771f, 0.02631401f, 0.01494252f, 0.01639587f, 0.01412420f, 0.01600439f, 0.01267634f, -0.01786235f, 
    0.01739925f, -0.01610249f, -0.03366011f, 0.01350551f, 0.00517697f, 0.02547682f, -0.03321557f, -0.03525501f, 
    -0.01078224f, -0.00239279f, 0.01040464f, -0.04324449f, -0.00479605f, -0.03914323f, -0.00733812f, -0.01143744f, 
    0.00882753f, 0.00153042f, -0.01837043f, -0.03318990f, 0.01571689f, 0.00857618f, -0.02132233f, -0.00327537f, 
    -0.03383155f, 0.00539135f, -0.02762765f, 0.01718559f, -0.03309651f, -0.04019819f, -0.02519681f, -0.04102059f, 
    0.02181762f, -0.04148866f, 0.01099723f, 0.01647412f, 0.01216220f, 0.00404245f, -0.01357371f, -0.03695347f, 
    0.02347238f, -0.02207217f, 0.00204904f, 0.01855234f, -0.01618631f, 0.03040061f, 0.00940369f, 0.01455307f, 
    -0.02850042f, -0.00042477f, 0.01980598f, 0.02642192f, -0.02364945f, 0.00363532f, -0.02010349f, -0.02140136f, 
    0.00398306f, -0.01385009f, -0.03390019f, 0.02606286f, -0.02792787f, -0.00761746f, 0.02929739f, 0.02154991f, 
    -0.02665844f, 0.02808566f, -0.00724011f, 0.01293238f, 0.01933332f, -0.00755096f, 0.00411110f, 0.02642631f, 
    -0.00255836f, -0.03469251f, -0.03108040f, 0.03119086f, -0.01651386f, -0.01939793f, 0.02259352f, 0.01140023f, 
    0.02090032f, 0.00087788f, -0.02244765f, -0.03948480f, -0.00970713f, 0.02193072f, -0.02082594f, -0.03338592f, 
    -0.03916831f, 0.00109463f, 0.00261919f, 0.01534673f, 0.02899792f, -0.02159990f, 0.02547482f, 0.00513728f, 
    -0.01031172f, -0.02186288f, 0.01251997f, -0.01286523f, 0.00944233f, -0.00725823f, 0.00446667f, -0.03682942f, 
    0.00153620f, -0.01127236f, -0.00443931f, -0.03558138f, -0.00659609f, -0.03285877f, 0.02159034f, 0.03324665f, 
    -0.02542036f, -0.03285714f, 0.01003444f, 0.00910042f, 0.00879921f, -0.03847219f, -0.03159790f, 0.02087947f, 
    -0.02614546f, -0.01087117f, -0.00582325f, -0.00953596f, -0.02232570f, 0.01846014f, 0.00214879f, 0.02401223f, 
    0.00060006f, -0.03366917f, 0.00740880f, -0.01465185f, -0.03789091f, 0.02330937f, -0.03241854f, -0.02286678f, 
    0.01359941f, -0.02707765f, -0.01032226f, -0.00331106f, 0.01780990f, 0.02239977f, 0.01574888f, -0.01407775f, 
    -0.03110329f, 0.00521657f, -0.01977545f, -0.02438125f, -0.02271700f, -0.02473810f, 0.00122539f, 0.02842320f, 
    0.00648837f, -0.03653736f, -0.02895918f, 0.01138330f, 0.02861767f, 0.02099488f, -0.02744469f, 0.00512457f, 
    0.00753672f, 0.00074893f, 0.01996932f, 0.01385599f, -0.03306265f, 0.00061310f, 0.02015904f, -0.01332592f, 
    -0.03750916f, 0.01730326f, 0.00666464f, -0.02979093f, -0.02402747f, 0.00892986f, 0.02868330f, -0.03135480f, 
    0.02153675f, -0.03616843f, -0.01950241f, -0.01937603f, 0.01816868f, -0.02581563f, 0.02017330f, -0.03774074f, 
    0.02487015f, 0.00171698f, 0.02251290f, -0.03484698f, 0.01912543f, -0.00306341f, -0.03101592f, -0.00911461f, 
    -0.01390809f, 0.03006353f, 0.02062084f, -0.03450740f, -0.01200206f, 0.01099810f, -0.02220931f, -0.03755337f, 
    0.02352724f, 0.02712008f, -0.02157351f, -0.03565703f, 0.02959667f, -0.03142623f, 0.02232979f, -0.01636583f, 
    0.00692877f, 0.00070873f, -0.02246374f, 0.03067838f, 0.00852163f, 0.02446492f, 0.00670934f, 0.00848571f, 
    -0.02502826f, -0.01289196f, 0.02481853f, -0.02165809f, 0.02307075f, -0.01396615f, -0.02776206f, 0.02995040f, 
    0.02362981f, -0.00279278f, 0.02117858f, -0.00903050f, -0.00304791f, -0.04033092f, -0.01550720f, -0.01117689f, 
    0.00053848f, 0.00901434f, -0.00323989f, -0.01366471f, 0.00640707f, -0.01497936f, -0.01193486f, -0.04053143f, 
    0.02246137f, 0.02104360f, 0.03003960f, -0.00130161f, -0.00704113f, 0.00625816f, 0.02854903f, 0.02308388f, 
    -0.02540284f, 0.02182646f, -0.02443155f, 0.00729633f, -0.00715692f, -0.02650655f, 0.02999388f, 0.00130018f, 
    -0.02692888f, -0.02262309f, -0.00502306f, -0.02259411f, -0.00908454f, -0.00744198f, -0.00400131f, -0.00187009f, 
    0.02287240f, 0.02406824f, 0.01001229f, 0.00834490f, 0.00465124f, 0.00443656f, -0.02151699f, 0.01017471f, 
    0.00538690f, 0.00941313f, 0.02218214f, 0.01801089f, -0.02028618f, 0.00163505f, -0.02993763f, -0.00002249f, 
    -0.03147787f, -0.01738252f, -0.00001187f, 0.01846954f, -0.02109519f, 0.01515167f, 0.03132768f, 0.00052925f, 
    0.01387459f, 0.00599093f, 0.00015970f, -0.01734102f, -0.00617487f, 0.01567286f, -0.01755008f, 0.01670084f, 
    -0.01748753f, 0.00077858f, 0.01243988f, -0.00912341f, -0.02355071f, 0.01557148f, 0.01613106f, 0.00392143f, 
    -0.02082507f, 0.00594887f, -0.03399442f, -0.01925849f, -0.02037293f, 0.02783296f, -0.01650955f, -0.03388547f, 
    -0.02884351f, 0.01955115f, 0.02236809f, 0.02696389f, 0.01635037f, -0.00893397f, -0.02407914f, -0.00566892f, 
    0.02491461f, 0.02716410f, 0.02137689f, 0.00451605f, -0.03478622f, 0.02190604f, -0.02686081f, -0.03476805f, 
    0.01377240f, -0.01742538f, 0.01262273f, 0.00927434f, -0.00154086f, -0.01643535f, -0.00031083f, -0.01062885f, 
    0.01404589f, 0.02757791f, 0.01992279f, -0.00573151f, -0.00276412f, -0.00996638f, -0.02610395f, 0.00868588f, 
    0.02152863f, 0.01483061f, 0.01950405f, 0.01285267f, 0.02825373f, 0.02299743f, -0.00481448f, -0.02007057f, 
    -0.01353100f, 0.00923473f, -0.00621997f, -0.01280409f, 0.00912630f, -0.04187069f, -0.03897941f, 0.00029813f, 
    -0.03482009f, -0.03713005f, -0.00306974f, -0.01811802f, -0.02125283f, -0.01923099f, -0.02234431f, -0.03063040f, 
    -0.00711601f, -0.00988575f, 0.02763960f, -0.01514837f, 0.00743714f, -0.04096748f, -0.01298032f, 0.01919451f, 
    -0.03286260f, -0.01575463f, 0.01331621f, -0.01387091f, -0.01709015f, 0.01865353f, -0.02040972f, -0.00024594f, 
    -0.01029132f, -0.03509397f, 0.01482995f, -0.00572276f, -0.02826400f, -0.00931345f, -0.03928944f, -0.04372961f, 
    0.02217521f, 0.02286058f, 0.01688903f, 0.00836539f, -0.02756387f, 0.01695994f, 0.00789886f, -0.00346242f, 
    0.00356004f, 0.00287918f, -0.02509483f, 0.02532511f, -0.02463442f, 0.01808066f, -0.00213667f, 0.00020285f, 
    -0.04098244f, 0.00138872f, -0.02468604f, 0.00512218f, 0.01116576f, -0.01584320f, 0.01160764f, 0.00903333f, 
    -0.00425912f, 0.01927203f, 0.02185082f, 0.03206965f, 0.02852595f, -0.02172500f, 0.00471305f, -0.04300544f, 
    -0.02641682f, -0.01177087f, 0.01103575f, 0.01015939f, 0.00091726f, -0.02119940f, -0.02576335f, 0.00998820f, 
    -0.01258328f, -0.03624235f, -0.02931387f, -0.01417837f, -0.00235544f, 0.02278946f, -0.00356795f, -0.02853689f, 
    -0.02645626f, -0.02603387f, -0.02977631f, 0.00882965f, 0.02158266f, -0.01970245f, 0.01625379f, -0.00297785f, 
    -0.02245174f, 0.00206686f, -0.00997592f, -0.01661591f, 0.02359145f, 0.00629308f, -0.01560974f, -0.00858181f, 
    -0.00771591f, -0.01445494f, 0.01584735f, -0.01455931f, -0.02890754f, -0.02993487f, -0.00283186f, -0.01044983f, 
    -0.04124133f, 0.00270924f, -0.01853495f, -0.01043016f, 0.01351777f, -0.00846638f, -0.01816355f, -0.00401013f, 
    0.01650544f, 0.01897654f, -0.00696160f, -0.02779235f, -0.00685611f, -0.01371868f, -0.04064000f, 0.02303671f, 
    0.01441398f, 0.00139156f, 0.00109524f, 0.03343647f, -0.00263257f, -0.02031462f, -0.02603821f, 0.00882938f, 
    0.02856956f, 0.01856833f, -0.02824533f, -0.04013323f, 0.02845900f, -0.00990496f, 0.01520894f, 0.03416998f, 
    -0.03723597f, 0.02913435f, 0.02975100f, 0.01650964f, 0.01202329f, -0.01418999f, 0.00571394f, -0.03501002f, 
    0.02358072f, -0.02709004f, -0.04045034f, -0.01067241f, 0.01455060f, 0.00004880f, 0.00461616f, 0.00707014f, 
    -0.03697378f, 0.01778690f, -0.03611891f, -0.00353617f, -0.02522667f, 0.01623687f, 0.02047041f, -0.01306606f, 
    -0.02220856f, -0.00829091f, -0.04167064f, 0.02645533f, -0.02636559f, -0.02026104f, 0.01624473f, 0.00182935f, 
    -0.02676190f, 0.02757773f, -0.03414271f, 0.00435534f, 0.01414732f, 0.01721934f, -0.00380367f, -0.03194183f, 
    0.02142771f, 0.01553037f, 0.01946396f, -0.00443544f, 0.02414603f, 0.01989613f, 0.00098051f, -0.03170279f, 
    -0.00732220f, -0.00814526f, -0.03432308f, -0.00511346f, -0.02953509f, 0.01625636f, -0.03521694f, 0.00211041f, 
    -0.01932148f, -0.00259494f, 0.01887564f, 0.01002119f, -0.02777144f, -0.03542402f, 0.01261501f, -0.00324185f, 
    -0.00748808f, -0.02836427f, 0.02888114f, 0.01626530f, 0.02686574f, -0.03877670f, 0.01266936f, 0.02001087f, 
    -0.01555842f, -0.03155890f, 0.02213298f, -0.02207972f, 0.00497350f, -0.00554459f, 0.00490888f, 0.00144253f, 
    -0.03262186f, 0.02012959f, -0.01184719f, 0.00685663f, -0.00765650f, -0.01616205f, 0.00123783f, 0.00236490f, 
    -0.02753416f, 0.00792206f, -0.04157775f, -0.00795534f, 0.00529173f, -0.01751318f, 0.01210503f, 0.02628037f, 
    0.01298503f, 0.02740426f, -0.01535184f, 0.02257225f, -0.00875261f, 0.01006595f, 0.02258613f, 0.01341665f, 
    -0.04186208f, -0.03690388f, 0.01935444f, -0.01293098f, -0.02237364f, 0.01268743f, -0.04040807f, -0.03353533f, 
    -0.01471952f, -0.00751711f, -0.02478467f, -0.04257613f, -0.01099415f, 0.00107034f, -0.00156186f, -0.03071452f, 
    0.01789527f, 0.00335917f, -0.01554779f, 0.02802231f, -0.02075622f, 0.02666547f, 0.00031083f, 0.00101996f, 
    -0.03631210f, -0.04083763f, 0.00521246f, 0.00231201f, -0.03690023f, -0.02888703f, 0.02327613f, 0.02038378f, 
    0.01056322f, -0.00398682f, 0.03197221f, -0.02505707f, -0.00073632f, 0.01136657f, 0.00802476f, 0.01895333f, 
    -0.01562067f, -0.04249835f, -0.00806480f, 0.01185011f, -0.00673066f, -0.02769673f, -0.02933276f, -0.01452177f, 
    0.00487146f, -0.00660999f, -0.01387563f, -0.00550084f, -0.00306406f, -0.00708964f, 0.01080108f, -0.00938891f, 
    -0.03517728f, 0.00466781f, 0.01010332f, -0.03094987f, -0.01080062f, -0.00789711f, -0.03291948f, -0.03977597f, 
    -0.00677214f, 0.02464236f, 0.02177690f, 0.01621079f, -0.01062564f, 0.02995333f, -0.02072075f, 0.00044346f, 
    -0.00343686f, 0.01090690f, -0.01182506f, 0.00494518f, 0.00588397f, 0.02491469f, -0.02142723f, -0.04314059f, 
    -0.02766392f, 0.02548578f, 0.02526002f, 0.00539745f, -0.00893110f, -0.00515685f, 0.00953029f, 0.02515046f, 
    0.00864857f, 0.01370483f, -0.02223511f, 0.02131124f, 0.02650563f, -0.00457032f, -0.02121900f, 0.01572799f, 
    -0.00323097f, 0.00827827f, -0.02476564f, 0.01038791f, -0.01388255f, -0.01780722f, -0.03390779f, 0.00643043f, 
    0.02553735f, -0.03296330f, 0.02089803f, -0.01083408f, 0.02025990f, -0.00540598f, -0.03001508f, -0.00130948f, 
    -0.00781620f, -0.01522952f, 0.00817112f, 0.02080545f, 0.00914043f, -0.01589688f, 0.00752174f, -0.00585097f, 
    -0.02722057f, -0.02018066f, 0.00787246f, -0.03207960f, -0.01649619f, 0.01204550f, 0.01465661f, -0.01618228f, 
    0.01421676f, 0.00841870f, -0.03781197f, -0.01925567f, 0.02086334f, -0.03375933f, -0.00360474f, 0.01430018f, 
    -0.02024845f, 0.02552665f, 0.02846064f, -0.00929664f, 0.01968920f, -0.03707135f, -0.01806618f, 0.02352002f, 
    0.02697578f, 0.02575455f, -0.02493541f, 0.00446121f, -0.00111578f, -0.03360729f, -0.00574311f, 0.01934366f, 
    0.02503831f, -0.01269093f, -0.01065658f, -0.01391347f, 0.02082108f, 0.02301265f, -0.00118495f, 0.02411204f, 
    -0.03639662f, -0.00678859f, -0.02269485f, -0.02983352f, -0.00099967f, -0.03833919f, 0.00755201f, -0.00821138f, 
    -0.02726405f, -0.02198996f, 0.02916824f, -0.01718831f, -0.01241105f, -0.01236246f, -0.00533673f, -0.02635297f, 
    -0.00372577f, -0.03937995f, -0.00522684f, 0.00692570f, -0.02575081f, 0.02619475f, 0.01390738f, -0.01942592f, 
    0.01792950f, -0.01468732f, -0.01441843f, 0.02502645f, -0.01534603f, -0.00952521f, 0.00944817f, -0.01766256f, 
    0.02064047f, -0.01550190f, 0.02453819f, 0.01344544f, 0.01504051f, -0.01522432f, 0.01430730f, -0.02246629f, 
    -0.02048288f, -0.02153601f, 0.02968781f, -0.01157294f, -0.03924852f, 0.00653995f, -0.02327374f, 0.01277577f, 
    0.01001680f, 0.00081032f, -0.00834978f, -0.02824984f, -0.02027771f, 0.01102223f, 0.00867784f, 0.02499380f, 
    0.01510340f, 0.01470365f, 0.01083067f, -0.02738046f, -0.04007727f, 0.02866977f, 0.00214873f, -0.00116663f, 
    -0.00058872f, -0.01153276f, 0.00856319f, 0.01128926f, -0.00541874f, 0.00594936f, 0.00057658f, 0.01801830f, 
    -0.02686832f, -0.00558515f, -0.02699640f, -0.04121065f, 0.00571351f, -0.00275326f, 0.01225828f, 0.02585994f, 
    -0.03882103f, -0.01997861f, -0.02235384f, 0.02223627f, -0.03074396f, -0.02723792f, 0.00094474f, 0.00182528f, 
    -0.02777835f, -0.02154423f, -0.03043784f, 0.01526835f, 0.01569246f, 0.00120034f, -0.02351601f, 0.02630052f, 
    -0.01555358f, -0.00525226f, -0.02551080f, 0.01160184f, 0.00016480f, 0.00252015f, -0.03007838f, -0.03021075f, 
    -0.02885692f, 0.02946708f, -0.03189949f, -0.03664359f, -0.00261649f, -0.02953818f, 0.01765084f, 0.02509488f, 
    -0.00975421f, 0.01767206f, -0.01241732f, 0.01062644f, -0.01826469f, 0.01597255f, -0.02129559f, -0.01168019f, 
    -0.02872579f, -0.01241409f, -0.00265353f, -0.01915401f, 0.00708561f, 0.02476776f, 0.00453213f, -0.03304633f, 
    0.01012964f, 0.01252180f, 0.02965806f, 0.01901642f, -0.04088063f, 0.02120794f, -0.02486604f, -0.00178348f, 
    -0.02934225f, -0.01813835f, -0.03603527f, 0.00418410f, -0.00765705f, 0.00671116f, -0.00660612f, -0.02300302f, 
    0.01905954f, -0.01578885f, -0.01838015f, 0.00655825f, -0.02444323f, 0.00270338f, 0.00366911f, -0.03390049f, 
    -0.02776935f, 0.02387065f, -0.00587838f, 0.01820161f, -0.02993656f, 0.02526116f, 0.01929082f, 0.01340243f, 
    -0.02713109f, -0.01515961f, -0.02991148f, -0.00180792f, 0.01583323f, 0.00344576f, -0.00420854f, -0.04182510f, 
    -0.03852737f, -0.03274764f, 0.00735419f, 0.01805860f, -0.00536791f, -0.00855233f, -0.03450774f, 0.01926388f, 
    0.00188890f, -0.03550258f, -0.02826096f, 0.00502289f, -0.03762674f, 0.02524005f, -0.03595223f, 0.01148020f, 
    -0.01735744f, -0.00471399f, -0.01364462f, 0.00606190f, -0.01625936f, 0.01274467f, -0.02241710f, 0.02460687f, 
    0.01326942f, -0.00293469f, -0.04074374f, -0.00693712f, -0.03899455f, -0.02702558f, 0.01905366f, -0.02492830f, 
    0.00139129f, -0.02493651f, -0.02573106f, 0.02725253f, 0.02437265f, 0.01934256f, 0.02507515f, 0.02667174f, 
    -0.01199616f, 0.02805981f, 0.00176333f, 0.00368178f, -0.01589853f, -0.03013114f, 0.02068121f, -0.00746218f, 
    -0.01076660f, 0.01784359f, -0.02659216f, 0.01481310f, 0.00960733f, 0.02771174f, -0.03783561f, 0.00342330f, 
    -0.02438160f, 0.01064446f, -0.02940652f, 0.00695210f, -0.00611211f, -0.02629722f, -0.00320591f, -0.01947572f, 
    -0.03064285f, -0.04092252f, 0.00077717f, 0.00082286f, -0.03737911f, -0.01395800f, 0.01550461f, -0.02074870f, 
    -0.01553165f, -0.02676890f, -0.00594081f, -0.02054301f, -0.03597003f, 0.02176688f, -0.02173142f, -0.00995653f, 
    0.01407065f, -0.00945641f, 0.00939199f, -0.01335041f, -0.01745684f, -0.00423475f, 0.00622606f, 0.00839997f, 
    0.01872047f, 0.00240205f, 0.01774843f, -0.02523418f, -0.02194900f, -0.03855349f, -0.02001796f, -0.02662538f, 
    0.02096078f, -0.00101567f, -0.01102949f, -0.03433737f, -0.02052792f, -0.04192839f, -0.02142583f, -0.00817935f, 
    0.02222157f, -0.01039282f, -0.01430493f, 0.00803545f, 0.00408664f, -0.02098661f, 0.00954555f, 0.00820027f, 
    0.02414983f, 0.02821779f, 0.01490488f, -0.00535356f, -0.03677581f, -0.03750800f, -0.00536331f, 0.02663613f, 
    -0.00359911f, -0.00560529f, -0.00694511f, 0.01751441f, -0.03168155f, -0.01444420f, -0.00950269f, -0.02727739f, 
    -0.01343734f, -0.00180459f, -0.03284927f, -0.02679251f, -0.03784369f, -0.03670149f, 0.01538940f, 0.02005333f, 
    -0.02704366f, -0.03527120f, -0.01209530f, 0.00235603f, -0.02483582f, 0.00086946f, 0.00248685f, 0.00618393f, 
    -0.04021219f, 0.00827084f, -0.03208730f, -0.01163515f, -0.00836817f, 0.01291422f, -0.02652328f, 0.02659435f, 
    0.02997076f, -0.02304875f, 0.02725410f, 0.00622679f, -0.01324744f, 0.02957684f, -0.02079563f, 0.01405128f, 
    0.00543960f, 0.01639861f, -0.03601572f, 0.00471643f, -0.03657067f, 0.00021406f, 0.00302748f, 0.01028050f, 
    -0.02157377f, 0.01864276f, 0.00011689f, -0.00620856f, -0.01317922f, 0.00188480f, -0.02165151f, -0.03190541f, 
    0.01699826f, 0.00017411f, -0.03270358f, -0.03039416f, 0.01716254f, 0.02392328f, -0.01277778f, 0.02398020f, 
    0.00035030f, 0.01684781f, 0.01705618f, 0.02496652f, 0.02877880f, 0.01519269f, 0.02108659f, 0.00831110f, 
    -0.00325124f, -0.00449238f, -0.01765746f, -0.03658918f, -0.03061122f, -0.02424666f, -0.02337253f, -0.03763457f, 
    0.02562671f, 0.02380282f, -0.03943592f, -0.04159337f, 0.01430724f, -0.03539392f, 0.01720080f, -0.00640721f, 
    0.00103311f, -0.00067433f, -0.01967829f, -0.03730112f, -0.03381699f, -0.04071547f, -0.00015331f, -0.01453898f, 
    -0.03574331f, -0.01854159f, -0.00335458f, -0.02060262f, -0.00761712f, 0.01544875f, -0.03430644f, -0.02632077f, 
    -0.00377556f, -0.02211097f, 0.02703236f, -0.00031796f, -0.04097960f, -0.00042936f, 0.02366300f, 0.02346021f, 
    -0.02575077f, 0.00764918f, -0.03900282f, -0.03021568f, 0.02939438f, -0.00941447f, -0.03142542f, 0.00053891f, 
    0.02390267f, -0.02336159f, -0.03081551f, -0.03567554f, 0.00867231f, 0.00171552f, 0.00723253f, -0.04031569f, 
    -0.01670814f, 0.02847958f, 0.00585904f, -0.00476556f, -0.02695101f, 0.02573771f, -0.02651270f, -0.02986809f, 
    0.02237844f, 0.01781969f, 0.01641080f, 0.00040681f, -0.03993999f, -0.02544570f, -0.03803511f, -0.00439254f, 
    0.00173776f, 0.02818561f, -0.03234389f, 0.00904448f, -0.03966377f, -0.01332331f, 0.02283751f, -0.01174275f, 
    -0.01031824f, -0.01668296f, -0.02247578f, 0.00679125f, -0.03380342f, 0.02239313f, 0.02953773f, -0.00426232f, 
    -0.04075801f, 0.00828149f, -0.00259416f, -0.02339518f, -0.01073785f, 0.01368523f, -0.00875967f, -0.03350164f, 
    -0.02482697f, -0.03771846f, 0.00843260f, 0.02973125f, -0.01586911f, -0.02994254f, -0.03162903f, -0.01766834f, 
    0.02339199f, 0.01502637f, -0.03363176f, -0.01442602f, 0.02121052f, -0.01257952f, 0.01841516f, -0.00263612f, 
    0.01443497f, -0.01523058f, -0.03344412f, 0.00435271f, -0.00133863f, 0.00954189f, -0.03364741f, -0.00150158f, 
    -0.00989635f, -0.03834358f, -0.02305110f, -0.01676760f, -0.02883305f, -0.03594414f, -0.02149652f, -0.03041350f, 
    0.00463903f, -0.00548639f, 0.00638995f, -0.00348025f, 0.00365646f, -0.03785615f, 0.01087443f, 0.01482275f, 
    -0.03981961f, -0.03352816f, 0.01082343f, -0.03485761f, 0.00620074f, 0.01510104f, -0.02010550f, -0.02897512f, 
    0.01558836f, -0.01032556f, -0.03887377f, -0.03199679f, 0.01041864f, -0.02670552f, -0.00655123f, -0.02896858f, 
    -0.01807739f, -0.02149063f, -0.01362821f, 0.00766677f, 0.01266267f, -0.03139414f, -0.03190685f, -0.01560576f, 
    0.00289891f, 0.02832620f, -0.02236023f, -0.03882298f, -0.02300015f, -0.03278691f, 0.00418801f, -0.03529809f, 
    -0.00733182f, -0.03533550f, -0.03625583f, 0.02216221f, -0.02537857f, 0.00778325f, 0.01654934f, 0.00344697f, 
    -0.01291037f, 0.02837031f, -0.02564046f, -0.03963384f, 0.01196835f, -0.00921666f, -0.04123934f, 0.00979585f, 
    0.02431752f, -0.02326377f, -0.04093042f, -0.01396614f, 0.00305502f, -0.03894697f, 0.02532958f, -0.01187735f, 
    -0.00098826f, -0.01346204f, 0.02533373f, -0.03871956f, -0.00069816f, 0.00970973f, 0.02169815f, 0.00150066f, 
    -0.00057624f, -0.03375989f, -0.02485813f, -0.02609887f, -0.02841608f, 0.01272194f, 0.01571073f, -0.00553587f, 
    -0.03567798f, 0.02971756f, -0.00953841f, 0.02566750f, -0.00214220f, 0.02798040f, 0.01197298f, -0.00018387f, 
    0.02122952f, -0.00145632f, -0.01237172f, 0.01470221f, 0.01651892f, 0.02213308f, 0.00732386f, -0.03671019f, 
    -0.00963119f, -0.01796099f, -0.02335022f, -0.03251882f, 0.02492158f, -0.03902543f, 0.02691714f, -0.01700071f, 
    0.01468992f, 0.02097359f, -0.03831105f, -0.03214773f, -0.00830430f, -0.00526789f, -0.00517835f, 0.01552985f, 
    0.01745331f, -0.02636842f, 0.00395792f, 0.00923967f, 0.01611909f, 0.00006086f, -0.01713874f, 0.01246486f, 
    -0.03963727f, 0.00969264f, 0.00247086f, 0.00619048f, 0.00848960f, 0.02994733f, -0.03388026f, 0.02698583f, 
    0.01130681f, 0.01867010f, -0.03009022f, -0.01656758f, -0.03039188f, -0.02998468f, -0.03046651f, 0.01120901f, 
    0.01984281f, -0.03779669f, -0.01388202f, -0.01509741f, -0.04175670f, 0.00905553f, 0.02753967f, -0.04101552f, 
    -0.00173180f, -0.01998378f, -0.03099767f, 0.00465737f, -0.02911841f, 0.01219242f, 0.00353213f, 0.01220555f, 
    -0.04123249f, -0.01738714f, 0.01628868f, -0.00315749f, 0.00493458f, -0.01049651f, -0.04173769f, -0.02269207f, 
    -0.02671358f, -0.03049310f, -0.00220136f, -0.00378154f, -0.01832174f, 0.00359219f, -0.02347234f, -0.01892676f, 
    0.02707171f, 0.02127966f, -0.02254908f, -0.01179104f, -0.03491930f, -0.04051058f, -0.00151383f, 0.02588802f, 
    -0.04038956f, 0.02731723f, 0.00377127f, 0.00134944f, -0.02255728f, -0.02800020f, 0.01338972f, 0.02585947f, 
    -0.02826987f, -0.02370178f, -0.03432535f, 0.00351233f, 0.01025298f, 0.00770003f, 0.00908362f, -0.04188753f, 
    -0.02613664f, 0.00212209f, -0.02139107f, -0.00902566f, -0.00110310f, -0.00569692f, -0.02936643f, -0.00123361f, 
    -0.03140673f, -0.02720785f, -0.00509644f, 0.02141668f, -0.00870832f, 0.00366578f, 0.02684324f, -0.03314395f, 
    0.01877957f, -0.01380581f, -0.02881737f, -0.03457887f, 0.02120820f, -0.02545818f, -0.00869848f, -0.01611950f, 
    0.01839176f, 0.00333141f, -0.03892177f, -0.02124287f, -0.02722364f, 0.02646792f, -0.00405280f, -0.02639718f, 
    0.01794169f, 0.00674283f, -0.01942806f, -0.00692564f, 0.02917747f, -0.01345642f, -0.00121139f, -0.02475308f, 
    -0.00245269f, -0.02556116f, -0.01660665f, -0.03717094f, 0.00111373f, -0.03695416f, -0.03721325f, 0.02321863f, 
    -0.23183860f, 0.03261910f, -0.06839591f, 0.07374918f, -0.01026719f, 0.04024358f, -0.02828061f, -0.07737935f, 
    -0.04390896f, -0.08212910f, 0.10935479f, 0.11399593f, -0.23081724f, 0.34736243f, 0.04837585f, -0.11682691f, 
    0.07933702f, -0.06958199f, -0.13358454f, 0.04412608f, 0.11403412f, -0.00839502f, -0.04358168f, -0.02780260f, 
    -0.19970678f, -0.01964544f, -0.07392677f, 0.06259084f, 0.01607708f, -0.02439078f, -0.02353364f, -0.09849553f, 
    -0.01637065f, 0.15598637f, 0.14323017f, 0.09132229f, 0.16491170f, 0.07752306f, -0.04175385f, -0.10019763f, 
    -0.06454343f, -0.09748476f, -0.04498487f, 0.04648858f, -0.09189056f, 0.14662880f, 0.10884909f, 0.20707431f, 
    0.18310960f, 0.03291965f, 0.02790949f, -0.05540378f, 0.02314679f, 0.01973286f, -0.07612945f, -0.00945475f, 
    0.10771690f, 0.02118862f, 0.02875802f, 0.03803204f, 0.29455686f, 0.07323823f, 0.11448620f, 0.00197406f, 
    0.16223674f, -0.00264987f, -0.01248085f, -0.11727279f, -0.06093801f, -0.00610845f, -0.02957903f, -0.00548025f, 
    0.29393870f, -0.05438379f, -0.07457831f, -0.08855759f, 0.08508537f, 0.05229680f, -0.09381924f, -0.01719557f, 
    0.00552606f, 0.07101949f, -0.00134846f, 0.06281216f, -0.14499934f, -0.19288538f, 0.14222625f, -0.04632932f, 
    0.04622183f, -0.01112449f, 0.03508542f, 0.03991017f, 0.02286577f, 0.00483567f, 0.00586924f, -0.04064456f, 
    -0.16034420f, 0.04498960f, -0.01622350f, 0.05447246f, 0.14469071f, 0.11729863f, -0.18703507f, 0.06244517f, 
    0.04837457f, -0.03534193f, 0.24037652f, 0.00941173f, -0.26488236f, 0.21688814f, -0.04082661f, 0.03841784f, 
    -0.00462241f, 0.17464152f, -0.13608690f, -0.01285635f, 0.09463573f, 0.00705787f, 0.10710346f, -0.03185451f, 
    0.12027813f, -0.23480293f, -0.05267899f, -0.06029189f, 0.00356994f, -0.01155957f, -0.15845542f, 0.01053084f, 
    -0.03294794f, 0.06402560f, -0.01015014f, 0.19418956f, -0.02795452f, 0.01788264f, -0.01034839f, -0.13767387f, 
    0.14530145f, 0.05159590f, 0.18370168f, 0.14320487f, -0.01038087f, 0.06977051f, -0.20335859f, 0.01587272f, 
    -0.01593107f, -0.09155247f, 0.13210844f, 0.10253366f, 0.10703336f, 0.03320119f, 0.00992138f, -0.09534989f, 
    -0.10697819f, 0.10710031f, 0.01090936f, -0.06644508f, 0.04482720f, 0.00559816f, 0.01566474f, 0.11252179f, 
    0.10890312f, 0.01646544f, -0.00845368f, 0.00196132f, -0.05994494f, -0.08064543f, 0.06973097f, -0.02479516f, 
    -0.01939100f, 0.21581638f, 0.10373721f, -0.03871446f, 0.06496122f, 0.06822562f, -0.08717518f, 0.00106826f, 
    0.16388407f, 0.01826644f, -0.04596250f, 0.07661084f, 0.06781666f, 0.28238040f, 0.05042263f, -0.09464496f, 
    0.03063721f, -0.01693681f, -0.00794422f, -0.08281309f, -0.00803860f, -0.02677123f, 0.08791394f, 0.15578052f, 
    0.17434940f, 0.21634072f, -0.09899598f, -0.05425879f, 0.00686548f, 0.02134817f, -0.04906490f, -0.07368092f, 
    -0.02365911f, 0.01626711f, 0.05747466f, 0.05235751f, -0.15140839f, -0.25276414f, -0.03041353f, -0.13166095f, 
    0.03757463f, -0.09535164f, -0.01102080f, 0.00689733f, -0.09832763f, 0.10816340f, 0.03084032f, -0.04546422f, 
    0.25035462f, -0.04922451f, -0.01363103f, 0.10933876f, -0.02119976f, 0.03653231f, 0.00109123f, 0.00332869f, 
    0.03666195f, 0.01786528f, 0.15909258f, -0.00989429f, 0.26942623f, -0.05801274f, -0.00906557f, -0.15987152f, 
    -0.00814107f, -0.02702254f, -0.02144108f, 0.05595540f, 0.05437431f, -0.00056872f, -0.03175504f, -0.07593099f, 
    0.20921117f, -0.00278542f, 0.11012712f, 0.10842530f, -0.00120847f, -0.09693940f, 0.04556100f, -0.04902772f, 
    0.01404350f, 0.05080493f, 0.03895899f, 0.12779462f, -0.13696025f, -0.12471205f, 0.05158475f, -0.03628672f, 
    0.13628286f, 0.04996914f, 0.00941944f, -0.06847227f, -0.09119764f, -0.09729020f, 0.10363995f, -0.11754879f, 
    -0.19767945f, -0.11401245f, 0.01462568f, 0.02153621f, 0.03792746f, 0.14379518f, -0.13770053f, -0.11200393f, 
    0.02995608f, -0.07913017f, -0.09427665f, -0.00180125f, -0.06594273f, 0.04434006f, 0.00435364f, 0.07647378f, 
    0.14371903f, 0.00790887f, 0.12128357f, 0.08722075f, -0.09633538f, -0.13776386f, -0.06760040f, 0.13287099f, 
    -0.05078794f, 0.11686098f, -0.01706354f, 0.15592390f, 0.00798034f, 0.07646496f, -0.03195078f, 0.03413752f, 
    0.00750082f, -0.07512690f, -0.08751749f, -0.05565272f, 0.22892255f, 0.01973862f, 0.01885798f, 0.05930131f, 
    0.11301474f, -0.14398973f, -0.17340836f, -0.04804827f, 0.03462788f, -0.15462971f, -0.02529150f, -0.06466308f, 
    0.07740544f, 0.09801545f, 0.02279635f, -0.00051183f, 0.00213190f, 0.14840309f, -0.01698407f, 0.05503694f, 
    0.07087608f, 0.00409902f, 0.00211350f, 0.06689772f, -0.17408465f, -0.07275102f, -0.08267527f, -0.00417629f, 
    0.11391301f, 0.02291323f, 0.04162202f, 0.04953737f, 0.03687338f, 0.10250194f, -0.00189360f, 0.01932290f, 
    -0.25836504f, 0.01137468f, -0.08524477f, -0.09575658f, -0.11805657f, 0.06784635f, 0.03609649f, -0.10763072f, 
    0.01464810f, -0.03847109f, 0.16372430f, -0.00050877f, 0.04375890f, 0.08553680f, 0.03708543f, 0.09378843f, 
    0.05131368f, -0.06857143f, 0.14761199f, 0.00212967f, -0.09631524f, -0.05861897f, 0.20193318f, -0.11666451f, 
    0.03537013f, 0.06120899f, -0.00748207f, -0.03278926f, 0.20530577f, 0.05021105f, 0.06968257f, -0.02128199f, 
    0.02069392f, 0.06080635f, -0.03651246f, 0.00920921f, -0.24681957f, -0.02224098f, -0.06918459f, 0.04413432f, 
    0.03522283f, 0.00893043f, 0.04380921f, 0.08357164f, -0.00662421f, 0.07625107f, -0.06039217f, -0.03260385f, 
    -0.03013726f, -0.05425757f, -0.02922131f, -0.09067401f, 0.01621347f, 0.12555528f, -0.12252459f, 0.02247168f, 
    0.08685710f, -0.00402714f, -0.05870677f, 0.00725785f, 0.19369046f, -0.09369583f, -0.03281293f, -0.03255610f, 
    0.02181063f, 0.03830125f, -0.02042192f, 0.10855277f, 0.06012370f, 0.06818471f, -0.05319156f, 0.00834799f, 
    -0.06204278f, 0.10589830f, 0.05403512f, 0.13808858f, 0.09717833f, 0.03697642f, 0.10036216f, -0.00525656f, 
    0.17074338f, -0.07291761f, 0.08493011f, 0.12934330f, -0.07172336f, -0.02911641f, -0.12927933f, -0.00365576f, 
    0.09441159f, 0.06270961f, -0.02620252f, -0.00859316f, 0.18982209f, -0.04658625f, 0.04469378f, 0.00891234f, 
    0.22890352f, 0.31213555f, -0.06761703f, 0.05340315f, 0.08874034f, 0.09508452f, 0.03649084f, -0.02241039f, 
    0.04833213f, -0.11259970f, 0.09402508f, 0.14652149f, -0.18297705f, 0.03423468f, -0.02849738f, -0.13702650f, 
    0.11114950f, -0.04920911f, -0.09213024f, 0.06778939f, -0.01441334f, 0.05590598f, -0.07108323f, 0.10668356f, 
    0.16586301f, -0.18899980f, -0.01530954f, -0.16472313f, 0.09754672f, -0.02116782f, -0.07089233f, 0.14335968f, 
    0.03888268f, 0.00670697f, 0.03050876f, -0.20223203f, -0.08463559f, 0.10841477f, -0.21760923f, -0.19567500f, 
    0.02167906f, 0.00620419f, 0.08897553f, 0.06690617f, 0.01242230f, -0.08240161f, 0.01166084f, -0.11410952f, 
    -0.25970608f, -0.07207258f, 0.11656548f, 0.26744649f, 0.13051613f, 0.04757110f, 0.05246519f, -0.01218377f, 
    0.01934486f, 0.01862421f, -0.01765698f, 0.12924880f, -0.17209013f, -0.06409168f, 0.13749021f, -0.08515885f, 
    0.06693622f, -0.10166145f, -0.10050788f, -0.03554513f, 0.05288448f, -0.04394093f, 0.15053247f, -0.06401096f, 
    -0.14433694f, 0.07673300f, -0.03525514f, 0.05001451f, -0.00275705f, -0.00562446f, -0.06549240f, 0.01621271f, 
    0.16535674f, 0.00677345f, 0.04770013f, -0.04997997f, -0.37727642f, -0.19068220f, 0.19058199f, 0.06557713f, 
    0.06979920f, -0.01997185f, 0.10093183f, -0.09605415f, 0.05559546f, -0.01239994f, 0.00455358f, 0.02546020f, 
    0.05435779f, -0.14226411f, 0.06252918f, -0.02689221f, 0.06591523f, 0.01304933f, -0.02993533f, 0.13507345f, 
    -0.00190974f, 0.04331395f, 0.05968641f, 0.22538865f, 0.12072797f, 0.06887825f, -0.08240429f, -0.01521987f, 
    -0.07809160f, -0.01720010f, 0.07283051f, 0.01914938f, 0.00992396f, 0.12351280f, 0.05101655f, 0.15233004f, 
    0.19858162f, 0.24372044f, -0.01012838f, 0.23753050f, -0.09302115f, 0.08124632f, 0.08387332f, 0.07267193f, 
    0.12738793f, -0.08159357f, 0.01018325f, 0.08571319f, -0.06268734f, -0.21194622f, 0.09100711f, 0.11993222f, 
    0.21996398f, -0.02982221f, -0.02947858f, 0.03827756f, 0.02044840f, -0.06409838f, -0.02142969f, 0.03167103f, 
    -0.23848689f, 0.02442303f, -0.06690679f, -0.08105575f, -0.00949591f, 0.07626384f, -0.02342801f, 0.07876429f, 
    0.02982059f, -0.11217769f, 0.06166447f, -0.03175300f, -0.02069755f, 0.28888795f, -0.02688297f, 0.11216014f, 
    0.23721935f, -0.00359468f, -0.10282725f, 0.01174481f, 0.09545632f, 0.06214965f, 0.01573518f, -0.06166479f, 
    0.02894927f, 0.12890767f, 0.21452412f, 0.01252269f, 0.09340443f, 0.09719860f, -0.07017953f, -0.07832795f, 
    0.04355653f, -0.01782987f, 0.09291389f, -0.05812439f, 0.24252962f, 0.08833902f, -0.10477995f, 0.13353571f, 
    0.02746857f, 0.05555681f, 0.02683707f, -0.03182984f, 0.04333893f, 0.04054756f, -0.02137257f, 0.03601597f, 
    0.12475097f, -0.17673361f, -0.05352613f, 0.02180657f, 0.00324432f, 0.11747555f, 0.02179053f, -0.04333362f, 
    0.10123946f, -0.05161151f, 0.14853583f, 0.09349909f, 0.22079659f, 0.02038165f, -0.12647183f, 0.09497082f, 
    -0.00939132f, -0.03240333f, -0.09294599f, -0.09149994f, -0.00485275f, 0.10205544f, -0.11629992f, -0.01441305f, 
    -0.12017581f, 0.14362535f, -0.04999589f, 0.02029032f, 0.04644299f, 0.03814332f, -0.03815873f, -0.21066551f, 
    0.03352405f, 0.08380450f, 0.15675454f, 0.08793719f, -0.41943392f, -0.04466744f, 0.06764988f, 0.09101814f, 
    0.01842492f, -0.03078275f, -0.04759407f, 0.00089053f, 0.07186247f, 0.00595604f, 0.03228249f, 0.10432840f, 
    0.06629215f, 0.02449772f, -0.05352310f, -0.01052582f, 0.05006228f, 0.11356568f, -0.04655425f, 0.01694570f, 
    -0.03643992f, -0.00488252f, 0.01083090f, -0.04826033f, 0.03590707f, 0.02149926f, 0.08200965f, 0.06043538f, 
    0.08353607f, 0.04789210f, -0.04060527f, -0.12084484f, -0.05827691f, -0.19534560f, 0.11596262f, -0.06231916f, 
    0.03087538f, 0.06582807f, -0.12895429f, -0.07862986f, -0.23265520f, -0.14631660f, 0.00280198f, -0.04602263f, 
    0.02730731f, 0.14989433f, 0.12160408f, 0.07294425f, 0.02385818f, 0.11878522f, 0.04053431f, -0.00145371f, 
    -0.05577779f, -0.03059429f, -0.00301510f, -0.05807465f, -0.01958415f, -0.00229561f, -0.14032917f, 0.14917989f, 
    0.09580313f, 0.02577872f, 0.06529299f, 0.05414267f, 0.19054408f, -0.09877542f, -0.06432309f, -0.01275912f, 
    0.15265480f, -0.00937512f, -0.11438455f, 0.04332542f, 0.01498805f, -0.07138200f, 0.13935062f, 0.11109823f, 
    0.10451735f, 0.01387299f, -0.05612668f, -0.05001733f, -0.06825402f, -0.04051542f, 0.01384765f, 0.09032673f, 
    -0.02848936f, 0.02463065f, 0.16445445f, 0.11167435f, 0.11893713f, -0.00217037f, 0.09681603f, 0.15811904f, 
    0.04525182f, -0.01806983f, 0.02473273f, 0.03440993f, 0.13876024f, -0.03966902f, 0.08247881f, 0.05325072f, 
    0.14989282f, -0.07367583f, 0.07126002f, 0.01460645f, 0.03624072f, 0.13897236f, 0.08542582f, 0.00197411f, 
    0.03969058f, 0.28617388f, -0.20711857f, -0.03269450f, 0.15163477f, 0.09576412f, 0.00083295f, -0.01748144f, 
    0.12655567f, 0.07557998f, -0.04750523f, 0.07386406f, -0.02224517f, -0.31048080f, 0.15745328f, -0.20504887f, 
    0.08737519f, -0.08651101f, 0.01604187f, 0.00033815f, -0.01438574f, 0.04469936f, 0.10374143f, 0.11030699f, 
    -0.15978189f, 0.14196222f, 0.17881837f, -0.30402687f, 0.07622591f, 0.03251125f, 0.07211103f, 0.05289898f, 
    -0.04399061f, -0.00710378f, -0.03023326f, -0.08352524f, 0.11539326f, -0.07422847f, -0.09707657f, -0.20503509f, 
    -0.05371397f, -0.09249183f, 0.05744645f, 0.06164027f, 0.03374030f, -0.13778259f, -0.05907082f, -0.07752714f, 
    0.25802699f, -0.12297384f, 0.10305510f, -0.00574219f, -0.00959368f, -0.00686610f, 0.04926827f, 0.08170427f, 
    -0.03233493f, 0.06264140f, 0.01946247f, 0.02674028f, -0.12204015f, 0.00763088f, 0.12088139f, -0.11385697f, 
    0.16282661f, 0.03025100f, 0.05571214f, 0.06628503f, 0.00872813f, 0.07159404f, -0.04701036f, 0.06280732f, 
    0.16206031f, 0.06560158f, 0.03290246f, -0.03776888f, 0.07068930f, 0.05476221f, 0.06070321f, 0.00438707f, 
    -0.05043783f, 0.01551857f, 0.04295897f, -0.03668610f, 0.30784354f, 0.00303403f, 0.17079604f, -0.21393335f, 
    -0.02609884f, -0.01231597f, 0.02010038f, 0.01980977f, -0.00063368f, -0.04229194f, 0.15518332f, -0.00059260f, 
    0.03277473f, 0.00626123f, -0.13419212f, -0.12045956f, -0.04830807f, -0.00868569f, 0.04797712f, -0.15552710f, 
    0.07363383f, -0.01263335f, 0.00311375f, -0.01031476f, -0.16981605f, 0.13571629f, -0.30198482f, 0.10777805f, 
    -0.12134656f, -0.09025062f, 0.00957635f, -0.02960677f, 0.07949849f, -0.07646734f, -0.03097783f, -0.06272893f, 
    0.28391171f, -0.13170370f, -0.08793937f, 0.06438053f, -0.07900868f, -0.12770776f, 0.02069282f, 0.03289694f, 
    0.03245498f, 0.00228747f, -0.09201115f, -0.13986704f, -0.07450423f, 0.06133520f, -0.02758264f, -0.12573661f, 
    0.05335173f, -0.06630091f, 0.02718577f, 0.02082933f, -0.11880679f, -0.03785370f, 0.02697979f, 0.07574195f, 
    -0.09064266f, 0.20975785f, 0.13964704f, -0.09200922f, 0.10878482f, 0.02447845f, -0.02452466f, -0.03351816f, 
    0.08945037f, -0.00496702f, 0.02863127f, 0.00120556f, 0.09202253f, 0.08371869f, 0.22186562f, -0.18874714f, 
    0.06057377f, 0.01341883f, 0.06335461f, 0.02562235f, -0.01164397f, 0.09192362f, 0.00209637f, 0.06191541f, 
    0.19535087f, -0.14813937f, -0.14118379f, -0.02838599f, -0.03177273f, -0.00588710f, 0.05272720f, 0.06291393f, 
    0.14402379f, 0.04145565f, 0.08711101f, 0.00761722f, 0.08100128f, 0.27187496f, -0.10738452f, 0.16158615f, 
    0.10824239f, -0.00906036f, 0.02795917f, 0.04982278f, 0.07931636f, -0.04102238f, 0.00420020f, -0.04255440f, 
    -0.04978925f, 0.32103419f, -0.14286540f, 0.49023888f, 0.16285068f, -0.00558470f, 0.02238359f, 0.03802286f, 
    0.05350685f, -0.03240646f, 0.00957769f, -0.08662834f, -0.01224889f, 0.18049656f, 0.07023533f, 0.10117424f, 
    0.00162530f, 0.00707833f, 0.00647733f, -0.11365022f, -0.03709808f, -0.00232927f, 0.13967869f, -0.09607591f, 
    0.02267707f, -0.20496638f, 0.05768160f, 0.11533739f, 0.08334322f, -0.08639978f, 0.07035592f, -0.02111845f, 
    -0.12292604f, -0.08898472f, -0.05737851f, 0.02574911f, 0.32722881f, -0.19887163f, -0.12888443f, 0.15169619f, 
    0.08162319f, 0.08458388f, -0.05963602f, 0.09663358f, 0.02108580f, 0.09804709f, 0.04197556f, 0.19506767f, 
    0.01510228f, -0.17820083f, 0.03282086f, 0.24354261f, -0.09082156f, 0.03367036f, 0.05127675f, 0.06249775f, 
    -0.13970637f, 0.02843010f, -0.06183069f, 0.04520365f, -0.09052084f, -0.06230721f, -0.09000279f, 0.06194963f, 
    0.12804911f, 0.02941874f, 0.00153149f, 0.08457583f, -0.07573620f, 0.01190694f, -0.11543728f, 0.05407297f, 
    -0.07431199f, -0.29087329f, 0.14236139f, -0.02808972f, -0.10019541f, 0.01376517f, 0.04620655f, 0.01024799f, 
    0.14228140f, 0.01040993f, 0.11825328f, 0.10684039f, -0.12995443f, 0.17800200f, -0.12466273f, 0.06841382f, 
    -0.03247621f, 0.01407249f, -0.02268210f, -0.16858956f, 0.03557529f, 0.19295609f, 0.05114347f, 0.01965777f, 
    -0.34431487f, 0.02116722f, -0.07343785f, 0.14155705f, -0.15657790f, 0.03729729f, -0.06627894f, 0.01763008f, 
    -0.04339842f, 0.00921699f, 0.03218230f, 0.03359824f, 0.09667352f, -0.34632623f, -0.14677382f, 0.07120400f, 
    -0.14787167f, 0.04692804f, 0.09738611f, 0.06377750f, -0.03543274f, 0.07642934f, 0.05626652f, 0.13618143f, 
    0.38055384f, -0.23019090f, -0.02284572f, 0.15458214f, 0.07359269f, -0.01610656f, -0.01919069f, 0.07303832f, 
    0.14227985f, 0.01565835f, 0.03262199f, -0.04053342f, 0.03429461f, 0.09402490f, -0.13834560f, -0.14835718f, 
    -0.08948126f, 0.00846074f, -0.13134572f, -0.06128716f, 0.08041559f, -0.03495058f, -0.04507406f, -0.03912549f, 
    -0.10658165f, 0.13732190f, -0.09050216f, 0.14609528f, 0.08066940f, 0.00034854f, -0.11154360f, 0.00818873f, 
    -0.02733516f, -0.04062006f, -0.00686389f, -0.02732953f, -0.03836998f, -0.26491630f, 0.05429020f, 0.14840071f, 
    0.04446693f, 0.05208050f, 0.02596380f, 0.12297799f, 0.00025388f, -0.02777330f, -0.00394347f, 0.03028429f, 
    0.01734820f, 0.17290534f, 0.03513226f, 0.04662743f, 0.12473452f, -0.09324700f, -0.00877835f, -0.05833470f, 
    -0.00445750f, 0.01389384f, 0.04700662f, 0.00857733f, -0.17198181f, -0.02118917f, -0.05693011f, -0.05714532f, 
    0.04766864f, 0.01863472f, 0.06957392f, 0.00546115f, -0.01508478f, 0.05279334f, 0.10811414f, 0.05713127f, 
    0.30891922f, 0.03340318f, -0.08041292f, -0.27190882f, 0.05643002f, -0.00958595f, 0.08951893f, 0.04639760f, 
    -0.03021987f, 0.04161317f, 0.03813492f, 0.08522265f, 0.19963664f, -0.04601866f, -0.06436688f, -0.19233364f, 
    0.00090066f, -0.00090577f, 0.09343871f, 0.02848969f, 0.00807009f, 0.07114621f, 0.09497038f, 0.01367622f, 
    0.12441608f, 0.09232138f, -0.09601882f, -0.12018351f, 0.13732074f, 0.02000151f, 0.04560657f, 0.00477413f, 
    -0.00592923f, -0.03859811f, 0.08543970f, -0.08889756f, 0.38210887f, -0.06285061f, 0.04244870f, 0.22348715f, 
    0.01900489f, -0.06295317f, 0.05028449f, 0.03107822f, -0.05713034f, 0.07336689f, -0.08604408f, -0.04503935f, 
    0.15284723f, -0.18706438f, -0.13981946f, -0.04264274f, 0.04915459f, -0.01761607f, -0.03391431f, -0.02060159f, 
    -0.07202189f, -0.00224245f, 0.01424064f, -0.06902573f, -0.13229147f, 0.23019104f, 0.06190936f, -0.16467637f, 
    0.14979771f, 0.09873678f, 0.03827440f, 0.07447347f, 0.04292763f, 0.05221414f, 0.04391284f, -0.06609336f, 
    0.17743105f, -0.06965427f, 0.08552548f, -0.33544537f, 0.03039653f, -0.10819014f, 0.11883914f, -0.03991254f, 
    -0.06977280f, 0.08911036f, 0.17923795f, 0.01969932f, 0.00775914f, 0.12430616f, -0.18837315f, -0.14035811f, 
    0.02458726f, -0.00013313f, 0.03505602f, -0.08441305f, 0.03031296f, 0.08959712f, 0.01724531f, 0.16807365f, 
    -0.11178826f, -0.05651256f, -0.01711702f, -0.07588996f, -0.14969270f, -0.06392545f, -0.08409482f, -0.02137679f, 
    -0.14026555f, 0.05179471f, -0.05243776f, -0.01442943f, 0.01679520f, 0.02328957f, 0.20237626f, -0.06837834f, 
    0.00186750f, 0.12739602f, -0.00105250f, 0.03117294f, -0.06973486f, 0.09641894f, 0.07259489f, 0.04757603f, 
    -0.16555794f, 0.23538551f, -0.36910820f, 0.01023122f, -0.00257686f, -0.07895230f, 0.01994241f, 0.02819363f, 
    0.09368685f, 0.03436520f, 0.03126401f, 0.03268771f, 0.09043885f, -0.07028636f, -0.11103155f, -0.06368297f, 
    -0.09836859f, 0.10370012f, -0.02053022f, 0.07102602f, 0.03146297f, -0.05192891f, 0.06373050f, 0.03231554f, 
    0.08495513f, -0.03970828f, 0.04625396f, -0.22279468f, 0.00269043f, -0.09839134f, 0.01030724f, -0.07445563f, 
    0.04722362f, 0.11420711f, 0.01936085f, -0.00351773f, 0.24872714f, 0.14871499f, -0.20556623f, 0.13423543f, 
    0.02160159f, 0.09431916f, 0.05602942f, -0.03953041f, -0.07331906f, 0.05023351f, -0.09222788f, -0.02768032f, 
    0.23871121f, -0.06838527f, -0.09138323f, 0.11994053f, 0.04769074f, 0.08478943f, -0.05471791f, 0.07217576f, 
    -0.02159435f, 0.07642579f, -0.04132222f, 0.06272905f, -0.12405688f, -0.17449731f, 0.10081656f, -0.08499354f, 
    -0.07060914f, -0.03226498f, 0.06850078f, -0.06581940f, -0.00698488f, -0.05623686f, 0.01032220f, -0.03384097f, 
    -0.03440304f, 0.18294086f, -0.06087895f, 0.27876189f, 0.09065456f, 0.05433203f, 0.01338057f, -0.00557594f, 
    0.10392171f, -0.06147363f, 0.03361455f, 0.00454849f, -0.10423698f, 0.10310413f, 0.09288174f, -0.28761414f, 
    0.24065632f, -0.07657561f, -0.01044869f, -0.05771226f, 0.05252707f, 0.02474573f, -0.06638245f, 0.11840343f, 
    0.08026129f, 0.05547168f, 0.06668468f, -0.15352060f, 0.03097201f, 0.08989102f, 0.01090882f, -0.02099250f, 
    0.00118884f, 0.09905958f, 0.05167078f, 0.03415976f, 0.07412323f, -0.15821347f, -0.17243998f, 0.25816497f, 
    0.04839875f, -0.00301190f, -0.01537762f, 0.03380544f, -0.17131299f, -0.01467759f, 0.03942408f, -0.03931930f, 
    -0.20329052f, -0.06313019f, -0.07433373f, -0.03791188f, -0.16921777f, -0.04329219f, 0.02194766f, -0.08314728f, 
    0.01804356f, 0.00297263f, -0.01645560f, -0.00178990f, -0.04559128f, -0.01563834f, -0.05886695f, 0.13879707f, 
    0.06653711f, 0.02810290f, 0.09178513f, 0.07475495f, 0.01386963f, -0.02705047f, 0.05224539f, -0.03740930f, 
    0.17671829f, 0.03145243f, 0.00519998f, 0.29308704f, -0.06829981f, 0.06030456f, 0.02243288f, -0.03910510f, 
    0.00016580f, -0.10414475f, 0.00346686f, -0.06759870f, -0.14085807f, 0.11960407f, 0.11868255f, -0.18606949f, 
    -0.10342789f, -0.07281549f, -0.04791411f, -0.03339588f, -0.04623039f, 0.13696463f, 0.01415413f, 0.15741241f, 
    0.27750704f, 0.10452005f, -0.02415889f, 0.12345433f, 0.08674003f, 0.03429018f, -0.04674200f, 0.02697933f, 
    0.05897519f, 0.02867892f, 0.01405452f, -0.01885867f, 0.30376673f, 0.05243795f, 0.10313824f, 0.04532811f, 
    0.18865275f, -0.06737590f, -0.01338017f, -0.06046032f, 0.10508619f, 0.08552464f, 0.03230763f, 0.10113680f, 
    0.03833656f, 0.11955056f, -0.21309152f, -0.07640953f, 0.00352914f, 0.01465657f, 0.05280789f, -0.03693785f, 
    -0.01516968f, -0.09618636f, -0.08272349f, -0.05337396f, -0.08980414f, -0.05494427f, -0.17953317f, 0.22445658f, 
    0.01514726f, 0.02738906f, 0.02523410f, 0.01839418f, -0.00299839f, 0.01555418f, 0.02358887f, 0.16762789f, 
    0.09307487f, 0.02284709f, 0.06430274f, -0.06596006f, 0.02344255f, 0.01488423f, 0.05511771f, 0.03776965f, 
    0.01957341f, -0.05001982f, 0.02667647f, 0.03043145f, -0.05343319f, 0.23940037f, 0.03934363f, 0.11458393f, 
    0.09092925f, -0.00635664f, 0.03820956f, 0.03518325f, 0.07364064f, 0.07530895f, 0.04913852f, 0.08440227f, 
    -0.09374244f, 0.01298410f, 0.04419199f, 0.05968988f, -0.04420964f, -0.03269215f, -0.06815904f, -0.12230079f, 
    0.03331571f, 0.02827491f, 0.00168980f, 0.05363761f, -0.08632821f, 0.19922379f, 0.06271486f, -0.02269438f, 
    -0.06500258f, -0.01133260f, 0.02843772f, 0.02001666f, 0.06116077f, -0.04273636f, -0.01287384f, 0.04418556f, 
    -0.03731439f, 0.02795995f, -0.02097309f, 0.00063616f, 0.02385692f, -0.03649187f, 0.02182272f, -0.02077882f, 
    0.00464466f, 0.01574121f, 0.02212642f, -0.02012639f, -0.03101013f, -0.01987319f, -0.04274817f, -0.04334584f, 
    -0.02524344f, 0.00376698f, -0.02581733f, 0.00281246f, -0.02852437f, -0.03383225f, -0.01155050f, -0.02582395f, 
    -0.00449453f, 0.00945206f, -0.03697073f, 0.02391589f, -0.02013295f, -0.03861085f, -0.01102301f, 0.00134890f, 
    -0.03072333f, -0.00726680f, 0.02093513f, -0.02953179f, -0.01767757f, -0.04122289f, 0.01612892f, -0.00266823f, 
    -0.04152291f, -0.02318760f, -0.00640592f, -0.00693928f, -0.02936751f, -0.00426836f, -0.00222047f, 0.01665627f, 
    0.02883525f, 0.02539939f, 0.00646514f, 0.01990364f, -0.01188201f, -0.01990920f, -0.03671216f, -0.02778827f, 
    0.00343156f, -0.00603668f, 0.00613657f, -0.00694822f, -0.03746013f, 0.00940245f, -0.03396299f, -0.01569018f, 
    -0.03189678f, -0.03005961f, -0.03397195f, -0.01319130f, -0.01669854f, -0.04185050f, -0.01771451f, -0.03813714f, 
    -0.00213745f, 0.01762734f, -0.01234107f, 0.01737866f, -0.03165815f, 0.00625338f, -0.01715902f, -0.02406649f, 
    0.02701899f, -0.00381995f, 0.01901784f, -0.03063739f, 0.02458174f, -0.00043182f, 0.02437700f, -0.01252461f, 
    0.00178739f, 0.00709070f, 0.01699351f, -0.02621450f, 0.02693367f, -0.01403187f, 0.01292033f, 0.01597118f, 
    -0.00631626f, -0.03722648f, 0.02357864f, -0.02832518f, 0.02588931f, -0.03240225f, 0.00227739f, -0.02136398f, 
    0.02374361f, -0.03001430f, 0.01948656f, 0.00685989f, -0.03540084f, 0.00393646f, 0.00728111f, -0.00074235f, 
    0.02210912f, -0.02592833f, -0.01052386f, -0.00326489f, 0.00361893f, 0.00270767f, 0.00654995f, 0.01146638f, 
    0.00311587f, -0.04240580f, -0.02151136f, 0.02719048f, 0.00937900f, -0.04114139f, 0.00478142f, 0.02261711f, 
    -0.03076078f, 0.02796089f, -0.01328472f, -0.00931925f, -0.03105982f, 0.00093841f, 0.02397037f, -0.03277911f, 
    -0.01197463f, 0.01161721f, -0.01622831f, 0.00401483f, 0.00949651f, 0.02573160f, 0.00029049f, -0.01479740f, 
    -0.03563233f, 0.00915387f, 0.02375469f, -0.02487513f, 0.02607277f, 0.02157131f, 0.00958502f, 0.02050760f, 
    -0.03463789f, -0.00045474f, 0.01959121f, 0.02053064f, -0.01844078f, -0.04002949f, -0.00737621f, 0.03398639f, 
    -0.01399808f, 0.00309663f, 0.02206471f, -0.00899533f, 0.01899996f, -0.01208108f, -0.03998040f, 0.00216346f, 
    -0.01634560f, -0.00115677f, 0.01820165f, 0.02292877f, -0.00750072f, -0.04377693f, -0.01055977f, -0.02316866f, 
    -0.04273666f, -0.02387907f, -0.03893564f, -0.03780480f, 0.01242988f, -0.00741541f, -0.03697693f, 0.00933216f, 
    0.01493443f, -0.03482933f, -0.00625704f, 0.02704176f, -0.00912722f, -0.02283026f, 0.01066282f, -0.03463624f, 
    -0.01875537f, -0.01892210f, -0.00545901f, -0.01772089f, -0.02894966f, 0.01245038f, -0.02227301f, -0.00891855f, 
    0.00967682f, -0.01684457f, 0.00353134f, -0.01627833f, 0.00100249f, 0.00097602f, 0.00353029f, 0.00970307f, 
    -0.02281939f, -0.01609055f, 0.00895111f, -0.00137210f, -0.01979672f, -0.01684695f, -0.01846804f, -0.01960357f, 
    0.01423874f, 0.01373253f, -0.01844373f, -0.02309927f, -0.02423147f, 0.00490754f, -0.02779756f, -0.01470171f, 
    -0.03842553f, 0.01139847f, -0.01616137f, 0.01660980f, 0.01025405f, -0.03650298f, 0.01922234f, -0.03704617f, 
    0.01080515f, -0.04168754f, -0.03316035f, -0.02121357f, 0.01630677f, -0.01690611f, 0.02736616f, -0.00661084f, 
    -0.01596699f, -0.00964929f, 0.02809220f, -0.02282733f, -0.02421335f, -0.00954312f, -0.00587055f, 0.00144006f, 
    -0.00466826f, -0.02462840f, -0.00947031f, -0.02574792f, -0.01797605f, 0.00319898f, 0.01207770f, -0.02255254f, 
    -0.04142587f, -0.01491826f, 0.02584668f, 0.02279615f, 0.00778510f, 0.01778259f, 0.01868598f, -0.02279404f, 
    -0.01794563f, -0.01607161f, -0.03419505f, -0.00595236f, -0.03838091f, 0.03371198f, -0.00774939f, -0.02386902f, 
    0.00059820f, -0.00384342f, -0.01914241f, 0.02120763f, -0.04332615f, -0.02090537f, -0.01131148f, 0.01494218f, 
    -0.02944962f, -0.01743657f, -0.00256851f, -0.01543055f, -0.03250416f, 0.01138534f, -0.02893720f, -0.02655583f, 
    0.01952018f, 0.00884498f, -0.02594855f, -0.02900281f, -0.01035342f, -0.02972041f, -0.03875026f, 0.00415727f, 
    -0.02388245f, 0.02260640f, -0.02442172f, -0.00374128f, 0.02647150f, -0.01504553f, 0.00359264f, -0.01108899f, 
    -0.00651114f, 0.00681653f, -0.01034746f, -0.02142438f, 0.00863042f, 0.02320784f, -0.01380692f, -0.03223794f, 
    0.01423220f, 0.00840029f, 0.00479921f, -0.03652062f, 0.01461969f, -0.01281923f, 0.00587993f, -0.01837959f, 
    -0.01039976f, -0.01107598f, -0.00641973f, -0.04310605f, 0.02436410f, -0.02309904f, -0.04344464f, -0.04245322f, 
    0.01245373f, -0.02614526f, 0.02598391f, -0.02139400f, -0.01077412f, 0.01426987f, -0.02696510f, -0.01214885f, 
    0.00252634f, 0.01294574f, -0.02861525f, 0.01089176f, -0.00683276f, -0.02540325f, 0.00948871f, -0.01124751f, 
    -0.01203532f, -0.04224574f, 0.02615759f, 0.00225408f, -0.00671178f, -0.02277023f, -0.00424496f, 0.01413714f, 
    -0.00180954f, 0.00171850f, -0.02211779f, -0.02739576f, -0.01958730f, -0.00188939f, -0.00133544f, 0.01887369f, 
    0.00553019f, 0.00243294f, 0.02122314f, -0.00277969f, 0.02711136f, 0.02840498f, 0.01889779f, -0.03410642f, 
    0.01642259f, -0.00102447f, -0.00882275f, -0.03717126f, 0.01608510f, 0.00998245f, -0.03597281f, 0.01754920f, 
    0.01692565f, -0.03222081f, -0.01757170f, 0.00544768f, -0.00743210f, 0.01368511f, -0.02868579f, 0.02118412f, 
    0.01841849f, -0.01611121f, -0.02949081f, 0.00720851f, -0.04256441f, -0.04394965f, 0.00455202f, -0.03206272f, 
    -0.03806861f, -0.01273799f, 0.01676564f, -0.04409111f, -0.01500070f, 0.01486493f, -0.00360591f, 0.02199152f, 
    -0.00740255f, -0.02428725f, -0.01088773f, 0.00943923f, -0.01388104f, -0.00722965f, 0.02151303f, -0.00730403f, 
    0.00214605f, 0.02355183f, -0.01239412f, 0.00797197f, 0.00936246f, -0.02368643f, -0.02223413f, -0.04001926f, 
    0.01014237f, -0.03486451f, 0.01418235f, 0.00179492f, 0.02332556f, 0.02314674f, 0.03192886f, -0.02222027f, 
    -0.02364755f, 0.00806567f, -0.03534820f, -0.02191907f, -0.01576231f, -0.01123966f, -0.00972562f, 0.00352924f, 
    -0.02980040f, -0.04334179f, 0.02570584f, 0.02018731f, 0.00737255f, 0.01328764f, 0.01686811f, -0.01728540f, 
    -0.00816513f, 0.01704622f, -0.00783081f, -0.02375515f, -0.03529477f, -0.00679504f, 0.01921980f, 0.01893814f, 
    -0.04207382f, 0.02576722f, -0.01931384f, 0.00776552f, -0.03521129f, -0.00110033f, 0.02261683f, 0.03181402f, 
    0.00508930f, -0.01397441f, -0.00111926f, -0.01711784f, -0.01161119f, 0.00004252f, -0.03442682f, 0.02224231f, 
    -0.01456507f, 0.00718764f, -0.01826187f, -0.01232848f, 0.02789470f, -0.03531498f, -0.03303272f, 0.01432123f, 
    0.01360397f, 0.00958841f, -0.03166440f, 0.00393906f, -0.01027917f, -0.01636747f, -0.04050316f, -0.02276748f, 
    0.02637695f, -0.00854931f, 0.01530720f, 0.00102377f, -0.02365333f, -0.03556444f, -0.03114646f, -0.04046249f, 
    -0.03832538f, 0.01165225f, 0.00275484f, 0.02585316f, 0.00853574f, 0.01783952f, 0.01673616f, -0.04309854f, 
    -0.01243803f, -0.01951677f, 0.00073234f, 0.01340804f, -0.00729587f, -0.01051019f, -0.00441361f, -0.01184581f, 
    -0.00726965f, 0.00927577f, 0.01724041f, 0.00411225f, -0.03312300f, -0.00389899f, -0.04310216f, -0.00920251f, 
    -0.02714247f, -0.02967393f, -0.01493814f, -0.00354462f, -0.02551544f, 0.00397495f, 0.01438597f, 0.00226973f, 
    -0.02572449f, -0.02014782f, -0.02859138f, -0.01683278f, -0.02684580f, 0.02553001f, -0.00947064f, -0.02708795f, 
    0.02424793f, 0.01977245f, 0.00306038f, -0.01085106f, -0.03035077f, 0.02558253f, -0.03734410f, -0.01425970f, 
    -0.01040874f, 0.02455927f, -0.00267095f, 0.00352711f, -0.02944527f, -0.02541907f, 0.02187576f, 0.02638111f, 
    -0.03222286f, 0.00495269f, -0.00387801f, -0.01993969f, -0.02695093f, -0.02561203f, -0.00880978f, -0.02385648f, 
    -0.00648623f, 0.02771433f, -0.02995498f, -0.01271006f, 0.01426107f, -0.00227693f, 0.00501453f, 0.02556699f, 
    0.00332180f, 0.02130924f, 0.00176730f, -0.00840016f, 0.00006748f, 0.00207607f, -0.04077004f, 0.02647214f, 
    -0.03531159f, 0.01544490f, -0.03436825f, 0.01421165f, -0.03834749f, -0.03356940f, -0.02199860f, -0.02187966f, 
    0.02717305f, -0.02401402f, 0.01271716f, 0.00302071f, 0.01856177f, -0.02286571f, -0.00428921f, -0.02970411f, 
    -0.01257349f, 0.02752472f, 0.03539336f, 0.00938459f, -0.01925704f, -0.01755999f, -0.00531840f, -0.01632750f, 
    0.00978832f, 0.02938984f, 0.01217313f, -0.00723507f, -0.01841035f, 0.01995087f, 0.02532453f, -0.00087834f, 
    -0.02417454f, -0.02388192f, -0.03045478f, 0.02419404f, 0.02840978f, -0.04127426f, 0.01562315f, 0.01530483f, 
    -0.01889356f, -0.02840142f, -0.02032097f, 0.02413336f, -0.04262138f, -0.00527035f, -0.02591409f, -0.01433199f, 
    0.01049039f, -0.01689043f, 0.00780113f, 0.02273101f, 0.00709524f, -0.02910950f, -0.03564177f, 0.00225827f, 
    -0.02911539f, -0.02702662f, -0.02460333f, 0.02717897f, -0.02845546f, 0.00158444f, 0.02579620f, -0.00674820f, 
    0.02505605f, 0.02382944f, 0.02388788f, -0.00642043f, -0.00694270f, 0.02207626f, 0.01071167f, 0.01594143f, 
    -0.02129121f, 0.00484158f, -0.04389421f, 0.02318407f, -0.02558200f, 0.02660336f, 0.01230409f, -0.03721701f, 
    0.02699225f, 0.02788544f, 0.01627283f, -0.00575012f, 0.00900444f, 0.02201486f, -0.00611327f, -0.04111801f, 
    0.00728801f, 0.02357401f, -0.01926446f, -0.00599257f, -0.02117186f, -0.02972547f, 0.01261522f, -0.04092430f, 
    -0.00390036f, 0.00250280f, -0.00773831f, 0.01382339f, -0.00330334f, -0.01932310f, 0.00049145f, 0.00086555f, 
    0.01661529f, 0.01552535f, -0.00658722f, 0.02685155f, 0.00808880f, -0.01468388f, -0.00907471f, 0.00806085f, 
    -0.03623232f, 0.00186642f, -0.04048568f, 0.01932579f, 0.01368394f, 0.02124266f, 0.01889668f, -0.02675347f, 
    0.02642885f, 0.03142200f, -0.02209370f, -0.01675940f, -0.00763656f, -0.03736647f, -0.03734667f, 0.00991422f, 
    -0.02921357f, 0.02503851f, 0.00947609f, 0.02577873f, -0.02420056f, -0.03040232f, -0.01415634f, -0.01489681f, 
    -0.01232179f, 0.01051869f, -0.01867153f, 0.00065961f, 0.01636071f, -0.03120949f, -0.03258787f, -0.03571271f, 
    0.02719305f, 0.01884136f, -0.04332340f, 0.02261079f, 0.00024756f, -0.00668163f, -0.04378964f, -0.03311124f, 
    0.00096364f, -0.03346011f, -0.01646637f, 0.01293459f, 0.01084327f, -0.00119885f, -0.01019039f, 0.00968292f, 
    -0.01471035f, -0.00760046f, -0.02712973f, 0.02358193f, -0.03373275f, -0.01512943f, 0.02032171f, 0.02259965f, 
    0.02675153f, 0.00374396f, -0.00779807f, 0.01186578f, -0.00578291f, -0.03396844f, -0.03370830f, -0.03386090f, 
    -0.03807540f, -0.02121621f, -0.01102400f, -0.00823725f, -0.00682264f, 0.02113386f, 0.00836419f, -0.03596225f, 
    -0.03935204f, -0.01730853f, -0.03353751f, -0.00071580f, -0.03695707f, -0.03706043f, -0.02245741f, -0.00090044f, 
    -0.04324088f, -0.02136983f, 0.01677698f, 0.01443592f, -0.00403715f, -0.00481740f, -0.00536165f, -0.03593768f, 
    -0.02331742f, -0.00335849f, -0.01349321f, 0.02294136f, 0.00623729f, 0.00279420f, -0.04100552f, -0.02123683f, 
    -0.00214685f, -0.03459715f, 0.01720488f, -0.01206762f, 0.00817296f, 0.00886111f, 0.02914554f, -0.02285235f, 
    0.01612474f, 0.02587419f, 0.01974742f, 0.01625506f, -0.03432380f, -0.00010521f, -0.04014608f, 0.02133186f, 
    0.00383633f, 0.00701720f, -0.02527389f, -0.00213013f, -0.02101987f, -0.03802175f, 0.02027155f, -0.03289636f, 
    -0.03772523f, -0.03836045f, 0.02193407f, 0.02561560f, 0.02722611f, 0.01068752f, -0.02547916f, -0.02629557f, 
    -0.03327560f, -0.03558043f, 0.02189830f, -0.00125743f, 0.00238161f, -0.03659929f, -0.01558383f, -0.00146235f, 
    -0.01166015f, 0.03912637f, -0.03012128f, 0.00680605f, 0.00856286f, -0.03673864f, 0.02667756f, -0.03724514f, 
    -0.00242070f, 0.00883400f, 0.00651026f, 0.01084933f, 0.02776701f, 0.00956676f, -0.00835005f, 0.02469636f, 
    0.01703490f, 0.01108065f, -0.02507783f, 0.00089055f, -0.02319079f, -0.01250377f, -0.02828911f, -0.02800258f, 
    -0.01535223f, 0.00852963f, 0.01718630f, 0.01873786f, -0.00998548f, 0.02618761f, 0.03007981f, 0.01274171f, 
    -0.02009538f, -0.01624434f, -0.01739116f, -0.03684419f, -0.04023214f, -0.00659341f, 0.02736393f, 0.00126046f, 
    -0.03607977f, 0.02289267f, -0.04018632f, 0.01912527f, 0.01252994f, -0.04016757f, 0.02160517f, 0.02532657f, 
    0.02066241f, -0.03592122f, -0.03898608f, -0.01387483f, 0.01673409f, -0.01225582f, -0.00152736f, 0.02175737f, 
    0.01951870f, 0.02922595f, 0.03543187f, 0.00245872f, 0.02616587f, -0.02388421f, 0.01408789f, 0.01880365f, 
    -0.01314035f, -0.00569945f, -0.02636926f, -0.02585503f, -0.02121256f, -0.03483691f, -0.03188851f, -0.00918552f, 
    0.00103824f, 0.01204972f, -0.02800678f, -0.00451466f, 0.02740503f, -0.03378386f, -0.04029959f, -0.00637155f, 
    0.02156547f, 0.02472946f, -0.02660411f, -0.03820645f, 0.00164043f, 0.01990159f, 0.02444290f, -0.00916792f, 
    0.02073066f, 0.02088488f, 0.00628378f, 0.02011673f, -0.03665026f, 0.00778858f, 0.02646908f, -0.01308590f, 
    -0.00430080f, -0.00033159f, -0.03373696f, -0.03272916f, -0.01331989f, -0.02218388f, 0.00079403f, 0.02241996f, 
    -0.01470165f, -0.03255544f, 0.00930324f, -0.02656339f, -0.00801857f, -0.00590520f, -0.02628664f, 0.02274616f, 
    0.00431201f, 0.02978685f, -0.02295800f, 0.02051548f, 0.02961569f, 0.02578390f, -0.01245708f, -0.01539299f, 
    -0.03137500f, 0.00834821f, -0.00087242f, 0.01287095f, 0.00714000f, -0.04043657f, -0.03132480f, 0.02256049f, 
    -0.02015057f, -0.03842330f, -0.00546092f, -0.02991774f, -0.01317381f, -0.00775462f, -0.02493157f, -0.04160007f, 
    -0.00552583f, 0.03020008f, -0.00861902f, -0.04067201f, 0.00488672f, 0.02344268f, -0.03561845f, -0.03236755f, 
    0.00480486f, 0.02083570f, 0.02675657f, 0.00068977f, 0.01571549f, -0.02955606f, 0.01885778f, 0.02706033f, 
    0.01501609f, 0.01894158f, 0.02535965f, 0.02282357f, 0.02092711f, -0.03815333f, 0.01929498f, -0.01780666f, 
    -0.00627733f, -0.00943793f, 0.00757426f, -0.03052815f, 0.01185363f, -0.03169600f, 0.01653951f, -0.02813336f, 
    0.02045308f, 0.02262217f, -0.04142322f, 0.02335152f, -0.01550937f, 0.00134111f, -0.01402494f, -0.03910487f, 
    -0.00186806f, -0.00388722f, 0.02994504f, -0.01191633f, -0.03592829f, 0.00264591f, 0.01275319f, -0.03100161f, 
    0.01989245f, 0.01800410f, -0.01521990f, -0.02011217f, -0.00193274f, 0.00679206f, -0.01773061f, -0.02913227f, 
    -0.03856725f, -0.00172973f, -0.02222506f, -0.01999077f, 0.00110643f, -0.03220565f, 0.00723869f, 0.02344089f, 
    -0.03367568f, 0.01421483f, 0.00323813f, 0.02654775f, 0.01768146f, -0.04101131f, 0.02119169f, -0.03066480f, 
    0.03023732f, -0.03133100f, -0.03006378f, 0.00401131f, -0.03816601f, 0.01717481f, 0.01161432f, -0.03075604f, 
    -0.01885418f, -0.03396847f, 0.01119712f, 0.01829864f, -0.02708651f, -0.01258831f, 0.01773478f, -0.00175014f, 
    0.02221921f, -0.02156369f, 0.01599585f, -0.02385417f, -0.03199100f, -0.00689724f, -0.00433548f, 0.02186998f, 
    -0.01383843f, -0.00309496f, -0.03762771f, -0.03308208f, -0.00159654f, -0.01628026f, 0.00488600f, 0.02442084f, 
    0.02440343f, -0.01198395f, -0.01361840f, 0.00260336f, -0.02947376f, -0.03577786f, 0.02784209f, 0.00395223f, 
    0.00757774f, 0.02241239f, -0.03148132f, 0.00369297f, -0.02835316f, -0.01628901f, 0.00541103f, -0.02494703f, 
    -0.02737568f, 0.02676704f, -0.01371718f, -0.00916107f, 0.03947321f, 0.02139784f, -0.00694101f, 0.02282094f, 
    -0.00402313f, -0.01318603f, -0.00960158f, 0.00853477f, -0.00511914f, -0.02936395f, -0.01526860f, -0.03758844f, 
    0.00438196f, -0.00776188f, -0.02465272f, -0.01549923f, -0.00066413f, 0.02379894f, 0.01186746f, -0.04036817f, 
    -0.03567548f, -0.02888696f, -0.01828038f, -0.03557963f, -0.02406416f, -0.01820493f, 0.00077010f, -0.04097129f, 
    -0.01498119f, -0.00257796f, -0.02207887f, -0.00494603f, -0.01824633f, -0.02119617f, 0.00422121f, -0.02828601f, 
    0.02472323f, -0.00258909f, -0.02995883f, -0.04001579f, -0.02107767f, 0.03758368f, 0.02708589f, -0.02417088f, 
    0.02013024f, 0.02657505f, 0.01058360f, 0.01553989f, -0.00640274f, 0.00761967f, 0.01911603f, -0.00091334f, 
    -0.00450404f, 0.01064187f, 0.00542747f, -0.00096511f, -0.02981356f, 0.00873916f, -0.00290455f, -0.04132050f, 
    -0.02168399f, 0.00516085f, -0.01397320f, -0.01379978f, -0.00579866f, 0.00442964f, 0.02427122f, 0.01914931f, 
    -0.00767539f, -0.00205278f, -0.02852321f, -0.02274379f, -0.00480943f, -0.01968779f, 0.01651487f, -0.00958689f, 
    -0.01483011f, -0.01069239f, 0.00687823f, 0.01933736f, -0.01639565f, 0.00602277f, 0.02875408f, 0.02016359f, 
    0.01334004f, -0.04158885f, 0.00150467f, 0.00034334f, -0.00287137f, 0.01999427f, 0.01211759f, -0.02925810f, 
    -0.00772303f, -0.00707241f, 0.00298113f, -0.02231428f, -0.03274245f, 0.03019975f, 0.00783683f, -0.02177288f, 
    0.03962834f, -0.04097302f, -0.02357403f, -0.03964005f, -0.01729236f, -0.01711355f, 0.00619760f, -0.03921520f, 
    0.02017986f, 0.00368450f, -0.00977543f, -0.02315663f, 0.02895912f, -0.00858921f, -0.02283261f, -0.00428857f, 
    0.01850433f, -0.02321038f, -0.00610102f, -0.00941013f, -0.04085356f, 0.00001163f, 0.01326140f, -0.01374380f, 
    -0.00674420f, 0.02293335f, -0.00845414f, -0.00649213f, 0.00517724f, -0.00460228f, 0.01796066f, 0.00342484f, 
    -0.01950346f, 0.02493703f, -0.00599768f, -0.00012076f, -0.03192273f, 0.01266593f, -0.01531514f, -0.04124227f, 
    -0.02901980f, -0.03860273f, -0.01745362f, -0.01636346f, 0.01940793f, 0.00138403f, -0.02572508f, -0.02849647f, 
    0.02134419f, -0.02700086f, 0.01281353f, 0.00224295f, -0.02521678f, -0.02877007f, -0.01157064f, 0.02418929f, 
    -0.02519353f, 0.02107242f, 0.00338525f, 0.00812514f, -0.01793206f, -0.01773799f, -0.03374963f, -0.01254808f, 
    0.02275755f, -0.01504111f, 0.00252918f, -0.01274691f, 0.01857463f, 0.01911208f, 0.01119738f, -0.00286536f, 
    0.00380558f, -0.03487845f, 0.02075005f, -0.02998786f, -0.00164224f, -0.03730406f, 0.02094764f, -0.00963570f, 
    -0.02649986f, 0.00029848f, -0.02061580f, 0.00120733f, 0.01723297f, -0.00674151f, -0.02927170f, 0.02216007f, 
    -0.02022806f, 0.01968287f, 0.00770260f, 0.01762119f, -0.02220050f, 0.01604255f, 0.01009734f, 0.00524710f, 
    -0.03714374f, -0.04108759f, -0.00886290f, 0.02258925f, 0.01310203f, -0.01306436f, 0.02638592f, -0.01807971f, 
    0.02480235f, -0.02583916f, -0.03459043f, -0.01847509f, -0.02530029f, 0.01195432f, -0.02639651f, 0.01319403f, 
    -0.03814580f, -0.01374008f, -0.01066711f, 0.02691070f, -0.04116849f, 0.02670461f, -0.02764743f, -0.02704610f, 
    0.01427078f, -0.01978443f, -0.02115405f, -0.00309654f, -0.00016404f, 0.00407927f, -0.02833483f, 0.00172832f, 
    0.01086240f, -0.01812717f, 0.01226729f, -0.04132584f, -0.01226014f, -0.03508150f, -0.02667226f, 0.02471274f, 
    0.01448749f, -0.03710717f, -0.03314335f, 0.00273677f, -0.03689507f, 0.01552466f, 0.01632915f, -0.02283427f, 
    -0.03117477f, -0.02474003f, 0.00030451f, -0.02381543f, -0.02879855f, 0.02418275f, -0.00965599f, -0.00207639f, 
    -0.03515612f, -0.02445841f, -0.00861819f, -0.03753994f, -0.03280622f, -0.00094567f, 0.00836981f, -0.02469682f, 
    0.01138274f, 0.02235916f, -0.01127667f, 0.02010074f, -0.03235840f, 0.00069846f, 0.02703714f, -0.01678434f, 
    0.02020204f, -0.01330978f, -0.02052816f, -0.02083995f, 0.02537673f, 0.02420853f, 0.01691106f, 0.01282665f, 
    -0.00997124f, -0.03940381f, -0.01229763f, 0.00238205f, 0.00619303f, 0.02009269f, -0.02832699f, -0.01306038f, 
    -0.00370979f, -0.02254981f, -0.02452267f, -0.00963579f, -0.00463952f, -0.00841596f, 0.00050608f, -0.02476105f, 
    0.01110206f, 0.01824247f, 0.01505182f, 0.00801657f, -0.03237417f, 0.03002815f, 0.01214541f, 0.01966732f, 
    -0.03384092f, 0.02556446f, -0.00244506f, -0.01498741f, -0.00264489f, 0.01968315f, -0.02605364f, -0.04144215f, 
    -0.02566495f, 0.00991511f, -0.00403174f, -0.01345689f, -0.00943934f, 0.01315359f, -0.01669948f, 0.02216193f, 
    0.00538750f, 0.02317368f, -0.02125829f, 0.01859620f, -0.01833061f, -0.01954412f, 0.01539081f, -0.03440408f, 
    0.02668559f, 0.00554188f, 0.00146930f, 0.00991249f, 0.01012593f, -0.03458805f, -0.03784093f, -0.02312262f, 
    0.01286349f, -0.03951928f, -0.00584599f, -0.01738137f, 0.02550206f, -0.03068802f, -0.00308665f, -0.02876413f, 
    0.00614757f, -0.04006598f, -0.01151961f, -0.01642300f, -0.01527282f, 0.00538375f, 0.02130048f, -0.03484653f, 
    -0.00048542f, -0.00303570f, -0.01443181f, -0.02435499f, -0.00089103f, -0.00629694f, 0.01606299f, 0.02538170f, 
    -0.02699166f, -0.01632116f, -0.01084425f, -0.00064941f, -0.02104504f, -0.00391344f, -0.02616779f, -0.01824443f, 
    0.03034876f, -0.01690740f, -0.00724911f, -0.01078917f, -0.02411387f, 0.01405664f, -0.01524034f, -0.03129945f, 
    -0.02356978f, 0.00621233f, 0.02148214f, -0.00935498f, -0.04124108f, -0.00359544f, -0.00117408f, 0.02043822f, 
    -0.00164201f, -0.01638928f, -0.00739680f, -0.01187645f, -0.03880196f, -0.01362348f, -0.02998596f, 0.02287543f, 
    0.01272325f, -0.00840909f, -0.03567129f, -0.01211838f, 0.00169805f, -0.03648217f, -0.04019048f, -0.01471583f, 
    0.01578290f, -0.03424581f, -0.01382640f, 0.00067343f, 0.02630987f, -0.02619298f, -0.00434508f, 0.01277582f, 
    -0.00502868f, -0.02911189f, -0.03800017f, -0.01875107f, -0.01122710f, -0.00859449f, -0.02292119f, -0.03638254f, 
    -0.00932483f, 0.01393318f, 0.02097207f, -0.01285739f, 0.01444791f, -0.01564280f, -0.00627017f, 0.01917045f, 
    -0.02802249f, -0.03956116f, 0.02307460f, 0.00971415f, -0.00441091f, -0.02329393f, 0.00899555f, -0.03172411f, 
    0.00613354f, 0.01018995f, 0.02665352f, -0.04049557f, -0.01833129f, 0.02151452f, -0.03987581f, -0.02898695f, 
    -0.01146006f, 0.02303560f, -0.00930782f, -0.02129502f, 0.01192298f, -0.00751281f, -0.01772636f, -0.02879346f, 
    0.00093373f, -0.02566754f, -0.01315186f, 0.00674113f, -0.02551668f, 0.00181184f, 0.01087927f, -0.00316581f, 
    -0.03173440f, -0.04063092f, -0.02426015f, 0.00114567f, -0.02558223f, 0.00743131f, -0.00699837f, 0.02453702f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02869472f, 0.04271161f, 0.05925933f, 0.03070729f, -0.04538171f, 0.01587817f, 0.05707390f, 0.00213359f, 
    0.03930810f, 0.05617205f, -0.00107912f, 0.00145100f, -0.02760701f, -0.01852609f, 0.02278940f, -0.02944511f, 
    0.02244745f, 0.01010934f, -0.02097591f, 0.08739722f, 0.02645482f, 0.01712578f, -0.02484801f, 0.00897936f, 
    -0.00027260f, -0.02340239f, -0.03376016f, 0.00810149f, 0.03789126f, -0.01425002f, -0.04173428f, 0.02040602f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03369794f, 0.08292741f, 0.23666471f, -0.02206955f, -0.03315444f, -0.06097348f, -0.22502054f, -0.54552072f, 
    0.25407895f, 0.18434720f, 0.13038634f, -0.06094013f, 0.02046596f, 0.11434275f, 0.08770550f, 0.11088303f, 
    0.05471761f, 0.02144360f, -0.14841421f, -0.23105317f, -0.14751872f, -0.00161752f, -0.35028464f, -0.10945524f, 
    -0.16969678f, 0.18256414f, 0.12425867f, -0.12626542f, 0.15622705f, -0.30646420f, 0.08714931f, -0.09617113f, 
    0.14061043f, -0.05186457f, -0.09715967f, -0.01452140f, 0.04100035f, 0.05865400f, 0.16141269f, 0.08569378f, 
    -0.16117114f, -0.16428953f, -0.00234403f, 0.16230205f, 0.05279003f, 0.02067729f, -0.05840179f, -0.16486378f, 
    0.09311012f, -0.13403583f, -0.06224588f, 0.09520706f, -0.07447916f, -0.16952142f, 0.04250469f, -0.08053134f, 
    0.02662064f, -0.02258042f, -0.16459544f, 0.05432957f, -0.17826185f, -0.16134690f, 0.16759314f, 0.13181132f, 
    -0.08359604f, -0.16290927f, -0.12156036f, -0.07004646f, 0.08943527f, 0.05253634f, 0.06764099f, -0.07060830f, 
    -0.01925169f, 0.01744941f, 0.05307354f, 0.12114726f, 0.00225732f, -0.16258775f, -0.17304812f, -0.09311099f, 
    -0.12902460f, 0.06438795f, 0.10883962f, -0.14277622f, 0.12818545f, 0.00206985f, -0.05140198f, -0.06102503f, 
    0.12270572f, -0.16395034f, 0.05455174f, -0.07314429f, 0.02021468f, -0.10440177f, 0.10078409f, 0.14859687f, 
    -0.01729646f, -0.13444816f, -0.24321596f, 0.29267788f, 0.10457522f, -0.17188783f, -0.03946965f, -0.08115161f, 
    -0.31889254f, 0.28676337f, -0.12231775f, 0.01401193f, -0.16724429f, -0.14654677f, -0.01785468f, -0.15057069f, 
    -0.16955118f, -0.16511396f, 0.00046908f, 0.05752280f, -0.17873195f, -0.07838833f, -0.01964690f, 0.18176655f, 
    -0.02507741f, -0.35540923f, 0.01816064f, -0.12503548f, 0.21532695f, 0.38507390f, 0.07685904f, 0.02911530f, 
    0.09367493f, 0.29420269f, -0.00785096f, -0.03365958f, 0.12300814f, -0.01848474f, 0.13098866f, 0.22456707f, 
    -0.54652488f, 0.03337734f, -0.07091755f, 0.07614298f, 0.01691890f, 0.09370001f, 0.38531172f, -0.05692724f, 
    -0.14971998f, -0.16266011f, 0.07580014f, 0.08995266f, 0.03218466f, -0.05774763f, 0.09398595f, -0.10393556f, 
    -0.10767358f, -0.10481836f, 0.01826567f, 0.16093166f, -0.08637312f, -0.09493328f, -0.05679383f, -0.05591210f, 
    -0.16367932f, 0.08806423f, -0.11962868f, 0.02271161f, 0.12536384f, 0.23821603f, -0.11986261f, -0.09008963f, 
    -0.13409193f, -0.02076511f, -0.08238193f, -0.02611723f, 0.14963494f, 0.11060426f, 0.32992345f, 0.16935194f, 
    0.17507242f, -0.08127556f, -0.03583285f, 0.33377060f, -0.14917172f, -0.11103635f, 0.15009758f, -0.16766492f, 
    0.14227118f, 0.26664463f, 0.03850485f, 0.11103830f, -0.15029566f, -0.21072136f, -0.09001382f, -0.08827858f, 
    -0.11033497f, -0.20613068f, -0.15650073f, 0.14143147f, 0.01500979f, -0.06672359f, 0.06977327f, 0.43630567f, 
    0.40437654f, 0.09243396f, -0.15386237f, 0.08940535f, -0.06413792f, 0.08912408f, 0.51208764f, 0.12958190f, 
    0.13931423f, 0.09559446f, -0.06913555f, 0.46719956f, 0.15234143f, -0.14177686f, 0.11631270f, -0.16267388f, 
    0.05416824f, -0.17613889f, -0.17214741f, 0.13888876f, 0.16372032f, -0.28771710f, -0.17380658f, -0.04143634f, 
    -0.12565129f, 0.24032187f, -0.25201657f, -0.26252592f, -0.08709918f, 0.24347626f, 0.28837237f, 0.24911126f, 
    -0.08382647f, 0.21864174f, 0.10582842f, 0.10353339f, -0.01093503f, 0.16126789f, -0.20731384f, -0.08345322f, 
    0.00068676f, -0.11766550f, 0.10800901f, 0.14420308f, -0.02321193f, 0.13791633f, -0.52614874f, -0.01362090f, 
    -0.03474620f, 0.20340104f, -0.16166596f, -0.02831145f, 0.12700151f, -0.03840199f, -0.01998545f, -0.01363942f, 
    -0.11576577f, -0.14184597f, 0.23388499f, 0.18561625f, -0.02315022f, -0.00254236f, 0.39699176f, 0.03198539f, 
    0.46289721f, -0.10091392f, 0.08948806f, -0.05890549f, -0.06384479f, -0.01792101f, -0.20084105f, -0.15986224f, 
    0.00575083f, 0.16468455f, 0.00485696f, 0.26940221f, 0.11664752f, 0.11461113f, -0.37932298f, 0.00446077f, 
    -0.00744653f, 0.23925129f, 0.10644945f, -0.02461400f, 0.00311763f, -0.03661370f, 0.10950609f, -0.07588127f, 
    0.12716463f, -0.03188541f, 0.10955010f, -0.25791508f, -0.00454829f, 0.23035046f, 0.30245596f, -0.09691409f, 
    -0.29118514f, 0.12163121f, -0.07135811f, 0.09505798f, -0.11523845f, 0.03953372f, -0.14637569f, -0.00954738f, 
    0.02589058f, 0.13410260f, -0.11618008f, -0.56670952f, 0.07516050f, 0.16318515f, 0.29579276f, 0.16347921f, 
    -0.09184770f, 0.32999775f, 0.00433749f, 0.09415972f, -0.08656219f, 0.00382964f, -0.09020124f, 0.14798024f, 
    -0.03985157f, -0.09296686f, 0.05906493f, -0.17938708f, -0.01458664f, -0.17129909f, -0.10710639f, 0.13188189f, 
    -0.01296722f, -0.01790060f, 0.13740973f, -0.10988860f, 0.03475447f, -0.06076728f, -0.09584180f, 0.09552990f, 
    0.13522893f, 0.10464656f, 0.02457156f, -0.01921132f, 0.11628879f, -0.14391965f, -0.09031577f, 0.11315621f, 
    0.04867591f, -0.08285064f, 0.16403112f, -0.03266900f, -0.07928035f, -0.06018892f, 0.11406233f, -0.12516619f, 
    -0.07604436f, 0.19311978f, -0.09724256f, -0.05968562f, -0.08132186f, 0.44775921f, -0.10242749f, -0.05426191f, 
    -0.34986889f, 0.13832408f, -0.14028591f, -0.03373179f, 0.06871076f, 0.12281632f, -0.09018596f, -0.08985815f, 
    0.13401379f, -0.07711855f, -0.09017012f, -0.40718085f, -0.11101861f, 0.02327648f, 0.02751466f, -0.11507034f, 
    -0.11759637f, -0.07121281f, 0.11780280f, 0.15047644f, 0.36047485f, 0.38381764f, 0.05710616f, 0.00994486f, 
    -0.00050704f, -0.23190339f, 0.17823534f, 0.36219162f, 0.08987585f, 0.12159365f, 0.10210128f, -0.26812223f, 
    0.37176749f, -0.14553595f, 0.09780808f, 0.11732125f, -0.01787352f, -0.06013673f, 0.26588467f, 0.10571910f, 
    -0.16237171f, 0.00630933f, 0.10261200f, 0.38645184f, 0.18270215f, 0.09743115f, -0.20398439f, 0.08601224f, 
    0.14975742f, -0.02060450f, 0.14392735f, 0.06792929f, 0.12491453f, 0.03897442f, 0.14292595f, -0.02316334f, 
    0.07366788f, -0.03586956f, 0.27509609f, 0.34301326f, -0.14128716f, -0.23447694f, -0.09025963f, -0.45472825f, 
    -0.03372390f, -0.00944523f, -0.02888030f, 0.11197770f, 0.16272244f, 0.08616592f, 0.24758261f, 0.03093264f, 
    -0.02281822f, -0.10857386f, -0.05408676f, 0.22671473f, -0.05824583f, 0.15614712f, 0.20556086f, 0.17083529f, 
    -0.11570565f, 0.23808987f, -0.11226466f, 0.14743648f, -0.07591638f, -0.05886377f, 0.11460959f, 0.05959235f, 
    -0.03671412f, 0.50838095f, 0.23349197f, -0.07190357f, -0.16136649f, 0.02237846f, 0.12649599f, 0.28825426f, 
    0.14274848f, 0.08448501f, -0.03213770f, -0.03873909f, 0.08879388f, -0.05082700f, 0.56079721f, -0.04879374f, 
    0.13983408f, 0.05945087f, 0.14388907f, -0.25720513f, -0.03488064f, 0.17512922f, 0.45596510f, -0.04710885f, 
    -0.08966892f, -0.29788861f, -0.11464208f, 0.06044099f, -0.20604318f, 0.01062611f, -0.08842864f, 0.10438091f, 
    -0.11504030f, -0.20541102f, 0.05337403f, 0.05284110f, -0.05608876f, -0.01394737f, -0.39664248f, -0.21447693f, 
    0.17010202f, 0.21901341f, 0.14071436f, -0.03739372f, -0.08553062f, 0.09900568f, -0.19770603f, -0.02265792f, 
    -0.01885639f, -0.03772461f, -0.08292142f, -0.35364512f, -0.05803170f, -0.16175529f, -0.05774483f, -0.12448899f, 
    0.11812596f, 0.11666960f, -0.06004718f, 0.07044561f, 0.40119272f, -0.08233961f, -0.07250521f, -0.14916536f, 
    -0.08837056f, -0.05899199f, 0.11164013f, 0.07873005f, 0.16720611f, -0.10858661f, 0.00829632f, 0.03566171f, 
    -0.18388291f, -0.13505273f, -0.00846157f, 0.10433954f, -0.02121206f, 0.12393173f, 0.07171216f, -0.05511181f, 
    -0.06646705f, 0.05373446f, -0.11266396f, -0.11612376f, 0.11014995f, -0.16198787f, 0.07789948f, 0.04302033f, 
    -0.06179903f, -0.06598198f, -0.10880686f, -0.00427765f, -0.04093213f, -0.07825032f, 0.14265095f, -0.02813927f, 
    0.14445163f, -0.14722535f, -0.09440936f, -0.05377537f, -0.11206010f, -0.09529994f, -0.09258392f, 0.08945899f, 
    -0.04621080f, -0.03118264f, 0.08564571f, 0.04954208f, 0.11308370f, 0.02342338f, -0.08696139f, 0.06531476f, 
    -0.12376627f, -0.00333877f, 0.12464859f, 0.11648746f, -0.17575403f, -0.15198031f, -0.06108543f, -0.01255928f, 
    -0.06419085f, 0.04753950f, -0.12972137f, -0.01583309f, -0.18066269f, -0.05494067f, 0.11860584f, 0.15832242f, 
    -0.12308643f, -0.16519505f, 0.01638944f, 0.01478714f, -0.05555977f, -0.22490378f, 0.19608304f, -0.17354906f, 
    -0.33660316f, 0.28464326f, -0.12250521f, 0.12673904f, -0.17546830f, 0.13693985f, 0.04006952f, -0.04160114f, 
    0.11211030f, 0.01545579f, -0.08318903f, 0.06780796f, -0.03401546f, 0.13128506f, 0.23323190f, 0.02504558f, 
    -0.18093920f, -0.28199178f, 0.07072348f, 0.09899469f, -0.26682785f, 0.34881097f, -0.18315472f, 0.00853402f, 
    -0.00286129f, -0.09487401f, -0.04620112f, -0.12396695f, -0.16168475f, 0.07292477f, 0.02293655f, 0.06993578f, 
    0.12310593f, -0.13031517f, -0.15326095f, 0.06739157f, -0.09047733f, 0.02109989f, -0.16036546f, 0.09191045f, 
    -0.02842468f, -0.11267045f, -0.06467969f, 0.09478198f, 0.15325291f, -0.04800675f, 0.13897045f, -0.10546547f, 
    0.10133365f, -0.06251174f, -0.03482895f, 0.13858595f, -0.14230099f, -0.08114876f, 0.09403082f, -0.01304502f, 
    -0.00456358f, 0.44507101f, 0.23096126f, 0.12119928f, 0.12432496f, 0.34794885f, -0.10846731f, -0.28538841f, 
    0.00484594f, 0.21137765f, -0.00779232f, -0.07983280f, 0.07314932f, -0.08218814f, 0.10658928f, 0.06766356f, 
    -0.09891181f, 0.00359864f, -0.10440666f, -0.08847984f, 0.06832732f, -0.11942324f, -0.35664177f, 0.10065365f, 
    -0.00836440f, -0.32936829f, 0.14191706f, 0.01219649f, 0.02312949f, -0.16181858f, 0.02062442f, 0.12236772f, 
    0.13987657f, 0.12243301f, 0.03356088f, 0.03795511f, 0.16786622f, 0.14289154f, 0.03709450f, -0.20634688f, 
    0.06993046f, 0.11499459f, -0.05982899f, -0.15494359f, -0.13863908f, -0.00517433f, -0.23707773f, 0.01462394f, 
    -0.12763308f, -0.06381769f, 0.00231247f, 0.10687579f, 0.05119651f, 0.04354300f, 0.42983758f, -0.11117364f, 
    0.15006854f, 0.19705565f, 0.02861024f, -0.03639251f, -0.45973092f, -0.04700168f, -0.03139845f, 0.14929515f, 
    0.09906375f, 0.03129401f, 0.13424252f, 0.04728051f, -0.16436502f, -0.36316043f, 0.33299315f, 0.13829462f, 
    0.26606932f, -0.02041215f, 0.16894506f, -0.15072590f, -0.02506527f, -0.06669292f, -0.40255278f, 0.14724471f, 
    0.00355896f, -0.09755954f, -0.15584940f, 0.26224431f, -0.08760195f, 0.11079168f, 0.06270108f, 0.09610903f, 
    -0.04258065f, 0.20339991f, 0.14467332f, 0.05803647f, -0.08095443f, -0.04343564f, -0.00589872f, 0.10532346f, 
    -0.04963784f, -0.07298697f, -0.01065246f, -0.24129504f, 0.03253711f, -0.08978815f, 0.39936110f, 0.45753357f, 
    0.09089872f, 0.12362817f, 0.14205298f, 0.08060667f, -0.15980120f, -0.00409701f, 0.19336143f, -0.13364430f, 
    -0.13873085f, -0.14007989f, -0.03312463f, -0.35002920f, -0.02219301f, -0.13214616f, 0.33824942f, 0.11808222f, 
    -0.16809063f, -0.09188014f, 0.06180388f, -0.16141486f, -0.04569392f, 0.33786622f, -0.03097218f, -0.10798199f, 
    0.15006849f, 0.33249483f, 0.34147412f, -0.13536876f, 0.11593661f, -0.36238614f, 0.14982890f, -0.20778327f, 
    -0.23852500f, 0.07857087f, -0.00046626f, -0.12794438f, -0.02511206f, 0.09344199f, -0.40606534f, -0.10305575f, 
    -0.14815043f, -0.12048207f, 0.04198351f, -0.22748764f, 0.12517646f, -0.16704313f, 0.11542378f, -0.14904599f, 
    -0.14971301f, 0.35282296f, 0.01403504f, -0.13270847f, -0.02760487f, 0.27848592f, 0.11215923f, -0.00311564f, 
    -0.01636792f, -0.17291811f, -0.00799344f, 0.07775959f, -0.11779108f, -0.13965939f, 0.18418325f, 0.14150019f, 
    0.08325971f, 0.10065711f, -0.16134529f, -0.10178082f, -0.16412994f, 0.07710576f, -0.36219424f, -0.16718607f, 
    0.15489061f, 0.07303389f, -0.13162680f, 0.25242537f, -0.03980926f, -0.09248435f, -0.20776552f, 0.01026949f, 
    -0.08623055f, 0.37200129f, -0.06006095f, 0.11680356f, -0.12055997f, -0.29564801f, -0.04228689f, 0.08898253f, 
    0.08722783f, -0.00576432f, 0.30397090f, 0.11975008f, -0.09394341f, 0.24919921f, 0.12921825f, 0.10458624f, 
    0.36664349f, -0.21124049f, 0.00988460f, -0.01313900f, -0.02833408f, 0.13640377f, -0.13589704f, -0.10102475f, 
    0.09616115f, -0.10254737f, -0.04766737f, -0.01510715f, -0.01651498f, 0.10789730f, 0.00144563f, -0.13763487f, 
    -0.03890079f, 0.12024449f, -0.15026239f, 0.16686173f, 0.44546521f, 0.42531371f, 0.07986261f, 0.05972248f, 
    -0.11947960f, 0.44544849f, 0.21245873f, 0.08380529f, 0.13814704f, -0.04936560f, -0.05834517f, 0.22509307f, 
    0.32142660f, -0.12515619f, 0.08227377f, 0.12258048f, -0.13580880f, 0.15242836f, 0.23412006f, 0.03706623f, 
    0.02770620f, -0.08555093f, 0.07389203f, 0.33912346f, -0.10427594f, -0.05473969f, 0.08884154f, 0.06758010f, 
    0.16583368f, -0.23661281f, -0.16438122f, -0.02928547f, 0.33273962f, -0.13995081f, -0.10984407f, -0.04380317f, 
    0.01503105f, -0.33804056f, -0.06239680f, -0.10985973f, 0.13157625f, -0.24054241f, 0.16378383f, 0.20993115f, 
    -0.09968946f, 0.21904333f, 0.08036742f, -0.14379813f, 0.12325360f, -0.15857975f, -0.20077746f, -0.05480414f, 
    -0.17424402f, 0.10456870f, -0.07817763f, -0.13074814f, -0.09666799f, 0.17003877f, -0.23807980f, -0.03146104f, 
    -0.05715412f, 0.41109440f, 0.06518956f, -0.11521759f, -0.05134796f, -0.38697487f, -0.04145043f, 0.04299785f, 
    0.03970526f, -0.15730919f, -0.00142833f, 0.02054629f, -0.13773459f, 0.08679251f, -0.07711232f, 0.05700236f, 
    -0.12396257f, -0.13884704f, 0.07013074f, -0.00842891f, 0.14914802f, 0.03301040f, -0.03031595f, 0.10158733f, 
    -0.17294239f, 0.09525216f, 0.08183791f, 0.04146858f, -0.09756432f, -0.18174264f, 0.13157222f, -0.16934288f, 
    -0.06146119f, -0.18428299f, -0.11302549f, -0.17436720f, 0.13314000f, -0.00502976f, -0.08017953f, 0.09071118f, 
    0.17563199f, -0.10450253f, 0.08271719f, 0.00512795f, -0.10645459f, -0.15771370f, -0.12945172f, 0.05389564f, 
    -0.10114105f, -0.14481607f, 0.06200333f, 0.13956949f, 0.09798337f, 0.16532166f, 0.04053115f, 0.17064832f, 
    -0.01766478f, -0.05126864f, -0.01789501f, 0.11559270f, -0.16768788f, 0.03467491f, 0.17944622f, 0.04144496f, 
    -0.03495982f, 0.00874264f, 0.13385382f, -0.05520128f, 0.08268764f, -0.15740576f, 0.14432658f, 0.06084508f, 
    0.11852012f, -0.04917306f, -0.08193903f, 0.10460018f, -0.05116388f, -0.03760681f, -0.02743128f, -0.12855172f, 
    -0.00321045f, 0.04467171f, -0.10837578f, -0.16354613f, 0.15985847f, 0.09385924f, 0.05201817f, 0.09776035f, 
    0.00334209f, -0.16723171f, -0.14758426f, -0.06845534f, -0.08120083f, -0.04719319f, -0.06414208f, 0.08282835f, 
    -0.10511562f, -0.14495949f, -0.04107139f, 0.04050867f, -0.07661106f, -0.19199586f, 0.11632194f, 0.10140439f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.19321136f, 0.08241896f, -0.12888274f, 0.12597370f, -0.05340889f, 0.14075623f, 0.04030038f, 0.04979977f, 
    -0.01521226f, 0.06327348f, -0.17684117f, -0.15703532f, -0.11375481f, -0.14836936f, 0.13619606f, 0.04163377f, 
    -0.02153636f, -0.03296692f, 0.18174356f, 0.11241907f, 0.11129282f, -0.00813825f, 0.12321425f, -0.01281607f, 
    0.14373437f, 0.10225983f, 0.15194859f, -0.05462456f, -0.00002065f, -0.06402574f, -0.14290114f, 0.09264392f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.26432866f, -0.06775120f, 0.10718529f, -0.39809403f, -0.50664359f, -0.20337369f, -0.17632990f, -0.33362836f, 
    0.06901351f, 0.25543499f, 0.00633757f, -0.34296408f, -0.03679202f, 0.30097306f, -0.15836488f, 0.29023513f, 
    -0.15479454f, -0.11784998f, 0.03694657f, -0.03870583f, -0.19978626f, 0.13813670f, 0.19152963f, -0.12179575f, 
    0.24111947f, 0.18204539f, -0.14892963f, -0.25253436f, 0.44865340f, -0.19944046f, -0.15597533f, -0.01791667f, 
    0.40796494f, -0.15758671f, -0.03791183f, -0.47163704f, 0.35880387f, 0.35543746f, 0.05497934f, -0.18671268f, 
    0.27747026f, -0.29970995f, -0.13807419f, -0.17452820f, 0.30799603f, 0.26613429f, -0.00230375f, -0.06808218f, 
    0.00946136f, 0.11708516f, -0.37238646f, 0.13326100f, 0.25230324f, 0.05753904f, 0.13477139f, -0.34699544f, 
    -0.04980343f, -0.02818245f, -0.01052284f, 0.25669572f, -0.26419848f, 0.06405710f, -0.07876299f, -0.18891820f, 
    -0.12105367f, 0.06276396f, 0.01003533f, 0.37734136f, -0.67114222f, -0.21178529f, 0.27710795f, -0.65216434f, 
    -0.06505073f, -0.30574882f, -0.01937726f, 0.09697799f, 0.05429525f, 0.16223061f, 0.09380919f, 0.31633162f, 
    0.14236148f, -0.16631481f, 0.21102203f, -0.07764705f, 0.11542192f, -0.07859492f, -0.38367718f, 0.03237208f, 
    -0.34281653f, -0.46290660f, 0.06758154f, 0.07324479f, -0.48027310f, -0.13407242f, -0.17201282f, 0.04775996f, 
    -0.89928085f, -0.07241094f, 0.09837327f, 0.16463490f, -0.05574379f, 0.02759557f, 0.14785235f, 0.26127529f, 
    0.07285425f, -0.10763406f, -0.13005017f, -0.30603543f, -0.44259366f, -0.19964661f, -0.19299097f, -0.18905213f, 
    -0.18161920f, 0.16105609f, 0.14593889f, -0.04289780f, -0.46763781f, 0.26103178f, 0.40637144f, -0.00155826f, 
    0.14045426f, 0.38522804f, -0.45557854f, -0.40772530f, 0.36463490f, 0.13180725f, -0.05971992f, -0.16892333f, 
    0.04687030f, 0.01123815f, -0.08104622f, 0.24941075f, 0.09876090f, 0.13561213f, -0.16553955f, 0.30885983f, 
    0.05044437f, 0.20190375f, -0.03794789f, 0.17115201f, 0.05479318f, -0.31613374f, -0.21858856f, 0.14638434f, 
    0.08575676f, -0.13040525f, 0.15266952f, 0.13937825f, 0.20051616f, -0.23715667f, -0.26364982f, -0.03587050f, 
    -0.10774847f, 0.08325555f, -0.20962784f, -0.51319444f, 0.41683963f, 0.04690390f, -0.02538396f, -0.05338443f, 
    -0.20148782f, -0.01480083f, 0.04511738f, -0.41222069f, -0.60955262f, -0.23418263f, -0.01544910f, 0.24643843f, 
    0.21688157f, 0.03314652f, -0.03290492f, 0.10948654f, -0.20185994f, -0.40743384f, 0.00566083f, 0.07459161f, 
    -0.08166688f, -0.07536404f, -0.38156936f, 0.09046271f, -0.03229144f, -0.21239100f, 0.18405670f, 0.08304151f, 
    0.14298360f, -0.02680362f, 0.20833214f, 0.30634993f, 0.07726050f, -0.14950049f, -0.15195955f, -0.17785409f, 
    -0.54614162f, -0.14107814f, -0.07211988f, 0.03135565f, -0.62671405f, -0.11747317f, -0.65730840f, -0.17650104f, 
    0.07628394f, 0.25544214f, 0.01458692f, 0.21895438f, -0.03230916f, -0.01673505f, -0.10558590f, -0.19191918f, 
    0.04039689f, 0.04574002f, 0.24647069f, 0.05668209f, -0.09350190f, 0.32983509f, 0.16629001f, 0.14708519f, 
    0.34860110f, -0.27196577f, 0.19608298f, -0.30571222f, -0.50970620f, -0.09093256f, -0.09538505f, 0.05351644f, 
    -0.13375652f, -0.05447836f, 0.16056950f, -0.14731914f, 0.02669480f, 0.25175929f, 0.27247742f, 0.08488896f, 
    -0.24637848f, 0.25681022f, -0.10647513f, 0.14929584f, -0.12682799f, -0.38267693f, 0.21360835f, -0.04026023f, 
    0.14597741f, 0.00673494f, 0.06121033f, -0.04272913f, -0.46310383f, 0.07704268f, -0.31990600f, 0.33020595f, 
    -0.53468919f, -0.19865404f, -0.13214743f, -0.25801820f, 0.10395477f, 0.06491403f, 0.11125077f, 0.11761367f, 
    -0.40452832f, 0.09734395f, -0.03918283f, 0.20111191f, -0.00663118f, -0.15501881f, 0.13448301f, -0.15651383f, 
    0.24402823f, -0.36553171f, 0.06840612f, 0.06768671f, 0.33859372f, 0.16986404f, -0.61144567f, 0.22119908f, 
    -0.09869212f, 0.15308392f, -0.10713296f, -0.10767730f, -0.36945873f, -0.44101101f, 0.08710430f, -0.13856201f, 
    0.03318403f, -0.08785225f, 0.33197036f, 0.20511673f, -0.13992283f, -0.15845342f, 0.05547933f, 0.06701297f, 
    0.03789494f, 0.11128701f, -0.00893659f, 0.17081396f, 0.26491868f, 0.30564705f, -0.22572537f, -0.05765622f, 
    -0.59669900f, 0.01616353f, 0.09623072f, 0.34992725f, -0.57866830f, -0.01420162f, 0.11529293f, 0.21978256f, 
    -0.10460822f, -0.16192248f, 0.09993855f, -0.07675944f, 0.27968270f, 0.05923897f, -0.43608579f, -0.19698925f, 
    0.19802561f, -0.58164155f, -0.15755115f, 0.23267199f, -0.36410591f, -0.07812031f, -0.08743209f, -0.15180549f, 
    -0.47697049f, 0.15398170f, 0.05424580f, 0.15822375f, -0.02484500f, -0.18564813f, 0.30681068f, -0.02809538f, 
    0.07594630f, -0.28164098f, 0.16846038f, -0.52770656f, 0.20229769f, -0.15519787f, 0.06625167f, -0.31875172f, 
    0.03354226f, 0.01330395f, 0.19485790f, 0.05158599f, 0.08947080f, -0.05305042f, 0.22379912f, 0.04056879f, 
    -0.70998645f, 0.09027167f, -0.16126600f, 0.34485388f, -0.06378538f, -0.07195749f, -0.03273954f, -0.03771758f, 
    -1.03900063f, 0.08677904f, -0.09170505f, 0.11189807f, 0.27009219f, -0.75565159f, -0.07047018f, -0.26312140f, 
    0.06109845f, 0.04024388f, -0.00122619f, -0.16351479f, -0.11700951f, 0.04477726f, 0.29684567f, -0.66688013f, 
    -0.12834847f, 0.08388487f, 0.28471977f, 0.04336835f, -0.21613419f, -0.15869439f, 0.21853596f, 0.25459835f, 
    0.28546131f, -0.26059321f, -0.02453288f, 0.04737448f, -0.20702143f, -0.07603034f, -0.01004781f, 0.14019653f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.06082230f, 0.15780628f, -0.09044857f, -0.03263874f, 0.06577252f, -0.01487057f, -0.12747157f, 0.10752289f, 
    -0.01294553f, 0.13702573f, 0.02541333f, -0.01155578f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
