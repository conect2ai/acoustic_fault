#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.08491002f, 0.15796989f, 0.42369163f, 0.52281123f, 0.18398653f, 0.80649853f, -0.04245802f, -0.14930694f, 
    0.06459025f, 0.41525820f, 0.45919126f, -0.31027538f, -0.36180270f, -0.46327847f, -0.43221784f, -0.14504726f, 
    -0.15549576f, -0.07975425f, -0.24459100f, -0.08910646f, 0.20726232f, -0.31082386f, -0.46214730f, 0.48009118f, 
    -0.41082025f, 0.49931306f, 0.12807211f, 0.08812951f, 0.12065345f, -0.03125005f, 0.00641945f, 0.23176104f, 
    0.15872645f, 0.12636073f, -0.25559315f, 0.12234848f, 0.44161990f, 0.10722250f, 0.53711480f, -0.21591102f, 
    -0.11531249f, 0.14914148f, -0.06808363f, 0.23657092f, 0.01201722f, 0.17215681f, 0.08524624f, 0.05588229f, 
    0.51467532f, 0.34997422f, 0.54726118f, 0.10334595f, 0.51407421f, 0.08710006f, -0.80163556f, -0.65824813f, 
    0.11246946f, 1.16151083f, -0.53210121f, -0.11700708f, -0.02793334f, 0.11375830f, 0.21467002f, 0.29252422f, 
    -0.52932036f, 0.27232930f, 0.18937977f, -0.57464176f, -0.14789365f, 0.21363510f, -0.00745739f, -0.09624901f, 
    -0.38303941f, -0.03577391f, 0.51411980f, -1.21441627f, -0.90191585f, -0.80446857f, 0.23853724f, 0.95896453f, 
    -0.30814829f, 0.33509105f, -0.72683823f, -0.48490551f, 0.24837865f, 0.69009179f, 0.57158661f, 0.44480625f, 
    -0.19396590f, 0.34000230f, -0.09606439f, 0.08625104f, -0.26598489f, -0.17685623f, 0.11767312f, 0.30678356f, 
    -0.29357350f, 0.12291750f, 0.21463679f, 0.10229561f, -1.59215379f, -1.13098443f, -0.59832597f, -0.93295211f, 
    -0.95513564f, 0.90397859f, -0.80625689f, -1.10995734f, -0.59048158f, -0.41694006f, -0.18942289f, -0.22325070f, 
    -0.50826257f, -0.54463661f, -0.45550358f, -0.20060362f, -0.85641295f, -0.34562233f, -0.43655175f, -0.45937499f, 
    -0.04400482f, 0.47256887f, 0.00752057f, -0.39868596f, -0.29993951f, 0.33994660f, 0.06225802f, -0.53056294f, 
    0.62757039f, -0.12936300f, 0.18543474f, 0.30611691f, -0.08567730f, -0.16844897f, -0.26958185f, -0.30622700f, 
    0.03095638f, -0.48758683f, 0.40109000f, -0.46117499f, -0.16631626f, -0.15572296f, 0.22505881f, -0.28436798f, 
    -0.47223002f, -0.41055113f, -0.33140531f, -0.63200510f, -0.75502902f, -1.21888113f, -0.08948596f, -0.27280331f, 
    -0.46961343f, -0.87600267f, -0.81763083f, -0.85913950f, -0.97828740f, -1.44951260f, -1.23747969f, -1.15605867f, 
    0.15714365f, -0.22497779f, 0.24644776f, -0.37863412f, 0.57412398f, 0.26212832f, 0.26419210f, 0.32214826f, 
    -0.15263094f, 0.23557125f, -0.02361481f, -0.23244251f, 0.42568374f, 0.26956487f, -0.15520872f, -1.37403369f, 
    -0.69846743f, -1.31911886f, -1.65371859f, -0.95367509f, 1.04561460f, 0.49940780f, 0.42897326f, 0.12221604f, 
    0.59290296f, -0.42135379f, -0.42560330f, 0.00554282f, 0.11028865f, -0.14821629f, -0.03760598f, 0.02607684f, 
    0.06111324f, 0.25169620f, -0.01772774f, -0.14412016f, -0.07118319f, 0.04191005f, -0.15815759f, -0.15214682f, 
    -1.39546788f, -0.08390860f, -0.59586567f, -0.28570956f, 0.35424507f, 0.35654014f, 0.13804233f, 0.03835434f, 
    0.72414678f, 0.81778991f, 0.25683770f, -0.29170340f, -0.38573867f, -0.04039745f, 0.35996363f, 0.01053105f, 
    -0.07615101f, -0.39753264f, 0.02915958f, -0.27162442f, -0.19171275f, -0.27786517f, -0.59491003f, -0.37249029f, 
    -0.59826547f, 0.95029777f, 0.08270243f, 0.01399455f, 0.55476332f, 0.37579742f, 0.10035502f, 0.57890171f, 
    0.07528444f, -0.36957580f, -0.48724213f, 0.00975881f, 0.15275858f, 0.02864743f, -0.35794017f, 0.24398139f, 
    -0.35686314f, -0.28695858f, 0.19098985f, 0.07321279f, 0.00655498f, 0.49317849f, 0.11020446f, 0.10094150f, 
    -0.39704767f, -0.58950061f, -1.77908278f, -0.66891038f, 0.24671440f, 0.62029982f, 0.87588149f, 1.03314483f, 
    0.15383540f, -0.30395359f, -0.06420164f, 0.07204716f, -0.02862275f, -0.43096298f, -0.79055315f, 1.04514742f, 
    -0.68695742f, 0.00815204f, 0.04866848f, -0.18492357f, 0.26183724f, -0.03743681f, 0.09065862f, 0.00715675f, 
    0.21458079f, 0.39593545f, -0.12479956f, -1.27871609f, -0.27157146f, -0.36645547f, 0.64614099f, 1.09605992f, 
    0.16380730f, 1.18674183f, -0.39185721f, -0.34506249f, -0.07747269f, -0.13033202f, 0.03105396f, 0.19752769f, 
    -0.29134706f, -0.09545650f, -0.38249898f, -0.53922826f, 0.41801050f, -0.52808177f, -0.31046599f, -0.18121235f, 
    -0.13212846f, -0.32797182f, 0.15783159f, 0.02961956f, -0.25844905f, -0.79542732f, -0.07312019f, 0.74183238f, 
    0.32066718f, -0.84638071f, -0.41430083f, 0.26965851f, 0.96312326f, -0.24318613f, -0.05484688f, -0.82038975f, 
    -0.39485416f, 0.81717420f, 0.34787500f, -0.54573584f, 0.07281064f, 0.02353160f, 0.02964946f, 0.27670822f, 
    0.13534214f, -0.41559070f, 0.13946651f, 0.47998223f, 0.10070739f, -1.34623766f, -0.72644526f, -0.54032671f, 
    0.26449975f, -0.60859066f, 0.85359144f, 0.15601748f, -0.12690966f, 0.63142025f, 1.16072309f, 0.34488136f, 
    0.06726666f, 0.15850027f, -0.46847659f, 0.07108350f, -0.57733798f, 0.15437879f, -0.36127859f, -0.24346115f, 
    -0.46923062f, 0.05075104f, 0.11924016f, 0.47009823f, 0.08511839f, 0.48764557f, -0.58680469f, -0.60059947f, 
    0.04584380f, 0.52531266f, 0.21893772f, 0.76033807f, 0.73800629f, 0.60012305f, -1.02003717f, -0.88828593f, 
    0.43298721f, 0.13555975f, -0.40427661f, -0.28659987f, -0.08382718f, -0.17318468f, -0.02490827f, -0.31222901f, 
    -0.10947840f, 0.39896259f, 0.19219933f, -0.10428431f, -0.15977678f, 0.23433517f, -0.07469627f, -0.20383443f, 
    0.66162235f, 0.52887189f, 1.24094141f, 0.99396479f, 0.10637527f, -0.67953235f, -1.15465403f, -0.63636160f, 
    -0.23897187f, -0.11701467f, 0.07882369f, 0.15796421f, 0.09694868f, 0.05956289f, -0.26951110f, 0.29943427f, 
    -0.13741021f, 0.04908524f, 0.17526917f, -0.19487955f, 0.03118680f, 0.00107395f, 0.06403391f, -0.00979531f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.44259581f, 0.22599049f, 0.72261029f, 0.69690287f, 0.09791905f, 0.01857080f, -0.04336300f, 0.01218448f, 
    0.14089519f, 0.16017680f, 0.43763837f, 0.65261894f, 0.65034831f, 0.64338535f, 0.58669817f, 0.59920710f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.58325511f, -0.54548639f, 0.24943210f, -0.31201154f, 0.06774075f, 0.03016336f, 0.01693928f, 0.08735196f, 
    -0.14416808f, -0.04189750f, -0.06656645f, 0.00588130f, -0.03041422f, -0.01559805f, 0.13819253f, 0.13216272f, 
    -0.01293783f, 0.05326859f, -0.12144956f, -0.00144516f, -0.11533553f, 0.02919814f, -0.09473976f, 0.00160948f, 
    -0.61570978f, -0.72279638f, 0.19318970f, 0.08142129f, -0.25442272f, -0.03884635f, -0.00785373f, 0.04517504f, 
    -0.25775912f, -0.19566877f, -0.30324951f, -0.18761168f, 0.34562463f, 0.73350453f, -0.02197994f, -0.26932907f, 
    -0.10253543f, 0.03216526f, 0.14170457f, -0.35817832f, 0.06577991f, -0.13742612f, -0.12841195f, -0.06364673f, 
    0.46381450f, 0.38527432f, -0.24124879f, -0.42859372f, 0.15855959f, 0.41152996f, 0.11560108f, -0.08443187f, 
    -0.13109435f, -0.12868093f, -0.27074799f, 0.02370913f, 0.20122088f, -0.34692624f, -0.31343284f, -0.13066274f, 
    -0.07105158f, -0.01987543f, -0.09085017f, 0.01488076f, 0.20286211f, 0.05423440f, -0.17712359f, 0.33506951f, 
    0.57651603f, 0.40735462f, -0.25767091f, -0.42392531f, 0.16123246f, 0.03368585f, -0.14503460f, 0.16474219f, 
    0.04975326f, 0.06121689f, 0.02100623f, 0.02245592f, 0.41316056f, 0.07419177f, -0.36393297f, -0.00435045f, 
    0.14383587f, 0.35215509f, 0.03540897f, -0.07463951f, 0.06883053f, 0.09272948f, 0.02483602f, -0.00572881f, 
    -0.47561118f, 0.11574426f, 0.12862723f, 0.11130511f, -0.04968613f, 0.05872753f, 0.01331324f, 0.06914988f, 
    0.11517281f, 0.25160843f, 0.07690950f, 0.06875548f, -0.20699246f, -0.18665743f, -0.17593680f, 0.09320649f, 
    0.00861217f, -0.06566279f, 0.10190272f, 0.08089472f, -0.05337833f, 0.08033010f, 0.07649734f, 0.04014109f, 
    0.76873177f, -0.08535425f, 0.06991212f, -0.55761641f, -0.16987142f, -0.23519275f, 0.11754136f, 0.06182610f, 
    -0.02689770f, 0.05479246f, -0.39053929f, -0.26356596f, 0.55858856f, 0.11278707f, -0.00572480f, -0.14893807f, 
    -0.01677121f, -0.04834961f, 0.15295433f, -0.08914549f, -0.19619250f, -0.23495054f, 0.01972247f, 0.14219739f, 
    -0.09355474f, 0.04976686f, 0.34276649f, -0.54881728f, -0.13952190f, -0.10207674f, -0.29114291f, -0.09521402f, 
    0.03332417f, -0.11618137f, -0.25326565f, -0.32270581f, -0.07417602f, 0.13689777f, 0.22443978f, -0.10830674f, 
    0.13660158f, 0.08692388f, 0.07368070f, -0.23587978f, -0.09018929f, -0.23561004f, -0.18206419f, -0.27083957f, 
    0.39441556f, -0.37296283f, -0.42722744f, -0.16840544f, -0.18798935f, -0.20541273f, 0.09523265f, -0.09370430f, 
    -0.31627986f, -0.10203960f, -0.07029698f, -0.21528180f, -0.57576352f, 0.05328334f, -0.12945552f, 0.02051822f, 
    0.09077313f, -0.18828844f, -0.18937849f, -0.16820431f, 0.00457868f, -0.05558785f, 0.09779823f, 0.07270326f, 
    0.76226658f, 0.55626559f, 0.14322472f, 0.31127846f, -0.06299374f, -0.07107447f, -0.08733631f, -0.05107345f, 
    0.23307593f, 0.06260768f, 0.15579355f, 0.16345747f, 0.07500637f, 0.06856698f, -0.07283332f, 0.08531315f, 
    0.14466853f, 0.03126949f, 0.04385199f, 0.07142619f, -0.09344891f, -0.17580417f, 0.06069798f, -0.00754685f, 
    0.46374279f, -0.40532798f, -0.05945651f, 0.01889672f, -0.09447198f, 0.27533308f, 0.27949440f, -0.24319975f, 
    0.03973819f, -0.16008134f, -0.05761761f, 0.03786427f, -0.39619645f, -0.28329223f, -0.32002810f, 0.09186917f, 
    -0.01095581f, 0.13729428f, 0.34709930f, 0.08912892f, 0.04893654f, -0.09490541f, 0.03821919f, 0.12849592f, 
    -0.01279775f, 0.44387242f, 0.07253727f, 0.22771195f, -0.00887255f, -0.13316064f, -0.05822610f, 0.28295985f, 
    0.11310545f, 0.02953275f, -0.06936885f, -0.16849385f, 0.09692816f, -0.09320777f, 0.07687921f, -0.18633734f, 
    -0.08529812f, 0.05998376f, -0.04537595f, 0.05061318f, -0.56698400f, -0.63779360f, -0.21606891f, -0.27675399f, 
    0.19445762f, 0.12734358f, 0.17767699f, -0.31752127f, -0.24781893f, -0.00562649f, -0.05570795f, -0.30970874f, 
    -0.04646967f, -0.02977018f, -0.00304122f, 0.01109293f, 0.41274187f, 0.30525538f, -0.17460713f, -0.06072785f, 
    -0.08058540f, 0.27901262f, -0.07460692f, -0.37624934f, -0.00017964f, -0.07927471f, -0.05714540f, -0.24178706f, 
    0.04312651f, 0.07818222f, -0.14872964f, -0.05754807f, -0.01075649f, 0.02145622f, -0.10930687f, -0.07871092f, 
    -0.23165095f, -0.05407043f, -0.26240635f, -0.14657739f, 0.53515428f, 0.18016596f, 0.16900402f, 0.16015038f, 
    -0.07503405f, -0.09162085f, -0.14438152f, 0.03097568f, -0.10620995f, -0.12125637f, 0.07182994f, 0.02543514f, 
    -0.09206672f, -0.25228348f, 0.05352534f, 0.02771286f, -0.03394071f, -0.20654403f, 0.20675343f, 0.03580946f, 
    0.06887084f, -0.31243500f, 0.19460687f, -0.13487515f, 0.18356961f, -0.56231636f, 0.06581284f, 0.25332358f, 
    -0.11203385f, -0.04347339f, 0.01119141f, -0.08711457f, 0.16819017f, -0.26157463f, -0.38843894f, -0.14035377f, 
    -0.80706197f, 0.42838231f, -0.02409749f, 0.16674994f, 0.11910997f, 0.08690771f, 0.35921597f, -0.16911122f, 
    0.02580888f, -0.07389980f, 0.14847526f, -0.02237879f, 0.00832275f, 0.30617514f, -0.29693329f, -0.68145162f, 
    -0.08652093f, 0.07227752f, 0.09548381f, 0.11208384f, -0.11701801f, 0.07417069f, 0.04086699f, 0.06739316f, 
    0.15180741f, -0.45514613f, 0.02409296f, 0.14363696f, -0.02493712f, -0.11338461f, 0.26507002f, -0.00061475f, 
    0.11433932f, 0.27302101f, 0.15548383f, -0.01237642f, -0.20407793f, 0.26177132f, -0.28027293f, -0.10084135f, 
    0.02084708f, -0.39641708f, 0.10989182f, -0.05567734f, 0.00141871f, 0.03017435f, -0.00799550f, 0.10180452f, 
    -0.12779899f, 0.03891398f, -0.27719793f, -0.31275821f, 0.05295901f, -0.03883524f, 0.05338556f, 0.19861794f, 
    -0.10362665f, -0.10928017f, -0.12063918f, 0.08267358f, -0.17918205f, -0.07445280f, -0.03573506f, -0.03233593f, 
    -0.21013997f, -0.02103347f, -0.04590443f, 0.06737886f, 0.01262601f, -0.03893540f, 0.00167865f, -0.01552735f, 
    -0.11886082f, 0.10052731f, -0.27776089f, -0.14869903f, -0.02771768f, 0.08958951f, -0.01444212f, 0.01911280f, 
    0.17542113f, 0.01591267f, -0.03241098f, 0.07157564f, 0.40259919f, -0.40627667f, 0.01297839f, -0.02766435f, 
    0.21373691f, -0.35127217f, -0.12853533f, 0.08595372f, 0.00389974f, 0.10246313f, -0.18254730f, 0.00548107f, 
    -0.23065603f, 0.26640746f, 0.55890536f, 0.45673871f, -0.19774711f, -0.13938682f, -0.13795225f, 0.13740851f, 
    0.01787867f, -0.05838824f, -0.14655119f, 0.00518408f, -0.07011970f, -0.01319812f, 0.23781258f, -0.13454227f, 
    -0.00277056f, -0.13034561f, -0.16258314f, -0.11351212f, 0.27355891f, 0.14831212f, 0.18054239f, 0.16992854f, 
    -1.75824153f, -1.41551805f, -0.15915783f, -0.59217018f, -0.27535045f, 0.09029696f, 0.07360051f, -0.41729659f, 
    -0.03987805f, 0.02302060f, -0.07361205f, -0.08347094f, -0.15408637f, 0.72743905f, 0.94409752f, 0.44398940f, 
    -0.15018545f, -0.07473289f, 0.13524495f, -0.06747900f, 0.04640739f, 0.03683783f, -0.02290444f, -0.10893077f, 
    0.13795455f, -0.08064297f, 0.15960251f, 0.26366979f, -0.01151185f, 0.02606884f, 0.05201621f, -0.10252706f, 
    0.19847926f, 0.16023301f, 0.06223343f, 0.43204311f, 0.13291024f, 0.07070433f, -0.13930821f, -0.17165497f, 
    -0.00335395f, -0.08294860f, 0.14100377f, 0.20059463f, -0.01806705f, 0.04201700f, -0.01363437f, -0.07850920f, 
    -0.13187136f, -0.27297264f, 0.10110677f, 0.37356934f, 0.10813659f, 0.00324339f, 0.09344401f, -0.06718770f, 
    0.08168658f, -0.09309999f, 0.12386048f, -0.02652634f, 0.06966235f, -0.19369350f, -0.03179456f, -0.29494560f, 
    0.05333764f, 0.01941185f, 0.10290468f, 0.11836366f, -0.16824721f, -0.05929198f, 0.07985628f, -0.36753163f, 
    -0.04658775f, 0.13141082f, -0.31900120f, 0.37068796f, -0.31029591f, -0.07485723f, 0.34993950f, -0.33144584f, 
    -0.05431165f, 0.11314356f, -0.02493899f, -0.00478057f, -0.18802486f, -0.13094270f, 0.24906208f, 0.37985873f, 
    0.13880914f, 0.05340884f, 0.02986231f, -0.12962170f, -0.12151798f, -0.30095139f, -0.16224241f, 0.06851267f, 
    0.17481688f, -0.16165990f, -0.14880659f, -0.29844090f, 0.09620410f, -0.24654151f, 0.14803976f, 0.30125004f, 
    0.19021998f, 0.10049262f, -0.09289480f, -0.07211931f, -0.66557831f, 0.51750952f, -0.29351729f, -0.28218725f, 
    0.07966193f, -0.25085104f, 0.04840706f, 0.15349409f, -0.03555083f, 0.03405682f, 0.06545614f, -0.01465802f, 
    -0.26802826f, 0.32635325f, 0.07537790f, -0.79992956f, -0.16391270f, 0.04798931f, 0.28465822f, -0.07070451f, 
    0.12818912f, 0.12898467f, 0.00847691f, 0.04963902f, -0.62161553f, -0.04816753f, -0.24416944f, -0.04888226f, 
    0.11117793f, -0.19462085f, 0.08062826f, 0.03312819f, -0.03512549f, 0.16261259f, -0.04034118f, -0.28588623f, 
    -0.24982879f, -0.20808437f, 0.16376369f, -0.24222508f, -0.00193937f, -0.32357410f, -0.30407104f, 0.19233726f, 
    0.07055973f, 0.14211747f, -0.00808872f, -0.18317361f, 0.02032425f, 0.00381530f, -0.61738509f, -0.27123562f, 
    0.34461457f, 0.18605858f, 0.07211611f, -0.12328808f, -0.06391577f, 0.13187599f, -0.16220750f, -0.07606421f, 
    -0.08674500f, -0.16570549f, 0.02036003f, 0.41439635f, 0.00763762f, -0.06171504f, 0.05479933f, 0.08106046f, 
    -0.09203482f, 0.02071908f, 0.09944504f, 0.12047560f, 0.00333860f, 0.04816136f, -0.07152435f, 0.45966452f, 
    -0.05517726f, 0.12465075f, -0.10782523f, 0.02162343f, -0.10300882f, 0.06460007f, 0.07124940f, 0.05959141f, 
    0.00560824f, -0.61303920f, -0.07742252f, 0.40562579f, 0.01829241f, 0.06271582f, 0.23991612f, -0.02919347f, 
    0.01553372f, -0.01090207f, -0.27169368f, -0.17411228f, 0.42138046f, -0.30240253f, -0.12209734f, 0.44594282f, 
    0.26377258f, 0.03990678f, 0.01735074f, 0.03643683f, -0.10760124f, -0.05830607f, 0.07075202f, 0.12854294f, 
    0.65139288f, -0.04171452f, -0.03293021f, -0.08400708f, 0.27991602f, 0.05493449f, 0.02888748f, -0.11173774f, 
    -0.17039667f, -0.15261410f, -0.12978613f, -0.18077545f, -1.03344405f, 0.05944008f, -0.20253755f, 0.47988671f, 
    -0.35061857f, 0.05749621f, -0.28286296f, 0.02766031f, 0.13848959f, 0.22911634f, -0.17749058f, 0.06883747f, 
    -0.44095886f, 0.81221944f, -0.68606210f, -0.70874226f, 0.15646891f, 0.34438604f, -0.01607170f, -0.02033280f, 
    -0.28857067f, -0.06695753f, 0.11291102f, 0.01771783f, -0.32815379f, 0.78384614f, -1.30974054f, -0.84730941f, 
    0.20570114f, 0.22772279f, -0.24109699f, -0.04441812f, -0.19029108f, 0.08090913f, -0.18692075f, 0.02939512f, 
    -0.02805169f, -0.17205763f, -0.31646490f, -0.44959989f, -0.20625409f, -0.06995872f, -0.24906786f, 0.25740480f, 
    -0.14844444f, -0.14551239f, 0.01397702f, 0.13933714f, 0.24662915f, 0.01598601f, 0.16511573f, 0.10435607f, 
    0.36779645f, -0.09154486f, -0.04609867f, -0.24021460f, -0.00227030f, 0.13487454f, -0.15839384f, 0.07822408f, 
    -0.63098049f, 0.70917577f, -0.37477866f, 0.27113116f, 0.12985116f, -0.15727632f, -0.07919984f, 0.02102840f, 
    -0.13194656f, -0.20195992f, -0.05085317f, 0.12792704f, -0.23498321f, 0.58879995f, 0.01673880f, 0.25596511f, 
    -0.33425340f, 0.29145297f, 0.09944386f, 0.10057586f, 0.20202684f, -0.02755514f, -0.07070110f, 0.27708504f, 
    0.18453911f, -0.78476435f, -0.82028067f, 0.34912619f, 0.09444970f, 0.00208431f, -0.02810793f, 0.04699449f, 
    -0.07691842f, -0.13869627f, -0.23910281f, -0.05460658f, 0.16771941f, 0.06644202f, 0.11652107f, 0.11736539f, 
    0.07775613f, 0.16865878f, -0.06092040f, 0.06916920f, -0.01347824f, -0.08587654f, -0.12569207f, -0.07920247f, 
    -0.09752101f, -0.23444682f, 0.03173932f, -0.31639653f, 0.00842672f, -0.10141165f, -0.37886724f, -0.00894793f, 
    -0.10816630f, -0.03555844f, -0.26470336f, -0.28763899f, 0.19645803f, 0.15658168f, 0.05060503f, 0.12426881f, 
    -0.01614977f, -0.22532816f, -0.35543972f, -0.16858318f, -0.03842799f, 0.08605548f, 0.09338292f, 0.12993397f, 
    0.06488341f, -0.08015817f, 0.04832688f, 0.15312691f, 0.04291141f, -0.02532454f, -0.06058146f, -0.09514047f, 
    0.04079080f, -0.08711737f, 0.06871426f, 0.10485669f, -0.05310173f, 0.04828816f, 0.08958316f, -0.11031619f, 
    0.05919926f, -0.16584343f, 0.02277522f, -0.21781842f, 0.13790715f, 0.08717971f, 0.10455291f, 0.39931077f, 
    -0.01245151f, 0.55526513f, 0.26044264f, 0.30003580f, -0.09437506f, 0.05161695f, -0.04977379f, 0.27338859f, 
    0.06617002f, -0.09785748f, 0.00789311f, -0.05310189f, -0.40681788f, 0.04765603f, 0.36844328f, 0.12284427f, 
    -0.16430745f, -0.09579352f, -0.06064576f, 0.01640091f, -0.03965355f, 0.03746521f, -0.06403906f, 0.13152312f, 
    -0.07227924f, 0.01278280f, -0.28116697f, 0.03264007f, -0.14651157f, 0.03938377f, 0.12861834f, 0.00988223f, 
    0.25497541f, 0.08310559f, 0.01872192f, 0.23834303f, -0.10695908f, -0.22201192f, -0.04557832f, -0.03560769f, 
    0.18384053f, -0.09682259f, 0.17156217f, -0.17845631f, 0.09169286f, -0.03679030f, 0.07274590f, 0.02709178f, 
    0.03090467f, -0.53197110f, 0.23068383f, 0.09388020f, -0.03194738f, 0.11691412f, -0.01422366f, -0.12314269f, 
    -0.02253032f, 0.29620197f, -0.35934097f, -0.00020310f, -0.46821240f, -0.75810319f, 0.06221728f, 0.00341570f, 
    0.16104536f, -0.02114826f, -0.03172375f, -0.02965132f, -0.16985361f, 0.15487304f, -0.10097550f, -0.18440118f, 
    -0.08870979f, -0.43542203f, 0.03613867f, -0.27904451f, -0.49580428f, -0.09633799f, 0.01265733f, 0.02109343f, 
    -0.22142823f, -0.05388598f, -0.25326800f, 0.13076250f, 0.50783426f, 0.23873450f, -0.10833602f, 0.17195547f, 
    0.05438004f, -0.05836563f, 0.01660096f, -0.17621948f, -0.01204778f, -0.25725389f, -0.12918788f, -0.13938622f, 
    0.25915736f, -0.25949717f, 0.11020090f, 0.02571361f, -0.17094553f, 0.07309284f, -0.10954113f, -0.22793899f, 
    0.00487651f, -0.07965813f, -0.16496220f, -0.12414161f, 0.28403720f, -0.06143782f, 0.34565812f, 0.64253640f, 
    0.01733770f, -0.03360170f, 0.02372391f, 0.15071948f, -0.06020784f, 0.06754661f, 0.01866344f, 0.00203427f, 
    -0.57251066f, -0.28728625f, -0.29148608f, 0.29367462f, 0.01197391f, 0.08035696f, -0.05066815f, 0.09004753f, 
    0.02101850f, -0.11615250f, 0.02271376f, 0.03997703f, -0.08438743f, -0.19781066f, -0.06477890f, 0.00186365f, 
    -0.19359335f, 0.14071023f, -0.13888398f, -0.24411425f, 0.09454657f, 0.13797569f, -0.11348685f, 0.15105163f, 
    0.05841878f, -0.11275942f, -0.46311721f, 0.53221494f, 0.25061017f, -0.32828945f, -0.19707039f, 0.19978161f, 
    0.00222440f, 0.24714012f, 0.25539699f, 0.28837681f, 0.11970007f, 0.09249991f, 0.38292325f, -0.36617589f, 
    0.12915875f, -0.08181048f, 0.04380250f, 0.39302310f, 0.10315394f, 0.00758937f, -0.00184077f, 0.02069016f, 
    -0.09472334f, 0.23154943f, 0.18186578f, -0.45482838f, 0.05548673f, 0.14693952f, 0.11452108f, -0.05111929f, 
    0.04391641f, -0.04583090f, 0.03578846f, -0.03746337f, 0.02024045f, -0.01644494f, -0.11139386f, -0.23209085f, 
    0.09953709f, 0.02051284f, 0.17311069f, 0.05915106f, -0.28285277f, -0.26656404f, -0.22970048f, -0.98844576f, 
    0.18784402f, 0.33690169f, 0.25336638f, 0.07107531f, 0.42001477f, 0.11619884f, 0.09282672f, 0.21342486f, 
    -0.06947100f, 0.02099595f, 0.08799203f, 0.03902481f, -0.54067940f, 0.05458089f, -0.36107937f, -0.73705542f, 
    0.11228877f, -0.10703459f, -0.13682507f, 0.00713141f, 0.14635180f, -0.09697708f, -0.07248196f, -0.00290246f, 
    -0.54138124f, -0.05054682f, 0.05585805f, -0.08142509f, -0.00456567f, 0.04477300f, 0.04842775f, 0.10111525f, 
    -0.01259358f, -0.23506029f, -0.01976935f, -0.22291531f, -0.08562378f, -0.10884032f, -0.24148703f, 0.20876391f, 
    0.05795071f, -0.00149615f, 0.02842159f, 0.18019898f, 0.00440340f, 0.10105017f, -0.10332737f, -0.20838997f, 
    -0.34868422f, 0.06486401f, 0.20033079f, 0.21995883f, -0.16603287f, -0.05519984f, 0.08573262f, -0.21597941f, 
    0.05249764f, 0.11006837f, -0.07442474f, 0.05193875f, 0.04334431f, 0.37296170f, 0.26655516f, 0.02780569f, 
    -0.06081894f, -0.14768665f, -0.06170988f, 0.01992114f, 0.09655940f, -0.16142851f, 0.13170783f, 0.20134604f, 
    0.45928121f, -0.36711881f, 0.17497645f, 0.17401898f, 0.09422332f, -0.00779156f, -0.10205028f, -0.13492177f, 
    0.01239142f, 0.18346442f, -0.16547729f, 0.00222670f, -0.79415703f, -0.65214914f, -0.10553075f, 0.00133171f, 
    -0.30458772f, -0.10037533f, -0.00943083f, 0.00711506f, 0.33222097f, 0.11448483f, 0.15084375f, 0.07719381f, 
    0.08202203f, 0.33603421f, -0.33875769f, 0.22075567f, 0.08016127f, 0.17087626f, -0.22334231f, 0.03873431f, 
    0.09745789f, 0.00117895f, -0.21181475f, 0.00655431f, -0.21555924f, -0.58650935f, 0.38942012f, -0.12745725f, 
    -0.03988242f, 0.07503369f, -0.17088921f, 0.12682198f, 0.04465715f, -0.07972465f, -0.03129426f, -0.03988704f, 
    0.20286067f, 0.13819326f, 0.19409530f, -0.06785379f, 0.15888940f, 0.03955925f, 0.01744876f, -0.07523510f, 
    0.09123617f, 0.08570268f, -0.02610335f, -0.23861372f, 0.12152895f, 0.10960919f, 0.10250857f, -0.08133808f, 
    0.20263335f, -0.26967445f, 0.15873814f, -0.12148177f, -0.11961121f, -0.12449732f, -0.19048096f, -0.07360610f, 
    0.61418235f, 0.33763111f, 0.17460823f, -0.41145620f, -0.00862635f, 0.01607986f, 0.30627874f, -0.42895615f, 
    0.05648122f, 0.03868943f, 0.13313378f, 0.02925666f, -1.17125380f, 0.28219235f, 0.42152834f, 0.19358924f, 
    -0.47336969f, -0.21675520f, -0.11466333f, -0.17402524f, -0.15542150f, 0.02826096f, 0.06634274f, -0.04606725f, 
    -0.88165307f, -1.39277875f, 0.04616415f, -0.18720485f, -0.05401916f, -0.13125324f, -0.16450946f, -0.55391431f, 
    -0.09850700f, 0.01019740f, -0.00374515f, -0.05945912f, -0.28633320f, 0.02860173f, 0.20196071f, 0.07134565f, 
    -0.11198183f, 0.05275796f, 0.15701126f, 0.06465419f, 0.18215029f, 0.37912661f, 0.12906981f, 0.26647460f, 
    -1.67662466f, -1.49914503f, -0.95169055f, 0.28248733f, -0.28566542f, -0.25827789f, -0.29184440f, -0.42115372f, 
    0.02412184f, -0.17341860f, -0.01622025f, -0.01623351f, -1.00136197f, 0.26311398f, 0.54215801f, 0.29291731f, 
    -0.26911011f, -0.19928382f, 0.00066672f, 0.14484763f, -0.02897958f, 0.03720129f, -0.11821106f, 0.15973891f, 
    -0.02268121f, 0.20835693f, -0.00226725f, 0.01138863f, 0.02125915f, 0.04893502f, 0.00412521f, 0.17139161f, 
    0.05159091f, 0.00196356f, 0.40251943f, 0.01093955f, -0.19264229f, -0.15695693f, -0.01423193f, 0.22858012f, 
    0.20814030f, 0.06828377f, 0.18339792f, -0.09938543f, -0.03867257f, -0.14641741f, -0.08229454f, 0.02807690f, 
    0.07676546f, -0.18599784f, 0.35318246f, -0.28899390f, 0.07084151f, -0.09005550f, -0.20844738f, 0.15339941f, 
    -0.16212514f, 0.07948894f, 0.23248966f, -0.14317390f, -0.18012647f, -0.08930169f, 0.22273830f, -0.20422003f, 
    0.02330159f, -0.05278270f, 0.07510439f, 0.14358744f, 0.01221731f, 0.19351000f, 0.00485660f, 0.27448559f, 
    -0.27926353f, 0.24591561f, -0.30613261f, -0.05435302f, 0.24369219f, 0.12193217f, -0.27144280f, 0.26939788f, 
    0.07176717f, -0.26212126f, 0.08871029f, 0.14311449f, -0.32928377f, -0.04166116f, 0.62420177f, 0.23532631f, 
    0.04094234f, -0.11719541f, -0.13345942f, 0.22930469f, -0.06306642f, 0.40328962f, -0.05313120f, -0.07356985f, 
    -0.34111512f, -0.07963971f, 0.02646337f, 0.09960170f, 0.28944409f, 0.00367906f, -0.00513206f, -0.33746973f, 
    0.04817094f, -0.18461053f, 0.15739258f, -0.07742755f, -0.60745692f, -0.80599672f, -0.69415247f, 0.49703985f, 
    0.13834748f, 0.37384754f, -0.11305860f, 0.02615072f, 0.10772420f, -0.06652564f, -0.09994671f, 0.02330752f, 
    0.11856656f, 0.11799043f, 0.22677554f, -0.28855193f, -0.01097790f, 0.13299808f, -0.16005661f, 0.00892812f, 
    -0.00313513f, 0.05209037f, 0.09358703f, -0.12296734f, 0.11534854f, 0.17165299f, -0.06297913f, -0.12943512f, 
    -0.06336650f, -0.04488234f, -0.02908172f, -0.03167639f, 0.00586715f, 0.02710778f, -0.05283429f, -0.07073037f, 
    0.13816155f, 0.45137274f, -0.51845127f, 0.15038539f, -0.06703538f, 0.08115013f, 0.02131724f, -0.17731667f, 
    -0.32139906f, -0.05834197f, -0.30633068f, -0.34265441f, 0.57701242f, -0.45065176f, 0.39439037f, -0.04245542f, 
    0.05005091f, -0.08658946f, 0.01488892f, -0.21122135f, -0.03528514f, 0.13745181f, 0.04217565f, -0.00236994f, 
    -0.50197566f, -0.97845674f, 0.60536009f, -0.38652429f, -0.11609126f, 0.06481468f, -0.10280490f, 0.32675126f, 
    -0.03514927f, -0.15863098f, -0.01245680f, -0.04402492f, 0.12930138f, -0.03278523f, -0.09562719f, -0.06875703f, 
    -0.06229129f, -0.12941858f, -0.04998345f, -0.05066507f, -0.01019936f, 0.30339280f, 0.00775430f, 0.16990836f, 
    -0.96745133f, -0.97082794f, 0.21603140f, 0.37440971f, 0.18855543f, -0.01285445f, 0.00788732f, 0.23714837f, 
    0.12464001f, -0.06390316f, -0.07491265f, -0.09414035f, 0.20443329f, -1.27923226f, -1.34918201f, -1.29937458f, 
    -0.06914998f, -0.20329189f, 0.15383847f, 0.42596009f, 0.05893409f, -0.14887010f, -0.07984836f, 0.18281776f, 
    0.53276581f, -0.48210314f, 0.16350956f, -0.19820178f, 0.04528472f, -0.07532715f, 0.02499465f, -0.08942098f, 
    0.27551320f, -0.27933326f, -0.07997157f, 0.01181725f, 0.14151131f, 0.14047900f, 0.05084211f, -0.12505661f, 
    0.08508583f, -0.05548696f, 0.05113675f, -0.06457740f, 0.10189242f, 0.16575924f, 0.08770452f, 0.01503529f, 
    0.47075996f, 0.06106651f, -0.20763329f, -0.52893686f, -0.17318732f, -0.12031265f, -0.14932050f, 0.28994903f, 
    0.07215752f, 0.27506644f, -0.01295797f, -0.21044071f, 0.26859829f, 0.02254553f, -0.13063380f, -0.30448905f, 
    0.01910340f, -0.00353209f, 0.01205065f, -0.10859405f, -0.12433481f, -0.04420917f, 0.16772963f, -0.33751777f, 
    0.53060949f, -0.35274196f, 0.00590057f, 0.00599733f, -0.31213576f, 0.02764710f, -0.19274060f, -0.43561804f, 
    -0.16209878f, 0.25249410f, 0.00818433f, -0.14875525f, 1.01530945f, -0.84939897f, -0.37089649f, -1.01426482f, 
    -0.10881418f, -0.05067340f, -0.17420959f, 0.21370535f, 0.02043089f, 0.12576395f, -0.00798492f, 0.00207036f, 
    -0.02366481f, 0.38380173f, -0.11605456f, -0.21946496f, -0.13009220f, 0.06551492f, 0.08599053f, 0.03880847f, 
    -0.23464744f, -0.04450471f, -0.18372087f, -0.13346304f, 0.17662171f, -0.22815494f, 0.28786078f, -0.12994631f, 
    -0.03282341f, -0.23276746f, -0.21856153f, -0.17321208f, 0.14356633f, 0.04745328f, 0.06690155f, -0.05450838f, 
    0.11188266f, 0.06003930f, 0.18890184f, -0.23848018f, -0.04526136f, -0.12613359f, -0.07112247f, -0.05363663f, 
    -0.07071204f, 0.04925834f, 0.09262218f, -0.04739977f, -0.26765567f, -0.02248712f, -0.04912008f, -0.05631123f, 
    -0.02650592f, -0.05949913f, -0.04199140f, 0.03358322f, 0.08541522f, 0.08286626f, 0.20893759f, 0.16157508f, 
    -0.75532621f, 0.52531135f, 0.15057196f, 0.32903492f, 0.08658989f, 0.23631325f, -0.01141872f, 0.06824995f, 
    0.16820519f, -0.12203053f, 0.24915649f, 0.09760135f, 0.48554838f, -0.34185699f, -0.64024061f, -0.35266429f, 
    -0.29573858f, -0.01920701f, 0.18434121f, -0.07093157f, 0.09191572f, -0.06552523f, 0.08914904f, -0.14844804f, 
    0.59231436f, -0.61534190f, -0.83349741f, -0.42725095f, -0.04986345f, -0.24694075f, 0.27553684f, -0.17501770f, 
    0.01880686f, 0.14792769f, -0.11544991f, -0.05923109f, -0.18718740f, -0.10138988f, 0.04519542f, 0.09943022f, 
    0.05402093f, 0.08409575f, -0.01083095f, 0.07944953f, 0.00041171f, 0.17545861f, -0.34268335f, -0.67976075f, 
    -0.59894627f, -0.42306882f, -0.12225503f, 0.02926745f, -0.00132469f, 0.11520915f, 0.00412743f, -0.04844102f, 
    -0.00483271f, -0.01044939f, -0.00021950f, 0.09702203f, -0.11878284f, -1.02916706f, -0.60174507f, 0.56418914f, 
    -0.05285262f, 0.28210464f, 0.22092046f, 0.33083272f, -0.19905727f, -0.09923229f, -0.12852070f, -0.09311244f, 
    -0.17849848f, -0.36444086f, -0.09861928f, -0.33772922f, 0.14182043f, 0.06101942f, -0.01760142f, 0.09120299f, 
    -0.44778734f, 0.05473814f, -0.05366847f, -0.39040291f, -0.52147108f, 0.01245921f, 0.32709229f, -0.22165851f, 
    -0.29844230f, -0.02688699f, -0.09505353f, -0.30106375f, -0.16344588f, 0.12112376f, -0.16697128f, 0.00388664f, 
    0.27925807f, -0.04242934f, -0.24246031f, -0.33509183f, -0.09054817f, -0.32116300f, -0.12359595f, 0.03939681f, 
    0.13032439f, -0.03521712f, 0.12750806f, 0.34946454f, 0.52824926f, 0.05307424f, -0.38938886f, -0.41374454f, 
    -0.27206093f, -0.09086788f, 0.02703183f, -0.15161540f, 0.26674160f, 0.10375556f, 0.32649079f, 0.24658671f, 
    0.71516967f, 0.16228642f, 0.02470040f, -0.63786209f, 0.18909030f, -0.07003093f, 0.06508927f, -0.20188820f, 
    0.11296740f, -0.05731061f, 0.18394321f, 0.21579045f, -0.30633250f, -0.54869300f, -0.63373798f, 0.54784805f, 
    0.10475516f, 0.15358594f, 0.18443243f, 0.13435857f, 0.28449172f, -0.14946239f, 0.18811850f, 0.32885340f, 
    0.06880707f, -0.17215770f, -0.20179296f, -0.25424835f, -0.22249955f, -0.15156935f, 0.20371065f, -0.11010510f, 
    0.07352847f, -0.07649382f, 0.21671242f, 0.10588985f, 0.28486741f, 0.30006418f, 0.18496858f, -0.55998355f, 
    -0.28658307f, -0.22177246f, 0.11097793f, -0.28056794f, 0.04917175f, 0.16861773f, -0.00767874f, 0.01292558f, 
    -0.26479235f, -0.63680291f, 0.09692687f, 0.12371071f, -0.00932869f, 0.23739120f, -0.06292165f, -0.15980974f, 
    -0.26362166f, 0.24242884f, 0.01880798f, -0.05442923f, -0.01878890f, 0.02802721f, -0.03689794f, 0.00910259f, 
    0.07894490f, 0.03590160f, 0.04388641f, 0.19162004f, 0.20966551f, -0.12840022f, -0.05442458f, 0.12555596f, 
    -1.10900533f, 0.10632079f, -0.80460185f, 0.07954320f, 0.02754612f, -0.06666876f, -0.20936282f, 0.20369147f, 
    0.05732635f, 0.06233532f, -0.33747268f, 0.08905625f, -0.22003224f, -0.67501378f, 0.51741529f, 0.13815248f, 
    0.12829217f, -0.07608065f, -0.37477952f, -0.11637433f, -0.02183565f, -0.32186919f, 0.02784984f, -0.12680149f, 
    -0.44793153f, 0.04880724f, 0.16206373f, -0.38544258f, -0.31390134f, 0.12319032f, 0.03425125f, 0.14049608f, 
    0.21741882f, 0.07181898f, 0.09767967f, -0.00268071f, 0.02696823f, -0.04430899f, 0.08016388f, -0.08188425f, 
    0.08753800f, 0.09760713f, -0.08899968f, 0.11113375f, -0.04538348f, 0.11897725f, 0.12590101f, 0.29750386f, 
    -0.05068639f, 0.08279719f, 0.05565836f, -0.36432585f, -0.08463857f, -0.01984387f, 0.03705807f, 0.28751436f, 
    -0.01650650f, 0.05136124f, -0.00872804f, -0.04664169f, 0.08509224f, -0.20844799f, 0.22571233f, -0.21146283f, 
    -0.09463660f, -0.38060969f, -0.22043198f, -0.03484716f, 0.07073931f, -0.10386290f, 0.06965071f, 0.13262966f, 
    0.19240868f, 0.03170294f, 0.59462452f, 0.56486320f, -0.17680350f, 0.00551598f, -0.10327648f, -0.36501074f, 
    0.12969279f, 0.11134133f, 0.07508537f, -0.08554530f, -0.18035533f, -0.45724329f, 0.30473778f, -0.43346649f, 
    0.06313208f, 0.20820050f, -0.00765840f, 0.17181642f, 0.06272162f, 0.03264885f, 0.07772788f, 0.03250900f, 
    -0.35242954f, -0.13171852f, -0.14697593f, 0.56703120f, 0.06193473f, 0.28316474f, -0.32865584f, 0.11186672f, 
    0.21524931f, -0.34203869f, -0.00590194f, -0.08350806f, -0.40637285f, -0.39680511f, 0.31840298f, 0.27067709f, 
    0.10209561f, 0.05561018f, -0.07700453f, -0.14052327f, -0.26946989f, 0.16646436f, -0.00329009f, 0.00828872f, 
    -0.06995887f, -0.13553123f, -0.21336435f, 0.33053303f, 0.10811653f, -0.20020638f, -0.09519932f, 0.14079139f, 
    -0.13403884f, -0.14468393f, 0.04810369f, -0.13214071f, 0.37944537f, 0.23931426f, 0.40764752f, 0.12488467f, 
    0.00887348f, -0.09103624f, -0.41454378f, -0.22457188f, -0.11542024f, -0.03601640f, -0.07056683f, -0.09257461f, 
    -0.35330674f, 0.25314566f, 0.36324212f, -0.14352356f, 0.23868652f, 0.20424461f, -0.98504448f, 0.25863346f, 
    0.09647369f, 0.02332394f, 0.03790699f, -0.19169956f, 0.69739670f, -1.27904713f, 0.17158021f, -0.00849263f, 
    0.31428728f, 0.41949219f, 0.27346814f, -0.07928388f, -0.20179531f, -0.07861646f, 0.05321123f, -0.11066745f, 
    0.12627798f, 0.01662814f, -0.42795792f, 0.16107897f, -0.09832915f, -0.05267250f, -0.30945989f, -0.27325839f, 
    0.13111354f, -0.22857818f, -0.31547230f, -0.10865340f, 0.10908318f, -0.08553540f, 0.30533606f, -0.28100389f, 
    -0.31575060f, -0.02311349f, -0.38173997f, -0.07438906f, 0.20405023f, 0.35371858f, 0.51185578f, 0.07982332f, 
    0.04739369f, -0.15203698f, 0.77979088f, -0.04705910f, -0.02216263f, 0.21331106f, -0.08665682f, 0.38603503f, 
    -0.05085997f, 0.12496902f, 0.15967476f, -0.09789616f, -0.95928675f, 0.34621650f, 0.00254642f, 0.44354254f, 
    -0.15290371f, 0.18237303f, -0.06149616f, -0.08284998f, -0.27554739f, 0.06298468f, -0.09618217f, -0.08098246f, 
    -0.03126572f, -0.58948326f, -0.52223450f, 0.28230238f, 0.05399942f, -0.10570690f, 0.11886590f, -0.01640671f, 
    -0.07052252f, 0.04227845f, -0.17616114f, -0.15812115f, -0.16351202f, 0.39525202f, 0.20949483f, 0.05886042f, 
    0.07662198f, 0.29046759f, 0.10374098f, -0.03267024f, -0.21558557f, -0.44767287f, -0.37971365f, -0.63833666f, 
    -0.50441068f, -0.28951186f, -0.15877983f, 0.47577053f, 0.12241174f, 0.02184641f, -0.13305786f, -0.03375518f, 
    -0.02858218f, 0.11824816f, -0.02642202f, 0.24593282f, 0.14831407f, -0.35279605f, 0.07931282f, 0.28604579f, 
    0.23505689f, -0.24589306f, -0.03458055f, -0.03991720f, -0.13600127f, 0.17392839f, -0.08939367f, -0.42806777f, 
    0.02834629f, -0.02570906f, -0.27928612f, -0.48586378f, -0.07159866f, -0.10019648f, -0.10595117f, 0.09423713f, 
    -0.09345528f, -0.12071113f, -0.12753837f, -0.68018359f, -0.77350861f, 0.02621963f, 0.11133018f, -0.50689739f, 
    -0.29312840f, -0.09219530f, -0.21997136f, -0.11099347f, -0.02935975f, -0.11553385f, 0.10928798f, 0.18607508f, 
    -0.23226635f, 1.17977226f, 0.03428311f, 0.19394037f, 0.08200352f, -0.07400452f, 0.02816789f, -0.00016045f, 
    -0.11217360f, 0.31030443f, 0.06990997f, 0.17956498f, -0.08582339f, 0.18538730f, 0.50072819f, 0.07898816f, 
    -0.05255632f, 0.03214491f, 0.17013821f, 0.14321788f, 0.30188781f, -0.30689871f, 0.13682620f, 0.07182784f, 
    -0.77947235f, 0.58688051f, -0.28174293f, 0.06162586f, -0.17734995f, -0.01335113f, -0.12798198f, 0.40481743f, 
    0.14989120f, -0.01421193f, 0.10474364f, -0.03080746f, -0.00458888f, 0.35268861f, 0.18700932f, -0.04159218f, 
    -0.05433372f, -0.08051136f, 0.11132205f, 0.07003868f, -0.14744155f, 0.05106554f, 0.23456921f, 0.15985653f, 
    0.06861012f, -0.24888197f, 0.58047003f, 0.08518955f, -0.16723126f, 0.07742983f, -0.34163517f, 0.22610542f, 
    -0.05283884f, 0.02168807f, 0.04494253f, 0.01564497f, -0.78840959f, -0.42457595f, -0.62151134f, -0.15878318f, 
    -0.40257111f, 0.15383743f, -0.02912360f, -0.27087671f, 0.17255491f, 0.01559237f, -0.05165710f, -0.13347107f, 
    -0.41844106f, 0.08227154f, 0.02934606f, 0.12796198f, -0.18694825f, -0.36787894f, 0.10999785f, -0.06975079f, 
    0.00615282f, -0.00712392f, 0.10032181f, -0.00261203f, 0.21803217f, 0.09639189f, 0.18196182f, -0.13301973f, 
    -0.07610196f, 0.14254686f, -0.02746308f, 0.10911052f, -0.19449504f, 0.02551158f, -0.07191341f, -0.24889080f, 
    0.37627429f, 0.00338542f, 0.66204494f, -0.32323542f, 0.12357243f, -0.16846876f, 0.30828333f, 0.14984277f, 
    -0.16459449f, 0.01294678f, 0.20094749f, 0.05633756f, -0.55823177f, -0.02553872f, -0.64887202f, 0.59986967f, 
    -0.06866156f, 0.31445515f, 0.01541720f, -0.09246605f, 0.06561100f, 0.04240387f, -0.20905443f, -0.16339982f, 
    0.05086146f, -0.55942696f, -0.36151260f, 0.43630370f, -0.33179665f, -0.05388013f, 0.02607630f, -0.25789639f, 
    0.03532683f, 0.06500930f, 0.12168478f, 0.07628555f, -0.18533112f, 0.07233504f, -0.21987897f, 0.17939587f, 
    0.17853820f, -0.07419889f, 0.04136418f, 0.16960143f, 0.32989156f, 0.07601082f, 0.36539999f, -0.10389302f, 
    -0.19171345f, -0.19736752f, -0.06518472f, -0.10884614f, -0.30163053f, -0.09782188f, -0.22180136f, -0.37441492f, 
    0.03949654f, 0.03821015f, -0.21062936f, -0.12690865f, -0.08299058f, 0.29655012f, -0.13378140f, -0.58451492f, 
    -0.11232319f, -0.09386656f, 0.44049081f, 0.18413918f, -0.09183464f, 0.03081025f, 0.04975943f, 0.04796419f, 
    -0.10443549f, 0.17700684f, -0.32981995f, -0.19387172f, -0.24144574f, -0.00347708f, -0.06391190f, 0.02700179f, 
    0.04616343f, 0.03555316f, 0.06493359f, 0.18110937f, 0.09025394f, 0.45803866f, -0.42306194f, 0.12907946f, 
    -0.13636565f, 0.10672659f, 0.01394164f, 0.03697047f, -0.02913173f, 0.01372734f, -0.12599857f, -0.04833457f, 
    -0.59546655f, -0.18709761f, -0.34793022f, 0.48596966f, 0.46882030f, 0.04350715f, 0.08630627f, -0.27070925f, 
    -0.04309963f, -0.20332059f, 0.18319860f, 0.29743552f, -0.77655596f, -0.11196425f, -0.85283136f, 0.72727847f, 
    -0.01818975f, -0.00674337f, 0.00348278f, -0.11469411f, 0.11634678f, 0.14231133f, 0.28399724f, -0.15273809f, 
    0.66055006f, -0.34840006f, 0.16840702f, 0.47659364f, 0.35365525f, 0.22501126f, 0.14567207f, 0.09363196f, 
    0.10168698f, 0.03469651f, -0.02821802f, 0.11310154f, -0.69785953f, 0.16029449f, -0.68577015f, 0.08078440f, 
    0.15019520f, -0.31843877f, 0.24389181f, -0.01358307f, -0.13529263f, -0.04055789f, -0.30936223f, -0.40670297f, 
    -0.88641948f, 0.31875429f, 0.11677934f, 0.03292985f, 0.02875109f, 0.14301488f, 0.39765522f, 0.05114871f, 
    -0.03423414f, -0.28400803f, -0.03736953f, 0.02437285f, 0.65676528f, 0.89593869f, 0.11294945f, -0.37141791f, 
    -0.00385462f, 0.06348553f, -0.20999518f, -0.10779972f, -0.09194638f, 0.01510078f, -0.05287334f, -0.17015986f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.33363685f, 0.09468707f, 0.17973433f, -0.05986274f, -0.22379409f, 0.09926605f, 0.16557415f, -0.32268548f, 
    0.25783309f, -0.03677080f, 0.18367754f, -0.12133720f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
