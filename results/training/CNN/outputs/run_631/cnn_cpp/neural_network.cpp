#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.96342313f, 0.65822178f, -0.37570140f, -0.05695121f, -0.53843457f, -0.18626153f, 0.41070932f, 0.34988114f, 
    0.43506986f, 0.75204170f, -0.26307946f, -0.09759964f, 0.23738450f, -0.27666199f, -0.22083504f, -0.17866334f, 
    -0.01730378f, -0.19213128f, -0.25534227f, 0.02309159f, 0.09938307f, -0.47778699f, -0.04371362f, -0.23426670f, 
    -0.18884873f, -0.70195442f, -0.84170097f, -0.59831154f, 0.05705703f, 0.36407429f, 0.01116696f, 0.15458421f, 
    0.26629287f, -0.45845717f, -0.63600302f, -0.06005740f, 0.37587351f, -0.06994930f, 0.21950680f, 0.26519161f, 
    -0.10455791f, -0.00486000f, -0.58862406f, -0.38899240f, 0.12071013f, 0.01579525f, 0.10149353f, 0.10224721f, 
    0.48527235f, 0.00668976f, 0.87805694f, -0.27550095f, -0.08295169f, 0.72991675f, 0.55824578f, 0.57197154f, 
    0.17968118f, -0.55361152f, 0.43963096f, 0.01210975f, 0.01167592f, 0.04037713f, -0.48327270f, 0.23799762f, 
    -0.23058826f, 0.33657148f, 0.14854330f, 0.32851076f, 0.43257916f, 0.57170224f, 0.00855933f, 0.26922244f, 
    -0.13882881f, -0.33759513f, -0.03388111f, -0.89409626f, -0.72137475f, -0.18048307f, 0.26247472f, 0.25827831f, 
    0.23472209f, 0.35683930f, 0.39994413f, 0.16778404f, -0.18562350f, 0.00975406f, -0.11713100f, 0.22682355f, 
    0.13476482f, 0.39526466f, 0.02426064f, 0.08992475f, 0.21862303f, 0.01336772f, 0.21890441f, -0.26947442f, 
    -0.19111618f, -0.28594080f, -0.08867326f, 0.05410979f, -0.11285923f, -0.81877089f, 0.53245211f, -0.17268825f, 
    0.10850015f, 0.66671640f, -0.00511925f, 0.37794602f, -0.25145933f, -0.21339883f, 0.14632167f, 0.08624876f, 
    0.15198989f, -0.48004091f, 0.02818062f, -0.22941045f, -0.53178072f, -0.03540920f, -0.46664277f, -0.63766247f, 
    0.22819266f, 0.52981234f, 0.16690709f, -0.07805042f, 0.21228364f, 0.28893167f, -0.09851908f, -0.47563395f, 
    0.11931030f, -0.03342023f, -0.29591060f, -0.80163866f, -0.65056771f, -0.55501908f, -0.04421952f, 0.06226277f, 
    -0.07022100f, -0.20280449f, 0.37475932f, -0.34743530f, 0.00011253f, -0.17532273f, -0.39471927f, -0.21191549f, 
    -0.33474731f, 0.18160881f, 0.35834318f, 0.52288818f, 0.23963118f, 0.19593696f, 0.61500067f, 0.49428028f, 
    0.52242762f, 0.47295293f, 0.60749465f, 0.50396115f, 0.18255025f, 0.65666133f, 0.28976360f, -0.04702383f, 
    -0.15297112f, -0.26774198f, -0.26409605f, -0.07791084f, -0.07830695f, 0.19096981f, -0.03373538f, 0.15632370f, 
    0.03242390f, 0.08175842f, -0.19809364f, -0.15560152f, 0.30701569f, 0.22872521f, 0.23826295f, -0.76574522f, 
    0.23701257f, -0.18257655f, -0.31164733f, -0.41416845f, 0.83913767f, 0.35083178f, 0.31442630f, 0.25321719f, 
    0.28963402f, -0.49596909f, -0.22238342f, -0.52815342f, -0.29429621f, 0.06202036f, -0.22734459f, 0.05773903f, 
    -0.45129082f, 0.06293102f, 0.04884674f, -0.35292122f, -0.19336922f, 0.21425742f, -0.19177125f, -0.10805859f, 
    -0.53712374f, -0.54196137f, -0.44268152f, 0.43095121f, -0.64562231f, 0.63036132f, 0.84059709f, -0.58417046f, 
    0.59490305f, 0.47891304f, -0.05992736f, -0.22403601f, 0.18681712f, -0.03070202f, -0.41925493f, -0.14332771f, 
    0.12286131f, 0.09332651f, -0.02230711f, -0.22161181f, 0.05333276f, -0.19265813f, 0.00817630f, 0.07433049f, 
    -0.08116123f, -0.64638907f, -0.85084260f, -0.62207484f, -0.46563840f, -0.09269103f, -0.34196571f, 0.50609970f, 
    0.50842661f, -0.31612623f, 0.54020435f, 0.05488469f, -0.14668073f, 0.25328639f, 0.02789947f, 0.26010007f, 
    -0.22017293f, -0.18564481f, -0.07784857f, -0.12200541f, -0.04628611f, 0.14994751f, 0.12394984f, -0.25657612f, 
    0.16058603f, 0.12379406f, 0.86117840f, 0.32527882f, 0.40692785f, 0.67545903f, 0.58096880f, -0.59776324f, 
    -0.73616087f, 0.02152731f, 0.06224918f, 0.03611800f, 0.31604710f, 0.02624558f, 0.13937268f, -0.21938740f, 
    -0.24816146f, 0.01593615f, -0.01817127f, 0.23003985f, -0.13142709f, -0.09509698f, -0.09279212f, 0.06038445f, 
    -0.00113168f, -0.26610884f, 0.23857470f, 0.44873682f, 0.95383310f, 0.70162290f, 0.13073038f, -0.26042438f, 
    -0.47435427f, -0.05116365f, -0.41846928f, -0.44631761f, 0.19181922f, 0.05470665f, 0.09547757f, 0.05696511f, 
    0.11748831f, 0.12998022f, -0.04818901f, -0.07050580f, 0.31349522f, 0.01289687f, -0.10231487f, 0.40712973f, 
    -0.07487632f, -0.31640923f, 0.31681818f, 0.42872015f, 0.43633434f, 0.00363327f, 0.61379081f, 0.73560077f, 
    0.43890765f, -0.24106298f, -0.04948811f, -0.44622964f, -0.34604347f, 0.34790283f, -0.27933788f, 0.38750869f, 
    0.13249612f, 0.47377291f, -0.00113721f, -0.25266111f, 0.09543935f, 0.32269993f, 0.13006057f, -0.29324570f, 
    -0.20974091f, 0.45654804f, -0.22093396f, -0.06391609f, 0.01683501f, -0.47021413f, -0.43029070f, -0.71482539f, 
    -0.22255328f, 0.60444200f, -0.41254407f, 0.83223093f, 0.40230492f, -0.47656694f, -0.19441703f, -0.16148461f, 
    -0.39080203f, 0.11446115f, -0.42143890f, 0.00502907f, -0.40778571f, 0.14891057f, 0.00775945f, 0.14716606f, 
    -0.06362120f, 0.19160268f, -0.04377594f, 0.17320022f, 0.01201584f, -0.22176827f, 0.06298207f, -0.08734608f, 
    0.48067263f, 0.40045002f, -0.81004792f, -0.07983322f, 0.21728297f, 0.33863127f, -0.55082279f, 0.21904586f, 
    0.15915704f, 0.19823723f, -0.36326471f, 0.02694538f, -0.13097778f, 0.32773086f, -0.08764985f, 0.16276066f, 
    -0.11364140f, 0.22725926f, 0.23931895f, 0.46734363f, 0.26272365f, 0.21463028f, -0.12646791f, 0.12063167f, 
    0.31896669f, -0.32659680f, 0.54698569f, 0.19533640f, -0.04243493f, 0.20588364f, 0.50038719f, 0.39611307f, 
    0.29536918f, -0.01430581f, -0.35908404f, 0.46405098f, -0.48408967f, 0.14176840f, -0.29457611f, -0.30775115f, 
    -0.41924861f, -0.19817315f, -0.00752188f, 0.25518376f, -0.13056445f, 0.06659606f, 0.30084994f, -0.10099039f, 
    -0.23930036f, -0.75442296f, 0.84189886f, -0.08480467f, 0.37247574f, 0.83486205f, -0.48640385f, 0.65873975f, 
    0.06743878f, -0.57148743f, 0.28243878f, -0.28584459f, 0.24057448f, 0.24235758f, -0.10355248f, 0.03991570f, 
    0.38868389f, 0.23807730f, -0.30323324f, 0.32225925f, -0.24072185f, -0.03698108f, -0.01037006f, -0.42419225f, 
    0.12666903f, 0.34888080f, 0.32788694f, 0.57160580f, 0.75223315f, -0.53479612f, 0.09515893f, 0.22659133f, 
    -0.14271645f, -0.03241175f, 0.46406657f, -0.05105329f, 0.20567511f, 0.12461580f, 0.33239016f, 0.44773659f, 
    0.17681904f, -0.32777399f, 0.10891561f, -0.33989096f, -0.20487349f, 0.05765472f, 0.11459220f, 0.21558279f, 
    0.22737037f, -0.36829996f, 0.59538764f, 0.57970107f, 0.37240225f, -0.60323244f, 0.58307487f, -0.41071048f, 
    0.21004990f, -0.21891673f, 0.20962064f, -0.03408876f, -0.51040596f, -0.27710426f, -0.09033567f, 0.34426135f, 
    0.45652798f, 0.21677575f, -0.27287757f, 0.20380472f, -0.10585210f, 0.38543415f, 0.46236545f, 0.02437129f, 
    -0.05618348f, 0.04719950f, -0.22276115f, 0.68507719f, 0.84361488f, 0.69128525f, -0.26405171f, -0.05638679f, 
    0.00503289f, 0.54667121f, -0.04698767f, -0.49417806f, 0.22931583f, 0.32364380f, 0.08724748f, 0.07388470f, 
    0.06309647f, -0.19657855f, 0.23402247f, 0.03850385f, 0.12919003f, 0.10529783f, -0.26529911f, 0.09375680f, 
    0.18296893f, 0.08732517f, -0.26638618f, 0.29266867f, -0.05828989f, 0.17869624f, 0.35339803f, -0.01830757f, 
    -0.09488353f, -0.08753926f, -0.60474229f, -0.69191915f, -0.61887342f, -0.03093443f, -0.19510230f, -0.02375371f, 
    0.32348776f, 0.36968786f, -0.19155882f, -0.07534929f, -0.38434994f, 0.21415262f, -0.02274572f, 0.62787139f, 
    0.43894616f, 0.14235952f, -0.24533655f, -0.16372679f, -0.26336023f, 0.76096529f, -0.11390745f, 0.55251092f, 
    0.55810601f, -0.19291864f, -0.81469506f, 0.24205059f, -0.41412640f, 0.23765953f, -0.27130243f, 0.43899435f, 
    0.25653818f, 0.16917928f, 0.03050736f, 0.05994212f, 0.14795624f, 0.01286204f, 0.14214474f, 0.30517837f, 
    -0.00355858f, -0.25674903f, 0.03372051f, -0.06520887f, 0.29446736f, -0.02723732f, -0.00697412f, -0.74430746f, 
    -0.32061148f, -0.60664958f, -0.18356015f, -0.15680443f, 0.19062792f, 0.65965790f, 0.31752545f, 0.51941460f, 
    -0.38065544f, 0.39284959f, -0.32050034f, -0.01084464f, -0.17203827f, 0.12022594f, -0.09896541f, 0.15912011f, 
    0.21314779f, -0.04130442f, -0.21448594f, 0.06681865f, -0.13466778f, 0.13936503f, 0.08081683f, 0.14270398f, 
    0.31169945f, -0.62850934f, 0.59732783f, 0.96365422f, 0.44468275f, 0.47581747f, 0.67609072f, 0.26617765f, 
    0.21690515f, -0.11628412f, -0.14088207f, -0.11362118f, -0.02041472f, 0.23827651f, 0.09358885f, -0.11361150f, 
    0.12103353f, -0.14587472f, 0.09041196f, 0.45590106f, -0.04289797f, -0.07909274f, 0.22115442f, -0.30138373f, 
    -0.61254501f, 0.57943493f, 0.47519672f, -0.09391761f, -0.10318352f, 0.14148170f, 0.83979237f, -0.31922835f, 
    -0.26456466f, 0.38668457f, -0.08606263f, 0.11915737f, 0.41696763f, -0.42324054f, 0.20591761f, -0.14600581f, 
    -0.49712622f, -0.07104355f, -0.22263998f, -0.03616782f, -0.03460744f, 0.12974915f, -0.03282135f, 0.22801507f, 
    -0.20438600f, 0.45022792f, 0.81852400f, 0.75022620f, -0.11574314f, 0.41175815f, 0.51275343f, -0.58645463f, 
    -0.56796724f, -0.35041267f, -0.11969861f, -0.12194350f, 0.27200589f, -0.16897561f, 0.27988601f, -0.14451264f, 
    -0.17432378f, 0.31033471f, 0.22495219f, -0.11661768f, 0.18502310f, 0.11139072f, 0.02093349f, -0.02250326f, 
    -0.18418938f, 0.03943479f, -0.40650454f, -0.80170697f, -0.67954099f, -0.18194932f, 0.06322151f, -0.54681468f, 
    -0.11991917f, -0.34943894f, -0.31583560f, 0.44730535f, 0.44180930f, 0.15622792f, 0.34595168f, 0.03467998f, 
    0.26385626f, -0.29018623f, 0.20658275f, 0.40318632f, 0.01954183f, 0.02944429f, 0.23707658f, -0.20629595f, 
    -0.05041529f, 0.04728811f, 0.16019146f, 0.23039347f, 0.51837820f, 0.79275525f, 0.63270038f, 0.56760740f, 
    0.54611301f, 0.15824890f, -0.46627292f, -0.31854087f, -0.33008343f, 0.14403629f, 0.33380699f, 0.21302040f, 
    -0.13048708f, -0.23058553f, 0.13466525f, 0.18441458f, 0.25067732f, -0.26444653f, 0.30974606f, 0.08598081f, 
    0.39428598f, -0.20184147f, 0.18070634f, 0.00055248f, -0.03001475f, -0.26960430f, 0.08826996f, 0.26410314f, 
    0.38361099f, -0.24626082f, -0.78478026f, -0.04609036f, -0.10619906f, -0.36391428f, -0.20397262f, 0.62482572f, 
    0.51576853f, 0.32921034f, -0.06519061f, 0.41637391f, -0.16805182f, 0.30955663f, 0.45188966f, -0.07464182f, 
    -0.33901563f, 0.37477803f, 0.01340529f, -0.32412171f, -0.10128656f, -0.19451983f, 0.83604538f, -0.44177559f, 
    -0.35751754f, 0.53412515f, 0.13223632f, -0.69417018f, -0.13411948f, 0.04447282f, -0.14364897f, 0.29003263f, 
    -0.17015202f, -0.33885461f, 0.40015128f, 0.12451201f, 0.19146751f, -0.18119541f, -0.12695964f, 0.02832369f, 
    0.24311046f, 0.37062588f, -0.01105541f, 0.10102909f, -0.47091773f, 0.48851231f, -0.57416570f, -0.39573449f, 
    0.32470733f, 0.40706640f, 0.29204103f, -0.67610508f, -0.05978845f, 0.17484185f, -0.19826232f, -0.66975731f, 
    0.30236682f, 0.36179626f, 0.13272333f, -0.05986470f, 0.22538951f, -0.40960902f, 0.19223896f, 0.20414706f, 
    -0.06302864f, 0.22032699f, 0.34098583f, -0.40698174f, -0.23840165f, -0.35994902f, 0.36629957f, 0.25610122f, 
    0.74645817f, -0.67061162f, -0.78969729f, -0.86106300f, 0.24553485f, -0.38069877f, -0.29215625f, -0.01273750f, 
    -0.45426750f, 0.09760226f, -0.23400562f, 0.46710512f, -0.07805461f, 0.01598155f, 0.08847421f, 0.12246099f, 
    0.27322054f, 0.16985479f, -0.00867025f, -0.00438789f, -0.12475956f, 0.23368032f, 0.26876050f, 0.08385067f, 
    0.89588302f, -0.32462028f, -0.35276133f, 0.71629351f, 0.45857409f, -0.56203783f, -0.18807782f, 0.34538415f, 
    -0.63445508f, -0.33220071f, -0.20391770f, 0.03305376f, 0.31160653f, -0.36051387f, -0.18455391f, -0.08466869f, 
    0.02642842f, -0.05782830f, 0.01932186f, -0.41121304f, -0.16549897f, -0.00189383f, 0.10108188f, -0.06991761f, 
    0.17721410f, 0.63131124f, 0.25296095f, 0.07273373f, 0.87396991f, 0.32804781f, 0.60632640f, 0.29330415f, 
    -0.19027494f, -0.00413085f, 0.48153636f, -0.07297212f, -0.17958306f, 0.17606467f, 0.29466745f, -0.22224623f, 
    -0.19921331f, -0.31039414f, 0.07121418f, -0.13596962f, -0.10517348f, 0.10109866f, -0.38647693f, 0.48617548f, 
    0.19601421f, 0.32639259f, 0.88710994f, 0.30761752f, -0.20344952f, 0.55989414f, 0.67106277f, -0.13661744f, 
    -0.22617488f, -0.19805609f, 0.33721915f, 0.42856255f, -0.41840589f, 0.20417504f, -0.02313035f, -0.38810834f, 
    0.07660155f, -0.40559173f, -0.21634543f, -0.16384377f, -0.31307730f, -0.03880896f, 0.22964153f, -0.28277797f, 
    0.32186720f, 0.15982012f, 0.20770867f, 0.22030289f, -0.78419346f, -0.83176732f, 0.05440680f, -0.50263882f, 
    -0.54154444f, 0.63977200f, 0.48095134f, 0.51646048f, -0.41083094f, 0.30741858f, 0.12037779f, -0.16359718f, 
    0.31500795f, -0.04275936f, 0.00521623f, -0.04499982f, -0.22222592f, -0.14152938f, -0.05369150f, 0.07437985f, 
    -0.18664894f, 0.38490251f, -0.12375621f, 0.01037342f, -0.44242555f, 0.28854540f, -0.64159137f, -0.54306310f, 
    0.52225637f, -0.09790304f, 0.52943981f, 0.11095229f, -0.36792937f, 0.32818893f, -0.26023099f, -0.27118680f, 
    0.32799241f, 0.38174412f, -0.03290309f, 0.21664080f, -0.42714620f, -0.35113665f, -0.09433323f, -0.39875183f, 
    -0.07442059f, 0.32995766f, 0.28702921f, 0.15668631f, 0.44507870f, -1.00079978f, -0.25219366f, 0.33771673f, 
    0.39941409f, -0.23481329f, 0.17822224f, 0.43128935f, -0.16292956f, 0.31919584f, -0.21484628f, 0.10119125f, 
    0.23849633f, -0.45408425f, 0.57014668f, -0.28666890f, -0.27262315f, 0.38172802f, -0.06912542f, -0.22066782f, 
    -0.37601516f, -0.08881171f, -0.02449619f, -0.13029264f, -0.03068644f, 0.29974821f, 0.71079177f, 0.65115398f, 
    0.80750763f, 0.18990284f, 0.39899585f, -0.24441361f, -0.12702301f, 0.08129933f, 0.15563977f, 0.10958632f, 
    -0.22679992f, -0.26406741f, 0.19024888f, 0.11208619f, 0.42628050f, 0.03160592f, -0.02165581f, 0.10350346f, 
    0.09564327f, 0.07843954f, 0.19609693f, 0.05396331f, -0.12205435f, -0.20675871f, 0.15938272f, -1.18751562f, 
    1.01329887f, 0.59925026f, -0.68933809f, 0.06517845f, -0.45934901f, 0.51969922f, 0.32089642f, -0.22505742f, 
    -0.40969548f, -0.41208878f, 0.21355249f, -0.02313462f, -0.03843353f, -0.03235803f, 0.22523317f, 0.07295664f, 
    0.12838799f, -0.14807065f, -0.34280133f, -0.07631231f, 0.04846392f, 0.14399417f, 0.09990922f, -0.08350365f, 
    -0.49758631f, -0.33623773f, -0.71107161f, -0.74562836f, -0.22420497f, -0.39071655f, 0.44512084f, 0.53943723f, 
    0.26786658f, 0.52148026f, 0.00960948f, -0.27081770f, 0.05589004f, -0.31315634f, -0.28920099f, 0.20761891f, 
    0.43631554f, 0.23271935f, 0.23329705f, 0.13977309f, 0.02549172f, -0.01757722f, 0.05329247f, -0.31550601f, 
    0.28839186f, 1.13968015f, 0.56730711f, 0.06494947f, 0.43315145f, 0.61827630f, 0.11352437f, 0.43649513f, 
    -0.46269721f, -0.22397141f, -0.48717424f, 0.01566549f, -0.09930608f, -0.06603441f, -0.16581792f, -0.44171268f, 
    0.02668493f, 0.08404569f, -0.00618084f, -0.22540854f, -0.08974880f, -0.17670391f, 0.24118383f, -0.11030988f, 
    0.04567536f, -0.08765119f, -0.66711307f, 0.07496238f, 0.67141122f, 0.92333776f, -0.37808079f, -0.06280207f, 
    -0.09264417f, 0.43966895f, 0.30704919f, -0.52760094f, -0.47896841f, -0.38131440f, -0.43050611f, 0.12420156f, 
    -0.04017211f, -0.24314070f, 0.14139460f, 0.02133259f, 0.24994704f, 0.16074930f, 0.02308988f, 0.24136399f, 
    -0.05844153f, 0.05550556f, -0.58253968f, 0.56210220f, 0.53837740f, -0.66710031f, -0.86143017f, -0.55429709f, 
    0.02749878f, -0.15338525f, 0.46068537f, 0.56719178f, 0.13679305f, -0.29714978f, 0.01439515f, 0.00018560f, 
    -0.26606596f, 0.07299218f, -0.04898678f, -0.09114242f, -0.01652710f, 0.02383488f, 0.10719969f, -0.01413912f, 
    0.31963295f, -0.28066057f, 0.34457144f, -0.19601247f, 0.67359376f, 0.71307135f, -0.02855368f, -0.46888655f, 
    0.63322932f, 0.65698773f, -0.50486636f, -0.06786809f, 0.47605374f, 0.55192304f, -0.27669257f, -0.23451360f, 
    -0.07699663f, 0.13915360f, -0.35222819f, 0.05923498f, 0.07737985f, 0.29830492f, 0.04769671f, -0.24172004f, 
    -0.29070529f, 0.06669530f, -0.06469774f, -0.15860085f, -0.33338901f, -0.79862410f, -0.29920998f, -0.49043968f, 
    -0.16001929f, -0.40191421f, 0.59159583f, 0.80247217f, 0.17682043f, 0.10216410f, 0.37371811f, -0.00198446f, 
    -0.19800909f, -0.10496727f, -0.18472949f, 0.32220480f, 0.16809218f, -0.02415486f, 0.21294989f, -0.00732319f, 
    -0.06060228f, 0.14205126f, -0.00939706f, 0.25722229f, 0.28272039f, 0.39987162f, -0.50350899f, -0.32325530f, 
    -0.69559228f, -0.76386517f, -0.59049553f, 0.43656155f, -0.50128448f, -0.19181193f, 0.23519649f, 0.44870290f, 
    -0.46941277f, -0.33859950f, 0.06342069f, 0.11691218f, -0.35487926f, 0.01815625f, 0.05951606f, -0.02940132f, 
    -0.09917758f, 0.21589711f, -0.08325595f, -0.06263215f, -0.15412629f, 0.09814056f, 0.44828832f, 0.14070921f, 
    -0.39783993f, -0.61261445f, -0.60335255f, -0.54323530f, 0.29876101f, -0.46752158f, -0.46161905f, -0.32357770f, 
    -0.32154578f, 0.28926656f, 0.40485844f, 0.07953488f, 0.16508065f, 0.02233148f, 0.07900593f, 0.30929017f, 
    0.29043916f, 0.02491306f, 0.02958724f, 0.01823392f, -0.04258038f, -0.35728046f, 0.19135423f, 0.36709103f, 
    -0.39847818f, -0.46397287f, -0.31826299f, 0.57882285f, 0.37585804f, 0.10325927f, -0.45562494f, 0.46006244f, 
    0.46972638f, -0.62244529f, 0.28504756f, -0.12856998f, -0.11920716f, 0.08943679f, 0.28499582f, 0.57891852f, 
    0.21264008f, 0.16515030f, -0.20358852f, -0.22541091f, 0.08487728f, 0.08072108f, 0.06591275f, -0.13295519f, 
    0.07318167f, 0.59522814f, 0.77398247f, 0.54963619f, -0.41083306f, -0.86193168f, -0.49106169f, -0.58758718f, 
    0.06553039f, 0.10764764f, 0.42565152f, 0.38935649f, 0.40026355f, -0.19033603f, 0.18170840f, 0.32493326f, 
    0.08054195f, 0.31347689f, -0.33369192f, -0.13818787f, 0.12844537f, 0.00260230f, -0.06304521f, 0.04396472f, 
    0.15776959f, 0.28901133f, -0.15060453f, -0.26116666f, 0.92666703f, 0.52673447f, -1.06670177f, -0.60304141f, 
    -0.43438023f, -0.08161440f, 0.13209032f, -0.19177587f, 0.30867973f, 0.29533997f, 0.11231077f, -0.10981227f, 
    -0.09040234f, -0.33636954f, -0.06264073f, 0.01560036f, -0.04394223f, -0.17360727f, 0.10208981f, -0.03950807f, 
    -0.04564559f, -0.13918115f, 0.15042570f, -0.17970431f, 0.16891128f, -0.12060180f, 0.93361849f, 0.82061106f, 
    0.63052845f, 0.18196295f, 0.04331854f, 0.25661924f, 0.21749818f, -0.02366878f, -0.30595776f, -0.05727516f, 
    -0.21997787f, 0.11004917f, -0.28330451f, -0.27548370f, -0.01264566f, 0.14978364f, -0.17416455f, 0.17320557f, 
    0.09771063f, -0.01973808f, -0.03200098f, -0.27367905f, 0.99370158f, 0.37371588f, 0.49655023f, -0.18370083f, 
    -0.48380604f, -0.82701945f, 0.46245733f, -0.48317444f, 0.14132400f, 0.29967007f, -0.07192154f, 0.30147690f, 
    -0.24922295f, -0.12829684f, -0.29238185f, -0.04230120f, -0.15002680f, -0.20424411f, 0.00499611f, 0.01048512f, 
    -0.19052638f, 0.25253043f, -0.11004640f, -0.13872696f, -0.09352631f, -0.70914435f, -0.43375123f, 0.23130687f, 
    -0.22755527f, -0.60757160f, -0.65681607f, -0.44754240f, 0.34146944f, -0.25709456f, -0.00410560f, 0.32114395f, 
    0.05883164f, -0.13886739f, 0.16159675f, -0.12770635f, 0.50565785f, -0.16553396f, -0.10822146f, 0.05498918f, 
    -0.14020054f, -0.04487571f, -0.40306756f, -0.04425128f, -0.27667999f, 0.43581960f, 0.14451593f, -0.14525299f, 
    -0.15075031f, -0.34665307f, -0.37094095f, 0.12807000f, 0.60083580f, -0.31328684f, -0.82094967f, -0.36502987f, 
    0.16830206f, 0.24336602f, 0.00247218f, -0.31786394f, -0.30921355f, -0.61275667f, 0.39514333f, 0.20138477f, 
    0.11043351f, -0.56160873f, -0.08610523f, -0.00396095f, 0.11015990f, 0.02200272f, 0.05025367f, -0.68659139f, 
    0.10951160f, 0.61359853f, 0.16475691f, -0.14619160f, -0.90842682f, 0.40169796f, -0.23965296f, -0.30255187f, 
    0.06648450f, 0.14981218f, 0.63584244f, -0.32260582f, 0.08660612f, -0.23434199f, 0.21041501f, 0.01780813f, 
    0.16026258f, 0.03092965f, 0.46795470f, -0.09878478f, -0.24839839f, 0.31545618f, 0.39702696f, -0.20017853f, 
    0.43615198f, 0.50266528f, 0.67136472f, 0.51751989f, 0.47265166f, 0.21740943f, -0.19959678f, 0.02676379f, 
    0.27346560f, -0.30605391f, -0.13374183f, 0.20174408f, 0.16240852f, 0.04695403f, 0.04410002f, 0.41699091f, 
    0.11854531f, -0.42309642f, -0.44726455f, -0.13415906f, -0.40332857f, -0.19695167f, -0.21368611f, -0.24332361f, 
    -0.18392588f, -1.43780053f, 0.65525180f, 0.79092830f, -0.80071718f, -0.43582138f, 0.82247835f, 0.17791195f, 
    -0.26290268f, 0.60562193f, 0.16938657f, 0.10927483f, -0.19873948f, 0.29303122f, 0.20299372f, -0.09476466f, 
    -0.31993207f, -0.12180260f, -0.03293369f, -0.12409568f, -0.19799371f, 0.08404555f, 0.17378089f, 0.00163075f, 
    0.14930858f, 0.06348542f, -0.23509961f, -0.80020660f, -0.37698150f, 0.12355655f, -0.31254449f, -0.67298728f, 
    0.39913592f, 0.73812169f, -0.56926906f, 0.07623044f, -0.13950175f, -0.14452718f, -0.55132329f, -0.48489672f, 
    -0.20535307f, 0.08179505f, -0.01018630f, 0.04273046f, -0.57263428f, -0.23121291f, -0.23949589f, -0.09386731f, 
    0.29136840f, 0.17169903f, 0.06823937f, 1.03030443f, 0.50644302f, 0.43417203f, -0.51380837f, -0.79821670f, 
    0.46779448f, -0.33017561f, -0.22645490f, -0.57424414f, 0.16999193f, 0.31670359f, 0.00739910f, -0.01824786f, 
    -0.08836921f, -0.26223546f, -0.21265630f, -0.26073417f, 0.04889489f, 0.02091436f, 0.04834234f, -0.12796432f, 
    0.11566725f, -0.05966280f, -0.21951912f, -0.03838230f, -0.59447801f, 0.29649708f, 0.28328177f, -0.57051259f, 
    -0.02051371f, -0.64505678f, 0.49873653f, 0.10938318f, -0.08289630f, -0.47174495f, 0.09435483f, -0.04612623f, 
    -0.29664722f, -0.06535055f, 0.07685710f, 0.17648013f, -0.34632349f, 0.13034284f, -0.36264849f, -0.09006955f, 
    0.18994039f, 0.43502983f, 0.17345200f, 0.32330024f, -0.25324103f, 0.60206026f, -0.22994186f, -0.03489845f, 
    0.59770149f, 0.26743606f, -0.79618841f, 0.19279262f, -0.56893575f, -0.24797671f, 0.57049137f, 0.33933359f, 
    0.43230832f, -0.38434306f, 0.10500066f, -0.25427762f, -0.41544259f, -0.33467916f, -0.37205881f, 0.19650941f, 
    -0.20859158f, 0.22576055f, 0.16946596f, 0.08106171f, 0.04398620f, 0.05885537f, -0.07129715f, 0.49627969f, 
    0.85028207f, 0.43763971f, 0.46669790f, 0.36111861f, -0.04028217f, 0.17509772f, 0.18477955f, -0.20014849f, 
    0.33828437f, -0.11285865f, 0.28685802f, 0.36604702f, -0.68822509f, -0.05133212f, -0.33115590f, 0.31903830f, 
    -0.26953331f, -0.10483045f, -0.04162171f, -0.42173946f, 0.10246068f, -0.20968661f, -0.25923717f, 0.94825888f, 
    0.66470987f, 0.51487815f, -0.05876107f, 0.17090006f, 0.25895494f, -0.16407824f, 0.04211485f, 0.42549303f, 
    0.37530991f, 0.24132392f, 0.29840410f, -0.23689763f, -0.20638634f, 0.28167903f, 0.01945267f, -0.15032944f, 
    -0.16266035f, -0.16045310f, -0.30019134f, -0.19680664f, 0.55284262f, 0.11647327f, -0.07212569f, 0.20102420f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30575228f, 0.06683432f, 0.14230520f, 0.08681851f, 0.12830739f, 0.20146510f, 0.04243689f, -0.08794748f, 
    0.18632440f, 0.10281994f, 0.20977126f, 0.06926209f, 0.13216107f, 0.11530825f, 0.13539790f, 0.08818530f, 
    0.17902993f, 0.20379722f, 0.13908455f, 0.16865668f, 0.19212176f, 0.10880317f, 0.10051981f, 0.21597378f, 
    0.11038741f, -0.05456261f, 0.39893779f, 0.16119336f, -0.04222860f, 0.12133571f, 0.02582744f, 0.20750421f, 
    0.04835881f, 0.00611096f, 0.24990846f, 0.22908497f, -0.05114552f, 0.22077353f, 0.25968927f, 0.16230085f, 
    0.11889115f, -0.03616069f, 0.06391209f, 0.06734262f, 0.00067370f, -0.04022413f, 0.16515546f, 0.21380997f, 
    0.16888532f, 0.12409636f, 0.31152514f, 0.15672837f, -0.02646736f, 0.04003443f, 0.29011771f, 0.13971697f, 
    0.02846595f, 0.02933776f, 0.03595304f, 0.19067112f, 0.29723930f, 0.05426315f, 0.05076003f, 0.06795182f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11203406f, -0.03243125f, -0.15487579f, -0.14209810f, -0.03665332f, -0.11186485f, -0.01686118f, 0.05824333f, 
    0.02216816f, 0.06704199f, 0.07903694f, 0.01829274f, -0.24714099f, 0.19277737f, -0.12895846f, -0.01765722f, 
    0.09140483f, 0.02401307f, -0.06547643f, -0.02395177f, 0.09175841f, -0.05405895f, 0.11942319f, -0.15642138f, 
    0.13210638f, -0.19146404f, -0.01389253f, 0.19803220f, -0.04270143f, -0.04601912f, 0.01109039f, 0.05197221f, 
    0.06490634f, -0.00492382f, -0.00850042f, 0.04743209f, -0.20098847f, 0.13375159f, -0.09206759f, 0.00087100f, 
    0.06596627f, -0.00030250f, -0.03142475f, 0.09598436f, 0.04948214f, 0.01862055f, -0.05333170f, 0.02450694f, 
    -0.03399692f, 0.01761940f, 0.15731312f, -0.00533893f, -0.04561402f, -0.00925748f, 0.03512940f, 0.01156089f, 
    -0.21814694f, 0.09844464f, -0.01822385f, 0.07027972f, 0.02247265f, -0.16539302f, 0.17662817f, 0.09041924f, 
    -0.00199129f, -0.00042678f, 0.01099584f, 0.06314549f, -0.13299263f, 0.01605153f, -0.04781472f, -0.08428913f, 
    0.02888791f, -0.05718092f, 0.01390646f, 0.12294114f, -0.13611525f, 0.03946091f, -0.04995571f, 0.05536623f, 
    0.03600597f, -0.01208972f, 0.01216137f, -0.08513565f, 0.34228298f, 0.07219438f, 0.11636157f, -0.06788247f, 
    0.07304237f, 0.09599303f, 0.01655267f, 0.05194615f, -0.04764216f, -0.05870919f, -0.01542420f, 0.07488501f, 
    0.33415124f, 0.21575843f, -0.14631113f, 0.02841804f, 0.00170843f, 0.08669011f, -0.06941689f, -0.02526714f, 
    -0.00912090f, -0.06656262f, -0.08489365f, 0.06641179f, -0.17797966f, 0.15102349f, -0.13613889f, -0.16939826f, 
    -0.00368213f, -0.04551411f, -0.07379676f, 0.00061976f, 0.10007831f, 0.00915464f, -0.03018311f, 0.07103448f, 
    0.13239452f, -0.03387135f, 0.01731157f, 0.07348268f, -0.13015562f, -0.01272559f, -0.09259880f, 0.04291304f, 
    -0.02068372f, 0.02925961f, -0.09663794f, -0.01241197f, -0.08067491f, 0.14488424f, -0.00322992f, -0.02673874f, 
    -0.15341294f, -0.00364996f, 0.07867816f, -0.05491588f, -0.06953605f, -0.01546675f, -0.08536629f, 0.01836215f, 
    0.10596042f, -0.00923978f, -0.17172699f, 0.14272285f, -0.14378212f, -0.03484630f, 0.04126137f, 0.04171363f, 
    -0.12313430f, 0.11331161f, -0.10734618f, 0.04998077f, -0.37134925f, 0.22444072f, 0.09540030f, -0.03909104f, 
    -0.00661856f, 0.00805405f, -0.03549148f, 0.00351610f, 0.01591999f, 0.04375724f, 0.06561443f, 0.07543367f, 
    -0.04555757f, 0.01282695f, 0.04208921f, 0.06606098f, -0.07798968f, 0.01847931f, -0.19089344f, -0.00775015f, 
    0.05019899f, -0.09473766f, 0.06291728f, 0.00006289f, -0.03572021f, 0.03329090f, -0.11530446f, 0.05399550f, 
    -0.02410012f, 0.17048883f, -0.03410914f, -0.05357901f, -0.02491149f, -0.02531087f, 0.12999809f, 0.14076129f, 
    -0.00818789f, -0.10755991f, 0.00594794f, -0.03891455f, 0.09161656f, 0.04694622f, 0.03009603f, 0.00408455f, 
    0.01641744f, -0.04029162f, -0.05098570f, 0.04693764f, 0.09185837f, 0.00046660f, -0.26759914f, 0.15138541f, 
    -0.09371653f, -0.02866140f, -0.07753674f, 0.02460241f, -0.09319216f, 0.03592720f, 0.03234484f, -0.10449315f, 
    0.04121743f, 0.08361319f, -0.04410901f, -0.46076638f, -0.00122504f, 0.07850254f, 0.02019826f, 0.00929982f, 
    0.10010041f, -0.05511398f, -0.08932788f, -0.01303389f, 0.00432836f, 0.16743799f, 0.08875994f, -0.27106407f, 
    -0.11251272f, -0.00969814f, 0.03894674f, 0.03545875f, -0.10632008f, 0.03717891f, -0.13311900f, -0.00758500f, 
    -0.08373170f, 0.11548427f, 0.15394662f, -0.06365182f, 0.03079005f, -0.03245493f, -0.01878857f, -0.10076346f, 
    0.02903792f, -0.14376400f, -0.03128991f, 0.03790190f, 0.19420497f, -0.04210630f, -0.18084247f, 0.23324916f, 
    -0.05052275f, -0.09095394f, -0.00996662f, 0.01559700f, 0.08371061f, 0.00541043f, -0.03928024f, -0.12283818f, 
    0.15183862f, -0.09761325f, -0.08551425f, -0.30424401f, -0.04222346f, 0.00879682f, -0.04968458f, -0.05047760f, 
    0.01108185f, 0.04337655f, 0.04719265f, 0.01082316f, -0.02223427f, 0.12479235f, 0.13508701f, 0.13660343f, 
    -0.13447517f, 0.06812884f, 0.01931312f, -0.07609260f, 0.00173325f, 0.00046510f, 0.01885508f, 0.01917439f, 
    0.09371044f, 0.00393815f, 0.12913199f, 0.00746884f, -0.14465180f, -0.04697143f, 0.05303330f, -0.03272857f, 
    -0.00143040f, 0.05085316f, 0.04381536f, -0.02136491f, -0.06792882f, 0.10350161f, 0.11829422f, -0.21921216f, 
    -0.09230011f, -0.09604761f, 0.05556554f, -0.02215522f, 0.02648671f, 0.01516196f, -0.10146204f, 0.05245719f, 
    -0.29457065f, -0.25811478f, -0.02197282f, 0.08189981f, -0.01651414f, -0.10648747f, -0.05673274f, 0.09518141f, 
    -0.09353951f, -0.00279776f, -0.13901947f, -0.00492316f, -0.00611905f, -0.01778010f, -0.04489236f, 0.07220375f, 
    -0.12668714f, -0.11890531f, 0.06827570f, -0.02332609f, -0.06943109f, 0.05505487f, -0.16348803f, 0.00490007f, 
    0.05348659f, -0.15315554f, 0.00614673f, -0.08818931f, 0.01911284f, 0.02215077f, -0.04775096f, 0.04716643f, 
    -0.00240081f, 0.01034021f, -0.16431271f, -0.05881141f, 0.06186469f, 0.01222262f, 0.35330564f, -0.16060355f, 
    -0.07521138f, -0.04886918f, 0.00251898f, 0.00434758f, 0.02646945f, -0.07493167f, 0.08275148f, 0.00783023f, 
    -0.17691353f, -0.01803135f, -0.05202904f, 0.00708873f, -0.10318701f, -0.00952957f, 0.12052798f, -0.05782247f, 
    -0.01498847f, -0.05718732f, 0.01531043f, 0.02058302f, -0.05896033f, 0.12330372f, 0.12734497f, -0.19521818f, 
    -0.10439219f, 0.01474416f, 0.06368704f, -0.02393054f, -0.06434774f, -0.04738944f, -0.06786609f, -0.00082695f, 
    0.28659427f, 0.00535516f, 0.01669895f, 0.21337667f, -0.15621303f, 0.05804357f, -0.05004596f, 0.02414775f, 
    -0.08671599f, 0.05267723f, 0.07352391f, -0.05506962f, 0.09501562f, 0.00887772f, -0.08280107f, 0.28683594f, 
    -0.17423119f, -0.00656375f, -0.06480329f, 0.05703892f, -0.17493455f, 0.13384169f, 0.01236721f, -0.00780224f, 
    0.12962747f, -0.16187169f, -0.03532779f, 0.21405150f, -0.12251675f, -0.06286988f, -0.06276536f, 0.02401830f, 
    -0.05491484f, -0.04823319f, -0.01849876f, -0.03296557f, -0.21894673f, 0.17896387f, -0.17250404f, -0.08483390f, 
    -0.09480835f, 0.01573580f, 0.06524244f, -0.03229322f, 0.04025491f, 0.03084303f, -0.06136095f, -0.08282923f, 
    0.05334649f, 0.08334198f, 0.07489885f, -0.18881579f, -0.00586254f, 0.01646604f, 0.05344370f, 0.04118483f, 
    -0.02641560f, 0.11625276f, -0.06711023f, -0.10722274f, -0.22828716f, 0.02070229f, -0.08759309f, 0.07749601f, 
    -0.00072054f, -0.03021220f, 0.05867229f, 0.05746877f, -0.00194313f, 0.05222258f, -0.13658211f, 0.02401816f, 
    0.07745119f, 0.06450994f, -0.14488716f, -0.08055714f, -0.10267598f, -0.10886782f, -0.02999505f, 0.04786296f, 
    -0.01212529f, -0.03125155f, -0.03210243f, -0.01084850f, -0.32747713f, 0.08769363f, 0.11579365f, 0.01999269f, 
    0.08246925f, -0.04162002f, -0.02527376f, -0.01670696f, 0.04953359f, -0.01012775f, -0.05735968f, -0.03065751f, 
    0.05969305f, 0.17345254f, -0.11925550f, -0.39062613f, 0.10766413f, 0.03727054f, 0.05897722f, 0.02108163f, 
    -0.05714053f, 0.02012652f, 0.02143125f, 0.02501751f, 0.12379365f, 0.21969613f, 0.04333552f, 0.04651316f, 
    -0.21224733f, -0.03116256f, -0.03213463f, 0.12020258f, 0.03421273f, -0.05611312f, -0.00550032f, -0.18606788f, 
    -0.22619179f, 0.09683336f, -0.00540464f, 0.44076452f, -0.03503772f, 0.00707936f, 0.05794814f, 0.01541143f, 
    0.04855174f, -0.08657724f, 0.03848416f, -0.04620479f, 0.03471044f, -0.05235117f, -0.13903022f, -0.30777490f, 
    0.01459259f, 0.08302254f, 0.02164894f, -0.16306485f, -0.09453867f, -0.00739603f, 0.02525197f, 0.07513800f, 
    0.14773647f, -0.06236428f, 0.15782599f, -0.14451991f, -0.02553885f, 0.13436547f, 0.06849634f, 0.00098740f, 
    0.07771796f, 0.03700156f, -0.05667921f, -0.02792447f, 0.35116747f, 0.13588160f, 0.12153697f, -0.11195857f, 
    0.16006000f, 0.07903380f, -0.02893637f, 0.11169507f, 0.08960276f, -0.04775677f, -0.02499842f, 0.08061962f, 
    0.20816100f, -0.16393059f, -0.08997209f, -0.25371397f, 0.03465287f, 0.03829569f, 0.00557974f, 0.01156596f, 
    -0.04215259f, -0.01425015f, -0.12142467f, 0.08335835f, -0.13727720f, -0.30550310f, 0.04830441f, -0.09088230f, 
    -0.10510989f, 0.02172243f, 0.06123194f, -0.06801588f, 0.03174078f, -0.01344863f, -0.06818162f, 0.03657275f, 
    -0.00379659f, 0.03354644f, -0.05078187f, 0.25773910f, -0.01113977f, 0.12605765f, -0.04475578f, -0.05342153f, 
    -0.03863722f, -0.05578660f, 0.02402747f, -0.05089803f, -0.30572897f, 0.10817317f, 0.09076236f, 0.02484250f, 
    0.02301674f, -0.00206254f, 0.03011049f, 0.00747575f, 0.04158238f, 0.01836019f, 0.04958453f, 0.06041371f, 
    -0.02241499f, 0.00115819f, -0.22238566f, 0.26947677f, -0.07408393f, 0.02594723f, -0.01351836f, -0.21695031f, 
    0.02365682f, 0.04551966f, -0.00604584f, -0.03698300f, -0.01941529f, -0.04201025f, 0.18815774f, 0.22693846f, 
    -0.00558000f, 0.06803664f, 0.00844360f, -0.10920232f, -0.03498275f, -0.00129859f, -0.06443468f, 0.02618803f, 
    0.08933133f, 0.03502933f, 0.01885629f, 0.02908052f, -0.04722870f, -0.09365758f, -0.16750221f, 0.08006506f, 
    -0.01109733f, -0.00265382f, 0.00765310f, -0.04399538f, -0.39167741f, -0.10805324f, -0.36621293f, 0.08515715f, 
    -0.14073752f, 0.04646847f, -0.05135759f, 0.11957511f, 0.05730825f, 0.09539620f, -0.04517907f, 0.00084344f, 
    -0.36231631f, 0.08798354f, 0.12104820f, -0.13069288f, 0.02613986f, -0.04017049f, 0.07538331f, -0.00859976f, 
    -0.00052985f, 0.08480210f, 0.02546604f, 0.00141149f, -0.27753794f, -0.17748345f, -0.00276274f, 0.14645492f, 
    0.05525659f, 0.02456925f, -0.00855808f, 0.02553428f, 0.11056825f, -0.03428532f, 0.10755200f, -0.02216828f, 
    0.06275525f, -0.07044297f, -0.07432404f, 0.02478436f, -0.05529785f, -0.07689167f, 0.03188220f, 0.04946833f, 
    0.00237197f, 0.00260848f, -0.01171249f, -0.06199717f, 0.35786948f, -0.07844870f, 0.03789423f, 0.02716731f, 
    -0.07927728f, -0.03306888f, -0.00311388f, -0.06576167f, -0.02593304f, -0.07148489f, 0.08052132f, 0.01033368f, 
    -0.40240255f, 0.09694500f, 0.02813740f, -0.04122591f, -0.08444229f, 0.16163182f, -0.13935487f, -0.02599264f, 
    0.03761714f, 0.11728061f, 0.07360094f, 0.03202957f, -0.11528122f, 0.08361251f, 0.08431630f, -0.21073617f, 
    -0.00673514f, -0.07679042f, 0.01957832f, 0.00236617f, -0.16274321f, -0.01493787f, -0.08957122f, -0.06324324f, 
    -0.22199272f, -0.05221451f, 0.03515842f, -0.13742346f, -0.00852734f, -0.02608575f, -0.13244592f, -0.02541439f, 
    -0.00455994f, -0.03354826f, 0.06869374f, -0.03956147f, 0.22592723f, -0.09394401f, 0.01387218f, 0.27472684f, 
    -0.07337391f, -0.16003743f, -0.02269565f, -0.02348913f, -0.12416348f, 0.07360965f, -0.04967944f, -0.00774665f, 
    -0.06172921f, -0.03725126f, -0.12141334f, -0.05719563f, -0.13850757f, 0.02484110f, -0.03253484f, -0.03642389f, 
    0.09574817f, 0.00176535f, -0.06267076f, 0.01984615f, 0.21316719f, -0.14931524f, 0.01102868f, -0.11094688f, 
    -0.07298763f, 0.02055819f, 0.01455671f, 0.06900629f, 0.03585836f, -0.00026740f, -0.04895684f, -0.02628437f, 
    0.28974098f, 0.05784452f, 0.09373306f, -0.06174833f, 0.03509074f, -0.02857876f, -0.01608292f, 0.01915813f, 
    -0.05886018f, -0.06100917f, -0.04780978f, -0.00726853f, 0.11802392f, -0.02418587f, -0.05775404f, 0.02849379f, 
    -0.04189186f, -0.05922515f, -0.01407348f, 0.01490832f, -0.00836510f, 0.00518494f, -0.05323071f, 0.02382264f, 
    0.38973472f, -0.20803450f, 0.15619193f, 0.04703311f, 0.01878505f, 0.01025079f, -0.12635325f, 0.04053527f, 
    -0.10790972f, 0.02483108f, 0.01236609f, -0.09374963f, 0.20259514f, 0.17505120f, -0.03318716f, 0.09919337f, 
    0.12843199f, 0.06699805f, -0.09514899f, -0.06659973f, -0.11813932f, 0.01375138f, 0.04732149f, 0.00390420f, 
    -0.05059766f, 0.05952605f, -0.09979504f, 0.05304157f, 0.00905300f, 0.17197852f, 0.05216929f, 0.01399761f, 
    0.04279423f, -0.19036788f, -0.01589176f, -0.04206890f, -0.16014634f, -0.02274710f, -0.15345304f, -0.22924058f, 
    0.12456062f, 0.04125325f, -0.01413187f, 0.05657491f, 0.00440838f, -0.08321113f, -0.06521046f, 0.01394576f, 
    0.16301583f, 0.15397435f, 0.09354858f, 0.13485445f, -0.07325289f, -0.00817131f, 0.04839195f, 0.01952169f, 
    -0.04751817f, 0.09516715f, 0.05196010f, 0.09370533f, -0.37987745f, 0.00056698f, -0.10674953f, -0.00642090f, 
    -0.00218840f, -0.21056870f, 0.01888838f, -0.17634435f, 0.14512192f, 0.19791141f, -0.15694480f, -0.11526264f, 
    -0.15138322f, -0.12738931f, -0.13455428f, 0.02108242f, 0.09416930f, -0.04344032f, 0.02280627f, 0.08615386f, 
    -0.04727897f, -0.00950862f, 0.11981531f, 0.01298450f, 0.35024914f, -0.02121798f, 0.04077290f, 0.04955850f, 
    -0.01529225f, 0.00108901f, 0.02683763f, 0.04861228f, -0.01570701f, -0.05254696f, -0.00771021f, -0.03978034f, 
    0.06070909f, -0.03131485f, 0.14191216f, 0.20835944f, -0.00917402f, -0.00253312f, -0.02057631f, 0.05408928f, 
    0.05083488f, -0.04789071f, -0.01772706f, -0.00512066f, 0.02414844f, 0.04474796f, -0.05184608f, -0.03943640f, 
    -0.07546824f, -0.00459951f, -0.02514282f, 0.06703966f, 0.13200736f, 0.05806027f, 0.08591217f, 0.04089956f, 
    0.08586942f, 0.05031854f, 0.07950306f, 0.11435524f, 0.03837950f, -0.04307029f, -0.06710124f, 0.03071848f, 
    0.08644357f, -0.09655462f, 0.02037903f, -0.12014843f, 0.32890660f, -0.01973134f, -0.08413267f, -0.23963547f, 
    0.08551949f, 0.00057611f, -0.08209900f, 0.00293720f, 0.08971500f, -0.03672803f, -0.01037718f, -0.09832273f, 
    -0.29961830f, 0.05015817f, -0.10936455f, 0.19747408f, -0.05806808f, 0.00510959f, -0.01692011f, 0.00661521f, 
    -0.01213709f, 0.02414236f, -0.03188230f, -0.00898973f, 0.21054229f, 0.03551373f, 0.09197091f, 0.10993899f, 
    0.03344391f, 0.12521966f, -0.00894187f, -0.05085471f, -0.07421336f, -0.00517345f, -0.20434442f, 0.10081395f, 
    -0.24627785f, 0.15679781f, -0.01094199f, 0.10800637f, -0.04491893f, 0.07119615f, -0.05200417f, -0.01485251f, 
    -0.00115545f, 0.04480772f, 0.00657594f, -0.06025464f, 0.11979874f, 0.07988052f, 0.08509535f, 0.12454415f, 
    -0.11852097f, 0.05143442f, 0.09010450f, 0.02165715f, 0.05851096f, -0.11736760f, 0.01630131f, 0.15710801f, 
    0.07102297f, -0.02965070f, 0.02017105f, 0.12530495f, -0.02790656f, -0.18087023f, -0.03197123f, 0.03923042f, 
    -0.00808297f, 0.01228342f, -0.11896382f, 0.03255358f, 0.11758234f, 0.19293246f, -0.03490830f, -0.04207819f, 
    -0.04932166f, -0.06533315f, -0.00202576f, 0.01471046f, 0.07607518f, -0.10428606f, 0.04722400f, 0.00250309f, 
    -0.14163041f, -0.18282710f, -0.03942616f, -0.17925903f, -0.02190975f, 0.07146697f, -0.03068887f, -0.00381221f, 
    -0.02276595f, 0.12603186f, 0.11651289f, 0.03516499f, 0.19464427f, -0.20761262f, -0.16279702f, 0.05391951f, 
    -0.04703420f, -0.07781558f, -0.08219435f, -0.05058739f, 0.06506928f, 0.12072866f, -0.03649013f, 0.11681192f, 
    -0.03375151f, -0.19030264f, 0.01741838f, -0.18344517f, 0.13277517f, 0.09898339f, 0.15588236f, 0.03194627f, 
    0.00687510f, -0.03790081f, -0.01171223f, 0.00973614f, 0.08985368f, 0.04039500f, -0.03571247f, 0.05640325f, 
    0.09624630f, -0.00167482f, -0.16480413f, -0.02543752f, 0.12748486f, 0.17377508f, 0.07903702f, 0.08409066f, 
    -0.11297307f, 0.14038549f, -0.00012091f, 0.02355372f, -0.01043963f, 0.00780408f, -0.03651712f, -0.12175834f, 
    -0.07963335f, -0.09821793f, 0.02445854f, -0.02600153f, 0.16871642f, 0.03166881f, -0.01599462f, 0.00769823f, 
    -0.09529972f, -0.01182455f, -0.01344332f, 0.02225006f, -0.05422011f, -0.02629869f, 0.15034689f, -0.05561358f, 
    0.25295392f, -0.02226403f, -0.05897665f, 0.01225270f, 0.06338703f, 0.04254665f, 0.04177368f, -0.00301185f, 
    0.05357702f, -0.11799123f, 0.14997582f, 0.00525811f, 0.10981789f, 0.01047970f, 0.17704156f, 0.07234310f, 
    -0.11173007f, 0.04949204f, 0.06229755f, -0.01845478f, 0.00409164f, 0.04552585f, 0.14525196f, -0.06767620f, 
    -0.24666837f, -0.06268337f, -0.03336519f, -0.02325028f, 0.02400280f, -0.00958254f, 0.04447789f, -0.00340889f, 
    0.09879195f, -0.11193170f, 0.12069159f, 0.05027270f, -0.07078129f, -0.08486652f, -0.09858391f, -0.14797807f, 
    -0.02860827f, -0.01539003f, -0.04203200f, 0.01550935f, -0.02018263f, 0.08138600f, -0.01753872f, -0.00669806f, 
    -0.28714567f, 0.07119451f, -0.14464346f, 0.04483177f, 0.15421529f, -0.04537953f, -0.14153436f, -0.01725071f, 
    -0.08876542f, -0.07797643f, 0.20114322f, -0.07258338f, 0.14187051f, -0.25864524f, 0.04207149f, -0.29259104f, 
    -0.03980053f, 0.05638321f, 0.05971309f, 0.09933785f, 0.06698450f, 0.03492798f, 0.13966238f, 0.06091692f, 
    -0.11583842f, -0.20114262f, 0.06071313f, 0.12914506f, 0.04824641f, 0.02663066f, -0.02664203f, 0.06121641f, 
    0.03133082f, 0.00197623f, -0.10258172f, -0.07246399f, 0.13160960f, 0.06088381f, 0.04873950f, 0.06593145f, 
    -0.07711537f, 0.01139627f, 0.02137291f, 0.01666304f, 0.02895081f, -0.05871790f, -0.00030976f, 0.10533228f, 
    0.19006510f, 0.01639692f, 0.10598201f, 0.16534100f, -0.02038428f, 0.04213502f, 0.07258198f, 0.04752341f, 
    -0.07318293f, -0.04359759f, -0.08499581f, 0.01122129f, 0.28038147f, -0.35536170f, -0.18561791f, 0.09752683f, 
    -0.12395979f, 0.08513108f, -0.01821732f, 0.11922932f, 0.00952954f, -0.05187758f, 0.02051632f, 0.08294173f, 
    -0.01296325f, -0.04371829f, -0.13031325f, -0.31353426f, 0.00391465f, 0.02172986f, -0.02968197f, 0.00510232f, 
    0.01051802f, -0.03286803f, -0.10594221f, -0.04158455f, -0.24522360f, 0.05797555f, -0.31264907f, 0.18081920f, 
    -0.09761214f, 0.04699595f, -0.02874811f, 0.20838790f, -0.02592196f, -0.10872708f, 0.04246315f, -0.07038540f, 
    0.14709421f, -0.02711185f, -0.02709689f, 0.19827832f, -0.04474357f, -0.06498484f, 0.08700801f, 0.02788919f, 
    0.04304217f, -0.04282247f, -0.06860991f, -0.01081414f, -0.30256689f, 0.12393923f, -0.29170653f, -0.42720702f, 
    0.03589773f, 0.16778530f, 0.03018386f, 0.01135313f, 0.11712704f, 0.04806704f, 0.00495350f, -0.03848719f, 
    0.11634377f, -0.04641247f, -0.03109719f, -0.23053518f, -0.00344088f, -0.11238241f, -0.03142799f, 0.10544994f, 
    0.10238968f, 0.01063071f, 0.01944140f, 0.06359781f, 0.27204183f, -0.24038559f, 0.09593652f, -0.02658842f, 
    -0.12250268f, 0.11037762f, -0.03509197f, -0.02025939f, -0.07506535f, -0.00890838f, 0.02741568f, 0.07932198f, 
    -0.12830691f, 0.08251526f, -0.31762663f, 0.08654753f, 0.01285132f, -0.09104073f, -0.00052421f, -0.03708329f, 
    -0.03446163f, 0.08983015f, -0.06036330f, 0.01409390f, 0.17987934f, -0.21494298f, 0.06099870f, -0.31741509f, 
    0.08177740f, -0.09041180f, -0.05294471f, 0.09486213f, -0.02781136f, -0.01484056f, -0.04239583f, 0.04837172f, 
    0.09909113f, -0.11523569f, 0.01988056f, -0.08867184f, 0.08226153f, -0.20148325f, -0.08949861f, 0.01399827f, 
    0.03548894f, -0.11904509f, 0.05450249f, -0.04656945f, -0.02021327f, -0.01750079f, -0.21762694f, -0.05714095f, 
    0.01895511f, -0.13123658f, -0.02353454f, -0.08128143f, 0.07278372f, 0.10062623f, -0.08768785f, 0.05179333f, 
    -0.26307148f, 0.00445377f, 0.11562784f, -0.19193874f, -0.03152560f, -0.07154471f, 0.10335129f, 0.06015253f, 
    -0.03839353f, 0.04804651f, 0.09925644f, -0.13343601f, 0.14670287f, 0.06806069f, -0.07353680f, -0.02617139f, 
    -0.05322725f, 0.09359480f, -0.00000139f, 0.11260444f, 0.01685239f, 0.04909202f, 0.07323994f, 0.03792136f, 
    -0.23975614f, 0.20796043f, 0.00318671f, 0.13488787f, -0.03958582f, -0.02351758f, -0.07755708f, 0.05743922f, 
    0.01575342f, 0.10071473f, -0.02466405f, 0.03035991f, -0.09664310f, 0.01173035f, -0.14394912f, -0.14087728f, 
    -0.02803924f, -0.06620081f, -0.06878037f, -0.00464541f, -0.09873708f, 0.08537345f, 0.05957925f, 0.02877421f, 
    -0.49150330f, -0.00837233f, -0.25072339f, -0.03642185f, -0.07274767f, 0.04176209f, -0.01726241f, 0.06112294f, 
    -0.00588555f, -0.08598121f, 0.02793741f, -0.03810713f, 0.09309360f, 0.06689546f, -0.07318022f, 0.09303544f, 
    0.02270901f, -0.00149270f, -0.02249399f, 0.08621753f, -0.09043151f, 0.08312769f, 0.08413535f, 0.07171401f, 
    0.34122396f, -0.01086639f, -0.23519903f, -0.03110022f, 0.05552983f, -0.21542852f, 0.06601606f, -0.07514073f, 
    -0.11019763f, -0.05313993f, -0.04336749f, -0.03973597f, 0.01701535f, 0.09262211f, 0.13702586f, 0.01116111f, 
    0.05082180f, -0.06537151f, -0.18611448f, 0.04256010f, -0.17006512f, 0.01409755f, 0.00339355f, 0.08509268f, 
    0.19324481f, -0.00621543f, -0.30145839f, -0.00503332f, 0.00009036f, -0.02400390f, -0.08949886f, 0.03316106f, 
    0.04587457f, -0.17682743f, 0.04911160f, -0.16461456f, -0.30616745f, -0.00004504f, -0.21806806f, -0.05504474f, 
    -0.03233018f, -0.09106538f, -0.12790182f, -0.19591615f, 0.00850383f, -0.07124364f, 0.11976342f, 0.03655371f, 
    0.08949332f, 0.07037723f, 0.00034451f, 0.09285644f, -0.07340214f, 0.05455479f, -0.01596005f, -0.04759979f, 
    0.09046187f, -0.04268491f, 0.02558754f, 0.05116354f, -0.78436083f, 0.02575034f, 0.06434847f, -0.05289472f, 
    -0.05670786f, -0.04485200f, 0.09668587f, 0.05668092f, -0.07875454f, 0.05300704f, -0.05988654f, -0.11025413f, 
    0.03283470f, -0.17276585f, -0.05758980f, 0.04374443f, -0.08908331f, -0.05054721f, -0.10488944f, -0.05066784f, 
    0.06835147f, -0.21162739f, -0.18799388f, -0.07092712f, 0.19000663f, -0.02681128f, -0.02095534f, -0.17174001f, 
    -0.08592083f, -0.04550215f, 0.05971897f, -0.08585056f, 0.03201318f, -0.08104856f, 0.03404471f, -0.01049840f, 
    -0.17701967f, 0.09517956f, -0.11929485f, -0.11330838f, 0.06251035f, -0.00004715f, -0.07780359f, -0.01075665f, 
    0.07263741f, 0.02649714f, -0.09105905f, 0.02419869f, 0.05063786f, -0.13219567f, -0.04621509f, 0.01101803f, 
    -0.06135582f, 0.07451595f, 0.03279359f, 0.12257633f, 0.08483151f, 0.03148619f, -0.14474310f, -0.02941622f, 
    0.07537711f, 0.16413121f, 0.10863030f, 0.15395398f, -0.01125899f, -0.07631093f, -0.00702962f, -0.01884146f, 
    -0.12310856f, -0.15906698f, 0.05895239f, 0.00088893f, 0.09519170f, 0.03027037f, 0.12384298f, 0.14071941f, 
    0.00914025f, -0.05861182f, 0.01546629f, -0.02562001f, -0.03015857f, -0.07081336f, 0.00504458f, -0.02927188f, 
    0.15675730f, -0.01909921f, 0.01100841f, -0.09061275f, -0.04495749f, -0.00804821f, 0.11777970f, 0.00305934f, 
    -0.05587273f, -0.02840849f, -0.03232198f, -0.10637082f, 0.23749846f, -0.09508771f, -0.12296459f, -0.15277325f, 
    -0.16990179f, -0.02971608f, -0.06204926f, -0.09603723f, 0.13275211f, -0.12987910f, 0.10161185f, -0.14981572f, 
    -0.02859186f, -0.13757661f, 0.10024893f, 0.04592855f, 0.05930867f, 0.03674548f, 0.03541435f, -0.00948431f, 
    -0.00789032f, -0.14563967f, -0.03408431f, 0.00347818f, 0.12236249f, 0.01295541f, 0.03944968f, 0.00492348f, 
    -0.13956268f, -0.10298811f, -0.06706856f, 0.15235332f, -0.00736643f, -0.06783329f, -0.03082111f, -0.05130196f, 
    -0.14132948f, -0.08215873f, 0.10661136f, -0.01853330f, -0.05186893f, 0.01396419f, -0.03155185f, -0.12309828f, 
    -0.03033230f, -0.03042716f, -0.03892433f, -0.06480702f, -0.36554158f, -0.13017720f, -0.19228387f, -0.23491664f, 
    -0.05906470f, -0.04868763f, -0.06327271f, -0.04828814f, -0.00834570f, 0.04050117f, 0.07314515f, -0.02696395f, 
    -0.00444372f, 0.05322367f, -0.03007300f, -0.03517650f, 0.06970644f, -0.00723371f, -0.00922786f, 0.01655569f, 
    -0.02668586f, 0.00646945f, 0.05330848f, -0.03327353f, 0.34892941f, 0.14767767f, 0.00158675f, 0.13975161f, 
    -0.01258814f, 0.08423770f, 0.02670108f, 0.13456376f, -0.12310372f, -0.02948227f, 0.07552584f, -0.03759240f, 
    0.30287093f, -0.09531786f, 0.14289275f, -0.02117978f, -0.02105302f, -0.05824472f, -0.02740172f, 0.04730281f, 
    0.01103404f, 0.08562633f, -0.04182052f, 0.00485409f, 0.25922820f, 0.04703289f, 0.04018830f, 0.23790827f, 
    -0.14802918f, -0.10940576f, -0.01178529f, 0.02313474f, 0.04848221f, 0.00237710f, -0.06165955f, -0.03973309f, 
    0.02036912f, 0.14985482f, -0.13233097f, 0.04386465f, -0.01307796f, -0.01949511f, 0.03273651f, 0.00576159f, 
    -0.03557677f, 0.03285059f, 0.02332652f, -0.01991737f, -0.07803421f, 0.03676412f, -0.07553834f, -0.08564636f, 
    0.06343473f, 0.12113448f, 0.06295151f, -0.04154240f, -0.03333598f, -0.02840030f, -0.07688462f, -0.03095089f, 
    0.00055675f, 0.00492999f, 0.04819867f, 0.02070270f, -0.07854383f, 0.09631480f, 0.01712625f, -0.05151378f, 
    -0.03432029f, 0.09443991f, -0.08388706f, -0.00532204f, 0.13712120f, -0.07216717f, -0.06582854f, 0.02060157f, 
    -0.00472439f, 0.02508276f, -0.06157902f, 0.00868501f, 0.00297796f, 0.01415439f, 0.00127052f, 0.14972776f, 
    -0.03085340f, -0.02423154f, 0.09149061f, -0.10986413f, -0.09802007f, -0.04204483f, 0.00296022f, -0.02388508f, 
    0.00273246f, -0.08961780f, -0.01041625f, 0.03951323f, 0.01869915f, 0.12660672f, -0.13150772f, 0.03449813f, 
    0.00355207f, -0.05850828f, 0.02801682f, -0.00411646f, -0.05779717f, -0.01894607f, 0.14103290f, -0.01302291f, 
    -0.11161835f, -0.00780555f, 0.04502019f, 0.03885448f, -0.07615849f, 0.05731168f, -0.03906288f, 0.02593006f, 
    0.01161924f, -0.08232993f, -0.00720300f, -0.09368807f, 0.01237543f, -0.05976696f, -0.03781554f, -0.06598574f, 
    -0.03871318f, 0.08942807f, 0.00805950f, -0.05354938f, -0.04564565f, 0.05116387f, -0.01830588f, -0.08712935f, 
    -0.17721479f, -0.05518536f, -0.09237459f, -0.17549968f, 0.07887980f, -0.00303698f, 0.02269824f, -0.17557743f, 
    0.06937382f, -0.05980137f, -0.01360241f, -0.02603616f, -0.03826403f, 0.00411869f, 0.05405476f, -0.09013539f, 
    0.07143215f, 0.02337681f, 0.04777212f, -0.03071386f, -0.04637338f, 0.01139115f, 0.00529312f, 0.00478425f, 
    -0.24304299f, 0.01509843f, 0.02075599f, -0.09021916f, -0.01817700f, 0.01231843f, -0.01513618f, -0.00849807f, 
    0.04897961f, 0.04600755f, -0.13051224f, -0.04408428f, 0.08679092f, 0.15313073f, -0.09609991f, -0.04990027f, 
    0.01179921f, 0.06653549f, -0.01700287f, 0.03367398f, -0.02287548f, -0.07304954f, -0.04739156f, -0.06724163f, 
    0.11041592f, 0.06664729f, 0.03432925f, 0.18154234f, -0.14309259f, -0.05092568f, 0.05107842f, 0.07708990f, 
    0.02446038f, -0.04701863f, 0.00840535f, 0.10757971f, -0.04406214f, -0.10823930f, 0.02551476f, -0.00555870f, 
    0.02079173f, 0.05537244f, 0.10121332f, -0.02056667f, 0.09966279f, -0.06623523f, 0.03504785f, 0.00752930f, 
    0.18808664f, 0.01057740f, -0.06226693f, -0.08055447f, -0.00712947f, 0.09186950f, -0.00741665f, 0.06893151f, 
    -0.02686390f, 0.06560072f, 0.00359643f, -0.09467083f, -0.06682946f, 0.00381171f, 0.03921761f, 0.03065645f, 
    0.01837101f, 0.08042987f, 0.06420175f, -0.11214693f, 0.03758916f, 0.01446251f, -0.07968558f, -0.05764763f, 
    0.32595602f, -0.28420407f, 0.02352448f, -0.03687303f, -0.09833169f, 0.01002593f, -0.07153305f, -0.03555347f, 
    -0.08163705f, 0.02607029f, -0.02574962f, -0.07514484f, 0.07327641f, -0.06929889f, -0.01211068f, 0.14002518f, 
    0.07486065f, -0.06999756f, -0.04433583f, -0.11600933f, 0.04932282f, -0.00325715f, -0.05818299f, 0.08786313f, 
    -0.17421994f, 0.05899193f, -0.00601686f, -0.05348429f, 0.01470650f, 0.04561416f, 0.04239841f, -0.00952605f, 
    -0.06678890f, 0.10331144f, -0.10628395f, -0.10728697f, -0.11302178f, -0.07816464f, -0.19111179f, -0.06342050f, 
    0.04267753f, 0.00316919f, 0.14253475f, -0.04048678f, -0.08014861f, 0.00468424f, -0.05529757f, 0.01849089f, 
    0.34444630f, -0.12122159f, -0.20362565f, 0.09507947f, -0.01603344f, 0.06487180f, 0.07222436f, -0.01846983f, 
    -0.03867831f, 0.07095569f, -0.07528622f, -0.09848247f, -0.31789246f, -0.06774848f, -0.12977590f, -0.12304486f, 
    0.06882598f, 0.01991872f, 0.03574669f, -0.05246101f, -0.08321468f, -0.00286644f, 0.05017760f, -0.06562035f, 
    0.24539617f, 0.09280583f, -0.01164513f, -0.11503655f, 0.07225155f, -0.07299224f, 0.01428514f, -0.01297457f, 
    -0.02102667f, 0.10236697f, 0.02600871f, -0.06444172f, 0.08674507f, -0.07291114f, 0.04099403f, -0.10559187f, 
    0.09402250f, 0.09765451f, -0.04989243f, 0.03327926f, -0.07468121f, 0.17520782f, 0.01121819f, 0.03836334f, 
    0.04888701f, -0.04572945f, 0.00580746f, -0.16436148f, 0.03991690f, 0.04788955f, -0.03616555f, -0.03573515f, 
    -0.03662251f, 0.07714624f, 0.06346563f, -0.05029092f, 0.21228179f, -0.01462022f, -0.00704538f, 0.01619430f, 
    -0.19189796f, -0.13618408f, 0.02855204f, 0.03478009f, 0.02279190f, -0.03273249f, 0.06325016f, -0.01412166f, 
    -0.00401284f, -0.00910429f, 0.03758043f, -0.01085765f, -0.07657231f, 0.08697885f, -0.12449594f, -0.13692887f, 
    0.09341199f, 0.06342045f, 0.00063930f, 0.05982748f, 0.36801797f, -0.05273973f, -0.01404206f, -0.04146199f, 
    -0.04959920f, -0.01715547f, -0.03216977f, -0.03852751f, -0.04898273f, -0.03199613f, -0.02691747f, -0.03936917f, 
    -0.22310537f, 0.05748638f, -0.01403389f, -0.02375770f, 0.04323799f, 0.01294903f, 0.04337400f, -0.09470635f, 
    0.03733431f, 0.00550501f, -0.01807195f, -0.02668513f, 0.29875684f, 0.01167059f, -0.48272610f, -0.15037462f, 
    0.11439318f, 0.02127625f, -0.01414725f, 0.05806378f, -0.02069635f, -0.02492081f, -0.00235161f, -0.08415321f, 
    0.07460223f, -0.04201552f, 0.02133881f, 0.28204104f, -0.14769238f, -0.04758842f, 0.08684861f, -0.01902400f, 
    -0.07439440f, -0.03115287f, -0.06192968f, 0.06217198f, 0.08233770f, -0.07827205f, -0.00640896f, -0.14295079f, 
    0.09211022f, -0.08617460f, 0.01873578f, -0.00641870f, 0.02258582f, 0.09106617f, 0.05314451f, 0.00541407f, 
    -0.28540263f, 0.00178796f, -0.43692070f, -0.10643622f, -0.16826627f, 0.06221770f, -0.07750359f, 0.01409389f, 
    -0.01930103f, -0.03502335f, 0.01957793f, -0.05608953f, -0.21441227f, 0.15693457f, -0.03319734f, 0.21175967f, 
    -0.07222281f, -0.06671412f, 0.11493726f, 0.01890096f, -0.06836320f, -0.10489126f, 0.00908303f, 0.01572386f, 
    0.13083979f, -0.04013418f, 0.05993859f, 0.05434915f, 0.08992585f, 0.06756134f, 0.03508509f, -0.01836149f, 
    0.01146277f, -0.03099510f, 0.02302852f, -0.05179038f, 0.30683246f, 0.08104520f, 0.18923807f, 0.24428543f, 
    -0.07183170f, -0.14743961f, -0.09380312f, 0.12551990f, 0.04965632f, -0.05790190f, 0.03612905f, 0.00295318f, 
    -0.16252482f, 0.09368031f, 0.02935959f, 0.07892944f, 0.10767676f, -0.10302586f, -0.09275948f, -0.06818395f, 
    -0.06171957f, 0.09047633f, -0.00986954f, 0.02112835f, -0.36305645f, -0.17777668f, 0.05627700f, -0.22549643f, 
    0.00065739f, -0.08946142f, -0.04015851f, 0.02706031f, -0.03677240f, -0.00747836f, 0.01258011f, -0.10681245f, 
    -0.02591165f, -0.07940990f, -0.10821987f, 0.00327704f, -0.11368159f, 0.02273079f, -0.12841192f, 0.03779982f, 
    0.07382263f, 0.04654934f, -0.07993790f, -0.01317285f, -0.18323870f, 0.09415926f, 0.12572540f, -0.10035104f, 
    -0.06130320f, 0.01862496f, 0.05689511f, -0.02340183f, -0.04812115f, -0.04217213f, 0.00007669f, -0.01193028f, 
    -0.02598865f, -0.14284003f, -0.10405569f, -0.04488210f, -0.12125055f, 0.13545354f, -0.03745119f, -0.03945869f, 
    0.06387394f, 0.03881446f, -0.02716948f, -0.04364541f, 0.06418545f, -0.16908270f, 0.05946539f, 0.00155080f, 
    0.05663606f, -0.00543194f, 0.01397911f, -0.11106391f, 0.05748939f, 0.05852251f, -0.01822529f, 0.06163604f, 
    -0.10006364f, 0.29834977f, -0.00922091f, -0.23286997f, -0.09102199f, 0.01377884f, 0.07548386f, 0.06621379f, 
    -0.01615858f, -0.08580796f, -0.09473058f, -0.02492856f, 0.05414922f, -0.12564048f, -0.18522950f, -0.10750822f, 
    0.03653910f, -0.00723872f, -0.05811637f, -0.00716947f, -0.01929370f, -0.07389353f, -0.04237099f, -0.09318255f, 
    -0.17287047f, -0.09746978f, 0.06739923f, -0.24402381f, 0.03286945f, -0.02609657f, -0.00600536f, -0.05506574f, 
    -0.09738032f, 0.05864811f, -0.03946845f, -0.00895263f, 0.25868252f, 0.01681888f, -0.18366316f, 0.00954908f, 
    -0.06087301f, 0.01049809f, -0.07288349f, -0.05957307f, -0.06188708f, -0.14940085f, 0.04395084f, -0.03206814f, 
    0.04489267f, 0.03801234f, -0.15668583f, 0.15442333f, 0.10526186f, 0.09510619f, -0.00921560f, -0.12594497f, 
    0.01393798f, 0.05376680f, -0.03152317f, -0.10140502f, 0.34593132f, 0.17601211f, -0.10171282f, -0.04273611f, 
    -0.00223952f, 0.03021410f, -0.01056528f, 0.00458548f, -0.09098499f, 0.10391040f, 0.03590179f, 0.01719134f, 
    0.38234538f, -0.08396070f, -0.03867496f, 0.18066785f, -0.12574618f, -0.06260097f, -0.12907448f, -0.05792310f, 
    0.01507014f, 0.04646497f, 0.09424626f, 0.07777427f, -0.25888181f, -0.05831944f, 0.02256298f, -0.25716507f, 
    0.05883136f, -0.02402866f, 0.03843147f, 0.03725636f, -0.01573131f, -0.02037544f, -0.03030712f, -0.04340952f, 
    0.13802941f, -0.01945126f, -0.26961315f, -0.08385101f, -0.03043196f, 0.05822188f, 0.03876782f, -0.06539701f, 
    -0.01738635f, -0.04311106f, 0.00138870f, -0.09584754f, 0.04564640f, 0.10366672f, 0.03064744f, -0.13574260f, 
    0.02641643f, 0.04998969f, 0.10156660f, -0.03075965f, -0.05572366f, -0.00362755f, 0.08403593f, 0.04202670f, 
    -0.02280231f, 0.08451480f, -0.08641153f, 0.12556919f, 0.02432347f, 0.04663561f, 0.00409602f, -0.06745724f, 
    -0.10724632f, 0.09026480f, -0.10094334f, -0.04364587f, 0.09270872f, 0.13462989f, 0.02319791f, -0.13037437f, 
    0.07661836f, 0.03171925f, 0.00098070f, 0.02301998f, -0.01107004f, 0.07282232f, 0.12000405f, -0.00099686f, 
    -0.01150558f, -0.19166502f, -0.22292385f, 0.07923683f, -0.04681152f, 0.06102124f, -0.10520062f, -0.04262969f, 
    -0.00546574f, 0.09153640f, -0.00357463f, 0.10846435f, 0.12887473f, 0.16519625f, 0.08317726f, 0.09650545f, 
    -0.03962782f, -0.11540370f, 0.02866999f, -0.02928504f, -0.06435806f, -0.04162775f, 0.01328044f, -0.00993413f, 
    -0.03452583f, -0.17323403f, -0.12155870f, 0.03397101f, -0.07719909f, 0.01083071f, -0.03123486f, -0.06741190f, 
    0.00266964f, -0.04204635f, 0.08497065f, 0.04305888f, -0.07932497f, -0.03978964f, -0.01281088f, -0.00941753f, 
    -0.01556857f, -0.12680858f, 0.07136917f, -0.06510418f, 0.03708681f, -0.06608694f, -0.06540158f, -0.00259321f, 
    0.21473487f, -0.03273693f, 0.00525744f, 0.11171207f, 0.00215683f, -0.00624116f, -0.05075974f, -0.13415091f, 
    0.16027491f, 0.05019729f, 0.06417388f, 0.03758286f, 0.15042719f, 0.13273393f, 0.08575306f, 0.03184188f, 
    0.05034123f, -0.03762675f, -0.01309786f, 0.02017169f, 0.10745800f, 0.08394220f, 0.06687042f, -0.05135083f, 
    -0.43556812f, -0.27225286f, -0.09592004f, -0.09576920f, -0.14521380f, -0.05034203f, 0.04099949f, -0.02495414f, 
    -0.08192427f, -0.09195251f, -0.01406415f, -0.07937820f, -0.35688496f, -0.00935992f, 0.01776613f, -0.17487159f, 
    -0.04448710f, 0.01308744f, -0.02048896f, 0.10468184f, 0.03238383f, -0.15336533f, 0.07865731f, 0.01113689f, 
    0.02278858f, -0.03484603f, -0.04156355f, -0.06891488f, 0.03604545f, -0.05044519f, 0.04764488f, 0.00800020f, 
    0.02939833f, -0.07161225f, 0.01850986f, -0.05861390f, 0.16616546f, -0.00952729f, 0.02035809f, -0.07181520f, 
    -0.06104784f, -0.09672999f, -0.01996919f, -0.01937109f, -0.11918391f, -0.01627215f, -0.06215686f, 0.07438117f, 
    0.19687372f, -0.20622742f, -0.04820447f, 0.14997676f, 0.01309642f, 0.10241012f, 0.05830476f, -0.08571326f, 
    0.00598374f, -0.03033450f, -0.08477265f, -0.11237843f, -0.29970866f, -0.17172544f, -0.21831611f, 0.10265129f, 
    -0.01098758f, 0.00681867f, 0.03420893f, -0.00532905f, -0.04966080f, -0.06727687f, -0.02582896f, -0.04847290f, 
    -0.26665732f, -0.12861796f, -0.02303929f, 0.27061820f, -0.04696624f, 0.06324063f, -0.04560961f, -0.02512494f, 
    0.04693232f, -0.08867116f, -0.04447365f, 0.20020415f, -0.18623556f, 0.01722282f, 0.08956373f, 0.08042955f, 
    -0.02331381f, -0.01283458f, 0.17675240f, 0.05506792f, -0.04427115f, 0.03482335f, -0.14149162f, 0.09282186f, 
    -0.09900729f, 0.00323814f, 0.13768135f, -0.00610015f, -0.00468738f, -0.01449244f, -0.04096144f, 0.06703860f, 
    0.03014004f, -0.09942149f, -0.00870978f, 0.01785621f, -0.02709729f, 0.05671789f, -0.08081225f, -0.07914178f, 
    0.03798725f, 0.03987968f, 0.05764231f, -0.04441737f, -0.05216126f, -0.00155816f, 0.03784614f, 0.00860103f, 
    0.02380374f, -0.19298111f, 0.08409251f, 0.10028160f, 0.05576104f, -0.06613507f, 0.07195781f, -0.03161637f, 
    0.02264473f, 0.03536484f, 0.05305452f, -0.01450781f, -0.35073236f, -0.29818055f, -0.06729169f, -0.02209858f, 
    -0.06098989f, -0.05317316f, 0.02007359f, 0.05962713f, -0.01563826f, -0.00456088f, -0.00691684f, -0.01763518f, 
    -0.06368520f, -0.03736864f, -0.03011326f, -0.04327392f, -0.04116391f, 0.07644253f, 0.13678196f, -0.08553293f, 
    -0.02933167f, -0.09096417f, 0.13588189f, -0.03033145f, -0.42533311f, -0.25670406f, -0.01324382f, 0.12281436f, 
    -0.05123207f, -0.03059420f, -0.06203020f, -0.02657035f, -0.05163304f, -0.04475922f, -0.00029056f, -0.08325870f, 
    0.13269116f, 0.08163520f, 0.13235158f, 0.10644182f, 0.02437738f, 0.18309121f, 0.05532905f, -0.07023371f, 
    -0.00472794f, -0.02738538f, -0.06249503f, 0.09000486f, -0.37313896f, 0.00252625f, -0.12741822f, 0.07857739f, 
    -0.03669798f, 0.04433374f, 0.06984023f, 0.06460626f, -0.04589413f, -0.05193826f, -0.03268427f, -0.10616367f, 
    0.06975865f, -0.04347430f, -0.02182022f, -0.07038819f, -0.01138825f, -0.01897234f, -0.02990497f, -0.07831110f, 
    -0.08294791f, 0.04295335f, -0.00793084f, 0.02967168f, -0.21560445f, -0.01070346f, -0.24825932f, -0.02427106f, 
    -0.05196266f, -0.05369263f, 0.08197102f, -0.10909470f, -0.01833958f, -0.03169319f, -0.00162893f, -0.06565922f, 
    -0.17309511f, 0.02585750f, 0.14532454f, -0.06447621f, 0.01596370f, 0.01957852f, -0.04345408f, 0.06440161f, 
    0.03095710f, -0.01263165f, 0.01468722f, 0.07944538f, 0.40407556f, -0.27800193f, -0.15933241f, 0.21960378f, 
    -0.02123500f, 0.02522148f, 0.03019119f, -0.03683629f, 0.06018011f, -0.01436170f, -0.11646323f, -0.01542979f, 
    -0.00228845f, 0.08981635f, 0.02448087f, 0.03316459f, -0.09472658f, -0.07146758f, -0.04013344f, -0.06065622f, 
    -0.00607972f, -0.03970213f, -0.04656220f, 0.03107536f, -0.04876053f, -0.47536355f, -0.00252058f, 0.24716371f, 
    0.00642713f, -0.04799147f, -0.01484349f, -0.02730059f, 0.01852794f, 0.01593963f, -0.10719395f, -0.08249807f, 
    0.12409551f, 0.00707514f, 0.06399594f, 0.28080007f, -0.01290572f, 0.17296316f, -0.02289785f, -0.01315826f, 
    0.02151003f, -0.06289789f, -0.07613119f, -0.09972381f, 0.37692618f, 0.29704705f, 0.00492928f, 0.04765169f, 
    -0.07112350f, 0.04529015f, 0.10915086f, -0.04181561f, 0.00599261f, -0.02498296f, -0.03613076f, -0.14090110f, 
    -0.13423865f, 0.20917654f, 0.12377492f, 0.10424057f, 0.03554382f, -0.01969656f, 0.03494625f, 0.00120164f, 
    -0.12377640f, -0.03674020f, -0.16205519f, -0.05549775f, 0.10722832f, -0.06216497f, -0.04933487f, -0.10866635f, 
    -0.09874473f, 0.08057556f, -0.00907209f, 0.08889592f, 0.00296468f, 0.00768558f, -0.04261729f, 0.01037420f, 
    0.28338173f, -0.15073642f, 0.24301568f, 0.01374094f, 0.05232425f, 0.10941160f, 0.10146707f, -0.04833790f, 
    0.05027812f, 0.00137686f, -0.00005549f, 0.00103566f, -0.36592758f, -0.11230607f, -0.20087387f, -0.10303257f, 
    -0.06697163f, -0.05215669f, -0.06652444f, -0.13304810f, 0.11648435f, -0.01715541f, -0.03251781f, 0.04800881f, 
    0.11220890f, -0.18027234f, -0.12629083f, 0.06472197f, 0.05451874f, 0.05886202f, -0.05359705f, -0.04637621f, 
    0.06812774f, 0.07085782f, -0.05592094f, 0.04697257f, 0.18906935f, -0.14947814f, -0.00793997f, -0.00250516f, 
    -0.04936947f, -0.12301324f, -0.04746363f, -0.02847656f, -0.05236800f, -0.01805736f, 0.02189620f, -0.05071048f, 
    -0.06196573f, 0.18038328f, 0.01040822f, 0.12125295f, 0.07600056f, -0.11891961f, -0.08015487f, 0.03934333f, 
    -0.04975159f, 0.19243212f, -0.08198332f, -0.00404508f, -0.06678361f, 0.18936577f, 0.09150586f, -0.04436382f, 
    0.03569170f, 0.03111449f, 0.10133757f, 0.05804980f, -0.02796497f, -0.04456895f, 0.07312065f, 0.08223380f, 
    -0.26400101f, -0.41275692f, -0.16491592f, 0.04451731f, -0.11349007f, 0.06540018f, 0.12967223f, -0.05018821f, 
    0.02914377f, -0.05971895f, 0.07866597f, -0.01110238f, -0.13306169f, 0.22049227f, 0.14520399f, -0.06737947f, 
    -0.03638681f, 0.07202002f, 0.05426736f, 0.08352497f, -0.00244895f, 0.05519986f, -0.10892057f, 0.04599505f, 
    -0.07423928f, -0.02542489f, -0.07533673f, -0.18463448f, -0.12245407f, -0.03448976f, 0.07060608f, -0.03284861f, 
    -0.03193430f, 0.02272666f, -0.08202170f, 0.02711533f, -0.20073907f, -0.40014806f, -0.03971874f, 0.10466204f, 
    -0.11562259f, 0.07914063f, -0.10519435f, 0.06722142f, -0.06805178f, -0.06718078f, 0.02132670f, -0.02552248f, 
    -0.20317355f, 0.04131131f, 0.07582867f, 0.10879390f, -0.09070076f, 0.04129912f, 0.07536547f, 0.01393823f, 
    0.05733605f, -0.06647187f, 0.12141965f, 0.09191898f, -0.04007885f, -0.20993628f, 0.01732534f, 0.01728317f, 
    -0.10486756f, 0.11492057f, 0.08329855f, 0.05309710f, -0.13312273f, 0.06276598f, -0.04778369f, 0.01352455f, 
    0.09494039f, 0.11771318f, -0.32115871f, 0.00216225f, -0.16686268f, -0.01392478f, 0.01939836f, -0.13301949f, 
    -0.01260896f, -0.02139470f, -0.13496466f, 0.04427409f, -0.11779360f, 0.01809575f, 0.02343547f, -0.18150790f, 
    -0.09195251f, -0.16329663f, 0.07289309f, -0.07812965f, -0.07320860f, -0.16892786f, 0.04362557f, -0.04675936f, 
    -0.04282083f, 0.01975809f, 0.00719769f, -0.07003000f, -0.01410617f, -0.03505999f, 0.07407153f, 0.00248269f, 
    -0.03624585f, 0.00274484f, 0.02504192f, 0.02578123f, 0.13917026f, 0.02032272f, -0.01029517f, 0.03077750f, 
    -0.07745156f, -0.09154808f, 0.08237225f, 0.00543429f, -0.04852723f, -0.01243380f, -0.09497901f, 0.00524486f, 
    0.09284840f, 0.12550539f, 0.11118340f, 0.07149039f, -0.05744874f, -0.06300975f, 0.11587529f, -0.09509026f, 
    0.06775935f, -0.00787197f, 0.02183856f, -0.12946156f, -0.11217450f, -0.21394950f, -0.19831151f, 0.03459534f, 
    -0.03287908f, -0.02189824f, 0.00506261f, 0.06536124f, 0.01706071f, 0.02024466f, -0.10328009f, -0.05831376f, 
    -0.00241075f, 0.11116384f, -0.03950596f, 0.01748491f, 0.01424765f, 0.01337981f, 0.07782830f, -0.01599213f, 
    -0.07342013f, -0.00317010f, -0.02183598f, 0.05437209f, -0.04663197f, -0.01324619f, -0.14641309f, 0.09743221f, 
    -0.08454102f, 0.03554883f, -0.00184161f, 0.02172408f, 0.11729118f, -0.01720457f, 0.04216811f, 0.06794907f, 
    -0.30700326f, 0.43797892f, -0.31293160f, -0.01328388f, 0.04422434f, 0.18458714f, 0.01670951f, 0.04002303f, 
    -0.03430830f, 0.04325484f, 0.10008118f, 0.04851750f, 0.04029834f, 0.09405717f, 0.17038752f, -0.03695542f, 
    -0.00091294f, -0.09444823f, -0.03516480f, -0.02537847f, -0.00822130f, 0.01129415f, 0.01390138f, -0.00142044f, 
    0.08216920f, 0.04782822f, 0.12094735f, -0.00868926f, -0.05500732f, 0.01731786f, 0.01114760f, 0.03044940f, 
    -0.00968190f, 0.12285604f, -0.14102954f, 0.08573341f, -0.43306682f, 0.36081144f, 0.06369517f, 0.09569026f, 
    0.06207898f, 0.01534430f, 0.00586652f, 0.04966522f, -0.07342093f, -0.11695213f, -0.04991743f, -0.04490747f, 
    0.04089275f, -0.29311556f, -0.05741588f, 0.10915092f, -0.08509646f, -0.00798937f, 0.10489618f, 0.02833625f, 
    0.03680040f, 0.03416821f, -0.01425847f, -0.06446347f, 0.15182349f, 0.21036193f, 0.08418796f, -0.13229090f, 
    0.04185378f, 0.02367309f, 0.03653861f, 0.06788756f, 0.06586002f, -0.07477193f, -0.02899051f, 0.06225709f, 
    0.18060949f, -0.10267086f, 0.17978537f, 0.05424837f, 0.07380346f, 0.01722992f, 0.04914494f, 0.09505223f, 
    -0.05047325f, 0.01985348f, 0.02331800f, -0.02300701f, 0.14426662f, -0.05477490f, -0.16086628f, 0.17546339f, 
    -0.09933066f, 0.06689214f, -0.06436362f, 0.09082478f, -0.01392488f, -0.01488765f, -0.03450194f, 0.06530074f, 
    -0.08189713f, 0.26004222f, 0.11674579f, 0.09524719f, -0.00601019f, -0.00439435f, -0.04597531f, -0.00707633f, 
    -0.00869273f, 0.03500972f, -0.08093801f, -0.04360717f, -0.17767064f, 0.11427289f, -0.03841137f, 0.17809427f, 
    0.14836012f, 0.08383369f, -0.00556078f, -0.08211465f, -0.01178806f, 0.10424376f, 0.14028056f, -0.01672753f, 
    0.17734638f, -0.13422298f, -0.03949344f, 0.10351878f, -0.05799350f, 0.00895362f, -0.01699905f, 0.02307117f, 
    0.10603851f, 0.09534510f, -0.03440534f, -0.07789784f, -0.34789845f, -0.34657604f, -0.25926390f, -0.07488250f, 
    -0.01446201f, 0.00723824f, -0.03561501f, 0.02315747f, -0.05630747f, -0.01295381f, -0.05884398f, -0.08031840f, 
    -0.07713843f, -0.20594011f, 0.12168390f, 0.13665423f, 0.03056046f, 0.04513562f, 0.04797761f, 0.00351863f, 
    -0.01477192f, 0.00433481f, 0.07151722f, -0.02501315f, -0.31885132f, 0.02669435f, -0.05886288f, -0.18880865f, 
    0.03938784f, -0.01139878f, 0.02017070f, 0.04231430f, -0.10341544f, -0.03229598f, -0.01244875f, -0.03899567f, 
    0.05254355f, 0.23889041f, -0.08142808f, -0.09881248f, 0.04514783f, 0.07162850f, 0.16202576f, 0.01296065f, 
    0.03738386f, -0.09461119f, -0.03723353f, -0.07578576f, -0.29945767f, 0.04456154f, -0.02178274f, -0.03545924f, 
    0.08002538f, 0.00424794f, 0.08024954f, 0.01596353f, 0.02226120f, -0.00081230f, 0.04100161f, -0.03408677f, 
    -0.10811775f, 0.13673532f, -0.16739659f, -0.35370761f, 0.05720917f, -0.03568306f, -0.04035848f, -0.04690397f, 
    -0.14251827f, -0.00902965f, -0.02989267f, -0.01002466f, -0.02450729f, 0.01604355f, 0.10200442f, 0.04294241f, 
    -0.09324550f, -0.04220783f, 0.03852326f, -0.04953964f, -0.10436050f, 0.12299459f, 0.01236616f, 0.06511581f, 
    0.18318500f, 0.02957938f, -0.10523364f, -0.02289864f, 0.01430746f, -0.12230634f, 0.02298558f, 0.04825184f, 
    0.03216738f, -0.06769041f, 0.02972815f, -0.02717161f, 0.06841537f, -0.16399962f, 0.10694018f, 0.17155199f, 
    0.01306571f, 0.07360320f, 0.01740837f, 0.14544334f, 0.09166463f, 0.02756704f, 0.11383667f, 0.18105122f, 
    -0.49831104f, 0.09190284f, 0.05984597f, 0.17808187f, 0.00251440f, 0.07440919f, -0.05123011f, -0.01460010f, 
    -0.01541108f, 0.05297919f, -0.03150245f, 0.03968174f, -0.32194614f, -0.01379849f, -0.06907173f, 0.11532545f, 
    -0.01461857f, -0.01875995f, 0.00233018f, 0.04782476f, 0.04361875f, -0.19593279f, -0.03523589f, -0.01187414f, 
    -0.00473310f, -0.12890805f, 0.05475217f, 0.14184520f, -0.10387534f, -0.01639232f, 0.02904828f, -0.03959165f, 
    0.01985023f, 0.03858838f, -0.02083465f, -0.03954723f, -0.30476487f, -0.24533102f, 0.13347782f, 0.02934989f, 
    -0.06998244f, -0.01652484f, -0.06635188f, 0.00938207f, 0.17155546f, -0.04882476f, -0.10877799f, -0.15922680f, 
    -0.21923742f, -0.00548511f, 0.12214416f, 0.08888856f, 0.01195759f, 0.02582176f, -0.11346784f, 0.01969303f, 
    0.09631190f, -0.07693388f, -0.06555106f, 0.09771720f, -0.15721008f, 0.00632340f, -0.01863208f, -0.05274289f, 
    -0.02684218f, -0.02042459f, 0.03855966f, -0.08831298f, 0.02488642f, -0.11238424f, 0.10096639f, 0.01475569f, 
    -0.09694940f, -0.12314761f, 0.03642274f, -0.32267854f, -0.08263192f, 0.04444617f, -0.05911605f, 0.05900240f, 
    -0.09527475f, 0.05339314f, 0.02628600f, -0.06065245f, 0.14989798f, -0.15870106f, 0.08255436f, 0.12454276f, 
    0.13775657f, 0.07027303f, 0.03314586f, 0.01937157f, -0.08230570f, -0.00521596f, 0.08487196f, -0.10178947f, 
    0.05468141f, 0.15535383f, -0.20555045f, -0.28676802f, 0.09849352f, -0.09891102f, 0.05344819f, 0.00018910f, 
    0.01354160f, 0.00007646f, 0.03428662f, -0.10345748f, -0.31605166f, -0.02295876f, -0.02232784f, -0.13291520f, 
    -0.07448155f, -0.09752110f, -0.06849223f, 0.06677690f, 0.06109290f, -0.04252570f, -0.02534940f, 0.09449382f, 
    0.10322446f, 0.00821378f, -0.01362540f, 0.07266536f, -0.07847165f, -0.02737690f, -0.02149463f, -0.04045115f, 
    -0.01413671f, 0.05056748f, -0.14769639f, -0.04190662f, -0.27998707f, -0.01497649f, -0.04654113f, -0.01967538f, 
    -0.04368413f, 0.02050134f, 0.00648613f, 0.13471632f, 0.08237074f, -0.01346066f, -0.00465176f, -0.10045727f, 
    -0.18343490f, -0.05187334f, 0.06436963f, 0.07234504f, 0.01598235f, 0.05702276f, -0.09143789f, -0.01528728f, 
    -0.05423989f, 0.00264846f, 0.04350007f, 0.00617248f, -0.19823346f, -0.13840382f, 0.11271086f, 0.03319240f, 
    -0.00259514f, 0.03752217f, 0.09977219f, -0.01942216f, 0.00867875f, -0.06760777f, -0.05666846f, -0.19735588f, 
    -0.26580137f, 0.15641922f, 0.13884845f, 0.18993646f, 0.06596572f, -0.07246529f, -0.08085229f, 0.04781418f, 
    -0.06101476f, 0.08057626f, 0.05500387f, -0.08255139f, 0.25156471f, -0.30972847f, -0.25015730f, 0.08784744f, 
    -0.10829642f, 0.07863001f, 0.10381642f, -0.13248667f, 0.06095619f, -0.04897787f, 0.09866686f, -0.11079851f, 
    -0.46792546f, 0.10786887f, -0.07945664f, -0.11411259f, 0.04291745f, -0.03824495f, 0.01285023f, 0.03954167f, 
    -0.04265476f, -0.00349852f, -0.04549653f, 0.01153516f, -0.30301154f, -0.10353202f, 0.08094928f, 0.00503633f, 
    0.07152214f, 0.08477190f, -0.02232873f, 0.02372017f, 0.05222047f, 0.00150670f, 0.06974682f, 0.03811090f, 
    -0.06958189f, 0.14819436f, 0.11852556f, 0.10134140f, -0.00725576f, 0.01880515f, -0.06331298f, 0.10292198f, 
    0.07920545f, -0.00886604f, -0.06309712f, -0.05875876f, -0.10379088f, 0.19772518f, -0.05228921f, -0.12498495f, 
    0.03731193f, -0.03333243f, -0.04002925f, 0.07398315f, 0.01518628f, -0.08690824f, 0.00225430f, -0.05478676f, 
    -0.11100687f, -0.01928151f, 0.02225571f, 0.14065096f, -0.00485567f, -0.00866356f, -0.00591894f, -0.02968885f, 
    0.20452589f, -0.04723436f, -0.01454277f, -0.08444474f, 0.22440849f, -0.12047608f, -0.18254514f, 0.01825199f, 
    -0.09188415f, -0.10333938f, -0.02025565f, -0.01826309f, -0.00600754f, -0.12535100f, 0.14427672f, -0.14018454f, 
    -0.27609670f, -0.00862569f, -0.10685793f, -0.12754965f, 0.07352080f, -0.06543387f, -0.03121839f, 0.02156680f, 
    -0.06883776f, 0.01643759f, -0.02012055f, -0.08720010f, 0.04175507f, -0.00784031f, -0.04399418f, 0.09660521f, 
    0.10605253f, 0.00944510f, 0.09541702f, -0.00824492f, -0.03575181f, 0.01996688f, -0.03986348f, 0.00630441f, 
    0.11260412f, 0.18443468f, 0.04866000f, 0.05721819f, -0.06206786f, -0.04000561f, -0.06526667f, -0.09333369f, 
    -0.02161933f, 0.00844559f, -0.02227347f, 0.03851011f, 0.03604447f, 0.06682485f, -0.01453724f, -0.02644474f, 
    -0.00320379f, -0.04860580f, 0.00638450f, -0.00319718f, -0.16783774f, -0.08920094f, 0.04242282f, 0.01884253f, 
    0.19689864f, -0.07065548f, 0.12773159f, 0.17682005f, -0.03827879f, -0.07912604f, -0.01245367f, -0.04915472f, 
    -0.04321763f, 0.03690310f, -0.08378870f, 0.02360998f, -0.32927322f, 0.25160426f, 0.02434996f, -0.02070711f, 
    0.06390914f, -0.00925503f, 0.03894675f, -0.01135410f, -0.00628683f, -0.01702334f, -0.04694672f, 0.10747172f, 
    -0.11381188f, 0.05360126f, -0.19980338f, 0.03467279f, 0.07916492f, -0.13011090f, 0.02516415f, 0.09684169f, 
    0.03224551f, -0.17159048f, -0.06598385f, 0.02603349f, 0.16558875f, 0.10219018f, -0.05639580f, -0.38115320f, 
    -0.01554307f, 0.05041719f, -0.02953763f, -0.05899506f, 0.00947991f, -0.07983977f, -0.08125776f, -0.00345395f, 
    0.03703717f, -0.07112607f, 0.03342567f, 0.13585728f, -0.03501756f, -0.01872995f, 0.00348050f, 0.00798767f, 
    0.08525861f, 0.07846927f, 0.09513098f, -0.03536043f, 0.29402614f, 0.14586551f, 0.17697920f, 0.03215725f, 
    -0.10549189f, -0.00322004f, 0.12264455f, -0.00212024f, 0.01507423f, -0.02970905f, -0.05520417f, 0.05293651f, 
    -0.09830862f, -0.04574668f, 0.17948626f, 0.29529935f, -0.00516314f, -0.03792747f, 0.06531772f, 0.02563464f, 
    -0.03378474f, 0.01296801f, 0.07219685f, -0.05023916f, 0.44218746f, 0.05172810f, 0.10737341f, 0.04183259f, 
    -0.00874027f, 0.04042195f, -0.04550250f, 0.07521642f, 0.01359319f, -0.01809015f, 0.05260283f, 0.06623778f, 
    0.15183255f, -0.03364162f, -0.02934059f, -0.27308780f, 0.06152407f, 0.22754706f, 0.08662066f, 0.01361138f, 
    -0.05739741f, -0.13858633f, 0.03136507f, 0.08073078f, -0.04575380f, -0.24696513f, -0.01403477f, 0.00422696f, 
    0.01341488f, -0.01919370f, 0.02316019f, -0.08832759f, -0.05868997f, -0.02183191f, 0.05865971f, -0.00686454f, 
    -0.07646813f, -0.24773596f, -0.15784810f, 0.08862630f, -0.03299755f, -0.06906363f, 0.02879641f, 0.11409723f, 
    -0.06552587f, 0.01804430f, -0.04272282f, 0.14968437f, -0.49931011f, -0.16711038f, -0.03920840f, 0.04263269f, 
    0.03358868f, -0.02146045f, 0.00761548f, 0.06916599f, -0.11565497f, -0.10511313f, 0.01994524f, 0.00274962f, 
    0.03680471f, -0.18705440f, 0.03384315f, 0.25387064f, 0.04907611f, -0.03370585f, -0.00226385f, 0.09448063f, 
    0.03222388f, 0.03682455f, 0.02041774f, 0.04042643f, 0.02415095f, 0.06874466f, 0.16050008f, 0.16915318f, 
    0.10865901f, 0.06928866f, 0.05850604f, 0.14318888f, 0.04027200f, -0.02058823f, 0.08099379f, 0.06174948f, 
    -0.01385305f, -0.05868324f, -0.06873550f, -0.11045908f, 0.09694906f, -0.09858888f, -0.02831822f, -0.05340251f, 
    0.14788273f, -0.08020674f, -0.05315799f, -0.02198316f, 0.08814554f, -0.43599659f, -0.10115197f, -0.05823961f, 
    -0.22223201f, 0.03852188f, 0.01845843f, -0.10053220f, 0.06282513f, 0.10095319f, 0.03723083f, 0.00329499f, 
    0.04383393f, -0.35847905f, -0.00840113f, -0.11416713f, 0.04059871f, 0.08315019f, 0.00463707f, -0.04405013f, 
    -0.05387981f, 0.02663453f, 0.02166626f, 0.01552667f, 0.01811654f, -0.02415609f, -0.11601642f, 0.02092560f, 
    -0.04897947f, 0.12985462f, 0.08157838f, 0.07040417f, 0.01063566f, -0.02237899f, 0.10355772f, -0.00771405f, 
    -0.27608809f, -0.17916703f, 0.23429303f, -0.03041347f, -0.05464198f, 0.05464177f, 0.02129058f, 0.03011236f, 
    0.07620150f, 0.04529729f, 0.05695454f, -0.09073620f, 0.32762766f, -0.17125680f, 0.03472159f, 0.00081467f, 
    0.09084135f, -0.00397605f, 0.13648263f, 0.02276326f, -0.03535652f, -0.07486216f, -0.04197595f, -0.03695701f, 
    -0.12633981f, -0.04226417f, 0.23904888f, -0.16155040f, 0.15315300f, 0.03261054f, 0.01739875f, 0.03709953f, 
    0.10098051f, 0.01141731f, -0.00027004f, 0.10816307f, 0.01333980f, -0.03835143f, 0.05519667f, -0.03002101f, 
    -0.12570107f, 0.02494701f, 0.00067853f, 0.00504395f, -0.09451408f, 0.09304414f, -0.10707273f, -0.08727013f, 
    -0.00498128f, 0.01950569f, -0.01669871f, 0.05042730f, -0.06901834f, 0.03621850f, 0.07247115f, 0.13792080f, 
    -0.08713898f, -0.00516378f, 0.02313888f, 0.04903064f, 0.35877806f, 0.31494218f, -0.15939619f, -0.18836287f, 
    0.04665600f, 0.01863711f, 0.14629307f, 0.03227837f, 0.05588116f, -0.04430116f, -0.02706045f, -0.03002577f, 
    -0.29768395f, -0.11653666f, 0.05301419f, -0.02154071f, 0.05459580f, -0.04835978f, 0.05990792f, 0.12772867f, 
    -0.06677711f, -0.01880613f, -0.02160353f, 0.14924191f, -0.23502772f, -0.08230958f, 0.13695377f, 0.00992695f, 
    -0.01206836f, 0.15656947f, -0.00427606f, 0.03959027f, 0.06358538f, -0.01465291f, 0.03950320f, -0.01563586f, 
    0.02042726f, 0.03426041f, 0.05644832f, -0.04690820f, -0.12712175f, 0.01562364f, 0.11920020f, -0.13229489f, 
    -0.02320140f, -0.00359539f, 0.07537656f, 0.12012338f, -0.34694439f, 0.04260325f, 0.20101945f, 0.07956062f, 
    0.00126301f, -0.01784275f, 0.01634413f, -0.08250453f, -0.01974182f, 0.05884780f, 0.04973841f, -0.08589321f, 
    0.00926478f, 0.17799750f, -0.18012968f, 0.01883245f, 0.02371093f, -0.04041327f, 0.07074296f, 0.08441111f, 
    -0.10849690f, 0.06958085f, -0.04725974f, 0.04350225f, -0.12301539f, -0.12347683f, -0.02834401f, 0.00544875f, 
    -0.15496631f, -0.06015022f, -0.11073064f, 0.01283820f, 0.07620376f, 0.07174161f, -0.00442151f, 0.11186904f, 
    0.34082976f, 0.01428734f, -0.04004003f, -0.10541134f, -0.22242077f, -0.06302103f, -0.15182120f, -0.09990247f, 
    -0.04080229f, -0.05181981f, -0.06854599f, -0.07135202f, -0.41776848f, -0.00728101f, 0.05244191f, -0.16656567f, 
    0.04407540f, 0.02394592f, 0.16875888f, 0.12776217f, -0.13694692f, 0.17659800f, -0.16272613f, 0.14717919f, 
    -0.19046564f, 0.04990801f, -0.15607265f, -0.06486506f, -0.02748105f, -0.09415492f, -0.02726498f, -0.08280457f, 
    0.18469650f, 0.17582920f, 0.07232524f, 0.15033656f, -0.36977795f, -0.09205182f, -0.09188960f, -0.17895684f, 
    0.00496503f, 0.10468697f, 0.00535769f, -0.11562143f, 0.09081541f, 0.02785060f, 0.01901332f, 0.03368889f, 
    -0.17539012f, -0.16992031f, 0.10403179f, 0.19728695f, -0.05090358f, -0.12621228f, -0.04510980f, 0.17275681f, 
    0.13088095f, -0.05116285f, -0.01296122f, -0.26000634f, 0.01246439f, 0.06436891f, 0.11027377f, 0.31784788f, 
    0.00910942f, -0.01040962f, 0.07422324f, 0.07640253f, 0.05120221f, -0.10081316f, -0.00589132f, 0.06107833f, 
    0.05803472f, 0.06782568f, 0.09302504f, 0.02983699f, 0.11499647f, 0.02553211f, 0.11551634f, -0.05749643f, 
    0.13187104f, -0.02985149f, -0.03562076f, 0.09189062f, -0.03017846f, 0.12385234f, -0.01785547f, -0.10043090f, 
    0.12718688f, -0.05314122f, -0.00337934f, -0.24070358f, -0.13503014f, -0.04470393f, -0.10348474f, -0.15940593f, 
    -0.14017759f, 0.13623433f, -0.15349859f, -0.09853812f, 0.05820535f, -0.03337713f, 0.03855740f, -0.12438613f, 
    -0.03629709f, -0.14276569f, 0.14866713f, -0.16830653f, -0.62699544f, -0.21149795f, -0.29831564f, -0.13211106f, 
    0.11837789f, 0.06653044f, 0.06726658f, -0.00695313f, -0.11195091f, 0.16513556f, 0.07149491f, -0.07466033f, 
    -0.03241519f, -0.01581915f, -0.07149524f, -0.05723387f, 0.01962541f, -0.04708816f, -0.00173592f, -0.05589333f, 
    -0.04502529f, -0.07327934f, 0.04514552f, 0.14837943f, 0.09884337f, 0.09254953f, 0.02013460f, 0.10082750f, 
    -0.07663498f, 0.15484546f, -0.07527474f, -0.02533067f, -0.18635873f, 0.03981338f, 0.16254029f, 0.08352172f, 
    0.13422777f, 0.02494330f, 0.04610126f, -0.06229242f, 0.06842045f, 0.03674443f, 0.02974418f, -0.01563854f, 
    -0.06730396f, -0.02760669f, 0.11579005f, 0.07503118f, -0.15039210f, 0.09410081f, -0.18771552f, -0.16558035f, 
    0.07366193f, -0.01527705f, 0.00010843f, -0.01775870f, 0.07048354f, -0.01165203f, -0.04906506f, -0.22424889f, 
    0.00520843f, 0.12288448f, -0.06037225f, -0.10831165f, 0.10006557f, -0.03912683f, 0.12356794f, 0.01012092f, 
    0.20245554f, 0.08347692f, -0.09737687f, 0.02436282f, 0.01043259f, 0.10621725f, -0.00025649f, -0.22848144f, 
    -0.16468644f, -0.07151417f, 0.02199636f, 0.05033878f, 0.14600994f, -0.07073940f, -0.08102290f, -0.28772387f, 
    -0.30128628f, -0.14932792f, 0.14267662f, 0.12612073f, 0.00934793f, 0.01238605f, -0.00152734f, -0.12204328f, 
    0.02148591f, -0.02585530f, 0.08300460f, 0.18215899f, 0.11372758f, 0.04162126f, 0.02714569f, -0.07233299f, 
    0.12002152f, -0.03850611f, -0.06180596f, 0.06945439f, -0.11189453f, -0.00236923f, -0.07585762f, 0.02390875f, 
    0.16398905f, 0.07947987f, 0.12676512f, -0.12791681f, -0.06821112f, 0.05509086f, 0.06891875f, 0.01627466f, 
    0.02176688f, 0.15272497f, 0.16468702f, -0.05671520f, -0.01169755f, -0.02757263f, 0.15818796f, 0.06820806f, 
    -0.06949537f, -0.09251100f, -0.09972111f, -0.05747266f, 0.04504351f, 0.05842256f, 0.04873374f, 0.12226111f, 
    0.02909675f, 0.01851617f, -0.05727379f, 0.23464648f, 0.08911400f, -0.07274231f, 0.13197546f, 0.00861163f, 
    -0.01166031f, 0.08001290f, -0.01008728f, 0.02695039f, -0.08125838f, 0.15528090f, 0.03737014f, 0.04941993f, 
    -0.07001030f, 0.00865883f, 0.04832197f, -0.02014537f, -0.11274982f, -0.12369962f, 0.16714837f, 0.10362370f, 
    0.02902135f, 0.09284850f, -0.07582717f, -0.07179145f, 0.05668403f, 0.05535884f, -0.13263696f, -0.03118639f, 
    0.02588717f, -0.12298939f, -0.06243484f, 0.02771191f, -0.15047617f, 0.22468409f, 0.27292100f, -0.36916459f, 
    -0.01211938f, -0.00586358f, -0.05697194f, 0.07407393f, 0.06891917f, -0.02609567f, -0.06205936f, -0.02998458f, 
    -0.26111737f, -0.16031000f, 0.03333646f, 0.05077458f, 0.05993596f, -0.13594525f, 0.03435472f, 0.13974382f, 
    -0.02556415f, 0.02445735f, -0.04432048f, -0.05187003f, -0.04767222f, -0.03429478f, 0.09016620f, 0.22002189f, 
    0.02917986f, -0.10454620f, 0.02743965f, -0.02161041f, -0.09861347f, 0.06729974f, -0.02709751f, 0.12944491f, 
    -0.30637234f, -0.03948362f, -0.03631511f, 0.03822409f, 0.06608210f, -0.07417507f, 0.03917555f, 0.10565915f, 
    -0.01997431f, 0.06514906f, 0.08648719f, 0.10552068f, -0.00722087f, -0.04775332f, 0.21177748f, 0.18088175f, 
    0.01248540f, 0.07781012f, -0.04845304f, 0.06348088f, 0.00819910f, 0.06036445f, 0.05267566f, 0.18264256f, 
    0.23550583f, 0.07509830f, -0.14869140f, -0.07538797f, -0.07031419f, -0.12709299f, -0.02663008f, -0.09617670f, 
    -0.05468333f, -0.00723385f, 0.17043690f, 0.26394466f, -0.08035724f, 0.02866847f, -0.08337606f, 0.17532559f, 
    -0.09531124f, -0.00542023f, 0.09270599f, -0.10021646f, -0.12047738f, 0.14358653f, -0.10465841f, 0.15837391f, 
    0.09660558f, -0.25986814f, -0.12120564f, -0.14310025f, -0.07203766f, -0.00690926f, -0.01274688f, 0.06478295f, 
    -0.00543743f, 0.04138583f, 0.02274879f, 0.12924553f, -0.09824838f, 0.08786656f, 0.07517541f, 0.09968162f, 
    0.01348107f, -0.08189206f, 0.00413484f, -0.05197619f, -0.01375378f, -0.05077393f, -0.04565957f, -0.06764422f, 
    -0.08531756f, -0.03190922f, -0.03140803f, -0.09873967f, -0.09923797f, 0.01704788f, -0.03173056f, -0.01187627f, 
    -0.02588848f, -0.25975415f, -0.02284431f, 0.04408895f, 0.01758701f, 0.00998584f, 0.09028541f, -0.05045527f, 
    -0.01900562f, 0.04866843f, 0.16076712f, 0.02134359f, 0.18027589f, -0.16574478f, -0.03703674f, -0.11180616f, 
    0.02557427f, -0.09311841f, -0.10244710f, -0.35914293f, -0.09356825f, -0.03015276f, 0.00406731f, 0.05125588f, 
    0.08564176f, 0.00403893f, -0.03831093f, -0.08593282f, -0.44670060f, -0.14145692f, -0.25218645f, 0.03508374f, 
    0.24020456f, -0.02835446f, -0.01897779f, -0.08300661f, 0.07570695f, 0.10657586f, -0.17779154f, -0.00222650f, 
    -0.13000473f, -0.07510000f, -0.03111175f, 0.02703867f, -0.22127710f, 0.19399334f, 0.09119029f, -0.03256628f, 
    0.07667322f, -0.01513788f, 0.22006015f, 0.00624846f, -0.27065897f, 0.03067110f, 0.05239013f, -0.01638364f, 
    0.19259194f, -0.03250256f, 0.05730247f, -0.13199826f, -0.04723668f, -0.02060702f, 0.00756937f, -0.05617142f, 
    0.17485206f, 0.09433989f, 0.13726580f, -0.05728043f, 0.00573208f, 0.03294643f, -0.01437795f, 0.02132451f, 
    -0.03708433f, -0.00268765f, 0.05587477f, 0.14205711f, -0.11226297f, -0.17226920f, 0.02890794f, 0.21585496f, 
    -0.01530443f, -0.10532263f, -0.02804149f, 0.00579324f, 0.12013613f, -0.04620557f, 0.04017081f, 0.01777423f, 
    -0.06925542f, -0.18284214f, -0.17152777f, -0.04218597f, 0.08271602f, 0.13108894f, -0.12807243f, -0.01132094f, 
    -0.01785817f, 0.00536033f, -0.04629028f, 0.11055356f, -0.14360934f, -0.07830136f, 0.15284650f, 0.20123790f, 
    0.01926538f, -0.14268209f, 0.09730423f, -0.12248571f, 0.10342770f, 0.00927201f, -0.04680880f, 0.08155783f, 
    -0.04202952f, 0.07744328f, 0.04190812f, -0.10998600f, -0.07747023f, -0.07360658f, 0.01380942f, 0.03188529f, 
    -0.00608991f, 0.11121462f, -0.08816926f, -0.07304964f, 0.10960448f, -0.12757534f, -0.10707267f, 0.03015318f, 
    0.01504023f, -0.09721308f, -0.06389440f, -0.10726818f, 0.03008827f, 0.01737781f, -0.10528606f, -0.12721826f, 
    0.09413884f, -0.02917649f, 0.14959121f, 0.01981276f, 0.07640063f, -0.09214652f, -0.00216793f, -0.11426076f, 
    -0.01526150f, -0.08869420f, 0.08563751f, -0.06335268f, -0.32678735f, 0.11637001f, -0.07516600f, -0.04556999f, 
    0.02167899f, 0.12044463f, 0.08522469f, -0.00285096f, 0.16691959f, -0.04866149f, -0.00421036f, 0.00126042f, 
    0.07368228f, -0.06195492f, -0.15920545f, 0.09762952f, 0.09299640f, 0.13688689f, -0.15017639f, -0.08102003f, 
    0.06417383f, 0.02872333f, 0.05522374f, -0.11144350f, -0.21378660f, -0.00446331f, -0.07151487f, 0.08737017f, 
    0.01664586f, -0.04749569f, 0.00584885f, 0.00988675f, 0.10641089f, -0.02767192f, 0.07251707f, 0.08849163f, 
    -0.07362613f, -0.01637302f, -0.03442521f, -0.27544928f, 0.15604031f, 0.05255028f, 0.06018383f, 0.03829128f, 
    0.10776829f, 0.05985729f, 0.02572748f, 0.07701869f, 0.11181305f, 0.19222918f, -0.04795966f, 0.00755904f, 
    -0.01916895f, -0.01243931f, 0.02217600f, 0.06751607f, -0.12043284f, -0.04762439f, -0.05901072f, 0.08451634f, 
    0.12299227f, 0.05240447f, 0.07789252f, 0.20246337f, -0.09587242f, -0.07751742f, -0.06027213f, 0.10294611f, 
    -0.00447537f, -0.10733924f, 0.01335925f, 0.07655761f, -0.11266309f, 0.15659890f, 0.19799338f, -0.34585685f, 
    -0.03060423f, -0.08354843f, 0.05481157f, -0.02893494f, 0.08821733f, 0.05030357f, -0.05020194f, -0.10010402f, 
    -0.09040321f, -0.13690744f, -0.01071855f, 0.09669389f, -0.12506245f, -0.07416568f, -0.04594037f, -0.02359177f, 
    0.02301064f, -0.01622595f, 0.00671005f, -0.07490421f, -0.08340603f, -0.09914847f, -0.13589887f, 0.02458420f, 
    -0.06998803f, 0.07541092f, 0.01363149f, -0.07010914f, 0.19427219f, -0.11419675f, 0.00649693f, 0.08676964f, 
    -0.03061074f, 0.12508595f, 0.11103588f, 0.09341015f, -0.03541036f, 0.00150865f, 0.04501667f, -0.00822752f, 
    0.03432534f, -0.08954018f, -0.00540049f, -0.02076914f, 0.18067908f, -0.10994405f, -0.10575028f, -0.08747014f, 
    0.00445286f, -0.03708574f, 0.16218629f, 0.06261482f, 0.03904044f, 0.10045348f, -0.12574320f, 0.22357114f, 
    0.03767948f, 0.03769764f, 0.16516659f, 0.11390591f, 0.02900833f, 0.00184329f, 0.09708504f, -0.07293829f, 
    -0.18937778f, -0.08614650f, -0.17180245f, 0.05709698f, -0.30487362f, -0.29673293f, 0.01825905f, 0.10812246f, 
    -0.03217934f, -0.03565339f, -0.03463067f, -0.20226607f, -0.03826941f, -0.08894212f, 0.01229951f, -0.00241071f, 
    -0.14229782f, 0.19674052f, -0.06705246f, -0.18322544f, 0.13646682f, 0.07276694f, 0.18441714f, 0.02532744f, 
    0.04357344f, -0.04377900f, -0.15049559f, -0.14763807f, 0.00794770f, 0.03445911f, 0.04123299f, 0.11507948f, 
    0.05054437f, -0.13330342f, -0.02316925f, -0.03561484f, 0.11310885f, -0.07407642f, 0.02226784f, -0.04839408f, 
    -0.01546586f, -0.05007771f, 0.02523609f, 0.19990748f, 0.05469146f, -0.03295292f, 0.14564888f, 0.11897538f, 
    0.12466039f, 0.14526588f, -0.16019759f, 0.04521584f, -0.12227416f, -0.14524858f, 0.06456389f, 0.04551454f, 
    -0.05614832f, -0.09637936f, 0.01725428f, 0.03445434f, -0.02023070f, -0.14086680f, -0.08243029f, -0.14919068f, 
    0.00378319f, -0.10790923f, 0.15228872f, 0.08356728f, 0.04908114f, 0.05036327f, 0.01504585f, -0.07334036f, 
    -0.04199842f, -0.04669407f, -0.03193252f, 0.00310704f, 0.10869645f, 0.02252952f, 0.00522084f, 0.06406785f, 
    0.02202483f, 0.00889036f, 0.04708488f, 0.02654008f, 0.00574251f, -0.12591742f, -0.07865324f, 0.00371472f, 
    -0.50986373f, 0.07504519f, 0.11754811f, 0.23223624f, 0.10567075f, -0.03841716f, 0.00543590f, 0.04685415f, 
    0.01522938f, 0.02939909f, 0.04235663f, 0.00089089f, 0.16999747f, 0.00053452f, -0.05255228f, -0.07397769f, 
    -0.10902561f, 0.05403786f, -0.04236486f, -0.18552521f, 0.13516404f, -0.08500306f, 0.05917775f, -0.03658410f, 
    -0.07975406f, -0.03619143f, 0.07642623f, -0.34283444f, -0.07765110f, 0.11845405f, -0.05364972f, 0.09448288f, 
    -0.04567631f, -0.11295430f, -0.11394341f, -0.20438975f, -0.10056973f, -0.35325775f, -0.05902185f, 0.03497286f, 
    -0.11666020f, 0.07922317f, -0.06391175f, 0.11616177f, 0.11529150f, 0.03055695f, -0.04457263f, 0.02113657f, 
    0.21237822f, -0.07971040f, 0.02890122f, 0.13874698f, 0.04916514f, 0.02408312f, 0.06747071f, -0.03227967f, 
    -0.13602857f, 0.04211507f, 0.19067374f, 0.12523824f, -0.02880073f, -0.03651930f, -0.34826910f, -0.11631767f, 
    -0.04295875f, -0.02286792f, -0.11998455f, -0.02346673f, -0.02052888f, 0.02010692f, -0.05139928f, -0.06940211f, 
    -0.18707298f, 0.10772993f, 0.16192870f, -0.08372463f, -0.09424408f, -0.04002411f, 0.03032506f, 0.10324120f, 
    0.01378577f, 0.04429853f, -0.08434504f, 0.07309373f, 0.12551783f, -0.25574440f, -0.16176078f, -0.08003711f, 
    -0.13139182f, 0.10272320f, -0.07919536f, 0.05200788f, -0.03455115f, -0.02988830f, 0.00922526f, 0.19237302f, 
    0.10216807f, -0.20227101f, 0.16087867f, -0.19275996f, -0.09867398f, 0.08267071f, -0.03142427f, -0.07817675f, 
    0.02237088f, 0.05884796f, -0.01603636f, 0.13227211f, -0.34936303f, -0.21028654f, -0.03181678f, -0.28613579f, 
    -0.04505568f, 0.03416908f, 0.01978198f, -0.11046891f, -0.03837072f, -0.12028126f, 0.08326577f, 0.10700153f, 
    0.01667231f, 0.25083217f, 0.11737461f, -0.35562876f, -0.05587577f, 0.11828326f, 0.00026234f, -0.02183909f, 
    -0.04705407f, 0.09159950f, -0.02488223f, -0.06683043f, -0.00802216f, 0.04863432f, 0.08550341f, -0.01608754f, 
    0.12975278f, -0.12955096f, -0.00890690f, 0.05098813f, 0.05563073f, -0.04992068f, -0.13517123f, -0.18111153f, 
    0.12243927f, 0.08386884f, 0.03020831f, -0.19651958f, -0.03111846f, 0.00610914f, 0.11862637f, -0.09138944f, 
    -0.04736887f, 0.09262308f, -0.01657976f, 0.02811562f, -0.18852633f, -0.16551998f, -0.09752537f, 0.04028263f, 
    0.05348765f, 0.00625808f, 0.00229171f, 0.09648439f, 0.01389355f, -0.00878123f, 0.04341044f, 0.19119376f, 
    0.02531247f, -0.05599261f, 0.03864498f, 0.07053792f, -0.03407227f, 0.02041295f, -0.01558934f, -0.06293097f, 
    -0.15497124f, -0.02625169f, 0.01877110f, -0.13372321f, -0.25512630f, -0.08770657f, 0.08598026f, 0.08052088f, 
    -0.00529251f, -0.15380551f, -0.03805802f, -0.03483964f, -0.10673073f, 0.04521764f, 0.02846097f, 0.05842513f, 
    -0.03818833f, -0.17289622f, -0.11098624f, 0.18000445f, -0.06526678f, 0.03596520f, 0.06786406f, -0.02028655f, 
    0.02170222f, 0.08474568f, -0.04797642f, -0.07253615f, 0.09014861f, 0.09637165f, 0.13375983f, 0.02265378f, 
    -0.02119491f, -0.00066240f, -0.00019979f, -0.05207115f, -0.04093730f, 0.11376407f, -0.01960980f, -0.15413037f, 
    -0.23395233f, 0.05973509f, 0.24316826f, 0.07948030f, 0.10177544f, 0.10062393f, 0.01195125f, 0.04967507f, 
    -0.13423352f, -0.18307619f, 0.02863792f, 0.03163584f, -0.05195523f, 0.14767690f, -0.05488043f, 0.14999072f, 
    0.00860801f, 0.09855872f, 0.06403361f, 0.03616210f, 0.06774814f, -0.05319195f, -0.01637163f, -0.05783049f, 
    0.08341917f, 0.04049624f, -0.01379855f, -0.11173595f, 0.02613164f, -0.13333011f, -0.00228066f, 0.13225828f, 
    -0.14218163f, -0.18523504f, 0.06874068f, -0.02005637f, 0.02405605f, 0.11014878f, 0.17048581f, -0.12790607f, 
    0.10476864f, 0.01081860f, 0.06368041f, -0.02502602f, -0.03534802f, 0.09132406f, -0.05802466f, -0.06608771f, 
    -0.22122367f, -0.06321470f, -0.06092959f, -0.01869031f, -0.04638364f, -0.03233066f, -0.00229643f, -0.00418573f, 
    0.05396830f, 0.06025724f, 0.05815089f, 0.03360165f, -0.18734492f, -0.13884008f, 0.08866286f, -0.04562036f, 
    -0.04758290f, 0.09553294f, -0.04523843f, 0.09844310f, -0.06173547f, -0.09939517f, -0.12258048f, -0.02864042f, 
    0.16929024f, -0.04395294f, -0.10349009f, 0.10093572f, 0.01136483f, -0.02946333f, -0.01734879f, 0.01616892f, 
    -0.03260595f, -0.02758677f, 0.02984621f, 0.03034640f, 0.05874179f, 0.20180975f, -0.06673644f, -0.00267351f, 
    -0.13848270f, 0.08901615f, 0.04273920f, 0.05832117f, 0.19817226f, -0.05086064f, -0.01287679f, -0.01414112f, 
    -0.27100804f, 0.10298043f, -0.12596482f, -0.20740169f, -0.06803437f, -0.00416104f, -0.02864957f, -0.03662534f, 
    0.00125535f, 0.01396152f, -0.04948903f, -0.02999084f, 0.17076793f, 0.04286639f, -0.05994441f, -0.24792042f, 
    0.03660174f, -0.02307007f, 0.06255554f, -0.00147989f, 0.04640611f, -0.14185992f, -0.00967480f, -0.18338983f, 
    -0.12413982f, -0.05540205f, 0.05948322f, 0.00517665f, 0.10290702f, 0.13390242f, 0.01295864f, 0.04180144f, 
    -0.11931818f, -0.16927604f, -0.00039971f, -0.17714001f, -0.03672279f, 0.00535394f, 0.15469202f, 0.00395262f, 
    0.06443609f, 0.00462120f, -0.04840648f, -0.06406140f, 0.09034622f, -0.10106047f, 0.01455000f, -0.11105876f, 
    0.33174998f, -0.08399201f, 0.14475001f, 0.06491023f, 0.03471588f, 0.20933567f, 0.11647004f, -0.02354197f, 
    0.14748065f, -0.03578655f, -0.13529038f, 0.04057560f, 0.18781251f, -0.13351181f, -0.20094903f, 0.37548670f, 
    -0.04758278f, 0.03012619f, -0.06026932f, -0.12658821f, 0.07574310f, -0.04656506f, -0.13535576f, 0.03132528f, 
    0.17029591f, -0.06588545f, 0.02989226f, -0.13181372f, 0.09582470f, 0.05397693f, 0.03434564f, 0.06886635f, 
    0.00084336f, 0.10957961f, 0.07865109f, -0.04207030f, 0.07656779f, -0.03393410f, 0.16958998f, -0.04370971f, 
    0.00788630f, -0.05464749f, 0.00989410f, 0.02885471f, 0.04988023f, 0.04833216f, -0.00813882f, 0.14419019f, 
    -0.28405514f, 0.17107944f, 0.09953087f, -0.13072650f, -0.07871081f, 0.06353708f, -0.07287614f, 0.04031578f, 
    -0.04063245f, -0.05816351f, 0.04897924f, 0.10162229f, -0.03997752f, -0.06962619f, 0.10650577f, -0.10435086f, 
    0.01294072f, -0.00757217f, 0.08486304f, -0.13357949f, 0.02929658f, -0.11728603f, 0.20910618f, 0.13263650f, 
    -0.11819141f, -0.07583077f, 0.03648929f, -0.07806174f, 0.09875494f, -0.07553594f, 0.06531852f, -0.15973277f, 
    0.03140283f, -0.09454037f, -0.13242853f, -0.07694922f, 0.24669658f, -0.15507028f, 0.01924827f, -0.02741959f, 
    -0.00343280f, 0.11601058f, 0.00950029f, -0.02376083f, 0.00677373f, 0.07210232f, 0.08371396f, -0.05240458f, 
    -0.18302698f, 0.25126380f, 0.14472257f, -0.05654942f, 0.02271748f, 0.00410333f, 0.03521333f, 0.05221892f, 
    0.00591934f, 0.00336733f, -0.02951753f, -0.16907060f, 0.06083209f, -0.14987974f, -0.18029028f, 0.02416108f, 
    -0.00091135f, -0.07177631f, -0.00457599f, -0.03628573f, -0.13194886f, 0.04979018f, -0.10702292f, 0.01588172f, 
    -0.34634173f, -0.11559448f, -0.17859876f, -0.18501742f, 0.07341570f, -0.02143299f, 0.12287360f, -0.08033642f, 
    0.07946328f, -0.10271421f, 0.01425930f, -0.03302265f, -0.25478205f, 0.20864859f, -0.10263810f, -0.14724183f, 
    0.10877272f, 0.06051127f, -0.10879441f, 0.15879847f, 0.01023714f, 0.01864245f, 0.17198037f, 0.02416765f, 
    0.26495761f, -0.14687364f, 0.15575258f, -0.23172817f, 0.05558847f, 0.04060992f, 0.02208163f, -0.00645135f, 
    0.00409180f, -0.01855253f, 0.05742631f, 0.00870231f, -0.35022551f, 0.12581268f, -0.16269490f, 0.27843240f, 
    0.00991123f, 0.05315368f, 0.02771621f, 0.11646086f, 0.11986142f, -0.04798658f, -0.04123322f, -0.08319665f, 
    -0.32890669f, 0.16531992f, 0.08899427f, 0.00297612f, -0.01487149f, 0.17100677f, 0.12709410f, -0.03753592f, 
    0.02031267f, 0.18827395f, 0.04031086f, 0.06956535f, 0.13358173f, -0.20592403f, -0.13189334f, -0.08681847f, 
    -0.09103437f, -0.02393042f, 0.04621023f, -0.08150964f, -0.14114641f, 0.02773075f, -0.02805036f, 0.02011465f, 
    -0.08936378f, 0.06589686f, -0.17610170f, -0.14807279f, -0.22074969f, -0.00793460f, 0.17630772f, -0.13770510f, 
    -0.03620795f, 0.11510707f, -0.09770665f, 0.14930180f, 0.05509700f, -0.11641207f, -0.31488368f, 0.02813853f, 
    0.01849276f, -0.06863901f, -0.07515161f, -0.05750182f, 0.00000788f, -0.09136196f, -0.10916442f, -0.11496847f, 
    -0.14279939f, -0.06671765f, 0.21154749f, 0.02338283f, -0.07456592f, 0.08204431f, 0.00695965f, -0.06977016f, 
    -0.08566137f, -0.07414567f, 0.00077348f, -0.11363886f, -0.29462513f, 0.10339946f, -0.06549529f, 0.31245783f, 
    0.03077666f, 0.08512539f, -0.09139282f, -0.01048875f, 0.07288734f, -0.09525360f, -0.01303408f, -0.30384645f, 
    -0.12758356f, -0.07329023f, 0.23429002f, -0.24884532f, 0.07424761f, -0.07090186f, 0.11392526f, -0.02115885f, 
    -0.03850372f, 0.10980342f, -0.06663322f, -0.07264278f, 0.20634221f, -0.08474260f, -0.02340078f, -0.02872017f, 
    -0.06638692f, 0.02206220f, 0.00936312f, 0.02622289f, -0.05278502f, -0.10991402f, -0.01007685f, 0.06961314f, 
    -0.26388380f, 0.08687054f, 0.15224847f, 0.08838758f, 0.01541648f, 0.07493673f, 0.05970217f, -0.03859918f, 
    -0.08245713f, -0.03531957f, 0.09408116f, 0.05757996f, -0.22020470f, 0.21614440f, -0.13565132f, -0.09769391f, 
    -0.01293559f, -0.02292555f, 0.02148394f, -0.10743074f, 0.01734900f, -0.00941277f, 0.08296755f, -0.17032947f, 
    0.22633880f, -0.27674249f, -0.14988182f, 0.02958130f, -0.05900427f, -0.00262010f, 0.02409591f, 0.16081697f, 
    0.08390726f, 0.06163558f, -0.01568388f, 0.10263252f, 0.01671507f, -0.00294830f, 0.05762225f, 0.02389390f, 
    0.08425619f, 0.09672769f, 0.03676973f, -0.03180396f, -0.07170641f, 0.05692192f, 0.01011130f, -0.14916959f, 
    0.02225815f, 0.27536666f, 0.08894674f, -0.20936199f, -0.10392195f, -0.09483272f, 0.02187071f, -0.00318908f, 
    0.03883877f, 0.12253506f, 0.10629812f, -0.07709782f, 0.34407827f, -0.13545519f, -0.03038248f, 0.15530017f, 
    -0.11145146f, -0.01314654f, -0.00555167f, 0.13028307f, -0.11163311f, 0.10968247f, -0.00830649f, 0.02713920f, 
    0.07867330f, -0.14546847f, -0.10486287f, -0.25266862f, 0.08313315f, -0.11743189f, -0.04939328f, -0.10435144f, 
    -0.11781275f, 0.13173242f, 0.11836690f, 0.12304376f, -0.08900626f, 0.10589026f, -0.10479303f, 0.27217403f, 
    0.07808562f, 0.13785675f, -0.03382465f, 0.11726593f, -0.05874414f, 0.04245869f, -0.04743182f, 0.00178538f, 
    0.04090988f, -0.01965441f, -0.14479592f, -0.04833612f, 0.07802639f, -0.11484402f, -0.06052164f, 0.01207854f, 
    -0.17891322f, -0.11740971f, -0.03126870f, 0.00231441f, 0.28569296f, 0.17542374f, -0.02205453f, -0.19009703f, 
    0.00151968f, 0.06991459f, -0.16211240f, -0.09480368f, 0.05307287f, 0.02467852f, 0.08662440f, 0.11784271f, 
    0.12676288f, 0.00591003f, 0.05060277f, -0.22531238f, -0.16701108f, 0.00504243f, 0.05922359f, 0.12769185f, 
    0.07738946f, 0.00277314f, 0.07962274f, 0.19476813f, -0.53640747f, 0.23679297f, -0.01854267f, 0.17691669f, 
    -0.09264795f, -0.04742920f, 0.04012261f, 0.06206921f, -0.11058075f, 0.13726908f, 0.14983095f, 0.00003003f, 
    -0.18894339f, -0.05268055f, -0.05935904f, -0.17219228f, -0.08390397f, 0.01504891f, 0.01973172f, -0.02544337f, 
    0.06292520f, -0.04496327f, -0.04225505f, -0.03876689f, 0.12279890f, -0.07921680f, 0.16905573f, 0.01500502f, 
    0.09350853f, 0.00155502f, -0.05270898f, -0.00253942f, -0.00567225f, 0.04170227f, -0.02454728f, 0.02242991f, 
    -0.26347604f, 0.07058710f, -0.03454519f, -0.01305615f, -0.08078244f, 0.04927790f, 0.01023785f, -0.09862674f, 
    -0.06694806f, 0.00868450f, 0.01771836f, -0.09488234f, -0.07611693f, -0.09780607f, 0.09262970f, -0.03401689f, 
    0.00595068f, 0.04373919f, 0.00651059f, -0.00978201f, -0.01451510f, 0.01509902f, 0.00499790f, -0.06209426f, 
    -0.01463704f, -0.12556022f, -0.04184394f, -0.11180307f, 0.03093642f, -0.03833111f, 0.00022002f, 0.01810165f, 
    -0.03748195f, 0.00932134f, -0.03237639f, -0.05308269f, -0.06107821f, 0.03353989f, -0.03520201f, 0.11144368f, 
    -0.06467018f, -0.03474623f, -0.07763885f, -0.06078426f, -0.14156134f, 0.03875353f, 0.00232414f, 0.00375459f, 
    -0.02303414f, 0.00325657f, -0.02666173f, -0.08227603f, -0.08939191f, -0.02246579f, -0.00779946f, -0.07793929f, 
    0.00486061f, 0.04112069f, 0.04987585f, 0.00271576f, 0.14695244f, 0.13209836f, -0.01206658f, 0.15573333f, 
    0.07801467f, -0.04883549f, 0.09548398f, 0.05984219f, 0.05970770f, 0.00314601f, 0.02463157f, 0.03182095f, 
    -0.22465622f, 0.20878877f, 0.06996218f, -0.02223240f, 0.02000904f, -0.04046409f, -0.03608662f, 0.01598447f, 
    -0.01749897f, 0.07952265f, -0.02842368f, -0.05485249f, 0.03143273f, 0.13821945f, 0.18092635f, 0.12200883f, 
    0.02391462f, 0.07954087f, 0.05933896f, -0.04515843f, 0.05846599f, -0.00052263f, 0.00183673f, 0.00644502f, 
    -0.13358290f, 0.00309714f, -0.15716773f, -0.05920821f, -0.00554988f, -0.04893668f, -0.07417655f, -0.06577152f, 
    -0.05679699f, -0.04954979f, 0.02473298f, -0.07972055f, 0.04348042f, -0.22929861f, -0.07854089f, -0.08503749f, 
    0.09961908f, -0.08452150f, -0.04251124f, -0.05016056f, -0.02180443f, -0.05056985f, -0.04609720f, -0.00567990f, 
    -0.05197264f, -0.11230132f, -0.10301267f, -0.18455599f, -0.02484564f, -0.01608459f, 0.00650908f, -0.06188464f, 
    -0.06914259f, 0.00337955f, -0.02076647f, -0.04553461f, 0.14357178f, -0.02835085f, 0.19583988f, 0.06682996f, 
    0.00486032f, 0.01391427f, -0.04158021f, 0.06629860f, -0.07469565f, 0.04311416f, 0.02360362f, -0.02326433f, 
    0.16016605f, -0.10849359f, 0.02236123f, 0.00059472f, 0.02892856f, -0.01360945f, 0.03952347f, 0.01205325f, 
    0.01163227f, -0.05345124f, 0.03031188f, -0.06564499f, -0.10606162f, -0.03344863f, -0.04923442f, -0.19945309f, 
    0.04066400f, -0.00487053f, -0.04069372f, 0.00965123f, -0.03762313f, 0.03418463f, 0.02595463f, 0.00825591f, 
    0.05727729f, 0.01438515f, -0.09021982f, -0.10017002f, -0.03335458f, -0.06637405f, -0.02579216f, -0.00413285f, 
    -0.03550192f, -0.08388864f, -0.02501097f, -0.02733644f, 0.03103699f, -0.01900699f, -0.11529753f, -0.12547025f, 
    0.01226894f, -0.00848101f, -0.01493984f, -0.00806326f, 0.02379360f, 0.04637709f, -0.07004696f, -0.04558060f, 
    -0.00085590f, -0.15013444f, -0.15577900f, 0.06807608f, 0.02627654f, 0.00120547f, 0.01802059f, -0.03305067f, 
    -0.03734981f, -0.06220262f, 0.06467643f, 0.08393947f, 0.10027616f, -0.24082910f, -0.01045103f, -0.05250183f, 
    0.02338342f, -0.02419120f, 0.04630218f, -0.05496344f, -0.00924127f, -0.06670538f, -0.06838679f, -0.01905949f, 
    0.13075274f, -0.05088355f, -0.11010180f, 0.09830787f, -0.02748149f, -0.16835207f, -0.06852463f, -0.13825852f, 
    0.05655581f, -0.03372813f, -0.04530404f, -0.04760214f, 0.20657702f, -0.08363735f, -0.11116318f, -0.04359275f, 
    -0.12471773f, -0.06557237f, 0.01457285f, -0.02722806f, -0.07419116f, -0.08266000f, -0.01639267f, -0.04996850f, 
    0.08166502f, 0.00659078f, 0.13947520f, 0.08750378f, 0.01787030f, 0.04929862f, 0.03717496f, 0.04431381f, 
    0.01349659f, 0.04416021f, -0.04356588f, 0.03402652f, -0.07581104f, 0.06002766f, 0.07365892f, -0.05783314f, 
    0.02160417f, 0.00672739f, -0.03202868f, -0.05015634f, -0.01919070f, -0.04162976f, -0.07707267f, -0.05904346f, 
    0.13728493f, -0.09915050f, -0.03805791f, 0.01335323f, 0.07256435f, 0.08959384f, 0.02101333f, 0.02290061f, 
    -0.06363917f, -0.01883724f, -0.07255816f, -0.02128720f, -0.11291996f, 0.08145068f, -0.20816951f, -0.05551098f, 
    0.01506859f, -0.05907540f, 0.02371820f, -0.04304446f, -0.06692383f, 0.02138759f, 0.03211088f, -0.01974532f, 
    0.05582902f, 0.03062114f, 0.11200038f, 0.01961864f, -0.08282195f, -0.07201031f, -0.02067633f, -0.10013481f, 
    -0.04138501f, 0.00086003f, -0.02862201f, -0.04338093f, -0.27125800f, 0.05320636f, -0.09554515f, -0.16527714f, 
    -0.02845819f, -0.05470947f, -0.03151343f, -0.04018995f, 0.03276332f, 0.05668116f, -0.05805597f, 0.02745908f, 
    0.11466428f, -0.04459142f, 0.00977654f, -0.02782684f, -0.03571299f, 0.00595171f, -0.03300584f, -0.05525162f, 
    0.03407318f, 0.07313270f, 0.05398553f, -0.00366027f, -0.23509631f, 0.11244543f, -0.02381416f, 0.02623564f, 
    0.06655334f, -0.08352185f, -0.02782756f, -0.04405895f, 0.00606992f, -0.05591706f, -0.02067375f, 0.00366384f, 
    0.17007823f, -0.26937538f, 0.15021586f, -0.01691042f, -0.06983103f, -0.03262962f, 0.00768373f, -0.05473599f, 
    -0.04400800f, 0.06713739f, -0.07107467f, -0.02137263f, 0.05214379f, 0.19694574f, -0.05045953f, 0.17155255f, 
    0.09079815f, -0.10907662f, -0.09297589f, 0.08642894f, 0.00144867f, 0.01742333f, -0.03011999f, -0.01663893f, 
    0.04458753f, 0.13512018f, 0.04041487f, 0.06901494f, -0.06721720f, -0.03326600f, -0.05936703f, -0.04061553f, 
    -0.02455081f, -0.02000112f, -0.06485888f, -0.07100414f, -0.12615064f, 0.06648660f, -0.05428780f, -0.13043204f, 
    -0.04729496f, -0.00699943f, -0.01930177f, -0.04337845f, -0.08068218f, 0.10494847f, -0.03606349f, -0.07981927f, 
    -0.23687400f, 0.09561800f, -0.11069181f, -0.11294585f, 0.02737523f, -0.02012692f, -0.08523127f, -0.01698770f, 
    -0.10906024f, -0.04490566f, -0.00059533f, -0.08282180f, 0.15001523f, 0.13129434f, 0.14852057f, -0.00101082f, 
    -0.17793342f, 0.11584568f, -0.00904023f, -0.00473418f, 0.01172794f, 0.04023836f, 0.02169343f, -0.03269007f, 
    -0.05145726f, -0.06789611f, 0.14943050f, 0.17757657f, 0.02954264f, 0.01465124f, -0.04397706f, 0.10114779f, 
    -0.02969603f, -0.05207802f, -0.03705826f, 0.05568128f, 0.03915631f, 0.02338523f, 0.16770400f, 0.05708623f, 
    0.06640696f, 0.01912146f, -0.03055542f, -0.04728507f, -0.07052068f, 0.03897911f, 0.02844562f, -0.04621860f, 
    -0.08007812f, 0.00957232f, -0.15531300f, -0.16547829f, -0.03081977f, -0.00217725f, -0.02729755f, 0.02049747f, 
    -0.04909129f, -0.06606991f, -0.01516041f, -0.01882901f, 0.18109077f, -0.22060736f, 0.12939440f, 0.21075372f, 
    0.07628331f, -0.02914486f, 0.02582714f, -0.08422045f, -0.06768762f, -0.01128466f, -0.06743281f, 0.04443146f, 
    0.13856199f, 0.09411669f, 0.16135216f, 0.07032976f, 0.08840624f, 0.04630770f, 0.04676695f, -0.04123178f, 
    -0.05388013f, 0.06272902f, -0.02506585f, -0.05132702f, -0.35506546f, 0.08556318f, -0.01614740f, 0.05517760f, 
    -0.11461033f, -0.03445774f, -0.03680308f, -0.03715172f, 0.05263238f, 0.01981916f, -0.05732207f, -0.09093492f, 
    0.29700813f, -0.11407784f, 0.12138712f, 0.06612961f, 0.00108879f, 0.02220923f, 0.02117154f, -0.13527659f, 
    0.04665691f, 0.03978778f, 0.03717808f, -0.15736179f, 0.08090101f, 0.17213430f, -0.10256469f, 0.14624538f, 
    -0.00628357f, -0.03012917f, -0.05267113f, -0.02805455f, 0.02546087f, 0.04852736f, 0.04899522f, -0.13702863f, 
    0.14086208f, 0.15764083f, -0.15384822f, -0.05182084f, 0.02381423f, 0.05257948f, 0.01158393f, -0.06041408f, 
    -0.03136073f, 0.08477651f, 0.07039005f, -0.00334410f, -0.04085383f, 0.16243418f, 0.14620261f, 0.10523999f, 
    0.14315163f, 0.04298779f, 0.04896367f, 0.06163885f, -0.08750901f, 0.05901619f, 0.11160490f, -0.00761216f, 
    0.05133730f, 0.14516897f, 0.01725444f, 0.19640933f, 0.12628803f, 0.09381908f, 0.05590884f, -0.01879912f, 
    -0.00253214f, 0.03056787f, -0.04863898f, -0.08188899f, 0.02961421f, 0.15439285f, 0.02971377f, 0.15191497f, 
    0.01674681f, -0.00129955f, -0.04573267f, 0.00082916f, 0.00896197f, -0.00635835f, -0.02380627f, -0.09264424f, 
    0.03722737f, -0.10302445f, 0.05527030f, -0.19542100f, -0.03361880f, -0.00403891f, -0.01686032f, 0.00876448f, 
    -0.07079214f, -0.00331143f, 0.05788630f, -0.07043391f, -0.23432043f, -0.02021064f, -0.03627250f, -0.03165553f, 
    0.07499292f, -0.04354378f, -0.06021006f, -0.01420902f, 0.03183876f, -0.02878729f, -0.00221340f, -0.06630150f, 
    0.22844101f, -0.03795957f, 0.02615638f, 0.03091663f, 0.04724051f, 0.00743307f, -0.04516564f, -0.10374142f, 
    -0.03254190f, -0.02886017f, 0.00516069f, -0.01959107f, -0.18609393f, 0.16726251f, 0.02460281f, -0.20400372f, 
    -0.07345279f, 0.00671902f, -0.05091385f, -0.06292055f, -0.02942656f, -0.07954311f, 0.02561564f, -0.07207452f, 
    0.04984373f, -0.31845641f, -0.22184138f, -0.01215630f, -0.06897234f, -0.00302998f, -0.09988844f, 0.00805060f, 
    -0.09788975f, -0.03455655f, -0.02096049f, -0.02375906f, 0.19649404f, -0.03429090f, 0.11064551f, 0.18559748f, 
    0.08104625f, 0.02144654f, -0.03905087f, 0.02829782f, -0.01819035f, -0.08196451f, -0.08615418f, -0.05088499f, 
    0.09058360f, 0.06389015f, 0.11102236f, 0.04674864f, -0.05276036f, -0.11720810f, 0.00615418f, -0.03617691f, 
    -0.02016441f, 0.04324724f, -0.00419141f, -0.06776374f, 0.19329144f, -0.15756269f, 0.11596531f, 0.01733460f, 
    0.06792564f, 0.03118468f, -0.00922293f, -0.02778155f, -0.09787554f, -0.05535880f, 0.01653158f, -0.03312283f, 
    -0.15491329f, 0.02059548f, -0.05813546f, -0.08768197f, 0.00533501f, 0.00708976f, 0.02949357f, -0.07004830f, 
    -0.03250763f, 0.00879977f, 0.04911955f, -0.11950448f, 0.10899144f, 0.08761220f, -0.02769783f, 0.10754190f, 
    0.14238305f, -0.05010764f, 0.00071973f, 0.03942815f, -0.00405957f, 0.04591384f, -0.04454760f, -0.09935833f, 
    0.28695384f, -0.01254219f, 0.17530289f, 0.06110810f, -0.01566678f, 0.03183013f, 0.01376513f, 0.01203413f, 
    -0.07297421f, 0.08856035f, 0.05567710f, -0.05085839f, -0.16799679f, -0.11031649f, -0.12639485f, -0.01166189f, 
    -0.07072036f, -0.09804003f, -0.05563296f, 0.03464632f, -0.07436199f, 0.02456895f, -0.00822564f, 0.00261738f, 
    0.17829977f, -0.04425759f, 0.12504590f, 0.11494496f, 0.08760593f, 0.03498314f, -0.05414604f, -0.06089998f, 
    -0.13099515f, -0.11547729f, 0.06575783f, -0.05645346f, 0.05948965f, 0.02143976f, -0.13333161f, -0.09204128f, 
    -0.07040010f, -0.08812101f, -0.04168505f, 0.00574796f, -0.08575010f, -0.06165573f, 0.02105897f, -0.04073493f, 
    -0.23159404f, -0.01636481f, -0.03063939f, -0.13712724f, -0.00463315f, 0.05971802f, -0.02488505f, -0.08232571f, 
    -0.07177382f, -0.03401052f, -0.01492953f, -0.01885941f, -0.12937938f, -0.02112124f, -0.18208323f, -0.09846732f, 
    -0.00082348f, 0.05256301f, -0.02167956f, -0.02303542f, -0.03931372f, 0.02642025f, -0.01864303f, -0.07147856f, 
    0.10266717f, 0.04287193f, -0.18652661f, 0.02228019f, -0.01586805f, 0.01590569f, -0.16170532f, -0.03203680f, 
    -0.04735624f, 0.04970645f, -0.05758383f, 0.03276927f, -0.32397169f, -0.05580882f, 0.02791758f, -0.19366664f, 
    0.00589018f, 0.06412994f, 0.07644562f, -0.12463828f, 0.03057874f, 0.09399785f, -0.10279063f, 0.14316553f, 
    0.02486602f, -0.01264413f, 0.16256638f, 0.14046177f, -0.09254678f, -0.06178482f, 0.02664832f, 0.01606755f, 
    0.01625239f, 0.04587093f, 0.10568729f, 0.12742531f, -0.12054234f, -0.15751781f, 0.16029476f, -0.00807501f, 
    -0.10418703f, 0.04722482f, 0.01672586f, -0.13226847f, -0.07886465f, 0.08276787f, 0.02494490f, -0.02365898f, 
    -0.09786793f, 0.11933239f, -0.04347460f, -0.03782649f, 0.07916090f, 0.02865491f, -0.10599411f, 0.04978198f, 
    0.15451671f, -0.06385239f, -0.10091455f, -0.11441236f, -0.15070358f, -0.02633796f, 0.00301110f, -0.23912229f, 
    -0.10245372f, 0.08700561f, 0.08478492f, 0.07324556f, 0.09302912f, -0.06606447f, 0.02455110f, 0.02732542f, 
    0.21178544f, 0.16511393f, 0.05050537f, 0.12397927f, 0.03033591f, 0.02299412f, -0.04423244f, -0.12424245f, 
    -0.03198065f, 0.01655670f, 0.01955890f, -0.04258777f, 0.02830076f, -0.06567005f, 0.06129695f, -0.02191135f, 
    -0.03006967f, -0.16269930f, 0.03596224f, -0.05691632f, -0.01618285f, -0.07765562f, -0.10628516f, -0.15722245f, 
    0.17205399f, -0.13893162f, 0.18551697f, 0.07977699f, -0.11040794f, -0.05304776f, -0.11928858f, -0.04439963f, 
    -0.02573531f, -0.13066430f, -0.00653340f, -0.03736513f, -0.13900360f, -0.00612201f, 0.20477401f, 0.00806824f, 
    0.02981860f, 0.06264206f, -0.04648356f, -0.01836159f, -0.00189994f, 0.01962710f, 0.05409798f, -0.10008158f, 
    -0.09725178f, -0.14776921f, 0.06421060f, 0.04159082f, 0.14225191f, 0.02744653f, -0.02052622f, -0.01948386f, 
    -0.01833260f, -0.08474212f, 0.11566423f, -0.02447988f, 0.03976440f, -0.13100311f, -0.22140437f, -0.01294947f, 
    0.01550986f, 0.01808420f, 0.00123459f, 0.03778027f, 0.01117997f, -0.00460253f, 0.16334838f, 0.01982552f, 
    0.03347178f, -0.08008109f, -0.11141306f, 0.03953833f, 0.05476401f, 0.03283213f, -0.03142622f, 0.03816349f, 
    0.06538007f, -0.05535229f, 0.13258292f, -0.11453252f, -0.08909196f, 0.00807713f, 0.01807389f, -0.13142776f, 
    -0.08754894f, -0.10563233f, -0.03991599f, -0.14678508f, -0.01018446f, -0.07905114f, 0.02729592f, -0.07169814f, 
    0.12363592f, -0.08487180f, -0.06613033f, -0.06259235f, -0.00491793f, -0.03240933f, 0.13451985f, -0.00486270f, 
    0.09111338f, 0.06565392f, -0.04449870f, 0.10063519f, 0.12971833f, -0.12153835f, 0.05272450f, 0.06061035f, 
    -0.09623248f, 0.00516724f, -0.01369215f, -0.02906533f, 0.01955792f, -0.02683622f, 0.03342799f, -0.11193142f, 
    0.05173268f, 0.12797631f, 0.09682903f, 0.03702826f, 0.05585103f, -0.03837560f, -0.07902452f, -0.09530172f, 
    -0.04982274f, -0.00606274f, 0.06740836f, -0.03422906f, 0.15255876f, -0.14110035f, -0.05535118f, 0.06185846f, 
    0.06929630f, -0.04984054f, -0.00975069f, -0.08214493f, 0.08823027f, 0.01428368f, 0.03068493f, -0.14567660f, 
    -0.02699432f, -0.00447844f, -0.09790275f, 0.02796393f, -0.05237923f, 0.00451017f, -0.03034951f, 0.03204776f, 
    0.02391367f, 0.06354904f, 0.01971299f, -0.04525666f, 0.18690483f, 0.10960273f, -0.29016978f, 0.09514155f, 
    0.10138138f, 0.07704625f, -0.01824734f, -0.08418290f, -0.07113012f, -0.03903558f, 0.10167349f, 0.06128537f, 
    -0.04867868f, -0.21574838f, -0.15553804f, -0.28166676f, -0.11648691f, -0.15239042f, -0.00504202f, 0.00435272f, 
    -0.01221275f, 0.02871666f, 0.09480456f, -0.16200410f, 0.06488805f, -0.20472603f, -0.10175546f, -0.07688377f, 
    0.06341324f, 0.01317107f, -0.07787382f, -0.07122314f, -0.08305807f, -0.03044040f, 0.13137293f, -0.03024695f, 
    -0.12120358f, 0.05105196f, 0.03133206f, 0.13980252f, -0.07089129f, -0.03290403f, -0.05581545f, -0.01981861f, 
    0.06278542f, 0.02529210f, -0.01741901f, 0.13610469f, 0.23215826f, -0.01317662f, -0.01414040f, 0.13101257f, 
    -0.12601177f, -0.07219663f, -0.05768239f, 0.00523391f, -0.02402226f, 0.03183437f, -0.09754390f, -0.06085370f, 
    0.09228253f, -0.02213973f, -0.15074405f, 0.03842923f, 0.06296123f, -0.05397592f, 0.02439250f, -0.04281097f, 
    -0.03914485f, -0.00368012f, -0.03105081f, -0.12862042f, -0.02178322f, -0.03237646f, -0.10605343f, -0.05034094f, 
    0.01308572f, -0.02267143f, -0.04651285f, -0.00400292f, 0.06116595f, 0.02286434f, 0.10345031f, -0.05425086f, 
    -0.09150369f, 0.14211728f, 0.05486353f, -0.14600363f, -0.05023045f, 0.01384313f, -0.07378801f, -0.06848535f, 
    -0.02259670f, 0.08113927f, 0.05022379f, 0.06204426f, 0.00822350f, -0.01019028f, 0.06429641f, 0.17263839f, 
    0.09145728f, 0.01323662f, -0.01068009f, 0.01440549f, 0.04311921f, 0.00623599f, 0.03731652f, 0.05458125f, 
    -0.02905405f, -0.23069564f, 0.00247739f, -0.17143008f, 0.04820322f, 0.01437374f, 0.00425665f, 0.05733193f, 
    -0.11272551f, 0.05661395f, 0.10751324f, 0.03339501f, -0.16102238f, -0.00864295f, -0.01247677f, -0.08513901f, 
    0.06149856f, 0.08570454f, -0.18153825f, -0.05445074f, 0.06550662f, -0.05984886f, 0.10429179f, -0.03168715f, 
    0.04950216f, -0.21539423f, 0.12875609f, -0.11908802f, -0.07633869f, 0.06706617f, 0.00165080f, -0.03170719f, 
    0.03601142f, 0.05210649f, -0.02636894f, 0.06324587f, -0.12262952f, 0.31550840f, -0.30727962f, -0.15715021f, 
    -0.06633698f, -0.08770938f, -0.08265296f, 0.04742940f, 0.07766046f, -0.07402822f, 0.06598304f, -0.01114310f, 
    -0.18446985f, -0.06204637f, -0.08337497f, -0.03313914f, -0.08090964f, -0.07391863f, 0.02920492f, -0.08216054f, 
    0.12599361f, -0.19259989f, -0.05841907f, 0.04848375f, 0.19775403f, -0.10378502f, 0.05396957f, 0.15591769f, 
    0.10828619f, 0.04854107f, -0.00774520f, -0.05189924f, -0.05687464f, -0.01155904f, 0.09436006f, -0.12329315f, 
    -0.08786216f, -0.10415405f, -0.01416840f, 0.11421694f, 0.12499054f, -0.04303147f, -0.01660784f, -0.02709348f, 
    0.00664908f, 0.05571698f, -0.07063667f, -0.02472285f, -0.05977851f, -0.01083697f, 0.13404574f, -0.15704571f, 
    -0.07871716f, -0.10692278f, -0.07362629f, 0.09517969f, -0.05579466f, 0.00488339f, -0.01766846f, 0.00978353f, 
    -0.00014962f, 0.12414038f, 0.06847084f, 0.12744120f, 0.07821587f, 0.05023094f, -0.08851628f, -0.00949838f, 
    -0.01192835f, -0.04555061f, 0.01869626f, -0.00953669f, -0.04604253f, -0.32342616f, 0.04612793f, -0.04835164f, 
    -0.04715817f, -0.06428684f, -0.02037945f, -0.14583790f, 0.03412491f, -0.02568050f, -0.06979398f, 0.03031198f, 
    -0.00080015f, -0.09531114f, -0.00990994f, 0.08209717f, 0.02211440f, 0.07841912f, -0.04198206f, -0.04345179f, 
    -0.00028886f, 0.02638608f, 0.08494262f, -0.05214468f, 0.04176415f, -0.03775054f, -0.03144107f, -0.08613162f, 
    0.08563559f, -0.05058798f, -0.04564425f, -0.06936058f, 0.00796023f, 0.05808182f, 0.03551269f, -0.01481297f, 
    -0.21878295f, 0.03194870f, 0.13158956f, 0.06844944f, -0.20618726f, 0.09345806f, -0.13174681f, -0.06934246f, 
    0.05099953f, 0.01395069f, -0.02064499f, -0.02158684f, 0.04646294f, -0.02209372f, 0.00877906f, 0.10185198f, 
    0.09351510f, 0.06571747f, 0.06097418f, -0.09486774f, -0.01847157f, -0.06223646f, 0.04557489f, 0.08801530f, 
    -0.02690691f, -0.10527360f, 0.02457581f, 0.02431016f, 0.05331347f, -0.26566127f, -0.04989445f, 0.04209769f, 
    0.01284086f, 0.08248692f, -0.03151109f, -0.01198472f, 0.02013048f, 0.29115605f, -0.10962483f, 0.02484513f, 
    0.00129309f, 0.03728145f, -0.04489313f, 0.10725358f, 0.08581791f, 0.02925538f, -0.07048229f, -0.03876486f, 
    -0.01010425f, 0.03036289f, 0.01820490f, 0.02501946f, 0.00209588f, 0.00810545f, -0.09618606f, 0.00301067f, 
    -0.07088790f, 0.01828706f, 0.04348999f, -0.02014059f, -0.04469923f, -0.04382702f, 0.16214046f, 0.05316908f, 
    -0.15866159f, 0.07137981f, 0.00541679f, -0.04679013f, -0.08763968f, 0.01866137f, -0.01297736f, 0.00383683f, 
    -0.14473005f, -0.00693408f, 0.11655089f, -0.11059617f, 0.00102393f, 0.08256771f, -0.07805573f, -0.00897914f, 
    -0.02591340f, -0.06673965f, -0.00535542f, -0.04786050f, -0.05803487f, 0.23826191f, -0.00760726f, -0.16863519f, 
    -0.12218703f, -0.08264518f, -0.00571168f, 0.01223318f, -0.01039689f, 0.02065972f, 0.06532787f, 0.12378469f, 
    -0.27255359f, -0.20566350f, 0.06287286f, -0.01610104f, -0.02941480f, -0.02659682f, 0.04934121f, 0.06550092f, 
    -0.08230960f, 0.07926141f, -0.05903996f, 0.14767906f, 0.11948899f, 0.09453014f, -0.16242623f, -0.13131738f, 
    0.04338823f, -0.02192255f, 0.02281966f, 0.04988431f, 0.04061479f, -0.10953832f, -0.02333564f, 0.16918081f, 
    0.10895006f, -0.21990336f, 0.07647007f, -0.16348037f, -0.00835024f, -0.11387023f, 0.01126780f, -0.00847645f, 
    -0.03311799f, -0.02436033f, 0.00852737f, 0.09753735f, 0.10772073f, 0.01201725f, 0.00606498f, 0.18700705f, 
    0.00960614f, -0.13175128f, -0.04954710f, 0.07041403f, 0.08878306f, -0.07690725f, -0.12035646f, -0.06930411f, 
    0.18355007f, -0.07000224f, -0.26330382f, -0.13331787f, 0.01502063f, 0.02490098f, 0.01482402f, -0.09168985f, 
    0.07965764f, 0.09383819f, -0.03503507f, 0.03568096f, -0.10996582f, -0.27421394f, 0.13905640f, -0.12744454f, 
    0.11789915f, 0.04261482f, -0.09682914f, -0.05822942f, -0.02447957f, -0.02189823f, 0.07478683f, 0.08528649f, 
    0.03808645f, 0.00045991f, -0.32307491f, -0.11118397f, -0.05499512f, -0.04657639f, 0.08395123f, -0.00984213f, 
    0.00077623f, -0.17095606f, 0.00248653f, 0.03018058f, -0.10148225f, -0.13920644f, -0.14565465f, -0.00013623f, 
    -0.00746703f, -0.02786580f, 0.06117443f, -0.02493018f, 0.12525529f, 0.03285959f, 0.03370550f, 0.11745013f, 
    -0.05811836f, -0.21374129f, 0.14316970f, 0.13025664f, 0.11873867f, 0.00925338f, -0.09685799f, -0.03858611f, 
    -0.08831307f, 0.11274005f, -0.00830707f, -0.06828985f, 0.09510367f, -0.08575584f, 0.04771619f, -0.02227353f, 
    0.12379193f, -0.06574930f, -0.02774657f, 0.03486329f, 0.15591457f, 0.03734404f, 0.10812030f, -0.01721678f, 
    -0.12326815f, -0.12301540f, -0.01580380f, -0.20692042f, -0.02106771f, -0.05124861f, 0.13320133f, -0.10110742f, 
    0.06364992f, -0.08271514f, -0.21250142f, -0.01548914f, 0.10691274f, 0.18000765f, -0.23991394f, -0.00470440f, 
    0.00978197f, -0.01406902f, -0.08174501f, -0.02987158f, 0.01715006f, -0.01784374f, -0.01305356f, 0.00587584f, 
    -0.06496451f, -0.09796448f, -0.01245847f, -0.20309095f, 0.03590338f, -0.07975985f, 0.06420375f, 0.00416666f, 
    -0.02721052f, 0.00201380f, -0.10123786f, 0.00701864f, -0.02612961f, -0.02176231f, -0.18153746f, -0.20153847f, 
    0.10098204f, -0.05339265f, 0.08629803f, 0.01352242f, 0.09671960f, 0.01680371f, 0.16709149f, 0.07378259f, 
    0.09180751f, -0.05442016f, 0.10501020f, 0.16837560f, 0.11708013f, 0.00592822f, -0.06944078f, -0.00709454f, 
    -0.10018872f, 0.00005463f, 0.18708768f, -0.20946248f, 0.11238252f, 0.11721239f, 0.02754282f, 0.09420174f, 
    0.09504873f, 0.05133105f, 0.00070850f, -0.03206275f, -0.02995057f, -0.02073693f, -0.12141385f, 0.03926543f, 
    -0.05913479f, 0.08017658f, 0.08236893f, 0.08964616f, 0.01439918f, 0.03902676f, 0.18189906f, -0.04105286f, 
    0.10383956f, 0.03608973f, 0.01467451f, 0.04742632f, 0.02929314f, -0.26332945f, -0.30221871f, 0.40843132f, 
    -0.09775541f, -0.02999293f, -0.03984675f, 0.13663858f, 0.01336415f, -0.00150883f, -0.02659803f, 0.07104846f, 
    -0.09651881f, 0.43301874f, -0.10644884f, -0.01755944f, 0.09991573f, 0.01093089f, 0.00844403f, -0.05162041f, 
    -0.10920305f, 0.05161185f, -0.03697400f, 0.03124713f, 0.27586952f, -0.03413402f, -0.08159096f, 0.14502080f, 
    0.04656059f, -0.07642999f, 0.08096071f, 0.04024168f, -0.03130740f, -0.17059100f, -0.01122335f, -0.03479513f, 
    0.27623403f, 0.08940249f, -0.11515195f, 0.00541719f, 0.07444917f, -0.01151997f, 0.01576025f, -0.02772230f, 
    0.06482221f, 0.13675922f, -0.06235798f, 0.16585179f, -0.08192982f, 0.08691903f, 0.02400247f, -0.04488673f, 
    -0.03100570f, 0.02153188f, 0.00575961f, -0.12351955f, 0.00366935f, -0.08457955f, 0.06336786f, 0.03629428f, 
    0.02097390f, 0.01025604f, -0.13320132f, -0.05017194f, 0.07639843f, 0.05469256f, -0.12069301f, -0.02928858f, 
    -0.06987475f, 0.05176570f, -0.03305316f, -0.04971498f, -0.24296638f, -0.06862412f, 0.06658293f, -0.04832343f, 
    0.09995373f, -0.09024919f, -0.06943052f, 0.05764346f, 0.06208413f, -0.06015379f, 0.13932160f, 0.00351701f, 
    -0.36283806f, -0.13993599f, -0.04239232f, -0.06115478f, 0.06337608f, -0.03521568f, -0.05443690f, 0.05139166f, 
    0.09548745f, 0.15073512f, -0.08731146f, 0.10935774f, 0.03511861f, -0.22304109f, 0.01127834f, -0.01858715f, 
    0.04360074f, -0.10839864f, 0.01234198f, -0.03328273f, -0.02637332f, 0.12126061f, -0.10389397f, -0.00991465f, 
    -0.17950103f, 0.00353526f, 0.07213528f, -0.16819900f, -0.01743493f, -0.16903281f, 0.02548269f, 0.05997467f, 
    -0.04382355f, 0.03431819f, -0.03613845f, -0.02740068f, 0.02381762f, -0.01733373f, 0.19309543f, -0.10791174f, 
    0.08409122f, 0.00048582f, -0.05219060f, -0.13478771f, -0.18925826f, -0.03456111f, -0.11866973f, -0.06437224f, 
    -0.22465460f, 0.19017214f, -0.01888509f, -0.33580139f, 0.00636031f, -0.03128860f, 0.00035532f, 0.01811601f, 
    -0.07118713f, 0.05992217f, -0.04942064f, 0.00515125f, 0.22086588f, -0.21051496f, -0.09595040f, 0.20504418f, 
    0.01532879f, 0.06709887f, -0.09463868f, -0.00282716f, -0.14848550f, 0.02358785f, -0.05728694f, -0.06001932f, 
    0.11437486f, 0.16367365f, -0.06104000f, 0.05176789f, 0.10261157f, -0.02287831f, 0.00393122f, -0.04251824f, 
    -0.10893427f, 0.04781784f, 0.03657819f, 0.12062140f, 0.03073006f, 0.03543671f, -0.03613354f, -0.07757409f, 
    0.04301348f, -0.04091937f, 0.07227021f, 0.02150900f, 0.06144704f, -0.00088513f, 0.03391854f, 0.08371184f, 
    0.53091180f, 0.06156056f, -0.19261174f, -0.34780282f, -0.00063327f, -0.03534243f, 0.07048614f, 0.13601589f, 
    -0.01670115f, -0.00007885f, -0.11175237f, 0.04280076f, -0.09070767f, 0.07546140f, 0.11857307f, -0.01285632f, 
    0.03259514f, 0.10639165f, 0.01120135f, -0.08557948f, 0.02596692f, -0.01423474f, 0.00293864f, -0.08102460f, 
    0.00066418f, -0.08690857f, -0.08187933f, 0.09140473f, -0.04138492f, 0.07119063f, -0.10163891f, -0.01119705f, 
    -0.04970083f, 0.03410220f, 0.06922197f, 0.03362874f, 0.08958421f, -0.10470235f, 0.14391540f, -0.05469318f, 
    0.01989515f, 0.03636904f, -0.02493647f, -0.05263181f, -0.08395009f, 0.11676922f, 0.00535385f, -0.05121156f, 
    -0.03483437f, 0.05861148f, -0.03694070f, -0.19961864f, 0.06600449f, 0.04476211f, 0.09139609f, 0.05912926f, 
    0.02820916f, 0.00187383f, -0.18789114f, 0.03190573f, -0.04257046f, 0.03137061f, 0.01674193f, -0.16477939f, 
    -0.04879876f, -0.00507027f, -0.06387930f, -0.04317657f, -0.02178639f, -0.01184716f, -0.03766472f, 0.14118683f, 
    0.13981925f, -0.22779070f, -0.07080898f, 0.02096802f, -0.05859076f, -0.01941225f, 0.06487025f, 0.10237712f, 
    -0.06232326f, -0.03341471f, -0.02189394f, -0.03257444f, -0.01853921f, 0.16250172f, -0.13426283f, 0.00842705f, 
    0.16084081f, -0.02999619f, -0.01257077f, 0.00763811f, -0.16092129f, -0.02983262f, 0.03157549f, 0.01135483f, 
    0.32442757f, -0.13196433f, 0.14719340f, -0.10365742f, -0.02192710f, 0.14946604f, 0.02709277f, -0.05536555f, 
    0.08905999f, 0.02949653f, -0.01054929f, 0.07653002f, -0.01435954f, 0.09223802f, -0.00241480f, -0.29936039f, 
    -0.04638779f, 0.05955020f, -0.07648784f, 0.06872939f, -0.15285027f, -0.02027139f, -0.06880494f, -0.02931543f, 
    -0.11217263f, -0.33518681f, 0.04051282f, -0.07295915f, 0.01118232f, 0.00323353f, 0.02931959f, -0.13263974f, 
    -0.00354116f, -0.05056849f, -0.11461864f, -0.02332478f, -0.08491056f, 0.12440606f, -0.20570241f, -0.27007669f, 
    0.01906392f, 0.04025602f, 0.00823461f, 0.06058089f, -0.00408130f, -0.00695213f, -0.02550976f, -0.12442004f, 
    0.02492224f, 0.02070863f, -0.02500004f, -0.10013381f, -0.18015866f, 0.02037850f, 0.02321582f, 0.01257293f, 
    -0.08129003f, 0.18410546f, -0.36815244f, -0.02326157f, -0.22307013f, 0.01190410f, 0.08696409f, -0.16384523f, 
    -0.16969818f, -0.04004257f, -0.00339318f, 0.11188421f, -0.11539365f, -0.04998850f, -0.08859924f, -0.05719911f, 
    0.07660067f, 0.06187497f, -0.14434363f, 0.06061611f, -0.03062193f, -0.04580408f, 0.14591494f, -0.04093026f, 
    0.03018080f, 0.02017266f, -0.03190241f, -0.07222767f, -0.19410761f, -0.04204880f, 0.31744105f, -0.14998588f, 
    -0.01402985f, 0.05006385f, -0.07731305f, 0.06233048f, 0.08941808f, -0.07076384f, 0.05900839f, 0.03480891f, 
    -0.36639267f, 0.02970277f, -0.27136183f, -0.12790270f, -0.00397524f, -0.07201283f, 0.07000033f, 0.05023873f, 
    -0.04856558f, 0.04209243f, 0.01792442f, 0.03545371f, -0.37773451f, 0.23688051f, -0.10397620f, -0.16615269f, 
    -0.00769575f, -0.00795731f, -0.00033459f, -0.09572291f, -0.03824368f, 0.01183555f, -0.02007824f, -0.01915530f, 
    -0.30395648f, 0.27753854f, -0.03152050f, -0.04282275f, 0.07099046f, -0.01153533f, 0.01864600f, -0.11242507f, 
    0.06681067f, -0.07316260f, 0.11520735f, 0.02646688f, -0.12691608f, 0.03892134f, 0.03630817f, 0.23245023f, 
    -0.03208319f, -0.01228329f, -0.07129494f, -0.03228035f, -0.01575893f, 0.01365269f, 0.02260640f, -0.08177924f, 
    0.25381023f, -0.27242568f, 0.03913782f, 0.16905455f, -0.03384551f, -0.08598838f, -0.07382732f, 0.04011902f, 
    -0.07777607f, 0.12255732f, 0.08042384f, 0.07033504f, 0.01367000f, -0.13769880f, 0.03260494f, 0.16591397f, 
    -0.01604358f, -0.06754676f, -0.01932320f, -0.00307341f, 0.04452300f, 0.13417108f, 0.14003687f, 0.01654832f, 
    0.04370913f, -0.17725807f, 0.01868661f, -0.05684879f, 0.02334444f, 0.13735180f, -0.00591340f, -0.03110750f, 
    -0.12082626f, -0.05548147f, -0.07357066f, -0.04549370f, 0.31043872f, -0.38555238f, 0.06474959f, 0.01723414f, 
    -0.00071756f, 0.06511714f, 0.05082763f, 0.07919267f, -0.15089248f, 0.01545127f, 0.08962676f, 0.03123293f, 
    0.03327839f, -0.34829646f, -0.13048664f, -0.02788652f, 0.00735448f, 0.02807178f, -0.03508566f, 0.12877260f, 
    -0.21054241f, -0.00088126f, -0.01862245f, -0.06114555f, -0.55749071f, 0.20639041f, -0.22489430f, -0.18729752f, 
    0.07438265f, -0.02796841f, 0.04861895f, 0.02110679f, -0.04667612f, 0.01444358f, -0.15678766f, -0.09638839f, 
    0.19980183f, 0.05090016f, -0.00867482f, 0.21820219f, 0.05444319f, -0.04659637f, -0.01968659f, -0.01369347f, 
    0.00109135f, 0.04259409f, -0.01014071f, 0.03993896f, -0.02664616f, 0.16301496f, 0.27273872f, 0.01560760f, 
    -0.02321698f, 0.02068430f, 0.06913948f, 0.11200825f, 0.07359464f, -0.00349235f, 0.13122064f, 0.01755209f, 
    -0.08754887f, 0.27390379f, 0.03950357f, -0.09417996f, -0.19846109f, 0.08199699f, -0.15812354f, 0.07524510f, 
    0.00178180f, 0.09668730f, -0.03334069f, -0.02839068f, -0.11360299f, -0.14271206f, 0.04595391f, 0.06873669f, 
    0.16571076f, 0.01434530f, 0.05396289f, -0.08033522f, 0.01408502f, -0.04073459f, 0.00158872f, 0.10269374f, 
    -0.18584241f, -0.03580318f, 0.12729762f, -0.21255378f, 0.08330083f, -0.08483637f, -0.01509511f, 0.08272912f, 
    0.01583639f, -0.04893949f, 0.05890418f, 0.04105909f, -0.04306942f, 0.00409630f, 0.19222613f, 0.02125809f, 
    0.05703625f, -0.03757185f, -0.06125027f, -0.12986411f, -0.09864020f, 0.00363105f, -0.08302550f, -0.04800262f, 
    0.30465937f, 0.08985111f, -0.21071033f, 0.24107346f, -0.13931641f, -0.05267857f, 0.06098577f, -0.01946262f, 
    -0.02870626f, -0.06381935f, 0.02914396f, -0.07456245f, 0.31402278f, -0.05908354f, 0.30116314f, 0.04676120f, 
    0.05820812f, -0.03004129f, 0.07841048f, -0.05821471f, 0.00998788f, -0.01719281f, -0.01275142f, -0.04366245f, 
    0.16450316f, 0.22694220f, -0.06043178f, -0.05624380f, -0.05775850f, -0.07989047f, -0.02326018f, 0.01262733f, 
    0.05195553f, 0.08256831f, 0.04404810f, -0.05426992f, -0.12887773f, 0.16859350f, -0.10885465f, 0.00311431f, 
    0.09461235f, 0.04408052f, -0.07240705f, -0.06239472f, -0.08885977f, 0.00015318f, 0.04909397f, -0.00611165f, 
    0.06893650f, -0.06188586f, 0.13253671f, 0.04614204f, -0.00121755f, 0.02419728f, 0.00074245f, 0.01579167f, 
    -0.00881795f, 0.01995991f, -0.05249337f, 0.13463585f, 0.05244896f, -0.22359917f, -0.15456606f, 0.06146362f, 
    0.00846632f, 0.01573529f, 0.04967247f, 0.03167599f, 0.11431757f, 0.10897752f, 0.02958651f, -0.03441939f, 
    -0.13654548f, 0.00600152f, -0.03466766f, 0.07322758f, 0.02701242f, 0.01705370f, -0.04485910f, 0.01708091f, 
    -0.17172757f, 0.09564319f, 0.08627775f, 0.03332320f, -0.01309908f, -0.23822553f, 0.24430843f, -0.13688645f, 
    0.03374156f, 0.02017726f, -0.05139914f, 0.02632795f, 0.11865235f, -0.15564394f, -0.02272163f, -0.15141979f, 
    -0.02019689f, -0.05369783f, -0.03839057f, -0.24265826f, 0.04041866f, 0.00456436f, -0.12857184f, 0.06659647f, 
    0.09360589f, -0.03865466f, 0.13598859f, 0.03303228f, -0.31915545f, -0.25728017f, 0.13051493f, -0.18210867f, 
    0.05897257f, -0.05268419f, -0.11630356f, -0.10335514f, 0.00821813f, -0.01695605f, 0.11770188f, 0.06156486f, 
    0.04264721f, 0.01978264f, -0.12129734f, 0.10216959f, -0.11695557f, 0.00858757f, -0.00690245f, 0.04638401f, 
    -0.08733849f, -0.02729601f, 0.11336339f, 0.05043220f, 0.21715601f, 0.07029980f, 0.07298194f, -0.01172138f, 
    -0.07011428f, 0.00546928f, 0.06962146f, 0.00626279f, -0.05648706f, 0.08565450f, 0.09077942f, 0.05928117f, 
    0.15924537f, -0.26226422f, 0.03340710f, 0.09688120f, -0.04285954f, 0.08338398f, -0.04060637f, 0.02714278f, 
    -0.02882446f, -0.03702396f, 0.08769447f, -0.03579975f, -0.47268033f, 0.09229688f, 0.01912694f, -0.23748052f, 
    -0.17028847f, 0.06165694f, 0.05156900f, -0.15306172f, 0.00356015f, 0.03373860f, 0.01700451f, 0.07951503f, 
    -0.02714565f, -0.03363379f, -0.01844305f, -0.09745052f, 0.03426626f, -0.05000913f, -0.02321031f, -0.06191861f, 
    0.15408820f, 0.04573666f, -0.13360317f, -0.02278168f, 0.14358735f, 0.18965594f, 0.17065844f, -0.15594070f, 
    0.09916543f, 0.11351176f, -0.11609539f, -0.05536507f, 0.01844152f, -0.03280355f, -0.11824355f, -0.12099493f, 
    -0.35634688f, -0.15474777f, -0.08643003f, -0.03976649f, 0.11776131f, 0.04532202f, 0.00666491f, -0.07380799f, 
    0.00299089f, -0.13695687f, 0.00090852f, 0.04102448f, 0.21366744f, -0.08878273f, -0.04306309f, 0.09599635f, 
    -0.08151352f, 0.02774266f, -0.06023102f, -0.00178580f, 0.05544123f, 0.01648549f, -0.12088210f, 0.05272115f, 
    -0.33225015f, -0.30020735f, -0.03700556f, -0.03839868f, 0.07940801f, -0.03547386f, -0.00738287f, 0.05298037f, 
    0.06610723f, 0.11238271f, 0.06545684f, 0.07814517f, 0.22832936f, 0.09108152f, -0.03393720f, 0.01966611f, 
    -0.10397705f, 0.00141986f, -0.00172154f, -0.00192395f, -0.06147280f, 0.06504371f, 0.00302628f, -0.00233846f, 
    0.05132128f, 0.12479736f, 0.04157796f, 0.07197534f, -0.03683299f, 0.03796538f, 0.04931509f, 0.10317124f, 
    -0.01080794f, -0.04542372f, 0.00860832f, -0.01334392f, 0.20908181f, 0.05248107f, 0.17587425f, 0.07951514f, 
    0.13016924f, 0.18919034f, 0.09106807f, 0.03123944f, 0.05389872f, 0.03038315f, -0.01451927f, -0.00125502f, 
    -0.27144572f, -0.19355823f, -0.08837740f, -0.24663697f, 0.01847105f, 0.07822307f, -0.07305379f, -0.00754167f, 
    -0.01642474f, 0.06926802f, -0.04382847f, 0.04907839f, 0.11948974f, 0.01936562f, 0.04207714f, -0.11967333f, 
    -0.24963552f, -0.02231141f, 0.09482470f, -0.06017267f, 0.05817118f, 0.07665101f, -0.32670963f, -0.18846212f, 
    0.21838006f, 0.10571080f, -0.02620456f, 0.08948185f, -0.05284600f, -0.06250805f, 0.10557352f, 0.06203657f, 
    0.07940264f, -0.01253698f, 0.02429589f, 0.08214883f, 0.19530740f, 0.00664799f, -0.05888079f, -0.07906124f, 
    -0.09280307f, 0.07451813f, -0.01931598f, 0.06466337f, 0.04695079f, 0.11973155f, -0.03008748f, -0.00463904f, 
    -0.16369240f, 0.01840507f, -0.00190911f, -0.09676496f, 0.12625858f, -0.02022838f, 0.00397371f, 0.02368365f, 
    -0.08282308f, -0.05719294f, 0.07049730f, 0.05680686f, -0.27681884f, 0.13230515f, 0.06480412f, -0.06459543f, 
    0.07753344f, 0.05198854f, -0.12122241f, 0.02299763f, 0.07467139f, 0.12163974f, 0.00623435f, 0.05197428f, 
    -0.08907884f, -0.10307119f, -0.00644684f, -0.08625435f, -0.03311253f, -0.07445469f, -0.04568867f, 0.03948046f, 
    0.02436182f, 0.10874704f, 0.10864118f, -0.11090505f, 0.25163069f, -0.05883635f, -0.06230063f, 0.10255499f, 
    -0.17252858f, -0.06470453f, -0.06854524f, -0.00503194f, -0.02127590f, 0.04636311f, -0.02627337f, -0.05565061f, 
    -0.17679852f, -0.03098728f, -0.11725458f, 0.09526731f, 0.04877671f, -0.02507198f, 0.05433311f, 0.00389687f, 
    0.08622459f, 0.04629853f, 0.08205699f, 0.13829792f, -0.00462977f, -0.10793840f, -0.13410060f, -0.00571467f, 
    0.00292047f, 0.02307992f, -0.03200215f, 0.00733764f, 0.10404292f, 0.05971184f, -0.10982692f, 0.06916907f, 
    -0.12454510f, 0.17727776f, 0.11821108f, -0.08214831f, 0.01312171f, 0.04990913f, -0.02167417f, 0.07788866f, 
    -0.00054134f, 0.13338509f, 0.03064001f, 0.00892691f, -0.29457915f, -0.04915779f, -0.02033705f, 0.09890433f, 
    0.12047452f, -0.05015948f, 0.02103614f, -0.05831806f, 0.02811238f, -0.01720449f, 0.07988312f, 0.04624301f, 
    -0.18440035f, -0.10651752f, 0.09878995f, 0.06761265f, 0.04424976f, 0.00948426f, 0.02539176f, 0.13058011f, 
    0.04649714f, 0.10238180f, -0.08502558f, 0.04272287f, -0.34461498f, -0.15873998f, -0.20576425f, -0.10762335f, 
    0.10190622f, -0.00935781f, -0.09088471f, -0.03096848f, 0.00856522f, -0.00745940f, 0.06264155f, 0.05605289f, 
    0.11460876f, 0.07178757f, 0.08633864f, 0.05433878f, -0.08829007f, -0.07892215f, -0.06303257f, 0.05069844f, 
    -0.01858975f, 0.03618181f, 0.05671343f, -0.00380492f, -0.32441697f, -0.04034871f, 0.20991673f, -0.11110763f, 
    0.09524649f, 0.07378215f, -0.05276101f, 0.01980362f, -0.06363165f, 0.13526334f, 0.07588845f, 0.06784879f, 
    0.12038288f, 0.08446863f, -0.00135798f, -0.00801536f, -0.05346128f, 0.06812216f, 0.01458661f, -0.03104082f, 
    0.09713643f, 0.01156121f, -0.01703143f, -0.09904849f, 0.14163923f, -0.09163044f, -0.13530613f, 0.00055223f, 
    0.03028025f, -0.05717138f, 0.02055310f, 0.15688223f, 0.02158139f, 0.09361001f, 0.04009186f, 0.13343099f, 
    -0.20592090f, 0.09673761f, -0.15288140f, 0.08123388f, 0.03557724f, -0.01765359f, -0.04054176f, -0.05911740f, 
    0.13230251f, 0.02840566f, -0.01412231f, 0.01531591f, -0.52404487f, -0.06772684f, -0.07274653f, -0.20490344f, 
    0.11795748f, -0.15252653f, -0.05114262f, -0.01674874f, -0.06654376f, -0.01834327f, 0.06209550f, -0.04189298f, 
    0.17867701f, 0.11977867f, -0.05360534f, -0.02095882f, 0.02554866f, 0.11724850f, 0.06272446f, 0.02808744f, 
    0.00265677f, 0.09515937f, 0.14069159f, 0.07833906f, -0.22216722f, -0.06602229f, -0.16275816f, -0.39022630f, 
    0.07495283f, 0.04071509f, -0.00504285f, 0.07835184f, -0.02861461f, 0.02258455f, 0.11685492f, 0.16482209f, 
    0.18374722f, 0.08658761f, -0.11248905f, -0.22072868f, 0.02155649f, -0.12173623f, 0.04221408f, -0.00152236f, 
    -0.04453237f, 0.13941637f, 0.15101548f, 0.05561995f, -0.00366898f, -0.07471474f, 0.00504724f, -0.00331802f, 
    0.13802721f, 0.07847720f, -0.03639232f, 0.13548458f, 0.07396153f, 0.19501667f, -0.03013707f, 0.21135855f, 
    0.10398991f, 0.24649635f, -0.01388867f, -0.13776192f, -0.03185416f, 0.02684968f, -0.02295360f, 0.19787695f, 
    -0.00059029f, 0.08938123f, 0.13842739f, 0.01488025f, -0.10554787f, -0.09436541f, 0.03970103f, 0.03370892f, 
    0.04117156f, 0.02562060f, -0.06126041f, -0.08471112f, 0.01292039f, 0.05333869f, 0.01267494f, 0.01229766f, 
    -0.15354842f, -0.08661718f, -0.02190284f, -0.04000851f, -0.04354783f, 0.00497028f, -0.03725839f, 0.08324581f, 
    -0.00260486f, -0.03232978f, -0.02812846f, 0.00510696f, -0.24030276f, -0.17288326f, -0.06828971f, -0.06407948f, 
    0.08646622f, 0.06593798f, 0.03809213f, -0.06023131f, 0.19722950f, -0.00704137f, 0.08993036f, -0.03863008f, 
    -0.02867253f, -0.19950531f, -0.04272642f, 0.02347984f, 0.05070532f, 0.02604198f, 0.05334473f, 0.03929697f, 
    -0.02149414f, 0.06003737f, 0.06077217f, 0.00520929f, 0.08882900f, -0.17326452f, 0.11229628f, -0.09582247f, 
    -0.10948925f, 0.07974264f, 0.07591925f, -0.01942518f, 0.01565537f, 0.00677362f, 0.02276423f, 0.02646105f, 
    0.17951620f, 0.03332290f, 0.04899896f, -0.00032705f, -0.04152600f, 0.10896393f, -0.04088899f, -0.06758795f, 
    0.06268055f, -0.02109433f, -0.03381304f, -0.03005175f, 0.01351524f, -0.03538372f, -0.02022494f, 0.11868738f, 
    -0.05331666f, 0.14553039f, -0.08235746f, 0.05966059f, 0.03113537f, 0.02400118f, -0.08458663f, -0.12344317f, 
    -0.48245779f, -0.15695983f, -0.04011212f, -0.17127362f, 0.08407964f, -0.05330862f, -0.07313626f, -0.02034660f, 
    -0.04635971f, 0.00705582f, -0.06420897f, 0.05557177f, -0.44123030f, -0.00581449f, -0.02202729f, -0.14546412f, 
    0.02795960f, 0.11296448f, -0.04825134f, -0.02274260f, 0.01712685f, -0.07532340f, 0.01723924f, -0.03153943f, 
    0.11824604f, 0.10497770f, 0.07200295f, -0.10590424f, -0.09058291f, -0.02041889f, -0.03808816f, -0.06059857f, 
    0.04730802f, 0.04868554f, 0.04414374f, 0.02146375f, -0.31937194f, -0.36133435f, -0.11645762f, -0.27954614f, 
    -0.03851861f, 0.03118765f, 0.05067954f, -0.08161887f, 0.00865449f, -0.02698722f, -0.06074286f, 0.03222721f, 
    -0.28077614f, -0.07821426f, 0.04286925f, -0.08198853f, 0.01101441f, -0.22877303f, -0.09628500f, 0.13981313f, 
    -0.08886459f, 0.03768862f, -0.09974086f, -0.02214100f, -0.05348427f, -0.13107824f, 0.11260860f, 0.00183758f, 
    -0.08216792f, 0.03165840f, -0.06920189f, -0.03662454f, 0.07831250f, -0.00333662f, -0.01521258f, -0.11733931f, 
    -0.68366116f, -0.29228887f, -0.01181192f, 0.02801742f, 0.11332664f, -0.11619302f, -0.05265743f, -0.08027897f, 
    -0.03533098f, -0.13161682f, -0.03887583f, -0.05670103f, 0.22643694f, 0.06286229f, -0.10060942f, 0.04467059f, 
    -0.14111084f, 0.04106532f, -0.02102930f, 0.01289885f, 0.05620024f, 0.13509521f, 0.00248629f, 0.04451519f, 
    0.03186693f, 0.06060174f, -0.10524115f, -0.06088133f, -0.11475123f, 0.08278931f, -0.01840034f, -0.06864203f, 
    0.08282712f, 0.03848511f, -0.03720317f, -0.05822140f, 0.09924440f, 0.00284174f, -0.06932023f, -0.10028675f, 
    0.04194639f, 0.07827888f, -0.01250503f, 0.03185615f, 0.02932326f, 0.02773651f, 0.07336989f, 0.04671630f, 
    0.03103284f, -0.08164520f, -0.06769025f, 0.00066090f, 0.00657413f, -0.09029164f, 0.06584764f, 0.10982391f, 
    -0.05927738f, 0.02828356f, -0.00261406f, 0.05661362f, -0.12557921f, 0.18662848f, 0.15109214f, 0.12292050f, 
    0.12457560f, -0.01919599f, 0.02662582f, -0.03523988f, -0.02938258f, 0.03795822f, -0.01496347f, 0.13426247f, 
    0.10467958f, 0.25525391f, 0.12494915f, 0.06712479f, 0.10307317f, 0.01974400f, 0.03206582f, 0.05197295f, 
    -0.00672519f, 0.02641313f, 0.01661498f, -0.07470962f, 0.02059698f, -0.08333340f, -0.16883156f, -0.08506041f, 
    0.09034131f, -0.17882948f, -0.07220653f, 0.02144032f, -0.09483932f, -0.02463923f, -0.10420326f, 0.02792848f, 
    -0.54822105f, -0.33363020f, 0.16818130f, 0.08823346f, 0.04128779f, -0.03114654f, 0.04565687f, -0.06664687f, 
    0.06976847f, -0.03792578f, -0.18073526f, -0.05891219f, 0.07052609f, 0.17084841f, 0.13087909f, -0.16464683f, 
    0.05752253f, 0.04859851f, -0.00329428f, -0.01180519f, -0.03083026f, -0.03261796f, 0.02406981f, 0.09913653f, 
    -0.00570556f, 0.04680520f, -0.15365024f, 0.07722074f, -0.08022458f, -0.00645612f, -0.01961363f, 0.08661585f, 
    0.05047183f, -0.07107452f, 0.01810717f, -0.13010707f, 0.14344396f, 0.13614449f, 0.03446472f, -0.05928615f, 
    -0.02417757f, -0.14453959f, 0.08645627f, 0.02468572f, 0.04199201f, 0.10251183f, 0.09991843f, 0.16487606f, 
    -0.41089815f, -0.18164314f, -0.16524549f, -0.29642525f, 0.13034979f, -0.12199258f, -0.17708440f, -0.07374433f, 
    -0.06186379f, -0.19606425f, -0.04017810f, -0.00836511f, -0.27362841f, 0.02577545f, -0.21778619f, 0.02655846f, 
    0.01810421f, -0.06260076f, -0.04937760f, 0.02438002f, -0.00337057f, 0.08304106f, 0.00962448f, -0.08307265f, 
    0.02610114f, 0.07133481f, -0.10757457f, -0.00347415f, -0.05267966f, 0.02511492f, 0.00368670f, -0.05688817f, 
    0.09423838f, -0.10075869f, -0.08498067f, -0.04867006f, -0.55457038f, -0.17304102f, 0.03348016f, 0.03497158f, 
    0.12672187f, -0.01152849f, 0.03094650f, -0.08599582f, 0.06030710f, 0.00300918f, -0.07654198f, -0.01373910f, 
    0.01284703f, 0.01240576f, -0.02473441f, -0.17041226f, 0.06089739f, -0.05091985f, 0.14282437f, -0.05027769f, 
    0.04926755f, 0.06815942f, 0.04297369f, 0.16146791f, 0.25383288f, -0.17281356f, 0.09231073f, 0.04649800f, 
    0.08869850f, 0.03579950f, 0.00015797f, 0.05830371f, 0.03662813f, -0.04624388f, -0.16018859f, 0.00080695f, 
    -0.35992050f, -0.16632703f, -0.08440558f, -0.43236431f, 0.09407050f, -0.06786007f, -0.15210581f, 0.00206376f, 
    -0.03542343f, -0.10227381f, 0.03108457f, -0.04536283f, -0.30524021f, -0.25929409f, -0.06780284f, -0.08242600f, 
    -0.03587507f, 0.07096896f, 0.05074256f, -0.03058048f, 0.12155150f, -0.02019701f, -0.04008591f, 0.12789413f, 
    -0.25106934f, 0.14981563f, -0.03244627f, -0.03042721f, 0.11084229f, 0.05265267f, -0.01467546f, 0.11147154f, 
    0.07440387f, -0.03228589f, 0.02009549f, -0.04117418f, -0.01686680f, 0.06645069f, 0.15474162f, -0.05231781f, 
    0.09061524f, -0.01779862f, -0.00831588f, -0.05614767f, -0.04511416f, -0.03765541f, 0.08915985f, 0.03254202f, 
    -0.06487259f, -0.25134405f, 0.07807791f, -0.00605999f, -0.02325366f, 0.00137632f, 0.04748304f, 0.02668486f, 
    -0.10043555f, -0.07280086f, -0.09524818f, -0.05888560f, 0.00888196f, 0.02839989f, 0.08488089f, -0.04928392f, 
    -0.05312887f, -0.04161241f, -0.03859987f, 0.00619112f, -0.07282019f, 0.06885575f, 0.09031425f, 0.00848365f, 
    -0.28778094f, -0.17604640f, 0.06035928f, 0.06702314f, -0.12007250f, 0.10798581f, -0.04745898f, -0.00396673f, 
    0.10330945f, -0.01828702f, 0.10982292f, 0.09376329f, 0.24467899f, -0.05187714f, -0.17369153f, -0.07243340f, 
    0.05144779f, -0.09126182f, 0.01341416f, -0.00231430f, 0.02854798f, 0.11236650f, -0.04260619f, -0.10515238f, 
    -0.19466747f, -0.38146451f, -0.19865626f, -0.24834852f, 0.06962299f, 0.00456125f, 0.00382182f, 0.09851034f, 
    -0.03886434f, 0.03479242f, -0.06713267f, -0.13106763f, -0.34270144f, -0.16195008f, -0.03649595f, -0.06366723f, 
    -0.06687981f, 0.10165636f, 0.03877050f, 0.10309297f, -0.08596797f, 0.03503422f, 0.07049800f, -0.03945060f, 
    0.24312933f, -0.14458761f, -0.01315818f, -0.06309583f, 0.00469983f, 0.04759150f, 0.12426820f, 0.02109683f, 
    -0.09718557f, -0.07904290f, -0.17950334f, 0.03616979f, -0.05456482f, 0.08491495f, -0.05768367f, 0.08049606f, 
    -0.01172518f, 0.03121910f, -0.03009412f, -0.07514653f, 0.01956538f, -0.05963145f, 0.09913187f, -0.02914583f, 
    0.07292376f, 0.13817592f, -0.12234618f, -0.24218164f, 0.03511623f, -0.03490252f, 0.05290302f, 0.08887326f, 
    0.02452444f, 0.02061489f, -0.03991311f, -0.01156449f, 0.44982430f, 0.10669515f, -0.13088949f, -0.05261963f, 
    -0.09658219f, -0.11109570f, -0.00627234f, 0.02917104f, 0.02725019f, -0.04540639f, -0.03975879f, 0.05817921f, 
    0.06219499f, -0.00288079f, -0.10470410f, -0.03840350f, 0.09966154f, -0.04184655f, 0.10822564f, -0.00463750f, 
    0.09588349f, 0.00095938f, -0.07264479f, 0.04786517f, -0.17598759f, 0.01139050f, 0.11171556f, 0.05729218f, 
    0.09565949f, -0.02547010f, 0.09431850f, -0.10362532f, -0.02594785f, -0.06144860f, 0.07072513f, 0.03172989f, 
    0.23687451f, -0.09330393f, 0.09474947f, 0.13148427f, 0.00307723f, -0.00248036f, -0.00816848f, -0.07371428f, 
    0.00152805f, -0.00259299f, 0.06279627f, -0.13872586f, -0.34515679f, -0.12189918f, -0.04753082f, -0.07266442f, 
    0.01575978f, -0.04364369f, -0.00780759f, 0.12582743f, 0.06297313f, 0.01452114f, 0.01994122f, -0.07156496f, 
    -0.08781006f, -0.29575154f, 0.12058910f, 0.02706984f, -0.09532640f, -0.01205518f, -0.03840052f, 0.16297437f, 
    -0.04223998f, -0.07438377f, 0.04902346f, 0.00219118f, 0.16590478f, -0.10906682f, 0.06521074f, 0.03890698f, 
    0.01410766f, -0.01873057f, -0.00661166f, -0.03207959f, -0.04847275f, 0.01479409f, 0.02368544f, 0.00798918f, 
    0.05730609f, 0.13919388f, -0.10314109f, 0.13131949f, -0.06337621f, -0.09092064f, -0.03692409f, 0.01024785f, 
    0.05957967f, -0.10776236f, -0.04320385f, 0.13521428f, 0.37779287f, -0.07602866f, -0.17939746f, -0.02133914f, 
    -0.02019548f, -0.01547918f, 0.05766837f, -0.02192423f, -0.05336043f, 0.11131807f, -0.02372885f, -0.02517733f, 
    0.12685613f, 0.04510611f, -0.06716011f, 0.17200039f, -0.00744182f, 0.09994525f, -0.05222444f, 0.00988851f, 
    0.13689770f, -0.09896479f, -0.00121795f, -0.03595975f, 0.07447460f, 0.02640566f, -0.02655040f, -0.09033766f, 
    0.16866019f, -0.03272575f, -0.11173937f, 0.05004513f, -0.02555453f, 0.05884488f, -0.05466263f, -0.01626814f, 
    -0.16750591f, 0.15693228f, -0.11388452f, -0.04317372f, -0.08501858f, -0.10989541f, -0.03854530f, 0.06385930f, 
    -0.02229775f, 0.05660054f, 0.01074849f, -0.06054516f, -0.20364922f, -0.13353775f, 0.00570205f, 0.04090714f, 
    0.07906470f, 0.01387724f, 0.10300970f, 0.02203289f, -0.02310821f, 0.02608692f, 0.01628696f, 0.04535803f, 
    0.00849367f, -0.10230485f, -0.03826385f, 0.08054978f, -0.01753970f, 0.04051303f, -0.08082961f, 0.04710701f, 
    0.04212966f, -0.00179496f, 0.02788940f, -0.06955346f, 0.26905772f, -0.06973700f, -0.15898585f, 0.20631263f, 
    0.01035643f, -0.03948078f, -0.10439878f, -0.03293127f, 0.05760583f, -0.00965216f, 0.02609738f, -0.02032889f, 
    0.17546864f, 0.12762243f, -0.05253910f, 0.01668727f, -0.03561711f, 0.07324480f, 0.00038959f, -0.05792487f, 
    -0.03373098f, -0.07621559f, -0.10246962f, -0.10684749f, 0.18557161f, -0.20705667f, -0.11954931f, 0.07406082f, 
    -0.01699083f, -0.03606187f, -0.01227702f, -0.07360813f, 0.00143010f, -0.05816814f, -0.07646408f, -0.05297271f, 
    -0.09478517f, 0.06760593f, -0.02063529f, 0.02140732f, 0.06553662f, -0.01627425f, -0.05826460f, 0.00355183f, 
    0.08160473f, -0.07181448f, -0.12138560f, -0.03124975f, 0.11184397f, -0.08637530f, -0.08493511f, 0.31212047f, 
    0.17070580f, 0.03364606f, 0.05541279f, -0.01564882f, -0.00564128f, -0.06279752f, 0.00431773f, 0.04776314f, 
    -0.33708650f, 0.18197753f, 0.13886155f, -0.01067297f, -0.10253476f, -0.01856634f, -0.05406758f, -0.04329673f, 
    0.02048882f, 0.03250019f, 0.01609214f, -0.00649100f, 0.12388807f, -0.15031564f, -0.16866091f, 0.02477076f, 
    -0.02749643f, 0.03847986f, -0.10571174f, -0.11546569f, -0.04370316f, 0.01605309f, -0.09384683f, 0.01292738f, 
    -0.43158013f, 0.15529081f, -0.08058789f, -0.06314331f, 0.16096975f, -0.00538480f, 0.02412112f, -0.08590791f, 
    0.08393329f, 0.04168481f, -0.00176329f, 0.05469929f, 0.03332245f, -0.30335489f, -0.06797579f, -0.16765741f, 
    0.08035396f, -0.05376108f, 0.00318444f, 0.05734969f, -0.11997043f, -0.02320699f, -0.08233342f, 0.01969557f, 
    0.04572566f, 0.21657279f, -0.16493616f, -0.09145977f, 0.15090936f, 0.03019857f, -0.03715396f, 0.11566641f, 
    0.09424329f, -0.00017702f, 0.09409082f, 0.01173699f, -0.16636713f, 0.10847681f, 0.05094486f, -0.13455796f, 
    0.15348926f, -0.09094908f, 0.01214708f, -0.00856501f, 0.01552718f, 0.11368708f, 0.03793539f, -0.20045196f, 
    -0.09409561f, -0.04554275f, -0.03317513f, 0.14978538f, 0.18951765f, -0.02957986f, 0.01229016f, 0.08636650f, 
    -0.04221760f, -0.05700823f, 0.11504649f, 0.06511597f, -0.10040116f, 0.12874143f, 0.07803635f, -0.18096474f, 
    -0.02980772f, -0.05069786f, 0.02106665f, -0.07597161f, -0.03339436f, 0.07767666f, -0.03067596f, 0.09765328f, 
    0.08756103f, 0.14082347f, -0.16926402f, -0.08421753f, -0.10151593f, -0.03749363f, -0.00420875f, 0.04564128f, 
    0.02874575f, -0.08898994f, -0.02923120f, 0.04414637f, -0.39800692f, 0.17434365f, 0.09946018f, 0.10756566f, 
    -0.12083317f, -0.02440410f, -0.06434183f, 0.08120454f, 0.00292792f, -0.05053693f, 0.12397020f, 0.01377320f, 
    -0.02631168f, 0.16091920f, -0.06004616f, 0.08838274f, -0.11755124f, -0.06530160f, 0.02040264f, -0.17675561f, 
    -0.05966542f, 0.01541699f, -0.05462168f, -0.13939282f, 0.06730809f, -0.00014591f, -0.19490997f, 0.04511851f, 
    0.08074152f, 0.03224388f, 0.03929143f, -0.18647572f, 0.00737631f, 0.04276364f, 0.02151763f, -0.05341516f, 
    -0.23268273f, 0.01973861f, 0.12054539f, -0.29763409f, -0.00485106f, 0.02616988f, -0.04349621f, -0.03712823f, 
    -0.01176682f, -0.07744602f, -0.04015776f, -0.02637339f, -0.11194540f, 0.17618357f, 0.02261443f, -0.01392431f, 
    0.03707295f, -0.00729657f, -0.15043123f, -0.09444657f, -0.07861809f, 0.07134178f, 0.05277694f, 0.04821836f, 
    0.08438981f, -0.04895761f, -0.15958980f, 0.03242584f, 0.00669332f, -0.04757471f, -0.05383020f, 0.08938485f, 
    0.06753378f, 0.00389811f, 0.01595200f, -0.01320021f, -0.01557914f, -0.15499331f, -0.06024626f, 0.03214836f, 
    -0.15808836f, -0.00015738f, -0.07026622f, 0.15955840f, -0.13591611f, -0.02184474f, 0.02430519f, -0.15667458f, 
    0.22729835f, -0.00945017f, -0.18724182f, 0.03161982f, -0.08817103f, -0.05354089f, -0.02505762f, -0.03700617f, 
    0.08778597f, -0.05148684f, -0.08634291f, -0.05056555f, 0.07152531f, -0.15771626f, -0.09063356f, -0.02550832f, 
    0.02097562f, -0.01952677f, -0.03873530f, -0.05923538f, -0.11227255f, 0.03290303f, -0.07777193f, -0.12972388f, 
    0.16204797f, 0.02094288f, 0.09109700f, -0.25480038f, -0.00582205f, -0.01514364f, -0.03012452f, 0.06008745f, 
    -0.09874402f, -0.08243714f, 0.04981885f, -0.01561261f, 0.28780454f, -0.00854320f, 0.03223514f, -0.11287412f, 
    0.00437088f, -0.00111062f, 0.01012544f, 0.07052118f, 0.04365629f, 0.01068764f, -0.00759362f, 0.03589763f, 
    0.07510146f, 0.03997556f, 0.04094047f, -0.07992263f, 0.12417095f, -0.00759998f, -0.05750487f, 0.09503834f, 
    0.10722063f, -0.00837920f, 0.09965806f, 0.00351893f, -0.10064867f, -0.14445709f, -0.06308658f, -0.12083980f, 
    0.02746527f, 0.02577077f, 0.04235128f, 0.05991045f, 0.05031531f, 0.06559759f, 0.00792006f, 0.00229798f, 
    0.40607241f, 0.20449975f, -0.04516451f, -0.06627149f, 0.08566036f, -0.00870854f, -0.03562412f, 0.02370026f, 
    -0.00743488f, 0.01885662f, 0.09515681f, 0.01926608f, -0.27232400f, 0.23770839f, -0.06873272f, -0.04156335f, 
    -0.17537227f, 0.03739141f, 0.15805262f, -0.05326204f, -0.00058936f, 0.04810378f, -0.01039880f, -0.03766389f, 
    -0.09816021f, -0.14641088f, -0.10755015f, 0.19601108f, -0.02814363f, 0.09123944f, 0.05126152f, -0.17829520f, 
    -0.02867425f, 0.01720059f, 0.01213002f, -0.01130505f, 0.17334811f, 0.17234844f, -0.07882215f, 0.06111072f, 
    -0.08231168f, -0.01765831f, -0.08347636f, 0.07246755f, -0.01805385f, -0.06126237f, -0.05942041f, -0.05739976f, 
    0.06525531f, -0.09473965f, -0.01426883f, -0.09363875f, -0.02694698f, 0.00036380f, -0.05657214f, 0.10789502f, 
    0.02431461f, 0.03614521f, 0.02162700f, 0.06630632f, -0.27561474f, -0.19969261f, -0.04392161f, 0.07239544f, 
    -0.01739283f, 0.16237080f, -0.10338807f, 0.05450780f, 0.05803787f, -0.05418801f, -0.06938966f, 0.15164086f, 
    -0.26116052f, 0.16331568f, -0.05949632f, 0.14406031f, -0.01366239f, -0.11706522f, -0.00644971f, -0.02547154f, 
    0.02012556f, -0.01202988f, 0.10309035f, -0.10349013f, 0.33275706f, -0.11194475f, -0.08462831f, -0.00358130f, 
    0.02125938f, -0.15693586f, -0.03599014f, 0.00452101f, 0.06349113f, 0.07729119f, 0.03680412f, 0.08611852f, 
    -0.05457753f, 0.03627729f, 0.00922975f, -0.01283324f, -0.09624702f, 0.00146803f, -0.04119850f, 0.00219007f, 
    -0.06344073f, -0.01258963f, 0.11189921f, -0.08665892f, 0.20523421f, 0.08834020f, -0.27181494f, -0.16599791f, 
    0.19791414f, -0.04999657f, -0.03610783f, 0.08509660f, 0.00879902f, 0.00256615f, 0.01954126f, -0.00173029f, 
    0.08602417f, -0.17381361f, -0.01666221f, -0.09762402f, 0.02090439f, -0.01666955f, 0.00465951f, -0.01395546f, 
    0.02318929f, 0.06239640f, 0.01614933f, -0.00638427f, 0.22507824f, -0.08216955f, 0.01853795f, -0.08810538f, 
    -0.01200332f, 0.05463177f, -0.02591794f, 0.05558973f, 0.09054627f, 0.00444151f, 0.00191200f, -0.02919363f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05707054f, 0.00698818f, -0.03797571f, -0.01380075f, 0.03027971f, 0.02157498f, -0.01719972f, -0.05078825f, 
    -0.03057765f, 0.00145428f, 0.07867040f, 0.00251660f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
