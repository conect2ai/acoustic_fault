#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.15667856f, 0.23464647f, 0.10794616f, 0.45837325f, 0.48215190f, 0.15983047f, -0.18431008f, -0.42971751f, 
    0.08283428f, 0.27106476f, 0.06784429f, 0.18393034f, 0.01043389f, -0.06283621f, -0.15955326f, -0.03811190f, 
    -0.20672056f, 0.00160526f, -0.02385387f, 0.05985558f, -0.11620054f, 0.21246329f, 0.26391679f, -0.14392483f, 
    -0.27018911f, -0.83362657f, -0.07622622f, -0.54277313f, -0.63945824f, -0.35583609f, 0.41588005f, 0.32595268f, 
    0.40541500f, 0.28161764f, 0.42916113f, 0.17284854f, 0.24756953f, 0.17015737f, -0.05511207f, -0.04491054f, 
    0.20111713f, -0.11841413f, -0.24259111f, -0.13030495f, -0.01403092f, -0.04172770f, 0.13397850f, 0.10278884f, 
    -0.02221282f, -0.12752289f, 0.23286940f, -0.66960740f, -0.29758170f, 0.00952452f, -0.66304302f, 0.84081352f, 
    -0.00149341f, -0.31508639f, 0.19530335f, -0.24355274f, 0.01397537f, -0.29198748f, -0.16377421f, -0.15046521f, 
    0.38018510f, 0.12201420f, 0.25309008f, 0.07014985f, -0.03246797f, -0.19049765f, 0.01231998f, 0.17844544f, 
    0.16226256f, -0.15631102f, -0.11539023f, 0.47861308f, 0.59733963f, -0.54336339f, -0.17986733f, -0.25893298f, 
    -0.65476221f, -0.55065548f, 0.18127315f, 0.65854853f, 0.30814984f, -0.24871419f, -0.16648869f, 0.10750005f, 
    0.30917689f, -0.05667522f, 0.00373959f, 0.11904024f, -0.29142660f, 0.14165825f, -0.07672471f, -0.18194017f, 
    0.14634621f, -0.13904931f, -0.09177569f, -0.01671468f, 0.73677617f, -0.09660950f, 0.14226648f, 0.26258335f, 
    -0.01691873f, 0.27788365f, -0.05803517f, -0.02017643f, 0.20626478f, -0.10162777f, 0.11683926f, 0.09968573f, 
    -0.36014396f, 0.06080016f, -0.23425080f, -0.03486217f, 0.25164542f, 0.20088810f, -0.22613814f, -0.06948873f, 
    -0.24936050f, -0.13922976f, -0.31285432f, -0.25822914f, -0.06921650f, -0.77801901f, 0.03119326f, 0.09507225f, 
    -0.54087222f, -0.40624234f, 0.19546156f, -0.33524510f, 0.11576108f, 0.38308781f, 0.00543512f, -0.36351815f, 
    -0.38477108f, -0.01855842f, -0.14460726f, -0.24190019f, 0.27218834f, -0.01739910f, -0.00288894f, 0.07504875f, 
    -0.00454740f, -0.11482093f, 0.15347418f, -0.21750630f, -0.31169984f, -0.50159019f, 0.90072560f, -1.31272292f, 
    -0.04868133f, 0.79033577f, 0.33847886f, -0.11762237f, 0.38339564f, -0.63110203f, -0.61678165f, -0.42529336f, 
    0.17369317f, -0.03570192f, 0.11238410f, -0.00042399f, 0.05820819f, -0.11191113f, -0.04569760f, -0.09347242f, 
    0.26679373f, 0.03491713f, -0.16967003f, -0.05522624f, -0.08206312f, 0.20167591f, -0.22163646f, 0.34985107f, 
    -0.05333490f, -0.49177915f, -0.45968989f, -0.05692347f, -0.19839278f, -0.03926702f, -0.08572865f, -0.21660863f, 
    -0.36675858f, -0.06068263f, -0.16078252f, 0.33001420f, -0.27441415f, 0.05414945f, -0.24895318f, -0.19714648f, 
    0.15694676f, -0.28157878f, -0.12457475f, 0.31226677f, 0.25621894f, 0.21955396f, 0.30880445f, 0.51533836f, 
    -0.89727980f, -0.40214375f, -0.31663957f, -0.02176036f, 0.28411609f, -0.07107661f, -0.07221437f, -0.41082937f, 
    -0.32154122f, -0.26536614f, -0.24062662f, 0.08557043f, -0.33164296f, -0.31969649f, -0.52618408f, -0.04042475f, 
    0.06234474f, -0.13864036f, 0.18298145f, -0.22181982f, 0.12622854f, 0.02110053f, -0.04668756f, -0.13214312f, 
    -0.12388080f, -0.03899286f, -0.18197168f, 0.57692206f, 0.01144900f, -0.66474992f, -0.07762769f, 0.21689336f, 
    0.14381161f, -0.20069925f, 0.17732729f, -0.21110937f, -0.03822681f, 0.14822993f, 0.23064709f, 0.08920500f, 
    0.05329342f, 0.01285801f, 0.11084996f, -0.26814806f, 0.50169533f, -0.12147556f, 0.37828848f, 0.19245645f, 
    -0.11689554f, -0.29887316f, 0.76798493f, -0.61573517f, -0.73976934f, -0.60486913f, -0.43765333f, 0.54744214f, 
    0.40953657f, 0.10973829f, -0.15184747f, -0.27753428f, -0.23717254f, -0.04055448f, 0.14733416f, -0.10308795f, 
    0.26840541f, -0.02479099f, -0.23912542f, -0.02265632f, -0.32856280f, -0.19595367f, 0.17858081f, -0.42404103f, 
    -0.18391745f, 0.35305598f, 0.01285801f, 0.58225298f, 0.29750395f, 0.15816753f, 0.09163883f, -0.24158858f, 
    -0.44129890f, -0.00847452f, 0.12733553f, -0.26138476f, -0.47654903f, -0.23321471f, 0.22488424f, 0.17773907f, 
    -0.08018681f, -0.35264879f, 0.20003971f, 0.20829128f, -0.19250326f, -0.06352406f, 0.08330211f, -0.11568850f, 
    -0.06229773f, -0.08143523f, 0.10930748f, 0.34488183f, -0.04130618f, -0.07493631f, -0.45352837f, -0.63108957f, 
    -0.52821171f, 0.15302627f, 0.16931415f, -0.36269125f, -0.33332568f, 0.26618883f, 0.11986937f, 0.20462701f, 
    -0.05439999f, -0.25143182f, -0.23356025f, -0.16856614f, 0.31246200f, 0.15394334f, -0.17714649f, -0.04377188f, 
    -0.31094939f, -0.04163813f, -0.14086238f, -0.19803721f, -0.44347781f, -0.89114028f, -0.60759258f, -0.17398398f, 
    0.35000226f, -0.30274189f, 0.45886001f, -0.50145543f, -0.49028236f, 0.67267466f, 0.59300745f, -0.01761946f, 
    -0.14402092f, -0.06219738f, 0.15334854f, -0.01885371f, -0.15719305f, -0.05229136f, -0.14061171f, 0.05004573f, 
    -0.17238523f, 0.12490427f, -0.11547222f, -0.08771285f, 0.04484844f, 0.23505828f, -0.10420354f, 0.16780110f, 
    0.30987272f, -0.06356827f, -0.05588302f, 0.27518350f, 0.53231293f, -0.10964306f, 0.43196708f, -0.14551063f, 
    -0.02655527f, -0.17320772f, -0.25698394f, 0.29712275f, -0.30694953f, -0.12380138f, -0.01616869f, 0.05762735f, 
    0.08279156f, -0.43194067f, 0.17451438f, 0.00492693f, 0.10611344f, 0.12283233f, 0.06719726f, 0.06713804f, 
    0.06040371f, -0.43292633f, -0.29799989f, -0.43417710f, -0.59869522f, -0.41364643f, -0.51521504f, -0.52520281f, 
    -0.45628023f, 0.46567097f, 0.23068890f, 0.28095141f, -0.18449092f, -0.13994899f, 0.09624571f, 0.18831742f, 
    -0.23779069f, -0.38764697f, -0.33579090f, -0.09519164f, -0.29291698f, -0.04391513f, -0.04740773f, -0.10822470f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14427739f, 0.07674389f, -0.02071404f, 0.30256340f, -0.02802339f, -0.09600262f, 0.13265966f, 0.18258940f, 
    -0.18173553f, -0.07848264f, 0.28880540f, 0.25287065f, 0.00764462f, 0.14626488f, 0.24530934f, 0.13362649f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02586504f, -0.32877752f, -0.08400986f, 0.16660191f, 0.12127683f, 0.07380009f, 0.22131452f, 0.01405795f, 
    -0.04131351f, 0.16807625f, 0.13284725f, -0.01928853f, -0.25806606f, 0.33320549f, 0.23080921f, 0.00175443f, 
    0.01258255f, -0.06060837f, -0.06452239f, 0.18105358f, -0.03252302f, 0.10152921f, 0.11734267f, -0.01563637f, 
    0.30171075f, -0.05425273f, -0.11934598f, -0.10121857f, 0.03826516f, -0.00168993f, -0.08943136f, 0.00711433f, 
    -0.04845238f, -0.08965883f, 0.03316316f, -0.04657105f, 0.07023102f, 0.21128443f, -0.39914331f, -0.11485805f, 
    0.05729607f, -0.08761510f, 0.11844666f, 0.19117816f, -0.03554993f, -0.08404893f, 0.11169630f, -0.01912216f, 
    0.17252792f, -0.01489388f, -0.01675774f, 0.02136059f, 0.01213452f, -0.08601854f, -0.01988162f, 0.15518212f, 
    -0.03439885f, 0.06730196f, 0.06767126f, -0.02201601f, -0.35333556f, -0.09226217f, -0.05028972f, -0.16162989f, 
    -0.15739760f, 0.10016912f, 0.00263010f, 0.04012513f, 0.04222621f, 0.16581935f, -0.04223433f, 0.05188514f, 
    0.31712636f, -0.49831849f, 0.32695872f, -0.18422593f, 0.10391580f, 0.12957865f, -0.08560500f, 0.04870172f, 
    0.09633337f, -0.03149996f, -0.04023955f, 0.03806074f, -0.05435221f, -0.01021694f, 0.16017829f, 0.00415096f, 
    0.02297721f, -0.10003352f, -0.08526672f, -0.04191897f, -0.07537550f, -0.21975754f, -0.09693984f, 0.05891811f, 
    -0.10343520f, -0.07340618f, 0.18345931f, 0.15627189f, -0.07748697f, 0.02808908f, 0.01090016f, -0.02769824f, 
    -0.06299244f, 0.03125605f, 0.03550669f, -0.04591786f, 0.05162389f, 0.01297085f, -0.10335044f, -0.10888033f, 
    0.04298753f, 0.25253749f, -0.06660294f, 0.06523257f, -0.08074480f, -0.19474231f, -0.08390768f, 0.14265706f, 
    0.25752175f, 0.04268688f, -0.02450852f, -0.11173638f, -0.02844051f, -0.06921056f, -0.07821452f, -0.07544836f, 
    -0.04583471f, -0.12137723f, 0.06529624f, 0.11021404f, -0.00078428f, 0.00492974f, -0.26819989f, -0.10642413f, 
    0.19406968f, 0.06217559f, 0.11858723f, 0.05180503f, -0.01960491f, -0.12084331f, 0.02241465f, -0.19482137f, 
    -0.12112395f, 0.04116849f, 0.15519589f, -0.13261421f, 0.03910709f, 0.07334862f, 0.00455982f, 0.07647778f, 
    -0.01198655f, 0.09617287f, 0.06334998f, -0.00777039f, -0.11021791f, 0.13946074f, -0.11262055f, -0.03211110f, 
    -0.06014917f, -0.01022231f, 0.20373467f, -0.04947888f, 0.05747617f, 0.02232608f, 0.05657256f, 0.06010190f, 
    -0.00317046f, 0.17799634f, 0.09048208f, 0.22283287f, 0.07049080f, -0.03080260f, -0.12536900f, -0.03805700f, 
    -0.05208755f, 0.13786624f, 0.02179516f, 0.09898463f, 0.09954497f, 0.25858352f, 0.14428081f, -0.05765441f, 
    -0.00938575f, -0.05004308f, 0.04906916f, -0.00616701f, 0.01675146f, 0.13695130f, 0.01640289f, -0.12423515f, 
    0.23512848f, 0.26815140f, -0.05499561f, 0.10305787f, -0.00861877f, 0.04532809f, -0.02185712f, -0.07297695f, 
    -0.06678523f, 0.02250564f, 0.09074058f, 0.06830961f, -0.08528136f, 0.05890286f, 0.04295032f, -0.07547843f, 
    -0.09356818f, 0.04487498f, 0.01015685f, -0.00815162f, -0.08078466f, 0.03023925f, 0.01011688f, -0.05164448f, 
    -0.16997434f, -0.01514389f, 0.27770358f, 0.26810983f, 0.04429121f, -0.02860234f, 0.01442850f, 0.11882614f, 
    -0.03556608f, -0.09407255f, -0.06182001f, -0.07352053f, -0.05697269f, -0.11230014f, 0.10849636f, -0.03406448f, 
    0.20722899f, 0.10905153f, -0.08469298f, -0.00762020f, -0.04940373f, 0.06932329f, 0.09916644f, 0.07945369f, 
    -0.04507396f, -0.08779979f, -0.05420327f, -0.03136626f, 0.00674968f, -0.01681690f, -0.10765517f, -0.00675933f, 
    0.13520570f, 0.17147487f, -0.06191404f, 0.06333698f, 0.01292455f, -0.06171698f, -0.04082013f, 0.16094838f, 
    0.06091772f, -0.21943578f, 0.08998406f, -0.03579721f, -0.01905285f, 0.11305848f, 0.08504002f, -0.05671611f, 
    -0.04856312f, 0.38533545f, -0.05955218f, 0.21471804f, -0.11889114f, -0.00576028f, -0.12260842f, 0.07235837f, 
    -0.15580234f, -0.07025960f, 0.08992762f, -0.02162139f, -0.04527602f, -0.01149640f, 0.21345782f, 0.08718359f, 
    -0.08470388f, 0.11552762f, -0.03999013f, 0.13788877f, -0.05948263f, 0.02691713f, 0.03400105f, -0.00494235f, 
    -0.07147627f, -0.13878626f, -0.01663960f, 0.08156888f, -0.15232736f, -0.06755708f, -0.12841406f, -0.13293906f, 
    0.07983640f, 0.02744558f, 0.01385473f, 0.05003531f, -0.05089428f, 0.11317796f, -0.01779035f, -0.07053202f, 
    0.05361504f, 0.15189999f, -0.01356460f, 0.07018250f, 0.08801421f, 0.03806352f, 0.08358835f, -0.02310657f, 
    -0.06973030f, -0.02978694f, 0.33204958f, 0.24962854f, -0.09909465f, -0.04461565f, 0.03670284f, 0.07641864f, 
    0.03533794f, 0.02964970f, 0.04460977f, 0.02633408f, 0.22252849f, 0.22824509f, 0.17244904f, 0.13886443f, 
    -0.00997815f, -0.01760624f, 0.03050215f, 0.04254321f, -0.07298917f, -0.10801671f, -0.00718456f, -0.03419128f, 
    0.02747661f, 0.01996430f, 0.00634083f, 0.04695006f, -0.02026110f, -0.12554775f, 0.03232661f, -0.05440434f, 
    0.18988240f, 0.14442025f, -0.06801671f, -0.00456909f, -0.15261966f, -0.02582485f, -0.11597544f, 0.15431733f, 
    0.02173450f, -0.10747296f, 0.06520114f, -0.07988846f, -0.09656721f, -0.08261135f, 0.04077460f, -0.05909264f, 
    -0.00949384f, -0.06677010f, 0.15515412f, 0.16360955f, -0.06166915f, -0.07066680f, 0.05958256f, -0.06421819f, 
    -0.04810220f, -0.00038387f, 0.09595545f, 0.12497497f, -0.10859627f, -0.06279644f, -0.01437516f, 0.11059777f, 
    0.00855983f, 0.07355550f, 0.14166299f, 0.02523755f, 0.01362945f, 0.10741333f, 0.01345565f, 0.06039849f, 
    -0.04651457f, -0.33504179f, 0.03704750f, -0.01722523f, 0.18213028f, 0.09680297f, 0.13825469f, -0.10431378f, 
    -0.00505238f, -0.03883602f, 0.00180273f, -0.02006064f, -0.15322340f, 0.20594554f, 0.08014095f, -0.07123988f, 
    -0.00592370f, -0.04172909f, -0.07556483f, -0.05984209f, -0.05673998f, -0.01691285f, -0.00699420f, 0.05490411f, 
    0.50589156f, 0.01789054f, -0.12400722f, -0.14601615f, -0.19021551f, -0.01513701f, -0.00861568f, 0.22335349f, 
    0.03778780f, -0.02286415f, 0.00678740f, -0.05006006f, -0.18006776f, 0.05791891f, 0.04978069f, -0.14630747f, 
    0.22648473f, -0.15909520f, 0.05590158f, 0.02687447f, 0.01980808f, 0.02826522f, -0.02761727f, 0.06447720f, 
    -0.04042795f, -0.27485374f, -0.12095880f, -0.00665973f, -0.01587445f, 0.09086405f, -0.05943777f, 0.01520191f, 
    -0.02871451f, -0.03949052f, 0.12064122f, 0.07363362f, -0.24596351f, 0.10324255f, -0.04023725f, -0.07998516f, 
    -0.02540877f, 0.05518035f, -0.13272832f, -0.00627180f, 0.08673597f, -0.01598890f, 0.03157651f, 0.07700786f, 
    0.36986461f, -0.61755264f, 0.32281667f, -0.52872580f, 0.02814738f, 0.13055643f, -0.10767224f, 0.25937226f, 
    0.02309107f, 0.04344691f, 0.03481323f, -0.07009756f, 0.18223308f, 0.03525285f, -0.06565347f, -0.11808189f, 
    0.13066483f, 0.07058596f, 0.11317905f, 0.17323351f, -0.03889849f, -0.10851292f, -0.03817113f, 0.04821211f, 
    0.15570620f, 0.08608257f, 0.22739176f, 0.01325513f, 0.00678305f, 0.01585775f, -0.06579946f, 0.10964623f, 
    0.10763384f, -0.04173338f, 0.02574839f, 0.04676026f, 0.03679196f, 0.20600036f, -0.14454117f, -0.14969052f, 
    -0.06844562f, 0.04186831f, 0.06855845f, -0.08974750f, -0.04121358f, -0.03876204f, 0.05875058f, 0.13433237f, 
    0.26065335f, -0.11189822f, 0.00902875f, -0.16351022f, -0.11848943f, -0.06742509f, -0.08374917f, -0.03809970f, 
    -0.08334070f, -0.00553952f, -0.00236041f, -0.01535505f, -0.16688740f, -0.03962253f, -0.24503310f, 0.00279983f, 
    0.13914897f, 0.13330631f, -0.08237800f, 0.18591470f, -0.06072169f, -0.03482817f, -0.01520216f, -0.06301624f, 
    0.15671246f, 0.16209155f, 0.12169185f, -0.27083701f, 0.00429989f, 0.01644302f, -0.12236281f, 0.12729681f, 
    -0.01038710f, -0.08516733f, 0.14578377f, -0.01555832f, 0.15815453f, 0.10948834f, 0.05514232f, -0.04482105f, 
    -0.06861960f, 0.06585383f, 0.05044504f, -0.07262530f, 0.11396269f, -0.10148896f, -0.01292800f, 0.02813827f, 
    0.01750976f, -0.20787138f, -0.11375187f, 0.20392239f, -0.06427472f, -0.06749874f, 0.02625895f, 0.03374043f, 
    0.03903023f, 0.10537827f, -0.16473824f, -0.05441917f, 0.13703355f, 0.40472639f, 0.22502895f, -0.04876665f, 
    0.01849374f, -0.07353669f, 0.08082230f, 0.11291997f, -0.00623214f, 0.07787038f, 0.00041012f, -0.08065676f, 
    0.02731192f, -0.22965464f, -0.17455171f, 0.23793779f, -0.01552963f, 0.10065127f, 0.07394680f, 0.01849212f, 
    0.04802831f, -0.04216674f, -0.02634019f, -0.16765551f, -0.50292253f, 0.31321493f, 0.09593552f, -0.18641588f, 
    -0.07389701f, -0.19303225f, -0.10311574f, -0.02385425f, 0.10033450f, -0.04764007f, 0.00765478f, 0.01172504f, 
    0.18892005f, 0.11541405f, 0.06067312f, 0.00059377f, 0.02316811f, 0.01449278f, 0.08860780f, 0.11763150f, 
    -0.06426509f, 0.01206643f, 0.09126150f, -0.18880652f, 0.69988614f, 0.15996233f, 0.10495064f, -0.03705123f, 
    0.05956058f, -0.12648197f, 0.01722384f, 0.24845700f, 0.12218825f, 0.10745139f, 0.19291332f, -0.05638482f, 
    -0.01149012f, -0.08993040f, -0.10491043f, 0.18697724f, -0.00582863f, 0.01975344f, -0.01188725f, 0.01324878f, 
    0.04501865f, -0.19491585f, 0.17126220f, -0.01315556f, -0.21258138f, 0.04454452f, 0.14619182f, -0.14049122f, 
    -0.05716933f, -0.09871253f, 0.06559044f, 0.01660329f, 0.18008460f, -0.01442611f, 0.13104063f, -0.00731866f, 
    -0.05740517f, -0.23146805f, 0.12358177f, -0.26399329f, 0.16119242f, 0.15117511f, 0.01341309f, 0.26976261f, 
    -0.00063022f, 0.15724868f, -0.07620053f, -0.05564855f, 0.11856711f, -0.02177780f, -0.03828936f, -0.17110439f, 
    0.15621626f, 0.02052194f, -0.07570994f, 0.10729957f, 0.04408101f, -0.04283107f, 0.05101740f, -0.08416531f, 
    -0.23854196f, 0.09705845f, 0.25794876f, 0.00505215f, -0.03132366f, 0.07342815f, 0.09705032f, -0.05275114f, 
    -0.00383237f, 0.00532466f, 0.01853494f, 0.03730470f, -0.09082951f, -0.10259514f, -0.19498093f, 0.11562933f, 
    0.12286072f, 0.00656409f, 0.20149799f, 0.03425089f, 0.00424715f, 0.08534956f, -0.03346037f, 0.02936053f, 
    -0.03328265f, 0.07305336f, 0.08245607f, -0.28529191f, 0.01276967f, -0.11572137f, -0.10320295f, 0.26875430f, 
    -0.06003979f, 0.08072185f, -0.06095909f, 0.05123224f, 0.11175241f, -0.06821786f, -0.33819166f, -0.01597713f, 
    0.17152996f, 0.15335964f, 0.02764786f, 0.19257706f, 0.00489278f, 0.05455552f, -0.00473084f, 0.06583272f, 
    -0.03545574f, 0.15072249f, 0.02483984f, -0.29068658f, -0.12932950f, 0.01403754f, 0.08695819f, 0.14181663f, 
    0.05800156f, 0.05183112f, 0.13036014f, -0.05898136f, -0.27487752f, -0.11699927f, 0.33358595f, 0.20747945f, 
    -0.06120368f, -0.01770919f, -0.02407704f, -0.05281296f, 0.05691100f, 0.03275197f, -0.00598329f, 0.10150320f, 
    -0.12030837f, -0.24083562f, 0.03092270f, 0.04912225f, 0.02196904f, -0.04426611f, -0.02027294f, -0.17644441f, 
    0.06770916f, 0.18815987f, 0.07472149f, 0.03757856f, -0.03286749f, 0.06122825f, 0.16341126f, -0.02421125f, 
    0.17207722f, 0.00950863f, 0.03188218f, -0.05683349f, -0.01669068f, -0.09940225f, -0.09687601f, -0.00437016f, 
    -0.10863774f, 0.04115104f, 0.03237468f, 0.16975780f, -0.10772856f, -0.07650416f, -0.15773581f, 0.07958370f, 
    0.03853394f, -0.19343589f, 0.01718284f, -0.07695761f, -0.10138240f, -0.10512036f, -0.12585692f, 0.06899708f, 
    0.06026270f, -0.03017935f, -0.02926794f, 0.11343271f, 0.17534418f, -0.16282174f, 0.07454179f, 0.08781993f, 
    -0.03539908f, -0.04512294f, 0.09032382f, -0.08928300f, 0.10993180f, 0.01411323f, -0.07088246f, -0.14471230f, 
    0.04464173f, -0.08609868f, 0.11758790f, 0.02045608f, 0.47894612f, -0.24789840f, 0.08810977f, 0.16457455f, 
    -0.07648901f, 0.20563303f, -0.12422302f, 0.08333372f, 0.17673822f, -0.02939519f, -0.04995114f, 0.05187870f, 
    0.13992061f, 0.00013138f, 0.00404085f, 0.08813386f, 0.12145657f, 0.11409324f, 0.09671751f, -0.01595940f, 
    0.18896957f, -0.06509952f, 0.02350493f, 0.02302099f, -0.15719694f, -0.02389369f, 0.19045742f, -0.15641797f, 
    -0.10584163f, -0.12578398f, 0.00730476f, 0.04212958f, -0.03552243f, -0.07835568f, 0.07333823f, -0.09499151f, 
    -0.09752628f, 0.26444042f, 0.23089279f, 0.13963091f, 0.18944384f, 0.01899744f, 0.10545548f, -0.01901182f, 
    0.00367131f, -0.00506293f, -0.07087974f, -0.07020058f, -0.07391700f, 0.03642022f, 0.09186509f, 0.00295137f, 
    -0.03363250f, 0.01478739f, -0.04393245f, -0.09676506f, 0.05804075f, -0.04987763f, -0.00155664f, -0.00182646f, 
    -0.19115233f, 0.01373409f, 0.26185220f, 0.12104973f, -0.08887952f, -0.01342468f, 0.13180436f, -0.03217284f, 
    -0.06454338f, -0.02798850f, 0.09477957f, 0.06015698f, 0.03248703f, -0.34332061f, -0.17249767f, 0.19684365f, 
    0.11407081f, 0.08944745f, 0.05345713f, 0.01711274f, 0.03431714f, -0.01456750f, -0.10200818f, -0.03129742f, 
    -0.12313595f, 0.15003932f, -0.03022311f, -0.10666554f, 0.01081659f, -0.13635798f, 0.05992497f, 0.07081364f, 
    0.15640096f, 0.01748514f, 0.00422933f, 0.07326666f, 0.17874914f, -0.06386939f, -0.17467450f, -0.10939132f, 
    0.15419604f, -0.06464189f, -0.00656128f, 0.06074470f, 0.11890285f, -0.03252196f, -0.04639474f, 0.05619665f, 
    -0.05756539f, 0.14238299f, -0.02398579f, 0.12062233f, 0.00438250f, -0.06347096f, 0.09454861f, 0.06849323f, 
    0.05944242f, 0.01603452f, 0.17970993f, 0.09239022f, -0.05793037f, -0.24395849f, 0.29324451f, 0.21352486f, 
    -0.11608213f, 0.02484343f, 0.01148520f, 0.00877091f, -0.06518038f, 0.06863710f, 0.02525098f, 0.09515898f, 
    0.07175696f, -0.11712876f, 0.06751581f, 0.04137983f, 0.04040748f, -0.06096300f, -0.01677606f, 0.02853404f, 
    -0.03159327f, -0.12167992f, -0.06777312f, 0.04385167f, 0.06363098f, 0.07112954f, 0.21351936f, 0.08194662f, 
    -0.05119048f, 0.02172125f, -0.02852915f, -0.17650299f, 0.04350675f, 0.04264881f, -0.01565333f, 0.06934109f, 
    0.22675759f, 0.25010192f, -0.13051824f, 0.03609492f, -0.13349655f, -0.06369969f, 0.05692735f, 0.07246684f, 
    -0.04319650f, 0.07129617f, -0.00285374f, -0.03900817f, 0.11969039f, -0.11252134f, 0.16002706f, -0.13965839f, 
    -0.08458427f, -0.21207850f, -0.02397291f, -0.09323330f, -0.06839646f, -0.04541057f, -0.07146285f, 0.09111205f, 
    -0.17082439f, 0.33540329f, 0.35876897f, 0.22487004f, 0.02980376f, -0.01425236f, -0.04052932f, -0.03143425f, 
    -0.02069714f, 0.04906439f, -0.03831921f, -0.06570790f, -0.00679552f, 0.02388447f, 0.06947785f, 0.04830367f, 
    0.12765090f, 0.09557060f, 0.17181997f, 0.05261391f, 0.06695892f, 0.06004238f, 0.05790668f, 0.05466579f, 
    0.07898354f, 0.18741938f, 0.01433632f, -0.03782687f, -0.00750687f, -0.04934610f, -0.06794885f, -0.02550137f, 
    -0.11420744f, -0.13802199f, -0.04734460f, -0.04098875f, -0.15668444f, 0.13906628f, 0.08938301f, 0.15686807f, 
    0.06367683f, -0.07512416f, -0.00190028f, -0.08317877f, -0.00429832f, 0.05757193f, -0.06113903f, -0.13097222f, 
    -0.48633152f, 0.24301703f, -0.08592192f, -0.01142726f, -0.16185282f, 0.08516234f, -0.03044099f, 0.47046763f, 
    0.01526715f, 0.04393847f, 0.06025674f, 0.02766751f, -0.00194387f, -0.04129265f, 0.14020799f, -0.14670008f, 
    0.03324170f, 0.15089521f, -0.14365485f, 0.01526485f, -0.04216067f, -0.05922510f, 0.06997256f, 0.00190303f, 
    -0.29605827f, -0.26739612f, -0.02620181f, 0.09057936f, 0.01830509f, 0.00665502f, -0.15340440f, 0.03950061f, 
    -0.03991980f, -0.06775902f, -0.06266929f, -0.05744319f, 0.12371987f, 0.01461287f, 0.11096469f, -0.15021047f, 
    -0.00875425f, -0.06094676f, 0.18738869f, 0.04292881f, -0.11692332f, 0.03372236f, 0.17413896f, -0.11974632f, 
    0.12526813f, 0.07531784f, 0.25947160f, -0.05281220f, 0.04247699f, 0.00492306f, -0.00533953f, 0.17433073f, 
    0.07765012f, 0.09460546f, -0.01314965f, 0.00485822f, 0.24059291f, 0.02750201f, 0.11701221f, -0.13614720f, 
    -0.09178632f, 0.13228801f, 0.00603455f, -0.06300267f, -0.13378590f, 0.01549752f, -0.00777796f, 0.01586434f, 
    0.17601426f, 0.10899425f, 0.04555881f, 0.01879859f, -0.06456858f, -0.11711812f, 0.09808645f, 0.07297115f, 
    0.05251449f, 0.11300407f, -0.07445844f, 0.03492625f, -0.06469107f, 0.36393011f, 0.00491162f, 0.18616106f, 
    0.08630630f, 0.13594669f, -0.19861092f, 0.21934147f, 0.04683076f, 0.03980867f, -0.02997754f, -0.24813290f, 
    0.10476358f, -0.00961485f, 0.21464184f, -0.11626659f, -0.16828559f, -0.10257860f, 0.07050833f, -0.11227440f, 
    0.12946747f, 0.06581847f, -0.04982360f, -0.01168433f, -0.19988172f, -0.34983107f, -0.10304816f, 0.03324492f, 
    0.10923115f, -0.02550620f, -0.06714349f, -0.11116863f, 0.13398845f, -0.06501719f, 0.04599947f, 0.18461472f, 
    -0.28433231f, -0.48304790f, -0.12787722f, -0.07931305f, 0.06964602f, -0.01597178f, -0.04586047f, -0.00343345f, 
    -0.00747127f, -0.02856790f, 0.08529183f, 0.05812458f, -0.10588349f, 0.31532732f, 0.11907589f, 0.03305587f, 
    0.04318949f, 0.05396113f, 0.08449465f, 0.03598838f, 0.00867662f, -0.04089976f, 0.09340201f, 0.08773177f, 
    0.35747734f, 0.07970737f, 0.40325019f, -0.14411356f, -0.02263549f, 0.07464988f, -0.06043749f, 0.15333086f, 
    0.02455749f, -0.17433964f, -0.06070218f, -0.09600781f, -0.08198013f, -0.24607077f, 0.11011242f, -0.06838191f, 
    -0.00951491f, -0.00368944f, -0.17193620f, -0.09690531f, 0.13303137f, 0.03953050f, -0.09660235f, -0.02070994f, 
    -0.14963366f, -0.28364384f, -0.16217536f, -0.17210265f, -0.09002616f, 0.04133392f, 0.00688311f, -0.01793205f, 
    0.10166956f, 0.04995422f, 0.05043667f, 0.15573837f, -0.12160841f, 0.16884162f, 0.13174480f, 0.09854799f, 
    -0.07364753f, -0.10655577f, -0.00520245f, 0.14904456f, 0.01739781f, -0.07712719f, 0.04887081f, 0.03586549f, 
    0.17501289f, 0.09827731f, 0.34482184f, -0.43315479f, -0.10783713f, 0.04150202f, -0.01447464f, -0.00485365f, 
    -0.06524789f, -0.03837616f, -0.09557478f, -0.00976500f, 0.29334679f, 0.29388484f, 0.22222550f, 0.10274868f, 
    0.01267153f, 0.05821579f, 0.02207900f, 0.10873029f, -0.00669507f, -0.08416567f, -0.06439670f, -0.10195144f, 
    -0.13791157f, 0.03108378f, 0.41572067f, 0.23782775f, -0.19679761f, 0.00911076f, 0.02820132f, 0.18812518f, 
    0.09592416f, -0.05815965f, -0.10063905f, 0.05785149f, -0.01267854f, -0.00331202f, -0.18436882f, 0.03997212f, 
    0.07159093f, 0.23036692f, 0.10056691f, 0.02428947f, 0.13336474f, 0.00152119f, 0.10076223f, 0.03253878f, 
    0.31056893f, -0.01982253f, 0.16119546f, 0.02842898f, -0.04460855f, 0.03663465f, 0.08626144f, -0.11309748f, 
    0.09082379f, 0.05104903f, -0.02626040f, -0.02130226f, 0.30334392f, 0.12921208f, -0.08694232f, 0.03038242f, 
    0.04317064f, -0.04914656f, -0.00098229f, 0.01931802f, 0.04487515f, 0.02755346f, 0.04783342f, 0.02254267f, 
    0.12389963f, 0.20542672f, 0.09055141f, -0.04380001f, -0.02630179f, 0.05673724f, 0.00176431f, 0.03048487f, 
    0.02471786f, -0.06052898f, 0.08883151f, 0.13204841f, 0.05950953f, 0.04406088f, 0.13730919f, 0.09488301f, 
    -0.07662065f, 0.05447530f, 0.03404711f, -0.17643020f, 0.05568047f, -0.16191454f, -0.01516607f, 0.07947785f, 
    -0.07452200f, -0.31697091f, -0.32809684f, 0.01847858f, 0.07343013f, 0.00696257f, -0.00486880f, -0.01153388f, 
    0.07030044f, -0.00471540f, -0.00459096f, -0.04562537f, 0.18300954f, 0.34516588f, 0.36946639f, 0.08106703f, 
    -0.04173912f, -0.02872710f, 0.03488160f, 0.05425489f, -0.03112201f, -0.00332103f, -0.08280230f, 0.09457967f, 
    -0.02114452f, 0.08400954f, -0.04434494f, -0.23721282f, -0.21684799f, -0.01326774f, -0.40317318f, -0.00502919f, 
    0.02710719f, 0.03079838f, -0.10089357f, 0.12394910f, 0.65777099f, -0.10671716f, 0.04097175f, 0.01664278f, 
    0.16214803f, 0.02727562f, 0.10125022f, 0.01080144f, -0.06053890f, -0.00124483f, 0.01487894f, 0.02606498f, 
    -0.30420172f, 0.05764166f, 0.08112662f, 0.06939034f, -0.12705964f, 0.01990183f, 0.05142232f, 0.13315627f, 
    -0.10478219f, -0.08244243f, -0.03947252f, 0.08870355f, -0.18188573f, -0.13329923f, -0.18742295f, 0.12494645f, 
    -0.05024181f, -0.05148133f, 0.09988037f, -0.25169221f, 0.01262784f, 0.11635692f, 0.10036081f, 0.05053552f, 
    -0.09551243f, 0.05426858f, 0.09811267f, -0.29597491f, -0.17959081f, -0.11258543f, 0.00201208f, -0.04918090f, 
    -0.03167602f, 0.29907688f, 0.11315746f, 0.05005627f, 0.20579432f, -0.02238710f, -0.08786162f, 0.05101214f, 
    0.08193517f, -0.04649889f, 0.17588475f, 0.07455565f, 0.03500829f, 0.05551435f, 0.07960659f, 0.11481836f, 
    -0.34845984f, 0.27051589f, 0.06933922f, 0.28485572f, 0.06452143f, 0.10530436f, -0.06926509f, 0.14448416f, 
    -0.08859878f, -0.00186972f, 0.14070272f, 0.00477089f, -0.04696636f, 0.09353536f, 0.08742494f, 0.13267300f, 
    -0.10219583f, 0.10872465f, 0.08642641f, 0.09915767f, 0.02718511f, 0.02443497f, 0.05945568f, -0.02286780f, 
    -0.10326492f, -0.03832917f, -0.25412935f, 0.04683381f, 0.01262793f, 0.00168676f, -0.03845268f, 0.15396298f, 
    -0.08259433f, 0.01126130f, 0.09099397f, 0.09077532f, 0.11424938f, 0.27864951f, 0.15077697f, 0.14664359f, 
    -0.10936316f, -0.09311651f, -0.14659612f, -0.01131341f, 0.04261056f, 0.07299076f, -0.25181809f, 0.13506700f, 
    -0.23551615f, 0.07272115f, 0.02792736f, 0.17841183f, 0.01373622f, 0.09956830f, 0.16958867f, 0.04972058f, 
    -0.07917275f, 0.13512613f, -0.01603201f, 0.04438632f, -0.08559754f, 0.17054282f, 0.34098306f, 0.11513814f, 
    0.06338248f, -0.14238074f, -0.01741089f, 0.11693236f, -0.13621309f, -0.00534826f, -0.00276715f, -0.18019514f, 
    -0.12745488f, -0.06855188f, 0.04211872f, 0.09749471f, 0.01090864f, 0.01193847f, 0.06291671f, -0.05499711f, 
    0.09178087f, 0.08220681f, -0.14276767f, -0.02313811f, 0.13207151f, -0.09839885f, 0.00705989f, -0.10120307f, 
    0.10405441f, 0.01915233f, -0.06712125f, 0.02583318f, -0.05544623f, 0.09682795f, 0.00908392f, -0.01802633f, 
    0.11358000f, -0.02549704f, -0.03360569f, -0.20090161f, 0.11288751f, 0.20671770f, 0.03488342f, -0.07888748f, 
    -0.08199222f, -0.02192362f, -0.05018758f, 0.09108136f, -0.14105344f, -0.11047084f, -0.05698175f, 0.14066029f, 
    0.02983859f, 0.09054834f, 0.09769262f, 0.09791474f, 0.03909013f, 0.14055653f, -0.00752838f, -0.07061231f, 
    -0.06552948f, -0.05577208f, -0.03292089f, -0.04829755f, -0.07220339f, 0.00751792f, 0.04696812f, -0.00218462f, 
    -0.03027087f, -0.04540109f, -0.04787979f, 0.04393277f, -0.01525667f, 0.02530031f, 0.05398480f, -0.02366787f, 
    0.03957209f, 0.02185606f, -0.05612125f, 0.05781415f, -0.07584774f, -0.05392560f, 0.00746241f, -0.01579592f, 
    -0.02627273f, -0.01382382f, 0.05671112f, 0.01389189f, 0.01060776f, -0.03377605f, -0.01310528f, -0.01258190f, 
    0.04374985f, 0.05195022f, -0.05883673f, -0.03159999f, -0.03749591f, -0.00570392f, 0.04117928f, 0.03201672f, 
    0.06424747f, 0.00125322f, 0.04687414f, 0.03425876f, -0.07043720f, 0.00110802f, -0.07376498f, -0.03516991f, 
    -0.00374238f, -0.02344233f, 0.04779401f, -0.05394528f, 0.00495490f, 0.01141370f, 0.00952253f, -0.00071309f, 
    0.04047100f, 0.01823823f, 0.04277594f, -0.04735266f, -0.07640006f, 0.04587997f, 0.02365195f, 0.05027196f, 
    -0.08403776f, 0.04000586f, 0.05705080f, -0.01805101f, -0.07820452f, -0.05898662f, 0.01883225f, 0.03712627f, 
    0.05384480f, 0.05445624f, -0.00938413f, 0.03241599f, -0.04828815f, 0.01399386f, -0.07094425f, 0.02973051f, 
    0.05426726f, -0.05829759f, -0.04990807f, 0.02840020f, -0.04505681f, 0.06577624f, -0.01544215f, -0.00732934f, 
    -0.05949800f, -0.05170043f, 0.05950255f, -0.04716748f, 0.00438640f, -0.07288979f, -0.04350755f, 0.01740702f, 
    0.01163301f, -0.05236132f, -0.00219769f, -0.02938855f, 0.00611059f, -0.02735713f, 0.01802420f, -0.04698368f, 
    0.04080357f, 0.05343006f, 0.05712250f, -0.04189191f, 0.03128944f, -0.01216185f, -0.07866630f, -0.01634327f, 
    -0.07379824f, -0.03621775f, 0.04816979f, 0.01182099f, 0.00164416f, 0.00179743f, -0.07898054f, -0.07363321f, 
    -0.01316911f, -0.07931212f, -0.05624561f, -0.05368144f, -0.06834913f, 0.00586101f, -0.00287967f, -0.06538048f, 
    -0.02346167f, -0.00910364f, -0.06963976f, 0.01284938f, -0.03853133f, 0.02339571f, 0.06209815f, -0.04562616f, 
    -0.06635934f, -0.01333678f, -0.03339543f, 0.03496193f, 0.03999501f, 0.02827495f, 0.05142148f, 0.00310554f, 
    -0.07211244f, 0.00488969f, -0.06647515f, -0.08291104f, 0.02563121f, -0.04167731f, 0.01812111f, -0.03832737f, 
    -0.00306545f, -0.02586774f, -0.08311398f, 0.00072750f, -0.01582804f, 0.05795704f, -0.02538086f, 0.06064923f, 
    0.01045881f, -0.01072825f, -0.00279561f, 0.00242233f, 0.05494415f, 0.00370627f, -0.00811965f, -0.02791393f, 
    -0.03744047f, 0.06600529f, -0.03024459f, 0.03286838f, 0.02582713f, -0.06745341f, 0.03157069f, -0.07190390f, 
    0.04899749f, 0.03004691f, -0.07879160f, -0.05625015f, 0.00467933f, -0.07168901f, 0.03995587f, -0.08076990f, 
    0.04506388f, 0.02655570f, 0.05186002f, 0.01853656f, -0.07212754f, -0.05662882f, 0.04631694f, 0.04768280f, 
    -0.04472240f, 0.06459226f, 0.02009418f, 0.22446015f, 0.02049996f, -0.19258133f, -0.01770534f, 0.01785416f, 
    0.03167542f, 0.00125252f, -0.06952920f, -0.06862021f, -0.47232780f, 0.25249484f, 0.01460436f, 0.02317150f, 
    -0.02569774f, -0.06571229f, -0.03150659f, -0.14566560f, -0.03323406f, 0.14372919f, 0.08842426f, 0.16220003f, 
    0.12351261f, -0.09317967f, 0.38108683f, -0.09975854f, 0.08152483f, 0.15866880f, -0.04515998f, 0.19403085f, 
    -0.02202370f, 0.02059579f, -0.04734131f, -0.10591522f, 0.18572642f, -0.14530498f, 0.40923879f, -0.01495807f, 
    0.26044154f, 0.07804746f, -0.16807982f, 0.06763227f, 0.19286396f, 0.07901973f, 0.00718855f, 0.10667394f, 
    -0.14328147f, -0.08885220f, -0.17054500f, -0.01062190f, -0.02741439f, -0.04648330f, -0.06389739f, -0.10974630f, 
    0.16572882f, -0.06966246f, -0.05888605f, 0.04646200f, -0.22478978f, 0.18855086f, 0.17344601f, 0.10805512f, 
    0.02188539f, -0.21878795f, 0.01869521f, 0.13355960f, -0.01644366f, -0.01497286f, 0.01724428f, -0.14701571f, 
    0.30023623f, 0.29561359f, -0.16700809f, -0.21929683f, -0.05166416f, -0.00513831f, 0.07648864f, -0.07213144f, 
    -0.13096707f, -0.09512610f, 0.07376658f, -0.09147280f, 0.08853353f, -0.11869016f, -0.00448577f, -0.20626003f, 
    0.05656628f, 0.28645903f, 0.02518624f, 0.09725418f, 0.01506933f, 0.10040504f, 0.02474649f, -0.06344968f, 
    -0.27888733f, 0.10414948f, 0.30916229f, -0.05297790f, 0.02580078f, 0.01746743f, 0.21318525f, -0.02943234f, 
    0.11816425f, -0.01164661f, -0.15775618f, 0.01368576f, -0.06238143f, 0.11772568f, -0.31236458f, -0.07232133f, 
    0.11575063f, -0.02421879f, 0.05020720f, 0.07182508f, 0.14656588f, 0.14019552f, 0.26151252f, -0.02103705f, 
    0.29846248f, -0.14622459f, 0.39551356f, -0.14949188f, -0.06060968f, 0.08234553f, 0.04019099f, 0.10095178f, 
    0.12289093f, 0.05953628f, 0.01315079f, -0.03300666f, 0.29603556f, 0.08365205f, -0.09353527f, 0.01640991f, 
    0.01144561f, 0.14157271f, -0.02885033f, 0.05207563f, -0.00704723f, -0.10074335f, 0.07544129f, 0.09927132f, 
    0.05748985f, 0.12012357f, 0.08161309f, -0.24874112f, -0.07782895f, 0.01258331f, -0.02498057f, 0.15187196f, 
    0.09490144f, -0.11561206f, 0.04867210f, 0.07481702f, -0.33311841f, -0.17276645f, 0.14277120f, 0.18306844f, 
    0.05687723f, 0.01863638f, 0.06992164f, -0.07955441f, -0.01353907f, -0.28726998f, 0.11016686f, 0.01325649f, 
    -0.04475911f, -0.22712773f, -0.17158280f, 0.14728583f, -0.09856763f, -0.15162808f, 0.05870776f, -0.10639689f, 
    -0.01258625f, -0.01587023f, 0.06503500f, -0.03671044f, -0.07620408f, 0.08618631f, 0.09532112f, -0.17059931f, 
    0.11243255f, 0.20494723f, 0.07750674f, -0.00998127f, 0.02337297f, -0.12788460f, -0.02272510f, 0.21961753f, 
    0.00507805f, 0.00507794f, -0.10024592f, -0.10057980f, 0.00815261f, -0.01522836f, -0.06770913f, -0.05000840f, 
    -0.07808918f, 0.00858135f, -0.06807891f, 0.01842222f, -0.01966759f, 0.00627652f, -0.07487336f, -0.05403610f, 
    0.02800059f, -0.05190651f, 0.01184214f, -0.05807785f, 0.02742585f, -0.03520645f, 0.01145680f, -0.10398872f, 
    -0.07938882f, -0.06723668f, 0.01131143f, -0.07669406f, 0.05554161f, -0.05316559f, 0.03126382f, -0.08144948f, 
    -0.09594524f, -0.05208306f, -0.06379414f, -0.07161625f, 0.03003925f, -0.06560742f, -0.02748584f, 0.02604232f, 
    -0.00598325f, -0.11172631f, -0.01806480f, -0.10950296f, -0.04617086f, 0.00532679f, -0.00194187f, -0.08846124f, 
    -0.04836111f, -0.06342164f, -0.02784069f, -0.05825602f, 0.02158776f, -0.02322968f, -0.02778883f, -0.08067300f, 
    -0.07616545f, -0.02136071f, -0.07364766f, 0.01024765f, -0.02297552f, 0.00095091f, 0.07928666f, -0.00607929f, 
    -0.07702718f, -0.06981586f, -0.05368120f, -0.05069501f, -0.01369930f, 0.00462134f, 0.01578680f, -0.03087101f, 
    -0.01913980f, -0.07730927f, 0.01498090f, -0.05461348f, 0.02833728f, -0.09168772f, -0.00586318f, -0.02428000f, 
    -0.01672495f, -0.00741306f, -0.02471726f, -0.05264593f, -0.01402123f, 0.00612723f, -0.06270626f, -0.01829056f, 
    0.02712257f, -0.07798540f, -0.01441539f, 0.01206395f, -0.08438277f, 0.00848507f, -0.03792858f, -0.05394002f, 
    -0.04134271f, 0.02105111f, 0.00641360f, -0.06165647f, 0.03938295f, -0.07319902f, -0.03585069f, -0.04836043f, 
    0.01742049f, -0.00281832f, -0.01214581f, -0.08201389f, 0.03192884f, -0.06199479f, 0.03029964f, -0.03968965f, 
    0.03949106f, -0.10551164f, -0.06310295f, -0.10241217f, 0.00295531f, -0.04843657f, 0.01769506f, -0.08131821f, 
    0.00290474f, -0.02806561f, 0.05918083f, 0.03535526f, -0.01513478f, -0.02295438f, 0.01293355f, -0.00442182f, 
    -0.10741624f, -0.01011867f, -0.03670810f, 0.04376536f, -0.01410715f, -0.02976915f, -0.01223862f, -0.03479301f, 
    -0.06751864f, -0.00091003f, -0.05822047f, 0.02708447f, -0.05117638f, 0.00324560f, -0.06492170f, -0.01233549f, 
    0.05025781f, -0.05732498f, -0.06657425f, -0.01156360f, -0.04705467f, -0.07715546f, 0.02683079f, -0.06901936f, 
    0.02663222f, -0.04962289f, 0.02322135f, -0.06264449f, -0.01119913f, -0.03293733f, -0.02541432f, 0.04538026f, 
    -0.07037046f, -0.02568771f, -0.10991041f, -0.04066994f, 0.00313874f, 0.02197566f, 0.01857378f, -0.08264759f, 
    -0.03857503f, -0.08515654f, 0.00535696f, -0.07142138f, -0.00087295f, 0.00210463f, -0.02651441f, -0.01992134f, 
    -0.02840111f, -0.11251017f, 0.00976785f, 0.02534474f, -0.03486618f, -0.05401230f, 0.05685633f, -0.05102289f, 
    -0.00080685f, -0.00410464f, 0.01817604f, -0.06034471f, -0.07685845f, -0.03712192f, 0.01369266f, -0.07880966f, 
    -0.08469828f, 0.17175117f, 0.00412393f, -0.02443968f, -0.02030701f, -0.08105595f, -0.02294155f, -0.10956252f, 
    -0.08291499f, -0.00486246f, -0.07937700f, -0.07492132f, -0.03344106f, -0.20707217f, -0.31024975f, -0.17179111f, 
    0.04022161f, 0.02232420f, 0.01985213f, -0.07496110f, -0.00187897f, 0.20967413f, -0.00078678f, 0.00727661f, 
    0.18788315f, 0.27877337f, -0.18998376f, 0.15272400f, 0.03926557f, 0.09900629f, 0.01591065f, 0.06041930f, 
    -0.17077690f, 0.13723816f, 0.02856391f, 0.06449965f, 0.02795995f, -0.16472937f, 0.12208241f, -0.02345986f, 
    0.02653613f, -0.06453642f, -0.03789885f, 0.11157891f, 0.04340457f, -0.11320339f, -0.08205154f, -0.00466198f, 
    -0.09366125f, 0.05683566f, -0.01317269f, 0.02539971f, -0.01027731f, 0.02089749f, -0.06786601f, -0.04890797f, 
    -0.22464772f, -0.13818608f, -0.14280623f, -0.13308018f, 0.15807664f, 0.14108185f, 0.15485978f, 0.00528824f, 
    0.01697639f, 0.09226912f, 0.06710444f, 0.13585830f, -0.16320813f, -0.02613573f, -0.02978167f, -0.18493888f, 
    0.21540560f, 0.30340981f, -0.12396894f, 0.04321089f, -0.04760832f, 0.17265251f, 0.00073404f, 0.24316429f, 
    -0.00719021f, -0.02502042f, 0.01682086f, -0.05792825f, 0.16757457f, 0.11229352f, -0.02102753f, 0.13831370f, 
    0.05787385f, 0.21630818f, 0.25710857f, 0.13929677f, 0.04000433f, -0.01130900f, 0.10438695f, 0.10779667f, 
    0.34350842f, 0.25550780f, -0.05392298f, -0.02640251f, 0.02449310f, 0.15276025f, 0.15653124f, 0.10402934f, 
    0.02434354f, 0.06241269f, -0.08053614f, -0.03379077f, -0.22449473f, -0.12830029f, -0.03479284f, -0.24226260f, 
    -0.04473240f, -0.02264680f, 0.18116650f, 0.10140561f, -0.05400695f, 0.22165133f, 0.00973984f, -0.13728659f, 
    0.21615726f, -0.10681630f, -0.12306155f, 0.17970321f, 0.08425282f, 0.08334901f, -0.00881700f, 0.14534840f, 
    0.16610374f, 0.03320898f, 0.00170827f, -0.01849857f, 0.11273274f, -0.03517863f, 0.06332219f, 0.00626912f, 
    0.06641092f, 0.24729796f, 0.00165322f, -0.04865408f, 0.00702959f, 0.04290147f, 0.01742528f, 0.01097661f, 
    0.18576106f, -0.00465484f, -0.24914846f, 0.09424447f, 0.10477082f, -0.08030134f, -0.05858773f, 0.01873218f, 
    -0.04283620f, -0.04297008f, -0.01136394f, -0.17770706f, -0.11663318f, 0.26134726f, -0.01899086f, -0.28447539f, 
    0.19866456f, -0.00123028f, 0.10349025f, -0.04644396f, 0.11518053f, 0.02323111f, 0.08877381f, 0.03990284f, 
    -0.06839505f, 0.08108619f, 0.06831042f, 0.07039148f, -0.22033483f, -0.11229805f, -0.07691065f, -0.04365493f, 
    -0.06623165f, 0.07548396f, -0.07523186f, 0.04307909f, 0.27826267f, -0.00768535f, 0.02019178f, 0.03967658f, 
    0.07901774f, -0.04245447f, -0.05361881f, 0.06616251f, -0.12506746f, -0.02811813f, -0.00242269f, 0.03163128f, 
    -0.00306294f, -0.24652189f, 0.05663825f, 0.05408865f, 0.15343806f, -0.02457022f, 0.09913328f, -0.17801079f, 
    -0.06406894f, -0.08752280f, 0.08789026f, 0.00313766f, 0.02178737f, 0.10239037f, 0.11338003f, 0.15425497f, 
    0.07461139f, -0.00840961f, 0.10207880f, 0.01016532f, 0.12134402f, -0.14484429f, -0.06583952f, 0.06534832f, 
    0.27818751f, -0.06977557f, -0.02364680f, -0.16758820f, 0.03203388f, 0.03678452f, -0.00441283f, -0.01375885f, 
    -0.00804241f, -0.13782027f, -0.06578057f, 0.04989153f, -0.33930299f, 0.01167319f, 0.00785241f, -0.20092002f, 
    0.17139815f, 0.05397147f, 0.04387390f, -0.05245269f, -0.02570798f, 0.00338779f, 0.07219068f, 0.10224278f, 
    0.31374335f, -0.21185422f, -0.15416934f, -0.00071609f, -0.07380874f, -0.03358116f, 0.08422915f, 0.18412484f, 
    -0.07654671f, -0.05288797f, -0.05808344f, 0.02750862f, -0.29004222f, 0.08240402f, -0.05118842f, -0.02816671f, 
    -0.02668843f, 0.11855067f, -0.09758454f, 0.08843634f, 0.05686829f, -0.00741634f, 0.05502364f, 0.15661818f, 
    0.35929859f, -0.39173374f, 0.41652828f, -0.43750808f, -0.00139423f, -0.05244115f, 0.00932012f, 0.00665491f, 
    -0.03710616f, 0.11887090f, 0.02845274f, 0.05546383f, -0.00008615f, 0.01618565f, 0.01318862f, -0.12839399f, 
    0.06766456f, 0.02924483f, 0.01921128f, 0.21274909f, 0.02200828f, -0.13658820f, -0.11795725f, -0.12491812f, 
    0.05203447f, 0.00453660f, 0.23438197f, 0.14158371f, 0.05497002f, 0.08250904f, -0.08410624f, 0.10832370f, 
    0.17776546f, 0.00861672f, 0.02284997f, -0.00711825f, -0.03732454f, 0.28627685f, -0.23608783f, -0.38767576f, 
    0.01528598f, -0.13512434f, -0.06562813f, -0.23250830f, -0.04005615f, -0.16489181f, 0.07691623f, 0.22001795f, 
    0.22729765f, -0.10633161f, 0.07220944f, -0.05578981f, -0.05196670f, -0.09402145f, 0.00493812f, -0.08670610f, 
    0.03744362f, -0.09192389f, 0.00599319f, 0.06003863f, -0.07540835f, -0.10297722f, -0.26894560f, -0.09075381f, 
    0.04099785f, 0.06783285f, 0.02462644f, 0.24508420f, 0.00923688f, -0.03996963f, -0.12257367f, -0.09997167f, 
    0.06663015f, 0.07692824f, 0.06502293f, -0.18347628f, 0.19746472f, 0.12150719f, 0.00674899f, 0.03726092f, 
    0.08566086f, -0.01118203f, 0.06827486f, 0.01043175f, 0.10809572f, 0.18556051f, 0.08477827f, -0.03081570f, 
    -0.04724404f, 0.12240197f, 0.06989322f, -0.04024624f, 0.02770198f, -0.08184748f, -0.06523464f, 0.00566573f, 
    0.05800210f, -0.18654792f, -0.12965971f, 0.26893669f, 0.05130533f, -0.18270063f, -0.08898416f, -0.09665752f, 
    0.11848115f, -0.08181613f, -0.21445094f, -0.04756709f, 0.16708633f, 0.33078361f, 0.13356765f, -0.01204489f, 
    0.09818640f, 0.10169595f, 0.07269541f, 0.05087106f, 0.06427829f, 0.06499686f, 0.11066005f, 0.05537257f, 
    0.07480878f, 0.00253364f, 0.09214772f, 0.01762388f, -0.01549222f, -0.11335567f, 0.04452493f, -0.05374224f, 
    -0.04894233f, 0.01293634f, 0.12734435f, -0.02070193f, 0.36022574f, 0.29508060f, 0.16704343f, 0.13293369f, 
    -0.09471573f, -0.08794221f, 0.02815799f, -0.05733963f, -0.01980655f, -0.04065148f, -0.01599711f, -0.00670269f, 
    -0.01328938f, -0.08811427f, 0.25588897f, -0.17561877f, -0.01062103f, 0.05719020f, -0.02456291f, 0.09966900f, 
    0.11587115f, -0.05823068f, -0.04539605f, -0.10517096f, -0.66848272f, -0.10194950f, 0.12217429f, -0.07531258f, 
    -0.02047642f, 0.06973877f, 0.05366827f, -0.20370604f, 0.08182179f, 0.07118329f, 0.02992932f, 0.09434877f, 
    0.27757648f, 0.01769230f, 0.01937834f, -0.12190223f, -0.09864374f, -0.08766203f, 0.00021876f, -0.05103445f, 
    0.04033418f, 0.08603998f, -0.15242381f, 0.14840750f, -0.22217019f, 0.12792534f, -0.15812559f, 0.11449993f, 
    0.16587402f, 0.03437348f, -0.14917248f, 0.07706837f, -0.04386726f, 0.09900504f, -0.03074713f, -0.10036039f, 
    0.05166250f, -0.02901063f, 0.15176648f, -0.29249495f, -0.02134166f, 0.07006241f, -0.07092951f, -0.15020400f, 
    -0.01965948f, -0.07962023f, 0.13649251f, -0.05188131f, -0.02115917f, 0.02004552f, 0.22272795f, -0.01514153f, 
    0.04691783f, 0.10810024f, 0.18225145f, 0.11799438f, -0.07346075f, 0.02329748f, -0.01958776f, -0.11170223f, 
    -0.06665181f, -0.20297140f, 0.08167043f, 0.12029634f, 0.01497000f, -0.06539566f, -0.06476854f, 0.19659102f, 
    0.12494720f, -0.05117562f, -0.19685383f, -0.11247540f, 0.12887944f, 0.35180187f, 0.01620483f, -0.19129914f, 
    -0.06664853f, -0.05820971f, -0.05574456f, 0.03225661f, -0.02647135f, -0.03236912f, 0.15352683f, 0.01520442f, 
    0.42326638f, 0.00044811f, 0.23288612f, 0.10172784f, -0.18251103f, -0.01871637f, 0.07817532f, -0.16008265f, 
    0.04832868f, -0.02877999f, 0.03983641f, 0.00593025f, -0.05234927f, 0.05059618f, -0.14282848f, -0.06721988f, 
    -0.06605122f, -0.05038211f, 0.05122092f, -0.13122958f, -0.07220334f, -0.08769625f, -0.02596241f, 0.01803875f, 
    0.20993035f, 0.04298844f, 0.19164993f, -0.08709504f, 0.06047298f, 0.03554683f, -0.07755765f, 0.02994106f, 
    0.15020202f, 0.05168872f, -0.03314992f, -0.00355380f, 0.12842277f, 0.23125786f, -0.01495359f, -0.01131733f, 
    -0.17483059f, 0.07119509f, -0.07798042f, 0.01039334f, 0.06386501f, -0.14268360f, 0.10694544f, -0.06525662f, 
    0.05051815f, -0.01588845f, -0.03778115f, 0.16842535f, -0.04733358f, 0.03490831f, 0.08144722f, 0.10738562f, 
    -0.00982959f, -0.01053568f, 0.00987103f, -0.15624930f, -0.03234103f, 0.09830947f, 0.06299931f, 0.03504013f, 
    -0.00857971f, 0.00630138f, 0.02210868f, 0.06737645f, 0.12995782f, -0.01958377f, -0.00905256f, 0.05693034f, 
    0.17132509f, 0.41605756f, 0.11938559f, -0.13426721f, -0.13090932f, -0.04218723f, 0.01756701f, -0.07116103f, 
    0.01500697f, -0.01807474f, 0.01244828f, 0.14533482f, 0.47097182f, -0.32554924f, -0.19867466f, 0.10410671f, 
    -0.05995066f, 0.04212506f, 0.03681146f, 0.04748397f, -0.09648828f, -0.03971042f, -0.02303888f, 0.06525826f, 
    -0.16461225f, 0.16881427f, 0.01016032f, 0.29725498f, 0.05549044f, 0.05476717f, 0.07332853f, -0.03505898f, 
    -0.17864980f, -0.00628030f, -0.13192593f, 0.01509736f, -0.29826149f, -0.16060795f, 0.12780501f, -0.06209731f, 
    -0.02615309f, 0.06248460f, -0.06071718f, -0.04255512f, 0.08419909f, -0.05531127f, 0.01689519f, 0.04911540f, 
    -0.15606840f, 0.06695826f, 0.07365067f, -0.14143763f, -0.09073053f, -0.10489628f, 0.01935408f, 0.04466856f, 
    -0.00714842f, 0.13693498f, -0.18174517f, 0.03936496f, 0.36532775f, -0.00353633f, 0.00692091f, 0.19825557f, 
    0.08618822f, -0.01267296f, 0.07265130f, 0.09335729f, -0.09959190f, -0.07892828f, 0.03447409f, -0.01436971f, 
    -0.01643998f, 0.26323050f, -0.24375482f, 0.55510402f, -0.11896377f, -0.05555006f, -0.04632222f, 0.12549022f, 
    -0.02692006f, -0.01382758f, 0.00940011f, 0.04228170f, 0.07683529f, 0.09617689f, -0.05126489f, 0.15677845f, 
    -0.14591908f, 0.10838043f, 0.07579977f, 0.01467292f, 0.02140183f, 0.03517512f, 0.01748822f, -0.09793459f, 
    0.18844016f, -0.05894880f, -0.26678818f, -0.01245256f, -0.01282350f, 0.09536863f, 0.01321815f, 0.11753703f, 
    -0.09352506f, -0.14331467f, -0.14971070f, 0.02747966f, -0.07146133f, 0.16108175f, 0.26572096f, 0.01351603f, 
    0.01879239f, -0.00727104f, -0.02059845f, 0.18665488f, -0.02816366f, 0.14361998f, 0.03705204f, -0.03307306f, 
    -0.05436363f, -0.03460835f, -0.06817416f, 0.36323497f, 0.05856148f, 0.00975916f, 0.05719468f, 0.00341563f, 
    0.00310562f, -0.03317167f, -0.03270726f, 0.01134360f, 0.02813997f, 0.05796004f, 0.45691162f, 0.20763424f, 
    -0.07156421f, 0.04907931f, -0.12838742f, 0.07833181f, -0.01576554f, 0.10199814f, 0.09479695f, -0.06795423f, 
    0.05903970f, -0.11054599f, -0.16453710f, 0.36885592f, 0.00606383f, -0.04512009f, 0.03341019f, -0.10557543f, 
    -0.06769851f, 0.07655596f, -0.01239843f, 0.06264788f, 0.19994377f, 0.34141216f, -0.14109266f, -0.08878689f, 
    0.28978330f, -0.06152623f, 0.02585836f, -0.02547789f, -0.02598924f, 0.02603081f, 0.03236195f, -0.09020274f, 
    0.06141165f, 0.15305437f, 0.15205483f, -0.00983733f, 0.00022346f, 0.06471287f, -0.00046300f, 0.04925302f, 
    -0.06749541f, 0.01254065f, -0.00394552f, 0.09920328f, 0.09064938f, -0.21965785f, -0.15825956f, 0.10407306f, 
    -0.00064303f, 0.09237701f, 0.03670120f, 0.09307972f, -0.00348107f, -0.07483301f, 0.02677154f, 0.01502227f, 
    -0.10363338f, 0.36893004f, -0.08314208f, -0.39053807f, -0.34380841f, -0.25490424f, -0.01715060f, -0.16297817f, 
    -0.04946321f, -0.00557552f, -0.06092058f, 0.13054046f, 0.35130334f, -0.29597136f, -0.00248378f, -0.03374386f, 
    -0.07963143f, -0.04225383f, -0.01420674f, 0.05861278f, 0.07344636f, 0.09855414f, 0.01630882f, -0.06401655f, 
    -0.26527795f, 0.16824572f, 0.24285786f, 0.27337831f, 0.17983671f, 0.03787841f, 0.09351054f, -0.01167524f, 
    0.01812305f, -0.00583878f, -0.03316521f, 0.08035859f, 0.03235750f, 0.07385838f, 0.03262090f, 0.17482713f, 
    0.11183584f, 0.07359914f, 0.02874939f, -0.00234039f, 0.05793681f, 0.09390404f, 0.21236110f, 0.08561362f, 
    -0.21685819f, 0.13700530f, -0.02672634f, -0.16579856f, -0.09248722f, -0.10576623f, -0.05325518f, -0.17394261f, 
    -0.01346139f, -0.06374248f, -0.02400186f, -0.08957615f, 0.18924184f, -0.02846115f, 0.00741153f, 0.08548674f, 
    0.00067803f, -0.15423056f, 0.08750859f, 0.04133121f, -0.14726387f, 0.03538749f, 0.01151622f, -0.22107002f, 
    -0.19046432f, 0.55869716f, -0.00077023f, 0.51776749f, -0.04456284f, 0.12367736f, 0.01534916f, -0.03885329f, 
    -0.08667023f, -0.05548915f, 0.09150584f, -0.01712047f, -0.05767384f, -0.01477241f, 0.19626816f, 0.26862064f, 
    -0.03267601f, 0.18024716f, -0.01158962f, 0.14208829f, 0.02497365f, 0.08975196f, 0.19324510f, 0.19328287f, 
    -0.21599016f, -0.13235062f, -0.12811278f, -0.01064310f, 0.00722773f, 0.00390302f, -0.14644784f, -0.08789463f, 
    0.03046827f, -0.00883310f, 0.09328834f, -0.00373786f, -0.14333048f, -0.19017576f, 0.00269012f, 0.09102203f, 
    0.03494384f, -0.00808543f, -0.06809074f, 0.23207566f, -0.23957348f, 0.14330542f, -0.02016468f, -0.18489297f, 
    -0.19315787f, 0.16902006f, 0.24465345f, 0.17660375f, 0.05363680f, 0.08459244f, 0.03221687f, 0.07794995f, 
    0.21067804f, 0.02839801f, 0.07570186f, -0.03672466f, -0.03573741f, 0.11754203f, 0.15780586f, 0.17355509f, 
    -0.08566099f, 0.00146745f, -0.06529082f, 0.06446943f, -0.07133122f, -0.02427118f, 0.06421209f, 0.12825531f, 
    0.02488111f, -0.12871021f, 0.10808305f, 0.25154552f, -0.01556594f, -0.11902496f, 0.05453208f, 0.03459563f, 
    0.08844682f, -0.15285975f, -0.18793862f, -0.14763486f, -0.09285680f, -0.14626496f, -0.04169336f, 0.17554626f, 
    0.05019463f, 0.01451989f, 0.03600243f, 0.04895072f, -0.01487127f, 0.05643923f, 0.00775071f, -0.10700902f, 
    -0.11244790f, 0.16611868f, 0.18321227f, -0.21429180f, -0.11183120f, -0.06721301f, -0.08116326f, -0.09219230f, 
    -0.03914949f, 0.01416839f, 0.13166319f, 0.12728401f, -0.16714501f, -0.21578120f, -0.07963699f, 0.21837795f, 
    0.00685142f, 0.03094207f, 0.06325532f, -0.11679295f, 0.14163339f, -0.08682404f, 0.06746918f, 0.17020908f, 
    0.07374952f, 0.26935315f, -0.05567394f, -0.16035797f, -0.26955378f, -0.21260665f, -0.02729258f, -0.01037578f, 
    0.04941252f, -0.00274932f, -0.03708624f, -0.03916705f, -0.12729785f, -0.07967348f, -0.13124810f, -0.27448800f, 
    -0.16295934f, -0.12785834f, -0.12943238f, -0.02400121f, 0.15994102f, 0.02693877f, -0.01800844f, -0.04647296f, 
    -0.09016932f, 0.17579252f, 0.10161899f, 0.26295912f, 0.19324745f, 0.00494814f, 0.10225505f, -0.04009300f, 
    -0.04128656f, -0.07432152f, -0.01521838f, -0.00468142f, 0.54047787f, 0.13771561f, 0.02775521f, 0.20005076f, 
    0.19020405f, 0.01532996f, 0.06120462f, 0.18151943f, 0.02632060f, 0.13126543f, 0.15626056f, 0.16817655f, 
    -0.27348799f, 0.04586250f, -0.05583895f, 0.02496422f, -0.02932866f, -0.03223670f, -0.07512763f, -0.17078802f, 
    0.05196845f, -0.23056766f, 0.02623419f, -0.13193023f, 0.03474068f, -0.00478955f, 0.10528894f, -0.06803709f, 
    0.04027381f, -0.08118649f, 0.15916391f, 0.08820200f, -0.07426817f, -0.02457371f, -0.04786367f, -0.24242927f, 
    -0.14935896f, 0.41008621f, -0.09758853f, 0.31058753f, -0.00299743f, 0.09434532f, 0.07672185f, 0.08108679f, 
    0.01659670f, -0.03220176f, 0.01558743f, -0.06712519f, -0.10143438f, -0.08334887f, 0.08214555f, -0.02216971f, 
    0.09668891f, 0.09035055f, -0.06806533f, 0.01383223f, 0.01790319f, -0.02240930f, 0.14751634f, 0.14608924f, 
    -0.16467197f, 0.03708427f, 0.05409845f, -0.16718759f, -0.01363906f, -0.00533458f, 0.00716507f, -0.15390007f, 
    0.05366579f, -0.01300445f, -0.01873357f, 0.02820714f, -0.09732408f, -0.14793840f, -0.14413136f, 0.09853861f, 
    0.01349781f, 0.07152908f, 0.23816022f, 0.16939320f, 0.03917938f, 0.27756253f, -0.02416208f, -0.10830648f, 
    -0.17367874f, 0.08360831f, 0.18688875f, -0.07210679f, 0.07124034f, 0.09930474f, -0.05906357f, 0.35125095f, 
    0.16303463f, 0.11735748f, -0.06360620f, -0.03463619f, 0.06464759f, 0.07193404f, 0.09289112f, 0.16225176f, 
    0.10579073f, 0.11169932f, -0.02951436f, 0.00347503f, -0.01651154f, -0.02556776f, -0.01936871f, 0.12501273f, 
    -0.04782365f, -0.00635789f, 0.03306634f, -0.05533325f, -0.15111324f, 0.00682411f, 0.11663576f, 0.18315741f, 
    -0.05396510f, -0.05236306f, -0.10336058f, -0.14523067f, -0.14551871f, -0.27606395f, 0.06780475f, 0.19254757f, 
    0.08597438f, 0.05652085f, 0.09015708f, 0.08391663f, 0.05185695f, 0.07539981f, 0.04598902f, -0.04018372f, 
    -0.11807373f, 0.21630566f, 0.06228461f, -0.15816824f, -0.08914950f, -0.13623831f, -0.10165972f, -0.13967459f, 
    0.08498526f, 0.14003597f, 0.18177021f, 0.06208709f, -0.10265661f, -0.26943305f, -0.01405687f, 0.00224155f, 
    0.08958097f, 0.03677855f, 0.00856681f, -0.13283633f, 0.04265656f, -0.05369770f, -0.02244097f, 0.15354601f, 
    -0.15809080f, 0.21770993f, 0.09633830f, 0.15302876f, -0.07961226f, -0.27909395f, -0.06789877f, -0.16993026f, 
    -0.12122779f, -0.03764539f, -0.10493357f, -0.10505560f, 0.01288943f, -0.14992414f, -0.28166679f, 0.00577549f, 
    -0.00139926f, -0.02856631f, 0.04195302f, -0.09609030f, -0.04630456f, 0.08794112f, -0.00811309f, 0.05545789f, 
    0.07332759f, 0.29054826f, 0.05098891f, 0.03887532f, 0.08338702f, 0.04265201f, -0.00740958f, 0.05875667f, 
    -0.14168045f, 0.13394356f, -0.00480607f, 0.10609512f, -0.09791601f, -0.01054058f, 0.19219808f, 0.10827951f, 
    -0.02527635f, -0.04220783f, 0.04648249f, 0.00041705f, 0.12714818f, 0.03287691f, -0.12311425f, 0.17961796f, 
    -0.09931007f, 0.04927278f, -0.05044476f, 0.00778006f, -0.09878332f, -0.10132474f, -0.10082125f, -0.18954188f, 
    -0.10136319f, -0.17502131f, -0.06136434f, -0.04691489f, 0.20245115f, 0.21851788f, 0.09545941f, 0.06651922f, 
    0.00494520f, 0.03967064f, 0.01809738f, 0.09856142f, -0.13401423f, 0.12611119f, -0.14926642f, -0.28064007f, 
    0.26124367f, 0.36727598f, -0.26887792f, 0.10999829f, -0.11307242f, 0.05804975f, -0.03715785f, 0.02946685f, 
    0.01740777f, -0.06013846f, 0.04272520f, -0.03604601f, 0.10951006f, -0.01465312f, -0.06486924f, 0.06194493f, 
    0.05185249f, 0.27439803f, 0.24944766f, -0.02797134f, 0.01744492f, 0.08938733f, 0.14666505f, 0.09445269f, 
    0.25587311f, 0.24463175f, -0.06411835f, -0.07763480f, 0.08540730f, 0.05187231f, 0.18644954f, 0.12250986f, 
    0.01444688f, 0.00218465f, -0.15982804f, -0.08090393f, -0.17921154f, -0.10131224f, 0.02796699f, -0.22939302f, 
    -0.06528722f, -0.04761377f, 0.20909180f, 0.15309489f, 0.08270650f, 0.33309087f, 0.09992868f, -0.00126264f, 
    0.42015475f, -0.11887527f, 0.04223648f, 0.11480297f, 0.10339568f, 0.21427099f, 0.05359548f, 0.02105503f, 
    0.15396619f, -0.01802563f, 0.08036570f, -0.10899085f, 0.01281131f, -0.14433211f, 0.12092931f, -0.00494549f, 
    0.01710004f, 0.14496852f, 0.05909934f, 0.00107559f, -0.00380769f, -0.04925746f, 0.03531994f, 0.19256538f, 
    0.18605155f, 0.03058564f, -0.11934054f, 0.02464396f, -0.02015510f, 0.02157890f, -0.09927543f, 0.05108442f, 
    0.01219850f, -0.09440518f, 0.01093834f, -0.05943990f, -0.13171344f, 0.19432496f, 0.03665088f, -0.14064471f, 
    0.12018997f, 0.07447391f, -0.05790820f, 0.08966229f, 0.00260638f, -0.08754224f, 0.12894440f, -0.03065003f, 
    0.00297279f, 0.04961363f, -0.01377186f, 0.02925655f, -0.25353885f, -0.12796064f, -0.02276868f, -0.04439979f, 
    -0.03638517f, -0.05602104f, 0.04682159f, -0.00212502f, 0.16491435f, -0.10986552f, -0.15707503f, -0.07230237f, 
    0.20580253f, 0.10078071f, -0.01035476f, -0.02369926f, -0.01482603f, -0.09153301f, 0.03089935f, 0.04413482f, 
    0.06700011f, -0.06383504f, -0.03791406f, 0.04011600f, -0.07262504f, 0.00571268f, -0.07400916f, 0.04284062f, 
    0.00689349f, -0.04759224f, -0.06098401f, -0.00226236f, 0.03808849f, -0.00582520f, -0.05523835f, 0.01842176f, 
    0.02242197f, -0.05458264f, -0.03453363f, -0.07549611f, 0.05319587f, -0.04605667f, -0.01448408f, -0.03184161f, 
    0.02986568f, -0.04728988f, -0.02381065f, -0.04818530f, -0.05735230f, -0.00742638f, -0.03948101f, -0.02700783f, 
    0.04739765f, -0.05472619f, -0.01140685f, 0.03534353f, -0.03202109f, 0.02171290f, 0.00402313f, -0.07687248f, 
    -0.07429145f, -0.03970353f, -0.06740765f, -0.07439091f, -0.00380214f, 0.02535670f, -0.01786307f, 0.03086569f, 
    0.06501111f, -0.01699997f, -0.06192785f, 0.02486147f, -0.05991832f, 0.01437938f, 0.02703167f, 0.03731498f, 
    -0.07545635f, -0.04001842f, -0.01195916f, -0.01096719f, 0.04215994f, -0.01643519f, -0.05435430f, -0.04962599f, 
    -0.03474871f, 0.01847672f, -0.00879008f, 0.06193351f, -0.06959224f, 0.05541878f, -0.06743746f, 0.03805777f, 
    -0.05625187f, 0.03854198f, -0.03438099f, -0.03464175f, -0.06130118f, -0.07168837f, -0.03870602f, 0.03739049f, 
    0.01183899f, -0.01433066f, 0.04488275f, 0.04748667f, 0.03594285f, 0.03849998f, 0.02650317f, -0.04883635f, 
    0.03615030f, 0.03267819f, -0.07886951f, 0.00319262f, -0.06899419f, -0.05288272f, -0.02873028f, 0.03604213f, 
    0.02200464f, 0.05826472f, 0.04175333f, -0.06642643f, 0.04914472f, 0.05110595f, 0.04050265f, -0.02018755f, 
    0.05320403f, -0.03589353f, -0.08242197f, -0.03549370f, 0.07244602f, 0.04680509f, -0.00267101f, 0.03551850f, 
    -0.07341443f, -0.06050515f, 0.05118918f, -0.04009669f, -0.04965964f, 0.06485403f, 0.00959070f, 0.02921324f, 
    -0.01998024f, -0.05858655f, -0.04502857f, 0.04798179f, 0.00238794f, -0.03891941f, 0.05391218f, -0.06207312f, 
    -0.05469463f, 0.05147468f, 0.02045565f, 0.03804007f, 0.02418241f, -0.01869249f, -0.00260434f, -0.00454065f, 
    0.03255412f, -0.01075839f, -0.07496592f, 0.03904273f, 0.00146922f, -0.05345274f, -0.02142042f, -0.03060696f, 
    -0.07064942f, 0.02429254f, 0.03285325f, 0.03735514f, 0.06008764f, -0.05885359f, 0.03398751f, 0.00187566f, 
    -0.01105470f, -0.04972147f, 0.02056274f, -0.03044681f, -0.07511333f, -0.03910944f, -0.05350255f, 0.04947299f, 
    -0.01877242f, -0.02087079f, -0.06410942f, -0.00442745f, -0.08063043f, 0.06007478f, 0.02877991f, 0.02913151f, 
    -0.06929275f, 0.02445304f, -0.03208414f, 0.03588558f, 0.03971837f, 0.02763178f, -0.00492946f, 0.05901997f, 
    -0.06527940f, -0.04448973f, -0.00836795f, -0.07050859f, -0.01482995f, -0.02310707f, -0.00349110f, 0.01562856f, 
    -0.04726604f, 0.05300222f, 0.01924489f, -0.07330841f, -0.06677471f, -0.05057585f, -0.02297184f, -0.02690495f, 
    0.11408038f, 0.03508833f, 0.00246476f, 0.08664288f, 0.00633581f, 0.05168802f, -0.12696236f, 0.09646284f, 
    0.06544534f, -0.09574810f, 0.00779323f, -0.13244523f, 0.14744695f, 0.05872476f, 0.07880866f, 0.10907394f, 
    0.03762242f, -0.07729528f, 0.01125904f, -0.02168422f, -0.09426409f, 0.03525426f, 0.07166715f, 0.02003540f, 
    -0.30690646f, -0.06490197f, 0.25742510f, 0.07987620f, -0.01237468f, -0.02211112f, -0.01528695f, -0.05570741f, 
    0.02583364f, -0.09998440f, 0.02024399f, -0.04159318f, 0.38799262f, -0.00208370f, 0.11192057f, -0.07920145f, 
    -0.16963591f, 0.01873633f, -0.09494615f, 0.00213114f, 0.08306435f, 0.18069713f, 0.02410921f, -0.08094265f, 
    0.08313238f, -0.05912560f, 0.01220718f, 0.06154242f, -0.05802429f, -0.04828082f, 0.01311442f, -0.05624605f, 
    0.15108758f, 0.20564249f, 0.16037430f, 0.14992744f, 0.21767272f, -0.06416844f, 0.05872428f, 0.10418136f, 
    -0.01284296f, -0.06816711f, 0.19508854f, -0.05161628f, 0.02324467f, -0.03902441f, 0.14586115f, 0.20320904f, 
    -0.39864215f, 0.18247265f, -0.07569130f, 0.35615188f, 0.06262450f, -0.13809381f, 0.15958692f, 0.06690148f, 
    -0.05614544f, -0.05624148f, 0.00613829f, -0.02244066f, 0.00341182f, 0.08122785f, 0.05493167f, -0.06637125f, 
    -0.07992956f, -0.04954066f, -0.08379476f, 0.12100582f, -0.01457499f, 0.01005864f, -0.11167566f, -0.18059058f, 
    -0.17487988f, -0.13784377f, -0.16523819f, 0.09670434f, 0.05444655f, -0.05525867f, 0.02473317f, -0.00702135f, 
    -0.00971236f, -0.02126632f, -0.07208457f, 0.02960679f, 0.07008114f, 0.02988126f, -0.04235849f, 0.02269118f, 
    0.05849605f, -0.06977306f, -0.09400532f, 0.00817336f, 0.15310574f, 0.05502183f, -0.16344672f, -0.03076676f, 
    -0.30510569f, 0.22235790f, 0.08474533f, 0.17288654f, 0.00186291f, -0.11638223f, 0.15435080f, -0.01642554f, 
    -0.11142187f, 0.03355890f, 0.02099797f, -0.05791860f, 0.13446018f, 0.04141958f, 0.24845123f, 0.03694603f, 
    -0.14160962f, -0.01586422f, 0.04279597f, 0.06004184f, -0.11972055f, -0.04852491f, -0.07597673f, 0.01248171f, 
    -0.14185305f, -0.09613850f, 0.05244346f, 0.07588727f, -0.06705093f, -0.05513247f, 0.03051631f, -0.01541604f, 
    0.03572863f, 0.08341184f, -0.06266967f, 0.19242226f, 0.02476986f, -0.09460223f, 0.10493042f, 0.25438166f, 
    0.06187629f, -0.15463832f, -0.02592040f, -0.03397905f, -0.11925329f, 0.04752535f, -0.05204733f, 0.15147381f, 
    0.08786794f, -0.13347073f, -0.10521297f, -0.09605536f, 0.14823721f, 0.00355863f, -0.01540074f, -0.09153535f, 
    -0.03241699f, -0.15723170f, 0.03211015f, -0.07344051f, -0.08000675f, -0.04664644f, -0.00329052f, 0.11419272f, 
    0.00801339f, -0.01339779f, 0.14799596f, -0.00728828f, -0.01337464f, 0.00103334f, 0.05377506f, 0.00241626f, 
    -0.27362081f, -0.19403216f, -0.04539258f, 0.14712337f, 0.08514933f, 0.12979475f, -0.12937497f, 0.00967729f, 
    -0.21655966f, -0.14152469f, 0.00288442f, 0.10644899f, 0.17570087f, 0.35908532f, 0.24659064f, 0.29637691f, 
    -0.13948593f, 0.01145829f, 0.00099327f, 0.09878950f, -0.11771403f, -0.06295117f, -0.03221144f, 0.08465348f, 
    -0.19105896f, 0.07184711f, 0.15770519f, 0.04633005f, -0.01565115f, 0.08787173f, 0.00705938f, -0.12874173f, 
    -0.01467951f, 0.03663600f, -0.00414702f, 0.14822170f, -0.07934937f, 0.21457930f, -0.06912419f, 0.10205984f, 
    -0.06855963f, 0.18432023f, 0.14800555f, 0.00379902f, 0.03427330f, -0.03253540f, 0.06897473f, 0.22688858f, 
    -0.15423723f, 0.07516280f, -0.26924896f, -0.31920484f, 0.05611758f, -0.17799680f, -0.03598936f, 0.00514742f, 
    -0.01447080f, 0.19509609f, -0.00238524f, 0.16163740f, 0.06053523f, 0.07992298f, -0.13944675f, 0.03986597f, 
    0.08700453f, 0.16514434f, -0.03513606f, -0.00893908f, 0.09676532f, 0.15542363f, 0.04370525f, 0.18834262f, 
    -0.12947381f, -0.09939033f, -0.20814529f, 0.25993565f, 0.00495235f, -0.03301072f, -0.16698901f, -0.07311729f, 
    0.11055402f, -0.11073176f, 0.15251313f, 0.02853488f, -0.06183636f, -0.12095628f, -0.08869591f, -0.16782878f, 
    0.12686452f, -0.06304202f, -0.01926704f, -0.20446154f, -0.10385481f, -0.06626943f, -0.16569375f, -0.21975523f, 
    0.07434440f, -0.04447772f, -0.22485314f, -0.07262482f, -0.04303602f, 0.11997386f, 0.04505703f, 0.05662655f, 
    -0.23782089f, -0.02882562f, -0.12147393f, -0.10782718f, 0.22091842f, -0.04223601f, 0.09038588f, -0.09164905f, 
    -0.05406384f, 0.00808900f, 0.06455050f, -0.09210238f, -0.02083046f, -0.25813562f, -0.05014229f, 0.21076116f, 
    0.22725184f, 0.17985833f, 0.00674633f, 0.13742287f, 0.07760266f, 0.06573875f, 0.18296234f, 0.00153597f, 
    0.04306073f, 0.01595672f, 0.01407240f, 0.14283347f, -0.22916828f, -0.15186910f, 0.17348535f, -0.28261837f, 
    0.00004286f, 0.08666376f, 0.00937045f, -0.08147487f, -0.17253664f, -0.13139907f, -0.11508535f, -0.19345105f, 
    0.16354379f, -0.01405640f, 0.03902827f, 0.11815271f, 0.13038993f, 0.22965056f, 0.12625539f, -0.08075366f, 
    -0.08061334f, 0.18188933f, -0.02017072f, 0.15919957f, 0.16082840f, 0.34023070f, 0.09444006f, 0.13181676f, 
    0.07284690f, -0.08700315f, 0.09613286f, 0.19066976f, 0.15430678f, 0.04359667f, 0.00846772f, -0.02271540f, 
    -0.06825414f, 0.00871111f, 0.03229924f, -0.12875734f, 0.04229979f, -0.12824623f, -0.09970586f, -0.03065574f, 
    -0.04561038f, -0.14334270f, 0.06925330f, -0.09552469f, 0.06533146f, -0.05818700f, -0.15606342f, -0.18903582f, 
    -0.00392963f, -0.06277356f, -0.05730789f, 0.00213222f, 0.14509767f, 0.09530666f, 0.06425539f, 0.03725117f, 
    0.06838118f, 0.23745683f, 0.09180219f, 0.01455818f, -0.12281282f, -0.03494892f, -0.17923808f, -0.02768072f, 
    0.00235177f, -0.00625838f, -0.04238726f, -0.04974006f, -0.12980384f, -0.13568498f, -0.09301671f, -0.03809088f, 
    0.00594492f, 0.09515795f, -0.07315331f, 0.02096007f, -0.08231559f, 0.12104947f, 0.02516781f, -0.02464869f, 
    -0.23009005f, -0.04916849f, 0.12758999f, 0.10407546f, 0.07191411f, 0.11225440f, 0.12390986f, 0.06146475f, 
    0.07063373f, -0.00192600f, 0.01103362f, 0.04001803f, 0.29240918f, 0.03173069f, 0.19353895f, 0.10465255f, 
    0.05531191f, 0.17724302f, -0.11397285f, 0.02307220f, -0.03662440f, 0.05775423f, 0.20486701f, 0.01065977f, 
    -0.07027669f, -0.00143159f, 0.01981534f, 0.00850694f, -0.05434646f, -0.08337046f, 0.05186094f, -0.08457775f, 
    0.05985150f, 0.10473587f, -0.00195337f, 0.04667248f, 0.25063044f, -0.13995011f, 0.08565851f, 0.00346423f, 
    -0.02846158f, -0.05504948f, 0.06958241f, -0.02918092f, 0.07115074f, 0.10147078f, 0.02140824f, 0.01560572f, 
    -0.19586535f, 0.32892525f, -0.39791861f, 0.30753228f, 0.10583849f, 0.00703773f, 0.21248645f, -0.32458434f, 
    -0.02497557f, -0.10397434f, 0.02831639f, 0.07916124f, -0.09943944f, -0.13449037f, -0.00283305f, 0.18849784f, 
    -0.05719011f, -0.01456750f, -0.01041378f, 0.14642587f, -0.04437132f, 0.10009176f, -0.05283019f, 0.06215835f, 
    0.01549439f, 0.10288090f, -0.22179285f, 0.06512931f, -0.02692456f, -0.03257964f, 0.02563292f, -0.22260734f, 
    0.04091576f, 0.06360740f, -0.04908389f, 0.01833462f, -0.09928259f, -0.16078822f, -0.04470934f, 0.13851318f, 
    -0.04795778f, 0.10406684f, -0.11887088f, 0.12643963f, 0.04618463f, 0.02046679f, -0.05788903f, -0.05812072f, 
    -0.11503644f, 0.09265046f, 0.07762179f, 0.10734820f, -0.00397359f, 0.11702720f, 0.34447506f, 0.03933417f, 
    0.07842141f, 0.11501035f, 0.06532399f, 0.04265384f, -0.01448989f, 0.00693684f, 0.11620057f, 0.14259721f, 
    0.06670389f, -0.05216642f, 0.21539830f, -0.10214306f, -0.01797855f, -0.03977832f, 0.01800192f, 0.02081352f, 
    -0.09436885f, 0.00435367f, 0.00482551f, 0.13304201f, -0.07331634f, 0.10404092f, 0.00900593f, -0.00527927f, 
    0.09988769f, 0.07443226f, -0.09688062f, -0.02012726f, 0.00252069f, -0.27372840f, -0.01019325f, -0.01402473f, 
    0.29945841f, -0.12747961f, 0.19168326f, 0.01365778f, 0.10334837f, 0.07046530f, 0.05887888f, -0.01122880f, 
    -0.18780205f, 0.08005241f, 0.10347961f, 0.00321456f, -0.00415648f, -0.03495068f, -0.03001213f, -0.02325820f, 
    0.00859118f, -0.05633377f, 0.02998167f, 0.06574452f, -0.18124917f, -0.19814347f, -0.10292906f, -0.00236164f, 
    -0.08940250f, 0.08600232f, 0.04796465f, -0.00664130f, 0.11933977f, 0.09766266f, -0.03001478f, 0.01833948f, 
    -0.27784380f, -0.31610849f, -0.00953050f, -0.04394043f, 0.03365528f, -0.02177099f, -0.11065951f, 0.05058371f, 
    0.05905602f, 0.03187120f, 0.10008021f, 0.09160376f, -0.14504504f, 0.02927001f, -0.13687290f, 0.07090266f, 
    0.11733441f, 0.17173959f, 0.01932053f, 0.18359606f, 0.18093120f, -0.07908549f, 0.01864686f, -0.07955044f, 
    0.40740043f, -0.05814224f, -0.02650483f, -0.19692387f, -0.02284140f, 0.05119276f, 0.03254407f, 0.01100154f, 
    0.02761235f, -0.12730564f, 0.09307705f, -0.08210827f, 0.04555705f, -0.31039810f, 0.05026096f, 0.03885297f, 
    -0.02016873f, 0.00366853f, -0.24687967f, -0.03678535f, 0.07197394f, -0.07768405f, -0.02369453f, 0.05657916f, 
    -0.10002255f, -0.31609610f, -0.17136693f, 0.03361575f, 0.02873448f, 0.07561031f, 0.03613745f, 0.00491010f, 
    0.14363585f, -0.02617858f, 0.08793612f, -0.01566147f, -0.06555042f, -0.01410584f, 0.22385225f, -0.05286256f, 
    -0.08892553f, -0.03388058f, 0.09676788f, 0.21243347f, -0.05100297f, -0.10329562f, -0.00261712f, 0.09551600f, 
    0.36862910f, -0.01913952f, 0.27346635f, -0.31804958f, 0.00329162f, -0.10208100f, 0.03871108f, -0.03709706f, 
    -0.01903322f, -0.03203580f, 0.03757780f, 0.04010929f, 0.29242676f, 0.19370142f, 0.17366290f, 0.09415047f, 
    0.02455270f, -0.09904828f, 0.04261776f, -0.12618676f, 0.04685591f, -0.08203445f, -0.12529463f, -0.03754972f, 
    0.07085697f, 0.13031617f, 0.31402805f, 0.07299659f, -0.19938324f, 0.07539862f, 0.13099316f, 0.06331443f, 
    0.04775858f, -0.05517165f, -0.04126460f, 0.04605231f, -0.10071215f, -0.06927330f, -0.10455351f, 0.08299120f, 
    0.08113260f, 0.02441420f, -0.03306857f, -0.03582504f, -0.10894091f, -0.02829023f, -0.08481500f, -0.06914952f, 
    0.07968845f, -0.15544954f, -0.10428815f, -0.01016099f, 0.13998027f, -0.02335090f, -0.01861296f, -0.13087071f, 
    0.10157264f, -0.02376934f, -0.05645702f, 0.06736273f, 0.19680269f, 0.11091508f, -0.09038760f, 0.07094637f, 
    0.09938557f, -0.14095916f, -0.02499897f, -0.15379043f, -0.01127527f, 0.11183738f, -0.11175162f, -0.00086284f, 
    0.07371594f, 0.13972032f, -0.08244174f, -0.08205473f, 0.13237558f, 0.07741020f, 0.14710259f, -0.01337696f, 
    -0.01655241f, -0.05074254f, 0.29898080f, 0.12890866f, 0.06871823f, -0.03828024f, 0.21818294f, -0.00599605f, 
    -0.08736669f, 0.05312980f, 0.09265001f, -0.15572430f, 0.05736883f, -0.08955232f, 0.02309140f, 0.13242051f, 
    -0.06005858f, -0.23432201f, -0.17896278f, -0.03897158f, 0.07064137f, -0.06094956f, -0.01456202f, 0.02959775f, 
    -0.02197071f, 0.03917346f, -0.05379290f, 0.08681250f, 0.30165219f, 0.43950802f, 0.38327047f, -0.02327390f, 
    -0.03144192f, 0.08802549f, 0.07009783f, -0.01749329f, 0.03243572f, 0.04706400f, 0.02504572f, 0.01123014f, 
    0.01809194f, 0.01715724f, 0.03228167f, -0.10071442f, 0.06114878f, -0.12590706f, -0.09178659f, -0.08226233f, 
    0.01369660f, -0.10245039f, 0.04341023f, -0.00877494f, 0.37713972f, -0.01123747f, 0.00074123f, 0.14243539f, 
    -0.19068776f, -0.10317622f, 0.05034426f, 0.05337150f, 0.14873010f, -0.12675884f, -0.04090843f, 0.06282997f, 
    -0.03292003f, -0.15243696f, 0.17263180f, 0.09678053f, 0.05780255f, -0.05994394f, 0.03819230f, 0.00129473f, 
    0.14679106f, -0.12360390f, -0.12080828f, 0.14020427f, -0.28086033f, -0.23484980f, 0.06806425f, 0.04616932f, 
    0.15414602f, 0.16804491f, -0.01880313f, -0.07540728f, 0.02900883f, 0.08525799f, 0.09571514f, -0.05494973f, 
    0.02372058f, -0.15763903f, 0.05754070f, -0.13184299f, 0.01062595f, -0.05300048f, 0.13100466f, 0.14128450f, 
    0.12142341f, 0.23379397f, 0.07064997f, 0.16908814f, -0.17749742f, -0.06825399f, -0.00291359f, -0.05475040f, 
    0.04114845f, -0.04767459f, -0.03165874f, 0.08020149f, 0.12584880f, 0.01826006f, 0.16342454f, 0.24624242f, 
    0.14742115f, -0.18854678f, 0.49336588f, -0.20308270f, 0.03331517f, -0.02223339f, 0.09097882f, 0.15909222f, 
    -0.01384110f, 0.03115651f, -0.07096756f, 0.02544514f, -0.07053161f, 0.07240633f, 0.20053196f, -0.05835216f, 
    0.07421286f, -0.15435848f, -0.08660807f, 0.03580734f, -0.19926551f, -0.17116134f, -0.19421755f, -0.32795227f, 
    -0.10705779f, -0.14294688f, 0.19433407f, 0.09485765f, -0.00271641f, 0.01686066f, -0.10405137f, 0.12011677f, 
    0.05047988f, -0.07945483f, -0.00825463f, 0.08574767f, 0.00328751f, -0.17249060f, -0.10930572f, -0.16924894f, 
    0.08384658f, 0.05143645f, -0.02327453f, -0.27009431f, 0.02612433f, -0.26480770f, -0.07724211f, 0.10979902f, 
    -0.30121985f, -0.10256230f, 0.04996508f, -0.01391237f, -0.10441232f, -0.06734002f, 0.05016193f, 0.05913834f, 
    0.02968752f, 0.11437853f, -0.14992142f, 0.12374805f, 0.02979620f, 0.09636620f, -0.02257246f, -0.09949733f, 
    0.14121281f, -0.12454966f, -0.16768396f, 0.19736387f, -0.17519854f, -0.01052193f, -0.18917374f, -0.29465958f, 
    -0.00151953f, 0.02145849f, 0.02259119f, 0.08005940f, 0.08063982f, -0.07541406f, 0.06888926f, 0.04775439f, 
    0.00237578f, 0.12000731f, 0.17949377f, 0.15339373f, 0.34923989f, 0.06528304f, 0.07363811f, 0.24733829f, 
    -0.21385257f, 0.12442441f, -0.06267530f, 0.00986977f, 0.09763953f, 0.03089394f, -0.08586069f, 0.10884843f, 
    0.09735193f, 0.05114251f, -0.05692209f, -0.11877657f, 0.11545265f, -0.04477338f, -0.23923826f, -0.14600036f, 
    -0.12597632f, 0.06749131f, -0.10151006f, -0.25789541f, 0.11446685f, 0.13598870f, 0.22062619f, 0.16283898f, 
    0.06202401f, 0.05098010f, -0.00477588f, 0.06481865f, 0.07561883f, 0.00002285f, 0.10894183f, -0.00706482f, 
    0.06344572f, 0.01163896f, 0.01975432f, -0.05198925f, -0.04033419f, 0.01045611f, -0.02329003f, -0.01882715f, 
    -0.03687272f, -0.07458618f, -0.02233883f, -0.03192603f, 0.01558886f, 0.01041236f, 0.00242717f, 0.04230326f, 
    -0.05525150f, -0.06154248f, 0.02877459f, -0.03403176f, -0.02745572f, -0.00151025f, 0.02152062f, 0.02368891f, 
    0.05454693f, -0.07318375f, 0.04700957f, -0.00911754f, 0.04890940f, 0.04722060f, 0.05183632f, 0.03502464f, 
    0.03865207f, -0.01049913f, -0.06474332f, -0.04901436f, 0.03491015f, -0.07052819f, 0.00733452f, -0.03066928f, 
    -0.00579162f, 0.05497730f, 0.02385501f, 0.06389849f, -0.04728967f, -0.03080049f, 0.01329180f, 0.05516728f, 
    0.03227376f, 0.04176291f, -0.07120914f, 0.03401542f, -0.00752797f, -0.03010651f, 0.01887340f, -0.02564614f, 
    0.01077177f, 0.00967076f, -0.07351366f, 0.00896443f, -0.05003102f, -0.02889454f, -0.05302491f, 0.00761723f, 
    0.03052982f, 0.05854848f, 0.00754471f, 0.00916332f, -0.01387154f, 0.04687535f, -0.02513357f, -0.06770288f, 
    0.03591983f, -0.02007298f, 0.00200715f, 0.01109562f, 0.05856548f, -0.05776747f, -0.04267273f, 0.04449501f, 
    0.05973712f, -0.06223167f, 0.04486908f, -0.00209962f, -0.02482230f, -0.02626176f, 0.04881347f, 0.01532457f, 
    0.00131914f, -0.00704666f, -0.04941765f, -0.00366490f, 0.02590589f, -0.02477722f, -0.06825475f, -0.03528512f, 
    0.05335745f, 0.00985474f, -0.03765722f, -0.04279058f, 0.03374263f, 0.01147731f, -0.02920686f, 0.04613943f, 
    -0.00505511f, -0.07555953f, -0.06190761f, 0.03040864f, -0.06229525f, 0.05004621f, 0.00330789f, -0.07318817f, 
    -0.03784981f, -0.04915170f, -0.06038238f, 0.04111469f, -0.03788609f, -0.06840363f, -0.07619284f, -0.02367879f, 
    0.00153002f, -0.03371575f, -0.01314082f, -0.04299056f, -0.01659740f, -0.03087174f, -0.06168712f, -0.07629307f, 
    -0.00385043f, -0.06360651f, -0.04421064f, -0.04844773f, -0.03570864f, -0.04456819f, -0.04837533f, -0.01981854f, 
    0.01448210f, -0.01182452f, -0.00585194f, 0.04023706f, -0.02533136f, -0.06283573f, 0.00078969f, -0.02514665f, 
    -0.03051804f, 0.02533286f, 0.01087078f, -0.04992091f, 0.01802025f, 0.03678419f, 0.00180260f, -0.04694365f, 
    0.00522174f, -0.03172974f, 0.00843919f, 0.04613524f, 0.01013981f, 0.03833690f, 0.05224739f, 0.00720293f, 
    -0.02574039f, -0.02592599f, -0.07146831f, 0.01050322f, -0.05887775f, 0.02034516f, 0.06388230f, -0.06647348f, 
    0.04455968f, -0.03829362f, 0.00366538f, -0.04652004f, 0.03364966f, -0.06708618f, -0.06244960f, -0.06724788f, 
    -0.01222877f, -0.04505132f, -0.01532128f, -0.01813832f, -0.01808190f, 0.06312030f, -0.07034267f, -0.03247203f, 
    0.03799456f, 0.00727771f, 0.02455384f, -0.02521399f, -0.06122986f, 0.03804842f, -0.07179063f, 0.01304683f, 
    -0.05348148f, -0.01524759f, 0.01878301f, 0.04299766f, -0.06825420f, 0.00101215f, 0.04694891f, -0.08350956f, 
    0.01719380f, 0.01284433f, 0.02360153f, 0.04267021f, -0.03684320f, -0.04136937f, -0.01784143f, 0.02874355f, 
    -0.04915608f, -0.05260596f, 0.03623025f, 0.00506257f, 0.08526172f, 0.04485943f, -0.02449057f, 0.01288210f, 
    0.03488174f, 0.01356389f, 0.02699240f, 0.06814595f, -0.02884191f, -0.04136144f, 0.06565864f, -0.02242536f, 
    -0.01435028f, 0.03772083f, 0.03638166f, 0.03840446f, -0.06864708f, -0.07078686f, 0.02273504f, -0.07856829f, 
    -0.08671927f, -0.09012571f, 0.01047353f, -0.09098262f, -0.04576691f, -0.00617135f, -0.03386692f, -0.01877987f, 
    -0.00687332f, -0.05098743f, -0.07329012f, -0.06834552f, -0.07545772f, -0.07616187f, -0.03301748f, 0.04702301f, 
    0.00954072f, 0.11520202f, 0.04336950f, -0.04990341f, -0.06474248f, -0.05009362f, -0.05564644f, -0.04979667f, 
    0.03378356f, -0.03301649f, 0.02469769f, 0.06766802f, -0.08271975f, 0.01069979f, -0.01796522f, -0.01575162f, 
    -0.09369621f, -0.10066125f, 0.01245139f, -0.04998932f, 0.04591773f, 0.05238595f, -0.02179879f, 0.02288728f, 
    -0.10503592f, 0.02473216f, 0.00815164f, -0.04267177f, -0.04188237f, -0.07476512f, -0.05341184f, -0.04855493f, 
    0.07501758f, -0.03385876f, -0.01746459f, -0.05465712f, -0.08322531f, -0.07856882f, -0.09705492f, -0.01713925f, 
    0.02666925f, 0.04551613f, 0.05658533f, 0.00633537f, -0.05838669f, -0.04817472f, 0.02546913f, 0.00660171f, 
    -0.03861647f, -0.02306478f, -0.01392729f, -0.09872396f, -0.05486662f, -0.08882437f, -0.08662383f, -0.08748500f, 
    -0.00677679f, 0.03534579f, -0.04385472f, -0.08631619f, 0.00115783f, -0.00699723f, -0.08957193f, -0.10101287f, 
    0.03305626f, -0.04530873f, 0.06041760f, -0.03904619f, -0.08816532f, -0.11039742f, -0.00947285f, 0.00634208f, 
    0.03565624f, 0.00548382f, -0.03137211f, -0.01170410f, -0.08411013f, 0.03193325f, 0.04273591f, -0.03981014f, 
    -0.06321295f, -0.03598624f, -0.01335711f, -0.02234941f, -0.08047469f, -0.03875633f, -0.05509438f, -0.00267841f, 
    -0.06987386f, -0.01071022f, 0.06359404f, -0.06179861f, 0.03914237f, -0.03317707f, -0.01052407f, -0.03211132f, 
    0.00247672f, 0.05562461f, 0.01644521f, -0.03021805f, -0.05740629f, -0.00360695f, -0.02791372f, 0.06636010f, 
    -0.07093716f, -0.06566988f, 0.04479911f, 0.04248215f, -0.04250896f, 0.02514830f, 0.00886766f, -0.03891164f, 
    0.03683938f, -0.04254430f, -0.08075661f, -0.08414096f, -0.08242576f, -0.07367326f, -0.00292452f, -0.03830544f, 
    0.03137515f, -0.10138652f, -0.02616302f, 0.02161955f, -0.04147887f, -0.05548972f, -0.04466059f, 0.02371621f, 
    -0.05625054f, -0.05614031f, -0.07579543f, -0.04038153f, -0.07980140f, 0.01814969f, -0.08237483f, -0.01845553f, 
    -0.24234854f, -0.05383452f, -0.08355105f, -0.17293139f, -0.15758677f, -0.01881692f, -0.09716471f, -0.06712528f, 
    0.17678146f, -0.10703594f, 0.02334360f, 0.07100724f, -0.00810384f, -0.21798228f, -0.15595329f, -0.24900085f, 
    0.02060249f, -0.00563704f, 0.09667200f, -0.01937973f, -0.04398370f, 0.04750720f, -0.10355751f, -0.07515222f, 
    -0.04724409f, 0.29174751f, -0.27247715f, 0.05621510f, 0.01132262f, -0.00979102f, 0.06344758f, 0.06273234f, 
    -0.21116251f, 0.03260530f, 0.09798083f, -0.14679913f, 0.45933348f, 0.17734694f, -0.17828678f, 0.10526629f, 
    -0.15440591f, -0.27139887f, 0.09008382f, 0.00122358f, -0.03030002f, 0.04941078f, -0.05367218f, -0.11464182f, 
    -0.26068136f, -0.07562260f, -0.01937660f, -0.00379558f, -0.07138831f, 0.13960412f, -0.06426756f, -0.11068403f, 
    0.02083476f, -0.11993020f, 0.01516341f, -0.17990771f, 0.32301691f, -0.00096485f, 0.03735642f, 0.03464207f, 
    0.08275665f, -0.02892272f, 0.21636236f, 0.09255164f, -0.02197670f, 0.01789688f, -0.10026809f, -0.19622380f, 
    -0.12115656f, 0.04808576f, -0.09614009f, 0.28039381f, 0.15412851f, -0.00722372f, 0.02094146f, 0.15442893f, 
    0.05957447f, 0.06691457f, -0.03133010f, -0.07933314f, 0.11135850f, 0.01166969f, -0.05045354f, 0.09643087f, 
    -0.02565672f, 0.05275598f, 0.09328090f, 0.00029972f, 0.12640797f, 0.05435999f, 0.16138817f, 0.19158731f, 
    -0.02594062f, 0.12478500f, -0.09413285f, -0.04645307f, 0.18913974f, 0.01353805f, 0.03339996f, -0.01873046f, 
    0.02564200f, 0.04172855f, 0.14627036f, -0.04856949f, -0.11599768f, -0.19781666f, 0.07436892f, 0.06344548f, 
    0.06777355f, -0.02367434f, 0.11575215f, 0.13776398f, 0.08974271f, 0.31426376f, -0.18127544f, -0.05565251f, 
    -0.20316713f, 0.08150419f, -0.16621809f, -0.02569949f, 0.06517549f, -0.00553534f, -0.13052978f, 0.15763271f, 
    0.00216624f, 0.03931744f, -0.11687402f, -0.03577609f, -0.11999247f, -0.11617294f, 0.00885923f, 0.28606537f, 
    0.13342927f, -0.04219115f, -0.00275216f, 0.00580973f, 0.00248900f, 0.13164164f, 0.06641085f, 0.05078047f, 
    -0.03256675f, -0.00683946f, -0.00188724f, -0.05083300f, 0.05239615f, -0.00317809f, -0.00817291f, 0.15458891f, 
    0.01797557f, -0.16292782f, 0.03963083f, -0.13752130f, -0.21648140f, -0.17186590f, 0.14864658f, -0.10011538f, 
    0.03614338f, 0.12817115f, -0.12828511f, -0.05108214f, 0.02321846f, -0.02784648f, -0.01025184f, -0.03061580f, 
    0.00335833f, 0.16818044f, 0.01109030f, -0.07864468f, -0.07892073f, -0.06143135f, -0.02613606f, -0.18606260f, 
    0.03529992f, 0.13217661f, 0.06372761f, 0.16433981f, 0.11035462f, -0.04768357f, 0.07399274f, 0.18579909f, 
    0.14023140f, 0.14326958f, 0.11748077f, -0.04994576f, -0.00593610f, -0.08869231f, -0.05855862f, -0.08229300f, 
    -0.01537872f, 0.02281960f, 0.13251637f, 0.07370146f, 0.04811226f, -0.06803146f, 0.10195398f, -0.04628895f, 
    -0.13068046f, 0.03981721f, -0.05613882f, -0.06337149f, 0.19508488f, -0.05180172f, -0.02020101f, 0.05198543f, 
    -0.06208057f, -0.09095757f, 0.03062834f, -0.03862532f, -0.14714473f, 0.05379223f, -0.08452546f, 0.02994823f, 
    0.06693868f, 0.18620338f, 0.14817953f, 0.01733381f, 0.04788328f, 0.03788847f, 0.06472211f, 0.08249356f, 
    -0.07922448f, 0.04174338f, -0.01838117f, 0.00223148f, -0.38337708f, 0.03294210f, 0.07554583f, 0.05450765f, 
    -0.01124831f, 0.02090916f, 0.10952763f, -0.05633572f, 0.07513852f, 0.05470450f, -0.00777507f, 0.22211139f, 
    -0.01725165f, 0.06952417f, -0.08116994f, -0.04523355f, -0.08152621f, -0.08695193f, -0.11348823f, -0.08999302f, 
    -0.17456792f, -0.01693719f, -0.20830102f, 0.00970349f, -0.01723913f, 0.21943241f, -0.05877665f, 0.21548787f, 
    0.06780375f, 0.16832662f, -0.05085780f, 0.04340195f, -0.08699124f, 0.10758722f, -0.14700714f, -0.18165323f, 
    0.03807104f, 0.24885553f, -0.23981106f, -0.00559368f, -0.19989173f, 0.03895939f, -0.10454686f, 0.01654159f, 
    -0.02442612f, -0.15887733f, 0.05275197f, -0.06565028f, 0.10503155f, 0.06633550f, -0.00654163f, 0.10827814f, 
    0.07098810f, 0.13788733f, 0.20075212f, -0.04016283f, -0.10338011f, 0.08543340f, 0.11509311f, -0.04702872f, 
    0.20059142f, -0.02974101f, -0.08308835f, 0.04862784f, -0.00784179f, 0.05025610f, 0.07226509f, 0.19199066f, 
    -0.05423642f, 0.03280541f, -0.10383543f, -0.08547269f, 0.05712733f, 0.12046088f, 0.11537792f, -0.15132241f, 
    -0.01478558f, -0.03079737f, 0.02291686f, 0.02224966f, -0.07518271f, 0.06546617f, 0.13638334f, 0.07022055f, 
    0.45133460f, -0.05798565f, 0.01335999f, 0.19668227f, 0.01033662f, 0.06618917f, -0.02047089f, -0.02351118f, 
    0.08181440f, -0.07001060f, 0.03773317f, 0.00350068f, -0.03312711f, -0.09768096f, -0.00113474f, -0.19168808f, 
    -0.02950768f, -0.00032589f, 0.06410947f, -0.12920001f, -0.00351946f, 0.01413744f, 0.06433505f, 0.04807569f, 
    0.21587282f, -0.01973429f, 0.07714218f, 0.02299709f, 0.11053250f, 0.00088412f, -0.09818958f, -0.09450500f, 
    0.10452381f, 0.09404539f, -0.09132119f, -0.05624554f, 0.07792287f, 0.31759056f, -0.12751900f, -0.22416799f, 
    0.07380638f, -0.00319838f, 0.05290658f, 0.08319169f, 0.08841560f, 0.01490388f, 0.11120567f, -0.15281008f, 
    0.00074065f, -0.02035619f, 0.08026468f, 0.00291028f, -0.15177941f, -0.10179018f, -0.02395607f, 0.04672020f, 
    -0.07494575f, -0.09333120f, 0.02267548f, 0.05612914f, 0.04793223f, -0.10060699f, -0.11265485f, 0.00152393f, 
    0.12059123f, -0.03472153f, -0.05201415f, 0.11294469f, 0.07982076f, 0.07635635f, 0.04576572f, 0.07500321f, 
    -0.02542412f, 0.05077173f, -0.00624109f, -0.02958456f, 0.06378341f, -0.06842238f, -0.03917541f, -0.04844921f, 
    -0.05146491f, 0.04089770f, -0.07779634f, -0.05381591f, 0.03710714f, -0.02716530f, 0.01733969f, 0.01065187f, 
    0.04288434f, -0.04177909f, -0.02989900f, -0.02969317f, 0.05485616f, 0.01733565f, -0.03341372f, 0.04426806f, 
    -0.00094481f, -0.06378854f, -0.07201385f, -0.00557476f, -0.02548691f, 0.04005206f, -0.07331157f, 0.03433950f, 
    0.03538784f, 0.03396656f, -0.01545456f, -0.02980605f, 0.00726770f, 0.05401667f, 0.00757201f, -0.06097127f, 
    -0.03315920f, 0.02125533f, 0.04330735f, -0.00866625f, -0.01965366f, 0.01337927f, -0.02509512f, 0.02458612f, 
    -0.03291023f, 0.02495937f, -0.05501639f, -0.03372707f, -0.07184844f, -0.01326297f, 0.05008332f, 0.02855857f, 
    0.04094793f, 0.01410095f, -0.00192989f, -0.03184859f, -0.00572766f, -0.00092421f, 0.03558261f, 0.01287142f, 
    -0.02665215f, -0.01091532f, -0.00107089f, 0.04845493f, 0.05284347f, 0.05750619f, 0.02760403f, 0.01716196f, 
    0.00483649f, -0.03364961f, -0.02503807f, -0.03379533f, 0.01585506f, 0.00112484f, -0.04792854f, 0.02724510f, 
    0.02823850f, 0.02895911f, -0.01308460f, 0.02134690f, 0.04336436f, -0.02159076f, 0.04665701f, -0.07349690f, 
    -0.06643867f, -0.03992772f, -0.06196954f, -0.07952564f, 0.03148346f, -0.00158469f, -0.07999139f, 0.01058023f, 
    -0.06260242f, -0.03685115f, -0.06647941f, 0.01849356f, 0.00460511f, -0.01821573f, 0.05134321f, 0.00030629f, 
    -0.06926657f, 0.03000510f, 0.00527442f, -0.08043662f, -0.01544657f, -0.01930344f, 0.01968431f, -0.01302508f, 
    -0.08003082f, -0.03352800f, -0.04739591f, 0.01131923f, -0.05080243f, -0.00687533f, -0.07103909f, -0.06247094f, 
    0.01220198f, 0.03856091f, -0.02095396f, -0.04285536f, 0.01452478f, -0.02892720f, -0.08520412f, -0.06939118f, 
    -0.06404109f, 0.00527742f, 0.00722810f, -0.01684838f, -0.04073965f, 0.05084733f, -0.03838462f, -0.05815407f, 
    0.03894108f, 0.03345815f, -0.01620710f, -0.01107392f, 0.01120950f, 0.02043934f, -0.03089839f, -0.02707512f, 
    0.04543267f, -0.03128772f, -0.03667785f, -0.04938829f, 0.01313995f, -0.00777974f, 0.00002484f, -0.05338651f, 
    -0.01351102f, 0.03995328f, -0.04819625f, 0.04161208f, 0.03310170f, -0.03414392f, 0.00437598f, 0.04941900f, 
    0.04515160f, 0.05278889f, -0.07730947f, -0.03013014f, 0.01797163f, 0.03031906f, 0.05264112f, 0.03653745f, 
    -0.01384009f, -0.03970313f, 0.06496129f, -0.04027150f, 0.06595397f, -0.00509399f, 0.03363810f, -0.01516935f, 
    0.02082390f, -0.00515920f, 0.04354062f, -0.07738040f, -0.06486452f, 0.04076623f, -0.05427554f, 0.02029716f, 
    -0.06890132f, 0.02560179f, 0.01941706f, 0.00957218f, -0.03322156f, -0.03141097f, -0.05538358f, -0.07999105f, 
    -0.23490191f, 0.08522935f, 0.00806454f, 0.08852210f, -0.11124955f, -0.05822365f, 0.02719619f, 0.07950575f, 
    -0.01474617f, -0.01528177f, -0.06400635f, 0.07556265f, -0.16864850f, -0.11415153f, -0.02582140f, 0.02736463f, 
    0.09536924f, 0.02806056f, 0.12765218f, -0.09269159f, 0.08506864f, 0.07460663f, -0.14508586f, -0.06461772f, 
    -0.25788742f, 0.17512333f, 0.12190949f, 0.26726460f, 0.11546342f, 0.07403298f, 0.08948750f, -0.12475529f, 
    0.01584229f, 0.07160763f, 0.00634906f, 0.10907764f, 0.36429614f, 0.00316035f, 0.09286210f, 0.34675235f, 
    -0.12625207f, 0.16659258f, 0.07293483f, -0.04221040f, -0.03704948f, 0.01026505f, -0.09659478f, 0.11674440f, 
    -0.06554329f, -0.00875402f, -0.11609530f, 0.08229402f, -0.07304868f, 0.02513058f, -0.03822092f, 0.04580498f, 
    -0.03956004f, -0.09369300f, -0.11154947f, -0.05035811f, 0.19385916f, 0.07322247f, 0.04393002f, 0.02305605f, 
    -0.01589917f, -0.00590773f, 0.04852836f, -0.00399692f, -0.12037041f, 0.11994903f, -0.06247632f, -0.24404109f, 
    -0.31551066f, 0.48389074f, -0.32325932f, 0.42891681f, 0.01133148f, -0.02043219f, -0.04743788f, 0.00777145f, 
    0.00400781f, -0.05793198f, -0.09377673f, -0.02170430f, 0.08298600f, 0.07510136f, 0.05585240f, 0.09873805f, 
    0.06845456f, 0.21617092f, -0.09695481f, -0.08570552f, -0.00700570f, 0.03614677f, 0.00400170f, 0.03618991f, 
    -0.00709859f, 0.04800101f, -0.14834458f, -0.16455875f, 0.11473932f, 0.07719404f, 0.06691955f, -0.07436871f, 
    -0.07112358f, 0.12576614f, 0.10385972f, -0.03226842f, -0.10009751f, -0.21332693f, 0.07964785f, 0.17536813f, 
    0.14325330f, -0.12313028f, 0.30193734f, -0.01467450f, 0.07363532f, 0.11807042f, 0.01128755f, 0.15176453f, 
    -0.02104248f, 0.20585032f, 0.03578256f, 0.02160244f, 0.07572205f, 0.09247279f, 0.08444977f, 0.04842512f, 
    0.22182299f, 0.06306874f, -0.08004377f, -0.06042001f, 0.07625168f, -0.06143196f, 0.00075417f, -0.08632924f, 
    -0.01126526f, 0.02521467f, -0.01643808f, 0.05384354f, 0.03279516f, 0.08096543f, 0.05049458f, 0.13689159f, 
    -0.10993996f, -0.08654942f, -0.07437453f, 0.06621818f, -0.03110317f, -0.07421238f, -0.01583627f, 0.07342517f, 
    0.02824080f, -0.03357232f, -0.12324410f, -0.03317710f, -0.22601737f, 0.04699317f, 0.16019724f, 0.15288846f, 
    0.26806363f, 0.12402380f, 0.00227009f, 0.12205932f, -0.00224241f, 0.02667235f, -0.17596368f, 0.12703133f, 
    -0.23475410f, -0.01052833f, 0.07287532f, -0.09963074f, -0.01854229f, -0.08940125f, -0.08706544f, 0.00998006f, 
    0.03394459f, 0.05682905f, 0.23001246f, 0.18978442f, 0.04313830f, -0.20339106f, -0.09459788f, -0.00971655f, 
    0.19531301f, 0.09269574f, -0.02185271f, -0.10832415f, -0.06088803f, -0.00373007f, -0.14153491f, -0.00549283f, 
    -0.24065813f, -0.20071176f, -0.07921772f, -0.11979623f, -0.00347325f, -0.10911842f, -0.00525699f, -0.08222441f, 
    0.04601221f, -0.01849846f, -0.01066481f, -0.00549944f, -0.19004330f, 0.01651463f, -0.05956940f, 0.16017264f, 
    -0.05091513f, 0.04111160f, 0.04303718f, 0.03376357f, 0.08382594f, 0.09550589f, -0.09161191f, -0.13478851f, 
    0.25242665f, -0.17801172f, 0.01650380f, 0.02780553f, 0.02396790f, 0.03169251f, 0.10148022f, 0.00672239f, 
    0.02616141f, 0.03162445f, -0.03719486f, 0.06715442f, -0.30190715f, -0.07233457f, 0.09510726f, 0.08970103f, 
    0.16002688f, 0.13249090f, -0.10874187f, -0.07706969f, 0.08486666f, -0.05317229f, 0.08311066f, 0.13508300f, 
    -0.13902707f, -0.16106586f, -0.15363663f, -0.15328166f, -0.01263992f, 0.02374693f, -0.00158605f, -0.10599225f, 
    -0.11162464f, -0.20823880f, -0.00047484f, -0.15556759f, -0.11372965f, 0.19143896f, -0.01144482f, -0.03134859f, 
    -0.00310015f, -0.11270330f, 0.04335854f, 0.02381324f, 0.03170831f, 0.00256782f, 0.01809165f, -0.12364166f, 
    0.53781265f, 0.03572258f, 0.17709300f, -0.34279418f, -0.00658302f, -0.04898804f, -0.22426383f, -0.06187115f, 
    -0.03733220f, -0.14586897f, -0.01640000f, 0.02841580f, -0.02804687f, -0.09824266f, 0.18121201f, 0.00036650f, 
    0.06247179f, 0.12203764f, 0.01108809f, -0.11757179f, 0.05188644f, -0.01605429f, 0.15058753f, 0.17865586f, 
    0.05230127f, 0.11174852f, 0.12212797f, -0.07343729f, -0.05891974f, 0.04944996f, 0.14058813f, 0.11573379f, 
    0.10754813f, -0.00164166f, 0.04723100f, 0.03100667f, -0.11830365f, -0.09746955f, -0.01842198f, 0.03306604f, 
    0.07551707f, 0.03803351f, 0.15415609f, -0.09486378f, -0.17418209f, 0.05799445f, 0.07502723f, -0.06641832f, 
    0.27421281f, -0.11981242f, 0.04965037f, 0.08790845f, 0.12778680f, 0.19066645f, 0.09593733f, 0.08376436f, 
    0.07963414f, -0.04866140f, 0.08483992f, 0.02572536f, -0.14418492f, 0.08653224f, -0.04586968f, -0.02098177f, 
    0.13223380f, 0.02015021f, -0.13449292f, -0.03384266f, -0.02564430f, -0.10391182f, 0.09795036f, 0.04663773f, 
    0.17218895f, 0.03949099f, 0.09844726f, 0.02167944f, 0.02532147f, 0.10916874f, 0.11444163f, 0.02880977f, 
    -0.06258021f, -0.14845957f, 0.13730030f, -0.09463437f, 0.06777266f, -0.07963327f, -0.00316097f, 0.11456143f, 
    -0.08187551f, 0.04288268f, 0.05220589f, 0.16629320f, 0.10615508f, -0.09314549f, 0.02644684f, 0.05410811f, 
    -0.14313011f, 0.08261800f, 0.04966145f, -0.00201104f, -0.09057846f, -0.14877039f, -0.01822774f, 0.00349456f, 
    0.03084721f, 0.08097609f, 0.12435886f, 0.04390751f, 0.19559273f, 0.18635732f, 0.13712297f, -0.17401136f, 
    0.09123905f, 0.05918657f, 0.04665423f, -0.09285552f, 0.01249154f, 0.00250705f, 0.06255214f, 0.08636108f, 
    -0.04798315f, -0.04209690f, -0.06691387f, -0.03310234f, 0.11523870f, -0.03884198f, 0.05390991f, 0.08312266f, 
    0.07840078f, 0.01345403f, -0.10644392f, -0.05637783f, -0.09742678f, -0.20063202f, -0.01328206f, 0.03184117f, 
    0.06088360f, 0.09540136f, -0.01802394f, 0.01352743f, -0.16158977f, -0.11131915f, 0.16268073f, 0.13209680f, 
    0.03619201f, -0.03188850f, -0.14143735f, -0.22436008f, 0.02836557f, -0.17613344f, 0.00992129f, 0.04479937f, 
    0.02610660f, 0.09673785f, -0.01384592f, -0.02029140f, 0.13824637f, -0.13860698f, 0.01149179f, 0.12778454f, 
    -0.00763408f, 0.14971443f, -0.19619824f, -0.02476641f, 0.05474299f, 0.08106320f, -0.23008271f, 0.07190961f, 
    -0.10424503f, 0.13507047f, -0.04995165f, 0.02141300f, -0.00789532f, -0.00778202f, 0.08826426f, -0.07644592f, 
    0.11505105f, -0.20153475f, -0.04605709f, 0.01344374f, -0.11137645f, -0.10912502f, 0.19747822f, -0.00396640f, 
    -0.00903579f, 0.07781185f, 0.12630583f, -0.01754780f, -0.10068382f, -0.24299803f, -0.04389388f, 0.01226019f, 
    0.10245217f, -0.10122281f, 0.21409830f, -0.11246349f, 0.24153125f, 0.02188330f, 0.15634707f, 0.17031585f, 
    0.22013605f, 0.05495286f, 0.10526090f, 0.04929308f, 0.06453197f, -0.03374072f, -0.02369110f, 0.10071336f, 
    -0.34656432f, -0.14321639f, -0.06398045f, -0.35691130f, 0.18933195f, -0.00509057f, 0.05803359f, 0.01269151f, 
    0.03690983f, 0.08232459f, 0.19993432f, -0.05503624f, -0.03120134f, -0.11689306f, 0.03864709f, 0.22816776f, 
    -0.13530669f, -0.03324593f, 0.01718342f, -0.00390021f, 0.06098373f, -0.04424186f, 0.06824029f, 0.08331253f, 
    0.09144755f, -0.00579818f, -0.22678842f, 0.08702566f, -0.19840115f, 0.05537568f, -0.15093376f, -0.10020439f, 
    -0.10144985f, -0.04783773f, -0.30372921f, -0.09895828f, 0.10780694f, 0.13884369f, -0.16018502f, -0.01911275f, 
    -0.07487039f, 0.00667943f, 0.07819033f, -0.18110430f, 0.03028719f, 0.01412802f, -0.03598025f, -0.00673641f, 
    -0.00613957f, -0.01316064f, -0.32361260f, -0.09249451f, 0.06358501f, 0.01443909f, 0.11360607f, 0.05023449f, 
    -0.16412014f, 0.04433782f, 0.02809765f, -0.08884196f, 0.06223071f, -0.01001888f, 0.04492261f, -0.08469808f, 
    -0.29227430f, -0.41170716f, 0.10622940f, 0.06659776f, 0.02286369f, -0.04799021f, 0.24153568f, -0.07392588f, 
    0.02380532f, 0.07860520f, 0.16424920f, 0.24077104f, -0.22179529f, -0.02738687f, 0.15449642f, 0.02595431f, 
    0.09261400f, 0.01588677f, 0.02987221f, 0.02234536f, 0.09561044f, -0.00856242f, -0.01420455f, 0.04301883f, 
    0.00480263f, 0.01770297f, 0.01488955f, -0.08786438f, 0.05287571f, 0.25892457f, 0.21030328f, 0.10516340f, 
    0.03518962f, 0.00404034f, 0.01956586f, -0.22096799f, -0.02172532f, 0.01254373f, -0.01399819f, -0.06884690f, 
    0.05519990f, 0.02100771f, 0.02568489f, 0.19859985f, 0.08906787f, 0.04954362f, 0.08409674f, 0.00422764f, 
    -0.08467439f, 0.00715842f, 0.00897009f, -0.03578091f, -0.35450876f, -0.00151672f, -0.08583594f, -0.03171045f, 
    0.05396745f, 0.08124486f, 0.09578903f, 0.11409357f, 0.09600211f, -0.04649308f, 0.01834409f, 0.03824648f, 
    -0.09101182f, -0.03733864f, 0.20488840f, -0.32998720f, 0.04847376f, -0.01302416f, 0.10027146f, -0.18542349f, 
    -0.01334787f, 0.03117329f, 0.10019337f, -0.04156565f, 0.31775212f, -0.00947563f, -0.00874206f, 0.20702766f, 
    -0.14808998f, -0.05738805f, 0.08298331f, 0.06115989f, 0.11303088f, 0.03356504f, -0.22316577f, 0.06541243f, 
    0.03726846f, 0.14205796f, 0.08756806f, 0.09180322f, 0.12243257f, 0.07779343f, 0.08791388f, 0.05306951f, 
    0.01338339f, 0.02375365f, 0.01495928f, 0.01978051f, -0.44883287f, -0.19989271f, 0.06813935f, -0.14378887f, 
    -0.29693970f, 0.23508826f, -0.01853969f, 0.02405146f, -0.09059717f, -0.02105570f, 0.13811381f, -0.01481810f, 
    -0.02263447f, 0.35492310f, -0.20591681f, 0.40310889f, 0.05839833f, -0.04424431f, 0.32143801f, -0.08191782f, 
    0.01967907f, -0.04533658f, 0.03485439f, 0.10163675f, -0.17635757f, -0.00676531f, -0.07566148f, -0.02404591f, 
    -0.04347122f, -0.04655563f, -0.06816236f, -0.08081071f, -0.03124383f, 0.00547633f, -0.01609418f, -0.02611842f, 
    -0.39949140f, -0.20285991f, -0.07984550f, -0.05466294f, -0.07781871f, -0.00760027f, -0.04063286f, -0.09113607f, 
    -0.09544214f, 0.04655826f, 0.10097770f, 0.06433704f, -0.00890278f, -0.15204060f, -0.02817724f, -0.06621356f, 
    -0.03095174f, 0.09207432f, -0.08420437f, -0.03108574f, -0.09470738f, 0.02385710f, -0.05122740f, -0.01594886f, 
    0.02591969f, 0.16839686f, -0.16300946f, -0.13858572f, 0.09332951f, -0.05342693f, 0.09904608f, -0.08812882f, 
    0.06987183f, 0.05749846f, 0.07787314f, -0.03982351f, 0.26192915f, -0.05371140f, -0.13635927f, -0.05030783f, 
    -0.01902543f, -0.11146576f, 0.03775467f, -0.06722712f, 0.07623815f, 0.07758804f, -0.04900997f, 0.00025039f, 
    -0.22186571f, 0.04445324f, 0.03999464f, 0.07869596f, -0.05394535f, -0.02435210f, 0.21343252f, -0.01679893f, 
    -0.14255485f, 0.02032567f, 0.13036613f, -0.06602027f, -0.29371944f, -0.12605672f, 0.00639280f, 0.25623891f, 
    -0.01568447f, -0.08513664f, 0.25932205f, 0.20596263f, 0.02955271f, -0.02283429f, 0.01279670f, 0.10147078f, 
    0.13120185f, 0.18343003f, 0.15646327f, -0.07121749f, 0.08522043f, -0.03255501f, -0.05137515f, 0.02895474f, 
    0.08186797f, 0.05350325f, -0.10168841f, -0.01250052f, 0.02965235f, -0.03817458f, 0.16695771f, -0.19377787f, 
    -0.00294875f, 0.00793115f, -0.13471501f, -0.20435371f, 0.08783180f, -0.00593113f, 0.15029541f, 0.03172079f, 
    -0.14117773f, -0.04681702f, 0.03629866f, -0.06572889f, -0.09146219f, -0.12929563f, 0.07952943f, -0.05322443f, 
    0.13967998f, -0.03002879f, -0.00421679f, 0.07890312f, 0.02545055f, -0.00469931f, -0.02084090f, -0.02116280f, 
    -0.12584215f, -0.00585450f, -0.03316724f, 0.12513123f, 0.33165744f, 0.08527101f, 0.07394958f, -0.14386599f, 
    -0.01428078f, -0.06501254f, -0.10277618f, -0.00855821f, 0.11912158f, 0.02134260f, 0.11013214f, -0.07426802f, 
    -0.03511651f, -0.02940304f, 0.02043044f, 0.01222192f, 0.37256637f, 0.26296532f, -0.19573963f, 0.01781035f, 
    0.09451938f, 0.10173115f, 0.10741564f, 0.10181241f, -0.01810498f, 0.04537940f, 0.25946978f, -0.07676534f, 
    -0.19867051f, -0.08643473f, -0.10507634f, -0.13436575f, -0.04412204f, 0.04463142f, 0.01128472f, -0.08179511f, 
    -0.01743258f, -0.13158268f, 0.09367235f, -0.10651432f, -0.10827490f, -0.20746033f, -0.06678969f, -0.16776356f, 
    0.04524608f, -0.15283820f, 0.10542873f, 0.12341013f, -0.03576522f, -0.07586697f, 0.01031921f, 0.02623921f, 
    0.18562572f, -0.09151562f, 0.45773849f, 0.07898164f, 0.13569903f, 0.20697938f, 0.04415093f, -0.08285892f, 
    0.07660968f, -0.07645574f, -0.12957352f, -0.08210338f, -0.15306309f, -0.03839807f, 0.10037799f, 0.11950201f, 
    0.05702266f, 0.08176076f, -0.04546819f, 0.03293248f, 0.10563044f, -0.00974025f, -0.03675858f, 0.10679303f, 
    -0.08176462f, -0.08297986f, 0.15605925f, 0.01542497f, -0.07351775f, 0.05138452f, 0.03424622f, -0.04946449f, 
    -0.02620842f, -0.00147458f, 0.01395772f, -0.03547926f, 0.01040544f, -0.21868467f, -0.15936042f, 0.09706312f, 
    0.03631313f, 0.14556119f, 0.17751200f, 0.16079797f, 0.01889493f, 0.03601838f, 0.03507543f, 0.10929845f, 
    -0.21907803f, 0.07264327f, -0.03753717f, -0.09555387f, -0.04434958f, 0.07388294f, -0.11033276f, 0.07064467f, 
    0.17688398f, 0.00963197f, -0.01502115f, 0.03361851f, -0.16366236f, 0.10911050f, -0.01406023f, 0.06431459f, 
    0.23832245f, 0.04869196f, -0.05223091f, 0.12864552f, 0.17276490f, -0.04517413f, 0.04683390f, 0.02929627f, 
    -0.23783991f, -0.01486682f, 0.02012112f, -0.04102771f, -0.05474130f, 0.11965812f, 0.17861609f, 0.08313634f, 
    -0.11602864f, -0.19512446f, 0.15476921f, -0.26797608f, 0.02709399f, -0.25089219f, -0.00975104f, 0.11782049f, 
    -0.11528902f, 0.08496112f, 0.08795243f, -0.03241809f, 0.10988272f, 0.04406892f, -0.00356161f, 0.02035730f, 
    -0.01435765f, 0.17550007f, 0.10384818f, -0.02700131f, -0.04059156f, 0.01152865f, -0.09058049f, -0.01565537f, 
    0.05744001f, 0.04992344f, 0.15605697f, 0.18535969f, -0.05488419f, 0.03804623f, 0.12853780f, 0.12255058f, 
    0.02437885f, 0.09496709f, 0.12982121f, -0.12623109f, -0.02340267f, -0.07345562f, -0.06829224f, -0.07093770f, 
    -0.06527998f, -0.03735117f, 0.07710513f, 0.05602513f, 0.11615176f, 0.04374986f, -0.16990447f, -0.14420627f, 
    -0.03638484f, -0.11083507f, 0.04244018f, -0.05023061f, 0.21551915f, -0.00603886f, 0.09241087f, 0.06073629f, 
    -0.04848167f, -0.24940686f, -0.07321404f, -0.26669729f, 0.08638109f, 0.02218001f, 0.03474233f, 0.01476484f, 
    0.06035148f, -0.01020672f, -0.44736713f, 0.19276735f, -0.02688733f, -0.07176232f, -0.01247870f, 0.03474699f, 
    -0.06064998f, 0.05626050f, -0.04253368f, 0.03681702f, -0.07241096f, 0.03598735f, -0.05342143f, -0.13237472f, 
    0.05124696f, -0.22930603f, 0.09919657f, -0.13613285f, -0.14058216f, 0.15726207f, 0.00892519f, -0.13373846f, 
    -0.03227544f, -0.14536448f, 0.03499824f, 0.04690735f, 0.04676455f, 0.08271804f, -0.09416315f, 0.07915105f, 
    0.00392619f, 0.08050732f, 0.07943743f, -0.05207628f, 0.18876258f, -0.19229427f, -0.04324500f, -0.01293497f, 
    0.13767563f, -0.12852611f, 0.06963051f, -0.03005359f, 0.12873505f, 0.08849555f, 0.10740037f, 0.10162176f, 
    0.29304054f, -0.15894884f, 0.35609728f, 0.06681883f, -0.01930770f, 0.12815237f, -0.13406472f, 0.30153301f, 
    0.08913913f, 0.10599264f, -0.21796066f, -0.07544207f, 0.10172042f, 0.05477764f, 0.12150040f, 0.14318778f, 
    0.03111529f, 0.01698436f, -0.03367477f, 0.07634977f, 0.01081772f, -0.23242606f, -0.07235400f, -0.14011919f, 
    0.11826520f, 0.05523997f, 0.12862757f, 0.08508354f, 0.00111332f, 0.03448501f, -0.09855390f, 0.14942557f, 
    0.08648115f, -0.02033195f, 0.01156811f, -0.02985490f, -0.16480730f, -0.03396064f, -0.29202774f, -0.32251501f, 
    0.09773571f, -0.13015850f, 0.05126779f, -0.10304457f, 0.03337127f, -0.09146069f, -0.15672699f, 0.08447248f, 
    -0.09778985f, 0.03170483f, -0.05620886f, 0.07140406f, 0.01861364f, -0.01484131f, -0.25323865f, -0.00228111f, 
    0.05704440f, 0.05671125f, -0.11938077f, 0.05810230f, -0.16915676f, -0.04666904f, 0.08196618f, 0.08484384f, 
    -0.04646340f, 0.01998665f, -0.07815808f, 0.16491123f, -0.06239915f, 0.01913917f, -0.00471461f, -0.34898216f, 
    0.04997203f, 0.05243418f, -0.08499173f, -0.03045559f, 0.13012700f, -0.14887905f, -0.04579407f, 0.08773243f, 
    0.08268073f, 0.03419851f, 0.16675282f, -0.10164974f, -0.09801672f, 0.08213940f, -0.10966880f, 0.05858058f, 
    -0.04928163f, 0.02959426f, -0.12254776f, -0.40305999f, 0.06921712f, 0.10634437f, 0.03446359f, 0.12989433f, 
    0.07773194f, 0.06761082f, -0.09597152f, 0.07474422f, 0.07524210f, 0.01923790f, -0.05683378f, -0.30563131f, 
    -0.13163422f, 0.02786950f, -0.27933824f, -0.12218633f, 0.25201452f, 0.32887140f, 0.25451258f, 0.23354556f, 
    0.00640304f, 0.01313506f, 0.04398960f, 0.18569589f, 0.02152430f, 0.13452114f, 0.06250485f, -0.12759396f, 
    0.02522579f, 0.05325561f, 0.05915933f, -0.01988539f, 0.03044422f, -0.05165377f, 0.00599175f, 0.00311968f, 
    0.02641664f, -0.07155528f, 0.02896909f, 0.04039753f, 0.04054023f, -0.03276156f, -0.03324016f, 0.01540770f, 
    -0.05099638f, 0.00004527f, -0.00313156f, -0.03535987f, -0.06179724f, -0.01550813f, 0.03829384f, -0.03048409f, 
    0.04716322f, -0.04696032f, -0.02790225f, 0.06419775f, 0.01493014f, -0.03997844f, 0.03818092f, -0.04043039f, 
    0.03178949f, -0.07658833f, -0.00513243f, -0.01250261f, 0.04621839f, -0.05196636f, -0.04440127f, -0.07403443f, 
    0.03272156f, -0.01779826f, 0.05717064f, -0.03866546f, -0.02718370f, 0.01781084f, -0.06668867f, -0.00899911f, 
    -0.01933629f, -0.04855039f, -0.07355996f, 0.02290996f, -0.07609142f, -0.06960587f, -0.03941764f, 0.05633884f, 
    0.01205723f, -0.04315927f, 0.03336444f, -0.05029168f, 0.04793072f, -0.06044886f, -0.00243203f, -0.01639536f, 
    0.00899174f, 0.01371132f, -0.01629311f, -0.06845509f, 0.03877854f, -0.05406031f, 0.00125569f, -0.07753202f, 
    0.01754167f, -0.02065289f, -0.06603342f, 0.06272603f, -0.02461536f, -0.06945973f, -0.05220213f, -0.06638837f, 
    -0.04209764f, 0.05726845f, -0.00913553f, -0.02199966f, -0.05293823f, 0.01678279f, 0.02961384f, 0.03619130f, 
    0.00003260f, -0.03488268f, 0.05154957f, 0.01817885f, -0.06440160f, 0.02611103f, 0.06270164f, -0.01903817f, 
    -0.06019735f, -0.06470774f, -0.07187339f, -0.00277900f, -0.04611338f, -0.03190203f, -0.00722692f, -0.06294539f, 
    0.01928469f, -0.06961911f, 0.00778099f, -0.02569131f, -0.06470165f, -0.04215144f, -0.03511715f, 0.00097873f, 
    -0.03118275f, -0.05604314f, -0.06379502f, 0.04016979f, -0.05880361f, -0.04193600f, -0.07891916f, -0.01750634f, 
    -0.01881392f, 0.02988105f, 0.06096011f, 0.02007067f, 0.03598382f, 0.02349976f, 0.00828010f, 0.03641972f, 
    -0.07634778f, -0.00486545f, 0.05816629f, 0.02890867f, -0.00773398f, -0.04897432f, 0.00584273f, -0.02684742f, 
    -0.03764889f, -0.05641258f, 0.04255224f, -0.05813113f, -0.03220938f, 0.01824726f, -0.02111200f, -0.02069517f, 
    -0.08287816f, 0.03116272f, 0.00235246f, 0.06174699f, 0.01474065f, -0.01909167f, -0.01599647f, 0.04865062f, 
    -0.06118826f, 0.03434882f, -0.06053489f, 0.03630501f, -0.04767708f, 0.00737327f, 0.03958398f, -0.04218198f, 
    0.02907925f, -0.07093501f, 0.03265232f, -0.07860826f, -0.01658159f, 0.04649875f, -0.00178716f, 0.04932046f, 
    0.03394779f, 0.05912157f, -0.01148204f, -0.03977637f, 0.00227715f, 0.06306218f, -0.04380095f, -0.02403708f, 
    -0.01328073f, -0.05983242f, -0.01928407f, 0.04921881f, -0.00310781f, 0.01337002f, 0.00711759f, -0.03837904f, 
    0.00641238f, -0.01410091f, -0.00374725f, -0.02271921f, 0.03672254f, -0.00079558f, 0.03718589f, 0.00845093f, 
    0.07528549f, -0.09495191f, 0.00428661f, -0.05995997f, -0.04415467f, 0.04435117f, -0.02430788f, -0.05930771f, 
    -0.05657273f, -0.00022984f, -0.06806724f, -0.05551378f, -0.38409007f, 0.18336657f, 0.05061697f, -0.09294369f, 
    -0.13323581f, -0.01235223f, -0.02100137f, -0.01560342f, 0.02041830f, 0.17934752f, 0.09819293f, -0.03178341f, 
    -0.01706824f, -0.19468662f, 0.00459801f, 0.00884998f, -0.01411250f, 0.00377163f, 0.23209094f, -0.03242966f, 
    -0.06335948f, -0.07613359f, -0.04293228f, 0.05817085f, 0.51300812f, 0.07958627f, 0.03610926f, 0.17517518f, 
    0.21667135f, 0.08183031f, 0.08877008f, 0.03812992f, 0.04862284f, 0.03983391f, 0.04369230f, 0.21099336f, 
    -0.04092122f, -0.11973855f, -0.02006266f, -0.03593782f, -0.10405678f, -0.04897658f, 0.07252972f, -0.10466020f, 
    -0.02692412f, -0.12048991f, 0.00926686f, -0.12558648f, -0.16001767f, -0.00817525f, -0.14148735f, -0.09598073f, 
    0.02060360f, 0.12336062f, -0.00409529f, 0.07141799f, 0.20491347f, 0.09646000f, 0.15123700f, 0.17061144f, 
    0.17075330f, -0.32866293f, 0.05135062f, -0.24658027f, 0.19876067f, 0.07885286f, 0.20145211f, -0.17003520f, 
    0.01989620f, 0.00165054f, -0.04889378f, 0.06396902f, -0.15128146f, -0.12522922f, -0.05760649f, -0.18634617f, 
    0.10570060f, -0.13770938f, -0.03311081f, -0.00740496f, -0.05573288f, 0.02899018f, -0.08393023f, -0.01716630f, 
    -0.08485062f, -0.05431674f, -0.10805602f, -0.11966311f, -0.03065489f, -0.11035828f, 0.13338530f, -0.16350338f, 
    0.12539949f, 0.05527326f, 0.05044747f, 0.08083454f, -0.00809639f, -0.00181112f, -0.05952247f, 0.12926091f, 
    0.08592374f, 0.05399253f, 0.08602630f, -0.04743494f, 0.19232021f, 0.02151202f, -0.00901499f, 0.11324243f, 
    -0.21997933f, 0.04119159f, 0.01067681f, -0.24471545f, 0.01017317f, 0.05142236f, 0.10624044f, 0.09860332f, 
    -0.07596710f, 0.05540333f, 0.06281897f, 0.15362659f, -0.17361642f, 0.08458541f, -0.10686256f, 0.11636631f, 
    0.29751182f, 0.02402705f, 0.10928962f, 0.02698997f, 0.16410522f, 0.00773926f, -0.02723300f, 0.05188465f, 
    -0.24046278f, -0.06222250f, -0.09131081f, -0.20295300f, -0.03727235f, 0.11453568f, 0.06695943f, 0.16724421f, 
    0.06444735f, -0.06563715f, 0.00179057f, 0.00745770f, 0.03437643f, -0.30864221f, 0.14794816f, -0.03781535f, 
    0.11243113f, -0.13340034f, 0.13523878f, 0.09866506f, 0.25511649f, 0.12347709f, 0.04027195f, 0.09091189f, 
    -0.17592494f, 0.07953309f, -0.01584844f, 0.07199891f, -0.04238292f, -0.08718278f, -0.06556271f, -0.02174966f, 
    0.00314044f, 0.10997133f, 0.14044903f, 0.21314888f, -0.17078312f, 0.04011887f, -0.10756773f, -0.22546816f, 
    -0.02564913f, 0.11818696f, 0.04840998f, 0.07909732f, 0.00994323f, 0.10030495f, 0.04950886f, -0.03809259f, 
    0.17433475f, 0.04228134f, -0.01251460f, 0.07131261f, -0.00957250f, 0.02943618f, -0.02159358f, 0.08218548f, 
    -0.08535755f, 0.05632945f, 0.05718840f, -0.14931549f, -0.32895690f, -0.15922275f, -0.20950575f, -0.15023054f, 
    -0.00553135f, 0.01137562f, -0.10392416f, -0.11166786f, -0.10729793f, 0.07540400f, -0.08110642f, -0.09284750f, 
    0.29082105f, 0.07419398f, 0.03677087f, -0.02740049f, -0.13026908f, 0.06815706f, 0.05597559f, 0.12557045f, 
    -0.11579660f, 0.04773013f, -0.04130847f, -0.12887622f, 0.22818828f, -0.22154157f, 0.30053180f, -0.01156839f, 
    0.17816713f, 0.02737984f, -0.00219497f, 0.11233033f, 0.00279756f, 0.02916979f, -0.05303650f, 0.08781882f, 
    0.08657453f, 0.03213257f, -0.02292964f, 0.03124459f, 0.01737053f, -0.04700381f, -0.01047404f, -0.01255043f, 
    0.00981393f, -0.15968160f, -0.06369284f, -0.08622993f, -0.01534833f, 0.17628320f, 0.17363507f, 0.03735573f, 
    0.10347158f, 0.14871499f, -0.04408496f, 0.09985752f, 0.05768288f, -0.02938753f, -0.05721556f, -0.05994051f, 
    0.10262135f, 0.02180400f, -0.29355696f, -0.27566198f, -0.16187832f, -0.04323521f, 0.23940630f, 0.18357556f, 
    -0.05830542f, -0.00634555f, 0.03173056f, 0.02791804f, 0.11807717f, 0.10561056f, -0.14472507f, -0.01383545f, 
    0.08352617f, 0.11420496f, 0.16374454f, 0.03616266f, -0.04334586f, 0.04658426f, 0.08231974f, 0.01735794f, 
    0.21451591f, 0.21655582f, 0.12404610f, 0.05860816f, 0.11043476f, -0.04144596f, 0.19302994f, 0.13529587f, 
    0.00776063f, -0.00975487f, -0.05801804f, -0.08061878f, -0.01224478f, 0.08063150f, -0.01298398f, -0.11005853f, 
    0.06850027f, -0.02324937f, 0.06670618f, -0.01308341f, 0.15455973f, 0.07862144f, 0.09439947f, -0.07898057f, 
    0.29782104f, -0.17595428f, -0.08473460f, -0.06221000f, 0.03401960f, 0.02276452f, 0.06461167f, 0.11023807f, 
    0.04950550f, -0.07577744f, -0.13248289f, -0.08588034f, 0.27573293f, -0.01145659f, -0.06093932f, -0.11519133f, 
    -0.07004162f, 0.03006826f, 0.16302231f, -0.10102729f, -0.00429547f, 0.01345626f, -0.04849590f, 0.09035481f, 
    0.14638975f, 0.15428169f, -0.06256169f, -0.05903893f, 0.02622124f, 0.04881367f, 0.02352668f, 0.07974219f, 
    0.11054010f, -0.03306310f, -0.11003412f, -0.03171204f, -0.01015996f, 0.10761181f, 0.12483114f, -0.12430339f, 
    0.26399469f, -0.03825794f, -0.01549322f, 0.05460956f, 0.08318084f, -0.06216884f, 0.08973963f, -0.05712974f, 
    0.02484332f, -0.09889100f, -0.01327726f, 0.05399646f, -0.10410467f, -0.00743694f, 0.05136537f, -0.02030941f, 
    0.11386622f, 0.06980633f, 0.06699165f, 0.09697708f, 0.08241114f, -0.01696868f, -0.03181317f, -0.03041317f, 
    0.11589897f, -0.04041528f, 0.00990535f, 0.06790178f, -0.04856277f, -0.08405961f, -0.10628121f, 0.12238066f, 
    -0.13811460f, -0.33449793f, -0.03838848f, 0.04580522f, 0.18047747f, -0.03239796f, -0.23374486f, -0.12695505f, 
    0.10650630f, -0.20442365f, 0.08446065f, 0.02722104f, -0.08317420f, 0.01064508f, 0.06148390f, 0.19552523f, 
    0.08012933f, 0.00675648f, 0.13471989f, -0.13004664f, -0.02890096f, 0.00514633f, 0.03526932f, 0.13486442f, 
    0.09781122f, -0.20024832f, -0.11905453f, -0.19627872f, -0.17625782f, 0.02149719f, 0.03667559f, -0.02021443f, 
    0.08239079f, -0.09395365f, 0.01659865f, 0.08098150f, -0.25101975f, -0.07784376f, 0.03718929f, 0.07403469f, 
    -0.14595900f, -0.11030001f, 0.02632398f, -0.14144592f, 0.09772287f, 0.00715074f, -0.11648134f, -0.01617721f, 
    -0.07667008f, -0.24862933f, -0.13636601f, -0.09158591f, 0.00242356f, 0.13414575f, -0.01406335f, -0.02095407f, 
    0.10465209f, 0.13144302f, 0.16652326f, 0.19212563f, -0.03686475f, 0.05622780f, -0.07314586f, 0.10772180f, 
    -0.03315555f, 0.03187015f, -0.13840178f, 0.07715421f, 0.00174008f, 0.01533249f, -0.05178154f, 0.18535161f, 
    0.19650216f, -0.23195882f, 0.36869711f, -0.21227233f, 0.08411048f, -0.03068725f, -0.01622641f, -0.02148431f, 
    -0.00508367f, 0.14143392f, -0.05697605f, 0.03449986f, 0.21417394f, -0.05943126f, -0.13824336f, -0.02124422f, 
    0.14676799f, 0.15976234f, 0.08982195f, 0.03079383f, 0.11042468f, -0.09483212f, -0.09643812f, -0.23689604f, 
    0.09140372f, 0.14640699f, 0.18204007f, -0.04305747f, -0.00710014f, -0.10829423f, 0.01296208f, 0.19108616f, 
    0.05517559f, 0.00176172f, 0.10383784f, 0.08180029f, -0.09131788f, -0.02124322f, -0.25981572f, -0.16955039f, 
    -0.11697157f, -0.19143604f, 0.05872874f, -0.22580086f, 0.16059573f, 0.02874893f, -0.02387390f, 0.14032465f, 
    0.06747502f, -0.01302609f, -0.10595613f, -0.02385874f, 0.06769495f, 0.06709844f, 0.04523787f, -0.00229123f, 
    0.03137437f, -0.01016677f, -0.12655175f, 0.08813302f, -0.28196934f, -0.18648386f, -0.14132172f, 0.16499946f, 
    -0.00408412f, 0.02076667f, -0.08499583f, 0.24102069f, -0.07696420f, -0.04628877f, -0.05373478f, -0.01933063f, 
    0.00743506f, 0.09374730f, 0.11105862f, -0.03431381f, 0.30787501f, 0.05844691f, 0.03351349f, 0.06918304f, 
    -0.09481514f, 0.05241449f, 0.20918199f, 0.20164324f, 0.04546950f, 0.00438897f, 0.21585871f, -0.04429099f, 
    -0.02895527f, 0.21378957f, -0.00377758f, -0.02868899f, -0.02107393f, -0.19744314f, -0.02757008f, 0.14874966f, 
    0.02976706f, -0.09116170f, -0.19671510f, 0.06773742f, -0.04789385f, -0.09574991f, 0.01084833f, 0.02185176f, 
    0.08456724f, -0.01017776f, -0.04089544f, -0.09302187f, 0.31507191f, 0.35601759f, 0.17824578f, 0.07909249f, 
    0.26149353f, 0.05281114f, 0.07391633f, 0.06340519f, -0.08664042f, 0.10452050f, 0.05817533f, 0.05634457f, 
    -0.05420485f, -0.00194119f, -0.02772211f, 0.05273598f, -0.06786107f, -0.01334157f, -0.07582527f, -0.04535638f, 
    0.04624317f, 0.00864021f, 0.03385207f, 0.03881276f, 0.01353930f, 0.00306466f, -0.04755764f, 0.04258418f, 
    -0.06468002f, -0.02014753f, 0.01778527f, 0.02833220f, -0.04577734f, 0.00845216f, -0.01003385f, -0.06159171f, 
    0.02702278f, -0.01863925f, -0.03652108f, -0.06462853f, 0.02080932f, -0.03983155f, 0.01301404f, -0.05247561f, 
    -0.07041662f, 0.05419726f, 0.00798082f, -0.02031754f, -0.03366427f, 0.03948994f, -0.00808524f, -0.01581259f, 
    0.01126814f, 0.06171799f, 0.03494719f, -0.03916244f, -0.06303076f, 0.05929947f, -0.06004626f, 0.05188143f, 
    0.05500726f, 0.00519127f, 0.02250551f, 0.05655583f, 0.03278208f, -0.03576668f, -0.06394465f, -0.00866706f, 
    0.05176481f, -0.06780297f, 0.05733036f, -0.03101920f, -0.03720462f, -0.05036089f, -0.02742146f, -0.05463738f, 
    0.05042589f, 0.00861246f, -0.03577938f, -0.06167752f, -0.00913357f, -0.00949192f, -0.03045553f, -0.04098494f, 
    0.05600823f, -0.06836212f, -0.04588050f, -0.04853871f, -0.00260658f, 0.05407654f, 0.03062624f, 0.05931691f, 
    -0.05496819f, -0.01145906f, 0.01966078f, -0.07739522f, -0.01105337f, 0.05869560f, -0.07707770f, 0.04620667f, 
    -0.07348485f, -0.05107515f, 0.04113695f, -0.05133594f, 0.03017203f, -0.04775764f, -0.07312094f, -0.03324973f, 
    -0.03912489f, -0.00561698f, -0.00781515f, 0.00811502f, 0.03976148f, -0.03915086f, 0.02244643f, -0.01482014f, 
    -0.02928459f, 0.03018164f, 0.05809898f, -0.07568863f, -0.05774777f, 0.01136195f, -0.00537031f, -0.01528960f, 
    -0.06679834f, 0.03738072f, -0.01755475f, 0.01558338f, -0.03322032f, -0.06842245f, -0.04912465f, -0.00333380f, 
    -0.08237352f, -0.05808163f, -0.06957845f, -0.02789421f, -0.00113644f, -0.08428010f, -0.00990248f, 0.05553439f, 
    -0.02255749f, -0.04113501f, -0.03043004f, 0.00528443f, -0.01380808f, -0.06106158f, 0.03032642f, 0.02439599f, 
    0.03649216f, 0.00358373f, 0.04315225f, 0.04997768f, -0.06528085f, 0.03121156f, -0.05403831f, 0.04944159f, 
    0.02280489f, 0.04800166f, -0.02454890f, 0.00531301f, 0.06702063f, -0.05357436f, -0.01774574f, 0.00281866f, 
    -0.02902300f, 0.02585363f, -0.05576466f, -0.05846909f, 0.05393303f, 0.00849398f, -0.06094669f, 0.03797484f, 
    -0.04506899f, 0.00951395f, -0.01574476f, 0.02360736f, 0.00104255f, -0.01802620f, -0.07279073f, -0.07892409f, 
    -0.05457864f, -0.07179868f, -0.02033797f, -0.02700755f, -0.02428468f, -0.05682038f, 0.00420624f, 0.03103046f, 
    0.01759058f, -0.04329796f, 0.02197306f, -0.02301474f, 0.02453063f, 0.03743180f, -0.05813006f, -0.04064636f, 
    0.02969100f, 0.03121295f, 0.00598709f, 0.02706838f, 0.03711855f, -0.04770223f, 0.05307915f, -0.03902236f, 
    -0.14892675f, -0.23296668f, 0.10637056f, -0.04267762f, 0.06750432f, -0.01109655f, -0.02531953f, -0.06755324f, 
    0.09325137f, -0.08881051f, -0.06821474f, -0.11228058f, -0.03495295f, 0.29249150f, 0.18806875f, 0.12122706f, 
    0.00162969f, -0.04946663f, -0.13190192f, -0.03447407f, -0.05386804f, 0.17577775f, 0.04419232f, 0.08655031f, 
    0.09613330f, -0.16802377f, -0.10043328f, -0.22465307f, -0.16590719f, 0.01646291f, 0.11324859f, 0.13008717f, 
    -0.01954805f, -0.05887525f, 0.08643249f, 0.11559960f, 0.11644847f, 0.44332612f, -0.14600608f, 0.08986972f, 
    -0.11924897f, -0.08661155f, 0.16616127f, 0.03488861f, 0.03665882f, 0.05962465f, 0.11086625f, 0.07956334f, 
    -0.14247996f, -0.05214662f, -0.12466285f, -0.09628364f, -0.09680474f, -0.00241705f, -0.04766586f, -0.13651176f, 
    -0.07103754f, -0.01232896f, 0.12161059f, -0.02635267f, -0.14857763f, -0.03945388f, -0.11637087f, 0.04751677f, 
    -0.11705627f, 0.12577581f, 0.05218479f, 0.09607361f, -0.01929682f, -0.00141416f, -0.04873668f, 0.09030236f, 
    -0.00603979f, -0.42864454f, 0.14622645f, -0.10616234f, 0.22480862f, -0.06543674f, 0.04212621f, -0.23765098f, 
    -0.01018800f, -0.03444614f, 0.14076950f, -0.10845096f, -0.04286804f, -0.16446272f, -0.10573742f, -0.14327961f, 
    0.18073379f, 0.11077206f, 0.12792487f, 0.08202842f, -0.02119201f, 0.03931469f, 0.05004788f, 0.12266719f, 
    -0.23677056f, -0.09943075f, -0.13981719f, -0.25024405f, 0.05820286f, -0.08174983f, 0.04855406f, 0.05151433f, 
    -0.02247029f, 0.02612363f, 0.08585913f, 0.10365472f, 0.08338576f, -0.04214799f, -0.19339888f, 0.01917499f, 
    0.04557109f, 0.01732587f, 0.14302886f, -0.06321255f, 0.02883562f, 0.07888980f, -0.05003833f, 0.07905108f, 
    0.07328392f, 0.19401148f, 0.11529882f, -0.15484956f, 0.00223096f, 0.00892669f, 0.05870805f, 0.20453326f, 
    0.10773287f, -0.00106954f, 0.22671688f, 0.00315850f, -0.28504425f, -0.16527575f, -0.29762512f, -0.02752044f, 
    0.29393384f, -0.03150252f, 0.15370017f, -0.05549122f, 0.04436332f, -0.13220078f, -0.04134961f, 0.04425357f, 
    -0.17291306f, -0.13068902f, 0.18374467f, -0.21643852f, -0.11788446f, 0.04161712f, 0.08379965f, 0.22481883f, 
    0.12618548f, 0.01892850f, -0.05544967f, 0.12992562f, 0.05828052f, -0.45293877f, 0.17743877f, -0.02053958f, 
    -0.14146045f, -0.03364452f, 0.12031490f, 0.14741936f, 0.08099215f, 0.03307645f, 0.02389257f, 0.14976475f, 
    -0.09385899f, 0.06268495f, -0.08219323f, 0.01741368f, -0.12978981f, -0.08408687f, -0.04461713f, -0.00716424f, 
    -0.01217633f, 0.08481017f, 0.13576090f, 0.10878578f, -0.19636682f, 0.02182901f, -0.14663674f, -0.16903520f, 
    0.16916929f, 0.07169057f, 0.19914781f, 0.09248157f, -0.01863805f, -0.01597974f, -0.00943725f, 0.03927751f, 
    -0.23897049f, -0.11507717f, -0.10236078f, 0.02065096f, -0.24225588f, -0.23936778f, 0.05282372f, -0.08949730f, 
    0.04817791f, -0.03639726f, 0.09193832f, 0.02155570f, -0.36693397f, 0.05253422f, 0.07016388f, -0.14024466f, 
    -0.18104360f, -0.21291474f, -0.03438266f, 0.01480448f, 0.08993638f, -0.08205792f, -0.10342237f, 0.04740898f, 
    0.17513989f, 0.11909429f, -0.03027861f, 0.15565893f, 0.09352124f, 0.04113008f, 0.03884563f, 0.14971557f, 
    -0.05587620f, -0.06799659f, 0.01402257f, 0.01318223f, 0.32234555f, 0.27002695f, 0.00335129f, -0.06626789f, 
    0.16294037f, -0.01817200f, 0.08842161f, 0.13372792f, 0.01089529f, 0.01394119f, 0.06628900f, 0.06949832f, 
    -0.23777923f, -0.09700611f, -0.18874666f, 0.00289639f, -0.01648332f, 0.00300139f, -0.18626410f, 0.03098630f, 
    0.06248644f, -0.27708083f, 0.09377564f, 0.05591678f, -0.23306817f, 0.14747360f, 0.02973074f, -0.04154445f, 
    0.06351523f, -0.05072377f, 0.03485209f, -0.03748522f, -0.06722663f, -0.05945440f, -0.01685023f, -0.10147408f, 
    0.14336161f, -0.20571125f, 0.16450493f, -0.32497072f, -0.05783385f, 0.09160630f, 0.00337429f, 0.11950047f, 
    0.09987585f, -0.03211215f, 0.01542649f, -0.05155233f, 0.05110798f, -0.08471743f, 0.02938294f, -0.08392046f, 
    0.10208903f, 0.12738743f, -0.02388141f, 0.09613024f, 0.24341929f, 0.00716239f, 0.07452986f, 0.16829969f, 
    -0.16338433f, 0.00938895f, 0.31513885f, -0.13036831f, -0.01764122f, 0.05240007f, -0.04544120f, -0.03615330f, 
    0.05363096f, -0.06645171f, -0.02931583f, -0.00069511f, -0.05303833f, -0.17139892f, -0.20484677f, -0.01436441f, 
    0.13533263f, 0.13424024f, 0.30944243f, 0.12737098f, 0.01427424f, 0.12393948f, 0.08302713f, 0.15929508f, 
    0.12760778f, 0.01564026f, 0.15892217f, -0.04027117f, -0.10490998f, 0.01277495f, -0.17857046f, 0.21754661f, 
    0.06015523f, -0.01056297f, 0.02849688f, 0.06595801f, 0.04219761f, -0.13953571f, -0.15840846f, -0.00532040f, 
    0.18991463f, 0.17982727f, -0.10537936f, 0.20372881f, 0.21325186f, 0.06226386f, -0.00194598f, 0.06997548f, 
    0.01301756f, 0.22288728f, 0.04493286f, -0.18885955f, -0.10486223f, -0.05487425f, 0.02607898f, 0.02150830f, 
    -0.05901911f, -0.12040447f, 0.10275678f, -0.11363620f, -0.12865157f, -0.01529875f, 0.06930462f, 0.22431663f, 
    -0.04813506f, 0.01214700f, 0.05951487f, -0.06916388f, 0.09839711f, -0.13322701f, 0.13398668f, -0.08318079f, 
    -0.26135474f, 0.05296753f, -0.04174823f, -0.03963958f, -0.12818676f, -0.14257111f, -0.10677098f, -0.11354692f, 
    0.04145585f, 0.19582412f, 0.07159842f, -0.04589644f, 0.02080086f, 0.16052082f, 0.07724874f, 0.00536168f, 
    0.01928970f, 0.00219310f, -0.01836193f, -0.10130605f, -0.00346431f, -0.14708243f, -0.11252026f, 0.01570676f, 
    -0.04946718f, -0.32698426f, -0.03944974f, 0.10306493f, 0.08826791f, -0.08582120f, -0.14812003f, -0.01268953f, 
    -0.00144115f, -0.02179952f, 0.09278970f, 0.01286571f, 0.32980102f, 0.32087213f, 0.17045970f, 0.20803335f, 
    0.00611376f, -0.15241273f, -0.05450938f, -0.04032626f, 0.05131533f, -0.10379797f, 0.00144595f, 0.19086677f, 
    0.05690803f, -0.03865868f, 0.15682727f, -0.37279549f, 0.06648106f, 0.10606371f, -0.08652477f, 0.13024943f, 
    0.09600741f, -0.07372337f, 0.05900580f, -0.06077249f, -0.24127746f, 0.23844191f, -0.18200786f, -0.04441123f, 
    -0.14373966f, -0.11053662f, 0.04001636f, -0.02823662f, 0.07468965f, -0.01989348f, 0.02723991f, 0.11303633f, 
    0.19380599f, -0.01155546f, -0.03915517f, -0.17831209f, -0.14081365f, -0.09206808f, -0.02324502f, 0.00791614f, 
    0.12485178f, 0.02815900f, 0.02302470f, 0.21298684f, -0.25646982f, 0.02631794f, -0.17812286f, 0.11511885f, 
    -0.06816489f, 0.11352006f, -0.11063063f, 0.06539116f, -0.05978040f, -0.06030438f, -0.03121905f, 0.12278867f, 
    -0.15445296f, -0.13910179f, 0.23387919f, -0.17439537f, 0.14949107f, 0.07463740f, 0.10355487f, -0.08023613f, 
    0.03450935f, -0.07404587f, 0.12269480f, 0.08207193f, 0.05985655f, 0.16215873f, 0.14385085f, -0.04670987f, 
    0.09286853f, 0.06653041f, 0.25361231f, 0.08075406f, 0.00988775f, 0.02338723f, 0.06418068f, -0.00085304f, 
    -0.27998006f, -0.22599390f, 0.12135181f, 0.14529884f, -0.04863760f, 0.01014991f, -0.05873951f, 0.05589269f, 
    -0.12437843f, 0.03536900f, 0.03394260f, 0.04020344f, 0.23316778f, 0.10622138f, -0.22990152f, -0.12473875f, 
    -0.07115333f, -0.00583374f, -0.15538238f, -0.00119712f, 0.03259952f, -0.00158457f, 0.17337491f, 0.14792687f, 
    0.38516286f, 0.26554516f, 0.24875182f, -0.04362632f, 0.04609862f, -0.05856506f, 0.14002408f, -0.01662675f, 
    0.07830871f, 0.10558115f, 0.02230072f, -0.03441248f, 0.03395156f, -0.13661909f, -0.27611512f, -0.16055098f, 
    -0.02146976f, -0.04703987f, 0.25435942f, -0.03702312f, -0.04855927f, -0.05941636f, -0.07764431f, -0.01190075f, 
    0.08760512f, -0.03418534f, 0.23088664f, -0.17985335f, 0.07191721f, 0.09604882f, -0.02107601f, 0.02427536f, 
    0.02636375f, 0.05960481f, 0.04671786f, 0.15651445f, -0.00557953f, 0.00661695f, -0.05787523f, -0.03356327f, 
    -0.19683489f, 0.01042668f, -0.10028303f, 0.11765699f, -0.12858932f, 0.06651372f, 0.02847626f, -0.01517691f, 
    0.15950860f, -0.00883828f, 0.02356552f, 0.01227334f, 0.09842291f, 0.04197456f, 0.09018228f, -0.03226160f, 
    0.06426558f, -0.08387283f, 0.04632314f, -0.11878866f, -0.20036140f, 0.10174470f, 0.04765452f, 0.07798985f, 
    0.06680164f, 0.01292446f, 0.08716675f, 0.07211795f, -0.00526057f, -0.03474739f, 0.05309933f, 0.06456930f, 
    -0.00109546f, -0.01869405f, -0.06433543f, -0.05582541f, 0.06263682f, -0.02231676f, -0.00852169f, -0.07198420f, 
    0.01711114f, -0.02435884f, -0.03699955f, 0.01063714f, 0.03236184f, 0.02322157f, 0.00338783f, 0.05437504f, 
    -0.01642576f, -0.02399961f, -0.03297357f, -0.05477981f, -0.06677487f, 0.06209844f, 0.03172912f, -0.02859874f, 
    -0.00270271f, -0.05633269f, -0.01958206f, -0.00057151f, -0.00671221f, 0.00302473f, -0.05551348f, 0.04751439f, 
    -0.00400670f, 0.02440757f, 0.00593697f, -0.06890960f, -0.06687944f, 0.01796780f, 0.03146732f, -0.00131923f, 
    0.03927322f, -0.02001022f, -0.06612682f, 0.02887314f, 0.02596391f, 0.03490529f, 0.06030661f, 0.02857787f, 
    -0.03884265f, -0.05702879f, -0.01327468f, 0.01788115f, -0.06127983f, -0.03504657f, -0.01421450f, -0.03929969f, 
    0.04770864f, -0.03041047f, 0.02882969f, -0.03228663f, -0.03309925f, -0.04908358f, 0.05277134f, -0.04769959f, 
    0.05637059f, -0.05996677f, -0.05389575f, -0.00929384f, -0.01781626f, -0.04043085f, 0.03581463f, -0.07291049f, 
    -0.03577047f, -0.04815632f, 0.03838500f, 0.02403897f, -0.02427678f, 0.04214288f, -0.05513972f, 0.05417517f, 
    -0.01763045f, -0.07409441f, 0.04554608f, 0.00348036f, 0.01524857f, -0.02686614f, -0.01732689f, -0.04269119f, 
    -0.04447729f, 0.00147314f, 0.04405347f, -0.03615400f, 0.03648335f, 0.00036505f, 0.00982184f, -0.04040084f, 
    0.01001960f, 0.06918367f, -0.02696897f, -0.04919465f, 0.01609150f, -0.07008588f, -0.00077178f, -0.00250433f, 
    0.03961958f, 0.06076095f, 0.04228246f, -0.07089111f, 0.03662669f, -0.00709727f, -0.06651311f, -0.01743710f, 
    -0.00208290f, -0.00529539f, 0.02688557f, 0.01066438f, -0.02218011f, -0.04366025f, 0.05906896f, -0.00332581f, 
    -0.00984334f, -0.05173355f, -0.04907380f, -0.07756668f, 0.00707849f, 0.04485671f, -0.03065692f, 0.04338154f, 
    -0.06070689f, 0.01743353f, -0.02455916f, -0.00562668f, 0.00383505f, 0.04674017f, 0.01462532f, -0.03605863f, 
    -0.06974876f, 0.02361481f, -0.07751993f, -0.05678160f, -0.04283572f, -0.02666452f, -0.05595425f, 0.01318647f, 
    -0.07330004f, -0.04234773f, -0.05180303f, 0.03484292f, -0.06717771f, -0.06802655f, -0.01692376f, -0.05990828f, 
    -0.07765072f, 0.03351958f, 0.05897770f, -0.03304971f, 0.03773877f, -0.02141348f, 0.05234099f, 0.00581201f, 
    0.02348088f, -0.02426526f, -0.00439380f, 0.02433339f, -0.06466080f, -0.05635944f, 0.04322976f, -0.01052873f, 
    0.01848637f, -0.06502760f, 0.03560367f, -0.03322415f, -0.04571617f, -0.00854487f, -0.01894348f, 0.03279369f, 
    -0.05314393f, -0.06574677f, -0.05217965f, 0.04190219f, 0.00611919f, 0.03541902f, -0.03015256f, 0.04828922f, 
    -0.00694086f, 0.01210201f, 0.03392126f, 0.01739860f, 0.05167882f, 0.02810371f, -0.01685485f, 0.06489577f, 
    0.17228866f, 0.08495123f, -0.08101144f, 0.01396975f, 0.05558382f, 0.04687351f, 0.08829609f, 0.06191329f, 
    0.13458805f, -0.00667245f, 0.01818812f, 0.01424306f, 0.45273772f, 0.33064276f, 0.45746368f, 0.06343542f, 
    -0.01075694f, -0.17981918f, -0.11017019f, -0.11821704f, -0.07479147f, -0.06022310f, 0.16069373f, 0.23967813f, 
    -0.25131729f, 0.18527573f, 0.08431616f, 0.17603567f, -0.06835558f, -0.05165109f, -0.07779465f, 0.08332362f, 
    0.00592171f, 0.01713695f, 0.00313451f, -0.00628198f, 0.00605005f, 0.38073677f, -0.24964696f, -0.17782150f, 
    -0.00600768f, -0.17133890f, 0.19637670f, -0.04463198f, 0.06354992f, 0.04008081f, 0.14136171f, -0.06614737f, 
    0.12137076f, 0.10765090f, 0.05051122f, -0.08360957f, -0.01651638f, -0.07814151f, -0.01047904f, 0.00606500f, 
    0.12965323f, 0.10240643f, 0.12578195f, 0.09371822f, -0.08059972f, -0.05490832f, -0.21136703f, -0.01582364f, 
    0.08605579f, -0.10091478f, 0.06793612f, -0.07940671f, 0.05557100f, -0.06298618f, 0.03843090f, 0.12595007f, 
    -0.19804291f, -0.24217832f, 0.07026368f, 0.11503445f, 0.05529074f, 0.12003960f, -0.15844636f, 0.39258599f, 
    0.16714883f, 0.05245734f, 0.01646467f, -0.07031688f, -0.19909972f, -0.06757444f, -0.03786819f, -0.12497820f, 
    -0.11029774f, -0.02923805f, 0.07348566f, 0.23842333f, 0.05175473f, 0.01090771f, -0.05742192f, -0.07650869f, 
    -0.25080004f, -0.23087983f, -0.14011107f, 0.12772496f, -0.01693641f, 0.02781872f, -0.23437653f, 0.03082400f, 
    -0.06623083f, -0.13293450f, 0.04169103f, 0.05383161f, 0.08647217f, 0.10284676f, 0.05773047f, -0.12638868f, 
    0.01187021f, 0.10441341f, -0.12068707f, 0.16550322f, 0.11300982f, 0.04987333f, 0.12431651f, 0.05800255f, 
    -0.06053951f, 0.10390995f, 0.20833981f, 0.08654969f, -0.08036219f, -0.12926483f, -0.02788153f, -0.04473030f, 
    -0.03089338f, 0.14956398f, 0.10681742f, 0.02822475f, -0.14112090f, -0.04996807f, 0.16322449f, -0.04933861f, 
    -0.12540145f, 0.30432123f, 0.07392130f, 0.22695714f, 0.02649232f, -0.02509037f, 0.10269186f, -0.04723465f, 
    -0.03185682f, 0.00496933f, 0.19179699f, -0.01609435f, 0.03032933f, -0.08827750f, 0.02094681f, -0.02116050f, 
    -0.08743889f, 0.09353515f, -0.05080922f, 0.02492442f, 0.16932358f, 0.18692134f, -0.13467568f, 0.09472118f, 
    0.01209510f, 0.04105728f, -0.22540522f, 0.00987375f, -0.23323041f, 0.20460813f, 0.12712301f, -0.12845948f, 
    0.10368703f, 0.02233004f, -0.02775768f, 0.00278649f, 0.04657485f, 0.08217846f, 0.06376231f, 0.06264881f, 
    -0.04696531f, -0.03158760f, -0.14634019f, -0.15515320f, -0.23822384f, -0.09045725f, -0.11216114f, 0.12409315f, 
    0.02175064f, -0.11085057f, 0.10341474f, 0.05271643f, -0.05268342f, -0.07362185f, 0.11549260f, -0.06898339f, 
    -0.00417198f, 0.23013663f, 0.15319090f, 0.01885907f, -0.05786243f, 0.07387882f, 0.00546608f, -0.01096429f, 
    0.00690464f, -0.04853557f, -0.06731437f, 0.04692980f, -0.42193624f, -0.24162011f, -0.28601900f, -0.00817438f, 
    -0.05715562f, 0.16045120f, -0.03830034f, 0.09516106f, -0.03294993f, 0.20187351f, -0.10240576f, -0.03531605f, 
    0.22524427f, -0.10854294f, 0.02768218f, 0.08571583f, 0.03654839f, 0.08984448f, 0.04376568f, -0.08050915f, 
    -0.02673995f, -0.14645152f, -0.05937071f, -0.03449174f, 0.19584236f, -0.23934196f, 0.26711324f, 0.11319958f, 
    0.11672433f, 0.21027415f, -0.16517194f, 0.08751595f, 0.03127543f, 0.00524128f, 0.14266762f, 0.08152165f, 
    -0.14010608f, -0.05848930f, -0.02425252f, 0.00596459f, -0.07849991f, -0.01262652f, -0.06220165f, 0.01541488f, 
    0.06650530f, 0.09766921f, 0.00066966f, 0.08589474f, 0.12487780f, 0.03337849f, 0.12743139f, -0.09007043f, 
    0.04883461f, -0.02956950f, -0.02140807f, 0.02682835f, 0.05546762f, 0.11118706f, 0.08234154f, -0.07098962f, 
    0.21446976f, 0.17432384f, -0.31463158f, 0.09136444f, -0.01694654f, -0.16210173f, 0.30149332f, -0.20604779f, 
    -0.10572354f, 0.05971268f, 0.02213355f, 0.09225448f, 0.09782147f, 0.01885172f, -0.14134835f, 0.05242988f, 
    0.08085656f, 0.06916378f, 0.02877779f, -0.07235043f, -0.02666287f, 0.01349648f, -0.11098240f, -0.03657060f, 
    0.28279710f, 0.23445767f, -0.04325710f, -0.15153544f, 0.05192120f, 0.05207564f, 0.19171119f, -0.03696592f, 
    -0.02672515f, 0.10107000f, -0.08752871f, -0.02193084f, -0.21015607f, -0.10064735f, -0.02051244f, 0.10648115f, 
    0.08894298f, 0.08738791f, 0.10714581f, 0.04286664f, 0.11217195f, 0.03352108f, -0.01011719f, -0.05833824f, 
    -0.02466916f, -0.17654674f, -0.04045957f, 0.01551326f, 0.07870527f, 0.17880629f, 0.05331450f, -0.01640910f, 
    0.01791269f, -0.01688932f, -0.07621042f, 0.10126058f, 0.11555146f, 0.11943420f, 0.08176200f, 0.05497770f, 
    0.08685996f, -0.12038608f, -0.04622872f, -0.12128470f, -0.01423030f, -0.04435701f, -0.04061256f, 0.10787540f, 
    -0.06011587f, 0.09163691f, -0.23503153f, 0.08132007f, -0.05724594f, 0.11487448f, 0.00412028f, -0.03255098f, 
    0.06660577f, -0.07969569f, 0.00643187f, 0.07967716f, -0.04058786f, -0.06103371f, 0.21099526f, -0.13243465f, 
    0.25467888f, -0.05019050f, 0.19736223f, -0.10085397f, 0.20884854f, -0.04074734f, -0.01538575f, 0.10828641f, 
    -0.06221379f, -0.09905431f, -0.03903246f, 0.14083394f, -0.05649816f, -0.09946145f, 0.00383599f, -0.02441744f, 
    -0.05468152f, 0.06207962f, 0.10619891f, 0.22579633f, 0.12810908f, 0.00491690f, -0.08869473f, -0.14873424f, 
    -0.02280807f, 0.01390073f, -0.00395836f, 0.05166551f, 0.03513186f, 0.08563416f, -0.01549245f, 0.08832137f, 
    -0.14226499f, -0.12560810f, -0.01818524f, 0.08000848f, -0.13430519f, -0.11986047f, 0.06181782f, -0.05805686f, 
    0.06547405f, -0.01159439f, -0.12090950f, -0.10563089f, -0.37309447f, 0.12924281f, 0.02071188f, -0.17688607f, 
    -0.19811265f, -0.19969749f, 0.02014507f, 0.00854017f, 0.08747467f, -0.05007418f, 0.03884007f, -0.03373493f, 
    0.03066067f, 0.15148859f, 0.00935336f, -0.00434932f, 0.17173102f, 0.00080904f, 0.09146931f, 0.03865415f, 
    -0.05947444f, 0.03265712f, 0.06702664f, -0.07977325f, 0.50715512f, 0.43459037f, -0.18531370f, 0.21487050f, 
    -0.05145182f, -0.03281538f, 0.12785499f, 0.25145006f, 0.12588660f, 0.01512440f, 0.09975642f, 0.12469462f, 
    -0.24529198f, 0.00012397f, -0.15235853f, 0.06271831f, -0.01798258f, 0.00113966f, -0.00782902f, -0.19390661f, 
    0.00937232f, -0.31385893f, -0.02768205f, -0.07095005f, -0.12766753f, 0.06500649f, 0.12364633f, -0.05482620f, 
    0.01295876f, -0.09823798f, 0.02279682f, -0.07951988f, -0.04515262f, -0.03606140f, -0.02713260f, -0.22147556f, 
    -0.04121302f, 0.08280095f, 0.05240626f, 0.01469588f, 0.17211476f, 0.15677015f, 0.01835845f, -0.10184608f, 
    0.00731021f, -0.01374577f, -0.07400966f, -0.07077147f, -0.10952286f, -0.04290556f, 0.03298369f, -0.05551172f, 
    0.14341730f, 0.15100308f, 0.01091504f, -0.10594741f, 0.00382832f, -0.01990667f, 0.17637010f, 0.16574340f, 
    -0.24536519f, 0.01400919f, 0.11562449f, -0.05615915f, 0.02126604f, 0.09779650f, 0.16175646f, -0.09168760f, 
    -0.03157656f, -0.01487610f, -0.00148502f, -0.02513321f, 0.02790968f, -0.42452598f, -0.35787183f, 0.13676171f, 
    0.08955118f, 0.10571669f, 0.18042664f, 0.20023894f, -0.01090049f, 0.26245603f, 0.10632486f, -0.09354952f, 
    0.21582067f, 0.25115559f, 0.11972935f, -0.15847427f, 0.06778151f, 0.03744642f, -0.07373997f, 0.20780167f, 
    0.14666897f, 0.04260752f, 0.15059152f, -0.03417577f, 0.00780622f, -0.11183540f, -0.11074433f, -0.01024396f, 
    0.10935889f, 0.06968747f, 0.09615249f, -0.15368736f, 0.17201643f, 0.02492378f, -0.04139045f, 0.23946549f, 
    -0.11260752f, 0.06884213f, 0.11220077f, -0.02733816f, -0.11671375f, -0.04763568f, 0.06079262f, 0.12178111f, 
    -0.04616661f, -0.21021329f, 0.04312273f, -0.13031393f, -0.19780843f, -0.14086460f, 0.14386077f, 0.15657768f, 
    -0.05126268f, -0.00988183f, 0.04059308f, 0.05217107f, 0.01579436f, 0.05047131f, 0.04130189f, -0.02834031f, 
    -0.10369151f, 0.19080862f, 0.20319210f, -0.01517486f, -0.03290489f, -0.14395426f, -0.07580601f, -0.10572338f, 
    0.09455756f, 0.12288577f, 0.23276515f, 0.12620027f, 0.00888430f, -0.10517462f, 0.03813388f, -0.05182987f, 
    0.08261096f, 0.11122166f, -0.06375883f, -0.13748872f, -0.03141150f, -0.10176080f, -0.11531603f, 0.09082013f, 
    0.09935892f, 0.16197667f, -0.07831248f, -0.27060476f, -0.06746698f, 0.00186303f, 0.07215473f, -0.09789068f, 
    -0.05871344f, 0.13970354f, -0.08636343f, 0.11773949f, 0.23234485f, 0.18648207f, 0.11686874f, 0.06734453f, 
    -0.10949256f, 0.00595974f, -0.01428355f, 0.16116035f, 0.06866431f, 0.05129936f, -0.00740506f, -0.11049560f, 
    -0.01685975f, 0.04774128f, -0.01396592f, 0.10514543f, 0.04404312f, 0.02657117f, -0.01415605f, -0.02135532f, 
    0.00643525f, -0.09654122f, -0.13257810f, 0.02799297f, -0.26599517f, 0.03395965f, -0.19582027f, -0.13035326f, 
    0.17213759f, 0.14227542f, 0.03953319f, -0.05167037f, -0.00683860f, 0.02423695f, 0.23753579f, 0.05754535f, 
    0.02325720f, 0.06504378f, -0.01429124f, -0.13478585f, -0.07520063f, -0.02135883f, -0.09464803f, 0.00332715f, 
    0.01575553f, 0.11126702f, -0.03569162f, 0.04126489f, -0.08437449f, -0.16966945f, -0.05742529f, -0.04151716f, 
    0.00424508f, -0.08993355f, 0.03949114f, 0.01536387f, -0.03044467f, -0.01489083f, 0.05487811f, 0.09735619f, 
    0.13688515f, 0.04226085f, 0.26938227f, 0.12155589f, 0.02212301f, 0.20230296f, -0.07268566f, 0.13159023f, 
    0.01933849f, -0.15894496f, -0.00741748f, 0.06297565f, -0.09484523f, 0.05539915f, 0.22025505f, 0.13979132f, 
    -0.10525757f, -0.11993013f, 0.02340047f, 0.14687669f, 0.03328358f, -0.06102329f, -0.03570965f, 0.02911928f, 
    -0.09936234f, -0.24309754f, -0.04036803f, 0.16555724f, -0.05476520f, 0.02945926f, -0.16878155f, -0.06877371f, 
    0.07031655f, 0.06547695f, 0.10639588f, -0.01330908f, -0.01635624f, 0.19986036f, -0.01414152f, -0.12305386f, 
    -0.04288214f, 0.14399612f, -0.12078911f, 0.07901572f, -0.12800877f, -0.15582222f, -0.03248366f, 0.10185323f, 
    0.00988629f, 0.04107286f, 0.15665548f, 0.05322812f, -0.00213711f, 0.10754444f, 0.07257422f, 0.01296958f, 
    0.06848000f, -0.05018302f, 0.10560186f, 0.12282782f, -0.09586477f, 0.17245808f, 0.03182189f, 0.05975894f, 
    0.06468143f, -0.04367344f, -0.10177140f, 0.12573983f, 0.05397313f, -0.03531007f, 0.09319814f, -0.17815511f, 
    0.02319240f, -0.12565456f, 0.03241527f, 0.11915331f, -0.00459838f, -0.05105134f, -0.03019391f, -0.02121861f, 
    0.03613746f, 0.00311895f, 0.03176977f, -0.11275564f, 0.13157471f, -0.01102830f, -0.27831715f, 0.05768544f, 
    -0.01034568f, 0.01890886f, 0.06835908f, 0.01314467f, 0.05298528f, 0.05904819f, 0.03366585f, -0.01189980f, 
    -0.01294496f, 0.13688523f, 0.19003995f, -0.02655659f, -0.01904117f, -0.02457018f, -0.09192805f, -0.03589156f, 
    -0.13186975f, -0.06622510f, -0.11124305f, 0.07113115f, -0.12480166f, -0.04839542f, 0.08533087f, 0.15873040f, 
    -0.13044193f, 0.06745167f, 0.12563217f, 0.08483437f, 0.07550300f, 0.08013913f, 0.08218496f, -0.08328890f, 
    0.05617489f, 0.09763851f, 0.22176218f, -0.06113795f, -0.03240645f, -0.04549852f, -0.07548582f, 0.08956725f, 
    0.06228763f, -0.15814039f, 0.10391590f, -0.03128402f, 0.03351164f, -0.38007659f, -0.18669437f, -0.02319765f, 
    -0.02854062f, -0.00184745f, 0.09560286f, 0.12245776f, 0.18661574f, 0.02980730f, 0.01630920f, -0.04306461f, 
    0.06951919f, 0.10640758f, -0.13270262f, -0.06219248f, 0.01106069f, 0.14641808f, 0.12637548f, -0.08309127f, 
    -0.05288142f, -0.04429526f, -0.01969850f, -0.01595082f, 0.28354558f, -0.06487987f, 0.18834610f, -0.02132814f, 
    -0.09331690f, -0.06324916f, -0.01999981f, -0.02171095f, -0.07343439f, -0.10573518f, -0.03396446f, -0.06862979f, 
    -0.03021763f, -0.23697630f, 0.14106523f, 0.07638688f, -0.01040288f, 0.04828811f, -0.06097514f, -0.06070503f, 
    0.09679786f, 0.00841235f, 0.20377804f, 0.07211721f, 0.20629540f, 0.08213680f, 0.21928759f, -0.02805305f, 
    0.05749486f, 0.18736120f, -0.03389031f, 0.13186702f, 0.08378588f, 0.03036799f, -0.02177267f, 0.11568868f, 
    -0.01554991f, -0.13203511f, 0.07743021f, 0.07412113f, -0.03766783f, -0.03077438f, 0.27425331f, 0.06929830f, 
    0.09251420f, 0.20054054f, -0.00371095f, -0.01797619f, 0.00164245f, -0.03448363f, -0.28611320f, -0.06075506f, 
    0.15781137f, 0.05123292f, 0.02685047f, 0.08985947f, -0.13399531f, -0.22592607f, -0.27235785f, -0.15523218f, 
    0.35065094f, 0.21034487f, -0.10139786f, -0.03566785f, 0.23603281f, 0.10617319f, 0.18703276f, 0.08381300f, 
    -0.13264723f, -0.10453312f, -0.08954445f, 0.05856294f, -0.23825143f, -0.58912122f, 0.20409068f, -0.03430077f, 
    0.05360722f, -0.07041132f, 0.15042676f, -0.04413044f, 0.14365281f, 0.10423619f, -0.16380244f, -0.07400293f, 
    -0.14194512f, -0.04702159f, -0.27133721f, -0.05346071f, 0.04503927f, -0.03615314f, -0.04564818f, 0.09787764f, 
    -0.04253004f, -0.00067046f, -0.06901787f, -0.01683269f, -0.16617890f, -0.09315792f, -0.15419880f, 0.08332584f, 
    0.11616598f, -0.00257469f, 0.03401068f, 0.01604976f, -0.13747112f, 0.06789372f, -0.23778008f, -0.15802242f, 
    -0.06667456f, 0.03382203f, -0.16111667f, 0.17083159f, 0.07103969f, 0.19763251f, 0.14541242f, 0.10721612f, 
    -0.04676993f, -0.00830014f, 0.01534068f, 0.06849086f, 0.26411703f, -0.07718643f, 0.27554479f, -0.09597580f, 
    0.10834133f, 0.08915840f, 0.02621501f, 0.09973718f, 0.26022580f, 0.11948713f, -0.14838114f, 0.02032639f, 
    0.18908440f, 0.08896162f, -0.02668889f, -0.13140570f, -0.09392869f, -0.09012626f, -0.03901712f, -0.12827273f, 
    -0.10243443f, -0.02232433f, -0.03418056f, -0.04913179f, 0.14478140f, 0.03777120f, -0.00430590f, -0.00113752f, 
    0.03247040f, -0.04952366f, -0.01618836f, 0.15628459f, -0.05651114f, -0.04684702f, -0.05104755f, 0.07735141f, 
    -0.38153920f, -0.28963155f, -0.29765075f, -0.29996136f, 0.08447609f, -0.05532090f, 0.03141719f, -0.01969056f, 
    0.00805757f, 0.08516318f, 0.05009231f, -0.01566994f, 0.24234834f, 0.03336405f, -0.13973963f, 0.02918372f, 
    0.07515607f, 0.16584998f, 0.11171206f, 0.18805774f, 0.02350553f, -0.11221486f, -0.06298020f, -0.08772179f, 
    0.43172690f, 0.31871042f, 0.01207771f, -0.01723930f, -0.00884468f, -0.00274126f, 0.10450289f, -0.14149888f, 
    -0.06156740f, 0.10830685f, 0.05185571f, -0.07470526f, -0.32643342f, -0.28187367f, -0.03369702f, -0.08727612f, 
    -0.00803568f, 0.09809404f, -0.12076561f, 0.00701972f, -0.14235859f, -0.10442699f, -0.14927460f, -0.09631664f, 
    -0.11462674f, -0.21340622f, -0.14106244f, -0.03152876f, 0.08009007f, 0.01778210f, 0.01528066f, 0.12982510f, 
    -0.19529730f, -0.06259134f, -0.09891705f, -0.16631350f, 0.06085457f, 0.21509849f, 0.15211892f, 0.13348809f, 
    -0.11690474f, 0.25471088f, -0.02953236f, 0.15692054f, -0.14736682f, -0.06574347f, -0.08410680f, -0.02706514f, 
    0.16694553f, -0.01826077f, 0.17338833f, -0.13629425f, -0.05604953f, 0.05074896f, 0.07758958f, 0.11282726f, 
    -0.08573856f, 0.04169317f, -0.08017808f, 0.08522449f, 0.33128414f, 0.19564371f, 0.23158859f, 0.19493787f, 
    0.07977366f, 0.00283588f, 0.06540314f, -0.03737664f, 0.03105568f, -0.04835830f, 0.06001559f, 0.04724093f, 
    0.27898863f, 0.19494043f, 0.20680554f, 0.15361424f, 0.02635252f, 0.19466242f, 0.07200405f, 0.14427739f, 
    -0.00935501f, 0.02204770f, -0.12024695f, -0.11249949f, -0.12611623f, -0.13425769f, 0.13330482f, 0.03950647f, 
    -0.04070163f, 0.03893622f, -0.03145570f, -0.23385765f, -0.15433204f, 0.13851215f, 0.03071175f, 0.06086655f, 
    0.28843120f, -0.03810437f, 0.00305535f, 0.14187816f, 0.04823301f, 0.17271805f, -0.05511248f, -0.17990217f, 
    -0.01927213f, -0.12038574f, -0.02843470f, -0.03828187f, 0.12164013f, -0.09823522f, -0.13504854f, -0.01981543f, 
    -0.14858896f, -0.04274346f, -0.05392813f, -0.15415204f, 0.09802182f, 0.06364356f, 0.10838413f, 0.00962613f, 
    0.21928295f, 0.10573210f, -0.13018820f, 0.14815037f, 0.16383117f, 0.00283555f, -0.02260124f, -0.01997583f, 
    -0.18225226f, -0.13640167f, 0.10784838f, -0.05815891f, 0.21599646f, 0.33851382f, 0.05249738f, -0.02497032f, 
    -0.09910301f, 0.08350915f, 0.18219616f, -0.12759258f, 0.00437914f, -0.05247753f, -0.02553693f, -0.06952232f, 
    -0.08004518f, -0.14069860f, -0.09664257f, -0.16161995f, 0.05746519f, -0.05629243f, 0.05147338f, 0.06580708f, 
    0.07514722f, 0.06392924f, -0.05665645f, -0.00946151f, 0.26926076f, 0.28114629f, 0.20262383f, 0.17533542f, 
    -0.07642961f, -0.09378640f, -0.14648138f, 0.04683200f, -0.08315217f, -0.09906452f, -0.14109491f, 0.05453236f, 
    0.13671669f, -0.13770239f, -0.01065644f, 0.00180171f, 0.08375351f, -0.03932732f, 0.03716443f, 0.00246288f, 
    0.09887288f, 0.12388296f, -0.03908699f, 0.01457557f, 0.13875152f, 0.23716950f, 0.30174738f, -0.05468873f, 
    -0.00715380f, -0.11205436f, -0.10688024f, -0.01554679f, 0.05344818f, -0.03302165f, 0.09043515f, 0.17337365f, 
    0.24613316f, 0.01781617f, -0.30907419f, -0.39300445f, -0.10078886f, -0.02166313f, -0.11174716f, 0.23028892f, 
    0.06644337f, 0.02893056f, 0.05565651f, -0.06949755f, -0.12506095f, 0.40085778f, -0.28894788f, -0.15442698f, 
    -0.04026773f, -0.27777368f, -0.07265925f, 0.03282846f, 0.01345843f, -0.07651555f, 0.21846467f, -0.07141747f, 
    0.11895274f, 0.10252779f, 0.09531656f, -0.04569498f, -0.02014155f, 0.02575666f, 0.02870109f, -0.00458892f, 
    0.20490025f, 0.11140060f, 0.11414053f, 0.13355489f, -0.13265482f, -0.14452347f, -0.10702957f, -0.05740130f, 
    -0.08177461f, 0.10682123f, 0.04411217f, 0.00535690f, -0.04821568f, -0.08175845f, -0.04558193f, 0.08233485f, 
    0.18709382f, -0.57653445f, -0.00885955f, -0.29577816f, 0.09646542f, 0.18127261f, 0.07136790f, 0.04000431f, 
    0.09839095f, 0.05209401f, 0.08418990f, 0.04579176f, -0.05588442f, 0.03418180f, 0.03204688f, -0.10908154f, 
    -0.08504228f, -0.21057154f, 0.18843763f, 0.22966900f, -0.01757010f, -0.06299479f, 0.02758721f, 0.05512811f, 
    0.08457011f, -0.00226897f, 0.13175228f, -0.00420283f, 0.04848114f, -0.07411086f, -0.08262794f, 0.10565922f, 
    -0.06929573f, 0.00108887f, 0.01482710f, 0.03165902f, 0.14889511f, 0.04719206f, -0.02135224f, -0.06355200f, 
    -0.13338503f, 0.04651346f, -0.23462242f, 0.04694151f, -0.05528646f, 0.04551407f, -0.00519560f, -0.03860980f, 
    0.01703284f, -0.11227647f, -0.07948082f, -0.14770174f, 0.01864239f, 0.05000956f, -0.05595682f, -0.00515046f, 
    -0.02330210f, -0.05310101f, 0.20370688f, 0.09288211f, -0.13372104f, -0.03227839f, -0.14119755f, 0.04975124f, 
    0.11292870f, 0.05902610f, 0.04838118f, -0.09671853f, -0.05435314f, 0.00622283f, -0.03223168f, -0.00413281f, 
    -0.05295246f, -0.10122314f, 0.27379233f, -0.20253108f, 0.07997862f, 0.14217943f, 0.05712729f, 0.04747044f, 
    0.00724708f, -0.09795783f, 0.01413799f, 0.04784643f, 0.00663536f, -0.07037649f, -0.19326040f, -0.19502398f, 
    -0.24570525f, -0.00622864f, -0.00172739f, -0.20478004f, -0.01839168f, 0.04850991f, 0.10270401f, -0.18050733f, 
    0.23458360f, 0.16336478f, 0.06330440f, 0.09967052f, 0.06620141f, -0.00530832f, -0.05381354f, -0.04568747f, 
    0.08373252f, 0.03203957f, -0.16211407f, -0.07155371f, -0.06777373f, 0.17920604f, 0.02783038f, 0.06179641f, 
    -0.05457698f, -0.01732152f, 0.14475828f, 0.22108363f, -0.02448046f, -0.05387322f, 0.00167449f, -0.01151890f, 
    -0.08927892f, 0.01031394f, -0.11368345f, -0.08433050f, -0.01978566f, -0.02834560f, 0.02858814f, 0.02178486f, 
    0.04061922f, -0.00227680f, 0.01742187f, -0.04236641f, -0.30915719f, -0.11620130f, -0.16522314f, -0.30866119f, 
    -0.11815773f, -0.08339498f, -0.02876354f, 0.13297434f, 0.17427911f, -0.03840145f, 0.06603584f, 0.01866465f, 
    0.05813209f, 0.15710236f, -0.26884788f, 0.10676769f, 0.06334465f, 0.00951183f, 0.13190731f, -0.09466596f, 
    -0.02392567f, 0.04258277f, 0.03052097f, -0.02109162f, 0.71683991f, 0.00996874f, -0.13612233f, -0.02915049f, 
    -0.05140470f, -0.13068283f, 0.08069029f, 0.15495294f, 0.01806593f, -0.06007693f, 0.05884502f, -0.03520897f, 
    -0.14483513f, -0.12652478f, -0.04462988f, 0.00293701f, 0.00785795f, 0.08168082f, -0.00717337f, 0.05613182f, 
    -0.08586955f, -0.16720253f, 0.14737801f, -0.20989062f, 0.00558316f, -0.11940949f, 0.20078221f, -0.19532654f, 
    -0.01129931f, 0.06419329f, 0.18463184f, 0.03622286f, -0.07676929f, 0.02954691f, 0.05576659f, -0.03382687f, 
    0.00843287f, -0.06538761f, 0.16987120f, 0.11127873f, 0.22381184f, 0.14695673f, 0.10674943f, 0.16221437f, 
    0.01743862f, 0.05619162f, -0.06071675f, 0.02729451f, -0.05054157f, -0.05135755f, -0.20121993f, 0.01312137f, 
    0.06601744f, -0.00643071f, -0.08023519f, -0.05125200f, 0.06069899f, -0.10714004f, -0.05254878f, 0.00837950f, 
    -0.04310952f, 0.13209949f, 0.15334521f, -0.04945599f, 0.08009950f, 0.07485295f, 0.05469692f, -0.04147633f, 
    -0.04234497f, 0.06278444f, 0.02763175f, -0.04274599f, -0.04511954f, -0.27923784f, -0.08521530f, 0.07088181f, 
    0.09960786f, 0.08654930f, 0.21336614f, 0.11860041f, 0.08579644f, 0.16342698f, -0.05985796f, 0.05513991f, 
    -0.25669736f, 0.11816271f, -0.24381965f, -0.16596377f, 0.08162476f, -0.04790567f, -0.08780575f, 0.15537417f, 
    0.05120157f, 0.04087324f, 0.02113619f, 0.11767147f, -0.00753262f, -0.07908425f, -0.02989818f, 0.05130769f, 
    0.18528742f, 0.05111942f, -0.12825333f, 0.04088061f, 0.08897950f, 0.06154771f, -0.00140888f, 0.04284637f, 
    -0.12726521f, 0.00055046f, -0.10127332f, -0.07439707f, -0.03514736f, 0.06472120f, 0.05396461f, 0.11764555f, 
    -0.15393455f, -0.05924873f, 0.14101775f, -0.07624437f, -0.15514512f, -0.19609348f, 0.13895847f, 0.02032917f, 
    0.04999632f, -0.03681079f, 0.07720332f, -0.09726068f, 0.14406806f, 0.02823950f, -0.02294654f, 0.06534296f, 
    -0.06534985f, 0.16245264f, 0.11926193f, -0.12337907f, -0.06162924f, -0.09233322f, -0.08696306f, -0.04594663f, 
    0.02476619f, 0.17433162f, 0.06449263f, 0.12771223f, 0.13376720f, 0.10744221f, 0.09222879f, 0.09283253f, 
    0.06319964f, 0.04590748f, 0.04618191f, -0.14302081f, -0.03548712f, -0.03468956f, -0.08277828f, -0.06713269f, 
    -0.33192325f, -0.20122026f, 0.12008736f, 0.04483935f, -0.13187458f, 0.11350048f, -0.12735842f, 0.00548480f, 
    -0.12739405f, -0.26693970f, -0.08668647f, -0.00442898f, 0.13668020f, -0.13874407f, -0.04347412f, 0.34049597f, 
    -0.10091879f, -0.12410202f, -0.16742557f, -0.29338786f, 0.15727545f, -0.01821674f, -0.00316562f, 0.06390054f, 
    -0.00859411f, -0.01549922f, -0.37131643f, 0.01397865f, 0.01031775f, 0.12953986f, -0.16697353f, -0.08471819f, 
    0.04529819f, -0.08302958f, 0.05658243f, 0.16500816f, -0.11373545f, -0.03369444f, 0.04754239f, -0.04184076f, 
    -0.22618674f, -0.00768290f, -0.15273257f, -0.10695215f, 0.18241349f, 0.05335715f, 0.09244701f, 0.00533577f, 
    -0.17957823f, -0.30814898f, -0.08027209f, 0.14545205f, -0.09225955f, -0.10202177f, 0.03286529f, 0.01001308f, 
    0.14932820f, 0.17261325f, 0.18930367f, -0.05353119f, 0.22384991f, -0.20913278f, -0.00777845f, -0.02083323f, 
    0.11884735f, -0.06948845f, 0.15220469f, -0.10639557f, -0.00389500f, 0.09135185f, 0.10524686f, 0.14958221f, 
    0.31006017f, -0.03125178f, 0.36413571f, 0.24762881f, 0.17438608f, 0.09169010f, -0.08914127f, 0.15911572f, 
    0.03259048f, 0.02439246f, -0.21513817f, 0.06094091f, 0.08718525f, 0.08048782f, -0.05671633f, 0.09323595f, 
    0.10167897f, -0.03256674f, -0.08855948f, 0.09038475f, -0.02862672f, -0.28745502f, -0.13161597f, -0.06300008f, 
    0.23893267f, 0.05394269f, -0.08732212f, 0.06192287f, -0.02792220f, 0.07838535f, 0.08744468f, 0.09824479f, 
    0.00118251f, -0.03057203f, 0.12355677f, 0.07581922f, -0.34026554f, -0.41267690f, -0.02138082f, 0.08019616f, 
    -0.01196042f, 0.03715109f, -0.24135445f, -0.17367578f, 0.00745047f, -0.13663146f, -0.03200099f, 0.04524200f, 
    0.00170217f, -0.10421699f, -0.15228273f, 0.24909882f, 0.06805384f, -0.15541524f, -0.09235677f, -0.06798825f, 
    0.11733681f, 0.04857504f, 0.10880246f, 0.19992577f, -0.04677123f, -0.06013300f, -0.01512889f, -0.03845277f, 
    0.06618162f, -0.09618553f, -0.13804688f, 0.30958673f, -0.12291747f, -0.08695599f, -0.17796966f, -0.41298470f, 
    -0.00325032f, -0.12101600f, -0.04329508f, 0.21868204f, 0.19015218f, -0.08880748f, -0.00755199f, -0.05641580f, 
    -0.05547912f, 0.05958386f, 0.08600368f, 0.10743458f, 0.03109058f, 0.18975464f, 0.02454109f, 0.06550577f, 
    -0.02215674f, -0.03283810f, -0.00359009f, -0.35156107f, 0.05158977f, 0.13753404f, -0.10747804f, 0.04964064f, 
    -0.29554445f, -0.19019032f, -0.10306264f, -0.02791775f, 0.23722842f, 0.19704415f, 0.05600064f, -0.04899364f, 
    -0.17254244f, -0.10040757f, -0.13403553f, -0.09941663f, 0.22572708f, 0.28109935f, 0.21224402f, 0.26178873f, 
    0.04231214f, 0.06322414f, -0.03390611f, 0.17821573f, 0.04011267f, -0.02567126f, 0.00956507f, 0.03733232f, 
    -0.07526533f, 0.05032615f, 0.12167724f, -0.01089969f, -0.00401239f, -0.12008695f, -0.10586131f, 0.07898662f, 
    0.02431332f, -0.11021007f, -0.02438427f, -0.10324842f, -0.44157493f, 0.03547725f, -0.09148995f, 0.18824288f, 
    -0.00835385f, 0.06867641f, 0.05996597f, 0.01560056f, 0.27314913f, 0.06383707f, -0.01140988f, -0.06052063f, 
    -0.07450935f, -0.24491854f, 0.06650258f, -0.05838246f, 0.16733405f, -0.04534214f, 0.03522176f, -0.02666673f, 
    0.06794997f, -0.07639880f, 0.06027000f, -0.00661415f, 0.31824803f, 0.06098603f, 0.00255407f, 0.14818472f, 
    0.03132097f, 0.18950015f, -0.02738626f, 0.06207947f, 0.00095523f, 0.00568904f, 0.03445545f, 0.18433928f, 
    -0.08006258f, -0.07604370f, -0.10815644f, -0.09617770f, 0.01108843f, 0.02294310f, -0.04438017f, -0.10618412f, 
    0.04060433f, -0.21177498f, -0.06416830f, -0.02154743f, -0.11048524f, -0.01395748f, 0.00650164f, -0.06112480f, 
    0.06180571f, -0.04108656f, -0.00313512f, -0.01091225f, -0.09995838f, -0.03622681f, 0.00922318f, -0.09616939f, 
    0.16585161f, 0.27524522f, 0.16347019f, -0.03154383f, 0.06686676f, 0.07935163f, 0.14076567f, -0.33098170f, 
    0.01212633f, -0.13814412f, -0.14898416f, -0.00419904f, -0.05802887f, -0.16861647f, 0.02269692f, -0.06268518f, 
    0.09277354f, 0.06288312f, -0.00267559f, -0.12247411f, -0.01857734f, -0.01474345f, -0.02965397f, 0.04565678f, 
    -0.09028188f, 0.05906088f, 0.15334618f, -0.04971205f, -0.01360560f, -0.04693257f, 0.09042804f, -0.25340265f, 
    0.02246042f, 0.11973239f, 0.04853008f, 0.02247548f, -0.06870064f, -0.20335110f, -0.10175990f, 0.18559831f, 
    0.08376766f, 0.08699870f, 0.15486987f, 0.08409917f, 0.07020035f, 0.01397232f, -0.03980259f, 0.06775037f, 
    -0.10115341f, 0.03010129f, -0.01027345f, -0.11574641f, 0.03770971f, 0.10294713f, 0.06707378f, -0.03495506f, 
    0.23474868f, 0.05380185f, 0.02322900f, 0.11513266f, -0.01547926f, -0.02295844f, -0.05230892f, -0.08199413f, 
    0.08633186f, -0.07482868f, 0.03247370f, 0.06796477f, 0.12729451f, -0.04114997f, -0.11100373f, 0.14000584f, 
    -0.04418397f, -0.02175433f, 0.01441950f, 0.02718096f, -0.02179689f, 0.14470154f, 0.06805690f, 0.10839625f, 
    0.00266245f, -0.13553227f, 0.08129814f, -0.02114743f, 0.00353693f, -0.36620134f, 0.22430633f, 0.21566902f, 
    0.05339101f, 0.00171645f, 0.12307895f, 0.17565964f, 0.04674128f, 0.03439289f, 0.07072701f, 0.20753333f, 
    -0.13368273f, 0.12610592f, 0.00297801f, 0.06716759f, -0.05272068f, -0.10429674f, -0.07191546f, -0.00375143f, 
    -0.03767809f, -0.00671322f, 0.11949582f, 0.15486290f, 0.00839291f, 0.04273143f, 0.00506104f, -0.22091463f, 
    -0.00276392f, 0.05604085f, -0.11862020f, -0.13370217f, -0.00882299f, 0.04290400f, -0.04366039f, 0.05214953f, 
    -0.09406721f, -0.00570600f, 0.10497875f, 0.04767784f, -0.05499459f, 0.06739026f, -0.27933264f, -0.00886201f, 
    -0.11487562f, -0.24300879f, -0.07939016f, 0.09838504f, 0.33048254f, 0.02662149f, 0.23337115f, 0.31813043f, 
    -0.10805475f, 0.00449260f, 0.10606636f, 0.11720517f, 0.07226130f, -0.04205236f, -0.08426297f, 0.18792632f, 
    -0.21109176f, -0.03618159f, 0.09496840f, 0.07352311f, 0.00311452f, 0.14045161f, 0.02121537f, 0.03722076f, 
    0.03028716f, -0.08849729f, -0.09731048f, 0.17042588f, -0.06397121f, 0.06991745f, -0.00081699f, 0.17255925f, 
    -0.14496858f, 0.24684975f, -0.00040477f, -0.11383437f, -0.15712208f, -0.08233439f, 0.09281101f, 0.03407765f, 
    -0.09230497f, -0.15937865f, -0.09824309f, -0.13405211f, 0.00121266f, -0.06095000f, 0.02443082f, -0.05929307f, 
    0.04976989f, 0.25016451f, 0.22025833f, 0.17164378f, 0.16179432f, -0.09398388f, -0.09390578f, 0.04108687f, 
    0.13700385f, 0.18312220f, 0.14427093f, 0.05956920f, 0.06405400f, 0.14027071f, 0.11989626f, 0.33872023f, 
    -0.11352891f, -0.03085714f, 0.05995302f, 0.47020394f, 0.03337814f, -0.04511235f, 0.17879325f, -0.04819329f, 
    0.06273384f, -0.01033474f, -0.09881850f, -0.00291845f, -0.02627834f, -0.07343571f, -0.19256426f, -0.09187850f, 
    0.00159286f, -0.16050266f, 0.01020202f, -0.07484548f, -0.26352346f, -0.08289808f, -0.30901036f, -0.40908423f, 
    0.17992184f, 0.07049890f, -0.27317807f, 0.04355342f, 0.08230588f, 0.03813866f, 0.02245274f, 0.04726762f, 
    -0.21728879f, -0.01633806f, -0.02024338f, 0.02585178f, 0.05298611f, -0.39963818f, 0.21613513f, -0.09302152f, 
    -0.01156361f, -0.01240736f, -0.05343889f, -0.22209185f, 0.08614576f, -0.11163444f, -0.11488605f, 0.03821802f, 
    -0.18896219f, 0.26781431f, -0.12027697f, 0.15218614f, 0.04173618f, -0.01640065f, 0.21250720f, -0.05869324f, 
    0.00630864f, 0.09288684f, 0.03841765f, 0.07042678f, -0.18839221f, -0.08678477f, 0.16597912f, 0.13307770f, 
    0.03785524f, -0.01097671f, 0.02721348f, -0.07361292f, -0.19836743f, -0.13918602f, -0.20819026f, -0.41925922f, 
    -0.06248735f, -0.03387486f, -0.00887887f, 0.33934987f, 0.23662053f, 0.09394371f, 0.14438981f, 0.02431130f, 
    0.06375142f, 0.10290600f, -0.00437443f, 0.22678560f, 0.04337679f, -0.07115833f, 0.11325818f, 0.16408625f, 
    -0.01304564f, 0.10770631f, 0.01007081f, 0.10441419f, 0.09269293f, 0.06482399f, -0.13675661f, 0.10899282f, 
    0.03315175f, -0.04314561f, -0.09602548f, -0.09682602f, 0.10906824f, 0.07244486f, -0.09635428f, -0.09029709f, 
    -0.22390096f, -0.19962794f, -0.02564821f, -0.13707291f, 0.08130638f, 0.03232865f, 0.01272687f, 0.07165090f, 
    -0.03350087f, -0.06452026f, -0.01423473f, 0.13914937f, 0.06869849f, 0.16269022f, 0.09208300f, 0.02211607f, 
    -0.05479417f, -0.33327949f, 0.00245761f, 0.17959930f, 0.03191021f, -0.03935209f, 0.04528752f, -0.03337701f, 
    -0.03142232f, -0.14897342f, -0.01947785f, -0.02590710f, -0.21991462f, 0.32977051f, 0.05996354f, -0.09315217f, 
    0.00737244f, -0.18428546f, -0.04700328f, 0.06398505f, 0.10603850f, -0.08441097f, 0.13459197f, 0.04951870f, 
    0.24776606f, -0.14545022f, 0.00600317f, -0.16001777f, -0.04053968f, -0.07360566f, -0.06227875f, 0.08298276f, 
    0.07623141f, -0.09448225f, 0.08083030f, 0.01323181f, 0.07158661f, -0.01848324f, 0.00817366f, 0.06172956f, 
    0.10123935f, -0.00668634f, 0.06558020f, -0.01182031f, 0.14257641f, 0.02738497f, -0.01169746f, 0.00307472f, 
    0.15987465f, 0.02515540f, -0.09036537f, 0.10880115f, 0.03371311f, 0.09160259f, -0.01991169f, -0.07390213f, 
    0.09150897f, -0.13306150f, 0.11681443f, 0.11462615f, -0.33852610f, -0.00507144f, 0.01052863f, 0.00240490f, 
    -0.00821752f, -0.13427296f, -0.11498250f, 0.03658247f, 0.02307537f, -0.10405489f, 0.04954565f, -0.03635392f, 
    0.25534272f, -0.14638586f, 0.35021767f, -0.44634882f, 0.09289680f, 0.09067756f, 0.05181457f, 0.15317148f, 
    0.05319316f, -0.04203109f, -0.01013165f, -0.00939196f, 0.01563385f, 0.01877548f, 0.13168596f, -0.18675765f, 
    0.09409501f, 0.02086032f, -0.03693144f, -0.00913021f, 0.09692401f, -0.00699223f, -0.07476148f, 0.04175477f, 
    -0.19717696f, 0.00792479f, 0.33228701f, 0.09777570f, -0.08261427f, 0.05689370f, 0.05418982f, 0.05132186f, 
    -0.01391095f, 0.03935704f, 0.07837723f, 0.03784983f, 0.09495052f, -0.09789824f, -0.14925314f, 0.02100240f, 
    0.03732535f, 0.03569476f, -0.03470450f, -0.08831347f, -0.09794250f, -0.04966420f, -0.03874355f, 0.05731220f, 
    0.16791169f, 0.07199495f, 0.08608515f, -0.16824299f, -0.02148290f, -0.13622025f, -0.10105572f, -0.03728208f, 
    0.04208625f, -0.00953655f, -0.01269475f, -0.05105535f, 0.10674006f, 0.01169779f, -0.26924270f, -0.01624589f, 
    0.15232317f, 0.03612112f, -0.03418900f, 0.14805728f, 0.07351406f, -0.04677057f, -0.05506544f, 0.01038604f, 
    0.00831163f, 0.15542820f, 0.04861382f, -0.20157966f, -0.06297478f, -0.08059534f, 0.00129541f, 0.05323597f, 
    0.04853380f, -0.08500472f, 0.10219257f, 0.06559990f, -0.09315819f, -0.07972348f, 0.13364540f, 0.10047992f, 
    -0.23181908f, -0.00721095f, 0.06667962f, -0.07528358f, -0.00693756f, -0.00153252f, -0.06149926f, 0.10591587f, 
    0.09011929f, -0.14442755f, -0.03379619f, 0.24184415f, 0.12881804f, -0.03329558f, 0.01954219f, -0.05870680f, 
    0.03534261f, -0.00433432f, -0.11275963f, -0.07739654f, 0.12831029f, 0.25230688f, 0.20045637f, 0.03367811f, 
    0.00773343f, -0.00169298f, -0.09034422f, -0.05243428f, 0.12386907f, -0.00868874f, 0.08423238f, -0.03130636f, 
    -0.01897768f, 0.03565321f, -0.07186784f, -0.02312789f, 0.03458720f, -0.06374417f, -0.04269022f, 0.03390604f, 
    0.00765409f, -0.06935922f, 0.05004155f, -0.07151140f, -0.06255881f, -0.01289030f, 0.04334166f, 0.03425484f, 
    -0.04505822f, 0.00590650f, 0.02846259f, -0.03233094f, -0.06909031f, 0.05556448f, -0.02432424f, 0.04083506f, 
    0.06565940f, -0.03897479f, -0.05713829f, -0.07032205f, 0.04124473f, 0.02152409f, 0.03277956f, 0.05808293f, 
    0.00985952f, -0.06795974f, -0.03660039f, 0.05376097f, -0.05225251f, 0.02205508f, -0.05857833f, -0.04186580f, 
    0.05042055f, -0.05390251f, 0.00430011f, -0.05861602f, -0.06895314f, -0.03591004f, 0.01825348f, -0.03182098f, 
    -0.06292427f, -0.02185567f, 0.05936121f, -0.05923330f, 0.01616000f, -0.02398404f, -0.07293797f, -0.06917191f, 
    0.01139222f, -0.06057767f, -0.04089194f, -0.00746995f, 0.04350960f, -0.06265733f, 0.06137360f, 0.04302454f, 
    -0.07589020f, -0.06678265f, 0.00268813f, 0.06039391f, -0.05699127f, 0.06137560f, -0.00286764f, 0.04979054f, 
    0.00452302f, 0.04534704f, -0.02919323f, -0.03902450f, 0.01273430f, -0.06300246f, -0.01198005f, 0.00153249f, 
    -0.01962937f, -0.05500414f, -0.03985178f, -0.05088371f, -0.01137763f, -0.05083319f, -0.07093003f, 0.04694793f, 
    -0.06567061f, 0.00749648f, -0.04677899f, -0.01487838f, 0.04671499f, -0.04582790f, 0.05599733f, -0.02851383f, 
    -0.06938700f, 0.02504614f, 0.04619281f, 0.04408733f, -0.05333670f, -0.01145751f, 0.02882997f, -0.07602769f, 
    -0.06392647f, 0.02233624f, -0.00739237f, -0.02626953f, 0.00357450f, -0.06781016f, 0.04196760f, -0.03059740f, 
    0.03956088f, 0.01108262f, -0.05509135f, 0.01738274f, -0.00720915f, -0.05371455f, -0.05255653f, -0.02562488f, 
    -0.01039244f, -0.02916176f, 0.01682138f, -0.04889888f, -0.02284444f, 0.01702959f, -0.02266095f, 0.00831721f, 
    0.01312267f, -0.02176962f, 0.01526067f, -0.05310235f, 0.05255114f, -0.00251325f, 0.02415274f, 0.00424998f, 
    0.05363328f, 0.03652170f, -0.05356724f, -0.06848873f, 0.04860388f, 0.00904436f, -0.04812982f, -0.00550871f, 
    -0.00446045f, 0.05958633f, 0.02313036f, -0.00010485f, 0.05958476f, 0.04400345f, 0.03292578f, -0.01025734f, 
    0.01952491f, 0.04160573f, -0.02672070f, -0.08016137f, 0.05975666f, 0.05547627f, 0.03999252f, 0.00590070f, 
    0.00679397f, 0.05018068f, 0.05583508f, -0.03532294f, -0.01530047f, -0.03932520f, -0.04010184f, -0.01630759f, 
    0.01974093f, -0.00766398f, 0.03948984f, -0.00258782f, -0.07172789f, -0.06294094f, -0.05851616f, -0.01487921f, 
    -0.02549061f, -0.05145833f, -0.03827506f, 0.02342487f, -0.06931172f, -0.04435734f, 0.03101800f, 0.06301807f, 
    -0.03720519f, -0.07170945f, -0.00666065f, 0.05342405f, 0.00493620f, -0.00514583f, -0.06189780f, 0.05876990f, 
    0.11614475f, -0.02445733f, 0.06383265f, -0.11581643f, -0.07044885f, -0.00658888f, -0.08741029f, -0.01143986f, 
    0.01197489f, -0.00105048f, -0.12067119f, 0.00276017f, -0.28404656f, -0.17341936f, -0.16788127f, -0.01169667f, 
    -0.03547237f, 0.06331237f, 0.03404231f, -0.02357839f, 0.18827716f, 0.01009270f, 0.09637054f, -0.05981092f, 
    -0.10683312f, -0.26309282f, 0.10310451f, 0.05067676f, 0.08777858f, -0.05639132f, 0.12430439f, 0.09635784f, 
    0.06735567f, -0.12912515f, 0.08760925f, 0.08950381f, 0.52919084f, -0.03190390f, 0.07173744f, 0.22163419f, 
    0.13486102f, 0.22983226f, 0.11623019f, -0.08863835f, -0.03462372f, 0.02980399f, 0.14822474f, 0.10153376f, 
    0.02318029f, 0.04725053f, -0.03450096f, -0.13491186f, -0.00657811f, 0.02997562f, 0.05817469f, -0.14978835f, 
    0.00346080f, -0.23887594f, -0.08388288f, -0.09654079f, -0.14249915f, -0.08068337f, -0.05130646f, -0.14586781f, 
    0.06581657f, -0.15702498f, 0.04289928f, 0.00486479f, 0.00683255f, 0.08077901f, -0.01164924f, -0.13508557f, 
    0.02869563f, 0.10110535f, 0.29925874f, -0.08972026f, 0.04362096f, 0.21893217f, 0.25126153f, -0.18092047f, 
    0.19787210f, -0.13071533f, -0.11188020f, -0.04962517f, -0.19350052f, -0.17760709f, 0.03759969f, -0.00005200f, 
    0.06773838f, 0.01009827f, 0.01926240f, -0.01180678f, 0.09307340f, 0.05745526f, -0.03499379f, 0.03398878f, 
    -0.16903794f, 0.03879040f, 0.13794456f, -0.02329908f, 0.10321542f, 0.06534951f, 0.10094047f, 0.00058190f, 
    0.00575419f, 0.07101166f, 0.14570914f, -0.00306309f, 0.01172748f, -0.12803280f, -0.11623736f, 0.09787104f, 
    0.12914123f, 0.05704772f, 0.10272876f, 0.14131473f, 0.11708922f, -0.02855811f, 0.05430491f, 0.09806001f, 
    -0.28469551f, 0.05869987f, 0.11637109f, -0.16989926f, 0.03128144f, 0.22399850f, 0.17441611f, 0.07632677f, 
    0.11060092f, -0.00476340f, -0.08171656f, 0.06925173f, 0.02416114f, 0.05026258f, -0.04331146f, 0.06744774f, 
    0.26949909f, -0.09854740f, 0.03904591f, 0.08286845f, 0.03391313f, -0.00365178f, -0.06809156f, 0.01200826f, 
    -0.21952879f, 0.06586935f, 0.03349492f, -0.13097584f, -0.03821699f, 0.11404983f, 0.04403450f, 0.21566701f, 
    0.20087638f, -0.18614139f, 0.00705211f, -0.12860784f, -0.13765678f, -0.51458561f, 0.27309582f, 0.05902767f, 
    0.04890109f, 0.08436734f, 0.10798742f, 0.08059333f, 0.17546193f, 0.07616256f, 0.01120406f, 0.21762434f, 
    -0.12130361f, 0.02455504f, 0.03057443f, 0.01988459f, -0.02608875f, -0.03956212f, -0.15802157f, -0.00621548f, 
    -0.06835961f, 0.12320252f, 0.05954049f, 0.07125669f, -0.10761849f, -0.02109477f, 0.06559271f, -0.02592481f, 
    0.05036467f, 0.15469995f, 0.04667074f, -0.10588767f, 0.13473870f, 0.13119656f, -0.03778492f, -0.01488646f, 
    0.18682787f, 0.13047710f, 0.05406360f, -0.25369558f, -0.02383116f, 0.16176285f, -0.10835714f, -0.00265771f, 
    0.06885593f, 0.05749603f, 0.02357745f, 0.00790462f, 0.25075713f, 0.10245187f, -0.07963949f, 0.01674037f, 
    -0.18931325f, 0.01246369f, -0.03390905f, 0.04004527f, -0.12499627f, 0.27445078f, -0.05879919f, -0.07585067f, 
    -0.02175566f, -0.34370852f, -0.04621020f, 0.14680798f, -0.03643700f, 0.03916695f, 0.02016719f, 0.19502956f, 
    0.03853185f, -0.06606805f, -0.12118713f, -0.02791593f, 0.13546754f, 0.12285528f, -0.04189633f, -0.07646897f, 
    0.18258055f, 0.15650643f, 0.08282418f, -0.08886639f, 0.09784643f, 0.13513507f, 0.07807615f, 0.18310389f, 
    -0.07332348f, -0.03302724f, -0.00810906f, -0.19904646f, -0.06557901f, 0.00512861f, 0.04985505f, -0.01821695f, 
    0.15564501f, 0.03952874f, 0.07088687f, 0.07330249f, 0.11006975f, -0.18805836f, -0.19666129f, 0.04287270f, 
    0.08552451f, -0.01651722f, 0.03434654f, -0.05380706f, 0.09039225f, -0.00894583f, 0.03748233f, 0.16195457f, 
    -0.04548372f, -0.04125844f, -0.05942735f, 0.07996268f, 0.18869606f, -0.09033498f, -0.01932720f, -0.09528273f, 
    -0.01002841f, 0.11934561f, 0.04086895f, -0.02994177f, -0.07698870f, -0.08493242f, 0.01323196f, -0.05919154f, 
    -0.09082193f, -0.08636013f, 0.04689556f, 0.07946540f, 0.05185980f, 0.10591777f, -0.12007722f, -0.07521215f, 
    -0.01027904f, -0.01994035f, -0.24464051f, -0.20923327f, -0.00410411f, -0.05053454f, -0.09271954f, 0.05445885f, 
    -0.07938319f, -0.07767109f, 0.02789538f, 0.13499095f, 0.01915437f, 0.15782037f, -0.00125351f, 0.01976534f, 
    -0.11721164f, 0.06030973f, 0.03510285f, 0.10500082f, 0.13103408f, -0.14461781f, 0.02239424f, 0.01142893f, 
    -0.26968977f, -0.04013370f, -0.03911786f, 0.00953655f, -0.03173573f, 0.04467588f, 0.24515602f, 0.21205483f, 
    -0.02959271f, 0.10676822f, 0.06677412f, 0.23107207f, -0.23466203f, 0.08967077f, 0.22147372f, 0.14444931f, 
    0.20294133f, -0.03250371f, 0.17506634f, 0.02798232f, 0.02210675f, -0.00375186f, -0.09864966f, -0.04596812f, 
    -0.15693080f, -0.22008231f, -0.03939450f, 0.14520392f, -0.01448731f, 0.13276197f, 0.10423625f, 0.11040282f, 
    0.17718773f, 0.06333797f, -0.09062843f, 0.01718264f, 0.24686448f, -0.33963904f, -0.03779784f, -0.11290520f, 
    0.07562931f, -0.09314352f, 0.13666604f, -0.04850730f, 0.01376440f, 0.01671277f, 0.01348322f, 0.06774633f, 
    -0.04104054f, 0.05986506f, -0.05954299f, 0.08652882f, -0.04665256f, 0.07190987f, 0.03712231f, 0.03285320f, 
    -0.05006951f, 0.09645776f, 0.12419468f, 0.13949656f, -0.22671671f, -0.11200781f, -0.19172651f, -0.11242069f, 
    -0.12491043f, 0.05851641f, 0.15684071f, 0.18796825f, 0.02389264f, 0.13268073f, 0.03785124f, -0.04588399f, 
    0.03370552f, -0.00333034f, 0.04078858f, 0.17095944f, -0.05130759f, -0.05648354f, 0.13788740f, -0.04960867f, 
    0.02506016f, -0.04755875f, 0.04883731f, -0.18864447f, -0.33163583f, 0.02127119f, -0.04341864f, -0.14286239f, 
    -0.10489947f, -0.05344827f, -0.02176629f, 0.01410753f, -0.02464838f, 0.09842692f, 0.06145756f, 0.04221819f, 
    0.15927941f, 0.13145410f, 0.25300461f, 0.01062135f, 0.10488027f, -0.02108669f, 0.01823916f, 0.14360467f, 
    0.03612956f, 0.03946001f, 0.05827167f, -0.06922479f, 0.14166108f, 0.26133883f, 0.02181539f, 0.19877347f, 
    0.08741619f, -0.04464651f, 0.05587509f, 0.05796871f, 0.14740212f, 0.01845514f, 0.04414486f, 0.25821576f, 
    -0.08985333f, 0.12964444f, -0.05363322f, -0.13713737f, -0.07150792f, -0.16111432f, -0.10088412f, -0.21936902f, 
    0.03015389f, -0.26596871f, -0.14259802f, -0.05577474f, -0.25618640f, 0.21210773f, 0.03479167f, 0.07981937f, 
    0.14266390f, 0.11601593f, -0.11046791f, 0.06204161f, -0.04472375f, -0.01574790f, -0.05236790f, -0.14867912f, 
    0.08946194f, 0.07634193f, -0.16187893f, -0.19490844f, -0.11837924f, 0.05879486f, 0.05188831f, -0.08697657f, 
    -0.04375073f, -0.04574983f, 0.10467535f, -0.03118089f, -0.04386308f, -0.08747856f, 0.00260473f, -0.10321006f, 
    0.11658734f, 0.11330942f, 0.10938311f, -0.06780104f, -0.01690473f, 0.05439482f, 0.10319451f, 0.09239725f, 
    0.07925416f, 0.08053661f, 0.01503837f, -0.05175372f, 0.03151584f, -0.02537365f, 0.12525682f, -0.04723986f, 
    -0.05453433f, -0.08350489f, -0.12607673f, -0.09248445f, 0.06451973f, -0.13348880f, -0.14489263f, -0.19672590f, 
    -0.04870668f, 0.17274386f, 0.16033448f, 0.05448683f, 0.10597733f, -0.01328097f, 0.32881588f, 0.03063091f, 
    0.31624755f, 0.06700725f, 0.07623596f, -0.11401024f, -0.09538225f, 0.04898559f, 0.04309664f, 0.05414804f, 
    0.12374343f, 0.02150626f, 0.08912347f, -0.00767889f, -0.01815462f, -0.03498019f, -0.11315311f, -0.25118816f, 
    0.02530931f, 0.12752844f, 0.21535264f, -0.09461742f, 0.00380306f, 0.07357094f, 0.01568842f, 0.15536359f, 
    0.14415409f, 0.05799102f, 0.15947729f, -0.08848929f, -0.00231697f, 0.14063311f, 0.09400446f, -0.02978260f, 
    0.03590732f, 0.03997914f, -0.04156587f, -0.06129795f, 0.00642389f, 0.08382517f, 0.15465115f, -0.03737498f, 
    0.14136468f, 0.03886298f, 0.02629968f, 0.32525152f, 0.07024602f, 0.04969110f, 0.07780715f, -0.00037577f, 
    -0.06490497f, 0.10001280f, 0.19188415f, 0.02746300f, -0.21468331f, -0.30768061f, -0.08565854f, -0.07186042f, 
    0.18278790f, 0.07296937f, 0.18801033f, -0.02053427f, -0.09274966f, -0.09763408f, -0.17778890f, -0.24662989f, 
    0.03860065f, 0.01609432f, -0.14298065f, -0.07913078f, 0.09604432f, -0.03188798f, -0.03158401f, 0.09350608f, 
    -0.09921787f, -0.06134353f, -0.12888978f, 0.30296159f, 0.07637963f, 0.04132874f, 0.21206132f, -0.04142069f, 
    -0.04909140f, -0.07048523f, 0.05161408f, 0.11908697f, -0.25188673f, 0.44108784f, 0.38030586f, 0.04399561f, 
    -0.10152216f, -0.18279828f, -0.01761506f, -0.05905505f, 0.04988392f, -0.09174026f, 0.08601494f, 0.08996361f, 
    0.05090588f, 0.09399008f, 0.13280392f, -0.04544197f, -0.04941462f, 0.18029419f, 0.01836242f, -0.02078262f, 
    -0.05817414f, 0.08369529f, -0.01258569f, 0.00953819f, 0.00894616f, -0.05307128f, 0.02026186f, -0.01684231f, 
    0.03058418f, -0.09511926f, 0.07874483f, 0.06613141f, -0.04342346f, 0.15574364f, -0.02334626f, 0.06440753f, 
    -0.03696857f, -0.12198706f, -0.24898323f, 0.01863435f, -0.03150086f, -0.02952093f, -0.00949332f, 0.11394128f, 
    -0.03371873f, 0.09020720f, 0.18226661f, 0.24039254f, -0.15184712f, -0.01611865f, 0.04032666f, -0.08289505f, 
    -0.01367371f, -0.11280093f, 0.00421366f, 0.06155173f, 0.02168643f, -0.04556235f, 0.11548828f, 0.14163554f, 
    -0.01033477f, 0.00035832f, 0.17154145f, -0.07992156f, -0.14725810f, -0.01087542f, -0.11322320f, 0.26467049f, 
    0.05452915f, 0.02541407f, 0.01860441f, 0.03122942f, 0.18666089f, 0.12286555f, -0.01147803f, -0.12830529f, 
    0.02909443f, 0.12845850f, -0.03256261f, -0.01732614f, -0.14648442f, -0.12241402f, -0.12786648f, -0.24165575f, 
    -0.14202154f, -0.08936898f, 0.20046361f, 0.13210332f, -0.06109514f, 0.03471380f, -0.05684452f, -0.02282948f, 
    -0.00111262f, 0.02318188f, 0.10432521f, 0.02933509f, 0.17205833f, 0.16349480f, -0.06048994f, -0.15688048f, 
    0.08860105f, -0.01379393f, 0.20376207f, 0.02982655f, 0.12062752f, 0.06908926f, 0.02719606f, -0.09397332f, 
    0.22173849f, 0.16215272f, 0.09366804f, -0.12224676f, -0.01139640f, -0.15666749f, -0.09983102f, -0.06057929f, 
    0.05924196f, 0.06610768f, 0.00546043f, -0.06722022f, 0.25279462f, -0.16644526f, -0.00205856f, 0.02321905f, 
    0.01075895f, 0.07359078f, -0.10536724f, 0.22166802f, -0.02576029f, -0.08772570f, 0.02088868f, -0.16421825f, 
    0.08421048f, 0.19905271f, -0.03224127f, -0.11218691f, 0.05306712f, -0.14947015f, 0.10410087f, 0.02053265f, 
    -0.04748618f, 0.03776944f, 0.14196359f, 0.05771016f, -0.12414239f, 0.27588570f, 0.07645773f, 0.16318169f, 
    -0.06673660f, -0.00437406f, -0.00576298f, -0.11399674f, -0.02462363f, -0.11027177f, -0.04543434f, -0.02644688f, 
    0.00609899f, -0.23791470f, -0.12817736f, 0.11796132f, 0.07477693f, 0.01676824f, 0.09318281f, -0.02649153f, 
    0.00397384f, -0.01340741f, -0.15534209f, -0.07267614f, 0.05092509f, 0.18463041f, 0.06888075f, -0.04808735f, 
    0.09619892f, 0.07295045f, -0.04446043f, 0.02226413f, 0.07563338f, -0.01525508f, 0.15332183f, 0.17170660f, 
    0.12559694f, 0.05153353f, -0.04334649f, 0.07283580f, -0.10079095f, -0.10790119f, 0.11777693f, -0.05604580f, 
    -0.06421707f, 0.06613114f, 0.04232814f, -0.06475494f, -0.21753275f, 0.21154684f, 0.02498796f, -0.18125881f, 
    -0.08534028f, -0.21317233f, -0.16545902f, -0.03067584f, 0.06362978f, -0.00200846f, -0.04173440f, -0.09223830f, 
    0.21495599f, 0.04768868f, 0.09690756f, 0.04508634f, 0.15883288f, 0.03891260f, 0.00003556f, 0.14260343f, 
    -0.01255273f, 0.05383971f, -0.01840137f, -0.05959524f, 0.07175796f, -0.10824335f, 0.13719843f, -0.10545591f, 
    0.26878765f, 0.01906194f, 0.10728296f, 0.13529985f, 0.15762003f, 0.07635036f, 0.09566033f, 0.05535502f, 
    0.16612893f, 0.04120639f, -0.02844923f, 0.01420195f, 0.00855702f, -0.01265988f, -0.01193537f, 0.01628361f, 
    -0.00185295f, -0.17190735f, -0.08847139f, -0.02707998f, -0.32320571f, 0.11352069f, 0.12239832f, -0.00506571f, 
    0.02948182f, -0.06780914f, -0.00943686f, 0.06844877f, -0.00643334f, -0.00756505f, 0.00412968f, -0.07293492f, 
    0.18814135f, -0.07603803f, 0.26517627f, -0.25576541f, -0.02525645f, 0.07275348f, 0.09324650f, 0.36809307f, 
    0.06479699f, 0.00138678f, -0.05644052f, -0.02991380f, 0.02095816f, 0.01167791f, 0.11273433f, -0.12472597f, 
    0.12316958f, 0.09038971f, -0.00293299f, 0.11724729f, -0.01328239f, 0.00787182f, 0.10935908f, 0.10562017f, 
    -0.17278183f, -0.04756871f, 0.21806410f, 0.11599787f, -0.00456272f, 0.01719878f, -0.08793628f, -0.01737867f, 
    0.14507028f, 0.07894270f, 0.08881925f, -0.01064195f, -0.04486115f, -0.10822814f, -0.11369438f, -0.09145514f, 
    -0.02381818f, 0.10170747f, 0.13315567f, -0.01150304f, -0.20686150f, -0.03238172f, 0.20584418f, -0.00244365f, 
    0.22629431f, 0.00190578f, 0.08161459f, -0.17499238f, -0.13378830f, -0.01730111f, -0.10798849f, 0.21791935f, 
    0.03970758f, -0.08451828f, -0.08356192f, -0.05497310f, 0.13772625f, 0.09274776f, -0.10399309f, -0.04649127f, 
    0.09292346f, 0.07955649f, -0.01258146f, 0.13017328f, 0.02149770f, -0.03366898f, 0.10920214f, 0.08633493f, 
    -0.03630530f, 0.18879527f, 0.04304386f, -0.14166813f, 0.00285751f, -0.06532613f, 0.01239302f, 0.06040610f, 
    -0.04517202f, -0.05220791f, 0.05261417f, -0.07606909f, -0.00509190f, 0.17328504f, 0.04653363f, 0.00720297f, 
    -0.13770258f, 0.05947879f, 0.11554588f, 0.02859040f, 0.13860135f, -0.10538544f, -0.01429223f, -0.14041662f, 
    0.05185545f, 0.01438011f, 0.14179839f, 0.13755800f, -0.06091132f, -0.15600500f, -0.08168615f, -0.05504528f, 
    0.00996871f, 0.10349184f, -0.00719698f, 0.04079975f, -0.01980287f, 0.08749377f, 0.13387664f, 0.11062919f, 
    0.08331019f, 0.07270684f, 0.02566892f, -0.02929892f, 0.00621039f, -0.04034869f, -0.04169397f, 0.12238756f, 
    -0.24860875f, -0.06775814f, -0.09291228f, -0.04495484f, -0.21189238f, -0.10836264f, -0.28236613f, 0.07628175f, 
    0.09127340f, -0.09383555f, -0.05945030f, -0.04181643f, 0.53664047f, -0.00694819f, -0.04052654f, 0.07831317f, 
    -0.00627389f, -0.02724945f, 0.03321541f, 0.28651267f, 0.03332964f, -0.00416968f, -0.10078282f, -0.09346508f, 
    -0.27672750f, 0.27430734f, 0.00939786f, -0.08271906f, 0.09034258f, -0.02551770f, 0.03406601f, -0.12593360f, 
    0.03511434f, 0.00837645f, 0.07099565f, -0.10542811f, 0.17456281f, 0.18216161f, -0.39537153f, 0.12161260f, 
    -0.30185017f, 0.03969090f, 0.03593615f, 0.02942275f, 0.06523094f, -0.09632596f, -0.03332377f, 0.01035790f, 
    -0.04891516f, 0.07344107f, 0.00508977f, -0.21812485f, -0.04065474f, 0.06795985f, 0.01892932f, -0.12038370f, 
    0.06591924f, 0.13424531f, 0.01876022f, -0.01736830f, 0.29479939f, -0.18668814f, -0.08186722f, -0.00795110f, 
    0.02577096f, 0.06097265f, 0.21512353f, 0.05027779f, -0.01371446f, 0.02417468f, -0.08944365f, 0.03061438f, 
    -0.48292774f, 0.44285914f, 0.05159396f, 0.50702649f, 0.06297617f, 0.06971610f, 0.06242966f, -0.03042076f, 
    0.09162094f, -0.02879975f, -0.01847581f, -0.03737598f, 0.05251230f, 0.12660660f, 0.04508236f, 0.13840131f, 
    -0.04166828f, 0.01946649f, 0.04375453f, -0.03976610f, 0.08240753f, 0.05047817f, -0.01026510f, 0.14303648f, 
    -0.04184156f, -0.09680381f, -0.31484404f, -0.00565846f, 0.15350787f, 0.02371429f, -0.03231305f, -0.01191173f, 
    -0.13054425f, 0.04916493f, 0.11745770f, -0.06491624f, 0.02721784f, -0.50874180f, 0.10021859f, 0.11339767f, 
    0.01136104f, 0.04541709f, -0.10853076f, 0.10836526f, -0.08062248f, 0.15557966f, -0.08806858f, 0.03689499f, 
    -0.06049668f, 0.40795767f, 0.00005676f, 0.21491703f, 0.17818786f, -0.06438554f, 0.13293271f, 0.04220762f, 
    0.07167260f, 0.01569366f, -0.06705909f, 0.03988803f, -0.14149313f, -0.18199953f, 0.04661418f, 0.02274305f, 
    0.04285514f, -0.00989665f, 0.09476957f, -0.06659757f, -0.08671519f, 0.05354250f, -0.01873328f, 0.02290399f, 
    -0.13046379f, -0.23673129f, -0.01806577f, 0.20589907f, -0.03570628f, 0.11522850f, 0.07585829f, 0.03897100f, 
    -0.01437431f, 0.03323361f, -0.06965495f, -0.02132050f, -0.04610956f, 0.00422739f, 0.12754177f, -0.06117237f, 
    0.04149712f, 0.12122998f, -0.10317485f, 0.02342395f, 0.01084352f, 0.18228133f, -0.03851979f, -0.04062686f, 
    0.09380092f, 0.15868174f, 0.08434331f, -0.29736295f, 0.06178856f, 0.08131728f, -0.04125397f, -0.13754518f, 
    -0.11605674f, 0.02772193f, 0.04609909f, 0.06889723f, -0.14731365f, -0.28367242f, -0.05011642f, 0.13174896f, 
    0.09926338f, 0.08088381f, -0.06903778f, -0.02663920f, -0.01892097f, -0.06964873f, -0.07488494f, -0.02544708f, 
    0.00421285f, -0.03912555f, -0.05820081f, 0.00789276f, 0.04454620f, 0.01398748f, 0.02470163f, -0.01565568f, 
    0.02639836f, -0.06199531f, -0.04985799f, 0.00878840f, -0.01656879f, -0.05918080f, -0.04955127f, 0.05831956f, 
    0.02765502f, -0.02434566f, 0.01983751f, -0.02392829f, -0.04333481f, -0.07444045f, -0.07088514f, -0.05378191f, 
    0.05495710f, -0.02103013f, -0.07780117f, -0.06503910f, -0.06023794f, -0.02689809f, -0.02426905f, 0.02348188f, 
    0.06652953f, -0.04283994f, -0.03487470f, -0.06427135f, -0.06883208f, -0.07060952f, 0.02915075f, 0.00284420f, 
    0.06249861f, 0.04058663f, -0.03019320f, -0.01378510f, -0.02143852f, 0.03244983f, -0.06632019f, 0.03146255f, 
    -0.05804099f, -0.00107210f, -0.07296082f, 0.00590242f, -0.06643848f, 0.00063720f, 0.01493255f, 0.04521897f, 
    0.05284954f, -0.02778145f, -0.00707286f, 0.04180972f, -0.06997378f, 0.02882579f, 0.00063992f, -0.06284576f, 
    0.01139206f, -0.07944941f, -0.00945831f, 0.05292317f, 0.02786729f, -0.04655739f, -0.01800061f, -0.01399777f, 
    0.03257868f, 0.02781537f, 0.00063949f, 0.02765460f, 0.05664984f, 0.03494028f, 0.00096615f, 0.00255626f, 
    0.00171041f, -0.03350522f, 0.05080376f, -0.07740640f, -0.00685251f, -0.00680477f, -0.05071062f, -0.06884222f, 
    0.00119227f, 0.04357646f, 0.05584871f, -0.01893254f, -0.00370899f, 0.04012015f, 0.05509349f, 0.03602255f, 
    -0.02851964f, 0.04798673f, 0.06793560f, 0.05669793f, -0.01553748f, -0.07121369f, 0.01577491f, 0.03812267f, 
    0.04096892f, 0.00593419f, -0.01023534f, -0.06695329f, -0.03921540f, -0.07990400f, -0.02967053f, -0.01834269f, 
    0.06029012f, -0.02429782f, -0.07559819f, 0.01298528f, 0.03511789f, -0.07776470f, -0.06684864f, -0.01294290f, 
    -0.02339466f, -0.06004402f, 0.04109368f, -0.06683075f, 0.00321521f, -0.04065295f, -0.00523131f, 0.01189031f, 
    -0.03292979f, 0.00473476f, -0.06094221f, 0.02110458f, -0.02432349f, -0.00439629f, 0.01335226f, 0.03094389f, 
    -0.00267509f, -0.03772999f, 0.03621446f, -0.07861227f, -0.03750807f, -0.01820061f, 0.00375095f, -0.04227889f, 
    0.00927964f, 0.04279279f, -0.02326266f, -0.07163005f, 0.05362806f, -0.05172556f, -0.02365126f, -0.04905061f, 
    -0.00670650f, -0.02378294f, -0.07085031f, -0.03919775f, -0.00796019f, -0.02593550f, 0.00212271f, 0.03789610f, 
    -0.02702340f, 0.01020894f, -0.03994104f, -0.06147028f, 0.05188959f, 0.01395194f, 0.02241617f, -0.02978827f, 
    -0.01869777f, -0.01279196f, -0.02171869f, 0.03935353f, -0.06417309f, -0.04708723f, 0.06263453f, -0.06067403f, 
    0.03195494f, 0.03158475f, 0.06119410f, -0.02470796f, 0.01497773f, 0.05094187f, -0.07408848f, 0.01259269f, 
    -0.03224040f, -0.03928791f, 0.00509528f, -0.04580849f, -0.02610713f, 0.04228584f, 0.00818485f, -0.05282100f, 
    -0.05647846f, 0.15725356f, 0.00695809f, 0.00472372f, -0.09519995f, -0.07061127f, -0.40030518f, -0.05198233f, 
    0.03121037f, -0.26593584f, 0.05049177f, 0.12167720f, 0.33874351f, 0.02264388f, 0.19221072f, 0.47180566f, 
    -0.10232947f, -0.04516020f, -0.00588268f, 0.06861562f, 0.09014906f, -0.03488182f, -0.00852104f, 0.04553183f, 
    -0.26491070f, -0.12793805f, 0.01478768f, 0.12922612f, 0.04946007f, 0.06973140f, -0.04269802f, -0.06996538f, 
    0.10121176f, -0.05722254f, -0.08607249f, 0.18535827f, -0.05393378f, -0.08423161f, 0.02102570f, 0.10698424f, 
    -0.01351946f, 0.40337083f, -0.12386364f, -0.06206070f, -0.01675667f, 0.02122853f, 0.08062346f, -0.00776756f, 
    -0.26145819f, -0.13503379f, -0.00349287f, -0.17287664f, 0.11053137f, -0.00478677f, 0.07117637f, -0.06750394f, 
    0.09958986f, 0.31494990f, 0.08068558f, 0.14881538f, 0.11561133f, -0.14785007f, -0.02211446f, -0.01807808f, 
    0.00630584f, -0.02014129f, 0.19478317f, -0.03083002f, 0.10574356f, -0.01980218f, 0.14414605f, 0.21145417f, 
    -0.05373101f, 0.10244166f, 0.21462145f, 0.39882842f, 0.08011216f, 0.06696275f, 0.14822559f, 0.05852563f, 
    0.07563501f, 0.09641388f, -0.16025040f, 0.08043921f, -0.14177220f, 0.02645636f, -0.09180133f, 0.06270231f, 
    0.07200007f, -0.05970357f, -0.07450315f, -0.02614210f, -0.22217223f, -0.15995759f, -0.29628143f, -0.28081986f, 
    -0.07462966f, -0.07395209f, -0.14242887f, -0.00713023f, -0.01569051f, -0.01913854f, -0.03439395f, -0.04280866f, 
    -0.09789216f, -0.02950998f, -0.03745706f, 0.07377182f, 0.03469400f, -0.42976239f, -0.05566236f, 0.21138109f, 
    0.10235123f, -0.02461854f, -0.07183982f, -0.13270168f, 0.06250089f, -0.05545695f, -0.16704006f, 0.04185930f, 
    -0.32988328f, 0.12570512f, -0.09756771f, 0.16239239f, 0.06046193f, -0.11602945f, 0.13136564f, -0.05320604f, 
    0.03429453f, 0.02350659f, 0.03403114f, 0.13399386f, -0.21420103f, 0.07934338f, 0.11362186f, 0.06083365f, 
    0.07442898f, -0.02427498f, -0.03839694f, 0.07739649f, -0.12733313f, -0.12380753f, -0.24268411f, -0.38170162f, 
    -0.08530634f, -0.03661748f, -0.11662076f, 0.30444151f, 0.12327208f, 0.04277883f, 0.13578081f, 0.01037638f, 
    0.04142674f, 0.16672395f, 0.07391156f, 0.10063060f, 0.06576405f, -0.09058619f, 0.06338821f, 0.32355419f, 
    -0.24143021f, -0.00673673f, 0.03530393f, -0.02447973f, 0.14666934f, 0.09101440f, -0.15004839f, 0.13804351f, 
    0.11405694f, 0.05078740f, -0.04178562f, -0.17141578f, 0.40167195f, 0.10428438f, -0.22930668f, -0.05011260f, 
    -0.11740951f, -0.13061495f, 0.02474541f, -0.07601710f, 0.12198751f, 0.06935765f, 0.05971827f, 0.17510889f, 
    -0.04583394f, 0.08582772f, -0.06764778f, 0.04544273f, 0.09880001f, 0.10289390f, 0.10859469f, 0.03868434f, 
    0.30301985f, 0.36227775f, 0.04677800f, 0.21181296f, -0.10650212f, -0.07593615f, 0.02050255f, -0.05520971f, 
    0.01741404f, -0.06158439f, -0.02785221f, -0.05069006f, 0.14868097f, -0.13243023f, -0.40496439f, -0.39490366f, 
    -0.11802828f, -0.24490258f, 0.00789905f, 0.07040644f, -0.01299176f, -0.19338086f, -0.07527190f, -0.02184998f, 
    -0.11874865f, -0.04495044f, 0.00496894f, 0.16394924f, 0.15467896f, -0.07113319f, 0.03048466f, 0.06332671f, 
    0.00705687f, -0.08684164f, -0.09880275f, -0.06606149f, 0.22466506f, -0.36513984f, 0.21340302f, -0.10279407f, 
    0.16873597f, 0.15027337f, 0.11777142f, -0.00142515f, 0.06228305f, 0.12784079f, -0.00806682f, 0.06298598f, 
    0.27498797f, 0.06201635f, 0.12950432f, 0.15420364f, 0.02733973f, -0.06338626f, -0.05323231f, 0.09699854f, 
    -0.00765706f, -0.13097741f, 0.00672793f, -0.10450561f, -0.22072460f, -0.01256731f, 0.06288610f, -0.02559505f, 
    0.03604791f, -0.06263097f, 0.10797212f, 0.03868451f, 0.02332920f, -0.06395394f, 0.22875452f, 0.02403494f, 
    -0.08090758f, 0.43583456f, 0.10672514f, -0.12845604f, 0.00427737f, 0.06847460f, 0.10694562f, 0.33114201f, 
    0.00032066f, 0.06172159f, -0.00398766f, -0.04923681f, -0.12269413f, -0.05535652f, 0.12401446f, -0.23575582f, 
    -0.01432913f, 0.20979615f, -0.13954183f, -0.02542459f, -0.09464259f, 0.00805142f, -0.09377160f, -0.04384983f, 
    -0.24333461f, -0.08795343f, 0.31387639f, 0.15964310f, 0.06909822f, -0.01158269f, -0.00611759f, 0.10139176f, 
    -0.00415739f, 0.06224947f, 0.00398068f, 0.03822086f, -0.00558085f, 0.04764493f, -0.07518249f, 0.04465579f, 
    -0.02255314f, -0.05167913f, 0.01862000f, -0.02042894f, -0.01963891f, 0.03756615f, 0.00285447f, -0.23053148f, 
    -0.00183421f, -0.11330301f, 0.06864090f, -0.08270729f, 0.01604725f, -0.07674021f, 0.03162480f, 0.21943398f, 
    0.09363513f, 0.00482175f, -0.05640025f, -0.04355649f, 0.39674562f, 0.12863895f, 0.06576648f, -0.06532595f, 
    -0.01873800f, -0.05637819f, -0.12257739f, 0.07595028f, -0.13581426f, -0.08711316f, 0.05346777f, 0.04311175f, 
    0.02489316f, 0.02245211f, -0.11233301f, -0.07324017f, 0.06889132f, -0.03112805f, 0.01954084f, 0.11727546f, 
    0.15615028f, 0.15819757f, 0.12007296f, 0.10696345f, -0.07489062f, 0.11575270f, 0.04126702f, 0.02599327f, 
    -0.07486884f, 0.03500865f, -0.16632216f, -0.05803482f, -0.03090134f, -0.00862340f, 0.03035489f, -0.12469277f, 
    0.22751023f, -0.09610128f, 0.22566022f, 0.15961571f, 0.01934079f, -0.07748448f, 0.02014795f, -0.16012822f, 
    -0.05203849f, -0.00694050f, -0.01919432f, -0.10293259f, -0.05345841f, -0.11321656f, 0.11345506f, 0.15490243f, 
    0.23652111f, 0.11602767f, -0.00171174f, -0.01329216f, 0.05025391f, 0.02593230f, 0.08721892f, 0.09984207f, 
    0.15432167f, 0.15721706f, 0.02413860f, -0.15331183f, -0.09463990f, 0.06171219f, -0.10356689f, 0.00127317f, 
    0.04410160f, 0.03647194f, -0.00833995f, -0.07603690f, 0.24448358f, -0.09477066f, -0.10844456f, 0.08012044f, 
    -0.09148562f, 0.00360862f, 0.07202727f, -0.03707382f, 0.01476911f, 0.11965562f, -0.00509087f, 0.09810892f, 
    -0.20068660f, -0.19063652f, 0.13970734f, 0.07336523f, -0.00300668f, 0.02820097f, 0.04448606f, 0.06804454f, 
    0.08683665f, -0.05517572f, -0.03321100f, -0.04630508f, 0.07449914f, 0.09045702f, 0.09840833f, -0.08449186f, 
    0.05655350f, 0.17423090f, -0.13947101f, 0.03610466f, 0.01384802f, 0.11369134f, 0.09817709f, 0.00826255f, 
    -0.05011807f, 0.00168911f, 0.09219110f, -0.06919199f, -0.11532578f, 0.02593779f, -0.06386381f, -0.01170659f, 
    0.09328222f, 0.10110112f, 0.06259046f, 0.04428815f, 0.13326494f, -0.10532256f, 0.02884330f, 0.16044575f, 
    0.14742035f, -0.00660578f, 0.07030710f, -0.03051834f, 0.11432899f, -0.02099560f, -0.06850671f, 0.04501723f, 
    -0.14271691f, 0.17121904f, -0.25411639f, 0.19329064f, -0.03678531f, -0.08081511f, 0.21329373f, -0.24854110f, 
    0.09054363f, 0.03224001f, 0.11626086f, 0.03722399f, -0.18853675f, -0.03993749f, -0.02047531f, 0.15856706f, 
    -0.10243797f, 0.00412969f, 0.06876341f, 0.17992812f, -0.04301745f, 0.02831271f, -0.09525219f, -0.00716884f, 
    -0.04119843f, -0.02855209f, -0.29774556f, -0.07188614f, 0.03338500f, -0.01176742f, -0.00280734f, 0.02793617f, 
    0.03638888f, -0.02376952f, -0.18341623f, 0.01302822f, -0.07305777f, 0.10816608f, 0.01805739f, 0.04299310f, 
    -0.08076038f, -0.03605140f, -0.11320206f, -0.00091942f, 0.15541178f, 0.01772089f, 0.03205679f, -0.05336192f, 
    -0.18040057f, -0.07666694f, 0.15251249f, 0.19736031f, -0.06381564f, 0.14628832f, 0.25753906f, -0.02141245f, 
    0.04148556f, 0.02041001f, 0.04683864f, 0.18789269f, -0.12075423f, 0.04242115f, 0.19768126f, 0.11758496f, 
    -0.00395959f, -0.02045546f, 0.24379119f, -0.02961535f, -0.01876114f, 0.05038362f, -0.01348906f, -0.03217574f, 
    -0.10606174f, -0.15856741f, 0.08235668f, 0.15413015f, 0.02195477f, 0.18431188f, 0.02437955f, 0.08421026f, 
    0.08110291f, 0.08070240f, -0.07041409f, 0.04472598f, 0.14781214f, -0.26679540f, 0.01782308f, 0.03590460f, 
    0.21537907f, -0.08786164f, 0.07984645f, 0.14354584f, -0.07402813f, 0.18833242f, 0.11558900f, 0.03192140f, 
    -0.15434079f, -0.07332293f, -0.07767769f, -0.11432914f, -0.10031566f, -0.04742647f, 0.00829132f, -0.02112328f, 
    -0.01945013f, -0.08319588f, 0.11173078f, -0.01033166f, -0.20521547f, -0.22910169f, -0.17568393f, 0.03071676f, 
    -0.07861242f, 0.05685052f, 0.09238033f, 0.08311405f, 0.01245601f, 0.05693033f, -0.02700789f, -0.05455103f, 
    -0.04219385f, -0.20265783f, -0.01280952f, 0.09194621f, 0.05350181f, 0.26736253f, -0.08168843f, 0.09642800f, 
    0.10074411f, -0.19904482f, -0.07722174f, 0.03145403f, -0.18208851f, 0.03426954f, 0.09673060f, 0.02779467f, 
    0.02715507f, -0.12114924f, -0.02760888f, 0.06266309f, 0.07750077f, -0.00287920f, 0.11442246f, 0.12061292f, 
    0.04028574f, -0.07587469f, -0.11910182f, 0.02122824f, -0.03625050f, 0.05495993f, 0.02963902f, 0.06965488f, 
    0.00875079f, -0.17784718f, 0.00253034f, -0.01300096f, 0.50107652f, -0.11784639f, -0.01150613f, 0.02423233f, 
    0.05638653f, 0.05588578f, -0.02909330f, -0.00733203f, -0.01602870f, 0.07177479f, 0.19785637f, -0.08192699f, 
    -0.06021171f, -0.24588436f, -0.11378720f, 0.12377079f, -0.01679724f, 0.13089851f, 0.15871826f, 0.18990763f, 
    0.15350479f, 0.01332252f, 0.21700084f, 0.05436651f, -0.00950362f, -0.19520858f, 0.04450507f, -0.19085777f, 
    -0.04856948f, -0.08400106f, 0.11460222f, 0.08836025f, 0.16542545f, -0.02879671f, 0.03949085f, 0.27054110f, 
    0.02902845f, -0.29998317f, 0.35167998f, 0.03912880f, 0.11999913f, -0.10716939f, 0.19792578f, 0.13393089f, 
    0.05027722f, 0.12506118f, -0.17189549f, -0.04222138f, 0.06808174f, 0.03355213f, -0.06385737f, -0.15101193f, 
    -0.00319979f, -0.04863630f, 0.01489864f, -0.01739062f, -0.03062884f, -0.16525374f, -0.20633064f, -0.10970236f, 
    -0.19804034f, -0.05939429f, 0.18874049f, 0.06444224f, 0.00647474f, -0.03304508f, 0.04207303f, -0.08133831f, 
    -0.02410648f, 0.00081264f, 0.11212745f, 0.12105421f, -0.07060800f, -0.06672433f, -0.25984067f, 0.23176984f, 
    0.07710054f, 0.03471424f, 0.08449899f, -0.04729107f, 0.06645419f, -0.00346390f, -0.18843895f, 0.04338030f, 
    -0.32185668f, 0.07391418f, -0.01796133f, -0.16104786f, 0.01294064f, -0.09832430f, 0.06805427f, 0.11668275f, 
    -0.02688037f, 0.05019978f, -0.00355359f, 0.04602919f, -0.02626956f, -0.08855957f, -0.07630996f, 0.19222970f, 
    0.19041932f, -0.01103455f, 0.05125443f, 0.15210471f, -0.02243975f, 0.06067958f, -0.11063720f, -0.10658312f, 
    -0.21527071f, 0.03563900f, 0.01213861f, -0.21198030f, -0.03864787f, -0.00700739f, 0.02863193f, 0.07089294f, 
    0.06466584f, 0.05045098f, 0.13735880f, 0.18161984f, -0.05157816f, -0.29395521f, 0.13950169f, 0.22154926f, 
    -0.01288870f, -0.00375596f, -0.00479733f, -0.06507260f, 0.06625560f, -0.05668168f, -0.05915099f, 0.12438950f, 
    0.04601663f, -0.11633790f, -0.20158504f, 0.02833403f, 0.12734284f, 0.05075756f, 0.02509313f, -0.18503858f, 
    -0.06325097f, -0.01812177f, 0.02748144f, 0.00585299f, 0.07727145f, 0.24120212f, 0.23229747f, 0.19171052f, 
    0.01311657f, -0.03636098f, 0.12217460f, 0.07360721f, 0.05842022f, 0.08396637f, 0.09039739f, -0.08542747f, 
    -0.38748106f, -0.11382329f, -0.30393961f, -0.28903061f, -0.05486213f, -0.03448148f, -0.12685868f, -0.09555856f, 
    -0.06336898f, 0.03081802f, -0.03061766f, 0.03655464f, 0.47172117f, 0.00773884f, 0.08688886f, 0.15146962f, 
    0.01468152f, -0.00691205f, 0.13184343f, 0.13480517f, -0.04068970f, -0.02034972f, -0.02186207f, 0.05780506f, 
    -0.08558583f, 0.15391259f, 0.15705404f, 0.23194699f, 0.03142436f, 0.01179151f, 0.00894830f, 0.07001472f, 
    0.03906779f, -0.03050181f, -0.04561032f, 0.07582358f, -0.30383399f, 0.03278229f, -0.19300018f, 0.02143399f, 
    -0.03489204f, 0.00025782f, 0.05684855f, -0.19981389f, 0.03420227f, 0.06892226f, 0.05062622f, -0.01771086f, 
    -0.17925437f, -0.08168928f, -0.09753043f, -0.24324566f, -0.10209740f, -0.11719102f, -0.17703794f, -0.02984038f, 
    -0.11262932f, 0.11747915f, 0.05525016f, 0.02422913f, 0.10360140f, -0.12158871f, -0.00105617f, 0.10780933f, 
    -0.03571875f, -0.15895362f, 0.13289014f, -0.07273617f, -0.06132350f, 0.10783779f, 0.00633013f, -0.12677552f, 
    -0.00879281f, 0.24543890f, 0.06008213f, 0.32537854f, 0.01151306f, 0.10300242f, -0.33229399f, 0.05745630f, 
    -0.12052321f, -0.08731751f, -0.08089524f, 0.14882497f, 0.02424367f, 0.09805255f, 0.18535842f, 0.17764205f, 
    0.01280242f, 0.21305583f, 0.00827926f, 0.17736436f, 0.09691262f, 0.09888756f, 0.23085433f, 0.13643952f, 
    -0.11836547f, -0.12268410f, -0.05452708f, 0.04083301f, -0.17268126f, 0.02066759f, -0.15596333f, -0.02035525f, 
    -0.00337257f, 0.13949732f, 0.05298656f, 0.05997575f, -0.12268144f, 0.14902659f, -0.06121954f, -0.07932477f, 
    -0.04633569f, -0.03803249f, -0.13533276f, -0.00516699f, -0.07665180f, 0.01312886f, 0.03833212f, -0.04124275f, 
    0.01497480f, 0.09306345f, 0.16148600f, 0.20945172f, 0.01793489f, 0.06519394f, 0.06255845f, -0.00683787f, 
    -0.05268595f, 0.01325391f, 0.04818086f, 0.06612129f, -0.13903356f, 0.01328081f, 0.09727276f, 0.03805705f, 
    -0.02248384f, -0.03262607f, 0.02449775f, 0.10235885f, 0.00995657f, -0.13261235f, 0.17389829f, -0.05550113f, 
    0.02756848f, -0.08383375f, 0.21121719f, 0.13538627f, 0.15323749f, 0.00362985f, 0.00939284f, -0.04960145f, 
    0.10292463f, 0.03807744f, -0.01889796f, -0.14481694f, -0.04191270f, 0.07920714f, -0.17557114f, 0.08616153f, 
    -0.03089815f, 0.10234594f, 0.01700569f, 0.08380131f, 0.02348837f, -0.01928679f, 0.02571130f, -0.00133081f, 
    -0.13777211f, 0.07895976f, -0.10155303f, -0.15394206f, 0.10805622f, -0.01959370f, -0.03598256f, -0.03120937f, 
    -0.03428154f, -0.02656248f, 0.06154421f, -0.01003436f, 0.03508214f, -0.07709502f, -0.01101171f, 0.20709279f, 
    0.03602404f, -0.04438397f, 0.01421364f, -0.05233832f, -0.01425631f, -0.01848952f, 0.12896129f, 0.14304304f, 
    -0.26063091f, -0.32954335f, -0.00629975f, -0.23449148f, -0.10656173f, -0.07117149f, -0.26070166f, 0.08264062f, 
    -0.04286332f, -0.06098895f, 0.01937626f, -0.07441028f, 0.12800799f, 0.12580979f, 0.06257854f, 0.34074354f, 
    0.09888466f, -0.01304821f, 0.07160598f, 0.00619241f, -0.00654168f, -0.01977851f, 0.01984020f, 0.29560515f, 
    -0.03557510f, -0.12931159f, 0.33990496f, -0.06077460f, -0.01371431f, 0.05915605f, 0.06173910f, 0.03709815f, 
    0.16629919f, -0.03835142f, -0.15130387f, 0.03797711f, -0.27711248f, -0.13163872f, 0.31953213f, 0.03908820f, 
    -0.13435815f, 0.20733997f, -0.32300037f, -0.21621639f, 0.04314959f, -0.01780522f, -0.09209149f, 0.12819529f, 
    -0.03732513f, -0.31707659f, -0.30674553f, -0.22760929f, -0.13544576f, -0.02328758f, -0.13081260f, -0.05181174f, 
    -0.02256266f, 0.14011303f, 0.10176367f, 0.24562848f, 0.11920930f, 0.23863667f, 0.13747063f, 0.24394011f, 
    0.02208732f, 0.10639191f, 0.05424234f, 0.08274441f, 0.06156208f, 0.04088179f, -0.03081155f, 0.03787682f, 
    -0.14374810f, 0.21473135f, 0.04105054f, -0.13041520f, 0.03762388f, -0.13984962f, 0.09200205f, -0.19922227f, 
    0.01863548f, -0.05460119f, 0.09690035f, -0.06242013f, 0.20695412f, 0.11467914f, 0.03281146f, 0.05526230f, 
    -0.07147694f, 0.06795955f, 0.04453437f, 0.02420201f, -0.07889861f, -0.04564362f, -0.19582428f, -0.19863933f, 
    0.07362645f, 0.11690210f, 0.15751474f, 0.22833157f, 0.02180486f, -0.02812097f, 0.04788399f, 0.18481116f, 
    0.07825343f, 0.00444255f, -0.11499590f, 0.04781827f, 0.15398420f, 0.14912830f, -0.25007749f, -0.07850935f, 
    -0.08475120f, -0.03688133f, -0.10497075f, -0.17644364f, 0.01147254f, 0.05901828f, 0.02226513f, 0.05928283f, 
    0.30085316f, 0.01783980f, 0.40349725f, 0.17331569f, 0.09311733f, 0.11301246f, 0.24039237f, -0.15714879f, 
    0.03718083f, 0.01509825f, -0.01307528f, 0.10891617f, 0.01053097f, 0.04585303f, -0.04760753f, 0.00180529f, 
    -0.07611706f, -0.02326030f, 0.12698984f, 0.04701375f, -0.13804610f, -0.08657229f, -0.14655243f, 0.11306722f, 
    0.28037864f, 0.11726493f, 0.15402457f, 0.03738173f, 0.15359968f, 0.10449610f, 0.11306920f, 0.07037850f, 
    0.10936290f, -0.10615876f, 0.00323808f, 0.25712860f, 0.21880347f, 0.00519371f, 0.24843991f, 0.07568785f, 
    -0.01142738f, -0.03166414f, -0.14001571f, 0.05052133f, -0.11721697f, -0.01951428f, 0.01367623f, 0.09699773f, 
    -0.24761473f, -0.46972606f, -0.39207926f, -0.12383654f, -0.04891425f, -0.04731520f, 0.03187294f, -0.02034670f, 
    -0.08832828f, -0.15697794f, 0.07856160f, -0.10477412f, -0.00954426f, 0.19747029f, 0.03566122f, 0.10477385f, 
    0.14115997f, 0.14323831f, 0.10512115f, 0.06410144f, -0.00232102f, -0.00730912f, -0.09434605f, 0.06751758f, 
    0.03898126f, 0.37997183f, 0.26112676f, -0.00407071f, -0.13424389f, -0.26374653f, -0.12380126f, -0.11329839f, 
    -0.09062719f, -0.01789862f, -0.07603703f, -0.08861465f, 0.06075386f, -0.24501112f, -0.27087283f, 0.01943270f, 
    -0.03298023f, 0.08496696f, 0.04813903f, -0.03741003f, -0.02133255f, 0.19935437f, -0.03143439f, 0.02563398f, 
    0.03460275f, 0.03734116f, 0.07874303f, 0.08460545f, 0.07749944f, 0.02263164f, 0.12884589f, 0.01196994f, 
    -0.06556094f, 0.05969192f, -0.06650058f, 0.10382379f, 0.03708420f, -0.00301739f, 0.19638462f, 0.10577573f, 
    0.03137403f, -0.00736539f, -0.02453475f, 0.01151875f, 0.07664298f, -0.07356714f, -0.02245915f, 0.10814667f, 
    -0.27156693f, 0.03924423f, -0.05229110f, -0.01223964f, -0.01349237f, -0.02121472f, -0.09396856f, -0.21165302f, 
    -0.01048531f, -0.12425394f, -0.12788758f, -0.00471154f, 0.11395220f, 0.23151486f, 0.09506202f, 0.01945114f, 
    0.12398346f, 0.08915599f, -0.01300266f, 0.03440470f, -0.04805508f, 0.00187193f, -0.12141404f, -0.12139418f, 
    0.11964379f, 0.37299916f, -0.27804145f, 0.11087583f, -0.11586701f, -0.07053808f, 0.13006079f, 0.01713532f, 
    -0.07457589f, 0.08352016f, 0.05304134f, -0.02482699f, 0.07901952f, -0.12192926f, -0.05157741f, 0.16319427f, 
    0.15880252f, 0.20238082f, 0.18470971f, -0.00744139f, 0.03297674f, 0.02375375f, 0.08018825f, 0.08519612f, 
    0.24922335f, 0.23847160f, -0.22297263f, -0.09200739f, 0.13422883f, 0.08170237f, 0.15640719f, 0.11525721f, 
    -0.01239426f, -0.04458112f, -0.17931919f, -0.03488177f, -0.17506742f, -0.13030794f, 0.01912387f, -0.01344718f, 
    -0.09706978f, -0.03002709f, 0.25404480f, 0.06673576f, 0.04528811f, 0.29633424f, 0.13178845f, -0.20416270f, 
    0.02654423f, -0.14786807f, -0.05979049f, 0.06743058f, 0.06101148f, 0.13062076f, 0.02603162f, 0.03721517f, 
    0.02770565f, 0.03611499f, 0.01174711f, 0.07404108f, -0.06645735f, 0.02150877f, 0.17895964f, 0.05212476f, 
    0.01445050f, 0.00618323f, 0.07219756f, -0.00596585f, 0.00083130f, 0.00082774f, 0.05957306f, 0.20905487f, 
    0.08422796f, 0.03289854f, -0.06804690f, 0.04510302f, -0.01584615f, 0.06724101f, -0.04848509f, 0.10415340f, 
    -0.04302134f, -0.01206474f, -0.08562889f, 0.01372054f, 0.09112799f, 0.04315037f, 0.16882361f, -0.15463100f, 
    0.17285280f, 0.04674169f, -0.04587508f, 0.14198400f, 0.00785613f, 0.00588684f, 0.03079310f, 0.00632571f, 
    0.02753207f, 0.21713153f, 0.01303675f, 0.02256240f, -0.18719354f, -0.11783944f, -0.12408218f, -0.09105843f, 
    0.03044991f, 0.03986003f, 0.21553662f, 0.03986708f, 0.08591760f, -0.14086987f, -0.17150946f, -0.09286501f, 
    0.20944151f, 0.09714771f, -0.10645580f, -0.01400412f, -0.00063816f, -0.06475707f, -0.06642244f, 0.13197854f, 
    0.14594039f, 0.11219475f, -0.06941284f, 0.11956064f, 0.05424802f, 0.05500422f, 0.01984865f, 0.02533747f, 
    -0.10339133f, -0.02565653f, 0.00205697f, -0.14931732f, -0.42397699f, -0.04893956f, -0.05978839f, -0.22878772f, 
    -0.03432787f, 0.05303660f, -0.13624513f, -0.02737684f, -0.09853776f, 0.10189933f, -0.01359517f, -0.07181201f, 
    0.38953948f, 0.20456940f, -0.09443624f, 0.09491929f, -0.03406463f, 0.08869480f, 0.06834356f, 0.16354772f, 
    -0.10922016f, 0.05439768f, -0.04860267f, -0.11075270f, 0.19994269f, -0.03647691f, 0.21295188f, -0.18842968f, 
    0.23314796f, -0.07104082f, 0.01343150f, 0.17641965f, 0.02803480f, 0.03782843f, 0.00077857f, 0.11020266f, 
    -0.00439944f, 0.03486468f, -0.07601911f, 0.04846223f, -0.06709415f, -0.13000476f, -0.00728967f, 0.04210525f, 
    -0.05281405f, -0.06628697f, -0.07811979f, -0.14647889f, 0.04753174f, 0.18647917f, 0.14136605f, -0.04181287f, 
    0.09195884f, 0.22813803f, 0.00070908f, 0.07094996f, 0.00827353f, 0.13161242f, -0.08077437f, -0.02363220f, 
    0.28326103f, -0.20434695f, -0.32018936f, -0.23889698f, -0.06849552f, -0.00130369f, 0.15686762f, 0.17348695f, 
    -0.02443227f, 0.05597644f, 0.14197636f, 0.02953780f, 0.14242533f, -0.06995483f, -0.21203910f, -0.08759511f, 
    0.02606170f, -0.05771608f, 0.02269007f, 0.14738463f, -0.03044667f, 0.01726567f, 0.04168209f, -0.07469801f, 
    0.28670201f, 0.17611924f, 0.01792202f, 0.00136904f, 0.02251335f, 0.05440153f, 0.02012315f, -0.01810482f, 
    -0.08655138f, -0.01975174f, 0.00284562f, -0.03577002f, -0.18157636f, 0.00219637f, 0.07644126f, -0.17738596f, 
    -0.00366877f, -0.00123936f, -0.01371059f, 0.07079753f, 0.15132304f, -0.04146480f, 0.04703523f, 0.03568623f, 
    0.17224224f, -0.16950800f, -0.20014520f, -0.10658159f, 0.04494003f, 0.04276086f, 0.00245002f, 0.08710934f, 
    -0.12044736f, 0.01781844f, 0.00341049f, -0.07552514f, 0.16433400f, -0.03567415f, 0.03223466f, -0.10440225f, 
    -0.10334514f, 0.17862128f, 0.07659077f, -0.01459845f, -0.07641421f, 0.02402655f, 0.07737822f, -0.07554077f, 
    0.17333810f, 0.17060615f, -0.00338461f, 0.02114546f, 0.00889823f, 0.09297368f, -0.09332001f, 0.02663620f, 
    -0.09097955f, 0.07313251f, -0.02541095f, -0.00501431f, -0.02561104f, 0.29796910f, 0.00601403f, -0.15787721f, 
    0.23147950f, -0.07149925f, 0.11489699f, -0.02831225f, 0.16339983f, -0.06385319f, 0.13155685f, -0.06430805f, 
    -0.04865940f, -0.10791732f, 0.09888308f, 0.12253835f, -0.08821587f, -0.03709795f, -0.03681522f, -0.10153440f, 
    0.02055124f, 0.14481798f, -0.09903552f, 0.00503892f, 0.08362784f, 0.10337546f, 0.04431125f, -0.12983549f, 
    0.03353806f, -0.13794686f, 0.02814110f, 0.06986311f, -0.12704089f, 0.05403646f, 0.03235561f, 0.02287199f, 
    -0.26776570f, -0.13055374f, -0.08478315f, -0.07894951f, 0.02595896f, 0.05424131f, -0.02074820f, 0.01948001f, 
    0.01706203f, -0.05395392f, 0.10307278f, 0.03717663f, 0.35854930f, 0.39444950f, 0.17521340f, 0.22617719f, 
    0.04383652f, 0.04060012f, 0.08303700f, -0.06738605f, -0.12759492f, 0.00750841f, -0.09444895f, 0.11340509f, 
    -0.03773940f, 0.24495395f, 0.06055948f, -0.06965040f, -0.05870896f, 0.16797216f, 0.02237715f, 0.14009492f, 
    -0.02641044f, 0.15232275f, 0.05027584f, 0.07704982f, -0.23064698f, 0.25799650f, -0.10210427f, 0.03848533f, 
    -0.07929479f, -0.09777204f, 0.19858970f, -0.09638814f, -0.19427659f, -0.00718661f, -0.10122585f, 0.01281446f, 
    -0.00766951f, -0.08026438f, -0.11342063f, -0.00685154f, 0.06536871f, -0.02861286f, 0.00444871f, 0.11573598f, 
    -0.10821352f, 0.10825375f, -0.01953397f, 0.00603647f, 0.22183707f, 0.14740187f, -0.17485145f, 0.14837712f, 
    -0.04887122f, 0.25044635f, 0.04770240f, 0.12704846f, 0.03576458f, 0.10891686f, 0.03795038f, 0.02273679f, 
    -0.37950698f, 0.08653015f, -0.37345442f, 0.24449904f, -0.03384862f, 0.03024205f, -0.13572598f, -0.03984531f, 
    -0.08363497f, -0.00617269f, 0.05201501f, -0.01847009f, 0.08599841f, 0.13263057f, 0.06689452f, 0.06038369f, 
    0.03904402f, 0.11409252f, 0.08792694f, 0.09588676f, -0.03782094f, 0.06923761f, -0.01606101f, -0.05367924f, 
    0.02466374f, -0.02801891f, -0.17188832f, -0.07444093f, 0.20865834f, 0.09740554f, 0.01359499f, 0.10844473f, 
    0.03109602f, 0.03556439f, -0.01753563f, 0.03935771f, 0.08218703f, 0.05150340f, 0.04679528f, -0.04305470f, 
    -0.05841175f, -0.11881468f, 0.13332421f, -0.20710628f, 0.12009444f, 0.16991892f, 0.11916938f, 0.11866608f, 
    0.35698095f, 0.24764659f, 0.09547476f, 0.18336529f, -0.02837597f, 0.02328198f, 0.06280668f, -0.11450372f, 
    0.04069369f, 0.04671828f, -0.02707048f, -0.04631853f, -0.21459252f, -0.20971645f, -0.11064708f, -0.14618964f, 
    -0.06519642f, 0.06480660f, 0.27548113f, 0.04848055f, -0.03703978f, -0.01149088f, 0.03125547f, 0.03458126f, 
    0.08353820f, -0.03194083f, 0.14227699f, -0.05896608f, 0.11288356f, -0.01207578f, -0.04245475f, 0.00423458f, 
    0.11763600f, 0.16589440f, -0.10237905f, 0.00112564f, 0.03764356f, 0.14961149f, -0.12452447f, -0.00466961f, 
    0.00565164f, 0.04083008f, -0.18214825f, 0.14671826f, -0.13313514f, 0.01119088f, -0.07768880f, 0.11859007f, 
    -0.17876141f, -0.15310876f, -0.16395220f, -0.21118674f, 0.05306352f, 0.05476294f, 0.05867754f, 0.04330407f, 
    -0.09097808f, -0.06659093f, 0.14926958f, -0.02896943f, -0.16092516f, -0.18300134f, -0.22486959f, -0.01028173f, 
    0.08853097f, -0.00436450f, 0.17028284f, 0.18580672f, -0.03244932f, -0.05567648f, -0.06755701f, 0.01443190f, 
    -0.01074821f, -0.25134915f, -0.01364885f, 0.21153629f, 0.00961955f, 0.10861175f, 0.06904104f, 0.09285150f, 
    -0.00407341f, -0.07539276f, -0.04369267f, -0.05394454f, -0.35747641f, 0.30800283f, 0.37919810f, 0.06258736f, 
    0.02412072f, -0.12950629f, 0.01554410f, 0.00921759f, 0.11840744f, 0.04865890f, 0.08273979f, 0.07025976f, 
    -0.00035124f, -0.09657157f, 0.18169491f, -0.07300288f, -0.00540399f, 0.01698397f, -0.03757146f, -0.00180217f, 
    0.00540783f, -0.04668331f, -0.04887815f, -0.06737632f, 0.45951664f, 0.24331246f, -0.05021749f, 0.16863066f, 
    0.01452194f, 0.04910014f, 0.04427278f, 0.05701278f, -0.00985189f, 0.01353549f, 0.08303180f, 0.06532660f, 
    -0.12251069f, -0.14127766f, -0.10876580f, 0.04817052f, 0.05761040f, 0.10756383f, 0.00899657f, 0.02413943f, 
    0.10069585f, 0.01323784f, 0.26947501f, 0.08390283f, -0.24797367f, -0.00562416f, -0.07345956f, -0.05668370f, 
    -0.06907374f, -0.02196661f, 0.03651713f, -0.01820521f, 0.09012290f, 0.00459503f, 0.02564874f, 0.01135207f, 
    -0.13422439f, -0.20784418f, 0.09779602f, -0.19249421f, 0.16029303f, -0.00179577f, 0.01790283f, 0.06811839f, 
    0.10408743f, 0.05698816f, -0.07289513f, -0.06075317f, 0.01978103f, -0.11655357f, -0.06593086f, -0.28904629f, 
    0.02359710f, 0.00434524f, -0.04867134f, -0.03075137f, 0.02561747f, -0.00539740f, -0.12526932f, -0.09571428f, 
    -0.38721031f, -0.10971826f, 0.30179098f, -0.01770946f, -0.01672248f, -0.01226481f, 0.10328928f, -0.06108347f, 
    -0.02370689f, 0.05407748f, 0.11390942f, 0.03631215f, 0.08614538f, -0.04654031f, -0.22021180f, 0.12086133f, 
    0.13866816f, 0.07320914f, 0.14030737f, 0.02446402f, 0.08698818f, 0.09527168f, 0.01140440f, 0.04366420f, 
    -0.09200313f, 0.14316893f, 0.09413299f, -0.32508659f, 0.06516253f, -0.05698268f, 0.02739267f, 0.13005295f, 
    -0.00612926f, 0.07711399f, 0.00978233f, 0.01786603f, -0.02918370f, -0.10766514f, -0.14912798f, -0.02746191f, 
    0.22935058f, 0.10467947f, -0.05121190f, 0.16750059f, -0.09265463f, -0.07381851f, -0.06079184f, 0.04108780f, 
    -0.12959819f, 0.16854623f, 0.18716934f, -0.26061061f, -0.00266910f, -0.00927904f, 0.08381424f, 0.11459847f, 
    0.08637293f, 0.10627107f, 0.06644700f, -0.00502003f, -0.15853284f, -0.21756963f, 0.23221874f, 0.35475317f, 
    -0.14955015f, 0.07014278f, 0.00538420f, 0.00105356f, -0.07465034f, 0.09539492f, 0.01672004f, 0.08575280f, 
    -0.13196482f, -0.18898611f, -0.14804807f, 0.05616512f, 0.12945454f, 0.02068917f, -0.02448799f, -0.09941733f, 
    -0.03946191f, 0.00524307f, 0.07818008f, -0.05711359f, -0.05232256f, 0.13128109f, 0.10964739f, -0.11520471f, 
    0.07905966f, 0.05084557f, -0.00552785f, -0.14184248f, -0.03126679f, -0.03138483f, -0.06447867f, -0.03084912f, 
    -0.33059427f, -0.38136312f, -0.15937264f, -0.04260848f, 0.08915070f, -0.01639356f, -0.03505236f, -0.08374201f, 
    -0.04351082f, -0.13188909f, 0.11467159f, 0.09712572f, 0.03353778f, -0.02730167f, 0.10006978f, -0.01939682f, 
    0.07474255f, -0.12644386f, 0.00241867f, 0.10538903f, 0.08286820f, -0.07755607f, -0.14191930f, 0.00313603f, 
    0.21835162f, 0.07531895f, -0.17620794f, -0.01018161f, -0.02934201f, 0.00650984f, -0.00033755f, -0.06040428f, 
    0.04078175f, 0.00048518f, 0.05577036f, 0.03563610f, -0.03795670f, 0.11036889f, -0.16346239f, -0.03920231f, 
    -0.01288415f, 0.00042536f, 0.10504626f, -0.01096763f, 0.00096646f, -0.08481596f, -0.07412983f, 0.09118301f, 
    -0.07397357f, -0.17947121f, -0.20654613f, -0.00510242f, -0.02197592f, -0.04096137f, -0.07521905f, -0.03729352f, 
    -0.15185112f, -0.15020479f, -0.02577375f, -0.11235532f, -0.07239347f, -0.02371847f, -0.04849511f, -0.04011104f, 
    0.05339333f, -0.04637598f, 0.00918017f, 0.05710332f, -0.00401465f, 0.02997411f, 0.01597882f, 0.01216184f, 
    0.32258320f, -0.21060203f, 0.33690929f, -0.18438555f, 0.12223351f, 0.07188468f, -0.14554331f, 0.15858382f, 
    0.01541981f, 0.04170784f, -0.08794562f, 0.10629950f, 0.11265738f, 0.01923546f, 0.13163851f, 0.08943944f, 
    0.23192447f, 0.05568991f, 0.11306118f, 0.09705442f, 0.09145933f, -0.00199966f, 0.01950328f, 0.11867356f, 
    0.01420233f, 0.04971038f, 0.19489521f, 0.00578970f, -0.03057988f, 0.08418528f, 0.06974247f, 0.08542166f, 
    0.06544533f, 0.07306941f, 0.14654696f, 0.06663776f, -0.08980431f, -0.21957767f, -0.09990800f, -0.01733555f, 
    0.05640324f, 0.05811907f, 0.18694107f, 0.00738757f, -0.00126891f, 0.07795762f, 0.01091644f, 0.15485503f, 
    0.19313474f, 0.03620921f, -0.15316509f, -0.03697672f, 0.11095855f, -0.02862399f, -0.11733551f, 0.04253060f, 
    0.04435696f, 0.02924981f, -0.03896029f, 0.00360305f, -0.13039137f, -0.18748561f, -0.11547326f, -0.08810943f, 
    0.14825378f, 0.06377794f, -0.12042896f, 0.12605917f, 0.08474924f, -0.09499005f, 0.07944411f, -0.10493492f, 
    0.10034692f, 0.05347219f, 0.02166177f, 0.05464074f, 0.22166911f, -0.02859505f, 0.03285793f, 0.00351533f, 
    -0.14421168f, -0.08143682f, 0.24066029f, -0.13929255f, -0.04584930f, 0.07380626f, -0.10133937f, -0.02503558f, 
    -0.16245355f, 0.16530536f, 0.12010466f, -0.07940993f, 0.00064459f, -0.04930528f, 0.00527547f, -0.01670629f, 
    -0.02332336f, 0.16213155f, 0.06315648f, 0.01764761f, 0.05182447f, -0.14883225f, -0.05569627f, -0.03515865f, 
    0.06973529f, 0.06941967f, -0.12040233f, 0.05686118f, 0.15058003f, 0.26488030f, 0.08004008f, 0.10569263f, 
    0.10489407f, 0.01510122f, 0.03802650f, -0.04331060f, -0.00162610f, -0.05292423f, -0.03750224f, 0.07121589f, 
    0.21985108f, 0.03145519f, 0.18766208f, 0.25258631f, 0.06945906f, -0.01643489f, 0.03855141f, 0.00878665f, 
    0.01866170f, 0.07870220f, 0.09579687f, -0.01602608f, 0.17177975f, -0.33457339f, -0.17951450f, -0.13210171f, 
    -0.02955232f, -0.08194143f, -0.05366643f, -0.04046988f, 0.06641020f, 0.01388437f, -0.02943901f, -0.11383659f, 
    -0.21764964f, -0.53290033f, -0.36117351f, -0.48862553f, 0.22760351f, -0.08332051f, -0.05464644f, 0.01734555f, 
    0.10344495f, 0.06174524f, 0.15549029f, -0.03982025f, -0.00050228f, 0.28127909f, -0.08688027f, -0.07484323f, 
    -0.05902084f, 0.02404314f, 0.15723312f, 0.13396908f, 0.11970149f, 0.00367872f, -0.03586801f, -0.01796299f, 
    0.20659773f, 0.18284157f, 0.08730370f, -0.04311465f, -0.05021557f, 0.07435533f, -0.05320209f, 0.03782614f, 
    0.34975439f, 0.03146397f, -0.04412958f, 0.05128476f, -0.41969216f, -0.40569070f, -0.14298072f, -0.28016436f, 
    -0.01538964f, 0.17993794f, -0.02441998f, 0.10368124f, -0.08812419f, -0.19333039f, -0.12988576f, 0.10728395f, 
    0.00474198f, -0.10007870f, -0.00132956f, -0.19719264f, 0.11827867f, 0.10751127f, 0.34273052f, -0.10685059f, 
    0.04330371f, 0.15556104f, -0.10967103f, 0.04019976f, -0.11661859f, -0.14367174f, -0.09667204f, -0.04473618f, 
    0.03872500f, 0.11764721f, 0.19128072f, 0.08244506f, -0.04383998f, 0.03228602f, 0.10395995f, 0.01263032f, 
    -0.04979701f, -0.22212966f, -0.31858766f, -0.21908472f, 0.10235199f, -0.09796248f, -0.06536544f, 0.05781433f, 
    -0.08844687f, -0.07945829f, -0.02183140f, -0.01784153f, 0.07947444f, -0.01586236f, -0.05997237f, -0.05022148f, 
    -0.04524490f, -0.01594064f, -0.10741824f, 0.01844430f, -0.05933866f, 0.04026054f, 0.09568166f, 0.08615135f, 
    0.14611669f, -0.21195529f, -0.31376824f, -0.09654211f, -0.02984350f, -0.02178636f, 0.10233304f, 0.17535903f, 
    0.23259200f, 0.03237439f, -0.06660838f, 0.02557017f, 0.01854075f, 0.07390666f, -0.10721448f, 0.06300764f, 
    0.12234762f, -0.05432149f, 0.18542193f, -0.34799871f, -0.03847419f, -0.00929087f, 0.01700668f, 0.07877980f, 
    -0.16528551f, -0.19080642f, 0.12563637f, -0.08387300f, 0.00283756f, 0.10815693f, -0.00442618f, 0.16737038f, 
    -0.11325330f, -0.16746229f, 0.13441759f, -0.00047491f, -0.03976086f, -0.22473642f, -0.02940166f, -0.38667759f, 
    -0.27047163f, -0.04168678f, -0.16958125f, 0.11618561f, -0.05553856f, -0.05027578f, 0.06007990f, -0.30407393f, 
    0.27165538f, 0.27629071f, 0.19486539f, 0.11043306f, -0.04305358f, 0.08350834f, -0.03669357f, -0.04206499f, 
    0.14765936f, 0.06543844f, 0.03158961f, 0.07691370f, -0.13434249f, -0.04321718f, -0.04437555f, -0.00593966f, 
    0.21064885f, 0.17985080f, -0.05263920f, 0.12098971f, -0.00578887f, -0.17864512f, 0.01489082f, 0.09606601f, 
    0.02685940f, -0.04823607f, 0.01962085f, -0.07248344f, -0.01319835f, -0.00474394f, -0.05561276f, 0.02161294f, 
    0.02231254f, -0.06875874f, -0.04884045f, 0.05080706f, 0.00738869f, 0.06586365f, -0.01217352f, 0.05402777f, 
    0.06250539f, 0.05822856f, -0.07042688f, -0.00966585f, -0.07013441f, -0.00094329f, 0.00421722f, -0.00026747f, 
    -0.06380577f, -0.07555886f, 0.06306318f, 0.00536131f, -0.00735413f, 0.02331441f, 0.00232965f, 0.02576747f, 
    -0.02554204f, 0.03460075f, -0.02468849f, -0.06022801f, -0.00228855f, -0.05447845f, -0.00401038f, -0.02082358f, 
    -0.03405672f, -0.00984892f, -0.05989915f, 0.06557156f, -0.03207201f, 0.03547829f, 0.05309368f, -0.01765253f, 
    -0.00368659f, -0.00427804f, -0.00525703f, -0.06243515f, -0.05239290f, -0.05926944f, 0.00131082f, 0.02914844f, 
    -0.06783773f, 0.02546639f, 0.03459790f, 0.03003146f, 0.02558762f, -0.02021804f, -0.00620016f, -0.03628679f, 
    -0.07080296f, -0.01271395f, -0.02212920f, -0.04349045f, 0.00821712f, 0.00816881f, 0.04235785f, -0.03987276f, 
    0.01058626f, 0.00148823f, -0.01940494f, -0.05252555f, 0.05525589f, 0.00628571f, -0.05144276f, -0.06737905f, 
    -0.02906839f, -0.06604089f, 0.01659835f, 0.04982479f, -0.01724691f, 0.06486515f, 0.00300747f, 0.06045754f, 
    0.01131160f, -0.00331847f, -0.02127440f, 0.04380158f, -0.01690340f, -0.04801187f, -0.01157848f, -0.04033960f, 
    0.02548827f, -0.01611109f, -0.00922882f, -0.06623938f, 0.01172149f, -0.07305188f, 0.02533348f, -0.03750798f, 
    -0.05186165f, 0.00437236f, 0.06877606f, -0.06349219f, -0.03166630f, -0.01017638f, -0.04690154f, -0.05254960f, 
    0.00994660f, 0.02386805f, 0.02111962f, -0.07160608f, 0.02005278f, -0.01270090f, 0.05319500f, 0.00233657f, 
    -0.03967189f, 0.04540870f, -0.00818699f, 0.04206383f, -0.07608601f, -0.03233878f, 0.01688666f, 0.05404555f, 
    -0.03801883f, -0.06906227f, 0.01003756f, 0.00752886f, 0.02378196f, -0.02124882f, -0.03614779f, -0.04852479f, 
    -0.06205710f, 0.06536343f, -0.03869848f, -0.03825865f, 0.04587999f, -0.06460023f, -0.05428191f, -0.04742181f, 
    0.00806074f, -0.03717284f, 0.05093113f, -0.06677520f, -0.05784041f, 0.05493366f, 0.00572680f, 0.04950396f, 
    0.06534611f, -0.04092173f, -0.05851165f, -0.07681833f, 0.05135624f, -0.05540477f, -0.05678830f, -0.06148760f, 
    -0.00659870f, -0.03892313f, -0.03140552f, -0.04590577f, -0.00031400f, -0.00423013f, -0.04075818f, -0.07503674f, 
    -0.03434318f, 0.00115867f, -0.04732918f, -0.01822207f, 0.02059847f, 0.02294418f, -0.04515854f, 0.00643463f, 
    -0.03777409f, -0.02911351f, 0.05754562f, -0.05441783f, -0.03852515f, -0.01790050f, -0.06208888f, -0.06022021f, 
    -0.00717416f, -0.02903407f, 0.01852029f, -0.02228693f, -0.03803309f, 0.06268546f, 0.03986446f, -0.07013471f, 
    -0.00945075f, 0.19618858f, 0.02827009f, -0.07350952f, 0.00882980f, -0.08988512f, 0.07205342f, -0.02917652f, 
    -0.05561839f, 0.08879231f, 0.01851861f, 0.06749884f, 0.46067268f, -0.25051868f, -0.13075116f, 0.06287617f, 
    -0.12105222f, -0.00522657f, 0.06701047f, 0.12823470f, -0.05805477f, 0.00720902f, -0.08482597f, -0.09476307f, 
    -0.08205424f, 0.18126968f, -0.04751826f, -0.01971672f, 0.13575783f, -0.04275543f, 0.08677566f, -0.00358740f, 
    -0.02313031f, 0.12131423f, -0.09097057f, 0.02497766f, -0.49919415f, 0.12692197f, -0.11035451f, -0.04197482f, 
    -0.00964867f, 0.03444686f, -0.03018064f, 0.13390715f, 0.03223364f, -0.04745636f, 0.05053918f, 0.01206970f, 
    0.01533360f, 0.04315531f, 0.10006407f, -0.12367422f, 0.05764851f, -0.01225224f, -0.02330568f, -0.03849817f, 
    -0.12510380f, -0.00135898f, -0.11190616f, -0.07710789f, 0.09035051f, 0.06668622f, 0.02149975f, 0.10223459f, 
    0.12588814f, 0.16257718f, -0.04017771f, 0.01277405f, -0.10253466f, -0.07822079f, -0.10956980f, -0.14443129f, 
    0.17948595f, 0.31762418f, -0.00635526f, 0.15036039f, -0.06511591f, 0.03358641f, 0.08206031f, -0.06295918f, 
    0.02868386f, -0.06875388f, 0.02180410f, -0.01992078f, -0.02161385f, 0.07026641f, 0.11285572f, 0.17706899f, 
    -0.02848235f, 0.12380259f, 0.07858659f, 0.02652618f, -0.05029378f, 0.02345717f, 0.13664061f, 0.13879335f, 
    0.19847699f, -0.11321002f, -0.27095306f, 0.07051413f, -0.02560388f, 0.06713013f, -0.05349496f, 0.13277242f, 
    -0.08919137f, -0.08481450f, -0.16393298f, -0.01248439f, 0.04148111f, -0.08207527f, 0.03859382f, -0.11456406f, 
    0.00503940f, 0.05675042f, 0.03690757f, 0.11193378f, -0.10799427f, 0.05313751f, 0.14473923f, -0.12131013f, 
    0.32982340f, -0.05105893f, 0.02590171f, 0.34560996f, -0.03058941f, 0.16747336f, 0.01926462f, 0.12120913f, 
    0.16007945f, 0.02260142f, 0.11809875f, 0.11234482f, 0.02715877f, 0.04697100f, 0.02161533f, 0.01425665f, 
    -0.04277851f, 0.07454422f, 0.15145718f, -0.09633448f, -0.05576067f, -0.06000313f, 0.00297142f, 0.02227368f, 
    0.20880066f, -0.21433969f, 0.03300767f, 0.31485617f, 0.07989705f, 0.03043109f, 0.08271292f, -0.05393723f, 
    -0.14926559f, 0.01574642f, -0.02862697f, 0.02782160f, 0.19096102f, 0.39741731f, -0.21918482f, -0.23399329f, 
    -0.09986593f, 0.01623910f, -0.06857766f, 0.20909536f, 0.05843415f, 0.07990815f, -0.01116056f, -0.33811152f, 
    0.03225887f, 0.16966935f, 0.22789997f, -0.08303240f, -0.11983684f, -0.07649971f, -0.02983603f, -0.04050671f, 
    0.02092951f, 0.06209065f, 0.12642239f, 0.11443537f, -0.00680256f, -0.13465762f, -0.10379402f, 0.14785452f, 
    -0.05828971f, 0.03134994f, -0.13933700f, 0.01756779f, -0.00054144f, -0.08848058f, -0.01226268f, 0.20407678f, 
    0.03744667f, -0.00842746f, -0.01999390f, 0.18293256f, -0.04461474f, 0.10409503f, 0.03533799f, -0.06338722f, 
    0.02082890f, 0.00580829f, -0.00178134f, 0.00146367f, 0.09159005f, 0.27671099f, 0.16859892f, -0.06140561f, 
    -0.00768829f, -0.03524429f, -0.11249804f, 0.04037422f, -0.14944851f, 0.00273090f, 0.14816147f, 0.08151141f, 
    -0.06489608f, 0.29332486f, 0.11763153f, -0.04885695f, 0.03992684f, -0.00056108f, -0.01509652f, 0.04781294f, 
    -0.01594942f, -0.05873863f, -0.00499605f, -0.10184520f, 0.07031672f, 0.32006139f, -0.24883495f, 0.00940984f, 
    0.00669038f, -0.03963081f, 0.03601404f, -0.02844751f, 0.11970370f, 0.14184879f, 0.03992032f, 0.10593877f, 
    0.12400690f, 0.13825116f, 0.07634838f, -0.07017563f, -0.08819173f, -0.11069443f, -0.07572853f, -0.14057100f, 
    0.09316254f, 0.09937579f, -0.01802944f, -0.01535403f, 0.03808850f, 0.09636152f, -0.03122206f, 0.07631511f, 
    -0.10322025f, 0.06977019f, 0.03141322f, -0.04566913f, -0.05772473f, 0.11556155f, -0.09387497f, -0.05337203f, 
    -0.41719791f, 0.30116737f, -0.32003376f, 0.37774444f, 0.09294799f, 0.02422869f, -0.12880069f, -0.03978226f, 
    -0.01710516f, -0.08866949f, 0.16516960f, 0.03519665f, 0.05314676f, -0.00316342f, 0.15935072f, 0.08085859f, 
    0.02544542f, 0.02688801f, 0.12238262f, 0.00146137f, -0.15737712f, 0.06876444f, 0.07594110f, -0.04422660f, 
    -0.10926238f, -0.12241182f, -0.05605406f, 0.18931635f, -0.01880538f, -0.00646801f, -0.06661191f, -0.16462624f, 
    -0.13488552f, 0.08635839f, -0.03481849f, -0.03446437f, 0.15256451f, 0.02878887f, -0.06472074f, -0.06987515f, 
    0.04826198f, 0.14261533f, -0.13007882f, 0.17144854f, -0.11141205f, 0.00405101f, 0.02056732f, -0.08551532f, 
    0.28750777f, 0.31034714f, 0.20731682f, 0.15823469f, -0.06132625f, -0.02722348f, 0.18469197f, -0.13686022f, 
    0.10478549f, -0.00266311f, 0.20984565f, -0.09984184f, 0.14062616f, -0.01638394f, 0.11998380f, -0.12181730f, 
    0.01747495f, 0.07521572f, 0.21403509f, -0.23556443f, -0.07180338f, 0.05090366f, 0.02083129f, 0.02090309f, 
    0.04451328f, -0.05264489f, 0.09895267f, 0.02753678f, 0.00182965f, -0.03169259f, -0.07935362f, -0.03676971f, 
    0.00874687f, 0.02271907f, -0.09515493f, -0.08914021f, -0.19223291f, 0.17589836f, -0.19683348f, -0.03924932f, 
    -0.02072045f, -0.17349011f, -0.00328799f, 0.04566886f, -0.14441377f, 0.08558798f, 0.10132400f, 0.04046392f, 
    0.06452665f, 0.07759992f, 0.18714853f, 0.13226098f, -0.09444931f, 0.00806336f, -0.00173879f, -0.01773561f, 
    -0.00445746f, -0.08754636f, 0.06897541f, 0.06325217f, -0.22426274f, -0.17257704f, -0.09530195f, -0.04827597f, 
    -0.08364507f, 0.03164962f, 0.12191071f, 0.06847052f, 0.10763223f, -0.01479816f, 0.04531507f, -0.04900926f, 
    0.06100731f, 0.15273100f, -0.13424961f, 0.15628543f, -0.11940181f, 0.03951608f, -0.15167485f, -0.03719483f, 
    -0.04801119f, -0.00884511f, -0.11480515f, 0.01020474f, 0.02653941f, 0.00113199f, 0.03227650f, -0.06415189f, 
    -0.05019520f, 0.01369915f, -0.10210319f, -0.06102041f, -0.18136537f, 0.07049412f, 0.13526227f, 0.01026170f, 
    -0.31135616f, 0.20014578f, 0.03013476f, 0.18561485f, 0.01886805f, 0.07734358f, 0.10177605f, -0.04346972f, 
    -0.05025353f, -0.01236648f, 0.01876153f, -0.05609586f, 0.48369682f, 0.08791839f, -0.10160290f, -0.02436703f, 
    -0.09998766f, 0.05257294f, 0.06431253f, -0.00774698f, -0.03523676f, 0.05992417f, 0.00424794f, -0.07552567f, 
    -0.01048121f, 0.05017430f, -0.03449512f, 0.02479985f, -0.04317399f, -0.00911130f, -0.01935728f, 0.00225731f, 
    0.08915015f, 0.18923445f, 0.07253655f, -0.00355997f, 0.20833321f, -0.20912534f, 0.04718818f, 0.04073432f, 
    0.00503910f, -0.10719661f, 0.21179408f, -0.06148309f, -0.01573636f, 0.05385903f, 0.07476614f, -0.00262905f, 
    -0.37358809f, 0.27189684f, -0.31032735f, 0.48442718f, 0.02300822f, 0.03957182f, -0.10423446f, 0.17946830f, 
    -0.01088120f, -0.08707038f, -0.06155394f, 0.04471376f, -0.04880324f, 0.09522507f, 0.04047402f, 0.10963647f, 
    -0.09753793f, 0.05849907f, -0.02275745f, 0.16902277f, 0.03471063f, 0.01392207f, 0.06536994f, -0.05862345f, 
    -0.21917060f, -0.09751496f, -0.15685090f, 0.15257007f, 0.04371075f, 0.04340049f, -0.05265465f, -0.20670556f, 
    -0.09331828f, 0.06396935f, 0.12592623f, -0.00826733f, -0.00885852f, -0.02571401f, 0.02030347f, 0.00165135f, 
    -0.02250622f, 0.02156571f, -0.06080183f, 0.08890517f, 0.11870371f, -0.02041103f, -0.11498763f, 0.02837542f, 
    -0.19681908f, 0.19417858f, 0.07305052f, 0.10633808f, -0.00604778f, -0.04114222f, 0.15101568f, 0.12687311f, 
    -0.03020330f, 0.11017120f, -0.01640909f, 0.03108755f, 0.11571105f, -0.10499679f, 0.18487895f, 0.01199314f, 
    -0.04516569f, 0.01920623f, 0.11209651f, 0.05978867f, -0.02619087f, 0.05163884f, -0.04943062f, -0.05690748f, 
    -0.08719497f, -0.07496905f, 0.07663260f, 0.07782680f, -0.01905659f, -0.07668104f, 0.10548281f, 0.03640619f, 
    0.09960354f, 0.12542568f, 0.00494366f, 0.05308235f, -0.21514010f, -0.07146927f, -0.04599166f, 0.22092964f, 
    0.10279053f, -0.05638615f, -0.03221713f, -0.14536677f, -0.06958435f, 0.01876771f, 0.09336929f, 0.01522808f, 
    -0.02760253f, -0.04213238f, 0.05826719f, -0.15311790f, 0.04808583f, 0.01309389f, 0.02307216f, -0.04459421f, 
    -0.08533364f, -0.00188118f, 0.01655713f, 0.00497954f, -0.09374658f, -0.17291105f, 0.02121973f, 0.08949015f, 
    -0.01921301f, -0.05463881f, 0.07837246f, -0.01885448f, 0.10945119f, 0.01904469f, 0.11344424f, 0.04336284f, 
    -0.07946806f, 0.00448839f, -0.02309192f, 0.02320031f, 0.05372934f, -0.07903022f, -0.07831651f, 0.03696356f, 
    -0.03222951f, 0.05441288f, -0.02842786f, 0.00525327f, -0.03947696f, -0.00143914f, 0.03325678f, 0.02946225f, 
    -0.07849307f, -0.04256193f, 0.01139276f, 0.00272216f, -0.06940932f, -0.04986527f, -0.00117234f, 0.04815751f, 
    -0.03485420f, 0.01419169f, -0.04886751f, -0.04217334f, -0.02990731f, 0.05614771f, -0.07077005f, 0.01353016f, 
    0.00888242f, 0.00903485f, -0.06314045f, 0.01713833f, 0.05598522f, 0.04358320f, -0.03815426f, -0.05860515f, 
    -0.06300025f, 0.00016555f, -0.07488321f, 0.04534925f, 0.03775488f, 0.06297736f, -0.04162095f, -0.06096593f, 
    0.05940956f, -0.02854138f, 0.04164257f, -0.03345100f, -0.07860495f, -0.00922614f, 0.05380625f, -0.00232077f, 
    -0.05863966f, -0.06065716f, 0.03156853f, -0.01623830f, -0.00566203f, 0.06857281f, 0.03033532f, 0.00231217f, 
    -0.05473969f, 0.04272795f, -0.02916940f, -0.03193522f, -0.05577428f, 0.05597032f, 0.05097954f, -0.05597775f, 
    -0.06060721f, 0.01411359f, -0.06065627f, -0.03466801f, 0.00622777f, -0.04079393f, -0.01648115f, 0.06360085f, 
    -0.02482756f, -0.02409464f, 0.02614909f, -0.00447652f, -0.03529976f, -0.01167036f, -0.07065981f, -0.01848108f, 
    -0.00663764f, -0.01577669f, -0.06003232f, -0.04202626f, -0.05924437f, -0.01599478f, -0.02159079f, -0.02030113f, 
    0.04187623f, 0.04189921f, 0.01711379f, -0.07030880f, -0.07144321f, -0.06333455f, -0.04674022f, -0.02833501f, 
    -0.02217710f, 0.00159577f, -0.06325237f, -0.03740423f, -0.02175252f, 0.02268996f, 0.03923849f, 0.05190197f, 
    0.01824796f, 0.04033375f, 0.01501662f, 0.01058422f, -0.01422664f, 0.00772452f, -0.01903871f, -0.06826093f, 
    -0.04622076f, -0.05590201f, 0.05898902f, 0.06271087f, -0.06632980f, 0.06003086f, -0.04077883f, -0.06748101f, 
    0.03381401f, -0.06272679f, 0.00823550f, -0.05488189f, -0.06195617f, 0.01911694f, -0.00145771f, 0.02827924f, 
    -0.01819799f, 0.03249379f, -0.05643245f, -0.03472988f, -0.07726040f, -0.02688415f, 0.00349268f, -0.03106117f, 
    -0.03305614f, 0.04892178f, -0.01477474f, -0.01136188f, -0.04546218f, -0.04161845f, -0.03631711f, 0.03223050f, 
    -0.02186897f, 0.00301480f, -0.01976816f, -0.03803411f, -0.04844465f, 0.04760320f, 0.04478278f, -0.03506280f, 
    -0.00477678f, -0.06118657f, -0.07060851f, 0.02362703f, 0.05146281f, -0.00427760f, -0.02317483f, -0.00197442f, 
    -0.00038842f, -0.00565245f, 0.05876484f, -0.02216802f, -0.05445952f, 0.03102691f, 0.00350910f, 0.01162600f, 
    -0.04382431f, 0.02538749f, -0.07836501f, -0.05118940f, 0.00985908f, -0.01753456f, -0.07564536f, 0.04362410f, 
    0.04456559f, 0.06094279f, -0.03051972f, 0.04622576f, 0.02392009f, 0.04784184f, 0.05931423f, 0.04673260f, 
    0.02852516f, 0.07666172f, -0.03325048f, 0.02988550f, 0.04720883f, 0.04721025f, 0.02478417f, 0.06653085f, 
    -0.03735216f, 0.03236231f, 0.03797207f, -0.06313212f, 0.24110661f, -0.12203499f, -0.06218264f, 0.07056052f, 
    -0.01893735f, 0.05580541f, 0.06640189f, -0.01552248f, -0.04655014f, -0.05040240f, 0.02113133f, -0.04125458f, 
    0.02253250f, 0.05624493f, -0.02859689f, -0.11063521f, 0.03571042f, 0.05377567f, -0.02841355f, 0.05103958f, 
    -0.04727926f, -0.01219170f, -0.00462495f, -0.06703692f, 0.04093962f, -0.08269066f, -0.00086462f, -0.04299231f, 
    0.02736508f, 0.13658644f, -0.02269797f, 0.11208230f, -0.14469227f, -0.05793858f, 0.11161955f, -0.05141127f, 
    -0.08452472f, 0.04122456f, 0.00685246f, 0.05970404f, 0.01431545f, -0.03016637f, -0.00183795f, -0.02153841f, 
    0.08393687f, 0.13294166f, 0.04928358f, -0.05269013f, -0.03840508f, -0.09935524f, -0.12195097f, -0.14862183f, 
    0.02413822f, 0.05309214f, -0.01022592f, 0.02563949f, -0.07539736f, -0.04072617f, -0.01022192f, -0.05250436f, 
    0.08433211f, 0.03861415f, -0.00445163f, 0.01918890f, -0.02459375f, 0.09819978f, 0.08201769f, -0.09051410f, 
    0.01813473f, 0.04861104f, -0.06463116f, 0.02532699f, 0.03084577f, 0.01349281f, 0.05625352f, -0.00463463f, 
    -0.06485730f, -0.10192385f, 0.00414158f, 0.05173768f, -0.02481032f, -0.00233133f, 0.05132755f, -0.01529433f, 
    -0.06965515f, -0.11989598f, -0.10818028f, 0.00458899f, -0.04736003f, -0.06967583f, 0.01730945f, -0.05083550f, 
    -0.03045044f, -0.04546288f, -0.13904037f, -0.00302204f, -0.02284789f, 0.08966719f, 0.09749100f, 0.09764698f, 
    0.08389343f, 0.05172818f, 0.04722576f, 0.03426139f, 0.07219176f, 0.05459064f, 0.02796109f, 0.02045046f, 
    -0.02983202f, 0.02845135f, -0.04704228f, 0.00240744f, 0.01221708f, 0.04767165f, -0.05245623f, 0.00937227f, 
    -0.11033216f, 0.02628832f, -0.02793243f, -0.05313926f, -0.01471825f, 0.02901722f, 0.03096640f, -0.02253829f, 
    -0.00766815f, 0.00609438f, 0.00959847f, -0.08069802f, -0.02189638f, -0.02724923f, 0.06159233f, 0.01046073f, 
    -0.14319767f, -0.16182856f, -0.07133447f, -0.19355546f, -0.10424766f, -0.04332865f, -0.01030993f, -0.05084630f, 
    -0.12945151f, -0.11183643f, 0.00999562f, -0.08667290f, -0.06507244f, -0.10235360f, -0.01851911f, 0.01288536f, 
    0.08138043f, -0.12045725f, 0.06708315f, 0.07463218f, 0.02635331f, -0.07080664f, -0.01503704f, -0.13827702f, 
    -0.01121823f, 0.02925829f, -0.02113407f, -0.04921659f, 0.02243744f, -0.03640551f, 0.04111113f, -0.05009563f, 
    -0.01792740f, 0.00859053f, 0.02727544f, 0.05126546f, -0.10690883f, -0.05843703f, -0.10727014f, -0.07985640f, 
    -0.00648161f, 0.12655692f, 0.04750519f, 0.04981771f, -0.10606807f, -0.11685777f, -0.07498609f, -0.04305997f, 
    0.02384975f, -0.17379391f, 0.00374118f, 0.05738876f, -0.00068916f, 0.04216432f, -0.16778569f, 0.04842801f, 
    0.00685351f, 0.01239739f, -0.06274758f, -0.01557321f, -0.06799050f, 0.25612921f, 0.17677493f, 0.11646323f, 
    0.01085611f, 0.08644170f, -0.09551821f, 0.05654253f, -0.04994257f, 0.07904703f, 0.08328597f, 0.16488416f, 
    -0.19588172f, -0.18281469f, -0.09106506f, -0.00627035f, -0.16057310f, 0.13677631f, 0.00128458f, 0.07790808f, 
    0.04769696f, -0.00794849f, 0.07545373f, 0.14480567f, 0.21583186f, 0.24544887f, -0.17068563f, -0.02289142f, 
    -0.17955936f, -0.11240197f, 0.03678068f, -0.00195869f, -0.02200232f, -0.01190893f, -0.01361828f, -0.08564983f, 
    -0.09454184f, -0.08044715f, -0.12852819f, 0.00504917f, -0.00051413f, 0.10985620f, 0.07127639f, 0.00583406f, 
    0.12008083f, 0.34164032f, 0.10748287f, -0.03324463f, 0.15950075f, -0.08144282f, -0.01448536f, 0.00354438f, 
    0.05083282f, 0.00972381f, 0.06638617f, -0.10377999f, 0.05160079f, 0.15509351f, 0.13525914f, 0.12580578f, 
    -0.06711717f, -0.07114653f, -0.22080564f, 0.40650105f, 0.21362704f, -0.05978084f, 0.01154308f, -0.21440053f, 
    -0.08361339f, -0.01561160f, 0.05416630f, 0.03698382f, 0.04869908f, -0.04259697f, -0.18149538f, 0.03347550f, 
    -0.09280904f, -0.04493034f, 0.17170602f, 0.19606422f, -0.01331184f, 0.03676176f, -0.09682840f, -0.07410286f, 
    0.03958552f, -0.00797974f, -0.10685874f, -0.00588358f, -0.01870601f, -0.05338813f, 0.05408954f, -0.13586034f, 
    -0.09565523f, 0.01678188f, 0.05574140f, 0.08721969f, 0.09082909f, 0.16140169f, -0.02690760f, -0.05489321f, 
    -0.14455220f, -0.14175849f, -0.21426582f, -0.06829499f, 0.17256601f, -0.02714298f, -0.21538648f, 0.06873890f, 
    -0.09975465f, 0.15558915f, 0.04062612f, 0.15191090f, 0.09669100f, -0.08898677f, 0.10536943f, -0.16551876f, 
    -0.19417840f, 0.04921079f, 0.12431547f, 0.09815615f, -0.11786713f, -0.15959433f, 0.17427452f, 0.04089468f, 
    -0.08027948f, -0.04214868f, 0.20986289f, 0.18885291f, 0.03391406f, 0.07223190f, -0.10217391f, -0.05466202f, 
    -0.19502690f, -0.21635430f, 0.07333875f, -0.01401115f, 0.01702912f, 0.05408955f, 0.07383241f, 0.03712561f, 
    0.09215854f, 0.03220915f, 0.00228334f, 0.02594849f, -0.07284164f, -0.14828090f, -0.06432077f, 0.08073404f, 
    0.13969789f, -0.14765432f, 0.04399670f, -0.02381291f, -0.20007396f, 0.11941592f, 0.03300777f, 0.14453411f, 
    -0.15652324f, -0.03943726f, -0.19910464f, 0.01426479f, 0.06509130f, 0.04971110f, 0.10626657f, 0.06817164f, 
    -0.01192361f, -0.04402664f, -0.04794738f, -0.05108004f, -0.07303730f, -0.02131655f, -0.05119587f, -0.02515356f, 
    0.01792062f, 0.03932773f, 0.16694088f, 0.15944444f, 0.01716859f, 0.03659498f, 0.09944495f, -0.00424587f, 
    0.05613986f, 0.18486013f, 0.13402686f, -0.02840310f, -0.04898170f, 0.04593418f, -0.03374735f, -0.17391032f, 
    -0.01284980f, -0.01757837f, -0.07418486f, 0.04839052f, -0.01017063f, -0.31792587f, -0.23504367f, -0.29208529f, 
    -0.04830400f, 0.05135515f, -0.04005906f, 0.00584089f, -0.16463904f, 0.11595870f, 0.04702239f, -0.07127882f, 
    0.18896757f, 0.05655654f, -0.14085595f, 0.13725679f, -0.11285617f, 0.04423610f, 0.07714731f, 0.18838674f, 
    -0.05837191f, 0.02368963f, -0.03681073f, -0.04877971f, 0.01597599f, -0.17920864f, 0.16870366f, -0.12446988f, 
    0.16345957f, -0.05973757f, 0.05221742f, -0.05764138f, 0.06487748f, 0.04268207f, 0.06833602f, -0.05716737f, 
    -0.06357206f, -0.04758104f, 0.01964427f, 0.05361275f, -0.12290651f, -0.09545803f, -0.01769179f, -0.02558963f, 
    0.07756173f, 0.02216195f, 0.05705272f, -0.03811723f, 0.25246924f, 0.06141549f, 0.16009596f, -0.03046650f, 
    0.14838743f, 0.02031108f, -0.02207865f, 0.14261252f, 0.00403685f, 0.09990969f, 0.10484713f, -0.12532575f, 
    0.10634711f, 0.09646542f, -0.18453108f, 0.05893566f, -0.14683735f, -0.03807556f, 0.09860753f, 0.09012080f, 
    0.02475934f, 0.08674638f, -0.03335236f, -0.08775655f, 0.05149818f, 0.01670413f, -0.09895035f, 0.16198470f, 
    0.02072698f, 0.06996389f, 0.11370888f, 0.11351097f, -0.05769140f, 0.01042390f, 0.03383539f, -0.04287354f, 
    0.19118892f, 0.26600832f, -0.05468000f, -0.04382795f, 0.12605827f, -0.05815091f, -0.00687961f, 0.07605887f, 
    0.06057490f, -0.08572909f, -0.00128343f, 0.04863875f, -0.14321409f, 0.05577165f, 0.04243318f, -0.07262877f, 
    -0.15350562f, -0.15875299f, 0.00510742f, -0.01019622f, -0.05805084f, 0.12990628f, -0.10669526f, -0.18978386f, 
    -0.05830394f, -0.17448492f, -0.06761793f, -0.04553676f, 0.01978430f, 0.14530954f, 0.04119079f, 0.05583940f, 
    -0.13617340f, 0.02451167f, 0.01745361f, -0.01633615f, 0.05724321f, 0.09695144f, 0.10624594f, 0.17505582f, 
    0.00349970f, 0.02227055f, -0.01364412f, 0.00674957f, -0.09954567f, -0.03395839f, -0.03506184f, 0.06198082f, 
    0.02700482f, -0.06195763f, -0.17105144f, -0.04047173f, -0.05698014f, 0.00702965f, 0.04414317f, 0.04904618f, 
    0.08581550f, 0.01357783f, -0.03027311f, -0.00316701f, 0.06139056f, 0.02576507f, 0.08038787f, -0.18991883f, 
    0.19241294f, 0.02911734f, -0.06467630f, -0.13609751f, 0.13749644f, 0.05728233f, 0.09181949f, -0.10938554f, 
    0.04620215f, -0.04162227f, 0.04820151f, 0.10361101f, -0.17374346f, -0.02408770f, 0.00618522f, -0.10009466f, 
    0.02484203f, -0.07442895f, -0.05110425f, 0.02984026f, -0.02068988f, 0.00339665f, 0.03960451f, 0.08698746f, 
    0.12884597f, 0.05373344f, 0.03170832f, 0.16873910f, 0.00400768f, 0.04146375f, 0.04703758f, 0.10755899f, 
    -0.02703831f, 0.34072444f, -0.01880879f, -0.03577658f, -0.01312201f, 0.11080438f, 0.02875608f, 0.10975925f, 
    -0.12244584f, 0.03221629f, 0.11588003f, 0.01269056f, -0.05066571f, -0.09767013f, -0.06586322f, 0.11122252f, 
    0.01896302f, 0.14276886f, 0.08638371f, 0.08413389f, -0.09316175f, 0.07770395f, -0.09662023f, -0.04971571f, 
    -0.00100879f, 0.19805788f, 0.21499440f, 0.30877221f, -0.00045468f, 0.06072539f, 0.12693764f, -0.06689963f, 
    -0.20507008f, -0.02215479f, -0.08453164f, -0.02515740f, -0.02217896f, -0.30419338f, 0.37805578f, 0.02908505f, 
    0.13637325f, 0.10205098f, -0.09914379f, 0.13789724f, -0.03902396f, 0.12449851f, 0.07746299f, 0.01130134f, 
    -0.07379808f, -0.04022903f, -0.03809427f, 0.00579624f, -0.05111075f, 0.03939324f, 0.02146501f, 0.18222430f, 
    0.03091267f, 0.13081472f, -0.03663424f, 0.15512769f, 0.24912426f, 0.13037840f, 0.03464186f, 0.12815960f, 
    0.10886205f, 0.05721080f, -0.01811688f, -0.03022766f, 0.04169753f, 0.05893625f, 0.08567934f, -0.03096291f, 
    -0.02396484f, 0.36315280f, -0.45027742f, 0.22570235f, -0.13266179f, -0.09863701f, -0.00866012f, 0.11061136f, 
    -0.14983712f, 0.14064324f, 0.07567812f, -0.01203123f, 0.18925017f, 0.05782082f, -0.06392316f, 0.10223615f, 
    0.01128929f, 0.09434874f, -0.05597354f, -0.09396150f, -0.10467791f, -0.00810176f, -0.05389721f, -0.15245283f, 
    0.29220963f, 0.11040293f, -0.20440513f, -0.14048365f, 0.01786514f, 0.00666862f, 0.09869906f, 0.06521542f, 
    0.05202813f, -0.06189264f, -0.18871118f, -0.07937527f, -0.09517656f, 0.06743214f, 0.11664115f, 0.01344385f, 
    0.12936851f, -0.11809393f, 0.19370376f, -0.17283344f, -0.00746012f, 0.04922486f, 0.03575269f, -0.11492835f, 
    0.10344858f, -0.07989264f, 0.01810612f, 0.17538285f, 0.05033016f, -0.02626161f, -0.05421952f, 0.00009217f, 
    -0.02949818f, -0.07241886f, 0.02904729f, -0.08639276f, 0.20579816f, -0.02042310f, 0.26443189f, -0.02243294f, 
    -0.09948940f, -0.01964292f, -0.07123128f, -0.02442704f, -0.04387596f, -0.00533574f, -0.04243409f, 0.03772422f, 
    0.09969629f, 0.07591190f, -0.30115816f, 0.14620765f, -0.05021072f, 0.02705628f, 0.01821985f, -0.08603266f, 
    0.02504724f, 0.21602686f, -0.06395344f, 0.11149169f, 0.06536111f, 0.27975777f, 0.03820788f, 0.01243842f, 
    0.36234289f, -0.03184165f, -0.00973594f, 0.07140199f, 0.07496785f, -0.01536299f, -0.11678121f, -0.08600248f, 
    -0.08464490f, -0.25426295f, -0.03504593f, -0.12886192f, -0.00443180f, -0.05578031f, 0.10613651f, 0.08585883f, 
    -0.01129626f, 0.06915910f, 0.13354805f, 0.08933306f, 0.10839023f, -0.26688167f, -0.12112234f, -0.02212041f, 
    0.02151379f, -0.06440542f, -0.09199481f, 0.02588751f, 0.01322961f, -0.02210162f, -0.01263055f, 0.11774749f, 
    0.14617628f, 0.24489677f, -0.04492248f, 0.15345474f, -0.04075924f, -0.02400498f, -0.01261036f, 0.10553379f, 
    -0.03129592f, -0.07563652f, 0.01270446f, -0.00255831f, -0.22327463f, 0.26571664f, 0.07564370f, 0.05079941f, 
    0.00216173f, -0.15068035f, -0.02002282f, -0.03528427f, -0.01801771f, 0.05857399f, 0.04317525f, 0.13164307f, 
    -0.15668899f, -0.01656121f, 0.54943329f, 0.14066152f, 0.16029650f, 0.05397444f, 0.01731473f, 0.00237590f, 
    -0.03713718f, -0.11651844f, -0.06213370f, -0.12731478f, 0.51736122f, -0.16351283f, 0.36282679f, 0.09251560f, 
    -0.01687146f, 0.28696525f, -0.07937793f, 0.07413040f, 0.09937653f, 0.11729999f, 0.02615682f, 0.06283562f, 
    -0.00539331f, -0.07667669f, -0.08473619f, 0.09463112f, -0.05801401f, 0.01345524f, -0.00733281f, 0.05866273f, 
    0.29287779f, 0.04366653f, 0.12174156f, 0.21164694f, -0.06868600f, -0.01247534f, 0.12442210f, 0.11597066f, 
    0.00785640f, -0.12020497f, 0.11392733f, -0.09231734f, 0.00307410f, -0.04059329f, 0.13816679f, 0.03457449f, 
    -0.37047562f, 0.47384179f, -0.16317365f, 0.19943734f, 0.01718383f, -0.03644929f, 0.05487812f, 0.05844707f, 
    -0.13133760f, 0.03747757f, -0.03086400f, 0.07564019f, -0.05515167f, -0.04474815f, 0.11583032f, -0.17914890f, 
    -0.09595822f, 0.11740453f, -0.07288314f, -0.01697989f, -0.12985785f, 0.03538153f, -0.06070371f, -0.25511569f, 
    -0.33930561f, -0.08833837f, 0.17645594f, 0.17425284f, -0.00345040f, -0.06796575f, 0.06900664f, -0.14524357f, 
    -0.03874732f, -0.02888375f, -0.11042833f, 0.01768705f, 0.05995407f, -0.03957151f, -0.08069537f, 0.19197574f, 
    0.08806970f, 0.11611275f, 0.08371393f, 0.09780842f, 0.08526918f, -0.03893562f, 0.07304627f, -0.07204251f, 
    0.00177133f, 0.23864940f, 0.34656540f, -0.03258073f, -0.14096655f, -0.11677576f, 0.13143313f, 0.09113781f, 
    0.02545772f, 0.09236243f, -0.00364720f, -0.05914450f, 0.46247566f, 0.10721087f, 0.03264498f, -0.10338181f, 
    0.03783976f, 0.03834125f, 0.19592485f, -0.04951108f, -0.12603110f, 0.03897421f, -0.13115977f, 0.05785659f, 
    -0.04459296f, 0.13393338f, 0.00759833f, 0.05228987f, -0.07319565f, -0.19914941f, 0.08751641f, 0.05126856f, 
    0.07236771f, 0.05241684f, 0.07429879f, 0.13621840f, -0.24242610f, -0.15054935f, 0.18030120f, 0.43150285f, 
    0.01677843f, -0.04220024f, -0.17845696f, 0.03455302f, -0.10646162f, -0.03140088f, -0.04532752f, -0.02245124f, 
    0.06067866f, -0.13200435f, 0.11611652f, 0.06239643f, -0.00583457f, 0.03079195f, -0.00253575f, 0.03544074f, 
    -0.06014957f, -0.08399916f, 0.09123079f, -0.00736380f, -0.11407050f, -0.22984147f, 0.06898015f, -0.03793565f, 
    -0.03079156f, 0.03011482f, -0.00086537f, -0.15286727f, 0.14509863f, -0.10629608f, -0.06816585f, 0.02777648f, 
    -0.05855068f, -0.00675576f, -0.01062483f, -0.01403345f, -0.05171067f, 0.04042171f, -0.03042049f, -0.05602030f, 
    0.04884062f, -0.03534746f, -0.02388398f, -0.07616278f, -0.06084083f, 0.04589294f, -0.01945137f, 0.03126543f, 
    0.03669203f, 0.04142962f, -0.04569196f, -0.05335567f, -0.00740200f, -0.03492476f, 0.01594413f, -0.05760526f, 
    -0.05450702f, 0.04070757f, -0.00513266f, 0.05595395f, -0.03348156f, 0.06192349f, 0.06004988f, 0.02054274f, 
    0.00713109f, -0.00990940f, 0.02715007f, -0.05534990f, -0.06144202f, 0.01363710f, -0.02025048f, -0.00122993f, 
    0.01740755f, -0.04622440f, -0.02686181f, -0.03205060f, 0.05802855f, 0.03168729f, -0.03235070f, -0.02890651f, 
    0.03997738f, -0.06062844f, 0.04954686f, 0.01461438f, -0.05909083f, 0.02669674f, 0.05158215f, -0.08498843f, 
    0.05206409f, -0.08043399f, -0.01934698f, 0.03547310f, 0.04345099f, -0.05392941f, -0.01537245f, 0.02021624f, 
    -0.01817487f, -0.00821560f, 0.01806366f, 0.06411018f, 0.05739301f, -0.00402957f, -0.03389284f, -0.06031629f, 
    0.02257628f, 0.01773079f, -0.06240878f, -0.01624354f, 0.03360279f, -0.04896099f, 0.01776965f, -0.01796154f, 
    -0.07523609f, 0.01337537f, -0.00651731f, 0.00698770f, -0.00442628f, -0.02847386f, 0.05424163f, -0.05277237f, 
    -0.00315868f, 0.02686318f, 0.05672241f, 0.05330748f, 0.05131454f, 0.05806547f, -0.01654215f, -0.03483866f, 
    -0.06239060f, -0.07406189f, 0.06843038f, -0.01795026f, 0.05262736f, 0.05463059f, -0.00705144f, -0.04817852f, 
    0.01098187f, -0.07796167f, -0.05866183f, -0.05136902f, -0.05558935f, 0.00422438f, -0.04400519f, -0.02045170f, 
    -0.03808536f, 0.02740134f, -0.01453727f, 0.04557364f, 0.02526892f, -0.00677025f, 0.02056724f, -0.07340443f, 
    -0.01943194f, -0.06523711f, -0.07320639f, -0.02944312f, -0.02426158f, -0.07370529f, -0.01086229f, -0.06322752f, 
    -0.05720314f, 0.03850716f, 0.00564002f, -0.02303659f, 0.01270996f, 0.02167962f, 0.01074806f, -0.05155639f, 
    0.02810457f, -0.04016821f, -0.03068397f, -0.03974101f, 0.00536572f, -0.02570248f, -0.02130825f, 0.00092197f, 
    0.03758043f, -0.01195072f, 0.02767924f, 0.02909917f, -0.04972729f, -0.00586880f, 0.03997195f, -0.01448207f, 
    0.02178626f, 0.00964836f, -0.04624692f, 0.03000682f, 0.06045437f, 0.00549381f, 0.00389304f, -0.04929072f, 
    -0.02564056f, 0.04416696f, 0.00684664f, -0.06913802f, -0.04137040f, -0.04675618f, -0.07884435f, 0.03339266f, 
    0.03418099f, -0.04953253f, 0.01346569f, -0.01390428f, 0.05354977f, 0.02064468f, 0.01530665f, -0.01388524f, 
    0.02717083f, -0.04128706f, -0.04649823f, 0.03636698f, -0.04839466f, -0.06789880f, 0.06257303f, -0.04513814f, 
    0.00620829f, 0.00598521f, -0.01615181f, 0.02140141f, 0.03684856f, 0.03408289f, 0.01939998f, -0.07702953f, 
    0.03870779f, 0.05087014f, -0.02208531f, 0.01081565f, -0.00416970f, -0.07533006f, 0.03743628f, 0.01444005f, 
    -0.04683517f, -0.07246411f, 0.04458746f, 0.04187204f, -0.05850198f, 0.01335769f, -0.05892954f, -0.03929956f, 
    0.04489813f, -0.04386381f, 0.04802862f, -0.01200621f, 0.00289125f, -0.07590912f, 0.02082936f, 0.00236250f, 
    -0.04627326f, 0.00202364f, -0.03676042f, -0.00848453f, 0.04773553f, 0.04964891f, 0.01766070f, -0.03872021f, 
    0.06788777f, 0.06333165f, -0.01232423f, 0.06127492f, 0.04151219f, -0.07518129f, -0.07231598f, 0.02553876f, 
    -0.00261535f, 0.05111921f, -0.06223470f, 0.05626287f, -0.06316058f, -0.02501027f, -0.05123961f, 0.04954259f, 
    0.05921782f, -0.04562135f, -0.02894558f, -0.05929153f, -0.05110573f, -0.02270230f, 0.04999875f, -0.07812600f, 
    -0.04039763f, -0.00676890f, 0.03169961f, -0.06618951f, 0.01067019f, -0.04876334f, -0.01496040f, 0.02001527f, 
    0.04842242f, -0.03969381f, -0.00709603f, 0.03386984f, -0.00594287f, -0.00210315f, 0.03444435f, 0.02328761f, 
    0.06052215f, 0.03647924f, -0.04953649f, -0.06767970f, -0.03114232f, 0.04487658f, -0.00585884f, 0.00635797f, 
    -0.06627961f, 0.05625829f, -0.07428049f, -0.02165874f, 0.05352478f, -0.04991380f, -0.01859945f, 0.01061664f, 
    -0.03093768f, -0.01738925f, -0.07470465f, -0.00467182f, -0.04880536f, 0.01108951f, -0.01975082f, -0.00876115f, 
    0.06038510f, -0.07471480f, -0.03281283f, -0.01485712f, 0.02525419f, 0.04652809f, 0.00836178f, -0.07322833f, 
    0.01676923f, -0.00425154f, -0.05505021f, 0.00354898f, -0.04418235f, 0.04028597f, 0.01611264f, -0.00550500f, 
    -0.02015616f, -0.02569626f, 0.01081516f, -0.03171724f, -0.00839486f, -0.06633728f, 0.00757638f, 0.05605381f, 
    0.05854488f, -0.03280455f, -0.02359076f, 0.04857084f, -0.06403460f, 0.01208706f, -0.01190600f, 0.02644622f, 
    -0.05533586f, -0.00006498f, -0.05817201f, -0.05950209f, 0.04743584f, -0.04048692f, -0.03965636f, 0.01665880f, 
    0.00588764f, 0.02008927f, -0.06607084f, -0.07550465f, -0.04053872f, 0.03332080f, 0.03493939f, 0.05518207f, 
    -0.03173403f, -0.05888102f, -0.03405434f, -0.00536414f, 0.01923088f, 0.00522732f, 0.00106163f, -0.00096518f, 
    -0.03985414f, -0.01944171f, 0.04600792f, -0.06152187f, -0.05176043f, -0.06540772f, -0.00809841f, -0.03822611f, 
    -0.02079546f, 0.00792722f, 0.03139474f, 0.00184838f, -0.05617060f, -0.04702464f, -0.05832338f, 0.04159006f, 
    -0.03853634f, -0.03815161f, -0.07107709f, -0.05373122f, 0.01932903f, -0.05008069f, -0.07926866f, -0.04475428f, 
    -0.02015663f, 0.05168808f, -0.00397337f, -0.07738788f, -0.02349661f, -0.02321444f, -0.01851784f, 0.04491341f, 
    0.01709428f, -0.02343253f, 0.03720380f, 0.04251776f, 0.00816231f, 0.04691167f, -0.02314430f, 0.02805466f, 
    0.33246705f, 0.22942156f, 0.03603817f, 0.19946080f, -0.05050328f, 0.10889059f, -0.00267653f, 0.06263275f, 
    -0.12579325f, -0.06824772f, 0.01145684f, -0.12840456f, -0.41205439f, -0.06552447f, -0.18859674f, -0.42415109f, 
    -0.13842292f, -0.10421520f, -0.15544978f, -0.02933044f, -0.04621722f, -0.06842396f, 0.10774363f, -0.16742291f, 
    -0.15010200f, -0.00033301f, -0.05996455f, 0.05167865f, 0.05579529f, 0.01945564f, -0.10604281f, -0.06656230f, 
    0.02054287f, -0.04890584f, 0.08958714f, -0.08836389f, 0.55416101f, 0.09464959f, 0.01214641f, -0.05823217f, 
    0.09696169f, 0.17139409f, 0.02043464f, 0.31337622f, 0.03186855f, 0.06166689f, 0.12533052f, 0.06941288f, 
    -0.00459169f, 0.06443442f, 0.01733370f, 0.06454279f, 0.01099717f, 0.00435823f, 0.06878733f, 0.13659112f, 
    0.30191365f, 0.11718491f, 0.02625867f, 0.04657434f, -0.07335281f, -0.37869999f, 0.23079926f, -0.25520369f, 
    0.15940383f, 0.10962285f, 0.09853663f, -0.21529393f, 0.06293444f, 0.12541336f, 0.17902854f, 0.14714405f, 
    -0.14621733f, 0.04068315f, -0.26927540f, 0.16903026f, 0.09605009f, 0.02219433f, 0.25055242f, 0.38126159f, 
    0.07093127f, 0.12063168f, -0.03083467f, 0.14651778f, -0.15733211f, -0.05092189f, -0.10068917f, -0.07866202f, 
    -0.07557026f, -0.18695891f, -0.03491542f, 0.09446520f, -0.09188853f, -0.08589175f, -0.06448304f, -0.13860077f, 
    0.02899238f, -0.39425176f, -0.16679867f, 0.06685027f, 0.08299505f, -0.10769336f, -0.11605886f, -0.22210206f, 
    -0.02192318f, -0.02738218f, 0.05456532f, -0.04216698f, -0.00602979f, -0.13615522f, -0.07551402f, -0.08193792f, 
    0.01571854f, 0.06177459f, -0.12777734f, 0.05795800f, 0.07215338f, -0.27633950f, -0.16414765f, -0.09076340f, 
    -0.21407506f, -0.20531346f, -0.31602749f, 0.01668667f, 0.01364910f, -0.08507821f, 0.10236426f, 0.22268224f, 
    0.04730863f, 0.16446143f, 0.03780304f, 0.07200511f, 0.42385080f, 0.10115674f, 0.01173921f, -0.09182943f, 
    0.03578393f, -0.01143440f, 0.02810824f, -0.08476961f, -0.10668594f, -0.05792188f, -0.08617848f, -0.11369212f, 
    -0.11742274f, 0.07692447f, -0.06343596f, 0.18926173f, -0.00180766f, 0.13433444f, 0.15254934f, -0.03620744f, 
    0.09868200f, 0.11238793f, 0.18878414f, 0.04081966f, -0.25641945f, -0.04874074f, -0.09071466f, 0.02315023f, 
    0.24254279f, -0.21169877f, 0.10077465f, -0.04338872f, 0.03886136f, 0.08258646f, 0.09045833f, -0.08526267f, 
    0.14477390f, 0.06407671f, 0.22259685f, 0.06813845f, 0.03907408f, -0.01597813f, -0.06333812f, -0.10680991f, 
    -0.05907874f, 0.04308810f, -0.07033424f, -0.02059868f, -0.25643432f, -0.21143955f, -0.02589157f, 0.01257905f, 
    -0.07344887f, -0.01477296f, 0.11526281f, -0.00265084f, 0.06558927f, 0.05710087f, 0.10298156f, -0.00107246f, 
    0.02557698f, 0.20098600f, -0.00070684f, 0.17519961f, -0.12796898f, -0.10255724f, 0.03925673f, 0.02558205f, 
    -0.04000419f, -0.08307588f, 0.04199392f, -0.00380173f, 0.40199307f, 0.00406499f, 0.02849478f, -0.01730736f, 
    -0.07327958f, -0.16201840f, -0.04535491f, -0.04964844f, -0.05027073f, -0.11552807f, -0.03697119f, -0.01684772f, 
    -0.19185409f, 0.13371477f, 0.26146272f, 0.11156694f, 0.12334243f, -0.06222298f, 0.02016331f, 0.02446687f, 
    0.00526771f, 0.00052403f, -0.05088784f, -0.11554196f, -0.15334252f, -0.27420714f, 0.11289357f, 0.04019299f, 
    0.02564117f, 0.04849219f, 0.00532785f, -0.03669670f, 0.07397443f, 0.13105381f, -0.14071178f, 0.08196954f, 
    0.13300219f, 0.14864436f, 0.07665816f, 0.04529407f, -0.05124157f, -0.03280213f, -0.09703712f, -0.08071323f, 
    -0.12521078f, 0.12101257f, 0.04550447f, 0.14888296f, -0.02958400f, 0.16201122f, 0.10216185f, 0.10247629f, 
    0.01921301f, -0.02411848f, 0.03872248f, -0.03483655f, -0.03585775f, -0.04704289f, 0.16015007f, -0.05358649f, 
    -0.25864965f, 0.50349307f, -0.00421036f, 0.15067472f, -0.05113829f, 0.01191256f, 0.04629422f, 0.34754294f, 
    -0.08511754f, -0.06736539f, 0.06554508f, 0.06849194f, 0.07092492f, 0.18169960f, 0.07802662f, 0.01880114f, 
    -0.04491925f, 0.17445657f, -0.01517364f, 0.06190780f, -0.13850878f, -0.02783650f, 0.00105108f, -0.13627622f, 
    -0.13019642f, -0.25560006f, 0.15341263f, 0.25810692f, -0.12289967f, 0.04991205f, -0.18057950f, 0.16616629f, 
    0.03192269f, -0.02293123f, -0.07534629f, -0.06856846f, 0.06667039f, 0.04302327f, 0.05602212f, -0.09817857f, 
    0.04202768f, -0.05797420f, -0.05566351f, -0.01335820f, -0.16548996f, 0.00332079f, -0.05063026f, -0.07890591f, 
    0.15293972f, 0.11846869f, 0.24259739f, 0.18635157f, -0.00438355f, 0.02416482f, 0.07775988f, 0.03058841f, 
    0.06176322f, 0.08317550f, -0.00690309f, -0.04929468f, 0.24415128f, 0.00788290f, 0.07839118f, -0.10004842f, 
    -0.14517711f, 0.02705971f, -0.03956409f, -0.01028268f, -0.17072460f, -0.06671774f, -0.07088607f, -0.01630198f, 
    0.25126809f, 0.13195005f, 0.02388800f, 0.11507490f, -0.00939913f, -0.15749869f, 0.04437706f, -0.11363434f, 
    0.05233067f, 0.17426252f, 0.01018648f, 0.12279879f, -0.08582856f, 0.35138565f, -0.02683295f, 0.11501551f, 
    -0.00874467f, -0.00840378f, -0.13232552f, 0.06299719f, -0.00169195f, -0.05158980f, 0.01006830f, -0.03002482f, 
    0.07781100f, -0.11701941f, 0.09119777f, -0.03597023f, 0.03043549f, 0.04318145f, 0.07245973f, -0.09695718f, 
    -0.01392503f, -0.15309869f, -0.00782611f, -0.06323049f, -0.01476573f, -0.13430375f, 0.04514425f, 0.23373620f, 
    0.00998181f, 0.01016813f, -0.08088630f, -0.10104056f, 0.02313273f, -0.14649141f, -0.00284016f, 0.13328306f, 
    0.20336770f, 0.18552658f, -0.10198133f, -0.06059854f, -0.13022894f, -0.08660174f, 0.00579713f, 0.03406764f, 
    0.03627175f, 0.09421036f, -0.07950278f, -0.05942413f, 0.08813506f, 0.06590064f, 0.11755603f, -0.10278658f, 
    -0.07312559f, -0.13853186f, -0.05063223f, -0.08700261f, 0.13712229f, 0.11243204f, 0.00891225f, -0.06622183f, 
    -0.20499673f, -0.07458065f, 0.19045185f, 0.14387786f, 0.13426749f, 0.03265240f, 0.04842291f, 0.04621000f, 
    0.00423577f, -0.03652588f, 0.00154940f, -0.07159968f, 0.25553921f, 0.24177650f, 0.01137531f, -0.00610544f, 
    0.12904590f, 0.07321954f, 0.05817298f, 0.03267929f, 0.00429103f, 0.20361541f, 0.34388581f, 0.15518492f, 
    -0.08375387f, -0.01344145f, 0.08090582f, -0.10268849f, -0.09196019f, -0.02106672f, -0.05733906f, -0.07701422f, 
    0.13073242f, -0.07324694f, 0.06838088f, 0.08446120f, -0.12873271f, -0.04738132f, -0.07817836f, -0.03576509f, 
    0.15649407f, -0.19519821f, 0.11558036f, 0.06914290f, 0.01408226f, 0.01251708f, -0.00629128f, -0.05197902f, 
    -0.15752070f, 0.21499385f, 0.07524757f, 0.02940245f, -0.03866835f, 0.14282012f, 0.11196072f, -0.05024928f, 
    0.07954571f, -0.12605122f, -0.07122315f, 0.01667556f, -0.18034808f, -0.05736991f, 0.22083944f, -0.03025987f, 
    -0.02296337f, 0.06014483f, -0.00276468f, 0.18133798f, 0.01445855f, 0.04765366f, -0.02523638f, -0.00090405f, 
    -0.25055200f, -0.10006433f, 0.07611009f, 0.02466578f, 0.00205699f, -0.05436861f, -0.07337750f, -0.08739066f, 
    0.01665265f, -0.02774046f, 0.07517754f, -0.02059467f, 0.06731334f, 0.09473912f, -0.05187766f, -0.01096611f, 
    0.00304366f, 0.06934139f, 0.10554481f, 0.20074455f, -0.00119998f, 0.04185596f, 0.21816409f, 0.07433008f, 
    -0.05011162f, 0.01353102f, 0.39479610f, 0.01099707f, -0.10203646f, 0.02834863f, 0.15454377f, 0.18005700f, 
    0.08871531f, -0.01243272f, 0.01428088f, 0.14081611f, 0.05937521f, 0.06938919f, -0.00369794f, -0.00530436f, 
    0.18844575f, 0.16266605f, 0.16920170f, 0.11162352f, -0.05788731f, -0.08735141f, 0.06924591f, 0.02769608f, 
    -0.00796546f, 0.05386082f, 0.23474491f, -0.08976869f, -0.08846260f, 0.09727422f, 0.08393716f, 0.12804644f, 
    0.20697816f, -0.03071174f, -0.06173535f, -0.18564267f, -0.07458629f, -0.16068785f, 0.00206921f, 0.15678562f, 
    -0.07354251f, 0.08276549f, -0.06472106f, 0.05685051f, 0.01044803f, 0.15354395f, -0.01586268f, -0.09660377f, 
    -0.16104613f, 0.04872895f, 0.01024430f, -0.02888522f, -0.08378197f, -0.03935203f, 0.01475462f, -0.05224422f, 
    -0.00264480f, 0.08296428f, 0.13826856f, 0.01006567f, -0.28929579f, -0.09193138f, -0.03489021f, 0.05652615f, 
    0.01307052f, 0.11952020f, 0.14112334f, -0.06174968f, 0.14397717f, -0.07413512f, -0.00930606f, 0.00226160f, 
    0.06960573f, -0.02879686f, 0.07863420f, 0.06873665f, 0.08009570f, -0.08743736f, -0.07048977f, -0.05350426f, 
    0.02163610f, -0.06484692f, -0.03259926f, 0.11397592f, 0.32351592f, 0.06571852f, -0.09085064f, -0.14740126f, 
    0.00377784f, -0.03733139f, -0.06161827f, -0.03181387f, 0.04663313f, -0.02144583f, -0.01428447f, 0.01297403f, 
    0.24508135f, -0.07038064f, -0.26296383f, -0.61664420f, -0.17626949f, 0.04799461f, -0.05397174f, 0.26710996f, 
    0.11718708f, -0.07006933f, -0.00634156f, -0.05694634f, -0.33240589f, 0.08379405f, 0.00867913f, -0.11628597f, 
    0.08184504f, 0.10950165f, -0.02870645f, 0.10254737f, 0.14412659f, 0.02770602f, 0.02478675f, -0.06582260f, 
    0.12143418f, 0.07077592f, -0.03907720f, 0.08339623f, 0.04645730f, 0.03720984f, -0.05135391f, 0.03282352f, 
    0.19521020f, 0.03701762f, 0.01525887f, 0.02466549f, -0.44879746f, -0.14469442f, -0.14682069f, -0.28533560f, 
    -0.13070700f, 0.02640458f, -0.09794198f, 0.14376967f, 0.06856853f, -0.03862851f, 0.01170446f, 0.03382445f, 
    0.12012026f, -0.05653433f, 0.22598630f, -0.42040327f, 0.01436846f, 0.03896533f, 0.03061589f, 0.09404266f, 
    0.01323573f, 0.10631093f, 0.02589163f, 0.00702386f, 0.22795926f, 0.12118915f, 0.11583198f, 0.10976525f, 
    0.12832601f, 0.23020783f, 0.13580360f, -0.06658563f, -0.03191302f, -0.00222339f, 0.03316554f, 0.02033255f, 
    -0.48711884f, -0.13732801f, 0.00282854f, -0.21650809f, 0.04336312f, -0.08372203f, 0.03460056f, 0.25436851f, 
    0.09693564f, -0.03436379f, 0.04700547f, -0.06672437f, 0.04348661f, -0.04565890f, -0.04102693f, -0.07859989f, 
    -0.09998917f, -0.04432547f, -0.11958748f, 0.05285299f, -0.21468191f, 0.11178123f, 0.07962953f, -0.09011320f, 
    0.25874367f, -0.18535268f, -0.18198957f, -0.30432597f, 0.09670813f, 0.12346975f, -0.11599093f, 0.15582028f, 
    0.06840181f, -0.06622893f, 0.01961628f, 0.00198137f, 0.10987344f, 0.02317760f, -0.16303237f, 0.16924322f, 
    0.07732120f, -0.08831351f, -0.05653625f, -0.30683553f, -0.05414990f, -0.03765992f, -0.02118254f, 0.02369591f, 
    0.12944447f, 0.04240560f, -0.02215013f, -0.34359881f, 0.00065099f, -0.08944885f, -0.16130255f, 0.14495750f, 
    0.11537963f, -0.00654257f, 0.12188548f, 0.14549477f, -0.11693256f, -0.10740799f, 0.01015161f, -0.55854326f, 
    -0.31817067f, 0.12155947f, -0.07422159f, -0.17007065f, 0.08255938f, -0.14107007f, 0.00888558f, -0.12915416f, 
    0.21060653f, 0.00651300f, 0.11425082f, 0.17689447f, 0.03631476f, 0.04052669f, 0.03539781f, 0.05864441f, 
    -0.02170141f, 0.06220959f, 0.05389153f, 0.05481240f, -0.05519093f, 0.29364511f, 0.04669220f, 0.10131990f, 
    0.17104127f, 0.14703518f, 0.08745700f, 0.23861665f, 0.11182451f, 0.00810752f, -0.01815039f, 0.04504884f, 
    0.12028247f, -0.01490667f, -0.28548104f, 0.05078722f, 0.00379291f, -0.02313673f, -0.10515765f, -0.02393434f, 
    -0.14494725f, 0.09959309f, -0.01223152f, 0.08137690f, 0.10188878f, 0.47642791f, 0.32089788f, 0.15455121f, 
    -0.05641780f, -0.07292185f, -0.02036805f, 0.02546467f, -0.10574642f, 0.11432391f, 0.05373204f, -0.00921751f, 
    -0.20211481f, 0.05439186f, 0.30011967f, 0.10050638f, 0.13272581f, -0.01976295f, -0.03023515f, -0.01589206f, 
    0.05456624f, -0.00235822f, 0.01560091f, -0.03563120f, -0.08843388f, 0.15690652f, 0.04887727f, 0.02202585f, 
    0.07453804f, 0.15340431f, 0.01115140f, -0.09672672f, 0.03658355f, 0.03028210f, 0.02228626f, -0.00854949f, 
    -0.05037233f, 0.13974823f, 0.00150065f, -0.00985142f, -0.04931079f, -0.13403131f, -0.06367366f, 0.03497340f, 
    -0.04867553f, 0.13472557f, 0.04785398f, 0.12197263f, -0.00286203f, 0.00330729f, -0.06335624f, 0.14852341f, 
    0.03521948f, -0.01771676f, 0.04989881f, -0.04939803f, 0.13472517f, 0.12497026f, 0.18708538f, 0.03990225f, 
    -0.16260599f, 0.20394793f, -0.20872447f, 0.22379033f, 0.01813091f, 0.08280503f, -0.16488090f, -0.03320996f, 
    -0.00076758f, -0.12593487f, 0.01140998f, 0.18494932f, -0.16253440f, 0.03136202f, 0.21170309f, 0.05055023f, 
    -0.08262583f, 0.05090642f, -0.00952937f, 0.09791271f, -0.08049588f, 0.05627268f, -0.08875835f, -0.13255526f, 
    -0.29039109f, -0.23460734f, 0.00254758f, 0.20809144f, -0.15330245f, -0.01510659f, -0.07971875f, -0.18847038f, 
    0.07674254f, 0.08549429f, 0.08144325f, -0.04093571f, 0.03928701f, 0.13795851f, -0.03619596f, -0.13046095f, 
    -0.09579828f, -0.06667793f, -0.20499416f, -0.04108114f, 0.12237053f, -0.28384426f, 0.11773121f, -0.09990244f, 
    0.20325889f, 0.24151079f, 0.39931357f, 0.20482506f, -0.04055211f, 0.11404715f, 0.15728194f, -0.07441179f, 
    0.03855294f, 0.11546962f, 0.12287641f, 0.04501611f, 0.13717288f, 0.06851804f, 0.08938133f, -0.19531372f, 
    -0.12772557f, 0.02500673f, 0.09346462f, -0.05690187f, 0.02230270f, -0.12453125f, 0.06992233f, -0.07198831f, 
    0.14459437f, 0.03510180f, 0.25243595f, 0.11910088f, 0.05556285f, -0.08424181f, -0.02157006f, -0.05397686f, 
    0.14054236f, 0.31428546f, -0.13669924f, 0.02755380f, -0.14168650f, 0.12730902f, -0.27433580f, 0.18374504f, 
    0.02764559f, -0.05358058f, 0.07308280f, 0.02381762f, -0.09363114f, 0.06767146f, 0.19843414f, 0.03755142f, 
    -0.19997296f, -0.26244852f, -0.08539684f, -0.10757106f, -0.01922737f, -0.06464333f, 0.02440360f, -0.00232711f, 
    -0.01005723f, -0.23393390f, -0.00136336f, -0.11960211f, -0.21707904f, -0.12072949f, -0.01015393f, -0.01410340f, 
    -0.01977006f, -0.01940255f, 0.09929195f, 0.01340219f, 0.08936586f, 0.13600647f, 0.16089976f, 0.09975768f, 
    0.12411707f, 0.03434112f, 0.22827664f, -0.14865486f, 0.03053033f, -0.18906784f, -0.21266839f, -0.22563986f, 
    0.07261539f, -0.07298539f, 0.12413546f, 0.00601636f, 0.60778123f, -0.24650063f, -0.16320293f, 0.16004671f, 
    0.01894549f, -0.02090110f, 0.14715950f, -0.18060158f, 0.07784045f, 0.07866420f, 0.14482455f, 0.10920897f, 
    -0.09887046f, -0.29292867f, 0.16573073f, -0.06581403f, -0.07165202f, -0.00509995f, -0.00403434f, 0.01883768f, 
    0.18949924f, -0.13471889f, -0.14711003f, 0.17095771f, -0.49216372f, -0.47222677f, 0.21067706f, 0.00467182f, 
    -0.05912583f, 0.11894378f, -0.17252323f, -0.15015848f, 0.00489679f, -0.04371795f, -0.15384814f, 0.02839047f, 
    0.21714415f, -0.07673652f, 0.10538093f, -0.13291131f, -0.14626214f, 0.07682949f, 0.06859172f, 0.08914730f, 
    0.15303662f, 0.27074671f, 0.16098316f, 0.20737842f, 0.04228928f, 0.03324271f, 0.07149825f, 0.06103413f, 
    0.01760655f, 0.15792210f, 0.05049820f, 0.15557501f, 0.10168457f, -0.02246530f, 0.09403412f, 0.23384553f, 
    0.17641166f, -0.03850810f, 0.31111550f, -0.20584188f, -0.00598092f, 0.03427225f, 0.23488712f, 0.04216596f, 
    -0.01584514f, 0.11773533f, -0.02440933f, 0.01002754f, -0.04889821f, 0.15865690f, 0.04494752f, 0.08752423f, 
    0.03491054f, -0.01884771f, -0.03273968f, 0.02086875f, -0.22224078f, -0.12702852f, -0.28221604f, -0.46074441f, 
    0.22301744f, 0.00142725f, 0.01297282f, -0.02176533f, -0.05560010f, -0.04785528f, -0.02612133f, 0.22802289f, 
    -0.04706196f, -0.06105909f, -0.01677357f, 0.00037646f, -0.00906780f, 0.01084371f, 0.07655520f, -0.23656705f, 
    0.03380068f, -0.16325526f, -0.06755942f, -0.33209455f, 0.09179097f, -0.17078757f, -0.15526164f, 0.16918093f, 
    -0.17512210f, -0.08681084f, 0.04450462f, 0.14318277f, -0.02620959f, -0.05704437f, 0.11120140f, -0.11988562f, 
    0.07263466f, 0.07286841f, -0.01967851f, -0.00426933f, -0.07899135f, 0.12594183f, 0.03617650f, 0.09466680f, 
    0.09879013f, -0.05837411f, -0.12558286f, 0.16716188f, -0.27185833f, -0.07000987f, -0.16156159f, -0.29799131f, 
    0.07166429f, -0.02487551f, -0.08842402f, 0.13143677f, 0.18487149f, -0.00328742f, 0.06465497f, 0.01399453f, 
    0.06905758f, 0.10838065f, 0.04153804f, 0.19102331f, 0.52227587f, 0.05105664f, 0.20022604f, 0.00645734f, 
    -0.12025534f, 0.09167565f, -0.10743582f, 0.11878132f, 0.10965551f, -0.08279820f, -0.00638673f, 0.12508947f, 
    0.13728535f, -0.00775616f, -0.19489329f, 0.01941261f, -0.07288546f, 0.01607218f, -0.15864001f, 0.00167569f, 
    0.02190292f, -0.04894463f, -0.09792056f, -0.20302773f, 0.08375982f, 0.19655950f, 0.10709275f, 0.15267979f, 
    0.08302879f, 0.16958122f, 0.12535983f, 0.22148870f, 0.01329970f, 0.07024740f, 0.05800531f, -0.06389128f, 
    0.00280603f, -0.00248730f, -0.06128973f, 0.01633936f, -0.09893991f, 0.02849600f, -0.03566729f, -0.02931079f, 
    0.01221187f, 0.01722777f, 0.03638903f, -0.02290685f, 0.04029557f, -0.03575476f, 0.03310614f, 0.03941195f, 
    0.01834841f, -0.04779837f, -0.02643263f, -0.05423782f, 0.04851369f, -0.03291513f, -0.03162239f, -0.06920365f, 
    -0.03954688f, -0.00865953f, -0.08942086f, 0.02991880f, 0.07047994f, -0.04185213f, -0.05835379f, -0.07449029f, 
    -0.02493586f, -0.10443469f, -0.00335048f, -0.01436373f, 0.06142113f, -0.03229961f, 0.03626893f, 0.02904758f, 
    -0.01013706f, -0.06577747f, -0.04657811f, -0.07074091f, -0.02695587f, -0.08305881f, -0.09891287f, 0.00807793f, 
    -0.06149647f, 0.02632477f, -0.05442131f, -0.02931526f, -0.04059817f, -0.05874566f, -0.10935057f, 0.03833148f, 
    0.05133126f, -0.07892378f, -0.02051477f, 0.00182193f, -0.03521356f, 0.07138467f, -0.01859840f, 0.05277281f, 
    0.01787114f, 0.05519127f, -0.03476600f, 0.00804742f, -0.03818990f, -0.04688174f, 0.02163795f, -0.02335846f, 
    -0.06494078f, -0.05691407f, 0.03078835f, -0.02622516f, -0.01066554f, 0.00400020f, -0.09634146f, -0.03366571f, 
    -0.01536978f, 0.00178799f, -0.02236339f, -0.04289082f, -0.00469411f, -0.04812720f, 0.00447271f, -0.08243235f, 
    0.03238127f, -0.06860717f, -0.05399911f, -0.06499478f, -0.00579408f, -0.03615101f, -0.02275385f, 0.04781225f, 
    0.08752509f, -0.01864699f, 0.00536219f, 0.01399317f, 0.05216067f, -0.05390549f, -0.09016484f, -0.00870613f, 
    -0.10503436f, -0.01440843f, -0.05388096f, -0.00822364f, -0.00145280f, -0.02908800f, -0.01759436f, 0.00611190f, 
    0.00009051f, -0.06837595f, -0.03915805f, 0.02175303f, 0.00279267f, -0.00790952f, -0.05929454f, -0.05917392f, 
    -0.04963561f, -0.00142696f, -0.04959741f, -0.03279848f, -0.05968711f, -0.04168111f, 0.02219987f, -0.07598940f, 
    0.00182267f, 0.02407355f, -0.09167901f, -0.06744657f, -0.05941988f, -0.05408239f, 0.03698482f, -0.02067223f, 
    -0.01472652f, -0.04562493f, -0.04771540f, -0.09291623f, 0.01883418f, -0.03028833f, -0.06479929f, -0.09464209f, 
    0.02110883f, 0.02385502f, -0.05847502f, -0.00171615f, -0.05570886f, 0.01466886f, -0.02637294f, 0.04637532f, 
    -0.04151672f, -0.02419643f, -0.02031848f, -0.06865900f, 0.01114797f, 0.00334440f, -0.00812401f, 0.06197679f, 
    -0.03677057f, 0.02419292f, -0.02808325f, 0.00283465f, -0.10587462f, -0.06067876f, -0.05693203f, 0.00755949f, 
    0.03762604f, -0.05713509f, -0.08939821f, 0.02565889f, 0.03753680f, -0.06190990f, -0.06000881f, -0.00059744f, 
    -0.02947778f, -0.07080863f, -0.02241536f, -0.06017945f, -0.06426902f, 0.05444859f, 0.00435867f, 0.02807107f, 
    0.05448327f, 0.04048936f, -0.06396942f, 0.00534805f, 0.02656378f, -0.08208968f, -0.10628716f, -0.06913037f, 
    0.03340512f, 0.02077515f, 0.02975499f, 0.03785688f, -0.05526007f, 0.04650262f, -0.01877282f, 0.05474732f, 
    -0.05049049f, 0.04835338f, -0.00868046f, -0.02136230f, 0.06174248f, -0.04246224f, 0.05000735f, 0.04306179f, 
    -0.07202542f, -0.05786186f, -0.05275401f, 0.04712150f, -0.00697775f, 0.02322346f, 0.00834791f, -0.05567994f, 
    -0.03419739f, 0.02102302f, -0.06167466f, 0.02871878f, -0.07032710f, -0.07058316f, -0.00408821f, -0.06379811f, 
    0.00418485f, -0.06165644f, -0.05186518f, -0.02127954f, -0.06724180f, 0.07012837f, 0.02798815f, -0.03482107f, 
    -0.01195247f, -0.04631626f, -0.00139279f, -0.01296232f, 0.00179131f, -0.02786155f, -0.00557276f, -0.00803387f, 
    -0.04280368f, 0.00175974f, 0.03321137f, -0.02350170f, 0.01947895f, 0.05419203f, -0.06263560f, -0.03608176f, 
    -0.03096790f, 0.04931224f, -0.07467885f, 0.06338161f, -0.03297522f, 0.06334118f, 0.06310857f, 0.05274041f, 
    -0.04891694f, 0.06954116f, -0.03310054f, -0.04898012f, -0.05289375f, -0.00294417f, -0.03853368f, -0.05031838f, 
    -0.03794373f, -0.01755048f, 0.02815941f, 0.02107758f, 0.05470718f, 0.01250662f, -0.06763019f, 0.04665721f, 
    -0.03007142f, 0.05808866f, -0.01607252f, -0.02321069f, -0.00276981f, 0.03905051f, -0.03670715f, 0.06624482f, 
    0.00263605f, -0.05736735f, -0.04592316f, -0.00000312f, -0.00274148f, -0.00265683f, -0.06952225f, -0.04588452f, 
    -0.06836324f, 0.00366124f, -0.03790687f, -0.03273084f, -0.03745183f, -0.02514611f, -0.00409109f, -0.03093210f, 
    0.00119209f, 0.00871943f, -0.06338278f, -0.03377375f, 0.06086262f, 0.05354012f, -0.05076460f, 0.00765215f, 
    -0.04216808f, -0.04138714f, -0.03302887f, -0.03749022f, -0.07182041f, -0.04848867f, -0.02314860f, 0.04034533f, 
    -0.05265615f, -0.04244870f, -0.02576496f, 0.03688897f, 0.00564828f, 0.05171437f, -0.03529446f, 0.00329540f, 
    -0.00900389f, 0.02362099f, -0.03558525f, 0.03929293f, -0.07534400f, -0.03571351f, -0.05370801f, 0.03290745f, 
    -0.03105531f, -0.05009032f, -0.04049441f, -0.05075168f, -0.06032788f, 0.03924138f, 0.01697251f, 0.03117207f, 
    0.00995922f, 0.02486442f, 0.01138891f, 0.02801139f, 0.06103035f, -0.01656467f, 0.00623930f, 0.01147560f, 
    0.00271391f, -0.06307608f, -0.04031529f, -0.06044391f, -0.00798165f, 0.00349158f, -0.06868262f, -0.03261238f, 
    0.01166264f, -0.05839117f, -0.06199408f, -0.00272634f, 0.04306079f, -0.01158820f, -0.04860834f, 0.04470835f, 
    -0.01814457f, -0.06319467f, 0.06240995f, -0.07448054f, 0.01638683f, -0.03725751f, -0.02652065f, 0.03548490f, 
    0.05205174f, 0.00899169f, 0.02133343f, 0.01463751f, 0.01480431f, -0.04946756f, 0.00797578f, 0.02413494f, 
    -0.06341292f, -0.01721402f, 0.03207517f, 0.03335041f, -0.03316344f, 0.00226403f, 0.06770165f, -0.03855170f, 
    0.26945546f, 0.35456195f, -0.01919953f, -0.12148572f, -0.11765648f, 0.03373552f, -0.05066284f, 0.01798618f, 
    -0.21457334f, -0.06833468f, 0.00110282f, 0.04471903f, 0.19126469f, -0.07946809f, 0.07953440f, 0.09146431f, 
    -0.09356010f, 0.23474684f, 0.00468983f, -0.02379529f, 0.00284433f, 0.13298096f, 0.02580370f, 0.01223407f, 
    -0.08937042f, -0.15269190f, 0.19377559f, 0.35028929f, -0.11587095f, 0.12860411f, 0.04700655f, -0.04010649f, 
    -0.04862932f, -0.06703706f, -0.08332492f, 0.17005403f, -0.16009563f, -0.19091044f, 0.25023958f, 0.02224020f, 
    0.14295115f, 0.11889271f, -0.00739633f, -0.05755499f, 0.00227745f, 0.04331160f, 0.07222813f, 0.19305910f, 
    -0.20913260f, -0.01375296f, 0.06318410f, -0.06133024f, -0.04414754f, -0.22807895f, -0.01029502f, 0.06059675f, 
    0.13004878f, 0.20724733f, 0.03073445f, 0.14142987f, 0.17587544f, 0.14286073f, 0.04644398f, 0.20197181f, 
    0.14772809f, 0.13715516f, 0.10337923f, 0.04586018f, 0.08582240f, 0.02809389f, 0.06579198f, 0.21163048f, 
    0.01568768f, -0.07810415f, -0.31280756f, 0.14501952f, -0.08119600f, -0.03594673f, 0.11367271f, 0.00021697f, 
    -0.01300823f, 0.07414591f, 0.12556617f, -0.02735142f, -0.10000984f, -0.02372643f, -0.14454687f, -0.02906613f, 
    -0.00635191f, -0.12045724f, -0.05052073f, 0.03222157f, -0.12625815f, 0.15387239f, -0.13080691f, -0.12096267f, 
    0.23816101f, -0.00161124f, -0.33245483f, -0.20837004f, 0.06619462f, -0.01504700f, 0.01006470f, -0.00510158f, 
    -0.03019726f, -0.16287653f, -0.13224936f, -0.05791410f, -0.12818813f, 0.30373183f, 0.17119595f, 0.00489383f, 
    -0.07739132f, -0.11303528f, 0.02107180f, -0.10995893f, 0.13237916f, -0.16096736f, -0.02314539f, 0.07029588f, 
    -0.26804706f, -0.12988408f, 0.01267286f, 0.15821679f, 0.00292616f, 0.10494182f, 0.12414510f, 0.00979463f, 
    -0.15749699f, -0.00628073f, -0.00112839f, 0.12911354f, -0.07185963f, 0.12464795f, 0.40662396f, 0.16829304f, 
    -0.07390719f, 0.01990344f, -0.01548275f, 0.05120478f, -0.09885859f, 0.00623563f, -0.05617595f, -0.04757531f, 
    0.02809277f, 0.06454604f, -0.09564511f, 0.14672461f, 0.05317198f, 0.08827365f, 0.02681686f, -0.07278197f, 
    0.03527769f, 0.04049315f, -0.19929104f, -0.03461709f, 0.31974158f, 0.09425309f, 0.09729658f, 0.06555919f, 
    0.25852045f, -0.02417570f, 0.23805788f, 0.17810032f, 0.18418239f, 0.04608270f, 0.09708944f, 0.06042856f, 
    -0.06387241f, -0.13995656f, -0.05992870f, -0.11324708f, -0.08446881f, 0.04359441f, -0.11228248f, 0.01411658f, 
    -0.12288979f, -0.06114763f, -0.07863115f, 0.04848814f, -0.09812215f, -0.13728240f, -0.22253513f, -0.02297047f, 
    -0.06484461f, -0.09661936f, 0.08002828f, 0.08282916f, 0.05928255f, 0.07872818f, 0.01231815f, -0.08640333f, 
    -0.19080564f, -0.01323666f, -0.12700686f, 0.09399676f, -0.06513581f, 0.08921306f, -0.05212170f, 0.00491635f, 
    -0.09529273f, -0.12934746f, -0.08376037f, 0.03255892f, -0.25624895f, -0.08124215f, 0.03462179f, -0.07458131f, 
    0.11917783f, 0.00498017f, -0.05319765f, -0.04258556f, 0.05233496f, 0.09593648f, 0.11053097f, -0.08075354f, 
    0.04237656f, 0.02528100f, -0.31444773f, 0.37663361f, 0.08173647f, 0.10387964f, 0.02200318f, -0.04345682f, 
    -0.15168644f, -0.05721729f, 0.02988956f, -0.02082476f, 0.54451823f, -0.01441824f, -0.02264468f, 0.01243397f, 
    -0.03985141f, -0.07465991f, 0.02783854f, 0.20858091f, -0.04501829f, 0.12004064f, 0.10157139f, 0.01983763f, 
    -0.17620778f, -0.09102436f, -0.09088255f, -0.00865597f, 0.00965799f, 0.01066821f, 0.08007655f, 0.08989680f, 
    0.09988824f, 0.08139034f, 0.19549695f, -0.07220223f, 0.35339069f, -0.26482332f, 0.02107958f, -0.09823756f, 
    0.04902184f, -0.12421499f, 0.18036316f, -0.01526589f, 0.08680969f, 0.01489657f, 0.13146575f, 0.01311765f, 
    -0.00905051f, -0.01012936f, -0.01944567f, 0.56560034f, 0.15336078f, 0.04616437f, -0.16998681f, 0.13032034f, 
    -0.04152656f, 0.02757072f, -0.14374462f, 0.01440165f, 0.05100936f, -0.01346609f, -0.07331291f, -0.00271548f, 
    -0.07903514f, -0.10054924f, -0.18299834f, -0.07688117f, 0.10195874f, -0.00589839f, 0.06551650f, 0.01348389f, 
    0.10191213f, 0.07592267f, -0.03624402f, -0.08254804f, -0.02451371f, 0.13956468f, 0.15413833f, -0.27030626f, 
    0.03399612f, 0.10670287f, 0.11725024f, 0.13165882f, -0.17181295f, -0.13455729f, 0.07040095f, 0.09852239f, 
    0.05624940f, 0.01939851f, 0.15634586f, 0.08988030f, 0.01629107f, 0.04770788f, -0.26611900f, -0.05734577f, 
    -0.42696142f, 0.13900189f, -0.24657685f, 0.03080771f, 0.16636109f, 0.03835543f, -0.04942998f, 0.07981971f, 
    -0.07102761f, 0.03674940f, 0.04125625f, 0.08669665f, 0.01780668f, -0.01335292f, 0.19059004f, 0.26094162f, 
    0.17279370f, 0.06224030f, -0.04358729f, 0.22744669f, 0.11330435f, 0.00541304f, 0.01165890f, -0.05970838f, 
    -0.19714634f, -0.00993852f, -0.20652270f, 0.01594643f, 0.03288604f, 0.03023506f, 0.07470416f, -0.06958967f, 
    -0.04038541f, 0.12673528f, 0.10174999f, -0.14837347f, -0.31437320f, -0.04907636f, -0.10262658f, 0.19937085f, 
    0.16254644f, -0.09823189f, 0.06799584f, -0.23195036f, -0.03532612f, 0.03736868f, -0.05765196f, 0.13870844f, 
    -0.17832297f, 0.02373024f, -0.04603728f, 0.07253811f, 0.01954075f, -0.04884375f, 0.04193946f, -0.11258081f, 
    -0.00200304f, 0.13631210f, -0.02027778f, 0.06500861f, 0.17884919f, 0.03363710f, 0.13293616f, 0.01545104f, 
    0.04500493f, 0.04098148f, 0.06827734f, 0.00560829f, 0.06175757f, 0.04913090f, 0.03771327f, -0.06006427f, 
    -0.01993556f, -0.06444374f, 0.24641867f, -0.09303059f, -0.01916543f, -0.10128415f, -0.09741811f, 0.05467054f, 
    0.11372223f, -0.12101946f, 0.01652210f, -0.15732530f, -0.03483451f, -0.14637530f, -0.17965487f, -0.04356453f, 
    -0.04634299f, 0.10612514f, -0.01681315f, -0.13856225f, 0.06311627f, 0.12707904f, 0.08232295f, 0.00619497f, 
    0.29969424f, -0.12281389f, -0.07305465f, -0.08299658f, -0.16883597f, 0.00834806f, 0.12222236f, 0.05578795f, 
    -0.06888634f, -0.10331050f, 0.04329399f, 0.08319154f, -0.09673630f, -0.09015162f, 0.22330381f, 0.08815891f, 
    0.06921526f, -0.13303930f, -0.01124727f, -0.01738518f, 0.06576797f, -0.09561606f, -0.08493859f, 0.02958667f, 
    -0.05730632f, -0.18256520f, 0.05670081f, 0.08961521f, -0.06358348f, 0.06180315f, -0.04564639f, -0.08183547f, 
    0.04232071f, -0.03930427f, 0.13490297f, 0.01992324f, -0.09398443f, 0.19512433f, 0.11733221f, -0.05833086f, 
    0.08324721f, 0.11171804f, -0.03778751f, 0.12186610f, 0.11444025f, 0.04269294f, -0.06366465f, 0.09005792f, 
    0.28770086f, -0.23462622f, 0.05162437f, -0.17817430f, -0.02783730f, -0.13687293f, 0.31329483f, -0.07098664f, 
    0.06552572f, 0.10841881f, 0.03210111f, -0.00656273f, 0.00950228f, -0.01054204f, -0.17969218f, -0.06673536f, 
    0.08100380f, 0.00282705f, 0.08526728f, -0.05394733f, 0.09959299f, 0.05112001f, -0.09289085f, -0.02632789f, 
    0.19815174f, 0.25668690f, -0.00200779f, -0.21228231f, 0.14090125f, -0.08172513f, 0.12915295f, 0.09642535f, 
    -0.02965149f, -0.13519698f, -0.04513765f, 0.04160239f, -0.24260780f, 0.03805945f, -0.03903131f, 0.08887535f, 
    -0.03076254f, -0.04611615f, 0.13507554f, -0.03864357f, 0.07888076f, 0.05085903f, -0.04052975f, 0.02291066f, 
    -0.06601029f, -0.25791964f, -0.06435331f, -0.12078325f, -0.01494677f, -0.03866372f, -0.00294841f, 0.03935812f, 
    -0.09823751f, 0.02490303f, 0.04926589f, 0.11152507f, -0.22880812f, 0.03977124f, -0.09530394f, 0.04877639f, 
    0.13205567f, -0.05952844f, -0.06430602f, 0.00983851f, 0.07333004f, 0.07874984f, -0.10815609f, 0.05185053f, 
    0.02424577f, -0.01823534f, -0.05599452f, -0.19651391f, 0.02453455f, 0.13565449f, 0.06988373f, 0.20457853f, 
    -0.01598933f, 0.00360240f, 0.12505335f, 0.05480863f, 0.29034775f, -0.12827623f, 0.25522172f, -0.15140592f, 
    0.17969549f, 0.06645913f, 0.06380786f, 0.07516056f, 0.11149985f, -0.06679861f, -0.03470009f, 0.18324013f, 
    0.01425498f, 0.07079262f, -0.11328562f, -0.02255717f, -0.25660020f, -0.16334441f, -0.02138342f, 0.02222120f, 
    0.12110507f, 0.17738682f, 0.07290133f, 0.04874496f, 0.08485942f, 0.07731909f, -0.04302758f, -0.05900801f, 
    0.12775519f, 0.10511322f, -0.04895926f, 0.06212690f, -0.00949583f, 0.10792868f, 0.01729749f, -0.02955277f, 
    0.14833699f, 0.13742900f, 0.10666347f, -0.03595534f, 0.11803228f, 0.06097114f, -0.02295861f, -0.04037990f, 
    -0.08877379f, -0.06637954f, -0.04308826f, -0.12844706f, 0.21774268f, -0.07621372f, -0.06770889f, -0.23837510f, 
    0.01836282f, -0.19482824f, -0.16181919f, -0.21679509f, 0.00479138f, -0.02733173f, 0.02831456f, -0.01341751f, 
    0.39088741f, 0.11230489f, 0.04742819f, 0.01108470f, -0.17495443f, 0.01781546f, 0.05885040f, 0.20201622f, 
    -0.02193157f, -0.03163377f, -0.04267851f, -0.11991952f, -0.14317550f, -0.30160844f, 0.33010152f, -0.22567369f, 
    0.12377223f, -0.04702084f, 0.02768644f, -0.03180162f, -0.09060065f, 0.09119019f, -0.14181958f, -0.01793935f, 
    0.29817793f, 0.04907728f, 0.11330841f, 0.15407145f, -0.13489489f, -0.06365018f, -0.09645338f, 0.12911998f, 
    -0.09051190f, 0.02345199f, -0.02640804f, 0.05325698f, 0.07869718f, 0.10470290f, 0.23038499f, 0.08054325f, 
    0.03531940f, 0.09687769f, -0.05531541f, 0.14572115f, 0.07888137f, 0.00776458f, 0.02539549f, 0.00824061f, 
    0.17228124f, -0.02100054f, 0.09592741f, -0.26633433f, -0.00329219f, 0.06826513f, 0.15513006f, 0.32033277f, 
    -0.03331027f, 0.00735531f, 0.05414894f, 0.11058641f, 0.18809427f, 0.22441034f, 0.02373713f, 0.06592263f, 
    0.02906368f, 0.07353463f, 0.14579624f, 0.19017202f, -0.04921814f, -0.02489227f, -0.01945617f, -0.18230630f, 
    0.29538858f, 0.06106773f, 0.15239027f, 0.19882478f, 0.13752492f, -0.03620597f, 0.04092663f, 0.23794346f, 
    0.09523154f, -0.07613908f, -0.10910191f, -0.06149177f, 0.00530334f, 0.27672634f, 0.16259705f, -0.43783286f, 
    0.01046029f, -0.19722912f, -0.01570019f, -0.03800434f, 0.14891544f, 0.03819460f, 0.08429570f, -0.03570658f, 
    0.19595565f, -0.19618624f, -0.09806316f, -0.07142106f, 0.04929166f, -0.02882868f, 0.01197949f, 0.03254231f, 
    -0.00433791f, 0.01904621f, -0.12326919f, -0.11380636f, 0.33703542f, 0.04109190f, 0.06004427f, 0.07974613f, 
    0.03775202f, -0.00457618f, 0.04235043f, 0.24057430f, -0.04703489f, 0.00591032f, -0.06273724f, -0.10653893f, 
    0.25052461f, 0.15988497f, -0.03963418f, -0.20672975f, 0.00530795f, -0.02786006f, -0.13322236f, 0.11694641f, 
    0.09976993f, -0.00127366f, -0.05872455f, 0.06726527f, 0.11850279f, 0.40340599f, 0.12639229f, -0.16119100f, 
    0.09847119f, 0.06548045f, -0.09791929f, -0.07130917f, -0.01694549f, -0.08934949f, -0.03611426f, 0.07613747f, 
    0.18893681f, -0.22901027f, -0.09580518f, 0.16670258f, -0.17619875f, 0.02557674f, 0.01497428f, -0.05866357f, 
    -0.06447700f, -0.04954436f, -0.12265289f, -0.13695519f, 0.17358170f, 0.20207882f, 0.13418686f, 0.28883001f, 
    0.04395101f, -0.00694198f, 0.04042272f, 0.15612525f, -0.07898025f, -0.00610749f, -0.03722915f, -0.06155794f, 
    0.11783047f, 0.11822551f, 0.05618996f, 0.27780113f, 0.01680773f, 0.01153380f, 0.01555687f, 0.04815320f, 
    -0.02709756f, -0.06161718f, -0.04637125f, 0.02002400f, -0.45565644f, 0.05041388f, 0.14356022f, -0.20296201f, 
    -0.25421846f, -0.18672927f, -0.12212734f, 0.01471918f, -0.05769030f, -0.00481716f, 0.17662518f, -0.02756894f, 
    -0.22724067f, 0.14223184f, -0.52514976f, -0.35879844f, 0.28639951f, 0.05131198f, -0.18219665f, -0.03032762f, 
    0.07305145f, -0.09327225f, 0.02668963f, -0.01958215f, 0.57178837f, 0.39135107f, -0.16252694f, -0.02007398f, 
    0.08119070f, 0.11338109f, 0.14834307f, 0.16609892f, 0.05328944f, 0.13859154f, 0.12541060f, 0.09838136f, 
    0.04459563f, 0.13832334f, 0.06113417f, 0.10061931f, -0.06215381f, -0.09998707f, 0.03033778f, -0.00287801f, 
    0.29348156f, 0.07290996f, 0.02053316f, -0.00028218f, -0.15720625f, -0.61956251f, 0.06525104f, -0.16925251f, 
    0.17091833f, 0.08441143f, 0.24444376f, -0.26152810f, -0.14462255f, 0.06691999f, 0.10178601f, 0.04593850f, 
    -0.10181862f, 0.11097697f, -0.32352352f, 0.33045405f, 0.28658924f, 0.26071787f, 0.03618558f, 0.11610806f, 
    0.02700155f, -0.04322590f, 0.16299590f, 0.06436130f, -0.10759836f, -0.22955941f, -0.21560428f, -0.17863300f, 
    -0.02364163f, -0.06161733f, -0.03061673f, -0.00070845f, -0.05125212f, -0.06735881f, -0.12461016f, -0.09540768f, 
    -0.27490830f, -0.82456702f, -0.55127966f, 0.14094661f, 0.06367197f, 0.04849510f, 0.09814525f, -0.08615041f, 
    -0.14369814f, 0.07643171f, 0.04783454f, -0.04845550f, -0.00144526f, -0.10820555f, 0.02526930f, -0.00435231f, 
    -0.04110651f, -0.01419396f, -0.07185029f, 0.07499204f, -0.04560990f, -0.13610168f, 0.02962871f, -0.14367044f, 
    0.33296359f, 0.09403367f, -0.22924778f, 0.10085113f, 0.09355428f, -0.13552195f, -0.04598305f, 0.09990191f, 
    0.15442568f, -0.05076754f, 0.07215766f, 0.00879311f, 0.34546524f, -0.07737443f, -0.08068549f, -0.09037525f, 
    0.09827554f, -0.03649790f, 0.26752031f, -0.16966635f, -0.07874775f, -0.07063385f, -0.08061861f, 0.01895685f, 
    -0.13547821f, -0.10799879f, 0.09749093f, 0.29021662f, 0.01426539f, 0.13316262f, -0.00203629f, -0.03885829f, 
    -0.03153173f, 0.03720991f, 0.09151422f, 0.10111059f, -0.59574980f, 0.27025610f, -0.31387067f, 0.03124159f, 
    -0.02946743f, -0.24711210f, 0.10173185f, -0.11624596f, 0.12441957f, -0.02657192f, 0.03775573f, -0.13684775f, 
    0.14924254f, 0.07375594f, 0.23232691f, 0.05819641f, 0.05423438f, -0.07587151f, 0.07107645f, -0.11542621f, 
    -0.01060744f, 0.13156965f, -0.08529178f, -0.02539163f, -0.07169962f, -0.38030463f, -0.11548939f, -0.12496763f, 
    0.03254049f, 0.03025449f, -0.00945944f, 0.11969447f, 0.07246623f, 0.03054446f, 0.07125794f, -0.04040318f, 
    -0.25826544f, -0.41821477f, -0.29036653f, -0.31017882f, -0.04927029f, -0.01134779f, -0.06413979f, -0.00098939f, 
    -0.07164639f, 0.04230755f, 0.00056682f, -0.11461452f, 0.06162291f, 0.12378697f, -0.01143511f, 0.11982280f, 
    0.06280079f, 0.13291158f, -0.00237371f, 0.02610367f, -0.00566319f, 0.05307987f, 0.12112729f, 0.02383076f, 
    0.33915487f, 0.11950985f, 0.25352591f, 0.00366598f, 0.07864177f, 0.04643192f, 0.07933478f, -0.03958492f, 
    0.01478945f, -0.07388242f, 0.07168604f, -0.02424439f, -0.35938677f, -0.33736721f, 0.13752799f, -0.13122050f, 
    0.02168983f, 0.11160137f, -0.21324196f, -0.05851914f, 0.01072343f, -0.03853546f, -0.07410397f, 0.08100156f, 
    -0.05953766f, -0.18176311f, -0.18995197f, -0.02743319f, -0.10927321f, -0.08465541f, -0.05361139f, 0.03024759f, 
    -0.28611982f, -0.07153831f, -0.06268863f, 0.03362277f, -0.02293745f, 0.24704361f, 0.13811630f, 0.20662297f, 
    0.01797296f, 0.15413497f, -0.09896565f, 0.08542924f, -0.08813421f, 0.02293531f, -0.00131298f, 0.11394255f, 
    0.18343195f, 0.11338690f, 0.12231199f, -0.31710759f, -0.15762253f, -0.03522690f, -0.00776644f, -0.10256545f, 
    -0.02492114f, -0.01313039f, 0.06924007f, 0.13473041f, 0.15986402f, 0.14331031f, 0.25517309f, 0.20286548f, 
    -0.09213333f, -0.03829169f, 0.12815653f, 0.01560423f, -0.06246532f, 0.01094600f, -0.00478434f, 0.01765442f, 
    0.25918278f, 0.14129187f, 0.29624113f, 0.23968320f, -0.05359974f, 0.08113953f, 0.08304514f, 0.06468182f, 
    0.04996681f, -0.03068304f, -0.11656646f, 0.03432236f, -0.10175499f, 0.12973893f, -0.04150310f, -0.21653104f, 
    -0.16818240f, 0.13621061f, -0.13355270f, -0.14071283f, -0.00446749f, -0.12747632f, 0.08122401f, -0.08783139f, 
    0.34925529f, -0.02357798f, 0.26472870f, 0.23076327f, 0.00017957f, 0.07230740f, -0.02106291f, -0.12335502f, 
    -0.03016787f, -0.12886845f, -0.02890764f, 0.05939552f, 0.09267231f, -0.06937926f, -0.08594143f, -0.24607994f, 
    -0.06630126f, -0.00906536f, 0.01425068f, -0.05405860f, 0.00863438f, 0.03547000f, -0.03400996f, -0.04150121f, 
    0.20732708f, 0.19657753f, 0.04512734f, 0.10754854f, 0.02528744f, 0.07929668f, 0.03549318f, 0.02492257f, 
    -0.00598464f, -0.05104845f, -0.03585160f, 0.01315181f, 0.26119915f, 0.40608954f, 0.09218886f, -0.04910443f, 
    0.11024611f, 0.05184729f, 0.12847002f, -0.01439611f, 0.08193035f, -0.04843340f, 0.07917994f, 0.03559341f, 
    -0.33337405f, -0.46294123f, -0.42258373f, -0.22069013f, -0.15120688f, 0.01821845f, 0.06249633f, 0.04773602f, 
    -0.09288090f, -0.06282177f, -0.05486448f, 0.03354989f, 0.14548700f, 0.23619756f, 0.22702944f, 0.15331763f, 
    -0.19402958f, -0.00929976f, 0.00923470f, 0.13004744f, -0.08785143f, 0.04599857f, -0.05935120f, 0.06440865f, 
    -0.21368863f, -0.18796718f, -0.11113852f, 0.18669493f, -0.03833836f, 0.00940072f, 0.04758096f, 0.01581720f, 
    -0.04475856f, -0.12738948f, -0.02602753f, -0.06351056f, -0.21807337f, 0.10886636f, -0.09258723f, -0.28053641f, 
    0.07994903f, -0.11857815f, -0.08934843f, -0.02752198f, 0.02934181f, 0.02879110f, 0.08538149f, 0.13259099f, 
    0.19964935f, 0.18655132f, -0.42906323f, -0.00822113f, -0.01253957f, 0.06002765f, 0.14376496f, 0.01788615f, 
    -0.10277763f, 0.00915538f, 0.04107140f, -0.05386128f, 0.25110611f, -0.07161846f, -0.21634269f, -0.13724205f, 
    -0.02192698f, -0.18333736f, 0.08789057f, 0.10478609f, -0.04024222f, 0.02980597f, -0.16018893f, -0.10706726f, 
    0.02578856f, -0.05658886f, -0.06552593f, 0.15991348f, -0.00869868f, -0.05723321f, -0.12200651f, 0.03842717f, 
    -0.05987899f, -0.07074258f, 0.15138701f, -0.14163026f, -0.01006602f, -0.02450941f, 0.14099474f, -0.17733106f, 
    -0.03051747f, 0.07977799f, 0.00096751f, -0.01980272f, 0.03913371f, 0.03136539f, -0.04940873f, -0.01677017f, 
    0.09105493f, -0.24103802f, 0.20185038f, -0.08838871f, 0.13339601f, 0.21726955f, -0.05942166f, 0.29603973f, 
    0.10836164f, 0.00383734f, -0.14168766f, 0.02978167f, 0.15723129f, 0.14018641f, -0.06006021f, 0.09103662f, 
    0.13840999f, 0.02347913f, 0.01108496f, 0.06559272f, 0.08512073f, -0.11180589f, 0.06280252f, 0.00801509f, 
    0.07111272f, 0.18895608f, 0.17323470f, 0.03204826f, -0.00286918f, 0.07782585f, 0.02493720f, 0.07948507f, 
    0.01543319f, 0.07805280f, 0.13778117f, -0.04750795f, -0.05408359f, -0.12886070f, -0.08516360f, -0.05671679f, 
    0.03127815f, 0.00367135f, 0.26805627f, 0.03486414f, 0.09723110f, 0.16675283f, -0.20691694f, 0.06900016f, 
    0.07690249f, 0.04270637f, -0.35419452f, -0.11454004f, -0.03580702f, -0.00326345f, -0.24855766f, 0.14068973f, 
    0.04525015f, -0.09553499f, -0.05500640f, -0.03352123f, -0.08481423f, -0.17960279f, -0.20789918f, -0.03404411f, 
    0.12533218f, 0.11473800f, -0.10940037f, 0.10966415f, -0.09459683f, 0.02081917f, 0.04709712f, -0.06760305f, 
    0.01700756f, 0.07685417f, -0.12920159f, -0.12414194f, 0.11171041f, -0.08246807f, 0.00256740f, 0.09157657f, 
    0.05435237f, -0.01991541f, 0.17946805f, 0.00552718f, -0.16197830f, 0.23715170f, -0.07804051f, -0.10491779f, 
    -0.02814503f, -0.06487931f, -0.03491155f, -0.13645367f, -0.02616496f, 0.04882549f, -0.04631693f, -0.01874026f, 
    0.04752368f, 0.01767539f, 0.09481017f, 0.13692501f, -0.03548627f, 0.03367829f, -0.07419433f, -0.05248987f, 
    -0.04832732f, 0.12235652f, -0.08032648f, 0.08533973f, 0.24039546f, 0.23176464f, 0.09671241f, 0.12586561f, 
    0.08484377f, -0.03183915f, 0.07234009f, 0.07684052f, -0.03300761f, 0.04273976f, 0.06802853f, -0.05921001f, 
    -0.11850005f, -0.16230719f, -0.12621893f, -0.00180028f, 0.01284065f, 0.08895501f, -0.02494118f, 0.02878355f, 
    0.03470865f, -0.17511557f, -0.07140285f, 0.10253578f, -0.04587174f, 0.31747973f, 0.44402558f, 0.24411836f, 
    0.11402120f, -0.01227580f, 0.06557555f, 0.10668599f, 0.16522433f, -0.07704581f, 0.03114123f, -0.06711181f, 
    -0.20770337f, -0.12763001f, 0.05050127f, 0.14664547f, -0.06871180f, 0.03999076f, -0.07345986f, -0.11235810f, 
    -0.02143425f, -0.13885665f, -0.13121910f, 0.09194760f, 0.46066499f, 0.27013770f, -0.14082019f, 0.05593878f, 
    -0.12859082f, 0.10782310f, 0.08989443f, 0.14483023f, 0.00770416f, 0.11484183f, 0.14352925f, -0.05791531f, 
    -0.09943832f, -0.18777084f, -0.17082314f, -0.05153530f, 0.06314040f, -0.01790241f, 0.03164028f, 0.08346194f, 
    0.07696076f, 0.08073746f, 0.19969065f, 0.05198720f, -0.02727511f, -0.15793188f, -0.01606064f, 0.01867830f, 
    0.04593405f, -0.09925584f, 0.12285465f, -0.04751197f, 0.02787778f, -0.04931222f, 0.09438113f, 0.16042374f, 
    -0.16298774f, -0.08472821f, 0.27511701f, 0.34964541f, 0.26209873f, -0.01416283f, -0.02654710f, -0.02041548f, 
    0.02113875f, 0.02902772f, -0.15137738f, -0.05813686f, -0.04121958f, -0.01670494f, 0.00037467f, -0.06135113f, 
    -0.10899808f, -0.12299965f, -0.19497186f, -0.12776193f, 0.04216535f, -0.10864571f, -0.07723452f, -0.16630286f, 
    -0.25420791f, -0.14391559f, 0.11897651f, 0.05359798f, -0.10183223f, -0.03965025f, 0.00677756f, -0.19073606f, 
    0.00607744f, -0.04085950f, 0.09289823f, 0.13364942f, 0.06148298f, -0.08290328f, -0.05569474f, 0.24615829f, 
    0.01773447f, 0.05096127f, 0.01158100f, -0.04932087f, 0.18867563f, 0.01153864f, -0.11445159f, 0.04679646f, 
    -0.41556519f, 0.17495339f, 0.12475387f, 0.02590108f, 0.02070824f, -0.13713016f, 0.11037070f, -0.01007232f, 
    -0.09177889f, 0.11408993f, 0.00219137f, 0.03405914f, -0.09994439f, 0.04059350f, 0.17921065f, 0.20033455f, 
    0.14040682f, 0.01740197f, -0.03436505f, 0.25165123f, 0.00695461f, 0.03364176f, -0.12138755f, -0.17859888f, 
    -0.27085319f, 0.00136496f, 0.04577031f, 0.04475163f, -0.00435420f, 0.04405794f, 0.07539426f, -0.02978370f, 
    0.03846556f, 0.13525808f, 0.15148655f, -0.01199304f, -0.04505762f, -0.25376496f, 0.10145850f, 0.50128508f, 
    0.00071594f, -0.03741498f, 0.02814534f, -0.09738825f, -0.18023822f, 0.02485611f, 0.02062958f, 0.19870692f, 
    -0.10008202f, -0.04805443f, -0.05679170f, -0.11362261f, 0.21201010f, 0.02103533f, -0.04311806f, 0.02168220f, 
    -0.00080265f, 0.02683253f, 0.10395186f, -0.01891533f, 0.01852148f, 0.05649073f, 0.18525198f, 0.08318137f, 
    0.00389603f, 0.14028339f, 0.11210013f, -0.14483534f, 0.02137455f, 0.18678036f, 0.10770454f, -0.08547620f, 
    0.06394123f, -0.03669450f, -0.14812739f, 0.05047053f, 0.14927489f, 0.09938639f, 0.17796716f, -0.06621126f, 
    -0.10907976f, 0.02631802f, 0.06805640f, 0.02313244f, -0.30406034f, 0.35547149f, 0.26691076f, -0.00677028f, 
    -0.09468275f, -0.01346643f, -0.13200806f, 0.20651583f, 0.12258759f, 0.01020341f, 0.10781489f, -0.06426322f, 
    0.25908905f, -0.10676083f, 0.00712500f, 0.03486767f, 0.10670616f, 0.00439822f, -0.08163388f, 0.05560922f, 
    0.08440580f, -0.14196122f, -0.07102747f, 0.01546033f, 0.06139191f, 0.13562588f, -0.10235973f, -0.26165032f, 
    0.30164182f, -0.03419292f, 0.03886554f, 0.15352519f, 0.03418633f, 0.01888058f, 0.15357217f, 0.11618529f, 
    -0.01117834f, -0.05430430f, -0.10554418f, -0.10369170f, -0.01578994f, -0.10249152f, 0.05373142f, 0.07610183f, 
    0.07549115f, 0.10113579f, 0.13318028f, 0.11273857f, -0.30538747f, 0.00199522f, -0.00457868f, -0.08648627f, 
    0.04552106f, 0.03318199f, 0.00203210f, -0.05755568f, 0.04558295f, 0.09381951f, 0.04981807f, 0.16503394f, 
    0.40289032f, -0.45062432f, 0.29563066f, -0.24196984f, -0.07705142f, 0.00115799f, 0.00623258f, 0.12523264f, 
    0.07615925f, -0.08065468f, -0.03874044f, 0.05891462f, 0.03008706f, -0.01095773f, 0.00195576f, -0.10334016f, 
    0.08748685f, -0.14225678f, -0.05744979f, 0.07190871f, -0.05978842f, -0.05433175f, -0.18725732f, -0.10330372f, 
    -0.03529308f, -0.15920772f, 0.13090789f, -0.01462483f, -0.17985782f, -0.03661644f, -0.04459316f, -0.17250369f, 
    -0.00223871f, 0.05152283f, -0.03030320f, 0.08702526f, 0.06145426f, 0.25847891f, -0.07165027f, 0.00624112f, 
    0.08142931f, 0.15997407f, 0.14494818f, 0.00295468f, 0.10258900f, -0.26246628f, 0.14231099f, 0.13915925f, 
    0.08683296f, -0.14079267f, 0.06697980f, -0.13173540f, -0.10981621f, -0.11488647f, -0.02287295f, 0.04980626f, 
    -0.04909869f, -0.00064576f, 0.02241998f, 0.04665633f, -0.04436668f, 0.00335451f, -0.01890730f, -0.01155085f, 
    0.12882659f, 0.08422868f, -0.03405350f, 0.28225252f, 0.05238990f, -0.13596879f, 0.06430069f, -0.12243592f, 
    -0.04564149f, 0.18320380f, 0.09393692f, -0.01781464f, 0.01672032f, 0.08205857f, -0.07354685f, 0.02865263f, 
    -0.06331734f, 0.02659133f, 0.09028685f, -0.03951651f, 0.19762816f, 0.15190311f, -0.12071538f, 0.12774312f, 
    -0.05730368f, -0.01025293f, 0.22844261f, -0.01987650f, 0.06010000f, -0.03093768f, 0.08390660f, -0.02087237f, 
    -0.10308992f, 0.00616004f, -0.02588854f, 0.14691658f, 0.09620318f, -0.10579155f, -0.09140690f, 0.01049030f, 
    0.03896006f, 0.10128433f, -0.14418052f, 0.03695491f, 0.05834090f, 0.20632979f, 0.13730958f, -0.14363350f, 
    -0.10398714f, -0.10016439f, 0.04697785f, 0.05042498f, 0.00347905f, 0.12464941f, 0.05110871f, -0.13238315f, 
    0.08684441f, -0.03690851f, 0.03729217f, 0.01983779f, -0.04488443f, -0.06553048f, -0.03696332f, -0.04559506f, 
    0.08248232f, -0.06843556f, -0.03101521f, -0.12052032f, 0.02768302f, 0.09578246f, 0.03601902f, -0.05859069f, 
    -0.12452000f, -0.04353679f, -0.12106590f, 0.05395720f, -0.03047742f, 0.14278956f, 0.00012721f, 0.02953178f, 
    0.24459742f, -0.17467448f, -0.31819800f, -0.29713574f, -0.25945553f, -0.01971379f, 0.15672012f, -0.03584206f, 
    -0.04277030f, 0.04553798f, 0.09580380f, 0.04197303f, -0.00705866f, 0.29759377f, -0.14187637f, -0.13889816f, 
    0.23973925f, -0.08863297f, 0.11010230f, 0.11243164f, 0.04981568f, -0.03820326f, 0.02501382f, 0.13897213f, 
    0.03434096f, 0.10978676f, 0.07301209f, 0.05233695f, 0.02754624f, -0.01851621f, 0.05336247f, -0.04506163f, 
    -0.15321586f, -0.09099992f, -0.04800950f, -0.12246746f, -0.15199289f, -0.08481167f, -0.03616160f, -0.05497652f, 
    0.08572675f, 0.25662953f, 0.09350821f, 0.11677504f, 0.07083772f, 0.07775176f, -0.01133716f, 0.18377379f, 
    0.22190461f, -0.37165123f, 0.26573744f, -0.29305360f, 0.17124517f, 0.05725341f, 0.12675749f, -0.16861452f, 
    0.08820663f, 0.00105917f, 0.02288073f, 0.08668159f, -0.09757639f, -0.11762180f, -0.17203133f, -0.13803639f, 
    -0.03848339f, -0.07989820f, 0.03871787f, -0.03649170f, 0.00748600f, -0.00126396f, 0.03200024f, 0.09190318f, 
    -0.07791094f, -0.05024084f, 0.01936794f, -0.16100729f, -0.07710234f, -0.10657570f, 0.09669320f, 0.09282245f, 
    0.06962793f, 0.08975422f, 0.05334185f, 0.02936209f, -0.02472926f, -0.13627878f, -0.18642598f, -0.07262204f, 
    -0.12993440f, 0.06841455f, -0.15824999f, 0.04183161f, -0.07077684f, 0.02991006f, -0.02305360f, 0.09841692f, 
    -0.00087458f, -0.03824098f, -0.08339282f, -0.13667330f, -0.02339448f, 0.10691554f, 0.05766204f, 0.09456959f, 
    0.11115158f, 0.01702616f, 0.17512093f, 0.13936488f, -0.19666316f, -0.00024307f, -0.26795176f, -0.01960107f, 
    0.14356336f, 0.08101892f, 0.11045371f, -0.14414106f, -0.02760367f, -0.06210962f, 0.12400775f, 0.05056043f, 
    -0.09716124f, -0.00967036f, 0.06444801f, -0.22024202f, -0.09701379f, 0.13552298f, 0.12710698f, 0.36700672f, 
    0.10501640f, -0.03275222f, 0.16874188f, 0.00015636f, 0.02708786f, -0.16782363f, 0.02786998f, -0.21045052f, 
    -0.10311440f, -0.18683490f, 0.12209353f, 0.06836101f, 0.20155978f, 0.07021849f, -0.02312607f, 0.05850277f, 
    0.04806017f, 0.06008491f, 0.14490846f, 0.17977978f, -0.02171896f, -0.05929134f, -0.01540117f, -0.09836611f, 
    -0.10469012f, -0.01077801f, 0.05869046f, 0.00343282f, -0.18976282f, 0.01681356f, -0.12769210f, -0.19338146f, 
    0.02998207f, 0.03544391f, 0.21948196f, 0.20706838f, 0.08085091f, 0.03226689f, -0.05321296f, 0.05629686f, 
    0.00470621f, -0.11070392f, 0.12865268f, -0.10079720f, 0.12101179f, -0.04710237f, 0.02491632f, 0.06072986f, 
    0.02716428f, 0.04258742f, 0.01224466f, -0.01471181f, -0.11477155f, -0.16999316f, -0.08339698f, 0.06651916f, 
    0.09101283f, 0.16545115f, 0.10617954f, -0.14833646f, 0.11150073f, 0.19162348f, 0.05360311f, 0.06020965f, 
    0.08665807f, -0.18861307f, -0.10467979f, -0.11216138f, -0.05518926f, 0.11171284f, 0.01129432f, 0.07599835f, 
    -0.08135083f, -0.08266315f, -0.04917585f, 0.07949919f, -0.08136388f, 0.03201273f, 0.16240776f, 0.13736221f, 
    0.05439519f, 0.09365342f, -0.04151574f, -0.03529294f, -0.05032869f, -0.01009156f, 0.11081541f, 0.16302374f, 
    -0.21243978f, -0.15026432f, -0.09714907f, -0.03080577f, -0.06248109f, -0.01160187f, 0.00647629f, -0.07168109f, 
    0.12965299f, 0.01995671f, -0.03708417f, 0.09783351f, 0.09861603f, 0.03890207f, 0.08522943f, 0.00640655f, 
    0.08631103f, 0.07678018f, -0.00636962f, 0.15035796f, -0.01014149f, -0.02204466f, -0.09357528f, -0.09522969f, 
    0.26418498f, -0.01009976f, -0.10361245f, -0.08824369f, 0.09870598f, -0.07439674f, 0.13866155f, -0.28450477f, 
    0.05324272f, 0.00674596f, -0.07628709f, -0.06144608f, 0.14827770f, -0.03311013f, -0.09909567f, -0.00366630f, 
    0.06208028f, 0.14000493f, 0.15040104f, -0.21333301f, 0.08044373f, -0.00235754f, -0.05077860f, -0.00394879f, 
    0.13732257f, 0.30998394f, -0.11581270f, -0.22442256f, 0.17849998f, 0.00602325f, 0.23910363f, 0.13515086f, 
    0.01877556f, -0.11452729f, -0.00698428f, -0.03882283f, -0.05966513f, -0.05989609f, -0.10996017f, 0.14661248f, 
    0.05390660f, -0.02017527f, 0.17155682f, 0.02008860f, 0.07724325f, 0.15040775f, -0.03443349f, 0.05696445f, 
    -0.00728147f, -0.17323250f, 0.00013861f, -0.07422601f, 0.06903002f, 0.20438091f, 0.12868966f, 0.00670956f, 
    0.08351827f, 0.06327971f, 0.02287210f, 0.03069708f, -0.23235430f, 0.01145939f, -0.01531858f, 0.22661230f, 
    0.07787150f, -0.02643649f, 0.01918565f, -0.11166552f, 0.02552226f, -0.03321547f, -0.01987525f, 0.08591251f, 
    0.03529658f, -0.04424880f, -0.10391227f, -0.06955159f, -0.09323856f, 0.13984013f, -0.00627245f, 0.11636926f, 
    0.04018340f, -0.17300661f, -0.02599524f, 0.02930391f, 0.14656007f, -0.20857482f, 0.26043251f, -0.12463137f, 
    0.10751627f, -0.00845661f, 0.02277213f, 0.06223689f, 0.03129971f, 0.05065602f, -0.01947380f, 0.08364859f, 
    -0.17756842f, -0.00647507f, -0.20644696f, 0.15321182f, -0.12623125f, -0.05689722f, -0.00920006f, 0.07728902f, 
    -0.00144793f, -0.00317544f, 0.15335114f, 0.11525381f, 0.03751690f, 0.02446930f, -0.05579294f, -0.06955758f, 
    0.07711875f, 0.06975717f, 0.09338268f, -0.00784890f, -0.04675952f, -0.01930477f, -0.17657763f, 0.00670702f, 
    -0.22818966f, 0.03548890f, 0.02505473f, -0.22826986f, -0.07245380f, -0.11881451f, -0.00435201f, -0.11070307f, 
    -0.03212084f, -0.02009698f, 0.00636729f, 0.03828276f, 0.13739523f, -0.18165787f, -0.01795951f, 0.23561913f, 
    0.00865090f, 0.20636433f, 0.14782862f, 0.10915832f, 0.00032177f, 0.11397586f, -0.09470019f, -0.04000837f, 
    -0.22158127f, 0.05667663f, -0.07804334f, 0.25317901f, 0.11535266f, 0.01652873f, -0.03336274f, -0.11287660f, 
    -0.00661853f, 0.05202976f, -0.06145097f, 0.24782963f, -0.16943206f, 0.00176664f, 0.10229162f, 0.14259028f, 
    0.02178759f, 0.12571007f, -0.02272061f, -0.05600489f, 0.06081497f, 0.01811749f, -0.06888513f, 0.11266535f, 
    -0.31494340f, -0.09608258f, -0.15624398f, -0.01395109f, 0.01768672f, 0.05626447f, -0.01908401f, -0.00803292f, 
    -0.03308103f, 0.16074064f, -0.02099723f, -0.03301199f, 0.34454691f, -0.09224606f, -0.06919251f, 0.21805941f, 
    0.05879192f, -0.08861534f, 0.04525781f, -0.00307505f, -0.03293418f, 0.02748987f, 0.10042825f, -0.06429099f, 
    0.16205952f, 0.40467209f, -0.17637607f, 0.54440624f, 0.06388450f, 0.01621766f, -0.05733194f, -0.29569647f, 
    0.05416842f, -0.02310214f, 0.02015948f, 0.09279881f, 0.11176066f, -0.07096920f, 0.00435624f, 0.24726073f, 
    -0.05472773f, 0.25179666f, -0.01762102f, -0.30121449f, 0.10408839f, -0.00124851f, 0.11068019f, 0.11131823f, 
    0.22607754f, 0.06174443f, -0.30008250f, -0.23672983f, 0.04564462f, 0.11728378f, 0.10472246f, 0.02831786f, 
    -0.06528345f, -0.01191364f, 0.11034827f, 0.06197876f, -0.24312848f, -0.16472271f, 0.08115719f, -0.03372702f, 
    0.06359099f, -0.12626052f, -0.02720255f, 0.01232501f, -0.15273522f, 0.11126612f, -0.12090129f, -0.17898522f, 
    -0.04681754f, -0.08877031f, -0.08727410f, 0.34941792f, 0.15983404f, 0.17130788f, 0.10531668f, -0.00212964f, 
    0.12368827f, 0.07982061f, 0.13582711f, 0.07731127f, -0.12924141f, -0.03926559f, 0.15934384f, 0.10320015f, 
    -0.01985439f, 0.03853471f, -0.11488169f, -0.04459190f, 0.07460973f, 0.03660984f, -0.02125328f, 0.05024425f, 
    0.04186994f, -0.19480556f, -0.20351082f, 0.32736558f, 0.02253858f, 0.01299935f, -0.03348859f, -0.04305720f, 
    -0.04913148f, -0.05706352f, -0.04374028f, 0.04194099f, -0.05436596f, 0.03222329f, -0.13263558f, -0.01327820f, 
    0.08337850f, -0.01813027f, 0.20006309f, 0.09639075f, 0.01411102f, -0.02012143f, 0.03737142f, 0.15113129f, 
    -0.15571161f, 0.16349107f, -0.07547876f, -0.12059007f, -0.06606117f, -0.04640357f, -0.08129453f, -0.04426528f, 
    -0.01734460f, 0.03295077f, 0.17664155f, 0.01536389f, 0.18086226f, -0.06685267f, -0.14357838f, -0.01460680f, 
    0.07807972f, 0.02208341f, 0.06788028f, -0.00407820f, -0.03145324f, -0.00264803f, 0.10586196f, 0.10389284f, 
    0.19868851f, 0.17989793f, 0.05281068f, 0.05148283f, -0.02857414f, 0.11009850f, -0.00042570f, -0.01436018f, 
    -0.01447267f, 0.01145001f, 0.06017610f, 0.05648842f, 0.06934478f, -0.32706377f, -0.24711061f, -0.55679494f, 
    -0.04139551f, -0.13069716f, -0.00093773f, 0.07224123f, 0.03107223f, 0.10499589f, 0.03245018f, -0.05395810f, 
    0.10435127f, -0.05053798f, -0.18779071f, -0.09854374f, 0.06217372f, -0.05033334f, -0.14503106f, 0.15915628f, 
    -0.05943288f, -0.00198025f, -0.07876384f, -0.01204886f, 0.25666291f, -0.05668619f, 0.00972690f, -0.01816900f, 
    -0.07167812f, 0.18786885f, 0.13224290f, 0.33239886f, 0.05218839f, 0.17245989f, 0.18231224f, -0.00850909f, 
    0.16075936f, -0.00446470f, 0.10674609f, 0.08701394f, -0.10673790f, -0.05939265f, -0.04900437f, 0.01035231f, 
    0.54325664f, 0.35622174f, 0.09144190f, 0.12671502f, -0.37426051f, -0.58823758f, 0.00854969f, -0.31516096f, 
    0.05822270f, 0.04554802f, 0.05190735f, 0.04388953f, -0.05501295f, 0.01873502f, 0.14736857f, -0.04150220f, 
    -0.07295371f, 0.14003795f, -0.04736483f, 0.04213375f, 0.08886627f, 0.18934761f, 0.25106546f, 0.37836170f, 
    0.05719354f, 0.21229577f, 0.00673212f, 0.07024541f, 0.10683773f, 0.13980608f, -0.10717606f, 0.10282190f, 
    0.04981558f, 0.05276522f, 0.10565301f, 0.09866679f, -0.05466471f, -0.13315371f, -0.09293405f, -0.14952612f, 
    -0.39079076f, -0.30529913f, -0.31645104f, -0.01246299f, 0.01387512f, -0.11573806f, -0.11140655f, 0.09772649f, 
    -0.05948972f, -0.01377362f, 0.02090243f, 0.07075319f, 0.06671710f, -0.19393782f, 0.01952561f, -0.03993259f, 
    0.06519426f, 0.15041287f, -0.03653354f, 0.10587158f, -0.05733139f, -0.11895139f, -0.05057546f, -0.17759916f, 
    -0.04340311f, -0.27389437f, -0.31411901f, 0.00845033f, 0.07813742f, -0.12105741f, 0.08045067f, 0.20075138f, 
    0.07420927f, 0.09102920f, 0.08643291f, 0.05493391f, 0.44961545f, 0.07726685f, 0.09431166f, -0.07981690f, 
    0.03048012f, 0.05148395f, 0.14222884f, -0.10929504f, -0.11435518f, 0.06876638f, -0.16582325f, 0.03267845f, 
    -0.28779873f, -0.18284270f, -0.15215930f, -0.05514677f, -0.06334240f, -0.02278183f, 0.09173093f, -0.04243207f, 
    -0.02153081f, 0.05336513f, 0.06093725f, -0.00254830f, -0.35404992f, 0.04621341f, -0.19073993f, -0.36614782f, 
    -0.01896299f, 0.00876254f, -0.02417100f, 0.07832021f, -0.12670954f, 0.08513529f, 0.02978988f, -0.12359087f, 
    0.18621281f, 0.12112253f, 0.23623507f, 0.07217252f, -0.12004824f, 0.03375501f, 0.04459310f, -0.11611979f, 
    0.00892886f, 0.10364658f, -0.00206643f, -0.02151131f, -0.46704960f, -0.24780340f, 0.10987348f, 0.21303052f, 
    -0.14049330f, -0.07490393f, 0.10543758f, 0.14151600f, -0.03041495f, 0.02372912f, 0.11505067f, 0.02022834f, 
    0.08079359f, 0.41541195f, 0.10966501f, -0.24813311f, -0.25722945f, -0.12547761f, -0.01285835f, -0.09085952f, 
    0.04189256f, 0.13180600f, -0.19045547f, -0.04069702f, 0.37137517f, -0.56972897f, -0.43096936f, -0.12049250f, 
    -0.06600866f, 0.08940636f, -0.09163062f, -0.03015900f, 0.00732704f, 0.07341991f, 0.04408347f, 0.04198888f, 
    -0.07381696f, 0.19567668f, 0.05213531f, 0.28634271f, 0.11539479f, 0.02483089f, 0.17910609f, 0.13909708f, 
    -0.05357989f, 0.12200382f, -0.11747728f, -0.02445193f, -0.05373321f, -0.17916586f, 0.35052729f, -0.01324396f, 
    0.13381179f, 0.00118983f, -0.02735617f, 0.05079917f, 0.05633068f, 0.07156724f, 0.05182092f, 0.05929058f, 
    -0.03884716f, 0.03309255f, 0.17669070f, -0.07195293f, -0.17610253f, -0.12955646f, -0.16458425f, -0.16723426f, 
    -0.09594034f, -0.03235601f, -0.05536865f, -0.02326735f, 0.30013645f, 0.11239409f, 0.19699880f, 0.05167513f, 
    0.09575681f, -0.00779414f, 0.15852526f, 0.17057021f, -0.03937832f, -0.03359813f, -0.09584901f, -0.14305878f, 
    -0.03935023f, 0.36977705f, -0.25397718f, 0.23901354f, -0.04234679f, 0.14810781f, 0.17653523f, 0.11624301f, 
    -0.06176789f, 0.03980565f, 0.05910542f, -0.02058885f, -0.00165777f, 0.04239256f, 0.00723234f, 0.32036790f, 
    -0.07216121f, 0.10673086f, 0.10617007f, 0.21592171f, 0.08589578f, 0.18570602f, 0.05073769f, 0.12834887f, 
    0.28644207f, 0.12933870f, -0.18708794f, -0.06266085f, 0.14682612f, -0.04070063f, 0.02373794f, 0.05041271f, 
    -0.05689894f, -0.06298872f, -0.02294250f, -0.05568773f, -0.15555388f, -0.10902853f, 0.07714080f, -0.07420397f, 
    -0.10521957f, -0.16474172f, -0.04702898f, 0.08418078f, 0.00766960f, 0.16024174f, -0.00067171f, -0.11197983f, 
    -0.20633401f, -0.24006332f, -0.07346748f, 0.15929629f, 0.13730456f, 0.14055438f, 0.05051620f, 0.14473049f, 
    0.00626020f, -0.00884792f, -0.02283518f, 0.03655474f, 0.10634217f, -0.02551135f, 0.29824755f, 0.20752920f, 
    -0.07700667f, 0.04943258f, -0.02702045f, -0.08521304f, -0.07640082f, 0.04142855f, -0.01146205f, 0.14036310f, 
    -0.05222991f, -0.12007267f, -0.12312839f, 0.15213621f, 0.04172244f, 0.02057083f, 0.04358088f, 0.02243474f, 
    -0.05664555f, -0.07643211f, -0.10613586f, -0.08890534f, 0.17157726f, -0.04790814f, 0.05745947f, -0.25561923f, 
    0.22572590f, 0.05822723f, 0.03404416f, 0.08791524f, 0.07498214f, 0.11009908f, -0.02404558f, -0.08036138f, 
    0.07787748f, 0.07733230f, 0.07273441f, -0.16479723f, -0.13438629f, 0.03056384f, -0.09628480f, -0.12542641f, 
    0.04084848f, 0.05800191f, 0.08975802f, 0.04048778f, -0.05111026f, -0.24093814f, -0.07498700f, 0.22838283f, 
    0.02014486f, 0.01731504f, 0.09846573f, 0.11376730f, -0.00569937f, -0.10065183f, 0.04492277f, -0.00417715f, 
    0.04151743f, -0.07280555f, -0.04959272f, -0.05443864f, 0.04844314f, -0.06130854f, 0.06290898f, -0.06128241f, 
    -0.06469582f, 0.05697574f, -0.07206315f, -0.02086012f, -0.03856254f, -0.01192080f, 0.03310983f, -0.04286239f, 
    -0.05531918f, 0.04330435f, -0.06153401f, 0.03272934f, -0.06088082f, 0.01356754f, 0.01327977f, 0.04943046f, 
    -0.07157755f, -0.01692155f, -0.03033692f, -0.01716349f, -0.00204785f, 0.04295388f, 0.05310666f, 0.00688446f, 
    -0.05862971f, -0.04435971f, 0.03618436f, -0.02650095f, 0.03619536f, -0.03085641f, -0.02235159f, -0.06161791f, 
    -0.02694574f, -0.05064796f, 0.04962244f, 0.03425368f, 0.03680303f, 0.06044238f, 0.02343636f, -0.03759736f, 
    0.02510429f, -0.03601104f, 0.01744709f, 0.01001893f, 0.05176375f, -0.03122513f, -0.02468569f, 0.05147633f, 
    0.06852569f, 0.02440977f, -0.05219295f, 0.00307796f, -0.06272043f, 0.00406511f, -0.01955172f, 0.00894723f, 
    0.00731772f, -0.06304839f, 0.00165053f, -0.06661844f, -0.04871754f, 0.04449578f, 0.02507319f, -0.07590855f, 
    -0.03591828f, -0.06174412f, -0.03622301f, -0.03848741f, 0.01473741f, 0.05523421f, 0.04781240f, -0.00367003f, 
    0.03069311f, 0.06672648f, 0.05133810f, -0.04209814f, -0.02217600f, -0.05155862f, -0.05366848f, -0.03034233f, 
    0.05307353f, 0.04710728f, -0.04493060f, 0.03120102f, 0.03288824f, -0.06842668f, -0.06031873f, -0.07817241f, 
    0.03059882f, -0.02162402f, -0.06000291f, -0.03815047f, -0.05957857f, -0.05847551f, 0.00553883f, 0.01779353f, 
    -0.03055594f, 0.01557056f, -0.04182959f, -0.01726644f, -0.00615860f, -0.05223781f, -0.02543230f, 0.05034447f, 
    -0.06078772f, -0.05386759f, 0.02110252f, 0.00689559f, 0.05805016f, 0.00891040f, 0.05199415f, 0.00297925f, 
    -0.07035397f, 0.01993475f, -0.01739924f, -0.03558122f, -0.05993657f, 0.06872985f, 0.01821029f, -0.02912520f, 
    -0.01220434f, 0.03542869f, 0.03414245f, -0.07824593f, 0.04783021f, -0.07738464f, -0.00104174f, -0.04485698f, 
    0.02156547f, -0.00614896f, 0.03758831f, -0.02609413f, 0.05371506f, -0.01586563f, -0.03420902f, -0.02780675f, 
    -0.03190205f, 0.01620202f, 0.04223482f, -0.01467381f, 0.00363195f, -0.02229967f, -0.00251886f, -0.00439911f, 
    0.01426745f, -0.05507542f, -0.05002545f, 0.04922977f, -0.07796099f, -0.03329176f, -0.06139052f, 0.04437336f, 
    0.01573936f, 0.01531329f, -0.04031576f, -0.01126922f, -0.05099951f, -0.01810926f, -0.00497603f, -0.02017312f, 
    -0.03094512f, 0.01796871f, 0.00714110f, 0.01884486f, -0.06172170f, 0.02170433f, 0.01713873f, 0.03140675f, 
    -0.05695273f, -0.04309167f, -0.01404380f, -0.07235612f, -0.01109259f, 0.03230315f, -0.00291409f, 0.04252935f, 
    -0.07656626f, -0.04583383f, -0.07250315f, 0.04617044f, 0.02439591f, -0.00901163f, -0.04682657f, -0.07271337f, 
    0.05446900f, 0.03550106f, 0.18096505f, -0.16733049f, 0.05620400f, 0.02089020f, -0.09399966f, -0.13824241f, 
    0.08124698f, 0.03222148f, -0.06758315f, 0.03253657f, 0.51742262f, -0.20598595f, -0.26913258f, -0.13541976f, 
    -0.01132812f, -0.01052537f, -0.08478264f, 0.04916444f, 0.00649139f, 0.21961485f, -0.08909597f, 0.05681434f, 
    0.22951138f, -0.28087541f, -0.33696440f, -0.11468659f, -0.14368112f, -0.02370543f, 0.02153300f, 0.27227023f, 
    -0.03540283f, -0.02086080f, -0.03584970f, 0.10752112f, -0.27800876f, 0.04900186f, -0.08526542f, -0.06870297f, 
    0.18319906f, -0.03590306f, -0.00408862f, -0.17761512f, 0.15016352f, 0.01050565f, 0.06444284f, 0.04435559f, 
    0.08646665f, -0.05965788f, 0.07526894f, -0.02404084f, -0.15966809f, -0.00957630f, -0.07034357f, -0.06327736f, 
    0.03196130f, -0.02253811f, 0.06960184f, -0.02498755f, 0.11358487f, -0.16404034f, -0.09284097f, -0.02383265f, 
    0.02996281f, 0.02256275f, -0.04292632f, 0.10368554f, 0.02612280f, -0.03136411f, 0.06232554f, 0.11264969f, 
    0.19674560f, -0.02681122f, 0.34434608f, -0.21039350f, 0.04229048f, -0.10326019f, 0.07945120f, -0.06497844f, 
    -0.03416269f, 0.12918323f, -0.03391438f, -0.00230871f, -0.05805028f, -0.02887067f, -0.05711034f, 0.17287378f, 
    0.02800335f, 0.07905730f, 0.19062078f, 0.11069102f, 0.02450804f, 0.02291549f, 0.11563834f, 0.02055399f, 
    0.00897317f, -0.04694599f, -0.19421960f, -0.21852231f, -0.03886011f, -0.08546104f, 0.03059675f, 0.08987791f, 
    0.03745495f, 0.00614394f, 0.09667476f, 0.15505390f, -0.03946551f, 0.22265850f, -0.00617496f, -0.04645363f, 
    -0.08519242f, -0.15460642f, -0.02626389f, 0.09820137f, -0.03527767f, 0.06837285f, -0.10763969f, -0.09412419f, 
    -0.08058285f, -0.19725598f, -0.13431975f, 0.05499667f, 0.02991150f, 0.05145283f, 0.10966592f, 0.18293601f, 
    -0.02396570f, 0.00975212f, -0.01426358f, 0.18004102f, -0.25211427f, 0.04346925f, 0.03103415f, 0.21527961f, 
    0.11973672f, 0.00498796f, 0.06974729f, -0.07454382f, 0.03747215f, -0.03731813f, -0.02063414f, -0.04822515f, 
    -0.02654992f, -0.23102114f, -0.03541382f, -0.03154844f, -0.04515218f, 0.05063996f, 0.00430741f, 0.14727856f, 
    0.17138922f, -0.13847794f, 0.01844852f, 0.18281442f, 0.20914672f, -0.28872728f, -0.09150603f, -0.46218625f, 
    -0.01366173f, 0.11163321f, -0.05919615f, -0.00198776f, 0.07689632f, 0.03228961f, -0.01654608f, 0.10419948f, 
    0.08717281f, 0.09721048f, -0.01442961f, 0.24452239f, -0.09341674f, 0.07314526f, 0.00758858f, 0.00694641f, 
    -0.15499738f, -0.01985603f, 0.09113896f, 0.14073436f, -0.10767201f, 0.08082841f, -0.07209484f, 0.06188665f, 
    -0.01934657f, 0.11085941f, -0.00422150f, 0.21998090f, 0.01800663f, 0.10504910f, -0.03917298f, -0.00820687f, 
    0.01922653f, 0.02838774f, -0.05783680f, 0.02685691f, 0.04867442f, -0.04154149f, 0.02625647f, 0.03789000f, 
    -0.01814139f, -0.01938066f, -0.04124152f, 0.05356723f, -0.05945718f, 0.04234489f, 0.05697203f, -0.01766499f, 
    0.03882012f, -0.01189220f, 0.04938166f, 0.04867599f, 0.00392813f, -0.03343761f, -0.02168137f, -0.04102858f, 
    0.03443071f, 0.01320048f, -0.03456400f, -0.04092554f, -0.01951028f, -0.07333001f, 0.00864015f, 0.03825860f, 
    0.00172395f, -0.07199122f, 0.05585786f, 0.03149555f, -0.07095256f, 0.04128096f, -0.03279831f, -0.07743495f, 
    -0.01429229f, -0.07835115f, -0.05239988f, -0.02153931f, 0.00393949f, -0.04101408f, 0.01640848f, -0.03424938f, 
    -0.05424337f, -0.05814317f, 0.05673516f, -0.05951713f, -0.03678532f, -0.05879350f, 0.04419573f, -0.05657484f, 
    -0.03822986f, -0.03773021f, -0.05992528f, -0.00001965f, 0.02394702f, 0.04661007f, 0.01067672f, 0.04160023f, 
    -0.05551928f, -0.06984921f, 0.06210396f, -0.02046995f, -0.03091246f, -0.00505796f, -0.00455490f, -0.00024131f, 
    -0.01871456f, -0.03745759f, -0.02471502f, 0.00753229f, 0.00408106f, -0.03726711f, -0.01601530f, -0.06451865f, 
    -0.07260251f, 0.02585676f, 0.03855262f, -0.03593365f, -0.04462700f, -0.01504159f, 0.04290253f, -0.00587704f, 
    -0.06596656f, -0.02027519f, 0.03778479f, -0.00842255f, 0.03305509f, 0.06175707f, -0.04979497f, 0.01511048f, 
    -0.00530066f, -0.06934898f, -0.04376492f, 0.04322443f, -0.03480370f, 0.03109512f, 0.06061660f, -0.00513395f, 
    0.01152309f, -0.03456399f, -0.01708100f, 0.02619818f, -0.02669594f, 0.04185203f, 0.05583608f, -0.06131403f, 
    -0.03565548f, -0.05480135f, 0.03731525f, 0.02264544f, -0.02178368f, -0.03682032f, 0.03431128f, 0.05819980f, 
    -0.06167318f, 0.02661926f, 0.00019884f, -0.01761224f, -0.05561527f, -0.02423145f, 0.05118125f, 0.03774146f, 
    -0.04889132f, -0.05944561f, -0.06848745f, -0.04082553f, 0.04135005f, -0.06335618f, -0.01059598f, 0.00967604f, 
    0.01660292f, 0.03359147f, -0.07308540f, 0.00881994f, -0.06658062f, -0.04048300f, -0.05321617f, -0.04856883f, 
    -0.07633936f, 0.03362573f, -0.02151266f, -0.00611481f, -0.03331437f, -0.04540773f, -0.04628459f, -0.07560249f, 
    -0.04378143f, 0.00517993f, 0.06087548f, 0.05508921f, 0.00411509f, 0.03005185f, -0.05456486f, 0.00675246f, 
    -0.02792596f, -0.04880307f, 0.00955670f, -0.06955009f, -0.02106311f, -0.01120362f, 0.01139122f, 0.05512181f, 
    0.03031386f, 0.06317879f, -0.03920665f, 0.05569256f, 0.00257738f, 0.02244461f, 0.02314205f, -0.06932781f, 
    -0.06103829f, 0.04961729f, -0.05094527f, 0.01344068f, -0.06555315f, -0.06037610f, -0.07758706f, -0.05444394f, 
    0.00776454f, 0.01017444f, -0.06553360f, 0.00946253f, 0.03777305f, 0.05473221f, 0.03200630f, -0.07104492f, 
    0.02460498f, -0.24571681f, 0.01343373f, -0.01198482f, 0.03347968f, 0.01938593f, -0.04624609f, -0.05463712f, 
    0.07665303f, 0.05792649f, -0.00238156f, -0.09781770f, 0.09137746f, 0.29838246f, 0.32432649f, 0.14511076f, 
    -0.04778459f, -0.04812704f, -0.10460950f, -0.14659448f, 0.03501244f, 0.10950652f, 0.14088598f, 0.16328289f, 
    0.04251460f, -0.24820270f, 0.00870773f, -0.31955388f, -0.01266104f, -0.04733780f, -0.02164082f, 0.21964897f, 
    0.21139127f, -0.06048845f, -0.02273078f, 0.12731047f, -0.16226116f, 0.60717279f, -0.27866551f, 0.03073537f, 
    -0.00754026f, -0.06265767f, 0.14290963f, -0.10004517f, 0.06759050f, 0.04147099f, 0.18050928f, 0.17175931f, 
    0.01256736f, -0.04136917f, -0.00543469f, -0.17145698f, -0.04394169f, -0.02080319f, -0.03383641f, -0.08071665f, 
    0.04857255f, 0.00977036f, -0.08202077f, -0.00057737f, -0.28429314f, -0.01594865f, -0.28965986f, -0.01880514f, 
    0.08002626f, 0.06432459f, -0.06192051f, 0.07684825f, 0.12216031f, 0.08804848f, -0.13458808f, 0.00356003f, 
    0.02128516f, -0.40944782f, 0.06479898f, -0.18949585f, 0.06567056f, 0.09484828f, 0.04991881f, -0.27826232f, 
    0.12284127f, -0.05396298f, 0.10256506f, -0.06032880f, -0.13540184f, -0.22489284f, -0.01193297f, -0.14189138f, 
    0.18286745f, 0.05032375f, 0.14424352f, 0.02991093f, 0.01148434f, 0.07636710f, 0.08243118f, 0.18738832f, 
    -0.15858345f, -0.11819061f, 0.00970599f, -0.14186372f, 0.08161391f, 0.03205711f, -0.02596376f, 0.01892939f, 
    -0.03289701f, -0.00362061f, -0.05313390f, 0.04650540f, 0.19768593f, 0.06302035f, -0.17795210f, -0.03227139f, 
    -0.09991554f, 0.07135090f, 0.07937880f, 0.07056021f, 0.09456155f, 0.07395773f, 0.15915488f, 0.25734866f, 
    0.23434830f, 0.10732661f, 0.16959582f, -0.24846375f, 0.14911002f, 0.02100139f, 0.07777070f, -0.05098426f, 
    0.14961563f, 0.05884969f, 0.14053892f, 0.13520308f, -0.41821328f, -0.04428069f, -0.18124987f, -0.14387904f, 
    0.17227608f, 0.01480133f, 0.16915642f, -0.00806144f, -0.04688391f, -0.01707508f, 0.03092267f, -0.03348838f, 
    -0.09265598f, -0.10874149f, 0.37739784f, -0.14046563f, -0.01057164f, 0.11826546f, -0.04382320f, 0.18681170f, 
    0.13798535f, -0.01254540f, -0.13363998f, -0.00330832f, 0.10008606f, -0.26834482f, 0.01709447f, -0.15905190f, 
    -0.16339333f, 0.04629041f, 0.07536010f, 0.15536135f, 0.04129786f, 0.11360247f, 0.10822447f, 0.11852650f, 
    -0.04372406f, 0.12977819f, -0.01735817f, -0.02423932f, -0.01171820f, -0.08082500f, 0.01549571f, 0.02939652f, 
    -0.04980122f, -0.00524277f, 0.13153537f, -0.04113133f, -0.37511733f, -0.05303935f, -0.20909198f, -0.15685196f, 
    0.07439194f, 0.06392924f, 0.05383691f, 0.11717247f, -0.04488828f, 0.00606073f, 0.00436236f, -0.08739099f, 
    0.12260592f, 0.16663083f, 0.21929193f, 0.19415890f, 0.00419057f, 0.09319312f, -0.02308370f, 0.03275255f, 
    0.02778332f, 0.09611934f, 0.11838441f, 0.06995478f, -0.32215047f, 0.03502105f, -0.27352622f, -0.27464181f, 
    -0.12949449f, 0.03662635f, 0.07298589f, 0.07866319f, 0.22094050f, 0.18966787f, -0.07841407f, 0.03578766f, 
    0.23478001f, -0.16413991f, -0.23963739f, -0.26943383f, 0.03013272f, -0.04384716f, -0.20240276f, 0.14815713f, 
    -0.10310476f, -0.02777578f, -0.10195791f, -0.06483045f, -0.42689922f, 0.25283796f, 0.09979064f, 0.03791406f, 
    0.10878599f, -0.07556363f, 0.18042569f, 0.25446412f, 0.10476187f, 0.27651218f, 0.12597087f, -0.01046264f, 
    0.08348469f, -0.04923159f, 0.03805753f, 0.11677225f, 0.00625110f, 0.03488044f, -0.03752573f, -0.04251280f, 
    0.23695719f, 0.14874190f, -0.14044079f, 0.02213960f, -0.11675147f, -0.16929249f, -0.27116209f, 0.18001392f, 
    0.27121693f, -0.01832213f, 0.04298408f, -0.01078011f, -0.16135871f, -0.02868955f, 0.01116681f, -0.03130270f, 
    0.62261236f, -0.05292210f, -0.09148155f, 0.05660162f, 0.07683791f, 0.09479829f, 0.02136545f, 0.24002717f, 
    -0.15710251f, 0.03480233f, 0.00314184f, -0.10067633f, 0.06512979f, -0.14987075f, -0.08727367f, 0.00707265f, 
    0.08655156f, 0.00158600f, 0.08502202f, -0.04180344f, -0.09479468f, -0.01705668f, 0.02460476f, 0.08067979f, 
    0.20844589f, -0.15925452f, -0.37573704f, -0.40804577f, 0.14206362f, -0.16595697f, -0.06435672f, 0.06158745f, 
    -0.02113079f, -0.00382065f, -0.16033469f, -0.03721484f, -0.06346357f, 0.14427432f, 0.04632451f, -0.02332100f, 
    0.17812456f, 0.06378047f, 0.11259912f, -0.02826994f, -0.01507765f, -0.03850784f, 0.03417570f, 0.11236173f, 
    0.06980015f, -0.68229169f, -0.06985447f, -0.02925867f, -0.13474554f, -0.17521080f, 0.00062853f, 0.04103350f, 
    0.16970453f, -0.04868776f, -0.04472605f, 0.00258522f, 0.15622570f, -0.00103138f, 0.02874247f, 0.08457031f, 
    0.03187136f, -0.22382417f, -0.01233188f, 0.06841036f, 0.04781473f, -0.03390277f, -0.06120048f, 0.02134858f, 
    -0.07328656f, -0.23841228f, 0.13283753f, -0.01582930f, 0.06552440f, -0.03358784f, -0.17221908f, -0.01175771f, 
    0.08590409f, 0.09903384f, -0.05135486f, 0.02820281f, -0.05926168f, -0.09812364f, -0.69226271f, -0.36496165f, 
    -0.05535361f, -0.05109403f, 0.12171541f, 0.14070590f, 0.06723683f, -0.27309740f, -0.10884156f, -0.03469454f, 
    0.19399597f, 0.14822257f, 0.15945956f, 0.18095261f, -0.03626143f, -0.05083302f, -0.01851241f, 0.02103161f, 
    0.09651462f, 0.09968745f, 0.10202979f, 0.09520514f, -0.27857569f, -0.05415828f, 0.01813177f, -0.11817176f, 
    0.17169371f, 0.03762646f, 0.09851457f, 0.10073978f, -0.00382681f, 0.00063472f, 0.05647121f, -0.12502305f, 
    -0.00708031f, -0.19340301f, -0.01256149f, -0.12120561f, 0.08682985f, 0.22533903f, -0.10030609f, 0.01149607f, 
    0.10346735f, -0.10992748f, 0.00726946f, 0.10927855f, -0.02676507f, 0.02427399f, 0.10840140f, -0.09819415f, 
    0.16354910f, -0.06325350f, 0.08342606f, 0.00303184f, 0.06407368f, 0.04036131f, -0.03861829f, -0.14539938f, 
    0.16734439f, -0.08121462f, -0.29718506f, -0.03970793f, -0.14836954f, 0.03699024f, 0.06665833f, 0.21041377f, 
    -0.06840342f, -0.12150380f, -0.06695811f, 0.07531808f, 0.18662687f, 0.10932328f, -0.17273350f, -0.11118563f, 
    0.13815744f, -0.18910767f, 0.10408497f, 0.01979340f, -0.12226434f, 0.13566273f, 0.14904715f, -0.22013426f, 
    -0.11731372f, -0.38353088f, -0.04228972f, -0.06012666f, -0.07647281f, 0.09642891f, 0.12718599f, 0.13201614f, 
    0.04245187f, 0.10501280f, 0.15332390f, -0.09496631f, 0.11867367f, -0.18845709f, -0.04665864f, -0.06774882f, 
    0.03023684f, 0.03664603f, 0.15064530f, 0.08224628f, 0.12873057f, -0.04424684f, 0.07769615f, 0.17036594f, 
    0.11063987f, -0.51234192f, 0.32694027f, 0.01001433f, 0.12688664f, -0.07659677f, 0.14054163f, 0.06397337f, 
    0.05349996f, -0.01992805f, -0.04122406f, -0.08308450f, 0.06201473f, 0.07692686f, -0.13196574f, -0.05779272f, 
    0.06391013f, -0.10136449f, 0.06881083f, 0.07308547f, 0.06842665f, -0.10293977f, -0.00730368f, 0.03720520f, 
    -0.07542394f, 0.18677616f, 0.02926130f, 0.04566469f, 0.08525678f, -0.02696770f, -0.04270160f, -0.02498195f, 
    -0.06799364f, -0.03378351f, 0.14976904f, 0.14767520f, -0.03782914f, 0.15681024f, -0.16099466f, -0.05243203f, 
    0.09539028f, 0.01291255f, 0.01857686f, -0.03190897f, 0.16297023f, 0.10711247f, -0.16578978f, 0.05342840f, 
    -0.26723555f, 0.05123576f, -0.20867075f, -0.21418680f, 0.00709125f, -0.04062799f, 0.02345279f, 0.19993477f, 
    -0.19096214f, 0.02160954f, -0.08578417f, 0.03639598f, -0.25401762f, 0.10119712f, -0.15242499f, 0.26018211f, 
    0.21798295f, -0.07571071f, -0.05047269f, 0.09341805f, 0.04584887f, 0.02162726f, -0.11743585f, -0.17790890f, 
    -0.20705685f, -0.02232341f, 0.16142990f, -0.16482033f, 0.04353756f, 0.08702995f, 0.06455414f, 0.22937855f, 
    0.09340895f, -0.05273266f, 0.15557797f, 0.01136727f, 0.16347384f, -0.35689706f, 0.14829986f, -0.09210078f, 
    0.04441596f, 0.15586640f, -0.07406760f, -0.18593533f, 0.03361099f, 0.00476168f, -0.14890820f, 0.11884911f, 
    0.03192176f, 0.01458085f, -0.03610902f, 0.07219980f, -0.07793400f, 0.05123067f, -0.01352470f, -0.20222285f, 
    -0.05158828f, 0.11736320f, 0.11957970f, 0.00953117f, 0.03515088f, 0.31357232f, 0.29939929f, 0.25647828f, 
    0.08523051f, 0.05528383f, 0.20718782f, 0.11390565f, -0.04723744f, 0.05730402f, 0.08486179f, -0.17819355f, 
    0.09910652f, 0.11959453f, -0.18973099f, -0.06714296f, -0.08113277f, 0.20957702f, -0.18822503f, -0.05891054f, 
    -0.08682117f, -0.06704412f, -0.04514867f, 0.15438627f, 0.15904039f, 0.17984045f, 0.14439222f, 0.07405283f, 
    -0.00584028f, 0.04247240f, -0.03825292f, 0.24088854f, -0.02602449f, 0.07359882f, 0.11035866f, 0.03842165f, 
    -0.15873906f, -0.09050839f, 0.00860957f, 0.07776535f, 0.05358228f, 0.05948927f, 0.03275077f, -0.11098689f, 
    0.03331124f, -0.18422587f, -0.14051436f, -0.00554199f, 0.07630984f, -0.06779868f, -0.13575980f, -0.07913789f, 
    0.09699924f, 0.10497525f, -0.11120363f, 0.08003956f, 0.00413708f, 0.05848879f, 0.14942007f, 0.02013560f, 
    -0.09542973f, -0.16887251f, 0.11594137f, -0.17986776f, -0.08352433f, -0.10820624f, 0.11828142f, 0.17393082f, 
    0.12285417f, 0.44791269f, 0.22625494f, 0.22787835f, 0.13642138f, -0.30855763f, -0.06393402f, -0.07936755f, 
    -0.07980450f, 0.00522370f, 0.15528029f, 0.00083986f, 0.08893858f, -0.06458315f, 0.14976306f, 0.29570398f, 
    -0.04854191f, -0.11249129f, 0.20768079f, 0.26379752f, 0.21998523f, 0.04418308f, 0.04166699f, 0.11173099f, 
    0.06466431f, 0.08402590f, -0.02469962f, 0.14936936f, -0.14581968f, 0.09220155f, 0.09625818f, 0.09647813f, 
    -0.06760924f, -0.14318337f, -0.15001070f, 0.00279686f, -0.09338835f, -0.10549710f, -0.37883338f, -0.26132017f, 
    -0.03005763f, -0.15463884f, -0.11628245f, 0.13107078f, -0.15377060f, 0.04239020f, -0.08776590f, -0.11284390f, 
    -0.16377927f, 0.00177784f, 0.07550070f, 0.06856181f, 0.01915666f, -0.02914002f, 0.11856496f, 0.02572858f, 
    -0.04083339f, 0.12507668f, -0.19858414f, -0.07091679f, 0.00378301f, -0.28492063f, -0.30898783f, 0.05446839f, 
    -0.28707033f, 0.17555094f, -0.04692450f, 0.15683863f, 0.00790719f, -0.02861225f, 0.07300539f, 0.01738027f, 
    -0.17899026f, 0.02192035f, 0.12159177f, 0.12956199f, 0.10010060f, 0.15778922f, 0.26331618f, 0.01772010f, 
    0.09291663f, -0.06005499f, -0.04551815f, 0.09479383f, -0.05306633f, -0.02628508f, -0.12012381f, -0.42511973f, 
    -0.12783228f, -0.01872650f, -0.08711015f, 0.26769006f, 0.06403384f, 0.08068139f, 0.07921424f, -0.05921283f, 
    0.04274799f, 0.12588523f, 0.04779249f, 0.12727375f, 0.21837240f, -0.03711950f, -0.10764326f, 0.19650631f, 
    0.00107866f, -0.15893544f, 0.19022985f, -0.02138741f, 0.07687620f, -0.02887043f, 0.03067157f, 0.02474718f, 
    0.04031104f, -0.00815096f, -0.03251052f, -0.01478521f, 0.26271236f, 0.24287719f, -0.11429340f, -0.02485069f, 
    -0.13926141f, -0.12010118f, -0.17636679f, -0.04497746f, -0.06666666f, 0.02891113f, 0.07124347f, 0.19150603f, 
    -0.20941190f, -0.00148320f, 0.16271661f, 0.07518138f, 0.07937134f, 0.20055297f, 0.09490235f, -0.05290949f, 
    -0.07061311f, -0.31618223f, 0.02078093f, 0.16315348f, 0.23976985f, 0.20088407f, -0.14072056f, -0.06579835f, 
    -0.01251853f, -0.20373879f, 0.03239215f, 0.08572149f, 0.10591725f, 0.21619831f, 0.31400919f, 0.11448366f, 
    -0.12441668f, -0.05850014f, 0.06313106f, 0.07620090f, 0.04346974f, 0.11435247f, 0.00690934f, 0.18064353f, 
    0.19256097f, -0.17557868f, -0.23773885f, -0.13551849f, -0.16901030f, 0.13906799f, 0.04326338f, 0.01207165f, 
    -0.02467813f, -0.10897280f, -0.00583565f, 0.14393121f, -0.04549273f, 0.12536629f, -0.09413049f, 0.09378832f, 
    -0.06032264f, -0.13391313f, 0.11034216f, 0.05776325f, 0.06371523f, 0.03181236f, 0.01880719f, 0.01491679f, 
    -0.09377410f, -0.21422680f, -0.03889076f, 0.03665695f, 0.00260511f, 0.02992256f, 0.00348290f, 0.11736332f, 
    0.06676491f, 0.30896717f, 0.19879195f, 0.22025169f, -0.09727775f, -0.06558403f, -0.17444366f, -0.09909896f, 
    0.04830319f, 0.21189024f, -0.03874064f, 0.01865558f, 0.19472519f, 0.02528497f, 0.08388143f, 0.36341417f, 
    0.00773376f, -0.51407260f, 0.11798383f, -0.00587390f, 0.14738284f, -0.12250077f, 0.05950461f, 0.10207716f, 
    0.05701547f, 0.12316289f, -0.17027940f, 0.07345354f, -0.01801527f, -0.08356351f, -0.22405598f, -0.19375958f, 
    0.06470323f, -0.06341480f, 0.06165437f, 0.00602703f, -0.10188859f, -0.28586411f, -0.18246548f, -0.18897739f, 
    0.18870433f, 0.12362161f, -0.11232896f, -0.15196809f, 0.04874100f, -0.01466641f, -0.10038600f, 0.05600090f, 
    -0.06739078f, -0.06732383f, 0.05613963f, 0.02245149f, 0.08136946f, 0.06725613f, -0.12472574f, -0.14325143f, 
    0.05371245f, -0.04289030f, -0.04379869f, -0.17629358f, 0.12014405f, 0.02751837f, -0.13404456f, 0.14958176f, 
    -0.06277823f, 0.12947777f, -0.18790668f, -0.21495420f, 0.10153913f, -0.09022981f, -0.01373782f, 0.03698662f, 
    0.02448777f, 0.06283876f, 0.05054789f, 0.15024571f, -0.36208650f, -0.16160373f, -0.23679169f, 0.05060934f, 
    0.11763991f, 0.03695365f, -0.01840832f, 0.13339071f, -0.06323834f, -0.06833877f, -0.12254593f, -0.33448756f, 
    -0.01396949f, 0.05116005f, 0.07854569f, -0.02520989f, 0.25622255f, 0.08215583f, 0.03119274f, 0.04882849f, 
    -0.01176575f, 0.21045151f, 0.14424631f, 0.25667730f, 0.12858358f, 0.05714223f, 0.13009785f, -0.00253774f, 
    -0.13339162f, 0.03838632f, 0.08623461f, 0.03480229f, 0.12371545f, 0.01213098f, -0.09286321f, 0.12084911f, 
    0.01271784f, -0.04025270f, -0.18890567f, 0.16866325f, 0.05325719f, -0.01412048f, 0.03270182f, 0.04371123f, 
    -0.12191527f, 0.05120778f, -0.17155479f, -0.14745691f, 0.15758853f, 0.19988944f, -0.02027984f, -0.01528627f, 
    0.05113387f, -0.03984412f, 0.06494683f, 0.03090189f, 0.05013952f, 0.14202805f, 0.06711741f, -0.08896906f, 
    -0.17862038f, -0.16241468f, -0.12348929f, 0.16538338f, -0.07266714f, -0.03114245f, -0.15404561f, -0.16344137f, 
    -0.10394113f, 0.00163026f, -0.01084222f, 0.13730450f, 0.01841443f, 0.41851830f, 0.28929806f, 0.24914239f, 
    0.03031043f, 0.01260027f, -0.17809463f, 0.05326737f, 0.00983511f, 0.14402446f, 0.15151916f, 0.03887827f, 
    -0.29283422f, 0.06709225f, 0.12181107f, 0.07214124f, 0.10416369f, 0.13130225f, -0.09474275f, 0.04696840f, 
    -0.01004754f, 0.00657109f, -0.00739500f, -0.05430057f, 0.18116069f, 0.41577485f, -0.11181962f, -0.04544508f, 
    -0.16678223f, 0.15672271f, -0.02565948f, 0.00360753f, -0.02947104f, 0.12754670f, 0.06000371f, 0.09131791f, 
    -0.18213253f, 0.06460825f, -0.19112504f, -0.08604499f, -0.04422224f, -0.07749993f, -0.10418973f, -0.11800756f, 
    0.04688117f, 0.15252982f, 0.04765597f, -0.00055399f, 0.13561821f, -0.08663051f, -0.16234121f, 0.12329661f, 
    -0.00895198f, -0.09722086f, 0.13423090f, -0.02646263f, -0.07800993f, 0.13217659f, 0.07100350f, -0.06663835f, 
    -0.15233380f, 0.33319706f, -0.33222586f, 0.49513501f, 0.04076654f, 0.01520172f, -0.28019276f, -0.16529855f, 
    0.12799937f, -0.16176942f, -0.00677312f, 0.09893814f, -0.00998629f, -0.00545762f, 0.10588973f, 0.05461895f, 
    -0.04332786f, 0.12246589f, 0.04870180f, -0.07272568f, 0.01227257f, 0.07953844f, 0.03681440f, 0.06985857f, 
    -0.26706627f, -0.15949786f, -0.17804514f, 0.11915975f, 0.06802449f, 0.00918240f, 0.12978230f, -0.11110123f, 
    -0.08452967f, -0.01568188f, 0.01359889f, 0.09084547f, -0.01318138f, -0.08623393f, -0.11281060f, -0.00453513f, 
    -0.05610089f, 0.00674711f, -0.15260114f, 0.16228598f, -0.04178213f, 0.02196932f, -0.06562709f, -0.03690503f, 
    0.20606023f, 0.28187898f, 0.18104804f, 0.18703367f, 0.08923239f, 0.05181294f, 0.03192225f, 0.00524960f, 
    0.16312927f, -0.00729540f, 0.19953196f, 0.05112047f, -0.14916226f, -0.09021632f, 0.14900620f, 0.02612282f, 
    -0.04810446f, 0.02227506f, 0.18952364f, -0.17838328f, 0.01818999f, -0.09408550f, -0.06904177f, -0.00533291f, 
    -0.05297591f, -0.10980352f, 0.16780296f, 0.08290788f, -0.02332159f, -0.05420752f, 0.04953803f, 0.06419672f, 
    0.08011601f, 0.04755489f, -0.08094338f, 0.08269380f, -0.29474336f, -0.06330992f, -0.20961039f, 0.20334345f, 
    0.01009497f, -0.13611478f, 0.08986998f, -0.06210539f, -0.12385760f, 0.08385070f, 0.05963182f, -0.07920022f, 
    -0.10377810f, 0.07322826f, 0.13135965f, 0.04017125f, 0.11152264f, -0.08231256f, -0.06334324f, -0.08827505f, 
    -0.10345846f, -0.21525989f, 0.11203656f, 0.14439888f, -0.17254706f, -0.14251223f, -0.06917678f, -0.10701577f, 
    -0.01671759f, 0.07984979f, 0.10966212f, 0.03796990f, 0.04267110f, 0.04233528f, 0.07660713f, 0.05211368f, 
    0.19345747f, -0.12661333f, -0.12070379f, 0.11351044f, 0.09675246f, 0.11544175f, 0.01316529f, 0.02602745f, 
    -0.00021526f, -0.06252962f, 0.08591446f, 0.03178250f, 0.13284366f, 0.40311372f, 0.36805484f, -0.00182251f, 
    -0.10845856f, -0.20248975f, -0.13336401f, 0.01357019f, -0.03012073f, -0.12590559f, 0.23636630f, 0.16204125f, 
    -0.06507950f, 0.03553856f, 0.13014729f, 0.08053155f, 0.06136230f, 0.02014945f, -0.01653492f, -0.01378610f, 
    0.14245994f, 0.03065156f, 0.03460601f, -0.06765670f, 0.16694535f, 0.34651333f, -0.16461214f, -0.10059515f, 
    -0.04681842f, -0.14985588f, 0.21731266f, 0.06472117f, 0.14470221f, 0.10570593f, 0.00827943f, -0.05308161f, 
    0.20055114f, 0.09023600f, 0.02877935f, 0.06655926f, 0.03242714f, 0.01921901f, 0.03346490f, 0.07438366f, 
    0.05388945f, -0.02139668f, 0.20905365f, 0.05739016f, -0.14639270f, -0.10242672f, -0.14632779f, -0.07089553f, 
    0.03861545f, -0.10607439f, 0.01362519f, -0.02540868f, 0.10059534f, 0.05868969f, 0.05584481f, 0.12868069f, 
    -0.09031048f, -0.30496985f, 0.32584667f, -0.12169266f, 0.17303668f, 0.18100773f, -0.02726975f, 0.26833797f, 
    0.03185581f, 0.00659053f, 0.08695588f, -0.01130722f, -0.27569303f, -0.05502196f, 0.09922265f, -0.15269321f, 
    0.00498518f, -0.08325863f, 0.00835803f, 0.24274224f, -0.02509467f, -0.07675634f, -0.07868221f, -0.07165516f, 
    -0.30846274f, -0.27761158f, 0.16102679f, 0.16565330f, 0.00055789f, 0.04587129f, -0.17348976f, 0.01080992f, 
    0.03107570f, 0.01113957f, 0.11504208f, 0.07670934f, 0.18299115f, 0.10939494f, -0.11115096f, -0.07474584f, 
    0.02635461f, 0.08520973f, -0.07923294f, 0.12722340f, 0.14045949f, -0.09029800f, -0.03987444f, 0.01799608f, 
    -0.00523529f, 0.14786239f, 0.14256051f, -0.06249572f, -0.18981461f, -0.27034652f, -0.06037757f, -0.01086950f, 
    -0.02983612f, 0.17237957f, 0.13496658f, 0.05307019f, -0.08703509f, -0.05384118f, -0.11315886f, -0.12344305f, 
    0.07525948f, 0.06775430f, 0.08529609f, 0.23877209f, -0.01664224f, 0.06737479f, -0.02040211f, -0.03095088f, 
    -0.08584826f, -0.01546932f, 0.16558488f, -0.10782167f, 0.09298351f, -0.04308838f, 0.07841133f, 0.05704728f, 
    0.07317363f, 0.14308752f, 0.10292651f, 0.07626781f, -0.03119634f, 0.04512304f, -0.13536294f, 0.26189891f, 
    -0.20334594f, 0.02061425f, -0.17847171f, -0.03634413f, -0.07188018f, 0.03477728f, 0.04040368f, 0.02663663f, 
    0.16506541f, 0.06701373f, 0.09240740f, 0.08932374f, 0.10978153f, 0.00330474f, 0.02008765f, 0.02092450f, 
    0.01898102f, -0.06967337f, -0.14176597f, -0.18868756f, -0.15376122f, 0.05154980f, 0.06712183f, 0.15196466f, 
    -0.07011825f, 0.01223980f, 0.10185026f, -0.02527732f, 0.04188976f, -0.01796336f, 0.10769402f, -0.02655087f, 
    -0.25962833f, -0.19188952f, -0.18020453f, 0.13316612f, -0.12502889f, 0.08285113f, -0.02004677f, 0.07618011f, 
    -0.04162818f, -0.12681425f, -0.01639238f, 0.03143419f, 0.17571288f, 0.23148113f, 0.16815922f, -0.05621735f, 
    0.12607475f, -0.13188514f, -0.02785655f, 0.21780455f, -0.03218720f, -0.02878978f, 0.09463500f, 0.11775152f, 
    -0.26296887f, 0.37449729f, 0.06942947f, -0.08577093f, 0.06525139f, 0.13610680f, 0.03590738f, -0.06575844f, 
    -0.05512499f, -0.02283269f, -0.08020549f, 0.14390551f, 0.42142385f, 0.02757978f, -0.25344044f, 0.02404805f, 
    -0.21360719f, -0.16109255f, -0.04866388f, 0.00848515f, -0.01004987f, 0.10286660f, 0.02445348f, -0.02208769f, 
    0.10594660f, -0.06604728f, -0.15859941f, 0.10300681f, -0.08925078f, -0.13506177f, 0.07893366f, 0.02127809f, 
    0.01345038f, 0.23924437f, 0.22913706f, 0.07317594f, 0.15641573f, -0.05331522f, 0.01239578f, 0.00701113f, 
    -0.08930808f, 0.14861451f, 0.09752762f, 0.02013777f, -0.11408608f, -0.06381094f, -0.04974451f, 0.11355638f, 
    -0.37531072f, 0.17461368f, -0.08538404f, 0.46385396f, 0.02577521f, -0.01965864f, 0.02044622f, 0.23414834f, 
    0.18282300f, -0.07055089f, -0.08533387f, 0.10994767f, 0.18992426f, 0.16567761f, 0.00019027f, 0.03869712f, 
    0.03920254f, 0.02714285f, 0.00705807f, -0.01761899f, -0.13715875f, -0.20942006f, -0.07718964f, -0.08934814f, 
    -0.16355139f, -0.03952190f, -0.18817696f, 0.11867978f, 0.05581199f, 0.03533073f, 0.06897602f, 0.02872038f, 
    -0.18327013f, 0.02600740f, 0.09831981f, -0.03348793f, 0.22435029f, -0.29477456f, -0.01597273f, -0.06789415f, 
    0.09212030f, -0.03761573f, 0.04995174f, 0.07119488f, 0.00130180f, 0.15949368f, -0.20937712f, -0.06456242f, 
    0.25759432f, 0.43185404f, -0.10942518f, 0.06817675f, 0.16666616f, -0.01779837f, -0.01118347f, 0.00168234f, 
    0.05564910f, -0.05517353f, -0.00532557f, 0.04970476f, 0.19741876f, -0.17649274f, -0.01850463f, -0.03977272f, 
    -0.15185659f, 0.12284976f, 0.16737188f, -0.06063529f, -0.14583117f, 0.01407460f, -0.10104247f, -0.15898781f, 
    -0.06269156f, 0.08977418f, -0.07955888f, 0.18276617f, 0.14675421f, 0.03347379f, 0.11526542f, 0.07221533f, 
    -0.02245715f, 0.10052292f, -0.02427169f, 0.27490178f, -0.05724033f, 0.28743735f, 0.17032887f, 0.13868463f, 
    -0.02791560f, -0.02325113f, -0.12487115f, 0.01217118f, 0.04581950f, 0.09384152f, -0.10451803f, 0.01006141f, 
    0.17812324f, -0.11264811f, 0.01416385f, -0.12886234f, 0.21094429f, 0.14387220f, 0.15528271f, -0.15944098f, 
    -0.05592535f, -0.08731540f, -0.06973126f, 0.04919884f, 0.01950683f, -0.06806650f, -0.05301667f, 0.11659978f, 
    0.05534125f, -0.03514637f, 0.04304040f, 0.11396261f, -0.01496748f, 0.02517523f, 0.05797824f, 0.07430647f, 
    0.15953808f, 0.10272933f, 0.14373364f, 0.11314803f, 0.06311241f, 0.13039300f, 0.05503508f, 0.02221811f, 
    -0.09501804f, -0.00292556f, 0.03484850f, 0.06697127f, -0.26687267f, 0.16832861f, 0.15671746f, -0.09668045f, 
    -0.16479827f, -0.00225085f, -0.10505830f, -0.07787336f, -0.00766618f, 0.11663003f, 0.01296423f, 0.04638972f, 
    -0.03629182f, -0.17193206f, -0.31761408f, -0.09792664f, 0.06819981f, -0.03463776f, -0.21886301f, 0.13196447f, 
    -0.23951761f, -0.15783508f, -0.14435056f, 0.05431840f, -0.25097957f, 0.27863726f, 0.00746095f, -0.05891525f, 
    0.14949876f, 0.13315623f, 0.26025254f, 0.27220869f, 0.02448311f, 0.12656341f, 0.07100472f, 0.08009875f, 
    0.00314703f, 0.04757613f, -0.03219283f, 0.07929637f, -0.02260019f, 0.00440505f, -0.03806829f, 0.03795286f, 
    0.39497903f, 0.33691865f, -0.07578078f, 0.10346019f, -0.33051875f, -0.51336813f, -0.40982518f, -0.13568532f, 
    0.15291189f, -0.09197960f, -0.00104110f, -0.04484483f, -0.11099493f, 0.12738587f, 0.02203175f, -0.06264709f, 
    0.46443424f, 0.09589670f, -0.20689540f, 0.22071461f, 0.07703398f, 0.05055163f, 0.02874663f, 0.13810405f, 
    -0.06576905f, 0.06718235f, 0.01195872f, -0.02118763f, 0.18385389f, -0.12826020f, -0.07755088f, 0.05764889f, 
    0.11459906f, 0.10314693f, 0.16374286f, 0.09044680f, -0.15931398f, -0.04247433f, -0.05392659f, -0.11685213f, 
    -0.27091146f, -0.63279182f, -0.64545470f, -0.55123562f, 0.11342546f, -0.03882312f, 0.05849674f, -0.05364336f, 
    0.02368560f, -0.06674477f, -0.10548083f, -0.00103151f, 0.01056955f, 0.16598083f, 0.04688778f, -0.06298311f, 
    0.09610483f, -0.00965690f, 0.02931276f, 0.08508255f, 0.04270970f, -0.07024811f, -0.02453053f, -0.01585508f, 
    -0.02758281f, -0.54518658f, -0.01720035f, -0.04315628f, -0.01017686f, -0.12765945f, 0.02361398f, 0.06356420f, 
    0.11468324f, 0.04051518f, -0.14280580f, -0.06508114f, -0.00684958f, 0.03468707f, -0.01831534f, 0.17735766f, 
    0.20016496f, -0.00995282f, 0.03804297f, 0.06465513f, 0.01557873f, -0.02845464f, -0.06903975f, -0.01024601f, 
    -0.24446580f, -0.38972330f, -0.08686401f, -0.33969232f, 0.10121252f, -0.05308945f, -0.22956409f, 0.06084585f, 
    0.05417387f, 0.07317643f, 0.06113879f, -0.04865605f, -0.56155956f, -0.04483606f, -0.67251974f, -0.36314788f, 
    0.15236056f, -0.08933502f, 0.17261964f, -0.17171916f, -0.04961921f, -0.20727934f, -0.03290435f, -0.06806020f, 
    0.17689316f, 0.14023443f, 0.13836306f, 0.24391100f, -0.02670468f, -0.01930864f, -0.01816640f, -0.02611356f, 
    -0.07865262f, 0.18131742f, 0.09152848f, 0.05790593f, -0.24509783f, -0.21618043f, -0.38460863f, 0.00678809f, 
    0.20359202f, 0.12463144f, 0.14646757f, 0.20735136f, 0.10775871f, 0.09171615f, 0.09346810f, -0.03365719f, 
    -0.08959630f, 0.03909901f, -0.02334336f, 0.01179782f, 0.02327329f, 0.05375710f, 0.18239780f, 0.02471630f, 
    -0.05431303f, 0.04755965f, 0.00689388f, 0.02182663f, 0.22684735f, 0.29730043f, 0.31449166f, 0.20401177f, 
    -0.06035272f, -0.06868521f, 0.02841298f, -0.06787319f, -0.00320179f, -0.04419097f, 0.09179708f, 0.16276775f, 
    -0.26190731f, 0.08903509f, 0.10120764f, 0.08526589f, 0.01203841f, -0.04855344f, -0.01544688f, -0.09523501f, 
    -0.04671273f, 0.01903605f, -0.00465749f, 0.05634254f, -0.24881665f, 0.38858497f, -0.23635504f, 0.01603164f, 
    -0.07024155f, -0.10936944f, 0.22525759f, -0.06890213f, -0.05040926f, 0.04746812f, 0.05841451f, -0.00112833f, 
    0.03650510f, 0.12537998f, -0.09238433f, -0.13575037f, -0.00339433f, -0.00471385f, 0.03008454f, -0.06756429f, 
    -0.05383429f, -0.02420554f, -0.02858024f, 0.09890395f, -0.10870453f, 0.09075010f, -0.13048550f, 0.05955110f, 
    -0.01857282f, -0.01052393f, -0.05032830f, -0.11204649f, 0.00457902f, -0.03397826f, 0.01757456f, 0.01679604f, 
    0.00283091f, -0.12601517f, 0.02732273f, 0.15501712f, 0.05441596f, 0.03277449f, -0.13170041f, 0.03289776f, 
    0.02360744f, -0.06654640f, 0.05424850f, -0.03425454f, -0.29810232f, -0.15313478f, -0.00985431f, -0.10263351f, 
    -0.02684701f, 0.01004133f, -0.01726527f, 0.11606108f, 0.05266422f, 0.04391911f, 0.02240027f, 0.05074604f, 
    -0.11236413f, -0.22922426f, -0.09812657f, 0.00547578f, -0.12090610f, 0.08963015f, -0.10192911f, -0.01844246f, 
    -0.05177721f, -0.00042704f, -0.01604810f, 0.03615430f, 0.10673071f, 0.06102660f, -0.01668212f, -0.01426860f, 
    0.08638756f, 0.08282372f, 0.03515662f, 0.22108905f, 0.06692419f, -0.06928943f, 0.11430100f, -0.00094162f, 
    0.13744563f, 0.14853135f, 0.14815244f, 0.06546715f, -0.04302518f, -0.10307645f, 0.03850963f, -0.08461667f, 
    0.02890090f, -0.00484294f, 0.14747454f, 0.02782679f, -0.14917345f, -0.00813137f, 0.02391046f, -0.08679308f, 
    -0.01448197f, 0.12535138f, 0.02478344f, 0.16624562f, 0.09784228f, 0.04381263f, 0.00533726f, -0.10962468f, 
    0.10350949f, 0.05526272f, 0.22518745f, -0.00254799f, 0.13766144f, -0.07584785f, 0.04864099f, -0.10585999f, 
    -0.12848276f, 0.12732302f, -0.08090109f, -0.03593891f, 0.11240641f, 0.20138516f, -0.28195286f, 0.11006647f, 
    -0.02365859f, 0.13832957f, -0.07068307f, 0.26079786f, -0.14826341f, 0.00868184f, -0.01530336f, -0.10995919f, 
    -0.03873663f, 0.12098731f, 0.13077715f, -0.15285924f, 0.05928654f, 0.06423028f, -0.05972291f, 0.04688329f, 
    -0.00229901f, -0.02802921f, 0.04413855f, -0.04223714f, -0.12366388f, -0.14162025f, -0.09827518f, 0.03407249f, 
    0.04064213f, 0.02750733f, -0.09025589f, -0.16424334f, 0.03123254f, -0.10594616f, 0.02736976f, -0.06265815f, 
    0.04375451f, 0.10301033f, -0.02364499f, -0.06702077f, -0.00675042f, -0.02300127f, -0.07900745f, 0.03852217f, 
    -0.02699857f, -0.07784837f, 0.00161845f, -0.03989880f, -0.06287834f, -0.26850635f, -0.23282875f, -0.08447226f, 
    -0.04324103f, -0.01874161f, -0.02390054f, -0.15018822f, 0.19561170f, 0.03985878f, 0.08616424f, 0.01803947f, 
    -0.14575687f, -0.17597473f, 0.13642094f, 0.11120991f, 0.08273366f, -0.05177276f, 0.17951106f, -0.01583554f, 
    0.09982667f, -0.01804950f, -0.03271052f, 0.00558315f, 0.60305905f, -0.08348156f, 0.04694932f, 0.14226818f, 
    -0.02460849f, 0.24916798f, 0.05446339f, -0.10673679f, -0.01292270f, 0.13482246f, 0.01226016f, 0.12367651f, 
    0.03251700f, 0.09883505f, 0.02230007f, -0.11924782f, 0.01301212f, -0.09612429f, 0.01458150f, -0.06545364f, 
    0.05476028f, -0.25871906f, 0.02562527f, -0.10643076f, 0.02166905f, -0.01670094f, 0.11259739f, -0.06688531f, 
    0.02314297f, -0.15093061f, 0.03811204f, 0.01737677f, 0.04441860f, -0.02146065f, -0.04585353f, -0.10208066f, 
    -0.22599119f, 0.20999300f, 0.22191659f, 0.09622776f, 0.05941121f, 0.18056509f, 0.19251449f, -0.12424999f, 
    0.18549410f, 0.02063095f, -0.02448335f, 0.02059647f, -0.20498388f, -0.09424213f, 0.06411067f, 0.08848865f, 
    0.06212155f, 0.06761700f, 0.04703504f, -0.01748141f, 0.12813860f, 0.06700498f, 0.01209532f, 0.09804901f, 
    -0.28738466f, -0.01072193f, 0.02894595f, -0.10768788f, 0.07723346f, -0.01392875f, 0.17670889f, -0.04020060f, 
    -0.01739094f, 0.06283205f, 0.16023155f, -0.00520040f, -0.05498184f, -0.17105839f, -0.14409104f, 0.05947124f, 
    0.02786119f, 0.02689181f, 0.09903520f, 0.11060391f, 0.01498090f, 0.07067463f, 0.01984298f, 0.01664469f, 
    -0.32620820f, 0.08118037f, 0.17113772f, -0.12390453f, 0.11198393f, 0.17688759f, 0.08449388f, 0.17049961f, 
    0.16378316f, 0.11989574f, -0.07960173f, 0.04671545f, 0.04374494f, 0.01529099f, -0.08473852f, 0.09532736f, 
    0.19795156f, -0.11961329f, -0.02494366f, -0.03366414f, 0.03120902f, 0.01038957f, 0.03506925f, 0.00669252f, 
    -0.20490074f, 0.07350890f, 0.02980440f, -0.11104045f, -0.14404136f, 0.12056224f, 0.07278605f, 0.09911123f, 
    0.11674637f, -0.03083614f, 0.03061289f, -0.13217032f, -0.21631855f, -0.47445121f, 0.30229500f, 0.07138624f, 
    0.04681536f, 0.02728092f, 0.06187879f, 0.15822276f, 0.10318242f, 0.16039376f, -0.02993918f, 0.23579538f, 
    -0.01875069f, 0.04461904f, 0.10350315f, 0.00169330f, 0.01926079f, -0.07603882f, -0.13867936f, -0.08404842f, 
    -0.08770080f, 0.07757615f, 0.11680990f, 0.02464153f, -0.04954907f, -0.14612976f, 0.09175280f, 0.09779292f, 
    0.09394536f, 0.17552400f, -0.03052635f, -0.06510998f, 0.02537102f, 0.01565517f, 0.03260294f, -0.04454432f, 
    -0.02055572f, 0.04640838f, 0.13719259f, -0.14312273f, 0.01781368f, 0.05292904f, -0.01809645f, -0.12944511f, 
    0.00004797f, -0.02084284f, -0.02623541f, 0.04928377f, 0.04171540f, -0.10682539f, 0.04875666f, -0.06797174f, 
    -0.11519137f, -0.07811408f, 0.04513992f, -0.04834565f, 0.08252966f, 0.05801707f, -0.18338679f, -0.05858194f, 
    0.06127513f, 0.08199186f, -0.23184361f, 0.14324255f, -0.02487460f, 0.00643723f, 0.12592016f, 0.10456304f, 
    -0.24314739f, 0.00736426f, -0.03088870f, 0.01634952f, 0.03776452f, 0.31952456f, -0.05435020f, 0.06763201f, 
    0.09254112f, -0.24819376f, 0.17659424f, -0.03929738f, -0.06460802f, -0.04471720f, 0.08613982f, 0.12655868f, 
    -0.20333304f, -0.08474515f, -0.12817283f, -0.07714867f, -0.10938212f, -0.08054217f, -0.06237135f, -0.01731280f, 
    -0.03812376f, -0.13919088f, 0.00854770f, -0.06929924f, 0.11793491f, 0.18924733f, 0.08417410f, 0.03069977f, 
    0.12042697f, 0.02933673f, 0.07374587f, -0.02312352f, 0.02040892f, 0.05615090f, -0.03237821f, -0.07564417f, 
    0.08455529f, -0.15756251f, -0.04209256f, -0.07226677f, -0.03378306f, 0.05256205f, -0.05172664f, 0.11481196f, 
    0.08730356f, 0.03562789f, -0.05515984f, -0.21416388f, 0.01342778f, -0.14969888f, -0.21923597f, 0.06212840f, 
    0.13601059f, 0.03130299f, 0.07088879f, 0.06049715f, 0.10075221f, -0.06634928f, 0.04131719f, 0.17872259f, 
    0.10903271f, 0.20450872f, -0.03780978f, -0.18006913f, 0.13416630f, 0.06115099f, 0.01970663f, 0.09090899f, 
    0.05235370f, 0.07062749f, 0.03875446f, -0.03321378f, -0.06118560f, -0.00780109f, -0.06297038f, -0.08936755f, 
    0.01748717f, -0.02979710f, 0.26482525f, 0.12600908f, 0.11265471f, 0.19920804f, 0.10406925f, 0.09248295f, 
    -0.05939029f, -0.04663319f, -0.11356006f, -0.07901236f, 0.04563774f, 0.07770860f, -0.02213930f, 0.18650316f, 
    -0.04287146f, -0.04110105f, 0.01559720f, -0.01545591f, -0.32595760f, -0.01402824f, -0.01082757f, 0.17191422f, 
    0.06087166f, 0.03109912f, -0.12772183f, 0.09540161f, 0.04679442f, 0.04535148f, 0.01244321f, 0.03287227f, 
    0.00032793f, 0.01410193f, 0.16920966f, -0.12488840f, -0.00216314f, 0.12378544f, 0.06213225f, 0.10932473f, 
    0.06675588f, 0.00438091f, -0.13568425f, -0.14674537f, -0.04071262f, -0.02629407f, 0.05668534f, -0.13666613f, 
    0.17200212f, 0.15350685f, -0.00706036f, 0.06260501f, 0.03934771f, -0.02726398f, -0.04529897f, 0.01944818f, 
    -0.12305284f, 0.16610132f, 0.04647952f, 0.02889028f, -0.13835154f, -0.12874958f, 0.00016896f, -0.04791833f, 
    0.05573052f, 0.13479811f, 0.09564535f, 0.14883311f, -0.00410424f, -0.04732590f, -0.08415873f, -0.00534154f, 
    0.18006045f, 0.06830952f, -0.02279029f, 0.00036807f, -0.05735870f, 0.07292761f, -0.05472612f, 0.00772532f, 
    0.04493437f, -0.09589113f, 0.05359319f, -0.12277585f, 0.09058581f, -0.03546733f, -0.00944012f, -0.05089182f, 
    0.25275102f, -0.07299472f, -0.00877882f, 0.09900261f, 0.55653113f, -0.01751597f, 0.17943330f, -0.10071548f, 
    0.12139326f, -0.06012274f, -0.03376376f, -0.08822281f, 0.02168173f, -0.17864548f, 0.17668080f, 0.11145253f, 
    -0.01862240f, 0.14483356f, -0.19752206f, -0.12252165f, -0.00538294f, -0.01303077f, 0.06661892f, 0.12995489f, 
    0.08945403f, -0.01919107f, 0.05009569f, -0.04530488f, 0.08912152f, 0.22043714f, -0.36999255f, -0.04297775f, 
    -0.11730648f, -0.17524464f, 0.17837048f, -0.17779921f, 0.08493479f, 0.05628108f, 0.00495751f, -0.10813257f, 
    0.17112686f, 0.14214279f, 0.04201365f, -0.08249591f, -0.07585883f, 0.08625560f, -0.03094905f, -0.06927618f, 
    0.06202270f, -0.08612722f, 0.22702189f, -0.01615501f, -0.01877999f, -0.21361765f, -0.12218001f, -0.02989177f, 
    0.02079884f, -0.02600145f, 0.10285600f, 0.09984769f, -0.04826869f, -0.20159511f, -0.10791829f, -0.05705258f, 
    -0.14249316f, -0.30719900f, 0.44875479f, -0.03511910f, 0.24678524f, 0.18672659f, -0.06186856f, 0.04115629f, 
    0.14432049f, -0.01599823f, 0.00608630f, 0.04801967f, -0.07237154f, 0.00319968f, 0.06839497f, 0.09708808f, 
    -0.02846452f, 0.05079024f, 0.01201594f, -0.12685865f, 0.18214907f, -0.03799302f, 0.00371093f, 0.14181817f, 
    -0.26727280f, -0.12487169f, 0.21570884f, 0.09459259f, 0.11165068f, -0.06157071f, -0.12579465f, 0.15158400f, 
    -0.09626886f, -0.08177069f, 0.04429336f, 0.09554236f, 0.23044503f, -0.03005498f, -0.16724049f, -0.06845737f, 
    -0.04782846f, 0.10951041f, -0.18757524f, 0.18077278f, 0.05241600f, 0.12101749f, -0.04966260f, 0.02052858f, 
    -0.14012566f, 0.20985918f, 0.10668375f, -0.01475815f, -0.02440538f, 0.02678665f, 0.04112779f, 0.05488991f, 
    0.00187693f, 0.09199463f, -0.00199886f, 0.06275729f, -0.25604910f, 0.03132357f, -0.10390065f, 0.04822266f, 
    0.08152760f, 0.02633396f, -0.03530791f, 0.14643125f, 0.02640712f, -0.02912658f, 0.12063656f, -0.17173339f, 
    -0.10285021f, -0.14545821f, 0.21354178f, -0.13742767f, 0.06625400f, 0.05232120f, 0.09909248f, 0.13685425f, 
    0.03701584f, -0.05338828f, 0.00354619f, 0.02790152f, 0.06800227f, -0.18491982f, 0.05650643f, 0.00308653f, 
    -0.31547266f, 0.14126760f, -0.22718103f, -0.01303704f, -0.04364320f, 0.05639762f, 0.08575840f, 0.09175777f, 
    0.19927658f, 0.17896837f, 0.03749948f, 0.03323902f, 0.05655929f, 0.09716450f, -0.05507944f, -0.10389555f, 
    -0.06893884f, 0.02368875f, -0.09557829f, -0.03296482f, -0.07212871f, 0.08688568f, 0.26720712f, 0.25114781f, 
    0.00361193f, 0.12644868f, 0.17557152f, 0.00689584f, -0.01263801f, 0.03172696f, 0.03324311f, -0.12538941f, 
    0.02920673f, 0.04758245f, 0.09974082f, -0.11430461f, 0.04410050f, -0.04665063f, 0.09419248f, -0.01363497f, 
    -0.01938556f, 0.10283048f, 0.11605749f, 0.05163367f, 0.33848694f, 0.05338567f, 0.01170067f, 0.16406880f, 
    0.02055150f, 0.04505982f, -0.01340029f, 0.02052316f, -0.07146411f, 0.03981827f, 0.01758935f, -0.03223525f, 
    0.26877636f, 0.07008959f, 0.03076169f, -0.28647742f, -0.01276395f, 0.03103765f, -0.01604726f, 0.19620469f, 
    0.01061122f, 0.10423233f, -0.11137478f, 0.00457945f, -0.64105237f, -0.06279932f, 0.17337050f, -0.12408885f, 
    0.06155686f, 0.06552930f, -0.14941052f, 0.08221268f, 0.05827752f, -0.02970506f, 0.11385254f, 0.00596465f, 
    0.07876186f, -0.06965091f, 0.03357356f, -0.03647571f, 0.07121938f, 0.02131812f, -0.03272687f, 0.00904307f, 
    -0.03492235f, 0.09321304f, -0.10120009f, 0.12755454f, -0.04577972f, 0.15723029f, -0.09365094f, 0.09705186f, 
    -0.04723899f, 0.27724105f, -0.15334913f, 0.08180361f, -0.02526445f, -0.02308179f, -0.00106455f, 0.06329666f, 
    0.34244615f, -0.11389480f, -0.22492339f, -0.37645945f, -0.11195762f, -0.04980154f, 0.02331359f, -0.13130458f, 
    -0.10848501f, 0.04050111f, 0.00566381f, 0.11063541f, 0.13409857f, 0.18485419f, 0.15558170f, 0.03335957f, 
    0.04825072f, -0.01983215f, 0.15535890f, 0.02239114f, -0.10461429f, 0.02268091f, -0.05490609f, -0.02601357f, 
    0.32522783f, 0.04823209f, -0.07675906f, 0.03666695f, 0.02494961f, -0.01363298f, -0.00493721f, 0.21102712f, 
    0.01105512f, -0.00254089f, -0.20475779f, -0.08100325f, 0.07139885f, 0.23053540f, 0.07890343f, -0.12316173f, 
    -0.02058834f, 0.03062988f, -0.12182405f, -0.17938842f, -0.10612974f, -0.09904037f, 0.20367008f, -0.04867196f, 
    0.36074573f, -0.13518719f, 0.06388556f, 0.07139681f, -0.08329206f, 0.10946310f, -0.02975189f, -0.13571973f, 
    -0.06901974f, -0.09311479f, 0.10430104f, 0.03181907f, 0.00095147f, 0.12184768f, -0.09166463f, -0.06718460f, 
    -0.12445408f, 0.06332183f, 0.08331283f, -0.18275574f, -0.11798518f, -0.07403348f, 0.03538400f, -0.04197775f, 
    0.29137620f, 0.03808914f, -0.07171630f, -0.03256587f, 0.03341511f, -0.00289464f, -0.04210688f, -0.05277639f, 
    -0.00845270f, 0.18476793f, -0.05113692f, 0.16859318f, 0.29205295f, 0.32525662f, -0.11400613f, -0.25931305f, 
    0.02928332f, -0.01543962f, -0.07457365f, 0.01233334f, -0.02996578f, -0.05215785f, -0.01554927f, -0.22000219f, 
    0.05720919f, -0.10234626f, -0.02469311f, 0.05262967f, -0.05558423f, -0.03122800f, 0.09913906f, 0.11944007f, 
    0.06833345f, -0.00827200f, 0.08171841f, -0.08823878f, -0.04591707f, -0.00104848f, -0.13785076f, -0.03275268f, 
    0.00774398f, 0.02597849f, -0.08102543f, 0.21724851f, -0.13440916f, -0.01970114f, -0.16649295f, 0.07000639f, 
    0.29019848f, 0.09257527f, -0.04027453f, -0.08816078f, 0.04597749f, -0.05044802f, -0.25942218f, -0.04249580f, 
    -0.13876455f, -0.03357039f, -0.09741905f, 0.03737784f, 0.28978625f, 0.17943424f, 0.17666510f, 0.21276659f, 
    -0.14953582f, -0.05274527f, -0.01214728f, -0.17690568f, -0.02708494f, -0.00576494f, -0.00332712f, 0.01776205f, 
    -0.34357062f, -0.20354837f, 0.37018648f, 0.05167620f, 0.02686651f, 0.03434011f, -0.00127416f, 0.02963765f, 
    0.12415090f, -0.09879241f, -0.13979374f, 0.02962115f, -0.11993594f, -0.14554484f, 0.13131700f, 0.09492316f, 
    0.16513464f, 0.23719560f, -0.04226061f, -0.18954286f, 0.01352879f, 0.21780385f, 0.11542238f, 0.01893844f, 
    0.06521814f, -0.07264832f, -0.02159962f, -0.29114106f, -0.16682445f, -0.12156297f, 0.04243331f, -0.03577430f, 
    0.03313946f, 0.23910969f, 0.12736535f, 0.32403019f, 0.00775639f, -0.14176960f, -0.07145282f, 0.09186041f, 
    0.10304200f, -0.07705215f, 0.10502942f, -0.03648593f, 0.12704082f, 0.04743774f, 0.04838562f, 0.15713623f, 
    -0.06744605f, 0.19862862f, 0.20576958f, 0.18130511f, 0.16891742f, 0.05151736f, 0.07257882f, 0.05041983f, 
    -0.05068563f, -0.07778534f, 0.09841681f, 0.01660062f, -0.15348159f, 0.04230157f, 0.15383005f, -0.09305176f, 
    -0.19301514f, -0.08399905f, -0.02441712f, 0.01030300f, -0.19552802f, -0.10165769f, -0.24179529f, -0.16413498f, 
    -0.26176101f, -0.14258572f, -0.04024104f, 0.09849641f, -0.04540088f, -0.09582604f, -0.08501876f, 0.02323863f, 
    0.06469354f, 0.03065885f, -0.00986747f, 0.16043067f, 0.16075525f, 0.47077456f, -0.17925370f, 0.05730208f, 
    -0.14505352f, -0.07747433f, -0.23551859f, -0.05043911f, -0.10862900f, -0.20643654f, 0.00038166f, 0.06229028f, 
    -0.13775115f, 0.02942247f, 0.29591575f, 0.11200665f, -0.08052015f, 0.09424070f, 0.16130438f, -0.07314572f, 
    -0.01621511f, 0.14843760f, -0.04418173f, 0.07711437f, 0.14236481f, 0.28341261f, 0.23332828f, 0.07578755f, 
    -0.02732000f, -0.02103172f, -0.06348538f, 0.11446144f, -0.09604593f, -0.24213775f, -0.07469258f, -0.22442769f, 
    -0.00066704f, -0.04416968f, 0.10145894f, 0.01189010f, 0.09660962f, 0.00535576f, -0.04982413f, 0.03664107f, 
    0.08148460f, 0.14103305f, 0.01467078f, 0.01257336f, 0.16563776f, -0.14791593f, 0.00259907f, 0.24700996f, 
    -0.02143490f, -0.12122129f, -0.02140603f, 0.02772364f, 0.05666644f, -0.04241217f, 0.04485514f, 0.03804699f, 
    0.06792445f, -0.25228116f, -0.21898520f, 0.03535613f, 0.11937626f, 0.13949515f, -0.06668087f, 0.01697032f, 
    -0.12153240f, -0.06496470f, 0.01406914f, -0.16226710f, -0.13011089f, -0.00985826f, 0.09133971f, 0.18839176f, 
    0.05643923f, 0.05788366f, 0.10757500f, 0.01852209f, 0.10936475f, 0.06774170f, 0.07401711f, 0.04183372f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.14621125f, 0.10524001f, 0.07483648f, 0.06778033f, 0.04355234f, 0.05867243f, 0.10477623f, 0.02021238f, 
    -0.05466574f, 0.21688315f, -0.04151605f, 0.03699645f, -0.02467658f, -0.01754796f, -0.03113795f, 0.10388688f, 
    0.19536974f, 0.09725946f, -0.05365033f, 0.02264016f, 0.00851303f, 0.09763440f, -0.12088908f, 0.00057177f, 
    -0.04729147f, -0.07389842f, -0.01932969f, 0.06045533f, -0.06542894f, 0.05815370f, 0.12158332f, -0.01288919f, 
    0.09495108f, 0.14484425f, -0.01520580f, 0.00413547f, 0.08515759f, 0.07454826f, -0.02837179f, 0.05048043f, 
    0.23845941f, 0.11627489f, 0.04137468f, -0.06802730f, -0.00218481f, 0.06563921f, 0.27559295f, 0.05440601f, 
    -0.03122920f, -0.12673752f, -0.00542391f, 0.02649382f, -0.04145876f, 0.09319261f, -0.11056517f, 0.13141032f, 
    0.05464101f, 0.14951053f, 0.00827768f, 0.19128695f, 0.06928302f, 0.13657747f, 0.01894605f, 0.01673189f, 
    -0.05155760f, -0.02749602f, 0.03860074f, -0.02043452f, 0.09572491f, -0.09844849f, 0.09182592f, 0.05040475f, 
    -0.08491488f, 0.19444565f, 0.04393194f, 0.16247605f, 0.00281440f, 0.06231970f, 0.01680260f, -0.04015433f, 
    -0.00662534f, 0.06459104f, -0.06713405f, -0.03261605f, -0.05981295f, 0.15199807f, 0.01001629f, 0.00258863f, 
    0.02784610f, 0.02105492f, 0.17826761f, 0.01436863f, 0.01282068f, -0.10509290f, -0.07811219f, -0.01385357f, 
    0.07693608f, 0.00218802f, 0.00783180f, -0.04343749f, 0.17319170f, -0.12035173f, 0.03294135f, 0.07633509f, 
    0.08407034f, 0.16190375f, 0.03842466f, 0.00167436f, 0.12140482f, 0.03757352f, 0.01938494f, -0.01193822f, 
    0.03106168f, 0.11451520f, 0.20535889f, 0.01702570f, -0.01164357f, -0.06032974f, 0.14731860f, 0.07405036f, 
    0.00204704f, 0.26132581f, 0.08619156f, 0.11135620f, 0.05116815f, 0.08545901f, 0.01823849f, -0.02259017f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02815472f, -0.30848700f, 0.18042471f, -0.16315208f, -0.09122384f, -0.21227767f, 0.00345874f, -0.27915886f, 
    -0.00801275f, -0.08967901f, 0.07580206f, 0.11360492f, 0.15010130f, -0.00054345f, 0.05486137f, -0.49281669f, 
    -0.41434810f, 0.12323650f, -0.04838353f, -0.20443909f, 0.21557285f, -0.25698477f, 0.10298227f, 0.00595145f, 
    -0.05531621f, 0.08465492f, -0.02318853f, 0.10676857f, -0.02556718f, -0.01785502f, 0.07055194f, 0.11716413f, 
    0.04805232f, -0.44486192f, 0.07141395f, 0.04262342f, -0.04385825f, 0.13039717f, 0.18122841f, 0.00077403f, 
    0.04398533f, -0.08519756f, -0.05669371f, 0.06562208f, -0.19636591f, 0.13778536f, -0.36577007f, -0.28091606f, 
    0.34695327f, 0.22908950f, 0.03143265f, 0.03950915f, 0.08187481f, -0.07074239f, 0.15605386f, -0.08149809f, 
    -0.09027550f, -0.35002294f, -0.06700914f, -0.00349030f, 0.02991005f, -0.11278531f, -0.13195987f, -0.02367856f, 
    0.03069532f, -0.45834261f, -0.22323622f, -0.08862624f, -0.16032621f, 0.04468488f, 0.14169393f, 0.27427238f, 
    0.05953387f, -0.21249594f, 0.05174365f, -0.35411021f, -0.08292396f, 0.03675908f, -0.33107963f, -0.25754625f, 
    0.06833377f, -0.11872371f, -0.02558511f, 0.09232976f, 0.14596906f, -0.33272007f, -0.02401939f, -0.07669546f, 
    -0.03337097f, -0.06741891f, -0.40840262f, 0.07275704f, -0.31894490f, 0.18337120f, 0.03254608f, -0.03713792f, 
    0.14479667f, -0.02103685f, 0.23473616f, 0.13839321f, -0.07495794f, 0.11501184f, 0.11427704f, -0.28004569f, 
    0.00084575f, 0.09441281f, 0.09270114f, 0.07945007f, -0.11870721f, -0.05135908f, 0.05564191f, -0.04419148f, 
    0.05517915f, -0.10659554f, -0.09956107f, -0.01496701f, -0.09396014f, 0.24265647f, -0.21287455f, -0.27990156f, 
    0.08366415f, -0.06666127f, -0.09634718f, -0.35535777f, 0.06666800f, -0.34669203f, 0.22844376f, -0.35449103f, 
    -0.02301953f, 0.09811537f, 0.03434286f, -0.07838898f, 0.03367627f, 0.16273744f, 0.15913452f, -0.27773049f, 
    -0.05415988f, 0.22836122f, -0.03865512f, 0.08362330f, 0.01888042f, 0.24783438f, -0.00921550f, -0.03662290f, 
    -0.01965330f, 0.19213742f, -0.03880616f, -0.13298278f, -0.12442866f, -0.03126656f, 0.01913061f, -0.43511534f, 
    0.04677577f, 0.02275547f, -0.22418196f, 0.24724790f, -0.01469241f, -0.02742110f, 0.08924532f, -0.03832756f, 
    0.02311197f, -0.19616298f, -0.40876430f, -0.08684490f, -0.12997967f, 0.16796446f, -0.09711320f, 0.00837995f, 
    -0.23112418f, -0.01969374f, 0.07294493f, 0.00144767f, -0.15443718f, 0.04745030f, 0.00851166f, -0.02047258f, 
    -0.41050851f, 0.13080494f, -0.05963482f, -0.25086236f, -0.37931350f, 0.03430913f, -0.64249831f, 0.04497431f, 
    0.04626733f, -0.08927105f, -0.11097314f, 0.21173005f, 0.01869171f, 0.15615171f, -0.19992909f, -0.04738557f, 
    -0.79414088f, 0.26012594f, -0.06715731f, -0.45237947f, -0.02941130f, 0.17343436f, 0.14750350f, 0.14634767f, 
    0.04200610f, -0.19262026f, -0.05277553f, 0.17444976f, 0.05784206f, 0.13145958f, 0.26670676f, -0.08862488f, 
    -0.03968620f, 0.05083117f, -0.16602075f, 0.08587040f, 0.07978620f, 0.12034107f, -0.02868696f, -0.06643580f, 
    0.29143795f, 0.18211077f, 0.04950951f, 0.08498536f, 0.20487359f, -0.05706838f, -0.01063386f, 0.01115520f, 
    -0.18432754f, -0.25292489f, -0.10320845f, 0.20292023f, 0.45157915f, 0.30378723f, -0.07998159f, -0.54337257f, 
    -0.11128771f, 0.05623385f, 0.01642643f, -0.07376420f, 0.37447682f, 0.05334166f, -0.05845769f, 0.01312151f, 
    0.00317815f, -0.03700928f, 0.18530281f, -0.69033837f, -0.59278959f, -0.49188113f, 0.03793097f, -0.11300001f, 
    -0.03914034f, 0.35969159f, -0.06788336f, -0.07727955f, -0.17066373f, -0.18363091f, 0.20454577f, -0.09179855f, 
    -0.34269223f, 0.04865035f, -0.13752046f, -0.01896583f, 0.05695863f, 0.18741551f, -0.13271269f, 0.07302291f, 
    -0.05234392f, 0.27024826f, -0.07104029f, -0.33186164f, -0.10726912f, 0.19414605f, -0.01735723f, 0.04197446f, 
    0.16175507f, 0.00991167f, 0.02200125f, 0.10651434f, 0.37617499f, -0.01029246f, -0.28172725f, 0.17273596f, 
    -0.01354371f, -0.03562830f, -0.19010578f, 0.04762271f, 0.03421386f, 0.08762705f, 0.02193598f, -0.03425835f, 
    0.00529712f, -0.06775501f, -0.29015085f, -0.03947604f, -0.02512619f, -0.13073286f, 0.03136601f, -0.00737616f, 
    0.10224392f, 0.12286822f, 0.07299496f, -0.08524317f, 0.09119201f, -0.09014373f, 0.13237198f, -0.06758465f, 
    -0.32025477f, -0.30876267f, -0.20557116f, -0.23968309f, -0.70130438f, 0.06107028f, 0.22509572f, -0.01812342f, 
    -0.00226438f, -0.00520521f, -0.03646135f, 0.18491352f, 0.05100708f, -0.03007076f, 0.06677312f, -0.04599955f, 
    0.29071209f, -0.00071629f, 0.02272350f, -0.10885201f, 0.04075847f, 0.16343021f, 0.12130675f, -0.37841678f, 
    0.18036568f, 0.13071699f, -0.16171567f, -0.30794111f, -0.03803812f, -0.03564746f, 0.03090467f, -0.04684038f, 
    -0.09077173f, -0.04659585f, -0.01246785f, -0.18437631f, 0.05752342f, 0.22925264f, -0.05197027f, 0.00748498f, 
    -0.38955244f, 0.14357199f, 0.09681553f, -0.24165224f, 0.16622268f, 0.08122220f, -0.05509856f, -0.08234913f, 
    0.16047089f, -0.23492442f, -0.04350974f, -0.30729148f, -0.49908125f, -0.48290217f, -0.33883882f, 0.17776485f, 
    -0.12718810f, -0.22197384f, 0.07611798f, -0.00169043f, -0.72227848f, -0.27077782f, 0.03271063f, -0.24292774f, 
    0.02682240f, 0.12212893f, 0.00855341f, -0.33652201f, -0.10178305f, 0.03540099f, 0.16684729f, 0.00470235f, 
    0.02552763f, -0.38971704f, 0.16502456f, 0.02321227f, 0.04106168f, -0.06835120f, 0.02378265f, 0.35916132f, 
    -0.54275846f, 0.06696910f, -0.28850201f, -0.33038658f, 0.04871063f, -0.28854480f, -0.03309952f, 0.29903573f, 
    -0.05030858f, -0.06468425f, 0.06542959f, 0.00161855f, -0.23608732f, -0.10305362f, 0.23322941f, 0.11977750f, 
    -0.08408532f, 0.02784433f, 0.03529803f, 0.23977181f, -0.06481991f, 0.20647389f, -0.00403076f, -0.10823580f, 
    -0.07791505f, -0.03396076f, 0.22212680f, -0.04086877f, -0.04366236f, 0.06521901f, -0.09106683f, -0.07294992f, 
    -0.57416320f, -0.15361048f, 0.08010548f, 0.02732198f, -0.13753459f, -0.11524644f, 0.04603760f, -0.09054917f, 
    -0.13786863f, -0.36165389f, -0.00258819f, -0.07001832f, -0.09575810f, 0.05562681f, -0.27998447f, -0.01939587f, 
    0.06438091f, -0.00528067f, -0.35435897f, -0.10156927f, 0.13701503f, -0.05892815f, 0.17585054f, -0.34569404f, 
    -0.05099546f, -0.10009117f, 0.28394368f, -0.31267679f, -0.10394096f, -0.42594936f, 0.35957035f, 0.04115476f, 
    0.22908926f, -0.13474233f, 0.14985360f, 0.02752613f, 0.15606625f, 0.11251952f, 0.09524325f, -0.18170859f, 
    0.09676701f, -0.26389092f, -0.09957653f, -0.26137006f, 0.01682089f, 0.07289948f, 0.10389137f, 0.22792177f, 
    -0.07124641f, -0.08622432f, 0.18619141f, 0.11047387f, 0.06732759f, -0.00776962f, -0.01994266f, 0.05758246f, 
    -0.34466606f, 0.05632805f, -0.09878557f, 0.03271486f, 0.03888267f, 0.11225468f, 0.07811852f, -0.07719075f, 
    0.03127196f, 0.12232447f, -0.12349742f, 0.01335991f, -0.16864134f, -0.00599637f, -0.05863059f, 0.06794841f, 
    -0.60420233f, -0.38488749f, 0.02928238f, 0.13260198f, -0.11503533f, 0.18144418f, -0.02915396f, 0.34177709f, 
    0.07095059f, -0.27371901f, -0.09912350f, 0.01546031f, 0.13527372f, -0.04708769f, 0.16486908f, -0.22936292f, 
    0.15788274f, -0.39508364f, -0.23591816f, -0.01183526f, -0.13697183f, 0.04713167f, -0.15994756f, 0.13876016f, 
    0.15360469f, -0.02175727f, 0.11760510f, -0.11072675f, 0.12598260f, -0.17018352f, 0.17649539f, -0.10640132f, 
    -0.07137617f, -0.03141646f, 0.05952890f, -0.08283728f, 0.19255625f, 0.13363524f, -0.04146941f, -0.14890197f, 
    -0.21701580f, -0.12256555f, -0.02966359f, -0.04152574f, -0.03995612f, -0.20790021f, 0.13236415f, 0.25792882f, 
    0.00977787f, 0.02167734f, -0.23044683f, -0.10117530f, -0.06274593f, -0.14455435f, 0.07843418f, 0.04558427f, 
    0.17478263f, 0.05189375f, 0.18029900f, -0.02993876f, -0.20563734f, -0.15507536f, 0.11835547f, 0.07638533f, 
    -0.39431727f, -0.02080369f, 0.11034676f, 0.00825299f, -0.02656648f, -0.10185452f, -0.22619146f, 0.18989266f, 
    -0.09364250f, 0.08046651f, 0.07435904f, -0.01430830f, 0.18851443f, 0.02507184f, 0.03115203f, 0.18645807f, 
    0.04591402f, -0.13005506f, -0.49055654f, -0.26363894f, 0.09541683f, 0.06304835f, -0.03219918f, 0.05080487f, 
    0.22318439f, 0.10375637f, -0.22888739f, 0.08085116f, 0.12460031f, 0.03255851f, -0.21230581f, -0.13531443f, 
    -0.12733571f, -0.03400505f, 0.15165147f, 0.18697973f, 0.03880795f, 0.00722087f, -0.16750267f, -0.07476329f, 
    -0.05869151f, -0.09173668f, -0.02661964f, -0.10584512f, -0.08404765f, -0.10567239f, 0.00105856f, -0.00893270f, 
    0.01590786f, 0.09230463f, -0.08661126f, 0.05531813f, 0.08868508f, 0.16546230f, -0.00620344f, -0.02532177f, 
    -0.19657528f, 0.02033162f, -0.18204148f, 0.02567863f, -0.12712777f, 0.10250845f, 0.04261791f, 0.13617115f, 
    0.19691743f, -0.32971099f, -0.21946819f, 0.01469716f, -0.07170658f, -0.23282900f, -0.01840096f, -0.13065343f, 
    0.04155784f, -0.12502116f, 0.26145691f, -0.00242036f, 0.21914218f, 0.05198297f, -0.00223138f, 0.07262053f, 
    0.05616688f, -0.10769760f, 0.03228143f, -0.13140821f, -0.29129869f, 0.08664329f, -0.05635385f, 0.14850539f, 
    0.04799949f, -0.06320915f, 0.08169916f, 0.32976031f, 0.20475890f, -0.13676530f, 0.15400395f, -0.45538351f, 
    0.07285845f, 0.22019362f, 0.06146590f, 0.04179144f, -0.06490789f, -0.17216583f, -0.23284088f, -0.07549252f, 
    0.17071141f, 0.05601317f, 0.00319212f, -0.09811512f, -0.41444042f, -0.01186000f, 0.13366190f, -0.16304885f, 
    -0.02596488f, -0.11048009f, 0.27087098f, -0.15064348f, 0.06208053f, 0.08581842f, 0.12530921f, 0.08969191f, 
    0.07314482f, 0.14311077f, 0.02501711f, -0.06215642f, 0.17673899f, 0.08908795f, 0.03583048f, -0.07858306f, 
    0.24515511f, 0.30327180f, -0.02666344f, 0.00302394f, -0.25743249f, 0.12761378f, 0.32655987f, -0.22652891f, 
    0.11209215f, 0.04478231f, -0.11777593f, 0.30708876f, -0.01730427f, 0.18167388f, -0.36039993f, 0.21822651f, 
    0.01565701f, 0.20476237f, -0.14865635f, 0.09117653f, -0.02109695f, 0.12385619f, -0.00713948f, 0.08040897f, 
    -0.27353173f, 0.06690786f, -0.14276358f, 0.15721993f, -0.13192587f, -0.00464349f, 0.12209994f, 0.03870086f, 
    -0.11712413f, 0.20884474f, 0.07751570f, 0.08268021f, -0.00525099f, -0.11225468f, -0.19535683f, -0.07545055f, 
    -0.01427960f, -0.05030386f, -0.14822046f, 0.04738606f, -0.13983084f, 0.06873976f, -0.01959123f, 0.04650823f, 
    -0.22473320f, -0.10691546f, -0.00447871f, 0.11682586f, -0.30212462f, -0.17537329f, -0.00480521f, 0.05549466f, 
    -0.44819862f, 0.09179810f, 0.13413385f, -0.00417429f, -0.35749024f, -0.01788946f, 0.11608108f, 0.02478517f, 
    -0.10524714f, 0.15109845f, 0.14514017f, -0.00843544f, -0.13018321f, -0.06804533f, 0.02757719f, 0.13733329f, 
    0.06804576f, 0.03038368f, -0.23913513f, 0.07875030f, -0.52000368f, -0.10509104f, -0.03963801f, -0.11243761f, 
    -0.02118930f, -0.18960603f, -0.11635440f, 0.18773153f, 0.11377503f, 0.03216019f, -0.21054623f, -0.40919194f, 
    0.22755100f, -0.08154772f, -0.35697269f, 0.13843973f, 0.09791417f, 0.00047969f, -0.57513940f, -0.13013661f, 
    -0.08646853f, -0.21448794f, 0.00995183f, -0.43491584f, -0.31961858f, -0.21053433f, -0.22649935f, -0.10398647f, 
    0.06970625f, -0.37429613f, 0.00140043f, 0.07059938f, 0.31766218f, 0.10869573f, -0.45112175f, -0.18492049f, 
    -0.06047071f, -0.01465371f, -0.09870702f, -0.12585238f, 0.06279486f, 0.03035060f, -0.22010130f, -0.11047652f, 
    0.14490469f, 0.09400871f, -0.37895155f, 0.03755212f, 0.12370197f, -0.23527311f, -0.36585134f, 0.04423973f, 
    0.15810977f, -0.07663397f, 0.14556713f, 0.05612647f, 0.05352789f, -0.06534891f, 0.26747593f, 0.05185359f, 
    0.06136353f, -0.33279806f, 0.03229117f, 0.16596568f, -0.06554245f, 0.10440667f, 0.15300797f, 0.04398175f, 
    -0.02864335f, 0.03239005f, 0.03814600f, 0.15889561f, -0.00441237f, -0.00921571f, 0.36936745f, 0.02665900f, 
    0.08653796f, -0.26794848f, 0.03005383f, 0.05144358f, -0.23705032f, -0.56917876f, -0.27068782f, -0.00799977f, 
    0.10378022f, 0.12889393f, -0.11281259f, 0.02934189f, 0.00188718f, -0.10903195f, 0.35112962f, 0.12438320f, 
    0.00484872f, 0.02939527f, 0.09936655f, -0.26418778f, -0.21042031f, 0.09562372f, -0.02401172f, 0.04406177f, 
    0.11657711f, -0.12398831f, 0.08640284f, -0.21516860f, 0.18700124f, -0.49486294f, 0.03568491f, 0.08009090f, 
    -0.09921247f, 0.03244743f, -0.28202301f, -0.62664336f, 0.35529241f, -0.43903434f, -0.03351158f, 0.14293957f, 
    0.09823566f, 0.07728365f, -0.14646183f, -0.16662255f, -0.03061809f, -0.36665860f, 0.00845342f, -0.30612931f, 
    -0.09165569f, 0.13534994f, -0.28573340f, -0.08826530f, 0.26249030f, 0.06967305f, 0.26124313f, 0.10498042f, 
    0.26657417f, -0.23683733f, 0.06074842f, 0.06252507f, -0.18681771f, -0.03951301f, -0.18572874f, -0.06587592f, 
    -0.27549079f, -0.14916576f, -0.00274343f, -0.03942433f, -0.01980749f, 0.07850920f, -0.52368140f, 0.23826978f, 
    -0.02509277f, -0.46010733f, -0.02773747f, -0.26394039f, 0.19493167f, 0.17564909f, 0.01231593f, 0.03868226f, 
    0.01475792f, -0.31070888f, -0.04794684f, -0.03713065f, -0.45143628f, -0.09110308f, -0.29454678f, 0.46363646f, 
    -0.07926832f, -0.01440483f, 0.15377223f, -0.06846630f, -0.01148057f, -0.29832563f, -0.21755512f, 0.14668724f, 
    -0.05903161f, 0.08729057f, -0.05473202f, -0.07191086f, -0.00624137f, -0.01573934f, 0.00390842f, -0.00749046f, 
    0.03420347f, -0.24402714f, 0.17675665f, 0.05326961f, 0.17707095f, -0.17933160f, -0.21985078f, 0.07202968f, 
    0.34371707f, -0.27675718f, 0.17030923f, 0.03012303f, -0.00111250f, -0.05490414f, 0.01405651f, 0.05772755f, 
    -0.01577836f, 0.02574157f, 0.03445871f, -0.00809055f, -0.31441757f, 0.02690377f, 0.23815674f, -0.01624668f, 
    0.11127893f, 0.06156482f, 0.08136173f, 0.06732967f, -0.14885646f, -0.31834382f, 0.00758014f, -0.14323930f, 
    -0.29104090f, -0.25976267f, -0.19992414f, 0.21326409f, -0.07177014f, 0.11059082f, -0.30836684f, -0.12826501f, 
    0.06629828f, -0.01632057f, -0.25361919f, 0.07861683f, -0.21131001f, -0.19316930f, 0.01158354f, 0.04723670f, 
    -0.05215345f, -0.01060552f, 0.09313756f, 0.09218350f, -0.30324379f, 0.47087303f, -0.07747125f, 0.01876701f, 
    0.07617863f, -0.30885577f, 0.28027347f, 0.21868217f, -0.38264400f, -0.16885404f, -0.13434225f, -0.17168862f, 
    -0.15749779f, 0.04840187f, 0.03316645f, -0.26073352f, 0.13338430f, 0.30257991f, -0.00295447f, 0.18368436f, 
    -0.05858981f, 0.09403292f, -0.14453162f, 0.20350716f, 0.07748442f, 0.01742929f, -0.71872085f, 0.02772105f, 
    -0.17609172f, -0.33458915f, 0.06716104f, 0.09986122f, 0.02898354f, 0.32485658f, 0.13958319f, 0.14155082f, 
    0.05802674f, 0.14784323f, -0.21341088f, -0.22056879f, -0.23784813f, -0.20270354f, -0.57261950f, -0.15973215f, 
    -0.01176877f, -0.02936323f, -0.03265259f, 0.09201416f, -0.58251745f, -0.20504054f, 0.16251434f, 0.24481118f, 
    0.17738576f, 0.09326954f, 0.05477516f, -0.24834867f, -0.07152239f, 0.20316030f, -0.19789778f, -0.25302312f, 
    -0.01122126f, -0.00908068f, 0.00233267f, 0.02991186f, 0.01312417f, -0.02518075f, 0.25567117f, -0.23426786f, 
    -0.11052116f, 0.25121534f, -0.26345494f, 0.06292914f, 0.19726500f, -0.13826585f, -0.27862781f, 0.06957038f, 
    0.09253804f, 0.02118918f, -0.35615677f, 0.04915542f, -0.14451487f, 0.24545418f, 0.02369640f, 0.22147049f, 
    -0.09930774f, -0.26278651f, -0.05336376f, 0.05055995f, -0.27421036f, 0.23724027f, -0.13061725f, -0.26895139f, 
    -0.08021484f, 0.17905854f, 0.24573731f, 0.10664399f, -0.61169523f, -0.02151187f, -0.06658802f, -0.04133445f, 
    0.01109194f, -0.36463338f, 0.17787099f, -0.38387337f, 0.10064758f, -0.46141109f, 0.29339626f, 0.06192914f, 
    -0.24357343f, -0.23986377f, 0.01159125f, -0.01316401f, 0.02178459f, 0.21099637f, -0.15294507f, -0.10004307f, 
    0.05659107f, 0.01891949f, 0.01804697f, 0.12854216f, -0.03151445f, -0.26572666f, 0.00812387f, 0.06900378f, 
    -0.04414374f, -0.39345863f, 0.13169059f, -0.28876784f, 0.01652948f, -0.18058352f, -0.06112399f, 0.01105152f, 
    0.28557539f, 0.11521593f, 0.20028032f, -0.34400150f, -0.29300529f, -0.28176770f, -0.27052116f, -0.05356433f, 
    0.15854707f, 0.14902715f, 0.23448958f, 0.24903233f, -0.07227591f, 0.25634220f, -0.07000758f, 0.18593806f, 
    -0.04887233f, 0.12206570f, 0.14518823f, -0.12840927f, -0.16603151f, -0.29402849f, 0.06477519f, -0.19355707f, 
    -0.64533579f, 0.16741472f, 0.03214340f, 0.07057782f, 0.20514522f, -0.20748948f, -0.06280356f, -0.19244269f, 
    0.28275469f, 0.04659390f, 0.43697500f, 0.14346237f, -0.33202073f, -0.20449799f, 0.13762167f, 0.01850260f, 
    -0.02141393f, 0.09261343f, -0.03198330f, -0.38492969f, 0.31886068f, 0.14920758f, -0.40133196f, -0.40945253f, 
    -0.19039525f, -0.31335837f, 0.02908497f, -0.05245543f, -0.12986979f, -0.13635078f, 0.05825261f, 0.01520107f, 
    -0.02309479f, 0.11341065f, -0.07031433f, -0.18405877f, -0.00794071f, -0.47716093f, 0.01597456f, -0.06544506f, 
    -0.20987163f, -0.07134335f, 0.14429441f, -0.05267694f, 0.13220151f, 0.02984927f, 0.16720343f, -0.05594714f, 
    0.26583490f, 0.06960032f, 0.13789745f, -0.06253123f, 0.13221247f, -0.14173000f, -0.26214579f, 0.10292812f, 
    -0.31459650f, -0.27134404f, 0.29593411f, -0.18758965f, -0.00791688f, -0.16767070f, -0.07031713f, 0.22920485f, 
    -0.00291940f, -0.05502411f, 0.13889912f, -0.08124789f, 0.07469131f, 0.07455280f, -0.46300858f, 0.06262694f, 
    -0.20050804f, -0.21216948f, -0.06661521f, 0.22396088f, -0.11027526f, 0.12665838f, -0.39120853f, 0.16149940f, 
    0.07361046f, 0.17221159f, 0.06886918f, -0.07428574f, 0.07099178f, -0.43534118f, -0.05219723f, -0.07182978f, 
    0.05649371f, -0.00254830f, 0.14973374f, -0.00601844f, -0.48747960f, -0.15950030f, 0.05227745f, 0.00927428f, 
    -0.11316382f, -0.28511277f, 0.07668793f, 0.15157528f, 0.08881941f, -0.03084263f, 0.00628864f, -0.06931156f, 
    -0.00901184f, -0.02979058f, 0.10421181f, 0.08555294f, -0.16445805f, 0.00752742f, 0.02865909f, 0.07936928f, 
    0.30626157f, 0.17943785f, 0.00814155f, -0.27739292f, -0.18456565f, -0.43388930f, 0.00325323f, 0.11683703f, 
    0.00333119f, 0.24992062f, 0.14680295f, 0.37702766f, 0.06469712f, 0.26348341f, -0.02493416f, 0.17455763f, 
    -0.10346479f, 0.27921233f, -0.01984761f, -0.17779584f, 0.11953430f, 0.17338108f, 0.04783934f, 0.15223825f, 
    0.00654788f, 0.08040012f, -0.13510387f, 0.03057784f, -0.26022577f, 0.39933380f, -0.26732650f, 0.28202519f, 
    -0.07540580f, -0.17996550f, -0.08987592f, 0.17278649f, -0.37016827f, -0.15088645f, 0.14699796f, 0.29727530f, 
    0.21420527f, 0.15722170f, -0.00858683f, -0.17207947f, -0.04977263f, -0.12385149f, -0.39907181f, -0.40701365f, 
    -0.00348996f, -0.07904752f, 0.39521715f, 0.19373895f, 0.00121193f, 0.19313535f, 0.00357157f, -0.29017293f, 
    -0.21227738f, 0.08787106f, 0.22024204f, -0.03523614f, -0.22676603f, -0.04275564f, -0.18878619f, 0.01255539f, 
    -0.00797072f, 0.15756793f, -0.05547428f, 0.07312082f, 0.18832485f, -0.33298290f, 0.15167776f, 0.15850146f, 
    -0.28244862f, -0.03847378f, 0.07326375f, 0.23564106f, -0.05763159f, -0.32109153f, -0.34060588f, -0.20895594f, 
    0.01227095f, -0.12765884f, -0.23256281f, 0.03679590f, 0.00489602f, 0.13352120f, 0.34592277f, -0.05347298f, 
    -0.33769882f, 0.04208205f, -0.23092471f, -0.28815278f, 0.29248169f, -0.39198726f, 0.08401921f, 0.04969020f, 
    0.16133539f, -0.23439851f, 0.17618851f, -0.37233427f, -0.00001065f, 0.22625841f, 0.22735040f, 0.23391341f, 
    0.01468024f, 0.07569018f, -0.22127327f, 0.10242188f, -0.02364203f, -0.15816845f, 0.06921066f, -0.07868535f, 
    -0.22537936f, 0.20091978f, 0.09955155f, -0.03614782f, 0.06665902f, -0.60075343f, 0.01286095f, 0.05812975f, 
    -0.27040038f, 0.12978987f, -0.44276845f, 0.01503979f, -0.23836844f, -0.19929577f, 0.20708622f, -0.17017867f, 
    -0.28654987f, -0.03995689f, -0.38042197f, 0.03904713f, 0.10958104f, 0.17413098f, 0.05042157f, -0.13645504f, 
    0.04635461f, -0.05493369f, -0.50321245f, -0.07743956f, -0.24663919f, -0.21969862f, 0.12726444f, 0.04873694f, 
    0.17764820f, -0.45531082f, 0.16622140f, -0.00172713f, 0.25423366f, 0.29808021f, -0.39504209f, -0.36681062f, 
    -0.28100795f, 0.24044560f, -0.14721903f, 0.18585421f, 0.11504713f, 0.20696171f, 0.07321165f, -0.00428321f, 
    0.08978804f, 0.11081110f, 0.03553794f, -0.03712831f, -0.46396586f, -0.40848815f, 0.15571882f, 0.01449380f, 
    0.16832159f, -0.16469459f, -0.02452074f, 0.21510440f, -0.43435335f, 0.15925281f, 0.00165502f, 0.02137823f, 
    0.07895476f, -0.03732421f, -0.11473545f, -0.29481846f, -0.06812230f, 0.04529849f, -0.40437907f, -0.41953537f, 
    0.00573210f, -0.11287561f, -0.06395049f, 0.01248422f, 0.10419747f, 0.19179481f, -0.45392913f, -0.05028487f, 
    -0.48619410f, 0.00346572f, -0.51373559f, 0.02661776f, 0.03071189f, 0.23578385f, -0.18091273f, 0.01182657f, 
    0.13988766f, -0.43025607f, -0.29156226f, 0.13372047f, -0.59450209f, -0.03830028f, -0.14837986f, -0.06956686f, 
    -0.01516562f, 0.05380814f, 0.09069685f, -0.05637623f, 0.10295542f, 0.11154190f, -0.24531618f, -0.05237713f, 
    0.00422218f, 0.29420811f, 0.07342719f, 0.14478628f, -0.26128802f, -0.28347555f, 0.03634083f, 0.28617942f, 
    -0.32336029f, 0.01756995f, -0.56931919f, -0.26932681f, 0.07966945f, -0.34826291f, -0.12992206f, 0.23515008f, 
    -0.04376535f, -0.13971421f, -0.00431678f, 0.20413196f, 0.37493798f, 0.31897256f, -0.02105906f, -0.08443225f, 
    0.34229857f, 0.20233107f, 0.09644148f, -0.29783493f, 0.13845031f, -0.01113130f, 0.05269574f, 0.00797888f, 
    0.38732287f, 0.19960696f, -0.03462762f, 0.19432499f, -0.01622189f, -0.17677577f, -0.04615043f, 0.16315551f, 
    0.13020457f, -0.11788100f, -0.19910349f, -0.17126727f, 0.12213773f, 0.20838133f, 0.04088571f, -0.18286176f, 
    0.03244352f, -0.44785452f, -0.26440519f, -0.11508251f, 0.27743688f, -0.25256166f, -0.15744656f, 0.02935291f, 
    -0.00233912f, -0.17001356f, -0.17720620f, 0.09527594f, -0.14990018f, -0.39092413f, -0.30256727f, 0.12383048f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.22670487f, 0.11914084f, 0.10925426f, -0.11962659f, 0.03211512f, 0.11127131f, 0.05188182f, -0.06802704f, 
    0.06167278f, 0.08707695f, -0.01093372f, -0.09473749f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
