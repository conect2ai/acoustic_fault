#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.17857924f, -0.39249167f, -0.50155610f, -0.19202746f, 0.27050689f, 0.00529256f, 0.20760097f, 0.30730176f, 
    0.08187070f, -0.26207387f, -0.04971279f, 0.14704773f, -0.09403539f, -0.06944795f, -0.10160222f, -0.43100727f, 
    -0.11742511f, -0.07768103f, -0.08022280f, -0.60343969f, 0.40427592f, 0.28819868f, 0.39292881f, 0.35878083f, 
    0.46107504f, -0.11636330f, -1.23480523f, 0.15322575f, 0.82773978f, 0.64847267f, -0.91726875f, -0.92814708f, 
    -0.78989875f, 0.13457653f, 0.49136502f, -0.21622188f, 0.42878285f, 0.28639737f, 0.36306259f, -0.15991873f, 
    -0.05012916f, 0.03288208f, -0.35424900f, -0.21542318f, -0.47048092f, 0.30207732f, -0.22774620f, -0.07481956f, 
    0.16631447f, 0.07308653f, -0.17749105f, 0.66807264f, -0.11543015f, -0.81479394f, -0.41750893f, -0.60599279f, 
    0.25811812f, 0.18569812f, 0.37386656f, -0.02231632f, -0.11052482f, -0.33928266f, -0.25502533f, -0.05173037f, 
    0.27642748f, -0.11933832f, -0.03668562f, -0.36564595f, -0.38482055f, -0.84638739f, -0.41348249f, -0.26064169f, 
    -0.28680170f, -0.56679714f, -1.02170253f, -1.37259042f, -0.85490304f, -0.45540118f, 0.76374322f, 0.86772043f, 
    0.68741947f, 0.13007620f, -0.29854333f, 0.11480551f, 0.29639235f, -0.19445063f, 0.02073227f, -0.47430611f, 
    -0.11252417f, -0.33505246f, 0.30446741f, 0.14179412f, 0.07851898f, 0.18753050f, 0.24679083f, -0.25063929f, 
    -0.33216020f, -0.19098559f, -0.22119837f, -0.32420918f, 0.86339062f, 0.32112715f, -0.11218117f, -0.20265524f, 
    -0.52243006f, -0.54047704f, 0.34270686f, 0.56758589f, -0.04913988f, -0.41798806f, -0.47559056f, -0.20176737f, 
    -0.37490827f, 0.01476821f, 0.27802828f, -0.06949008f, 0.13127252f, 0.27907988f, -0.26561570f, -0.20935933f, 
    -0.11997010f, -0.10815645f, -0.17154025f, 0.09373797f, 0.16904296f, 0.99610323f, -0.64061397f, -0.90504915f, 
    -1.13938832f, -0.99268532f, -0.02454671f, -0.06684902f, 0.38588279f, -0.02181554f, 0.10211681f, -0.14097098f, 
    0.40861487f, 0.66953075f, -0.21219274f, -0.15617101f, -0.11797577f, -0.10623862f, 0.23616597f, -0.12077724f, 
    0.11369871f, 0.13292779f, -0.25985569f, -0.29093254f, -0.16886650f, -0.35074356f, 0.81982315f, 0.61180609f, 
    0.52201319f, -0.01534514f, 0.48003343f, -0.52160835f, -0.42601511f, 0.10704782f, -0.01834559f, -0.21264182f, 
    0.00302577f, -0.01858312f, 0.35041842f, -0.29553354f, -0.05293421f, 0.01555842f, 0.23104496f, -0.05574042f, 
    0.05289477f, -0.11365794f, -0.18668066f, 0.17038956f, 0.00741064f, 0.13361648f, -0.05532736f, -0.21301045f, 
    0.02294175f, -0.59176391f, -0.61075115f, -0.49205571f, -0.46792549f, -0.47907707f, -0.89499241f, -0.51079500f, 
    0.19924042f, -0.01194105f, 0.35853171f, -0.19822426f, -0.29626578f, 0.18858109f, 0.30527276f, 0.39815861f, 
    0.15333697f, 0.10914076f, -0.01368130f, -0.04699510f, -0.03213453f, -0.23873907f, 0.08812434f, -0.02533774f, 
    0.27677062f, 0.16481557f, 0.12473059f, 0.50029188f, -0.03157554f, 0.20664287f, 0.16758762f, 0.05142283f, 
    -0.06036784f, 0.00349233f, 0.07454761f, -0.24661294f, -0.00762701f, -0.25981897f, 0.23790455f, 0.03719231f, 
    0.10303189f, 0.12691411f, 0.25585330f, 0.20086400f, 0.02410017f, -0.29216054f, -0.19403929f, -0.03706766f, 
    -0.44069716f, -0.22673926f, 0.29155260f, -0.98150212f, -0.47478732f, -0.35852274f, -0.81437421f, -0.78922790f, 
    -0.06014784f, -0.77783293f, -0.79791486f, 0.22582650f, 0.26585078f, 1.07980287f, -0.42716780f, -0.16626035f, 
    0.25994849f, -0.19380262f, -0.24609402f, 0.21145880f, -0.25262383f, 0.03475257f, 0.27313304f, -0.14751294f, 
    -0.26707265f, 0.42196545f, -0.62753123f, -0.25354716f, -0.50135630f, -0.03167444f, 0.36042294f, 0.03587941f, 
    0.38601393f, 0.00719281f, 0.56622881f, -0.24036402f, 0.13515884f, -0.35821959f, 0.51056224f, -0.58558643f, 
    0.18123926f, -0.35034078f, 0.06919780f, 0.30523610f, -0.16354339f, -0.28871101f, -0.01926348f, 0.64700991f, 
    -0.32117009f, -0.37085298f, 0.36895788f, 0.15953802f, 0.49455476f, 0.55569500f, 0.05747110f, -0.54516459f, 
    -0.29031491f, 0.16032097f, 0.06538279f, 0.13579616f, -0.23717467f, 0.01718649f, -0.01112980f, -0.12354843f, 
    0.27305970f, -0.08393519f, 0.17637342f, -0.04787504f, -0.13626549f, -0.46733752f, -0.06200431f, -0.42873672f, 
    -0.43648914f, -0.42673346f, -0.15267722f, 0.02092944f, -1.04045188f, -0.02448530f, 0.66479033f, 0.64337808f, 
    -0.50000364f, 0.31205538f, 0.29101029f, -0.53152740f, 0.72677284f, -0.47048762f, -0.46873507f, 0.00236995f, 
    0.11218738f, 0.05173979f, -0.34004369f, 0.13186713f, 0.16543484f, -0.16067119f, -0.49390110f, 0.16143072f, 
    0.03089161f, -0.20077416f, 0.12019099f, -0.00563311f, -0.19099753f, -0.13664697f, 0.40879259f, 0.60604477f, 
    -0.44562191f, -0.43996879f, -0.05477963f, 0.18213527f, 0.27332857f, 0.13120273f, 0.00245508f, -0.34302607f, 
    -0.39039615f, 0.23142193f, -0.15306695f, -0.05514155f, 0.01443884f, 0.09294923f, -0.02493242f, -0.24214095f, 
    0.04567916f, -0.30283150f, -0.24107672f, -0.54660529f, -0.49993762f, -0.77663028f, 0.01735394f, 0.06992204f, 
    0.01164139f, 0.30982047f, -0.29571760f, -0.44767597f, -0.21829617f, -0.32208660f, 0.71303940f, -0.43170989f, 
    -0.36775726f, 0.02654758f, 0.10110202f, 0.00576823f, 0.60398602f, -0.28159231f, 0.46580181f, -0.14759095f, 
    -0.55577648f, -0.06091316f, 0.11228468f, 0.48126420f, 0.11593134f, -0.31081414f, -0.20333596f, -0.53443903f, 
    -0.54583317f, -0.46142063f, -0.48962969f, -0.50354975f, -0.55927026f, -0.86980170f, -0.64984173f, -0.60408628f, 
    -0.81095982f, -0.20592625f, -0.29727504f, -0.48854131f, -0.14727129f, -0.21928060f, -0.44568565f, -0.16595623f, 
    -0.47935757f, -0.34157044f, -0.62144083f, -0.25773653f, 0.32600677f, 0.23919390f, -0.05753116f, 0.09986337f, 
    0.65695107f, 0.92772818f, -0.11124417f, -0.08806386f, -0.84720325f, -0.67325157f, -0.52294838f, -0.09150028f, 
    0.51409900f, -0.35540184f, 0.26475823f, 0.11350133f, 0.41366756f, 0.36829793f, -0.01019809f, 0.00814227f, 
    -0.09767654f, 0.14663120f, -0.25408712f, -0.42687231f, 0.21222228f, 0.19734846f, -0.15865453f, 0.05877762f, 
    0.04042804f, 0.60357106f, 0.03848166f, -0.15151493f, -0.13123848f, -0.02826903f, 0.46452191f, 0.52307343f, 
    0.13688834f, 0.20591487f, 0.36032638f, 0.07168874f, 0.03076989f, -0.20497987f, -0.62627679f, -0.48570183f, 
    -0.11256144f, -0.05299957f, -0.06417242f, -0.22267941f, -0.17282368f, 0.42820808f, 0.12619507f, -0.15473570f, 
    -0.23678066f, 0.18949497f, 1.24244785f, -1.17888296f, -0.21007355f, 0.18901896f, 0.55207336f, 0.00710579f, 
    0.32298118f, 0.39155158f, -0.46413955f, -0.05620458f, -0.22615264f, 0.07165050f, -0.10723369f, -0.37430814f, 
    0.38910973f, 0.00697398f, -0.08386397f, -0.06024208f, -0.20574397f, -0.19404621f, 0.21859285f, -0.09854699f, 
    -0.08723092f, -0.07858320f, 0.03431574f, -0.14636840f, -0.23475201f, 0.18738125f, 0.17537566f, 0.09505723f, 
    -0.38208440f, -0.22700313f, 0.40159595f, 0.11870997f, 0.08108931f, -0.03335954f, 0.03995263f, 0.66474873f, 
    -0.20625976f, -0.49502653f, -0.55637252f, -0.00986978f, -0.05778198f, 0.27522954f, 0.21177679f, 0.29483351f, 
    -0.30321801f, -0.15897176f, 0.00342473f, 0.40776241f, -1.05506527f, 0.89101756f, 0.47137660f, 0.12953322f, 
    0.06822523f, -0.02424610f, 0.39287883f, -0.27840292f, 0.04880228f, -0.41189888f, -0.11225297f, 0.13558479f, 
    -0.38621539f, 0.16368864f, 0.16347893f, -0.08658878f, 0.08450396f, 0.14833327f, 0.19208257f, -0.36284536f, 
    0.14982416f, -0.05296435f, 0.25924441f, -0.04121327f, -0.38157773f, -0.66741621f, -0.98436427f, 0.08146355f, 
    0.63786775f, 0.60317141f, 0.70270967f, -0.09594957f, -0.25917363f, 0.01210178f, 0.30142385f, 0.18561208f, 
    0.00952392f, 0.21885221f, -0.02271568f, -0.28380457f, -0.41120699f, -0.31109744f, 0.48659956f, -0.03281642f, 
    0.04177439f, -0.22976942f, -0.07182245f, -0.27563763f, 0.35529992f, 0.01123743f, -1.26028574f, -0.57029194f, 
    -0.40721586f, -0.73354906f, -0.32603762f, 0.37077743f, 0.34216258f, -0.82158381f, -0.80054998f, 0.71080464f, 
    -0.47963223f, -0.29452169f, -0.35702878f, -0.39063877f, -0.27797973f, 0.21356145f, 0.28969479f, 0.17378509f, 
    0.18675880f, 0.01457257f, 0.19360711f, 0.05372148f, -0.02929671f, 0.09728590f, 0.21332870f, -1.12371218f, 
    -0.79076862f, -0.75377697f, 0.03036908f, -0.68120360f, 0.65747929f, 0.12666082f, 0.04356450f, 0.21467678f, 
    0.41098726f, 0.03680048f, -0.14990239f, -0.19017474f, 0.73619574f, 0.05945143f, -0.15469046f, 0.07407916f, 
    -0.39534870f, 0.06272049f, 0.11724432f, 0.18783490f, 0.14059497f, 0.20997335f, 0.22196688f, -0.08785652f, 
    -0.03156183f, -0.49782950f, -0.28471658f, 0.42784476f, 0.57224947f, -0.63034964f, 0.13322383f, 0.22554809f, 
    0.53570515f, -0.30171984f, 0.58008105f, -0.42060289f, -0.50749207f, -0.01868581f, 0.20474257f, 0.05033538f, 
    0.11274921f, -0.18748677f, -0.27600631f, 0.29536432f, 0.02143438f, -0.37204191f, -0.06709674f, 0.23939192f, 
    0.11081521f, 0.43012208f, 0.53713876f, 0.28610373f, -0.34597012f, -0.34610912f, -0.23212008f, 0.01117870f, 
    -0.37187085f, -0.10482825f, -0.02686105f, -0.10978677f, 0.09973280f, 0.13222899f, 0.01147060f, 0.13627627f, 
    -0.11253445f, -0.20875715f, 0.20647992f, 0.25764847f, -0.37256664f, 0.05192688f, 0.31661591f, -0.42539445f, 
    0.38021037f, 0.05265912f, -0.54241580f, -0.52240181f, -0.40162674f, -0.29271859f, 0.46113995f, -0.37486294f, 
    0.09469660f, 0.46344784f, 0.56500238f, 0.46084908f, 0.00949109f, 0.04049952f, 0.23466645f, -0.02517481f, 
    0.38322696f, -0.31670332f, -0.08896548f, 0.01023693f, -0.08530881f, -0.45221603f, -0.16676950f, 0.31456953f, 
    0.08354597f, -0.07788828f, 0.52897567f, -1.29446995f, -0.43404427f, -0.76294994f, -0.89732409f, -0.89821559f, 
    0.65450251f, -0.18112347f, -0.20343649f, 0.39855716f, 0.83566052f, -0.06730372f, 0.19103350f, -0.27790558f, 
    0.01206251f, -0.42306584f, -0.20106763f, -0.42878959f, 0.02474899f, 0.07624009f, -0.17986044f, -0.01542461f, 
    -0.06877097f, -0.12966850f, 0.05164360f, 0.18701595f, 0.15261203f, -0.14214630f, 0.12854545f, 0.00646127f, 
    0.17655434f, -0.24179049f, 0.10682443f, -0.13497093f, -0.22546564f, -0.03511993f, -0.13465726f, 0.10327791f, 
    0.07669887f, -0.33630309f, 0.08817618f, 0.28924420f, -0.01674276f, -0.07319889f, 0.32032582f, -0.10226379f, 
    0.18417874f, 0.07838844f, -0.07706806f, 0.15396467f, -0.15293881f, -0.52681237f, -0.59687454f, -0.43573409f, 
    -0.11438002f, -0.70579726f, 0.33737031f, 0.27904043f, 0.23249403f, 0.51695311f, 0.60529435f, 0.17362730f, 
    0.06393780f, -0.01285857f, 0.02958191f, -0.14849924f, -0.24364431f, 0.04105829f, -0.19697298f, -0.07090612f, 
    -0.18960857f, -0.37400207f, -0.33840001f, -0.25256014f, -0.29019150f, 0.10200273f, 0.09794693f, -0.29440683f, 
    0.51698607f, 0.90142572f, -0.70086628f, -0.31410056f, 0.03269584f, -0.63186753f, -0.55250859f, 0.17296676f, 
    0.45309940f, -0.40525338f, -0.47415683f, -0.26474425f, -0.51740825f, 0.13556600f, 0.22977695f, 0.07569773f, 
    -0.05906437f, -0.24195082f, -0.00765833f, -0.15916082f, -0.11444785f, -0.06408133f, 0.24654754f, 0.96187496f, 
    0.65585250f, -0.32399243f, -0.05311274f, -0.45556909f, -0.25820971f, 0.09008425f, 0.08941106f, -0.05025724f, 
    0.28045031f, 0.08149038f, 0.24235861f, -0.04288828f, -0.18135183f, -0.48101151f, 0.14232212f, -0.31256601f, 
    -0.01126425f, -0.08557575f, -0.05612974f, -0.30609313f, 0.26985201f, -0.20662209f, -0.27900323f, 0.27698761f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.05880310f, 0.31952459f, -0.04803555f, 0.08254083f, 0.33472854f, 0.47307110f, 0.19004382f, 0.03943242f, 
    0.04011715f, 0.19333076f, 0.20649368f, 0.03654467f, 0.01386642f, 0.09930687f, 0.17352939f, -0.32781324f, 
    0.31737712f, 0.28172296f, 0.53868210f, 0.33309200f, 0.28852856f, 0.45384842f, -0.32254007f, 0.36942303f, 
    0.44041649f, 0.22340751f, 0.44255617f, 0.07681580f, 0.26781026f, 0.16558313f, 0.14294179f, 0.49317923f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03850289f, 0.10771742f, 0.00914133f, 0.05320776f, 0.17567225f, 0.11998485f, 0.03630744f, -0.07793359f, 
    -0.01714776f, -0.10554950f, -0.07762416f, -0.08193766f, -0.01479251f, 0.56145000f, 0.20454155f, -0.83391172f, 
    0.02388872f, 0.00354715f, 0.10951248f, -0.12710829f, 0.07276106f, -0.10378096f, -0.07154924f, -0.02405341f, 
    0.13005401f, 0.09457023f, 0.08147531f, -0.01137398f, -0.01676114f, -0.00576607f, -0.30517673f, -0.03717148f, 
    -0.13824806f, -0.04708603f, 0.07966809f, 0.08048785f, 0.55842060f, 0.27299100f, -0.00526073f, -0.11398302f, 
    -0.08129513f, -0.00102929f, 0.21527815f, -0.24205728f, -0.00347821f, 0.15810312f, 0.12690020f, -0.03885038f, 
    -0.46102154f, -0.43688697f, 0.29839349f, 0.05370342f, -0.02442409f, 0.00952164f, -0.07451360f, -0.00542598f, 
    0.02321497f, 0.05211904f, -0.10396886f, -0.07539795f, 0.21737440f, 0.01876263f, -0.11900941f, 0.07057603f, 
    0.09964232f, 0.06385686f, -0.02165654f, -0.12454981f, -0.09779944f, -0.04991608f, 0.07533017f, 0.06377216f, 
    -0.08175329f, -0.04931754f, -0.11114456f, 0.15097199f, 0.05196279f, 0.02483335f, 0.00601643f, 0.00266972f, 
    -0.06611628f, 0.06599181f, 0.01536757f, 0.03255473f, 0.31612653f, 0.29383802f, -0.18169355f, -0.25118962f, 
    0.09402727f, 0.13691290f, -0.02977072f, -0.02142336f, 0.05736661f, 0.07147366f, 0.05607995f, 0.02528846f, 
    -0.10570015f, 0.00436019f, 0.04638881f, 0.09068020f, 0.06477477f, 0.02043192f, -0.01297489f, 0.01086724f, 
    -0.27540228f, -0.09653312f, -0.09127678f, 0.13633586f, 0.32938099f, 0.22770527f, -0.26173154f, -0.24362493f, 
    0.12145917f, -0.11684985f, 0.13139918f, -0.01952461f, 0.01291449f, -0.00556283f, 0.00740237f, -0.03187743f, 
    -0.11476057f, 0.13868187f, 0.03283307f, -0.28922796f, -0.03119055f, 0.06295604f, 0.10080291f, -0.28954145f, 
    -0.05683698f, -0.00247942f, -0.11462118f, -0.21475618f, -0.39678979f, -0.64826047f, 0.06925149f, -0.09178320f, 
    0.02136466f, 0.03409549f, -0.02118751f, 0.13345313f, -0.20456046f, -0.04723347f, -0.07978894f, 0.07140160f, 
    0.41739121f, 0.05059441f, -0.08250596f, -0.40624195f, -0.02876736f, -0.13313940f, 0.05397135f, 0.14645930f, 
    -0.01360120f, 0.03273498f, 0.10024231f, -0.01750595f, -0.61881667f, -0.40857816f, 0.15229459f, 0.11124749f, 
    0.06508680f, 0.07174876f, -0.03420243f, 0.07692990f, 0.06966614f, -0.02676592f, -0.06742952f, 0.06784455f, 
    -0.17111185f, -0.09223910f, 0.14380223f, -0.08643921f, -0.50540322f, 0.09843015f, -0.22356644f, -0.08307635f, 
    0.07882687f, -0.10869459f, -0.14622182f, -0.20681129f, 0.38036954f, 0.18955241f, -0.03385710f, -0.26760593f, 
    0.12258571f, 0.19718149f, 0.02274189f, 0.01230944f, -0.05618436f, -0.14157338f, -0.09005017f, -0.08290748f, 
    0.08761986f, -0.45159149f, -0.04108679f, -0.11597742f, -0.09521033f, 0.10381340f, -0.14188495f, -0.16856642f, 
    -0.01173258f, -0.10271927f, -0.06572735f, -0.17565660f, -0.43225953f, -0.49391896f, -0.73473144f, 0.01758117f, 
    0.01925313f, 0.02442339f, 0.07183119f, 0.07178522f, -0.06587183f, 0.03126835f, -0.01522202f, -0.05249271f, 
    -0.36443397f, -0.66606820f, -0.46930441f, 0.05453910f, -0.09702877f, -0.03017853f, 0.07526998f, -0.08548451f, 
    -0.04301900f, 0.01210125f, 0.01125978f, -0.19174698f, -0.21032178f, 0.00813721f, 0.26982686f, -0.19039203f, 
    -0.16909289f, -0.11518568f, 0.05068168f, -0.04236677f, -0.07246309f, -0.16521817f, 0.04314354f, 0.07368004f, 
    -0.43290934f, -0.26305345f, -0.04592023f, 0.03738682f, -0.14817606f, -0.15646464f, -0.02680976f, -0.02469550f, 
    -0.05593192f, 0.01649775f, 0.03065074f, 0.05939458f, 0.30912924f, 0.11989287f, 0.09640060f, 0.00184293f, 
    -0.04505583f, -0.04995202f, 0.00230409f, -0.03707478f, 0.03218742f, -0.19529396f, -0.25367445f, -0.01952133f, 
    0.46614987f, 0.29108667f, -0.14948554f, -0.17457762f, 0.17554432f, 0.24080139f, 0.01101751f, 0.14260694f, 
    0.03247657f, 0.02309499f, 0.05990212f, -0.00589755f, 0.23185666f, 0.07051081f, -0.05105481f, -0.13818158f, 
    0.12619035f, 0.14066873f, -0.04793676f, -0.01856916f, -0.08924305f, 0.00692560f, -0.05004254f, -0.05816313f, 
    0.20582837f, -0.48559213f, 0.13543089f, -0.57716686f, -0.12160607f, 0.05356330f, 0.00633242f, -0.06048212f, 
    -0.02287716f, -0.06752124f, -0.17774293f, 0.02824450f, 0.09217032f, -0.20908977f, -0.03322918f, -0.01519957f, 
    0.07624597f, 0.15734346f, -0.38177204f, -0.17225549f, -0.01492328f, -0.03385888f, -0.04881292f, -0.02701024f, 
    -0.44226179f, 0.15442906f, 0.11387381f, 0.00147988f, 0.04440214f, 0.07752073f, 0.06661033f, -0.15211312f, 
    -0.22241667f, -0.31988326f, -0.21883360f, -0.19289014f, 0.26921776f, 0.19467609f, 0.12769574f, -0.16783324f, 
    0.05388458f, 0.17948821f, 0.20289250f, 0.10858780f, 0.06042184f, 0.02867228f, 0.04697119f, -0.08206338f, 
    -0.07242312f, 0.05047133f, 0.06178215f, 0.01119235f, -0.14115435f, -0.08133675f, -0.24603194f, -0.20810547f, 
    -0.02196696f, 0.06881142f, -0.05724764f, 0.04765741f, -0.15400462f, -0.14229041f, 0.09177931f, 0.06406210f, 
    0.12294626f, 0.05830026f, 0.06933783f, 0.08861048f, 0.04356648f, 0.33658630f, 0.05665512f, -0.07629695f, 
    0.47493413f, 0.01939745f, -0.05223740f, -0.74746829f, -0.21318574f, -0.14805311f, -0.15304230f, 0.16996913f, 
    -0.03840889f, -0.08380850f, -0.01472365f, 0.02019352f, -0.75885946f, -0.41868982f, -0.64193314f, 0.05144093f, 
    0.05551906f, 0.04247688f, -0.00775756f, -0.01262972f, -0.10372514f, 0.01424454f, 0.01731003f, 0.01812964f, 
    0.05302905f, 0.12049431f, 0.12310129f, -0.00380111f, -0.03177269f, 0.00020655f, 0.11497112f, 0.07378392f, 
    -0.11880014f, 0.11215786f, -0.02850263f, -0.12275155f, -1.40559769f, 0.19774245f, -0.51563776f, -0.04991909f, 
    0.02553282f, -0.11734830f, -0.08957969f, -0.01218721f, -0.05217946f, -0.03360500f, 0.09982240f, 0.09673805f, 
    -0.30374369f, -0.01345472f, 0.34652022f, -0.31624186f, 0.16317154f, 0.01261772f, -0.21252140f, 0.00414822f, 
    -0.15444048f, -0.06612393f, -0.47283268f, -0.20579585f, 0.02666829f, -0.01953171f, -0.11212864f, 0.02261726f, 
    -0.06753474f, 0.06294231f, -0.04603981f, 0.02275616f, 0.29290503f, -0.29658729f, -0.25366375f, -0.10543999f, 
    0.78769708f, 0.13771817f, 0.27132469f, 0.03533834f, -0.05515660f, -0.07790503f, 0.08026928f, -0.10692267f, 
    0.01038253f, 0.18416432f, -0.06172381f, 0.12439021f, 0.33236510f, -0.18978348f, -0.02843072f, -0.11593688f, 
    0.10753223f, 0.15753841f, -0.11789785f, -0.20786577f, 0.25695831f, -0.02160371f, -0.01980154f, 0.11258695f, 
    0.19408162f, 0.11756044f, 0.11084972f, -0.00343016f, 0.01577628f, -0.11072812f, 0.02943108f, -0.05106023f, 
    -0.05822045f, 0.08907862f, 0.02630115f, 0.02914684f, -0.06908789f, -0.05928676f, 0.14095888f, -0.06899805f, 
    -0.12289698f, -0.14370911f, -0.34316197f, -0.10978541f, -0.05784377f, -0.08473952f, -0.12115711f, 0.03811700f, 
    0.11091647f, 0.14016758f, 0.09092030f, 0.10135004f, -0.07658251f, -0.03061147f, 0.03049008f, -0.05233112f, 
    0.26121467f, -0.11999165f, 0.17393230f, -0.01819299f, -0.06679792f, -0.04124006f, -0.10918603f, 0.07546482f, 
    -0.30524683f, 0.20352501f, -0.25090444f, -0.22620326f, -0.07836782f, -0.01595719f, 0.04674729f, 0.11310634f, 
    -0.36866042f, -0.00651904f, -0.15702778f, 0.15357804f, -0.04335769f, 0.00564238f, -0.07534970f, 0.00334504f, 
    0.00203457f, 0.10657753f, -0.14736059f, -0.11194392f, 0.11051209f, -0.12517542f, 0.07907549f, -0.12369806f, 
    0.07056733f, 0.07061560f, 0.03865011f, 0.03592654f, 0.21323520f, -0.31809115f, -0.58711588f, 0.00918630f, 
    -0.12228602f, -0.07782695f, -0.10985311f, -0.34755677f, -0.14338107f, -0.01384578f, -0.01333482f, 0.03582981f, 
    -0.15239352f, -0.08531383f, 0.03224856f, -0.12116346f, 0.01513852f, 0.03273647f, -0.00090393f, 0.03936877f, 
    0.04003170f, -0.02165346f, -0.13332745f, -0.00925631f, -0.42429501f, -0.08993457f, -0.00645446f, -0.15771449f, 
    -0.20539960f, -0.00447685f, -0.16382615f, -0.04742997f, 0.04866425f, -0.05155973f, 0.05366290f, -0.06029912f, 
    -0.10211646f, 0.09919828f, 0.07064035f, 0.03343358f, 0.11171369f, 0.27275294f, 0.16357012f, 0.15853788f, 
    -0.00372092f, -0.06606211f, 0.10351314f, 0.22219199f, -0.02945279f, 0.06167590f, -0.01415052f, 0.02560425f, 
    -0.22964260f, -0.22891168f, 0.12392386f, -0.22630261f, 0.00120564f, 0.04157059f, -0.12267452f, 0.14461316f, 
    -0.03790389f, -0.06138465f, 0.07617731f, 0.22546138f, 0.54608834f, 0.15834950f, 0.18379644f, 0.30156621f, 
    -0.08118787f, -0.00459025f, -0.03824587f, 0.04034202f, 0.04339249f, 0.03724681f, -0.03291105f, 0.15746006f, 
    0.97135323f, 0.00337086f, 0.32009044f, 0.30569994f, -0.08352255f, 0.01391594f, -0.08850142f, -0.09477885f, 
    0.02568127f, 0.05261622f, 0.01535226f, 0.09669446f, -0.14988190f, 0.25969270f, -0.03679504f, 0.10905386f, 
    0.09910471f, 0.20606124f, -0.02018332f, -0.15647942f, 0.18734722f, -0.02878871f, -0.03752044f, 0.09951784f, 
    -0.04499634f, -0.28668529f, -0.00137579f, -0.15502352f, -0.03567870f, -0.03716222f, 0.02974951f, 0.11873988f, 
    0.02607233f, -0.03997765f, 0.15101838f, 0.02340595f, 0.26413345f, 0.08527278f, -0.07581200f, 0.10583775f, 
    -0.06666075f, 0.01855170f, 0.10201113f, -0.07509172f, 0.05643767f, -0.11303957f, -0.02483046f, 0.17064825f, 
    0.61582249f, 0.15603264f, 0.22204578f, 0.04096702f, -0.03806588f, 0.17291984f, -0.03764354f, -0.11350010f, 
    -0.04989126f, -0.00965948f, -0.10284129f, -0.01529341f, -0.21802528f, -0.06922673f, 0.07406664f, -0.36926544f, 
    -0.02507753f, 0.03182171f, 0.08489352f, -0.13364726f, -0.14127095f, -0.11695379f, 0.15362684f, -0.16340320f, 
    -0.38987750f, 0.24133535f, 0.12046751f, 0.23913167f, 0.04432398f, 0.06998242f, 0.21768847f, -0.19938701f, 
    0.13490033f, 0.10578876f, -0.02671439f, 0.05801164f, 0.15574913f, -0.05219858f, 0.00250524f, -0.00094881f, 
    -0.01936329f, -0.14730906f, 0.09497659f, 0.00277606f, -0.04393584f, -0.10508715f, 0.01448822f, 0.01716024f, 
    -0.44863167f, 0.11116360f, -0.11882485f, -0.19353823f, -0.11011021f, 0.12797435f, 0.03676369f, -0.04636041f, 
    0.00172587f, 0.11039034f, 0.07625362f, -0.02125365f, 0.27773470f, 0.14718540f, -0.03813047f, -0.21097681f, 
    -0.14697774f, 0.13639845f, 0.06281560f, 0.02576673f, -0.01991336f, 0.04778885f, -0.02193499f, -0.11252878f, 
    0.00672694f, -0.03145793f, -0.06947579f, -0.00814416f, 0.05727599f, 0.19759235f, 0.00378983f, -0.08419268f, 
    0.03142329f, -0.10610927f, 0.02693978f, 0.05843098f, 0.12454396f, -0.01023488f, -0.28935415f, -0.21211143f, 
    -0.08239307f, 0.03686828f, -0.02893553f, -0.08522474f, 0.03567555f, -0.20873626f, -0.06036472f, -0.13519126f, 
    0.05937925f, -0.20919642f, -0.22441928f, -0.90517253f, 0.11557071f, -0.07333332f, -0.19884364f, -0.05460831f, 
    0.04819652f, -0.05393443f, -0.02048065f, 0.02319674f, 0.30739412f, 0.19099465f, 0.52274680f, -0.09817883f, 
    -0.00484111f, -0.01141688f, -0.06038477f, -0.00277561f, -0.00334063f, 0.03017780f, -0.06526490f, 0.09046330f, 
    -0.11954731f, -0.06043908f, -0.02679452f, 0.02640836f, -0.22342227f, -0.00553961f, 0.04852909f, -0.09996611f, 
    -0.05889323f, -0.10769481f, -0.04007253f, -0.13084057f, -0.22294658f, 0.01073299f, -0.56209362f, 0.13353199f, 
    -0.22705105f, -0.08483472f, -0.18224451f, -0.01155066f, -0.05236893f, -0.03507692f, 0.03347101f, -0.08224265f, 
    -0.10748994f, -0.01549511f, 0.05026265f, 0.11051038f, -0.04076042f, -0.00452454f, 0.12955084f, -0.19731799f, 
    0.00432843f, 0.16177845f, -0.10388269f, 0.24431778f, -0.13970977f, -0.23957251f, -0.01623184f, 0.22218473f, 
    0.05526153f, -0.12765856f, 0.01734501f, 0.19586964f, 0.02407416f, 0.08592092f, -0.15598696f, 0.16825134f, 
    -0.23803060f, 0.20439819f, -0.04398487f, -0.06142599f, 0.02939655f, 0.05859588f, 0.03714417f, -0.04214286f, 
    0.01675758f, -0.00621163f, 0.04662190f, -0.01310438f, -0.07854024f, 0.40199557f, -0.00067814f, 0.20661187f, 
    -0.18597908f, -0.01019490f, 0.14818843f, -0.14464824f, 0.07197999f, 0.18299361f, 0.09453370f, -0.02463185f, 
    -0.26492923f, -0.22667633f, 0.07930956f, 0.03944654f, -0.07219576f, 0.01156520f, 0.08378641f, 0.02805071f, 
    0.00167252f, -0.04060161f, -0.03517250f, 0.01577447f, -0.13685527f, -0.64636034f, -0.11016997f, -0.25574836f, 
    0.08787632f, -0.00062217f, -0.23184523f, -0.07484432f, -0.01187415f, 0.06421337f, -0.04314225f, 0.03944703f, 
    -0.08286078f, 0.01605889f, -0.11106963f, -0.11410575f, 0.00768142f, -0.04471685f, 0.01584729f, -0.00912126f, 
    0.06299992f, 0.05110023f, -0.05789422f, 0.05223074f, -0.42365527f, -0.31130046f, -0.34406698f, -0.22106494f, 
    0.09603044f, 0.15273166f, 0.08454853f, -0.22977674f, 0.04810730f, -0.02240494f, -0.00278660f, -0.02276852f, 
    -0.31736723f, -0.03371035f, -0.11163953f, 0.17833208f, 0.17723748f, 0.04508043f, -0.08373266f, 0.11252898f, 
    0.20060597f, 0.02094225f, -0.03933595f, -0.05836403f, -0.05921324f, -0.10736737f, -0.09314227f, -0.15831390f, 
    0.02577453f, -0.04060839f, -0.04354999f, -0.03601604f, -0.06849533f, -0.18141788f, 0.13173947f, 0.03724910f, 
    0.41649321f, -0.04811112f, -0.52611858f, 0.20262878f, -0.00675223f, -0.03234336f, -0.05134789f, 0.06042773f, 
    -0.03660264f, -0.05774183f, 0.13067342f, -0.10343041f, 0.08740889f, -0.00083002f, -0.16487791f, 0.03289643f, 
    0.04145840f, -0.01732063f, -0.00575648f, -0.08072414f, 0.16830587f, 0.23259816f, 0.22274436f, 0.02543368f, 
    -0.25081643f, -0.08582814f, -0.14122841f, 0.11798554f, -0.05320333f, -0.19047201f, -0.19324650f, -0.27367294f, 
    0.06896038f, -0.01855308f, -0.17109235f, -0.00932391f, -0.92038375f, -0.33314258f, -0.22872609f, -0.39949217f, 
    -0.02051389f, -0.00080989f, 0.03636281f, -0.16888042f, -0.02547970f, -0.06611519f, -0.06359763f, -0.06996928f, 
    -0.48639125f, -0.04258104f, 0.00617427f, 0.05133152f, -0.02421175f, -0.00598542f, -0.26518017f, -0.38497835f, 
    0.07146786f, -0.08162177f, -0.05214230f, 0.09595372f, -0.39894831f, -0.09343860f, -0.03632644f, -0.23504631f, 
    0.04717600f, -0.00603693f, -0.03219826f, 0.10235325f, 0.07582168f, -0.08703265f, -0.04671530f, -0.10561395f, 
    0.11107442f, -0.09387169f, -0.16728009f, 0.45026043f, -0.08454520f, 0.04994861f, -0.03002601f, -0.01319287f, 
    0.06437550f, 0.09961919f, -0.21051547f, 0.11791567f, 0.15051556f, 0.07960972f, -0.12812629f, -0.12328873f, 
    -0.03417909f, 0.15420327f, -0.01154604f, 0.14357735f, -0.03526787f, -0.02871306f, 0.04130439f, -0.18704386f, 
    0.33941773f, 0.18129927f, -0.32696024f, 0.00816616f, 0.13829248f, -0.20112959f, 0.02467628f, -0.06217628f, 
    -0.02197427f, -0.05733178f, 0.05241282f, 0.02810723f, -0.13949151f, 0.08678190f, -0.10085604f, 0.02479542f, 
    0.08360462f, -0.02325755f, 0.04114299f, 0.13315077f, -0.24068405f, 0.01693249f, 0.17568947f, -0.28583258f, 
    -0.45930529f, -0.51468122f, 0.54360855f, 0.44231901f, -0.07455425f, 0.06253242f, -0.01497259f, 0.11263597f, 
    0.02299705f, -0.01913681f, -0.00042555f, -0.02802877f, -0.13081118f, 0.06398941f, 0.61236745f, 0.42461058f, 
    -0.00163277f, 0.01073180f, 0.21847063f, 0.17136586f, 0.06641538f, -0.04304479f, 0.08642843f, 0.01536016f, 
    0.18451817f, 0.02848455f, -0.38783038f, 0.29489267f, -0.01465146f, -0.12998435f, 0.13742609f, 0.04642489f, 
    -0.04229774f, 0.21205235f, -0.23709990f, 0.30285031f, -0.20995104f, -0.10994041f, 0.21624725f, 0.02354688f, 
    0.17106211f, -0.01210496f, -0.23155619f, 0.33712780f, 0.05771642f, -0.19118048f, 0.10720627f, -0.13113756f, 
    -0.30945581f, 0.15498918f, 0.01988979f, 0.06457249f, -0.00779289f, 0.19851865f, -0.01374118f, 0.06795188f, 
    -0.25455239f, 0.04922811f, -0.05608525f, 0.04985830f, 0.26168102f, 0.71895534f, 0.52318400f, 0.58235759f, 
    -0.06970903f, 0.00097605f, -0.09640562f, 0.16909224f, -0.09478672f, -0.00873483f, -0.02896844f, 0.01171282f, 
    0.03246455f, 0.00886423f, 0.03306764f, 0.01478964f, -0.15442491f, -0.16125439f, 0.01045941f, 0.13240981f, 
    0.03468356f, -0.04646349f, 0.00270205f, 0.01950207f, -0.00861674f, 0.31279176f, 0.17483334f, 0.16706726f, 
    0.01238870f, 0.00376457f, 0.04051973f, -0.07671146f, -0.00146785f, -0.08902885f, -0.01962854f, 0.07197788f, 
    -0.86492437f, 0.33522147f, 0.14532268f, -0.07362238f, -0.04111950f, 0.04341652f, -0.03337530f, 0.04579811f, 
    0.01415024f, -0.05938870f, -0.00573231f, 0.00620213f, -0.16982317f, 0.13173845f, 0.11242248f, -0.17442183f, 
    -0.01856842f, 0.03622263f, -0.02551505f, 0.09828755f, 0.05652884f, -0.10018542f, 0.01546377f, -0.01622164f, 
    0.05777752f, 0.27409711f, 0.08083707f, 0.22473320f, 0.10583974f, -0.23644926f, 0.08851754f, -0.17368513f, 
    0.06434964f, 0.18894443f, 0.13460520f, 0.23831126f, 0.19787459f, 0.05483907f, -0.33122623f, 0.07511808f, 
    -0.01552564f, -0.25483146f, 0.10586058f, 0.10439939f, -0.06265023f, -0.01455768f, -0.05808112f, 0.10081355f, 
    0.38684717f, -0.14814134f, 0.09954641f, 0.11218885f, 0.00506434f, 0.03427842f, -0.03017267f, 0.07997262f, 
    0.01729958f, -0.02466376f, 0.01102050f, 0.10212918f, 0.06659201f, 0.61525196f, -0.46832508f, -0.44736457f, 
    0.10942480f, 0.17991452f, 0.15374658f, 0.06154864f, -0.24928133f, 0.01324939f, -0.12574257f, 0.10849565f, 
    -0.19297944f, -0.26303491f, 0.22654778f, -0.10321665f, -0.29592833f, -0.18046679f, 0.07079040f, 0.04513352f, 
    -0.13365412f, -0.08173752f, -0.04157289f, -0.03633855f, -0.32624996f, -0.09949640f, 0.01321371f, 0.44828275f, 
    -0.01575153f, 0.10032251f, 0.06858915f, 0.04883239f, -0.05447236f, -0.02188216f, 0.04894498f, 0.10112821f, 
    -0.53144020f, -0.18136477f, 0.04319640f, -0.15579799f, -0.37237585f, -0.21335377f, -0.31944785f, -0.16299394f, 
    0.01178094f, 0.11145473f, -0.12215773f, -0.05135003f, 0.00111491f, -0.27233982f, -0.11324836f, 0.17713144f, 
    -0.06064478f, 0.02157412f, 0.09262924f, -0.10255316f, 0.01975168f, 0.08288524f, -0.12090541f, 0.01440931f, 
    -0.22860955f, 0.17318533f, -0.00934011f, -0.02972951f, -0.09229193f, -0.09211231f, 0.04889855f, -0.04365003f, 
    0.14734806f, 0.15303095f, 0.07723461f, -0.04242165f, -0.13279967f, -0.17129035f, -0.03318102f, 0.21272166f, 
    0.13062724f, 0.13205566f, -0.09181935f, 0.00267199f, -0.01537017f, -0.08624823f, 0.09874803f, -0.10260677f, 
    0.37730694f, 0.36596319f, -0.23162262f, -0.33236781f, 0.30258128f, 0.04355435f, -0.29359752f, 0.13136823f, 
    -0.03515327f, 0.10142799f, -0.15875065f, -0.06161794f, -0.02503058f, 0.13714072f, 0.24675542f, -0.14880985f, 
    -0.14048079f, -0.01836134f, 0.01952006f, -0.22183689f, 0.14836600f, -0.01275039f, 0.16790907f, -0.00222415f, 
    0.25858513f, 0.71177280f, 0.17399028f, -0.25295970f, -0.02172842f, 0.03059798f, 0.14878091f, 0.00776166f, 
    -0.46694511f, 0.11133327f, -0.22410892f, 0.03431304f, 0.48402056f, 0.02790899f, 0.13031670f, 0.02197366f, 
    0.03986859f, 0.06216034f, 0.01125294f, -0.01785268f, 0.11220339f, 0.19698465f, 0.15344122f, 0.05500390f, 
    0.26613113f, -0.32843566f, 0.10576305f, -0.36857980f, -0.13529733f, -0.08225514f, 0.07908767f, 0.32203946f, 
    0.08305032f, 0.00501586f, -0.32783791f, -0.07397891f, 0.06756564f, -0.15717331f, 0.01852136f, 0.27655134f, 
    0.01427157f, 0.00440219f, -0.01556285f, 0.04901609f, -0.08361657f, -0.01135746f, -0.06999999f, -0.08383624f, 
    0.00631368f, -0.06958687f, 0.24315867f, 0.11467002f, -0.12016656f, -0.03939385f, -0.19332030f, 0.19982655f, 
    -0.01206272f, -0.00678185f, 0.01388896f, -0.16278760f, 0.17279138f, 0.06703784f, -0.20281173f, 0.14486682f, 
    0.27901506f, 0.29954728f, 0.08139303f, 0.17521651f, -0.22936761f, 0.27099785f, 0.04860843f, -0.19125794f, 
    -0.98545867f, 1.27770638f, -0.52701956f, 0.28392345f, 0.19020011f, -0.12671980f, 0.02471314f, -0.31514642f, 
    -0.14713193f, 0.17858705f, -0.14083706f, -0.15609789f, -0.09121906f, -0.11485083f, -0.22395641f, -0.38193807f, 
    -0.04148142f, -0.08403649f, -0.17698079f, -0.28634208f, 0.01116362f, 0.00285603f, -0.07334630f, -0.05557703f, 
    0.48966834f, 0.64698249f, -0.02004858f, -0.18031128f, -0.20008336f, 0.03148200f, -0.02790956f, -0.24291757f, 
    -0.10825903f, -0.06889282f, -0.03637075f, 0.34396577f, -0.79270649f, 0.48897129f, -0.16945095f, -0.82005250f, 
    0.31616837f, 0.10623283f, -0.10865977f, -0.15826485f, -0.33740488f, -0.02694479f, -0.00989693f, -0.23210339f, 
    0.04550932f, -0.17942433f, -0.07432732f, 0.17299351f, 0.06347975f, -0.15536281f, -0.12123068f, -0.21110295f, 
    -0.15278751f, 0.11961890f, -0.08848259f, 0.03281428f, -0.05155425f, -0.17345874f, 0.06149859f, 0.06515522f, 
    0.20687154f, 0.13809699f, -0.04233105f, -0.05628146f, -0.19783840f, -0.08690672f, 0.08575562f, 0.07731941f, 
    0.06478327f, 0.24742608f, -0.62853795f, -0.75838012f, 0.02013835f, -0.29793513f, -0.15043797f, 0.04619152f, 
    -0.26927668f, 0.01842136f, 0.00052451f, -0.09004734f, -0.36486793f, 0.12401632f, 0.31548262f, 0.05140854f, 
    -0.14924735f, -0.02324411f, 0.06639930f, -0.06242499f, -0.07314770f, -0.02583915f, -0.02227120f, 0.02741877f, 
    0.41616192f, 0.06676975f, -0.13595238f, 0.04409191f, 0.21999216f, 0.02176839f, 0.18700552f, 0.08039203f, 
    0.10099566f, 0.06615573f, -0.03731547f, -0.06559715f, 0.07604560f, -0.24279509f, -0.00265328f, 0.24786589f, 
    0.13028865f, -0.06211763f, -0.04435549f, -0.09679305f, -0.13960822f, -0.08141245f, 0.13080570f, 0.09251428f, 
    -0.15306109f, 0.28528357f, -0.16389616f, 0.06448960f, -0.09632571f, -0.12012492f, -0.11064799f, -0.22253387f, 
    0.08462443f, 0.00561400f, -0.15803777f, -0.09709809f, -0.02020974f, -0.25719810f, 0.11891039f, 0.20562705f, 
    0.23012260f, 0.19298416f, -0.08262464f, -0.02777756f, -0.18649787f, 0.02499456f, 0.04201264f, -0.13204628f, 
    -0.16553947f, 0.12178934f, 0.16279744f, 0.57295167f, -0.19926210f, -0.20044364f, 0.02351866f, -0.15685984f, 
    -0.14434038f, 0.15504040f, 0.11081628f, 0.16065474f, -0.59690273f, 0.18102637f, 0.07237044f, 0.02486279f, 
    -0.04986119f, 0.03468374f, -0.42569026f, -0.08323919f, -0.17424393f, 0.02834286f, 0.07087191f, -0.04711689f, 
    0.14001015f, -0.02611519f, 0.09786674f, 0.10046078f, 0.01308466f, 0.13186297f, -0.06919607f, 0.05845697f, 
    0.00680796f, -0.18317547f, -0.18765455f, -0.14951842f, 0.13489185f, -0.13497756f, 0.34919921f, 0.28799462f, 
    -0.16957521f, 0.16006348f, -0.24324563f, -0.11398870f, -0.11248613f, 0.01846553f, -0.05461781f, -0.01002897f, 
    -0.05996683f, 0.10347552f, -0.16434722f, 0.08319376f, -0.05306765f, -0.10522760f, 0.09417367f, -0.06347783f, 
    0.14178880f, -0.03266384f, 0.19167811f, 0.41884604f, -0.04402933f, -0.57116944f, 0.32920262f, -0.01221933f, 
    -0.08485603f, -0.05424358f, -0.09345417f, -0.11143578f, -0.19992307f, -0.00445303f, 0.05519061f, 0.08896048f, 
    -0.54677552f, 0.38268620f, -0.62105089f, -0.14573926f, 0.10149819f, -0.08579269f, -0.06409024f, 0.16436404f, 
    -0.09539525f, 0.10634472f, -0.01486064f, -0.21019056f, -0.06319710f, -0.01362413f, 0.12398420f, 0.03626462f, 
    0.04898676f, -0.16589987f, -0.01480386f, -0.21646665f, 0.08892260f, -0.01484194f, -0.04453745f, 0.00961878f, 
    0.06996644f, 0.13865314f, 0.15439394f, 0.17938222f, 0.10941133f, 0.05809064f, 0.11052161f, 0.06242434f, 
    0.04706912f, -0.05091452f, 0.00133224f, -0.06541754f, 0.14012092f, 0.14652680f, 0.16425541f, 0.31311199f, 
    -0.10662655f, 0.11750858f, -0.01065913f, -0.05544886f, 0.03452188f, 0.06937950f, 0.00248512f, -0.02378662f, 
    0.00665050f, -0.03248888f, 0.04914094f, 0.01012045f, 0.12763901f, 0.06850695f, 0.00169577f, 0.01924072f, 
    -0.04528113f, -0.04406666f, 0.09705463f, 0.21496674f, 0.19123067f, 0.23060787f, 0.34256458f, 0.04663270f, 
    -0.21707690f, -0.20869255f, 0.01748957f, 0.09785600f, 0.09669154f, -0.08281124f, 0.03438553f, -0.07067851f, 
    0.17223640f, -0.19304071f, 0.01069514f, -0.09130958f, -0.19259211f, -0.00338239f, -0.02624297f, -0.07029399f, 
    0.07208071f, -0.03154114f, -0.05999803f, -0.26909804f, 0.07839618f, 0.20423733f, -0.08357495f, 0.16962568f, 
    0.09113965f, 0.00033597f, -0.07256515f, -0.07201415f, -0.17986844f, 0.34682328f, 0.15577076f, -0.07432836f, 
    0.01545033f, -0.80923873f, 0.03047190f, -0.28146443f, 0.04967017f, -0.04908027f, 0.15569596f, -0.18145064f, 
    0.12534207f, 0.22854233f, -0.15960377f, 0.03944943f, 0.02686835f, 0.00701285f, -0.08311533f, -0.09879308f, 
    -0.00640588f, -0.13698287f, 0.08957692f, -0.07491085f, 0.06499150f, -0.00610311f, 0.06273477f, 0.33297020f, 
    -0.06582236f, -0.14386860f, 0.14019413f, 0.09296183f, -0.13541590f, 0.11067979f, -0.05323017f, -0.02680716f, 
    -0.03088008f, -0.18523607f, -0.07017955f, -0.03431695f, -0.02259387f, 0.01515453f, 0.14638478f, 0.16393210f, 
    0.10972125f, 0.12546048f, 0.08998892f, -0.02589640f, -0.01442662f, -0.05753873f, 0.03625816f, -0.02783500f, 
    -0.12198500f, 0.15960717f, 0.21589212f, 0.18590114f, -0.01914254f, 0.12208965f, 0.02879237f, 0.00631988f, 
    -0.09544020f, 0.03160507f, -0.08750948f, -0.17920262f, 0.14177047f, 0.16175717f, -0.14401437f, -0.42847717f, 
    0.12522396f, 0.09703682f, 0.01841017f, 0.15103200f, 0.01886530f, -0.05432928f, -0.14317554f, -0.06152551f, 
    -0.03121682f, -0.58524573f, -0.17208351f, -0.98313040f, 0.04662790f, 0.09854550f, 0.10137919f, 0.13121744f, 
    -0.00866044f, -0.11350439f, -0.09392105f, 0.04808062f, 0.01504065f, -0.03688910f, -0.23295498f, -0.09861886f, 
    -0.03290800f, -0.06456120f, -0.03150910f, 0.13858417f, -0.14109574f, 0.00940201f, -0.20043547f, -0.29624799f, 
    0.37036327f, -0.39649916f, -0.22921439f, 0.57576209f, 0.18383822f, -0.17797804f, -0.02649087f, -0.17144006f, 
    0.15782322f, -0.17097484f, -0.09308999f, 0.00574246f, -0.02087851f, -0.21697225f, -0.21056339f, -0.00151453f, 
    -0.04583255f, 0.00096799f, -0.03228818f, 0.01704074f, -0.26908556f, 0.06402384f, -0.10475817f, -0.07610726f, 
    -0.35333338f, -0.00146238f, 0.06802215f, 0.18320851f, -0.16413757f, -0.00770561f, -0.04203324f, -0.07220720f, 
    0.05310165f, 0.09155019f, 0.07046654f, -0.02176711f, 0.12537880f, 0.23722146f, -0.01769638f, 0.06939758f, 
    -0.29338235f, -0.07779975f, 0.05805758f, -0.04522939f, 0.15198930f, 0.00970007f, -0.22929081f, 0.18014799f, 
    -0.04174691f, -0.17818958f, 0.29245764f, -0.42771935f, -0.25382549f, 0.02296996f, -0.10954452f, 0.14510651f, 
    -0.22350994f, -0.14886601f, -0.04992632f, -0.15415035f, -0.09593077f, 0.15226793f, -0.04367185f, 0.12772720f, 
    0.01075065f, 0.08971086f, 0.08689247f, -0.24144627f, 0.01072684f, 0.01473128f, -0.10344075f, -0.17266081f, 
    0.07733299f, -0.00156829f, 0.03059738f, 0.02560642f, -0.03396080f, -0.01984269f, -0.07532862f, -0.05691029f, 
    -0.01299094f, -0.18613745f, -0.09145622f, 0.02727970f, 0.02754613f, 0.16454805f, -0.00242907f, 0.24997263f, 
    -0.04827039f, -0.02554468f, -0.10775571f, -0.14601758f, -0.04151147f, -0.09221208f, -0.04547229f, 0.05967707f, 
    0.01403394f, -0.00930712f, 0.03355413f, -0.01097149f, 0.11363154f, -0.17967877f, 0.07271724f, 0.01679210f, 
    0.09254616f, -0.07682365f, -0.10908999f, -0.14075913f, 0.04325791f, 0.13353212f, 0.01643122f, 0.04490110f, 
    -0.04283322f, -0.00604107f, 0.09371090f, 0.05032359f, 0.05014220f, 0.00966894f, 0.01493373f, 0.17631122f, 
    0.15591584f, -0.22774543f, 0.00174294f, 0.15717876f, 0.04746762f, 0.00637766f, -0.03763747f, 0.16002932f, 
    0.05842482f, -0.04290292f, -0.05022994f, -0.04056713f, -0.19482398f, -0.83063030f, -0.35452932f, -0.03334054f, 
    0.10181762f, 0.05851637f, 0.12649974f, -0.02797697f, 0.13005218f, 0.00029896f, 0.01640745f, -0.01716736f, 
    -0.15063505f, -0.22652812f, -0.06821892f, -0.17305087f, -0.09831891f, 0.01743328f, -0.05673788f, -0.17284960f, 
    0.15294492f, -0.01889860f, 0.14773452f, 0.16999879f, 0.57944000f, -0.20160763f, 0.70320117f, -0.17103493f, 
    -0.04505247f, -0.00963332f, 0.09161479f, 0.18722917f, 0.10254858f, 0.00979739f, -0.01589170f, 0.03817280f, 
    0.01092630f, 0.07646028f, -0.10802597f, 0.00778690f, -0.01022793f, 0.05066681f, 0.00043865f, 0.00580479f, 
    0.09384705f, -0.06737019f, -0.12583315f, -0.68949342f, -0.29145232f, -0.04698378f, 0.31089181f, -0.25540167f, 
    -0.06775151f, -0.32413962f, -0.04602160f, -0.00361507f, -0.14152151f, -0.13984837f, 0.00672115f, -0.09851383f, 
    -0.11613241f, -0.64117420f, -0.43036449f, 0.13123630f, 0.03581894f, 0.05634242f, -0.13012324f, 0.05242380f, 
    0.07458729f, -0.17123109f, 0.16279709f, -0.05107086f, 0.23191200f, -0.06762517f, -0.14895661f, -0.24873732f, 
    -0.00577794f, -0.01116954f, -0.09130281f, 0.22015500f, -0.04792116f, -0.17059389f, 0.01279356f, -0.18027788f, 
    -0.20504373f, -0.15452270f, -0.14105754f, -0.01315051f, 0.11943866f, 0.09102473f, -0.12657653f, 0.00710957f, 
    0.02617568f, -0.02679441f, 0.01885190f, -0.00414189f, 0.10045138f, 0.23601381f, 0.18167251f, -0.14630964f, 
    0.30821389f, 0.09512339f, 0.08685812f, 0.19858973f, -0.03778159f, -0.10598194f, 0.16570354f, -0.01476173f, 
    -0.03554007f, -0.11184289f, -0.08685358f, 0.00788779f, 0.03086540f, -0.10124874f, -0.07535788f, 0.06248446f, 
    -0.16783302f, 0.14413375f, -0.32929623f, -0.28448537f, 0.10840179f, 0.19452846f, 0.10762738f, -0.01380243f, 
    0.34740838f, 0.15286201f, 0.13806683f, -0.05383799f, 0.00134782f, 0.05636446f, -0.00449744f, 0.05440519f, 
    0.17011873f, -0.19945557f, 0.04359513f, -0.06902964f, -0.01144795f, -0.23915815f, 0.18831886f, 0.02838948f, 
    -0.09102912f, -0.02044461f, 0.20068662f, 0.42395213f, 0.04611279f, 0.01959159f, -0.32356128f, 0.22345865f, 
    0.03066858f, 0.11851097f, -0.02068755f, 0.01335743f, 0.08423889f, 0.07801008f, -0.08520160f, -0.05393508f, 
    -0.15281504f, -0.38381353f, -0.00521834f, 0.61630511f, 0.03184048f, -0.00501369f, -0.08640533f, -0.02699939f, 
    0.05823128f, -0.38492674f, -0.04334673f, -0.21904461f, -0.14112315f, -0.17857315f, -0.24109928f, 0.02034492f, 
    0.05351553f, 0.08878507f, 0.05785118f, -0.00999987f, -0.16695793f, -0.39867109f, -0.32477582f, -0.50459009f, 
    0.24527968f, -0.12089153f, -0.14487851f, 0.41624337f, 0.12805627f, -0.12218605f, 0.14923169f, 0.30136937f, 
    -0.03898285f, 0.15225215f, 0.27122495f, -0.02774113f, 0.12672515f, 0.21101466f, 0.20669697f, -0.11802506f, 
    0.07132100f, -0.07376706f, 0.04113464f, -0.10401614f, 0.11235503f, 0.01763688f, 0.04418247f, 0.02676011f, 
    0.33267027f, 0.01335734f, -0.36539739f, 0.09143792f, -0.00812945f, -0.02052329f, 0.09204383f, -0.07308034f, 
    -0.09846090f, 0.11202971f, -0.02007834f, -0.01745450f, -0.19097495f, 0.00132310f, -0.48331925f, -0.11781599f, 
    -0.02179293f, -0.07613283f, -0.01401014f, -0.07295412f, 0.04453635f, -0.15651926f, 0.16007383f, 0.13287233f, 
    -0.33398145f, -0.27924773f, 0.32857013f, -0.18601042f, 0.13850945f, -0.11494417f, 0.00370477f, 0.14780603f, 
    -0.03099016f, 0.03009076f, 0.08515482f, -0.07810011f, 0.15898260f, -0.49326190f, 0.03478415f, 0.26724318f, 
    0.01581471f, -0.14340964f, -0.04414981f, 0.06766027f, -0.06717850f, 0.09641536f, -0.03070567f, 0.13745031f, 
    -0.68898737f, 0.31509373f, 0.19292362f, 0.21185239f, -0.07649770f, -0.00553656f, -0.14154465f, 0.17743579f, 
    0.03073476f, 0.04609346f, -0.10881664f, -0.10691895f, 0.15094128f, -0.09912626f, 0.22264588f, -0.02760403f, 
    -0.13449432f, 0.10873244f, -0.05249933f, 0.00877373f, 0.16673866f, 0.01341828f, 0.07469580f, 0.11798546f, 
    -0.46000150f, 0.14288867f, 0.07798986f, -0.28817025f, 0.22781232f, -0.08928731f, 0.03369739f, 0.17255260f, 
    -0.04738532f, -0.05212490f, 0.07560372f, 0.13545722f, -0.32449752f, -0.32071277f, -0.24884765f, -0.16462576f, 
    0.10673112f, 0.07886203f, -0.11636837f, -0.00952051f, 0.13673265f, 0.19856149f, -0.01741014f, -0.09893381f, 
    0.07010428f, -0.37355447f, 0.09570612f, 0.14312722f, 0.06711045f, -0.04988293f, -0.05716359f, 0.07875319f, 
    -0.01004330f, -0.06685798f, 0.15642166f, 0.09678496f, -0.09980088f, -0.03401633f, -0.27291283f, -0.08664532f, 
    -0.04353719f, 0.16495742f, 0.11203948f, 0.03282895f, 0.02877882f, 0.05210657f, -0.00056475f, 0.06395933f, 
    0.03963353f, -0.32642287f, 0.20239760f, 0.19745457f, -0.06179982f, -0.16737020f, 0.00394014f, 0.00208935f, 
    0.18841811f, 0.03282927f, -0.02447198f, -0.04039739f, -0.44522449f, -0.22270900f, -0.06306017f, -0.22201173f, 
    0.07665795f, 0.05556376f, -0.08513558f, -0.10674407f, 0.00688787f, -0.06458749f, -0.06101654f, -0.01556574f, 
    -0.06336489f, 0.01717986f, -0.05035186f, -0.00813117f, 0.04852083f, 0.01337938f, 0.14691104f, 0.30263433f, 
    0.03131638f, 0.16020030f, 0.09985098f, 0.03807474f, -0.18751886f, -0.66828579f, -0.25573346f, -0.17798243f, 
    -0.07837063f, 0.06256401f, -0.08148378f, 0.12558158f, -0.02356720f, -0.19058870f, 0.05402281f, 0.04154533f, 
    0.22122131f, 0.14259581f, -0.03697792f, 0.30688873f, 0.12790734f, 0.03845492f, 0.01275907f, -0.00092836f, 
    0.02316765f, 0.13500828f, 0.01780066f, -0.09142895f, 0.49576798f, -0.11480073f, -0.64905918f, 0.47648442f, 
    0.07603431f, -0.06025919f, 0.09834324f, 0.09639339f, 0.13144627f, -0.05101935f, -0.06187822f, 0.04802405f, 
    -0.28178105f, -0.06306133f, -0.13205677f, -0.19300348f, -0.20706716f, -0.49987319f, -0.08672822f, 0.06509034f, 
    0.01760916f, 0.06101216f, -0.09139793f, -0.09720397f, -0.17204724f, -0.73946649f, -1.05716515f, 0.02955356f, 
    -0.09719287f, -0.01927840f, 0.05436273f, 0.17760648f, -0.07690760f, 0.05475856f, -0.07957859f, -0.09966023f, 
    0.15113646f, -0.06584569f, -0.21722299f, -0.24926886f, -0.10061464f, 0.02309018f, 0.05646133f, 0.25547934f, 
    0.01191527f, 0.10410256f, 0.33086815f, 0.12744619f, -0.07576581f, -0.07683855f, 0.12760812f, 0.19252969f, 
    -0.00616679f, -0.02672025f, 0.08697832f, 0.09783188f, 0.00363069f, 0.13997388f, 0.21896064f, -0.08539005f, 
    0.24028002f, 0.12817822f, 0.18422380f, -0.37168258f, -0.00329091f, 0.03272763f, 0.23550509f, 0.01569977f, 
    0.11662817f, -0.03720578f, -0.05158185f, 0.11226654f, 0.32580158f, 0.53430754f, -0.26887271f, -0.25779471f, 
    -0.00800176f, 0.04436360f, -0.06608920f, 0.14850692f, 0.00585326f, 0.01030395f, -0.08926497f, 0.12530385f, 
    -0.00040191f, -0.20362681f, -0.22473896f, -0.13345450f, -0.04878807f, 0.10326270f, 0.10748466f, -0.03888181f, 
    -0.10569023f, -0.04117008f, -0.20083264f, -0.02464512f, -0.57431167f, -0.63571733f, -0.73544002f, -0.10239352f, 
    -0.16795565f, -0.01862946f, -0.10346978f, -0.05034458f, 0.06958286f, 0.03402473f, 0.06299356f, -0.08432028f, 
    0.08917259f, -0.08705197f, -0.02795388f, -0.00600408f, 0.06180643f, 0.12849033f, 0.12143309f, 0.00726124f, 
    0.10226460f, 0.11271068f, -0.05543722f, -0.08343263f, -1.13838458f, -0.89254516f, -0.18438192f, -0.47515926f, 
    -0.15256383f, -0.37054628f, -0.14078197f, -0.18139182f, 0.01839713f, 0.01525684f, -0.08887301f, 0.00710833f, 
    -0.32358888f, 0.08086105f, 0.30784437f, 0.02303654f, -0.11389792f, 0.00270316f, 0.10225490f, 0.00304287f, 
    0.03979059f, 0.03250418f, -0.00166325f, 0.20642895f, 0.16663416f, 0.02022532f, 0.08883426f, -0.14423685f, 
    -0.00711702f, 0.03295831f, -0.01822708f, 0.06725773f, -0.02651832f, 0.12727208f, 0.09957283f, -0.00291156f, 
    -0.23013294f, 0.08767943f, 0.35782304f, -0.24943431f, -0.14627060f, 0.15306444f, 0.00390699f, -0.20727693f, 
    0.09676576f, 0.16150588f, 0.09000779f, 0.08254808f, 0.15238765f, 0.09008826f, 0.03835948f, -0.08740030f, 
    -0.06454267f, 0.00624087f, 0.05087389f, 0.01111541f, -0.02570230f, 0.19921337f, 0.21364407f, 0.17079078f, 
    -0.06672683f, 0.03344211f, 0.05918936f, -0.03729598f, 0.09459782f, 0.18385357f, 0.08252898f, -0.24612881f, 
    -0.01187025f, -0.12738316f, 0.08545370f, -0.00451610f, -0.53309655f, -0.78208530f, -0.50936997f, -0.32404634f, 
    -0.21963772f, -0.21098204f, -0.10873627f, -0.34939614f, -0.08684518f, -0.10172649f, 0.03444670f, -0.09922001f, 
    0.90366584f, 0.12928300f, -0.32159308f, -0.41647056f, -0.08256789f, -0.31247774f, 0.39936933f, 0.27711332f, 
    0.03827052f, 0.11118527f, -0.08899009f, -0.13782528f, -0.10069076f, -0.08170670f, -0.11827248f, -0.15023659f, 
    0.00822087f, -0.07627221f, -0.01323915f, -0.06248973f, -0.02765959f, 0.04961397f, 0.02015674f, -0.13124783f, 
    -0.22745058f, 0.09201375f, 0.01108898f, -0.10122155f, 0.07081385f, -0.09720039f, 0.06546934f, 0.10929659f, 
    0.01062175f, -0.00887327f, 0.08995768f, -0.09985219f, -0.03669182f, 0.05283503f, -0.04030645f, -0.00841460f, 
    0.08715782f, 0.02390837f, 0.06564295f, -0.02280401f, 0.00623166f, 0.08719064f, -0.01183425f, 0.09993736f, 
    -0.16131923f, -0.14612715f, 0.27385065f, 0.10040140f, -0.00068841f, 0.26848894f, -0.02135700f, -0.15445483f, 
    0.12283382f, 0.02326198f, -0.01422871f, -0.05713299f, -0.35396650f, 0.14885074f, 0.29797712f, 0.19383655f, 
    0.02519557f, -0.06914514f, -0.04868690f, 0.14854643f, 0.19154155f, 0.11278863f, -0.11184400f, 0.10726570f, 
    -0.61963522f, -1.07079494f, -0.42655459f, 0.10684618f, -0.24340083f, -0.28567448f, -0.03073091f, -0.12483866f, 
    -0.07288345f, -0.01752477f, -0.02231787f, -0.06424713f, -0.61791492f, 0.34614351f, 0.44481081f, 0.08903729f, 
    0.01338672f, -0.01424985f, -0.19979893f, 0.00113868f, -0.01760855f, -0.07542004f, 0.08666721f, 0.13943559f, 
    -0.02842924f, -0.02233505f, -0.34700838f, 0.03424093f, 0.18042339f, -0.03150962f, -0.10844692f, 0.14423209f, 
    0.08538739f, -0.15250503f, 0.16113773f, -0.23704131f, 0.38600135f, -0.24918495f, -0.23771387f, -0.10117995f, 
    0.03623588f, -0.05426235f, 0.26672164f, -0.11601578f, 0.01829729f, 0.00523407f, -0.14220950f, 0.02595612f, 
    -0.12357926f, 0.44623590f, 0.16255070f, 0.05810918f, -0.10905255f, -0.19412094f, 0.01608247f, 0.16584030f, 
    -0.00597366f, 0.09430870f, 0.17757322f, 0.13516895f, -0.94775987f, -0.44664133f, 0.47892782f, 0.65410340f, 
    -0.18027829f, -0.24240467f, 0.14970538f, -0.03962359f, -0.12830567f, 0.06266267f, -0.04756695f, -0.00436567f, 
    -0.00044344f, -0.10131658f, -0.08615878f, 0.02252410f, 0.04107946f, 0.00246034f, -0.03301982f, -0.01138257f, 
    0.03287969f, -0.08829398f, -0.00121096f, -0.05992306f, -0.34452543f, 0.40977207f, 0.32258490f, 0.22961624f, 
    -0.06601032f, -0.07862084f, 0.04103841f, 0.11399776f, 0.05050243f, 0.12951043f, 0.08004933f, 0.04576470f, 
    0.18676364f, -0.10174915f, -0.43562454f, -0.42943439f, 0.10321300f, 0.02409739f, 0.24621902f, -0.37218702f, 
    0.01486791f, 0.17621657f, 0.02780876f, 0.08372141f, 0.09386820f, -0.02114142f, -0.09458771f, -0.22033356f, 
    0.08034469f, 0.02373936f, 0.14895836f, 0.00981717f, -0.04995266f, 0.06650013f, -0.01991857f, -0.16881205f, 
    0.14503063f, 0.09074777f, 0.04025344f, -0.00145131f, -0.00060460f, 0.03160763f, 0.24929127f, 0.02624903f, 
    0.05319726f, -0.00846467f, 0.00972373f, 0.06744121f, -0.09053874f, -0.94226617f, 0.58720529f, 0.18664090f, 
    0.03020299f, 0.05202483f, 0.15802947f, -0.10329569f, 0.02534587f, 0.01624723f, -0.02258265f, 0.06040569f, 
    -0.34209841f, 0.07897197f, -0.04069249f, 0.55193377f, -0.15141051f, 0.00730486f, 0.10736959f, -0.07643706f, 
    0.10997634f, -0.10567541f, -0.03162597f, -0.06617355f, 0.46930644f, -0.22007342f, 0.09807074f, -0.32108912f, 
    0.03302361f, -0.13615814f, -0.30156052f, 0.10577983f, -0.08802700f, -0.10560863f, 0.03119747f, -0.15834773f, 
    -0.20675719f, 0.37936118f, -0.09249099f, 0.17047246f, -0.16014555f, 0.12191659f, 0.15786569f, -0.11402012f, 
    -0.05264524f, -0.00513054f, 0.07665453f, -0.06755134f, -0.84820873f, -0.12067300f, -0.30018416f, -0.08106359f, 
    -0.27382120f, -0.00859949f, 0.21800415f, 0.00166395f, -0.18912753f, 0.01311794f, -0.00478403f, -0.08066253f, 
    -0.04603929f, 0.02995267f, -0.01657233f, -0.01239748f, 0.07554010f, -0.12899342f, -0.00032555f, -0.03555667f, 
    0.08450936f, -0.03319528f, 0.00515627f, -0.04027174f, -0.40756893f, -0.24603178f, -0.10608950f, -0.09091267f, 
    0.08918048f, 0.15933648f, 0.03044874f, 0.00892075f, 0.02150444f, 0.07020774f, -0.07638946f, -0.03284025f, 
    0.11430585f, 0.07836912f, 0.11532773f, 0.02762929f, 0.01774057f, -0.00700030f, -0.07413346f, -0.03702951f, 
    -0.16228506f, 0.01024539f, 0.03947368f, 0.05411751f, -0.70382094f, -0.01855478f, -0.23951772f, 0.31602654f, 
    0.16182384f, -0.07921703f, 0.11370723f, -0.01315378f, -0.07430538f, -0.01632964f, -0.01626403f, 0.07126308f, 
    0.39507234f, -0.11407728f, -0.16764575f, -0.25504762f, -0.02534342f, -0.00239234f, 0.05504389f, -0.06902728f, 
    0.07883196f, -0.01383305f, 0.12069405f, -0.16945000f, 0.01462316f, 0.12117785f, -0.02345808f, 0.08359119f, 
    -0.03572016f, 0.06275129f, -0.03251947f, 0.07118519f, 0.08404962f, 0.05171925f, -0.08974954f, -0.19588909f, 
    0.36986306f, 0.07697956f, -0.27350107f, 0.01406825f, 0.03894877f, -0.00589058f, -0.07522821f, 0.01680000f, 
    -0.07432747f, 0.24116708f, 0.06199430f, 0.06235026f, 0.02424361f, 0.17533655f, -0.01709292f, 0.09933919f, 
    -0.06091037f, 0.04878334f, -0.00688392f, -0.00185867f, 0.07398936f, 0.06613197f, 0.00704055f, 0.02503049f, 
    0.01508806f, 0.20845027f, 0.14696224f, 0.03534769f, -0.17979658f, -0.02971089f, 0.15391317f, 0.00305046f, 
    0.06009424f, 0.04572118f, 0.01147608f, -0.17766158f, -0.44471318f, -0.36415249f, -0.04059420f, 0.54244709f, 
    -0.02699612f, -0.04739075f, -0.07448052f, 0.00419720f, -0.08736287f, -0.13819252f, -0.10838943f, -0.01612807f, 
    -0.44171005f, 0.15956606f, -0.03897441f, 0.28553331f, -0.04636727f, -0.04997701f, 0.01467912f, -0.05541141f, 
    -0.01143013f, -0.19420370f, -0.00629237f, 0.09812088f, -0.04147905f, 0.00954150f, 0.14523983f, -0.01052839f, 
    0.07642858f, 0.07928869f, 0.04711349f, -0.02104257f, -0.00723876f, -0.01309526f, 0.02690828f, -0.10584943f, 
    -0.02542362f, -0.09997805f, -0.06666667f, -0.14079881f, 0.08649790f, -0.16927193f, 0.07293358f, -0.17312241f, 
    0.05016635f, 0.02686770f, -0.03473835f, -0.08372102f, 0.17282942f, 0.10199682f, -0.13127992f, -0.04868845f, 
    -0.04511193f, -0.07880899f, -0.13292687f, -0.04582579f, -0.10882964f, 0.07647391f, -0.00913745f, -0.09335269f, 
    0.17544217f, 0.02406752f, -0.08872104f, -0.19346526f, -0.09564207f, -0.02612280f, 0.06955186f, -0.02008923f, 
    -0.07901023f, 0.03200082f, 0.10859041f, -0.12272889f, 0.26760787f, 0.04765704f, -0.01881406f, -0.66427606f, 
    -0.01680751f, 0.10938325f, -0.02404860f, -0.01326954f, -0.11973583f, 0.15628278f, -0.07134137f, -0.29057008f, 
    -0.16344701f, -0.47563788f, -0.00679461f, -0.54042941f, 0.05396339f, -0.11023564f, -0.03418905f, 0.28626418f, 
    0.05580468f, -0.03775621f, -0.01390862f, -0.03656657f, 0.77084744f, -0.64603114f, -0.64672548f, -0.66692835f, 
    -0.14965646f, -0.28195304f, -0.12399942f, 0.23223305f, 0.01580208f, 0.18018986f, 0.01517249f, 0.02000225f, 
    0.24843068f, -0.23216896f, 0.08645048f, -0.28062767f, -0.00883986f, 0.08378599f, 0.04256897f, -0.18108064f, 
    -0.05396444f, 0.13759468f, -0.24779207f, -0.13900027f, -0.13049088f, 0.06489143f, 0.07783832f, 0.01982776f, 
    -0.13105835f, -0.08500811f, -0.18334688f, 0.05485410f, -0.05333296f, 0.05218610f, -0.03101876f, 0.02005730f, 
    0.50240576f, -0.28071541f, -0.38429651f, -0.19870274f, 0.02296583f, -0.04330104f, 0.04450380f, -0.12601763f, 
    0.00138571f, 0.05968972f, 0.07397162f, -0.07369778f, 0.02803253f, -0.61257648f, -0.36713752f, -0.56117260f, 
    -0.14300889f, -0.04576217f, -0.15360522f, 0.35006267f, 0.07935926f, -0.01493661f, -0.05472654f, 0.09419756f, 
    -0.05588158f, 0.05754825f, 0.00470791f, 0.01092250f, -0.01237767f, -0.34958452f, -0.18333921f, -0.15044905f, 
    -0.03437951f, 0.03912756f, 0.03384447f, 0.00583272f, 0.28202301f, -0.33735445f, 0.00802063f, -0.19990328f, 
    -0.04529097f, -0.01328872f, -0.08816914f, -0.00802604f, 0.31088826f, 0.12306745f, -0.11108904f, -0.13527757f, 
    0.22461993f, -0.21547984f, 0.10235640f, 0.06688400f, -0.22264713f, 0.18896045f, -0.02684851f, -0.02396096f, 
    -0.01108611f, -0.06423950f, 0.02053703f, 0.07487290f, 0.00597555f, -0.01790366f, 0.03548620f, -0.11265071f, 
    0.10100465f, -0.02314588f, 0.06364321f, -0.06701421f, 0.10112093f, -0.01744859f, -0.02156671f, 0.03369480f, 
    -0.14074610f, -0.17302181f, -0.11505314f, -0.12657918f, 0.00294291f, 0.02957533f, 0.00220751f, -0.06756356f, 
    0.07921341f, 0.18649597f, 0.16072263f, 0.32407385f, 0.99053150f, -0.07603610f, -0.12355707f, -0.29707304f, 
    0.16898073f, 0.00480667f, -0.04563212f, -0.21310902f, 0.06249050f, 0.18794011f, 0.19282445f, 0.01440804f, 
    -0.25291237f, -0.26315251f, -0.07567326f, -0.12737606f, 0.20108907f, 0.08628771f, -0.01608208f, 0.16381520f, 
    -0.15787604f, -0.11784655f, -0.31196484f, -0.65317625f, 0.18394671f, 0.14634539f, -0.33268619f, -0.22582902f, 
    0.04336996f, -0.10048345f, 0.24774222f, -0.05918096f, 0.03760317f, 0.02645332f, -0.20477080f, -0.15973380f, 
    -0.79524416f, -0.02344396f, 0.32936999f, 0.18626948f, -0.08795070f, -0.03284857f, -0.08752573f, -0.05843708f, 
    0.05642398f, -0.16378427f, 0.04160997f, 0.00849715f, -0.19803126f, -0.29174507f, -0.05138477f, 0.41965795f, 
    0.15578668f, 0.14295551f, 0.09715174f, 0.26429117f, -0.10211369f, -0.15881824f, -0.09060831f, 0.04881975f, 
    -0.11911400f, 0.15860945f, 0.03139699f, 0.05413276f, -0.02281111f, -0.08762749f, -0.03016927f, -0.05111557f, 
    0.00643488f, -0.00366883f, 0.04598064f, 0.11830148f, -0.30820099f, -0.43794200f, -0.02869180f, 0.18072587f, 
    0.01527046f, 0.07375320f, 0.10258329f, -0.07698965f, -0.14215982f, -0.09875245f, -0.04935219f, -0.15588450f, 
    -0.20258506f, -0.13645869f, -0.02475628f, -0.06957097f, -0.00645671f, -0.00744206f, -0.03863714f, -0.10701980f, 
    -0.13234055f, -0.14467792f, -0.09537704f, -0.12955822f, -0.07900434f, -0.40612608f, -0.50128084f, 0.14647190f, 
    -0.15972693f, -0.09224457f, -0.03442721f, 0.03814243f, -0.01336754f, 0.04810685f, 0.03796519f, 0.01276836f, 
    0.00210411f, -0.11405712f, -0.25906244f, -0.02737966f, 0.03509335f, -0.16628005f, 0.07149590f, -0.01135315f, 
    0.00816980f, 0.08897945f, -0.29660273f, 0.16294076f, -0.29094988f, -0.06599746f, 0.02706216f, -0.09494899f, 
    0.00612677f, -0.07294696f, -0.09959602f, 0.02440559f, -0.00576282f, -0.26567742f, 0.05284381f, -0.16510603f, 
    0.09442318f, 0.43632159f, -0.27764603f, -0.01062555f, -0.08710320f, 0.00479435f, 0.05521912f, -0.01049238f, 
    0.03500292f, 0.09623033f, -0.09187616f, 0.35399541f, -0.39561114f, -0.03376081f, 0.00681314f, 0.04985116f, 
    -0.01531240f, -0.04631572f, -0.05896251f, 0.03238732f, -0.08421227f, 0.08848953f, -0.03886943f, -0.55756634f, 
    -0.20057718f, -0.08933488f, -0.02713311f, -0.20553344f, 0.21662831f, 0.04792378f, 0.03168318f, -0.05755614f, 
    -0.15470243f, 0.15056069f, 0.11444203f, 0.20000926f, -0.09682040f, -0.43780389f, -0.51391429f, -0.41374055f, 
    -0.04611599f, -0.14007148f, -0.07175616f, -0.03136795f, 0.04557156f, 0.09698106f, 0.06625126f, 0.11282078f, 
    -0.42030841f, 0.05171268f, 0.04247875f, 0.18709423f, 0.25156587f, 0.05979726f, -0.08336832f, 0.13215987f, 
    0.07749665f, 0.09461889f, 0.15339783f, 0.13575405f, -0.53216583f, 0.17491694f, 0.09582552f, 0.09494050f, 
    -0.21201302f, -0.12248585f, -0.00170922f, -0.12123224f, -0.05914362f, 0.07090874f, -0.02714231f, 0.11100496f, 
    0.29368877f, -0.05468220f, 0.08090881f, -0.26034939f, -0.15265132f, 0.11773361f, -0.07510904f, -0.13715692f, 
    0.04229069f, 0.01266514f, -0.00595559f, 0.08848881f, 0.16201358f, 0.02694415f, -0.20440800f, 0.11292013f, 
    0.09707587f, -0.05122285f, 0.13641988f, -0.00532511f, 0.13570407f, -0.05512502f, 0.17518683f, -0.02546584f, 
    0.29987147f, 0.20346664f, 0.10419945f, -0.22528642f, 0.03405350f, -0.08719708f, 0.05258199f, -0.01779257f, 
    -0.08685529f, 0.02252384f, -0.06911483f, 0.12790489f, 0.15593621f, -0.08527660f, -0.28041568f, -0.15972584f, 
    0.00580296f, -0.15145427f, 0.06257033f, -0.07480565f, 0.21480845f, 0.00715306f, 0.24252030f, 0.19986834f, 
    0.02249591f, -0.28289604f, -0.42970797f, 0.18672508f, 0.04739241f, 0.10408041f, 0.08731923f, -0.06218107f, 
    0.01952544f, 0.00386907f, -0.03596122f, 0.05899495f, -0.08912346f, -0.76380455f, -0.10229558f, -0.16513738f, 
    -0.00727579f, 0.17149113f, 0.28740904f, 0.16365993f, 0.03541280f, -0.05385172f, -0.01428959f, 0.04140984f, 
    0.23032984f, 0.04915423f, 0.04610862f, -0.48085400f, -0.02615592f, -0.10828824f, 0.04491198f, 0.02355282f, 
    0.20678708f, -0.16306591f, 0.18922047f, -0.03762348f, -0.20214623f, 0.00148964f, 0.10710077f, 0.11282590f, 
    -0.03360159f, -0.13682882f, -0.19780827f, 0.05622337f, 0.08730941f, 0.11025871f, 0.20249459f, 0.16414540f, 
    -0.03493208f, -0.22729239f, -0.41186857f, -0.18867463f, 0.12109876f, 0.00500017f, 0.09978588f, 0.08907152f, 
    0.12962835f, 0.09148139f, -0.00780824f, 0.22215232f, -0.37522286f, -0.65181452f, -0.68176281f, 0.31379846f, 
    0.18660608f, 0.12930134f, 0.22279236f, 0.02665111f, 0.05770323f, -0.00389182f, 0.21581852f, 0.01396874f, 
    -0.01612929f, 0.03518122f, 0.13107280f, -0.02633050f, 0.09108234f, 0.10669532f, -0.12925132f, -0.15902665f, 
    0.01745298f, 0.15521191f, 0.09302025f, 0.11739054f, -0.30000013f, -0.18602248f, 0.01675207f, 0.01158702f, 
    -0.01361710f, 0.03001188f, 0.04936155f, -0.08949802f, -0.06978619f, 0.09902604f, -0.15400492f, -0.24529000f, 
    -0.09181353f, 0.30687183f, 0.48128858f, 0.07212619f, 0.03478070f, -0.03390272f, -0.12821569f, -0.10794648f, 
    -0.04099182f, 0.06989587f, -0.08750473f, -0.01304843f, -0.53164095f, 0.22771432f, 0.04632354f, -0.03653452f, 
    -0.15821902f, -0.08325341f, -0.14894098f, -0.07232574f, -0.19434623f, -0.05698658f, 0.05943957f, -0.02343606f, 
    0.25858334f, -0.07694764f, 0.17674723f, -0.03548676f, 0.12832586f, -0.20953894f, -0.00646585f, 0.08804100f, 
    -0.05723358f, -0.06463927f, -0.16131327f, -0.01424908f, -0.20428053f, -0.46181360f, 0.11034697f, 0.23716411f, 
    0.04456807f, 0.18046230f, 0.07620309f, -0.27990377f, 0.05180249f, -0.15688255f, -0.15124707f, -0.08848611f, 
    -0.10920443f, 0.30679631f, -0.18663391f, -0.07159271f, 0.06787030f, -0.07372299f, 0.03649854f, -0.07125365f, 
    0.07009343f, -0.02096735f, 0.21627906f, 0.18830080f, -0.15902829f, -0.00455581f, 0.22541714f, 0.38807973f, 
    -0.02906845f, 0.12660873f, -0.31107530f, -0.08430935f, 0.32352349f, 0.02764959f, -0.03908909f, -0.00328247f, 
    -0.28530613f, -0.27856156f, -0.49669528f, -0.08722285f, 0.11298661f, -0.22341751f, 0.04502446f, -0.09014881f, 
    -0.02844689f, -0.07422784f, -0.12089027f, 0.00918545f, -0.22704405f, 0.30830458f, 0.81568599f, -0.70179123f, 
    0.04839432f, -0.21290962f, 0.08799095f, -0.08470967f, -0.05163973f, 0.03349211f, 0.05420885f, 0.04982225f, 
    -0.23173681f, -0.13614210f, -0.57003242f, 0.13389507f, 0.31403294f, 0.07374115f, 0.27584964f, 0.08182008f, 
    0.03969833f, -0.18983068f, 0.05032421f, -0.07718810f, -0.11959630f, 0.20507085f, 0.50785375f, -0.29047108f, 
    -0.30029985f, -0.03239669f, 0.27434251f, 0.05268828f, 0.02386874f, 0.07987400f, 0.04999600f, 0.00564807f, 
    0.01092576f, -0.19184035f, 0.00525343f, -0.06805456f, -0.05075956f, 0.06790280f, 0.03870329f, 0.14002840f, 
    0.08692452f, -0.02386132f, 0.08995575f, 0.15385789f, -0.58240694f, 0.51395875f, -0.09013295f, -0.37408093f, 
    -0.25391802f, -0.19054516f, 0.21731357f, 0.28861415f, -0.05208734f, 0.03375140f, -0.02506112f, -0.06171479f, 
    0.36218318f, 0.03364160f, 0.08119290f, 0.33992302f, 0.15494873f, -0.07313558f, 0.00093476f, -0.14199300f, 
    0.00620795f, -0.14655958f, -0.09395858f, 0.07352938f, -0.09776834f, 0.16729814f, -0.31839228f, 0.28137869f, 
    0.04860985f, 0.03792366f, 0.07893087f, 0.12444589f, -0.06766899f, 0.15410972f, 0.18339013f, 0.15763757f, 
    -0.82257682f, 0.01094643f, -0.47377029f, 0.30637845f, 0.12544078f, -0.05576746f, -0.12027741f, 0.19628936f, 
    0.11615260f, -0.14928277f, -0.09506473f, 0.08554218f, -0.11685061f, 0.18915030f, -0.09934497f, 0.10702373f, 
    -0.00136570f, -0.07472164f, 0.05285897f, -0.00980601f, 0.15875493f, 0.07725824f, 0.03948230f, 0.46565065f, 
    0.14887859f, 0.04947498f, -0.68993020f, -0.05631372f, 0.03456305f, -0.10080061f, -0.12712105f, -0.15147813f, 
    0.17163110f, -0.18641527f, -0.08730106f, -0.07129663f, -0.30992386f, -0.06473991f, 0.01805960f, -0.11136999f, 
    -0.12042949f, -0.06778734f, -0.00554786f, 0.14400750f, 0.06538626f, 0.07529318f, 0.05405848f, -0.05432618f, 
    -0.31330574f, 0.57379460f, -0.47469676f, 0.12426315f, -0.05127375f, -0.15791607f, 0.02206809f, -0.17164227f, 
    0.22285172f, -0.03793032f, -0.03137582f, -0.14071806f, 0.29644182f, -0.17929712f, 0.23574263f, 0.05635562f, 
    0.02196679f, -0.05326691f, 0.08202495f, -0.05720724f, -0.06458467f, 0.30961648f, -0.06447106f, 0.01620083f, 
    -0.18566917f, -0.53995997f, -0.00967457f, -0.42720437f, 0.13476913f, 0.04949521f, 0.04855099f, -0.11096346f, 
    0.04613952f, -0.16147406f, -0.04661037f, -0.12541077f, -0.21402901f, -0.33620682f, -0.03067694f, 0.12616867f, 
    0.04003535f, -0.02250646f, 0.16872348f, 0.00801410f, 0.07410340f, 0.00668934f, -0.14448832f, 0.02399517f, 
    -0.31879693f, -0.26342952f, -0.28479961f, -0.11346947f, 0.00818839f, 0.10145386f, -0.05710244f, -0.03919278f, 
    -0.04624081f, -0.17113441f, 0.04037027f, 0.03037065f, 0.14377150f, -0.38782772f, 0.24352127f, 0.26400861f, 
    0.07210134f, -0.02171937f, -0.20073853f, -0.07559022f, -0.10760523f, 0.07834418f, -0.04154739f, 0.11471193f, 
    -0.17684357f, -0.33160606f, -0.08515824f, -0.37356448f, -0.22479369f, 0.18415040f, 0.04347275f, -0.09012763f, 
    0.14212927f, 0.01723140f, -0.03735661f, 0.01449270f, 0.24396066f, 0.06905839f, -0.31022575f, 0.20120439f, 
    -0.31764191f, 0.03626698f, -0.19563991f, -0.05582567f, 0.10134937f, -0.15221794f, 0.09294794f, 0.05933650f, 
    -0.33490071f, 0.25553569f, 0.23441425f, 0.25086883f, 0.05975733f, -0.07396638f, -0.21653865f, 0.03404308f, 
    -0.05068022f, -0.01265274f, 0.04988329f, -0.33418927f, -0.16007279f, 0.37585694f, -0.24403702f, -0.07746660f, 
    -0.09205274f, 0.00844145f, 0.06266371f, -0.08248775f, 0.00394699f, -0.05870929f, -0.41171712f, 0.13024934f, 
    0.33580843f, 0.08915585f, 0.36365366f, 0.36436316f, 0.16521281f, -0.42350635f, -0.00566448f, -0.35390350f, 
    -0.18172087f, -0.11135713f, -0.09214996f, -0.00867522f, 0.06345832f, -0.22993939f, 0.06497879f, -0.59180063f, 
    -0.13206975f, -0.19063525f, 0.15339126f, -0.21522655f, 0.09032901f, 0.00441846f, -0.02459457f, 0.09598155f, 
    -0.01479948f, -0.17449006f, -0.07344975f, -0.33099025f, 0.17492597f, 0.03466409f, 0.00609803f, 0.17826609f, 
    0.02119685f, -0.02747069f, -0.11277172f, -0.00350466f, 0.42058560f, 0.12568800f, 0.20429000f, 0.12831914f, 
    -0.01501700f, -0.15177576f, -0.17099024f, -0.20654237f, -0.00837346f, 0.18620886f, 0.05408840f, 0.09390347f, 
    -0.28701067f, -0.81903809f, -0.27927577f, 0.14560442f, 0.02906665f, 0.17513469f, -0.00100894f, 0.25162086f, 
    0.03061885f, 0.10607599f, 0.07957041f, -0.11330558f, -0.12527652f, -0.11049950f, 0.06811736f, -0.06386233f, 
    0.09281733f, 0.09939977f, 0.08996815f, 0.02474383f, -0.04165816f, 0.09167203f, 0.01428590f, -0.06689021f, 
    -0.07778726f, 0.17242041f, 0.01478626f, 0.10098290f, -0.16695164f, 0.17306282f, -0.13474387f, 0.11183078f, 
    0.24961551f, 0.03339428f, 0.32790160f, 0.30208430f, -1.22035623f, 0.28587085f, -0.12347883f, 0.10072101f, 
    -0.04908748f, 0.32486394f, -0.11499520f, -0.08301113f, -0.00478315f, 0.16922213f, 0.06849974f, 0.09069508f, 
    0.17494020f, -0.06962772f, -0.01950686f, -0.06116730f, 0.04598420f, -0.14845282f, 0.05944478f, 0.13335577f, 
    -0.14747202f, -0.09838443f, -0.58321738f, -0.52933669f, -0.28320792f, 0.32919264f, -0.29426461f, -0.11968386f, 
    0.08145117f, 0.17079924f, -0.26131615f, 0.01047128f, -0.36205527f, -0.04420867f, -0.18305346f, -0.44437402f, 
    -0.04183729f, 0.00281715f, 0.22192983f, 0.00390347f, 0.11346176f, 0.23947884f, -0.08463424f, -0.06820557f, 
    -0.00534714f, 0.03404354f, 0.08569251f, 0.01083724f, -0.23520225f, -0.20840153f, 0.09760966f, 0.35180196f, 
    0.07121313f, -0.14311302f, -0.22377838f, 0.26462236f, 0.05819668f, -0.15994483f, -0.21983397f, -0.15900688f, 
    -0.41513062f, -0.46697447f, -0.25504732f, -0.15518798f, -0.35422841f, -0.24608505f, -0.07041684f, 0.12426165f, 
    -0.06951947f, 0.10914281f, 0.14381720f, 0.10951804f, -0.22743693f, 0.03104460f, 0.01933782f, 0.06606233f, 
    0.10046183f, -0.30799863f, 0.12156856f, 0.09093987f, -0.10257328f, -0.07207722f, 0.02548346f, -0.02453558f, 
    -0.24471505f, -0.17840013f, 0.05027897f, -0.08880460f, -0.22471271f, -0.01643771f, -0.39074633f, -0.16402610f, 
    -0.18028902f, -0.03360168f, -0.16661701f, -0.27960557f, -0.10811941f, -0.76704848f, 0.33526048f, 0.17847320f, 
    -0.01726948f, 0.20968013f, -0.08667048f, 0.12850721f, -0.03986900f, 0.03842758f, 0.19120805f, -0.01751723f, 
    -0.11868235f, 0.38107219f, 0.66956246f, 0.16068728f, -0.17374942f, 0.04299538f, 0.26578230f, 0.06239969f, 
    0.04692995f, -0.13040966f, 0.30793825f, 0.06842700f, -0.08147020f, 0.01547643f, 0.13845587f, -0.46611625f, 
    0.01370965f, -0.15959643f, -0.07820293f, 0.08256441f, -0.05107458f, -0.19099966f, -0.09523753f, -0.28435147f, 
    0.56679487f, 0.49593395f, 0.37288818f, -0.11100147f, -0.10373552f, 0.25185364f, -0.16887689f, 0.00238706f, 
    -0.10535838f, -0.06063452f, 0.00022074f, -0.09866025f, 0.28258288f, -0.15353167f, 0.33127883f, -0.20886287f, 
    -0.06926218f, -0.22270188f, 0.00693004f, 0.04223885f, -0.03818922f, -0.05554914f, -0.39414486f, -0.28452823f, 
    -0.28467762f, 0.50494349f, 0.31533390f, -0.05139391f, 0.08064154f, 0.28126326f, -0.00998073f, -0.18725137f, 
    -0.27786714f, 0.10375416f, 0.09210905f, 0.21573895f, -0.27466002f, -0.31174284f, -0.48931715f, 0.16481778f, 
    -0.02257729f, 0.08075603f, -0.15718509f, -0.07613847f, 0.11785316f, 0.18560141f, 0.03708183f, 0.14592624f, 
    -0.14188492f, 0.08955769f, 0.02315002f, 0.02261451f, -0.04300313f, 0.05102049f, 0.26988420f, -0.17453921f, 
    -0.05610638f, 0.03051928f, 0.03347581f, 0.17885876f, -0.15753813f, 0.18250330f, 0.13172403f, -0.08234143f, 
    0.01832611f, -0.20148061f, 0.00036823f, -0.11599474f, 0.07787556f, -0.20793772f, 0.08161479f, -0.02225268f, 
    -0.82603985f, 0.80179584f, 0.24410449f, -0.00760546f, -0.06553845f, 0.08940867f, -0.07252927f, 0.32151809f, 
    0.03871892f, -0.13004497f, 0.22815636f, 0.09618687f, -0.46237239f, 0.00959642f, 0.29738152f, 0.09912954f, 
    -0.26781240f, -0.07765175f, -0.21328568f, 0.24278717f, 0.18436973f, -0.21792409f, 0.25157014f, 0.08073611f, 
    0.41978967f, -0.07974957f, 0.47086650f, -0.24281970f, -0.15317111f, 0.01007580f, -0.03839869f, -0.01506537f, 
    -0.12005076f, 0.04381049f, -0.15020385f, 0.02911365f, -0.39210019f, 0.27186880f, -0.34760058f, 0.24048239f, 
    0.07938951f, 0.01715671f, -0.03042773f, -0.09748778f, 0.14043312f, -0.17621364f, 0.03014210f, 0.14711064f, 
    -0.28535122f, -0.10758685f, -0.07655995f, 0.17229815f, -0.09278131f, -0.05619966f, 0.14525151f, 0.03285932f, 
    -0.11554505f, -0.09828561f, 0.08270095f, 0.01275186f, -0.18868586f, 0.56290925f, -0.04239971f, -0.07869357f, 
    -0.00448988f, -0.04803814f, 0.08644956f, 0.12913133f, -0.22186853f, 0.19463971f, -0.17513166f, -0.27247441f, 
    -0.54095811f, 0.45996079f, -0.12830865f, 0.13270025f, -0.06161990f, 0.12745921f, -0.32979310f, -0.07210903f, 
    0.04800304f, -0.01033712f, 0.13928393f, -0.06734977f, 0.00941305f, -0.22318967f, 0.04243876f, -0.08681347f, 
    -0.11636903f, 0.10940512f, 0.18041126f, 0.07369192f, 0.01123859f, 0.09500594f, 0.03273974f, 0.00757417f, 
    0.06152228f, 0.14818920f, 0.22032492f, -0.18562491f, -0.12404087f, 0.02949080f, 0.16934067f, -0.05244460f, 
    0.06846569f, 0.04599779f, 0.22852668f, 0.13557944f, 0.19224408f, 0.02012000f, -0.10137337f, -0.07048167f, 
    -0.12195860f, -0.04361087f, 0.05766097f, -0.07925447f, -0.07628586f, -0.04309733f, -0.14207003f, -0.19374490f, 
    -0.18265317f, -0.02427024f, 0.17818071f, -0.05489534f, -0.08245637f, 0.04692664f, 0.15132028f, -0.01673514f, 
    -0.16041684f, -0.08564445f, 0.15402976f, 0.07340851f, -0.24279515f, 0.19492789f, 0.01569430f, -0.25651008f, 
    0.05061943f, -0.01640769f, -0.12909445f, -0.01391821f, 0.03758381f, -0.18131363f, -0.27155167f, -0.23170647f, 
    -0.11733689f, -0.12744901f, 0.04894599f, 0.04463176f, -0.10333908f, 0.30187446f, -0.01514527f, -0.20195857f, 
    -0.04848653f, -0.01814100f, 0.09472329f, -0.09599270f, -0.05971303f, 0.21086952f, -0.08960175f, -0.06226244f, 
    -0.07241140f, -0.06801072f, 0.09590056f, -0.08030840f, -0.03393872f, -0.08364504f, 0.06573455f, 0.12956618f, 
    -0.13338345f, -0.09857630f, -0.34516478f, -0.22510485f, 0.10138767f, 0.06966507f, -0.21726353f, 0.14407764f, 
    -0.29535219f, -0.31219244f, -0.14368224f, -0.33210531f, 0.19051096f, -0.00155112f, -0.32040679f, 0.12791044f, 
    0.27382794f, -0.33291343f, 0.16444333f, -0.03741484f, -0.14849031f, 0.09053780f, 0.07492042f, -0.04577636f, 
    -0.04012360f, -0.31168485f, -0.10075871f, -0.25122711f, 0.00144722f, 0.02937114f, -0.06519602f, 0.15005654f, 
    -0.02686065f, -0.00335550f, 0.06844770f, 0.09740911f, -0.54512447f, -0.05480277f, -0.32880428f, 0.17413062f, 
    0.25178787f, 0.10893765f, 0.23519196f, -0.12367779f, -0.09176098f, 0.13164622f, 0.32636821f, 0.10440856f, 
    0.36366871f, 0.05956401f, -0.15486842f, 0.09364035f, 0.00793560f, -0.01088308f, -0.09039284f, 0.11002979f, 
    -0.15917228f, -0.12164246f, -0.13100497f, -0.04135966f, -0.45353934f, -0.33596969f, 0.20548812f, -0.08882360f, 
    -0.14899366f, -0.00447387f, 0.11519384f, -0.02610510f, -0.02180791f, 0.23110858f, 0.07562819f, -0.05282876f, 
    0.66926044f, 0.35990047f, 0.42400512f, -0.22830175f, -0.18074383f, 0.14485164f, -0.24506766f, 0.25556192f, 
    -0.10171215f, 0.06600855f, -0.02154588f, -0.11024132f, -0.09316693f, 0.17669687f, -0.40653160f, 0.11913398f, 
    -0.13535956f, -0.33529979f, 0.13171922f, -0.00517336f, 0.07719674f, 0.07581072f, -0.06382983f, -0.06079728f, 
    -0.07213373f, 0.13654760f, -0.13323262f, -0.13668729f, -0.04737733f, -0.15358295f, 0.18974562f, 0.10838930f, 
    0.04806972f, 0.03127051f, -0.08753653f, -0.01195634f, -0.12384512f, -0.40906888f, 0.42728004f, -0.15466301f, 
    -0.06038741f, -0.26769719f, -0.28110188f, -0.09996738f, 0.05823489f, 0.09009873f, -0.06415550f, -0.04783654f, 
    0.05498874f, -0.15331714f, -0.01448647f, 0.09183042f, 0.06090681f, 0.23973809f, -0.04620540f, 0.22717044f, 
    -0.05470284f, 0.05699977f, 0.29663479f, -0.45389956f, 0.25422528f, -0.04416143f, 0.30465716f, -0.01383998f, 
    0.06977621f, 0.03907598f, 0.07047775f, -0.07113367f, 0.14291346f, 0.08928588f, 0.18512735f, 0.08080982f, 
    -0.53892779f, -0.43220517f, 0.43990496f, 0.03959530f, 0.27105436f, -0.05488943f, 0.15836005f, -0.04771487f, 
    0.11772357f, 0.17485242f, 0.17341094f, 0.09984286f, -0.00501162f, -0.01569803f, 0.05832619f, -0.23167628f, 
    0.10892204f, 0.07161506f, 0.02839320f, 0.04974443f, 0.08896938f, 0.08532705f, 0.08147781f, -0.07915289f, 
    0.24122079f, 0.08473548f, 0.31681743f, -0.08398113f, 0.17159128f, 0.00396880f, -0.03592193f, 0.03010205f, 
    0.27406135f, -0.15071434f, -0.02223878f, 0.09138523f, -0.11512991f, -0.45056051f, 0.01751697f, -0.17262897f, 
    -0.23426780f, -0.08640395f, -0.22221629f, -0.26875788f, 0.05459650f, 0.03683227f, 0.00230963f, 0.02789034f, 
    0.25962788f, -0.36971155f, 0.46655604f, 0.05100944f, 0.22539380f, 0.05873493f, -0.08542001f, 0.13780122f, 
    -0.13024610f, -0.01308991f, -0.04949154f, 0.02743027f, -0.41200072f, -0.16248779f, -0.12156818f, 0.02131836f, 
    -0.09765836f, 0.04885831f, -0.09876039f, 0.03722049f, -0.29954794f, -0.05266853f, 0.08382554f, -0.06714865f, 
    -0.21918581f, 0.20367536f, -0.33966279f, 0.32212159f, -0.11012450f, 0.21153325f, -0.06103136f, 0.15994562f, 
    -0.16321394f, -0.06398683f, -0.01903451f, 0.12343568f, 0.21272157f, -0.10788313f, 0.41786733f, -0.26988140f, 
    -0.01518701f, -0.08146147f, 0.05311389f, 0.00059132f, -0.02267537f, 0.01221075f, -0.02047245f, -0.01371275f, 
    -0.13946062f, 0.12705964f, -0.10085881f, -0.15870549f, 0.01148643f, 0.15004720f, 0.11094989f, 0.04482353f, 
    -0.03961863f, 0.26883081f, 0.13441555f, -0.09022339f, -0.51287460f, -0.27227730f, -0.49081397f, 0.36844042f, 
    0.07693318f, -0.16583286f, 0.09405664f, -0.03669120f, 0.03086313f, -0.04611850f, 0.15420578f, -0.18661843f, 
    -0.22028856f, 0.55026042f, -0.53432387f, 0.06591143f, -0.23164409f, 0.07130327f, 0.23890391f, -0.00335011f, 
    -0.02758982f, 0.07919008f, -0.05067585f, -0.04836585f, -0.04451266f, -0.04845284f, -0.06703018f, 0.48374966f, 
    0.17550799f, -0.12304600f, 0.03624399f, 0.06184985f, 0.02951930f, -0.07695550f, -0.17192833f, 0.02359709f, 
    0.12311907f, -0.25498310f, -0.05460577f, 0.19663650f, -0.03622220f, 0.20078848f, 0.10679808f, 0.14191093f, 
    0.15325421f, -0.13389991f, -0.03351412f, 0.02438428f, 0.16636704f, 0.25497562f, 0.10722774f, 0.03158392f, 
    0.05948906f, -0.07633945f, -0.13089010f, 0.04071707f, -0.11062768f, 0.14925309f, 0.04826219f, -0.03272267f, 
    -0.10836029f, -0.39913774f, -0.23892692f, -0.06606210f, 0.11524435f, -0.01234362f, -0.13077220f, 0.17641093f, 
    0.00015721f, 0.03003163f, 0.05701467f, -0.17827688f, -0.27326509f, 0.09621256f, -0.32845807f, -0.74822605f, 
    0.17783728f, -0.41264108f, 0.03963560f, 0.07885414f, 0.02130495f, 0.12536104f, 0.03484177f, -0.00872446f, 
    0.05898347f, 0.18834619f, 0.03447254f, 0.08069387f, -0.05553496f, 0.01656371f, 0.04008519f, -0.01465248f, 
    -0.12365161f, -0.14497101f, -0.17254874f, 0.00884190f, -0.08459285f, 0.03571291f, -0.33923438f, -0.01770524f, 
    0.10796332f, -0.14153354f, 0.02054492f, 0.00123809f, -0.06807481f, 0.01149530f, -0.03737029f, 0.00605102f, 
    -0.59593505f, 0.38379857f, 0.09687889f, 0.45928162f, -0.13624308f, -0.26162887f, 0.27034229f, -0.06826819f, 
    -0.05205542f, -0.03810952f, 0.14912750f, -0.19559775f, 0.21233734f, 0.02525675f, 0.21383224f, 0.11738750f, 
    -0.11419415f, 0.09116358f, -0.08008705f, 0.09534097f, -0.18462831f, 0.02196738f, 0.04597586f, -0.06182801f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.23393235f, 0.11526594f, 0.06646205f, -0.08720511f, -0.07623841f, 0.02354403f, -0.00089649f, -0.16609591f, 
    0.10670707f, 0.02943142f, 0.07579017f, -0.07366956f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
