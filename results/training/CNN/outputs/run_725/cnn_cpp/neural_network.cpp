#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.65943146f, 0.02317817f, 0.64938486f, 0.77118582f, -1.03610134f, 0.54104060f, 0.03068176f, 0.18250337f, 
    -0.57295763f, 0.81887686f, -0.09420479f, 1.15657997f, -1.01543641f, -0.19109879f, -0.65437031f, -0.08594117f, 
    0.44734398f, 0.12335919f, -1.05596161f, 0.17866747f, -0.63671547f, 0.77877861f, 0.46970606f, 0.47718698f, 
    0.05033086f, 0.14748222f, -0.41881448f, -0.33746335f, -0.72315395f, -0.68286115f, 0.35169670f, -0.59589249f, 
    0.61725926f, -0.13208210f, 0.03593120f, -0.10346934f, 0.85899663f, 0.01356260f, -0.38537261f, -0.56665093f, 
    0.71356165f, -0.31399530f, 0.00987967f, 0.60886973f, -0.49428236f, -0.69507533f, -0.91894162f, -0.74440747f, 
    0.26039290f, 0.50595379f, 0.54923648f, 0.59590095f, -0.18138607f, 0.22988041f, -0.68835086f, -1.14445722f, 
    0.46335247f, 0.66284668f, 0.52918935f, 0.27111048f, -0.26337668f, -0.09184414f, -0.25079769f, 0.87040323f, 
    -0.90590090f, -0.34427503f, 0.02142208f, -0.64686501f, -0.47169575f, -0.18609969f, 0.49899232f, -0.02915987f, 
    0.78790420f, -1.05277240f, 0.21892698f, 0.53769821f, 0.04071026f, 0.39383525f, -0.04138385f, 0.41207927f, 
    -0.30227789f, 0.89448822f, -0.85494441f, 0.54723811f, -0.09645057f, 0.08957039f, 0.51714486f, 0.15788808f, 
    0.09158283f, -0.54250342f, 0.95255309f, -1.06787074f, 0.39823061f, -0.82374156f, 0.59000808f, 0.32353923f, 
    0.09223324f, 0.08901798f, 0.05194709f, 0.76979220f, -1.02628362f, -0.22352554f, 0.80320901f, -0.21560271f, 
    -0.55768991f, -0.21313916f, -0.22635759f, -0.42420942f, 0.68931109f, 0.85540658f, -0.61569893f, 0.62708908f, 
    0.25551003f, -0.06338678f, 0.08537728f, 0.09823049f, -0.31490225f, 0.22592060f, 0.92561769f, -0.11961851f, 
    0.62032253f, -0.44252485f, -0.82892048f, 0.45796108f, 0.14207403f, 0.27070406f, -0.87866318f, -0.50189155f, 
    0.34240851f, -0.38303763f, 0.03957772f, 0.66723341f, 0.04141412f, -0.46641076f, 0.50327110f, 0.42479953f, 
    -0.87212306f, -0.35474727f, 0.39659825f, 0.75162005f, 0.68317801f, -0.30778107f, 0.43300629f, -0.23423083f, 
    0.77875412f, 0.96965885f, -0.50828958f, 0.69882470f, -0.32440719f, -0.63336951f, 0.00697815f, -0.23823397f, 
    -0.21973982f, 0.89443827f, 0.49759084f, 0.81850547f, 0.15637955f, -0.69505459f, 0.01262156f, 0.04804256f, 
    -0.09184834f, 0.12432515f, -0.12866282f, -0.78447717f, -0.82348746f, 0.52801180f, -0.58333802f, -0.50319922f, 
    -0.52336234f, -0.27235350f, -0.15376846f, -1.32946622f, 0.92262810f, 0.33859086f, -0.41979247f, 0.99315721f, 
    -0.21677327f, -0.26435089f, 0.22407131f, 0.28673869f, 0.20565391f, -0.51836747f, -0.45736063f, 0.35172778f, 
    0.87664026f, -0.24243277f, -0.36128974f, -0.44147798f, -0.29172134f, 0.69960177f, 1.24745178f, 0.14877091f, 
    -0.66526425f, 0.07747836f, 0.51899385f, 0.41065860f, -0.37061942f, -0.48489389f, -0.30915073f, -0.59895355f, 
    -0.31353772f, -0.46761733f, -0.49163467f, 0.81307381f, 0.25550696f, 0.05619117f, 0.54528707f, -1.10927546f, 
    0.16989367f, -0.50647432f, 0.02579219f, 0.83676583f, -0.58067960f, -0.25610068f, 0.05484661f, 0.27673286f, 
    1.15021980f, -0.62273985f, -0.31150812f, -0.12567781f, -0.58237153f, -0.32040334f, -0.00248734f, -0.47678718f, 
    0.23756284f, -0.47991148f, -0.54472250f, -0.82200789f, 0.46727347f, 0.71454489f, 0.51224095f, -0.27777657f, 
    0.00132890f, -0.15355718f, -0.37059975f, -0.68091214f, 0.42111650f, -0.48747805f, 1.02214956f, 0.44434223f, 
    -0.05070572f, -0.15815338f, -0.00301755f, 0.69786114f, 0.26062265f, -0.81916040f, -0.94157654f, -0.43095222f, 
    -0.36423156f, 0.40903127f, 0.10643031f, 0.35015222f, 0.46182409f, 0.89293194f, -0.70861793f, -0.71352750f, 
    0.54332840f, 0.89076853f, 0.35790738f, 0.39856410f, 0.04140181f, 0.65349656f, 0.21629286f, 0.43281862f, 
    0.72031271f, 0.70830488f, -0.63647223f, 0.18460104f, -0.50311297f, -0.18027408f, 0.58580869f, 0.45844910f, 
    0.00909185f, 0.38964948f, -0.96072018f, -0.78715688f, -0.21935639f, 0.76947576f, 0.26651120f, 0.73107356f, 
    0.70350343f, 0.85335505f, 0.60921836f, 0.52049798f, 0.31266400f, 0.10648227f, 0.75715184f, 0.05327645f, 
    0.00774970f, 0.96633524f, -0.62162644f, 0.47669080f, 0.63882548f, -0.79959041f, 0.28120285f, 0.29513010f, 
    0.34808695f, 0.87543905f, 0.74510711f, 0.56553727f, -0.17338014f, -0.59815753f, 0.18834028f, 0.14884803f, 
    -0.27025849f, 0.22928816f, 0.99140751f, 0.15014002f, -0.34933966f, -0.32734299f, 0.08958770f, 0.92849141f, 
    -0.50482172f, -0.59313607f, 0.37368423f, 0.01668690f, -0.34512842f, 0.01233478f, -0.18374459f, 0.00787787f, 
    0.47793344f, 0.57796270f, 0.60596097f, -0.07520533f, 0.34582257f, -0.31435511f, 1.03642154f, -0.44368869f, 
    -0.95493442f, -0.74570853f, 0.54127145f, 0.20000896f, 0.22624296f, -0.78647381f, 0.19531249f, 0.60841984f, 
    -0.92244065f, -0.30414078f, -0.48563999f, 0.41307011f, -0.17383358f, -0.45272318f, 0.39940527f, -0.74826968f, 
    0.37563565f, -0.71368587f, 0.49204332f, -0.20687790f, 0.61336547f, -0.43893504f, 0.42402869f, -0.77633655f, 
    -0.95386791f, -0.72226948f, -0.02674205f, -0.48397216f, 0.03349072f, -0.05933353f, 0.30186808f, -0.31172353f, 
    -0.64868224f, -0.90210170f, -0.78560013f, -0.58512408f, 0.60245347f, 0.40068242f, 0.17832355f, 0.07233568f, 
    0.26071799f, -0.02107731f, -0.58343166f, -0.67315871f, -0.66950464f, -0.52203780f, -0.72986799f, -0.59489393f, 
    0.11184834f, 0.27634528f, 0.69711041f, 0.61823326f, 0.82500541f, 0.50533116f, 0.11132732f, 0.38800699f, 
    0.01817401f, -0.37463364f, -0.02511415f, -0.17263548f, -0.60348427f, 0.91094071f, -1.04161024f, 0.25930667f, 
    0.08410349f, 0.07369153f, -0.06603837f, -0.07158974f, 0.96610230f, -0.03552159f, -0.98069608f, 0.26828852f, 
    0.17394203f, 0.29292291f, 0.24444452f, 0.03949098f, 0.08294189f, -0.27085534f, -0.13072500f, -0.92094481f, 
    0.19866395f, -0.39137971f, -0.83686399f, -0.26010761f, -0.53902167f, 0.67744744f, 0.62464809f, -0.23355959f, 
    -0.42595619f, 0.74181980f, 0.44269231f, 0.47697112f, -0.25563422f, -0.56746936f, 0.52066523f, 0.28061283f, 
    0.04554605f, 0.00957328f, 0.25563443f, 0.36125219f, 0.01407904f, 0.40830803f, 0.54143888f, 0.21522176f, 
    -0.48778331f, -0.63985157f, 0.17045812f, -0.34018424f, 0.81646401f, -0.75016326f, -0.06515599f, 0.20141199f, 
    -0.25781822f, 0.09772605f, 0.76329970f, 0.81337333f, -0.99345732f, 0.62413758f, 0.25315979f, 0.18408665f, 
    0.53246951f, -0.50677246f, -0.45872968f, 1.07297432f, -0.27057150f, 0.57294911f, 0.79855710f, 0.48935559f, 
    -0.41468018f, -0.29693949f, 0.22231254f, -0.81502688f, 0.28881440f, 0.13927430f, 0.13129567f, 0.70922464f, 
    0.47020623f, -0.26767215f, 0.41826826f, 0.45206469f, 1.01514220f, 0.83114606f, -0.74653935f, 0.17905663f, 
    0.30725113f, -0.55174345f, 0.29964334f, 0.14690125f, 0.26855832f, 0.69527864f, 1.06523943f, 0.14030360f, 
    -0.72837174f, 0.27769005f, 0.08526211f, -0.13185887f, 0.45742971f, -0.25548998f, -0.53865093f, -0.36636591f, 
    0.10279904f, 0.70004243f, -0.44803894f, -0.77636492f, 0.45697159f, 0.31882071f, 0.60241991f, 0.60062701f, 
    0.85636610f, 0.49711481f, -0.47942293f, 0.52022767f, -0.16180322f, -0.38803828f, 0.05918793f, -0.45267233f, 
    -1.04489231f, 1.14640033f, 1.02758515f, 0.78579473f, -0.17728226f, -0.38701078f, -0.40128961f, -0.33721352f, 
    -0.28903252f, -0.68740398f, -0.69186431f, -0.46653032f, 0.45064074f, -0.14756979f, -0.49384630f, -0.46142697f, 
    -0.18954806f, 0.11032685f, 0.93736506f, 0.02209730f, -0.20662414f, 0.41234756f, 0.49089298f, -0.55440086f, 
    -0.42401853f, -0.30561095f, -0.12888011f, 0.16377850f, -0.50062466f, 0.34101072f, -0.46801481f, -0.86647445f, 
    -0.54062515f, 0.35401356f, -0.49202678f, -0.10862671f, -0.34947231f, -0.42770427f, -0.00686512f, -0.71120918f, 
    -0.82441741f, 0.05271231f, -0.43501726f, 0.10096226f, -0.30565163f, -0.44251817f, -1.07167578f, -0.30568093f, 
    -0.36169243f, 0.61147952f, 0.88453937f, -0.06091331f, -0.41354874f, -0.60280955f, -1.05591428f, 0.66844594f, 
    0.79991567f, 0.18868853f, 0.57027864f, 0.46264270f, 0.31126952f, 0.03752645f, 0.11527245f, -0.46102774f, 
    -1.08127630f, -0.01107537f, 0.91167951f, 0.15664817f, 0.21078391f, -0.00802640f, -0.46573734f, 0.19583732f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02065905f, -0.05663882f, -0.03594572f, 0.24800825f, 0.03811903f, 0.04991983f, -0.04548251f, 0.03346721f, 
    0.24497537f, -0.03023583f, -0.12855388f, 0.34216931f, 0.08657579f, -0.19863641f, 0.17731439f, 0.10322317f, 
    -0.19419858f, 0.24168290f, 0.25725475f, 0.18212047f, 0.04974202f, 0.05114450f, 0.12613669f, -0.01737490f, 
    0.00398816f, 0.08006682f, 0.08430539f, 0.25055462f, 0.08022527f, 0.10253182f, -0.15033089f, 0.09063828f, 
    0.12709664f, 0.18072364f, 0.10324667f, 0.28246042f, 0.15335359f, 0.15716451f, -0.16011295f, 0.14358461f, 
    0.28578708f, -0.14650546f, 0.43467030f, -0.02878899f, 0.31011972f, -0.02635537f, 0.06589659f, 0.28154534f, 
    0.29604656f, -0.00282685f, 0.09895984f, 0.26887739f, -0.14480814f, 0.34720278f, 0.16423552f, 0.09687303f, 
    0.01820115f, -0.02466543f, 0.10206258f, 0.04661328f, 0.01468020f, 0.07561903f, 0.24279131f, 0.06538805f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18798034f, -0.28754592f, 0.10379890f, -0.01816500f, -0.17665045f, -0.12659539f, 0.08051284f, 0.03148237f, 
    -0.04108946f, 0.11448263f, -0.09780300f, -0.09242618f, -0.00297357f, 0.01621685f, -0.08228919f, -0.02684297f, 
    -0.02880519f, -0.05331692f, -0.01621497f, 0.01508207f, 0.26881626f, -0.00652846f, 0.00821581f, 0.06926191f, 
    -0.15821031f, -0.08747611f, -0.03999001f, -0.02943258f, 0.09792994f, -0.01756765f, -0.06890947f, 0.01842613f, 
    -0.00034409f, 0.03005666f, -0.03139951f, -0.08795378f, -0.02300630f, 0.03023665f, 0.05115234f, -0.03149455f, 
    0.30201489f, 0.07485925f, 0.08683565f, -0.16066416f, -0.22848383f, 0.10022733f, 0.01885641f, -0.04715699f, 
    0.06256078f, -0.02949378f, 0.02669511f, -0.10519341f, -0.11293145f, -0.02732060f, 0.04285875f, 0.02476948f, 
    0.09477922f, -0.02701152f, 0.08357555f, -0.04704308f, 0.16221133f, -0.12653300f, -0.07400341f, -0.07556845f, 
    -0.25682130f, -0.03525236f, 0.08885778f, -0.01726320f, 0.02402005f, -0.02617625f, 0.05632941f, -0.03264475f, 
    0.01817409f, 0.02247166f, -0.09110748f, 0.04718003f, -0.10332660f, 0.05248965f, -0.05325104f, -0.02332972f, 
    -0.05797330f, 0.00557840f, 0.05349804f, 0.06311668f, 0.14658880f, -0.09707054f, -0.00801342f, -0.08607820f, 
    -0.01394231f, 0.08606502f, -0.01483143f, 0.03698603f, 0.09193660f, -0.07249603f, 0.03512002f, -0.06094959f, 
    0.00696439f, -0.00183308f, 0.06328186f, -0.09837601f, -0.08339357f, 0.09682540f, -0.04687693f, -0.10948954f, 
    -0.19618739f, 0.06466900f, 0.08827404f, -0.07886089f, 0.04136097f, 0.02866676f, -0.00230387f, 0.04428541f, 
    -0.03651252f, 0.04188805f, 0.01561377f, 0.08241797f, 0.06492511f, -0.04296501f, 0.07824339f, -0.02858846f, 
    -0.28030193f, 0.23901995f, 0.34660658f, 0.03237231f, -0.41748372f, 0.12812275f, 0.04663965f, 0.06973866f, 
    0.07840645f, 0.01199275f, 0.00624354f, 0.02963763f, 0.00164044f, -0.04025972f, -0.01805801f, 0.04413335f, 
    0.08576627f, -0.05474269f, -0.00903797f, -0.00047187f, 0.04387004f, -0.51395011f, 0.24570371f, 0.00034699f, 
    -0.18863770f, -0.01066051f, -0.00865953f, 0.06638516f, 0.00577312f, 0.03309788f, -0.09276485f, 0.05683224f, 
    -0.00528178f, 0.03832288f, 0.05636342f, -0.02320933f, -0.02067276f, -0.01725453f, 0.14023060f, -0.06158888f, 
    0.18848479f, -0.07947537f, -0.00562672f, -0.06109664f, -0.19852471f, -0.00406085f, -0.01035397f, -0.04418673f, 
    0.00876988f, -0.03435478f, -0.03807994f, 0.08241774f, 0.02051657f, -0.04259256f, 0.02833964f, -0.02435313f, 
    -0.00370752f, -0.02989070f, -0.03938767f, -0.00691187f, 0.21652621f, -0.04496444f, -0.05939716f, 0.04787345f, 
    -0.19327918f, -0.13864660f, 0.00672690f, -0.03354472f, 0.00221795f, -0.01216421f, -0.06030366f, 0.04969177f, 
    -0.03064032f, -0.03009357f, -0.02456898f, -0.05099209f, -0.07793765f, 0.00086284f, 0.01477505f, 0.06295703f, 
    0.17393780f, -0.04927601f, -0.01939845f, 0.05945872f, -0.28502664f, -0.13483112f, -0.03029130f, 0.01036766f, 
    0.01446127f, -0.01053073f, 0.02659793f, 0.02388857f, 0.04310793f, -0.02418956f, -0.01510795f, -0.01973347f, 
    -0.14707060f, -0.00385939f, -0.01385131f, 0.07955040f, 0.06034452f, -0.17185630f, 0.15827346f, 0.12156254f, 
    -0.05049788f, 0.05162817f, -0.03033957f, -0.02116833f, -0.05318826f, -0.05570922f, -0.07278617f, -0.00555673f, 
    0.02311541f, 0.00299270f, 0.03527059f, -0.01159889f, 0.07474153f, -0.00444783f, -0.07673285f, 0.01160974f, 
    0.13717264f, -0.01742447f, 0.07993905f, -0.07356403f, 0.29407355f, -0.17487840f, 0.02077379f, 0.05761844f, 
    0.12990698f, -0.06628386f, 0.01102966f, 0.03938608f, -0.08264084f, -0.01344081f, -0.01037808f, 0.00337383f, 
    0.01078236f, 0.03840489f, -0.05044206f, 0.03739063f, 0.03056744f, 0.05132386f, 0.01434753f, -0.04969072f, 
    0.11345977f, -0.13030484f, 0.01750442f, 0.10007852f, -0.05096613f, -0.06109200f, -0.02416764f, 0.02136493f, 
    -0.01156056f, 0.05060189f, 0.01163524f, 0.07948082f, 0.00517788f, 0.11273525f, -0.07085467f, -0.10783565f, 
    -0.19905424f, 0.08392908f, -0.03529733f, 0.11022269f, -0.08619667f, -0.02429412f, 0.00632758f, -0.05556694f, 
    0.03356646f, -0.02515549f, 0.00683525f, -0.02224013f, 0.00073554f, 0.00218331f, 0.01009012f, -0.04825982f, 
    -0.01131826f, -0.03242224f, 0.07549087f, 0.05053471f, 0.11349402f, 0.10724507f, -0.12330715f, -0.14859268f, 
    -0.04744793f, 0.00217986f, -0.01886329f, -0.00887203f, -0.04715931f, -0.00896454f, -0.00667056f, 0.00719429f, 
    0.04903194f, 0.01793043f, -0.01467248f, 0.06005554f, 0.04618635f, 0.01108009f, -0.04697963f, 0.07845389f, 
    0.20543742f, -0.00677901f, 0.10280553f, -0.00367891f, 0.24364878f, -0.13658977f, 0.01321222f, 0.01492432f, 
    0.03991380f, -0.04199644f, 0.06314760f, 0.04995431f, -0.03309651f, 0.00487608f, -0.11505532f, 0.13453756f, 
    0.05949039f, 0.04468594f, -0.07313658f, -0.01308493f, 0.12485825f, -0.01614275f, 0.01982154f, -0.13668928f, 
    -0.00972048f, -0.12757029f, -0.16593920f, -0.06858536f, -0.00374245f, 0.00093707f, -0.04043709f, -0.06815470f, 
    -0.03017609f, -0.03381021f, -0.03706899f, 0.06474310f, -0.00898728f, -0.01417697f, 0.04646361f, 0.07793172f, 
    0.11387102f, -0.23588800f, 0.00064088f, 0.12446722f, -0.12151736f, 0.08274367f, 0.00142926f, 0.04383266f, 
    0.01014370f, -0.05556994f, 0.00038851f, -0.02764880f, 0.00840700f, 0.10251401f, 0.02224462f, 0.02011290f, 
    -0.00578473f, 0.01709083f, -0.12690745f, -0.03366291f, 0.26885867f, -0.00605692f, 0.19211757f, -0.13575509f, 
    0.05687758f, -0.00646765f, 0.01449063f, -0.00494350f, -0.01061816f, -0.02348448f, 0.00989053f, -0.01288325f, 
    -0.01272099f, -0.01804431f, 0.03097837f, 0.04842704f, -0.08450518f, 0.06591973f, 0.03286862f, -0.05855960f, 
    -0.06081095f, 0.12472288f, 0.12601994f, 0.04335916f, 0.03744943f, 0.00557101f, 0.03381077f, 0.04552760f, 
    -0.07024994f, -0.04346714f, 0.09917562f, 0.07611626f, 0.06343409f, -0.02029399f, -0.00458617f, 0.02030218f, 
    0.04888957f, 0.04039845f, -0.06401182f, 0.03289555f, 0.11671377f, 0.12463690f, 0.12720907f, -0.26200053f, 
    0.31985700f, -0.23770982f, -0.07989527f, 0.00367619f, 0.01607985f, 0.01789752f, -0.07156745f, 0.03296768f, 
    0.02047979f, -0.07854540f, 0.10469745f, -0.05294195f, 0.03582091f, -0.06767630f, -0.01481850f, -0.00955215f, 
    -0.21814589f, -0.14667380f, -0.12079280f, 0.07064159f, -0.07361395f, 0.04442193f, 0.00325426f, -0.09262739f, 
    -0.00566340f, 0.00305440f, 0.02482140f, 0.05204834f, 0.03290026f, 0.00914450f, 0.03442882f, 0.00561759f, 
    -0.05905639f, 0.09389912f, -0.01926184f, -0.05065865f, 0.57723397f, 0.17942391f, 0.07947523f, -0.17971970f, 
    -0.12147113f, 0.05547712f, 0.01552588f, -0.08411773f, 0.01922188f, -0.01717373f, 0.07988784f, 0.02534314f, 
    -0.10593330f, 0.05266630f, 0.03680859f, -0.02886919f, -0.04449422f, 0.06793363f, 0.04873196f, 0.01065563f, 
    0.05864620f, -0.35072571f, 0.24012630f, 0.21715850f, 0.03524770f, 0.02113055f, 0.01146481f, 0.02636043f, 
    0.09651256f, -0.02782998f, -0.09982921f, -0.00403456f, -0.01019026f, -0.02733417f, 0.02967714f, 0.00046330f, 
    -0.01525189f, 0.01949914f, 0.07843762f, -0.04474019f, 0.08241785f, 0.16237968f, 0.01634385f, -0.20962586f, 
    -0.25569379f, 0.08090568f, 0.06100753f, -0.02208092f, 0.08526154f, -0.07681489f, 0.06256539f, -0.01082418f, 
    0.00954281f, 0.02501361f, -0.00232152f, -0.00647615f, 0.05990332f, 0.00445736f, 0.00575892f, 0.02028515f, 
    -0.18559298f, 0.11696294f, 0.07016135f, 0.02172953f, -0.16536513f, -0.02269637f, -0.00553268f, 0.03250857f, 
    -0.02335387f, -0.05032106f, 0.04041653f, -0.02732332f, -0.04205539f, 0.01969424f, -0.01027034f, -0.02573743f, 
    -0.04318645f, -0.02104952f, 0.04650659f, -0.01515380f, -0.15530148f, -0.07998782f, 0.06007611f, 0.09120756f, 
    0.09155209f, -0.01402080f, 0.00317053f, 0.00573573f, 0.03492577f, 0.03570015f, 0.03552520f, -0.09949756f, 
    0.04124371f, -0.04131676f, -0.01421190f, -0.01417169f, -0.03129064f, -0.02863466f, 0.01679065f, -0.01284218f, 
    -0.35226610f, 0.05487192f, -0.01662298f, -0.12600274f, 0.17442964f, -0.02756590f, -0.08086190f, -0.08285493f, 
    -0.02264490f, -0.00081430f, 0.02936870f, -0.03335444f, 0.07436933f, 0.05337173f, 0.07083946f, -0.08675911f, 
    -0.00055976f, -0.05924037f, -0.06743240f, -0.05632286f, 0.08705416f, 0.01377841f, 0.11477702f, 0.00877117f, 
    0.09678828f, -0.15732542f, -0.08602162f, 0.04568595f, 0.04317383f, -0.03577833f, 0.05203437f, 0.03011117f, 
    -0.15036111f, 0.04054090f, -0.09726527f, 0.00868031f, -0.05952441f, 0.02043515f, -0.04924387f, 0.00485942f, 
    0.10878798f, -0.18070768f, 0.22817981f, -0.21348064f, 0.11546615f, -0.07605658f, -0.08956128f, -0.00819943f, 
    -0.03966805f, 0.00312682f, -0.11164322f, 0.00003609f, 0.03287689f, 0.00771433f, -0.05772256f, 0.00005630f, 
    0.04777827f, 0.01841668f, -0.01235191f, 0.02005587f, 0.00831678f, -0.03997235f, -0.05607505f, -0.02175739f, 
    0.09665693f, -0.03481100f, -0.07502603f, -0.04325332f, 0.01929687f, -0.01057059f, -0.03727525f, 0.01370373f, 
    0.01546552f, 0.05262397f, -0.03164804f, -0.06506467f, -0.04311543f, -0.05113588f, -0.03757327f, 0.01716333f, 
    0.20729044f, -0.04367258f, -0.08212634f, -0.14501655f, 0.11416363f, -0.02783817f, 0.00801623f, 0.08142859f, 
    -0.03766936f, 0.03193360f, 0.02232277f, 0.02937499f, -0.00120745f, 0.02153518f, 0.06334250f, -0.00426121f, 
    -0.06629679f, 0.11959196f, -0.02791485f, -0.03741306f, 0.14085697f, 0.08496068f, 0.02850720f, -0.25148082f, 
    0.09429428f, -0.16089982f, -0.19712776f, -0.08583232f, -0.01663629f, 0.02027391f, -0.00202985f, -0.06089283f, 
    0.05480353f, -0.01977546f, -0.03572859f, 0.11944812f, 0.00739303f, -0.02625596f, -0.01959188f, 0.08528740f, 
    -0.02710624f, -0.04354053f, -0.06757789f, 0.08391295f, 0.13629019f, -0.01438319f, 0.04049280f, -0.14338958f, 
    0.04255560f, -0.05688393f, -0.02711448f, -0.02662807f, 0.15112966f, -0.05164520f, 0.04742845f, 0.07465693f, 
    0.08780748f, -0.02915186f, -0.11286725f, 0.02166262f, -0.05263886f, -0.02034791f, -0.16576537f, -0.01984458f, 
    -0.05364015f, -0.02982233f, 0.01688646f, 0.00145814f, -0.04908701f, 0.00014154f, 0.05106352f, 0.01455149f, 
    0.02712605f, 0.04411549f, 0.02315274f, -0.00582112f, -0.04522455f, -0.00626361f, -0.08561815f, -0.02583971f, 
    0.08834853f, -0.06228579f, 0.00561784f, 0.00190138f, -0.10296047f, -0.07629438f, -0.03509505f, -0.04281762f, 
    -0.06711230f, 0.00009654f, -0.00310006f, 0.00667174f, -0.01426415f, -0.08828802f, -0.06828342f, -0.03517749f, 
    -0.00063729f, 0.09716628f, 0.11779197f, -0.04885473f, -0.18248606f, -0.08448853f, -0.16913757f, 0.00346465f, 
    -0.04413643f, -0.06594683f, -0.07697809f, -0.05791058f, 0.01875050f, 0.00498227f, 0.07505281f, 0.12088065f, 
    0.03677187f, 0.01523810f, -0.07435513f, 0.08939374f, -0.02702921f, 0.00416344f, 0.03734994f, -0.04478323f, 
    0.10822820f, -0.00903170f, -0.00714918f, 0.14062275f, -0.21678798f, -0.05827668f, -0.11888544f, 0.06870811f, 
    -0.09455328f, -0.00587274f, 0.01255428f, -0.10465149f, -0.10021055f, 0.03851498f, -0.04912165f, -0.17705232f, 
    -0.09537850f, 0.02422754f, -0.10150890f, -0.04104069f, -0.01359556f, -0.25605586f, -0.17352204f, -0.09937855f, 
    -0.26986858f, -0.01781811f, -0.06213249f, 0.02121557f, 0.04357849f, 0.03171253f, -0.05887574f, -0.15888779f, 
    -0.02897706f, -0.06270825f, 0.01723412f, 0.06756826f, -0.07262491f, 0.02491257f, 0.03431326f, 0.03023893f, 
    -0.23791081f, 0.19889188f, -0.14124697f, -0.06974825f, -0.19289894f, 0.01134298f, -0.05651765f, -0.01670877f, 
    0.04046385f, -0.02047038f, -0.00231546f, 0.01188996f, -0.00134601f, 0.08325411f, 0.03492444f, -0.01285444f, 
    -0.06652514f, 0.00789343f, 0.00301514f, -0.01893276f, -0.11301777f, -0.51910377f, 0.09895079f, 0.10505474f, 
    -0.00128028f, 0.06545252f, 0.00330725f, 0.04549514f, 0.07229155f, 0.02825139f, 0.02450452f, -0.02175470f, 
    -0.07047509f, 0.10902645f, -0.03089032f, -0.07988949f, -0.00235294f, -0.04101687f, 0.02500906f, -0.05496756f, 
    0.07407353f, -0.01849252f, 0.02432045f, -0.01627330f, 0.03781529f, -0.14998037f, -0.18008123f, 0.01566694f, 
    -0.01231270f, -0.01629409f, -0.03369915f, 0.00086530f, -0.03671101f, -0.01170048f, 0.00949015f, -0.00372282f, 
    0.05385336f, 0.00610799f, -0.04805339f, 0.06536499f, 0.18172882f, -0.22484954f, -0.16574824f, 0.17365126f, 
    -0.20060956f, -0.10620441f, 0.08162836f, 0.02946487f, 0.06652004f, -0.05809151f, 0.03792571f, -0.00516978f, 
    0.01584128f, -0.02726079f, 0.01885053f, -0.03426732f, -0.02990215f, 0.04225112f, -0.00673809f, 0.08758980f, 
    -0.05465065f, -0.06887074f, -0.04828612f, -0.05661933f, 0.11742728f, -0.03250761f, -0.00194024f, -0.00434532f, 
    0.05724462f, -0.05457548f, -0.03607879f, -0.00302755f, 0.01383271f, 0.03307275f, -0.02101777f, 0.04341609f, 
    -0.02829962f, 0.04425396f, -0.02584250f, 0.01434157f, 0.00314920f, -0.34787360f, 0.05108415f, 0.06059361f, 
    -0.08515137f, 0.00401945f, -0.00732794f, -0.11260011f, 0.04285588f, -0.01479882f, 0.04223481f, -0.06600356f, 
    0.02666742f, 0.08420172f, -0.08209785f, 0.12821808f, -0.07940958f, -0.03316363f, -0.17835402f, -0.11544199f, 
    -0.02075869f, 0.04703181f, -0.05154826f, 0.01087108f, 0.04821623f, 0.03950335f, 0.06727173f, 0.05054872f, 
    -0.01565851f, -0.08423675f, -0.05484834f, -0.02439172f, -0.01584242f, -0.04869574f, 0.02265272f, 0.06801686f, 
    0.07573807f, -0.01014259f, -0.10896816f, 0.06359947f, -0.13234423f, -0.06816878f, -0.04685054f, -0.02918104f, 
    -0.02783859f, -0.03286297f, -0.06954101f, -0.05939796f, -0.02396639f, -0.02661104f, 0.07778464f, 0.07056087f, 
    0.01148773f, 0.03972702f, 0.03977691f, 0.04589551f, -0.04792618f, -0.01602307f, 0.01772668f, -0.05446200f, 
    -0.08376446f, -0.13342845f, 0.16080697f, 0.00136619f, -0.25964674f, -0.05070281f, -0.00894772f, -0.01563874f, 
    0.06384925f, 0.02068898f, -0.02685788f, 0.07955561f, -0.04598025f, -0.03766595f, -0.07249469f, 0.00964272f, 
    -0.11730746f, 0.01664859f, -0.05544209f, -0.04834306f, -0.04649937f, 0.02946221f, -0.03755545f, 0.00021854f, 
    0.19340344f, -0.05514143f, -0.00162715f, -0.08961893f, -0.05911034f, 0.01305343f, 0.05742786f, -0.04029755f, 
    0.14151186f, -0.01527950f, -0.00264765f, -0.06518506f, -0.03703764f, -0.04313525f, 0.03392524f, -0.08384980f, 
    0.30689782f, 0.05372277f, 0.07039955f, -0.11204223f, 0.14351803f, -0.02444885f, -0.02893605f, 0.03537322f, 
    -0.06912063f, -0.10581473f, 0.06416307f, -0.08699822f, -0.10516552f, 0.03726659f, 0.09009428f, -0.03391064f, 
    0.03336453f, -0.03872124f, -0.03375179f, 0.07626449f, 0.07212501f, 0.08806425f, 0.06785762f, -0.07264397f, 
    -0.00708651f, 0.05951963f, 0.02935702f, 0.01024182f, 0.05953799f, -0.05794103f, 0.07136174f, -0.04642975f, 
    -0.01416295f, -0.00540726f, 0.00569398f, 0.06572698f, -0.01054274f, 0.00366048f, 0.00849841f, 0.02505174f, 
    -0.07855018f, -0.01214210f, 0.04165754f, -0.06275610f, 0.30041361f, -0.10474186f, 0.12424118f, 0.02474300f, 
    0.12591042f, -0.03195836f, 0.02800149f, 0.00895632f, 0.06631643f, 0.03387817f, -0.06014619f, 0.09391737f, 
    -0.06335014f, 0.04868831f, 0.05415999f, -0.02217381f, 0.08435553f, 0.09138024f, 0.03697256f, -0.16529572f, 
    0.22535191f, -0.14231640f, 0.01954029f, -0.08230969f, 0.02205723f, 0.01734503f, -0.06956880f, 0.00287237f, 
    0.03788500f, -0.06718790f, 0.04334564f, -0.04462516f, 0.02578647f, -0.04190557f, 0.02525262f, -0.04239027f, 
    -0.25066519f, -0.26757282f, -0.02803754f, 0.00454402f, 0.00647837f, -0.00324390f, -0.07247873f, -0.10115446f, 
    -0.07560564f, 0.03762924f, -0.00433557f, 0.01590411f, 0.06485058f, -0.03991429f, 0.08972692f, 0.03615925f, 
    0.07356773f, 0.00850856f, -0.01002487f, -0.12031999f, 0.07320680f, 0.07844132f, -0.01830698f, -0.08130120f, 
    0.21133024f, -0.07321513f, -0.05454767f, -0.06356151f, 0.03287802f, 0.04468925f, -0.02888581f, 0.00079252f, 
    0.05359470f, -0.03439308f, 0.02080231f, 0.03177447f, 0.08095413f, -0.03061140f, 0.04248909f, -0.03213498f, 
    -0.08562092f, 0.08969907f, 0.14255425f, 0.08837798f, 0.12273803f, -0.10122998f, -0.20929930f, 0.09331109f, 
    -0.05406541f, -0.00410576f, 0.03391158f, 0.02712951f, 0.02309523f, 0.12891854f, -0.11579765f, 0.03076699f, 
    -0.06377046f, -0.00757094f, -0.05228901f, -0.11168469f, -0.00558740f, -0.17845429f, -0.08744772f, 0.04562777f, 
    -0.18429479f, 0.08598641f, -0.00028044f, -0.01870128f, -0.00278945f, -0.07234438f, 0.00825995f, -0.07550563f, 
    -0.05648519f, 0.04244581f, 0.00574393f, -0.03722436f, -0.03545329f, 0.03718925f, -0.09517507f, 0.01069261f, 
    0.07299171f, -0.00515130f, 0.08134357f, 0.12632027f, 0.25127983f, 0.00279832f, -0.14458103f, -0.03382915f, 
    0.04051894f, -0.00974370f, 0.00434076f, 0.05096252f, -0.05639558f, -0.01150630f, -0.06546100f, -0.00379597f, 
    -0.02039229f, 0.01447392f, -0.02257009f, 0.07036202f, 0.02898385f, -0.20095393f, 0.04839567f, 0.11631902f, 
    0.05596761f, -0.01741246f, -0.05062286f, -0.05749331f, 0.01258449f, 0.00703764f, -0.01402868f, -0.01031844f, 
    -0.04162998f, -0.02230763f, -0.06933692f, 0.05516229f, -0.05173697f, 0.10178135f, 0.03949189f, -0.13329718f, 
    -0.07648560f, -0.29569495f, -0.23082612f, 0.16568424f, -0.06061524f, 0.00147638f, -0.00468746f, -0.07426059f, 
    0.03384450f, 0.01697707f, -0.03618719f, -0.00317335f, 0.00577839f, -0.07145123f, -0.02385341f, 0.02093504f, 
    0.03980150f, -0.03887895f, -0.09337992f, 0.01836047f, -0.22801429f, 0.18935485f, -0.03594163f, -0.07122920f, 
    -0.27489617f, -0.02962353f, 0.07070933f, -0.08274531f, 0.05219697f, 0.02745303f, 0.03385648f, -0.00868786f, 
    -0.00983177f, 0.00428617f, -0.03733403f, -0.01571497f, -0.09489965f, -0.01760497f, 0.10462246f, -0.00258796f, 
    -0.00678291f, -0.04777410f, 0.18888265f, 0.01711633f, 0.16436003f, -0.04439782f, -0.02679889f, 0.02199371f, 
    -0.07157698f, -0.03489486f, 0.03097379f, -0.06068963f, 0.05461415f, 0.04061038f, 0.02723394f, 0.03456193f, 
    -0.06745047f, -0.05222799f, 0.04043887f, -0.08752462f, 0.00861022f, -0.01914987f, 0.08360749f, -0.04094392f, 
    -0.30777562f, 0.09430908f, 0.10420337f, -0.06805915f, 0.05564190f, -0.02488594f, -0.05995627f, 0.00051345f, 
    -0.04671268f, -0.03370769f, 0.02429351f, 0.03479105f, 0.11187850f, 0.03823233f, 0.03388450f, -0.01511276f, 
    0.01012906f, 0.24909861f, 0.11851268f, 0.01500801f, 0.14564297f, -0.10330379f, -0.04715773f, 0.06738503f, 
    -0.00285027f, 0.10334173f, 0.05294764f, -0.06041801f, 0.13853584f, 0.03474160f, 0.01814589f, 0.00155410f, 
    0.03029327f, 0.05516600f, 0.11089554f, 0.15747423f, 0.04874300f, -0.02112191f, -0.05928472f, 0.04914058f, 
    -0.05385751f, 0.05285059f, -0.01669022f, 0.01025712f, -0.00547489f, 0.01264110f, 0.08670773f, -0.00830190f, 
    -0.03839130f, -0.00221540f, 0.03753522f, 0.06264845f, 0.00069862f, -0.07537355f, -0.06919806f, 0.08632562f, 
    -0.24153118f, 0.00303512f, -0.23938861f, -0.06919304f, -0.06086126f, 0.00322652f, -0.01862222f, -0.08007671f, 
    -0.11513334f, 0.11521559f, 0.08937623f, 0.10059241f, -0.02835369f, -0.00870385f, 0.01514923f, 0.06648838f, 
    0.02078282f, 0.03528098f, -0.02598477f, 0.06938883f, -0.02738197f, 0.02257795f, -0.02767958f, 0.00827608f, 
    -0.08120401f, -0.03421148f, -0.02810582f, 0.04686784f, 0.00514070f, 0.07707563f, 0.14596082f, -0.06710473f, 
    0.04176327f, 0.05096982f, 0.00651094f, -0.03829304f, 0.04002740f, -0.12664481f, 0.06988297f, 0.00243200f, 
    0.27947173f, -0.11517411f, -0.04127308f, -0.02567915f, 0.00119103f, -0.03599283f, -0.09512901f, 0.01940031f, 
    0.02358539f, 0.00002122f, -0.00110546f, 0.04283911f, -0.07855163f, 0.15761934f, -0.04227875f, 0.05126420f, 
    -0.00758968f, -0.02238480f, -0.01543132f, 0.02698581f, 0.26105112f, 0.08817147f, -0.12275048f, 0.05774290f, 
    -0.13642737f, 0.02977093f, 0.07857851f, 0.06092959f, -0.02785739f, 0.06442881f, 0.00094924f, -0.06676637f, 
    -0.06125841f, 0.03386888f, -0.03856321f, 0.09510582f, 0.02901911f, -0.01430064f, 0.00258295f, 0.03831754f, 
    0.22668573f, 0.01471095f, -0.24063559f, 0.06199081f, -0.35167560f, 0.03611191f, 0.05646836f, -0.02703617f, 
    -0.06027798f, 0.08829616f, -0.02472829f, 0.05358783f, -0.02733939f, 0.06351434f, 0.08653644f, 0.01203434f, 
    0.10536918f, 0.04249562f, -0.00169774f, -0.00340553f, 0.07127091f, -0.13519855f, 0.17212278f, -0.11452400f, 
    0.03216828f, 0.03367712f, 0.09637766f, -0.02113011f, 0.02011954f, -0.08769893f, -0.00764227f, 0.03594563f, 
    0.02650781f, -0.03922042f, -0.03353021f, 0.04229266f, -0.02184816f, -0.10121544f, -0.08977312f, -0.01662437f, 
    0.20854339f, -0.20444137f, 0.08299202f, -0.03264888f, -0.01942740f, -0.01497767f, 0.11582317f, 0.01518098f, 
    0.05919873f, 0.01688900f, 0.02673218f, -0.06762502f, 0.03586164f, 0.03185515f, -0.05485937f, 0.02737003f, 
    0.02259596f, 0.01812726f, 0.00936656f, 0.04357014f, 0.14030674f, -0.03812090f, 0.04335019f, 0.03844586f, 
    0.06468716f, -0.08067928f, -0.04911740f, 0.04613981f, 0.00070489f, 0.02854897f, 0.05272033f, 0.02938447f, 
    -0.04018672f, -0.03178693f, -0.14945962f, 0.04307173f, -0.01632011f, 0.01607462f, 0.00901576f, 0.01027561f, 
    0.12899262f, -0.22940052f, -0.02158837f, 0.03384616f, 0.14842550f, -0.02378274f, -0.00784804f, -0.02134253f, 
    -0.02255945f, 0.00019051f, -0.00047187f, 0.02438864f, -0.12505016f, -0.03741523f, -0.17629474f, 0.00546829f, 
    -0.14407362f, 0.10566887f, 0.01088289f, -0.00041911f, 0.22481398f, -0.20913047f, 0.04591015f, -0.17332408f, 
    -0.16096887f, 0.04610067f, 0.12952860f, -0.05693918f, -0.03112336f, -0.05448958f, 0.06498383f, -0.09378476f, 
    0.01293652f, -0.01651690f, -0.00883871f, -0.00383973f, -0.04322873f, -0.13292266f, 0.08840496f, 0.13521501f, 
    0.01511403f, -0.14469855f, 0.10278403f, -0.02783167f, 0.07332189f, -0.10000657f, -0.02509923f, -0.04496427f, 
    -0.03122697f, -0.02763713f, -0.05798447f, -0.02131191f, -0.07271989f, 0.06739663f, -0.03123884f, -0.10140901f, 
    0.06736083f, 0.02600268f, 0.03423247f, -0.03672886f, -0.13589197f, -0.16376778f, 0.11920264f, -0.06668230f, 
    0.19672097f, 0.02823781f, -0.08995856f, -0.00255847f, -0.08208206f, 0.02285552f, -0.00562828f, 0.09507910f, 
    0.07721142f, -0.02378221f, -0.01232868f, -0.04101929f, -0.00008088f, -0.15491889f, 0.03355356f, 0.02404303f, 
    0.05562025f, 0.13731265f, -0.02667949f, -0.08507843f, -0.19083466f, 0.00093337f, -0.02616061f, -0.11626611f, 
    0.02661621f, -0.02547883f, -0.08643348f, 0.01078152f, -0.05649710f, 0.02839829f, 0.06053578f, 0.08177933f, 
    0.02541226f, -0.00512742f, 0.02477046f, -0.00271768f, 0.21515581f, -0.16341873f, 0.02534864f, -0.01351037f, 
    -0.03108421f, 0.02795726f, 0.07407878f, -0.03284227f, 0.05544716f, 0.03711661f, 0.05537354f, -0.05052352f, 
    -0.00986605f, 0.02045346f, -0.11339534f, 0.06961688f, 0.00999643f, -0.01625705f, -0.03152828f, 0.02056169f, 
    -0.04367603f, -0.30870509f, 0.04957566f, -0.22200321f, 0.13669688f, -0.08331774f, -0.07098217f, 0.00941409f, 
    0.02286380f, -0.07122175f, -0.10269058f, -0.00756424f, -0.01097060f, -0.01967199f, -0.06051711f, -0.09170344f, 
    -0.04429781f, -0.13046901f, 0.10351985f, -0.08600368f, 0.07430014f, 0.09226178f, 0.06588244f, 0.03183218f, 
    0.07192085f, -0.08713780f, -0.01887650f, 0.07397654f, -0.01153497f, 0.01034866f, 0.01098552f, -0.01560404f, 
    0.08119754f, 0.05133247f, -0.02254467f, 0.04230590f, -0.04587468f, -0.02396604f, -0.01768534f, 0.01559651f, 
    -0.01054284f, -0.00737094f, -0.06149750f, -0.15218833f, -0.01318195f, 0.02325946f, 0.00133899f, -0.02552907f, 
    0.05655351f, 0.06291075f, 0.01130716f, -0.02433388f, 0.03158233f, -0.04775059f, -0.02218349f, -0.02561289f, 
    0.04106486f, -0.18011217f, 0.00290743f, -0.01648739f, -0.48075369f, 0.09749953f, -0.20077318f, -0.23261723f, 
    0.12758656f, -0.13369104f, 0.12202750f, -0.02483307f, -0.03360473f, 0.07811776f, -0.04472802f, -0.03204350f, 
    0.07795694f, -0.05378156f, -0.02154525f, -0.03652412f, 0.02870700f, 0.09000675f, -0.10001121f, -0.02071915f, 
    0.17410776f, -0.31062996f, -0.06603359f, 0.01858643f, 0.01144007f, -0.00810020f, -0.03754593f, -0.01048839f, 
    0.07915847f, -0.04501334f, 0.05635059f, 0.06828513f, -0.09569992f, -0.06860019f, -0.04088583f, -0.04964333f, 
    0.03909327f, -0.04010966f, 0.07541981f, 0.05114951f, 0.07152128f, 0.16108681f, -0.00661545f, 0.07494514f, 
    0.12475796f, -0.02715404f, -0.03012307f, 0.01108715f, 0.03767507f, -0.05222001f, 0.05554388f, -0.04069906f, 
    -0.09732784f, 0.16366039f, -0.07813470f, -0.00258362f, -0.01611099f, 0.03252326f, -0.07070623f, -0.00890226f, 
    -0.13725524f, 0.05532479f, 0.05798257f, -0.04967332f, -0.10224201f, 0.04838227f, -0.08391491f, 0.01727617f, 
    0.12544367f, 0.03571570f, -0.03739664f, 0.00050599f, 0.01162998f, -0.05654522f, -0.03568154f, 0.07094952f, 
    0.02313210f, -0.03906761f, 0.03601054f, 0.04792523f, -0.42101347f, -0.13881561f, -0.21814795f, -0.09241135f, 
    0.05858160f, 0.02199690f, 0.04090912f, -0.05149099f, 0.07986791f, 0.14075531f, 0.00035925f, -0.01404853f, 
    0.04706861f, -0.07538530f, 0.00422492f, 0.04986063f, 0.00427964f, -0.06165446f, -0.04624023f, -0.18977478f, 
    0.08335077f, -0.20945792f, 0.02392966f, -0.31952837f, -0.11489780f, 0.04832672f, 0.06372536f, 0.05681937f, 
    -0.08406555f, 0.03312424f, 0.04352166f, 0.09595518f, -0.00857891f, 0.00506654f, -0.04856777f, -0.10165001f, 
    -0.06421316f, -0.10110870f, -0.04216211f, -0.11060859f, 0.10924504f, -0.06370368f, -0.17440477f, -0.00819780f, 
    -0.20415732f, 0.00832055f, 0.02353278f, -0.09903853f, -0.01497647f, 0.09910299f, 0.04423834f, 0.04956379f, 
    -0.01828193f, -0.03630365f, 0.00761654f, 0.07896620f, 0.01909501f, -0.00023232f, -0.05013491f, 0.04035870f, 
    -0.04732445f, 0.03638131f, -0.03155389f, 0.01505640f, 0.01564028f, -0.06674207f, -0.00450600f, -0.06840786f, 
    -0.03742040f, 0.03216554f, 0.02662757f, -0.00499767f, -0.05167660f, -0.05077498f, 0.03313443f, -0.07413142f, 
    -0.07646646f, -0.00556130f, -0.18817599f, 0.02824797f, 0.22540163f, -0.21027964f, -0.09370001f, -0.02518085f, 
    -0.06980190f, -0.02338861f, -0.09527338f, 0.00168456f, 0.07867335f, -0.02341865f, -0.03298154f, 0.06412238f, 
    -0.00879894f, 0.05317042f, 0.06747075f, 0.03643595f, -0.14387184f, -0.01936025f, -0.03755323f, -0.00633704f, 
    0.33309826f, -0.02593003f, 0.05426300f, -0.10021294f, 0.01859467f, -0.15941596f, -0.01222469f, 0.00907286f, 
    0.05247723f, -0.08719472f, 0.04923950f, -0.00131857f, -0.02733887f, 0.03551367f, 0.01530085f, -0.04423255f, 
    -0.02667529f, 0.10446569f, -0.00881321f, 0.02440840f, 0.07291503f, -0.09572099f, 0.06714535f, -0.06352945f, 
    0.19816475f, 0.00543814f, -0.00618048f, 0.02230982f, 0.00307520f, -0.09357052f, -0.12137612f, -0.02209353f, 
    0.02392451f, -0.02963658f, 0.07020748f, -0.04825681f, 0.09463954f, -0.00520641f, 0.09444494f, 0.05473308f, 
    -0.13698892f, -0.04851538f, 0.07197396f, -0.11202671f, 0.24943329f, 0.02808927f, -0.06724889f, 0.08326634f, 
    -0.05934289f, -0.02677554f, 0.06237545f, -0.01402018f, 0.04090568f, -0.03849643f, 0.02770616f, -0.03192139f, 
    -0.02070593f, -0.18328047f, -0.05093540f, -0.00597009f, 0.15049334f, 0.30321470f, 0.13284504f, 0.02162239f, 
    0.13863008f, -0.06980664f, -0.01260287f, 0.02906141f, -0.02085691f, 0.06298524f, -0.04834080f, -0.00910055f, 
    -0.01005584f, -0.10337383f, 0.01528442f, -0.02391938f, 0.07455771f, 0.03197199f, -0.00124044f, 0.07709442f, 
    -0.07295179f, -0.02745378f, 0.05157921f, -0.06937531f, 0.06959055f, -0.08002627f, -0.06727877f, -0.04457266f, 
    -0.04958118f, 0.00447781f, 0.01323679f, 0.02365376f, 0.03108408f, -0.05703792f, 0.08526043f, 0.01159977f, 
    -0.03951018f, -0.00783405f, -0.04459241f, -0.02352390f, 0.12137702f, 0.09476520f, 0.11789084f, 0.12966806f, 
    0.16834557f, -0.00568399f, -0.08430087f, 0.08082610f, 0.03406921f, -0.02263691f, -0.10460827f, -0.01015799f, 
    0.00625618f, 0.11267740f, 0.01057126f, 0.04427483f, -0.04807812f, 0.03399254f, -0.05879919f, -0.05860270f, 
    0.12476628f, -0.08971459f, 0.11505243f, -0.00817928f, 0.05353041f, -0.09853606f, -0.14110103f, -0.08724523f, 
    0.00064378f, -0.00856669f, 0.05032323f, 0.05155862f, -0.17276846f, 0.00171747f, -0.10084458f, -0.03677228f, 
    -0.07029548f, 0.04828795f, 0.10542712f, -0.08067250f, -0.04677268f, -0.05094415f, 0.02216757f, 0.05924848f, 
    -0.01307114f, -0.07921895f, -0.00323762f, -0.02359809f, 0.15823662f, -0.05122654f, -0.07478686f, -0.01650746f, 
    -0.00655305f, -0.01496440f, -0.10224959f, 0.00062477f, 0.04186597f, 0.02783735f, 0.04374009f, 0.05045614f, 
    -0.33749536f, -0.01839430f, 0.10671931f, -0.13310014f, -0.21557292f, 0.02153339f, 0.01712624f, 0.03214427f, 
    0.03185330f, -0.06565992f, 0.02957502f, 0.12817341f, 0.12456140f, 0.01323812f, 0.01364072f, 0.02272510f, 
    -0.04726295f, -0.18002880f, -0.04037650f, 0.01044801f, -0.18056707f, -0.03104247f, -0.16083147f, -0.17734441f, 
    -0.30718553f, 0.10003929f, 0.01014232f, -0.02280234f, 0.04418933f, 0.01100622f, -0.07029538f, -0.03098403f, 
    -0.04887513f, -0.04618724f, -0.08505221f, -0.00570868f, -0.00121454f, -0.00962969f, -0.08860410f, -0.00021061f, 
    0.01938674f, -0.42922133f, -0.10256474f, -0.03770327f, 0.04051301f, 0.14921254f, 0.01090908f, 0.03913840f, 
    -0.02354202f, -0.09183378f, 0.13666779f, 0.11255384f, -0.02991206f, -0.06530322f, 0.03027579f, 0.06457885f, 
    -0.02416501f, 0.03742102f, 0.05573150f, -0.00576812f, 0.10704912f, -0.00989894f, -0.05211136f, 0.01569079f, 
    -0.14710006f, 0.05547149f, -0.00891947f, -0.00145959f, 0.04597086f, 0.07009081f, -0.01989436f, -0.01755353f, 
    0.06883337f, 0.12149297f, -0.06592379f, -0.03036053f, 0.15294412f, -0.08110166f, -0.08112242f, -0.05362014f, 
    0.30820531f, -0.08165150f, -0.06854472f, 0.08643939f, -0.07458860f, -0.03399456f, 0.03921960f, 0.02128858f, 
    0.03678935f, 0.08258323f, 0.00566177f, -0.04227782f, 0.00311297f, 0.01652847f, 0.07568965f, 0.13269995f, 
    -0.01195222f, 0.00479930f, -0.13220590f, 0.01221876f, -0.03720878f, -0.10653462f, -0.01847116f, -0.23292620f, 
    0.00374762f, -0.09178711f, 0.02531731f, 0.09488545f, 0.02990458f, 0.00065818f, -0.23489511f, -0.09298591f, 
    0.11209887f, 0.05341000f, 0.06117579f, 0.01335915f, -0.02558671f, -0.04408011f, -0.15046458f, -0.02856512f, 
    0.07684325f, 0.09335321f, 0.10751632f, 0.06577711f, 0.13520440f, -0.01818192f, 0.01588605f, 0.02508353f, 
    0.02491172f, 0.05524804f, -0.05171382f, 0.01741330f, 0.04743948f, 0.06107144f, 0.01668544f, 0.01424025f, 
    0.03415528f, 0.07505567f, 0.01102754f, 0.03612674f, -0.63199425f, 0.08043611f, 0.06930499f, -0.02033819f, 
    -0.10622134f, 0.11382847f, -0.00811239f, -0.06377862f, -0.01975754f, -0.04005449f, 0.01867212f, 0.00964869f, 
    -0.13163489f, 0.04833487f, -0.09043612f, -0.07190447f, -0.18264326f, -0.06059317f, -0.05418466f, -0.11530590f, 
    0.14537227f, -0.37808824f, 0.11834218f, -0.01512554f, -0.09332670f, -0.02293114f, -0.01797043f, -0.02397486f, 
    0.01400692f, 0.01411270f, 0.03617224f, -0.02356184f, -0.06692097f, 0.05686442f, -0.01468870f, -0.01529978f, 
    0.02014060f, -0.05179284f, 0.02049907f, 0.01751634f, -0.25662085f, 0.01733962f, -0.03204462f, -0.04078677f, 
    0.16585408f, 0.11231259f, -0.11797187f, 0.20726861f, -0.01073839f, -0.04961975f, -0.14809796f, -0.06035419f, 
    -0.00843474f, -0.10267168f, 0.10994168f, -0.08453547f, 0.07897575f, -0.06544324f, -0.00687026f, -0.12134608f, 
    0.05977331f, -0.16594344f, 0.05331441f, 0.00119593f, -0.00778618f, -0.02377790f, 0.03421693f, -0.12845160f, 
    0.03994272f, 0.09366081f, 0.10990217f, 0.07078587f, -0.05614204f, 0.01891001f, -0.01006898f, -0.03518509f, 
    0.03124998f, -0.01190665f, 0.05333925f, 0.05953348f, 0.11000983f, 0.00099254f, 0.11321162f, -0.00433643f, 
    -0.00654441f, -0.04531522f, 0.00242068f, -0.04500302f, 0.05660281f, -0.01971235f, -0.05292196f, -0.08041790f, 
    -0.05245688f, -0.04747402f, -0.02431859f, 0.04247767f, 0.06139382f, -0.01226532f, 0.03930469f, 0.06816204f, 
    0.01296556f, -0.13497919f, -0.23645611f, 0.01258356f, 0.02014982f, -0.05936446f, -0.01735583f, 0.03459805f, 
    -0.03075983f, 0.13012949f, 0.08206861f, -0.00640909f, 0.01207322f, 0.01796386f, 0.02825437f, 0.00267434f, 
    0.06402024f, -0.06920744f, -0.06665875f, 0.08132725f, -0.16132760f, 0.19658877f, -0.04060567f, 0.04940491f, 
    0.14353964f, 0.01504923f, -0.06568808f, 0.01830165f, 0.06478500f, 0.04420966f, 0.00941287f, 0.05774795f, 
    -0.02344692f, -0.00250026f, -0.13860345f, 0.01607345f, -0.04202118f, 0.10501160f, -0.07187119f, 0.05673722f, 
    -0.15299523f, 0.16066334f, -0.02791333f, 0.02499052f, 0.11196373f, 0.03278719f, 0.01812729f, -0.06687669f, 
    -0.02028252f, 0.01805632f, 0.06724843f, 0.08736370f, 0.10199507f, -0.02586698f, 0.09780478f, 0.02456552f, 
    -0.04314272f, 0.05252185f, 0.03719908f, -0.05824547f, -0.19219400f, 0.16136850f, -0.09365445f, -0.07735484f, 
    -0.06574763f, 0.02065217f, 0.05138543f, -0.02097773f, -0.05769804f, -0.02163015f, -0.06046690f, 0.04449834f, 
    0.02845230f, -0.05360848f, -0.01017876f, 0.01166556f, 0.00743177f, 0.06365740f, -0.01844260f, 0.02179522f, 
    0.29801258f, -0.27838105f, 0.12265689f, -0.17598446f, -0.11038979f, -0.08993891f, -0.16167766f, -0.01445495f, 
    -0.02950021f, 0.00211812f, -0.04143452f, 0.00819128f, 0.00785510f, -0.03652256f, 0.10479434f, -0.06447171f, 
    -0.02413908f, -0.08030619f, -0.00777290f, -0.04713387f, 0.17354813f, 0.08318493f, 0.00430580f, 0.01011917f, 
    0.01866466f, 0.01757414f, -0.05898272f, 0.01093281f, 0.05999682f, -0.06451973f, 0.05090549f, 0.04503185f, 
    -0.02560619f, 0.13589072f, -0.07425421f, 0.03314121f, 0.03072673f, -0.00511086f, -0.02987438f, -0.04249822f, 
    -0.18768257f, -0.04048850f, 0.02845914f, 0.00325426f, -0.00149680f, 0.08291014f, 0.00797908f, 0.00637090f, 
    0.00603783f, 0.01457250f, -0.06505279f, -0.05543343f, 0.01291718f, -0.04463975f, -0.09259722f, 0.06865204f, 
    0.01416957f, -0.14099184f, 0.08286225f, 0.04157082f, 0.17382242f, 0.24731795f, 0.00820618f, 0.07019180f, 
    0.16729353f, -0.02472860f, -0.04787407f, 0.06940507f, 0.01628987f, 0.00810810f, 0.05008627f, -0.05902426f, 
    -0.05866731f, 0.03836297f, -0.10254773f, -0.03450124f, 0.03626063f, 0.07005033f, -0.03072260f, 0.02853320f, 
    0.02815872f, 0.04803713f, -0.10633252f, -0.07502346f, 0.11568344f, 0.03188614f, 0.08340181f, 0.03232303f, 
    -0.09365683f, 0.05384400f, -0.04434835f, 0.02650355f, 0.00519464f, -0.05884730f, -0.07560927f, 0.11897909f, 
    -0.14255178f, 0.00544789f, 0.04959312f, 0.03044632f, -0.02444965f, 0.09351000f, -0.01696347f, 0.03308656f, 
    -0.20618188f, 0.00943531f, -0.12778270f, 0.07600344f, 0.04723793f, -0.01952466f, 0.01150756f, -0.03715534f, 
    0.06953218f, -0.03330083f, -0.00848249f, 0.00511150f, 0.06027565f, -0.14531027f, 0.04034730f, -0.07402248f, 
    0.27291411f, -0.22695553f, 0.10902359f, -0.05376474f, 0.03383077f, -0.03593525f, -0.04042394f, -0.00671804f, 
    0.03153460f, -0.01717053f, -0.06309997f, 0.00501676f, -0.04564961f, -0.06879549f, 0.02158389f, -0.13611019f, 
    0.07886969f, -0.06629731f, 0.10651680f, -0.02444549f, -0.14982522f, -0.02981683f, -0.03471623f, -0.18332040f, 
    -0.29062408f, 0.11038236f, 0.07120726f, 0.01915550f, -0.03983258f, -0.05207427f, -0.01367818f, 0.05061663f, 
    0.04552378f, 0.10901485f, 0.00746036f, -0.06379813f, -0.11973406f, -0.10199551f, 0.03938819f, -0.07787984f, 
    -0.16328967f, -0.04771105f, -0.01735816f, -0.28609446f, -0.17497067f, -0.00670861f, 0.02260522f, 0.00616441f, 
    0.00038098f, -0.00211293f, -0.13522398f, 0.02033898f, -0.03093099f, 0.11066630f, -0.12237839f, -0.08052316f, 
    -0.04619292f, -0.03054816f, -0.01855239f, -0.11032026f, 0.11588723f, -0.11574886f, -0.00971564f, 0.07378296f, 
    -0.14716341f, -0.10248059f, -0.03365055f, -0.04363003f, 0.04414293f, 0.00631037f, 0.08696987f, -0.01594127f, 
    -0.12508622f, -0.02015418f, -0.02637533f, 0.01995354f, -0.04083080f, 0.00449204f, -0.12561670f, -0.03577216f, 
    -0.25676131f, 0.11958837f, -0.05548201f, -0.10667773f, 0.04709732f, -0.06716450f, 0.06986193f, 0.00301011f, 
    -0.01479111f, -0.02001312f, -0.02395220f, -0.01854571f, 0.05946078f, -0.04513017f, 0.00110132f, 0.08540405f, 
    -0.03164075f, 0.07492382f, 0.00487880f, 0.10526937f, 0.00925834f, 0.15629509f, -0.09613820f, 0.01222656f, 
    -0.26388657f, -0.00635368f, 0.03977117f, 0.02848175f, -0.11613283f, 0.07444815f, 0.02390537f, 0.05773981f, 
    -0.05319497f, 0.06449041f, 0.04862328f, 0.04605640f, 0.08178726f, -0.02249908f, 0.03526321f, -0.01106207f, 
    -0.30978703f, 0.13433276f, 0.05950708f, -0.05662586f, 0.07543047f, 0.07677010f, 0.00493945f, -0.04428057f, 
    0.04710261f, 0.03513755f, 0.01391709f, -0.01227737f, 0.00718825f, -0.03923756f, 0.05612455f, 0.00692418f, 
    0.01423281f, -0.15611945f, -0.09097915f, -0.02893748f, -0.05185988f, 0.22039416f, -0.03971849f, -0.12201449f, 
    0.00599868f, -0.00930383f, 0.09359618f, -0.01060594f, 0.00861913f, -0.12500554f, -0.01313086f, 0.03017610f, 
    -0.06164213f, -0.09144303f, -0.01334213f, -0.00012349f, 0.04346933f, 0.03737982f, -0.00154433f, -0.02757983f, 
    0.19392796f, 0.08876871f, 0.10906956f, 0.05876657f, 0.12403194f, -0.07499823f, -0.02013586f, -0.08558863f, 
    0.04188383f, 0.04405012f, -0.02855341f, -0.10845875f, -0.09169569f, -0.04779954f, -0.05775661f, -0.02293932f, 
    -0.02034347f, -0.03208581f, 0.03612475f, -0.04189335f, 0.01109634f, 0.03628245f, 0.07466888f, 0.11309666f, 
    -0.00793313f, -0.05221105f, -0.06207383f, -0.09561982f, 0.02433682f, 0.00348277f, -0.02571194f, -0.02582378f, 
    0.00429010f, 0.00951475f, -0.00641548f, 0.00953059f, 0.03512662f, 0.02448419f, 0.00025768f, 0.01773888f, 
    0.10510089f, 0.07622415f, 0.04269169f, -0.16961537f, 0.01481062f, -0.02626962f, 0.02459544f, 0.02784374f, 
    0.00969347f, -0.02113701f, -0.01110327f, -0.04616836f, 0.05933574f, -0.04134262f, -0.03691725f, 0.05545412f, 
    -0.03558076f, -0.00518254f, 0.02675004f, -0.01664239f, 0.13491839f, 0.00669450f, 0.13375859f, 0.07619602f, 
    0.14566158f, -0.13196585f, -0.02456796f, -0.12299931f, 0.01828901f, 0.00255392f, 0.03236712f, -0.07229790f, 
    0.02032463f, -0.02839066f, 0.04068673f, 0.05232181f, -0.09995931f, 0.00535607f, -0.00559109f, 0.07104460f, 
    0.22298034f, -0.13612664f, 0.14922310f, -0.04178424f, 0.21216221f, -0.18967824f, -0.07844828f, -0.02442668f, 
    0.00122643f, 0.01706179f, 0.07623993f, -0.05008590f, -0.03977089f, -0.16481003f, 0.10135736f, -0.00997502f, 
    -0.08676984f, -0.05067617f, 0.02954990f, 0.00593767f, -0.41833332f, -0.24639793f, -0.03896495f, -0.37786603f, 
    -0.20268776f, 0.02229621f, 0.03302486f, 0.03664409f, 0.03024898f, -0.00911175f, 0.01274041f, 0.00860597f, 
    0.02510312f, -0.08021907f, -0.04615323f, 0.08122695f, 0.02384763f, 0.09364665f, 0.05652162f, -0.07340819f, 
    -0.14263211f, 0.03881938f, 0.02606582f, -0.06844675f, -0.03714687f, -0.02347835f, 0.00515627f, 0.01033660f, 
    0.01588858f, 0.03434440f, -0.03107385f, -0.08218936f, 0.03645917f, -0.03763226f, 0.03944786f, -0.00671778f, 
    0.04204420f, -0.03768916f, 0.04774759f, 0.04131924f, -0.14887863f, 0.11008123f, 0.00304047f, -0.06845896f, 
    0.05306540f, 0.01757232f, -0.02553893f, 0.03905246f, 0.03698497f, 0.03025923f, -0.03491704f, 0.00272045f, 
    0.03594171f, 0.02684631f, 0.03017610f, 0.00829448f, -0.03305949f, -0.05294301f, 0.04681173f, 0.04641409f, 
    0.29601032f, 0.10205909f, -0.07532939f, -0.15496944f, -0.03488290f, -0.02138696f, 0.00725297f, 0.05583255f, 
    0.05476649f, 0.06496321f, -0.01976163f, 0.02033578f, -0.07762875f, -0.00700003f, -0.02530309f, 0.01024923f, 
    0.03896430f, -0.06110381f, 0.06571081f, 0.04777303f, -0.30044806f, -0.09874437f, -0.04066652f, -0.04405791f, 
    -0.04680304f, -0.01343959f, -0.02017490f, -0.06771881f, -0.02662093f, 0.01659706f, 0.02512251f, -0.03025476f, 
    0.01025356f, -0.05676855f, -0.00578430f, -0.00026356f, -0.02928250f, -0.03006694f, -0.06601122f, 0.00922643f, 
    0.26224902f, -0.27269405f, -0.03794468f, -0.11184054f, -0.09219988f, 0.01076734f, -0.06019937f, 0.10246761f, 
    0.00357554f, 0.03023920f, 0.00916235f, 0.02119889f, 0.10179623f, -0.00103312f, -0.01794144f, 0.03449447f, 
    -0.02144437f, 0.07205958f, -0.03577283f, -0.04972030f, 0.11143535f, -0.02699924f, 0.01916824f, -0.10264575f, 
    -0.01938013f, 0.07600712f, -0.00001017f, 0.09481791f, -0.05022892f, -0.05489516f, 0.01748594f, 0.07728277f, 
    -0.04116069f, -0.01139216f, -0.02731718f, 0.03876212f, -0.12334622f, 0.06742013f, -0.01688820f, 0.01625022f, 
    0.15263829f, -0.04723471f, -0.11445136f, 0.03804086f, 0.01403350f, -0.09908351f, -0.02138931f, 0.07959635f, 
    -0.01514207f, 0.02130818f, 0.06774852f, 0.01199196f, 0.00712249f, -0.05899692f, 0.02044811f, 0.05095131f, 
    -0.00129733f, -0.05122488f, 0.09389624f, -0.03465396f, 0.07245252f, 0.04422556f, 0.07819059f, 0.06541166f, 
    0.03361390f, -0.06654637f, -0.04738752f, 0.01004464f, 0.05186680f, 0.03242425f, 0.03236319f, -0.04865620f, 
    -0.01426289f, 0.02663945f, 0.00802685f, 0.00268418f, -0.01766336f, -0.06187562f, -0.05063668f, -0.00281670f, 
    0.25354689f, -0.39153153f, -0.02128262f, -0.17891705f, -0.08149217f, 0.07176262f, -0.09929816f, 0.12221227f, 
    -0.01493016f, 0.00379099f, -0.03570669f, 0.05099085f, 0.04454585f, -0.03649693f, -0.07514227f, 0.07123162f, 
    -0.02870716f, 0.04545008f, -0.13475642f, -0.03562529f, -0.14005533f, 0.06789821f, -0.00953683f, -0.01740684f, 
    0.06462818f, 0.05603156f, 0.04965587f, 0.00204303f, -0.02138268f, -0.03331215f, -0.06457916f, 0.02616730f, 
    -0.00753108f, -0.01256935f, -0.00076994f, -0.02660668f, 0.00336677f, -0.02350691f, -0.10725226f, 0.03923520f, 
    -0.19430700f, -0.18559684f, -0.00081831f, 0.01838431f, -0.06308040f, -0.06178867f, -0.04278355f, -0.03194088f, 
    -0.01866772f, 0.01768205f, -0.02715377f, -0.00873480f, -0.03040065f, 0.03052966f, 0.03426330f, 0.01019928f, 
    -0.05365339f, 0.04557003f, -0.00341782f, -0.04046744f, 0.21514301f, 0.04358177f, -0.23014671f, -0.10191167f, 
    -0.14038906f, 0.04156550f, -0.01469839f, -0.03755648f, -0.05208949f, 0.03051817f, 0.00816164f, 0.01676043f, 
    -0.00166021f, -0.02584564f, 0.02728557f, 0.01903461f, -0.01460313f, -0.07732058f, -0.01890620f, 0.01835164f, 
    0.07714802f, -0.11920929f, 0.11251648f, -0.00747950f, 0.11527108f, -0.00639510f, -0.06666408f, -0.08163189f, 
    0.01671327f, 0.11273555f, 0.01135438f, -0.05161871f, -0.02278749f, 0.08053160f, 0.04215255f, -0.05645341f, 
    -0.09347807f, 0.01900746f, -0.08193415f, -0.06858588f, -0.03997660f, -0.00048835f, -0.03167012f, -0.13551682f, 
    0.04005059f, 0.03612787f, 0.00043369f, 0.14887947f, 0.06186727f, -0.03054051f, -0.07807051f, 0.03176686f, 
    0.03513325f, 0.03171432f, -0.02646982f, -0.02444382f, -0.01325402f, 0.00695250f, -0.06406702f, -0.06821779f, 
    0.43318653f, -0.05278017f, -0.06657095f, 0.13045724f, -0.34031489f, -0.06073805f, -0.05887538f, 0.01181242f, 
    -0.13032800f, 0.06609519f, -0.00525338f, -0.01617345f, 0.03125706f, -0.15895465f, -0.05024000f, 0.02431440f, 
    -0.03193813f, 0.01072916f, 0.08568861f, 0.02963264f, 0.27507868f, -0.14843966f, -0.12763007f, -0.18459186f, 
    0.03606560f, 0.06510708f, -0.04839446f, -0.11183404f, 0.03768575f, 0.04607470f, 0.04011766f, 0.00823608f, 
    0.04991976f, -0.01127158f, 0.04683533f, 0.00043332f, 0.00805572f, 0.02590935f, 0.02051546f, -0.01787019f, 
    -0.34028345f, -0.13220255f, -0.16244136f, -0.21344474f, -0.19352289f, 0.02669575f, -0.04481919f, 0.05813473f, 
    0.04572225f, 0.02628427f, -0.03757779f, 0.02497527f, -0.01882418f, -0.03283705f, -0.04020932f, -0.01618448f, 
    0.03799974f, 0.10607712f, 0.08360370f, 0.02346911f, 0.15890843f, 0.05170356f, 0.11318728f, 0.16908699f, 
    0.16164951f, -0.12533803f, -0.02996531f, -0.07008589f, 0.02574593f, 0.01538043f, 0.10722751f, -0.08103088f, 
    -0.03278760f, 0.04105320f, -0.00143230f, -0.00957800f, -0.00379844f, -0.01269354f, -0.01582990f, -0.02573587f, 
    0.19552228f, 0.04744204f, -0.03148172f, -0.01686113f, 0.04452857f, -0.02705054f, 0.01405293f, 0.02480445f, 
    0.02158317f, 0.04397271f, 0.02963543f, 0.05138935f, 0.01999036f, 0.00206611f, 0.00458135f, 0.05327376f, 
    -0.03115818f, -0.02596143f, 0.03032755f, -0.00133868f, 0.07621165f, 0.04695942f, -0.01212688f, -0.10286295f, 
    -0.11772078f, 0.01894849f, 0.02199156f, 0.05536508f, -0.09574867f, 0.02899931f, -0.02678608f, 0.05229177f, 
    -0.04321373f, -0.12263139f, 0.00331695f, 0.01736135f, 0.00415181f, 0.05802328f, 0.02091956f, 0.02239933f, 
    -0.00431886f, 0.10068769f, 0.02585823f, -0.03559147f, -0.13027543f, 0.01023473f, -0.05442297f, 0.08404510f, 
    -0.01459053f, -0.00125417f, -0.01904169f, -0.02826002f, 0.11167348f, -0.06007645f, -0.03519285f, 0.01681207f, 
    -0.07032120f, -0.05501090f, 0.01556387f, -0.00428733f, 0.01836068f, -0.11389919f, 0.11199431f, -0.07912196f, 
    0.04311934f, 0.06330953f, -0.03040745f, 0.05679071f, 0.07147698f, 0.03047009f, -0.02424712f, 0.03341167f, 
    -0.02073799f, -0.00345747f, -0.03048791f, -0.00464967f, -0.07292344f, -0.04256176f, -0.07854618f, -0.05689793f, 
    -0.16054344f, -0.13306133f, 0.12884741f, -0.24810146f, -0.14955381f, 0.12247852f, 0.04601204f, 0.03385565f, 
    -0.00732651f, 0.01799105f, -0.00758944f, 0.12813462f, 0.01877544f, -0.15453318f, -0.01100810f, 0.10482849f, 
    -0.00933839f, 0.03812009f, -0.09772924f, -0.08638094f, -0.02571124f, -0.02024795f, 0.00884021f, -0.07259551f, 
    0.03299952f, 0.02139221f, 0.01587530f, 0.07053611f, -0.02963264f, -0.05523371f, -0.04696927f, 0.05098106f, 
    0.04447103f, 0.01737427f, 0.04799394f, -0.04081199f, -0.16238922f, -0.08774958f, -0.03316357f, -0.04189276f, 
    0.09422872f, -0.00169840f, 0.04903064f, -0.14161171f, -0.07426248f, 0.05243088f, -0.03351382f, 0.01611523f, 
    -0.01189204f, -0.02425678f, -0.03718528f, -0.01962133f, 0.01652427f, -0.01052634f, 0.02295203f, -0.04617066f, 
    -0.11039440f, 0.05400127f, 0.03736861f, -0.00095373f, -0.18185247f, 0.08136770f, -0.05647937f, -0.04245142f, 
    0.10575565f, 0.01357920f, 0.02696999f, 0.10634698f, 0.03227966f, -0.06784269f, -0.04672792f, 0.08648290f, 
    0.00788766f, -0.04839873f, -0.05865286f, -0.03166347f, 0.00556895f, -0.02008644f, -0.08129097f, 0.01763958f, 
    0.00642528f, 0.02589136f, -0.10339967f, 0.11748231f, -0.14769363f, 0.05430865f, -0.11614737f, 0.06987940f, 
    0.10985590f, 0.09411903f, -0.03798694f, 0.01042051f, -0.01583229f, 0.03355414f, -0.05991021f, -0.13964945f, 
    0.05963626f, -0.00299539f, 0.01439079f, 0.01503643f, 0.05820293f, 0.01979523f, 0.12210447f, 0.02725545f, 
    -0.00417245f, -0.04739711f, -0.01815668f, 0.01821724f, -0.03456267f, -0.03049484f, -0.01091112f, -0.00024063f, 
    0.04490441f, -0.05405468f, -0.02922941f, 0.03299279f, -0.06201954f, 0.00861351f, 0.03106837f, -0.05883243f, 
    0.02649062f, 0.04522768f, -0.08939505f, -0.01068598f, -0.10334140f, 0.02161034f, 0.12468742f, -0.06967728f, 
    -0.01022443f, -0.06368349f, -0.00878245f, -0.01205844f, -0.00842051f, -0.07370682f, -0.04984959f, 0.02536626f, 
    0.00257628f, 0.03310975f, -0.02558528f, -0.08019490f, 0.22576892f, -0.10178106f, -0.23791978f, 0.01941829f, 
    -0.16366270f, 0.01905278f, 0.05952188f, -0.02542716f, -0.00626486f, -0.07328814f, -0.05490910f, 0.01053106f, 
    -0.00277377f, 0.02701142f, -0.04077682f, 0.02217263f, 0.04372427f, -0.03266789f, 0.03726968f, -0.03041296f, 
    0.25508827f, 0.03124804f, 0.10878088f, 0.05628296f, -0.12975658f, -0.08613915f, 0.04261748f, -0.05188809f, 
    -0.00250981f, 0.08747920f, 0.03096475f, -0.00638027f, 0.04237106f, 0.00697949f, -0.02897123f, -0.02211252f, 
    0.04673633f, 0.05477761f, 0.07106593f, 0.05147096f, 0.00992553f, -0.22915688f, -0.01715485f, 0.03224004f, 
    -0.10148682f, -0.07646329f, -0.00585322f, -0.04405420f, 0.00196816f, -0.02045432f, 0.02645921f, 0.00710859f, 
    0.01294248f, -0.04027160f, 0.01644602f, -0.03392291f, -0.00683214f, 0.06207035f, 0.03612733f, 0.01017327f, 
    0.28164762f, -0.02414585f, 0.02958201f, 0.08220672f, 0.03106278f, -0.11062970f, 0.01912629f, -0.04549264f, 
    -0.03665807f, 0.03827917f, 0.03510782f, -0.03347759f, -0.00131143f, -0.00397156f, -0.03998640f, 0.01066038f, 
    -0.02953460f, 0.01140960f, 0.05110321f, 0.03635419f, -0.00040846f, -0.21795388f, -0.08447109f, -0.26221940f, 
    -0.35340878f, -0.04217982f, 0.05242538f, -0.07255989f, -0.02855320f, -0.02645358f, 0.07542899f, 0.03868761f, 
    -0.01586281f, -0.02477001f, -0.01510423f, -0.04158587f, 0.00035270f, 0.10615223f, -0.02745567f, -0.04064730f, 
    -0.10487125f, -0.03210608f, -0.01215413f, -0.06305840f, 0.03421203f, 0.05897957f, -0.01020562f, 0.02207434f, 
    0.03022342f, -0.00289508f, -0.02095212f, 0.02192160f, -0.01461391f, -0.02076182f, -0.01148002f, -0.07201859f, 
    -0.03768905f, -0.03685693f, -0.09047730f, -0.01441329f, 0.32910103f, 0.08912527f, -0.20110138f, -0.04855090f, 
    -0.08219699f, -0.08152509f, 0.04682263f, 0.06356109f, -0.02477751f, -0.01602574f, -0.01381490f, 0.05641321f, 
    -0.04953917f, 0.06110668f, -0.09253622f, 0.03393374f, 0.03624678f, -0.01607230f, 0.10324303f, -0.07784198f, 
    0.01330360f, -0.00404475f, -0.00776059f, -0.05453980f, -0.09025408f, -0.04411635f, -0.08720104f, 0.04321146f, 
    -0.00045686f, 0.04276057f, -0.06179408f, -0.02810926f, 0.01513776f, -0.00153042f, -0.01564832f, -0.01603069f, 
    0.00037141f, 0.03673912f, 0.04903107f, -0.05361555f, -0.30970839f, -0.22690517f, 0.04045846f, -0.16146871f, 
    -0.30579779f, 0.03479610f, -0.10191231f, -0.04785683f, -0.01643863f, 0.02519972f, 0.00580746f, 0.02393921f, 
    0.00585326f, 0.01447383f, -0.05726618f, -0.03623442f, -0.10869374f, 0.07598165f, -0.02592201f, 0.00149724f, 
    -0.08458123f, 0.04409670f, 0.12185408f, 0.09239781f, 0.01129646f, -0.02797842f, -0.14788547f, -0.03984734f, 
    0.05258457f, 0.05774468f, -0.05500931f, -0.03622939f, 0.00086338f, 0.05050389f, -0.03912643f, -0.14580141f, 
    -0.01505070f, -0.05364370f, -0.00785498f, -0.01910779f, 0.00666088f, 0.00242453f, 0.11659528f, -0.02351603f, 
    0.01440147f, -0.06237957f, 0.02974294f, -0.02190320f, -0.01453041f, -0.07393356f, -0.02183831f, -0.00669228f, 
    0.05324524f, 0.01646235f, -0.00980796f, -0.03190611f, -0.07049038f, 0.03364743f, 0.00035072f, -0.04044292f, 
    0.26674846f, -0.08140151f, -0.04968612f, -0.10188371f, -0.04899199f, -0.02246784f, 0.00992213f, -0.02764131f, 
    0.03882333f, 0.02495944f, -0.00315004f, -0.08243622f, 0.00219006f, 0.00477012f, -0.03069218f, -0.00410665f, 
    0.01994722f, -0.01612696f, 0.10054506f, -0.08701643f, 0.18013492f, 0.06844773f, -0.13998251f, -0.02910548f, 
    -0.01380982f, 0.02192507f, 0.07682712f, 0.01039626f, -0.04017095f, -0.07611688f, -0.01101408f, -0.03396463f, 
    0.05145971f, 0.06201196f, 0.01789495f, -0.00275669f, -0.01702987f, -0.12836842f, -0.04946709f, -0.03342996f, 
    0.10493474f, 0.07088574f, 0.02076236f, 0.01210804f, 0.01406198f, 0.00932913f, 0.00545102f, 0.00081905f, 
    0.02039388f, 0.05890050f, -0.06547976f, -0.00887552f, 0.03686939f, 0.06893063f, -0.03951152f, -0.06193973f, 
    -0.03859568f, 0.02316090f, -0.09338898f, -0.00675798f, 0.15686855f, 0.01936832f, -0.05545600f, 0.01040275f, 
    0.04455376f, -0.10694448f, -0.06026770f, -0.02793989f, -0.01709847f, 0.00831890f, 0.00980511f, -0.05175206f, 
    -0.04482353f, -0.02349749f, 0.01253568f, 0.03003595f, -0.02180725f, -0.08257053f, 0.02272706f, 0.00830271f, 
    0.18524837f, -0.07323200f, 0.02150746f, -0.21303724f, -0.11032850f, 0.03428665f, -0.06423007f, 0.11499607f, 
    -0.00257200f, -0.02116528f, -0.04468147f, 0.07488447f, 0.06509925f, -0.05574169f, 0.01280407f, 0.04535569f, 
    -0.06271508f, 0.10937665f, 0.07971232f, -0.03107986f, 0.05256757f, 0.03194825f, -0.02583057f, -0.10981610f, 
    -0.01137259f, 0.03397469f, 0.03942591f, 0.09427847f, -0.00811678f, -0.02599907f, -0.01473597f, -0.00248279f, 
    0.05631926f, -0.02434378f, 0.00019778f, 0.01248329f, -0.02014345f, 0.02188407f, 0.00725594f, -0.01012744f, 
    0.15341538f, -0.01006204f, 0.00251849f, -0.05171851f, -0.08727571f, -0.01443615f, -0.00941084f, -0.08787712f, 
    -0.00447924f, 0.05294289f, -0.05137575f, 0.03675294f, 0.01319598f, -0.04481099f, 0.03490473f, -0.02311353f, 
    -0.03165432f, 0.10103931f, 0.04348646f, 0.04463966f, 0.00842207f, 0.01778318f, -0.10507310f, -0.17232652f, 
    0.06744967f, 0.05083095f, 0.00159917f, 0.08094517f, -0.04027318f, -0.00958977f, -0.08052277f, 0.01017267f, 
    -0.02930909f, 0.02507680f, -0.01182330f, -0.02496968f, 0.02631740f, -0.00722024f, -0.12037902f, 0.01544649f, 
    0.14874955f, -0.03149183f, -0.12327028f, 0.00978608f, -0.03507208f, -0.02012007f, 0.08190996f, 0.07008998f, 
    -0.00654860f, 0.01705932f, -0.01498851f, 0.03729482f, -0.08762328f, 0.03137840f, -0.02978883f, -0.04043896f, 
    0.05618713f, -0.00975234f, -0.03535040f, -0.02215656f, 0.07281979f, -0.19707388f, -0.00184139f, -0.08062885f, 
    0.07588723f, -0.05293351f, -0.02179700f, -0.07667562f, -0.00928216f, 0.01722861f, 0.01431308f, -0.01013565f, 
    0.03968874f, 0.03445106f, 0.01715261f, -0.08047715f, 0.00517706f, 0.02688906f, 0.00049569f, -0.00964338f, 
    -0.03737923f, -0.24783798f, 0.06235919f, -0.19068331f, 0.00022017f, 0.03174726f, -0.09097606f, -0.04212256f, 
    -0.00107572f, 0.08332273f, -0.08282579f, 0.04832099f, 0.00021880f, 0.00781388f, -0.04888122f, 0.02536210f, 
    -0.09193853f, -0.00546674f, -0.06343582f, -0.10283313f, -0.14403743f, -0.08718498f, -0.10659318f, -0.02783296f, 
    -0.08610065f, -0.01959006f, 0.05774780f, -0.06549973f, -0.00525819f, -0.05211720f, -0.02836951f, 0.03315254f, 
    0.05114350f, -0.02794857f, -0.06348130f, 0.01763962f, 0.01846945f, 0.00821690f, -0.04725574f, -0.06768201f, 
    0.04311809f, -0.18032449f, -0.13341023f, -0.07844666f, -0.24761927f, -0.00401869f, 0.04801202f, -0.05076592f, 
    0.07446890f, -0.05327998f, 0.02260017f, 0.02403336f, 0.01899298f, -0.00472729f, -0.03231790f, 0.00488709f, 
    -0.02585799f, -0.00116303f, 0.02750542f, -0.04767694f, 0.22147158f, 0.00840301f, -0.02982937f, 0.19653805f, 
    0.06234306f, -0.06610313f, -0.00626894f, 0.00875209f, 0.05829192f, 0.04509443f, -0.00619668f, 0.05990741f, 
    0.11001635f, 0.05381367f, 0.00839572f, 0.05602067f, -0.12750934f, -0.00208870f, 0.03256596f, -0.03446027f, 
    0.16992736f, 0.06256838f, -0.13584389f, 0.00147226f, -0.06322978f, -0.05873402f, 0.00602224f, 0.03838736f, 
    -0.03951708f, -0.04213216f, -0.06264585f, -0.02474252f, -0.00082756f, -0.01387147f, 0.02611949f, 0.01347524f, 
    -0.03569012f, -0.12193624f, -0.00009917f, 0.02603202f, 0.06204170f, 0.03051526f, 0.14437807f, 0.03074381f, 
    0.21733353f, -0.14267829f, -0.06563000f, -0.15745622f, 0.01610382f, 0.03129831f, 0.01290648f, -0.01840556f, 
    -0.04131543f, -0.08775823f, 0.07580011f, -0.01573381f, -0.03820745f, -0.08401962f, 0.00102771f, 0.04769709f, 
    -0.07067680f, -0.26908001f, -0.39185759f, 0.19911589f, 0.09414864f, -0.01199518f, 0.06231282f, 0.00334160f, 
    -0.07835116f, -0.07862863f, 0.02435609f, 0.04447287f, -0.06153851f, -0.00324768f, 0.01619585f, -0.04504389f, 
    0.00538482f, 0.03385719f, -0.03105900f, -0.09833014f, -0.29733658f, 0.21258974f, -0.07591820f, 0.21663010f, 
    0.14735897f, 0.00692927f, 0.07282962f, 0.08758345f, 0.03381500f, 0.02167879f, 0.03118212f, -0.02069775f, 
    -0.05353064f, -0.03604965f, -0.11132695f, 0.03170607f, -0.08320213f, 0.02622284f, 0.06812713f, -0.09629734f, 
    -0.26843515f, 0.14521174f, -0.04014670f, -0.13504115f, 0.02508058f, -0.04828150f, -0.10040323f, 0.04376588f, 
    -0.01048470f, 0.01591836f, -0.07411988f, -0.07189409f, 0.01383360f, -0.00986010f, 0.02460377f, 0.00884579f, 
    0.01396477f, -0.01141360f, 0.04355259f, 0.03100979f, 0.06412929f, 0.03602811f, -0.07459581f, 0.04963051f, 
    0.00817839f, -0.08094496f, -0.04649575f, 0.02035442f, -0.03932037f, 0.01482332f, -0.03219156f, -0.01776518f, 
    0.03875390f, -0.02373692f, 0.02221010f, -0.02030847f, -0.00905997f, 0.05847969f, -0.01660886f, -0.00041485f, 
    -0.04671573f, 0.01683323f, 0.07410759f, 0.01057702f, 0.11887001f, -0.02459861f, 0.04610853f, -0.03247254f, 
    0.00488548f, 0.08497820f, -0.05000041f, 0.03696252f, 0.06838954f, 0.03434867f, 0.06301986f, -0.06818336f, 
    0.01536013f, -0.06477895f, 0.01019369f, 0.04924360f, 0.10383154f, -0.08802687f, -0.02192738f, -0.06103510f, 
    -0.05516280f, -0.06594947f, -0.08142166f, 0.03700136f, -0.08113898f, -0.00506493f, -0.05023158f, 0.03577291f, 
    0.05415436f, 0.01546736f, 0.02578875f, -0.03740225f, -0.02550650f, 0.08181565f, -0.03141279f, 0.04796050f, 
    0.11833864f, -0.24193458f, 0.05055616f, -0.13130300f, -0.13393815f, -0.06832276f, -0.19634818f, -0.10921183f, 
    0.03078662f, 0.01676157f, 0.04150034f, -0.10835975f, 0.06886223f, -0.11162575f, 0.04844403f, -0.05991051f, 
    0.01330634f, 0.00871843f, 0.10812819f, 0.10955833f, 0.08933719f, 0.17473750f, 0.09646200f, 0.15633832f, 
    0.03793539f, 0.01032752f, 0.06785312f, -0.03495235f, 0.02506484f, 0.03333168f, 0.07565224f, -0.04421141f, 
    -0.04554918f, -0.05409105f, -0.03587113f, 0.03127150f, -0.05070613f, 0.08623831f, 0.04473525f, 0.05724877f, 
    0.06338423f, 0.08554472f, -0.14580622f, 0.07181875f, -0.14139298f, -0.05035541f, 0.09656242f, -0.03033604f, 
    -0.02530931f, -0.04712049f, 0.03779953f, 0.02329379f, 0.01426115f, -0.00432294f, 0.01579396f, -0.02610983f, 
    -0.02475786f, -0.02323629f, -0.01849678f, 0.01767856f, 0.00262045f, -0.12721223f, -0.02219562f, 0.02093121f, 
    0.05096886f, 0.01953046f, 0.13284342f, 0.00359386f, 0.05385857f, -0.08979602f, -0.06790268f, 0.04170476f, 
    -0.04698608f, -0.00834006f, 0.01781084f, -0.05704540f, -0.03612739f, -0.01928581f, -0.00420435f, -0.00102146f, 
    -0.23336026f, 0.11051726f, -0.03446174f, 0.08931573f, 0.03421647f, 0.03425795f, 0.06317646f, -0.00618824f, 
    0.08442063f, -0.04896790f, -0.02916423f, 0.04840051f, -0.05996606f, -0.05130104f, 0.06233294f, -0.00665935f, 
    -0.04470366f, -0.04284066f, 0.01892018f, 0.00197374f, -0.00034798f, 0.03930968f, 0.01735999f, 0.02817857f, 
    0.00051522f, -0.05093727f, 0.06255110f, -0.01514797f, -0.02177758f, 0.00379183f, 0.05457895f, 0.00281940f, 
    -0.01772329f, -0.00749202f, 0.00391247f, 0.02739095f, 0.02513208f, -0.00404641f, 0.01227478f, -0.01999387f, 
    0.02038771f, -0.01124017f, -0.21993268f, -0.01780111f, 0.01615200f, -0.10776205f, -0.03746733f, -0.04275076f, 
    0.05625942f, 0.05187509f, -0.04636108f, -0.10242804f, 0.02331765f, 0.04493143f, 0.02959251f, -0.05388075f, 
    -0.05663092f, -0.02194785f, -0.02349877f, 0.02389747f, 0.36558384f, 0.11279327f, -0.01841297f, 0.17719992f, 
    0.01194217f, 0.02794003f, 0.03847615f, -0.01736561f, 0.06327798f, -0.01213982f, -0.07186372f, -0.00279313f, 
    -0.03560506f, 0.01368997f, -0.07471810f, -0.04224327f, 0.05186681f, 0.10143827f, 0.01346422f, -0.07594463f, 
    0.04892019f, -0.00757335f, 0.07178752f, -0.00109911f, -0.00075170f, -0.00661292f, -0.08564949f, 0.00757841f, 
    -0.00558957f, 0.00767431f, -0.04977475f, -0.00390927f, -0.04770854f, 0.02790380f, -0.02009177f, 0.00608580f, 
    0.00766184f, -0.02791515f, -0.05964727f, -0.00621451f, -0.00073107f, 0.00154655f, -0.09333809f, -0.02146688f, 
    -0.18716322f, 0.01555465f, -0.02900668f, -0.00238992f, -0.07600555f, 0.00633917f, -0.04986828f, 0.02932724f, 
    0.02057789f, -0.00039535f, -0.02496460f, 0.00142268f, -0.07125331f, -0.00396406f, -0.02053458f, 0.03988968f, 
    0.18376361f, 0.11509890f, -0.23536238f, 0.03825215f, 0.05242646f, -0.06169474f, -0.00124326f, -0.01514473f, 
    0.00931989f, 0.08460152f, 0.03647478f, -0.08308172f, 0.00470952f, 0.06378756f, 0.00198289f, -0.06168453f, 
    0.03172930f, 0.02323569f, 0.00382224f, 0.00262802f, 0.00874542f, -0.41257077f, -0.27848971f, 0.10099614f, 
    0.08030328f, 0.02311403f, 0.07026498f, 0.03115851f, 0.01379911f, -0.08880346f, 0.03665109f, 0.02082568f, 
    -0.02602935f, -0.04949623f, -0.04487177f, -0.02421400f, 0.03752680f, 0.03023793f, -0.02886515f, -0.00888378f, 
    0.07721762f, 0.04197247f, -0.06493548f, 0.02770063f, -0.03307894f, -0.04183451f, 0.01071523f, 0.01128792f, 
    0.00869266f, 0.00151488f, -0.05281161f, -0.00858781f, -0.03448130f, -0.01392364f, 0.02064690f, 0.01700047f, 
    -0.00080614f, 0.06793185f, -0.01813679f, -0.02847522f, -0.17261304f, 0.34149346f, 0.09285131f, -0.03042414f, 
    -0.12771675f, 0.00315810f, 0.02191676f, -0.08586811f, 0.06938943f, -0.04024590f, -0.00204005f, -0.01156548f, 
    -0.08928922f, 0.01341758f, -0.06585948f, -0.05627219f, -0.01951909f, -0.08537930f, 0.10596924f, -0.00766613f, 
    -0.15715685f, -0.10175237f, -0.03824747f, 0.01177765f, -0.06854509f, -0.03110026f, -0.02129724f, 0.05930037f, 
    -0.07823955f, 0.07183598f, -0.07124100f, -0.03619969f, 0.06182149f, 0.05221099f, 0.00519437f, 0.06119465f, 
    0.01136517f, 0.01848406f, 0.03683307f, 0.03919916f, -0.28255737f, -0.31891733f, -0.11087189f, -0.12642981f, 
    0.17973542f, -0.06390624f, 0.10110924f, -0.01771882f, 0.05415650f, -0.00789154f, -0.00245022f, 0.01850322f, 
    0.02459879f, -0.06747769f, -0.02040457f, -0.01974580f, -0.00691183f, -0.07015433f, 0.00894723f, -0.01910363f, 
    0.16604701f, -0.07324383f, 0.06890284f, 0.06373212f, -0.03396144f, -0.07369595f, -0.01138506f, 0.00498282f, 
    -0.15929057f, -0.04245178f, -0.05069514f, -0.02676485f, 0.01594941f, 0.04792977f, 0.02384933f, 0.00190624f, 
    0.04484579f, 0.00335258f, 0.02285586f, 0.01859547f, 0.02764940f, 0.25852540f, 0.01592306f, 0.09075726f, 
    -0.00316960f, -0.01799954f, -0.02588901f, 0.00922155f, 0.04707341f, -0.02770638f, -0.01666676f, -0.03591185f, 
    -0.06210724f, 0.03606170f, -0.04277873f, 0.00708451f, -0.02461882f, 0.02605253f, 0.13135710f, 0.01492926f, 
    0.13930555f, 0.10111511f, 0.22296472f, 0.00825415f, 0.14397497f, -0.05695047f, 0.12985955f, -0.01512657f, 
    -0.00231051f, 0.04427344f, 0.06210160f, -0.01346020f, -0.10920313f, -0.05462181f, -0.08374505f, 0.01122481f, 
    0.09999602f, -0.03822216f, 0.07269615f, 0.03101415f, -0.09159575f, -0.06183340f, -0.11496900f, -0.08551329f, 
    -0.05659194f, -0.07464592f, -0.11982886f, 0.10619546f, -0.06137528f, 0.04088984f, -0.04224696f, -0.00950842f, 
    0.05047701f, -0.05962084f, 0.04760739f, 0.00123049f, -0.03482993f, 0.03742132f, 0.08080708f, -0.01222208f, 
    -0.05693203f, 0.10065142f, 0.07950054f, 0.05442769f, -0.04084871f, -0.00498553f, -0.09841903f, -0.02542160f, 
    -0.04131987f, -0.09407511f, -0.01002804f, -0.00669123f, -0.04396687f, 0.00227064f, 0.07225382f, 0.06588909f, 
    -0.00163910f, -0.03821344f, 0.08243416f, 0.02117707f, 0.12061420f, -0.04219428f, 0.05963850f, 0.02540031f, 
    0.05748382f, -0.02142918f, 0.01753831f, 0.02850197f, -0.01681094f, 0.01536414f, 0.07118110f, -0.04639428f, 
    -0.03736474f, -0.10788674f, -0.04803246f, 0.00548823f, -0.01311579f, 0.05187628f, -0.02682747f, 0.04738494f, 
    -0.03330998f, -0.35231102f, -0.00958381f, -0.02668975f, -0.05779847f, -0.08700492f, -0.02176186f, 0.05986169f, 
    -0.00022583f, -0.01620116f, -0.00375090f, 0.07949386f, -0.00729551f, -0.02515425f, -0.00871828f, -0.03000954f, 
    0.05302754f, -0.09924379f, 0.06847043f, 0.00717190f, -0.24637394f, -0.18855917f, -0.16288389f, 0.10315886f, 
    -0.00136504f, -0.03730085f, -0.07351799f, -0.10026795f, 0.02759392f, -0.00425406f, -0.01620564f, -0.06225503f, 
    0.04243159f, 0.04973304f, 0.01776953f, 0.02080418f, -0.01089926f, 0.00312978f, -0.01747535f, 0.05184208f, 
    0.12800145f, -0.16802950f, -0.18150216f, 0.26305044f, 0.10507876f, 0.08358446f, 0.08523154f, -0.03878106f, 
    0.06205710f, -0.02654895f, -0.07093883f, 0.02697525f, -0.24017876f, -0.07240322f, 0.00509301f, -0.02735744f, 
    0.00005568f, 0.13285558f, -0.06175367f, -0.06087350f, -0.32870534f, -0.41181019f, -0.17715561f, -0.10951957f, 
    -0.15746145f, -0.08693993f, -0.13261113f, 0.03226630f, 0.00500817f, -0.07787317f, -0.01113275f, -0.01167807f, 
    -0.02352646f, -0.03584672f, 0.05676321f, 0.02347947f, -0.08111393f, 0.03307283f, -0.08976080f, -0.00658101f, 
    0.28379032f, 0.04415680f, -0.03260230f, -0.00730354f, -0.04880264f, -0.01210826f, 0.00147990f, -0.02955222f, 
    0.01624068f, -0.02727114f, -0.08317409f, 0.01319907f, -0.04023431f, 0.09121113f, -0.03249922f, -0.03502466f, 
    -0.00206219f, -0.05224928f, 0.02875886f, 0.02897377f, 0.02319130f, -0.59197897f, -0.32361409f, 0.02224254f, 
    0.13811485f, -0.02394822f, 0.06100211f, 0.03904087f, -0.00249877f, -0.05087031f, 0.07835807f, 0.06327661f, 
    0.03074578f, -0.03951935f, -0.01525760f, 0.00699220f, 0.01682999f, 0.02287449f, 0.01840000f, -0.04254723f, 
    0.09153352f, -0.23674031f, -0.03092124f, -0.01347630f, 0.04893910f, -0.05140454f, -0.03959405f, 0.01423589f, 
    -0.06430775f, -0.02124616f, -0.06609833f, 0.01956588f, 0.01049821f, 0.02111302f, 0.02005269f, 0.04259041f, 
    0.03795982f, 0.03843774f, -0.00208289f, 0.06848334f, 0.01280519f, -0.08589790f, 0.08328719f, 0.00974064f, 
    0.00935482f, -0.00882438f, -0.00381552f, 0.00291390f, -0.08578403f, -0.07054885f, 0.00947145f, -0.02183245f, 
    0.02472539f, 0.04714264f, 0.04065268f, 0.02574135f, -0.02925365f, -0.06306514f, 0.01296213f, -0.08532713f, 
    -0.01109747f, -0.01047880f, 0.00288197f, 0.24309924f, 0.08677933f, 0.09736970f, 0.14626616f, 0.05385045f, 
    0.00218424f, -0.00421923f, -0.06951455f, 0.05129583f, -0.01392144f, -0.15308340f, -0.12257479f, 0.01742708f, 
    0.01678728f, 0.08508018f, -0.00287278f, -0.06505783f, -0.24806386f, 0.19465750f, 0.06790931f, 0.12961644f, 
    0.04991058f, 0.08009605f, 0.01511094f, 0.04822322f, 0.01017315f, 0.06773489f, -0.06727736f, -0.03291289f, 
    0.02505755f, -0.03137222f, -0.04919884f, -0.03479228f, 0.03755660f, -0.05926988f, 0.08485183f, -0.04547392f, 
    -0.22072975f, 0.02816715f, -0.00690788f, 0.10795426f, 0.01273651f, -0.00845993f, 0.00682073f, -0.05894412f, 
    0.00759059f, 0.00135505f, -0.06390258f, 0.06366728f, -0.03361659f, 0.01041034f, 0.04827885f, -0.00272424f, 
    0.09044866f, -0.00676137f, -0.05573689f, -0.06977099f, 0.10359569f, 0.00736697f, -0.05725889f, -0.00747499f, 
    -0.01740777f, -0.12014578f, -0.07572175f, -0.02970645f, 0.01776402f, 0.02840756f, -0.03652170f, -0.05001705f, 
    0.08775698f, -0.00394845f, 0.05741241f, -0.06574990f, 0.01659545f, 0.02324298f, 0.03634702f, 0.03914092f, 
    -0.03500006f, -0.00256202f, 0.02424758f, -0.00901282f, -0.02996707f, -0.01226483f, -0.08849750f, 0.05282209f, 
    -0.03427526f, -0.02367389f, -0.02451526f, 0.06035789f, -0.03328416f, 0.02591376f, 0.06487022f, 0.00845748f, 
    0.01710658f, 0.03236270f, 0.05507736f, -0.05252970f, 0.20994239f, 0.17146528f, 0.11970282f, 0.08147646f, 
    -0.00991173f, -0.05270808f, 0.00327993f, 0.04465038f, -0.06366232f, -0.06413956f, 0.01915654f, 0.02665621f, 
    0.01426478f, -0.04006404f, -0.01828909f, 0.10371964f, -0.08152965f, 0.18223163f, 0.03111450f, 0.08170006f, 
    -0.29239148f, -0.35174575f, -0.17260155f, -0.02452882f, -0.02199877f, -0.07590808f, -0.02443775f, -0.00383322f, 
    0.01244690f, -0.04493379f, -0.00693221f, -0.02420091f, 0.05718622f, 0.01508226f, -0.00873269f, 0.06496799f, 
    -0.01467200f, -0.01459016f, -0.00680207f, -0.01551945f, -0.05005091f, 0.40202850f, 0.09671531f, 0.11728118f, 
    0.08654906f, 0.14474975f, 0.01043459f, 0.04660763f, -0.02010855f, -0.09655154f, -0.09645966f, -0.07424809f, 
    0.02890464f, 0.01748767f, 0.06458320f, -0.03668638f, 0.03842924f, -0.04946203f, 0.07977697f, -0.00251457f, 
    0.06172762f, -0.02300478f, -0.03742819f, 0.03623898f, -0.07108672f, -0.08376994f, -0.06316221f, -0.01253765f, 
    0.02130216f, 0.00945606f, 0.01323451f, -0.02019796f, 0.00830991f, 0.00371389f, -0.01835028f, -0.02840885f, 
    -0.01181835f, -0.06660068f, 0.00579841f, -0.01712091f, 0.23530622f, 0.12128635f, 0.00383288f, -0.00661926f, 
    -0.08640737f, -0.01390439f, 0.00802844f, -0.05123821f, -0.00215958f, -0.10979418f, -0.00416018f, 0.02831283f, 
    -0.00164151f, -0.08713168f, 0.02125524f, -0.05157290f, -0.02152414f, 0.02843776f, -0.03652825f, -0.03172325f, 
    -0.05342956f, 0.05540622f, -0.10290936f, -0.09450232f, -0.18149339f, -0.01025966f, 0.05572613f, -0.06171909f, 
    -0.03986041f, -0.04818640f, -0.07141939f, 0.03276430f, -0.01545356f, 0.02735272f, -0.01755868f, 0.03715931f, 
    -0.00330368f, 0.04117243f, -0.12932490f, 0.11874476f, -0.08004750f, -0.10241108f, -0.03134513f, -0.04719130f, 
    -0.06244085f, -0.02355982f, -0.05609310f, 0.00168571f, -0.01122672f, -0.06819475f, -0.05662743f, -0.02732811f, 
    0.04069836f, -0.01291858f, -0.00732486f, -0.03580886f, -0.01135522f, -0.02656068f, -0.04211403f, -0.00111453f, 
    -0.13105685f, 0.19255713f, 0.06802420f, 0.11264637f, 0.03575775f, -0.01008260f, -0.03905026f, 0.02832513f, 
    0.03519753f, 0.03917890f, 0.00410009f, -0.01137056f, 0.02178003f, 0.00047650f, -0.02810184f, 0.00102834f, 
    0.01723031f, -0.01401325f, 0.08378082f, 0.00724914f, -0.43055400f, 0.20164691f, 0.00657967f, 0.04086787f, 
    0.12979443f, 0.03745965f, 0.05009881f, -0.01011061f, 0.02761961f, -0.08695702f, -0.08431008f, -0.02637919f, 
    0.02451067f, 0.02121086f, 0.07730852f, -0.03810323f, 0.02012372f, -0.12876339f, 0.04629392f, -0.00203210f, 
    -0.18166897f, 0.05138662f, -0.01823577f, -0.11877643f, -0.17991118f, -0.07786616f, -0.05479752f, -0.01512568f, 
    0.06506912f, 0.01125912f, -0.00896811f, -0.09254053f, -0.03681886f, -0.00333956f, -0.07274986f, 0.02033010f, 
    -0.03563925f, -0.00105998f, -0.00471912f, 0.08010610f, -0.18496783f, 0.08715506f, 0.05978440f, -0.10032740f, 
    -0.11436222f, 0.00076265f, -0.03495562f, -0.00731539f, -0.03031078f, -0.03612360f, -0.03025050f, -0.01482686f, 
    -0.08207867f, -0.00813790f, -0.01816267f, -0.00738838f, -0.02709961f, -0.08551069f, -0.00448906f, -0.02475760f, 
    0.05821960f, -0.08571220f, -0.14814292f, 0.04279525f, 0.04741219f, -0.04545894f, -0.05297499f, 0.05100155f, 
    0.03846672f, 0.02934885f, -0.02542765f, 0.01277719f, 0.01460767f, -0.02714408f, 0.03720989f, -0.06371021f, 
    0.04161530f, 0.00988571f, -0.00600636f, 0.00819546f, -0.15366714f, -0.15498266f, -0.13522980f, -0.08370375f, 
    0.16475953f, -0.07399052f, 0.01843271f, -0.02603049f, 0.04317287f, 0.00961134f, 0.02879862f, 0.05993758f, 
    -0.00807442f, -0.01040630f, 0.01531232f, -0.05862678f, 0.00460604f, -0.06550965f, 0.01457307f, 0.06643332f, 
    0.07640998f, 0.16105218f, 0.03574760f, 0.01453439f, -0.01075824f, 0.12404844f, 0.05040194f, 0.00004058f, 
    0.09502513f, -0.04229200f, -0.05293566f, 0.06278518f, -0.02616872f, -0.00655674f, -0.03141833f, 0.01360599f, 
    -0.02798213f, 0.01911164f, -0.07675558f, -0.06034559f, -0.29741257f, -0.04176645f, -0.28530452f, -0.07493173f, 
    0.12120504f, -0.08840443f, 0.02480315f, -0.02815391f, -0.03574776f, 0.04669558f, -0.04944127f, -0.03611784f, 
    0.12573770f, 0.08530151f, -0.01973184f, -0.00725396f, -0.05104730f, -0.07420416f, 0.02516753f, 0.09863546f, 
    0.30093253f, -0.03590595f, -0.06041503f, 0.04098610f, -0.00210192f, 0.05753356f, -0.10011432f, 0.00981595f, 
    0.11731248f, -0.05819987f, 0.06486478f, 0.04030966f, 0.03796058f, 0.02701549f, -0.07742973f, -0.08372359f, 
    0.06001964f, -0.01292565f, 0.09243804f, -0.00472949f, 0.08949767f, 0.03302233f, -0.10208275f, 0.05018620f, 
    0.02438819f, -0.06524545f, -0.06351258f, -0.03401327f, 0.11142374f, -0.05778624f, 0.00728526f, -0.02530439f, 
    -0.00641205f, -0.05572025f, 0.04252745f, -0.09220945f, -0.08291882f, 0.04008586f, -0.00802641f, -0.01270040f, 
    -0.16952732f, -0.15830453f, -0.05113328f, -0.00760457f, -0.03442478f, -0.02051367f, 0.00063299f, -0.00745096f, 
    -0.03757181f, 0.06434427f, -0.05554819f, -0.02037420f, 0.05538559f, 0.07916892f, -0.01092754f, 0.08862723f, 
    -0.03714839f, -0.01549952f, -0.02901193f, 0.04528255f, 0.08615727f, 0.13062252f, 0.02281773f, 0.20224656f, 
    0.09034715f, 0.04420263f, 0.12260018f, -0.03329392f, 0.00169895f, 0.08341998f, -0.04711458f, 0.06249774f, 
    -0.07030746f, -0.08724087f, -0.02851148f, -0.00009610f, 0.07391793f, 0.01647880f, 0.05404078f, -0.03448356f, 
    0.04298643f, 0.15076129f, 0.14352904f, 0.20676138f, 0.06190499f, -0.01930057f, -0.06405323f, -0.02311311f, 
    -0.06518147f, -0.01667427f, -0.05098671f, -0.01745695f, -0.00969724f, 0.03237184f, -0.00181114f, 0.01328591f, 
    0.00731841f, 0.08964769f, 0.07024886f, 0.00085807f, 0.07784586f, -0.22568880f, 0.12130193f, -0.02893553f, 
    -0.04425571f, -0.04633002f, -0.01392164f, 0.01089712f, -0.02784126f, 0.01357729f, -0.07013718f, 0.04864629f, 
    -0.02822345f, -0.03019399f, 0.06769649f, -0.00830788f, 0.07553915f, 0.05456148f, -0.00304356f, 0.02987295f, 
    -0.26201618f, 0.11084339f, 0.06500627f, -0.12178425f, -0.10801979f, 0.00296007f, -0.10863749f, -0.01151385f, 
    -0.00794017f, -0.09671377f, 0.04557752f, -0.01411377f, -0.05789234f, 0.04901654f, 0.00501846f, -0.02725836f, 
    -0.02528955f, -0.13546979f, 0.00718081f, -0.03209781f, 0.08578631f, -0.03943835f, -0.13697322f, -0.07800996f, 
    -0.01701415f, -0.02650550f, -0.05426158f, -0.05023587f, 0.02382353f, -0.09662041f, -0.07127818f, 0.05827987f, 
    -0.00342567f, -0.03166403f, 0.01015781f, -0.03595505f, -0.02750653f, 0.05050690f, -0.09971642f, 0.02680090f, 
    0.01510455f, -0.08931738f, -0.05624649f, -0.10704155f, 0.09723599f, 0.02274882f, 0.00962438f, -0.04770526f, 
    -0.11543554f, -0.08760836f, 0.08189212f, 0.04600230f, -0.02134506f, -0.04415616f, -0.18282065f, 0.08933246f, 
    -0.06547262f, -0.10822069f, -0.11804665f, -0.10521834f, -0.25227219f, -0.26678321f, 0.15600622f, 0.14758523f, 
    0.02867511f, -0.06394008f, -0.06810207f, -0.03301251f, -0.07594128f, -0.02561289f, 0.03708138f, 0.01597701f, 
    0.08749475f, -0.05522427f, -0.09266129f, 0.03091455f, -0.04984968f, 0.02840050f, 0.02380912f, -0.02916069f, 
    0.15809983f, -0.07323418f, -0.11005200f, 0.05041389f, 0.16361281f, 0.07619075f, 0.03103678f, 0.12236263f, 
    -0.01468905f, 0.00352758f, 0.01679283f, -0.02269650f, 0.07905984f, 0.04379841f, -0.03700031f, -0.06099158f, 
    0.00135905f, -0.03540706f, 0.10357036f, -0.08177866f, -0.16155373f, -0.01893868f, -0.14139448f, 0.07392435f, 
    0.11543429f, 0.09539270f, -0.03992432f, 0.05308054f, 0.08416136f, 0.07155450f, 0.03456205f, 0.05540058f, 
    -0.02387819f, -0.08824316f, 0.02824540f, 0.04127248f, -0.00644716f, 0.01861362f, 0.03880711f, 0.05236835f, 
    -0.07254822f, 0.01538427f, 0.20643000f, -0.04926609f, -0.01669735f, 0.00378828f, 0.03830048f, -0.01469876f, 
    -0.01686528f, -0.12034600f, 0.03896230f, 0.02963020f, -0.00389349f, -0.05441508f, 0.00299813f, -0.01714191f, 
    -0.03906908f, -0.05087133f, -0.12623718f, 0.02832993f, -0.27219546f, 0.14203617f, -0.13687195f, 0.05194275f, 
    0.14644343f, 0.07589919f, -0.04662898f, 0.01184324f, 0.04348150f, 0.04616340f, 0.00099801f, -0.06120039f, 
    0.04611131f, 0.02938283f, -0.03377450f, -0.02199395f, 0.00089383f, 0.03715113f, -0.00109920f, 0.01152526f, 
    -0.32969803f, 0.01837727f, -0.21602881f, -0.05488812f, 0.22570081f, -0.04041858f, -0.00706337f, -0.05065191f, 
    0.05974520f, -0.04365963f, 0.06612281f, -0.03818082f, -0.08653303f, 0.07144621f, 0.07546032f, 0.03033713f, 
    0.01241772f, 0.02248989f, 0.01614886f, -0.01056058f, -0.10523848f, 0.18666071f, -0.15391405f, 0.23191090f, 
    -0.27769962f, -0.09250473f, -0.05163275f, -0.03736776f, -0.07719751f, -0.11619320f, 0.09707868f, -0.06589244f, 
    -0.00512479f, 0.01624649f, -0.08722363f, -0.05254429f, 0.03882793f, 0.02825244f, -0.06040390f, 0.00744065f, 
    -0.29903576f, 0.14094917f, -0.01860821f, -0.12201405f, -0.14200804f, 0.04297354f, -0.01517780f, -0.07853545f, 
    -0.15165450f, -0.00051682f, 0.02904189f, -0.05240235f, -0.06166517f, -0.02330257f, -0.00177373f, 0.05547392f, 
    0.00288689f, -0.06768176f, -0.01870683f, -0.04078524f, -0.19327328f, -0.01806507f, 0.11321256f, -0.17042905f, 
    -0.14651892f, 0.07644148f, 0.04760046f, -0.03030576f, -0.04353395f, 0.02574115f, 0.06088452f, 0.00696033f, 
    0.01278066f, -0.10058657f, -0.01681415f, 0.06649263f, -0.00107522f, -0.07045726f, -0.04667731f, 0.03173596f, 
    -0.35899055f, 0.10569759f, 0.05163316f, -0.21059205f, -0.13573782f, -0.01997069f, 0.04818740f, -0.04512132f, 
    -0.01762018f, 0.01361695f, -0.00861742f, -0.03651166f, 0.07377594f, -0.02041023f, 0.03919949f, -0.02932055f, 
    0.03243535f, 0.00124998f, 0.05860290f, -0.05072908f, -0.12735724f, 0.22917867f, 0.00377494f, 0.10914050f, 
    -0.07582468f, 0.04292377f, -0.08394249f, 0.00906130f, 0.01619206f, -0.10882226f, -0.00866910f, -0.02420522f, 
    -0.05373577f, 0.02890026f, 0.00165317f, -0.06972045f, -0.06982674f, 0.03500599f, -0.10912815f, 0.05524741f, 
    0.02865152f, -0.05771550f, -0.13025837f, 0.04574210f, -0.11490025f, 0.06610000f, 0.02315120f, 0.03797484f, 
    0.04796585f, 0.04730622f, 0.01227708f, -0.09133047f, -0.02142863f, -0.00048140f, 0.01861912f, 0.06960703f, 
    0.06946228f, -0.06848199f, -0.06741212f, 0.00785257f, -0.35206598f, -0.12200256f, 0.10704252f, -0.04105929f, 
    -0.05638472f, -0.12035733f, 0.01776592f, -0.08894406f, 0.05164102f, 0.00073397f, -0.04399897f, -0.11972208f, 
    0.00326874f, 0.01737908f, 0.09009178f, -0.10201494f, 0.03976043f, -0.01034645f, -0.03113041f, -0.00955398f, 
    -0.01612724f, 0.03305015f, -0.07834043f, -0.03784713f, 0.06993870f, -0.01723606f, -0.00274901f, -0.01058354f, 
    0.07124524f, -0.01263614f, 0.02240073f, -0.04939737f, -0.01470669f, 0.03321294f, -0.06641636f, -0.10989689f, 
    0.00035901f, -0.09291655f, 0.02222556f, -0.00496047f, -0.27187437f, 0.17079046f, 0.06660264f, 0.09817740f, 
    0.00807480f, 0.10681112f, -0.05842505f, 0.05323066f, -0.09351812f, 0.09925959f, -0.05626037f, 0.05325557f, 
    0.05823520f, -0.02513397f, 0.03551420f, 0.09856514f, -0.00968159f, -0.04036742f, 0.01913803f, -0.04772790f, 
    -0.02015020f, 0.04348690f, 0.10289748f, 0.10925281f, -0.15498094f, 0.02350664f, -0.03552901f, 0.00846452f, 
    0.02231151f, 0.08238183f, -0.05511644f, -0.02378161f, 0.00774237f, 0.01468932f, 0.07400440f, -0.02577135f, 
    0.02492169f, -0.02274317f, -0.05376691f, 0.03901425f, -0.11000758f, -0.01459031f, 0.14537756f, 0.07272341f, 
    0.02201562f, -0.01442088f, 0.04959355f, -0.06613716f, -0.01075591f, 0.04069518f, 0.02836825f, 0.08220489f, 
    0.00754898f, 0.02379068f, -0.02478379f, -0.07370573f, 0.06254932f, -0.01694740f, 0.05250147f, 0.04726369f, 
    -0.10385538f, 0.03033890f, -0.00808701f, 0.12990130f, 0.07124636f, 0.01015841f, -0.03644439f, 0.02274498f, 
    0.04949667f, -0.03526235f, 0.02838426f, -0.00701351f, 0.00795194f, -0.00418983f, 0.02806668f, 0.07068764f, 
    -0.01291104f, 0.03455440f, 0.00830540f, 0.12074843f, -0.08398744f, 0.30326614f, 0.04314322f, 0.00190818f, 
    -0.10740124f, 0.08056977f, -0.03094916f, 0.11769509f, -0.03918909f, -0.06374201f, -0.03229439f, -0.03971662f, 
    -0.07432197f, -0.00559498f, 0.02857681f, -0.03855848f, 0.06516857f, -0.08648548f, -0.01734729f, -0.07959801f, 
    -0.29356033f, 0.06289340f, 0.15421072f, 0.10406341f, 0.00895431f, 0.01373019f, -0.06066440f, 0.00961553f, 
    0.04522474f, -0.03321381f, -0.14732790f, -0.07284173f, 0.01952028f, 0.10575872f, 0.04472557f, -0.03737511f, 
    0.03146633f, 0.05999842f, 0.07099549f, -0.01047085f, -0.01759471f, -0.33351451f, 0.06120770f, 0.00858343f, 
    -0.07010274f, -0.05665359f, -0.04266355f, 0.12949948f, -0.02990459f, 0.04131839f, 0.02831315f, 0.02524645f, 
    -0.07242565f, -0.08463433f, -0.03617991f, 0.06944333f, -0.02526562f, -0.00201163f, 0.05313128f, 0.06051439f, 
    0.23869336f, 0.07195289f, -0.12119958f, 0.04044657f, 0.15385176f, -0.01466560f, 0.09993518f, -0.06351430f, 
    -0.03162916f, 0.06917778f, 0.04650527f, 0.11126399f, -0.07749908f, -0.02495818f, -0.02288476f, -0.11539437f, 
    -0.09933519f, -0.03982330f, -0.00816918f, -0.08771272f, -0.21472143f, 0.01631360f, 0.13433319f, -0.14967988f, 
    -0.17994000f, 0.06784384f, -0.02316736f, -0.01317144f, -0.04413750f, 0.03190367f, 0.02938383f, -0.01364147f, 
    -0.06162850f, 0.02337826f, 0.03853898f, -0.01169799f, -0.00783827f, 0.00807238f, 0.06036137f, -0.00390429f, 
    0.05571056f, 0.22879376f, -0.16220959f, 0.08102639f, -0.25153396f, -0.10149194f, -0.04921032f, 0.02083872f, 
    -0.02169125f, -0.10362298f, -0.01324755f, 0.00399421f, 0.02993811f, -0.00082231f, 0.01330180f, -0.04834606f, 
    0.05158998f, 0.10116237f, 0.01256380f, 0.08825730f, -0.43512318f, -0.05124757f, -0.02788936f, 0.12506235f, 
    0.15040404f, 0.09191641f, -0.01819613f, 0.10477947f, 0.01752460f, 0.15737480f, -0.00483495f, 0.02610832f, 
    0.06145208f, 0.02167907f, 0.01785937f, 0.00305671f, -0.03734902f, 0.03774160f, 0.10587902f, -0.08892374f, 
    -0.46618566f, 0.00497749f, -0.03048967f, -0.02121596f, 0.05361177f, -0.00620122f, 0.06052396f, 0.02850930f, 
    0.13857242f, 0.05388641f, -0.07347748f, -0.09673434f, 0.03744582f, 0.07397008f, -0.01043792f, -0.05029384f, 
    0.17621191f, 0.00687690f, -0.02052429f, -0.08141410f, -0.02420517f, -0.18822002f, -0.13191296f, 0.04793021f, 
    -0.10750345f, -0.01188511f, -0.01042184f, 0.00809980f, -0.07808504f, -0.08202710f, -0.03898647f, 0.06861378f, 
    0.03635599f, -0.02203883f, 0.05875719f, -0.06107832f, -0.04682602f, 0.06529787f, -0.00786487f, 0.04878869f, 
    0.09884338f, -0.27611709f, -0.04925750f, 0.00421610f, -0.03556241f, -0.01975808f, 0.04057804f, 0.09310300f, 
    -0.07130576f, -0.06141198f, -0.00954860f, 0.00343335f, -0.08558379f, -0.03743995f, 0.03748348f, 0.02624260f, 
    -0.05587660f, -0.01814247f, -0.05877367f, -0.02537415f, -0.11540417f, 0.23782423f, 0.00365365f, -0.13313730f, 
    -0.05566743f, 0.01431476f, -0.02102732f, -0.05936420f, 0.02186703f, 0.08904515f, 0.01826759f, -0.01383313f, 
    0.03193327f, 0.00575932f, 0.04895521f, -0.02601823f, 0.04031982f, -0.06736904f, -0.06333463f, -0.00529284f, 
    -0.16876532f, -0.20089869f, 0.16629508f, 0.11134096f, -0.17263062f, -0.16601506f, 0.07512502f, -0.07928809f, 
    -0.00711996f, -0.07850320f, 0.02883709f, -0.16272719f, -0.00387468f, 0.08285905f, 0.09043743f, -0.13785779f, 
    0.01541830f, -0.06412390f, -0.02339273f, -0.02475137f, -0.23665217f, -0.07211795f, -0.07063624f, -0.07203019f, 
    0.10771447f, 0.04703971f, -0.03812189f, -0.05896477f, 0.11134465f, 0.05175585f, 0.09153508f, -0.03191905f, 
    0.14938328f, -0.06340423f, -0.00475449f, 0.13307668f, 0.03436339f, -0.04171431f, 0.03187318f, 0.03092332f, 
    -0.21533808f, -0.06031406f, -0.05842433f, -0.07440191f, -0.06799529f, 0.06153318f, 0.04815370f, -0.00455070f, 
    0.01327019f, -0.07250531f, -0.00029643f, -0.03421482f, -0.02957180f, 0.00038458f, 0.01943943f, -0.06338187f, 
    0.07213411f, -0.04735348f, -0.05580308f, 0.02752013f, -0.02261051f, -0.12843998f, 0.16390571f, 0.07574310f, 
    -0.02848417f, -0.11705460f, 0.01883601f, -0.09052372f, -0.02074488f, 0.08708828f, 0.04966182f, 0.10457546f, 
    -0.04401354f, -0.05326593f, 0.00025024f, -0.10383897f, -0.02181897f, -0.08962971f, 0.08636669f, 0.04655320f, 
    0.35298043f, -0.10804955f, 0.02644870f, 0.00101647f, -0.19465342f, -0.04809971f, 0.00963458f, -0.03585447f, 
    -0.02995430f, 0.00333502f, -0.04675082f, 0.06169062f, 0.03548893f, 0.01880608f, 0.13798890f, -0.08268186f, 
    -0.02964281f, -0.02239089f, 0.02770587f, -0.16787134f, -0.09646732f, 0.01313147f, 0.01010456f, -0.05018450f, 
    0.04965326f, 0.05972496f, 0.06479482f, -0.02566661f, -0.05134363f, 0.01957064f, -0.01581068f, 0.04758975f, 
    0.02005356f, 0.07226072f, -0.05334155f, 0.00636670f, -0.05991194f, -0.03851384f, -0.03187763f, -0.02746884f, 
    -0.16114745f, -0.25162873f, 0.20424022f, 0.15382862f, 0.05342190f, 0.04165666f, -0.00118894f, -0.06280284f, 
    -0.10793769f, 0.00191779f, 0.02348033f, -0.03091674f, -0.13387947f, -0.03120310f, 0.05188457f, -0.11775199f, 
    -0.06974233f, -0.00366544f, 0.02729196f, 0.02902351f, -0.07342592f, 0.01759311f, 0.06543922f, 0.02280091f, 
    -0.06009585f, -0.00858609f, -0.03185830f, 0.04814666f, -0.10115130f, -0.01472930f, 0.07746818f, 0.02765574f, 
    -0.04602652f, -0.01260972f, 0.02623656f, -0.02159194f, 0.01787316f, -0.00129260f, 0.04162010f, 0.04627663f, 
    -0.22048000f, -0.11399614f, -0.06860351f, -0.15241359f, -0.03873169f, 0.03236616f, -0.02835315f, 0.01783445f, 
    0.00158811f, -0.03421918f, 0.03258796f, -0.06383105f, 0.09401195f, -0.03834604f, 0.08900120f, -0.00982349f, 
    -0.12106664f, -0.07693957f, 0.01461541f, -0.03836799f, -0.12620230f, -0.00007892f, 0.00068330f, 0.06461043f, 
    0.11889238f, 0.10220319f, 0.03669104f, -0.01416794f, 0.13601796f, 0.10187095f, 0.04815912f, 0.03176416f, 
    -0.00260256f, -0.05951412f, -0.01020975f, 0.02016690f, 0.02776454f, 0.01413412f, 0.08473366f, 0.00573864f, 
    -0.20210090f, 0.14257896f, 0.01715234f, 0.07833319f, 0.06844167f, 0.10889718f, -0.03978207f, 0.00770106f, 
    -0.00275372f, 0.05821965f, -0.02410877f, 0.00113402f, 0.01623516f, -0.00618991f, -0.03021475f, -0.00851850f, 
    0.03051364f, 0.09236748f, 0.05911874f, -0.12150959f, 0.03663043f, -0.00952419f, -0.01827660f, 0.16280405f, 
    -0.05041614f, 0.03636429f, -0.01017627f, -0.01973564f, 0.08801814f, -0.05037997f, 0.11143517f, 0.10563534f, 
    0.05577162f, -0.06153445f, 0.04957915f, 0.05416747f, 0.04650906f, -0.08810763f, 0.06713222f, 0.02102688f, 
    0.05243296f, 0.09322874f, 0.06784270f, -0.04726915f, 0.03439483f, 0.02477945f, 0.05772920f, -0.04349564f, 
    0.08060149f, 0.04840944f, 0.00210194f, -0.01899498f, 0.02268287f, 0.00908411f, -0.03531452f, -0.01165327f, 
    0.06444284f, -0.04505461f, 0.04732331f, 0.00993406f, -0.23215251f, -0.10499121f, -0.01656721f, -0.17909110f, 
    0.01282377f, -0.06503435f, -0.06545345f, 0.07750148f, -0.00655078f, 0.10114211f, -0.03302610f, -0.07104727f, 
    0.00832379f, -0.01612081f, -0.01057986f, -0.00641985f, 0.06933726f, -0.05755193f, 0.09230647f, -0.05253523f, 
    0.18171453f, 0.11422310f, -0.19017661f, -0.04662410f, -0.18150558f, -0.01128069f, 0.02626754f, 0.04331602f, 
    -0.13859336f, 0.03388752f, -0.10479194f, 0.01587699f, 0.02837669f, -0.00604969f, -0.03654151f, 0.01067713f, 
    -0.03776243f, 0.05499933f, -0.05815751f, 0.01191281f, 0.06543929f, -0.11735279f, 0.09253339f, 0.04308987f, 
    -0.10217997f, -0.10973153f, 0.06719591f, 0.03947144f, -0.02484418f, -0.00718947f, 0.11057717f, 0.01217461f, 
    -0.00931629f, 0.00476639f, 0.05374933f, -0.01248436f, -0.00822986f, 0.08532535f, 0.09858625f, 0.09944661f, 
    0.11086145f, 0.03134514f, -0.16808197f, 0.10761116f, -0.02240728f, 0.06895074f, -0.05325618f, -0.01903989f, 
    -0.05027034f, 0.01312633f, -0.06211504f, 0.01652580f, 0.08983364f, 0.11305194f, 0.11198450f, -0.09490611f, 
    -0.04067461f, 0.08009712f, -0.03976169f, -0.08937575f, -0.11984061f, -0.03489863f, 0.02216213f, 0.00635093f, 
    0.05833733f, 0.08787864f, 0.05831392f, 0.00681278f, -0.07994590f, 0.00452297f, 0.01293134f, 0.06103437f, 
    -0.02831933f, 0.02944889f, 0.02315364f, -0.04038489f, -0.02568876f, 0.05293573f, 0.00186248f, 0.02620435f, 
    -0.25351048f, 0.02637832f, 0.02477125f, -0.14131513f, -0.09250601f, 0.05239503f, -0.01555467f, -0.07356744f, 
    -0.00765512f, -0.06652527f, -0.06303103f, 0.09876820f, -0.05468590f, 0.03435193f, 0.02309082f, 0.00035238f, 
    0.02015421f, 0.01755105f, 0.02324203f, -0.00497379f, -0.30969149f, -0.12068075f, 0.16302788f, 0.06645183f, 
    0.03402385f, -0.10932972f, -0.03642198f, 0.13142540f, -0.03336246f, 0.05497197f, 0.05250025f, -0.01008327f, 
    -0.06332406f, -0.05136653f, -0.00190850f, 0.02489923f, -0.00908756f, -0.08137331f, -0.05668485f, -0.01757794f, 
    -0.02045309f, -0.05262570f, -0.14076762f, 0.19244064f, 0.03773119f, 0.20254201f, -0.02489595f, 0.17670768f, 
    0.01259934f, 0.01781529f, -0.03721537f, -0.04702795f, -0.03877719f, -0.04868969f, -0.02728151f, -0.00789801f, 
    0.08119451f, -0.05756863f, 0.03748380f, 0.02887578f, -0.03587262f, 0.08902942f, 0.00514211f, 0.01141711f, 
    0.10728997f, 0.04281329f, -0.00415046f, 0.05075951f, 0.04442444f, 0.02635630f, -0.02685795f, 0.01883913f, 
    -0.02104447f, -0.01991864f, 0.00589167f, -0.00090748f, 0.03605874f, -0.01541281f, 0.04699190f, -0.07346442f, 
    0.00080724f, -0.16255151f, -0.12859802f, -0.03461614f, -0.12478018f, -0.11553071f, -0.07260621f, -0.07330097f, 
    0.04099040f, -0.06950342f, -0.05659607f, -0.00871122f, -0.04740139f, -0.00888063f, -0.00730908f, -0.05973703f, 
    0.07984346f, -0.04014096f, -0.05991007f, -0.00509593f, -0.02276355f, -0.12650119f, 0.17482296f, 0.06005092f, 
    0.00145449f, -0.08578952f, -0.09044937f, 0.08109061f, -0.05365257f, -0.00202977f, 0.02697315f, -0.02896410f, 
    -0.05270586f, -0.08892294f, 0.00040378f, 0.05427809f, -0.00186638f, 0.01961899f, -0.06617528f, -0.01819405f, 
    -0.11021195f, 0.12272736f, 0.10673875f, -0.08986713f, -0.00753092f, 0.04534966f, 0.00732392f, -0.01162542f, 
    0.00648222f, -0.06121132f, -0.01851431f, -0.07531140f, -0.08656368f, 0.05982633f, 0.02946823f, -0.01850337f, 
    -0.11949417f, -0.05990788f, -0.16659831f, 0.06004354f, -0.05052758f, 0.10626883f, 0.25156522f, 0.09019272f, 
    0.02289899f, -0.04292079f, -0.00758898f, 0.03687878f, 0.02424058f, 0.03773288f, 0.08740373f, -0.00403526f, 
    0.02526247f, -0.04427569f, 0.04730712f, 0.11889796f, 0.06493327f, -0.01824538f, -0.08567812f, -0.03594853f, 
    0.36160302f, 0.35835952f, -0.21109682f, -0.19729087f, -0.01881141f, -0.04895604f, 0.06296752f, 0.03010686f, 
    0.07300862f, -0.00521388f, -0.05427883f, 0.01330871f, -0.02749296f, -0.02443785f, 0.01449566f, -0.06276099f, 
    0.14498535f, 0.07030644f, -0.01114585f, 0.08757679f, -0.10519835f, -0.08442513f, 0.02906948f, -0.04449979f, 
    0.08367154f, -0.05541979f, 0.05704891f, -0.04839541f, 0.11159304f, -0.00764280f, 0.01855521f, 0.00757078f, 
    0.02746611f, 0.04895264f, -0.02598581f, 0.05957523f, -0.06317410f, 0.05995190f, 0.04391436f, 0.12876591f, 
    0.15474880f, 0.24305694f, 0.10869592f, 0.01456633f, -0.16460514f, 0.05796734f, -0.05507047f, -0.03666956f, 
    0.03742053f, 0.00053864f, 0.02100820f, 0.04437131f, -0.04766601f, 0.08954892f, 0.07154506f, -0.07313734f, 
    0.00696628f, -0.03468543f, -0.11598436f, 0.05147850f, 0.05966993f, -0.10657116f, 0.11855552f, 0.13538316f, 
    0.04616889f, 0.07919832f, 0.01881827f, -0.00897906f, -0.08828329f, 0.03083544f, 0.08279643f, 0.04033007f, 
    -0.12828720f, -0.07304627f, 0.08182658f, -0.05449229f, -0.03261446f, 0.05381598f, -0.00252619f, 0.10982779f, 
    0.03270019f, -0.12022953f, -0.01600823f, 0.09084687f, 0.10685924f, -0.01378001f, 0.06953084f, 0.06724165f, 
    0.06320442f, -0.00216148f, 0.05936044f, 0.05711702f, 0.01007805f, 0.04067530f, 0.02016914f, 0.00807052f, 
    -0.01879630f, 0.02931270f, 0.06428785f, 0.02502038f, -0.48645318f, -0.15763147f, 0.00263469f, 0.05066690f, 
    0.23623911f, 0.05959482f, 0.04219256f, 0.00606245f, 0.05619499f, 0.09279926f, -0.07672389f, -0.08431327f, 
    0.07864662f, 0.07052633f, -0.00386152f, -0.07468902f, 0.18121560f, 0.01450899f, 0.11769529f, -0.14289525f, 
    0.20819996f, 0.23660068f, -0.14866641f, 0.03306582f, 0.05242362f, -0.00876260f, 0.04550124f, 0.12736949f, 
    0.04353606f, -0.00151373f, -0.04101929f, 0.03990446f, -0.00286740f, 0.00126912f, -0.06818155f, 0.00773132f, 
    -0.00755419f, -0.15148857f, -0.02790779f, -0.05364669f, -0.33543006f, 0.03243154f, -0.06509010f, 0.03146489f, 
    0.17087530f, 0.02080985f, -0.01902031f, -0.01320859f, 0.03201875f, -0.01302448f, 0.07784539f, -0.03771159f, 
    -0.03336355f, 0.06753952f, -0.02736731f, -0.02870407f, -0.03465320f, 0.02551390f, 0.02545894f, 0.05833925f, 
    -0.09516860f, -0.03800756f, 0.03031440f, 0.17223559f, -0.07878899f, -0.01522769f, -0.03353507f, -0.03337471f, 
    0.01678723f, -0.03029737f, 0.07824534f, 0.02883442f, 0.02982568f, 0.02431106f, 0.05660038f, -0.02451179f, 
    0.01587657f, 0.10339589f, -0.07503968f, -0.13156350f, 0.06458273f, 0.04826607f, 0.01726288f, 0.05277031f, 
    0.07541998f, -0.06865621f, -0.10567135f, 0.08723592f, -0.00210743f, 0.07887773f, -0.07312880f, -0.12330533f, 
    0.03332753f, 0.03482750f, 0.08513592f, -0.11125387f, -0.05271751f, -0.06760127f, -0.01927789f, -0.08452675f, 
    -0.29808784f, 0.18872213f, 0.08720584f, -0.14518391f, -0.09834943f, 0.11432822f, 0.04912634f, 0.09442016f, 
    -0.06360058f, -0.06964087f, 0.07077852f, -0.10085484f, 0.05008253f, -0.05595600f, 0.02568441f, 0.10870938f, 
    -0.04557597f, 0.04991360f, -0.08503614f, 0.01626231f, -0.20968415f, -0.07534772f, -0.11080118f, -0.08358993f, 
    0.02121951f, 0.09970217f, 0.03581528f, -0.01295815f, 0.01944277f, -0.02675256f, -0.09286205f, 0.13442045f, 
    0.01693479f, -0.04651314f, -0.06905556f, 0.03269081f, 0.03984357f, -0.05199108f, -0.05016077f, 0.01001490f, 
    -0.11084688f, -0.16992295f, 0.00252940f, 0.01449013f, 0.07025576f, 0.01379702f, -0.04967255f, 0.06026080f, 
    -0.00189536f, 0.02365294f, -0.03789584f, -0.06846872f, -0.13559720f, -0.09358459f, 0.00188612f, -0.01831995f, 
    -0.03083720f, 0.02934131f, -0.04246196f, 0.04231571f, -0.52205408f, -0.14555189f, -0.20177075f, -0.12600653f, 
    -0.04598770f, 0.07007976f, -0.00208639f, 0.00920551f, -0.02432294f, -0.20840442f, 0.01287539f, 0.01025656f, 
    0.00076810f, -0.04410101f, 0.03414790f, 0.05030479f, -0.00617432f, 0.00983770f, -0.07484309f, -0.01170416f, 
    -0.44741476f, 0.21049297f, -0.15576477f, -0.02856114f, -0.17905621f, 0.03292958f, 0.00539971f, 0.08798586f, 
    -0.15029518f, -0.07171571f, -0.03557387f, -0.01384063f, 0.00189718f, -0.13087812f, -0.07529642f, 0.00271473f, 
    -0.05549352f, 0.00698989f, 0.07677573f, -0.03699100f, 0.00985368f, -0.19735812f, -0.17331734f, 0.16788587f, 
    0.13497752f, -0.01400166f, -0.17144823f, 0.04284637f, 0.08642057f, 0.15892486f, 0.00613326f, -0.01707035f, 
    0.04777327f, 0.01606077f, 0.08298952f, -0.14170882f, -0.09180144f, -0.09252126f, -0.06290422f, -0.15092018f, 
    -0.27388713f, 0.00453595f, 0.03729209f, 0.14750832f, 0.01839623f, -0.08105265f, -0.04911270f, -0.00236683f, 
    -0.04732133f, -0.01469070f, 0.04282650f, -0.04447424f, 0.03445993f, 0.00335966f, -0.03987961f, -0.01115760f, 
    -0.01251486f, 0.01121200f, 0.03359161f, -0.02184805f, -0.22737101f, 0.11809748f, 0.02153128f, 0.08848063f, 
    -0.04007909f, -0.08173453f, 0.07155008f, -0.10709170f, -0.04678711f, 0.09050988f, 0.00110351f, -0.04857846f, 
    0.02203369f, -0.04645988f, 0.00190344f, -0.00314408f, 0.00977715f, 0.00604822f, -0.07236147f, -0.17371787f, 
    -0.24513525f, 0.00561641f, 0.12355814f, 0.05627387f, -0.02741465f, -0.04056916f, -0.01724356f, -0.01442169f, 
    -0.00032196f, 0.01534536f, 0.03709240f, -0.05514937f, -0.02911224f, -0.02816600f, 0.01306993f, -0.06161522f, 
    0.04461932f, -0.03651187f, -0.01067582f, 0.03105869f, -0.02633930f, 0.08328068f, -0.14906144f, 0.02162752f, 
    0.10518053f, -0.02252862f, 0.01284813f, 0.01682555f, 0.02263004f, 0.08360625f, 0.09757060f, 0.10559659f, 
    0.01441075f, -0.00860003f, 0.01267483f, -0.01774673f, 0.00479022f, 0.04376638f, 0.12190815f, -0.15786932f, 
    0.05260175f, 0.15058817f, -0.00419591f, 0.00298162f, -0.07895346f, 0.02908036f, 0.01124625f, -0.13068995f, 
    -0.08116165f, 0.04440393f, -0.03044272f, 0.00019590f, 0.02920641f, -0.04318498f, -0.02588090f, 0.01231618f, 
    -0.03236547f, -0.00870664f, 0.04228302f, -0.01496315f, -0.02541224f, -0.04617410f, -0.03577942f, 0.10301594f, 
    -0.10604016f, -0.11369840f, -0.03760739f, 0.08414662f, -0.00808834f, 0.10749780f, -0.08155693f, -0.06621039f, 
    -0.04609648f, -0.02320361f, -0.01380081f, 0.03737546f, 0.03765419f, -0.09135109f, 0.10294568f, 0.11076854f, 
    -0.21637683f, -0.21687928f, -0.18318886f, 0.03571076f, -0.04846142f, 0.09980623f, 0.10104911f, 0.05971517f, 
    -0.06076392f, 0.02046864f, 0.02121724f, -0.05439396f, 0.05519493f, -0.03378043f, -0.09508463f, 0.04542882f, 
    -0.08030581f, 0.06321717f, -0.11444440f, 0.02644537f, -0.13450046f, 0.11600455f, -0.04909803f, -0.03237225f, 
    -0.01735385f, -0.06104675f, -0.02950956f, -0.00626213f, 0.00013366f, -0.09607604f, -0.00397204f, 0.01402718f, 
    -0.04431863f, -0.04832578f, 0.01110150f, -0.07123825f, 0.01864015f, 0.04480302f, 0.05766275f, 0.00865760f, 
    -0.02875031f, 0.01830797f, -0.01902691f, 0.03056831f, -0.02130662f, 0.07563255f, -0.09616033f, -0.00280630f, 
    -0.03666161f, 0.04342564f, -0.03058562f, -0.04606361f, 0.00033158f, -0.00506452f, -0.01800157f, -0.03309198f, 
    -0.06519549f, -0.10653486f, 0.08137499f, 0.00168635f, 0.09342512f, 0.01541604f, 0.01814522f, 0.16396935f, 
    0.09554984f, 0.02783100f, 0.03320339f, 0.05541857f, -0.01477742f, -0.02032245f, 0.02817999f, -0.12332388f, 
    -0.05841698f, 0.05693251f, 0.06151401f, 0.03083095f, -0.03403978f, 0.07626420f, 0.03003643f, 0.00328481f, 
    -0.02798168f, 0.00619415f, -0.11213010f, -0.06850620f, 0.02144120f, 0.04929562f, 0.12448351f, -0.00332762f, 
    -0.00026812f, 0.07235336f, 0.05055143f, 0.13934372f, 0.05922462f, -0.06743570f, -0.00488644f, -0.08756347f, 
    0.00370623f, -0.01131329f, 0.06143318f, -0.04806170f, -0.30193096f, -0.23107596f, -0.02978947f, 0.09406307f, 
    -0.20872553f, 0.06633289f, 0.00805734f, -0.00179925f, 0.00465089f, -0.02307772f, 0.08409274f, 0.07774002f, 
    0.04874926f, 0.07528885f, -0.05365036f, 0.01627894f, -0.03383225f, -0.03555238f, -0.00698703f, 0.01356429f, 
    0.10707253f, 0.22795559f, -0.16138245f, -0.08779645f, 0.03500178f, -0.01291841f, 0.05206990f, -0.03211755f, 
    0.01198272f, -0.07551180f, 0.08266159f, -0.00827605f, -0.08482999f, -0.06132666f, -0.00611730f, -0.09271049f, 
    -0.00389951f, -0.05932439f, 0.01773593f, -0.03366168f, 0.06949709f, 0.00182596f, -0.05613643f, 0.12970166f, 
    -0.13770244f, -0.01522739f, -0.06982002f, -0.16665982f, -0.01017109f, 0.07433292f, -0.05076477f, 0.01573640f, 
    0.18365838f, 0.04831940f, 0.04246505f, -0.02075288f, -0.00570145f, 0.03606141f, 0.07898103f, -0.01558186f, 
    -0.28866601f, -0.41572046f, -0.05732399f, -0.00733587f, -0.04682808f, 0.08660767f, 0.06260239f, 0.04835812f, 
    0.09872255f, -0.04548745f, 0.03326207f, 0.03800911f, -0.03577853f, 0.15111268f, -0.04240240f, 0.01593854f, 
    0.05354171f, -0.03801060f, -0.16337384f, 0.14926086f, -0.49328816f, -0.11932177f, -0.08499447f, -0.10925622f, 
    -0.04591425f, -0.04770551f, 0.07841723f, 0.14048164f, -0.02554750f, -0.07231046f, 0.03249019f, 0.00585632f, 
    0.13158792f, -0.03857599f, 0.00020210f, -0.04590454f, -0.09122945f, -0.19022720f, -0.06426807f, 0.08448927f, 
    0.06007645f, -0.16339248f, -0.06024865f, 0.10697344f, 0.23904704f, -0.04485719f, -0.12931378f, -0.08644510f, 
    0.05419923f, -0.02542845f, 0.05248421f, -0.05843478f, 0.02281062f, 0.07812022f, -0.04421661f, 0.06232568f, 
    -0.16663615f, -0.14767762f, -0.11855320f, -0.04611988f, -0.17067049f, 0.19584545f, -0.10693930f, -0.15540996f, 
    0.02025953f, 0.02418222f, 0.06628141f, 0.06400003f, -0.10987254f, -0.16289169f, 0.03957865f, 0.02438997f, 
    -0.00498546f, -0.03983121f, 0.00959085f, 0.01952492f, 0.05258968f, 0.00583630f, 0.03253292f, -0.01746128f, 
    -0.00552670f, 0.13075867f, -0.10052674f, -0.05224719f, -0.16126242f, 0.04702861f, 0.05324563f, 0.03389987f, 
    0.00883392f, -0.07050548f, 0.05276702f, 0.00175099f, -0.06095782f, -0.09549280f, -0.10864434f, 0.08896460f, 
    -0.12018248f, 0.00252980f, 0.13159157f, -0.00246116f, -0.05713553f, -0.01698754f, 0.20787202f, 0.16965441f, 
    0.13647981f, -0.06883758f, -0.07118061f, -0.01465507f, 0.02067218f, 0.03903808f, -0.03388404f, -0.17585792f, 
    -0.00973434f, 0.09063308f, 0.04747982f, 0.09210058f, 0.10228680f, -0.15751278f, -0.10006222f, 0.03060191f, 
    0.00992122f, 0.13585411f, 0.04877592f, 0.07553892f, -0.04330484f, -0.02071197f, -0.04355364f, -0.09655849f, 
    -0.01668371f, 0.09437126f, 0.02544218f, -0.02715702f, -0.11200756f, 0.04638704f, -0.08976431f, 0.05579498f, 
    -0.00724991f, 0.04676444f, 0.05808985f, 0.02703592f, 0.10889398f, 0.03479012f, 0.08333901f, 0.13149007f, 
    -0.02124085f, -0.03547158f, 0.03531107f, -0.02334077f, -0.02149656f, -0.06692457f, -0.01184535f, 0.01421622f, 
    0.02114001f, -0.04130308f, -0.06040647f, 0.02189965f, -0.00370492f, 0.02572159f, 0.06212268f, 0.08604167f, 
    0.13360570f, 0.08717395f, -0.07206836f, 0.03625869f, 0.06109389f, -0.04911554f, -0.11327120f, 0.04422020f, 
    0.02861832f, 0.06416173f, -0.06609389f, 0.03533174f, -0.05902134f, 0.10938403f, -0.02920772f, -0.03323904f, 
    0.03650962f, -0.01000345f, 0.11086559f, -0.09120899f, 0.14570467f, -0.06081163f, 0.20642570f, 0.13436249f, 
    -0.06298110f, 0.06440695f, 0.11509890f, 0.02251738f, 0.01839376f, -0.01258410f, 0.01846760f, -0.02735997f, 
    -0.08029221f, 0.03422002f, 0.02952252f, 0.03362230f, 0.05079714f, 0.06036052f, 0.00761066f, -0.00424578f, 
    -0.01299023f, 0.02816395f, 0.11014204f, 0.03057817f, -0.01332461f, -0.04325641f, -0.00262882f, 0.03429223f, 
    0.01009685f, 0.14574061f, 0.09099357f, -0.01386495f, -0.01319201f, -0.06110955f, -0.08524179f, -0.03056787f, 
    0.01573756f, -0.16353925f, 0.06866585f, 0.01483667f, 0.07555776f, 0.07575420f, 0.00594803f, 0.08744379f, 
    -0.04591611f, -0.03067119f, 0.01247890f, -0.02093311f, 0.01367223f, 0.03921578f, 0.02702964f, -0.12299760f, 
    -0.01726085f, 0.08448164f, -0.00088682f, 0.04474778f, -0.00708440f, 0.03394062f, 0.04591535f, 0.03439464f, 
    0.11429371f, 0.10859325f, 0.09147581f, -0.14617734f, 0.06835689f, 0.02804190f, -0.00182437f, 0.03372939f, 
    -0.08903649f, 0.14248772f, -0.05792094f, -0.02636535f, 0.03720038f, -0.01329195f, -0.09641776f, 0.05755472f, 
    -0.12448371f, 0.04068315f, 0.01194870f, 0.14036708f, -0.05268207f, -0.03002778f, 0.02715798f, -0.00468910f, 
    -0.01540050f, -0.01820150f, -0.10374416f, -0.02029088f, 0.01720090f, -0.00850990f, 0.03923237f, 0.01868753f, 
    -0.04405852f, 0.03457465f, -0.01865175f, 0.06615075f, 0.05088400f, -0.02278878f, -0.09686965f, 0.07821885f, 
    0.10764528f, 0.04293005f, -0.01252626f, 0.14453679f, 0.18117616f, -0.07236287f, -0.01709853f, 0.03994224f, 
    0.08455849f, 0.07007419f, -0.02155570f, -0.16923812f, -0.00957464f, 0.17663482f, 0.16639687f, 0.04641011f, 
    0.16338105f, -0.08040968f, -0.13816971f, -0.03562669f, 0.13914055f, -0.04291790f, -0.07937749f, 0.09233005f, 
    0.02474953f, -0.10817093f, 0.01137116f, -0.02835466f, 0.07333726f, -0.04953313f, 0.01040377f, -0.03579632f, 
    0.06692263f, 0.11518671f, 0.20372306f, -0.14571008f, -0.01975684f, 0.02416920f, -0.23995675f, -0.10274056f, 
    -0.15518774f, 0.17144908f, 0.12712766f, -0.01847163f, 0.03241585f, -0.00036428f, 0.01677339f, -0.07204849f, 
    0.09994645f, 0.04390085f, -0.05924191f, -0.11314985f, 0.00448050f, 0.02537394f, -0.06300394f, 0.07918352f, 
    0.03681544f, -0.02576242f, -0.10191377f, 0.02924899f, -0.33430651f, -0.02272884f, -0.16538055f, 0.01856835f, 
    0.07219572f, 0.04322951f, 0.08027459f, 0.10469967f, -0.06178242f, 0.04956751f, -0.00991130f, 0.15696794f, 
    -0.02953036f, -0.01913638f, 0.02574427f, 0.03741327f, 0.01075151f, -0.00011034f, -0.05875241f, -0.04313608f, 
    -0.48793328f, -0.13818771f, -0.18892995f, -0.19509703f, 0.03795495f, 0.08031894f, -0.01288007f, -0.04251307f, 
    0.06328600f, -0.14377300f, 0.04294563f, 0.05624307f, -0.00655390f, 0.00410945f, -0.03824190f, -0.02748101f, 
    -0.02160079f, -0.05013653f, -0.05400183f, 0.02213175f, -0.04428749f, 0.00742203f, 0.01596428f, 0.06026404f, 
    0.08050461f, 0.03780219f, -0.06295957f, -0.01466526f, -0.10120738f, 0.09654503f, 0.03802473f, 0.01959712f, 
    0.08866934f, 0.09827687f, -0.09459360f, -0.10051110f, -0.07812317f, -0.08320902f, -0.04991140f, -0.06226174f, 
    0.13277610f, 0.03908688f, 0.06496236f, 0.09417000f, -0.04607910f, -0.01371628f, 0.02734877f, 0.03250921f, 
    -0.03387614f, -0.01886770f, 0.06070879f, -0.02561260f, 0.00756704f, -0.02823737f, -0.01773993f, 0.03898560f, 
    -0.01492114f, 0.10425276f, 0.05202854f, 0.04067639f, 0.11410527f, 0.07384479f, -0.11231551f, -0.05480294f, 
    -0.30182633f, 0.00218167f, -0.00383270f, -0.04302200f, 0.02455663f, 0.05022248f, -0.05764797f, 0.03700917f, 
    0.10704637f, -0.05675622f, 0.00083256f, 0.02143412f, -0.02344265f, 0.03085402f, -0.13744721f, 0.03029888f, 
    -0.03898767f, 0.13399452f, 0.04699316f, -0.00897679f, 0.03073853f, 0.01100342f, -0.05899975f, -0.02602466f, 
    -0.00843018f, 0.02667571f, -0.02309426f, 0.03310643f, -0.00160569f, -0.02106479f, -0.00620984f, 0.02682886f, 
    -0.00790018f, -0.02152560f, 0.05135702f, -0.01969496f, -0.09150573f, 0.05691889f, -0.13990726f, 0.03011706f, 
    0.05059052f, -0.06439806f, 0.06300839f, 0.05057982f, 0.04641103f, 0.09662948f, 0.03596560f, -0.01949371f, 
    0.11202265f, 0.01826789f, -0.11995330f, -0.03072684f, 0.04751126f, -0.21080166f, -0.03778546f, 0.13798487f, 
    0.14759637f, 0.18936218f, 0.03531399f, -0.13962463f, -0.01788017f, -0.09333914f, 0.01600117f, -0.03283049f, 
    0.05880073f, -0.14338194f, 0.10922302f, 0.01100666f, 0.01005563f, -0.10482627f, 0.03256191f, 0.16486239f, 
    -0.04776699f, 0.06657554f, 0.11042533f, 0.02642523f, 0.01010036f, 0.01753030f, 0.02639717f, 0.05519731f, 
    0.00285975f, 0.05926586f, 0.03964086f, 0.07206643f, 0.03550815f, 0.08622464f, 0.03436037f, -0.00969579f, 
    0.02443782f, -0.04661429f, -0.02329497f, 0.03619254f, 0.10644048f, -0.10644251f, -0.03494037f, 0.02130708f, 
    -0.15082210f, 0.03818896f, -0.12096216f, -0.01123560f, 0.07744123f, 0.05769085f, 0.03856174f, 0.05379856f, 
    0.10138790f, -0.10272107f, -0.00715126f, -0.03246200f, -0.00429732f, -0.05908407f, -0.00155091f, -0.02492292f, 
    0.00631885f, -0.00463311f, -0.02382007f, -0.01715146f, 0.21744850f, -0.01239502f, -0.03123866f, -0.02904939f, 
    -0.20602091f, -0.18844087f, 0.05536300f, -0.02431111f, 0.05874100f, 0.02135315f, -0.01762394f, 0.07328098f, 
    -0.00582177f, 0.06977513f, 0.10878941f, -0.04418502f, 0.01000669f, 0.12034881f, 0.09237779f, 0.03441010f, 
    -0.11326282f, 0.14322747f, 0.14453457f, 0.00850718f, -0.07653744f, -0.14406139f, 0.04943250f, -0.01834701f, 
    -0.07147001f, 0.04281189f, 0.11272899f, -0.02568373f, 0.01482978f, -0.00442882f, -0.12479541f, 0.05990565f, 
    0.01092523f, -0.00086296f, 0.08467831f, 0.03702931f, -0.24666560f, -0.09612329f, -0.03461691f, -0.01487105f, 
    -0.06212125f, 0.00177341f, 0.06986593f, 0.00359252f, -0.00347497f, -0.06495504f, 0.07351987f, 0.01766114f, 
    0.04665897f, 0.02264647f, -0.01758813f, -0.02853102f, 0.01280802f, -0.02480696f, 0.06996737f, 0.03028040f, 
    -0.06060212f, 0.03888420f, 0.04281958f, 0.11413660f, 0.08508221f, 0.03872166f, -0.03143087f, 0.06290846f, 
    -0.06950900f, 0.10594014f, 0.00705972f, -0.10902966f, -0.02478879f, 0.02124422f, -0.02271212f, 0.00944719f, 
    0.08130454f, -0.15542132f, 0.05820783f, -0.00819733f, 0.00149572f, -0.01238977f, 0.00066941f, 0.05498111f, 
    0.02046121f, -0.06081882f, 0.09352080f, -0.02165726f, 0.00223005f, 0.02657508f, -0.01873091f, -0.01358561f, 
    -0.02319595f, 0.01248551f, 0.05769612f, -0.01347406f, -0.06662985f, 0.01299302f, 0.06432479f, 0.04611948f, 
    -0.09411413f, -0.19074160f, 0.01604434f, 0.01516696f, 0.01628473f, -0.12383523f, 0.08348500f, 0.05916517f, 
    -0.02746697f, 0.07916553f, -0.01219518f, 0.11107431f, 0.09271731f, 0.03580280f, 0.12116744f, 0.05122039f, 
    0.08850926f, -0.08422114f, 0.04079980f, -0.12342523f, 0.04223521f, -0.10695005f, -0.02869998f, 0.04262220f, 
    -0.02332899f, -0.09189190f, 0.08867484f, -0.05282389f, -0.05165801f, -0.01034147f, -0.02789318f, 0.13984464f, 
    0.07856733f, 0.02865670f, 0.07336831f, -0.06748569f, -0.10053823f, 0.08040462f, 0.03872695f, -0.04716480f, 
    -0.24562077f, -0.23018554f, 0.31546411f, 0.22325821f, -0.48662999f, 0.05039221f, -0.01141074f, -0.00594602f, 
    -0.04203627f, -0.07836311f, -0.04779650f, -0.01408631f, 0.00147908f, -0.03434764f, 0.13745330f, -0.06256400f, 
    -0.01499066f, 0.04960045f, 0.06981241f, -0.03475892f, -0.22958978f, 0.03853839f, -0.11825006f, -0.07474773f, 
    -0.01646911f, -0.02571745f, 0.18179096f, 0.03227355f, -0.06694885f, 0.10004136f, -0.05283769f, 0.14448671f, 
    0.01409236f, -0.05062870f, 0.04383505f, 0.01685036f, 0.09617753f, -0.04551078f, 0.01702198f, -0.01120964f, 
    0.02922027f, -0.04796302f, -0.02819922f, -0.00596225f, 0.16265102f, -0.06094574f, -0.01548794f, 0.00104763f, 
    -0.05207746f, -0.03938061f, 0.12153053f, 0.01985085f, 0.05921144f, -0.02885206f, -0.00527990f, -0.00260258f, 
    0.03786377f, 0.02281167f, -0.01914707f, 0.05685561f, 0.06027628f, 0.01455486f, 0.00424725f, 0.02710417f, 
    0.17436242f, -0.02417347f, -0.05706834f, -0.06284900f, 0.01821045f, 0.02463361f, 0.00111782f, -0.04729069f, 
    0.17582342f, 0.10426976f, 0.06957837f, 0.11346395f, 0.09527608f, -0.07701039f, -0.15696141f, 0.00010328f, 
    0.09806523f, 0.06390545f, -0.05583804f, -0.02448960f, 0.10190856f, 0.06147017f, -0.06375218f, -0.00230718f, 
    -0.01066368f, 0.07575348f, 0.03849887f, -0.08879810f, 0.04113084f, 0.04409758f, 0.05994834f, -0.09477061f, 
    -0.00923590f, 0.02990746f, -0.16346687f, -0.07311299f, -0.15219730f, 0.21943308f, -0.30282882f, -0.16259493f, 
    -0.13927838f, 0.12561366f, 0.04815155f, 0.07999445f, -0.04957901f, -0.12005598f, -0.03370534f, 0.01173830f, 
    -0.20218746f, 0.00868786f, -0.06930211f, 0.00640263f, -0.04265558f, 0.02016947f, -0.00903084f, 0.00599851f, 
    -0.20690453f, -0.12953718f, 0.03182773f, 0.04108241f, -0.24195321f, 0.05447011f, -0.09843786f, -0.01728314f, 
    0.00831467f, 0.00883108f, 0.06906784f, 0.03907822f, 0.00053704f, 0.04744227f, -0.02071614f, -0.07185993f, 
    0.07458790f, 0.14845628f, -0.00552530f, -0.02858809f, -0.26657510f, -0.14939803f, -0.21884124f, 0.03365672f, 
    -0.09487084f, 0.02252718f, 0.06892204f, -0.00211985f, 0.02308816f, -0.10549794f, -0.00195871f, -0.01398710f, 
    0.07030652f, -0.08017126f, 0.01738322f, 0.15499376f, 0.03171822f, 0.05014334f, -0.02242566f, -0.01129674f, 
    -0.31768078f, 0.17658544f, 0.00798510f, 0.10162072f, 0.08373047f, -0.01286731f, -0.04536483f, 0.09694367f, 
    0.06610488f, -0.01919475f, -0.12649813f, -0.00705785f, -0.05380669f, 0.04468573f, 0.02222804f, -0.08771744f, 
    0.00084188f, -0.02605478f, 0.02630724f, 0.04656067f, 0.04579706f, 0.14846033f, 0.06854884f, -0.01814538f, 
    -0.15874751f, 0.06770530f, 0.06740767f, 0.02423422f, -0.03245351f, 0.02866505f, -0.00655962f, -0.04065135f, 
    -0.01736577f, 0.01700640f, 0.00813370f, 0.07619862f, -0.05458780f, -0.05289635f, 0.00108321f, -0.03717889f, 
    0.10738363f, -0.16102794f, 0.04312674f, 0.01835685f, -0.04399870f, -0.17149648f, -0.04369238f, -0.09248534f, 
    0.08217474f, 0.02736989f, 0.01899410f, 0.06470402f, -0.01651273f, -0.00903381f, 0.10979477f, -0.01644765f, 
    -0.01190758f, -0.08283901f, -0.11291704f, -0.06394367f, -0.18558551f, -0.01622939f, -0.04369998f, -0.28479972f, 
    0.02041827f, -0.02528723f, -0.02865183f, 0.01646572f, -0.02772624f, -0.05367364f, -0.04874763f, -0.07373165f, 
    -0.07800096f, 0.02231255f, -0.00369454f, -0.02796730f, -0.00403281f, 0.01236151f, 0.09679524f, -0.01516736f, 
    0.05047547f, -0.01328118f, 0.01042244f, 0.01117219f, -0.00579076f, 0.07939252f, 0.09401990f, -0.00544617f, 
    0.02357398f, 0.04301661f, -0.12228161f, -0.06218017f, 0.11780433f, 0.00947706f, -0.09001653f, -0.06896259f, 
    0.06569567f, 0.08668832f, 0.03323961f, 0.01660578f, -0.03880581f, -0.11526261f, 0.01050176f, -0.09288862f, 
    0.03196503f, -0.03452552f, -0.01822881f, 0.02713705f, -0.02250766f, 0.08135263f, -0.00301744f, 0.02566362f, 
    -0.00570461f, 0.07893706f, -0.02408223f, -0.08316811f, -0.01279377f, -0.00483934f, 0.03857721f, 0.03809247f, 
    0.06696679f, -0.59392619f, -0.23361215f, -0.05953463f, -0.02712680f, -0.01994801f, 0.06936505f, -0.02288525f, 
    0.08652427f, -0.01282758f, -0.03208705f, 0.06966448f, 0.05652237f, 0.06783314f, 0.05755093f, 0.02951365f, 
    0.02944240f, -0.02236751f, -0.13468435f, 0.03842900f, 0.02821988f, -0.05018625f, -0.06347007f, -0.23937868f, 
    0.12180524f, -0.03861363f, -0.00022948f, -0.06805902f, -0.08821638f, -0.04306982f, -0.00814038f, -0.07694820f, 
    -0.09351826f, -0.03613372f, -0.00490733f, 0.02812393f, -0.09985332f, 0.17177026f, 0.03774591f, 0.14969446f, 
    0.13533080f, -0.11959577f, 0.06854203f, -0.05666396f, 0.28827029f, 0.04799664f, -0.04381470f, 0.00655273f, 
    0.00727949f, -0.03388345f, -0.06965002f, -0.00437442f, -0.01661683f, -0.01753967f, 0.05059383f, -0.04713146f, 
    -0.06256463f, 0.09143325f, -0.05339021f, 0.04812554f, 0.26543167f, -0.02952294f, 0.07907151f, 0.09085355f, 
    0.26847991f, 0.04198645f, -0.03947214f, -0.00082469f, 0.03518400f, -0.12253840f, -0.08737294f, 0.07397833f, 
    -0.03010342f, 0.08671643f, 0.09260448f, -0.04624933f, -0.01976929f, -0.03905097f, 0.05953303f, -0.00844355f, 
    0.43983427f, 0.00696562f, 0.14184330f, 0.14327914f, 0.17990790f, 0.01459576f, -0.07248344f, 0.00951248f, 
    0.00014608f, -0.04586243f, -0.01323810f, -0.01380278f, 0.13498956f, -0.04672333f, 0.03720902f, 0.05645462f, 
    0.05480429f, -0.11249116f, -0.06557097f, -0.05920919f, -0.01503004f, -0.09193116f, -0.22811052f, -0.25210401f, 
    0.19808601f, -0.07814866f, -0.00944516f, 0.03002494f, 0.02620001f, 0.01390583f, -0.04683384f, 0.01930273f, 
    0.03677636f, -0.01979243f, 0.07554876f, 0.01388595f, 0.00771835f, 0.09962518f, -0.04923091f, 0.14020817f, 
    -0.05796228f, 0.04477088f, -0.16936192f, 0.15502419f, -0.08853085f, -0.02597972f, 0.02090563f, -0.00559503f, 
    0.06098578f, 0.10245638f, 0.04794051f, -0.00930778f, 0.06988409f, -0.09707866f, 0.05696173f, -0.02277110f, 
    -0.02547199f, 0.02014663f, -0.06490369f, 0.01322362f, 0.10293989f, 0.04657905f, -0.15382466f, 0.18234438f, 
    -0.14015609f, 0.03378194f, 0.06814251f, 0.00824236f, 0.05691944f, -0.09044698f, -0.00591366f, 0.12618124f, 
    -0.03647203f, -0.00440569f, -0.03189841f, -0.07023103f, 0.02607673f, 0.07704285f, -0.11577987f, -0.03062767f, 
    -0.05687809f, -0.25209826f, -0.01521121f, -0.03699536f, -0.14880529f, 0.00708093f, 0.01830735f, 0.00601010f, 
    -0.08234334f, 0.02701391f, 0.05027593f, 0.01732876f, -0.06121255f, 0.02004132f, 0.08104125f, -0.07274588f, 
    0.04549441f, -0.01745540f, 0.07361272f, -0.07653703f, 0.01344147f, -0.30452222f, 0.11601458f, -0.12315985f, 
    0.10147876f, 0.04301204f, 0.03138207f, -0.00616470f, 0.07913846f, -0.05839492f, 0.03754032f, -0.00491024f, 
    -0.01866486f, 0.03172335f, -0.01466630f, -0.02164473f, -0.05390735f, -0.07922089f, -0.04104245f, -0.00447316f, 
    0.03959497f, 0.12143095f, -0.18494731f, 0.18542564f, -0.31829587f, -0.07167763f, 0.09711133f, -0.00340629f, 
    0.07097240f, 0.00777950f, 0.04966995f, 0.04075819f, 0.04754769f, -0.01349229f, 0.03317890f, -0.04417728f, 
    0.03939036f, 0.14183304f, -0.07726092f, 0.02917368f, -0.13469793f, 0.21371165f, 0.03714415f, 0.07486946f, 
    -0.12905757f, -0.01860045f, 0.01729213f, 0.01940439f, 0.07348619f, 0.01775825f, -0.01357222f, 0.03917157f, 
    0.02070350f, -0.05688731f, -0.04214613f, -0.00514706f, -0.00435748f, 0.01031054f, 0.05107652f, -0.02146354f, 
    -0.07619280f, -0.01537978f, -0.12180416f, -0.26694867f, 0.12876371f, -0.08970560f, -0.06533594f, 0.02798116f, 
    -0.02314651f, -0.08995032f, -0.02721885f, 0.01165521f, -0.03204457f, -0.02715236f, -0.02191443f, -0.02083687f, 
    0.10117798f, 0.07094697f, 0.04017022f, 0.01296975f, 0.13995115f, -0.23435469f, 0.03064017f, 0.12068523f, 
    0.10755025f, 0.06922229f, -0.01198228f, 0.09849683f, 0.01773318f, -0.01184811f, -0.04911008f, 0.01889926f, 
    -0.06763057f, -0.04210351f, -0.03597123f, -0.03682647f, 0.01728861f, 0.12746097f, 0.06745220f, 0.04994199f, 
    0.10669301f, -0.27077395f, -0.01557313f, -0.11460631f, 0.02496751f, 0.06604319f, 0.04102200f, -0.04198210f, 
    0.01322608f, -0.10738425f, 0.01368516f, -0.02881581f, -0.00089575f, 0.08489570f, 0.03300644f, 0.17671831f, 
    -0.05262532f, 0.04201953f, -0.11339033f, 0.10316540f, -0.42099351f, 0.31037435f, 0.06375276f, 0.06239545f, 
    -0.20553493f, 0.12079476f, -0.02559182f, 0.06867674f, 0.03018722f, -0.13753669f, 0.05097166f, 0.03645745f, 
    -0.13707303f, 0.03825776f, -0.03851163f, 0.11161131f, -0.03815580f, -0.08460452f, -0.00688137f, 0.06285838f, 
    -0.35083103f, -0.09194241f, 0.01968068f, -0.14692177f, 0.07193186f, 0.10245390f, 0.07755531f, 0.06305299f, 
    -0.04972309f, 0.07499443f, 0.10483524f, -0.14168222f, -0.03232652f, 0.02606177f, 0.07793970f, -0.05867499f, 
    -0.06380712f, -0.02817142f, 0.16910170f, -0.11875238f, -0.01766813f, -0.03632490f, -0.05850105f, 0.11827791f, 
    0.18239936f, -0.02374386f, 0.07488775f, -0.03092020f, -0.05160242f, -0.12449215f, -0.00166427f, -0.00928731f, 
    -0.06229085f, 0.05632154f, 0.02432028f, 0.01318298f, 0.04069846f, 0.14881620f, 0.02516385f, 0.13738182f, 
    -0.01875916f, -0.10870206f, -0.25592911f, -0.10480580f, 0.09411326f, 0.01028546f, 0.10179108f, -0.01081392f, 
    -0.00359945f, 0.12153922f, -0.09753015f, -0.00728484f, 0.11143645f, -0.00142804f, -0.02225854f, 0.05092721f, 
    0.02825987f, 0.08851416f, 0.07763129f, 0.07831541f, -0.06551973f, -0.30005196f, -0.02210523f, -0.19467309f, 
    0.00557796f, -0.08030192f, 0.03867366f, -0.07365857f, 0.08347832f, -0.02189298f, -0.01612383f, 0.01084179f, 
    0.02709937f, 0.10667668f, 0.00585876f, -0.03573648f, 0.03527608f, -0.08666155f, -0.07895268f, 0.02600938f, 
    0.24948569f, -0.37715319f, 0.00566287f, -0.10234079f, -0.05187986f, 0.03421438f, -0.00837175f, 0.03407102f, 
    -0.03243876f, -0.02635747f, -0.01328441f, -0.07532449f, 0.17646384f, 0.01407552f, 0.04038256f, 0.02887558f, 
    0.01426382f, 0.03875824f, -0.07276408f, -0.01967832f, -0.05205276f, 0.07510072f, -0.07560391f, 0.03430711f, 
    -0.03000883f, 0.12354736f, 0.07976983f, -0.09542405f, -0.02127354f, 0.10001092f, -0.00221377f, 0.01754038f, 
    -0.03467809f, -0.01853866f, -0.12485068f, 0.00073186f, 0.04134523f, 0.02618607f, 0.09624483f, -0.01914152f, 
    -0.42218137f, 0.13017893f, -0.01305400f, 0.11516225f, 0.10475440f, 0.04539395f, 0.03066893f, 0.05505682f, 
    -0.02237667f, -0.01074935f, -0.03127405f, -0.00823298f, 0.13645376f, -0.07309035f, -0.00524814f, -0.04942039f, 
    0.02726071f, -0.13088076f, -0.09549017f, -0.08005533f, -0.02178703f, -0.03774629f, 0.00599639f, 0.02330131f, 
    -0.02031320f, -0.05909336f, -0.00136445f, -0.03633531f, 0.03633543f, 0.02517299f, 0.02178778f, -0.03108991f, 
    0.08590369f, 0.03028241f, 0.11312502f, -0.00254938f, 0.03316025f, -0.01155881f, -0.14153153f, 0.00802569f, 
    -0.10416269f, 0.11181838f, -0.05995417f, 0.09375234f, -0.23249871f, -0.02958004f, 0.12516342f, 0.03712932f, 
    -0.03952627f, -0.08088145f, 0.08626337f, -0.06835824f, -0.07955640f, -0.02371327f, 0.02059756f, 0.02964184f, 
    -0.02738122f, 0.19785285f, -0.15270439f, 0.09496958f, -0.34711194f, 0.14854541f, -0.07341292f, 0.18824825f, 
    -0.09490278f, -0.14804901f, -0.09021428f, 0.02221323f, -0.01180235f, 0.04732536f, -0.02323755f, -0.01235654f, 
    0.02275226f, -0.06309329f, -0.00669205f, -0.08033048f, -0.01644652f, -0.10995735f, -0.12288566f, -0.12197431f, 
    -0.08898718f, -0.08344434f, -0.02800633f, 0.14290218f, -0.00782457f, 0.04398670f, 0.06040429f, -0.05146269f, 
    0.11295813f, 0.00716793f, -0.09982939f, 0.03254094f, -0.02116759f, -0.01372281f, 0.04788375f, 0.07731243f, 
    -0.00685659f, 0.03033442f, -0.08909887f, -0.03632246f, -0.17514437f, 0.21934874f, 0.04999297f, 0.03188776f, 
    -0.26385102f, 0.07431046f, 0.06303149f, 0.03879535f, 0.03414622f, 0.00567304f, -0.03474339f, 0.04659313f, 
    0.01901107f, -0.06664521f, -0.03856869f, -0.02476204f, -0.00508676f, -0.02729625f, 0.01714757f, -0.04907453f, 
    -0.28201842f, 0.03058315f, 0.03094598f, 0.04111549f, 0.07432494f, 0.10595779f, 0.01850436f, 0.02244356f, 
    -0.02377780f, 0.00956200f, 0.07107767f, -0.03249187f, 0.05164147f, 0.07629263f, -0.06482541f, 0.08722058f, 
    0.02447231f, -0.16696124f, 0.00897926f, -0.05443253f, 0.11775604f, 0.03026295f, 0.03627625f, 0.04071309f, 
    0.05724717f, 0.04084761f, -0.00001039f, 0.03651545f, 0.03974613f, 0.00741933f, -0.02140654f, -0.01708899f, 
    0.00855931f, -0.01160832f, 0.04395106f, -0.02000454f, -0.01918183f, 0.04260567f, -0.02404969f, -0.05679936f, 
    0.00237247f, 0.09285303f, 0.02227758f, -0.11638149f, -0.11360327f, -0.03236016f, 0.02224676f, 0.06115538f, 
    0.01571723f, 0.06189575f, -0.00575316f, 0.00024134f, -0.05716842f, -0.05139482f, -0.07595696f, 0.04759596f, 
    -0.17657903f, 0.15131487f, 0.09226415f, 0.00357017f, 0.15990376f, -0.02965540f, 0.07800946f, -0.16899872f, 
    0.10245501f, 0.02332697f, -0.01701521f, -0.00270813f, -0.05964296f, -0.02404137f, -0.02930767f, 0.02746723f, 
    -0.08270697f, -0.07295068f, -0.01123139f, -0.04363206f, 0.06259517f, 0.05055443f, 0.04176191f, 0.09959098f, 
    0.22154473f, 0.09345382f, 0.01878336f, -0.00958443f, 0.07711679f, -0.20211904f, 0.01551543f, 0.04453002f, 
    0.01972270f, -0.00863763f, 0.09185268f, -0.11166611f, 0.07028057f, 0.03588266f, 0.00367507f, 0.01133546f, 
    0.02957101f, 0.07302299f, -0.03672809f, 0.05609023f, -0.19015495f, 0.12002238f, 0.04429530f, -0.30103651f, 
    0.04093685f, -0.01288750f, -0.10648283f, -0.04301606f, -0.06061708f, -0.19495510f, 0.02702633f, -0.05183423f, 
    0.02108100f, -0.03415762f, -0.00148474f, 0.02634386f, -0.03966101f, 0.00927291f, 0.00488423f, 0.08059169f, 
    -0.05370129f, -0.00174631f, 0.00644625f, -0.15486988f, 0.08956839f, -0.01357454f, 0.06227414f, 0.05443964f, 
    -0.08396986f, 0.00409098f, 0.05535404f, -0.07741975f, 0.06400631f, 0.03094230f, -0.02824179f, -0.00569864f, 
    -0.00110422f, -0.05640690f, 0.05813032f, 0.13122113f, -0.17173743f, -0.03484146f, -0.08557031f, -0.22795995f, 
    0.05029662f, 0.03516260f, -0.00559045f, 0.03551334f, -0.08718757f, 0.01562111f, -0.07420821f, -0.03306065f, 
    -0.03324026f, -0.05469568f, 0.02640349f, 0.02076044f, -0.00244706f, 0.05851406f, 0.13046250f, 0.04883921f, 
    -0.15878664f, 0.17816357f, -0.00483572f, 0.10353488f, -0.06746687f, -0.02637899f, -0.05695324f, -0.01120460f, 
    0.07677087f, 0.02809024f, -0.00826951f, 0.02659852f, -0.03496305f, 0.02571617f, 0.07244742f, -0.04238793f, 
    0.00424654f, -0.09188654f, -0.00020342f, -0.07022483f, 0.34207621f, -0.19103169f, 0.06100317f, 0.01367232f, 
    -0.09684128f, 0.01441277f, 0.09519285f, 0.03120175f, -0.05211392f, -0.04976646f, 0.05401529f, -0.05079023f, 
    -0.01394656f, 0.06231458f, 0.03973131f, -0.00515214f, 0.04493785f, -0.02361969f, 0.06776971f, 0.05979256f, 
    -0.05855337f, -0.17839622f, -0.04834697f, 0.03897139f, 0.12400242f, 0.04420447f, 0.02497621f, 0.02702429f, 
    0.00318070f, 0.04933633f, 0.04745966f, -0.02758426f, 0.02314505f, -0.08210202f, -0.01695168f, -0.00013036f, 
    -0.00292525f, -0.05076514f, 0.01460174f, -0.00083033f, 0.04494923f, 0.05269493f, -0.02279502f, -0.10975458f, 
    0.21148346f, 0.02457440f, 0.03625631f, -0.09014985f, -0.15084714f, -0.09697799f, -0.02761986f, 0.04427105f, 
    -0.02970759f, 0.01876076f, 0.01947373f, 0.12505199f, 0.06831054f, 0.01158688f, 0.03770797f, -0.09734247f, 
    -0.14860563f, -0.36502424f, -0.07694404f, -0.02452151f, 0.13383448f, -0.06837624f, 0.07903939f, 0.00596635f, 
    -0.13164727f, 0.02839074f, -0.03286316f, -0.06905023f, -0.01299834f, 0.07313386f, -0.14644025f, 0.02424641f, 
    -0.00431403f, -0.03734750f, -0.05003683f, -0.05590664f, -0.02954130f, -0.01121056f, -0.02951418f, 0.08024976f, 
    0.02695531f, -0.04804717f, -0.01455404f, 0.01650683f, 0.00566731f, -0.04765674f, 0.01219753f, 0.01681243f, 
    0.00616787f, -0.04355109f, -0.00824582f, -0.03395067f, -0.01265422f, 0.02509464f, -0.06387135f, -0.10271671f, 
    0.17967984f, -0.02799490f, -0.04751604f, -0.03803390f, -0.05524213f, 0.03583532f, 0.09674402f, 0.00113462f, 
    -0.10025290f, -0.05927217f, -0.03005945f, -0.02028707f, 0.07201689f, -0.02185431f, 0.00789660f, -0.03436139f, 
    -0.04011163f, 0.04883905f, 0.02309723f, 0.05991614f, 0.03549540f, 0.09565101f, 0.11912922f, -0.00584171f, 
    -0.15194026f, 0.13570201f, 0.00150795f, 0.04169150f, -0.02287204f, 0.00067946f, -0.00159110f, -0.00865270f, 
    0.02203257f, 0.01925913f, -0.05793087f, 0.00309427f, 0.07346530f, -0.01916646f, -0.00059732f, -0.09251434f, 
    -0.03706028f, -0.07937182f, -0.03738553f, 0.06504901f, -0.09929283f, -0.09182046f, -0.02817549f, -0.01198778f, 
    0.02264743f, 0.00645976f, -0.15658103f, -0.00874138f, -0.03089454f, 0.01420468f, -0.01789572f, -0.00984040f, 
    -0.06781328f, 0.00563806f, -0.12410422f, -0.04256778f, 0.03307694f, -0.22455727f, -0.01959007f, 0.08473769f, 
    -0.01494994f, -0.04287574f, -0.01703781f, 0.03875459f, -0.03743368f, 0.03862322f, 0.02890336f, -0.00880249f, 
    -0.05462293f, 0.09042894f, -0.01714442f, -0.03410575f, 0.00547401f, 0.03904090f, -0.07366182f, -0.04592074f, 
    -0.10832238f, 0.10383737f, -0.16596927f, 0.20152101f, -0.19931152f, 0.00288882f, 0.10459715f, -0.02519854f, 
    -0.00710906f, 0.06867480f, 0.00024670f, 0.05357795f, -0.00511272f, -0.02328470f, -0.09126136f, 0.01669222f, 
    -0.01700606f, 0.01295314f, -0.12375104f, -0.00039675f, -0.22291757f, 0.16818890f, 0.05473996f, 0.02435206f, 
    -0.17947644f, 0.05192350f, 0.01440905f, 0.03122248f, 0.04541212f, 0.01429873f, -0.00501647f, 0.00663533f, 
    0.01511222f, 0.03289085f, -0.09710792f, -0.05257612f, 0.04450418f, -0.02383130f, 0.03227260f, 0.01612186f, 
    0.18884248f, -0.12104575f, -0.14440978f, 0.01541099f, 0.01513808f, 0.00849029f, 0.04004711f, -0.00579411f, 
    -0.02210390f, -0.09716249f, 0.03687227f, -0.05986111f, -0.08103440f, -0.04113887f, -0.09300883f, -0.11963900f, 
    -0.01921599f, 0.03477110f, 0.02154664f, 0.10694750f, -0.22133583f, 0.13465764f, 0.13045672f, 0.06592190f, 
    -0.35539797f, 0.07863768f, -0.04136602f, 0.07469363f, 0.01326158f, 0.00260492f, -0.02502565f, -0.04454404f, 
    -0.00978290f, 0.08780100f, -0.07101934f, 0.03922525f, 0.00293932f, -0.05013932f, 0.02185242f, -0.00251267f, 
    0.16124678f, 0.08897218f, -0.05254519f, -0.01489895f, 0.17400050f, -0.06283492f, -0.06079991f, 0.01781736f, 
    0.07427686f, 0.07445635f, 0.00923765f, -0.03598558f, -0.00065806f, -0.04048052f, -0.05825622f, 0.03398693f, 
    -0.01566940f, -0.00653197f, -0.02740391f, 0.08937496f, 0.00122559f, -0.02081001f, 0.00398446f, -0.31681675f, 
    0.09772798f, -0.02912803f, 0.02728079f, -0.08341286f, -0.03283959f, -0.10980094f, 0.05766153f, 0.05861072f, 
    -0.00402911f, 0.01181405f, 0.01540341f, -0.00316584f, 0.10868239f, -0.04166804f, -0.00800276f, 0.04866762f, 
    -0.12811643f, -0.15036321f, -0.00305015f, -0.00509309f, 0.01588945f, -0.09145333f, 0.06639401f, -0.08118056f, 
    -0.03417048f, -0.02091981f, -0.00031887f, -0.01802824f, 0.04865932f, 0.05027604f, 0.02614994f, 0.11794414f, 
    -0.00393399f, -0.02484416f, -0.00713971f, 0.09282101f, -0.04291151f, 0.05280111f, -0.11584721f, -0.19429021f, 
    -0.07644247f, -0.11624129f, 0.00526158f, 0.08826927f, -0.00438285f, 0.05604228f, 0.00689936f, -0.10445441f, 
    -0.09545354f, 0.01855377f, -0.02076783f, -0.05955496f, -0.08387659f, 0.11888205f, 0.15658613f, 0.07216144f, 
    -0.13097271f, 0.05313376f, -0.08544686f, -0.17844184f, -0.03823185f, 0.04437048f, 0.02289241f, 0.09645759f, 
    0.02563075f, -0.07336868f, 0.03816706f, -0.01401539f, -0.05911832f, -0.07205600f, 0.00364301f, -0.06393304f, 
    -0.04879119f, -0.07717649f, 0.11536907f, 0.01105801f, 0.10048033f, -0.33115932f, 0.00091096f, -0.29469833f, 
    0.06943479f, 0.06546942f, -0.05688223f, -0.01389321f, -0.08305447f, -0.06387702f, -0.03586415f, -0.02758287f, 
    0.11351689f, 0.05873494f, 0.03532344f, 0.02329195f, -0.03806273f, -0.07879803f, -0.03315094f, 0.06521536f, 
    0.14475702f, -0.26558679f, -0.00297641f, 0.09839250f, 0.00185504f, -0.02164715f, -0.06633986f, 0.00173729f, 
    0.00485775f, 0.01989979f, 0.00245858f, -0.02725125f, -0.05821131f, -0.09493691f, 0.05088397f, -0.03434766f, 
    -0.02482416f, -0.01695710f, -0.01387846f, -0.13100436f, 0.04625776f, -0.34723338f, -0.04672229f, -0.17756835f, 
    0.03685775f, -0.12614919f, 0.12510346f, 0.04771935f, -0.00620188f, 0.05145145f, -0.07223427f, 0.03742890f, 
    0.02972766f, 0.09271866f, -0.00992409f, -0.09505668f, 0.00710983f, 0.01488988f, -0.06768233f, 0.02968061f, 
    -0.04686628f, 0.07472526f, -0.22377741f, -0.12492265f, -0.04127313f, 0.07973691f, 0.00835318f, -0.09570024f, 
    0.05322628f, -0.05535280f, -0.12094319f, 0.02721031f, -0.08530203f, -0.05894330f, -0.02821716f, 0.00349596f, 
    -0.09083499f, -0.04370230f, -0.03333624f, 0.05416055f, 0.08472028f, -0.12744454f, -0.09421876f, 0.02452063f, 
    0.04637949f, -0.01613004f, -0.09180980f, -0.04229006f, 0.02521003f, -0.05178594f, -0.02798542f, -0.01767080f, 
    0.00305515f, 0.02281092f, 0.04873905f, -0.10040427f, 0.05501334f, -0.00823565f, 0.01459112f, 0.01438278f, 
    -0.00554900f, 0.00702158f, 0.12439153f, 0.03329657f, 0.03019904f, 0.05283365f, -0.04319596f, 0.08465067f, 
    -0.00638096f, 0.00112815f, -0.01760902f, 0.01978520f, 0.03908317f, 0.02411214f, -0.05025671f, 0.01484639f, 
    -0.02949336f, 0.03205636f, -0.00582290f, -0.05672698f, 0.11267010f, 0.10327540f, 0.16229922f, 0.07886960f, 
    0.09453059f, 0.00994877f, 0.01541428f, -0.03428117f, 0.00495674f, -0.05172807f, -0.06290589f, 0.00262135f, 
    -0.04880956f, 0.02383564f, -0.06246084f, 0.01077064f, -0.03544062f, -0.00380624f, -0.03724771f, -0.08363651f, 
    -0.04551258f, -0.07888163f, -0.15215619f, -0.00572826f, 0.03748868f, -0.03368807f, 0.01018162f, 0.00718788f, 
    -0.00799352f, -0.02070936f, -0.01703858f, -0.02037237f, -0.03096615f, -0.02602310f, 0.02613377f, 0.00818144f, 
    -0.02189593f, 0.02530718f, -0.01991601f, -0.02286063f, -0.02247675f, 0.02442995f, 0.10633984f, 0.05607035f, 
    0.05724340f, 0.01343339f, 0.04257121f, -0.03695030f, -0.01112891f, -0.07263337f, -0.01840045f, 0.00612050f, 
    0.00458701f, -0.01463019f, -0.01393256f, 0.00321008f, -0.05060738f, 0.00299209f, 0.05055349f, -0.03965112f, 
    -0.04192581f, 0.12075841f, 0.15792453f, 0.12673245f, 0.21253262f, 0.10525304f, 0.16891696f, -0.00215040f, 
    0.00357507f, -0.00325751f, 0.03235682f, -0.00900727f, 0.06311718f, -0.01107748f, -0.00296660f, -0.01811114f, 
    0.00783775f, -0.01386774f, -0.03695737f, 0.03971140f, 0.02900124f, 0.18535431f, -0.06824647f, 0.12160655f, 
    0.15702261f, -0.08275810f, 0.02230783f, -0.09563013f, -0.00224886f, -0.01475581f, -0.09937423f, -0.01319898f, 
    -0.08187019f, -0.00595784f, -0.02807634f, 0.06547839f, -0.01994521f, 0.05633748f, -0.08180229f, -0.01862647f, 
    -0.05729356f, 0.03096594f, -0.05192873f, 0.03213431f, 0.05739711f, -0.04141092f, -0.03003961f, -0.07123622f, 
    0.04832220f, 0.02791848f, -0.03658339f, 0.02497185f, -0.08751201f, -0.00587998f, -0.01520852f, -0.01055292f, 
    -0.06303976f, 0.02452968f, -0.04756445f, -0.04346334f, -0.02584844f, 0.05521594f, -0.09766569f, 0.02642468f, 
    0.00205546f, -0.04365132f, -0.02074428f, -0.03383644f, 0.06280676f, 0.01565291f, -0.04305134f, -0.00472064f, 
    -0.03892068f, 0.04206165f, -0.01897951f, 0.01791488f, -0.01626007f, 0.00430023f, -0.05072568f, -0.00896742f, 
    0.11153708f, 0.07751586f, -0.08384007f, -0.08229852f, 0.06908870f, -0.17491032f, 0.01110669f, 0.05089838f, 
    -0.00516496f, 0.00079964f, -0.04704180f, -0.01360528f, -0.04719597f, 0.02709955f, -0.00246437f, 0.01757512f, 
    0.05604853f, 0.00300150f, -0.02604443f, 0.01046178f, -0.01647585f, 0.05139634f, 0.00207072f, 0.04877526f, 
    0.06841747f, -0.05073595f, 0.03589737f, -0.00733408f, -0.01601914f, 0.00726322f, -0.12665965f, 0.02869400f, 
    -0.10700370f, -0.05103041f, -0.08912731f, -0.03779513f, -0.00647800f, 0.01293432f, -0.08157739f, 0.02328642f, 
    -0.17717375f, 0.13723500f, 0.09241067f, -0.06395551f, -0.06179013f, -0.06258091f, -0.00087654f, -0.03879200f, 
    -0.02444966f, -0.06195326f, 0.00252318f, 0.04391114f, -0.01166033f, 0.01823974f, -0.02280199f, 0.04090182f, 
    0.05792696f, -0.02969825f, -0.01174967f, -0.01427562f, -0.40068468f, 0.08878198f, -0.06210368f, 0.02112143f, 
    0.03252037f, 0.03281761f, -0.08017223f, -0.02736431f, 0.09428030f, -0.00212195f, -0.03263843f, 0.04704050f, 
    0.00442036f, 0.01008449f, 0.02198667f, -0.01829654f, -0.01076994f, 0.04088317f, 0.05081644f, 0.06921671f, 
    0.05105454f, -0.07950747f, 0.05993012f, 0.06336403f, 0.04735317f, 0.04573546f, -0.00078318f, -0.03772323f, 
    0.00766793f, 0.00241036f, -0.02420973f, 0.01352689f, -0.01109494f, -0.02015031f, -0.00861429f, -0.06508990f, 
    0.04837244f, -0.01308160f, 0.02345317f, -0.02701683f, 0.00225642f, -0.14508024f, 0.10335122f, -0.04187632f, 
    0.01165767f, -0.08384629f, 0.04920499f, -0.07358068f, -0.01578162f, 0.02290718f, 0.01623282f, 0.03775640f, 
    -0.08019900f, 0.01377391f, 0.02377208f, -0.01126911f, -0.01353060f, 0.06218035f, -0.00045142f, -0.04733897f, 
    -0.09942368f, 0.13228473f, -0.00578057f, -0.04564264f, 0.04992222f, -0.01830082f, -0.02981218f, -0.08812581f, 
    -0.00622512f, -0.06120873f, -0.04246405f, 0.01113409f, 0.04100405f, 0.08418041f, -0.04433937f, 0.05184842f, 
    0.04004750f, 0.01371175f, 0.02198821f, -0.00304978f, -0.17234081f, -0.05735163f, -0.17316388f, -0.14764696f, 
    -0.04039899f, 0.01216755f, -0.09228950f, -0.01015038f, -0.01608934f, -0.03356140f, -0.09874588f, 0.03421246f, 
    0.06059204f, -0.01922007f, -0.03054453f, -0.04500376f, -0.05315962f, -0.01887820f, -0.01523684f, -0.01236353f, 
    0.06862297f, 0.11250595f, 0.07378477f, 0.09793910f, 0.13066180f, -0.00801664f, 0.05595151f, 0.02475943f, 
    -0.03235162f, 0.00274316f, -0.06995154f, -0.00449577f, -0.04475290f, -0.03801674f, -0.08540765f, 0.00213609f, 
    0.00183142f, -0.00271692f, -0.01052647f, -0.02400316f, 0.18045858f, -0.23327172f, 0.13240077f, 0.07159077f, 
    -0.11188208f, 0.12298483f, -0.02963586f, -0.05897570f, 0.01453616f, 0.00397427f, -0.04490995f, 0.06502368f, 
    -0.02878797f, 0.00323277f, -0.01203295f, 0.02042382f, 0.05215748f, 0.00358346f, -0.02215705f, 0.01789254f, 
    -0.03872270f, 0.09787226f, 0.16507295f, -0.05243337f, 0.00713052f, -0.08246147f, 0.03738552f, -0.02906195f, 
    -0.00460302f, -0.04828951f, -0.03706685f, 0.03314858f, -0.04613736f, -0.00141573f, -0.08109278f, -0.01413678f, 
    -0.00547293f, 0.01909905f, 0.01433707f, -0.02998386f, -0.09791440f, -0.21915291f, -0.06885239f, -0.19110094f, 
    -0.25592491f, 0.03580454f, 0.02758645f, -0.01697394f, -0.07335915f, -0.02619991f, -0.01947170f, 0.04314050f, 
    -0.00259044f, -0.06605633f, -0.03440635f, -0.03332018f, 0.06398433f, 0.02765658f, -0.00686150f, 0.02353068f, 
    0.14857845f, 0.06827570f, 0.14343700f, 0.06788363f, 0.03247588f, -0.01243257f, -0.02484093f, -0.08212389f, 
    -0.01783710f, 0.01277047f, -0.01360844f, 0.01497291f, -0.03802463f, 0.07153790f, -0.04951851f, -0.03322550f, 
    0.03098973f, 0.02736877f, 0.06230318f, -0.07297678f, -0.04176540f, 0.07287060f, 0.12710799f, 0.03111649f, 
    0.00939069f, 0.12619895f, -0.01357728f, 0.02033479f, 0.05973054f, 0.01919506f, -0.09339125f, 0.07801457f, 
    0.05252582f, 0.00431897f, -0.03082184f, 0.03803612f, 0.02463108f, -0.02134384f, -0.02643088f, 0.01538774f, 
    -0.00259865f, 0.17811793f, -0.12293903f, 0.08268251f, 0.10616417f, -0.07552780f, -0.00436439f, -0.06122973f, 
    -0.01107567f, 0.00540529f, -0.10775594f, -0.01796641f, 0.01873623f, -0.02932646f, -0.06944088f, 0.00545870f, 
    -0.00668762f, 0.06372098f, -0.02046093f, 0.01740682f, 0.08703664f, 0.05058579f, 0.18211564f, 0.07210805f, 
    0.05220414f, 0.01495082f, 0.05555714f, -0.00362569f, 0.02175049f, 0.01750523f, -0.00647962f, 0.00121512f, 
    0.02118049f, 0.04005656f, -0.04539892f, -0.04243398f, 0.00513169f, 0.00812174f, 0.04984287f, 0.00875386f, 
    0.14594078f, -0.01218965f, 0.03954950f, -0.03217549f, 0.07293928f, 0.00509528f, 0.06460845f, -0.01214059f, 
    0.03333848f, -0.01550769f, -0.06541710f, 0.02537134f, -0.02364180f, 0.04084827f, -0.07685422f, -0.01756025f, 
    0.00312185f, -0.01024428f, -0.02738389f, -0.05564823f, -0.01696958f, 0.08593743f, -0.06625304f, -0.09058358f, 
    0.08285017f, -0.00041700f, 0.03290561f, -0.12295317f, -0.05664337f, -0.00744708f, -0.01160153f, 0.00148265f, 
    0.02386114f, -0.00121251f, -0.03805175f, -0.04283009f, -0.02122136f, 0.01426351f, -0.03815398f, 0.01807112f, 
    0.03651798f, -0.04581091f, 0.01712011f, -0.06772448f, -0.05817865f, 0.02600017f, -0.01036206f, -0.04257708f, 
    -0.05019509f, 0.00945654f, -0.00413548f, 0.03508097f, 0.07212735f, -0.02524297f, -0.07017092f, 0.02574996f, 
    0.06058475f, -0.03904934f, -0.02679282f, 0.03288933f, -0.07170442f, 0.06331408f, -0.15348211f, -0.05715560f, 
    -0.06481209f, -0.12161597f, -0.02991580f, 0.00059094f, -0.05499875f, -0.04533371f, 0.02462172f, -0.00084341f, 
    -0.04902354f, 0.06718846f, -0.07135847f, 0.02401908f, -0.02693999f, -0.02622150f, -0.04264300f, -0.06022765f, 
    -0.11166196f, 0.12491190f, -0.22485131f, 0.11831142f, 0.06716167f, -0.04471777f, -0.12972634f, -0.06465993f, 
    0.05405622f, -0.02505376f, -0.07035021f, 0.10787580f, 0.02605760f, -0.07943368f, -0.06878544f, -0.00431759f, 
    0.01119513f, 0.02274478f, 0.03292781f, 0.02364975f, -0.01700135f, -0.02887701f, -0.00696370f, -0.09753365f, 
    -0.08154047f, -0.00745978f, -0.03799727f, 0.01590735f, -0.04476002f, -0.12530971f, 0.04787134f, -0.03202312f, 
    -0.03570970f, 0.01868735f, -0.07041673f, 0.05479045f, 0.04463598f, -0.02099658f, -0.01240097f, 0.00422308f, 
    -0.21568723f, 0.07518348f, 0.12003626f, -0.01376126f, -0.02933613f, -0.02230548f, -0.09348560f, -0.02087652f, 
    0.07519129f, -0.06081296f, -0.03005539f, 0.02883518f, -0.03795609f, -0.01426663f, -0.04775154f, 0.00952025f, 
    0.03657111f, 0.05622038f, -0.05100684f, -0.00608831f, -0.37854320f, -0.09012306f, -0.22962593f, -0.15602583f, 
    -0.17739004f, 0.01243709f, -0.03983168f, -0.04861456f, 0.02408490f, -0.04677369f, -0.04929293f, -0.02444553f, 
    0.01798080f, -0.06183016f, 0.00467020f, -0.06907811f, 0.00110215f, 0.03746907f, -0.01706087f, 0.04563890f, 
    -0.03794383f, 0.03577222f, -0.01339430f, -0.14131811f, -0.09698472f, -0.08934044f, 0.09683429f, 0.06942611f, 
    0.00636473f, 0.02386607f, -0.02774293f, -0.02357584f, 0.01826218f, -0.08809221f, 0.11176895f, -0.04560481f, 
    0.02470995f, -0.00773627f, -0.01563922f, 0.03160032f, 0.10318512f, 0.03912659f, -0.04218300f, -0.00263059f, 
    -0.00279292f, -0.05861480f, 0.01612670f, -0.01087710f, -0.01905168f, -0.01160083f, -0.03637502f, 0.01279074f, 
    -0.00608810f, -0.01154095f, 0.03199681f, -0.07543306f, -0.02338959f, 0.01652618f, 0.04158974f, -0.05381041f, 
    -0.00556831f, -0.09371396f, -0.13194209f, 0.01711271f, 0.13377577f, -0.09296866f, -0.14917397f, -0.06964058f, 
    -0.04003955f, -0.01775083f, -0.02330213f, 0.04713118f, -0.00284213f, -0.04745359f, -0.04000379f, -0.08237352f, 
    -0.00325346f, -0.01344687f, -0.03169546f, 0.04326393f, 0.11351503f, -0.03819114f, 0.10350515f, 0.06905404f, 
    0.10530973f, 0.03982317f, 0.03172566f, -0.04015439f, -0.07003503f, 0.03900199f, -0.01245182f, -0.02918939f, 
    -0.01433093f, -0.01228262f, -0.02100649f, -0.02462411f, 0.01249831f, 0.06088752f, 0.06517006f, -0.01382849f, 
    0.17349318f, 0.03122793f, -0.01133273f, -0.06601181f, 0.13521008f, -0.22580673f, -0.03449379f, -0.05775949f, 
    -0.02160271f, -0.02600725f, 0.05339052f, 0.00567838f, -0.04532997f, 0.03957490f, -0.08453690f, 0.01924456f, 
    0.03941123f, 0.03834014f, -0.05679752f, -0.04350368f, 0.05951016f, 0.06763870f, 0.16081202f, 0.10602617f, 
    0.11962307f, 0.06435461f, 0.08392259f, 0.00339465f, -0.02140427f, -0.04163393f, -0.01229635f, -0.00096257f, 
    -0.05953811f, -0.03358874f, -0.07603504f, -0.00796685f, -0.02574407f, 0.02683502f, 0.00866486f, -0.06716751f, 
    0.11956492f, 0.00456628f, 0.14212821f, -0.02121286f, 0.01924798f, -0.00728213f, 0.07237177f, -0.04051290f, 
    -0.05979593f, -0.04631183f, -0.03016491f, 0.01332056f, -0.05854065f, -0.00028402f, -0.05926280f, -0.03294491f, 
    0.02086196f, -0.02849934f, 0.05972620f, -0.06212819f, 0.15508883f, 0.13557495f, 0.06398833f, 0.00592961f, 
    0.16041629f, 0.03871234f, 0.06435212f, -0.07550657f, 0.03977269f, -0.00220729f, 0.00399825f, -0.00059533f, 
    -0.01145669f, -0.02155273f, -0.00234245f, -0.09575766f, 0.05095247f, 0.00047021f, 0.06558353f, -0.03033331f, 
    -0.00562223f, -0.11336128f, -0.06881488f, -0.12497215f, -0.10400408f, -0.01403377f, -0.05209767f, -0.03125805f, 
    -0.02138269f, -0.04741773f, 0.01128970f, -0.03397352f, 0.00038675f, -0.00367058f, -0.01237631f, -0.02774440f, 
    -0.03124909f, -0.05409926f, 0.01735312f, -0.01477442f, 0.19636503f, -0.31698111f, 0.04382422f, -0.07816494f, 
    0.22701475f, -0.02625996f, -0.02905707f, 0.03655245f, -0.00264161f, 0.01151156f, -0.05566332f, 0.00192946f, 
    -0.04355114f, 0.08438414f, -0.03004209f, -0.05316146f, 0.07726660f, 0.01859904f, 0.03102313f, -0.02808402f, 
    -0.12961444f, 0.04136473f, -0.02708840f, -0.05667993f, 0.04802793f, -0.01320460f, 0.06791645f, -0.05737926f, 
    -0.05751787f, 0.00953352f, -0.01111383f, 0.02490951f, -0.03547795f, 0.00166880f, 0.01294538f, 0.03890329f, 
    0.00224321f, 0.02355819f, -0.02007420f, 0.00246769f, -0.04297270f, 0.13550985f, 0.04311118f, 0.05904832f, 
    0.13452192f, 0.05600211f, 0.02163363f, -0.06297307f, 0.01719423f, 0.03375193f, -0.02608225f, -0.02301602f, 
    0.03896458f, -0.02704531f, -0.01948798f, 0.08457802f, -0.03063657f, 0.07315335f, 0.04250255f, -0.07394984f, 
    -0.04640174f, 0.02086997f, 0.03779733f, -0.12936358f, -0.03028034f, -0.07008799f, -0.01181339f, 0.01058483f, 
    -0.06515185f, 0.02659445f, -0.05050179f, 0.01644597f, -0.03957594f, -0.00628692f, 0.06052710f, -0.06041893f, 
    0.02644150f, 0.04764633f, 0.00374938f, 0.04208468f, -0.03908871f, -0.02383007f, -0.01890807f, -0.03509989f, 
    -0.05067539f, -0.02993804f, -0.02898354f, -0.04780113f, -0.05340738f, -0.04967409f, -0.01607658f, 0.03755808f, 
    -0.03098468f, 0.00338515f, 0.00649090f, -0.03008173f, -0.03983985f, 0.03174592f, -0.03405544f, -0.06174615f, 
    0.06933878f, 0.08800604f, 0.14497113f, -0.06622879f, 0.05607057f, -0.02865627f, 0.08561067f, 0.01759415f, 
    -0.01250580f, -0.01892934f, -0.01047664f, -0.02967643f, -0.04479420f, 0.02246331f, -0.03808134f, -0.02603656f, 
    -0.01049221f, -0.03500766f, -0.01395540f, -0.02141010f, 0.12198609f, -0.33821088f, -0.00215636f, -0.16814934f, 
    -0.18768241f, 0.03668948f, -0.02296172f, -0.00885352f, -0.05314266f, -0.02220540f, -0.03960758f, -0.05506720f, 
    -0.04226782f, 0.01137162f, -0.07873637f, -0.05384362f, 0.10728733f, -0.04415170f, 0.04417994f, -0.03540514f, 
    -0.10134166f, -0.00305528f, 0.04393033f, -0.01442894f, -0.07606243f, -0.01272373f, -0.09982571f, -0.02125147f, 
    -0.04881231f, -0.00866808f, -0.01265121f, 0.03926606f, -0.01867859f, 0.08555053f, -0.10193857f, 0.00829682f, 
    0.01890473f, -0.04235124f, -0.04350661f, 0.03498008f, 0.06440507f, -0.19665016f, 0.02057739f, 0.01777746f, 
    -0.11017168f, -0.00874352f, -0.02725154f, -0.03103550f, -0.03882017f, -0.05903710f, 0.01274713f, 0.02733503f, 
    -0.03060677f, 0.00551796f, -0.07281845f, -0.05519442f, 0.01643129f, -0.00549554f, -0.03330757f, -0.01047118f, 
    -0.28035244f, 0.18954313f, 0.09872435f, -0.05347073f, -0.00412402f, 0.04935756f, 0.02064519f, -0.09284373f, 
    0.03971048f, -0.05742085f, 0.00195988f, 0.03554928f, -0.04724645f, 0.02919444f, -0.05579283f, 0.00335162f, 
    0.04381277f, 0.08273286f, -0.00948259f, 0.01356524f, -0.10720586f, -0.12516776f, -0.07827598f, -0.05208553f, 
    -0.12434711f, -0.02716664f, -0.04572434f, -0.03455774f, 0.01062585f, -0.03591703f, -0.01158723f, -0.02497982f, 
    0.02439206f, -0.06161284f, -0.02850430f, -0.01476321f, 0.04074458f, -0.04813438f, 0.00172728f, -0.03136218f, 
    -0.09525219f, 0.01217211f, 0.01381065f, 0.02756944f, 0.03220496f, -0.07138062f, -0.06656805f, 0.00860281f, 
    0.00363096f, 0.04691160f, -0.03846963f, 0.02799668f, -0.02766169f, -0.02762178f, 0.01725639f, 0.02657824f, 
    -0.01912893f, 0.00920117f, 0.04735463f, -0.00155119f, -0.01010856f, -0.29898271f, -0.06744537f, -0.08783434f, 
    -0.18260650f, -0.02507322f, -0.07427423f, 0.00073009f, -0.04176147f, -0.09696834f, 0.01926814f, -0.05841728f, 
    -0.06769025f, 0.00339428f, -0.03151032f, 0.02114248f, 0.01032122f, -0.03552124f, -0.01075695f, -0.06024377f, 
    -0.04959340f, 0.03355446f, -0.05774458f, 0.09545100f, -0.01071668f, 0.06861484f, -0.03150237f, -0.02058148f, 
    -0.00718867f, -0.04233990f, -0.03138581f, 0.00104824f, -0.03062664f, 0.00513102f, -0.03167986f, 0.13035999f, 
    -0.02586843f, 0.00536464f, -0.02576461f, -0.02006549f, -0.04035043f, 0.13614219f, 0.11446015f, 0.13331164f, 
    0.11089569f, 0.06440543f, 0.09962236f, 0.01748698f, -0.05232083f, 0.02535563f, -0.05291754f, -0.02031063f, 
    -0.00018581f, 0.00643342f, -0.03837010f, 0.02450733f, 0.05155257f, 0.03106230f, 0.00382633f, -0.00693576f, 
    -0.14595771f, 0.09639249f, -0.19776739f, -0.02201267f, -0.06305991f, -0.05782268f, -0.01510057f, 0.00085000f, 
    -0.05483750f, -0.00996278f, -0.00037016f, -0.01840082f, -0.07195354f, 0.00729864f, -0.04618488f, -0.01646156f, 
    -0.00991387f, -0.02275543f, -0.03612272f, -0.07085903f, 0.03259569f, 0.02277864f, -0.05823697f, 0.03075443f, 
    0.15079433f, -0.04318924f, -0.14837496f, -0.10193163f, -0.03984432f, -0.00887288f, 0.01998001f, 0.06540140f, 
    -0.03070912f, 0.02302798f, -0.09778526f, -0.02694757f, -0.00380533f, 0.00634588f, -0.06246422f, 0.02072866f, 
    0.08464935f, 0.06866734f, 0.06368977f, 0.05901205f, 0.15492865f, 0.02967046f, 0.02367127f, -0.02089548f, 
    -0.03712597f, -0.00983324f, -0.01660624f, 0.02968765f, -0.06582513f, -0.03933031f, -0.03703791f, -0.09400464f, 
    0.07329206f, 0.01351405f, 0.05347798f, 0.00576716f, 0.18488440f, 0.02968951f, 0.17683694f, 0.08083475f, 
    0.11962118f, 0.01196658f, 0.05520390f, -0.04392538f, 0.05895447f, -0.01696374f, 0.01977426f, 0.08298302f, 
    0.02377660f, 0.00153686f, -0.01378916f, -0.00059385f, -0.00832370f, -0.04856882f, 0.01804991f, -0.04193792f, 
    0.12971394f, -0.05556960f, 0.07690996f, 0.05364041f, -0.07480089f, 0.08731981f, 0.00523280f, -0.02021466f, 
    -0.03963189f, 0.02658961f, -0.03197424f, -0.08233196f, -0.07656724f, -0.00321133f, -0.06038263f, -0.01326433f, 
    0.04124966f, -0.00900260f, 0.03827906f, -0.05107977f, -0.09876276f, 0.10749514f, 0.11676670f, 0.13575836f, 
    0.15537581f, 0.01651882f, 0.03554167f, -0.06961016f, 0.01900895f, -0.01738323f, -0.04025092f, -0.00714675f, 
    0.05088368f, -0.03364385f, -0.00764850f, -0.00337038f, 0.00217908f, -0.00218157f, 0.00020573f, -0.02142668f, 
    -0.01848582f, 0.21092938f, -0.00947176f, -0.04317813f, 0.05237395f, 0.02444762f, 0.04769323f, -0.02908987f, 
    -0.06348301f, -0.04962100f, 0.04799958f, 0.06422066f, -0.03206920f, 0.08965450f, -0.04058166f, -0.10635187f, 
    -0.03612120f, 0.04804571f, 0.05619404f, -0.10165180f, -0.03707126f, -0.14385086f, -0.10957946f, -0.21006691f, 
    0.03326532f, 0.00238074f, 0.08483054f, -0.07623543f, -0.04948643f, -0.03672519f, 0.03456195f, 0.01370573f, 
    0.04176241f, 0.03775866f, 0.00106994f, 0.00676709f, 0.05264599f, 0.07685433f, -0.04628802f, -0.05852171f, 
    -0.07189191f, -0.05662362f, 0.08065650f, 0.12113902f, 0.07118626f, -0.12608522f, -0.04423738f, -0.03424535f, 
    0.00998776f, -0.01643555f, -0.08384957f, -0.08827873f, -0.07514072f, -0.01323727f, 0.01792924f, 0.06450815f, 
    0.03130013f, 0.00372800f, 0.04397465f, 0.05542184f, -0.22878255f, -0.01272629f, 0.11391256f, -0.00885020f, 
    -0.01716402f, -0.01262878f, 0.00317616f, -0.02291280f, -0.00683893f, -0.01130272f, -0.00936995f, 0.01618262f, 
    -0.01057803f, 0.04961084f, 0.05194504f, -0.01060107f, 0.02092598f, -0.02849190f, -0.04482396f, -0.00745173f, 
    0.06286565f, 0.13553321f, -0.22122845f, -0.03572476f, -0.02629889f, 0.03762798f, 0.03291292f, 0.00292528f, 
    -0.07142950f, 0.00054643f, 0.02312113f, 0.03422586f, -0.04405888f, 0.04967058f, -0.00176996f, -0.06384585f, 
    -0.03115345f, -0.09874383f, -0.00863397f, -0.02191943f, -0.13196699f, -0.07453582f, 0.20753372f, 0.01285402f, 
    0.11612141f, -0.06880090f, -0.03143437f, 0.03174720f, 0.01707190f, -0.00139926f, -0.04185969f, -0.01105652f, 
    0.00375908f, 0.03262472f, 0.01663246f, -0.04260610f, -0.01120305f, 0.02942694f, -0.06011156f, 0.00362170f, 
    -0.12306795f, -0.18628018f, 0.20127097f, 0.01901507f, 0.09758198f, -0.11738511f, -0.04974999f, -0.04762152f, 
    -0.07758176f, -0.04019813f, 0.02182569f, -0.03848338f, -0.09151153f, -0.11895909f, 0.04198101f, -0.02798359f, 
    -0.05549201f, -0.01604414f, 0.11694791f, 0.02666288f, -0.10964847f, 0.16144583f, 0.01109886f, -0.23542008f, 
    -0.11386260f, -0.06911321f, 0.00248890f, -0.07890417f, -0.07779720f, -0.11781238f, 0.07273955f, 0.06353394f, 
    0.05940474f, 0.08100498f, -0.02286364f, -0.04678814f, 0.02228942f, -0.20214444f, -0.00346317f, 0.09297173f, 
    -0.06227474f, 0.11951533f, 0.03312120f, -0.01796550f, -0.03463076f, -0.09012111f, -0.01943471f, -0.05578272f, 
    -0.00830694f, -0.03705447f, 0.06589393f, 0.04669116f, -0.01900426f, 0.03325355f, -0.02690156f, -0.07012916f, 
    0.04815602f, -0.02349894f, 0.05195351f, -0.01920160f, -0.00901002f, 0.06718079f, -0.04895748f, -0.04948509f, 
    0.01704151f, 0.05390595f, -0.01735771f, -0.06338786f, -0.03517588f, -0.00807132f, 0.09579408f, -0.05179590f, 
    0.03220117f, -0.00393591f, -0.00444023f, -0.02812964f, 0.03139196f, 0.04488757f, -0.02598223f, -0.03506435f, 
    0.01417405f, 0.01711413f, -0.07631484f, -0.15073808f, -0.05362200f, 0.06475955f, 0.02980169f, -0.05018850f, 
    -0.05507810f, -0.04896037f, 0.06936297f, 0.04625074f, 0.00570440f, -0.01096180f, 0.00446895f, 0.00314073f, 
    0.07652041f, 0.01680639f, 0.04888422f, -0.03719874f, -0.04113754f, 0.04353891f, 0.14734077f, -0.07410494f, 
    -0.06136968f, -0.06836997f, -0.00079633f, 0.02024918f, -0.00813437f, -0.03107708f, 0.00723169f, 0.00627024f, 
    0.04123761f, -0.03119335f, -0.02325241f, -0.08980583f, 0.01736738f, -0.08050355f, 0.03639113f, -0.10120221f, 
    0.10836992f, 0.06612553f, -0.08550797f, 0.04564700f, 0.03550011f, -0.00069971f, 0.01826891f, -0.11313798f, 
    -0.05762129f, -0.01187269f, -0.00916420f, -0.05863456f, -0.00544572f, -0.06104772f, 0.04693127f, -0.00754085f, 
    0.04083566f, -0.03646935f, 0.11412267f, -0.05603960f, 0.01549601f, 0.06347495f, -0.18477245f, 0.01350682f, 
    0.03101736f, 0.05767829f, 0.02898978f, -0.05136219f, -0.00659562f, -0.03852821f, 0.10477991f, 0.03038160f, 
    0.08766146f, -0.01520169f, 0.00631170f, 0.00174021f, 0.05170984f, 0.00853360f, 0.12188961f, 0.00690517f, 
    0.00506998f, -0.10573019f, 0.14463343f, -0.11873223f, 0.08881979f, -0.05741781f, -0.00783772f, 0.02705150f, 
    -0.05016752f, 0.02373142f, 0.00374596f, -0.03026974f, 0.04846054f, -0.02820409f, -0.02514718f, -0.00336586f, 
    -0.02914128f, 0.00240960f, -0.10315466f, 0.05044473f, 0.03238130f, 0.06887129f, -0.02115337f, -0.00359924f, 
    0.06830887f, -0.04181419f, -0.05621533f, -0.01417561f, 0.02262506f, 0.00189871f, 0.05630849f, 0.02370276f, 
    -0.03767521f, -0.02048529f, 0.04849019f, -0.00493746f, 0.02335246f, 0.04109112f, 0.04963199f, 0.01669703f, 
    0.00848073f, 0.00188455f, -0.10727633f, 0.10895296f, 0.03743691f, -0.01783968f, 0.02566439f, -0.13151245f, 
    -0.03517127f, -0.06936410f, 0.05752821f, 0.00368402f, 0.04220191f, -0.02336095f, 0.14956063f, -0.05949735f, 
    0.05416859f, -0.04099222f, 0.13548875f, -0.07309075f, -0.03967071f, -0.01301767f, -0.00691469f, 0.05218435f, 
    0.05823493f, 0.05904064f, 0.00976019f, -0.07722442f, -0.03646733f, -0.02942365f, 0.00988804f, 0.02818544f, 
    0.03082076f, 0.02458889f, 0.01872157f, -0.08298612f, 0.07062291f, 0.04749838f, 0.02782220f, -0.05799511f, 
    -0.12785394f, -0.00519780f, 0.17240283f, -0.11338021f, -0.16280971f, -0.01011227f, 0.00167868f, -0.00508687f, 
    -0.01036211f, -0.00859175f, 0.02110112f, 0.04966020f, -0.00939853f, -0.01921433f, -0.01299084f, -0.07063571f, 
    -0.01433657f, -0.08129212f, 0.00790083f, -0.07161439f, -0.00132710f, 0.01558720f, -0.02914664f, 0.04274624f, 
    -0.00535732f, -0.06843532f, 0.01231998f, -0.07065928f, -0.07699594f, 0.08768667f, -0.00001108f, -0.02104275f, 
    -0.03298213f, -0.08995535f, 0.03975660f, 0.04418180f, -0.00535705f, -0.07339542f, 0.06156554f, 0.01841264f, 
    0.19291225f, 0.09616841f, 0.03344722f, -0.02105875f, 0.01030105f, -0.02362146f, -0.00156048f, 0.02675158f, 
    -0.05549625f, 0.04062392f, 0.03013840f, -0.04078791f, -0.03142806f, -0.03809563f, 0.05634837f, 0.02845832f, 
    -0.08857178f, -0.03478693f, 0.02769740f, -0.05720074f, -0.06118551f, 0.03372944f, -0.06769615f, 0.10035793f, 
    0.11831279f, 0.09704952f, 0.06211711f, -0.03296029f, -0.01755804f, -0.05233495f, -0.02930509f, 0.00234784f, 
    0.04154371f, 0.02470444f, 0.01179683f, -0.02207283f, -0.09962438f, -0.00264783f, 0.04234090f, -0.05132062f, 
    -0.11518010f, 0.06804705f, 0.14010778f, -0.03193433f, -0.01095418f, 0.01619309f, -0.03021755f, 0.05471225f, 
    0.01266446f, -0.20189416f, 0.03574492f, -0.07945821f, 0.09806549f, 0.11973175f, 0.06005999f, 0.00106963f, 
    0.01158926f, 0.00284782f, -0.16207653f, 0.00270049f, -0.05357521f, -0.07244686f, 0.04507789f, 0.02785593f, 
    -0.14893425f, 0.05154218f, -0.01346046f, -0.05336569f, -0.15336351f, 0.03482427f, 0.02583692f, -0.04209874f, 
    -0.02065484f, 0.00226315f, -0.02975087f, 0.02662155f, -0.00216231f, -0.14151648f, 0.00819044f, -0.04454525f, 
    -0.18147258f, 0.03658781f, -0.05508360f, -0.06831805f, -0.22846219f, -0.11374108f, 0.01901494f, -0.02976407f, 
    0.01397397f, -0.10657109f, 0.07138962f, -0.02250390f, 0.03318517f, 0.00698779f, -0.00229885f, -0.09171727f, 
    0.05269383f, -0.07923506f, 0.04162960f, 0.00501053f, -0.07202429f, -0.03586493f, 0.07276414f, 0.04652892f, 
    0.08020817f, -0.08773025f, -0.05071902f, -0.02377306f, -0.01705312f, -0.00750247f, -0.02754555f, -0.03740235f, 
    -0.11268130f, -0.05687284f, 0.03119795f, 0.06869787f, 0.00560657f, -0.00573874f, 0.01114961f, 0.00718539f, 
    0.05859661f, -0.10950799f, 0.05366292f, 0.02224347f, 0.06632198f, -0.03058223f, -0.03833808f, 0.01386649f, 
    -0.09970041f, 0.04729922f, 0.00038779f, -0.00221025f, -0.01605985f, -0.00163882f, 0.04307552f, 0.04101741f, 
    0.00127996f, 0.00730880f, 0.04736799f, 0.06224944f, -0.15993489f, 0.10517227f, -0.17579554f, -0.19447413f, 
    -0.13972004f, 0.02972870f, 0.02085290f, 0.01570916f, 0.06235475f, -0.02135421f, 0.05496123f, -0.00063030f, 
    0.03871310f, 0.02521951f, -0.00052738f, 0.04197636f, 0.00559013f, -0.07936535f, -0.02063904f, 0.06104194f, 
    0.02422280f, 0.18862432f, -0.17215008f, 0.08327793f, -0.00252695f, 0.06996839f, -0.07412484f, -0.05180395f, 
    -0.06994099f, 0.05972487f, -0.03112055f, 0.07441285f, -0.01718388f, 0.07708246f, 0.00038627f, 0.05267949f, 
    -0.03898666f, -0.00340212f, 0.06993818f, 0.04715549f, 0.09625521f, 0.05239791f, -0.08966387f, 0.10729097f, 
    0.01572231f, 0.04723934f, 0.02192284f, -0.04960476f, -0.03360918f, -0.04528879f, 0.00444452f, -0.02234984f, 
    0.04598651f, 0.01324841f, 0.02389083f, -0.01654056f, -0.03466501f, -0.05624507f, 0.06474710f, -0.05646558f, 
    0.02767956f, -0.09572531f, -0.21193349f, -0.11599336f, 0.05706368f, 0.01113083f, 0.06451244f, -0.03266105f, 
    -0.02545603f, 0.03290616f, 0.06696369f, 0.04103844f, 0.03231447f, 0.03165115f, 0.03805570f, 0.05093808f, 
    0.00539275f, 0.01274113f, 0.07759010f, 0.01485669f, 0.17479838f, 0.07632035f, -0.03047363f, 0.05959004f, 
    0.11334827f, 0.06880461f, -0.00396334f, -0.01510433f, -0.03745172f, 0.01025586f, -0.06564540f, 0.01329764f, 
    -0.00562759f, 0.01210328f, -0.05199531f, -0.03005877f, 0.00090069f, 0.08679144f, 0.05131283f, -0.00452021f, 
    0.08418714f, 0.11235593f, -0.19281612f, 0.08347827f, -0.04427520f, 0.01368077f, 0.00225265f, -0.04843549f, 
    -0.06416488f, 0.02082170f, 0.04942843f, 0.02481754f, 0.08684986f, 0.03426612f, 0.00474838f, 0.05059198f, 
    -0.00815575f, -0.02410645f, 0.07306796f, 0.01003406f, -0.01262101f, -0.02313032f, -0.05878698f, 0.04262177f, 
    0.09793787f, 0.05663044f, 0.01643888f, -0.10181186f, -0.00700771f, -0.07116852f, 0.02920218f, 0.00732719f, 
    0.02070300f, 0.01289880f, 0.00613889f, -0.06736622f, 0.09163163f, 0.03072359f, 0.05734004f, -0.08007742f, 
    -0.00257016f, 0.14973745f, -0.07901288f, -0.13109466f, -0.05340488f, -0.02716801f, 0.08474011f, -0.00120456f, 
    -0.00615603f, -0.05786346f, 0.09303944f, -0.00073780f, -0.01694695f, -0.06586303f, 0.06869014f, -0.11429510f, 
    -0.03770669f, 0.02570596f, 0.02745942f, 0.00450589f, 0.00728228f, 0.03260731f, -0.00462424f, 0.00241075f, 
    0.00910784f, 0.01035394f, -0.02185692f, -0.00514108f, -0.05096475f, -0.02403109f, 0.01572324f, -0.00856542f, 
    0.01055244f, 0.07350344f, -0.03749787f, 0.06218575f, 0.01254897f, -0.03612152f, -0.02824126f, 0.02952820f, 
    -0.08653768f, -0.14071618f, -0.12263132f, -0.17682216f, -0.02123208f, 0.07388690f, -0.03232598f, -0.03189626f, 
    -0.06902398f, -0.11195873f, 0.00844188f, 0.04038212f, 0.00484167f, -0.02400803f, -0.03804937f, 0.07154517f, 
    0.06264690f, 0.06866677f, -0.08844115f, -0.07206348f, -0.11249299f, -0.15617180f, -0.04666879f, -0.28689858f, 
    -0.09862459f, 0.07231466f, -0.06256112f, 0.01824654f, -0.01316835f, -0.05085346f, 0.03224828f, 0.02682156f, 
    0.01596714f, 0.01122002f, 0.01673424f, 0.00765028f, 0.01115894f, -0.01615676f, -0.09617881f, -0.03466913f, 
    -0.02612438f, -0.07690937f, -0.11043276f, -0.12055184f, -0.07449967f, 0.11804431f, 0.02152090f, 0.00414695f, 
    -0.15353213f, -0.10517016f, -0.06534300f, 0.02808760f, -0.01192301f, 0.01573099f, -0.01731424f, -0.02551454f, 
    0.09415257f, -0.07231880f, -0.07871648f, 0.03808050f, -0.16953112f, -0.08443560f, 0.21913810f, -0.10050274f, 
    -0.10260977f, -0.01336623f, 0.06594659f, -0.06414633f, -0.09562013f, -0.10443233f, 0.05097296f, 0.02488829f, 
    -0.08346801f, 0.01424546f, -0.00455413f, -0.02229405f, 0.05983416f, 0.00146437f, -0.22322153f, -0.00648352f, 
    -0.10227851f, -0.05541932f, 0.15453045f, -0.01686669f, 0.05836875f, -0.03545235f, 0.00711736f, 0.00073656f, 
    -0.03073793f, -0.04938211f, 0.00245677f, -0.02621749f, 0.00983435f, 0.00891792f, 0.00099886f, -0.00606184f, 
    -0.04045643f, -0.03292110f, -0.00895941f, 0.01734391f, -0.18388255f, 0.11163523f, -0.06306222f, -0.26559433f, 
    -0.35026911f, -0.03482504f, -0.02944583f, -0.01230422f, -0.07977217f, -0.05749638f, 0.03506346f, 0.00264423f, 
    0.04632393f, -0.01571989f, 0.03559889f, 0.04164025f, 0.05944296f, -0.14314705f, -0.17268531f, -0.02475549f, 
    0.10575017f, 0.09445997f, 0.02749507f, 0.05544042f, 0.11881803f, 0.06077631f, 0.02225128f, -0.08944067f, 
    -0.06625801f, -0.07164296f, 0.04286259f, 0.00363512f, -0.02771346f, -0.05541070f, -0.02169914f, -0.04012179f, 
    0.01307354f, 0.06623344f, 0.03017559f, -0.01191181f, -0.11966383f, -0.18604138f, 0.08106967f, -0.12946191f, 
    -0.01128766f, 0.05864458f, 0.01360444f, -0.05685266f, -0.02652733f, 0.01450542f, 0.00834121f, 0.07108156f, 
    0.03491385f, 0.02322108f, 0.02134570f, -0.03718321f, -0.01265456f, 0.01132009f, -0.13217883f, 0.06661327f, 
    -0.04903317f, 0.11716183f, -0.01032513f, 0.04977588f, -0.03885504f, -0.07062463f, 0.02363757f, -0.02464400f, 
    -0.01290134f, 0.02550497f, 0.07159012f, 0.02704767f, -0.01793928f, -0.00147668f, 0.02086063f, -0.08616554f, 
    -0.00876922f, -0.06524152f, 0.05224985f, 0.03566166f, -0.16725145f, 0.00743877f, -0.04351161f, -0.16077299f, 
    -0.36010543f, -0.01897930f, -0.01212759f, -0.01612939f, -0.01198298f, 0.09366786f, 0.03100191f, 0.03823710f, 
    0.04660824f, -0.03838811f, 0.00009788f, -0.11790212f, -0.00160961f, -0.20653427f, 0.09783397f, -0.05240453f, 
    0.07345489f, 0.10197160f, 0.01562152f, -0.02318308f, 0.00502668f, -0.03546456f, -0.04309444f, 0.03842854f, 
    -0.05241208f, -0.02979853f, 0.04551248f, -0.04042772f, -0.04252448f, -0.07512496f, -0.05071095f, -0.06218147f, 
    0.00002516f, -0.00015095f, 0.07450338f, -0.04347836f, 0.08036286f, 0.02251427f, -0.08782945f, 0.04970261f, 
    0.00175534f, -0.04847149f, -0.01689851f, 0.00767320f, -0.00946527f, 0.02326301f, -0.05339843f, 0.02676754f, 
    0.02567048f, 0.04566929f, -0.00926832f, 0.02305195f, 0.04813511f, -0.04199035f, -0.01707757f, 0.01784233f, 
    -0.01398185f, -0.08977154f, -0.03613676f, -0.04532818f, -0.14292985f, -0.00651367f, -0.00720548f, -0.02033238f, 
    -0.11178030f, 0.01647833f, 0.03989906f, 0.02043046f, 0.01303207f, 0.05060636f, 0.01873580f, -0.01084663f, 
    -0.02612339f, -0.08036232f, 0.01749509f, -0.04523353f, 0.12984778f, -0.06062604f, -0.04477314f, 0.03766424f, 
    0.07394826f, 0.08804791f, 0.02527873f, 0.00671840f, -0.01135207f, -0.05440177f, -0.01306738f, 0.07000490f, 
    -0.10226398f, 0.05808708f, -0.01226233f, 0.04206977f, -0.04139129f, 0.01528015f, 0.04123194f, 0.03030690f, 
    0.12380499f, 0.06980445f, -0.06791709f, 0.02471698f, 0.11531370f, -0.05278708f, -0.04302227f, -0.15485746f, 
    -0.03642879f, 0.01671840f, -0.03094882f, -0.02232659f, 0.01565924f, -0.09912174f, 0.00064137f, 0.01565278f, 
    0.04290842f, 0.01967267f, 0.07464956f, 0.00602751f, 0.06210964f, -0.01757189f, 0.05977263f, 0.06538659f, 
    0.09017888f, -0.04778058f, -0.01359925f, 0.00408082f, -0.04293193f, 0.01382905f, -0.02876729f, -0.03630375f, 
    -0.00452564f, -0.01203214f, -0.02932149f, 0.02078856f, -0.02349662f, -0.01755025f, 0.05258981f, 0.04612650f, 
    0.00505136f, 0.07866403f, -0.14875680f, 0.04189652f, 0.01473824f, 0.00956798f, 0.04167629f, -0.04675640f, 
    -0.06760158f, -0.00675021f, 0.03102230f, -0.00726235f, 0.03042002f, -0.00813455f, 0.05460726f, -0.00351051f, 
    -0.01589926f, -0.04256725f, 0.11049554f, -0.00705977f, 0.05221540f, -0.01216979f, -0.15782024f, 0.05284986f, 
    0.04554607f, 0.05178946f, 0.00091061f, -0.07152255f, -0.02351058f, 0.01259426f, -0.01250520f, 0.02736530f, 
    -0.04870400f, 0.02672085f, -0.02878817f, -0.03172309f, -0.02912951f, 0.00097343f, 0.06267059f, -0.00184229f, 
    0.01810621f, -0.02598557f, 0.02027951f, -0.10273815f, -0.14504258f, -0.05301259f, -0.01194981f, 0.05824051f, 
    0.03332478f, -0.03727057f, 0.05096099f, 0.02340908f, 0.06128373f, 0.01454944f, -0.00129106f, 0.00329553f, 
    -0.04259469f, -0.07106993f, 0.01632546f, -0.00836028f, 0.10241313f, -0.08095213f, -0.17459044f, 0.12796193f, 
    0.12596425f, 0.07794435f, 0.01816109f, -0.10557587f, -0.03524126f, -0.02674270f, -0.03905163f, -0.02349828f, 
    -0.02191082f, 0.00422333f, -0.00144345f, -0.07780880f, -0.02299141f, 0.01427133f, 0.06131955f, -0.06803453f, 
    -0.07847703f, -0.02019374f, 0.01570387f, -0.02429494f, 0.04367459f, 0.07349471f, -0.09481965f, -0.08516022f, 
    0.03606539f, -0.05532938f, 0.08133843f, 0.04809278f, 0.03805301f, -0.02851327f, 0.12088200f, -0.00862718f, 
    0.00820566f, -0.01460655f, 0.00142185f, -0.00702170f, -0.10596947f, -0.15725569f, 0.10294892f, -0.17198132f, 
    -0.16759069f, 0.03540667f, -0.03755985f, 0.00960109f, -0.01466606f, 0.00820732f, -0.01138303f, 0.00476343f, 
    0.00971590f, -0.08319156f, -0.00596420f, -0.02432348f, -0.05691539f, -0.04302293f, -0.04212065f, -0.04971321f, 
    0.16029242f, 0.07795823f, 0.10661466f, 0.08154278f, -0.02220043f, 0.01815694f, 0.00920675f, 0.03066687f, 
    -0.06872431f, -0.04074674f, 0.05101264f, -0.03829001f, 0.02465676f, -0.13511789f, -0.01630339f, -0.06547394f, 
    -0.08037926f, -0.02449345f, 0.10312026f, -0.07244489f, -0.17265263f, -0.18306313f, -0.15213260f, -0.19833179f, 
    -0.13224152f, 0.07306404f, -0.01323140f, -0.01728230f, 0.00068591f, -0.07337236f, 0.03950765f, 0.09536834f, 
    -0.05640834f, -0.04841364f, -0.04076298f, -0.03078104f, 0.05456062f, -0.01239891f, -0.10852061f, -0.12866791f, 
    -0.11482426f, -0.09414747f, 0.00491758f, -0.27514046f, -0.16927586f, 0.00246300f, 0.00005412f, -0.03214380f, 
    0.03759441f, -0.05870979f, 0.03000020f, -0.00894555f, -0.03385374f, 0.00709365f, 0.00516794f, -0.02638485f, 
    0.02702894f, -0.00380383f, -0.11285903f, -0.02102034f, -0.13310991f, -0.01542282f, 0.11024740f, 0.02588847f, 
    0.15230638f, -0.01027231f, -0.00946013f, 0.07660833f, -0.02464015f, 0.00492679f, 0.07818808f, -0.06159942f, 
    -0.08401907f, -0.01876736f, 0.10574557f, 0.00936305f, 0.02122918f, 0.06478309f, -0.02347596f, 0.03295132f, 
    0.07866984f, 0.01681401f, 0.03903600f, 0.02780893f, 0.10373013f, -0.00431625f, -0.00701704f, -0.02494851f, 
    -0.00946043f, 0.00629935f, 0.01250966f, 0.01680788f, -0.03395675f, 0.03507236f, -0.02802753f, 0.03339307f, 
    0.03355389f, 0.00067826f, 0.00958026f, 0.03963114f, -0.10725155f, -0.00426064f, 0.14220291f, -0.00388406f, 
    0.06883726f, -0.06399719f, -0.01790025f, -0.03103906f, -0.00065162f, 0.01005105f, 0.01989313f, 0.01102313f, 
    -0.00164237f, -0.08418786f, 0.01478542f, -0.05068445f, 0.00740292f, 0.02421085f, 0.03950100f, -0.03472878f, 
    0.32804030f, 0.02126767f, -0.03433713f, -0.20043349f, -0.24524091f, -0.03380979f, 0.00857157f, 0.08031353f, 
    0.10191603f, -0.08620696f, 0.00026841f, 0.06342913f, -0.04094462f, -0.11565697f, 0.05363182f, 0.04431301f, 
    0.08139366f, -0.00973473f, 0.01870553f, 0.03138186f, -0.05883460f, -0.14399415f, 0.10526504f, -0.33970055f, 
    -0.32235786f, -0.03815163f, 0.05038980f, -0.01841767f, -0.01550221f, -0.00305850f, -0.05566235f, 0.02349458f, 
    -0.04979824f, 0.00873460f, -0.00634141f, -0.15800393f, 0.10351309f, 0.08756552f, 0.10698127f, 0.04038905f, 
    -0.32143459f, -0.27383623f, -0.09068058f, 0.16504459f, -0.04896367f, 0.01158831f, 0.11084889f, -0.01019050f, 
    0.03422139f, 0.02010559f, -0.10407120f, 0.02437753f, 0.03577310f, -0.03518770f, -0.09128269f, -0.06627033f, 
    -0.03326068f, -0.03068062f, -0.00186108f, 0.10932909f, 0.08645704f, -0.06986680f, -0.02749740f, 0.05350679f, 
    0.01723114f, -0.03872919f, 0.03715140f, -0.03414737f, 0.01374921f, -0.01393414f, -0.04565014f, -0.02826821f, 
    0.03632587f, 0.06297433f, 0.07889593f, -0.01567787f, -0.04358442f, 0.08908565f, -0.04470992f, 0.02968695f, 
    -0.36029056f, 0.09593686f, -0.08655996f, 0.06613459f, -0.28102839f, 0.02436486f, -0.00840567f, 0.00099333f, 
    0.06803583f, 0.01280197f, 0.06447988f, -0.03487205f, 0.01569164f, 0.08253346f, 0.04497648f, 0.01579134f, 
    0.02450190f, 0.05129996f, 0.06395219f, -0.01672176f, 0.01970059f, -0.11100249f, -0.02225577f, 0.06369983f, 
    -0.02067907f, 0.01302553f, -0.00981973f, -0.09773412f, 0.04144200f, 0.06043293f, -0.01663850f, 0.03680030f, 
    -0.00372224f, -0.05427118f, 0.01313703f, -0.11889564f, 0.00623713f, -0.04014441f, 0.02574563f, -0.02399791f, 
    0.38258341f, -0.17484108f, -0.13373937f, -0.10192346f, 0.14810425f, 0.14548475f, -0.15606922f, 0.05246472f, 
    -0.15605828f, 0.20203641f, -0.05608423f, -0.05485644f, 0.06724869f, 0.11964460f, -0.05504270f, -0.02682952f, 
    0.01055031f, -0.02138518f, 0.01408159f, -0.17440781f, 0.03623984f, 0.08333810f, -0.11252503f, -0.03257984f, 
    -0.15792327f, 0.03211853f, 0.09176422f, 0.01766831f, 0.00662414f, 0.01422095f, -0.09147707f, -0.00111830f, 
    -0.00814166f, -0.00393132f, 0.05727989f, 0.04326443f, 0.06035616f, -0.03031252f, 0.11532466f, 0.02357980f, 
    0.28089690f, -0.02143540f, -0.16912900f, 0.06232651f, -0.05941048f, 0.02288586f, 0.04822284f, 0.13486961f, 
    0.01778954f, -0.05589093f, -0.02832056f, 0.05327554f, 0.02132202f, 0.05687788f, 0.02268573f, 0.01079984f, 
    0.00307139f, 0.03099393f, -0.01535669f, 0.04596822f, 0.28607202f, -0.10900072f, -0.15425229f, 0.04839262f, 
    -0.23481679f, 0.01570914f, -0.03527211f, 0.15572502f, 0.02875170f, -0.06670612f, 0.01135145f, -0.11167216f, 
    0.02558170f, 0.07608478f, -0.00801087f, -0.00651008f, 0.09222897f, 0.06273989f, 0.06905486f, 0.11145596f, 
    -0.12738951f, -0.15757829f, -0.21317680f, 0.14748269f, -0.38451624f, 0.09129174f, 0.01206463f, -0.02557812f, 
    0.03179819f, 0.03322194f, -0.12457670f, -0.08228832f, -0.01615067f, 0.20031643f, 0.02564625f, 0.01585200f, 
    -0.00250294f, 0.03045517f, 0.03537990f, 0.00980928f, 0.14975426f, 0.11152684f, -0.07159082f, 0.06527022f, 
    -0.03578759f, 0.05223588f, 0.02423679f, 0.00145299f, 0.04180150f, 0.13371703f, -0.07832699f, 0.00730954f, 
    0.04507110f, 0.00184327f, -0.00191017f, 0.08497642f, 0.04910826f, 0.04281541f, -0.04276548f, -0.05105677f, 
    -0.31395766f, 0.16374943f, 0.23916288f, -0.04673068f, 0.11860422f, 0.08789909f, 0.04021500f, -0.00427505f, 
    -0.00845690f, -0.07385743f, -0.02398964f, 0.07254819f, 0.04570691f, 0.02106632f, 0.04972835f, 0.00022604f, 
    0.00544357f, 0.04066936f, -0.10018501f, 0.07785466f, -0.18356670f, 0.16465671f, 0.17817146f, -0.39423221f, 
    -0.04357696f, -0.03794371f, 0.02722160f, -0.02944634f, -0.00069237f, 0.10728746f, 0.02030754f, -0.11620927f, 
    0.02584672f, -0.13343658f, -0.01665039f, 0.01020263f, 0.01643933f, 0.06074817f, -0.07916196f, 0.01108769f, 
    0.24678724f, 0.03562253f, 0.00934151f, 0.04199242f, -0.00089452f, 0.05390089f, -0.02400260f, 0.07727311f, 
    0.04729038f, -0.00357261f, -0.00628127f, 0.01180976f, 0.00063200f, 0.03256895f, 0.02026586f, 0.14756355f, 
    -0.05799881f, 0.01865388f, -0.00042570f, 0.02178472f, -0.04051656f, 0.03049436f, -0.17442895f, 0.13896352f, 
    -0.08125223f, 0.03662321f, 0.02131985f, -0.02661367f, 0.00248670f, -0.01022303f, -0.06216951f, -0.03065334f, 
    -0.00361745f, -0.02035382f, 0.06713119f, -0.05217340f, -0.01342170f, 0.06545527f, -0.03735518f, -0.01742765f, 
    -0.39351872f, 0.12772503f, 0.24004866f, -0.16403930f, 0.09071037f, -0.01224511f, 0.07146359f, -0.03841248f, 
    -0.07277443f, 0.06301515f, -0.03230990f, -0.00637472f, -0.00647790f, -0.03867118f, 0.04995369f, 0.01944794f, 
    0.06534528f, 0.06839777f, -0.10788055f, 0.06117989f, 0.11528528f, -0.06356452f, 0.05027752f, -0.15535703f, 
    -0.20639287f, -0.01540493f, 0.02602622f, -0.03526792f, -0.02776467f, 0.03534546f, 0.00092822f, -0.06474604f, 
    -0.00876556f, -0.06937865f, 0.01083038f, -0.03593418f, 0.02624535f, -0.08782782f, -0.04049880f, 0.00022080f, 
    -0.11156771f, 0.00356956f, 0.04411588f, 0.01104110f, 0.02415033f, 0.08953083f, 0.04647303f, -0.06852426f, 
    -0.04607329f, 0.07424118f, -0.06309627f, 0.00964044f, -0.05024457f, 0.03091339f, 0.06367794f, 0.08828762f, 
    -0.03308478f, 0.04147378f, -0.02588055f, 0.03888586f, 0.43055466f, -0.53163522f, 0.06348204f, -0.10534056f, 
    0.22907056f, -0.04153647f, -0.02773731f, -0.04496160f, 0.04571044f, -0.00635741f, 0.01960470f, -0.04337530f, 
    0.02199101f, 0.01262431f, 0.04155506f, -0.02199583f, -0.03305273f, -0.04187953f, 0.01014414f, 0.11810366f, 
    -0.25440899f, 0.15942208f, -0.17103827f, 0.05196333f, 0.04420297f, 0.07150625f, 0.01989278f, -0.06221326f, 
    0.03300803f, 0.15281847f, -0.07084240f, -0.03543783f, 0.01224134f, 0.00596514f, 0.04843836f, 0.09349945f, 
    0.00596571f, 0.02494537f, 0.02703430f, -0.05480089f, 0.20625383f, -0.14199206f, 0.15968029f, -0.01683647f, 
    -0.21018958f, -0.02907826f, 0.04245883f, 0.04742786f, -0.00011300f, 0.11139870f, 0.00076727f, -0.04322877f, 
    0.07171952f, -0.19007507f, -0.00521223f, -0.02385579f, -0.01296875f, -0.07307866f, -0.08647741f, -0.08842733f, 
    0.04950379f, 0.07855070f, -0.19119540f, 0.08191273f, 0.03448111f, -0.12353586f, -0.01446990f, 0.00318905f, 
    0.09457969f, -0.09290867f, -0.09658177f, 0.04663561f, -0.04288719f, -0.09585948f, -0.00732172f, 0.07972628f, 
    -0.00393067f, 0.07122248f, 0.01876408f, 0.09260594f, 0.35586447f, -0.42832386f, 0.01978968f, 0.14496197f, 
    0.27380097f, -0.03004964f, -0.04401504f, 0.01732241f, -0.01511024f, -0.00042003f, -0.04807980f, 0.01349306f, 
    0.00450420f, 0.07815466f, -0.08674388f, -0.06457916f, 0.03820407f, 0.08739848f, 0.01468581f, 0.08238263f, 
    -0.06937849f, -0.01155934f, 0.01978228f, 0.05409323f, -0.25691170f, -0.00314994f, 0.06675763f, -0.03842859f, 
    -0.04740601f, -0.06183055f, -0.09219278f, -0.09605987f, -0.04970662f, -0.04165514f, 0.13495058f, -0.00110134f, 
    0.04887208f, -0.03657983f, -0.09260680f, 0.01586267f, -0.09710693f, -0.13191891f, -0.00919743f, 0.16181727f, 
    -0.02322209f, 0.10150729f, 0.05688418f, -0.06564059f, 0.01541522f, 0.01532634f, -0.04640521f, -0.01398568f, 
    -0.04385316f, 0.01751675f, -0.00365243f, -0.08633284f, -0.14373572f, 0.03274640f, -0.04430488f, 0.02043822f, 
    0.13693646f, -0.15988205f, 0.10613225f, 0.05812589f, -0.02506758f, 0.01372878f, -0.02500551f, -0.05367422f, 
    -0.06558910f, 0.06607308f, -0.01934235f, 0.06433931f, -0.05965480f, 0.06875130f, -0.04950946f, 0.00278110f, 
    0.00550643f, -0.01676540f, 0.04047699f, -0.02670820f, -0.22168435f, -0.00952137f, 0.11909508f, -0.02387019f, 
    -0.09503022f, -0.04745582f, 0.02540953f, 0.01825768f, -0.02272737f, 0.03280495f, 0.02095789f, -0.02575569f, 
    -0.06497473f, -0.00383742f, -0.03708468f, -0.00806135f, 0.02421517f, 0.05138557f, 0.09740122f, -0.05319240f, 
    0.15245725f, -0.23083128f, 0.13158877f, -0.01521456f, -0.19671692f, 0.06621730f, -0.03134523f, -0.06020543f, 
    0.08890485f, 0.01950736f, 0.00544813f, -0.03446148f, -0.01359483f, -0.06916726f, -0.05181594f, -0.01490763f, 
    -0.01694588f, -0.08153993f, -0.04645910f, -0.05324949f, -0.18176709f, 0.01271891f, -0.02082260f, -0.05437807f, 
    -0.07542726f, 0.11310652f, 0.04781222f, -0.02949500f, -0.04773543f, 0.04627630f, 0.06158985f, -0.02705583f, 
    -0.07905685f, 0.02728800f, -0.04255079f, 0.12075768f, -0.02367808f, 0.00305904f, -0.05321720f, -0.02729929f, 
    0.02672640f, 0.29212323f, -0.03378354f, -0.30300885f, -0.20049201f, -0.08314271f, -0.02734491f, -0.05623728f, 
    -0.03111909f, 0.15736084f, -0.03349810f, -0.01001075f, 0.06671152f, -0.08621504f, 0.01970478f, 0.06643612f, 
    -0.03407886f, -0.04361853f, 0.00926145f, -0.05492602f, 0.07837027f, -0.02782749f, 0.01297038f, -0.10587554f, 
    -0.14511594f, 0.01504031f, 0.04682431f, 0.01030812f, -0.01206913f, -0.10422132f, -0.11578156f, 0.12848966f, 
    -0.01390616f, 0.06800139f, -0.00143134f, -0.04108665f, 0.00944800f, -0.08372779f, 0.02728934f, -0.04165394f, 
    -0.13431124f, 0.05843777f, 0.17613780f, -0.06078862f, 0.10064742f, 0.00898716f, 0.02223148f, 0.01119016f, 
    -0.04425221f, 0.00489364f, 0.00361220f, 0.02643012f, -0.03338980f, 0.07394354f, -0.09285259f, 0.02081620f, 
    -0.04200057f, 0.08583964f, -0.09881686f, 0.02718770f, -0.00325018f, -0.13225448f, 0.07211143f, -0.01757740f, 
    -0.28126433f, -0.07692564f, 0.08028845f, 0.06485409f, -0.06857042f, -0.00554612f, 0.05490603f, -0.06556488f, 
    -0.01999967f, -0.07309188f, -0.00754303f, -0.01387844f, -0.04280027f, -0.03812283f, -0.08152498f, -0.03070074f, 
    -0.21352157f, 0.10821473f, -0.18732485f, 0.16646284f, -0.01153123f, 0.03371056f, 0.10730369f, 0.05718714f, 
    0.09646992f, -0.13551548f, 0.08593864f, -0.03578145f, 0.00105805f, -0.02321468f, -0.01423305f, 0.10312875f, 
    -0.06231308f, 0.03618129f, -0.06644300f, 0.03289457f, 0.10613050f, 0.00921668f, -0.07172797f, 0.02403230f, 
    0.05715530f, -0.02643497f, -0.01737775f, 0.01381408f, -0.03208350f, -0.03215243f, 0.02706320f, -0.04599513f, 
    0.00263408f, -0.10885829f, 0.03249896f, -0.07654905f, -0.00484056f, -0.08227079f, 0.08751188f, 0.02656645f, 
    0.10823292f, 0.17695493f, -0.10791537f, -0.37618434f, -0.17628883f, -0.01276248f, 0.02827865f, 0.02154431f, 
    0.01211438f, 0.00356126f, -0.07044075f, -0.00404527f, 0.04356060f, -0.03339927f, -0.06794182f, -0.02286594f, 
    0.00457193f, 0.05813871f, 0.04980962f, -0.00501801f, -0.11219611f, -0.10267741f, -0.00853848f, 0.01080286f, 
    0.11004034f, -0.10758892f, 0.04535922f, -0.03831068f, -0.00240544f, 0.08292621f, 0.06732157f, 0.03328401f, 
    0.05536107f, -0.10445648f, -0.08982814f, 0.02644360f, -0.10418116f, 0.01064277f, 0.06939984f, 0.06261770f, 
    -0.16760214f, 0.01312805f, -0.02186413f, 0.05031960f, -0.14184736f, -0.06836216f, 0.01642352f, -0.08324954f, 
    -0.04102016f, 0.06892838f, -0.14463928f, 0.12935150f, -0.10025524f, 0.07948243f, -0.06322946f, 0.01913293f, 
    -0.04360373f, -0.13644010f, 0.11896592f, -0.04633241f, -0.01169543f, -0.18560132f, -0.13731281f, 0.17120342f, 
    -0.02589607f, -0.09648470f, 0.09912733f, 0.01278234f, -0.10402273f, -0.00323490f, -0.01566412f, -0.00333094f, 
    -0.03636957f, 0.02983046f, 0.03996986f, 0.00170487f, -0.09478398f, 0.04349405f, 0.07090023f, 0.02182354f, 
    0.04160842f, -0.23862320f, -0.03346109f, 0.09928552f, -0.01906933f, -0.01919019f, -0.01110819f, -0.06436534f, 
    0.00473869f, 0.02902988f, -0.05476082f, 0.05033609f, -0.05388020f, -0.04195467f, -0.04234029f, -0.06001118f, 
    0.01444035f, 0.03342452f, 0.03986863f, -0.00199859f, -0.11693002f, -0.01531122f, -0.10039973f, 0.09258293f, 
    0.03488830f, -0.02828432f, -0.05979584f, -0.06056935f, 0.02485480f, -0.03331367f, -0.02829477f, -0.01311851f, 
    -0.13347085f, 0.02018477f, 0.02506916f, 0.08680263f, -0.01615401f, 0.13911454f, 0.00915898f, 0.13620223f, 
    0.07776404f, -0.11627772f, 0.01172859f, -0.08231170f, -0.04185003f, -0.01843141f, 0.08137856f, -0.00140690f, 
    -0.03014119f, -0.08626511f, 0.05280301f, -0.01191352f, -0.06430927f, 0.03018657f, -0.02218435f, 0.02191822f, 
    -0.00975611f, -0.10197625f, -0.06224579f, -0.03521919f, -0.01729913f, -0.26225832f, 0.08072884f, -0.01294712f, 
    -0.03702856f, 0.00477286f, -0.01269295f, -0.00440926f, -0.05026187f, -0.02782226f, 0.00539558f, 0.05090634f, 
    0.05170316f, 0.01306328f, -0.02704889f, 0.06629814f, 0.01221853f, 0.11011475f, 0.03913328f, 0.07155458f, 
    -0.19250572f, 0.15149307f, 0.14903595f, 0.12953302f, -0.00821254f, 0.03046800f, 0.02622364f, -0.01961979f, 
    0.01312488f, -0.10357250f, 0.04350292f, -0.05612985f, 0.06863964f, 0.03823093f, 0.04671390f, 0.00419591f, 
    -0.00442396f, 0.01197824f, -0.12816831f, -0.07776806f, -0.20864832f, -0.10775969f, 0.07788011f, 0.03496204f, 
    -0.06836995f, 0.11386483f, 0.04530358f, -0.07209973f, 0.11076428f, -0.04738634f, -0.03747528f, 0.02803530f, 
    -0.16623004f, 0.02629430f, 0.09474659f, 0.00376636f, -0.01445784f, 0.17885996f, 0.02368858f, 0.14089176f, 
    -0.16697812f, 0.07509772f, 0.10938742f, 0.01744762f, -0.01886492f, 0.11187174f, -0.00846174f, 0.06369297f, 
    0.04706001f, -0.02640772f, -0.09755162f, 0.00752371f, -0.01591484f, -0.00989376f, -0.00232468f, 0.03243576f, 
    -0.05928012f, -0.08949021f, -0.17300293f, 0.00019676f, 0.00632771f, 0.06606054f, -0.02732635f, -0.03998706f, 
    -0.02981333f, 0.03303057f, 0.03304185f, -0.04135082f, -0.00732512f, -0.02547226f, -0.06937733f, 0.00079954f, 
    0.05870597f, -0.01107197f, 0.01021589f, -0.03587617f, -0.01818064f, -0.02127345f, 0.03740853f, 0.07942395f, 
    -0.11053801f, -0.18860312f, 0.03933457f, 0.03561310f, 0.22373012f, -0.02319546f, 0.01899191f, 0.00359781f, 
    -0.03775510f, 0.06022185f, 0.03582476f, -0.01339121f, -0.02492642f, 0.01345132f, 0.00733145f, -0.04806287f, 
    0.02624099f, 0.00467104f, 0.03900543f, -0.01172771f, 0.07807294f, -0.29959720f, 0.29164603f, -0.02012042f, 
    -0.14931630f, 0.05511603f, -0.03215090f, -0.04704263f, -0.01754679f, -0.00082420f, 0.02196870f, 0.01181028f, 
    0.03742051f, -0.11359049f, 0.05255416f, -0.03036190f, 0.01269643f, -0.07910072f, 0.03567898f, 0.05539750f, 
    0.14549023f, -0.34022468f, 0.06760464f, -0.08387181f, 0.00291070f, 0.00752483f, 0.02326089f, 0.05680085f, 
    0.00143871f, -0.08983681f, 0.03254885f, 0.10092334f, 0.05782409f, 0.06951369f, -0.02522235f, -0.01373684f, 
    0.00591185f, -0.01254625f, -0.10372469f, -0.01379821f, 0.26704302f, -0.19572270f, 0.00360574f, 0.02540763f, 
    -0.05436367f, 0.04028264f, -0.02114321f, -0.05841659f, -0.01963192f, 0.02173048f, -0.02361884f, 0.04761024f, 
    0.04314681f, -0.00579216f, 0.02490423f, -0.01690469f, -0.04556969f, -0.04259792f, -0.07796501f, -0.02083228f, 
    -0.34068894f, 0.18183929f, 0.21711025f, -0.11150068f, -0.00009602f, 0.04050255f, 0.07642344f, 0.01555903f, 
    -0.06376336f, -0.02022511f, -0.03547870f, 0.00134413f, 0.00919851f, -0.02392503f, 0.01551603f, 0.05921453f, 
    -0.01093122f, 0.12457751f, -0.13291998f, 0.03521863f, 0.05958432f, -0.10961039f, 0.09295694f, 0.00501072f, 
    -0.12611732f, 0.00473969f, -0.00257476f, -0.01165097f, -0.04961142f, 0.00906696f, -0.01571945f, 0.04011183f, 
    0.02664530f, -0.04914061f, 0.02447302f, -0.00819428f, -0.08248518f, 0.00524586f, 0.00531029f, 0.01095878f, 
    -0.07443818f, 0.16277452f, -0.08407238f, -0.01490535f, 0.03236537f, 0.02029597f, -0.09200286f, -0.00992581f, 
    -0.03376647f, 0.00108540f, 0.02549214f, 0.04155161f, 0.02205894f, -0.04844161f, -0.05485046f, -0.02625116f, 
    -0.00670602f, 0.09673166f, -0.01852950f, -0.05208271f, 0.05034921f, -0.19490154f, 0.01233799f, -0.01341533f, 
    -0.07526488f, -0.00099274f, -0.00733434f, -0.02519939f, 0.01810956f, -0.04681367f, -0.01654128f, 0.08171285f, 
    -0.05340744f, -0.01177092f, -0.00203280f, -0.05082536f, -0.05041308f, 0.02092804f, 0.01635514f, 0.01704290f, 
    -0.28576270f, -0.21820325f, 0.08776154f, -0.17473081f, 0.09973983f, -0.02443462f, 0.04219263f, -0.12845287f, 
    -0.00255361f, 0.05417690f, -0.01016479f, -0.12039675f, -0.01462470f, 0.01275334f, 0.04267239f, 0.07192107f, 
    0.04844626f, -0.10054769f, -0.03554975f, -0.07981370f, -0.08539965f, -0.10555796f, -0.02152038f, 0.05817525f, 
    0.06482169f, 0.03559556f, -0.06085497f, 0.00461154f, -0.04572012f, 0.18329258f, 0.00343235f, -0.00183417f, 
    -0.01888138f, 0.03443528f, 0.00169129f, 0.04950325f, 0.01052878f, 0.07611439f, -0.00134628f, -0.02574053f, 
    -0.50825286f, 0.23117307f, -0.13921604f, 0.05575081f, -0.02507285f, 0.06363058f, 0.08641794f, -0.00690951f, 
    0.13528392f, 0.09438550f, -0.01157302f, 0.00302187f, -0.02570707f, -0.01688614f, 0.05664928f, 0.15328902f, 
    0.01688856f, 0.11691154f, -0.10028686f, -0.03966397f, 0.02335033f, 0.00700841f, -0.05827844f, -0.12133750f, 
    -0.14177784f, -0.13563247f, -0.01827576f, 0.07827347f, 0.08202382f, -0.03858222f, -0.06790182f, 0.02141100f, 
    0.01058832f, -0.00073329f, -0.00975788f, 0.07621294f, 0.09814736f, -0.04999482f, 0.00116339f, 0.04197799f, 
    0.05558451f, 0.00204453f, -0.01607918f, 0.10953198f, -0.08120215f, -0.07961372f, -0.04488362f, -0.07451355f, 
    -0.08286320f, 0.00182075f, 0.03099574f, -0.01591836f, 0.06361920f, -0.04355129f, 0.00011899f, 0.10490538f, 
    0.09286723f, 0.03628182f, 0.04162884f, 0.07276712f, 0.30232292f, 0.08036301f, -0.24448197f, 0.15716061f, 
    -0.05633623f, -0.00329392f, -0.00164472f, 0.03373634f, 0.00039957f, 0.01861095f, -0.01366202f, -0.04516061f, 
    0.07643290f, -0.04212359f, 0.05033325f, 0.05980193f, -0.00813044f, 0.00155342f, 0.03536881f, 0.02386050f, 
    0.08693949f, -0.15502034f, 0.04739592f, -0.05856657f, 0.00845215f, -0.00750831f, -0.00462940f, -0.09261044f, 
    -0.02851048f, 0.02537711f, -0.01474707f, -0.04441922f, 0.03527123f, 0.09294438f, 0.05744711f, -0.02040356f, 
    0.01810627f, -0.04452593f, 0.01733112f, 0.04522717f, 0.26962924f, 0.00052089f, -0.06256740f, -0.07309924f, 
    0.03181271f, 0.12123195f, -0.14592561f, 0.03955927f, -0.05304362f, 0.17665844f, -0.01980839f, -0.04090075f, 
    0.02752413f, 0.07230040f, -0.05022675f, -0.02433043f, -0.06254855f, -0.03165640f, -0.01567096f, -0.08516780f, 
    -0.39204675f, -0.24186327f, 0.11269961f, -0.04853446f, -0.04509741f, 0.06859870f, -0.00202319f, -0.02954570f, 
    -0.02797556f, 0.07149620f, -0.02474832f, 0.01808604f, -0.00206337f, 0.02959584f, 0.03108669f, -0.02539553f, 
    0.01987844f, 0.10935610f, 0.09138014f, 0.03783545f, -0.10815781f, -0.05697509f, 0.08397110f, -0.12602466f, 
    -0.21443820f, 0.07728950f, 0.03095240f, 0.00033449f, -0.00484183f, 0.04148666f, 0.01580937f, 0.07590504f, 
    0.04917436f, 0.06158689f, 0.01904337f, 0.04636391f, 0.02497707f, -0.02654622f, -0.08832280f, -0.01788175f, 
    0.18030754f, 0.03561713f, 0.00378734f, 0.01562124f, -0.04421404f, -0.09321722f, -0.04866091f, -0.04782332f, 
    0.09016221f, -0.00909016f, -0.04359730f, 0.07483570f, -0.05966701f, -0.01154059f, 0.05475347f, 0.01318276f, 
    -0.01220751f, 0.05272483f, -0.00774109f, -0.01886423f, 0.07268959f, 0.03228594f, 0.05886400f, -0.09441737f, 
    0.00785580f, 0.00339296f, -0.05202954f, 0.06444524f, 0.00359256f, 0.00661627f, -0.01280946f, 0.01259442f, 
    -0.01737010f, 0.04645409f, 0.01861322f, -0.02847266f, 0.04084408f, -0.03046013f, -0.06436019f, 0.08794397f, 
    -0.19905050f, -0.14852381f, -0.02206715f, 0.03416347f, -0.04783960f, 0.02458500f, 0.07738231f, -0.03800150f, 
    -0.00781725f, 0.04720017f, 0.06751860f, -0.03491872f, -0.04157181f, -0.04139837f, 0.01378347f, 0.05491607f, 
    0.06655800f, 0.04346652f, 0.03817756f, -0.01102255f, 0.13310421f, 0.07294162f, -0.02147425f, 0.01502433f, 
    -0.05580242f, -0.04365264f, -0.04484808f, 0.02720431f, 0.02064515f, -0.05376958f, -0.02504030f, -0.03479135f, 
    -0.06864907f, 0.00842867f, -0.02425009f, 0.03728713f, 0.07661893f, 0.03981064f, 0.00758517f, -0.04956380f, 
    0.24008818f, 0.19136268f, -0.14326747f, 0.08482711f, -0.06574021f, -0.10522904f, -0.08513317f, -0.02019127f, 
    0.01521491f, -0.08121021f, 0.05517189f, 0.03491384f, -0.03091333f, -0.13866530f, -0.09343319f, -0.08626983f, 
    -0.08618293f, 0.10213019f, -0.13025691f, -0.05674208f, -0.04890498f, -0.11471584f, 0.09211919f, -0.00981709f, 
    0.04872376f, 0.15007851f, -0.00378612f, 0.03906104f, 0.02533427f, 0.08693187f, 0.01584779f, -0.00068581f, 
    0.03318923f, 0.03528938f, -0.02021609f, -0.02261147f, 0.03398658f, -0.17547590f, -0.01605805f, 0.01689526f, 
    -0.06481505f, -0.07650687f, 0.07319669f, 0.06370613f, 0.07114719f, 0.01203645f, 0.02722108f, 0.05844906f, 
    0.06208858f, 0.02412073f, 0.02048780f, -0.00902246f, -0.00048642f, 0.01745432f, 0.00126473f, 0.01729516f, 
    0.00875839f, 0.03832775f, 0.11348949f, 0.03811765f, -0.17817637f, -0.11327770f, 0.05642645f, 0.02585158f, 
    -0.02854559f, 0.01864919f, 0.01636391f, -0.03688810f, -0.06128868f, -0.00629121f, -0.00401122f, -0.00937356f, 
    0.06053146f, -0.03807352f, 0.02934078f, -0.02853063f, 0.01845283f, 0.03172518f, -0.00711760f, 0.07229436f, 
    -0.23029695f, -0.28153858f, -0.01099003f, -0.02210834f, 0.04696131f, 0.02511120f, 0.06154738f, 0.00532865f, 
    -0.05940907f, -0.01024091f, 0.00460064f, 0.00550139f, 0.03161871f, -0.03736388f, 0.02080856f, 0.01734184f, 
    -0.00453357f, 0.04616548f, 0.02081467f, 0.06690823f, -0.12258910f, 0.00699455f, 0.06788930f, 0.07937537f, 
    0.01311892f, 0.04794564f, 0.05104365f, 0.06568567f, 0.02472146f, 0.00230505f, 0.04191065f, 0.02011427f, 
    0.02757424f, -0.00964935f, 0.00959892f, -0.01280404f, -0.04298821f, -0.06291552f, 0.04813256f, -0.00872625f, 
    -0.28303707f, -0.22665593f, -0.14067662f, -0.05469831f, -0.03425236f, -0.00711220f, 0.05455770f, -0.01631042f, 
    -0.04766926f, -0.02596659f, 0.07144195f, 0.03883753f, -0.02044265f, -0.01139300f, 0.00945992f, 0.04503735f, 
    -0.02135326f, 0.03286871f, 0.08844049f, 0.02671472f, -0.24711555f, -0.18336055f, -0.24951391f, -0.09617356f, 
    -0.05554009f, 0.04676106f, -0.03102789f, -0.03638586f, 0.00645838f, -0.02321063f, 0.08033448f, 0.01903243f, 
    0.04457695f, -0.04143590f, 0.00424141f, -0.00920498f, -0.00226109f, -0.09601897f, 0.02002057f, -0.03726157f, 
    -0.00222737f, 0.08103468f, -0.04565407f, -0.00710644f, 0.02163203f, -0.01358530f, 0.03595009f, -0.00875088f, 
    0.01027093f, -0.04469609f, 0.01364688f, -0.00492348f, 0.05800258f, 0.02133839f, 0.04428478f, 0.02565421f, 
    0.07955455f, 0.07349618f, -0.05372173f, 0.08581358f, 0.11192276f, 0.02630053f, -0.04609942f, -0.00283501f, 
    0.07903218f, -0.10033050f, -0.02336313f, 0.04258507f, 0.04216432f, 0.00369340f, 0.00502903f, -0.05161462f, 
    -0.01991342f, -0.04497392f, 0.00458975f, -0.07267151f, 0.04921238f, 0.01464695f, 0.04819001f, 0.03508474f, 
    -0.43983415f, -0.25573125f, -0.04479451f, -0.12201884f, -0.13444582f, 0.03171530f, 0.00995895f, -0.01714959f, 
    -0.03570317f, -0.08391184f, 0.06248513f, 0.01343189f, -0.06141673f, -0.01865817f, 0.03152617f, -0.00362668f, 
    -0.11180571f, -0.09773454f, 0.01112365f, -0.04424777f, -0.38190913f, -0.19413395f, 0.02367487f, -0.08939679f, 
    -0.13189322f, 0.06486100f, -0.00644329f, 0.00576318f, -0.06858084f, 0.04375037f, 0.03922325f, -0.03205213f, 
    -0.00787664f, 0.06609236f, 0.02657854f, 0.01670186f, -0.06087539f, -0.00443426f, -0.03394835f, -0.03891297f, 
    0.08992866f, 0.07273863f, -0.00060524f, 0.06223156f, -0.01733640f, -0.01650504f, -0.02345427f, 0.05837705f, 
    -0.02356623f, 0.00085306f, 0.00716429f, 0.02214753f, -0.00563213f, -0.05177156f, -0.04683762f, 0.01511473f, 
    -0.06921235f, -0.08804551f, -0.01978139f, -0.02811271f, -0.22796340f, 0.00038189f, -0.17409424f, 0.03561238f, 
    0.13733454f, -0.01796965f, -0.06339812f, -0.04809925f, -0.00121985f, 0.07494488f, 0.05399585f, 0.00869207f, 
    0.03218781f, -0.05709542f, 0.08297863f, 0.07301989f, 0.02571526f, 0.04435412f, -0.09583893f, 0.02763009f, 
    0.17100807f, 0.02235473f, -0.15699425f, 0.03551124f, -0.09204296f, -0.06433973f, 0.03549967f, 0.03788364f, 
    0.00082034f, -0.07739066f, 0.04541025f, -0.01691302f, 0.04987961f, -0.13661273f, -0.03451569f, -0.03782471f, 
    0.00920831f, -0.06575440f, 0.01125687f, -0.02153601f, -0.24497290f, -0.04487308f, -0.13889490f, -0.01811361f, 
    -0.07115870f, 0.10882259f, 0.00564816f, -0.08034664f, -0.06302826f, -0.01667633f, -0.01506045f, -0.03086553f, 
    0.01101196f, 0.06369749f, 0.07060732f, -0.03621463f, 0.04237827f, 0.04558649f, -0.05522034f, 0.05876267f, 
    -0.03512795f, 0.10482597f, 0.04154472f, -0.11917707f, 0.02849088f, 0.02018093f, 0.05004356f, 0.08791539f, 
    0.05637573f, 0.04155432f, -0.03610542f, -0.04429374f, -0.02919587f, -0.05065621f, 0.01491201f, 0.01541574f, 
    0.10544320f, -0.02322856f, -0.07278372f, 0.06311678f, 0.10912163f, 0.06689496f, -0.15505515f, 0.16378903f, 
    0.02510136f, -0.15444458f, -0.05573637f, 0.04131655f, 0.01318944f, 0.05275495f, -0.02477605f, 0.03677755f, 
    0.02850527f, -0.10759713f, 0.05389099f, -0.01345570f, 0.00553034f, -0.05415763f, -0.13564742f, -0.12153836f, 
    -0.26792812f, -0.29938433f, 0.16495620f, 0.04904408f, -0.05657391f, 0.01720256f, 0.00527002f, 0.01702956f, 
    -0.03140187f, 0.02637648f, 0.02180073f, -0.01653953f, -0.03496251f, 0.04027050f, 0.03195526f, -0.03930631f, 
    -0.09874393f, -0.17682648f, -0.08274607f, -0.06844166f, 0.23392163f, 0.04840332f, 0.03643911f, 0.02580971f, 
    -0.06499164f, -0.13702886f, -0.07073705f, -0.03881419f, 0.06898893f, -0.07273442f, -0.04089357f, 0.02341492f, 
    -0.07320456f, -0.07162998f, -0.02689173f, -0.01674535f, -0.00993313f, -0.02043546f, -0.06796742f, -0.01732020f, 
    0.11445337f, -0.03367124f, -0.11503550f, -0.02179375f, 0.08016341f, -0.05864700f, -0.00600880f, -0.02618178f, 
    -0.01343667f, -0.04293397f, 0.01788595f, 0.04452769f, -0.04348578f, -0.04847383f, 0.01813750f, -0.02626275f, 
    0.02028420f, 0.01099624f, -0.07610574f, 0.11613296f, 0.01557121f, -0.04969281f, 0.12372196f, 0.07411201f, 
    0.06200596f, 0.08055955f, 0.07726759f, 0.01676927f, 0.03995222f, -0.10369107f, -0.01833357f, 0.00612576f, 
    0.08598041f, 0.05833713f, 0.03196268f, 0.03610241f, 0.05008750f, -0.02628656f, -0.04187197f, -0.02763772f, 
    -0.14617991f, -0.09837563f, -0.09435648f, 0.03227725f, 0.13684028f, 0.03759127f, 0.00501268f, -0.09269478f, 
    -0.00494394f, -0.04741682f, -0.02728914f, -0.02778782f, -0.06781974f, 0.02635236f, 0.08696341f, 0.00092903f, 
    0.13060600f, 0.12551560f, 0.08540051f, 0.08381782f, -0.18967263f, -0.14562841f, -0.18646078f, -0.07922737f, 
    -0.21143003f, 0.06961086f, 0.08785023f, 0.02546379f, -0.06119895f, 0.01986538f, 0.06899898f, -0.01696920f, 
    0.04054612f, 0.00281160f, -0.03451794f, 0.00109683f, 0.03011454f, 0.03890217f, 0.09012250f, 0.01447535f, 
    0.03152250f, -0.15967849f, 0.07560706f, -0.10800581f, 0.03183895f, 0.04564156f, 0.01267811f, 0.03230315f, 
    -0.06150883f, 0.06888650f, -0.08796986f, -0.01387066f, 0.02347565f, -0.00816607f, -0.15083079f, 0.03330089f, 
    0.03622132f, -0.10284919f, 0.02413660f, 0.05933984f, -0.37000322f, -0.30380249f, -0.13528034f, -0.11765093f, 
    -0.14736553f, 0.04908177f, 0.06011112f, -0.08120598f, -0.07377286f, 0.05535183f, 0.00016223f, -0.07275985f, 
    -0.04833436f, 0.03622976f, -0.01190692f, -0.02641261f, 0.01066749f, 0.04485176f, 0.07395430f, 0.02039714f, 
    -0.13105512f, -0.05124800f, -0.14731932f, -0.01315171f, -0.01803380f, -0.00199158f, 0.02009933f, -0.03007275f, 
    0.01825722f, -0.01598072f, 0.03803555f, 0.01788306f, 0.04045834f, -0.04227725f, 0.03467738f, 0.02421210f, 
    0.03496496f, 0.02338777f, 0.05462329f, -0.00863039f, -0.52381980f, -0.11005957f, 0.00541114f, -0.07012026f, 
    -0.11768215f, 0.09843315f, -0.03377627f, 0.00291502f, -0.07486089f, 0.02341966f, -0.00307707f, -0.00130589f, 
    -0.00583654f, 0.17542741f, 0.00835130f, 0.02813680f, 0.00194753f, 0.01894358f, -0.05143622f, 0.02071624f, 
    -0.22794743f, -0.24462040f, 0.07342261f, -0.05679113f, 0.07371312f, 0.01812508f, 0.04356441f, 0.00823142f, 
    -0.01902999f, -0.10913361f, 0.04575090f, -0.04582661f, -0.00583207f, 0.05065977f, 0.06802029f, -0.05920424f, 
    -0.05015337f, -0.03937183f, 0.04758880f, 0.04604050f, -0.00743267f, 0.02576574f, -0.03275211f, -0.06584550f, 
    0.02972580f, 0.06341548f, 0.04006297f, -0.01428651f, 0.04477717f, 0.00069479f, 0.01717896f, -0.01839408f, 
    -0.00498107f, -0.00996152f, 0.01313912f, 0.06037907f, 0.09688471f, 0.12284366f, 0.04773096f, 0.09359686f, 
    0.10970622f, 0.16176419f, 0.08579072f, -0.07756103f, -0.07182669f, 0.00851771f, -0.01026638f, -0.04280429f, 
    0.05447920f, 0.07369916f, 0.00542919f, 0.02141629f, 0.04115930f, 0.00667827f, 0.02268939f, 0.00713965f, 
    0.10547658f, -0.08409066f, -0.03221206f, 0.00016893f, 0.13967451f, 0.18299164f, 0.06324809f, 0.02989525f, 
    0.08436777f, 0.02308631f, 0.02288182f, 0.08882172f, 0.03117630f, 0.05420676f, -0.01128555f, -0.06576291f, 
    0.02644597f, 0.04881654f, 0.00848943f, 0.07196468f, -0.06380563f, -0.03342424f, -0.12659350f, -0.02269149f, 
    -0.09955243f, -0.02308395f, 0.01876416f, -0.07702474f, -0.08899303f, 0.07478906f, 0.08357215f, 0.00688200f, 
    -0.02035902f, 0.07716949f, -0.08744974f, 0.00546154f, -0.06634481f, -0.10691880f, 0.01552513f, 0.11696133f, 
    0.09195214f, 0.02294601f, 0.06981441f, 0.12251253f, 0.12975687f, 0.01835017f, 0.04972153f, -0.04450914f, 
    -0.09823517f, 0.03964042f, -0.04366489f, 0.09031051f, -0.06117160f, 0.03862270f, 0.00799683f, 0.00634143f, 
    -0.01991262f, 0.01782094f, -0.04545352f, -0.01285791f, -0.00493053f, -0.08195643f, -0.08156019f, -0.01934987f, 
    0.10519917f, 0.00406760f, 0.02470768f, 0.00764990f, -0.02731701f, 0.00085705f, 0.02843158f, 0.03032562f, 
    0.03212435f, -0.01585853f, 0.02975846f, 0.03970846f, -0.01182189f, 0.01679768f, -0.01969500f, -0.02603051f, 
    0.07119448f, -0.01030780f, -0.07901097f, 0.06694086f, 0.16512115f, 0.01752491f, 0.03382650f, 0.06944034f, 
    0.00433506f, 0.06566709f, 0.08539359f, 0.02326878f, 0.00771468f, 0.03454154f, -0.06981134f, -0.03126361f, 
    0.02389842f, -0.02830820f, -0.07002468f, 0.03186294f, 0.04544611f, -0.25888330f, -0.11931899f, -0.03156997f, 
    -0.25186816f, -0.16894262f, -0.11010887f, -0.08124628f, -0.10528760f, 0.08849332f, 0.01839448f, -0.04632704f, 
    -0.05294027f, 0.01943731f, 0.01838448f, -0.04487270f, -0.00254809f, -0.00652870f, 0.01909973f, -0.03725003f, 
    -0.05914044f, 0.02767400f, 0.02763271f, 0.02800926f, -0.20113339f, 0.12490959f, 0.04621326f, -0.03940835f, 
    0.06305194f, 0.02411623f, 0.05661192f, -0.01770708f, 0.04911278f, 0.02025971f, -0.02783982f, 0.07271970f, 
    -0.03641364f, -0.04931390f, -0.01697686f, 0.09302770f, -0.05771260f, -0.01062448f, -0.13740684f, 0.08833766f, 
    -0.10199302f, -0.13904586f, -0.08175236f, -0.00679306f, 0.10388240f, 0.01792108f, 0.01969706f, 0.03264160f, 
    0.03404000f, -0.02131348f, 0.05864272f, -0.05391091f, 0.00827399f, -0.00251350f, 0.02037198f, 0.05032153f, 
    0.01649511f, 0.05399786f, 0.09876297f, 0.04454034f, 0.15395845f, 0.05992999f, -0.09988188f, 0.08484869f, 
    -0.01518871f, 0.06846845f, 0.07745140f, 0.09156000f, -0.03015011f, 0.02024765f, 0.00943894f, -0.01719486f, 
    -0.02622232f, -0.06910529f, 0.00456338f, -0.01806529f, 0.03056799f, -0.10594274f, -0.04138143f, 0.00992643f, 
    0.01764793f, 0.00015313f, -0.06726409f, 0.02212658f, 0.02441213f, -0.04477230f, -0.02454710f, 0.11286327f, 
    0.00896960f, -0.07325552f, 0.02124461f, -0.05184047f, -0.00852738f, -0.10057028f, 0.04729316f, 0.02156740f, 
    0.00446061f, 0.04486052f, 0.08607341f, -0.02959529f, 0.00236613f, -0.03506432f, -0.05471840f, -0.03247074f, 
    -0.00372377f, 0.01992184f, 0.02760236f, 0.01974452f, 0.08412205f, 0.01904656f, 0.08411782f, -0.01511271f, 
    0.00032102f, -0.04405750f, -0.00762009f, 0.11383425f, 0.08234994f, 0.10041905f, 0.11787697f, 0.05761715f, 
    0.10262239f, 0.01831541f, -0.04243400f, 0.05331931f, -0.00373254f, -0.04284230f, 0.00655672f, -0.01131983f, 
    0.03593368f, 0.05623325f, 0.06777422f, 0.01887978f, -0.02829164f, -0.01510398f, -0.01531635f, 0.02948116f, 
    -0.01822066f, -0.02553837f, -0.04409862f, 0.03496251f, -0.25828865f, 0.02298236f, -0.20344272f, -0.07269829f, 
    -0.06409073f, 0.00175534f, 0.01217643f, -0.07842047f, -0.01669429f, 0.02848177f, -0.04133748f, 0.01424987f, 
    -0.09183025f, 0.04510241f, -0.04560147f, 0.01537418f, -0.02915561f, 0.06978887f, -0.06159542f, 0.08858439f, 
    -0.09975252f, -0.00306507f, -0.09267252f, -0.03096893f, -0.04408768f, -0.00166951f, 0.02503183f, -0.08568842f, 
    0.00718343f, -0.04007645f, 0.01571369f, 0.02833496f, 0.03638186f, -0.06619544f, 0.08631347f, -0.00850496f, 
    -0.01826247f, 0.08092527f, 0.01025221f, -0.00283567f, 0.07129154f, 0.06195427f, -0.04027057f, -0.01666511f, 
    -0.00001115f, 0.00056394f, 0.02682928f, -0.01756451f, 0.04367537f, 0.00861766f, -0.01158825f, 0.00306898f, 
    0.06210331f, -0.01364744f, 0.03517720f, -0.00145853f, 0.06455205f, 0.07213461f, -0.00250659f, 0.04449765f, 
    -0.31558245f, -0.33445799f, -0.16421625f, -0.01943634f, 0.05364526f, 0.05488430f, 0.02838539f, -0.03810735f, 
    -0.00319928f, -0.07473590f, 0.09821287f, 0.01102048f, 0.00140343f, 0.03916360f, 0.02830531f, 0.02222686f, 
    0.01087115f, -0.01613135f, 0.04361592f, 0.01193196f, -0.29489270f, -0.13503061f, -0.07626568f, 0.06550705f, 
    -0.04526298f, 0.02820833f, -0.00627021f, -0.03873670f, -0.04727338f, 0.01686361f, 0.02502050f, 0.02639249f, 
    -0.02702228f, 0.05573911f, 0.04619774f, 0.04921123f, 0.06487158f, 0.02344007f, -0.01520189f, -0.01419693f, 
    0.13281417f, 0.10485380f, -0.11670709f, 0.06090422f, 0.01532613f, 0.02070112f, -0.03106667f, 0.06443042f, 
    -0.00350018f, 0.01618603f, 0.02281337f, -0.06219465f, 0.10316808f, -0.04602395f, 0.01846327f, 0.03875481f, 
    0.08946270f, -0.01210911f, 0.08609480f, 0.09119777f, -0.42397702f, -0.22195692f, -0.07786559f, -0.07288592f, 
    -0.23654118f, 0.00978130f, 0.04715411f, -0.03822919f, -0.01185872f, 0.05705268f, 0.03275284f, 0.01079363f, 
    -0.03447980f, -0.07355575f, -0.00739354f, -0.00855470f, -0.05559707f, 0.03022526f, -0.00492471f, -0.02431024f, 
    -0.44633025f, 0.08292827f, -0.18238366f, -0.09225032f, 0.09413026f, 0.11855969f, -0.04704890f, -0.10647804f, 
    -0.05820089f, 0.03132331f, 0.03639701f, -0.01707808f, 0.00998616f, -0.07750248f, 0.05587661f, -0.06986349f, 
    -0.07708216f, 0.01621868f, 0.00148244f, -0.00351136f, 0.15146324f, 0.10374165f, -0.10845429f, 0.11169806f, 
    -0.04931686f, -0.02233476f, -0.05688248f, 0.12262385f, -0.10421745f, 0.03314184f, 0.01380449f, -0.00633330f, 
    0.00050631f, -0.10214958f, -0.11079448f, -0.00999282f, -0.06140298f, -0.13034064f, -0.02781823f, -0.04623758f, 
    -0.31220832f, -0.16654254f, 0.05723480f, -0.03901537f, -0.18797430f, 0.03844624f, 0.10350921f, 0.04766132f, 
    -0.06612194f, -0.08936457f, 0.11269937f, -0.03912197f, 0.05307507f, -0.08586434f, -0.06154500f, -0.00986750f, 
    0.00972185f, 0.00844609f, 0.10599270f, 0.02932335f, 0.10642733f, 0.16662803f, 0.14974557f, -0.03859685f, 
    -0.06728543f, 0.01766118f, -0.01767324f, 0.00337557f, 0.03194341f, 0.05228316f, -0.06442735f, -0.03716231f, 
    0.05268168f, -0.00547168f, 0.01704813f, 0.01830497f, 0.00821131f, -0.08574901f, -0.10533424f, -0.00413182f, 
    0.18356329f, 0.10247320f, 0.02666618f, -0.09472027f, 0.00859278f, 0.07825337f, 0.03313689f, 0.04325816f, 
    0.02130259f, 0.01750434f, -0.05177616f, 0.02188874f, 0.01320509f, -0.03506534f, -0.00715262f, 0.03866977f, 
    -0.01578088f, -0.11532393f, -0.12187157f, 0.08209624f, 0.19628167f, -0.05924282f, -0.03759657f, -0.01983152f, 
    0.09458507f, -0.05240805f, -0.08654311f, -0.10051862f, -0.02631618f, -0.10527208f, 0.04413902f, 0.03200424f, 
    -0.03656637f, -0.00498613f, -0.04542193f, -0.18546116f, 0.05370234f, -0.02728817f, -0.11337876f, 0.02722135f, 
    -0.19140781f, 0.07590092f, -0.17527248f, -0.07393308f, 0.07113444f, 0.09591204f, 0.01036013f, -0.02318057f, 
    0.00865020f, 0.09125196f, 0.02630685f, 0.03132055f, 0.02376233f, -0.00473220f, 0.03724634f, -0.00873868f, 
    0.06281861f, 0.13612568f, 0.00611131f, 0.07100193f, 0.15094316f, 0.15102649f, -0.04166100f, 0.08503268f, 
    -0.03367722f, -0.06098049f, -0.16639620f, 0.12259545f, 0.00854639f, 0.05400834f, 0.02421587f, -0.00715602f, 
    -0.01169458f, -0.04367184f, -0.10778955f, -0.01440806f, -0.06482082f, 0.04709899f, 0.01018832f, -0.06713809f, 
    0.13958342f, -0.31059653f, -0.08262719f, -0.18462686f, -0.11122208f, 0.11313497f, -0.04572013f, -0.04830420f, 
    0.03865190f, 0.08916050f, -0.00721485f, -0.03192328f, 0.07140118f, 0.03954998f, 0.01533354f, 0.03098755f, 
    0.05538962f, 0.02699414f, 0.02820344f, -0.00087575f, 0.24222505f, 0.11984899f, -0.07661180f, -0.05053223f, 
    0.32431862f, 0.03283831f, -0.14494084f, -0.05387764f, 0.01398599f, -0.02479500f, 0.00815082f, 0.05007470f, 
    0.01875139f, -0.02443920f, -0.04172600f, 0.08774328f, -0.04509065f, 0.02785977f, -0.01441870f, 0.09131324f, 
    -0.03008631f, -0.08375397f, -0.04134989f, -0.06252419f, 0.00668975f, -0.04587341f, 0.02413603f, -0.01159887f, 
    -0.07030188f, -0.08204981f, -0.15495965f, 0.04687170f, 0.08995464f, 0.01362454f, -0.12705712f, -0.07202216f, 
    -0.02896938f, 0.03566307f, -0.15228614f, -0.00016895f, 0.13803510f, 0.06048839f, 0.00786961f, -0.01598868f, 
    0.02508055f, 0.00564263f, -0.03099865f, -0.04528179f, -0.08623476f, -0.09653877f, -0.00103051f, -0.02071218f, 
    0.08866227f, 0.04528148f, -0.06169084f, 0.02709827f, -0.01102056f, 0.00973287f, -0.02435238f, -0.06122596f, 
    0.03011342f, 0.11986914f, -0.01631615f, -0.01027055f, -0.05391520f, 0.00064130f, 0.02027022f, 0.02474719f, 
    0.00411788f, -0.00792081f, 0.03149179f, 0.06308797f, -0.03901937f, -0.05353157f, -0.01618024f, -0.03862846f, 
    0.03886481f, -0.02539094f, -0.01918888f, -0.03736275f, 0.00843085f, -0.01910665f, 0.07956156f, 0.00012294f, 
    -0.00258710f, -0.04696871f, 0.02238061f, 0.05605528f, -0.06756771f, -0.04757323f, 0.01923256f, -0.04066104f, 
    0.01278677f, -0.13713053f, -0.10884177f, -0.03766069f, -0.06383590f, -0.07509393f, -0.00183258f, -0.04059689f, 
    -0.41067144f, -0.03595864f, 0.04101485f, -0.10273932f, 0.04532587f, -0.08473061f, 0.03496907f, 0.00874766f, 
    0.09229153f, -0.14239895f, -0.03561666f, 0.04994214f, 0.01380015f, 0.06305939f, -0.00877381f, -0.03218812f, 
    -0.13091648f, 0.06926700f, -0.15383327f, 0.07514730f, -0.10253759f, -0.02623968f, -0.09352269f, -0.08599825f, 
    0.15284036f, 0.08271307f, -0.16637455f, -0.01045086f, 0.04243617f, 0.02948774f, -0.02182191f, 0.10396501f, 
    -0.09625551f, -0.02260488f, 0.05004242f, 0.07375889f, 0.06134738f, 0.05570146f, -0.05643604f, 0.01453277f, 
    -0.14941989f, -0.08084098f, -0.00941231f, -0.07142979f, 0.02906314f, 0.08327352f, -0.07487099f, -0.01160448f, 
    0.03983974f, 0.07031013f, -0.08106840f, 0.03576548f, -0.07064110f, 0.01419610f, 0.00527660f, 0.04795793f, 
    0.03938765f, -0.02844774f, -0.07029143f, -0.06831630f, -0.34013751f, 0.10173768f, -0.09329925f, -0.11682600f, 
    0.03772213f, 0.03331453f, -0.01395662f, 0.02951785f, 0.00325607f, 0.09971417f, -0.00262468f, -0.01508774f, 
    -0.01540428f, 0.04651965f, 0.00710333f, 0.06857320f, 0.04665024f, -0.04234694f, -0.05849602f, -0.06747063f, 
    -0.39422569f, 0.24421445f, 0.01428466f, -0.00862775f, 0.27734452f, 0.16738717f, -0.07527084f, 0.04795653f, 
    0.03086662f, 0.07314448f, 0.00345868f, 0.07929295f, 0.04047621f, 0.00218067f, -0.00911956f, -0.03153263f, 
    0.08667099f, -0.01795224f, -0.10620026f, -0.05643335f, 0.05108530f, -0.22675933f, 0.00014912f, 0.04435940f, 
    0.03542773f, -0.02729961f, -0.09589306f, 0.00674607f, -0.02236687f, 0.01620398f, -0.07736215f, 0.00856112f, 
    -0.03984626f, -0.00849202f, -0.03257413f, -0.01556432f, 0.03736192f, 0.01239464f, 0.02639827f, -0.02313097f, 
    0.01320002f, -0.07246283f, -0.04779138f, 0.06535728f, -0.10673899f, 0.07907833f, 0.03764427f, 0.05728890f, 
    -0.01982901f, -0.04784682f, -0.00927734f, 0.03204373f, 0.01458172f, 0.02015092f, -0.05460402f, -0.07663396f, 
    -0.02444704f, -0.05069127f, -0.12050177f, 0.03515485f, 0.25349206f, -0.16628820f, -0.13896991f, 0.11278445f, 
    0.00980514f, 0.05417968f, 0.01487837f, -0.08092453f, -0.01736157f, -0.04972592f, 0.08373138f, 0.00399785f, 
    -0.01173044f, 0.07745474f, 0.01799930f, 0.10028403f, -0.03912428f, 0.02139760f, -0.07749113f, 0.01725421f, 
    -0.28143844f, 0.13201568f, 0.07810497f, -0.00981764f, 0.09086633f, -0.09442206f, -0.01663030f, 0.04427936f, 
    -0.02683348f, -0.02400580f, 0.06061188f, 0.02626775f, 0.02061435f, -0.06047837f, -0.04310026f, -0.09929237f, 
    0.01902188f, -0.05088094f, -0.02273395f, 0.04275469f, -0.15882418f, -0.10518666f, -0.03446842f, 0.02293679f, 
    -0.05677443f, 0.04277848f, 0.02235904f, 0.01817749f, -0.01864301f, 0.10045400f, -0.04572950f, -0.02623121f, 
    -0.00130069f, 0.00133912f, -0.01349529f, -0.03307267f, 0.05127626f, -0.01418130f, -0.09925268f, -0.04035031f, 
    0.20720601f, -0.01843874f, -0.14078407f, 0.05355569f, -0.04211772f, 0.07763945f, -0.06154780f, -0.04517695f, 
    -0.00395368f, -0.06860097f, 0.05283965f, -0.01283945f, 0.04139470f, 0.02867020f, -0.07557401f, 0.05524690f, 
    0.03918451f, -0.05694270f, -0.08798218f, 0.04208420f, 0.28877771f, 0.02709709f, -0.12439570f, -0.16075951f, 
    -0.01996722f, -0.01780150f, -0.05315491f, -0.04757586f, 0.01817072f, 0.01633250f, 0.01556767f, 0.00673132f, 
    0.01344841f, 0.01983354f, 0.04544653f, 0.02784459f, 0.03413345f, -0.02129585f, -0.01181120f, 0.00457582f, 
    0.22123177f, -0.08222081f, -0.00411664f, 0.00710067f, -0.01627845f, -0.08259629f, -0.08094328f, -0.01175381f, 
    -0.04253468f, -0.07241086f, -0.03094625f, -0.03827981f, 0.02080256f, 0.03124661f, -0.06518111f, -0.01834192f, 
    -0.05489620f, -0.01302323f, -0.00088414f, 0.05425923f, -0.30615187f, 0.13998660f, -0.00588095f, 0.05170121f, 
    -0.08467996f, -0.05757739f, -0.04417691f, -0.02751649f, -0.00177493f, -0.02425101f, -0.07106437f, 0.01718850f, 
    0.07763311f, 0.05311631f, -0.04424460f, 0.03298446f, 0.00436769f, -0.11184617f, -0.02185750f, -0.01247232f, 
    -0.00361139f, -0.17830765f, 0.02142509f, 0.04439634f, -0.15868209f, 0.04020453f, 0.03078399f, 0.08314844f, 
    -0.04215570f, 0.04728273f, -0.03056975f, 0.02630660f, -0.01947488f, -0.04640546f, -0.04630156f, -0.06610154f, 
    -0.01474014f, -0.04329036f, -0.00627464f, 0.01606546f, 0.25382689f, 0.09631313f, -0.15305838f, 0.02696312f, 
    -0.19031739f, 0.04484157f, 0.14558424f, -0.01557830f, -0.02446692f, 0.07866757f, 0.05191369f, 0.02782230f, 
    -0.05505950f, -0.02732712f, 0.09627782f, 0.00054259f, -0.04067986f, -0.01724824f, -0.00671842f, 0.10833137f, 
    -0.26903841f, 0.24714564f, -0.01781066f, -0.07174494f, 0.05646777f, -0.07830925f, -0.11877102f, 0.12739491f, 
    -0.10994700f, -0.00677617f, 0.01984912f, 0.01783533f, 0.05710117f, -0.05869776f, -0.07250778f, -0.03203791f, 
    0.00872361f, -0.05011464f, -0.02330519f, -0.13681638f, 0.06075042f, 0.02601418f, 0.07363711f, 0.00292529f, 
    -0.16867639f, -0.09737525f, -0.01462425f, -0.02331889f, -0.07801698f, -0.07699261f, -0.16321266f, -0.00727307f, 
    0.07828306f, 0.05115321f, -0.06461436f, 0.05780749f, -0.02211427f, 0.06793389f, -0.06620910f, -0.06136852f, 
    0.04217830f, 0.19592699f, -0.04561770f, -0.02799880f, 0.17833395f, 0.07727388f, -0.18305209f, -0.03108481f, 
    0.10878055f, 0.01555347f, 0.03991016f, 0.08221361f, -0.04779804f, -0.03190135f, 0.02968296f, 0.00461268f, 
    0.07715219f, 0.04135813f, -0.03447991f, 0.03886745f, 0.03607569f, -0.07246466f, 0.03189175f, 0.02802347f, 
    -0.06095735f, 0.01156423f, 0.01486197f, 0.00602205f, -0.06289223f, -0.06065066f, -0.06452928f, -0.01519306f, 
    0.07458372f, 0.00161994f, -0.06448425f, -0.08455133f, 0.02355341f, -0.01262199f, -0.06973657f, 0.02353303f, 
    -0.26444176f, 0.17474493f, -0.02571315f, 0.02204689f, 0.02561704f, 0.03875927f, -0.01035895f, 0.01305800f, 
    0.03034855f, 0.06296869f, -0.06137610f, 0.01561103f, 0.09486092f, -0.05401614f, 0.04054496f, -0.05607180f, 
    -0.01367285f, 0.06486958f, -0.07021587f, -0.04127815f, 0.00982065f, 0.19323000f, -0.08331923f, -0.06988927f, 
    0.17753683f, 0.05924611f, 0.01552319f, -0.01428027f, -0.01295000f, -0.01197392f, 0.03259193f, 0.08917346f, 
    -0.03690190f, 0.01923476f, 0.02302321f, -0.01615641f, -0.02250305f, 0.08296709f, 0.01536712f, 0.04984920f, 
    -0.25696221f, 0.11230741f, -0.07567481f, -0.01084758f, -0.08232112f, 0.09634487f, 0.12855834f, 0.08233247f, 
    0.01694117f, 0.05862451f, -0.04660320f, -0.01663504f, 0.01207478f, -0.08516473f, 0.02647346f, -0.01270365f, 
    -0.01874274f, -0.04713104f, -0.05147004f, 0.00500171f, 0.16697931f, -0.11556493f, -0.13957134f, 0.01201174f, 
    -0.16496703f, 0.02545584f, -0.02643383f, 0.09350166f, -0.07722272f, 0.07626474f, -0.03372481f, 0.05100645f, 
    -0.01206832f, -0.06445037f, -0.03749925f, -0.00703745f, -0.02227950f, -0.08073309f, -0.03930778f, -0.05735504f, 
    0.17174278f, 0.06711520f, -0.25779951f, 0.09547962f, -0.01685704f, 0.19020756f, -0.04085859f, 0.01482838f, 
    0.10161258f, -0.05915355f, 0.07515302f, 0.08305527f, 0.02022604f, 0.09216095f, -0.02007373f, 0.08009750f, 
    -0.02445891f, 0.06554767f, -0.05068243f, 0.04683397f, 0.27487227f, -0.24331650f, -0.22016276f, -0.08713341f, 
    -0.15933032f, 0.04575273f, -0.01559537f, -0.00962124f, -0.00735756f, 0.09021102f, 0.07986070f, -0.01791459f, 
    0.00658009f, -0.00859350f, -0.02273369f, -0.01442023f, -0.08277473f, 0.01491350f, -0.05880617f, 0.03321365f, 
    0.08587606f, -0.12713178f, -0.07048798f, 0.10718000f, -0.12692152f, 0.05164180f, 0.06524829f, 0.05698780f, 
    -0.04243212f, 0.00704728f, -0.04900775f, -0.08113121f, 0.02510498f, 0.07730123f, -0.06049459f, -0.01585484f, 
    -0.00647082f, 0.03350598f, -0.07816909f, -0.06107075f, 0.36196828f, 0.15284222f, -0.17139617f, -0.12975006f, 
    -0.02800455f, 0.01491020f, 0.02768937f, -0.08231832f, 0.04415729f, -0.01962724f, 0.05892069f, 0.00880094f, 
    -0.02669156f, 0.00107573f, 0.00639907f, -0.01432057f, 0.00868769f, -0.00261106f, -0.04123589f, 0.04455946f, 
    -0.32957309f, 0.26490775f, -0.10405872f, 0.09919787f, -0.20748281f, 0.08009917f, 0.02212438f, 0.02096785f, 
    0.03142053f, 0.07394676f, 0.01258504f, -0.02160876f, 0.02016987f, -0.00589300f, 0.04709432f, -0.01627622f, 
    0.11236211f, -0.00754370f, -0.06424992f, 0.01916183f, -0.14960399f, 0.10744190f, -0.00769929f, -0.02182745f, 
    -0.00664713f, 0.03559642f, 0.04774810f, 0.04115462f, -0.00886946f, 0.05367117f, -0.04926189f, -0.03695304f, 
    -0.01919446f, -0.03632645f, 0.06979485f, 0.01992542f, -0.05283986f, -0.04823197f, 0.00544394f, -0.08351550f, 
    0.20132393f, -0.04554047f, -0.12449282f, -0.02873046f, 0.22721510f, 0.02025543f, -0.09451453f, 0.00993389f, 
    0.08797434f, -0.04713356f, 0.05999284f, -0.04239045f, 0.01422558f, 0.02705731f, 0.04124280f, 0.01785140f, 
    0.02875856f, 0.04371002f, 0.02046210f, 0.09427968f, 0.10282961f, -0.02124739f, -0.00572466f, 0.01916633f, 
    0.08850244f, 0.02918326f, -0.03858944f, 0.01327208f, 0.11216185f, -0.08662448f, -0.00251329f, -0.01442129f, 
    -0.04234336f, 0.14715050f, 0.07742939f, 0.04632914f, 0.01965104f, -0.03436119f, 0.05794541f, 0.02085550f, 
    -0.09069444f, 0.21835750f, 0.03261895f, 0.04841737f, 0.27709198f, 0.09570635f, -0.03709100f, 0.05441394f, 
    0.05539051f, 0.06354462f, -0.04451779f, 0.08567645f, 0.10827997f, -0.07093178f, -0.00113864f, -0.15696266f, 
    0.01035611f, 0.06936879f, 0.04844384f, -0.01952804f, 0.15310089f, 0.07738200f, -0.11242028f, -0.18360095f, 
    -0.01401499f, -0.12790906f, -0.03712129f, -0.02629448f, -0.11463051f, -0.14161739f, -0.04417856f, 0.03113220f, 
    0.01963808f, -0.00823973f, -0.01252255f, 0.05309130f, -0.03684030f, 0.02805170f, 0.01780783f, -0.07939988f, 
    -0.09346890f, 0.12729593f, 0.00156632f, 0.00276717f, -0.02053708f, -0.00606278f, -0.03702770f, 0.02568787f, 
    -0.06289142f, -0.08057774f, 0.00873697f, -0.04542453f, 0.06270689f, -0.11071830f, 0.02474385f, 0.02494955f, 
    0.05262507f, 0.03870824f, 0.01838873f, -0.05382806f, -0.11772954f, 0.05337520f, -0.19501095f, -0.11555697f, 
    -0.02553999f, -0.07584896f, -0.07065707f, -0.05197041f, -0.00682172f, -0.09319055f, 0.15805209f, 0.05437873f, 
    -0.05774759f, -0.06639519f, -0.03595142f, 0.03709065f, 0.00755902f, 0.00731569f, 0.05114056f, 0.01300437f, 
    0.11796103f, -0.15497158f, -0.14648052f, -0.13627893f, -0.12318719f, -0.02806550f, 0.00648288f, 0.03616649f, 
    -0.00273955f, 0.08564541f, -0.00658822f, 0.05828303f, 0.01362058f, -0.00944770f, 0.05678494f, -0.01949846f, 
    -0.00471356f, -0.02570608f, -0.00769707f, -0.03773788f, -0.21411654f, 0.24274026f, -0.06050285f, -0.00497991f, 
    0.39672667f, 0.00958418f, -0.16232263f, 0.00590815f, 0.05212332f, 0.08633453f, 0.04097540f, -0.02654576f, 
    0.02308152f, 0.05694004f, 0.04336172f, -0.02234567f, 0.06572607f, -0.04478800f, 0.01072502f, -0.07428733f, 
    -0.17250903f, 0.03082824f, 0.02298483f, 0.04906566f, 0.00314363f, 0.09347879f, 0.01608674f, 0.02032982f, 
    -0.04407801f, 0.03549018f, 0.03763701f, 0.01553131f, -0.01979424f, 0.00048025f, -0.01687104f, -0.07225505f, 
    -0.00041764f, -0.07133076f, -0.03830008f, 0.01219506f, 0.17091730f, -0.07085570f, -0.03775704f, 0.00872449f, 
    0.05271693f, -0.09105317f, -0.08652245f, -0.05956631f, 0.04805132f, -0.00880023f, 0.05233546f, -0.07281070f, 
    -0.05907785f, 0.03261117f, -0.05567782f, -0.02507026f, -0.04446356f, 0.10747895f, 0.04484739f, -0.01887213f, 
    -0.07883945f, -0.28335986f, 0.01383260f, 0.08227658f, -0.11610561f, 0.08181359f, -0.03379175f, 0.09557452f, 
    0.00565816f, 0.11278745f, -0.01942649f, -0.07814761f, 0.00654006f, 0.03019726f, 0.03453472f, -0.07568620f, 
    -0.01606283f, -0.02932779f, -0.09958522f, -0.09904523f, 0.04587069f, -0.09252609f, -0.02274204f, 0.03035383f, 
    0.00290760f, 0.08946307f, 0.05061797f, -0.01115710f, -0.01996850f, 0.03740236f, 0.00570914f, -0.06872009f, 
    0.00724014f, 0.02655470f, -0.03862236f, -0.05814097f, -0.07750332f, 0.02854172f, 0.00801308f, 0.00967748f, 
    0.05757356f, 0.07627162f, 0.02523187f, 0.08075977f, 0.08463659f, -0.00691235f, -0.05310177f, 0.00514075f, 
    -0.03345214f, -0.04474232f, 0.00936406f, -0.01965050f, 0.03044762f, -0.00735727f, 0.00112339f, 0.05840297f, 
    -0.01315677f, 0.05733206f, -0.00877593f, -0.08629414f, 0.36270845f, -0.03473010f, -0.13486607f, -0.04532763f, 
    -0.12994716f, -0.09166172f, 0.00416092f, 0.03247809f, 0.05338666f, 0.07010104f, 0.08175820f, -0.02855529f, 
    -0.01956287f, -0.08956380f, 0.05590411f, 0.05979488f, -0.07838397f, -0.04544837f, -0.05782866f, -0.01861550f, 
    -0.25689042f, -0.24015114f, -0.06336389f, -0.03239366f, -0.15250598f, 0.01514523f, 0.04093387f, -0.05127522f, 
    0.08320485f, -0.00295493f, -0.09538585f, -0.03683333f, 0.02202901f, -0.00502515f, 0.03463352f, -0.11107899f, 
    -0.01525349f, -0.03084757f, -0.09695835f, -0.07826885f, -0.23468368f, 0.06249671f, 0.03172660f, 0.00193953f, 
    0.03020984f, 0.02187527f, 0.00510088f, -0.03581448f, 0.02773013f, 0.02705866f, -0.04426021f, -0.01144930f, 
    0.02484877f, -0.02335911f, -0.02018110f, -0.04481904f, -0.00835996f, -0.01648713f, -0.03599363f, 0.01589948f, 
    0.15556754f, 0.00471620f, -0.04109642f, 0.06894394f, 0.00484426f, 0.10130103f, 0.02735762f, -0.04330773f, 
    -0.05762507f, 0.00751014f, -0.00350390f, 0.01180997f, 0.03614793f, 0.04068097f, -0.00678196f, -0.04314566f, 
    -0.03235895f, 0.00791427f, -0.09969922f, 0.05131810f, 0.21798843f, 0.12183688f, -0.07788768f, 0.01192974f, 
    -0.16247261f, 0.03339718f, 0.02028896f, 0.00000216f, 0.02148022f, -0.01369070f, 0.05839324f, 0.04573940f, 
    -0.01344618f, -0.02524564f, 0.03364430f, -0.00596549f, 0.01993517f, 0.01486848f, -0.04389317f, 0.04724608f, 
    0.07358842f, -0.12003405f, 0.02372706f, 0.13606302f, -0.02969636f, 0.00478336f, 0.08308651f, 0.00810158f, 
    0.07673114f, -0.04914070f, 0.02239767f, -0.14882484f, -0.08964227f, 0.03741527f, 0.01500959f, 0.02837461f, 
    -0.00133160f, 0.04095450f, 0.05579654f, -0.04300883f, 0.27655989f, 0.02888756f, -0.20099925f, -0.07616492f, 
    -0.31928137f, 0.01909878f, -0.05103790f, 0.02943493f, -0.00606999f, -0.00349381f, 0.05128401f, -0.02961772f, 
    -0.03121489f, -0.04427251f, -0.02147471f, -0.08120316f, -0.00953940f, -0.02736912f, -0.03761670f, 0.03360827f, 
    -0.05137632f, -0.24304527f, 0.00195422f, 0.04685356f, 0.00829797f, -0.09528685f, 0.11288392f, 0.04796051f, 
    -0.05342232f, -0.11188571f, 0.06578413f, -0.03092648f, -0.03484219f, 0.04358518f, 0.02279879f, 0.07079133f, 
    0.07318757f, -0.11517556f, -0.00895074f, 0.11887757f, 0.24222067f, -0.07177883f, 0.03636606f, -0.03338975f, 
    -0.00406698f, -0.11825684f, -0.01068196f, 0.06852666f, 0.04150014f, -0.11272956f, 0.00786855f, -0.11038627f, 
    -0.03361554f, 0.06946127f, -0.05182857f, -0.05052432f, -0.09097667f, 0.00519089f, -0.06577797f, 0.07200836f, 
    0.04293153f, -0.09944872f, -0.13711089f, 0.01040189f, -0.20343973f, 0.01695676f, 0.03762249f, 0.05959712f, 
    -0.05732160f, 0.08518375f, -0.07724628f, 0.09062817f, -0.02058207f, -0.01406672f, -0.02198147f, -0.08816820f, 
    0.03200070f, 0.01241034f, -0.02185088f, -0.06538630f, 0.09332775f, -0.03305473f, -0.06423380f, -0.14437196f, 
    0.18948674f, 0.03669999f, -0.05771791f, 0.05595779f, 0.12492244f, 0.01097520f, 0.00247129f, -0.08388036f, 
    -0.00910866f, -0.00500175f, -0.05394949f, -0.03613945f, -0.03390368f, -0.01506009f, 0.04074204f, 0.10093554f, 
    -0.16434133f, 0.08046707f, -0.10924472f, -0.14207262f, 0.07050861f, -0.09116957f, -0.17060374f, -0.02936208f, 
    -0.03306182f, -0.00988176f, 0.03376923f, 0.01842269f, -0.00848821f, -0.00394749f, 0.06200747f, 0.11190522f, 
    -0.10333429f, 0.04258694f, 0.04919952f, -0.02874595f, -0.27073976f, 0.20021065f, -0.00044640f, -0.01014192f, 
    -0.07782583f, 0.00596492f, -0.00992808f, 0.03929982f, -0.03696649f, -0.00125966f, 0.04729749f, 0.01525419f, 
    -0.01439841f, -0.06030912f, -0.00191767f, 0.00402443f, -0.03283699f, -0.05821229f, -0.02947115f, 0.03027314f, 
    -0.15830244f, 0.00407149f, 0.04976361f, 0.02624089f, 0.02716148f, -0.05438563f, 0.11404651f, -0.05752046f, 
    0.02392433f, -0.00208089f, -0.05012680f, 0.07354309f, 0.07397460f, 0.04182949f, 0.05411645f, -0.00895622f, 
    0.04510357f, 0.01749486f, -0.03175838f, 0.00991611f, 0.04348427f, -0.15988375f, 0.13284697f, 0.01362548f, 
    0.10076148f, -0.04060901f, -0.00659870f, 0.06796537f, 0.02566839f, -0.13172466f, 0.00262051f, -0.13197286f, 
    0.02078985f, 0.05357578f, -0.06954680f, -0.07913151f, -0.11874779f, -0.02979454f, -0.06427568f, 0.02260228f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04167367f, 0.02857283f, -0.03903965f, -0.02287444f, 0.00739327f, -0.00718348f, 0.00147354f, -0.03650647f, 
    -0.01481737f, -0.00145289f, 0.02328507f, -0.01223922f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
