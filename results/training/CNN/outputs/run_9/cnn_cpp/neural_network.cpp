#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.40878913f, 1.34695184f, 0.61150646f, -1.00878358f, 0.51403767f, 0.26847565f, -0.27167547f, -0.14652617f, 
    -0.06042658f, 0.26524925f, -0.91052938f, 0.74631757f, 0.17666997f, 0.67932105f, -0.50071108f, 0.02635919f, 
    0.59294194f, -0.44959435f, 0.84732878f, -0.22885831f, -0.83576477f, -0.36953518f, -0.65540177f, 0.21328935f, 
    -0.38628030f, -0.21452846f, 0.30162773f, 0.77501041f, 1.02815032f, 0.38905701f, 0.21103516f, 0.38495821f, 
    0.56134206f, 0.49193811f, -0.12252530f, 0.17196718f, -0.67522877f, -1.15831745f, -0.93554837f, 0.41907525f, 
    0.15686621f, -0.20189144f, -0.14855625f, 0.36394259f, 0.33196101f, -0.90502399f, 0.18311575f, -0.01765839f, 
    0.36905682f, 1.09773290f, -0.24944536f, -0.25409630f, -0.28412348f, 0.12348599f, 0.09541155f, -1.27207744f, 
    -0.55343640f, -0.96940744f, -0.20253684f, 0.11290324f, 0.25259256f, 0.24515052f, 0.27576160f, 0.26134136f, 
    -0.47184336f, 1.09266746f, -0.96320796f, -0.59457529f, -0.44238541f, 0.48452368f, 0.28727803f, -0.05698754f, 
    -1.15911531f, -0.14590608f, 0.28967810f, 0.60642332f, 0.44420159f, 0.72531825f, -0.01521544f, -0.21577071f, 
    0.32376605f, -0.88350928f, 0.36252111f, 1.09989822f, 0.59612101f, 0.46748972f, -0.13923393f, 0.09653568f, 
    0.55090016f, 0.07781426f, 0.42690912f, 0.04967936f, -0.93492633f, -0.52303362f, 0.33958963f, -0.74301642f, 
    0.25825277f, -0.02153194f, -0.37697187f, -0.38597730f, -0.86137104f, -0.75357139f, 0.52445316f, 0.75814104f, 
    -0.13671280f, 0.06131554f, -0.30909839f, -0.27012798f, 0.99111784f, 1.08239388f, 0.80127829f, 0.03509198f, 
    -0.98211062f, -0.58733833f, 0.00601143f, 0.02741450f, 0.15163369f, 0.98816788f, -0.94580930f, 0.20568950f, 
    0.76736009f, 0.60173637f, 0.61637706f, -0.56837910f, -0.07894633f, -0.12121972f, -1.18358123f, 0.48301154f, 
    -0.27468979f, 0.53466707f, -0.00862839f, -0.92421234f, 0.06055228f, 0.01340907f, -0.22025539f, 1.19866335f, 
    0.70409203f, -0.54579794f, 0.83866453f, 0.29592800f, -0.55484796f, -0.39114317f, -0.01896034f, -0.04103867f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24905370f, 0.11503752f, -0.19408263f, 0.25885403f, 0.20540322f, -0.33832633f, 0.21522711f, 0.10501883f, 
    -0.08090342f, 0.10209436f, 0.05445206f, 0.01834475f, 0.07267700f, -0.09586824f, 0.02667466f, 0.12572101f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.13699563f, -0.06494476f, 0.04389058f, -0.01213418f, 0.27361420f, -0.04535156f, 0.06476995f, -0.01860409f, 
    -0.21170799f, -0.09986300f, -0.10253870f, 0.05334747f, 0.05273334f, 0.00184359f, 0.01816159f, 0.11624894f, 
    0.15565099f, -0.23745847f, 0.09947100f, 0.06503370f, 0.26366082f, -0.10558158f, -0.13996062f, -0.19460157f, 
    -0.13957132f, -0.00524821f, -0.06075444f, -0.03079827f, 0.07261623f, -0.02456471f, -0.00923074f, 0.17642018f, 
    -0.07272870f, 0.17766005f, 0.04860075f, -0.06090388f, 0.01191509f, 0.03167305f, -0.05886947f, -0.07884883f, 
    -0.01693460f, 0.23456539f, -0.18711309f, 0.17024374f, -0.08811121f, 0.11629251f, 0.19249411f, 0.11754666f, 
    -0.03064111f, -0.14295307f, -0.10250334f, 0.13242121f, -0.01081874f, 0.12462510f, -0.00018803f, 0.06392261f, 
    0.13845542f, 0.22852300f, -0.02173001f, 0.00574330f, 0.04642501f, 0.10456976f, -0.06132638f, -0.24866842f, 
    0.09292398f, -0.14021695f, 0.07802383f, -0.06080947f, -0.07843176f, -0.04563703f, -0.01624829f, -0.03548268f, 
    -0.01610578f, -0.23698559f, -0.03135135f, -0.04094837f, -0.00374753f, -0.26005748f, -0.24226764f, -0.14849120f, 
    0.08321808f, 0.00100217f, 0.25069347f, 0.04896080f, 0.10207143f, -0.04359519f, -0.03230236f, -0.06057767f, 
    0.10005287f, -0.00309163f, 0.09743058f, -0.06124364f, -0.18446834f, -0.02009736f, 0.09026790f, -0.00231099f, 
    -0.02827312f, 0.16323796f, -0.11181775f, 0.16218121f, 0.74001914f, 0.00739543f, 0.07061900f, -0.10982967f, 
    0.10923112f, 0.04529887f, 0.01347960f, 0.02764117f, 0.14339224f, 0.15223590f, -0.10222903f, -0.02423626f, 
    0.02643280f, 0.27670485f, 0.03261534f, 0.12258961f, 0.04740965f, -0.12562698f, 0.08160830f, -0.01544683f, 
    0.27278948f, 0.18882599f, -0.10014706f, -0.20608097f, -0.12692979f, -0.04436204f, -0.03279053f, -0.00022705f, 
    0.00958922f, 0.00550665f, -0.10581828f, -0.05119949f, -0.07945663f, -0.16389276f, 0.07358573f, -0.05657649f, 
    0.01589551f, 0.02441078f, 0.16354349f, 0.05722793f, 0.27058366f, -0.11227565f, -0.26612991f, -0.28127587f, 
    -0.01623314f, -0.05360407f, 0.06434130f, -0.07913279f, -0.08608708f, -0.06390734f, -0.09895112f, 0.09379119f, 
    -0.16368303f, -0.19600180f, -0.23489526f, 0.09940877f, -0.02705198f, 0.06672233f, 0.32327715f, 0.01022512f, 
    0.59688556f, 0.00879767f, -0.03217252f, -0.11183740f, 0.15433937f, -0.00858151f, -0.05940385f, 0.03150042f, 
    0.15909964f, 0.12503855f, -0.17808279f, 0.00447026f, -0.06486335f, 0.07820614f, 0.07426358f, -0.02605137f, 
    0.20068656f, -0.23932911f, -0.13218601f, -0.12605107f, 0.31639844f, 0.07644184f, 0.00805393f, -0.03944298f, 
    0.08874018f, 0.01901959f, -0.04688734f, 0.11764479f, 0.00340230f, -0.04519521f, -0.02167317f, 0.09748416f, 
    0.01134611f, -0.01978788f, 0.02647198f, 0.04337472f, -0.02839905f, -0.30079779f, -0.16683535f, -0.03808761f, 
    -0.32639655f, 0.48548436f, -0.05279000f, -0.13223678f, -0.07120521f, 0.07625576f, 0.02167623f, -0.05931611f, 
    -0.04663755f, 0.01830066f, -0.21275051f, -0.00160243f, 0.10452554f, 0.01945890f, 0.09308726f, 0.09488708f, 
    -0.01250122f, 0.03721282f, 0.17324512f, -0.04431239f, -0.17973275f, -0.05110229f, 0.47333056f, -0.03706675f, 
    0.12950769f, -0.10795633f, -0.04188162f, -0.04815942f, 0.04266225f, 0.07734300f, 0.00946345f, -0.08967974f, 
    0.11812580f, 0.13141218f, 0.05026745f, -0.05654720f, 0.08531561f, 0.17557204f, -0.01829230f, 0.04037274f, 
    -0.06920259f, 0.11542062f, 0.00917315f, -0.19527681f, 0.05597467f, 0.02189839f, 0.04624235f, -0.17164789f, 
    0.00968220f, -0.05972235f, 0.02367682f, 0.06375232f, -0.04105173f, -0.15493044f, -0.09907558f, 0.17055877f, 
    0.07542592f, 0.05732873f, 0.02394066f, -0.02988779f, 0.01373282f, 0.08981851f, -0.21917781f, -0.22372161f, 
    -0.05465109f, 0.20173037f, -0.05238107f, 0.23540422f, -0.01402395f, 0.12362721f, -0.09051303f, -0.08485323f, 
    0.05274691f, 0.15103671f, -0.00000670f, 0.03360374f, 0.26232073f, -0.12774181f, -0.32763082f, -0.10531486f, 
    0.40121338f, -0.01433805f, 0.04233212f, -0.06600013f, 0.16073211f, -0.01833418f, -0.10715412f, -0.12097586f, 
    0.08515831f, -0.00469795f, -0.11962193f, -0.07120539f, -0.06235477f, 0.08804569f, -0.00881068f, 0.16246681f, 
    -0.00475957f, 0.05479053f, -0.03269550f, 0.00240824f, 0.13549446f, 0.29902518f, -0.00123202f, -0.10609227f, 
    0.19794825f, -0.07643954f, -0.02875245f, -0.03590204f, 0.03124329f, 0.08566601f, -0.06604205f, 0.15527590f, 
    0.04995307f, 0.22520006f, 0.14402895f, 0.03671792f, 0.09105934f, 0.12004973f, -0.45465830f, 0.06928371f, 
    0.10969775f, -0.22074990f, 0.42723688f, 0.19369002f, 0.05755667f, -0.04324747f, 0.00720707f, -0.05802266f, 
    0.07976615f, -0.10205072f, 0.11094320f, 0.01433740f, 0.09729596f, -0.08503619f, 0.13593125f, 0.10691284f, 
    0.08053940f, -0.10495456f, 0.16096292f, 0.01299789f, -0.16811112f, 0.20588048f, -0.14092875f, 0.01967716f, 
    -0.01431875f, 0.21776220f, -0.02580992f, -0.04215913f, 0.09070466f, -0.10363006f, 0.07109479f, 0.19947423f, 
    -0.04278221f, 0.15319136f, -0.04237733f, 0.10390632f, -0.09019458f, -0.10909800f, 0.06313367f, -0.11630693f, 
    0.06790526f, 0.57151610f, -0.19488367f, 0.50340438f, 0.03557267f, -0.01803330f, 0.04550283f, 0.06075616f, 
    -0.05964812f, -0.02495563f, -0.03320742f, 0.04654159f, 0.07650133f, 0.08024614f, 0.11535013f, 0.00925110f, 
    0.18525733f, 0.13113357f, 0.00302511f, 0.24150479f, -0.10722522f, -0.29134944f, -0.05979800f, -0.08528608f, 
    -0.28596964f, 0.15289435f, 0.13177104f, -0.16137359f, 0.02431081f, -0.03140737f, 0.03691249f, -0.12092708f, 
    -0.06165605f, -0.19683716f, 0.03522819f, 0.14169100f, 0.03367442f, -0.17950714f, 0.01196877f, -0.06861887f, 
    -0.15906930f, 0.03332647f, -0.07483305f, 0.03507892f, 0.08239733f, 0.01766378f, 0.04130923f, -0.13703743f, 
    -0.06615007f, -0.05286223f, 0.13555980f, 0.06840470f, -0.07876029f, -0.06578988f, 0.07093681f, -0.11111980f, 
    -0.14406590f, 0.10609002f, 0.04705223f, 0.06018329f, 0.27404723f, -0.06644034f, -0.05310991f, -0.03195712f, 
    -0.03322490f, 0.05962563f, -0.10102304f, 0.10195062f, 0.11235040f, 0.11517523f, -0.06193292f, -0.12999272f, 
    0.03618633f, 0.14255661f, -0.04886390f, -0.02742041f, 0.10069066f, -0.04580405f, -0.13303807f, 0.05149770f, 
    -0.28876382f, 0.46750709f, -0.20589690f, 0.00944369f, -0.03327300f, 0.06969743f, -0.15636849f, -0.10262694f, 
    -0.13486925f, 0.00614311f, -0.00537439f, -0.03202665f, -0.12590608f, -0.05187985f, -0.01423192f, -0.10429368f, 
    0.02234767f, 0.03968839f, 0.02472755f, 0.14158185f, 0.44272706f, 0.08743348f, 0.08418455f, -0.07300920f, 
    0.27984110f, 0.05338435f, 0.07524125f, 0.13544728f, -0.05670502f, 0.15132347f, -0.01101766f, 0.01411595f, 
    -0.08157804f, -0.01707773f, -0.18492413f, 0.09631921f, 0.07520779f, 0.10574117f, 0.01111084f, 0.01840139f, 
    0.21680681f, -0.14678483f, 0.05850134f, -0.16733056f, 0.09526138f, 0.01736104f, -0.12168565f, 0.05129114f, 
    0.19462694f, 0.05067506f, 0.02806581f, -0.12842548f, -0.02072031f, -0.00609373f, 0.03144779f, 0.05523013f, 
    -0.02248569f, -0.09315759f, -0.17069246f, -0.07707777f, 0.03701448f, 0.02447360f, -0.00856317f, 0.06197097f, 
    -0.01093483f, 0.27807638f, -0.03205688f, 0.03361488f, 0.09559789f, -0.07840008f, 0.02437697f, -0.01393206f, 
    0.06591401f, 0.09116443f, -0.00045673f, 0.07228807f, 0.07762256f, -0.19294231f, -0.02984261f, -0.07457833f, 
    -0.33182681f, 0.38386559f, 0.49596891f, 0.12929475f, -0.13218476f, 0.04620656f, 0.18056038f, 0.03806559f, 
    -0.02457365f, -0.08545549f, -0.08307277f, 0.07375941f, 0.11110471f, -0.05716677f, -0.00637908f, -0.01897944f, 
    0.08217720f, 0.16521148f, 0.06523972f, -0.00280190f, -0.32474184f, 0.00719605f, 0.16956235f, 0.03825604f, 
    0.14478248f, -0.01465836f, -0.05509662f, 0.01308685f, -0.03391330f, -0.04524522f, -0.06798837f, -0.10429316f, 
    0.16015396f, 0.02185478f, -0.07246300f, -0.04093985f, -0.02972023f, 0.05660113f, 0.07649901f, 0.04019358f, 
    -0.06291287f, -0.12219129f, 0.04262610f, -0.06280049f, -0.29216129f, 0.12196189f, 0.18209821f, -0.12159496f, 
    -0.03044754f, -0.01295913f, 0.11341426f, 0.01447397f, -0.15064110f, -0.09058932f, -0.02557162f, 0.07992169f, 
    0.06260746f, -0.04714311f, 0.05714363f, -0.07728776f, -0.31375647f, 0.20580295f, -0.26118660f, 0.02269484f, 
    -0.08231393f, 0.12950142f, -0.03545916f, 0.18832158f, 0.15102305f, 0.00272023f, -0.19408137f, -0.07498769f, 
    -0.01478556f, 0.00382505f, 0.16167171f, 0.06641115f, 0.09386249f, 0.01735239f, -0.11434836f, -0.10040236f, 
    0.36099952f, 0.20096642f, 0.18835083f, 0.15435468f, -0.03301345f, -0.14208458f, 0.08789635f, -0.06208916f, 
    0.05410233f, -0.01918982f, -0.05232144f, 0.00832790f, 0.12089393f, 0.08035111f, 0.00939234f, 0.10925721f, 
    0.09622141f, 0.05330060f, 0.04688583f, 0.08271629f, -0.29379836f, 0.39700928f, -0.15025303f, 0.23199899f, 
    -0.20817260f, 0.18988077f, 0.11579539f, -0.01837910f, -0.01367319f, 0.08834787f, 0.10294917f, 0.09182373f, 
    0.06374490f, 0.03430656f, 0.09072512f, 0.11035823f, 0.09482010f, 0.10966630f, -0.26499945f, 0.14073066f, 
    -0.25330317f, 0.28108820f, -0.24817890f, 0.10348824f, 0.11626662f, 0.13131374f, 0.11341555f, -0.03978019f, 
    -0.07962294f, 0.07426020f, 0.05860566f, -0.00754814f, -0.06101835f, 0.02806200f, 0.11384553f, -0.00957522f, 
    0.05709311f, -0.08152004f, -0.03203614f, -0.02182946f, -0.37119538f, 0.13619906f, 0.08960943f, -0.21477601f, 
    -0.15989372f, -0.01235422f, 0.00293407f, -0.04813600f, -0.04906709f, -0.03291247f, 0.12583609f, 0.09369607f, 
    -0.02698899f, -0.06014572f, -0.09052522f, -0.01967362f, -0.01019763f, -0.01563640f, 0.05463128f, -0.02293180f, 
    0.41969183f, -0.11137874f, -0.12173813f, 0.27185187f, -0.04192027f, -0.03810798f, 0.11830502f, 0.14971153f, 
    0.00554923f, -0.11864459f, -0.04812050f, 0.17035933f, 0.08178919f, 0.01320629f, 0.06903312f, 0.10888214f, 
    0.11851792f, 0.10279265f, 0.22622631f, 0.01564851f, -0.18745962f, -0.26142263f, -0.12142261f, -0.36363590f, 
    0.04530538f, -0.14472610f, -0.13927275f, 0.04556184f, -0.20826893f, -0.13996707f, -0.05190209f, -0.07865275f, 
    -0.10672534f, -0.02507835f, 0.04240843f, -0.01913168f, -0.05225864f, -0.10454793f, -0.05643902f, 0.05299298f, 
    0.06791415f, 0.22030133f, -0.00958052f, -0.08753995f, 0.10964884f, 0.13249043f, -0.11616429f, 0.05169762f, 
    0.23769215f, 0.08188542f, 0.09804664f, 0.08693381f, 0.04045733f, 0.02054010f, 0.07717444f, -0.00061646f, 
    0.02363793f, 0.12887177f, -0.02028374f, 0.11282381f, 0.28290597f, 0.34889922f, -0.03639026f, -0.04696409f, 
    -0.24149890f, 0.15083912f, 0.00626189f, 0.02725980f, 0.08368295f, 0.14904749f, 0.12378551f, -0.03833522f, 
    -0.06235720f, 0.13586859f, -0.01792256f, -0.08096264f, -0.06307077f, 0.00263099f, 0.03393448f, -0.04414320f, 
    0.39950275f, 0.06814585f, -0.04562668f, 0.02018136f, -0.27338094f, 0.09042250f, 0.04444756f, -0.01480163f, 
    0.01605321f, 0.01319559f, -0.04038623f, 0.07514738f, 0.10972636f, -0.15821637f, -0.00185686f, 0.02961574f, 
    0.02852269f, 0.11891543f, 0.05756512f, 0.01632758f, -0.12279743f, 0.00517472f, 0.02551779f, 0.40151140f, 
    -0.00448417f, -0.08860233f, 0.06983199f, -0.18865722f, -0.14468142f, -0.07790851f, -0.00078480f, 0.18215682f, 
    0.08564904f, -0.02639575f, -0.05370719f, 0.09530208f, 0.02363235f, -0.06190167f, 0.12813291f, -0.02545062f, 
    0.27404580f, 0.30142587f, 0.03047048f, -0.28503063f, 0.10082891f, -0.06765195f, -0.06529853f, -0.05627492f, 
    0.22613147f, 0.07930402f, 0.01218003f, -0.16380803f, -0.05753800f, -0.02740437f, 0.02869283f, 0.13448638f, 
    0.13968605f, -0.08376195f, -0.05358341f, -0.06850338f, -0.12792583f, 0.09879898f, -0.16665480f, -0.24568267f, 
    -0.13739634f, 0.00910078f, -0.04470384f, 0.11102743f, -0.06140765f, 0.02802615f, -0.02928506f, 0.03402081f, 
    -0.00451306f, -0.08462088f, 0.02733479f, 0.02999761f, -0.04579239f, -0.08415911f, -0.00502827f, 0.00042264f, 
    -0.03611196f, 0.09438460f, 0.25220320f, -0.09821503f, 0.10027193f, 0.06362244f, 0.07587522f, 0.12016445f, 
    0.10808268f, 0.14222322f, -0.04761655f, 0.00947580f, 0.07930667f, -0.12126733f, 0.14459465f, 0.03493962f, 
    0.04381659f, 0.03451733f, 0.09559949f, -0.02508273f, -0.11964232f, -0.01658020f, 0.27734190f, -0.11729772f, 
    0.00683411f, -0.13387536f, 0.01876873f, 0.16699110f, 0.14571983f, -0.02761075f, 0.10404625f, -0.12746809f, 
    0.08226331f, 0.20938346f, 0.07393955f, -0.12899835f, 0.01619742f, 0.08839918f, -0.04468569f, -0.09756158f, 
    -0.27056375f, -0.28013411f, 0.01654792f, 0.04841631f, 0.30133083f, -0.02169806f, 0.00847002f, -0.11083611f, 
    -0.16695677f, -0.15714258f, 0.08200687f, 0.01944371f, -0.04568556f, 0.07955810f, 0.01509226f, 0.09679504f, 
    0.09985545f, -0.00571361f, -0.12861060f, -0.04077730f, -0.29458877f, 0.17291014f, -0.01742739f, -0.09410725f, 
    -0.31903300f, 0.00462751f, 0.01056502f, 0.12680912f, -0.03126937f, -0.01045536f, -0.01110516f, -0.01367574f, 
    0.02240055f, -0.03144743f, 0.16368560f, -0.06708920f, 0.00388643f, -0.22531131f, -0.03703618f, 0.01111658f, 
    0.72496808f, 0.35130197f, 0.01204423f, -0.42565027f, -0.08458112f, 0.16925018f, 0.05452861f, -0.09487151f, 
    0.05924576f, 0.06328473f, -0.02015842f, 0.07361696f, -0.05261912f, 0.12355009f, 0.05230610f, -0.04860940f, 
    -0.10228936f, 0.15538527f, 0.05021622f, 0.03106379f, 0.13582237f, -0.36408225f, -0.04194077f, -0.22021826f, 
    0.01725058f, -0.05160570f, -0.07792486f, 0.00519133f, -0.06604131f, -0.02166479f, 0.19300292f, -0.03092389f, 
    0.06834657f, 0.15836871f, -0.02515203f, 0.10685900f, -0.06578130f, -0.06241620f, -0.31939611f, 0.07702021f, 
    0.04494018f, 0.05555488f, -0.17470501f, 0.15002120f, -0.39592481f, -0.03546102f, 0.07476640f, -0.10417087f, 
    0.03626491f, 0.10001772f, 0.07901463f, 0.02174293f, 0.13057077f, 0.09570021f, 0.09548870f, -0.08862258f, 
    -0.08480996f, 0.13957924f, 0.01872579f, 0.02884035f, -0.07318363f, -0.02808807f, -0.01798981f, 0.19020000f, 
    0.19865021f, 0.03245752f, -0.02180468f, 0.05165081f, 0.03900957f, 0.04842849f, 0.09398655f, -0.06421714f, 
    -0.01498868f, -0.07911968f, 0.05693438f, 0.15934534f, 0.11487164f, 0.00547572f, -0.02410501f, -0.09573033f, 
    -0.33653253f, 0.17130628f, -0.13704613f, -0.12152023f, 0.06326465f, 0.00390757f, -0.10028061f, 0.00053150f, 
    0.06022081f, 0.10080394f, 0.16171516f, -0.04084708f, 0.05269914f, -0.10774969f, -0.00224676f, -0.00569103f, 
    -0.05142927f, -0.11051248f, -0.07954150f, 0.08658831f, 0.51384115f, 0.14789726f, 0.05027109f, 0.19592899f, 
    -0.07362227f, 0.09488107f, 0.08782475f, 0.08141045f, -0.08658447f, 0.03386252f, 0.02470477f, -0.09725885f, 
    0.01406653f, 0.04792067f, -0.03379700f, 0.02936371f, 0.04803876f, 0.12948368f, 0.09213135f, 0.11428026f, 
    -0.08808406f, -0.19294567f, -0.05304939f, -0.07635108f, 0.00664184f, 0.05727717f, 0.14534086f, 0.06112459f, 
    -0.02679425f, -0.02821088f, 0.06018521f, 0.02942554f, 0.17070769f, 0.00492513f, -0.02247526f, 0.09618048f, 
    0.14537401f, -0.04913228f, -0.02616963f, -0.01786949f, -0.30826154f, 0.01366521f, -0.09220197f, -0.22381958f, 
    -0.12567580f, -0.05973890f, 0.01349673f, 0.04976430f, -0.04542118f, 0.12258536f, -0.03119208f, -0.02813171f, 
    0.02037287f, -0.18017891f, 0.00162096f, 0.00977607f, -0.19346550f, -0.08270689f, -0.06141741f, -0.14211729f, 
    -0.27813062f, -0.17966771f, 0.01155030f, -0.10879674f, 0.04501292f, 0.14812167f, 0.01680567f, 0.01248879f, 
    0.03833068f, -0.00029336f, 0.06020529f, 0.09903711f, 0.11674803f, 0.02412535f, 0.00293590f, 0.10394485f, 
    0.11500101f, 0.06570469f, -0.02959351f, 0.14031197f, 0.19079877f, 0.22478314f, 0.03795331f, -0.03608013f, 
    0.28808016f, -0.01653302f, 0.00969984f, -0.05911762f, 0.19695708f, 0.07058112f, 0.04186593f, -0.08892798f, 
    0.14548287f, 0.22881764f, 0.23693697f, 0.04292120f, 0.11080889f, -0.07697269f, -0.20464997f, -0.01140125f, 
    -0.60163331f, 0.02271833f, 0.08580771f, -0.04071091f, -0.03689418f, -0.01250182f, 0.07552975f, 0.03186597f, 
    0.00656376f, -0.06959883f, 0.07553109f, -0.05691711f, 0.00004591f, -0.11418224f, -0.17553692f, 0.00503237f, 
    -0.08170329f, 0.15885548f, -0.05751027f, 0.13778825f, -0.04823460f, -0.17892113f, 0.06995036f, 0.14323097f, 
    -0.10926067f, 0.00773873f, 0.08548015f, -0.07095949f, -0.12723400f, 0.02149855f, -0.04552478f, -0.00938228f, 
    0.00239849f, 0.10568416f, 0.06660631f, -0.06340345f, 0.06711601f, 0.13095273f, 0.10750628f, 0.07403658f, 
    0.19830595f, -0.24712403f, -0.01507192f, 0.03958277f, 0.02201905f, 0.01691648f, 0.06211668f, -0.02514048f, 
    -0.09676732f, -0.02750472f, 0.07771465f, -0.04805905f, -0.05575483f, 0.03898508f, -0.00037147f, -0.07715910f, 
    -0.02986907f, -0.11332298f, -0.06605309f, 0.06749703f, 0.28718668f, -0.09853866f, -0.19164489f, -0.10428806f, 
    -0.06567283f, 0.21623155f, 0.04428374f, 0.09919074f, -0.03154777f, -0.02554794f, 0.06413617f, -0.01118045f, 
    -0.16334781f, -0.11594845f, -0.04627618f, 0.12753022f, -0.06935403f, -0.15912233f, -0.05140050f, 0.02406108f, 
    0.51272106f, 0.20498101f, -0.15824293f, 0.15047355f, 0.12200374f, 0.16610026f, 0.05325568f, 0.10125141f, 
    -0.07236692f, -0.08648103f, 0.06371903f, -0.11132193f, 0.08742910f, 0.20098069f, 0.15328293f, -0.01598192f, 
    0.06906839f, 0.07370612f, -0.04291767f, -0.05464672f, -0.17585316f, 0.05873667f, 0.07409906f, -0.00139527f, 
    0.02228988f, -0.12056597f, 0.00178918f, -0.00824918f, 0.01219137f, 0.01985425f, 0.09191414f, -0.02918078f, 
    -0.10280395f, -0.04970905f, 0.06945392f, -0.07835611f, -0.02710780f, 0.03310143f, 0.17613885f, 0.05592897f, 
    -0.34996104f, -0.24048030f, 0.01525096f, 0.10121369f, -0.17526925f, 0.02640256f, 0.10328823f, 0.09863454f, 
    -0.11644416f, -0.02084974f, -0.03001325f, 0.02369111f, 0.12247142f, -0.06590889f, 0.05944900f, -0.03663091f, 
    -0.02569363f, -0.03035244f, 0.06969420f, 0.01126901f, 0.16957019f, -0.31896654f, 0.00655016f, -0.03754978f, 
    -0.17470992f, 0.23105034f, 0.05869716f, 0.06658769f, -0.14731568f, -0.09946681f, 0.17710254f, -0.06362327f, 
    0.05579840f, 0.01959671f, 0.03280375f, 0.02147818f, 0.09079982f, -0.10478845f, 0.13915448f, -0.08001394f, 
    0.20439029f, -0.35916838f, 0.21003446f, 0.11909322f, -0.05136335f, -0.04293085f, -0.06839693f, -0.10361145f, 
    0.08775396f, 0.10269996f, 0.09420759f, 0.04772278f, 0.12536426f, 0.02102563f, 0.08902103f, -0.02328344f, 
    -0.03367346f, 0.04431878f, 0.02640479f, 0.01640601f, -0.36147165f, 0.02234588f, -0.02515249f, 0.04941241f, 
    -0.01572913f, 0.10445791f, -0.05173098f, 0.07974867f, -0.03744212f, 0.03041722f, -0.02106019f, 0.12782651f, 
    -0.07027332f, -0.00789984f, -0.03836408f, 0.04440756f, 0.01883677f, 0.01210307f, -0.11875243f, -0.06008111f, 
    0.06569162f, -0.14434251f, 0.12406492f, 0.14199144f, 0.30629557f, -0.00638027f, 0.00194209f, -0.06011249f, 
    -0.02888167f, 0.05816026f, -0.06958295f, -0.15746874f, 0.11645614f, 0.01589814f, 0.11459173f, 0.02538359f, 
    -0.08603669f, -0.04599039f, -0.20457354f, -0.01198908f, -0.01223033f, -0.10720787f, 0.19374368f, -0.14631246f, 
    -0.21560882f, -0.09046552f, -0.10037681f, 0.03647695f, 0.01411107f, 0.11754078f, 0.00228492f, -0.07742131f, 
    0.04272483f, 0.00693972f, 0.07235548f, 0.05054411f, -0.06194643f, 0.07044642f, -0.03413307f, 0.18735668f, 
    -0.22584572f, 0.06035510f, -0.18170166f, 0.02323562f, -0.11192641f, 0.08274960f, 0.16073446f, 0.01441499f, 
    -0.01677513f, -0.03065483f, -0.00687349f, 0.09228837f, 0.07913359f, 0.00106626f, 0.06308664f, -0.02564563f, 
    -0.03094079f, 0.06794231f, 0.02669319f, -0.02746241f, 0.20269375f, 0.20556961f, 0.20886816f, -0.07257807f, 
    0.02183362f, -0.10445657f, 0.18227103f, 0.14667043f, 0.00981369f, -0.11775126f, 0.01042811f, 0.02529361f, 
    -0.00875995f, 0.02927358f, -0.05842286f, 0.03958213f, -0.06320896f, 0.01684217f, -0.10965140f, -0.01291525f, 
    -0.31819826f, -0.13215873f, -0.10919631f, 0.31613412f, 0.07431024f, 0.10494096f, 0.06623539f, 0.01394322f, 
    -0.00226425f, 0.01095564f, 0.06957420f, -0.09443131f, -0.06973071f, 0.09018276f, -0.04763975f, -0.04619903f, 
    0.01261902f, 0.03931988f, -0.07555190f, 0.06027315f, 0.24028277f, -0.07923435f, 0.05421503f, -0.00850464f, 
    -0.12000879f, -0.18309516f, -0.12102193f, 0.05344657f, 0.11258406f, 0.15798545f, -0.07310104f, -0.09558538f, 
    0.07217624f, -0.02484298f, 0.16090201f, -0.03763223f, -0.02946836f, 0.00750415f, -0.00295113f, 0.13113855f, 
    -0.09687122f, 0.09166733f, -0.01969023f, 0.07235791f, -0.25945312f, 0.09117892f, 0.17879868f, 0.11956491f, 
    0.03078120f, -0.02767326f, 0.07099387f, 0.01167707f, 0.06721158f, -0.07232928f, 0.06835748f, -0.00047232f, 
    -0.04779673f, 0.11752947f, 0.03516851f, 0.04896875f, -0.34846982f, 0.03641569f, 0.26309484f, -0.02323983f, 
    -0.08144634f, 0.09743153f, 0.05786797f, -0.04436871f, -0.12039447f, 0.02938453f, -0.09243990f, -0.03365800f, 
    0.16025646f, 0.06506786f, -0.08424897f, -0.02872064f, 0.02952906f, 0.02178854f, -0.03214211f, -0.08231809f, 
    -0.24146459f, -0.28281492f, 0.37429267f, 0.28489822f, 0.19405384f, 0.13469426f, 0.01928068f, 0.03844472f, 
    0.07772991f, -0.04055983f, 0.01710407f, -0.00182267f, 0.01136978f, 0.00449766f, 0.00744380f, 0.00299801f, 
    0.10265074f, 0.02172369f, -0.06756353f, -0.07941598f, -0.18003857f, 0.34874448f, -0.16646601f, -0.04487187f, 
    -0.13114986f, 0.20762262f, 0.19513535f, -0.03905725f, -0.00737248f, -0.05264989f, -0.00216716f, 0.14471303f, 
    -0.00157374f, -0.02223224f, -0.07645787f, 0.12567113f, -0.00955790f, -0.08722026f, 0.05223910f, -0.06328390f, 
    0.05112196f, 0.14853078f, 0.31897354f, -0.12175062f, -0.24559970f, -0.21162644f, -0.18862882f, 0.06264151f, 
    -0.02795469f, 0.15484484f, -0.09129730f, -0.10108718f, 0.02596842f, 0.04150366f, -0.01065213f, 0.03027627f, 
    -0.07846288f, -0.05303140f, 0.07154172f, -0.07119878f, 0.17058423f, 0.09094334f, -0.17336537f, 0.11910058f, 
    0.01376920f, -0.02956215f, 0.07869121f, -0.03698212f, -0.00235833f, -0.07037682f, -0.01615900f, -0.02883815f, 
    -0.11655997f, 0.00266333f, 0.05318933f, -0.00541555f, 0.06768605f, 0.01865045f, 0.05655254f, 0.09108978f, 
    -0.27375212f, -0.05447230f, 0.26353160f, 0.09498643f, 0.03282982f, -0.07090060f, -0.07139908f, 0.17386334f, 
    -0.08664688f, 0.04015508f, -0.09323892f, 0.05291122f, 0.10509326f, -0.05588334f, -0.02421684f, 0.00694751f, 
    -0.02828422f, 0.01269111f, -0.01400802f, -0.02802206f, -0.07421271f, 0.20262416f, 0.14902699f, -0.15414208f, 
    0.19718039f, 0.05032896f, -0.04178829f, -0.01321913f, 0.06834842f, -0.02167293f, 0.02323148f, 0.12314153f, 
    -0.01999545f, 0.04234222f, -0.03520425f, 0.16502436f, 0.06757762f, 0.07826229f, -0.00619025f, 0.10373181f, 
    0.15754567f, -0.15343057f, -0.14850643f, 0.00490773f, 0.26477113f, 0.00692329f, 0.00904561f, -0.19270134f, 
    -0.00846794f, -0.04869982f, -0.02651722f, -0.01951926f, 0.19373307f, 0.16072251f, -0.04637343f, -0.02534978f, 
    0.01901205f, 0.03726515f, -0.02883686f, -0.00450022f, -0.10391131f, 0.05925194f, 0.02098123f, -0.00776325f, 
    -0.14306174f, 0.12286749f, 0.01983674f, -0.04297639f, 0.04684381f, -0.02241524f, 0.08791862f, 0.05312193f, 
    0.01971161f, -0.01244802f, 0.03112895f, -0.00248409f, 0.05965167f, -0.02840908f, 0.02270058f, 0.06139309f, 
    0.19301650f, -0.15307133f, 0.35771063f, 0.27646640f, 0.08242786f, 0.05651185f, 0.10813451f, 0.04666007f, 
    -0.07044549f, 0.10722724f, 0.02669009f, -0.05563453f, 0.03466859f, 0.03472961f, 0.11004537f, 0.15034775f, 
    -0.10528731f, 0.07195101f, -0.04798834f, -0.01947990f, -0.06676258f, -0.26022851f, -0.03588874f, -0.32293788f, 
    -0.07320312f, -0.07841142f, -0.10003501f, 0.05928134f, -0.18317103f, -0.07020590f, -0.13917099f, -0.12312581f, 
    -0.04768321f, -0.00356117f, 0.05271191f, -0.04452923f, -0.07907411f, -0.01926004f, -0.12042356f, -0.00208075f, 
    0.10009971f, -0.03265829f, -0.10104308f, 0.02942698f, -0.05654016f, -0.12670335f, -0.06636459f, -0.04155459f, 
    0.06088013f, 0.15460505f, -0.00722506f, 0.13032761f, 0.07027490f, 0.01449229f, 0.17563650f, 0.01489349f, 
    -0.03160300f, 0.17487167f, 0.06063768f, 0.09377108f, 0.38758886f, 0.36838397f, 0.21525632f, 0.01687198f, 
    0.12762025f, -0.00817701f, -0.05965721f, -0.03355277f, 0.24809562f, 0.05497696f, 0.00892397f, 0.02424155f, 
    0.05984015f, 0.10413536f, -0.07915021f, -0.06572068f, -0.08155908f, -0.08191103f, -0.04320437f, 0.03898383f, 
    0.28131789f, -0.21023118f, 0.02175782f, 0.18899603f, -0.25099999f, -0.13336800f, 0.13830762f, -0.07793884f, 
    -0.11718167f, -0.05476011f, -0.00921409f, 0.00513732f, -0.02773231f, -0.09187618f, 0.00970906f, -0.02596588f, 
    0.00004351f, 0.06550301f, 0.15548368f, 0.04966402f, 0.09114137f, 0.27004907f, 0.05633300f, 0.19192679f, 
    -0.12635571f, -0.09722251f, 0.17357133f, 0.03568092f, -0.02681231f, -0.01474094f, -0.03487457f, 0.08515640f, 
    0.03870422f, 0.01838555f, -0.08070756f, 0.01643030f, 0.13520764f, 0.01396785f, 0.07835274f, -0.02607716f, 
    0.17745130f, 0.26358953f, 0.05953311f, -0.10400450f, -0.27872774f, -0.00845780f, -0.01315696f, -0.03477607f, 
    0.12662770f, 0.13778472f, -0.03733780f, -0.04129983f, 0.03366101f, -0.01797693f, 0.04505425f, 0.05817308f, 
    -0.12801053f, -0.12149110f, 0.06073478f, -0.01691274f, -0.17803173f, -0.02719794f, 0.22371362f, -0.07240090f, 
    -0.09955373f, 0.06101353f, -0.07648025f, -0.13012961f, 0.07105605f, -0.02861457f, -0.15449296f, -0.04677928f, 
    0.06859154f, -0.08177226f, -0.05573814f, -0.10113246f, 0.00987226f, -0.18741871f, 0.13751602f, -0.02702453f, 
    -0.05839275f, -0.12833779f, 0.42339298f, -0.02634287f, 0.21166316f, 0.07597148f, 0.06078685f, 0.10788348f, 
    0.05664704f, 0.12646396f, 0.02588151f, 0.03631544f, 0.03742485f, -0.08093466f, 0.18923010f, 0.06885333f, 
    0.10792272f, 0.05768515f, -0.01536347f, 0.03127364f, 0.06586512f, 0.26117215f, -0.10857129f, -0.14349981f, 
    -0.02170315f, -0.02003673f, 0.00112248f, 0.04601445f, -0.00100619f, 0.16412318f, -0.02796794f, 0.11026512f, 
    0.08553351f, -0.06490194f, -0.04095684f, 0.04650993f, -0.07670613f, -0.06888480f, 0.01206141f, -0.05651641f, 
    -0.14685538f, -0.15760086f, -0.01140921f, -0.07524206f, 0.09116021f, -0.03787716f, -0.02141677f, -0.07444904f, 
    -0.16295049f, 0.08163423f, -0.06726751f, -0.11055178f, -0.10863383f, -0.07720858f, 0.00605877f, 0.00584796f, 
    -0.03431047f, -0.09029275f, -0.13769403f, -0.03158294f, 0.18158357f, 0.21085022f, -0.27645311f, -0.01530592f, 
    -0.24344791f, 0.00111113f, 0.07075727f, 0.05766229f, 0.04177406f, -0.07921670f, -0.09117705f, 0.04065527f, 
    0.12854810f, -0.07283051f, -0.00482706f, -0.01894719f, 0.03034027f, 0.02452140f, -0.02601136f, 0.09037434f, 
    0.32617781f, 0.25256586f, 0.11675704f, 0.11068767f, 0.27477258f, 0.00874533f, -0.04900895f, -0.08620323f, 
    0.05345481f, 0.08939609f, -0.11839032f, 0.08964065f, 0.02170063f, 0.00795580f, 0.05657944f, 0.07178777f, 
    -0.07029485f, 0.03239466f, 0.13188207f, 0.06061141f, -0.31567416f, 0.14125310f, 0.07107094f, -0.17610464f, 
    0.31770617f, 0.07638408f, 0.06501821f, 0.02496184f, -0.00509346f, 0.05833222f, -0.05236327f, 0.10693784f, 
    -0.04328170f, 0.09053532f, -0.05630659f, 0.17408612f, -0.05149571f, 0.03254975f, -0.20574845f, 0.08599491f, 
    0.02546907f, -0.04571887f, -0.03592842f, -0.01424877f, 0.00607940f, -0.01366941f, 0.03526358f, 0.03427364f, 
    -0.05644112f, -0.03290726f, -0.05959741f, 0.03296394f, 0.04472198f, -0.04772846f, -0.01158650f, 0.00071559f, 
    -0.02045023f, -0.02467528f, -0.03197068f, -0.03766934f, 0.01845663f, -0.01067129f, -0.03854326f, 0.04352313f, 
    0.02824897f, -0.03695353f, -0.03485289f, -0.00643024f, -0.03036987f, 0.04075221f, 0.02863287f, 0.04403401f, 
    -0.03425942f, -0.02909436f, 0.01292837f, 0.00250464f, 0.01767663f, 0.03259785f, 0.04811785f, 0.00359650f, 
    -0.02594944f, -0.03775373f, 0.03200294f, -0.02617594f, 0.00650002f, -0.00877132f, 0.02097496f, -0.02152716f, 
    -0.00610234f, -0.01335718f, -0.02415858f, 0.04722314f, 0.01517897f, 0.01186340f, 0.01575415f, 0.04567843f, 
    0.01374945f, -0.00758107f, -0.01447564f, 0.03411557f, 0.03812264f, 0.02963091f, -0.04727069f, 0.02543088f, 
    -0.03911394f, -0.01798838f, 0.01525254f, -0.04033069f, -0.00772044f, 0.03079245f, 0.03189645f, -0.02689476f, 
    0.00311417f, -0.01471657f, 0.04286449f, -0.03776987f, 0.01830508f, -0.04386217f, -0.05995815f, -0.02728662f, 
    0.00835538f, -0.00800326f, -0.03907440f, 0.02690361f, -0.00035980f, -0.03531178f, 0.01536124f, -0.00124126f, 
    -0.03720237f, -0.02102384f, -0.00073829f, 0.01118261f, 0.03158031f, 0.01655590f, -0.01692718f, -0.04062459f, 
    0.04039697f, -0.00691899f, 0.01970275f, -0.05475331f, -0.00849140f, -0.05101166f, -0.01376401f, -0.02769595f, 
    0.02222085f, -0.01400130f, -0.06100038f, 0.01941285f, 0.01492490f, 0.03401498f, -0.05544961f, 0.03791356f, 
    0.02586759f, -0.02053477f, -0.05652842f, -0.02527172f, -0.03095741f, 0.03317352f, 0.00073775f, -0.01688166f, 
    -0.01933490f, 0.03557844f, -0.00881741f, 0.02086455f, -0.01936960f, -0.02603317f, -0.04192842f, 0.01956310f, 
    -0.03860741f, -0.02026110f, -0.04676879f, -0.03862100f, 0.02325870f, 0.01671167f, 0.00835146f, -0.03477415f, 
    0.02187157f, -0.00355871f, -0.06023420f, -0.03041414f, 0.00026804f, -0.02302474f, 0.03552205f, -0.04932246f, 
    0.03959584f, 0.02578586f, 0.03643941f, -0.04067251f, 0.01241694f, -0.04037274f, 0.01059035f, 0.01100207f, 
    0.03188990f, 0.00729810f, -0.02368700f, -0.02578844f, 0.03670348f, 0.01632368f, 0.01090854f, -0.00635290f, 
    -0.01764362f, 0.04183052f, -0.02896686f, -0.04455009f, 0.01060169f, -0.01586234f, 0.00363412f, -0.01407635f, 
    0.01054890f, 0.04346900f, -0.05144347f, -0.03574521f, 0.04272799f, 0.04729163f, 0.03220074f, -0.02625321f, 
    -0.05715734f, 0.04180742f, -0.04707554f, -0.01741111f, -0.04548914f, -0.02711511f, -0.05649109f, 0.04207922f, 
    0.04599726f, -0.01077061f, -0.02358926f, -0.04715957f, -0.00334576f, -0.00345327f, -0.01206968f, 0.03450935f, 
    -0.05100853f, -0.03867942f, -0.04470308f, 0.00181741f, -0.02090320f, 0.02217985f, -0.03613402f, 0.04367439f, 
    0.01288322f, 0.04140528f, -0.00341065f, 0.02592559f, 0.02175944f, 0.04558848f, -0.06025001f, -0.01501162f, 
    0.03324631f, -0.03330628f, -0.02234512f, 0.04733715f, 0.00896046f, -0.05650755f, -0.04035516f, 0.04755503f, 
    -0.03177470f, 0.02173481f, -0.01074814f, -0.02499786f, 0.02297568f, 0.04322331f, -0.00807221f, 0.02843518f, 
    0.04521564f, 0.01463954f, 0.01380847f, -0.05710019f, -0.03654370f, 0.02085563f, 0.02018798f, 0.00701669f, 
    -0.03563830f, 0.03830311f, -0.00988004f, -0.02669586f, -0.02022623f, 0.03011363f, -0.02362090f, -0.00983342f, 
    -0.02304946f, 0.03283131f, -0.01900500f, -0.04086983f, -0.02476736f, -0.03070205f, -0.02072912f, 0.01439735f, 
    -0.05460108f, 0.00699266f, -0.01464429f, 0.03430162f, -0.05257999f, -0.02937018f, -0.03803278f, 0.02272544f, 
    -0.02955334f, 0.02587738f, -0.04549757f, 0.03076979f, 0.03787491f, 0.01299497f, 0.00502552f, 0.00356855f, 
    0.01366179f, -0.02676977f, 0.02219436f, 0.00312284f, 0.02042186f, -0.00204349f, -0.01939881f, -0.02451329f, 
    -0.01200383f, -0.03612772f, -0.00504566f, -0.02679729f, 0.00644641f, 0.04160718f, -0.01087525f, -0.05316043f, 
    -0.04517777f, -0.00673953f, -0.02233255f, -0.04015556f, 0.04324734f, -0.00097513f, -0.03500636f, -0.02037514f, 
    -0.04897324f, -0.01688032f, -0.00328518f, -0.00082002f, -0.05133559f, 0.01625140f, 0.01279436f, -0.05082479f, 
    -0.05719671f, -0.05229891f, -0.06019753f, -0.01895972f, 0.02238403f, -0.02331930f, 0.01110620f, -0.04986342f, 
    -0.05332902f, -0.01977095f, 0.02005356f, 0.03305073f, 0.03310965f, -0.01213829f, -0.03326609f, 0.01994975f, 
    0.03976634f, 0.00755772f, -0.04470126f, -0.04905673f, 0.03810507f, -0.05915981f, -0.06065982f, 0.00940012f, 
    -0.35466382f, 0.13490185f, -0.18809913f, -0.09533165f, -0.13067789f, 0.09009308f, 0.07195894f, 0.05334948f, 
    0.13135569f, -0.01207147f, 0.01454619f, -0.03455608f, -0.06385723f, 0.05924398f, -0.01758900f, 0.08671625f, 
    0.09779351f, 0.02625914f, -0.15344542f, 0.03669301f, 0.04640476f, 0.22313009f, 0.02284336f, 0.05937943f, 
    0.17371526f, 0.03245313f, 0.15759440f, -0.00830195f, 0.19602861f, -0.03323251f, 0.10891142f, 0.00259681f, 
    0.02597355f, -0.06208082f, 0.12438746f, 0.08775363f, -0.06041168f, 0.01288676f, 0.12083855f, 0.05920957f, 
    0.13106732f, 0.36247331f, 0.05598603f, 0.11760918f, 0.33424547f, 0.03519515f, -0.07191265f, 0.12257693f, 
    -0.10255325f, 0.00794764f, -0.08501163f, 0.01774105f, -0.01477598f, -0.09751783f, -0.12504911f, 0.03605846f, 
    0.09068284f, 0.19903594f, -0.14204849f, -0.01087464f, -0.32083592f, -0.36872712f, -0.04209056f, -0.07745740f, 
    -0.14792283f, 0.09996846f, 0.05338273f, 0.00623288f, 0.08534499f, 0.02217305f, 0.08029715f, 0.10175636f, 
    -0.02697687f, 0.06252480f, 0.08258122f, -0.02628468f, 0.07585660f, -0.01890665f, 0.02152695f, 0.03880711f, 
    0.40294635f, 0.27103823f, 0.09367064f, 0.11623101f, 0.09016382f, -0.06043072f, -0.19563963f, 0.09042684f, 
    0.07766996f, -0.18608540f, -0.09987123f, -0.13433608f, -0.05925262f, -0.01625072f, -0.06545342f, -0.01278320f, 
    0.10618830f, 0.16400303f, -0.02190987f, -0.19763546f, -0.40547350f, 0.11036302f, -0.17496948f, 0.10361010f, 
    0.00744341f, 0.01139005f, -0.22573398f, -0.04836366f, 0.02721478f, -0.06350446f, -0.14245650f, 0.06460924f, 
    0.06257851f, -0.03012623f, -0.06549642f, -0.08106618f, -0.01473457f, 0.04032276f, 0.05152635f, -0.11914317f, 
    0.24586836f, 0.32768625f, 0.08925319f, 0.01587286f, 0.09850415f, 0.04309851f, -0.03663702f, 0.11995314f, 
    -0.11128720f, -0.04892835f, -0.02912827f, 0.00972046f, 0.07583049f, -0.04108772f, -0.00535389f, 0.09452263f, 
    0.06597190f, 0.14041971f, -0.05436029f, -0.09706195f, -0.04084781f, 0.31344065f, -0.02638667f, 0.31026766f, 
    0.50483209f, 0.05919436f, 0.02986854f, 0.04120659f, 0.11181894f, 0.03391255f, 0.00835564f, 0.03150665f, 
    0.09434368f, 0.00867405f, 0.01889415f, 0.07503196f, 0.08336893f, -0.01742648f, -0.00090307f, -0.07628138f, 
    -0.12996729f, 0.00595801f, -0.03755283f, -0.03588068f, 0.18020473f, -0.16455497f, -0.03471611f, 0.01162885f, 
    0.05770158f, -0.13864607f, -0.05771202f, 0.06758416f, -0.02930216f, 0.00733972f, -0.01132605f, -0.02750326f, 
    -0.01192070f, 0.03115338f, 0.02241546f, -0.09480985f, 0.07068232f, 0.09982104f, -0.24643134f, -0.16061388f, 
    0.03529048f, -0.09125211f, 0.19782181f, 0.06279371f, 0.21603505f, 0.10652693f, 0.00971044f, 0.03902569f, 
    -0.03972461f, -0.10381114f, 0.04409377f, 0.03669598f, 0.01404508f, 0.06075957f, 0.17713538f, 0.01311809f, 
    0.25786260f, 0.01998151f, 0.08586787f, -0.10303576f, 0.09565973f, -0.02383620f, 0.02189119f, 0.09260520f, 
    -0.00312821f, 0.12176057f, 0.04217962f, 0.01459828f, -0.09290446f, -0.03776350f, -0.12797734f, 0.01548480f, 
    -0.02515016f, 0.07362645f, -0.00949610f, -0.02777249f, 0.37964374f, -0.09810259f, -0.00643314f, 0.10598108f, 
    0.05058681f, -0.11933485f, -0.21436150f, 0.23127629f, -0.00070820f, -0.07608722f, -0.10834140f, -0.12898394f, 
    0.02057862f, -0.07782263f, -0.06112411f, -0.13910016f, 0.00140811f, 0.09614629f, 0.04640474f, -0.10623333f, 
    -0.10351133f, -0.21864498f, -0.37052193f, -0.03059236f, 0.06307731f, 0.15569781f, 0.07990207f, 0.00936765f, 
    0.02757252f, -0.00065629f, 0.00991904f, 0.12820770f, -0.01644600f, 0.17768133f, -0.05677962f, 0.22067414f, 
    0.04549218f, -0.03244815f, -0.06769223f, 0.05327837f, -0.30003798f, -0.17029610f, 0.01022833f, -0.02109795f, 
    -0.17369984f, 0.01892801f, 0.02150002f, 0.02324562f, 0.07987415f, 0.13600801f, -0.00829187f, 0.16611800f, 
    0.06251760f, -0.02714542f, -0.05419533f, -0.01246582f, -0.05983244f, 0.02503153f, -0.07298195f, 0.00404461f, 
    0.27799934f, 0.28469297f, -0.14767510f, 0.06705490f, 0.14406548f, 0.02003144f, 0.09736577f, 0.00701025f, 
    0.14886361f, -0.11131498f, -0.02450908f, -0.10289574f, 0.07396892f, -0.02384565f, 0.04233294f, 0.11373882f, 
    0.02948895f, -0.05076732f, 0.17018814f, -0.05075960f, -0.20680907f, -0.29314467f, -0.32417515f, -0.04837249f, 
    -0.40668750f, 0.03698775f, -0.05123992f, 0.07955239f, -0.01063002f, 0.04220537f, -0.09166131f, -0.04598774f, 
    0.02349721f, 0.04583070f, -0.18227680f, -0.01936065f, 0.00399938f, -0.03942701f, -0.05954573f, -0.04790874f, 
    -0.20844160f, 0.22589450f, 0.01979467f, -0.21705343f, 0.41111985f, -0.07253073f, -0.05237353f, 0.13764063f, 
    0.08632287f, -0.04894317f, 0.05603177f, -0.09342057f, -0.08496369f, -0.02431748f, 0.01963245f, 0.10007437f, 
    0.06007037f, 0.05818043f, -0.01937672f, 0.10660558f, 0.09183361f, -0.05083252f, 0.07721399f, -0.02056039f, 
    -0.18932258f, 0.05631831f, -0.00589599f, -0.00620651f, 0.08235941f, 0.10411582f, -0.07634833f, 0.09276450f, 
    0.02187906f, 0.02085749f, -0.00989557f, -0.01499197f, -0.03140162f, 0.09736468f, -0.02166301f, 0.17795838f, 
    -0.04628574f, -0.20340852f, 0.02214972f, 0.05420419f, 0.22972658f, 0.07436950f, -0.02527501f, 0.10009676f, 
    -0.02571475f, -0.16298382f, -0.08384290f, 0.04775287f, -0.01861907f, 0.07693885f, 0.09952431f, 0.00037214f, 
    0.11692369f, 0.00980262f, 0.09527562f, -0.06569912f, -0.12808688f, -0.18905051f, -0.12504721f, -0.03400576f, 
    0.14341933f, -0.11241312f, -0.05874101f, 0.01701491f, 0.11967000f, 0.00305991f, 0.11473722f, 0.12670657f, 
    0.02265615f, 0.04620868f, 0.15585285f, -0.05197154f, -0.04407740f, -0.11594753f, -0.13289565f, -0.12377284f, 
    0.44373551f, 0.15819314f, -0.18671875f, -0.10788437f, -0.27774501f, 0.01620609f, -0.15204923f, 0.11260276f, 
    -0.01958879f, 0.02748496f, -0.06901495f, -0.09039824f, 0.00199510f, 0.09443920f, -0.03450241f, 0.00737356f, 
    -0.01370490f, 0.07401361f, -0.00550509f, 0.08834645f, 0.09509808f, -0.20371555f, -0.05822087f, 0.06785364f, 
    -0.01436625f, -0.11531311f, 0.12765953f, -0.08614371f, 0.02330943f, -0.06882575f, -0.11556657f, 0.05304106f, 
    -0.06888357f, 0.21804272f, 0.04328599f, 0.01151144f, 0.06288859f, 0.09276837f, -0.06995419f, -0.00295409f, 
    -0.13593026f, -0.10007439f, -0.08883242f, 0.12094992f, 0.13128282f, -0.02840922f, 0.04759012f, 0.18943585f, 
    0.04807015f, 0.06163353f, -0.03645699f, -0.03453353f, 0.05627889f, -0.05961207f, 0.09161139f, 0.02446300f, 
    -0.10252431f, -0.07266850f, 0.07716504f, 0.04043883f, -0.15981977f, 0.03148844f, 0.03780124f, 0.08151112f, 
    -0.27952749f, 0.12537716f, 0.10398486f, 0.07565137f, 0.04732918f, 0.10076044f, 0.02300357f, 0.06850976f, 
    0.01694999f, -0.12954731f, -0.03955058f, 0.09803022f, -0.01070829f, 0.01320408f, 0.23147105f, 0.08923092f, 
    0.05640718f, 0.02141342f, -0.16230033f, -0.02991756f, -0.16173498f, -0.02162670f, 0.04188656f, -0.03294189f, 
    -0.02899639f, -0.02564930f, -0.05282009f, 0.16449293f, -0.00259898f, 0.17024791f, 0.12796970f, 0.00212791f, 
    -0.06138692f, 0.00328919f, -0.05627764f, -0.09617863f, -0.29224828f, 0.17530064f, 0.06298069f, -0.05016754f, 
    0.09459869f, -0.06098913f, -0.00124757f, -0.01522067f, 0.02252169f, 0.12639344f, 0.03904085f, 0.08876667f, 
    0.06679043f, 0.00995512f, -0.07064098f, -0.12337454f, -0.04411857f, 0.00807504f, -0.07958995f, -0.06245397f, 
    0.07733115f, -0.07964283f, -0.02539093f, 0.15197659f, -0.09977415f, -0.05109492f, 0.11172799f, 0.17245790f, 
    0.08937728f, 0.03151551f, 0.05776588f, 0.08999529f, -0.01948955f, 0.01156863f, 0.04036279f, 0.07209559f, 
    0.16785577f, 0.09150486f, 0.08430201f, -0.02059654f, 0.26267427f, -0.14687915f, -0.16494307f, -0.05936675f, 
    -0.30196220f, -0.02721988f, -0.15372154f, 0.03660093f, 0.03593931f, -0.03550774f, -0.03870702f, 0.04221014f, 
    0.10720629f, 0.01300782f, -0.06137981f, -0.01415831f, -0.05620840f, 0.02483734f, -0.05082505f, 0.07088449f, 
    0.14730138f, 0.08832202f, 0.17024045f, -0.18299147f, -0.13121124f, -0.07171670f, -0.09838069f, -0.02589894f, 
    0.07985177f, 0.23417859f, 0.13579564f, -0.03735270f, -0.02231578f, -0.01230015f, -0.02460125f, 0.05556491f, 
    0.00772288f, -0.06825143f, 0.03373099f, 0.02937344f, 0.12371225f, -0.32489362f, -0.11927765f, 0.10865225f, 
    -0.00583940f, 0.21118206f, 0.06993298f, -0.06185228f, 0.02348684f, 0.14676555f, -0.04827528f, 0.01289645f, 
    0.09807482f, 0.05572373f, -0.08204813f, 0.07641633f, 0.03762870f, -0.02214698f, -0.05005209f, 0.05349902f, 
    0.06563295f, 0.01265252f, -0.03028029f, 0.04136140f, 0.30689821f, -0.00388992f, -0.04432198f, -0.00474274f, 
    -0.02490125f, -0.02426251f, 0.07827237f, -0.05052589f, -0.06777757f, 0.02517228f, -0.02410949f, 0.07137769f, 
    -0.06408161f, 0.10860621f, -0.05872168f, 0.02552151f, -0.21393046f, -0.03508431f, -0.06729467f, 0.11613514f, 
    0.13182057f, -0.03943221f, 0.02597358f, -0.02545561f, 0.09309231f, -0.03646674f, -0.09723202f, 0.07511206f, 
    -0.04397270f, 0.12259113f, 0.04046451f, -0.00457362f, -0.01467891f, 0.08509842f, -0.02473306f, 0.01614570f, 
    0.03875212f, 0.03535549f, -0.00003965f, 0.00531960f, -0.01495545f, -0.02311531f, -0.04180351f, -0.04837894f, 
    -0.02671344f, -0.05688199f, -0.02675048f, -0.01728578f, -0.05737826f, 0.00411379f, -0.02388045f, 0.03431360f, 
    0.01232582f, -0.02331444f, 0.00356762f, 0.00689238f, 0.04603595f, -0.00456125f, -0.00988783f, -0.01754175f, 
    -0.04689412f, 0.04471961f, 0.03040708f, -0.03098626f, 0.00952373f, -0.02615391f, 0.04563263f, -0.03101144f, 
    0.04902730f, -0.05355914f, 0.01605914f, 0.03533384f, -0.02427254f, -0.04259870f, -0.04747558f, 0.01170316f, 
    -0.05224422f, 0.02361010f, -0.05541850f, 0.03952602f, 0.01054460f, -0.03631306f, -0.01087920f, -0.04788877f, 
    -0.01376135f, -0.05304701f, -0.02409715f, 0.02750788f, 0.00509366f, -0.03886113f, -0.05801357f, -0.01650137f, 
    -0.03331382f, 0.01580171f, 0.01828320f, 0.00200142f, 0.04276857f, -0.03135586f, 0.00542537f, -0.05342455f, 
    -0.03927672f, -0.00871130f, -0.02351148f, 0.00570161f, 0.00015910f, -0.03431392f, 0.02537872f, 0.05415319f, 
    -0.03153759f, 0.00470165f, -0.02813138f, 0.02516363f, -0.03246498f, 0.02008476f, -0.00536791f, -0.05993607f, 
    -0.05393098f, -0.00606178f, -0.00862465f, -0.04558175f, -0.05709749f, 0.01357190f, -0.00198002f, -0.03891534f, 
    0.03510496f, -0.02345386f, 0.02230316f, -0.05936883f, -0.03026192f, -0.04903034f, 0.02016426f, 0.02722037f, 
    -0.05736919f, -0.02167397f, -0.05375423f, 0.05181852f, -0.01904743f, -0.00945705f, -0.00989505f, 0.02676056f, 
    -0.00146750f, -0.00508629f, -0.00996921f, -0.05033359f, -0.00098991f, -0.02447003f, 0.03244440f, -0.05176795f, 
    0.04310580f, -0.04208465f, -0.01195378f, 0.01625756f, -0.00385280f, -0.06009198f, -0.02212076f, -0.00851891f, 
    0.00397823f, 0.01334135f, 0.03495096f, -0.00943501f, 0.00832694f, -0.04653976f, -0.05240411f, -0.06142104f, 
    -0.04849191f, -0.02037196f, -0.00469643f, 0.04335113f, -0.05026887f, 0.03695943f, -0.04531045f, 0.04615425f, 
    -0.01971977f, 0.00872376f, -0.02466878f, 0.03271187f, 0.00878056f, 0.03292334f, -0.01778331f, 0.00385623f, 
    -0.05248777f, -0.01547546f, -0.05028340f, -0.01682045f, -0.04873528f, 0.02589610f, 0.04530241f, 0.04925035f, 
    -0.06179571f, -0.03736099f, 0.02118346f, -0.05061327f, 0.03177921f, 0.01696431f, -0.00514886f, -0.02215334f, 
    -0.03271009f, -0.06361951f, 0.00718075f, -0.00709931f, 0.01082660f, 0.02493138f, 0.03183609f, -0.03260859f, 
    -0.00646433f, 0.00287251f, 0.04144285f, 0.03686555f, -0.01952972f, 0.01746872f, 0.02648058f, 0.01004386f, 
    0.02418013f, -0.04574211f, -0.04472256f, 0.04439573f, 0.02539010f, 0.01647048f, -0.00954087f, 0.03111627f, 
    -0.01585411f, 0.02890859f, -0.00162447f, -0.05307831f, -0.02669569f, -0.00305523f, -0.02205790f, 0.00003785f, 
    0.04652311f, -0.01392092f, -0.02674740f, -0.05054623f, 0.00116351f, -0.05378454f, 0.01006775f, -0.00996332f, 
    -0.00686500f, -0.05857770f, 0.01169765f, -0.03731813f, 0.02489925f, -0.00064713f, 0.04109139f, -0.04996167f, 
    0.02146311f, 0.01160789f, 0.00574939f, 0.03705562f, 0.03953868f, -0.04087854f, -0.01948566f, 0.04331488f, 
    0.02128864f, -0.04089498f, -0.00734842f, 0.04108785f, -0.05408791f, -0.03808051f, -0.03913867f, -0.00217909f, 
    0.04789279f, 0.03163021f, -0.00494499f, 0.03356653f, 0.01152128f, -0.05507932f, -0.04153452f, 0.01527835f, 
    0.01125311f, 0.02661860f, 0.03726112f, 0.03656475f, -0.00510314f, -0.00053466f, 0.04589207f, -0.02682612f, 
    0.02164535f, -0.04205238f, -0.02114490f, 0.01987243f, 0.02306770f, -0.00049287f, -0.00698190f, -0.03125257f, 
    0.00624500f, -0.04595255f, 0.02979388f, 0.03537295f, -0.03051560f, -0.02314238f, -0.04860757f, -0.00404021f, 
    0.00503090f, 0.02914731f, -0.01644027f, 0.02062022f, 0.04590090f, -0.01774446f, 0.00980654f, -0.01630756f, 
    0.00086875f, -0.02699457f, -0.01970751f, -0.03585765f, -0.05277308f, -0.06001754f, 0.00514960f, 0.01275826f, 
    -0.02955724f, 0.03525312f, 0.03557373f, -0.02992564f, -0.03047925f, -0.03727221f, 0.05175134f, 0.00064304f, 
    0.02949901f, -0.02007159f, 0.02238588f, -0.00627956f, -0.00316934f, -0.05389597f, 0.01501261f, -0.00830278f, 
    -0.03527053f, 0.02200713f, -0.02326467f, 0.05199070f, -0.05756141f, 0.02597922f, -0.05539081f, -0.05592411f, 
    0.00383779f, 0.04988895f, -0.02568359f, -0.00244115f, -0.00604502f, -0.03704726f, -0.04733687f, -0.05603966f, 
    0.03516077f, 0.03347147f, -0.01162607f, 0.01380689f, 0.04226731f, -0.02112383f, -0.02787955f, 0.00182301f, 
    -0.01310146f, 0.01179720f, 0.05350288f, 0.01288487f, 0.05193579f, -0.02261267f, 0.01899437f, -0.03490300f, 
    -0.02615384f, 0.14379588f, -0.15006323f, -0.07565148f, -0.24260236f, 0.10253946f, 0.10509087f, 0.04136774f, 
    0.00767576f, -0.02604789f, -0.07757914f, 0.04220285f, 0.06163909f, 0.12331649f, 0.02846467f, -0.08920401f, 
    -0.01128204f, 0.04668496f, 0.08248717f, 0.00722303f, 0.30087537f, -0.14692721f, -0.01535070f, 0.24854742f, 
    0.23466118f, -0.02118892f, 0.06785168f, 0.02596292f, 0.06078619f, 0.05614414f, 0.07908641f, -0.13882531f, 
    0.10429904f, -0.03395844f, 0.08664866f, 0.12998043f, 0.02506584f, 0.00207002f, 0.09158626f, 0.03970159f, 
    -0.23094946f, -0.21494482f, -0.08856427f, -0.29648501f, 0.01075480f, 0.10834971f, -0.06173842f, 0.02577733f, 
    -0.04272372f, 0.15237568f, 0.21869127f, 0.01253597f, 0.01719318f, 0.05702208f, -0.21196541f, 0.01033949f, 
    0.09158669f, -0.03041474f, -0.07735122f, 0.01755742f, -0.12802151f, 0.37655917f, -0.07975475f, 0.36168930f, 
    -0.02783826f, 0.22317155f, 0.14174011f, 0.02647229f, 0.01349097f, -0.02585855f, 0.06032401f, 0.05695455f, 
    0.06793868f, -0.00416090f, 0.04081077f, 0.08155731f, 0.10023519f, 0.05443827f, 0.07829124f, -0.08059554f, 
    0.19315295f, -0.12226376f, 0.06467073f, -0.24751289f, 0.15826087f, -0.18696429f, -0.08156027f, 0.03864712f, 
    -0.13880216f, -0.10953534f, 0.10227177f, -0.07650423f, -0.04514486f, -0.00056164f, -0.04329837f, 0.04131486f, 
    0.09148038f, -0.07111514f, -0.03631136f, -0.03191033f, 0.01116405f, -0.28896257f, -0.31137684f, -0.03293756f, 
    -0.01813924f, -0.06019847f, -0.10195425f, -0.01285362f, -0.07198052f, 0.13019182f, -0.07733943f, -0.07604429f, 
    0.09363735f, -0.06825600f, 0.08674391f, -0.05944325f, -0.03420836f, -0.05600233f, -0.11039570f, 0.01711708f, 
    0.20566671f, 0.14247546f, 0.10722660f, -0.25679660f, -0.03270981f, 0.02870976f, 0.00148413f, 0.06830674f, 
    -0.03328647f, 0.02523585f, 0.12562858f, 0.10895554f, 0.01881680f, -0.06257948f, 0.07300153f, -0.00199422f, 
    0.11323051f, 0.04781786f, 0.05278714f, 0.08267767f, 0.01627687f, 0.39688134f, -0.02309071f, -0.18006194f, 
    0.12051710f, 0.12300959f, 0.10043206f, 0.00197238f, 0.12356679f, -0.00325361f, 0.06761036f, 0.00444115f, 
    -0.03867691f, 0.14750403f, 0.07672992f, 0.09677422f, 0.03148321f, -0.05050326f, -0.07085270f, -0.02010747f, 
    0.02911664f, -0.21441239f, 0.03822596f, -0.05327576f, 0.04598004f, -0.12463141f, -0.04879021f, -0.01410761f, 
    0.02405774f, -0.00382005f, 0.05045789f, 0.04767455f, -0.00424156f, 0.10714485f, 0.00295248f, 0.00483629f, 
    -0.01111738f, 0.03187318f, -0.04180152f, 0.01766351f, 0.33613858f, -0.30879006f, -0.14376995f, 0.18848719f, 
    0.02588120f, -0.04652394f, 0.01468763f, -0.12684254f, 0.02868299f, 0.11802634f, 0.00351146f, -0.01672362f, 
    -0.03322770f, 0.01364590f, 0.03904881f, 0.03932551f, 0.00024549f, 0.16716476f, -0.00463616f, 0.08145556f, 
    0.07594531f, -0.08773670f, -0.32321459f, 0.10217299f, -0.19922267f, 0.10977682f, 0.06636741f, 0.00767494f, 
    -0.09317555f, 0.00106338f, -0.02779164f, -0.02110326f, 0.01781703f, 0.18387605f, 0.06047455f, 0.12245234f, 
    -0.00112621f, -0.05011459f, 0.08627849f, 0.12957455f, 0.50202304f, -0.29405433f, -0.19497006f, -0.13566354f, 
    0.13478334f, -0.07007019f, -0.15408894f, 0.01992805f, -0.04237378f, 0.04983401f, 0.00631534f, 0.06488807f, 
    -0.18657912f, -0.03256227f, -0.02555153f, 0.07252331f, -0.03504898f, -0.17417398f, -0.13585982f, 0.10474600f, 
    0.03966242f, 0.20885114f, -0.15670678f, 0.24313949f, -0.01807745f, 0.20056140f, 0.13089627f, 0.14908884f, 
    -0.06378234f, -0.00061294f, 0.08266373f, 0.10599484f, 0.03185242f, 0.09171785f, 0.11045916f, 0.01335419f, 
    0.01861724f, -0.01273649f, -0.07997315f, -0.01601427f, -0.08458783f, -0.21531121f, 0.12629746f, -0.06871173f, 
    0.27170455f, -0.03950458f, 0.00961313f, -0.02316659f, -0.00904928f, 0.06099987f, -0.00481862f, -0.09926289f, 
    0.04946438f, 0.08355814f, -0.06449100f, -0.01643690f, -0.06540688f, 0.01863466f, 0.13942870f, -0.08415519f, 
    -0.17637655f, -0.16285475f, -0.13706505f, 0.17319129f, 0.19644322f, 0.05014304f, 0.12540181f, -0.02646855f, 
    0.02730652f, -0.12358219f, 0.07837793f, -0.04888224f, -0.03256685f, 0.01684798f, -0.00520530f, 0.11844349f, 
    0.04916157f, -0.09770572f, 0.05484212f, 0.10645210f, -0.05146072f, -0.28098381f, -0.16487530f, 0.15010391f, 
    -0.22089522f, 0.09482146f, 0.18119296f, 0.07653022f, -0.11686294f, 0.00173330f, 0.11235665f, -0.16311532f, 
    -0.07022548f, -0.06802911f, 0.08270296f, -0.06263351f, -0.07145214f, 0.03096568f, 0.03544283f, 0.00745744f, 
    0.00462750f, -0.05216785f, 0.04373601f, -0.05959668f, 0.04839904f, 0.02622705f, 0.04006305f, 0.04548900f, 
    -0.02250555f, 0.02400154f, -0.04627298f, -0.00641681f, 0.02171504f, 0.03113146f, -0.03008526f, -0.00050224f, 
    0.01333836f, 0.01124192f, -0.04660334f, -0.05716844f, -0.06048417f, -0.01039182f, 0.00202293f, -0.04157986f, 
    -0.03652630f, -0.02571894f, -0.02544898f, 0.04091158f, -0.01982168f, -0.04547953f, 0.02950777f, 0.04980782f, 
    -0.04620097f, 0.01385889f, 0.02908785f, 0.02562445f, -0.03806283f, -0.02859996f, -0.02970551f, -0.05269079f, 
    -0.03965493f, -0.04055559f, -0.05448321f, 0.04620045f, 0.00379325f, 0.03126451f, 0.01527778f, 0.00751437f, 
    -0.03579222f, 0.02819175f, 0.01606282f, 0.03810831f, 0.04874494f, 0.00794653f, -0.02862018f, -0.03949958f, 
    0.03543451f, -0.01539696f, -0.02272683f, -0.06346177f, 0.03950246f, -0.00538826f, -0.04396692f, -0.04017584f, 
    -0.00336164f, -0.00986550f, -0.05773501f, 0.03488776f, 0.03521819f, 0.04120751f, -0.04067437f, -0.02955038f, 
    0.01336722f, 0.01344244f, -0.04216661f, -0.06312931f, -0.02414445f, 0.00585672f, -0.01764688f, 0.03514556f, 
    0.01754003f, 0.00380787f, -0.00232760f, -0.02781734f, 0.04694217f, -0.01328451f, -0.05794778f, -0.03767859f, 
    -0.03016852f, -0.00891266f, 0.01525273f, -0.05573766f, -0.04375691f, -0.02833062f, -0.01251458f, -0.02512411f, 
    -0.02982555f, -0.04286150f, 0.00478957f, -0.02062933f, 0.00189045f, 0.03657571f, 0.00506585f, -0.04534414f, 
    -0.00155743f, -0.05352593f, 0.01021092f, -0.00796324f, 0.05179474f, -0.03884766f, -0.02913509f, 0.04414162f, 
    -0.03998342f, -0.04345261f, -0.04088070f, 0.03631048f, -0.01083642f, -0.03863270f, 0.03739564f, 0.03302395f, 
    -0.01885004f, 0.04558866f, 0.05040883f, -0.03053657f, 0.02795716f, 0.01502703f, -0.02916506f, 0.02615452f, 
    0.04510028f, -0.04167175f, -0.03456962f, 0.04339797f, -0.04380606f, -0.00376784f, -0.01244046f, -0.02226114f, 
    0.03457651f, -0.00974892f, -0.00237711f, -0.05299886f, 0.01112579f, 0.03249671f, 0.04012627f, 0.03101313f, 
    -0.00735043f, -0.06629963f, 0.01522094f, 0.03314071f, 0.00936316f, 0.03312371f, -0.03576303f, -0.04165229f, 
    -0.01525286f, -0.04563369f, 0.02705486f, 0.01809760f, 0.03513177f, 0.02414628f, -0.00307813f, 0.01652911f, 
    -0.06408653f, 0.00322509f, 0.04621995f, -0.00683684f, -0.00874480f, 0.04715104f, 0.02606001f, -0.02486173f, 
    0.05124195f, 0.04651950f, -0.04896327f, -0.01852464f, -0.05152917f, -0.01052295f, 0.00014620f, -0.02485156f, 
    0.03292343f, 0.04547898f, -0.01846783f, 0.04120798f, -0.03768607f, -0.04965008f, 0.01511653f, -0.05951644f, 
    0.04065457f, -0.02940604f, 0.00198959f, -0.03733721f, 0.01794191f, 0.04004615f, -0.02128142f, 0.04691164f, 
    -0.00288417f, 0.03920975f, -0.04812799f, -0.00360527f, -0.01195733f, -0.03436902f, -0.02323723f, -0.03011268f, 
    0.04203530f, 0.00224873f, 0.02111553f, -0.03419625f, -0.04416932f, 0.03881569f, 0.00430064f, 0.01426026f, 
    -0.02812526f, 0.02661161f, -0.04033269f, -0.01644967f, 0.04929310f, -0.00858834f, 0.03864886f, 0.00983981f, 
    -0.02207894f, -0.03151553f, 0.01752348f, 0.02861772f, -0.03330790f, 0.03656249f, -0.05206491f, -0.02366619f, 
    -0.02525413f, -0.02313142f, -0.04802846f, -0.06340250f, 0.01620483f, -0.00348552f, -0.03226698f, -0.06001689f, 
    -0.02605237f, 0.00448647f, -0.03450514f, 0.01183522f, -0.00891049f, -0.06185996f, -0.02853343f, 0.04251184f, 
    -0.03298502f, 0.01557245f, -0.05104097f, 0.04445804f, -0.04352557f, -0.01941341f, 0.02856470f, 0.02095984f, 
    0.03785373f, -0.04493073f, -0.02741563f, 0.01906522f, 0.04195749f, 0.03036395f, 0.01630535f, -0.01993612f, 
    0.00728255f, 0.02828201f, -0.00246817f, -0.03976441f, -0.00682527f, 0.03580555f, -0.01468410f, -0.04110670f, 
    -0.03710299f, -0.03283355f, -0.02525887f, -0.02010539f, 0.01630110f, -0.02589380f, 0.04309226f, -0.02046378f, 
    -0.01629856f, -0.01051651f, -0.02016052f, -0.03410250f, 0.03510963f, 0.02981033f, -0.01182724f, -0.01222839f, 
    0.02649497f, -0.01930957f, -0.05035818f, -0.03800691f, -0.00260756f, -0.01603666f, 0.03797974f, -0.01889894f, 
    0.00165376f, 0.02346304f, 0.02907249f, 0.00640047f, -0.03633704f, 0.00815088f, 0.02500047f, -0.03425876f, 
    -0.03925396f, -0.04541190f, -0.00023437f, 0.02516240f, -0.03326255f, 0.00495954f, -0.00182463f, -0.04442799f, 
    -0.02305124f, -0.05460397f, -0.04298324f, -0.02556865f, 0.02231435f, 0.04943936f, -0.01610274f, 0.02821179f, 
    -0.04048845f, 0.02586886f, -0.04186736f, 0.03505784f, 0.02433065f, 0.04568553f, 0.04898438f, -0.00114216f, 
    -0.25072491f, 0.33309260f, -0.03881657f, -0.04629987f, -0.14038076f, 0.09359352f, 0.07516635f, 0.05777743f, 
    0.00498389f, -0.05743916f, 0.03092516f, -0.05398091f, -0.10675179f, 0.09305594f, -0.01137317f, 0.00015444f, 
    0.00290987f, -0.01155902f, -0.06489522f, -0.02081918f, 0.11583257f, 0.13599116f, -0.00720737f, 0.17421952f, 
    0.21615508f, 0.02167941f, 0.07072568f, -0.10385796f, 0.13322583f, 0.03467363f, 0.13802758f, -0.13529992f, 
    -0.02857502f, -0.06750581f, 0.02294881f, 0.02919340f, 0.06884022f, -0.11826484f, 0.09351289f, 0.10204901f, 
    0.35996959f, 0.38191485f, 0.01814924f, -0.07860903f, 0.03061857f, 0.02079173f, -0.01318353f, -0.00626298f, 
    -0.05789163f, -0.00468933f, -0.02903478f, 0.10271817f, -0.08695146f, -0.05519554f, -0.04293082f, -0.02541860f, 
    0.06861782f, -0.03149724f, 0.03840998f, 0.01549424f, -0.08652320f, 0.00289519f, -0.06032328f, 0.14589176f, 
    0.09349068f, 0.02863045f, -0.00360544f, -0.07530880f, 0.10744093f, 0.03836671f, 0.05886488f, 0.10547376f, 
    0.03012628f, -0.01864179f, -0.00215377f, 0.01857166f, 0.03109534f, -0.08188373f, -0.01213288f, -0.11240368f, 
    0.25339085f, 0.14665370f, 0.02818603f, 0.01519607f, 0.05763436f, 0.01518257f, -0.08652662f, -0.00199008f, 
    0.02806913f, 0.02788769f, -0.03860896f, 0.00012637f, 0.11913766f, 0.00174692f, -0.11748142f, -0.04900111f, 
    0.09379692f, 0.04239426f, -0.01733634f, -0.03146888f, -0.58875203f, -0.00937922f, -0.29025197f, 0.02895016f, 
    -0.15700248f, 0.06915961f, -0.03273236f, -0.00298255f, 0.00461817f, -0.01918619f, -0.05069833f, 0.01842044f, 
    0.03167413f, -0.08684851f, -0.06396733f, 0.08724791f, 0.03076084f, -0.04498542f, 0.07335616f, -0.02430121f, 
    0.09727238f, 0.21512374f, 0.19107445f, -0.11195419f, 0.12828216f, 0.00575377f, -0.07308701f, 0.02766046f, 
    0.09244188f, 0.00276109f, -0.04964210f, 0.11668967f, 0.09192224f, -0.09490461f, 0.05377619f, 0.02631589f, 
    0.08457059f, 0.08799279f, 0.00562441f, -0.13291872f, -0.21178241f, 0.12889063f, -0.11187632f, 0.32896060f, 
    0.48426911f, 0.12009101f, 0.02698146f, -0.05981386f, 0.01347407f, 0.02781540f, 0.07814715f, -0.00738787f, 
    0.09349582f, 0.04069046f, 0.02402451f, 0.03325965f, -0.03386810f, -0.09367318f, 0.07170285f, -0.01597506f, 
    -0.30194327f, -0.07723401f, 0.09742870f, -0.09917966f, 0.09891094f, -0.01801280f, -0.11976190f, -0.03268929f, 
    -0.09697469f, -0.06033256f, 0.04670788f, 0.04927688f, 0.01150567f, 0.08746149f, -0.09229052f, 0.00155854f, 
    0.12186895f, -0.03408138f, -0.08449546f, -0.04198284f, 0.16800667f, -0.00803229f, -0.19186608f, -0.04766129f, 
    0.03965390f, -0.11331049f, 0.05165405f, 0.01460291f, 0.16677067f, 0.05231787f, 0.07833045f, -0.02197941f, 
    -0.10865688f, -0.10335700f, -0.06140425f, 0.07709384f, -0.01947290f, 0.08229864f, -0.03790534f, 0.01606252f, 
    0.40869772f, 0.10843776f, -0.21084625f, -0.14781587f, 0.09175526f, 0.02589474f, 0.01932105f, 0.00731190f, 
    0.05340011f, 0.13869472f, -0.02554775f, -0.02872116f, -0.06927164f, 0.01505743f, -0.01935408f, -0.02624050f, 
    -0.10264514f, 0.03577459f, 0.04371853f, 0.05107472f, 0.16824183f, -0.14993347f, -0.11795648f, -0.09808841f, 
    -0.02884563f, -0.05735737f, -0.15943876f, 0.08357381f, -0.01533973f, -0.06507779f, -0.03034311f, 0.03293689f, 
    0.08471709f, 0.00057083f, -0.02749582f, -0.09481011f, 0.08289541f, 0.05597083f, 0.00464961f, 0.04268271f, 
    0.20036985f, 0.00272379f, -0.28987274f, 0.23151767f, 0.20271142f, 0.12416835f, 0.06491224f, 0.03714183f, 
    0.04000084f, -0.06746288f, 0.07835630f, 0.07601757f, 0.04235540f, 0.11196045f, 0.07100414f, 0.04656775f, 
    0.08742812f, 0.07618116f, -0.01670712f, 0.02369545f, -0.19070251f, -0.19933343f, 0.13934991f, -0.10007292f, 
    -0.07288960f, -0.05661140f, 0.11109391f, -0.04334870f, -0.09288358f, 0.04180567f, 0.12620427f, 0.06387104f, 
    0.08054803f, 0.14341705f, 0.01561992f, 0.02467589f, -0.05873014f, -0.07772686f, -0.01821223f, -0.03737083f, 
    0.18261708f, 0.27727368f, -0.12220600f, -0.01518427f, -0.07107626f, 0.16909871f, 0.14678556f, 0.03275370f, 
    0.14020324f, 0.02875383f, -0.03683848f, 0.04104466f, -0.01270317f, 0.08142012f, 0.01139436f, 0.01737549f, 
    0.06437735f, 0.08221836f, -0.02157601f, 0.11223773f, 0.20612006f, -0.15766034f, -0.16541040f, 0.06200245f, 
    -0.27117246f, -0.10666291f, -0.02669785f, -0.04446190f, -0.00948144f, -0.01825062f, -0.07082119f, -0.11204847f, 
    -0.00749741f, 0.01677752f, -0.01958192f, -0.18595311f, -0.01703762f, -0.19325252f, 0.02005114f, -0.07299441f, 
    0.07397157f, -0.03570085f, 0.20866407f, 0.16284774f, 0.07058030f, 0.00114664f, -0.03126913f, -0.03825641f, 
    0.02491512f, 0.10150399f, 0.07083913f, 0.10876910f, 0.10275115f, -0.06959448f, 0.05411145f, 0.03918284f, 
    -0.02531316f, 0.00738416f, 0.22670200f, -0.01192092f, -0.39678046f, 0.13955383f, -0.06324273f, 0.03333183f, 
    -0.08397993f, 0.04980627f, -0.12981161f, 0.02559027f, -0.08551838f, -0.08885881f, -0.06474169f, 0.14554636f, 
    -0.02504247f, -0.04526474f, 0.00058261f, 0.04732422f, 0.05141388f, 0.05003090f, -0.06236941f, -0.10342766f, 
    0.01232627f, 0.02637837f, -0.02900241f, 0.29570657f, -0.07277158f, -0.07925862f, -0.09295882f, 0.00277731f, 
    -0.03886847f, 0.04231061f, 0.12041738f, -0.04896632f, 0.16492921f, 0.00088672f, 0.12274938f, 0.01104177f, 
    -0.07022671f, -0.01170582f, -0.02908735f, 0.08766548f, 0.22872396f, -0.12541157f, 0.08081520f, -0.01198305f, 
    -0.16281903f, -0.10253628f, 0.02756371f, 0.01931728f, -0.01777714f, 0.16716802f, -0.05333721f, -0.03647315f, 
    -0.01335998f, -0.02389769f, 0.02424581f, 0.08771719f, -0.00920350f, 0.00285106f, 0.10025954f, 0.07003071f, 
    -0.49302858f, -0.11358480f, -0.29814386f, -0.10760703f, -0.05595760f, 0.05112687f, 0.12176593f, -0.08059609f, 
    -0.00393558f, 0.03483256f, 0.06941389f, 0.16156229f, 0.09475663f, 0.02155551f, 0.13269876f, 0.06456662f, 
    0.02154463f, 0.00924019f, 0.09324936f, -0.00942040f, -0.11354134f, -0.02229842f, 0.10496243f, -0.04945330f, 
    -0.03180882f, 0.00158765f, 0.10150193f, 0.16233167f, 0.05324685f, -0.03156610f, 0.00453115f, -0.02183658f, 
    -0.03182598f, 0.04372426f, 0.03604125f, -0.03460982f, -0.02557636f, -0.02686655f, 0.06244070f, 0.09573008f, 
    -0.64631194f, -0.11421238f, -0.20445831f, 0.27390096f, 0.02422880f, 0.17500983f, -0.02875387f, -0.04777500f, 
    0.10788222f, 0.02116317f, 0.07752707f, -0.01482921f, 0.01654488f, 0.04443416f, 0.06401135f, -0.08209198f, 
    0.03394025f, -0.00151435f, -0.11214317f, 0.10474859f, 0.14794919f, -0.13714099f, 0.25606039f, 0.01372409f, 
    0.03929704f, -0.10509104f, 0.03341921f, 0.14716317f, -0.00630668f, 0.20417635f, -0.00226869f, -0.09709511f, 
    0.04159123f, 0.09299006f, 0.08382980f, 0.02175141f, 0.04530008f, 0.00816397f, -0.02099686f, 0.12205079f, 
    -0.22813635f, -0.00271883f, -0.00055342f, -0.04731260f, -0.14344588f, 0.09540599f, 0.09456727f, 0.00068611f, 
    0.06095811f, 0.00703067f, 0.01972912f, -0.05644650f, 0.06061041f, -0.06950273f, -0.07386078f, -0.04322239f, 
    -0.02578242f, 0.01128732f, -0.04879833f, -0.01291597f, -0.28410852f, 0.02903144f, 0.16678791f, 0.02736662f, 
    -0.09664073f, 0.16318829f, -0.01234338f, 0.01484665f, 0.00246196f, -0.03629609f, -0.03755022f, 0.00163400f, 
    0.08867009f, 0.15716530f, 0.02882178f, -0.03970589f, 0.09305388f, -0.13587329f, -0.06355918f, -0.03942710f, 
    -0.27671850f, -0.11274488f, 0.43131271f, 0.23642573f, 0.08010232f, -0.02004250f, 0.02784430f, 0.07631750f, 
    0.00679376f, -0.03438878f, -0.02988639f, 0.03023422f, 0.04005038f, 0.05982881f, -0.06517076f, -0.05683538f, 
    0.16343278f, -0.06546789f, -0.02247528f, -0.07313879f, -0.51728332f, 0.11229602f, -0.19739123f, -0.00961259f, 
    -0.03860625f, 0.13558242f, 0.05176195f, 0.00459545f, -0.02623301f, -0.02518571f, 0.04338596f, -0.00536420f, 
    0.06560528f, 0.05013474f, 0.01262938f, 0.06602637f, -0.01521877f, -0.05891997f, 0.05917750f, -0.02632155f, 
    0.39735994f, 0.00745225f, 0.27151725f, 0.12021463f, -0.15557522f, -0.01418044f, 0.05181919f, 0.07171334f, 
    0.03136162f, 0.06859309f, 0.00811261f, -0.04899371f, -0.00344201f, 0.02857067f, 0.13819289f, -0.00110981f, 
    -0.06644956f, 0.05375147f, 0.07134239f, 0.02301390f, -0.03401519f, 0.23565008f, -0.20049225f, 0.09441087f, 
    -0.04473824f, 0.03637591f, 0.06972525f, -0.05617745f, -0.01318547f, -0.09428625f, -0.08080627f, 0.02612066f, 
    -0.05387865f, 0.01748641f, 0.03914418f, 0.15327294f, 0.01058545f, 0.14499021f, -0.02339721f, 0.03659086f, 
    0.06148089f, -0.11879334f, 0.27116305f, -0.08879793f, -0.13199560f, -0.14005467f, -0.00273422f, 0.02218980f, 
    -0.08349330f, -0.04380255f, -0.00319723f, 0.06208517f, 0.03172147f, -0.00009420f, 0.03396929f, -0.04775420f, 
    0.10722157f, 0.02899309f, -0.03137502f, 0.00611450f, 0.11841314f, 0.25372750f, 0.07155658f, 0.16183227f, 
    0.06278624f, 0.11630431f, 0.05283120f, -0.03192110f, 0.07410665f, 0.05551732f, 0.12814742f, 0.06191589f, 
    0.03984712f, 0.09010299f, 0.04768508f, 0.11597792f, 0.04044199f, 0.09839568f, -0.04927762f, 0.15982291f, 
    -0.38336936f, 0.14454806f, -0.13160747f, 0.05259834f, 0.11037612f, 0.01031090f, -0.00288452f, -0.15422021f, 
    0.03028741f, 0.04642265f, 0.09437518f, -0.00539195f, -0.01215352f, 0.03687596f, 0.01248747f, -0.00741866f, 
    0.07358432f, -0.13651535f, 0.12095549f, -0.00454196f, -0.23165856f, 0.15953536f, -0.03439062f, 0.16314135f, 
    0.06034633f, 0.01658355f, -0.01007278f, -0.08161289f, 0.10085366f, 0.09680664f, 0.03797084f, -0.02232133f, 
    -0.10195848f, 0.04703541f, -0.04144451f, 0.02533122f, 0.08528522f, -0.05689398f, 0.02234340f, 0.00622032f, 
    0.20614536f, 0.42084783f, 0.20202868f, 0.01803475f, 0.10520116f, -0.09169491f, 0.02538699f, -0.10687476f, 
    0.01629306f, -0.04248798f, 0.13324521f, 0.17378858f, -0.00214889f, 0.02247432f, 0.04165849f, -0.03921401f, 
    -0.09122887f, -0.17496772f, 0.00203547f, -0.00242559f, 0.39471519f, -0.13542967f, -0.14975899f, -0.15373370f, 
    0.15162988f, 0.13914530f, 0.02389016f, -0.09263784f, -0.03156745f, 0.07898866f, -0.12482494f, 0.03805788f, 
    -0.06564199f, 0.01470132f, -0.03888323f, -0.03556168f, -0.03243963f, 0.00194988f, -0.04386899f, 0.15837631f, 
    0.06845439f, 0.21134645f, 0.07776926f, 0.03382580f, -0.24492401f, 0.02056696f, 0.03519119f, 0.03858569f, 
    0.10086374f, -0.08348938f, -0.00924477f, 0.00668542f, 0.14376983f, 0.05065209f, -0.03289145f, 0.04405790f, 
    0.13697706f, 0.07867647f, -0.01363606f, -0.04729296f, -0.43870664f, 0.34744340f, 0.14355963f, -0.01965645f, 
    -0.21334733f, -0.08890440f, 0.07547265f, -0.00300618f, 0.05841129f, 0.05217325f, -0.06508786f, 0.01333777f, 
    -0.00136606f, -0.09368175f, 0.01951205f, 0.14752875f, -0.07457352f, -0.12529638f, 0.14163746f, -0.02639149f, 
    -0.35904628f, 0.13962664f, 0.14619017f, 0.00995847f, 0.02203403f, 0.00911888f, -0.22330032f, 0.05544357f, 
    0.04180540f, -0.12799811f, -0.04758510f, 0.09263959f, 0.06374597f, 0.06676506f, 0.04748332f, 0.04124345f, 
    0.00328282f, 0.01494249f, -0.04171138f, -0.01672360f, 0.06874891f, -0.00808318f, -0.14439367f, 0.33004329f, 
    0.52057624f, 0.06479383f, -0.07654399f, -0.09314294f, 0.10296046f, 0.02004392f, -0.01144908f, 0.05067239f, 
    0.03013939f, -0.07575793f, -0.00454487f, 0.05625920f, 0.03184570f, 0.07919072f, -0.06543355f, 0.02677504f, 
    -0.38513985f, 0.05929425f, 0.44144511f, -0.03190595f, -0.01006822f, -0.03865343f, 0.07816412f, 0.00758578f, 
    -0.03152702f, -0.08621193f, -0.02938917f, -0.03294252f, 0.04922496f, -0.13409880f, -0.14555642f, -0.00667892f, 
    0.04942766f, 0.12087531f, -0.13256288f, 0.14407279f, -0.20455310f, 0.15222864f, 0.21874864f, 0.10347202f, 
    0.02056406f, -0.01681449f, 0.05048388f, 0.03594222f, 0.01801248f, -0.02084789f, 0.06500998f, 0.03277607f, 
    -0.07524399f, -0.01607592f, -0.00488982f, 0.02788022f, -0.01299723f, -0.02222203f, 0.01088589f, 0.06358274f, 
    0.29802209f, 0.23267625f, 0.01504612f, -0.06037562f, 0.30456880f, -0.16111979f, 0.00896764f, 0.02336719f, 
    -0.14357939f, 0.11100904f, -0.01553868f, 0.02000571f, 0.03664537f, -0.05438033f, -0.01030444f, -0.12101305f, 
    -0.12227993f, -0.19824080f, -0.03371222f, -0.06432227f, 0.06428856f, 0.06113586f, 0.06665995f, 0.00799830f, 
    -0.16030620f, 0.00519645f, -0.10132495f, 0.19248371f, -0.01603666f, -0.15494055f, 0.05622513f, -0.09919014f, 
    -0.00847834f, -0.05983507f, 0.00349105f, -0.04365778f, 0.11156120f, 0.07535203f, 0.02029926f, 0.00634386f, 
    0.46467972f, -0.15155223f, -0.35299107f, 0.14664786f, 0.44473574f, 0.05549299f, -0.08324227f, -0.06409030f, 
    0.00335289f, -0.14983912f, 0.09710927f, -0.02393048f, 0.04628322f, 0.16535506f, 0.04348606f, 0.03448592f, 
    0.11951842f, 0.14029792f, 0.13103533f, 0.02591973f, -0.07965755f, 0.13141634f, 0.01026342f, -0.08593255f, 
    -0.21509579f, 0.05643598f, 0.10687532f, 0.07236808f, -0.04693104f, 0.06418557f, 0.13190544f, 0.21207766f, 
    -0.09955575f, -0.02305545f, 0.05216801f, -0.00681472f, 0.07151286f, -0.05628234f, -0.04892214f, 0.02683423f, 
    0.32919356f, 0.19673799f, -0.01798009f, -0.00404157f, -0.25140524f, 0.06217029f, -0.17867504f, 0.00315017f, 
    -0.00626690f, -0.10806050f, 0.06471191f, 0.05994044f, -0.01646970f, -0.00811729f, 0.08934361f, -0.09801473f, 
    0.01358179f, -0.02680289f, -0.00963520f, -0.01986180f, 0.41112512f, -0.04976008f, -0.18493132f, 0.07925449f, 
    0.08702767f, -0.03671943f, -0.08546145f, -0.10873575f, 0.01079541f, 0.00704787f, 0.04737271f, -0.02760949f, 
    0.04189214f, 0.03180859f, -0.07497732f, -0.06238423f, 0.08404333f, -0.21183956f, 0.16698237f, -0.03470359f, 
    0.25011837f, -0.26069337f, 0.25340801f, 0.20170215f, -0.27456141f, -0.05042851f, 0.05939398f, 0.07637463f, 
    -0.06066298f, -0.06856573f, 0.07152925f, 0.08064606f, 0.09492735f, 0.02735879f, -0.03086949f, -0.09559950f, 
    0.03726784f, -0.06676211f, 0.18456644f, -0.01469317f, -0.25755659f, 0.09715696f, -0.18227836f, 0.00027171f, 
    0.20029071f, 0.10922571f, 0.01347705f, 0.03181374f, 0.07863583f, -0.10026129f, -0.00706377f, 0.03785070f, 
    -0.09597531f, 0.06800503f, 0.08449966f, -0.05336106f, -0.02012808f, -0.07590676f, -0.01586585f, -0.19503337f, 
    0.23157404f, 0.66709799f, -0.07313703f, 0.24925680f, -0.05646394f, 0.02762279f, -0.03681307f, 0.00091500f, 
    -0.01236560f, 0.12697656f, 0.03345591f, 0.04592272f, 0.04245809f, 0.06353217f, -0.03187514f, 0.07399796f, 
    0.02046576f, 0.16928738f, -0.04448173f, 0.19209482f, 0.21027078f, -0.24245863f, 0.07433257f, 0.08368282f, 
    -0.40141913f, -0.00834198f, 0.17928624f, 0.08503607f, -0.04959187f, -0.01314701f, -0.09514473f, -0.07571939f, 
    -0.00754641f, -0.12983975f, -0.01148136f, 0.02423103f, -0.04606736f, -0.11077447f, 0.00357654f, 0.01133076f, 
    -0.28631508f, -0.10235658f, -0.03634092f, -0.02786626f, 0.12959646f, 0.03714349f, 0.14036590f, -0.14195202f, 
    0.02867552f, -0.04025872f, 0.05622921f, 0.14402026f, -0.02792585f, -0.00778559f, 0.10137442f, -0.04856520f, 
    -0.04559254f, 0.08513075f, 0.04637597f, -0.02889024f, -0.23021488f, -0.06418978f, 0.15258729f, -0.02340868f, 
    -0.06101458f, 0.13706423f, -0.07751635f, 0.21620636f, 0.08852449f, 0.08404075f, 0.00825235f, -0.12204511f, 
    0.08123865f, 0.09304009f, -0.04603820f, 0.08296582f, -0.03894336f, 0.02316168f, -0.06192731f, 0.11506002f, 
    -0.20662583f, 0.14714059f, -0.14487705f, 0.03919617f, 0.04269567f, 0.06565744f, -0.13172382f, -0.20404975f, 
    -0.07023045f, -0.01535284f, -0.04788440f, 0.01799421f, -0.09345859f, -0.07243336f, 0.01232854f, -0.09573799f, 
    0.14261821f, 0.00658737f, 0.04373169f, -0.00147894f, 0.30841964f, -0.05686246f, 0.01110143f, 0.11436941f, 
    0.62526786f, -0.05359885f, 0.04319243f, 0.13757506f, -0.01437389f, 0.13931620f, 0.01324094f, -0.12590805f, 
    -0.09279512f, 0.05936313f, 0.01623178f, -0.06604572f, 0.05796590f, 0.07399707f, 0.09630810f, -0.00128701f, 
    -0.19147588f, -0.20219411f, 0.12056090f, -0.11370311f, -0.11594471f, 0.01693626f, -0.07435922f, 0.10241219f, 
    0.08438122f, 0.00291285f, 0.03713547f, -0.10032238f, -0.01409886f, -0.03959067f, -0.12204457f, -0.13733339f, 
    -0.01914368f, -0.04375996f, -0.04331034f, -0.03421619f, 0.10840571f, -0.06816819f, 0.12273297f, 0.00891596f, 
    -0.10518184f, 0.15841214f, -0.02265561f, -0.02925828f, 0.02266290f, -0.16710885f, -0.04840659f, -0.00069757f, 
    -0.08034588f, 0.09742838f, 0.00112140f, -0.01967350f, 0.07902864f, -0.14367972f, 0.00223605f, -0.16024023f, 
    -0.03996596f, 0.08872638f, 0.33985999f, 0.01722578f, 0.12556772f, 0.00576813f, 0.05439534f, 0.00279439f, 
    -0.06357983f, 0.12092668f, -0.05223288f, -0.02420294f, 0.03382344f, 0.04123379f, -0.15318227f, 0.07561871f, 
    0.10303092f, 0.07651632f, -0.00878445f, -0.02025481f, -0.35616481f, -0.07092589f, -0.00907929f, 0.01405764f, 
    0.16708927f, 0.10232764f, -0.03743129f, 0.03757672f, -0.04131864f, 0.08369049f, -0.02215766f, -0.02991243f, 
    0.17164636f, 0.07012957f, 0.03843188f, -0.08009423f, -0.07038917f, 0.04868453f, 0.11317161f, 0.00050027f, 
    0.37603351f, -0.02255594f, -0.17209800f, 0.15533929f, -0.10224576f, 0.07385533f, 0.22115862f, 0.01727545f, 
    -0.01770155f, -0.10599563f, -0.11908159f, -0.01525176f, -0.05530792f, -0.03838232f, 0.03052802f, -0.05437801f, 
    -0.00132770f, 0.12507872f, 0.09053740f, 0.09085272f, -0.27229887f, 0.08839970f, -0.12779187f, -0.11670715f, 
    -0.10789187f, -0.00380903f, 0.01738135f, 0.10319765f, -0.00159761f, -0.00405824f, -0.15844828f, 0.07327533f, 
    -0.05151574f, 0.08773716f, 0.01550696f, 0.10660125f, -0.02756328f, 0.13563982f, -0.05840423f, -0.03418622f, 
    0.15378653f, 0.07362901f, 0.13287567f, 0.03937556f, -0.14153662f, -0.09578083f, 0.08875348f, -0.04602940f, 
    0.01577112f, 0.03093557f, -0.09382667f, -0.02050877f, 0.02695079f, 0.03280328f, -0.02769644f, -0.01699678f, 
    0.06925219f, 0.03634068f, 0.04760308f, 0.08844867f, 0.14267011f, 0.34956348f, -0.07436854f, 0.16280217f, 
    -0.15437679f, 0.13274223f, 0.02166483f, 0.02454689f, 0.08249009f, 0.09369181f, -0.07428546f, 0.06163722f, 
    0.06452971f, 0.08762424f, 0.03613192f, 0.08641697f, 0.06603353f, -0.02658519f, -0.20240089f, 0.05345970f, 
    0.04106341f, -0.02244469f, 0.01385823f, -0.04861839f, 0.01592505f, 0.02882466f, -0.05190736f, -0.04420239f, 
    -0.04308571f, -0.05941692f, 0.04340253f, 0.00683893f, -0.05099589f, 0.02252471f, 0.00109390f, -0.06042686f, 
    0.00017459f, -0.00878203f, -0.00910485f, 0.04861590f, 0.01872178f, -0.04354755f, 0.00927144f, 0.04166121f, 
    -0.00015965f, 0.00977295f, 0.02918594f, 0.03069176f, -0.03385602f, 0.03924288f, -0.01384624f, -0.01394606f, 
    0.04296388f, 0.01821682f, 0.04477076f, 0.01584825f, -0.04665627f, 0.00731947f, -0.04962264f, 0.00667331f, 
    0.00336793f, -0.04522857f, 0.03787625f, -0.00637078f, -0.01361069f, -0.03318999f, 0.00019355f, -0.01508162f, 
    -0.02411474f, -0.01755538f, -0.01515609f, 0.02635346f, 0.01937253f, -0.04478010f, -0.03783076f, 0.02140107f, 
    0.00179001f, -0.01225332f, -0.03120608f, -0.05012462f, 0.01733338f, 0.03037299f, 0.01941792f, -0.06142448f, 
    0.04717929f, -0.04150555f, -0.04243014f, 0.00912689f, -0.01787530f, 0.01931497f, -0.01524705f, 0.01446875f, 
    -0.06122162f, 0.04310735f, 0.03088496f, 0.02896061f, -0.04754086f, -0.03309355f, -0.00332731f, -0.01992019f, 
    0.04308646f, 0.01103361f, 0.02741461f, 0.01265269f, -0.00887065f, -0.04652366f, 0.00795807f, -0.04321498f, 
    0.04002029f, -0.01814753f, 0.02565611f, -0.05074786f, -0.03503631f, -0.00804388f, 0.01893502f, 0.03526779f, 
    0.01090933f, -0.03999705f, -0.01571186f, -0.00843731f, -0.04637884f, 0.00926082f, -0.00745038f, -0.02276824f, 
    -0.00779423f, -0.03028158f, 0.02894102f, -0.01329453f, -0.00823150f, -0.04191959f, 0.03662235f, -0.05162373f, 
    -0.00926801f, 0.04280078f, 0.04402298f, -0.00038249f, 0.02852056f, 0.01859503f, 0.03543211f, -0.04971910f, 
    0.02191485f, 0.05136083f, 0.03668237f, 0.03998233f, -0.02514178f, -0.03837319f, -0.04068472f, 0.01248227f, 
    -0.00683101f, 0.04973038f, -0.00953340f, -0.05463693f, 0.02947166f, 0.04795965f, 0.01187251f, -0.04879755f, 
    -0.03147907f, -0.05191251f, -0.03404190f, -0.03717777f, 0.04372687f, -0.00309382f, -0.05736367f, -0.01135998f, 
    -0.05007842f, -0.05517667f, 0.02462598f, 0.01992156f, 0.00545499f, 0.03100517f, -0.02189399f, -0.00039830f, 
    -0.04039483f, -0.03768720f, -0.04360159f, 0.03295387f, 0.00973870f, -0.05819805f, -0.02502476f, -0.02878984f, 
    0.00278553f, 0.04944729f, 0.01689776f, -0.02165748f, -0.03329046f, 0.02547233f, -0.04664158f, 0.04065710f, 
    0.04630909f, -0.06047982f, 0.01322849f, 0.02902283f, -0.05148000f, -0.05303847f, -0.01440001f, 0.00886694f, 
    -0.05467362f, -0.01470520f, 0.03594311f, -0.02204838f, -0.01410276f, -0.05157884f, 0.00892744f, -0.03465491f, 
    0.03888750f, -0.00780696f, 0.01879813f, -0.00598594f, 0.01466260f, -0.01133419f, -0.02648415f, -0.04634419f, 
    0.03149186f, 0.03891084f, -0.03001943f, -0.05975403f, -0.00436072f, 0.02569324f, -0.01418497f, -0.02097507f, 
    0.01045693f, -0.01436082f, 0.04598653f, 0.01195674f, 0.03080210f, 0.02448548f, 0.03727074f, 0.00345583f, 
    0.03486140f, -0.03808911f, 0.04333435f, 0.04188951f, 0.00193345f, -0.03309618f, -0.05016436f, 0.00689083f, 
    -0.05899359f, 0.01474954f, 0.01322336f, -0.01931320f, -0.03110239f, 0.04459322f, -0.04439721f, -0.04596352f, 
    -0.00656761f, -0.00252475f, 0.00564636f, -0.02681639f, 0.02989523f, -0.01239319f, -0.03167925f, -0.00977576f, 
    0.03692215f, -0.03438044f, 0.03193415f, -0.01900814f, -0.02973517f, 0.00727078f, -0.02280423f, -0.01448386f, 
    0.01905396f, -0.03136311f, -0.02443788f, -0.04218223f, -0.05076743f, 0.01368388f, -0.04535840f, -0.04861672f, 
    -0.02697334f, -0.05056030f, 0.04238450f, -0.02364264f, 0.01295907f, -0.02329412f, 0.03844014f, -0.03026251f, 
    0.00601170f, 0.02365326f, -0.00773590f, 0.05042449f, -0.04973709f, 0.02701275f, -0.00767095f, 0.00887103f, 
    -0.02082869f, -0.04941730f, -0.04947161f, -0.01118909f, -0.00445533f, -0.05818919f, -0.00503866f, -0.01726280f, 
    -0.03386548f, 0.01431675f, 0.01359847f, -0.03078509f, 0.02891287f, -0.00872996f, -0.01703550f, -0.03622839f, 
    0.01162659f, 0.02066128f, -0.06501283f, 0.02433072f, -0.00874133f, -0.02294345f, 0.01190388f, 0.04274280f, 
    -0.03073701f, 0.01594908f, -0.01815184f, 0.02590540f, -0.01928218f, -0.01242046f, -0.01835856f, -0.04769112f, 
    -0.05959558f, -0.04715855f, -0.06201879f, -0.03518267f, -0.05753886f, -0.01460645f, -0.02745813f, -0.00381378f, 
    0.02579688f, 0.01683160f, 0.03939151f, -0.02947660f, -0.05178815f, -0.04768720f, -0.02006417f, 0.01372024f, 
    -0.04710833f, -0.00572337f, -0.00103625f, -0.05059531f, 0.04174604f, 0.01324106f, -0.04170284f, 0.03143007f, 
    0.20310380f, -0.14094877f, 0.03910736f, -0.21956465f, -0.29065076f, -0.00509285f, 0.06514543f, -0.02181110f, 
    0.07886612f, 0.05822296f, -0.01279747f, -0.06364410f, -0.03611312f, 0.12902071f, -0.06763183f, 0.01807728f, 
    0.03387344f, -0.02133378f, -0.10230663f, 0.10886208f, 0.21379668f, -0.08631662f, -0.03903314f, 0.22413614f, 
    0.14613099f, 0.13697039f, 0.14138232f, -0.01963819f, 0.05165151f, 0.11519848f, 0.02903068f, -0.04899448f, 
    -0.05768679f, -0.01386265f, 0.06084971f, 0.02706681f, 0.15812388f, 0.10960299f, 0.03035287f, 0.06652528f, 
    -0.03502348f, 0.10052747f, -0.00082058f, -0.06530148f, 0.51757914f, 0.09866117f, -0.07137523f, 0.13057211f, 
    -0.00174267f, 0.09317117f, -0.04591051f, -0.12776603f, -0.02782059f, -0.00437912f, -0.07607167f, 0.13970910f, 
    0.02626657f, -0.01960907f, -0.15328081f, 0.01484104f, -0.19157003f, 0.01399286f, 0.21138409f, 0.14352329f, 
    -0.26929632f, 0.02920454f, 0.07943267f, 0.06957473f, -0.02280498f, -0.04031297f, 0.07629277f, 0.03536236f, 
    0.00687399f, -0.02136652f, 0.12127271f, -0.01126779f, 0.09573963f, 0.08706116f, -0.03997283f, 0.06397377f, 
    0.42575204f, 0.05052150f, -0.00439751f, 0.05612641f, 0.03477539f, -0.01731980f, 0.03907403f, 0.03288215f, 
    -0.16503055f, 0.03188339f, -0.03082709f, 0.01174619f, 0.00050762f, 0.03572574f, -0.09936727f, 0.03064720f, 
    0.07024916f, 0.00928783f, -0.01654180f, -0.05488001f, -0.00963688f, -0.12758839f, -0.05307215f, 0.02232102f, 
    0.01424747f, -0.07891446f, 0.11761484f, 0.03403521f, -0.01527738f, -0.16182402f, -0.14117038f, 0.07975809f, 
    0.09592442f, -0.02969011f, -0.04023926f, 0.01544962f, 0.02075286f, 0.01535044f, -0.14403996f, -0.01751266f, 
    0.18484513f, 0.04172670f, -0.03750358f, -0.03005015f, 0.19613828f, -0.01471042f, -0.07185730f, -0.02720259f, 
    -0.08787394f, 0.03258020f, -0.02325412f, 0.07838505f, -0.04486426f, 0.04526539f, 0.12572813f, 0.04670224f, 
    0.00682843f, -0.01283543f, 0.05564461f, 0.05916777f, 0.25529772f, 0.34709349f, -0.13201307f, -0.10777739f, 
    0.15270963f, 0.13564040f, -0.06819711f, 0.10669387f, 0.11592341f, 0.10723429f, -0.05224409f, 0.00437449f, 
    0.08162079f, 0.10874675f, 0.18071724f, -0.03335861f, 0.05069344f, -0.10244616f, 0.01044975f, 0.01251051f, 
    -0.09739165f, -0.13203134f, -0.12202501f, -0.02241286f, -0.19447313f, 0.04433478f, 0.06772456f, 0.12076955f, 
    -0.13872318f, -0.08211311f, 0.06011952f, 0.13299160f, 0.08247092f, 0.17250697f, 0.08030681f, -0.03844873f, 
    -0.08038906f, -0.01210969f, -0.09119229f, -0.06448048f, 0.03025910f, -0.07306900f, 0.06295246f, 0.13410589f, 
    -0.04019839f, 0.05624762f, 0.09407616f, -0.02318181f, -0.07680917f, 0.03759041f, -0.03836950f, 0.00351074f, 
    0.03538986f, 0.06472006f, -0.05399282f, 0.01952619f, 0.07124174f, 0.12134329f, -0.06853349f, -0.00178651f, 
    0.19366652f, -0.25393343f, -0.01342982f, 0.12500119f, 0.00232793f, 0.07498215f, -0.07394476f, 0.02881022f, 
    0.07834110f, -0.00030246f, 0.05398168f, 0.07618781f, -0.04885894f, 0.14730285f, -0.05528950f, 0.10726695f, 
    0.13495363f, 0.09440389f, 0.06510080f, 0.08092036f, 0.48743862f, -0.00553886f, -0.09860175f, -0.04905721f, 
    -0.03197396f, 0.13979667f, 0.15198010f, -0.04910211f, -0.05553573f, 0.06411544f, -0.05893779f, 0.12046598f, 
    -0.10802727f, -0.07897190f, -0.14916824f, 0.00858492f, -0.00316294f, -0.14419641f, -0.08712032f, 0.08161773f, 
    0.08027557f, 0.27684140f, -0.06172956f, -0.08300909f, -0.27845863f, 0.07533079f, 0.03354213f, 0.12990685f, 
    0.08118160f, 0.07910147f, -0.03504410f, -0.06132936f, -0.00122711f, 0.09464210f, 0.03116204f, 0.08661357f, 
    -0.02099545f, -0.11178314f, -0.08813244f, -0.01707254f, 0.18037209f, -0.41022512f, -0.03102397f, 0.01502297f, 
    0.15026127f, 0.00818799f, 0.10814796f, 0.02095431f, -0.00908884f, 0.09398840f, 0.00480346f, -0.02576026f, 
    -0.00489200f, 0.04532233f, -0.12767813f, -0.01231353f, 0.00496769f, -0.04339005f, 0.00302830f, 0.03250419f, 
    -0.42493805f, 0.04036464f, -0.07698003f, 0.36774829f, 0.38009498f, -0.06130268f, -0.00460755f, 0.16373962f, 
    -0.03305559f, -0.01269125f, -0.07211751f, 0.03492245f, 0.03189656f, -0.01928718f, -0.11603830f, 0.26535314f, 
    0.05393676f, 0.04352400f, -0.03789384f, 0.09008174f, -0.38288051f, 0.08532874f, -0.01331539f, -0.08746418f, 
    -0.15991884f, 0.05918737f, 0.06915186f, 0.05885630f, -0.02180018f, -0.05149671f, -0.04635859f, -0.02951812f, 
    -0.11609130f, 0.03697852f, 0.01602049f, -0.03367778f, 0.01019438f, 0.06212602f, 0.01036143f, -0.01533094f, 
    -0.00704066f, 0.03900003f, -0.01304601f, -0.02592674f, -0.05684284f, 0.04605321f, -0.03702616f, 0.00657428f, 
    0.00016528f, -0.06145297f, -0.00612161f, -0.04377868f, -0.02151639f, 0.00361250f, -0.01358109f, 0.00757267f, 
    0.03084176f, -0.05811629f, 0.02077865f, 0.03875097f, -0.03626215f, -0.02783650f, -0.03722941f, -0.05340474f, 
    -0.03180017f, -0.00961618f, 0.03733977f, -0.03002592f, -0.06244640f, 0.02997128f, -0.02392760f, -0.01804520f, 
    -0.04397326f, -0.00770319f, -0.05855904f, 0.00472056f, 0.04326547f, -0.04505746f, 0.02711680f, -0.05228303f, 
    -0.00056115f, -0.02310385f, 0.01632098f, 0.00655088f, 0.03977202f, -0.02929540f, 0.02296842f, -0.02930559f, 
    0.01937086f, -0.01837920f, -0.01233292f, -0.01514241f, 0.01800071f, 0.00218186f, -0.02876856f, 0.02420262f, 
    -0.05326860f, -0.01136987f, -0.02738150f, 0.04496189f, -0.04470594f, -0.02040763f, 0.01433278f, -0.01175704f, 
    0.00071378f, -0.04499441f, 0.03372897f, 0.03120873f, -0.00918742f, 0.03654685f, -0.03014456f, -0.05050340f, 
    -0.02560363f, -0.02167572f, -0.05088456f, -0.04736913f, 0.02020297f, -0.03766566f, -0.04018372f, 0.03235235f, 
    0.02988911f, -0.02108239f, -0.01219666f, -0.04246004f, -0.03935496f, -0.05641945f, -0.05999631f, 0.04697230f, 
    0.00078659f, -0.01618224f, -0.03261539f, -0.06289715f, -0.02024430f, 0.00473735f, 0.01649220f, 0.00334530f, 
    0.01140286f, -0.00679759f, -0.04998446f, 0.01934633f, 0.02518041f, -0.00455432f, -0.05398535f, 0.04463353f, 
    -0.05069337f, -0.01708570f, 0.04395128f, -0.03743494f, 0.00884567f, -0.04197428f, -0.03197484f, -0.00619873f, 
    -0.02896333f, -0.03868942f, 0.00077146f, -0.02918287f, 0.04340918f, 0.01126949f, -0.00311327f, -0.02531590f, 
    -0.03017260f, -0.01677252f, -0.01632420f, -0.02029698f, -0.02577459f, -0.05397370f, 0.01580269f, 0.00243052f, 
    0.03731287f, -0.00843228f, 0.01920916f, 0.02177774f, 0.04163727f, -0.01384558f, 0.03355927f, -0.04217707f, 
    -0.03760279f, 0.04285550f, -0.02598174f, -0.05776478f, -0.00751567f, -0.05797515f, -0.05566137f, 0.02443522f, 
    0.02989436f, 0.01226772f, 0.04231655f, -0.05012880f, -0.05745523f, 0.03443825f, -0.03495447f, 0.00008903f, 
    0.04534103f, 0.00951738f, -0.04208444f, 0.02853563f, 0.00388184f, -0.04812935f, 0.03280299f, -0.00128162f, 
    -0.01661199f, -0.04350675f, -0.04524348f, -0.05794019f, 0.02516238f, -0.04929869f, -0.04881629f, -0.01652705f, 
    0.02670955f, 0.03656125f, 0.00499077f, 0.00167546f, -0.02542056f, 0.00136784f, 0.00014069f, -0.03023791f, 
    -0.03899108f, -0.01013703f, 0.01277169f, -0.05558516f, 0.01914631f, -0.02758225f, -0.05618085f, 0.03152410f, 
    -0.02165502f, -0.00400663f, 0.04096577f, -0.00038565f, 0.01631598f, 0.02821075f, 0.04145627f, 0.00642951f, 
    0.02809535f, -0.00778099f, -0.01262610f, -0.01755673f, 0.03383288f, 0.00588707f, -0.02426266f, 0.03143275f, 
    0.01012644f, 0.00305391f, 0.02409358f, -0.03030480f, 0.02974028f, 0.04693284f, -0.05696545f, -0.04658462f, 
    -0.01170230f, 0.02443194f, 0.04286655f, 0.04359680f, 0.04951235f, -0.04743597f, 0.04412916f, 0.02529093f, 
    0.00431517f, 0.03399646f, 0.00041802f, -0.04400497f, -0.01574567f, -0.03129047f, 0.03494982f, -0.01670424f, 
    -0.04722410f, -0.04396440f, 0.03038246f, 0.04736361f, -0.02808831f, -0.02494108f, -0.04040404f, 0.00609087f, 
    -0.04782860f, 0.00509966f, -0.05956551f, 0.03359907f, -0.05537038f, -0.04066962f, 0.00493167f, -0.01093215f, 
    0.00406270f, 0.01532878f, 0.00163015f, -0.05171973f, 0.00465453f, -0.02258684f, 0.02872148f, -0.05661176f, 
    0.03985449f, -0.02821726f, -0.05859823f, -0.06095953f, -0.02185374f, -0.04918729f, 0.01520799f, -0.02218577f, 
    -0.01027984f, -0.03479765f, 0.03546582f, 0.01114511f, -0.01761078f, -0.04303811f, 0.04991421f, -0.05465864f, 
    0.04493282f, -0.03939033f, 0.02838654f, -0.04760867f, -0.02356751f, 0.03116973f, 0.04769447f, -0.00506692f, 
    -0.04079068f, -0.04103366f, 0.04054807f, 0.01052271f, -0.06225036f, -0.05227149f, 0.02634638f, 0.01262008f, 
    -0.02976758f, -0.05287994f, -0.06163618f, -0.03002739f, 0.01174745f, -0.00870156f, -0.05698512f, -0.00401224f, 
    -0.01253363f, -0.00424443f, 0.04666858f, -0.04399554f, 0.00512079f, -0.01869666f, -0.01246030f, -0.04213116f, 
    0.03203380f, 0.00423777f, 0.02746930f, 0.04318368f, -0.01139099f, -0.01496797f, -0.00445560f, -0.04770661f, 
    0.03487849f, 0.01793786f, 0.02463243f, -0.01712964f, -0.05730594f, -0.03104872f, 0.01525378f, -0.00181510f, 
    -0.00457839f, -0.04337650f, 0.02946090f, -0.00954365f, -0.00384822f, -0.01569647f, 0.00817968f, -0.01062702f, 
    -0.16711493f, -0.08525396f, 0.23793632f, 0.32881400f, -0.06847260f, 0.09115827f, -0.10026408f, -0.02195415f, 
    -0.05275906f, 0.05209845f, -0.01468129f, 0.18769103f, -0.01853761f, -0.09849716f, 0.08899289f, -0.08921267f, 
    0.01616260f, -0.01588372f, 0.01801749f, -0.05882955f, -0.01593624f, 0.09596898f, -0.08598688f, 0.01903433f, 
    0.01193458f, -0.08311464f, -0.01602091f, -0.03336867f, -0.04795717f, 0.02799874f, 0.06645765f, 0.04370489f, 
    0.00036806f, 0.12638883f, -0.03489579f, 0.07338316f, -0.10103002f, -0.05978821f, 0.00627301f, -0.06875623f, 
    0.08712044f, 0.30521515f, -0.10902815f, 0.07104692f, -0.02612394f, -0.05316282f, 0.14898339f, -0.08386418f, 
    -0.08455655f, -0.02689157f, 0.03398796f, 0.10544107f, 0.09282932f, -0.09029835f, 0.01928120f, 0.01426286f, 
    0.09008107f, 0.06443860f, 0.02678736f, 0.11790785f, -0.28328478f, -0.11407907f, -0.18417154f, -0.05800961f, 
    -0.11046087f, 0.17728326f, 0.08873666f, -0.09750715f, 0.02281751f, 0.01230088f, -0.05249187f, -0.02082371f, 
    -0.01665074f, -0.10335193f, -0.06183572f, 0.00103995f, 0.05474002f, 0.07887921f, 0.18186568f, 0.06387816f, 
    -0.19666748f, 0.13666612f, 0.23740271f, -0.02243244f, 0.23191015f, 0.01989526f, 0.13429064f, 0.00463367f, 
    0.03344937f, -0.14832565f, 0.15670501f, 0.10445238f, -0.01702828f, -0.02815515f, -0.06125532f, 0.05740276f, 
    -0.04753043f, -0.10393363f, 0.05719780f, 0.02704797f, 0.06443316f, 0.19134147f, -0.06620896f, 0.03838610f, 
    -0.06762834f, 0.09905992f, -0.03788810f, -0.05036132f, -0.03726542f, 0.10540666f, 0.05632166f, -0.06947634f, 
    -0.05387964f, -0.07134797f, 0.04321423f, -0.08775482f, 0.16741884f, 0.06828912f, 0.05334846f, 0.08898665f, 
    0.01362552f, 0.44037384f, 0.08339774f, -0.11124938f, 0.03794929f, 0.06593718f, 0.01941655f, -0.07949097f, 
    -0.10051007f, -0.08581147f, 0.01923642f, 0.01213752f, 0.00843775f, -0.01818230f, -0.02223154f, -0.11875012f, 
    0.07280240f, 0.00984927f, -0.07041093f, -0.02370030f, 0.23632243f, -0.19960892f, 0.04679321f, 0.01122989f, 
    0.35573748f, -0.01647104f, -0.20649657f, -0.09429315f, -0.00546209f, -0.01153067f, 0.02118262f, 0.10468108f, 
    -0.09557557f, 0.07755323f, -0.04729668f, 0.08742047f, -0.05256139f, 0.10844307f, -0.06396053f, 0.08037715f, 
    0.15007821f, -0.10285009f, 0.04131714f, 0.08435608f, 0.24867727f, 0.06631510f, -0.05788197f, 0.06454737f, 
    0.04147477f, 0.07302053f, -0.01342556f, -0.00271063f, -0.04657031f, -0.14773352f, -0.06406003f, 0.11458261f, 
    0.15833718f, 0.06766431f, 0.06038524f, 0.04047202f, 0.26499847f, 0.06965835f, -0.19144462f, -0.01729429f, 
    -0.02193269f, 0.12168666f, 0.03842000f, 0.07613185f, 0.03872935f, -0.00574391f, 0.02343206f, -0.02710771f, 
    0.03679011f, 0.06692189f, 0.03942367f, 0.04952839f, -0.03930032f, 0.06554412f, 0.05461071f, 0.02649647f, 
    -0.28332213f, 0.28924462f, 0.09270763f, 0.17544943f, 0.08068378f, 0.06307532f, 0.10657249f, -0.08411913f, 
    -0.06473081f, -0.14481206f, 0.01040661f, 0.01536712f, -0.02060200f, -0.09151027f, -0.06633186f, -0.07380764f, 
    -0.10025094f, -0.07806493f, 0.06902057f, 0.00276873f, -0.34892097f, 0.16377690f, 0.39423811f, 0.15072797f, 
    0.28120920f, -0.12661947f, 0.03639057f, 0.10670935f, 0.06125684f, -0.13392074f, 0.07686460f, -0.07607806f, 
    0.05268174f, 0.03949606f, -0.03298716f, -0.04663117f, 0.06083137f, -0.00633344f, 0.04479729f, 0.06230083f, 
    -0.48012134f, -0.20850153f, -0.01223801f, 0.12313340f, 0.00270821f, 0.01860907f, -0.00827160f, -0.08708810f, 
    0.00711321f, -0.04725780f, 0.11243883f, 0.25046724f, 0.01904618f, 0.03919718f, 0.01645924f, -0.12324018f, 
    -0.02736546f, 0.06906237f, 0.06042854f, 0.02214012f, -0.26084822f, 0.19514726f, 0.11799671f, -0.09213869f, 
    0.18852390f, -0.10476020f, -0.19387141f, 0.06169844f, -0.02991274f, -0.18057792f, -0.00646483f, -0.07885958f, 
    -0.06195749f, -0.09194087f, 0.11247296f, -0.09718482f, -0.04538590f, 0.07304707f, -0.01996017f, -0.05736552f, 
    0.11623055f, 0.17554973f, 0.07751870f, -0.09658157f, -0.25973183f, -0.09631659f, 0.07009108f, -0.03422052f, 
    0.06458442f, -0.04581593f, 0.10929211f, -0.05369138f, -0.02706087f, -0.06494562f, 0.07502279f, -0.06118907f, 
    0.11651554f, -0.03646548f, -0.04806831f, 0.03761859f, -0.15471196f, 0.04821770f, -0.12259032f, 0.12584850f, 
    -0.21318126f, -0.10303512f, 0.02555244f, -0.08483024f, -0.06030977f, 0.02296809f, 0.13185756f, -0.00550505f, 
    0.11527207f, -0.07612038f, 0.03110447f, -0.01770861f, -0.05222364f, 0.02303022f, 0.03576152f, 0.01786801f, 
    0.01340913f, -0.01031689f, 0.02950083f, 0.04477665f, 0.04747935f, -0.05544638f, 0.00435207f, -0.04957439f, 
    0.03472472f, 0.02066241f, 0.00771196f, -0.00678951f, -0.03828481f, -0.01543064f, -0.05354356f, -0.00195667f, 
    -0.01125856f, -0.00136265f, -0.02538158f, -0.01215648f, -0.03848371f, 0.03526996f, -0.00154147f, -0.06105000f, 
    -0.04162246f, 0.01265776f, -0.03948678f, -0.04558136f, -0.02836950f, 0.02626423f, -0.00276914f, 0.02990880f, 
    0.04133284f, 0.02909479f, -0.02688061f, -0.02323879f, 0.04599538f, -0.03985197f, 0.00852963f, 0.01374955f, 
    0.04430202f, -0.00607707f, 0.01454363f, -0.02233633f, 0.04745683f, 0.03881010f, -0.01935222f, -0.05347325f, 
    -0.00148101f, 0.04281445f, 0.01758021f, -0.01254445f, 0.03758124f, -0.02215064f, -0.02421935f, 0.00218226f, 
    0.00327876f, -0.04270814f, 0.04338037f, -0.02494616f, -0.00747664f, 0.03351324f, 0.01838071f, 0.00254308f, 
    0.03597347f, 0.00373192f, -0.05060513f, 0.00181940f, 0.03920562f, -0.04494848f, -0.04411163f, -0.02712983f, 
    0.03468791f, 0.00854605f, 0.04596089f, 0.05103272f, -0.00795054f, -0.00170182f, 0.00338066f, 0.03409800f, 
    -0.01710726f, -0.04819683f, -0.02560527f, 0.03416922f, 0.01238336f, 0.00256382f, 0.00348655f, -0.03469133f, 
    0.02686134f, -0.04813527f, 0.02879678f, -0.00226484f, -0.00170774f, -0.04274473f, 0.02502476f, 0.01541070f, 
    -0.01057426f, 0.03860351f, -0.04025060f, -0.05678749f, -0.01546513f, 0.01650995f, 0.00976257f, 0.00494994f, 
    0.04614310f, -0.03739290f, -0.02323563f, 0.00811443f, -0.02432587f, -0.03180414f, 0.02557944f, 0.01221587f, 
    -0.03515156f, 0.03380103f, 0.01765704f, -0.04988477f, -0.03296565f, -0.01016932f, -0.02674937f, -0.03259406f, 
    -0.04393625f, -0.03372509f, 0.03494554f, 0.02628759f, 0.04437030f, 0.04790457f, -0.02174855f, -0.05890710f, 
    -0.02007623f, 0.02585621f, -0.02113432f, -0.02670095f, 0.02549283f, 0.02840364f, -0.05364158f, 0.04048197f, 
    -0.05774648f, -0.04130685f, 0.03906699f, -0.02554556f, -0.04917342f, -0.01890724f, -0.04167858f, 0.01207573f, 
    -0.01483225f, -0.03696317f, 0.00554284f, -0.04584881f, -0.06081386f, 0.03030580f, -0.05814271f, -0.03427385f, 
    0.03220574f, -0.00725507f, 0.04727070f, 0.04186972f, -0.05245629f, -0.01981224f, -0.02177867f, 0.01441245f, 
    -0.02365408f, -0.01196519f, -0.06146144f, -0.04363002f, -0.04279884f, 0.03214392f, 0.01753936f, 0.00791888f, 
    0.02154506f, 0.01836532f, 0.01314310f, -0.03597405f, -0.03035926f, 0.04708396f, 0.01494906f, 0.02334425f, 
    0.04638001f, -0.05380163f, -0.05710341f, -0.04402935f, -0.01585619f, -0.03023835f, 0.03715314f, -0.02349377f, 
    -0.02823745f, -0.04513391f, -0.01788833f, -0.04023953f, -0.00772801f, 0.00080177f, 0.04762021f, 0.01534127f, 
    0.04981474f, -0.03412023f, -0.01924408f, -0.02885069f, 0.01231062f, -0.00066151f, 0.00338427f, 0.00135309f, 
    -0.03735713f, -0.02970988f, -0.05971166f, 0.02370415f, -0.03317007f, 0.03454639f, -0.02178762f, -0.01437385f, 
    0.00757290f, 0.01907628f, -0.05429680f, -0.01011721f, 0.04741757f, -0.00049511f, -0.05304586f, -0.03515078f, 
    0.02543190f, -0.00978815f, -0.02144937f, -0.00583488f, 0.04646186f, 0.03643971f, 0.02142665f, 0.03955204f, 
    0.01267895f, 0.00883234f, 0.02476490f, -0.04292465f, -0.04492332f, -0.03596163f, 0.01141841f, 0.04295259f, 
    -0.03668166f, -0.02729211f, -0.01211674f, -0.02032906f, 0.02557769f, 0.02476769f, -0.04647266f, -0.03582768f, 
    0.01369471f, -0.03515033f, -0.04968904f, -0.05791656f, -0.03367173f, -0.01130374f, 0.04376289f, 0.00666531f, 
    0.01265160f, -0.05033363f, -0.03531612f, 0.03967720f, -0.04853700f, 0.02463538f, 0.02816250f, -0.02623829f, 
    0.02573381f, -0.04720737f, -0.01592407f, -0.03251839f, -0.05377281f, -0.03893857f, -0.01407360f, -0.05477083f, 
    -0.00568935f, -0.01106537f, 0.03755340f, 0.00937268f, 0.00804409f, 0.01533043f, -0.05736714f, 0.04624753f, 
    0.01456166f, -0.04325379f, 0.02021649f, -0.05516715f, -0.03603862f, -0.03464298f, 0.01984522f, -0.05838497f, 
    0.02696304f, 0.04365627f, -0.02834802f, 0.02341590f, -0.04641270f, 0.02529539f, 0.00780219f, 0.01889648f, 
    -0.00229427f, -0.00136052f, -0.03209846f, -0.00986537f, -0.03563322f, -0.01018221f, 0.02078349f, -0.04311349f, 
    -0.04533865f, 0.00847540f, -0.00199493f, 0.00228559f, -0.00652948f, 0.00229061f, 0.00590054f, -0.04209422f, 
    -0.04543706f, -0.00413136f, -0.00891313f, -0.01903973f, 0.03777006f, 0.00181728f, -0.04753937f, 0.00165209f, 
    0.02710035f, -0.05914362f, -0.03894624f, -0.00825777f, -0.05684585f, 0.04370803f, 0.00233397f, 0.01355780f, 
    0.24988328f, -0.16814561f, 0.10925526f, -0.05050799f, 0.12449396f, 0.11741136f, 0.13455391f, -0.01126529f, 
    -0.04441098f, 0.07861755f, 0.03544385f, -0.04487513f, -0.00532196f, 0.12078130f, -0.02212444f, 0.01288606f, 
    -0.12424853f, 0.11574852f, -0.01405607f, 0.06081973f, 0.02307473f, 0.00128729f, 0.04465683f, -0.05695202f, 
    -0.06640138f, 0.01938595f, 0.09054781f, 0.02285190f, -0.15273249f, 0.01425560f, 0.04577018f, -0.08610114f, 
    0.02705847f, -0.02509843f, 0.02766691f, -0.07059498f, 0.09786984f, -0.00685958f, 0.08670234f, 0.18233335f, 
    -0.13998915f, -0.34766763f, 0.22504145f, -0.21745400f, -0.15603541f, -0.10995330f, -0.05088942f, 0.03942103f, 
    -0.05216889f, -0.01017766f, -0.07890143f, -0.23630500f, 0.03820327f, 0.09155062f, 0.03371359f, -0.07362583f, 
    -0.07867841f, -0.03170349f, 0.02094399f, 0.00610299f, -0.04369481f, 0.27476022f, 0.11203002f, 0.22646061f, 
    0.16817524f, -0.00064745f, 0.06005451f, -0.03570376f, -0.10427725f, -0.02647368f, 0.03499093f, -0.00572415f, 
    0.02537602f, 0.09769647f, -0.03252328f, 0.21906379f, 0.03692578f, 0.06971807f, 0.10815480f, -0.02366598f, 
    -0.09075890f, -0.03766375f, -0.11310610f, 0.12711716f, -0.02274677f, 0.08300626f, 0.02007157f, 0.10590260f, 
    -0.04379185f, 0.12662672f, -0.05836574f, -0.00497667f, 0.04982210f, -0.03566469f, 0.05578819f, 0.03006831f, 
    0.05661249f, -0.04900633f, 0.15408564f, 0.02129590f, -0.10091951f, -0.19055822f, -0.27210519f, 0.08533288f, 
    0.17950125f, -0.07185749f, -0.02297186f, -0.10561414f, -0.02981672f, 0.03476588f, 0.16927877f, -0.04530980f, 
    -0.05474222f, -0.10670098f, 0.05613386f, -0.05208883f, 0.10954981f, -0.04329037f, 0.15048204f, -0.04360428f, 
    0.12200283f, -0.06906480f, 0.10034785f, 0.11243755f, 0.05098688f, -0.03480755f, 0.22605255f, -0.00693466f, 
    0.08506691f, 0.01207083f, 0.02232095f, -0.07641262f, 0.04613730f, 0.12435240f, 0.02814279f, 0.03853492f, 
    -0.00223989f, 0.01138569f, -0.05109493f, 0.06751727f, -0.29467735f, -0.01011301f, 0.33778310f, -0.24352092f, 
    -0.54665726f, 0.06877080f, 0.00795818f, -0.05643197f, -0.06342503f, -0.01369737f, -0.08352014f, 0.02583369f, 
    0.03874677f, 0.01126784f, 0.07696494f, 0.06246400f, -0.00585240f, -0.11134297f, -0.08749507f, -0.01951931f, 
    0.22836588f, 0.03247074f, -0.23232605f, 0.03477874f, -0.09115538f, 0.02113170f, 0.00526125f, 0.04614800f, 
    -0.16181937f, 0.11321795f, 0.05396098f, -0.02287930f, -0.00997896f, 0.00342812f, 0.18583231f, 0.18169212f, 
    0.00084104f, 0.04475095f, 0.10232492f, -0.01895471f, -0.16784874f, -0.06314626f, -0.11608414f, -0.05020908f, 
    0.04768713f, 0.02935666f, -0.04544099f, -0.15493697f, 0.06383752f, 0.08469116f, 0.03674177f, -0.03391962f, 
    -0.00054151f, -0.08765234f, 0.02492454f, 0.01820552f, -0.08777432f, 0.06177982f, -0.01698156f, 0.00468252f, 
    -0.00039521f, -0.06375945f, -0.16842453f, 0.11020502f, -0.16629055f, 0.02488351f, -0.00047150f, 0.11427580f, 
    0.23528358f, -0.06315397f, 0.05668132f, 0.00460307f, 0.00247560f, 0.22369042f, 0.13205576f, 0.10572595f, 
    0.09128454f, 0.00151058f, 0.00485049f, 0.08039590f, 0.01115746f, 0.05696877f, -0.39121735f, -0.08705534f, 
    -0.05776633f, 0.12436058f, 0.05900798f, -0.18830997f, 0.00537119f, 0.21809046f, 0.06085165f, 0.12516230f, 
    -0.08036127f, 0.01054910f, 0.10238086f, 0.13167134f, 0.08706393f, -0.01986225f, 0.00207037f, -0.07812165f, 
    -0.35046563f, -0.03916693f, 0.31178206f, 0.12920986f, -0.07579880f, -0.04981013f, 0.11679311f, 0.03108256f, 
    -0.02961153f, 0.08119767f, -0.12018516f, -0.08250210f, 0.12113765f, 0.03900278f, 0.09231959f, -0.01228087f, 
    -0.00306123f, -0.04815618f, -0.03414539f, -0.16664594f, 0.45700905f, 0.03564360f, -0.09344766f, 0.07245599f, 
    0.04124131f, -0.08570582f, 0.09209227f, -0.11376855f, 0.04243189f, -0.07726664f, 0.16599932f, -0.08473103f, 
    0.08853304f, 0.04190885f, -0.07269381f, 0.02833713f, -0.00482730f, 0.04558564f, 0.08661678f, 0.07540841f, 
    -0.42716655f, -0.12683995f, -0.03566059f, -0.06739858f, 0.06860886f, 0.03440538f, -0.04565072f, 0.02383633f, 
    0.04713476f, 0.22478415f, 0.06531966f, 0.08272183f, 0.00653753f, -0.07410175f, 0.02131194f, 0.07724059f, 
    -0.02317092f, -0.09967334f, 0.00871200f, 0.05683313f, -0.30814636f, 0.30280960f, 0.24525006f, 0.03423261f, 
    0.12717283f, -0.01092392f, 0.13162220f, -0.00509406f, -0.06782268f, -0.03138093f, 0.05306390f, -0.04144491f, 
    -0.00573560f, -0.03427009f, 0.04512845f, 0.00741553f, -0.00600131f, 0.05422994f, 0.16815096f, 0.01992994f, 
    -0.06617343f, -0.05112954f, -0.21083117f, -0.25485113f, 0.23556322f, 0.09145845f, 0.09024792f, -0.07010858f, 
    -0.06193610f, -0.10418285f, -0.01545669f, -0.04078459f, 0.00700355f, 0.06953264f, -0.08147302f, 0.13954678f, 
    0.08892642f, 0.03265829f, -0.07361095f, 0.07106262f, 0.27889469f, -0.12052427f, 0.02655743f, -0.16062792f, 
    -0.23160669f, 0.02498839f, 0.11524104f, 0.00569089f, 0.03711160f, 0.01757803f, 0.05226798f, -0.02589398f, 
    0.10433727f, 0.09053378f, 0.00720827f, 0.05584898f, -0.01432251f, 0.11824650f, 0.11606228f, 0.09350368f, 
    -0.44947022f, -0.40610588f, 0.04489924f, 0.01830355f, 0.01940411f, 0.07682861f, 0.00529342f, 0.07381687f, 
    0.02547873f, -0.08873358f, 0.07153756f, -0.04390664f, -0.04374920f, 0.02336234f, 0.03949951f, 0.10835121f, 
    0.02977921f, -0.00466158f, 0.02141730f, -0.11592187f, -0.31590596f, -0.16188249f, -0.13680549f, -0.07699118f, 
    0.12716489f, 0.19237238f, 0.13192137f, 0.05047606f, -0.00776469f, -0.17665049f, 0.04568098f, 0.07802598f, 
    0.01960845f, 0.10072365f, -0.03508591f, -0.03711620f, 0.01626024f, 0.16329701f, -0.00038857f, -0.05675602f, 
    0.41047272f, -0.00336720f, 0.14274035f, -0.01898654f, 0.01322803f, -0.02918577f, -0.22019075f, 0.07728098f, 
    0.03123271f, 0.00767538f, -0.04512184f, -0.11778709f, -0.02826898f, 0.06760807f, -0.00558530f, 0.03745208f, 
    -0.01076666f, 0.08396854f, 0.00939377f, 0.07811507f, 0.56960028f, -0.11921967f, -0.14641526f, 0.00052204f, 
    0.15982498f, 0.03129746f, -0.12573448f, -0.09184203f, 0.05682620f, 0.04311512f, -0.00864893f, -0.07686264f, 
    0.04809117f, 0.08145842f, -0.05594463f, -0.11790799f, 0.09854019f, 0.03749232f, 0.02505828f, -0.06216690f, 
    0.40136328f, 0.05362381f, 0.12197038f, -0.07428875f, -0.11123934f, -0.06180582f, 0.14125647f, -0.00729717f, 
    -0.09452827f, 0.01819544f, 0.03639603f, -0.13055067f, -0.02551619f, -0.01376288f, 0.04758447f, 0.08120312f, 
    0.07303468f, -0.05984213f, 0.09588638f, 0.03522302f, 0.07400417f, 0.34299588f, 0.06770939f, -0.20704661f, 
    -0.47737390f, 0.15430780f, 0.12337749f, 0.02994564f, -0.03356908f, -0.08308078f, 0.06549609f, 0.14209156f, 
    0.02510153f, -0.03768305f, -0.10109372f, 0.08517199f, 0.08210785f, 0.04443123f, 0.08377989f, -0.12397254f, 
    0.30985838f, 0.15572307f, -0.14765470f, -0.04377564f, 0.05184199f, -0.11710872f, 0.01178659f, -0.06273161f, 
    -0.03958238f, 0.01272129f, 0.01864106f, 0.08719596f, 0.05485004f, 0.11064023f, 0.17275131f, 0.07660614f, 
    0.01149268f, 0.05262439f, 0.00538896f, 0.00173883f, 0.10433448f, 0.05604348f, -0.05070832f, -0.09746778f, 
    0.13550356f, 0.00145511f, 0.10965191f, 0.01381715f, 0.04965350f, 0.07160084f, -0.02278687f, 0.01433201f, 
    -0.00311161f, -0.03370884f, 0.02937507f, 0.02311626f, 0.03767093f, 0.07937882f, 0.13433068f, 0.05876453f, 
    -0.23921868f, 0.13564737f, 0.03131003f, -0.04643473f, -0.13955921f, -0.03413427f, 0.01725523f, -0.05016346f, 
    0.03371534f, -0.04995112f, 0.06378169f, 0.08899350f, -0.00077226f, 0.01689533f, 0.14392070f, 0.06830567f, 
    -0.05276695f, 0.03872547f, 0.02980683f, 0.05542773f, 0.51473087f, -0.07815012f, 0.05328561f, 0.05000873f, 
    -0.10636223f, -0.11367419f, -0.10694870f, 0.03237840f, 0.04930529f, 0.14785090f, -0.04020358f, -0.03234379f, 
    -0.03497037f, 0.02537248f, 0.00475457f, -0.00625671f, -0.08761017f, 0.00721204f, -0.07308900f, -0.09016112f, 
    -0.35363808f, -0.10706639f, 0.05070754f, -0.28299570f, -0.08044253f, -0.00432903f, 0.11073489f, 0.04597010f, 
    0.01630289f, 0.12706810f, 0.07893303f, 0.08875618f, -0.09230891f, -0.11207008f, -0.12810370f, 0.03949944f, 
    0.02569008f, 0.00552047f, -0.13816120f, -0.12168078f, 0.16113737f, -0.11055697f, -0.01584733f, -0.10038303f, 
    -0.10667509f, 0.00766091f, -0.09036458f, 0.03224564f, 0.11197619f, -0.02098573f, -0.01903086f, -0.00490006f, 
    0.16759431f, -0.01642155f, -0.06680212f, -0.06201641f, 0.02440199f, -0.07440979f, 0.11345793f, -0.01201001f, 
    -0.08820052f, 0.01482244f, -0.21273145f, 0.08687189f, 0.24030638f, 0.05885401f, -0.11867441f, -0.12284271f, 
    0.03590292f, 0.09134743f, 0.04246271f, 0.00303449f, -0.09449992f, 0.02507831f, -0.07012430f, 0.11675818f, 
    -0.09522440f, -0.11179382f, -0.04707252f, -0.04045566f, -0.51332408f, -0.23269631f, 0.10757837f, -0.03216873f, 
    0.00209059f, 0.01476827f, 0.21426500f, 0.13316029f, 0.03998499f, -0.03258792f, 0.07717074f, 0.00237980f, 
    -0.05413859f, -0.04306734f, -0.01759177f, 0.13056333f, -0.02173726f, 0.15131913f, 0.06265023f, -0.10235093f, 
    -0.03868283f, 0.00510265f, 0.01157005f, -0.04617194f, 0.04353236f, -0.02296599f, 0.00531798f, -0.03426942f, 
    0.02013889f, 0.01823115f, -0.01809156f, -0.04125188f, -0.00371654f, -0.04678925f, -0.04674520f, -0.01163243f, 
    -0.03289801f, -0.04706527f, -0.03869296f, -0.06112513f, -0.01641010f, -0.01510319f, -0.03995178f, -0.04341545f, 
    0.03555102f, -0.05508040f, -0.06141244f, -0.03099799f, 0.04576179f, -0.01860103f, 0.02305197f, 0.04866403f, 
    -0.05416407f, 0.00323443f, -0.05428077f, -0.04843740f, -0.00673668f, 0.02874337f, 0.02825698f, 0.00725771f, 
    0.00160799f, 0.02766293f, -0.01682183f, -0.04428151f, 0.02693080f, -0.03848646f, 0.04894391f, 0.03014741f, 
    0.03507160f, -0.03094022f, -0.01312822f, -0.06130104f, -0.01277565f, -0.01338905f, 0.01141738f, -0.00298231f, 
    0.02666656f, 0.01846937f, 0.03786066f, 0.04420288f, 0.02715935f, -0.02032762f, -0.01693957f, 0.01459405f, 
    0.01190256f, 0.02469266f, 0.00720952f, 0.00119724f, 0.03268342f, 0.03151133f, 0.00734258f, 0.01336767f, 
    0.04447920f, -0.05129176f, -0.00525937f, -0.03552056f, -0.01867535f, 0.00770515f, -0.03247459f, 0.01576778f, 
    0.04077723f, -0.01147502f, -0.05529043f, 0.04697052f, -0.02500758f, 0.04075198f, -0.01389671f, -0.02876564f, 
    -0.01302897f, -0.05464570f, -0.02106610f, -0.03728923f, -0.01819920f, 0.03675679f, -0.04334756f, 0.04944856f, 
    -0.05820182f, 0.03618820f, 0.02267480f, -0.03264665f, -0.02513110f, 0.01129601f, 0.02026207f, 0.02098630f, 
    0.05558533f, 0.03020968f, 0.01831392f, 0.00668209f, -0.01592691f, -0.03912234f, 0.04849117f, -0.01192964f, 
    0.01020280f, -0.00711741f, -0.05124207f, -0.03779026f, -0.04556796f, -0.01668884f, 0.01102944f, 0.04089599f, 
    -0.04988497f, -0.05852303f, -0.04794416f, -0.01793014f, 0.03659040f, -0.03409576f, -0.01752459f, 0.03711522f, 
    0.04312153f, 0.02454802f, 0.02105847f, 0.03071565f, -0.03514578f, 0.03179986f, 0.04393262f, -0.00094541f, 
    -0.01454578f, 0.00324338f, 0.02282444f, 0.00408085f, 0.03467187f, -0.04874987f, 0.02894064f, -0.04411716f, 
    0.04288092f, -0.04496378f, 0.02615615f, 0.01805702f, -0.02640416f, -0.00334249f, -0.03508580f, 0.03672789f, 
    0.04391892f, -0.05156955f, -0.06008486f, 0.02159989f, -0.05361922f, 0.02088232f, 0.04286084f, -0.00968481f, 
    0.03819418f, -0.02854973f, 0.01954103f, -0.03120433f, 0.01753842f, -0.05248994f, 0.01618084f, -0.00442690f, 
    -0.04560167f, 0.02547269f, -0.03207732f, -0.04157646f, -0.00517725f, 0.03975712f, -0.02077949f, -0.05558664f, 
    -0.03733456f, 0.01438710f, -0.03794464f, -0.05445038f, 0.00844196f, 0.03289647f, -0.05093132f, -0.04983805f, 
    0.03382216f, -0.05781777f, 0.04302103f, -0.02652539f, 0.04188892f, -0.02123863f, -0.00770017f, -0.04957991f, 
    -0.02132138f, -0.01957753f, -0.03431752f, -0.00320289f, 0.00473260f, -0.03578817f, 0.00856008f, -0.01254162f, 
    0.02585689f, -0.03009116f, 0.05567091f, 0.04092989f, -0.03501505f, 0.00510314f, -0.05102153f, 0.04971040f, 
    -0.05428198f, 0.04752377f, 0.03456544f, -0.05782294f, -0.04097010f, 0.01312489f, 0.00362656f, 0.00674726f, 
    -0.02857406f, -0.00419623f, 0.01398573f, -0.05730869f, -0.03635581f, -0.00170519f, -0.01960769f, 0.01389459f, 
    -0.04611869f, 0.03052985f, 0.00962527f, 0.02379429f, -0.01274540f, 0.00335412f, 0.01982040f, 0.04721794f, 
    -0.04509843f, 0.02287262f, -0.05764215f, 0.03641122f, -0.04705415f, 0.01245961f, -0.02277863f, -0.00418635f, 
    0.00463485f, 0.04465477f, -0.02962452f, -0.01268775f, -0.02282127f, -0.03965955f, -0.02227268f, 0.00584217f, 
    -0.04867776f, 0.01300450f, 0.03204723f, -0.06079361f, -0.06189023f, -0.01048947f, 0.02841152f, -0.04088935f, 
    0.02197900f, 0.04428747f, -0.05710148f, 0.02154107f, -0.00358714f, -0.03456165f, -0.03506148f, -0.01796202f, 
    0.01106535f, -0.00387763f, 0.03907054f, 0.02102548f, 0.03030222f, 0.04734213f, -0.05540653f, -0.01254033f, 
    0.04986439f, 0.02555892f, -0.01510094f, -0.02966498f, 0.00632538f, 0.01282765f, -0.02514868f, -0.05654358f, 
    -0.06066042f, 0.01026640f, -0.01391109f, -0.05171219f, 0.00105214f, -0.01580586f, 0.04644223f, 0.00107756f, 
    0.04063329f, -0.03117533f, -0.05709833f, -0.03879131f, 0.03952872f, 0.02654225f, -0.02475379f, -0.00434404f, 
    -0.01717426f, -0.01798775f, -0.05033814f, -0.04999798f, 0.02351353f, -0.01654533f, 0.01544854f, 0.04355341f, 
    -0.03964982f, 0.00897013f, 0.02482031f, -0.04491685f, 0.02535619f, -0.01267701f, -0.01136870f, -0.05390016f, 
    -0.03879287f, -0.00355888f, -0.01634498f, 0.04078230f, -0.05458483f, 0.04414890f, -0.03255175f, -0.03668912f, 
    -0.04407120f, 0.02886617f, -0.00688340f, 0.03955434f, 0.01896442f, -0.05902313f, -0.05160553f, 0.02197196f, 
    -0.05649488f, -0.04785375f, 0.03266226f, 0.01420298f, -0.04772522f, -0.04549281f, 0.01593302f, 0.00258900f, 
    0.00404989f, -0.00629927f, 0.01480473f, 0.04494432f, -0.05385630f, -0.05530385f, 0.00871049f, 0.04723682f, 
    0.02847025f, -0.00362173f, 0.00844901f, 0.04056548f, 0.00132435f, 0.03910903f, -0.01046040f, -0.02798728f, 
    -0.01877251f, 0.02768692f, 0.00450624f, 0.00120631f, -0.03398820f, -0.00716130f, -0.00764477f, -0.02237086f, 
    0.04231382f, 0.02437927f, -0.04007297f, -0.06218117f, 0.00805299f, -0.02328534f, -0.02222006f, 0.03103359f, 
    0.03628856f, 0.04722461f, -0.00268699f, 0.01398368f, 0.00848194f, -0.04073311f, 0.00239417f, 0.00971670f, 
    -0.04054666f, 0.01132098f, -0.02488442f, -0.04039555f, 0.03952967f, 0.05012167f, 0.02600892f, -0.04351802f, 
    -0.06321396f, -0.04674641f, -0.00081966f, -0.03240407f, 0.03270166f, -0.03203893f, 0.03293492f, -0.04038727f, 
    -0.03236060f, -0.00199886f, -0.03243206f, 0.04605731f, -0.02776376f, -0.04327722f, 0.01968815f, 0.04935896f, 
    0.02877820f, 0.04839847f, -0.05373630f, -0.04840716f, 0.04396071f, 0.01405597f, -0.02034132f, -0.06201910f, 
    -0.04188026f, -0.00913306f, 0.00665640f, -0.05750848f, -0.05916394f, 0.04068938f, 0.00951277f, -0.04249864f, 
    0.02925546f, 0.00095396f, -0.00170897f, 0.01538360f, -0.05686211f, -0.01118022f, -0.04080690f, -0.01945663f, 
    0.03656769f, -0.04739601f, -0.05256493f, -0.03691188f, -0.05112118f, 0.03339759f, -0.04630647f, -0.05798595f, 
    -0.05319390f, 0.02662453f, 0.02819810f, 0.04428256f, -0.00298787f, -0.01415385f, -0.04660463f, -0.04680319f, 
    0.00401784f, 0.02855250f, 0.03782164f, -0.06014045f, 0.01782043f, 0.03062172f, -0.00376958f, -0.02764331f, 
    -0.04022200f, -0.06071080f, 0.03274005f, -0.01045448f, 0.02919861f, -0.03572612f, -0.03579069f, -0.02563374f, 
    0.03773459f, 0.00795629f, 0.01702552f, 0.02860881f, -0.05177521f, 0.02643894f, -0.03273413f, -0.01052887f, 
    0.03931405f, -0.05038146f, 0.01635692f, -0.04177165f, 0.03936270f, -0.05257221f, -0.04886200f, -0.01128414f, 
    -0.00864433f, -0.01958068f, 0.03545452f, -0.05282448f, -0.01912174f, -0.05691591f, -0.03538511f, -0.02548930f, 
    -0.00922189f, -0.00958422f, 0.00151990f, -0.01324911f, 0.00633927f, -0.03744992f, -0.04327785f, 0.00996663f, 
    -0.04491534f, 0.01077185f, -0.01528181f, -0.00280595f, -0.04678548f, -0.04808521f, 0.03771918f, 0.03822657f, 
    -0.04105959f, -0.02939409f, -0.04657790f, -0.05087875f, -0.03667017f, 0.03334989f, -0.00549394f, 0.04100110f, 
    0.00303647f, 0.00280742f, 0.04645148f, -0.02586031f, 0.01503101f, -0.03059469f, -0.04665245f, 0.01081510f, 
    -0.06162908f, 0.01927846f, 0.01492998f, 0.02211165f, 0.00296806f, 0.00670853f, -0.00788974f, -0.01762585f, 
    0.01779222f, 0.04259797f, -0.03604234f, -0.00961610f, 0.00038050f, -0.00889030f, -0.00383486f, 0.01653299f, 
    -0.04715549f, -0.06327587f, 0.02354519f, -0.03847982f, -0.04166758f, 0.02519456f, -0.03876773f, -0.05237118f, 
    0.02412460f, 0.04175598f, -0.02520045f, 0.01305015f, 0.02790229f, 0.01956718f, -0.00502383f, -0.03169244f, 
    0.01464626f, 0.02141872f, -0.05750424f, -0.02067749f, -0.03909078f, -0.03019012f, 0.00610044f, -0.01271044f, 
    0.01762906f, 0.00583283f, 0.00361527f, -0.05521348f, 0.00892922f, -0.00744045f, 0.04929916f, -0.02445560f, 
    -0.02728576f, -0.01148470f, 0.02228104f, -0.05543184f, -0.05218070f, -0.05946605f, -0.03663705f, -0.00353568f, 
    -0.04466324f, -0.02909214f, -0.04568187f, -0.04322309f, 0.00586973f, -0.05631952f, -0.03823121f, 0.03629685f, 
    0.01331773f, -0.01483669f, -0.00270222f, -0.00045538f, -0.03339849f, 0.03369575f, 0.00005747f, 0.01687350f, 
    -0.03233171f, -0.04919659f, 0.04144481f, 0.01500288f, -0.00101059f, -0.02661794f, -0.04527645f, 0.04461413f, 
    0.04469758f, 0.03183660f, -0.04604519f, -0.05570578f, 0.02434785f, 0.02908460f, 0.00329406f, -0.05369118f, 
    0.00025313f, -0.03126812f, -0.06418298f, 0.04614770f, 0.04735979f, -0.02832653f, 0.02691303f, 0.04355106f, 
    -0.00621863f, -0.04768883f, -0.03722825f, -0.01947894f, -0.06023161f, -0.04917744f, 0.03113238f, -0.00686728f, 
    0.01372556f, -0.05275186f, -0.01794503f, -0.05867530f, 0.01907734f, -0.00110200f, -0.01011684f, 0.02091118f, 
    0.02282650f, -0.05106590f, -0.00586647f, -0.02500091f, -0.00445409f, -0.05356418f, -0.02521727f, 0.01633941f, 
    0.00224331f, -0.00108850f, -0.04117810f, -0.03227811f, -0.02851036f, 0.03590323f, 0.00433414f, 0.02797598f, 
    -0.29069003f, 0.05956663f, -0.08090705f, -0.17945604f, 0.15194102f, 0.01394772f, -0.09923051f, -0.11413252f, 
    0.12424140f, 0.01918855f, 0.05162117f, -0.08846711f, -0.07574489f, 0.03423468f, -0.05228901f, 0.09745217f, 
    0.02792237f, -0.02830009f, 0.04175694f, 0.05421078f, -0.13039640f, 0.09104313f, -0.07574157f, 0.23036481f, 
    -0.00456730f, 0.00500109f, 0.01236671f, 0.01269078f, 0.08236266f, 0.09732801f, 0.03846058f, 0.06778847f, 
    0.03096171f, -0.03323273f, -0.03083667f, -0.08842631f, 0.04200417f, 0.04331362f, -0.13057829f, 0.10841870f, 
    0.21131302f, -0.04872844f, 0.40811619f, -0.02497530f, 0.60532188f, 0.05470934f, 0.03244014f, -0.01014310f, 
    0.04735253f, -0.05396003f, -0.15018833f, -0.15334126f, -0.04384964f, 0.03297418f, 0.02370473f, 0.00945519f, 
    -0.11224978f, -0.11398900f, -0.09073739f, -0.01777316f, -0.19450177f, -0.06129556f, 0.04448093f, -0.20671022f, 
    0.04956912f, -0.12532969f, -0.09302868f, -0.00496205f, -0.01387345f, -0.00668612f, 0.06225712f, 0.05444803f, 
    0.00410272f, 0.06904856f, 0.11576734f, -0.07280919f, 0.02162070f, 0.08701798f, -0.07171396f, 0.08866569f, 
    0.27426907f, 0.11728265f, -0.20619747f, -0.08263276f, -0.31466052f, 0.01196312f, -0.10750652f, 0.09130812f, 
    -0.04339236f, 0.01882978f, -0.18058008f, -0.07812145f, 0.06947980f, 0.05073092f, -0.06196630f, 0.01162360f, 
    0.05693837f, 0.15374316f, -0.01654549f, -0.05227644f, -0.08141498f, 0.27520570f, 0.09566665f, -0.00128115f, 
    -0.12652032f, -0.08006772f, 0.14006492f, -0.04589585f, 0.09713391f, -0.14347343f, -0.00193156f, 0.07664362f, 
    -0.01778346f, 0.01952995f, -0.06824789f, 0.15170740f, -0.07407146f, -0.03798465f, -0.06348562f, -0.04687707f, 
    -0.00489267f, -0.14531417f, 0.14678428f, 0.14402866f, 0.11624076f, -0.01195978f, -0.09939813f, 0.12239133f, 
    0.04149545f, -0.02994686f, -0.06529837f, -0.08588412f, -0.02083416f, -0.03435541f, 0.06120699f, 0.06897155f, 
    -0.03210193f, 0.00782563f, -0.02241593f, 0.01939657f, 0.19766371f, 0.36078903f, -0.11590930f, 0.22611901f, 
    0.02929514f, 0.04316235f, -0.03257585f, 0.01151659f, 0.12945800f, 0.06424700f, -0.02182891f, -0.05657386f, 
    0.14580043f, -0.08985236f, 0.06711497f, 0.08726308f, 0.06746012f, -0.08442239f, 0.02677444f, 0.04672982f, 
    -0.25701478f, -0.00820131f, 0.05646385f, -0.03167391f, -0.30232549f, 0.04511460f, 0.12291787f, -0.01034096f, 
    -0.03323319f, -0.03229922f, 0.02690127f, -0.00482511f, -0.01043861f, 0.03242300f, 0.07764543f, -0.02152393f, 
    -0.00097712f, 0.10360956f, -0.03346947f, -0.00552288f, -0.48933733f, -0.10560759f, 0.37714309f, 0.12159067f, 
    -0.04867410f, -0.04004106f, 0.07094552f, 0.00257738f, -0.01425051f, 0.08587500f, 0.10458141f, 0.12339933f, 
    0.02750431f, -0.10047814f, 0.00618180f, -0.12574129f, 0.05498972f, 0.08364946f, -0.00314642f, 0.03242301f, 
    0.19552566f, -0.25532362f, 0.06692048f, 0.13319939f, 0.35034606f, 0.02850494f, 0.05917472f, 0.04381779f, 
    0.06542663f, 0.08986881f, -0.02514436f, -0.01866900f, 0.00268318f, 0.03677181f, -0.02842275f, -0.07314282f, 
    0.16510145f, -0.04390482f, 0.03619123f, -0.09554340f, 0.35260835f, 0.13999237f, -0.25334468f, -0.13997601f, 
    -0.41721964f, 0.08570626f, 0.03784127f, -0.02590561f, 0.02637856f, -0.13922219f, -0.08600371f, 0.13653414f, 
    -0.08166031f, -0.15578577f, -0.07469433f, -0.02545012f, 0.09729569f, -0.03609934f, -0.08208243f, 0.00207186f, 
    0.22480607f, -0.06127115f, -0.17686494f, -0.06949847f, 0.14722541f, -0.05456527f, -0.15687032f, 0.05287712f, 
    -0.00246739f, 0.02723238f, 0.03044191f, -0.14932154f, -0.00329452f, 0.13431309f, -0.04134911f, 0.17026071f, 
    0.01030656f, -0.04559309f, 0.01111649f, -0.00072685f, 0.31893650f, -0.18315797f, -0.13469316f, 0.02041827f, 
    -0.10298747f, -0.00497649f, 0.16358888f, -0.03476942f, -0.01890553f, 0.01041171f, 0.01293165f, 0.07205023f, 
    0.02570265f, -0.06721394f, -0.02716306f, 0.01671023f, 0.03050412f, -0.00319485f, -0.05084609f, 0.00699460f, 
    0.07703217f, 0.23127742f, -0.08350725f, 0.38654143f, 0.33777922f, 0.07530811f, -0.11006822f, 0.16812502f, 
    0.00953014f, -0.09692045f, -0.02407251f, 0.02273499f, -0.05698979f, -0.06626844f, -0.00140133f, 0.02809488f, 
    -0.01331830f, -0.02001885f, 0.10159568f, 0.02419056f, -0.10926460f, -0.11375657f, -0.08199914f, -0.08241882f, 
    0.23299348f, -0.17781936f, -0.11867731f, -0.00583649f, 0.05188759f, -0.06620256f, -0.12185508f, -0.02430146f, 
    -0.05060661f, 0.13111939f, -0.10288674f, 0.03673494f, 0.05990115f, -0.06573249f, 0.06435082f, -0.01549162f, 
    0.36066112f, -0.03811343f, 0.00247559f, 0.06386465f, -0.04150573f, -0.04245155f, 0.10337906f, -0.06890967f, 
    -0.06177258f, 0.05032432f, -0.05271336f, -0.03017549f, -0.01145954f, -0.01969534f, 0.05749242f, 0.01992914f, 
    0.03275419f, -0.03964564f, -0.06458366f, 0.01475898f, -0.09579726f, 0.10526104f, 0.12684239f, -0.37143779f, 
    -0.02393595f, 0.11550533f, -0.05019123f, 0.03593866f, -0.03298465f, 0.00785792f, -0.00046004f, 0.06371245f, 
    -0.16770537f, 0.02033994f, 0.02061145f, 0.09869419f, 0.05167548f, -0.03349803f, 0.04457205f, 0.02669175f, 
    -0.28678036f, 0.18646567f, -0.34736636f, 0.15031828f, -0.14216708f, -0.11404534f, -0.15353690f, -0.03506255f, 
    -0.04415825f, -0.13062052f, 0.11606777f, 0.06561888f, 0.04845261f, -0.03343278f, 0.09845883f, -0.04238535f, 
    0.05876517f, 0.11931296f, 0.15077364f, 0.03513816f, 0.46722561f, 0.12889406f, 0.28530911f, -0.05520656f, 
    0.11070728f, -0.00527534f, 0.15461425f, -0.00965985f, -0.09617611f, 0.07188737f, 0.02870922f, 0.04862113f, 
    -0.02350411f, -0.07868304f, -0.05375983f, 0.04668366f, -0.05281000f, -0.08140835f, 0.04306863f, 0.05410505f, 
    -0.25129962f, -0.12606116f, -0.11615806f, 0.16555998f, -0.01949574f, 0.22664090f, 0.02880150f, 0.06272753f, 
    0.06665038f, 0.12207988f, 0.00869959f, -0.09248809f, -0.09015069f, -0.01511854f, 0.04677878f, 0.06606848f, 
    0.01846714f, -0.02904729f, 0.12352823f, 0.02927652f, -0.33282933f, -0.13524954f, -0.15612590f, -0.19569874f, 
    0.14558524f, 0.12798278f, 0.08673653f, 0.02338354f, -0.00564067f, -0.01010423f, 0.01351670f, 0.07335865f, 
    0.02070323f, 0.11763167f, -0.02279156f, -0.01655046f, 0.02907264f, 0.08374428f, 0.02479250f, -0.07643522f, 
    -0.28158814f, -0.16141848f, -0.30759889f, 0.08210512f, 0.15072402f, 0.18077689f, -0.10537157f, -0.07381073f, 
    0.07034803f, 0.02738496f, -0.02741875f, 0.09428844f, -0.10069820f, -0.04441262f, -0.05529037f, 0.09184305f, 
    -0.04193197f, 0.03123854f, 0.10910875f, 0.02466527f, -0.03984328f, -0.36522314f, 0.25683722f, -0.03651462f, 
    -0.01763406f, -0.06088895f, -0.11980125f, -0.07163940f, -0.08396105f, -0.03545212f, 0.14329267f, 0.04776090f, 
    0.00467277f, 0.02951758f, 0.09996246f, -0.05493635f, 0.02935105f, -0.02771320f, 0.10710581f, 0.09572947f, 
    -0.02195797f, 0.40228286f, -0.48891774f, -0.05215447f, 0.07887449f, 0.17399855f, 0.16088007f, 0.01287071f, 
    0.13855802f, 0.11707106f, 0.02604904f, 0.08869343f, 0.01211701f, 0.14150661f, 0.02121536f, -0.06465529f, 
    0.10957807f, -0.10763329f, 0.01685650f, -0.01785536f, -0.02562900f, 0.57483345f, -0.12365704f, -0.42735571f, 
    0.07202362f, 0.01653795f, 0.06779093f, 0.05444767f, 0.02473795f, 0.14027204f, -0.02078477f, -0.01342577f, 
    0.03339510f, 0.07849638f, -0.04857089f, 0.04657908f, 0.00096226f, -0.02612230f, -0.05893097f, 0.05068565f, 
    0.01112498f, -0.00741245f, 0.11498200f, -0.14582729f, -0.10348155f, -0.10645241f, -0.08453970f, -0.02537782f, 
    0.06491141f, -0.06890411f, 0.02211981f, 0.07791454f, 0.02813016f, 0.13199559f, -0.04611337f, 0.02863894f, 
    -0.01572486f, 0.15171172f, 0.06944582f, 0.04864074f, -0.55813521f, -0.19126320f, -0.00494194f, 0.21777667f, 
    -0.07301038f, 0.11764402f, 0.06280897f, 0.00999905f, 0.04446825f, 0.13818885f, -0.05113560f, -0.18446575f, 
    -0.00573823f, 0.05703270f, -0.03794739f, 0.00801436f, 0.01844008f, 0.12809663f, 0.11867832f, -0.09389941f, 
    0.23654521f, 0.17924190f, 0.41325018f, 0.05662688f, 0.07953429f, -0.22892076f, 0.00459780f, -0.23726465f, 
    -0.12720743f, -0.08927970f, -0.05360967f, -0.02998482f, 0.05888186f, 0.04371023f, 0.11208019f, -0.06240544f, 
    0.04891908f, -0.06759035f, -0.06478137f, 0.22477518f, -0.06383854f, 0.12506892f, -0.04555254f, 0.04296126f, 
    -0.19923818f, 0.18017976f, 0.00978345f, 0.10671201f, 0.05473274f, 0.24800698f, 0.15037839f, 0.03644737f, 
    -0.06068753f, 0.16099672f, 0.01411816f, 0.11592774f, 0.05330003f, -0.07353279f, 0.04009065f, -0.00062263f, 
    -0.34665847f, -0.21630657f, 0.06580839f, -0.34289092f, -0.24316990f, -0.01479433f, -0.03721831f, 0.01882763f, 
    -0.02952095f, 0.06336609f, 0.16130853f, 0.00900097f, 0.00758689f, 0.06121098f, -0.00139260f, -0.02811816f, 
    0.08369030f, 0.10551137f, -0.11439725f, -0.03420204f, 0.17956455f, 0.18639152f, 0.41701940f, -0.13255234f, 
    -0.05178886f, 0.23935191f, -0.00521223f, 0.08962373f, -0.07456681f, -0.00983628f, 0.00272273f, 0.02230814f, 
    0.01624653f, 0.02573151f, 0.06863627f, 0.09984351f, 0.05131770f, -0.06985450f, -0.01495398f, 0.07973146f, 
    -0.05995993f, 0.00476303f, 0.02526510f, -0.03573035f, -0.03734089f, -0.00580315f, 0.03445207f, 0.04383714f, 
    -0.03291569f, -0.03769615f, -0.03215500f, 0.02014741f, -0.02586167f, -0.04831631f, 0.01146963f, -0.04755662f, 
    0.00429110f, 0.00060502f, -0.04914661f, -0.00386104f, 0.03708452f, -0.03693201f, -0.00967971f, 0.01418287f, 
    0.01390882f, -0.03416992f, 0.01230535f, 0.00753260f, 0.01461981f, -0.00440344f, -0.05074139f, -0.05638489f, 
    -0.01008531f, -0.01219727f, 0.01599712f, 0.01856368f, -0.04494059f, 0.03693383f, -0.04357651f, 0.04464305f, 
    0.03554223f, -0.00755095f, -0.00403844f, 0.04231553f, 0.02097145f, -0.05238573f, -0.05370185f, -0.02947628f, 
    -0.02242104f, -0.04720044f, 0.04435402f, 0.03361615f, 0.03800849f, 0.02254729f, 0.01081851f, 0.00316549f, 
    -0.05886280f, -0.02602842f, 0.01342757f, 0.00162065f, 0.04477612f, -0.02515520f, 0.02060350f, 0.02645914f, 
    -0.03363566f, -0.02212129f, 0.04291444f, 0.00748678f, 0.03589321f, -0.04221098f, 0.00291989f, 0.02912225f, 
    -0.06208605f, -0.04540935f, -0.04794849f, -0.00606861f, -0.03946384f, 0.03573438f, 0.04293966f, -0.02410168f, 
    -0.04298433f, 0.02944980f, 0.00313934f, 0.04524361f, -0.05078176f, -0.01202195f, 0.04052182f, 0.01021855f, 
    -0.03071924f, -0.03209843f, -0.05055204f, 0.05160898f, -0.04906322f, -0.00678976f, 0.02346203f, -0.01330482f, 
    0.03927135f, -0.05832550f, -0.00633166f, 0.00801380f, -0.00875051f, 0.04271053f, 0.02433648f, -0.04392046f, 
    0.04773691f, -0.05788429f, -0.06441082f, 0.03847697f, 0.03691263f, -0.04983762f, -0.03640043f, -0.02372608f, 
    -0.06094093f, -0.00110677f, 0.02610008f, 0.03480931f, -0.02813007f, 0.00666440f, -0.03568302f, -0.00647438f, 
    0.01054840f, 0.04731311f, 0.01383812f, -0.05863605f, 0.03749443f, 0.01317627f, -0.03431066f, 0.00811043f, 
    -0.00887254f, -0.04113603f, -0.00577342f, 0.02180761f, -0.05491802f, 0.02382700f, 0.04804826f, -0.02977958f, 
    -0.02286362f, -0.04969005f, -0.00091038f, -0.03389686f, -0.04575427f, 0.05578263f, -0.00756768f, -0.02415074f, 
    -0.00471253f, 0.02276035f, 0.03998866f, 0.00202959f, 0.02996913f, 0.03069968f, -0.00928836f, -0.05565542f, 
    -0.03381825f, 0.01822832f, 0.00003285f, -0.00809745f, 0.04163440f, -0.00009061f, -0.04271387f, 0.04501415f, 
    -0.03885874f, -0.04755459f, -0.02584616f, 0.04525020f, 0.04441040f, 0.01841539f, -0.03311057f, 0.04974483f, 
    -0.02827057f, 0.02742107f, -0.04017483f, -0.04638978f, 0.03698292f, -0.02559826f, -0.01716981f, 0.01405595f, 
    0.00726064f, 0.02420034f, -0.05976828f, 0.02076155f, 0.02488025f, 0.02015919f, -0.02559634f, 0.01803143f, 
    -0.01687081f, -0.04584881f, -0.05558910f, 0.03120689f, 0.04855723f, -0.00524938f, 0.03617927f, 0.00063186f, 
    -0.02399338f, -0.03990877f, -0.04644780f, -0.03719378f, -0.02526578f, 0.03346926f, 0.02944964f, -0.02235706f, 
    0.05426887f, 0.01324261f, 0.02231608f, -0.01669524f, -0.00795380f, 0.05031284f, 0.04634172f, 0.00501101f, 
    -0.00972616f, -0.05363983f, 0.02954214f, 0.02923753f, 0.02324732f, -0.00461408f, -0.01191644f, -0.03591736f, 
    -0.01839201f, -0.04769225f, 0.01207207f, -0.00706540f, -0.02383668f, -0.04352584f, -0.05396841f, 0.01839848f, 
    0.02389842f, -0.00152853f, 0.02587806f, 0.00084352f, 0.01514585f, 0.02312917f, 0.03742466f, -0.03141091f, 
    -0.00010385f, -0.05691846f, -0.06179085f, -0.01315525f, 0.02486927f, 0.04205093f, -0.04191082f, 0.02088074f, 
    0.03571816f, -0.04699791f, 0.02780151f, 0.01007258f, -0.05038994f, 0.00707196f, -0.02889705f, -0.02136430f, 
    -0.03303662f, -0.03218516f, -0.04741153f, -0.01289836f, -0.01439622f, 0.03465505f, -0.05062889f, 0.01642850f, 
    0.04455958f, -0.02808602f, 0.03393053f, 0.01237609f, 0.00952248f, -0.01093956f, -0.04802318f, -0.02124432f, 
    -0.02466217f, -0.00402560f, -0.00572772f, 0.02099801f, -0.00612740f, -0.05160588f, 0.03456743f, 0.02228915f, 
    0.01173496f, 0.02970113f, 0.02457989f, 0.02571042f, -0.05862410f, -0.01092860f, -0.00212310f, -0.06376720f, 
    -0.02308046f, -0.01763585f, 0.03527476f, -0.00376824f, 0.02749608f, 0.04574668f, 0.03302564f, -0.04132649f, 
    -0.05651789f, -0.05157354f, 0.04103980f, -0.01619551f, -0.01804834f, 0.00856330f, -0.03756379f, -0.05833129f, 
    -0.00638370f, 0.02364048f, -0.02906043f, -0.04252483f, 0.03307382f, -0.05918617f, -0.04573459f, -0.02633170f, 
    -0.00601786f, -0.01694340f, 0.01995138f, -0.00719455f, -0.04496670f, 0.00721675f, 0.01428397f, 0.00109607f, 
    -0.05210821f, -0.02958271f, 0.01772491f, 0.04395835f, 0.01697742f, -0.02421560f, -0.04008897f, 0.02274188f, 
    0.06243769f, -0.22972643f, -0.14979719f, -0.09910339f, 0.14187431f, 0.08241061f, 0.05273375f, -0.12416069f, 
    0.01031409f, 0.02686071f, 0.00235061f, -0.09575609f, -0.01099932f, 0.06887764f, -0.01059788f, 0.09682168f, 
    0.04790520f, 0.02250002f, -0.20898619f, 0.10911754f, 0.32279724f, -0.19809027f, -0.00592645f, -0.11410160f, 
    -0.03217058f, -0.01673946f, 0.15321466f, 0.04623056f, 0.08393960f, -0.03504946f, 0.11749101f, -0.06263904f, 
    -0.08487025f, 0.12245797f, 0.07036027f, -0.04252669f, 0.07290266f, 0.02570068f, 0.11883426f, 0.10268615f, 
    -0.19509421f, 0.26789436f, 0.08662056f, -0.10181718f, 0.21386823f, 0.05415760f, 0.03876931f, 0.07999942f, 
    0.05135222f, -0.11313555f, 0.04252593f, 0.08958840f, -0.05790647f, -0.00135053f, 0.03550538f, -0.06034008f, 
    0.01364516f, 0.00452625f, -0.05810636f, -0.05203519f, 0.15996338f, 0.01455998f, -0.01024379f, -0.10183034f, 
    0.10990187f, 0.10740396f, 0.01543783f, 0.04573741f, -0.11509576f, -0.09436931f, -0.02856327f, 0.01534102f, 
    -0.12429231f, 0.06392534f, -0.01253020f, -0.07965608f, -0.00183563f, 0.11262177f, -0.05865461f, 0.01951268f, 
    0.45118323f, 0.07315651f, 0.30208591f, 0.31609988f, 0.00008488f, 0.00142904f, -0.10764850f, 0.14907239f, 
    -0.01731365f, 0.02561428f, -0.03281524f, -0.03987344f, -0.06335843f, -0.01385173f, -0.10204589f, -0.07612606f, 
    0.03710553f, 0.03842194f, -0.04285006f, -0.04068955f, 0.07931269f, 0.20894970f, 0.06677122f, 0.07870966f, 
    0.12890594f, 0.03035549f, -0.05258682f, -0.23610426f, -0.02156816f, 0.02425327f, -0.04129151f, 0.06152653f, 
    0.06479956f, 0.02060024f, -0.04566370f, 0.02930105f, 0.10931277f, -0.08586787f, 0.03967150f, -0.11202114f, 
    0.40861940f, -0.01325352f, 0.27858379f, -0.15524225f, -0.08278479f, -0.10423707f, 0.04491872f, 0.03416932f, 
    -0.06822623f, -0.07433040f, -0.04113846f, 0.10165665f, 0.00052918f, 0.03080104f, -0.00888802f, 0.10279125f, 
    -0.02179375f, 0.11551014f, -0.00765829f, 0.08301369f, 0.11564439f, -0.00535679f, -0.27244610f, -0.19230999f, 
    0.03255055f, 0.10065292f, -0.03851301f, -0.12320755f, 0.01712609f, -0.18182456f, 0.02632235f, 0.11679443f, 
    0.07091067f, -0.01074826f, -0.09512565f, 0.04511658f, 0.06713704f, -0.04715240f, -0.06408589f, -0.05513150f, 
    0.04204809f, 0.19643377f, 0.20330282f, 0.12506744f, 0.14834711f, 0.01477400f, -0.08472744f, 0.01637385f, 
    -0.12175143f, -0.04545745f, 0.04664394f, 0.06306288f, 0.09665731f, 0.03537710f, -0.00935316f, -0.00714857f, 
    -0.08587854f, 0.07643287f, 0.05646174f, 0.10392517f, 0.07394385f, 0.13100842f, 0.01253139f, -0.07608037f, 
    0.08233146f, -0.00185873f, 0.08559065f, 0.08567089f, -0.13236670f, 0.02736157f, 0.05009263f, 0.02216712f, 
    -0.12274545f, -0.06263810f, 0.06194598f, 0.08129968f, -0.03400397f, 0.07850805f, 0.04180536f, 0.16078675f, 
    0.23599845f, 0.23281039f, -0.22394052f, -0.20258868f, 0.03945542f, -0.04064368f, -0.01392840f, -0.11880804f, 
    -0.04844437f, 0.06811286f, 0.03005609f, 0.11775418f, -0.01857837f, -0.09379380f, 0.07087496f, -0.07561231f, 
    -0.18544531f, -0.01031492f, 0.06877972f, -0.00982978f, 0.51468962f, 0.18088053f, 0.33663794f, 0.20654134f, 
    -0.06811165f, -0.02348568f, 0.07779343f, 0.02125378f, -0.00566337f, 0.08506566f, -0.03347498f, 0.01126086f, 
    -0.10767430f, -0.04292472f, -0.08992282f, -0.05666389f, 0.03807404f, -0.03985506f, 0.00225671f, -0.15080076f, 
    -0.16975808f, -0.09917667f, -0.20760658f, -0.26052669f, 0.35935241f, 0.00410999f, -0.11552566f, -0.04019496f, 
    -0.02442113f, -0.11623187f, 0.01852535f, 0.05306209f, 0.05531641f, 0.05065133f, -0.03151292f, 0.07376429f, 
    0.00756369f, -0.03475960f, -0.04929313f, -0.00042400f, 0.21261129f, -0.02426079f, 0.07873636f, -0.03783638f, 
    -0.15428662f, -0.01191586f, -0.03993964f, 0.09397557f, 0.04168271f, 0.01722078f, 0.09744085f, 0.16434433f, 
    0.02206253f, -0.09364073f, -0.09287644f, -0.11452825f, 0.15366685f, -0.04273040f, 0.12922703f, -0.02473180f, 
    -0.31475854f, -0.03245408f, -0.19935781f, 0.19141884f, 0.03691423f, 0.23770325f, -0.16737480f, -0.03080079f, 
    0.02079500f, 0.05988130f, 0.14672869f, -0.02034638f, -0.00708087f, 0.01332703f, -0.01018651f, 0.04394723f, 
    -0.06026889f, -0.03142187f, 0.06130064f, -0.01240514f, 0.00956553f, 0.02943698f, 0.07670046f, -0.17838164f, 
    0.04753250f, 0.02392955f, -0.00102748f, -0.06110963f, -0.01924017f, -0.12073059f, -0.05859686f, 0.05156167f, 
    -0.07896699f, -0.09177749f, 0.01469293f, 0.07814121f, 0.03551513f, -0.13036060f, 0.19297788f, -0.09159271f, 
    -0.00691290f, -0.01605594f, 0.02546773f, 0.02631751f, -0.04394557f, -0.03907932f, 0.00557048f, -0.04884411f, 
    0.03399240f, 0.01782505f, -0.00466435f, -0.00421427f, 0.01342713f, -0.04067305f, 0.00395709f, -0.03727644f, 
    -0.01708811f, -0.01068931f, 0.02395231f, -0.01909662f, 0.02392849f, 0.00825777f, -0.04460146f, -0.03937775f, 
    0.04549530f, 0.02649998f, -0.05631926f, 0.03965249f, 0.00118135f, 0.00419216f, 0.03884379f, 0.02052450f, 
    -0.05996229f, 0.01430188f, -0.05726064f, -0.04332375f, -0.02991869f, 0.01806119f, -0.03136799f, -0.02345590f, 
    0.03410091f, 0.02780340f, 0.01632945f, -0.03783089f, -0.01669708f, -0.00984595f, -0.04564010f, 0.03722552f, 
    -0.00597506f, -0.02255771f, 0.02879645f, 0.00163823f, -0.00683006f, 0.04793664f, 0.00652092f, -0.04068893f, 
    -0.05669777f, 0.05153311f, -0.00054736f, -0.05316811f, -0.00357188f, -0.01544019f, -0.00374786f, 0.00544726f, 
    -0.02996638f, 0.04437687f, 0.04893756f, -0.04935204f, 0.02385692f, -0.00267941f, -0.01648682f, -0.03124254f, 
    -0.02479146f, 0.02127245f, 0.04514449f, 0.01416542f, -0.03086425f, -0.01180127f, -0.01723334f, 0.02879034f, 
    0.04350182f, -0.03309565f, -0.05991429f, -0.01353494f, -0.05722101f, -0.00725007f, -0.04418275f, 0.02042263f, 
    0.02446333f, 0.02636604f, -0.05711998f, -0.03826300f, -0.02552305f, -0.01278639f, -0.02203316f, -0.05051797f, 
    0.02689124f, -0.03458323f, 0.01864634f, -0.00607886f, -0.01858480f, -0.00544247f, -0.00058354f, -0.05686928f, 
    -0.03673401f, 0.04728282f, 0.02482220f, -0.06108566f, -0.01671522f, 0.00747639f, -0.04984133f, 0.03971278f, 
    0.04203913f, -0.01993932f, 0.04646289f, -0.00094115f, 0.02441090f, -0.06061968f, -0.06038425f, -0.05317543f, 
    -0.00170090f, -0.00304789f, 0.03160876f, 0.02384387f, -0.03638514f, 0.04964424f, -0.05707802f, 0.04791987f, 
    -0.04481479f, -0.02701127f, 0.00288949f, -0.01827466f, 0.04337447f, 0.03052530f, -0.03485352f, 0.01792107f, 
    -0.01719560f, -0.02306307f, 0.01318423f, 0.04387698f, 0.01942667f, -0.04434413f, -0.00944760f, 0.02639538f, 
    -0.00149761f, -0.01966043f, -0.00214802f, -0.04609549f, -0.01827723f, 0.00881350f, 0.00572673f, -0.01827139f, 
    0.03775746f, 0.00902111f, 0.01176611f, -0.00677691f, -0.04889247f, 0.04684752f, -0.06099644f, -0.02326415f, 
    0.02474212f, -0.02172009f, 0.04307216f, -0.00397486f, -0.01713498f, -0.03949496f, -0.00766194f, -0.05051521f, 
    0.03055788f, -0.00247458f, 0.03276794f, -0.05439471f, -0.05209198f, 0.03253083f, -0.05400234f, -0.05526383f, 
    0.03545064f, 0.01177938f, 0.03126318f, -0.01733474f, -0.04069575f, 0.00868013f, 0.04787943f, -0.00617560f, 
    0.01379971f, 0.00746567f, -0.04806218f, -0.03214290f, 0.03786877f, 0.03614487f, -0.04341482f, 0.03110761f, 
    0.00435205f, 0.03048257f, -0.00950763f, -0.01067593f, -0.05015529f, -0.04737090f, -0.02569936f, -0.00783004f, 
    -0.00036991f, -0.03149645f, -0.00828150f, -0.04453183f, -0.00935895f, -0.00590366f, 0.02688438f, -0.04932008f, 
    -0.00575170f, 0.03631387f, 0.01055914f, -0.06021311f, -0.02783632f, -0.02729566f, -0.05699569f, -0.03024933f, 
    0.03684396f, -0.03496589f, 0.02993578f, 0.00714616f, -0.01291386f, 0.01904798f, -0.00858310f, -0.05694633f, 
    -0.01966385f, -0.01311246f, 0.05002340f, 0.04693530f, 0.01241998f, -0.00254811f, 0.00046369f, -0.01908647f, 
    0.01248907f, -0.05358976f, 0.02043629f, -0.03963391f, 0.03649826f, 0.01958846f, -0.05045539f, -0.05580746f, 
    -0.00769781f, -0.02084528f, -0.03979586f, 0.00501880f, 0.03552775f, -0.00468571f, -0.01432804f, -0.05432636f, 
    -0.04141331f, -0.02393185f, -0.02985221f, -0.02319685f, 0.00576125f, -0.01409115f, -0.00990895f, -0.02873070f, 
    -0.00900381f, -0.03183862f, 0.04064293f, 0.04083170f, -0.02713061f, -0.01133374f, -0.02412012f, 0.04004924f, 
    0.00170003f, -0.02711671f, -0.04738617f, 0.00235903f, 0.01054842f, -0.04922347f, 0.05034127f, 0.00058948f, 
    0.03633111f, -0.00213559f, -0.04752675f, -0.04925778f, -0.04518640f, 0.03013013f, 0.02964539f, 0.02928702f, 
    -0.02273518f, 0.00998067f, 0.02493738f, 0.04626187f, -0.02301463f, -0.03799212f, -0.01678054f, 0.03536307f, 
    -0.01351561f, -0.00264355f, -0.02594332f, 0.00536664f, -0.04724434f, -0.02817505f, 0.00234246f, -0.02007260f, 
    -0.01116191f, -0.03367434f, -0.04906264f, 0.01849165f, -0.01772251f, -0.05502954f, -0.03492038f, -0.02529796f, 
    -0.02336938f, 0.02764193f, -0.04438404f, -0.01567801f, -0.03607173f, 0.03617804f, -0.02288548f, -0.04615160f, 
    -0.05441570f, 0.01777802f, -0.03529787f, 0.04008529f, 0.01484297f, -0.00887591f, -0.03904388f, -0.02419942f, 
    -0.19790454f, 0.09561450f, 0.03254855f, 0.01074826f, 0.06997859f, 0.02114109f, 0.13935006f, 0.11269701f, 
    0.10168663f, 0.00021435f, 0.05336739f, 0.09543709f, 0.09504368f, 0.00041444f, 0.03012829f, 0.07698651f, 
    -0.02252059f, -0.02723325f, 0.03509257f, 0.11235720f, -0.13767257f, 0.25821719f, -0.00075871f, -0.16089725f, 
    -0.03996959f, 0.15568502f, -0.08459029f, -0.06829322f, 0.07410879f, -0.01944984f, 0.00564074f, 0.03907656f, 
    -0.02181936f, -0.03636036f, 0.08627023f, 0.11048122f, 0.01005673f, 0.05174126f, 0.13952707f, 0.01978333f, 
    -0.02792532f, 0.18077080f, -0.06147726f, 0.28363037f, -0.00806938f, -0.09936175f, -0.19908614f, 0.12863843f, 
    -0.12585849f, -0.01271373f, 0.10247952f, 0.09663123f, 0.00592210f, 0.06164391f, 0.12495875f, -0.00420542f, 
    0.13316119f, 0.10147621f, 0.06703976f, 0.13885227f, 0.00328910f, -0.58854443f, -0.13368252f, 0.00413757f, 
    -0.14248700f, 0.06530490f, 0.17560388f, 0.03335809f, 0.00814970f, 0.13200535f, -0.04276486f, 0.07787216f, 
    -0.02365734f, -0.01909767f, 0.01712572f, 0.16142583f, -0.01055993f, -0.07635454f, 0.07140347f, -0.06890662f, 
    0.21497446f, 0.05323984f, -0.16066159f, 0.09681253f, -0.14683557f, 0.01458800f, -0.18962033f, -0.07852193f, 
    0.03589952f, 0.03897363f, -0.00453031f, -0.03217992f, 0.07526959f, -0.01394596f, 0.03375139f, 0.08044486f, 
    -0.15230715f, 0.03881467f, 0.08014639f, -0.03375970f, -0.42467162f, -0.27885994f, -0.32478893f, 0.01584398f, 
    0.09826165f, 0.00013568f, -0.13353917f, 0.06868815f, 0.04043045f, -0.03414010f, -0.24486719f, -0.06960100f, 
    0.02452170f, 0.00065139f, 0.03668126f, -0.17973696f, -0.03648140f, 0.04542121f, -0.04556644f, 0.07156649f, 
    -0.17466331f, 0.20241222f, -0.13821489f, 0.11872666f, 0.10303032f, 0.12234354f, -0.09971157f, -0.11121345f, 
    0.05263063f, 0.03288621f, -0.00605057f, 0.08326246f, 0.00566818f, -0.03718735f, 0.08319879f, 0.02350740f, 
    0.09727541f, -0.03943536f, 0.03856561f, -0.03409981f, -0.28976777f, 0.15567628f, 0.32258746f, 0.08714181f, 
    0.17415948f, 0.17124352f, 0.09234381f, 0.15116133f, -0.03672475f, 0.20637687f, 0.01898015f, 0.08339644f, 
    0.09185512f, -0.07480907f, 0.01626036f, 0.05145197f, 0.06736112f, -0.04306409f, 0.10248814f, -0.05793791f, 
    -0.02273243f, 0.04816674f, -0.13297783f, -0.17959225f, 0.08747512f, -0.00872852f, -0.10462084f, 0.02184935f, 
    0.03143622f, -0.02840349f, -0.09007500f, -0.02997793f, -0.02909796f, 0.05699679f, 0.04050568f, -0.06722268f, 
    -0.03519802f, -0.05830534f, -0.00484529f, -0.12402317f, -0.09353243f, 0.40824959f, -0.18560909f, -0.13448833f, 
    0.10786238f, 0.08788358f, 0.07823765f, -0.08259843f, 0.13926253f, -0.02805029f, 0.00086776f, -0.04157951f, 
    0.06050570f, 0.04673319f, -0.03345382f, -0.03647386f, 0.01338453f, -0.08606570f, -0.02592652f, -0.00831255f, 
    0.08443981f, 0.06055700f, 0.21491332f, -0.03069115f, -0.16471729f, -0.08080676f, 0.03735223f, 0.14052430f, 
    -0.01043232f, 0.00348970f, 0.05914059f, 0.12844160f, -0.01883461f, -0.00032084f, 0.06229035f, 0.02007729f, 
    0.09153491f, 0.09436212f, 0.01500179f, 0.03287341f, -0.06692266f, -0.19298641f, -0.17966643f, 0.26628265f, 
    -0.06012760f, -0.07284576f, -0.19616054f, 0.11289985f, -0.01588972f, 0.06877819f, -0.08022475f, -0.15499003f, 
    0.02190457f, -0.01705144f, -0.00934176f, -0.11811430f, -0.05987556f, 0.06726466f, 0.06128991f, -0.04397566f, 
    -0.04086930f, -0.31034994f, 0.11527551f, 0.10104423f, -0.07888834f, 0.11284964f, 0.20491487f, -0.02963769f, 
    -0.04982062f, 0.07635704f, 0.10898143f, 0.04902402f, -0.15503049f, -0.02330639f, 0.01052839f, -0.05231482f, 
    -0.03698895f, 0.00295676f, -0.05006667f, 0.05735166f, -0.27332407f, 0.06749263f, -0.20707999f, 0.06573422f, 
    -0.13950045f, 0.15738216f, 0.02933776f, 0.11469718f, 0.04574205f, 0.13773486f, -0.06932151f, 0.02288307f, 
    0.16839032f, 0.13316400f, -0.01639584f, 0.04196273f, -0.11617115f, 0.03983440f, -0.04002583f, 0.03493942f, 
    0.29858428f, 0.18463288f, -0.02886573f, -0.05831336f, -0.00985066f, -0.19118203f, 0.08404364f, -0.10787766f, 
    0.08140983f, 0.08579272f, -0.01073834f, -0.07279154f, 0.03742716f, 0.08231971f, 0.12968160f, -0.01136841f, 
    0.05077477f, -0.00978811f, -0.14920264f, 0.03798583f, -0.39069945f, 0.03209788f, -0.16310325f, 0.16060989f, 
    -0.27118632f, 0.26987159f, 0.15936188f, 0.08133551f, -0.03893199f, 0.08095133f, 0.03504148f, -0.12243676f, 
    0.14785497f, 0.00986269f, 0.01966710f, -0.01328353f, -0.03451749f, 0.04455407f, -0.06934951f, 0.06151761f, 
    -0.03395458f, 0.34206879f, -0.15628883f, -0.07687329f, 0.24596408f, 0.06453878f, -0.01097511f, 0.12782468f, 
    0.01100308f, -0.09328144f, -0.08327243f, -0.05969020f, 0.05812318f, 0.02993224f, -0.02508064f, 0.06521469f, 
    0.06836122f, -0.06837916f, 0.22726128f, -0.00136046f, 0.22415817f, -0.18112721f, 0.08921462f, 0.09445462f, 
    -0.08865967f, -0.02552934f, -0.01318662f, 0.05293066f, -0.03089675f, 0.08152847f, -0.04699716f, 0.00806373f, 
    0.09493863f, -0.06024078f, -0.01881141f, -0.09147169f, 0.01561562f, 0.02549028f, 0.02873657f, -0.01676065f, 
    0.08028980f, -0.14739995f, 0.16899076f, -0.10798430f, -0.24759513f, 0.05712024f, -0.03108926f, 0.07692116f, 
    0.14764416f, 0.10224044f, 0.03654817f, 0.08809700f, -0.09085238f, 0.12043166f, -0.04098951f, -0.02396672f, 
    0.03916322f, 0.02832828f, 0.10771468f, -0.03264974f, 0.23754321f, 0.28891402f, -0.12608242f, 0.13559859f, 
    0.32301164f, -0.11770404f, -0.03431981f, 0.06042760f, 0.12400062f, -0.08570024f, -0.03044814f, 0.01662821f, 
    0.08349785f, -0.00248083f, 0.15123247f, -0.14949103f, -0.04202669f, -0.06588250f, -0.15323174f, -0.10518846f, 
    0.03433102f, -0.14213589f, -0.09217666f, -0.29349163f, -0.14289729f, -0.15151246f, -0.10734259f, -0.07736545f, 
    -0.03065870f, 0.02518825f, -0.03632608f, -0.07039496f, 0.05578241f, 0.06725533f, 0.01967674f, -0.07299176f, 
    0.05952622f, 0.12372363f, -0.04185216f, 0.15028535f, 0.39396161f, -0.07410923f, 0.28092051f, -0.09068117f, 
    -0.03044479f, 0.07350247f, 0.09712548f, -0.03765473f, 0.07643930f, 0.15876858f, 0.05305280f, -0.02574637f, 
    0.03492249f, 0.19919437f, 0.17231964f, 0.23305966f, -0.06177805f, -0.06660933f, 0.02892340f, 0.04304058f, 
    -0.03236355f, -0.24184085f, 0.12747088f, -0.00821596f, -0.23533867f, -0.18097241f, -0.04859986f, 0.05369921f, 
    -0.04125984f, -0.01476430f, -0.00120486f, -0.04162091f, 0.05703352f, -0.09603222f, 0.11217132f, -0.04128234f, 
    -0.07789685f, 0.08107176f, 0.12943430f, -0.09245124f, -0.07416524f, 0.17346273f, -0.24221574f, 0.17010047f, 
    -0.11415932f, 0.04299492f, 0.16242865f, 0.02961050f, 0.01963895f, -0.10900401f, 0.05524686f, 0.03611304f, 
    -0.08209400f, -0.06110579f, -0.07372838f, -0.03708766f, -0.04252227f, 0.08282114f, 0.17327297f, -0.00130906f, 
    0.13726412f, -0.10352638f, 0.27015799f, -0.03862242f, -0.08993874f, -0.04660156f, 0.06043259f, -0.13804108f, 
    0.01312529f, -0.05198108f, -0.05644254f, 0.04101872f, -0.04424321f, 0.06418294f, 0.02887987f, 0.01305627f, 
    0.12494759f, -0.00997437f, -0.06379614f, 0.03980770f, 0.26373726f, -0.27228442f, 0.26160535f, 0.28152913f, 
    -0.01745183f, -0.05254870f, -0.16587099f, 0.14748569f, 0.06379268f, -0.08306712f, 0.02487462f, -0.01885677f, 
    0.02518045f, 0.02951894f, -0.03555203f, -0.09196617f, 0.04141980f, -0.01188823f, -0.00554361f, -0.02119843f, 
    0.14792240f, 0.12046808f, -0.11595929f, -0.14797072f, -0.07704366f, -0.12192626f, -0.03428037f, 0.07892825f, 
    -0.05042960f, 0.14482361f, -0.04244001f, -0.05555598f, 0.05300647f, 0.05283199f, 0.02843978f, 0.14221954f, 
    -0.00143373f, 0.10793352f, -0.02219044f, -0.02041037f, 0.09023421f, -0.25163972f, 0.05767109f, -0.24661474f, 
    -0.16688468f, -0.01154144f, -0.09585562f, -0.02138136f, -0.00077991f, -0.04200706f, 0.02140346f, 0.01914518f, 
    0.03575689f, 0.07090562f, 0.19819923f, 0.03186200f, -0.00811656f, 0.15192126f, -0.10010368f, 0.11552325f, 
    0.47436750f, 0.23819181f, -0.14884955f, -0.03712738f, 0.22401723f, 0.07153825f, -0.01716923f, 0.14215271f, 
    0.06815228f, -0.10922569f, 0.14458095f, -0.00328056f, 0.01581877f, -0.09522913f, -0.01046596f, 0.14702228f, 
    0.06831079f, 0.09146356f, 0.02148310f, 0.00773691f, 0.10341989f, -0.08527725f, -0.02155588f, -0.08687051f, 
    -0.07120217f, 0.22751048f, 0.02242145f, -0.02933574f, 0.02413980f, 0.11336910f, 0.02544706f, 0.02463092f, 
    0.03340799f, 0.03181315f, -0.00757919f, 0.06652433f, -0.02391276f, -0.07771482f, -0.07763395f, 0.04963636f, 
    0.32109132f, -0.15212218f, 0.05666722f, 0.00511111f, 0.09128917f, 0.02715497f, -0.07047657f, -0.09296338f, 
    0.07405999f, -0.04204482f, 0.03698971f, 0.04755811f, -0.13980071f, 0.10867991f, 0.00613272f, -0.02552293f, 
    0.04223822f, 0.08586246f, 0.05163976f, 0.07892021f, 0.51791745f, -0.10924557f, -0.04639002f, 0.10619453f, 
    0.28773588f, -0.11765414f, -0.11239491f, 0.08252349f, 0.15288275f, 0.01621254f, -0.08915325f, 0.08902461f, 
    -0.11039814f, 0.06928450f, -0.00459802f, -0.02981507f, 0.03990541f, 0.06869445f, -0.09230653f, 0.04991407f, 
    0.01905513f, -0.00169020f, -0.05090393f, 0.02215525f, -0.04720487f, 0.02161434f, 0.03821206f, -0.01584833f, 
    -0.05159787f, -0.01843978f, 0.00101636f, -0.01377501f, 0.03299820f, 0.04399151f, -0.01917500f, -0.06193000f, 
    -0.04197650f, 0.00638822f, 0.00690504f, -0.06178058f, 0.01159626f, 0.01267854f, 0.03185119f, -0.00196955f, 
    -0.02718482f, -0.02848694f, -0.01235290f, -0.04489440f, -0.01255893f, 0.04074835f, -0.02355919f, 0.00039295f, 
    0.02458587f, 0.03655995f, -0.05988678f, 0.03562202f, -0.06063346f, 0.03882531f, 0.00012215f, -0.00861731f, 
    0.04094674f, 0.00454080f, 0.00330690f, -0.01608183f, 0.00395673f, -0.03241502f, -0.05080834f, -0.02024681f, 
    -0.05222792f, 0.02055721f, -0.01344961f, 0.05026551f, 0.00335793f, -0.05942161f, 0.02121531f, -0.02753570f, 
    0.04440446f, 0.01592376f, 0.04962713f, 0.02845278f, 0.01070574f, 0.01044600f, 0.00682283f, 0.01546053f, 
    0.00324356f, -0.02275298f, -0.00519601f, 0.03975758f, -0.00536980f, -0.01544553f, -0.04913286f, -0.01699051f, 
    -0.03922782f, 0.03189247f, 0.02265310f, -0.06082686f, 0.04824809f, 0.00028640f, 0.04800238f, -0.02457442f, 
    -0.00161125f, -0.03883329f, -0.02894313f, -0.04488895f, 0.04651765f, -0.02816413f, -0.05066018f, -0.01548093f, 
    -0.04929791f, -0.03035661f, -0.00392192f, -0.05112719f, 0.00759487f, 0.01294514f, -0.02210937f, -0.02351069f, 
    0.00028238f, -0.02909739f, -0.00788463f, 0.03464660f, 0.00992132f, -0.04584119f, 0.03033776f, 0.01677881f, 
    -0.03243211f, -0.05037815f, -0.03815575f, -0.02406988f, 0.04506031f, -0.02973926f, -0.01932884f, 0.04167957f, 
    -0.00682076f, -0.01604564f, 0.02026189f, 0.00992881f, -0.01669234f, 0.00382405f, 0.02414973f, -0.01971544f, 
    -0.03732301f, 0.01995997f, 0.02355323f, -0.00325053f, 0.02599343f, -0.04125319f, -0.05145698f, -0.01008821f, 
    -0.01738559f, -0.02306347f, 0.00059986f, -0.03055826f, -0.03054799f, -0.04825721f, -0.01184860f, 0.01297884f, 
    0.01955855f, -0.01849617f, -0.03058173f, -0.01557698f, -0.04301876f, -0.04425686f, -0.06275756f, 0.02352566f, 
    0.00137204f, -0.06350841f, -0.04803506f, 0.00199876f, -0.04205551f, 0.00872717f, -0.03757631f, -0.00663480f, 
    0.02480320f, -0.02479734f, -0.02129499f, 0.01156006f, 0.00880767f, 0.00598361f, -0.02671753f, -0.05524418f, 
    -0.00998788f, -0.02469418f, -0.04703775f, -0.04074402f, -0.02156720f, -0.05969768f, 0.04049159f, 0.03721543f, 
    -0.03953015f, -0.05533644f, 0.00274459f, 0.02668770f, -0.02095785f, -0.01685647f, -0.01257545f, -0.02460533f, 
    -0.05076209f, 0.03899755f, -0.01616745f, -0.03933771f, 0.03225937f, -0.02913729f, -0.00598594f, 0.03051270f, 
    -0.00084886f, -0.05681214f, 0.03404411f, -0.04576735f, -0.01488838f, 0.01844822f, -0.05295922f, -0.00756733f, 
    -0.04565642f, -0.02277631f, -0.01489533f, -0.02813013f, -0.02012556f, -0.03165835f, -0.03253235f, -0.02907026f, 
    -0.02331562f, 0.03637908f, 0.00217330f, 0.02347858f, 0.00869515f, -0.03838262f, -0.00550870f, -0.03516787f, 
    -0.04145930f, 0.00227903f, -0.00747815f, 0.04987311f, 0.01485940f, 0.02269141f, -0.05640407f, -0.02808040f, 
    -0.04121453f, -0.01293692f, 0.03167012f, 0.01613737f, -0.01755001f, 0.02536231f, 0.00042370f, -0.05124982f, 
    -0.00053031f, 0.00499191f, -0.05684243f, -0.05095094f, -0.02632111f, -0.04349250f, 0.03587827f, 0.01143918f, 
    -0.03599576f, -0.06201239f, 0.02250021f, -0.01203175f, -0.02106417f, -0.06035021f, 0.03221717f, -0.06140124f, 
    -0.00406957f, -0.01650530f, 0.03692745f, -0.00866860f, -0.02175411f, 0.04736870f, -0.01542063f, -0.00087139f, 
    -0.04748088f, 0.01847018f, -0.05913941f, 0.01070757f, 0.04205781f, -0.02812424f, 0.02257557f, -0.00709094f, 
    0.03251932f, 0.04057982f, -0.05900219f, -0.01751584f, -0.04973926f, -0.01735291f, 0.02699316f, -0.04312103f, 
    -0.05836798f, 0.01915413f, -0.01779807f, -0.05252111f, 0.01524845f, 0.02543261f, -0.01205286f, -0.06350783f, 
    -0.00898795f, 0.03553099f, -0.00388079f, -0.02242639f, 0.01781905f, -0.01153686f, -0.03327723f, -0.01241192f, 
    0.02861606f, -0.00732323f, 0.01972526f, 0.04294411f, 0.03780953f, -0.02286837f, 0.00191873f, -0.02759111f, 
    0.03129782f, -0.04706468f, -0.03101991f, -0.00866893f, -0.00959935f, -0.02205181f, 0.00833103f, 0.04248250f, 
    0.03918695f, 0.00629938f, -0.04679528f, -0.03121101f, 0.00009594f, -0.02122012f, 0.00209566f, 0.03704961f, 
    0.01797513f, -0.03838755f, 0.01631647f, -0.03062015f, -0.06265090f, 0.00631765f, -0.02765787f, -0.02674033f, 
    -0.02596348f, -0.02278754f, 0.04179993f, 0.03306998f, -0.00392908f, 0.02853044f, -0.06021284f, 0.03591904f, 
    0.03731668f, 0.16726929f, -0.18105520f, -0.00261545f, -0.13310529f, -0.04502532f, 0.02742645f, 0.13334133f, 
    -0.07052317f, 0.06688434f, -0.06807853f, -0.04088444f, -0.11955623f, -0.01548861f, 0.04326392f, 0.05053853f, 
    -0.02332349f, -0.02228179f, -0.27193043f, -0.08645208f, 0.02840038f, -0.07392716f, 0.14011805f, -0.10716316f, 
    -0.09456304f, -0.01264691f, -0.07864925f, 0.00893363f, 0.01221952f, -0.10676814f, -0.06536534f, -0.06451529f, 
    -0.05387982f, 0.03845951f, -0.00213097f, 0.12579252f, -0.08015968f, -0.10652366f, 0.03473344f, -0.12819894f, 
    0.10590692f, 0.34810910f, -0.24524513f, 0.14735807f, 0.04762863f, 0.04786230f, 0.04277925f, 0.12575847f, 
    0.10815357f, -0.09553822f, -0.06496287f, 0.18613526f, 0.01022057f, -0.06125190f, 0.12842092f, -0.01290600f, 
    0.14741763f, 0.17743723f, 0.09604230f, -0.09479910f, 0.06784669f, -0.13981658f, -0.00188369f, -0.22007211f, 
    -0.01010629f, -0.10745414f, -0.12333430f, 0.04472772f, 0.09243587f, -0.10411100f, -0.06395868f, 0.06784111f, 
    -0.15304634f, -0.05266702f, -0.01115500f, -0.03153168f, -0.00055294f, 0.01630807f, -0.10073826f, -0.09112827f, 
    0.32749525f, 0.08466818f, 0.28415582f, 0.27223119f, 0.22401378f, 0.17916110f, -0.03405281f, 0.00979896f, 
    0.14781295f, -0.02500848f, 0.10084573f, -0.05171822f, 0.02717009f, 0.05542972f, -0.05087316f, 0.04937590f, 
    -0.00912443f, 0.02961668f, 0.09838521f, -0.01052247f, 0.06081099f, 0.07702932f, 0.13505968f, 0.06886554f, 
    0.00096954f, 0.14289792f, -0.05274909f, -0.00333262f, 0.02313468f, -0.07253227f, -0.13520269f, 0.15137002f, 
    0.01534441f, 0.08243149f, -0.06303222f, -0.03174232f, 0.03436977f, 0.18738668f, -0.05607051f, -0.08901867f, 
    0.33286345f, 0.14345621f, 0.01009725f, -0.03463551f, 0.03839389f, 0.12006526f, -0.02189568f, -0.04070193f, 
    0.08598635f, 0.12524480f, -0.05294116f, 0.08283388f, 0.04235794f, -0.06452932f, -0.12629235f, -0.13243364f, 
    -0.10985634f, -0.00812050f, 0.10448243f, 0.00618189f, 0.16099679f, -0.33207715f, -0.19866066f, 0.06405760f, 
    0.25615352f, 0.01315715f, -0.09056439f, -0.02052722f, -0.05679218f, -0.03975134f, 0.01591460f, -0.02814478f, 
    -0.01826725f, 0.02465382f, -0.02165549f, -0.01214834f, -0.11372631f, 0.01939093f, -0.03367471f, 0.07717665f, 
    0.10118211f, 0.10694878f, -0.06968006f, 0.07348763f, 0.26586467f, 0.03088851f, -0.04202300f, -0.07701820f, 
    0.08793699f, 0.00143735f, -0.10290685f, 0.08115132f, -0.02446162f, 0.08845098f, -0.06293413f, -0.02062728f, 
    0.00780678f, -0.05724567f, -0.02795906f, -0.01138379f, 0.34032238f, 0.16381405f, -0.20254599f, -0.13047887f, 
    -0.01937758f, -0.12733145f, 0.04606954f, 0.12639979f, -0.15715495f, -0.00464654f, -0.00234544f, 0.05928071f, 
    -0.05811594f, -0.03898727f, 0.05591298f, 0.11283003f, -0.10944370f, 0.02243187f, -0.01213543f, 0.05708895f, 
    0.06866913f, 0.11438913f, -0.06903797f, -0.15041147f, -0.09006843f, -0.00252518f, 0.02634992f, -0.13398929f, 
    0.00715458f, 0.07543734f, 0.01790480f, 0.08898707f, 0.11578528f, -0.10738265f, 0.01675093f, -0.05138837f, 
    -0.15889890f, 0.07422885f, 0.14010470f, -0.00664705f, 0.00136861f, -0.15355888f, 0.43435410f, 0.22582109f, 
    0.17242318f, -0.04869477f, 0.05806589f, 0.09928692f, 0.01895668f, -0.06655382f, 0.07123694f, -0.12817922f, 
    0.16688237f, 0.08798877f, -0.03718458f, -0.07355274f, -0.11945123f, 0.04848947f, 0.12074052f, 0.03592491f, 
    -0.00260512f, 0.01712962f, -0.00446652f, -0.10881224f, 0.02433473f, -0.04435470f, -0.19433384f, -0.06005475f, 
    0.00795369f, -0.03190544f, -0.01509210f, 0.13238229f, 0.02781542f, -0.07432604f, -0.06874551f, 0.11534110f, 
    -0.01639463f, -0.03608499f, -0.08099712f, 0.17585342f, -0.42313910f, -0.13535470f, 0.23366793f, -0.02725352f, 
    -0.11433043f, 0.00647182f, -0.13938798f, 0.12984303f, 0.05471136f, 0.03616630f, -0.05926504f, 0.00928660f, 
    -0.06126313f, -0.02666411f, -0.02431590f, -0.08327695f, -0.02185209f, -0.06258447f, -0.09139434f, -0.04123507f, 
    0.21022086f, 0.08388887f, -0.10246523f, -0.07825844f, -0.15563478f, 0.16046163f, 0.05018351f, -0.00479619f, 
    0.00065354f, -0.01351686f, -0.03873667f, 0.03596516f, 0.04290690f, 0.07334623f, 0.04164531f, -0.03804625f, 
    -0.02081028f, 0.07304630f, 0.04535163f, 0.01765304f, 0.19895074f, -0.07374693f, -0.10052837f, -0.19660583f, 
    -0.29348540f, -0.00707805f, -0.15914448f, 0.02417499f, 0.09224062f, -0.00327997f, -0.04760468f, 0.00725741f, 
    0.01211778f, -0.09426258f, 0.01708722f, 0.00181550f, 0.01182855f, -0.11575077f, -0.02869952f, -0.10530326f, 
    -0.01792260f, 0.02470203f, 0.02994817f, 0.00748409f, -0.02469048f, -0.00680556f, -0.01464382f, -0.06220862f, 
    0.02254100f, -0.04675115f, -0.01739340f, 0.01699387f, -0.01679146f, -0.04374013f, -0.04624420f, 0.00892155f, 
    0.00397843f, 0.04410123f, 0.02974897f, 0.01507713f, -0.06063200f, -0.03044927f, -0.01713767f, -0.05667074f, 
    -0.02438198f, -0.00902324f, -0.01832702f, -0.04604983f, 0.02976611f, -0.02052280f, -0.03364560f, 0.02768396f, 
    0.01632524f, 0.04121788f, 0.03901140f, 0.02382650f, 0.04139652f, -0.04433338f, 0.04057243f, -0.04643571f, 
    -0.02919007f, 0.04821632f, 0.03407314f, -0.06088854f, 0.02207754f, -0.04004286f, -0.02927186f, 0.04655065f, 
    -0.01018461f, 0.02961888f, 0.04924251f, -0.01105585f, -0.00830950f, -0.05730040f, -0.05376417f, 0.01301130f, 
    -0.00701736f, -0.04090678f, -0.02261839f, 0.03381315f, 0.02686502f, -0.01699143f, -0.00828048f, 0.02132012f, 
    0.00985565f, 0.01188558f, 0.00842914f, -0.03189668f, 0.01814697f, -0.04009869f, -0.05657059f, -0.02750800f, 
    -0.04158140f, -0.03133230f, 0.00899096f, -0.01929395f, 0.00527972f, -0.04963569f, 0.04978653f, -0.00307042f, 
    0.03182901f, -0.02436535f, 0.02269111f, -0.02705916f, -0.03449759f, -0.04199044f, -0.05890551f, -0.01536545f, 
    -0.01607768f, -0.04096721f, -0.04279874f, -0.01137781f, 0.03276042f, -0.01362462f, -0.00756974f, 0.02186843f, 
    0.04659760f, 0.04211323f, -0.03107326f, 0.01372798f, -0.01734550f, -0.05448732f, -0.00166109f, -0.02488772f, 
    -0.02758522f, -0.00956034f, 0.00200864f, -0.01003205f, -0.01967659f, 0.04648674f, -0.00914404f, -0.00413379f, 
    -0.04971927f, 0.04522302f, -0.00561872f, -0.03248234f, 0.03810940f, -0.01859592f, 0.05184593f, -0.04532104f, 
    -0.03320085f, -0.04890884f, -0.00854947f, -0.01624339f, 0.02410511f, -0.02338552f, -0.00555717f, -0.02870895f, 
    -0.03207712f, -0.00649499f, 0.03753364f, -0.01158041f, -0.00897487f, -0.01427657f, -0.01302723f, 0.04210248f, 
    -0.03852983f, -0.04570172f, -0.02438059f, 0.01611399f, -0.03302362f, -0.02910725f, 0.02770353f, -0.04330953f, 
    -0.04229245f, 0.01846951f, 0.03683989f, 0.03425609f, -0.01439776f, -0.03031443f, 0.03932821f, -0.01208613f, 
    0.04159658f, -0.05242654f, -0.01035986f, 0.02771075f, -0.00073552f, -0.02555804f, 0.03450703f, -0.01950520f, 
    -0.04590853f, 0.04474446f, 0.03600535f, 0.03717865f, -0.00257781f, -0.05246013f, -0.04645196f, -0.03180965f, 
    -0.01384435f, 0.00535160f, 0.04438832f, 0.00109945f, -0.04020484f, -0.00315421f, -0.05772864f, 0.02403219f, 
    -0.05055812f, 0.01994186f, 0.02522452f, 0.00749400f, -0.00412076f, 0.03647413f, -0.00840564f, -0.00205550f, 
    -0.02117107f, -0.00315198f, -0.00861018f, 0.01022153f, 0.04786870f, -0.02411957f, -0.05199631f, -0.00760307f, 
    -0.02879770f, 0.03157777f, -0.02408355f, 0.00745064f, 0.03620564f, -0.01367133f, 0.01741112f, -0.03596222f, 
    0.04231476f, -0.04300619f, -0.04365218f, -0.05849834f, 0.01612434f, -0.05847258f, 0.01192713f, 0.03318393f, 
    -0.00534788f, -0.01280621f, -0.00099240f, -0.01968242f, -0.04917169f, -0.03365526f, -0.02458376f, -0.04431777f, 
    -0.00842436f, -0.00152486f, -0.06469496f, -0.02532055f, 0.03179186f, -0.00761655f, -0.02928355f, -0.05496282f, 
    0.02597587f, 0.04190916f, -0.05719578f, -0.05526714f, -0.04633591f, -0.01809238f, -0.00613248f, -0.02302341f, 
    -0.05278618f, -0.02980798f, -0.00115354f, -0.02678674f, 0.02453405f, -0.00887312f, -0.00920527f, -0.01398461f, 
    -0.05535541f, -0.00462149f, 0.02208650f, -0.00050599f, 0.02748311f, 0.01860469f, -0.02386927f, -0.02659553f, 
    0.01858757f, -0.03075649f, 0.01487304f, -0.01473957f, -0.01551537f, 0.01124609f, 0.01595099f, -0.02774156f, 
    0.03019786f, 0.01729326f, -0.01448566f, 0.01894848f, 0.01309421f, 0.05104044f, 0.01797774f, 0.02371387f, 
    0.05211569f, 0.04796259f, -0.05901656f, -0.02617558f, -0.05418092f, 0.04065064f, -0.04152565f, 0.00168873f, 
    -0.00600795f, 0.03139695f, 0.03639857f, -0.04774257f, -0.05996520f, -0.00615654f, 0.01674456f, -0.02573652f, 
    -0.00042840f, -0.02271938f, -0.04097149f, -0.04306117f, 0.02094794f, -0.01844616f, 0.03180504f, -0.01891841f, 
    0.03443535f, -0.04110875f, 0.02996677f, -0.02756184f, -0.05695231f, 0.02410329f, -0.02101574f, -0.03917714f, 
    0.03205129f, -0.02503675f, -0.00861354f, 0.01973189f, -0.02436610f, 0.00858664f, -0.01209394f, 0.01936080f, 
    -0.03792598f, 0.01878900f, -0.00469343f, -0.04399951f, -0.05218079f, 0.03218272f, -0.02817138f, -0.01939164f, 
    -0.04148159f, 0.00790463f, -0.04278887f, -0.02954414f, 0.02668759f, 0.00016787f, -0.01806563f, 0.02528721f, 
    0.02542813f, 0.00933867f, 0.05189340f, -0.03301539f, 0.02029296f, 0.03545118f, 0.03776509f, -0.00111922f, 
    -0.02816409f, 0.02262381f, -0.05120555f, -0.03055870f, 0.02897708f, 0.02413633f, -0.03014826f, -0.05425434f, 
    0.02407675f, -0.06301060f, 0.01816414f, -0.03286612f, -0.03197575f, 0.00780114f, 0.01362617f, -0.04359995f, 
    0.03438975f, 0.00544455f, 0.04577122f, -0.01984383f, -0.06341998f, 0.04298960f, -0.03273379f, 0.03217001f, 
    0.02279990f, -0.00562287f, -0.03826271f, 0.01220783f, 0.02693360f, -0.04964827f, -0.03484608f, -0.05048355f, 
    0.05630565f, -0.01024243f, 0.01009084f, 0.03676915f, 0.03928408f, -0.04186787f, 0.00141824f, -0.03806053f, 
    -0.03827453f, -0.04558252f, -0.01033420f, 0.00351182f, 0.03311802f, 0.02407056f, 0.02443684f, 0.04578198f, 
    -0.06687615f, -0.05699775f, 0.02518857f, 0.02529541f, -0.02262300f, 0.03611830f, 0.02487152f, -0.01162321f, 
    -0.01334022f, -0.03825987f, 0.01803101f, 0.04410952f, -0.04084114f, -0.00577767f, 0.03124489f, -0.05592991f, 
    -0.03897813f, -0.00299290f, -0.05637297f, 0.01817195f, -0.05319680f, 0.01774316f, 0.04279801f, -0.04868354f, 
    -0.04804029f, 0.00742174f, 0.02719315f, -0.05379900f, -0.00692952f, -0.01584709f, -0.01200750f, 0.01283416f, 
    0.04245977f, 0.00548127f, 0.03924982f, -0.02762605f, 0.01494646f, -0.03208748f, 0.03631875f, 0.01074131f, 
    -0.00147575f, 0.01112833f, 0.01537346f, -0.00117216f, 0.02699409f, 0.00413361f, 0.03687907f, -0.02768082f, 
    -0.01237544f, 0.04365306f, -0.00795352f, -0.00177787f, 0.01693402f, -0.06028078f, -0.03416174f, -0.04414965f, 
    0.02177940f, -0.01020682f, 0.03423438f, -0.01375498f, -0.05825204f, -0.04227028f, 0.02036314f, -0.02755548f, 
    -0.03608280f, -0.02631400f, -0.01768767f, -0.03731433f, -0.01666389f, -0.03129329f, -0.03575918f, 0.02027811f, 
    0.00037122f, 0.01418926f, 0.02901654f, -0.00171605f, 0.03918023f, -0.01511685f, 0.00029284f, 0.02911072f, 
    -0.04168212f, -0.03968231f, 0.01845749f, 0.01968568f, -0.05749310f, 0.00364647f, -0.02678665f, 0.03388283f, 
    -0.04538232f, 0.01152259f, -0.02207027f, -0.04084718f, 0.01674602f, 0.03195692f, -0.03946591f, -0.04710550f, 
    0.02239366f, -0.06252544f, -0.06600629f, 0.02720698f, 0.02157018f, -0.05208890f, 0.03814415f, 0.01912965f, 
    -0.01450731f, -0.02257050f, -0.00421705f, -0.01165539f, -0.02812004f, -0.00332231f, 0.04517452f, 0.03881881f, 
    0.02219499f, 0.00094519f, -0.01874011f, -0.00847804f, 0.01373517f, 0.01309356f, -0.02187844f, 0.02915755f, 
    -0.05285496f, 0.01891058f, -0.00180851f, 0.02530677f, 0.01601270f, -0.07276370f, -0.05213251f, 0.03277467f, 
    -0.03696101f, -0.04990467f, 0.01973545f, 0.04393219f, 0.00643936f, -0.03024994f, -0.01861884f, 0.00980008f, 
    -0.00979384f, -0.02331833f, -0.05993257f, -0.06547841f, -0.04647110f, -0.00573105f, -0.06956986f, -0.02088301f, 
    0.02816666f, 0.01120606f, 0.00071615f, -0.03571960f, -0.00568946f, 0.03251135f, -0.00958529f, 0.01232860f, 
    0.01341037f, 0.02769904f, -0.03262142f, 0.00823850f, 0.01583025f, -0.02766479f, -0.04679487f, 0.02317249f, 
    0.04217520f, -0.00630993f, -0.03507154f, 0.03238203f, -0.03387671f, -0.06268694f, -0.03836048f, -0.01403937f, 
    0.01188359f, 0.02285516f, -0.03939307f, -0.04339089f, -0.02807188f, -0.02166133f, 0.01140844f, 0.00438303f, 
    0.01366368f, 0.03753728f, -0.05520517f, -0.01233947f, 0.01477156f, -0.06011337f, -0.00022398f, 0.02282371f, 
    -0.03473225f, -0.01464603f, -0.05507090f, 0.02840459f, 0.02029530f, 0.00398738f, -0.03612166f, -0.06356733f, 
    -0.04485540f, 0.02965660f, -0.03580788f, -0.00943089f, -0.01329294f, -0.01447727f, -0.05750106f, -0.00269280f, 
    -0.01214124f, -0.00640825f, 0.02211665f, -0.02688038f, 0.03073416f, -0.05635172f, 0.01787332f, -0.00080214f, 
    -0.01062158f, 0.01044863f, 0.04300840f, -0.04920821f, 0.03711176f, 0.03089392f, -0.00987683f, 0.01750586f, 
    -0.06625270f, 0.00084337f, -0.05894369f, -0.01689498f, 0.01371743f, 0.00202959f, -0.03235651f, 0.04141086f, 
    0.00939270f, -0.01617610f, -0.02958700f, -0.01090773f, 0.03484469f, -0.05157296f, -0.04194951f, 0.04293992f, 
    -0.03347890f, -0.00990774f, -0.01519670f, -0.03088188f, -0.04886590f, -0.01626219f, 0.00192188f, -0.00857703f, 
    0.03085951f, -0.01697522f, -0.01691709f, 0.00596017f, -0.01118555f, -0.05002444f, -0.05627043f, 0.03020724f, 
    0.03799526f, -0.04321636f, 0.04053062f, 0.00784406f, -0.04057385f, -0.02073338f, -0.06292017f, 0.00341110f, 
    -0.02118580f, -0.03202860f, 0.00199123f, -0.02822180f, -0.03735204f, 0.02958380f, -0.01471349f, -0.02806103f, 
    -0.02747130f, 0.05343041f, 0.03619863f, -0.02222055f, 0.05972332f, -0.04666457f, 0.03886708f, 0.01907479f, 
    -0.05099672f, 0.03136696f, -0.07014394f, -0.02434450f, -0.00839016f, -0.04252594f, -0.02431066f, 0.00038413f, 
    -0.02152611f, -0.01360712f, -0.02228901f, -0.02776312f, 0.06375476f, 0.00704062f, -0.05446866f, 0.04600479f, 
    0.04226120f, -0.03697189f, -0.00795459f, -0.01148255f, -0.07019803f, 0.01919517f, 0.00605649f, 0.03496883f, 
    0.00352306f, -0.06414345f, -0.02234530f, 0.04054194f, -0.08034171f, -0.04919732f, -0.04894172f, -0.05153216f, 
    0.00103545f, -0.00893631f, 0.02137038f, 0.00477747f, -0.05947489f, -0.03645113f, 0.01271363f, -0.02678004f, 
    -0.02574753f, -0.09985726f, -0.04269063f, -0.00854518f, -0.01025559f, -0.05720248f, -0.00705629f, -0.04075453f, 
    -0.00297513f, -0.04198721f, -0.06938600f, -0.05060579f, 0.05562910f, 0.01634606f, -0.00079172f, 0.02356789f, 
    -0.02530209f, 0.01589053f, 0.02886812f, -0.05738847f, -0.03555789f, -0.02252879f, 0.03954231f, -0.01160725f, 
    -0.02986453f, 0.02739182f, -0.00836972f, -0.03975133f, 0.02805505f, -0.03708693f, -0.05068191f, -0.03363742f, 
    -0.04314303f, -0.05933288f, 0.02029177f, -0.00163332f, 0.04669782f, -0.00574214f, 0.02546052f, -0.00820397f, 
    -0.02907013f, 0.00373830f, -0.01142689f, -0.05333913f, -0.07969658f, -0.07796118f, -0.04161915f, -0.04773806f, 
    -0.00225035f, 0.01747045f, -0.03567004f, -0.00503566f, -0.01156659f, -0.01161410f, -0.03154276f, -0.05445610f, 
    0.01602356f, 0.04151608f, 0.01540419f, -0.04157561f, 0.03510933f, -0.03803237f, -0.03680626f, 0.02616811f, 
    0.03033716f, -0.07791135f, 0.01875866f, -0.00202223f, 0.01492763f, 0.03098899f, -0.06039574f, -0.00915454f, 
    -0.04582440f, 0.00209437f, -0.01807051f, -0.00349793f, -0.00139102f, -0.03716561f, -0.05748582f, -0.01502739f, 
    -0.04548403f, -0.00662411f, 0.00494288f, 0.01045394f, -0.01414363f, -0.08029491f, -0.00153979f, -0.07276380f, 
    -0.04583726f, 0.00954363f, -0.03754712f, -0.07263489f, -0.02844492f, 0.00362824f, -0.07998852f, 0.04662627f, 
    0.02354791f, -0.00811000f, -0.06844310f, -0.05633581f, -0.00930121f, -0.00812687f, -0.08006968f, -0.00752435f, 
    -0.03084209f, -0.03470118f, -0.02523034f, 0.00727317f, 0.00094697f, 0.00563233f, -0.06520477f, 0.04162602f, 
    -0.01685808f, -0.08055622f, 0.01958496f, -0.00096054f, 0.06047844f, 0.03977543f, -0.06561507f, -0.02097919f, 
    -0.00741248f, -0.01079229f, -0.04994180f, -0.06544919f, -0.03596486f, -0.01228788f, -0.02569990f, -0.03633228f, 
    -0.01058007f, -0.01635081f, 0.01936714f, -0.05968884f, 0.01536003f, -0.03006691f, -0.06887420f, -0.04030146f, 
    0.00022321f, -0.02147632f, 0.00770403f, 0.01283028f, 0.04806620f, 0.00352567f, -0.01175002f, -0.04464171f, 
    -0.04716668f, -0.08083496f, 0.01131023f, 0.01670999f, 0.02373241f, 0.01542770f, -0.03110666f, 0.02463151f, 
    0.03575655f, 0.04213221f, 0.05285766f, 0.07757901f, 0.02168167f, -0.03783961f, 0.02200883f, -0.06627743f, 
    -0.07272572f, -0.09021218f, -0.00628083f, -0.00851681f, -0.02527677f, 0.01458019f, 0.01503657f, -0.03231896f, 
    -0.01990093f, -0.03149908f, -0.04125428f, 0.00329508f, -0.05555505f, -0.04069458f, -0.02210435f, 0.00487980f, 
    -0.02151483f, 0.00020044f, 0.01957964f, -0.04263542f, 0.04038712f, -0.02093012f, -0.04975873f, -0.03610216f, 
    -0.00369850f, -0.05783778f, 0.00952263f, 0.00930082f, 0.01253963f, -0.03884788f, 0.01409606f, -0.06523494f, 
    0.00345610f, 0.04059764f, -0.03671520f, -0.06310346f, 0.01966159f, 0.01149543f, -0.02252918f, 0.01244056f, 
    -0.00664775f, -0.01591497f, -0.02021971f, 0.00540332f, -0.06126045f, -0.07100774f, -0.00629359f, -0.07940078f, 
    -0.02072594f, -0.03940196f, -0.05506159f, -0.04073619f, 0.04671305f, -0.01914696f, -0.01129198f, 0.02194661f, 
    -0.04663194f, -0.04073663f, -0.02810802f, 0.06787444f, -0.05351517f, -0.05465786f, 0.00862252f, 0.03247589f, 
    -0.04615179f, -0.03269000f, -0.07031937f, -0.00675373f, 0.00594160f, -0.02055764f, 0.02015521f, -0.08935944f, 
    -0.02258459f, 0.00155671f, -0.03508829f, 0.00638500f, 0.01409128f, 0.03252624f, -0.02561986f, -0.05228291f, 
    0.00420327f, 0.01726954f, 0.02512350f, 0.02987917f, -0.00441058f, -0.05263384f, -0.04227868f, -0.01377996f, 
    -0.02794828f, -0.06082197f, 0.01139594f, -0.01887136f, -0.01622579f, 0.00853022f, -0.03397100f, 0.01180413f, 
    0.02656773f, -0.07575216f, -0.03856040f, 0.01947396f, 0.02321963f, 0.02658545f, -0.05518700f, -0.05007782f, 
    -0.00790975f, -0.04642060f, -0.05839936f, -0.05573193f, -0.05625064f, -0.00501778f, -0.04155007f, -0.06363618f, 
    0.15447643f, 0.15957661f, -0.13245076f, 0.01854017f, -0.19406156f, 0.02737265f, 0.12140763f, 0.11354374f, 
    0.03452841f, -0.04628690f, -0.03708283f, -0.03495784f, 0.02443458f, 0.16055498f, 0.01022973f, -0.01227643f, 
    -0.09419867f, 0.01478473f, -0.08754050f, -0.05412983f, -0.04698567f, 0.13225462f, 0.22006424f, -0.07332226f, 
    0.11513929f, -0.01244363f, 0.00071589f, 0.07247298f, -0.03627117f, -0.06311055f, 0.09710693f, -0.12371220f, 
    -0.08162854f, -0.09068462f, 0.01533288f, -0.09222753f, -0.00783697f, -0.02913287f, 0.04075105f, -0.01276642f, 
    0.37024087f, -0.28060570f, 0.12517640f, -0.19122845f, -0.28412113f, -0.01961067f, -0.01180740f, 0.02323144f, 
    0.06684668f, 0.22750771f, -0.15102431f, -0.05952273f, -0.07207316f, -0.14987032f, -0.09719737f, 0.06545733f, 
    -0.09199512f, 0.02055865f, -0.04467262f, -0.03766737f, 0.05488442f, 0.31649151f, 0.33464810f, -0.02197737f, 
    0.12735941f, -0.20863634f, -0.11276212f, 0.15329593f, -0.01660985f, -0.01572323f, 0.02422943f, -0.10587453f, 
    0.06053035f, 0.11813582f, -0.13923343f, 0.07949715f, 0.00502058f, -0.01235939f, 0.04236701f, 0.04985510f, 
    -0.27719018f, -0.18694086f, -0.13949504f, 0.12462131f, 0.16713527f, 0.06708702f, 0.08469954f, -0.03287038f, 
    0.05508575f, 0.18076819f, 0.00807543f, 0.07077470f, 0.02973513f, -0.00920017f, -0.03924125f, -0.01454714f, 
    0.04269033f, -0.01181929f, 0.03984670f, -0.04521137f, -0.21941726f, 0.23223794f, 0.02883857f, -0.08526133f, 
    0.14228928f, 0.18792057f, -0.10258593f, 0.14258437f, 0.02137310f, 0.04180945f, 0.20950016f, 0.03702263f, 
    -0.00379511f, -0.03324227f, -0.10123672f, 0.05290547f, 0.00538042f, 0.01529556f, 0.06308418f, -0.09141718f, 
    0.46614155f, -0.20502198f, 0.05172194f, 0.17500407f, -0.08552299f, 0.02654860f, 0.03652397f, -0.06394407f, 
    0.07834830f, -0.00028906f, -0.01126575f, 0.04768300f, 0.02683808f, 0.01596030f, -0.12763751f, 0.00054093f, 
    0.00085558f, 0.02828787f, -0.07964130f, -0.05846104f, -0.32006660f, 0.01128864f, 0.00660025f, 0.15161534f, 
    -0.14677644f, -0.08947261f, 0.04069749f, 0.04525287f, -0.03713292f, -0.01297334f, -0.05139572f, -0.20415413f, 
    -0.04803199f, 0.07557545f, 0.07531722f, -0.10115270f, -0.03507005f, -0.07107519f, 0.06175913f, -0.03251038f, 
    0.00825029f, 0.24816462f, -0.08983395f, -0.03701377f, -0.07598856f, 0.06839552f, -0.01025571f, -0.00116066f, 
    -0.01989175f, 0.01595524f, 0.11994230f, 0.02031558f, -0.04640489f, 0.05084201f, -0.04463262f, 0.09129792f, 
    0.02141115f, -0.10623745f, 0.15646678f, -0.04191497f, 0.14687514f, -0.16478993f, 0.03053487f, -0.16062400f, 
    -0.05430034f, -0.04345496f, -0.03847645f, 0.01982101f, -0.00454442f, 0.03353550f, -0.01363426f, -0.01213545f, 
    -0.08588687f, -0.09162304f, 0.01745040f, -0.00196943f, -0.00446270f, 0.12266880f, 0.05594390f, -0.02306209f, 
    0.13848200f, -0.39632726f, -0.05116278f, -0.10017963f, -0.00525874f, 0.04375565f, -0.11918638f, 0.01739900f, 
    0.18138781f, 0.06167245f, -0.01122244f, -0.02895618f, -0.03360625f, 0.05525311f, 0.09497271f, 0.05677681f, 
    -0.02324627f, 0.07881853f, -0.06612941f, 0.05453081f, -0.10784110f, -0.01136359f, -0.19039945f, -0.15638429f, 
    0.13400587f, 0.05359056f, 0.04336410f, 0.00002425f, 0.07157969f, 0.17726676f, 0.13601317f, 0.10647961f, 
    0.07018553f, 0.07533433f, 0.11252626f, 0.07871738f, 0.00093774f, 0.05697735f, -0.03172301f, -0.05274067f, 
    -0.13482355f, 0.12656800f, 0.07216329f, 0.16527656f, 0.20072120f, 0.02776920f, 0.08666402f, 0.11105408f, 
    -0.01221978f, -0.04782038f, -0.18798400f, -0.02528476f, 0.06277217f, -0.03874420f, 0.07029010f, 0.02643986f, 
    -0.03002217f, -0.06467135f, -0.06291389f, 0.09170576f, 0.08055557f, 0.15538424f, 0.18679334f, -0.05261765f, 
    0.01840313f, -0.10599568f, 0.10109556f, -0.13896728f, -0.00215911f, 0.02205415f, 0.14967518f, 0.00764836f, 
    -0.03306429f, 0.03646087f, -0.01637482f, -0.02587065f, -0.03360026f, -0.04778964f, 0.04264723f, 0.12828821f, 
    0.09378798f, -0.02249090f, -0.02515883f, -0.26121572f, -0.03904737f, 0.30727530f, 0.11706979f, 0.05735393f, 
    0.04334630f, 0.15435655f, -0.07708287f, 0.18929687f, 0.03510767f, 0.01426835f, 0.00707405f, -0.06904054f, 
    0.01533536f, 0.07313860f, 0.10130234f, -0.01985424f, 0.28264332f, -0.02745104f, 0.27608892f, -0.20888352f, 
    0.01913626f, -0.03284273f, -0.22791797f, 0.13885278f, 0.10396249f, 0.01774671f, -0.08534247f, -0.13575801f, 
    -0.04287792f, -0.05009288f, 0.02414602f, 0.00580638f, -0.01137101f, -0.09142333f, -0.03090467f, -0.07934509f, 
    -0.06162486f, 0.00708081f, -0.05387166f, -0.00074838f, -0.00534782f, -0.03995875f, -0.00930106f, -0.02242254f, 
    -0.05399556f, 0.00287947f, 0.00833494f, 0.02523020f, 0.02606307f, 0.02306215f, 0.00762707f, -0.02386144f, 
    -0.03406047f, 0.03066772f, 0.04988442f, 0.01514550f, 0.03662997f, -0.02765433f, 0.01359955f, -0.00227041f, 
    0.00763953f, 0.01244951f, -0.04544459f, -0.03450251f, 0.01767238f, 0.02997326f, -0.02492599f, 0.04084304f, 
    0.02923151f, -0.04349667f, -0.01186434f, 0.02652333f, 0.02022451f, -0.00602108f, -0.03481506f, 0.00070751f, 
    0.02180174f, -0.02443118f, 0.01625612f, 0.04440864f, -0.04416883f, -0.00780903f, 0.01675160f, -0.02712303f, 
    0.04311927f, -0.03621696f, -0.05471945f, -0.04444663f, -0.02272179f, -0.04506659f, -0.04707237f, -0.01508351f, 
    0.03695450f, 0.02333190f, 0.02449314f, -0.02463065f, 0.03075699f, 0.03263843f, 0.04729531f, 0.01321951f, 
    -0.01411687f, -0.05570031f, 0.02977591f, -0.02882102f, -0.02832097f, 0.03861108f, -0.03517852f, -0.05661487f, 
    -0.02181100f, 0.02256078f, -0.03841813f, -0.01821030f, 0.00851684f, -0.06008036f, -0.02618505f, 0.00195559f, 
    0.01011314f, 0.04880957f, -0.01669824f, -0.05490823f, 0.03449462f, 0.04387010f, -0.06214324f, 0.01596103f, 
    -0.00128477f, -0.02452583f, 0.01752619f, -0.03363881f, -0.03849872f, -0.03522906f, 0.02474650f, -0.00459943f, 
    -0.04268891f, 0.03737469f, -0.03559405f, -0.00821375f, 0.01056976f, 0.00749634f, -0.06145152f, -0.05574909f, 
    0.03071388f, 0.02980510f, 0.01508119f, -0.02208295f, -0.06006956f, 0.03667511f, -0.02147019f, -0.02498443f, 
    -0.05377483f, 0.03197640f, -0.03615075f, -0.05318140f, 0.03295039f, 0.02822016f, -0.03248450f, -0.02065293f, 
    0.00426428f, 0.03675639f, 0.04300438f, -0.03032309f, -0.02647897f, 0.02133694f, -0.05110249f, -0.02832853f, 
    -0.00178005f, 0.01460318f, -0.04537363f, 0.04223958f, -0.06468307f, 0.04400727f, 0.02890771f, -0.06231696f, 
    -0.03132106f, 0.01904834f, -0.04113054f, -0.02899495f, -0.06255527f, 0.02281583f, -0.02552163f, 0.02436668f, 
    0.01602800f, -0.00081275f, 0.01895181f, -0.02109155f, -0.00922442f, 0.00944644f, -0.01332367f, -0.03081640f, 
    0.01032295f, -0.03178216f, -0.04405506f, 0.03318854f, -0.03655353f, -0.04065938f, 0.02513758f, -0.01106625f, 
    -0.01038143f, -0.01730748f, 0.03967425f, -0.05283340f, -0.01223743f, -0.03989662f, -0.06115040f, -0.00557670f, 
    0.02007154f, -0.01360155f, 0.04583392f, 0.04143529f, -0.00504113f, 0.03291455f, -0.01035714f, -0.00449326f, 
    0.02084595f, 0.00957918f, -0.04625914f, -0.05104736f, -0.01061345f, 0.00653561f, 0.03459343f, 0.02547582f, 
    0.03243810f, -0.02259078f, -0.01665087f, 0.03497327f, -0.02884184f, -0.04590333f, 0.00359363f, -0.02240512f, 
    -0.04748191f, -0.00850406f, -0.04413646f, -0.00001454f, -0.01471728f, 0.02804021f, -0.01522289f, 0.03539809f, 
    -0.01312559f, 0.03737271f, -0.05237270f, -0.00676016f, -0.04972218f, 0.01881274f, -0.04088197f, 0.03633608f, 
    0.02589403f, -0.00515623f, 0.04242846f, 0.01708830f, 0.02119387f, 0.01556935f, 0.04332710f, -0.06314239f, 
    0.04882661f, -0.01401736f, -0.02727180f, -0.01827801f, -0.00808584f, -0.04462536f, -0.00852469f, 0.04015908f, 
    -0.00253660f, 0.00763995f, -0.01947255f, -0.02730678f, -0.04759674f, -0.04289613f, -0.03487131f, 0.01684121f, 
    0.00333787f, 0.04809235f, 0.02116064f, 0.03204509f, -0.02619150f, 0.02584591f, -0.06289601f, 0.03580688f, 
    -0.06100421f, -0.04809594f, -0.02793377f, -0.05983235f, 0.01612460f, -0.03619138f, -0.01953538f, -0.00903569f, 
    -0.00973768f, 0.04195445f, -0.05577694f, 0.01092029f, 0.03744948f, 0.04214294f, -0.04402272f, -0.00527356f, 
    0.04164778f, 0.04301648f, 0.01518531f, 0.01083008f, -0.03869644f, 0.02787486f, 0.01093658f, 0.04673256f, 
    0.04106901f, -0.05562511f, -0.01677444f, -0.04598219f, -0.02714644f, -0.06049466f, 0.01085350f, -0.01278247f, 
    -0.02320554f, -0.02223402f, 0.03543828f, -0.03374499f, 0.03510168f, -0.05838124f, 0.01777438f, 0.02456972f, 
    -0.04988528f, 0.04645468f, 0.00241651f, -0.05701736f, 0.00737222f, 0.04227306f, -0.03226838f, -0.03488206f, 
    -0.03689126f, -0.01931646f, 0.01983747f, -0.04461418f, -0.00329005f, 0.03552599f, -0.04045150f, 0.01354332f, 
    -0.02699429f, 0.01773874f, 0.01600770f, -0.05250719f, 0.01509671f, -0.00799004f, -0.06431655f, 0.03378809f, 
    -0.00072557f, 0.02813805f, 0.00819942f, 0.01937417f, 0.01725015f, 0.01696783f, 0.03953941f, 0.04910155f, 
    -0.03149829f, -0.01194760f, -0.04615521f, -0.03601770f, -0.01252953f, 0.03854801f, -0.04578246f, -0.04322857f, 
    0.29248920f, -0.04441424f, -0.06836702f, -0.18714944f, -0.23320320f, -0.08420708f, 0.16798390f, 0.05974453f, 
    0.01408598f, -0.04819568f, -0.00782027f, -0.13320667f, -0.04812200f, 0.02135236f, -0.04818232f, 0.01876307f, 
    -0.01534829f, 0.05822032f, -0.09691901f, 0.05463066f, 0.43298948f, -0.26695874f, -0.02385308f, -0.00901481f, 
    0.22095224f, 0.13644657f, 0.01949963f, -0.00146301f, -0.00922217f, 0.09382642f, -0.10720514f, -0.12218411f, 
    0.00767834f, -0.02485278f, 0.10566111f, 0.09022982f, 0.08761079f, 0.02286239f, 0.07070830f, 0.08838084f, 
    -0.21654326f, 0.09643725f, -0.13579209f, -0.15476443f, 0.09492417f, 0.12067200f, -0.09915355f, 0.15095267f, 
    -0.01273420f, 0.05633213f, -0.02666768f, 0.01695909f, -0.07778022f, 0.07564488f, -0.04667558f, 0.05302903f, 
    0.06806529f, 0.12170979f, -0.02074295f, -0.05779172f, 0.14187051f, 0.45093265f, 0.10889980f, 0.26183346f, 
    0.02151145f, -0.03575939f, 0.08890160f, 0.05841311f, -0.00424895f, -0.03593221f, 0.16590893f, 0.08706170f, 
    -0.02446007f, 0.01662872f, -0.04668036f, 0.05454633f, 0.00753819f, -0.01908591f, -0.08488597f, -0.15198128f, 
    0.27995029f, -0.01570539f, 0.26676729f, 0.10639490f, 0.11443286f, 0.05119149f, 0.07013927f, -0.01438636f, 
    -0.06973014f, 0.09608807f, -0.03458998f, -0.05482469f, -0.05671659f, 0.10937715f, -0.03938047f, -0.01562443f, 
    0.00826927f, 0.02308714f, 0.02215319f, -0.01885989f, 0.03157019f, -0.34624392f, -0.18248467f, -0.03367688f, 
    0.06892537f, -0.01717825f, 0.10971114f, -0.03943839f, -0.14374439f, -0.02367960f, -0.15901215f, 0.12125903f, 
    0.08677013f, 0.09384330f, 0.03412129f, 0.04735343f, 0.02955753f, 0.01282709f, -0.14140421f, -0.05516889f, 
    0.23595361f, -0.11446293f, 0.04602960f, -0.09933341f, 0.07891298f, 0.03333396f, 0.06743068f, 0.12517685f, 
    -0.06742962f, 0.11414964f, -0.01781828f, 0.13299511f, 0.04459217f, -0.07715347f, 0.00171953f, 0.01100263f, 
    0.01042154f, 0.05498545f, 0.06305663f, 0.02500588f, 0.06585980f, 0.02701312f, -0.20783654f, -0.34578344f, 
    -0.08505534f, 0.13257974f, 0.00245672f, -0.02845342f, 0.08143140f, -0.08178524f, 0.03194012f, 0.00761585f, 
    0.03422797f, 0.06364214f, 0.06657125f, -0.03722305f, -0.07090429f, -0.10990518f, 0.01793115f, 0.01775397f, 
    0.13638851f, -0.09367321f, -0.18326215f, 0.05046124f, 0.01364854f, -0.03443945f, 0.00432586f, -0.01555369f, 
    -0.16804853f, -0.02586020f, 0.01100680f, 0.14469676f, -0.02314839f, 0.17673029f, 0.07696739f, -0.05509936f, 
    -0.09186890f, -0.04821775f, -0.06631689f, -0.08759996f, 0.41308236f, -0.11659869f, -0.13995272f, 0.06261320f, 
    0.01215742f, -0.11476946f, 0.03535097f, -0.06923940f, -0.05884199f, 0.08033005f, -0.07497893f, -0.05266362f, 
    -0.12401661f, -0.01581344f, -0.05423771f, 0.04697123f, 0.02598753f, 0.01916920f, -0.07040928f, 0.08479583f, 
    0.26409328f, -0.11896046f, -0.41876826f, -0.03236366f, -0.28696400f, 0.03389851f, 0.02432651f, -0.04959644f, 
    0.05703741f, 0.02662626f, 0.00316884f, 0.05240461f, -0.00931274f, 0.18783872f, 0.06904902f, 0.04714883f, 
    0.00038054f, 0.07895494f, 0.04400333f, 0.18066043f, 0.32688370f, -0.08844597f, 0.06111760f, -0.01816809f, 
    0.06825343f, 0.10447402f, 0.01978415f, -0.08362287f, -0.06499203f, 0.10658190f, -0.01199379f, 0.09286952f, 
    -0.06363805f, -0.03270122f, 0.03923926f, 0.00399069f, -0.07676332f, -0.03478172f, -0.05338573f, 0.03938470f, 
    0.23998749f, 0.44985792f, -0.04007951f, -0.12081233f, -0.11919355f, 0.04439566f, 0.11578639f, 0.02259721f, 
    -0.01610115f, 0.04353433f, 0.04009052f, -0.05158238f, 0.08746461f, -0.01271049f, -0.04703573f, 0.02426073f, 
    -0.00782820f, -0.06550171f, -0.09849435f, 0.07820771f, 0.13787043f, -0.38639331f, 0.07440967f, -0.03228103f, 
    0.25333911f, 0.03350033f, 0.01985002f, 0.03852542f, -0.01439851f, 0.11957661f, 0.07115746f, -0.03575199f, 
    0.01169313f, 0.10003090f, -0.06733068f, -0.02625676f, 0.11484358f, -0.11973153f, -0.00620862f, -0.04050701f, 
    -0.50051576f, -0.25587919f, -0.00499229f, 0.16176106f, 0.19793881f, 0.12147893f, 0.10478418f, 0.01685164f, 
    -0.00371905f, 0.00220231f, 0.02621023f, -0.03510992f, 0.04546529f, 0.02109972f, -0.14879306f, 0.13719238f, 
    -0.01872866f, 0.00223820f, -0.00877320f, 0.06110644f, 0.09386275f, 0.06126650f, 0.08176676f, -0.02621909f, 
    -0.09481317f, 0.00985854f, 0.03704352f, -0.01755258f, 0.05509661f, 0.07230631f, -0.11445681f, 0.04050730f, 
    -0.04126258f, -0.09527689f, 0.08635150f, -0.00678609f, -0.00174408f, 0.03715776f, -0.04010591f, -0.10225355f, 
    -0.00471882f, -0.04177621f, 0.03602068f, 0.03260190f, -0.04385721f, 0.04385161f, 0.03387463f, -0.00258056f, 
    0.01543965f, 0.01567029f, 0.03370384f, -0.03926354f, 0.01900723f, 0.04757229f, -0.01714788f, 0.00050684f, 
    0.01660873f, 0.00601474f, -0.01309673f, 0.01685153f, -0.04982613f, -0.04818666f, -0.03535103f, -0.02779040f, 
    -0.03462776f, -0.03941017f, -0.02278749f, -0.01326878f, -0.00845362f, 0.04529344f, -0.03501464f, 0.00313945f, 
    -0.00920132f, 0.00444507f, 0.03853377f, -0.00435711f, -0.05672724f, -0.02989895f, 0.03123596f, 0.00555856f, 
    -0.03301667f, 0.00582024f, 0.05084883f, 0.04562682f, -0.02255903f, 0.00479163f, -0.05349599f, 0.00213471f, 
    0.02000208f, 0.02680992f, -0.00434518f, -0.02097571f, -0.01942256f, -0.01755155f, -0.04941707f, -0.04922830f, 
    0.04260500f, -0.04736988f, 0.02511362f, 0.03535397f, 0.02888033f, -0.01295871f, -0.03500562f, -0.06074681f, 
    0.02988493f, -0.05633081f, -0.05665153f, -0.02441445f, 0.00903631f, -0.00917271f, -0.05832002f, -0.01540739f, 
    -0.03252884f, -0.02499069f, -0.00224860f, -0.01601658f, 0.03951120f, 0.04683898f, 0.03625786f, -0.00026436f, 
    -0.01636101f, -0.03632143f, -0.03383811f, -0.01367548f, 0.03106182f, -0.03839639f, 0.03565354f, -0.03240675f, 
    0.00962573f, -0.02633656f, 0.00103851f, -0.00463391f, 0.04899145f, 0.01817356f, -0.01163227f, -0.00807298f, 
    -0.00806381f, -0.02236549f, -0.00500887f, 0.00125743f, -0.00978416f, 0.04124629f, 0.02062636f, -0.00487392f, 
    0.01845074f, 0.02463082f, 0.02145071f, -0.00315105f, -0.00448569f, 0.00936331f, -0.05385785f, 0.04479057f, 
    -0.00866273f, -0.02616257f, 0.01049104f, -0.04858577f, -0.04313914f, 0.00041794f, -0.03253895f, -0.02879573f, 
    -0.02935769f, 0.00299275f, 0.02769825f, 0.03889772f, 0.02510667f, 0.03483086f, -0.00731449f, -0.00985324f, 
    0.05213128f, -0.00463240f, -0.02484239f, 0.00209664f, -0.04772678f, -0.04453818f, 0.04696075f, 0.00241242f, 
    0.02259698f, 0.02287750f, -0.05755189f, -0.01258858f, 0.05627188f, -0.02418585f, -0.05591948f, -0.05268257f, 
    -0.03678395f, -0.01232046f, -0.00687939f, -0.03963523f, 0.00981372f, -0.03775945f, 0.03054751f, 0.00763120f, 
    -0.04075560f, 0.01825950f, 0.00461238f, -0.00449197f, -0.03342684f, 0.01481880f, -0.01263308f, 0.04615155f, 
    0.03061980f, 0.01113922f, 0.00404881f, -0.04411265f, 0.01814916f, 0.04409225f, 0.01181998f, 0.03837029f, 
    -0.03391279f, -0.04737980f, -0.02130604f, -0.05701767f, -0.04972529f, 0.04052049f, 0.02235023f, -0.02205858f, 
    0.00829776f, 0.01100038f, -0.00240360f, -0.01332991f, 0.02318639f, 0.03114848f, -0.00929654f, 0.04831310f, 
    0.01720759f, -0.02509765f, -0.00977083f, -0.03107463f, 0.05013222f, -0.02045459f, 0.01716866f, -0.01985268f, 
    -0.04051074f, -0.04075984f, -0.04963167f, -0.02716046f, 0.02695693f, 0.03909318f, 0.01585822f, 0.02195663f, 
    0.00857391f, -0.02414629f, -0.02379538f, 0.04147822f, 0.03583926f, 0.02802755f, -0.02342585f, -0.02347696f, 
    -0.04964618f, -0.00773145f, 0.01311692f, -0.05709192f, -0.00927259f, -0.01226138f, 0.05346454f, 0.04445548f, 
    -0.04050038f, -0.01832509f, 0.04040669f, -0.06016856f, 0.01690207f, -0.00571969f, 0.03295300f, 0.03503151f, 
    -0.05536994f, -0.00943953f, -0.01169703f, 0.00168139f, -0.01213187f, -0.03804441f, -0.03674150f, 0.00407773f, 
    0.01504232f, 0.00841546f, -0.02623797f, 0.04815467f, -0.01424891f, 0.05032164f, -0.03100260f, -0.03928752f, 
    0.02884878f, -0.05498250f, 0.00292830f, 0.02472250f, 0.01299960f, -0.00087697f, 0.00151542f, -0.05957681f, 
    -0.01517011f, -0.05382256f, -0.06504889f, 0.04207045f, -0.05521530f, 0.00473782f, -0.03896631f, -0.04678946f, 
    -0.00840975f, -0.01152971f, -0.03837946f, -0.04730080f, 0.03697960f, 0.01538695f, -0.03886246f, -0.03349887f, 
    0.00941175f, 0.03061810f, 0.03240921f, 0.01668353f, -0.02734824f, -0.02557308f, -0.01733663f, 0.04972666f, 
    0.04245439f, -0.00046462f, 0.00167988f, -0.02390992f, -0.00580797f, -0.05413056f, 0.02641581f, -0.04807771f, 
    0.00090760f, 0.04291033f, 0.02732280f, -0.01851148f, 0.01710696f, -0.01019398f, -0.03732794f, -0.04229609f, 
    -0.01588163f, -0.02195167f, 0.01648240f, 0.00002846f, -0.04820567f, 0.01586382f, 0.00826083f, 0.00559353f, 
    -0.02841164f, 0.00792071f, 0.01828835f, -0.03677402f, -0.00123148f, -0.02441064f, -0.02401841f, -0.05659639f, 
    0.03758915f, 0.01017405f, 0.00236021f, -0.03295237f, 0.03955342f, 0.01514686f, 0.02361922f, -0.00572317f, 
    -0.02950998f, -0.02065657f, 0.00789376f, -0.04696728f, 0.00630081f, -0.05601321f, 0.00498312f, -0.00835661f, 
    0.13796909f, -0.01813557f, 0.21363758f, 0.22525747f, -0.35435912f, -0.05783643f, -0.05998853f, 0.11146044f, 
    -0.06976311f, -0.03528890f, -0.00006865f, 0.04357260f, 0.00824828f, -0.02244562f, -0.00383604f, -0.16597795f, 
    -0.04665247f, -0.01908619f, 0.11244889f, -0.06943087f, -0.06318161f, 0.03675564f, -0.03391974f, 0.17536385f, 
    0.17030157f, -0.07202111f, 0.07187503f, 0.03403695f, -0.03602910f, -0.02201648f, 0.02268175f, 0.05664691f, 
    0.06049974f, -0.01992051f, 0.03384618f, 0.03211436f, -0.05616803f, -0.04556939f, -0.11723941f, -0.13130572f, 
    0.23125659f, 0.02492678f, -0.12771937f, 0.04376150f, 0.09630649f, 0.12909277f, 0.12705831f, -0.07287045f, 
    0.04748733f, 0.18278635f, 0.00520331f, 0.00817813f, 0.12326086f, 0.01955414f, -0.07403550f, 0.08923995f, 
    0.07183184f, 0.11536244f, -0.03506092f, 0.06058665f, -0.30290347f, 0.19424950f, 0.10203768f, 0.10925633f, 
    -0.31094989f, -0.12446809f, -0.00262141f, -0.00662408f, 0.10182353f, 0.06480076f, 0.01174943f, -0.09092855f, 
    0.11999632f, -0.06309935f, -0.02746349f, -0.03502906f, 0.02828793f, -0.05506024f, 0.06994938f, -0.06540475f, 
    -0.41495633f, -0.20231259f, 0.01747385f, -0.32585871f, 0.26385444f, 0.06882797f, 0.17173912f, -0.09232493f, 
    -0.05553944f, -0.11932778f, 0.13889955f, 0.07440197f, -0.00103624f, -0.07662593f, 0.02552000f, -0.05776216f, 
    0.00747785f, 0.03990593f, -0.00523004f, 0.06951522f, 0.20034236f, 0.03951231f, 0.12009961f, -0.05548872f, 
    -0.14943017f, 0.14119367f, 0.10714986f, 0.18215612f, 0.07501259f, 0.01099439f, 0.05980869f, -0.05441334f, 
    0.07667927f, 0.08886492f, -0.05572164f, 0.03394474f, -0.01392402f, 0.09203431f, -0.15250427f, 0.14220044f, 
    0.02085688f, 0.10927588f, -0.07761312f, -0.08186006f, 0.05997307f, 0.01074616f, 0.00045435f, -0.11037043f, 
    -0.09192257f, 0.00647614f, 0.04559823f, 0.02787242f, -0.03304395f, 0.01813816f, 0.00582289f, -0.12317000f, 
    0.08640962f, -0.03194366f, 0.03281535f, -0.09716298f, 0.41643786f, 0.09030367f, -0.00793266f, 0.07369867f, 
    0.26425672f, -0.13684671f, -0.02327008f, 0.01288837f, 0.03057780f, 0.05196627f, 0.03802475f, -0.09104528f, 
    -0.08030599f, 0.08928854f, 0.09950355f, -0.04690438f, -0.12195149f, 0.06548922f, -0.01150230f, 0.03734913f, 
    0.08661462f, -0.40127677f, 0.03828153f, -0.01889124f, -0.11067262f, -0.03886181f, -0.00485745f, 0.12029695f, 
    0.17122601f, -0.04322426f, 0.01059763f, -0.09914582f, -0.03387147f, 0.01062355f, -0.03292465f, -0.05581933f, 
    0.07226328f, 0.03942902f, -0.00407534f, 0.01377709f, 0.23505427f, -0.32472387f, -0.03498407f, 0.20528901f, 
    -0.15643418f, 0.06425758f, 0.01092868f, 0.09124417f, -0.04042378f, -0.09991754f, -0.02722837f, -0.05844713f, 
    0.04083472f, 0.06562414f, -0.00313740f, 0.01044737f, 0.03971678f, -0.00059529f, -0.04410256f, -0.08693886f, 
    -0.32670578f, -0.17124103f, 0.03858906f, 0.31571487f, 0.12448470f, 0.20507595f, 0.02570790f, 0.06430335f, 
    0.00008186f, -0.04823422f, -0.06202428f, -0.14072445f, -0.04639606f, -0.04185812f, -0.04319696f, 0.00822164f, 
    0.04947776f, 0.04933105f, 0.11820062f, 0.05969572f, -0.23374222f, 0.07914053f, 0.05381732f, -0.25048035f, 
    0.32361796f, 0.01118291f, 0.08960411f, 0.01623361f, 0.04748449f, -0.16934654f, 0.04640424f, 0.03960601f, 
    0.11401891f, 0.08857568f, -0.03694263f, 0.01241991f, 0.02106155f, -0.00836389f, -0.01697782f, 0.22841790f, 
    0.02033265f, 0.30265027f, -0.00548179f, 0.19101328f, -0.24251226f, -0.00033561f, -0.00361052f, 0.12539329f, 
    0.06248704f, -0.05424680f, -0.03477781f, 0.07129153f, 0.03195685f, 0.01725497f, 0.07283758f, 0.02041538f, 
    -0.13488682f, 0.04973986f, 0.02145191f, 0.04144949f, -0.33501589f, -0.12049002f, 0.14409138f, -0.04366562f, 
    0.34808022f, -0.02882497f, -0.11289417f, 0.01830045f, 0.03251601f, -0.05238568f, -0.06362866f, -0.09801067f, 
    -0.03723345f, 0.00044424f, 0.08584117f, 0.07856677f, -0.00622171f, 0.10772874f, -0.09678669f, -0.05958918f, 
    0.07275134f, 0.05188895f, 0.17945206f, 0.06060891f, -0.05626037f, -0.04996872f, 0.23624346f, 0.08389006f, 
    0.01996791f, -0.10795771f, -0.08051887f, 0.10437723f, 0.08469877f, -0.07477030f, 0.04055553f, 0.05679531f, 
    0.05378431f, 0.07884161f, 0.10434555f, 0.13169323f, 0.03749749f, 0.01972096f, -0.12453766f, 0.13508016f, 
    -0.12642682f, -0.14956257f, 0.05184703f, 0.02051402f, -0.03558991f, 0.11106509f, 0.08294234f, 0.04653515f, 
    0.06132571f, 0.08010469f, -0.00587556f, -0.02465008f, 0.05762400f, 0.10084707f, -0.11416046f, 0.03147460f, 
    0.25244269f, -0.18722668f, 0.24828131f, 0.25267434f, -0.05510738f, -0.11109307f, -0.02649533f, 0.05684181f, 
    -0.00660067f, -0.00985644f, 0.06253371f, 0.11250658f, -0.06449754f, -0.12528342f, -0.05748911f, -0.07734004f, 
    0.00893917f, -0.03061951f, 0.03722163f, -0.06516592f, -0.22842692f, 0.07791962f, -0.07232497f, -0.02166225f, 
    -0.01606520f, 0.00305218f, -0.05539564f, -0.00740437f, 0.05193075f, -0.05610368f, -0.09457518f, 0.07722440f, 
    -0.13573875f, 0.05210348f, -0.05198498f, 0.01271899f, -0.12228274f, -0.05581272f, -0.09944862f, -0.20829287f, 
    0.18480651f, 0.50599915f, -0.12251145f, 0.27780157f, 0.05803999f, 0.09161042f, 0.12280671f, -0.03788330f, 
    0.01010593f, 0.05349646f, -0.06473880f, 0.14078927f, 0.09080492f, -0.01247228f, 0.06805645f, 0.03561644f, 
    0.12398141f, 0.13967979f, 0.02516433f, 0.09640229f, 0.04670531f, -0.20908117f, 0.11507674f, -0.13295850f, 
    -0.29432777f, -0.06800830f, 0.09626794f, 0.01504470f, 0.07584974f, -0.00893389f, 0.02637375f, 0.01932332f, 
    0.01035378f, -0.14376193f, -0.01348933f, -0.06149933f, -0.03554316f, -0.08088546f, -0.02919293f, 0.02866408f, 
    -0.28109223f, -0.02216604f, 0.11195057f, 0.00562763f, 0.11133254f, 0.06797045f, 0.10613398f, -0.08882955f, 
    -0.00350858f, -0.03977630f, 0.11742473f, 0.10131007f, -0.04120993f, -0.00961250f, 0.01744830f, -0.09150793f, 
    -0.10644484f, 0.07590644f, 0.06317274f, 0.04393933f, 0.03757179f, 0.06018141f, 0.23012419f, 0.02862252f, 
    -0.07786543f, 0.18280447f, 0.06284703f, 0.14552322f, 0.02128124f, 0.02052836f, -0.02558746f, 0.06961952f, 
    -0.01198508f, 0.21837780f, -0.06197049f, 0.04950346f, -0.00442917f, 0.15242824f, -0.03028061f, 0.10672437f, 
    -0.09247141f, 0.14653088f, -0.14555396f, 0.09341475f, 0.11972900f, 0.07541586f, -0.13186482f, -0.13243246f, 
    -0.05089206f, 0.01944438f, -0.01863461f, 0.06160815f, -0.10192567f, -0.04562765f, 0.04657178f, -0.15001656f, 
    0.02893027f, -0.01936803f, 0.08077753f, -0.04287358f, 0.36161250f, -0.36938673f, -0.17038700f, 0.07726588f, 
    0.42259303f, -0.12009005f, -0.06625559f, 0.07042714f, -0.04562048f, 0.12902936f, 0.02978322f, -0.05783768f, 
    -0.06911169f, -0.01324295f, -0.00353332f, -0.11112607f, -0.06970479f, 0.09776276f, 0.15916649f, 0.06314410f, 
    -0.06327802f, -0.09393034f, 0.00150446f, 0.07558144f, 0.08944757f, 0.11295263f, -0.07270452f, 0.05140335f, 
    0.15918723f, 0.03850260f, -0.04314944f, -0.02913924f, 0.03041583f, 0.02418673f, -0.06526658f, -0.08194301f, 
    0.02250006f, -0.07578518f, 0.01331153f, -0.05930379f, 0.16266695f, 0.11362448f, 0.11651902f, -0.00509436f, 
    -0.05315209f, 0.05211380f, -0.02325989f, 0.14310004f, -0.04947794f, -0.08407430f, -0.00458223f, 0.00711824f, 
    -0.01970974f, 0.09023137f, 0.04686851f, 0.05171613f, 0.02256377f, -0.17520632f, -0.08353999f, -0.09592342f, 
    -0.10305960f, 0.14845420f, 0.31089053f, 0.00689861f, 0.11883473f, -0.00384133f, -0.07619096f, 0.00992577f, 
    -0.07203990f, 0.00504712f, -0.04529131f, -0.06054114f, 0.02729997f, -0.18250608f, -0.17442279f, -0.06315909f, 
    0.05671248f, 0.01927042f, -0.03197535f, -0.10345211f, -0.46221629f, 0.02871654f, 0.32329047f, 0.18714744f, 
    0.25896677f, -0.00603180f, 0.05518151f, -0.00903387f, 0.00847418f, -0.04699234f, -0.01119532f, -0.07729816f, 
    0.21396805f, 0.04422458f, -0.08389408f, -0.11397450f, -0.01590644f, 0.03929373f, 0.14107269f, 0.04948102f, 
    0.18895769f, 0.02955761f, -0.02831741f, -0.01703502f, -0.08033490f, -0.04944559f, 0.00638623f, -0.07264845f, 
    0.02090677f, -0.08819224f, -0.00063374f, 0.08105282f, 0.01509099f, -0.09419641f, -0.00703379f, -0.06004384f, 
    -0.01565181f, 0.10185387f, 0.10258725f, 0.13834924f, -0.36791465f, 0.09591677f, -0.07079860f, 0.03210118f, 
    -0.00822785f, 0.02828080f, -0.09916392f, 0.10209161f, -0.01540795f, 0.00958999f, -0.13778667f, -0.01094899f, 
    -0.00513562f, 0.05315723f, 0.09149933f, 0.07207933f, 0.00191090f, 0.09786201f, -0.06532353f, -0.00979816f, 
    0.13280188f, 0.09712194f, 0.18982410f, -0.01555764f, -0.13477395f, -0.16137394f, 0.11976811f, 0.02528273f, 
    0.03965713f, -0.05492395f, -0.00875722f, -0.08052281f, 0.08750671f, 0.06018021f, 0.01567525f, 0.01865206f, 
    0.14586452f, 0.08726113f, -0.05159848f, 0.02851636f, 0.18172905f, 0.34869504f, -0.09465720f, 0.05879765f, 
    -0.05865867f, 0.03446684f, -0.00297003f, -0.00830579f, 0.05462898f, 0.14745082f, -0.05221555f, 0.10808858f, 
    0.10851789f, 0.10851882f, -0.05988282f, 0.06600884f, 0.07040378f, 0.02553315f, -0.15760615f, 0.09160104f, 
    0.04071961f, -0.02890490f, 0.47594133f, 0.09747406f, 0.21638384f, 0.07740301f, -0.10742459f, 0.00072319f, 
    -0.00989498f, -0.03724460f, -0.00346159f, -0.00146138f, -0.00936981f, -0.01224060f, -0.08759933f, 0.09183816f, 
    0.02549689f, -0.04801938f, 0.10518201f, -0.05610504f, -0.11783390f, 0.14573839f, -0.05485178f, 0.13916637f, 
    0.06639539f, -0.11907005f, 0.08395123f, -0.17060888f, -0.04873626f, 0.06732877f, 0.00237120f, 0.02181327f, 
    0.02444363f, 0.05669146f, -0.02303717f, -0.15052295f, -0.04941590f, -0.07534081f, -0.00610367f, 0.12325671f, 
    0.51067275f, -0.09374397f, 0.38598189f, -0.13326317f, 0.00200431f, -0.16164173f, 0.22013798f, -0.11273913f, 
    -0.08837092f, 0.05884207f, -0.13859193f, -0.10967687f, 0.01342199f, 0.01094148f, 0.01605200f, -0.06112363f, 
    0.02945656f, 0.03610593f, 0.03464130f, 0.07143565f, -0.24432887f, 0.22641753f, 0.06506732f, 0.12616716f, 
    -0.02425235f, -0.04158301f, -0.09955025f, -0.11914780f, 0.01742303f, 0.03174526f, -0.01289919f, 0.06653085f, 
    0.05233226f, -0.02799884f, -0.06290907f, 0.05260606f, 0.07424364f, -0.03467414f, 0.06020506f, -0.06290933f, 
    -0.40352672f, 0.02379262f, -0.10644334f, -0.12612745f, 0.02985218f, 0.06187702f, 0.19662173f, -0.03550030f, 
    0.02915427f, 0.12900968f, -0.00202712f, 0.07513076f, -0.03300929f, -0.03023908f, 0.06180668f, -0.02654053f, 
    0.04285478f, -0.00723374f, 0.00936052f, 0.12045421f, -0.25443134f, 0.05631917f, -0.06456809f, 0.15136039f, 
    -0.11120857f, -0.02253852f, 0.10426028f, 0.04336700f, 0.08690238f, -0.08108117f, 0.10620558f, -0.02369118f, 
    -0.08787405f, 0.00524508f, 0.06328456f, 0.12867440f, 0.19559622f, 0.02094360f, 0.27140030f, 0.16208540f, 
    -0.21187395f, 0.16876008f, 0.16391975f, 0.09577198f, 0.21216777f, -0.00039431f, 0.08092867f, -0.04452688f, 
    0.07599168f, 0.06777259f, -0.03034375f, -0.10778113f, -0.01958475f, 0.10059106f, 0.04501295f, -0.01968280f, 
    -0.07963620f, -0.05305170f, -0.04481065f, -0.01494624f, -0.12934226f, -0.21757597f, 0.07116882f, 0.16517963f, 
    -0.08864917f, -0.07168256f, -0.11971862f, 0.00671299f, -0.13646996f, 0.10914182f, -0.15070054f, 0.05549922f, 
    -0.06965622f, -0.07454585f, 0.00704876f, 0.01977026f, -0.10437636f, -0.07655443f, -0.00369910f, 0.07266746f, 
    0.12589085f, -0.29457328f, -0.02437781f, 0.06567084f, -0.19217327f, 0.08007403f, -0.00629572f, 0.05398892f, 
    -0.14380819f, 0.07897408f, -0.00375718f, 0.00125468f, -0.03738058f, 0.02678747f, 0.00767529f, 0.08446274f, 
    0.02958240f, -0.01116565f, 0.05154696f, 0.03829300f, -0.13361113f, -0.02374995f, 0.10299246f, 0.09396897f, 
    -0.01176931f, 0.10398329f, -0.06155423f, 0.01131212f, 0.09432855f, -0.04262929f, 0.02847062f, 0.00057838f, 
    -0.03960717f, -0.06482518f, 0.01028238f, 0.07590662f, -0.00547259f, -0.01953427f, -0.07728330f, -0.05378346f, 
    -0.20733051f, 0.26861709f, 0.06635374f, 0.22602691f, 0.25175592f, 0.13124688f, 0.00573362f, 0.06038867f, 
    0.18855043f, 0.03198732f, -0.00529544f, -0.08323285f, -0.04748312f, 0.12912235f, -0.04131721f, 0.04893795f, 
    0.12668942f, -0.01072005f, 0.00248014f, -0.00672261f, -0.40977770f, 0.20069060f, -0.20522492f, -0.19160497f, 
    0.04462004f, 0.05105818f, 0.18214722f, -0.13522488f, 0.11158402f, -0.00742831f, 0.02201292f, 0.26957837f, 
    0.10713044f, -0.00384161f, 0.08649334f, 0.07929768f, 0.15811621f, 0.05199510f, 0.15194020f, 0.07627270f, 
    -0.29708129f, 0.00486747f, 0.07223155f, 0.24585411f, 0.00738440f, -0.05930783f, -0.02496239f, 0.01270164f, 
    0.10982847f, 0.00826518f, -0.12575027f, 0.02047131f, 0.14614351f, -0.00357599f, 0.04279638f, -0.04625055f, 
    0.00607102f, 0.02936837f, 0.16197437f, -0.06699292f, 0.33312964f, 0.09788099f, -0.04353469f, -0.07186033f, 
    0.09960012f, -0.05354199f, 0.09210330f, -0.15843913f, -0.02427767f, -0.14653465f, 0.09548120f, -0.00981998f, 
    -0.03369329f, 0.06963817f, 0.10614894f, 0.14191064f, -0.06070265f, -0.03527164f, -0.11156594f, -0.00160085f, 
    0.03244780f, 0.27384901f, 0.11098594f, 0.00643841f, 0.00380016f, 0.11881763f, 0.05625728f, 0.05073818f, 
    0.18085852f, 0.14434388f, 0.06113293f, 0.11429943f, -0.08217104f, -0.07309116f, 0.01917305f, 0.03469939f, 
    0.06154649f, -0.00698158f, 0.08026890f, 0.12537122f, -0.00817046f, 0.53456032f, 0.00890276f, 0.22295582f, 
    0.16209173f, -0.23370689f, 0.00475321f, -0.16287644f, -0.01661002f, -0.02572617f, -0.05132726f, -0.00607064f, 
    -0.05873880f, 0.10586466f, -0.02031156f, 0.00727105f, 0.02616217f, -0.01684311f, 0.04122264f, 0.04200820f, 
    -0.24774489f, 0.48453212f, 0.04338482f, -0.11249585f, 0.16913877f, 0.08666095f, -0.04820550f, 0.33313218f, 
    -0.01005610f, 0.03136525f, -0.04493693f, -0.07360477f, -0.16647971f, 0.05706726f, -0.03901564f, 0.03466742f, 
    -0.02726354f, 0.04466017f, -0.07146893f, 0.04590952f, 0.10628341f, 0.04409479f, 0.24050304f, 0.01656708f, 
    -0.05079152f, -0.10388501f, 0.10771319f, -0.11728559f, -0.02713415f, 0.07660572f, -0.05294214f, -0.04487575f, 
    0.09975996f, -0.08950502f, -0.06333859f, -0.02083833f, -0.07188839f, 0.06150171f, -0.03221396f, 0.05846232f, 
    0.49402174f, -0.43879744f, 0.10808852f, -0.15227009f, -0.03885887f, -0.04733527f, 0.08424199f, -0.02321442f, 
    0.00043270f, -0.00273852f, -0.21279384f, 0.03514008f, 0.01939414f, -0.03354809f, -0.04676989f, -0.05753847f, 
    0.10801641f, 0.04511910f, 0.13955542f, -0.11939929f, -0.39805001f, 0.23141496f, 0.06314963f, 0.13148102f, 
    0.30483070f, -0.08348356f, -0.18664680f, -0.03508973f, 0.14285943f, 0.05346826f, 0.10811457f, 0.08047942f, 
    0.13274592f, 0.07890923f, -0.01709354f, 0.05023706f, 0.06267277f, -0.02332521f, -0.02802377f, -0.09871377f, 
    0.04356817f, 0.01282637f, -0.14746167f, -0.23291202f, 0.09444279f, 0.00483382f, -0.00570473f, 0.00898990f, 
    0.01805156f, -0.00728213f, -0.05709807f, -0.10278693f, -0.00072670f, 0.09543720f, -0.01137955f, 0.06796630f, 
    0.07118215f, 0.02304189f, -0.03842334f, 0.01967613f, -0.15588245f, 0.00306181f, -0.14906180f, 0.01777202f, 
    -0.02872725f, 0.08466770f, -0.01673662f, 0.07937404f, -0.01797626f, 0.00715569f, 0.06425993f, 0.02434467f, 
    0.02680376f, 0.09646412f, -0.01261173f, 0.03479870f, 0.11895823f, 0.13025105f, -0.02268380f, 0.05327914f, 
    0.24607114f, 0.00546877f, -0.06172183f, -0.01043324f, 0.09243456f, -0.06346166f, 0.13300526f, 0.08894678f, 
    0.07930327f, 0.07724199f, -0.00752971f, -0.01819676f, 0.03334504f, -0.01250401f, -0.03484735f, -0.03513232f, 
    -0.15931669f, -0.01400999f, -0.03748832f, -0.12344375f, -0.29404801f, 0.00748803f, 0.13053545f, 0.29578847f, 
    -0.26346514f, -0.04966164f, 0.04812605f, -0.00495290f, -0.04814636f, 0.05007299f, -0.07224210f, -0.00269846f, 
    -0.05464232f, -0.06357202f, 0.01990404f, -0.04486536f, -0.15513848f, 0.01375450f, 0.10648809f, 0.08207864f, 
    0.17946023f, -0.03139318f, -0.24631599f, 0.03195134f, 0.00925321f, 0.01854740f, 0.06644361f, 0.04661078f, 
    -0.01563072f, 0.03577523f, -0.01230214f, 0.03255633f, -0.17076331f, 0.10471206f, 0.06118172f, 0.10512622f, 
    0.20478460f, -0.00915112f, 0.07230487f, 0.01211308f, 0.10179558f, -0.03980386f, -0.07188624f, -0.06544915f, 
    0.05390516f, -0.09157416f, -0.03990136f, 0.06316227f, 0.05714640f, 0.11074999f, -0.01093646f, 0.01372461f, 
    0.01027880f, -0.10404014f, -0.07785940f, 0.03438288f, -0.06571373f, 0.08217957f, -0.11146121f, -0.04670430f, 
    0.06939137f, -0.11624759f, -0.22839954f, 0.03669094f, 0.06185072f, 0.00788130f, 0.07068025f, 0.17696507f, 
    0.18486574f, -0.01307994f, -0.10848197f, -0.10518613f, 0.02928544f, 0.03488867f, 0.00762321f, 0.08885161f, 
    -0.04225848f, 0.13406235f, 0.09117625f, 0.02189590f, -0.09693477f, -0.21873291f, -0.26026553f, -0.23220536f, 
    0.00580181f, -0.10435407f, -0.00453092f, 0.03608369f, 0.13495159f, -0.13746607f, -0.02355477f, 0.11188652f, 
    0.16259965f, 0.05846408f, 0.03065456f, 0.02495342f, 0.02122611f, 0.16424863f, -0.05721839f, 0.03040483f, 
    -0.27490398f, 0.15492241f, 0.12402370f, 0.23547283f, 0.04678964f, -0.08894631f, -0.06888229f, 0.14292903f, 
    0.10513408f, 0.04519865f, 0.03376630f, 0.06230313f, 0.07871239f, 0.03076309f, -0.05486305f, 0.04733934f, 
    0.00834120f, 0.03130451f, 0.02921172f, 0.08523031f, -0.11532378f, -0.18391177f, 0.25054726f, -0.11123779f, 
    0.20718542f, 0.07693466f, 0.07256849f, -0.10675474f, 0.05050366f, 0.00658527f, 0.07257675f, 0.04785234f, 
    0.02972954f, 0.08099584f, 0.03900198f, 0.01339956f, -0.00733197f, -0.01582213f, -0.14049929f, 0.01700300f, 
    0.39295742f, 0.21926613f, -0.12513761f, -0.22750261f, 0.09619143f, 0.14381218f, 0.12711912f, -0.03087723f, 
    0.08572914f, -0.00240624f, 0.03236649f, 0.10147613f, -0.04386416f, -0.01422700f, -0.03808107f, -0.05794392f, 
    0.04412616f, 0.08922379f, -0.05937470f, 0.03874844f, 0.15294874f, -0.16713488f, 0.02449262f, 0.09424424f, 
    -0.10660286f, -0.21817431f, -0.08994119f, -0.07158992f, 0.14284067f, 0.04226490f, -0.00151640f, -0.01378246f, 
    -0.04800955f, 0.00734375f, -0.07796115f, -0.10917135f, -0.04725379f, 0.00080862f, -0.09715574f, 0.05200721f, 
    0.08900656f, 0.06973143f, -0.16314603f, 0.01134394f, 0.21926947f, 0.07859178f, 0.09426203f, 0.02665094f, 
    -0.09103733f, -0.00161007f, -0.01940136f, -0.03241859f, 0.05939376f, -0.02915797f, -0.07267544f, -0.02286411f, 
    0.04710390f, 0.00932323f, -0.04125399f, -0.06399696f, 0.05409586f, 0.04881891f, 0.09585015f, -0.28751111f, 
    -0.02114474f, -0.01653716f, -0.05585428f, 0.09968409f, -0.07783374f, -0.10256482f, -0.00119801f, -0.07897981f, 
    -0.11561161f, 0.07327451f, -0.00097949f, -0.05453877f, 0.08003506f, -0.08643556f, 0.08533432f, -0.04089645f, 
    -0.05842681f, -0.15840538f, -0.00035118f, -0.07094443f, -0.53775859f, -0.11935171f, -0.13063939f, 0.02273965f, 
    0.12811767f, -0.02368813f, 0.03006206f, 0.06574132f, -0.03769773f, -0.04515186f, 0.00434230f, -0.12853494f, 
    -0.11312567f, 0.04585453f, 0.20075364f, -0.10790592f, 0.47688285f, 0.10391346f, 0.12562068f, 0.08090032f, 
    0.40988946f, -0.04853242f, -0.01654595f, 0.17042966f, 0.02189417f, -0.01488602f, -0.02830245f, 0.07030316f, 
    0.02990946f, 0.12975690f, -0.13399549f, -0.02108424f, -0.07539222f, 0.01476486f, 0.00677710f, 0.03349095f, 
    -0.18863846f, -0.01148867f, 0.12323594f, 0.24991934f, 0.06330543f, 0.07554097f, -0.12323426f, -0.06074518f, 
    0.16949667f, 0.27154344f, -0.02091785f, -0.06485811f, 0.04983435f, 0.03532702f, 0.02517626f, 0.07331868f, 
    -0.05804002f, -0.05808973f, -0.02007688f, 0.03079815f, -0.04292643f, 0.09230357f, 0.06099763f, -0.06663240f, 
    0.24525018f, 0.07741048f, -0.06414679f, -0.06780529f, -0.03224764f, 0.10854810f, 0.10518719f, 0.01693935f, 
    0.03863839f, -0.03558862f, 0.03805303f, -0.00670352f, 0.03201632f, -0.05904304f, 0.25797534f, -0.04507529f, 
    0.16538306f, -0.15245387f, 0.04295950f, 0.18340653f, -0.15371530f, -0.10432362f, 0.01692055f, 0.02605166f, 
    0.13838299f, 0.00972538f, 0.01443689f, 0.01829104f, 0.10744036f, 0.04450550f, -0.00522930f, 0.08260334f, 
    -0.09796218f, 0.11973713f, -0.11282632f, -0.03243109f, -0.38697252f, -0.34174314f, 0.03107418f, 0.03073991f, 
    -0.20261872f, -0.07183969f, 0.13391088f, -0.00966437f, -0.20319289f, -0.20995741f, 0.08395785f, -0.04487553f, 
    -0.06629397f, -0.02447050f, -0.08842710f, -0.12673283f, -0.01194957f, 0.01771517f, -0.01386070f, -0.02657697f, 
    0.07509004f, 0.38318956f, -0.02949804f, 0.08712266f, 0.20188436f, -0.01017443f, -0.08527392f, -0.08519988f, 
    -0.07231401f, 0.00044316f, 0.02645047f, 0.03423496f, 0.10237698f, -0.04876532f, -0.07775219f, 0.12974136f, 
    0.05470040f, -0.06170363f, 0.14541936f, 0.03805913f, 0.21918233f, 0.24827930f, -0.04578359f, -0.23596185f, 
    0.13169369f, -0.06868358f, -0.07089256f, 0.12942736f, 0.00008035f, -0.06813935f, 0.01116699f, 0.05077493f, 
    -0.05558539f, -0.03998563f, 0.05915624f, 0.07234717f, -0.03817349f, -0.05616587f, 0.08665054f, 0.04511910f, 
    0.23555487f, 0.18467075f, -0.14150818f, -0.30467010f, -0.27092803f, -0.14303078f, -0.07020637f, -0.02687025f, 
    0.05495276f, 0.11454417f, 0.04216570f, -0.04264730f, 0.03104845f, -0.04204217f, 0.16218212f, 0.04290974f, 
    -0.16341166f, -0.03453506f, -0.10002642f, 0.03783896f, -0.27136427f, 0.00254574f, 0.10134620f, 0.16119319f, 
    0.03381451f, -0.00449995f, -0.17759284f, -0.11011508f, -0.02315352f, 0.23986019f, 0.10910195f, -0.14346038f, 
    0.04166310f, 0.10232525f, 0.22449471f, 0.02041748f, -0.06320207f, 0.08899526f, 0.09347859f, -0.09882537f, 
    -0.03686094f, -0.18350264f, 0.10269365f, 0.02181683f, 0.45778990f, 0.01681157f, 0.07413705f, 0.05791100f, 
    -0.02423442f, 0.01108112f, -0.00667997f, -0.08081404f, -0.02184859f, -0.09580530f, 0.00426174f, -0.10239945f, 
    0.04606987f, 0.04508434f, 0.01479258f, 0.12521335f, 0.03448062f, 0.30550516f, 0.07467681f, 0.07196832f, 
    -0.20091040f, -0.00205330f, 0.01503091f, -0.03754888f, 0.08887196f, 0.01884245f, 0.10209979f, 0.10620685f, 
    0.07623283f, 0.00744164f, -0.07772423f, 0.07117552f, -0.00485090f, -0.01847314f, 0.06912809f, 0.09840993f, 
    0.15077263f, -0.16229048f, -0.16239426f, -0.37663433f, -0.21333055f, 0.10203923f, -0.04425288f, -0.07427172f, 
    0.06903896f, 0.16236050f, 0.02629141f, 0.03976491f, -0.04586257f, 0.10184947f, -0.00956185f, -0.05645318f, 
    -0.06363700f, -0.01871555f, 0.03200969f, -0.10327019f, 0.51366377f, 0.09695552f, 0.28698683f, -0.11639990f, 
    0.22739528f, 0.18824016f, -0.11705439f, 0.05116261f, 0.06208885f, 0.04398218f, -0.10174607f, -0.01145931f, 
    0.11461249f, -0.00724235f, 0.03139640f, 0.01560860f, -0.04730774f, -0.16966657f, 0.05141122f, -0.06709506f, 
    0.28857383f, -0.26016846f, 0.23676980f, -0.08788218f, -0.15684497f, -0.06591757f, -0.03459070f, 0.11293649f, 
    0.02159960f, -0.04732632f, -0.02260631f, 0.02875377f, -0.04977488f, -0.02781980f, 0.03590635f, -0.01219194f, 
    0.01297761f, 0.04241149f, -0.05680527f, -0.01054674f, 0.20595995f, -0.02742876f, -0.00637062f, 0.00529593f, 
    0.05191630f, 0.03328268f, -0.00296267f, -0.03859836f, 0.00795523f, -0.00422479f, -0.08859658f, 0.01286306f, 
    0.08879680f, 0.01818848f, -0.01906303f, 0.11209228f, 0.01086264f, 0.03232444f, 0.03619184f, 0.01442582f, 
    -0.22012062f, -0.18237314f, -0.15341324f, 0.14450824f, 0.22676346f, -0.01184938f, 0.00471950f, 0.05028075f, 
    -0.07608440f, 0.01073623f, -0.00964460f, -0.13376161f, 0.05357660f, 0.08690915f, -0.02096140f, 0.12763135f, 
    0.16274334f, 0.28666857f, 0.02590858f, 0.08388579f, -0.36955518f, 0.01960852f, 0.00624424f, 0.23253782f, 
    -0.29969081f, 0.03316296f, 0.10817112f, -0.10052904f, 0.04617649f, -0.10214309f, 0.12463286f, 0.01334397f, 
    -0.02950671f, -0.15498407f, 0.05546283f, 0.06825306f, 0.03173769f, -0.12974761f, 0.00450769f, -0.16737804f, 
    0.01702487f, -0.03352860f, -0.00800145f, 0.02096216f, 0.21084870f, 0.00399649f, -0.05327553f, -0.05365247f, 
    -0.04180622f, -0.01847270f, -0.01677271f, 0.08286610f, -0.14449427f, -0.08121081f, -0.04191973f, 0.00792699f, 
    -0.09010632f, -0.00582103f, 0.08542287f, 0.07893662f, 0.30326927f, -0.47030318f, -0.28121525f, 0.05069856f, 
    0.13519721f, 0.08944314f, -0.00410292f, -0.03105256f, -0.02882252f, -0.00902795f, -0.15340365f, 0.00159716f, 
    0.09756021f, 0.12790649f, 0.04851745f, -0.08647125f, 0.08098750f, 0.11506027f, -0.11326533f, 0.03947460f, 
    0.14473501f, 0.24699509f, -0.15062407f, -0.01159834f, 0.23237553f, -0.02471338f, 0.14661615f, -0.06599534f, 
    -0.08642351f, 0.10144316f, 0.04352150f, -0.09923791f, -0.09759162f, -0.05102566f, -0.02759682f, -0.00336836f, 
    0.02845963f, -0.01601951f, 0.18960276f, 0.04534055f, 0.11974031f, 0.12950723f, 0.20565349f, -0.26952863f, 
    -0.29002956f, 0.04779472f, 0.05444185f, 0.15452397f, -0.02519949f, 0.10815448f, -0.06970982f, 0.02991466f, 
    -0.01369676f, -0.00440024f, -0.01738680f, 0.06839049f, -0.02861006f, 0.02191735f, 0.17618318f, 0.02541854f, 
    0.38860071f, -0.17867583f, -0.42750382f, 0.01843717f, -0.00312392f, 0.01652103f, -0.05131952f, 0.13061455f, 
    -0.04930302f, 0.03750380f, -0.05142691f, 0.06696273f, -0.04310740f, 0.15493074f, 0.20675194f, -0.03364182f, 
    -0.00653104f, -0.10153529f, 0.02362823f, -0.09314620f, 0.24540934f, -0.06903827f, -0.25643054f, 0.00714191f, 
    0.01453382f, 0.11516964f, 0.00872278f, -0.11196703f, 0.05475911f, 0.02179577f, -0.06796287f, -0.04513673f, 
    0.03106738f, 0.02058830f, -0.06441141f, -0.01154547f, 0.03165545f, -0.05501972f, -0.14198422f, -0.04163950f, 
    -0.39492324f, -0.02874187f, -0.00859883f, 0.14749613f, -0.14461027f, 0.11542621f, 0.06899216f, 0.02369459f, 
    0.10024643f, -0.14887203f, 0.03996091f, 0.08925881f, 0.01655495f, 0.08700590f, -0.05366232f, 0.11372861f, 
    0.16128781f, 0.19557680f, 0.10406606f, 0.04293651f, -0.01629386f, -0.03605165f, -0.02219577f, 0.07677860f, 
    0.21624330f, 0.02956548f, -0.00689223f, -0.13477458f, 0.02621583f, 0.07716962f, -0.01930040f, 0.08846916f, 
    0.00634799f, -0.00220911f, -0.01505941f, 0.00391677f, -0.07351644f, -0.01191057f, -0.03968148f, 0.04029077f, 
    -0.38378572f, 0.11322741f, 0.21450809f, -0.03006921f, -0.50920457f, 0.01153096f, 0.07231257f, -0.03393529f, 
    0.03558363f, 0.13395412f, -0.02822864f, -0.00649328f, -0.08497209f, -0.06347223f, -0.08986176f, -0.10211795f, 
    -0.08861557f, -0.05362026f, -0.05708533f, -0.00898673f, -0.05794761f, -0.19429021f, -0.03463581f, 0.08579721f, 
    0.27682036f, -0.00539730f, -0.03940833f, -0.00545534f, 0.09045481f, 0.01589427f, -0.13449563f, -0.13799433f, 
    0.03239888f, 0.01720004f, -0.01658760f, 0.00819043f, -0.02947607f, -0.00250686f, -0.09411590f, -0.08893467f, 
    -0.25882423f, 0.07268126f, 0.06316642f, 0.14320271f, 0.30364618f, -0.06222297f, 0.13824686f, 0.04214743f, 
    0.07745911f, 0.13345738f, 0.04325226f, -0.06228333f, 0.11584859f, -0.04692617f, -0.04649001f, 0.24226238f, 
    0.09782829f, 0.02905645f, 0.00205371f, 0.08141608f, -0.59561563f, 0.26797196f, -0.01703579f, 0.06586654f, 
    -0.26710621f, 0.05091750f, 0.23877762f, 0.05199382f, 0.03095880f, 0.08657919f, -0.02149617f, -0.02029767f, 
    0.05689099f, 0.05982778f, 0.06542309f, 0.08819415f, -0.06822414f, 0.20291944f, -0.18664441f, 0.03053815f, 
    -0.01281513f, -0.03909821f, 0.04153347f, 0.02825951f, 0.04617478f, 0.00198768f, 0.03241083f, 0.04739301f, 
    0.01931901f, 0.00448604f, 0.00066111f, -0.02531021f, -0.03859633f, 0.01091609f, 0.02332466f, -0.01200304f, 
    -0.05715850f, -0.00870562f, 0.00191422f, 0.01245338f, 0.03442121f, 0.03023881f, -0.06011999f, -0.04512044f, 
    -0.01268630f, -0.00334892f, -0.04769501f, -0.02810556f, 0.00914150f, -0.01379213f, 0.01976757f, -0.00886245f, 
    0.00937530f, 0.04972307f, 0.04453737f, 0.03210913f, -0.00347126f, -0.03738882f, -0.00840319f, 0.00685672f, 
    0.06420168f, 0.04138878f, -0.02386313f, -0.01917969f, -0.01734185f, 0.04526845f, 0.02695730f, 0.02029132f, 
    0.02030720f, -0.00035623f, -0.03652992f, 0.04605099f, 0.02703723f, 0.04416972f, -0.02917604f, -0.03979121f, 
    0.02989327f, 0.02589775f, -0.04971607f, -0.01258310f, -0.00409187f, -0.02443350f, 0.03582102f, 0.02105278f, 
    -0.01596537f, 0.04717448f, -0.00150373f, -0.06686440f, 0.03972560f, -0.02368653f, -0.05149494f, 0.02000500f, 
    -0.06168942f, -0.01206712f, -0.03826322f, -0.06162053f, 0.00266609f, 0.01938534f, -0.02967473f, -0.05850215f, 
    0.04405266f, 0.03038682f, 0.01918654f, 0.02482475f, 0.02274024f, 0.00374372f, -0.03577563f, -0.02579507f, 
    -0.00845704f, -0.00066337f, 0.00939179f, -0.02012881f, -0.00481773f, 0.00792668f, 0.03362567f, -0.03537199f, 
    0.02972722f, -0.04453098f, -0.05982248f, 0.04167594f, 0.02716651f, -0.02516584f, 0.01496275f, -0.03021170f, 
    -0.04658317f, -0.03541201f, -0.04899762f, 0.01865739f, 0.04142594f, -0.04144855f, 0.00179595f, -0.02285350f, 
    -0.04435924f, 0.04742965f, 0.01042724f, -0.02441638f, 0.01225273f, -0.00674554f, -0.04977585f, 0.04207047f, 
    -0.00945374f, 0.00797949f, 0.04085422f, 0.00482860f, -0.03783006f, 0.01979725f, -0.02404786f, 0.02359141f, 
    -0.06029288f, -0.01524536f, -0.03118810f, -0.04065773f, -0.06221393f, -0.05319153f, -0.06184873f, 0.00883971f, 
    -0.00536775f, -0.05415285f, -0.01727503f, -0.00072693f, -0.05958762f, 0.02881281f, -0.00774406f, 0.00193156f, 
    0.02048601f, 0.03182760f, -0.04354886f, 0.00529782f, -0.05017912f, -0.03830445f, -0.00271750f, -0.01285567f, 
    -0.02191565f, -0.03330192f, 0.01116114f, -0.00452407f, -0.01839442f, -0.02823065f, -0.01144028f, 0.01211943f, 
    0.00771092f, 0.00798636f, 0.00099976f, -0.03400623f, 0.04092288f, -0.04031521f, -0.04809464f, 0.01233029f, 
    -0.05389893f, -0.04910028f, -0.05871977f, 0.02781721f, 0.03367877f, 0.02826483f, 0.01302684f, 0.02756870f, 
    0.01774144f, -0.01603917f, 0.03632611f, -0.00851111f, -0.00495504f, -0.00448548f, -0.01192395f, 0.01210177f, 
    0.02948968f, -0.00772027f, -0.00024839f, 0.00043941f, -0.05294755f, -0.02105117f, 0.03197720f, -0.02559429f, 
    -0.03545153f, -0.03252542f, 0.01134600f, -0.04638781f, 0.01347617f, -0.03831612f, -0.04186878f, 0.02243469f, 
    0.00688194f, -0.02399216f, -0.03374074f, 0.02207827f, 0.01789654f, -0.02776838f, 0.02865960f, 0.02836012f, 
    -0.00936193f, 0.03267854f, -0.01602469f, 0.03628768f, 0.02493135f, -0.04833058f, -0.06035865f, 0.00490991f, 
    -0.05364591f, 0.00983015f, -0.01201552f, 0.01189098f, 0.00643648f, -0.04233421f, 0.03519339f, -0.04286407f, 
    0.01990687f, -0.02828769f, -0.01208520f, -0.02994473f, -0.03317608f, -0.00550497f, 0.04087019f, -0.04835917f, 
    0.05628888f, -0.02882147f, -0.02593963f, 0.04125956f, -0.02716105f, -0.05212691f, 0.02823042f, 0.02211778f, 
    -0.00221795f, 0.00955655f, -0.06218003f, -0.06353717f, -0.05184590f, -0.01180064f, -0.03436976f, 0.04586210f, 
    0.00788338f, -0.05668488f, 0.00753225f, -0.04235098f, 0.03338014f, -0.04259688f, 0.03161879f, 0.00249110f, 
    -0.00769984f, 0.02136604f, -0.01938181f, -0.05311859f, 0.01308737f, -0.01033000f, -0.05140992f, 0.00352711f, 
    0.03845368f, 0.04326405f, -0.01806121f, 0.03813681f, 0.03178824f, -0.00516773f, -0.01302598f, 0.03190925f, 
    -0.05708545f, 0.00828243f, 0.04864431f, 0.03123830f, -0.05657560f, 0.03104792f, -0.02145268f, -0.03848737f, 
    0.01828862f, 0.02642876f, 0.04642336f, -0.05922622f, -0.02283878f, -0.01854069f, -0.01241527f, -0.01007076f, 
    -0.00338555f, 0.00242374f, -0.03466871f, -0.03804457f, 0.04749111f, -0.02227782f, -0.05003817f, 0.02062802f, 
    0.00261320f, 0.01076653f, -0.03369232f, 0.00041606f, -0.05235673f, -0.04218923f, 0.04598965f, 0.01703973f, 
    -0.03744452f, 0.01911742f, -0.03944964f, 0.00108943f, 0.01837828f, 0.00941379f, 0.02684242f, -0.01853154f, 
    0.03457036f, -0.02722005f, 0.04553263f, 0.04743716f, -0.04308664f, 0.05857709f, -0.01929962f, -0.06489027f, 
    -0.08688109f, 0.12713966f, -0.14363787f, -0.08498593f, 0.39266202f, 0.01143350f, 0.07479593f, -0.05224546f, 
    0.00824490f, 0.05314945f, 0.06569500f, -0.05920059f, 0.10446517f, -0.02350712f, 0.13296512f, 0.14258754f, 
    -0.01960794f, 0.02764513f, -0.02138686f, 0.07087693f, 0.05235418f, -0.11180913f, 0.11296465f, -0.15552731f, 
    -0.31237549f, -0.01205841f, -0.08353582f, 0.06114365f, -0.06952624f, 0.09855271f, 0.01217805f, 0.07000712f, 
    0.11675379f, -0.01493710f, -0.01915817f, 0.10118610f, 0.03207686f, 0.15179500f, -0.01147410f, 0.15745217f, 
    -0.37015447f, -0.33260369f, 0.12559670f, 0.02420258f, 0.03953123f, -0.00568588f, -0.10950598f, 0.04270975f, 
    0.05497431f, -0.15250215f, 0.10710158f, -0.11720184f, -0.02590923f, 0.01589630f, 0.14409702f, -0.10680598f, 
    -0.01547760f, -0.08780535f, 0.04871743f, -0.13777526f, 0.17532751f, -0.07402941f, -0.13571496f, -0.13903181f, 
    0.36324254f, 0.10258536f, -0.10457321f, -0.07456052f, -0.05671076f, 0.09332287f, -0.01131825f, 0.13427290f, 
    -0.05098614f, 0.09991041f, 0.12234350f, -0.02937055f, 0.02942126f, 0.06942683f, -0.07564598f, 0.06975868f, 
    0.31639266f, 0.08255732f, -0.13973515f, 0.16219503f, -0.21269526f, -0.07434455f, -0.12361163f, 0.13807337f, 
    0.04154026f, -0.00271345f, -0.07423853f, -0.06277261f, 0.00044284f, 0.02525789f, 0.05674774f, 0.09459735f, 
    -0.00286778f, -0.02791899f, -0.06416100f, 0.06874718f, 0.40815797f, -0.02119027f, 0.00288015f, 0.02333509f, 
    0.17325848f, -0.07933270f, 0.03974403f, -0.14259154f, -0.03132490f, 0.00939564f, -0.01737032f, -0.00610363f, 
    -0.06468835f, -0.01867578f, 0.06677712f, -0.08220409f, -0.02063942f, 0.01449675f, -0.02070995f, -0.08772237f, 
    0.01225692f, -0.20284373f, -0.00640029f, 0.09491225f, -0.12036934f, 0.06125733f, 0.15908894f, 0.19974557f, 
    0.00194332f, -0.02218210f, 0.02764056f, -0.00077453f, 0.08243739f, 0.07072107f, 0.02690010f, 0.09409989f, 
    -0.05641471f, -0.01931474f, 0.01105361f, 0.07481351f, -0.05199028f, 0.02972997f, 0.15429209f, -0.15023790f, 
    -0.57536262f, 0.03487636f, 0.02886401f, -0.06575521f, 0.05744310f, -0.06551398f, 0.03607472f, 0.13357167f, 
    0.14104123f, -0.07287888f, -0.05795967f, 0.13976546f, 0.00763690f, 0.00605356f, 0.03678625f, 0.01536091f, 
    0.20935820f, 0.27589899f, -0.04566906f, 0.02940475f, 0.08932206f, 0.03733293f, 0.11240017f, -0.05740126f, 
    0.01997420f, 0.03069434f, 0.02745790f, 0.04248481f, 0.05925684f, 0.05268835f, 0.12517759f, 0.07196043f, 
    -0.02258317f, 0.09927896f, 0.06064148f, -0.00021591f, -0.29020292f, 0.22664793f, 0.05243692f, -0.09115734f, 
    0.19533128f, -0.04264283f, 0.05355478f, 0.01388445f, 0.04471947f, 0.05452380f, 0.03687881f, 0.05758177f, 
    0.14733586f, 0.01476301f, 0.05096344f, -0.08570695f, -0.05919281f, -0.00446006f, 0.09880307f, 0.05609421f, 
    -0.01434147f, 0.06029295f, -0.01199368f, 0.00322388f, -0.14478907f, -0.04621766f, 0.02057392f, 0.06232236f, 
    -0.05889503f, -0.06236591f, 0.07580867f, 0.06688338f, 0.11173344f, -0.05725949f, 0.09353045f, -0.01555386f, 
    0.08200864f, 0.00883731f, 0.01419235f, -0.05650721f, 0.29774672f, 0.01875726f, 0.00804889f, 0.13998103f, 
    -0.29344976f, -0.01605158f, 0.02440006f, 0.00838510f, 0.00445844f, 0.01908923f, 0.01174497f, 0.01536484f, 
    -0.06564885f, 0.06530960f, -0.00009210f, 0.07044844f, -0.01150782f, 0.02610469f, -0.06584336f, -0.09957664f, 
    0.02415945f, 0.02298830f, 0.23649137f, -0.28793809f, 0.06262351f, -0.12521994f, -0.07286955f, -0.08665628f, 
    -0.03361627f, 0.10557675f, 0.09726609f, -0.03576867f, -0.07977202f, 0.04331269f, -0.02936830f, 0.11374126f, 
    0.01775569f, 0.00098433f, -0.03210383f, -0.05283351f, 0.33843064f, 0.02140748f, -0.04673251f, 0.15630950f, 
    -0.15212288f, 0.10363392f, -0.01672230f, 0.03966910f, 0.01357405f, -0.00065927f, 0.03711695f, 0.03610989f, 
    0.09359545f, -0.12468139f, -0.03890760f, -0.05232120f, 0.07340989f, 0.00930060f, 0.00254526f, -0.03273251f, 
    -0.08914455f, -0.08097804f, -0.06602219f, -0.00400070f, 0.12147558f, -0.01455336f, -0.19693792f, -0.05212685f, 
    -0.11692590f, 0.09156163f, 0.12982067f, -0.05163071f, -0.04010881f, -0.01781040f, 0.07328662f, -0.02542585f, 
    -0.06384540f, 0.00868761f, -0.07108663f, -0.16361362f, -0.13778396f, -0.16040720f, 0.10660817f, -0.04046405f, 
    0.33728397f, 0.09358758f, -0.01102255f, 0.04878157f, 0.05737583f, 0.00059541f, 0.12502709f, 0.03921722f, 
    -0.04664091f, -0.09286588f, 0.07070373f, 0.10888415f, -0.07833512f, 0.09196378f, 0.09465707f, -0.01573841f, 
    0.07431077f, 0.06167396f, 0.01386776f, 0.18521185f, -0.30525756f, -0.05520814f, 0.13722780f, -0.13905871f, 
    -0.06599859f, 0.07354438f, 0.04617512f, -0.06802613f, -0.02067110f, -0.01052639f, 0.06986293f, -0.05903162f, 
    -0.21534999f, 0.02644586f, -0.19181125f, -0.08237751f, -0.07887331f, 0.14279138f, -0.08420807f, -0.06422108f, 
    0.12988488f, -0.03186124f, -0.07844429f, -0.03319497f, 0.00573819f, 0.01804156f, 0.05045695f, -0.01968467f, 
    -0.14832069f, -0.09376895f, -0.03564156f, 0.11477672f, -0.03212791f, -0.13985364f, 0.03994720f, -0.05554314f, 
    -0.09992827f, 0.12355811f, -0.14450692f, -0.22889353f, -0.07206602f, -0.09920326f, -0.11378057f, -0.03811648f, 
    -0.05316847f, -0.01458393f, 0.00233203f, -0.06993025f, -0.05402560f, -0.04068379f, 0.08953571f, -0.16894318f, 
    -0.00482077f, -0.13405156f, -0.10288969f, -0.00321113f, 0.39132085f, 0.26305887f, 0.13676772f, 0.17171028f, 
    0.03697593f, 0.08033179f, 0.06248213f, -0.13625477f, -0.11120890f, 0.03483508f, -0.03350130f, 0.00039778f, 
    0.00508707f, -0.06981171f, -0.09419175f, 0.13581905f, 0.02602919f, 0.06904321f, 0.04640953f, 0.10825739f, 
    -0.12181902f, 0.09477265f, 0.00511892f, 0.06942487f, -0.04048030f, 0.07630337f, 0.10814683f, -0.00442279f, 
    -0.01360167f, -0.00791966f, 0.05229339f, 0.04670237f, 0.02539939f, -0.01089142f, -0.08454670f, 0.01844068f, 
    0.08071698f, -0.12553313f, 0.02529951f, -0.09955623f, -0.56178784f, -0.07568247f, -0.22783877f, -0.12375686f, 
    -0.11767172f, -0.10388689f, -0.01662907f, 0.01011945f, -0.18776581f, -0.00067887f, -0.00012574f, 0.01580095f, 
    -0.14433575f, -0.25768307f, -0.03671141f, 0.02344033f, -0.05448342f, -0.08791088f, -0.02690654f, -0.15865374f, 
    -0.22834414f, 0.04143887f, -0.03507421f, -0.12744343f, 0.11789118f, 0.16623162f, -0.08911140f, -0.00034230f, 
    0.06873783f, -0.07062010f, -0.00959201f, 0.08744202f, 0.03961268f, 0.07791783f, 0.01213839f, 0.04197803f, 
    0.05665404f, -0.02960377f, -0.12995200f, 0.02907878f, -0.13757098f, -0.17183091f, 0.08145031f, -0.13667832f, 
    0.06822865f, -0.05881241f, -0.18431632f, -0.13279456f, -0.04256699f, 0.02261938f, -0.00855262f, -0.11171351f, 
    0.08652201f, 0.09847233f, 0.14758621f, -0.06557354f, -0.01146639f, -0.13597658f, -0.29301494f, 0.01672498f, 
    -0.31678575f, 0.04082915f, -0.14984132f, -0.00469543f, 0.03868915f, 0.03337174f, 0.01627619f, 0.05930033f, 
    -0.02561350f, -0.01386210f, 0.02450961f, 0.08564701f, 0.02696585f, -0.09345402f, -0.15432772f, 0.08696974f, 
    -0.11765662f, 0.05934315f, -0.07803553f, 0.07707303f, -0.09803502f, 0.05449372f, -0.06289814f, -0.14065339f, 
    -0.04598428f, -0.06981612f, 0.05849138f, -0.19410618f, -0.13025829f, 0.05821149f, -0.00179570f, -0.03556592f, 
    -0.08793707f, -0.00420766f, -0.02191163f, 0.12253236f, 0.00877388f, 0.08313251f, -0.05009876f, 0.07226465f, 
    0.18291867f, -0.16442402f, -0.23392275f, -0.00210035f, -0.05002807f, 0.02941518f, -0.04815675f, -0.08344365f, 
    0.02648700f, -0.10996319f, 0.02031873f, 0.02776741f, -0.02851234f, 0.04325606f, -0.02852408f, -0.11670755f, 
    -0.09628044f, -0.19172093f, -0.09399358f, 0.10156674f, -0.01344037f, 0.17572626f, -0.22799559f, -0.01640944f, 
    -0.03074118f, 0.06512034f, 0.05441337f, -0.05794383f, 0.01897719f, -0.09078261f, 0.06344809f, -0.01018300f, 
    -0.18937287f, -0.06324264f, -0.06039312f, 0.07238617f, -0.00528655f, -0.18364298f, -0.06597102f, -0.04603640f, 
    0.13860740f, 0.06511938f, 0.12173597f, 0.14259139f, 0.10464040f, -0.03045280f, -0.07892270f, -0.13336433f, 
    -0.12595277f, -0.04145937f, 0.00045487f, -0.10155768f, 0.11463524f, 0.19130442f, 0.10896000f, -0.12632351f, 
    -0.02690135f, -0.09717522f, -0.01487510f, -0.06170805f, 0.13671105f, 0.06216932f, 0.06652305f, -0.08034531f, 
    0.10655459f, -0.17240897f, -0.00222683f, -0.02808430f, -0.09858744f, -0.10265660f, 0.17792946f, -0.09169025f, 
    -0.10785815f, -0.01814515f, 0.01763813f, -0.11378553f, 0.05881905f, -0.03141447f, 0.09934592f, -0.07452668f, 
    -0.53773737f, -0.16468966f, -0.02672148f, -0.16522773f, -0.30058381f, 0.00314190f, 0.02457036f, 0.05467177f, 
    -0.01229677f, 0.03163639f, 0.02187212f, -0.01766831f, 0.09725837f, -0.11022683f, -0.03311644f, -0.01678641f, 
    0.00538290f, -0.11625929f, -0.01105758f, 0.01890830f, 0.20459503f, 0.03605099f, 0.16329810f, -0.04033644f, 
    -0.16053364f, 0.06825606f, 0.05740817f, -0.08463752f, -0.17204396f, -0.08921832f, 0.09271698f, -0.21402670f, 
    0.06717686f, -0.06943452f, 0.07322992f, -0.14618300f, -0.03340307f, -0.21270470f, 0.09597717f, -0.08914282f, 
    0.02715560f, -0.04537890f, -0.00964257f, -0.04322254f, -0.02023852f, -0.04191316f, -0.03954517f, -0.01155102f, 
    -0.01168608f, -0.05018485f, 0.02847889f, 0.01243726f, 0.04641841f, 0.03789531f, 0.01648408f, 0.04083315f, 
    -0.02580226f, 0.02581656f, -0.05508497f, -0.02807770f, -0.03529155f, -0.01282551f, 0.03824463f, 0.02108249f, 
    0.02500714f, 0.04312581f, -0.05750158f, 0.01934264f, -0.05202616f, -0.06294878f, 0.01481628f, 0.02032943f, 
    -0.00806628f, -0.01358530f, 0.04556942f, -0.05676451f, -0.03535643f, 0.00505479f, 0.03162946f, 0.03911128f, 
    -0.03669002f, 0.00550862f, -0.06450038f, -0.01448780f, -0.04082686f, -0.06210444f, -0.00054086f, 0.03688169f, 
    0.01802225f, -0.00587287f, 0.03734973f, -0.02221448f, -0.04461427f, -0.04407682f, -0.01007599f, 0.00658702f, 
    0.04445194f, -0.04655361f, 0.00528371f, 0.00434161f, -0.00308740f, -0.01991087f, -0.04059416f, -0.03650882f, 
    0.06320047f, -0.00874937f, -0.01830123f, 0.02532207f, 0.04211275f, 0.00385176f, 0.01586064f, 0.01945045f, 
    0.01255249f, 0.00621884f, 0.00864843f, -0.02546511f, 0.02178192f, -0.03163021f, -0.02103318f, -0.03597794f, 
    0.00483667f, -0.03829816f, 0.03266479f, 0.04527102f, -0.01733042f, -0.06408279f, -0.03421983f, 0.02762709f, 
    -0.00739219f, -0.00719456f, -0.00823113f, -0.03678641f, -0.03064375f, 0.04101004f, -0.05728067f, 0.02443639f, 
    0.03984322f, 0.04396551f, -0.00056289f, 0.01129118f, -0.02587762f, 0.03079046f, -0.01860298f, -0.04375345f, 
    0.01038944f, -0.00266687f, -0.03975777f, -0.05435813f, 0.03459272f, -0.00927643f, 0.01423451f, -0.03161936f, 
    -0.02076052f, -0.03064896f, 0.04173439f, -0.07166779f, -0.04722706f, 0.03857021f, 0.02893251f, -0.01825700f, 
    -0.03847200f, 0.03010422f, 0.01853855f, 0.03244133f, -0.01208391f, 0.03093066f, -0.02500343f, 0.00356381f, 
    -0.03795356f, -0.02458051f, -0.04422260f, 0.02850513f, -0.01042942f, 0.01825847f, 0.03032926f, 0.02546635f, 
    0.03067843f, -0.00520188f, 0.04149619f, 0.00626254f, 0.02425828f, 0.02371250f, 0.01271490f, -0.06020065f, 
    -0.04026415f, 0.02619985f, -0.01504308f, -0.04944234f, -0.01220753f, 0.02244548f, -0.04925197f, -0.03860388f, 
    -0.00310276f, -0.03537044f, 0.02923217f, 0.00462778f, -0.00111668f, -0.03289186f, 0.01187092f, -0.03695572f, 
    -0.02565246f, 0.00703200f, -0.01428711f, 0.03587275f, 0.03516398f, -0.01148576f, 0.03950533f, -0.04468130f, 
    0.01606420f, -0.04723044f, 0.00712568f, -0.02168268f, -0.03118841f, -0.06599037f, -0.04028631f, -0.00866082f, 
    0.02573820f, 0.02560305f, -0.00824144f, -0.05003570f, 0.04152294f, 0.00766739f, 0.02110467f, 0.02859788f, 
    0.01894723f, -0.01605209f, 0.01944046f, 0.04432450f, 0.03364139f, 0.02271141f, -0.01301837f, 0.02966772f, 
    -0.02869625f, 0.00694459f, -0.00522585f, 0.02651124f, 0.04074536f, -0.03985097f, 0.05029898f, -0.01196962f, 
    0.00723876f, -0.05236410f, -0.02304889f, -0.00361779f, -0.04910901f, -0.03307530f, 0.03641411f, -0.04773568f, 
    0.02022494f, -0.02645277f, 0.04382380f, 0.03263502f, -0.05352887f, -0.01391803f, 0.00230431f, -0.04884162f, 
    0.04080205f, -0.05103707f, 0.02736335f, -0.03908418f, -0.00017832f, -0.01623889f, -0.01049420f, -0.04887824f, 
    -0.06227454f, -0.02153845f, -0.05626027f, 0.01492427f, 0.00992482f, -0.00193978f, -0.03134737f, 0.00646340f, 
    0.00027100f, 0.03087510f, 0.00516073f, 0.00972661f, 0.01559929f, -0.01436692f, 0.01186679f, -0.04035966f, 
    -0.02850492f, -0.01834927f, -0.01315281f, -0.01007394f, -0.00310672f, -0.00938259f, 0.02997357f, -0.03847584f, 
    0.02217189f, -0.03465179f, 0.03595946f, 0.02396265f, -0.02398961f, 0.03920028f, 0.03870566f, -0.02390681f, 
    -0.00664834f, -0.03979517f, -0.02780721f, 0.02371570f, -0.03063742f, -0.05270052f, -0.05554300f, 0.03112418f, 
    0.02117113f, -0.02372019f, -0.01619887f, -0.01474139f, -0.04560972f, 0.03801319f, 0.03507743f, -0.02367604f, 
    0.00247306f, -0.02676103f, -0.03389775f, -0.04748142f, 0.00056534f, 0.00646468f, -0.01474671f, 0.03321426f, 
    0.00979055f, 0.03702968f, -0.03011397f, -0.01985936f, 0.02568131f, -0.04570483f, -0.00880540f, 0.04462046f, 
    0.01291591f, -0.05755272f, 0.00919139f, -0.03325048f, 0.00590721f, -0.05356507f, 0.03356271f, -0.03849277f, 
    -0.02550010f, -0.01825627f, -0.03159533f, -0.00904994f, 0.03239146f, -0.05809304f, -0.03215055f, 0.05866429f, 
    0.02583029f, -0.00380270f, 0.04774153f, -0.04076189f, -0.01377850f, -0.05932524f, 0.03822924f, 0.05177505f, 
    -0.03946817f, 0.02161039f, 0.00797406f, -0.01983282f, 0.00629506f, 0.00180975f, -0.04899213f, -0.05698220f, 
    -0.00853414f, -0.03966067f, 0.01483757f, 0.04303461f, -0.00173750f, 0.04312526f, 0.00051066f, 0.01221422f, 
    -0.02098575f, -0.00944760f, -0.01829342f, 0.04483940f, -0.02899807f, 0.03892926f, 0.02130399f, -0.06226973f, 
    -0.04886775f, -0.03817206f, 0.02125227f, -0.04303580f, 0.00572238f, -0.00445716f, 0.03581326f, 0.01919223f, 
    -0.01091718f, -0.02998217f, -0.01742097f, 0.00958467f, 0.02099491f, -0.05267222f, -0.05316585f, -0.03416352f, 
    -0.03893323f, 0.02516971f, -0.01105389f, -0.05391184f, -0.02942993f, 0.01150204f, -0.04271631f, 0.00636756f, 
    -0.00564240f, -0.04111819f, 0.00883524f, -0.05525360f, -0.00659487f, -0.03889808f, 0.03217327f, -0.02372650f, 
    -0.05404212f, 0.01207019f, -0.00948474f, 0.02073047f, -0.05908429f, -0.02993126f, -0.05380872f, -0.03107951f, 
    -0.03787752f, -0.03959571f, 0.03819171f, -0.05941734f, -0.01384438f, 0.03681771f, -0.04935788f, -0.01818549f, 
    0.03456656f, 0.00099042f, -0.00509940f, -0.03136287f, -0.02290629f, -0.01706933f, -0.00017152f, 0.03730211f, 
    0.02319280f, 0.02118584f, 0.00181328f, -0.04167507f, -0.06424665f, -0.00008309f, 0.04199110f, -0.01262000f, 
    0.00853054f, -0.04545172f, -0.01536869f, -0.01435888f, -0.05604722f, 0.03867511f, 0.03643025f, -0.01087011f, 
    0.02128944f, -0.01071387f, -0.04764203f, 0.02971731f, 0.01917713f, 0.00600771f, 0.04289027f, 0.01129382f, 
    -0.02091754f, 0.04023727f, -0.01120714f, 0.03857010f, -0.01089171f, 0.01644816f, 0.00676481f, 0.00391710f, 
    -0.02547912f, -0.00914161f, 0.00300532f, 0.00670720f, -0.05158015f, 0.04492571f, -0.00917307f, -0.03372236f, 
    0.02146602f, -0.01123056f, -0.03170065f, 0.04694062f, -0.05131788f, -0.02026075f, 0.02400368f, -0.00255598f, 
    -0.05721957f, -0.02791234f, -0.05682287f, -0.00706127f, 0.00080138f, -0.03994219f, -0.02392948f, 0.03448088f, 
    -0.02638868f, -0.00591526f, 0.02087238f, -0.06175574f, -0.05971171f, -0.03831377f, -0.03445584f, -0.01242721f, 
    0.00910762f, 0.03717329f, -0.05869784f, 0.03525182f, 0.03339531f, -0.01013398f, -0.02620498f, -0.03680142f, 
    -0.05192817f, -0.02682716f, 0.04072265f, -0.01932760f, 0.00086044f, -0.05560920f, -0.03507362f, 0.00555426f, 
    -0.04380699f, -0.05764567f, 0.03528319f, 0.00478993f, 0.01472444f, -0.04541928f, -0.03793277f, -0.06134525f, 
    -0.00873771f, 0.00848630f, -0.00479424f, 0.02126702f, 0.04156389f, 0.01634218f, -0.05966245f, -0.04277634f, 
    -0.00979996f, -0.05419944f, 0.03915285f, -0.06258909f, 0.03214602f, -0.02562172f, 0.00968772f, 0.01369186f, 
    -0.02194284f, -0.01610299f, 0.03356354f, -0.02399064f, -0.00540203f, -0.05305670f, 0.03709549f, 0.03344327f, 
    -0.06198078f, -0.00296067f, -0.00978877f, 0.01989267f, -0.05298823f, 0.04577515f, -0.01456204f, -0.00152590f, 
    0.01897846f, -0.04308235f, -0.01272938f, 0.01694539f, 0.01789601f, -0.05787985f, -0.00347177f, -0.02260881f, 
    -0.05313272f, 0.00908137f, -0.06456673f, -0.00866248f, -0.05660742f, -0.01666191f, 0.04936852f, 0.02129394f, 
    0.03881716f, -0.00696642f, 0.04334692f, -0.03109091f, -0.05551010f, -0.05440773f, -0.05296954f, 0.02219193f, 
    -0.04458975f, -0.00021657f, -0.04445932f, -0.03374759f, -0.04060591f, 0.01930789f, -0.03416163f, -0.06296891f, 
    -0.02063907f, 0.04997936f, 0.03168865f, -0.02039286f, 0.03686303f, -0.05357835f, 0.03215456f, -0.00191941f, 
    -0.02672024f, 0.01525280f, -0.04399137f, 0.02019233f, 0.03820562f, -0.02708044f, -0.04736814f, 0.01289257f, 
    -0.02841652f, -0.00366086f, 0.02918473f, -0.00649931f, -0.05309829f, -0.04612719f, 0.02325905f, -0.00551484f, 
    -0.00572029f, -0.04905491f, 0.03687822f, -0.05656326f, 0.03637767f, 0.03515417f, -0.03752704f, 0.03076959f, 
    0.03493265f, 0.02759599f, -0.02475229f, -0.04852294f, 0.00341129f, -0.04339349f, -0.05579192f, -0.05824072f, 
    -0.00487990f, 0.04268282f, 0.02090437f, 0.04545787f, -0.01716198f, 0.01727832f, 0.01508068f, -0.01049395f, 
    -0.00600752f, -0.03367537f, -0.01936123f, 0.02763065f, -0.04500794f, -0.02810274f, -0.05215808f, -0.05809106f, 
    0.03675097f, -0.03575785f, 0.01490384f, -0.00982519f, -0.00583336f, -0.04270788f, 0.03860932f, 0.03392475f, 
    0.00648925f, 0.03904422f, -0.05979702f, 0.02745616f, 0.02232702f, -0.03537573f, -0.06010589f, -0.01519935f, 
    -0.01697112f, 0.00376916f, -0.05451620f, 0.03100264f, 0.04699351f, 0.00128609f, 0.04242249f, 0.01364359f, 
    -0.05953255f, 0.00885828f, 0.02926190f, -0.06432823f, 0.02278994f, -0.00652273f, -0.05086602f, -0.00113427f, 
    -0.04107139f, -0.04454545f, -0.03293428f, 0.04282349f, -0.03225603f, -0.05577680f, -0.01110038f, 0.04023831f, 
    0.26639253f, -0.09751771f, -0.16918996f, 0.06666545f, 0.13515829f, -0.05678568f, -0.02639853f, -0.04567223f, 
    -0.08657917f, 0.10483684f, 0.06231377f, 0.00378568f, 0.08439643f, 0.03527423f, 0.05743042f, -0.02688122f, 
    0.04944120f, 0.06217576f, 0.02404106f, -0.04278981f, -0.02965975f, -0.15746678f, 0.06338450f, -0.06597665f, 
    -0.11869205f, -0.01848670f, -0.05620864f, 0.16831908f, 0.01852993f, 0.03397129f, 0.04401116f, 0.17716514f, 
    -0.00655475f, -0.01023557f, -0.05743395f, 0.01388249f, -0.00348024f, 0.10647911f, -0.12441323f, -0.11556025f, 
    -0.46871138f, -0.39352226f, -0.18544288f, 0.10664305f, -0.09471681f, 0.08700822f, -0.00931653f, 0.02944682f, 
    0.05577407f, -0.02947009f, 0.04321795f, 0.01366210f, 0.03998133f, 0.06926847f, 0.01463348f, 0.00346983f, 
    -0.06115891f, -0.03034256f, -0.01102044f, -0.04420136f, 0.33399543f, 0.15679908f, 0.08917410f, -0.15283278f, 
    0.16745047f, -0.02794021f, 0.05789027f, 0.13159229f, -0.05975448f, 0.04892565f, 0.03011226f, -0.02561724f, 
    -0.02780962f, 0.07543828f, -0.02254881f, -0.02809972f, -0.00470450f, 0.10893260f, -0.05818838f, 0.07617304f, 
    -0.02945854f, -0.20579098f, -0.04345201f, -0.01800939f, -0.05355471f, -0.02638379f, 0.00771504f, -0.00510164f, 
    0.04042588f, 0.03584260f, 0.03483862f, -0.06836721f, -0.08823354f, 0.01859394f, 0.10622266f, 0.03280772f, 
    0.05890539f, 0.04927071f, 0.00963997f, 0.08357462f, 0.72523963f, 0.11359916f, 0.32556841f, -0.17458047f, 
    0.14153577f, -0.03768648f, 0.11597151f, -0.03191208f, -0.01276451f, 0.02716504f, 0.10955270f, 0.04369036f, 
    -0.00207910f, 0.07939692f, 0.05438054f, -0.02616648f, -0.08380808f, 0.03408303f, -0.12077623f, -0.03219499f, 
    -0.06083874f, -0.38326797f, -0.19161269f, 0.05875237f, -0.34091225f, 0.07520964f, 0.00476616f, 0.06668994f, 
    -0.04782397f, 0.05138244f, 0.08533705f, -0.02154397f, -0.00693848f, -0.00635043f, 0.03287611f, -0.01049077f, 
    -0.00643905f, 0.08196955f, 0.07104284f, 0.03067276f, 0.32607564f, -0.00247061f, -0.06628650f, -0.22672160f, 
    -0.26321539f, -0.10649822f, -0.04430490f, -0.03837609f, 0.09712728f, -0.06189946f, 0.08336253f, 0.01364056f, 
    -0.04233223f, 0.05943107f, 0.03786060f, 0.00140807f, 0.00863787f, 0.03367014f, -0.01063359f, 0.03895478f, 
    0.21400385f, 0.22824046f, 0.10218120f, -0.00269925f, 0.04584615f, 0.07519320f, 0.10231037f, -0.02055482f, 
    0.16224594f, 0.05185184f, 0.04685737f, -0.02599141f, 0.11414191f, -0.01137843f, -0.02278979f, -0.03838704f, 
    0.01916116f, 0.01913154f, 0.01679180f, 0.04671397f, -0.07571120f, 0.08413722f, 0.26976576f, 0.05739199f, 
    0.00569462f, -0.02350470f, 0.00389363f, 0.01254900f, -0.04950203f, 0.06334398f, -0.08319371f, -0.01704453f, 
    0.16609800f, 0.03503563f, 0.07381297f, -0.03990296f, -0.01585266f, 0.04051907f, 0.02873496f, 0.01342983f, 
    -0.20719962f, -0.16169471f, 0.07778031f, -0.04900131f, -0.20357122f, 0.00872520f, -0.12010495f, 0.03641877f, 
    -0.05652096f, -0.01678225f, 0.02674189f, 0.01712781f, 0.03678828f, 0.05593487f, 0.04825065f, -0.05605302f, 
    0.04207756f, 0.08460379f, 0.05427152f, -0.05238742f, 0.14060837f, 0.03701048f, 0.10623277f, 0.02223117f, 
    -0.12073047f, 0.10872748f, 0.06729724f, -0.05637406f, 0.02477940f, 0.01026560f, 0.04761588f, -0.04569988f, 
    -0.07734409f, 0.07449593f, 0.01212321f, 0.09883431f, -0.05005425f, -0.06029831f, -0.02305906f, -0.00361116f, 
    0.30149961f, 0.28902113f, 0.24617350f, -0.19512053f, -0.04090752f, -0.09610478f, -0.09486152f, -0.05565928f, 
    -0.08732495f, 0.03796258f, -0.07253297f, -0.08355989f, 0.02519892f, -0.00472977f, 0.07784496f, 0.05709630f, 
    -0.05119915f, -0.00632168f, -0.00799162f, -0.03128831f, 0.16576929f, 0.06980644f, 0.05758479f, 0.15394704f, 
    -0.04129653f, 0.09946327f, -0.01814437f, 0.05245956f, 0.02504669f, 0.03312673f, -0.03734043f, -0.12322944f, 
    -0.06219791f, -0.11781202f, -0.04519350f, -0.06527475f, 0.07454028f, -0.05015128f, 0.05323626f, 0.07779300f, 
    -0.18845338f, -0.33838132f, 0.16091187f, -0.00697353f, -0.02527606f, -0.15868972f, -0.08525641f, 0.01191660f, 
    -0.14830655f, 0.01785007f, 0.00670994f, 0.04364905f, 0.03818566f, -0.05557320f, 0.00648833f, 0.06525964f, 
    -0.04628822f, 0.09154862f, 0.05606499f, -0.06109130f, 0.13290246f, -0.15849829f, 0.16859688f, -0.07924870f, 
    0.30824104f, 0.17822015f, 0.04899430f, 0.02509748f, 0.03525544f, 0.07263036f, 0.12790003f, 0.18760854f, 
    -0.06420425f, -0.02053197f, 0.03068537f, 0.18708034f, -0.01101711f, 0.11323118f, 0.03080507f, -0.01151781f, 
    -0.37820303f, 0.42218298f, 0.02447384f, 0.15940532f, -0.10250318f, 0.02080058f, 0.05995525f, 0.04783850f, 
    0.03207480f, 0.07475724f, 0.03879410f, -0.01900694f, -0.03312924f, -0.07348723f, 0.06497581f, -0.00201546f, 
    -0.07860436f, -0.03615174f, -0.00420860f, -0.02730524f, -0.18798226f, 0.24723276f, 0.03818322f, 0.05010660f, 
    0.04182192f, -0.01973596f, -0.03035409f, -0.07270923f, 0.12450358f, 0.07188100f, 0.00454820f, 0.02634356f, 
    -0.02077512f, -0.05913126f, 0.04571593f, 0.13010189f, -0.06794478f, -0.04506271f, 0.01228994f, 0.09002396f, 
    0.11593961f, 0.14954254f, -0.23999278f, -0.09975684f, 0.11468875f, -0.15717888f, -0.01791189f, -0.02226907f, 
    -0.07876360f, -0.06369835f, 0.08435552f, 0.14421956f, 0.05640021f, -0.01812452f, 0.01729047f, -0.10123473f, 
    0.00822488f, -0.25027305f, 0.02431030f, -0.02719259f, 0.05523183f, 0.01799044f, -0.09712637f, 0.18164235f, 
    0.15532619f, 0.17813860f, 0.00157741f, -0.13714018f, 0.03141638f, 0.16816059f, 0.01148723f, 0.02132827f, 
    -0.01122973f, -0.04963236f, -0.00409169f, 0.04611346f, 0.09065695f, -0.00799464f, 0.16980915f, 0.03862780f, 
    0.01649497f, 0.33229980f, -0.08825819f, -0.10166365f, -0.04594480f, 0.04108134f, 0.02418976f, 0.08583294f, 
    0.08162313f, -0.07842391f, 0.02006386f, 0.07065827f, 0.15183224f, -0.02497132f, -0.04011032f, 0.12902090f, 
    0.10202883f, -0.09928204f, 0.00717921f, -0.02128648f, -0.59056342f, -0.01507104f, -0.30290931f, -0.03001678f, 
    -0.24175462f, -0.04272551f, -0.02049432f, 0.07041248f, -0.15725252f, 0.00596526f, -0.05184960f, -0.03719803f, 
    -0.06374502f, -0.15451893f, 0.01221852f, -0.04956624f, 0.03573820f, 0.02696848f, -0.05244127f, 0.01664609f, 
    -0.39911321f, 0.28707919f, 0.01717957f, -0.10022627f, 0.13245298f, 0.22996488f, -0.01027966f, 0.05921463f, 
    0.12150808f, -0.10108826f, -0.00110702f, 0.17276615f, 0.12108579f, 0.15177205f, 0.11577994f, 0.01126443f, 
    0.07285631f, -0.06625664f, -0.15492967f, -0.01690012f, -0.21221782f, -0.09568137f, 0.24650659f, 0.23252136f, 
    0.23072000f, 0.07997423f, -0.09281074f, -0.12102754f, 0.11132216f, 0.19044104f, 0.06907860f, 0.07728495f, 
    0.07405286f, 0.09814473f, 0.22578727f, 0.16444953f, -0.02475243f, -0.05846239f, -0.13533407f, 0.05254215f, 
    -0.26076934f, 0.05469341f, 0.04137664f, -0.10416935f, 0.08498096f, 0.00476127f, 0.00391104f, 0.01426273f, 
    0.01882300f, -0.04838362f, -0.02492939f, -0.02300601f, -0.06144751f, -0.04643536f, -0.11893308f, 0.12082615f, 
    0.15898535f, 0.05534894f, -0.04686989f, 0.04295465f, -0.07288590f, 0.19939964f, -0.22348295f, -0.10353147f, 
    0.03664865f, -0.05221406f, 0.11305531f, -0.07131931f, 0.07736543f, 0.09471068f, 0.05810688f, 0.06707792f, 
    -0.00631389f, 0.00748757f, 0.02663583f, 0.04188009f, 0.03685256f, 0.19061014f, 0.01171674f, 0.09657294f, 
    0.22849102f, -0.01769427f, -0.14284834f, 0.13354121f, 0.03622976f, 0.06613883f, 0.06972648f, 0.05746293f, 
    -0.01729941f, -0.00803747f, 0.06188961f, 0.06533851f, -0.00563351f, 0.02543742f, -0.02515997f, -0.08265605f, 
    -0.05373690f, -0.14607109f, 0.07031457f, 0.01754870f, 0.02708775f, -0.09220760f, -0.15998694f, -0.06248888f, 
    -0.03906317f, -0.07629229f, -0.04529079f, 0.10744827f, 0.02318249f, -0.15009083f, 0.08409274f, -0.07756802f, 
    -0.07758670f, -0.05472609f, 0.00373645f, -0.00627657f, 0.11269481f, 0.01111569f, 0.04577997f, -0.01340359f, 
    0.09260432f, -0.08860778f, 0.03122265f, 0.33722639f, 0.15212877f, 0.05753960f, -0.04785850f, -0.02537506f, 
    -0.01392476f, 0.04939426f, 0.09601454f, -0.00472264f, 0.03183315f, 0.14556403f, 0.11456738f, 0.03106990f, 
    0.09584378f, 0.06613553f, 0.04708391f, -0.02290508f, -0.21760042f, 0.06425329f, 0.18995427f, -0.00284859f, 
    0.09765055f, -0.03659339f, 0.08505062f, -0.10406706f, -0.07757240f, -0.11492926f, 0.09600868f, -0.06161396f, 
    0.03521274f, 0.02349537f, 0.03303777f, 0.00457092f, -0.02968056f, -0.00529023f, 0.01604682f, -0.07075695f, 
    0.07685521f, 0.15216385f, -0.03759787f, -0.20048444f, -0.21939789f, -0.05274555f, 0.09712957f, 0.06287888f, 
    0.02635080f, -0.04382885f, 0.10732514f, 0.00889372f, 0.07384825f, 0.01632867f, 0.13540836f, -0.07441650f, 
    0.02607624f, -0.09823494f, -0.05545264f, 0.01630711f, 0.17745534f, -0.15673733f, -0.16849142f, 0.15812862f, 
    -0.27712232f, 0.01239923f, -0.00939391f, -0.02876263f, -0.15852277f, -0.03527701f, 0.13944408f, -0.24725309f, 
    0.07488733f, 0.02428845f, 0.01678362f, -0.11174777f, 0.04304842f, -0.08542555f, 0.16328371f, -0.03166183f, 
    0.02619584f, -0.05728951f, -0.04054892f, 0.03585780f, -0.01477105f, -0.01437962f, -0.02802137f, 0.04081518f, 
    0.04134945f, 0.01412268f, 0.02810214f, -0.02181371f, -0.05844481f, -0.01798092f, 0.03068106f, 0.00891342f, 
    -0.04010012f, 0.03154859f, -0.01384911f, 0.00235060f, -0.05704413f, 0.04577222f, -0.03835438f, -0.03883025f, 
    0.01551167f, -0.03824295f, -0.05542903f, -0.03916787f, 0.01485850f, 0.00831219f, -0.00861131f, -0.02940683f, 
    -0.02131049f, -0.05294335f, 0.00693621f, 0.01070495f, -0.00112838f, 0.05090405f, -0.04282924f, -0.05198219f, 
    0.04130696f, 0.02757765f, -0.00438713f, 0.03177363f, -0.05661318f, 0.00340741f, -0.05069669f, 0.01575045f, 
    -0.01693399f, -0.04662167f, -0.03299583f, 0.04944752f, 0.00966142f, 0.03206609f, 0.01924438f, 0.04519907f, 
    -0.03352586f, -0.00478586f, 0.02710633f, -0.05992268f, 0.02098948f, 0.02855995f, -0.05439147f, -0.00488972f, 
    -0.03617806f, -0.01988769f, -0.04775400f, -0.05290658f, -0.04444787f, -0.04956445f, -0.03825767f, 0.03746909f, 
    0.00041975f, -0.02211626f, -0.04761352f, 0.02205522f, 0.00744063f, -0.00633027f, -0.03477029f, 0.02510531f, 
    -0.00360046f, -0.02787463f, 0.01798751f, 0.02498496f, 0.00653996f, -0.03816284f, 0.03786289f, -0.04890143f, 
    -0.02219837f, -0.00469781f, 0.03519622f, -0.05829841f, 0.04631225f, 0.01271362f, -0.02567489f, -0.05498390f, 
    0.04687741f, 0.00894537f, -0.01414764f, 0.03376491f, -0.01430396f, -0.00225775f, -0.00832075f, 0.00061819f, 
    -0.05101654f, 0.02125763f, -0.02951214f, -0.06487256f, -0.03534202f, 0.02073243f, 0.03975131f, 0.00871681f, 
    -0.01544403f, -0.00148014f, -0.02064423f, -0.05309743f, 0.01571994f, -0.03654072f, 0.02676907f, 0.02805530f, 
    0.03790837f, -0.01430491f, -0.04223672f, -0.05182964f, 0.00227560f, 0.03080129f, -0.01467445f, -0.02035176f, 
    0.02250485f, 0.02542710f, 0.00582938f, -0.02889111f, 0.03007539f, -0.00541154f, 0.03532672f, 0.02157920f, 
    0.04824088f, -0.03555776f, 0.01169215f, 0.01385452f, -0.00037497f, -0.03254774f, -0.01055478f, -0.05333662f, 
    -0.02016236f, 0.00815231f, 0.02612782f, -0.00271970f, -0.03871339f, -0.00358303f, -0.05874528f, 0.02837784f, 
    0.00903295f, 0.03927182f, 0.04648133f, -0.03608802f, -0.05360603f, 0.04999201f, -0.02038426f, -0.01810528f, 
    0.02928520f, 0.03446459f, -0.02858873f, -0.05086102f, -0.01404573f, 0.00067149f, 0.02852597f, -0.04186055f, 
    0.04240187f, -0.01623912f, -0.02771299f, -0.04243504f, -0.05679471f, -0.02797406f, 0.05069372f, -0.00470555f, 
    0.00906481f, -0.05880180f, -0.00584310f, -0.03632585f, -0.01723169f, -0.03077658f, -0.02360914f, 0.04202130f, 
    0.01957923f, -0.04230853f, -0.00153963f, 0.02215161f, 0.04768066f, -0.02694271f, -0.05987097f, 0.03529427f, 
    -0.00719333f, -0.00988209f, 0.03079239f, -0.04371133f, -0.04306876f, 0.04842377f, 0.02781745f, -0.03569190f, 
    -0.05245820f, 0.01497367f, 0.02042386f, 0.00673397f, -0.01072339f, 0.04984276f, -0.03873745f, 0.02892102f, 
    0.00404950f, 0.00228536f, -0.03980891f, -0.05343752f, -0.00804406f, 0.04596581f, 0.00273335f, 0.03444986f, 
    -0.03041223f, -0.05160004f, -0.02340535f, 0.03414639f, 0.04000736f, 0.00848842f, -0.03864004f, -0.02196599f, 
    -0.00125187f, -0.00954357f, 0.02606863f, -0.04157488f, -0.03253015f, -0.06330232f, -0.03708000f, 0.03433743f, 
    -0.00317492f, 0.04411328f, 0.00588127f, -0.00473343f, -0.06258536f, -0.04130378f, -0.02574263f, 0.03222511f, 
    0.00099889f, 0.02320259f, 0.02116672f, 0.04178631f, 0.02213280f, -0.01444970f, -0.04767145f, -0.03435440f, 
    -0.02285791f, 0.00455515f, -0.03019653f, 0.00781825f, -0.01533057f, -0.01763977f, -0.00081404f, 0.04696636f, 
    -0.05223352f, -0.02136853f, -0.05572651f, -0.01453422f, 0.04106906f, -0.01242321f, 0.03065811f, -0.03367802f, 
    -0.05889016f, 0.01607357f, 0.04728405f, -0.03471937f, -0.04565863f, -0.05111686f, 0.02356355f, 0.00255711f, 
    0.03476488f, -0.04823120f, 0.02052818f, -0.02652352f, 0.00523084f, 0.04898170f, 0.02886980f, -0.04051515f, 
    -0.00586655f, -0.01880880f, -0.03451357f, 0.00275619f, -0.05490697f, 0.03592723f, -0.01576439f, 0.02157569f, 
    -0.05265069f, -0.01418627f, -0.03419507f, 0.00660950f, 0.00165915f, -0.02325847f, -0.05467842f, -0.00328885f, 
    -0.05337168f, -0.04679823f, -0.05763649f, -0.03341376f, 0.04572592f, 0.03422169f, 0.01657124f, 0.03132937f, 
    -0.00678906f, 0.02174771f, 0.03535951f, 0.04054533f, 0.02139393f, -0.00961568f, 0.00233011f, -0.02251679f, 
    0.03797584f, 0.02016863f, -0.00783869f, -0.02595030f, 0.04386767f, -0.00327739f, 0.02163162f, -0.00333348f, 
    -0.06108177f, 0.20687249f, -0.08494531f, -0.08932052f, 0.03252412f, -0.00241618f, -0.03962026f, 0.06649411f, 
    -0.01779814f, -0.04534294f, -0.10016809f, -0.02938340f, -0.04763237f, -0.08413651f, -0.01900943f, 0.04957895f, 
    0.04711674f, 0.00417234f, 0.10651801f, -0.03623343f, 0.32705465f, -0.27304599f, 0.05786790f, 0.04559865f, 
    -0.06641880f, -0.03137013f, -0.02503915f, 0.03225173f, -0.02411563f, 0.14130791f, -0.12442192f, 0.06628810f, 
    0.14704566f, -0.01156133f, 0.01213366f, 0.10196491f, -0.06292422f, 0.13021703f, -0.00977317f, -0.03965706f, 
    -0.21544728f, -0.09029651f, -0.30015936f, -0.05632316f, 0.00837912f, 0.14233734f, -0.09798905f, 0.13534142f, 
    0.10039888f, -0.00843384f, 0.08631951f, 0.12767516f, -0.00150236f, 0.02653780f, -0.04303779f, 0.03114941f, 
    0.13951786f, 0.11185646f, 0.04534998f, -0.09118865f, -0.04615854f, 0.22727175f, -0.15256894f, 0.16854167f, 
    0.13803695f, 0.08301878f, 0.04876382f, -0.00298842f, 0.07035492f, 0.00795488f, 0.14219135f, 0.11167569f, 
    0.12098533f, 0.01379287f, 0.10354716f, -0.08300112f, 0.00404472f, -0.12008772f, -0.06391735f, -0.14524724f, 
    0.23975076f, -0.05193177f, 0.11422940f, -0.29254133f, 0.11008562f, -0.04662861f, -0.08904209f, 0.04910617f, 
    -0.03284009f, -0.11380742f, 0.02748578f, -0.17901780f, -0.18490806f, 0.06239383f, -0.07812802f, 0.00094062f, 
    0.02001022f, -0.03372505f, -0.12986100f, 0.04326025f, 0.47260153f, -0.37512407f, -0.01116092f, -0.04548122f, 
    -0.06107211f, 0.01588248f, 0.05885087f, 0.00666860f, 0.04767454f, 0.08030204f, -0.07884958f, 0.03414189f, 
    0.11132301f, 0.12639493f, 0.06429119f, 0.04687404f, -0.05692448f, 0.13927430f, -0.21533605f, -0.01575756f, 
    0.10894782f, 0.02009996f, -0.07814971f, -0.24389368f, -0.00423177f, 0.06464281f, 0.03205867f, 0.11795884f, 
    -0.04937992f, 0.03753592f, 0.11141554f, -0.00302588f, 0.03711600f, -0.11601282f, -0.02479153f, -0.00772993f, 
    -0.01609497f, -0.01907146f, 0.17894904f, -0.08488038f, 0.17351845f, 0.07124814f, -0.12848356f, -0.16399336f, 
    -0.06366667f, 0.02314640f, 0.09108077f, -0.09631322f, 0.08661573f, -0.09904704f, 0.09044696f, 0.11336951f, 
    -0.04559207f, 0.07579777f, -0.09226300f, 0.05730844f, -0.12790638f, 0.09365302f, 0.13978417f, -0.01609839f, 
    0.34234914f, -0.14843251f, -0.04180655f, -0.04603086f, 0.15662764f, 0.00245850f, 0.00713489f, -0.07582705f, 
    0.15133876f, 0.00641731f, -0.03338838f, 0.10215504f, 0.00814364f, 0.18042521f, 0.09815961f, -0.07774471f, 
    0.06676447f, 0.02636571f, -0.02956384f, -0.05746379f, 0.37873071f, -0.21095198f, -0.13417956f, 0.19181478f, 
    0.00494475f, -0.01684997f, 0.01982747f, 0.09104232f, 0.09558873f, 0.06668654f, -0.03528287f, 0.00824553f, 
    0.03681681f, -0.02626499f, 0.00748429f, -0.06236749f, -0.04209150f, 0.01385983f, -0.14462520f, -0.01215729f, 
    -0.13742457f, 0.06736962f, -0.32561803f, 0.09872135f, -0.22675006f, 0.03943775f, 0.04346545f, -0.10532252f, 
    -0.06104621f, -0.04910835f, -0.12766555f, 0.02635220f, 0.05816452f, 0.01432683f, 0.02350391f, 0.03137860f, 
    0.03183550f, 0.11142486f, 0.11807424f, -0.00102958f, 0.31233445f, -0.27529901f, 0.21601135f, -0.14007048f, 
    0.03284695f, -0.12174608f, -0.07795774f, 0.03729044f, 0.02790208f, -0.15365686f, -0.00878024f, -0.07793351f, 
    -0.04017020f, 0.11511438f, -0.00000779f, 0.03122983f, -0.08549816f, 0.00997188f, -0.07447614f, 0.09258329f, 
    0.18969320f, 0.39914483f, 0.01114216f, -0.08639432f, -0.15714654f, -0.00640828f, -0.03381452f, 0.00490614f, 
    0.01541360f, 0.04073595f, 0.11275040f, 0.14667992f, 0.00465513f, -0.04176149f, -0.07878201f, 0.07344524f, 
    0.04771420f, -0.01716533f, -0.05152715f, 0.00486573f, -0.20088048f, -0.29368082f, 0.10784237f, -0.01866731f, 
    0.29881492f, 0.14543733f, -0.07900669f, 0.06432626f, -0.00021093f, 0.17033857f, -0.10732852f, -0.09174680f, 
    0.01817089f, 0.08938506f, -0.03022725f, 0.00778872f, -0.01413071f, -0.02289114f, -0.07120582f, -0.12779056f, 
    0.04761899f, -0.15032975f, 0.02837411f, 0.07970106f, 0.13023829f, -0.05676773f, 0.12490840f, -0.00551872f, 
    -0.10624838f, -0.14061852f, 0.07868080f, -0.08964697f, 0.02200856f, 0.03773650f, -0.09705123f, 0.10083676f, 
    -0.04724496f, 0.06162820f, 0.02111376f, -0.00190919f, 0.08505298f, -0.32766512f, -0.10075833f, 0.15714487f, 
    -0.12886070f, -0.02674743f, 0.08299471f, 0.04788494f, 0.06742784f, 0.10117617f, 0.04939219f, -0.00268788f, 
    0.02808094f, -0.00127460f, 0.04304603f, -0.07226750f, 0.00219764f, 0.15864666f, -0.14472325f, 0.01939656f, 
    -0.09885218f, 0.33430290f, 0.03473563f, 0.07883249f, 0.15208410f, 0.05152749f, -0.03404627f, -0.03321386f, 
    -0.10191045f, -0.01422467f, -0.03846601f, 0.07602493f, 0.00011048f, -0.01080118f, 0.06091670f, 0.00722544f, 
    -0.04682450f, 0.00076647f, 0.12552875f, -0.03432232f, 0.14370240f, -0.02395146f, 0.00240000f, 0.22769235f, 
    0.06301277f, -0.08432297f, 0.01822657f, -0.08299774f, -0.09989411f, 0.15881482f, 0.02743588f, 0.02728328f, 
    0.09336582f, -0.09910299f, -0.03915568f, 0.01359321f, -0.07327055f, -0.03697040f, -0.02036547f, 0.13536780f, 
    0.00700822f, -0.42712331f, 0.06352136f, -0.35717416f, -0.19484374f, -0.07728667f, 0.04113032f, -0.00343350f, 
    0.09854424f, 0.13704267f, 0.12120885f, -0.01724527f, 0.00462935f, 0.08998677f, -0.08888926f, -0.10295872f, 
    -0.00696502f, -0.12831683f, 0.03524570f, 0.00864951f, 0.07255321f, 0.57212061f, -0.12358368f, 0.22366099f, 
    0.28203124f, 0.06728360f, -0.02865009f, -0.17662576f, 0.00198289f, -0.02539142f, -0.01214827f, -0.01757058f, 
    0.05026569f, -0.01456897f, -0.01769393f, 0.01314665f, 0.01780824f, 0.02152376f, 0.01497522f, -0.04761394f, 
    -0.33018416f, -0.01936560f, -0.01500652f, -0.34125659f, -0.07109506f, -0.01683547f, 0.12656277f, 0.06851345f, 
    -0.04384802f, 0.04519359f, 0.04742878f, -0.00727786f, 0.07621033f, 0.08786114f, -0.06469178f, 0.00443272f, 
    0.22775233f, -0.12123448f, -0.03816630f, 0.04830395f, -0.00928903f, 0.02132762f, -0.04541263f, -0.10559949f, 
    -0.11063295f, -0.08079153f, 0.13651519f, -0.06232358f, -0.03769226f, 0.11407305f, 0.13546677f, -0.04259745f, 
    -0.00278313f, -0.07553414f, 0.12063501f, 0.18609668f, -0.03823969f, -0.17459403f, 0.10094526f, 0.07139154f, 
    -0.14891538f, -0.01040999f, 0.14753674f, -0.20547108f, -0.04817418f, -0.02918322f, 0.00657703f, 0.07903320f, 
    0.01188795f, -0.02536147f, 0.02427526f, 0.00841045f, 0.05792267f, 0.06599327f, 0.05183822f, 0.01189767f, 
    -0.01453799f, 0.02357844f, -0.00117225f, 0.01853907f, -0.12759429f, 0.02605102f, 0.04330745f, -0.08215621f, 
    -0.24707001f, 0.01102019f, 0.00099480f, -0.22941044f, 0.06544598f, -0.11944247f, -0.03930603f, 0.07223785f, 
    -0.03409216f, 0.05676161f, 0.04790393f, 0.03502897f, -0.04870818f, -0.05925078f, -0.11225532f, 0.07591260f, 
    0.03070736f, -0.25138858f, 0.19352229f, -0.01906620f, -0.14358746f, -0.07013119f, 0.01826058f, 0.06560443f, 
    -0.04807952f, 0.00703165f, 0.02672340f, -0.08996058f, -0.04420304f, -0.08126003f, -0.01087405f, 0.17897888f, 
    0.11022556f, 0.06687151f, 0.00138372f, 0.03741548f, 0.08413330f, -0.31024772f, 0.07950354f, 0.13318157f, 
    -0.02088695f, -0.01991918f, -0.07992819f, -0.05016704f, 0.06093076f, 0.04194527f, 0.01188220f, -0.01978794f, 
    -0.06134949f, -0.02054633f, 0.05193600f, 0.06706792f, -0.05766146f, 0.14759591f, -0.09141690f, 0.03151755f, 
    -0.09027360f, 0.03254885f, -0.35769051f, 0.13525319f, 0.09281233f, 0.07175820f, -0.01842923f, 0.01214520f, 
    0.00865956f, 0.02315197f, -0.05985385f, -0.13141142f, 0.02431689f, 0.10681015f, 0.04943155f, -0.02521368f, 
    0.02257359f, -0.11630265f, 0.01971701f, 0.05189115f, -0.00060909f, 0.00991544f, -0.23118496f, -0.35388651f, 
    -0.04690815f, 0.00198054f, 0.03355648f, -0.05974420f, 0.04207165f, -0.08405868f, 0.14197388f, 0.15423179f, 
    -0.10929645f, 0.04486610f, 0.09859841f, 0.11333941f, 0.06136064f, -0.08904205f, -0.11390998f, 0.10843647f, 
    0.09034358f, 0.22916293f, 0.02825999f, 0.26840445f, 0.11503860f, 0.10464722f, -0.02768613f, 0.03739072f, 
    -0.03967776f, -0.07192686f, 0.03442619f, 0.01188525f, 0.07306070f, 0.09152859f, 0.12091031f, 0.07166786f, 
    0.02488754f, 0.06678871f, 0.04747862f, -0.12413073f, 0.24251993f, 0.10797919f, 0.15122028f, -0.05803703f, 
    0.25692996f, -0.04792796f, 0.08408954f, -0.16822620f, -0.03607898f, -0.14582574f, 0.13459615f, -0.12768850f, 
    -0.00173496f, 0.06205004f, 0.05514143f, 0.08172622f, -0.01090651f, -0.04371621f, 0.04569159f, -0.02188818f, 
    -0.13991842f, -0.17300771f, 0.11925001f, -0.04048454f, -0.13288322f, 0.02885695f, 0.04489679f, 0.01508291f, 
    0.03431525f, -0.03840244f, 0.08099357f, 0.11054685f, -0.04051268f, -0.00276276f, 0.03291292f, -0.05572375f, 
    -0.01834825f, -0.06407992f, 0.01391593f, 0.10378579f, 0.35159665f, -0.06330115f, 0.03221080f, 0.15279157f, 
    0.22413710f, -0.23112792f, 0.05032341f, -0.06774519f, -0.06876518f, 0.02709760f, 0.06024329f, -0.03254649f, 
    -0.04999426f, -0.05173690f, 0.07252918f, -0.14108315f, 0.04424747f, -0.05683607f, 0.08269060f, 0.03930869f, 
    0.01074746f, -0.04582960f, 0.02531266f, -0.06525723f, -0.04303049f, 0.02980241f, -0.03575112f, -0.04147054f, 
    -0.06066391f, -0.03861647f, 0.03731602f, 0.01524635f, 0.01499558f, 0.00279476f, -0.06020503f, -0.06028223f, 
    -0.05498747f, 0.00512000f, 0.02546743f, 0.01617820f, 0.01505413f, -0.02420809f, -0.01865224f, 0.00881589f, 
    -0.01522336f, 0.02008823f, -0.01930335f, 0.04870509f, -0.06385621f, -0.04946956f, -0.03352610f, -0.01860842f, 
    0.04502226f, 0.00669723f, -0.04022602f, -0.02167922f, -0.04800316f, -0.06621386f, 0.00651927f, -0.04535007f, 
    0.01173461f, -0.00830281f, 0.01266494f, 0.02601705f, -0.02236383f, -0.05738514f, -0.03001988f, -0.03622164f, 
    0.00587958f, 0.01964881f, 0.02068949f, 0.00056899f, 0.01228127f, -0.03064730f, -0.01445389f, 0.01224757f, 
    -0.03082774f, 0.00962836f, -0.03813554f, -0.00861271f, -0.02630608f, -0.02967529f, 0.03530493f, 0.01205073f, 
    -0.01848159f, -0.04883081f, 0.04388415f, 0.00718970f, -0.05341154f, -0.00456317f, -0.03149398f, 0.01556268f, 
    0.00245658f, -0.00012289f, 0.02723531f, -0.03997125f, 0.03680764f, 0.04241091f, 0.05031413f, -0.01451276f, 
    -0.04027671f, -0.05461617f, -0.04899845f, -0.05144540f, -0.03852767f, 0.03090748f, -0.00221090f, 0.00916961f, 
    -0.05012868f, -0.00336474f, 0.01764911f, 0.02107873f, 0.02886437f, 0.03558828f, 0.01169000f, 0.00638192f, 
    0.02944593f, 0.02381976f, 0.01159264f, -0.00616858f, -0.04803258f, -0.01928273f, -0.00442965f, -0.04865128f, 
    0.00055049f, 0.04351605f, -0.02162775f, -0.02650549f, -0.02231320f, -0.03949976f, 0.03773826f, 0.04528345f, 
    -0.00712773f, 0.01746643f, -0.00970343f, 0.04056757f, -0.00250387f, 0.01674336f, 0.02650067f, 0.00435101f, 
    -0.00177533f, -0.00212134f, -0.03601572f, 0.00250405f, -0.01023436f, 0.03714012f, 0.04522700f, -0.01482909f, 
    -0.00381861f, -0.01789056f, 0.03137976f, -0.04988907f, -0.02455900f, -0.01023543f, -0.03270390f, -0.04936515f, 
    0.04710601f, -0.00288197f, 0.03097463f, -0.00055484f, 0.03888752f, 0.03369509f, -0.03956890f, -0.02260049f, 
    -0.05220828f, 0.02044236f, 0.00250581f, -0.04773200f, -0.02871199f, -0.05761818f, -0.03848130f, 0.02700930f, 
    -0.00860397f, -0.04834180f, -0.03168649f, -0.03463753f, -0.00005754f, -0.04505542f, -0.01763545f, -0.06509177f, 
    -0.06119198f, 0.00758530f, 0.02328147f, -0.01287652f, 0.00756135f, 0.03272662f, 0.03479590f, -0.00807149f, 
    0.01679076f, 0.03779721f, -0.01673490f, 0.01258673f, 0.00501397f, -0.02427748f, 0.00713976f, 0.02320650f, 
    -0.02151559f, -0.01753844f, -0.04526768f, 0.03070491f, -0.03176244f, 0.02502944f, -0.00776856f, 0.03429239f, 
    0.04931723f, 0.00276112f, -0.01860034f, 0.03292600f, 0.00182181f, 0.00690594f, 0.01509998f, 0.01477304f, 
    0.03450145f, -0.04335270f, -0.05581012f, 0.03850468f, -0.03491121f, 0.03479880f, 0.01196797f, -0.00638816f, 
    -0.05799584f, 0.04308185f, 0.02175461f, -0.02849907f, 0.04525178f, 0.03877538f, 0.04212229f, 0.03124062f, 
    -0.02064407f, -0.05985037f, -0.03324065f, 0.00041336f, -0.05527389f, 0.03216906f, -0.03261687f, 0.03231199f, 
    -0.02782356f, 0.03544999f, -0.00792666f, 0.02087635f, -0.03949684f, 0.03579884f, -0.05730596f, -0.04043502f, 
    0.02296295f, 0.00666847f, -0.00465627f, -0.04154479f, -0.02679602f, -0.03614423f, 0.03563321f, 0.04469793f, 
    0.00865006f, -0.05841797f, 0.01137594f, 0.01696373f, -0.03278692f, 0.01974141f, 0.03740414f, 0.00287863f, 
    -0.03189887f, -0.03796501f, 0.00176822f, -0.00568585f, 0.00604755f, 0.03062160f, -0.02243499f, 0.00722028f, 
    -0.02733507f, -0.00658019f, 0.04869549f, -0.05200899f, 0.03456874f, -0.00516078f, 0.02796089f, -0.06627873f, 
    -0.04432693f, -0.03773969f, 0.04220172f, -0.05357876f, -0.03439162f, 0.02078600f, 0.01833086f, -0.03737679f, 
    0.00275078f, -0.03428075f, -0.00684877f, -0.04031147f, 0.00525642f, 0.00637467f, 0.00452843f, 0.00856101f, 
    -0.03956564f, 0.01720635f, 0.03842731f, -0.04604403f, 0.02319252f, -0.02495115f, -0.05746391f, -0.04730799f, 
    -0.05053819f, -0.01494726f, 0.00255119f, -0.01522730f, -0.04765214f, -0.04181014f, -0.05390598f, -0.01441460f, 
    0.01817984f, 0.00814078f, -0.05562203f, -0.00812416f, -0.00957053f, -0.00913727f, 0.01000058f, -0.01878810f, 
    0.04905657f, -0.04441315f, -0.06034780f, 0.01690652f, -0.00472662f, -0.02003189f, 0.03236278f, 0.03072446f, 
    0.02592330f, -0.00642558f, -0.05546286f, 0.00759014f, 0.01754862f, -0.00784895f, -0.04086661f, 0.02683257f, 
    -0.02707672f, -0.01400737f, -0.01834839f, -0.05897740f, 0.01890186f, 0.00587974f, -0.01834958f, -0.03724150f, 
    0.01443549f, 0.23432858f, -0.07467879f, 0.11760736f, -0.17172995f, -0.03348212f, 0.02686674f, 0.08899520f, 
    0.01332163f, 0.06248762f, -0.01130857f, -0.12301400f, 0.01893315f, 0.03419542f, 0.12805755f, -0.04422114f, 
    -0.04470827f, -0.05387405f, -0.14059167f, 0.02843193f, -0.33176687f, 0.21139652f, 0.16512170f, -0.05064821f, 
    0.00188107f, 0.08829493f, -0.00627077f, 0.02385780f, 0.02744407f, -0.00560717f, 0.08384554f, 0.02132297f, 
    -0.07010613f, -0.12795676f, -0.04408303f, -0.00086775f, 0.04278966f, -0.01236730f, -0.10940494f, 0.06891071f, 
    0.35046050f, -0.25010759f, 0.02880770f, -0.01294600f, 0.05396086f, -0.08728735f, 0.02001668f, 0.00067277f, 
    0.03192249f, 0.13862112f, -0.13350827f, -0.00802566f, -0.06781340f, -0.03202124f, -0.04078227f, 0.01626888f, 
    -0.06189006f, -0.08892097f, -0.04076995f, -0.13618997f, 0.00313692f, 0.08890126f, 0.22389781f, -0.07046227f, 
    0.05111476f, -0.11196662f, -0.08500142f, 0.12744096f, -0.03064370f, 0.13179834f, -0.12403226f, -0.05638141f, 
    0.07907534f, 0.08898398f, 0.00072475f, 0.05519098f, 0.07428034f, 0.03828654f, -0.07811494f, 0.13557252f, 
    -0.06751487f, 0.02591096f, -0.29989764f, 0.05349538f, -0.04969648f, 0.14322108f, 0.07557376f, -0.03551675f, 
    0.05859314f, 0.14507796f, -0.02331394f, 0.00729515f, 0.08800694f, -0.02687944f, 0.07991152f, -0.01066667f, 
    0.02027737f, -0.05517146f, 0.02469189f, 0.00980585f, -0.32822630f, 0.32225877f, 0.09323248f, -0.05207324f, 
    -0.01494416f, 0.00381899f, 0.00207120f, 0.16983600f, 0.05316576f, -0.13823549f, 0.12262788f, 0.12644035f, 
    -0.05689523f, -0.05437385f, -0.11196093f, -0.04735868f, -0.06501624f, 0.05013023f, -0.03278282f, 0.01000908f, 
    0.18158086f, -0.21629822f, -0.11617208f, 0.17315601f, 0.03753279f, 0.16977397f, -0.01985564f, 0.00353574f, 
    0.05421141f, 0.01804412f, -0.08994532f, 0.06505726f, -0.01046566f, -0.01426905f, 0.01931827f, -0.00330162f, 
    -0.06063323f, -0.02027272f, -0.03850459f, -0.04181955f, -0.17275366f, -0.08407762f, 0.17306881f, 0.28965998f, 
    -0.03578859f, -0.18085955f, -0.01507762f, 0.00911692f, 0.07273768f, 0.15628675f, -0.00089520f, -0.08388785f, 
    0.00736805f, -0.04824479f, 0.17835739f, -0.07023136f, -0.09790605f, -0.18637109f, -0.06945651f, 0.09959829f, 
    -0.11950615f, 0.26221496f, -0.19987857f, -0.02315552f, -0.09154152f, 0.11315608f, 0.11031303f, -0.01363226f, 
    0.01350187f, 0.01089321f, 0.12595318f, 0.00772367f, -0.06872248f, -0.00606874f, -0.00842451f, 0.08719630f, 
    0.09968162f, 0.00843167f, 0.07827007f, 0.07345688f, -0.25579944f, 0.16748092f, 0.10189540f, -0.15051895f, 
    -0.08361743f, -0.06513837f, 0.03419704f, -0.00293036f, -0.06210667f, 0.06971722f, -0.08379973f, 0.02986332f, 
    0.03550999f, -0.02315570f, 0.04086382f, 0.03399827f, 0.08167671f, 0.07565527f, -0.00121460f, -0.10135775f, 
    0.17494701f, -0.47356609f, 0.23772459f, 0.05783859f, 0.09826194f, 0.05070415f, -0.00941620f, 0.16525358f, 
    0.14108466f, 0.08639766f, 0.00388623f, -0.03626006f, -0.03204864f, -0.04594924f, 0.07962288f, -0.02405299f, 
    -0.02867350f, -0.00714713f, 0.00631426f, -0.03698690f, -0.04940629f, 0.07495204f, -0.30049822f, -0.05543952f, 
    -0.06333684f, 0.06732867f, 0.14766020f, 0.03278775f, 0.11220688f, -0.01990305f, 0.08921511f, -0.01190616f, 
    0.15422390f, 0.00823164f, 0.03480670f, 0.00351916f, 0.05661659f, -0.02475971f, 0.00389854f, -0.06503265f, 
    0.01271075f, 0.01512909f, 0.33845124f, 0.20253064f, 0.11593156f, -0.05035852f, -0.06902521f, 0.11304644f, 
    -0.01836906f, 0.05657021f, -0.10272931f, -0.07716210f, 0.00455513f, 0.19590405f, 0.10080395f, 0.04238626f, 
    -0.04207307f, -0.03984499f, -0.02293608f, 0.09338258f, -0.01119698f, 0.03699674f, 0.13373080f, 0.09018669f, 
    0.03331974f, -0.06758082f, 0.08329797f, -0.06395239f, 0.02115989f, 0.07689593f, 0.02861572f, 0.02316960f, 
    -0.05685180f, 0.06348817f, 0.05170614f, 0.09064756f, -0.02620056f, -0.02374871f, -0.09921929f, 0.07517835f, 
    0.15200669f, 0.07811413f, -0.02809128f, -0.23548040f, -0.06945407f, 0.11013032f, 0.08301651f, 0.06981757f, 
    -0.03622692f, 0.04816302f, -0.13420318f, 0.09704801f, 0.12545452f, -0.03621143f, -0.00951834f, -0.10009735f, 
    -0.03843165f, 0.01687262f, -0.02741724f, -0.05317480f, 0.14741659f, -0.11883284f, 0.21642259f, -0.20043990f, 
    0.00960302f, -0.01443875f, -0.16744095f, 0.03697921f, 0.01162776f, 0.05239552f, 0.06700138f, -0.09982143f, 
    0.09273732f, 0.11467005f, -0.10308222f, 0.08544228f, 0.08061733f, -0.13771336f, -0.04698777f, 0.02970490f, 
    -0.16571639f, 0.09993785f, -0.24200621f, -0.00571132f, 0.31941718f, 0.01204010f, 0.05607154f, -0.12731379f, 
    0.09253962f, 0.05109741f, 0.07409006f, 0.06547479f, 0.10122181f, 0.03829371f, 0.05384900f, 0.09919766f, 
    -0.03224967f, 0.02656873f, 0.03905627f, 0.10333991f, -0.30611372f, 0.17046690f, 0.04860521f, -0.03800149f, 
    -0.18747123f, 0.04711520f, -0.06469773f, 0.06471375f, -0.09507095f, 0.00090969f, 0.06730170f, 0.03105539f, 
    -0.01646943f, 0.00469002f, -0.08907220f, -0.00025236f, 0.17564489f, 0.08310264f, -0.03602073f, 0.03561742f, 
    -0.15484352f, -0.17066105f, 0.24297659f, 0.03584533f, -0.11293355f, -0.09867144f, -0.13249956f, -0.03639319f, 
    0.00703128f, -0.00828330f, 0.01057082f, -0.09223966f, 0.01685462f, -0.00411298f, 0.12754118f, -0.07578374f, 
    -0.14047232f, -0.20622709f, -0.06470647f, -0.06205648f, 0.28979939f, -0.15650520f, -0.00508436f, -0.12408651f, 
    0.25560740f, -0.01934638f, -0.03102869f, 0.01112284f, -0.14193776f, 0.09493391f, -0.13596852f, -0.01085888f, 
    0.06392701f, 0.18612322f, 0.01959749f, 0.10940199f, 0.04577806f, 0.17074390f, 0.02082630f, 0.17993151f, 
    -0.01753173f, 0.00925522f, -0.24499306f, 0.16331594f, -0.27694893f, -0.03747727f, -0.00292469f, 0.12260409f, 
    0.13820493f, 0.11289551f, -0.04498510f, 0.02843989f, 0.20263219f, -0.02898491f, 0.06604994f, 0.08237045f, 
    0.10781886f, -0.00107570f, 0.01939869f, 0.03273464f, -0.09612218f, 0.27057627f, 0.06269501f, -0.00129389f, 
    0.10165190f, -0.07766463f, -0.01691533f, -0.01849962f, 0.03180364f, -0.01813209f, 0.14657667f, 0.01604540f, 
    -0.06183904f, -0.18205762f, 0.07236047f, -0.03930967f, -0.13118878f, -0.13252093f, 0.12792577f, -0.05905357f, 
    -0.14446160f, -0.26679778f, 0.07293895f, 0.21982165f, -0.10236671f, 0.08139606f, 0.04762403f, -0.00751298f, 
    0.08732134f, -0.08919597f, -0.05619396f, -0.02321349f, 0.03836006f, 0.09907200f, -0.02959508f, 0.06831919f, 
    0.05421402f, 0.06900285f, -0.13839258f, 0.07202484f, -0.08542559f, 0.05605809f, 0.11655631f, 0.05261444f, 
    -0.28416350f, -0.08458563f, 0.08644971f, -0.07971012f, 0.06524586f, 0.07644437f, -0.02448374f, -0.04193829f, 
    0.19303699f, -0.02350372f, 0.01338417f, 0.06072559f, 0.16064055f, -0.06703493f, -0.15489516f, -0.03149682f, 
    -0.14778866f, 0.36491218f, 0.08300842f, -0.07982783f, -0.07652702f, -0.04643302f, 0.04441965f, -0.00661414f, 
    -0.02214034f, 0.00702261f, 0.05068595f, -0.03769964f, 0.13433714f, -0.10756413f, 0.00634782f, 0.14411472f, 
    -0.04742018f, 0.07938625f, 0.10037706f, 0.14857243f, -0.49362272f, 0.11489274f, 0.21487401f, -0.16588368f, 
    0.01423637f, -0.05072053f, -0.04884727f, -0.09694586f, 0.01705493f, 0.04593610f, 0.02756513f, 0.02994239f, 
    0.00614685f, -0.00764363f, 0.01662022f, -0.00211310f, 0.02729632f, 0.06621458f, 0.20113997f, 0.14059053f, 
    0.09501478f, -0.05088394f, 0.16863160f, -0.03207214f, -0.02041686f, -0.02082358f, -0.07286840f, 0.12467556f, 
    -0.01640237f, 0.09999394f, 0.12016057f, -0.04099627f, 0.01899495f, 0.02635275f, 0.18047751f, -0.03679131f, 
    0.06864102f, -0.17323112f, -0.19876462f, -0.00860588f, 0.22694622f, 0.11321080f, -0.28530848f, -0.00994590f, 
    -0.35212305f, 0.12283070f, -0.04565484f, 0.07429704f, -0.02039672f, 0.03155068f, 0.14586766f, -0.03296453f, 
    -0.13711846f, -0.07123749f, 0.08374174f, 0.13076852f, 0.13390575f, -0.01082876f, -0.03056773f, -0.18144776f, 
    0.12819670f, -0.23027748f, 0.06436044f, 0.01488963f, 0.27097666f, 0.01408688f, -0.01544282f, 0.02934539f, 
    -0.09334005f, 0.04824415f, 0.04714168f, -0.18206035f, -0.01275965f, 0.07507996f, 0.08518568f, 0.01376635f, 
    0.06713915f, -0.02080108f, 0.03240835f, -0.06372060f, 0.26552007f, 0.28314739f, -0.19438569f, 0.06378965f, 
    -0.33528212f, -0.04866913f, 0.14289932f, -0.02435169f, -0.01181868f, -0.11563277f, 0.16894002f, 0.03827076f, 
    0.06638806f, -0.01402391f, 0.05477973f, -0.02181764f, 0.01615140f, -0.02558376f, 0.11252619f, 0.12993352f, 
    0.02749972f, 0.01276119f, -0.01832160f, -0.10076220f, -0.12746401f, 0.06649301f, -0.17133455f, 0.07003480f, 
    -0.09104016f, 0.03499825f, 0.04125579f, 0.08265884f, 0.00373254f, 0.05303946f, 0.08576579f, -0.16563842f, 
    -0.10852705f, -0.00016519f, 0.06197685f, -0.13722630f, 0.02208824f, -0.17255038f, 0.23243870f, -0.12890939f, 
    0.33905238f, 0.04359409f, -0.01019538f, -0.04488174f, -0.05756706f, -0.03831288f, 0.14542876f, -0.04714090f, 
    0.05210483f, -0.07885792f, -0.01469717f, 0.08746450f, -0.00564787f, -0.04166092f, 0.17624679f, 0.04232784f, 
    0.30835706f, -0.17730431f, 0.04915624f, -0.07144681f, 0.02239666f, 0.03222194f, 0.05515071f, 0.17321922f, 
    0.01758469f, 0.03862341f, 0.05850049f, -0.08745424f, -0.01142360f, -0.05760006f, -0.11222196f, 0.14682063f, 
    -0.03066001f, 0.04034666f, -0.21570049f, -0.00460430f, 0.12722871f, 0.05360373f, 0.08123488f, -0.44005716f, 
    -0.05605133f, 0.11201656f, 0.01632195f, -0.07196764f, -0.02943003f, -0.11363752f, -0.03035184f, -0.01842007f, 
    -0.05243328f, 0.05025768f, 0.00552238f, -0.03599149f, 0.04127347f, -0.06972481f, 0.09345099f, -0.01355603f, 
    -0.08417699f, 0.39017323f, -0.12283724f, 0.08577619f, -0.30357680f, -0.04391626f, -0.05927712f, 0.08507230f, 
    0.01617295f, -0.05931215f, -0.05442974f, -0.01213601f, -0.00933243f, 0.03376189f, 0.11026987f, -0.01411162f, 
    0.09096105f, 0.14691648f, 0.18472700f, -0.07763171f, 0.23242563f, -0.09066415f, 0.14180680f, 0.08374445f, 
    0.03360905f, -0.09106731f, 0.01728929f, -0.02834431f, -0.00327154f, -0.04911858f, 0.00792048f, 0.09199538f, 
    -0.07602482f, -0.01373687f, -0.14105780f, 0.03893296f, -0.01655724f, -0.07313035f, -0.05781018f, -0.10100382f, 
    0.10157825f, 0.07009704f, 0.18439823f, 0.37780577f, 0.07578071f, 0.12153092f, 0.03258837f, 0.05686670f, 
    0.05448137f, 0.17193945f, -0.05689133f, 0.00795435f, -0.02517410f, 0.03178677f, -0.00862409f, 0.04346479f, 
    -0.16620952f, 0.02538806f, 0.08063273f, -0.05728274f, -0.30952397f, -0.34748736f, -0.21872559f, 0.02773020f, 
    0.26539814f, 0.06395198f, -0.12329309f, 0.03313537f, -0.11442408f, -0.08482374f, -0.10186730f, 0.14216554f, 
    -0.04441524f, 0.09589654f, -0.01661304f, -0.05705399f, 0.05153293f, 0.06060332f, 0.13021430f, -0.03111245f, 
    0.08844317f, 0.01888523f, -0.13206637f, 0.20154703f, 0.10379519f, 0.10643040f, 0.07861968f, 0.02837632f, 
    0.17921193f, 0.12362183f, -0.09977811f, 0.05013670f, -0.04635357f, -0.01458088f, -0.02049394f, 0.11480242f, 
    -0.13769144f, -0.00190513f, 0.08006554f, -0.06264424f, -0.33026090f, -0.42339522f, 0.17079864f, -0.22567859f, 
    -0.20419115f, 0.12124120f, 0.03943752f, 0.05665110f, -0.21831392f, 0.02223215f, -0.01716343f, 0.02979151f, 
    -0.00951059f, -0.10586714f, -0.04561462f, -0.02480836f, -0.08622250f, -0.09273182f, 0.17221639f, 0.02158575f, 
    0.07917340f, 0.21702304f, -0.34593505f, 0.04339555f, 0.21623769f, 0.13162681f, -0.02211265f, 0.03920616f, 
    -0.06651118f, 0.02214391f, -0.04711871f, 0.12627697f, 0.05014995f, 0.15840968f, -0.00454768f, -0.04773591f, 
    -0.09761870f, -0.20843884f, 0.07550807f, -0.03313547f, 0.16077211f, 0.37309405f, -0.15369581f, -0.33853102f, 
    0.20743404f, -0.03640866f, -0.04910672f, 0.03025233f, -0.02115966f, -0.04344124f, -0.05128988f, -0.01143460f, 
    -0.02379075f, 0.04212433f, -0.08099632f, 0.03935818f, -0.05940738f, -0.13469723f, -0.06762651f, 0.03167792f, 
    0.27437896f, 0.39175355f, -0.01174734f, -0.23265427f, -0.29216760f, -0.15073487f, 0.02287561f, -0.05040539f, 
    0.20646027f, 0.02021254f, 0.08056349f, 0.08745366f, 0.05567518f, 0.09658686f, -0.04705593f, 0.01686657f, 
    -0.01156327f, 0.05221736f, -0.00153030f, 0.09765802f, -0.34016475f, -0.11883901f, 0.09474569f, 0.41246825f, 
    0.00858149f, 0.08121765f, -0.04059245f, 0.02504079f, -0.01013059f, 0.25899282f, -0.11069883f, -0.12116793f, 
    0.07143409f, 0.04443691f, 0.03497732f, -0.08895316f, 0.00449725f, 0.08103666f, 0.04733966f, -0.12342129f, 
    -0.00034774f, -0.04427982f, 0.11367249f, -0.08718118f, -0.04609866f, -0.20746410f, 0.16010924f, -0.03341539f, 
    0.01658751f, 0.12238954f, -0.01735744f, -0.05597077f, 0.05652889f, -0.04759985f, -0.06595124f, -0.09069575f, 
    0.07155558f, -0.01606909f, 0.01230248f, 0.08806446f, 0.06840867f, 0.03916143f, -0.12201656f, 0.09172018f, 
    -0.14932734f, 0.12795351f, -0.07245025f, 0.00053827f, 0.03825897f, 0.09701296f, 0.01863537f, 0.08379301f, 
    0.10358556f, 0.04993309f, -0.05420882f, 0.01525392f, 0.04180292f, -0.10248058f, 0.02419746f, 0.05105949f, 
    -0.21441716f, -0.04068792f, 0.01789765f, -0.17002028f, 0.00863621f, 0.11335596f, 0.01916411f, 0.02201534f, 
    0.04010003f, 0.18422267f, 0.04192509f, -0.07349861f, 0.06432531f, 0.11094370f, -0.02578558f, -0.01348598f, 
    0.06032150f, 0.10771558f, -0.05349078f, 0.04881570f, 0.02405942f, 0.40189362f, 0.17975603f, -0.06710577f, 
    -0.15521285f, 0.12351101f, 0.05663731f, -0.02752727f, 0.13239364f, -0.04817214f, -0.15422539f, -0.00264534f, 
    0.00133708f, 0.04464984f, 0.06279669f, -0.05203992f, 0.02290419f, -0.04803718f, -0.08388355f, -0.02406754f, 
    -0.01159478f, 0.04152069f, -0.03502338f, 0.00491841f, 0.00391178f, -0.02474802f, -0.05451004f, -0.03290378f, 
    -0.04011430f, -0.05002933f, -0.04457382f, -0.04568546f, 0.04617803f, 0.00051236f, 0.01934851f, -0.05848164f, 
    0.05136178f, 0.01529088f, 0.00248818f, -0.02800299f, 0.00250825f, -0.03150928f, 0.04566092f, -0.01413676f, 
    -0.02598774f, -0.04521078f, 0.01418461f, -0.02274142f, -0.03069600f, 0.03610304f, 0.01760734f, -0.03264085f, 
    0.02963994f, -0.01601020f, -0.03976532f, 0.00880965f, -0.02813582f, -0.01169178f, -0.00019199f, 0.04621367f, 
    -0.04303643f, 0.00943378f, 0.04012067f, 0.02789602f, -0.00730543f, 0.02441235f, -0.04728223f, 0.01874568f, 
    -0.04073387f, -0.02868456f, 0.04125460f, -0.02462663f, 0.02413495f, -0.01068014f, 0.03708408f, -0.02357215f, 
    -0.04938660f, -0.06475350f, 0.00133463f, -0.00322680f, 0.01206312f, 0.01883277f, 0.00417085f, 0.02948930f, 
    0.03434214f, -0.04241769f, 0.04715364f, 0.01115111f, -0.00467614f, 0.02046187f, -0.00380792f, 0.00473189f, 
    -0.04023275f, 0.01827252f, -0.03105080f, -0.04310382f, -0.01860968f, -0.02453149f, -0.01022536f, 0.00873129f, 
    -0.03855640f, 0.00986986f, -0.04976723f, -0.04707251f, -0.02305059f, -0.02199648f, 0.04255608f, -0.03303530f, 
    -0.01084701f, 0.00174116f, 0.04220234f, 0.04712515f, 0.02278045f, -0.05949627f, -0.05438346f, -0.03104377f, 
    0.00106860f, 0.02120703f, 0.02583606f, -0.01106589f, 0.03476435f, -0.00663233f, -0.04316790f, 0.01827001f, 
    0.01946962f, -0.06235927f, 0.03720540f, 0.02184384f, 0.02945345f, 0.02088070f, -0.02303557f, -0.00412923f, 
    -0.00377253f, -0.05802932f, -0.03026702f, 0.00802377f, -0.00027734f, -0.01504385f, -0.01698803f, -0.04418146f, 
    0.02249915f, -0.01911642f, -0.05499355f, -0.03514846f, -0.04983666f, -0.03724811f, 0.04003304f, 0.02375865f, 
    -0.04227662f, -0.03838077f, 0.01140687f, 0.01895017f, -0.03694208f, -0.05045420f, -0.06145359f, 0.01315245f, 
    -0.05183238f, 0.02203628f, -0.02350125f, 0.02439761f, 0.01854688f, -0.01945653f, 0.04590182f, 0.03035076f, 
    0.00187943f, -0.01148405f, -0.04003347f, 0.02860348f, -0.03335707f, -0.03570740f, -0.01627822f, 0.04362234f, 
    0.03599292f, -0.01975634f, -0.01989931f, -0.05225341f, -0.04731551f, 0.02102608f, -0.01821171f, 0.00229246f, 
    0.03870690f, -0.01225598f, 0.04733820f, 0.04108248f, -0.01693220f, -0.02593156f, 0.00226924f, -0.04386933f, 
    0.04885263f, -0.05173030f, -0.00880881f, 0.01340250f, 0.04030818f, 0.03847621f, 0.01009906f, -0.03915508f, 
    0.00822503f, 0.03923944f, 0.04342826f, 0.00699476f, 0.03289866f, -0.02515681f, 0.01319819f, -0.05782238f, 
    -0.03247774f, -0.01109130f, -0.06350657f, 0.01161475f, -0.02442646f, -0.03099655f, 0.04035080f, 0.00139763f, 
    -0.05626088f, -0.00774642f, -0.01905168f, 0.00240125f, 0.03791270f, -0.04261778f, -0.05541428f, -0.00958078f, 
    -0.00082275f, -0.02134558f, 0.05516914f, 0.02115437f, -0.02167711f, -0.03890545f, 0.04813484f, 0.05248022f, 
    0.03475042f, 0.03080817f, -0.03626656f, -0.01226424f, -0.00550738f, 0.03264555f, -0.00689166f, -0.05376354f, 
    -0.04578236f, -0.01978436f, 0.04641526f, 0.00253207f, -0.03077810f, 0.01710541f, -0.02408594f, 0.01910668f, 
    -0.03625073f, 0.04477508f, 0.03918331f, 0.04568938f, -0.04138416f, 0.01312649f, -0.04263592f, 0.00576038f, 
    -0.00641075f, -0.00295431f, -0.00795459f, -0.05541595f, -0.06693506f, -0.05362317f, -0.05230645f, 0.04132469f, 
    -0.01274560f, -0.00868244f, 0.00310856f, 0.04436066f, -0.06420463f, 0.02004720f, -0.04421094f, -0.04258328f, 
    0.01918605f, -0.00448427f, -0.03395111f, 0.03606053f, 0.03585747f, 0.01448783f, 0.03052437f, -0.05814247f, 
    -0.04294888f, -0.04774694f, 0.01487790f, -0.05529002f, -0.05731302f, -0.02216806f, -0.01112164f, -0.03918065f, 
    -0.00057418f, 0.00209737f, -0.06157997f, 0.04216836f, -0.02896261f, -0.01833853f, 0.02668450f, -0.04252197f, 
    0.04486754f, -0.00606328f, -0.00995422f, 0.02500631f, 0.02999792f, -0.05099684f, 0.03271900f, 0.00632196f, 
    -0.05398871f, -0.00875736f, -0.02144714f, -0.00126656f, 0.02958329f, -0.02326502f, -0.04698512f, 0.01480812f, 
    -0.05434148f, -0.02963474f, 0.00691721f, 0.02417726f, -0.06361940f, 0.03904213f, -0.02544854f, 0.00355311f, 
    0.02403794f, 0.00988131f, -0.05191629f, -0.05887748f, -0.01364177f, 0.02325130f, -0.02978764f, -0.02850338f, 
    -0.05801050f, 0.01095141f, -0.01885322f, 0.03537495f, 0.01785302f, 0.04130843f, 0.01431548f, 0.02757789f, 
    -0.05071777f, -0.03470929f, -0.00398083f, 0.04199530f, -0.05946869f, 0.03936999f, 0.00981580f, -0.05521432f, 
    -0.03166155f, 0.01024477f, -0.04690157f, 0.03930872f, 0.01036103f, -0.01737086f, -0.00650151f, 0.01565800f, 
    0.03957230f, -0.02518469f, 0.00273962f, -0.02957007f, 0.00534926f, -0.04021715f, -0.04429111f, -0.01055178f, 
    -0.01578800f, 0.02040712f, -0.05781666f, 0.04455091f, -0.03845613f, -0.01021340f, -0.01712299f, 0.04701639f, 
    -0.01841707f, -0.00821476f, -0.04082988f, 0.01325261f, 0.04917328f, -0.03924914f, 0.00688186f, 0.03483129f, 
    0.00101349f, -0.03823582f, 0.01459047f, 0.00837164f, -0.01838610f, -0.03477381f, -0.04004936f, -0.03581934f, 
    -0.03628010f, -0.02861740f, 0.02683112f, -0.06524968f, 0.07262927f, -0.04022403f, 0.03709681f, -0.02147339f, 
    -0.03166827f, 0.03510641f, -0.01901678f, 0.02795555f, -0.05690546f, -0.00668290f, 0.00629728f, -0.05342676f, 
    -0.03034200f, 0.02626557f, 0.02562093f, 0.03420341f, -0.06260965f, 0.04900889f, 0.03523004f, 0.00115597f, 
    -0.02249028f, -0.05385638f, -0.04193468f, 0.03080226f, 0.00772915f, 0.02674884f, 0.00245036f, -0.04369247f, 
    0.01018672f, -0.01812984f, 0.02565974f, -0.04538881f, -0.03507206f, 0.00963348f, 0.03143575f, -0.00359924f, 
    -0.05312828f, 0.02022784f, -0.03347612f, 0.00242530f, 0.01899763f, -0.04995228f, -0.04418861f, 0.03105372f, 
    0.01620104f, 0.03381784f, 0.03169109f, -0.05567544f, 0.00783219f, 0.00052141f, -0.00277117f, 0.00739100f, 
    -0.03671859f, -0.02006283f, 0.00383300f, -0.04918091f, -0.06812007f, -0.00636308f, -0.03238047f, 0.00506789f, 
    -0.07123666f, 0.02634324f, -0.00637065f, 0.00893533f, 0.00892325f, -0.03142913f, 0.02127475f, 0.02582724f, 
    0.03415586f, 0.03378487f, 0.00195068f, -0.04573038f, -0.05126568f, 0.00214891f, -0.00853325f, 0.01895257f, 
    0.02971306f, 0.02430423f, -0.06382699f, -0.01301844f, 0.01104571f, 0.00267401f, -0.06055275f, -0.04701367f, 
    -0.02595164f, -0.00443065f, 0.01871500f, -0.00384553f, -0.03684214f, 0.00545571f, 0.05148754f, 0.00844313f, 
    -0.02822582f, -0.04396471f, 0.04580465f, -0.01872391f, -0.03370330f, -0.00264196f, 0.03968353f, -0.04629882f, 
    0.01449893f, 0.00399812f, 0.05292537f, 0.00864323f, -0.03198382f, 0.00747954f, -0.03155628f, 0.00697355f, 
    0.04074546f, -0.04147303f, 0.04244592f, 0.05604602f, 0.03530493f, -0.04240813f, 0.04354247f, -0.01469867f, 
    0.03745079f, 0.02619321f, -0.05151135f, -0.05088285f, -0.00061541f, -0.06803999f, -0.02888192f, -0.01150527f, 
    -0.02355425f, 0.00728730f, 0.05205392f, -0.01004957f, -0.05465861f, -0.00437186f, -0.03556796f, 0.01533076f, 
    -0.04676779f, -0.00433250f, -0.01746375f, -0.02056124f, 0.03304695f, -0.02758747f, -0.02767871f, -0.02509800f, 
    -0.04946118f, 0.00849465f, -0.04767316f, 0.03259358f, 0.00264868f, 0.02844266f, 0.02423117f, 0.04049827f, 
    -0.01515714f, -0.00218310f, -0.01117120f, 0.00998413f, -0.02061650f, 0.01184552f, -0.01164350f, -0.02801456f, 
    -0.07256608f, 0.00917481f, -0.00111018f, -0.04616500f, 0.01247277f, 0.00554659f, -0.04262496f, 0.01137177f, 
    -0.06203289f, 0.03872897f, 0.00463472f, -0.00779027f, -0.05479425f, 0.02733872f, 0.05534891f, -0.01861545f, 
    -0.03729971f, -0.04769723f, 0.07421102f, -0.01299863f, 0.03627612f, -0.08052709f, -0.01248235f, -0.06131301f, 
    0.02756899f, 0.02960736f, -0.04079384f, 0.02046942f, -0.03986978f, 0.03365832f, -0.04312580f, -0.00336730f, 
    0.03588430f, -0.02168071f, -0.02269115f, 0.00914871f, -0.02601095f, -0.06521366f, 0.01089628f, 0.04511351f, 
    -0.01949816f, -0.00482083f, -0.01552915f, -0.03136767f, 0.04556313f, -0.04709776f, 0.05777547f, -0.00035285f, 
    -0.05792121f, -0.02503782f, -0.01206576f, -0.04467656f, 0.04266023f, 0.05622040f, 0.03020282f, -0.01071455f, 
    -0.05476856f, -0.00930731f, 0.03527879f, -0.04695182f, -0.00200984f, -0.00989450f, -0.01269212f, -0.06653833f, 
    -0.00625759f, -0.02499394f, 0.00784271f, 0.04478220f, -0.00036901f, -0.00633000f, -0.03363333f, -0.05889352f, 
    0.00777117f, -0.05225911f, 0.00734691f, -0.06929837f, -0.00130371f, 0.02099747f, -0.05030502f, -0.01195272f, 
    -0.04127586f, -0.00275029f, -0.03003479f, 0.02643574f, 0.03706480f, 0.01908606f, -0.02213060f, -0.06037653f, 
    -0.05809981f, 0.01756312f, 0.03743164f, 0.04290238f, 0.00995308f, -0.01336716f, -0.02718541f, 0.04174118f, 
    -0.02108234f, 0.02585026f, -0.00978264f, -0.02906394f, -0.03504121f, -0.04006147f, 0.00731147f, 0.00919481f, 
    -0.03232050f, 0.00951871f, -0.00474919f, -0.03801429f, -0.00577631f, 0.00410174f, 0.00771876f, -0.02351832f, 
    -0.03956512f, -0.01055631f, 0.00565336f, -0.03935352f, -0.05283369f, 0.00537361f, 0.06146408f, -0.06206167f, 
    0.24301904f, -0.63403571f, -0.02267496f, -0.01668537f, -0.01960230f, 0.03439341f, -0.00707155f, -0.15696584f, 
    -0.01389790f, -0.01018922f, -0.01288064f, 0.01730083f, 0.12858465f, 0.05420039f, -0.00885590f, -0.05923718f, 
    -0.02022808f, 0.00817141f, -0.10606856f, -0.02962435f, 0.16247272f, -0.12933534f, -0.05760838f, -0.01833544f, 
    0.05245125f, 0.01839972f, 0.02472563f, 0.05974378f, 0.05473332f, -0.02621994f, 0.10402536f, -0.04108011f, 
    -0.00684129f, 0.13495675f, 0.00155825f, -0.02707830f, 0.11355940f, 0.07289021f, 0.03102123f, -0.04390446f, 
    -0.20873697f, 0.11527923f, 0.13223705f, 0.03658884f, 0.16983232f, -0.00064433f, 0.08295117f, 0.06992847f, 
    0.03722804f, -0.01958309f, 0.02554956f, -0.07836881f, 0.05983322f, -0.00638478f, 0.06222875f, 0.11220310f, 
    -0.05188421f, 0.08016159f, -0.03055293f, 0.11158127f, -0.13671702f, -0.06783310f, 0.02936964f, -0.25896984f, 
    -0.23935018f, 0.14767575f, 0.14037074f, 0.10541429f, -0.11972919f, -0.14998075f, -0.03086145f, -0.11944357f, 
    -0.08648131f, 0.04283302f, -0.04209403f, -0.03688787f, -0.00638005f, 0.14165939f, 0.04136603f, 0.03769056f, 
    0.11268273f, -0.02990779f, 0.25407299f, 0.25065231f, 0.10704025f, -0.04094194f, -0.04933626f, -0.00182544f, 
    0.02231018f, -0.02549911f, 0.01415142f, 0.03466190f, -0.09885439f, -0.07547036f, -0.02306793f, -0.05263149f, 
    -0.01065827f, 0.10961615f, 0.09569243f, -0.03218753f, 0.44963595f, 0.08227541f, 0.05094013f, 0.02286535f, 
    0.20440133f, 0.04576049f, -0.13717821f, -0.10871039f, 0.07239088f, 0.02178927f, 0.05628512f, -0.00354443f, 
    0.06896225f, -0.04677177f, -0.04505570f, -0.14095761f, 0.08662196f, 0.03893868f, 0.06231058f, -0.05446847f, 
    0.33286721f, 0.07138497f, 0.16553035f, -0.10356687f, -0.05205786f, -0.06355218f, 0.06863829f, -0.15857628f, 
    -0.06386799f, 0.03290269f, -0.04807615f, -0.05242679f, -0.08891364f, 0.02575628f, -0.02818559f, 0.00282901f, 
    0.13964991f, 0.10476922f, 0.07518916f, 0.08541701f, 0.20979017f, 0.03919517f, -0.19415383f, -0.27644035f, 
    -0.11973142f, 0.04840120f, 0.04372973f, -0.00322796f, -0.01823628f, -0.12354279f, -0.01079412f, 0.10530797f, 
    0.11167932f, 0.07290228f, -0.06514458f, 0.03005493f, 0.20128313f, 0.00033768f, -0.09080417f, 0.00310237f, 
    0.21639289f, 0.09688318f, 0.09003624f, 0.11743698f, 0.06098357f, 0.04339792f, -0.05119886f, 0.03884466f, 
    0.00642565f, 0.12225871f, 0.05095427f, -0.03694815f, 0.08491550f, -0.01384460f, 0.03282525f, -0.08496163f, 
    -0.14223029f, 0.01629898f, 0.09261807f, 0.00076801f, 0.04553324f, -0.08129216f, -0.05647545f, -0.03697751f, 
    0.01429227f, 0.05829773f, 0.03324649f, 0.00259523f, -0.07834526f, -0.06226203f, 0.03690368f, -0.02719296f, 
    0.06033570f, 0.00161150f, 0.00215436f, -0.04124826f, 0.02591996f, 0.04228922f, 0.14189965f, 0.06642857f, 
    -0.18628967f, 0.16743279f, 0.09426581f, 0.01325837f, -0.08999696f, 0.05703258f, -0.02398305f, -0.08006202f, 
    0.03196162f, -0.03658669f, 0.09322337f, 0.14953297f, 0.01798534f, -0.05925283f, 0.02243698f, 0.01978389f, 
    -0.03651489f, -0.04491232f, 0.01063245f, 0.04518173f, 0.16398156f, 0.23184356f, 0.22386940f, 0.14974745f, 
    0.13606448f, -0.01673049f, 0.07777057f, -0.05154308f, -0.00728769f, 0.25143954f, 0.02834850f, 0.10111384f, 
    -0.15141042f, -0.05270777f, -0.15646543f, 0.05311229f, 0.01695383f, -0.08049940f, 0.04597803f, -0.11942848f, 
    -0.42689869f, -0.16676037f, -0.14576621f, -0.32561070f, -0.06828349f, 0.05391600f, 0.05402135f, -0.08261350f, 
    -0.07256013f, -0.04775655f, -0.03503872f, 0.01548948f, -0.06224979f, -0.09501512f, 0.02419915f, -0.06817035f, 
    -0.01311084f, 0.03408418f, -0.04438426f, -0.07013988f, 0.18125470f, 0.10575566f, -0.08806970f, 0.04284520f, 
    -0.12374313f, -0.08971575f, 0.00860526f, 0.06002771f, 0.06689067f, -0.01467712f, -0.08330726f, 0.03394747f, 
    -0.07498154f, -0.03627729f, -0.02791393f, -0.09810066f, 0.07896341f, 0.03760312f, 0.11463105f, 0.02310503f, 
    -0.38522172f, -0.00524079f, 0.02979227f, 0.28322208f, 0.16245320f, 0.00179277f, -0.04367202f, 0.03613371f, 
    0.03870234f, 0.08311515f, -0.00714587f, -0.01152510f, 0.00750414f, -0.07254183f, -0.04722941f, 0.12194283f, 
    0.01686564f, -0.05666034f, 0.03999327f, -0.05938523f, -0.44147846f, 0.22978224f, 0.08979149f, -0.18239492f, 
    0.01292658f, 0.15477446f, 0.21481889f, 0.10170764f, -0.09530811f, -0.11802226f, 0.09334688f, 0.08146979f, 
    -0.03855106f, -0.10884403f, 0.08128963f, 0.16435342f, -0.00357187f, 0.08706474f, 0.10670791f, -0.06391704f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01188836f, 0.08181083f, -0.02861624f, 0.10938866f, 0.05966751f, -0.01279305f, 0.02818710f, 0.03982625f, 
    0.06997158f, -0.04572326f, -0.00246350f, -0.02481238f, 0.01556145f, 0.06356716f, 0.01290710f, 0.01948966f, 
    -0.05369742f, 0.08578482f, 0.03100641f, 0.04266045f, -0.01496798f, 0.11926544f, 0.02439263f, 0.02470544f, 
    -0.03049905f, 0.06488843f, 0.02039069f, 0.03563524f, -0.03720813f, 0.00388867f, 0.06744295f, -0.09225369f, 
    0.00871819f, -0.07853961f, 0.02869811f, -0.04024716f, -0.00393820f, -0.01350600f, 0.01185525f, 0.00055311f, 
    0.03781120f, -0.05815298f, 0.00490294f, -0.03600284f, 0.00499360f, 0.01705894f, 0.09718960f, -0.04321850f, 
    0.07692898f, 0.04309333f, -0.05495149f, -0.06440064f, -0.00967631f, 0.13751085f, 0.03995562f, 0.00972142f, 
    0.01546660f, -0.05461976f, 0.09711143f, 0.07972845f, 0.02253375f, -0.05122089f, 0.00400628f, 0.01101651f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.32235989f, -0.10431321f, 0.26260960f, -0.27088070f, 0.22592786f, 0.26084554f, 0.02602761f, -0.53967905f, 
    0.26373655f, -0.04516909f, -0.37362838f, 0.02791938f, -0.40028960f, 0.12486161f, 0.11682656f, -0.20818944f, 
    -0.11595502f, -0.30726761f, 0.09251812f, -0.18560882f, -0.04367236f, -0.07148907f, -0.01752929f, 0.09581129f, 
    -0.10480613f, 0.28660744f, -0.07120800f, 0.08350149f, -0.04157218f, 0.09459373f, -0.34660152f, 0.27557021f, 
    -0.06720463f, -0.10338034f, -0.02835966f, -0.11444886f, -0.03166507f, -0.07295064f, -0.09383652f, -0.35151047f, 
    0.05346691f, -0.10627870f, -0.01331796f, 0.09944966f, 0.06163936f, 0.06009176f, -0.43684214f, 0.04908034f, 
    0.26628989f, -0.31248719f, 0.01571812f, 0.05949092f, 0.30937091f, -0.22640997f, 0.10269227f, -0.00582606f, 
    0.06475829f, -0.08851192f, 0.09332789f, 0.24061672f, -0.38896510f, 0.02868281f, -0.10151140f, -0.20092401f, 
    -0.51162720f, -0.83762324f, -0.27961376f, 0.13572913f, -0.01640360f, -0.10087372f, -0.04154527f, -0.01989748f, 
    0.16639835f, -0.05830595f, 0.01278120f, 0.10774811f, 0.12143177f, -0.14344639f, 0.01991589f, -0.30547932f, 
    -0.09717111f, 0.14329004f, -0.06691613f, -0.44586864f, -0.00758192f, 0.22771564f, -0.03637945f, 0.07507835f, 
    -0.07018002f, 0.19446889f, 0.23195982f, -0.07694539f, 0.10090509f, -0.00666258f, -0.14531040f, 0.04839798f, 
    -0.01400004f, -0.04161116f, -0.01630771f, -0.04500283f, -0.05248052f, 0.21924342f, -0.07672802f, 0.22931993f, 
    0.02016523f, -0.34483808f, -0.40810546f, 0.06902299f, 0.19593415f, 0.19056965f, -0.28178850f, -0.00583149f, 
    0.11931487f, 0.24783826f, -0.00851167f, -0.04952789f, -0.01959610f, 0.06818215f, -0.11804618f, -0.16025357f, 
    0.07501445f, -0.03530703f, 0.19374289f, 0.19923384f, 0.23974708f, -0.02326626f, -0.03659261f, -0.17496455f, 
    0.24980488f, -0.22526143f, 0.42252949f, 0.09410062f, -0.41938099f, 0.16416192f, 0.07950187f, 0.08431519f, 
    -0.41588411f, -0.09543989f, 0.28773111f, -0.06920857f, -0.09642827f, -0.41960552f, -0.37867233f, -0.09406116f, 
    0.12336713f, -0.20028757f, -0.02323085f, -0.09390278f, -0.06875523f, -0.11395102f, 0.30647621f, -0.00329190f, 
    -0.01712396f, -0.48900181f, -0.09313966f, 0.12143148f, 0.08426749f, 0.00846442f, -0.16040745f, 0.22083817f, 
    -0.11912701f, 0.27001601f, -0.03404021f, -0.05008008f, -0.06359920f, 0.39704040f, -0.02798093f, 0.17730290f, 
    0.11976166f, 0.13287641f, -0.14504908f, -0.50561953f, 0.06564324f, 0.35051912f, -0.05133008f, -0.09589458f, 
    0.00856853f, -0.23154527f, 0.01604189f, -0.06159495f, 0.25073448f, -0.38332981f, 0.00542299f, 0.28310615f, 
    -0.10225412f, 0.02269848f, 0.03659394f, -0.07638364f, -0.04198568f, -0.01070287f, 0.02350285f, 0.16411717f, 
    0.04679206f, 0.19054456f, 0.34141561f, -0.34070209f, -0.25067294f, 0.29915339f, 0.02809862f, 0.34191185f, 
    0.10510479f, -0.11435854f, -0.05774648f, -0.12672862f, 0.27411956f, -0.05443442f, 0.26929593f, 0.20019424f, 
    0.03167674f, -0.14293362f, 0.04090587f, -0.04156133f, 0.08365002f, -0.11762408f, -0.00551801f, 0.07965998f, 
    -0.08434461f, 0.22335848f, -0.75169301f, 0.03566418f, -0.08597222f, -0.02338853f, 0.37771004f, 0.18959466f, 
    -0.00829373f, -0.19235286f, -0.10164906f, 0.11330067f, -0.05847831f, -0.03759471f, 0.02763445f, -0.70214802f, 
    -0.10857094f, -0.16390203f, -0.04830531f, 0.14020082f, 0.10975725f, -0.02052471f, -0.27759165f, 0.10768449f, 
    -0.13374351f, -0.48387805f, -0.03785330f, 0.01190546f, -0.75887072f, 0.03101579f, -0.05469158f, -0.37569588f, 
    -0.20364839f, 0.08302306f, -0.03770154f, 0.14113900f, -0.17793295f, 0.08855902f, -0.00412002f, -0.16883473f, 
    -0.01770975f, 0.14500372f, 0.33181798f, -0.24587823f, -0.03433559f, -0.28932279f, 0.11564165f, -0.04195724f, 
    -0.02799295f, -0.05032421f, -0.28941345f, 0.03793897f, 0.01250930f, 0.14717036f, -0.07269239f, 0.09151507f, 
    0.04507465f, -0.38498813f, 0.06714257f, 0.21156755f, -0.04890054f, -0.00895190f, -0.26894945f, 0.08041157f, 
    0.00106407f, -0.30708653f, 0.38359359f, -0.07239616f, -0.29590353f, 0.00069946f, 0.25683331f, -0.23129463f, 
    0.09549466f, 0.21347135f, 0.07816852f, -0.01189585f, -0.05216024f, 0.07361345f, -0.00427578f, -0.24097496f, 
    -0.06615748f, 0.02426022f, 0.22041924f, 0.12686835f, 0.24546936f, 0.25005484f, -0.01364887f, 0.01143507f, 
    -0.07384106f, 0.13860998f, 0.06955843f, 0.11290605f, -0.21648361f, 0.25950563f, -0.11353331f, -0.13559470f, 
    -0.11982816f, 0.02432992f, 0.18037228f, -0.07543456f, 0.38244185f, -0.03938131f, -0.08542973f, -0.43743885f, 
    -0.57150143f, -0.01599707f, -0.32646915f, 0.37218434f, 0.26955354f, -0.01583050f, 0.07268435f, -0.29056147f, 
    -0.25313246f, -0.03906956f, 0.05889891f, -0.03852653f, -0.07971622f, 0.32390982f, 0.02943989f, 0.19161117f, 
    -0.01152862f, 0.06757215f, 0.01755424f, -0.09930769f, 0.09746830f, 0.11588228f, -0.48307064f, -0.00547051f, 
    0.06848467f, 0.08037215f, -0.03618754f, -0.04788893f, -0.32750311f, -0.03787455f, -0.12188068f, -0.10109194f, 
    -0.06510734f, -0.59414905f, 0.08301461f, -0.00439501f, -0.07073548f, 0.16151530f, 0.06125355f, -0.14202099f, 
    -0.00198577f, 0.25092289f, -0.00884917f, 0.13702129f, -0.12684116f, -0.12877585f, -0.18988465f, -0.11268141f, 
    -0.13107242f, 0.30828333f, -0.04981177f, 0.02097915f, 0.01957723f, 0.14282750f, -0.04092081f, -0.26340190f, 
    0.11651937f, 0.09142782f, 0.21403395f, 0.17485990f, -0.47735807f, -0.02501636f, 0.09820497f, -0.13012065f, 
    0.18470544f, 0.05878744f, -0.40144029f, -0.19508961f, -0.05620653f, -0.19199067f, 0.02768992f, -0.12004603f, 
    0.20067351f, 0.09176950f, 0.34631804f, 0.04914361f, -0.00506707f, -0.05605492f, -0.38528568f, -0.02964390f, 
    -0.11415259f, 0.19856286f, 0.03544054f, 0.02426868f, -0.00340932f, 0.04158248f, 0.04815263f, 0.09266274f, 
    -0.08809447f, -0.02331655f, -0.30799672f, -0.06437276f, -0.36258498f, -0.03325254f, -0.13637406f, 0.18985885f, 
    -0.04453846f, -0.20240848f, 0.09029204f, 0.05804225f, 0.03609409f, -0.08847986f, -0.10668018f, 0.22050194f, 
    -0.09803660f, 0.39435050f, -0.01839654f, 0.20553529f, 0.38829005f, -0.49475464f, 0.37336650f, -0.03582994f, 
    -0.13193269f, -0.23941796f, 0.09295290f, -0.08665338f, -0.12333512f, -0.08730172f, -0.03574261f, 0.42712456f, 
    0.16828646f, 0.08140206f, -0.10517696f, -0.45408168f, -0.40305352f, -0.08439567f, 0.02770362f, -0.28292665f, 
    0.24452922f, 0.08783548f, 0.10909820f, -0.41463307f, 0.07550900f, 0.08414671f, -0.06996451f, 0.18386112f, 
    -0.47676903f, -0.07273439f, -0.26372093f, -0.00353426f, 0.08373652f, -0.39956915f, 0.02087320f, 0.10590434f, 
    0.00808636f, 0.21331076f, -0.11332376f, 0.31352079f, 0.03724948f, -0.11267022f, -0.05072295f, 0.06896553f, 
    -0.06753697f, 0.09209017f, -0.16803078f, 0.02870771f, 0.31237057f, 0.02024764f, -0.46540868f, -0.42974016f, 
    0.09147499f, 0.28013584f, 0.03066716f, 0.08474834f, 0.05544311f, 0.11344667f, -0.08709755f, 0.01072662f, 
    0.03281660f, 0.18950455f, 0.26934972f, 0.21867537f, -0.05434423f, -0.14105526f, 0.05256016f, -0.01450738f, 
    -0.39479843f, 0.00966919f, -0.13063841f, 0.01017426f, -0.23985919f, -0.26035997f, -0.01960997f, -0.41638446f, 
    -0.23991765f, -0.08277681f, 0.01898061f, -0.34438822f, 0.00644867f, -0.13391863f, 0.06151768f, 0.40139040f, 
    0.24184412f, 0.03177220f, -0.50410450f, 0.12208019f, -0.43733498f, -0.67722541f, 0.11158889f, -0.24380346f, 
    -0.43988466f, -0.07494878f, 0.28075436f, -0.08050877f, -0.01612836f, -0.13609894f, 0.18673351f, -0.15142548f, 
    -0.01111648f, -0.44543394f, 0.00646393f, 0.29643318f, 0.02584415f, 0.23375551f, 0.12998433f, 0.09907531f, 
    0.09316795f, -0.38473648f, -0.07415412f, -0.11243346f, 0.27484897f, -0.09502144f, -0.26973033f, 0.10289750f, 
    -0.10135817f, -0.18259969f, 0.05466046f, -0.02927568f, 0.08253430f, -0.24744545f, -0.04742647f, 0.08903518f, 
    -0.04449539f, -0.24577425f, -0.25086358f, 0.11175767f, -0.37425497f, 0.26701665f, -0.24909852f, -0.09087159f, 
    0.14734408f, 0.28578901f, 0.11130622f, -0.01691790f, 0.00199422f, 0.15031728f, -0.10953525f, 0.07086019f, 
    0.32364741f, -0.06859092f, -0.49174285f, 0.13855484f, 0.05174815f, -0.01833723f, -0.11509694f, 0.21912491f, 
    0.15891817f, 0.23580121f, -0.35144797f, -0.22895023f, 0.20321290f, 0.17045969f, 0.01205477f, -0.34610650f, 
    0.15576965f, -0.08711428f, -0.14151196f, -0.05148435f, -0.50848120f, 0.14464894f, -0.49472526f, 0.08884867f, 
    0.11093121f, 0.17620763f, -0.04084906f, -0.21024390f, -0.07612695f, 0.24131507f, 0.22340621f, -0.06127914f, 
    0.10980271f, -0.10438970f, 0.17666654f, 0.06314331f, -0.03803632f, -0.02313022f, 0.18968655f, -0.18727741f, 
    -0.13229236f, -0.29968393f, 0.02114098f, 0.05467065f, -0.09630819f, -0.14361377f, 0.07042636f, 0.09476953f, 
    -0.07223775f, -0.12183376f, 0.04508072f, 0.02288100f, -0.41491663f, -0.01413915f, 0.36180526f, 0.11581019f, 
    0.11676349f, -0.16875295f, 0.09965788f, 0.10337047f, 0.09286457f, -0.50001842f, -0.02137912f, -0.10516762f, 
    -0.27359650f, 0.03852607f, -0.10306091f, -0.00514849f, 0.38343507f, 0.10779489f, -0.07976934f, 0.30925390f, 
    -0.44428214f, -0.01044075f, 0.18026419f, 0.02933938f, 0.10089196f, 0.13478126f, -0.02037759f, 0.37682980f, 
    0.23799470f, 0.09857185f, 0.20382573f, 0.08939117f, -0.05950144f, -0.26758930f, -0.13119502f, -0.57890570f, 
    0.05337287f, 0.22820336f, -0.10224105f, 0.17922731f, -0.03308530f, 0.18925670f, 0.45147818f, 0.11168419f, 
    0.10428517f, 0.20920798f, -0.62836963f, 0.10468747f, 0.13946846f, 0.06403749f, 0.27648377f, -0.60596532f, 
    -0.11818637f, -0.02724077f, 0.00997932f, 0.07226942f, 0.06817453f, -0.27579948f, 0.09041966f, -0.26289880f, 
    0.08080982f, -0.22766989f, -0.52645916f, -0.19273762f, -0.00963793f, -0.40288916f, 0.22462752f, 0.00047513f, 
    0.33802134f, 0.01943578f, 0.09155995f, -0.07086168f, -0.03553160f, 0.25776812f, 0.10825824f, -0.01551998f, 
    -0.19356199f, 0.10015969f, 0.08537836f, 0.25519407f, -0.45734563f, 0.11291430f, -0.02780861f, 0.30100328f, 
    0.13279182f, 0.10512569f, -0.26987451f, 0.38693824f, -0.13491067f, -0.33217779f, -0.01681223f, 0.27522698f, 
    0.17243421f, 0.10338669f, 0.13577728f, 0.08330584f, 0.20918098f, -0.01291245f, 0.32946065f, 0.20171265f, 
    -0.04408045f, 0.23206034f, 0.02988902f, -0.14698042f, 0.02263651f, -0.68394172f, -0.24188031f, -0.04688388f, 
    -0.04659650f, 0.09985942f, 0.00346395f, 0.03818917f, 0.06749515f, 0.05467802f, 0.15707442f, 0.06774326f, 
    -0.11939261f, 0.23956029f, 0.09824257f, -0.03880375f, 0.01076677f, -0.50964421f, -0.01981675f, 0.21141692f, 
    0.09584973f, -0.02361193f, 0.19640869f, -0.42603695f, -0.45504284f, -0.37288290f, -0.29836488f, 0.03681669f, 
    -0.10900549f, 0.06634321f, -0.01920371f, 0.01281195f, -0.05967954f, 0.16497883f, -0.12453016f, 0.26834127f, 
    -0.24064957f, 0.04160946f, -0.10148645f, -0.17300570f, -0.12726152f, -0.04099916f, 0.05515455f, -0.32611132f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03627346f, -0.02787644f, -0.06359295f, -0.01605414f, 0.13288632f, 0.19117336f, -0.03542150f, -0.00253440f, 
    0.10978806f, -0.05357366f, 0.18000208f, 0.06171217f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
