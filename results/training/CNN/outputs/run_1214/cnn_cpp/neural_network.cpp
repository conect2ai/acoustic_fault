#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.49968132f, 0.82310182f, 0.22092718f, -0.25621644f, -0.16336992f, -0.04916450f, 0.04223813f, 0.31115440f, 
    0.18394020f, -0.38419631f, -0.22542560f, -0.03468860f, -0.13436323f, -0.14083941f, 0.17216450f, 0.02837196f, 
    0.11070194f, 0.03826172f, 0.08381395f, -0.43956608f, -0.08129510f, -0.01342733f, -0.47360960f, -0.34731770f, 
    -0.49187934f, -1.14363551f, -0.39808235f, -0.40370336f, 0.01902419f, -0.45017296f, 1.00119555f, -0.04511832f, 
    -0.03367046f, 0.53702980f, 0.42963046f, 0.01333184f, -0.14293727f, 0.10098522f, 0.42483705f, -0.35419390f, 
    -0.22621500f, -0.00753685f, -0.01542394f, -0.17285201f, -0.04243778f, 0.02588703f, 0.24775866f, 0.18829370f, 
    0.07703858f, -0.17729227f, -1.12480736f, -0.29790917f, -0.56946170f, -0.81123906f, -0.19440459f, 0.29201859f, 
    0.35535005f, 0.18671234f, 0.48810583f, 0.46008909f, -0.24894103f, -0.38847363f, -0.23972668f, -0.29283527f, 
    0.02699387f, 0.19295743f, 0.13749528f, -0.30509627f, -0.01996264f, -0.10909714f, -0.19151394f, -0.37323898f, 
    -0.07645074f, -0.30638921f, -0.48797542f, 0.65479171f, 0.48723987f, -0.35840985f, 0.33051476f, -0.82107401f, 
    0.21684462f, -0.54137850f, -0.44429225f, -0.34502938f, -0.13995157f, 0.57617420f, -0.19289701f, -0.09607638f, 
    0.06178269f, -0.19672348f, 0.18812153f, 0.39643228f, 0.52771759f, -0.29050839f, -0.42736778f, -0.39991662f, 
    -0.00493081f, 0.15701543f, 0.22264095f, 0.32014897f, 0.61591452f, 0.23970327f, 0.69555700f, -0.18654594f, 
    0.12252419f, -0.62893981f, 0.07824323f, 0.48659283f, -0.56589669f, -0.54463166f, -0.35691530f, 0.02253078f, 
    0.18420908f, -0.21639845f, 0.01359961f, 0.07829119f, -0.00392846f, -0.04188383f, 0.11540103f, -0.10935982f, 
    -0.13282202f, -0.01897195f, -0.02230637f, -0.01498765f, 0.16905792f, -0.40965798f, 0.15489855f, 0.30847648f, 
    0.46866903f, 0.34990573f, 0.41082588f, 0.29766095f, 0.32354555f, -0.21368879f, 0.12866388f, 0.30463436f, 
    0.21855472f, 0.26779377f, -0.56572324f, -0.24877512f, 0.07997447f, -0.13698119f, -0.06536307f, -0.01441188f, 
    0.17290798f, 0.07629294f, -0.09119029f, -0.01858364f, -0.14899787f, 0.07132248f, 0.12482615f, 0.52892095f, 
    -0.09900534f, -0.33905673f, 0.17204991f, -0.43231815f, -0.18537340f, 0.10046608f, -0.09909487f, -0.14257403f, 
    0.27672681f, -0.23839067f, -0.20133968f, 0.24445407f, 0.07817141f, 0.27087200f, -0.18250091f, 0.04146501f, 
    -0.20378351f, -0.50659418f, 0.04876231f, 0.23308668f, -0.10462806f, 0.36577570f, 0.47336698f, -0.95910555f, 
    0.29451808f, -0.32610476f, -1.06814945f, -0.41060352f, -0.29950121f, 0.14596206f, 0.63397014f, 0.66901016f, 
    0.14744255f, -0.16927736f, -0.40955424f, -0.17356548f, -0.72627741f, 0.01484818f, 0.05750040f, 0.19313686f, 
    0.21748666f, 0.24873222f, 0.08002265f, -0.06560902f, 0.38684803f, -0.19289039f, -0.09497171f, 0.38240513f, 
    0.63574910f, 0.65400320f, -0.02936106f, 0.25421596f, -0.99123502f, -0.04839325f, -0.31462899f, -0.45637873f, 
    0.19707936f, -0.13184375f, 0.20084070f, -0.30443072f, 0.17401791f, 0.31097862f, 0.17573109f, -0.23381278f, 
    -0.04276981f, -0.30465719f, 0.03040351f, 0.21939898f, 0.14862968f, 0.23032986f, 0.06049274f, -0.13237897f, 
    -0.07024562f, -0.11491686f, -0.15393718f, -0.42807311f, -0.56426001f, 0.07550240f, -0.40403253f, -0.44221494f, 
    -0.75841814f, -0.62583154f, -0.98254740f, 0.37925193f, 0.89913774f, 0.01418786f, -0.23143896f, -0.25439608f, 
    0.00124457f, -0.43336245f, -0.19688506f, -0.14472844f, -0.04269861f, 0.02331327f, -0.17660359f, -0.30846637f, 
    0.11763012f, -0.28606185f, -0.72469360f, -0.65568411f, -0.47812212f, -0.19961178f, -0.06977874f, -0.23225608f, 
    -0.28974918f, -0.39271447f, 0.32670739f, -0.63662088f, -0.22600009f, 0.15238196f, 0.32537428f, 0.19236672f, 
    -0.44807151f, -0.26631168f, -0.47924852f, -0.15497568f, -0.15996158f, -0.25989440f, 0.17690964f, 0.24923305f, 
    0.14906435f, 0.21620810f, 0.29233554f, -1.10172987f, -0.94264007f, -0.57771039f, 0.57928348f, 0.96737498f, 
    0.42966285f, -0.12937093f, -0.46638915f, -0.16507916f, 0.22856437f, 0.36199823f, 0.18701504f, -0.26173103f, 
    0.14012022f, -0.27640688f, 0.32458130f, -0.17537403f, 0.03799566f, 0.22661807f, -0.07924289f, -0.13715370f, 
    -0.00257726f, -0.20622213f, -0.29188105f, -0.17032887f, -0.49175522f, -0.01318320f, -0.16198225f, 0.53516722f, 
    0.45846727f, -0.24591987f, -0.44389412f, 0.13535354f, 0.42424658f, 0.53521657f, 0.09688755f, 0.42933729f, 
    -0.43902075f, 0.06363823f, -0.28839111f, -0.34031183f, 0.24273716f, 0.22759323f, -0.40177912f, 0.06099166f, 
    -0.18372466f, 0.06723770f, 0.09379604f, 0.21281807f, -0.15879346f, 0.39052075f, -0.93391210f, -0.07611011f, 
    -0.15240733f, 0.16895074f, 0.11687890f, 0.15242653f, 0.26955193f, 0.54588830f, 0.15662482f, 0.26361203f, 
    0.13853936f, 0.34671515f, -0.18230584f, 0.18097447f, 0.07182086f, -0.37538889f, -0.19452965f, 0.16519953f, 
    -0.23209848f, -0.10028476f, -0.18732041f, 0.29649320f, 0.03066432f, 0.07329461f, -0.42919573f, 0.04388534f, 
    -0.17876863f, 0.14094551f, 0.69621402f, -0.00112028f, -0.40142319f, -0.38332623f, 0.06974637f, 0.29709888f, 
    0.09700594f, -0.16122417f, 0.09551767f, 0.22911519f, 0.11645579f, -0.35056347f, 0.31792927f, -0.02741969f, 
    -0.00647354f, 0.06012130f, 0.19485511f, 0.22848307f, 0.15655318f, 0.46208066f, 0.39407036f, 0.00576637f, 
    0.51758468f, 0.45589888f, 0.19001496f, 0.22245908f, -0.81408650f, -0.68728834f, 0.05566374f, -0.06458805f, 
    0.00233442f, -0.24193688f, -0.33732900f, -0.08485135f, 0.47106105f, -0.28559017f, 0.09187460f, 0.04061237f, 
    0.27735537f, 0.21790384f, -0.14092696f, -0.20384456f, -0.15273455f, -0.15889989f, -0.07376978f, 0.14228474f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.32942760f, 0.39137065f, 0.08566418f, 0.27756542f, 0.22322424f, 0.30889580f, 0.16559935f, -0.12753884f, 
    0.37446854f, 0.12737316f, 0.18753861f, 0.24437167f, 0.28754950f, 0.01019618f, 0.28454128f, 0.18281929f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01889477f, -0.08055174f, 0.02274125f, -0.05329926f, -0.05606345f, -0.06922353f, -0.06111846f, -0.02741183f, 
    -0.04568446f, -0.02708820f, -0.02254991f, -0.04036723f, -0.05980939f, 0.04155759f, -0.00001704f, -0.00707684f, 
    -0.05192915f, -0.03308658f, -0.05960744f, -0.02330783f, -0.06812682f, 0.04827212f, -0.03815614f, -0.07543248f, 
    -0.06376388f, 0.02943688f, 0.00901505f, 0.00307404f, 0.04378499f, 0.00419773f, -0.00370137f, -0.07267490f, 
    0.02066132f, -0.00401428f, -0.01888827f, -0.06975312f, 0.05905615f, 0.04543487f, 0.05363223f, -0.05222426f, 
    -0.04202065f, -0.06135979f, -0.04995582f, 0.05279560f, 0.01118582f, 0.04830164f, 0.05720281f, -0.05033036f, 
    0.00502353f, 0.02906555f, 0.01106706f, 0.05157638f, 0.03980984f, 0.04274300f, 0.03576729f, -0.03134705f, 
    0.06005444f, -0.01204841f, -0.02837050f, 0.02207903f, 0.00054025f, 0.04634448f, -0.01286418f, -0.07356060f, 
    -0.07640360f, 0.04142394f, 0.05958492f, -0.02133340f, 0.03281369f, 0.06123951f, -0.03975872f, -0.01995179f, 
    -0.07319677f, -0.05917723f, -0.00728763f, -0.05805196f, 0.00492729f, -0.05700688f, 0.00683666f, 0.04375219f, 
    -0.00481214f, -0.07121797f, -0.06575152f, -0.03663569f, 0.04104424f, -0.07021536f, -0.00833330f, -0.03151131f, 
    -0.06134673f, -0.01492207f, -0.00937555f, -0.03859001f, -0.07072586f, -0.03892867f, 0.04114132f, 0.00497809f, 
    0.02889874f, 0.05930371f, -0.06973793f, -0.03666594f, 0.03685297f, 0.04932761f, -0.06746630f, -0.02170360f, 
    0.04110226f, 0.01461990f, -0.07708186f, -0.00787449f, -0.05426801f, -0.01628927f, 0.05345524f, -0.00052816f, 
    0.03345034f, 0.06164419f, -0.00047877f, 0.03635472f, 0.01429552f, -0.03303782f, -0.06621706f, -0.00890888f, 
    -0.07344899f, 0.00124682f, -0.04132947f, -0.04823686f, -0.07140825f, -0.06025672f, -0.01352844f, -0.06177542f, 
    -0.05342109f, -0.06529827f, -0.07202788f, -0.01818832f, 0.05804680f, -0.01500402f, -0.06989805f, 0.03563097f, 
    -0.03025211f, 0.04087112f, -0.06953554f, -0.01196909f, -0.00849363f, -0.02036652f, 0.05712070f, 0.03655019f, 
    0.01139454f, -0.05883202f, 0.03876304f, -0.04318241f, 0.02803481f, 0.02776649f, 0.00636969f, -0.01106614f, 
    0.01988397f, 0.03285537f, -0.04439513f, -0.05868370f, -0.02606701f, -0.03895815f, -0.06497601f, -0.01601629f, 
    0.01437068f, -0.04339736f, 0.01858306f, -0.03351055f, -0.05420822f, 0.02331120f, 0.01311351f, -0.02543680f, 
    -0.07039038f, 0.05885896f, -0.04064071f, -0.06926106f, -0.04008611f, -0.04809805f, -0.05573223f, -0.04118181f, 
    -0.05427910f, 0.04595129f, -0.07278974f, 0.05611645f, 0.02310511f, -0.06959656f, -0.00923043f, 0.06384692f, 
    0.05236432f, 0.02806010f, -0.02249784f, -0.01014941f, -0.00545336f, -0.00471648f, -0.07435846f, 0.04650800f, 
    -0.05393324f, 0.12805216f, -0.18601143f, -0.15975998f, -0.14323935f, 0.03294826f, 0.15621573f, 0.09453516f, 
    0.32087430f, 0.19666594f, 0.09477150f, -0.14103678f, -0.09206551f, -0.17506225f, 0.16612338f, 0.01934303f, 
    0.15283453f, 0.06424043f, 0.01568495f, 0.10428341f, 0.04177050f, 0.08709398f, -0.01830106f, 0.06155538f, 
    -0.05437449f, -0.23987314f, 0.05104763f, 0.06671481f, -0.04590407f, 0.03947549f, 0.05080469f, 0.26156950f, 
    0.08419247f, -0.05734158f, 0.14624040f, 0.11574390f, 0.15311964f, -0.12858257f, 0.03351945f, 0.17938364f, 
    0.07426003f, 0.22622196f, 0.16207674f, 0.13748799f, -0.01958512f, -0.16522042f, 0.03466226f, -0.15187398f, 
    -0.34729075f, 0.09431182f, -0.17492506f, 0.06867068f, 0.29551223f, -0.03184933f, -0.05452534f, 0.07316346f, 
    -0.00336098f, -0.03378456f, -0.03269633f, 0.03436987f, -0.03582866f, -0.01248131f, -0.09933541f, -0.20174335f, 
    0.00645326f, -0.26023206f, 0.02146792f, 0.03930058f, 0.23188604f, -0.00163300f, 0.04186711f, -0.10350934f, 
    0.06410090f, -0.11087468f, -0.20421177f, -0.06142147f, 0.02015803f, -0.13123375f, -0.03241381f, 0.06469286f, 
    -0.09364651f, -0.15054592f, 0.04776781f, -0.08820601f, 0.21282621f, -0.33281636f, -0.17435917f, 0.43219933f, 
    0.00965064f, -0.08725110f, 0.18557061f, 0.21471867f, -0.12534964f, -0.19192109f, 0.06329454f, 0.05109175f, 
    0.14336406f, 0.36924368f, 0.06274143f, 0.23153828f, 0.08083533f, 0.16263171f, 0.01108192f, 0.00837451f, 
    -0.09661452f, -0.08568733f, -0.02121136f, -0.03136434f, -0.30802244f, 0.10252310f, 0.38386521f, 0.16517666f, 
    0.21693364f, 0.16598442f, 0.22992058f, -0.07647833f, -0.04143248f, -0.09711178f, 0.10888592f, -0.01289989f, 
    -0.00501082f, -0.17593093f, 0.12876472f, 0.09867241f, -0.03112949f, 0.05327774f, -0.02280505f, -0.20247975f, 
    0.01211813f, 0.18224093f, 0.01432881f, 0.01869831f, -0.23975773f, -0.12640017f, 0.30379096f, -0.29088101f, 
    0.14751440f, 0.29940000f, -0.22213227f, 0.12308148f, 0.05005516f, 0.00376431f, 0.08802443f, -0.00224662f, 
    0.38088331f, -0.09314154f, -0.07105605f, -0.24565545f, -0.10235991f, -0.10973217f, 0.04677562f, 0.08282818f, 
    0.05171631f, 0.04526525f, 0.23051709f, 0.09280333f, -0.10319087f, 0.03526394f, 0.04450040f, -0.07645450f, 
    -0.06170035f, -0.11632766f, -0.07459226f, 0.21860392f, 0.18022548f, 0.06209827f, 0.16230947f, -0.07081892f, 
    -0.01240883f, -0.37484890f, 0.06406741f, -0.13988985f, -0.14423388f, 0.00264982f, -0.11299478f, 0.08223850f, 
    0.00657449f, 0.13753030f, -0.02201886f, -0.10554632f, -0.03295210f, -0.29100507f, -0.23167174f, 0.15684158f, 
    -0.08808134f, 0.19716099f, -0.01672011f, 0.08503207f, 0.03101499f, 0.07339963f, 0.15103300f, -0.02801027f, 
    0.20102467f, 0.02957294f, 0.03022741f, 0.01980253f, -0.05706277f, 0.01709928f, 0.11397284f, 0.11996961f, 
    0.11225112f, 0.15505809f, 0.00700829f, -0.14433949f, -0.69456095f, -0.30432397f, 0.22222424f, -0.03283072f, 
    0.10716861f, 0.06363515f, -0.12094007f, -0.07540607f, 0.09049617f, 0.11173227f, 0.01536048f, 0.10560162f, 
    -0.12753746f, 0.03599516f, 0.09597689f, -0.05825714f, -0.01978716f, 0.04862826f, 0.11225402f, 0.01334174f, 
    -0.02759775f, -0.04885077f, 0.19851889f, 0.08737568f, 0.24455769f, -0.04694814f, -0.25564012f, 0.06924351f, 
    0.04345284f, 0.21015052f, 0.21826650f, 0.04848070f, 0.09413939f, -0.08814083f, 0.02691646f, -0.16878967f, 
    -0.14240482f, -0.25395074f, 0.19385339f, 0.12377600f, 0.12396127f, 0.15319645f, 0.07870609f, 0.04504127f, 
    -0.04620510f, 0.00113103f, -0.07114556f, -0.00672550f, -0.02567281f, -0.03677133f, -0.02667731f, 0.01956335f, 
    0.10088206f, -0.18146461f, -0.01252128f, -0.07657808f, 0.08411393f, -0.19276956f, 0.04718971f, -0.15669791f, 
    0.21069081f, -0.17612484f, -0.06059337f, -0.19302651f, 0.07746392f, -0.04171307f, 0.04608832f, 0.02979683f, 
    0.05782235f, 0.01386292f, 0.02934653f, -0.02347339f, 0.09672026f, -0.27646449f, -0.10713214f, 0.26919097f, 
    0.03497094f, -0.07991266f, 0.10383507f, 0.17148578f, 0.00263091f, -0.01188311f, 0.23866935f, 0.20542741f, 
    0.40918812f, -0.14792863f, -0.00350340f, 0.29598480f, 0.10996076f, 0.22060786f, 0.35938254f, -0.05747745f, 
    0.03596669f, -0.12806360f, -0.07120480f, 0.11124270f, -0.24424426f, 0.00404759f, 0.25721073f, 0.01427252f, 
    0.14528753f, 0.17886227f, 0.14204042f, -0.09506292f, 0.02818825f, 0.02475489f, 0.10493618f, -0.00173418f, 
    -0.01754135f, -0.07503031f, 0.15170825f, -0.03198633f, 0.08953519f, 0.02844616f, -0.00257286f, -0.21307068f, 
    0.08251701f, 0.15585916f, -0.01894334f, 0.12556417f, -0.56488675f, 0.08428019f, 0.28918961f, -0.28936711f, 
    0.13622493f, -0.14331172f, 0.00255084f, 0.14213131f, -0.05615761f, 0.15200244f, 0.18723585f, -0.09012350f, 
    0.05482099f, -0.00869204f, 0.04470452f, 0.35922647f, 0.08389866f, -0.10863128f, -0.09213886f, 0.13883828f, 
    0.05589036f, 0.10236089f, 0.25106838f, -0.09012459f, -0.12020077f, 0.09977441f, -0.00378102f, 0.08364686f, 
    -0.02559144f, -0.07665928f, -0.13722274f, 0.08027593f, 0.09375042f, 0.06917854f, 0.05534804f, -0.10382111f, 
    -0.10619708f, -0.11773130f, -0.08807693f, -0.01540125f, -0.07326035f, 0.14261666f, -0.11484363f, 0.05014978f, 
    0.09083649f, 0.01726833f, -0.03803092f, 0.04062024f, 0.05100882f, -0.21284254f, 0.03115687f, 0.28283554f, 
    0.05526512f, 0.09179587f, 0.09224322f, 0.15114979f, -0.09753054f, 0.12474342f, -0.01942955f, 0.03214557f, 
    -0.28681234f, 0.00130748f, -0.18694159f, -0.01482643f, 0.00548482f, 0.13196996f, -0.09633648f, 0.06012086f, 
    0.27672994f, 0.24387829f, 0.07976466f, -0.09790543f, 0.08513786f, -0.40571904f, 0.14046931f, 0.06243479f, 
    0.09753563f, 0.13642228f, -0.21375936f, 0.03653732f, 0.10040913f, -0.07909956f, -0.09798425f, -0.00209855f, 
    -0.06651800f, -0.11319562f, 0.21109688f, 0.01133943f, 0.06506958f, 0.19535176f, 0.21894109f, 0.27393028f, 
    0.07362761f, -0.07461371f, 0.09523638f, 0.31415597f, 0.02711482f, 0.00867606f, 0.18148249f, -0.01787695f, 
    -0.07236907f, 0.17084764f, -0.08337082f, 0.02929692f, -0.20143804f, -0.00258408f, 0.24314816f, -0.18371575f, 
    -0.23939922f, 0.18389590f, 0.05641256f, 0.09609128f, 0.27464482f, -0.07466333f, -0.19014479f, -0.08426239f, 
    0.01543980f, -0.05434772f, -0.04705539f, -0.13631260f, -0.14328784f, 0.20603411f, -0.19171944f, -0.17969935f, 
    0.08431748f, -0.11623342f, -0.11777107f, 0.09875826f, 0.06875916f, 0.05226823f, 0.24644415f, -0.00402451f, 
    -0.02963482f, -0.07209485f, -0.06984764f, 0.12791583f, 0.12532316f, -0.08640098f, -0.10043085f, -0.15140271f, 
    -0.07777678f, -0.13628970f, -0.05351806f, -0.04138576f, 0.37023005f, 0.01513990f, -0.04541770f, 0.03755324f, 
    0.08988900f, 0.00996800f, 0.05428375f, 0.16712926f, -0.15668567f, -0.13976511f, 0.19223520f, 0.23521370f, 
    -0.20564863f, 0.13354194f, 0.08741853f, -0.07226930f, -0.09488491f, 0.19548683f, 0.00138085f, -0.02908099f, 
    0.11360934f, -0.10257522f, -0.13343912f, -0.16456856f, -0.03829861f, 0.30801609f, -0.04320634f, -0.15942186f, 
    0.11726194f, 0.05708079f, 0.15891674f, 0.10260478f, 0.01306022f, -0.03683428f, 0.05838691f, -0.11595855f, 
    0.24259564f, 0.02993111f, -0.04595565f, -0.08444642f, 0.22978680f, 0.06949595f, -0.01149159f, -0.07022804f, 
    0.09398431f, -0.01273623f, -0.05983292f, 0.00977661f, 0.26943684f, -0.11550611f, 0.32019687f, -0.10471458f, 
    0.05375023f, 0.04180600f, -0.18039180f, 0.12997644f, 0.13807799f, -0.03734477f, 0.06549930f, 0.10632506f, 
    0.39511216f, -0.32978389f, -0.03383697f, -0.10513575f, -0.00808299f, -0.03517146f, 0.02643386f, 0.17425133f, 
    0.03042615f, 0.02756808f, 0.02989445f, -0.03138605f, 0.16090736f, -0.21235180f, -0.05979050f, -0.15323150f, 
    0.15362404f, -0.20671557f, 0.13998196f, -0.20762247f, -0.04089703f, 0.07289707f, 0.09824701f, -0.00309190f, 
    0.02028983f, -0.14256062f, 0.37297383f, -0.08125116f, -0.04591526f, 0.01776327f, -0.08709325f, 0.08098833f, 
    0.07670440f, -0.12166235f, -0.29980361f, -0.25563487f, 0.09707256f, 0.00085630f, 0.17455789f, 0.19608843f, 
    -0.07368183f, -0.01537295f, -0.12208699f, 0.01971742f, -0.00209616f, -0.06518457f, 0.05622135f, -0.08327150f, 
    0.00251016f, 0.22655824f, 0.15987715f, -0.05439576f, -0.08545625f, 0.01601380f, -0.03847564f, 0.12467333f, 
    0.05285777f, 0.20001626f, -0.06665886f, -0.04026719f, 0.06757438f, -0.16368970f, 0.20553184f, 0.30637479f, 
    0.10154319f, -0.08836442f, 0.03171045f, 0.05941622f, -0.03657477f, 0.06637611f, -0.00867365f, 0.04911357f, 
    0.26270959f, -0.22449204f, 0.06207016f, 0.16778204f, 0.06846639f, -0.09200361f, 0.18203695f, 0.10310787f, 
    0.05641863f, 0.18085276f, 0.12738116f, 0.16192380f, -0.56234390f, -0.19151169f, 0.34091169f, 0.57688648f, 
    -0.04426902f, -0.04483211f, 0.29557675f, 0.05824092f, -0.01530424f, 0.05503631f, 0.05900449f, 0.06152068f, 
    -0.24253789f, 0.21780509f, 0.17315082f, 0.08104308f, -0.13988531f, 0.00553158f, -0.03520522f, 0.09000973f, 
    -0.09893656f, 0.03108066f, 0.03152313f, 0.04823425f, -0.13573514f, 0.06143891f, -0.08108043f, -0.35327020f, 
    -0.18174855f, -0.05819146f, 0.03431151f, 0.03978020f, -0.03480083f, -0.04243521f, -0.04987466f, -0.22104830f, 
    -0.02852827f, -0.11821622f, 0.00155544f, -0.03806692f, 0.08304422f, -0.03670542f, 0.15972313f, 0.02007288f, 
    -0.04553276f, -0.01508362f, 0.00406080f, -0.05708670f, 0.47508919f, -0.16643809f, -0.08229665f, 0.11481176f, 
    0.05011379f, 0.04098782f, 0.07558580f, 0.20841801f, -0.02554021f, -0.04258857f, 0.06236957f, 0.10816107f, 
    -0.47611722f, 0.05916063f, 0.37717748f, -0.09695429f, 0.09088889f, 0.02757866f, -0.04810481f, 0.01069611f, 
    -0.01377917f, -0.04057335f, 0.00184466f, -0.01701258f, -0.31073907f, -0.29985967f, 0.06533568f, 0.09129497f, 
    -0.05654756f, 0.00610616f, 0.18709546f, 0.13898554f, 0.11754756f, -0.01457275f, 0.14471783f, 0.00920437f, 
    -0.12292841f, -0.32229057f, -0.25326619f, 0.05957936f, 0.02041787f, -0.10053333f, 0.01986919f, 0.08151148f, 
    0.01470969f, 0.11297914f, 0.01145250f, 0.01704336f, -0.05607624f, -0.00201109f, -0.38617644f, 0.01129020f, 
    0.13143212f, 0.10192890f, -0.23689422f, 0.13389637f, 0.08172764f, 0.07796425f, 0.06434429f, -0.00102841f, 
    0.44609907f, 0.03114681f, -0.10267821f, -0.23891975f, -0.01082663f, 0.08728651f, 0.10149451f, -0.01165131f, 
    0.06367630f, 0.05917889f, 0.10779037f, 0.05312629f, -0.14293818f, -0.13395403f, -0.07038211f, -0.19665498f, 
    -0.06097732f, -0.05375443f, -0.01831901f, -0.07719805f, -0.06488920f, 0.11651665f, 0.15074997f, -0.12683329f, 
    0.02188452f, -0.06051189f, -0.18127488f, -0.20350352f, 0.01731804f, 0.07211144f, -0.06888851f, -0.16303919f, 
    0.04324887f, -0.00762576f, 0.02667950f, 0.09870102f, 0.30587858f, -0.01083440f, 0.00525293f, -0.11573645f, 
    -0.14643204f, 0.02768826f, 0.13334820f, 0.08182143f, -0.04471044f, 0.03538096f, 0.07656121f, -0.02854816f, 
    -0.00422326f, -0.06951655f, 0.02652317f, 0.05556007f, -0.02770750f, -0.04625110f, -0.07105405f, -0.04340011f, 
    0.00142659f, -0.04302699f, -0.00030382f, -0.05608135f, 0.01436193f, 0.06017774f, -0.03552693f, -0.05829937f, 
    -0.00830382f, 0.06746008f, 0.01438100f, -0.01105349f, -0.01655406f, -0.06178797f, -0.05174251f, 0.01690883f, 
    0.00920825f, 0.03734219f, -0.06407185f, -0.03040971f, 0.03215311f, -0.05082035f, -0.00775377f, 0.00725886f, 
    0.00486215f, -0.00623099f, 0.06125119f, 0.00661837f, 0.00014862f, -0.03345565f, 0.03618658f, -0.03970009f, 
    -0.02434436f, -0.07159020f, -0.05647668f, -0.06404670f, -0.01069559f, -0.02810158f, 0.00863259f, -0.04390075f, 
    -0.03123130f, -0.03666686f, -0.01123217f, 0.05944936f, 0.00107437f, -0.02511663f, 0.03762130f, -0.01064918f, 
    0.05391520f, 0.04971878f, -0.00073383f, -0.01054803f, 0.03206649f, -0.07965298f, -0.07018567f, -0.07719436f, 
    -0.05233573f, -0.02622484f, 0.07370082f, 0.02535752f, -0.00109560f, 0.06698897f, -0.03096583f, -0.04021962f, 
    -0.00419405f, 0.06947885f, -0.04877291f, -0.04391921f, -0.04254331f, -0.03849556f, -0.04723111f, -0.03286654f, 
    -0.05080274f, -0.03158859f, 0.00821869f, -0.05553743f, 0.04559840f, -0.00117039f, -0.01326248f, 0.05164501f, 
    -0.03412416f, -0.00029903f, 0.03142060f, 0.02821679f, 0.06218604f, -0.03345559f, -0.02960096f, -0.01747741f, 
    -0.05354039f, -0.05355886f, -0.08009356f, -0.00859005f, -0.02155659f, -0.06383102f, 0.07184175f, 0.01257526f, 
    0.02293106f, -0.00009057f, -0.06198972f, 0.04338859f, -0.01882264f, -0.03877774f, 0.05927076f, -0.01500915f, 
    -0.06498192f, 0.01891370f, 0.01852873f, -0.01471548f, -0.01978944f, 0.05174788f, 0.05326850f, 0.00347416f, 
    0.02575304f, -0.02238973f, -0.03557045f, -0.04175075f, -0.02682254f, -0.03355670f, -0.05032013f, 0.03381298f, 
    -0.00579076f, 0.02611939f, -0.03183535f, -0.04518150f, 0.02132175f, 0.04782290f, -0.05912677f, -0.07426114f, 
    -0.08973509f, 0.01427546f, 0.03307784f, 0.01307631f, -0.02966735f, 0.03257454f, 0.05112213f, -0.06420808f, 
    -0.03748185f, -0.01221227f, -0.07115741f, 0.05057835f, 0.04389903f, 0.01283167f, 0.04467100f, -0.02947797f, 
    -0.00606207f, -0.05325168f, -0.01670873f, -0.05414558f, -0.01015726f, -0.06077743f, 0.00522009f, -0.01991704f, 
    -0.08243679f, -0.03123485f, -0.06375378f, 0.07297987f, 0.04578858f, 0.05349377f, 0.04376843f, 0.01859657f, 
    0.03445081f, 0.03568636f, -0.02092082f, 0.00319378f, 0.02785272f, -0.02295680f, 0.05108917f, -0.01869493f, 
    -0.02784099f, 0.04806761f, 0.04192009f, 0.01259187f, -0.05872807f, 0.00501320f, -0.02026126f, 0.03627025f, 
    0.03308949f, -0.05332742f, -0.01103967f, -0.01094254f, -0.04094440f, 0.04574800f, 0.02829430f, -0.00876819f, 
    -0.01980058f, 0.10798239f, 0.20693877f, 0.04074056f, -0.12188279f, -0.01986649f, -0.07928934f, 0.10049311f, 
    -0.04613008f, 0.04732065f, -0.08956311f, -0.25798616f, -0.25113177f, -0.31065372f, -0.23404528f, -0.32760870f, 
    0.07725445f, 0.02504873f, 0.03407366f, -0.07284272f, -0.06662881f, 0.17029546f, -0.04457670f, 0.06685370f, 
    0.30228639f, -0.25235063f, -0.19948038f, -0.36263430f, 0.07491279f, 0.00026401f, -0.01631287f, 0.10699058f, 
    -0.00815933f, -0.01419102f, 0.01795410f, -0.19022006f, 0.22455716f, -0.00234465f, 0.01083029f, 0.48880771f, 
    -0.08796021f, 0.14989039f, 0.30031267f, 0.09451674f, -0.03276338f, -0.12088116f, -0.03166132f, 0.01456686f, 
    0.12717931f, 0.11225977f, 0.19789794f, 0.08878238f, -0.00498108f, -0.02043929f, 0.00686123f, 0.03664541f, 
    -0.09829579f, -0.06256666f, -0.01570880f, 0.01925611f, -0.13528797f, 0.06512028f, 0.06756777f, -0.06555864f, 
    -0.12496613f, -0.05470575f, -0.07646623f, -0.19251223f, 0.13174751f, 0.01106634f, -0.04239687f, -0.01318545f, 
    0.33166134f, 0.16295411f, -0.04658805f, -0.14947537f, 0.13128774f, -0.08142043f, -0.07185179f, 0.01547129f, 
    0.04973852f, 0.16304678f, 0.11630964f, 0.13457914f, 0.38597640f, -0.44645083f, 0.03179406f, -0.06893867f, 
    0.12103798f, -0.09247966f, 0.20412028f, 0.19854914f, -0.15973143f, -0.09956136f, 0.00081066f, 0.06292403f, 
    0.30200443f, 0.03094753f, 0.22151427f, 0.16377737f, 0.05381894f, 0.03042976f, 0.42192027f, 0.15870596f, 
    -0.08910155f, -0.03921238f, 0.05808229f, 0.01155768f, 0.00535199f, 0.01396743f, 0.34938532f, 0.18291704f, 
    0.06087984f, 0.19902089f, 0.24071518f, 0.13296837f, -0.04460516f, -0.06500331f, 0.13615286f, 0.00434375f, 
    0.09371105f, -0.07770958f, 0.03717227f, 0.09381489f, 0.21744870f, 0.11854506f, 0.07537667f, 0.02613712f, 
    -0.04521312f, 0.12715134f, -0.03617635f, 0.04879472f, -0.25878498f, 0.36129922f, -0.45077109f, -0.25150746f, 
    0.16515581f, 0.10517035f, 0.15181370f, 0.00701769f, -0.12174289f, 0.01144436f, 0.10418688f, -0.00816757f, 
    0.38251281f, 0.20824111f, 0.17799067f, -0.18634309f, 0.04153159f, -0.03022136f, -0.05794146f, -0.19866276f, 
    0.12827775f, 0.09664627f, 0.19209665f, -0.02441880f, -0.14919385f, -0.19924060f, -0.25462416f, -0.10125918f, 
    -0.10591047f, -0.08426592f, -0.10744433f, -0.07660419f, 0.19315866f, 0.10737274f, 0.10189949f, 0.03664179f, 
    0.01465307f, -0.03820452f, 0.01154713f, -0.24177267f, 0.00929470f, 0.15936363f, 0.04098519f, -0.16621953f, 
    0.14043328f, 0.07198339f, 0.05926840f, 0.08385956f, 0.29423118f, -0.02258060f, 0.24029325f, -0.13765801f, 
    -0.07722998f, 0.03567394f, 0.03767938f, 0.09475954f, -0.00974460f, -0.00532496f, -0.05490043f, -0.03150560f, 
    -0.14319181f, -0.04334423f, 0.20020150f, -0.00354335f, 0.04599949f, 0.04871352f, -0.08832836f, 0.07034484f, 
    0.09909534f, 0.14638190f, -0.01281370f, -0.07323475f, -0.42932567f, -0.31044611f, -0.12367514f, 0.20646890f, 
    0.05295795f, 0.00465712f, 0.00952074f, -0.00633903f, 0.02924760f, 0.00312271f, 0.10676752f, 0.02479706f, 
    0.11426600f, 0.22124974f, 0.13335519f, -0.10560355f, 0.09019051f, -0.01247468f, 0.03426773f, -0.00436273f, 
    0.07607338f, 0.09192874f, 0.15041544f, -0.06690127f, -0.12322447f, 0.11142076f, 0.18435311f, 0.00685542f, 
    -0.01694546f, -0.01808289f, 0.09799774f, 0.03389537f, 0.00956691f, -0.02481631f, 0.09036906f, -0.07579955f, 
    0.23422949f, -0.01262377f, 0.21397474f, 0.09865055f, -0.01458860f, -0.00845426f, -0.05827371f, -0.03879851f, 
    -0.01979638f, -0.07136130f, 0.01357055f, -0.06727120f, -0.05821674f, 0.07883635f, -0.09273815f, 0.15843758f, 
    -0.06796618f, -0.03316091f, -0.01427745f, -0.03501641f, 0.27297246f, 0.13834909f, 0.11390503f, 0.20773144f, 
    0.03796007f, -0.06012389f, -0.00491431f, -0.15558271f, 0.11408268f, -0.11773433f, -0.08674998f, 0.01028208f, 
    -0.09797917f, 0.08431009f, 0.06512475f, 0.12187241f, 0.14282016f, 0.13829899f, -0.08034551f, -0.05804142f, 
    0.14853117f, -0.06791410f, -0.10724525f, 0.01047753f, -0.14420719f, -0.12826392f, 0.05069733f, 0.13298860f, 
    -0.01212605f, 0.02678750f, 0.06418838f, -0.00203243f, 0.17859890f, 0.10046409f, 0.19006366f, 0.13550955f, 
    -0.11924725f, 0.06113700f, -0.05188806f, 0.09897500f, -0.06940085f, 0.00880657f, -0.06341828f, -0.15022591f, 
    -0.10732999f, 0.17049408f, 0.18959178f, 0.10746144f, 0.03968722f, 0.04519609f, 0.00064753f, 0.04430027f, 
    0.01483860f, -0.03413360f, -0.13198623f, 0.00069545f, 0.25056171f, 0.03886639f, 0.14039166f, 0.15602919f, 
    0.02785626f, -0.03327172f, 0.10901263f, -0.00318696f, -0.26163903f, 0.17630996f, -0.19841897f, 0.16036385f, 
    0.11875820f, -0.08985417f, 0.12084522f, 0.08483892f, 0.22015285f, -0.04188244f, 0.21417317f, 0.06084113f, 
    0.28880057f, 0.09146824f, -0.04981258f, 0.39401916f, 0.16721576f, -0.05934577f, 0.04258199f, -0.11214384f, 
    0.18383867f, 0.06598581f, 0.20674856f, 0.28957704f, 0.15808828f, -0.14549294f, -0.03073119f, -0.09096511f, 
    -0.00615302f, -0.06987987f, -0.10453010f, -0.10285125f, 0.13399121f, 0.26734135f, 0.24388564f, -0.04609210f, 
    0.02388506f, -0.00205185f, 0.04758881f, -0.07580195f, 0.25712341f, 0.11665223f, 0.07218444f, -0.10947651f, 
    0.06484771f, -0.05874775f, -0.11453140f, -0.03983191f, 0.22052293f, 0.00451038f, 0.24057557f, 0.03514293f, 
    0.12882674f, -0.09050061f, 0.01423667f, -0.04625719f, 0.00688104f, -0.00565005f, 0.08178369f, -0.08073182f, 
    0.10448536f, -0.17493114f, 0.02251956f, -0.08548906f, -0.04178341f, -0.02915965f, -0.03284512f, 0.09957569f, 
    -0.07807881f, -0.06367115f, 0.04952712f, 0.12442943f, -0.31711486f, 0.18190412f, 0.10608069f, 0.24456085f, 
    -0.06947569f, -0.11205284f, 0.00988108f, 0.11311261f, -0.08468709f, -0.02295996f, 0.07469528f, -0.02198577f, 
    -0.14020045f, 0.40412053f, 0.19366349f, 0.06455059f, 0.03475689f, 0.05349607f, 0.05623745f, -0.05170401f, 
    0.07809665f, 0.12350778f, -0.01970891f, -0.04744769f, -0.04128167f, -0.05881726f, 0.00571710f, -0.36927262f, 
    0.00005049f, -0.07173549f, -0.03802990f, -0.04743284f, 0.02816093f, 0.10590300f, 0.02685115f, 0.09749629f, 
    0.53660679f, -0.26211214f, -0.10348617f, -0.25990137f, -0.06424477f, 0.00995229f, 0.12386531f, -0.10502106f, 
    -0.07132547f, 0.10322384f, -0.01288549f, -0.01347092f, 0.00973954f, -0.05984788f, -0.08353301f, 0.16739443f, 
    -0.08112767f, 0.08811627f, 0.02382356f, -0.00258666f, 0.11803854f, 0.05308444f, 0.15975124f, 0.05006308f, 
    -0.07720835f, -0.14001274f, -0.02776838f, -0.11612418f, -0.02238493f, 0.05153434f, 0.02353344f, -0.00113349f, 
    -0.03950126f, 0.10065693f, 0.07102803f, 0.12655301f, -0.45710364f, 0.52432376f, 0.08355912f, -0.15344055f, 
    -0.02550538f, 0.09457743f, 0.03017535f, -0.03099675f, -0.09197462f, 0.00393938f, -0.00864125f, -0.09051634f, 
    0.23851578f, -0.10288576f, -0.00707932f, -0.10969503f, -0.00595160f, -0.26459447f, 0.07744540f, -0.13625938f, 
    -0.05653464f, 0.03237351f, 0.00825916f, 0.11593358f, 0.03382059f, -0.02580880f, -0.37514350f, -0.13080204f, 
    -0.06522070f, 0.06693754f, -0.05479479f, -0.02606681f, 0.01486779f, 0.00124011f, -0.29425195f, 0.11255503f, 
    -0.04815415f, 0.03763537f, 0.05898914f, -0.09720194f, 0.02709302f, 0.03783045f, 0.16143246f, 0.13915280f, 
    -0.03944222f, -0.10257708f, 0.08247763f, 0.00228344f, 0.10124154f, -0.01336557f, 0.19467363f, 0.31541455f, 
    -0.02823299f, -0.11231235f, 0.37355897f, 0.27264950f, 0.33176601f, 0.08709143f, 0.21603501f, -0.05824044f, 
    -0.45155135f, 0.04945754f, 0.08493663f, 0.46258086f, 0.04278152f, 0.10626776f, -0.02018186f, 0.09964051f, 
    0.14992045f, 0.12731467f, 0.19297092f, 0.11646887f, -0.07753175f, 0.11431316f, -0.00593446f, 0.15273827f, 
    -0.10968588f, -0.03334300f, 0.02298818f, 0.02402330f, -0.03666019f, -0.04981117f, 0.05923656f, 0.02110864f, 
    -0.16912273f, 0.07881939f, -0.07188065f, 0.00054783f, 0.11404341f, -0.05446310f, 0.20789535f, 0.03489006f, 
    -0.06338786f, 0.04053370f, -0.03221118f, 0.01828480f, -0.20738433f, 0.04778637f, -0.02576259f, -0.20158987f, 
    0.31445226f, 0.09197557f, 0.10082070f, 0.00385005f, -0.05035211f, -0.08132209f, -0.07389718f, 0.06997755f, 
    -0.11069924f, -0.39605927f, 0.02146824f, 0.06312571f, -0.22045955f, -0.20319231f, -0.13806592f, -0.06829346f, 
    -0.09113198f, 0.10304981f, -0.16611858f, -0.09068602f, 0.22096439f, 0.36224645f, 0.02852974f, -0.21867248f, 
    0.06020265f, 0.15533099f, 0.01253513f, 0.14702362f, -0.05455882f, 0.11600224f, -0.04098922f, -0.04345291f, 
    0.47557032f, 0.10389601f, -0.03962444f, -0.04520784f, 0.06944534f, 0.05255211f, -0.07783066f, 0.09885804f, 
    -0.07051764f, 0.14969444f, 0.06468439f, -0.11224280f, 0.13278984f, -0.12677327f, -0.23123471f, -0.00394970f, 
    -0.03083646f, -0.04769355f, 0.09896859f, -0.06886116f, -0.09068363f, 0.21862641f, 0.01526846f, 0.14952457f, 
    -0.18115863f, -0.50046146f, 0.15081890f, 0.14848796f, -0.24946983f, -0.02538571f, -0.05314990f, -0.12645248f, 
    0.01717753f, 0.05651745f, 0.03651392f, 0.06197993f, -0.21218489f, -0.24392682f, 0.02466332f, -0.04451380f, 
    -0.11330913f, -0.09074164f, -0.06028127f, -0.15826650f, -0.02226984f, 0.01620361f, 0.04705761f, 0.09177768f, 
    -0.03885937f, -0.01854777f, 0.08405142f, 0.06263611f, -0.11121561f, 0.10745909f, 0.16446109f, -0.06603752f, 
    -0.00409930f, 0.04423801f, 0.00673424f, 0.00933837f, 0.25132346f, 0.15414269f, 0.26881471f, -0.03705713f, 
    0.12701836f, 0.22324875f, 0.03175534f, 0.08000430f, 0.04853830f, 0.02349568f, 0.05861528f, 0.00201156f, 
    -0.02728371f, -0.38251421f, 0.06593592f, -0.19442715f, -0.12655756f, 0.10078938f, 0.10186495f, -0.11703883f, 
    -0.07566911f, -0.00537255f, 0.05477758f, 0.05751697f, 0.19206265f, 0.13235588f, 0.03123457f, 0.02340855f, 
    0.11585993f, 0.10534087f, -0.07900362f, 0.13962387f, -0.08108597f, 0.01196891f, -0.06144205f, -0.22520256f, 
    0.19669479f, 0.39619440f, 0.13334246f, 0.01002238f, 0.12853919f, 0.10108644f, 0.05956870f, -0.00470926f, 
    -0.09189781f, -0.13166575f, -0.02807185f, 0.02792767f, 0.10370171f, 0.41114649f, -0.29466856f, -0.07532229f, 
    0.09667531f, 0.01896467f, 0.22404693f, -0.10987251f, -0.11009075f, -0.02985170f, -0.13363019f, -0.13304886f, 
    -0.42865321f, 0.17318803f, 0.37245652f, -0.44731122f, -0.06102986f, 0.10223219f, -0.04424816f, 0.04350532f, 
    0.04476687f, 0.01809002f, -0.02301032f, -0.12733206f, -0.12662600f, 0.03764198f, -0.39514980f, -0.02764700f, 
    -0.04362453f, -0.02532611f, 0.05452798f, 0.04369484f, -0.02120168f, 0.02759992f, -0.06661200f, 0.12982428f, 
    -0.08431282f, 0.20957279f, 0.06323720f, -0.02009633f, -0.06980982f, 0.11142863f, 0.05449763f, -0.03127634f, 
    0.14399397f, -0.07443182f, 0.04367957f, 0.06723417f, -0.28985399f, 0.16631456f, 0.13283272f, -0.25745222f, 
    -0.18151583f, -0.02863528f, -0.07868511f, -0.01832528f, 0.03516129f, 0.05034101f, -0.07785008f, -0.02182168f, 
    0.26638967f, 0.17975973f, 0.05175890f, 0.09560642f, -0.02967674f, 0.11601779f, 0.14337018f, -0.07123988f, 
    0.12334040f, 0.25950834f, 0.12168750f, 0.17317888f, 0.09698355f, -0.05045834f, 0.07945187f, 0.12622710f, 
    -0.18417834f, -0.09780179f, -0.17948338f, 0.10837177f, 0.00196141f, -0.09859988f, 0.02740426f, -0.17106995f, 
    0.08234309f, 0.07515786f, 0.04899656f, 0.04252968f, -0.09647898f, -0.20816346f, 0.06462155f, 0.04432752f, 
    0.06884052f, -0.03004085f, 0.14461876f, 0.19697525f, 0.11629675f, -0.12514569f, 0.17923331f, 0.08407534f, 
    -0.06576290f, 0.22247639f, -0.02936947f, -0.15071033f, -0.09275491f, -0.09255579f, 0.09783683f, 0.01393202f, 
    0.53593963f, 0.18858662f, 0.02741414f, -0.16993093f, -0.11448923f, -0.15282540f, 0.09953074f, 0.03195245f, 
    -0.02210714f, -0.03424862f, -0.04198683f, -0.08568703f, 0.09457470f, 0.25148830f, 0.12154079f, 0.08314980f, 
    0.06483076f, 0.14961606f, 0.02563474f, 0.09779785f, -0.00652083f, 0.10085106f, 0.12188866f, -0.17680472f, 
    0.29301324f, 0.05533021f, -0.06630562f, 0.06817893f, -0.23978369f, 0.12643865f, 0.00065076f, -0.11863148f, 
    -0.06697030f, -0.15927260f, -0.16358024f, -0.13725798f, -0.15418960f, 0.16136599f, 0.26138082f, -0.19111088f, 
    -0.26609862f, -0.09629293f, 0.09282878f, -0.10121688f, 0.03280923f, 0.01782949f, -0.06794138f, -0.06432253f, 
    0.15823042f, 0.12097711f, 0.22360167f, 0.05338774f, -0.10933430f, -0.04453531f, 0.15449844f, -0.07631275f, 
    0.05135894f, -0.03539710f, -0.11713291f, 0.08572380f, -0.51666170f, -0.36417222f, 0.10108554f, -0.18136871f, 
    -0.02137418f, 0.00313308f, 0.15988116f, 0.21008778f, 0.14806926f, 0.04712562f, -0.07076333f, 0.14027904f, 
    -0.28207523f, -0.08003041f, -0.14384691f, -0.15659007f, 0.01252296f, -0.13163503f, -0.03631578f, 0.26475760f, 
    -0.03576936f, -0.04277996f, 0.02534432f, -0.07557707f, -0.12357254f, -0.04380496f, -0.08424947f, 0.53351635f, 
    0.26378459f, -0.07408104f, -0.06390919f, 0.36766526f, -0.05211383f, 0.04090171f, 0.17302063f, -0.04659649f, 
    -0.05205189f, 0.01078438f, 0.14889459f, 0.21957661f, -0.02758273f, 0.12872490f, -0.14663331f, -0.00271420f, 
    -0.10285558f, 0.03603159f, -0.00705903f, -0.19770084f, -0.06661393f, 0.12509055f, -0.06076901f, -0.05896175f, 
    0.02869228f, -0.01115902f, 0.09086375f, -0.08303614f, -0.19681768f, 0.13873056f, 0.09313788f, 0.11354085f, 
    0.04539960f, -0.08576737f, -0.00988174f, 0.09190212f, -0.00656741f, 0.04994375f, -0.02972655f, 0.19586767f, 
    -0.09822425f, -0.20729303f, -0.21765460f, -0.09035265f, 0.14408824f, -0.03287902f, -0.01913470f, -0.03855822f, 
    -0.11995514f, -0.04986777f, 0.04751492f, 0.03762436f, -0.11123414f, 0.00551578f, 0.05552464f, -0.04829622f, 
    0.07487710f, 0.10453005f, 0.44760200f, 0.26944426f, -0.05976662f, -0.00915191f, -0.26696333f, -0.03394900f, 
    -0.15926427f, -0.05006938f, -0.27597257f, -0.09740239f, 0.23883273f, 0.16271131f, -0.21557584f, -0.02299811f, 
    -0.19304758f, 0.00027723f, -0.04270013f, 0.08773685f, -0.06807530f, 0.07800215f, 0.29973146f, 0.09110218f, 
    0.36537191f, 0.10318463f, -0.05588325f, -0.09429412f, -0.01306724f, -0.02447839f, -0.05085360f, -0.07236321f, 
    0.06160181f, 0.13144863f, -0.09018465f, -0.25577873f, -0.15282433f, -0.00226735f, 0.00491612f, -0.11098731f, 
    0.12471648f, -0.02649065f, 0.02413046f, 0.03946873f, 0.16038658f, 0.03338203f, 0.07045606f, 0.35427952f, 
    0.56903720f, -0.05634403f, 0.22518511f, 0.23707169f, -0.26687014f, -0.08778792f, -0.03025699f, 0.03070260f, 
    -0.15983260f, 0.09921844f, -0.00222994f, -0.05849232f, 0.17209972f, 0.07376249f, 0.13292018f, 0.12306589f, 
    -0.20043078f, 0.01011953f, -0.12412122f, -0.09958164f, 0.05130224f, -0.03513671f, 0.03194413f, 0.04258382f, 
    -0.17722796f, 0.08949784f, 0.06421956f, 0.01037001f, -0.01700413f, 0.17117207f, 0.03703462f, -0.18324643f, 
    -0.04066144f, 0.15300831f, 0.10818753f, 0.23428859f, -0.11110530f, 0.27843443f, 0.18671663f, -0.26572278f, 
    0.11554615f, 0.22423476f, 0.02531676f, -0.00674373f, -0.04718386f, 0.07725666f, -0.01908922f, 0.01784493f, 
    -0.18746367f, -0.09987523f, 0.20077099f, -0.24199851f, -0.11853467f, -0.17930019f, 0.09888723f, -0.02769832f, 
    0.01370971f, 0.03402641f, 0.08546548f, 0.12977453f, 0.06143565f, -0.11818285f, -0.10001420f, -0.14405315f, 
    -0.07052485f, 0.09903501f, -0.02831803f, 0.24899058f, 0.01302802f, -0.00321094f, -0.23193786f, 0.09570678f, 
    -0.01627463f, 0.16002055f, -0.12684502f, 0.05339581f, 0.25757813f, 0.07710791f, 0.24454661f, 0.35961407f, 
    -0.02776788f, -0.02154497f, 0.02835293f, 0.01123225f, 0.27111807f, 0.30303800f, -0.33242562f, 0.24220753f, 
    0.14447516f, -0.11593591f, 0.21896647f, 0.02989462f, 0.07397830f, -0.04422053f, -0.05960767f, -0.06245849f, 
    -0.06204625f, 0.13822041f, 0.34463912f, 0.10937879f, 0.07041599f, 0.01851201f, 0.08208798f, -0.12945661f, 
    0.17961147f, 0.06036001f, 0.01473998f, -0.02721522f, 0.06953844f, -0.30507615f, -0.33173597f, -0.20451443f, 
    -0.19219486f, -0.03469746f, -0.05723725f, -0.34670073f, 0.00678259f, 0.08777221f, 0.14475043f, 0.12707533f, 
    -0.11401306f, 0.00390849f, -0.08950393f, -0.21495709f, 0.13276160f, 0.04899314f, 0.27098587f, -0.12839884f, 
    -0.02152804f, -0.11219294f, 0.11855351f, 0.15845895f, -0.10015446f, 0.08534175f, 0.14205958f, -0.30335161f, 
    0.12339852f, -0.14980875f, -0.04235189f, 0.02108461f, -0.08823334f, -0.07781072f, -0.27002791f, -0.11093954f, 
    0.24701117f, 0.09206398f, 0.22641416f, -0.15088268f, 0.07289230f, -0.05796021f, 0.08538657f, -0.16115652f, 
    0.06692920f, 0.22992806f, 0.35669911f, 0.48354560f, 0.22903089f, 0.12469165f, 0.28759187f, 0.17027755f, 
    -0.12244192f, -0.06878120f, 0.09987389f, 0.17695795f, 0.01338942f, -0.13337572f, -0.10878477f, 0.10037836f, 
    -0.00310817f, 0.05252279f, 0.02759353f, 0.14187583f, -0.10454547f, 0.05271466f, 0.19516081f, 0.06641648f, 
    0.10638612f, 0.07869592f, 0.25950459f, 0.32736707f, 0.17553760f, -0.01103450f, 0.32979223f, 0.08689982f, 
    0.04522552f, 0.02873022f, 0.16923940f, -0.00386280f, 0.06828224f, 0.02571377f, -0.14538287f, -0.15686363f, 
    0.47536641f, 0.38749850f, 0.06941609f, -0.16031928f, -0.10520138f, -0.06084301f, -0.09279746f, -0.10525705f, 
    -0.10323398f, -0.23300578f, -0.10506340f, 0.08874185f, 0.01797643f, 0.20411907f, 0.07321871f, -0.05016006f, 
    0.04187313f, 0.35946092f, 0.12947553f, -0.04672572f, 0.02251219f, 0.15373844f, 0.04460934f, -0.06565133f, 
    0.52439207f, 0.15120986f, -0.02861483f, -0.09686195f, 0.04781697f, -0.02304118f, -0.13106406f, -0.03560956f, 
    -0.27444902f, -0.25984260f, -0.25379562f, -0.24451850f, -0.07490610f, 0.16585533f, 0.01138900f, -0.00431170f, 
    0.00179468f, -0.01489324f, 0.13561642f, 0.01763332f, -0.04303686f, -0.16597743f, -0.16389170f, 0.01275960f, 
    0.36797228f, 0.04453835f, 0.21002792f, -0.05824259f, 0.19365327f, -0.04929666f, -0.00016850f, 0.01132619f, 
    0.09980123f, -0.02039249f, -0.00568216f, 0.19710113f, -0.27942649f, -0.12224492f, 0.03088595f, 0.09482949f, 
    -0.00998414f, -0.04631890f, -0.00428682f, 0.03016872f, 0.08791503f, 0.14577956f, 0.03269123f, -0.07302652f, 
    -0.23878987f, -0.17898245f, -0.01657522f, -0.03386569f, -0.13010028f, -0.25355548f, -0.03183454f, 0.15715557f, 
    -0.28496984f, 0.00806648f, -0.14031364f, -0.07648145f, 0.00525937f, -0.34453738f, 0.02455695f, 0.46633476f, 
    -0.10804702f, 0.11548050f, 0.16760555f, 0.15421034f, 0.15583029f, 0.22587828f, 0.24270259f, 0.00008985f, 
    -0.08470965f, -0.02802023f, -0.17281505f, 0.24575387f, 0.00798030f, -0.04889616f, -0.10653292f, 0.08421994f, 
    0.04184740f, 0.04990495f, -0.04338749f, -0.07087955f, -0.12951900f, 0.33784941f, -0.09004770f, -0.13602225f, 
    -0.15769115f, -0.15405233f, -0.08122787f, 0.03144902f, -0.14896590f, -0.04387361f, 0.10992429f, 0.00306023f, 
    -0.12187663f, -0.17957501f, -0.34862602f, 0.20703852f, 0.06566598f, -0.20057791f, -0.16451821f, 0.06788559f, 
    -0.42814824f, -0.42203540f, -0.10304529f, -0.26782790f, 0.09637885f, -0.06316617f, -0.01550900f, -0.13313730f, 
    0.22097124f, -0.06784104f, 0.14460632f, 0.05452565f, -0.02391755f, -0.11273143f, 0.02194552f, 0.11808205f, 
    -0.04838108f, 0.02090903f, -0.01088152f, -0.02678917f, 0.02231622f, 0.03489058f, 0.04201616f, 0.04850611f, 
    -0.06027388f, -0.06854440f, 0.02915417f, -0.04073259f, -0.06727198f, 0.01472649f, -0.02128594f, 0.02091023f, 
    -0.00007186f, -0.01937053f, -0.00003444f, 0.05167495f, -0.02414269f, 0.04681224f, -0.04776343f, -0.04357640f, 
    -0.04204540f, -0.05338312f, 0.02772896f, 0.04688868f, -0.04183197f, -0.03624950f, 0.01361710f, -0.01020523f, 
    -0.05621381f, -0.06621864f, -0.00508526f, 0.01378581f, -0.05754038f, 0.00535638f, -0.00961360f, 0.01619852f, 
    0.01046691f, -0.05865301f, 0.00464198f, -0.06157311f, -0.06762414f, 0.02412298f, 0.02149926f, 0.06050414f, 
    -0.04253250f, 0.00239928f, 0.01382842f, 0.03809414f, 0.05647197f, 0.05096000f, -0.04972114f, -0.06851143f, 
    -0.00488190f, 0.04183228f, -0.07102688f, 0.00454517f, 0.04221782f, -0.03756100f, -0.06274291f, -0.01593065f, 
    -0.00542401f, -0.06279957f, -0.00574489f, 0.04092554f, -0.02943751f, -0.07228400f, -0.01894098f, 0.00416411f, 
    -0.00347876f, -0.05143975f, -0.06633436f, -0.03663215f, -0.04183685f, -0.01791473f, 0.03617478f, -0.06000848f, 
    -0.03845309f, 0.01099779f, 0.05998510f, 0.01831815f, -0.02448601f, -0.06156211f, 0.01610243f, -0.01068257f, 
    0.00400418f, -0.00412271f, 0.01270325f, 0.05758195f, -0.02216068f, -0.06796005f, -0.01393884f, 0.05061346f, 
    -0.01314006f, -0.02647157f, -0.01362904f, -0.05445615f, 0.06598274f, 0.04169955f, -0.07703660f, -0.00170786f, 
    -0.04100116f, -0.00907718f, 0.02940002f, -0.03463991f, 0.06624624f, -0.06496058f, -0.06004950f, 0.01156090f, 
    0.04739225f, 0.01257635f, -0.05972273f, -0.05473845f, 0.04269014f, -0.07006846f, -0.01717246f, -0.07628878f, 
    0.02111565f, 0.03083990f, -0.03422188f, -0.05750204f, -0.02566317f, -0.04132194f, -0.03656327f, -0.03837023f, 
    0.05781203f, -0.07056446f, 0.04246233f, 0.05390370f, -0.06528330f, 0.01927594f, 0.02141921f, -0.00278704f, 
    0.04278548f, -0.05128396f, -0.02994217f, 0.04748895f, 0.01087473f, -0.06129977f, 0.05857754f, -0.02921819f, 
    0.04998263f, 0.03116457f, 0.03782207f, 0.03111181f, -0.00820249f, -0.01626555f, -0.04799210f, 0.00902470f, 
    0.01268992f, 0.00809356f, 0.04998244f, -0.05342890f, 0.00772930f, -0.00082899f, -0.03488554f, -0.00590394f, 
    -0.06400828f, -0.04239653f, 0.04749376f, -0.01941846f, -0.01895270f, -0.04705396f, 0.02004496f, -0.07004692f, 
    -0.01004619f, -0.07169783f, 0.05500302f, 0.06504563f, -0.03881362f, 0.05578519f, 0.05334816f, -0.03726295f, 
    -0.01355196f, -0.05740932f, -0.02136886f, 0.03077611f, -0.00798603f, -0.04376914f, 0.02624921f, 0.01682892f, 
    -0.02051281f, -0.02292019f, 0.06523131f, -0.02945299f, -0.06609116f, -0.02499498f, -0.04193939f, -0.03902348f, 
    0.07350749f, 0.01987851f, -0.10907877f, -0.06252883f, 0.05752121f, 0.00436439f, 0.16736226f, 0.01027986f, 
    -0.09609810f, 0.07422765f, 0.19578047f, 0.04967986f, 0.00543825f, 0.48859271f, -0.04541653f, 0.03711551f, 
    -0.12135907f, -0.04160082f, -0.05971489f, -0.12846890f, 0.06473636f, -0.06903347f, -0.06027547f, -0.02010063f, 
    -0.18521857f, 0.14467387f, -0.01058806f, -0.22591102f, -0.03872353f, -0.13892077f, -0.00213521f, 0.21219626f, 
    0.06227956f, -0.02906634f, 0.09036294f, 0.06510265f, 0.48368019f, -0.06554956f, -0.34058118f, 0.10521576f, 
    0.02066862f, 0.10861900f, 0.13784283f, 0.03767769f, -0.01126891f, -0.02306482f, 0.03666400f, -0.13053639f, 
    -0.09289182f, -0.30396867f, -0.01816597f, -0.35349169f, 0.09312538f, -0.02979343f, -0.00634008f, 0.09377919f, 
    0.02915844f, -0.00150728f, -0.01447792f, -0.01288082f, -0.22272564f, -0.07447077f, 0.09297156f, 0.10649931f, 
    0.03000092f, 0.00493647f, -0.11827806f, 0.06179684f, 0.09535357f, 0.06373131f, 0.06027133f, 0.08493762f, 
    0.21181364f, 0.03239771f, -0.14682241f, -0.05943090f, 0.09311116f, 0.14433005f, 0.03033894f, 0.03229869f, 
    0.00110789f, -0.08793870f, -0.10294380f, -0.07013082f, -0.41921908f, -0.12747586f, 0.12337201f, -0.19762361f, 
    -0.10161033f, 0.01120374f, 0.10428298f, -0.06306936f, 0.09841847f, 0.10144691f, 0.07004083f, -0.07923230f, 
    0.63798368f, 0.21807668f, -0.12060554f, 0.12318035f, 0.13384002f, -0.01793876f, 0.33675548f, -0.07218608f, 
    -0.00834256f, 0.08859295f, -0.01566509f, 0.04814096f, 0.08251286f, 0.01968829f, 0.14776920f, -0.08178955f, 
    0.02000778f, -0.01178891f, -0.05868272f, -0.03846397f, 0.14258216f, 0.01937783f, 0.08563175f, 0.00103590f, 
    -0.06365369f, 0.12107480f, 0.17296126f, -0.03170671f, -0.17926341f, -0.02976927f, -0.12207615f, 0.10035643f, 
    0.02224320f, 0.03980342f, 0.09239693f, -0.03072459f, -0.28880215f, -0.12685034f, 0.30021822f, 0.32119602f, 
    0.08972847f, 0.10650020f, 0.04913713f, -0.04594177f, 0.05050597f, 0.05240523f, 0.07571471f, 0.04726616f, 
    -0.30910626f, 0.07608081f, 0.00972836f, 0.31956619f, -0.11646695f, -0.05543624f, -0.09538537f, -0.04173709f, 
    0.02348357f, -0.03688060f, 0.10909553f, -0.20530717f, -0.11539181f, 0.09450661f, 0.13360804f, 0.10180733f, 
    -0.01394660f, -0.08188557f, -0.05243742f, 0.01384318f, 0.01241665f, 0.03345175f, -0.04699231f, 0.23463142f, 
    -0.10947809f, 0.00861561f, -0.15373026f, -0.02498930f, 0.08822005f, -0.00531739f, 0.13655080f, 0.25368926f, 
    -0.07280152f, -0.08718784f, -0.06972069f, -0.08134422f, 0.06625493f, 0.08720686f, -0.27235261f, 0.06599630f, 
    0.13927002f, 0.02203297f, 0.00498786f, 0.05111498f, -0.08731131f, 0.06215460f, -0.18569733f, 0.03316747f, 
    0.13501509f, 0.16305417f, 0.33954474f, -0.05613450f, 0.09496557f, 0.01764336f, 0.00422815f, 0.04235364f, 
    -0.06827979f, -0.10759950f, 0.07403174f, -0.03184052f, -0.20641784f, -0.19406955f, -0.04130498f, -0.09081972f, 
    -0.01269234f, -0.07722510f, -0.00601858f, 0.00967225f, -0.04175081f, 0.02912637f, 0.13622528f, 0.24323501f, 
    0.10727262f, 0.04837412f, 0.02556304f, 0.12950726f, 0.03256409f, 0.07631784f, 0.00437305f, -0.00054914f, 
    0.15315112f, 0.14564343f, 0.31936941f, -0.02003336f, -0.10390172f, 0.14207153f, 0.30569249f, -0.08685634f, 
    -0.05661573f, -0.03922944f, 0.32053787f, 0.24546719f, 0.03913286f, 0.05149635f, -0.11550906f, 0.05585205f, 
    0.12825695f, 0.12159310f, -0.19076031f, 0.01659461f, 0.04617707f, 0.07969844f, 0.06244769f, -0.19574158f, 
    -0.02902093f, -0.13066061f, -0.00891703f, -0.03050372f, 0.05617490f, 0.16338404f, 0.00213175f, 0.00032669f, 
    -0.09233780f, -0.04574600f, -0.03883050f, -0.05762151f, -0.01599662f, 0.13545030f, -0.01085883f, 0.05680174f, 
    0.07710800f, 0.06686898f, -0.00779319f, -0.17030901f, 0.10638461f, -0.12725192f, -0.00768754f, 0.05488470f, 
    0.05581186f, 0.08444192f, 0.02768657f, -0.00736513f, 0.04859770f, -0.01504932f, -0.18414818f, 0.07510495f, 
    0.10925873f, -0.18158728f, 0.20626757f, -0.03434034f, -0.07252641f, -0.02330938f, -0.03093417f, -0.06524652f, 
    0.24183054f, 0.11618581f, 0.08021975f, -0.01137064f, 0.23938859f, -0.05447894f, 0.34577972f, 0.16431329f, 
    0.11903349f, -0.01799444f, 0.21067469f, 0.07815310f, -0.18476839f, -0.18607090f, -0.08958381f, 0.00881420f, 
    -0.29966831f, 0.18974607f, 0.16293293f, 0.01184585f, 0.01517006f, 0.06655294f, -0.07451150f, 0.15936148f, 
    -0.15279357f, -0.30010942f, -0.07010531f, 0.05197310f, 0.07034357f, -0.08088131f, 0.14668903f, 0.13688420f, 
    -0.01588453f, 0.08453900f, 0.00503946f, 0.17613305f, 0.05342668f, -0.02053527f, 0.03754856f, 0.09068383f, 
    -0.01298412f, -0.08793934f, 0.24254903f, 0.10601340f, 0.32270083f, 0.25143477f, 0.30388024f, -0.00508216f, 
    0.43009713f, 0.01320073f, 0.02567163f, 0.24428423f, -0.03456175f, -0.00032659f, -0.12235679f, -0.01010562f, 
    0.28281558f, 0.10630028f, -0.02080995f, 0.15924664f, 0.05193508f, -0.10250892f, -0.05303745f, -0.03099897f, 
    -0.09211115f, -0.08175992f, -0.08896650f, -0.10888629f, 0.08826210f, 0.16926400f, 0.20843242f, 0.03769205f, 
    -0.03260016f, -0.17270759f, -0.12291912f, -0.05353115f, 0.34933001f, -0.05153416f, 0.17385261f, 0.10458154f, 
    0.00758507f, -0.02784820f, 0.04448143f, -0.05327687f, 0.15955776f, -0.18750979f, -0.18977208f, -0.08002128f, 
    0.34099525f, 0.11007379f, 0.09053902f, 0.05472590f, -0.03655392f, -0.03085117f, 0.06187780f, -0.07047771f, 
    0.09863515f, 0.08287022f, -0.09563314f, 0.14017086f, -0.18813930f, -0.29394975f, 0.16380097f, -0.25713295f, 
    -0.11412439f, 0.08452168f, 0.22523727f, 0.28441736f, 0.42614603f, 0.36771640f, -0.02102212f, -0.38871175f, 
    -0.23132332f, -0.09213141f, -0.03267887f, 0.02574020f, 0.16943866f, -0.00255476f, -0.14679672f, 0.00353777f, 
    -0.10772603f, -0.16914025f, -0.17793170f, -0.08169718f, -0.05089938f, 0.15678073f, -0.01327613f, 0.05565112f, 
    0.16371031f, 0.08123589f, 0.08036805f, 0.11785279f, 0.19853006f, 0.06249830f, 0.05399000f, 0.07325769f, 
    0.05468993f, 0.00064714f, 0.01166752f, 0.21929961f, -0.03455931f, -0.09287522f, -0.00858547f, 0.00245027f, 
    -0.13531917f, 0.26649851f, -0.18371777f, -0.10440960f, 0.01437177f, -0.03106506f, -0.01838322f, 0.00804027f, 
    -0.07300217f, -0.06901823f, -0.13093154f, -0.12094481f, 0.08010551f, 0.08506636f, 0.17339186f, -0.11960780f, 
    -0.16071786f, -0.10723640f, 0.25194573f, -0.11704790f, -0.18293163f, -0.03779678f, -0.12364093f, -0.03329983f, 
    -0.15339132f, 0.26103270f, 0.03740562f, 0.29304868f, 0.09296639f, 0.08095956f, 0.07228409f, 0.09214187f, 
    -0.25965184f, -0.19845301f, -0.22162186f, -0.27283812f, -0.32592911f, -0.28011313f, 0.00460530f, -0.02853586f, 
    -0.05100417f, 0.17776050f, 0.12826537f, 0.10592940f, 0.10716276f, 0.11759244f, -0.03044097f, 0.06277990f, 
    0.05460467f, -0.13995489f, -0.12919077f, 0.02981079f, -0.05099533f, -0.01488285f, -0.13862620f, 0.08690593f, 
    0.01479028f, -0.03059221f, 0.17348336f, -0.13293044f, 0.25268152f, 0.19128753f, 0.16613789f, 0.23342897f, 
    0.10877595f, -0.08032748f, 0.02361302f, -0.02998449f, 0.04281406f, 0.12201285f, 0.22467944f, 0.05015661f, 
    0.07175966f, 0.03913133f, 0.16080603f, 0.15978010f, -0.11464522f, 0.15534046f, 0.01400073f, 0.08985776f, 
    0.03305103f, 0.00701273f, 0.03510680f, 0.01174545f, 0.55958557f, -0.17619428f, 0.16769941f, -0.20566981f, 
    -0.19176099f, 0.18797509f, -0.06300766f, -0.05916001f, 0.20887166f, 0.21541767f, 0.02646626f, -0.02319390f, 
    -0.03324085f, 0.00676568f, 0.05507349f, -0.30167288f, -0.15154752f, 0.13302197f, -0.06192210f, -0.04511562f, 
    -0.16915180f, -0.06916680f, 0.01563245f, -0.18396978f, 0.16323631f, 0.15644343f, -0.21001555f, -0.14260828f, 
    -0.15865350f, -0.03459555f, 0.06911309f, 0.04956426f, 0.19355899f, -0.19770566f, -0.03453166f, 0.07423537f, 
    -0.17058189f, -0.11743027f, 0.12144569f, -0.08640871f, -0.07273332f, -0.09705131f, -0.28820494f, -0.09799400f, 
    -0.43439633f, -0.21344541f, 0.17289284f, -0.40469009f, -0.02108343f, 0.09569515f, 0.01279175f, 0.06970656f, 
    0.08624138f, 0.13161673f, -0.06731156f, -0.05970281f, 0.02623949f, 0.04928590f, -0.11024312f, 0.01254535f, 
    0.28865638f, -0.02265674f, 0.07436901f, -0.11302254f, -0.03916566f, -0.00097295f, -0.00939973f, 0.05040634f, 
    0.05663946f, 0.15463473f, 0.08584131f, 0.28794566f, -0.44367135f, -0.20190765f, 0.40949968f, 0.48531008f, 
    0.13930607f, -0.13341698f, 0.14626393f, -0.10428689f, 0.07157882f, -0.10049298f, -0.05530161f, 0.00302448f, 
    -0.13635805f, 0.09173726f, 0.23581234f, 0.13013056f, -0.07158908f, -0.02523303f, 0.04487526f, -0.11542118f, 
    0.01415308f, 0.07107259f, 0.23589025f, 0.20502454f, -0.06553242f, 0.01953567f, 0.08167954f, 0.13914409f, 
    0.03815414f, -0.09762380f, 0.17696835f, -0.09872993f, 0.07279577f, 0.05275244f, -0.18421248f, -0.14082859f, 
    0.27047822f, 0.11352013f, 0.39305142f, -0.08239897f, 0.03882022f, 0.13768600f, 0.04062636f, -0.02409794f, 
    -0.07928585f, -0.05664303f, -0.06428711f, 0.00990946f, 0.01608046f, -0.01469004f, -0.06611002f, 0.01442708f, 
    0.00050505f, 0.01901836f, 0.16308077f, 0.07174648f, 0.01351485f, -0.03751001f, -0.07010648f, -0.00171506f, 
    0.29239008f, -0.18976271f, -0.01617415f, -0.17791915f, 0.11539748f, 0.12439346f, 0.02684397f, 0.26356867f, 
    -0.07452495f, -0.06191699f, -0.01174632f, -0.15092231f, 0.14495063f, 0.22258244f, 0.06221797f, 0.24241640f, 
    -0.03832210f, -0.14005482f, -0.15622109f, 0.10172098f, -0.05560306f, -0.00687049f, 0.08346277f, -0.10173342f, 
    0.10227057f, -0.10500337f, 0.14113475f, 0.14072697f, 0.22757015f, 0.02452065f, -0.00541568f, 0.13362993f, 
    0.05144747f, -0.03036457f, -0.10403013f, 0.06334522f, -0.25627419f, -0.26344845f, -0.07697233f, 0.17005548f, 
    0.07807804f, -0.00932680f, 0.00930568f, -0.16515249f, -0.04239242f, 0.03744807f, 0.04138067f, -0.06836192f, 
    -0.12992987f, -0.25777236f, 0.06442120f, 0.04778967f, -0.00183402f, -0.06190426f, -0.03620677f, -0.10669503f, 
    -0.07111496f, 0.00949094f, -0.00882087f, -0.15902871f, -0.48031625f, -0.12530412f, -0.12146974f, 0.15835536f, 
    -0.05813663f, -0.16997531f, -0.14356744f, -0.10599629f, -0.08195559f, 0.19065535f, 0.32669392f, 0.08905067f, 
    -0.11368322f, 0.00465573f, -0.17829391f, 0.34296215f, -0.10881435f, -0.00227957f, 0.06051327f, 0.13987170f, 
    0.09407396f, 0.12167774f, 0.12681596f, 0.11812218f, -0.15969443f, 0.21900654f, 0.06556710f, 0.10880510f, 
    -0.00523070f, -0.02052263f, 0.07912795f, 0.08399312f, 0.05338441f, 0.14679311f, 0.13932233f, 0.03207672f, 
    -0.11269392f, -0.08820921f, -0.08765481f, 0.12053614f, 0.09195155f, 0.14126293f, -0.16682464f, 0.04320704f, 
    0.00693486f, -0.07051681f, -0.13963498f, -0.12700655f, 0.28031436f, -0.13811533f, 0.17436066f, -0.06456534f, 
    0.01536825f, 0.13082825f, 0.10909962f, 0.08333012f, -0.03369783f, 0.00416118f, 0.03432990f, 0.05662308f, 
    0.02360010f, 0.04696400f, -0.05877331f, -0.06155831f, -0.04757976f, 0.02572352f, 0.17199941f, 0.14949270f, 
    0.39912376f, -0.04501074f, 0.09684625f, -0.08913121f, -0.06695762f, 0.25074384f, 0.10946064f, 0.10795501f, 
    0.01633593f, -0.05094279f, -0.05654750f, -0.07207102f, 0.08813389f, 0.07221963f, 0.21293855f, 0.12423767f, 
    -0.07372504f, 0.25194734f, 0.29923326f, 0.12631321f, 0.04954426f, -0.19266960f, -0.13589628f, 0.08485080f, 
    0.03377584f, -0.15555848f, 0.01873905f, -0.02738175f, 0.17237970f, -0.19639868f, -0.10346228f, -0.28910032f, 
    0.17886341f, 0.22656119f, 0.02521098f, 0.00376726f, 0.09731578f, -0.13604178f, 0.04080300f, -0.09951298f, 
    -0.20682621f, -0.36192611f, -0.30833858f, 0.10058724f, 0.08555177f, -0.18039234f, 0.03797689f, 0.09267395f, 
    0.01582012f, -0.08454780f, -0.03090206f, 0.00463980f, -0.13951570f, -0.17491162f, 0.01780573f, 0.09040769f, 
    0.17346630f, -0.10344163f, -0.26465717f, -0.07346817f, 0.35327217f, 0.04380453f, 0.03563743f, 0.03267122f, 
    -0.06999085f, -0.21174163f, -0.24936499f, -0.10619958f, -0.06681860f, 0.05686147f, -0.00239727f, -0.13045792f, 
    0.12084446f, -0.02322124f, 0.04449319f, 0.08474179f, -0.06796700f, 0.05525720f, 0.03828549f, 0.22127973f, 
    0.05842821f, -0.13656259f, 0.11718896f, -0.11413088f, -0.11793874f, -0.01958091f, -0.01777813f, -0.04474509f, 
    0.41879278f, 0.42336392f, -0.17845169f, -0.03548034f, 0.21845615f, 0.02724130f, 0.27238038f, 0.06968988f, 
    -0.00792786f, 0.11197332f, -0.08875734f, 0.11033028f, -0.21573457f, -0.03088144f, 0.29487196f, -0.15796578f, 
    0.23825204f, 0.13186085f, 0.15529211f, 0.03961933f, 0.13827230f, -0.07655328f, -0.00196416f, 0.13003169f, 
    -0.20091534f, 0.06004153f, 0.14675952f, 0.07659432f, -0.02207218f, 0.03841183f, -0.00747570f, 0.01074733f, 
    0.10447031f, 0.17227304f, 0.12586750f, -0.00406343f, -0.50976801f, -0.09231174f, 0.38387403f, 0.13148984f, 
    0.32156163f, 0.07173036f, -0.16674365f, 0.22924054f, 0.13827214f, 0.06740667f, -0.06578201f, -0.03802810f, 
    -0.01045542f, -0.03653918f, -0.05488523f, 0.28589010f, -0.01746194f, -0.06015439f, -0.08828702f, -0.05040164f, 
    0.22540201f, 0.09949788f, 0.15154091f, 0.08543433f, 0.05724517f, -0.03631624f, 0.16984761f, -0.13212733f, 
    -0.12968495f, -0.17757261f, -0.19843099f, -0.08422013f, 0.14703266f, 0.16171326f, 0.11178635f, -0.02217532f, 
    -0.05424204f, -0.14720507f, 0.00278505f, 0.00329772f, -0.00668689f, 0.09384935f, 0.21490559f, 0.14510588f, 
    0.10867856f, 0.05338370f, -0.08193055f, 0.04058744f, -0.34743851f, -0.30288532f, -0.60757250f, 0.28584102f, 
    -0.11688577f, 0.02075547f, 0.03069993f, 0.04489272f, -0.13443641f, 0.04975127f, 0.01969242f, -0.07374659f, 
    -0.24297416f, -0.09668691f, 0.00043877f, -0.08870278f, -0.00745280f, 0.04654584f, -0.10617515f, -0.01293569f, 
    0.05658922f, 0.01808717f, -0.02092658f, 0.06572399f, -0.16468899f, -0.07009646f, 0.14458004f, 0.06294613f, 
    -0.09931600f, -0.02457326f, 0.01060342f, 0.11095919f, -0.02261736f, -0.12999630f, 0.11408883f, 0.10096665f, 
    0.05819198f, 0.27573168f, 0.25427255f, 0.22393413f, 0.04076282f, -0.03114063f, -0.16120087f, -0.13348383f, 
    0.05866076f, 0.09352306f, -0.01619877f, 0.07992323f, -0.29244465f, 0.08826181f, 0.08846951f, -0.31686348f, 
    0.19711606f, 0.11034177f, 0.01770132f, 0.04133570f, -0.02735824f, -0.06518167f, 0.01260929f, 0.05258674f, 
    -0.35528740f, -0.34683031f, -0.16639094f, 0.07745834f, -0.01431660f, -0.11223304f, -0.11012088f, -0.13939863f, 
    0.03955847f, -0.06604706f, -0.07105912f, -0.08449578f, -0.13637024f, -0.12656555f, -0.27542177f, -0.16776711f, 
    -0.01976571f, -0.10029125f, -0.06871007f, -0.04925302f, -0.07541682f, 0.10080259f, 0.06502933f, 0.09150317f, 
    -0.32652748f, -0.09834513f, 0.04773590f, 0.06367307f, 0.06934186f, -0.03686889f, -0.05919413f, 0.09486941f, 
    0.08624755f, 0.02859498f, 0.05184658f, 0.15065460f, -0.12593843f, 0.43902370f, -0.16405693f, 0.30780312f, 
    0.17115594f, 0.04971937f, 0.08337938f, 0.01800672f, 0.05254369f, -0.01365601f, 0.03174563f, 0.14048217f, 
    -0.53953302f, -0.22377959f, -0.15054221f, -0.04388306f, 0.08158800f, -0.01562894f, -0.09103473f, 0.02327307f, 
    0.06270023f, 0.11769556f, -0.03026550f, 0.13437504f, 0.15686812f, 0.27124226f, -0.00521364f, 0.02015172f, 
    0.08617754f, 0.07477498f, 0.19392577f, 0.24149919f, 0.04170416f, -0.05580338f, -0.01504511f, 0.18945844f, 
    0.06522514f, 0.24025880f, 0.10295311f, 0.27021420f, 0.05299536f, 0.09985557f, 0.30153838f, 0.36268643f, 
    0.10482968f, -0.01495389f, -0.00465480f, -0.03996599f, 0.07890432f, -0.16102073f, 0.21661261f, -0.17182910f, 
    0.04289701f, -0.01741792f, 0.09120049f, 0.26720405f, 0.08625113f, -0.03955396f, -0.18348736f, 0.14466983f, 
    0.21601225f, -0.13500652f, -0.18502240f, -0.16482335f, -0.16463971f, -0.11947396f, 0.00090686f, 0.03233851f, 
    0.13742362f, 0.11335061f, 0.13888197f, 0.07399742f, 0.01145668f, -0.30919647f, -0.11667378f, -0.04123062f, 
    -0.05208869f, -0.02841883f, -0.12269405f, -0.08036561f, 0.06986061f, 0.07577044f, 0.02463782f, -0.01957865f, 
    0.06349869f, -0.10692099f, 0.14886397f, -0.02297631f, -0.09809794f, 0.08468761f, 0.06581308f, 0.15059938f, 
    0.10418736f, 0.14411211f, 0.05494701f, 0.08778210f, -0.39551857f, -0.27776852f, -0.22697338f, 0.04519014f, 
    0.16916259f, -0.01462976f, 0.08916791f, 0.17621706f, 0.03142420f, -0.09913755f, -0.04854053f, -0.06922660f, 
    0.17796677f, -0.01106852f, 0.02194190f, -0.07264921f, 0.07687274f, -0.02436332f, 0.07370381f, -0.00773116f, 
    -0.12601556f, 0.01454782f, 0.07730301f, 0.20483081f, 0.08608956f, 0.46041417f, -0.11293173f, 0.17877097f, 
    0.05096732f, -0.03233015f, 0.10054339f, -0.15070936f, -0.09045405f, -0.08584913f, 0.02621350f, -0.06855477f, 
    0.15365377f, 0.23977000f, 0.12232757f, 0.03937370f, 0.15892851f, -0.09214165f, -0.19120038f, -0.16398899f, 
    0.01674739f, 0.09913685f, 0.09773339f, 0.11318643f, 0.23715080f, 0.09054217f, -0.17202055f, 0.24265526f, 
    0.06717744f, -0.07330671f, 0.13893992f, 0.00113264f, 0.06870335f, 0.06972826f, -0.17035094f, 0.04312514f, 
    0.37889615f, -0.06961961f, 0.12202377f, -0.14700468f, -0.03258128f, 0.00260936f, 0.03169029f, -0.00327519f, 
    0.00367796f, 0.01822897f, 0.01030362f, -0.03166891f, -0.19945104f, -0.20840839f, 0.02195667f, 0.23727065f, 
    -0.01772351f, 0.10731381f, 0.01664235f, -0.04619277f, -0.00952465f, -0.01529004f, -0.12849966f, 0.11531442f, 
    0.23157018f, -0.08533099f, -0.02246831f, -0.00116369f, -0.04651799f, 0.03011826f, 0.06044356f, -0.03620622f, 
    0.00258262f, -0.12161615f, -0.01702844f, -0.12366659f, 0.12521744f, 0.07211673f, 0.27552179f, -0.21122158f, 
    -0.05758006f, 0.00626111f, -0.10767010f, -0.11300989f, -0.00074057f, 0.04718225f, -0.05570212f, -0.14578436f, 
    0.16596811f, 0.08949631f, -0.04047965f, 0.03255157f, 0.17146957f, -0.09715234f, 0.10779202f, -0.01153770f, 
    -0.01016024f, 0.07250002f, -0.06992649f, -0.06370309f, 0.05498260f, -0.25621974f, 0.21955290f, 0.19946630f, 
    0.02799919f, 0.05451240f, -0.02914901f, 0.08844543f, 0.18263339f, 0.10628299f, 0.07302269f, 0.02513500f, 
    -0.15211308f, 0.16514598f, 0.18480833f, 0.25827435f, -0.03489948f, -0.04061166f, 0.00260665f, 0.20075326f, 
    -0.02182876f, 0.06974049f, 0.08718301f, -0.03973632f, -0.55130726f, 0.05438108f, -0.25408891f, 0.48157656f, 
    -0.02913183f, 0.03113673f, 0.01420779f, -0.08904471f, 0.04808223f, 0.15363333f, 0.01467210f, 0.08429208f, 
    -0.41996184f, 0.09492459f, -0.06984986f, 0.11428908f, -0.02433776f, 0.09401333f, 0.00005790f, -0.10916695f, 
    -0.00831983f, -0.02040752f, 0.04870679f, -0.03848384f, -0.23503859f, 0.03007052f, 0.10973252f, 0.01831666f, 
    0.04453493f, -0.02261685f, -0.05424496f, -0.07164921f, 0.00373592f, 0.05795786f, -0.01441834f, 0.14151272f, 
    -0.11758281f, 0.11553616f, -0.27804703f, 0.00179273f, 0.04944279f, 0.02906119f, 0.08577903f, -0.07322364f, 
    -0.12462968f, -0.03290760f, -0.11107059f, -0.09779066f, 0.15672912f, -0.03950730f, -0.03542082f, -0.10263149f, 
    0.11150017f, -0.05435218f, -0.09451842f, -0.01946152f, 0.01633617f, 0.16433957f, -0.05519468f, -0.08591562f, 
    -0.03933904f, -0.04326406f, -0.06440922f, -0.06341095f, 0.04490385f, -0.00576407f, 0.03371494f, -0.06629899f, 
    -0.03096141f, -0.00489412f, -0.02652167f, -0.02496999f, -0.00964101f, 0.05748873f, -0.00123810f, -0.07167671f, 
    0.03449529f, 0.01810271f, 0.05430942f, 0.05760317f, 0.04427823f, -0.05805687f, -0.02828515f, 0.04503472f, 
    0.00970993f, -0.00017375f, -0.01295267f, 0.05911733f, 0.01988223f, -0.07325340f, 0.06191298f, -0.04448739f, 
    0.01817192f, -0.03617574f, -0.01861068f, -0.01451144f, 0.01885363f, -0.03305195f, -0.04198658f, 0.05170977f, 
    0.03637874f, -0.06114490f, -0.06517388f, -0.06076768f, -0.00832983f, -0.04596555f, -0.02671392f, -0.03731403f, 
    0.01878832f, 0.00200453f, -0.06667873f, 0.06009300f, 0.00661638f, 0.04162429f, -0.07342260f, -0.02035757f, 
    -0.01049025f, -0.04920652f, 0.03589616f, 0.03823574f, 0.03870687f, 0.06516095f, 0.00146006f, 0.03389754f, 
    -0.01806433f, -0.07686570f, -0.05668015f, 0.03813086f, -0.04914245f, -0.07724214f, -0.00878427f, -0.02230367f, 
    -0.07497385f, -0.03821165f, 0.03720620f, 0.03989850f, -0.05107079f, 0.05845869f, 0.04647242f, -0.01822773f, 
    -0.07577420f, 0.05076802f, 0.00450167f, -0.01257745f, 0.02408867f, 0.03846342f, 0.02353435f, -0.00641053f, 
    0.06101660f, 0.04944136f, -0.05586126f, 0.00742849f, -0.01858674f, -0.01316655f, 0.00022191f, -0.00526140f, 
    -0.02221324f, -0.02954710f, -0.03708929f, 0.00760982f, 0.01510415f, -0.07671042f, -0.02752218f, -0.00008696f, 
    -0.07066287f, -0.02711117f, -0.05887872f, 0.04553117f, -0.00170380f, 0.00088854f, 0.04944030f, -0.03129439f, 
    -0.00753339f, 0.01372257f, 0.03880477f, -0.01970893f, 0.04283738f, -0.00652631f, -0.06120621f, -0.06741952f, 
    -0.00956498f, 0.04958129f, 0.01214320f, -0.01263823f, -0.06450640f, -0.05331658f, -0.03109862f, -0.02887351f, 
    -0.02537641f, 0.05852718f, -0.06729586f, -0.05319040f, 0.00314040f, 0.01746225f, 0.04793925f, 0.01465545f, 
    0.04837746f, 0.05349009f, 0.00236500f, -0.02794311f, -0.06727520f, -0.05632268f, -0.05124999f, -0.01911562f, 
    -0.03344591f, -0.00521314f, 0.01990462f, 0.03393828f, 0.04188358f, -0.00673637f, -0.06487915f, -0.03704959f, 
    -0.02387921f, 0.03719459f, -0.06782535f, 0.03408868f, -0.05974161f, -0.03300270f, -0.04159176f, -0.05294276f, 
    -0.07301726f, 0.03802030f, -0.05868412f, -0.04763632f, -0.03312524f, -0.04028294f, -0.03875946f, 0.04483395f, 
    -0.03506904f, 0.02175874f, -0.03802332f, -0.02979026f, -0.03216701f, 0.06492773f, 0.05630333f, -0.04770584f, 
    -0.01803351f, 0.02015814f, 0.01281663f, -0.05452252f, -0.02064794f, 0.02369479f, 0.01587731f, -0.05781902f, 
    -0.04242373f, -0.02677575f, -0.03016034f, -0.05853242f, -0.04616604f, 0.00002788f, -0.01154466f, 0.05984721f, 
    0.01573082f, -0.11491485f, -0.21828297f, -0.15838839f, -0.08451045f, -0.12112640f, -0.09338404f, -0.09245773f, 
    0.12186097f, -0.01713569f, 0.07904147f, 0.16441201f, 0.05772348f, -0.11097755f, 0.03885199f, 0.03039024f, 
    0.17301524f, 0.16345724f, 0.10407987f, 0.03678893f, 0.05940038f, -0.01424467f, 0.00385074f, -0.00647796f, 
    -0.12144261f, -0.02773239f, 0.14673573f, 0.23495561f, 0.11926044f, 0.05708203f, 0.05997952f, 0.09789487f, 
    0.05752181f, -0.06998740f, 0.08533465f, 0.14823298f, 0.19770177f, 0.31189162f, 0.23296548f, 0.02894192f, 
    -0.02842613f, -0.01645518f, -0.07169683f, 0.02075673f, -0.00640630f, -0.13448431f, -0.08906305f, -0.20778260f, 
    0.09720996f, 0.08109615f, -0.17548794f, -0.09088074f, 0.10473280f, 0.00352367f, 0.00434023f, -0.07688500f, 
    0.13152981f, -0.05071710f, 0.03005262f, -0.09460334f, -0.25253916f, -0.37166762f, -0.32465169f, -0.21041809f, 
    0.08740562f, -0.02463119f, 0.03248299f, 0.08802222f, -0.02057978f, 0.06726963f, -0.26451746f, 0.13011821f, 
    -0.03790741f, -0.00574124f, 0.11587539f, 0.22183256f, 0.16871488f, 0.02976523f, 0.09998057f, 0.17422354f, 
    -0.09381676f, -0.02655306f, -0.08359796f, -0.02960659f, 0.26535177f, 0.10585149f, -0.09059469f, 0.18149859f, 
    0.05346761f, -0.03681090f, -0.04729456f, -0.00685765f, -0.02791953f, -0.00953850f, 0.03635907f, 0.12803134f, 
    -0.16675849f, -0.09837937f, -0.11477607f, 0.13272902f, 0.19547801f, 0.09914408f, -0.20255499f, 0.19350083f, 
    -0.01596562f, 0.06079173f, -0.08660919f, -0.05661461f, 0.08910013f, 0.19401048f, 0.25370011f, 0.27362412f, 
    0.02213839f, 0.03273145f, -0.04555377f, 0.07160348f, 0.05892420f, 0.13128288f, 0.03517675f, 0.07832259f, 
    0.00721367f, 0.03496819f, 0.24364707f, 0.17401569f, -0.14410666f, -0.08219446f, -0.13109501f, -0.00414122f, 
    0.02096951f, 0.08507828f, 0.04946455f, -0.07288297f, -0.36688319f, 0.00063689f, 0.23488002f, -0.09945989f, 
    -0.09861754f, 0.08252580f, -0.18335253f, 0.08153022f, 0.07574044f, 0.02920695f, -0.02221483f, 0.20537943f, 
    -0.40029451f, -0.20602469f, -0.17570181f, -0.29702860f, -0.23633015f, -0.04218522f, -0.15973593f, 0.01723101f, 
    -0.10197020f, -0.05705194f, -0.16503699f, -0.00302496f, -0.23235303f, -0.04927029f, -0.12191137f, -0.17480780f, 
    0.07225738f, 0.06983119f, 0.04596740f, 0.09133445f, 0.18099156f, 0.04971615f, 0.00597669f, -0.01133715f, 
    -0.06075708f, 0.00291404f, -0.01015712f, 0.08439264f, 0.02972340f, 0.05930806f, -0.08615311f, 0.20894799f, 
    0.08493154f, 0.12877831f, -0.11559169f, -0.03726291f, 0.13298692f, -0.11459786f, 0.06112919f, 0.20781055f, 
    -0.13846730f, -0.07455391f, -0.16147538f, -0.11092518f, 0.13233502f, 0.10195781f, 0.03119551f, -0.02712963f, 
    -0.02621415f, -0.09530410f, 0.36614484f, 0.13153817f, -0.05440343f, -0.04567302f, -0.19449204f, -0.05059221f, 
    -0.03895649f, -0.05925338f, -0.19544969f, -0.00212281f, -0.14508288f, 0.06096531f, -0.07504099f, -0.05812347f, 
    0.16495547f, 0.13265975f, 0.13435516f, 0.14147769f, -0.11687930f, 0.25023150f, 0.29306251f, 0.08102986f, 
    0.38584641f, 0.17458281f, 0.11019304f, 0.16769247f, 0.01330895f, -0.02152049f, -0.02709267f, -0.20968457f, 
    -0.10161870f, 0.10793990f, -0.04994303f, -0.15344216f, -0.26409790f, 0.11000481f, -0.01502535f, -0.08699842f, 
    0.20725547f, 0.02519424f, -0.06766886f, -0.10514429f, 0.02205396f, 0.08979816f, -0.03071631f, 0.20849425f, 
    0.36552107f, 0.01270117f, 0.37546214f, 0.39154589f, -0.21028119f, -0.07944392f, -0.05818962f, -0.19030227f, 
    -0.06510346f, -0.01968173f, -0.01215183f, -0.04773567f, 0.11766931f, -0.13615084f, 0.01033246f, -0.04176015f, 
    -0.06464265f, -0.19948332f, -0.12457126f, -0.10205071f, -0.03157935f, -0.10266422f, -0.08059772f, 0.16864103f, 
    -0.00617632f, -0.04972976f, 0.24953283f, -0.01947183f, -0.01400284f, 0.00229107f, 0.09224986f, 0.01775051f, 
    0.05062166f, 0.20106748f, 0.15460606f, 0.18404141f, 0.22349949f, 0.25514224f, 0.02400364f, 0.17190617f, 
    0.22017568f, 0.16424960f, -0.17134733f, 0.03615690f, 0.04965632f, -0.03342253f, 0.01790389f, 0.02086224f, 
    -0.40555310f, -0.24480319f, 0.03961390f, -0.20020060f, -0.11860705f, 0.04991484f, -0.08370750f, 0.03847761f, 
    -0.07660249f, 0.00931363f, 0.06466452f, -0.04821313f, 0.15227565f, -0.03894908f, -0.23516054f, 0.00749259f, 
    0.10920692f, 0.24312778f, 0.07793738f, 0.11973152f, -0.05206450f, -0.04201800f, -0.03629218f, 0.16239923f, 
    0.05932427f, 0.14641848f, -0.09932722f, 0.17215045f, 0.25537738f, 0.17471962f, 0.31750470f, 0.21082085f, 
    -0.05873135f, 0.08085056f, 0.02118696f, 0.07836999f, -0.08094056f, 0.45435229f, -0.40779841f, -0.10460272f, 
    0.08982506f, 0.00569028f, 0.21043676f, 0.10280571f, -0.03686177f, -0.08441757f, -0.10559423f, 0.10414653f, 
    -0.10539500f, 0.26230654f, 0.08068045f, -0.10614356f, -0.04719166f, -0.07894923f, 0.10256752f, -0.05038043f, 
    0.00294643f, 0.04851975f, 0.01737686f, 0.23928611f, -0.11557390f, -0.12013738f, -0.27878749f, -0.16249420f, 
    -0.21683642f, 0.04211098f, -0.13717753f, -0.28757900f, 0.12752213f, 0.08471636f, 0.17452411f, -0.01306124f, 
    -0.07939322f, -0.00203144f, -0.12348262f, -0.14941834f, 0.04641168f, 0.13653135f, 0.17298123f, -0.13038629f, 
    -0.02066150f, -0.03090927f, 0.12250516f, 0.12471639f, -0.03073831f, 0.17692237f, 0.34282628f, -0.09469297f, 
    -0.09124883f, -0.03102174f, 0.02359000f, -0.05693822f, -0.03599367f, -0.08439121f, 0.06056232f, -0.01931882f, 
    -0.21496587f, -0.14664771f, -0.64295393f, 0.20353489f, -0.07595605f, -0.11096850f, -0.11883187f, -0.13310313f, 
    0.05144362f, 0.14456847f, 0.06431525f, -0.08908226f, -0.10354175f, -0.03999342f, -0.01525708f, -0.01463976f, 
    -0.10613912f, -0.07821250f, -0.16382273f, -0.11622263f, 0.20517337f, 0.12346289f, -0.18079141f, 0.04434394f, 
    -0.25881708f, 0.04668398f, -0.03251018f, -0.19573916f, 0.02474248f, 0.12114330f, 0.21304770f, 0.11299682f, 
    -0.18877192f, -0.03474323f, 0.09917380f, 0.06550878f, 0.28833815f, 0.14008382f, -0.20280080f, 0.25842899f, 
    -0.02065752f, 0.20633164f, -0.04565864f, 0.01154757f, -0.22504324f, 0.29129338f, 0.16914959f, -0.12963127f, 
    -0.59519684f, -0.25173712f, 0.11751983f, -0.14848183f, 0.32405183f, 0.10583161f, -0.00088575f, 0.30167353f, 
    -0.08513516f, -0.07063664f, -0.02872695f, -0.12062202f, -0.48866493f, 0.02360282f, 0.16513398f, 0.13798687f, 
    -0.03767965f, -0.19330955f, -0.20634378f, 0.00354645f, 0.02930325f, -0.06762014f, 0.15688197f, -0.12279522f, 
    -0.15678281f, 0.01131962f, -0.07480134f, 0.21444653f, 0.14214750f, 0.09763917f, 0.08919905f, -0.00753461f, 
    -0.23971483f, 0.03388298f, 0.02939320f, -0.22016744f, -0.02640346f, -0.06300597f, 0.17908576f, -0.13890085f, 
    0.04266071f, 0.20071062f, 0.16344088f, 0.32717544f, 0.01531012f, 0.01452838f, 0.05723788f, -0.06943073f, 
    0.05191489f, -0.14288369f, -0.16968639f, 0.22593525f, -0.04153066f, 0.20408683f, 0.15149942f, 0.10121353f, 
    -0.10199628f, -0.09763286f, -0.09394112f, -0.11246493f, 0.28976509f, 0.29542059f, 0.06568451f, -0.00300265f, 
    0.06442413f, -0.08120620f, -0.15127465f, 0.02298313f, 0.04181943f, 0.03994574f, 0.21876642f, 0.06365576f, 
    0.34544688f, 0.09779447f, 0.07342144f, -0.22909424f, 0.10844422f, -0.00128501f, -0.07948604f, -0.07855152f, 
    0.18730740f, -0.05045230f, -0.00813838f, 0.03210634f, 0.29649934f, 0.25276554f, 0.23533496f, -0.02353115f, 
    -0.18526436f, 0.05095350f, 0.05282642f, -0.20956208f, 0.18346962f, 0.10880183f, 0.11499573f, 0.04499834f, 
    -0.29873931f, 0.06310410f, 0.35490203f, -0.08460533f, -0.07112646f, 0.03276087f, -0.06753815f, -0.30247495f, 
    -0.08748394f, -0.13195871f, 0.05428908f, -0.06853651f, 0.29683354f, 0.09939722f, 0.26275256f, 0.27488974f, 
    0.20717283f, -0.35793620f, 0.03569010f, -0.03276773f, 0.11284678f, -0.12343339f, -0.17878133f, 0.12251808f, 
    -0.26010877f, 0.16499525f, 0.22687189f, -0.32400653f, -0.19188046f, 0.14182433f, 0.02942106f, -0.08129554f, 
    -0.30027542f, -0.17379494f, -0.28907743f, -0.46499059f, 0.28239095f, 0.30770537f, 0.44177693f, 0.18429799f, 
    0.03470314f, -0.03141344f, 0.01329621f, 0.14280325f, -0.12710470f, 0.11660311f, -0.06557304f, -0.01676911f, 
    -0.02195439f, 0.22743304f, 0.10516480f, 0.05029641f, -0.15652445f, -0.12668140f, -0.01969734f, -0.01627344f, 
    0.05538417f, -0.01759963f, -0.11074056f, -0.13706188f, 0.18248002f, -0.05760226f, 0.01818690f, 0.03322400f, 
    -0.10234027f, -0.07474028f, 0.06008883f, 0.13557656f, -0.04377965f, 0.33487341f, 0.02865220f, -0.00000998f, 
    0.28070667f, -0.17240906f, -0.09927372f, -0.02994156f, 0.05170227f, -0.11948754f, 0.14671816f, 0.17713757f, 
    0.04712009f, -0.03000039f, -0.12070540f, -0.21240230f, -0.43416268f, -0.02287431f, 0.27502811f, 0.35689810f, 
    0.04441325f, 0.02866175f, 0.23691423f, 0.08409154f, 0.01788823f, -0.10003527f, 0.08294261f, 0.11875501f, 
    -0.12425377f, 0.17782238f, 0.02915869f, 0.15568757f, -0.17911416f, -0.13217300f, -0.10238221f, 0.01994965f, 
    -0.04054016f, -0.04293599f, -0.03202496f, 0.01792683f, 0.15877214f, 0.12436624f, 0.10003626f, -0.21427149f, 
    -0.08443988f, -0.14346652f, 0.00450219f, -0.04678732f, 0.18100999f, 0.01071539f, -0.06001863f, 0.02715177f, 
    0.01818720f, -0.00600252f, -0.02312944f, -0.08319059f, 0.04136348f, -0.02873235f, 0.00318122f, 0.02545949f, 
    0.13099527f, 0.17002048f, 0.16758563f, 0.18567048f, 0.19591989f, -0.07597990f, 0.00050340f, 0.28668681f, 
    0.15921156f, 0.02823636f, 0.10047168f, 0.06822746f, -0.01781037f, -0.03620068f, 0.01989495f, 0.11789709f, 
    -0.33755270f, 0.09954523f, 0.23784970f, -0.07544865f, 0.08632024f, 0.14297043f, 0.15553270f, -0.03270260f, 
    -0.15622175f, 0.09171127f, 0.11139205f, 0.03500286f, -0.25888968f, -0.25494012f, 0.11311394f, 0.08942688f, 
    0.11502412f, 0.15223128f, 0.28704208f, 0.15956680f, -0.01602101f, -0.04774207f, 0.10264806f, 0.09873932f, 
    -0.08745361f, -0.23353544f, -0.08084791f, 0.05250128f, 0.05165995f, 0.10581915f, 0.05481147f, 0.17802319f, 
    0.05514198f, 0.13076986f, 0.09855599f, 0.10911058f, -0.02955866f, 0.12618516f, -0.32601222f, -0.22846328f, 
    0.19591957f, 0.09084538f, -0.15309606f, 0.15040982f, 0.00228347f, -0.07811982f, -0.08623450f, -0.14113215f, 
    0.38192555f, 0.20310381f, -0.03207618f, -0.13463992f, -0.02744154f, -0.08355850f, 0.01847956f, -0.07113953f, 
    0.00672720f, 0.11259667f, 0.23716117f, 0.01073067f, -0.04180934f, -0.10582352f, -0.25676569f, -0.24119534f, 
    -0.11092350f, 0.00480805f, -0.00909864f, -0.06113578f, 0.13215628f, 0.13946860f, 0.09494331f, 0.04892351f, 
    0.09599601f, -0.11384035f, -0.09131246f, -0.15098880f, 0.07248590f, 0.04330798f, 0.04632965f, -0.13145298f, 
    0.03945796f, 0.18396030f, 0.09124846f, 0.12234292f, 0.06632794f, -0.04220045f, 0.00281261f, -0.03195853f, 
    -0.18687861f, 0.07374031f, 0.00836980f, -0.12032259f, 0.01719468f, 0.04035714f, -0.07212058f, -0.00729759f, 
    0.05283879f, -0.01957178f, -0.03290382f, -0.04916907f, -0.07118948f, 0.02429431f, -0.06804275f, -0.02696935f, 
    -0.02644289f, -0.06033094f, 0.02573895f, -0.04046114f, -0.01362659f, -0.05007668f, 0.00490084f, 0.00293404f, 
    0.04847160f, -0.01876820f, 0.05157354f, -0.08330075f, -0.08060505f, -0.03470439f, 0.05379305f, 0.01111360f, 
    -0.07361360f, -0.04484207f, -0.05910147f, 0.01251658f, -0.00019608f, 0.02765378f, -0.06357774f, 0.01354888f, 
    0.01388103f, 0.03455354f, -0.07592655f, -0.00421177f, -0.07326012f, 0.05181094f, 0.03300124f, -0.05156063f, 
    -0.01251852f, -0.04140452f, -0.05911162f, 0.01139808f, 0.00285795f, -0.02964443f, -0.07422318f, -0.05900050f, 
    -0.00157346f, -0.01984286f, -0.07856708f, -0.07572872f, 0.01287638f, 0.05473787f, -0.03756959f, -0.06667617f, 
    0.01297469f, -0.03507582f, 0.03690632f, 0.05724936f, -0.06855309f, 0.02683096f, 0.03356989f, -0.08006999f, 
    -0.00012595f, 0.03648319f, -0.04283300f, -0.02718864f, -0.06033905f, -0.06331182f, -0.00952832f, -0.05082393f, 
    -0.06633783f, -0.07866993f, 0.03008194f, 0.02350897f, 0.04605498f, -0.06268218f, -0.06472408f, -0.02065029f, 
    0.05714836f, 0.05690514f, 0.04030717f, 0.05857672f, 0.01827812f, 0.05427238f, 0.05717360f, -0.07411685f, 
    0.02795419f, 0.03292820f, -0.03963492f, 0.04972839f, 0.02545289f, 0.03229222f, -0.01567809f, -0.00786753f, 
    -0.01700070f, -0.05507420f, 0.01067965f, 0.02355866f, -0.08148938f, -0.01172564f, -0.01853948f, 0.04482304f, 
    -0.06561587f, 0.00469482f, 0.01731466f, -0.04268398f, -0.01031788f, -0.03491420f, -0.00684793f, -0.05678520f, 
    -0.04003345f, -0.04495897f, -0.04536081f, -0.06889943f, 0.01995879f, 0.04125434f, 0.00343815f, -0.04756020f, 
    0.02709419f, -0.02955075f, 0.04182770f, 0.01148899f, -0.00879941f, -0.07905827f, -0.04523259f, -0.02768693f, 
    -0.05819637f, -0.02580605f, 0.02799517f, -0.06737150f, -0.00191544f, 0.03025051f, -0.01821358f, 0.02328456f, 
    -0.02582110f, -0.07315387f, 0.06263302f, -0.05777718f, -0.05761632f, -0.00455703f, 0.04576566f, -0.02158849f, 
    0.02640200f, 0.03916934f, 0.00925323f, 0.00114462f, 0.02890952f, -0.00910857f, 0.00212577f, -0.04525401f, 
    0.02419654f, -0.00691892f, -0.05174840f, 0.00165784f, 0.04126901f, -0.07782006f, 0.04686375f, 0.02376614f, 
    0.01617715f, -0.01676682f, -0.02039645f, -0.04654266f, -0.05473631f, -0.04581803f, -0.01635362f, 0.00405426f, 
    -0.02105067f, 0.01170853f, -0.00214316f, 0.05054803f, -0.01868663f, 0.04069803f, 0.02572476f, -0.06334556f, 
    -0.04519807f, -0.02336591f, 0.05438484f, 0.04070130f, 0.04103171f, 0.04770934f, 0.03844343f, 0.00155111f, 
    0.02079828f, 0.01145993f, -0.01440942f, 0.04773997f, -0.07483876f, 0.00420946f, 0.03019698f, 0.04218750f, 
    -0.03578070f, -0.05801966f, -0.12475958f, 0.04030176f, -0.01705100f, 0.00844338f, 0.09345993f, -0.09931095f, 
    0.02813033f, -0.04833540f, 0.15008023f, 0.01718532f, 0.01466958f, 0.38482541f, -0.07170617f, -0.20752943f, 
    -0.15761276f, -0.11674868f, -0.06799009f, -0.02808000f, 0.12175766f, 0.06046102f, 0.12379096f, 0.11420090f, 
    -0.15939537f, 0.36885074f, -0.00225237f, -0.06786856f, -0.01701338f, 0.02503513f, -0.02024785f, 0.08890311f, 
    0.09651377f, -0.08009880f, 0.06967905f, -0.02208876f, 0.36645433f, -0.03226211f, -0.35577869f, -0.43752423f, 
    0.02850172f, 0.02211507f, 0.02566404f, 0.12844422f, 0.16704999f, 0.00715693f, 0.06337150f, 0.01378960f, 
    0.01403930f, -0.34785855f, -0.24881282f, -0.16886698f, 0.05894732f, 0.07390869f, 0.11574086f, 0.00380032f, 
    0.01358427f, -0.02754878f, -0.06320124f, -0.11370175f, -0.02499471f, -0.07901640f, 0.12566321f, 0.30895621f, 
    -0.02730454f, -0.06131649f, -0.10481569f, -0.00139775f, 0.14389774f, 0.08561449f, 0.19261643f, 0.19987221f, 
    -0.07173587f, -0.01401578f, -0.20683339f, -0.07423530f, -0.02057801f, 0.02824498f, 0.05679124f, -0.13896854f, 
    0.02657083f, -0.04518255f, -0.02428010f, 0.09934814f, -0.58401132f, 0.19416775f, -0.00508426f, -0.19201581f, 
    -0.04977184f, 0.09571151f, 0.17954344f, -0.13758251f, 0.00687622f, -0.00736407f, -0.16363825f, -0.05867481f, 
    0.57718062f, 0.16609070f, -0.42498162f, 0.05674945f, -0.00264425f, -0.08455250f, 0.24589123f, 0.10168482f, 
    -0.01234028f, 0.03568023f, 0.06838267f, 0.07900462f, 0.29567128f, 0.15529726f, 0.04732480f, -0.10443053f, 
    0.04360441f, 0.00364068f, -0.03876529f, 0.01291684f, 0.00445191f, -0.02174781f, -0.03960506f, 0.04151294f, 
    0.08157612f, 0.23015589f, 0.18305181f, -0.13101459f, -0.09159672f, 0.06068870f, 0.01432047f, -0.04898884f, 
    0.07209817f, -0.09851745f, 0.01512026f, 0.02640525f, 0.11556932f, -0.16137733f, 0.44051430f, 0.13712567f, 
    -0.04953977f, 0.02063107f, 0.26047540f, -0.06847746f, 0.16137668f, 0.11294008f, 0.07673068f, 0.06535720f, 
    -0.28845412f, -0.00522228f, 0.04280864f, 0.34995645f, -0.00183678f, -0.00724348f, -0.12563373f, -0.04155116f, 
    0.00439221f, -0.04604885f, -0.06709370f, -0.05218555f, 0.21612410f, 0.01780110f, 0.21257056f, 0.13319521f, 
    -0.04682469f, -0.06414407f, -0.16133083f, 0.01728285f, 0.02776692f, -0.05607830f, -0.05518867f, 0.12646760f, 
    -0.15317518f, 0.03391761f, 0.01791184f, -0.00820502f, 0.05243253f, -0.04065175f, 0.13931435f, 0.02047786f, 
    -0.11290731f, -0.07174701f, -0.04611579f, 0.04859986f, -0.27373365f, 0.12852220f, -0.27365616f, 0.15178950f, 
    0.20526609f, -0.06394471f, 0.03411693f, 0.00112490f, -0.02750642f, -0.04471153f, -0.17854972f, 0.07273217f, 
    -0.06200337f, -0.02785683f, -0.00136030f, 0.03975016f, 0.02270951f, 0.01590841f, -0.05258504f, -0.02903110f, 
    -0.04069172f, -0.00250616f, -0.05397891f, 0.00812062f, 0.01727507f, -0.00477498f, -0.02722794f, -0.06182737f, 
    0.04287676f, -0.07119798f, 0.02134146f, -0.02579406f, -0.00347929f, -0.03364288f, 0.00498393f, 0.00256558f, 
    0.05093137f, -0.05057849f, -0.04775058f, 0.00497279f, 0.02882199f, -0.07022645f, 0.05041710f, 0.04765978f, 
    0.00064889f, -0.08172836f, -0.02469108f, 0.05516627f, -0.00425773f, -0.01428297f, -0.03389632f, -0.07380936f, 
    -0.06811579f, -0.06035222f, -0.05869453f, 0.06043348f, 0.01610400f, -0.02539566f, -0.05112720f, -0.04372700f, 
    -0.04522692f, 0.05341764f, -0.00377909f, 0.04443599f, -0.05096862f, 0.01584608f, -0.03796551f, -0.01276537f, 
    0.02438032f, 0.02774075f, 0.00819602f, -0.04214979f, 0.03433774f, -0.08896729f, 0.03498085f, -0.05695095f, 
    -0.00337469f, -0.01459803f, -0.06914806f, -0.03254143f, -0.07246539f, 0.03660202f, 0.05789229f, 0.05780654f, 
    0.00614147f, 0.04998339f, -0.03194279f, -0.05925503f, -0.01573875f, -0.01577685f, 0.05623783f, -0.02526021f, 
    -0.02447215f, -0.01669390f, -0.00820879f, 0.05850900f, 0.03894444f, -0.01289291f, 0.05156104f, 0.02672477f, 
    0.00439517f, 0.04139919f, 0.02637886f, 0.04697647f, -0.01372355f, 0.04536316f, -0.01935140f, -0.07043628f, 
    0.03293142f, 0.02236191f, -0.05577341f, -0.02854381f, 0.03461174f, -0.05942092f, -0.03275988f, 0.05118005f, 
    0.05905579f, -0.03995637f, -0.05503188f, 0.00395105f, -0.01779133f, 0.00102195f, 0.04288193f, -0.01207006f, 
    0.01177873f, -0.06707271f, -0.04439807f, 0.00710207f, 0.05232365f, 0.02099925f, -0.02928457f, -0.03906685f, 
    0.01799103f, -0.01733086f, 0.00124026f, -0.02372221f, -0.05879444f, -0.06694981f, -0.03640983f, -0.03415216f, 
    0.01788589f, -0.01159509f, 0.06159951f, -0.04155440f, -0.02273388f, 0.04771599f, 0.02562251f, 0.02558628f, 
    -0.07518889f, 0.03241222f, 0.00534812f, 0.04367106f, 0.06026439f, -0.02045964f, 0.03353290f, 0.03309453f, 
    -0.01219557f, -0.05356088f, 0.04172227f, 0.03448329f, 0.03638649f, 0.03387906f, 0.00650760f, -0.00806140f, 
    -0.01291218f, -0.02280052f, 0.06696408f, -0.06845257f, 0.04526195f, 0.05338872f, 0.00970508f, 0.04498940f, 
    0.01695996f, -0.04671603f, -0.01132508f, -0.00717223f, 0.03412947f, 0.01308740f, -0.00833343f, -0.07134326f, 
    -0.01924117f, -0.05967581f, 0.04256867f, -0.04301424f, -0.07593492f, 0.05503898f, 0.05271688f, -0.04860662f, 
    0.01884463f, 0.01887090f, 0.00770834f, 0.02177053f, -0.02055619f, 0.00690650f, -0.02547990f, 0.05353064f, 
    -0.08303734f, -0.01699971f, -0.03455892f, 0.00855918f, -0.06555019f, 0.05777844f, -0.04635569f, -0.00701453f, 
    0.01554806f, 0.01929282f, -0.15985754f, -0.08223689f, -0.06606580f, -0.02188855f, 0.15059659f, -0.03341398f, 
    0.12826006f, 0.01864258f, -0.01480113f, -0.17591691f, -0.03540892f, 0.24510689f, 0.01936886f, 0.01356306f, 
    0.08634319f, 0.17557397f, -0.04494174f, -0.18369943f, 0.14322115f, 0.00935778f, 0.05236086f, 0.03826306f, 
    -0.02355723f, 0.22989249f, 0.33199272f, 0.00400338f, -0.00476113f, -0.07865576f, -0.03888453f, 0.06668781f, 
    0.07386339f, -0.12412185f, -0.04174109f, -0.02454807f, 0.22825463f, -0.04120589f, -0.26361281f, 0.03271123f, 
    0.09857470f, 0.16218913f, 0.01865006f, 0.01910618f, 0.12870416f, -0.04794864f, -0.02264575f, -0.06835052f, 
    -0.37967968f, -0.41559851f, -0.07130142f, 0.05172465f, 0.12954184f, 0.05658168f, 0.09954803f, 0.12831220f, 
    0.06804392f, -0.04400093f, -0.04558231f, 0.00182250f, -0.15625891f, -0.13852762f, 0.06231378f, 0.05974897f, 
    -0.00472204f, 0.00379729f, -0.16348828f, 0.00576278f, 0.10622714f, -0.04681480f, -0.03743770f, 0.12485899f, 
    -0.07502301f, -0.19418271f, -0.07990676f, 0.02365228f, 0.04456088f, 0.04821126f, 0.16248079f, -0.07507539f, 
    -0.05882967f, -0.07647444f, -0.05622719f, 0.10467033f, 0.04549849f, -0.14115877f, -0.00946170f, 0.16064560f, 
    0.03294939f, -0.05446895f, 0.05333116f, 0.01385540f, 0.02255901f, 0.01654848f, 0.08307636f, -0.00649752f, 
    0.25902775f, 0.26933640f, -0.31118488f, 0.16236855f, 0.09085290f, 0.10305756f, 0.17556657f, 0.04463821f, 
    -0.05385112f, 0.01515748f, -0.19617693f, 0.05704219f, -0.03141138f, 0.04354301f, 0.41740564f, -0.09331182f, 
    0.14985925f, 0.10313815f, 0.14599773f, 0.08652824f, 0.07562858f, 0.10152528f, 0.09493985f, 0.01667703f, 
    0.02263742f, 0.20075242f, 0.18482003f, 0.16265579f, -0.09617942f, 0.06539509f, -0.06374543f, -0.09502338f, 
    0.06939672f, 0.10153704f, 0.05184826f, 0.06269012f, -0.53092474f, -0.01251895f, 0.34177983f, 0.07938249f, 
    0.14346120f, -0.04012961f, -0.26152861f, -0.07457558f, -0.01668946f, -0.02747030f, -0.18149911f, 0.10067882f, 
    -0.22481960f, -0.10348931f, -0.03074347f, 0.05912025f, 0.02933411f, -0.04593800f, -0.01772844f, -0.06748635f, 
    -0.00392333f, -0.00537924f, 0.09962352f, 0.05096557f, -0.03448928f, 0.09995306f, 0.17618199f, 0.03216357f, 
    -0.00411381f, -0.11110877f, -0.03132828f, -0.01561152f, 0.11250389f, 0.05145986f, -0.01687703f, 0.12422546f, 
    0.00174585f, -0.00135738f, -0.07516968f, 0.02466926f, -0.05985525f, 0.19832131f, 0.22207305f, 0.02914388f, 
    0.06588861f, 0.03209227f, -0.04235549f, 0.12355250f, -0.20650625f, -0.13539806f, -0.33397692f, 0.37795526f, 
    -0.07058007f, 0.15724847f, 0.07014176f, 0.02300755f, -0.08851930f, 0.15119791f, 0.01142787f, -0.00751706f, 
    0.03799507f, 0.06337544f, -0.30251989f, 0.03068580f, 0.06061656f, -0.01837387f, -0.02556282f, -0.16240251f, 
    0.14469035f, 0.08378790f, 0.13272767f, 0.32108986f, 0.34326276f, -0.04510095f, 0.43505353f, 0.08013605f, 
    -0.18196444f, -0.06396917f, -0.21711898f, 0.06674143f, 0.14222209f, -0.01305888f, -0.12937264f, 0.11706675f, 
    -0.09306989f, -0.05030268f, 0.18972224f, 0.19993642f, -0.06217770f, 0.19819359f, 0.28341848f, 0.24651067f, 
    0.23600429f, 0.03347642f, 0.14710568f, 0.34117600f, -0.02641231f, 0.05621111f, 0.23074594f, -0.13586424f, 
    -0.06975072f, 0.16815938f, -0.05095077f, 0.04679915f, -0.10140193f, 0.04406255f, 0.21058309f, -0.17094499f, 
    -0.32906327f, 0.16699556f, -0.13781328f, -0.05794683f, 0.18032002f, 0.03973246f, -0.11041933f, -0.12413383f, 
    -0.05812874f, -0.01720353f, -0.11796160f, -0.26419327f, 0.04749439f, 0.22391704f, -0.11416572f, -0.25066265f, 
    0.02382079f, 0.01862860f, -0.05238942f, 0.03872734f, -0.03863007f, 0.07425120f, 0.19295499f, -0.03538923f, 
    -0.13356362f, -0.02160885f, -0.07140312f, 0.18673848f, 0.08056546f, 0.06219715f, -0.02325853f, -0.12278797f, 
    -0.19580278f, -0.22633922f, -0.09635528f, -0.29424345f, -0.12111461f, 0.01921170f, -0.06248745f, 0.06043452f, 
    0.04959610f, 0.08474965f, 0.15642323f, 0.14763045f, -0.08317075f, -0.02299326f, 0.02360782f, -0.04584903f, 
    -0.12844580f, 0.09142298f, -0.13600656f, -0.24315076f, 0.11715014f, 0.10839778f, -0.07679158f, -0.02809534f, 
    0.21272370f, -0.11051464f, -0.11384256f, -0.10567786f, 0.07874937f, 0.20629911f, -0.13695128f, -0.03283544f, 
    -0.00766915f, -0.15152243f, 0.09445515f, 0.11314364f, 0.11795124f, 0.04426328f, 0.18782851f, -0.07149089f, 
    0.19776535f, 0.02668286f, 0.06147645f, -0.12800509f, 0.05789712f, 0.04380808f, 0.04674596f, -0.06494910f, 
    0.08031882f, -0.11972363f, -0.18132842f, -0.11112472f, 0.41618687f, -0.28318983f, 0.60495871f, 0.10372742f, 
    -0.04612848f, 0.03642396f, -0.16017501f, 0.13442323f, 0.33033147f, 0.05268283f, 0.22283415f, 0.18920083f, 
    0.16254343f, -0.21442784f, -0.17080876f, -0.00919094f, 0.02790128f, -0.03234187f, -0.03676012f, -0.04193770f, 
    -0.02542205f, 0.05720516f, 0.03056699f, -0.09039810f, 0.03448153f, 0.14875084f, -0.02440560f, -0.12910746f, 
    -0.02171304f, -0.14929052f, 0.00113379f, -0.03592752f, 0.01289731f, 0.07340602f, 0.04868291f, 0.11514930f, 
    -0.11105056f, -0.21738520f, 0.14292686f, 0.02571507f, 0.02438077f, -0.03904269f, -0.18032901f, 0.07235974f, 
    -0.23432229f, -0.21920548f, -0.27599072f, -0.47561511f, 0.00659919f, -0.10202409f, 0.02651663f, 0.17522272f, 
    0.13047506f, -0.03207528f, -0.00637982f, 0.03282146f, -0.04810884f, -0.09017289f, 0.05957136f, 0.04421027f, 
    0.04866464f, -0.01577801f, 0.06862644f, -0.03853083f, 0.03290874f, -0.03037845f, -0.03309090f, 0.04996391f, 
    -0.06420304f, -0.02961203f, 0.05692744f, -0.01847734f, -0.03059727f, -0.01182096f, 0.06092045f, -0.05431871f, 
    0.03556075f, 0.04359240f, 0.01364808f, 0.00412705f, 0.02191160f, -0.03925447f, -0.05485221f, 0.05143883f, 
    0.00992774f, -0.00839486f, -0.02499094f, -0.00900734f, 0.02591712f, -0.02814795f, -0.07436795f, -0.02445220f, 
    -0.00152050f, -0.01410301f, -0.01087307f, -0.05609379f, 0.03342193f, 0.00710397f, -0.00051608f, 0.02297199f, 
    0.01582671f, -0.04842915f, -0.06278038f, 0.03735364f, 0.02272250f, -0.08243830f, -0.04926812f, -0.00267706f, 
    -0.06315991f, 0.06055811f, 0.04326758f, -0.02463669f, -0.01434919f, -0.06791744f, -0.01255702f, 0.04651396f, 
    -0.00050342f, -0.06312310f, 0.03136267f, 0.02745065f, -0.02224853f, 0.01738804f, 0.04090162f, -0.01770321f, 
    -0.02904951f, -0.01736417f, -0.06783821f, 0.02443248f, 0.04660567f, -0.06488851f, -0.05190268f, -0.04610320f, 
    0.01007066f, -0.03677790f, 0.02724241f, 0.05114574f, 0.03159034f, -0.07332221f, -0.05943989f, 0.05658050f, 
    0.00313593f, -0.05719471f, -0.07763978f, 0.01359228f, 0.02101659f, 0.00865420f, 0.01593166f, 0.02217146f, 
    -0.03951539f, -0.02555377f, -0.01616539f, -0.06864490f, -0.03929507f, -0.00056541f, -0.03876958f, -0.05573362f, 
    -0.05892844f, -0.07354024f, 0.03112119f, 0.05654646f, -0.02901581f, -0.03401515f, -0.06086773f, 0.03336706f, 
    -0.03882017f, -0.02399027f, 0.02515868f, 0.06521351f, -0.00404780f, 0.02126370f, 0.02983021f, -0.02283579f, 
    0.03780943f, -0.06458055f, 0.04034627f, 0.02760604f, 0.01951224f, 0.06128943f, -0.06164533f, -0.00611910f, 
    -0.06947190f, -0.04863146f, -0.00748833f, 0.01301044f, -0.01197673f, 0.05334092f, 0.05648268f, 0.05002434f, 
    -0.06758696f, -0.03475716f, 0.05240353f, -0.06413280f, -0.02167948f, 0.01971233f, -0.01722071f, -0.03654793f, 
    0.03139763f, 0.04575417f, -0.04132176f, -0.00086640f, -0.00640578f, -0.01186200f, 0.03393988f, -0.00823241f, 
    -0.01226803f, 0.04458006f, -0.06333295f, -0.07399917f, -0.00742080f, 0.01775317f, 0.04469938f, 0.05652603f, 
    0.00703816f, 0.02055736f, -0.04414153f, 0.02186410f, -0.03455941f, -0.05664602f, -0.03100709f, -0.05923096f, 
    0.03158756f, 0.00169137f, -0.04941056f, 0.05522763f, 0.05058765f, 0.03707563f, 0.06243565f, -0.07887463f, 
    -0.04709138f, 0.00626233f, 0.00207445f, 0.04262230f, -0.07116432f, -0.06866201f, -0.02281918f, 0.04294501f, 
    0.06305373f, -0.04294779f, -0.01789028f, 0.01530124f, -0.06356654f, -0.05936407f, 0.03041397f, 0.04270742f, 
    -0.05725690f, 0.00817675f, -0.04899352f, -0.02124256f, -0.01680444f, 0.04556070f, -0.02303347f, 0.02417017f, 
    0.23726209f, 0.02376583f, -0.00912650f, 0.01821091f, 0.07580239f, -0.00705627f, 0.01097237f, -0.05971724f, 
    0.09386747f, -0.05615995f, 0.14081347f, -0.02080922f, -0.23205757f, -0.06167537f, -0.07420519f, -0.37402487f, 
    -0.16768290f, -0.08627105f, -0.03960462f, 0.11741034f, -0.00838018f, 0.05879016f, 0.03138264f, 0.06845143f, 
    -0.37181720f, 0.17433856f, -0.13067389f, -0.11675992f, -0.07317044f, 0.02439121f, -0.09688047f, -0.03358511f, 
    0.09147072f, -0.04672707f, 0.06765411f, 0.09678189f, 0.41976970f, 0.17370541f, -0.23595431f, -0.64678556f, 
    0.17825104f, 0.12463304f, 0.00971384f, 0.11265999f, 0.10818397f, -0.06250592f, -0.01471663f, 0.03838447f, 
    0.42600816f, -0.00420465f, -0.16859728f, -0.12166171f, 0.00633099f, -0.08044563f, 0.02601640f, -0.09949071f, 
    -0.06445061f, 0.07294685f, -0.06282497f, 0.08608324f, 0.21275407f, 0.09480758f, 0.10126111f, 0.19574542f, 
    0.11021248f, -0.04685830f, -0.01585473f, -0.00295656f, -0.06378121f, -0.04640266f, 0.08224552f, -0.03197158f, 
    0.14737581f, 0.19572522f, 0.05069589f, -0.12065800f, 0.01402927f, -0.03451267f, 0.00534531f, 0.00547849f, 
    -0.00641793f, -0.01509377f, -0.04138001f, 0.02429929f, -0.71370125f, 0.02658964f, -0.03541399f, 0.08698009f, 
    0.02385990f, 0.02011990f, 0.13699786f, 0.01880414f, -0.03433253f, -0.00666448f, -0.04773204f, -0.10006812f, 
    0.59131610f, -0.15844832f, -0.10035361f, 0.10352197f, 0.02678273f, -0.05830009f, 0.06471007f, 0.06857811f, 
    0.01449036f, -0.07476575f, 0.03985379f, 0.11715450f, 0.18594936f, 0.24651946f, 0.07327542f, 0.12991677f, 
    0.16753502f, 0.02312135f, -0.06024149f, -0.14306161f, -0.01241299f, 0.00540690f, -0.06768325f, 0.17698291f, 
    0.03310383f, 0.14254458f, 0.32781923f, -0.00419606f, 0.06766269f, 0.16311535f, 0.06917813f, -0.09741405f, 
    0.04874445f, 0.00600902f, 0.03364000f, 0.03363913f, 0.01045679f, -0.14848521f, 0.42641407f, -0.18457589f, 
    -0.10222825f, -0.16036138f, 0.29207134f, 0.01511182f, 0.00152065f, 0.16037038f, 0.06834824f, -0.10158236f, 
    -0.20526469f, -0.07772283f, 0.10697969f, 0.33490050f, -0.02457362f, 0.07051004f, -0.10874369f, 0.02397518f, 
    0.00836163f, 0.01109262f, 0.04654530f, -0.11140569f, 0.06451222f, 0.04108249f, -0.06586555f, -0.06730985f, 
    0.00475669f, -0.03782236f, -0.04254372f, 0.04750862f, 0.02918550f, -0.01584502f, -0.06334125f, -0.07604801f, 
    -0.15427433f, 0.02777742f, 0.02276149f, 0.08472437f, -0.14984019f, 0.00195380f, -0.09501998f, 0.15963966f, 
    0.01247299f, -0.00732417f, -0.08611848f, -0.11145335f, -0.09345470f, 0.03033972f, 0.11158492f, 0.07463018f, 
    0.07096603f, -0.06506659f, -0.13326031f, -0.09972982f, -0.06550636f, 0.03353261f, 0.03296361f, 0.11726881f, 
    -0.18447541f, 0.09217712f, -0.27627745f, 0.18473692f, -0.03023735f, -0.03570626f, -0.13311234f, -0.22995088f, 
    -0.07713836f, 0.01829961f, 0.03179466f, 0.27561167f, 0.12142389f, 0.22936656f, 0.14116327f, 0.32512057f, 
    -0.21495883f, -0.14242977f, -0.06981809f, -0.03553792f, 0.13158673f, -0.14414248f, 0.06701859f, -0.04327254f, 
    -0.11611192f, 0.26813203f, 0.21327633f, 0.10677180f, -0.02443841f, -0.06309503f, 0.04044238f, -0.09551921f, 
    0.13007361f, 0.01046221f, 0.01003702f, 0.25609642f, -0.33527914f, 0.09096529f, -0.06644151f, 0.09972416f, 
    0.08953285f, 0.19405599f, -0.10563812f, -0.00417922f, 0.08356521f, 0.01624358f, 0.26320139f, 0.05128261f, 
    -0.06134984f, -0.01113280f, 0.02757133f, 0.02135944f, -0.19361280f, -0.07423416f, -0.04180614f, 0.14473565f, 
    0.07004110f, -0.05994391f, -0.11148582f, -0.33306107f, -0.18890925f, -0.12245440f, -0.09144065f, 0.06802963f, 
    -0.01552834f, -0.08756192f, 0.13471378f, 0.06898339f, 0.05617512f, 0.08560675f, 0.00240044f, 0.13431160f, 
    -0.17291294f, -0.12394048f, 0.05019075f, 0.26171410f, 0.05516801f, 0.10094389f, 0.10012744f, 0.02127903f, 
    -0.12634245f, -0.13215795f, -0.22958545f, 0.00773451f, -0.17378117f, 0.18765463f, 0.06508967f, -0.27307615f, 
    0.02394907f, 0.11807898f, 0.02203892f, -0.07175524f, 0.20624571f, 0.10602147f, -0.00885942f, 0.12753032f, 
    -0.55375487f, 0.03081949f, -0.01033712f, 0.01207293f, -0.15737978f, 0.00439144f, -0.16677360f, 0.07135554f, 
    0.08178119f, 0.18978833f, -0.05281413f, -0.06346885f, 0.19520357f, 0.22358786f, -0.12069023f, 0.05251186f, 
    0.10192793f, -0.06147562f, -0.10541224f, 0.25270221f, 0.06748872f, 0.09719125f, -0.18109934f, -0.02650309f, 
    0.21434815f, 0.16583952f, 0.13121726f, 0.03635383f, 0.03012831f, 0.15586305f, 0.04485825f, 0.20715582f, 
    0.11420552f, -0.02744465f, 0.07788727f, -0.06835369f, 0.18534192f, -0.03736382f, 0.33987284f, 0.23214738f, 
    -0.20449170f, 0.03603947f, -0.27389121f, -0.11371974f, 0.09034733f, 0.01641173f, -0.02762634f, 0.10942928f, 
    -0.30265889f, -0.01803074f, -0.11117660f, -0.03058976f, -0.05645392f, 0.02861637f, 0.09618994f, -0.06969409f, 
    -0.02216655f, -0.01716891f, -0.13974437f, 0.05229354f, 0.14874735f, -0.10521194f, 0.13405488f, -0.08919270f, 
    -0.00309983f, -0.31951085f, -0.10130543f, -0.20287560f, -0.08320771f, 0.01379167f, -0.10805789f, 0.07841023f, 
    -0.07237063f, 0.23852481f, -0.01897373f, -0.07737654f, 0.01594959f, 0.07901875f, 0.01300110f, 0.17357606f, 
    -0.18828347f, -0.01460324f, -0.20689027f, -0.39790875f, -0.01630671f, 0.14264970f, 0.33437660f, 0.17852426f, 
    0.02453093f, 0.00319775f, -0.02329185f, 0.10798484f, 0.08809448f, -0.00174182f, -0.08000592f, -0.11066403f, 
    -0.32415819f, 0.16073966f, -0.03261319f, 0.21321543f, 0.03355795f, -0.02128702f, -0.05093398f, -0.03768983f, 
    -0.08889362f, -0.06413782f, -0.06202552f, -0.05824891f, 0.10351850f, -0.12577625f, -0.23661919f, -0.20559826f, 
    -0.14007930f, -0.10205163f, 0.07801844f, -0.01338522f, 0.21071784f, 0.14193061f, 0.03716203f, 0.05958895f, 
    -0.30745146f, -0.29883507f, -0.24150498f, -0.11074672f, -0.07768133f, 0.05976481f, 0.10998937f, 0.19678509f, 
    -0.02805524f, -0.06893285f, -0.13404445f, -0.10202246f, -0.38317457f, 0.22500601f, 0.12127843f, 0.06112478f, 
    0.03477510f, 0.01637294f, 0.03981025f, 0.26797217f, 0.06570774f, -0.15437475f, 0.05700659f, -0.06888995f, 
    -0.24434358f, 0.15775731f, -0.00662750f, 0.31010619f, 0.04026814f, 0.03828375f, -0.06954409f, 0.02142453f, 
    0.12297662f, -0.02905911f, 0.04249775f, -0.05206564f, 0.17138115f, 0.11728099f, -0.09599259f, -0.15171924f, 
    0.00602530f, -0.09130204f, 0.05744877f, 0.02655514f, 0.00962512f, 0.07588609f, 0.13219954f, 0.04784833f, 
    -0.17106433f, 0.14604394f, 0.02908961f, 0.17969123f, 0.04191038f, -0.05137455f, -0.31794342f, -0.01447803f, 
    0.12487778f, 0.03153941f, 0.16130683f, 0.15522467f, -0.16299026f, -0.16203435f, -0.17049384f, 0.07268648f, 
    0.10590044f, 0.10381318f, 0.01859717f, 0.11594248f, -0.01486732f, -0.04067791f, -0.05079893f, 0.04199255f, 
    -0.41439807f, 0.06235559f, 0.01817905f, 0.07156385f, -0.09417211f, 0.05215772f, -0.09485707f, 0.10590405f, 
    -0.13401210f, 0.14668950f, 0.03034676f, 0.04804636f, 0.34209624f, 0.30221537f, 0.04820431f, 0.04134364f, 
    0.01032893f, 0.02602138f, 0.07110213f, 0.15097080f, -0.08357570f, -0.00741223f, 0.21629156f, 0.01541963f, 
    0.28560767f, -0.07015838f, 0.06864750f, 0.10955798f, -0.01232160f, 0.24812490f, 0.15049289f, 0.04147952f, 
    0.11044328f, -0.09597542f, -0.00274833f, 0.08022200f, 0.51806182f, -0.18048711f, 0.03993176f, -0.48109803f, 
    -0.09807803f, 0.13820313f, -0.05398757f, -0.03411425f, 0.06153672f, -0.03198394f, -0.07890124f, 0.06544989f, 
    0.57561797f, 0.18573934f, -0.19281110f, -0.20371993f, 0.07736119f, -0.20745422f, 0.15958627f, -0.11614142f, 
    -0.07220346f, -0.09448681f, 0.05941183f, 0.07679108f, 0.08038371f, -0.22439706f, -0.21000001f, -0.10121641f, 
    0.01472578f, 0.04215681f, -0.06091880f, 0.09021296f, 0.21168631f, -0.00737742f, -0.01995730f, 0.10507518f, 
    0.18306446f, -0.01896344f, 0.10560764f, -0.16809951f, 0.08567385f, 0.00520313f, -0.11372073f, -0.09883192f, 
    0.02604400f, 0.20262457f, 0.08563118f, 0.05677074f, 0.01822009f, 0.07354767f, 0.06245832f, 0.22018445f, 
    0.03211636f, -0.05485013f, -0.04052029f, 0.07952777f, 0.12646446f, -0.03505381f, -0.12210647f, -0.08165100f, 
    0.06949501f, -0.15574095f, 0.11386503f, -0.02948156f, -0.18264338f, -0.09215576f, -0.11160093f, 0.02183286f, 
    0.21306244f, 0.07451706f, 0.00706982f, -0.08883660f, -0.08997970f, -0.23628095f, 0.19856517f, -0.24955048f, 
    0.10469425f, 0.14525001f, -0.00173029f, 0.19310789f, 0.00404094f, 0.12615392f, 0.19962250f, 0.00676291f, 
    0.25963756f, 0.03232357f, 0.15226351f, 0.09783522f, -0.00491955f, 0.11676931f, 0.01738668f, -0.08373097f, 
    0.14175609f, 0.00357255f, -0.04345560f, 0.04672865f, -0.12628269f, -0.15370344f, -0.05499510f, -0.09408724f, 
    0.10809045f, 0.11600615f, -0.09047833f, -0.02857989f, -0.07933144f, -0.00353789f, 0.06331044f, 0.08749864f, 
    0.01767872f, -0.05586264f, 0.09001342f, 0.36375290f, -0.05525528f, -0.05815024f, -0.00241205f, -0.13122620f, 
    -0.04180802f, 0.02743551f, -0.01227998f, -0.00417938f, 0.28548700f, -0.05259224f, -0.01936908f, 0.03456691f, 
    0.06625061f, -0.08923151f, -0.03646975f, -0.03925117f, 0.15179218f, -0.02523864f, -0.05106372f, 0.09242918f, 
    -0.04455089f, -0.14305243f, 0.14519601f, 0.08429769f, -0.02579069f, -0.01200181f, 0.21374561f, 0.04698749f, 
    -0.05654585f, -0.00408752f, 0.05417420f, 0.01939986f, 0.24038851f, 0.10285523f, -0.13019212f, 0.41544023f, 
    0.13291238f, 0.02175815f, -0.01837348f, 0.07791620f, -0.05905863f, -0.10068227f, -0.00377861f, 0.06376760f, 
    -0.15567379f, -0.13318041f, -0.00774803f, -0.10236382f, -0.11979556f, 0.15961038f, -0.17765757f, 0.05671326f, 
    0.02260563f, -0.12212222f, -0.08559734f, -0.09432622f, -0.06076131f, 0.11588268f, -0.17069213f, -0.00755855f, 
    0.30289128f, 0.10942738f, 0.06253523f, 0.05844520f, -0.08096788f, -0.05105529f, -0.02671361f, 0.04374987f, 
    0.04362435f, 0.05357401f, -0.03654302f, 0.05568289f, 0.12253170f, 0.17040776f, 0.08610262f, -0.18086502f, 
    -0.07939862f, 0.09881736f, 0.02006311f, -0.01067031f, -0.07261872f, 0.24108584f, -0.02625451f, -0.41970825f, 
    0.08302806f, -0.07151882f, -0.00680286f, 0.12039309f, -0.01919984f, 0.02404173f, -0.17599352f, 0.13016820f, 
    0.08647823f, -0.06255140f, 0.03565471f, -0.31531873f, 0.05765037f, -0.00410222f, 0.06638528f, 0.16356201f, 
    0.00061987f, 0.08220765f, -0.00097698f, 0.13874254f, 0.06964250f, 0.02900067f, -0.25037763f, -0.05536508f, 
    -0.13259314f, 0.09390449f, 0.04701016f, -0.15758672f, 0.05646562f, 0.04325840f, -0.00858463f, -0.10565744f, 
    -0.13512762f, -0.09706745f, 0.03287986f, 0.01370677f, -0.07982942f, 0.04710100f, 0.01565059f, -0.11041925f, 
    0.04628839f, 0.11537202f, 0.10301634f, 0.06939918f, -0.24052340f, 0.01393879f, 0.20631433f, 0.08981018f, 
    -0.19849527f, 0.01722381f, 0.00336494f, -0.08897938f, 0.07224417f, -0.03149684f, 0.13991171f, 0.03286849f, 
    -0.12751348f, -0.15799043f, -0.05644454f, 0.00730794f, 0.07978566f, 0.02810788f, 0.00441867f, 0.02189880f, 
    -0.04842867f, -0.02683270f, 0.02088549f, 0.07525364f, -0.28467262f, 0.22305387f, 0.11619347f, 0.15268227f, 
    -0.03855878f, 0.10490886f, 0.12474834f, 0.02281569f, 0.18867849f, 0.05235329f, 0.03893292f, 0.11460791f, 
    -0.18511203f, 0.19909719f, 0.05956216f, 0.10368770f, 0.05640636f, 0.16256119f, 0.15140836f, 0.09504342f, 
    -0.01486578f, -0.04963507f, -0.06073198f, -0.06812803f, 0.13508643f, -0.00282758f, -0.21788366f, -0.37143356f, 
    0.11252461f, 0.04828320f, -0.06219814f, 0.01776148f, 0.15979365f, -0.01768270f, 0.04680134f, 0.06837190f, 
    0.01613034f, -0.21108142f, -0.12691778f, -0.05300170f, 0.17736374f, -0.01491461f, 0.15834987f, -0.02927018f, 
    -0.00699450f, 0.02097298f, -0.07283249f, 0.03832225f, 0.05865021f, -0.12492556f, 0.05576777f, 0.25194207f, 
    -0.02735833f, -0.11697902f, 0.01092612f, 0.05356658f, 0.06725565f, -0.12308386f, 0.08766550f, -0.01214061f, 
    -0.28310749f, -0.10523931f, -0.11916934f, 0.02363761f, -0.00345200f, -0.03697310f, 0.08563164f, -0.00408353f, 
    0.06902297f, 0.03444470f, 0.03497043f, 0.14280550f, -0.48644039f, 0.41970119f, 0.00051359f, 0.06615886f, 
    -0.04394263f, 0.05558680f, -0.00600728f, -0.03985910f, -0.01528349f, -0.02719802f, 0.05862613f, -0.01157360f, 
    0.07167623f, 0.07955314f, -0.23822473f, -0.08618945f, -0.20276052f, -0.12927829f, -0.09031995f, -0.06021214f, 
    -0.08382970f, 0.13763739f, -0.03859070f, 0.01902645f, 0.19816606f, 0.18965662f, -0.15755439f, -0.16857551f, 
    0.06506994f, 0.01481197f, -0.07027446f, -0.04728217f, 0.02426812f, 0.01090468f, 0.05244863f, 0.00828168f, 
    0.03775185f, 0.11485341f, 0.10821342f, -0.13016006f, 0.00663096f, 0.21204613f, 0.15054366f, -0.07131570f, 
    0.04084618f, -0.12223724f, -0.07539082f, -0.00918370f, 0.52767909f, -0.12545525f, 0.47079822f, -0.08478887f, 
    -0.03405296f, 0.11968446f, 0.26376328f, 0.10747158f, 0.13017160f, 0.08280779f, -0.03098017f, -0.11622784f, 
    -0.20444784f, 0.03320496f, 0.01671772f, 0.33346316f, 0.07139080f, -0.09319649f, 0.02848802f, 0.09242453f, 
    -0.02813599f, -0.10374890f, 0.04881413f, 0.01478351f, 0.05904556f, 0.02623868f, 0.15928687f, 0.23440962f, 
    -0.02383870f, -0.02009171f, 0.00543631f, 0.01935128f, -0.00048417f, -0.10200219f, -0.12577429f, 0.01548809f, 
    -0.15293288f, -0.06749849f, 0.01075936f, 0.14027514f, -0.06998003f, -0.14706294f, -0.07711016f, -0.11245415f, 
    -0.02519497f, 0.09322801f, 0.09571745f, 0.02019371f, -0.39360550f, 0.18803395f, -0.09347755f, 0.12597793f, 
    0.06406844f, 0.00633202f, 0.13121219f, 0.10380895f, -0.02370036f, -0.11053330f, -0.08249583f, 0.10452696f, 
    -0.12913121f, 0.11294428f, -0.08052926f, 0.18635395f, -0.09974913f, -0.05307064f, 0.10607029f, 0.12062189f, 
    0.06147641f, 0.08266326f, 0.08077044f, 0.03672335f, 0.24073635f, -0.06182231f, -0.23586507f, -0.39258295f, 
    -0.04083438f, 0.27863383f, -0.36488929f, 0.00322263f, 0.03818638f, -0.20064011f, 0.00866082f, 0.08216655f, 
    0.23232110f, -0.15708089f, 0.01726657f, 0.14071389f, 0.21041828f, 0.22804821f, 0.10840340f, -0.10587250f, 
    -0.02266887f, 0.08809616f, 0.15090246f, 0.28214955f, 0.01470312f, -0.17687358f, 0.06511019f, 0.03140853f, 
    -0.19344538f, 0.12209804f, -0.09028123f, 0.15467942f, -0.10737532f, 0.10847563f, 0.05566631f, -0.11495708f, 
    -0.23291418f, 0.08514558f, -0.16771802f, 0.11799392f, 0.24544729f, 0.00961865f, -0.00962344f, 0.07449757f, 
    0.00614929f, -0.01375273f, 0.02751785f, -0.03211138f, -0.17171918f, 0.05745400f, 0.04628829f, 0.01635589f, 
    -0.05800131f, 0.31235102f, -0.21849929f, 0.09674062f, 0.06095936f, 0.10481776f, 0.13705595f, -0.00920225f, 
    -0.10750999f, 0.11059979f, -0.10279949f, 0.20028274f, -0.06409611f, -0.13957214f, 0.06281385f, -0.32622048f, 
    -0.24553607f, -0.10065717f, -0.34282750f, -0.51069754f, 0.47677672f, -0.17090479f, 0.16379596f, -0.20781676f, 
    0.04614362f, 0.11720701f, 0.03022677f, -0.08431920f, -0.08046270f, 0.03056081f, 0.02189475f, 0.31068733f, 
    -0.11208739f, 0.18988310f, -0.14770252f, -0.21017304f, -0.15608983f, -0.06408049f, -0.00465427f, -0.06673263f, 
    0.16148530f, -0.19234668f, -0.11540101f, -0.07303996f, 0.23820516f, 0.38749585f, 0.02686842f, -0.03625962f, 
    0.06153545f, 0.08648401f, 0.10548934f, 0.20143265f, 0.12326402f, 0.11865685f, 0.14765100f, -0.03059885f, 
    0.18231948f, 0.19930780f, -0.04901353f, -0.06173398f, 0.03831844f, -0.07764010f, 0.07979102f, 0.16872212f, 
    -0.01485391f, -0.06606432f, -0.03620412f, -0.02184663f, 0.38277081f, -0.00906421f, 0.11810596f, 0.23506001f, 
    0.08432336f, -0.01660150f, 0.09902577f, 0.16477215f, 0.15053971f, 0.00537479f, 0.10027389f, -0.02475577f, 
    0.16248704f, -0.31975311f, 0.17199223f, -0.12362774f, 0.03920911f, 0.13434327f, -0.16827600f, -0.10809751f, 
    -0.07234015f, 0.03131402f, -0.18610279f, -0.04542744f, 0.22046565f, -0.30900383f, 0.14911999f, -0.12084393f, 
    0.24210133f, -0.22597621f, 0.01898712f, -0.75739491f, -0.07578380f, -0.02797472f, 0.03894512f, -0.04127622f, 
    0.03717440f, -0.17435420f, 0.38471222f, -0.09410388f, 0.03845076f, -0.16967204f, -0.04858094f, -0.21675415f, 
    -0.09262868f, -0.56353337f, -0.33371764f, -0.35827816f, -0.03438813f, 0.18065105f, 0.03640302f, 0.18060513f, 
    0.06680694f, -0.00647121f, 0.05449704f, 0.17262118f, 0.04227485f, -0.03276706f, 0.02464156f, 0.02519808f, 
    0.22865251f, -0.11945244f, 0.26249996f, -0.03503940f, -0.07135473f, 0.06145994f, -0.17116451f, 0.00253698f, 
    0.06293765f, 0.17424196f, 0.06491823f, 0.26187605f, 0.07158324f, -0.19545232f, 0.52463263f, 0.34543061f, 
    0.08030084f, 0.03714915f, 0.05038660f, 0.06788114f, 0.01323097f, -0.14755796f, -0.00410867f, -0.10976408f, 
    0.29196104f, 0.11280010f, 0.22213715f, 0.17890012f, 0.00649225f, 0.04130105f, 0.08119331f, -0.10266592f, 
    0.10734464f, 0.05609463f, 0.04346723f, 0.27835596f, -0.28618485f, 0.03211122f, 0.18113938f, -0.02299068f, 
    -0.04631101f, 0.00921968f, 0.05161475f, -0.12648687f, -0.10109257f, 0.13297258f, -0.01335839f, 0.15482721f, 
    0.55855113f, 0.43024489f, 0.39637831f, -0.13017935f, -0.32513309f, 0.14250459f, -0.05849995f, -0.15435962f, 
    -0.07752913f, -0.08905037f, 0.04542298f, -0.28749263f, -0.05302915f, 0.11257213f, -0.24892917f, -0.17218247f, 
    0.04470735f, 0.14187224f, 0.32331896f, -0.11215141f, 0.02911278f, -0.04763655f, -0.17694917f, -0.09123272f, 
    0.29009163f, 0.02807948f, 0.30618647f, -0.01747172f, 0.07409016f, 0.13607894f, 0.17090988f, 0.36284673f, 
    -0.10714889f, -0.05465072f, -0.13331518f, -0.12725025f, 0.37738639f, 0.35006377f, 0.00541991f, 0.03404900f, 
    0.10518743f, 0.11809934f, -0.24894799f, -0.01226273f, 0.10601139f, -0.03063004f, -0.05843051f, 0.04289652f, 
    -0.42288062f, -0.35880357f, 0.38791630f, -0.26829433f, -0.08838550f, 0.01187452f, -0.25596583f, 0.22819346f, 
    0.07419027f, 0.02384363f, -0.04996237f, -0.06661948f, -0.02006036f, 0.08401085f, -0.23858687f, 0.24933310f, 
    0.02804474f, 0.05610961f, -0.09314083f, 0.08193717f, 0.02338354f, 0.03375816f, -0.15138376f, 0.00836461f, 
    0.04268425f, 0.04361546f, 0.01279680f, 0.18120882f, 0.07160067f, -0.07604498f, 0.01742013f, 0.04051253f, 
    -0.06428138f, -0.11802156f, -0.05136317f, -0.26185265f, 0.00242004f, 0.15824266f, -0.16410024f, 0.09110945f, 
    -0.03503731f, -0.06710207f, -0.08960941f, -0.10285234f, 0.10698289f, 0.03431019f, 0.12755440f, 0.20531112f, 
    -0.22232977f, -0.19309360f, -0.24269316f, -0.06157761f, 0.03991128f, 0.09074072f, 0.12971821f, 0.04868119f, 
    0.07176273f, 0.00500692f, -0.31297854f, 0.07937346f, -0.15942210f, 0.10938527f, -0.24061137f, 0.04070403f, 
    -0.12014085f, 0.21599181f, 0.15824360f, -0.23166877f, -0.15426272f, 0.08584461f, -0.08266197f, -0.16339627f, 
    -0.13173647f, 0.06777019f, -0.23054905f, -0.11753052f, 0.08393920f, 0.11634172f, -0.14508806f, 0.09237485f, 
    -0.07278007f, -0.27336711f, -0.33895719f, -0.38935140f, 0.49456760f, -0.04411083f, 0.55550343f, -0.26971892f, 
    0.00130352f, -0.05027881f, -0.12018048f, 0.00937776f, 0.05391040f, -0.19572192f, 0.09161589f, 0.00292001f, 
    -0.39342102f, -0.22291748f, -0.34397048f, 0.14328729f, 0.11302242f, -0.01573667f, 0.04725836f, -0.08530623f, 
    0.07387866f, -0.10717157f, -0.00630652f, 0.09599075f, 0.22933359f, 0.18405338f, -0.01963253f, 0.03678268f, 
    -0.15568551f, 0.12533191f, 0.00636706f, 0.04040323f, 0.06538256f, -0.20360599f, 0.07607502f, 0.01911798f, 
    0.08291751f, 0.44055104f, 0.20700014f, 0.11637404f, 0.02366405f, 0.02754087f, -0.09241287f, 0.02071698f, 
    0.04671416f, -0.09885844f, -0.05249657f, 0.13129614f, 0.12111479f, 0.42117307f, 0.16905046f, -0.24574579f, 
    0.03197372f, 0.13055518f, -0.17262301f, -0.01184434f, 0.09966381f, -0.06162936f, 0.15604518f, -0.04057290f, 
    -0.19708686f, -0.31217632f, -0.60123026f, -0.14706379f, 0.15458809f, -0.02934209f, -0.02493065f, -0.07670419f, 
    0.09653238f, -0.02514151f, -0.05398788f, -0.10318671f, -0.31550339f, -0.30695593f, -0.24848773f, -0.01486449f, 
    0.19563965f, 0.08643001f, -0.08669690f, 0.09446764f, 0.06899183f, 0.19623032f, -0.07386880f, 0.18087332f, 
    -0.26091740f, 0.12773782f, 0.11364112f, 0.22267829f, 0.03180866f, 0.11950384f, 0.04838241f, -0.01874789f, 
    -0.04859411f, -0.11531804f, -0.06439069f, 0.08432459f, -0.02760660f, 0.46311483f, 0.10270333f, -0.41506529f, 
    0.14590184f, 0.02791487f, 0.16252562f, -0.04006786f, -0.02535343f, -0.00995704f, -0.03393079f, 0.03680238f, 
    -0.11731613f, 0.11919379f, -0.29907548f, -0.06163593f, -0.04631069f, -0.06629243f, -0.00827021f, 0.07214991f, 
    0.16760099f, 0.11003419f, -0.04495169f, 0.02159382f, 0.37271580f, 0.46501040f, 0.11045834f, 0.01297169f, 
    -0.02803410f, 0.00662292f, -0.04717602f, 0.14271319f, -0.03756886f, 0.08877515f, -0.14178723f, 0.08683473f, 
    0.21402468f, 0.35442087f, 0.23155268f, 0.20031337f, -0.07690001f, 0.05177570f, 0.08937244f, 0.28507119f, 
    0.11561992f, 0.02323001f, 0.00542340f, -0.00359442f, 0.08858500f, -0.07622682f, 0.44642362f, 0.23882200f, 
    -0.19900927f, -0.03816668f, -0.13114280f, 0.02278352f, 0.16304529f, -0.01630241f, -0.07501179f, 0.07535666f, 
    -0.31120080f, -0.49810380f, 0.07666935f, -0.09477132f, -0.10400870f, 0.01533513f, -0.00393501f, -0.05381512f, 
    0.02111827f, -0.02712330f, -0.10302911f, 0.07528210f, 0.07536280f, -0.39992914f, -0.03777982f, -0.12718536f, 
    0.05415696f, -0.01672287f, -0.07981055f, -0.22239487f, -0.01194669f, 0.15679482f, -0.01237669f, -0.03300048f, 
    -0.02291559f, -0.08735857f, 0.34889030f, 0.11335084f, -0.05297371f, 0.04856702f, 0.14492349f, 0.26037550f, 
    -0.02289756f, 0.03430329f, -0.10296285f, -0.04038346f, -0.20117782f, -0.15727545f, -0.15452935f, 0.16431953f, 
    0.18165328f, -0.08261122f, 0.09137449f, 0.02777381f, 0.07796881f, 0.05440605f, 0.00839143f, -0.04926682f, 
    -0.11632853f, 0.05343574f, -0.29589707f, 0.13642326f, 0.06449320f, -0.12201554f, 0.09707197f, -0.12667249f, 
    0.00639498f, 0.08896204f, 0.11675926f, 0.30169773f, 0.17724460f, 0.28153247f, -0.00068256f, 0.27265376f, 
    -0.11242777f, 0.00384736f, -0.00972405f, -0.15220723f, 0.09530318f, -0.10607807f, -0.08347059f, 0.10797802f, 
    -0.28579149f, -0.04543182f, 0.20899236f, 0.25920701f, 0.09156251f, 0.06492147f, -0.05437461f, -0.08996287f, 
    0.13207068f, 0.10488532f, 0.15603966f, 0.36092809f, -0.10743348f, 0.06717284f, 0.06116128f, 0.10679407f, 
    0.06210661f, -0.02195675f, 0.09178357f, 0.13270411f, -0.03005062f, 0.22274527f, 0.00830146f, -0.28992844f, 
    -0.27423841f, 0.26603991f, -0.05395027f, 0.00666335f, 0.05929297f, 0.03372299f, 0.09260349f, 0.12785779f, 
    0.08946647f, -0.19324236f, -0.12354168f, -0.22878295f, -0.32925647f, -0.12009729f, 0.06389517f, 0.09403857f, 
    0.03859483f, 0.15151222f, -0.01931630f, 0.01612599f, -0.04999074f, 0.05198778f, 0.04513444f, -0.00692105f, 
    -0.14116469f, 0.04858055f, -0.29353109f, 0.23135643f, 0.07026773f, -0.04941005f, -0.09123333f, -0.09362271f, 
    -0.13526332f, -0.34353027f, -0.33070001f, -0.43610755f, -0.01393752f, -0.14777136f, 0.14488760f, -0.11248075f, 
    -0.00446525f, 0.05332826f, 0.10836606f, -0.06612628f, -0.01347698f, -0.02730072f, -0.05342123f, -0.06539698f, 
    -0.03199011f, 0.14585876f, -0.20539269f, 0.06520821f, 0.07436198f, 0.01372913f, -0.10385505f, 0.06590827f, 
    0.02025546f, 0.12605751f, -0.11346086f, -0.15466143f, 0.17591137f, 0.07025337f, 0.09455734f, 0.07936183f, 
    -0.05712049f, -0.10884940f, 0.01635629f, -0.00455083f, 0.22292648f, 0.21002635f, 0.15733075f, -0.04682047f, 
    0.08669872f, 0.09004341f, 0.11765604f, 0.03759700f, -0.11146442f, -0.06172887f, 0.02866320f, 0.15823881f, 
    0.07194605f, 0.05610321f, -0.00000107f, 0.03858547f, 0.09028932f, -0.41213015f, 0.21852034f, 0.34284672f, 
    -0.20873067f, 0.09405814f, -0.14727984f, -0.00182529f, 0.20389633f, 0.08330338f, 0.18379188f, 0.00071963f, 
    -0.19674806f, -0.09465662f, -0.18251988f, 0.01703363f, 0.11127447f, -0.19344504f, -0.12548012f, -0.17429624f, 
    -0.12587249f, 0.04720232f, -0.02884699f, -0.07501094f, 0.09264096f, 0.04829260f, 0.55291861f, 0.16679856f, 
    0.21640290f, -0.40386254f, -0.28153524f, -0.29119104f, 0.02597143f, -0.07838887f, -0.22693262f, 0.01572408f, 
    -0.05469181f, 0.00471277f, -0.20054582f, -0.08681947f, -0.03553230f, -0.14300337f, -0.12703079f, -0.01019408f, 
    -0.46178710f, -0.11075420f, -0.26473367f, -0.52823997f, 0.27452794f, 0.27633858f, 0.00695451f, 0.37117472f, 
    0.09881394f, 0.05739920f, 0.09620475f, 0.10315883f, -0.02361571f, -0.05866569f, -0.10389100f, -0.07872844f, 
    0.20121908f, 0.33093077f, 0.05135313f, 0.06071312f, -0.05991449f, -0.08514555f, 0.07316119f, -0.13894767f, 
    0.12279848f, -0.08553870f, 0.19114584f, 0.32926965f, 0.58582139f, 0.13815114f, -0.00897652f, -0.15738998f, 
    -0.21710376f, 0.03016821f, 0.06212229f, 0.12110077f, -0.02778305f, -0.10686108f, 0.06978402f, 0.02957069f, 
    0.12897070f, -0.05813251f, -0.06183216f, 0.25484774f, -0.13990025f, -0.06554125f, -0.11541900f, -0.09689179f, 
    0.00930795f, 0.02223823f, 0.03133273f, 0.18845929f, -0.11516920f, -0.13047035f, 0.42179689f, -0.12713009f, 
    0.03000323f, -0.05381785f, 0.01332023f, 0.17747468f, 0.13510776f, 0.12900607f, -0.10335703f, -0.04910588f, 
    0.29523727f, 0.49272209f, -0.29886499f, 0.04186913f, 0.08213244f, -0.00933754f, -0.00355034f, -0.07557654f, 
    0.14556669f, -0.00446715f, 0.01964032f, 0.04128052f, 0.21297844f, 0.12923388f, 0.10671224f, -0.01059457f, 
    0.10952605f, 0.19537048f, -0.02264874f, -0.04247949f, 0.02439727f, 0.25175670f, -0.09209831f, 0.07315188f, 
    -0.03399143f, 0.25593245f, 0.15352489f, 0.16253179f, 0.05342765f, 0.02578752f, 0.16564399f, 0.01709763f, 
    0.06869979f, -0.08591077f, -0.12207928f, -0.15500432f, -0.08787356f, -0.03077067f, -0.08660453f, 0.00403228f, 
    -0.07587556f, -0.01825433f, 0.11381050f, -0.17405708f, -0.01939202f, 0.00471533f, -0.13926403f, -0.09837309f, 
    0.05481988f, 0.26520759f, -0.15802167f, -0.06928013f, 0.14884432f, 0.06577759f, -0.13302305f, 0.18706445f, 
    0.07651428f, -0.02865557f, 0.08538426f, -0.02451129f, -0.02944873f, 0.02263170f, 0.16697185f, 0.22090255f, 
    0.03029310f, -0.13002315f, 0.10603373f, -0.08016225f, -0.00003117f, 0.01204333f, 0.04814890f, 0.07533496f, 
    -0.11903828f, -0.21554144f, -0.01296690f, 0.22007774f, -0.10221364f, -0.14882039f, 0.01648970f, 0.16777241f, 
    -0.07014497f, -0.07344261f, -0.02527947f, 0.07717666f, 0.06604038f, -0.38465109f, 0.11191490f, 0.26177564f, 
    -0.10927121f, -0.06176401f, -0.17881565f, 0.04881436f, -0.03499420f, 0.15810406f, -0.01689311f, 0.09320837f, 
    0.08475890f, -0.17859925f, -0.01621165f, -0.08766800f, -0.03627252f, 0.06147464f, -0.07926492f, -0.01170345f, 
    -0.15691021f, -0.12671146f, -0.19070661f, -0.00263017f, 0.17998473f, -0.01019899f, 0.09474124f, -0.17685334f, 
    -0.05438165f, 0.04127253f, -0.01548329f, -0.05011314f, 0.00882751f, 0.04457343f, 0.04835493f, 0.06280693f, 
    0.14265016f, -0.01164331f, -0.02751425f, 0.15473059f, 0.06078543f, -0.02259831f, 0.03197486f, 0.10116703f, 
    -0.11643754f, -0.08577703f, -0.01421459f, -0.08442301f, 0.10929086f, 0.02301478f, -0.24124992f, 0.14398284f, 
    -0.08347090f, 0.03257609f, 0.03227439f, -0.06843628f, 0.14428154f, -0.09817284f, 0.10333478f, 0.08718897f, 
    -0.31457692f, -0.27119082f, 0.14429845f, 0.13799544f, -0.08365624f, -0.07875629f, -0.07473772f, 0.03605066f, 
    -0.19600046f, 0.13336709f, 0.03277357f, 0.02323497f, 0.18571083f, 0.15251073f, -0.09886699f, -0.15260878f, 
    0.02027294f, 0.13022441f, 0.03270920f, 0.06291569f, -0.08829305f, 0.15898113f, -0.01523720f, 0.09055535f, 
    0.37228975f, -0.01776260f, -0.13759701f, 0.02654423f, 0.06015811f, 0.22398579f, 0.01594006f, 0.05725710f, 
    -0.02070124f, 0.16262592f, 0.10891764f, -0.03666218f, 0.16531870f, -0.04708500f, -0.22887467f, 0.20403099f, 
    0.11402579f, -0.11197857f, 0.06596760f, 0.18693599f, -0.19347602f, 0.10125217f, 0.02994500f, 0.11600669f, 
    -0.37637988f, -0.34334347f, 0.29030600f, 0.12077401f, -0.09927373f, -0.09420359f, -0.05183791f, 0.02701465f, 
    -0.06086424f, 0.07245252f, 0.07383344f, 0.06219250f, -0.07125875f, -0.21649067f, 0.13995282f, -0.07815544f, 
    -0.05370901f, -0.06127516f, -0.03127486f, -0.10321780f, -0.04150873f, 0.03785963f, 0.12995414f, 0.21479467f, 
    0.00368535f, 0.04841610f, 0.10451319f, -0.07038608f, -0.03401366f, -0.04601564f, 0.17563979f, -0.10193894f, 
    -0.04017153f, 0.07070344f, 0.04053890f, 0.01354809f, 0.35345510f, -0.06901609f, 0.20443778f, 0.12632422f, 
    -0.03166436f, 0.23001276f, -0.07062323f, 0.10879156f, 0.02505952f, 0.07084002f, 0.02295581f, 0.01565122f, 
    0.00095691f, -0.22688289f, -0.05500438f, -0.08965290f, -0.15880372f, 0.14227684f, 0.11719998f, -0.05887944f, 
    -0.02594652f, -0.02796612f, 0.00816457f, 0.04349069f, 0.22212569f, 0.10776791f, -0.04398366f, -0.11998540f, 
    0.05553078f, 0.00850356f, 0.03212868f, 0.08074629f, -0.11179976f, -0.02245715f, 0.00744237f, -0.09917983f, 
    0.18512437f, 0.29863811f, 0.04753318f, -0.06234809f, 0.12452349f, 0.08488912f, 0.22690015f, 0.01487999f, 
    -0.17601219f, -0.04656719f, 0.02488682f, 0.06631777f, 0.42238155f, 0.42925590f, -0.29668331f, -0.18430541f, 
    0.08727994f, 0.21464568f, 0.20553711f, -0.06889075f, -0.26106074f, -0.12625523f, -0.00322796f, -0.04808900f, 
    0.12329695f, 0.33373502f, 0.24832752f, -0.50636894f, -0.04625796f, 0.13805312f, 0.01414471f, 0.05291787f, 
    -0.01312917f, -0.06768353f, -0.07018683f, -0.11388912f, -0.05412237f, -0.18566357f, -0.08160488f, -0.01913819f, 
    -0.04436452f, -0.05645313f, -0.00759639f, 0.04218912f, -0.04926854f, -0.15408435f, 0.00108454f, 0.09175491f, 
    -0.01192813f, 0.16603123f, -0.00953562f, -0.03409820f, -0.06876492f, 0.05694766f, 0.05079312f, -0.13923527f, 
    0.02082934f, -0.04754639f, 0.08568421f, 0.13072196f, -0.09936764f, 0.36490023f, 0.15812789f, -0.18806562f, 
    -0.17889477f, -0.03682515f, -0.03853988f, 0.05688104f, 0.00974170f, -0.00813501f, -0.04909764f, 0.08087303f, 
    -0.15162674f, 0.06659246f, -0.31219211f, 0.25146723f, -0.06492785f, -0.02984977f, -0.22656411f, 0.15638466f, 
    0.15349421f, 0.03004536f, -0.00772378f, 0.01184459f, 0.24182050f, -0.04501693f, -0.10198278f, -0.12248998f, 
    -0.11558919f, 0.11466967f, -0.30383664f, -0.03646164f, 0.12593974f, -0.10237394f, 0.05743103f, -0.03401260f, 
    -0.02756905f, -0.19734588f, -0.10101049f, 0.14058007f, 0.00583486f, 0.07827663f, -0.04829354f, -0.03428482f, 
    0.09238265f, 0.13016723f, 0.08287717f, 0.18021046f, 0.00175966f, -0.02434687f, 0.02357434f, 0.19119973f, 
    -0.15566301f, 0.20779295f, -0.16458182f, 0.18039677f, -0.18042161f, 0.04898736f, 0.11478117f, -0.03748139f, 
    -0.63878697f, 0.21077073f, 0.05891770f, 0.28736347f, 0.40319580f, -0.12739787f, 0.02016887f, 0.19831897f, 
    -0.06186873f, -0.18932153f, 0.13012891f, -0.06779554f, -0.17082496f, 0.10996727f, 0.00177976f, -0.03247033f, 
    -0.09502951f, -0.22342619f, -0.26377037f, 0.13217703f, 0.20377925f, -0.01589433f, 0.13996524f, 0.01663779f, 
    -0.38133109f, 0.14830133f, 0.04900897f, 0.36083078f, -0.05507044f, -0.01617511f, 0.00129910f, -0.15434147f, 
    -0.06993071f, -0.12856446f, -0.23944026f, -0.31024387f, 0.41957903f, -0.13456973f, 0.01364192f, -0.17039628f, 
    0.03535082f, 0.11428642f, -0.05123372f, 0.15066648f, 0.06145900f, -0.02605502f, 0.02724575f, 0.24900909f, 
    -0.37971765f, 0.02492360f, 0.00298755f, -0.09059054f, 0.00683644f, 0.16957295f, -0.05715078f, -0.06685656f, 
    0.14562777f, -0.27982175f, -0.07967554f, -0.15097788f, 0.16108803f, 0.43138722f, -0.00546417f, -0.03166737f, 
    0.18140016f, -0.02495428f, 0.07517397f, 0.22782010f, 0.10676721f, -0.07739031f, 0.02199762f, 0.09396437f, 
    0.26191500f, 0.19611605f, 0.00385050f, -0.09055491f, 0.19040738f, 0.05599340f, 0.07083113f, 0.27069175f, 
    -0.10650470f, -0.05574908f, -0.00437961f, -0.07071191f, 0.26035920f, 0.17529638f, 0.23519446f, -0.02822241f, 
    0.02414962f, 0.04664388f, -0.09696336f, -0.01716948f, 0.04736552f, 0.10288036f, -0.01983310f, -0.00621504f, 
    0.23927134f, -0.13874601f, 0.20748743f, -0.26609203f, -0.00137859f, 0.01890641f, -0.04237556f, -0.30052882f, 
    -0.08293429f, 0.14666137f, -0.07186433f, -0.07670397f, 0.31807810f, -0.21856014f, 0.06984240f, -0.01811507f, 
    0.08153702f, -0.40061587f, 0.04256495f, -0.61603743f, 0.12252457f, 0.21856359f, -0.10627583f, -0.03302934f, 
    -0.06724522f, -0.04309995f, 0.52958280f, -0.09285990f, 0.03266067f, 0.13269065f, -0.01759527f, -0.07163069f, 
    -0.07548305f, -0.28384864f, -0.43041095f, -0.40256897f, -0.16169320f, 0.12109976f, 0.24568020f, 0.25480539f, 
    -0.03923910f, 0.11001042f, 0.01721989f, 0.15071422f, -0.10823452f, -0.02306289f, 0.03527015f, -0.32527095f, 
    0.10146166f, 0.09957483f, 0.01506401f, -0.14420779f, -0.05347102f, -0.13899817f, -0.00449056f, -0.02657158f, 
    0.00327206f, 0.33322644f, 0.07975831f, 0.31312856f, -0.02259818f, 0.14657454f, 0.58048666f, 0.46927130f, 
    0.17592230f, -0.02976559f, 0.13679983f, 0.05614168f, -0.07538185f, 0.10610937f, -0.10506148f, -0.03089320f, 
    0.05663595f, -0.08819711f, 0.11840125f, 0.17683698f, -0.01947637f, 0.01994894f, 0.22663654f, 0.19869883f, 
    0.01667970f, 0.25497687f, 0.14276657f, 0.17535493f, -0.27438942f, -0.13487239f, 0.03933629f, 0.42365959f, 
    -0.00687571f, -0.05685258f, 0.13174385f, -0.06993496f, -0.19488581f, 0.14845937f, -0.03742258f, -0.07524333f, 
    -0.09975895f, 0.23260084f, 0.67126697f, -0.00964684f, -0.23277017f, 0.03532622f, -0.02516763f, 0.07775684f, 
    0.02730824f, 0.03608118f, -0.03737213f, 0.08335554f, -0.04993597f, -0.09889857f, 0.01249508f, -0.37187621f, 
    -0.00947844f, -0.08664978f, 0.09068317f, -0.03218424f, -0.21400511f, -0.05455459f, -0.00928437f, -0.08972105f, 
    0.20082538f, -0.32079449f, -0.00718679f, 0.00035113f, 0.14591403f, 0.04602323f, 0.09566685f, 0.03232089f, 
    -0.14848925f, -0.18249649f, 0.05774438f, -0.31478208f, 0.36969966f, -0.06485046f, 0.11064971f, 0.32490790f, 
    0.03166398f, 0.15079778f, -0.12892048f, 0.19016035f, 0.12381784f, -0.07329408f, 0.14271960f, -0.08698227f, 
    -0.31349546f, -0.24459438f, 0.42131516f, 0.05644679f, 0.15292083f, 0.31244460f, -0.03861083f, -0.15305422f, 
    0.06785916f, -0.12437061f, -0.06351550f, 0.00950157f, -0.00185618f, -0.26103410f, -0.07959040f, -0.00543700f, 
    0.10034429f, -0.17707987f, -0.08272738f, -0.01765109f, 0.07645643f, 0.04671476f, 0.15533590f, -0.12478727f, 
    -0.01655997f, -0.10942845f, -0.06727052f, -0.01072405f, -0.03289760f, -0.00450439f, -0.18727589f, -0.15204659f, 
    0.00322280f, -0.02240926f, 0.02549864f, -0.09746654f, -0.12011358f, 0.10806067f, -0.30441448f, 0.07756380f, 
    0.02865062f, 0.02998832f, -0.20179713f, 0.03290874f, -0.20767200f, 0.03554310f, 0.24261203f, 0.02555265f, 
    0.08707140f, 0.39583352f, -0.22228272f, -0.26418835f, -0.16410933f, 0.04761827f, 0.06433925f, 0.16136326f, 
    -0.07734449f, 0.04479116f, 0.14135833f, 0.04612692f, -0.28885898f, 0.43384919f, -0.02687464f, 0.18187441f, 
    -0.09355786f, 0.03477143f, 0.08789552f, 0.20718777f, 0.03355391f, 0.01642942f, -0.02437346f, 0.05782948f, 
    0.00207302f, 0.09142007f, -0.34525201f, 0.02056810f, -0.01484144f, 0.09554702f, -0.18441045f, 0.03173452f, 
    -0.09462520f, -0.10956223f, -0.10527689f, -0.12861869f, 0.37969163f, 0.26323190f, 0.40367442f, -0.04097148f, 
    -0.20663846f, 0.03485518f, -0.11205211f, 0.12828717f, 0.02867190f, -0.05140062f, 0.13720588f, -0.04786940f, 
    0.45219347f, 0.30099756f, 0.16152442f, -0.15300553f, 0.00593147f, -0.13018636f, 0.06188347f, -0.03698833f, 
    0.01307150f, 0.07878634f, 0.04775507f, 0.25007665f, 0.35859123f, 0.32069874f, 0.03874711f, -0.05358102f, 
    0.02242695f, -0.02375080f, 0.13739648f, 0.07189395f, -0.10042434f, 0.19559617f, 0.09872266f, 0.02356818f, 
    0.11316613f, -0.19290029f, -0.08542610f, 0.00278144f, -0.08836409f, -0.21970168f, -0.12256221f, -0.07722300f, 
    -0.04918469f, 0.10794146f, -0.10431057f, 0.02623436f, -0.13544704f, -0.05697174f, 0.25871646f, 0.29722553f, 
    0.13239338f, -0.11651048f, 0.27854228f, -0.04300433f, 0.05979272f, -0.03430473f, -0.15328683f, 0.02638250f, 
    0.30089533f, 0.53908509f, 0.03625258f, -0.10028014f, -0.21049716f, 0.04288204f, -0.07739516f, -0.02408486f, 
    0.00851611f, 0.01983774f, 0.06968094f, 0.06869036f, 0.15378107f, 0.10332175f, 0.11181111f, -0.02145880f, 
    -0.08317518f, 0.01509180f, 0.01821561f, -0.04039180f, -0.04284065f, 0.18631335f, -0.18633072f, -0.01695887f, 
    0.15575692f, 0.11277619f, 0.04838866f, 0.05054426f, 0.17001058f, 0.09668918f, 0.11266521f, 0.08670973f, 
    -0.08975334f, -0.00528194f, 0.00093672f, -0.12092273f, 0.04253544f, -0.09846619f, 0.07227743f, 0.08980727f, 
    -0.03575430f, -0.01944650f, 0.04800969f, -0.05284701f, 0.04116531f, 0.02936211f, -0.14947180f, -0.21609285f, 
    -0.02378664f, 0.01935687f, 0.20055394f, 0.10013882f, 0.35268939f, 0.07264927f, 0.00039889f, -0.00877557f, 
    0.03998886f, 0.04362525f, 0.01866695f, -0.03852343f, -0.08538348f, -0.18684354f, 0.33507356f, 0.39878798f, 
    0.03676353f, -0.01958806f, 0.02651636f, 0.04986593f, 0.04132768f, 0.03186954f, 0.02255557f, 0.14960353f, 
    -0.10461263f, -0.18713106f, 0.03318759f, 0.25620955f, -0.09072354f, -0.04871079f, -0.09095461f, 0.11673187f, 
    -0.11103891f, 0.04219222f, -0.03379198f, 0.05136618f, -0.31928343f, -0.10509814f, -0.27898535f, 0.09653470f, 
    -0.14523163f, 0.06271520f, -0.10872687f, 0.06555507f, -0.06668193f, 0.12486783f, 0.00864030f, 0.02992369f, 
    0.08755357f, 0.14738023f, -0.05553827f, -0.11292619f, -0.07489242f, -0.00406933f, -0.06280065f, -0.01724262f, 
    0.01462362f, 0.01992906f, -0.01873887f, 0.05786803f, -0.10156810f, -0.00768558f, -0.07459565f, -0.15595193f, 
    -0.04486348f, 0.10074181f, -0.04327909f, 0.00786039f, 0.03837935f, 0.09526271f, 0.02577850f, 0.01773115f, 
    0.09404833f, 0.00293138f, -0.20795146f, 0.07226179f, 0.06314458f, 0.08830849f, -0.04997652f, -0.04921356f, 
    -0.07877712f, 0.08237793f, -0.00470657f, -0.06284521f, 0.21812871f, -0.12005946f, -0.00126119f, 0.02256591f, 
    -0.08265521f, 0.05739870f, -0.18975547f, -0.09409104f, 0.12289698f, 0.03727550f, 0.03475292f, 0.05437918f, 
    0.26479569f, -0.00700805f, 0.13163364f, -0.00056896f, -0.06951101f, -0.07036249f, 0.10597185f, -0.19936846f, 
    -0.00429123f, -0.10332374f, 0.09169604f, 0.15112206f, 0.21481012f, 0.74460036f, 0.26113355f, -0.05461958f, 
    -0.20339058f, 0.04084565f, 0.10256084f, 0.07357519f, 0.03463320f, 0.19352280f, 0.13032380f, -0.04506185f, 
    0.06028882f, 0.22351511f, 0.12605123f, 0.27257970f, -0.04502396f, 0.11433287f, -0.06017466f, -0.00557507f, 
    0.07713929f, 0.13179675f, -0.11752550f, -0.07386915f, 0.08584830f, -0.26159608f, -0.35129347f, -0.39222786f, 
    0.23862697f, 0.14942436f, 0.03440003f, -0.01331771f, 0.13419564f, 0.07501250f, -0.08487284f, 0.14876133f, 
    -0.09064403f, -0.25992328f, -0.14924403f, 0.09010066f, -0.06631128f, -0.11138035f, 0.15194869f, -0.08289599f, 
    -0.08950661f, 0.12089420f, -0.09519573f, 0.04463535f, 0.31357402f, -0.09506248f, 0.21248233f, 0.11002546f, 
    -0.01905259f, -0.10606999f, 0.02110584f, -0.10019196f, 0.07851941f, 0.02188937f, 0.04813062f, 0.14059298f, 
    -0.09592226f, -0.18864678f, -0.24268343f, 0.08174314f, 0.00699129f, 0.09229733f, 0.22690518f, -0.12350363f, 
    -0.00085919f, -0.04796153f, -0.11376360f, -0.03876870f, -0.63911963f, 0.38406536f, 0.12158879f, 0.30296138f, 
    -0.05214571f, 0.17305046f, 0.04170293f, -0.13994877f, 0.03003466f, 0.02862079f, -0.08640657f, -0.04489061f, 
    0.21038382f, 0.20252030f, -0.29566786f, -0.14934716f, -0.00485533f, -0.02858360f, 0.00995468f, -0.10964368f, 
    0.06044228f, 0.03339294f, -0.00454510f, 0.04547103f, -0.04243750f, -0.18289249f, -0.02263425f, -0.07695241f, 
    0.25427213f, 0.02385429f, -0.07457995f, 0.06495737f, 0.05115684f, 0.07374763f, 0.06879634f, -0.01667153f, 
    -0.19388455f, 0.16392331f, 0.03230079f, -0.05252548f, -0.08508151f, 0.12974082f, -0.01397408f, 0.01524783f, 
    -0.06912149f, -0.05023637f, -0.08383321f, 0.03364525f, 0.16437276f, -0.07251143f, 0.41878623f, -0.00804751f, 
    0.15839984f, 0.19521359f, 0.09704322f, 0.19178469f, 0.10150062f, 0.20859516f, 0.01491014f, -0.18748534f, 
    -0.25943980f, 0.08562098f, 0.09951576f, -0.01886957f, -0.03885750f, 0.08688954f, -0.05905510f, 0.10388715f, 
    0.06762003f, -0.09458031f, 0.00451929f, -0.05602193f, 0.11074207f, 0.29592559f, 0.04783455f, 0.07985747f, 
    -0.19072980f, -0.11593369f, -0.00674090f, 0.03640432f, 0.05792762f, 0.06651325f, 0.06855071f, 0.20064412f, 
    -0.28291500f, -0.03248870f, -0.09948842f, 0.07398194f, -0.04790784f, 0.03234582f, 0.05382427f, 0.00663771f, 
    -0.20679531f, -0.05324949f, -0.00266849f, -0.01878866f, -0.53636086f, 0.07301674f, -0.26848635f, 0.03270531f, 
    -0.06890067f, 0.12470402f, 0.00397319f, -0.05409980f, -0.02038014f, 0.04312650f, -0.24655372f, -0.02759143f, 
    -0.18669580f, -0.15059233f, -0.08669589f, 0.00612843f, 0.07204320f, 0.04970160f, -0.01248742f, -0.01058221f, 
    0.01790860f, -0.08296821f, -0.03497291f, -0.01822573f, -0.21167287f, -0.20115225f, -0.32875255f, 0.11682801f, 
    0.03376147f, 0.05780172f, 0.15212756f, 0.16234186f, 0.20423444f, -0.06921706f, -0.04420530f, -0.13994616f, 
    0.02667337f, 0.03279029f, -0.11147934f, -0.31468064f, 0.14994553f, 0.05654207f, 0.06677302f, 0.08668662f, 
    0.13898154f, -0.05488591f, -0.07473481f, 0.01194886f, -0.10843168f, 0.36179027f, 0.22699144f, 0.41115835f, 
    0.06818722f, -0.08167589f, 0.01306168f, -0.04719171f, -0.00432123f, -0.12106983f, 0.20676543f, -0.03700125f, 
    0.37032273f, 0.06505393f, 0.29627588f, 0.11119273f, -0.14182876f, -0.01828384f, -0.10651796f, 0.02307827f, 
    0.02538218f, 0.08005462f, -0.01558953f, -0.10751016f, -0.11665671f, -0.05499284f, -0.16469772f, -0.06728414f, 
    -0.09836576f, 0.02564375f, 0.02338565f, -0.01879518f, -0.02009746f, 0.05678555f, 0.06263234f, 0.29297954f, 
    -0.09600801f, 0.05945477f, 0.15331510f, 0.07151966f, 0.03553610f, 0.06462796f, -0.21979883f, 0.05527464f, 
    -0.07038203f, 0.03705768f, 0.06023551f, 0.17929699f, 0.12418693f, 0.31832695f, 0.15976840f, -0.38671646f, 
    0.00267347f, 0.08618084f, -0.04510694f, 0.02737561f, -0.01994294f, 0.04163719f, 0.00446481f, 0.10140239f, 
    -0.29214060f, 0.00426232f, 0.20604756f, 0.08087837f, -0.02110402f, 0.09197095f, -0.20079996f, -0.03303718f, 
    -0.21110322f, 0.04027594f, 0.01355421f, -0.02328952f, 0.44155663f, 0.45215601f, -0.03103943f, -0.02422714f, 
    0.01273604f, 0.04845943f, 0.01861935f, 0.26758802f, 0.04180067f, 0.06248109f, 0.03589494f, 0.09222972f, 
    0.39523387f, 0.21714339f, 0.15842423f, 0.04822122f, 0.16898331f, 0.20502679f, 0.07373043f, 0.32361630f, 
    0.18229355f, 0.03191421f, 0.03954281f, -0.09976562f, 0.08277209f, 0.28723040f, -0.13070598f, 0.00205845f, 
    -0.00675855f, 0.18419190f, -0.00568365f, 0.04420874f, 0.16356401f, -0.15066606f, -0.01454337f, 0.09425261f, 
    0.07055959f, 0.00726545f, -0.01216755f, -0.07243871f, -0.01493716f, 0.10178950f, 0.07098005f, 0.00411467f, 
    0.03477775f, 0.12308194f, 0.18695748f, 0.20130405f, -0.10420173f, -0.26717511f, -0.22483072f, -0.11481783f, 
    -0.01579984f, 0.10051835f, 0.06062934f, 0.03936842f, -0.00499565f, -0.03718117f, -0.05393670f, -0.16953617f, 
    0.02468237f, 0.16913137f, 0.07398256f, -0.08514986f, -0.04172647f, 0.11947785f, -0.12931088f, -0.09705870f, 
    -0.00917942f, -0.02658569f, 0.01194818f, 0.06602713f, 0.19607736f, 0.07730905f, 0.64576000f, 0.10916311f, 
    -0.01268388f, -0.11888709f, -0.08253613f, -0.02624922f, 0.15419988f, 0.04842110f, -0.04131857f, -0.08172028f, 
    -0.04986362f, 0.03071519f, 0.00224370f, -0.07688083f, 0.03025770f, -0.06304625f, 0.01912730f, 0.05746588f, 
    0.02728290f, 0.02889490f, 0.02535776f, 0.00164599f, -0.06721130f, -0.02801564f, -0.06151882f, -0.06504733f, 
    -0.05378310f, 0.00333509f, -0.00820827f, -0.04481116f, 0.02436525f, -0.01038157f, 0.04844108f, -0.05516705f, 
    -0.03238551f, -0.02254432f, -0.05748707f, -0.01992166f, 0.00982082f, -0.04622164f, 0.05125866f, -0.06440941f, 
    0.05635002f, -0.07416544f, 0.06094387f, 0.01172038f, 0.00805088f, -0.01200721f, 0.02295043f, -0.07777319f, 
    0.01211761f, 0.01434928f, 0.00566482f, -0.05216286f, -0.00829366f, 0.00777724f, -0.01697014f, 0.04882392f, 
    0.00868786f, 0.01511629f, -0.07162255f, -0.03083926f, -0.07855832f, 0.01356645f, -0.04009371f, -0.04050119f, 
    -0.02666302f, -0.04512003f, -0.02152258f, 0.03457888f, 0.03116271f, 0.00147946f, 0.04894425f, -0.01792292f, 
    -0.02699041f, 0.02357866f, -0.04400417f, 0.02750169f, 0.06566989f, 0.07255628f, -0.00847758f, 0.00744712f, 
    -0.07653710f, -0.01087772f, -0.02134708f, -0.03540213f, 0.05689795f, 0.02268519f, 0.01907246f, 0.04478794f, 
    0.00121421f, -0.04065486f, 0.02475808f, 0.03559631f, -0.00932783f, 0.00836377f, -0.04720398f, -0.06241376f, 
    0.00181024f, -0.07009567f, 0.03009202f, -0.06908358f, -0.04548022f, -0.07042222f, -0.01690452f, 0.05837701f, 
    -0.01931129f, -0.08065011f, 0.05383229f, 0.05760505f, -0.06565289f, 0.02317061f, 0.02623527f, -0.05373871f, 
    0.01959953f, -0.05340015f, -0.05575829f, -0.01498794f, 0.01756997f, -0.01234803f, 0.00339885f, -0.04506061f, 
    -0.06000850f, 0.04497106f, 0.00346824f, -0.01636281f, 0.01565576f, -0.06619710f, 0.02414631f, -0.01198833f, 
    0.05686478f, 0.00330374f, 0.05032254f, -0.06375228f, -0.06288147f, 0.01051769f, -0.05440269f, 0.03038489f, 
    -0.01713218f, -0.06140567f, -0.07867100f, -0.02391461f, 0.04311796f, -0.01086439f, -0.00267845f, 0.01752285f, 
    0.04867931f, 0.02048019f, -0.04470243f, 0.01968671f, -0.04985498f, -0.01191203f, -0.01674984f, -0.03448322f, 
    0.02219217f, -0.03782973f, -0.00008882f, 0.05212690f, -0.00809094f, -0.06180433f, 0.04995643f, 0.01015630f, 
    0.03062695f, -0.04641034f, 0.03065587f, -0.04979108f, -0.06798115f, -0.06697529f, -0.03070910f, 0.03197588f, 
    -0.01609993f, 0.01610581f, -0.05349466f, 0.02978925f, 0.01172982f, 0.02673076f, -0.04319132f, -0.01272578f, 
    -0.07779282f, 0.05367801f, -0.04394411f, 0.01976294f, -0.04959591f, 0.01909543f, 0.03754280f, 0.01288007f, 
    -0.05921319f, 0.03572375f, 0.04012765f, -0.00361469f, 0.02314897f, 0.05662845f, -0.06595042f, -0.04803780f, 
    0.03594882f, -0.04057568f, -0.01516730f, -0.06255597f, 0.02603913f, 0.04202052f, 0.04945423f, 0.04552773f, 
    0.05128167f, -0.04734965f, -0.00264793f, 0.00574932f, 0.04072533f, -0.02756379f, 0.00201913f, -0.05835832f, 
    -0.01705746f, 0.07760474f, 0.00141778f, -0.11658891f, -0.66085958f, -0.05835497f, -0.13945045f, 0.04387796f, 
    0.05373420f, -0.06184024f, 0.08878223f, -0.05286494f, 0.18362120f, 0.02309483f, -0.14636351f, -0.03280288f, 
    -0.34545073f, 0.08939880f, -0.07739051f, -0.39939746f, -0.01556533f, -0.10351966f, -0.01432858f, 0.08384670f, 
    -0.03989360f, -0.13772444f, -0.01861622f, -0.02869087f, 0.28795153f, 0.08080031f, -0.23963627f, 0.07840481f, 
    0.06040474f, 0.17210399f, 0.17842323f, -0.04792412f, -0.03227561f, -0.21564758f, 0.04839828f, -0.09162468f, 
    0.39555812f, -0.17785414f, 0.33482343f, -0.01197199f, -0.07725348f, -0.08556351f, -0.03262394f, 0.13040581f, 
    -0.04365642f, 0.06802949f, 0.02911302f, 0.06765542f, 0.04771293f, -0.00005111f, -0.06743952f, 0.08383092f, 
    -0.07318702f, -0.03168623f, -0.02235512f, 0.03116998f, 0.09471491f, -0.02661318f, 0.13185404f, 0.03543890f, 
    0.19977461f, -0.05926625f, -0.02130467f, -0.18744534f, 0.05331354f, -0.00662009f, -0.16674857f, 0.13303290f, 
    0.00194943f, 0.06570789f, 0.16498272f, 0.21248795f, -0.51144791f, -0.13199866f, 0.04786917f, -0.09519878f, 
    0.07833045f, -0.03514146f, 0.07788082f, 0.11387201f, -0.09192076f, -0.05236710f, 0.04409268f, 0.08765238f, 
    0.14500418f, -0.15463750f, 0.09665276f, 0.29184550f, 0.09338976f, 0.20387353f, 0.08571333f, -0.17777728f, 
    -0.16879126f, 0.08151866f, 0.01207213f, 0.10784877f, 0.15726005f, 0.10274426f, 0.23373549f, 0.02883145f, 
    0.06510643f, 0.12487421f, -0.06809320f, -0.03649184f, -0.00958054f, 0.03091905f, 0.03787860f, -0.00239259f, 
    0.19251053f, 0.04534369f, 0.35531378f, -0.03084861f, -0.04817314f, 0.13495536f, -0.03471261f, 0.05212754f, 
    0.17666151f, 0.09692296f, -0.03000026f, 0.03781630f, -0.37645778f, 0.26232752f, 0.00843381f, -0.09585595f, 
    0.04273544f, 0.03353547f, 0.00386984f, 0.01488650f, -0.01495599f, -0.07329177f, 0.00128925f, -0.07891214f, 
    -0.14434041f, 0.10527749f, 0.11498639f, 0.23795265f, -0.09470353f, 0.04018765f, -0.05539738f, 0.03064688f, 
    0.10593483f, -0.01494411f, 0.34631079f, 0.09652441f, -0.01282883f, -0.04114185f, -0.19086498f, 0.08043275f, 
    -0.08228564f, 0.02326506f, 0.02088140f, 0.19254151f, 0.05433290f, -0.03040111f, 0.08973081f, -0.10174900f, 
    -0.09130631f, 0.12157077f, -0.06345353f, -0.00884346f, 0.00025667f, 0.22602904f, -0.13842936f, -0.00069865f, 
    -0.00725568f, -0.02178051f, -0.07473953f, 0.02840241f, 0.15907389f, -0.01965074f, 0.53525949f, 0.08575747f, 
    -0.02453076f, -0.04388484f, -0.11720216f, 0.06484579f, -0.02261711f, 0.04305704f, -0.02236581f, 0.01623968f, 
    -0.21812801f, 0.16112816f, -0.38100454f, 0.07401924f, -0.05126275f, -0.00597572f, 0.02832796f, -0.12371634f, 
    0.19877031f, -0.00561573f, 0.07386877f, -0.08690237f, 0.17875563f, 0.11192249f, 0.12835442f, 0.24992123f, 
    -0.06198436f, -0.14734410f, -0.00501557f, 0.07896671f, 0.13671717f, -0.01426098f, 0.03552672f, 0.03857202f, 
    -0.39909944f, 0.01170355f, 0.15611267f, -0.01650264f, -0.11135143f, -0.10511488f, 0.04787207f, 0.28334758f, 
    0.15416820f, -0.13415881f, -0.09792266f, 0.02909872f, -0.13608457f, 0.07348221f, 0.06936758f, 0.07605328f, 
    0.10768468f, 0.22973806f, -0.09741263f, 0.04091731f, -0.04436238f, -0.31774107f, 0.12602881f, -0.13438612f, 
    -0.21846598f, -0.00172309f, -0.31410623f, -0.04581738f, 0.09905349f, -0.11314746f, -0.02059587f, 0.25144252f, 
    0.09268704f, 0.01424506f, -0.08773138f, -0.18515067f, -0.09504701f, -0.03188900f, -0.23925012f, -0.16322526f, 
    0.05461236f, -0.27441251f, 0.01838864f, 0.14856912f, 0.18502432f, -0.03230333f, 0.03500094f, -0.02840011f, 
    -0.13301037f, -0.20220356f, -0.05324356f, 0.25838998f, -0.05462832f, 0.08269835f, -0.11820744f, 0.06974737f, 
    0.03858619f, -0.14257328f, -0.10776436f, 0.01506194f, -0.37708488f, 0.05669721f, 0.02140801f, 0.08655488f, 
    -0.03660027f, -0.04852086f, 0.12684326f, 0.03567072f, 0.10359930f, -0.03839801f, -0.00119879f, 0.07531654f, 
    -0.15205668f, 0.38194782f, -0.06359146f, 0.19185956f, -0.00732618f, 0.15666190f, 0.00535695f, -0.03707819f, 
    -0.11056487f, 0.24558711f, -0.05248611f, -0.05240313f, -0.00370939f, 0.17005770f, 0.22756703f, -0.02599855f, 
    0.22188616f, -0.05014796f, 0.00231198f, 0.08766479f, 0.10386702f, -0.09830811f, 0.02909409f, 0.07409728f, 
    0.02354362f, 0.09028409f, 0.12855853f, -0.03902740f, -0.03993080f, 0.04303114f, -0.08359879f, 0.00498195f, 
    0.23846944f, 0.03771695f, 0.03348278f, -0.05816618f, 0.04330256f, -0.19467589f, 0.61885864f, -0.03135731f, 
    -0.00413790f, 0.18378653f, -0.33290800f, 0.07783861f, 0.08476307f, 0.03215725f, -0.09254776f, -0.02980448f, 
    -0.03430856f, -0.13015480f, -0.24429759f, -0.02051121f, -0.11451960f, -0.05189709f, 0.09138855f, 0.00456075f, 
    -0.00700226f, -0.04591217f, 0.15578960f, -0.06777951f, 0.05023295f, 0.05284441f, 0.18061215f, -0.16781752f, 
    -0.07238460f, -0.22779806f, -0.02234716f, 0.15419400f, 0.14648545f, -0.04994874f, 0.06104521f, 0.04529569f, 
    -0.04900215f, -0.19474639f, 0.14460738f, -0.07725814f, -0.06384812f, 0.08548756f, 0.00484584f, 0.21839711f, 
    -0.04626645f, 0.25261739f, -0.16474019f, -0.08881429f, -0.05151172f, -0.00813128f, -0.04302631f, 0.38311258f, 
    -0.02163091f, 0.02516391f, -0.03503175f, 0.10609683f, -0.02000009f, 0.09118354f, -0.01392634f, -0.12422156f, 
    -0.02567419f, -0.03301613f, -0.05597973f, -0.03869167f, 0.02093803f, -0.05893813f, -0.02828559f, -0.01443855f, 
    0.01347822f, -0.05350867f, -0.05081753f, 0.06431681f, 0.00177395f, -0.08013206f, 0.01909071f, 0.00147372f, 
    -0.02222594f, 0.06387936f, -0.07016661f, 0.01455329f, 0.06372129f, -0.04821354f, -0.01566539f, 0.03435922f, 
    -0.01662581f, -0.05684317f, -0.03333914f, 0.01237649f, 0.02611691f, 0.00426426f, 0.06651088f, -0.02269295f, 
    -0.04270262f, 0.02295233f, -0.02525934f, -0.03227776f, -0.03507845f, -0.05649336f, 0.04563550f, 0.04650700f, 
    -0.00280298f, 0.03840713f, 0.03023257f, 0.02761196f, -0.04141970f, 0.06099631f, 0.04310168f, 0.03786851f, 
    -0.03473222f, -0.01705797f, -0.00283087f, -0.04270132f, -0.06756203f, -0.05492431f, 0.01483787f, -0.06718364f, 
    -0.05382523f, -0.00966094f, -0.02691293f, -0.02251070f, 0.04101670f, -0.02714312f, 0.05258295f, 0.04015959f, 
    0.04118970f, 0.02644049f, 0.03495324f, -0.01521269f, 0.05700644f, 0.00425076f, 0.00459161f, 0.02317516f, 
    -0.06994043f, -0.05119142f, -0.02950395f, 0.02801702f, -0.01846111f, 0.03297478f, 0.04547969f, -0.06150094f, 
    0.01579145f, -0.07179803f, -0.03987618f, 0.01073137f, 0.04027767f, -0.02719573f, -0.07427856f, 0.04301807f, 
    0.01621022f, 0.01509780f, -0.05334729f, 0.00832723f, -0.04221615f, -0.05788067f, 0.02590510f, -0.01284103f, 
    0.05327543f, 0.01895011f, 0.00360124f, 0.00828774f, -0.02498307f, 0.05799556f, -0.05637911f, -0.01425832f, 
    0.05597061f, 0.03341881f, -0.03902598f, -0.05818329f, 0.05473713f, -0.03228109f, -0.03261335f, 0.06342595f, 
    -0.02557740f, -0.07203478f, -0.05664451f, -0.08131520f, -0.00901350f, -0.01142051f, -0.04099674f, -0.03554100f, 
    -0.07532964f, 0.06895342f, -0.01593596f, -0.01401605f, -0.04619527f, -0.05676376f, -0.01961221f, 0.05542262f, 
    -0.02223407f, -0.04388548f, -0.07041521f, 0.01557618f, -0.01035514f, 0.03854793f, 0.05788969f, 0.00353721f, 
    0.05772545f, -0.04503802f, -0.01618345f, 0.04759535f, -0.02977981f, 0.05841695f, -0.01016275f, -0.05001651f, 
    0.03024836f, -0.00912419f, -0.05115301f, 0.02415128f, -0.03343453f, -0.06931867f, -0.02790050f, 0.06521308f, 
    0.04125629f, -0.07663330f, -0.01067790f, 0.00564749f, -0.02175676f, -0.03390120f, 0.01423709f, -0.01789158f, 
    0.04111945f, -0.08008654f, -0.00820932f, 0.02562004f, -0.05500764f, -0.01281171f, -0.00728585f, 0.06279065f, 
    -0.00396266f, -0.01327586f, -0.04277127f, 0.03733056f, -0.05223699f, -0.00259940f, -0.06839568f, -0.07115337f, 
    -0.01102431f, -0.06168002f, 0.01099305f, 0.05099596f, -0.05247992f, -0.07155672f, -0.01141435f, -0.06486036f, 
    -0.00957747f, -0.06752107f, -0.03541429f, 0.07019729f, 0.05548790f, -0.00883065f, -0.02588195f, -0.06036939f, 
    0.04734151f, 0.24290147f, 0.24805236f, 0.17518985f, -0.01376747f, -0.04221900f, 0.05589260f, -0.03356164f, 
    0.09177485f, 0.03104744f, -0.02940452f, 0.08963234f, 0.08563309f, 0.12401748f, -0.57395607f, -0.11532041f, 
    -0.09501092f, 0.10611862f, 0.01812513f, 0.01336427f, 0.00516623f, -0.01249405f, 0.26194507f, -0.05432254f, 
    -0.32752323f, -0.48397505f, -0.36072421f, -0.25391477f, 0.11928530f, 0.14375953f, -0.13507338f, -0.11286304f, 
    0.00372381f, -0.04047009f, -0.09757800f, -0.03848439f, -0.09907351f, -0.11455534f, -0.11543309f, 0.28154239f, 
    0.26699668f, 0.22841373f, -0.17820093f, 0.08811155f, -0.04128547f, 0.12844548f, 0.10511999f, -0.00239803f, 
    0.43664080f, 0.08646696f, 0.34186327f, 0.37185636f, 0.07838145f, -0.08117941f, 0.06199643f, -0.05263934f, 
    -0.00564390f, -0.02944491f, -0.05795231f, 0.04383617f, 0.10083579f, 0.16882882f, 0.08845263f, 0.29271546f, 
    -0.05042771f, 0.04480627f, -0.11624221f, -0.05923962f, 0.23740949f, 0.04965498f, 0.09446082f, 0.22605328f, 
    -0.11691161f, 0.03168054f, 0.23248819f, 0.21101420f, -0.01662607f, 0.06284361f, 0.05224695f, -0.16066635f, 
    -0.13887030f, -0.08367513f, -0.08664472f, 0.07589300f, -0.23102984f, -0.44849783f, -0.37381592f, -0.92755270f, 
    0.02553419f, -0.09808702f, -0.05399987f, -0.28459480f, -0.18983836f, -0.17148817f, -0.06554572f, 0.12238219f, 
    0.00052604f, 0.15533470f, -0.21573681f, 0.11434616f, 0.09953008f, 0.21632116f, -0.03626425f, 0.33793509f, 
    -0.11478002f, -0.14999461f, -0.10506172f, 0.00450033f, 0.23584716f, -0.12505342f, -0.41466349f, -0.40857780f, 
    0.04953551f, 0.12985875f, 0.13166837f, 0.32544851f, 0.11312237f, 0.22124997f, -0.27634123f, 0.11304451f, 
    -0.58299547f, -0.17387782f, -0.53284532f, -0.23335126f, 0.11586912f, 0.05615199f, 0.26597583f, 0.16153464f, 
    -0.07127142f, 0.05902249f, -0.06909618f, -0.12898362f, 0.16964841f, -0.03394102f, -0.52061760f, 0.06195801f, 
    0.07755685f, 0.07284941f, -0.11562709f, -0.13207045f, 0.14166096f, 0.22192977f, -0.19310428f, 0.05161421f, 
    0.05636664f, 0.12110734f, 0.15992157f, 0.03932910f, 0.04997507f, 0.03353983f, -0.07049943f, 0.05420935f, 
    0.09848548f, 0.01461160f, 0.00293475f, 0.29426062f, 0.26610437f, -0.02303886f, 0.22584707f, 0.07402290f, 
    -0.04424924f, -0.09506857f, 0.03435195f, -0.13480917f, 0.05380809f, 0.09428447f, -0.03433803f, -0.02022049f, 
    -0.18344538f, 0.06779983f, 0.02956983f, -0.01621873f, -0.01791106f, 0.02309620f, 0.08981179f, -0.15157422f, 
    -0.15431188f, -0.16278979f, -0.00929421f, -0.08378763f, 0.10662579f, 0.52819568f, 0.30821347f, 0.32684410f, 
    0.11566090f, -0.03618636f, 0.03632055f, 0.03340049f, 0.01677842f, 0.00539069f, -0.04042388f, -0.03435415f, 
    -0.21270671f, -0.25042450f, -0.21368490f, 0.01084899f, 0.07098486f, -0.10067530f, -0.05065774f, 0.00295994f, 
    0.09253546f, 0.02553294f, 0.13852769f, -0.11866196f, 0.06029259f, -0.18881914f, 0.17112613f, -0.12884845f, 
    0.00502016f, 0.22049236f, 0.01077090f, 0.00858233f, -0.08095044f, -0.08778834f, -0.07095951f, 0.10318773f, 
    -0.25911492f, -0.08809002f, 0.04896902f, -0.02380344f, 0.08859011f, 0.25492430f, 0.06953352f, 0.04298905f, 
    0.00820686f, -0.09901385f, 0.16138157f, 0.12954016f, 0.32995465f, 0.31796843f, 0.09732138f, 0.00230313f, 
    -0.05894487f, -0.05227392f, -0.06067966f, 0.19129145f, -0.05580885f, -0.04042164f, 0.02603267f, -0.17363249f, 
    -0.11330496f, 0.12990043f, -0.15193185f, -0.15713640f, 0.03314266f, 0.04484929f, -0.10340270f, 0.00362266f, 
    0.12814239f, 0.05673534f, -0.05504753f, -0.07463256f, -0.25733235f, -0.26863393f, -0.34538853f, -0.11733760f, 
    0.00955771f, 0.01443208f, 0.15889613f, -0.06289159f, -0.08567658f, 0.10095892f, 0.01992831f, 0.03482754f, 
    0.12564114f, 0.25979477f, 0.23312160f, 0.08375107f, 0.03062903f, -0.19463995f, 0.00031474f, 0.10378463f, 
    0.00938773f, -0.01268930f, -0.14169313f, -0.02200442f, 0.26080692f, 0.00086235f, -0.01917325f, 0.18508598f, 
    0.05945725f, 0.16151433f, 0.14536846f, 0.13448766f, -0.00423212f, -0.01155122f, 0.03928585f, 0.06647579f, 
    -0.02478888f, -0.17193474f, 0.02765419f, 0.07685394f, -0.27360401f, -0.01716912f, -0.10322740f, 0.10366261f, 
    -0.03810549f, -0.05174793f, 0.03064415f, -0.15144318f, 0.51521051f, 0.44505921f, 0.20002422f, 0.33658600f, 
    0.01646783f, -0.06916118f, -0.00874989f, -0.06443244f, -0.03647087f, 0.06782524f, -0.01176620f, 0.11893646f, 
    0.31814244f, 0.12624347f, 0.29262313f, 0.06428137f, 0.03281548f, 0.07715524f, -0.15171076f, -0.12785731f, 
    -0.04282479f, -0.00154542f, -0.02773379f, 0.01518478f, 0.16924700f, 0.06467347f, 0.18038490f, -0.24020790f, 
    -0.12955873f, 0.17831415f, 0.06396907f, -0.12279014f, -0.19544950f, -0.13009985f, -0.11361050f, 0.13437144f, 
    -0.25566065f, -0.22918539f, -0.03692186f, -0.39258546f, -0.14534926f, 0.06150604f, 0.03313494f, -0.06012947f, 
    -0.11500967f, -0.05414381f, -0.43636376f, -0.01364042f, -0.05756428f, -0.20645632f, -0.18146369f, 0.00348116f, 
    0.24583535f, 0.10102092f, 0.04456316f, 0.01038604f, 0.10935383f, -0.01656894f, -0.14883451f, 0.03599913f, 
    0.06230698f, 0.11050670f, 0.25076267f, -0.04151998f, 0.05232564f, -0.06611536f, -0.18561052f, 0.13073628f, 
    0.10450445f, 0.04578812f, -0.15031455f, -0.11278944f, 0.27348107f, 0.02009338f, 0.27491921f, -0.03222122f, 
    -0.11121498f, -0.14250900f, -0.12573229f, 0.00290990f, 0.01259504f, -0.06293069f, -0.03554446f, -0.03347750f, 
    0.07761653f, 0.05940084f, 0.03291715f, 0.11497612f, 0.00210171f, 0.02577382f, 0.02287290f, 0.05222762f, 
    0.28891766f, 0.22648615f, -0.01562635f, -0.02532704f, 0.24107452f, -0.17956950f, -0.46625817f, -0.16956376f, 
    0.03063465f, -0.06056543f, -0.06101410f, 0.15499350f, -0.19018069f, -0.05574056f, 0.20387192f, -0.24817716f, 
    -0.23109040f, -0.74215084f, -0.36327061f, -0.41919193f, 0.01047310f, -0.22794710f, -0.16420870f, 0.00148653f, 
    0.00841163f, -0.17977153f, 0.05155600f, -0.04807436f, 0.22429094f, -0.01829046f, 0.01208995f, 0.16249408f, 
    0.03281256f, 0.21998622f, -0.23416518f, 0.00693520f, -0.11118609f, 0.11934655f, -0.01914900f, -0.10497120f, 
    0.67242891f, 0.37671927f, 0.22639593f, 0.16312568f, -0.05801727f, -0.09750686f, 0.01372750f, -0.04643342f, 
    0.10302267f, 0.01725933f, 0.00626122f, 0.01338839f, 0.08184289f, 0.16563179f, 0.04549175f, 0.12679218f, 
    0.00038123f, 0.03885015f, -0.00191697f, 0.07075421f, 0.10711800f, 0.08931381f, 0.01516359f, 0.14673395f, 
    0.09027853f, 0.16301329f, 0.20300150f, 0.18225555f, 0.07120664f, 0.06920439f, -0.16443254f, -0.07570256f, 
    -0.09419114f, -0.11975813f, -0.08100063f, 0.01878200f, -0.14030074f, 0.05865328f, 0.01393570f, -0.53307354f, 
    -0.14316048f, -0.05934859f, -0.06605659f, 0.06121412f, -0.00474254f, -0.01597345f, -0.08282568f, -0.04813182f, 
    0.05393236f, 0.19635636f, 0.16427015f, 0.06532066f, -0.05300182f, -0.01032276f, -0.09825195f, 0.10828219f, 
    0.07502467f, 0.01714741f, -0.01061050f, -0.08079406f, -0.22944382f, -0.06654228f, 0.22434452f, 0.14765811f, 
    0.11892837f, 0.09246697f, 0.08312928f, 0.25394529f, 0.07915143f, -0.09458274f, -0.16504255f, 0.18897636f, 
    -0.40479088f, -0.53619838f, -0.36719421f, -0.24656765f, 0.16469055f, 0.00038555f, -0.10938140f, 0.23064111f, 
    0.01728508f, -0.06392528f, 0.00261898f, -0.04730473f, 0.03098963f, 0.00350651f, -0.24471989f, 0.15818453f, 
    0.02747022f, 0.23298785f, -0.13577490f, 0.05391788f, 0.09526919f, -0.09682941f, -0.10834716f, 0.13875303f, 
    0.04132931f, 0.10258701f, 0.19484393f, -0.14740595f, -0.02832985f, 0.29078788f, 0.04562735f, -0.02943658f, 
    0.12355571f, 0.03461177f, 0.01281966f, 0.17631967f, 0.15897012f, -0.11863627f, -0.00423041f, 0.02460079f, 
    -0.00522265f, 0.03223398f, 0.03370247f, 0.02750078f, -0.08402780f, 0.03777599f, 0.01135892f, -0.02699478f, 
    -0.00485675f, 0.01904305f, 0.09514143f, 0.10337173f, -0.13559891f, 0.01890419f, 0.03869063f, 0.03561037f, 
    -0.08167837f, -0.06373475f, -0.03005120f, -0.04639310f, 0.20235674f, 0.21014731f, 0.35290870f, -0.09250353f, 
    -0.14885128f, -0.07711187f, -0.05157159f, 0.15127690f, 0.01774963f, 0.04778553f, 0.13294193f, -0.00600744f, 
    0.04713689f, 0.05210733f, -0.02219893f, 0.01895015f, -0.02380693f, -0.04487647f, 0.00412780f, -0.04657769f, 
    -0.00803537f, -0.08041397f, 0.01798116f, 0.04377774f, -0.05701270f, -0.05192609f, -0.02788806f, -0.01849759f, 
    0.00464777f, -0.07634715f, -0.01405033f, 0.05012234f, -0.02457443f, 0.05117624f, 0.02364963f, 0.02940858f, 
    -0.00975084f, -0.01474100f, 0.00860888f, -0.00762352f, 0.00887548f, -0.06692535f, -0.02369343f, 0.02931765f, 
    0.05015709f, 0.03522010f, -0.03320257f, -0.00096467f, 0.05978276f, 0.04276164f, -0.03354841f, 0.03089353f, 
    -0.06526387f, -0.04888952f, -0.02347527f, 0.02669781f, 0.00523772f, -0.06035929f, -0.07231978f, -0.01080120f, 
    -0.08120456f, 0.04046745f, -0.00976960f, -0.04220217f, -0.02341898f, 0.01860780f, -0.05230178f, 0.02753372f, 
    0.00851954f, -0.00493174f, -0.07966912f, -0.05292046f, -0.02433678f, -0.01221059f, -0.04337539f, 0.01931878f, 
    0.01378537f, -0.05895134f, 0.05271654f, -0.07260680f, -0.04942285f, -0.04074253f, -0.02259231f, -0.02899521f, 
    -0.06110274f, 0.00980770f, 0.03658936f, 0.05434178f, -0.06507050f, -0.04615961f, 0.05791924f, -0.06891116f, 
    0.04744844f, 0.00860399f, 0.02477335f, 0.02970805f, -0.04787034f, -0.05818463f, 0.06928632f, -0.02220086f, 
    0.00356713f, -0.03628469f, -0.01093389f, 0.00742297f, 0.02304054f, -0.00694646f, 0.01088255f, 0.05423901f, 
    0.04534034f, -0.05029922f, 0.02027839f, -0.02559905f, 0.02887146f, -0.03484101f, -0.00657170f, 0.05429872f, 
    0.02285561f, -0.03967799f, 0.03889768f, -0.03936684f, 0.06331962f, 0.04859172f, -0.01394032f, 0.03571106f, 
    -0.03982897f, 0.01410583f, -0.02227223f, 0.06224578f, 0.00780730f, -0.07992708f, 0.05413899f, 0.02740913f, 
    -0.03414020f, -0.06290112f, 0.03032520f, -0.02129627f, -0.06241096f, -0.04292703f, -0.00490969f, -0.00605034f, 
    -0.00931674f, -0.08511694f, 0.02777315f, 0.00612112f, -0.08232038f, 0.01242728f, 0.01111148f, 0.00146077f, 
    -0.00006029f, 0.02586039f, -0.06374314f, 0.03925960f, 0.01832999f, 0.01081052f, -0.04540796f, -0.01746754f, 
    -0.04491238f, 0.00766637f, -0.04771143f, 0.00766667f, -0.02254720f, 0.04664967f, 0.01380143f, -0.05839174f, 
    0.01105867f, 0.05061145f, -0.04576510f, -0.04396126f, 0.03322698f, 0.03315026f, -0.00592609f, -0.05609491f, 
    -0.05534364f, 0.04733627f, -0.01818341f, 0.05391294f, -0.02191278f, 0.00963535f, -0.00584017f, 0.00214529f, 
    -0.04071152f, 0.02486809f, 0.01483988f, -0.06547621f, -0.02090190f, -0.00930472f, 0.03961352f, -0.02252451f, 
    0.04553396f, 0.00837351f, -0.03115229f, -0.05788947f, 0.04549335f, -0.03768595f, 0.00663196f, -0.05442974f, 
    0.01491071f, -0.02981233f, 0.04645425f, 0.02507523f, -0.05138895f, 0.00939557f, -0.03245955f, -0.05637886f, 
    0.12664235f, 0.12439720f, 0.06632977f, -0.07125242f, 0.03273201f, -0.00095895f, 0.09048591f, -0.04458398f, 
    0.05480284f, 0.14786960f, 0.06330907f, 0.08115584f, 0.35279885f, 0.20629446f, 0.11543097f, 0.16215689f, 
    0.03344523f, 0.06932583f, 0.04808028f, -0.15881148f, 0.05604549f, 0.04095273f, -0.05308909f, 0.03143576f, 
    0.15445559f, -0.14613844f, 0.00112766f, 0.08244458f, -0.02848717f, -0.02565185f, -0.04948911f, 0.12802218f, 
    -0.07172195f, 0.03280004f, 0.12798898f, 0.16766217f, 0.18056092f, -0.17376830f, -0.05983799f, 0.39080393f, 
    0.02708090f, 0.07586828f, 0.15233976f, 0.05510523f, -0.05600331f, 0.01525631f, -0.07414785f, -0.08243469f, 
    -0.27271095f, 0.03028668f, 0.11836670f, -0.17512962f, 0.11086374f, 0.07053073f, 0.07766163f, 0.15321079f, 
    -0.00874552f, -0.09194832f, 0.08862147f, 0.05232732f, -0.14274861f, -0.06658780f, 0.06779371f, -0.07418560f, 
    0.02662186f, 0.12256613f, 0.00858373f, -0.03817615f, -0.09449381f, -0.04986689f, -0.09734837f, -0.03538357f, 
    0.28400943f, -0.08016531f, -0.12983459f, 0.02086809f, 0.00817718f, 0.00406841f, 0.17164135f, -0.04407077f, 
    -0.05803934f, -0.10128687f, -0.06615175f, -0.23091199f, 0.56514144f, -0.37504560f, 0.14305568f, 0.12743510f, 
    -0.08445369f, -0.04803433f, 0.08755831f, 0.11293107f, 0.13838948f, 0.02176026f, 0.07196864f, -0.02318843f, 
    0.28555894f, 0.14542550f, -0.04495031f, 0.02852160f, 0.27759883f, 0.16143522f, 0.16053782f, -0.03170510f, 
    0.10052039f, -0.11368062f, -0.10233261f, 0.01915015f, -0.07810142f, -0.23685199f, 0.33168861f, 0.17047277f, 
    0.05049417f, 0.00255911f, 0.02235843f, -0.12227979f, 0.05292425f, 0.04067092f, 0.21806990f, -0.17779934f, 
    -0.11349466f, -0.00656683f, -0.05489151f, -0.00402282f, -0.11906232f, -0.24645998f, -0.13785766f, 0.00146400f, 
    -0.02841482f, 0.08254546f, -0.06672090f, 0.12172787f, -0.40559471f, 0.07700203f, -0.13944654f, 0.20117854f, 
    0.16495569f, 0.06396687f, -0.22979257f, -0.16788989f, -0.19884516f, 0.05705092f, 0.00293275f, -0.02357378f, 
    -0.02990788f, 0.00274710f, -0.02512057f, -0.14205712f, -0.03776043f, -0.04162757f, 0.03508069f, -0.05032976f, 
    -0.03260138f, -0.05305464f, -0.07237721f, -0.20259911f, -0.07914416f, 0.20479494f, 0.11471184f, 0.05974020f, 
    0.14605238f, 0.00954414f, -0.08470587f, 0.01288340f, 0.02358039f, 0.12714228f, 0.08568689f, 0.15907274f, 
    0.03834812f, 0.00434312f, -0.08887479f, -0.03140106f, 0.10181807f, 0.03154149f, -0.00908524f, 0.10567641f, 
    0.12878850f, -0.09818114f, 0.00983060f, -0.03978639f, 0.22225593f, -0.05791555f, -0.18078373f, 0.04869051f, 
    -0.15543163f, 0.09139800f, 0.04837419f, 0.07257190f, 0.01716111f, 0.02371827f, 0.05387206f, 0.02285603f, 
    0.03026893f, -0.04452220f, 0.00692706f, -0.00970300f, 0.06189019f, 0.00276731f, -0.04860346f, -0.12171772f, 
    -0.13142279f, -0.06125762f, -0.05473546f, 0.31052488f, 0.39703253f, 0.37477756f, -0.11759540f, 0.12248043f, 
    -0.13499060f, 0.13395607f, 0.10423198f, -0.00677070f, -0.12555076f, -0.19357440f, -0.05481363f, -0.01183516f, 
    0.30322567f, 0.05977565f, 0.11945002f, 0.19723935f, 0.13338785f, 0.04231979f, -0.00061723f, -0.15870978f, 
    -0.02498311f, 0.21645394f, -0.11251716f, 0.07013848f, -0.12071627f, -0.04130751f, 0.04327534f, 0.34991804f, 
    0.06294855f, -0.04783966f, 0.10894021f, 0.01164245f, -0.01440499f, 0.08598009f, -0.10535455f, 0.05748030f, 
    -0.14270917f, -0.01027363f, -0.02951221f, -0.05819935f, -0.03208961f, 0.04670056f, -0.00522340f, -0.02161550f, 
    -0.06585483f, -0.09009344f, 0.08030311f, -0.05351657f, -0.17126542f, -0.22174494f, 0.04743035f, -0.03938894f, 
    -0.16596727f, 0.16862884f, 0.00182186f, -0.09812465f, -0.22105815f, 0.01279445f, -0.20440368f, 0.07499112f, 
    -0.10423747f, 0.06992761f, 0.07485668f, 0.18327212f, 0.03174107f, 0.08625396f, 0.21278553f, 0.03137992f, 
    -0.00528605f, -0.05464441f, -0.16350156f, -0.19097200f, 0.35912943f, 0.25463960f, 0.18142597f, -0.10428033f, 
    0.03466584f, 0.05301660f, 0.00871954f, -0.07910240f, 0.11653185f, 0.08520266f, -0.08233169f, -0.03290991f, 
    -0.32499999f, -0.13340156f, -0.04987962f, -0.18523625f, 0.08018313f, -0.07807552f, -0.14215790f, 0.09280763f, 
    0.04160907f, -0.08144786f, -0.11744679f, -0.08601483f, 0.12055843f, -0.02557300f, 0.09038208f, 0.16997416f, 
    -0.03058071f, -0.08763710f, 0.02596569f, 0.16868275f, 0.07537776f, 0.19251645f, 0.06218840f, 0.02638053f, 
    -0.01538898f, 0.20824860f, 0.04587541f, 0.29544145f, -0.06459359f, 0.02687665f, 0.07997232f, 0.36851597f, 
    -0.06664468f, -0.06079456f, 0.11867630f, 0.03656436f, -0.03043883f, 0.09010617f, -0.15658635f, 0.35541648f, 
    -0.23142385f, 0.04750839f, -0.07521003f, -0.09652042f, 0.05800319f, 0.07142848f, -0.05099012f, 0.09176309f, 
    -0.49887037f, 0.02898839f, 0.05788147f, -0.33450669f, -0.14258535f, 0.06290123f, 0.02779443f, -0.02473682f, 
    -0.12480281f, 0.01605943f, -0.12042972f, 0.06130181f, -0.12251570f, 0.00818648f, 0.00458630f, -0.02599039f, 
    -0.02201547f, 0.01393512f, 0.07848603f, -0.08832482f, 0.01782718f, 0.03506236f, -0.05256440f, 0.04942688f, 
    0.04763353f, 0.08941172f, -0.11019155f, 0.01382229f, 0.12325948f, 0.01527639f, -0.01799136f, 0.00403628f, 
    -0.15900804f, -0.08181278f, 0.00758450f, -0.08700816f, -0.18363599f, -0.18123509f, 0.02161060f, 0.06400488f, 
    0.19715632f, 0.10705158f, -0.06297255f, -0.07677460f, 0.09239407f, -0.00039394f, 0.07871757f, 0.04004816f, 
    -0.00162736f, -0.34224868f, 0.20574944f, -0.05028811f, -0.04467105f, -0.14206260f, -0.11330900f, -0.06832474f, 
    -0.19387713f, -0.10426592f, -0.11098715f, 0.02429888f, 0.15633503f, 0.28304633f, 0.09558457f, -0.16995555f, 
    -0.03124334f, 0.15133040f, 0.04318399f, 0.06596590f, -0.13128550f, -0.00331148f, -0.07069430f, 0.05094713f, 
    0.48302683f, 0.22534163f, 0.09682555f, 0.09348568f, 0.08389445f, 0.14615288f, -0.02935052f, -0.10332137f, 
    -0.01448386f, 0.17866215f, 0.02472649f, 0.00351315f, 0.04949506f, -0.05930179f, -0.02109485f, -0.09765695f, 
    0.02088330f, -0.10692433f, 0.10850854f, -0.12920474f, 0.01513199f, 0.09907431f, -0.09296866f, 0.27275676f, 
    -0.09508815f, -0.35026813f, 0.01980866f, -0.13052702f, -0.18373320f, 0.14725068f, -0.13292938f, -0.14583430f, 
    -0.11603253f, 0.09001390f, 0.02490647f, 0.03885249f, -0.41863927f, -0.31909326f, -0.10472006f, -0.21005963f, 
    -0.13597701f, 0.11623106f, 0.07925736f, -0.11575525f, -0.09533747f, 0.03330927f, -0.10263658f, -0.00773967f, 
    -0.10666917f, 0.11919151f, 0.04769736f, -0.11516902f, -0.06769521f, 0.09707486f, 0.10438676f, -0.08554155f, 
    -0.08360590f, 0.03165314f, -0.08141784f, 0.01101055f, 0.26479053f, 0.29256207f, 0.27451670f, 0.07075859f, 
    0.12869354f, 0.20754576f, 0.10853889f, -0.00740810f, 0.03090458f, 0.06159716f, -0.10644615f, -0.09390289f, 
    -0.18900834f, -0.44332558f, 0.01926648f, -0.30416253f, -0.19995321f, -0.18839906f, 0.01074094f, -0.14614400f, 
    0.04508672f, -0.07441837f, 0.04747108f, -0.00080964f, 0.23008543f, 0.24209724f, -0.03548534f, 0.14282048f, 
    0.01512183f, -0.01873429f, -0.09845269f, 0.03009387f, -0.08531502f, 0.09493085f, 0.00299185f, -0.01113651f, 
    0.11291735f, 0.31895313f, 0.09776180f, 0.17451972f, 0.14441775f, 0.00145902f, 0.18963733f, 0.16493911f, 
    -0.23395225f, -0.16333613f, 0.03049100f, 0.07039276f, 0.24699803f, 0.40246964f, -0.29920164f, 0.10855262f, 
    0.03084873f, -0.06833361f, 0.27974209f, 0.02872673f, -0.01892045f, 0.05886684f, 0.03126178f, 0.01299529f, 
    -0.58140093f, -0.04027044f, 0.22453769f, -0.24166900f, 0.04962486f, 0.04392424f, 0.00386748f, -0.04590184f, 
    0.02578825f, 0.04409426f, -0.23153105f, -0.09802834f, -0.30349910f, -0.08456456f, -0.41768256f, 0.12674962f, 
    -0.04541871f, 0.12825082f, 0.15616789f, -0.10511651f, -0.05346466f, -0.00494776f, -0.05230708f, 0.01909860f, 
    -0.10538761f, 0.12803207f, 0.00414568f, -0.00704823f, 0.10779393f, 0.02489572f, 0.02263213f, -0.11388177f, 
    -0.07302961f, -0.09888446f, 0.08562691f, -0.09167707f, -0.34399220f, -0.05580934f, 0.08864702f, -0.42841175f, 
    0.14568879f, -0.02333429f, -0.04758984f, -0.02518367f, 0.01118981f, -0.03308320f, -0.09862583f, 0.06119965f, 
    -0.08805541f, -0.09885720f, 0.07336688f, 0.04777864f, 0.00774206f, -0.03505849f, -0.08087804f, 0.02003505f, 
    -0.04818136f, 0.13824309f, 0.09680519f, -0.00246277f, 0.46334735f, -0.09030426f, 0.21577629f, -0.11021099f, 
    0.03680804f, 0.05411764f, -0.16812193f, 0.05123386f, -0.09578768f, -0.04968066f, 0.08138951f, -0.01286989f, 
    0.36731195f, -0.04189739f, -0.04465998f, 0.11131729f, 0.18105361f, 0.04242386f, -0.11239938f, -0.07034663f, 
    -0.03315125f, 0.08160251f, 0.23182403f, 0.19778498f, -0.06461783f, -0.08577495f, 0.12581392f, -0.09125422f, 
    -0.06510950f, 0.04432664f, -0.07953230f, -0.14430566f, -0.12777370f, 0.15417375f, 0.03557750f, 0.07929634f, 
    -0.16658750f, 0.05574407f, -0.13669734f, 0.06637686f, 0.02458701f, 0.13202764f, -0.01128906f, -0.05786574f, 
    0.03443183f, 0.03975772f, 0.07827308f, 0.02643502f, 0.01259875f, 0.08464164f, 0.10713205f, -0.02068802f, 
    0.04619012f, 0.10802945f, 0.00181527f, -0.00436325f, -0.09712052f, -0.05159599f, -0.21612847f, -0.16050959f, 
    0.09932891f, 0.11321254f, 0.00146928f, 0.04901278f, -0.00155170f, 0.09264801f, 0.13539737f, -0.05136271f, 
    0.02922623f, 0.02276013f, -0.11699474f, -0.18732958f, 0.49446788f, -0.03344256f, 0.03012076f, 0.07923458f, 
    0.05518905f, 0.03841582f, 0.11921799f, 0.02317519f, 0.01542789f, 0.04726655f, 0.05016009f, 0.12708931f, 
    0.01220555f, -0.00030648f, 0.14787778f, -0.14798631f, -0.27845955f, -0.16652474f, 0.14406870f, 0.00206299f, 
    0.05423841f, -0.03942978f, 0.02950228f, 0.02244061f, -0.18675901f, 0.01115251f, -0.21109453f, -0.09502319f, 
    0.09255870f, -0.02911165f, 0.17525722f, 0.09053919f, -0.12437877f, -0.18512426f, -0.12687051f, 0.02094649f, 
    -0.06871393f, 0.06515182f, -0.15643539f, -0.04954331f, 0.13224936f, -0.10164668f, 0.09157118f, -0.10581315f, 
    -0.12540938f, -0.03100526f, -0.08692187f, -0.03758252f, 0.32990089f, 0.11090284f, 0.02657801f, -0.03452114f, 
    -0.02942375f, 0.08868129f, -0.01208723f, 0.07296425f, 0.02547049f, 0.08832102f, 0.00697185f, 0.14966086f, 
    0.07257418f, 0.04717031f, 0.18198381f, -0.31273136f, 0.05669922f, 0.02527104f, -0.00926663f, -0.00464621f, 
    -0.06105037f, 0.05881425f, -0.16554455f, -0.23931792f, 0.03975014f, 0.06737550f, 0.14892723f, -0.06637671f, 
    0.06431735f, 0.04182280f, 0.05551774f, -0.02149965f, -0.09916625f, 0.08277242f, -0.02832702f, 0.01400810f, 
    0.06928501f, 0.00731535f, -0.00003920f, 0.00352899f, -0.09452651f, -0.21393368f, 0.09450434f, 0.12970373f, 
    -0.01349536f, -0.10549662f, 0.00543395f, 0.00432555f, -0.01243047f, -0.12438753f, -0.20741986f, -0.17082159f, 
    -0.01273170f, 0.13019255f, 0.00075529f, -0.00908576f, -0.04594109f, 0.08188392f, 0.10921098f, 0.09853417f, 
    0.19456546f, 0.04074697f, 0.31007361f, -0.07164806f, -0.00562680f, -0.16048211f, -0.06213109f, 0.00586584f, 
    -0.12233804f, 0.06859138f, -0.00368352f, 0.42735040f, -0.09678034f, 0.25382808f, 0.09214462f, 0.19148102f, 
    -0.04958472f, -0.01945812f, 0.23836832f, 0.14705876f, -0.06703251f, -0.04733701f, 0.06112640f, -0.10651509f, 
    0.10457689f, 0.05057468f, 0.11229328f, 0.34344110f, -0.14745294f, 0.05113161f, -0.02093990f, -0.06495374f, 
    -0.03545776f, 0.20133963f, -0.12204394f, -0.16984297f, -0.27619994f, -0.01131304f, 0.39369351f, 0.01783803f, 
    0.21692176f, -0.31398785f, 0.14115192f, -0.04386942f, 0.15572515f, 0.17973380f, -0.10924098f, 0.07229707f, 
    0.34007367f, 0.26111019f, 0.18803518f, -0.02695680f, -0.11951006f, -0.06848209f, 0.13503331f, -0.08427858f, 
    -0.08493359f, -0.06485642f, -0.04040930f, -0.03323828f, 0.22204332f, 0.00996525f, 0.02054407f, 0.09914467f, 
    -0.11838977f, 0.11442685f, -0.00118221f, 0.02542905f, 0.09827519f, 0.02693689f, 0.11832703f, 0.07869413f, 
    -0.09980583f, -0.06363580f, 0.08259091f, 0.03006853f, 0.06835952f, -0.05008102f, 0.06056071f, 0.12690851f, 
    0.03333413f, 0.12487134f, 0.01234635f, -0.04474415f, -0.00526867f, 0.30211967f, 0.06055813f, 0.15400401f, 
    0.02333537f, 0.02263504f, -0.17715861f, -0.18086137f, -0.04505338f, 0.02976272f, -0.10493380f, -0.15880509f, 
    -0.20501386f, -0.04188590f, 0.08805823f, -0.12605041f, 0.28808004f, -0.11076264f, -0.26298293f, -0.05802019f, 
    -0.04845649f, -0.01344523f, 0.11596637f, -0.00253525f, -0.08103403f, -0.33850384f, -0.05844880f, 0.14929615f, 
    -0.17079818f, -0.02109484f, -0.02807867f, -0.08186951f, -0.00606871f, 0.09263100f, -0.04289296f, 0.09971272f, 
    -0.18733533f, -0.23408391f, -0.12195925f, 0.18881008f, -0.02744859f, -0.01243682f, 0.17730476f, 0.14835781f, 
    -0.09056965f, -0.02665090f, 0.02543484f, 0.05285082f, -0.12895022f, -0.06074083f, -0.39631262f, 0.26887217f, 
    -0.11909498f, -0.18988335f, 0.08531220f, 0.07739958f, 0.14562191f, 0.19031624f, 0.18524675f, -0.07557264f, 
    -0.05094631f, 0.03626725f, -0.10484499f, 0.11042117f, -0.01104812f, -0.03112070f, 0.00270123f, -0.08267973f, 
    0.02480888f, 0.00856605f, 0.09093527f, 0.31410179f, -0.08444389f, 0.11537374f, -0.03572306f, -0.00631523f, 
    -0.04855785f, 0.09692274f, 0.03108296f, -0.02622761f, 0.06441922f, 0.07003804f, 0.06822700f, -0.00102499f, 
    -0.00965116f, -0.05090765f, -0.18438369f, 0.00517604f, 0.27780202f, 0.07799735f, -0.00023337f, -0.05902226f, 
    -0.13424276f, 0.07304503f, 0.09936887f, -0.01931313f, -0.03594140f, 0.01748803f, -0.01171505f, -0.15197645f, 
    0.02830173f, -0.04254770f, 0.04324319f, -0.12328651f, 0.00882158f, -0.07293569f, 0.03194565f, -0.02759141f, 
    0.01610505f, -0.05993552f, -0.00688061f, -0.00146430f, 0.06323650f, -0.02612371f, -0.01930122f, -0.01423535f, 
    -0.04308159f, 0.03809460f, -0.01175540f, -0.00589503f, -0.05920495f, -0.07215720f, -0.02991738f, 0.02592122f, 
    0.00994518f, -0.04381287f, -0.06483886f, -0.01010425f, 0.01551293f, -0.06042618f, 0.02720017f, -0.06665562f, 
    -0.00361487f, -0.04462054f, 0.03875624f, -0.00229807f, -0.05005497f, 0.04634937f, -0.03680992f, 0.05997969f, 
    -0.03140515f, -0.00075693f, -0.02911384f, -0.06676304f, 0.04612066f, -0.00510885f, 0.00958897f, 0.00500678f, 
    0.06673852f, 0.04742442f, 0.04673685f, -0.06677492f, 0.05164130f, -0.07200641f, 0.05823649f, -0.03197845f, 
    -0.01668640f, -0.04261955f, 0.02422745f, -0.00264706f, -0.01972413f, 0.03111915f, -0.07407636f, -0.04650259f, 
    0.00131841f, -0.03937086f, -0.03826382f, -0.07222942f, -0.03099716f, -0.02653178f, 0.00752530f, -0.02844879f, 
    -0.06988189f, -0.01822856f, -0.06525280f, 0.05087886f, 0.06483322f, -0.05451454f, -0.07286913f, -0.05730302f, 
    -0.04029945f, -0.05399359f, -0.04932188f, 0.01616669f, 0.00255430f, 0.00438368f, -0.01627713f, -0.00067896f, 
    -0.01901674f, 0.06113383f, -0.05344382f, 0.03812032f, 0.00196854f, -0.02065947f, -0.04445974f, -0.03368807f, 
    -0.00613134f, 0.01705187f, -0.06175068f, -0.00679722f, 0.02213366f, -0.06635893f, 0.05804299f, -0.04086915f, 
    -0.00522411f, 0.01869044f, 0.01061711f, 0.01060926f, -0.05129745f, -0.03385326f, 0.03144472f, -0.03280843f, 
    0.00680117f, -0.06149017f, -0.03610260f, 0.02633342f, -0.05482468f, -0.00534370f, -0.07183082f, 0.00349515f, 
    -0.07329501f, -0.03203440f, 0.05794255f, 0.05117761f, 0.02266339f, -0.03026959f, -0.05576792f, -0.07358257f, 
    0.06551995f, 0.00717292f, 0.06365805f, 0.04264363f, -0.01377609f, -0.07206062f, 0.05016601f, -0.03718668f, 
    -0.01081239f, 0.03504409f, 0.00496729f, 0.05568492f, 0.06340214f, -0.06541885f, -0.00764497f, -0.04016924f, 
    -0.00441057f, 0.01118920f, 0.01643032f, -0.02971527f, 0.00796528f, 0.00641481f, 0.02209967f, -0.02801344f, 
    -0.00601289f, 0.00097200f, -0.04110717f, -0.03973804f, -0.03607501f, 0.05692853f, 0.05107506f, 0.04220281f, 
    0.06441779f, -0.05123081f, -0.07601965f, 0.00876646f, 0.04712013f, 0.01433416f, 0.06241151f, 0.04755587f, 
    -0.04467864f, -0.05626028f, 0.00827071f, 0.03854205f, -0.05200256f, -0.02429918f, -0.00021800f, 0.01087294f, 
    -0.03683856f, -0.02400302f, -0.06927162f, -0.00046801f, 0.02334358f, -0.06583913f, -0.02029162f, 0.06219628f, 
    0.05305606f, -0.02629234f, 0.01879186f, -0.00928339f, 0.00604199f, 0.04162624f, 0.03393601f, -0.07725114f, 
    -0.00731878f, 0.04112472f, -0.06017511f, -0.06839837f, 0.02590527f, 0.01281511f, -0.02826636f, 0.06607348f, 
    -0.28361166f, 0.03752523f, -0.09440771f, 0.07036081f, -0.05785786f, 0.07414935f, 0.13086966f, 0.04295068f, 
    0.05667314f, -0.08279505f, 0.06263604f, -0.14317474f, -0.14636576f, -0.03353560f, -0.07452921f, -0.16608569f, 
    -0.05136642f, -0.08359720f, -0.16481252f, -0.06842091f, 0.12538764f, 0.20138000f, -0.08451281f, 0.19369693f, 
    -0.21308218f, 0.08182304f, -0.04888585f, -0.14330924f, -0.03726092f, 0.09196331f, -0.04128125f, 0.20667255f, 
    -0.00889920f, -0.03550615f, 0.07931264f, -0.07471318f, 0.20344964f, 0.14879841f, -0.16098875f, -0.20513141f, 
    -0.00562360f, 0.11436836f, 0.06531014f, 0.36447534f, 0.07997976f, -0.08147699f, 0.11941069f, 0.03741471f, 
    -0.46288025f, -0.25589406f, -0.26754889f, 0.10749143f, 0.21154362f, 0.09859865f, 0.03804036f, 0.08095343f, 
    -0.03523217f, -0.04701902f, -0.11215980f, 0.03319619f, -0.05692778f, -0.08373035f, 0.01850319f, 0.03980432f, 
    -0.03110305f, -0.15234703f, -0.05099560f, -0.14323357f, 0.11208250f, 0.04503024f, 0.09756452f, -0.06339474f, 
    -0.13750972f, 0.11174955f, -0.13971883f, 0.01723022f, -0.05935690f, -0.13223237f, -0.02919065f, -0.00547668f, 
    0.07188375f, 0.06253154f, 0.02477576f, 0.20911580f, -0.33783099f, -0.17773199f, -0.13328022f, 0.01589126f, 
    0.02690408f, 0.07954266f, 0.26959550f, 0.15936404f, -0.02234638f, -0.00673689f, 0.13172802f, 0.02928001f, 
    0.38256669f, 0.26189730f, -0.28940150f, 0.07965828f, -0.13319650f, 0.07135036f, 0.25612414f, 0.10208695f, 
    -0.14919753f, 0.10203772f, 0.08793446f, 0.02692617f, 0.16570790f, 0.31471345f, 0.06924562f, -0.19110946f, 
    -0.01499045f, 0.11186105f, 0.06440488f, -0.05151148f, -0.03005243f, -0.08121144f, 0.13332112f, 0.02665757f, 
    0.14514919f, 0.09297466f, 0.09295727f, -0.17494044f, 0.03881554f, 0.12900639f, 0.02773181f, -0.15028121f, 
    0.13325776f, -0.04380442f, -0.01058677f, 0.05786541f, 0.43195242f, -0.21175781f, 0.47479764f, -0.31450474f, 
    0.05313515f, 0.13584289f, 0.19397849f, -0.02834960f, 0.08375832f, -0.06524862f, 0.02782496f, -0.09095940f, 
    0.27846372f, 0.04234755f, -0.04380634f, 0.13518088f, 0.09307580f, -0.11556780f, -0.07892630f, -0.11933871f, 
    0.07047906f, 0.01202668f, 0.06303780f, 0.09082658f, 0.19820644f, -0.09352523f, 0.04301664f, -0.06509085f, 
    -0.05574006f, -0.04384343f, -0.19051695f, -0.02709510f, 0.20062096f, -0.05045694f, 0.03883222f, 0.11154576f, 
    -0.02127531f, -0.16647679f, 0.09313544f, -0.15659873f, -0.03480653f, -0.04778235f, -0.00357170f, -0.03509159f, 
    0.03288452f, 0.10571039f, 0.00035109f, 0.10264269f, -0.16600026f, 0.16634755f, -0.16048212f, 0.27514541f, 
    0.14664094f, 0.12387966f, 0.17999208f, 0.09162117f, -0.12915620f, 0.01097504f, -0.15878756f, -0.02218335f, 
    -0.06688315f, 0.20482741f, -0.12349262f, 0.12081971f, 0.00303644f, -0.05413112f, 0.05663949f, -0.09709350f, 
    -0.10363952f, -0.05928763f, 0.10172340f, 0.18424121f, 0.27029288f, 0.23362935f, -0.08546349f, 0.31442252f, 
    -0.06270409f, -0.05563024f, 0.09232824f, -0.14236024f, 0.31320187f, -0.03556263f, -0.06659614f, 0.12704378f, 
    -0.24024662f, 0.06218801f, 0.11319315f, -0.08887427f, -0.05118506f, -0.04447148f, 0.04953252f, 0.16701256f, 
    -0.02670835f, -0.00255278f, -0.08011209f, 0.00563039f, 0.02304289f, -0.01600234f, -0.02217562f, 0.27487364f, 
    0.01698076f, -0.17433450f, 0.09633692f, 0.18182047f, 0.08283220f, 0.04073318f, 0.08220767f, -0.09390692f, 
    -0.18229961f, -0.05563529f, 0.14635871f, -0.15765014f, 0.08511978f, 0.14064452f, 0.08103677f, 0.32960698f, 
    -0.00670672f, -0.01177761f, -0.00067321f, -0.04775748f, -0.19124193f, 0.02930188f, 0.11345284f, -0.03013169f, 
    -0.01301489f, 0.13053799f, 0.04380366f, 0.07481655f, -0.01319817f, 0.03366015f, 0.01251148f, 0.01664945f, 
    0.04131493f, 0.00867267f, -0.19948290f, 0.08675769f, 0.04539882f, 0.02798908f, -0.06882365f, -0.01062629f, 
    0.04370608f, 0.01127241f, -0.08705421f, -0.00606889f, -0.10085963f, -0.16072230f, 0.20676103f, -0.26612142f, 
    -0.07217721f, -0.04843113f, 0.03322215f, 0.00561252f, 0.04916049f, 0.03036222f, 0.03143812f, -0.09330313f, 
    0.00308748f, 0.29830912f, -0.16090797f, 0.09445444f, 0.05612747f, 0.13971226f, 0.11834391f, 0.00350848f, 
    -0.01064730f, 0.15520298f, -0.12289036f, 0.08811055f, 0.07535183f, -0.11433369f, 0.14674795f, -0.04759990f, 
    -0.11722928f, -0.11701828f, 0.01963300f, 0.05379013f, 0.09899745f, 0.04931271f, 0.23355548f, -0.12484740f, 
    0.07246768f, -0.04017273f, 0.09394985f, -0.00021452f, -0.22801043f, -0.07823902f, -0.14192472f, 0.03556082f, 
    0.04239352f, -0.08057178f, 0.04991286f, -0.03809508f, 0.06248355f, -0.25069609f, 0.01708352f, 0.41437519f, 
    0.03474304f, 0.13440318f, -0.25285360f, -0.20005727f, 0.04295956f, 0.07344415f, -0.01002593f, 0.06401882f, 
    -0.02987392f, 0.00152733f, -0.11848137f, 0.10961412f, -0.08206120f, -0.03803262f, 0.06816196f, -0.13520545f, 
    -0.07981803f, -0.19940054f, 0.06105115f, -0.17116871f, -0.02919587f, 0.05959853f, 0.20940739f, 0.01769709f, 
    0.07125106f, 0.02929300f, -0.03397751f, 0.09865710f, -0.01571197f, 0.02324368f, 0.02095636f, 0.22489361f, 
    0.11691125f, 0.03401312f, -0.09443814f, 0.03870011f, 0.09915799f, 0.12642172f, -0.03866323f, 0.00785419f, 
    -0.06540512f, -0.01401084f, -0.05703722f, -0.02680535f, 0.13769256f, 0.12605093f, -0.20347889f, 0.12202419f, 
    0.01401168f, -0.03215542f, 0.12293784f, 0.14236178f, 0.06636885f, -0.07407526f, -0.13397591f, 0.03692248f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02644385f, 0.10660217f, 0.17530723f, -0.04487837f, 0.02516839f, 0.00200881f, 0.08617757f, 0.28858465f, 
    0.24611112f, -0.11080705f, 0.10458002f, 0.17899473f, 0.03813448f, -0.07205516f, 0.08572202f, 0.17848574f, 
    -0.13525030f, 0.12196191f, 0.23277448f, 0.07021946f, 0.10395301f, -0.00419588f, 0.02665545f, 0.21617381f, 
    -0.04435542f, 0.12839493f, 0.01091878f, 0.06548418f, -0.01602344f, 0.06842928f, -0.09407052f, -0.03102226f, 
    0.11957509f, 0.00327776f, 0.03685034f, 0.00715274f, 0.11161675f, -0.15343337f, 0.01044280f, 0.00931106f, 
    -0.03643588f, -0.03197172f, -0.07145400f, -0.10955209f, -0.05107462f, 0.08117568f, 0.11398534f, -0.00168577f, 
    -0.07925750f, 0.05739999f, 0.07053366f, 0.03480406f, 0.22978865f, -0.10284298f, -0.06366960f, -0.06597535f, 
    -0.03309298f, -0.11716851f, -0.08443537f, -0.22597298f, 0.16312718f, -0.00574499f, 0.07892982f, -0.03293146f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.01487799f, -0.52225113f, -0.31237882f, 0.13776961f, -0.43558234f, -0.12593231f, -0.13819322f, -0.14950906f, 
    0.07020611f, 0.33111250f, -0.14242168f, 0.18558954f, -0.29086214f, 0.07174353f, -0.06468044f, -0.28808364f, 
    0.19548737f, -0.20077708f, -0.43319854f, -0.00167716f, -0.17343853f, -0.01221274f, -0.15606110f, 0.00870829f, 
    0.45577770f, -0.30392182f, -0.11039156f, 0.14314142f, -0.07526318f, -0.18433970f, 0.17574002f, -0.01237596f, 
    -0.01091347f, 0.17599453f, -0.01320365f, 0.00950072f, 0.17030047f, 0.26687849f, 0.07611281f, 0.06177777f, 
    -0.02566396f, -0.40408018f, 0.30840054f, 0.26164731f, 0.09752201f, -0.50066113f, 0.10827913f, 0.13058521f, 
    -0.13105676f, -0.04039707f, -0.21431428f, -0.03944270f, -0.29801795f, 0.14318146f, 0.13717824f, 0.03014823f, 
    -0.17463796f, 0.01863666f, 0.29712150f, 0.14550166f, -0.23147273f, 0.03315010f, 0.14751539f, -0.09422075f, 
    -0.01557809f, -0.48260877f, -0.19071661f, -0.48878413f, -0.33129621f, -0.02984077f, 0.05176148f, 0.08442590f, 
    0.18351334f, 0.16655867f, 0.20182291f, 0.40535790f, 0.09956450f, -0.01849134f, -0.08532553f, 0.07145021f, 
    -0.08095780f, -0.05612182f, -0.00510467f, 0.17757247f, 0.17670941f, -0.05948685f, 0.05363339f, 0.28471646f, 
    -0.95122659f, -0.06621072f, -0.02965649f, 0.20702191f, 0.09896322f, -0.10695151f, -0.37953517f, -0.07128106f, 
    0.21452592f, 0.04921430f, -0.12265288f, 0.01168835f, 0.04157121f, -0.17237981f, 0.05658781f, 0.19487929f, 
    -0.75746107f, 0.05169169f, -0.00404264f, -0.62099540f, -0.52189583f, 0.10259911f, 0.18165386f, 0.09656519f, 
    0.00582675f, 0.03825116f, -0.43450826f, -0.06229210f, 0.54732859f, -0.02909412f, 0.20108439f, 0.10868274f, 
    -0.27926564f, 0.30008072f, 0.47350132f, -0.06528571f, 0.16006730f, -0.11163016f, -0.12103073f, -0.25713068f, 
    -0.11012376f, -0.12858509f, -0.09871361f, 0.18527302f, 0.11026340f, 0.07153704f, -0.77042532f, 0.08918425f, 
    0.21483532f, -0.45337701f, 0.16442077f, 0.11188124f, 0.12247878f, 0.08137969f, -0.18899879f, -0.04984494f, 
    -0.57961994f, 0.19629015f, 0.14248155f, 0.14339867f, -0.02947884f, 0.02500108f, -0.12903778f, 0.17375784f, 
    -1.00615239f, 0.03288159f, 0.09023165f, -0.17292795f, 0.07022386f, -0.00692961f, 0.31835148f, -0.07731278f, 
    -0.30140942f, 0.46051669f, -0.10608618f, 0.16387673f, 0.22325952f, -0.38725340f, 0.42759562f, 0.01535271f, 
    -0.07889370f, -0.06645805f, -0.40362477f, -0.26498857f, 0.33706918f, -0.11938910f, 0.34581807f, 0.01715322f, 
    -0.10161448f, -0.06024908f, 0.47466439f, 0.05674333f, -0.68118912f, -0.39971969f, -0.01882683f, -0.04910437f, 
    -0.14102000f, 0.02213185f, -0.76557481f, 0.00676442f, 0.22643451f, 0.03437354f, -0.31844538f, 0.08732039f, 
    0.08198891f, 0.17547660f, 0.11557239f, 0.15874866f, 0.35286683f, -0.02941143f, 0.22703902f, 0.04534595f, 
    -0.58856821f, 0.12742719f, -0.02450639f, -0.18168192f, -0.09689572f, 0.06141289f, -0.40436429f, -0.09366775f, 
    -0.15354238f, 0.13651761f, -0.10191342f, 0.03345444f, -0.01714808f, 0.02095306f, 0.12792018f, 0.17805992f, 
    -0.16879572f, 0.08366384f, 0.07070220f, -0.61973202f, 0.05859978f, 0.03913070f, -0.10180176f, 0.03941552f, 
    -0.50089198f, -0.04143879f, -0.16426711f, 0.27667823f, -0.47243485f, 0.19733804f, 0.23959278f, -0.09636512f, 
    -0.15896805f, -0.04602215f, 0.17463481f, 0.17894138f, 0.29415765f, 0.08303238f, -0.28307775f, 0.01177593f, 
    0.01587319f, -0.16142067f, -0.34039229f, -0.05083979f, -0.16649140f, 0.07411747f, -0.50504720f, -0.05449226f, 
    0.27514812f, 0.18299975f, 0.13374178f, 0.23927534f, -0.02187122f, -0.09703911f, -0.48863080f, -0.38913292f, 
    -0.02393058f, 0.02757906f, -0.13778260f, -0.05152842f, -0.20672506f, 0.00777356f, -0.19273962f, -0.20431501f, 
    -0.31615672f, -0.19878276f, -0.41363245f, -0.51387644f, -0.03215273f, 0.01439121f, 0.01403202f, -0.21213903f, 
    0.42200401f, 0.06889101f, -0.19182913f, 0.02927129f, 0.05085256f, 0.03653830f, 0.26299617f, -0.25658223f, 
    0.19777125f, -0.25195280f, 0.10515250f, 0.00764088f, 0.03351495f, 0.03024936f, 0.12189401f, -0.10304712f, 
    0.16049665f, 0.23773552f, 0.13571022f, -0.17389403f, 0.01573096f, -0.04378036f, 0.03495755f, 0.17332043f, 
    0.39772749f, 0.25548071f, -0.10531472f, 0.05890790f, 0.14834222f, 0.13827707f, -0.08604737f, 0.03858808f, 
    0.09463786f, 0.03623587f, 0.30973840f, 0.00019225f, -0.28427029f, 0.20725831f, 0.10716715f, -0.02157080f, 
    0.06765811f, 0.19413024f, -0.16469419f, -0.19194964f, -0.00194337f, -0.00936257f, -0.01982812f, 0.19749393f, 
    0.00356737f, 0.21212669f, 0.30819181f, 0.12411210f, -0.23641497f, 0.10899936f, 0.15865454f, 0.15967561f, 
    -0.00423762f, -0.07872277f, -0.39449048f, -0.08219975f, -0.52878094f, 0.08960204f, 0.01551180f, 0.00924924f, 
    -0.29251683f, -0.06062895f, 0.25864109f, 0.16333415f, -0.12732895f, 0.01698000f, 0.07457875f, 0.00140231f, 
    0.11698065f, -0.00865861f, 0.06189977f, 0.19989794f, -0.09036402f, 0.16463396f, -0.13106456f, -0.11413618f, 
    0.28118926f, 0.02611564f, 0.10364400f, 0.05822678f, 0.11050624f, -0.11088029f, -0.25349805f, 0.14449024f, 
    -0.45319369f, -0.36147541f, -0.09401429f, 0.08453657f, -0.45912364f, -0.26763004f, -0.05045671f, 0.10846007f, 
    0.02117284f, 0.21860854f, 0.29305577f, 0.02173169f, -0.03009621f, 0.05653542f, -0.11760694f, -0.10268156f, 
    -0.23949009f, -0.34914187f, -0.22181129f, -0.14552066f, -0.34379730f, -0.01026144f, 0.38012055f, -0.17196567f, 
    0.11437795f, 0.36509940f, 0.32434329f, -0.17209451f, -0.07068234f, -0.07160702f, -0.03627803f, -0.06349850f, 
    0.13240640f, -0.38988802f, 0.01915480f, -0.53511262f, 0.39099771f, -0.04745498f, 0.15381955f, 0.23849052f, 
    0.08488028f, 0.24216963f, 0.23571792f, -0.31329870f, 0.06885950f, -0.01304857f, -0.28673455f, -0.51814163f, 
    -0.31633118f, -0.09893689f, 0.01198262f, 0.27763793f, 0.02690910f, 0.02989863f, 0.17989931f, 0.06711037f, 
    0.36198848f, -0.86732203f, -0.26153478f, -0.07651567f, 0.12360614f, -0.51471823f, -0.29139465f, -0.95160282f, 
    -0.11910874f, 0.05515389f, -0.22433202f, -0.82507420f, 0.19431549f, 0.05145493f, 0.38685054f, -0.62862551f, 
    0.01286752f, -0.09800713f, -0.19487050f, 0.08571693f, -0.57970697f, -0.23078482f, -0.31022611f, -0.03601762f, 
    0.14502937f, -0.58741850f, -0.30795825f, 0.06237367f, 0.06549943f, -0.08790696f, 0.27220523f, -0.12899619f, 
    0.03500568f, 0.32555383f, -0.38258582f, 0.26396808f, 0.21249440f, -0.09129707f, 0.13381544f, -0.22477709f, 
    -0.22104532f, -0.31988686f, 0.13324459f, 0.18117876f, 0.07995825f, 0.03784370f, -0.19557746f, 0.08120410f, 
    0.61037457f, -0.43228626f, -0.09636169f, -0.36030847f, -0.52570134f, -0.01139242f, -0.42293760f, -0.40744320f, 
    -0.37490022f, 0.23667324f, -0.08221657f, -0.21844764f, -0.11097419f, -0.24906927f, 0.32614475f, 0.05171799f, 
    0.03497447f, -0.24188876f, 0.15333703f, -0.05052159f, -0.14572182f, 0.45301837f, -0.23276933f, -0.42279321f, 
    -0.16362955f, 0.29012606f, -0.20949255f, 0.30780655f, -0.56355149f, 0.22002025f, 0.00355574f, -0.07155591f, 
    -0.11374500f, -0.31938148f, 0.35262266f, -0.03664872f, -0.15352929f, -0.10219353f, 0.18069406f, -0.09457707f, 
    -0.09123912f, -0.19017912f, -0.17041811f, 0.23891121f, -0.06816686f, -0.11805961f, 0.08241849f, -0.10457856f, 
    0.01429858f, -0.00663111f, -0.16136487f, -0.11026232f, 0.43230113f, -0.03023831f, 0.21660672f, 0.21699189f, 
    -0.05019852f, -0.40350184f, -0.55675089f, 0.22676757f, -0.27917954f, 0.09056125f, -0.60224593f, 0.23950842f, 
    -0.39869583f, -0.03271431f, -0.28174496f, 0.10947159f, -0.57420814f, -0.07981680f, -0.50865674f, 0.26073894f, 
    -0.51321262f, 0.30851707f, 0.05426720f, -0.43683580f, -0.09801254f, -0.40859711f, -0.21495904f, -0.01199773f, 
    -0.62749952f, -0.26752353f, 0.36361787f, -0.05432639f, -0.01821180f, -0.39127365f, -0.34161907f, -0.48084590f, 
    0.12277102f, 0.02031462f, 0.23940912f, -0.19324920f, 0.14534752f, 0.07529001f, -0.26864573f, 0.18373753f, 
    -0.03464215f, -0.07304717f, -0.30954552f, -0.09214164f, 0.05296500f, -0.24096622f, -0.20563030f, -0.07858564f, 
    -0.23487262f, 0.00841854f, -0.22684541f, -0.20574972f, 0.34180069f, 0.02488416f, 0.26915282f, 0.06201731f, 
    -0.00339870f, -0.13645412f, -0.13233763f, 0.14725843f, -0.08052863f, -0.08860484f, -0.23764420f, 0.05330389f, 
    0.00795767f, -0.53752130f, 0.12064794f, -0.11006133f, 0.12882815f, -0.08042544f, 0.22502404f, 0.11523107f, 
    -0.30540112f, -0.18180059f, 0.26498672f, -0.05281509f, 0.18394816f, 0.05546232f, -0.19904517f, -0.54392856f, 
    -0.05560894f, -0.23944779f, 0.02041756f, 0.32854444f, 0.06368167f, 0.27234960f, 0.11935905f, -0.07809167f, 
    -0.22922251f, -0.03160767f, -0.23959826f, -0.48786697f, -0.02640314f, 0.55340594f, -0.51751941f, 0.36824581f, 
    0.59259009f, 0.15669392f, -0.13610996f, 0.15285395f, -0.39710754f, -0.14896955f, 0.02298542f, -0.26100415f, 
    -0.00552033f, -0.40368605f, 0.02451649f, -0.04311872f, 0.16677967f, -0.48444644f, -0.21490896f, 0.04975284f, 
    0.17979133f, 0.15691282f, -0.53610086f, 0.06190892f, -0.12941110f, -0.02260063f, 0.18069015f, 0.29747000f, 
    0.03097046f, 0.07649513f, 0.07635561f, -0.63658953f, 0.12548973f, -0.07437038f, 0.29756001f, -0.13109748f, 
    -0.13601217f, 0.39803368f, 0.04909869f, 0.25425303f, -0.35200080f, 0.03138973f, 0.26857308f, -0.22248328f, 
    0.07309069f, -0.08418181f, 0.19283250f, -0.24697529f, 0.38933152f, 0.05079529f, -0.17436782f, 0.10957735f, 
    -0.02230421f, 0.21872602f, -0.06093162f, -0.04718537f, 0.09234056f, 0.27946424f, -0.90982330f, 0.00253842f, 
    -0.44505087f, -0.16237086f, -0.24608646f, -0.12528029f, -0.17502700f, -0.64294690f, -0.55815518f, -0.38430893f, 
    -0.31320354f, -0.48670384f, 0.33177558f, -0.28251523f, 0.37331158f, 0.27661321f, 0.34955996f, 0.02331766f, 
    -0.01672753f, 0.25932169f, 0.04584852f, 0.05838928f, -0.67004937f, -0.48838115f, -0.26941547f, -0.00673018f, 
    0.34422335f, 0.15355724f, 0.05310697f, -0.26192126f, 0.02763483f, -0.07672732f, -0.13699761f, 0.17985635f, 
    0.02478626f, -0.19732653f, 0.09834448f, 0.12392610f, 0.25619814f, -0.08000974f, 0.26692861f, 0.25942042f, 
    0.13540010f, -0.37119427f, 0.30259284f, 0.14490081f, 0.31833783f, 0.01091956f, 0.09262769f, 0.17618100f, 
    -0.49100721f, 0.39797410f, -0.25720209f, -0.69784576f, 0.28902507f, 0.01439816f, -0.08022247f, -0.14177176f, 
    0.22053520f, -0.01257511f, 0.08349822f, -0.34413353f, 0.06059710f, -0.34405670f, -0.04168940f, 0.06334271f, 
    -0.07916143f, 0.04038347f, -0.31706014f, -0.48883134f, -0.57692713f, -0.28650585f, 0.62054384f, -0.04804233f, 
    -0.27740994f, -0.18772677f, -0.56116503f, -0.40018687f, 0.37869123f, 0.15613374f, -0.74360383f, 0.14471658f, 
    0.07885423f, 0.30082613f, -0.37028107f, 0.03631233f, -0.29588801f, -0.04109716f, 0.03353930f, -0.06851231f, 
    0.11840089f, -0.11942592f, -0.15219150f, -0.07480869f, 0.05854076f, 0.05206179f, -0.42046437f, 0.11163124f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12355267f, 0.04504022f, 0.01057728f, -0.08285172f, -0.18182731f, 0.19587629f, 0.10646561f, -0.20705673f, 
    0.24681374f, 0.12718572f, 0.12635754f, -0.00191293f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
