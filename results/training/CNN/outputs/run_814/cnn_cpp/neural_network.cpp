#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.43734902f, 0.14817196f, -0.36872357f, -0.58224303f, -0.89582676f, 0.74377537f, 1.04901731f, -0.25119463f, 
    0.15824203f, 0.42413181f, -0.07630264f, 0.11751302f, 0.02010844f, -0.10670017f, -0.47733757f, -0.15054357f, 
    0.16671365f, 0.01126031f, -0.10293788f, -0.32214367f, -0.37936440f, -0.25292039f, 0.03131880f, -0.17517777f, 
    -0.07085606f, 1.17448664f, 0.80148184f, -0.09271532f, 0.77610165f, -0.54002321f, -0.02498424f, 0.10260191f, 
    -0.54994029f, -0.17105521f, -0.06910019f, 0.15111175f, 0.19267233f, -0.13334696f, -0.24940105f, -0.00936910f, 
    0.25196326f, -0.25340232f, 0.32079661f, 0.20781720f, 0.07533957f, 0.16625540f, 0.26626086f, 0.19472969f, 
    -0.13415644f, 0.34942174f, -0.62585151f, 0.28306827f, -0.62384003f, 0.89116085f, 0.74827975f, 0.48060372f, 
    0.32810485f, 0.36613962f, -0.26319697f, 0.42019251f, -0.49088624f, -0.22698332f, 0.23658308f, -0.25126535f, 
    0.13683675f, -0.42895824f, -0.35795414f, 0.21029747f, -0.02100706f, -0.04451468f, 0.39094087f, -0.18326800f, 
    -0.18434654f, 0.33235782f, -0.28746131f, -0.88028020f, -0.63292426f, 0.89271629f, 0.83744574f, -1.09241629f, 
    -0.15414718f, 0.27880946f, 0.60054839f, 0.00936803f, -0.57728189f, -0.30316964f, -0.35992137f, -0.19895706f, 
    -0.23818606f, 0.25225407f, -0.08817265f, 0.29480270f, 0.00975088f, -0.16866058f, 0.06690209f, -0.06577052f, 
    0.14136814f, -0.00096496f, 0.26314926f, -0.00670244f, 1.48911476f, -0.09150013f, -0.79124492f, 0.61772203f, 
    1.00672364f, 0.42291373f, 0.41266590f, -0.13185292f, 0.55405909f, 0.35916519f, -0.66393858f, -0.06514312f, 
    -0.16617741f, -0.21525288f, -0.14648570f, -0.28942332f, -0.25595313f, 0.11065288f, 0.03987334f, -0.33500037f, 
    0.26872358f, 0.27142099f, 0.22141674f, 0.07818350f, 0.17887582f, -1.21335518f, 1.02676427f, 0.83781445f, 
    -0.52060515f, 0.58651012f, 0.74779201f, -0.52009267f, -0.44142762f, -0.19514047f, -0.72785258f, -0.37926257f, 
    0.10469485f, 0.16910127f, 0.27289394f, -0.27953762f, -0.23212686f, -0.14764912f, 0.12226788f, -0.19961669f, 
    0.03742832f, -0.23121931f, -0.13751861f, -0.07832371f, 0.06224405f, -0.10362461f, 0.36149427f, 0.62785637f, 
    0.91167015f, 0.74068922f, 0.81240064f, -0.50246829f, 0.12399742f, -0.64574301f, -0.82463783f, -0.34395623f, 
    0.18703213f, -0.04581153f, 0.16708988f, 0.46520153f, 0.26390722f, -0.21565618f, 0.13915931f, 0.27888161f, 
    -0.23234497f, 0.47463763f, -0.01909038f, 0.19037324f, -0.10028798f, 0.32620651f, 0.01091139f, -1.55155098f, 
    -0.04556018f, -0.67548507f, 0.25639135f, -0.82443202f, 0.37110746f, 0.18247244f, -0.09886394f, 0.65906703f, 
    -0.06441538f, -0.21011327f, -0.39040360f, -0.03935255f, 0.11686409f, 0.36592647f, -0.02048912f, -0.03880218f, 
    -0.14988825f, -0.22287396f, -0.25280517f, 0.25967735f, 0.27953893f, 0.39173824f, 0.14837149f, 0.25500941f, 
    -0.48144007f, -0.87094396f, -0.78013247f, -0.50926644f, -0.48586076f, 0.53261638f, 1.05676508f, 0.37230024f, 
    0.22408976f, 0.32732660f, -0.40134439f, -0.13102026f, -0.40840882f, -0.28936663f, -0.32213005f, 0.07694454f, 
    -0.08096760f, 0.11795539f, 0.11583843f, 0.23479627f, 0.09098040f, -0.24996395f, -0.08941550f, -0.32761392f, 
    0.14831421f, -0.33806375f, -0.95853823f, -0.88712764f, -0.60906351f, -0.44401410f, -0.64580506f, -0.20214413f, 
    0.01791406f, -0.40626976f, 0.06605604f, -0.13960701f, 0.20079626f, 0.24579798f, 0.06734722f, -0.12010387f, 
    0.25847435f, 0.16822353f, 0.30701518f, -0.02387815f, 0.04966994f, -0.08988674f, -0.03734979f, -0.32771465f, 
    0.15259957f, 0.00392228f, -0.07902517f, -0.10455354f, 0.36723092f, -0.86988640f, -0.72626585f, 0.21235298f, 
    -0.26273465f, 0.35594004f, -0.54813486f, -0.08957635f, 0.79178768f, -0.09796242f, -0.34860957f, -0.04105681f, 
    -0.27241918f, -0.41473565f, -0.00793439f, -0.19936775f, -0.49423534f, 0.16920324f, 0.00025141f, 0.50192398f, 
    0.19152066f, 0.02094063f, -0.21522209f, -0.62819922f, -0.84590566f, -0.98403931f, -0.56843221f, 0.23243903f, 
    -0.56489533f, 0.38424763f, 0.58031529f, -0.52389055f, 0.24311808f, -0.10346743f, 0.06895650f, 0.31246489f, 
    0.02045331f, 0.29365012f, -0.10178394f, -0.06222659f, -0.12891990f, -0.09258390f, 0.05371661f, 0.40065545f, 
    -0.17342007f, 0.05267328f, 0.23954552f, 0.06260894f, -1.10348427f, 1.50336766f, -0.28325546f, -0.38205945f, 
    0.47356290f, -0.77031964f, 0.79563147f, 0.44461459f, -0.29372108f, 0.12191186f, -0.21548335f, -0.00240422f, 
    0.00199910f, -0.42450246f, 0.06982592f, 0.33799511f, -0.03911674f, 0.04574900f, 0.01383147f, 0.04836814f, 
    -0.12872069f, 0.03656674f, -0.01756396f, -0.04732760f, -0.05587104f, 0.81265157f, 0.94838899f, 0.56558549f, 
    0.86727530f, 0.03261648f, -0.36004242f, 0.47291580f, 0.17598726f, 0.02289329f, 0.35563323f, 0.06197330f, 
    0.10981307f, -0.17908132f, 0.51402467f, 0.25509182f, 0.00881124f, -0.06152667f, 0.47790897f, -0.00298977f, 
    -0.21318303f, -0.09613127f, 0.26196653f, -0.30847275f, 0.16841820f, 0.06354807f, 0.37404823f, 0.08632877f, 
    0.80048579f, 0.74235958f, 0.35772321f, 0.25718498f, 0.08202747f, -0.47697744f, -0.68568647f, 0.55908805f, 
    0.22520322f, 0.53695083f, 0.27207115f, -0.02282958f, 0.14175798f, -0.32844934f, -0.35136130f, 0.12894131f, 
    0.14162993f, -0.38655674f, 0.36913803f, 0.20242040f, -0.31077337f, 0.10911996f, 0.03076818f, 1.31706667f, 
    0.90976036f, -0.12611111f, -1.15113914f, -0.49938634f, 0.04769577f, -0.62005484f, -0.30871031f, 0.13283406f, 
    0.47032845f, -0.36262858f, -0.10816442f, -0.14372502f, 0.28110674f, -0.02786102f, -0.34315002f, -0.05023523f, 
    -0.10885444f, -0.31231308f, 0.24138306f, -0.10010087f, 0.17132711f, -0.43611559f, -0.19954039f, 0.24494089f, 
    -0.50866985f, 0.34057614f, -0.34909433f, 0.11565182f, 0.14316234f, -0.68686414f, -0.32685262f, -0.43380922f, 
    -0.78761727f, -0.71068674f, -0.19764799f, 0.07399292f, 0.46603262f, -0.15626292f, -0.41601267f, 0.19704081f, 
    -0.35715556f, 0.04429612f, -0.04103437f, -0.01298295f, -0.39152539f, 0.19193655f, -0.21239609f, 0.10807790f, 
    0.30657902f, -0.09452547f, 0.17508969f, -0.26388726f, -0.47759968f, -0.70333374f, -0.97589022f, -0.62768179f, 
    0.81311929f, 0.03444791f, 0.43790942f, 0.21894807f, -0.18565258f, -0.23555042f, -0.53861207f, -0.05709623f, 
    -0.18781023f, 0.03976302f, 0.13417034f, -0.11475182f, -0.34835541f, 0.09045592f, 0.24394326f, -0.03599926f, 
    0.32859987f, 0.27487108f, 1.05043614f, -1.11609864f, 0.59601146f, 0.39775953f, 0.27357388f, 0.76904809f, 
    0.57142591f, 0.60998166f, -0.33140573f, -0.14498793f, -0.14190102f, 0.24983640f, -0.28285348f, 0.11145614f, 
    -0.07826304f, -0.29987028f, -0.03121453f, -0.00011418f, 0.46379629f, 0.06804168f, -0.08299547f, -0.06438785f, 
    -0.02810448f, 0.02447522f, 0.14550599f, -0.74241841f, -0.00916659f, 1.17133617f, 0.04549944f, -0.44262064f, 
    -0.86735982f, 0.88460398f, -0.37963119f, -0.49227577f, -0.27254793f, -0.31507286f, 0.38100171f, -0.03319458f, 
    0.32901868f, -0.27522480f, 0.11307438f, -0.28973156f, 0.06513838f, -0.10098130f, -0.14206828f, -0.28226584f, 
    0.23366554f, -0.21471956f, 0.12048376f, 0.01707440f, -1.18935585f, 0.80563581f, -0.45026469f, -0.40832019f, 
    -0.03138250f, 0.50775015f, 0.20028700f, -0.27123374f, 0.51271307f, -0.50768518f, -0.33543307f, -0.03466418f, 
    -0.70278358f, 0.56491047f, -0.02653565f, -0.26196429f, 0.34065008f, 0.19709961f, 0.11979496f, 0.11354128f, 
    -0.14184238f, -0.33270794f, -0.27959678f, -0.09770111f, 0.22068352f, -0.54882014f, 0.03499787f, -1.01669681f, 
    0.00074078f, 0.06923228f, -0.28180709f, 0.92622548f, 0.64213806f, 0.69252521f, 0.46528950f, -0.06408437f, 
    -0.27428707f, 0.25332060f, -0.46819460f, -0.03576042f, -0.15922049f, 0.02451877f, -0.15513237f, 0.07543010f, 
    -0.45814440f, -0.00277649f, 0.01154021f, -0.29551518f, -0.18793015f, -0.05991538f, -0.56048512f, -0.34620130f, 
    0.62490779f, 1.00738442f, 0.28332421f, -1.01352751f, 0.18834071f, 0.54392970f, -0.30457103f, -0.23021965f, 
    0.54510409f, 0.13664523f, 0.10067928f, 0.49179858f, 0.31009626f, 0.51586598f, 0.39050648f, -0.20399438f, 
    0.23936088f, 0.02281492f, -0.16745673f, -0.28540832f, -0.12800127f, -0.26659948f, -0.24314232f, -0.49238405f, 
    -0.88498014f, -0.63789028f, 0.48398486f, 0.22609299f, -0.17008688f, -0.14658821f, -0.48297563f, -0.14126225f, 
    0.06373180f, 0.44206062f, 0.34395453f, 0.24519843f, 0.16483608f, 0.54793936f, 0.37589777f, 0.09368997f, 
    -0.41616276f, 0.07341972f, 0.45360178f, 0.19254883f, 0.05524421f, -0.11626603f, -0.08281406f, 0.35326824f, 
    0.88837868f, 0.81254530f, 0.82121205f, 0.59440881f, 0.46409360f, 0.14321762f, -0.62157482f, 0.12928498f, 
    -0.56364375f, 0.49981499f, -0.34110147f, 0.05249401f, -0.24794938f, 0.12559855f, -0.18971793f, -0.26041412f, 
    -0.07804186f, -0.27111268f, -0.03688109f, -0.27115399f, 0.10709589f, 0.30481589f, 0.23003922f, -0.39264128f, 
    0.24952452f, -0.22347344f, -0.84323275f, -0.36025944f, -0.53997540f, 0.15837872f, -0.56495577f, 0.84026659f, 
    -0.04689192f, -0.45890924f, 0.00026320f, 0.37909406f, -0.29896015f, -0.25088841f, -0.14229079f, -0.08831721f, 
    -0.32523015f, -0.19650112f, -0.67900521f, -0.19278432f, -0.30357403f, -0.37624890f, 0.21674916f, -0.03953910f, 
    -0.30838305f, -0.32846797f, 0.27815491f, -0.08211604f, 0.83770883f, 0.87694645f, 0.71878570f, 0.54221851f, 
    0.09765833f, 0.15979318f, 0.05482973f, -0.30649978f, -0.71313524f, 0.08600213f, 0.16007614f, -0.11635820f, 
    -0.06404629f, 0.20629217f, 0.35162255f, 0.63111264f, 0.26703304f, -0.21467882f, 0.06827810f, -0.20835654f, 
    -0.07475320f, -0.20267791f, 0.24782203f, -0.72358686f, -0.35207093f, -0.68189406f, -0.33634219f, -0.07684471f, 
    -0.51720792f, 0.44257909f, 0.09129439f, 0.24071747f, 0.47717476f, 0.71551663f, -0.23973911f, 0.29194242f, 
    -0.27581930f, -0.42794368f, 0.26739189f, 0.32009831f, 0.52671826f, 0.61399144f, -0.31561774f, -0.26127541f, 
    -0.03134810f, 0.04914738f, -0.02706143f, 0.17983519f, 0.68735737f, -0.23225254f, -0.58045834f, -0.81210738f, 
    -0.20332584f, 0.34799418f, 0.29914272f, -0.50802600f, -0.76569474f, 0.00234276f, 0.33140320f, 0.06541873f, 
    0.86067951f, -0.09349606f, -0.10984209f, -0.38216060f, 0.04370817f, 0.03567227f, 0.17236345f, -0.14914121f, 
    0.22778557f, -0.25605834f, 0.11390493f, 0.52469158f, -0.07703847f, -0.35214549f, -0.44172493f, 0.48472393f, 
    -0.43604758f, -0.15181930f, 0.07854196f, -0.69458288f, -0.74680752f, -0.81390440f, -0.00901366f, 0.07924701f, 
    0.29590386f, 0.60202843f, -0.02332565f, 0.11371239f, 0.44465053f, 0.38961530f, 0.38799495f, 0.09304558f, 
    -0.17141642f, 0.29824659f, -0.26351151f, 0.00614442f, -0.44234332f, 0.23998331f, -0.41871893f, -1.68353713f, 
    -0.58085930f, 0.54892761f, 0.33731633f, -0.47298136f, 1.03062677f, 0.45145068f, -0.35248482f, 0.13509947f, 
    0.41287696f, 0.14950097f, -0.12020636f, -0.10833941f, 0.25435022f, -0.20705007f, 0.04217223f, 0.06514811f, 
    -0.33010364f, -0.07684200f, 0.03467428f, -0.00947639f, 0.02218146f, 0.03024763f, 0.10694247f, 0.76403129f, 
    0.39182511f, 1.01972616f, 0.17403482f, 0.50436175f, 0.90530592f, 0.23686446f, -0.48536992f, 0.56954128f, 
    -0.15980554f, -0.02008309f, 0.58409637f, -0.09945229f, 0.19474596f, -0.56573308f, -0.03217098f, -0.08273831f, 
    -0.19650275f, -0.20604241f, -0.24014431f, 0.31223515f, -0.01711914f, 0.29617268f, 0.27756861f, 0.21758462f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02447521f, 0.17368560f, 0.20847383f, 0.13013719f, 0.27672252f, 0.09962090f, 0.26528740f, -0.00554567f, 
    0.14955224f, 0.24278696f, 0.16551085f, 0.12690382f, 0.19184351f, 0.30810317f, 0.24200821f, 0.18524332f, 
    0.17759503f, 0.04063462f, 0.00343382f, -0.03761491f, -0.13903327f, 0.17963959f, 0.23404330f, 0.00605594f, 
    0.18507864f, 0.21592814f, -0.04290000f, 0.28165212f, 0.13070685f, 0.38329223f, 0.30027300f, 0.12285878f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.44350687f, 0.13063629f, 0.08052646f, -0.34102631f, -0.00843461f, 0.17319673f, -0.19981217f, -0.00149660f, 
    -0.04833481f, 0.03517473f, -0.07877781f, 0.08870997f, 0.07025477f, 0.10274249f, -0.03164852f, 0.17546265f, 
    -0.24923813f, 0.02194190f, -0.08853651f, 0.14605121f, -0.17846338f, 0.03267157f, -0.09625059f, -0.05965139f, 
    -0.02860932f, 0.09546345f, 0.11285808f, 0.12214275f, -0.04230703f, -0.04430641f, 0.00773195f, -0.10784827f, 
    -0.00315548f, 0.02358657f, -0.13274249f, -0.10726919f, -0.13937065f, 0.31701705f, -0.10476539f, 0.48910958f, 
    0.03388825f, 0.05288502f, 0.01537955f, 0.06838084f, 0.02453589f, 0.12234013f, -0.07207431f, -0.03287800f, 
    0.20857093f, -0.10649174f, 0.03733736f, 0.27972218f, -0.03704492f, -0.04358890f, 0.06358655f, 0.01671450f, 
    -0.18805118f, 0.17166413f, 0.03726400f, -0.17127839f, -0.65313387f, 0.20213683f, 0.21279125f, -0.10798120f, 
    0.11241196f, -0.12341701f, -0.00232813f, -0.15681902f, 0.08663951f, -0.13640353f, -0.03842020f, 0.10485903f, 
    0.08963996f, 0.17851022f, -0.17282024f, 0.07097669f, -0.23400582f, -0.18129995f, -0.02020338f, 0.03292017f, 
    -0.10545635f, -0.03624943f, -0.05514680f, -0.06216566f, 0.74613208f, 0.20646288f, -0.26569685f, -0.15247791f, 
    0.12742552f, -0.13487887f, -0.14541423f, 0.00760560f, 0.04734046f, -0.03569261f, -0.15033425f, 0.06428225f, 
    0.05355794f, 0.10127071f, 0.12429406f, -0.48033810f, 0.11335968f, 0.15611817f, 0.11731420f, 0.01027439f, 
    0.00272168f, -0.02086844f, 0.00049228f, 0.03046408f, -0.30030349f, -0.34574181f, 0.07006614f, -0.17304549f, 
    0.03815743f, 0.04099603f, 0.05044036f, -0.00165536f, -0.05599809f, -0.03987757f, 0.01421336f, -0.04692366f, 
    -0.39636222f, -0.03724856f, 0.10066622f, -0.06630669f, 0.04698046f, 0.19320869f, 0.10641760f, -0.08483696f, 
    -0.16470937f, -0.15702993f, 0.02658926f, 0.09500216f, -0.52486408f, 0.22346996f, -0.25894031f, 0.03236113f, 
    0.03239941f, -0.01892892f, -0.28538284f, 0.13577364f, 0.06972037f, 0.01892103f, -0.17314778f, -0.01455454f, 
    0.16816419f, -0.03025516f, 0.23832643f, -0.18280651f, -0.01270640f, -0.11645027f, 0.08389623f, -0.08790413f, 
    -0.07753134f, -0.09887752f, -0.06422682f, 0.01947746f, 0.04114361f, 0.08324791f, -0.15971954f, 0.16554856f, 
    -0.21430951f, -0.08734898f, -0.00710332f, -0.04467398f, -0.11381174f, 0.06605004f, -0.08280555f, -0.12821957f, 
    -0.07465808f, 0.11965350f, -0.11553504f, 0.06533594f, -0.29162064f, -0.10527643f, 0.03746916f, -0.13915780f, 
    -0.09353763f, 0.17413823f, -0.06263056f, -0.04058029f, 0.03163904f, 0.15456302f, 0.03646886f, -0.66161519f, 
    0.01547098f, -0.10338549f, 0.06475946f, 0.00733541f, 0.01001803f, -0.08900738f, -0.05701222f, 0.10432483f, 
    -0.06399142f, 0.13521776f, 0.12362731f, 0.10533504f, -0.14632182f, -0.03181240f, 0.02617753f, 0.17066836f, 
    -0.01424356f, -0.03169137f, -0.00643093f, -0.17485319f, -0.55605745f, -0.09226223f, -0.06201736f, 0.06466764f, 
    -0.06160441f, 0.04681769f, -0.10654128f, -0.11250828f, 0.02069195f, 0.07572251f, 0.03274995f, 0.02376717f, 
    0.16213834f, -0.00304621f, -0.15567438f, -0.08408004f, -0.04276568f, -0.02090580f, 0.13722135f, -0.00736386f, 
    0.14987922f, 0.09087719f, 0.02673294f, 0.04041440f, -0.37160304f, -0.02007785f, 0.06812879f, 0.30799866f, 
    -0.07120184f, 0.01479455f, 0.12048059f, 0.10925309f, -0.06776042f, 0.02171825f, -0.04154452f, -0.00167516f, 
    0.07474399f, 0.19689989f, -0.02726351f, -0.03640448f, 0.18190263f, 0.07121073f, 0.08852574f, 0.11810430f, 
    -0.11638832f, 0.02551391f, -0.07307641f, 0.05843220f, 0.05848535f, 0.30071375f, -0.00609032f, -0.22249095f, 
    0.13074087f, 0.05809899f, 0.06062461f, 0.01879830f, -0.11306678f, -0.06597632f, -0.04971384f, 0.14505763f, 
    -0.13460208f, 0.13803788f, -0.23159909f, 0.28064594f, 0.08629383f, 0.11825796f, 0.06919243f, -0.10373788f, 
    0.00735879f, 0.09905681f, 0.04377425f, -0.02015784f, -0.35627544f, -0.08799814f, 0.03727705f, 0.19387972f, 
    0.15801843f, 0.01660221f, 0.04334474f, 0.07364861f, -0.03276829f, -0.05053675f, 0.09959685f, 0.09784686f, 
    0.23830290f, -0.02132092f, 0.13113526f, -0.03995778f, -0.23691565f, -0.09143612f, -0.07081310f, 0.10974593f, 
    -0.15601385f, 0.02480806f, -0.01726244f, -0.04003617f, -0.33046660f, -0.02633415f, 0.19926368f, -0.08596385f, 
    -0.12978415f, 0.02385421f, 0.01063904f, -0.10361633f, -0.10153417f, 0.12303316f, -0.04015703f, -0.01626352f, 
    -0.16444269f, -0.15190448f, -0.15451761f, 0.21337020f, -0.11159942f, 0.08554716f, 0.20761889f, 0.07215499f, 
    -0.06366948f, 0.03000424f, -0.05255168f, 0.11958949f, 0.12077753f, 0.19198145f, -0.23534012f, -0.10256457f, 
    0.07109723f, 0.04445177f, -0.04185503f, 0.06662303f, 0.18465249f, 0.03424908f, -0.15175523f, -0.02438825f, 
    -0.54991138f, -0.34499529f, 0.21698198f, -0.29121295f, 0.00270932f, 0.02341298f, 0.06482650f, -0.01038372f, 
    -0.06674016f, 0.00660407f, -0.01044431f, -0.00558891f, -0.32915920f, -0.16338284f, 0.16070323f, -0.05298977f, 
    0.04681011f, -0.08446173f, 0.05053214f, -0.00328452f, 0.00880888f, 0.02208581f, -0.16087285f, -0.02055890f, 
    -0.54994106f, 0.18598476f, -0.14206766f, 0.14632675f, 0.05361987f, -0.00383811f, -0.12174045f, -0.09702724f, 
    -0.01504940f, 0.12173150f, -0.06841134f, -0.01082460f, -0.04525952f, 0.00179842f, 0.10107710f, 0.07905028f, 
    -0.01076483f, -0.09543170f, 0.01354849f, 0.03422515f, -0.10782618f, 0.14318112f, -0.04881493f, -0.04353033f, 
    -0.35656890f, -0.12549132f, -0.05485856f, -0.11676552f, 0.09407949f, -0.07909195f, 0.06568274f, -0.07030001f, 
    -0.02222173f, -0.05497252f, 0.15400444f, -0.03122036f, 0.39360577f, -0.32113168f, -0.08694599f, 0.05557980f, 
    -0.03986000f, -0.07674116f, 0.05483137f, 0.07009035f, -0.03279473f, -0.00743352f, -0.06920745f, 0.16003190f, 
    0.11092813f, 0.04006717f, -0.09631736f, 0.18035603f, 0.05351288f, -0.00116542f, -0.09878463f, 0.07366540f, 
    0.00396523f, 0.17950279f, 0.12315012f, 0.01912705f, -0.76831973f, 0.02865743f, -0.07410491f, 0.17707205f, 
    -0.11096338f, -0.01456247f, -0.07807820f, -0.02245830f, -0.01370459f, 0.06439459f, -0.12578131f, 0.06908122f, 
    0.39736179f, -0.29250437f, 0.18797155f, 0.03548126f, -0.07703722f, -0.02249040f, -0.25077143f, 0.02415236f, 
    0.07887261f, -0.06308284f, -0.15891710f, 0.05082022f, 0.10069440f, -0.22756208f, -0.29849800f, -0.25979865f, 
    -0.12122953f, 0.15741785f, 0.05788049f, -0.19126008f, -0.10266351f, 0.14499123f, -0.00707936f, -0.01847976f, 
    0.01111324f, -0.08478664f, 0.18268560f, 0.08407548f, -0.01590848f, 0.04442345f, 0.06055995f, -0.04847479f, 
    0.08209512f, -0.01925854f, 0.10282709f, 0.06507132f, -0.42879733f, 0.14399000f, -0.02226941f, -0.13022397f, 
    0.19443850f, -0.00779013f, 0.01414441f, 0.03930129f, 0.19485958f, 0.00803578f, -0.02550103f, 0.04072246f, 
    0.03152711f, -0.18657903f, -0.08703241f, -0.10344040f, 0.07994102f, -0.20696643f, -0.00047859f, 0.06578160f, 
    0.06346553f, 0.14348462f, -0.07469905f, 0.08504565f, 0.03767622f, -0.03864152f, 0.08908631f, -0.02755041f, 
    -0.05132251f, 0.08590874f, 0.18181463f, 0.08254236f, -0.08924899f, 0.05274430f, 0.13114387f, 0.04952938f, 
    -0.05944088f, -0.00402957f, -0.25041115f, -0.02364286f, -0.09054748f, -0.10108823f, -0.00885294f, 0.17524527f, 
    0.16589826f, -0.26091027f, -0.13139595f, -0.08328144f, 0.41481245f, -0.04749252f, 0.15722094f, -0.15529735f, 
    -0.00913281f, -0.07939941f, 0.08245989f, -0.00781635f, -0.04990672f, -0.04948591f, 0.06238902f, 0.02480096f, 
    -0.08086248f, 0.11464165f, -0.26387751f, -0.53302568f, 0.09967890f, 0.25370291f, -0.06072783f, 0.11648064f, 
    0.13570113f, -0.03824763f, 0.06669459f, 0.05885337f, 0.27239123f, -0.00587428f, 0.04724470f, 0.21037300f, 
    -0.03614053f, -0.08000533f, 0.01059709f, -0.01200130f, 0.02772984f, -0.01463060f, -0.07757852f, 0.15060088f, 
    0.02944595f, 0.19541185f, 0.18005866f, 0.16731669f, -0.10789951f, 0.03816744f, -0.00815188f, 0.07659568f, 
    0.08208995f, -0.01315552f, 0.04776153f, -0.07795774f, 0.17237698f, -0.08450308f, 0.01029994f, -0.40244922f, 
    -0.09977920f, -0.06319897f, 0.15767856f, 0.00679783f, -0.07928209f, -0.08080357f, 0.09253898f, -0.00548157f, 
    -0.05765218f, -0.30180204f, -0.11358346f, -0.45756853f, 0.05261415f, 0.05202173f, 0.03790626f, -0.00820427f, 
    -0.13253760f, 0.10484362f, 0.09006974f, -0.05000847f, 0.18608758f, -0.18423145f, -0.11055461f, -0.28482521f, 
    -0.12332509f, 0.02468366f, -0.15603638f, 0.25872076f, 0.07351848f, 0.01580941f, -0.00365783f, 0.03376916f, 
    0.43720382f, -0.08536898f, 0.08292137f, 0.21327537f, -0.00805133f, -0.12935030f, -0.00792441f, 0.04785589f, 
    -0.03767816f, 0.02849204f, -0.05385994f, -0.07235251f, -0.61312723f, 0.10041704f, -0.35080025f, -0.19432543f, 
    -0.23944114f, 0.01101440f, -0.06504232f, -0.04012277f, 0.08403502f, -0.10261571f, -0.00580369f, -0.17956078f, 
    -0.63253766f, -0.01432169f, -0.14492460f, -0.24754134f, 0.03675830f, 0.03930467f, -0.02958646f, 0.09255606f, 
    0.02154823f, 0.11074741f, 0.04712506f, -0.22781785f, 0.33870152f, -0.05882204f, -0.04116577f, -0.05888317f, 
    0.22635089f, 0.09042388f, -0.23271880f, -0.03684906f, 0.14923882f, -0.01448456f, -0.08809023f, -0.09993526f, 
    -0.17905235f, -0.03977213f, -0.14241934f, 0.10298423f, -0.05599594f, -0.06648773f, -0.18906438f, -0.21621320f, 
    -0.02243540f, -0.14894658f, -0.05437634f, 0.04891822f, -0.01251753f, -0.06259076f, -0.11316399f, 0.03848713f, 
    -0.04511717f, 0.04023534f, -0.12234531f, -0.06863208f, -0.20599864f, 0.02879935f, 0.05007608f, 0.02897033f, 
    0.29209083f, 0.03141258f, 0.06023332f, 0.27531654f, -0.03682023f, -0.05981834f, 0.13824120f, 0.02437496f, 
    0.00454275f, -0.14707369f, -0.03338238f, -0.09285817f, 0.26212418f, -0.02846181f, -0.14192098f, 0.06305937f, 
    -0.12370855f, -0.32988188f, 0.00193099f, -0.00865348f, 0.03991456f, -0.03983011f, -0.31373674f, -0.25408611f, 
    0.29601821f, 0.11059218f, 0.01433479f, 0.16378106f, -0.12316512f, 0.03769118f, -0.08589537f, 0.00287150f, 
    0.03923844f, -0.06002688f, 0.11982050f, 0.00379843f, 0.20323668f, -0.14450474f, -0.18344234f, -0.04814735f, 
    -0.02923084f, -0.08131612f, 0.05445559f, 0.03289243f, 0.09814359f, -0.10780858f, 0.06028198f, 0.08144253f, 
    0.41273317f, -0.11260492f, -0.01895720f, -0.18247649f, 0.06881117f, -0.06414476f, 0.05577682f, 0.02789638f, 
    0.08819801f, -0.05244374f, 0.07996358f, -0.11250740f, -0.11434983f, 0.16675836f, 0.08190592f, 0.05143499f, 
    0.02213709f, 0.00647164f, 0.04770573f, 0.04930854f, 0.20818593f, 0.04450899f, 0.12501520f, 0.01576275f, 
    0.28814736f, -0.14470986f, -0.02857175f, 0.15413006f, -0.13960198f, 0.09178893f, -0.06478830f, 0.05945919f, 
    -0.03075102f, -0.14575323f, 0.17655356f, -0.00901165f, 0.07876588f, -0.00057087f, 0.29120839f, 0.14702867f, 
    -0.20121609f, 0.07688536f, -0.02106166f, 0.06639536f, -0.06058654f, -0.24560535f, -0.07775911f, -0.12115817f, 
    0.51721543f, 0.06041196f, 0.20274954f, 0.00829908f, 0.06533640f, -0.02133276f, 0.02713252f, 0.10035661f, 
    -0.01789751f, 0.01539492f, 0.03060273f, -0.12368784f, 0.15786687f, -0.00116690f, 0.03315089f, -0.26789591f, 
    0.06638901f, -0.00359844f, 0.05599790f, -0.11021432f, 0.07402757f, -0.02329906f, 0.07342286f, -0.04635799f, 
    0.02894866f, -0.09479091f, 0.05575033f, 0.10393310f, -0.01933442f, -0.01777468f, 0.06893086f, -0.05521581f, 
    0.08811060f, 0.04285123f, -0.00766120f, 0.06501198f, 0.06390092f, -0.05585773f, -0.48390961f, -0.40200290f, 
    -0.24304372f, -0.04105094f, -0.08271769f, 0.10669298f, 0.14213589f, 0.10495923f, 0.08927673f, -0.13023202f, 
    0.14145485f, 0.09121951f, 0.12584691f, -0.11777554f, 0.07623746f, 0.05592861f, 0.08062669f, 0.04161820f, 
    0.02306996f, 0.07087402f, -0.05344145f, 0.11096773f, 0.21910432f, -0.03264117f, -0.20830597f, 0.01772533f, 
    -0.00194981f, -0.01319223f, 0.05680941f, -0.18087368f, -0.08817514f, 0.04761644f, -0.04425442f, -0.01369516f, 
    0.04433500f, -0.00696756f, -0.15875091f, 0.08598958f, 0.16150935f, 0.04179648f, -0.09208909f, -0.13627215f, 
    -0.01454076f, -0.00840272f, -0.14951061f, -0.02071513f, 0.18685445f, 0.04563962f, -0.21050322f, 0.16681117f, 
    -0.16197532f, -0.22902618f, -0.21560018f, 0.06614433f, 0.00828965f, -0.04231308f, -0.04513242f, 0.09850680f, 
    0.23769423f, 0.00576359f, 0.20934343f, 0.22556713f, -0.24897078f, -0.15485580f, 0.08802482f, 0.19365482f, 
    0.12862544f, -0.09475718f, 0.00369592f, -0.07867657f, 0.34213883f, -0.18002264f, -0.12579018f, 0.05873035f, 
    -0.12237193f, -0.12547913f, -0.10126873f, -0.12575454f, 0.06027260f, -0.01760215f, -0.07703325f, -0.00316006f, 
    -0.31340349f, -0.22589847f, 0.21749754f, -0.23980869f, -0.02101652f, 0.05678151f, -0.08895660f, -0.00994940f, 
    0.08147375f, -0.13602003f, -0.08794007f, -0.09150157f, 0.35219932f, 0.01980169f, -0.16956189f, 0.13236171f, 
    -0.19175591f, -0.03824118f, -0.15200122f, 0.04084719f, 0.09391502f, -0.10705341f, 0.00233986f, 0.02228135f, 
    0.23827884f, 0.02095202f, -0.35702458f, -0.14883953f, 0.16655383f, 0.08323106f, 0.03412621f, -0.06919730f, 
    -0.04340957f, 0.02322964f, 0.06868616f, -0.09504791f, 0.15638077f, 0.03288820f, -0.03812313f, -0.20084102f, 
    0.09720358f, 0.09172778f, 0.06659663f, -0.03357838f, -0.01407236f, 0.05996146f, -0.02239832f, -0.00219016f, 
    0.01383173f, -0.05795102f, 0.03971672f, -0.03959245f, -0.08554591f, 0.15682928f, 0.08476296f, -0.04750729f, 
    -0.00961185f, 0.09911554f, -0.05854351f, -0.10015966f, -0.20661478f, -0.21173997f, 0.01943023f, -0.30821517f, 
    0.12325939f, -0.11771191f, 0.20416296f, -0.09942622f, -0.12764621f, 0.02683992f, -0.00392013f, -0.10636606f, 
    -0.19721681f, -0.07943407f, -0.42629582f, -0.15321478f, 0.22203472f, -0.09245000f, -0.05932337f, -0.13150945f, 
    0.03712441f, 0.06011585f, -0.02844327f, -0.05136291f, 0.06110008f, -0.25821847f, 0.28732646f, 0.22394097f, 
    -0.01329169f, -0.17856032f, 0.08012854f, -0.07432102f, -0.02387831f, -0.11429857f, 0.05415526f, 0.12670046f, 
    -0.31014022f, 0.08991685f, 0.18365595f, -0.09854660f, 0.01631774f, -0.03255085f, -0.05514732f, 0.11921401f, 
    -0.07962714f, -0.03935622f, -0.03198079f, -0.11685324f, 0.54951167f, 0.01480846f, -0.58022732f, -0.27491140f, 
    -0.09288389f, -0.01938034f, 0.14903185f, 0.03451573f, 0.05520451f, 0.06985267f, -0.11323432f, -0.03130055f, 
    0.12185760f, -0.06327039f, -0.21874590f, -0.00198027f, -0.06162759f, -0.06873765f, 0.02368215f, -0.03598724f, 
    -0.20213829f, -0.05212836f, -0.06508061f, 0.12387771f, 0.10147031f, 0.23128772f, 0.04950680f, 0.28489348f, 
    -0.12207634f, -0.10208680f, 0.06621233f, 0.14504796f, -0.05969785f, -0.01818531f, 0.06544193f, -0.03391628f, 
    0.36535069f, -0.06111677f, -0.31697133f, 0.09818621f, -0.05026894f, 0.18629403f, -0.04422811f, -0.05434763f, 
    -0.08645081f, -0.06493899f, -0.06897073f, -0.09401847f, 0.43581963f, -0.27790901f, 0.01739068f, -0.19033410f, 
    0.00021753f, -0.09478297f, 0.05592988f, -0.02863087f, -0.05024663f, -0.00846597f, 0.04851239f, -0.15216939f, 
    -0.18138282f, 0.17776813f, -0.05653319f, -0.07668938f, 0.06348135f, 0.10583364f, -0.00205544f, -0.10795381f, 
    -0.08428061f, 0.06562898f, -0.03330545f, -0.07206281f, 0.22936809f, -0.31790382f, 0.03802543f, -0.07179567f, 
    -0.06228802f, 0.14501403f, -0.08537363f, 0.07048438f, 0.17066178f, 0.04514328f, -0.08959254f, -0.04860631f, 
    -0.29553699f, -0.17573284f, 0.18568440f, 0.14916541f, -0.04948135f, 0.11826809f, 0.03607349f, -0.06039932f, 
    -0.10343069f, -0.05466435f, -0.29050651f, 0.08706019f, 0.05464215f, -0.13473704f, 0.21752344f, 0.19524068f, 
    -0.17351255f, -0.12050455f, -0.01480686f, -0.00169680f, -0.24668698f, -0.09325396f, -0.05470616f, -0.02489457f, 
    -0.22315882f, -0.09816274f, 0.10027608f, -0.41325849f, -0.16672096f, -0.11621494f, -0.04363461f, 0.11503308f, 
    -0.14663082f, 0.02993659f, -0.02409806f, -0.06026685f, -0.06303386f, -0.35691988f, -0.11487536f, -0.17337419f, 
    -0.06582252f, -0.02591568f, -0.02556755f, -0.03557664f, -0.10807379f, -0.03999194f, -0.19825153f, -0.16846013f, 
    0.61116338f, -0.18221067f, 0.10093868f, 0.09219778f, -0.04233040f, 0.06316893f, -0.11309830f, -0.03381198f, 
    0.02206544f, 0.00442607f, 0.07864159f, -0.04598066f, 0.08731866f, 0.01954710f, -0.07945986f, 0.12462001f, 
    0.00344710f, -0.00175043f, -0.05130066f, -0.00009136f, -0.13861868f, 0.02763295f, 0.05834637f, -0.00489794f, 
    -0.27026862f, -0.01039593f, -0.06523720f, -0.08541951f, -0.11332048f, 0.14031981f, -0.01869677f, -0.02924198f, 
    -0.09090953f, -0.04385737f, -0.02991240f, 0.07213049f, 0.17855318f, -0.52602428f, -0.49496001f, 0.01147957f, 
    0.05297104f, 0.13882595f, -0.18063262f, -0.00229590f, -0.08034673f, 0.06229000f, -0.03992402f, 0.01399912f, 
    -0.11706559f, 0.16539286f, -0.15836503f, 0.04259364f, -0.01704681f, -0.10544626f, 0.03495935f, 0.03593867f, 
    -0.06489711f, -0.02565963f, -0.00481346f, 0.03623902f, 0.19605196f, 0.17277142f, 0.06115849f, -0.19847806f, 
    0.08932403f, -0.11518186f, -0.03811505f, 0.12813388f, -0.16754457f, -0.13173404f, 0.04242917f, -0.02298433f, 
    -0.05569009f, -0.14591452f, -0.13820717f, -0.12816496f, 0.00220646f, 0.06522179f, -0.08174315f, -0.09919167f, 
    0.00838261f, -0.03699565f, 0.05736495f, 0.01036891f, 0.77164620f, 0.04069975f, 0.01817122f, 0.24305299f, 
    0.15897381f, -0.01060756f, 0.01922142f, 0.19725905f, 0.01892119f, 0.06849370f, -0.09375592f, -0.10732062f, 
    -0.38148218f, -0.26298967f, 0.20378697f, 0.23486841f, 0.06017265f, 0.05719040f, -0.00427357f, -0.01431701f, 
    -0.07032032f, -0.12128034f, -0.12240889f, -0.12849978f, 0.08431773f, 0.32694903f, -0.02578894f, -0.11670855f, 
    -0.19214574f, -0.01248879f, 0.11791956f, 0.02682825f, -0.07660869f, 0.05954945f, -0.00040034f, -0.06263648f, 
    -0.05845030f, -0.13825668f, -0.03994277f, -0.21595125f, -0.04281458f, -0.09809223f, 0.10251918f, 0.03809747f, 
    -0.12349175f, -0.06027718f, 0.07958534f, -0.04523950f, 0.06231193f, -0.06808497f, 0.00527656f, -0.07465080f, 
    -0.09002724f, -0.23070827f, -0.10807797f, -0.01165218f, -0.06904900f, 0.10612705f, -0.05182719f, 0.07575397f, 
    0.09827307f, 0.02999620f, 0.13263313f, -0.13319141f, 0.05977215f, -0.02665046f, 0.05243230f, 0.07781522f, 
    0.18116504f, -0.06565679f, 0.01819069f, 0.01694106f, 0.17974119f, -0.00163024f, -0.02044400f, 0.00234140f, 
    0.00112775f, -0.07604341f, 0.11376438f, -0.07233540f, -0.02726502f, 0.07492977f, -0.01772401f, -0.00597750f, 
    -0.59705621f, 0.46265554f, 0.18455265f, -0.06010489f, -0.06971560f, 0.00452080f, -0.08765183f, 0.22469828f, 
    0.10779718f, 0.10121322f, -0.14108934f, 0.03663427f, -0.90455014f, -0.47944260f, -0.20709737f, 0.04877414f, 
    -0.25252500f, 0.03739850f, 0.06877755f, 0.05412088f, -0.04242853f, -0.14247289f, 0.17607746f, -0.04747797f, 
    -0.45975751f, -0.36079907f, 0.01397306f, 0.22778136f, 0.07755807f, -0.04534311f, -0.01086827f, -0.21357478f, 
    -0.02174834f, 0.05182536f, -0.13561717f, 0.01263791f, -0.15749910f, -0.02487600f, 0.09775919f, -0.14194573f, 
    -0.07273336f, -0.01611530f, -0.07034672f, 0.13238236f, 0.15190344f, 0.09624388f, -0.02145607f, 0.21280634f, 
    0.15485717f, 0.22370309f, 0.26376790f, 0.08707795f, -0.00223303f, -0.06410123f, 0.04283700f, 0.05282011f, 
    0.12721354f, 0.03806493f, -0.17711107f, -0.00789388f, 0.07015989f, -0.05859981f, 0.06584854f, 0.15043060f, 
    -0.02500601f, 0.07694487f, -0.03760455f, -0.07747957f, -0.16774540f, -0.06701106f, -0.09151559f, 0.04772200f, 
    -0.20828053f, -0.27731159f, 0.09674060f, 0.02682190f, -0.11738797f, 0.06843452f, 0.03183625f, 0.05312673f, 
    -0.05782003f, 0.00352671f, 0.08281334f, 0.12187415f, -0.35220814f, 0.51771653f, 0.15042290f, 0.02824340f, 
    0.07966357f, 0.00934549f, 0.03564801f, 0.04550789f, -0.12280101f, -0.06592125f, 0.08717241f, 0.20721859f, 
    0.32669500f, 0.24954093f, 0.07496956f, 0.03628856f, -0.02637800f, -0.17774230f, 0.04285448f, -0.01708491f, 
    0.04726800f, -0.19236545f, 0.09353302f, 0.12766846f, -0.14364456f, 0.09686951f, -0.14747325f, -0.17873672f, 
    -0.08257135f, -0.02903440f, 0.18204555f, -0.06945617f, -0.11080953f, -0.02138032f, -0.02833946f, 0.02008819f, 
    -0.52217591f, 0.14007701f, 0.26509175f, 0.06657789f, 0.09086844f, 0.08310166f, 0.09368169f, 0.02559015f, 
    0.03761511f, -0.15381005f, -0.24212284f, -0.10499995f, 0.07641254f, 0.07557216f, -0.07622224f, -0.06340747f, 
    0.01032288f, -0.01901647f, -0.00241969f, -0.22484380f, 0.03928127f, -0.07575726f, -0.03794222f, -0.15628557f, 
    -0.05156394f, -0.70882529f, -0.24889691f, 0.27130148f, -0.04593725f, 0.03870691f, -0.08279251f, -0.11557064f, 
    0.06550915f, -0.08913400f, 0.05484883f, 0.07837602f, -0.06727258f, 0.08599546f, -0.02281323f, 0.19385317f, 
    -0.02904032f, -0.03112055f, -0.02327376f, 0.15656877f, -0.03380076f, 0.10027121f, 0.07622918f, 0.10383248f, 
    -0.14079432f, -0.52652502f, -0.08164208f, 0.14852193f, -0.03143067f, -0.05200186f, 0.04246195f, 0.00884714f, 
    0.12742223f, -0.12249187f, -0.04842560f, 0.00718119f, -0.31035495f, 0.26894423f, -0.12867855f, -0.24394910f, 
    -0.20231372f, -0.13386761f, 0.04870592f, 0.06476270f, 0.00739712f, -0.05219742f, -0.10993797f, -0.03279619f, 
    0.05129457f, -0.02327522f, 0.11412784f, 0.05047973f, -0.11283197f, -0.03380252f, 0.19957921f, 0.09318017f, 
    -0.14860611f, 0.06417631f, 0.12444492f, 0.05798954f, 0.09011509f, 0.04148950f, 0.11107034f, 0.01355057f, 
    0.08060702f, 0.00511295f, 0.09617063f, -0.00455507f, 0.00068853f, -0.00313391f, -0.21116254f, -0.17657265f, 
    0.11050345f, 0.02164101f, 0.00533112f, 0.05959364f, -0.04810156f, -0.06077548f, 0.07832160f, -0.06281798f, 
    -0.01121949f, 0.11388382f, -0.14774516f, 0.04788518f, 0.17308591f, -0.75275844f, -0.29035723f, -0.05999658f, 
    0.08460096f, -0.10003483f, -0.01728444f, -0.00622868f, 0.01592531f, 0.17131525f, -0.02035535f, 0.07981858f, 
    -0.20980798f, -0.07526930f, 0.19915862f, 0.35331416f, 0.07552641f, 0.00960387f, 0.16972569f, 0.02957668f, 
    0.06367116f, 0.12610394f, 0.01567164f, 0.02456304f, -0.21752512f, 0.22373496f, 0.26420110f, -0.00753245f, 
    -0.09530771f, 0.00778842f, 0.00534322f, -0.11968837f, 0.29264998f, -0.10195709f, -0.09494216f, -0.14163820f, 
    -0.02039896f, -0.07328320f, -0.13358998f, 0.01270931f, -0.02119951f, 0.02921258f, 0.09691846f, 0.02545397f, 
    -0.02848726f, -0.13692445f, -0.03705388f, -0.15000311f, -0.06972928f, -0.43300194f, -0.14568672f, -0.34671825f, 
    -0.07362191f, 0.15191486f, 0.00120036f, 0.05730010f, -0.11426274f, -0.09034391f, 0.01131282f, 0.15399937f, 
    0.28979921f, 0.00262458f, -0.07968331f, 0.08057533f, -0.01966488f, -0.05839301f, 0.06278011f, -0.11607772f, 
    -0.20561245f, 0.06446832f, -0.08196709f, 0.01062614f, 0.14263427f, 0.50759047f, -0.09231286f, -0.35636666f, 
    -0.10896239f, 0.05476430f, -0.05311788f, 0.15739024f, -0.13866566f, 0.09930719f, -0.07958678f, 0.03150335f, 
    -0.26877713f, 0.02154869f, 0.26277763f, 0.16625100f, -0.08814391f, 0.06908559f, -0.06781779f, -0.04668425f, 
    0.03257709f, -0.09741540f, -0.10870616f, -0.05467391f, -0.03933083f, -0.31619337f, -0.17684506f, -0.12347575f, 
    0.10409196f, 0.12110836f, -0.02142204f, 0.09733211f, 0.01767739f, -0.20608096f, -0.10138252f, -0.03163558f, 
    -0.64882290f, 0.02605301f, 0.17282131f, 0.35871816f, -0.08393210f, -0.07872181f, 0.00570186f, -0.07800638f, 
    -0.00437673f, 0.12687506f, 0.07996935f, 0.01238530f, 0.04638644f, 0.06764250f, 0.14660148f, 0.31581494f, 
    0.11571914f, 0.04237928f, 0.00839822f, 0.25019711f, 0.00744615f, 0.07274312f, 0.05856675f, 0.06150265f, 
    0.06867931f, 0.14814918f, 0.13658054f, -0.20459177f, -0.06153535f, -0.02229414f, 0.00007691f, -0.11626032f, 
    -0.01840272f, 0.07530921f, -0.04339083f, 0.10082930f, -0.09453264f, 0.10882545f, -0.16010301f, 0.00365420f, 
    0.01863815f, -0.00729062f, 0.10687196f, 0.13728842f, -0.09951144f, -0.21974406f, -0.03694350f, -0.10703485f, 
    -0.05763971f, 0.10075167f, 0.05346164f, 0.08486927f, -0.14688265f, -0.07156519f, 0.11723154f, -0.13938719f, 
    -0.01251239f, -0.00187649f, 0.00461700f, -0.02191632f, -0.17271568f, -0.11556827f, 0.04686241f, 0.03350770f, 
    -0.05131646f, 0.07848296f, 0.07727959f, 0.10051693f, 0.12107979f, 0.04674794f, -0.02876037f, -0.00417501f, 
    -0.56685394f, -0.20460720f, 0.12027168f, -0.09001484f, 0.01827106f, -0.14597635f, -0.20402949f, 0.02676671f, 
    0.11408427f, -0.17654997f, 0.01196824f, 0.13850969f, -0.16580485f, -0.46113244f, -0.05776798f, 0.05654372f, 
    -0.05436672f, -0.03483549f, 0.06337952f, 0.02725932f, -0.04819671f, -0.01703761f, 0.06120919f, -0.03625429f, 
    -0.13555919f, -0.10551886f, 0.17977718f, -0.06349336f, 0.18412136f, -0.07278338f, 0.04206908f, -0.02012607f, 
    0.10531645f, -0.02033137f, -0.05604736f, 0.11764238f, 0.11287766f, -0.37248236f, -0.06200514f, -0.11227149f, 
    -0.03373449f, -0.12733658f, 0.11385792f, 0.08366608f, 0.14331956f, 0.06784470f, 0.06090764f, 0.11871193f, 
    -0.45148361f, 0.49940884f, -0.02309257f, -0.29523203f, 0.18909942f, 0.06423604f, -0.01411966f, 0.02503257f, 
    -0.00829372f, -0.04050072f, 0.06357577f, -0.07432531f, -0.34577930f, -0.10944281f, 0.21981306f, -0.27529448f, 
    0.17103690f, -0.04014901f, 0.04842684f, -0.05206926f, 0.00078108f, -0.01560196f, -0.07623651f, 0.06418841f, 
    0.41968048f, 0.15310983f, -0.16234376f, -0.33554199f, -0.03893100f, -0.19983619f, 0.07409725f, 0.05228183f, 
    0.04916772f, -0.08430823f, 0.10189651f, 0.13746914f, -0.17940998f, -0.17899771f, 0.03122988f, 0.11857963f, 
    -0.06558146f, 0.01419604f, 0.11218064f, 0.01275990f, -0.00034491f, -0.01798344f, 0.08232521f, -0.00208746f, 
    -0.40158722f, -0.06307739f, 0.09000444f, 0.16219002f, -0.00578374f, -0.02847016f, 0.07121917f, 0.10740837f, 
    -0.08227122f, 0.10639490f, -0.09923376f, -0.05334187f, -0.16796692f, 0.03379279f, 0.09238940f, 0.11065410f, 
    0.02425080f, -0.04479507f, -0.02422368f, 0.13366954f, 0.25280464f, -0.16584837f, -0.07586396f, -0.22256258f, 
    -0.21296731f, 0.01783092f, 0.13882257f, 0.17077769f, -0.04851056f, 0.01336283f, -0.07307369f, 0.02234530f, 
    0.14053690f, -0.04144740f, 0.09411073f, 0.05892340f, -0.42974523f, 0.10666183f, 0.07091299f, -0.05034498f, 
    0.02529101f, 0.15428534f, 0.09017289f, -0.06393448f, 0.10502969f, -0.08282775f, -0.04968033f, 0.08670153f, 
    0.20726991f, 0.22066073f, -0.23501842f, -0.22288720f, -0.01718050f, -0.05398224f, 0.08916878f, 0.12250561f, 
    -0.02212489f, 0.23255716f, -0.20063175f, 0.05749954f, -0.10420452f, 0.03353915f, -0.06432251f, 0.22723207f, 
    0.10189356f, 0.04510446f, 0.14621323f, 0.00567683f, 0.06993937f, 0.17815769f, 0.09492972f, -0.08822268f, 
    -0.00125885f, -0.19983317f, 0.01680689f, 0.08606265f, 0.13809407f, 0.03335591f, -0.02909555f, -0.12350221f, 
    -0.03233102f, -0.03263819f, -0.07522482f, 0.02759651f, -0.00639299f, -0.09555990f, 0.21809238f, 0.04026221f, 
    -0.07235654f, 0.07926890f, 0.05795204f, 0.00633627f, 0.03234974f, 0.00222546f, -0.13422705f, 0.19246602f, 
    -0.71020764f, 0.24615611f, -0.12998399f, -0.15215054f, -0.00305574f, -0.03983457f, 0.07255010f, 0.08192058f, 
    -0.06827526f, 0.01464901f, -0.09107013f, 0.07387062f, -0.00478502f, 0.25497550f, -0.18292983f, -0.19281761f, 
    -0.04624888f, -0.14280227f, -0.07035916f, 0.04523522f, 0.01400126f, -0.01143651f, -0.06343756f, 0.05329168f, 
    -0.00570159f, -0.01599096f, -0.29388726f, -0.03649105f, 0.05834742f, -0.00723268f, -0.02619544f, -0.14125812f, 
    -0.02083445f, -0.21096952f, 0.00809283f, -0.06073247f, -0.09246399f, 0.02992878f, 0.06793594f, -0.05737133f, 
    -0.00568055f, -0.03715060f, -0.05141771f, 0.06523003f, -0.05603101f, 0.02235724f, 0.17725429f, 0.01071263f, 
    -0.39796799f, 0.23013079f, 0.37686479f, -0.57537562f, -0.07439024f, 0.12176569f, 0.03200297f, 0.04490707f, 
    -0.09744300f, -0.12194563f, 0.06748722f, -0.47822908f, -0.19828427f, 0.11570964f, -0.09078706f, 0.16851918f, 
    0.10121100f, 0.02505038f, 0.12874755f, 0.02213805f, 0.08935972f, -0.15722780f, -0.00635587f, -0.15068619f, 
    0.08666678f, -0.03445930f, 0.01608195f, -0.33649272f, -0.13941844f, -0.07020773f, -0.13579814f, 0.04123544f, 
    0.23680931f, -0.10212401f, 0.03172937f, -0.11653541f, -0.35195315f, -0.48669338f, 0.37431443f, 0.37802354f, 
    -0.20951012f, -0.05381604f, 0.05603290f, -0.12875246f, -0.15637387f, -0.02107513f, 0.07320071f, -0.02931842f, 
    0.22018048f, -0.08661060f, 0.15253757f, 0.00112344f, -0.16658348f, -0.00575172f, 0.11474506f, 0.06709524f, 
    -0.20296037f, 0.17923975f, 0.08923712f, 0.29028794f, -0.82483071f, -0.05598358f, -0.05350533f, 0.03213089f, 
    0.12017007f, 0.26745659f, 0.26661655f, 0.07398915f, 0.08143143f, 0.09790196f, 0.02658877f, 0.02198019f, 
    0.16938633f, 0.01435312f, -0.40743765f, -0.05785559f, 0.28434762f, 0.04385186f, -0.16927141f, -0.07723603f, 
    0.07843287f, -0.06504362f, -0.03898387f, -0.11172223f, -0.12679957f, -0.17716335f, -0.23835203f, 0.13004825f, 
    0.12680356f, 0.11375319f, -0.09872347f, 0.07531653f, 0.08736397f, 0.00088558f, 0.00030892f, 0.06324156f, 
    -0.27172920f, -0.42056829f, -0.02159032f, 0.22358097f, 0.12010054f, -0.25484431f, 0.01381032f, 0.07038071f, 
    0.06151624f, 0.06977207f, -0.08749273f, -0.09093238f, -0.77522755f, -0.14523228f, -0.14735360f, -0.11712532f, 
    0.04277936f, 0.10839999f, 0.15315668f, 0.05092885f, -0.00390542f, 0.12242989f, 0.05396605f, -0.12140864f, 
    -0.16175336f, -0.19336672f, 0.06453900f, 0.14270528f, -0.13639820f, -0.11604680f, -0.01684952f, -0.10952495f, 
    0.08381019f, 0.12838583f, -0.04528450f, 0.18127978f, -0.00724092f, 0.04248741f, 0.03869818f, -0.17207201f, 
    0.10287869f, 0.16272964f, -0.09037507f, -0.06668937f, -0.14973994f, -0.04937602f, 0.26746476f, 0.02676689f, 
    0.19661319f, -0.14794236f, 0.12902559f, -0.01899913f, -0.03141916f, 0.05452084f, 0.03036025f, 0.12980461f, 
    -0.14337415f, -0.03281964f, 0.08671836f, -0.06253576f, 0.08790120f, 0.11329788f, -0.00829441f, 0.03584358f, 
    -0.01488355f, -0.05617308f, -0.12096354f, -0.17381915f, -0.03635707f, -0.04711417f, -0.00902033f, -0.13229126f, 
    0.10439265f, -0.00192590f, 0.13797295f, 0.22636339f, -0.09822828f, 0.13423456f, 0.03073257f, -0.09560737f, 
    0.02503049f, -0.05074866f, 0.11429325f, 0.22434834f, 0.02874796f, -0.02195995f, -0.09812039f, -0.00271495f, 
    0.21354155f, 0.18964769f, 0.09282940f, 0.03837121f, 0.10781638f, -0.14889272f, -0.07521984f, -0.00765083f, 
    -0.48235184f, 0.20009522f, 0.28277692f, 0.22529793f, 0.03055537f, 0.09118762f, -0.07667793f, -0.13881899f, 
    -0.00458128f, -0.10963765f, 0.11477128f, -0.05631794f, 0.13223270f, -0.17178370f, -0.21872713f, 0.36858329f, 
    0.06262574f, -0.11301695f, -0.11671952f, 0.05876728f, -0.10719775f, 0.03315939f, -0.04010090f, -0.07416714f, 
    0.01223462f, -0.23494096f, 0.39970475f, 0.03427543f, 0.14432119f, 0.00267548f, -0.03084947f, -0.33475232f, 
    0.05214045f, -0.04326362f, 0.01029401f, -0.03852250f, -0.18501888f, 0.13831767f, -0.06730257f, -0.14238220f, 
    -0.10965709f, 0.16412985f, -0.14590169f, -0.31735328f, 0.08070862f, -0.03527937f, 0.02077612f, -0.09358571f, 
    0.10379371f, -0.05623089f, -0.01765721f, -0.38988194f, 0.20715745f, -0.06643537f, 0.02268814f, 0.12958054f, 
    0.08298327f, -0.00572225f, 0.12830096f, 0.16356787f, -0.14459966f, -0.07779586f, 0.06259815f, -0.14266959f, 
    0.02724370f, 0.04659278f, -0.07801455f, 0.00595970f, -0.08379495f, 0.17625540f, 0.17449404f, 0.40769249f, 
    -0.01930783f, 0.07405493f, 0.09538037f, 0.19737607f, -0.09288539f, -0.17023282f, 0.05893993f, 0.01538501f, 
    -0.02905668f, 0.00823760f, -0.05034575f, 0.02781023f, -0.09517390f, -0.41198644f, 0.00104329f, -0.02620523f, 
    0.14107767f, 0.05418593f, 0.00823476f, 0.02498998f, -0.13987920f, 0.02183679f, -0.03595723f, -0.04940192f, 
    0.07561520f, 0.09538070f, 0.16707054f, 0.03794523f, 0.19451396f, -0.03525514f, -0.11291535f, -0.06734616f, 
    -0.02150314f, 0.10023431f, 0.18749537f, 0.05269324f, -0.35617331f, -0.20333871f, 0.01246722f, -0.16489585f, 
    0.03952261f, 0.03538730f, -0.20568597f, -0.01811657f, 0.12160325f, -0.16175146f, 0.08907264f, 0.19312482f, 
    -0.14165369f, 0.21626778f, 0.27785689f, 0.28161013f, -0.04841383f, -0.06474492f, 0.19586827f, 0.12228660f, 
    0.05712631f, -0.11390206f, 0.15814398f, -0.02971404f, -0.04465543f, 0.07028078f, -0.10289614f, 0.03335056f, 
    0.04910730f, -0.11693226f, -0.17046356f, 0.08928830f, -0.09434877f, -0.01648743f, 0.40054718f, 0.14890663f, 
    -0.76637423f, 0.15794834f, -0.20308140f, -0.48024338f, 0.15328491f, -0.02838991f, -0.01760634f, -0.08263132f, 
    0.06843192f, -0.12176976f, -0.12733877f, -0.12714919f, -0.16639191f, -0.09483689f, 0.15913333f, 0.17900126f, 
    0.11929478f, 0.05768263f, -0.00586781f, 0.02591834f, 0.21489163f, 0.01542135f, -0.25359306f, -0.00793431f, 
    0.02723227f, -0.36310562f, 0.01612726f, 0.19319218f, 0.02447432f, 0.04649106f, -0.09723708f, -0.05660246f, 
    0.14694691f, 0.05935087f, -0.07555597f, 0.18161879f, -0.24414638f, 0.13472861f, 0.13439684f, 0.06164785f, 
    0.05080259f, 0.19420446f, 0.10660974f, 0.04114128f, 0.12576468f, -0.07745706f, -0.10962817f, -0.08859845f, 
    0.06936773f, -0.12209993f, 0.00371308f, 0.18378311f, -0.08174837f, 0.10752857f, -0.02574204f, -0.00238957f, 
    0.04860728f, -0.04498666f, -0.02691717f, 0.16110778f, 0.40087637f, -0.45550910f, 0.24823667f, -0.38281330f, 
    0.15099333f, -0.04043315f, 0.01721741f, -0.04496536f, -0.00880605f, -0.11862312f, 0.02762155f, 0.04274042f, 
    -0.24364035f, -0.09632754f, 0.20158350f, -0.12803921f, -0.11014695f, 0.03656644f, 0.02317817f, 0.22010866f, 
    -0.05855120f, -0.14992277f, 0.02907947f, 0.17296197f, 0.31742859f, -0.10963608f, 0.08067043f, -0.10559495f, 
    -0.05776504f, -0.01631404f, 0.09979220f, 0.01537516f, 0.14265737f, -0.09033235f, -0.07895645f, 0.19141176f, 
    0.17663263f, 0.20949228f, 0.14358813f, -0.48038617f, 0.04248771f, -0.00843771f, -0.06216876f, 0.06339023f, 
    0.10534749f, -0.05746083f, 0.01751014f, -0.17758310f, 0.28094307f, -0.04281872f, 0.30945688f, 0.06325947f, 
    -0.26046675f, 0.13455303f, -0.16650367f, -0.20432237f, -0.25837746f, 0.09043861f, 0.05370519f, 0.00452328f, 
    -0.17199525f, -0.47682205f, -0.33604887f, -0.06743006f, 0.00145072f, 0.00537304f, 0.04098247f, -0.07634126f, 
    0.04557356f, -0.01658561f, 0.04355504f, 0.19773626f, -0.23116131f, 0.01172109f, -0.37778682f, -0.16848575f, 
    -0.15512232f, -0.03752596f, 0.06945856f, -0.13235284f, 0.00894375f, -0.07721407f, 0.04365817f, -0.10566948f, 
    -0.01928623f, 0.12134024f, -0.60886830f, 0.16602272f, -0.14650230f, 0.08174974f, -0.03442140f, -0.07927416f, 
    -0.26712266f, 0.00005395f, 0.01404569f, -0.03138506f, -0.37812045f, -0.00992595f, -0.03934877f, -0.32582632f, 
    0.02009593f, 0.00556081f, -0.01014665f, -0.18873833f, 0.09307663f, -0.04590870f, 0.02018709f, -0.00104484f, 
    -0.43603039f, -0.04343369f, 0.03340412f, 0.13108931f, 0.02734827f, 0.03510052f, 0.08985609f, 0.01261462f, 
    -0.13132624f, -0.18007684f, -0.04825770f, -0.15181321f, -0.05830687f, 0.31685808f, 0.26148477f, -0.12853177f, 
    -0.08989885f, -0.09222224f, 0.08288812f, 0.11044183f, 0.06160377f, 0.17178731f, -0.18463686f, 0.00735006f, 
    0.24093308f, 0.07959412f, -0.09002268f, -0.24258806f, -0.00693722f, -0.11002606f, -0.05727059f, -0.02861298f, 
    0.13363582f, -0.00123604f, -0.04136547f, 0.00590009f, -0.24441835f, 0.18971644f, -0.21650739f, 0.57035398f, 
    -0.02551978f, 0.09600757f, -0.01062767f, 0.13154705f, 0.06131959f, 0.01712011f, -0.01256859f, -0.07882066f, 
    0.06342658f, 0.02344405f, -0.17279515f, 0.13298419f, -0.11768473f, -0.03416938f, -0.05152094f, -0.11817183f, 
    -0.17563242f, -0.01967301f, -0.01930002f, -0.00818927f, -0.61399764f, -0.03896758f, -0.15737709f, 0.12299740f, 
    0.05934381f, 0.07886331f, -0.03105464f, -0.17685401f, 0.00753778f, -0.06556351f, 0.09610768f, -0.13344392f, 
    0.49601835f, -0.43766093f, -0.02430789f, -0.05571917f, -0.09814835f, 0.03052823f, -0.02339385f, 0.08409187f, 
    0.00803734f, 0.01538844f, -0.20043820f, 0.00229084f, 0.29728356f, -0.29611319f, -0.04002649f, 0.00227873f, 
    0.04425747f, 0.09179362f, 0.20476933f, -0.10682163f, -0.03973888f, 0.02034226f, 0.19518359f, -0.13764547f, 
    0.01875391f, -0.24145605f, -0.05652863f, 0.39431068f, -0.16513075f, 0.04911182f, -0.02598417f, 0.07466945f, 
    0.17872974f, 0.07078099f, -0.01407972f, -0.00643210f, -0.60689318f, -0.34670594f, 0.10716771f, -0.01670622f, 
    0.18161407f, 0.01675566f, 0.11474036f, -0.02650245f, -0.03951688f, 0.00457131f, 0.13285758f, 0.25496930f, 
    0.25339276f, 0.07094660f, 0.22601235f, -0.13105376f, -0.12928602f, -0.06445202f, 0.22005740f, 0.05676763f, 
    0.00566376f, 0.00531796f, -0.01146001f, -0.18167345f, -0.00951533f, 0.00652633f, 0.06752613f, 0.01786410f, 
    -0.11941131f, -0.05835924f, 0.10113914f, -0.05773930f, 0.07120427f, -0.28693336f, 0.04068603f, -0.42962661f, 
    -0.07585493f, 0.37069768f, 0.17279445f, -0.19008611f, -0.00746027f, 0.18780984f, -0.10853188f, 0.22445577f, 
    -0.00653832f, 0.04410844f, 0.08664268f, 0.00471922f, 0.16374628f, 0.20973988f, -0.15590714f, -0.23401701f, 
    -0.10441266f, -0.03349176f, 0.09283777f, 0.11843772f, 0.13542791f, -0.08812449f, 0.27288303f, 0.14409205f, 
    0.02946593f, -0.01064677f, 0.05899264f, -0.16811515f, -0.11813395f, 0.16370341f, -0.06662778f, 0.04773724f, 
    0.00870453f, 0.06139523f, -0.24305174f, -0.21611671f, -0.28567004f, -0.07439940f, -0.12710796f, -0.19116883f, 
    0.04466465f, 0.09668598f, -0.00997657f, -0.01064031f, -0.01510936f, 0.04065562f, -0.18862669f, -0.03966441f, 
    -0.06519921f, -0.09663180f, -0.28061232f, 0.01477225f, -0.00240148f, 0.09923971f, -0.15433213f, -0.00091119f, 
    0.06283618f, -0.00152834f, -0.01596178f, -0.00664281f, 0.09030118f, -0.04866195f, -0.30216065f, 0.05708870f, 
    0.16651177f, 0.10985225f, -0.15411082f, -0.13495073f, 0.02702338f, 0.01667686f, -0.12202314f, -0.05506475f, 
    0.43995425f, -0.24203609f, 0.14768670f, -0.15669753f, 0.05444434f, 0.03176547f, 0.18521957f, 0.05415375f, 
    -0.00765617f, 0.05679627f, 0.18127762f, 0.02701006f, -0.26640305f, 0.04997642f, -0.00034313f, 0.15589392f, 
    -0.19173819f, -0.10275304f, 0.02205433f, 0.02488801f, -0.07843611f, 0.05666430f, 0.24457520f, 0.13991663f, 
    -0.06355499f, 0.24093081f, 0.09695197f, 0.09718906f, 0.00451058f, -0.21103166f, 0.03124702f, 0.11041878f, 
    0.07480972f, -0.00867448f, -0.04895339f, -0.05745416f, -0.37489721f, 0.18515004f, -0.10624126f, 0.02209899f, 
    -0.13135129f, -0.11568590f, 0.04673854f, -0.08628881f, -0.06296293f, -0.03949616f, -0.05461454f, -0.16344963f, 
    -0.33150515f, -0.01408696f, -0.10333754f, -0.31952000f, -0.11034189f, -0.04741610f, -0.12396146f, -0.03973619f, 
    -0.08548892f, 0.04839031f, -0.09576386f, -0.06168533f, 0.30161446f, 0.04930208f, 0.19599013f, 0.15633544f, 
    0.12287706f, -0.07028202f, 0.07141139f, -0.07563367f, -0.03509501f, 0.06225048f, 0.08047052f, -0.08970706f, 
    -0.11385152f, 0.20256186f, -0.18842639f, 0.02059391f, -0.16729394f, 0.03742173f, -0.07834163f, -0.19860213f, 
    -0.17227180f, 0.10074704f, -0.11384302f, -0.26857549f, -0.08728712f, 0.27507514f, 0.05496788f, 0.19842720f, 
    -0.00399025f, -0.06415553f, -0.01384564f, -0.05211508f, -0.10010190f, 0.05427753f, -0.01188704f, -0.10431508f, 
    -0.14987735f, -0.48824441f, -0.13685001f, -0.06505296f, -0.17193808f, -0.12069878f, -0.01476118f, -0.01226149f, 
    -0.00548665f, 0.05098241f, 0.00387602f, -0.05361676f, -0.18772416f, 0.04376923f, 0.11631837f, 0.15483235f, 
    0.16250645f, 0.00143364f, 0.07093436f, -0.00693018f, -0.16496602f, 0.01246615f, 0.08600311f, -0.10011815f, 
    0.11609752f, 0.15514417f, 0.15544826f, 0.25441241f, 0.07960188f, 0.02884416f, 0.14405155f, -0.00470041f, 
    -0.01227647f, -0.03182154f, 0.01906304f, -0.11173601f, 0.15909250f, 0.16400279f, 0.19786079f, 0.12699378f, 
    0.14639914f, 0.10994229f, -0.09820320f, -0.03252180f, -0.04776749f, -0.08758061f, -0.16523559f, -0.11194322f, 
    0.05081514f, 0.12902047f, 0.07061613f, 0.27910411f, -0.03529322f, -0.10279529f, 0.02644203f, -0.05846525f, 
    -0.10109492f, -0.04008519f, 0.03113489f, -0.02062620f, 0.25581399f, -0.05610089f, 0.25499755f, 0.16548131f, 
    0.02639577f, 0.02691629f, 0.03032796f, -0.01287616f, -0.07183300f, 0.02548110f, -0.08853784f, -0.08021808f, 
    0.20492838f, -0.46037436f, 0.28353131f, 0.16358377f, 0.17412227f, -0.03281287f, -0.15640555f, -0.00353789f, 
    -0.08034204f, -0.02684018f, -0.04346056f, 0.05720434f, -0.01680071f, -0.01304844f, 0.05494545f, -0.17399535f, 
    -0.00178418f, -0.05952490f, 0.03060047f, -0.04944839f, 0.02586890f, 0.05052207f, -0.06318103f, -0.06073937f, 
    -0.04475300f, -0.17611353f, -0.22393185f, -0.25898418f, 0.06947871f, -0.07189932f, -0.02214997f, -0.07900409f, 
    -0.02862507f, -0.03516772f, -0.20095448f, -0.08364837f, -0.11172245f, -0.01671243f, -0.36136687f, 0.07501030f, 
    -0.04350251f, 0.06842252f, -0.03949057f, 0.01327654f, -0.13769072f, 0.05041485f, 0.10062907f, -0.15143186f, 
    0.12435310f, -0.10544690f, 0.15635371f, 0.26602253f, -0.07968049f, -0.08337519f, -0.15533768f, -0.06777003f, 
    -0.01768352f, 0.02424398f, -0.08376714f, -0.06840676f, 0.33498725f, 0.10399581f, 0.10226537f, 0.11311370f, 
    0.11684827f, -0.11320002f, 0.12222921f, -0.09952802f, -0.08798897f, 0.14965065f, 0.09881141f, -0.17424075f, 
    -0.07214910f, -0.10966074f, -0.04437854f, -0.06465375f, -0.16036008f, -0.09939522f, 0.10640272f, -0.11262582f, 
    0.05923237f, -0.00318805f, -0.18499061f, -0.00538122f, 0.33496571f, -0.21379504f, 0.28999344f, 0.05377911f, 
    0.13133760f, 0.05402830f, 0.00753521f, -0.08449937f, -0.11559864f, -0.00863386f, -0.12378682f, -0.06884759f, 
    -0.08511839f, 0.30876705f, 0.00062142f, 0.11575295f, 0.16715088f, 0.11417565f, 0.14104570f, 0.08005167f, 
    -0.01675789f, -0.02292390f, 0.05368638f, 0.00454124f, -0.06853051f, -0.08712970f, 0.08778506f, -0.02992287f, 
    -0.02292524f, -0.07658358f, -0.03123283f, 0.06076990f, 0.00196579f, 0.01599945f, -0.03089001f, -0.03095227f, 
    0.34588683f, -0.31447724f, -0.04772070f, -0.18146679f, -0.14521162f, 0.01446556f, 0.03271008f, -0.04987382f, 
    -0.08543496f, 0.00832547f, -0.12889652f, -0.04636626f, -0.04447266f, -0.03554120f, 0.18217470f, -0.12860303f, 
    -0.06716201f, -0.02294345f, -0.03398701f, -0.09296259f, 0.07114735f, 0.03906689f, -0.08902428f, -0.00640915f, 
    -0.31990871f, -0.18606803f, -0.23493321f, -0.33238241f, 0.02287743f, -0.08158647f, 0.00238728f, -0.06613343f, 
    -0.12833472f, 0.04805495f, -0.00472099f, -0.04380024f, 0.07211025f, 0.14962521f, 0.23249288f, -0.04124018f, 
    -0.05205058f, 0.03933476f, -0.02351792f, -0.04807831f, -0.06632867f, 0.06454123f, -0.03048786f, 0.00883249f, 
    -0.21826281f, 0.13073336f, -0.08440430f, -0.06784847f, -0.09835839f, -0.00043587f, 0.00694192f, -0.05611236f, 
    -0.11503311f, 0.07344937f, -0.01873494f, -0.04871417f, -0.11096518f, 0.15691145f, 0.13635610f, 0.03661817f, 
    0.18382686f, 0.01266454f, 0.09294590f, -0.17173423f, 0.03577950f, 0.03009891f, 0.01405478f, -0.08809894f, 
    -0.12595682f, 0.03138187f, 0.02746749f, 0.11351109f, -0.21291393f, -0.08677500f, -0.17414697f, -0.05135639f, 
    -0.11821219f, 0.05713577f, -0.12713857f, -0.09798756f, 0.05209854f, -0.02446209f, -0.00490012f, 0.17300215f, 
    0.09318522f, -0.21529032f, -0.07280053f, -0.04069246f, 0.02625774f, -0.03720700f, -0.03860142f, -0.12884922f, 
    0.22479184f, -0.19546418f, 0.14695080f, -0.18537618f, 0.00751734f, 0.00802371f, -0.01434273f, -0.04868106f, 
    -0.08779108f, 0.16045676f, -0.12169705f, 0.02103076f, -0.14438783f, 0.08905558f, -0.23919117f, -0.13051434f, 
    -0.09656888f, 0.01213642f, 0.03856325f, -0.11023217f, -0.03541284f, 0.01009332f, 0.06293155f, 0.04939741f, 
    0.25172177f, 0.19194327f, -0.15582529f, 0.14449315f, -0.12417139f, -0.13373205f, 0.03147206f, 0.04415817f, 
    -0.12428041f, -0.19030963f, 0.00976875f, 0.09927177f, 0.19593479f, -0.17330706f, -0.20199998f, 0.04109933f, 
    0.11603863f, 0.00187873f, 0.04775809f, 0.01784646f, 0.00239475f, 0.07519689f, 0.06489346f, 0.10502051f, 
    0.25613615f, -0.01173744f, -0.10963837f, 0.17949387f, -0.11421924f, -0.16488801f, 0.02024441f, -0.17266072f, 
    -0.03055939f, -0.14374064f, -0.11151584f, -0.18477280f, 0.09955999f, -0.31721637f, 0.02127917f, -0.44674695f, 
    -0.06665230f, -0.21112819f, 0.10736396f, -0.09504525f, 0.01943104f, 0.19572143f, -0.03304492f, 0.04987975f, 
    0.23727749f, 0.02695023f, 0.15659299f, 0.02961062f, 0.06799090f, -0.05463713f, -0.03796417f, 0.01168601f, 
    0.07988784f, 0.02367449f, 0.04853036f, -0.13223386f, -0.11556380f, -0.32016930f, -0.10315620f, -0.21776830f, 
    0.19586392f, -0.14912148f, -0.22527911f, 0.01218494f, 0.10492511f, 0.05640587f, 0.06896852f, -0.35886857f, 
    -0.19606718f, -0.28921264f, -0.21286096f, 0.26314715f, 0.11332127f, -0.01412621f, -0.03749527f, -0.04792991f, 
    0.08881258f, 0.09819910f, 0.12325801f, 0.02253642f, -0.09826531f, -0.31336084f, 0.24525553f, 0.01840086f, 
    -0.04779730f, -0.12664513f, -0.04689381f, -0.06732272f, 0.07511794f, 0.09705985f, -0.00511380f, -0.22193061f, 
    0.02102338f, -0.02538466f, 0.17251666f, 0.11333358f, -0.19569899f, 0.17248181f, -0.08276147f, 0.00999978f, 
    -0.05866564f, -0.14273396f, 0.03964298f, -0.06048532f, -0.48138613f, 0.16285245f, 0.11270009f, -0.19117253f, 
    0.16660705f, -0.02334140f, -0.06867656f, -0.08033806f, 0.17268883f, -0.13754311f, 0.08953413f, 0.01049669f, 
    0.00544764f, 0.29286554f, -0.09010492f, -0.37295118f, 0.15478493f, -0.09383361f, 0.20904320f, 0.10299131f, 
    0.04519837f, 0.03924712f, -0.05400398f, 0.04161165f, -0.29810762f, 0.01883215f, 0.20345257f, 0.03902665f, 
    -0.17359184f, 0.03958113f, 0.07926102f, -0.13483545f, -0.00881606f, 0.13665564f, 0.13796487f, 0.07348314f, 
    0.14585477f, 0.19339000f, -0.05239946f, 0.22237334f, 0.01771737f, -0.18993279f, -0.19793868f, -0.23650517f, 
    -0.00371831f, 0.14701524f, -0.04521818f, 0.03913673f, 0.23340455f, -0.15476376f, -0.10218411f, 0.20148644f, 
    0.21474636f, -0.06259421f, -0.06310186f, -0.06725805f, 0.07235316f, -0.04048795f, 0.19905414f, -0.04322511f, 
    0.17947339f, -0.01591591f, -0.18048820f, 0.12972854f, 0.03438647f, 0.02609926f, -0.00840410f, -0.03685636f, 
    0.00711683f, -0.12841563f, 0.10579532f, 0.02614705f, -0.05948122f, 0.17381211f, -0.44175586f, -0.20803188f, 
    -0.00131643f, 0.02647511f, -0.35917988f, 0.01203666f, 0.07599640f, -0.03241681f, -0.15964517f, 0.02877774f, 
    -0.11229260f, -0.25118786f, -0.20240757f, -0.40355861f, -0.09208404f, 0.08274534f, -0.06029650f, 0.09973635f, 
    0.07701933f, -0.13202216f, 0.19559121f, -0.05796314f, 0.04835266f, 0.06156160f, -0.04655223f, 0.01168945f, 
    0.11324438f, 0.00624093f, -0.01088307f, 0.14289273f, -0.09309153f, -0.15801096f, -0.08233939f, 0.04721732f, 
    0.11425155f, 0.32470682f, -0.06572182f, 0.05460356f, 0.00724442f, -0.01411092f, -0.05890634f, -0.17595130f, 
    0.08061027f, -0.11372088f, 0.20812722f, 0.06711444f, 0.15664741f, -0.62980187f, -0.26287624f, -0.16125791f, 
    -0.00333869f, 0.10042203f, 0.02345764f, -0.14403521f, 0.08995245f, -0.01416845f, 0.21160665f, 0.11893722f, 
    -0.13101292f, -0.28928763f, -0.07646422f, -0.32296109f, 0.00845988f, 0.06978381f, -0.50373733f, -0.29829252f, 
    0.03168857f, 0.07573102f, 0.13367067f, -0.08032507f, 0.07734090f, 0.03022109f, 0.06746310f, 0.17870353f, 
    -0.30205211f, 0.04587717f, -0.09840551f, -0.05507116f, -0.03576598f, -0.10329939f, -0.13798338f, -0.13052528f, 
    0.13420653f, -0.26261777f, 0.06815093f, 0.06863158f, 0.02972229f, -0.16367744f, 0.01836339f, -0.04737065f, 
    -0.05921717f, 0.07581182f, 0.01486370f, 0.19515872f, -0.17877212f, 0.02470374f, 0.14778912f, -0.10105551f, 
    -0.16438019f, 0.01484552f, -0.03443607f, 0.10546234f, -0.00546352f, 0.16889776f, -0.07815623f, 0.09210800f, 
    -0.12029184f, -0.10176511f, -0.07706918f, 0.26681179f, 0.13856362f, 0.00108718f, -0.06937151f, -0.07653991f, 
    0.11973193f, 0.05034907f, -0.03820880f, -0.20554657f, -0.36249712f, 0.01273047f, -0.09538984f, -0.27423951f, 
    0.15827215f, 0.08254594f, -0.08347312f, -0.25902328f, 0.06166774f, 0.04562485f, -0.23928244f, 0.01952256f, 
    0.08699077f, -0.01083816f, 0.20177272f, 0.24181557f, 0.13589847f, -0.18118110f, 0.00927133f, -0.08705293f, 
    0.04807415f, -0.09894323f, 0.27677774f, -0.02163163f, -0.26228777f, -0.05810587f, 0.24537848f, 0.08701611f, 
    -0.10829414f, -0.08526736f, -0.07936577f, -0.28530028f, 0.02841358f, -0.24783173f, 0.24946077f, 0.20081475f, 
    -0.04025238f, 0.29292673f, -0.24791107f, -0.19282605f, -0.13213487f, 0.04598732f, 0.14325374f, -0.19902842f, 
    0.07008103f, 0.04728796f, -0.00752238f, 0.01342688f, -0.09781255f, -0.09492461f, -0.15346934f, -0.51341242f, 
    -0.02611551f, -0.07695616f, 0.02317329f, -0.10990442f, 0.11108790f, 0.05369864f, 0.13035420f, 0.06195008f, 
    -0.14166518f, 0.06911363f, 0.18704529f, -0.11059336f, -0.14130056f, 0.02408569f, -0.00071924f, -0.08581334f, 
    -0.00975142f, 0.02217828f, -0.10968152f, 0.08626035f, 0.31399924f, -0.10836562f, 0.00013776f, 0.13807534f, 
    0.12471100f, 0.17046010f, 0.05258261f, -0.04253921f, 0.06424465f, -0.02781943f, 0.14286816f, -0.08164147f, 
    -0.27719212f, -0.15591040f, 0.20109765f, -0.06288218f, 0.04962478f, 0.07997088f, -0.13871010f, 0.11451441f, 
    0.16444066f, 0.15378989f, 0.15143672f, -0.01847744f, -0.40864649f, 0.11472260f, -0.01127539f, -0.15144292f, 
    -0.04031267f, -0.08119779f, 0.10657390f, -0.03189745f, -0.13447259f, 0.02435099f, 0.06621896f, -0.01129897f, 
    0.19394785f, -0.10508825f, -0.08382143f, -0.10012417f, 0.09096909f, -0.03653777f, 0.05623292f, -0.03081931f, 
    -0.13921082f, 0.08888166f, 0.04793855f, 0.24202646f, 0.40160340f, 0.18201083f, -0.01108938f, 0.24186352f, 
    0.14786810f, -0.00700947f, 0.07644760f, -0.04271408f, -0.13535161f, 0.09886780f, 0.05217611f, 0.10797453f, 
    -0.79590446f, 0.62664020f, -0.35069060f, 0.08182330f, 0.15228380f, -0.01212323f, -0.01598560f, -0.04066579f, 
    0.00714943f, -0.02668040f, 0.03637328f, 0.04927762f, -0.19448277f, -0.23168796f, -0.19609644f, -0.23687975f, 
    0.02768828f, 0.00024663f, -0.19475032f, 0.12279316f, 0.00899598f, -0.06777566f, 0.04191226f, -0.00592993f, 
    -0.06837686f, 0.06896181f, -0.28475586f, -0.49298689f, 0.02246806f, -0.01852571f, -0.03212943f, 0.18290089f, 
    0.02691387f, -0.12796526f, -0.06317127f, -0.07487704f, -0.40510634f, -0.14508212f, 0.02743831f, 0.35534400f, 
    0.00636826f, -0.23007539f, 0.07491347f, 0.02673838f, 0.00528326f, -0.08258712f, -0.03460309f, 0.03209528f, 
    -0.20206425f, -0.00904659f, 0.14732131f, -0.02783134f, 0.09805811f, 0.11507285f, -0.06344748f, 0.08956221f, 
    -0.04333380f, -0.09026740f, 0.08156235f, -0.04160413f, -0.18146515f, -0.26718047f, -0.13729566f, 0.04583531f, 
    0.02071021f, -0.06951447f, -0.02878319f, -0.10145244f, -0.15373223f, -0.04712188f, -0.25147349f, -0.03174200f, 
    0.39379394f, -0.03435442f, 0.10130147f, -0.08076673f, -0.08862904f, -0.01718096f, 0.01233992f, 0.05354149f, 
    0.04109169f, 0.11702331f, 0.11310484f, 0.18077768f, 0.09792604f, -0.29490575f, -0.15922998f, 0.09960970f, 
    -0.03044660f, -0.12752210f, -0.12708507f, -0.06589866f, -0.03131450f, 0.10061646f, -0.12311488f, -0.02816191f, 
    0.72694999f, -0.79343992f, -0.03192705f, 0.01688552f, -0.10833163f, 0.01477447f, 0.16848958f, 0.10690575f, 
    -0.03144499f, 0.07049736f, 0.13402578f, -0.18426092f, -0.19134445f, -0.09655239f, 0.08908537f, 0.00917116f, 
    0.07064172f, 0.06743159f, 0.02815334f, -0.14465995f, -0.01719177f, -0.06187733f, -0.09176803f, -0.12422174f, 
    -0.20888977f, 0.27468503f, -0.12138744f, -0.36269173f, -0.01559727f, 0.23649263f, 0.14208055f, -0.10480762f, 
    -0.15932849f, 0.13012025f, 0.01422823f, 0.02778742f, 0.38814610f, 0.16544908f, 0.37619951f, 0.06421109f, 
    0.03306991f, 0.09754699f, -0.06639212f, -0.08642662f, -0.06809431f, 0.04241427f, -0.14310735f, 0.05680262f, 
    -0.00584755f, -0.07873029f, -0.18271971f, 0.02889108f, -0.05865662f, -0.07227495f, 0.07122531f, 0.25168392f, 
    0.05856399f, 0.21119450f, -0.12291043f, 0.04869248f, 0.20238660f, 0.03186228f, 0.03064175f, -0.10225002f, 
    -0.00700885f, -0.12421729f, 0.23065706f, -0.01434361f, -0.28439647f, 0.05160232f, -0.02871968f, -0.00796439f, 
    0.36082810f, 0.05876449f, -0.44225463f, 0.04811768f, 0.14191853f, 0.06808840f, 0.19211614f, 0.02103663f, 
    -0.19339590f, 0.01970909f, 0.09797189f, 0.19923796f, -0.04786709f, -0.24451745f, 0.17620412f, -0.19114625f, 
    0.04492317f, -0.07070362f, -0.08833577f, 0.12401311f, -0.01025367f, 0.04345151f, -0.11713034f, 0.19610059f, 
    -0.52515078f, -0.08039553f, 0.09003194f, 0.24144731f, -0.17379622f, -0.04143026f, 0.20308793f, 0.04230610f, 
    -0.26813367f, 0.04564638f, 0.09645145f, -0.07845628f, 0.24491376f, -0.32949117f, 0.09481246f, 0.01977960f, 
    0.04552780f, 0.00643948f, -0.05847052f, 0.14076199f, -0.14547537f, 0.17167743f, -0.07554828f, 0.06017002f, 
    0.15834437f, 0.14141323f, 0.02729017f, -0.11340911f, 0.09658445f, -0.14434987f, 0.08205598f, 0.03436663f, 
    0.13207750f, -0.04182022f, 0.13665210f, -0.11492669f, -0.18721847f, -0.13853747f, -0.28528795f, 0.09688476f, 
    0.06491137f, -0.01215095f, 0.03710284f, -0.12020657f, 0.05871438f, 0.15486032f, -0.10337821f, -0.08324844f, 
    -0.16632707f, 0.00680600f, -0.09895709f, -0.34143943f, 0.00691602f, 0.06589228f, 0.00844296f, -0.11107490f, 
    -0.05851095f, -0.06759407f, -0.03537137f, 0.11204313f, -0.14866751f, -0.25138411f, -0.13166282f, 0.10770390f, 
    0.00880764f, 0.00899598f, -0.18239832f, 0.08565529f, -0.08658845f, 0.13067231f, 0.18292946f, 0.08093517f, 
    0.06314972f, 0.20143920f, -0.23120449f, -0.02550304f, 0.20947929f, -0.16977429f, -0.04047441f, -0.07061267f, 
    -0.06114831f, -0.13583638f, -0.23474197f, -0.06398530f, 0.00441625f, -0.55904520f, -0.03230068f, 0.24448213f, 
    0.00200860f, -0.07795390f, -0.10390920f, 0.20734422f, -0.23574354f, 0.12947102f, -0.02148119f, -0.06741995f, 
    -0.29648164f, 0.21481419f, -0.01877701f, 0.20491682f, 0.06169050f, 0.13356449f, -0.15158463f, 0.05971792f, 
    -0.03318213f, 0.12740366f, 0.00317275f, 0.05171053f, -0.09867743f, 0.14047429f, -0.03736809f, -0.30075037f, 
    0.04371234f, 0.12122609f, 0.04306525f, 0.09902688f, -0.21588120f, 0.09930023f, -0.01868270f, -0.12422923f, 
    -0.05599569f, -0.13288219f, -0.09551906f, 0.13717076f, 0.03900535f, -0.07534448f, -0.06589390f, -0.07033298f, 
    0.08498952f, 0.01786293f, -0.01979769f, -0.07311773f, -0.00418810f, 0.43193680f, -0.03590581f, -0.54125208f, 
    0.18738590f, 0.09232985f, -0.03772784f, -0.18504140f, -0.06982073f, -0.02582389f, 0.18282706f, -0.02322210f, 
    0.00475630f, 0.23931111f, -0.25625736f, -0.07501244f, -0.23615202f, -0.12770979f, 0.06727039f, -0.00760651f, 
    -0.04984256f, -0.19364454f, 0.10128735f, -0.20460179f, -0.80773360f, -0.33257827f, 0.20228851f, -0.01290452f, 
    0.14191857f, -0.10928297f, 0.03687389f, 0.08732711f, 0.24318787f, 0.19290845f, 0.12592185f, 0.06564107f, 
    0.30812442f, -0.00278239f, 0.02747400f, 0.11120284f, -0.01216849f, -0.08018997f, -0.07341521f, 0.13698493f, 
    0.12885354f, 0.05188631f, 0.05448275f, 0.03967201f, -0.15142776f, -0.16459101f, -0.07028384f, 0.10789653f, 
    -0.03601678f, 0.09894481f, 0.08216784f, 0.03654813f, 0.08215760f, 0.13301264f, -0.06210886f, 0.02011731f, 
    -0.45231339f, -0.63736892f, -0.08467270f, 0.03531775f, 0.01046000f, -0.06803701f, 0.09630601f, 0.01708239f, 
    0.03622660f, 0.08237933f, 0.06808637f, 0.06051273f, -0.31743312f, 0.17074510f, -0.17993449f, -0.17901243f, 
    0.17572437f, -0.09139974f, -0.10634154f, 0.06580092f, 0.10483796f, 0.06789655f, -0.00919692f, -0.13160166f, 
    -0.31276911f, 0.01379982f, -0.11457321f, -0.23317917f, -0.01449311f, -0.03209262f, 0.00536489f, 0.00464441f, 
    0.08477970f, 0.19435214f, 0.11920758f, 0.22129564f, 0.31585437f, -0.08117583f, -0.05145775f, -0.02528428f, 
    -0.13566631f, -0.04905127f, 0.06315062f, -0.09208460f, 0.02407013f, 0.18383861f, 0.08763427f, 0.09622075f, 
    0.37093693f, 0.10943709f, -0.10139681f, -0.14911743f, -0.16546711f, -0.04778760f, -0.03200081f, -0.01250513f, 
    0.08539291f, 0.01197070f, -0.08473942f, -0.04811494f, 0.14228779f, 0.12299015f, -0.08701613f, -0.21671477f, 
    -0.01848840f, 0.12977986f, 0.04321859f, -0.09399757f, -0.08786113f, -0.08297725f, 0.14641225f, -0.08410733f, 
    -0.08165126f, 0.15506355f, 0.14164995f, 0.09886456f, 0.07338744f, 0.09542768f, 0.02574727f, 0.06603208f, 
    0.01477709f, 0.01521157f, -0.08065450f, 0.00784880f, 0.22720994f, -0.06034009f, 0.01417260f, -0.12247529f, 
    -0.11434999f, 0.15841794f, -0.08208343f, -0.01213046f, 0.02980754f, 0.15956174f, -0.00005711f, 0.09332088f, 
    -0.36204836f, 0.14036116f, -0.14952910f, 0.01829322f, 0.14345455f, -0.01594563f, -0.17314039f, -0.05781845f, 
    0.01466530f, 0.06530128f, -0.06350826f, 0.05619933f, -0.79936755f, -0.17409639f, -0.22382037f, -0.01874930f, 
    0.07621125f, -0.04524577f, -0.12033244f, -0.09527228f, -0.00964496f, 0.10172142f, 0.04621371f, 0.13333040f, 
    -0.02193694f, 0.01032679f, -0.01683513f, 0.11306462f, 0.09044256f, 0.05934352f, -0.05130095f, 0.03123953f, 
    0.06176501f, 0.02049812f, 0.16213319f, 0.06649008f, -0.77486211f, -0.21430275f, 0.17117403f, 0.26901072f, 
    0.05578505f, 0.13714871f, 0.05424238f, -0.11050715f, 0.01794353f, -0.20142093f, -0.19120644f, -0.04978460f, 
    0.35151052f, 0.16159675f, 0.10426505f, 0.03951545f, 0.02567769f, 0.20034602f, 0.06534791f, 0.00120782f, 
    -0.02118559f, 0.03650554f, 0.09026114f, 0.10235418f, -0.11296703f, 0.38999429f, -0.03006327f, -0.10017742f, 
    0.10149632f, 0.17147326f, 0.07474853f, -0.02914598f, 0.15249784f, -0.07318136f, -0.04838910f, -0.07865962f, 
    -0.15482834f, -0.22868301f, -0.05382681f, -0.10061093f, -0.20861247f, 0.03795644f, -0.08999072f, -0.08449237f, 
    0.06117143f, -0.01477448f, 0.03405273f, -0.22117127f, -0.17327966f, 0.04213500f, -0.05170258f, -0.02452143f, 
    0.03763686f, 0.02803420f, -0.03316478f, 0.00304653f, 0.07041447f, 0.01021870f, -0.03355601f, -0.09468188f, 
    -0.06464846f, -0.21491379f, -0.15717822f, 0.08378451f, -0.05221608f, 0.13947834f, -0.15777953f, 0.09431967f, 
    0.00256940f, 0.10162508f, -0.32122666f, -0.20623432f, 0.28017613f, -0.14141352f, 0.00226135f, 0.00614623f, 
    -0.09594923f, -0.11363979f, -0.00780880f, 0.03291710f, 0.02175609f, -0.11623649f, -0.08789205f, -0.03432883f, 
    -0.39551985f, 0.10057455f, -0.10671709f, -0.05572930f, -0.03612917f, -0.11028051f, -0.12685913f, 0.01865624f, 
    0.03320915f, 0.04587821f, 0.11557733f, 0.09321016f, 0.33823755f, 0.15989964f, -0.06565199f, 0.09367581f, 
    0.03792027f, 0.03161298f, 0.08261495f, 0.16235745f, 0.04312997f, 0.07849772f, -0.00944960f, 0.25126514f, 
    -0.49031621f, -0.02100314f, -0.11131051f, -0.25476632f, 0.12619968f, -0.06649596f, -0.01739572f, -0.04619233f, 
    0.06220853f, -0.03364302f, 0.02652083f, -0.05499974f, 0.30251622f, -0.01711387f, -0.03353136f, 0.10671841f, 
    -0.04363297f, -0.13646589f, -0.01043158f, -0.13207801f, -0.08268894f, -0.20463546f, -0.41514942f, -0.13455731f, 
    -0.62785012f, -0.14703026f, -0.17633900f, -0.35201988f, -0.09926210f, -0.01654072f, -0.04198446f, 0.05153045f, 
    -0.07014162f, 0.08343185f, 0.27547550f, -0.02275505f, 0.17804974f, 0.11766659f, 0.08487858f, 0.01609734f, 
    0.09685730f, 0.06428885f, 0.09020694f, -0.00702852f, -0.03061295f, 0.00720509f, 0.14143451f, 0.05816565f, 
    0.11061540f, 0.03777047f, -0.16777664f, 0.04242721f, -0.08569370f, 0.10166692f, -0.10968032f, -0.14679453f, 
    0.14914924f, 0.04824849f, -0.10115673f, -0.02231863f, 0.18982445f, 0.24172662f, -0.11767116f, 0.04625186f, 
    -0.06836727f, -0.05565385f, -0.05936874f, 0.14951414f, -0.13544329f, 0.00378841f, 0.26336181f, 0.08381860f, 
    0.12920181f, -0.05607226f, -0.20048039f, 0.09617091f, 0.09483178f, -0.00426387f, -0.00037553f, 0.12013672f, 
    -0.00787986f, -0.01977800f, 0.06087154f, 0.00231213f, -0.58466369f, -0.29914549f, -0.06085231f, -0.33145869f, 
    0.15206127f, 0.15329435f, 0.10075619f, -0.03995219f, 0.14966446f, -0.02015304f, -0.03701478f, 0.02750435f, 
    -0.11175746f, -0.33751580f, -0.19609088f, -0.00624019f, 0.00255436f, 0.07700916f, 0.04288832f, -0.09013838f, 
    -0.02607388f, -0.08639834f, -0.15057920f, -0.10674870f, 0.52405787f, 0.12315428f, -0.15283008f, -0.01155655f, 
    0.18313023f, 0.01896426f, -0.07304288f, -0.12518822f, -0.14259374f, -0.03729661f, -0.02978348f, 0.00005797f, 
    0.01277713f, -0.25685552f, -0.04512425f, -0.01634631f, 0.12102913f, -0.01126852f, 0.02589985f, 0.05208996f, 
    0.03560105f, -0.06580009f, -0.16121452f, 0.26195961f, -0.62796384f, 0.05987483f, 0.30169526f, -0.18440843f, 
    -0.16144979f, -0.06406687f, -0.05865575f, -0.00726031f, -0.00393787f, 0.05927338f, 0.01443256f, -0.16184269f, 
    -0.43562263f, 0.01948928f, -0.14918287f, 0.02795169f, 0.24955571f, 0.04288143f, 0.09794113f, 0.11851154f, 
    0.13094413f, 0.00034947f, -0.04614346f, -0.00627733f, -0.28465086f, -0.10705926f, 0.10411582f, 0.38908577f, 
    -0.01798250f, 0.07220263f, 0.01791593f, 0.05303364f, 0.12787782f, -0.21262696f, 0.01919177f, 0.16653588f, 
    0.34306756f, 0.02096840f, -0.24167763f, 0.19894139f, 0.10514534f, 0.01224024f, -0.02686552f, -0.07464829f, 
    0.04843600f, -0.03066304f, 0.02251622f, -0.07602921f, 0.09761453f, -0.12232126f, 0.01790217f, -0.05006785f, 
    0.02364641f, -0.01035300f, -0.02291032f, -0.03074653f, -0.10607466f, -0.03186226f, 0.19355762f, 0.06889899f, 
    -0.08039219f, -0.05020801f, -0.08217912f, 0.08245368f, -0.09704080f, 0.12559995f, -0.00949296f, -0.08160386f, 
    -0.11169189f, -0.08760461f, -0.03046243f, -0.17310993f, -0.11744830f, 0.18894923f, -0.24789160f, -0.02404614f, 
    -0.07570443f, -0.06926811f, -0.08381909f, -0.22102877f, 0.04939577f, 0.03982548f, -0.06552081f, -0.07785182f, 
    0.11450344f, -0.28150976f, 0.01821551f, 0.03939280f, -0.16330525f, 0.07647505f, -0.18142702f, -0.14016058f, 
    0.00607533f, 0.17266139f, 0.22605114f, -0.25374451f, -0.25353634f, 0.20434502f, -0.00952244f, 0.13150175f, 
    0.11081418f, -0.05521429f, -0.01430175f, -0.01228030f, 0.06913432f, -0.09111382f, -0.02388561f, 0.11445589f, 
    -0.48425195f, 0.19611791f, -0.15361094f, 0.03308263f, 0.00506340f, 0.00599765f, -0.04401739f, 0.17779581f, 
    -0.08975010f, -0.02518850f, 0.05768616f, -0.08321280f, 0.39405671f, -0.00259874f, -0.13940886f, -0.20900133f, 
    0.06084406f, -0.07995432f, -0.02834142f, 0.08614338f, -0.01416191f, 0.01143503f, -0.14530724f, 0.01450767f, 
    0.38609213f, 0.03796636f, -0.19612625f, -0.07491007f, 0.17810856f, -0.13262327f, 0.07134113f, 0.02621300f, 
    0.08024658f, -0.10420522f, 0.00877208f, 0.17896375f, 0.53120703f, 0.14060825f, -0.15634084f, 0.07625265f, 
    -0.03258834f, -0.12474611f, -0.10771246f, 0.00025411f, 0.15876918f, 0.19018558f, 0.08463269f, 0.16235469f, 
    -0.30695930f, 0.10432068f, -0.14680246f, 0.01541451f, 0.08933207f, -0.02126218f, -0.02427373f, 0.01720016f, 
    0.12772903f, -0.15040688f, 0.04606564f, -0.15817894f, -0.11116305f, 0.45197088f, -0.05093173f, -0.18722011f, 
    -0.05016864f, 0.06239459f, -0.13205568f, -0.13752584f, -0.03743917f, 0.10484063f, -0.01080474f, -0.00450862f, 
    -0.71782368f, -0.68121231f, 0.05119878f, -0.23239230f, 0.03613050f, -0.07119291f, -0.00675430f, -0.07212518f, 
    0.02617197f, 0.11385346f, -0.12472612f, 0.19818303f, 0.35107037f, 0.31932357f, 0.02441767f, 0.19309735f, 
    -0.18257819f, 0.00285519f, -0.16665380f, -0.01278585f, 0.09366667f, 0.04310552f, 0.04101469f, -0.05615794f, 
    0.08818783f, -0.11495201f, 0.04862941f, 0.18925121f, 0.01589372f, 0.07734353f, -0.09422124f, -0.00043986f, 
    -0.05091741f, 0.01289451f, 0.00512160f, 0.11411594f, -0.27234006f, -0.06792572f, -0.08113363f, 0.06330074f, 
    -0.05757632f, -0.14561678f, 0.02538507f, 0.10846632f, 0.06020030f, 0.03365215f, 0.12177078f, -0.05148650f, 
    -0.23265950f, 0.37358367f, 0.06437825f, -0.20665811f, -0.04115434f, 0.09000966f, -0.13093342f, 0.10803904f, 
    -0.09629276f, 0.07093198f, 0.03446696f, 0.00448998f, -0.12021266f, 0.24055189f, -0.01330886f, -0.01170260f, 
    0.13731936f, -0.12056649f, 0.08230571f, -0.02334704f, 0.06405006f, -0.18388082f, -0.18342350f, -0.03211067f, 
    0.51385325f, -0.10773671f, -0.21111719f, -0.41196907f, 0.02683961f, -0.18415332f, 0.08215691f, 0.04844816f, 
    0.05224762f, 0.18017308f, 0.15472464f, -0.01875061f, 0.01533552f, 0.11126119f, -0.26109624f, 0.03613458f, 
    0.16807672f, -0.06917159f, -0.00050012f, -0.10045291f, 0.06380440f, 0.06632804f, 0.11012337f, -0.01175397f, 
    -0.11493190f, -0.18125603f, 0.16541344f, -0.28973100f, -0.05749113f, 0.10081892f, -0.10146610f, 0.11249941f, 
    0.06225207f, -0.14501223f, -0.00512855f, -0.14783458f, 0.34979916f, 0.13054040f, 0.04450956f, 0.04642226f, 
    -0.13635148f, -0.04635710f, 0.06800275f, -0.10557687f, -0.16530293f, 0.15179516f, -0.08582804f, -0.12091631f, 
    0.17819324f, -0.33244610f, -0.27492481f, 0.11588288f, 0.20073102f, -0.13416639f, -0.01151591f, 0.03479671f, 
    -0.08331174f, 0.09833805f, -0.13320784f, 0.10248272f, 0.03818958f, -0.08952085f, -0.08695399f, 0.22568008f, 
    -0.28334528f, 0.16742730f, 0.06438657f, 0.03149060f, 0.00834386f, -0.16336462f, -0.21948528f, -0.03037424f, 
    -0.23158933f, 0.24076547f, 0.03752201f, -0.06899156f, 0.18095928f, -0.05583451f, 0.13569321f, -0.03720863f, 
    0.03510282f, -0.11491371f, 0.13964632f, -0.09462532f, 0.28416008f, -0.48144558f, -0.32678837f, 0.02600130f, 
    0.03171463f, -0.01435662f, -0.02032460f, 0.04322504f, -0.00822308f, -0.00405571f, -0.09163531f, -0.07041426f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05406293f, 0.01347177f, -0.05890977f, 0.00015337f, 0.02287197f, 0.03413537f, -0.02785697f, -0.13101606f, 
    -0.01007739f, -0.01298981f, 0.11072471f, 0.05904970f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
