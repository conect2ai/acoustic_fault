#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.30555788f, -0.55958098f, 0.04282447f, -0.67761564f, 1.12418258f, -1.28149664f, -0.17419395f, 0.37642375f, 
    -0.62980342f, -1.15510619f, 0.90489525f, 0.13061897f, 0.08514810f, -0.24687672f, -0.68082285f, 0.02301139f, 
    -0.22247361f, -0.73042929f, -1.90833890f, 0.21207605f, -0.48859224f, 0.55649418f, -0.02266267f, 0.02953975f, 
    0.23818946f, 0.16311213f, 0.38042909f, 0.46867380f, 0.52581728f, 0.89194560f, -1.11702204f, -1.09176445f, 
    -0.66820711f, 0.03251102f, 0.21751405f, -0.11710972f, -1.11320090f, -0.28652519f, -1.13479352f, -0.39105347f, 
    0.96142936f, 1.00764692f, -0.01952398f, -0.18963765f, -0.02711446f, 0.83137137f, 1.07258868f, 1.22186637f, 
    -0.47925338f, 0.65648919f, 0.44804224f, 0.17489785f, -0.16427897f, -0.20789094f, -0.64067817f, 0.21814343f, 
    -0.72859728f, -0.51736772f, 0.35880053f, -1.27275646f, -0.06386510f, 0.41246989f, 0.69181496f, -0.44326308f, 
    -0.77708006f, -1.00897324f, -0.32383007f, -0.94316518f, -0.65077949f, -0.14611514f, -0.46365601f, -0.20962849f, 
    -1.16451013f, -0.92155915f, -0.60363066f, 0.05320592f, -0.60599065f, 0.59596223f, -0.22828017f, 0.10175259f, 
    0.04033711f, -0.86693591f, -0.46643043f, 0.12176087f, 1.01596189f, 1.49725580f, -0.09502616f, -0.11721423f, 
    -0.04884709f, -0.28078744f, 1.16826975f, 0.41440096f, 0.94922632f, 0.88459599f, 0.18413022f, -0.09655069f, 
    0.28589144f, 0.56511885f, 0.02390645f, 0.59795517f, -1.09648645f, 0.63685954f, 0.75328046f, -1.24552798f, 
    0.55787939f, -0.08730836f, -0.13400997f, -0.31339166f, 1.18566227f, 0.21986136f, -0.34364167f, -0.96038395f, 
    0.54063416f, -0.59034199f, 0.66009003f, 0.23655827f, 0.09299837f, -0.55125844f, -1.11330295f, -1.35997188f, 
    0.61048084f, -0.16646545f, -0.33549538f, 0.20457672f, 0.58509123f, 0.19794242f, 0.04387917f, -0.95551348f, 
    -0.03506314f, -1.05264735f, -1.04106116f, 0.41648963f, 0.33383498f, 0.47143635f, 0.15166391f, -0.14945941f, 
    -1.20042288f, 0.63705444f, 0.63206446f, 0.01663680f, 0.87492985f, 0.42475796f, -0.05701225f, 0.67715400f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.44624174f, 0.37378711f, 0.45878142f, 0.66137940f, 0.34533897f, 0.68348461f, -0.11487506f, -0.00775812f, 
    -0.20862237f, -0.00633994f, 0.45940182f, 0.17939208f, -0.27961320f, -0.16375270f, 0.24628977f, 0.29392254f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.89868063f, -0.27950448f, 0.13915138f, 0.17999327f, 0.08838110f, 0.08162671f, 0.26135060f, -0.04713322f, 
    0.01427080f, -0.45978284f, -0.18611801f, -0.18559313f, -0.23862046f, -0.20477574f, -0.08014409f, 0.03459074f, 
    0.00473006f, 0.07920799f, -0.14779235f, -0.45170963f, 0.02752514f, -0.01308537f, 0.12455534f, -0.08729785f, 
    0.14601415f, -0.01032618f, 0.02721661f, 0.28366575f, 0.28976780f, 0.33282706f, 0.01219670f, 0.06226982f, 
    -0.18560888f, 0.09878494f, 0.08638727f, 0.11028855f, 0.44325054f, -0.54954273f, -0.17658302f, -0.05971812f, 
    0.03512339f, -0.03450813f, -0.26909620f, 0.01845936f, 0.01652038f, 0.22104727f, -0.43995714f, 0.31442824f, 
    0.02225185f, 0.10665360f, 0.10462955f, -0.14303418f, -0.06115986f, -0.06092367f, -0.21086290f, -0.32817093f, 
    -0.38000962f, 0.17975892f, -0.09636804f, 0.06926222f, -0.28370705f, 0.05517298f, 0.04763540f, 0.01920582f, 
    0.03544488f, 0.16069546f, 0.05850187f, 0.16201551f, -0.04327230f, 0.04327379f, 0.12404789f, 0.23723727f, 
    0.25493261f, -0.31906870f, -0.17034538f, -0.15827303f, 0.03673655f, 0.09819231f, -0.21796094f, -0.12894729f, 
    0.00780921f, -0.05974734f, -0.05313821f, -0.04457386f, 0.07445857f, -0.06278448f, -0.06855413f, 0.00193232f, 
    0.00237897f, 0.21134825f, 0.13165087f, 0.13773687f, -0.69299036f, -0.01392778f, 0.06884771f, 0.00593412f, 
    0.06818387f, 0.01412162f, 0.12190779f, 0.73277831f, 0.01757847f, -0.22318788f, 0.14320689f, -0.01751141f, 
    0.14957385f, 0.02914513f, -0.01615100f, 0.19013752f, -0.23763959f, 0.04125773f, -0.07458510f, 0.02026662f, 
    -0.04985431f, 0.07793425f, -0.10231829f, 0.02923769f, -0.17062114f, 0.08443071f, -0.40356126f, 0.11793927f, 
    0.08281429f, 0.07992489f, 0.03790333f, 0.15126474f, -0.17145568f, -0.14676970f, -0.15706344f, -0.01886938f, 
    -0.15203626f, -0.02938375f, -0.01939987f, -0.05020355f, 0.07847710f, 0.12823723f, -0.03309966f, 0.92229247f, 
    0.30757749f, 0.08045248f, 0.16466783f, 0.08690955f, -0.09815549f, -0.01704590f, 0.11326990f, -0.07405563f, 
    -0.01583463f, 0.03994274f, 0.04446418f, 0.04710840f, 0.04961019f, 0.00353264f, 0.03336328f, -0.06411393f, 
    -0.02809801f, -0.07899071f, -0.04301941f, -0.07756574f, 0.05217803f, 0.05844522f, -0.03897513f, -0.07283192f, 
    0.00467453f, -0.02342617f, 0.01205989f, 0.00779718f, -0.03980757f, 0.06655928f, -0.02515975f, -0.06497356f, 
    -0.07030505f, -0.06767163f, 0.02554483f, -0.04129178f, -0.02822932f, -0.00043344f, 0.00680549f, -0.02831509f, 
    0.02834923f, 0.03196900f, -0.03884468f, 0.02986429f, -0.04932198f, -0.05941941f, 0.01790600f, 0.01567540f, 
    -0.02226736f, 0.02239050f, -0.00822305f, 0.05623284f, 0.03297232f, 0.02557894f, -0.05301854f, 0.04877668f, 
    -0.01786554f, -0.09013958f, 0.03053997f, 0.00679247f, 0.00744396f, -0.02711146f, -0.05784883f, 0.04819642f, 
    0.04963512f, -0.03417868f, -0.00875724f, -0.04518763f, 0.06247177f, -0.05640860f, -0.01489716f, 0.05650589f, 
    -0.04135533f, 0.00753420f, -0.04016443f, -0.08303015f, 0.00270857f, -0.03957157f, -0.06487474f, -0.04292754f, 
    0.02508475f, 0.06589518f, -0.04980756f, -0.04282665f, 0.01859662f, 0.05700524f, 0.05062188f, 0.05560784f, 
    -0.02040214f, 0.00227631f, 0.04851298f, 0.00887064f, 0.00908922f, 0.04494695f, 0.04302684f, -0.04471502f, 
    0.02930403f, 0.03916821f, -0.08290786f, 0.00726781f, -0.05434532f, -0.09494750f, -0.06067445f, -0.03868312f, 
    0.01266088f, -0.01651769f, -0.02725960f, 0.00804984f, -0.02466254f, 0.02095401f, -0.09330587f, 0.01765927f, 
    0.00272659f, -0.05749186f, -0.06898174f, 0.04886160f, 0.00774592f, 0.03473765f, -0.08434226f, 0.00718203f, 
    0.03510006f, -0.08531621f, 0.06363130f, 0.03945107f, 0.04598840f, -0.00658646f, -0.03058922f, -0.09405513f, 
    -0.09399730f, 0.03326983f, -0.05658046f, 0.03743228f, -0.05180454f, 0.03247418f, 0.03387327f, -0.04728419f, 
    -0.00822197f, -0.09393738f, 0.02721692f, -0.09830943f, 0.02567142f, -0.00399784f, -0.03322382f, 0.01840039f, 
    -0.06514889f, -0.08168866f, 0.04505653f, 0.04127122f, -0.06643473f, 0.04590575f, -0.06349179f, 0.05194093f, 
    -0.09206909f, -0.17892109f, -0.35987976f, 0.18159494f, 0.27123085f, -0.07841418f, -0.06724062f, -0.12071568f, 
    -0.04431877f, -0.30509821f, 0.00568966f, 0.08691267f, 0.12876377f, 0.14947057f, -0.00904668f, 0.09374227f, 
    -0.05594930f, -0.24114774f, -0.43466914f, -0.26198226f, 0.40821642f, 0.10507654f, 0.19749875f, 0.01447466f, 
    -0.05173055f, 0.02176838f, 0.26950073f, -0.12032386f, -0.00313098f, -0.08320532f, 0.19983029f, 0.03539966f, 
    -0.04791313f, -0.01277186f, -0.01752571f, -0.02172643f, -0.57805306f, -0.17115831f, 0.34793794f, 0.10430487f, 
    0.06620867f, 0.08368837f, -0.11003891f, 0.01151026f, -0.12701492f, 0.20797470f, 0.25391078f, 0.37576264f, 
    0.06309375f, -0.00746696f, -0.05472015f, -0.03613629f, 0.13557687f, 0.12665085f, 0.08721997f, -0.00105344f, 
    -0.04338396f, 0.08983704f, 0.04146533f, 0.23224220f, 0.11804169f, -0.24370521f, 0.03310873f, 0.07434854f, 
    -0.19493008f, -0.17025931f, 0.09349277f, 0.03326785f, -0.06503265f, -0.13844568f, 0.07250626f, 0.09806589f, 
    -0.52216476f, -0.23035657f, 0.02224047f, 0.01724963f, 0.02870564f, 0.01920162f, -0.08842359f, -0.22441928f, 
    -0.06282808f, -0.52118862f, -0.47261691f, -0.09816379f, -0.04090655f, -0.16355325f, -0.04196443f, 0.05640941f, 
    0.04173998f, -0.15579227f, 0.53376615f, 0.35334206f, 0.08665407f, 0.07791156f, 0.07889043f, 0.00961953f, 
    0.09351982f, 0.06983362f, -0.14808267f, -0.22649968f, -0.09764078f, -0.10181290f, 0.07246762f, -0.26334012f, 
    -0.02882291f, -0.10101575f, 0.21910703f, 0.29765940f, 0.22701396f, 0.13048238f, -0.05246639f, -0.03708481f, 
    -0.38249117f, -0.12011831f, 0.11589754f, 0.11860646f, -0.17719387f, -0.56120580f, 0.09355631f, 0.51717860f, 
    0.28377831f, 0.00784061f, 0.22667499f, 0.03530945f, -0.04591256f, -0.09145416f, 0.04056315f, -0.07145573f, 
    0.07635758f, 0.10611965f, 0.26191375f, 0.05116573f, 0.17351568f, 0.32330778f, -0.06956360f, 0.04498275f, 
    -0.33063599f, 0.02053990f, -0.14230931f, -0.04891679f, 0.04333390f, 0.00546032f, -0.03577225f, 0.16812955f, 
    0.13698961f, -0.27123502f, -0.44799563f, -0.11578596f, -0.03502352f, 0.15534732f, 0.26014969f, -0.04570666f, 
    -0.08733375f, -0.30937237f, -0.68988842f, -0.22354774f, -0.06207326f, 0.05711797f, 0.16434999f, -0.00052531f, 
    -0.12376951f, -0.06873225f, -0.55974364f, 0.06449136f, -0.04920567f, -0.17640871f, -0.18540817f, 0.15044048f, 
    -0.18482316f, -0.04152862f, -0.11604299f, 0.82247531f, 0.28268990f, -0.15425625f, 0.25657296f, 0.11481509f, 
    0.28105927f, -0.06551035f, -0.18943886f, -0.13055150f, 0.06441935f, 0.42109150f, -0.18164133f, -0.04398890f, 
    0.13573664f, -0.16312182f, -0.12349144f, 0.19498886f, 0.04233988f, 0.26301447f, -0.09622078f, -0.08078136f, 
    0.16408271f, -0.17060445f, 0.06844610f, 0.08393191f, 0.18049768f, 0.17311396f, 0.14303917f, -0.21277362f, 
    -0.67775875f, -0.11625759f, -0.00462247f, 0.37359452f, 0.10885740f, -0.14644597f, -0.17985535f, -0.04137444f, 
    0.02541370f, -0.39916247f, 0.34873921f, 0.09720605f, -0.07310742f, 0.00993461f, -0.00694905f, -0.07148261f, 
    0.30816138f, 0.58278453f, -0.13386703f, -0.13169360f, 0.06020327f, -0.11625323f, -0.36342630f, 0.08838007f, 
    -0.01988902f, -0.37214166f, -0.48529693f, -0.34635442f, -0.46914923f, 0.09379520f, -0.06043353f, -0.13922861f, 
    0.21864696f, -0.15772538f, 0.19769813f, -0.26203975f, -0.09323568f, 0.30640045f, 0.14352702f, -0.00769621f, 
    0.12534855f, 0.18080814f, 0.11728114f, -0.17265134f, -0.04691259f, 0.40353939f, 0.27110124f, 0.08466306f, 
    0.00821866f, 0.01838028f, 0.07793846f, 0.01677239f, 0.46730638f, -0.29186100f, -0.04779243f, 0.37470275f, 
    -0.07039973f, 0.02582990f, 0.06107379f, -0.04218556f, -0.07021855f, 0.26095119f, 0.01359061f, -0.30407912f, 
    -0.36159775f, 0.04739924f, 0.18865357f, 0.01442147f, 0.03108770f, -0.08534800f, 0.24437422f, 0.26411974f, 
    -0.33231294f, 0.34042147f, -0.20359075f, 0.27506101f, 0.14429817f, 0.19931823f, 0.33503157f, -0.08418405f, 
    0.50380564f, 0.41236478f, -0.13195302f, -0.04618440f, -0.00458389f, -0.00166909f, 0.37208483f, 0.04349596f, 
    -0.20475966f, -0.20845307f, -0.27627945f, 0.33551985f, 0.04470376f, 0.20529899f, 0.16956905f, -0.07448693f, 
    0.18483402f, -0.02124851f, -0.41416770f, -0.22820279f, -0.10480066f, 0.27487826f, 0.02391496f, -0.08363743f, 
    0.13724385f, -0.09981024f, 0.11223830f, 0.31739309f, -0.40401223f, 0.25399324f, -0.09216721f, 0.20342889f, 
    -0.01696858f, -0.17954735f, 0.07414205f, -0.47490731f, -0.53750473f, -0.06893378f, 0.00924404f, -0.18050835f, 
    0.04855617f, -0.06101410f, -0.01560815f, 0.12612741f, 0.42140752f, 0.50057954f, -0.10215533f, 0.14629048f, 
    -0.08739978f, -0.08727953f, 0.06103364f, 0.13604110f, 0.06922422f, -0.20591097f, 0.53412545f, -0.02791116f, 
    -0.21096660f, -0.30541530f, 0.01907541f, 0.05856806f, 0.14493410f, 0.06713732f, -0.11215972f, -0.39635321f, 
    -0.25119412f, 0.03760114f, 0.14058970f, 0.00250222f, -0.00731332f, -0.02152928f, 0.03243048f, 0.05682699f, 
    0.53225517f, 0.03748319f, 0.10773139f, -0.03536144f, 0.13748795f, 0.05707983f, 0.06063425f, -0.06202088f, 
    0.01600620f, 0.31227064f, 0.37507048f, 0.18872154f, -0.23394248f, 0.34900117f, 0.16941600f, -0.00274792f, 
    0.07814310f, 0.19456081f, 0.08978939f, 0.06692742f, 0.07920086f, 0.16725855f, -0.04045872f, 0.05213755f, 
    0.15504189f, -0.04218923f, 0.19355485f, 0.10477437f, 0.54126376f, 0.02709197f, -0.14504713f, -0.07651811f, 
    -0.13607645f, -0.19196256f, 0.10799217f, 0.22924879f, -0.03912760f, -0.01196108f, -0.19689745f, 0.16550858f, 
    -0.03719765f, -0.06077525f, -0.05866284f, -0.23102623f, 0.23988986f, -0.79842257f, -0.28848675f, -0.10265111f, 
    -0.24942283f, -0.09020887f, -0.10555260f, -0.12703785f, -0.03879255f, 0.48369837f, 0.21574947f, 0.40901485f, 
    0.14155480f, -0.12384655f, -0.11729594f, 0.07904492f, -0.10045833f, 0.00412682f, -0.81425256f, -0.36746264f, 
    -0.08063298f, -0.03523068f, -0.02767766f, 0.00305546f, 0.07779131f, -0.10856327f, 0.11716542f, -0.28915271f, 
    0.15237433f, -0.14624625f, 0.19349243f, 0.14083624f, 0.18607323f, -0.04991234f, 0.00255053f, -0.06701660f, 
    -0.35892263f, 0.31847259f, 0.04047922f, 0.14295565f, -0.18618222f, -0.14375238f, 0.09149767f, -0.00563336f, 
    0.13369824f, 0.32971865f, 0.25285953f, 0.12955692f, -0.15240732f, -0.15436620f, -0.02873841f, 0.19334337f, 
    0.13721381f, 0.37806103f, 0.43088877f, 0.00491887f, 0.12334801f, -0.02918249f, 0.12348504f, -0.09051769f, 
    0.28353152f, 0.13901511f, -0.03913713f, -0.30704167f, 0.12328948f, 0.30601773f, -0.28557113f, 0.14937891f, 
    -0.41219306f, -0.08133891f, 0.25671580f, 0.12697691f, -0.12503928f, 0.21067698f, 0.14734830f, 0.22356904f, 
    0.22418548f, 0.13943282f, -0.00698974f, -0.27541026f, 0.29861102f, -0.27820620f, -0.00323679f, 0.27458483f, 
    0.16078006f, -0.01522134f, 0.53194338f, 0.22225314f, -0.13859512f, -0.51287752f, -0.18027836f, 0.22310141f, 
    0.14312433f, 0.15092820f, -0.01843045f, -0.02674076f, 0.16007556f, -0.33726645f, 0.07725097f, -0.21938795f, 
    -0.08216293f, 0.32068098f, 0.16995166f, 0.06963725f, -0.11205963f, 0.38232255f, 0.01840916f, 0.33781627f, 
    -0.18993062f, 0.00969261f, -0.16676845f, 0.21539745f, 0.25233400f, 0.02589814f, -0.06892493f, -0.02489719f, 
    0.06314452f, 0.08465567f, 0.01029976f, 0.18390228f, 0.20942757f, -0.02536863f, 0.24337794f, 0.18613414f, 
    0.02465640f, 0.11211742f, -0.34010869f, 0.23782688f, -0.11492284f, -0.00627291f, 0.04235173f, 0.14358507f, 
    -0.11485052f, 0.14501530f, -0.06722182f, 0.14272210f, -0.50274414f, -0.16061509f, -0.14588277f, 0.12492165f, 
    0.12175345f, 0.13804547f, -0.29804668f, -0.12290139f, -0.45022434f, -0.00648850f, 0.07373023f, -0.49108160f, 
    -0.17604172f, -0.18946858f, -0.27058572f, 0.00914315f, -0.08823032f, -0.23635913f, -0.51818156f, 0.03349897f, 
    0.40151325f, 0.10399152f, 0.26375768f, -0.18331268f, -0.17260635f, -0.14610949f, -0.33573008f, -0.39453086f, 
    0.01831629f, -0.02219815f, -0.28705177f, -0.02339470f, 0.20434105f, -0.01554998f, 0.11537725f, 0.32320669f, 
    0.01617982f, -0.25759870f, 0.23997061f, 0.07681888f, -0.16841273f, -0.09468541f, 0.05948615f, -0.16685443f, 
    0.14549492f, 0.06761285f, -0.24715543f, 0.07395059f, 0.37415406f, 0.19300462f, -0.02222236f, 0.03375370f, 
    0.07691973f, 0.29827407f, -0.26774693f, 0.06008807f, -0.13447343f, -0.24813965f, -0.09488922f, 0.01530257f, 
    -0.07464254f, 0.19039288f, 0.67065942f, 0.16595095f, -0.42371362f, -0.05437009f, -0.07028275f, 0.00557471f, 
    0.04962835f, 0.15499753f, -0.11412397f, 0.13941880f, 0.27777559f, 0.39932105f, 0.04356531f, 0.01525900f, 
    -0.10704540f, -0.05358374f, 0.21406385f, 0.03168762f, 0.09819817f, -0.44959006f, -0.15807244f, -0.13267578f, 
    0.00881222f, 0.16766895f, -0.18595210f, -0.15290198f, 0.21843092f, -0.31579736f, 0.53170413f, 0.43332514f, 
    0.04941202f, 0.07839973f, 0.10788184f, -0.04667065f, -0.00893387f, -0.08601294f, -0.04102943f, 0.23452140f, 
    -0.07882719f, 0.00476655f, -0.10230199f, -0.01634739f, -0.18726395f, -0.14142741f, -0.12660421f, -0.05751523f, 
    0.07931445f, -0.02658395f, -0.21599384f, 0.05790303f, 0.05865568f, -0.00851862f, 0.00278575f, 0.07312173f, 
    -0.30999959f, -0.09893812f, 0.00470724f, -0.01219848f, -0.14966284f, -0.01759842f, -0.01391697f, -0.18456137f, 
    0.09005623f, -0.00002522f, -0.78890544f, -0.06308573f, -0.01714106f, -0.12767340f, 0.11041774f, 0.01342973f, 
    0.00525128f, 0.03499822f, -0.46237025f, 0.16945167f, -0.03567481f, -0.24107459f, -0.22049366f, -0.02446859f, 
    -0.02135122f, 0.20658195f, -0.11407227f, 0.02888088f, 0.05649061f, -0.07000813f, 0.17959321f, 0.12570839f, 
    0.17172533f, 0.08524046f, -0.19005808f, -0.14312260f, -0.26085848f, 0.19074273f, -0.23591372f, 0.22461113f, 
    -0.13511042f, -0.20104498f, 0.04020754f, 0.06492013f, -0.24320056f, 0.31290510f, -0.12484960f, -0.13643877f, 
    -0.02068416f, -0.15788765f, -0.18873627f, 0.05118174f, -0.08302155f, -0.03670916f, 0.04343681f, 0.29884261f, 
    0.06414957f, -0.06185525f, -0.00830504f, -0.07000852f, 0.03621407f, 0.21499930f, -0.00345580f, 0.30498129f, 
    -0.31834763f, 0.04858506f, 0.01000905f, 0.15998961f, 0.10424206f, -0.09314726f, 0.06651759f, -0.23657152f, 
    0.06531788f, -0.01989844f, 0.00168995f, -0.08012202f, -0.07906716f, 0.03686449f, -0.02330819f, -0.03670692f, 
    0.04230860f, 0.03785835f, -0.08313747f, 0.00339990f, -0.04700522f, 0.01948693f, -0.05804789f, 0.01704738f, 
    0.06121782f, -0.08495612f, 0.01867992f, 0.00602337f, 0.02172314f, 0.03168226f, -0.03112024f, -0.04225694f, 
    0.04907745f, -0.06303176f, -0.00735913f, -0.02445241f, 0.00503679f, 0.06021040f, -0.05732135f, -0.03821640f, 
    -0.04964251f, 0.03308236f, -0.03577387f, 0.01428346f, -0.01028055f, -0.07772388f, -0.06658620f, -0.02903068f, 
    0.07436065f, -0.08706046f, -0.08599271f, -0.01987972f, 0.02367760f, -0.04416083f, -0.07010485f, 0.01164682f, 
    0.06895690f, -0.01110587f, 0.02914282f, -0.01703141f, -0.00154678f, -0.04009775f, -0.02279237f, -0.06980477f, 
    0.06436585f, -0.01215060f, 0.00530816f, -0.01117753f, 0.01553288f, 0.00030898f, -0.03745603f, -0.04806675f, 
    -0.04106872f, -0.01374110f, 0.00004460f, -0.01543708f, -0.07937465f, 0.05606114f, -0.03529519f, 0.00569842f, 
    -0.07096737f, 0.03221146f, 0.07378192f, 0.02915711f, 0.05900093f, 0.00541242f, 0.04441212f, 0.01119797f, 
    -0.05696736f, -0.02190929f, -0.06385357f, 0.06242624f, 0.07189494f, 0.00327444f, -0.07061718f, 0.02498898f, 
    -0.04568432f, -0.06690277f, -0.05818925f, 0.01549913f, -0.00658981f, -0.03067503f, 0.01507021f, 0.04402667f, 
    -0.07564629f, -0.06422906f, -0.01644276f, 0.05577897f, 0.03953946f, -0.05702389f, -0.01236918f, -0.07656400f, 
    0.00926979f, 0.05082445f, -0.02761540f, -0.01126887f, -0.03688402f, 0.00604819f, -0.05022139f, 0.03650784f, 
    0.05296842f, -0.02089951f, -0.08018582f, -0.04390175f, -0.08255170f, 0.01861553f, -0.08002053f, -0.04932749f, 
    0.02146187f, -0.03024212f, -0.07090687f, 0.04246761f, -0.04821848f, 0.06615975f, -0.00815046f, -0.02902328f, 
    0.04812961f, -0.04072751f, 0.05254708f, -0.00419271f, 0.01000288f, 0.06376497f, -0.03884306f, -0.07573037f, 
    -0.04032804f, -0.08858915f, -0.06856558f, -0.02825649f, -0.05548328f, 0.01538553f, 0.03103411f, -0.00506310f, 
    -0.00829415f, -0.03930961f, -0.06208788f, -0.02355005f, 0.05753859f, -0.06116367f, -0.04414674f, 0.07064747f, 
    -0.05257768f, -0.02922871f, -0.04777518f, -0.01626975f, -0.05987845f, -0.08078232f, 0.04935779f, -0.00880686f, 
    0.06267915f, 0.04639225f, -0.04379137f, 0.02087494f, -0.01212935f, -0.08538597f, -0.08556017f, -0.05077290f, 
    -0.02654167f, 0.05232150f, 0.00697551f, 0.02823859f, -0.02798820f, 0.06032170f, -0.08146153f, 0.04067197f, 
    -0.02995015f, -0.00922226f, -0.07269090f, -0.06900616f, -0.07548861f, -0.00293383f, -0.04834739f, -0.01481322f, 
    -0.02598543f, -0.00010373f, -0.06751995f, 0.05348707f, -0.04147240f, -0.01157175f, -0.00041303f, -0.09620114f, 
    -0.06885631f, -0.07923428f, -0.06970180f, -0.03482655f, 0.06961554f, 0.06654286f, 0.07234591f, -0.00878382f, 
    -0.03163739f, 0.01789120f, -0.01596032f, -0.00985457f, -0.03925660f, 0.00678169f, -0.04120469f, -0.05550554f, 
    0.01814608f, -0.06697008f, 0.02015125f, -0.07263985f, -0.00340642f, 0.00605283f, -0.03871502f, 0.06670751f, 
    -0.01032815f, -0.00296499f, -0.09566165f, 0.07237667f, -0.08425702f, -0.03569884f, 0.00476914f, 0.06006898f, 
    -0.00189774f, 0.06887892f, 0.01884399f, -0.06470990f, -0.07021812f, -0.04298927f, 0.02113880f, -0.05027264f, 
    -0.07326946f, -0.07346305f, -0.01013726f, -0.01616204f, 0.02239874f, -0.07055111f, 0.02353916f, 0.04191272f, 
    -0.08221909f, -0.03915669f, -0.03533525f, 0.04920643f, 0.00323724f, -0.04185873f, 0.00038590f, -0.07390051f, 
    0.03048065f, -0.03918457f, -0.02152787f, -0.01910030f, -0.02770323f, -0.01092271f, -0.06786939f, 0.04541554f, 
    0.00072354f, 0.07040147f, -0.04016782f, -0.05008174f, -0.04869230f, 0.02102199f, -0.03883535f, -0.08873145f, 
    0.06171657f, -0.00697962f, -0.02795989f, -0.06987030f, -0.06942825f, 0.05674885f, -0.05530115f, -0.02827336f, 
    -0.07919540f, -0.04377070f, 0.00579968f, -0.07085404f, 0.06737496f, 0.02049722f, 0.00699724f, 0.02515618f, 
    0.01218559f, 0.05895768f, -0.06126717f, 0.04855080f, -0.01482777f, -0.05708267f, 0.02943731f, -0.01236432f, 
    -0.05415469f, -0.06633514f, 0.05493421f, 0.06049818f, -0.03435186f, -0.03457697f, 0.02628349f, -0.08113568f, 
    -0.08614630f, 0.01381589f, -0.07222798f, -0.07905776f, 0.07083171f, 0.02380219f, 0.05621147f, -0.05887177f, 
    0.04213277f, -0.07519955f, 0.05004494f, -0.06045026f, 0.04951231f, -0.00842617f, -0.07233069f, 0.04499661f, 
    0.04622523f, 0.00877621f, -0.02021766f, -0.05743666f, -0.02720471f, -0.07559875f, -0.06990302f, -0.02696931f, 
    -0.06949485f, -0.01450691f, -0.04355645f, 0.02542409f, -0.05935932f, 0.01529546f, 0.06474303f, -0.02434766f, 
    -0.01102819f, 0.04258674f, 0.00847305f, -0.04435631f, 0.03915778f, -0.02046824f, -0.07138076f, 0.00794799f, 
    0.04391126f, 0.00695361f, -0.06119315f, 0.06245312f, 0.04716701f, 0.00357324f, -0.02727093f, 0.05531615f, 
    0.02071486f, -0.07191771f, -0.05357897f, -0.01434380f, 0.00518847f, 0.02747696f, -0.03685505f, -0.04994218f, 
    0.06753240f, -0.08561697f, -0.07184759f, -0.03879970f, 0.05329909f, -0.00723276f, 0.02597912f, 0.04796522f, 
    -0.02360068f, 0.00809438f, -0.07820455f, -0.08327571f, 0.02087976f, -0.08626281f, 0.02435433f, 0.05260989f, 
    0.04299574f, -0.07731643f, 0.00978850f, 0.03834023f, -0.05012584f, -0.08262590f, -0.03386766f, -0.07161386f, 
    -0.04778894f, 0.06862438f, 0.07683612f, -0.06379325f, 0.02915489f, 0.06157551f, -0.00060628f, -0.01319726f, 
    -0.01849769f, -0.01958909f, -0.05713594f, -0.05126210f, 0.06262212f, 0.07187267f, 0.07532280f, 0.03447284f, 
    -0.08896922f, -0.00866425f, 0.00954137f, -0.04776129f, -0.05236286f, -0.06001295f, -0.07526956f, -0.00881123f, 
    0.04980575f, 0.05912898f, -0.03186862f, 0.00089168f, 0.00052629f, 0.02300799f, -0.06135624f, -0.02456902f, 
    -0.04957181f, -0.06724424f, -0.06440635f, -0.01036652f, -0.05997531f, -0.07673351f, -0.07896663f, 0.00528175f, 
    0.06525352f, -0.07287838f, 0.05300212f, -0.02652749f, 0.02922254f, 0.00047124f, 0.01390493f, -0.07394852f, 
    -0.01522385f, 0.02825839f, 0.01233960f, -0.07474593f, -0.03238301f, 0.02500047f, -0.06566560f, 0.03346327f, 
    0.04638611f, -0.05920478f, 0.03839736f, 0.02591976f, -0.05148571f, 0.01542036f, 0.01869795f, 0.05268208f, 
    0.02087866f, -0.01896277f, -0.04744871f, -0.05220545f, -0.05083224f, -0.04054020f, -0.03721338f, 0.02593471f, 
    0.04803140f, 0.01516217f, -0.04591210f, -0.04139333f, -0.01051569f, -0.06303894f, 0.05817115f, 0.00578348f, 
    -0.09009685f, -0.07453204f, -0.03569635f, -0.06802862f, 0.06803261f, -0.05141878f, -0.01740403f, 0.03574300f, 
    0.01401349f, 0.01007202f, -0.07234748f, 0.02117263f, -0.03830905f, -0.06211321f, 0.04142073f, -0.02005434f, 
    -0.01195625f, 0.05231383f, 0.00321439f, 0.00873145f, -0.07561871f, -0.07005938f, 0.05921500f, 0.02028160f, 
    0.03310455f, -0.08034497f, 0.06257502f, -0.06264302f, -0.06192140f, 0.04554401f, 0.03602076f, -0.07370555f, 
    0.06067297f, 0.02470080f, -0.02896143f, -0.01498810f, -0.08916855f, -0.03966742f, -0.07384085f, -0.06533684f, 
    -0.05585071f, 0.02878937f, -0.07496090f, -0.00903477f, 0.05387347f, 0.03569500f, -0.07221015f, -0.00810173f, 
    -0.03006152f, 0.02831918f, -0.02624826f, -0.07236313f, -0.02603244f, 0.04477001f, -0.03819241f, -0.00474975f, 
    0.06331947f, 0.02906615f, -0.04856136f, -0.04598166f, -0.00555627f, 0.03812208f, -0.00348583f, 0.04201328f, 
    0.05430817f, -0.06017065f, 0.02534253f, 0.04284815f, -0.08292359f, -0.01329318f, -0.08755362f, -0.07559462f, 
    0.04106287f, -0.08478636f, -0.06840941f, 0.05409417f, -0.02518605f, -0.05236045f, -0.01128499f, -0.08289331f, 
    0.06121812f, -0.05323467f, 0.04275722f, 0.03365498f, 0.04519164f, -0.05428864f, -0.04815471f, -0.01471523f, 
    -0.03939018f, 0.03107566f, 0.05417240f, 0.03718526f, 0.02655494f, -0.07023145f, -0.08386730f, -0.01993932f, 
    -0.03371489f, 0.02893685f, -0.01536101f, -0.01463661f, 0.03249079f, -0.03384744f, -0.01385072f, -0.03032006f, 
    0.05067498f, -0.00090509f, 0.00459923f, -0.05963586f, -0.00168176f, -0.04032824f, -0.07578140f, 0.05861644f, 
    -0.03361854f, 0.02908370f, -0.01839332f, 0.04768531f, -0.06466649f, 0.00073954f, -0.05730822f, 0.06441671f, 
    0.05805589f, -0.03043245f, -0.02309742f, -0.04945816f, 0.05224922f, 0.01183125f, 0.00364042f, -0.00284018f, 
    -0.08178676f, -0.02363319f, 0.04226192f, -0.05101765f, 0.03365262f, 0.00989556f, -0.03095025f, 0.03013756f, 
    -0.01351784f, 0.05534275f, -0.02833894f, -0.06395692f, -0.02881929f, -0.05986837f, 0.04332729f, -0.03964796f, 
    -0.07467284f, -0.06273185f, -0.07492768f, -0.02653045f, 0.02894196f, 0.01165137f, 0.04750239f, -0.05469714f, 
    -0.04128418f, -0.08816928f, -0.09096268f, -0.05155066f, -0.00763619f, 0.05495385f, -0.07231396f, 0.01158048f, 
    -0.10515529f, -0.07677901f, 0.04863766f, 0.01208800f, 0.02478488f, 0.02333907f, -0.05187626f, 0.04426843f, 
    0.04251202f, 0.02883347f, -0.05641209f, -0.02340141f, 0.05529612f, -0.04746222f, 0.05446992f, -0.03075231f, 
    -0.08376340f, -0.01612173f, -0.03669704f, -0.07182762f, 0.00879341f, -0.01449063f, -0.05821287f, -0.00657918f, 
    0.05408700f, -0.06762235f, -0.06631398f, 0.02086104f, -0.03477642f, 0.04919729f, 0.02040723f, -0.07893404f, 
    -0.08931890f, 0.00452866f, -0.05267972f, 0.03491416f, 0.03871261f, -0.09073532f, -0.07963950f, -0.00324454f, 
    -0.05454696f, 0.04587411f, -0.02259369f, 0.06133937f, -0.04822538f, -0.03354848f, -0.06759452f, -0.07465348f, 
    -0.01614628f, 0.05409439f, 0.01906100f, -0.07469997f, 0.01287266f, -0.00090563f, -0.00257484f, -0.04693199f, 
    0.02362413f, 0.01320624f, 0.03117696f, -0.07132322f, -0.01616208f, 0.05207502f, -0.04508813f, -0.07907203f, 
    -0.03262848f, -0.04488936f, -0.10490565f, -0.02326963f, -0.04741712f, 0.05881017f, -0.08018599f, -0.01053019f, 
    -0.06609926f, 0.00542670f, -0.00226336f, -0.01628234f, 0.02645889f, 0.05280599f, -0.03891588f, 0.02199200f, 
    0.03653646f, -0.06465594f, 0.06191555f, -0.06912437f, 0.01471936f, 0.03012162f, -0.07295507f, -0.08401905f, 
    0.05154276f, -0.01161194f, 0.00790013f, -0.03162012f, 0.04273181f, 0.00048797f, 0.04537265f, -0.02194889f, 
    0.00057773f, -0.00598085f, -0.07006710f, 0.01809396f, -0.03367126f, 0.02082771f, 0.03669903f, -0.01375375f, 
    0.14917442f, 0.05285899f, -0.37648869f, 0.06992549f, 0.17503537f, 0.04580316f, -0.05108053f, -0.20091470f, 
    0.04373116f, 0.29450214f, -0.58585232f, -0.27197430f, -0.40394211f, -0.01358966f, 0.30443019f, 0.03926213f, 
    0.16123466f, 0.15795581f, 0.70471483f, 0.45117769f, -0.13736980f, 0.08065408f, 0.09970754f, -0.23728459f, 
    -0.10428795f, 0.05824294f, -0.28810665f, -0.43965104f, 0.25866935f, -0.10536619f, -0.10088424f, -0.13366573f, 
    -0.11046486f, 0.03534487f, -0.07029787f, -0.05908727f, 0.42339331f, 0.38425803f, -0.14433438f, -0.00271872f, 
    -0.10689140f, 0.13759388f, 0.02308223f, -0.17497529f, 0.27758011f, -0.22878657f, 0.30931365f, -0.20539607f, 
    0.00640276f, 0.04344086f, 0.20319681f, -0.10401019f, -0.07419142f, -0.01900492f, -0.20167835f, -0.16757092f, 
    -0.46829420f, 0.18099044f, 0.13120936f, -0.04487872f, 0.32571810f, 0.19399914f, -0.28709596f, -0.97933465f, 
    -0.75755501f, -0.03376356f, 0.12698890f, 0.07440775f, -0.23915836f, 0.17454605f, 0.19413163f, 0.22079758f, 
    0.27754459f, 0.08400479f, -0.07687717f, 0.09353679f, -0.04671300f, 0.01097148f, -0.03333725f, -0.01099447f, 
    -0.08896215f, 0.61910921f, -0.10020909f, 0.13879973f, -0.04011663f, -0.13196501f, -0.09243972f, -0.00641382f, 
    0.10888865f, 0.18614677f, -0.33146515f, -0.15984046f, 0.29339638f, 0.18859909f, 0.22520888f, -0.08114512f, 
    0.02818765f, 0.07740608f, -0.10069691f, -0.95276463f, -0.00559030f, 0.16929236f, 0.00646414f, 0.16297427f, 
    -0.31203115f, 0.14417394f, -0.22308356f, 0.07339788f, 0.21582873f, 0.31823811f, 0.04032189f, -0.02316098f, 
    0.24598630f, 0.50321364f, -0.29220894f, -0.23231393f, -0.12442751f, 0.26826194f, -0.38320160f, 0.08527693f, 
    0.03363023f, 0.08083698f, -0.12007685f, 0.01712974f, -0.15841088f, -0.16626708f, 0.13919055f, -0.57966328f, 
    -0.27606630f, -0.08115298f, 0.12443143f, 0.03827023f, -0.19251354f, 0.11492732f, 0.07111795f, -0.23609908f, 
    0.02378961f, 0.07423343f, -0.01890138f, 0.02019925f, 0.08473683f, -0.13756287f, -0.06897386f, -0.16144285f, 
    0.01216863f, -0.27687934f, -0.40063909f, 0.08380467f, 0.25279117f, 0.30322200f, -0.31415814f, -0.14348869f, 
    -0.05511848f, 0.30796275f, -0.06783277f, -0.03594785f, 0.16238368f, 0.05954271f, -0.15183620f, 0.06225654f, 
    0.10723217f, 0.21002883f, -0.15676160f, -0.71744889f, -0.09177142f, -0.07268567f, -0.01239925f, 0.09298484f, 
    0.37957239f, 0.31367072f, -0.01052844f, 0.30964082f, 0.66862816f, -0.12770438f, -0.20628150f, 0.00214805f, 
    0.20845224f, -0.12451094f, -0.08713518f, 0.38765079f, 0.27678749f, -0.08972292f, -0.76175064f, 0.21851029f, 
    0.06321689f, -0.06914467f, 0.27679124f, -0.12136508f, -0.06328143f, -0.20122804f, 0.22544649f, 0.14477566f, 
    0.11320383f, 0.14276160f, 0.16908684f, 0.13471994f, 0.03644133f, -0.05796555f, -0.07977089f, -0.46065259f, 
    -0.32356563f, 0.04315569f, -0.01372264f, 0.14772877f, -0.07628610f, -0.03323234f, 0.48980594f, -0.21230492f, 
    0.03602365f, 0.05419844f, 0.07088380f, -0.04544881f, -0.40960053f, 0.18185736f, 0.05592906f, -0.18680324f, 
    -0.34454039f, -0.06584196f, -0.54654026f, 0.19936010f, 0.20084921f, 0.22304618f, -0.40301833f, 0.00432165f, 
    0.02992831f, -0.10546447f, -0.12267436f, -0.17085914f, -0.03487346f, 0.02660274f, -0.11086684f, 0.02038023f, 
    -0.13617864f, -0.16067553f, -0.17213377f, 0.11696870f, 0.53493148f, 0.01718780f, 0.12135167f, 0.07111534f, 
    0.14563935f, -0.15291293f, -0.10455810f, -0.47715765f, -0.05463513f, -0.05384861f, -0.05302040f, -0.07902937f, 
    0.01772322f, 0.25083894f, -0.12397554f, -0.12878697f, 0.01236030f, 0.21197532f, 0.01448784f, -0.19572589f, 
    0.15934134f, -0.20173791f, 0.07883108f, -0.17349342f, -0.15018035f, -0.24149774f, -0.16689642f, -0.68608934f, 
    -0.03972340f, 0.18920988f, -0.21097703f, 0.10988693f, 0.00816758f, -0.01390224f, -0.33192372f, -0.04541819f, 
    -0.10317144f, -0.17816152f, -0.17379329f, 0.09772065f, -0.06543224f, 0.18580978f, 0.06195734f, -0.30066371f, 
    -0.16194549f, -0.04637204f, 0.19140184f, 0.12541081f, -0.13222967f, -0.06282478f, -0.22711471f, 0.05470258f, 
    0.15903074f, 0.53941917f, -0.11421312f, 0.05351046f, 0.27325508f, 0.02470152f, 0.14250411f, -0.00884627f, 
    -0.26451626f, 0.33422160f, 0.09487823f, -0.01497713f, 0.26371950f, -0.20589592f, -0.06696671f, -0.01309074f, 
    0.13568272f, 0.02526726f, -0.05713494f, -0.00705945f, 0.21184923f, -0.17996436f, -0.04243302f, 0.04358057f, 
    0.05912372f, -0.09420300f, 0.18769324f, 0.44680595f, -0.03501693f, 0.43550065f, -0.13239232f, -0.22292489f, 
    -0.05815333f, -0.07716908f, -0.07090870f, -0.12880845f, -0.05827287f, 0.28025863f, 0.16350463f, 0.16372460f, 
    -0.01409817f, -0.07517152f, 0.24395052f, 0.25985697f, -0.01542136f, -1.20104170f, -0.21965456f, -0.01465494f, 
    0.14993580f, 0.24479702f, 0.35848603f, -0.07991983f, 0.17530251f, -0.13789712f, -0.05025705f, 0.06727553f, 
    -0.02396486f, -0.15868433f, -0.02977303f, 0.24100418f, -0.28715000f, -0.36139444f, 0.17755260f, 0.31018183f, 
    0.16776256f, 0.16906065f, -0.13069929f, -0.05343916f, -0.05905382f, -0.08838407f, -0.00456597f, -0.10132862f, 
    -0.03879049f, 0.41317344f, 0.36720461f, 0.13421084f, -0.02529799f, -0.05127553f, -0.12719490f, 0.35649171f, 
    0.11980164f, 0.92837846f, 0.53066587f, -0.35891795f, 0.05105149f, -0.04460956f, -0.06063757f, -0.13798140f, 
    0.26506448f, 0.18201177f, -0.84391081f, -1.14977038f, -0.59031808f, 0.02393760f, 0.01293445f, 0.23104256f, 
    0.11739992f, 0.05522500f, 0.05276530f, 0.20398247f, -0.84050840f, 0.13566260f, 0.33420813f, -0.11776036f, 
    0.06428958f, -0.04435673f, 0.19351393f, -0.01878064f, -0.35507035f, -0.69679922f, -0.00841827f, -0.00201471f, 
    0.01655710f, -0.37066412f, 0.05723048f, -0.12711586f, 0.01355690f, 0.04346435f, 0.19773975f, 0.19562453f, 
    0.00711009f, -0.16054785f, -0.00080495f, 0.21556450f, 0.30165479f, 0.11028261f, 0.17463872f, 0.17417029f, 
    -0.32555214f, -0.26878634f, -0.11229191f, -0.41248959f, 0.01042082f, -0.06531042f, -0.02616663f, 0.16788150f, 
    -0.13799255f, -0.03472635f, 0.06940360f, -0.20368621f, 0.03927448f, 0.01629092f, 0.07196472f, 0.11141833f, 
    -0.18110450f, -0.18284003f, -0.08217480f, 0.21322620f, 0.12458798f, 0.08210503f, 0.24381824f, 0.14553186f, 
    -0.10772466f, -0.05339520f, 0.27589926f, 0.37789050f, -0.08958003f, -0.17472970f, 0.02002759f, 0.02798813f, 
    -0.09751938f, 0.07404390f, -0.00660343f, 0.17333211f, 0.15167448f, 0.05930471f, 0.06562205f, 0.07147253f, 
    -0.19891958f, -0.11077891f, 0.17413703f, -0.23050763f, -0.23102297f, 0.02413113f, -0.01273850f, 0.12241688f, 
    0.06211310f, -0.08531997f, -0.09719301f, -0.21907583f, -0.06729255f, -0.16938539f, -0.20333377f, -0.18117946f, 
    -0.09277788f, 0.16189322f, -0.20532657f, -0.08989280f, -0.01351918f, -0.04208560f, -0.04658105f, -0.22784294f, 
    0.21609978f, 0.07024139f, -0.03467308f, 0.12325674f, -0.12382162f, -0.08233487f, -0.05618886f, -0.15797558f, 
    -0.03161789f, -0.06947933f, -0.13327636f, -0.09902067f, -0.04250802f, 0.10281196f, -0.20679583f, -0.03481428f, 
    -0.25369018f, 0.09766588f, 0.21024592f, 0.19951811f, -0.09452429f, 0.04778663f, 0.16169412f, -0.01401735f, 
    0.33124021f, 0.11717287f, 0.23210469f, 0.34067538f, 0.08679347f, -0.23188885f, -0.22549033f, 0.03836608f, 
    0.01202224f, 0.07052253f, -0.12324037f, 0.25438434f, -0.21360707f, -0.08501484f, -0.07440609f, -0.02629859f, 
    -0.03813791f, 0.03855949f, 0.56089056f, -0.00068085f, 0.21948832f, 0.45130759f, -0.08556092f, -0.08762266f, 
    0.20873046f, 0.04164712f, -0.07439392f, -0.01391864f, -0.28429487f, -0.05634686f, -0.02721039f, -0.16567591f, 
    -0.09421222f, 0.13837922f, -0.11312810f, -0.12702376f, -0.11026137f, 0.19139235f, -0.01780353f, 0.06334836f, 
    0.23950598f, -0.25765628f, 0.08996844f, 0.03017577f, 0.29563177f, 0.33009419f, 0.02076163f, -0.23967335f, 
    0.08928572f, -0.17607404f, 0.09859353f, -0.08629752f, -0.04794393f, -0.00966849f, -0.06967928f, -0.05867667f, 
    -0.43010211f, 0.00206943f, -0.00319343f, -0.15398198f, 0.11707205f, 0.02304016f, -0.03194256f, 0.26450604f, 
    0.34078610f, 0.22176601f, 0.00393683f, 0.14904653f, -0.08924574f, -0.02004052f, -0.10009106f, -0.10441633f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.15885857f, -0.06494378f, 0.27562454f, 0.31346539f, 0.12853137f, 0.17770687f, 0.12749694f, 0.05576814f, 
    0.02712531f, 0.05670093f, -0.02534186f, -0.08707513f, 0.06538150f, 0.54585165f, -0.20187493f, 0.08209147f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.58410162f, 0.05855643f, -0.65083760f, -0.55482107f, 0.39824319f, 0.48673567f, -0.48541132f, -0.20261398f, 
    0.04484680f, 0.21887200f, 0.13782205f, 0.02575503f, 0.18761152f, -0.05916494f, -0.08949006f, -0.32503456f, 
    0.44165874f, -0.09720672f, -0.01634469f, 0.03005802f, 0.86596131f, -0.38559365f, 0.03776788f, -0.09944933f, 
    0.19895455f, -0.22844975f, -0.13560756f, -0.23776564f, 0.03174487f, 0.32701206f, -0.40978473f, -0.62783700f, 
    0.06784350f, -0.13436303f, 0.24627110f, -0.15207769f, -0.43486574f, -0.15174124f, -0.13751556f, 0.01869871f, 
    0.10137153f, 0.00810526f, -0.12473965f, 0.07893696f, 1.45628440f, -0.62924612f, -0.43672678f, -0.63667798f, 
    0.05205978f, -0.22136869f, -0.56066692f, -0.07857703f, -0.79834038f, 0.14650972f, 0.57502031f, -0.15467593f, 
    -0.25344571f, 0.17168909f, 0.05195985f, 0.00111846f, -0.09103797f, -0.66306937f, 0.47867247f, -0.34844887f, 
    -0.37222442f, -0.23447430f, 0.26976353f, -0.70052427f, -0.13469079f, 0.57318693f, 0.23742011f, -0.02501781f, 
    0.17296584f, 0.20405628f, 0.11585417f, -0.23401837f, -0.11002830f, -0.27942008f, -0.16243613f, 0.30530351f, 
    -0.80130869f, -0.08637246f, 0.00682900f, -0.00156299f, -0.00089560f, 0.27783298f, -0.80227017f, -0.09123454f, 
    0.21010971f, -0.05139057f, 0.11354441f, 0.11763354f, -0.33141905f, 1.01632094f, -0.24232404f, 0.29420018f, 
    -0.68930972f, 0.19384070f, 0.27906367f, -0.04945061f, -0.59907299f, 0.19109342f, 0.84047508f, 0.20900367f, 
    0.22545759f, 0.01484083f, -0.09551306f, 0.15998589f, -0.09471139f, 0.30984974f, -0.37638417f, -0.20855591f, 
    -0.43686646f, 0.05009340f, -0.65888387f, -0.80011839f, 0.24494104f, -0.12560442f, -0.94710052f, 0.06773128f, 
    -0.12975767f, 0.19809492f, 0.22314313f, 0.22951776f, -0.02792112f, -0.26749521f, 0.75783783f, 0.21619247f, 
    -0.26053235f, -0.15601732f, 0.69636476f, 0.69456565f, 0.75620961f, -1.04179311f, -0.47176847f, -0.21039090f, 
    0.06088020f, -0.04904643f, 0.21385321f, 0.17388375f, -1.00031769f, -0.23675552f, -0.63992417f, 0.33335006f, 
    0.92788029f, 0.15713398f, 0.45190692f, -0.55992872f, -0.42333728f, 0.28631672f, 0.18611635f, -0.25556633f, 
    0.06465656f, 0.00633091f, 0.02734887f, 0.16504326f, -0.84930533f, -0.34149271f, -0.26655376f, 0.19404505f, 
    -0.09694244f, -0.22139108f, 0.03708051f, 0.50552386f, -0.87992460f, -0.54715067f, -0.18314123f, -0.10282222f, 
    0.05250101f, -0.05420386f, 0.14020805f, -0.21392202f, 0.03647276f, -0.74015695f, 0.47589856f, -0.02968805f, 
    -0.26116320f, -0.06911769f, -0.32967499f, 0.57483590f, -0.32596281f, -0.18665916f, 0.01424487f, -0.14031003f, 
    -0.11526454f, 0.04757449f, 0.15202047f, 0.23696259f, -0.20321864f, -0.40915403f, -0.05082684f, 0.75835204f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.39888352f, -0.39389327f, -0.27746937f, -0.12837814f, 0.21198821f, 0.39816114f, 0.18663868f, -0.63739014f, 
    -0.36862549f, -0.33717474f, 0.62726313f, 0.46927741f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
