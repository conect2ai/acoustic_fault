#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.16182888f, -0.13765368f, -0.76347601f, 1.10613215f, 1.02054238f, -0.67979592f, 0.60612917f, 0.56236601f, 
    -0.34380782f, 0.15168454f, -0.20308058f, 0.46423626f, -1.48054051f, -0.70983618f, -0.42957741f, 0.24634998f, 
    -0.22124819f, -0.27815738f, -1.10319102f, -1.04792106f, -1.00792992f, 0.84753144f, 0.92135841f, 1.02395105f, 
    -0.40414470f, 0.05078606f, 0.23535368f, -0.06113876f, 0.96492642f, 1.19929039f, -1.14792013f, 0.13452820f, 
    -0.12700042f, -0.50214583f, 0.55710274f, -0.36568981f, 0.64843220f, -1.47087228f, -0.51178253f, -0.93150228f, 
    -1.08403027f, 0.18008481f, -0.02449334f, 0.09583758f, 0.65463430f, 0.83231425f, 0.73442090f, 1.32495117f, 
    0.26405641f, -1.00263584f, -0.52046764f, -0.62430525f, -0.32708627f, -0.08988256f, 0.63952219f, 1.01630318f, 
    1.27346754f, 0.00984399f, 0.46166384f, 0.36093563f, 0.46582994f, -0.02476669f, -0.35623527f, -0.18989971f, 
    1.40788376f, 0.96905041f, 0.65942496f, 0.13682367f, -0.14793026f, -0.62133723f, 0.37104562f, 0.30868438f, 
    -0.46949655f, -1.19378042f, -0.46816015f, 0.93802804f, -0.65723085f, -0.54779732f, -0.09063756f, -0.50453210f, 
    -0.36085874f, -1.15421128f, -1.48611808f, -0.68804449f, -0.98884541f, -0.51812232f, -0.33429587f, 0.23674609f, 
    0.55545521f, -0.18564984f, 0.60807639f, -0.13891077f, 0.30661726f, -0.84825873f, -1.10937428f, -0.02443032f, 
    -0.38199553f, 0.56294507f, -0.20018788f, -0.46764779f, 0.95037150f, -1.01404583f, -0.12868057f, -0.73949707f, 
    -1.11032164f, 0.05784520f, 0.37592655f, -0.08455517f, 0.64827204f, 0.64599633f, 0.76176935f, 0.30935764f, 
    -0.98374242f, 1.22462773f, -0.22728667f, -0.22864597f, -0.02313171f, 0.55048245f, 0.73075134f, -1.35308492f, 
    -1.20995200f, 1.03465354f, -0.37528864f, 0.23685622f, 0.13781542f, 0.58514279f, 1.48222661f, -0.64683479f, 
    1.17694318f, 0.01316819f, 0.38666064f, -0.60484225f, -0.16565819f, 0.39606372f, 0.27603808f, 1.55142796f, 
    1.12291038f, 0.26380771f, -0.87578446f, -0.31669697f, 0.01441961f, 0.20695120f, 0.15255292f, 0.33565035f, 
    0.60822546f, 0.82508165f, 0.87127393f, 0.31836867f, 0.69679785f, 1.05346870f, 0.19976667f, -0.29391018f, 
    -0.23516409f, -2.12062263f, 0.77011138f, 0.74760771f, 0.94466197f, 1.13482237f, 0.62561959f, 0.11452228f, 
    -0.42342034f, -0.23330618f, 0.51513124f, 0.81512225f, 0.67607087f, -0.36352432f, -1.13528717f, -0.80878651f, 
    0.96394873f, 0.26326340f, 0.52674425f, -1.40966690f, -0.80464846f, 0.21886075f, 0.16794141f, -0.29131147f, 
    -1.22362602f, 0.28440985f, 0.18310595f, -0.90260273f, -0.29480594f, -0.61215621f, -0.93098700f, 0.79877168f, 
    -1.05959260f, 0.51895052f, -0.57448679f, 0.08317913f, -0.20451747f, -1.05997801f, -0.93354374f, -0.80163574f, 
    -0.08663294f, -0.48641869f, 0.47184545f, -0.47195911f, -0.61147511f, -0.67280048f, 1.50505781f, -0.75632858f, 
    -0.91583008f, -0.07817882f, -0.05596444f, -0.92270249f, -0.35023412f, 0.23589103f, 0.39049199f, 1.31302786f, 
    -0.88957083f, 1.06318176f, 0.11812679f, 0.15009776f, 0.87500775f, -0.42491788f, -0.18789645f, 0.06100285f, 
    -0.20437151f, 1.03104353f, -0.61611605f, 0.92317748f, -0.27668247f, -0.84681404f, -0.64842403f, -0.68560886f, 
    -0.76813871f, -1.36124659f, 0.24961057f, 0.59331840f, -0.03027119f, -0.76123881f, -0.76442510f, 0.26309416f, 
    0.24362266f, 0.80077761f, -1.43221629f, -1.02406561f, -0.88843650f, -0.39777246f, -0.60958874f, 0.84376860f, 
    0.80067134f, -0.02897022f, 0.72976995f, 0.72548258f, -0.08203332f, 0.56069088f, 0.63784665f, 0.69473058f, 
    0.85674149f, -0.44554549f, -0.63957459f, -0.35974121f, -0.73081738f, 0.60683203f, 0.66604871f, 0.89811754f, 
    0.76193309f, -1.29537797f, -0.17709571f, 0.00008443f, 0.52523476f, 0.10901595f, 0.74686104f, 0.57305205f, 
    -1.09238613f, -0.57966268f, -1.41714144f, 0.14402217f, -0.28437355f, 0.17982180f, -1.12579799f, -0.53496301f, 
    -1.00997043f, -0.32339334f, 1.36082542f, 0.69290507f, -0.05315154f, -0.14201616f, -0.18511088f, 0.88066411f, 
    -0.20808822f, -0.62471360f, 1.07327724f, -0.68058252f, 0.53307754f, 0.20727485f, 0.36796689f, 0.47595516f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27052444f, 0.47476071f, 0.15266609f, 0.38714969f, 0.22053958f, 0.00797443f, 0.23268811f, 0.20380324f, 
    0.21866621f, 0.59127712f, -0.02222411f, 0.37336326f, 0.43471977f, -0.07925766f, -0.31210199f, -0.24775751f, 
    0.25244677f, 0.24246532f, -0.02356760f, 0.35771343f, 0.01919214f, -0.50499749f, -0.03600807f, 0.02192554f, 
    0.02861120f, -0.17495616f, 0.44974929f, 0.06025055f, 0.08473168f, 0.28938785f, -0.04117635f, -0.12792553f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.04343413f, 0.01228403f, -0.02712580f, -0.02582959f, -0.02832108f, -0.05789734f, 0.00347055f, -0.04354844f, 
    0.01570809f, -0.03969769f, 0.01542370f, -0.05558712f, -0.05913278f, 0.04018500f, -0.01421786f, -0.00698263f, 
    -0.04961897f, 0.02041857f, -0.05986188f, 0.02044772f, -0.01396051f, -0.01756596f, -0.06202186f, 0.00636651f, 
    -0.02577653f, 0.04656905f, -0.06021028f, -0.01260156f, 0.00123436f, 0.00105895f, 0.00459099f, -0.02559055f, 
    -0.02992496f, 0.04943767f, 0.01740382f, -0.05433219f, 0.03981115f, -0.03197807f, 0.04527021f, 0.01751615f, 
    0.02090892f, -0.00645415f, 0.02930901f, -0.05726241f, 0.01244194f, -0.01312941f, -0.05951513f, -0.04406796f, 
    -0.01133141f, 0.01479532f, -0.06598188f, -0.05462928f, -0.02868913f, -0.04803865f, -0.05142193f, -0.04410321f, 
    -0.06500337f, 0.04597681f, -0.04099954f, 0.02030633f, -0.06470820f, 0.04946123f, 0.01185946f, -0.02862269f, 
    -0.04934034f, 0.01988507f, 0.05244385f, -0.06548052f, -0.02341660f, 0.02088879f, -0.04798439f, 0.02797493f, 
    -0.03004318f, -0.06608629f, -0.01999986f, 0.04714819f, -0.00065231f, 0.02408791f, -0.01684948f, -0.03318502f, 
    0.03356659f, 0.02269782f, -0.03125935f, -0.04233580f, 0.01080121f, -0.04529443f, 0.03397489f, 0.02300584f, 
    -0.05903728f, 0.02187708f, -0.04609310f, 0.03681134f, -0.01429831f, 0.04741187f, -0.03377454f, -0.02837769f, 
    -0.04701938f, 0.02533231f, -0.05427199f, -0.06542844f, -0.02683206f, 0.01683887f, 0.04037701f, -0.00921098f, 
    -0.00505899f, 0.00118763f, -0.00780837f, -0.01902270f, 0.03855173f, -0.01913705f, -0.04274155f, -0.01385103f, 
    -0.05524985f, -0.02017648f, -0.00944573f, 0.04587641f, 0.02772286f, -0.03523671f, -0.05898223f, 0.01963935f, 
    0.00887714f, -0.02339014f, -0.00706136f, 0.01882828f, 0.01283907f, -0.02243665f, 0.03596980f, -0.02021121f, 
    0.02595378f, -0.04183496f, -0.05588812f, -0.05508379f, 0.03306034f, -0.04223537f, 0.03310711f, -0.05979542f, 
    -0.05722815f, -0.00100349f, -0.03847457f, -0.06096914f, 0.02296673f, -0.02776548f, 0.00483421f, -0.00120769f, 
    0.02429596f, -0.04843821f, -0.04942103f, -0.01638502f, -0.05398700f, -0.04387947f, 0.00856344f, -0.03613160f, 
    0.03971152f, -0.01897581f, 0.04013031f, -0.03153510f, -0.03837661f, 0.01223624f, 0.01298203f, 0.02006606f, 
    0.02663334f, -0.06200202f, -0.05125611f, -0.00458497f, 0.03677385f, -0.05282590f, -0.06097548f, -0.03400499f, 
    0.04507920f, 0.00136711f, 0.03254688f, 0.01344054f, 0.04832877f, -0.06192818f, -0.02273120f, -0.02435869f, 
    0.04454724f, 0.03780149f, 0.03976175f, 0.01511523f, -0.03474368f, -0.04847103f, 0.03773828f, -0.00711192f, 
    -0.01084983f, 0.02855960f, 0.02298402f, -0.06336852f, 0.01564458f, 0.02635383f, -0.02166701f, 0.04126500f, 
    0.03440320f, -0.01269525f, -0.06069186f, -0.03607315f, 0.01051773f, -0.00821732f, -0.05279474f, -0.06106103f, 
    -0.01379597f, -0.03824884f, -0.05534394f, 0.02353747f, -0.01546866f, -0.05907191f, 0.01252639f, 0.01013112f, 
    -0.04730895f, -0.00598002f, -0.02870012f, -0.05623161f, 0.00572741f, -0.04438457f, 0.01914986f, -0.01384415f, 
    0.04061558f, 0.02760818f, -0.02000094f, 0.04961542f, 0.03316508f, 0.01885604f, 0.02580944f, 0.01107029f, 
    -0.04047920f, -0.00719317f, 0.03104447f, 0.03067194f, 0.02464154f, 0.03659121f, -0.02261486f, 0.01483540f, 
    0.04296493f, 0.02698927f, 0.00085140f, 0.01913905f, -0.02764065f, -0.05251526f, -0.04986453f, -0.03835966f, 
    -0.04302986f, -0.04193245f, -0.01588175f, 0.01226974f, -0.06138913f, -0.00292876f, -0.06048501f, -0.05714663f, 
    -0.03763695f, -0.00391692f, -0.05088806f, 0.04465232f, -0.04226881f, -0.00267636f, 0.02232770f, -0.00524484f, 
    0.04865966f, 0.01064811f, 0.01000385f, 0.02603439f, -0.04153364f, -0.01324435f, 0.01316433f, 0.02149381f, 
    0.04733341f, 0.04534395f, 0.00783218f, 0.03895108f, 0.04058743f, -0.04079481f, 0.02645503f, 0.02864074f, 
    0.01995761f, -0.03521664f, 0.00597981f, -0.04195994f, -0.05954748f, -0.01408623f, 0.02022724f, 0.02131844f, 
    -0.04077606f, -0.04028408f, -0.04505997f, 0.00888486f, 0.03430207f, -0.00884729f, 0.01107917f, -0.05598778f, 
    -0.07159411f, -0.23771638f, 0.07023170f, -0.05812572f, 0.03500500f, 0.04580033f, 0.18670395f, -0.12592566f, 
    0.11103341f, 0.12857106f, 0.15587460f, 0.00705033f, 0.04864042f, 0.18702632f, -0.09353894f, -0.21320494f, 
    -0.02073424f, -0.06108122f, -0.40991241f, -0.24115770f, -0.16237172f, -0.16986112f, 0.01960541f, -0.07491053f, 
    0.12597352f, -0.12731412f, -0.07159391f, 0.19235319f, 0.11393495f, -0.10590005f, 0.10971358f, -0.00536732f, 
    -0.03107349f, 0.13606542f, 0.01109001f, 0.05840387f, -0.23786809f, 0.22324018f, -0.43162176f, -0.17058654f, 
    -0.01197341f, 0.00492605f, 0.05806924f, -0.05843722f, 0.03519437f, 0.61410618f, 0.22918813f, 0.18810610f, 
    0.02762162f, 0.11448381f, 0.26051569f, 0.15802914f, -0.01449294f, 0.04445131f, 0.60584515f, 0.32189357f, 
    0.23026888f, 0.12086170f, -0.04023197f, -0.06758594f, 0.15197882f, 0.11527220f, -0.04934873f, 0.35008940f, 
    -0.12118003f, -0.08600395f, -0.15735134f, 0.08946738f, -0.07256196f, 0.23455577f, 0.06855051f, 0.02261411f, 
    0.01806905f, 0.06652044f, -0.75530332f, -0.11086845f, -0.00368274f, 0.15468732f, 0.23536302f, 0.12008178f, 
    -0.09966520f, 0.11920488f, -0.16622198f, -0.64442706f, 0.09712513f, 0.20241666f, -0.15435618f, 0.05231673f, 
    0.01634825f, -0.12233382f, 0.14822352f, 0.32413626f, -0.23060872f, -0.11948004f, 0.08853238f, 0.15126337f, 
    0.09143077f, -0.14135863f, 0.18541262f, 0.00261205f, -0.00127283f, -0.12550113f, 0.03142326f, 0.12127016f, 
    0.02543869f, -0.01831620f, -0.15995969f, 0.15819027f, 0.59131330f, 0.18600820f, 0.20070432f, 0.09640834f, 
    0.46561584f, 0.11194249f, 0.12262162f, 0.00900650f, 0.13714552f, 0.17541540f, -0.20237921f, 0.50382382f, 
    -0.09077006f, 0.08151693f, 0.09275019f, -0.09476902f, 0.16057122f, -0.27421096f, -0.20812130f, 0.05956651f, 
    0.06500064f, -0.17302158f, -0.04342444f, -0.01428810f, -0.02534283f, 0.14313112f, -0.09325726f, 0.80213046f, 
    0.20680076f, 0.09562682f, 0.12970129f, -0.14906919f, -0.08447926f, -0.07171136f, 0.01295626f, 0.15424220f, 
    0.41653988f, 0.15277384f, 0.24997629f, 0.08066248f, 0.18932654f, 0.04350043f, -0.03240857f, 0.11654494f, 
    -0.09455223f, -0.90931141f, -0.44994962f, -0.10333794f, -0.13497332f, -0.08179949f, -0.22369806f, -0.02231669f, 
    -0.03300408f, 0.05805407f, 0.46874607f, 0.26306954f, -0.25389296f, 0.19464177f, 0.05557369f, 0.09896445f, 
    0.16787101f, -0.19066140f, 0.03386910f, 0.15898129f, -0.35985330f, -0.22111981f, -0.01635295f, 0.03341130f, 
    -0.09831341f, 0.30863830f, 0.05647540f, -0.06686107f, -0.46416399f, 0.52028102f, -0.23209277f, -0.22966895f, 
    -0.11356694f, -0.02938943f, 0.04085127f, -0.30843014f, -0.03015985f, -0.18941069f, 0.15816835f, -0.02936360f, 
    -0.27964693f, -0.13404515f, 0.22548443f, -0.15596269f, 0.18485555f, 0.12651116f, -0.03726479f, -0.21007594f, 
    -0.46445510f, 0.11028104f, -0.10967444f, -0.16154681f, -0.15752257f, -0.04643225f, 0.12927103f, 0.17913888f, 
    -0.16233127f, 0.15279093f, -0.17439501f, 0.00776562f, 0.24244612f, 0.00529149f, 0.05032013f, 0.11629273f, 
    -0.44494289f, -0.17081386f, 0.06387119f, 0.18560362f, 0.17147519f, 0.03862149f, -0.09539955f, 0.00191935f, 
    0.03077908f, -0.15943678f, -0.00782815f, -0.04272188f, -0.00083248f, -0.06230140f, -0.11230360f, -0.02468737f, 
    -0.06658868f, 0.11167085f, -0.24024007f, 0.20005597f, -0.10705440f, 0.00253216f, 0.05509356f, 0.15179068f, 
    -0.02346371f, -0.11730982f, -0.05437220f, 0.05823578f, -0.17684193f, 0.11878399f, -0.00438296f, 0.10816282f, 
    0.19498642f, -0.20619243f, -0.02280669f, -0.00067006f, -0.38625526f, -0.20548284f, -0.11501382f, -0.10087177f, 
    -0.07250112f, 0.09707412f, 0.19876251f, -0.17715602f, 0.08644871f, 0.32313225f, 0.19020750f, -0.13036451f, 
    0.14502336f, 0.13463801f, 0.01033020f, -0.08389670f, -0.12650312f, 0.06591514f, -0.58489293f, -0.51112288f, 
    -0.39667940f, -0.07092151f, 0.13432151f, 0.00185019f, -0.26062179f, -0.05172881f, -0.15286393f, -0.10421467f, 
    -0.08949075f, 0.14035277f, 0.07322748f, 0.19868569f, -0.11721794f, -0.11005167f, -0.12758826f, 0.01651621f, 
    -0.03464581f, 0.03761509f, -0.06067710f, -0.04376434f, -0.04697188f, 0.01282918f, -0.00661022f, -0.00730191f, 
    0.00012201f, 0.00407941f, -0.02671061f, 0.02106926f, 0.02727025f, 0.00584123f, 0.02004323f, -0.01863197f, 
    -0.03978917f, -0.04623326f, -0.02860392f, -0.01107123f, -0.01625695f, 0.01950986f, -0.05619750f, 0.03762461f, 
    -0.05122564f, 0.04718463f, -0.05393976f, 0.00966192f, 0.02299913f, -0.03729182f, 0.00734579f, -0.03815240f, 
    0.01142978f, -0.01034624f, 0.02690946f, 0.03554818f, -0.01919668f, -0.05714101f, -0.05409390f, -0.06426097f, 
    -0.05589950f, 0.04390557f, -0.03782409f, -0.03019098f, -0.03491872f, -0.02768812f, 0.04643909f, 0.01793718f, 
    0.05197541f, 0.00777422f, 0.01998545f, -0.04623587f, 0.03582149f, -0.01018843f, 0.00000109f, 0.01508305f, 
    -0.06467736f, -0.00966971f, 0.01307743f, -0.04812236f, -0.04557367f, 0.02269861f, 0.00281122f, 0.02044615f, 
    -0.00654361f, 0.04391646f, 0.00612907f, 0.03560460f, -0.03346068f, -0.01979821f, -0.06083913f, -0.02198153f, 
    -0.00368083f, -0.02536581f, 0.00141878f, -0.02305712f, -0.02265009f, -0.03824692f, 0.01438501f, 0.03300821f, 
    0.02209420f, 0.05021921f, 0.03498121f, -0.04831287f, -0.04363531f, 0.03949103f, -0.04888415f, -0.03565693f, 
    -0.03426289f, 0.04496772f, 0.02237368f, -0.03370084f, -0.06410182f, -0.04412406f, -0.04935954f, -0.00924223f, 
    0.00632970f, 0.02259198f, -0.01881713f, 0.00411263f, -0.04032443f, -0.03548429f, 0.01086110f, -0.06802832f, 
    0.04014247f, -0.02059355f, 0.01329263f, 0.01368890f, 0.00079763f, 0.01400003f, -0.02196577f, 0.02993562f, 
    -0.03861192f, -0.03772990f, 0.01885607f, 0.04454282f, -0.01560992f, 0.00538208f, 0.00299658f, 0.03559306f, 
    -0.00539182f, -0.04799424f, -0.04292462f, -0.01388698f, 0.02497814f, 0.03629697f, 0.03255792f, -0.02137420f, 
    -0.03260900f, 0.04831994f, -0.05832913f, 0.04714142f, -0.04916891f, -0.03705110f, -0.02941365f, 0.03950235f, 
    0.04751234f, 0.00503907f, 0.02548470f, -0.05841181f, -0.01766291f, -0.04837172f, -0.00796783f, -0.01474427f, 
    -0.00981151f, -0.04289390f, 0.04917131f, 0.02648498f, -0.02251727f, -0.01570278f, -0.06593115f, -0.04601081f, 
    -0.05841846f, 0.02400186f, 0.01791130f, -0.02871073f, -0.03171035f, -0.04118726f, -0.01321042f, -0.00176545f, 
    -0.03612911f, -0.04931940f, 0.03198357f, -0.00530451f, 0.02180956f, -0.02225120f, 0.02014970f, -0.00138548f, 
    0.03314139f, 0.00486828f, -0.01204161f, -0.04345435f, -0.04018033f, -0.00730800f, -0.06617811f, 0.03118175f, 
    0.00804355f, 0.03527290f, 0.00367957f, -0.04123708f, -0.00889276f, -0.03308930f, -0.02482378f, 0.02457348f, 
    -0.03975539f, -0.03394176f, -0.00897876f, 0.00112800f, -0.02016923f, -0.04043465f, 0.04875363f, 0.01708956f, 
    0.00577344f, 0.01979276f, -0.05547666f, -0.00735475f, 0.02603179f, 0.00686007f, -0.02084154f, 0.04545397f, 
    -0.01933576f, 0.03037594f, -0.05538106f, -0.01531975f, -0.03935735f, -0.01053352f, 0.00580507f, -0.01524623f, 
    -0.00194228f, -0.02652970f, -0.05844542f, 0.04113695f, -0.03153196f, -0.05618443f, -0.00552546f, -0.05744462f, 
    0.04374406f, -0.03242079f, 0.03769910f, 0.04152519f, -0.05227836f, -0.06392975f, -0.02714859f, 0.03418836f, 
    0.02880946f, -0.00375878f, 0.04897499f, 0.04413647f, -0.04170628f, 0.00527977f, 0.01279114f, -0.01847065f, 
    0.00884386f, -0.04599115f, 0.03346936f, 0.00850500f, 0.03207376f, -0.05164342f, -0.03623005f, -0.02030813f, 
    0.03271986f, -0.05290486f, 0.01496936f, 0.01822655f, 0.04670620f, -0.03292679f, 0.01657607f, 0.02157328f, 
    -0.06744502f, -0.06170006f, 0.00289822f, 0.01817406f, 0.00669878f, -0.05229878f, -0.01509976f, -0.05373678f, 
    0.00257533f, -0.01017539f, 0.01539764f, 0.03370035f, 0.02578187f, -0.06446654f, 0.00941395f, -0.05374138f, 
    -0.02972525f, 0.00063988f, 0.04548305f, -0.04564781f, -0.05841684f, -0.03865745f, -0.06212644f, -0.04847406f, 
    -0.04935937f, -0.03753895f, -0.01125920f, 0.00829781f, 0.03126743f, -0.00643480f, -0.00030460f, -0.03121714f, 
    0.02425672f, 0.01298313f, 0.03217397f, -0.05214749f, 0.04419174f, -0.04942983f, -0.03989051f, 0.02442951f, 
    0.08866892f, 0.11501916f, 0.16935353f, 0.00785606f, 0.19836092f, -0.15632281f, -0.15715589f, 0.09813228f, 
    -0.08362818f, 0.07067851f, 0.07887782f, 0.00217461f, -0.09137795f, 0.01715226f, -0.00102382f, 0.07382815f, 
    0.12212735f, 0.07320402f, 0.11673892f, -0.10907035f, 0.24549779f, 0.06751616f, -0.11238741f, 0.04789121f, 
    -0.15863723f, 0.09383049f, 0.08056479f, 0.10419217f, 0.15260874f, -0.15711519f, -0.10751729f, 0.06464003f, 
    -0.04321053f, 0.05110490f, -0.11338501f, -0.05689017f, 0.25963494f, -0.23659116f, -0.01875736f, -0.18605261f, 
    0.03328506f, -0.25399783f, 0.19122082f, 0.22032428f, -0.08587462f, 0.21956325f, -0.12812287f, -0.69306755f, 
    0.04267129f, 0.06274392f, -0.02746715f, 0.18252033f, -0.00961188f, -0.14334545f, -0.10976733f, 0.07055478f, 
    -0.07829411f, 0.18623149f, -0.02074788f, 0.01969969f, -0.10839356f, 0.01123182f, 0.03071626f, 0.18971598f, 
    -0.08681383f, 0.10760693f, 0.13705255f, 0.13091847f, 0.19254002f, 0.15198989f, 0.01029772f, -0.25464651f, 
    -0.01131069f, -0.05553085f, 0.09690339f, 0.12653461f, -0.15968674f, 0.04837150f, -0.04840527f, -0.02981244f, 
    0.12876776f, -0.10286745f, -0.05377121f, 0.05846203f, -0.21730827f, 0.13879769f, -0.19740434f, -0.08633637f, 
    0.03225178f, 0.13630369f, 0.07201134f, -0.08083836f, -0.14866686f, -0.13790889f, -0.00278190f, -0.16200471f, 
    0.22336856f, 0.09291578f, -0.20280617f, 0.19588786f, 0.02118190f, 0.24596106f, -0.17881738f, 0.05347558f, 
    0.01191773f, 0.07564425f, 0.00977910f, 0.31735918f, 0.12615585f, -0.12680297f, -0.30214915f, 0.04538874f, 
    0.13503796f, 0.11345094f, -0.00751966f, -0.08782347f, -0.17937742f, 0.22717483f, 0.05131155f, 0.14512919f, 
    -0.30425900f, 0.05536577f, -0.07585140f, 0.09930493f, 0.21422929f, -0.26929677f, -0.15363777f, 0.05337775f, 
    -0.31046742f, 0.19179851f, -0.01099482f, 0.14279036f, 0.00137568f, -0.07143132f, 0.08163103f, 0.34145945f, 
    0.02416774f, -0.12054573f, 0.10256636f, 0.03943880f, -0.17727141f, 0.08666910f, 0.08081218f, -0.06305185f, 
    -0.17985731f, 0.02676470f, -0.14603257f, 0.09619103f, 0.00047294f, 0.07846753f, 0.02993457f, 0.06041990f, 
    -0.12431400f, -0.28588471f, 0.03098828f, -0.07118978f, -0.10960934f, 0.00906615f, 0.17281689f, -0.05690512f, 
    0.09963470f, -0.15082453f, 0.18157390f, -0.06866732f, 0.00097870f, -0.04774697f, -0.13117069f, -0.14059234f, 
    0.00698620f, 0.09378488f, -0.11837056f, 0.06516540f, -0.15582021f, 0.24235268f, -0.18695796f, 0.05985255f, 
    0.08267127f, -0.03454341f, -0.17156762f, 0.19225170f, 0.10791326f, -0.12531193f, 0.19194181f, -0.17579842f, 
    -0.02679474f, 0.15836953f, -0.02149978f, 0.08330776f, 0.17069100f, -0.14672436f, -0.03024645f, 0.20469286f, 
    -0.39506918f, 0.23360175f, 0.09393086f, -0.21972351f, -0.03263109f, 0.02547466f, 0.14128585f, -0.06909442f, 
    0.16664030f, 0.11908803f, 0.09213253f, -0.00376435f, 0.12812579f, 0.09076300f, -0.07772129f, -0.15226042f, 
    -0.05944851f, -0.33706924f, 0.03026571f, 0.06930233f, 0.18261242f, -0.06930230f, -0.14852917f, -0.18527149f, 
    0.30596739f, 0.13687399f, -0.22134462f, -0.06059209f, 0.01733188f, 0.15635756f, -0.05191796f, -0.06440901f, 
    -0.10820989f, 0.16997056f, 0.27193612f, 0.16319178f, -0.36274633f, 0.18037517f, -0.03313119f, -0.14741795f, 
    -0.03065630f, -0.12239158f, 0.21665168f, -0.14084145f, -0.17494518f, -0.07448728f, 0.12609793f, -0.26287770f, 
    -0.01703424f, 0.10342229f, 0.16501059f, -0.41638541f, -0.08362417f, -0.15492854f, 0.14053185f, 0.03900302f, 
    0.19737142f, 0.07808650f, -0.03102539f, -0.40138650f, 0.07075467f, 0.01943981f, -0.01197167f, 0.09419307f, 
    0.12969598f, 0.21445452f, -0.07426495f, 0.14313157f, -0.39678127f, 0.06974842f, 0.06532409f, 0.00745931f, 
    0.06133238f, -0.07614503f, 0.01581283f, 0.04113498f, 0.14495513f, -0.05742934f, -0.33662426f, 0.10782873f, 
    0.03217687f, -0.23562807f, -0.05429398f, 0.17699957f, -0.08997746f, 0.10801183f, 0.18239479f, 0.15807189f, 
    0.08798060f, 0.15018913f, 0.08357943f, -0.15153581f, 0.09752010f, -0.37010774f, 0.12644115f, -0.36063072f, 
    -0.45422843f, 0.00740127f, 0.05080733f, -0.00657171f, 0.04170024f, -0.24792674f, 0.01523283f, 0.12421978f, 
    0.01839914f, 0.16355704f, 0.15269285f, 0.11499656f, -0.06694513f, 0.05962126f, -0.02556027f, 0.10735968f, 
    0.03047648f, 0.31270105f, -0.24164419f, 0.10291081f, -0.42653474f, 0.36092883f, 0.22212973f, 0.10488793f, 
    -0.17385347f, 0.01642928f, -0.10203107f, -0.05202837f, 0.12752825f, 0.32613114f, -0.11837989f, 0.04058632f, 
    0.12076073f, 0.00030200f, 0.15665656f, 0.17803289f, 0.10417367f, -0.29190582f, -0.21467900f, 0.07140986f, 
    -0.14606380f, -0.08541240f, -0.00250874f, -0.11267582f, 0.39052185f, 0.02509303f, 0.17310685f, 0.27080002f, 
    0.01683045f, 0.28583604f, -0.15139075f, 0.08424837f, 0.04705365f, -0.04230162f, -0.16431646f, 0.19867727f, 
    0.44531882f, 0.28501973f, 0.24535941f, -0.03736974f, -0.07203571f, 0.00722634f, -0.01144897f, 0.07163856f, 
    0.21629901f, 0.22740301f, 0.07938745f, 0.21005346f, 0.06444693f, -0.06484590f, 0.11585505f, 0.08415870f, 
    -0.30938074f, -0.17603618f, -0.05812469f, 0.19801307f, 0.01062446f, -0.02728469f, 0.22064820f, 0.11212756f, 
    0.35088140f, -0.31524688f, 0.02073596f, 0.15862928f, 0.47440401f, 0.12098733f, 0.15385245f, 0.04458127f, 
    0.02090375f, -0.03877461f, 0.09810462f, -0.07201608f, -0.11637606f, -0.47567230f, -0.12408098f, -0.06042654f, 
    0.06999189f, 0.09485672f, 0.08743029f, -0.12830515f, 0.11926730f, 0.19100915f, -0.06417234f, 0.16204396f, 
    0.10821394f, -0.29289520f, 0.26414096f, 0.21315981f, -0.26590729f, -0.06790379f, 0.10332741f, 0.12981653f, 
    0.21745431f, 0.20282750f, 0.10677421f, 0.07111268f, -0.19184352f, -0.49874631f, -0.13810998f, 0.21466598f, 
    -0.02037928f, -0.23781011f, -0.07970721f, -0.13552712f, -0.21608540f, -0.09914917f, -0.22291425f, 0.16722147f, 
    -0.11376403f, -0.29744112f, 0.07040652f, 0.04261256f, -0.02407560f, -0.03375848f, 0.01202998f, -0.25274572f, 
    0.12824203f, 0.16393529f, -0.12342394f, -0.01531358f, 0.09532717f, -0.27205449f, -0.09391166f, -0.10678522f, 
    0.01841586f, 0.22378793f, 0.17523980f, 0.16363800f, 0.12932952f, 0.04253082f, 0.22561035f, -0.02382441f, 
    -0.11492319f, 0.24829111f, 0.12393612f, 0.21452354f, 0.06777310f, 0.06132075f, 0.09232476f, 0.14098203f, 
    -0.24069695f, -0.13105613f, 0.10799868f, 0.16916320f, 0.09161291f, -0.39007998f, 0.00109125f, -0.04137784f, 
    -0.21473573f, -0.08703808f, 0.15936716f, -0.00571584f, 0.18267646f, -0.10424804f, 0.30166680f, 0.01360319f, 
    -0.08900907f, 0.47073805f, 0.00102716f, 0.16418110f, -0.29068440f, -0.21138668f, -0.11031573f, 0.16499172f, 
    0.11085229f, 0.02650378f, -0.21215129f, -0.01841745f, 0.08531497f, -0.01314528f, 0.27534789f, -0.24400936f, 
    0.14191768f, 0.14333442f, 0.02598853f, 0.06950717f, -0.04747432f, 0.17994413f, -0.14607823f, -0.28915936f, 
    -0.25672081f, -0.26071957f, -0.21937928f, -0.18841544f, -0.04598015f, 0.04227922f, 0.20502503f, 0.13416873f, 
    0.05190654f, -0.10071892f, 0.06058348f, 0.02983524f, -0.02676704f, 0.05426807f, -0.11532195f, -0.08366811f, 
    0.21735904f, 0.09327547f, 0.37843081f, -0.10050692f, 0.13176270f, -0.10005599f, 0.15761003f, 0.09540772f, 
    0.26900771f, -0.05850114f, -0.17851354f, -0.33236489f, 0.13796134f, 0.02037572f, -0.21262793f, 0.04578521f, 
    0.17961539f, 0.19110821f, -0.81496519f, -0.40583667f, -0.28887090f, 0.41138500f, 0.12589148f, 0.13357204f, 
    -0.04900105f, -0.11598098f, -0.05965307f, 0.26761013f, 0.05078988f, 0.04859943f, 0.05210885f, 0.08562758f, 
    0.04069863f, 0.23750871f, 0.00260687f, -0.07187589f, -0.16860045f, 0.08056299f, 0.00066984f, 0.15036371f, 
    -0.01989746f, -0.02964768f, 0.15964933f, -0.01698931f, 0.03950152f, 0.20962280f, 0.38824034f, 0.24459080f, 
    -0.21929453f, 0.17413582f, 0.00703414f, -0.03185460f, 0.07951747f, 0.37020504f, -0.38481611f, 0.07826440f, 
    -0.54370940f, 0.09012326f, 0.17008571f, 0.30158344f, -0.00396480f, -0.43931988f, 0.06438306f, -0.08194835f, 
    -0.15005566f, -0.14142622f, -0.26759762f, -0.15732956f, 0.08004291f, -0.16426215f, -0.25981009f, -0.20143531f, 
    -0.00668883f, -0.02359217f, -0.02897354f, 0.00243023f, -0.03511089f, 0.01370120f, 0.00304407f, -0.03539976f, 
    0.01683110f, -0.02649994f, -0.00587022f, -0.00662360f, 0.04651286f, -0.02726481f, 0.03297811f, -0.05829707f, 
    -0.00215444f, -0.04441891f, 0.02186365f, -0.04284086f, -0.01666866f, 0.03235340f, -0.06347398f, -0.02949488f, 
    -0.03586322f, 0.04863994f, -0.04378453f, -0.02598407f, -0.02365584f, -0.01908083f, -0.01296251f, 0.01684742f, 
    0.04916907f, -0.02228920f, -0.00278677f, 0.04984298f, -0.02567076f, -0.02870132f, -0.00829659f, -0.00018183f, 
    0.01948445f, -0.01057130f, -0.02225235f, 0.00981428f, 0.01011616f, 0.02208781f, 0.04571268f, 0.03907012f, 
    0.00980860f, -0.04771377f, 0.02798003f, -0.01634856f, -0.01136077f, -0.01851644f, 0.00530539f, 0.01037742f, 
    -0.01988549f, 0.03876398f, 0.01229027f, 0.03328279f, 0.02286690f, 0.00574896f, 0.00708004f, -0.05980372f, 
    -0.04719480f, 0.04276540f, -0.05606519f, -0.03963390f, -0.00071126f, 0.01296553f, -0.04490349f, 0.01326836f, 
    -0.02745271f, -0.04252134f, 0.04371277f, -0.02913641f, 0.04595578f, -0.00409090f, 0.01590681f, 0.00575618f, 
    0.01181060f, 0.02033086f, -0.01856029f, 0.00748891f, -0.00775586f, -0.00226127f, -0.04256906f, -0.05570237f, 
    -0.01333561f, 0.02682713f, -0.02904689f, 0.00620341f, 0.01053126f, 0.03145986f, -0.03548900f, 0.00065111f, 
    0.03690950f, -0.01506727f, 0.00031658f, -0.03865951f, -0.06224740f, -0.03444234f, -0.05110974f, 0.05129810f, 
    -0.05091285f, -0.00911087f, 0.00754629f, -0.02932523f, -0.01215886f, 0.02591028f, -0.05528235f, 0.01940883f, 
    0.00107101f, -0.04960854f, 0.02631536f, 0.04950953f, -0.00036474f, -0.05064056f, -0.02902763f, -0.03897284f, 
    0.04471461f, 0.00211490f, -0.05432929f, -0.05387527f, -0.00543978f, -0.03251559f, -0.01958266f, 0.04552044f, 
    -0.06470256f, 0.04096876f, -0.06174775f, 0.02359366f, 0.04155684f, 0.01888639f, 0.00610359f, -0.00216011f, 
    0.00692142f, -0.00868178f, 0.03259447f, -0.01856378f, 0.04086546f, 0.03542884f, -0.00604158f, 0.03953318f, 
    -0.06149862f, 0.00602183f, -0.04190962f, -0.02544908f, -0.02343467f, -0.00344100f, 0.00878461f, 0.02662719f, 
    0.03917993f, -0.04461155f, 0.02962548f, -0.03512395f, -0.00699942f, 0.00794046f, -0.03748525f, -0.03034457f, 
    -0.01338906f, 0.03287845f, 0.03251905f, -0.02314128f, 0.00403447f, 0.00360950f, -0.04057569f, 0.03666758f, 
    -0.04522470f, -0.04255147f, -0.04376209f, -0.00084068f, 0.04643426f, 0.02442204f, -0.04554678f, -0.02115806f, 
    0.01017690f, -0.01751299f, -0.04676111f, 0.02231501f, -0.04311858f, 0.04283917f, -0.04342375f, 0.03677733f, 
    0.01760038f, -0.00954178f, -0.02970721f, -0.02709360f, -0.05325469f, 0.00916087f, 0.02522350f, -0.04970394f, 
    -0.00836028f, -0.01330340f, -0.04567179f, 0.00455329f, 0.01857129f, -0.05318169f, -0.03462424f, 0.04380762f, 
    -0.03629863f, 0.00970160f, 0.02770950f, -0.06090714f, 0.02170917f, -0.00214431f, -0.05894870f, 0.00307842f, 
    -0.05976640f, 0.01559125f, 0.02327514f, -0.05867668f, 0.02599827f, 0.03763742f, 0.05380056f, 0.04677656f, 
    0.00997350f, -0.04428741f, 0.04994560f, 0.01479204f, 0.04727689f, 0.02455454f, -0.02165057f, 0.03180879f, 
    -0.06287947f, -0.06091578f, 0.01352353f, 0.00415212f, -0.04794542f, -0.00420038f, -0.00355531f, -0.05049798f, 
    0.02987375f, -0.05437244f, -0.02987369f, -0.02483401f, -0.02168364f, -0.03905468f, -0.04426841f, -0.04957718f, 
    0.03879171f, -0.06616970f, -0.04623720f, -0.01446036f, -0.00064825f, -0.01401288f, -0.03307792f, 0.03474442f, 
    -0.05872970f, -0.04103841f, 0.02651722f, -0.01467302f, 0.03492928f, -0.01359917f, -0.01591375f, -0.01786987f, 
    -0.04214460f, -0.05231565f, 0.03691147f, 0.04264690f, -0.06434540f, -0.01879766f, 0.03276509f, -0.01892516f, 
    -0.01211017f, -0.01069895f, 0.03468566f, 0.01641450f, 0.02712300f, 0.00136264f, 0.00084019f, 0.02937807f, 
    0.02893802f, 0.00064145f, 0.04316038f, -0.01557846f, -0.01560759f, 0.02654465f, -0.02236516f, 0.00595036f, 
    -0.05913591f, 0.04099242f, 0.05099365f, 0.05265721f, 0.04463216f, -0.04036812f, 0.02085704f, 0.00695118f, 
    0.02775948f, -0.03395994f, 0.01886449f, -0.05409937f, -0.03675372f, -0.01066747f, -0.01940178f, -0.05820650f, 
    0.00807437f, -0.06213085f, 0.01698428f, -0.02817539f, 0.04050216f, -0.00339264f, -0.00992638f, 0.01063574f, 
    0.01621357f, -0.05831152f, -0.00893357f, -0.04532063f, -0.04766613f, 0.02077714f, -0.00146638f, 0.01390834f, 
    -0.00044579f, -0.01419060f, 0.01104739f, 0.02569146f, -0.03525569f, -0.06284542f, -0.02483190f, 0.00599617f, 
    -0.01701334f, -0.03364287f, 0.02927680f, 0.00056899f, 0.04048434f, 0.04957234f, -0.03375864f, -0.00499936f, 
    0.05030552f, -0.04761448f, -0.03292252f, -0.02229147f, 0.03003413f, -0.06019745f, -0.01721119f, 0.04139776f, 
    -0.00605069f, -0.02731171f, -0.00776033f, 0.04898533f, -0.03482049f, -0.00675211f, -0.05382548f, 0.01317428f, 
    0.03132730f, -0.05600700f, 0.01204227f, -0.06093999f, -0.02844303f, -0.05238164f, -0.04910406f, -0.03460212f, 
    -0.03563425f, 0.04160466f, 0.02195712f, -0.02816263f, -0.00307278f, -0.05685321f, -0.05317180f, -0.01925971f, 
    0.03300551f, -0.06122565f, -0.00715979f, 0.02725214f, -0.00064910f, 0.02023089f, 0.01948730f, -0.04858959f, 
    -0.05521581f, 0.01596266f, 0.04684273f, -0.03733671f, 0.01606519f, -0.01621271f, -0.05392130f, -0.01365034f, 
    0.02566101f, 0.05105593f, 0.02086676f, 0.03180891f, -0.02008981f, 0.03280598f, -0.01701480f, 0.01657520f, 
    -0.02568848f, -0.01573070f, -0.04156915f, 0.00098437f, 0.04435584f, -0.04924062f, -0.03693907f, -0.03303298f, 
    -0.00330433f, -0.00866994f, -0.06464025f, -0.02866170f, -0.05523453f, -0.03601528f, -0.04148374f, -0.02858504f, 
    -0.00288129f, 0.04480560f, 0.05018907f, -0.03097792f, -0.04039817f, -0.02638817f, -0.06007797f, -0.03663297f, 
    0.03675106f, 0.03133499f, 0.02624927f, -0.05077147f, 0.04372695f, 0.03280992f, -0.03671267f, 0.05572404f, 
    -0.02141831f, 0.00987983f, 0.01194161f, -0.04395066f, -0.02988733f, 0.03101362f, 0.04880071f, 0.02010294f, 
    -0.01677253f, -0.04904731f, -0.02548122f, 0.03466774f, 0.03736915f, -0.04066081f, -0.02828174f, 0.03716613f, 
    0.00447301f, -0.04388377f, 0.04237454f, -0.02072052f, -0.02832033f, 0.03608073f, -0.03222625f, 0.00095207f, 
    0.03164747f, -0.02546605f, 0.02018224f, -0.05132507f, 0.04817007f, 0.01289066f, 0.01755555f, -0.04740123f, 
    -0.03284003f, 0.03348096f, -0.04616371f, 0.05209661f, 0.00258035f, 0.02524652f, -0.03474206f, -0.00758932f, 
    0.01433803f, -0.05628938f, -0.01898442f, -0.04951023f, 0.00505847f, 0.00024604f, -0.02466590f, -0.01725337f, 
    -0.00523446f, -0.01008262f, 0.02084867f, -0.00889049f, 0.01095544f, -0.05544739f, -0.02049982f, -0.04166469f, 
    0.00423130f, 0.00965447f, -0.06138966f, -0.02681741f, 0.01759050f, -0.05307453f, 0.01326611f, -0.04410271f, 
    -0.02476901f, -0.02033314f, 0.01477535f, -0.04104429f, -0.00615926f, -0.00894686f, -0.05215200f, -0.03698999f, 
    0.01103426f, 0.00796012f, 0.02295983f, 0.02953442f, 0.01639832f, -0.02698959f, -0.06031144f, 0.04172735f, 
    -0.00450531f, 0.02142304f, -0.04906271f, -0.03776357f, -0.02038150f, -0.02040322f, 0.02780607f, 0.03628775f, 
    0.01173178f, -0.00919518f, -0.05968636f, -0.00824399f, 0.05008043f, -0.02991809f, 0.02254254f, -0.02864958f, 
    0.00917261f, -0.03719609f, -0.04183550f, 0.01720997f, 0.02640368f, 0.00224048f, 0.03751227f, 0.04510720f, 
    -0.00654359f, 0.00121125f, -0.04707599f, -0.03470330f, 0.04334189f, -0.04995845f, -0.03533239f, 0.04247342f, 
    0.03808297f, -0.01898132f, 0.05125014f, -0.02905053f, 0.05237018f, -0.04207433f, -0.05145240f, -0.02585657f, 
    -0.03499223f, -0.01030065f, -0.04270643f, 0.02442491f, 0.01859607f, 0.03995996f, -0.02738997f, -0.02893512f, 
    0.01088400f, -0.05115604f, -0.06281232f, -0.02653654f, -0.03322764f, -0.02352047f, -0.00882995f, 0.04781086f, 
    -0.01963574f, 0.04120905f, 0.02623147f, -0.02399472f, -0.06125214f, -0.01013046f, 0.01187254f, 0.00984188f, 
    -0.03627997f, 0.01796578f, 0.04917910f, -0.05222929f, -0.00571043f, 0.04931529f, -0.04720658f, -0.04008979f, 
    0.02063739f, 0.01746335f, -0.03143238f, 0.00799382f, 0.00095757f, 0.00937063f, 0.04598889f, -0.04412659f, 
    0.07669650f, 0.12749752f, -0.22607630f, 0.15460150f, -0.08586849f, -0.17886820f, 0.03784003f, -0.29664323f, 
    0.21334343f, -0.13225198f, -0.43946591f, -0.19474970f, 0.25737056f, -0.13163759f, -0.10040691f, 0.28848428f, 
    0.06581751f, 0.07595903f, 0.15924932f, -0.04771605f, 0.01585565f, 0.05067694f, -0.09028016f, 0.07647143f, 
    0.04318105f, 0.03020990f, -0.10745152f, -0.09019689f, -0.05481698f, 0.13696480f, 0.10370910f, 0.04706052f, 
    0.03500991f, 0.02005894f, 0.07689480f, -0.03110056f, 0.01098640f, 0.15341933f, -0.14179927f, 0.08898296f, 
    0.05411846f, 0.07013396f, -0.19513902f, 0.07202765f, -0.07722340f, -0.25403845f, 0.28617066f, 0.12058296f, 
    -0.08689561f, -0.01536155f, -0.13979121f, -0.20527717f, 0.00446808f, 0.15154843f, 0.33752674f, 0.28389260f, 
    0.14394866f, 0.13903047f, 0.06377390f, -0.08251338f, 0.06168038f, -0.13687809f, 0.07024977f, 0.38066337f, 
    -0.02009776f, -0.00929985f, -0.09978393f, -0.11222672f, -0.01982810f, -0.01724966f, 0.04475854f, 0.08102329f, 
    0.33907822f, -0.07846772f, 0.29480216f, -0.03065439f, -0.15317006f, 0.13774876f, -0.01619779f, -0.10293988f, 
    0.02384605f, 0.09716668f, 0.32983872f, 0.47379547f, 0.16480452f, -0.03702354f, -0.07868218f, -0.09141077f, 
    0.05107689f, 0.28418839f, -0.04409168f, -0.16556951f, -0.10643236f, 0.05820924f, 0.03807490f, 0.14831991f, 
    0.00180488f, -0.09245081f, 0.07537602f, -0.52960342f, -0.38508064f, -0.99138415f, 0.10825342f, -0.03820705f, 
    0.00786381f, 0.04218725f, 0.13333647f, 0.01889409f, 0.17262736f, 0.15362506f, 0.25948641f, 0.17391774f, 
    0.16906615f, 0.15380414f, -0.30287465f, 0.05633065f, -0.19731571f, 0.27868396f, -0.20332803f, -0.69419682f, 
    0.02913608f, -0.12501176f, -0.03387032f, -0.11812676f, -0.02815291f, -0.04288862f, 0.12754796f, -0.39476719f, 
    -0.24096105f, -0.00960187f, 0.01537876f, -0.22073829f, 0.06302715f, -0.00426209f, 0.18879756f, 0.08190641f, 
    0.10276112f, 0.22636825f, -0.05731964f, -0.16322361f, -0.00651677f, 0.02500546f, -0.02620763f, -0.08931748f, 
    0.31037340f, 0.30226234f, 0.24342749f, 0.00181490f, -0.02418631f, -0.01761472f, 0.01348951f, 0.14003104f, 
    -0.06699058f, 0.22014911f, -0.22606084f, 0.12917644f, 0.09006567f, -0.06955034f, 0.05891148f, 0.14552541f, 
    -0.01609722f, -0.20353089f, 0.14962594f, 0.26948103f, -0.03041467f, 0.09315870f, -0.06626940f, -0.05179322f, 
    -0.04051437f, 0.04033093f, -0.17911045f, -0.18551804f, -0.34614363f, 0.44960165f, 0.11508256f, 0.02754989f, 
    0.05549406f, -0.22011729f, 0.15069029f, 0.19407955f, -0.00001394f, 0.21249758f, 0.00910733f, -0.06319792f, 
    0.11623839f, 0.22185749f, 0.13234113f, -0.05636881f, -0.06080003f, 0.29320675f, 0.01409091f, 0.22033961f, 
    0.09785709f, -0.13567886f, 0.00106434f, 0.00765948f, 0.05948709f, -0.04657545f, 0.39057451f, 0.26718685f, 
    -0.28698793f, 0.08707868f, -0.02376950f, -0.15916114f, -0.12821972f, -0.16162843f, 0.10991631f, 0.13813296f, 
    -0.03106405f, 0.07798190f, -0.01992393f, -0.02543471f, -0.11330917f, -0.03766700f, 0.08678272f, -0.13506424f, 
    -0.69350421f, -0.55773979f, -0.63820714f, -0.11385659f, -0.13587710f, 0.04791537f, 0.22136939f, -0.00597479f, 
    -0.04357355f, -0.30295625f, -0.34870377f, -0.20108864f, 0.06061695f, -0.01017330f, -0.10717269f, -0.06534385f, 
    -0.07793542f, 0.02514312f, 0.30888933f, 0.27348632f, 0.34027708f, -0.09973377f, -0.03586481f, -0.02678251f, 
    -0.03561007f, 0.02865659f, -0.01825124f, 0.34340826f, 0.10767094f, 0.27458528f, -0.09371080f, -0.26716763f, 
    -0.02270585f, 0.01608913f, 0.15055251f, -0.19801767f, -0.30943573f, 0.04313303f, -0.23204431f, -0.00761678f, 
    -0.15320022f, -0.08482280f, -0.08375259f, -0.02073197f, 0.16912568f, -0.41885656f, -0.43773508f, -0.33936167f, 
    0.02192174f, 0.10890197f, -0.00347361f, 0.23137818f, 0.12190016f, 0.01368058f, -0.16721056f, -0.16469942f, 
    0.17783923f, -0.22483303f, -0.00847638f, 0.01787838f, 0.13020244f, 0.06379062f, 0.05413940f, 0.14739999f, 
    0.31947231f, -0.17551962f, 0.17133042f, 0.07249832f, 0.09698903f, -0.04454488f, -0.18090405f, -0.03480227f, 
    -0.00010113f, -0.07346340f, 0.04052981f, 0.05881098f, -0.09085662f, 0.00781364f, -0.05872224f, 0.02195166f, 
    -0.05714444f, 0.02040122f, -0.01140220f, 0.01729346f, -0.02327600f, -0.03060473f, 0.00706331f, -0.00782924f, 
    -0.00055655f, -0.02802378f, -0.04717241f, -0.01601510f, 0.02357344f, -0.04686243f, -0.00999410f, -0.03279610f, 
    0.01462578f, 0.02180967f, -0.02701015f, -0.07175526f, -0.02951681f, 0.02425231f, -0.05920003f, 0.03827807f, 
    0.02154888f, -0.07013946f, -0.04448980f, 0.02047846f, 0.03609918f, -0.00646896f, -0.01476334f, -0.02815328f, 
    -0.01510111f, -0.04302105f, -0.02718557f, 0.01835855f, -0.04406052f, -0.00329549f, -0.02687126f, -0.04284133f, 
    -0.01377919f, 0.03685655f, 0.02986415f, -0.02619114f, -0.06848958f, 0.00697563f, 0.03692790f, 0.03789823f, 
    -0.05353412f, -0.07221767f, -0.08115506f, -0.05243907f, -0.01390628f, 0.01353328f, -0.03169549f, -0.05871578f, 
    -0.04288061f, -0.06353965f, -0.06354079f, -0.04461817f, -0.00201283f, -0.01061215f, 0.00143576f, -0.00230369f, 
    0.04071805f, 0.01824070f, -0.05930534f, 0.03844397f, -0.03448433f, 0.01469525f, 0.03380923f, 0.03136095f, 
    -0.05000761f, -0.01438200f, -0.00597825f, -0.01305464f, -0.02566700f, 0.02583579f, -0.05682343f, -0.05961083f, 
    0.01791577f, 0.02369705f, 0.01476521f, 0.04710506f, -0.03037481f, -0.04167158f, -0.00156398f, 0.02725188f, 
    -0.00318236f, -0.05263403f, 0.03888737f, -0.03087762f, -0.05032790f, -0.01979987f, 0.00404995f, 0.02470701f, 
    0.04751247f, -0.01239512f, 0.04601192f, 0.04987895f, 0.05418079f, 0.03936463f, -0.06575461f, -0.05215659f, 
    -0.05647467f, -0.06014357f, -0.05743543f, -0.05259566f, 0.01693390f, 0.03449812f, 0.01122595f, 0.03002902f, 
    -0.02452934f, -0.08735421f, -0.00560615f, -0.00260801f, -0.03066831f, 0.00215496f, -0.00646099f, 0.00261325f, 
    -0.03716186f, 0.05245052f, -0.01919937f, -0.07289668f, -0.02381193f, 0.04674813f, -0.02234332f, 0.00419388f, 
    0.04741742f, -0.04602328f, 0.02729361f, -0.09058576f, -0.01290645f, 0.05468248f, -0.04250095f, -0.02828597f, 
    0.01868460f, 0.00346326f, -0.06371108f, -0.07007932f, -0.03374944f, -0.04493915f, 0.00327465f, -0.06132989f, 
    -0.01680961f, -0.00674176f, 0.02883526f, -0.07581072f, 0.03093212f, 0.01760392f, 0.01329884f, 0.01762161f, 
    -0.00850368f, -0.00908991f, -0.01485628f, 0.04235588f, -0.07343596f, -0.00473653f, 0.02912991f, -0.07608194f, 
    0.03730543f, -0.07077174f, -0.06451502f, 0.01513932f, -0.04268590f, -0.02291177f, 0.03988085f, -0.03989540f, 
    0.00778602f, -0.05624551f, -0.01919720f, -0.01636817f, -0.02249543f, 0.02109580f, -0.01304497f, 0.02943586f, 
    0.00538711f, 0.00242846f, -0.06004693f, -0.02102164f, -0.04688659f, -0.07447754f, -0.00413948f, -0.04051743f, 
    0.03310294f, 0.03889401f, -0.05993509f, -0.01379255f, 0.00313713f, 0.00854986f, -0.05714831f, -0.07798549f, 
    0.05012731f, 0.01355965f, -0.04029600f, 0.01700948f, 0.01007698f, -0.02670305f, 0.00438387f, -0.03613371f, 
    -0.03426148f, 0.02477888f, 0.01432347f, 0.00777025f, 0.01847368f, 0.01577882f, 0.00956821f, -0.03136842f, 
    0.03228445f, 0.02581971f, -0.09428558f, 0.00243469f, -0.02644816f, 0.00192231f, -0.05473496f, 0.00903185f, 
    -0.01459289f, -0.02127190f, -0.02315612f, 0.01137673f, 0.05912704f, 0.00499023f, -0.05216348f, -0.02929276f, 
    0.00066376f, 0.05201792f, -0.04660829f, -0.01797259f, 0.03927037f, -0.02404484f, 0.04994994f, 0.01997187f, 
    -0.05476015f, -0.01331376f, -0.06627789f, 0.01959741f, 0.06808548f, 0.01476214f, -0.04868707f, -0.08453614f, 
    0.02717315f, -0.03471117f, -0.06705463f, 0.02002192f, -0.01969133f, -0.06698168f, -0.06490151f, -0.01835462f, 
    -0.04056513f, -0.01646767f, -0.09191164f, -0.04541963f, 0.04243415f, -0.04557949f, -0.03513485f, -0.00895727f, 
    -0.05104507f, 0.01101292f, -0.01009697f, -0.05149270f, -0.04740707f, 0.02655618f, -0.09794378f, -0.06407773f, 
    0.00553450f, 0.01447158f, 0.02173065f, 0.00639680f, -0.06352986f, 0.03155848f, 0.01673841f, -0.07306430f, 
    -0.00042198f, 0.06815078f, -0.03213403f, -0.05570847f, -0.05794882f, 0.00698055f, 0.02032960f, 0.01449056f, 
    -0.01746670f, 0.02488509f, -0.00745822f, -0.01817454f, -0.00914109f, 0.00602743f, -0.02619941f, 0.01290681f, 
    -0.04061706f, 0.04512930f, 0.02961828f, -0.00019476f, 0.02384949f, -0.06435998f, 0.03472916f, -0.04956650f, 
    -0.06437772f, -0.01399712f, 0.03335423f, -0.00375485f, -0.05495795f, 0.04080069f, 0.01072697f, 0.03793241f, 
    -0.05445193f, -0.04588831f, 0.02068868f, -0.06048097f, -0.03756847f, -0.02093363f, -0.01932115f, 0.03628698f, 
    0.03401560f, -0.04629495f, -0.02849652f, -0.00638860f, -0.04221348f, -0.04605104f, 0.03004550f, -0.04773319f, 
    -0.01198938f, -0.00349890f, -0.04654511f, 0.04761948f, 0.04963746f, 0.02799541f, 0.02060669f, -0.02716267f, 
    0.01315563f, -0.00995662f, -0.00759445f, 0.03004045f, -0.01762140f, -0.03577944f, 0.02259027f, -0.04175264f, 
    -0.04757044f, -0.00613103f, -0.01704279f, -0.05061560f, -0.01770931f, -0.01429947f, 0.02765644f, -0.06146000f, 
    0.04149027f, -0.04175596f, 0.03044531f, -0.06125926f, 0.00301725f, 0.02250066f, -0.05791801f, -0.05136010f, 
    0.01608775f, -0.00775524f, -0.02988438f, -0.04310832f, 0.02722464f, -0.03676175f, 0.04517051f, -0.04590169f, 
    -0.02409381f, 0.02574020f, 0.04779497f, 0.03586087f, 0.00091941f, 0.02966334f, -0.00171344f, -0.01452109f, 
    0.00620242f, 0.03146720f, 0.01787620f, -0.06606571f, 0.02495176f, 0.00429988f, 0.02098608f, 0.00547176f, 
    0.04835265f, -0.03535326f, -0.01205057f, -0.03076795f, 0.01122689f, 0.03396408f, -0.03241097f, -0.02121169f, 
    -0.01963202f, -0.05089299f, -0.06274635f, 0.04422831f, 0.00810713f, 0.02559029f, 0.00575805f, 0.03998639f, 
    -0.01893032f, -0.01236342f, -0.02005495f, -0.06109825f, -0.05601441f, 0.04302108f, -0.06095888f, -0.05303775f, 
    -0.00682649f, -0.05673389f, -0.02239117f, -0.05763771f, 0.01786216f, 0.03842318f, 0.00205918f, -0.02270451f, 
    0.02785632f, -0.05476647f, 0.01093274f, -0.04267474f, -0.00209254f, -0.01946476f, 0.03138709f, 0.01824974f, 
    0.04252907f, 0.03317031f, -0.06722558f, -0.00045279f, -0.01602865f, -0.04294566f, -0.05451603f, 0.04947598f, 
    -0.00757806f, 0.01675626f, 0.03251804f, 0.04147852f, -0.06284066f, 0.04470157f, -0.06693034f, 0.00693309f, 
    0.00365501f, 0.03260044f, 0.03026557f, 0.01616937f, -0.02478141f, -0.03034643f, -0.01788536f, -0.01202080f, 
    -0.04294283f, -0.03250570f, -0.00364996f, -0.04197260f, -0.00414116f, -0.06361189f, 0.04877470f, 0.04812729f, 
    -0.03719635f, -0.04437327f, -0.04312871f, -0.03525221f, -0.00442763f, 0.00536352f, -0.05620786f, 0.02638502f, 
    -0.04919739f, -0.01885464f, 0.00061330f, -0.01138123f, -0.06405925f, -0.00468421f, 0.00466679f, -0.02071196f, 
    -0.06420399f, 0.01370405f, -0.01151525f, 0.01731189f, -0.04020704f, 0.03711277f, -0.00804054f, 0.03134582f, 
    0.01006431f, -0.04856874f, 0.01177118f, -0.05939024f, -0.06348953f, -0.04620679f, -0.06776673f, 0.04174044f, 
    -0.03501817f, 0.03594757f, -0.06241697f, -0.04845301f, -0.05148645f, -0.06113037f, -0.05742089f, -0.01069739f, 
    0.04084149f, -0.06295288f, -0.00233696f, 0.00642425f, 0.00023397f, -0.06289177f, 0.01120555f, 0.04743008f, 
    -0.02156626f, -0.02391336f, 0.00710100f, -0.00632163f, 0.00535156f, -0.04167521f, -0.06362491f, -0.03645446f, 
    0.00420867f, 0.01080165f, -0.00128238f, 0.02816608f, -0.02582110f, 0.03107664f, -0.04831748f, -0.00177214f, 
    -0.03171411f, 0.00133412f, 0.03743256f, -0.01114274f, -0.00331087f, 0.00838471f, -0.01466077f, -0.05737700f, 
    -0.00587717f, 0.03824146f, -0.04777421f, -0.06071951f, -0.05304355f, 0.03534617f, 0.01575337f, 0.02084081f, 
    -0.04389448f, 0.00597171f, -0.05209370f, 0.04042191f, 0.00983014f, -0.04054016f, -0.06632563f, -0.01659334f, 
    -0.04336556f, -0.01234055f, 0.04439934f, -0.00815641f, 0.00188057f, -0.00814535f, 0.03630253f, -0.01819607f, 
    -0.03924152f, 0.01164470f, 0.00449292f, 0.01608854f, 0.04116221f, 0.04850839f, -0.05208610f, 0.01915526f, 
    0.04374404f, 0.01341645f, -0.00300634f, -0.00179238f, 0.01071424f, -0.03613777f, -0.01236499f, -0.04729227f, 
    0.00214912f, -0.04534174f, 0.03851953f, 0.04112814f, -0.02238643f, -0.05966553f, 0.04012965f, -0.05940217f, 
    0.33545229f, -0.60828453f, 0.12944447f, -0.30418941f, 0.06783214f, 0.14865042f, 0.16030109f, 0.14663179f, 
    0.06620935f, 0.16816851f, 0.17260817f, 0.12253924f, 0.11465418f, 0.10521475f, -0.06127565f, -0.16201776f, 
    0.02391163f, 0.16290449f, 0.43927082f, 0.18963099f, 0.17999634f, -0.27606818f, 0.01172597f, -0.06416535f, 
    0.08260027f, -0.05372800f, 0.23426746f, 0.14606638f, 0.11820544f, -0.29738116f, 0.01903692f, 0.00845167f, 
    0.03450963f, 0.02284426f, -0.10672497f, -0.17692938f, 0.24677651f, -0.06207895f, -0.00701779f, 0.05827006f, 
    0.14365290f, -0.02369815f, -0.10006808f, -0.04113563f, 0.10764062f, -0.31492180f, -0.21825607f, 0.19713329f, 
    0.28010932f, 0.25178266f, 0.08568859f, -0.15606338f, -0.13815916f, 0.06988140f, -0.31300709f, 0.02200797f, 
    -0.17721540f, 0.09691780f, 0.09708661f, 0.01393823f, -0.10178128f, -0.10108376f, 0.04861081f, 0.28588241f, 
    -0.17513312f, -0.03191864f, -0.15877424f, 0.26235759f, -0.08178370f, 0.02266878f, -0.03587613f, 0.09403808f, 
    -0.30883014f, -0.20127106f, 0.13523358f, -0.12417828f, 0.08815367f, -0.09190269f, 0.05163065f, 0.15994257f, 
    0.00596387f, 0.00118368f, -0.50708950f, -0.03878853f, -0.02239020f, 0.03995779f, -0.01668947f, -0.15749475f, 
    -0.10292103f, -0.10656177f, -0.37684447f, 0.30369702f, -0.00232949f, 0.13685821f, 0.21244355f, 0.11465322f, 
    -0.10343184f, 0.04185543f, -0.19077723f, 0.03515556f, -0.58498776f, -0.35783467f, 0.06030703f, 0.12550433f, 
    -0.04545446f, 0.08937979f, -0.06787365f, -0.10662221f, -0.37050191f, 0.15815482f, -0.18340929f, 0.07440217f, 
    0.07485886f, 0.09767591f, -0.11177901f, 0.09404172f, 0.17504607f, 0.67282856f, 0.09889813f, -0.42044052f, 
    -0.03742609f, 0.21748635f, 0.22230379f, -0.11729372f, -0.07378580f, -0.03257275f, -0.96543825f, -0.00204199f, 
    -0.14553127f, 0.04174500f, 0.19418934f, -0.01086123f, -0.11171345f, -0.00501854f, -0.07606085f, 0.48544702f, 
    0.27056965f, -0.10091167f, -0.20410176f, -0.16416767f, 0.36397815f, 0.03751547f, 0.14707333f, 0.04699426f, 
    -0.30097094f, 0.00125481f, -0.08207555f, 0.10580458f, 0.01096832f, 0.00578127f, -0.07204178f, 0.11156457f, 
    0.22890820f, 0.30899945f, 0.35642156f, -0.04655596f, 0.00720161f, -0.13715747f, 0.19486441f, -0.06877517f, 
    -0.00789839f, -0.03449534f, 0.00749713f, 0.05227396f, 0.13424857f, 0.10715531f, 0.12090331f, 0.09044970f, 
    0.07491351f, -0.08737489f, 0.13978326f, -0.21322697f, -0.40722507f, -0.17682053f, -0.01865700f, 0.01977810f, 
    -0.01197243f, 0.06612556f, -0.11733535f, -0.06394982f, -0.35307378f, 0.06283870f, 0.08112428f, -0.07321662f, 
    0.09488472f, -0.05935342f, -0.03902136f, 0.00865036f, 0.06499010f, -0.19350658f, -0.35678110f, -0.42731541f, 
    0.09383243f, 0.05562601f, 0.28388473f, -0.02504807f, 0.10329480f, 0.24714039f, -0.40285510f, -0.33850229f, 
    -0.00150794f, -0.23958658f, 0.00382147f, 0.22209762f, -0.05944760f, -0.09435558f, -0.13353290f, -0.66580135f, 
    0.17809428f, -0.12943050f, 0.02995023f, 0.13074705f, 0.01765947f, -0.08680589f, -0.03961257f, 0.23931390f, 
    0.06411833f, -0.46254358f, -0.05368329f, -0.01033218f, 0.29452896f, 0.05670547f, -0.27166283f, -0.02318576f, 
    -0.28001156f, 0.07768116f, 0.25933105f, -0.49497718f, 0.13634430f, -0.04339508f, 0.03940172f, 0.19010395f, 
    0.17667250f, -0.02533642f, 0.47015527f, -0.05126219f, 0.05251293f, -0.06630524f, 0.07149903f, 0.07858208f, 
    0.05792766f, -0.11754183f, -0.01112941f, -0.18615843f, 0.20729095f, 0.13975336f, -0.05359016f, -0.06651373f, 
    -0.05968336f, -0.05009549f, -0.07358889f, 0.08470593f, -0.01363314f, -0.21446231f, 0.01689382f, -0.06080605f, 
    0.03292039f, 0.04878812f, 0.02570863f, -0.02845941f, 0.14866714f, 0.16914086f, 0.24370606f, -0.31918675f, 
    0.02840513f, -0.01731864f, 0.07525253f, 0.05936639f, -0.05383172f, -0.10510265f, 0.66831398f, 0.19244468f, 
    0.01446500f, -0.10780688f, 0.21842875f, -0.10820638f, 0.01952262f, 0.05948730f, 0.10204102f, -0.31706640f, 
    -0.12201510f, 0.28665546f, 0.06582358f, -0.25295407f, 0.00920982f, -0.12043215f, 0.02040407f, -0.07133259f, 
    0.21277730f, 0.10886414f, -0.22043917f, -0.15172444f, -0.18171370f, -0.24361390f, -0.00552571f, 0.13301866f, 
    0.24774235f, 0.06519812f, 0.26283997f, -0.01651739f, -0.24758121f, -0.07138562f, 0.10171477f, -0.19557332f, 
    0.10682078f, -0.30372271f, 0.39521477f, 0.26577106f, 0.18709357f, -0.07611618f, 0.08245519f, -0.15236941f, 
    0.11120537f, 0.13407375f, 0.07365979f, -0.10488166f, -0.11719391f, 0.08719066f, 0.01329833f, 0.09596413f, 
    0.01492823f, -0.12903717f, -0.11031514f, -0.02844013f, 0.22889848f, 0.38296476f, -0.13284469f, -0.08583335f, 
    -0.16253562f, -0.06573018f, 0.03117926f, -0.09883019f, -0.19391766f, -0.16639614f, -0.41046864f, 0.12362024f, 
    0.03843318f, -0.04153551f, 0.16105726f, -0.17523219f, -0.10644997f, 0.03582570f, -0.47393596f, 0.01609658f, 
    -0.08476704f, -0.10779527f, -0.07594936f, -0.09756555f, -0.04874538f, 0.04193989f, 0.05164246f, 0.08048386f, 
    -0.25316894f, -0.15119785f, -0.07028746f, 0.05052294f, 0.08219015f, -0.07404632f, -0.04573806f, -0.21785024f, 
    0.05256440f, 0.21763068f, -0.38433284f, -0.15040815f, -0.04292749f, 0.02719227f, 0.00681435f, -0.04945951f, 
    -0.02459056f, -0.03758302f, 0.29310650f, 0.25554562f, 0.09326968f, -0.17389683f, -0.24631618f, -0.16353111f, 
    -0.15517406f, -0.04970508f, 0.09000763f, -0.10223627f, 0.31800586f, 0.00921003f, -0.11535574f, -0.08471476f, 
    -0.04070944f, -0.04238810f, -0.15864256f, 0.24826007f, -0.01554295f, 0.01112319f, -0.04262821f, 0.08723354f, 
    -0.07595341f, -0.02296483f, 0.05751331f, -0.27966732f, -0.15286548f, -0.56418079f, -0.06282227f, 0.02809111f, 
    -0.05269598f, 0.04471032f, 0.06685948f, -0.17214152f, -0.09330905f, -0.23126739f, -0.31904125f, -0.37262750f, 
    -0.09456827f, 0.03231614f, -0.04048065f, -0.06932809f, -0.25440335f, -0.13815527f, -0.44059652f, -0.24431656f, 
    0.07072560f, -0.08489164f, 0.08363616f, 0.23132250f, 0.04990023f, -0.08355805f, 0.49009943f, -0.33392197f, 
    -0.50885910f, 0.19070941f, -0.14331168f, -0.02122701f, -0.26488346f, 0.12590453f, 0.09165271f, 0.02273213f, 
    -0.49371862f, -0.05356747f, 0.04045302f, -0.05851423f, -0.08208402f, -0.04050651f, -0.02602662f, -0.01237672f, 
    0.03057493f, -0.03848484f, 0.09046665f, 0.12283172f, 0.12917405f, -0.16955437f, -0.41265389f, -0.04126098f, 
    0.07249288f, 0.00725819f, 0.21090959f, -0.49977094f, -0.15937679f, 0.13032083f, -0.02333988f, 0.28669950f, 
    -0.05916101f, 0.08458039f, 0.00154053f, 0.21529511f, 0.28939795f, 0.11841695f, 0.03745864f, 0.07873418f, 
    -0.03497866f, -0.29965270f, -0.02172324f, 0.06725392f, 0.20141594f, 0.37639958f, -0.14405829f, 0.12265212f, 
    0.18058962f, 0.23221527f, -0.05341950f, -0.05887281f, -0.14136787f, 0.29408467f, 0.34975567f, 0.28114828f, 
    0.12879682f, 0.21174604f, 0.01527528f, -0.00592382f, 0.12924364f, 0.26712227f, 0.17667720f, 0.32653797f, 
    0.09200422f, -0.19642992f, 0.04284509f, 0.06332314f, -0.17466989f, -0.06279061f, 0.02277669f, -0.01670867f, 
    -0.13885416f, -0.19120115f, 0.00111961f, 0.08417339f, -0.13495357f, -0.03016347f, 0.01048323f, 0.32970011f, 
    0.55200559f, 0.12272644f, 0.08591038f, -0.14867955f, 0.21445486f, 0.00396711f, -0.25830433f, -0.21105266f, 
    0.05726220f, 0.28860968f, 0.16138364f, 0.12831450f, -0.02678039f, -0.03140955f, 0.00231183f, 0.01367133f, 
    0.03656184f, 0.23971118f, -0.01387162f, 0.20768178f, -0.05077506f, -0.12358228f, 0.06491323f, 0.01790748f, 
    -0.02326573f, 0.06419688f, 0.07459083f, -0.28900689f, -0.03563418f, -0.13857503f, 0.04824605f, -0.01508185f, 
    -0.13774823f, 0.00100727f, -0.11896299f, 0.13270530f, 0.19170797f, 0.02989449f, -0.21626946f, -0.02071912f, 
    -0.06720578f, 0.02683846f, 0.11784002f, 0.16099225f, -0.08139629f, -0.01305783f, -0.06166796f, 0.04316388f, 
    0.00593056f, 0.00610587f, 0.30324572f, -0.13553281f, -0.08343472f, -0.17657699f, 0.39122674f, 0.27971652f, 
    0.07556726f, 0.29716763f, -0.00638929f, -0.11030008f, 0.36455479f, -0.05344106f, 0.00886766f, 0.07316871f, 
    0.39196032f, -0.24333690f, -0.03670401f, -0.11828563f, 0.24781543f, 0.17049929f, 0.15096416f, 0.07374299f, 
    0.01223797f, -0.02203574f, -0.03379485f, 0.01714738f, -0.06152924f, -0.02585122f, -0.02850414f, -0.05715065f, 
    0.00785506f, 0.01952000f, 0.02572555f, 0.00194110f, -0.00677086f, 0.05518715f, 0.04688185f, 0.04481336f, 
    -0.02869241f, -0.02779049f, 0.00543446f, -0.05362597f, -0.04862633f, -0.02318731f, 0.01187282f, -0.04882398f, 
    0.03369228f, -0.02350090f, -0.02515867f, -0.04959775f, 0.03394633f, 0.01793296f, -0.00872422f, -0.01080886f, 
    -0.00733983f, -0.02695826f, 0.05642601f, 0.05019324f, 0.00996598f, -0.06135774f, -0.00873474f, 0.04483632f, 
    -0.05156052f, 0.01216432f, 0.02991649f, 0.04226200f, -0.00279111f, -0.05991247f, 0.01425761f, 0.01755953f, 
    -0.05365233f, 0.01793704f, -0.02345099f, 0.03445442f, -0.04881831f, -0.02586838f, 0.02958471f, -0.02254136f, 
    -0.03024436f, -0.02279655f, 0.02267991f, 0.01926656f, 0.04345582f, -0.00997819f, 0.03662524f, -0.06262148f, 
    0.01554346f, 0.02735717f, 0.05284679f, -0.06612063f, 0.03416608f, 0.04106895f, 0.05882155f, -0.00268572f, 
    -0.04769335f, 0.04307760f, -0.00315723f, 0.01864200f, 0.04726655f, -0.04000224f, -0.03653469f, 0.01139678f, 
    -0.04388196f, -0.01719053f, 0.00681253f, 0.05376805f, -0.01258984f, 0.04583886f, -0.01646846f, -0.03974933f, 
    0.02708216f, -0.05482357f, -0.04626237f, 0.03143656f, 0.04182262f, -0.04684373f, -0.04399865f, -0.06214132f, 
    0.01899768f, -0.00441759f, -0.03517365f, -0.02587778f, -0.02811044f, -0.03063726f, -0.03793706f, -0.01329722f, 
    -0.04110328f, -0.03360509f, -0.02098943f, 0.01263449f, -0.00021554f, 0.01587048f, 0.00348796f, -0.00060760f, 
    -0.02767472f, 0.02852047f, -0.02487800f, -0.05650491f, -0.05981861f, -0.01013595f, 0.02831095f, 0.04694505f, 
    -0.02445006f, 0.00740280f, 0.03153755f, -0.02869976f, -0.00072605f, 0.02662032f, 0.02946880f, 0.00596732f, 
    -0.01124683f, -0.05594497f, -0.05254751f, 0.01061433f, -0.06269892f, -0.02884905f, -0.02279952f, 0.01964359f, 
    -0.03472903f, -0.02211944f, 0.00810069f, 0.01710829f, -0.01431959f, 0.03171031f, 0.04626141f, -0.04089835f, 
    0.04408002f, 0.01232421f, -0.06478555f, -0.02360505f, -0.03415367f, -0.03040817f, 0.00543708f, 0.02956182f, 
    0.03829835f, 0.00655960f, 0.03566268f, 0.03923288f, -0.04126540f, 0.00849262f, 0.04510837f, -0.03020211f, 
    -0.04627003f, -0.02543966f, 0.02063235f, 0.01557902f, 0.03751352f, 0.05391892f, 0.01713424f, -0.03195312f, 
    -0.05431439f, -0.02604086f, -0.06252332f, -0.05333541f, -0.06539531f, -0.01389712f, -0.02125442f, 0.04707731f, 
    -0.05025106f, -0.02332121f, -0.01127717f, -0.00457696f, 0.01306003f, 0.05629244f, -0.01322492f, -0.04266478f, 
    -0.03161271f, -0.00881527f, 0.05955167f, -0.04655293f, 0.01137314f, 0.04755865f, -0.05605282f, -0.01366861f, 
    -0.05399646f, 0.04363314f, 0.05689673f, -0.06517655f, 0.05051071f, -0.01946337f, -0.01082721f, 0.01176288f, 
    -0.00147439f, -0.01129124f, 0.01741325f, 0.01096239f, -0.02481167f, -0.02645291f, 0.02279439f, -0.00376440f, 
    -0.03688885f, -0.00882459f, -0.00804978f, -0.03138679f, -0.03761772f, -0.06269878f, 0.00245874f, -0.01882949f, 
    -0.04785796f, -0.05474382f, 0.01809108f, -0.01795130f, -0.05985873f, 0.03740463f, -0.03735071f, -0.00784897f, 
    0.02495159f, -0.04323477f, -0.02766503f, 0.02387277f, -0.03365687f, -0.00884766f, 0.04423226f, -0.05560469f, 
    -0.02579633f, 0.02558539f, 0.00503097f, 0.01510194f, -0.02159184f, -0.04479861f, -0.03391578f, 0.03621870f, 
    0.04975055f, -0.04224737f, 0.03198331f, 0.01964447f, 0.04193004f, 0.00902656f, -0.02179994f, 0.01970632f, 
    0.03561382f, 0.02011916f, 0.00499058f, 0.03086257f, -0.05969813f, -0.01372016f, -0.00200535f, 0.00110114f, 
    0.02156727f, -0.06435819f, 0.01303166f, 0.03140024f, 0.03287955f, 0.00258323f, -0.05897883f, -0.05758341f, 
    0.04957592f, 0.01331890f, -0.04058596f, -0.02126382f, -0.05140904f, -0.06644441f, 0.04278333f, 0.01733723f, 
    -0.04201002f, -0.00868924f, 0.02021303f, -0.01894349f, -0.04652354f, 0.01656982f, -0.05854787f, -0.00903089f, 
    -0.04787445f, 0.02029325f, -0.02612690f, -0.01056357f, -0.01549475f, 0.04628849f, -0.03647871f, -0.01116040f, 
    0.03807103f, -0.00313253f, 0.01127562f, 0.00422891f, -0.05549594f, 0.01735659f, -0.02106014f, -0.03817348f, 
    0.01906882f, 0.00561888f, -0.01866917f, 0.01728240f, 0.01484761f, 0.00730486f, -0.02785638f, -0.05046044f, 
    0.06254470f, -0.02540207f, -0.02878961f, -0.02533288f, 0.04410037f, 0.00667441f, -0.05238598f, 0.04091940f, 
    -0.02218984f, -0.00750460f, -0.01192257f, 0.00142578f, 0.01745829f, -0.05171502f, -0.05966159f, -0.01915008f, 
    0.03729463f, 0.03074076f, -0.04789070f, -0.06009547f, -0.00734537f, -0.04961421f, -0.03291758f, 0.05509638f, 
    0.01535083f, -0.00400940f, -0.05576132f, 0.04864505f, -0.03679492f, -0.04945901f, 0.01329068f, 0.02509741f, 
    -0.00102260f, -0.07934428f, -0.05401058f, -0.05497644f, -0.01303059f, -0.05301826f, -0.00181384f, -0.01183945f, 
    -0.05093594f, -0.04038001f, -0.04106674f, 0.00587487f, 0.01012289f, -0.01069142f, 0.01054805f, -0.03025614f, 
    0.00598316f, -0.06152003f, -0.02874110f, 0.04695963f, 0.02281804f, -0.01329900f, 0.02152014f, 0.04174979f, 
    -0.00244932f, 0.04216525f, -0.02792425f, -0.02138908f, -0.01816470f, -0.06447504f, -0.00512863f, -0.00274751f, 
    -0.06443374f, -0.01783218f, 0.04335666f, 0.00843725f, 0.00375976f, 0.01004924f, 0.00469935f, 0.03112546f, 
    0.04842749f, 0.03032501f, -0.01741368f, -0.03935257f, -0.03481699f, -0.01580918f, -0.01007933f, 0.01167992f, 
    -0.02867923f, -0.03786048f, -0.01926990f, -0.06391810f, 0.02203347f, -0.05107511f, 0.03066913f, -0.04853403f, 
    -0.03004442f, 0.01192415f, 0.02549401f, 0.00270260f, -0.00792294f, -0.05305079f, -0.05446724f, 0.00116279f, 
    -0.03301635f, 0.01252967f, -0.02548668f, -0.05463541f, 0.03656793f, -0.01446258f, 0.04787582f, -0.01263313f, 
    -0.03973440f, 0.03586501f, 0.03425312f, -0.04241920f, -0.02309123f, 0.01611700f, 0.00604466f, -0.05830472f, 
    -0.02456244f, -0.03674388f, -0.04161962f, 0.02983092f, -0.01801514f, 0.01601307f, -0.04711274f, -0.04848887f, 
    0.04368987f, -0.02623136f, 0.04981590f, -0.01623121f, -0.04677168f, -0.06394883f, 0.03866909f, 0.04082514f, 
    0.02258950f, -0.01559577f, 0.04395974f, 0.00364578f, -0.04616484f, 0.04908714f, -0.02162121f, -0.00040561f, 
    0.01329575f, -0.01562922f, 0.05347076f, -0.02762272f, 0.01948640f, -0.04349608f, -0.01595934f, -0.03909476f, 
    -0.04762137f, -0.02384782f, -0.01802322f, -0.04726535f, -0.04613363f, 0.05337842f, -0.00873489f, -0.01422629f, 
    0.01264774f, 0.04842880f, 0.04070375f, -0.05874457f, -0.01394273f, 0.03080037f, 0.03851767f, -0.06674985f, 
    -0.03083191f, 0.05481093f, 0.00729879f, 0.02541436f, -0.02536543f, -0.05505377f, -0.01359623f, 0.03106193f, 
    -0.05900933f, 0.04793178f, 0.02618318f, -0.04339095f, 0.00090695f, -0.06552395f, -0.05019928f, 0.00942556f, 
    0.06134621f, 0.00005984f, -0.08031224f, -0.04213101f, 0.01707385f, -0.05377794f, 0.01645270f, 0.04126621f, 
    0.03789511f, 0.00038520f, 0.01082496f, -0.03792315f, -0.01175604f, -0.01020623f, 0.02031486f, 0.05612719f, 
    -0.01722980f, 0.02303423f, 0.01295077f, -0.00913747f, -0.06873592f, -0.06143342f, 0.00410266f, -0.00033553f, 
    -0.01606297f, -0.04794490f, -0.04371897f, -0.03177275f, -0.07562739f, -0.05122818f, -0.04091813f, -0.03510910f, 
    -0.03267436f, -0.06817558f, -0.04950270f, 0.02114072f, 0.03563997f, 0.02130070f, 0.04053950f, 0.04123963f, 
    0.03470552f, -0.04571329f, 0.01831552f, -0.03482060f, -0.01031757f, -0.01148582f, 0.04212436f, -0.02590347f, 
    -0.05459638f, 0.00896474f, -0.02618456f, 0.06385869f, -0.01409694f, 0.04040821f, -0.00044341f, 0.00618468f, 
    -0.06451828f, 0.04371485f, 0.04231481f, -0.01114076f, -0.05065741f, -0.05119625f, -0.02545995f, 0.03175782f, 
    0.03113484f, -0.01925833f, -0.03491625f, -0.02112726f, -0.05455607f, 0.04567407f, -0.02887220f, -0.03537467f, 
    -0.04760513f, 0.00144260f, -0.03392403f, -0.01455691f, 0.03173376f, -0.03804603f, -0.06889059f, -0.02051250f, 
    -0.04723021f, 0.03403873f, -0.02476029f, -0.06557884f, 0.00953711f, -0.02856283f, 0.00552263f, -0.00959143f, 
    0.02841888f, -0.04464205f, 0.00219245f, -0.00024585f, 0.02056000f, 0.02534513f, -0.05842682f, -0.06649072f, 
    -0.12236819f, -0.09337692f, -0.20733449f, -0.12582953f, -0.21850234f, 0.06778472f, 0.34885317f, -0.29921317f, 
    -0.00515418f, 0.00025422f, 0.28972316f, -0.01225852f, 0.07640520f, -0.00651083f, -0.06774131f, -0.04860276f, 
    -0.14908357f, 0.02273865f, 0.09190332f, 0.06723958f, 0.12189770f, -0.06123747f, 0.22470400f, 0.15174188f, 
    0.15539992f, 0.05392667f, 0.04486189f, -0.43502605f, 0.18251197f, 0.13999215f, -0.07720562f, 0.28299597f, 
    0.01414122f, -0.12314218f, 0.08084079f, 0.02649808f, 0.29649818f, 0.23334621f, -0.09895190f, -0.24723515f, 
    0.18128720f, -0.24737792f, 0.01855078f, 0.18615542f, -0.03847039f, -0.45062408f, 0.05652640f, 0.20310843f, 
    0.16897692f, -0.08214471f, -0.01727557f, 0.01408917f, 0.20101868f, -0.00982282f, -0.30084786f, 0.04788842f, 
    0.13551383f, -0.08802178f, 0.00342038f, 0.01721292f, 0.04726253f, 0.08551168f, 0.12640701f, 0.04794881f, 
    0.07696626f, -0.39279899f, 0.14470221f, -0.13447626f, -0.05685139f, 0.12166481f, 0.02480320f, -0.31484008f, 
    -0.18609898f, 0.03901618f, 0.08984725f, -0.04142633f, 0.07143708f, 0.25093225f, 0.12984234f, 0.11549929f, 
    0.07561138f, 0.14630690f, -0.06122405f, 0.31062603f, 0.12035382f, -0.17768772f, 0.21614459f, 0.04844470f, 
    -0.01515177f, 0.04893536f, -0.02959409f, 0.23294365f, -0.10988843f, 0.04332243f, 0.19462508f, -0.17493814f, 
    -0.03447663f, 0.22259153f, -0.12692568f, 0.25833192f, -0.02998234f, -0.02533428f, -0.07011091f, 0.20815325f, 
    -0.06650136f, 0.01659257f, 0.13423587f, -0.09035042f, -0.23906016f, -0.49721950f, -0.11878875f, -0.04439584f, 
    0.14775188f, -0.07435027f, 0.07057795f, 0.06313416f, 0.23911500f, -0.04708497f, -0.29378003f, -0.06186707f, 
    0.12406707f, -0.07472862f, 0.17282818f, -0.33556908f, 0.06846266f, 0.13775580f, -0.56229496f, -0.19635116f, 
    -0.06467716f, 0.39695802f, -0.06030677f, -0.12589177f, 0.04961378f, -0.01157546f, -0.02141388f, -1.00630212f, 
    -0.37447757f, -0.17888010f, 0.20771022f, 0.07901882f, -0.19852379f, -0.11776192f, -0.06850731f, 0.11231522f, 
    -0.20314911f, 0.00484686f, -0.12969792f, -0.18172896f, -0.13839366f, 0.00098041f, 0.01713281f, 0.03830548f, 
    0.20591843f, -0.01395636f, 0.00466496f, -0.24631597f, 0.09926105f, 0.07629059f, 0.01209887f, 0.08042502f, 
    -0.12720460f, -0.11766288f, 0.03957205f, 0.12556016f, -0.37023076f, 0.09559160f, 0.38972190f, -0.29597697f, 
    -0.16947503f, 0.04863314f, -0.03630932f, 0.11215027f, 0.08453818f, -0.21669059f, -0.03312114f, -0.11955113f, 
    0.16183767f, -0.06721476f, -0.38640416f, 0.13944542f, -0.09657222f, 0.09404027f, 0.34946671f, 0.11188453f, 
    0.18529308f, -0.05023261f, -0.18477640f, 0.14825299f, 0.01397460f, 0.04361731f, -0.23021911f, 0.17171323f, 
    0.29613480f, -0.06356750f, -0.06968796f, 0.01439523f, -0.25099283f, -0.07839416f, -0.19292966f, -0.09070989f, 
    0.12064186f, -0.24544352f, -0.06920619f, 0.02960478f, 0.20434852f, 0.18670589f, 0.02188182f, -0.03306900f, 
    -0.11344334f, -0.15460674f, 0.01609774f, 0.03825776f, -0.11285309f, 0.09870359f, 0.18230796f, -0.08580346f, 
    0.02234775f, -0.07513961f, 0.10974724f, 0.20784344f, 0.24141915f, 0.09169699f, 0.04521482f, 0.03310787f, 
    -0.01486975f, 0.18322250f, 0.02548457f, -0.46772501f, -0.27196696f, -0.29914841f, -0.01275522f, 0.11199225f, 
    -0.04916310f, -0.02976171f, 0.20986086f, -0.09931906f, 0.29602256f, -0.02381181f, -0.02431421f, 0.01266060f, 
    -0.08687495f, -0.04685002f, 0.11264386f, 0.11659119f, -0.16098325f, 0.09605373f, -0.27636668f, 0.04959211f, 
    -0.03434880f, 0.19580458f, 0.08359764f, 0.00357920f, 0.08730451f, 0.21824156f, -0.69641542f, -0.01510518f, 
    0.02512596f, -0.00093667f, -0.08957951f, 0.24743357f, 0.02647839f, 0.07607452f, 0.24167587f, 0.03689124f, 
    0.05996555f, 0.02207365f, -0.24633056f, 0.11108998f, 0.01455199f, 0.01432149f, 0.21167170f, -0.09069980f, 
    0.06587937f, -0.16725570f, -0.07732611f, 0.15872994f, 0.07620399f, 0.05623090f, 0.21815889f, -0.21356025f, 
    0.01827614f, -0.11787012f, -0.06493217f, 0.11605191f, -0.22479446f, -0.15568931f, 0.05314791f, 0.18867531f, 
    0.04586986f, 0.17529191f, -0.06918330f, -0.21906306f, -0.07081606f, -0.00171579f, -0.03985694f, -0.05019141f, 
    -0.05480957f, -0.20371422f, -0.15497336f, -0.11436650f, -0.13106911f, -0.04495376f, -0.32755271f, -0.03715914f, 
    -0.23304640f, 0.11368405f, -0.04482264f, 0.00464552f, 0.29142362f, 0.16503349f, -0.05370801f, 0.17273413f, 
    -0.15680531f, 0.12264380f, -0.03330168f, -0.33496872f, 0.05242225f, 0.15328029f, 0.02295597f, -0.01381480f, 
    -0.01991309f, 0.22258630f, -0.08387012f, -0.04081693f, 0.11535683f, 0.19886187f, -0.00772680f, -0.18633319f, 
    0.11763220f, -0.16702124f, -0.04367172f, 0.08383883f, -0.03329071f, -0.18590988f, -0.34270069f, -0.14781021f, 
    -0.03328456f, 0.14175336f, -0.05292374f, 0.03452477f, 0.17180309f, 0.04519322f, -0.04226599f, -0.14362244f, 
    0.17162734f, 0.27097219f, -0.01858017f, 0.05089469f, -0.13204733f, -0.12181427f, -0.17408867f, 0.09924196f, 
    0.02727004f, 0.43909213f, 0.17840049f, -0.14082055f, -0.08678873f, 0.00892345f, -0.04858916f, -0.01259189f, 
    -0.37452903f, 0.15862592f, 0.27959472f, -0.00467813f, -0.06545158f, -0.06287384f, 0.01547162f, -0.05063325f, 
    0.03399713f, -0.09114536f, -0.00118762f, 0.31459627f, 0.30452499f, 0.07387132f, -0.25980267f, -0.04228975f, 
    -0.02757546f, -0.00600241f, -0.17212108f, -0.02806303f, -0.28908908f, 0.11460459f, 0.10484104f, -0.03129187f, 
    0.13954769f, -0.01461657f, -0.09694346f, 0.07206122f, 0.04896433f, -0.11372323f, -0.03987061f, -0.03693976f, 
    -0.15025473f, -0.16859263f, 0.06639712f, 0.10268081f, -0.14198257f, 0.00194202f, -0.15486574f, -0.13261847f, 
    0.17190643f, 0.01548083f, 0.02871714f, 0.00428235f, -0.23422384f, 0.05314463f, 0.15230742f, -0.07609279f, 
    -0.19245112f, -0.13611898f, -0.03912380f, 0.08072381f, -0.10143986f, -0.13558172f, 0.01095375f, -0.16029584f, 
    -0.07203601f, -0.07703265f, 0.03446451f, 0.01366370f, -0.08104371f, 0.04628735f, 0.06603623f, -0.27127802f, 
    -0.35340512f, -0.38418710f, 0.22678202f, -0.08771251f, -0.03035187f, 0.08774357f, -0.10366981f, -0.04385336f, 
    0.01766413f, 0.00484144f, 0.11746109f, 0.12119579f, -0.03726173f, 0.11311679f, 0.09526326f, -0.07151283f, 
    -0.31612113f, 0.19445452f, 0.26123604f, 0.13676403f, 0.07104254f, -0.10498200f, 0.08332925f, 0.24378875f, 
    -0.15539950f, -0.14628807f, -0.06242586f, -0.21679835f, -0.15430680f, -0.09910226f, -0.06375863f, 0.01538162f, 
    -0.15029137f, 0.05799250f, 0.09775688f, -0.05209650f, -0.03261800f, 0.37473994f, -0.05141862f, 0.15039551f, 
    0.00648486f, -0.05244265f, -0.11208028f, -0.00925037f, 0.03223492f, 0.09219334f, 0.36026165f, 0.06099968f, 
    -0.03001094f, -0.00134335f, -0.00123086f, -0.00333908f, 0.07334288f, 0.16375263f, 0.06417594f, 0.30249432f, 
    0.10552288f, -0.03247734f, 0.14851387f, 0.00767436f, -0.00048173f, 0.14402844f, 0.07947394f, 0.60837346f, 
    -0.26838121f, -0.15964705f, -0.19857298f, 0.10181724f, 0.08326221f, 0.02707808f, 0.06315144f, -0.06022371f, 
    0.07776673f, -0.15854479f, 0.13581622f, 0.18942900f, 0.01054745f, -0.03549347f, -0.05059478f, -0.03202366f, 
    0.33191434f, 0.18871337f, 0.12150057f, 0.12277384f, -0.15503803f, 0.04584221f, 0.00122675f, 0.03138610f, 
    0.27141866f, 0.00660768f, -0.08528413f, 0.08271170f, -0.22374500f, -0.07674319f, 0.00732406f, 0.05886671f, 
    0.05531542f, 0.04797167f, 0.00191080f, -0.12646633f, 0.24265048f, 0.15407994f, 0.03934217f, 0.00830313f, 
    -0.19679883f, -0.04776071f, 0.04699095f, 0.07581230f, 0.23276396f, -0.18081310f, 0.04956774f, -0.01984056f, 
    -0.05157402f, -0.00756133f, 0.01331320f, -0.18970038f, 0.11523897f, -0.06442393f, 0.09304923f, 0.18805341f, 
    -0.09756765f, 0.00918033f, -0.08701422f, -0.13924104f, 0.12043833f, -0.31207889f, -0.37241822f, -0.34568527f, 
    -0.00510494f, -0.04683968f, 0.00025080f, 0.04090560f, 0.00821063f, 0.14236957f, -0.00223714f, 0.18583567f, 
    0.41350850f, -0.21804838f, 0.02936694f, 0.13124138f, 0.10528085f, 0.09518076f, 0.21320419f, 0.14608517f, 
    0.30641699f, -0.09075183f, -0.03873279f, 0.22464138f, -0.29400992f, -0.05665332f, 0.12330076f, 0.09587906f, 
    -0.00052086f, -0.24435031f, -0.00898498f, -0.27196726f, 0.04556476f, -0.28322005f, -0.12598936f, 0.15444405f, 
    0.00910670f, 0.01932281f, -0.00190587f, -0.01661566f, 0.25580093f, -0.08619802f, -0.18890640f, 0.07116757f, 
    -0.17951612f, 0.13795532f, 0.10967977f, -0.14020899f, -0.26019940f, 0.04617286f, 0.30708373f, 0.13321625f, 
    -0.04692184f, 0.06836922f, 0.12026013f, 0.25950989f, 0.09391364f, 0.16263062f, 0.04276971f, 0.02293518f, 
    -0.02445356f, 0.21498784f, -0.12654637f, 0.13435932f, 0.16380231f, 0.47251081f, 0.02086493f, 0.02448093f, 
    -0.12226406f, 0.01350130f, -0.01140696f, 0.13840082f, -0.02559633f, -0.10930654f, -0.40329191f, 0.31047109f, 
    0.05022724f, 0.01256267f, -0.05883878f, 0.34259656f, 0.01963076f, 0.07712211f, -0.11219027f, -0.27255243f, 
    0.30562866f, -0.24103114f, -0.06439890f, -0.00030006f, 0.02254217f, -0.14658038f, 0.09953415f, 0.01428500f, 
    0.24372795f, 0.16181974f, -0.22574097f, -0.03875316f, 0.19169310f, -0.04898879f, -0.03606157f, -0.16768724f, 
    -0.03462185f, 0.04852779f, -0.17669633f, -0.20322220f, -0.12287350f, 0.12606543f, 0.04115666f, -0.19795752f, 
    0.19912244f, -0.13058390f, 0.01826517f, 0.01311298f, -0.22799784f, 0.02323758f, -0.14861782f, 0.18065979f, 
    0.10698134f, 0.04811376f, 0.07978873f, 0.12424938f, 0.22935897f, 0.16102183f, 0.19713913f, -0.06594952f, 
    0.05050416f, 0.02527028f, 0.09965660f, 0.31517512f, -0.04268201f, 0.04771536f, 0.10725342f, 0.12676546f, 
    -0.11224209f, -0.05313994f, 0.13974498f, 0.15457118f, -0.43522006f, -0.24664317f, 0.24619806f, -0.03142415f, 
    -0.06289028f, 0.10617592f, 0.10594794f, 0.05806831f, -0.08332656f, -0.01656550f, -0.04029555f, -0.01558043f, 
    0.19517806f, -0.13488258f, -0.24445386f, -0.18480001f, 0.19580093f, -0.10658281f, -0.08817876f, -0.25277147f, 
    -0.05206977f, -0.23972888f, -0.20540304f, 0.01632453f, 0.20302935f, 0.19951659f, -0.32458180f, -0.10536164f, 
    -0.57945722f, 0.00803407f, 0.01727399f, 0.15926489f, 0.10962100f, 0.05505653f, -0.08325380f, 0.22731820f, 
    -0.48178014f, -0.30821371f, 0.27767915f, -0.09759270f, 0.00347263f, -0.05146819f, 0.02384983f, -0.13200986f, 
    0.16727929f, -0.33279434f, 0.00990417f, 0.05096936f, -0.12197160f, 0.09924017f, 0.06855009f, -0.01873462f, 
    -0.12387184f, -0.10433887f, -0.07841861f, -0.27752954f, 0.12932289f, 0.30070317f, 0.22400753f, 0.18618475f, 
    -0.00700324f, -0.01805549f, 0.07754666f, -0.22015709f, 0.13223101f, 0.22129533f, -0.13619426f, 0.02286469f, 
    -0.12949097f, 0.04536397f, -0.03435805f, -0.00688537f, -0.06032393f, -0.09524367f, -0.19288529f, -0.21279885f, 
    0.15750025f, 0.20220913f, -0.14792068f, -0.17646252f, 0.13580748f, 0.03004454f, 0.08438557f, -0.48428836f, 
    -0.17205940f, 0.11906786f, -0.03128963f, -0.02923171f, -0.16306512f, 0.00493045f, 0.28418171f, 0.56706679f, 
    -0.24036315f, -0.06672910f, -0.10104042f, -0.27660581f, 0.07031763f, 0.19353758f, 0.02342142f, 0.17899141f, 
    -0.27102378f, 0.02303126f, 0.00961301f, -0.08071434f, -0.06000311f, -0.04317942f, 0.32852241f, -0.16163419f, 
    0.28721291f, -0.27768531f, 0.10287817f, -0.09724171f, 0.03850307f, -0.05216141f, -0.11353257f, 0.03441550f, 
    0.18640000f, 0.11135396f, -0.00072707f, 0.11181437f, 0.13499419f, 0.07590834f, 0.13481921f, -0.00913507f, 
    -0.30018535f, -0.52641356f, 0.17486665f, 0.06660745f, -0.22121885f, -0.08353259f, 0.10701848f, 0.02221452f, 
    -0.00439398f, -0.05159899f, 0.03119310f, -0.60901815f, -0.35225749f, -0.18339124f, 0.04840590f, 0.16986698f, 
    0.03100071f, -0.08260968f, 0.12928151f, 0.12991278f, 0.38118500f, -0.36987942f, 0.33566257f, -0.09047437f, 
    -0.07493993f, 0.24577121f, -0.23849721f, 0.03054343f, -0.13020709f, 0.15497808f, -0.06889128f, 0.12538832f, 
    0.19270515f, 0.17992839f, -0.09865779f, 0.02642904f, -0.06306110f, 0.08198109f, 0.25762719f, 0.25873634f, 
    -0.02206051f, -0.00824190f, 0.17137127f, 0.11261904f, -0.07144107f, 0.26677448f, 0.11780678f, 0.31439120f, 
    -0.15055992f, 0.06643825f, -0.25296259f, 0.09274247f, -0.22568786f, 0.02215707f, -0.12565404f, -0.05358310f, 
    0.03591232f, -0.00723093f, 0.01127005f, 0.04297033f, 0.02924475f, -0.03795265f, 0.02416807f, 0.04927827f, 
    -0.03617793f, 0.00852567f, -0.04273625f, -0.00816600f, 0.03757969f, -0.03900338f, -0.03384570f, -0.01133585f, 
    0.00429040f, 0.00834525f, 0.02805557f, -0.03820414f, -0.05989625f, 0.01330398f, -0.02401376f, -0.00331436f, 
    -0.06379399f, 0.03166929f, -0.02180496f, -0.02543238f, 0.03715149f, -0.03784375f, 0.03228804f, -0.01110427f, 
    -0.02829619f, 0.02948549f, -0.05926231f, 0.02951138f, -0.02439060f, -0.05432304f, -0.00442021f, -0.03434735f, 
    -0.02639836f, -0.03116863f, 0.04304876f, -0.01798783f, 0.02583806f, -0.04425780f, 0.01638410f, -0.05104446f, 
    0.00605949f, -0.01697948f, -0.03032658f, 0.03060597f, -0.06127870f, 0.04968631f, -0.04098753f, -0.05314916f, 
    -0.03066670f, -0.01014019f, 0.02917362f, 0.04821075f, 0.04693889f, -0.05434114f, -0.03665333f, 0.02986499f, 
    -0.01796344f, -0.00688936f, -0.05520704f, -0.00782671f, 0.00218515f, 0.01652084f, 0.03701737f, 0.00274254f, 
    -0.02986360f, 0.05549833f, -0.04196345f, -0.03916826f, 0.04100879f, -0.06054776f, -0.01083987f, 0.06459705f, 
    -0.02477851f, -0.02069104f, -0.04991314f, -0.03930488f, -0.03543736f, -0.01295003f, -0.03387250f, 0.03797572f, 
    -0.03097694f, -0.05528144f, 0.02572145f, -0.04663118f, -0.01258430f, 0.04093912f, 0.02420507f, 0.00061784f, 
    0.03002430f, 0.01992575f, -0.04986256f, 0.01881613f, 0.04169326f, -0.03255711f, -0.06197618f, -0.06453254f, 
    0.03098928f, -0.01983505f, -0.02283870f, -0.01366677f, -0.05077353f, -0.06205983f, 0.00942933f, 0.01118598f, 
    -0.03656482f, -0.01987549f, -0.05662266f, 0.00354617f, 0.03665259f, 0.04296255f, 0.00486945f, 0.03767383f, 
    0.02346416f, -0.05499560f, 0.03229557f, -0.00868722f, 0.00009891f, -0.04529130f, 0.01401967f, -0.00943976f, 
    0.03105832f, -0.01407973f, -0.06191732f, -0.03945959f, 0.02568485f, -0.03115325f, 0.02725564f, 0.02669998f, 
    -0.04997855f, -0.03913829f, -0.03441179f, -0.01490497f, -0.00292875f, -0.01175954f, -0.01341988f, -0.00936864f, 
    0.02322668f, -0.05589859f, -0.01451996f, -0.04866862f, -0.03638992f, 0.02169699f, 0.03494091f, 0.01598246f, 
    -0.04537866f, -0.03544321f, -0.03709794f, -0.01231901f, -0.02394359f, 0.02015900f, 0.03960671f, 0.00521670f, 
    0.04055070f, -0.05443979f, 0.00751599f, 0.03942787f, 0.03182083f, -0.03075636f, 0.04404096f, 0.03996865f, 
    0.04444648f, -0.01584703f, -0.02452938f, -0.01540362f, 0.00922959f, -0.05262951f, 0.02895321f, 0.02942167f, 
    0.02083684f, 0.01701619f, 0.05560213f, -0.03208513f, -0.06346683f, -0.05755775f, -0.00034953f, -0.05518254f, 
    -0.03178774f, -0.03421627f, -0.02442294f, -0.04464188f, 0.04940736f, 0.02575685f, 0.04317623f, 0.05959670f, 
    0.03050116f, 0.01734136f, -0.04617444f, -0.00940562f, -0.04020392f, -0.03508620f, -0.00906130f, -0.06279994f, 
    0.00632540f, -0.02079490f, 0.04865565f, -0.04146350f, -0.06086446f, 0.00022996f, 0.02050802f, -0.04878618f, 
    0.00505226f, -0.03735340f, -0.05586981f, -0.00166875f, -0.04779791f, -0.06369670f, -0.03838902f, 0.01263048f, 
    0.01109239f, 0.02167815f, -0.05221388f, 0.02175572f, 0.00702608f, 0.02877646f, -0.04869704f, -0.05508702f, 
    -0.00673765f, 0.03482359f, 0.03337028f, -0.02130789f, -0.01985225f, -0.03729757f, -0.02441168f, 0.01009724f, 
    0.02266803f, -0.01351120f, -0.06224931f, -0.01576562f, -0.05754627f, -0.02224778f, -0.03114140f, 0.04516459f, 
    -0.06207000f, -0.01325848f, -0.05690198f, -0.00746432f, -0.01068517f, -0.00575728f, -0.03906652f, 0.02999740f, 
    -0.05620124f, -0.03405379f, -0.02719622f, 0.01559061f, 0.03509805f, 0.03206271f, -0.04812192f, 0.04329238f, 
    0.02547366f, 0.01278057f, 0.02483072f, 0.02392754f, -0.06022565f, 0.01364733f, -0.00981794f, -0.05009069f, 
    0.04659170f, -0.00152809f, 0.04154346f, 0.00939562f, 0.00417811f, -0.04504116f, -0.05899623f, -0.02289899f, 
    0.04202023f, 0.03800636f, -0.04327609f, 0.03287660f, 0.01884074f, -0.04688419f, -0.01550603f, -0.01415335f, 
    -0.01926743f, -0.02283970f, 0.04909377f, 0.00907546f, 0.05203725f, 0.04426731f, 0.03240902f, -0.00146729f, 
    0.17759170f, 0.08900397f, -0.05708907f, -0.08717022f, -0.10538156f, 0.05462374f, 0.08642106f, 0.28440446f, 
    0.16676793f, 0.26057419f, 0.17246677f, 0.10122372f, -0.20532049f, -0.21813542f, -0.07534346f, -0.01910604f, 
    0.05508601f, 0.05467216f, 0.14575475f, 0.21547417f, 0.01335987f, -0.20785715f, 0.00415167f, -0.12893170f, 
    0.03681652f, -0.07028352f, -0.15156598f, 0.09658391f, -0.06152578f, -0.03269338f, -0.06843311f, 0.20428424f, 
    0.11473092f, -0.16033362f, 0.11765198f, -0.01107109f, 0.51293057f, -0.28013855f, -0.17252116f, 0.01021694f, 
    -0.06372860f, 0.13124272f, 0.07463213f, -0.08538803f, 0.05638877f, -0.24736989f, 0.10271749f, 0.12798280f, 
    0.08020978f, 0.15105483f, -0.04339903f, 0.12712789f, 0.06296537f, 0.06671409f, 0.05509038f, -0.18594375f, 
    -0.16544621f, 0.11892200f, 0.04414880f, -0.13112286f, 0.06032420f, 0.10990170f, 0.09685854f, 0.07919870f, 
    -0.16440502f, 0.07433673f, -0.10000511f, -0.00340166f, 0.04957401f, -0.10358256f, -0.16590455f, 0.05177559f, 
    -0.33476880f, -0.04715148f, 0.19621876f, 0.04860406f, 0.08868349f, 0.09043290f, 0.17875525f, -0.16546530f, 
    0.08062141f, 0.18610828f, 0.16198678f, -0.24146189f, 0.00257361f, 0.10670511f, -0.11673076f, -0.08735488f, 
    0.14338970f, 0.05974376f, -0.08658203f, 0.04543716f, -0.07323610f, 0.01870588f, -0.07412688f, 0.08468046f, 
    -0.00365101f, 0.19073756f, 0.02216351f, 0.13721117f, -0.14885366f, 0.13333336f, -0.12940645f, 0.01661180f, 
    0.00118321f, 0.07107683f, 0.02133001f, 0.09783894f, -0.27771690f, 0.11333384f, 0.10184441f, 0.06907735f, 
    0.13946506f, 0.16952251f, 0.05689526f, -0.09682284f, 0.01935237f, -0.44832596f, 0.27206460f, -0.16043167f, 
    0.08804673f, 0.07816511f, -0.07694142f, 0.03527743f, 0.06235127f, 0.04043348f, -0.84085053f, 0.07683543f, 
    -0.05385939f, 0.00670329f, 0.13635133f, 0.08309392f, 0.04703049f, -0.06605590f, -0.20028682f, -0.20229535f, 
    0.33488721f, -0.13967223f, 0.07276268f, 0.03807861f, 0.01386709f, -0.00082104f, 0.19791424f, -0.06907919f, 
    -0.04347603f, -0.08864071f, -0.18354711f, 0.07831997f, -0.15792727f, -0.04526285f, 0.19594252f, -0.05095520f, 
    0.06472670f, 0.66820133f, -0.17990552f, -0.22162977f, -0.06069616f, -0.28879499f, 0.08642755f, -0.02108491f, 
    -0.04779789f, 0.21882619f, 0.10479349f, 0.10608614f, -0.01058614f, 0.18331724f, -0.20569941f, -0.17513674f, 
    -0.17406282f, 0.27837992f, -0.20038779f, 0.04535612f, -0.18106845f, -0.30458203f, -0.32721525f, 0.01679838f, 
    0.03397261f, -0.23348621f, 0.04506540f, 0.04340959f, -0.19662616f, 0.02203643f, 0.01025825f, -0.03864286f, 
    0.01979405f, -0.12557071f, 0.22556652f, -0.27540302f, 0.03014804f, -0.09268132f, -0.08488117f, -0.42119139f, 
    -0.40818819f, -0.18160234f, -0.00548723f, -0.04101627f, -0.00705379f, 0.00829872f, -0.13839011f, -0.22607397f, 
    -0.01102096f, -0.31369394f, -0.21384171f, 0.21225509f, 0.04382984f, 0.13078004f, 0.02653708f, -0.23212469f, 
    0.09386726f, -0.16003022f, -0.00049474f, 0.17920655f, 0.06740628f, -0.08290928f, 0.00142293f, -0.00162549f, 
    0.15363321f, -0.02388292f, 0.19686820f, 0.09889313f, -0.00597267f, -0.14753196f, 0.12949820f, 0.05095237f, 
    0.03102804f, 0.49482447f, 0.35396445f, -0.27153844f, -0.17175116f, -0.09031275f, 0.00019278f, -0.16034622f, 
    0.12614101f, 0.05943485f, 0.04254627f, 0.13722889f, 0.18830010f, -0.08706700f, 0.04213415f, 0.04561419f, 
    0.08455931f, 0.10302891f, -0.05856300f, -0.08651095f, 0.12707031f, -0.23770940f, 0.00831303f, -0.15752487f, 
    -0.00619725f, 0.03647696f, -0.20015994f, 0.03741254f, 0.15801547f, -0.44219694f, -0.11540040f, 0.10550385f, 
    -0.00335465f, 0.01408010f, 0.01501413f, 0.11600544f, -0.02872701f, 0.34048596f, 0.21794166f, 0.15126275f, 
    0.13586167f, -0.08792423f, -0.17677584f, 0.05174369f, -0.11472194f, 0.13523346f, 0.17862345f, 0.20965202f, 
    -0.05395316f, -0.03691901f, -0.15721421f, 0.01950959f, -0.05064712f, 0.01299154f, 0.07862177f, 0.04347714f, 
    -0.20988393f, 0.03587523f, -0.10640749f, 0.03833991f, 0.01345481f, -0.07832026f, 0.01870907f, -0.10427262f, 
    -0.13952939f, -0.07083612f, 0.04764251f, 0.11265260f, 0.10762740f, 0.06808410f, 0.30445185f, 0.11218715f, 
    -0.19733582f, 0.02519014f, -0.00415021f, -0.24365227f, 0.11873434f, 0.03758522f, 0.09874665f, -0.02306634f, 
    0.13850918f, 0.12976652f, 0.28782961f, 0.18761727f, 0.26635107f, -0.01636006f, 0.17355590f, -0.00825911f, 
    0.07054200f, 0.08398736f, 0.21837328f, -0.28291968f, -0.03199034f, -0.45147964f, -0.04556515f, -0.06518006f, 
    0.04966752f, 0.10331778f, 0.09299283f, -0.23104185f, 0.25855923f, 0.20491895f, -0.01693884f, -0.09038743f, 
    -0.19949907f, -0.00012468f, -0.02446396f, -0.18454981f, 0.19268270f, -0.32201016f, -0.10191018f, -0.37511033f, 
    -0.20341462f, -0.08616061f, -0.05632138f, -0.19718143f, -0.18753284f, -0.09982546f, -0.02908666f, 0.03156771f, 
    -0.10923796f, 0.04611237f, -0.10451498f, -0.18721631f, -0.08551697f, 0.13651118f, -0.10715979f, -0.49971089f, 
    0.26781896f, -0.33382127f, 0.13055806f, 0.01675898f, -0.02343620f, -0.05807515f, -0.07094979f, -0.06732008f, 
    0.37105179f, 0.16397960f, 0.20748453f, -0.20368461f, -0.05281512f, 0.08092257f, -0.12780884f, 0.06795261f, 
    -0.12995744f, 0.09888933f, 0.11864348f, 0.17107190f, 0.07991143f, -0.04185825f, -0.08833134f, -0.10337261f, 
    -0.20046321f, -0.06113561f, 0.04077347f, -0.14585948f, -0.17499502f, -0.22652446f, -0.15085518f, -0.01524127f, 
    -0.01767888f, -0.07556372f, 0.03996725f, -0.02072499f, 0.15026110f, 0.24408455f, -0.01550544f, 0.08131900f, 
    -0.04426894f, 0.11897553f, -0.00295493f, 0.01237896f, -0.17065296f, -0.15644293f, -0.24454492f, 0.10675555f, 
    -0.08837661f, 0.07267800f, -0.12133059f, 0.13572630f, -0.15380675f, -0.36533177f, -0.19306867f, 0.30446050f, 
    0.12850137f, 0.02536100f, -0.07768866f, -0.09894304f, 0.17029378f, -0.06956980f, -0.22403184f, -0.46563232f, 
    0.14110045f, -0.00625567f, 0.10859853f, -0.16289936f, -0.09998871f, 0.00692940f, 0.05822380f, 0.14779566f, 
    -0.27805880f, 0.15205359f, -0.00364089f, -0.09145992f, 0.05855350f, -0.04335464f, -0.03687684f, -0.01968034f, 
    -0.02544296f, -0.02261395f, -0.06874403f, 0.05518340f, -0.04035274f, -0.07993619f, -0.18314788f, 0.13421561f, 
    -0.11072065f, -0.06932174f, 0.04258039f, 0.06347136f, 0.01907331f, 0.08177094f, 0.00841655f, 0.04922316f, 
    0.22040115f, 0.14328608f, -0.12007344f, -0.05329701f, -0.24525142f, -0.00161080f, -0.21552883f, -0.00478494f, 
    -0.01320610f, 0.01143195f, 0.19583160f, 0.01357516f, -0.02545510f, 0.22858271f, 0.01076099f, -0.20550363f, 
    0.05644603f, -0.00401268f, 0.01796049f, -0.00744200f, 0.33295292f, 0.24090141f, 0.07877588f, -0.02278749f, 
    -0.12964793f, 0.11677581f, -0.04227627f, 0.05759272f, 0.21894360f, 0.30455396f, 0.31169140f, 0.39537886f, 
    0.07000372f, 0.10325144f, -0.02193677f, 0.02445854f, 0.04090552f, 0.11761180f, -0.02150161f, -0.11064482f, 
    0.23584348f, -0.05547567f, 0.17156099f, -0.07040454f, -0.03496161f, 0.13879333f, -0.04052100f, -0.17505543f, 
    0.01003684f, 0.07470012f, 0.01053529f, -0.02006594f, -0.01916850f, -0.06040150f, -0.01619523f, 0.30377182f, 
    -0.32852259f, 0.07428751f, 0.16267301f, 0.17751649f, -0.09502813f, -0.13130730f, 0.13192925f, -0.01699781f, 
    -0.14617977f, 0.10533248f, -0.07633545f, -0.04283689f, -0.35488293f, -0.11308178f, -0.03689228f, -0.05462742f, 
    0.03317655f, 0.30442041f, -0.00989487f, -0.01014412f, 0.04524495f, 0.10291311f, 0.04091386f, 0.09669608f, 
    0.03547155f, 0.16271588f, -0.08116202f, -0.05690468f, 0.02353522f, 0.04334815f, 0.14316799f, 0.20694885f, 
    -0.15468161f, 0.11527719f, 0.03215715f, 0.07566943f, -0.21111448f, 0.07346133f, -0.64327925f, 0.07680984f, 
    -0.06105202f, 0.13642202f, 0.08423790f, 0.08261485f, 0.16669674f, -0.10666439f, -0.10893915f, -0.02147080f, 
    0.00746658f, -0.11866356f, 0.07823876f, -0.22776087f, -0.05622242f, 0.13543651f, 0.18496804f, 0.08617472f, 
    0.32531250f, -0.00924142f, 0.14466098f, 0.08880504f, 0.04363180f, 0.03953747f, -0.13043225f, -0.05343942f, 
    0.08208711f, -0.15060180f, 0.12372599f, -0.00524621f, 0.19793907f, -0.11057194f, 0.04060403f, 0.27661169f, 
    0.01798190f, -0.05073854f, -0.02370977f, 0.04140268f, 0.04325754f, -0.04930881f, -0.04598304f, 0.03573928f, 
    -0.01867205f, -0.05916839f, 0.04468241f, 0.04493709f, -0.02254137f, -0.02631606f, 0.01949314f, -0.04943584f, 
    0.03176818f, -0.03209117f, 0.03325006f, -0.02930429f, -0.04687867f, -0.03970780f, 0.03724748f, -0.04696885f, 
    -0.02029943f, -0.00302849f, -0.01546766f, -0.00880652f, 0.01267702f, -0.02719644f, -0.04287844f, -0.02132523f, 
    0.01971312f, 0.00852063f, 0.04187541f, -0.03079754f, 0.05631181f, -0.03133282f, -0.03841594f, -0.03907483f, 
    -0.06339936f, -0.05575698f, 0.01289277f, -0.01611306f, 0.00215636f, 0.02796596f, 0.01433075f, -0.01116757f, 
    -0.05758659f, -0.02277153f, -0.04952641f, 0.03163329f, -0.01422356f, 0.04344447f, -0.02189866f, 0.00564250f, 
    -0.05178181f, -0.00512359f, -0.01290397f, -0.06280279f, 0.00087466f, 0.03894007f, 0.00308386f, 0.01345526f, 
    -0.06065447f, -0.01524481f, -0.04006630f, 0.01849238f, 0.01653859f, -0.02293726f, -0.00448419f, -0.04276481f, 
    -0.03994295f, 0.03134360f, -0.01583050f, 0.04977744f, 0.00163149f, 0.03190346f, -0.01545748f, 0.03679914f, 
    -0.00157195f, 0.00500502f, 0.03733890f, -0.03710486f, -0.02332655f, -0.00620493f, -0.00288280f, -0.01300277f, 
    0.01321672f, 0.05268652f, -0.02940966f, 0.00201743f, -0.00335873f, -0.03714861f, 0.02322969f, -0.02150478f, 
    0.04689417f, -0.06324440f, -0.01052957f, -0.00895928f, 0.01110794f, -0.01792919f, 0.03445828f, -0.05141972f, 
    0.02015623f, -0.03935847f, 0.00465434f, -0.00783147f, -0.01467771f, 0.01359178f, -0.05833123f, -0.04223512f, 
    0.03782990f, -0.04287783f, 0.01373038f, -0.02922849f, 0.03932272f, -0.02784341f, 0.05448480f, 0.05289381f, 
    -0.00941378f, -0.01472434f, -0.00407289f, -0.00816630f, 0.02064319f, -0.03873301f, 0.03962767f, 0.00182296f, 
    -0.01673530f, -0.04636728f, -0.03320788f, -0.05319054f, 0.00804733f, -0.03587673f, 0.00681317f, -0.00516881f, 
    -0.02779643f, 0.02477047f, -0.05417982f, 0.04111296f, -0.05905890f, 0.02714670f, 0.04556775f, 0.00177486f, 
    0.04755958f, 0.01609628f, -0.03054144f, 0.01936565f, -0.00289533f, -0.05766734f, -0.02024368f, -0.03066980f, 
    -0.06792985f, -0.06166482f, -0.04168330f, -0.04326000f, -0.04119704f, -0.04567892f, 0.03204961f, 0.04577723f, 
    0.00665234f, -0.06016337f, 0.01744373f, -0.03682538f, -0.04473805f, -0.05286723f, 0.04726116f, 0.00061396f, 
    -0.02449183f, -0.03418295f, -0.04210860f, -0.03497812f, 0.01386587f, -0.00756064f, -0.02088234f, 0.02611149f, 
    0.03435880f, 0.05083830f, -0.04218587f, -0.03922372f, 0.05243037f, 0.02728490f, -0.05236564f, -0.01670924f, 
    -0.01166402f, -0.00418116f, -0.03816451f, -0.05703536f, 0.02035552f, 0.04369350f, -0.02336229f, 0.03752880f, 
    -0.05814403f, 0.06130945f, 0.03145083f, -0.05919600f, -0.03077400f, 0.03875525f, 0.05004518f, -0.01371578f, 
    -0.00540324f, 0.03513884f, 0.01820380f, -0.00735895f, -0.03134178f, -0.05686515f, 0.01649349f, -0.00809711f, 
    0.01268603f, -0.04359540f, -0.00045272f, 0.00995793f, -0.03590026f, -0.01184044f, -0.00144895f, 0.04096349f, 
    0.02373446f, -0.01579520f, 0.03244499f, -0.00940256f, -0.04706282f, 0.04495102f, -0.02757413f, -0.00295989f, 
    -0.03798167f, -0.00668003f, -0.01862045f, -0.01952576f, -0.03158240f, 0.02535278f, -0.01761306f, -0.06177101f, 
    -0.00166996f, -0.03274962f, -0.00698530f, 0.04015407f, 0.01252019f, -0.02938122f, 0.03553540f, -0.02375997f, 
    0.01328469f, 0.05176586f, 0.01634582f, -0.02981778f, -0.01372147f, -0.01017010f, -0.04458015f, 0.00195924f, 
    0.02151192f, -0.00705167f, -0.02054729f, -0.04664280f, -0.02906465f, -0.03344180f, 0.01609046f, -0.05388499f, 
    0.03485317f, -0.04742923f, -0.00675280f, -0.03965000f, 0.00879324f, -0.01831312f, -0.00291002f, -0.04775134f, 
    -0.02707030f, -0.01350190f, -0.04577916f, 0.01596752f, -0.01758228f, -0.02804165f, -0.00824198f, -0.04519399f, 
    0.00415767f, 0.03468053f, -0.02668239f, -0.03184419f, 0.02419735f, -0.05180779f, -0.02099262f, -0.05067778f, 
    -0.03960797f, 0.01684262f, -0.00295183f, -0.03214190f, -0.00038413f, -0.00807039f, -0.01359063f, 0.01546730f, 
    0.78038943f, 0.05666076f, 0.05257530f, -0.09833284f, -0.06090922f, -0.16325970f, -0.08399075f, -0.04679243f, 
    0.06461108f, -0.20264395f, 0.02403637f, -0.48135412f, 0.20394278f, 0.17273150f, -0.10017882f, 0.09767650f, 
    0.15780869f, 0.17213985f, 0.00811426f, -0.38254812f, 0.39482674f, -0.02748692f, -0.02451222f, 0.09106313f, 
    -0.12207385f, -0.10901207f, 0.04518327f, -0.48285931f, 0.41811773f, -0.10586856f, 0.00378510f, -0.09489208f, 
    0.12218302f, 0.12713091f, -0.01180781f, -0.05837474f, -0.08429912f, -0.07695159f, 0.19986749f, 0.20247671f, 
    0.03364687f, 0.11693060f, 0.09446900f, 0.13734448f, 0.07147439f, -0.22722274f, 0.05598627f, -0.32014802f, 
    0.03744723f, 0.18305878f, -0.08425268f, 0.08967645f, 0.07211346f, 0.00045427f, -0.15673041f, 0.34351817f, 
    0.08139790f, 0.17977932f, 0.01152101f, -0.16969077f, 0.04290262f, 0.04717321f, 0.17770767f, -0.37995806f, 
    0.14617002f, -0.16635664f, 0.06954747f, -0.17439318f, -0.16082120f, 0.04985747f, -0.00472534f, 0.14133170f, 
    0.01927275f, -0.23392692f, 0.14916004f, 0.08211933f, -0.15147458f, 0.11022528f, -0.12538806f, 0.02093819f, 
    0.00769785f, -0.52633208f, 0.01546531f, 0.36472458f, 0.38649783f, 0.03678401f, -0.13338518f, -0.08087774f, 
    -0.19606203f, -0.10337194f, -0.20008580f, -0.16715808f, -0.13799743f, 0.06199914f, 0.14466687f, -0.21657953f, 
    0.13668989f, 0.02045417f, -0.18739170f, -0.25271735f, 0.01420751f, -0.29501349f, -0.15951104f, 0.22980711f, 
    0.04309602f, -0.08353353f, 0.09641313f, -0.11198618f, -0.06021437f, -0.13020973f, -0.02003937f, 0.05224128f, 
    0.20797545f, 0.20592566f, -0.02217367f, 0.08680094f, 0.09516891f, -0.06184465f, 0.21255006f, -0.22124833f, 
    0.00364178f, -0.33200049f, -0.16004606f, -0.05514209f, -0.09194929f, 0.08616100f, -0.01990223f, -0.09787235f, 
    -0.59247261f, 0.07742389f, 0.00030477f, 0.07991762f, 0.01190511f, -0.06799971f, 0.09218099f, 0.20816511f, 
    0.29794672f, 0.01878415f, 0.02383716f, -0.06426796f, 0.01601160f, -0.18526362f, -0.15724859f, -0.05590785f, 
    -0.13533202f, 0.10253703f, 0.00897106f, 0.23898566f, 0.11455221f, -0.11314864f, -0.00897993f, -0.04741541f, 
    -0.00327165f, -0.32294267f, 0.07611220f, 0.05712094f, -0.02913782f, -0.18661460f, 0.02357659f, 0.01418830f, 
    0.12119107f, 0.21427062f, 0.68046337f, 0.44671845f, -0.26985389f, 0.03879964f, 0.16801047f, -0.05795214f, 
    -0.05270075f, 0.21059586f, -0.18093273f, -0.44650522f, -0.31232077f, 0.34124163f, -0.07803051f, -0.09238116f, 
    0.05294393f, 0.02275418f, 0.34247494f, 0.10959980f, -0.13466175f, 0.09958019f, 0.03374056f, 0.07227910f, 
    -0.09161046f, 0.12273031f, -0.09796333f, -0.17404012f, 0.11768558f, 0.17728397f, -0.30640233f, 0.05362397f, 
    0.26790202f, 0.02017578f, -0.13825727f, -0.00013396f, -0.01610014f, 0.12703308f, 0.45075819f, 0.00214663f, 
    0.11778831f, -0.08897278f, -0.10040545f, -0.07258936f, 0.12770025f, 0.03041290f, 0.00085784f, -0.11314418f, 
    -0.06283023f, 0.21698506f, -0.02546784f, -0.04646976f, -0.05965342f, 0.11657545f, 0.06804208f, 0.08453920f, 
    -0.26017794f, -0.04652875f, -0.52128512f, 0.04676000f, -0.31753391f, -0.05894805f, 0.01638039f, -0.17041850f, 
    0.13023426f, 0.02641527f, -0.30879542f, 0.09194260f, 0.07961681f, 0.27860725f, -0.02522205f, 0.03212621f, 
    -0.05463162f, 0.09904607f, -0.30027577f, -0.09138502f, 0.30378869f, -0.28792039f, 0.29770556f, 0.08841696f, 
    -0.07268569f, -0.08625138f, 0.09654331f, 0.17406732f, -0.24084088f, 0.17569213f, 0.06685366f, -0.06514596f, 
    -0.21468729f, 0.11752642f, 0.03154329f, 0.18859421f, -0.10826391f, 0.00913650f, -0.51502883f, 0.15437384f, 
    -0.21373683f, 0.11803886f, -0.03569149f, -0.23218229f, 0.16630016f, 0.00981914f, 0.11591350f, -0.43833056f, 
    0.14482820f, 0.00001672f, -0.04446252f, 0.17817035f, 0.09172364f, 0.01246265f, -0.40206251f, -0.34254026f, 
    0.31711742f, -0.12282532f, -0.15571126f, 0.14409539f, -0.08962595f, -0.07638811f, 0.02737913f, 0.03899549f, 
    0.29721412f, -0.00913081f, -0.12031676f, 0.19825938f, -0.07211570f, 0.02068564f, 0.07846762f, 0.00379117f, 
    -0.00410370f, -0.01862168f, 0.02329216f, 0.03705467f, -0.14364290f, -0.06427631f, -0.12737754f, -0.08535022f, 
    0.17362629f, -0.13917372f, 0.10975274f, -0.22509174f, 0.07679740f, 0.16530621f, 0.06369159f, -0.01920979f, 
    0.05959556f, -0.11351907f, 0.01877886f, 0.16840604f, 0.13152407f, -0.03663987f, 0.19845966f, -0.02805493f, 
    0.10067318f, -0.11609547f, -0.11885142f, 0.30435440f, -0.02886703f, 0.09234414f, -0.11567520f, -0.11702852f, 
    -0.04250964f, -0.07731009f, -0.16009969f, 0.14564413f, 0.03382517f, 0.15337585f, -0.27089310f, 0.18273321f, 
    -0.30043778f, 0.22896655f, 0.23341002f, 0.19507881f, -0.02402849f, 0.49464652f, 0.05800632f, 0.08726898f, 
    0.22391917f, -0.00424580f, -0.01394225f, 0.09177882f, 0.07750733f, 0.23154894f, 0.31505215f, -0.44742399f, 
    -0.15192071f, 0.05971681f, -0.00103352f, -0.18188766f, 0.06986690f, 0.21533406f, 0.14747457f, 0.11735896f, 
    -0.24038519f, 0.00788115f, 0.10255591f, -0.05052724f, -0.03547090f, 0.04841244f, -0.15404880f, 0.19509739f, 
    0.25523227f, -0.15468827f, 0.19277626f, -0.16107982f, 0.09329088f, -0.03451290f, -0.21141426f, 0.02003586f, 
    0.03212781f, -0.06421468f, 0.34176621f, -0.14953606f, 0.14692260f, -0.03322465f, 0.00152601f, -0.10139439f, 
    0.09696408f, 0.02916905f, -0.18185166f, -0.04975821f, -0.08581240f, -0.04109217f, -0.03978263f, 0.15940922f, 
    -0.11981083f, 0.13345283f, -0.14743555f, 0.07149002f, 0.05706956f, 0.00399542f, 0.00513636f, 0.08995485f, 
    -0.23427862f, 0.16847560f, -0.12232570f, -0.07615227f, 0.24635689f, 0.01360821f, -0.14677291f, 0.11919154f, 
    -0.05295389f, -0.03665374f, -0.18423496f, -0.17989762f, -0.03364349f, -0.17879225f, 0.07672237f, -0.33036265f, 
    -0.12824583f, 0.02717334f, 0.01960720f, -0.03431337f, -0.04166732f, 0.08781374f, -0.05081933f, 0.13034844f, 
    -0.21968147f, 0.07192091f, -0.06726472f, -0.07835954f, -0.09210595f, 0.04385376f, -0.02206717f, 0.37234464f, 
    0.49235120f, 0.01128684f, 0.19801554f, -0.05901811f, 0.00727776f, 0.12682827f, 0.12936212f, 0.28478146f, 
    0.02495114f, -0.24385166f, -0.17154598f, 0.17631881f, 0.02571969f, -0.02452544f, 0.04807732f, 0.24136999f, 
    0.09649953f, -0.41241643f, 0.03745076f, -0.08143628f, -0.03048274f, 0.10071217f, -0.03946543f, -0.21848723f, 
    0.28211674f, 0.22224359f, 0.41441309f, -0.26832947f, 0.03265047f, 0.32942492f, -0.10426185f, -0.04113088f, 
    0.11075819f, 0.19034985f, 0.00079389f, -0.16702105f, 0.20485464f, -0.23086309f, -0.27868453f, -0.03210377f, 
    0.12406760f, -0.17044622f, 0.01094297f, 0.01728953f, 0.54158640f, 0.09372269f, 0.08963734f, 0.02101395f, 
    0.11973456f, -0.13887212f, 0.07401322f, 0.07949464f, -0.00678254f, 0.36825854f, 0.34524038f, 0.09482850f, 
    0.21092649f, 0.08672881f, -0.03246631f, -0.15810479f, 0.15293857f, 0.07068440f, 0.10667322f, 0.05303660f, 
    -0.00792032f, 0.20076263f, -0.27339554f, -0.11552113f, -0.05512551f, -0.09914615f, -0.09081947f, -0.90688407f, 
    0.05393889f, -0.18594734f, 0.08633535f, -0.13995418f, 0.13851590f, -0.13740687f, 0.09716426f, 0.07538490f, 
    -0.03423155f, -0.08196957f, 0.10072139f, 0.05782987f, 0.04561634f, 0.07762704f, -0.17300580f, 0.00022452f, 
    0.05720350f, -0.24143183f, 0.02491018f, -0.20071575f, -0.11190772f, 0.25533172f, 0.07376690f, -0.00227418f, 
    -0.09638291f, -0.31402466f, -0.46381378f, 0.41595164f, 0.01452371f, 0.03051263f, 0.08389254f, 0.13704550f, 
    0.19626418f, 0.11939147f, 0.01900995f, -0.70390338f, -0.24196668f, -0.19422248f, 0.21305726f, 0.04320939f, 
    0.10996898f, -0.06881016f, 0.06204121f, -0.09367730f, 0.07911484f, -0.01454197f, -0.15800324f, -0.06144358f, 
    -0.03099504f, -0.20342694f, -0.01019050f, -0.03364393f, -0.22192790f, 0.13107307f, -0.15326466f, -0.29788870f, 
    0.00487607f, 0.07530005f, 0.11163930f, 0.05380164f, -0.06905085f, -0.13277657f, -0.23354274f, 0.10602088f, 
    0.02446209f, 0.18590789f, -0.08648290f, -0.18445040f, -0.24994037f, -0.02722816f, -0.01483091f, -0.00978946f, 
    0.04287520f, 0.13979287f, 0.36780751f, -0.03799450f, -0.22620723f, 0.22652195f, 0.18409887f, 0.05150358f, 
    0.31033862f, -0.18518816f, -0.09327994f, -0.31356320f, -0.21973285f, 0.09412806f, -0.02411430f, 0.15351894f, 
    0.04485218f, 0.18025945f, -0.14173543f, -0.04537061f, -0.17972000f, 0.01096349f, -0.05858495f, -0.06556275f, 
    0.21746938f, 0.31072161f, 0.25223577f, 0.28498074f, -0.31233799f, 0.13453916f, 0.09164588f, -0.06154328f, 
    0.08378430f, -0.08521701f, -0.08075884f, -0.19278465f, 0.09449447f, -0.20746525f, -0.11241788f, 0.09692495f, 
    -0.34699258f, 0.06902206f, 0.07071872f, -0.12472109f, -0.20250906f, -0.50399899f, 0.05124768f, 0.01875500f, 
    0.16286777f, -0.06972069f, -0.00482116f, 0.13831609f, 0.10047002f, -0.15518062f, 0.05114408f, 0.09811586f, 
    -0.13278458f, -0.13743524f, -0.00839111f, 0.14725943f, 0.14104035f, 0.10493466f, -0.09626686f, 0.12307860f, 
    -0.08689758f, -0.14859530f, -0.09107655f, 0.10961396f, 0.01829678f, 0.05794492f, 0.05948743f, -0.26213765f, 
    0.14701663f, 0.28896177f, 0.06037002f, -0.13426866f, -0.26341251f, 0.16305025f, -0.05966106f, -0.17203619f, 
    0.12920636f, -0.11197270f, 0.02340429f, 0.20429677f, -0.04809254f, 0.09625012f, 0.02724035f, 0.04680913f, 
    -0.16951232f, -0.60996157f, -0.23990658f, 0.14645831f, -0.10238613f, -0.01419258f, 0.04441757f, 0.04798158f, 
    0.08127300f, -0.01118038f, 0.12349815f, 0.14586483f, -0.04809770f, -0.21780460f, -0.12457104f, 0.11634790f, 
    -0.05906831f, 0.03919756f, 0.08435247f, 0.01955581f, -0.34731826f, 0.03367393f, -0.00890441f, 0.15499125f, 
    -0.16253206f, -0.00624486f, -0.02560137f, 0.03574492f, 0.02824871f, 0.11902820f, 0.12104198f, 0.06037639f, 
    -0.09711584f, -0.00978921f, 0.05381295f, 0.11606850f, -0.14605190f, -0.13954113f, -0.31562135f, 0.14560953f, 
    -0.07888369f, -0.01594360f, -0.20017625f, -0.12872738f, -0.12768407f, -0.08640776f, 0.36302549f, -0.18506385f, 
    -0.05128696f, -0.12681146f, -0.02747808f, -0.01724357f, 0.29590052f, 0.16896784f, 0.01756069f, 0.50986677f, 
    0.20773877f, -0.08819987f, -0.15445441f, -0.17410740f, 0.06382688f, -0.05739813f, -0.08258107f, 0.10354146f, 
    -0.35313404f, 0.09158820f, -0.09885900f, -0.06745225f, -0.03914551f, 0.06759875f, 0.14226031f, 0.11107197f, 
    0.05766378f, 0.42192706f, 0.15602081f, 0.33086705f, -0.13940036f, 0.11798944f, -0.27876419f, -0.12408755f, 
    -0.21087046f, 0.02953835f, 0.15327252f, 0.23034932f, 0.07934765f, -0.03242483f, 0.08916166f, 0.24204156f, 
    -0.10860912f, -0.12501091f, -0.08648528f, -0.48410758f, -0.21152331f, 0.25478524f, -0.03828271f, 0.23240051f, 
    0.18095815f, -0.01275734f, 0.11705348f, -0.04457445f, 0.38347074f, 0.08878887f, -0.33636057f, 0.11709311f, 
    0.06125619f, 0.04643658f, 0.01777806f, -0.23907268f, 0.03611009f, -0.15128404f, 0.48778018f, -0.35982803f, 
    0.04538545f, -0.05377701f, -0.00802215f, 0.24900874f, 0.12609005f, 0.02884937f, 0.17673373f, -0.53065288f, 
    0.02705039f, -0.18865518f, 0.10466197f, 0.12061743f, -0.02565091f, -0.12640004f, 0.01795218f, 0.34056047f, 
    0.22143514f, -0.07832483f, -0.05218960f, 0.05831925f, 0.13464405f, 0.11330468f, 0.11630777f, 0.12246799f, 
    0.11812086f, -0.18725047f, 0.02625691f, 0.17151630f, -0.29074585f, -0.16496450f, 0.28547069f, 0.23207988f, 
    -0.14442162f, -0.49843317f, -0.20890354f, -0.11239147f, -0.12430785f, 0.05491118f, -0.19333823f, -0.12107044f, 
    -0.00751198f, -0.02173072f, -0.63371396f, 0.27626544f, -0.20657311f, -0.08332868f, -0.06272746f, 0.01573710f, 
    -0.04354523f, 0.15126073f, -0.04079575f, 0.33857456f, 0.05835115f, -0.16319434f, -0.04067484f, -0.07663579f, 
    -0.17152293f, 0.16760315f, 0.12019496f, 0.06186072f, 0.18442787f, -0.00509713f, 0.46289074f, -0.29085690f, 
    -0.24356169f, -0.24589325f, -0.01263652f, 0.22617228f, 0.03528179f, 0.00764635f, -0.02716526f, -0.21761861f, 
    0.03378088f, -0.02735094f, 0.03627920f, -0.18345343f, 0.12205868f, 0.02490359f, 0.36928552f, 0.66663438f, 
    -0.21067792f, 0.16658282f, -0.06957102f, -0.07169552f, 0.00626072f, 0.02285480f, -0.27867594f, 0.32512456f, 
    -0.28359380f, 0.02067270f, 0.37035081f, 0.33532646f, 0.28345248f, 0.06599786f, -0.01893073f, -0.05946049f, 
    0.18363616f, -0.06411488f, -0.23401044f, 0.10976495f, -0.10120726f, -0.15093157f, -0.19896132f, -0.00154162f, 
    0.20351830f, 0.17443147f, 0.22104397f, -0.00697694f, 0.05513118f, 0.02196992f, 0.05580625f, 0.10233255f, 
    0.05030125f, 0.05251982f, 0.27245587f, -0.15714161f, 0.06129942f, -0.11439080f, -0.12026954f, -0.01150315f, 
    0.04954332f, 0.06984633f, -0.10045954f, -0.07891812f, 0.32385504f, -0.01747858f, 0.18366642f, 0.09399716f, 
    -0.11180049f, 0.03019829f, -0.18019116f, -0.11693830f, 0.20037508f, -0.15347867f, 0.28802848f, 0.02019791f, 
    -0.15330765f, 0.17085330f, 0.05262673f, -0.07733104f, -0.06437875f, -0.19802016f, -0.03321302f, -0.14053869f, 
    0.11064956f, -0.03244421f, -0.29447284f, -0.11470893f, -0.21766908f, -0.00481497f, -0.11775457f, 0.22912557f, 
    0.21598279f, 0.02571329f, -0.29104778f, -0.07431956f, -0.05086704f, -0.10628457f, -0.03624548f, 0.13773181f, 
    -0.12928683f, -0.24915290f, -0.03554151f, 0.12881751f, 0.12936477f, 0.01846649f, -0.21043257f, 0.06938968f, 
    0.00585824f, 0.20239875f, -0.26765224f, -0.01535396f, -0.12636913f, -0.00070665f, -0.03191633f, -0.10817835f, 
    0.13541946f, 0.13371918f, 0.05892647f, -0.00030084f, 0.16341722f, 0.08413114f, 0.04010794f, 0.03828701f, 
    -0.02969432f, 0.13117653f, 0.48405972f, 0.08427692f, 0.21083675f, 0.16637118f, 0.15390806f, -0.05972986f, 
    -0.02256705f, 0.21793608f, -0.11195393f, 0.06325987f, 0.01546231f, 0.05322578f, 0.10631169f, 0.08380828f, 
    0.06819268f, -0.04472523f, 0.22439121f, 0.16454138f, -0.09605251f, 0.01170260f, 0.04264501f, 0.06375918f, 
    0.19614969f, -0.03471304f, -0.09396991f, 0.02371890f, -0.03966947f, -0.24791433f, -0.12683763f, 0.17989624f, 
    0.17450175f, -0.10586145f, -0.20411813f, -0.18366215f, 0.10883043f, 0.17899981f, -0.00591697f, -0.24972527f, 
    -0.41237769f, 0.11453398f, 0.09751560f, -0.04544755f, -0.10880990f, 0.08524484f, -0.01249860f, -0.41078430f, 
    -0.03978897f, -0.01633449f, 0.00521108f, -0.11011162f, -0.06886861f, 0.07081041f, 0.04004259f, -0.20271185f, 
    -0.37606263f, 0.02695687f, 0.24056150f, -0.13681941f, -0.12047865f, -0.07810266f, 0.04905558f, -0.07062785f, 
    -0.04028317f, 0.42392391f, -0.50841200f, -0.30270311f, -0.02592143f, -0.00836975f, 0.06733287f, 0.09169973f, 
    0.08889026f, -0.02127430f, 0.22299309f, 0.16102436f, -0.03650538f, 0.00044030f, 0.11488724f, 0.05445604f, 
    -0.14068861f, 0.18644975f, -0.09206800f, -0.14591675f, 0.09353623f, -0.06829483f, 0.02727939f, 0.05018830f, 
    0.00635731f, -0.02549696f, -0.01371886f, 0.06124357f, -0.08154705f, -0.09996815f, -0.02538116f, -0.10337093f, 
    0.14994560f, 0.04570245f, -0.03017652f, -0.04810529f, -0.00267571f, -0.15055205f, -0.50878692f, 0.02914251f, 
    -0.32694587f, -0.20785478f, 0.18789580f, 0.13622764f, -0.34918448f, -0.02843158f, 0.32013312f, 0.01448139f, 
    -0.06847576f, -0.00416147f, -0.06544857f, -0.37368953f, 0.06976049f, 0.06577865f, 0.23324932f, 0.31768343f, 
    -0.05549257f, 0.00186121f, -0.17835096f, 0.39282399f, -0.20293741f, -0.02098460f, 0.11649005f, 0.07328078f, 
    -0.20440048f, -0.13487487f, -0.11130974f, 0.21416475f, -0.21144596f, 0.02130575f, 0.01082336f, -0.07288785f, 
    0.16579700f, 0.19495638f, 0.17042585f, 0.02335209f, -0.15567248f, 0.07503966f, -0.00343948f, 0.15888844f, 
    0.12217330f, 0.11730292f, 0.13675594f, -0.01685911f, 0.08602036f, -0.17319745f, 0.07065538f, 0.09660737f, 
    -0.07483774f, 0.03949237f, -0.00498723f, -0.17295422f, -0.23145558f, -0.18764251f, -0.05141444f, -0.02025492f, 
    -0.10132695f, 0.18326604f, -0.01272913f, 0.08601610f, 0.08336423f, -0.05611544f, -0.09035572f, -0.13567798f, 
    -0.10873164f, -0.06074013f, 0.05568752f, -0.06286865f, 0.21530974f, 0.17815904f, 0.25968686f, 0.11651868f, 
    0.07868773f, 0.20148520f, -0.13391051f, 0.03629317f, -0.08783007f, 0.13676965f, 0.10670341f, -0.36897182f, 
    -0.02225900f, -0.24211192f, -0.04596926f, 0.07472015f, 0.02720267f, 0.14907435f, 0.15634233f, -0.00734732f, 
    0.32820246f, -0.00191306f, -0.10625833f, -0.05911408f, -0.23090470f, -0.12284273f, 0.00791357f, -0.04930135f, 
    -0.04791559f, -0.02806063f, 0.03034679f, -0.04569390f, 0.04432454f, -0.03689342f, 0.00193120f, -0.02433910f, 
    -0.02111833f, 0.04620320f, -0.04061548f, -0.05596352f, -0.04189770f, 0.00835422f, -0.01537567f, 0.03947277f, 
    0.04214660f, 0.01711268f, 0.04866871f, -0.01584969f, -0.06581394f, -0.00510408f, -0.04076324f, 0.03987907f, 
    -0.03868953f, 0.00065622f, 0.02001331f, -0.00332588f, -0.00014439f, 0.03492397f, 0.01491598f, 0.01278617f, 
    0.00160695f, -0.03404555f, 0.00886238f, 0.03641820f, 0.04779253f, -0.03906132f, 0.03928529f, 0.00853537f, 
    -0.04100020f, -0.05806311f, 0.01874358f, -0.05305495f, -0.03814410f, -0.03998036f, -0.06462482f, -0.00902536f, 
    -0.02486377f, 0.03710017f, -0.06442875f, 0.00861858f, -0.00301115f, -0.04671545f, -0.06526334f, 0.04463149f, 
    0.05100170f, -0.03676680f, -0.02151933f, -0.03465061f, 0.04131347f, -0.01132787f, -0.06311309f, -0.04641686f, 
    -0.02217320f, -0.00578030f, -0.04357333f, 0.00578400f, -0.03515918f, -0.05247285f, -0.01115867f, -0.06065907f, 
    0.02181333f, 0.00845939f, 0.01392792f, 0.01625234f, -0.05357054f, -0.03757707f, -0.06123241f, -0.01899084f, 
    0.01651458f, 0.01807467f, -0.00698947f, -0.04823755f, -0.02875309f, -0.03816900f, 0.00490862f, 0.04803837f, 
    0.00172924f, 0.02917705f, 0.01096194f, -0.03149015f, -0.04331170f, -0.04785021f, 0.03274521f, -0.00491912f, 
    0.00023044f, -0.06176895f, -0.03710813f, -0.00933642f, -0.02530937f, -0.01027968f, -0.05381074f, -0.01604336f, 
    -0.00493689f, 0.02847410f, 0.00651114f, -0.04783594f, 0.01773330f, -0.05324722f, -0.00646834f, 0.05620540f, 
    0.04548808f, 0.00446651f, 0.03655329f, -0.03220356f, 0.04255608f, 0.02279266f, 0.03866622f, 0.00727647f, 
    -0.04968396f, -0.05755078f, -0.06513160f, 0.03618574f, -0.03343194f, -0.01682696f, 0.02200360f, -0.06336250f, 
    0.04173876f, -0.03070789f, -0.03021785f, -0.05041905f, -0.02138738f, -0.01112569f, 0.02649673f, -0.06356471f, 
    -0.06608304f, 0.00100858f, -0.01110996f, 0.00156253f, -0.05892539f, -0.04089501f, 0.03973176f, 0.01243876f, 
    -0.06941845f, -0.03934268f, 0.02171320f, -0.05376326f, -0.06262301f, 0.02155123f, 0.03483943f, 0.00395092f, 
    -0.03869131f, -0.06700529f, -0.06734017f, 0.01604175f, -0.00711806f, 0.01077575f, -0.03757799f, 0.03538286f, 
    -0.03548579f, 0.02944357f, 0.02689257f, 0.04839075f, -0.04178559f, 0.01709138f, 0.01891349f, 0.02619610f, 
    0.01309068f, -0.00385998f, 0.03298244f, -0.01130508f, 0.04695649f, -0.00636573f, -0.00088202f, -0.04930768f, 
    -0.03040884f, -0.03966355f, 0.04993568f, -0.03118741f, 0.02361591f, -0.00857860f, -0.03393974f, -0.02625373f, 
    -0.03114647f, 0.05538221f, -0.02122672f, 0.04087994f, 0.00886525f, -0.04401452f, 0.02501466f, -0.04863477f, 
    -0.00880128f, 0.00394301f, 0.00801259f, -0.04761005f, 0.04620558f, 0.05711314f, -0.02648974f, 0.02601871f, 
    0.03454321f, -0.04384575f, 0.01182754f, 0.03809772f, -0.03716809f, 0.02043296f, 0.04517340f, -0.02245759f, 
    -0.05116257f, -0.05199135f, 0.05330976f, -0.02505876f, -0.01993330f, 0.01514520f, -0.02773786f, -0.05886387f, 
    -0.06185033f, -0.01186821f, 0.00528335f, -0.01864356f, 0.01022875f, -0.05513043f, 0.02821855f, 0.03540045f, 
    0.03045483f, 0.02264610f, 0.00287278f, -0.03942374f, 0.02779291f, -0.04496267f, 0.03621577f, 0.04276437f, 
    0.01373875f, 0.00404766f, -0.02010199f, -0.03995186f, 0.04223944f, 0.00808416f, 0.02253367f, -0.01136007f, 
    -0.05242759f, 0.01994836f, 0.00382121f, 0.01587550f, -0.06503425f, -0.00631210f, 0.03318800f, 0.01151669f, 
    -0.05859873f, 0.00659331f, -0.05431634f, -0.00944001f, -0.02204089f, 0.02722120f, -0.02558215f, -0.05146918f, 
    0.00143878f, 0.04239103f, -0.04906723f, 0.01737749f, 0.00243227f, 0.05230394f, 0.00714942f, -0.03072590f, 
    -0.06682209f, -0.06846651f, -0.02183933f, 0.02186453f, 0.02662620f, -0.04528415f, -0.05227122f, 0.02305616f, 
    0.03851625f, -0.02891693f, 0.01790408f, 0.04446886f, -0.03033407f, 0.00556585f, 0.00442189f, -0.05399970f, 
    0.01013611f, -0.03612724f, 0.04053557f, -0.04129846f, 0.02068770f, -0.01770945f, -0.06447315f, -0.01752453f, 
    0.33226401f, 0.14679804f, 0.25300691f, -0.22155219f, -0.04962926f, 0.07488946f, -0.15434593f, 0.07163576f, 
    0.01583762f, -0.16853513f, 0.13923627f, 0.08650792f, 0.12894443f, 0.11031715f, -0.27938524f, -0.05510205f, 
    -0.15034206f, 0.02206668f, -0.01547897f, -0.15335259f, 0.64258254f, -0.10975132f, 0.19473159f, -0.01776576f, 
    -0.08545646f, 0.00127438f, -0.00288815f, -0.18517612f, 0.36502647f, 0.45145431f, -0.07424649f, 0.22997466f, 
    0.15397878f, -0.13033041f, 0.09332722f, 0.00814668f, 0.19317056f, -0.07134191f, -0.19008085f, -0.08846898f, 
    -0.08584341f, 0.06319693f, 0.04627875f, -0.05380732f, -0.21053676f, -0.03513569f, 0.03435673f, -0.18677333f, 
    0.17999431f, 0.12368213f, 0.13424788f, -0.12738694f, -0.02677373f, -0.02632607f, -0.05410584f, 0.02549672f, 
    -0.01959507f, -0.01120171f, 0.10215513f, 0.18583575f, -0.12515698f, -0.13630919f, -0.00925061f, 0.17981887f, 
    -0.00545672f, 0.00473935f, 0.04910490f, 0.01792726f, 0.36875367f, 0.08983085f, -0.10625438f, -0.20638494f, 
    -0.18381608f, -0.37257195f, 0.18588139f, -0.07723244f, -0.01106321f, -0.01631371f, 0.13823843f, -0.02258483f, 
    0.06952058f, 0.05656270f, -0.08049286f, 0.11328223f, 0.08335420f, 0.00800799f, -0.01392640f, -0.17900181f, 
    0.09698872f, 0.00161371f, -0.23810898f, 0.16015761f, -0.04705246f, 0.09257933f, -0.00160186f, -0.19221406f, 
    0.01672521f, 0.15525676f, -0.13770704f, 0.00904239f, 0.03102644f, -0.03008557f, 0.12509733f, 0.05795600f, 
    -0.15054384f, 0.08181597f, 0.00489700f, 0.09858403f, -0.25681236f, 0.02088016f, -0.33035809f, 0.05094707f, 
    0.17062651f, 0.13507338f, 0.05017651f, -0.08589078f, -0.22703336f, -0.06307235f, -0.07617640f, 0.02130119f, 
    -0.20567767f, -0.02725383f, -0.06155377f, 0.06274068f, -0.09969466f, 0.05665934f, -0.08423355f, 0.12175477f, 
    -0.16909187f, 0.16387160f, 0.15003610f, 0.01660735f, 0.03103845f, 0.09391564f, 0.00979093f, -0.51732028f, 
    -0.10039979f, 0.03436732f, 0.22998415f, 0.02033472f, 0.01229400f, 0.18419945f, -0.03513245f, -0.19250806f, 
    -0.04498067f, 0.15626238f, -0.15879925f, -0.00911473f, -0.05118144f, 0.15948287f, -0.04247312f, 0.02695750f, 
    -0.28733665f, 0.47169966f, 0.08868325f, 0.08014260f, -0.13353527f, -0.15750888f, 0.18936639f, 0.06659245f, 
    0.02604073f, -0.12145496f, 0.15743497f, 0.09849423f, 0.36021057f, -0.10080396f, 0.08583099f, -0.05161811f, 
    -0.05861064f, -0.00978992f, -0.11405855f, -0.02915876f, -0.13972980f, -0.13304234f, 0.05567228f, -0.07588095f, 
    -0.03959818f, 0.07873092f, -0.01276297f, 0.01102208f, -0.02052821f, -0.30859417f, 0.21186714f, -0.04300494f, 
    0.02218636f, 0.15400667f, 0.09396826f, -0.04378509f, -0.04348278f, -0.24652351f, -0.36267072f, 0.10208068f, 
    -0.18152536f, 0.10337555f, -0.15249087f, -0.26681119f, 0.02865545f, 0.11108900f, 0.30056304f, -0.03441719f, 
    0.16290081f, 0.08916570f, -0.11953574f, -0.02972005f, -0.13237114f, 0.05517386f, -0.21605462f, 0.07304152f, 
    0.11609054f, -0.24874090f, 0.16857642f, 0.09558731f, 0.01113516f, -0.16394164f, -0.03053967f, -0.08477687f, 
    0.37112656f, -0.10143874f, -0.19055949f, 0.01540017f, 0.00622512f, 0.00755645f, 0.03069800f, -0.11767866f, 
    0.03645232f, 0.07634391f, 0.18381229f, 0.08333269f, -0.06752104f, -0.13275111f, -0.02604794f, 0.18980521f, 
    -0.02745071f, -0.16182604f, -0.10904998f, -0.04453462f, 0.02194452f, -0.06803050f, 0.03571972f, -0.12985297f, 
    -0.15026751f, -0.07991531f, 0.14882222f, 0.11740530f, -0.00067552f, 0.09909803f, -0.00648147f, -0.03835548f, 
    0.08148810f, -0.09881513f, 0.01520169f, -0.10186420f, 0.11904370f, -0.22690934f, -0.34299421f, 0.19412522f, 
    -0.18893820f, 0.24314186f, 0.11624932f, 0.18220657f, -0.01964400f, -0.01521463f, 0.27813748f, -0.10612949f, 
    -0.01383016f, 0.12097282f, -0.10473192f, -0.04846772f, -0.10305357f, -0.20696102f, -0.35835484f, 0.05386036f, 
    0.53752321f, -0.31864023f, -0.07850581f, 0.18363151f, 0.00895336f, 0.20436649f, 0.18964456f, 0.21094067f, 
    0.02645161f, 0.03597838f, -0.00965803f, -0.13722014f, -0.00651130f, -0.23496695f, 0.21432583f, -0.16041015f, 
    -0.00808668f, -0.14939556f, -0.10809745f, 0.14571120f, 0.13881676f, -0.01722407f, 0.24756093f, -0.02397706f, 
    0.15970673f, -0.14082243f, -0.16338980f, 0.32258555f, -0.02220002f, 0.06291198f, 0.22013423f, -0.09702791f, 
    0.11601889f, 0.31569743f, -0.01252373f, 0.12350231f, -0.46085298f, 0.03860871f, 0.20898236f, -0.08646542f, 
    0.03475009f, -0.14184977f, 0.15639018f, 0.11823922f, -0.12347346f, 0.20790917f, 0.16147621f, 0.00966187f, 
    0.26020724f, 0.07779279f, 0.09053245f, -0.03920363f, -0.35801023f, -0.40239275f, 0.20073466f, -0.00476746f, 
    0.27326104f, 0.14760248f, -0.14151779f, 0.08402855f, -0.32627469f, 0.08059021f, 0.11877875f, 0.27626997f, 
    -0.22534342f, -0.37994623f, -0.11588147f, -0.03081296f, 0.05750755f, 0.24073467f, 0.30589294f, 0.02580959f, 
    0.14838153f, 0.05244584f, -0.09511323f, -0.07818655f, 0.02998111f, 0.27376473f, 0.13032746f, 0.08040089f, 
    0.05250484f, 0.10991204f, -0.00882355f, 0.11282430f, -0.15349399f, -0.10219627f, 0.40369818f, 0.14078937f, 
    -0.16138116f, 0.18541034f, 0.09120674f, 0.23900385f, -0.03700952f, 0.11637395f, 0.06270022f, 0.21072866f, 
    -0.29522988f, -0.38922566f, -0.14273627f, 0.16777462f, 0.02118521f, 0.15956868f, 0.20146272f, 0.02323647f, 
    0.35394651f, -0.25031030f, -0.02048309f, -0.24308072f, 0.10588636f, -0.22913237f, 0.01406921f, 0.15755343f, 
    -0.02003432f, -0.01364735f, 0.06818718f, -0.17573534f, -0.14297290f, 0.11343131f, 0.03813703f, 0.19561134f, 
    0.19259460f, 0.00763741f, -0.39068088f, -0.11835732f, 0.16950949f, 0.06814739f, 0.24400832f, 0.07209488f, 
    -0.01732394f, -0.10962003f, 0.08938177f, 0.23918208f, 0.07355378f, -0.09069829f, 0.04967583f, -0.28704622f, 
    0.10747000f, 0.01992192f, 0.03653714f, 0.22242595f, 0.01159104f, -0.10265899f, -0.38276640f, -0.23762976f, 
    -0.00853141f, 0.03802570f, 0.36441508f, 0.09163373f, 0.06266838f, -0.06013212f, 0.05608134f, -0.01591467f, 
    0.03854913f, -0.13271840f, -0.09472988f, -0.15291283f, 0.15930997f, -0.16270050f, 0.01848030f, 0.10697992f, 
    0.32191879f, 0.09420344f, 0.00312150f, -0.13328688f, -0.21419707f, -0.34301752f, 0.31070080f, 0.37786695f, 
    0.19862477f, 0.06166745f, 0.31626832f, -0.02438552f, 0.05918359f, 0.22505927f, -0.21410744f, 0.29522455f, 
    0.03675265f, 0.26763406f, -0.13134703f, -0.00486478f, 0.00088509f, -0.08293695f, 0.02612263f, 0.08843113f, 
    -0.00936729f, -0.14133511f, 0.13735603f, -0.34491628f, 0.12045494f, 0.05882092f, 0.05025387f, 0.16137555f, 
    0.11700228f, -0.06674986f, -0.08435148f, 0.08411828f, -0.25578457f, 0.16208231f, -0.03238524f, 0.17339946f, 
    -0.00796934f, 0.16702755f, -0.00207482f, -0.06910524f, -0.30768928f, -0.11806101f, 0.39140549f, -0.24595912f, 
    0.34885547f, -0.10982135f, -0.31439242f, 0.20590328f, 0.00472986f, 0.07892315f, -0.29081237f, -0.44553867f, 
    -0.11826292f, 0.02068482f, 0.13907869f, 0.03213964f, 0.09443298f, -0.37050748f, 0.05321676f, -0.32975423f, 
    0.05376163f, -0.13907947f, 0.20155534f, 0.13621172f, -0.27396485f, 0.19761769f, 0.16235070f, 0.03339659f, 
    -0.15741709f, -0.09970581f, -0.01345846f, 0.03986352f, -0.09536862f, -0.02266665f, 0.13788740f, 0.02937408f, 
    -0.13489020f, -0.62799233f, -0.28927195f, -0.19181223f, -0.02067929f, 0.11418799f, -0.06918876f, 0.16732736f, 
    0.03158677f, 0.08601878f, -0.18287827f, -0.02046249f, -0.13209879f, 0.13782491f, 0.13680232f, 0.12199874f, 
    0.09478905f, 0.15027800f, 0.01719072f, 0.11093549f, 0.18999483f, -0.10451969f, -0.04761580f, -0.16097730f, 
    -0.62906492f, 0.47303912f, 0.16157500f, 0.23521832f, -0.33440173f, 0.13044748f, 0.08662284f, -0.04716001f, 
    0.21901843f, -0.08573397f, -0.09010940f, 0.34960935f, 0.16056466f, 0.00420305f, -0.04878119f, 0.18138976f, 
    0.11323551f, 0.07008226f, 0.17553750f, -0.00376990f, -0.04795935f, 0.37185770f, -0.14460512f, -0.09813126f, 
    -0.41516212f, 0.11795210f, 0.11145413f, -0.00217077f, 0.05104154f, -0.22806063f, -0.18311566f, -0.09292278f, 
    -0.17500474f, -0.41572791f, 0.12389300f, 0.12987196f, 0.16786441f, 0.23293522f, -0.10734495f, -0.00777474f, 
    -0.06162196f, -0.01481910f, -0.05431065f, 0.03137555f, -0.03606164f, -0.05658331f, 0.03392326f, 0.00020640f, 
    -0.00199577f, -0.02495696f, -0.01728044f, -0.00244467f, -0.01597598f, 0.04910471f, 0.01815644f, 0.01980468f, 
    -0.03558671f, -0.01822324f, -0.03119432f, -0.05693283f, 0.03355413f, -0.02109702f, 0.02901928f, -0.05624790f, 
    0.05007874f, -0.04860616f, 0.04528347f, 0.03791688f, 0.01818600f, 0.03533142f, -0.02359655f, -0.06247538f, 
    0.04530030f, -0.06558748f, 0.04641536f, 0.03673320f, 0.00535802f, -0.06338733f, -0.05163866f, 0.02320497f, 
    -0.00689207f, -0.01052599f, 0.01614233f, -0.00459619f, -0.05559023f, -0.05036226f, 0.00355262f, -0.03144143f, 
    0.00051998f, 0.02182170f, 0.01767990f, 0.04663917f, -0.06047979f, -0.00772078f, -0.05396064f, 0.04699977f, 
    -0.03794647f, -0.02315968f, 0.03212354f, -0.06687132f, 0.02721605f, -0.04143424f, -0.02908595f, -0.06152766f, 
    0.04799537f, 0.03946277f, -0.03094299f, -0.02720778f, 0.03176854f, -0.04325051f, -0.04101849f, 0.04338187f, 
    -0.03093689f, -0.02298170f, 0.03689903f, 0.00758108f, -0.03272631f, -0.03032544f, 0.01001775f, 0.01763241f, 
    -0.05692008f, 0.02246371f, 0.01163946f, -0.01365753f, 0.00786598f, 0.02919216f, -0.04509850f, 0.02718768f, 
    -0.01654495f, -0.04842672f, 0.03373328f, -0.01411618f, 0.04182761f, 0.02804528f, -0.06534532f, 0.03805294f, 
    0.03494199f, 0.03370124f, 0.04607117f, 0.01788671f, -0.04861850f, 0.01969586f, -0.04453627f, -0.00492094f, 
    -0.03258066f, -0.01791620f, -0.06638688f, 0.01783880f, -0.00569899f, 0.00830501f, 0.04041309f, -0.02120479f, 
    -0.02243533f, -0.05274603f, -0.06728865f, 0.00117297f, 0.04645274f, -0.05996798f, -0.00875675f, -0.01782291f, 
    -0.00333336f, -0.03110386f, -0.00896475f, -0.00660567f, -0.05892924f, -0.01987934f, -0.06295644f, -0.02182036f, 
    0.01056055f, -0.04656485f, 0.04593404f, 0.05064209f, -0.03329102f, 0.02885666f, -0.00251726f, 0.04098726f, 
    -0.01531358f, -0.02059606f, 0.02226238f, -0.03381026f, -0.06486655f, -0.04669545f, 0.00303309f, 0.03972683f, 
    0.00136232f, -0.00709429f, -0.00977894f, -0.03331293f, -0.04097220f, 0.03285789f, -0.04979764f, -0.02859607f, 
    0.03795699f, 0.01742806f, -0.03124013f, -0.00181890f, -0.01313819f, -0.06153159f, -0.04442106f, -0.01490224f, 
    0.00093396f, -0.03387592f, -0.02411973f, -0.00053660f, -0.06058890f, 0.01718059f, -0.00045889f, 0.01045042f, 
    -0.01955276f, -0.02711399f, 0.03127060f, -0.02926776f, 0.02479967f, 0.04281027f, -0.04098716f, -0.03689770f, 
    -0.06284089f, -0.06134032f, -0.02481231f, 0.04602483f, -0.00098965f, -0.05601488f, -0.04020144f, 0.03049823f, 
    0.04955012f, 0.01509116f, -0.01838180f, 0.04324589f, -0.04606009f, -0.01788005f, -0.00845190f, -0.03271910f, 
    0.03548168f, -0.02153176f, -0.02511633f, -0.01280906f, -0.02576618f, -0.02658785f, -0.03365009f, -0.05423075f, 
    -0.05981867f, -0.01517474f, -0.02282461f, 0.03742893f, 0.00383125f, -0.02571315f, 0.03608326f, 0.02896628f, 
    0.04475023f, -0.02207940f, -0.00542180f, -0.05535226f, 0.05094998f, 0.03269486f, -0.05665093f, 0.03867852f, 
    -0.02617448f, -0.04088005f, -0.02067345f, 0.02884187f, -0.03612518f, 0.01712348f, -0.04209385f, -0.00949677f, 
    0.05075313f, -0.03707379f, -0.01262588f, 0.02814636f, 0.00713998f, 0.00618156f, 0.03847987f, -0.04500163f, 
    -0.05215956f, 0.03428539f, 0.03575428f, -0.05241779f, -0.00745086f, -0.01391257f, 0.01703046f, -0.02829679f, 
    -0.04361755f, 0.03892475f, 0.02149458f, 0.00055225f, 0.04297508f, 0.03971673f, -0.06183457f, -0.05787107f, 
    0.00939614f, 0.00717603f, -0.00191141f, -0.02791822f, -0.04264437f, -0.04107476f, -0.00419434f, 0.03134145f, 
    -0.05419583f, 0.01532706f, -0.05381384f, 0.01023560f, 0.00332794f, -0.04845176f, -0.00869901f, -0.03973961f, 
    -0.02546223f, -0.01532028f, -0.00364702f, -0.03210251f, -0.02192366f, -0.01718689f, -0.02053877f, -0.05553238f, 
    0.01762678f, -0.05380162f, -0.00444867f, 0.03367848f, -0.05947430f, -0.01806266f, 0.02249137f, 0.02434615f, 
    0.03613489f, 0.03177033f, -0.06819948f, -0.03280125f, -0.02312118f, -0.05048310f, 0.00912768f, 0.04808785f, 
    0.20894590f, -0.11349338f, -0.05607019f, -0.11057706f, 0.03753337f, -0.06540680f, 0.11438300f, -0.06934852f, 
    -0.01432224f, 0.22602819f, 0.14264004f, -0.05000526f, 0.18264502f, -0.00736670f, 0.09884207f, -0.09480968f, 
    0.06617640f, 0.05908033f, 0.27058828f, 0.25719789f, -0.00234879f, -0.13187955f, 0.15249841f, -0.07594349f, 
    0.01955977f, 0.03749188f, 0.06690636f, 0.25007290f, 0.01930311f, 0.02103949f, -0.11899060f, 0.05227894f, 
    0.06312111f, -0.04483875f, 0.16100153f, -0.10720673f, -0.09123880f, -0.07719141f, -0.02930406f, 0.03656809f, 
    -0.18930186f, 0.28534001f, 0.02863759f, 0.14718503f, 0.03864821f, -0.08470913f, -0.06523991f, 0.09498962f, 
    -0.07944704f, 0.15184744f, 0.09661753f, -0.12917273f, -0.13982762f, -0.06092075f, -0.08212245f, -0.18784969f, 
    -0.02069466f, 0.24848205f, 0.06011168f, 0.06366213f, 0.13702540f, -0.06718320f, -0.04493135f, -0.37957129f, 
    0.03044971f, -0.16770290f, 0.03246817f, 0.08243656f, 0.04103381f, 0.23465931f, -0.05956086f, 0.00088441f, 
    -0.02992292f, -0.08123199f, -0.15957236f, -0.16154741f, 0.26090410f, -0.03363276f, 0.02824158f, -0.10248976f, 
    0.10910562f, 0.17511897f, 0.11040772f, -0.23212522f, 0.14031202f, -0.17277302f, 0.16414590f, -0.10210349f, 
    0.09731530f, 0.04529798f, 0.16733675f, 0.02052066f, -0.24836031f, -0.04430421f, -0.06264517f, 0.11421710f, 
    0.01218245f, -0.07286053f, -0.13328457f, 0.35907567f, -0.11122064f, 0.18276857f, 0.36148027f, -0.03495394f, 
    0.10369829f, 0.14666285f, 0.01433004f, -0.19315815f, -0.23052885f, -0.20104408f, 0.15284181f, 0.43215293f, 
    0.02810499f, 0.00473535f, -0.23341766f, 0.28682247f, 0.31370202f, -0.10678033f, -0.08063271f, 0.11026008f, 
    0.16729566f, -0.00447044f, -0.15703622f, -0.11983560f, 0.18169388f, 0.04386001f, -0.33738524f, -0.37367374f, 
    0.02024202f, 0.26849112f, 0.10205483f, -0.01494707f, 0.28933567f, -0.21657296f, -0.24576697f, -0.12101301f, 
    -0.15722594f, 0.37028685f, 0.18811384f, -0.14066452f, -0.24034867f, -0.00651045f, -0.05387073f, 0.14170705f, 
    -0.07610631f, -0.08441759f, -0.01626474f, 0.16429402f, 0.13953611f, 0.01899000f, 0.01577995f, -0.11812653f, 
    -0.09565694f, -0.08765458f, 0.04536564f, 0.07511335f, 0.30292717f, 0.05959087f, 0.08639978f, 0.11112916f, 
    -0.05450442f, -0.05848936f, 0.15589821f, -0.01684482f, -0.02685980f, 0.16154578f, 0.00250081f, 0.06284950f, 
    0.18460220f, -0.09472471f, 0.01438101f, -0.09124146f, -0.15956923f, -0.10267518f, 0.03670776f, -0.15949135f, 
    0.12398349f, -0.10768572f, 0.01572224f, -0.05068723f, 0.01083767f, 0.05667582f, -0.21340433f, 0.09238266f, 
    0.15147795f, -0.04038048f, 0.11112143f, 0.05694086f, 0.00385633f, -0.21121718f, 0.05122929f, -0.13832937f, 
    -0.28090596f, 0.09467348f, -0.13456570f, -0.28507599f, -0.15540817f, 0.12011091f, -0.16132587f, -0.22274509f, 
    -0.03736623f, 0.17117105f, -0.04550406f, 0.30173779f, 0.04966095f, -0.15688914f, -0.16698013f, -0.32447386f, 
    -0.01589594f, 0.12891980f, 0.25548932f, 0.02425359f, -0.04866465f, -0.00677421f, 0.06196925f, -0.01584002f, 
    -0.23564029f, -0.16058658f, -0.03914749f, 0.10895290f, 0.03990917f, -0.25651804f, 0.01630981f, -0.29865336f, 
    -0.35000509f, 0.20600055f, 0.14282233f, 0.19324335f, -0.21260878f, -0.20161030f, 0.04050731f, 0.01338513f, 
    -0.09875607f, 0.17202993f, 0.33005589f, 0.29060981f, -0.03333664f, 0.04131325f, 0.04657060f, 0.17394398f, 
    0.00488918f, 0.15948096f, 0.00887517f, -0.14073740f, -0.14585249f, -0.03451779f, 0.29761115f, 0.32673591f, 
    -0.16469657f, -0.19780746f, 0.01127919f, -0.07732472f, -0.19532610f, 0.07472885f, -0.18297848f, -0.07982897f, 
    0.06688858f, -0.09169477f, 0.26203132f, 0.01105410f, 0.20414890f, 0.24665965f, 0.21919893f, 0.11540833f, 
    -0.01749488f, -0.04600861f, 0.19315800f, -0.00424938f, 0.03764413f, 0.02962364f, 0.21566035f, -0.22316030f, 
    -0.05239043f, -0.11787089f, 0.18566799f, -0.26791742f, -0.02288751f, 0.05688867f, -0.12037104f, -0.10566349f, 
    -0.14477864f, 0.01444565f, 0.31405926f, -0.00546833f, -0.15799475f, 0.07278811f, -0.13087797f, 0.06720471f, 
    0.03583784f, 0.03061180f, 0.03328023f, -0.00476927f, -0.06088584f, 0.02601249f, -0.06292409f, 0.04269443f, 
    -0.06371707f, 0.02331144f, 0.02979327f, -0.04156706f, 0.02980844f, -0.01128353f, -0.04384083f, -0.04837119f, 
    -0.04443314f, 0.01080678f, -0.05249738f, -0.03002836f, -0.04406585f, -0.05540706f, -0.06118275f, 0.04551624f, 
    0.02144377f, -0.05951234f, 0.03629732f, -0.06271892f, -0.00867072f, -0.02141584f, -0.06209211f, -0.00421388f, 
    -0.05123813f, 0.00937492f, 0.02865828f, 0.04560365f, -0.02702401f, 0.01435543f, -0.03705261f, -0.03476711f, 
    0.00650753f, -0.03624521f, -0.04367673f, 0.01172755f, 0.00951893f, 0.00819673f, 0.01871283f, -0.02289386f, 
    -0.02359323f, 0.05045674f, -0.02677094f, -0.00230996f, -0.05745327f, -0.01338261f, 0.03522886f, 0.02207956f, 
    -0.03561565f, 0.02345890f, 0.01257316f, 0.00179287f, 0.02691290f, -0.01956472f, 0.00259757f, 0.03249444f, 
    0.00931930f, -0.02153404f, -0.04694209f, -0.03697215f, 0.04977751f, 0.03554850f, -0.00522616f, -0.03680037f, 
    0.02120407f, 0.01165758f, 0.03364403f, -0.01492436f, 0.02431613f, -0.01204702f, 0.04523695f, 0.00188179f, 
    -0.00033988f, -0.01350809f, 0.01909233f, -0.01490274f, -0.00365655f, 0.04489117f, -0.05639074f, 0.00510008f, 
    0.05113678f, 0.02864092f, -0.01385054f, 0.03104506f, 0.00459822f, -0.06242402f, -0.05222240f, 0.03707947f, 
    0.03768218f, -0.03796720f, -0.00352016f, 0.04446069f, 0.01358597f, 0.02669605f, -0.02581413f, -0.02392062f, 
    0.04471818f, -0.05229691f, 0.04565090f, -0.02457025f, 0.02768616f, -0.02007737f, 0.04077411f, 0.03892886f, 
    -0.05099554f, -0.01117912f, 0.02724975f, 0.05205198f, -0.04892489f, 0.02262435f, -0.03249971f, -0.02508716f, 
    -0.04144059f, 0.04404773f, -0.02122476f, 0.02337940f, -0.05493737f, 0.01119249f, -0.01871073f, 0.00887632f, 
    0.00776002f, 0.05055947f, -0.01234159f, -0.03699657f, 0.05276236f, -0.00805113f, -0.03904789f, -0.03500859f, 
    0.03789409f, -0.02208312f, 0.05103299f, -0.01901637f, -0.00289052f, -0.01136166f, 0.01100109f, -0.04432890f, 
    -0.03286341f, -0.00366453f, -0.05121197f, 0.04543784f, -0.03135556f, 0.01429051f, -0.05800234f, -0.02797751f, 
    -0.01402145f, 0.00498386f, 0.00945935f, 0.03888116f, -0.05547544f, -0.06103295f, 0.04914762f, -0.01550867f, 
    -0.02161230f, -0.02934328f, 0.04864013f, 0.03401445f, -0.00361026f, -0.01292751f, -0.01613646f, 0.03812739f, 
    -0.06310414f, 0.03553937f, 0.02271464f, -0.00813940f, 0.03321179f, -0.02577296f, -0.02649028f, 0.02557525f, 
    -0.05287809f, 0.03148130f, -0.01802483f, -0.04234798f, -0.05017179f, -0.06394943f, 0.04111784f, -0.01523980f, 
    0.04381876f, -0.04283794f, -0.04265130f, -0.00386763f, -0.05185186f, 0.04324792f, -0.00525625f, -0.03676587f, 
    -0.05821857f, -0.05314710f, -0.06195464f, -0.02549037f, -0.06218016f, -0.01031842f, 0.00293081f, -0.05353479f, 
    -0.03932640f, 0.03011225f, 0.03209624f, 0.03341513f, -0.02956639f, -0.00674220f, 0.02105389f, -0.01397525f, 
    0.00900533f, -0.02608738f, 0.03750640f, 0.01278896f, -0.00899343f, -0.06002211f, 0.00436545f, 0.01050668f, 
    -0.00266444f, 0.01331483f, -0.00281208f, -0.02449699f, -0.06108984f, 0.03507764f, -0.03425260f, -0.04360449f, 
    -0.06400840f, -0.06085184f, 0.01693969f, 0.00522368f, -0.00690319f, 0.05283549f, 0.03872904f, 0.04984501f, 
    0.04988236f, -0.02304494f, -0.02962977f, -0.04504928f, -0.01988063f, -0.01955528f, -0.04914632f, 0.01319576f, 
    -0.01193703f, -0.00003365f, -0.02492574f, -0.03334171f, 0.02637113f, -0.01345254f, -0.04410728f, -0.02723529f, 
    -0.03415496f, -0.02010446f, -0.03762500f, -0.02021340f, 0.03048806f, -0.03247683f, -0.01079404f, -0.04035427f, 
    0.00758246f, 0.03121314f, 0.00360539f, 0.01057735f, 0.05278079f, -0.06369346f, -0.02382277f, -0.02271724f, 
    -0.00525140f, 0.01190595f, -0.03518524f, -0.05136653f, -0.04245932f, -0.04924201f, 0.03215697f, 0.03448058f, 
    -0.01401429f, -0.01206460f, -0.03407453f, -0.06003122f, 0.05247931f, -0.00340355f, 0.02562725f, 0.03711928f, 
    -0.05909834f, 0.01341330f, -0.02552897f, -0.01267683f, -0.05258358f, 0.05099302f, 0.01122299f, -0.06391428f, 
    -0.34101078f, 0.20298928f, -0.06863795f, -0.10900453f, -0.03851441f, -0.01702545f, 0.02880174f, 0.01692171f, 
    -0.25928089f, 0.10082589f, -0.22264643f, -0.07393420f, -0.11045223f, 0.12536281f, -0.17047113f, 0.03676843f, 
    -0.12497122f, -0.12803152f, 0.19870444f, -0.03480918f, 0.16167375f, 0.10890166f, -0.06985316f, 0.22458950f, 
    0.13033597f, 0.04959400f, 0.24122190f, 0.13394929f, -0.02007482f, 0.02387595f, -0.00602187f, -0.14149097f, 
    -0.24299471f, 0.00090867f, 0.11214143f, -0.12727001f, 0.34484598f, -0.03986471f, -0.09036015f, -0.01067117f, 
    -0.03158969f, -0.12250482f, -0.04770030f, -0.08285635f, -0.33066255f, 0.20695919f, 0.11272778f, 0.05406987f, 
    -0.33929825f, 0.03712912f, -0.09424055f, 0.17502388f, 0.14272282f, -0.15333323f, -0.03726187f, 0.20460944f, 
    -0.00751256f, 0.04234457f, -0.11633229f, 0.07093713f, 0.23604372f, -0.10147069f, -0.04726200f, 0.17561311f, 
    0.31966811f, 0.21989347f, -0.10252590f, 0.13157356f, -0.02812444f, 0.02197743f, 0.14245605f, -0.30942026f, 
    0.23236682f, 0.26610395f, 0.09181297f, 0.20340946f, 0.07108100f, 0.09817965f, 0.02209652f, -0.09523088f, 
    0.06347892f, 0.02949880f, -0.00339192f, 0.27619466f, 0.03836411f, 0.13279571f, -0.11584830f, -0.03783922f, 
    0.00210887f, -0.09306692f, 0.24384134f, -0.12330604f, -0.02542357f, -0.09666080f, 0.03596126f, -0.02808766f, 
    -0.15054406f, 0.05521180f, -0.14489998f, -0.50482321f, 0.16321304f, -0.13493660f, 0.02349051f, 0.06356730f, 
    -0.14947464f, -0.02349458f, 0.04051737f, 0.29797953f, 0.28359920f, 0.02960651f, -0.31878519f, -0.23470250f, 
    0.07701677f, 0.04167185f, 0.02425992f, -0.08617371f, -0.24520491f, -0.22429292f, 0.07347135f, 0.13798667f, 
    0.05053406f, -0.17863059f, -0.12390039f, -0.21102823f, -0.17697997f, -0.12407721f, 0.48510042f, -0.03892640f, 
    -0.39860296f, -0.26727518f, 0.04546460f, 0.03766676f, -0.13580394f, 0.10498767f, 0.16516884f, -0.41184494f, 
    0.01952316f, -0.12582293f, -0.06818148f, 0.03605434f, -0.18317300f, -0.03130507f, 0.12137028f, 0.09124561f, 
    -0.08569317f, 0.21247873f, -0.06831650f, -0.02353444f, -0.00846628f, 0.07230835f, 0.13102917f, -0.12002148f, 
    -0.17542592f, 0.41810414f, 0.14630193f, 0.00442569f, -0.01640038f, 0.08028835f, -0.14580350f, 0.02880332f, 
    -0.04519592f, -0.28927886f, -0.67170662f, -0.15111074f, -0.05476896f, 0.10790846f, -0.14550719f, -0.22150652f, 
    -0.11177859f, 0.03205090f, 0.15629509f, -0.06693742f, 0.03875719f, 0.01829330f, 0.18704183f, 0.12051781f, 
    0.03451085f, -0.02356391f, -0.06195269f, -0.16851442f, 0.36183402f, 0.33798650f, 0.26599362f, 0.03517624f, 
    0.04794571f, 0.19341914f, -0.01627886f, -0.13206193f, 0.21057212f, 0.03403452f, 0.19491298f, 0.40067661f, 
    0.40177098f, 0.14459999f, -0.04100060f, 0.10560706f, 0.03722524f, 0.11477956f, 0.09685829f, -0.03309567f, 
    -0.23774453f, 0.01262154f, 0.11835517f, -0.04343259f, -0.30637380f, 0.16780455f, -0.09542064f, 0.21439953f, 
    -0.05440544f, -0.33368766f, -0.18087697f, 0.18445873f, -0.04364343f, 0.15540205f, 0.11239986f, -0.15846322f, 
    0.32516268f, 0.46543723f, 0.22002910f, -0.11640280f, 0.05893306f, 0.21091181f, -0.09733016f, 0.15507291f, 
    0.02894755f, 0.01025992f, -0.28745919f, -0.12713397f, 0.20438807f, 0.11153732f, -0.02382526f, -0.01270725f, 
    0.23444390f, 0.03353630f, -0.10545159f, -0.17735058f, 0.18741062f, 0.09499786f, 0.11945324f, -0.20885587f, 
    0.04054223f, -0.18765992f, -0.05353921f, 0.02528764f, 0.16236416f, -0.08200707f, -0.06945627f, 0.09696333f, 
    0.04641618f, 0.16759522f, 0.08911381f, 0.01539781f, 0.08057103f, 0.08805700f, 0.12729418f, 0.24476779f, 
    -0.01617929f, 0.14834526f, 0.02752329f, 0.09269214f, -0.13977590f, -0.17390341f, -0.06977008f, -0.10509257f, 
    0.06103903f, -0.08628387f, -0.23529702f, 0.01461418f, 0.01406625f, -0.03176527f, 0.40277988f, 0.19147834f, 
    0.16531444f, 0.19693193f, -0.03252867f, 0.20417926f, -0.08959862f, 0.08277427f, 0.26095644f, -0.08765788f, 
    0.08128139f, -0.09490228f, 0.11936893f, -0.03300084f, -0.06927663f, -0.07930068f, -0.10708316f, -0.28430891f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01569990f, 0.00039462f, -0.02992738f, 0.06353285f, 0.17764783f, -0.06343809f, 0.00867536f, 0.03909802f, 
    -0.05763398f, 0.01906198f, -0.11093098f, -0.16154358f, 0.01975954f, -0.01917330f, 0.13117784f, -0.12746626f, 
    -0.01643404f, -0.06506907f, 0.08537307f, 0.06183086f, -0.03014601f, 0.15595056f, -0.04255354f, 0.03720520f, 
    0.16856162f, -0.03017531f, 0.10591272f, 0.19713032f, 0.04252674f, 0.22540066f, -0.03287034f, -0.01198114f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.10600789f, -0.85028064f, 0.01515179f, -0.13993293f, 0.08511224f, -0.06342167f, -0.15713353f, -0.10708366f, 
    -0.13220169f, -0.00548097f, -0.18338948f, -0.35579261f, 0.01721237f, 0.02885577f, 0.00403676f, -0.08061876f, 
    0.23748587f, 0.14945889f, 0.13916895f, 0.24965827f, -0.00646050f, -0.29082572f, -0.50899774f, 1.01511157f, 
    -0.45185691f, 0.11965476f, -0.07380219f, 0.19570956f, 0.02002101f, -0.50878960f, -0.15907674f, 0.31331998f, 
    -0.06514265f, 0.07670356f, 0.07296567f, -0.29592627f, -0.15888485f, 0.13341704f, -0.15543595f, 0.82311833f, 
    0.00018067f, 0.14650090f, 0.33386278f, 0.02679320f, 0.12798499f, -0.11197866f, 0.10883083f, -0.51145637f, 
    -0.03561600f, 0.15057045f, -0.87989604f, 0.04944031f, -0.13593514f, -0.40453678f, -0.23489960f, 0.19740869f, 
    0.01836775f, 0.01000736f, -0.36423340f, 0.27883890f, 0.12431511f, 0.14752372f, 0.14320394f, -0.14071469f, 
    -0.15026481f, -0.13893628f, -0.16687997f, 0.24910326f, -0.18693446f, 0.01318336f, 0.08143558f, 0.08719507f, 
    0.15470022f, -0.12315621f, 0.89011574f, -0.57718891f, -0.12022798f, 0.13090010f, -0.03988914f, -0.14271523f, 
    -0.23485114f, -0.15831925f, 0.92335349f, -0.56747562f, -0.00988458f, 0.13845414f, -0.22365414f, -0.34390491f, 
    0.33450457f, -0.03560353f, 0.15869425f, -0.38383183f, 0.02999768f, -0.33033597f, -0.14255860f, 0.18401457f, 
    -0.12443025f, -0.25342825f, -0.00267514f, 0.49422932f, -0.36845353f, 0.09301097f, -0.12270119f, -0.65278459f, 
    -0.16614491f, 0.15163764f, -0.03990865f, 0.59959269f, -0.11495723f, -0.17868552f, 0.13636792f, 0.16108367f, 
    0.75917894f, 0.01004039f, 0.06447969f, -0.38662761f, 0.15718712f, 0.05375682f, -0.21637771f, -0.07558566f, 
    0.44049627f, 0.17166588f, 0.42398250f, -0.46369979f, -0.02260357f, 0.00919257f, -0.09181187f, -0.28266320f, 
    -0.14840312f, -0.63918626f, -0.03551462f, -0.00843582f, 0.27177626f, 0.12216429f, 0.02167418f, 0.09520475f, 
    -0.04234963f, -0.07756922f, -0.44585449f, -0.37498018f, -0.01550317f, 0.05168535f, 0.52883625f, 0.24259399f, 
    -0.14259961f, -0.17198744f, 0.02484022f, -0.21333531f, 0.08337265f, -0.37414318f, -0.39290431f, -0.78596789f, 
    0.03621420f, 0.10201586f, 0.60883504f, 0.08295310f, -0.06326445f, -0.00799154f, -0.13399924f, 0.18604833f, 
    -0.10954716f, -0.00387623f, -0.03887361f, -0.45148402f, 0.51907569f, 0.08098947f, -0.02813164f, -0.39271283f, 
    -0.03306310f, -0.02532947f, -0.38875476f, 0.42771363f, -0.05243500f, -0.03685888f, -0.39334577f, -0.32854810f, 
    -0.57693899f, 0.07631720f, 0.02446204f, -0.20031804f, -0.13729331f, -0.25244418f, 0.22270139f, 0.01902351f, 
    -0.70288223f, -0.16403836f, -0.51304430f, 0.43047681f, -0.02257864f, 0.07732211f, -0.02434975f, -0.17683877f, 
    0.14123924f, 0.70015979f, -0.14881131f, -0.16458017f, 0.28786916f, -0.01258065f, 0.02918828f, -0.57641894f, 
    0.04848097f, 0.01582921f, -0.53384936f, -0.44929692f, -0.12283426f, -0.11049447f, -0.21843298f, 0.45582548f, 
    0.42983449f, -0.17544857f, 0.41435373f, -0.62079000f, 0.00704471f, -0.59103400f, -0.22797367f, -0.27588129f, 
    0.52135086f, -0.09227059f, -0.22249265f, -0.09406569f, 0.08346847f, -0.16184983f, 0.02187886f, 0.00660996f, 
    -0.06681884f, -0.25768435f, -0.08443675f, -0.02924769f, -0.38746527f, -0.08879703f, 0.09176668f, 0.11818974f, 
    -0.16701183f, -0.09390524f, 0.03298602f, 0.36225557f, 0.03959957f, -0.10270306f, 0.11876208f, 0.51239753f, 
    -0.07591531f, -0.07066850f, -0.67111427f, 0.36047578f, 0.06730951f, -0.67706561f, -0.01055293f, 0.04881357f, 
    -0.64573038f, -0.05440992f, 0.34725526f, -0.34274033f, -0.03705371f, -0.45544362f, -0.11191458f, 0.65254402f, 
    -0.16261864f, 0.12270901f, 0.01349383f, -0.78479004f, -0.43638697f, 0.05802834f, -0.00548942f, 0.67467058f, 
    -0.09264961f, 0.02534767f, -0.23499151f, 0.27277818f, -0.05896434f, 0.11989693f, -0.22847988f, 0.60258037f, 
    -0.17662624f, -0.10414501f, -0.32038507f, -0.39527810f, -0.09565204f, 0.81633097f, 0.41952935f, 0.13873327f, 
    -0.07452165f, -0.13922279f, -0.13695100f, 0.22507711f, -0.10684343f, -0.19026822f, -0.11460462f, -0.54751223f, 
    0.02932093f, -0.03298338f, 0.06197032f, 0.23166914f, 0.13918401f, -0.03489438f, -0.01752694f, -0.23191766f, 
    0.06630475f, 0.15217997f, -0.64784330f, -0.09789712f, -0.01180940f, 0.07268121f, -0.44609904f, -0.16717501f, 
    -0.15930876f, -0.01880140f, 0.05048331f, 0.36885464f, 0.06200908f, 1.13957620f, -0.43368098f, -0.06247761f, 
    0.33466229f, -0.16661769f, 0.10120054f, -0.13096640f, 0.12138761f, -0.15496819f, 0.04715188f, 0.25434685f, 
    0.13924778f, -0.06807344f, 0.07750753f, -0.29614675f, -0.72691911f, 0.03132804f, -0.07902469f, -0.18375660f, 
    -0.06358682f, -0.13224171f, 0.42162114f, 0.13246696f, -0.18120804f, 0.04915558f, 0.73054767f, -0.36708900f, 
    -0.45542681f, 0.04315571f, 0.25128141f, 0.55172884f, -0.15174679f, 0.00741205f, -0.19954434f, -0.57018232f, 
    0.32139608f, 0.04378599f, 0.30955997f, 0.00302371f, -0.04397898f, 0.54706395f, 0.14668074f, -0.48906043f, 
    -0.04038995f, 0.09697046f, -0.09438515f, 0.47253186f, -0.36327755f, 0.15169211f, -0.13166085f, -0.02901556f, 
    -0.08061863f, 0.04069242f, -0.05513943f, -0.49848428f, -0.16906995f, 0.07222789f, -0.72989923f, -0.12465035f, 
    0.42008245f, 0.03574399f, -0.11082266f, 0.33409402f, -0.13315786f, -0.28387710f, 1.07708406f, -0.24562015f, 
    -0.07334744f, 0.08651633f, 0.10074642f, -0.41511795f, 0.02200212f, 0.35762635f, -0.05799285f, -0.25896549f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09522767f, 0.07229448f, -0.24940491f, -0.09962968f, 0.34497321f, 0.16716984f, -0.00132785f, -0.17180268f, 
    -0.25711513f, 0.17629491f, -0.04558804f, -0.04999176f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
