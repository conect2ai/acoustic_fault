#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.07087386f, -0.55317533f, -0.82226843f, -0.33708692f, 0.78960288f, -0.69188851f, -0.48059294f, -0.51836276f, 
    -0.64607191f, 1.18604052f, -0.32720393f, 1.15822732f, 1.09261537f, -0.13038060f, 0.20398834f, 0.31268299f, 
    0.40769622f, -0.70348555f, -0.80622387f, -1.04277790f, -0.86226314f, 0.30127624f, -1.25494456f, -0.38180602f, 
    0.11678934f, 0.37149802f, 0.39378968f, 1.02718556f, 0.64201236f, 1.39347029f, 0.11293399f, 0.15397067f, 
    0.85811532f, 0.18300764f, -0.08700845f, 0.46007708f, -1.30239749f, -0.76876736f, -0.43919179f, 1.01929331f, 
    1.42885923f, 0.16825186f, 0.28536898f, 0.41191909f, -0.20134676f, 0.32794657f, 0.65010107f, -1.63450384f, 
    -0.90862304f, 0.54152572f, -0.33987445f, 0.12589088f, -0.44278806f, -0.13497379f, 0.49331173f, -0.86444122f, 
    0.57648116f, 0.92121273f, 0.32283440f, 1.16101098f, -0.26995483f, -0.99960685f, 0.49877703f, -1.31800747f, 
    -1.37361431f, -1.36038888f, 0.05705586f, -0.29839799f, 0.55741978f, 0.34016523f, -0.14460129f, 0.28374669f, 
    0.44524091f, 1.29989052f, 1.00940585f, -1.45177674f, 0.11447991f, -0.72436458f, 0.28909960f, 0.57554805f, 
    0.31383500f, 1.21206713f, 0.59246683f, 0.73788601f, 0.89489287f, 0.56806219f, -0.57946616f, -0.15712260f, 
    0.20810574f, 0.34151772f, 1.10311961f, 1.30611551f, 0.48290184f, -0.53900248f, 0.15901877f, 0.35471851f, 
    -0.73294926f, -0.20873213f, -0.50344259f, -0.40225899f, -0.72231126f, -0.76129687f, -0.70400971f, 0.90267199f, 
    1.28033507f, -0.09072438f, -0.17985013f, -0.32589573f, 1.05755150f, 0.47088760f, 0.52233726f, -0.65990436f, 
    -1.67177176f, -0.50293970f, -0.51769370f, -0.03017589f, 0.32318059f, 1.65574455f, -0.86655748f, -0.86432463f, 
    -0.22955532f, -0.15493886f, -0.21711746f, -0.17992415f, -0.27527320f, 0.21682020f, -1.81067610f, 1.41694081f, 
    -0.48380435f, -0.10990751f, 0.44777986f, -0.10155405f, -0.12104409f, 0.08967561f, -0.29020274f, 0.90447271f, 
    1.24621272f, 0.25987068f, 0.10598923f, -0.24352844f, 0.35084903f, 0.86862826f, 0.79277402f, -0.04976317f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12263408f, 0.00177200f, 0.38644770f, 0.74189925f, -0.04236816f, 0.12134025f, 0.47732088f, 0.37651548f, 
    0.34272769f, 0.43125382f, 0.05273921f, -0.51470590f, 0.41519409f, -0.31083855f, 0.62989283f, -0.34927356f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.24022746f, -0.08398969f, -0.14977317f, -0.02326201f, 0.05925645f, 0.19140488f, 0.15472765f, -0.10149397f, 
    -0.07221826f, -0.25381562f, -0.15735337f, 0.14224611f, 0.14164700f, 0.10366944f, -0.02014011f, 0.00441420f, 
    0.15037136f, 0.20290397f, 0.15105684f, 0.05977583f, 0.02410043f, -0.06563305f, -0.01828765f, -0.00217381f, 
    0.07948119f, 0.21303952f, 0.25816071f, -0.68485796f, -0.07768495f, 0.17874387f, 0.16367961f, 0.16053744f, 
    0.08403198f, 0.06005375f, 0.12240962f, 0.05417002f, 0.55287462f, 0.19968893f, -0.27880934f, -0.05363645f, 
    -0.20667809f, -0.05254961f, 0.13192502f, 0.10603818f, -0.03077016f, -0.30400702f, 0.17678060f, 0.08538511f, 
    0.20740084f, 0.00057690f, 0.19014665f, -0.15143459f, 0.03835589f, 0.19216418f, 0.21955906f, -0.15547734f, 
    0.01282519f, -0.04394296f, 0.19188918f, 0.05726072f, 0.10041711f, 0.15234931f, -0.17379722f, 0.04856479f, 
    0.12081794f, 0.12047312f, 0.09484265f, 0.07207841f, 0.04635021f, -0.19271362f, -0.03269221f, 0.04624794f, 
    0.06395635f, 0.38848066f, 0.01654530f, 0.08577276f, 0.06793044f, -0.10797731f, -0.20640057f, -0.04856644f, 
    0.04207075f, -1.30919003f, -0.31572732f, -0.07688866f, 0.04873538f, 0.25047296f, -0.09746796f, 0.22273470f, 
    0.03822095f, 0.17889245f, -1.16354501f, 0.02940601f, -0.07770379f, 0.28407314f, 0.16005528f, 0.12146972f, 
    0.04343186f, -0.31229264f, 0.01154322f, 0.14121474f, -0.51802683f, -0.05765265f, 0.02256352f, 0.16422269f, 
    -0.47160187f, -0.23769422f, 0.00424808f, 0.05717169f, -0.39195856f, 0.45356750f, 0.23798841f, 0.34552333f, 
    0.21886311f, 0.13442115f, -0.13012525f, 0.15792148f, 0.12809101f, -0.32618284f, -0.35259634f, 0.12433632f, 
    -0.07322349f, -0.24100155f, -0.15255798f, -0.00773944f, -0.12985775f, -0.05446719f, -0.15047510f, -0.00533752f, 
    -0.13974345f, -0.01982593f, 0.45071208f, 0.05346730f, 0.33523041f, -0.22204985f, 0.15924682f, -0.85599124f, 
    -0.54881483f, -0.47826162f, 0.08267278f, -0.25654426f, -0.13385649f, -0.01119575f, 0.09973578f, -0.07634641f, 
    0.28631416f, -0.21009304f, -0.10809701f, 0.30169159f, 0.09136399f, 0.03319640f, 0.06609314f, 0.12591541f, 
    -0.23971626f, 0.58500689f, -0.04732633f, 0.22751300f, 0.06224836f, 0.20721361f, 0.14547507f, 0.11129233f, 
    0.13303316f, 0.07340642f, -0.66149628f, -0.04795073f, -0.23841734f, 0.24410534f, 0.20845422f, 0.06599103f, 
    -0.02986621f, 0.22390704f, -0.03792667f, 0.13919836f, 0.06239358f, 0.02720674f, -0.21640314f, -0.01219529f, 
    0.16945307f, 0.07199710f, -0.11537548f, 0.09354103f, 0.36728239f, 0.21080235f, -0.14841795f, 0.22756201f, 
    0.24974348f, -0.13915834f, -0.06642228f, -0.16382295f, -0.13610640f, -0.34130144f, 0.13697484f, -0.02124536f, 
    -0.05847684f, 0.01910748f, -0.01204997f, -0.34328791f, 0.01222198f, 0.22498086f, 0.64838147f, 0.25694335f, 
    -0.12726054f, -0.01457261f, 0.03028346f, -0.14526558f, 0.38353831f, -0.01106889f, 0.01336944f, -0.14022107f, 
    0.26668242f, -0.32511806f, 0.02264571f, 0.04861835f, 0.15048479f, -0.05198713f, 0.16866039f, -0.04590696f, 
    0.09176874f, -0.18181232f, 0.18934403f, -0.38696161f, -0.11755475f, 0.13142516f, -0.33233818f, 0.19070432f, 
    0.18020919f, 0.19604756f, 0.19542722f, 0.13450308f, -0.04570323f, -0.18767475f, -0.14235996f, 0.12748954f, 
    0.17317042f, -0.01457816f, 0.26029381f, -0.30066767f, 0.14888768f, -0.63473278f, -0.12763758f, -0.09653334f, 
    -0.15367541f, 0.08255769f, 0.14693490f, -0.26307687f, 0.05208512f, -0.94077426f, 0.04474644f, 0.05531131f, 
    -0.08895124f, -0.05652768f, -0.06455938f, -0.02926402f, 0.06967842f, 0.09760243f, 0.35159558f, -0.19917771f, 
    0.05503078f, 0.06845475f, 0.03495571f, 0.13754836f, 0.17903653f, -0.46134341f, -0.85636288f, 0.19249985f, 
    -0.30266848f, 0.20164700f, -0.10354809f, -0.23566136f, 0.06391231f, 0.12941349f, 0.50131989f, -0.43541020f, 
    0.03783311f, -0.06031172f, -0.05356370f, -0.22995096f, 0.01751235f, 0.00381922f, 0.05167591f, 0.08797750f, 
    0.35421425f, -0.17439772f, -0.28378120f, -0.23238091f, 0.03353860f, -0.21378250f, 0.10677090f, 0.21714263f, 
    0.08760263f, -0.00678444f, -0.54397959f, 0.00090072f, 0.12328968f, 0.05973538f, 0.03087260f, -0.14987561f, 
    -0.29989576f, -0.33860847f, -0.13186011f, 0.12982744f, 0.05273898f, -0.13099697f, 0.14031760f, 0.07558381f, 
    -0.09340192f, -0.22219294f, -0.09162419f, 0.00862908f, -0.40147796f, -0.06598145f, 0.16557111f, -0.06078862f, 
    0.21181074f, 0.05906910f, -0.02220268f, 0.30745840f, 0.22295286f, 0.32439753f, 0.11143314f, 0.07839336f, 
    0.04625297f, 0.09122594f, 0.13926002f, 0.13542120f, -0.51516622f, -0.49756113f, -0.39369902f, -0.00677817f, 
    -0.14253101f, -0.03675031f, 0.01854021f, -0.15365881f, -0.11048986f, -0.27679962f, -0.20744944f, 0.86187333f, 
    0.05873496f, 0.03948897f, -0.04384785f, -0.00465872f, 0.04044079f, 0.00174797f, -0.52176017f, -0.04900411f, 
    0.08831818f, -0.01340724f, 0.06620805f, 0.22948927f, -0.01644086f, -0.09406378f, 0.04624398f, -0.51196688f, 
    0.32369459f, -0.13045196f, 0.01729065f, -0.17089298f, 0.03699452f, 0.07473979f, 0.07372875f, -0.12303632f, 
    0.60434532f, 0.26838896f, 0.02378191f, 0.03598539f, -0.06030106f, 0.16812687f, -0.00615244f, -0.26508257f, 
    0.10017058f, 0.06521589f, -0.05914191f, 0.29355618f, 0.07923277f, 0.23778498f, 0.15092352f, 0.02921920f, 
    -0.02666120f, -0.05042322f, 0.01406330f, 0.23110454f, 0.01177149f, 0.08806541f, -0.07914019f, 0.12185421f, 
    0.10153045f, 0.04320246f, -0.05788513f, 0.02576136f, -0.04848282f, -0.41746360f, 0.05874695f, 0.29244909f, 
    0.15357555f, 0.02226403f, 0.06693161f, -0.02908125f, 0.15545054f, 0.24790792f, -0.00593461f, -0.23850989f, 
    -0.10855474f, 0.17449068f, -0.01085483f, -0.08626761f, 0.32889783f, -0.42783657f, -0.49064732f, -0.74182510f, 
    -0.09722444f, 0.03041813f, -0.30048841f, 0.01124211f, 0.13017884f, 0.01444735f, -0.46227312f, -0.05256460f, 
    -0.25073460f, -0.07608730f, -0.09861524f, -0.19050296f, 0.15696611f, -0.04823948f, 0.06885614f, 0.21847901f, 
    0.24908289f, 0.04266082f, -0.08364967f, -0.07353465f, -0.19514997f, 0.27941719f, 0.14163427f, -0.11758689f, 
    0.19168818f, 0.23836710f, 0.36029211f, 0.05729498f, 0.03374369f, -0.07069699f, -0.05938617f, 0.18715602f, 
    -0.33851662f, 0.05929169f, 0.28543746f, -0.12143780f, 0.08085619f, -0.06517116f, -0.18166088f, 0.04961165f, 
    0.01100653f, 0.10694411f, 0.25467813f, -0.01232426f, 0.13280748f, 0.10670619f, -0.00049927f, 0.30664089f, 
    -0.04089058f, 0.14086315f, 0.02443587f, 0.10528259f, 0.17141283f, -0.10362902f, -0.24438524f, 0.02695951f, 
    -0.21757270f, 0.05159362f, 0.15787086f, 0.09221577f, 0.40135458f, 0.36345407f, 0.40758872f, 0.21803510f, 
    0.24656096f, 0.15526301f, 0.28356764f, 0.28810480f, 0.07091035f, -0.12770958f, -0.39509910f, 0.07664242f, 
    -0.03392765f, -0.02223931f, -0.10405812f, 0.00561294f, -0.11888759f, -0.11670277f, -0.28810275f, -0.11361148f, 
    -0.28216165f, 0.07775354f, 0.10793369f, 0.13712886f, -0.08144984f, 0.09440076f, 0.02496359f, 0.58329296f, 
    0.25386059f, 0.24010566f, 0.19077343f, 0.00968841f, 0.13173133f, 0.39209017f, 0.02812046f, 0.18282440f, 
    -0.61456978f, -0.10984138f, -0.12836494f, -0.03950494f, 0.04115179f, -0.00043770f, -0.04227857f, 0.03945525f, 
    0.09827917f, -0.25796852f, 0.19902313f, -0.20353007f, 0.23194683f, -0.19849560f, -0.03719712f, 0.04933078f, 
    0.10411297f, 0.14509076f, 0.26742929f, 0.06298000f, 0.19253221f, -0.19839266f, 0.03619757f, 0.01033513f, 
    0.12049957f, 0.02777713f, 0.03544785f, 0.15618163f, -0.06416871f, 0.18010220f, 0.11387797f, 0.00633090f, 
    -0.04783091f, 0.02669043f, -0.03243542f, -0.02751141f, -0.20117839f, 0.19265318f, -0.25061309f, -0.31968224f, 
    -0.29454690f, 0.10506359f, -0.28610560f, 0.00144656f, -0.04869883f, 0.08579448f, -0.05924915f, -0.01640187f, 
    0.05942821f, -0.14665987f, -0.13353583f, -0.40713871f, 0.12606744f, -0.02849969f, -0.11036503f, -0.16905634f, 
    -0.00920306f, 0.19649230f, -0.02503770f, 0.07823884f, -0.21232508f, 0.01824147f, -0.08035617f, -0.18297350f, 
    0.34568021f, -0.17666282f, 0.21405567f, 0.02433767f, -0.16975644f, 0.19612101f, -0.07537751f, -0.11578345f, 
    0.02128438f, 0.04784609f, -0.05877608f, -0.03860724f, -0.07567436f, -0.07191575f, -0.04645077f, -0.03873480f, 
    0.01437072f, 0.03692932f, -0.04576573f, 0.05087289f, -0.06451710f, 0.00884563f, -0.06114493f, -0.04601490f, 
    0.06156637f, -0.04852190f, 0.03163372f, -0.03914564f, 0.00660571f, 0.00533840f, -0.02026812f, 0.05310249f, 
    0.03370564f, 0.01519800f, 0.00353066f, -0.02570383f, -0.06270326f, 0.02248520f, -0.06318621f, 0.04433988f, 
    -0.05147792f, 0.04765982f, -0.06279062f, -0.03581791f, -0.02497633f, -0.02891465f, -0.06032832f, -0.02564408f, 
    0.03011623f, 0.01984623f, -0.01051964f, 0.00494372f, 0.05113611f, 0.03415111f, -0.04046809f, -0.04378360f, 
    0.05471552f, 0.00303439f, -0.03195665f, 0.01400239f, 0.05018089f, 0.04268383f, -0.07232934f, -0.08752748f, 
    0.05589284f, -0.08816310f, 0.02393603f, 0.05467262f, -0.06370009f, -0.01791524f, 0.05667897f, -0.03314152f, 
    -0.01398510f, -0.06446370f, 0.03825680f, -0.05474916f, -0.00703824f, -0.02209816f, -0.03091562f, 0.00989119f, 
    -0.03916119f, -0.07326689f, 0.05520433f, -0.00932706f, -0.02068172f, 0.05409306f, 0.05377283f, 0.05193936f, 
    -0.08168507f, 0.05141202f, -0.00991469f, -0.00533129f, -0.04201870f, 0.05821137f, -0.01203679f, 0.04784290f, 
    -0.08515922f, 0.02318423f, -0.08912895f, -0.07941782f, -0.06421246f, 0.01869308f, -0.04154398f, -0.01919794f, 
    0.07455000f, 0.00722435f, 0.01926968f, -0.01726239f, -0.00780673f, 0.06289936f, -0.06987913f, 0.01759748f, 
    -0.03707158f, 0.01545251f, -0.04639628f, 0.05198243f, -0.07852668f, -0.03659385f, -0.00762298f, -0.08552041f, 
    0.01004744f, -0.02187898f, 0.04329279f, -0.03279910f, -0.00172923f, 0.04261202f, -0.05119521f, -0.05128660f, 
    0.04354126f, 0.00915624f, 0.02958042f, -0.03838216f, 0.03188927f, -0.04858995f, -0.02244555f, 0.00187864f, 
    -0.05952362f, -0.05007279f, -0.07995912f, -0.03275234f, -0.03051374f, -0.02698370f, -0.06578948f, -0.08267939f, 
    0.03885632f, 0.03894363f, -0.02444027f, 0.07036263f, 0.04350304f, -0.03649089f, 0.03016928f, 0.03468546f, 
    0.04542666f, 0.34032661f, 0.04589970f, -0.13834271f, 0.10565045f, -0.09331602f, 0.19000947f, 0.19015208f, 
    0.34412381f, -0.11200713f, -0.06858814f, 0.01845988f, 0.14101298f, 0.11344920f, 0.15228741f, -0.11902781f, 
    0.10239676f, -0.17098148f, -0.16600473f, -0.69436419f, -0.20897646f, 0.11194802f, 0.06986700f, -0.09825577f, 
    0.16429217f, -0.01436439f, 0.07098336f, -0.07688103f, 0.17131156f, -0.14306377f, -0.26585266f, 0.13776164f, 
    0.14262584f, -0.13605848f, 0.08661820f, -0.13479793f, 0.35842460f, 0.29745033f, 0.32847339f, 0.03717010f, 
    -0.28646335f, -0.08926246f, 0.11493572f, -0.04691585f, 0.09248558f, -0.36483389f, 0.20779926f, 0.03799829f, 
    -0.10120034f, -0.13464825f, -0.23900440f, -0.12608562f, -0.16199039f, -0.05558243f, -0.18592687f, -0.15514307f, 
    -0.40630049f, 0.17934698f, 0.14603558f, 0.02833882f, -0.03912018f, -0.11150028f, -0.31612897f, -0.24768895f, 
    0.04761645f, -0.20867127f, -0.15478861f, 0.23408224f, 0.11722545f, 0.09499045f, -0.19048931f, -0.15607952f, 
    0.01479403f, 0.20053320f, -0.06619540f, 0.26292282f, -0.21269225f, -0.21245323f, -0.00120042f, 0.03673952f, 
    -0.16870254f, -0.11412715f, -0.05334723f, 0.04098089f, 0.02328735f, 0.02367773f, 0.15588641f, -0.12371837f, 
    0.12681960f, -0.13341336f, -0.02995722f, 0.32389399f, 0.02573868f, 0.09078848f, 0.28323036f, 0.11788450f, 
    0.47279218f, 0.08665503f, 0.08699504f, -0.40720299f, 0.42580721f, -0.12371324f, -0.22962244f, -0.03534970f, 
    0.26268488f, 0.00327734f, 0.27601689f, 0.23732859f, 0.35697639f, -0.02679946f, 0.21411648f, -0.06803429f, 
    -0.10495704f, -0.19769496f, 0.06203944f, 0.20559402f, 0.08857552f, 0.30578360f, -0.37667027f, 0.06867803f, 
    -0.16662428f, -0.06616926f, 0.21781933f, -0.09639075f, 0.17102106f, -0.01133115f, 0.94263345f, 0.19706535f, 
    -0.26840767f, -0.35491431f, -0.03872334f, 0.06006686f, -0.32186076f, -0.00923027f, 0.09520248f, -0.13144863f, 
    -0.05784289f, 0.25226828f, 0.06704170f, -0.05593083f, 0.02220941f, 0.04753733f, -0.01406600f, -0.21685737f, 
    -0.02140383f, -0.10436162f, -0.07536255f, -0.10335845f, 0.02112504f, 0.01352384f, 0.04896171f, -0.06281644f, 
    0.01703963f, -0.04218008f, 0.01073844f, 0.00423558f, -0.04072533f, -0.06529191f, -0.02012049f, -0.08967914f, 
    -0.05543601f, -0.06489132f, 0.00525863f, -0.01681239f, -0.07062657f, 0.02228078f, 0.00308105f, -0.03157552f, 
    -0.00805898f, -0.04449750f, -0.08173949f, -0.07105845f, 0.05313528f, 0.00973393f, 0.03929345f, -0.03953901f, 
    -0.08648300f, -0.02996558f, -0.00579053f, -0.06793866f, -0.00500828f, -0.01212595f, -0.03905306f, 0.01645159f, 
    0.00640738f, -0.05641406f, -0.02636415f, 0.03340199f, 0.06668522f, -0.07172126f, -0.08749574f, -0.00970541f, 
    0.02413655f, -0.08040009f, 0.03107185f, -0.12008228f, -0.08110508f, -0.06874464f, -0.00435802f, 0.00471629f, 
    0.01446141f, -0.03202629f, -0.08217307f, -0.02252538f, -0.03727528f, 0.01130647f, -0.00567991f, 0.06666755f, 
    -0.03349923f, 0.01410055f, -0.00685327f, -0.03414397f, -0.00119192f, -0.05142280f, 0.02306881f, -0.07131825f, 
    -0.05076317f, 0.06265575f, 0.01287148f, 0.06622753f, 0.02369495f, 0.07690761f, -0.07813221f, 0.03760956f, 
    -0.03099164f, 0.05876292f, 0.01340257f, 0.09216151f, 0.04344892f, -0.08344162f, 0.03425981f, -0.01649705f, 
    -0.07997633f, 0.04596461f, -0.09150526f, 0.03649088f, -0.01948198f, -0.06297884f, -0.09088704f, 0.04654315f, 
    0.01869641f, -0.00541033f, -0.04648893f, 0.03268320f, -0.08674778f, -0.04243626f, -0.00658025f, 0.01758207f, 
    -0.08846838f, -0.03441671f, 0.07229330f, -0.02687744f, -0.11164217f, -0.08901086f, 0.06848378f, 0.08181798f, 
    -0.07665116f, 0.06234629f, -0.01882002f, -0.08049145f, 0.06573571f, 0.00855702f, -0.02616281f, -0.06392090f, 
    0.04969026f, -0.03454391f, -0.06419129f, 0.00760874f, -0.03722681f, 0.04291198f, 0.03153636f, -0.05798900f, 
    -0.01373868f, -0.01506450f, 0.00923305f, -0.06568921f, -0.08060443f, -0.10747053f, 0.00817292f, -0.03031669f, 
    -0.06855548f, 0.02394898f, -0.01602420f, -0.07979902f, -0.06812151f, -0.01570795f, 0.05238977f, 0.08557517f, 
    -0.22696067f, -0.44276905f, -0.58691424f, 0.22046988f, 0.09327627f, 0.25219813f, 0.17085120f, 0.25583073f, 
    -0.14451149f, -0.10977528f, 0.13209869f, 0.07846921f, -0.11950199f, 0.26866481f, -0.15667406f, -0.07423007f, 
    -0.03153954f, -0.00445363f, -0.31711760f, 0.02490086f, -0.24726711f, -0.12408454f, 0.30709001f, -0.09711510f, 
    -0.08298624f, 0.09267633f, -0.19572492f, -0.24511346f, 0.18811689f, -0.15704656f, 0.01390194f, -0.22000325f, 
    -0.04073843f, -0.16750982f, -0.02532382f, 0.12954168f, 0.61415529f, -0.42760503f, 0.16781043f, -0.37075517f, 
    -0.13263181f, -0.02378291f, 0.00006991f, 0.06274500f, -0.19006006f, 0.49780536f, -0.28898373f, -0.11978532f, 
    0.13395953f, 0.37696314f, -0.09538066f, -0.00818797f, 0.00286935f, 0.02448245f, -0.59100348f, 0.40657112f, 
    0.27137846f, 0.14081402f, -0.03029997f, -0.00411934f, 0.32735455f, -0.03883049f, 0.12001123f, 0.55560708f, 
    0.39287958f, 0.20530671f, -0.02101590f, 0.00915769f, -0.07072741f, -0.08829445f, -0.10834155f, 0.16303320f, 
    0.26471263f, 0.29773581f, -0.49053556f, 0.04101053f, 0.04595444f, -0.07956197f, 0.15618053f, 0.07254841f, 
    -0.18317257f, -0.04300939f, -0.13612565f, 0.18462761f, -0.10279768f, 0.14409438f, 0.01480861f, -0.05042117f, 
    -0.20977367f, 0.10854361f, 0.38769329f, 0.11390860f, -0.22707701f, 0.15349483f, -0.00834983f, 0.31266484f, 
    -0.19790964f, 0.11958528f, 0.08750827f, 0.47547877f, -0.07646582f, -0.52596062f, 0.10814419f, -0.17895174f, 
    -0.30705476f, 0.00446616f, -0.02326864f, 0.20314425f, -0.37455320f, 0.25866815f, 0.09603386f, 0.11117759f, 
    0.12373952f, 0.15000996f, -0.21992895f, 0.17550771f, 0.20631656f, -0.47770426f, -1.06041002f, -0.12515591f, 
    -0.16886547f, 0.11574665f, 0.24292296f, 0.01706392f, -0.04098212f, 0.01063456f, 0.12467917f, 0.02731974f, 
    -0.81444019f, -0.09482063f, 0.09999502f, 0.18376541f, -0.15394145f, 0.00191599f, 0.08329462f, -0.09018330f, 
    0.21876892f, 0.15634407f, -0.07011717f, -0.15979302f, 0.24590257f, 0.04018091f, -0.03873923f, 0.02880744f, 
    0.05770950f, 0.03329612f, 0.06549171f, -0.01672160f, -0.03956392f, -0.08741613f, -0.09123547f, -0.01897740f, 
    0.03865769f, 0.03431964f, 0.02534674f, 0.01897843f, 0.00403272f, 0.03698524f, -0.04995750f, 0.01379618f, 
    -0.00354404f, -0.03054021f, -0.00490718f, -0.02090921f, -0.06321264f, -0.02820371f, 0.06022913f, 0.06442779f, 
    -0.02800425f, 0.05656969f, 0.04629512f, 0.06709205f, -0.04056497f, 0.03672852f, -0.05092009f, -0.04467267f, 
    -0.05914266f, -0.00498803f, 0.05790073f, -0.03830414f, -0.07380495f, -0.05832674f, 0.00822515f, -0.04587432f, 
    -0.08508592f, -0.03161515f, 0.03215073f, -0.08383907f, 0.05838865f, -0.02197888f, -0.05836192f, -0.03755932f, 
    0.00670561f, -0.07656260f, 0.06647789f, 0.00943214f, -0.02325127f, 0.01240388f, 0.05001255f, -0.02997332f, 
    0.04016634f, -0.08799683f, -0.08565716f, 0.02655470f, -0.06532302f, -0.04371576f, 0.01623328f, -0.01379499f, 
    0.00406302f, -0.09423672f, -0.08490121f, 0.03876566f, -0.07095394f, 0.02742322f, -0.07942054f, -0.01781844f, 
    0.03611213f, -0.01593651f, -0.08741738f, -0.03338337f, -0.01748491f, 0.06744362f, 0.00163346f, 0.03468910f, 
    -0.05650140f, 0.02868550f, -0.07824633f, -0.07910272f, -0.07289480f, 0.02946624f, -0.08530393f, 0.04386126f, 
    -0.07472847f, 0.00297215f, 0.07958335f, -0.02772491f, -0.07614113f, 0.00261184f, 0.00284025f, -0.08957727f, 
    0.02964155f, 0.03783425f, -0.05633492f, 0.00005907f, -0.06002777f, -0.02680636f, -0.02503711f, -0.07146093f, 
    0.04633309f, -0.07725677f, 0.02202902f, -0.07642142f, -0.07265676f, 0.06838648f, 0.02593713f, -0.08829298f, 
    0.00714867f, 0.00868123f, -0.03904337f, 0.06582783f, -0.03660038f, -0.01994532f, -0.06453421f, -0.01870376f, 
    -0.00423709f, 0.06731929f, 0.02950022f, -0.01251610f, -0.08079016f, -0.03003848f, -0.05423591f, 0.06865460f, 
    -0.01771642f, 0.01122506f, 0.04738923f, 0.03529002f, 0.04414849f, 0.01742085f, 0.07097939f, 0.06478951f, 
    0.02143518f, 0.04513542f, 0.04130305f, -0.07099131f, -0.02450943f, -0.03455477f, -0.02113802f, 0.05210533f, 
    -0.28092444f, 0.18091822f, 0.18318433f, -0.02007062f, -0.16008161f, -0.15980032f, 0.06762854f, -0.08367217f, 
    0.53260887f, 0.14305082f, -0.01620223f, -0.31898561f, 0.04951500f, 0.09967828f, 0.20496368f, 0.12141149f, 
    -0.11394997f, -0.22229357f, -0.07231543f, -0.07709049f, 0.32540756f, 0.02685406f, -0.18918589f, 0.33029488f, 
    0.29481319f, -0.17985176f, -0.02429062f, 0.13012116f, 0.36923310f, -0.15817043f, -0.01184595f, -0.02897218f, 
    0.16433969f, 0.17872839f, 0.00783851f, -0.21824829f, -0.19643532f, 0.14631857f, 0.15052314f, 0.32218868f, 
    0.14249492f, 0.28617722f, -0.24074504f, 0.06971908f, -0.01880661f, 0.16726378f, -0.07626077f, 0.18371885f, 
    -0.01309914f, -0.02194038f, -0.18042278f, 0.19249874f, 0.07978201f, 0.15215340f, -0.31513271f, -0.31823877f, 
    -0.08945867f, 0.08112796f, 0.02477260f, 0.29879797f, -0.11010383f, -0.12664452f, -0.02902714f, 0.09588738f, 
    -0.30469084f, 0.29479212f, 0.25749251f, 0.07089290f, 0.10190320f, -0.07170592f, -0.22976902f, 0.09472632f, 
    -0.31785795f, 0.03810284f, 0.01214144f, -0.06015670f, -0.01049453f, -0.15531906f, -0.33954725f, 0.19987389f, 
    -0.07757235f, 0.14872134f, 0.17182727f, -0.16369192f, 0.07068437f, -0.28641349f, 0.01457088f, -0.09063231f, 
    -0.05307712f, -0.00582755f, -0.12668557f, 0.24256796f, 0.16785584f, 0.02569387f, 0.08503154f, 0.00504832f, 
    -0.12232099f, 0.02832168f, -0.26686540f, 0.01676772f, -0.10249015f, 0.11194236f, -0.08882032f, 0.08420970f, 
    0.13415413f, 0.16538645f, 0.31656060f, -0.07998502f, 0.04797116f, 0.35511258f, -0.13260204f, 0.04895455f, 
    0.01100745f, -0.34191906f, -0.11925416f, -0.10541715f, -0.00329502f, 0.23393364f, 0.09958005f, -0.40372401f, 
    -0.13765055f, 0.24823800f, -0.17052051f, -0.28234640f, 0.35454985f, -0.05414626f, 0.03205158f, -0.23217447f, 
    0.16166227f, -0.12614536f, -0.25879771f, -0.04551985f, 0.19693916f, 0.11797258f, 0.12014173f, -0.38389936f, 
    -0.21894971f, 0.03890168f, 0.01680275f, 0.20347737f, -0.05253614f, 0.11202636f, 0.01478809f, -0.10064628f, 
    -0.13388264f, 0.11955854f, 0.04035092f, 0.21064329f, -0.31948650f, 0.00332600f, -0.32186764f, 0.09179587f, 
    -0.05535785f, 0.19094276f, -0.58323532f, -0.18691930f, 0.22212173f, 0.34091863f, -0.05658601f, 0.02280892f, 
    0.24636608f, 0.14354707f, 0.39060262f, -0.22281054f, -0.37127689f, 0.06715278f, 0.11650176f, -0.11935700f, 
    0.05790671f, -0.03255625f, -0.13489659f, 0.29205850f, 0.34380069f, 0.05745733f, -0.04216671f, -0.06737491f, 
    -0.07833714f, 0.16901296f, 0.09860630f, 0.16657096f, -0.52880067f, -0.30023551f, 0.10707766f, -0.04858715f, 
    -0.02449045f, 0.04445274f, -0.28082004f, 0.15751262f, -0.07886639f, 0.25992572f, 0.02849150f, -0.13738738f, 
    -0.08376176f, 0.11196534f, 0.05635275f, -0.05962926f, -0.07151671f, -0.06350173f, -0.10544752f, -0.27169654f, 
    0.25370866f, 0.19346049f, 0.25647122f, 0.21858656f, -0.19883581f, -0.14005758f, 0.19880037f, 0.21063116f, 
    0.00211502f, 0.21121682f, -0.13437919f, 0.27463230f, -0.22014374f, 0.01804613f, 0.30733499f, 0.11185788f, 
    0.59717894f, 0.05321709f, -0.52868146f, -0.00682643f, -0.00204023f, 0.01773079f, 0.33934224f, -0.05759489f, 
    -0.12397932f, 0.53586179f, -0.25267112f, 0.00688530f, -0.05790351f, 0.16394374f, 0.16713500f, 0.17345341f, 
    -0.02590874f, 0.17364365f, 0.25096157f, 0.08880617f, 0.18932758f, 0.31482071f, 0.03050141f, 0.14061335f, 
    -0.14778990f, -0.30889460f, 0.03656541f, -0.83295155f, 0.01966759f, 0.03745418f, -0.23201147f, 0.18668446f, 
    0.11200733f, -0.24077718f, -0.04344418f, -0.11099485f, 0.45470828f, 0.44249931f, -0.28170800f, 0.36440119f, 
    0.03827603f, -0.06236337f, 0.15883236f, 0.12376904f, 0.04336037f, 0.08629363f, 0.20601469f, 0.19250081f, 
    -0.03977275f, 0.09973314f, -0.08784714f, 0.23046479f, 0.07319200f, -0.03677407f, -0.78369308f, -0.03046537f, 
    0.08587845f, -0.23293974f, -0.01424286f, -0.09435847f, -0.23810612f, -0.13546745f, -0.08733354f, 0.50072157f, 
    -0.22463265f, 0.02825068f, 0.25898120f, 0.04179164f, -0.02740060f, 0.30446383f, 0.02111231f, -0.31176496f, 
    -0.29343185f, 0.08830496f, 0.15479435f, 0.37178642f, 0.32083571f, 0.04198061f, -0.04036860f, -0.10675201f, 
    -0.07446612f, 0.31448695f, -0.00421991f, 0.00188457f, 0.05530679f, 0.03629526f, -0.07580063f, -0.10540686f, 
    -0.03343949f, -0.08388202f, -0.50146151f, -0.11602481f, 0.37430373f, 0.10863891f, 0.13411006f, -0.21065272f, 
    -0.07835845f, 0.15061423f, 0.00462435f, -0.21738860f, 0.38499177f, 0.02726614f, 0.19063064f, 0.28423437f, 
    0.06758798f, -0.02769775f, -0.17331621f, 0.10991766f, -0.46721494f, 0.01880531f, 0.12624459f, 0.02216119f, 
    0.02067656f, 0.16088581f, -0.06615909f, -0.08450604f, 0.04551132f, -0.04130296f, 0.18295138f, -0.01505487f, 
    -0.17083007f, -0.25345168f, -0.04718570f, 0.01474167f, 0.17552400f, -0.06025344f, 0.36245948f, -0.09779892f, 
    -0.08098494f, -0.23034036f, -0.05992978f, -0.16945763f, 0.04555827f, 0.20884567f, 0.03853527f, -0.60910279f, 
    -0.25958407f, 0.46575904f, 0.10265064f, 0.29194671f, 0.01492397f, 0.03261111f, 0.10188907f, 0.27626806f, 
    -0.04850417f, 0.27951393f, -0.46152037f, 0.08121947f, -0.06746601f, 0.04240930f, -0.01486651f, -0.14133053f, 
    -0.02380890f, -0.02287772f, 0.20743755f, -0.08868373f, 0.11427492f, -0.08382118f, 0.07330834f, -0.03772049f, 
    -0.00395521f, 0.07119765f, -0.43497691f, -0.13388313f, 0.36597517f, 0.02258210f, -0.11835141f, -0.18375483f, 
    0.15069726f, 0.16864219f, -0.08531398f, 0.54548699f, -0.26478443f, 0.08228134f, 0.07553153f, -0.15702184f, 
    0.11636335f, 0.30507258f, 0.03339131f, -0.16951726f, -0.01859041f, 0.11347070f, -0.26803580f, -0.12061925f, 
    0.03944987f, -0.15794586f, -0.16429055f, 0.23814315f, 0.13284416f, 0.62511766f, -0.08852224f, 0.20184106f, 
    -0.16697809f, -0.10282077f, -0.07003043f, -0.04328955f, -0.04376213f, 0.06422404f, -0.79041475f, -0.40115508f, 
    0.16866900f, 0.12618783f, 0.07854921f, 0.10638530f, 0.18191496f, 0.05457834f, 0.03030848f, -0.09150851f, 
    -0.01003128f, -0.25356534f, -0.11842974f, 0.21617326f, -0.07409827f, -0.08270086f, -0.07444701f, -0.34959391f, 
    -0.08424678f, -0.19889100f, 0.43869242f, 0.02660194f, -0.08410671f, 0.13352713f, -0.05110037f, -0.12897106f, 
    0.12015402f, -0.02701034f, 0.25742245f, 0.02298776f, 0.08609599f, -0.08235072f, -0.08538678f, 0.22618040f, 
    -0.14391543f, -0.01445294f, -0.47274426f, -0.13869777f, 0.15316698f, 0.00839192f, -0.10271733f, -0.51593751f, 
    -0.18325134f, -0.06527136f, -0.16301450f, -0.29881489f, 0.22772966f, -0.01974527f, 0.19646864f, 0.01740754f, 
    -0.07687929f, -0.10239499f, -0.14836201f, 0.09541152f, 0.55990297f, 0.11682845f, 0.60795331f, 0.19511186f, 
    -0.44298369f, 0.14962903f, 0.13261664f, 0.14436372f, -0.14856081f, -0.16873078f, -0.24969277f, -0.04887201f, 
    -0.04078326f, -0.17063168f, -0.35089630f, 0.00726206f, -0.06057393f, -0.04886946f, 0.11932065f, 0.06206601f, 
    -0.25088635f, -0.04794704f, -0.26845354f, 0.11188261f, -0.07914123f, 0.14166564f, -0.21849321f, 0.15231104f, 
    -0.13444364f, 0.47488260f, 0.28000370f, 0.06485784f, -0.00996242f, 0.07211675f, -0.11553106f, -0.01765223f, 
    -0.05440589f, 0.15846610f, 0.18340547f, 0.00782745f, 0.08434779f, -0.07040119f, -0.13418844f, -0.10536705f, 
    -0.06307370f, 0.16835912f, -0.07435064f, 0.11660989f, 0.13380893f, -0.05479776f, 0.08738688f, 0.09980683f, 
    0.00740611f, 0.15750109f, -0.49951148f, -0.22512808f, -0.04774636f, 0.13728651f, -0.00633993f, 0.19318444f, 
    -0.19710796f, 0.17873737f, 0.07217117f, 0.40927407f, 0.02679234f, 0.36632788f, -0.12933755f, 0.15947610f, 
    0.15650661f, -0.06179911f, 0.20211115f, 0.32376599f, -0.75178462f, 0.21007220f, -0.60054469f, 0.12995744f, 
    0.10662474f, 0.03832377f, -0.24356422f, 0.07775498f, 0.10071553f, 0.25260454f, 0.25620267f, -0.28836659f, 
    -0.13065363f, -0.05982253f, 0.00352245f, -0.15138000f, -0.07949191f, 0.09561194f, 0.52871603f, -0.02758109f, 
    -0.45383120f, -0.12671815f, -0.09129845f, 0.09827450f, -0.06082100f, -0.01544443f, 0.14912872f, -0.13903235f, 
    -0.02468694f, 0.15182759f, -0.10753123f, -0.19293708f, 0.08391257f, -0.09525625f, 0.28902015f, 0.02398574f, 
    -0.10708471f, 0.53387260f, 0.12372091f, -0.07144905f, 0.13538890f, 0.27072856f, -0.15284191f, -0.09318807f, 
    -0.16041449f, -0.73461330f, -0.54942930f, -0.01009791f, 0.18205431f, 0.14111145f, 0.09374723f, 0.05253573f, 
    -0.14683469f, -0.15809040f, 0.24504550f, 0.09204003f, -0.06509895f, -0.07643763f, -0.00255761f, 0.10440898f, 
    -0.01313460f, 0.11038680f, 0.19002092f, -0.54506606f, -0.30441600f, 0.23549621f, 0.17937253f, 0.10486814f, 
    0.07984610f, -0.02373678f, 0.07406712f, 0.10517231f, -0.13284190f, 0.48976994f, 0.09356099f, -0.09356753f, 
    0.15431948f, -0.09487057f, 0.10523362f, 0.33976570f, 0.11407331f, 0.43543905f, 0.00698982f, -0.61397088f, 
    0.03458096f, -0.10073887f, -0.14345555f, -0.12582979f, 0.06275587f, -0.11157171f, -0.24016303f, -0.32564619f, 
    -0.54369712f, 0.24001090f, 0.28819755f, -0.07435583f, 0.21236312f, 0.34249797f, 0.24357280f, 0.14731675f, 
    0.71366370f, -0.35432816f, 0.07665084f, 0.17856254f, 0.05179608f, -0.08578163f, 0.48828617f, 0.02722976f, 
    0.13934262f, -0.76903707f, 0.18909685f, 0.03581880f, -0.01136217f, 0.34641117f, -0.13447711f, -0.05560592f, 
    0.13778435f, -0.28573304f, -0.45395070f, 0.10371185f, -0.07233291f, -0.03347173f, 0.16462356f, 0.09506420f, 
    -0.00338368f, 0.07557224f, -0.24945046f, -0.41323227f, 0.14424808f, 0.10394852f, 0.08559278f, 0.13959162f, 
    -0.20102632f, -0.01274989f, 0.04143826f, 0.01870641f, 0.23521578f, 0.11160821f, 0.15523663f, -0.38282380f, 
    -0.33850688f, 0.05357298f, 0.30407685f, 0.01287574f, 0.52461588f, -0.45731753f, 0.32383579f, 0.08664636f, 
    0.01976812f, 0.09025874f, 0.09860753f, -0.38295713f, 0.13993044f, 0.55677211f, 0.58002084f, -0.07534436f, 
    0.20874508f, 0.05903170f, 0.15857899f, -0.07605395f, -0.08592455f, 0.14754252f, 0.12949218f, 0.22387889f, 
    -0.02188963f, -0.02792381f, 0.03830246f, -0.03271773f, -0.17253011f, -0.08353763f, 0.17505360f, -0.02166268f, 
    -0.66940713f, -0.12560529f, -0.06161293f, -0.17178944f, -0.08688528f, -0.09005866f, -0.27121407f, -0.07854924f, 
    -0.59785122f, 0.12771241f, -0.24726109f, 0.07709083f, 0.23523061f, 0.19359738f, 0.00459546f, -0.19034344f, 
    -0.14408854f, -0.03073705f, 0.23507269f, 0.31628585f, -0.08295347f, 0.03579502f, -0.14752896f, 0.44114950f, 
    0.04600298f, 0.13346632f, -0.26872304f, 0.00264019f, 0.29545653f, -0.06224429f, -0.06168257f, 0.16666615f, 
    0.20518997f, 0.06500459f, 0.12104003f, -0.15141378f, -0.01382735f, 0.50337720f, 0.26028466f, -0.17369486f, 
    -0.20465522f, -0.04519626f, -0.05408502f, 0.15954441f, -0.08423206f, -0.09140038f, -0.04185636f, -0.42493984f, 
    -0.14626364f, -0.06353572f, -0.13059959f, -0.20301019f, 0.06550299f, -0.15809575f, -0.27710584f, -0.99103373f, 
    0.03427704f, -0.25711095f, 0.00309713f, -0.00020262f, -0.27624014f, 0.12493891f, 0.53524005f, 0.27421096f, 
    0.30925927f, 0.15418299f, -0.15548366f, -0.10009171f, 0.28530133f, 0.10967496f, -0.07303841f, -0.20585385f, 
    0.29875654f, 0.69303703f, 0.03642287f, -0.10388276f, -0.09694231f, -0.00691220f, 0.27751747f, 0.15397714f, 
    0.27092794f, -0.14068034f, -0.23881756f, -0.05536415f, 0.09816480f, 0.04845176f, 0.24174957f, -0.09753585f, 
    0.12010414f, 0.03099479f, 0.15569991f, -0.20324579f, 0.19240239f, 0.07233635f, -0.21344227f, 0.11417659f, 
    0.05199807f, 0.29205927f, 0.09430794f, -0.22113220f, -0.00855490f, 0.20282641f, 0.11982698f, -0.17838638f, 
    0.03192211f, 0.34863749f, -0.18809432f, -0.34599838f, 0.38242337f, 0.08782288f, -0.08134200f, 0.26048797f, 
    -0.44902721f, 0.10499607f, 0.07891994f, -0.22799046f, -0.23143218f, -0.41983023f, 0.04186537f, 0.12025505f, 
    0.30323452f, 0.00842669f, 0.11914918f, -0.06783862f, 0.20647806f, -0.12897272f, 0.30702212f, -0.36935988f, 
    0.05445823f, -0.28050184f, -0.12283355f, 0.00719371f, -0.16588676f, -0.14656082f, -0.26102152f, -0.16962714f, 
    -0.80149972f, -0.32462662f, 0.09694966f, -0.12151325f, 0.06537568f, 0.05925189f, -0.05898989f, 0.21799020f, 
    0.25675252f, 0.05679900f, 0.07958357f, -0.33377492f, 0.04522290f, -0.14788623f, -0.31214929f, -0.16182083f, 
    -0.52729017f, -0.34516245f, 0.06291901f, 0.11872606f, -0.04801890f, 0.01677539f, -0.02354454f, 0.01741476f, 
    0.06753427f, -0.70359546f, 0.04610670f, -0.10861188f, 0.06482366f, 0.00126567f, -0.00063110f, -0.07037757f, 
    -0.13310929f, -0.12675402f, -0.05971299f, -0.23069870f, 0.15996872f, 0.26914483f, 0.04195227f, -0.03486409f, 
    -0.07130207f, 0.01004303f, 0.12311697f, 0.17094809f, -0.04721181f, 0.31940714f, 0.27448916f, 0.39290321f, 
    -0.12208742f, -0.07340390f, 0.08322144f, -0.16695346f, -0.33783105f, 0.06608085f, -0.59420353f, 0.13682833f, 
    -0.08613196f, -0.07496198f, 0.10783643f, 0.03177538f, -0.30764595f, -0.13482411f, 0.01969993f, -0.15158911f, 
    0.01859105f, -0.14225897f, -0.21099618f, 0.02102285f, 0.14093320f, 0.04345864f, 0.23638506f, 0.09762178f, 
    -0.23697619f, 0.23248662f, -0.12064189f, -0.05417001f, 0.07904750f, -0.01113512f, 0.04048828f, -0.02813703f, 
    0.02750766f, -0.44673797f, 0.35535899f, 0.08835252f, -0.02298698f, 0.20372272f, 0.01352384f, -0.04872748f, 
    -0.40089467f, 0.17138563f, 0.45780727f, -0.19239560f, 0.22889970f, 0.11370654f, 0.01106269f, -0.08084732f, 
    0.08175996f, -0.29362923f, 0.18661666f, 0.38678464f, 0.15899554f, 0.04415150f, 0.08717474f, 0.19561779f, 
    0.04698459f, 0.33442655f, 0.20817906f, 0.28244817f, 0.49696898f, 0.18429945f, 0.12063730f, -0.07676052f, 
    0.00757184f, -0.10946178f, -0.10428250f, -0.45689654f, -0.20736778f, -0.18033321f, 0.24070504f, -0.11275645f, 
    0.08725098f, -0.13479741f, -0.25330487f, -0.01490200f, -0.04190571f, 0.08104152f, 0.35422012f, -0.24586198f, 
    0.09507248f, 0.02596322f, 0.18753484f, 0.24726063f, 0.23695406f, -0.07563334f, -0.82707328f, -0.54089665f, 
    -0.18254961f, -0.02836180f, 0.10960110f, -0.28509071f, -0.08645202f, 0.01949042f, 0.26855487f, 0.08765150f, 
    0.16924858f, -0.08626605f, 0.32350454f, 0.08004419f, 0.13349922f, -0.09436412f, 0.24500802f, -0.28969106f, 
    -0.37810293f, -0.20046458f, -0.10387121f, -0.32896701f, -0.24649501f, -0.08622737f, -0.06263466f, -0.13142286f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.45829406f, 0.18518291f, 0.00152754f, 0.05498569f, -0.06169041f, 0.05703324f, -0.09701788f, 0.01771900f, 
    -0.01107876f, -0.08598026f, 0.00731929f, -0.01864144f, -0.18431792f, 0.10412685f, 0.09999233f, 0.49475548f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.38217428f, 0.63583171f, -0.52711910f, 0.35261428f, 0.03541024f, 0.73675215f, -0.20593387f, -0.14419617f, 
    -0.06250203f, -0.04930349f, -0.57831955f, -0.30502179f, -0.43376264f, -0.28070718f, -0.22159471f, -0.12293305f, 
    -0.23111033f, 0.06700823f, 0.17430355f, 0.51666689f, -0.17209432f, -0.56326973f, 0.14511226f, 0.68018252f, 
    0.09583792f, -0.29801142f, -0.35171184f, -0.41620550f, -0.46546263f, -0.16707443f, 0.48629820f, 0.07699028f, 
    0.18821853f, -0.14098732f, -0.64453089f, -0.40716109f, 0.16139098f, 0.36789879f, 0.13764669f, 0.80178201f, 
    -0.04556749f, -0.07582679f, 0.11093754f, 0.07107179f, 0.79574388f, -0.80302364f, -0.02368900f, -0.50323129f, 
    0.32466131f, -0.77853346f, -0.28357187f, -0.70248288f, 0.18936139f, 0.49998942f, 0.09225848f, -0.51378977f, 
    -0.17907391f, -0.31585404f, -0.18472190f, -0.30852914f, 0.12814796f, 0.84875476f, -0.07266496f, -0.25329989f, 
    -0.05975361f, -0.29295838f, -0.76860821f, -0.01532999f, -0.05310344f, 0.08025634f, 0.16031577f, -0.57262635f, 
    0.04227778f, 0.55212897f, -0.16598074f, -0.09123054f, 0.28852728f, -0.27294609f, -0.22162756f, 1.00680923f, 
    -0.53736287f, 0.19616272f, 0.61377305f, 0.38358527f, 0.21360089f, -0.15008198f, -0.05876271f, -0.23953216f, 
    0.12447282f, -0.60572422f, -0.32651311f, 0.32336465f, -0.47236368f, -0.05971691f, -0.21166344f, 0.31480375f, 
    -0.02293429f, 0.05818195f, 0.97788477f, -0.31856689f, -0.18579356f, 0.13484196f, -0.08301532f, -0.37719408f, 
    0.09732798f, 0.38590425f, 0.22864121f, -0.05809267f, -0.63059270f, -0.18717070f, -1.20320535f, 0.14381427f, 
    -0.43240154f, -0.35265675f, 0.29276183f, 0.33863777f, 0.16909522f, -0.23509488f, 0.18495436f, -0.46999452f, 
    -0.20975204f, 0.51712096f, -0.94295359f, 0.50228113f, 0.72199523f, 0.20844136f, -0.14630221f, -0.67495573f, 
    -0.64332545f, 0.20974259f, -0.44840330f, -0.34498665f, 0.10789657f, -0.79400080f, 0.22362931f, -0.26046973f, 
    0.24591132f, -0.82104689f, 0.18819818f, 0.46895218f, 0.24645978f, 0.14393929f, 1.11192048f, -0.43275669f, 
    -0.36308995f, 0.31939906f, -0.48480675f, -0.34749964f, 0.04412644f, -0.24715255f, -0.14075954f, -0.65118283f, 
    0.03915827f, 0.04765632f, 0.30810606f, 1.12875211f, -0.29128113f, -0.47548559f, -0.40013644f, 0.41472366f, 
    1.04955101f, -0.44291955f, 0.02788189f, -0.04520119f, 0.12321080f, -0.56600827f, 0.02141839f, 0.13596258f, 
    0.04710161f, -0.64092809f, 0.02104091f, -0.29423338f, 0.18289571f, -0.02392556f, 0.31765348f, -0.67887580f, 
    -0.29447460f, -0.41461655f, -0.24986751f, -0.15548651f, 0.21718034f, 0.25740063f, 0.11907072f, -0.13376340f, 
    -0.04479246f, -0.12951805f, 0.76447213f, -0.88575351f, -0.40131310f, 0.17637974f, 0.06063222f, -0.16195069f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18535846f, 0.27675956f, -0.25602123f, 0.22257775f, 0.17733954f, 0.26819417f, -0.11540813f, -0.65366429f, 
    -0.10367870f, -0.06776283f, 0.43074551f, 0.07666836f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
