#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.62259001f, -0.50423354f, -0.62337857f, 0.03616219f, -0.35286617f, 0.30493787f, -0.05322639f, 0.09227293f, 
    0.22795396f, -0.24851938f, 0.58034873f, -0.23163885f, -0.72277486f, 0.56023979f, -0.45491859f, -0.09429031f, 
    -0.31004587f, 0.04124094f, 0.10567231f, 0.58961779f, -0.73240334f, -0.26182914f, -0.50127828f, -0.13897638f, 
    0.26578116f, 0.15142031f, 0.39700499f, -0.28571177f, -0.16420016f, -0.90997648f, -0.09440024f, 0.34292260f, 
    0.51840293f, -0.00138209f, -0.55896640f, -0.22708061f, -0.57086134f, -0.19718473f, -0.49200028f, -0.12344487f, 
    0.33549699f, -0.56246710f, -0.23439971f, -0.42898110f, -0.15906891f, -0.11884061f, -0.88426220f, -0.60174274f, 
    -0.44687250f, 0.07050356f, -0.05132106f, -0.11841724f, 0.30717361f, -0.20880735f, -0.12766045f, 0.14132299f, 
    0.31155276f, -0.54331464f, -0.08970939f, -0.38407612f, 0.11522143f, 0.65009570f, -0.05758088f, -0.37571642f, 
    -0.53987932f, -0.64721090f, -0.46461111f, 0.60149300f, 0.59874868f, 0.20860402f, 0.10392575f, 0.08763764f, 
    0.24139705f, -0.61392391f, 0.48533353f, 0.62251157f, -0.49481249f, 0.14715017f, -0.19311804f, 0.20792933f, 
    -0.36904705f, 0.35747698f, -0.18397294f, 0.55798185f, -0.72901231f, -0.07363611f, -0.63522601f, 0.46252391f, 
    -0.08475437f, 0.02279320f, 0.07400125f, 0.27532548f, -0.69167775f, -0.37923414f, -0.52586937f, 0.39993536f, 
    -0.56201369f, -0.05059695f, -0.02101827f, -0.78885967f, 0.58775365f, 0.57581449f, 0.08971687f, -0.17314176f, 
    0.61109799f, -0.08532742f, 0.06005350f, 0.00769299f, -0.19248472f, -0.41631350f, 0.65000409f, -0.34420100f, 
    0.27408558f, 0.80070430f, 0.10884165f, -0.45221385f, 0.28140116f, 0.63804185f, -0.23622517f, 0.74383759f, 
    0.70579636f, 0.30568272f, -0.38820475f, 0.16580769f, 0.08043613f, 0.38871107f, -0.19461170f, -0.21673419f, 
    -0.42404875f, 0.64260572f, 0.40207738f, 0.21735400f, -0.26723525f, 0.17574678f, -0.58728635f, -0.35085189f, 
    -0.20008312f, 0.07945412f, -0.10477940f, -0.43955439f, 0.72738075f, -0.12146717f, 0.29412168f, 0.44578138f, 
    -0.57246584f, 0.20675403f, 0.30484247f, 0.15609059f, 0.62142402f, -0.59362465f, 0.13106790f, -0.10507884f, 
    -0.21143299f, 0.46298432f, 0.55231017f, 0.48683903f, -0.46345145f, -0.60029745f, -0.50678313f, -0.33746815f, 
    -0.48682877f, -0.29949594f, -0.68201047f, -0.03322854f, -0.23358434f, 0.66511488f, -0.36516112f, -0.57725102f, 
    0.27265239f, 0.01500618f, -0.50195193f, 0.72990406f, 0.69740272f, 0.52965093f, -0.66609687f, -0.33880985f, 
    0.08576755f, 0.05289307f, 0.03996793f, -0.00825388f, -0.42100385f, 0.19280645f, -0.25985631f, 0.22022153f, 
    0.63584960f, 0.43920156f, -0.24100873f, 0.19133036f, 0.44344768f, -0.04998926f, -0.36752385f, -0.40619755f, 
    0.42712685f, -0.28311637f, -0.13668324f, -0.40831634f, -0.61455935f, 0.35673314f, 0.33495179f, -0.89369035f, 
    -0.41790897f, -0.34550101f, -0.81852448f, -0.27781633f, -0.00381226f, 0.27807826f, 0.43488789f, -0.20683379f, 
    0.21456787f, 0.02015002f, -0.47147393f, 0.12645726f, 0.10846493f, -0.25149131f, 0.15467764f, -0.43466705f, 
    0.32030118f, 0.36404097f, 0.49049756f, -0.04883686f, -0.39500281f, 0.54422104f, -0.44027406f, 0.01984300f, 
    0.44212899f, 0.85362285f, 0.53478009f, 0.45030370f, 0.19664934f, -0.05195428f, 0.13276803f, -0.32981786f, 
    0.31191212f, -0.38425508f, -0.42059800f, 0.37587607f, 0.07143440f, 0.25219607f, -0.37181547f, -0.83107531f, 
    -0.30047172f, 0.18491368f, 0.34625071f, 0.44700247f, 0.38072532f, 0.52701908f, 0.57507557f, 0.26916784f, 
    0.05214211f, 0.08529764f, -0.07022374f, -0.22785473f, -0.70466793f, -0.60515237f, -0.50156337f, 0.59468591f, 
    0.34401035f, 0.06766845f, 0.42339316f, 0.11181287f, 0.19384107f, 0.25013843f, 0.08144773f, 0.30892789f, 
    0.56521749f, 0.53796536f, 0.57604694f, -0.26500940f, -0.28998977f, 0.02959963f, 0.70205396f, -0.63113773f, 
    0.05719326f, -0.11266372f, 0.18186003f, 0.34123996f, -0.00720867f, -0.14631604f, 0.13266373f, -0.71067071f, 
    -0.39640591f, 0.33644778f, -0.47155419f, -0.26536304f, -0.36167970f, 0.50668579f, -0.08777239f, 0.30385751f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11831604f, -0.13314213f, -0.01844023f, 0.01451105f, 0.02177323f, -0.24615513f, 0.11648030f, -0.00808086f, 
    -0.19864368f, -0.25791407f, -0.30061299f, -0.10836939f, -0.02972463f, -0.08756093f, -0.13006298f, -0.07137211f, 
    -0.15705088f, 0.30570561f, -0.04209118f, -0.13571966f, 0.16104907f, 0.01443986f, 0.01826981f, 0.12539738f, 
    -0.01856863f, 0.29545754f, 0.03310704f, 0.06622627f, -0.22637454f, 0.04384185f, -0.02641592f, 0.00608889f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.13082390f, -0.07736003f, -0.05159463f, 0.06715406f, 0.09352796f, 0.00759277f, -0.06182959f, 0.03134115f, 
    -0.02541698f, -0.03639856f, -0.10905930f, -0.04153042f, 0.13716006f, -0.15180448f, 0.04362112f, -0.21270372f, 
    0.01860423f, 0.00601911f, -0.06571292f, -0.07748690f, 0.14026833f, 0.07492601f, 0.06278742f, 0.09239305f, 
    0.04660547f, 0.00317371f, -0.11597908f, 0.27492341f, 0.03000891f, -0.04245286f, 0.03524075f, -0.06571086f, 
    -0.17535105f, 0.01016270f, 0.10251437f, 0.03538481f, -0.01843997f, -0.26266035f, -0.11141853f, 0.07552770f, 
    0.04277152f, 0.17837361f, 0.01225808f, -0.04262509f, -0.19253542f, 0.19158213f, -0.09473698f, -0.17508392f, 
    0.11750806f, -0.13134935f, 0.06540896f, 0.07013392f, -0.07511052f, -0.06423999f, 0.05825973f, 0.03059774f, 
    -0.01333938f, 0.06191067f, 0.09291076f, 0.06617876f, 0.05975139f, -0.00273836f, -0.06394600f, 0.25615242f, 
    0.03516541f, 0.09533149f, -0.03553526f, -0.06720736f, -0.06603551f, -0.01916835f, 0.02808444f, 0.07153714f, 
    -0.06672119f, 0.18668926f, -0.00994038f, 0.04317845f, -0.14626707f, -0.07573012f, -0.02579720f, 0.06793906f, 
    0.10845923f, -0.02366069f, 0.05075753f, -0.19278254f, 0.09903022f, -0.00802592f, 0.11283605f, -0.07121944f, 
    0.08589814f, -0.07077191f, 0.05565822f, 0.01746292f, -0.14581345f, 0.17555048f, 0.00953228f, -0.17199658f, 
    0.06429601f, 0.07897107f, 0.04509179f, 0.10760461f, -0.01135729f, -0.12272897f, -0.01592263f, 0.01963761f, 
    -0.05656858f, -0.09082470f, 0.18945764f, 0.12943304f, 0.20557904f, 0.09644247f, -0.18999998f, 0.11047202f, 
    0.05488417f, 0.09193578f, 0.06437434f, -0.01827653f, 0.10384727f, -0.11932112f, 0.05532527f, 0.10332382f, 
    0.05469780f, 0.06354377f, -0.13363235f, 0.12946539f, -0.00463525f, 0.18762429f, 0.07814974f, -0.03921923f, 
    0.07382778f, 0.00957151f, -0.06045774f, -0.24491914f, -0.03926923f, 0.02919404f, -0.16983245f, 0.27880055f, 
    0.00990012f, -0.09975269f, 0.04177392f, -0.00572248f, 0.00168271f, 0.03359439f, 0.02466694f, 0.16255313f, 
    0.11982030f, -0.22973655f, -0.20074153f, 0.00571861f, 0.03265021f, -0.02470262f, -0.05601938f, 0.01999633f, 
    0.04184751f, 0.00993772f, -0.00784904f, -0.14894888f, -0.01656611f, -0.01356756f, 0.07959496f, -0.16719978f, 
    0.07146253f, -0.08149660f, 0.00157251f, -0.05485511f, 0.10861611f, -0.00481678f, 0.07120429f, -0.04754442f, 
    0.15330333f, 0.05338547f, -0.05940081f, -0.00571331f, 0.05732822f, -0.18286909f, 0.10372739f, 0.02456725f, 
    0.09837864f, -0.10898278f, 0.01750280f, 0.18329406f, 0.14354049f, 0.06262035f, -0.02508845f, 0.03608497f, 
    0.07450827f, 0.10186669f, -0.03977832f, -0.06408083f, 0.10208894f, -0.04040129f, 0.04432344f, -0.02214500f, 
    0.13012622f, -0.04727973f, 0.06487560f, 0.06554656f, 0.10449447f, -0.14046860f, -0.11272699f, -0.14990205f, 
    -0.13950926f, 0.08851757f, 0.08264986f, 0.07792551f, -0.04609890f, 0.11973932f, -0.16111413f, 0.06414729f, 
    0.02769968f, -0.14041819f, -0.00890236f, -0.04651761f, 0.04747211f, 0.08200743f, -0.14698146f, 0.05932523f, 
    0.11785109f, 0.01429668f, -0.15349692f, 0.02094854f, 0.04479789f, 0.05435425f, -0.01361053f, 0.09472834f, 
    0.07782263f, 0.08762866f, -0.08598264f, -0.07187294f, 0.13739960f, 0.02711507f, 0.02956529f, -0.08949582f, 
    0.12081333f, 0.03756168f, -0.01333062f, -0.13780208f, -0.01324050f, -0.03503506f, 0.11152887f, 0.01779385f, 
    0.00801527f, 0.18042947f, -0.00138961f, -0.06221320f, -0.11024199f, -0.01807056f, 0.13767678f, 0.03769394f, 
    -0.05110983f, -0.00649916f, 0.07041429f, 0.08685545f, 0.08324267f, -0.06579529f, 0.16636464f, -0.08923529f, 
    -0.01805279f, 0.13328910f, -0.09372855f, -0.00199777f, -0.01136218f, -0.00560055f, 0.04258737f, 0.06155748f, 
    -0.06868470f, -0.07811294f, -0.10316012f, -0.03366364f, 0.04878068f, 0.10067680f, -0.01814201f, 0.04999098f, 
    -0.15906979f, -0.02849812f, -0.10451255f, 0.00417197f, 0.15408537f, -0.01512200f, 0.09451465f, 0.05593449f, 
    -0.22587901f, -0.10044869f, -0.01254688f, 0.12591051f, 0.06919599f, 0.04453614f, -0.11738532f, -0.02047950f, 
    -0.02435865f, -0.02586055f, 0.09500795f, -0.03128701f, -0.03399512f, 0.05525282f, 0.08331890f, -0.22374620f, 
    0.12838022f, -0.00307619f, 0.22536492f, 0.02267948f, -0.06458627f, -0.12966429f, -0.04110586f, 0.05514135f, 
    0.00550301f, 0.11321098f, -0.03973173f, -0.12425729f, 0.05527335f, 0.05536498f, 0.06467893f, -0.05119419f, 
    -0.05949075f, 0.08281450f, 0.01131610f, -0.18719202f, 0.03986649f, 0.22445506f, -0.04540039f, 0.04818751f, 
    0.01975730f, 0.08384980f, -0.07889065f, 0.07522593f, 0.04194206f, 0.03071650f, 0.06800244f, 0.04957455f, 
    -0.10132542f, 0.05769538f, 0.02304827f, 0.12789184f, 0.23398627f, -0.00152747f, 0.02397474f, 0.06987290f, 
    -0.00370569f, 0.08845405f, -0.05476578f, -0.18772955f, -0.12619255f, 0.09247008f, 0.04301010f, 0.06648210f, 
    0.10255727f, -0.03230160f, -0.04484638f, -0.26164886f, 0.02234028f, 0.03698454f, -0.07321394f, -0.06150516f, 
    0.04126231f, 0.15608805f, -0.05528494f, 0.15322182f, 0.11431084f, -0.04245472f, -0.01456222f, -0.04880320f, 
    -0.06268143f, -0.11645640f, -0.01845830f, -0.13140228f, 0.12890989f, 0.06173960f, -0.02468106f, -0.04201726f, 
    -0.15007348f, -0.04763842f, -0.08496206f, -0.04794808f, 0.02147430f, -0.04044330f, -0.11119630f, -0.10568811f, 
    -0.02043417f, 0.10120272f, 0.10734315f, 0.23421423f, -0.00514849f, 0.01379057f, 0.10383529f, 0.10523821f, 
    0.17489234f, 0.14272249f, -0.07171790f, 0.21168202f, 0.18023762f, 0.05095307f, -0.12478939f, 0.04778868f, 
    0.07923619f, 0.07653781f, -0.06323837f, -0.29023558f, 0.10211014f, 0.05225200f, -0.10706097f, 0.04221207f, 
    -0.02618031f, 0.35220718f, -0.01766373f, -0.12286324f, -0.06257294f, 0.10531180f, -0.04571872f, -0.09763584f, 
    -0.10421693f, -0.03872893f, 0.09062077f, -0.03165838f, 0.05996564f, -0.21962935f, -0.19103877f, 0.02230312f, 
    0.27984923f, 0.06113949f, -0.10617071f, 0.05631698f, -0.08399097f, 0.03601867f, 0.03728236f, 0.12822336f, 
    0.10298426f, -0.09394900f, -0.05615627f, -0.10418605f, 0.14361522f, -0.02284190f, -0.11223158f, -0.08418495f, 
    0.07151543f, 0.07049202f, 0.05963261f, 0.17372666f, 0.07353648f, 0.11487455f, -0.07575642f, -0.03578673f, 
    -0.07015455f, 0.04408964f, 0.04938922f, -0.13682632f, 0.10144998f, 0.04834855f, -0.09498944f, 0.04580448f, 
    -0.01808068f, 0.09765393f, 0.05410738f, -0.11413768f, 0.00382553f, -0.08861365f, 0.09235842f, 0.08545770f, 
    0.00365607f, 0.07055178f, -0.00980410f, 0.11750846f, -0.01935424f, -0.18214925f, -0.18426573f, 0.02542304f, 
    0.00564278f, 0.03739277f, -0.01997748f, -0.18748763f, 0.17158309f, -0.04168550f, 0.13051055f, 0.02801107f, 
    -0.01952584f, 0.04417551f, 0.09379719f, -0.05104845f, -0.20924617f, 0.05070524f, 0.09929606f, 0.07368349f, 
    0.01921414f, 0.09644235f, -0.08177795f, -0.16013069f, 0.06290702f, 0.13696165f, 0.16583812f, -0.18077454f, 
    -0.07278809f, 0.01997609f, 0.02641265f, 0.08099767f, 0.08417117f, 0.03110794f, -0.05476582f, 0.04130592f, 
    0.19019924f, -0.00640300f, -0.08747237f, 0.10334422f, -0.00572301f, 0.15874867f, 0.09859955f, 0.02911930f, 
    0.06580867f, -0.01098447f, -0.13044903f, 0.00046772f, 0.04219171f, -0.08510030f, -0.07619864f, -0.12835945f, 
    -0.22008465f, 0.03039388f, -0.05453706f, -0.18331234f, 0.05703148f, 0.01387693f, 0.02681014f, 0.00157571f, 
    -0.01270108f, -0.04128659f, -0.02916731f, 0.07413873f, 0.16544107f, -0.04386820f, -0.02689444f, -0.09468177f, 
    0.08225424f, 0.07640585f, -0.05484424f, -0.00422121f, 0.06198359f, -0.02558764f, 0.04508649f, 0.03727858f, 
    0.23740250f, 0.02467576f, 0.01873079f, -0.16924706f, 0.00387643f, -0.11976984f, 0.09361347f, -0.01207392f, 
    0.00326704f, -0.08328493f, -0.06358813f, -0.10003790f, 0.05166392f, -0.17522505f, 0.01322588f, -0.00613228f, 
    0.09273403f, 0.01865702f, 0.26134509f, -0.01530580f, -0.07472850f, -0.13812429f, 0.13998555f, 0.14236496f, 
    0.09152950f, -0.14585927f, 0.16156451f, 0.03726363f, 0.08020900f, 0.06785325f, -0.05500904f, -0.07807903f, 
    0.07921398f, 0.01923101f, -0.01718795f, 0.09218686f, -0.11147700f, 0.12554358f, -0.10777230f, 0.11960129f, 
    -0.05746227f, 0.05201615f, 0.01820258f, -0.02486129f, -0.05255697f, -0.02723793f, -0.04472158f, -0.05941623f, 
    -0.03926282f, 0.00803638f, -0.04692538f, -0.00679547f, 0.03927804f, -0.02716794f, -0.04223254f, -0.05847146f, 
    0.05245377f, 0.01802332f, -0.05415317f, -0.02065607f, -0.04688472f, -0.02174180f, 0.04411684f, 0.04421041f, 
    0.00677544f, 0.02979837f, 0.00909365f, 0.01363347f, -0.03881098f, -0.06012910f, 0.00812421f, -0.00000367f, 
    0.03361395f, -0.00475974f, -0.00029555f, 0.00411865f, -0.05113312f, 0.04083662f, -0.04751249f, -0.04892954f, 
    -0.06323408f, -0.03723782f, -0.00692403f, 0.04720004f, -0.06261791f, -0.00409351f, -0.01935574f, -0.04143792f, 
    -0.00778281f, -0.01723171f, 0.05023524f, -0.01774601f, 0.01556894f, 0.04794627f, -0.01100113f, 0.01901025f, 
    -0.06501443f, 0.03032749f, -0.00531687f, -0.00393656f, -0.05769895f, 0.04186906f, 0.04435375f, -0.02667590f, 
    0.01228413f, 0.03021913f, -0.01134594f, -0.01121182f, -0.04548447f, -0.03010397f, 0.00586783f, 0.00629210f, 
    -0.05844073f, -0.00979729f, 0.01116783f, -0.04336708f, 0.04032009f, -0.03731864f, 0.02599645f, 0.03520190f, 
    -0.04587107f, -0.03147198f, 0.03005740f, 0.02241008f, 0.00881933f, -0.04115359f, 0.01619071f, -0.03384669f, 
    -0.01263784f, -0.01389595f, -0.06755715f, -0.05446254f, 0.03146372f, -0.01901020f, -0.03686347f, 0.03712025f, 
    0.01621684f, -0.05260241f, -0.04406196f, 0.04329004f, -0.00736313f, 0.04155039f, -0.01261175f, 0.01896907f, 
    -0.03206657f, -0.01905496f, -0.03106904f, 0.01898794f, -0.04825833f, -0.00146494f, -0.05424344f, -0.02526423f, 
    0.01067279f, -0.00425548f, -0.02606841f, -0.02734352f, 0.03871261f, -0.02323701f, 0.03410332f, -0.01592666f, 
    -0.01535287f, 0.00430054f, 0.00330115f, -0.02392031f, 0.00833225f, -0.06086506f, -0.03064462f, 0.03256513f, 
    -0.02606766f, -0.00895654f, -0.05303315f, -0.02899581f, 0.04656862f, -0.03920566f, 0.01498039f, -0.02537267f, 
    -0.04718619f, -0.05628416f, 0.01526266f, -0.03624383f, -0.05045014f, -0.05065374f, -0.01332115f, -0.06342408f, 
    0.03342962f, -0.06799337f, 0.00644620f, 0.02733478f, 0.04649407f, -0.03113819f, 0.00901920f, -0.03832560f, 
    -0.01847459f, 0.01237292f, 0.03296630f, -0.04064285f, -0.00857393f, 0.03588978f, 0.00652812f, 0.01971909f, 
    0.00449314f, -0.00238722f, -0.00540401f, 0.01508864f, 0.00126630f, 0.03180434f, 0.03077734f, -0.03083526f, 
    -0.06392045f, -0.06337809f, -0.03335922f, -0.01420228f, -0.02106644f, 0.03182942f, -0.02427041f, 0.02874282f, 
    0.06034311f, -0.00475296f, -0.03966840f, 0.00798381f, -0.06744269f, 0.05756585f, -0.04582369f, 0.03059259f, 
    0.03960427f, 0.00440760f, -0.04715024f, 0.03601949f, 0.01343569f, -0.02242565f, -0.03364365f, -0.02478796f, 
    0.04483461f, -0.02149142f, -0.05363059f, -0.03532253f, 0.04373831f, -0.05614067f, -0.01726674f, -0.02521644f, 
    -0.00062106f, 0.00484421f, -0.04347258f, -0.05382440f, -0.01531126f, 0.03948870f, -0.01961501f, -0.05867665f, 
    0.00855415f, 0.01610791f, 0.04073928f, 0.01462849f, -0.02026660f, -0.00070439f, 0.03711082f, 0.02712083f, 
    0.01332238f, 0.00739953f, -0.01061190f, -0.03079656f, 0.00539652f, 0.04582573f, 0.03283991f, -0.02724515f, 
    -0.05373969f, -0.05828355f, 0.03624063f, -0.01914522f, -0.00479322f, -0.00755283f, -0.04414485f, 0.00971481f, 
    0.00489994f, 0.00557207f, -0.01971158f, -0.05973362f, 0.04262918f, 0.01483014f, -0.04243019f, -0.06779481f, 
    -0.03750362f, 0.03884479f, -0.01231030f, 0.01657132f, -0.05905383f, 0.04138689f, -0.03492639f, 0.03730478f, 
    -0.00397478f, 0.00372776f, 0.03421772f, 0.01497489f, -0.00364950f, 0.01049932f, 0.06277575f, -0.02173381f, 
    0.01628783f, -0.06043012f, -0.05496969f, -0.03120714f, 0.01652384f, -0.01553260f, 0.04862880f, 0.03248008f, 
    -0.05981584f, 0.02666409f, -0.00224273f, -0.00631651f, -0.00842519f, -0.05901500f, -0.04388935f, 0.00058006f, 
    -0.02880860f, 0.01846628f, 0.00371369f, -0.02631716f, 0.02091400f, 0.04401379f, 0.04458967f, 0.02588540f, 
    0.01128411f, -0.03640091f, -0.03096910f, 0.03373056f, -0.00543421f, 0.00142943f, 0.03611722f, 0.01596900f, 
    -0.05785512f, -0.03403022f, 0.00409046f, -0.01676546f, 0.00678396f, 0.04790960f, -0.06859017f, -0.04865410f, 
    -0.03726206f, 0.00331982f, -0.03421316f, 0.05292068f, -0.05418435f, -0.06560780f, 0.02364163f, 0.02063020f, 
    -0.06740773f, -0.03014126f, 0.04727928f, -0.03432225f, -0.06023130f, -0.05437401f, 0.04343393f, 0.01962557f, 
    0.04103128f, -0.04911565f, -0.04231076f, -0.02372425f, -0.01142682f, -0.01100485f, -0.01651691f, -0.04671610f, 
    0.03569204f, -0.03324720f, 0.00847347f, -0.01863480f, -0.05577993f, -0.05350849f, 0.02953686f, -0.02178278f, 
    -0.01266575f, -0.00978785f, -0.02748454f, -0.03644732f, -0.01178441f, 0.04197875f, -0.02162524f, 0.03509666f, 
    -0.05722451f, -0.01480164f, 0.03013405f, -0.03302395f, 0.01655143f, -0.01215070f, 0.02688435f, 0.02297461f, 
    -0.06454462f, -0.05033485f, -0.02104818f, 0.00877403f, 0.04467743f, 0.04156674f, -0.03027830f, -0.02656660f, 
    -0.03116631f, -0.04462261f, 0.03271320f, -0.00364252f, 0.03482283f, -0.00383310f, 0.03929751f, -0.02925066f, 
    -0.01133206f, -0.03948259f, 0.03373861f, -0.05286021f, -0.03398073f, -0.03363721f, 0.01546492f, -0.04736696f, 
    0.01247578f, 0.04323576f, -0.00043442f, 0.02383569f, 0.03920537f, -0.01932365f, 0.03321823f, -0.00372130f, 
    0.01961006f, 0.03614950f, 0.04451210f, 0.01252289f, -0.04101385f, 0.01589540f, -0.04062471f, -0.06685956f, 
    -0.03400428f, -0.06371763f, 0.04852351f, 0.03102857f, -0.01075236f, 0.01669499f, -0.04140140f, -0.00788396f, 
    -0.00626094f, -0.05386288f, -0.05102294f, -0.00457625f, -0.05785399f, -0.03140289f, 0.00514723f, 0.02381539f, 
    0.00106844f, -0.00540369f, 0.02696439f, 0.03191853f, 0.04732807f, 0.03075971f, 0.04802199f, 0.04470793f, 
    -0.06889046f, -0.03117754f, -0.06780544f, -0.03977865f, -0.06504859f, -0.05940597f, 0.01239077f, -0.01292466f, 
    0.03238115f, 0.04622081f, -0.00398168f, 0.05006138f, 0.01575310f, -0.02762252f, 0.02549957f, 0.02103983f, 
    -0.00175991f, -0.03347990f, -0.00023097f, -0.04718585f, 0.02020581f, -0.06217418f, -0.01448819f, -0.01398367f, 
    -0.06374408f, -0.03997067f, -0.00464938f, -0.02646253f, -0.06993227f, -0.06207458f, 0.04621435f, -0.06501687f, 
    0.01432160f, 0.00986975f, 0.01530867f, -0.03938690f, -0.00205705f, -0.05390380f, 0.03570067f, -0.03290349f, 
    0.01210476f, -0.01863452f, 0.02915421f, -0.03056374f, 0.02061297f, 0.03625351f, 0.01505652f, 0.03531743f, 
    -0.00894465f, -0.05593183f, -0.05663382f, 0.02177751f, 0.02605933f, -0.04330624f, 0.00722678f, 0.03901509f, 
    0.02821516f, 0.04450331f, -0.01471813f, -0.02207421f, 0.00599616f, -0.00531224f, -0.04756701f, -0.02655548f, 
    -0.02570976f, 0.01436609f, 0.01503552f, -0.06463358f, 0.03148444f, -0.00444487f, -0.02799810f, -0.05869777f, 
    -0.06853256f, -0.05210770f, -0.01404691f, -0.06440905f, -0.06279285f, -0.03099617f, -0.04508584f, 0.03264977f, 
    0.00603175f, 0.03577805f, 0.02773461f, 0.02001926f, 0.00247791f, 0.03136073f, -0.02826418f, 0.00594379f, 
    0.04697648f, -0.03698966f, -0.00372264f, -0.04028516f, -0.06256429f, 0.03903786f, -0.03860909f, 0.00116029f, 
    0.03395849f, -0.00544699f, 0.03665081f, -0.02614748f, 0.01667168f, 0.00074561f, -0.01538054f, 0.02940178f, 
    0.04358082f, 0.03285482f, -0.05568067f, -0.05430982f, -0.02421441f, -0.05505344f, 0.00659606f, -0.01717579f, 
    -0.00356243f, 0.02183895f, 0.01780046f, -0.02010721f, -0.06938732f, -0.02718425f, -0.03590778f, -0.01594980f, 
    -0.06863660f, -0.06226607f, -0.03909898f, -0.05062027f, -0.00369291f, 0.00393456f, -0.06324496f, -0.05079426f, 
    0.01416579f, 0.02478638f, -0.04477206f, 0.02489974f, -0.01409107f, 0.04402444f, 0.01005826f, -0.01502569f, 
    0.03108562f, 0.01507187f, -0.03191556f, 0.02324550f, -0.03433581f, 0.02000763f, -0.06792910f, -0.06648242f, 
    -0.00905637f, 0.03290795f, 0.00148418f, 0.03892332f, 0.01032679f, 0.04497312f, -0.03719996f, -0.03046833f, 
    -0.04519136f, 0.01638294f, 0.03436876f, 0.00388972f, -0.06329809f, -0.02238171f, 0.02692459f, 0.01982561f, 
    0.02165629f, -0.03972256f, -0.02452075f, -0.05893991f, -0.04195126f, -0.02059913f, 0.00356447f, 0.03130994f, 
    -0.03474196f, 0.02472909f, -0.04922748f, -0.03450251f, 0.00078635f, -0.01818747f, -0.01418899f, -0.02632487f, 
    0.03068404f, -0.03525176f, 0.04893173f, 0.02001952f, 0.01133485f, -0.04142388f, 0.01259245f, -0.01132250f, 
    0.01218944f, -0.02665608f, -0.05717079f, -0.00145570f, -0.03990494f, -0.03412383f, 0.02467603f, -0.04171380f, 
    -0.02493205f, -0.00133234f, 0.00807317f, -0.01008534f, -0.05264944f, -0.03987208f, -0.00972009f, 0.00952790f, 
    -0.00937767f, 0.01567867f, -0.04404913f, -0.05321473f, -0.01952192f, 0.02340535f, 0.01488855f, 0.05039600f, 
    -0.00052531f, -0.00333419f, -0.03453670f, -0.00657150f, 0.04367342f, -0.03283495f, -0.04672256f, 0.04957864f, 
    -0.00638397f, 0.03779726f, 0.02153726f, -0.03152760f, -0.01999771f, 0.05242017f, -0.04418055f, 0.05178690f, 
    -0.01005163f, 0.02654500f, 0.01368227f, 0.05792277f, -0.01018226f, 0.00555124f, 0.01693460f, 0.05108940f, 
    0.02132608f, -0.05234972f, -0.04552737f, -0.01801853f, -0.02572514f, -0.05250491f, 0.00498710f, 0.03515212f, 
    -0.03484759f, 0.04717569f, -0.01121612f, 0.00750861f, 0.05879257f, 0.03333182f, 0.03071431f, 0.03760321f, 
    0.03510121f, -0.01602412f, -0.01119854f, 0.04619482f, -0.03437003f, 0.02833223f, -0.04122093f, -0.03669089f, 
    -0.04074859f, -0.02540784f, -0.00712735f, 0.01058173f, -0.03848859f, 0.05309471f, -0.04031216f, 0.04491885f, 
    -0.03312773f, 0.03481053f, -0.02486878f, -0.01549281f, -0.05615443f, 0.03677459f, 0.01773281f, -0.06248193f, 
    0.06348661f, -0.00724183f, -0.05116246f, -0.02135812f, 0.01257951f, 0.04055769f, -0.03184012f, -0.05923727f, 
    -0.02455658f, -0.01537623f, -0.01889784f, 0.00894772f, -0.01392004f, 0.00526618f, -0.03515926f, -0.04324492f, 
    0.04545795f, 0.02843784f, 0.03180447f, 0.04781628f, -0.05777606f, -0.00269039f, 0.01733371f, -0.01657199f, 
    -0.04325728f, 0.03047803f, 0.04548255f, -0.04419273f, -0.01068325f, 0.03233331f, 0.01390972f, 0.04267867f, 
    0.00224462f, -0.00204603f, -0.01859666f, 0.04931949f, 0.00991728f, 0.02187114f, 0.02146433f, -0.00687109f, 
    0.05117436f, -0.02839387f, -0.03543917f, 0.03249697f, 0.01575334f, 0.03964739f, -0.00625321f, 0.05489533f, 
    0.02108491f, 0.02993415f, 0.02036251f, -0.01693825f, -0.01618287f, -0.03337606f, -0.03884382f, -0.01685742f, 
    -0.03247892f, -0.06474277f, -0.03068801f, -0.00564474f, -0.06058919f, -0.05399228f, -0.00550396f, 0.04520731f, 
    0.04329106f, -0.00503977f, 0.02383008f, -0.00296493f, -0.00674869f, 0.00749555f, 0.05205120f, 0.02542113f, 
    -0.02589056f, 0.00521016f, 0.03718867f, -0.05503825f, -0.00024054f, 0.02321620f, -0.05138489f, -0.01365366f, 
    0.00285701f, 0.05016819f, 0.03968678f, 0.02775598f, -0.05331543f, -0.01023503f, 0.04634269f, -0.00386531f, 
    -0.00059199f, 0.05276654f, 0.04522047f, 0.03253344f, -0.02775114f, 0.00761454f, -0.04502809f, -0.03794795f, 
    -0.01237611f, -0.00323885f, -0.06140764f, -0.03090516f, 0.01290606f, -0.04902509f, 0.03217700f, -0.05212273f, 
    0.00005694f, 0.00877782f, 0.01103392f, 0.03504984f, -0.04271712f, -0.05508611f, 0.00759349f, -0.02002326f, 
    0.01596902f, 0.03793063f, -0.02782891f, -0.04833513f, -0.01483458f, -0.00920430f, 0.04830030f, -0.03837437f, 
    -0.01348849f, -0.05079513f, 0.01939717f, -0.03478479f, -0.03780794f, -0.02575250f, -0.05331324f, 0.02161273f, 
    0.01878768f, 0.03471492f, -0.01680196f, -0.05700919f, 0.02354036f, 0.00340399f, -0.02533282f, 0.03990294f, 
    -0.02767413f, 0.01901573f, -0.06018999f, 0.03542132f, -0.01401217f, 0.02719305f, -0.06448466f, -0.01494792f, 
    0.04510504f, -0.02421030f, 0.00435235f, -0.03600479f, 0.05068034f, -0.03961987f, -0.04324515f, 0.01064068f, 
    -0.04154711f, -0.04345639f, 0.02857843f, 0.03454096f, -0.00269270f, -0.04685790f, -0.01033267f, -0.04938794f, 
    0.04374747f, -0.05331849f, -0.03194662f, 0.02016976f, -0.05422785f, 0.02585603f, -0.02735729f, -0.01596030f, 
    -0.02222983f, 0.01443452f, 0.03060952f, 0.02774957f, -0.04815415f, 0.02298055f, -0.04774671f, 0.02284695f, 
    0.01055357f, -0.00061766f, -0.05842750f, -0.02939422f, -0.02796349f, 0.03982651f, 0.03853840f, -0.00683434f, 
    0.06927042f, 0.21402287f, 0.17122689f, 0.09169547f, 0.07959040f, -0.03403075f, -0.04349599f, -0.05938000f, 
    0.06107015f, -0.17014390f, -0.06813514f, -0.01500384f, 0.11425604f, -0.02799194f, 0.00095106f, -0.04893505f, 
    -0.01319927f, -0.27069283f, -0.04204297f, 0.00457640f, 0.01852724f, -0.07399358f, -0.00651506f, 0.07694485f, 
    0.08076669f, -0.05028404f, -0.20455998f, 0.13751295f, 0.06856149f, -0.06409452f, 0.01556437f, 0.01360916f, 
    -0.12704054f, 0.08340353f, -0.02439142f, -0.02839846f, 0.01727589f, 0.08590447f, 0.10696754f, -0.02316793f, 
    0.09811870f, 0.09722368f, 0.01815351f, 0.01731496f, -0.11667161f, 0.11036052f, 0.22261091f, 0.15300934f, 
    0.04152527f, -0.08921393f, -0.11127904f, 0.13082638f, 0.09802626f, -0.03824803f, 0.00079992f, -0.36867663f, 
    -0.05519513f, 0.05594427f, 0.01221075f, -0.04917962f, 0.08760136f, -0.10685261f, 0.01986047f, 0.04134791f, 
    0.07317301f, 0.12762643f, -0.04835511f, -0.03730257f, -0.07273074f, 0.10876267f, 0.05383372f, -0.02556973f, 
    0.07831983f, 0.22073744f, 0.11095598f, 0.04671361f, -0.05645377f, -0.13435890f, 0.12069760f, 0.06950694f, 
    -0.07090880f, 0.00850627f, -0.20865625f, -0.11109874f, -0.01132644f, -0.00048364f, 0.09456221f, -0.02761208f, 
    0.06209562f, 0.08005320f, 0.31369138f, -0.03226251f, 0.08632386f, -0.00864395f, -0.02170948f, -0.14258237f, 
    -0.08539505f, 0.17414436f, -0.13929202f, -0.06790997f, -0.04854983f, 0.01984289f, 0.14044745f, -0.02163791f, 
    -0.05313114f, 0.03298916f, -0.15634088f, 0.00127743f, 0.00122672f, 0.00868409f, 0.06809910f, 0.05690389f, 
    -0.09030531f, -0.11524543f, -0.02132638f, 0.09352861f, -0.03458979f, 0.14371943f, 0.18037061f, 0.16722345f, 
    -0.02515409f, 0.01416674f, -0.18764570f, 0.02815936f, 0.09503672f, 0.07155633f, 0.09763530f, 0.14178748f, 
    -0.08063660f, 0.04046712f, -0.01412327f, -0.13858089f, 0.10891401f, -0.01008998f, -0.07164112f, -0.12567072f, 
    -0.01218808f, 0.20746903f, 0.05393337f, 0.00288639f, 0.06957974f, -0.02855401f, -0.04415271f, -0.04009276f, 
    0.08369827f, 0.23017396f, -0.01667105f, 0.10011210f, -0.02238395f, -0.01392908f, 0.04810062f, 0.08904010f, 
    0.00241315f, -0.16325814f, -0.26092485f, -0.16612171f, -0.12815432f, -0.03596220f, 0.12073274f, -0.18220873f, 
    -0.03666084f, -0.06278843f, -0.12889133f, 0.08500517f, 0.07383913f, 0.03431863f, 0.01511255f, 0.02211130f, 
    -0.02652344f, 0.00442349f, -0.20695442f, -0.15096731f, -0.15466486f, 0.12349293f, 0.06701964f, -0.11517720f, 
    0.07626605f, -0.07917680f, 0.09280221f, 0.02005542f, -0.00132828f, -0.08298971f, 0.08103469f, 0.04932600f, 
    0.04437894f, -0.05892973f, -0.06048255f, -0.03283301f, 0.11207590f, 0.21246485f, 0.21786477f, -0.06643828f, 
    0.05187708f, 0.11148082f, 0.00190163f, -0.06110162f, 0.01934300f, -0.11039256f, 0.12484650f, 0.21856250f, 
    -0.08628022f, -0.05818653f, -0.02332202f, 0.16770242f, -0.05983314f, -0.12985484f, -0.02869596f, -0.04056867f, 
    -0.15592732f, -0.07419498f, 0.07584961f, -0.18349263f, -0.13043480f, -0.12963098f, -0.06033947f, -0.07914241f, 
    0.01691927f, -0.12018181f, 0.02762126f, -0.11172905f, -0.04331593f, -0.01338414f, -0.11547666f, 0.06515983f, 
    0.00608426f, 0.02834992f, 0.02338851f, 0.06446221f, 0.18168153f, -0.08108716f, -0.04791106f, 0.09568829f, 
    -0.16048758f, 0.07592997f, -0.10819419f, -0.19671626f, -0.09038734f, 0.09523519f, 0.08778901f, -0.01464511f, 
    -0.03055671f, 0.09493020f, -0.05590161f, 0.17157958f, 0.02530149f, -0.08167558f, 0.04264009f, 0.02456334f, 
    -0.02341794f, 0.00882234f, -0.16103333f, 0.16222778f, 0.11484846f, 0.11227486f, 0.24959114f, 0.07041113f, 
    0.01349772f, -0.09410692f, 0.02020767f, 0.11168172f, 0.01355077f, 0.10211061f, -0.02608081f, -0.03551977f, 
    0.03629591f, 0.04948094f, -0.15610509f, 0.13606782f, -0.04299198f, 0.00688496f, -0.12848555f, 0.19193791f, 
    0.01530100f, 0.15720485f, -0.07963585f, -0.17057063f, -0.02482218f, 0.00028631f, -0.11984654f, 0.01826159f, 
    -0.03209184f, -0.03544357f, 0.10282513f, -0.11269453f, 0.10772512f, -0.04571720f, 0.08312136f, 0.01034879f, 
    -0.04094531f, 0.02217448f, -0.05879683f, -0.00195819f, 0.00518529f, -0.04584087f, 0.03826644f, 0.00639170f, 
    -0.03806884f, 0.02068820f, 0.00838450f, -0.05801379f, -0.00607182f, -0.02605574f, -0.01278601f, 0.03053419f, 
    0.01620839f, 0.05379128f, -0.05146779f, -0.04796955f, -0.05662324f, -0.00664084f, -0.03875254f, 0.02564837f, 
    -0.04730626f, 0.02988297f, 0.03922599f, -0.03836245f, 0.02928332f, -0.04858734f, -0.05628892f, -0.01013491f, 
    -0.00359369f, 0.05171561f, 0.02161395f, 0.02937385f, 0.02556019f, 0.04236083f, -0.04292501f, -0.01639557f, 
    0.00758744f, -0.02724315f, -0.04813129f, -0.04252075f, 0.02208854f, -0.00223405f, 0.04610876f, -0.02504425f, 
    -0.05337140f, 0.05849595f, 0.02660358f, -0.01124085f, 0.00413716f, -0.05242687f, -0.00273735f, -0.03236373f, 
    -0.01593232f, -0.03607994f, 0.01479960f, 0.04941028f, 0.04884337f, -0.00136910f, 0.04401083f, -0.00106718f, 
    0.01166193f, 0.03566201f, -0.00331107f, -0.01973955f, -0.00153083f, 0.03759719f, 0.02213485f, -0.01826989f, 
    0.02501642f, -0.03901738f, 0.05045991f, 0.04990424f, -0.05382606f, -0.00360776f, 0.03432734f, 0.02805319f, 
    -0.01354532f, -0.00618203f, 0.04661246f, -0.02420999f, -0.04276806f, 0.04274684f, 0.02304291f, -0.05852492f, 
    0.03315339f, -0.02443322f, -0.03327706f, -0.04650455f, -0.02798565f, -0.03789029f, -0.00015436f, -0.04364425f, 
    0.02207373f, -0.03989125f, 0.05561294f, -0.04093299f, 0.02699804f, -0.02202248f, -0.02855080f, -0.00588158f, 
    -0.01652825f, 0.04314366f, 0.04327641f, -0.02602560f, -0.01064445f, 0.02963081f, 0.01103844f, -0.00528987f, 
    0.02866241f, 0.02350779f, 0.01698861f, 0.03059167f, 0.05616539f, -0.01026583f, -0.02105483f, -0.02711610f, 
    0.02064257f, -0.03758470f, 0.02795877f, -0.04465369f, -0.05351286f, 0.02645818f, 0.04751480f, -0.01838867f, 
    -0.05892439f, -0.04176013f, 0.00243565f, -0.03937224f, -0.00713178f, -0.05615727f, -0.02179961f, 0.02654380f, 
    -0.03037015f, -0.03710525f, -0.02851843f, 0.04365700f, 0.02505344f, -0.02791838f, -0.04055800f, 0.03640695f, 
    0.02262160f, -0.00708857f, -0.02703482f, -0.03690936f, 0.00462805f, -0.04896414f, -0.03181021f, 0.04906274f, 
    -0.02411858f, -0.01621430f, -0.04795201f, 0.03391597f, -0.05295273f, 0.00029539f, -0.05143046f, -0.01402914f, 
    -0.05109493f, 0.02370732f, 0.02080875f, -0.04064051f, -0.05735034f, -0.00230349f, 0.04258451f, -0.03252866f, 
    -0.04899242f, 0.00129311f, -0.00145414f, -0.03909978f, -0.02076115f, 0.01003427f, 0.00781217f, -0.04920751f, 
    -0.04825012f, 0.01346153f, -0.02121653f, -0.01307177f, 0.02167797f, -0.03864515f, -0.00352636f, -0.03322253f, 
    -0.02874452f, -0.00150655f, -0.05876776f, -0.02985333f, -0.01290204f, 0.03624472f, 0.01868410f, 0.05350089f, 
    -0.04840326f, 0.05032340f, 0.01200435f, 0.00192096f, 0.00347933f, 0.00879667f, -0.02353085f, -0.04495984f, 
    -0.04170838f, -0.01514422f, -0.02495320f, 0.01280662f, -0.04739547f, -0.01267297f, 0.03094753f, 0.03438180f, 
    0.04353731f, -0.00486531f, 0.04721455f, 0.03984116f, -0.00687662f, 0.04395221f, 0.04965936f, 0.05464235f, 
    0.01344348f, 0.02608856f, -0.00121490f, -0.05495215f, -0.02572232f, 0.02984857f, 0.00995540f, -0.01966604f, 
    -0.00366648f, 0.01862327f, -0.00536862f, -0.03597444f, -0.01632846f, 0.01973134f, 0.05608716f, -0.01689950f, 
    -0.02402012f, 0.02825783f, -0.02774412f, -0.03649040f, -0.01532110f, -0.00894398f, 0.01081711f, -0.05616948f, 
    -0.01460360f, -0.03170256f, -0.05753142f, -0.01029452f, 0.03087642f, -0.04184995f, 0.02502643f, 0.00306637f, 
    -0.04426583f, 0.00451883f, -0.03441441f, -0.03605445f, 0.02939379f, 0.05407035f, 0.04007325f, 0.04001842f, 
    0.02900301f, 0.00207877f, 0.01041663f, 0.05339117f, 0.02334302f, -0.04263205f, -0.03016704f, -0.01121526f, 
    0.03288485f, -0.02603064f, 0.02505101f, 0.00362865f, 0.00639016f, 0.00482392f, 0.04055784f, -0.05250509f, 
    -0.03227056f, 0.03255714f, -0.05017643f, -0.02904212f, -0.01871513f, 0.00477817f, 0.00331794f, -0.03073057f, 
    -0.00168224f, 0.02573550f, 0.00454255f, -0.02860856f, -0.03548310f, 0.00698365f, 0.01309657f, -0.04746539f, 
    -0.03596706f, -0.04666019f, -0.05085934f, 0.03535995f, 0.03239756f, 0.02303605f, -0.03906592f, -0.04960974f, 
    -0.05115785f, 0.00202689f, -0.07296850f, -0.07030240f, -0.00299508f, -0.06105188f, -0.05930310f, -0.03524012f, 
    -0.00933801f, -0.02632015f, 0.02495016f, 0.01780384f, -0.00873738f, 0.02675345f, -0.06286464f, 0.00970194f, 
    0.02369970f, -0.06496253f, -0.00673597f, -0.04018384f, 0.04020318f, -0.05695386f, -0.01333806f, 0.03243989f, 
    -0.00734284f, 0.01836141f, -0.04251648f, -0.01334288f, 0.00019517f, -0.03337085f, -0.05655171f, 0.00202640f, 
    0.00733475f, -0.06320917f, -0.06210898f, -0.02520713f, -0.00950569f, -0.02693704f, -0.05650686f, -0.02764278f, 
    -0.06007243f, -0.04140364f, -0.02612173f, -0.04881812f, 0.03337519f, -0.03441934f, -0.04729598f, -0.05325193f, 
    0.03388268f, -0.07427048f, -0.07309310f, 0.00402935f, 0.01832434f, 0.02196472f, -0.01515041f, 0.03631636f, 
    0.03709046f, 0.01910449f, -0.03409021f, -0.02682267f, -0.02776037f, -0.00052546f, -0.06784116f, -0.00596082f, 
    0.01208519f, -0.01405486f, -0.06924117f, 0.04577288f, -0.00235913f, 0.02604957f, 0.03928537f, -0.03369833f, 
    0.02546864f, -0.06537344f, -0.02565228f, -0.07286722f, 0.03806307f, 0.02795610f, -0.02354862f, 0.02605757f, 
    0.00592705f, -0.05383154f, 0.03086682f, 0.03096055f, -0.02301568f, 0.03358092f, -0.02856705f, -0.05551004f, 
    0.01563345f, -0.05771196f, -0.01482030f, -0.06732549f, 0.01099670f, -0.04848652f, -0.05405637f, -0.06481005f, 
    -0.05286330f, 0.03232497f, -0.02739707f, -0.05604523f, -0.01408665f, 0.00475458f, 0.02934452f, 0.00449384f, 
    0.02845689f, 0.04149989f, -0.04425777f, 0.03024067f, -0.05105707f, -0.03356893f, -0.06817669f, -0.03774005f, 
    0.00110345f, -0.05752115f, 0.03198830f, -0.04584892f, -0.05031764f, -0.06191512f, 0.04228297f, 0.00257475f, 
    -0.05304313f, 0.01201050f, -0.02074811f, 0.02775535f, 0.01932654f, -0.00273554f, -0.02472109f, -0.04857059f, 
    0.03343367f, 0.01258101f, -0.03951668f, 0.03975943f, -0.01273625f, 0.00692585f, 0.01254863f, 0.01562209f, 
    0.02384133f, 0.01114438f, 0.03213347f, -0.04019666f, -0.04126857f, -0.04951544f, -0.06470998f, -0.04208177f, 
    0.04149564f, -0.05602814f, -0.03272826f, 0.00454576f, 0.03401519f, -0.06433957f, 0.04197378f, -0.06632544f, 
    -0.02715065f, -0.01329835f, -0.07004352f, -0.03180736f, 0.01273152f, 0.03931523f, 0.01071201f, -0.04994572f, 
    -0.00072224f, -0.05452599f, 0.00990653f, -0.08109212f, -0.04119749f, 0.00186889f, -0.03488268f, -0.00368041f, 
    0.02560851f, 0.04310494f, -0.00609854f, 0.03895785f, -0.00614561f, 0.02265130f, -0.04915599f, 0.01776815f, 
    0.03361692f, -0.00702990f, -0.03837021f, 0.04445395f, -0.01112553f, 0.02628051f, -0.04337105f, 0.03447557f, 
    -0.01472162f, -0.03773579f, 0.01482967f, 0.02827140f, 0.01713369f, -0.02212595f, -0.02939296f, -0.02860119f, 
    -0.03089132f, -0.05445882f, -0.02085315f, -0.06068660f, -0.04605979f, 0.00156641f, 0.03579891f, -0.01300141f, 
    -0.02122629f, 0.01758390f, 0.00291897f, -0.06446364f, -0.06366681f, 0.02649735f, 0.03785848f, -0.01781533f, 
    -0.04536912f, 0.05252174f, -0.06945822f, -0.06314669f, 0.04383757f, 0.01034332f, 0.04556691f, 0.01020911f, 
    0.04666825f, -0.05509511f, -0.05307873f, 0.00446794f, -0.03079028f, -0.02856215f, -0.04506814f, -0.06761926f, 
    -0.06140987f, 0.04071994f, -0.01522448f, 0.02838366f, 0.01947518f, -0.01597992f, -0.00763945f, 0.03840441f, 
    -0.01625667f, 0.04650403f, -0.05491373f, -0.06205469f, -0.06457091f, -0.05518135f, -0.04512577f, 0.01594251f, 
    -0.01667303f, -0.02521583f, -0.06018150f, -0.04023625f, -0.01349402f, -0.04512370f, -0.04141533f, 0.02383799f, 
    -0.05770306f, -0.00531044f, -0.05405342f, 0.04203729f, -0.03256315f, -0.02190942f, -0.06778601f, 0.04054135f, 
    -0.02255051f, 0.02489052f, 0.01033582f, 0.01219511f, 0.04730356f, 0.02289947f, 0.00814914f, -0.00414237f, 
    -0.01605164f, 0.02868122f, -0.01745886f, -0.02525178f, 0.03844489f, -0.06356581f, -0.07439443f, -0.05495949f, 
    -0.04950032f, -0.06352726f, -0.01545154f, 0.03568289f, -0.01776607f, -0.04598447f, 0.00097862f, 0.01308708f, 
    0.11694049f, 0.23282322f, -0.06935872f, 0.07142640f, -0.00536837f, 0.14960015f, 0.08074797f, 0.03247083f, 
    -0.03266991f, 0.07096983f, -0.01001487f, -0.29187354f, 0.12304223f, -0.02712354f, 0.05821058f, -0.00891090f, 
    0.03886095f, 0.04993331f, -0.01192268f, -0.27842247f, -0.00503746f, 0.03679411f, 0.11416496f, -0.10205876f, 
    0.07808039f, -0.15088353f, -0.00681768f, 0.13967985f, -0.07787956f, 0.06696897f, -0.02517383f, -0.01391575f, 
    -0.11539950f, 0.13134170f, 0.15883596f, -0.13935655f, 0.21114053f, -0.01684490f, -0.02506253f, 0.03856343f, 
    0.16853428f, 0.14354677f, 0.05186589f, -0.04584172f, -0.08182636f, -0.11422148f, 0.08863585f, 0.21634921f, 
    0.06720376f, 0.02029276f, -0.00058306f, -0.09588765f, -0.03563010f, -0.04827397f, -0.44698340f, -0.13096288f, 
    0.02007578f, -0.07301616f, 0.11107688f, -0.01211961f, 0.00618450f, -0.04936055f, -0.00546799f, 0.16190022f, 
    0.09977935f, -0.06800432f, 0.06891862f, -0.04253826f, 0.12006435f, 0.01147981f, 0.02411520f, -0.06506921f, 
    0.02829709f, -0.02612345f, 0.09825361f, -0.07198695f, -0.00042528f, 0.07028718f, 0.03021084f, 0.04429574f, 
    -0.09185855f, -0.29304951f, -0.15530206f, 0.02344768f, -0.04618856f, 0.01338566f, -0.03945895f, 0.08359527f, 
    0.00155873f, -0.03442292f, 0.10970227f, -0.15453307f, -0.38076207f, -0.01140111f, -0.02223284f, 0.09131276f, 
    -0.07399490f, -0.09228612f, 0.00286776f, 0.14504223f, 0.03331496f, -0.04476482f, 0.00858609f, 0.04290671f, 
    -0.16829441f, 0.04401235f, -0.02402181f, 0.01565797f, -0.21410450f, 0.18150517f, -0.15689474f, 0.02976251f, 
    -0.07744552f, 0.00663980f, 0.09646261f, 0.11532345f, -0.03278097f, -0.17397900f, 0.06681535f, 0.10178944f, 
    0.01424783f, -0.05196072f, -0.03513159f, 0.07263408f, -0.01611627f, 0.02499067f, 0.10105355f, -0.21850693f, 
    -0.08126157f, -0.09601230f, 0.08775526f, -0.03353982f, 0.05723997f, 0.02582587f, -0.07332900f, -0.07460074f, 
    -0.05007664f, 0.01742268f, 0.14019597f, 0.08206880f, 0.10870769f, 0.01621959f, -0.00343254f, -0.10371814f, 
    -0.24933670f, -0.16376169f, -0.14838184f, 0.01281344f, 0.15871048f, 0.09294477f, -0.00905175f, -0.02245024f, 
    -0.01826945f, 0.10012501f, -0.02948558f, 0.03660607f, 0.04777041f, -0.01567995f, -0.01778847f, -0.00687248f, 
    0.00868348f, -0.02750289f, 0.13535936f, -0.12300853f, -0.22357112f, 0.04230355f, -0.06243676f, 0.16352654f, 
    -0.01686949f, -0.01011094f, 0.03054273f, -0.21124116f, -0.06869189f, 0.05633447f, 0.04257276f, -0.17618610f, 
    -0.07423965f, 0.14568131f, -0.07082208f, -0.12617593f, 0.16002086f, 0.24007598f, -0.07022198f, -0.00100478f, 
    -0.08040889f, 0.00786280f, -0.01348894f, 0.06167185f, -0.03087393f, 0.12882933f, -0.09176548f, -0.10155348f, 
    0.02639540f, 0.05435741f, 0.07038126f, 0.10342806f, 0.01276715f, -0.26718524f, -0.30625612f, -0.14951222f, 
    0.06251135f, 0.02368570f, 0.09435471f, -0.02878808f, 0.00109218f, 0.15681906f, 0.07766677f, 0.02234605f, 
    0.10750642f, -0.22197853f, 0.10564937f, 0.04021709f, 0.10172988f, 0.18458679f, 0.03434166f, -0.02425306f, 
    -0.01099380f, 0.00994078f, -0.07743812f, 0.08187699f, 0.05748583f, 0.02805042f, -0.02020261f, -0.02697578f, 
    -0.05622735f, -0.01596841f, 0.01304123f, 0.10537067f, 0.01656423f, -0.07740361f, 0.00669053f, 0.09906514f, 
    -0.03285236f, 0.04518887f, -0.15610020f, -0.05724268f, 0.06901650f, 0.04906571f, 0.01570620f, 0.10695469f, 
    0.00601598f, 0.05246342f, 0.14223374f, 0.04359319f, 0.00115675f, 0.04303129f, 0.04812831f, -0.05406821f, 
    -0.07551877f, -0.00693619f, 0.17243831f, 0.12262875f, 0.26296321f, 0.44433367f, -0.04394179f, 0.07185768f, 
    -0.04695714f, -0.03176246f, 0.15273291f, -0.00362760f, -0.03838044f, 0.13917148f, 0.25999609f, 0.14623189f, 
    -0.03869787f, -0.11580853f, -0.00559558f, 0.12223205f, 0.14016671f, -0.02829650f, -0.31797087f, -0.11499613f, 
    -0.21269618f, 0.06510205f, 0.08316790f, 0.00420674f, 0.06531918f, 0.05855540f, 0.03898734f, -0.16459392f, 
    -0.01782348f, -0.07091191f, 0.02380879f, -0.10257127f, -0.04783864f, -0.03437266f, 0.09072891f, 0.14712247f, 
    0.08719223f, -0.07547338f, -0.01882414f, 0.19654146f, 0.09273010f, -0.03734117f, -0.02600867f, -0.09575352f, 
    0.03151364f, 0.05208406f, 0.14814337f, 0.15957102f, -0.15116282f, 0.12476216f, 0.13967325f, -0.04277208f, 
    -0.01325645f, 0.01328038f, 0.11122838f, 0.08499498f, 0.12087271f, 0.11935113f, -0.03494148f, -0.09893568f, 
    0.07488963f, -0.08996475f, -0.11747226f, -0.03697019f, -0.10156405f, 0.22220109f, -0.05198969f, 0.04490862f, 
    -0.06381059f, -0.03400576f, -0.17239128f, 0.00576154f, -0.12110344f, -0.16859680f, -0.10692592f, 0.06807987f, 
    0.03614946f, 0.03760036f, -0.05835542f, -0.11861557f, 0.09359464f, 0.04751447f, 0.18606417f, -0.06707150f, 
    0.16715308f, 0.13939179f, -0.05619285f, -0.00988985f, 0.05661530f, -0.01626516f, 0.13486972f, 0.09944031f, 
    -0.18030076f, -0.04550485f, 0.00246029f, 0.07916171f, 0.02394551f, 0.01394997f, 0.02801833f, -0.19406058f, 
    -0.14000331f, 0.08172295f, 0.08109898f, 0.09455952f, -0.03183291f, 0.08762009f, -0.14651403f, -0.00840933f, 
    0.14327537f, -0.22186960f, -0.41291025f, 0.01170003f, -0.17836758f, 0.11324388f, 0.01736522f, -0.05580597f, 
    -0.05037974f, 0.11804879f, 0.15140659f, 0.13064484f, -0.06266119f, 0.04539412f, -0.06266382f, 0.13006093f, 
    -0.07143237f, 0.15461640f, 0.21187909f, 0.03356150f, 0.24020801f, -0.11994648f, 0.03418118f, -0.02432198f, 
    -0.14368972f, -0.04286039f, -0.03043099f, -0.00204920f, 0.02735515f, 0.05968812f, -0.06377026f, 0.09377924f, 
    -0.15413353f, -0.03639827f, -0.06362145f, 0.07141133f, 0.06038592f, 0.10284020f, -0.02274195f, 0.11320261f, 
    -0.02335404f, 0.12549074f, 0.02146322f, 0.04290000f, 0.03044030f, 0.13242303f, -0.24984278f, -0.12091646f, 
    -0.03754383f, 0.05553058f, 0.02833151f, 0.03440110f, -0.05447469f, 0.09088514f, -0.05476375f, 0.04861293f, 
    0.04653770f, 0.10466966f, 0.03672094f, -0.02130091f, -0.07675056f, -0.10011222f, -0.09567264f, 0.00833136f, 
    0.06662961f, -0.05278289f, -0.10946739f, 0.02260768f, 0.10572922f, -0.02722967f, 0.01544213f, 0.02595259f, 
    -0.10695934f, -0.13948631f, -0.24322155f, -0.06190696f, 0.02119919f, -0.09577397f, -0.02551377f, -0.15776245f, 
    0.19142598f, 0.23018971f, 0.09942732f, -0.09368601f, 0.01735450f, 0.07149048f, -0.10505181f, 0.07115959f, 
    -0.04609008f, 0.13487515f, -0.11755660f, 0.07633580f, -0.16017215f, -0.02310321f, 0.00316197f, -0.02551727f, 
    -0.07205746f, 0.01157457f, 0.04430717f, 0.05138263f, 0.29574457f, -0.01639166f, 0.10037369f, -0.04926579f, 
    -0.00354550f, 0.05578726f, -0.13271686f, -0.02800084f, -0.16944763f, -0.34862301f, 0.22357795f, 0.19597727f, 
    0.07358433f, -0.00159587f, 0.07832819f, -0.11195632f, -0.10401274f, 0.16770451f, -0.01071065f, 0.01823323f, 
    0.02207346f, 0.00677617f, 0.09493406f, -0.07666697f, -0.05522523f, 0.19969060f, 0.04840935f, 0.07351886f, 
    -0.11902764f, 0.03630591f, -0.12154458f, 0.04664558f, 0.04468901f, -0.11981749f, -0.06476837f, -0.00707994f, 
    0.08215273f, 0.19865598f, -0.14053909f, 0.00063736f, -0.04815817f, -0.14246939f, -0.03882637f, -0.05646557f, 
    -0.02059758f, 0.20248882f, 0.05441324f, -0.01908750f, 0.03888541f, 0.06901274f, -0.05592680f, -0.06048663f, 
    -0.07518140f, 0.02972841f, 0.32057887f, 0.14333870f, 0.14952673f, 0.01151351f, 0.09866809f, 0.02253268f, 
    0.02910765f, 0.07428245f, 0.05902053f, 0.02689896f, -0.09198588f, -0.02810085f, 0.21434386f, 0.11532979f, 
    0.03968433f, -0.08960294f, 0.05211427f, 0.17122602f, 0.12605226f, 0.04698339f, 0.12053102f, 0.12521753f, 
    0.10728891f, 0.01993276f, -0.07520554f, 0.02771042f, -0.22339246f, -0.12017028f, 0.06642206f, 0.23302136f, 
    0.04012490f, 0.05489191f, -0.04669286f, 0.07807897f, -0.14499919f, -0.02553301f, -0.05462886f, 0.01265537f, 
    0.15073095f, 0.14663991f, 0.05623451f, 0.03498001f, -0.24819331f, 0.00221367f, 0.11101718f, -0.12621480f, 
    0.03402181f, 0.16764081f, -0.16343124f, 0.10464901f, 0.07682582f, -0.07034419f, -0.02576922f, 0.15353845f, 
    0.15074727f, -0.03475539f, 0.10839418f, 0.14928527f, 0.08838384f, 0.12469633f, -0.12063684f, -0.04271129f, 
    0.08594751f, -0.05922199f, -0.04517887f, -0.07458547f, 0.07311326f, -0.03015223f, 0.11295357f, -0.06795549f, 
    0.01255994f, -0.05195706f, -0.10943841f, -0.06688457f, -0.01336323f, 0.05584465f, 0.03390769f, -0.04973978f, 
    0.12641092f, -0.00669848f, 0.17598692f, 0.01881865f, 0.07650416f, 0.15945427f, -0.03391570f, -0.04945546f, 
    0.05479053f, 0.07243732f, -0.08926113f, -0.09289092f, 0.06351566f, -0.00732534f, 0.03801824f, 0.03050030f, 
    -0.07873057f, -0.03907542f, 0.08277544f, 0.07109805f, -0.14509585f, -0.05364395f, 0.18497348f, -0.14995326f, 
    0.03868476f, 0.12383205f, -0.10056654f, 0.07815407f, 0.06311194f, -0.19490868f, 0.06497184f, -0.08669850f, 
    -0.12953000f, -0.13471192f, -0.17134532f, 0.07632252f, 0.18703067f, -0.01583681f, 0.24610341f, -0.07304479f, 
    0.08746228f, -0.06418040f, -0.09133924f, 0.04135710f, 0.00588340f, -0.02415020f, 0.04735221f, -0.14272860f, 
    0.06375961f, -0.00813314f, -0.03139783f, -0.11593232f, -0.07410680f, -0.03471134f, 0.06928533f, 0.08537509f, 
    -0.16938604f, -0.38703370f, -0.13456222f, 0.08993761f, 0.02116478f, -0.12848249f, -0.07333121f, -0.02736477f, 
    -0.13875572f, 0.22794141f, 0.03475301f, 0.19673026f, -0.08766615f, -0.11395241f, 0.00131736f, -0.01011032f, 
    0.04635763f, -0.07445353f, -0.03895442f, 0.14988863f, 0.02179272f, -0.06035916f, -0.13598883f, -0.08111236f, 
    -0.03422587f, 0.16370745f, -0.07236765f, -0.26183236f, 0.01509274f, -0.08714218f, 0.10250989f, 0.09148169f, 
    0.03308186f, -0.05496792f, -0.09376780f, -0.05301339f, -0.10054904f, 0.00725507f, -0.08993246f, -0.06055672f, 
    -0.06035697f, 0.10169381f, -0.04461134f, 0.05617311f, -0.07246395f, -0.01604054f, -0.13830958f, -0.09912208f, 
    -0.01825668f, 0.05092135f, 0.17017029f, 0.08608364f, 0.01515429f, 0.02380424f, -0.08166690f, 0.22601721f, 
    0.01944267f, 0.09395601f, -0.08165177f, -0.02245034f, -0.19512424f, 0.17231181f, 0.02904407f, -0.11555927f, 
    0.03736964f, -0.06281061f, 0.00972192f, -0.03984924f, -0.10189219f, 0.10013545f, -0.14863975f, -0.04243385f, 
    0.15367246f, 0.00735453f, -0.10029680f, -0.03766027f, -0.13716619f, 0.00558661f, 0.02480274f, 0.08896586f, 
    -0.01472436f, 0.33439615f, 0.08424320f, -0.00100206f, -0.01207595f, 0.06031922f, -0.01679741f, 0.07499575f, 
    0.01738081f, -0.04598293f, 0.00002731f, -0.10202894f, -0.04804821f, -0.04051435f, 0.01069120f, 0.01501768f, 
    0.05225204f, 0.05267631f, -0.09099121f, 0.38079858f, 0.03933368f, -0.09695733f, 0.00078115f, -0.06463826f, 
    0.00033692f, 0.06346703f, 0.15091318f, 0.00707022f, 0.06437206f, 0.00848716f, 0.13223982f, 0.09206159f, 
    0.12957014f, 0.00758483f, 0.00594938f, -0.09515475f, -0.06320923f, 0.03566674f, -0.22831979f, 0.06771327f, 
    -0.01017397f, -0.00748062f, 0.06457964f, 0.03900219f, 0.05590783f, -0.02241625f, 0.08724623f, 0.05026165f, 
    -0.15395342f, -0.03174460f, -0.21725266f, 0.00277628f, -0.05689729f, 0.15748695f, -0.06074629f, 0.02946054f, 
    0.08636468f, -0.16551200f, -0.08016499f, 0.03804552f, 0.01175706f, 0.03594136f, 0.08241305f, -0.08229312f, 
    -0.28545913f, -0.07676095f, 0.02405058f, 0.03758535f, 0.01325821f, -0.00420831f, 0.05933952f, 0.00054268f, 
    -0.02430556f, 0.17192377f, -0.10949892f, 0.00117691f, 0.09924599f, 0.05986091f, 0.02203037f, 0.11345682f, 
    0.04642119f, 0.05645367f, -0.07276104f, -0.17434061f, 0.11556855f, -0.02309109f, -0.05960732f, -0.02641810f, 
    0.11226621f, -0.07979371f, 0.00794369f, -0.09487543f, -0.21474865f, -0.00646834f, 0.06656335f, 0.10918816f, 
    0.01657387f, 0.07373757f, 0.04727537f, 0.19205672f, 0.07730844f, -0.00231371f, -0.00139972f, -0.04469762f, 
    0.19982749f, 0.08383232f, 0.00451522f, 0.05563769f, -0.05715391f, -0.42319909f, -0.01517552f, -0.11597957f, 
    0.05011334f, 0.15036631f, 0.17276229f, -0.02108687f, -0.02139648f, -0.07336337f, -0.22760743f, 0.02844330f, 
    -0.09741063f, 0.07817718f, -0.07446257f, 0.07142160f, 0.07838584f, 0.02687257f, 0.00032757f, -0.18408449f, 
    0.21716307f, -0.00092818f, -0.09282138f, 0.02021246f, 0.02219960f, -0.01678728f, 0.04356676f, 0.06104944f, 
    0.12107638f, 0.17443831f, 0.11217964f, 0.15891534f, -0.09176996f, 0.07614640f, -0.14337076f, -0.02024140f, 
    -0.03041125f, -0.33489159f, 0.01400742f, -0.01462632f, 0.04597561f, -0.04961301f, 0.07024307f, -0.08203591f, 
    -0.20622186f, -0.03458032f, 0.24422559f, 0.08654169f, -0.08631769f, -0.02165742f, 0.03699766f, 0.05728359f, 
    -0.01422804f, -0.02007844f, -0.05254326f, 0.16763386f, 0.08487391f, -0.03255553f, 0.05809728f, -0.00322757f, 
    -0.02610688f, 0.01503215f, -0.05201375f, -0.03522794f, 0.15029396f, 0.11194309f, 0.14721566f, 0.09279788f, 
    0.02361755f, 0.12409910f, 0.00213897f, -0.02485474f, 0.04036918f, 0.11669374f, 0.14297640f, 0.09520618f, 
    0.00137764f, -0.05081566f, -0.02127673f, 0.11470328f, -0.05251160f, -0.06174023f, -0.00748981f, -0.05279562f, 
    -0.04233122f, 0.04360021f, -0.03866454f, -0.01168102f, 0.09783322f, 0.04110947f, -0.02643768f, 0.04559043f, 
    0.02068846f, 0.09927973f, 0.14916879f, -0.05844300f, -0.08608537f, 0.07348542f, 0.07568561f, -0.00715511f, 
    0.16299041f, -0.05790678f, -0.09479513f, -0.12598990f, -0.04481728f, -0.06133257f, 0.07409555f, 0.02226554f, 
    0.01142354f, -0.18460320f, 0.09098147f, 0.14865971f, -0.08576783f, -0.07564200f, 0.03711696f, -0.13397163f, 
    0.04854408f, -0.06337092f, 0.06411178f, 0.08411276f, 0.00664715f, -0.07993671f, 0.16720013f, 0.08404119f, 
    0.02887783f, 0.09158976f, -0.04000521f, -0.06280069f, -0.10759210f, -0.00923322f, -0.03765398f, 0.03469288f, 
    -0.04273382f, -0.20666961f, -0.05725678f, 0.04539707f, -0.03795868f, -0.03261815f, -0.10370536f, -0.04036184f, 
    0.08598321f, -0.17584534f, 0.02597793f, -0.06279065f, 0.08359739f, -0.30216372f, 0.04351213f, 0.07190829f, 
    0.04938328f, 0.02148673f, 0.02520614f, 0.06318776f, -0.04235765f, 0.12059859f, 0.13941537f, 0.17867240f, 
    0.10560134f, 0.11001939f, -0.11033337f, -0.01974866f, -0.08322560f, 0.08274505f, -0.02310522f, -0.00809925f, 
    -0.02141456f, 0.03311889f, -0.12283367f, -0.06555405f, 0.04393268f, -0.00322107f, 0.01087039f, 0.03512016f, 
    0.20624821f, 0.04208490f, 0.13746609f, 0.00867006f, 0.00200403f, -0.04543776f, -0.01441369f, 0.10591708f, 
    0.11983203f, -0.10926946f, -0.17724904f, 0.00899114f, -0.07158113f, -0.09361427f, 0.06737880f, -0.22476350f, 
    -0.16489679f, -0.12499349f, 0.11072897f, 0.01631752f, 0.03473488f, -0.03537780f, -0.02768511f, -0.15958185f, 
    0.10984591f, -0.01122472f, 0.05990395f, -0.06325730f, -0.12984574f, -0.03125775f, -0.20499358f, -0.03406941f, 
    -0.06136680f, -0.00591414f, -0.04584165f, 0.10086954f, -0.05355957f, 0.00982939f, 0.05147417f, 0.02477718f, 
    -0.05068838f, -0.17455649f, 0.02220675f, 0.19377302f, -0.01994546f, 0.22609667f, 0.14095028f, -0.12661809f, 
    0.02168588f, -0.06054417f, 0.06373879f, 0.16207983f, -0.05246563f, -0.12875819f, 0.29437104f, 0.10663138f, 
    0.06104483f, -0.06661871f, 0.00239729f, -0.09147083f, 0.10421766f, -0.03878797f, -0.08591984f, -0.07678498f, 
    -0.07708611f, -0.02883568f, 0.06793994f, -0.05258553f, -0.01388305f, -0.13216811f, -0.15685602f, -0.07454639f, 
    0.16178125f, -0.09809150f, -0.07233872f, -0.11705636f, -0.13775246f, 0.00205171f, -0.07255021f, 0.09265615f, 
    0.16987622f, -0.14870436f, -0.26773331f, -0.20757832f, -0.14287709f, -0.07837678f, -0.00497195f, -0.00812389f, 
    0.01885055f, -0.12241468f, 0.20274280f, -0.14970286f, 0.05937851f, -0.04553264f, 0.04814898f, 0.02950010f, 
    -0.01716031f, -0.16095667f, 0.06623456f, -0.17522293f, -0.00971718f, -0.06506602f, -0.05627142f, -0.08237605f, 
    -0.03213366f, 0.08973540f, 0.02140799f, 0.06480549f, 0.15496373f, 0.19133948f, 0.22218001f, -0.05048576f, 
    0.08627899f, -0.02117337f, 0.04924900f, 0.11349351f, 0.05196146f, -0.34149319f, -0.06922302f, 0.02361111f, 
    -0.00337999f, -0.11305092f, -0.19073279f, 0.03844056f, 0.09809515f, 0.00731585f, -0.03868371f, -0.03989418f, 
    0.01346779f, -0.03679395f, 0.04309281f, -0.16749649f, -0.05973776f, -0.01760140f, 0.02375239f, 0.00374063f, 
    0.08136513f, 0.06763750f, 0.04542030f, -0.10849965f, 0.12140778f, 0.10090589f, -0.08895680f, -0.05660743f, 
    -0.40638307f, -0.05233599f, -0.09413031f, 0.08424671f, 0.05402477f, -0.10550230f, 0.05396818f, 0.08788067f, 
    0.03501219f, 0.25361827f, -0.13076560f, 0.00404460f, -0.11649401f, -0.04937798f, -0.02484502f, 0.07174373f, 
    -0.15081069f, 0.06940477f, -0.02226225f, -0.02529118f, 0.27698037f, 0.02153956f, -0.02226369f, 0.12773666f, 
    -0.25984904f, -0.07868353f, -0.00521818f, 0.23352246f, 0.24101703f, -0.05032071f, 0.00026754f, -0.00608644f, 
    -0.03041195f, -0.08562548f, 0.13875629f, -0.02155354f, 0.02558766f, -0.16234446f, -0.12574683f, -0.00283927f, 
    0.01139784f, 0.04440651f, -0.08168386f, 0.03080845f, -0.07284836f, -0.36381605f, 0.06767543f, -0.24703336f, 
    0.03377281f, 0.04048552f, 0.02123708f, 0.11023001f, 0.04142178f, -0.19214870f, 0.09149465f, 0.21041170f, 
    -0.10149173f, -0.08682640f, -0.03844193f, -0.01494017f, -0.01926224f, 0.04130663f, -0.12339136f, -0.08370546f, 
    -0.20001450f, -0.31563008f, 0.03693806f, 0.05439896f, 0.14114113f, -0.02408280f, 0.02717409f, -0.14692888f, 
    0.16076452f, 0.09293490f, -0.04959868f, -0.11925070f, -0.08131256f, 0.05261415f, 0.06194782f, 0.08923365f, 
    -0.03267529f, 0.10325142f, 0.25372934f, -0.04763865f, -0.11997601f, -0.11525745f, 0.09574682f, -0.13257991f, 
    -0.08434662f, 0.04086642f, -0.14986145f, -0.09847920f, 0.25620171f, 0.07300475f, -0.16628884f, 0.08258575f, 
    -0.15611729f, -0.01111973f, 0.09927609f, -0.24450791f, -0.01064170f, 0.06158463f, -0.04548154f, -0.01604174f, 
    -0.06823604f, -0.06040017f, 0.01198759f, -0.01369547f, 0.13261366f, -0.05161885f, 0.12359639f, -0.07997776f, 
    0.09146288f, -0.01375095f, 0.17195033f, 0.05147838f, 0.06171456f, -0.03159071f, -0.05144920f, 0.05682784f, 
    0.01848508f, -0.05439664f, 0.00101229f, 0.04333620f, 0.11569287f, 0.04942889f, 0.01451878f, -0.00659238f, 
    -0.22531167f, 0.18751034f, -0.01761629f, -0.00213455f, 0.05653513f, 0.11621799f, -0.07191217f, -0.31380597f, 
    -0.15561529f, 0.05705645f, 0.12437634f, 0.03703221f, -0.13826768f, -0.00759092f, -0.03787543f, -0.00298232f, 
    -0.26704368f, -0.11153766f, 0.18357287f, 0.08641621f, 0.13901599f, -0.03488530f, -0.04787211f, 0.08821635f, 
    -0.04478470f, 0.08115847f, 0.06124426f, 0.01889327f, -0.05180288f, -0.09406342f, 0.15072761f, -0.08168987f, 
    0.18971525f, 0.07103468f, -0.28827742f, -0.02435053f, -0.06379753f, 0.00408251f, 0.04864815f, 0.01744007f, 
    0.16564091f, 0.07060309f, 0.05163356f, 0.10804134f, 0.19657022f, 0.10541739f, -0.04400627f, -0.06404682f, 
    0.07371807f, -0.09297326f, 0.00690654f, 0.00248710f, 0.21781242f, -0.09750536f, -0.07635023f, 0.08757580f, 
    0.04864831f, -0.05649285f, 0.05064533f, -0.06450661f, 0.00017147f, -0.05468190f, 0.00497584f, -0.13353850f, 
    0.00660144f, 0.00534573f, -0.09004106f, 0.14618725f, 0.15457904f, -0.02538362f, -0.14762051f, -0.01719738f, 
    -0.04379532f, 0.00225638f, 0.06293005f, -0.02083302f, -0.05247562f, -0.08192027f, -0.07370546f, -0.09815206f, 
    -0.19816244f, 0.00895318f, -0.12703100f, -0.03656738f, -0.03344013f, -0.03215299f, 0.10071131f, 0.03029250f, 
    -0.00940051f, 0.14305489f, 0.18857418f, 0.14249919f, -0.02489820f, -0.01704288f, 0.04448426f, -0.14233588f, 
    0.07370628f, 0.10716727f, 0.16163245f, 0.17012355f, -0.03904681f, -0.07214569f, 0.08785874f, -0.07078494f, 
    0.11604506f, 0.07465212f, -0.08061729f, -0.05197648f, 0.01817986f, 0.02532151f, -0.04310420f, 0.03775936f, 
    0.06925593f, 0.17368665f, 0.11306936f, 0.08391644f, 0.13401252f, 0.25110614f, -0.03069903f, 0.05494057f, 
    0.09502020f, 0.10808024f, -0.00055111f, 0.05022684f, -0.36085504f, -0.13862054f, -0.26917353f, 0.05412361f, 
    0.06150550f, 0.13063106f, 0.14513955f, 0.10146020f, -0.07425680f, 0.17681374f, 0.07387773f, 0.06992073f, 
    -0.20740712f, 0.12400227f, 0.00390472f, 0.15843290f, 0.02330826f, 0.09850319f, 0.25912979f, -0.20950496f, 
    0.10175049f, -0.15456979f, 0.11317779f, -0.10145235f, -0.15131211f, 0.03188946f, 0.03946966f, -0.11627998f, 
    -0.03520449f, -0.20545328f, -0.04282940f, -0.10674561f, 0.05639857f, 0.07860410f, 0.06188763f, 0.04293960f, 
    -0.03925786f, -0.00236142f, -0.05305398f, 0.00539574f, 0.03595183f, -0.05783112f, 0.04191359f, 0.03507045f, 
    -0.00249644f, 0.02760817f, 0.05340628f, 0.01680754f, 0.03418488f, 0.03210213f, -0.00084082f, -0.04801929f, 
    -0.04846155f, 0.04339952f, -0.05624896f, 0.00493838f, -0.00383556f, 0.01900722f, -0.05239343f, -0.03924438f, 
    -0.04221832f, 0.02868940f, 0.00588188f, 0.01165540f, -0.01415608f, -0.03213469f, -0.03955329f, -0.04913748f, 
    -0.04583789f, 0.03305250f, -0.05318645f, -0.05233000f, 0.00823861f, -0.03355023f, -0.03628129f, -0.04905292f, 
    -0.05492354f, -0.02953595f, -0.05002606f, 0.01910032f, 0.04889771f, -0.03772792f, -0.02842592f, 0.01422564f, 
    0.04249771f, -0.01363494f, 0.02565776f, -0.05628276f, -0.05628334f, 0.00399962f, 0.00962512f, -0.05397369f, 
    -0.03548907f, -0.06070303f, 0.03406905f, -0.00283084f, 0.03445644f, -0.02077362f, -0.00616107f, -0.00227558f, 
    -0.01564647f, -0.00384838f, -0.00381581f, -0.05874918f, -0.00888735f, 0.02808276f, 0.02131587f, 0.00670713f, 
    0.01543389f, 0.00128701f, 0.01771196f, 0.03054777f, -0.02595066f, -0.05110371f, -0.03693474f, -0.04841511f, 
    0.03669436f, -0.05180835f, -0.00491377f, -0.06051094f, -0.04463942f, 0.00226729f, -0.04410352f, 0.03737919f, 
    -0.05207393f, -0.00368676f, -0.04170175f, -0.05375629f, -0.06243746f, -0.03170887f, 0.02327128f, -0.00751190f, 
    -0.05769106f, 0.05080650f, 0.02265425f, 0.04884694f, 0.01316785f, 0.00651688f, 0.00501102f, 0.04545813f, 
    0.01787713f, -0.03250919f, 0.04960215f, -0.00574929f, 0.03520859f, -0.05711114f, 0.04128695f, -0.04767732f, 
    0.04797746f, 0.04380859f, -0.01264042f, -0.00763815f, 0.03180351f, -0.06389139f, 0.00326518f, 0.01679262f, 
    -0.02139521f, -0.02716364f, -0.03624587f, -0.04549607f, -0.05100563f, 0.02031737f, -0.01999954f, 0.02355259f, 
    -0.01340847f, -0.05753678f, -0.04243496f, 0.03512949f, -0.02220446f, -0.02960245f, -0.04397196f, -0.00765278f, 
    -0.01351828f, -0.03597924f, -0.06420127f, -0.02414045f, -0.00596656f, 0.05701059f, 0.04799768f, -0.05318889f, 
    -0.05739059f, 0.02480243f, -0.02778943f, -0.01762137f, 0.02024961f, 0.00993344f, 0.04802066f, -0.00161467f, 
    -0.01787219f, 0.01847489f, -0.03531305f, -0.01800470f, -0.04075782f, -0.00617712f, 0.04462489f, 0.00188408f, 
    -0.03726083f, -0.06381640f, -0.04604023f, 0.00882250f, 0.02643775f, -0.05457357f, 0.03360780f, 0.01413242f, 
    -0.02082275f, 0.01681113f, 0.03128276f, 0.03052187f, -0.04039672f, -0.05053253f, 0.02023139f, 0.01306830f, 
    -0.05368262f, -0.01204784f, 0.03146114f, 0.00687871f, 0.04338153f, -0.03004037f, -0.04397846f, 0.01972768f, 
    -0.02767247f, -0.04212413f, -0.03110102f, 0.04034521f, 0.05240374f, 0.00189375f, 0.03371254f, 0.04582666f, 
    0.01284391f, 0.02650800f, -0.01063197f, 0.03850832f, -0.02296254f, -0.05460061f, 0.04291471f, -0.02904398f, 
    -0.02204364f, -0.01143671f, 0.04309880f, -0.05026104f, 0.04346845f, 0.01522407f, -0.05066982f, -0.01608186f, 
    -0.03622289f, 0.03036270f, 0.05029776f, -0.06140027f, -0.00234215f, 0.04438036f, 0.00037657f, 0.00736038f, 
    0.01521124f, -0.02205455f, 0.02667614f, -0.02410877f, -0.06292676f, -0.00905547f, -0.04105979f, -0.03741556f, 
    0.00982012f, -0.04092805f, 0.03408986f, -0.05673534f, -0.05601550f, -0.02247345f, -0.05438733f, -0.02098296f, 
    -0.02005959f, -0.04220956f, 0.04679978f, 0.05231499f, 0.02193946f, 0.01464202f, -0.02865876f, -0.02460245f, 
    -0.03707053f, 0.03630455f, -0.06133565f, -0.03953936f, -0.06272551f, 0.00557343f, 0.00181922f, 0.01355713f, 
    0.04643627f, 0.02560428f, -0.01957558f, 0.04936619f, 0.01864266f, 0.00249472f, 0.00803435f, -0.05245996f, 
    0.01408314f, 0.04094735f, 0.02031536f, 0.00340495f, -0.04063754f, 0.04094924f, -0.04852479f, -0.06119586f, 
    -0.05634879f, 0.02615765f, -0.05296144f, -0.01191807f, -0.00626216f, -0.00378977f, -0.01748473f, -0.05495922f, 
    -0.01014274f, 0.03910641f, 0.02016609f, -0.03713513f, 0.00569425f, -0.01744384f, -0.04573894f, 0.00718992f, 
    -0.00108703f, -0.05006889f, 0.01065960f, -0.04844773f, -0.04187256f, -0.02398491f, 0.01070956f, -0.05964372f, 
    -0.02738197f, -0.04966645f, 0.04545736f, 0.03685549f, -0.06006121f, -0.00780689f, 0.04125680f, 0.03156031f, 
    -0.00938968f, 0.03445749f, -0.04322019f, 0.03097822f, -0.01044136f, -0.02433900f, -0.01751358f, 0.02712768f, 
    -0.05634160f, -0.01433446f, -0.00192038f, 0.01847589f, 0.01911811f, -0.01316393f, -0.06039156f, -0.00017692f, 
    0.04911572f, -0.05267733f, 0.00270507f, 0.02647540f, 0.03394267f, -0.06346514f, 0.01876269f, -0.03715228f, 
    -0.03845083f, -0.01786888f, -0.04398878f, 0.04265415f, -0.00371873f, -0.03163438f, -0.06100141f, -0.03757980f, 
    0.00485290f, -0.03011905f, 0.02470731f, 0.04658610f, 0.03819715f, -0.00218494f, -0.02775123f, 0.05801377f, 
    0.02193108f, 0.04516724f, -0.00151767f, 0.04477227f, 0.02502964f, -0.01078201f, 0.04508439f, 0.01819405f, 
    -0.04793787f, -0.04776976f, -0.03143446f, -0.04772931f, 0.05320920f, 0.04163947f, 0.01348646f, -0.04480792f, 
    0.00929026f, -0.01583035f, -0.03704549f, -0.03126133f, -0.02008527f, 0.05260523f, -0.05175504f, 0.04140583f, 
    0.01979789f, -0.02800435f, 0.00472982f, 0.04853251f, 0.01745618f, -0.05023314f, -0.02941060f, 0.02252729f, 
    -0.01757968f, -0.03201679f, -0.03012512f, 0.01070813f, -0.06061848f, 0.00344397f, -0.02458282f, -0.04225579f, 
    0.00757977f, -0.04550771f, 0.04756437f, 0.04994650f, -0.04431323f, -0.06203259f, -0.04914537f, -0.04197756f, 
    -0.05558181f, -0.01768924f, 0.03410556f, -0.01746576f, -0.04548876f, -0.04248182f, 0.01082914f, 0.03852281f, 
    0.02852353f, 0.02808150f, -0.02896079f, 0.01230676f, 0.01279352f, -0.03436712f, 0.01955632f, -0.06216225f, 
    -0.04330978f, -0.01679533f, -0.04607996f, 0.03148797f, -0.00644445f, 0.03971832f, -0.04035771f, 0.01115381f, 
    -0.05350430f, -0.01264793f, 0.00210947f, -0.01090758f, -0.00324766f, -0.02926524f, -0.01978213f, -0.00764085f, 
    0.00958241f, -0.02942350f, 0.05106767f, -0.01328943f, 0.00496518f, 0.00440183f, 0.01327068f, 0.01896853f, 
    -0.01434174f, -0.00839393f, 0.04478434f, -0.06123926f, 0.00720319f, -0.05079919f, -0.02537547f, 0.04745403f, 
    -0.00841169f, -0.04584404f, -0.03347977f, 0.00797149f, -0.00528139f, 0.04487101f, 0.02623128f, -0.01397382f, 
    -0.00763177f, -0.01053423f, -0.05676430f, -0.05323885f, 0.04059216f, -0.02307682f, 0.01184377f, -0.02320416f, 
    -0.04529662f, -0.06285282f, -0.00383954f, 0.03400393f, 0.04347713f, 0.03470534f, 0.01411844f, 0.01905876f, 
    0.04921490f, -0.02474280f, -0.03852020f, -0.04402332f, -0.05627725f, -0.01454911f, 0.01439466f, -0.05882872f, 
    -0.05071924f, -0.04945829f, -0.00648262f, 0.01690061f, -0.05343838f, 0.03737219f, 0.04008353f, -0.03852305f, 
    -0.04998940f, -0.02374369f, -0.01105308f, 0.00777422f, -0.04042133f, 0.01346212f, 0.00045776f, -0.04447342f, 
    -0.06258978f, -0.01085441f, 0.03307178f, -0.00497683f, -0.04389829f, -0.02424376f, -0.03613374f, 0.04185119f, 
    0.00576270f, -0.03935217f, -0.02629621f, -0.06257771f, -0.05228658f, -0.02128152f, -0.05626775f, -0.01990271f, 
    0.02757214f, -0.00802600f, 0.02972441f, 0.03431740f, -0.02180819f, -0.00775611f, -0.03126903f, 0.01021319f, 
    -0.04588422f, -0.00036246f, 0.04690432f, 0.02457459f, -0.03436542f, -0.04099216f, -0.02287979f, -0.01770956f, 
    0.02334445f, -0.03016006f, -0.01920073f, -0.01208893f, -0.04818662f, -0.01979023f, 0.03087037f, -0.05462064f, 
    0.00009840f, 0.04457195f, -0.00820480f, -0.04503161f, 0.00263700f, -0.03786400f, 0.01141057f, -0.05361619f, 
    -0.01640147f, 0.03014000f, 0.04513642f, -0.02098581f, -0.00615401f, 0.05335153f, -0.03448745f, 0.03702934f, 
    0.01955161f, -0.02625551f, 0.04699495f, -0.05584909f, -0.05871183f, -0.05041447f, 0.02056006f, -0.04250622f, 
    -0.03963135f, -0.05803742f, 0.02071265f, -0.03345395f, -0.03781638f, -0.05785254f, -0.02322846f, -0.02885359f, 
    -0.01940370f, 0.01393409f, 0.02413025f, 0.00689725f, 0.00039951f, -0.01346685f, -0.02239811f, -0.03377151f, 
    -0.01888585f, -0.02049363f, 0.03752775f, -0.01804551f, 0.04453370f, -0.04138140f, -0.04314139f, -0.05897839f, 
    0.02436528f, 0.04849795f, 0.01445787f, -0.00566040f, 0.00764555f, -0.04602444f, 0.04190931f, -0.00832391f, 
    0.05453898f, -0.06023898f, 0.22005983f, 0.02744046f, -0.22020885f, 0.03212165f, -0.15898459f, -0.00710479f, 
    -0.04060653f, 0.22587158f, 0.05357479f, -0.39062473f, -0.03591913f, 0.07177407f, 0.10145643f, -0.10866362f, 
    -0.17988713f, -0.13164677f, 0.02566148f, -0.13873024f, -0.05637413f, -0.08229921f, -0.00502028f, 0.02608961f, 
    -0.06234675f, -0.07838834f, -0.06140465f, -0.01060985f, -0.02360480f, 0.16686714f, 0.00801538f, 0.01534122f, 
    -0.05144823f, -0.12745754f, 0.02169312f, 0.13227572f, -0.18765126f, -0.09633587f, 0.04615409f, -0.09257093f, 
    -0.00421172f, 0.11926779f, 0.02517854f, -0.04245812f, 0.11675467f, 0.21988891f, -0.16062053f, 0.22371730f, 
    -0.15576266f, -0.03509371f, 0.06751464f, 0.08358896f, 0.02297681f, -0.07026516f, 0.09657031f, -0.04049124f, 
    0.09906209f, -0.10456432f, -0.12206805f, 0.02889759f, -0.07514809f, -0.11625823f, -0.16268374f, 0.35656112f, 
    0.01054004f, 0.22686996f, -0.14598536f, -0.13028748f, 0.01037234f, 0.00574069f, -0.02640529f, 0.00052995f, 
    -0.19929668f, -0.03093369f, -0.22001429f, 0.08849081f, -0.02679276f, -0.26569903f, 0.19675009f, -0.08957987f, 
    0.01567485f, 0.20304330f, 0.22024073f, 0.15866247f, -0.08990746f, 0.04825853f, -0.02350463f, -0.14042276f, 
    -0.23958664f, -0.02049032f, -0.16107155f, -0.10640444f, 0.01798180f, -0.02779820f, 0.04467870f, -0.05255092f, 
    -0.08985897f, 0.09056582f, 0.09240152f, 0.35795280f, -0.05457844f, -0.29612693f, -0.12528345f, 0.17393719f, 
    0.04197962f, 0.05671984f, -0.09087662f, 0.10650924f, -0.03194283f, 0.07203916f, -0.12615365f, -0.10547665f, 
    -0.03443195f, 0.00474374f, -0.08644168f, -0.09027433f, 0.09763983f, 0.07725465f, 0.02608424f, -0.01269070f, 
    0.03465712f, 0.06543712f, 0.01069003f, -0.03185412f, 0.10559484f, -0.12013181f, 0.02088853f, 0.06606402f, 
    0.22771464f, 0.00834963f, 0.12243766f, -0.08480842f, 0.05862865f, -0.02961222f, 0.04482140f, 0.09268250f, 
    0.04609158f, -0.22248317f, -0.08429832f, -0.02907074f, -0.21393612f, -0.13918009f, -0.08877391f, 0.06985527f, 
    0.40652335f, 0.05797701f, -0.31274122f, 0.05213788f, -0.05048440f, -0.13116618f, -0.03910168f, -0.02598039f, 
    -0.02727823f, -0.06577050f, 0.05746566f, 0.12657885f, 0.04573904f, -0.03264804f, 0.09428907f, -0.12247683f, 
    0.04968937f, 0.09097821f, 0.04983668f, -0.16369574f, 0.06153437f, -0.14543998f, -0.14529851f, -0.04647709f, 
    -0.06390442f, -0.16946098f, 0.09431648f, -0.13467352f, 0.13324524f, 0.17108680f, 0.06230996f, 0.08080927f, 
    0.14166588f, -0.11806779f, 0.13722689f, -0.04195656f, 0.18998446f, 0.13223144f, 0.15195763f, -0.13592474f, 
    -0.00545730f, -0.11196256f, 0.05853976f, 0.07735845f, 0.07443918f, -0.05883856f, -0.00293343f, 0.13588504f, 
    -0.01765073f, 0.01051089f, -0.09182056f, -0.24765196f, -0.02603489f, -0.01009888f, 0.16146196f, -0.17614706f, 
    0.02562987f, -0.03907494f, -0.00184488f, -0.04692631f, -0.00676137f, 0.01869373f, -0.15806770f, 0.01842089f, 
    -0.07380670f, -0.21059026f, -0.15463905f, 0.09252969f, 0.06122279f, -0.08060972f, -0.06626905f, -0.01921367f, 
    -0.25530154f, 0.13204247f, -0.10171539f, -0.03224358f, 0.13851510f, 0.04344649f, -0.36880529f, 0.09823622f, 
    0.20309810f, -0.07438825f, 0.14774056f, 0.11567444f, 0.05827342f, 0.03782428f, 0.05671028f, -0.10390797f, 
    0.11893500f, 0.01898295f, 0.03982958f, 0.01682729f, 0.08356274f, -0.08205545f, -0.03464871f, -0.00486558f, 
    0.02824299f, -0.01090199f, 0.06617433f, 0.21871458f, -0.13542409f, 0.02453661f, -0.04635318f, 0.09961666f, 
    0.08651920f, -0.07352636f, 0.02059694f, -0.11940814f, 0.17428614f, 0.02140277f, 0.26333013f, -0.06299623f, 
    0.01706515f, -0.09426136f, 0.00079938f, -0.02721521f, -0.01774433f, -0.05023252f, 0.07411712f, 0.16788442f, 
    0.08285886f, -0.07172469f, 0.01046047f, -0.08124154f, -0.14474775f, 0.14339636f, 0.24283263f, 0.09498435f, 
    -0.02124422f, 0.06846564f, -0.03366427f, -0.02862027f, -0.13650781f, -0.00720575f, 0.00859023f, 0.09078936f, 
    -0.21778885f, 0.04559886f, -0.06745498f, -0.12309950f, -0.15158385f, 0.04281132f, -0.07700069f, 0.03582727f, 
    0.04874519f, -0.00087955f, 0.01332829f, -0.01996651f, 0.00331077f, -0.04712260f, 0.02849235f, 0.01043816f, 
    0.02602948f, 0.00475373f, 0.00392054f, -0.05867130f, -0.03016435f, -0.01584090f, -0.03621955f, -0.05160155f, 
    -0.00721384f, -0.04741332f, -0.01288727f, 0.01565195f, 0.02140820f, -0.02371814f, -0.03469087f, 0.02132096f, 
    0.02157550f, 0.03828533f, 0.02702452f, 0.03670901f, -0.03863799f, -0.02443533f, 0.00088122f, -0.02851776f, 
    0.00706987f, 0.00132690f, 0.00068806f, 0.03496744f, -0.05479727f, -0.06754547f, 0.03132881f, 0.02741508f, 
    -0.02337828f, 0.00112067f, -0.02857693f, -0.05618583f, 0.03798334f, 0.01343960f, -0.04728700f, -0.03003540f, 
    0.05626478f, -0.01267673f, 0.03439102f, -0.03683112f, 0.04231732f, -0.04269646f, 0.05627903f, -0.02053583f, 
    0.03051545f, -0.06806578f, 0.00624676f, 0.02396760f, -0.04794053f, -0.00182969f, -0.04634826f, 0.02786498f, 
    0.04169846f, -0.04309967f, 0.03393764f, 0.00957260f, 0.04708383f, -0.05036384f, -0.06059419f, 0.00157658f, 
    -0.00648021f, 0.03634340f, -0.04054830f, 0.02710994f, 0.02944792f, 0.03950128f, -0.05262195f, -0.00699817f, 
    -0.04118429f, -0.04070860f, -0.01819976f, -0.01694767f, -0.03970594f, 0.00670135f, 0.03730476f, 0.04255026f, 
    0.05505008f, 0.00727030f, -0.05508995f, -0.05028672f, -0.01003741f, 0.04803844f, -0.03828466f, -0.01062542f, 
    -0.05319470f, -0.00884931f, 0.04762888f, -0.03799568f, -0.01632690f, -0.00852420f, 0.02883667f, -0.04090287f, 
    -0.00652977f, -0.02957401f, -0.04849336f, 0.03566421f, -0.02056118f, -0.02490854f, -0.06944387f, 0.03609060f, 
    -0.04410180f, 0.02299233f, 0.02150263f, 0.03518533f, -0.04535121f, 0.03542793f, 0.04849118f, -0.03687866f, 
    0.01671495f, 0.01862111f, -0.01162444f, 0.01353883f, -0.03614714f, 0.03687532f, -0.06100490f, 0.01447197f, 
    -0.03545889f, 0.04016540f, 0.00697695f, -0.03110491f, -0.02595219f, 0.04189890f, -0.00945758f, -0.00491005f, 
    0.00668258f, 0.00579567f, -0.04071777f, -0.00503250f, -0.03771172f, -0.00240214f, -0.02182954f, 0.01206463f, 
    -0.00567270f, -0.05386376f, -0.06748401f, 0.02548919f, -0.02008021f, 0.00343728f, 0.03511937f, -0.05541477f, 
    -0.04105923f, -0.03736611f, 0.05080239f, -0.01102675f, -0.01403307f, 0.04407191f, -0.06683136f, 0.00295092f, 
    0.01751260f, -0.00244369f, 0.01987777f, 0.01268897f, -0.02194621f, -0.04194082f, -0.05533054f, -0.02579237f, 
    -0.02962558f, -0.01082689f, -0.02069100f, 0.01398618f, 0.03298380f, 0.03329879f, -0.00254303f, -0.02289761f, 
    -0.01796110f, -0.03811888f, -0.00333427f, -0.00252133f, 0.04270862f, -0.02625229f, 0.03579053f, 0.04355393f, 
    -0.00502748f, 0.04406806f, -0.02396522f, -0.04620923f, -0.05380414f, -0.05044205f, -0.02360829f, 0.02300357f, 
    0.01460277f, -0.05962876f, 0.03165394f, 0.05233622f, -0.04598901f, 0.01393738f, -0.01806708f, 0.00880329f, 
    0.00961105f, -0.01448240f, -0.03828311f, -0.00820809f, 0.03539008f, -0.03334706f, -0.03786101f, -0.01994625f, 
    0.02994851f, 0.02337516f, -0.01020936f, 0.04818333f, 0.00444316f, -0.06529834f, 0.02843187f, 0.04439638f, 
    -0.05283234f, -0.00511208f, 0.04220731f, -0.04823874f, 0.02654814f, -0.02794198f, -0.04622638f, -0.04993211f, 
    -0.02664419f, 0.03032916f, -0.03928073f, -0.02001108f, 0.03389141f, -0.00263069f, 0.03160511f, -0.00634335f, 
    0.04224340f, 0.01020429f, 0.02726712f, 0.05112625f, 0.01862097f, 0.00438620f, -0.05978372f, 0.03874051f, 
    -0.01925029f, -0.05728162f, -0.00876703f, 0.00381422f, 0.02739774f, 0.01885147f, -0.03118372f, -0.03936292f, 
    -0.05711232f, 0.01112282f, -0.04765829f, 0.02324612f, 0.00977008f, 0.00724145f, -0.05777736f, 0.04767835f, 
    0.00892644f, 0.02895083f, -0.03270698f, 0.04752351f, -0.01232321f, 0.01372845f, 0.00609809f, -0.04588911f, 
    -0.02095375f, -0.05020811f, 0.00294216f, 0.00234025f, -0.06270509f, -0.01876083f, -0.02330743f, 0.01161680f, 
    -0.02133023f, -0.05536308f, -0.00234382f, -0.01352432f, -0.05288277f, -0.00946274f, 0.00641362f, -0.02838779f, 
    -0.02310652f, 0.03773753f, -0.02271250f, 0.01950157f, -0.00802875f, 0.04493633f, -0.00747525f, -0.03843585f, 
    -0.00345084f, 0.01593269f, -0.04205133f, -0.23031759f, -0.04549542f, 0.07486590f, -0.03936383f, 0.08349645f, 
    -0.00067810f, -0.06892844f, -0.06233248f, -0.09165408f, 0.01362852f, 0.05066541f, -0.11043702f, -0.11113640f, 
    0.03024014f, 0.08164481f, 0.25020996f, -0.00107542f, 0.05042005f, 0.18273865f, 0.06448244f, -0.00557975f, 
    0.04444867f, -0.04545858f, 0.12935033f, 0.05718127f, -0.18872695f, 0.03634911f, -0.07440959f, 0.08590213f, 
    -0.00984222f, 0.05536164f, 0.03048307f, -0.00682558f, -0.05626843f, -0.13341366f, 0.00514102f, -0.11268793f, 
    -0.01657844f, 0.09678930f, 0.07155456f, -0.06292916f, 0.06999941f, -0.03964642f, -0.06963395f, -0.10126680f, 
    0.15515637f, 0.01089635f, 0.10282925f, 0.05883038f, 0.01240643f, 0.01423168f, 0.31910223f, 0.14107431f, 
    -0.11361914f, 0.06611881f, -0.12564282f, 0.00393500f, 0.06595235f, 0.16975991f, 0.16473566f, 0.21477194f, 
    -0.01335626f, -0.06710194f, -0.01751621f, 0.02321061f, -0.07681023f, 0.01557442f, 0.08702601f, -0.06092691f, 
    -0.16273819f, 0.10449466f, -0.03529141f, 0.24268827f, 0.11092158f, -0.13471620f, 0.03927984f, -0.18919918f, 
    0.14575770f, 0.28786016f, 0.16714743f, 0.10923576f, 0.19367738f, -0.10885100f, 0.07736542f, -0.04246231f, 
    0.08365471f, -0.10350049f, -0.24472363f, -0.31372952f, 0.15402116f, 0.04821987f, -0.00835951f, 0.09136999f, 
    0.00108905f, -0.05761677f, -0.06213344f, 0.02883429f, -0.02367456f, -0.11095671f, 0.01642081f, -0.06576706f, 
    0.02171647f, -0.01323395f, -0.01753761f, 0.02782296f, 0.03557076f, -0.12073564f, -0.01438515f, -0.02212256f, 
    -0.06980887f, -0.07040481f, -0.05196882f, 0.05502225f, -0.03298863f, -0.39138055f, -0.27588376f, 0.01964371f, 
    0.00167536f, -0.02180201f, 0.00949681f, 0.05451585f, 0.06848240f, 0.03244139f, 0.09358453f, -0.07313950f, 
    -0.00108240f, -0.08253259f, -0.17643091f, -0.03059870f, -0.04337718f, 0.09619791f, 0.04820216f, -0.02099184f, 
    -0.03885555f, 0.07539659f, -0.05277691f, -0.10351590f, -0.00089340f, 0.06948303f, 0.13438627f, 0.06587589f, 
    0.11023150f, -0.22766277f, -0.10769728f, 0.06593396f, -0.01716783f, -0.06818116f, -0.05815158f, -0.04206186f, 
    0.11951566f, 0.20947793f, 0.16771232f, 0.06044675f, 0.13927190f, 0.15291059f, 0.10145036f, -0.05256936f, 
    -0.07167090f, -0.06918076f, 0.03760345f, -0.12257794f, -0.06331353f, 0.01171391f, 0.11479893f, -0.01179534f, 
    -0.02633645f, -0.02060274f, 0.02015608f, 0.15547399f, 0.08392392f, -0.29562443f, 0.16382420f, -0.04747697f, 
    -0.01170253f, -0.00028862f, 0.00231451f, -0.04182509f, 0.31639236f, -0.03306853f, -0.04734273f, -0.08545823f, 
    -0.18136431f, 0.05363704f, 0.05369893f, -0.01591167f, -0.06577790f, -0.07931755f, -0.04066452f, 0.12750283f, 
    0.04872501f, 0.11793946f, 0.10353043f, 0.13007616f, 0.02036060f, 0.01721560f, 0.22879311f, 0.02080812f, 
    0.03390815f, 0.23492292f, -0.04110113f, 0.15434945f, 0.02723201f, 0.06683598f, 0.11285434f, 0.07203942f, 
    0.07437047f, -0.10320975f, 0.03740670f, -0.02347525f, 0.08108576f, 0.02005362f, -0.03796818f, 0.08698675f, 
    -0.33736521f, -0.14303567f, -0.01999855f, 0.17548090f, 0.00611823f, 0.03645670f, -0.01179112f, -0.08582832f, 
    0.04825469f, -0.24993271f, -0.12182772f, 0.00691653f, 0.11732446f, 0.09884802f, -0.04598949f, 0.06961247f, 
    -0.13879028f, -0.06969395f, 0.19770090f, -0.08949079f, -0.02850938f, -0.13760597f, 0.08694360f, -0.03686656f, 
    -0.00177595f, -0.08924251f, 0.10036893f, -0.27125460f, -0.17405826f, -0.20798451f, 0.08108987f, 0.00237919f, 
    0.03593513f, 0.05724082f, -0.01522095f, 0.03274086f, 0.14601888f, 0.03487279f, -0.01456117f, -0.19795568f, 
    -0.05884725f, 0.01431249f, -0.02660335f, 0.04183393f, -0.00417380f, -0.22348848f, -0.18651542f, -0.02731935f, 
    0.08751882f, 0.03675605f, -0.09439451f, 0.01442736f, -0.03641596f, -0.01135427f, 0.01028427f, -0.08907083f, 
    0.09907315f, 0.05353142f, 0.02509076f, 0.07914697f, 0.07954581f, -0.02539701f, -0.01849481f, 0.16907939f, 
    0.18712556f, 0.10376327f, -0.03534081f, 0.06395213f, 0.01084117f, 0.05338889f, -0.04576597f, -0.01268555f, 
    0.00158406f, -0.21033832f, 0.16670822f, 0.10878207f, 0.07518935f, 0.07172932f, -0.08925904f, 0.02246289f, 
    -0.10762425f, 0.02271493f, 0.09512072f, -0.09332260f, 0.10520967f, 0.03147588f, -0.06959735f, 0.13408212f, 
    -0.10050565f, -0.03752404f, 0.06402565f, 0.24299286f, -0.15906867f, 0.10350947f, 0.09408885f, -0.12182774f, 
    0.03382492f, 0.14668955f, 0.11573344f, -0.06209115f, -0.19494669f, 0.05765931f, 0.05365298f, 0.03458880f, 
    0.06172247f, 0.07697324f, -0.03532757f, 0.00018052f, -0.14784163f, 0.06512998f, 0.00887097f, 0.19265813f, 
    -0.02986099f, 0.08292951f, 0.07462306f, 0.02917322f, 0.08287249f, 0.19461915f, -0.23683274f, 0.26034436f, 
    -0.04876239f, -0.03199548f, -0.06570029f, -0.07267763f, -0.13807082f, 0.08593216f, 0.11347042f, 0.01112299f, 
    -0.05931970f, 0.00839134f, 0.06588203f, -0.07829163f, -0.07380591f, 0.11549807f, 0.06857063f, 0.16425315f, 
    -0.16415663f, 0.16554880f, 0.01919192f, 0.00530427f, -0.03945722f, 0.00037298f, 0.10484483f, 0.00015832f, 
    0.20349583f, -0.12724972f, -0.14018013f, 0.02053518f, -0.00958810f, 0.04914931f, -0.15628819f, -0.06675661f, 
    0.02050659f, 0.10649221f, 0.05751143f, 0.03474659f, 0.03257705f, 0.03097273f, -0.04600835f, -0.08411645f, 
    -0.01665528f, -0.06099309f, 0.17898573f, -0.02632253f, -0.02812445f, 0.06896570f, 0.14637892f, -0.05471280f, 
    0.16623995f, -0.06090675f, -0.06695069f, 0.02107926f, 0.02374664f, 0.07899874f, 0.07672305f, -0.10368229f, 
    -0.00241238f, 0.07899650f, -0.07740595f, -0.08483805f, 0.23064359f, -0.25030091f, 0.02016528f, -0.02152495f, 
    -0.28169191f, 0.08415247f, 0.07995501f, -0.05185337f, -0.01594889f, -0.33117506f, -0.17114004f, -0.21498835f, 
    -0.03241703f, -0.16498572f, -0.11322267f, -0.09807295f, -0.04823386f, -0.11224775f, -0.09178089f, 0.11961827f, 
    0.05913685f, 0.05847795f, -0.01855309f, 0.21429238f, -0.07256177f, -0.07729598f, 0.15493049f, 0.20115033f, 
    -0.19661410f, -0.02460780f, -0.01412613f, -0.07513802f, -0.02190778f, -0.02823628f, 0.01733240f, 0.03055585f, 
    0.22475027f, 0.24014689f, -0.01787232f, 0.26719791f, -0.01104934f, 0.02065224f, -0.02762879f, -0.01219714f, 
    -0.03447273f, 0.02525261f, -0.04869203f, -0.18301670f, 0.07625231f, 0.02011208f, -0.04735026f, 0.00451651f, 
    0.03677160f, -0.12538020f, -0.00978425f, 0.06051632f, 0.01940994f, 0.03816636f, 0.00613850f, 0.11631413f, 
    -0.05417882f, 0.01981614f, -0.02636297f, -0.35144094f, -0.15673395f, -0.03968314f, 0.01922209f, 0.12963015f, 
    0.01435333f, -0.01936836f, -0.05380832f, -0.17416389f, -0.03967832f, -0.01502901f, -0.06045077f, -0.00709175f, 
    -0.07888874f, 0.05869876f, 0.11854003f, 0.02104035f, 0.07362089f, 0.20113780f, -0.04655981f, 0.04858858f, 
    -0.07023349f, -0.00269858f, -0.02262918f, -0.00998042f, 0.01133489f, -0.04114316f, 0.30091596f, 0.14554979f, 
    0.03454112f, -0.11443061f, -0.08864292f, -0.15031034f, 0.06767453f, 0.07184230f, 0.09145957f, 0.03351448f, 
    0.07601324f, 0.04376005f, -0.03085035f, 0.14670187f, -0.15904638f, -0.04473427f, 0.02347390f, -0.01119034f, 
    0.09198053f, 0.03682582f, -0.06082005f, 0.03737362f, -0.09097864f, -0.00716894f, 0.03655853f, -0.10268439f, 
    0.01772196f, -0.18744256f, 0.04110785f, -0.07874403f, 0.12668878f, 0.03101194f, 0.03224270f, -0.04570859f, 
    -0.15706342f, -0.12983276f, 0.22680005f, -0.06278486f, -0.17345154f, 0.16520587f, -0.04754882f, -0.03341991f, 
    0.03910330f, 0.02319666f, -0.01234568f, -0.01003594f, 0.01597709f, -0.13865270f, -0.07718089f, -0.09127986f, 
    0.05954084f, 0.02032450f, -0.02091861f, 0.01214230f, -0.07096580f, -0.07210416f, -0.00818362f, 0.03816250f, 
    0.02432515f, -0.01269022f, 0.04791829f, 0.07911213f, -0.02997849f, -0.00334317f, -0.17438874f, -0.08382801f, 
    -0.06789671f, -0.06077332f, 0.01697349f, 0.06716303f, 0.03180394f, -0.10141288f, 0.01885209f, 0.05655353f, 
    -0.04380128f, -0.06215756f, 0.08100165f, -0.04200520f, -0.13018243f, 0.13359554f, -0.10830483f, 0.10259163f, 
    -0.14899859f, 0.06175019f, 0.14717135f, 0.03244805f, -0.07448130f, 0.02131949f, 0.04437202f, 0.06748461f, 
    0.00213905f, 0.02086257f, -0.02450828f, -0.00946766f, -0.05439755f, -0.06701870f, -0.01071228f, -0.05975370f, 
    -0.05132999f, -0.01631217f, 0.04017850f, -0.03507138f, 0.01982924f, 0.04607552f, 0.00041518f, -0.05929061f, 
    -0.02956200f, -0.01292520f, -0.05928341f, 0.04524872f, -0.01740634f, -0.02440615f, -0.04239417f, 0.03782887f, 
    0.02548350f, 0.04985290f, 0.02695498f, -0.04816214f, 0.02898622f, -0.02755121f, -0.01467576f, -0.03899086f, 
    -0.05726317f, 0.02147378f, -0.06307542f, -0.01987889f, 0.01091962f, 0.03167631f, 0.01246126f, 0.00262240f, 
    -0.03570637f, -0.00338362f, 0.02058739f, -0.03845236f, 0.04510500f, 0.05088826f, -0.04874272f, 0.00833530f, 
    0.04868476f, -0.02559732f, -0.02685049f, -0.01579566f, -0.02138619f, -0.02018961f, 0.01838370f, 0.01523155f, 
    -0.02899782f, -0.03319322f, -0.05586239f, 0.01237207f, -0.01570505f, 0.03250907f, -0.05136566f, 0.01802362f, 
    0.02389670f, -0.03435386f, -0.05770622f, -0.02571020f, 0.04685039f, 0.02316418f, 0.04212989f, 0.01842808f, 
    -0.01180830f, -0.01001966f, 0.02482873f, -0.04354934f, 0.04533734f, -0.06263740f, -0.02849577f, -0.00420683f, 
    -0.02259728f, -0.01708105f, 0.04989648f, 0.03761800f, -0.05698177f, 0.01875805f, 0.04722640f, 0.04294844f, 
    -0.03385743f, -0.02865629f, 0.03749505f, -0.00724232f, 0.03790241f, -0.02789403f, -0.03401072f, 0.01363372f, 
    -0.01528237f, 0.02273726f, 0.00101041f, -0.05472302f, -0.03504091f, 0.03119314f, -0.02021842f, -0.04003475f, 
    -0.02684685f, 0.01110097f, -0.03436282f, -0.01848204f, -0.02169984f, -0.02605080f, 0.05195998f, -0.02157835f, 
    -0.03389467f, -0.04831161f, -0.04662989f, -0.03432353f, -0.02092387f, -0.05206256f, -0.01885886f, -0.02591566f, 
    -0.00630655f, 0.00133148f, -0.01816279f, 0.01146151f, 0.00651709f, 0.04907328f, -0.02381322f, -0.05823847f, 
    -0.06192538f, -0.04238086f, 0.00686600f, -0.06464300f, 0.03980368f, -0.04655711f, -0.01967514f, 0.02699080f, 
    0.00258959f, -0.03030686f, -0.03455917f, 0.03188677f, 0.01458113f, -0.00906554f, 0.05494104f, -0.04536923f, 
    0.02861581f, -0.04692440f, 0.04026258f, 0.04775605f, -0.00697934f, -0.04371921f, 0.01550456f, 0.01523146f, 
    -0.03978092f, 0.04277668f, -0.04492936f, -0.05109705f, -0.00963548f, 0.01587601f, -0.03412105f, 0.01632210f, 
    -0.04350097f, -0.00835286f, 0.00462003f, -0.00931115f, 0.01501839f, -0.03013114f, -0.02830354f, 0.03835077f, 
    -0.05076827f, 0.03339062f, -0.00031671f, 0.01631204f, 0.00897051f, -0.04167708f, -0.04652065f, -0.03926048f, 
    0.04977919f, 0.04622314f, -0.00333118f, -0.04076247f, 0.05006635f, 0.05205622f, -0.02690298f, -0.00581370f, 
    0.00485020f, -0.06491974f, 0.00814939f, -0.05207996f, 0.03604582f, 0.02334218f, 0.01373212f, -0.04859953f, 
    0.03771088f, -0.01474989f, 0.02748604f, 0.01452248f, -0.03122923f, -0.02504146f, -0.01342501f, 0.02685066f, 
    -0.02278446f, -0.00630345f, -0.02144383f, -0.06381803f, 0.03584777f, -0.00074822f, -0.00207874f, -0.04429165f, 
    0.01369472f, 0.01885322f, 0.01407740f, -0.06116199f, 0.03404511f, -0.03984279f, 0.03400571f, 0.01536694f, 
    0.03099598f, -0.01212431f, -0.00901016f, 0.01864666f, -0.05717228f, -0.05365265f, -0.01973077f, -0.05154910f, 
    -0.04796280f, 0.04793033f, -0.00108162f, 0.02746286f, 0.04429190f, 0.00616159f, 0.02814964f, 0.01424782f, 
    -0.01137413f, 0.03698865f, -0.04832928f, 0.00835162f, 0.04883164f, -0.01211665f, -0.05510987f, -0.01690659f, 
    -0.01334774f, -0.05831352f, 0.00346836f, -0.03339892f, 0.02751581f, -0.02441099f, 0.00751036f, 0.00193915f, 
    0.02071893f, 0.00363316f, -0.00493936f, -0.00212233f, 0.00460567f, -0.05034638f, 0.02705228f, 0.01061510f, 
    0.02194637f, -0.02872966f, 0.03296848f, 0.04264762f, 0.05234746f, -0.05342410f, 0.03680987f, 0.04963839f, 
    -0.03403873f, 0.01659770f, -0.01533552f, -0.05777654f, -0.02891043f, -0.03545575f, 0.00405003f, 0.03028789f, 
    -0.01690050f, 0.03496500f, 0.03379882f, -0.01356598f, -0.05254736f, -0.00656638f, 0.00557011f, -0.02365820f, 
    0.02294710f, 0.00242321f, 0.04942586f, -0.05477280f, 0.04978132f, 0.00893743f, 0.01235316f, -0.03066443f, 
    -0.12301013f, -0.21144724f, 0.08781398f, 0.27536601f, 0.14635062f, 0.00206997f, -0.05702314f, -0.04179301f, 
    0.03759648f, -0.03935148f, 0.15722771f, 0.20284216f, 0.14302440f, 0.04439742f, -0.00066856f, -0.13209061f, 
    0.02669526f, -0.03189395f, -0.12822986f, -0.09564973f, 0.17476593f, -0.23270686f, 0.00937544f, 0.03944601f, 
    0.06029007f, -0.03102632f, -0.18242158f, -0.17029563f, -0.07561859f, -0.06308554f, 0.00175675f, -0.01229721f, 
    0.09589786f, -0.02706057f, 0.11815950f, 0.14643572f, 0.15543525f, -0.02452150f, -0.00265990f, -0.05326565f, 
    0.10755691f, -0.09999150f, 0.12872052f, -0.09818348f, 0.11895925f, -0.07798105f, 0.09914933f, 0.10989847f, 
    0.05118306f, -0.01257545f, 0.00960328f, -0.13290142f, -0.01786333f, -0.02108116f, -0.11298679f, 0.06272799f, 
    0.22708511f, 0.09019505f, -0.12485989f, -0.04580265f, 0.00783305f, 0.08253248f, 0.15951583f, -0.23563580f, 
    -0.18137544f, -0.08025426f, 0.25375119f, 0.11394068f, 0.01307625f, 0.02444644f, -0.08320440f, 0.02275674f, 
    0.16694485f, -0.07929302f, -0.24436533f, -0.11380240f, 0.05042573f, -0.03255808f, -0.01508912f, -0.19652046f, 
    -0.12875757f, -0.03058629f, 0.12552717f, 0.08064056f, -0.17874402f, -0.04052604f, -0.20926514f, 0.01902779f, 
    0.00042147f, -0.01769379f, -0.14244828f, -0.26092991f, -0.01651407f, -0.08095077f, -0.01654874f, -0.14789148f, 
    -0.02228596f, 0.18861316f, -0.04863487f, 0.17496479f, -0.04769385f, -0.16566528f, -0.02922169f, -0.10410731f, 
    0.11756578f, 0.02101673f, 0.12312142f, -0.06682756f, 0.09917241f, -0.05716160f, -0.20097588f, 0.02910566f, 
    0.01349061f, 0.05068102f, -0.02845068f, -0.08139698f, -0.01239488f, -0.09431190f, -0.09798368f, -0.27650854f, 
    -0.02011962f, -0.13035762f, 0.08803762f, -0.06013504f, 0.03451542f, 0.07349879f, -0.04871516f, -0.11336378f, 
    0.03696628f, 0.11540118f, 0.01440322f, 0.17610925f, -0.14536147f, -0.03675310f, -0.04296123f, -0.01964092f, 
    -0.11206591f, -0.16596857f, 0.12043042f, 0.11411387f, -0.01861596f, -0.00193679f, 0.07923112f, -0.00532712f, 
    0.04727501f, 0.02194544f, -0.12384838f, 0.12426182f, -0.05562208f, 0.00166443f, 0.00789598f, 0.04057442f, 
    0.01873576f, -0.08645792f, 0.04522790f, 0.21995226f, -0.06825631f, 0.04186758f, -0.12371247f, 0.12511402f, 
    -0.03194306f, 0.01459081f, 0.00971434f, -0.17722432f, 0.01841035f, 0.11409257f, 0.07943697f, -0.07238062f, 
    0.08072264f, -0.05230265f, 0.01905635f, -0.28154185f, -0.01600648f, 0.23011640f, -0.04713883f, -0.03102208f, 
    -0.14482288f, -0.09978805f, 0.07032318f, -0.03078376f, 0.15640083f, 0.00237477f, 0.01917269f, 0.15616079f, 
    0.02864191f, 0.05769093f, 0.07958813f, 0.12626870f, -0.15123802f, -0.05882467f, -0.11418701f, -0.04129512f, 
    -0.16610415f, -0.07613513f, 0.04607119f, 0.02794954f, 0.13140339f, -0.02028714f, -0.00182565f, 0.03106819f, 
    0.04305289f, 0.00423039f, -0.05894660f, -0.09656189f, 0.12461391f, -0.00695883f, -0.12290523f, 0.04377781f, 
    0.08662292f, 0.03601513f, -0.02815145f, -0.05903092f, -0.08468121f, 0.08947731f, 0.03009091f, 0.09384832f, 
    -0.10330332f, 0.06381854f, 0.19865760f, 0.11702829f, 0.06704567f, -0.14475799f, 0.11695457f, 0.13884142f, 
    -0.02582402f, -0.18167157f, 0.30182126f, 0.27276343f, -0.01169604f, 0.10140184f, 0.16219854f, 0.03741711f, 
    -0.01364255f, 0.06578083f, -0.04913127f, -0.05949715f, -0.04092355f, -0.10744908f, 0.05741355f, -0.09284080f, 
    0.20557116f, 0.01829363f, 0.09320955f, 0.02144010f, 0.20444874f, 0.12367993f, 0.11560204f, 0.02381008f, 
    0.14428139f, 0.12396209f, 0.00858944f, 0.00550646f, -0.09947872f, -0.09595809f, 0.19043554f, 0.26539654f, 
    -0.00593013f, 0.01360064f, 0.03938260f, -0.03115856f, -0.10499071f, 0.09184866f, -0.04968604f, -0.04596921f, 
    0.14698301f, 0.02557102f, 0.11258145f, 0.09238592f, -0.03279345f, -0.00454635f, 0.11014860f, -0.06216162f, 
    -0.14613600f, -0.05136245f, 0.03599636f, -0.15989411f, -0.08749380f, 0.02288661f, 0.02559286f, 0.03328943f, 
    -0.03042145f, 0.06032562f, 0.08488960f, -0.09886902f, -0.05357924f, 0.08463615f, 0.00530137f, -0.23903406f, 
    0.13344882f, 0.05366100f, 0.06979565f, -0.02078121f, -0.01193392f, 0.04063864f, 0.05152315f, 0.05252443f, 
    0.08198061f, 0.11438482f, -0.01275906f, -0.35638395f, 0.10210555f, 0.10859580f, 0.05165419f, -0.00624446f, 
    0.05605321f, -0.09614505f, -0.01660316f, -0.22771254f, -0.17417888f, -0.02432317f, -0.05101564f, 0.05372356f, 
    0.02653303f, -0.06794585f, -0.05124556f, 0.36166143f, 0.03623069f, -0.02969124f, -0.00853209f, 0.05380909f, 
    -0.03638900f, 0.05912523f, -0.03924098f, 0.08544635f, 0.09028681f, -0.23547596f, -0.21763521f, 0.03188091f, 
    -0.02287399f, 0.01337576f, 0.08463473f, 0.08526383f, 0.06120557f, -0.34801763f, -0.18460475f, 0.26603469f, 
    -0.03577733f, 0.16392238f, 0.13339129f, 0.07008902f, -0.05339194f, 0.03961119f, -0.05693835f, 0.07649432f, 
    0.01750736f, 0.02653158f, -0.01925004f, -0.10641177f, -0.11037260f, 0.04625372f, -0.03214429f, 0.34985045f, 
    -0.15699434f, 0.08991204f, -0.02807192f, 0.07152926f, -0.04543423f, 0.06572016f, -0.06220625f, 0.09640300f, 
    0.06539917f, 0.24577011f, 0.18032686f, 0.02688612f, 0.11581775f, 0.05580454f, -0.13225587f, -0.16713250f, 
    -0.04217418f, 0.03733150f, 0.14783879f, -0.16162418f, 0.03186277f, 0.07186034f, -0.07072930f, -0.00095518f, 
    0.07338881f, -0.05156778f, -0.30606359f, -0.23962778f, -0.15045704f, 0.08829420f, -0.14704877f, 0.05985401f, 
    -0.15022284f, -0.02164330f, 0.08474974f, 0.29690552f, 0.03697221f, -0.27042997f, 0.15885842f, 0.08853969f, 
    0.03780728f, -0.05771301f, 0.04548956f, 0.00441055f, -0.21139325f, 0.13447851f, -0.10340295f, 0.02912993f, 
    -0.05093179f, -0.04085467f, 0.03199555f, -0.04542660f, -0.05902434f, -0.35161266f, -0.11338305f, 0.18885133f, 
    -0.22959687f, 0.13021369f, -0.05494902f, 0.02255326f, -0.02174070f, -0.05621931f, 0.23470509f, -0.15949354f, 
    -0.10752821f, -0.05649588f, 0.01284460f, -0.03702113f, 0.15789290f, 0.13836998f, -0.05346552f, 0.00567920f, 
    -0.01133229f, -0.01480617f, 0.00205050f, -0.14810173f, 0.06551441f, -0.05738946f, -0.04130192f, 0.06209217f, 
    -0.42389813f, -0.15641397f, -0.05979152f, 0.04577787f, -0.02082109f, 0.01363909f, 0.02048597f, -0.04145493f, 
    0.10620878f, -0.00869826f, -0.04233601f, -0.01314792f, 0.09417346f, 0.00784307f, 0.12381247f, -0.05438573f, 
    -0.05768732f, -0.05580095f, 0.03246139f, -0.36614275f, -0.09355760f, -0.07936756f, 0.02220761f, -0.04762040f, 
    0.00396306f, 0.00034303f, -0.17482446f, -0.06974504f, 0.04446287f, -0.10549816f, -0.09378651f, 0.04536519f, 
    0.10062695f, -0.08903591f, -0.06825373f, 0.03962940f, 0.16425410f, 0.11328807f, -0.00143581f, 0.09173714f, 
    0.06379075f, -0.01031829f, -0.06484909f, -0.06064305f, 0.18006603f, -0.22040386f, 0.06736390f, 0.06121374f, 
    -0.09917056f, 0.01985185f, -0.09594764f, -0.06688796f, 0.04675783f, 0.10828254f, -0.34730348f, 0.05122902f, 
    0.13761929f, -0.00262857f, 0.19133456f, 0.00135265f, -0.10332731f, 0.05442585f, -0.09321524f, -0.12261623f, 
    0.06995220f, -0.23598622f, -0.02364418f, 0.16722287f, 0.08510987f, 0.03533214f, 0.01552415f, -0.03946662f, 
    -0.10363779f, 0.04321855f, -0.10670940f, -0.05950036f, 0.08671025f, 0.01628994f, -0.04194014f, 0.04670376f, 
    0.05069891f, -0.06538887f, -0.00976314f, -0.01020902f, 0.04123241f, -0.01740508f, -0.01997285f, 0.02715112f, 
    -0.02755419f, 0.04092125f, -0.00936939f, -0.05591090f, -0.19133003f, 0.02952902f, 0.08588888f, 0.00202640f, 
    -0.01122219f, 0.01405730f, 0.08577599f, -0.12174138f, -0.16627650f, 0.12955627f, 0.05777667f, 0.10558999f, 
    0.05197909f, -0.10861624f, 0.04527885f, 0.06171502f, 0.20445688f, 0.03146232f, -0.04123020f, 0.04112259f, 
    -0.00822931f, -0.12839954f, 0.00431211f, 0.08831872f, 0.08269690f, -0.10159185f, 0.09783065f, 0.11301796f, 
    0.00634036f, 0.15316620f, 0.04909378f, -0.01447445f, -0.02812120f, 0.00040571f, -0.31946692f, -0.23717561f, 
    -0.16945170f, -0.00922111f, 0.12262215f, 0.03051071f, 0.13822439f, -0.04291841f, 0.10560230f, -0.14526959f, 
    0.10156922f, -0.02700255f, 0.06218439f, -0.09584315f, 0.22260913f, 0.08825511f, 0.00876219f, -0.02739354f, 
    0.08291882f, 0.04703198f, -0.02322050f, 0.03633625f, 0.06736068f, 0.00784064f, -0.07581284f, 0.02779044f, 
    0.14496936f, 0.04427848f, -0.03024057f, 0.14377016f, -0.06406966f, -0.11707008f, -0.00905596f, 0.07662492f, 
    0.04066874f, -0.08494975f, 0.27683026f, -0.04491295f, -0.04597753f, 0.07985216f, 0.12384178f, 0.09571627f, 
    -0.00456531f, 0.02105830f, 0.14509161f, 0.09493697f, 0.10064577f, -0.16518228f, 0.07252879f, -0.03315753f, 
    -0.02518424f, 0.00101698f, 0.07958894f, -0.01733552f, 0.05313198f, 0.16239415f, 0.08454716f, -0.02467353f, 
    -0.03518422f, 0.10258188f, -0.04271114f, -0.10884070f, 0.04291293f, -0.20844389f, 0.18266740f, -0.07066520f, 
    -0.05435170f, -0.01465832f, -0.23009913f, -0.07010718f, 0.09560619f, 0.04222533f, -0.05049834f, -0.04310380f, 
    0.07924579f, -0.01847076f, -0.01506447f, -0.03315510f, -0.04872970f, -0.06718331f, 0.05906677f, -0.00629765f, 
    0.05690014f, -0.01866728f, 0.00957678f, -0.17129222f, -0.04850480f, 0.01530605f, 0.05078349f, 0.00769999f, 
    -0.12243829f, -0.13030240f, -0.16157302f, 0.20580657f, -0.08317439f, -0.13047612f, -0.10778071f, -0.03027114f, 
    0.05171343f, -0.05899341f, -0.04420716f, 0.03885931f, -0.06180244f, 0.08383265f, -0.07465088f, 0.06030815f, 
    -0.18662059f, 0.13989063f, 0.22946052f, -0.08464888f, -0.09420910f, -0.18101674f, -0.01026893f, -0.05704196f, 
    0.02340000f, 0.09676570f, 0.04262788f, -0.23067774f, 0.01484404f, 0.10992987f, -0.05362647f, -0.13945323f, 
    -0.03871170f, 0.02212140f, -0.04622097f, 0.00651100f, 0.23968656f, -0.02543000f, 0.06077500f, -0.16527234f, 
    -0.05078008f, 0.01515170f, -0.02888580f, 0.04251828f, 0.03060661f, -0.12717336f, -0.12005998f, 0.01259161f, 
    -0.00784456f, 0.00984562f, 0.06707218f, -0.18093979f, 0.03781443f, -0.02525661f, 0.04766994f, 0.03872995f, 
    0.00903013f, -0.14081727f, 0.03814439f, 0.12674586f, -0.05458648f, 0.07836648f, 0.19333933f, 0.10599389f, 
    -0.03898897f, 0.04174411f, -0.07424144f, 0.03037618f, -0.05429508f, -0.03203559f, 0.04409566f, -0.00929150f, 
    0.18449368f, -0.00832479f, 0.23081934f, -0.09335282f, -0.00067840f, 0.04957136f, 0.01263680f, 0.03106301f, 
    0.03686473f, -0.06313939f, -0.15783265f, -0.00352174f, 0.04063737f, 0.01469885f, 0.00286679f, 0.09859156f, 
    0.06154337f, 0.05794633f, 0.29669270f, 0.16401775f, -0.09295136f, -0.09631205f, 0.11627286f, -0.12603110f, 
    0.07987109f, 0.02537602f, 0.02823617f, -0.28217489f, -0.59110254f, -0.09688965f, 0.01947748f, 0.01727231f, 
    0.06416351f, 0.00647109f, -0.00068593f, 0.05873074f, -0.05826037f, 0.00349488f, 0.00468195f, 0.05850654f, 
    -0.08282626f, 0.04371816f, -0.10106812f, 0.04061071f, 0.00851682f, 0.12991996f, -0.06523311f, -0.13018668f, 
    -0.07013809f, 0.05583640f, 0.00294269f, 0.02065106f, -0.05824933f, 0.09808977f, 0.24171935f, 0.05957817f, 
    -0.10608134f, -0.08292093f, -0.00644429f, -0.02236422f, -0.00800729f, 0.02409463f, -0.01989134f, -0.06422178f, 
    0.07238216f, 0.21344718f, -0.09557202f, 0.03921410f, 0.02585833f, 0.07999999f, -0.00712208f, 0.03804616f, 
    -0.31925485f, -0.37580505f, 0.09278928f, -0.01611270f, 0.11675146f, -0.01211490f, 0.07706842f, 0.01817056f, 
    -0.01081064f, -0.19354783f, -0.44859362f, 0.02284262f, 0.07116839f, 0.02594019f, 0.01844683f, 0.01211942f, 
    0.02426726f, -0.00237374f, 0.31172431f, -0.18640880f, 0.03697732f, -0.01840360f, -0.06622954f, -0.04483621f, 
    -0.03354707f, -0.03106861f, -0.05563903f, -0.27508062f, 0.13748489f, 0.09768789f, 0.04707934f, -0.07976814f, 
    0.09091128f, 0.05918115f, 0.05174751f, 0.05489761f, 0.07361972f, 0.13236365f, -0.03992487f, 0.01892649f, 
    0.09575672f, 0.01637108f, -0.00574119f, 0.16553122f, 0.09499754f, -0.25366035f, -0.19925466f, -0.01148182f, 
    0.07527121f, 0.04385921f, 0.06257323f, -0.00249896f, 0.26380563f, 0.05271170f, 0.06461980f, -0.03569182f, 
    -0.14767067f, 0.07594755f, 0.15727773f, 0.04752026f, -0.02738458f, 0.09929420f, -0.00032833f, -0.15610079f, 
    0.04890902f, 0.05068013f, 0.09130885f, 0.13367806f, -0.06601245f, 0.03894296f, -0.03736875f, 0.15719222f, 
    0.18799227f, -0.04896431f, 0.10978666f, 0.17272960f, 0.03367478f, 0.07041516f, 0.08702316f, -0.07703212f, 
    0.04977095f, -0.20373726f, -0.19052258f, -0.02594715f, 0.00225274f, -0.11348953f, -0.00559413f, -0.08981370f, 
    -0.00709831f, -0.03565624f, -0.35182503f, 0.21779427f, -0.07839002f, -0.04493819f, 0.07830105f, 0.10208607f, 
    -0.21439804f, -0.01699789f, 0.16980566f, 0.34117374f, -0.02472495f, -0.03378454f, -0.03817676f, 0.02468412f, 
    -0.10226168f, -0.04087899f, 0.11365230f, 0.06008042f, -0.10634281f, -0.00196480f, 0.10339735f, 0.20933734f, 
    0.11195879f, 0.11428562f, -0.14693412f, 0.03571428f, 0.06095557f, 0.07010128f, 0.05721581f, 0.23855317f, 
    -0.05764465f, -0.00091930f, -0.01227694f, -0.02132646f, -0.01395492f, 0.05035406f, -0.19664957f, -0.07348318f, 
    0.08518479f, -0.00463175f, -0.10820918f, 0.02411111f, -0.18120942f, -0.02047798f, -0.15236309f, 0.35511678f, 
    -0.06541521f, -0.04392546f, 0.01442142f, 0.14670803f, -0.03305442f, -0.00090524f, 0.05220106f, -0.00325824f, 
    0.13481520f, 0.05173077f, -0.05875826f, -0.09482736f, -0.12430537f, -0.05859158f, -0.02940072f, -0.18357365f, 
    0.03223517f, 0.11973220f, -0.17007738f, 0.23225625f, -0.00408379f, 0.07073033f, 0.10884114f, -0.01534393f, 
    -0.01464637f, -0.01891953f, 0.15117760f, 0.06562646f, 0.01466866f, -0.17026040f, -0.00337807f, 0.08311121f, 
    -0.08799984f, 0.26469848f, 0.10486118f, -0.03764958f, 0.07917223f, 0.14796750f, -0.04670974f, 0.01681135f, 
    -0.27720824f, -0.14172974f, -0.04915075f, 0.00069651f, 0.06901330f, -0.06574465f, -0.07050797f, -0.12686430f, 
    -0.07305729f, -0.07503615f, -0.08304691f, 0.04995088f, 0.01251372f, 0.00204965f, -0.02737253f, -0.09391646f, 
    -0.14138161f, 0.01747759f, -0.02999348f, 0.05992254f, 0.02300839f, -0.03008959f, 0.09104633f, 0.05256331f, 
    -0.00132697f, 0.00860110f, 0.15147048f, 0.05419867f, -0.03002619f, 0.05253559f, -0.06938994f, -0.06166562f, 
    -0.25753608f, -0.06787457f, 0.10456155f, -0.05986657f, 0.03392640f, -0.08304753f, -0.00780155f, -0.03718315f, 
    -0.15958087f, 0.34990534f, -0.08010963f, -0.00509074f, 0.03607326f, 0.06104229f, 0.01562700f, 0.08593056f, 
    0.02297431f, -0.03419629f, 0.09873026f, 0.11744832f, -0.04394845f, -0.18962352f, -0.15288049f, 0.07329478f, 
    0.10081455f, 0.05569715f, -0.25849935f, -0.11826168f, 0.02299564f, -0.03175539f, 0.07116336f, 0.11778957f, 
    0.05718518f, 0.10844851f, -0.08201555f, 0.08635148f, 0.10100111f, 0.09800862f, -0.17580509f, -0.11083946f, 
    -0.01787332f, -0.03352682f, 0.03022359f, 0.07426414f, 0.22303383f, -0.06667553f, -0.15511382f, 0.10041270f, 
    0.11412621f, 0.05968026f, 0.01742042f, 0.02626555f, 0.09036072f, 0.27823135f, 0.02174463f, 0.04261507f, 
    0.12222898f, -0.04015879f, 0.09004855f, 0.00445582f, -0.08684101f, 0.07890667f, -0.09738594f, 0.14837407f, 
    -0.01616970f, 0.01679284f, -0.02115699f, -0.09382647f, -0.05966561f, 0.09389949f, 0.12461626f, 0.11940937f, 
    -0.15071148f, -0.05653648f, 0.06068325f, -0.01519227f, -0.07418349f, -0.10733434f, 0.02296227f, -0.00211658f, 
    -0.05508659f, 0.03535051f, -0.04681571f, -0.08185409f, -0.04700686f, -0.11281107f, -0.06140298f, -0.00577468f, 
    -0.06387650f, 0.09377894f, 0.08195647f, -0.01390591f, -0.12465108f, -0.01253352f, -0.02737171f, -0.00745863f, 
    -0.05593817f, -0.03764882f, -0.23174857f, -0.02292577f, -0.13221785f, -0.01414485f, -0.10598515f, -0.04676428f, 
    0.00930755f, 0.05775217f, 0.00249980f, 0.03166536f, 0.06571167f, -0.08947060f, -0.07770627f, 0.03714329f, 
    -0.02258096f, 0.12320404f, 0.04658751f, 0.11726101f, 0.09729382f, 0.07362796f, -0.00595297f, 0.24212509f, 
    0.14788976f, 0.10969290f, 0.09929384f, 0.05519374f, 0.02961222f, 0.15735957f, 0.01959793f, 0.07642291f, 
    -0.01539630f, -0.04766270f, -0.05999864f, 0.11124160f, 0.17074884f, 0.07960324f, 0.09792923f, -0.15935574f, 
    -0.09330232f, -0.25866994f, 0.02832825f, -0.09538648f, 0.00034208f, -0.01702509f, -0.19243208f, -0.04662051f, 
    -0.12199674f, 0.08052328f, -0.01612459f, -0.00878742f, 0.01413495f, -0.10174751f, -0.10870027f, 0.03357887f, 
    -0.04698116f, 0.08768660f, -0.36926252f, -0.16135512f, -0.00997953f, 0.06857003f, 0.15544343f, -0.05844906f, 
    -0.10231367f, 0.08362215f, -0.10859182f, -0.24919084f, 0.03552528f, 0.10993297f, 0.10177542f, -0.04064276f, 
    -0.04895985f, -0.17143860f, 0.14847618f, 0.03894788f, -0.03822027f, 0.01331001f, 0.00492661f, -0.16415451f, 
    -0.06477151f, -0.00907750f, -0.04972479f, -0.06900951f, 0.35126227f, -0.10266910f, -0.15385804f, -0.01216816f, 
    0.01919176f, 0.01018798f, -0.08178772f, 0.03118765f, 0.20954058f, 0.03354961f, -0.13411969f, 0.01115986f, 
    0.03258269f, 0.01102981f, 0.00015627f, 0.02260970f, -0.19959109f, 0.04667974f, -0.05005130f, -0.24569109f, 
    -0.05937063f, 0.04963132f, 0.05920924f, -0.03114533f, -0.05535909f, -0.16562845f, 0.18778968f, 0.14409140f, 
    -0.11872552f, 0.05221900f, 0.08391301f, -0.04740477f, -0.06792665f, -0.07352878f, 0.07560802f, 0.11968143f, 
    0.26456687f, -0.12527515f, -0.04716763f, -0.03797749f, 0.10532528f, -0.05741904f, -0.01995091f, -0.06934571f, 
    -0.15163842f, -0.05650996f, 0.28194338f, -0.11673276f, 0.15760402f, 0.02153339f, 0.02314381f, -0.07624643f, 
    -0.05587026f, 0.36411387f, 0.05782386f, -0.10587437f, -0.07171063f, -0.03228581f, -0.04204338f, 0.00973238f, 
    0.00932615f, -0.10209415f, -0.23090197f, -0.09104376f, -0.19006312f, -0.12378659f, -0.04685686f, 0.01583873f, 
    0.00790162f, 0.00314591f, 0.07140525f, 0.11905245f, 0.03626343f, -0.11670746f, 0.07346211f, -0.02833120f, 
    -0.00623876f, -0.02062554f, 0.10069834f, -0.09941231f, -0.26361638f, 0.09352015f, -0.28302798f, 0.07520689f, 
    -0.15552409f, -0.02404502f, 0.01942717f, 0.08652184f, 0.02302856f, -0.12891439f, -0.07614361f, 0.22955801f, 
    -0.02452491f, 0.11635268f, 0.01947107f, 0.10545876f, 0.16442892f, -0.08435286f, 0.14032215f, -0.05676665f, 
    -0.18838120f, -0.01724177f, -0.05881988f, 0.11776444f, -0.05376720f, -0.00394968f, -0.12861194f, -0.28656131f, 
    -0.03769655f, -0.21408743f, 0.08480638f, -0.23186517f, 0.04586176f, 0.05633023f, 0.05481378f, 0.01917327f, 
    0.37474951f, -0.16544989f, 0.05611039f, -0.02170979f, 0.08782774f, 0.10753748f, -0.13604859f, -0.09054704f, 
    -0.04462359f, 0.11296690f, 0.16968043f, 0.06362982f, 0.14044465f, -0.05523374f, 0.10512267f, 0.00961621f, 
    0.02744064f, -0.07073748f, 0.10240476f, -0.27225649f, -0.00894746f, -0.00389356f, 0.02918947f, 0.11015912f, 
    -0.07464968f, 0.04546943f, -0.05736496f, 0.40465924f, 0.27874610f, -0.10827713f, 0.01348335f, -0.11168131f, 
    0.03475453f, -0.10308419f, 0.06964689f, 0.03507131f, 0.15803114f, 0.09219882f, -0.06565860f, -0.00027105f, 
    -0.04490098f, 0.11259848f, -0.05214657f, -0.01668913f, -0.00639329f, -0.33849186f, -0.05931088f, -0.03898367f, 
    -0.10648429f, 0.06980222f, -0.05896197f, 0.05608942f, 0.16906649f, -0.00269810f, 0.14378913f, -0.09852076f, 
    -0.00383795f, -0.08860892f, 0.03552629f, -0.05389596f, -0.01986341f, -0.05462024f, 0.05310680f, -0.08679985f, 
    0.06431457f, -0.16077827f, -0.00922529f, -0.03314928f, 0.10363559f, 0.07601597f, 0.15640794f, -0.08551219f, 
    0.22014455f, 0.11800746f, -0.08773527f, 0.03423743f, 0.01085708f, 0.03029793f, -0.03810790f, 0.09783582f, 
    0.03459981f, 0.15997481f, 0.12659086f, 0.00654326f, -0.10734724f, 0.04139840f, 0.07566620f, -0.12584992f, 
    0.11729963f, -0.05892423f, 0.01052216f, 0.02679195f, 0.10094542f, 0.01538296f, 0.03416968f, -0.11587167f, 
    0.04551073f, 0.10407609f, 0.11149987f, 0.03628957f, -0.01930898f, 0.10798958f, 0.13615362f, 0.10906989f, 
    -0.04661483f, -0.08893292f, 0.02130560f, 0.02234960f, 0.18809007f, -0.03936162f, -0.07451651f, -0.17795298f, 
    -0.04864214f, 0.01972893f, 0.05568467f, -0.07025619f, -0.12827580f, 0.00390470f, 0.16883069f, 0.07132614f, 
    0.00446991f, 0.04304571f, 0.09195448f, -0.18905023f, -0.10124171f, 0.07850664f, 0.11994731f, -0.10936165f, 
    0.07694209f, -0.01572753f, -0.04375890f, 0.15685561f, -0.01802230f, 0.03615909f, 0.07515809f, 0.01789726f, 
    -0.11525112f, -0.11060257f, 0.02524743f, 0.07028702f, 0.11839176f, -0.07964341f, -0.04596369f, -0.05339472f, 
    -0.08630016f, 0.02597456f, 0.05280408f, 0.00427866f, -0.07308935f, -0.17058615f, 0.05442839f, 0.13150291f, 
    0.03747343f, -0.26681742f, -0.30964613f, -0.05418913f, -0.08829618f, -0.10746651f, 0.00499399f, 0.00721771f, 
    0.12756453f, -0.22818884f, 0.21236964f, -0.02731708f, 0.06633488f, -0.02124335f, 0.09545697f, 0.03077411f, 
    0.04314449f, -0.00964963f, 0.07764774f, 0.13609755f, -0.02963798f, 0.00998920f, -0.11341109f, 0.08984063f, 
    -0.05008907f, -0.03586967f, 0.05054326f, -0.00783593f, -0.25936374f, -0.04510481f, -0.16074741f, -0.12301491f, 
    -0.07281893f, -0.02102496f, -0.04654665f, 0.00914591f, 0.06968618f, 0.24746864f, 0.03094433f, -0.10356663f, 
    0.08011276f, -0.02523790f, -0.09196801f, 0.00523213f, 0.03059157f, -0.10611831f, 0.10956188f, 0.06839950f, 
    -0.11427052f, 0.05707689f, -0.08495302f, 0.08196691f, -0.05160018f, 0.11978675f, 0.04385205f, 0.15358467f, 
    0.13829218f, 0.05989069f, -0.07028434f, 0.14033967f, -0.04645659f, -0.09604211f, 0.05283106f, 0.11248068f, 
    -0.20174231f, 0.16387570f, 0.09495030f, 0.01439585f, -0.03988814f, -0.02187290f, 0.14120704f, 0.00399092f, 
    -0.08088065f, -0.05333710f, -0.08075459f, 0.10831384f, 0.05471213f, -0.02374576f, 0.08310216f, -0.06025455f, 
    0.07295312f, -0.08565799f, -0.07849125f, -0.23404868f, -0.01014197f, 0.03216729f, 0.01071918f, -0.06425084f, 
    0.03069469f, -0.07142006f, -0.07296229f, -0.03119925f, 0.15704003f, -0.11951822f, -0.15032759f, 0.05152666f, 
    0.06418733f, 0.05565212f, -0.03090113f, 0.04330375f, -0.04493681f, 0.15155886f, -0.05000804f, -0.01187574f, 
    -0.05019956f, 0.09517484f, 0.01628689f, 0.03561414f, -0.13513546f, -0.11827249f, -0.15126839f, -0.02796152f, 
    -0.04774838f, 0.00122606f, -0.11122352f, 0.06806753f, 0.16515313f, 0.00640713f, 0.18609065f, 0.01171856f, 
    0.15504223f, 0.04388880f, -0.06043005f, -0.12981573f, 0.10483973f, 0.05216688f, -0.15637851f, -0.08295041f, 
    0.07768155f, -0.02264122f, -0.08715930f, 0.06746436f, 0.05955229f, 0.00765540f, 0.11149444f, 0.14916521f, 
    -0.16694497f, -0.02084007f, -0.44063812f, -0.16341318f, -0.00449067f, 0.05071824f, 0.12768096f, 0.07379647f, 
    0.12097372f, -0.39502087f, -0.12787756f, 0.20789520f, 0.08403414f, 0.04556767f, 0.01046383f, 0.01954573f, 
    -0.12343706f, -0.08776499f, -0.09542993f, -0.01742123f, -0.00750834f, 0.02894881f, -0.11779652f, -0.03617357f, 
    0.06401414f, -0.04884228f, 0.06298343f, -0.42881420f, -0.16625297f, -0.08271196f, 0.19922303f, 0.03328525f, 
    0.01139626f, 0.07722283f, -0.02888817f, -0.08511804f, 0.07336331f, 0.13510905f, 0.20143136f, -0.08603624f, 
    -0.11447293f, -0.06478728f, 0.06269648f, 0.09693483f, 0.07131030f, -0.06175131f, 0.04570838f, 0.08730751f, 
    0.08983567f, 0.01050696f, 0.10454453f, 0.01092248f, 0.00438881f, -0.02698123f, 0.17239086f, 0.05505076f, 
    -0.04325454f, -0.04478093f, -0.03306688f, -0.06987106f, 0.18385483f, -0.06124400f, 0.11723192f, 0.03112984f, 
    -0.22549018f, -0.03725750f, -0.08867995f, 0.01412057f, 0.03260491f, -0.03319499f, -0.09756640f, -0.14120792f, 
    -0.35073790f, -0.08261552f, -0.02093031f, 0.13103218f, -0.04812622f, 0.08004354f, 0.05475394f, 0.10786762f, 
    0.19215697f, -0.24198629f, -0.20493713f, 0.01301265f, 0.09752321f, 0.02485285f, 0.06100382f, 0.09262607f, 
    0.00787176f, -0.03791412f, -0.07717759f, -0.08565688f, -0.19213931f, -0.00747038f, 0.03074883f, -0.08110356f, 
    -0.00537500f, 0.10048592f, 0.02617932f, 0.04767125f, -0.10637051f, -0.07834515f, 0.03723173f, 0.15576988f, 
    -0.01988890f, 0.05712150f, -0.02040682f, 0.06256896f, 0.11550511f, 0.21987276f, 0.10125688f, -0.05340659f, 
    -0.01752254f, 0.06588984f, 0.08163096f, 0.04911966f, 0.08199850f, 0.17224228f, 0.08725461f, 0.07774394f, 
    0.06535954f, -0.01766905f, 0.05657063f, 0.13551761f, 0.03972008f, 0.01247310f, 0.02904186f, 0.03156600f, 
    0.02343891f, -0.10448874f, -0.10628839f, 0.13891429f, 0.08169872f, -0.10668413f, 0.01804497f, 0.04306423f, 
    0.19490235f, -0.09007468f, -0.04326988f, -0.07632267f, -0.14799611f, 0.09559741f, 0.08416282f, -0.00534351f, 
    0.22656234f, 0.12017010f, 0.15743667f, 0.04737497f, 0.03284026f, 0.18312334f, -0.02622404f, 0.00981877f, 
    0.06626398f, 0.02018588f, -0.15934183f, -0.05981455f, 0.06670432f, 0.07588833f, 0.16853224f, -0.08928937f, 
    -0.18231951f, -0.09295884f, -0.00184076f, -0.11572975f, -0.23327225f, -0.02853683f, 0.00725831f, -0.03744380f, 
    -0.03767607f, -0.01098146f, -0.00373066f, 0.07672176f, -0.00764203f, -0.00101333f, -0.04282914f, 0.06495249f, 
    0.08347111f, -0.03767972f, 0.02380785f, 0.10045139f, 0.11250545f, -0.01798888f, 0.04194543f, 0.07437664f, 
    0.03933465f, 0.09472627f, -0.11414277f, 0.11788647f, -0.11890554f, 0.13972868f, 0.11696981f, 0.22508766f, 
    0.04947564f, -0.11568473f, -0.09338742f, -0.05513336f, 0.03098934f, 0.03539153f, 0.02868628f, 0.03435772f, 
    -0.15369360f, 0.02054382f, -0.06198044f, 0.04387340f, 0.03911337f, 0.04762066f, 0.01948552f, 0.07381219f, 
    -0.00222448f, 0.06398612f, 0.08131063f, -0.00150627f, -0.04646594f, 0.01303866f, 0.01751739f, 0.00699945f, 
    -0.11542625f, -0.15731816f, 0.06065806f, -0.00031688f, -0.04753967f, -0.05287644f, -0.11670447f, 0.14427345f, 
    -0.01516222f, -0.19932719f, 0.13745244f, 0.04184548f, 0.02084131f, 0.02899974f, 0.03024608f, -0.03651433f, 
    -0.03249273f, -0.09270074f, -0.16661696f, 0.03315862f, -0.01027656f, 0.06987177f, 0.14573437f, -0.08604064f, 
    -0.12170751f, -0.12937970f, 0.21097721f, -0.17043103f, -0.13320354f, -0.08207255f, 0.01899790f, 0.10119627f, 
    -0.03902781f, 0.10338502f, -0.07307811f, 0.10030090f, -0.00943781f, -0.12280218f, -0.08755013f, 0.01865032f, 
    0.07464011f, -0.01386398f, -0.08122314f, -0.04641084f, -0.05030292f, -0.23378107f, -0.00423087f, -0.07520871f, 
    -0.11128855f, 0.00087326f, -0.06139621f, 0.06017932f, -0.00359557f, 0.15098920f, 0.09163650f, -0.04861544f, 
    -0.11862927f, 0.11517879f, 0.00282277f, 0.08003192f, 0.06699067f, -0.06186138f, -0.02026634f, 0.04020016f, 
    0.04041176f, 0.07532365f, 0.07162499f, 0.05010876f, -0.02670472f, -0.07751735f, -0.07654206f, -0.04336679f, 
    0.03358111f, 0.11966745f, -0.10932150f, 0.11772989f, -0.15120804f, -0.14158620f, 0.12263060f, 0.00683610f, 
    0.09878541f, -0.29870513f, 0.10624804f, -0.01203138f, 0.02595369f, 0.00173412f, 0.09025795f, -0.09584384f, 
    0.00096385f, -0.02779471f, 0.24402745f, 0.00184342f, -0.04814708f, 0.23784095f, -0.11298150f, 0.09679658f, 
    -0.04281301f, -0.04209014f, 0.01852617f, -0.30149502f, -0.05684122f, 0.00232391f, 0.15767939f, -0.04326849f, 
    -0.07973083f, -0.07465219f, -0.09250474f, 0.06284238f, 0.01584007f, 0.04153193f, -0.03370550f, -0.02642505f, 
    0.09413739f, -0.03601397f, 0.04740281f, -0.04858004f, 0.07712942f, 0.08052959f, 0.08161887f, -0.07341844f, 
    0.07948430f, -0.00258186f, 0.02950532f, 0.06818625f, -0.00006596f, -0.01433475f, 0.20497487f, 0.09368731f, 
    0.01753438f, -0.09531478f, -0.06887934f, 0.11448823f, -0.08421335f, 0.08336771f, -0.12723120f, -0.00988354f, 
    0.14805263f, 0.06210917f, 0.01231694f, -0.01278307f, 0.01778045f, -0.01737577f, -0.02889099f, 0.07559073f, 
    -0.06003766f, -0.42690915f, 0.04777827f, 0.10220215f, 0.04027057f, -0.08097952f, -0.00592215f, 0.04864273f, 
    0.06506220f, -0.16309211f, -0.05743413f, 0.03842906f, 0.02396784f, -0.11835860f, 0.05091354f, 0.01395341f, 
    -0.00026343f, 0.00925519f, 0.06239694f, -0.04406171f, -0.15864630f, 0.07261195f, -0.02760766f, -0.08679768f, 
    -0.04642056f, 0.16258980f, -0.04881922f, -0.34305415f, -0.04987531f, -0.07576004f, -0.15599658f, 0.07195191f, 
    0.03824723f, -0.04249401f, -0.06358298f, 0.00199232f, 0.19676347f, 0.11879270f, 0.19135340f, -0.17487644f, 
    -0.13596298f, 0.12515208f, 0.09145001f, 0.12373316f, -0.00443862f, -0.02477590f, -0.07001432f, 0.10397521f, 
    -0.00996696f, -0.06402101f, -0.14608465f, 0.13812609f, -0.10012884f, 0.05063108f, 0.01298815f, -0.10341304f, 
    0.06561071f, -0.01133696f, -0.09190650f, 0.01720521f, -0.18712190f, 0.03785275f, 0.08706457f, 0.14081591f, 
    0.08980259f, 0.11314549f, -0.19111444f, 0.00335700f, 0.05155553f, -0.03678306f, -0.04907297f, -0.03213024f, 
    -0.14234577f, 0.00078937f, -0.23485342f, 0.03474008f, 0.00287469f, 0.00293270f, 0.01585092f, -0.02923135f, 
    0.07557838f, -0.01538169f, -0.01045512f, -0.11007059f, -0.10562658f, 0.13140842f, -0.01764764f, 0.04462555f, 
    0.09644178f, -0.02170973f, -0.05894363f, 0.11670755f, 0.02503441f, 0.02080134f, 0.01326138f, -0.10686637f, 
    0.03790483f, -0.05560469f, -0.00334439f, 0.08565135f, -0.00487385f, 0.03393976f, 0.01022089f, -0.08686762f, 
    0.13322191f, 0.06218454f, -0.10660806f, 0.10042015f, -0.00672185f, -0.14618328f, -0.18693809f, -0.12187011f, 
    0.00688694f, 0.01483910f, -0.00979721f, 0.09636406f, -0.02936655f, 0.04211423f, 0.16284159f, -0.12762411f, 
    0.10649060f, 0.04204887f, -0.09171697f, 0.07294079f, 0.00283984f, 0.01147932f, -0.14137486f, -0.05016121f, 
    -0.10254882f, 0.04186273f, 0.12097053f, 0.10012020f, -0.04180923f, 0.00772579f, 0.06724501f, 0.09036085f, 
    -0.10822865f, -0.19843461f, -0.00624297f, 0.16970913f, 0.06978383f, -0.09274507f, -0.16738358f, 0.04290225f, 
    -0.15546691f, -0.05803464f, 0.00688938f, -0.08175358f, -0.06728446f, -0.04610140f, 0.08271988f, 0.03288415f, 
    -0.01082238f, 0.06506005f, 0.16666616f, 0.00700605f, 0.00232657f, 0.04649713f, 0.21179442f, 0.03403122f, 
    0.03663245f, -0.05226219f, -0.04393438f, -0.02074508f, 0.05468707f, -0.08734939f, -0.15545465f, -0.08165273f, 
    -0.12181961f, -0.05792811f, 0.07210887f, -0.12987192f, -0.06059956f, -0.01878626f, -0.11911616f, 0.16415703f, 
    -0.08958208f, 0.04816500f, -0.00083559f, 0.02148240f, -0.29117218f, -0.15161835f, -0.01596119f, 0.09437988f, 
    0.06200547f, 0.12291589f, -0.02040751f, -0.04050444f, -0.06192795f, -0.09300561f, 0.04222123f, 0.12687741f, 
    -0.07259128f, 0.07065315f, 0.04953117f, -0.05039262f, 0.02215282f, -0.01745119f, -0.09819603f, -0.24094366f, 
    -0.17584687f, 0.25268209f, 0.09332810f, 0.08788124f, 0.02419818f, -0.08669998f, -0.10019644f, -0.22790314f, 
    -0.11795999f, -0.29993439f, 0.13006948f, 0.00511277f, -0.10225635f, -0.05870011f, -0.14239457f, 0.06847882f, 
    -0.28192928f, -0.11320600f, -0.18354604f, 0.07600310f, 0.08423650f, -0.01078811f, -0.16340502f, 0.00763589f, 
    0.00120188f, 0.18027812f, 0.10470824f, 0.14768891f, -0.02697529f, 0.10452460f, -0.05669827f, 0.12932381f, 
    0.07113088f, 0.12507354f, 0.08863878f, -0.01712832f, -0.03372989f, 0.17690381f, 0.03324227f, -0.02518761f, 
    0.22193198f, -0.05015953f, 0.10299221f, 0.24993534f, 0.21259944f, 0.12872466f, -0.08793618f, -0.22334488f, 
    -0.13657972f, 0.20907936f, -0.07435353f, 0.06313007f, -0.17646384f, -0.16266693f, 0.05171558f, 0.12103488f, 
    0.07263138f, 0.02386070f, -0.04790184f, -0.08855037f, -0.07160887f, -0.11559355f, -0.14363474f, -0.19309387f, 
    -0.06206859f, 0.17242472f, 0.07899396f, 0.15007997f, 0.18700413f, -0.08314755f, -0.24494714f, 0.03562470f, 
    -0.14496158f, 0.18033580f, 0.08278664f, -0.04391350f, -0.14152145f, 0.09829427f, -0.00167922f, -0.08903719f, 
    -0.01733394f, -0.00157287f, -0.02414398f, 0.18253207f, 0.13032429f, -0.04779464f, 0.01146450f, 0.16036977f, 
    0.27503750f, 0.18548259f, 0.09439109f, -0.04991748f, 0.03642853f, -0.04715155f, 0.15270522f, 0.02680535f, 
    -0.12563451f, 0.28391758f, 0.17751664f, 0.16618489f, -0.17838277f, -0.00735150f, 0.03421953f, 0.07128210f, 
    0.03071688f, -0.01080180f, -0.07566304f, 0.00959940f, -0.07772793f, 0.14162160f, 0.03088791f, 0.04331252f, 
    0.07286897f, 0.10075861f, 0.21124136f, 0.17495522f, 0.09464766f, 0.15192737f, 0.09793375f, -0.08720854f, 
    0.06921201f, 0.05905226f, -0.00953925f, 0.01387744f, -0.09021440f, -0.11155601f, -0.15371284f, 0.02270550f, 
    0.07169237f, -0.14628312f, 0.02710313f, -0.11700681f, -0.13605523f, 0.01682025f, 0.04136347f, -0.05412757f, 
    0.25515234f, 0.15468611f, 0.06700365f, -0.05259484f, -0.07854820f, -0.10683001f, 0.13961668f, -0.07031454f, 
    -0.03408544f, -0.01255336f, 0.09382849f, 0.00261263f, -0.08384700f, 0.00752069f, -0.01755642f, -0.11519263f, 
    -0.12621517f, -0.10079969f, 0.17724004f, -0.01933942f, -0.09270687f, 0.07153381f, 0.05937129f, 0.05537140f, 
    -0.01399117f, -0.00637769f, -0.06041683f, 0.05756864f, -0.03782596f, 0.00042685f, 0.01839901f, 0.04733555f, 
    0.00214116f, -0.00983892f, -0.03153739f, -0.03247706f, -0.02193062f, -0.00099876f, 0.01504816f, -0.00131103f, 
    -0.02003773f, 0.01111400f, 0.01333976f, 0.01682813f, -0.06127077f, -0.04056682f, -0.05237560f, -0.04202961f, 
    0.04177340f, 0.00559215f, 0.04018364f, -0.02893601f, 0.01782074f, -0.04059746f, 0.04812984f, -0.00949214f, 
    0.02815277f, -0.05308681f, -0.02996134f, -0.01008894f, -0.04187959f, -0.01002504f, -0.02645591f, 0.01565732f, 
    -0.04558120f, 0.05315291f, -0.02842000f, -0.01630833f, 0.01417959f, -0.03987616f, 0.04700337f, -0.06638315f, 
    -0.00218914f, 0.02882764f, -0.02675802f, -0.00432064f, -0.04739307f, 0.02370554f, 0.01544329f, -0.05075698f, 
    -0.03900979f, -0.00270357f, 0.02642697f, -0.03537758f, 0.04442563f, -0.00528872f, -0.02217487f, -0.01134917f, 
    0.00772444f, -0.01705543f, 0.04522151f, 0.00417195f, -0.05787622f, 0.00087483f, -0.03321357f, 0.00119927f, 
    -0.00832685f, -0.00867214f, -0.00400822f, -0.04413449f, 0.04325030f, 0.04789426f, 0.05114377f, 0.00727975f, 
    -0.04784039f, -0.02141089f, 0.04583538f, 0.00668732f, 0.02106397f, -0.03026160f, -0.01418864f, 0.01104639f, 
    -0.04625373f, -0.00683331f, -0.01515703f, -0.05609913f, -0.01025972f, 0.03891229f, 0.04169357f, -0.00899291f, 
    -0.05516127f, 0.02366277f, 0.01579116f, -0.02569540f, -0.03233119f, -0.01580323f, 0.03192852f, 0.03352026f, 
    -0.02666965f, -0.02954696f, -0.05297147f, 0.05231823f, 0.02865102f, -0.03276264f, -0.05532143f, -0.06358960f, 
    0.04239035f, 0.01174282f, 0.03207516f, -0.05854165f, -0.04375461f, 0.00026423f, 0.00365360f, 0.04312064f, 
    0.05046757f, -0.05141849f, 0.03412230f, -0.02953959f, 0.00785382f, -0.02181810f, -0.05581307f, 0.01538918f, 
    -0.02643939f, -0.02109659f, -0.03182299f, 0.00072444f, 0.00044622f, -0.06367216f, 0.00129565f, 0.02750919f, 
    -0.05905343f, 0.01624919f, 0.00257734f, 0.00022573f, -0.03483361f, -0.03643697f, -0.02853961f, 0.04403503f, 
    0.02027613f, -0.05897548f, -0.01132658f, -0.02741838f, -0.05389789f, 0.00316247f, -0.04968633f, -0.05896313f, 
    -0.05639210f, -0.04249314f, -0.05597219f, -0.01039304f, 0.01604785f, 0.01293938f, 0.00647142f, 0.04297727f, 
    -0.03749676f, 0.04928417f, 0.01752212f, 0.03695251f, 0.04234242f, -0.04016975f, 0.02297377f, -0.04220613f, 
    -0.05182768f, 0.04307679f, -0.00361344f, -0.02111739f, -0.00477211f, -0.00347954f, 0.03388378f, -0.03287071f, 
    0.03975832f, -0.05118636f, -0.01373987f, 0.01981124f, -0.04136910f, -0.00085362f, -0.01541525f, 0.00406963f, 
    -0.00710149f, 0.02046996f, -0.00401891f, -0.02341115f, -0.00913380f, 0.02869797f, -0.02525072f, -0.05749819f, 
    0.03185687f, -0.06261705f, -0.06116254f, -0.04535330f, -0.01843157f, 0.02210927f, 0.01834261f, 0.03771488f, 
    -0.02120309f, 0.02756034f, -0.04774623f, 0.03349854f, -0.04106243f, 0.02448411f, -0.03244468f, -0.01526918f, 
    -0.03964148f, -0.04288530f, -0.02692839f, 0.02394310f, 0.01551033f, -0.02952649f, -0.03491455f, 0.03298777f, 
    -0.04822637f, 0.01518025f, 0.03036091f, 0.04077174f, 0.01301857f, -0.02158467f, 0.03853383f, 0.05099765f, 
    -0.01048375f, -0.01098401f, -0.04696130f, -0.06052511f, -0.04662238f, 0.04953838f, -0.00126216f, -0.04715068f, 
    0.03400855f, -0.04504265f, -0.00153217f, -0.03980370f, 0.02543760f, -0.03053746f, 0.04370014f, 0.00904345f, 
    -0.06433585f, -0.03113588f, 0.00344461f, 0.02851623f, -0.00444423f, -0.05357241f, 0.04604323f, -0.02931838f, 
    0.00355868f, -0.05826382f, -0.03629114f, -0.02086478f, 0.02158757f, 0.04241192f, -0.05854842f, 0.02140622f, 
    0.00531678f, -0.01890169f, -0.02501304f, -0.05984810f, 0.00126476f, 0.02602525f, 0.01237047f, -0.01971105f, 
    -0.05652765f, -0.03932546f, 0.02489376f, 0.00641538f, 0.04352456f, -0.00297637f, -0.04884879f, -0.06803850f, 
    -0.02717100f, -0.01163325f, -0.03841777f, -0.04986830f, -0.05532512f, 0.04038557f, -0.01635712f, 0.00303818f, 
    -0.06368756f, -0.02414578f, 0.01084358f, -0.05409234f, 0.02372253f, -0.02873831f, 0.03340823f, -0.06379535f, 
    -0.45775303f, -0.31121704f, 0.30299905f, 0.00002818f, 0.07588845f, -0.05338128f, 0.02497665f, 0.01893304f, 
    0.13172166f, -0.17171860f, 0.11157674f, -0.23652098f, -0.03179983f, -0.00276212f, 0.12341344f, -0.00758527f, 
    0.08042976f, 0.03667856f, -0.24766488f, 0.08154539f, -0.07266283f, -0.04143232f, 0.11824708f, 0.13350868f, 
    -0.03008541f, 0.02116923f, 0.04019099f, -0.09289897f, 0.10523355f, -0.02314516f, 0.00432473f, -0.04083284f, 
    0.05935118f, 0.12283646f, 0.00326831f, 0.04654820f, -0.28936052f, -0.10884639f, 0.08097832f, 0.02979739f, 
    0.04996183f, 0.09643497f, -0.02021752f, 0.06280800f, -0.12628412f, -0.24582280f, -0.24095337f, 0.12789792f, 
    -0.05564779f, 0.06327004f, -0.06738202f, -0.09711638f, -0.17090100f, 0.05569402f, 0.07422591f, 0.14084502f, 
    -0.05361966f, -0.07584421f, -0.00700811f, 0.06190918f, -0.05947973f, 0.12030087f, 0.01067146f, -0.30425993f, 
    -0.30868787f, 0.07844884f, -0.12488614f, -0.07296762f, -0.04245819f, -0.02355426f, -0.00635101f, -0.11779929f, 
    0.28749588f, -0.10920428f, -0.15372236f, -0.10207331f, -0.18253434f, 0.04018297f, -0.03041063f, -0.11858042f, 
    0.01334149f, -0.04949514f, -0.07402820f, -0.24735819f, 0.09216151f, 0.16314462f, -0.05710466f, -0.09711797f, 
    -0.07602552f, 0.04973346f, -0.19504037f, 0.01625148f, -0.16997293f, 0.02234753f, -0.07534372f, -0.04698626f, 
    -0.03190541f, -0.05092346f, 0.12156477f, -0.03274235f, -0.06626634f, -0.03724063f, 0.14935032f, 0.02740481f, 
    -0.04225911f, 0.07127656f, 0.04719977f, 0.11886850f, 0.31027237f, 0.02582708f, -0.23530154f, -0.00565410f, 
    0.01655622f, -0.10659546f, 0.08048788f, 0.11227835f, 0.07557166f, 0.01726613f, -0.00302412f, -0.10408122f, 
    -0.01894573f, -0.03318060f, -0.03058138f, -0.08355381f, -0.05483587f, 0.01641563f, 0.02340123f, 0.14584401f, 
    0.08341174f, 0.10500087f, -0.16649130f, -0.04249109f, 0.12812032f, -0.02220612f, -0.03268733f, 0.01356685f, 
    -0.18586908f, -0.23825017f, 0.00945623f, 0.06314368f, 0.01829178f, 0.07825047f, -0.08029958f, 0.13282011f, 
    -0.29270497f, -0.05362933f, -0.10164136f, 0.18917330f, 0.00458727f, 0.05298804f, -0.03353663f, -0.14821206f, 
    -0.02886369f, -0.07800686f, -0.03509397f, -0.03525477f, 0.03853114f, 0.15117350f, 0.09794299f, 0.03044539f, 
    0.05125837f, 0.16857579f, 0.01665653f, -0.18245910f, 0.05438118f, 0.03000068f, -0.16027290f, -0.05158569f, 
    0.02019503f, -0.00827433f, 0.15068816f, -0.11804693f, 0.03280814f, 0.11266550f, 0.14729668f, 0.08076862f, 
    0.14012893f, -0.06349178f, -0.04863700f, 0.02646720f, 0.11659196f, 0.03448431f, 0.07193783f, -0.05323170f, 
    -0.00739899f, 0.14111426f, 0.03200739f, 0.05279624f, 0.06879487f, 0.16922420f, 0.09983522f, 0.06121207f, 
    -0.04230158f, -0.07380255f, -0.00720439f, 0.06691503f, 0.12537254f, -0.04939986f, -0.19030420f, -0.16058369f, 
    0.04839978f, -0.03563660f, 0.04782527f, -0.14808527f, -0.09071883f, 0.09441303f, 0.00225210f, 0.07547347f, 
    0.02173373f, 0.20831490f, -0.13206047f, 0.12303228f, -0.00894096f, 0.24062763f, 0.02370702f, -0.02081159f, 
    0.02064545f, 0.03369999f, -0.01177529f, 0.12690359f, 0.06951735f, -0.09834549f, -0.01589537f, 0.04089284f, 
    0.08163924f, 0.16155538f, 0.14579901f, 0.11261787f, 0.06735140f, 0.01801346f, 0.05241923f, 0.13158508f, 
    0.08449556f, -0.03308219f, -0.07399310f, -0.18139866f, -0.00475968f, -0.02369011f, 0.11190227f, -0.08824579f, 
    0.07442606f, 0.12373219f, 0.05641204f, -0.11527269f, 0.04891278f, -0.05923475f, -0.03198097f, -0.04768326f, 
    -0.01310556f, 0.07230566f, -0.11723883f, 0.07869112f, -0.18175550f, -0.64958096f, 0.35160869f, -0.06567818f, 
    -0.17569251f, -0.03780407f, -0.05292260f, -0.13353859f, -0.01344314f, 0.02065979f, 0.04016589f, -0.06620001f, 
    0.00424459f, -0.04047685f, -0.10145949f, 0.08845381f, 0.07046280f, 0.05717907f, -0.03987159f, -0.09547818f, 
    0.03594207f, 0.14303757f, 0.04773515f, -0.05944211f, -0.00189780f, -0.01599270f, -0.00683112f, -0.01145713f, 
    -0.25166348f, -0.14569172f, -0.10073772f, 0.00090064f, -0.10604385f, 0.00167598f, -0.01418380f, 0.19294630f, 
    0.01824623f, -0.01411057f, -0.30485877f, -0.01779793f, 0.20577863f, 0.11600938f, 0.10375573f, 0.02871968f, 
    0.09621601f, -0.24675639f, 0.03823510f, 0.05285092f, 0.12417389f, 0.16691552f, -0.13446866f, -0.21053316f, 
    -0.00229521f, -0.00268303f, 0.06465240f, -0.13376728f, -0.01218201f, 0.00455083f, 0.01905318f, -0.02362833f, 
    -0.00889849f, -0.09947821f, -0.11441318f, -0.09422097f, -0.24476264f, -0.08861975f, 0.07843366f, 0.08670192f, 
    -0.22015008f, -0.01064951f, -0.02790644f, 0.16148096f, -0.17520134f, 0.01093300f, -0.06782638f, 0.04415413f, 
    0.01017067f, 0.04158457f, -0.08952903f, 0.00069333f, 0.01940052f, -0.08019058f, -0.01992645f, 0.10831936f, 
    0.14658397f, -0.26274034f, 0.12138452f, 0.05119477f, 0.13956018f, -0.06490715f, 0.12524992f, -0.03349890f, 
    0.13767236f, -0.06212117f, -0.04639247f, 0.12160725f, -0.07273503f, 0.06038259f, 0.03009438f, -0.14773946f, 
    0.02936021f, -0.11570127f, 0.08786462f, 0.02143827f, 0.08544765f, 0.05997636f, -0.00622476f, 0.07625239f, 
    -0.72746164f, -0.20239110f, -0.08099157f, 0.09176729f, 0.06731841f, -0.11891496f, -0.00033859f, -0.08692312f, 
    -0.15084940f, -0.17433091f, -0.05551609f, 0.08274066f, 0.00699287f, -0.03611654f, 0.04561254f, -0.16839156f, 
    -0.10275696f, -0.11041167f, -0.05809778f, -0.07487770f, -0.12448029f, -0.10764350f, -0.01643620f, -0.12705293f, 
    -0.24447666f, 0.02285699f, 0.03413216f, -0.02242300f, -0.17634508f, 0.12516090f, 0.10471079f, -0.02414883f, 
    0.00178473f, -0.08465924f, -0.00466137f, 0.11484790f, -0.20443310f, -0.02890138f, -0.16791914f, -0.09057990f, 
    -0.05140083f, -0.06242961f, -0.12569004f, 0.07145236f, 0.08853955f, -0.31780678f, -0.07903973f, 0.26412341f, 
    -0.02146364f, 0.12406911f, -0.02198038f, 0.01499658f, -0.02624157f, 0.14997636f, -0.08679651f, 0.04013268f, 
    -0.05842370f, -0.01392421f, 0.03141060f, -0.10659657f, 0.01356533f, 0.04023122f, 0.07625022f, -0.04143849f, 
    -0.00136099f, -0.06162364f, 0.02730371f, 0.13534229f, -0.10307980f, -0.10770182f, -0.06026260f, -0.01254968f, 
    -0.23079117f, 0.06378271f, -0.00740450f, 0.06273045f, 0.12836869f, 0.21899235f, -0.07454167f, 0.05494355f, 
    -0.09830705f, 0.06608385f, 0.03095369f, 0.11536530f, -0.04881165f, 0.11278518f, 0.17707621f, 0.13219646f, 
    -0.03290122f, -0.02125581f, 0.30837524f, 0.02001870f, -0.39019063f, -0.10663958f, 0.08361261f, 0.06454193f, 
    0.01528226f, 0.16060711f, 0.12303627f, -0.09236612f, -0.16603608f, 0.13069105f, -0.14930442f, -0.14099008f, 
    0.17169800f, 0.12223154f, -0.15934105f, 0.05440008f, -0.07280383f, 0.03099190f, -0.01586527f, -0.03019937f, 
    0.05945206f, 0.04348684f, 0.20061921f, 0.14705603f, 0.06192308f, -0.02008001f, -0.15030992f, -0.15430632f, 
    0.05720802f, 0.05936711f, -0.06506406f, 0.22929421f, -0.06398655f, 0.18809052f, 0.03502872f, 0.05041184f, 
    0.11911904f, 0.02112676f, -0.11020740f, 0.26859152f, 0.08483874f, -0.06781308f, -0.19446875f, 0.12228534f, 
    0.20460981f, 0.05246437f, -0.00681227f, -0.06162869f, 0.00558099f, 0.11666992f, 0.07980871f, -0.01547566f, 
    -0.03242144f, 0.01164985f, 0.15649830f, 0.00752627f, 0.00644551f, -0.01895116f, 0.00273712f, -0.02101665f, 
    0.28607723f, -0.12940773f, -0.08894363f, 0.26798388f, -0.06596744f, 0.08809678f, 0.03552397f, 0.12856710f, 
    0.12907448f, 0.10118108f, 0.09209848f, -0.00247897f, 0.07931584f, -0.02758256f, -0.02978549f, 0.01172826f, 
    -0.01446070f, 0.04917311f, 0.14844793f, -0.15999988f, 0.15965219f, 0.27926359f, 0.06334812f, 0.00923213f, 
    0.24474669f, 0.08297937f, 0.09709291f, 0.01365326f, -0.01461272f, 0.14437316f, -0.24146648f, -0.11695858f, 
    0.03349886f, -0.06358549f, 0.15105055f, -0.02603115f, -0.11429963f, 0.05813120f, 0.22916268f, 0.19711922f, 
    0.01855709f, -0.00562852f, -0.14225169f, 0.17071554f, -0.01685681f, 0.02342566f, -0.38543665f, -0.06798644f, 
    -0.16302808f, 0.15261641f, 0.01951045f, -0.04119675f, 0.00712666f, 0.03281555f, 0.06617855f, 0.19688854f, 
    0.19818391f, -0.06034333f, 0.03846529f, -0.05773040f, 0.11612484f, 0.00136341f, 0.09963202f, 0.02975739f, 
    -0.16401266f, -0.06038958f, 0.32298562f, 0.04292012f, 0.03621364f, -0.02477768f, -0.01135343f, 0.00673864f, 
    0.06904052f, -0.21083628f, -0.07214164f, -0.61167169f, 0.12083241f, 0.00971006f, 0.10970470f, -0.01418535f, 
    0.01966821f, 0.11820851f, -0.15844437f, 0.21432418f, -0.24739249f, -0.01778234f, 0.02048033f, -0.11845090f, 
    -0.09855448f, 0.05412396f, -0.07993896f, 0.15751061f, 0.04741384f, 0.05322432f, -0.07187987f, -0.03307639f, 
    0.01305374f, 0.06631605f, 0.11039908f, 0.04913935f, 0.02544201f, 0.08326004f, 0.02337278f, 0.04659135f, 
    -0.04416047f, 0.05472948f, 0.05104697f, -0.01444007f, -0.07899638f, -0.00514896f, 0.30299672f, 0.25724572f, 
    -0.04283552f, 0.09824366f, -0.15494439f, -0.00976798f, -0.02214500f, -0.09976880f, 0.08254372f, 0.01944142f, 
    -0.22037548f, -0.00775901f, -0.08270828f, 0.08705105f, 0.11445812f, -0.15431312f, -0.11194392f, 0.05900128f, 
    -0.07153105f, 0.21472616f, -0.10967117f, -0.01753658f, 0.14135472f, -0.09480086f, 0.04644072f, -0.08455847f, 
    0.22605534f, 0.04334527f, -0.08007867f, -0.03601499f, 0.10271348f, 0.06696516f, -0.01590806f, 0.07836741f, 
    -0.00042163f, -0.17464052f, -0.27178872f, -0.20467471f, 0.20056848f, 0.07570913f, -0.00093611f, 0.07402322f, 
    -0.02552558f, -0.00146542f, -0.05145438f, -0.12288723f, -0.07646738f, 0.13838317f, -0.07389802f, 0.00571146f, 
    0.08777355f, 0.08730274f, -0.01344685f, 0.02853893f, -0.00969641f, 0.12941638f, -0.08000636f, -0.02429820f, 
    -0.10386527f, -0.03657989f, 0.03691323f, 0.04725548f, 0.12990974f, -0.00366595f, 0.23942530f, -0.06755677f, 
    -0.05549764f, -0.05010170f, -0.00366666f, -0.04222391f, -0.12504454f, 0.13060312f, -0.02439167f, -0.18789674f, 
    0.06889255f, 0.01370967f, -0.05737137f, 0.02806970f, -0.10497725f, 0.16256693f, 0.31158394f, -0.04972346f, 
    -0.23454748f, 0.06491540f, -0.11204120f, 0.12265021f, -0.06002060f, -0.00866029f, 0.13877966f, 0.08827916f, 
    -0.18395680f, 0.09399610f, -0.13391913f, -0.02721952f, 0.00185341f, -0.01558899f, -0.10963518f, 0.02161153f, 
    -0.30164409f, -0.20910339f, -0.22609833f, 0.14724453f, 0.03386702f, -0.04434420f, 0.00501648f, -0.01742126f, 
    0.01335528f, -0.22008179f, -0.07441574f, -0.21173324f, 0.04421001f, 0.12672333f, -0.02000248f, 0.04724666f, 
    0.04847402f, 0.06359132f, -0.11851625f, -0.11968771f, 0.21934436f, -0.10294719f, -0.04917375f, 0.04671516f, 
    0.06227051f, 0.01940304f, 0.07764920f, -0.12174872f, 0.01754241f, 0.06608443f, 0.22859575f, -0.09083436f, 
    -0.07838108f, 0.01784814f, -0.04336115f, -0.03731811f, 0.21581148f, -0.04667796f, 0.17452018f, -0.01542058f, 
    -0.07845923f, 0.04996413f, 0.12404118f, -0.08322281f, 0.02665658f, 0.08614684f, 0.09837702f, 0.03781380f, 
    -0.17190070f, -0.12058353f, -0.04264759f, 0.08356413f, -0.01678634f, 0.12972370f, -0.06552249f, 0.13990143f, 
    0.01511392f, 0.05701392f, -0.12088274f, -0.05159992f, 0.10617417f, 0.04068496f, 0.04332850f, -0.15217935f, 
    0.01535457f, -0.20305724f, 0.02080307f, 0.00429504f, -0.02226406f, 0.03521755f, 0.06794348f, -0.05427779f, 
    0.09169751f, 0.05016468f, 0.09706751f, 0.13476822f, -0.06590053f, -0.12210359f, 0.10094258f, -0.05348369f, 
    0.07462885f, 0.08371449f, 0.07436430f, -0.01835817f, 0.02327396f, -0.01547159f, -0.05553883f, -0.02471977f, 
    0.06903934f, -0.00381937f, -0.08691549f, -0.17570262f, -0.28442916f, -0.04708022f, -0.08211353f, -0.04037727f, 
    0.06786836f, -0.06740972f, 0.10755516f, -0.03251914f, 0.17353719f, -0.01201421f, -0.01028226f, 0.03545439f, 
    -0.09802157f, 0.12427194f, 0.15266107f, -0.02244841f, 0.02658286f, -0.07201605f, 0.24053465f, 0.12001277f, 
    -0.08431876f, 0.01786104f, 0.00343446f, -0.03028359f, 0.15380338f, 0.12920401f, 0.07800305f, -0.00359893f, 
    0.05801794f, 0.02596954f, -0.03560751f, 0.03942315f, 0.07658370f, -0.00308346f, 0.01300846f, 0.07417253f, 
    0.09218464f, -0.11175671f, 0.11795506f, -0.01742761f, 0.05129326f, -0.02394416f, -0.14517908f, -0.22369395f, 
    -0.26053417f, 0.05202200f, -0.02251373f, 0.04091447f, -0.11125145f, -0.02881299f, -0.13656268f, 0.02659936f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00427664f, 0.00204172f, -0.00325843f, -0.02807479f, 0.04731645f, -0.03961864f, -0.04082501f, 0.04134557f, 
    0.04433480f, 0.04599156f, 0.03646840f, -0.00396328f, 0.01927804f, 0.03300251f, -0.03280703f, -0.04237295f, 
    -0.04133351f, 0.10596871f, -0.00422847f, -0.02049486f, -0.00912582f, 0.01415423f, -0.06502393f, -0.09223123f, 
    -0.00085275f, 0.04555367f, 0.01551003f, 0.00533306f, 0.00754156f, 0.18972097f, 0.11702336f, -0.03078800f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21744610f, 0.12918714f, -0.17341982f, -0.07250674f, 0.15609941f, -0.25207606f, 0.06453761f, 0.03947596f, 
    -0.18587507f, 0.29235259f, 0.37117460f, -0.12242843f, -0.25253168f, 0.11600658f, -0.09883815f, 0.29862612f, 
    -0.18042853f, 0.43294710f, 0.11456849f, -0.09413532f, -0.12211238f, -0.33561853f, -0.12145839f, -0.18597738f, 
    0.06918754f, 0.21737929f, 0.04223225f, -0.08156908f, 0.09214822f, 0.01791079f, -0.03832318f, 0.06950490f, 
    0.06263717f, 0.08654234f, -0.09446127f, -0.16283889f, 0.16177875f, -0.11935215f, 0.04946036f, 0.16614603f, 
    -0.18268980f, 0.23132682f, 0.03797682f, -0.10503073f, 0.32442924f, -0.09294615f, -0.12761734f, 0.01926788f, 
    0.01370863f, 0.31249407f, -0.15592195f, 0.15930486f, 0.26847431f, -0.13108996f, -0.14344685f, -0.37335920f, 
    0.01018902f, 0.01837954f, 0.20506136f, 0.21420257f, 0.14235203f, 0.09733751f, 0.18497670f, -0.17762220f, 
    -0.07361202f, 0.27379999f, 0.01037371f, 0.04853377f, -0.08198523f, -0.09592766f, 0.14832839f, 0.08533400f, 
    0.01236319f, -0.03753330f, -0.16122115f, 0.27052993f, 0.19240190f, 0.16189848f, 0.01116627f, -0.07915086f, 
    0.17411573f, -0.13710618f, 0.33604413f, 0.09998727f, 0.27406102f, -0.07499833f, 0.32453990f, 0.43277460f, 
    0.02922950f, -0.26085460f, -0.21874684f, -0.05454849f, 0.07182623f, 0.00509914f, -0.25427774f, 0.21553887f, 
    0.10856265f, -0.16785920f, 0.18613338f, -0.01350910f, -0.01229432f, 0.27012557f, 0.13003348f, 0.13484731f, 
    0.47761717f, 0.03195059f, 0.30801475f, -0.15887880f, -0.21385188f, 0.11404616f, 0.06276142f, -0.15737662f, 
    -0.17087899f, -0.24992841f, -0.20031334f, 0.07766289f, 0.16484120f, 0.21980716f, -0.06487801f, 0.27090842f, 
    0.00076700f, -0.00277305f, 0.12760015f, 0.08241085f, -0.02658317f, 0.22937854f, 0.18698995f, -0.31877747f, 
    0.09319784f, -0.15490533f, -0.13284746f, 0.09434537f, 0.14049286f, 0.16100827f, 0.14219218f, 0.16896054f, 
    0.43445280f, 0.03671568f, -0.16142881f, 0.01504549f, 0.08942284f, 0.06877748f, -0.14756237f, -0.20096447f, 
    -0.10950010f, -0.21815079f, -0.24208020f, 0.06611232f, 0.23598590f, 0.20984469f, -0.20541994f, 0.24466419f, 
    -0.00892327f, -0.24473733f, 0.14891794f, 0.40105820f, 0.00276784f, 0.05684484f, 0.12784074f, -0.16163944f, 
    0.09164695f, -0.17828937f, -0.16758783f, -0.01075084f, -0.12328123f, 0.13036810f, -0.06066217f, 0.17170854f, 
    -0.03646510f, 0.01895075f, -0.04365090f, -0.01547250f, -0.17695896f, -0.15489087f, -0.05613842f, -0.18514405f, 
    -0.08469584f, -0.03659024f, -0.14543918f, -0.00688665f, -0.12681998f, -0.16857207f, 0.06918032f, -0.02684083f, 
    -0.01248269f, -0.14000539f, -0.09767251f, 0.07853074f, -0.03669566f, 0.05111674f, -0.01296669f, -0.10721868f, 
    0.09590491f, -0.10574452f, -0.14160615f, 0.03773038f, -0.02892096f, -0.28240168f, -0.09285679f, -0.01181008f, 
    -0.06087086f, -0.07513494f, -0.12240559f, -0.19813469f, 0.04370962f, -0.11879666f, -0.04371102f, 0.19357632f, 
    -0.04039223f, -0.29734167f, -0.10808757f, 0.14590910f, 0.10021731f, 0.09589152f, 0.15223531f, 0.22984108f, 
    0.10839995f, 0.05194710f, -0.26657823f, -0.10217225f, -0.11794747f, 0.00428751f, 0.17681189f, -0.13855539f, 
    0.14005055f, 0.38427174f, 0.14140485f, -0.09481805f, 0.04513972f, -0.20687561f, 0.14543389f, 0.11386585f, 
    0.05039252f, 0.32753956f, 0.04561337f, -0.31619832f, -0.19203620f, -0.14479549f, -0.07508518f, 0.06388834f, 
    -0.07989729f, 0.26289862f, 0.04573759f, -0.04300653f, 0.11394134f, -0.10443942f, 0.11952680f, -0.10716182f, 
    -0.07440712f, 0.12267022f, -0.30989099f, -0.08436891f, 0.03994077f, -0.23957682f, -0.17803068f, -0.06460279f, 
    -0.22192323f, 0.15738675f, -0.02874633f, -0.07535708f, -0.00027582f, -0.00243017f, 0.12005829f, 0.04844590f, 
    0.36541408f, -0.00603316f, 0.19575469f, -0.05820781f, -0.18265700f, 0.10458643f, -0.05398653f, -0.06879116f, 
    0.03702726f, -0.18916821f, 0.06221925f, 0.18250324f, 0.04568034f, -0.08610903f, 0.41066927f, 0.18400346f, 
    0.13621596f, -0.08148762f, -0.05884942f, -0.01304576f, -0.05321350f, -0.37381822f, 0.23181294f, 0.10990336f, 
    0.08743078f, 0.29609674f, -0.07385567f, 0.11008350f, -0.00712943f, 0.09947158f, 0.00864160f, -0.04884234f, 
    -0.05497526f, -0.17178567f, 0.21455960f, 0.26705146f, -0.20559120f, 0.01017854f, 0.15038460f, 0.46547940f, 
    -0.07014147f, 0.08312790f, 0.29159835f, -0.08145105f, 0.05602149f, 0.00966225f, 0.15890522f, 0.03087798f, 
    -0.07101154f, 0.07686388f, 0.22135048f, -0.36297947f, 0.10360777f, -0.01903293f, 0.12164393f, 0.16508089f, 
    0.22470601f, -0.12184325f, 0.14360563f, -0.00498125f, 0.03249218f, 0.34535563f, -0.16338517f, 0.09821118f, 
    0.27226171f, -0.01798748f, -0.22734804f, 0.39643428f, 0.34028319f, 0.07641102f, 0.04469115f, -0.35711849f, 
    -0.03220450f, -0.16648763f, -0.26165727f, 0.13480890f, -0.21172132f, 0.07550079f, -0.15815979f, 0.30714211f, 
    -0.03197310f, -0.19834222f, -0.05372949f, 0.27054557f, -0.15262714f, 0.17711718f, 0.00460728f, 0.25931093f, 
    -0.16231552f, -0.18505213f, 0.04850874f, 0.12363923f, -0.12324515f, 0.37707502f, -0.03675999f, -0.05636166f, 
    0.01983515f, 0.14376085f, 0.11952415f, 0.18134935f, 0.11573653f, -0.03240552f, -0.09829331f, -0.04611483f, 
    0.08200792f, -0.22063839f, 0.13129449f, 0.07660777f, 0.34319884f, -0.41744962f, -0.19573322f, 0.07637911f, 
    0.06067480f, -0.07813662f, 0.31381503f, 0.04761641f, -0.03200516f, 0.42120332f, 0.22863224f, -0.24961330f, 
    -0.12996574f, 0.18569423f, -0.03887434f, -0.15510547f, -0.05030534f, -0.07922434f, -0.17398351f, 0.09403373f, 
    0.07505622f, 0.20844328f, 0.12771812f, -0.45103586f, -0.24499883f, -0.04932718f, -0.05643535f, 0.22529395f, 
    -0.04935868f, 0.02847379f, 0.07608420f, 0.14659278f, -0.03370208f, -0.31212741f, -0.12274781f, 0.04580238f, 
    -0.07339986f, 0.02699272f, -0.07092986f, 0.30930626f, 0.10544231f, 0.14684351f, 0.12417238f, -0.29274651f, 
    0.07281043f, -0.06795287f, -0.00747538f, 0.08126104f, 0.15542538f, -0.17146851f, -0.01342265f, 0.11082324f, 
    -0.29448915f, 0.29675353f, 0.22251682f, -0.08387935f, 0.14618079f, 0.01140675f, 0.08552133f, -0.48089683f, 
    -0.15452343f, 0.29455027f, -0.12432262f, -0.11424104f, 0.28949046f, -0.50094479f, 0.25716051f, -0.09132137f, 
    0.19821325f, 0.21467496f, 0.00231822f, -0.16536786f, -0.04884855f, 0.17353421f, -0.05815508f, 0.22245367f, 
    -0.03602410f, 0.10446680f, 0.02597948f, 0.09817071f, 0.07688566f, -0.07737212f, 0.15741731f, 0.06764309f, 
    -0.19922322f, -0.20076059f, -0.06904916f, 0.08092388f, 0.09776801f, 0.11786829f, -0.15710442f, 0.08108877f, 
    -0.08346335f, -0.09223660f, -0.03648619f, -0.16230741f, -0.00250220f, 0.11635184f, -0.12048837f, 0.00356112f, 
    0.09905898f, -0.08912095f, -0.13094664f, -0.18114695f, -0.09970637f, -0.16428860f, -0.08790649f, -0.01632360f, 
    0.25158232f, 0.00762505f, -0.00817975f, 0.17396824f, -0.03820846f, 0.05594629f, -0.14359024f, 0.12071040f, 
    0.00772248f, -0.19066595f, 0.39254168f, 0.21049632f, -0.22962528f, -0.00535139f, -0.12852800f, 0.36053041f, 
    -0.03076858f, -0.01936194f, 0.33801547f, -0.06059910f, 0.16561104f, -0.06909975f, -0.02303793f, 0.00302629f, 
    -0.21004820f, 0.29780537f, 0.06117386f, -0.14134087f, 0.10795905f, 0.29321480f, 0.15272394f, -0.19517784f, 
    -0.19594349f, 0.13546944f, 0.00048785f, 0.10279650f, -0.09165188f, 0.00442527f, -0.09489757f, -0.08739091f, 
    0.03058229f, -0.25101110f, 0.11934121f, -0.06498717f, -0.26436129f, 0.08325823f, 0.00923440f, 0.14427377f, 
    0.14966722f, -0.13097669f, 0.47541189f, -0.06932843f, 0.09884841f, 0.17667171f, 0.50109094f, 0.25488746f, 
    0.32861832f, 0.03102476f, -0.03447689f, 0.15835042f, 0.15980414f, -0.40440094f, 0.32800040f, -0.02112447f, 
    0.10451330f, 0.22257347f, -0.09066428f, 0.13058345f, -0.04480617f, 0.07120358f, 0.17079119f, -0.06938633f, 
    0.13483886f, -0.14509611f, 0.24695466f, -0.01960669f, -0.14556201f, -0.16473381f, -0.08761399f, -0.23961768f, 
    -0.00449219f, 0.05902423f, 0.09589375f, 0.09009139f, 0.13385084f, -0.28348812f, 0.30634102f, 0.20692666f, 
    -0.06648514f, 0.41109139f, 0.09580762f, -0.38420904f, 0.16127111f, 0.14774592f, 0.18319592f, 0.16235296f, 
    0.10414875f, 0.21643254f, -0.07074536f, -0.06682929f, 0.09615588f, -0.37300429f, -0.14772493f, 0.16227451f, 
    0.17282589f, -0.01088596f, 0.01381829f, -0.29598635f, 0.20946893f, 0.05061455f, -0.12522747f, 0.02444834f, 
    0.12682393f, -0.09944791f, -0.08724497f, -0.02918665f, -0.13695259f, 0.05289403f, 0.02328300f, 0.06728493f, 
    0.49053785f, -0.22276627f, -0.30888554f, 0.49965465f, -0.02990964f, -0.55084270f, 0.10481466f, -0.10024749f, 
    -0.11265521f, 0.29620299f, 0.11970379f, 0.17665921f, 0.12727307f, -0.09360687f, 0.17524701f, -0.04716728f, 
    0.01356965f, 0.19595946f, 0.10683221f, 0.16889881f, 0.04490592f, -0.08372774f, 0.06431478f, 0.20651628f, 
    -0.05638332f, 0.09015180f, -0.05045650f, -0.07674586f, 0.39872211f, -0.14740531f, 0.23743267f, -0.13889307f, 
    -0.13533258f, -0.25824893f, 0.09091893f, -0.23825428f, -0.15447530f, 0.45194018f, 0.01380666f, -0.28194249f, 
    -0.15121010f, 0.17121027f, 0.04583844f, 0.13303453f, -0.03470321f, 0.21249452f, 0.01621179f, -0.02368267f, 
    0.17480226f, 0.24894364f, 0.19982561f, -0.22001031f, -0.03550129f, -0.07262734f, -0.17612742f, -0.36038029f, 
    -0.10676676f, -0.29482514f, -0.00602010f, -0.14328976f, 0.12714446f, -0.04997871f, 0.16079535f, 0.23894475f, 
    0.28009859f, -0.19206476f, -0.29573312f, 0.35385916f, 0.03113198f, -0.07169504f, 0.01282111f, -0.07196140f, 
    -0.03699977f, 0.05910393f, 0.11367973f, -0.07054469f, 0.14783382f, 0.12840669f, 0.06202674f, -0.11329921f, 
    -0.16952018f, 0.22039604f, 0.44765586f, 0.04565021f, -0.01764919f, -0.03195159f, -0.00209128f, 0.06050835f, 
    -0.00562078f, 0.04583285f, 0.16363123f, -0.12564296f, 0.22388247f, -0.37988481f, 0.33116731f, -0.17694005f, 
    0.04897153f, -0.16173033f, -0.17430608f, -0.00861695f, -0.01204942f, -0.07636765f, 0.13992952f, -0.09702402f, 
    0.26175752f, 0.02745328f, -0.10187266f, 0.02901547f, -0.13592196f, 0.00391001f, -0.10171710f, -0.03867319f, 
    0.02606441f, -0.08065169f, 0.08299997f, 0.05585114f, -0.16099185f, -0.11181864f, 0.11030753f, -0.21346043f, 
    0.12452440f, 0.02446847f, 0.14796187f, -0.02318780f, -0.08506573f, 0.20179901f, -0.02264000f, 0.00641316f, 
    0.15862074f, 0.31494316f, 0.29394877f, -0.18803349f, -0.09276468f, -0.12543567f, -0.17362568f, -0.24630430f, 
    0.12921168f, 0.24766316f, 0.11074058f, 0.09649600f, -0.13698596f, 0.06200339f, -0.06899121f, 0.15892261f, 
    -0.07015260f, 0.02263744f, 0.34235173f, -0.01883497f, -0.26876140f, 0.17523786f, -0.01064421f, -0.27141714f, 
    -0.04058847f, -0.00744804f, -0.26643932f, 0.03319945f, -0.24151142f, 0.02115070f, -0.18216445f, 0.06056837f, 
    -0.18060321f, 0.22425129f, -0.19815180f, 0.10046216f, 0.12337511f, 0.59031004f, 0.15701871f, 0.07785728f, 
    -0.15909477f, -0.03118821f, -0.16038248f, 0.13676852f, 0.12943728f, -0.09124660f, 0.11455184f, -0.01179321f, 
    0.03067516f, -0.12057431f, -0.07657166f, 0.06210572f, -0.17748415f, -0.06404102f, 0.03865631f, -0.09746436f, 
    -0.06628664f, 0.15506752f, -0.14625926f, 0.09393978f, -0.03007868f, -0.10401431f, -0.01299895f, 0.03353073f, 
    -0.00083619f, 0.02096260f, -0.12931342f, -0.14873941f, -0.04428544f, 0.07188847f, 0.10900903f, -0.04375488f, 
    -0.23766208f, 0.00042114f, -0.10110267f, 0.17430158f, 0.14606018f, 0.23019789f, -0.11115104f, 0.11200894f, 
    0.17085734f, 0.16496880f, 0.16090332f, 0.10510009f, -0.29594299f, -0.02619543f, -0.04576182f, 0.17844966f, 
    -0.10819782f, -0.03236690f, 0.16302085f, -0.11845049f, 0.24163252f, -0.15464494f, 0.22769554f, 0.06161308f, 
    -0.15799741f, -0.13455966f, 0.03881468f, 0.14632897f, -0.08920185f, -0.12958919f, 0.20367102f, -0.20057817f, 
    -0.17460293f, 0.32499880f, -0.07847287f, -0.00066158f, 0.18071282f, -0.21806765f, 0.02880549f, 0.07559186f, 
    0.38487756f, -0.14020050f, -0.06020191f, -0.06723678f, -0.22477332f, 0.00285835f, -0.13725728f, 0.02696767f, 
    0.03225193f, -0.11395434f, 0.08705097f, 0.13197160f, 0.37832412f, 0.33131182f, 0.14632455f, 0.41024110f, 
    0.18883742f, -0.10685107f, -0.26622006f, 0.19875094f, -0.03568753f, -0.15605608f, -0.05575051f, 0.00944917f, 
    -0.03395806f, 0.25594324f, 0.09793689f, 0.05042343f, 0.08772324f, -0.35338774f, -0.03993258f, -0.07555307f, 
    0.12829065f, 0.03968709f, 0.15861027f, -0.28971726f, -0.20770942f, -0.14657880f, -0.15857863f, 0.13808930f, 
    0.03072996f, 0.31089538f, 0.35920551f, -0.15895821f, 0.06593042f, -0.03044617f, 0.33286414f, -0.34437782f, 
    0.21040051f, 0.18245253f, 0.16733119f, -0.10796761f, -0.13726723f, -0.26888609f, 0.06308643f, -0.23397781f, 
    0.18099746f, -0.22882926f, -0.10142678f, 0.18418989f, 0.03181478f, 0.25401202f, -0.07676772f, 0.16716819f, 
    0.30436614f, -0.22912030f, 0.05961038f, 0.20948820f, -0.01901060f, -0.01330546f, 0.13966079f, -0.12289996f, 
    0.12565210f, 0.16778803f, -0.12094224f, 0.13172933f, -0.07478124f, 0.15347794f, 0.04236723f, -0.10387792f, 
    0.20531096f, 0.23370808f, 0.17356107f, -0.08383298f, -0.13168399f, -0.03854283f, 0.25491464f, -0.06375405f, 
    0.35465005f, -0.01880484f, 0.00196531f, 0.09335975f, 0.02012909f, 0.35200649f, -0.03772425f, 0.06144825f, 
    0.35608196f, 0.27308953f, -0.24994563f, -0.08555394f, -0.03513628f, 0.09655024f, -0.02340149f, 0.11095054f, 
    0.02933829f, -0.17942907f, -0.05977255f, 0.04753638f, -0.09085678f, 0.11027275f, -0.37422252f, 0.37987921f, 
    -0.00806786f, 0.09979598f, 0.06430780f, 0.13371892f, 0.00132197f, 0.36240163f, -0.18582885f, 0.06610790f, 
    0.36137262f, 0.06621046f, 0.14837831f, -0.10149318f, 0.00967189f, 0.24827011f, 0.02610017f, 0.11382016f, 
    0.07074459f, 0.09124415f, 0.40063375f, 0.14170155f, -0.25090981f, 0.10951938f, 0.14577632f, 0.26396787f, 
    0.12959787f, 0.19375372f, -0.13925429f, 0.00485847f, -0.38052428f, 0.19012313f, -0.08614833f, -0.16156796f, 
    -0.14734766f, 0.34231740f, 0.18800104f, -0.14821641f, 0.15246552f, 0.51637179f, 0.09329221f, 0.13378896f, 
    0.08613108f, -0.08359731f, 0.11640443f, 0.05548494f, 0.06190980f, -0.05742820f, 0.05589407f, -0.14478511f, 
    -0.19679731f, 0.26632294f, 0.19315740f, -0.16780816f, 0.21552151f, -0.15755689f, -0.10403252f, -0.31729677f, 
    -0.16540608f, 0.21095139f, -0.08865349f, 0.12956652f, 0.04489779f, -0.39214626f, 0.30147153f, -0.10392477f, 
    0.31912604f, -0.21729062f, -0.35006154f, 0.11610549f, -0.13075471f, -0.01248261f, 0.01960487f, 0.26176441f, 
    -0.16990960f, 0.23378748f, 0.04297912f, 0.03462951f, 0.02780633f, 0.27135581f, 0.10009356f, 0.04384079f, 
    -0.00538470f, 0.03987589f, -0.19590081f, 0.12202848f, 0.18507673f, -0.05561972f, 0.17006932f, 0.13492019f, 
    -0.10053044f, 0.00630623f, 0.27917242f, 0.13837385f, 0.34159172f, -0.16095778f, 0.16471022f, -0.11656449f, 
    -0.25651604f, 0.11273617f, 0.31410530f, -0.22608496f, 0.03452828f, 0.45976964f, -0.20164299f, 0.43211687f, 
    -0.10303436f, 0.36112991f, -0.12576240f, -0.16599736f, 0.08059556f, -0.17331181f, -0.03777489f, -0.08198524f, 
    -0.07592101f, 0.01291107f, 0.18358183f, 0.01282475f, -0.02573922f, 0.12866084f, 0.01761543f, 0.14819691f, 
    0.01303961f, -0.06410962f, 0.45774028f, -0.14190976f, 0.34873334f, -0.02344436f, 0.38890526f, 0.17544262f, 
    -0.05262930f, -0.17721863f, -0.28765699f, -0.08557680f, 0.17555708f, -0.23600011f, 0.07877328f, -0.00678394f, 
    -0.01600040f, -0.03760238f, -0.00786484f, -0.09708815f, 0.07929108f, -0.14009255f, -0.01037343f, 0.02844784f, 
    0.06850166f, -0.05022093f, -0.09141385f, -0.05033541f, 0.07787414f, -0.15536234f, -0.08600660f, -0.17613778f, 
    -0.14817454f, -0.13088015f, -0.04166145f, -0.13522790f, -0.01164800f, -0.14250587f, -0.09299942f, -0.04668954f, 
    0.01000392f, 0.08145780f, -0.03218852f, -0.17690299f, -0.14543194f, -0.06662773f, 0.05732958f, -0.01449919f, 
    -0.21088506f, 0.03596487f, 0.17080063f, 0.16879833f, -0.14761186f, -0.11930127f, 0.09935955f, 0.00943890f, 
    0.25994569f, -0.13499515f, -0.28573570f, -0.18629079f, 0.06537122f, 0.01268615f, 0.15961769f, -0.31138530f, 
    -0.01468368f, 0.15487871f, 0.04830188f, 0.12371010f, -0.11068220f, 0.44145888f, -0.08686551f, 0.03235252f, 
    0.26018855f, 0.24236177f, 0.17060016f, 0.22270443f, -0.12526454f, -0.36392042f, 0.12636681f, 0.30247533f, 
    0.11118527f, 0.11139635f, 0.02076190f, -0.10298712f, 0.01459832f, 0.28020868f, -0.05001916f, 0.15073745f, 
    0.16414087f, -0.00450246f, 0.16718775f, -0.11441322f, -0.04721562f, -0.08687683f, 0.00908324f, -0.37788048f, 
    0.08421386f, -0.05891414f, -0.14864080f, 0.03240874f, 0.06793819f, -0.28190488f, 0.07249870f, 0.30681607f, 
    -0.15058187f, 0.34145424f, -0.33145922f, -0.04249351f, -0.00924699f, 0.17817605f, -0.02932928f, 0.45962006f, 
    0.18930578f, 0.37454867f, 0.12369455f, 0.11317402f, -0.02407314f, -0.38851228f, 0.07058666f, -0.13802387f, 
    -0.27282679f, -0.16449796f, -0.12096027f, -0.18244837f, 0.06457181f, -0.12895994f, -0.16604693f, -0.36618504f, 
    -0.08508763f, 0.23530516f, -0.04180543f, -0.01632002f, 0.32699615f, -0.08945591f, -0.16396724f, 0.16211712f, 
    -0.11773632f, -0.09698664f, -0.38522837f, 0.01029098f, -0.04035769f, 0.13055487f, -0.24699205f, 0.46086529f, 
    -0.00360994f, 0.38726914f, -0.02490632f, -0.07162072f, 0.06550195f, -0.19840972f, -0.04574699f, 0.14758773f, 
    -0.02449395f, 0.19294658f, 0.00115727f, -0.00258738f, 0.09808140f, -0.13732913f, -0.03617796f, 0.17394769f, 
    0.06983350f, -0.21360798f, 0.09089794f, 0.04705146f, 0.14011797f, -0.44003120f, 0.28448147f, 0.18700866f, 
    -0.07672924f, -0.24624921f, -0.20860486f, -0.04828538f, -0.15469846f, -0.04236775f, 0.06675883f, 0.31727442f, 
    0.19210143f, 0.03165011f, -0.06210747f, -0.15476356f, 0.08611433f, -0.13216151f, -0.02818674f, 0.10769586f, 
    0.16746394f, -0.07697304f, -0.23501830f, -0.49316436f, -0.19940789f, 0.03207649f, -0.08219544f, 0.24985367f, 
    0.07532440f, 0.18806782f, 0.08065259f, -0.14908634f, 0.10574823f, 0.20274726f, -0.36283308f, -0.11567180f, 
    0.17927930f, 0.25630733f, 0.03573410f, -0.08733868f, 0.00097947f, 0.29431266f, 0.02117399f, -0.00802597f, 
    0.03395028f, -0.17949022f, -0.01278666f, 0.13486195f, 0.02150013f, 0.31554899f, -0.08593426f, -0.04487114f, 
    0.41163918f, 0.06939873f, -0.15885614f, -0.06051566f, 0.02965429f, 0.11260169f, 0.13040479f, -0.04210747f, 
    -0.09812243f, -0.26419553f, 0.09995938f, -0.13528381f, -0.06006126f, -0.03957906f, -0.19286725f, 0.16016018f, 
    -0.13032755f, -0.06945799f, 0.20527889f, 0.37935302f, 0.13761908f, 0.11877701f, 0.23278472f, 0.10472614f, 
    -0.08175445f, -0.03616478f, 0.10265054f, -0.14079489f, 0.01535075f, 0.16560543f, 0.04142744f, 0.04013805f, 
    0.34366944f, -0.17019261f, 0.07118148f, 0.24599302f, 0.00324904f, -0.09000599f, -0.03698114f, 0.00623607f, 
    0.16074428f, 0.11913951f, 0.16202775f, -0.00149592f, -0.08440010f, -0.07384598f, 0.05901069f, -0.21139766f, 
    -0.25251785f, 0.26810244f, 0.34026951f, -0.14145425f, -0.05977862f, 0.03243148f, 0.37716761f, 0.32433325f, 
    -0.09920780f, -0.17022836f, -0.12027776f, -0.00331166f, 0.04379880f, 0.02654591f, 0.11502469f, -0.10809212f, 
    0.04709506f, 0.13641112f, 0.11698631f, -0.05444100f, 0.31033194f, -0.10653008f, 0.14420100f, -0.40024513f, 
    -0.05885873f, 0.11595283f, -0.25833097f, 0.10539939f, 0.38668489f, -0.26552656f, 0.09729925f, -0.15028737f, 
    -0.14871810f, -0.10413630f, 0.13712548f, 0.32168996f, 0.02640782f, 0.30308837f, 0.17814974f, -0.20348004f, 
    -0.12816806f, -0.08042817f, -0.15733518f, 0.04273870f, 0.01793955f, -0.11162715f, 0.08743376f, -0.02475602f, 
    0.29433084f, 0.04948518f, -0.35381749f, -0.13803783f, 0.16759995f, -0.02727771f, 0.09135616f, 0.01155271f, 
    -0.07887739f, -0.11851840f, -0.05836716f, 0.05093571f, 0.30209425f, -0.10965294f, -0.13643430f, 0.34989917f, 
    -0.23458858f, -0.21960074f, 0.13637441f, 0.45818040f, 0.11527808f, 0.23828584f, 0.16171233f, 0.20927529f, 
    0.06636916f, 0.07781094f, 0.13319737f, 0.07200251f, -0.12382723f, 0.07030938f, -0.17368567f, 0.04339766f, 
    0.21968859f, 0.10092459f, -0.38618255f, -0.01682193f, 0.12129092f, -0.12023778f, -0.13663936f, -0.15185295f, 
    -0.09408234f, -0.33651933f, 0.05207188f, 0.12869035f, 0.37776479f, 0.09462983f, 0.10771101f, 0.35286000f, 
    -0.38489631f, -0.07878181f, 0.28273848f, 0.04842570f, -0.05469923f, 0.46080929f, -0.00247406f, 0.34070888f, 
    0.32015082f, 0.01633792f, 0.00708820f, -0.11111071f, -0.03019340f, 0.06076026f, 0.01589531f, 0.02785478f, 
    -0.32291263f, 0.30382556f, 0.15431124f, 0.22949003f, 0.26447114f, 0.07812397f, -0.13897388f, 0.10197920f, 
    0.06204085f, 0.37598601f, -0.33365411f, -0.15820076f, -0.06670441f, -0.19110647f, -0.24144818f, -0.15422994f, 
    -0.31854954f, 0.28963917f, -0.02920199f, -0.20863168f, 0.17532776f, 0.28177741f, 0.09046465f, 0.15665765f, 
    0.08193500f, 0.17313685f, -0.10785739f, -0.05960960f, 0.16585834f, -0.28816289f, 0.00990230f, 0.13272339f, 
    -0.07927230f, 0.11847471f, 0.28501573f, -0.08816103f, -0.11097275f, -0.03848947f, -0.06027856f, 0.07041292f, 
    -0.07189035f, 0.30894741f, -0.00903090f, 0.09079105f, -0.14345333f, -0.32195032f, 0.23951191f, -0.25255707f, 
    0.33636487f, 0.05666915f, -0.15237743f, 0.16177945f, -0.12638400f, -0.50545919f, 0.28746659f, -0.18456979f, 
    0.09219701f, 0.11354596f, -0.02443855f, -0.08842902f, -0.10530666f, 0.07383593f, -0.16269068f, -0.03749374f, 
    -0.12036049f, 0.01045362f, 0.09938030f, -0.12549867f, 0.00505277f, -0.13266057f, 0.02313472f, 0.34093815f, 
    -0.02260845f, -0.05306213f, 0.09450651f, -0.13876291f, -0.03988591f, -0.35104534f, 0.12115522f, -0.06222362f, 
    0.30039549f, -0.14585422f, -0.06259618f, 0.18975008f, -0.02036567f, -0.19287731f, 0.33492565f, -0.31996658f, 
    0.22664317f, -0.23417957f, 0.11311901f, -0.16826336f, -0.16045375f, 0.22099024f, 0.13753293f, -0.05005977f, 
    0.21342067f, 0.16143748f, -0.19213778f, 0.06679772f, -0.00406435f, -0.03189249f, 0.02329863f, -0.00415671f, 
    -0.01099449f, -0.04976315f, -0.17857608f, 0.15570785f, 0.04979985f, 0.30449194f, -0.29430121f, 0.16511573f, 
    0.05576208f, -0.02002198f, 0.29002818f, -0.06977551f, 0.02581695f, 0.05718326f, -0.06293266f, -0.00755755f, 
    0.05405872f, -0.02747599f, 0.04936662f, 0.09817982f, -0.06548006f, -0.13657495f, -0.05833155f, 0.02338611f, 
    -0.09480926f, 0.25475994f, 0.19825058f, -0.02470239f, 0.02261391f, 0.10004329f, 0.15684891f, 0.27405480f, 
    0.15005568f, 0.13917093f, -0.02418409f, 0.08245806f, 0.16606098f, -0.31099021f, -0.07392812f, -0.23362236f, 
    -0.25400886f, 0.20283537f, 0.15860298f, 0.08418281f, 0.07892481f, 0.25147814f, 0.18477222f, -0.25306836f, 
    -0.27661180f, -0.00907933f, -0.03126570f, 0.00524865f, 0.15116335f, -0.10313088f, -0.04697683f, 0.02123594f, 
    0.25375339f, 0.05521559f, 0.02890547f, 0.01392672f, 0.25527492f, -0.11757512f, 0.03564277f, -0.15118603f, 
    -0.17079195f, -0.13719361f, 0.03828932f, 0.17828898f, 0.47538647f, -0.29354364f, 0.18406466f, -0.19575849f, 
    -0.19837381f, -0.25667048f, 0.37863737f, 0.20210871f, -0.13198647f, 0.49549562f, 0.35867146f, -0.22106409f, 
    0.21063967f, 0.08663189f, 0.03980413f, 0.03542218f, -0.02543649f, 0.02891643f, 0.01498596f, -0.12183667f, 
    0.28417552f, -0.14648773f, -0.39643914f, -0.09328148f, 0.00057581f, -0.16988362f, 0.02958884f, 0.32247463f, 
    0.05691599f, 0.16400889f, 0.03142912f, 0.00652631f, -0.10675484f, 0.34268114f, -0.34212798f, -0.00805603f, 
    0.02811758f, 0.25137988f, 0.24990606f, -0.07525385f, 0.12397597f, -0.08278445f, 0.23564187f, 0.07796188f, 
    0.04549590f, -0.02117262f, 0.15913375f, -0.06386620f, -0.11205834f, -0.26545078f, -0.09700713f, 0.05228366f, 
    -0.08521599f, 0.00891911f, -0.15872395f, 0.10219698f, 0.19388518f, -0.15600868f, 0.12129212f, -0.01757946f, 
    0.02329450f, 0.33378503f, -0.03242907f, -0.05304027f, -0.06716806f, 0.13712117f, 0.03764528f, 0.14301455f, 
    0.02832623f, 0.26242837f, 0.09511777f, -0.09614058f, 0.11246565f, 0.28366175f, -0.33701539f, 0.38465893f, 
    -0.07278939f, 0.25506893f, -0.16860116f, 0.14390936f, -0.12405598f, -0.03416817f, 0.15778458f, 0.14169590f, 
    -0.20035063f, -0.00926613f, -0.13157344f, -0.03242161f, 0.25065827f, -0.05734030f, 0.06966551f, -0.28833395f, 
    0.00330251f, 0.11569532f, 0.17795330f, -0.17054774f, 0.63261420f, -0.13486846f, 0.17182466f, -0.03405372f, 
    -0.22261125f, -0.29279360f, 0.23774369f, 0.22112541f, 0.14673531f, 0.22715034f, 0.13691412f, -0.20730974f, 
    -0.04051808f, 0.02099118f, 0.14132409f, 0.03918623f, 0.10710568f, -0.01825054f, 0.07247401f, 0.01762875f, 
    0.20441081f, 0.01848327f, 0.30108798f, 0.19076133f, -0.05824188f, -0.05912624f, -0.12429506f, -0.27399614f, 
    -0.11181387f, 0.08041930f, 0.15125069f, -0.09890869f, -0.52088720f, 0.59619772f, 0.38476032f, 0.00306497f, 
    0.31957608f, -0.20765491f, 0.07042441f, -0.15085432f, -0.10063232f, 0.18442383f, -0.09277218f, 0.30669397f, 
    -0.19987743f, 0.20382074f, 0.09844299f, -0.16227289f, -0.13488206f, -0.23530059f, 0.14394988f, 0.07443702f, 
    -0.13009676f, 0.21635760f, 0.17178224f, -0.42447460f, 0.08780525f, -0.06410047f, 0.10437889f, -0.31253254f, 
    -0.10078447f, -0.04006482f, 0.29149079f, 0.12472231f, 0.31407464f, -0.68124360f, -0.09788222f, 0.21710528f, 
    0.04044905f, -0.13832904f, -0.06597444f, 0.26151592f, 0.14501281f, 0.17730202f, 0.10079874f, -0.06562007f, 
    0.26785502f, 0.17915414f, 0.04818118f, -0.10181011f, -0.16438836f, -0.06861414f, -0.15272123f, -0.15063770f, 
    -0.08678785f, 0.04371311f, 0.23621279f, -0.12872654f, -0.19248664f, 0.09411159f, -0.03451462f, 0.05873015f, 
    -0.12303805f, 0.28827715f, -0.16867335f, 0.10691755f, -0.17326798f, -0.17841326f, -0.09563715f, -0.12861359f, 
    -0.25208193f, 0.25275540f, 0.00563674f, -0.19703428f, 0.06932760f, 0.34653929f, 0.15355778f, 0.34142551f, 
    -0.03929153f, 0.09295691f, 0.11131246f, -0.07186165f, 0.01176724f, -0.27351081f, -0.00276270f, 0.02327042f, 
    -0.14075761f, 0.27406487f, 0.42664844f, 0.06360968f, -0.30213848f, -0.08031836f, 0.00519234f, 0.25641558f, 
    -0.03040121f, 0.40861684f, 0.01455608f, 0.08538976f, -0.11601440f, -0.07807195f, 0.19070420f, -0.38572124f, 
    0.12834668f, 0.05311406f, -0.13175085f, -0.04448780f, 0.09169267f, -0.15412576f, 0.23750325f, -0.13196801f, 
    -0.22383609f, 0.18361968f, 0.16936034f, 0.09366867f, -0.15719594f, -0.12307137f, -0.08679770f, -0.08105940f, 
    -0.05052805f, 0.23430267f, -0.13480660f, 0.01143791f, 0.29503942f, -0.15527351f, 0.05451263f, -0.38552761f, 
    -0.15310889f, -0.03297063f, 0.12397209f, 0.12029824f, 0.24169730f, -0.54110736f, 0.26586562f, 0.10829131f, 
    0.10919579f, -0.56368250f, -0.05762472f, 0.40937001f, 0.11053018f, 0.20079288f, 0.06698502f, -0.19162825f, 
    0.02569372f, 0.22345920f, 0.09450306f, -0.11474867f, -0.06307039f, 0.25142127f, -0.14950719f, 0.13814530f, 
    -0.15558997f, 0.23908544f, -0.09401907f, -0.08881912f, 0.13573608f, 0.06393988f, 0.08047030f, 0.08727811f, 
    0.08027440f, -0.35669476f, 0.20523351f, 0.13247176f, 0.36294484f, -0.51701504f, 0.13027571f, 0.40475628f, 
    0.00783817f, -0.15350765f, -0.22949082f, -0.05744951f, 0.03295960f, 0.11123023f, -0.05849592f, 0.28009856f, 
    0.04467092f, -0.01846668f, -0.10090463f, -0.11413826f, -0.12205253f, 0.03608641f, -0.14156860f, -0.05930963f, 
    0.21271877f, -0.00451214f, -0.14870381f, 0.21396297f, -0.01253041f, 0.04583702f, -0.01565813f, 0.05140862f, 
    -0.14285120f, -0.04914570f, 0.29995313f, 0.07667029f, 0.17483941f, 0.27692389f, 0.08460653f, 0.48713362f, 
    0.18352650f, -0.13577981f, 0.20502192f, -0.03136256f, 0.11291602f, 0.13372366f, -0.11866944f, -0.30637601f, 
    0.16877429f, 0.27700832f, 0.05495794f, -0.01399969f, -0.07128107f, -0.28434208f, -0.14640215f, -0.00017848f, 
    -0.11138778f, 0.18646786f, -0.07887442f, -0.42824429f, 0.02606812f, 0.04843229f, -0.14483306f, -0.00831798f, 
    -0.02535367f, 0.16199411f, 0.08974792f, 0.12753122f, 0.16411136f, -0.07906661f, -0.21978343f, -0.07753959f, 
    0.01340639f, -0.02539233f, -0.33325332f, 0.35209057f, -0.13972011f, 0.10729191f, -0.12866242f, 0.26616588f, 
    0.17375727f, -0.03401060f, 0.15340969f, -0.08260068f, 0.09598244f, 0.24486624f, 0.01416170f, 0.02385887f, 
    -0.09392284f, 0.02828528f, -0.03341607f, -0.04639184f, -0.08603082f, -0.14541827f, 0.02913174f, -0.25458404f, 
    0.06790123f, 0.22354805f, 0.07768238f, 0.03210524f, 0.13004990f, 0.03081891f, -0.09425130f, -0.26008505f, 
    -0.30356652f, 0.36244097f, 0.41979286f, -0.23235685f, -0.00320911f, -0.04511885f, -0.20372570f, 0.00818344f, 
    -0.01519210f, 0.12053929f, 0.03372219f, -0.10341720f, 0.12466684f, 0.08524846f, -0.09422680f, 0.15442005f, 
    0.07385140f, 0.02346052f, 0.34376934f, -0.00051730f, -0.17482255f, -0.16546214f, -0.10561578f, 0.27134928f, 
    0.03527412f, 0.06049492f, 0.32362384f, 0.10081904f, -0.25858825f, 0.39404833f, 0.19681883f, -0.32582742f, 
    0.25117853f, 0.16327137f, 0.04410825f, -0.02067738f, -0.05884926f, -0.26838443f, 0.16592623f, 0.05951270f, 
    -0.03207609f, 0.07467690f, -0.10982971f, 0.07627686f, 0.10120870f, -0.11477745f, -0.11680607f, -0.12382361f, 
    -0.09748711f, -0.04936707f, -0.02874937f, -0.04033015f, -0.09679091f, -0.12561223f, -0.09438291f, -0.16706839f, 
    0.02552584f, -0.15179011f, -0.16937450f, 0.16756377f, -0.09745442f, 0.00229745f, 0.04489955f, 0.00967014f, 
    -0.02987445f, 0.04821920f, -0.17888544f, -0.01098250f, -0.16790935f, -0.18493815f, -0.07506395f, 0.04908724f, 
    0.11255860f, -0.20957360f, -0.12303159f, -0.13257098f, -0.12593320f, 0.42817891f, -0.11002199f, 0.16257502f, 
    0.00247701f, 0.06923361f, 0.04314053f, 0.59276348f, 0.14211830f, 0.05363726f, 0.02857645f, 0.38303137f, 
    -0.06307167f, 0.03565169f, 0.29719505f, 0.04379502f, -0.02937098f, -0.00015849f, -0.02721047f, 0.19566254f, 
    -0.26435596f, -0.01971814f, 0.20354630f, -0.24324366f, 0.13698520f, -0.19160165f, -0.03677986f, -0.22761029f, 
    0.21885680f, -0.12601338f, 0.07525866f, -0.03744890f, 0.14234617f, 0.26265097f, 0.04497048f, 0.13553298f, 
    0.36468169f, 0.24608634f, -0.21587010f, -0.03767895f, 0.22102806f, -0.04071592f, 0.06374997f, -0.18099530f, 
    -0.00202519f, -0.28412768f, -0.09974330f, 0.01696504f, 0.14512278f, 0.19345434f, -0.27027863f, 0.38326815f, 
    -0.11136948f, 0.21755247f, 0.23609440f, 0.01117171f, -0.01837826f, 0.14673139f, -0.14574793f, 0.20810612f, 
    -0.06338046f, 0.07175540f, 0.09525312f, 0.00591867f, -0.00830463f, 0.17739280f, -0.02565476f, -0.00934816f, 
    0.41185987f, -0.05941442f, -0.23324908f, -0.09145527f, -0.01612245f, -0.07813745f, -0.10163403f, 0.21495552f, 
    -0.03088167f, -0.06249399f, -0.11012581f, 0.13070409f, -0.26908484f, 0.32953757f, 0.08392794f, 0.29637736f, 
    0.22113286f, -0.16212645f, -0.10646703f, 0.34340906f, 0.16014756f, -0.28077811f, 0.05824291f, 0.37879470f, 
    0.01881253f, 0.20333248f, 0.06513253f, 0.00906348f, -0.00699534f, 0.11711828f, 0.13228317f, 0.09186908f, 
    -0.08334652f, 0.13276771f, 0.07038762f, 0.08769053f, -0.19921887f, 0.07712024f, -0.08972704f, 0.34214574f, 
    -0.04106149f, -0.12582347f, 0.25374299f, -0.11155745f, -0.09545448f, -0.07822372f, 0.01694805f, 0.31759724f, 
    -0.14953855f, 0.11486050f, -0.22146674f, 0.06177583f, -0.05171444f, 0.21078412f, -0.15100901f, 0.49019971f, 
    -0.24094999f, -0.09835381f, -0.18048020f, 0.00031445f, -0.03760599f, 0.04077922f, -0.04938129f, 0.00135341f, 
    -0.17070036f, -0.21076915f, -0.18598257f, -0.06289431f, -0.15585414f, -0.01946617f, -0.15592612f, -0.06345904f, 
    -0.16338012f, 0.09838662f, -0.02077090f, -0.07391410f, 0.07152071f, 0.03726060f, 0.10984420f, 0.02580375f, 
    0.02532673f, 0.04304664f, -0.03833728f, -0.22702156f, -0.10234290f, 0.09676839f, -0.08844618f, -0.08496685f, 
    0.24356034f, -0.22097425f, -0.08937044f, 0.07012555f, -0.08024333f, 0.18778028f, 0.07150472f, -0.03779024f, 
    0.08113524f, -0.04755693f, -0.31809264f, 0.00225946f, 0.31664923f, 0.07633065f, -0.08917129f, -0.37461513f, 
    -0.12884724f, 0.03732935f, 0.02239531f, 0.12001609f, -0.07535691f, 0.02770765f, -0.31265569f, 0.27513364f, 
    0.26710939f, 0.20881383f, 0.20099443f, 0.12187523f, 0.02416526f, -0.14460312f, 0.05067208f, 0.25483575f, 
    -0.21371619f, -0.19278453f, 0.07170589f, 0.09153725f, 0.06595406f, -0.06111581f, -0.07069348f, 0.07988666f, 
    -0.00967628f, 0.00147941f, 0.11145528f, 0.18039143f, 0.21644802f, 0.04980750f, -0.17568840f, 0.02722431f, 
    0.14924376f, -0.02072278f, -0.39404193f, 0.07264951f, -0.04533106f, -0.27265850f, 0.14288580f, -0.25562841f, 
    -0.02436471f, -0.12754975f, 0.06209798f, 0.22618155f, 0.12893875f, 0.28894341f, 0.31460065f, -0.19582742f, 
    0.14887363f, -0.13969879f, 0.09428136f, -0.12983420f, 0.05678859f, -0.22601663f, -0.12615375f, -0.11016903f, 
    -0.16960138f, 0.09983489f, -0.12745719f, -0.01443565f, 0.36748514f, -0.05158047f, 0.01409561f, -0.26927131f, 
    0.08899886f, -0.08056226f, -0.17019980f, -0.13814229f, 0.12836607f, 0.07088624f, -0.05528608f, -0.16005234f, 
    -0.05944963f, -0.29865292f, 0.11538308f, 0.37944794f, -0.03643956f, 0.50582296f, -0.00211030f, -0.14825502f, 
    0.19131801f, -0.00015732f, 0.03719754f, -0.05680903f, 0.11221352f, -0.21056862f, -0.14801729f, 0.05410158f, 
    0.08539298f, 0.11464395f, 0.01677479f, 0.00329638f, 0.32473716f, 0.04480253f, -0.13593020f, -0.53211093f, 
    0.10734411f, 0.12773234f, -0.19306716f, 0.14118123f, -0.04306585f, -0.34708032f, -0.16165881f, 0.18235451f, 
    0.26956132f, 0.17393392f, -0.13933110f, 0.00472023f, 0.07816041f, -0.05694725f, -0.00007288f, 0.18380336f, 
    -0.09525748f, -0.04613135f, -0.12135497f, -0.16537924f, 0.11121108f, -0.01900018f, 0.09342448f, 0.09943584f, 
    -0.00709953f, -0.06153891f, -0.02444637f, 0.06850234f, -0.04404259f, -0.05719525f, -0.17609093f, -0.03358739f, 
    0.03950281f, -0.02944878f, 0.07839286f, 0.15003587f, -0.00883236f, -0.14982645f, -0.11944758f, -0.07364980f, 
    -0.01982980f, -0.04275534f, 0.05631805f, -0.09418990f, 0.10209663f, 0.12701370f, -0.17440444f, -0.15642823f, 
    -0.16741946f, 0.28913885f, -0.10311336f, -0.13787726f, -0.01094716f, -0.06643806f, -0.15843959f, 0.02535940f, 
    -0.12538722f, 0.27675918f, 0.01919251f, -0.33921793f, 0.15378180f, -0.09662803f, 0.04448517f, -0.07387426f, 
    0.05332230f, 0.08862235f, 0.24549042f, 0.08142378f, 0.32001120f, -0.35317537f, 0.26492825f, -0.13789910f, 
    0.12383387f, 0.09961110f, -0.12511587f, 0.17575707f, 0.07468300f, -0.27072930f, -0.27514225f, 0.15912193f, 
    -0.15761726f, -0.17375517f, 0.14598189f, -0.00042124f, 0.01910972f, 0.08809568f, 0.03777770f, 0.15662853f, 
    -0.15144964f, 0.26227295f, 0.01379518f, 0.06860039f, 0.36715493f, 0.06667857f, -0.07689885f, -0.33223024f, 
    -0.03415256f, -0.08081745f, -0.03751172f, 0.14973131f, 0.11164971f, 0.04650883f, -0.15924655f, 0.06764956f, 
    0.09221727f, -0.35254690f, 0.17450757f, 0.30021417f, 0.06948218f, 0.55767637f, -0.06914455f, -0.23592854f, 
    0.18813097f, -0.20891042f, 0.02707883f, -0.07284077f, -0.03088614f, 0.39191949f, 0.07194027f, 0.17757966f, 
    0.07249416f, -0.16464065f, -0.09914289f, 0.34299836f, 0.01872346f, 0.06129629f, -0.00706594f, -0.44279912f, 
    0.00715714f, 0.03589008f, 0.06954663f, 0.02478164f, -0.03880526f, 0.14943269f, 0.06828761f, 0.36548063f, 
    0.10894345f, 0.26417118f, -0.02250754f, 0.04782039f, -0.09834073f, -0.02213312f, 0.07043151f, 0.41628361f, 
    0.32203373f, -0.20885587f, 0.04086414f, -0.14889558f, 0.04932330f, 0.22522646f, -0.01054069f, -0.06520421f, 
    0.33475822f, -0.27178213f, -0.20207077f, 0.04540597f, 0.11392754f, 0.09322093f, 0.10775641f, -0.33159247f, 
    -0.13870175f, 0.12946440f, -0.14469108f, -0.06369866f, -0.23687932f, 0.42920348f, -0.00824551f, 0.32546526f, 
    0.29752851f, 0.12655191f, 0.21985437f, -0.02970008f, -0.16483490f, -0.15307096f, 0.01095693f, 0.17264590f, 
    -0.26259273f, -0.10019574f, 0.13197677f, -0.08853016f, 0.03417101f, 0.18435110f, 0.03820264f, 0.07078715f, 
    0.41639781f, -0.14182313f, 0.04981444f, -0.18303882f, -0.18539056f, -0.08264980f, 0.17035522f, 0.14021064f, 
    -0.10494146f, -0.00177731f, 0.07822642f, 0.04615267f, 0.14670004f, 0.43913066f, 0.23606502f, -0.16821022f, 
    0.33294344f, -0.11350244f, 0.07493898f, 0.33216241f, 0.09651241f, -0.05319118f, 0.23099503f, -0.18594505f, 
    -0.07094225f, -0.09850355f, 0.15041770f, -0.13921621f, 0.10178957f, 0.14130850f, -0.17028500f, 0.03298459f, 
    0.28432560f, -0.00227924f, -0.31409761f, -0.38558182f, 0.15967128f, -0.13186678f, -0.02164445f, 0.22295493f, 
    0.14360461f, -0.19799821f, -0.27440974f, -0.00883519f, -0.10960842f, -0.06152537f, -0.29754624f, -0.01943313f, 
    -0.07586543f, 0.16061080f, -0.36272132f, 0.07123292f, 0.12836649f, 0.08651334f, 0.05828804f, 0.05987563f, 
    0.19714504f, -0.21074353f, -0.04013466f, -0.01067634f, -0.17152114f, 0.29366726f, -0.03548495f, -0.15532438f, 
    -0.07384248f, 0.29559371f, -0.10784722f, 0.22102532f, 0.22682185f, -0.09582867f, 0.09572523f, -0.10325469f, 
    0.12146245f, 0.20059003f, -0.33125874f, -0.11713266f, -0.14775366f, -0.28555492f, -0.11643352f, -0.25070551f, 
    0.10302056f, -0.16859794f, -0.18270992f, 0.20243566f, -0.04325813f, 0.50543296f, -0.15062615f, 0.39543581f, 
    0.28469402f, 0.28349862f, 0.08941209f, 0.05799498f, -0.11129822f, -0.49665254f, -0.09196198f, 0.14458770f, 
    -0.05304746f, 0.06241410f, -0.18007563f, -0.11163925f, -0.06849743f, -0.04959510f, -0.16604082f, 0.32081327f, 
    -0.09330220f, 0.24020629f, -0.03853985f, -0.03879056f, 0.24281111f, 0.04097696f, -0.59486192f, -0.17918938f, 
    0.07616301f, 0.06449291f, 0.05301543f, -0.02685684f, -0.04382694f, 0.53712761f, -0.17404835f, -0.07812378f, 
    0.30299568f, -0.15722935f, 0.05611202f, -0.16268578f, 0.14015874f, 0.15975890f, 0.10506704f, -0.11085697f, 
    -0.16021775f, 0.09663276f, 0.42989352f, 0.33915943f, -0.04295792f, -0.16329512f, 0.07000951f, 0.10816380f, 
    -0.17353651f, 0.44190279f, -0.12858066f, 0.00400605f, -0.22072311f, -0.13462010f, -0.11205397f, -0.30622646f, 
    -0.07390119f, 0.21057433f, 0.10881075f, -0.12211987f, 0.03050274f, 0.47226891f, 0.22703966f, -0.14942177f, 
    0.35205612f, -0.17774431f, 0.01005607f, 0.13822743f, 0.08013362f, -0.00005029f, -0.09992044f, -0.16561800f, 
    -0.20847070f, 0.15362297f, -0.16912501f, -0.05481833f, 0.35607088f, -0.08993679f, -0.08643090f, 0.00058425f, 
    0.17010993f, 0.29198143f, -0.03985035f, -0.04071182f, -0.26706579f, 0.06921555f, -0.39816308f, 0.05294204f, 
    0.22392091f, 0.03501366f, -0.03722940f, 0.20875868f, 0.17734522f, -0.09317775f, 0.10120223f, -0.03933745f, 
    0.04189856f, -0.15206964f, -0.12921607f, 0.06483662f, 0.00053257f, 0.20983298f, -0.08744531f, 0.06048469f, 
    0.25942150f, 0.08836260f, 0.18174449f, 0.01318289f, -0.06151082f, 0.17592674f, -0.05940438f, 0.05262701f, 
    0.08190214f, 0.16024207f, 0.23174037f, 0.06420022f, 0.01978054f, 0.10126612f, -0.12695189f, -0.26482522f, 
    -0.17668910f, -0.12365609f, 0.55323625f, -0.11547589f, 0.13574900f, 0.34221116f, 0.36956349f, -0.45606849f, 
    -0.19811021f, 0.00485597f, 0.15615879f, -0.06605775f, 0.07833008f, 0.06498881f, -0.03677681f, -0.07636557f, 
    -0.26247963f, -0.04679856f, 0.27272016f, 0.13284761f, 0.11831231f, -0.12198843f, 0.06769732f, -0.09096541f, 
    -0.00580618f, 0.13711818f, -0.03683533f, -0.03380422f, 0.16677868f, -0.17401193f, 0.18126598f, -0.41954261f, 
    0.27663589f, 0.03609765f, -0.20600250f, 0.28781945f, 0.15875417f, -0.40026426f, 0.32131913f, -0.15733655f, 
    -0.09872660f, 0.25182974f, -0.00926910f, 0.12970357f, -0.09481797f, 0.08225290f, 0.06124552f, -0.10335699f, 
    -0.12638484f, -0.03927697f, 0.14326616f, 0.30105168f, -0.14577101f, 0.00869586f, 0.11294518f, 0.14065349f, 
    -0.00955187f, 0.11156138f, 0.40301850f, 0.16733561f, 0.22573984f, -0.12324276f, 0.29450518f, 0.07182246f, 
    -0.28858870f, 0.26499993f, 0.33908975f, -0.42747307f, -0.11406610f, 0.36936575f, 0.17780274f, -0.16992915f, 
    0.07676264f, 0.18252219f, 0.17603903f, -0.08669411f, 0.01475018f, -0.07544400f, -0.02337152f, -0.04649866f, 
    -0.24305570f, 0.11488046f, 0.26488271f, -0.02596540f, 0.33075073f, -0.09730044f, -0.11263555f, -0.04385071f, 
    0.10749561f, 0.32233050f, 0.08089081f, -0.13019522f, 0.07815760f, -0.59897292f, -0.14228587f, -0.28780487f, 
    0.15776026f, -0.06535423f, -0.04146036f, 0.18442199f, 0.07672314f, -0.07951579f, -0.10133390f, -0.53250098f, 
    0.12170812f, 0.17055754f, 0.14485160f, -0.07208665f, -0.05569998f, 0.12192010f, -0.17423515f, -0.05965181f, 
    -0.11101610f, 0.06192246f, 0.31785944f, 0.20152728f, 0.00979452f, -0.14158992f, -0.12840244f, -0.05370773f, 
    -0.04873905f, 0.01659201f, -0.01250910f, -0.04440852f, 0.00264100f, 0.15704799f, 0.04340957f, -0.04323357f, 
    0.09061243f, -0.26029083f, 0.08313302f, -0.12832071f, -0.05790637f, 0.22262114f, 0.27515197f, -0.40572971f, 
    0.11699625f, 0.15668611f, -0.09226668f, 0.16498877f, 0.02628427f, -0.32415825f, -0.00929346f, -0.04294187f, 
    -0.03920425f, -0.02622342f, 0.04058877f, -0.54674906f, -0.05450904f, -0.06401207f, 0.07259586f, 0.38178453f, 
    0.05380953f, 0.07134711f, 0.18220520f, 0.14735545f, 0.32421520f, 0.21397458f, -0.40706739f, 0.15056886f, 
    0.21812075f, 0.07413001f, -0.32014099f, 0.26952001f, -0.11379255f, -0.10767166f, -0.24412921f, 0.07245750f, 
    -0.04611218f, -0.16772512f, -0.01893708f, 0.06315619f, 0.17588745f, 0.05719447f, 0.04378446f, 0.16530040f, 
    -0.10847039f, -0.18968484f, 0.03063889f, 0.00772823f, 0.11856122f, 0.00770775f, 0.04254910f, -0.15626813f, 
    -0.14754716f, -0.02099586f, -0.00618442f, -0.16097620f, -0.12880118f, 0.16562749f, -0.03733030f, 0.11378211f, 
    -0.04474617f, -0.01267007f, 0.07005930f, 0.02330355f, 0.13498002f, 0.02239689f, -0.17257687f, -0.11440188f, 
    -0.05218600f, -0.16472055f, 0.05127926f, 0.08278954f, -0.00914357f, 0.15089890f, -0.14003856f, -0.04345679f, 
    0.20308062f, 0.34496459f, -0.14849795f, -0.28611806f, -0.10729709f, -0.05834547f, -0.10654230f, 0.23507203f, 
    0.09002250f, 0.19699751f, -0.22594973f, -0.16408372f, 0.08248512f, 0.27346465f, -0.21321516f, -0.25301349f, 
    0.01483455f, -0.12080553f, 0.02416848f, 0.28304675f, 0.11672927f, 0.29571351f, 0.08900134f, 0.18616280f, 
    0.04866049f, 0.20142731f, 0.05714500f, -0.05223366f, -0.00600786f, 0.08387095f, -0.09426996f, -0.11742891f, 
    0.04303816f, 0.26867309f, 0.17338479f, -0.11227954f, -0.39358991f, 0.10592669f, 0.03010265f, -0.37000421f, 
    -0.16413064f, -0.02534603f, -0.14458416f, -0.08567238f, -0.42779249f, -0.15600900f, -0.13464031f, 0.08831125f, 
    0.30533895f, -0.15990628f, 0.02998466f, 0.05903491f, -0.12209358f, -0.21149793f, 0.08631750f, -0.06418549f, 
    -0.20098704f, -0.01827293f, -0.02512761f, 0.10977282f, 0.02668814f, 0.29367700f, -0.08453271f, -0.03678570f, 
    -0.10689555f, -0.01020793f, -0.40846503f, -0.09679278f, -0.16146980f, 0.00173392f, 0.15164116f, 0.18421859f, 
    0.00671066f, -0.25977668f, -0.06150473f, -0.06995169f, 0.13896358f, 0.19025169f, -0.33949140f, 0.27994576f, 
    0.31952471f, -0.09358248f, 0.06453171f, 0.29900515f, -0.16253510f, 0.07956228f, -0.06630003f, -0.13921005f, 
    0.20752908f, 0.18288584f, -0.13733487f, -0.06317583f, -0.05541013f, 0.13285014f, -0.03136672f, -0.17932500f, 
    0.04189103f, 0.12886420f, -0.01769448f, -0.11067723f, -0.19503315f, 0.10171307f, 0.12380639f, 0.30466306f, 
    0.14158244f, 0.03229995f, -0.13993816f, 0.07284179f, -0.06576429f, -0.37648141f, -0.00430792f, 0.20254779f, 
    -0.10526343f, 0.29798219f, -0.33821914f, 0.10150318f, -0.13917394f, 0.02568505f, -0.10956793f, 0.34962431f, 
    -0.24356528f, 0.20419501f, -0.12052277f, 0.05174008f, -0.12767486f, -0.19194359f, -0.09531918f, -0.02579579f, 
    0.14926241f, 0.10770036f, 0.39190763f, -0.20302616f, -0.30907321f, 0.07844654f, 0.14226714f, -0.01151074f, 
    -0.03971422f, 0.39698765f, 0.29588979f, -0.00919520f, 0.03022903f, 0.26626688f, 0.24116395f, -0.41506386f, 
    0.01948409f, 0.02378992f, 0.17199564f, -0.08628649f, 0.15585856f, -0.20773327f, 0.16645843f, 0.05089764f, 
    0.05588859f, 0.21740246f, 0.02932176f, 0.07587264f, -0.12265112f, 0.15167643f, 0.16685060f, 0.11880426f, 
    0.20727576f, 0.22404081f, 0.34305698f, -0.13291435f, -0.29626170f, -0.06540316f, -0.16286010f, -0.12599137f, 
    0.00154691f, 0.02523570f, -0.28604957f, -0.12111518f, -0.40221462f, 0.11469354f, -0.02273818f, 0.12436043f, 
    -0.05053568f, 0.16238756f, -0.17232817f, -0.11903218f, -0.11985673f, -0.19226061f, 0.00935120f, -0.11245739f, 
    0.13992710f, 0.08551694f, 0.07463925f, 0.16870166f, -0.00930337f, 0.07215370f, -0.15095030f, -0.05315504f, 
    -0.01464936f, 0.27174059f, 0.18833856f, 0.08716246f, -0.26535195f, 0.16754451f, -0.04736003f, 0.25664654f, 
    -0.01424096f, 0.16442806f, -0.03550877f, 0.08512220f, -0.40054503f, -0.09235755f, 0.23013587f, -0.24853997f, 
    0.34668756f, 0.37101236f, -0.34717274f, -0.00311948f, 0.09620278f, -0.27483085f, -0.05986938f, -0.01503098f, 
    0.25462416f, -0.28200236f, -0.11814680f, -0.16214387f, 0.08050886f, -0.10517711f, -0.14881651f, -0.10492843f, 
    -0.12986730f, -0.15119515f, 0.01812098f, 0.23712528f, 0.17577757f, -0.01288992f, 0.14671247f, 0.05236619f, 
    0.15761492f, 0.15491837f, -0.02583476f, 0.08106454f, 0.01314323f, 0.44996607f, -0.08287737f, -0.11260606f, 
    0.10016626f, -0.12575096f, 0.48116377f, -0.03804665f, -0.13574217f, 0.41505781f, 0.14512998f, -0.19980140f, 
    0.08027221f, 0.21972592f, 0.06406652f, 0.12149853f, -0.09184188f, -0.06032269f, 0.00279918f, -0.16337650f, 
    0.35690832f, -0.05039271f, -0.17890175f, 0.25939739f, -0.10677598f, 0.02782253f, -0.00435189f, 0.33987764f, 
    0.13895307f, -0.35752958f, 0.26891080f, 0.03902934f, 0.13095784f, 0.30033603f, 0.25823411f, 0.42319632f, 
    -0.05154951f, -0.14635335f, -0.10582088f, -0.03248033f, -0.05515240f, -0.05730532f, -0.12899518f, 0.35909811f, 
    -0.10389460f, -0.06469317f, 0.07382156f, 0.06043281f, 0.03657444f, 0.01752031f, -0.02818874f, 0.12953037f, 
    0.14089952f, -0.10218605f, -0.03069386f, 0.27988786f, 0.23236124f, -0.13662571f, -0.02495681f, 0.00812568f, 
    -0.15823279f, -0.08743466f, 0.06991818f, 0.05694061f, 0.25175199f, -0.10318088f, 0.22932057f, 0.19386731f, 
    0.18627623f, -0.28020853f, -0.00559678f, 0.11919449f, -0.08858605f, -0.04864068f, 0.27308491f, -0.37320492f, 
    0.15940064f, -0.20262505f, 0.06665312f, 0.08281378f, 0.02862141f, 0.25753200f, -0.04727869f, 0.04161843f, 
    0.25518245f, -0.09571091f, 0.26030624f, 0.20726174f, 0.03904584f, 0.01926153f, 0.07473914f, 0.02044772f, 
    -0.03660756f, 0.07739016f, 0.06299668f, -0.11883124f, -0.26882905f, 0.44730791f, 0.19833003f, 0.12065832f, 
    0.32405278f, 0.04195085f, 0.05373664f, -0.04662828f, 0.11503250f, -0.14326364f, 0.04523090f, -0.17839147f, 
    0.25869972f, 0.27006647f, 0.04647281f, 0.08593543f, -0.02417653f, -0.20915443f, 0.01377005f, -0.09712251f, 
    -0.17738709f, 0.20450741f, 0.05420171f, 0.10658413f, 0.15409431f, -0.04059241f, 0.01988821f, -0.27005893f, 
    0.14029644f, 0.22676876f, -0.19157924f, -0.15887573f, -0.19273952f, 0.20618589f, -0.10803786f, 0.03313690f, 
    -0.05481018f, 0.23999706f, -0.04073345f, -0.23969656f, -0.00321910f, 0.17516114f, -0.28626773f, 0.33729967f, 
    0.06055069f, -0.13226174f, -0.17092609f, 0.15113765f, 0.03130015f, 0.18710333f, -0.12052330f, 0.13044919f, 
    0.15118973f, -0.17932908f, -0.30331865f, -0.43393853f, 0.14943564f, -0.11174657f, -0.06575686f, -0.15809895f, 
    0.17619959f, 0.26422828f, 0.14676513f, 0.04267175f, -0.05948506f, 0.32875481f, 0.10050344f, -0.24760070f, 
    0.19792597f, 0.36361137f, -0.08674084f, 0.02995787f, -0.13644063f, -0.34728110f, 0.06562579f, 0.31883678f, 
    0.28246006f, -0.03826614f, -0.08567422f, 0.09851431f, -0.02111933f, -0.26706466f, 0.13031666f, 0.16372521f, 
    0.02823064f, -0.15733804f, -0.33333755f, -0.25779626f, 0.01649959f, 0.14687677f, 0.06601968f, 0.22542934f, 
    -0.04901304f, 0.04951400f, 0.02409103f, 0.11780653f, -0.05368464f, 0.38627034f, -0.04187440f, 0.29608905f, 
    0.22014646f, -0.02740861f, -0.01603332f, 0.01851315f, 0.03568579f, -0.04245510f, -0.17194471f, 0.48300919f, 
    0.10401296f, -0.40161574f, -0.16325867f, -0.15467769f, 0.13767843f, 0.36381027f, -0.08555382f, -0.14347255f, 
    0.11428928f, -0.08232164f, -0.05481733f, 0.36342058f, 0.06676251f, 0.13017899f, 0.09446117f, 0.16356231f, 
    -0.06587198f, -0.05248029f, -0.27250710f, -0.07905067f, -0.09930580f, -0.11147624f, -0.06818971f, 0.05739795f, 
    0.02406828f, -0.05468739f, 0.35495543f, 0.17580992f, -0.13466287f, 0.27732006f, 0.21472079f, -0.03264150f, 
    -0.12527607f, 0.41170803f, 0.09578598f, 0.14150508f, 0.07949472f, -0.27370915f, 0.10610260f, 0.03615257f, 
    -0.20117709f, 0.26197973f, 0.18715072f, -0.06301965f, -0.17192274f, -0.15474071f, -0.08193682f, 0.15139401f, 
    0.12627356f, 0.11507435f, 0.22251604f, -0.10944062f, 0.13694277f, -0.37526169f, 0.39524284f, 0.03598475f, 
    -0.04652008f, 0.00457509f, -0.16019292f, 0.06719565f, -0.14179729f, -0.02178189f, 0.15009582f, -0.04612302f, 
    0.28883284f, -0.24385969f, -0.14253816f, 0.09997584f, -0.02417528f, -0.04562661f, 0.05931273f, -0.04682300f, 
    0.30405700f, 0.06917087f, -0.22081047f, -0.00343402f, 0.26886392f, -0.11184693f, -0.06554081f, 0.21160740f, 
    -0.06963459f, 0.15953480f, -0.09784696f, -0.02691847f, -0.34358835f, 0.34979153f, -0.31920719f, -0.13065493f, 
    0.05089322f, -0.00858794f, 0.22311114f, 0.08787245f, -0.11122639f, 0.10255727f, 0.19135635f, 0.17286883f, 
    -0.02294630f, -0.17965847f, 0.10797449f, 0.08061112f, 0.01379591f, 0.04085053f, -0.14816524f, -0.01087477f, 
    -0.19373386f, -0.07972074f, -0.06233634f, -0.16983196f, -0.09588814f, 0.04570535f, -0.13708681f, -0.10629690f, 
    -0.16243610f, -0.11045019f, -0.10365947f, -0.01656163f, -0.01734847f, 0.04606976f, -0.12491494f, 0.07404755f, 
    -0.09833607f, -0.07612269f, -0.00042868f, 0.09471443f, 0.11605474f, 0.07473350f, 0.12553610f, -0.09370083f, 
    0.02942694f, 0.04152752f, -0.10382835f, 0.10422806f, -0.01247369f, -0.16937666f, -0.00209152f, 0.00047197f, 
    0.24369061f, 0.38953757f, 0.31229103f, -0.38808849f, -0.16253148f, 0.15674283f, -0.09692972f, 0.13563773f, 
    -0.16229352f, -0.14132868f, -0.11948273f, -0.09401281f, 0.15741058f, 0.07397566f, 0.13294978f, -0.21666566f, 
    0.09060483f, -0.12373422f, -0.28742242f, 0.35836524f, 0.01154440f, -0.20922484f, 0.03853733f, -0.33105391f, 
    -0.09182696f, -0.06487823f, -0.14779514f, 0.16551138f, 0.01200338f, -0.17910630f, 0.08747222f, 0.16543639f, 
    -0.08858588f, 0.10286687f, 0.10349832f, 0.08885220f, -0.15551879f, -0.12311763f, 0.11749214f, -0.15716362f, 
    0.08576674f, -0.11210363f, -0.06515840f, 0.05792479f, 0.09769068f, -0.12806006f, -0.02345511f, -0.10079553f, 
    -0.19797738f, 0.06477838f, -0.12811807f, -0.09032312f, 0.13003907f, -0.05220521f, -0.10831647f, -0.10407729f, 
    -0.10292608f, 0.14446333f, 0.07226018f, 0.15210925f, -0.05909883f, 0.03558035f, -0.03370420f, -0.09908678f, 
    0.02925593f, 0.19824159f, 0.16889377f, -0.38320705f, 0.12512819f, 0.12306456f, -0.02643164f, 0.05130214f, 
    -0.12795772f, 0.28293219f, -0.26059553f, 0.05585991f, 0.04856851f, 0.21198821f, -0.11143432f, -0.06597909f, 
    0.36239198f, -0.03157109f, -0.45313188f, 0.17286228f, 0.15112117f, -0.21517962f, -0.16837001f, -0.25470108f, 
    -0.04914586f, 0.17901492f, 0.15747672f, -0.05446048f, -0.11421287f, -0.30097896f, 0.17175934f, 0.10654744f, 
    0.25996459f, 0.04681981f, -0.12882166f, -0.02817690f, -0.20308506f, -0.04366105f, 0.14114524f, 0.23957454f, 
    -0.05000449f, 0.17761399f, 0.20370436f, 0.04641283f, 0.13360550f, 0.54816371f, 0.03149550f, 0.13533852f, 
    -0.35047504f, 0.14852412f, 0.34107697f, -0.22042786f, 0.08572307f, 0.16492726f, -0.00171617f, 0.24104962f, 
    -0.05417222f, 0.05089568f, 0.17241502f, 0.07333143f, -0.08883607f, -0.19193913f, 0.06475157f, 0.05913597f, 
    -0.00774590f, -0.12052327f, 0.03503978f, -0.14648561f, -0.10105675f, 0.12123212f, -0.14615391f, 0.08697806f, 
    -0.15654507f, 0.13469416f, -0.11765327f, -0.07202630f, -0.00124184f, -0.09047014f, 0.02381220f, -0.17035718f, 
    -0.11108872f, -0.10183508f, -0.16770479f, -0.15363030f, 0.02452120f, -0.00757910f, -0.04219728f, -0.04498028f, 
    0.02032635f, -0.01944252f, 0.13640833f, -0.04613652f, -0.05913307f, 0.23043190f, -0.16137809f, -0.17536579f, 
    0.08744783f, 0.01524412f, -0.11763743f, 0.20593014f, -0.21917431f, 0.05234393f, 0.15957266f, 0.19177262f, 
    0.12908101f, -0.18954834f, -0.02153021f, -0.11024372f, -0.24417578f, -0.08972082f, 0.09783583f, 0.25562143f, 
    -0.13008800f, 0.07411012f, 0.24745454f, -0.14563951f, -0.17605293f, -0.22255532f, -0.32712218f, -0.04487550f, 
    -0.00733275f, 0.18988915f, 0.10224038f, 0.09142737f, -0.08950026f, 0.00584240f, 0.11718244f, 0.04120490f, 
    0.17555659f, -0.03437793f, 0.08416088f, -0.23147865f, -0.09369425f, -0.11897099f, 0.05312972f, 0.01049998f, 
    -0.03101944f, 0.34241986f, 0.24868044f, -0.17374057f, 0.03711525f, 0.60857373f, 0.13769454f, -0.43171489f, 
    0.15837461f, -0.04136810f, 0.13712564f, -0.17787319f, 0.15935428f, -0.15639186f, 0.03103318f, -0.16787767f, 
    0.41561878f, -0.19717142f, 0.12959313f, 0.12723994f, 0.03289859f, 0.32768553f, -0.16915545f, 0.17031144f, 
    0.22998086f, -0.00619894f, 0.33162329f, 0.22997484f, -0.05689524f, 0.13482855f, -0.04006964f, -0.25285867f, 
    0.11392009f, 0.07738042f, -0.30615106f, 0.07724459f, -0.24764000f, -0.20188248f, -0.31880873f, 0.21175115f, 
    -0.08274986f, 0.03971351f, 0.16006406f, -0.00802196f, 0.01199542f, 0.23657174f, 0.21746470f, -0.27907732f, 
    0.37330240f, -0.20559263f, 0.03364966f, -0.12637691f, -0.03784397f, -0.00446316f, -0.10026598f, 0.02985407f, 
    0.19196057f, 0.07245285f, -0.06918418f, 0.29120451f, 0.26830387f, 0.06519690f, -0.05730713f, -0.26796409f, 
    0.16639556f, 0.10936871f, -0.33987182f, 0.06854904f, -0.20622264f, 0.14955257f, -0.07823499f, 0.05334945f, 
    0.33284634f, -0.12393177f, -0.11677638f, 0.15064716f, -0.12659246f, -0.09007451f, 0.08988192f, -0.17421788f, 
    -0.04321412f, -0.10802194f, 0.14905830f, -0.00182117f, 0.11081951f, 0.46770725f, 0.14177930f, -0.15823872f, 
    0.31400424f, -0.11394902f, 0.25448129f, 0.25118166f, -0.09234671f, -0.09539888f, -0.16994448f, 0.16747220f, 
    0.03051977f, 0.12433119f, 0.10497131f, -0.14156617f, -0.02424920f, 0.19792484f, 0.11715255f, -0.02072825f, 
    -0.31508473f, -0.06425228f, 0.41435909f, -0.11417214f, -0.14317115f, 0.13190936f, 0.15577093f, -0.13058914f, 
    -0.10842180f, 0.22324587f, -0.09241716f, -0.07544854f, -0.17139782f, -0.00451453f, 0.17086749f, 0.00611833f, 
    0.10440101f, -0.25971898f, 0.28151873f, 0.50907129f, -0.11027354f, 0.06270606f, -0.09711777f, 0.20987007f, 
    -0.06225643f, -0.11025862f, 0.46738344f, -0.12889597f, -0.02237968f, -0.01061856f, 0.37424707f, 0.30513427f, 
    0.20655686f, -0.08883394f, 0.21043043f, -0.05029022f, 0.12978330f, -0.49725586f, 0.04127492f, -0.13123710f, 
    -0.06539757f, 0.18600106f, 0.05892497f, -0.03322878f, -0.18419196f, -0.14358966f, 0.17675544f, -0.03540259f, 
    0.31491363f, -0.29300094f, -0.02590916f, -0.06109457f, -0.05735318f, 0.12313820f, 0.09114639f, 0.37328562f, 
    -0.01872516f, -0.09155123f, 0.29402527f, 0.09656230f, -0.06623128f, 0.52269542f, 0.17603914f, 0.21046749f, 
    0.24240112f, -0.04743651f, 0.08069915f, -0.13291435f, 0.01797768f, 0.17916983f, -0.13355957f, 0.38309842f, 
    0.33910277f, 0.11106981f, -0.00782267f, 0.12767844f, -0.11073720f, -0.01604924f, -0.07827369f, 0.00095927f, 
    0.19441590f, -0.06896201f, -0.03128213f, 0.36873779f, -0.08542296f, -0.03923672f, -0.05688282f, -0.08057078f, 
    0.02480313f, -0.23521422f, 0.34694362f, 0.16272075f, -0.19657004f, -0.02333664f, 0.14608961f, 0.51736385f, 
    0.36027175f, -0.22698581f, -0.11721928f, -0.11050627f, -0.02421353f, -0.60577494f, -0.16240585f, 0.07306509f, 
    -0.13438290f, 0.13092411f, 0.12792885f, -0.13393746f, -0.00364038f, -0.07635909f, -0.00306279f, 0.14362994f, 
    0.22528096f, 0.04733020f, 0.27865100f, -0.22473198f, -0.02326958f, -0.05005812f, 0.14294054f, 0.33650845f, 
    0.10318685f, 0.11473622f, -0.07851422f, -0.06088333f, 0.02488175f, 0.16375081f, 0.13877454f, -0.00957487f, 
    0.10685591f, -0.03865191f, -0.11707150f, 0.13688156f, 0.12629069f, -0.26352844f, 0.11073655f, -0.42800170f, 
    0.16753337f, -0.09646236f, 0.03342021f, 0.02708561f, -0.04549582f, 0.17855962f, 0.07043495f, -0.02722667f, 
    0.56196028f, -0.10299025f, -0.23085551f, -0.11688793f, -0.11784919f, -0.09660702f, 0.12440926f, 0.40114132f, 
    0.09215024f, -0.12326166f, 0.05930726f, -0.07779307f, -0.09865050f, 0.39236239f, -0.25684968f, -0.01232867f, 
    0.16315733f, 0.02846237f, 0.13664833f, 0.13212715f, 0.02204582f, 0.16119517f, 0.34260827f, 0.02054123f, 
    0.12881345f, 0.37047040f, -0.02839560f, -0.07385653f, -0.15080804f, -0.26872104f, -0.09791511f, 0.11802203f, 
    -0.06209362f, 0.05510877f, 0.06127990f, -0.23903848f, -0.23149583f, -0.05622495f, -0.00858937f, 0.05087001f, 
    0.04998879f, 0.19362861f, 0.23338640f, 0.09487948f, 0.05397697f, 0.23572890f, 0.08645505f, 0.30688572f, 
    0.24416220f, 0.26329398f, -0.31952181f, -0.01530294f, -0.04350643f, -0.38059309f, -0.17820972f, 0.13978846f, 
    0.00881655f, 0.02301156f, -0.13749516f, -0.10858025f, 0.10520656f, -0.07072636f, 0.08878383f, -0.07993221f, 
    0.11275037f, 0.02054404f, -0.12145961f, -0.13759074f, -0.05005654f, 0.01054455f, 0.07423031f, 0.09708897f, 
    -0.01417042f, -0.00340796f, 0.09519453f, 0.13087659f, -0.00361840f, -0.13905726f, -0.13629813f, -0.07658663f, 
    -0.14738750f, -0.14469634f, -0.05053325f, -0.17656030f, -0.09906878f, -0.18418364f, -0.09184347f, 0.06940098f, 
    -0.03446095f, 0.09199554f, 0.05910019f, -0.17533429f, -0.07752286f, -0.11940420f, 0.04762297f, -0.13282581f, 
    0.11931445f, 0.01582629f, 0.02899227f, -0.10041958f, 0.10355309f, -0.10164213f, 0.11971293f, -0.17156860f, 
    0.02115149f, 0.29557487f, -0.21813746f, -0.05874202f, -0.20187140f, 0.22153617f, 0.08570991f, -0.14568967f, 
    0.28423551f, 0.00625903f, 0.09014519f, 0.14650203f, 0.01391004f, -0.32999122f, 0.23640154f, -0.03783058f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07624025f, 0.12204655f, -0.04447326f, 0.22532918f, 0.28673187f, 0.01957759f, 0.08754048f, 0.13705701f, 
    0.16096595f, 0.04071361f, 0.17399648f, -0.07803647f, 0.03007226f, 0.25294966f, 0.09699757f, 0.21934915f, 
    -0.02380403f, 0.04024425f, 0.00046627f, 0.07025442f, -0.13987495f, -0.10093501f, 0.01898527f, 0.11395902f, 
    -0.06035410f, -0.16156681f, -0.00665048f, 0.04983690f, 0.07090252f, 0.22412942f, -0.13978358f, 0.04434386f, 
    0.00412003f, 0.17665559f, -0.18758629f, 0.00986408f, -0.12469361f, 0.22656865f, 0.11422771f, 0.28597507f, 
    -0.08711851f, -0.02819149f, 0.19554278f, 0.11587481f, 0.03541003f, 0.08295504f, 0.02498962f, -0.12770572f, 
    0.26244372f, 0.13664974f, 0.09731081f, -0.05642178f, 0.05979422f, 0.11883085f, 0.06408221f, 0.10512586f, 
    0.04085953f, -0.03641262f, 0.11745088f, -0.20514777f, -0.00608347f, 0.10024724f, 0.26442224f, -0.06739939f, 
    -0.09474958f, -0.16485935f, 0.13497844f, -0.13085710f, -0.15879752f, 0.01196453f, 0.16994034f, 0.12125525f, 
    0.07745308f, 0.19487080f, 0.05507046f, -0.24285622f, -0.06370988f, -0.12828611f, 0.12870030f, 0.05836985f, 
    0.01212957f, -0.18673274f, 0.02382261f, -0.00793384f, 0.04609936f, 0.05072660f, -0.11847164f, -0.06906240f, 
    0.20601112f, 0.19961044f, -0.11229227f, 0.01571566f, 0.07600962f, 0.30531484f, 0.13446857f, -0.14535773f, 
    0.10449859f, 0.39245048f, 0.03100230f, 0.28868511f, -0.21006355f, 0.18164302f, -0.09955974f, 0.27530977f, 
    -0.09065358f, 0.16783047f, -0.03510672f, -0.04841504f, 0.22534943f, -0.14585714f, 0.03545782f, 0.12867679f, 
    0.04533131f, 0.16603130f, -0.15739329f, -0.02458457f, 0.22965381f, 0.16209179f, 0.19450608f, 0.09129311f, 
    0.04916405f, 0.13204944f, 0.19085641f, 0.13789488f, 0.02271909f, 0.15326829f, -0.14386931f, 0.08764090f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.37821484f, -0.13326031f, 0.31213939f, 0.00575070f, 0.07028170f, -0.00951305f, 0.31098571f, -0.00676538f, 
    0.26455286f, -0.09928603f, 0.10761888f, -0.17612891f, -0.27252498f, 0.03107535f, 0.02730758f, -0.16010059f, 
    0.29638419f, 0.13718323f, 0.29351640f, -0.16518551f, 0.13605663f, -0.15654366f, 0.17293575f, -0.24680398f, 
    0.01659592f, -0.12902431f, 0.33992541f, -0.01801101f, 0.00779986f, -0.12485849f, -0.34021890f, 0.07220074f, 
    -0.22633125f, 0.19587034f, -0.02124234f, 0.24935155f, 0.12579885f, 0.12797272f, 0.16450007f, -0.04876309f, 
    -0.08786899f, -0.15321729f, -0.13773498f, 0.02924737f, -0.01425394f, -0.41760081f, 0.05380303f, -0.00164780f, 
    -0.05929156f, -0.39045346f, -0.11835967f, 0.01578167f, -0.01578741f, -0.00176376f, 0.11651617f, 0.01508264f, 
    -0.33024272f, -0.42368448f, 0.14823940f, 0.06852689f, 0.15386584f, -0.06760302f, 0.21271527f, -0.04217532f, 
    0.04267143f, -0.30314204f, 0.05095552f, 0.19502346f, -0.10813465f, -0.00318910f, 0.15304565f, -0.31643948f, 
    -0.24348810f, 0.17036530f, -0.07267548f, 0.03364898f, -0.16701020f, 0.16957392f, 0.24833211f, 0.06869714f, 
    -0.48080173f, -0.54414499f, -0.28596926f, -0.55942369f, -0.04589987f, -0.41843915f, -0.03246027f, -0.19961537f, 
    -0.08941901f, -0.07750827f, 0.10843462f, 0.01656439f, -0.32122540f, 0.25161088f, -0.30136696f, -0.08539114f, 
    -0.21006623f, -0.03356803f, -0.14806147f, -0.17069282f, 0.17161068f, 0.16573258f, 0.01659445f, -0.05669992f, 
    0.10249466f, 0.25831720f, -0.20144151f, 0.00726888f, -0.12340233f, -0.04391900f, -0.12278752f, 0.00701318f, 
    -0.00881338f, -0.13969889f, 0.02597031f, 0.01666872f, -0.06546188f, -0.10843443f, 0.11921970f, -0.19585276f, 
    0.19750041f, 0.21408598f, 0.52228051f, -0.03852656f, -0.08499085f, 0.24870656f, 0.06694973f, 0.06983007f, 
    -0.51628453f, -0.01728008f, -0.14524947f, 0.25542817f, 0.26066175f, 0.06343383f, -0.09381225f, -0.30239552f, 
    -0.01264778f, -0.06532582f, 0.17338362f, -0.06639008f, -0.17857774f, -0.31014267f, -0.05319899f, -0.17057405f, 
    -0.10453496f, -0.26131675f, 0.08155549f, -0.09347483f, 0.00439074f, -0.36239517f, -0.09182900f, 0.02889450f, 
    0.08001964f, -0.04610549f, 0.13636510f, -0.19767320f, 0.14632291f, 0.12862042f, 0.02941636f, -0.14448892f, 
    -0.10275029f, -0.26478845f, -0.02107252f, 0.23123066f, -0.19910710f, -0.67473000f, -0.34164682f, -0.04057894f, 
    0.22389612f, 0.03784341f, 0.01143553f, 0.12420033f, 0.14657918f, -0.19263384f, -0.24746856f, -0.26635787f, 
    0.23530303f, -0.17705078f, 0.04605892f, 0.17150036f, -0.04189543f, -0.04733238f, 0.41317877f, -0.48735645f, 
    -0.19809085f, -0.36040449f, -0.13522889f, -0.27107295f, 0.06120756f, -0.02152955f, 0.22392981f, 0.03110630f, 
    -0.05145515f, -0.00983492f, 0.17622371f, 0.22190630f, -0.17011325f, 0.04057901f, 0.03036132f, -0.25484508f, 
    0.17390867f, -0.10774159f, 0.00263220f, -0.30503723f, 0.16268186f, 0.03065746f, 0.21531169f, 0.29664317f, 
    0.31723681f, -0.06534509f, -0.03911153f, -0.14173771f, 0.00699097f, 0.18043275f, -0.22215268f, -0.10324842f, 
    -0.54782057f, -0.03290991f, -0.01865937f, 0.05986704f, 0.18165052f, 0.30831611f, 0.59147996f, -0.28009927f, 
    -0.01472669f, 0.46779424f, -0.25128213f, 0.26384726f, 0.03104516f, -0.00878151f, 0.09824836f, -0.02340169f, 
    0.06861526f, 0.10112836f, 0.10813352f, -0.46881333f, 0.21618627f, -0.07777458f, 0.03408931f, -0.07221153f, 
    0.12973115f, 0.19261880f, -0.04543278f, 0.17561454f, 0.15284733f, 0.03623997f, 0.12262262f, 0.20521136f, 
    -0.20919752f, 0.20384364f, -0.16924539f, -0.01207349f, 0.22070529f, -0.25040027f, -0.05910181f, 0.06655287f, 
    0.24804665f, 0.06652141f, -0.17124096f, -0.36823457f, -0.08555043f, 0.06799375f, 0.01368570f, 0.26365975f, 
    -0.42739606f, 0.03042038f, -0.12596630f, -0.55302978f, 0.13717522f, -0.25160211f, -0.07044403f, -0.04208745f, 
    -0.23964497f, -0.38294539f, 0.24112737f, -0.15879399f, -0.29551926f, -0.27779156f, -0.09235618f, -0.19088483f, 
    0.00760324f, -0.42849687f, 0.00086481f, 0.04552554f, -0.16466190f, 0.18126728f, 0.11362582f, -0.03922796f, 
    -0.21643819f, -0.10969587f, -0.05096093f, 0.00770250f, -0.37250710f, -0.20914230f, 0.00823441f, 0.22197135f, 
    -0.09128836f, -0.47392851f, -0.35411951f, -0.05477545f, -0.23232923f, 0.08249240f, 0.09223112f, 0.13400954f, 
    0.08012592f, 0.01899471f, -0.64069146f, 0.26784781f, 0.13641286f, -0.42281824f, -0.19680583f, -0.39704621f, 
    0.07697552f, 0.17280720f, -0.40355173f, -0.16175038f, -0.08408025f, 0.25225869f, -0.33349982f, 0.09191487f, 
    -0.08834627f, -0.20260747f, -0.00640022f, 0.19746380f, 0.14367208f, -0.06870721f, -0.02560373f, -0.38613951f, 
    -0.05078138f, -0.02994934f, 0.04248836f, 0.05070911f, -0.34569475f, -0.31833497f, -0.02566166f, -0.11313100f, 
    -0.15460965f, 0.01742877f, 0.45244667f, -0.03547133f, 0.21155286f, -0.27767685f, -0.12081867f, -0.33285120f, 
    0.14849772f, -0.16095385f, 0.39249480f, -0.05743279f, 0.14998974f, -0.36038542f, -0.19095097f, 0.22682050f, 
    -0.09207430f, -0.22694641f, 0.21702085f, 0.00637504f, 0.08971005f, -0.27066010f, -0.07348438f, 0.16307235f, 
    0.02278476f, 0.32412088f, -0.10310286f, -0.01374294f, 0.19821931f, -0.03407177f, 0.06012279f, -0.08907247f, 
    0.24517833f, 0.10812733f, -0.09404555f, -0.11334928f, 0.04394621f, -0.15785398f, 0.08388659f, -0.42025477f, 
    -0.29088974f, 0.16986299f, 0.12335263f, 0.05212440f, 0.08601397f, 0.22282858f, -0.01817194f, -0.00369521f, 
    0.05924042f, 0.05172893f, 0.01668495f, -0.51596022f, -0.58246624f, -0.05524755f, 0.13723028f, -0.02646982f, 
    0.13550426f, 0.18719725f, -0.56636101f, -0.07828846f, -0.33627534f, 0.00254930f, -0.08705573f, 0.19465005f, 
    0.23855959f, 0.09439877f, -0.31386042f, 0.20983271f, -0.47541547f, 0.18783033f, -0.16794176f, -0.39581528f, 
    -0.02291125f, 0.12719882f, -0.08917793f, 0.22151843f, 0.10839908f, -0.74583584f, 0.11283284f, -0.02259113f, 
    0.14500470f, 0.18061750f, -0.07843971f, -0.09593096f, -0.39846578f, -0.34846252f, 0.16246805f, -0.68243170f, 
    -0.46255562f, 0.26274186f, -0.14702947f, -0.40967977f, -0.15083589f, -0.04517321f, 0.17515774f, 0.15349993f, 
    -0.45752773f, 0.01244171f, 0.17832832f, 0.04116617f, 0.00660674f, 0.14270374f, 0.20620428f, -0.28466889f, 
    0.13019240f, 0.28232142f, -0.08033176f, -0.22298498f, -0.07617965f, -0.46586254f, -0.28945240f, 0.18364790f, 
    -0.07358585f, 0.01101855f, -0.61690342f, -0.14329875f, -0.07407553f, -0.02795978f, -0.38397449f, 0.47975010f, 
    -0.25223008f, -0.37994987f, 0.05318024f, -0.03667462f, -0.33747452f, -0.15180254f, -0.22182335f, 0.09885251f, 
    0.01433494f, -0.16801912f, -0.77218449f, 0.15509067f, -0.21554670f, 0.10864037f, 0.17906271f, 0.22386214f, 
    -0.04584851f, 0.14332551f, -0.33737168f, -0.04749329f, -0.19481874f, -0.38720405f, -0.14505495f, -0.23941834f, 
    0.36740756f, -0.17608961f, 0.00686675f, 0.16961822f, -0.01709341f, 0.14646076f, 0.03552241f, -0.12239607f, 
    -0.07950246f, -0.04944417f, -0.00192064f, 0.19608293f, -0.04916869f, -0.01494123f, -0.24019609f, -0.06405979f, 
    -0.33223742f, 0.12313462f, -0.01942983f, -0.19587919f, 0.20732892f, -0.25576219f, -0.21750291f, 0.20620604f, 
    0.22729529f, 0.17400768f, -0.09132527f, 0.04130146f, -0.10219102f, -0.08240321f, -0.00046614f, 0.05522869f, 
    0.02054453f, -0.01773491f, -0.03853851f, 0.23878470f, 0.07034309f, -0.02746123f, -0.12023421f, 0.15764883f, 
    0.17956720f, 0.03630060f, -0.27007958f, 0.10898310f, 0.31039894f, -0.05157324f, -0.07631811f, 0.19728868f, 
    0.02549427f, 0.19850253f, -0.29746783f, 0.13001947f, -0.00880166f, -0.01233517f, -0.41883984f, 0.10656612f, 
    0.04444183f, 0.25308460f, 0.22998771f, 0.10051049f, -0.22086081f, 0.01908427f, 0.01178322f, -0.18384951f, 
    0.02720289f, 0.17082211f, -0.08943681f, -0.16807106f, 0.05025237f, -0.19473268f, 0.18228003f, 0.11829948f, 
    0.10441230f, 0.06627020f, 0.04473155f, 0.17839491f, 0.19029696f, -0.12748562f, -0.00331394f, -0.00553161f, 
    -0.09833243f, 0.16462591f, 0.21843360f, 0.01571315f, -0.23177068f, 0.13616762f, -0.53592163f, 0.21493548f, 
    0.09971011f, 0.00501939f, -0.01147221f, 0.10317092f, -0.00852182f, -0.01104946f, -0.23072451f, -0.12378827f, 
    -0.03079561f, -0.17615955f, 0.03960026f, -0.08412635f, 0.10466699f, 0.01861972f, -0.25702387f, -0.14203787f, 
    -0.29289275f, -0.11892386f, -0.01762585f, -0.01387978f, -0.25009292f, -0.23763736f, -0.32650739f, 0.03433891f, 
    0.32987419f, -0.52950460f, 0.13695863f, -0.17524056f, -0.27403647f, 0.10734774f, -0.16723518f, 0.18304574f, 
    -0.15758361f, -0.05060064f, -0.08352559f, -0.06101979f, 0.02179814f, -0.47420448f, 0.12957726f, 0.08539917f, 
    0.14762035f, -0.23477542f, -0.19064932f, -0.32147196f, 0.10517145f, 0.01961555f, -0.29261976f, -0.24554875f, 
    -0.24692051f, -0.18071501f, -0.09549391f, 0.19976088f, -0.13796234f, 0.02884708f, 0.08679299f, 0.00010102f, 
    -0.33698952f, 0.27696034f, -0.00158170f, -0.32614797f, -0.06153600f, -0.08870304f, -0.33623999f, 0.05808650f, 
    -0.06398923f, 0.00029567f, -0.32793763f, 0.04603418f, 0.11255764f, 0.01481351f, 0.00362514f, -0.18059134f, 
    -0.26311329f, 0.09869917f, -0.17060642f, 0.17175129f, 0.21387465f, 0.06349088f, -0.19625665f, -0.40941751f, 
    -0.11111157f, -0.20226325f, 0.19913296f, 0.33534467f, -0.03216410f, -0.09335364f, -0.07212537f, 0.07090334f, 
    -0.16402030f, -0.12541334f, -0.03749736f, 0.00340064f, -0.05785479f, -0.00008867f, -0.10006291f, 0.15252320f, 
    -0.00764056f, 0.05409578f, -0.23042709f, -0.37900183f, 0.13459298f, 0.06388477f, 0.05249283f, -0.04571367f, 
    -0.18455054f, -0.21545701f, -0.00817545f, -0.30476823f, -0.15253814f, -0.13059200f, -0.05944688f, -0.17811495f, 
    0.22564487f, -0.02707019f, 0.14127719f, 0.14538884f, 0.01417695f, 0.08640287f, -0.01072364f, 0.17116420f, 
    0.06722063f, 0.12583445f, 0.19569412f, -0.02620353f, -0.30833215f, 0.07548705f, -0.38010931f, 0.02027541f, 
    -0.05241733f, -0.30143297f, 0.19239879f, -0.02264753f, 0.04297492f, -0.18328185f, -0.51715302f, -0.19878665f, 
    -0.01958201f, 0.37850961f, 0.08855757f, -0.05540610f, -0.29451200f, -0.00177334f, 0.07403117f, 0.44561493f, 
    0.24595070f, 0.04920018f, 0.04332545f, -0.27562696f, 0.27099422f, -0.04915294f, -0.00598610f, -0.04160800f, 
    -0.09427883f, 0.15052487f, 0.11530437f, 0.15985711f, 0.11524971f, 0.18272549f, 0.07335612f, -0.15861483f, 
    0.22165176f, 0.14167811f, -0.44074515f, -0.05008258f, -0.05151555f, -0.18690754f, 0.05197776f, -0.12112947f, 
    -0.69025761f, -0.00019942f, -0.15996619f, 0.22928491f, -0.24315147f, 0.25569901f, 0.01208226f, -0.29871100f, 
    -0.38894811f, -0.34750435f, 0.32695884f, -0.22867693f, 0.10399380f, -0.02082105f, -0.06500733f, -0.04171708f, 
    -0.14753406f, -0.53333694f, 0.03621984f, -0.02447462f, -0.31129956f, 0.45079222f, 0.22734021f, 0.06114240f, 
    0.12081096f, -0.61977661f, 0.11047284f, -0.03091103f, 0.04242761f, -0.53118360f, 0.00863007f, -0.05181729f, 
    -0.09023410f, 0.19429070f, -0.03533113f, -0.17010285f, 0.04916555f, 0.05560656f, -0.19197278f, 0.09473412f, 
    -0.03258395f, -0.43040293f, -0.16510047f, 0.08760463f, 0.14795363f, 0.17185177f, 0.01192375f, -0.46579918f, 
    -0.00149352f, -0.26537132f, 0.25284782f, -0.01289847f, 0.16220851f, 0.16959247f, -0.28709713f, -0.56162965f, 
    0.03673255f, 0.09710061f, 0.02459314f, 0.11438508f, -0.22568159f, -0.21628474f, -0.43862849f, 0.17868060f, 
    -0.08308556f, 0.00003622f, -0.00372061f, 0.22193131f, -0.28779361f, -0.39210662f, 0.05879299f, -0.23828816f, 
    0.02277532f, -0.28947002f, 0.25733307f, 0.07813537f, -0.12296668f, -0.12644355f, 0.18464518f, 0.18118811f, 
    -0.11169178f, 0.09609330f, 0.23503800f, -0.20786221f, -0.16511875f, 0.23611456f, -0.25832531f, 0.29677960f, 
    -0.54302955f, 0.11771796f, 0.33807054f, 0.05750417f, -0.13452810f, 0.18178652f, 0.17081927f, 0.01188046f, 
    -0.05268339f, -0.65165895f, -0.08746312f, -0.02076332f, -0.37561980f, -0.00983743f, -0.02996858f, 0.11788198f, 
    0.11641352f, 0.09009057f, -0.04980948f, 0.30466184f, 0.23553924f, -0.26621610f, -0.30958235f, 0.21472000f, 
    -0.34320664f, 0.02412141f, -0.16962546f, -0.22078435f, 0.08955137f, -0.06248712f, 0.32382169f, -0.33899933f, 
    0.30982980f, -0.09251928f, 0.11455832f, -0.03776857f, 0.09048925f, -0.25435144f, -0.20914136f, -0.23656522f, 
    0.11230344f, -0.60898644f, -0.00475979f, -0.08324544f, -0.40778145f, 0.10822813f, -0.20966139f, -0.29795143f, 
    0.22100420f, -0.38806427f, -0.17573985f, 0.13972323f, -0.06316575f, 0.00588007f, 0.23261617f, -0.07637744f, 
    0.24431939f, -0.40014762f, -0.01514557f, -0.03808595f, 0.03415820f, -0.45248574f, -0.04110993f, -0.47070950f, 
    -0.28456485f, -0.41311207f, -0.66288811f, 0.04617463f, -0.18592079f, -0.05649032f, -0.06549458f, 0.11352737f, 
    -0.15291548f, -0.45982441f, 0.27828774f, -0.14151946f, -0.29777232f, 0.04893459f, -0.14759390f, -0.20152965f, 
    0.04544693f, 0.24251947f, -0.16754423f, 0.12289336f, -0.08408600f, -0.42049423f, -0.04635499f, 0.19893537f, 
    0.24636778f, 0.11110029f, -0.38236061f, -0.04603169f, -0.00243811f, 0.04864322f, 0.10114124f, -0.39849263f, 
    -0.02747961f, 0.16716118f, 0.12162277f, -0.04386523f, -0.04561196f, 0.01329116f, 0.02512221f, -0.38256702f, 
    0.17327487f, 0.18616937f, 0.05944584f, -0.23270342f, 0.00511586f, -0.35890076f, 0.08197827f, -0.06483421f, 
    0.06597791f, 0.05848008f, -0.59952950f, -0.26720303f, 0.09239921f, -0.29755548f, -0.23514515f, 0.03721558f, 
    -0.09036812f, -0.17464605f, -0.14722417f, -0.09333875f, -0.11687947f, -0.17475721f, 0.08382170f, -0.00922576f, 
    -0.43140990f, -0.26832923f, -0.18809551f, 0.28547406f, 0.16026881f, -0.42241651f, -0.14997551f, 0.16830529f, 
    -0.04212183f, 0.31495595f, 0.01198125f, 0.07931332f, 0.35024157f, -0.03595604f, -0.19901951f, 0.06478217f, 
    -0.18409732f, -0.48547295f, 0.06754613f, 0.01677636f, -0.09828565f, 0.08352968f, -0.04741923f, -0.09607579f, 
    0.00219069f, -0.02258365f, -0.29890609f, -0.18428186f, -0.28906584f, -0.01062337f, -0.11494525f, 0.17940393f, 
    -0.45955902f, -0.08916766f, -0.19169731f, 0.01937711f, -0.25252226f, -0.30999172f, -0.09480986f, 0.04472158f, 
    -0.07686383f, -0.23923646f, 0.06828833f, -0.23571178f, 0.34165677f, 0.02300359f, 0.12088237f, -0.38597611f, 
    0.05963891f, -0.09888513f, -0.01704258f, 0.05199461f, -0.26035136f, -0.05494628f, -0.33768612f, -0.07060786f, 
    -0.16304488f, 0.05642827f, -0.02036114f, 0.22048043f, -0.09726054f, -0.23857465f, -0.40907255f, 0.15425393f, 
    0.24118936f, 0.26205164f, 0.41535378f, -0.11839969f, 0.08175494f, 0.14841111f, -0.01803598f, -0.49148482f, 
    -0.02774303f, -0.06053473f, -0.24820912f, -0.19701110f, -0.03370095f, 0.00685307f, -0.11678277f, -0.16763471f, 
    -0.04523136f, -0.11355043f, 0.21230114f, -0.07660855f, -0.28913671f, 0.14330854f, 0.06859151f, -0.19537470f, 
    -0.28664255f, 0.20429102f, -0.33514637f, -0.43043694f, -0.08443620f, -0.23006621f, -0.29179615f, 0.15525591f, 
    0.00742141f, -0.22260176f, -0.35395530f, -0.31723627f, 0.11202271f, 0.11926582f, 0.17222142f, 0.13858503f, 
    0.21560042f, -0.41122976f, -0.05731041f, 0.23197573f, 0.42911831f, -0.16792318f, 0.05440387f, -0.12535301f, 
    0.17431530f, 0.35272178f, 0.02835882f, 0.09698577f, 0.19475324f, 0.17840548f, -0.11784727f, -0.20544589f, 
    0.00307553f, -0.03611087f, -0.12915878f, 0.05282702f, 0.26206672f, -0.40071812f, 0.02416284f, -0.15076526f, 
    0.35487661f, -0.27752066f, -0.32512677f, 0.10332964f, -0.37950626f, 0.03142010f, -0.12946332f, -0.07826818f, 
    -0.03042883f, -0.01689949f, 0.22750214f, 0.17257400f, 0.16007644f, 0.03886596f, 0.22873828f, -0.02476699f, 
    -0.10710204f, 0.21206737f, -0.07771932f, 0.00953773f, -0.18343942f, 0.24120291f, 0.22798358f, -0.32579681f, 
    -0.08709149f, 0.41612664f, -0.38491833f, 0.05879877f, 0.06026902f, -0.36022365f, -0.12736665f, -0.27152443f, 
    -0.34144932f, -0.47244418f, -0.39945906f, -0.07544628f, 0.11116247f, 0.17352694f, -0.20935062f, 0.27921224f, 
    -0.20994510f, -0.05402708f, -0.01460957f, -0.31106457f, -0.08580946f, -0.37834466f, -0.12726924f, 0.17509677f, 
    0.34049171f, 0.09156027f, 0.12956879f, -0.31715336f, 0.11205092f, 0.02814669f, -0.31847829f, 0.00267953f, 
    -0.37755856f, -0.10322674f, -0.07372023f, -0.19541353f, -0.31574589f, 0.11363383f, 0.01758070f, -0.06500485f, 
    -0.30707279f, -0.08708180f, -0.28535575f, -0.39000997f, -0.05497649f, -0.24450122f, -0.03057187f, 0.00510386f, 
    -0.00173520f, 0.10544748f, 0.31075490f, -0.27693978f, -0.07682604f, 0.04671450f, -0.13744247f, 0.18958375f, 
    -0.35940909f, -0.16005492f, 0.11907165f, 0.04326278f, -0.18189505f, 0.24373463f, -0.07615524f, -0.19238631f, 
    -0.55586064f, -0.01350694f, -0.28861138f, 0.20814304f, -0.06621239f, -0.00952156f, -0.44719383f, 0.05607937f, 
    0.02215580f, -0.08860032f, -0.07045401f, -0.26831678f, -0.54721576f, 0.05476233f, -0.06116291f, 0.11122531f, 
    0.30435351f, 0.05766895f, -0.02733680f, -0.37718469f, 0.05627560f, 0.81387836f, 0.24016136f, -0.16569822f, 
    -0.16577846f, -0.34478629f, 0.11803801f, 0.10317537f, 0.28151542f, 0.25851339f, -0.26193061f, -0.34197760f, 
    0.01055896f, 0.01928470f, 0.07424810f, -0.37069425f, 0.33817205f, 0.26532376f, -0.13786161f, 0.14485385f, 
    0.00875401f, -0.33246928f, 0.26131472f, 0.26058295f, 0.03881579f, 0.15746990f, 0.14819559f, -0.41287166f, 
    0.02284051f, 0.33135688f, 0.14087163f, -0.19932973f, 0.14402635f, -0.06067544f, 0.00464154f, -0.32205042f, 
    0.21289803f, 0.10420207f, 0.02102009f, 0.18145792f, 0.26229864f, -0.06987144f, -0.25313249f, -0.66171801f, 
    -0.38478389f, 0.23423566f, 0.32228392f, -0.10858466f, 0.02112814f, -0.21302952f, -0.35188839f, 0.09471221f, 
    0.13582434f, -0.05275453f, 0.14281489f, -0.04542709f, 0.02250303f, -0.19705105f, -0.64413822f, 0.04918385f, 
    -0.37965271f, -0.22157331f, -0.29359561f, 0.00720440f, -0.01134265f, -0.13495557f, -0.33664545f, 0.35709921f, 
    -0.44661960f, 0.02202985f, -0.13787241f, 0.11898254f, -0.11468612f, -0.06127726f, -0.14983584f, -0.06589164f, 
    0.04432436f, -0.02115318f, -0.02806276f, -0.05310417f, -0.18345261f, -0.20049876f, -0.00931710f, -0.06269021f, 
    -0.25890875f, -0.12710494f, -0.21454901f, -0.22302932f, -0.62129468f, -0.05945139f, -0.05494665f, -0.23117481f, 
    0.20322821f, 0.10380039f, -0.41392493f, 0.01390380f, -0.23198192f, -0.05414688f, -0.06407948f, 0.08525707f, 
    -0.29090500f, 0.09828131f, -0.24636292f, -0.00450208f, -0.32550323f, 0.21380554f, 0.04875403f, 0.26040074f, 
    -0.12207032f, 0.23601423f, -0.45038313f, -0.07216179f, -0.64153820f, -0.04676910f, 0.30416805f, 0.02685289f, 
    0.08164902f, -0.17459397f, -0.43283656f, 0.14541093f, 0.23561110f, -0.12257957f, 0.18879110f, -0.14543672f, 
    -0.06485341f, -0.20237902f, 0.02198322f, 0.05650902f, -0.06267238f, -0.49514440f, -0.48420498f, 0.09793145f, 
    -0.31742924f, 0.17597535f, -0.00072493f, -0.57853132f, -0.27860573f, 0.19919552f, 0.05605084f, -0.22256790f, 
    0.15228018f, 0.11942143f, -0.14444363f, 0.18340129f, 0.23955974f, -0.05889226f, -0.07311063f, -0.52898592f, 
    0.19297981f, 0.09040146f, -0.75773025f, -0.54831946f, -0.00446333f, -0.21092081f, 0.48626947f, 0.06033716f, 
    -0.05397863f, 0.08814215f, 0.01052359f, -0.53554058f, -0.27150756f, -0.05671250f, 0.10712860f, -0.43753260f, 
    -0.25607494f, 0.12080322f, 0.05929370f, -0.11203932f, -0.17647399f, 0.05482549f, 0.20820634f, -0.28091508f, 
    -0.00237813f, -0.23430006f, -0.01217835f, 0.29656330f, 0.10822576f, 0.18437396f, -0.06519425f, 0.17913300f, 
    0.09808608f, -0.00755284f, -0.37199387f, -0.03598043f, -0.17875794f, 0.17587008f, -0.00254699f, -0.15756983f, 
    0.08721514f, 0.01982604f, 0.08442410f, 0.29388928f, -0.48466644f, -0.16929893f, 0.02559288f, 0.22449453f, 
    0.27922243f, -0.05634331f, -0.02042652f, -0.12454528f, 0.03619288f, -0.07145301f, -0.33504316f, 0.02287133f, 
    -0.07696224f, 0.16909148f, 0.02444442f, -0.07687657f, 0.16448599f, 0.32622781f, 0.04408101f, 0.07775948f, 
    -0.08960838f, -0.12028490f, 0.01612242f, -0.06242358f, -0.16905275f, 0.07993734f, -0.08739904f, 0.01477788f, 
    0.19034094f, -0.04350026f, -0.26369995f, 0.12601493f, -0.23023060f, -0.02988192f, -0.22087827f, 0.24934174f, 
    0.13973136f, -0.05709647f, -0.14454041f, -0.17532219f, 0.20329529f, 0.12864333f, 0.06865510f, -0.03193506f, 
    -0.01998206f, 0.07468228f, 0.04484580f, -0.04819562f, 0.18484202f, 0.23440693f, -0.09974009f, 0.38596046f, 
    0.06116356f, 0.06715752f, -0.05226637f, 0.02853169f, -0.10403571f, -0.13015226f, 0.20976113f, 0.15697159f, 
    -0.39718711f, 0.00294178f, 0.05050594f, -0.31285328f, 0.18723159f, -0.50779051f, 0.04173092f, -0.33772862f, 
    -0.21213007f, -0.25137690f, -0.05040505f, -0.44940090f, -0.46586266f, 0.07599261f, 0.20835425f, 0.10391763f, 
    -0.15490842f, 0.02476982f, -0.31860459f, -0.55931437f, -0.18127178f, -0.34105191f, 0.32153988f, -0.01383266f, 
    0.17176051f, 0.31742114f, -0.16357985f, -0.11031488f, -0.15290123f, -0.00442275f, -0.28247234f, 0.13633239f, 
    0.02330535f, -0.28173035f, -0.18989635f, -0.05429721f, 0.09958798f, -0.09958719f, -0.24687478f, -0.10971751f, 
    -0.22555822f, 0.00166559f, -0.06653570f, 0.00270074f, -0.22811429f, -0.11005479f, -0.14746866f, -0.03623168f, 
    -0.10034111f, -0.05165054f, -0.39946070f, 0.15215902f, -0.04441494f, -0.10005437f, 0.05307622f, -0.12906902f, 
    0.07707562f, 0.10821313f, -0.20167850f, -0.03180566f, 0.04085414f, 0.54423326f, -0.30016071f, 0.08738487f, 
    0.20685160f, 0.49089891f, 0.36145151f, -0.25716951f, -0.23613824f, -0.20388934f, 0.07691542f, 0.13587600f, 
    -0.22474743f, -0.29680565f, -0.15397835f, 0.18398669f, -0.14646626f, -0.02018619f, 0.31655470f, -0.04113383f, 
    0.26619065f, -0.31497580f, -0.06169201f, 0.26573619f, -0.00804022f, 0.18128352f, 0.06817096f, -0.04474418f, 
    -0.08380728f, -0.18610881f, 0.09942346f, 0.09982332f, -0.32907507f, 0.18121719f, -0.04305400f, 0.03527588f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.06786620f, 0.02412559f, -0.01208648f, -0.10447068f, -0.02379667f, 0.01683134f, 0.00522630f, -0.24550353f, 
    -0.08616553f, -0.04156625f, 0.13040218f, -0.09537775f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
