#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.42299667f, -0.85405517f, -0.48933387f, 0.11779284f, -0.45767379f, -0.03586671f, -0.02422720f, 0.19947940f, 
    0.20500104f, 0.27236551f, 0.06331854f, 0.46806216f, -0.35405266f, 0.56509322f, -0.28262910f, -0.41535029f, 
    -0.36929289f, -0.20189835f, 0.01263981f, -0.32112455f, -0.50754100f, 0.40090933f, 0.05073569f, -0.02222376f, 
    0.48235866f, 0.27626812f, 0.06977423f, 0.13370895f, 0.32758120f, 0.01925508f, -0.15794528f, -0.04306798f, 
    -0.20895010f, 0.09594569f, 0.01991703f, 0.57901013f, -0.48466328f, -0.40535775f, 0.52233285f, -0.23137175f, 
    -0.23262894f, -0.08589146f, 0.28248289f, -0.00634475f, -0.05433602f, 0.20089823f, -0.03455232f, -0.37167701f, 
    0.13412419f, 0.39335960f, 0.14225064f, -0.65751362f, 0.10535815f, 0.57646024f, 0.29483041f, -0.73227400f, 
    -0.41993627f, -0.42146501f, -0.06690561f, 0.29027385f, -0.14323163f, 0.40095150f, 0.11550003f, -0.00005065f, 
    -0.39150479f, -0.24632886f, 0.02426197f, 0.35803562f, 0.08337053f, -0.31934038f, 0.13650958f, -0.13889669f, 
    -0.15803494f, 0.34916136f, 0.43173331f, -0.48009938f, -0.33805993f, -0.47685093f, -0.57475024f, -0.43040574f, 
    -0.51705843f, -0.41022387f, -0.50551856f, -0.31950337f, -0.50978917f, 0.05790680f, 0.41238305f, 0.09751455f, 
    -0.17301515f, -0.01810933f, 0.24284913f, 0.19692039f, -0.13648488f, 0.24047087f, 0.29832593f, 0.02350988f, 
    0.01900174f, -0.29442465f, -0.34184930f, -0.04422024f, -0.56065327f, -0.46516684f, -0.63669163f, -0.56902391f, 
    0.24609497f, -0.20241912f, -0.05086382f, 0.42107502f, -0.03557421f, -0.26562220f, -0.30150378f, -0.49527302f, 
    -0.41114938f, 0.34424058f, -0.47573122f, 0.29474044f, -0.17979436f, -0.15059741f, -0.32254195f, -0.51584470f, 
    -0.55754256f, -0.30639422f, -0.39102003f, -0.36357045f, -0.59867674f, 0.33392614f, 0.23216005f, 0.27308717f, 
    0.10056005f, -0.17788446f, 0.32832491f, 0.43174532f, 0.05472920f, -0.30842429f, -0.02514524f, -0.42405155f, 
    0.61139488f, 0.06191213f, -0.20943630f, -0.21709724f, -0.14089115f, -0.25814578f, -0.20250973f, -0.24659239f, 
    0.54595196f, -0.04095066f, -0.12814394f, 0.26738781f, -0.01676911f, 0.14267814f, -0.14130273f, -0.28171283f, 
    -0.96363091f, -0.63945735f, -0.21765271f, 0.03646567f, 0.06502464f, 0.47329149f, -0.16887270f, -0.12973565f, 
    -0.31961757f, 0.42894402f, -0.29055050f, -0.58034253f, -0.54350823f, -0.02365217f, -0.02223568f, 0.03705856f, 
    0.36323634f, 0.64848077f, 0.12036096f, -0.16597129f, -0.20741360f, 0.61639661f, 0.20188519f, 0.39194062f, 
    0.93199790f, 0.29901028f, 0.05510631f, -0.15594006f, -0.93889272f, -0.91333479f, -0.19788438f, 0.48738280f, 
    0.37446749f, -0.37699613f, -0.50124991f, -0.15358958f, 0.25564098f, 0.13109799f, 0.11385426f, 0.28359976f, 
    0.49994332f, -0.00041767f, -0.29009998f, -0.27803856f, 0.01229758f, -0.33391541f, 0.00921498f, -0.34724340f, 
    -0.66842628f, -0.52388388f, -0.59334803f, -0.15426005f, 0.12572037f, -0.29100972f, -0.48395362f, -0.14025229f, 
    0.71826261f, -0.43862382f, 0.00582618f, 0.28040633f, -0.26638511f, -0.12348095f, 0.24478371f, 0.06843451f, 
    -0.03988042f, 0.05101630f, -0.25711128f, -0.38679677f, 0.24153160f, 0.57036477f, 0.06324951f, 0.17164753f, 
    0.30940089f, 0.19655190f, -0.10327567f, -0.12937178f, 0.46396849f, -0.13397303f, -0.07498208f, -0.21165179f, 
    0.21818613f, -0.14237201f, -0.08899447f, 0.12824854f, 0.15177000f, -0.38889137f, -0.20072587f, 0.54301620f, 
    0.03624219f, 0.24492714f, -0.48808050f, 0.16846429f, -0.03762610f, 0.13438094f, -0.02906935f, -0.41285932f, 
    0.20777726f, 0.56987870f, -0.01176901f, 0.24893770f, 0.17357554f, -0.05330194f, -0.22154038f, 0.52690518f, 
    0.13038908f, -0.43785006f, -0.43508899f, 0.49150339f, 0.45169610f, 0.34188884f, -0.41267839f, -0.72032529f, 
    0.25618896f, -0.17704123f, -0.34000954f, 0.30919170f, 0.29250595f, -0.04369105f, -0.26039150f, 0.10552880f, 
    -0.10159359f, -0.39033878f, 0.60218161f, 0.83582556f, 0.21212134f, -0.12629050f, 0.10459487f, 0.81671268f, 
    -0.31230995f, -0.11592441f, -0.51854295f, -0.60057145f, -0.04658023f, -0.01674699f, 0.10123555f, 0.06602868f, 
    -0.01545083f, -0.14605357f, -0.16720869f, 0.27206159f, -0.08917579f, -0.00559872f, -0.02268004f, 0.00699001f, 
    -0.12427697f, 0.22280820f, 0.40141442f, -0.19500449f, -0.35046324f, -0.47505575f, -0.75046647f, -0.63825649f, 
    -1.08505547f, 0.88594991f, 0.18423399f, 0.23520689f, -0.28936547f, -0.26532874f, -0.30968389f, -0.22886926f, 
    0.01424271f, 0.10670032f, 0.28838742f, -0.23126118f, 0.02506958f, 0.16756082f, -0.32114044f, -0.07016430f, 
    -0.34053382f, -0.38285020f, 0.20814358f, -0.14566308f, 0.12453829f, 0.07610498f, -0.12971470f, 0.07444350f, 
    0.44188219f, 0.29434291f, 0.26613450f, 0.31494963f, 0.38072461f, 0.37151861f, 0.05947726f, 0.21453446f, 
    0.13146640f, 0.21970643f, -0.03310005f, 0.02893442f, 0.09369746f, 0.12955308f, -0.08777657f, 0.03023942f, 
    -0.24032311f, 0.08512489f, -0.08143499f, -0.04306963f, 0.17571507f, -0.03977686f, 0.83614647f, 0.25877899f, 
    0.38770178f, -0.20765461f, -0.09631988f, -0.10590073f, 0.27428541f, 0.37773106f, -0.06136936f, -0.15072736f, 
    0.20636339f, 0.31457800f, -0.37204683f, -0.51357961f, 0.15220845f, -0.16199841f, 0.18703182f, -0.17477676f, 
    0.15588231f, -0.28232762f, 0.32622200f, 0.10766438f, -0.32266897f, -0.28320727f, -0.18411931f, -1.03384829f, 
    -0.60189939f, 0.30948773f, 0.38172522f, 0.26893732f, 0.17501046f, -0.30503207f, -0.01631117f, 0.54465717f, 
    0.14933823f, -0.06295297f, -0.53745288f, 0.46735716f, 0.13744009f, -0.34855449f, -0.57742518f, 0.29930732f, 
    0.14527373f, 0.06945433f, 0.15092543f, 0.18083324f, 0.17999698f, -0.28307852f, -0.26614085f, 0.21474111f, 
    -0.02737492f, -0.75699735f, -0.50406414f, -0.30016324f, -0.41953337f, 0.49579260f, -0.13024998f, 0.37224922f, 
    0.53313744f, 0.10187147f, 0.27353534f, 0.07037712f, -0.01122873f, -0.00015193f, 0.07981754f, -0.07725506f, 
    0.27532938f, -0.07789253f, -0.28399813f, -0.20173664f, -0.33554602f, -0.07974385f, -0.21661729f, -0.14523835f, 
    -0.41107050f, 0.38232952f, -0.00203218f, 0.29612297f, 0.00891983f, 0.55927730f, -0.31601617f, -0.01534655f, 
    0.11033844f, -0.01321255f, 0.57661086f, 0.18820083f, 0.29801682f, -0.22199412f, -0.29007795f, 0.39405024f, 
    0.07383934f, -0.09937377f, -0.17665869f, 0.02768817f, -0.31159064f, -0.09478389f, -0.10328817f, 0.31050664f, 
    -0.21688710f, -0.19651155f, -0.08837060f, 0.03385182f, -0.44805413f, 0.05149177f, -0.49476847f, -0.72999167f, 
    -0.71867025f, -0.71374488f, -0.57997078f, -1.07741416f, -0.03380518f, 0.08295330f, 0.37539724f, 0.70151985f, 
    0.09075632f, 0.12245870f, -0.28519693f, 0.03899352f, -0.41428965f, -0.31941846f, -0.30700013f, -0.03574121f, 
    -0.31023842f, 0.14215635f, 0.17312898f, -1.25369489f, -0.47000837f, 0.01118441f, -0.87095159f, -0.53731132f, 
    0.84913701f, 0.08011407f, -0.03776186f, 0.41749936f, 0.43205732f, -0.37979153f, -0.22763777f, 0.08251056f, 
    0.40018719f, 0.17982261f, 0.18367845f, -0.11497841f, -0.07810903f, -0.20115194f, 0.13214132f, 0.00517182f, 
    0.31504551f, 0.43653756f, -0.07980449f, -0.24384326f, -0.13080122f, -0.19782478f, -0.41012034f, 0.18191414f, 
    0.01184566f, 0.56889600f, 0.27691582f, 0.13937646f, -0.04024772f, 0.37074351f, -0.06080849f, 0.42148414f, 
    -0.07850684f, -0.19210035f, 0.48862633f, -0.39877978f, -0.24223426f, 0.19704944f, -0.31699938f, -0.21356088f, 
    -0.22989404f, -0.05641799f, 0.33923823f, 0.53579748f, 0.39286286f, 0.47646049f, 1.09396589f, 0.06886593f, 
    -0.69826978f, -0.53798372f, -0.08789837f, -0.04932791f, -0.06274480f, -0.28831640f, -0.32676873f, 0.06266754f, 
    0.44058084f, -0.10135189f, 0.24605285f, -0.02032740f, -0.16262800f, -0.05784762f, -0.15233818f, 0.28151613f, 
    -0.22623527f, 0.10801970f, 0.28457913f, 0.21346186f, 0.02848370f, 0.25178516f, -0.52735245f, -0.29908824f, 
    0.11009474f, 0.24613354f, 0.06208209f, -0.00051514f, 0.13760105f, 0.16978781f, -0.03544689f, 0.43378752f, 
    0.17850052f, -0.01823606f, 0.11180671f, 0.02053409f, -0.09308220f, -0.22553910f, -0.04109959f, 0.11041339f, 
    -0.35854575f, -0.13603282f, 0.34425476f, 0.47303966f, 0.04990232f, -0.05056393f, 0.28977007f, -0.06815735f, 
    0.09714568f, 0.55549783f, -0.66004610f, -0.95419812f, 0.29235920f, -0.03381920f, 0.29587516f, 0.80115074f, 
    0.25057176f, -0.03310396f, -0.43317211f, -0.47395891f, -0.34165153f, -0.00085931f, 0.12240761f, 0.18769039f, 
    -0.40983841f, -0.35854620f, 0.16870214f, -0.31411859f, 0.21786964f, 0.23254026f, -0.04169267f, 0.19109094f, 
    -1.18548894f, -0.65220737f, -0.39280480f, -0.45124537f, 0.16473752f, 0.25170681f, -0.04053435f, -0.93123466f, 
    -0.78272015f, 0.30002496f, -0.00034277f, -0.29457596f, -0.49821138f, -0.55523360f, -0.14858423f, -0.26042113f, 
    -0.14376333f, -0.26198432f, -0.22092812f, -0.49521089f, 0.14004585f, -0.24262249f, 0.01364737f, -0.08779945f, 
    -0.05757770f, -0.18985578f, 0.51051390f, 0.28614599f, 0.13342312f, 0.36715221f, -0.57859856f, -0.41913798f, 
    -0.15947516f, 0.31148455f, 0.05442756f, 0.25716156f, 0.05849347f, -0.34804696f, -0.38327965f, -0.04369158f, 
    -0.06462756f, 0.28428686f, 0.10695378f, 0.13425554f, 0.36189502f, -0.05895343f, -0.06613189f, -0.37167746f, 
    -0.44848123f, -0.20224991f, 0.72002351f, 0.88645881f, 0.34017804f, 0.33166805f, -0.29454789f, -0.68906468f, 
    -0.52568352f, 0.05841148f, 0.37537315f, -0.13478084f, 0.18899058f, -0.09531588f, -0.06911402f, -0.10888074f, 
    -0.48368213f, -0.18371695f, 0.15679960f, -0.11731994f, 0.07155831f, 0.10908018f, 0.00015335f, 0.05162251f, 
    -0.20765899f, 0.10339281f, 0.15895039f, -0.84445578f, -0.20122078f, 0.67214262f, 1.06636500f, -0.23613642f, 
    0.54265255f, -0.65331864f, -0.48020494f, -0.14649995f, 0.10325728f, -0.34138501f, -0.14455509f, -0.18052058f, 
    0.29696503f, 0.38221210f, -0.22439432f, 0.04373975f, -0.18249752f, -0.24622370f, 0.01915282f, -0.02028950f, 
    -0.24784715f, 0.14768158f, -0.07707415f, -0.56193537f, -0.04675223f, -0.24049771f, 0.00781529f, 0.27107206f, 
    0.54946882f, -0.07104653f, -0.00964189f, -0.21946792f, 0.43692642f, 0.39220166f, 0.01868202f, 0.02747072f, 
    -0.13761392f, 0.07754894f, 0.25879833f, -0.30133998f, -0.28744391f, -0.23733371f, 0.35749519f, -0.25366461f, 
    0.07983911f, 0.13371190f, -0.34185842f, 0.30759445f, 0.39613682f, -1.08137441f, -0.50426030f, -0.78258061f, 
    0.03282900f, 0.31128231f, 0.18936221f, 0.46589479f, 0.52623326f, 0.63550234f, 0.48073882f, -0.06281018f, 
    0.32740822f, -0.08020008f, 0.27196190f, -0.43550318f, -0.08616211f, 0.10970943f, 0.07573703f, -0.16989292f, 
    0.01463495f, 0.06235083f, -0.21018824f, -0.00256516f, 0.22367014f, -0.29236123f, -0.70095825f, -0.25243974f, 
    0.02015781f, 0.06350575f, -0.20706634f, -0.57970476f, -0.17440188f, -0.50902975f, -0.81980491f, -0.64646608f, 
    0.78244692f, -0.89642012f, 0.37097725f, -0.27144369f, -0.27707401f, 0.15231648f, -0.53187728f, -0.09806432f, 
    0.07183023f, -0.35318524f, -0.01880586f, 0.08941109f, -0.04619385f, -0.01695894f, 0.09350096f, 0.34190029f, 
    0.79251778f, -0.51440591f, -0.95119071f, -1.20003748f, 0.17755227f, 0.63436145f, 0.83737344f, -0.27939996f, 
    -0.62120908f, -0.39364299f, 0.57372469f, -0.15137094f, -0.05119241f, -0.18184820f, 0.00097711f, -0.32602668f, 
    -0.31055063f, -0.10728440f, -0.24890648f, 0.11590816f, 0.13385551f, -0.36911386f, 0.08180851f, -0.20113981f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21404967f, 0.04579846f, 0.50886500f, -0.21808761f, 0.18967538f, 0.43739080f, 0.10444826f, 0.35266027f, 
    -0.00028933f, 0.18984294f, 0.49250063f, 0.20885380f, 0.11107256f, -0.10227256f, 0.25235367f, 0.23794548f, 
    0.03125925f, 0.12999636f, 0.01783294f, 0.29049289f, 0.09363280f, 0.39240503f, 0.03304935f, 0.21033663f, 
    -0.20057468f, 0.10043194f, 0.27851000f, 0.01603710f, 0.37345505f, 0.04419103f, -0.04142082f, 0.49546191f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04325243f, -0.04714373f, 0.01442609f, 0.02333911f, -0.01667470f, -0.03922013f, 0.04783529f, 0.04830596f, 
    0.01521494f, -0.02669487f, 0.00941644f, -0.03799971f, -0.05030815f, -0.02548688f, -0.02273623f, -0.03077650f, 
    -0.01300330f, 0.01507709f, 0.02226470f, -0.00703675f, -0.00265247f, -0.04376765f, -0.02201642f, 0.04030013f, 
    -0.04719071f, -0.03217447f, -0.04661498f, -0.00160778f, 0.04347366f, 0.01400338f, -0.02259490f, 0.02426497f, 
    0.03066373f, -0.03084037f, 0.01184787f, 0.01619161f, -0.00294455f, -0.03714978f, 0.04608821f, 0.03273701f, 
    -0.03423437f, 0.04543070f, 0.04591492f, -0.01596457f, -0.00085268f, 0.03166129f, 0.03850568f, -0.01464488f, 
    0.02323221f, 0.02595593f, -0.00504468f, -0.04080446f, 0.01259412f, -0.03455388f, 0.04985526f, 0.01756943f, 
    -0.00765964f, -0.02610424f, -0.02315628f, -0.02740503f, 0.03026098f, -0.03621711f, 0.03503604f, -0.04364216f, 
    0.02016704f, 0.03459312f, -0.04571283f, -0.04287921f, 0.03785762f, -0.02130759f, 0.01056678f, 0.03376529f, 
    0.00580622f, 0.02868436f, 0.00416760f, -0.00612060f, 0.03984416f, -0.05094292f, 0.03413437f, -0.04872588f, 
    0.03764466f, -0.04596160f, -0.00157827f, -0.03002186f, 0.02386658f, -0.03999712f, 0.04766337f, -0.03951383f, 
    -0.01822432f, -0.00301105f, -0.02537003f, -0.01003539f, 0.00500465f, -0.01757638f, 0.01035626f, -0.02205106f, 
    -0.03418164f, 0.01396697f, -0.01543069f, -0.02666383f, -0.04104707f, 0.04443931f, -0.00765047f, 0.03631605f, 
    -0.02995949f, -0.03070959f, -0.03302564f, -0.04241905f, -0.02397639f, 0.02421151f, -0.04927707f, -0.04376752f, 
    0.00117590f, -0.04459934f, -0.00275479f, 0.00711253f, 0.03807814f, 0.04858999f, 0.02398514f, -0.01422786f, 
    -0.04567163f, 0.00241006f, 0.02977991f, 0.04371386f, 0.00689689f, 0.01503913f, 0.02941372f, -0.04595935f, 
    0.03012886f, 0.01512668f, -0.01472349f, 0.02202203f, -0.02680314f, -0.04215084f, 0.02895186f, 0.02972264f, 
    -0.02160727f, 0.04051714f, 0.02192593f, -0.01837138f, 0.02017508f, 0.02862202f, 0.02404653f, 0.02313225f, 
    -0.03829182f, -0.04399581f, -0.03951648f, 0.02853031f, -0.02990112f, -0.03484631f, 0.01904292f, -0.00806536f, 
    -0.04226934f, -0.04034763f, -0.04222303f, 0.03324059f, 0.03699080f, -0.01536818f, 0.04062143f, -0.04161257f, 
    0.04315967f, -0.04042099f, -0.01151812f, 0.04647652f, -0.04940243f, 0.00638130f, -0.01758938f, -0.00033350f, 
    0.02966622f, -0.01428253f, 0.01975702f, 0.04867302f, 0.02547301f, 0.05028063f, -0.04950707f, -0.03950468f, 
    -0.04334992f, -0.02419837f, -0.03928107f, 0.00107708f, -0.00275590f, -0.01350191f, -0.01976110f, 0.01834000f, 
    0.01864843f, 0.00327793f, -0.00411924f, 0.01937485f, 0.02336786f, -0.03493927f, -0.01472715f, -0.01899786f, 
    -0.04957819f, -0.00317839f, 0.04726984f, -0.03505607f, -0.04415347f, -0.01651483f, -0.00075922f, -0.02898947f, 
    0.00183371f, 0.01889652f, -0.04063344f, -0.03117107f, -0.00982383f, -0.02246598f, -0.01150023f, 0.00295383f, 
    -0.00779434f, -0.00515701f, -0.04706600f, -0.01202339f, 0.00649299f, -0.02246061f, -0.00180817f, 0.02320342f, 
    0.02802888f, 0.02657383f, 0.04083260f, 0.04875920f, -0.04148155f, -0.00009587f, 0.04431469f, -0.02149787f, 
    0.04748280f, 0.03703762f, -0.03334992f, 0.00293370f, 0.01871214f, -0.01362701f, -0.04473609f, -0.03828017f, 
    -0.02003877f, 0.00827468f, -0.04515518f, -0.04592476f, -0.03775062f, -0.01545286f, 0.03663228f, -0.03156982f, 
    -0.02693777f, -0.00727252f, 0.00417097f, -0.03865704f, 0.00267009f, 0.04753556f, -0.04239174f, -0.02001963f, 
    -0.00861698f, -0.04065391f, 0.04315674f, 0.01868169f, -0.04483422f, -0.00547509f, 0.04269429f, 0.01570702f, 
    -0.02155451f, -0.02124166f, -0.01248864f, 0.02675607f, 0.02137295f, -0.04716563f, 0.02746564f, 0.00428435f, 
    -0.03701524f, -0.02263926f, -0.00886789f, 0.02205440f, -0.03337803f, 0.01880365f, -0.01415166f, 0.04940133f, 
    0.03003740f, -0.04823779f, 0.00221849f, 0.04977955f, 0.00131827f, -0.04867936f, 0.01986988f, 0.02945331f, 
    0.03563867f, 0.03749318f, 0.02224288f, -0.01369608f, -0.05069412f, -0.00267421f, -0.02799361f, -0.04614737f, 
    0.03609340f, -0.04306814f, -0.02202155f, -0.04879582f, -0.03179279f, 0.02883587f, -0.02340101f, -0.04531875f, 
    0.03952308f, 0.01237352f, -0.00976962f, -0.00494232f, 0.03321404f, -0.04449802f, -0.02917570f, 0.02558828f, 
    0.03160546f, -0.04051281f, -0.01280947f, 0.00214394f, -0.03625857f, -0.03085344f, 0.04830133f, -0.02721077f, 
    -0.00610310f, -0.02877651f, -0.04877391f, -0.05036540f, -0.00039596f, -0.01702135f, -0.00202385f, -0.04120007f, 
    0.01669111f, -0.00456020f, 0.00637964f, 0.03291043f, 0.00674143f, 0.04535207f, -0.05090078f, 0.03691284f, 
    -0.01155847f, 0.01415672f, -0.05092564f, -0.03473274f, -0.00127139f, -0.05070984f, 0.02313877f, 0.00795696f, 
    -0.02506305f, 0.04226320f, -0.00815102f, -0.01788783f, -0.00344588f, -0.04035482f, -0.02949844f, -0.04296010f, 
    -0.00580873f, 0.04274588f, 0.01351218f, 0.01652420f, -0.00318847f, -0.02857088f, -0.01206947f, -0.02374893f, 
    -0.00864842f, 0.01830611f, 0.03301458f, 0.01914706f, 0.00503121f, 0.00797900f, -0.03565047f, -0.02240295f, 
    -0.04156505f, -0.04212943f, -0.02565932f, -0.02450053f, 0.01721391f, 0.03003260f, 0.00848691f, 0.03850356f, 
    -0.05080755f, 0.02191686f, 0.04028346f, 0.03399725f, 0.01956857f, -0.01353122f, -0.00024147f, -0.04736758f, 
    0.04125272f, -0.00685212f, -0.01771943f, 0.01099550f, -0.03916318f, 0.04281666f, -0.03568019f, 0.01985237f, 
    -0.03628296f, 0.01053844f, -0.03402736f, -0.01285176f, -0.01445080f, 0.05083717f, -0.00426721f, 0.02673881f, 
    -0.02767418f, -0.00075203f, -0.02825919f, 0.02172485f, -0.00350211f, 0.02854797f, -0.01186636f, 0.01691999f, 
    -0.02960651f, 0.02355047f, -0.02903631f, -0.04436429f, 0.01879733f, -0.01887443f, -0.00456108f, -0.04957858f, 
    -0.01971587f, -0.01027037f, -0.04505841f, 0.02216655f, 0.00663060f, -0.00443003f, 0.03718259f, -0.05305289f, 
    0.00534407f, -0.05330243f, 0.04724964f, -0.03446094f, -0.02608972f, 0.01823562f, -0.03508801f, -0.05442981f, 
    -0.04308441f, 0.01625441f, 0.03256290f, 0.01056073f, -0.05807100f, -0.03810528f, -0.01140210f, -0.02892638f, 
    0.02066222f, 0.02553123f, -0.04817033f, 0.03330573f, 0.04490595f, -0.03881516f, 0.03321687f, 0.00287078f, 
    -0.01203582f, 0.04145355f, -0.00638630f, -0.00757674f, 0.02914069f, 0.00835451f, -0.03319307f, 0.00995915f, 
    -0.04886257f, -0.00051690f, 0.00505950f, -0.01698842f, 0.00397986f, -0.00991878f, -0.02726762f, -0.00268189f, 
    -0.01871033f, -0.05257196f, -0.02450918f, 0.02620566f, 0.02188218f, -0.05298199f, 0.01917031f, -0.04617560f, 
    -0.00377043f, -0.05483491f, -0.01570007f, -0.00234750f, 0.01015326f, 0.00694840f, -0.04799505f, 0.00304080f, 
    -0.02085976f, -0.01998709f, -0.01983747f, -0.04431266f, -0.04994014f, 0.00450891f, -0.05187711f, -0.02042477f, 
    -0.04951369f, -0.05629420f, 0.01916523f, 0.02707663f, -0.04940013f, 0.02183788f, 0.01218609f, -0.04581947f, 
    -0.04927635f, 0.03480503f, -0.04453912f, -0.02892904f, 0.01666851f, 0.03310021f, -0.04553829f, -0.04193399f, 
    0.02808143f, 0.03159110f, -0.04649620f, -0.04619053f, -0.00832265f, -0.02534878f, -0.00708943f, 0.01239877f, 
    -0.05632886f, -0.02371804f, -0.02003171f, -0.00263901f, 0.02282779f, -0.05475615f, 0.00332179f, 0.02309403f, 
    -0.01441001f, 0.02373076f, -0.03281112f, -0.05386634f, -0.04382231f, -0.04254149f, -0.03882493f, 0.01943930f, 
    -0.02823089f, 0.02812135f, -0.03923782f, 0.01596721f, -0.00888265f, -0.01877197f, 0.00850329f, 0.04049198f, 
    0.03988532f, -0.01923642f, 0.00779365f, -0.04685740f, 0.02954154f, -0.00727832f, -0.04768178f, 0.02642685f, 
    -0.03345314f, -0.01468811f, 0.03281460f, 0.03106554f, 0.04069543f, 0.01462930f, -0.02989517f, 0.04384483f, 
    0.01180882f, -0.03851325f, 0.00103831f, -0.05276272f, -0.00272735f, 0.01009615f, -0.04199032f, 0.01563899f, 
    0.02080655f, 0.00609623f, 0.02350854f, -0.01084027f, -0.02692540f, 0.01507306f, -0.04227671f, 0.00309328f, 
    0.01720767f, -0.01604015f, -0.00124742f, 0.00761802f, 0.02302810f, -0.04351316f, -0.00699987f, -0.04416642f, 
    -0.03614804f, -0.00001511f, 0.03961484f, -0.02688174f, -0.03108163f, -0.05562567f, 0.00881393f, -0.03856413f, 
    -0.03672614f, -0.01431322f, 0.01581861f, -0.04589522f, -0.03799746f, 0.03819515f, -0.05847985f, 0.02349063f, 
    0.01839224f, 0.02103875f, 0.02873161f, 0.00232988f, 0.00308033f, -0.02651660f, -0.01015332f, 0.00676278f, 
    0.04396073f, -0.04048910f, 0.02933599f, -0.03927813f, -0.04492467f, -0.01638534f, -0.01784248f, 0.01784015f, 
    -0.04300683f, -0.03203591f, -0.03880342f, 0.00730426f, -0.03911837f, -0.00333762f, -0.06056333f, 0.03565426f, 
    -0.03576411f, -0.02596842f, 0.02434636f, -0.01134309f, -0.01615731f, -0.00892401f, -0.02565077f, -0.04310288f, 
    -0.02409864f, 0.01333147f, -0.03396263f, -0.05210236f, 0.03298789f, 0.02067676f, -0.02965464f, 0.03273809f, 
    0.02258744f, -0.03009376f, -0.04873842f, -0.05687877f, -0.02405700f, 0.02072706f, -0.03490112f, -0.02550467f, 
    0.03220091f, -0.05290508f, -0.01821824f, -0.03323728f, -0.04998278f, -0.01697236f, 0.00355359f, -0.01858097f, 
    -0.06089734f, 0.02083994f, -0.02116805f, -0.02943198f, 0.03588644f, 0.02925666f, 0.00850858f, -0.02488762f, 
    -0.04413515f, -0.01125315f, 0.02124960f, -0.02343722f, 0.00471214f, 0.01829698f, -0.01797890f, -0.03028121f, 
    0.00041966f, 0.01085608f, 0.01282343f, -0.01442318f, -0.00321298f, 0.03969642f, 0.03380955f, -0.00459650f, 
    -0.04974002f, 0.01601942f, 0.01197470f, -0.01526527f, 0.01705418f, 0.00952862f, -0.01173273f, -0.02905231f, 
    -0.02862988f, -0.03562474f, 0.00736384f, -0.04674589f, -0.02141263f, 0.02984130f, 0.00320601f, -0.04259849f, 
    -0.05617869f, -0.02628473f, 0.04831984f, 0.02887152f, 0.03479393f, -0.01164668f, -0.03830668f, 0.03748163f, 
    -0.05594133f, -0.04487507f, -0.00928787f, 0.00612301f, -0.00479625f, 0.00962805f, 0.04521421f, -0.03815796f, 
    -0.00735359f, 0.00092944f, 0.01259716f, -0.01729504f, 0.04882348f, 0.01308910f, 0.00170125f, 0.01732443f, 
    -0.04489323f, -0.01201061f, 0.02170806f, -0.02482088f, -0.00163295f, -0.02837715f, 0.02078813f, -0.00030417f, 
    -0.04771604f, -0.02818733f, -0.02828358f, 0.00852336f, -0.01628931f, 0.04747448f, -0.02264314f, 0.00218753f, 
    -0.03093007f, -0.00810054f, 0.03311389f, 0.02207562f, 0.03234431f, -0.02053363f, 0.02789178f, 0.04047627f, 
    0.02595329f, -0.00185235f, 0.01640327f, 0.03371541f, 0.01651830f, -0.02464332f, 0.04240810f, 0.00561430f, 
    -0.01083788f, 0.02186409f, -0.01441504f, -0.05466222f, -0.03325398f, -0.04723044f, 0.02997935f, -0.01376915f, 
    -0.01291685f, 0.00302746f, 0.03859578f, 0.01102079f, -0.06129723f, 0.01026307f, 0.00135185f, 0.00949482f, 
    -0.02969704f, 0.04761421f, -0.01743070f, -0.03458630f, -0.02307623f, 0.02510885f, -0.00607410f, 0.02727070f, 
    0.03036981f, 0.01725299f, 0.01967872f, 0.01994685f, 0.01417393f, -0.01738653f, -0.02426259f, -0.03544238f, 
    -0.04199641f, -0.03069577f, -0.15059410f, -0.03342618f, -0.04040454f, 0.06008234f, 0.13812773f, -0.28552854f, 
    -0.01825635f, -0.02651763f, -0.00323614f, 0.07124995f, -0.19403979f, 0.11734858f, -0.11455330f, -0.14388946f, 
    0.02896543f, 0.06340288f, 0.03650456f, 0.08738206f, 0.07222588f, -0.12281827f, -0.06610087f, -0.07568241f, 
    -0.39983010f, 0.04688641f, -0.01290931f, -0.12317063f, 0.01668708f, 0.06674086f, 0.01536000f, -0.02343017f, 
    -0.01891994f, -0.08019027f, 0.01398537f, 0.07340902f, -0.04726471f, 0.18613826f, -0.10422228f, -0.05380859f, 
    -0.21105029f, 0.12507175f, -0.04284653f, -0.01103873f, -0.03259378f, 0.02848963f, -0.01272741f, 0.02651905f, 
    -0.03537669f, 0.00160631f, 0.13730924f, 0.23461314f, -0.03514561f, 0.09877416f, 0.00768676f, 0.09389333f, 
    0.00429642f, 0.11583222f, 0.11806795f, 0.09913085f, 0.32069027f, 0.08554089f, -0.01760408f, -0.04493179f, 
    0.12075048f, 0.00331195f, -0.06197205f, 0.08930359f, -0.04393951f, -0.04549548f, -0.02296913f, -0.07123478f, 
    0.19477606f, 0.34714332f, -0.18351559f, -0.04930365f, 0.10105657f, -0.03795745f, 0.06063049f, 0.01958907f, 
    0.00223841f, -0.08968931f, -0.15048361f, -0.08635815f, -0.53136688f, 0.20029566f, 0.22717236f, -0.18777169f, 
    0.00425774f, 0.13713571f, 0.01105461f, -0.03939036f, 0.07903641f, 0.00305529f, 0.13679974f, 0.19861484f, 
    -0.15000129f, 0.29446146f, 0.06498900f, 0.11365297f, -0.26152262f, 0.06061181f, 0.04573533f, 0.14122687f, 
    -0.14043444f, -0.02623241f, -0.02121962f, -0.12370501f, 0.00292631f, -0.02485917f, -0.01816481f, 0.06569822f, 
    -0.00006356f, 0.04758674f, -0.01104144f, 0.00004923f, -0.04443283f, -0.02041108f, -0.08174535f, -0.07225846f, 
    0.34642217f, -0.07987045f, 0.39805490f, -0.22131799f, 0.00759969f, 0.27093351f, -0.09395795f, -0.01681880f, 
    0.13237953f, -0.12826806f, 0.13606116f, -0.15495871f, -0.25965494f, -0.07688323f, -0.24763510f, 0.06096276f, 
    0.06057786f, -0.34399551f, 0.08852067f, -0.18051015f, 0.04523837f, -0.03606341f, -0.03863715f, 0.01343734f, 
    0.12856764f, 0.08286345f, 0.33385092f, -0.16496767f, 0.03688038f, 0.17476293f, 0.07400638f, -0.19075461f, 
    0.04976754f, 0.02890974f, 0.06186448f, -0.03278244f, 0.12172430f, 0.02647312f, 0.18568444f, 0.15558083f, 
    -0.02428512f, -0.00163056f, 0.01141287f, -0.00038826f, -0.02869804f, 0.03607372f, -0.05665332f, -0.09676966f, 
    0.43277270f, -0.08453672f, 0.09516048f, -0.20949721f, 0.11823859f, -0.06669985f, -0.02382197f, -0.03015989f, 
    0.06736367f, -0.02910049f, -0.09303205f, 0.07873344f, -0.10739962f, 0.46719086f, -0.18851545f, -0.12036715f, 
    -0.23951595f, 0.14358597f, -0.03667917f, 0.06111697f, 0.07889012f, -0.02184858f, -0.17477231f, 0.06123981f, 
    0.21767154f, 0.22686416f, 0.22874624f, -0.03200749f, -0.06156060f, 0.02648364f, 0.06365046f, -0.18982099f, 
    0.16793559f, 0.21816911f, 0.15414341f, 0.19706123f, 0.13572693f, -0.12596747f, 0.08190487f, 0.12159030f, 
    0.00186248f, 0.02275541f, -0.01518969f, 0.06362831f, 0.05703116f, -0.00895089f, -0.11597232f, -0.09862355f, 
    -0.03898450f, -0.12662198f, -0.14201939f, 0.06575570f, -0.06705948f, 0.01310697f, 0.07362439f, 0.15622053f, 
    -0.04964388f, -0.08793174f, -0.02223926f, 0.03021759f, 0.09278652f, 0.31192049f, 0.36658609f, 0.07235951f, 
    -0.04806798f, 0.14765927f, -0.25208455f, 0.26143080f, -0.04394724f, -0.05881133f, 0.27576476f, 0.02003831f, 
    0.08287505f, 0.01388847f, 0.21892449f, -0.03165678f, -0.05412724f, 0.00663105f, 0.06839889f, 0.05098067f, 
    -0.01982156f, 0.01803609f, -0.11570016f, -0.21853577f, 0.25379041f, -0.10662130f, -0.18022609f, -0.06591681f, 
    0.11983369f, -0.08358572f, -0.06817503f, -0.02154469f, -0.03326110f, -0.11127017f, -0.12178048f, -0.01984426f, 
    -0.00395695f, -0.04046535f, 0.12936059f, -0.00815044f, 0.12752323f, 0.05000965f, 0.03209928f, 0.16133919f, 
    -0.05681675f, 0.04408244f, -0.18180299f, 0.05573023f, -0.06802518f, 0.65169209f, 0.17096700f, -0.03981849f, 
    -0.10458991f, 0.03650911f, -0.12129388f, 0.06459679f, -0.18442638f, 0.17884667f, 0.06758162f, -0.02583111f, 
    0.62135667f, -0.04133583f, 0.47083881f, 0.05585105f, 0.10056955f, 0.02780776f, -0.04637437f, 0.17835973f, 
    0.00771280f, -0.14807290f, -0.21112108f, -0.19969223f, -0.19560502f, 0.00504899f, 0.04214630f, -0.03308067f, 
    0.08384755f, 0.07571936f, 0.08313809f, 0.13577372f, 0.16665971f, 0.05350054f, 0.15467221f, 0.17826423f, 
    -0.37492400f, -0.14912899f, -0.03390476f, -0.19825758f, 0.09145455f, 0.12396315f, 0.05047025f, -0.05648578f, 
    0.00956856f, 0.01435821f, -0.02564847f, 0.02263738f, 0.14413409f, -0.49780926f, -0.17346284f, -0.08020527f, 
    0.00664026f, -0.06523456f, 0.02175108f, 0.12211000f, -0.05299177f, -0.02357866f, 0.33947483f, -0.03510198f, 
    -0.04585180f, 0.00765869f, -0.05219306f, 0.15344721f, -0.01183710f, 0.02940471f, -0.05964198f, 0.12180362f, 
    -0.06616689f, -0.01908797f, -0.01375222f, -0.12972501f, 0.29137701f, 0.23140670f, 0.34330392f, 0.18594833f, 
    -0.22033317f, -0.08463134f, 0.13309826f, -0.02943811f, 0.03657435f, 0.00188568f, -0.24694507f, 0.10279197f, 
    -0.12504904f, 0.15871550f, -0.12039836f, -0.37499759f, 0.01763622f, 0.04007393f, 0.17304061f, 0.08607313f, 
    -0.02833436f, -0.03343510f, -0.16748294f, -0.00326903f, 0.28198099f, 0.03511871f, -0.07585123f, -0.01289246f, 
    0.00009174f, -0.18123774f, 0.04798137f, -0.19772473f, 0.00160332f, 0.08514198f, -0.18714286f, 0.21897778f, 
    0.30956703f, 0.24048232f, 0.18016173f, 0.19388416f, -0.11801900f, 0.03857530f, 0.02636828f, 0.04000833f, 
    0.11853078f, 0.08718620f, 0.04356722f, -0.16512753f, -0.08299621f, -0.38001484f, -0.28837571f, -0.04038565f, 
    -0.20020717f, 0.01784930f, 0.03843962f, -0.14226502f, 0.02733313f, 0.11186507f, -0.09557900f, -0.00319779f, 
    -0.11450829f, -0.01713089f, 0.26140103f, 0.10102717f, 0.06592867f, 0.09703221f, 0.06663042f, 0.03379300f, 
    -0.03353435f, 0.06744598f, -0.08280900f, -0.02663715f, 0.21243431f, 0.19639398f, 0.34861308f, 0.29603124f, 
    -0.11085857f, 0.02783336f, 0.08622105f, 0.21850120f, 0.01848630f, 0.00390435f, 0.00075745f, 0.05716794f, 
    0.10129412f, 0.10900761f, -0.00418053f, 0.26345724f, 0.09639096f, 0.02521215f, -0.09891453f, 0.03809187f, 
    0.07144715f, 0.04478730f, -0.06536281f, 0.01260166f, -0.02238696f, -0.37261459f, -0.05649985f, 0.09570349f, 
    -0.01281623f, -0.05433149f, -0.03392033f, -0.06500693f, 0.10250944f, -0.12283226f, 0.01737726f, 0.03614190f, 
    -0.02616167f, -0.05279177f, 0.20751618f, -0.11688366f, -0.09157220f, -0.03759608f, 0.00045399f, 0.05930830f, 
    0.00926016f, 0.08069877f, 0.04799612f, 0.06946619f, 0.08138864f, 0.14187896f, -0.50341046f, 0.27831796f, 
    -0.10794545f, -0.01284224f, 0.08830009f, -0.10033636f, 0.07872716f, -0.06867991f, 0.01326200f, -0.02893218f, 
    0.25873962f, 0.28148526f, 0.35681075f, 0.36785462f, 0.04451256f, -0.09099498f, 0.31163049f, 0.10281283f, 
    0.11101456f, -0.05993254f, 0.00109289f, 0.10512444f, -0.05741382f, -0.25913948f, 0.11123705f, -0.16085953f, 
    -0.02911150f, -0.00767549f, 0.14253764f, -0.04535759f, -0.08690129f, 0.14401415f, 0.02948561f, -0.08891699f, 
    -0.06459226f, -0.10403816f, -0.40754205f, -0.13173220f, -0.02466790f, -0.13684566f, 0.07645568f, 0.00694396f, 
    -0.01301543f, 0.04634941f, -0.10699367f, -0.00149561f, 0.33423376f, -0.18450432f, -0.27808604f, -0.19217119f, 
    0.14822654f, 0.00714717f, 0.10465452f, 0.17474841f, -0.04134316f, 0.00720806f, 0.00397157f, -0.12715724f, 
    0.20842245f, 0.09376720f, -0.20569538f, 0.14482327f, 0.01603642f, 0.03437629f, 0.12196186f, 0.19334030f, 
    0.02718403f, 0.01771620f, -0.01798666f, -0.07389488f, -0.15709370f, -0.07970817f, -0.07528971f, -0.02605000f, 
    0.11974827f, 0.06811219f, -0.19220182f, -0.03687865f, 0.10922763f, 0.06684948f, 0.05085926f, 0.28392527f, 
    -0.45826280f, -0.46817672f, -0.22968304f, -0.07416625f, -0.02130307f, -0.02947085f, 0.06312135f, 0.03706753f, 
    0.01329953f, -0.04473843f, 0.05934181f, -0.05561401f, -0.39119247f, -0.18907893f, 0.26085967f, 0.13123482f, 
    0.12321601f, 0.20844878f, 0.19227049f, -0.24334612f, 0.08490921f, 0.00814469f, 0.01731659f, -0.02453246f, 
    0.10623948f, -0.17523398f, -0.08716317f, -0.02110268f, 0.12818459f, 0.00415921f, -0.09144043f, 0.03197077f, 
    -0.06619059f, -0.11593024f, -0.08869667f, -0.00286467f, -0.55125773f, -0.40144256f, -0.11882987f, -0.22474979f, 
    -0.00366363f, -0.12053036f, -0.03486445f, -0.16012141f, -0.00522699f, 0.08363638f, 0.14966838f, 0.09865430f, 
    0.38024434f, 0.72385204f, 0.32520750f, 0.33809322f, 0.07229664f, 0.07435980f, 0.14063588f, 0.30724722f, 
    -0.07674289f, 0.06095809f, -0.05321904f, -0.05300181f, 0.26235101f, 0.32905269f, -0.16601293f, -0.04531468f, 
    0.00929013f, -0.06444632f, 0.09179766f, -0.03789685f, 0.02744048f, 0.04414347f, -0.06809869f, 0.05214760f, 
    0.09319077f, 0.10224759f, -0.02074836f, -0.05876533f, 0.04993141f, -0.01287595f, 0.01176105f, -0.09037609f, 
    0.13710818f, 0.16341083f, 0.17668036f, 0.15710488f, 0.09236331f, 0.27342400f, -0.03860083f, 0.13595600f, 
    -0.00101338f, 0.17469881f, 0.26158074f, 0.20858356f, 0.16290139f, 0.11318155f, 0.04212488f, 0.00463198f, 
    0.05116966f, -0.00428235f, 0.16774039f, 0.02975530f, -0.13265058f, 0.09777591f, -0.06544958f, -0.08932824f, 
    0.21986042f, 0.15762211f, 0.24198651f, 0.15628293f, 0.17555177f, -0.17624062f, -0.21157488f, -0.39394769f, 
    -0.00283231f, 0.04550989f, 0.08957423f, 0.08329152f, -0.05679062f, 0.01079007f, 0.14497668f, 0.09943018f, 
    -0.19399036f, 0.16738842f, -0.22180723f, 0.14118211f, 0.16183315f, 0.08982172f, 0.12413952f, 0.16436689f, 
    0.10556451f, -0.04793384f, 0.02628491f, 0.20006755f, -0.05051246f, -0.18990017f, -0.08448803f, 0.16865051f, 
    -0.07424385f, -0.05682465f, 0.07776915f, 0.01597558f, 0.12668018f, 0.01159144f, -0.06174338f, -0.03035058f, 
    -0.37537754f, -0.40820602f, -0.50640213f, 0.28274468f, -0.18814671f, -0.01301363f, 0.08002116f, 0.01829595f, 
    0.05101418f, -0.00031287f, 0.02623568f, -0.05883493f, -0.12244745f, 0.00909769f, 0.23720244f, -0.01168910f, 
    -0.13438217f, 0.13236232f, -0.13293760f, -0.10412277f, -0.08265453f, -0.14840312f, -0.10365315f, 0.04542356f, 
    -0.30502582f, -0.25158727f, 0.12355219f, -0.14420979f, -0.06848323f, -0.07370976f, 0.02355785f, -0.15972708f, 
    -0.01671531f, 0.02128802f, -0.00308227f, 0.09617693f, 0.15960601f, 0.03114170f, -0.13347974f, -0.06574220f, 
    0.19220577f, 0.05280420f, -0.10224281f, 0.04466670f, -0.16919830f, -0.04383104f, 0.11572614f, 0.11938720f, 
    0.19532861f, 0.30212787f, 0.32182819f, 0.39959010f, 0.03098448f, -0.02263433f, 0.01797412f, 0.31771660f, 
    0.08106067f, 0.04768252f, -0.00056558f, 0.06743076f, 0.05342354f, -0.15967855f, -0.00754797f, 0.11420842f, 
    0.14584354f, -0.03301683f, -0.03900715f, -0.01802985f, 0.06275859f, -0.06241244f, -0.03526592f, 0.08480909f, 
    -0.14974076f, -0.03203280f, 0.00519365f, 0.00433302f, -0.11904036f, -0.24016419f, -0.12449107f, -0.19568442f, 
    0.10148052f, 0.03647892f, 0.09093348f, 0.00170143f, 0.19002116f, 0.17391708f, -0.01305681f, 0.01056366f, 
    0.00523733f, -0.00078634f, -0.06320398f, -0.14753348f, 0.07325649f, -0.01077885f, -0.02901688f, -0.05855126f, 
    0.02724409f, -0.18965264f, -0.16264348f, 0.05414177f, -0.00606174f, -0.00606861f, 0.20968045f, -0.11138596f, 
    0.02160703f, -0.02690049f, -0.22160320f, 0.05078575f, 0.00540084f, 0.19426815f, 0.20741673f, 0.13975716f, 
    -0.03459422f, -0.05649440f, 0.01597191f, -0.00946518f, -0.02941523f, -0.13717084f, 0.10903442f, 0.05016095f, 
    0.14615995f, -0.19264013f, -0.29502949f, 0.18037273f, -0.05180955f, 0.12161400f, -0.05026271f, 0.19451170f, 
    -0.09781878f, 0.07927954f, 0.19425106f, -0.00999279f, 0.17519173f, 0.06531706f, 0.45338118f, 0.27251327f, 
    0.00428773f, 0.04334447f, 0.02168000f, -0.05434795f, 0.04424041f, 0.03657477f, -0.00498406f, 0.15840068f, 
    -0.07127888f, -0.55595273f, -0.24365212f, -0.17382190f, 0.06398615f, -0.24102521f, 0.06745937f, -0.04418819f, 
    -0.01443778f, -0.12357390f, -0.07507873f, 0.02067293f, 0.11889046f, 0.21065688f, -0.28025088f, 0.02881248f, 
    -0.39453608f, -0.15906423f, 0.19344953f, 0.01776024f, -0.02766947f, 0.01899475f, 0.07301421f, 0.08492615f, 
    0.04857646f, -0.08303238f, -0.20471022f, -0.17841810f, -0.05450899f, -0.06881264f, -0.21664825f, -0.13387690f, 
    0.03196854f, 0.04583827f, -0.05029547f, -0.00470623f, 0.19540900f, -0.00481594f, 0.07239488f, -0.13655122f, 
    0.06733202f, -0.06108801f, 0.01716268f, -0.16720350f, 0.09028413f, -0.10483348f, -0.07761720f, -0.16600250f, 
    0.14841516f, -0.06518210f, 0.27505362f, 0.25207663f, 0.01667815f, 0.03409151f, 0.12791741f, 0.00394632f, 
    0.04071246f, 0.02500525f, 0.05864537f, 0.06601172f, 0.16083270f, -0.05261585f, 0.02244693f, 0.15902641f, 
    -0.02270818f, -0.31393972f, 0.00348393f, -0.01848256f, 0.13061082f, 0.08734123f, -0.01040287f, -0.05187455f, 
    -0.25644815f, -0.38394865f, -0.35421276f, -0.06749772f, -0.11484846f, -0.13895720f, 0.10047715f, -0.04405851f, 
    0.01489234f, -0.01097323f, -0.00028861f, 0.10568593f, 0.20948540f, 0.11506847f, 0.24315251f, -0.04408668f, 
    0.13325985f, 0.06468525f, -0.04329875f, -0.03223737f, 0.21630758f, -0.17682953f, -0.27085885f, 0.08183596f, 
    0.08403862f, 0.22494856f, 0.26591995f, 0.00570030f, -0.02561589f, -0.00376173f, 0.05469802f, -0.15673278f, 
    0.16694531f, 0.03607186f, 0.16065802f, -0.03193603f, 0.17028461f, 0.42395839f, 0.09772028f, -0.35045281f, 
    0.11467572f, 0.01371328f, -0.02081323f, -0.14014156f, -0.02245083f, -0.16785547f, 0.02648859f, 0.10019752f, 
    0.13505709f, -0.09728844f, -0.09272281f, -0.35028630f, -0.07734361f, 0.01219192f, -0.05080013f, -0.12080383f, 
    0.13902634f, 0.10871166f, -0.00410012f, 0.04715044f, 0.07649510f, -0.10377599f, 0.08510549f, -0.07227014f, 
    0.01766268f, -0.02910510f, -0.04136552f, -0.00606599f, 0.08454376f, 0.13057527f, 0.12238707f, 0.04516044f, 
    0.07173321f, 0.16744304f, -0.18166627f, 0.30605462f, -0.03392873f, -0.12309615f, 0.20028087f, 0.26163927f, 
    -0.12666903f, -0.04584416f, -0.06455947f, 0.02570872f, 0.45853081f, -0.15042888f, -0.50939006f, -0.52848220f, 
    -0.12061525f, 0.01505951f, -0.08981724f, 0.01518802f, -0.00572307f, 0.05376431f, 0.06335191f, 0.09469421f, 
    0.21941479f, 0.04150367f, 0.26781803f, -0.00112317f, -0.04693274f, -0.04859184f, 0.01339350f, 0.06427318f, 
    0.28594869f, 0.07890176f, -0.01706819f, 0.03252723f, 0.13224117f, 0.29700124f, -0.06215309f, 0.19504865f, 
    0.05436100f, -0.16470794f, 0.25310776f, -0.06864569f, -0.02883464f, -0.01146876f, -0.04786415f, -0.12785247f, 
    0.22290845f, 0.02610017f, 0.17208983f, -0.01480821f, 0.05948636f, -0.01871273f, -0.02369930f, -0.06594031f, 
    0.00135392f, 0.13828562f, 0.07798719f, 0.20522407f, -0.18270876f, 0.34323156f, -0.11989713f, -0.09407277f, 
    -0.10732573f, 0.08402970f, -0.00644978f, 0.00985737f, 0.12627964f, 0.16225146f, 0.31892243f, -0.14720169f, 
    0.19201829f, -0.16629873f, -0.22855659f, -0.02474382f, 0.22154982f, 0.17804971f, 0.13154392f, 0.31673926f, 
    -0.08178486f, -0.04382068f, 0.08732380f, 0.04645613f, 0.08876842f, -0.03196985f, -0.05420366f, -0.05593197f, 
    -0.11060349f, 0.15965225f, 0.29534754f, 0.02315754f, -0.00030660f, 0.07394385f, -0.01390288f, 0.00542117f, 
    0.24475360f, 0.24228279f, -0.19119304f, -0.06329484f, -0.09274013f, -0.01012372f, 0.12557860f, -0.11766762f, 
    0.04565050f, 0.08743304f, -0.01802374f, -0.04933155f, 0.42143220f, -0.37626740f, 0.04246751f, -0.15929569f, 
    -0.04432466f, 0.10074348f, -0.07240333f, -0.04800542f, -0.15396903f, -0.19514060f, 0.18293926f, 0.22735848f, 
    0.29711923f, 0.07249401f, 0.08487481f, 0.06910218f, 0.08199020f, -0.07231747f, -0.02238211f, 0.00189930f, 
    0.03041858f, -0.06809961f, -0.00095816f, 0.16980642f, 0.65854818f, 0.16871841f, 0.10720795f, -0.25396413f, 
    -0.02233437f, -0.03517642f, -0.00581073f, -0.08953978f, 0.02494954f, 0.04651416f, -0.21863656f, 0.11332091f, 
    0.00858276f, -0.28711122f, 0.04066252f, -0.03381446f, 0.00328700f, 0.15729527f, 0.12180420f, 0.17711934f, 
    -0.09016038f, 0.04567196f, -0.18703184f, -0.10291483f, -0.13869931f, -0.20096411f, 0.12072763f, 0.14955115f, 
    -0.04627866f, -0.09995608f, 0.20457181f, -0.08587554f, -0.01489668f, 0.23287034f, 0.08735477f, 0.09570730f, 
    -0.07817741f, -0.34906501f, -0.36769491f, -0.14450562f, 0.23002587f, -0.04163443f, 0.08131754f, 0.15093380f, 
    0.01314398f, -0.01001227f, -0.07005022f, 0.29986158f, 0.10500726f, 0.18555427f, 0.11778110f, -0.15558967f, 
    0.03527009f, -0.04576586f, -0.00291841f, 0.01711601f, 0.00108513f, -0.09582875f, 0.10928898f, -0.10398291f, 
    0.16667823f, 0.22773154f, -0.01766890f, 0.01990886f, 0.13190705f, 0.06273820f, 0.01156298f, 0.18014279f, 
    0.20193468f, -0.04865730f, 0.23617531f, 0.11451404f, -0.02454944f, 0.19452113f, 0.01570500f, -0.20571807f, 
    -0.16840607f, -0.05662375f, -0.15060973f, -0.06915478f, -0.21718295f, -0.08769287f, -0.10109510f, -0.13951983f, 
    0.03237963f, 0.10912395f, 0.29069477f, 0.11452695f, 0.18530901f, 0.07924215f, 0.11104297f, 0.17852682f, 
    -0.06036083f, -0.00797908f, -0.06243383f, -0.05898973f, 0.30053058f, 0.15267920f, -0.12065475f, 0.19806021f, 
    -0.15901470f, 0.08609764f, -0.00676145f, 0.02795554f, 0.07539666f, 0.08403876f, -0.07044152f, -0.03204532f, 
    0.25633660f, 0.25160083f, 0.11412243f, -0.17896172f, 0.08476122f, 0.08029655f, 0.11784967f, 0.20726247f, 
    -0.06314355f, -0.13983513f, -0.09406763f, -0.00083546f, -0.12264583f, 0.18393482f, 0.25452471f, -0.16470191f, 
    0.51316470f, -0.26549470f, -0.10449680f, 0.19542575f, 0.03149960f, 0.00292386f, 0.00389920f, -0.02482029f, 
    -0.22081587f, 0.13792294f, 0.04514030f, -0.07978176f, 0.04112390f, 0.18248911f, -0.08238260f, 0.03022509f, 
    -0.11649842f, -0.01870875f, -0.02058736f, -0.06736618f, 0.00095063f, 0.24504606f, -0.14173819f, -0.11018623f, 
    0.17094825f, 0.04809713f, 0.16512647f, -0.00789785f, 0.10365361f, 0.05272191f, 0.10456057f, 0.07947521f, 
    0.10487904f, 0.13050124f, 0.37081981f, -0.24492967f, -0.19470558f, 0.35394037f, -0.03691540f, 0.10225028f, 
    0.06765028f, 0.23049283f, 0.01630145f, 0.23398013f, 0.32400528f, 0.33088148f, -0.11121779f, -0.35932031f, 
    0.01531758f, -0.00874632f, -0.09066890f, 0.03265031f, 0.07324852f, -0.01929644f, 0.01841370f, 0.00180016f, 
    0.19578744f, 0.24162206f, 0.29096484f, -0.15787761f, 0.05953413f, 0.21970266f, 0.06858521f, 0.01908400f, 
    0.12239666f, -0.06440647f, 0.03507711f, -0.04417458f, 0.02222994f, 0.00578060f, 0.07442584f, 0.09880766f, 
    -0.13693379f, -0.03439636f, 0.02628796f, -0.11663233f, 0.17833439f, 0.18263634f, 0.30058971f, 0.10247366f, 
    0.23181628f, 0.14012629f, 0.27755839f, 0.13986318f, -0.22893718f, 0.03788080f, -0.06070994f, 0.12738101f, 
    -0.05490690f, -0.07446169f, 0.03031431f, -0.01949420f, 0.10306505f, 0.22535232f, -0.23715600f, 0.42786834f, 
    0.03092775f, -0.04154177f, 0.07899264f, 0.15320517f, 0.25524551f, 0.05266229f, 0.08875918f, 0.18237853f, 
    0.00374773f, -0.09308261f, 0.09197745f, -0.00745391f, -0.20779197f, -0.16804492f, -0.08980298f, -0.22194239f, 
    -0.16506378f, 0.10144763f, 0.03970744f, -0.08417640f, 0.23550671f, 0.13743009f, 0.15362829f, 0.21607810f, 
    -0.07872569f, 0.09748719f, -0.17167144f, -0.09484132f, -0.04946990f, -0.02538636f, -0.01875160f, -0.14508256f, 
    -0.09944800f, -0.09201270f, -0.10337088f, -0.37677601f, 0.05616944f, -0.16496338f, -0.09921175f, -0.16377918f, 
    0.13538603f, -0.12719190f, 0.07176168f, 0.21037394f, -0.30327463f, 0.14853579f, 0.13468081f, 0.00086915f, 
    0.09420204f, -0.00205878f, 0.04139066f, 0.16085196f, -0.13869454f, -0.06279883f, 0.10925615f, -0.08841003f, 
    -0.04942461f, -0.17336519f, -0.10004405f, 0.01051961f, -0.15160888f, 0.01674878f, -0.07306678f, 0.04180577f, 
    0.04066365f, 0.01065363f, -0.02601405f, 0.06466087f, 0.03390315f, -0.08438303f, 0.08961173f, -0.16030632f, 
    0.00381502f, -0.03122010f, -0.06136724f, 0.28863826f, 0.01017474f, 0.09448758f, 0.07606008f, 0.24727651f, 
    -0.26619250f, -0.02771903f, -0.05574026f, 0.05040545f, 0.08278383f, 0.00104779f, -0.00817933f, 0.10401681f, 
    0.02341481f, -0.01200033f, 0.13846271f, 0.07576972f, -0.40611190f, 0.46548328f, 0.12335653f, -0.21928205f, 
    -0.08878680f, -0.05994861f, -0.02679369f, -0.16995569f, 0.02743482f, 0.09572756f, -0.07640378f, 0.04063650f, 
    0.36235636f, 0.08704812f, 0.28533745f, -0.12738959f, -0.09968378f, 0.09082918f, -0.04813301f, 0.08845684f, 
    0.16409566f, 0.00268181f, -0.02029859f, -0.24179074f, -0.24276458f, 0.12858942f, -0.03980425f, -0.25647771f, 
    -0.03004427f, -0.07861362f, 0.03446565f, 0.04248428f, -0.21734965f, -0.15210646f, -0.15486637f, -0.09764922f, 
    0.15428288f, 0.28339732f, 0.29021424f, 0.17390864f, 0.01919369f, -0.08878326f, -0.18364429f, -0.06855377f, 
    -0.07923327f, -0.06324608f, -0.05307088f, 0.07395437f, 0.08913563f, -0.30302477f, 0.09121520f, -0.38342538f, 
    0.22496416f, -0.17920865f, 0.17712463f, -0.04131019f, 0.06193608f, -0.04390903f, 0.34010118f, -0.05151996f, 
    0.19398695f, 0.03533103f, -0.11457125f, 0.05655885f, 0.00944333f, 0.11103871f, -0.01926875f, -0.08731422f, 
    0.18416706f, 0.06815883f, 0.07737294f, 0.02110095f, -0.18844157f, -0.05664389f, -0.11807031f, 0.06874951f, 
    -0.18850583f, -0.11472380f, -0.04011917f, -0.17227690f, 0.21262567f, -0.11818727f, 0.15967168f, 0.14213485f, 
    -0.09850404f, -0.07150044f, -0.18761253f, -0.27951932f, -0.07999330f, -0.12753412f, 0.05542346f, 0.08684605f, 
    0.02493101f, 0.05112352f, 0.02783870f, 0.07381292f, -0.02195357f, 0.00020623f, 0.09840483f, -0.19647074f, 
    -0.20874786f, 0.26188225f, 0.14249228f, 0.35569277f, -0.05166601f, 0.11999532f, -0.08259499f, 0.05211593f, 
    -0.05475803f, -0.03873132f, -0.03227065f, -0.04665671f, -0.03369940f, 0.02312075f, -0.04114333f, 0.03050023f, 
    -0.01185395f, -0.01841483f, -0.01067279f, 0.04332236f, 0.03941201f, -0.01683049f, 0.02738279f, -0.03194342f, 
    0.00594786f, 0.04412395f, 0.03815718f, 0.01679641f, 0.02612091f, -0.05362949f, 0.02664456f, 0.01984135f, 
    0.02019845f, -0.03845078f, 0.03534434f, 0.03553562f, -0.03741707f, -0.00926922f, 0.03333914f, -0.01292666f, 
    0.01838743f, -0.04842452f, 0.04480718f, -0.03553133f, -0.02123612f, 0.03420870f, -0.01253921f, -0.01671632f, 
    0.02101582f, 0.03127510f, 0.03993963f, -0.00859907f, 0.02864219f, -0.03204043f, 0.01126435f, -0.01943510f, 
    -0.03480693f, -0.01827769f, -0.03635053f, 0.02651898f, -0.00050098f, 0.00807368f, -0.02110467f, 0.01470631f, 
    0.00671268f, 0.04035153f, -0.01015081f, -0.00819731f, 0.02612362f, -0.03728791f, -0.02767205f, -0.01347672f, 
    0.01753119f, 0.03606717f, -0.00666656f, 0.03963291f, 0.02452975f, -0.05578165f, -0.01908489f, 0.01054951f, 
    -0.03011455f, -0.04778894f, -0.03130668f, 0.01077039f, -0.05168330f, 0.04188156f, 0.00313949f, -0.04065052f, 
    -0.01238841f, -0.01279319f, 0.02958572f, -0.00458443f, -0.01348935f, -0.02826822f, 0.01740865f, -0.04771952f, 
    0.03189788f, -0.04150178f, -0.03250970f, 0.03481648f, 0.01888562f, 0.03432731f, 0.01554579f, -0.05319662f, 
    0.03797155f, -0.01614399f, -0.05560826f, 0.00823868f, 0.02781294f, -0.03117557f, 0.03058631f, -0.02661433f, 
    0.00392701f, 0.01457461f, -0.03475840f, -0.05085048f, 0.02451790f, 0.02544709f, 0.04480225f, 0.03534881f, 
    -0.03392873f, 0.01876971f, -0.05205168f, 0.01519667f, -0.02509602f, 0.00480069f, -0.00140007f, -0.01174464f, 
    0.04271933f, -0.00064823f, 0.04849186f, 0.00436530f, 0.01163149f, 0.02922384f, -0.00633788f, -0.01831178f, 
    -0.00909384f, -0.04140561f, -0.03738684f, 0.01936596f, -0.01084405f, 0.03453826f, 0.01913904f, -0.03238430f, 
    0.04150716f, -0.01700533f, 0.02577630f, -0.04578611f, -0.01678052f, 0.02976704f, 0.01330579f, -0.03382546f, 
    -0.03514895f, 0.02267224f, 0.04193682f, -0.00186212f, 0.00496758f, 0.03898461f, 0.02714722f, -0.02134708f, 
    -0.04795895f, 0.00218569f, -0.02604204f, 0.00854200f, 0.01794697f, -0.02322789f, 0.02529079f, -0.00177572f, 
    0.03006377f, 0.02852036f, 0.01926195f, 0.02593891f, -0.03566096f, 0.02353080f, 0.02125746f, -0.04722534f, 
    0.04473732f, -0.04130050f, -0.03951236f, -0.00498183f, -0.00798120f, -0.05384172f, 0.03465175f, -0.02547247f, 
    -0.03220397f, -0.02928820f, 0.02296125f, 0.01672531f, 0.01759287f, 0.04011127f, -0.03880772f, 0.04024291f, 
    0.03449338f, 0.01070482f, 0.04180524f, 0.00134465f, -0.00384111f, -0.03578474f, 0.00687735f, -0.05135566f, 
    -0.03690065f, -0.04862485f, -0.01358803f, 0.01551756f, -0.03682887f, 0.02790010f, -0.03260865f, -0.00861035f, 
    -0.01057327f, -0.02234811f, -0.00563003f, -0.05038855f, -0.03131065f, -0.03946135f, -0.04024501f, -0.01031644f, 
    -0.03393159f, 0.01059145f, -0.05067777f, -0.02247111f, -0.04148030f, -0.01505036f, 0.00235979f, -0.03292891f, 
    0.02463291f, 0.00668752f, 0.03056221f, -0.03594835f, 0.03391013f, 0.03395015f, 0.01427994f, -0.03399963f, 
    -0.00568144f, -0.02273349f, -0.05713197f, -0.05584439f, -0.04451245f, -0.02521509f, -0.01426037f, 0.02161966f, 
    0.04306440f, 0.02728996f, 0.04179286f, 0.01219256f, -0.01658286f, -0.00914388f, -0.04974934f, -0.03250442f, 
    0.04183416f, -0.04962428f, -0.03667830f, -0.04920881f, -0.04261803f, 0.00749668f, -0.03685236f, -0.04044358f, 
    0.03311813f, 0.01985596f, -0.01662570f, 0.01869179f, 0.04032826f, 0.01434561f, -0.02220201f, 0.00438489f, 
    0.01957141f, 0.04602514f, -0.01265878f, 0.00644494f, -0.03722652f, 0.00364291f, 0.03309144f, -0.04192289f, 
    0.03887916f, -0.04108073f, -0.01091670f, -0.05687805f, -0.02562255f, -0.02093297f, -0.00780697f, -0.04997398f, 
    0.00337500f, 0.00145125f, -0.03841279f, -0.05253402f, -0.02324578f, -0.02253917f, 0.04668675f, 0.05082335f, 
    -0.00155129f, -0.05288568f, 0.03424192f, -0.05681693f, -0.01614674f, -0.04482148f, -0.04033444f, 0.00792583f, 
    -0.02433595f, -0.05404485f, -0.04407354f, -0.01124877f, -0.02649702f, 0.02227049f, 0.01656593f, -0.04537054f, 
    -0.00855496f, -0.04601720f, 0.02844921f, -0.03574168f, 0.03588088f, 0.01511578f, -0.01005194f, 0.03107799f, 
    -0.02736966f, -0.02786917f, -0.02938759f, -0.02961422f, 0.03463559f, 0.04251086f, 0.02826153f, 0.04046514f, 
    -0.04290173f, -0.03502601f, -0.02545845f, 0.04182697f, -0.02322725f, -0.01373691f, -0.00816740f, -0.02910811f, 
    0.00450372f, 0.01561577f, 0.00205193f, -0.00503918f, -0.00562719f, -0.03359725f, 0.04603186f, 0.00636511f, 
    -0.05406714f, -0.02915434f, -0.01365860f, 0.00689768f, -0.01842311f, 0.03959994f, -0.00072350f, -0.04370783f, 
    0.00281391f, -0.03864128f, -0.00663046f, -0.00359541f, -0.04786443f, -0.04253919f, 0.04354244f, -0.05444593f, 
    0.02160916f, -0.01557833f, -0.05446661f, 0.01138974f, -0.02238536f, -0.04193893f, -0.04428230f, -0.03278812f, 
    -0.04693364f, 0.03738410f, 0.02502565f, 0.03808030f, -0.02753962f, 0.01107129f, 0.03622986f, 0.03648202f, 
    0.00667912f, -0.01474653f, -0.02715923f, 0.01639471f, -0.05380126f, -0.01674466f, -0.03522403f, -0.05344046f, 
    -0.03148012f, -0.03522867f, 0.02919205f, -0.01895194f, -0.00008698f, -0.01340085f, -0.05472945f, -0.00124876f, 
    -0.00466665f, -0.05126308f, -0.02086311f, 0.03639113f, -0.04313040f, 0.01671657f, 0.01156844f, -0.03969179f, 
    -0.02676653f, -0.03719532f, 0.00857308f, -0.00214641f, -0.04620828f, 0.02416493f, 0.03212249f, -0.03250146f, 
    0.02590416f, -0.04800582f, 0.03810396f, -0.02957220f, 0.03374527f, -0.02912586f, 0.00259184f, -0.00276441f, 
    0.00652916f, 0.02526225f, -0.02811937f, -0.06182777f, 0.01822154f, -0.04302545f, 0.03747035f, -0.01596547f, 
    -0.03257644f, -0.05283108f, 0.01592375f, -0.04350572f, -0.00737260f, 0.02184191f, -0.03943395f, -0.05802609f, 
    0.03256756f, 0.00744555f, -0.02800943f, -0.00097432f, 0.00718010f, -0.05235533f, -0.00370613f, -0.02206771f, 
    -0.01705912f, 0.00657018f, 0.03036028f, 0.00610940f, 0.02813116f, -0.00765903f, -0.04628060f, -0.05503852f, 
    0.02154759f, 0.03390832f, -0.00684433f, -0.02918052f, -0.05038663f, 0.04057179f, 0.02205330f, -0.03368735f, 
    -0.03308821f, -0.00724980f, -0.02321799f, -0.01978002f, 0.01237786f, 0.05018737f, 0.02439641f, 0.04461971f, 
    0.02065223f, -0.02338840f, 0.02646203f, 0.00204937f, -0.03594183f, 0.01370109f, -0.02239081f, -0.00813110f, 
    -0.03804196f, 0.00674941f, -0.04032451f, 0.00934396f, -0.01677851f, -0.02882445f, 0.03532657f, 0.03263699f, 
    -0.02503018f, -0.04656874f, -0.03419534f, -0.00955605f, 0.04213373f, 0.00822891f, -0.03349321f, 0.01720847f, 
    0.04755299f, -0.03344387f, 0.01988110f, -0.00362319f, 0.02563558f, 0.01251980f, -0.01110508f, -0.04588168f, 
    0.03756699f, -0.04032472f, 0.02487244f, 0.02032546f, -0.03971807f, -0.03165558f, -0.06164396f, -0.00973130f, 
    0.03329565f, -0.04087664f, -0.00398899f, 0.02919560f, 0.02136610f, 0.03713556f, -0.00847638f, -0.05451997f, 
    0.00536293f, 0.01207308f, 0.01964105f, 0.01693531f, 0.03394638f, 0.03402280f, -0.05010314f, -0.02784831f, 
    -0.01069324f, -0.04667995f, 0.01444828f, 0.04463196f, -0.04451595f, 0.00775863f, 0.02741207f, -0.00860882f, 
    0.01454206f, 0.02092721f, 0.02263200f, -0.01124672f, -0.05684753f, 0.03502449f, 0.03165432f, -0.03299554f, 
    -0.01270417f, -0.04547319f, -0.05140951f, 0.03317848f, 0.03342873f, 0.00133074f, -0.03974353f, -0.03153765f, 
    -0.00993983f, -0.01790080f, -0.01157913f, -0.00639817f, -0.03317251f, -0.05309077f, 0.03350029f, -0.04214765f, 
    -0.04520859f, -0.04244225f, -0.04061402f, 0.00260048f, -0.02439336f, 0.02260125f, -0.02587356f, -0.03376466f, 
    -0.01245184f, 0.00390184f, 0.00175775f, -0.01818643f, -0.04277851f, -0.04360064f, 0.00205233f, 0.00303948f, 
    0.01894052f, 0.01723684f, 0.04198685f, 0.02844719f, 0.03401655f, 0.03768312f, -0.00771062f, -0.03189882f, 
    -0.01770331f, 0.02040061f, -0.02697628f, -0.04472578f, 0.04195205f, -0.05250048f, -0.00306538f, -0.03796016f, 
    0.04184339f, -0.04811459f, -0.02644286f, -0.00327114f, -0.03619551f, 0.03853552f, 0.00740890f, -0.05094964f, 
    -0.01705751f, 0.02069803f, -0.01172408f, -0.01076392f, 0.04104961f, 0.02402607f, -0.00520041f, 0.00264597f, 
    0.01164351f, -0.04980396f, 0.03662854f, -0.02360488f, 0.01779336f, -0.00207464f, -0.00612694f, 0.04846448f, 
    -0.01339849f, -0.00572795f, -0.05651691f, -0.02041456f, 0.01868794f, 0.02653658f, 0.01640454f, -0.01110338f, 
    -0.03458356f, 0.02820004f, -0.04231029f, 0.02100483f, 0.01298001f, -0.01015111f, -0.03735688f, -0.04075522f, 
    0.00864895f, -0.01202062f, -0.01292076f, -0.00891260f, -0.05774632f, -0.01401918f, -0.00495912f, -0.02023691f, 
    0.03729765f, -0.01401998f, 0.03850805f, -0.00288105f, 0.03897073f, -0.05227534f, -0.03914196f, -0.04386756f, 
    -0.01749447f, -0.01524829f, 0.03786889f, -0.00585398f, -0.04957293f, -0.01976001f, -0.03540110f, -0.05077374f, 
    -0.03478443f, 0.00711658f, -0.03529206f, -0.03707680f, 0.02491128f, 0.00905980f, 0.03299787f, -0.00980891f, 
    -0.01547554f, -0.01427760f, 0.04656807f, 0.02110235f, 0.03955847f, 0.01607087f, -0.01385459f, -0.02364961f, 
    0.01808920f, 0.01249460f, 0.02023599f, 0.00322894f, -0.03689695f, -0.04502881f, -0.02004628f, -0.05638976f, 
    -0.02379895f, -0.00511953f, 0.02703247f, -0.00380326f, -0.03294976f, 0.03488012f, -0.04404138f, 0.00598059f, 
    0.01767508f, -0.03309157f, -0.04831988f, -0.04198747f, -0.01319334f, -0.02444863f, -0.00437109f, 0.03992466f, 
    -0.04275583f, 0.03066451f, 0.00670915f, -0.05986190f, 0.01569165f, -0.04355066f, -0.01552658f, -0.01796868f, 
    0.00941254f, 0.01747292f, 0.04288177f, -0.03290301f, 0.04543043f, -0.04919484f, 0.03932498f, -0.05835184f, 
    -0.03220075f, -0.04031452f, -0.01762238f, 0.01144154f, -0.05673546f, 0.00134803f, -0.00818067f, -0.05753196f, 
    -0.02904567f, -0.02883449f, 0.03855573f, 0.00418270f, 0.00754327f, 0.04161533f, 0.02033507f, -0.00924266f, 
    0.03495580f, -0.00783588f, -0.05902621f, -0.02313194f, 0.04322047f, 0.01963506f, -0.01163577f, -0.03834601f, 
    0.01918847f, 0.00308958f, 0.03651975f, 0.00280633f, -0.02976692f, -0.00626881f, 0.01637314f, -0.02678059f, 
    -0.03180229f, 0.05369070f, -0.04192369f, 0.00210256f, 0.02469028f, -0.00259531f, 0.00965972f, -0.05077479f, 
    0.00026601f, 0.03393691f, 0.01204867f, 0.03163356f, -0.00693757f, 0.00067447f, -0.05023308f, 0.03032916f, 
    0.01949261f, 0.03361766f, -0.05668602f, -0.02150492f, 0.03353190f, 0.01437820f, 0.00447940f, 0.00821824f, 
    -0.02088195f, 0.02973733f, 0.03409674f, 0.03749378f, -0.00399190f, 0.02413821f, 0.03487695f, -0.04104125f, 
    0.04642810f, 0.01936418f, -0.00609212f, -0.01821959f, -0.04951981f, -0.03698617f, 0.03283321f, -0.00505156f, 
    0.03426818f, 0.00923966f, -0.05690785f, 0.03895089f, -0.01127817f, -0.03812606f, -0.05102557f, 0.03791073f, 
    0.03627637f, 0.00782649f, 0.04156537f, 0.03558948f, -0.04985850f, 0.01849928f, -0.01326023f, -0.00404207f, 
    0.00487776f, -0.03411955f, -0.02421258f, -0.05159222f, 0.02687946f, 0.03710707f, -0.04694282f, 0.00776150f, 
    0.03469869f, -0.00097895f, -0.04075515f, 0.03145606f, 0.02038295f, -0.03354517f, -0.00803970f, -0.04711648f, 
    -0.01344717f, -0.03369043f, -0.01611864f, -0.03486829f, -0.00960550f, -0.03267095f, -0.00343545f, 0.01571639f, 
    -0.00505183f, 0.03005722f, 0.04091589f, -0.02067761f, -0.04499300f, -0.02673872f, -0.04034080f, 0.02369439f, 
    -0.04228481f, 0.01844825f, 0.02401001f, 0.00704144f, -0.00954361f, 0.01509427f, -0.00334320f, -0.02710531f, 
    -0.03896527f, 0.00727190f, -0.04488308f, 0.02124625f, -0.02878728f, -0.01059694f, 0.00175562f, 0.03693380f, 
    0.04573644f, 0.02659233f, -0.04165187f, -0.04263692f, 0.02409497f, -0.05036863f, -0.01205008f, 0.01392037f, 
    -0.03878062f, -0.02560891f, 0.00753127f, -0.00831022f, -0.03688647f, -0.03139203f, -0.02633036f, 0.04532963f, 
    -0.05082030f, -0.02216304f, -0.05257559f, 0.03110449f, -0.00769925f, 0.02991170f, -0.05202942f, -0.01287097f, 
    0.03911344f, 0.00177119f, -0.05462356f, -0.03494381f, -0.04100659f, 0.04340497f, 0.02654544f, 0.04323348f, 
    -0.01680679f, -0.00309076f, -0.01555462f, 0.02087815f, 0.00540486f, -0.02264930f, -0.04442943f, 0.03227318f, 
    -0.01542595f, -0.05029620f, -0.04391596f, 0.03635655f, 0.04540700f, -0.00043519f, -0.05558632f, -0.01929032f, 
    0.02913484f, 0.00283606f, -0.00229410f, -0.04346848f, 0.00055847f, -0.05402795f, -0.02819909f, -0.03820034f, 
    -0.04140285f, 0.00229676f, -0.04121739f, 0.01872280f, 0.02142829f, -0.01286943f, -0.04523841f, 0.02034129f, 
    0.01094395f, -0.01444614f, -0.00365395f, -0.01980260f, -0.04661072f, -0.01037811f, -0.01800815f, -0.00360457f, 
    0.03548430f, -0.03864788f, -0.01260642f, 0.03744960f, -0.03219064f, 0.02286066f, -0.01443022f, 0.02996740f, 
    -0.03652865f, -0.04372460f, 0.02336967f, -0.04576496f, 0.02258398f, -0.04679385f, 0.01862379f, 0.03052175f, 
    -0.01013403f, -0.01218584f, 0.00514660f, -0.01658141f, -0.02440482f, 0.04289649f, -0.01290898f, 0.00295567f, 
    0.01221684f, -0.04330410f, 0.04367337f, 0.03390579f, -0.05539510f, -0.04171540f, -0.02335718f, 0.02288375f, 
    0.02858920f, 0.00925102f, -0.02518146f, -0.00099488f, -0.02097987f, -0.05444279f, -0.04369883f, 0.01561371f, 
    0.02802484f, -0.03398274f, -0.00523860f, 0.02050311f, -0.03469985f, -0.03932584f, -0.02371102f, 0.01283896f, 
    -0.04658676f, 0.01273976f, 0.01020327f, 0.00437624f, -0.01371283f, 0.05077228f, -0.03487949f, 0.00901393f, 
    0.02238881f, -0.05052161f, 0.04582809f, -0.05591562f, 0.03566731f, -0.01977794f, 0.02202017f, -0.03878840f, 
    0.01450240f, -0.01533719f, -0.03513084f, -0.04877438f, 0.04398973f, -0.02931955f, -0.04129548f, -0.02036669f, 
    -0.03461218f, -0.02553577f, 0.03977389f, 0.00574788f, 0.03091586f, -0.03697928f, -0.03947613f, -0.03984283f, 
    -0.02229391f, 0.02682576f, 0.03931005f, -0.01041565f, -0.01796752f, -0.05153080f, 0.02388877f, 0.02115473f, 
    0.03288516f, 0.00839355f, -0.02411015f, -0.05097307f, -0.05274331f, 0.00382521f, -0.04192257f, 0.01057993f, 
    0.02405962f, 0.00872880f, -0.04284754f, -0.04284151f, -0.01865616f, -0.04640009f, -0.05211136f, -0.02838912f, 
    0.02690864f, 0.02483080f, 0.04185477f, 0.03256933f, 0.01952217f, 0.00934906f, 0.02954197f, -0.03837189f, 
    0.04439686f, -0.01688140f, -0.02302425f, -0.01085635f, -0.02462953f, 0.03887982f, 0.01061532f, -0.00099927f, 
    -0.01455876f, -0.04815075f, -0.05364558f, -0.04979204f, 0.03015478f, -0.01957034f, 0.02896889f, 0.02286777f, 
    -0.02479636f, -0.05376253f, -0.02557396f, 0.03422418f, 0.03747700f, -0.05178980f, -0.02993603f, 0.03577611f, 
    -0.00958529f, -0.00948785f, -0.03207075f, -0.02804776f, 0.00728754f, -0.03149971f, -0.03793422f, 0.01461380f, 
    -0.03635255f, -0.05604460f, 0.03182827f, -0.02733988f, -0.05448848f, -0.02619880f, -0.00120679f, -0.01334328f, 
    0.03055661f, -0.00028610f, -0.01410633f, -0.00388063f, 0.02048793f, 0.04401891f, -0.04159060f, -0.03962387f, 
    0.03602950f, 0.02947590f, -0.01250879f, 0.00618228f, -0.04529696f, 0.03761946f, -0.02893764f, -0.05582173f, 
    0.00488048f, -0.03465734f, 0.03306419f, -0.04088646f, -0.04183023f, -0.03118857f, -0.04069862f, -0.01214210f, 
    -0.04245637f, -0.04687756f, 0.03217482f, 0.04041652f, 0.02091710f, -0.03917007f, 0.01789865f, 0.04013203f, 
    -0.00308791f, -0.04494214f, -0.05439150f, -0.01339799f, -0.05039414f, 0.04224009f, -0.04490486f, -0.04324680f, 
    -0.02502203f, 0.01898355f, -0.00149711f, -0.04457281f, 0.00153809f, -0.00801146f, 0.00050648f, 0.02297311f, 
    -0.01071161f, -0.01857649f, -0.00315184f, 0.00911042f, -0.02139586f, 0.04584625f, -0.00510282f, -0.01129365f, 
    -0.03722151f, -0.03286741f, 0.01503134f, -0.03819187f, 0.01338361f, -0.01165963f, 0.03409478f, -0.01621987f, 
    -0.03040894f, -0.00403112f, 0.04304798f, -0.00017496f, -0.01509875f, -0.02628454f, 0.02947372f, 0.02085403f, 
    0.04279918f, -0.01399291f, 0.04125663f, 0.03463995f, -0.05214609f, 0.03794265f, -0.03022826f, -0.02256664f, 
    -0.00795983f, -0.01280651f, -0.03146149f, 0.00146500f, 0.02158385f, -0.04014396f, -0.05295612f, 0.02163099f, 
    0.00858561f, -0.05486675f, -0.00077191f, 0.03587483f, -0.02656025f, -0.04287717f, -0.02514045f, 0.03339427f, 
    0.01858861f, -0.02577277f, -0.05191710f, 0.03758041f, -0.02835167f, -0.00650852f, 0.02289915f, -0.04505120f, 
    0.12029707f, 0.11699758f, 0.32816973f, 0.19130534f, 0.06925430f, -0.16308087f, 0.12089743f, -0.07697098f, 
    -0.09659038f, 0.03600528f, 0.07810757f, 0.02196649f, -0.29564238f, -0.26501998f, -0.04582692f, 0.12052766f, 
    0.37216645f, 0.12258704f, -0.03991691f, 0.07943653f, -0.07085608f, -0.31596503f, -0.31377545f, -0.13911083f, 
    0.03575597f, 0.13456343f, 0.08577247f, -0.35143599f, 0.13254826f, 0.00800371f, 0.06037247f, 0.14131081f, 
    -0.18981174f, -0.05779541f, -0.25799516f, -0.40598869f, 0.06058590f, 0.14701538f, -0.02644523f, 0.01101342f, 
    0.02574472f, 0.13815212f, 0.16935107f, 0.03588447f, 0.14729890f, 0.06561340f, 0.19464190f, 0.04426659f, 
    0.04338681f, 0.01131273f, 0.09532994f, 0.09467883f, 0.14114890f, 0.16412956f, 0.13253707f, 0.13816763f, 
    0.04661375f, 0.02787053f, 0.37335667f, 0.43050861f, -0.11181398f, -0.10050190f, -0.01568510f, -0.16207428f, 
    0.25385401f, 0.03268183f, -0.15163340f, 0.00951527f, -0.06016375f, -0.16784121f, 0.14943184f, 0.02083497f, 
    0.01996036f, 0.27676022f, -0.12887643f, 0.08132490f, 0.22406349f, -0.02178780f, 0.04438363f, -0.00789069f, 
    -0.09584761f, -0.14227031f, 0.10762363f, -0.09090127f, -0.16688266f, 0.38489079f, 0.18857066f, 0.03371178f, 
    -0.04084510f, 0.19671996f, 0.03547051f, 0.04790590f, 0.14139199f, 0.06421787f, 0.23407780f, 0.10318837f, 
    0.13943268f, -0.05355223f, 0.03767717f, -0.04325354f, 0.13672173f, -0.07438765f, -0.07321253f, -0.14601789f, 
    -0.08774240f, -0.31384295f, -0.22629051f, -0.26819557f, -0.12160599f, -0.25143376f, -0.00730792f, 0.14455172f, 
    0.02264188f, -0.03490564f, -0.07169221f, -0.01388376f, -0.11926550f, -0.31618837f, -0.37944260f, -0.30375198f, 
    0.00447708f, -0.25409207f, -0.22920939f, -0.03270023f, 0.11794680f, -0.11841357f, -0.19527170f, 0.04818032f, 
    0.20631023f, 0.18712844f, 0.08850928f, 0.05888722f, 0.13716583f, -0.13730094f, 0.00968972f, 0.31613153f, 
    -0.00679592f, -0.09637736f, 0.05213016f, -0.29631603f, -0.30107182f, -0.14049383f, -0.18979204f, -0.06156695f, 
    0.19363157f, -0.06145244f, -0.01388663f, -0.04216449f, -0.00635774f, 0.04110256f, 0.03731180f, -0.05644515f, 
    -0.15159120f, -0.00546024f, -0.14123651f, 0.29920378f, 0.00706468f, -0.38565892f, -0.07406933f, 0.28136790f, 
    -0.02496446f, -0.05427430f, 0.04630856f, 0.12669155f, -0.09888948f, 0.09314335f, -0.06863182f, -0.06913611f, 
    0.12495755f, -0.10440319f, -0.32829383f, 0.02582594f, 0.15122780f, 0.16298555f, -0.03484255f, -0.16095187f, 
    0.16480486f, 0.01755048f, -0.08924944f, 0.32891273f, 0.06500594f, 0.01992168f, 0.10658124f, -0.01486201f, 
    0.09250331f, 0.01667755f, -0.00516127f, 0.07390991f, 0.22377646f, 0.05485126f, -0.10871457f, -0.18967086f, 
    0.18462105f, 0.30520302f, 0.33013251f, 0.24810383f, 0.13675681f, 0.06218426f, 0.08800970f, 0.07136249f, 
    0.23179397f, 0.23741478f, 0.28618729f, 0.55341184f, -0.02565498f, -0.44924766f, -0.39586857f, 0.09724367f, 
    -0.03091129f, 0.17477453f, -0.12061323f, -0.07012118f, -0.05742728f, 0.08004950f, 0.08798920f, 0.26204240f, 
    0.33449674f, 0.03634109f, -0.07255910f, -0.23189551f, 0.03040187f, -0.07128612f, 0.00545292f, 0.13414273f, 
    0.14905034f, 0.10872233f, 0.06581246f, -0.02140241f, -0.07119890f, -0.00161515f, 0.15006918f, 0.25727344f, 
    -0.14473560f, 0.24781477f, -0.02325361f, -0.02688563f, 0.19385451f, -0.13918586f, -0.07614285f, 0.19240664f, 
    0.11498459f, 0.05598191f, 0.13311186f, 0.13451956f, 0.10825697f, -0.26438767f, -0.12291715f, -0.13361603f, 
    -0.08055256f, -0.12019469f, -0.11942595f, -0.28142515f, 0.13717982f, 0.03260941f, -0.40448508f, -0.06544942f, 
    0.40190881f, 0.00855583f, -0.09023980f, -0.08027637f, -0.07055999f, -0.28903580f, -0.47530758f, -0.47497991f, 
    -0.18733890f, -0.11952671f, 0.20957996f, 0.25773075f, 0.26357335f, 0.03148582f, -0.04125290f, -0.09325496f, 
    -0.13366827f, -0.14293692f, -0.27990621f, -0.26578221f, -0.26971540f, -0.15263124f, 0.02499020f, 0.10833536f, 
    -0.13936166f, -0.16451414f, -0.14665288f, 0.01486298f, 0.13726284f, -0.02585554f, 0.29139781f, 0.15369606f, 
    0.19817145f, 0.10574409f, 0.02711958f, -0.00052063f, 0.16320564f, 0.11508932f, 0.03550803f, -0.19840463f, 
    -0.17724103f, -0.03572364f, -0.00558875f, 0.02661518f, -0.22839890f, 0.01857534f, -0.17772290f, 0.16078889f, 
    0.17562205f, 0.31260708f, 0.02792580f, 0.14402008f, 0.35052824f, 0.08639816f, 0.21812171f, 0.16850947f, 
    -0.19406915f, -0.29564896f, -0.13715407f, 0.07607684f, 0.13633353f, 0.31178713f, -0.00355108f, 0.13332182f, 
    -0.15079640f, -0.29858103f, -0.10501739f, -0.22381897f, 0.28151232f, -0.00067825f, -0.15194818f, 0.13447638f, 
    0.12679446f, -0.06924108f, -0.05295319f, -0.17981277f, 0.04131726f, 0.00523155f, 0.06502633f, 0.20400217f, 
    -0.10859328f, -0.06072463f, 0.05821792f, 0.38680753f, 0.14306393f, 0.02418572f, -0.09557444f, -0.06838325f, 
    -0.23759955f, -0.13165601f, -0.06592293f, -0.13960466f, 0.00825653f, 0.19197267f, 0.41232258f, 0.48056936f, 
    0.02797017f, -0.16699415f, 0.31450880f, 0.08668096f, -0.07096153f, 0.31751236f, 0.02633831f, 0.02279893f, 
    0.27437395f, 0.28705004f, -0.19957386f, -0.44258353f, 0.08376511f, 0.05012265f, 0.14742300f, 0.00287053f, 
    -0.04166031f, -0.09896858f, 0.03954988f, -0.02695413f, 0.01640089f, 0.13751845f, -0.03015412f, -0.01060932f, 
    0.13939250f, -0.19568184f, -0.21984755f, -0.06297971f, 0.22483481f, 0.14216770f, 0.19063312f, 0.32044411f, 
    0.00289972f, -0.05667573f, -0.02724500f, -0.00712809f, 0.00550634f, -0.01927764f, 0.01952425f, -0.01217884f, 
    -0.02069915f, -0.02621588f, 0.03656107f, -0.04440292f, 0.01887670f, -0.04367189f, -0.03079042f, -0.04646072f, 
    -0.04808198f, 0.00865150f, -0.00344281f, 0.01761965f, 0.03946166f, -0.02373787f, -0.01149238f, 0.02383171f, 
    0.03784471f, -0.03645183f, -0.02674680f, -0.05371469f, -0.04365977f, -0.00492755f, -0.04275401f, 0.02095508f, 
    0.02489512f, -0.05830432f, -0.00872550f, -0.04621779f, -0.03006235f, -0.04969541f, 0.00597095f, -0.02119942f, 
    -0.00425249f, 0.01004062f, -0.01908636f, 0.03098584f, -0.00527474f, -0.02519908f, -0.04286373f, -0.05135569f, 
    0.02925121f, -0.00280542f, 0.02961708f, 0.00917881f, 0.01428516f, -0.00152322f, -0.05349773f, -0.04114166f, 
    -0.02304170f, 0.00255132f, -0.02546873f, 0.01011892f, 0.00012005f, -0.03395313f, -0.05809014f, -0.00560962f, 
    0.02954438f, -0.00857234f, -0.03905030f, 0.01594868f, -0.02964997f, -0.02859370f, 0.00041347f, -0.03134516f, 
    -0.03621353f, 0.01517477f, -0.05316285f, -0.04251397f, -0.00374131f, 0.01478642f, -0.00013224f, -0.02152485f, 
    -0.01293616f, -0.05257563f, -0.03683748f, 0.02475599f, 0.03997256f, -0.05240908f, -0.04423594f, -0.01118621f, 
    -0.02453122f, 0.03931433f, -0.01834315f, 0.02971575f, -0.05042994f, 0.03937288f, 0.02273866f, -0.04283403f, 
    -0.02154707f, 0.03825914f, -0.00834779f, -0.01139450f, -0.00920692f, 0.02285141f, 0.00999745f, 0.02318544f, 
    0.03680778f, 0.01711411f, 0.02608248f, -0.01180028f, -0.03510349f, -0.02892664f, -0.03078024f, 0.04297651f, 
    -0.03547388f, 0.00534502f, -0.00268546f, 0.02831217f, -0.03544344f, -0.03660997f, 0.01864859f, 0.04026030f, 
    0.00405242f, 0.03262408f, -0.04133328f, 0.03563457f, -0.02730116f, 0.01269097f, 0.02137164f, -0.03024513f, 
    -0.04979426f, 0.04220488f, -0.04213080f, 0.00596469f, -0.03295384f, -0.00749621f, -0.03427756f, -0.04820988f, 
    -0.03661913f, -0.03174987f, 0.04271765f, -0.03396254f, -0.03710963f, -0.03014846f, -0.04513527f, -0.03917274f, 
    0.02949386f, 0.01518764f, -0.00604235f, 0.00229125f, -0.02878237f, 0.01706933f, -0.00194114f, -0.05049293f, 
    0.01774863f, 0.02414210f, -0.02217949f, -0.05614033f, -0.00377506f, -0.00001357f, -0.03871414f, -0.04918173f, 
    0.00892576f, 0.01570393f, -0.01316447f, 0.03972736f, -0.04546966f, -0.03789161f, -0.00570773f, -0.04701228f, 
    0.02666203f, -0.02959332f, 0.00905574f, 0.02012733f, 0.02305391f, -0.05068204f, 0.01152654f, -0.05729297f, 
    0.03684992f, -0.04210292f, -0.05592610f, 0.01719150f, 0.01891218f, -0.01773792f, -0.03239372f, 0.03745043f, 
    -0.03579135f, 0.00297546f, -0.01777971f, -0.03132633f, -0.04443051f, -0.03176021f, 0.03405377f, 0.00264448f, 
    -0.00160897f, 0.00944274f, -0.05165362f, 0.01650235f, -0.05466944f, -0.00611951f, 0.00420124f, -0.04242045f, 
    -0.04287406f, 0.02113518f, -0.00983513f, -0.01609183f, -0.02044907f, -0.01190078f, 0.03056352f, 0.02360564f, 
    0.04169872f, -0.04362170f, -0.03405267f, 0.04034308f, -0.03671222f, 0.04202442f, -0.04573325f, 0.00237661f, 
    0.01498356f, -0.04576624f, 0.03299549f, 0.03124365f, -0.02169962f, -0.01238349f, -0.01698386f, -0.01223885f, 
    -0.05028214f, 0.01049527f, 0.01361467f, 0.04150995f, 0.01433775f, 0.03376384f, 0.01928966f, 0.03735723f, 
    -0.05130575f, 0.01639644f, -0.02589801f, 0.04016805f, -0.02258435f, -0.04220925f, -0.00917981f, -0.03454465f, 
    0.02252793f, -0.04669095f, 0.02591232f, -0.01477160f, 0.01533115f, -0.02374899f, 0.00234513f, -0.02229145f, 
    -0.00513819f, -0.03165901f, 0.00126427f, 0.00520915f, 0.00129162f, -0.00754109f, -0.00092808f, -0.01194200f, 
    0.04487605f, -0.04191735f, -0.05549525f, -0.01638519f, -0.00810278f, -0.02416161f, -0.01858591f, 0.03623499f, 
    -0.04525484f, -0.05654278f, 0.02354801f, 0.02483048f, -0.02586741f, -0.03487589f, -0.03213026f, 0.00792393f, 
    0.03307821f, -0.00771930f, -0.04333336f, 0.02113431f, 0.01228288f, -0.00336331f, 0.02259793f, -0.04559330f, 
    -0.05707975f, 0.01194193f, 0.01384799f, 0.03898107f, 0.02697442f, -0.03390975f, -0.00832869f, -0.04640182f, 
    0.00559082f, -0.05486947f, 0.01382883f, 0.00594581f, -0.05843481f, 0.03902026f, -0.01047915f, 0.01450299f, 
    -0.01443361f, -0.04754256f, 0.00533825f, 0.02345026f, -0.04338316f, 0.01293986f, 0.00469131f, 0.02268651f, 
    0.02179492f, 0.03217946f, -0.03120028f, -0.05520476f, -0.05193827f, -0.04176268f, 0.03317009f, 0.02841657f, 
    0.02207369f, -0.01829853f, -0.03186673f, -0.00450298f, -0.00250886f, -0.03676008f, -0.00353217f, -0.02613067f, 
    -0.00186913f, 0.04200307f, -0.01174041f, 0.00901734f, -0.05636885f, 0.00114003f, 0.00269673f, -0.00680940f, 
    -0.00156493f, -0.02388425f, 0.03255737f, -0.00527760f, 0.02554327f, -0.04062009f, 0.03631420f, -0.02903573f, 
    -0.02120333f, -0.04689820f, -0.03287305f, -0.02274930f, -0.04601938f, -0.02898621f, -0.01606136f, 0.00906874f, 
    0.03935670f, -0.04204338f, 0.01987616f, 0.02209248f, -0.04385918f, 0.01403506f, 0.03923091f, -0.01521963f, 
    0.03742684f, 0.03413447f, -0.01549685f, -0.03730708f, 0.02226167f, -0.03445008f, -0.04215616f, -0.03225881f, 
    0.00240065f, -0.00845448f, -0.01026329f, 0.01270911f, -0.01143965f, 0.01630065f, -0.01698681f, -0.01901102f, 
    0.01419861f, 0.01922207f, -0.04616890f, 0.04235917f, -0.04854403f, -0.00195307f, -0.05661932f, -0.00085737f, 
    0.03030648f, -0.00347535f, 0.03173705f, -0.00609990f, -0.04022413f, -0.02481046f, 0.01798615f, -0.02077785f, 
    0.20267560f, 0.36578304f, 0.11884684f, 0.12633295f, 0.10057040f, 0.03506374f, -0.11094854f, 0.08972152f, 
    -0.07035903f, -0.08641542f, -0.09018570f, -0.03380240f, -0.06797850f, -0.12099104f, 0.14173998f, 0.30064413f, 
    -0.01795585f, 0.04233051f, -0.00299934f, 0.09122700f, 0.05191327f, -0.01429627f, -0.15653293f, -0.09914577f, 
    -0.20622459f, 0.22892928f, 0.04623683f, 0.01309241f, 0.01976159f, 0.08291800f, 0.05642341f, 0.35620809f, 
    -0.15709645f, -0.12043651f, -0.08615594f, -0.19069141f, 0.19295442f, 0.06602360f, 0.15093522f, -0.00300840f, 
    -0.05575066f, -0.07442483f, 0.15515986f, 0.13021463f, 0.02839151f, 0.08847159f, 0.02501352f, -0.01265934f, 
    0.00509617f, 0.04420399f, 0.31344500f, 0.07437482f, -0.00214007f, -0.06619003f, -0.18605861f, -0.05009452f, 
    -0.03610784f, 0.21914369f, 0.28992170f, 0.44468108f, 0.24350128f, 0.05263615f, 0.03000532f, -0.08410612f, 
    0.04483948f, 0.04116474f, 0.03245952f, 0.01389733f, -0.02133616f, 0.02042207f, -0.05769651f, 0.02270077f, 
    -0.19047031f, -0.06584457f, 0.28440538f, -0.08048436f, 0.04373461f, 0.02488425f, -0.10944487f, 0.07866190f, 
    0.00145028f, 0.15366812f, 0.05217863f, -0.01177551f, 0.37874985f, 0.23329005f, -0.19688004f, 0.07204966f, 
    -0.09081254f, -0.11115066f, 0.07785361f, -0.04471513f, 0.08839164f, 0.09924097f, -0.02757866f, 0.09365101f, 
    0.06764907f, 0.24987091f, 0.34249380f, 0.10758610f, 0.02039897f, -0.01848767f, -0.02582542f, 0.09385409f, 
    0.03406602f, -0.12267615f, -0.04499068f, -0.01252839f, 0.00423818f, 0.07942364f, 0.05500016f, 0.16050513f, 
    0.01691858f, -0.07166772f, 0.08841646f, 0.26139134f, -0.17064756f, -0.13135530f, -0.17376442f, -0.20108661f, 
    -0.13389198f, 0.16921188f, -0.36413479f, 0.04466338f, -0.15678890f, 0.07135558f, 0.11539999f, -0.06095451f, 
    -0.17907310f, 0.19853011f, -0.08345295f, -0.03901323f, 0.70593220f, 0.38903597f, -0.10830186f, 0.06834416f, 
    -0.25510740f, 0.33680058f, -0.05092913f, 0.21385764f, -0.15931778f, -0.01401997f, -0.02406962f, -0.10489808f, 
    0.14029817f, 0.12996253f, 0.15631871f, 0.29029456f, -0.12926815f, -0.06295077f, 0.23649056f, 0.11320710f, 
    -0.12423831f, 0.06068171f, 0.01395286f, -0.10968897f, -0.04394605f, 0.05080235f, 0.01636565f, 0.14184374f, 
    0.08763698f, 0.08739204f, 0.06458545f, 0.07876618f, 0.02540101f, 0.18179496f, -0.02234966f, -0.05355720f, 
    0.06841831f, -0.01502741f, -0.13819450f, 0.06991097f, 0.00194778f, 0.04352770f, 0.11041070f, 0.11602574f, 
    0.01533521f, 0.04949429f, 0.03044345f, -0.00213601f, -0.14207450f, -0.21643218f, -0.07530325f, 0.20729285f, 
    0.01290704f, 0.14938109f, 0.17976433f, -0.13147189f, 0.09987497f, -0.12594895f, 0.02050550f, -0.27200127f, 
    0.00300888f, 0.17615160f, 0.08243504f, 0.25218719f, 0.10212179f, -0.10099249f, -0.04962356f, 0.02562760f, 
    0.08851179f, 0.06077509f, 0.05844475f, 0.26963568f, -0.09441383f, 0.04215481f, -0.08764835f, 0.08494992f, 
    -0.06435584f, 0.09001248f, 0.02769235f, -0.02609108f, 0.03149803f, 0.11020119f, 0.06058985f, 0.13571529f, 
    0.36591706f, 0.27129796f, 0.21727949f, 0.12619571f, 0.05448974f, 0.10162131f, -0.04888647f, 0.27268940f, 
    0.00691214f, 0.06621628f, 0.07203212f, -0.14838718f, -0.12288456f, 0.52885848f, 0.20847869f, 0.23490311f, 
    0.00198077f, -0.10161028f, 0.06309756f, -0.21651603f, 0.06905690f, -0.06463657f, -0.00974610f, 0.05457999f, 
    -0.06693492f, 0.20135696f, -0.17407338f, 0.13627726f, 0.20556676f, -0.00955832f, -0.00348298f, -0.09287100f, 
    -0.24157901f, -0.02236413f, -0.05892493f, -0.00438595f, 0.17154385f, -0.00143901f, 0.19055705f, 0.03351438f, 
    0.09741750f, 0.13482560f, -0.11020619f, -0.10714831f, -0.08671972f, 0.00074895f, -0.12961151f, -0.21527764f, 
    -0.03659850f, 0.07690085f, 0.05117654f, 0.02362459f, 0.01308466f, 0.15407610f, 0.00236935f, -0.06515782f, 
    0.07396132f, -0.11293002f, -0.18444183f, -0.19154108f, 0.03465338f, -0.35435554f, 0.14085878f, -0.22478932f, 
    0.03522510f, -0.17117722f, 0.17321454f, -0.07866461f, 0.04610639f, -0.08906296f, -0.05738642f, -0.06491780f, 
    -0.19604303f, 0.07007190f, -0.37118050f, 0.41612735f, 0.11510701f, 0.06309233f, -0.08269518f, -0.31348521f, 
    -0.12938243f, -0.02381206f, 0.08023067f, 0.13054344f, 0.13517722f, 0.07057679f, -0.06236681f, 0.25420943f, 
    -0.05712249f, 0.08693571f, 0.04684360f, -0.06374685f, 0.09054257f, -0.03419210f, 0.02708028f, 0.09054928f, 
    0.35497558f, -0.13113633f, 0.08360749f, 0.21930601f, -0.04941063f, -0.01688881f, 0.09361335f, 0.17470227f, 
    0.01966157f, -0.02830723f, -0.03489162f, -0.07241137f, -0.29829785f, 0.41127625f, -0.22754201f, 0.32981527f, 
    -0.03573510f, -0.08558678f, 0.02367694f, -0.18542926f, 0.03747682f, 0.03733396f, -0.09125312f, 0.29490334f, 
    -0.13660190f, 0.11709182f, 0.00966133f, 0.20776103f, 0.01223737f, -0.01798963f, 0.01679291f, 0.04547029f, 
    -0.08150896f, -0.01069820f, -0.10800884f, -0.08089361f, -0.35693035f, 0.20578766f, -0.00572851f, 0.08133351f, 
    0.12216426f, 0.03362626f, -0.00310471f, 0.11119194f, -0.08585994f, 0.04878735f, 0.08818950f, 0.02149512f, 
    0.15782391f, -0.00250549f, 0.15256535f, 0.33497423f, 0.04243075f, 0.17097522f, 0.00796578f, -0.00728848f, 
    0.00791155f, -0.12392788f, 0.14490426f, -0.08691728f, 0.08323620f, -0.26858866f, 0.22090442f, -0.24950098f, 
    -0.04993517f, -0.20737992f, -0.11383053f, -0.06963535f, 0.06402105f, -0.05342282f, 0.14920634f, 0.11105368f, 
    0.01485287f, 0.03910382f, -0.05012866f, -0.02330161f, -0.04349158f, -0.00002900f, -0.05656830f, -0.01755427f, 
    0.03063315f, -0.02343983f, -0.03945321f, -0.01851037f, -0.00965508f, 0.02692384f, -0.04894483f, 0.01862889f, 
    -0.04625725f, -0.03574210f, -0.05519204f, -0.04479032f, -0.03917019f, -0.03172467f, -0.00897534f, -0.04525601f, 
    0.02037959f, 0.00139878f, 0.03722285f, 0.01538633f, -0.04270429f, 0.03125280f, 0.03707353f, 0.02869594f, 
    0.02247367f, 0.00026617f, 0.04000079f, 0.00393637f, 0.02961281f, -0.04603763f, 0.01592409f, 0.03910591f, 
    -0.03031597f, 0.02462428f, -0.04978342f, -0.02377635f, 0.01762831f, 0.03909562f, 0.03027091f, 0.03244172f, 
    0.04043905f, -0.01824132f, -0.01137485f, 0.02265811f, 0.00376622f, -0.02364164f, -0.04585218f, -0.02140867f, 
    -0.01508213f, 0.00240089f, -0.00880692f, -0.04291405f, -0.02470750f, 0.03827337f, -0.03407875f, -0.03373548f, 
    -0.02291266f, 0.02692654f, 0.02655329f, -0.04971253f, -0.02029057f, -0.00244551f, -0.01687892f, 0.01229688f, 
    -0.02853699f, -0.02551233f, 0.01338031f, 0.03959611f, -0.04061052f, -0.00443344f, -0.00581782f, -0.02952796f, 
    -0.00752686f, 0.01876876f, -0.03645702f, -0.05308422f, 0.00638859f, -0.01619106f, 0.00625406f, -0.02603662f, 
    -0.02727155f, 0.01675828f, 0.03069824f, -0.02546653f, 0.01901790f, -0.00457762f, -0.03635476f, -0.01509407f, 
    -0.04456656f, -0.02437625f, -0.02582997f, 0.00718441f, -0.02996759f, 0.01473054f, -0.02629048f, 0.00668856f, 
    -0.02043500f, -0.03448406f, 0.00099703f, 0.02415725f, 0.03209174f, -0.04775047f, 0.00975537f, -0.00964455f, 
    0.00547991f, 0.00311556f, 0.02829994f, 0.05001749f, 0.02687470f, -0.02046192f, -0.02406952f, 0.01568377f, 
    0.04157685f, 0.04043018f, -0.04922586f, -0.03546071f, -0.04215812f, -0.01533465f, 0.04343230f, 0.03040916f, 
    0.04021143f, 0.03325814f, -0.02457633f, -0.01046095f, -0.04670849f, -0.04559173f, -0.01843110f, -0.02165390f, 
    -0.03295571f, -0.04776858f, -0.05510434f, -0.00967138f, 0.01623234f, -0.00806487f, -0.04674562f, 0.02559174f, 
    0.00880896f, 0.02628686f, -0.02143862f, -0.01625749f, 0.01983229f, 0.02997241f, -0.03652046f, -0.05675991f, 
    -0.00679516f, 0.03202643f, 0.03389942f, -0.02470450f, 0.01949786f, -0.05101499f, -0.04795470f, 0.04000602f, 
    0.00965096f, -0.01667065f, 0.01410722f, 0.04020018f, 0.03605058f, 0.01379251f, -0.05053547f, 0.03212646f, 
    0.02216694f, -0.01139555f, -0.05457173f, 0.01783063f, 0.04463860f, -0.04910968f, -0.02395722f, -0.02458345f, 
    0.04347809f, -0.03699926f, 0.00082551f, -0.04375754f, 0.00380296f, -0.03633354f, -0.04681690f, -0.02047226f, 
    -0.01585465f, 0.02384720f, 0.03007399f, 0.01750301f, -0.00634333f, -0.00491337f, -0.01038317f, -0.04698718f, 
    -0.04884491f, -0.02496834f, -0.00281419f, 0.00761727f, -0.00936574f, -0.00978167f, -0.05259370f, 0.00828643f, 
    0.01478570f, -0.02533959f, -0.03049687f, -0.04190856f, 0.02571332f, -0.02011649f, -0.03739268f, -0.02314168f, 
    0.00268829f, -0.04770833f, 0.00959464f, -0.02469376f, 0.00959961f, -0.00520210f, -0.02495265f, -0.04952615f, 
    -0.02482279f, -0.02484279f, 0.03079413f, 0.01055713f, -0.02211427f, 0.00998926f, 0.03900906f, 0.04095242f, 
    -0.03136386f, -0.00619165f, -0.04576968f, 0.00999956f, -0.02949150f, -0.04270434f, -0.04781542f, 0.01894074f, 
    0.02921274f, 0.02054535f, -0.04611034f, -0.05477129f, -0.01856332f, -0.04236007f, 0.00310726f, -0.01668822f, 
    0.01923062f, 0.05054199f, 0.04436439f, 0.03610970f, 0.03156987f, -0.02482752f, -0.04101058f, 0.03669922f, 
    -0.01380579f, -0.01426412f, 0.02298160f, 0.01815997f, -0.05055226f, -0.00012676f, -0.04876225f, 0.02520328f, 
    -0.02010502f, 0.03066925f, -0.04125074f, -0.00539535f, -0.02818568f, -0.04254268f, -0.01806153f, -0.04111277f, 
    -0.02250762f, -0.03475095f, -0.01999944f, 0.01987797f, 0.01045194f, -0.01263609f, -0.01816012f, -0.04639302f, 
    -0.05135106f, 0.02811545f, 0.02196759f, -0.03830391f, -0.02955936f, -0.01041999f, 0.02903373f, 0.02763193f, 
    -0.00266652f, 0.01771789f, -0.00288542f, -0.01787710f, -0.03147153f, 0.04052097f, -0.00772376f, 0.00108127f, 
    -0.04070675f, 0.00531431f, 0.02769346f, 0.03473453f, -0.04510392f, -0.02173103f, -0.01834116f, 0.00997804f, 
    -0.00420372f, -0.03878717f, -0.02523559f, 0.03258063f, -0.03786936f, -0.04148014f, -0.05215713f, 0.01906177f, 
    -0.03587644f, -0.02840397f, -0.00684557f, -0.02183283f, 0.02288975f, 0.02475801f, -0.03448404f, -0.01282799f, 
    -0.02761794f, -0.00817128f, 0.03695147f, -0.02250069f, 0.00659133f, -0.00223017f, 0.04183319f, -0.05261729f, 
    -0.00934077f, -0.03510562f, -0.01296121f, 0.02852442f, -0.05519564f, -0.05523498f, 0.00870201f, -0.00139766f, 
    0.01770250f, 0.00338127f, 0.02161464f, 0.00882568f, 0.04473644f, -0.02533614f, -0.04236766f, -0.05159011f, 
    -0.04885936f, -0.00221770f, 0.04537803f, -0.02315373f, 0.01029904f, 0.02928253f, -0.04033503f, -0.03229418f, 
    -0.00114590f, 0.03610569f, -0.02661188f, -0.04322221f, 0.02681969f, 0.00339132f, -0.03854401f, 0.02950880f, 
    0.03095572f, -0.04672176f, 0.04185152f, 0.03733208f, -0.03596770f, 0.03022690f, 0.04291438f, 0.02896544f, 
    0.04342936f, -0.02006940f, -0.05620642f, -0.02499743f, -0.01914482f, -0.04996747f, -0.00520635f, 0.03729275f, 
    0.03648010f, 0.02301018f, 0.02161862f, 0.01048435f, 0.02003257f, 0.00338491f, -0.05352734f, -0.01897174f, 
    -0.04730664f, -0.05284810f, -0.04621445f, 0.03423057f, -0.04441931f, -0.01885143f, -0.00188885f, -0.05692873f, 
    0.03160434f, -0.05520578f, -0.01526676f, -0.02420941f, -0.02664600f, -0.04376023f, 0.03741707f, -0.04631302f, 
    -0.01351807f, -0.04885598f, 0.02394140f, 0.01621898f, 0.00566696f, -0.04350534f, 0.04191631f, 0.02775076f, 
    -0.03894845f, -0.02871971f, 0.03499518f, 0.02099528f, -0.02754952f, -0.03861574f, -0.04633461f, 0.03202475f, 
    -0.02904109f, -0.02357130f, -0.02388854f, -0.01381291f, 0.03724873f, -0.01436325f, 0.03801173f, 0.00743743f, 
    0.03021702f, -0.01679444f, -0.00518859f, 0.04053712f, -0.04812576f, -0.02902315f, 0.03892601f, 0.00688523f, 
    -0.02100476f, -0.03397695f, -0.04040578f, 0.01873401f, -0.04711174f, 0.00434601f, -0.01763494f, -0.04031041f, 
    -0.02253213f, -0.00435291f, -0.04898355f, 0.03700192f, -0.01662890f, 0.03154769f, 0.03065508f, 0.01062467f, 
    -0.03906256f, 0.03387661f, -0.03726606f, -0.02111703f, 0.01277931f, 0.02720963f, -0.05311599f, -0.04888060f, 
    -0.02605001f, -0.01441291f, -0.03181311f, -0.00548531f, 0.02035468f, 0.02166943f, -0.05985917f, 0.01820640f, 
    -0.03269265f, 0.02352891f, -0.00997426f, -0.05352470f, 0.01192695f, 0.03359705f, -0.02353568f, 0.02216368f, 
    -0.03300463f, 0.02720168f, 0.02358112f, 0.02394775f, 0.02920729f, 0.02486637f, -0.05439725f, 0.00989722f, 
    -0.03311275f, -0.00371236f, -0.05119230f, 0.00830767f, 0.02641641f, 0.00616549f, 0.00627433f, -0.05623029f, 
    0.03622139f, 0.03758205f, -0.02871276f, -0.05279097f, -0.05767237f, 0.02290406f, -0.00087333f, -0.01938601f, 
    0.01894296f, -0.01330469f, -0.03260274f, -0.02581866f, 0.02673086f, -0.00040375f, -0.03933819f, -0.04567087f, 
    -0.02905463f, 0.03398396f, -0.03041399f, -0.01707632f, -0.00315197f, -0.01299646f, 0.03309705f, -0.00249210f, 
    -0.02317393f, 0.01383264f, 0.03189335f, -0.04527681f, -0.03359934f, -0.03513244f, -0.02450072f, 0.00066892f, 
    0.02467792f, 0.00458793f, -0.00058064f, 0.02375941f, -0.00014991f, -0.01809605f, 0.01557999f, -0.00978004f, 
    0.00064582f, -0.03498333f, -0.03422603f, -0.05418107f, -0.01443930f, -0.03181723f, 0.02792327f, -0.05319016f, 
    0.02340774f, -0.03465874f, -0.01473131f, 0.02187499f, -0.00648944f, 0.00248172f, -0.04966921f, -0.00417676f, 
    -0.03536623f, -0.04453510f, 0.00782550f, -0.00671045f, 0.01347879f, -0.01620275f, -0.05773275f, -0.05053796f, 
    0.03679845f, -0.03291507f, -0.03221212f, 0.03721452f, 0.00452734f, 0.02745741f, -0.02316463f, -0.06077101f, 
    -0.02523537f, -0.02279903f, 0.03313906f, 0.00491803f, 0.02095848f, -0.02226460f, -0.00380275f, -0.00619035f, 
    0.04041413f, -0.00787153f, 0.01859976f, -0.02146857f, 0.00371422f, 0.00602879f, 0.00229909f, -0.03068360f, 
    0.00270648f, -0.01913714f, 0.00416430f, 0.02902927f, 0.00738305f, 0.01345474f, 0.03762805f, 0.01553749f, 
    0.00617469f, -0.04067328f, 0.01366148f, 0.03497652f, 0.03764517f, -0.00468446f, -0.05508545f, 0.01387779f, 
    0.00013356f, -0.02590369f, -0.04227528f, -0.02148609f, 0.02705044f, -0.01458348f, -0.02949433f, -0.03550992f, 
    -0.00890633f, 0.02894066f, 0.00021818f, 0.00971621f, -0.06039509f, -0.02465495f, -0.01376057f, 0.02557270f, 
    -0.01242719f, -0.03127266f, 0.02665645f, -0.01246554f, 0.00996787f, 0.02079306f, 0.03251665f, -0.03224588f, 
    -0.02237670f, -0.03189837f, -0.00830672f, 0.00916005f, 0.02377950f, 0.01526133f, 0.00127382f, -0.00665586f, 
    -0.00935015f, 0.00121542f, -0.01962909f, -0.02400883f, -0.01231267f, 0.02686380f, -0.03357835f, -0.02006380f, 
    -0.02330010f, -0.00012616f, -0.05737806f, 0.03772300f, -0.00806200f, -0.03972489f, 0.00468231f, -0.02527335f, 
    -0.00039485f, -0.02989198f, -0.00174491f, -0.04980274f, -0.04683511f, -0.00130050f, 0.00481934f, -0.05712192f, 
    -0.00067997f, 0.00878496f, -0.05265500f, -0.02240847f, -0.05269494f, -0.01807424f, 0.01392358f, -0.01562708f, 
    0.00262608f, 0.00760044f, -0.00350035f, 0.00592860f, -0.00081547f, 0.01930799f, 0.02404068f, -0.05929840f, 
    -0.06034799f, -0.04492959f, 0.02833759f, 0.00986728f, 0.01754057f, 0.00562426f, 0.03291407f, -0.03452973f, 
    -0.01654997f, -0.00110684f, -0.03609124f, -0.02410631f, -0.03677526f, 0.00294724f, 0.02939179f, -0.02563370f, 
    -0.02375385f, 0.00097440f, 0.01632351f, 0.02795812f, -0.02683957f, 0.03409271f, -0.03285474f, -0.05826190f, 
    -0.05436982f, -0.00221434f, 0.02520786f, 0.00605347f, -0.00557469f, 0.02393382f, -0.03483944f, -0.00278637f, 
    0.03895901f, -0.00948554f, 0.00340745f, -0.02830492f, -0.04082002f, -0.03703600f, -0.00236147f, -0.03546450f, 
    -0.03989838f, 0.01369953f, -0.01652470f, 0.03348288f, 0.02714843f, 0.02026590f, -0.01647082f, -0.00857573f, 
    0.00795453f, -0.02180659f, -0.02828930f, 0.01893596f, 0.04100663f, -0.02045619f, 0.00238556f, -0.03629240f, 
    0.01756330f, 0.03902413f, -0.00295349f, -0.05757106f, -0.05082827f, -0.04624251f, 0.03119001f, -0.02951179f, 
    0.02023381f, -0.01409137f, 0.02109325f, -0.03656217f, 0.04131158f, 0.02771820f, -0.03395466f, -0.00816217f, 
    0.00123348f, 0.03437532f, 0.00508002f, -0.03532374f, 0.01720486f, -0.01828575f, -0.04925775f, -0.02816746f, 
    0.01335073f, -0.05462282f, -0.01813453f, -0.04654311f, -0.00460321f, 0.02260308f, -0.03964707f, 0.03656320f, 
    -0.00693971f, -0.01879424f, -0.02164675f, -0.02132359f, -0.03381636f, -0.01034264f, -0.05456478f, -0.01916758f, 
    -0.02917284f, -0.00481248f, 0.04035253f, -0.05450799f, 0.03574625f, 0.02654507f, 0.04040062f, -0.00377641f, 
    0.00040036f, 0.02910344f, -0.04733853f, 0.03315225f, -0.00987378f, -0.00517377f, -0.01637571f, 0.03135905f, 
    0.20254651f, 0.35942769f, 0.12580888f, -0.04048883f, -0.14595233f, 0.19089933f, 0.01286340f, -0.07339817f, 
    0.19177055f, -0.17754760f, 0.05444208f, 0.03489575f, -0.10399857f, 0.06681647f, -0.06557267f, -0.03350327f, 
    0.21824412f, -0.13403046f, 0.06267483f, 0.04664673f, -0.06368251f, 0.00198658f, 0.10797881f, 0.02315276f, 
    0.41547900f, 0.05166649f, 0.05251873f, -0.12224588f, 0.13269828f, 0.19506009f, -0.00722875f, 0.05457875f, 
    0.11825497f, 0.11029745f, 0.15320399f, -0.00543049f, 0.16642870f, 0.06852294f, 0.02826121f, 0.15281142f, 
    0.15708244f, 0.20508559f, -0.13812831f, 0.21510209f, -0.06091508f, 0.00600800f, 0.03573738f, -0.00764446f, 
    -0.08367579f, 0.10609691f, 0.00889970f, -0.21376401f, -0.06025421f, 0.12457325f, 0.08894433f, 0.05546748f, 
    0.03332472f, -0.20710817f, -0.22436050f, -0.21910809f, -0.28076792f, -0.25391266f, 0.07255612f, 0.12002590f, 
    -0.08750689f, 0.00102872f, -0.01055460f, -0.01711167f, 0.10013711f, 0.00133086f, 0.10140523f, 0.08078156f, 
    0.01207138f, -0.11838993f, -0.08069979f, 0.44818807f, -0.08978610f, 0.12001012f, 0.03603814f, 0.08287819f, 
    0.04281352f, -0.02202505f, 0.08280972f, 0.00108642f, -0.45221516f, 0.05539610f, -0.06221637f, 0.04198184f, 
    0.17148602f, 0.06766379f, 0.09473822f, -0.00693843f, -0.05692022f, -0.06372305f, -0.03773092f, -0.11725765f, 
    -0.01626995f, -0.21776386f, -0.17671308f, -0.18416896f, 0.08449238f, 0.23791862f, -0.10666162f, -0.09438452f, 
    0.01700191f, -0.01028824f, 0.00243952f, 0.17227714f, -0.15334976f, -0.20077831f, 0.08253154f, 0.06826159f, 
    -0.10961016f, 0.03427025f, -0.08200890f, -0.00159946f, 0.12886328f, -0.02804270f, 0.24860029f, 0.02227804f, 
    -0.17351545f, 0.03078911f, -0.14984153f, 0.19400348f, 0.11415733f, -0.28044248f, 0.07668766f, 0.08881757f, 
    -0.04458279f, 0.17972641f, 0.07838695f, -0.00146879f, -0.65339100f, 0.15395850f, 0.17460687f, -0.09739455f, 
    -0.02213068f, 0.17049432f, 0.01238173f, 0.12413404f, 0.01439758f, 0.07038470f, -0.11398336f, -0.02755700f, 
    -0.06974748f, -0.01499585f, -0.11444796f, 0.11459715f, -0.03963179f, 0.05657164f, -0.00533209f, -0.11075424f, 
    -0.13649693f, -0.03685998f, 0.04343377f, 0.11763855f, -0.07024133f, -0.01386040f, -0.08031510f, -0.13003275f, 
    -0.06449012f, -0.10530054f, -0.07463558f, -0.03237016f, 0.04356149f, -0.04545447f, -0.00779842f, 0.13628207f, 
    -0.29001856f, -0.06517932f, 0.09873981f, 0.00528507f, 0.12493289f, -0.08835749f, -0.08261804f, -0.10114508f, 
    -0.00093765f, -0.00643848f, 0.08587763f, 0.10023836f, 0.26973003f, 0.11659439f, 0.02070672f, -0.02101580f, 
    0.00063103f, -0.26106638f, 0.07233147f, 0.07767393f, -0.07605151f, 0.17322353f, 0.03930844f, -0.02670414f, 
    -0.08289061f, -0.01051920f, -0.13737799f, -0.02323706f, 0.09758620f, 0.08120944f, 0.12303395f, 0.13326749f, 
    0.06842404f, -0.08127658f, 0.04152384f, 0.06753905f, -0.13240319f, -0.01339825f, 0.01908967f, -0.15242094f, 
    0.11614612f, -0.14078796f, 0.02128249f, 0.02198707f, 0.00977743f, -0.07871732f, 0.07666679f, 0.19064535f, 
    0.11399321f, 0.13228138f, -0.02922122f, -0.20275867f, 0.01887828f, -0.02733494f, 0.00579048f, -0.09205129f, 
    0.03513294f, 0.02512453f, 0.01204151f, 0.04841026f, -0.21410862f, -0.29713488f, -0.21050100f, 0.13594605f, 
    0.12745038f, -0.04555231f, 0.28013361f, 0.13965528f, 0.18175343f, 0.09347422f, -0.09814050f, 0.05250388f, 
    -0.06595494f, -0.17033222f, 0.03341333f, 0.06139791f, -0.16011374f, 0.01442808f, -0.04378132f, -0.03618099f, 
    0.22875069f, -0.04332482f, 0.14272459f, 0.02767170f, -0.17311980f, -0.09802252f, -0.16518576f, 0.01678892f, 
    0.17352428f, 0.15598127f, 0.01003134f, 0.04222377f, 0.00541934f, 0.12553644f, 0.04834993f, 0.00294451f, 
    0.03966362f, -0.05307365f, -0.02966116f, -0.11653633f, -0.00626407f, -0.08636753f, -0.06356220f, -0.16158000f, 
    -0.03294342f, 0.06508806f, 0.14022884f, 0.07367469f, -0.37609765f, 0.19484340f, -0.30816814f, 0.32496604f, 
    0.02730097f, -0.13849793f, -0.10575744f, -0.01089865f, 0.19759232f, -0.08659107f, -0.08745895f, 0.23434384f, 
    -0.11705565f, 0.07897264f, -0.07373545f, -0.16665730f, -0.04369834f, -0.08747670f, 0.14102635f, 0.14685057f, 
    -0.00888002f, -0.01901445f, 0.03925258f, 0.18564488f, -0.01231893f, 0.11171307f, -0.09700863f, -0.04875251f, 
    0.17951049f, -0.17799799f, -0.10560291f, -0.01288619f, -0.08488754f, -0.04102935f, -0.07579282f, -0.16581473f, 
    0.01160406f, 0.24097966f, 0.10159531f, 0.06810258f, 0.02468759f, -0.05570141f, -0.01545938f, 0.06521474f, 
    0.05803340f, -0.07398779f, -0.01002608f, -0.00553617f, 0.28680831f, -0.17183828f, -0.13379671f, -0.22959656f, 
    0.05833776f, 0.05117156f, -0.11249249f, 0.02425425f, 0.26396602f, -0.05118895f, -0.17110871f, 0.00668857f, 
    -0.06341273f, -0.00168369f, 0.00368282f, -0.19929454f, -0.13027243f, -0.06095761f, -0.01463715f, -0.01798396f, 
    -0.00368387f, 0.03993617f, 0.16060700f, 0.21388304f, -0.01831396f, -0.15042618f, -0.02267145f, -0.07066144f, 
    -0.18497480f, -0.02237522f, 0.08410729f, 0.03413333f, 0.33737952f, 0.05243541f, 0.11190626f, -0.10935070f, 
    0.24812250f, 0.32401356f, -0.03803371f, -0.17577615f, 0.11255272f, -0.06223462f, -0.03521750f, -0.04812711f, 
    0.01509643f, 0.13875520f, 0.08494954f, 0.22962725f, -0.03208961f, -0.00618306f, 0.09635505f, 0.17327659f, 
    0.03263576f, 0.26095933f, -0.13168870f, 0.20530847f, 0.08420552f, -0.03646500f, 0.01923109f, -0.19010651f, 
    0.09552348f, -0.09968145f, 0.28057516f, 0.29542312f, 0.10984146f, -0.29103488f, -0.08154862f, 0.28369799f, 
    -0.06420110f, 0.12863593f, 0.25147152f, 0.13850449f, 0.10567838f, -0.11378627f, 0.01055845f, -0.04390699f, 
    0.00657339f, 0.04040078f, 0.03656470f, -0.07227879f, -0.03246275f, 0.03818224f, -0.01975296f, -0.00643583f, 
    0.17343311f, -0.36354965f, 0.02481164f, 0.09636435f, -0.01663317f, -0.05164334f, 0.36089945f, 0.05801279f, 
    0.05122532f, 0.08797901f, -0.12580806f, -0.04459869f, -0.24037468f, -0.38218746f, -0.25958669f, -0.11228799f, 
    0.15624750f, 0.05717457f, 0.30655873f, -0.09832177f, 0.10189443f, -0.04399140f, 0.09613350f, 0.06822877f, 
    -0.01560627f, -0.24311042f, -0.25513938f, -0.00101096f, -0.00819010f, -0.06449730f, 0.09784168f, 0.00936703f, 
    0.08282004f, 0.07593110f, 0.06369639f, 0.16321240f, -0.26143023f, 0.18557629f, 0.15002429f, 0.05242215f, 
    0.11482842f, -0.00204118f, -0.03003390f, -0.05909804f, -0.06537167f, 0.04473945f, 0.01094817f, 0.04575099f, 
    -0.23950766f, -0.14077953f, -0.00767638f, -0.11755543f, 0.12135416f, -0.14749268f, 0.10403387f, -0.00099296f, 
    -0.01764213f, 0.01208636f, -0.04429081f, 0.00809152f, 0.36615989f, -0.11254852f, -0.20540413f, -0.03007447f, 
    -0.05416131f, 0.14168064f, 0.21454965f, 0.21176362f, 0.10752784f, -0.06817685f, -0.02039884f, 0.09891557f, 
    0.23220594f, -0.20392784f, -0.18854225f, -0.09036609f, 0.11245145f, -0.32917482f, 0.11113589f, -0.06291981f, 
    0.13972981f, -0.01692094f, -0.04481439f, -0.06675190f, 0.07131976f, 0.01956289f, -0.02512545f, -0.13342258f, 
    0.13638552f, -0.07887628f, -0.05498658f, -0.01378140f, 0.07190206f, 0.03493641f, -0.02181656f, -0.03873232f, 
    0.02330598f, -0.17198601f, 0.04246666f, 0.01651437f, 0.07929925f, -0.05716696f, 0.04145847f, -0.01088444f, 
    0.07887047f, 0.00757780f, 0.02214469f, 0.16666375f, 0.15155053f, -0.47407126f, 0.10023908f, 0.00151160f, 
    0.28268895f, 0.29680851f, 0.04913591f, 0.02238665f, 0.09433767f, -0.08017627f, -0.01674927f, -0.00110838f, 
    -0.08251639f, -0.19192640f, -0.30577433f, -0.07171733f, 0.00059221f, -0.14348203f, 0.07314830f, 0.16966897f, 
    -0.05253021f, -0.02731701f, -0.02720831f, 0.14536576f, -0.05585442f, -0.02103874f, -0.12471736f, -0.11895879f, 
    0.03963228f, 0.04457809f, 0.00805340f, -0.04363186f, -0.04320101f, -0.03125549f, -0.16510446f, -0.19329312f, 
    -0.10659546f, 0.18149975f, -0.02165280f, 0.08039752f, -0.00274883f, 0.07851298f, 0.04230377f, -0.07222842f, 
    0.01570508f, 0.05065222f, 0.03754756f, -0.07247435f, 0.00038740f, -0.22918199f, 0.20013145f, -0.10967591f, 
    0.43483675f, 0.06649589f, -0.05580959f, 0.03078956f, 0.15798329f, 0.03782969f, -0.02461025f, 0.14553019f, 
    0.13210966f, 0.15610434f, 0.14081307f, 0.02509457f, -0.07271095f, -0.02035627f, -0.02823782f, 0.00574737f, 
    0.01402168f, 0.06184679f, 0.09054386f, 0.17346685f, 0.12094294f, -0.01936975f, -0.08392373f, -0.10240133f, 
    -0.03517976f, 0.07088759f, 0.02088160f, -0.05351577f, 0.04970523f, 0.02488947f, 0.05515934f, 0.05339769f, 
    -0.15845399f, -0.20137836f, -0.21722610f, -0.01766298f, 0.06548721f, 0.11403301f, 0.11097831f, 0.02767096f, 
    0.02813804f, 0.00455139f, -0.05350712f, -0.04391755f, 0.37204042f, -0.03987634f, -0.00481891f, -0.02317453f, 
    -0.13930325f, 0.13369636f, -0.13376537f, -0.10945708f, 0.23292433f, 0.06417782f, 0.04203397f, 0.14262462f, 
    0.06963255f, -0.03902902f, 0.03682448f, -0.14887801f, 0.14307380f, -0.02410619f, -0.01771386f, 0.04621527f, 
    -0.09580626f, -0.04422739f, 0.10195330f, 0.13388556f, -0.01588100f, 0.23608401f, -0.03496081f, -0.04377187f, 
    0.10668621f, 0.11744809f, 0.23445965f, 0.07164191f, 0.04780335f, 0.01729056f, -0.10764593f, -0.07265926f, 
    0.09641546f, 0.04469648f, 0.02056324f, 0.04822363f, 0.10173186f, 0.06035540f, 0.02812094f, -0.05522539f, 
    0.12917523f, 0.08971292f, -0.09948896f, 0.05017043f, 0.29227954f, -0.13511226f, 0.14668795f, 0.33442381f, 
    -0.00403548f, 0.10963668f, 0.03585615f, 0.02807753f, 0.13105433f, 0.02257894f, 0.44612724f, 0.12721370f, 
    -0.30331010f, -0.26488435f, -0.05831343f, -0.25568488f, -0.13308127f, 0.00205378f, -0.07909775f, -0.01624585f, 
    -0.03727493f, 0.04719840f, 0.18022384f, 0.05386674f, 0.06094297f, -0.10949864f, -0.08760082f, -0.04822327f, 
    -0.03567290f, 0.16079329f, 0.12652561f, -0.01608747f, -0.08205618f, 0.14399770f, 0.05555083f, -0.03580366f, 
    -0.06566536f, -0.23809779f, -0.25809696f, -0.04180266f, 0.05438003f, 0.07040073f, 0.13943027f, 0.01750197f, 
    -0.03630293f, 0.07335287f, 0.02224215f, -0.11033395f, -0.06562766f, 0.23499943f, 0.27854326f, 0.20828266f, 
    0.03042000f, 0.11606816f, 0.03717827f, -0.00352779f, 0.03012851f, 0.05294904f, 0.05278287f, 0.28102511f, 
    0.12922679f, -0.09650435f, 0.08266949f, -0.08175404f, 0.21656817f, -0.02191930f, -0.01115818f, -0.07675029f, 
    -0.01275812f, 0.06571324f, -0.05846794f, -0.03593220f, 0.31070453f, 0.17557234f, 0.15443398f, 0.05387009f, 
    0.18247575f, -0.01623355f, -0.12336846f, -0.12797734f, -0.15451494f, 0.12035863f, -0.00978138f, 0.09569428f, 
    -0.04325334f, -0.16192433f, -0.08814933f, -0.11506432f, -0.00965557f, 0.05609037f, 0.08456007f, 0.05386496f, 
    -0.04588792f, -0.07811084f, -0.02489480f, -0.14581148f, -0.30203837f, 0.46256226f, 0.04856707f, 0.16652270f, 
    0.02586461f, 0.08904016f, 0.23437436f, 0.04829554f, -0.08481488f, 0.17866604f, 0.30649489f, 0.10135993f, 
    0.03546307f, -0.02144779f, 0.00284326f, 0.02127701f, -0.03087416f, -0.03022206f, -0.03768784f, -0.02996986f, 
    -0.03818424f, -0.05653445f, -0.02770844f, -0.01655226f, -0.04714202f, -0.02002750f, -0.02545743f, 0.02747727f, 
    0.00465526f, 0.03146758f, -0.01981729f, 0.01487196f, -0.05418878f, -0.00070806f, 0.03548362f, -0.01673259f, 
    -0.04210021f, -0.00940000f, 0.02027812f, -0.04045900f, 0.00980519f, -0.05548737f, -0.00458325f, -0.01073569f, 
    0.01241934f, -0.02109643f, -0.00131188f, 0.00029661f, -0.02270433f, 0.01696957f, 0.00768502f, -0.04595444f, 
    -0.04269974f, -0.02820659f, -0.04928999f, -0.04607845f, 0.03627634f, -0.03465132f, 0.00433330f, 0.03573861f, 
    0.03449615f, -0.00820988f, 0.01054256f, 0.02524102f, 0.02326308f, -0.04401432f, 0.03885188f, 0.02369418f, 
    -0.04825800f, -0.04787890f, 0.03515762f, 0.02058823f, 0.00586069f, 0.02600390f, 0.01027311f, -0.04423882f, 
    -0.00318850f, -0.01439957f, -0.02438471f, -0.01122048f, -0.04198077f, 0.02451783f, -0.02408411f, 0.02498456f, 
    0.03214723f, -0.01542688f, 0.03316097f, 0.02283501f, 0.03038581f, -0.00635615f, -0.04996118f, -0.01770054f, 
    -0.05216702f, 0.02795476f, 0.01027427f, -0.04608586f, 0.01049479f, -0.03769550f, 0.00434598f, 0.02927900f, 
    -0.02160458f, 0.02004014f, 0.03084225f, 0.00840059f, 0.00388492f, 0.00008899f, 0.00096687f, -0.02790423f, 
    -0.04807553f, 0.00282006f, 0.02507662f, 0.03818822f, -0.02973186f, -0.05555774f, -0.02299575f, 0.02992477f, 
    0.01549943f, 0.00335337f, 0.04455385f, -0.04840484f, -0.05046677f, -0.04281326f, 0.01576803f, 0.02895758f, 
    0.01361455f, -0.04076116f, 0.00196414f, -0.04711405f, -0.05368706f, 0.01516639f, -0.03525884f, -0.05395148f, 
    -0.00722501f, 0.02770447f, -0.04398920f, -0.02314226f, -0.03262481f, 0.03287893f, 0.03867478f, 0.02608956f, 
    -0.01264939f, -0.04513248f, 0.01848623f, 0.02241296f, -0.04287050f, -0.04499948f, 0.04114766f, -0.02225252f, 
    0.00863880f, -0.01990561f, 0.02022321f, 0.04377032f, -0.03435086f, -0.00459657f, 0.03675037f, 0.04358402f, 
    -0.01615268f, 0.00941039f, -0.01366859f, -0.04591404f, 0.00919521f, -0.02143017f, 0.01953301f, 0.03246593f, 
    -0.05149293f, 0.02131220f, -0.02949390f, -0.00187076f, 0.03355560f, -0.03235091f, 0.01955828f, 0.04244445f, 
    -0.04351033f, 0.03870038f, -0.01142544f, 0.01475779f, 0.04120957f, 0.02679378f, -0.03424649f, -0.03606872f, 
    -0.05306727f, 0.01996162f, -0.00067523f, -0.03405814f, 0.01993680f, 0.02954121f, 0.01601947f, 0.00710735f, 
    -0.03425301f, -0.01382908f, 0.03751727f, -0.02524042f, -0.02169800f, -0.01894751f, -0.00829615f, -0.01856889f, 
    0.01540709f, -0.01661972f, -0.03827633f, 0.02448080f, -0.00529146f, -0.03086334f, -0.00923203f, 0.00054121f, 
    -0.04389511f, -0.03940913f, 0.03040721f, 0.03794127f, 0.01765597f, -0.00509007f, 0.00476385f, 0.03320589f, 
    0.01936721f, -0.04126043f, -0.03758508f, -0.03291024f, -0.04489052f, 0.00812341f, 0.00563789f, -0.05743543f, 
    -0.01251348f, 0.01926514f, 0.01327234f, 0.00167383f, 0.04133384f, -0.05432097f, 0.02073921f, -0.04676698f, 
    0.00664235f, 0.02617485f, 0.00813638f, -0.00740590f, 0.02025580f, -0.01548681f, 0.00819483f, -0.01729210f, 
    -0.05399836f, 0.03565102f, 0.03107625f, -0.05245270f, 0.04269443f, 0.00261606f, -0.05513882f, -0.01076207f, 
    -0.00003383f, 0.01234385f, 0.03521457f, -0.01596210f, -0.00113812f, -0.05717998f, -0.05045867f, 0.04401186f, 
    -0.04377521f, -0.04509854f, 0.02771186f, -0.05271022f, 0.00019623f, 0.01520895f, -0.00026352f, -0.04174992f, 
    -0.03223316f, 0.00283315f, 0.02707936f, -0.04160848f, -0.03380191f, -0.01476629f, -0.04865128f, -0.01373639f, 
    0.04271299f, -0.03115066f, -0.01364226f, 0.02704956f, -0.03358946f, -0.03913757f, -0.02912056f, -0.01865665f, 
    0.00924204f, 0.03054387f, -0.04759095f, 0.00504761f, -0.00891248f, -0.00532585f, 0.00761435f, -0.05403378f, 
    0.04093349f, 0.01199745f, 0.01482501f, 0.01437016f, -0.05321443f, -0.03424175f, -0.04432326f, 0.02992405f, 
    0.01310569f, -0.01031123f, 0.01307202f, -0.02985806f, -0.04266477f, -0.00589159f, 0.03826320f, 0.02203944f, 
    -0.05362868f, -0.05730502f, -0.05894572f, 0.04018691f, 0.00128188f, -0.03948817f, -0.03408831f, 0.02018161f, 
    -0.05242617f, 0.03747995f, 0.00512655f, 0.01183245f, -0.01613775f, -0.01939528f, 0.02081632f, 0.02896437f, 
    -0.03316178f, 0.02750869f, -0.02593868f, 0.02276042f, -0.03427682f, -0.03725530f, 0.03001157f, -0.02562944f, 
    0.03530895f, 0.02221241f, -0.02676786f, -0.05543041f, -0.05034361f, -0.03135870f, -0.01693097f, -0.00236086f, 
    -0.03071083f, -0.03230171f, -0.01177775f, -0.01875713f, -0.03920577f, -0.01622485f, -0.01468805f, -0.03578376f, 
    0.00411041f, 0.01295313f, -0.03053591f, -0.01345779f, 0.03517221f, -0.02419325f, -0.00227820f, 0.03342495f, 
    0.02136159f, -0.02182522f, -0.03273744f, -0.03662189f, -0.03864224f, -0.02581211f, -0.04001432f, -0.05557307f, 
    0.03189082f, -0.01518750f, -0.00301158f, -0.05403242f, -0.03646177f, -0.01142699f, -0.01988708f, 0.01739693f, 
    0.01055459f, 0.00509348f, 0.02109563f, 0.03266840f, 0.00044636f, -0.02176699f, -0.01614247f, -0.02979715f, 
    0.01983884f, -0.01149281f, 0.02396188f, 0.02881936f, -0.03423054f, 0.01275060f, 0.02669144f, 0.04225775f, 
    0.00071715f, -0.04231105f, -0.02255453f, 0.01922943f, 0.02331808f, -0.02228865f, 0.00959529f, -0.00870878f, 
    -0.00915649f, 0.01214511f, -0.00423309f, -0.04421460f, -0.01244378f, 0.03615442f, 0.01648843f, -0.04622933f, 
    0.04382615f, -0.05339178f, 0.02842282f, 0.04088445f, 0.03211671f, 0.02720315f, 0.02025010f, 0.04102177f, 
    -0.02644519f, -0.01571285f, -0.02612229f, -0.01953849f, 0.02756152f, 0.03750243f, -0.00854183f, -0.05427907f, 
    -0.03073959f, -0.00998499f, 0.02882888f, 0.00689619f, 0.00997453f, 0.01936826f, 0.02607355f, -0.05165254f, 
    -0.00600832f, 0.03594131f, -0.03495788f, 0.03815028f, 0.02783220f, 0.02414631f, -0.00293105f, 0.04766083f, 
    0.01150041f, -0.02082815f, -0.04118462f, 0.01630333f, -0.01371523f, -0.05607359f, -0.02809210f, -0.04549522f, 
    -0.01845340f, -0.05461637f, 0.00021351f, -0.02777240f, -0.05076171f, 0.00749512f, -0.03120419f, 0.00870525f, 
    -0.02867057f, -0.03856981f, 0.01409699f, 0.02398091f, -0.03100998f, -0.01572289f, 0.03536550f, -0.03308836f, 
    0.04112292f, -0.04479256f, -0.02344253f, -0.01196696f, -0.03142243f, -0.00382690f, 0.02147051f, -0.01041035f, 
    -0.03288315f, -0.05581951f, 0.03446753f, 0.01257100f, 0.00116476f, -0.02922535f, 0.03139786f, 0.01221121f, 
    0.02170801f, -0.00166190f, 0.04154951f, 0.02314109f, -0.00103013f, -0.04333120f, -0.01637574f, -0.00558308f, 
    -0.01648737f, 0.03322146f, 0.02982982f, -0.03741641f, -0.00822146f, -0.03019862f, 0.03450653f, -0.01081398f, 
    0.00809370f, -0.01198797f, 0.02761742f, -0.01193163f, 0.01506249f, 0.02443920f, -0.01784696f, 0.01775816f, 
    -0.04935727f, -0.03657375f, -0.05603660f, -0.00140929f, -0.02953347f, 0.02430302f, -0.04249533f, -0.03004282f, 
    -0.05595443f, -0.04948159f, 0.03546038f, -0.01788219f, 0.02140336f, 0.01092330f, -0.00832507f, -0.04826768f, 
    -0.00031459f, 0.01699961f, -0.03351288f, -0.01756147f, -0.02602835f, -0.01223798f, -0.03908579f, 0.01245423f, 
    0.02883943f, 0.01598871f, -0.04133433f, 0.01188175f, 0.00298552f, -0.04559641f, 0.01526820f, 0.02679547f, 
    0.03180563f, 0.00747397f, -0.03877094f, -0.01273474f, 0.02178875f, 0.02495453f, 0.00476899f, -0.05135848f, 
    -0.03586031f, -0.01961918f, 0.03293082f, -0.03675979f, 0.02191222f, 0.00209889f, 0.02985176f, -0.03486425f, 
    -0.00183086f, 0.03179357f, -0.02036442f, 0.01294754f, -0.02074458f, -0.01360105f, -0.01672320f, 0.05199621f, 
    -0.05341891f, 0.01320649f, 0.03558529f, -0.00180704f, 0.02049270f, -0.02695271f, 0.04032766f, -0.01300169f, 
    -0.02785449f, -0.00060596f, -0.00456249f, -0.04858625f, -0.02302933f, -0.00215086f, -0.00900897f, -0.01805130f, 
    -0.01949236f, -0.04004597f, 0.00578191f, 0.03670639f, -0.01342165f, -0.00632364f, -0.05489600f, 0.01201415f, 
    -0.02763425f, -0.02160909f, -0.02594652f, 0.03619319f, 0.01032933f, 0.02538563f, -0.03798337f, -0.00975939f, 
    -0.02714328f, 0.00197880f, -0.00561728f, -0.05667466f, -0.04915864f, -0.00619351f, -0.00260065f, -0.05037439f, 
    -0.03442540f, 0.00012026f, -0.05575462f, -0.00520831f, 0.02983597f, 0.02456564f, -0.00265722f, -0.02148363f, 
    0.03775956f, -0.03746485f, -0.02934732f, 0.00149565f, -0.05129028f, -0.00688686f, -0.04135749f, -0.05274265f, 
    -0.06259578f, 0.03068670f, -0.05703143f, 0.00804947f, 0.01897462f, -0.03328530f, 0.03285325f, -0.05276690f, 
    -0.03846700f, -0.05896266f, -0.01182414f, 0.01411703f, 0.00505709f, -0.04899270f, 0.01238536f, -0.00645791f, 
    -0.01240464f, 0.02963637f, -0.01659344f, 0.00593884f, -0.05719673f, -0.04334991f, 0.03679670f, 0.01427639f, 
    -0.02612766f, -0.02815411f, 0.02321652f, -0.01572873f, 0.01552391f, -0.01456374f, 0.03702726f, 0.01323689f, 
    0.00442540f, 0.03897435f, -0.03099810f, 0.02477401f, 0.01057698f, 0.00232766f, -0.00022607f, 0.01052594f, 
    -0.00123128f, -0.05589352f, 0.00729435f, 0.00820935f, -0.01688318f, 0.00273361f, 0.00173253f, -0.00786727f, 
    0.02018077f, 0.02415736f, -0.01670898f, -0.00629860f, -0.04452865f, -0.05779429f, -0.01597180f, 0.01593165f, 
    -0.01678252f, -0.05397227f, -0.03658285f, -0.05443016f, -0.01260278f, 0.02907472f, 0.01910522f, -0.04337179f, 
    0.03230833f, -0.05636350f, -0.01913242f, 0.02994542f, 0.02845459f, 0.01788194f, 0.01038049f, 0.02986321f, 
    0.01877508f, 0.02648855f, 0.00890749f, -0.00134427f, 0.01457204f, -0.02671698f, -0.05722629f, 0.03803383f, 
    0.01790928f, 0.00422560f, 0.03281456f, -0.00938884f, -0.00895794f, 0.01640457f, -0.03751044f, -0.00855344f, 
    -0.00617235f, 0.03016186f, -0.04149928f, -0.05455276f, -0.05452868f, 0.00240770f, 0.01968428f, -0.05706384f, 
    -0.01450339f, 0.05293224f, -0.03513323f, 0.02594340f, 0.00268033f, -0.00564079f, -0.00156228f, 0.01396098f, 
    -0.00283048f, -0.01791140f, 0.01140032f, -0.02966690f, -0.04998868f, -0.02532480f, -0.01843072f, -0.05348474f, 
    -0.02624153f, -0.03825619f, -0.05299259f, 0.01320899f, -0.01882350f, 0.04153065f, -0.02777510f, -0.04414637f, 
    -0.00301081f, -0.01049720f, -0.01771848f, 0.03721231f, -0.01455291f, 0.00398080f, 0.03309271f, 0.01979181f, 
    -0.02846686f, 0.03921869f, 0.02318444f, 0.02320237f, 0.02847263f, 0.03168744f, 0.02952502f, 0.00172109f, 
    -0.05151727f, -0.06077200f, -0.02403487f, -0.01619503f, 0.02459940f, -0.00052058f, -0.06005964f, -0.02000474f, 
    -0.05096647f, -0.03514326f, 0.00139063f, 0.03186116f, -0.02555905f, 0.03262249f, -0.04216418f, -0.04177608f, 
    -0.02943408f, -0.01732532f, -0.03113227f, 0.01316628f, -0.01876206f, 0.02742382f, -0.00551520f, -0.01580472f, 
    -0.00210245f, -0.04233938f, -0.00285989f, -0.00828361f, 0.00583682f, -0.02733228f, -0.04184744f, 0.02005932f, 
    -0.01502088f, -0.03809890f, 0.01267692f, -0.04673254f, 0.02622916f, 0.01920348f, -0.00742515f, -0.00807340f, 
    0.03663648f, -0.05262354f, 0.02822499f, -0.01140351f, -0.01757608f, -0.00667077f, -0.02442009f, -0.01135091f, 
    0.04239977f, 0.03448414f, -0.06005436f, 0.02078748f, -0.01815599f, 0.01560056f, -0.05224931f, -0.01903712f, 
    -0.03464849f, -0.05407817f, 0.02875075f, 0.04122682f, -0.05668679f, 0.03959072f, 0.01726404f, -0.01967520f, 
    0.00497229f, -0.01287991f, 0.03781054f, -0.02014115f, 0.00827517f, 0.02720674f, 0.01075380f, -0.02662254f, 
    -0.04449271f, -0.04599158f, 0.03209559f, -0.04429426f, -0.00229884f, -0.01348495f, -0.02353111f, -0.01253722f, 
    -0.05326873f, -0.05851475f, 0.04153015f, -0.01212491f, 0.00576948f, 0.01717731f, 0.03486896f, -0.04511245f, 
    -0.04707540f, -0.00822748f, -0.04837154f, 0.00331494f, -0.02180827f, -0.05408525f, -0.00904350f, -0.04375834f, 
    -0.03796092f, 0.03418296f, -0.01351468f, -0.00049179f, 0.04161495f, -0.02403687f, 0.00067013f, -0.02539779f, 
    -0.05441583f, -0.04622875f, -0.00472367f, 0.02166230f, -0.02838510f, 0.01369513f, -0.01003189f, 0.00631008f, 
    0.02419948f, -0.02489611f, 0.03128927f, 0.03729600f, -0.05562329f, -0.04624594f, -0.03605295f, 0.00635978f, 
    0.01918758f, -0.01036127f, 0.02202782f, -0.04893507f, -0.00842852f, -0.02125076f, -0.03097771f, -0.00042677f, 
    0.01205536f, -0.01090989f, -0.03714354f, 0.02268491f, -0.04648931f, -0.05078078f, -0.03921504f, 0.03964283f, 
    0.00825426f, -0.01892794f, -0.04791000f, 0.00757604f, -0.02804312f, -0.01627542f, 0.01158390f, -0.01527657f, 
    -0.02082445f, -0.01250780f, 0.01030858f, -0.03452693f, -0.00485098f, 0.04019471f, 0.00852489f, -0.03323605f, 
    -0.03632844f, -0.03096274f, -0.03253057f, 0.03538226f, 0.00734226f, 0.03504995f, 0.01540210f, 0.01546296f, 
    -0.03752318f, -0.04192924f, -0.00281834f, -0.00417608f, 0.01599455f, -0.01857662f, -0.03905282f, -0.01883798f, 
    0.00489695f, 0.01500880f, -0.03057782f, -0.02604909f, -0.03541833f, -0.02870707f, -0.01311154f, -0.02284751f, 
    0.00883690f, -0.00470137f, -0.02842261f, -0.04962227f, -0.03359689f, -0.00854634f, -0.00807027f, 0.02959717f, 
    0.00390720f, -0.02910035f, -0.00251205f, 0.03690794f, 0.00858835f, 0.00292500f, 0.03588193f, -0.04442788f, 
    -0.01190960f, 0.01054228f, -0.01144706f, -0.05840753f, 0.03899014f, 0.01263090f, -0.01654618f, 0.02795141f, 
    0.04194473f, -0.00168235f, 0.01179531f, 0.01798561f, -0.00744384f, -0.02102926f, -0.04882016f, 0.03849743f, 
    0.03057562f, 0.01111246f, -0.04895366f, 0.03768055f, 0.01361650f, -0.00712250f, -0.05799835f, -0.04777410f, 
    0.01367733f, 0.00444229f, 0.04026007f, -0.04914228f, -0.04352013f, -0.01669030f, 0.03980345f, -0.04486668f, 
    0.04213510f, -0.01534573f, -0.05525631f, -0.01360805f, 0.00229749f, -0.04253451f, -0.04614574f, 0.03390301f, 
    0.03702903f, 0.04072735f, -0.03706751f, 0.00310713f, 0.03268229f, -0.02544197f, 0.04340392f, -0.05538859f, 
    -0.01984701f, 0.01472003f, 0.00279618f, -0.04031310f, -0.02288904f, -0.04714967f, 0.02161572f, -0.05428528f, 
    -0.02902588f, -0.03257411f, -0.05540327f, 0.01867788f, -0.01178902f, 0.04187828f, -0.03948587f, -0.02103102f, 
    0.01359392f, 0.00894223f, 0.01656635f, -0.01538042f, -0.04855236f, 0.03228587f, 0.01222220f, 0.00546424f, 
    -0.05141231f, 0.02204245f, 0.00780055f, -0.02983103f, -0.02445872f, 0.01384886f, -0.01998015f, -0.03520157f, 
    0.03254090f, -0.05154806f, 0.02497400f, -0.02217332f, -0.03119458f, -0.03592061f, 0.03664663f, 0.00533939f, 
    0.01957562f, 0.04405127f, -0.02580307f, 0.00382629f, -0.02200452f, -0.05435576f, 0.03916106f, -0.04899634f, 
    0.04406686f, 0.02757241f, 0.00207147f, -0.04530645f, -0.01474691f, -0.01775868f, 0.01795487f, 0.01946490f, 
    -0.00203666f, -0.05323765f, -0.00597458f, -0.03533119f, -0.05382369f, -0.03195895f, 0.03191968f, 0.00320480f, 
    -0.01408459f, -0.05642537f, -0.01686054f, 0.03204410f, 0.03623687f, 0.01832177f, 0.04553752f, -0.03086093f, 
    -0.03029654f, -0.02117413f, -0.01227191f, -0.03263299f, 0.02690190f, 0.00798856f, -0.02122606f, 0.04335155f, 
    0.03986194f, 0.03075275f, 0.03490063f, -0.00829253f, -0.02975342f, -0.02848021f, 0.03882368f, -0.01974708f, 
    -0.00297092f, -0.03544592f, 0.02048464f, -0.04555533f, 0.00694628f, -0.00786130f, 0.00571813f, -0.04719868f, 
    -0.04749027f, -0.02493596f, -0.05229343f, 0.02858371f, 0.02175505f, 0.00915254f, -0.03550235f, 0.00614591f, 
    0.03380368f, -0.01087098f, 0.00063193f, 0.04245549f, 0.00322695f, 0.03847097f, -0.02169303f, 0.02256975f, 
    -0.02006011f, 0.00138521f, -0.04735573f, 0.01540514f, 0.04179767f, -0.05169772f, 0.03787551f, -0.02276905f, 
    0.01323559f, 0.03523015f, -0.00646731f, -0.03827646f, 0.00634247f, 0.00148411f, -0.01815164f, 0.01134635f, 
    -0.04935725f, 0.02221765f, -0.04426786f, -0.00834678f, -0.00066187f, -0.00621495f, -0.04703103f, -0.03229733f, 
    0.02675541f, -0.01549673f, 0.00400997f, -0.00517701f, 0.03417997f, 0.03562780f, -0.02115062f, -0.04080217f, 
    0.03446372f, -0.01724552f, 0.01574162f, 0.03471620f, 0.03939779f, 0.00279844f, 0.02941201f, -0.04565277f, 
    -0.01917440f, -0.01749738f, -0.03403610f, 0.00772833f, 0.00802149f, 0.01343729f, -0.02843454f, 0.00937203f, 
    -0.04314573f, -0.04311693f, -0.01721906f, -0.05349928f, 0.00674032f, 0.00842605f, -0.00799973f, -0.00647893f, 
    0.00688085f, 0.01396845f, 0.00305181f, 0.01374051f, 0.01689386f, 0.02481641f, 0.02564839f, -0.03772609f, 
    0.04159638f, 0.02679344f, 0.00549879f, 0.01090144f, 0.04186988f, -0.01620614f, 0.01693518f, -0.02479005f, 
    0.12846406f, -0.50721425f, -0.38714921f, -0.23667242f, -0.04605143f, -0.02804081f, -0.02560419f, 0.13508609f, 
    0.08255325f, 0.13378055f, 0.02310651f, 0.02869155f, 0.23657371f, 0.02625614f, 0.04848928f, 0.13653226f, 
    -0.07350158f, 0.03291696f, -0.13602647f, -0.05224800f, -0.05088235f, -0.04817583f, -0.04573872f, -0.12289317f, 
    -0.12123059f, 0.03244699f, 0.20017403f, 0.02015246f, 0.17676345f, 0.12855040f, 0.03391045f, -0.03131080f, 
    -0.09539427f, -0.09232249f, 0.02012418f, 0.00013476f, -0.04355292f, 0.17893177f, 0.03558775f, -0.29525909f, 
    0.08500730f, -0.00834140f, 0.00041110f, 0.27994159f, 0.00388645f, 0.00882797f, 0.05048379f, 0.01282969f, 
    -0.14928670f, -0.13916099f, -0.21534908f, 0.15521431f, 0.02570586f, -0.03269307f, 0.04627342f, -0.02196699f, 
    0.13166606f, -0.04014614f, -0.05267626f, 0.02570791f, 0.30519071f, 0.20482357f, 0.13002658f, 0.28150937f, 
    -0.01860011f, 0.01646201f, 0.03729597f, -0.03738870f, 0.10943879f, -0.05613653f, 0.07528511f, -0.08304657f, 
    -0.29233381f, -0.25165030f, -0.18003468f, -0.60897702f, 0.05657959f, -0.03322100f, 0.04527108f, 0.00715521f, 
    -0.08334347f, 0.04251147f, 0.03653842f, 0.11729280f, -0.04316285f, 0.29919675f, 0.16507834f, -0.04415696f, 
    0.18377395f, -0.03241378f, -0.01974952f, 0.08272122f, -0.00925197f, 0.00792995f, 0.13169460f, 0.04742376f, 
    -0.05016339f, 0.12235180f, 0.14084865f, 0.04676111f, 0.18138786f, 0.04010428f, 0.41178259f, 0.03823525f, 
    0.01947815f, -0.12255684f, 0.04567378f, -0.05462900f, 0.07586970f, 0.01754641f, 0.01481910f, -0.09690724f, 
    0.18578506f, 0.12995084f, -0.07313737f, 0.02211010f, -0.25082895f, 0.02561206f, -0.27194676f, -0.03161199f, 
    0.05743669f, 0.22053343f, -0.02714107f, -0.05199504f, -0.15752044f, 0.08511779f, -0.16692829f, -0.07656300f, 
    0.22848153f, 0.12645084f, -0.04021728f, 0.19736117f, 0.57776690f, 0.12538475f, -0.06063078f, -0.09487911f, 
    0.08021433f, 0.06382968f, 0.10852429f, 0.10732435f, -0.02566336f, -0.06614346f, 0.01589262f, -0.08072671f, 
    -0.00977912f, -0.35844874f, -0.53614175f, -0.46053097f, -0.03392380f, -0.19764461f, -0.13985279f, 0.16623917f, 
    0.13996856f, 0.06171519f, 0.02021751f, -0.12387241f, 0.16948532f, 0.04552160f, 0.09138377f, 0.11901301f, 
    -0.04917309f, -0.06301324f, -0.08376945f, -0.04310251f, 0.07186712f, 0.07598945f, 0.04224539f, 0.03783029f, 
    0.17753699f, 0.07868508f, 0.09807619f, 0.24640945f, -0.06078862f, 0.04794766f, -0.04434571f, 0.11772938f, 
    0.08080506f, 0.10779261f, -0.09292119f, -0.02907159f, 0.11650600f, -0.06747452f, 0.03924258f, 0.20605139f, 
    -0.02579692f, 0.09064718f, -0.06602956f, -0.10661084f, 0.06829780f, -0.11299250f, -0.00518009f, -0.19754329f, 
    0.25179249f, -0.16177668f, 0.01721684f, -0.04915743f, -0.09944905f, -0.12870337f, -0.03020088f, -0.02526311f, 
    0.30862960f, 0.15752529f, 0.11058180f, -0.02343554f, 0.07688593f, 0.09807344f, 0.14889640f, 0.15762274f, 
    -0.07425691f, 0.04235332f, -0.09332149f, -0.10697310f, 0.11428253f, 0.03369671f, -0.03178369f, 0.02733982f, 
    0.28982407f, 0.66220897f, 0.30306646f, 0.22511005f, 0.02657959f, 0.09678428f, 0.06453874f, 0.25762236f, 
    -0.02099565f, 0.08203064f, 0.02659107f, 0.00456018f, -0.07345495f, 0.07587031f, -0.38262746f, -0.43020013f, 
    -0.17321023f, -0.18994695f, -0.10134305f, -0.04856257f, 0.04990797f, -0.01824114f, -0.02958035f, -0.08317832f, 
    0.10532159f, 0.11256753f, 0.04964142f, 0.02142528f, -0.04595252f, -0.01594069f, -0.03120411f, -0.13269962f, 
    -0.00486255f, -0.08804093f, -0.13369834f, -0.14730436f, -0.11810729f, 0.12876682f, 0.02689024f, 0.03319713f, 
    -0.14636578f, 0.13804589f, 0.13409506f, 0.06523417f, -0.11443603f, -0.11681370f, -0.11385488f, 0.01464932f, 
    0.15531257f, 0.12338119f, 0.03197789f, 0.10319657f, -0.12151329f, 0.04619959f, -0.10529441f, -0.03171668f, 
    -0.09238578f, -0.11849552f, -0.16847461f, -0.01735032f, 0.08938425f, 0.07265396f, 0.15616614f, -0.56091261f, 
    -0.08062874f, 0.02614789f, -0.10130343f, 0.08083738f, -0.09792467f, 0.01450328f, -0.10245331f, -0.07671131f, 
    0.07767600f, 0.11096748f, -0.17197919f, -0.12670109f, -0.09147448f, 0.09250018f, -0.10878988f, 0.07612671f, 
    0.23503806f, 0.00370933f, -0.04617509f, 0.04024835f, -0.10122658f, 0.01922512f, 0.12289674f, 0.02588712f, 
    0.05848402f, -0.04052093f, 0.09037284f, 0.14091733f, -0.02692653f, 0.00161122f, 0.03180368f, 0.09126996f, 
    0.19778100f, 0.08881582f, 0.08187613f, 0.26255012f, 0.08180059f, -0.02776004f, -0.02610146f, 0.00429984f, 
    -0.06272403f, -0.09859035f, -0.00152110f, 0.05408882f, 0.24358602f, 0.11667720f, 0.24079899f, -0.24766313f, 
    -0.01807922f, -0.04495755f, 0.08071576f, -0.03117686f, -0.05431843f, 0.02422435f, 0.05334390f, 0.00012056f, 
    0.03314577f, 0.13145795f, 0.16682017f, 0.09016076f, -0.02402284f, -0.01072083f, -0.04300830f, -0.06927129f, 
    0.01575462f, -0.00446306f, -0.13317518f, -0.09026115f, 0.32044527f, 0.06858832f, -0.14181042f, -0.08463283f, 
    -0.05207984f, -0.18622909f, -0.13597973f, -0.03646445f, 0.02892851f, -0.09777881f, 0.06954921f, 0.05933932f, 
    -0.19894572f, 0.08160943f, -0.00842121f, 0.08684988f, 0.13697140f, 0.03702312f, 0.12131722f, 0.25265256f, 
    0.09363523f, -0.00081035f, 0.04301921f, 0.00821508f, -0.25304827f, 0.00066029f, -0.22373123f, -0.18074772f, 
    0.04768426f, -0.20194021f, 0.06576870f, 0.14928807f, -0.01227583f, -0.04553315f, -0.05782500f, -0.03775818f, 
    -0.03986478f, -0.02487767f, -0.01617117f, 0.03310019f, 0.02337620f, -0.03193765f, 0.04280730f, -0.02548556f, 
    0.03628683f, -0.01274317f, -0.02110500f, 0.01702998f, 0.02197487f, -0.01370936f, 0.01432603f, 0.01409033f, 
    -0.02064066f, 0.03690967f, -0.02269237f, 0.02925188f, 0.03457814f, 0.00733894f, 0.03044130f, -0.01807745f, 
    0.00175447f, -0.02988970f, -0.05965927f, 0.03031457f, -0.01186653f, -0.02246771f, 0.01079741f, -0.05601269f, 
    -0.05100023f, 0.02239250f, 0.03014451f, -0.05443370f, 0.04194761f, -0.00807916f, -0.01828627f, 0.04003076f, 
    -0.03782209f, 0.03098739f, -0.04722269f, -0.05655627f, -0.02310412f, 0.01246747f, 0.01316350f, 0.01439220f, 
    0.04279288f, 0.00918040f, 0.02275424f, -0.04448222f, -0.05175217f, -0.05416917f, -0.05235250f, 0.02194175f, 
    0.00244261f, -0.05203309f, -0.03805441f, 0.01733827f, 0.02615681f, -0.04920542f, 0.04066770f, 0.03310574f, 
    -0.05240603f, -0.02121511f, -0.02322580f, 0.02071385f, -0.01600543f, -0.03733774f, -0.00101824f, -0.05508961f, 
    0.03052034f, 0.01012138f, -0.03837565f, -0.04191084f, -0.00967812f, 0.00347291f, 0.04410799f, 0.03521175f, 
    0.04000798f, -0.02051191f, 0.03101190f, -0.00819681f, -0.05950964f, -0.00414468f, -0.05729855f, -0.03446960f, 
    0.01284082f, -0.01432783f, -0.05502406f, 0.00468850f, -0.05705618f, 0.03055586f, -0.00246477f, 0.00368121f, 
    0.03381778f, -0.03684392f, 0.00406535f, -0.01156882f, 0.03195085f, 0.02164145f, -0.02047378f, -0.03685469f, 
    -0.00758562f, -0.03177700f, 0.02779553f, 0.02859470f, -0.01969899f, -0.00405582f, -0.02281206f, 0.02031213f, 
    -0.02736411f, -0.04584540f, 0.00599916f, -0.02282439f, 0.03157030f, 0.04018502f, -0.01512775f, -0.03671855f, 
    -0.04314493f, -0.05166208f, 0.03831780f, -0.02884891f, -0.04340582f, 0.00760479f, -0.03627198f, -0.01479694f, 
    -0.02520309f, -0.05751055f, -0.02231582f, -0.05932661f, 0.00166878f, -0.03479007f, 0.00624254f, 0.01061055f, 
    0.03924410f, 0.04334050f, 0.02110434f, 0.04103679f, 0.01102130f, -0.01373236f, -0.00470211f, 0.01692372f, 
    -0.02445080f, -0.01191628f, 0.04128225f, -0.02462418f, 0.02077596f, 0.00880427f, -0.01300315f, -0.04325693f, 
    0.03223440f, -0.03420082f, -0.04191937f, -0.04601380f, 0.01959852f, 0.03908406f, -0.02771235f, 0.02788269f, 
    -0.04254868f, 0.00377700f, 0.00691151f, -0.03636264f, -0.04443790f, 0.03815356f, -0.01873280f, 0.04095376f, 
    -0.03790583f, -0.01513958f, 0.00615458f, -0.04293294f, -0.01892593f, 0.02048860f, -0.02938940f, -0.02339602f, 
    0.02970579f, -0.05194071f, 0.00108193f, -0.02818375f, 0.02824316f, -0.04126244f, -0.02598466f, -0.03440844f, 
    0.00983926f, -0.04802963f, -0.03534294f, -0.03986552f, -0.05027228f, 0.01724576f, 0.03510768f, 0.02519266f, 
    -0.03765761f, -0.03856746f, -0.00093188f, 0.00387435f, 0.00934612f, 0.02473691f, 0.02496490f, -0.04831569f, 
    0.03736320f, -0.03599770f, -0.02850325f, 0.00152174f, 0.02680254f, -0.04369653f, 0.03487279f, -0.01960654f, 
    -0.01460884f, -0.01756889f, 0.04061947f, 0.02651235f, -0.02546241f, -0.03122701f, -0.01911949f, -0.02853952f, 
    0.03553597f, -0.04239709f, -0.04807265f, 0.05166092f, 0.02389000f, -0.00758237f, -0.01495991f, -0.05707726f, 
    0.02920932f, -0.03161127f, -0.04862776f, 0.01431222f, -0.01148795f, -0.05404244f, 0.00841733f, -0.05447902f, 
    0.04206174f, -0.05870195f, 0.02093421f, -0.00469377f, 0.00037912f, 0.02265661f, -0.04086341f, 0.04238009f, 
    -0.04677699f, 0.03743635f, -0.01371365f, 0.00822046f, -0.04472757f, -0.05812290f, 0.00520951f, 0.03943736f, 
    -0.02811795f, 0.03035332f, -0.05451148f, -0.03148284f, -0.05278381f, -0.03888736f, 0.01520955f, -0.01328946f, 
    0.00681258f, -0.05008699f, -0.01880946f, 0.02711262f, -0.01069045f, 0.02844779f, 0.02982777f, -0.02686704f, 
    0.04090114f, 0.01910184f, -0.02086696f, -0.04405294f, 0.03129382f, -0.02109261f, -0.05926374f, -0.04214298f, 
    0.01215909f, 0.04374250f, 0.01237482f, 0.03156631f, 0.01429469f, 0.02891921f, -0.04592466f, 0.03409944f, 
    -0.01008140f, 0.04053874f, -0.05043278f, -0.04850771f, -0.04208927f, -0.03588474f, 0.00411606f, -0.05579162f, 
    0.02870058f, -0.02033621f, 0.00402969f, -0.00663516f, 0.04257297f, 0.00769505f, -0.03022954f, 0.03359503f, 
    -0.01274158f, -0.02252151f, -0.04521355f, -0.01391308f, -0.04210774f, -0.01769285f, -0.06075047f, 0.04232455f, 
    0.02003028f, -0.02642991f, -0.05360685f, -0.05632749f, 0.00043926f, 0.02492357f, 0.00226173f, 0.00617800f, 
    0.02091422f, -0.03330616f, 0.04249330f, -0.02048187f, -0.03591272f, -0.03469756f, -0.04530381f, -0.01979351f, 
    0.02037092f, 0.02494613f, -0.05408525f, 0.00585969f, -0.03035878f, 0.04263446f, -0.05917713f, 0.02726399f, 
    -0.04001949f, -0.05360569f, -0.03469636f, -0.05139222f, 0.00356036f, 0.01442124f, 0.00323007f, -0.02351047f, 
    -0.04281108f, -0.01408774f, 0.01164256f, 0.04169635f, 0.04040469f, -0.00690106f, 0.02927025f, -0.02056838f, 
    -0.03140258f, -0.01994759f, 0.00604584f, -0.04025066f, 0.00562582f, 0.02702165f, 0.02557583f, -0.00968780f, 
    0.03735210f, 0.00345653f, -0.03761850f, -0.04501489f, -0.02236708f, 0.04094427f, 0.01874769f, -0.03365939f, 
    -0.02554107f, -0.00626854f, -0.01082151f, 0.03929634f, 0.05004282f, 0.03155768f, -0.01840007f, -0.00181483f, 
    0.04089247f, 0.02606498f, 0.01801161f, -0.05434830f, -0.02322789f, -0.03586038f, -0.02833615f, 0.02893515f, 
    -0.02536815f, -0.03922548f, -0.03415676f, 0.00989243f, -0.00467075f, 0.03340437f, 0.02937663f, -0.00078922f, 
    0.10467204f, 0.48918548f, 0.01819218f, -0.19205263f, -0.09641650f, -0.05231340f, -0.04588689f, -0.15637939f, 
    0.04362463f, -0.08407735f, -0.02763025f, -0.01451656f, -0.07653109f, -0.02571313f, -0.17872109f, -0.01709262f, 
    -0.09469294f, 0.09693605f, 0.05182389f, 0.08555396f, 0.02576523f, 0.15470754f, -0.09558807f, -0.05860463f, 
    -0.39808056f, -0.17373367f, 0.20327801f, 0.12326764f, 0.05367358f, 0.32517168f, 0.09380444f, 0.18136370f, 
    0.00180070f, -0.09073796f, 0.12020899f, -0.05089128f, -0.30404764f, -0.07152336f, -0.05251345f, -0.10682160f, 
    -0.11677478f, -0.04084360f, 0.00511334f, 0.15934396f, 0.01523781f, 0.09379967f, -0.01097658f, -0.08308021f, 
    -0.12598990f, 0.23693436f, 0.10435121f, 0.19802770f, 0.03559398f, 0.07318339f, 0.06623065f, 0.15110996f, 
    0.06285670f, -0.02451777f, -0.12267192f, -0.07109412f, 0.07229917f, -0.01616398f, 0.11354920f, -0.06639814f, 
    0.01358581f, -0.02240943f, 0.02863575f, -0.00700416f, 0.16413796f, -0.01892431f, 0.06683295f, -0.02490512f, 
    -0.21810463f, -0.17562202f, 0.52318269f, -0.10340678f, -0.12470356f, -0.06261416f, -0.03856363f, 0.10525492f, 
    -0.00891129f, 0.00922554f, 0.14978167f, -0.05866371f, -0.43517989f, 0.37314057f, -0.48057848f, 0.07343120f, 
    0.04169853f, 0.12353600f, 0.16393851f, -0.27129701f, 0.03278788f, 0.00890574f, -0.05814333f, 0.05872885f, 
    -0.23640150f, 0.12981546f, -0.12668176f, 0.14082947f, -0.17085196f, -0.10398975f, 0.13914938f, -0.03325058f, 
    0.04646289f, -0.10252237f, -0.01915780f, 0.04147278f, -0.03169018f, 0.00910943f, 0.00414085f, -0.05417797f, 
    0.02907725f, 0.03783247f, -0.02759924f, -0.00038408f, -0.02406777f, 0.05785127f, 0.04172252f, -0.10210441f, 
    0.23335436f, -0.09055398f, 0.37557307f, -0.06308431f, 0.01750404f, 0.04569191f, 0.01675398f, 0.08897816f, 
    0.10020991f, 0.13084476f, -0.01561241f, 0.02381882f, -0.21316114f, -0.33770275f, 0.02165271f, -0.07309710f, 
    0.11318558f, 0.09806225f, 0.10151193f, 0.02663915f, 0.02338118f, -0.01423238f, -0.01149458f, -0.09147473f, 
    -0.03311697f, 0.05594577f, 0.16006711f, 0.06912001f, -0.02021645f, 0.09050775f, 0.02838847f, 0.24444167f, 
    0.08719995f, 0.07075547f, -0.01622192f, -0.02645820f, -0.03667192f, 0.00240545f, -0.01913850f, -0.03205615f, 
    -0.01144866f, 0.12605891f, -0.07115906f, 0.04645059f, 0.03626118f, 0.02107798f, 0.13616687f, 0.09189653f, 
    0.09263026f, -0.14364207f, 0.23584546f, -0.13036957f, 0.00985781f, -0.08383416f, 0.15668604f, 0.11925624f, 
    0.14193347f, 0.02645270f, 0.03195629f, -0.03139054f, 0.14882980f, 0.35307702f, -0.06159332f, 0.35908499f, 
    -0.15958944f, 0.01820508f, 0.06242889f, 0.05786037f, 0.12528042f, 0.04960771f, -0.01790973f, -0.01298133f, 
    0.15809701f, 0.30948526f, 0.11673357f, 0.06585641f, -0.06215141f, -0.14650553f, -0.05656460f, -0.04593366f, 
    0.18497501f, 0.10421532f, 0.06648924f, -0.00177986f, -0.04336644f, -0.09586790f, 0.07686227f, -0.07374095f, 
    -0.08314235f, -0.00829691f, 0.04756347f, -0.01909447f, -0.00138592f, -0.05251469f, -0.05227619f, 0.08577147f, 
    -0.35404056f, 0.22407281f, -0.03905688f, 0.02118788f, -0.11517254f, 0.01214892f, 0.02321198f, -0.09765882f, 
    -0.03477935f, 0.01750297f, -0.02018211f, -0.08485267f, 0.34875962f, 0.37654889f, 0.08667985f, 0.25789189f, 
    -0.07352795f, -0.15570536f, 0.09423457f, 0.21322586f, 0.11998336f, 0.08449379f, 0.02961770f, 0.02655007f, 
    0.12741141f, 0.02370355f, 0.11805353f, -0.04741502f, -0.00040241f, 0.02050930f, -0.05606271f, -0.10901638f, 
    -0.18393329f, 0.02779116f, 0.16019902f, 0.10112989f, -0.02298893f, 0.06106957f, 0.01240967f, -0.15519576f, 
    -0.03123528f, -0.05894822f, 0.09412231f, 0.09680186f, 0.07986952f, 0.06132419f, 0.08506506f, 0.05153575f, 
    0.07616361f, 0.04374572f, 0.08173259f, -0.02425929f, 0.05369702f, 0.10105526f, 0.00089668f, -0.07368220f, 
    -0.07728148f, -0.09706164f, 0.04287114f, 0.13103344f, -0.23916766f, 0.38782108f, -0.09793387f, -0.26832989f, 
    -0.18815513f, 0.02292255f, 0.01454323f, 0.03308495f, -0.06765523f, -0.02127391f, -0.06646416f, -0.05823120f, 
    -0.03285310f, -0.16566643f, 0.05855512f, 0.16579060f, 0.05154826f, 0.02046616f, -0.13568151f, 0.26233619f, 
    0.07014994f, 0.04961718f, -0.15026411f, -0.16987784f, -0.10122938f, -0.21089323f, -0.22113945f, 0.02794623f, 
    0.07470647f, 0.16839106f, 0.16701889f, -0.05564804f, -0.02417438f, 0.04354234f, 0.01910697f, 0.04614601f, 
    -0.48237222f, 0.07395495f, -0.49395731f, 0.01215534f, -0.00702222f, 0.14754528f, 0.10500915f, 0.06926666f, 
    0.02439172f, -0.00972208f, 0.05837464f, -0.03692854f, 0.43933347f, -0.24661945f, 0.09922832f, -0.12492487f, 
    -0.09476690f, 0.13599291f, 0.00914979f, 0.01303749f, -0.01562409f, -0.03623754f, -0.00552719f, 0.01222046f, 
    0.03824417f, -0.09650937f, 0.06810830f, 0.01993671f, -0.02015133f, 0.09443238f, 0.03271842f, -0.04238257f, 
    0.06638447f, 0.02178220f, -0.08822088f, -0.06762208f, 0.21747439f, 0.37214705f, 0.24486685f, 0.12929156f, 
    -0.19003935f, -0.10551400f, -0.11831389f, 0.02153469f, 0.09063159f, -0.07404841f, -0.02820981f, -0.00167773f, 
    -0.29637578f, -0.45167178f, -0.19349217f, 0.19697216f, 0.07420162f, 0.08599064f, -0.02985352f, 0.18944871f, 
    0.03318761f, -0.06791144f, -0.02557298f, -0.00030164f, 0.02296254f, 0.10081620f, 0.43384728f, -0.13229860f, 
    -0.02932815f, -0.14627716f, 0.26440707f, 0.03100797f, -0.00023718f, -0.12642951f, -0.28221157f, -0.12005267f, 
    0.03524449f, -0.02576959f, 0.03145877f, -0.03624207f, -0.00127983f, -0.03100145f, -0.02569359f, -0.05618865f, 
    -0.04127360f, 0.05453483f, -0.05896033f, -0.01949674f, 0.01082964f, -0.04383980f, 0.00565157f, -0.02105524f, 
    0.02726512f, 0.01569558f, -0.01965597f, -0.00429735f, 0.03649597f, 0.03821635f, -0.05060904f, -0.03705103f, 
    -0.04078768f, -0.03349579f, 0.04406083f, -0.02934460f, -0.04595557f, -0.03590981f, 0.00720909f, -0.01211641f, 
    0.00490822f, 0.03706976f, 0.01581764f, 0.01277709f, -0.01254010f, -0.03970354f, 0.01327480f, -0.04991058f, 
    -0.00296357f, 0.02115898f, -0.02884797f, 0.02229377f, -0.02637841f, -0.02275365f, 0.04177967f, 0.00737372f, 
    0.01861301f, -0.04094629f, -0.01531259f, 0.03543865f, -0.05519760f, -0.01953666f, -0.04905837f, -0.04853061f, 
    0.03094561f, -0.00905563f, -0.02797360f, 0.01315051f, 0.02637327f, -0.04429667f, -0.03752011f, -0.02216969f, 
    0.02262368f, -0.02447346f, 0.00774235f, 0.00265689f, -0.05763759f, -0.02528890f, -0.04387738f, -0.02835252f, 
    0.04403267f, -0.05517021f, -0.00767454f, -0.00920078f, -0.05212735f, 0.04178096f, 0.02235915f, 0.03533195f, 
    -0.01387656f, -0.02138147f, 0.00978663f, 0.03167773f, 0.02333970f, -0.01715371f, -0.04917276f, 0.01911892f, 
    -0.05395606f, -0.00994087f, -0.03747983f, 0.02017409f, 0.00487006f, -0.03226032f, 0.01563274f, -0.00473496f, 
    -0.03760715f, -0.05329799f, 0.02462910f, -0.05176481f, -0.00166715f, 0.03110663f, -0.06135046f, -0.04650939f, 
    -0.03667009f, -0.01980387f, 0.02934563f, -0.00469741f, 0.02007540f, 0.03192891f, -0.03535959f, -0.00502628f, 
    0.02258370f, 0.01963070f, -0.05338065f, 0.01448852f, 0.01098063f, 0.02806562f, -0.01269008f, 0.01309403f, 
    0.02476243f, -0.01787840f, 0.03280011f, 0.01202433f, 0.01971036f, -0.04472883f, -0.02747468f, -0.01542876f, 
    -0.03294354f, 0.01615159f, 0.03082803f, -0.00500695f, 0.01311040f, -0.01988872f, 0.02701071f, 0.01099467f, 
    -0.03850444f, -0.03516230f, -0.00188767f, 0.00476531f, -0.05265643f, 0.01302106f, 0.03006507f, 0.02064956f, 
    -0.02024763f, 0.02530133f, 0.01566977f, 0.00231178f, -0.03649412f, -0.00478965f, -0.04932423f, 0.01572567f, 
    -0.02903856f, 0.03783586f, 0.03817587f, -0.03404928f, -0.04822864f, 0.00276973f, 0.03325831f, 0.01235109f, 
    -0.00422503f, 0.00214290f, -0.02303380f, 0.03394486f, 0.02713684f, -0.02246001f, -0.02647512f, -0.03201925f, 
    -0.00726644f, 0.02227955f, 0.02248821f, -0.03935742f, -0.05819928f, -0.05525738f, -0.00016712f, -0.01948363f, 
    0.04083750f, 0.01055734f, -0.05247521f, -0.02990482f, -0.02444776f, 0.02423311f, 0.02817274f, -0.01970234f, 
    -0.04518915f, 0.02811899f, -0.01079090f, -0.05783661f, 0.03568100f, 0.02417700f, -0.00077370f, -0.00309685f, 
    -0.01444227f, -0.03941911f, -0.03330915f, -0.04915480f, -0.04648240f, -0.02097142f, -0.01652134f, -0.05232855f, 
    0.04623757f, -0.02570217f, -0.03109642f, 0.02253356f, 0.04009867f, -0.01536053f, -0.01497808f, -0.02843240f, 
    0.02144337f, -0.03905502f, 0.03228188f, 0.03190866f, 0.02870617f, 0.00086588f, 0.01658111f, -0.03163801f, 
    0.00868073f, -0.01271637f, 0.02131669f, 0.01599614f, 0.00267215f, -0.04556433f, -0.01826733f, -0.05245910f, 
    -0.05010743f, -0.03460007f, -0.02088478f, 0.00716795f, 0.04111094f, -0.03677226f, -0.04348965f, -0.00054688f, 
    0.03708834f, 0.03555351f, 0.01810717f, 0.02727110f, -0.04029314f, -0.04603198f, -0.03653700f, -0.05210042f, 
    -0.00894910f, 0.02939449f, 0.02265770f, 0.00968501f, -0.01602152f, -0.02211583f, -0.05005392f, -0.01362847f, 
    0.05127787f, 0.03687571f, 0.03894991f, 0.00130911f, 0.02777718f, -0.04911106f, -0.01039152f, -0.05915971f, 
    -0.04071850f, 0.01433159f, -0.03012048f, -0.00160847f, -0.01268365f, -0.02342199f, -0.02653631f, -0.05453901f, 
    0.04111446f, 0.04229536f, 0.02226428f, -0.04539644f, 0.03308845f, -0.02610354f, 0.00593845f, 0.03004134f, 
    0.00859707f, -0.00405506f, -0.00127650f, -0.05630077f, -0.00177815f, -0.02629749f, -0.02846335f, -0.00124000f, 
    -0.03481616f, -0.01199493f, -0.03408948f, -0.05223515f, 0.04675998f, 0.00698068f, 0.02479540f, 0.02557870f, 
    0.02963600f, -0.00514653f, 0.01356571f, 0.04568207f, -0.01280642f, 0.00847886f, -0.04159217f, -0.01628691f, 
    -0.00426405f, 0.00582231f, 0.00195106f, -0.00617727f, -0.00391514f, 0.03154214f, -0.00339499f, 0.03621358f, 
    0.01165188f, 0.03512852f, 0.04484757f, -0.00543453f, -0.05131740f, 0.00222272f, 0.03945021f, -0.01631085f, 
    0.01128259f, 0.02219413f, 0.00016867f, -0.00490622f, 0.00669117f, -0.05088286f, 0.01264833f, -0.02067517f, 
    0.01570326f, -0.00438896f, 0.00123193f, -0.00520460f, -0.02161109f, -0.00885171f, 0.00706367f, 0.01534495f, 
    -0.04455122f, -0.03124137f, -0.02150507f, -0.00382346f, 0.02254834f, -0.04972669f, 0.03088549f, -0.03633983f, 
    0.02425338f, 0.04194780f, -0.01582343f, -0.04188319f, 0.00540483f, -0.05366570f, -0.00819175f, -0.06115336f, 
    -0.03712356f, 0.00927734f, -0.04231951f, 0.02741440f, -0.00094673f, -0.03958082f, -0.00986835f, -0.02312565f, 
    -0.04606153f, 0.02858880f, 0.02044381f, 0.02356691f, 0.00217583f, -0.00039219f, -0.01798816f, -0.01138516f, 
    -0.00320299f, 0.03587150f, 0.01429480f, 0.00309500f, -0.05062143f, 0.02540772f, -0.01883069f, -0.05214491f, 
    -0.02693330f, 0.02130613f, 0.02280232f, -0.01436817f, 0.03601408f, 0.04004018f, 0.04607405f, 0.02520028f, 
    0.04023531f, -0.05132206f, 0.03709352f, -0.04357184f, -0.03639673f, -0.02763978f, -0.01224770f, 0.00015201f, 
    0.15201026f, -0.01552499f, 0.24200948f, 0.08870063f, -0.29617012f, -0.01593635f, -0.12428299f, 0.11713673f, 
    0.22325838f, -0.04393833f, 0.05154233f, 0.05883386f, 0.01375778f, -0.07216685f, -0.00980556f, 0.18066193f, 
    0.26879835f, -0.06838184f, 0.02305402f, -0.02705016f, -0.05519991f, -0.03289373f, -0.03583936f, 0.08542392f, 
    -0.15054986f, -0.21659194f, 0.07092547f, 0.05118138f, 0.15571399f, 0.21961109f, 0.13256219f, 0.25351110f, 
    0.02416063f, 0.03032011f, -0.02564145f, 0.07981525f, -0.24826734f, 0.14366445f, 0.26360980f, 0.08640970f, 
    -0.03530769f, 0.06372146f, 0.01178635f, -0.05680912f, 0.05660403f, -0.01991745f, 0.00191758f, 0.08456226f, 
    -0.38297945f, 0.05935935f, 0.36018854f, -0.13053584f, -0.07385833f, -0.10489197f, -0.05751083f, -0.05630986f, 
    0.14737760f, 0.05959450f, 0.04176397f, 0.02459410f, 0.27530381f, -0.27162054f, -0.25339943f, 0.27866682f, 
    0.04144660f, 0.03273892f, -0.03443313f, -0.10610915f, 0.05719530f, -0.00467403f, 0.01815314f, 0.13693787f, 
    -0.27628520f, 0.06712414f, 0.30307746f, -0.00058722f, -0.15378924f, 0.11074968f, 0.03470047f, -0.03775322f, 
    0.03015522f, 0.12986359f, -0.18904603f, -0.05616438f, 0.51968616f, -0.21843083f, -0.61968869f, 0.36102536f, 
    0.19621481f, 0.21755283f, 0.09887446f, 0.22508860f, 0.02911200f, 0.17137353f, 0.01621869f, 0.04136674f, 
    -0.40243927f, -0.07311299f, 0.27964655f, 0.03849186f, 0.03605140f, 0.07517803f, -0.07303909f, -0.01305936f, 
    0.05203703f, 0.00700796f, 0.02411236f, -0.14449270f, 0.17927304f, -0.07237461f, 0.07703923f, 0.08273235f, 
    0.08963609f, 0.08027808f, 0.25391129f, 0.16573142f, -0.14017500f, -0.07659590f, 0.00275448f, -0.02171888f, 
    0.16037682f, 0.17844865f, 0.00988634f, 0.07141317f, 0.11969843f, -0.00676505f, 0.12845518f, 0.03807996f, 
    0.02990313f, 0.13474162f, -0.07889254f, 0.26688650f, 0.44735327f, -0.17680541f, -0.19321071f, -0.32441670f, 
    0.21493161f, 0.18656777f, -0.07409465f, 0.26318666f, -0.08159887f, -0.05359896f, -0.05263392f, -0.10435808f, 
    -0.08392291f, 0.26151699f, 0.15929416f, -0.14121354f, -0.05920901f, -0.11796683f, 0.09064304f, 0.02337464f, 
    0.06504069f, 0.01554467f, 0.05828176f, -0.01231219f, 0.11158272f, -0.01040884f, -0.02814421f, 0.03216264f, 
    0.04326230f, -0.08618969f, -0.07588748f, -0.05479586f, 0.14622203f, 0.15416837f, 0.10773599f, -0.06878168f, 
    0.55318975f, 0.08878557f, -0.25093788f, -0.05292829f, 0.09531256f, -0.05121026f, 0.00091270f, -0.02877406f, 
    0.13673590f, -0.04628913f, 0.10186707f, -0.03369889f, -0.31981272f, -0.34199333f, 0.05888161f, 0.51744926f, 
    0.04722184f, 0.04066958f, 0.13351107f, -0.13166524f, 0.02950697f, 0.09274783f, -0.06565180f, 0.43293509f, 
    0.11568171f, 0.14506061f, 0.06069050f, -0.09267415f, -0.13059974f, -0.00943384f, -0.03549450f, 0.00782515f, 
    0.14310756f, -0.24108930f, 0.15345043f, 0.16201748f, 0.19586030f, 0.01933698f, -0.00535849f, 0.12059373f, 
    0.03236113f, -0.04410263f, 0.03713685f, 0.03857003f, 0.01014047f, 0.00093137f, 0.03344245f, -0.16549170f, 
    -0.07667152f, 0.25064570f, 0.05080555f, -0.04256380f, -0.02084007f, -0.12893048f, -0.04620354f, -0.25628364f, 
    -0.01472623f, -0.10586926f, -0.05601337f, 0.09791145f, -0.80551982f, 0.23391283f, -0.01607521f, -0.00729186f, 
    0.05323786f, -0.18009160f, -0.08946829f, -0.06636026f, 0.24419840f, -0.12921469f, 0.11098501f, -0.00831949f, 
    0.02276810f, -0.00437144f, 0.02347607f, 0.17755365f, -0.09178010f, -0.02731891f, -0.12073412f, -0.00756133f, 
    0.07177635f, -0.02880604f, -0.03978436f, -0.03988740f, 0.27868304f, 0.08884585f, -0.23331939f, -0.27801904f, 
    0.21994051f, 0.08840123f, 0.18427874f, 0.13149400f, 0.02497658f, -0.00545497f, -0.11996622f, -0.04176010f, 
    0.01419060f, -0.00027544f, 0.08721355f, 0.14255624f, -0.03043408f, -0.06359407f, -0.12329734f, 0.00616014f, 
    0.09592088f, -0.08352056f, 0.06015720f, -0.04826978f, -0.12347854f, 0.22086403f, -0.34803954f, 0.11636326f, 
    0.02667462f, -0.06533914f, -0.04356040f, 0.02191035f, 0.26629031f, -0.14338557f, 0.09425757f, 0.00647333f, 
    -0.41097724f, 0.00803046f, 0.38680449f, 0.04999937f, -0.21103004f, -0.05683957f, -0.01076607f, 0.11762624f, 
    0.16255724f, 0.09382504f, 0.21985032f, 0.12037209f, 0.08345027f, -0.15770115f, -0.21851917f, 0.33114612f, 
    0.16567492f, -0.18716191f, 0.06003482f, 0.34318042f, 0.03954594f, 0.07042314f, 0.11320438f, 0.04182685f, 
    0.66794455f, -0.07616594f, -0.22777325f, 0.14686045f, 0.03528369f, -0.04972520f, 0.08662560f, -0.01434171f, 
    0.05196221f, -0.05017458f, -0.04369174f, 0.01738214f, -0.18636069f, -0.95901501f, -0.24084684f, 0.45402908f, 
    -0.09241331f, 0.08096187f, 0.04767087f, -0.02119464f, 0.16171598f, -0.06294598f, 0.05204375f, -0.10474345f, 
    -0.16398919f, -0.16528606f, 0.13422313f, 0.40638027f, -0.04328014f, -0.00798653f, -0.00914347f, 0.07178622f, 
    -0.04628244f, 0.07300843f, 0.01862126f, 0.13311645f, -0.65812534f, -0.06981423f, 0.18588656f, 0.29466072f, 
    -0.25676352f, -0.08550252f, -0.07055699f, 0.02059690f, 0.11067446f, -0.05292845f, -0.03391168f, 0.04210613f, 
    -0.20827696f, 0.26330915f, 0.17394321f, 0.02756292f, 0.08498139f, -0.15751214f, 0.07331590f, -0.28744292f, 
    0.12633540f, 0.03571459f, -0.01283709f, 0.12088995f, 0.12520863f, 0.28647894f, -0.13773943f, -0.76722479f, 
    0.12701559f, -0.04422797f, -0.12052809f, 0.03763704f, 0.17084557f, 0.05829948f, 0.24318914f, -0.07593525f, 
    -0.17184217f, -0.29025510f, -0.05388865f, 0.22171134f, -0.02896520f, -0.08403976f, -0.10783814f, 0.25707108f, 
    -0.01267043f, 0.02187829f, 0.13220172f, 0.09579155f, 0.03770502f, 0.05314652f, 0.07676359f, -0.15163766f, 
    -0.03646926f, -0.02803661f, 0.04604437f, 0.07130960f, 0.01113065f, 0.00071665f, 0.14388904f, 0.02822366f, 
    0.32404906f, -0.11218151f, -0.00180946f, 0.32620946f, 0.08271358f, -0.18969801f, -0.06653561f, -0.11539666f, 
    -0.01309073f, 0.15271451f, -0.00161567f, -0.04358734f, -0.22481586f, -0.26377720f, 0.00898837f, 0.10119502f, 
    0.03376398f, -0.01835012f, 0.01833178f, -0.15916087f, -0.00758728f, -0.02895076f, -0.11818250f, 0.02810683f, 
    -0.06561704f, -0.05096749f, -0.04474158f, 0.04472371f, 0.12763529f, -0.10458992f, 0.11587403f, -0.01354513f, 
    -0.00148954f, 0.03961629f, 0.07078655f, 0.00534251f, 0.03138775f, 0.42273620f, -0.05888964f, -0.45499194f, 
    -0.10863996f, -0.05393703f, -0.01902868f, -0.03621079f, -0.11038812f, 0.15694734f, -0.16087723f, 0.08870290f, 
    0.01472944f, 0.07859058f, 0.09915315f, 0.18787162f, -0.00405549f, 0.00982018f, 0.19515263f, 0.05802910f, 
    0.04192629f, 0.01893128f, -0.00242807f, -0.01091673f, 0.43645728f, -0.61073828f, 0.37397453f, -0.12658939f, 
    -0.05565009f, -0.10109569f, -0.07818937f, 0.07357706f, -0.00551325f, 0.01782537f, -0.02804228f, -0.14293304f, 
    -0.03418887f, -0.26012391f, -0.08533146f, 0.13630685f, 0.11010307f, -0.08521010f, 0.12321594f, 0.29800624f, 
    -0.03152250f, 0.19976723f, -0.01979060f, 0.01263474f, 0.03232499f, 0.07594921f, -0.19264810f, 0.03452908f, 
    0.08973702f, -0.04295352f, 0.00806667f, 0.01914061f, 0.28619033f, 0.07102291f, -0.05099506f, 0.36485922f, 
    -0.03129970f, -0.06577154f, 0.02965823f, -0.01660958f, 0.03643773f, -0.04113639f, -0.06391526f, 0.14513299f, 
    0.18016918f, 0.11676006f, 0.11707579f, 0.00206022f, -0.11247496f, -0.22845256f, 0.44350091f, 0.34370196f, 
    0.00091573f, -0.16878931f, 0.16547409f, -0.11073362f, 0.07059539f, -0.08382381f, 0.02030825f, 0.04199246f, 
    -0.20570117f, 0.01134710f, 0.12899257f, 0.22268900f, 0.13960430f, -0.02589564f, 0.07133475f, 0.00773807f, 
    0.08505043f, -0.01241249f, -0.05678430f, 0.04310636f, -0.12761800f, -0.03388418f, -0.15328442f, -0.14812897f, 
    -0.10261811f, -0.09709716f, 0.03003439f, -0.05690446f, 0.10458255f, 0.03803933f, 0.05642661f, 0.02709858f, 
    -0.24288228f, 0.20890267f, 0.18359751f, -0.04254929f, -0.16469605f, -0.03899223f, -0.19211243f, 0.02672510f, 
    0.02188794f, 0.11175267f, -0.19153120f, 0.05046538f, -0.11764424f, -0.20573173f, -0.32871917f, -0.10955966f, 
    0.24650306f, 0.17521721f, -0.05474856f, 0.08528677f, -0.03582441f, 0.15916891f, 0.16587564f, 0.18789424f, 
    -0.28041527f, -0.07819844f, 0.09309441f, 0.09661920f, -0.08456546f, -0.06278732f, -0.04869194f, -0.02709102f, 
    0.01697629f, -0.05260537f, -0.14456397f, 0.02467082f, 0.16777590f, 0.05940111f, -0.07330748f, 0.02333774f, 
    -0.09579194f, -0.02748866f, -0.15307385f, 0.00952947f, 0.10527859f, 0.15824153f, -0.05409069f, 0.16000172f, 
    -0.24969344f, -0.32984343f, -0.00428236f, 0.22336273f, 0.18138719f, 0.20263205f, 0.05955242f, 0.05520662f, 
    0.05772188f, -0.06020061f, 0.04281883f, -0.03945008f, 0.21747875f, -0.14022914f, 0.24728313f, 0.30305856f, 
    0.08987111f, 0.10848384f, 0.17866264f, 0.03494196f, 0.05776578f, 0.00738096f, -0.07223713f, -0.03915923f, 
    -0.20843379f, -0.16855706f, -0.02532281f, -0.27912191f, 0.07104621f, -0.00979872f, 0.01233646f, 0.05930569f, 
    -0.05544144f, 0.18512356f, 0.10740796f, 0.05332806f, -0.21113572f, 0.14077578f, 0.29258445f, -0.04052348f, 
    0.08299464f, 0.13096742f, -0.06341697f, 0.05843534f, 0.03418943f, -0.04619988f, 0.08980390f, 0.08233648f, 
    -0.03988601f, -0.07352876f, -0.30935636f, -0.09891558f, 0.06652194f, -0.01838264f, -0.02325317f, 0.12253622f, 
    0.09057185f, 0.06884626f, 0.04626170f, 0.10288920f, 0.50555068f, 0.02355271f, 0.16605191f, 0.34604079f, 
    0.07554834f, -0.01217050f, -0.03543296f, -0.09177613f, 0.02892686f, 0.20849371f, 0.00276832f, 0.18781973f, 
    -0.36169615f, -0.27875254f, 0.24879076f, 0.05788944f, -0.00989742f, -0.10413519f, -0.04151421f, -0.10671974f, 
    0.02151409f, 0.10406793f, -0.00392558f, 0.13287474f, 0.29714078f, -0.16345114f, 0.08015574f, -0.31309697f, 
    -0.13039532f, 0.08523005f, 0.00046454f, 0.01300601f, -0.04522811f, 0.01156742f, -0.27633613f, -0.06121795f, 
    0.00012733f, -0.00623636f, 0.41542110f, -0.22005406f, 0.03737449f, -0.09634098f, -0.17508350f, -0.01984050f, 
    -0.12275506f, 0.01323117f, -0.15479836f, -0.00422786f, 0.05681144f, 0.58828932f, 0.21315069f, 0.31933323f, 
    0.13674811f, -0.07989153f, -0.03058285f, -0.02419377f, 0.01777633f, 0.21307638f, 0.05675713f, 0.06498361f, 
    0.27363968f, 0.05882560f, -0.18837515f, -0.14453617f, 0.08092593f, -0.02832353f, -0.04359732f, 0.02116185f, 
    0.03610177f, 0.04482978f, 0.00361699f, 0.07564461f, 0.00450370f, -0.28531227f, -0.07921451f, -0.10359876f, 
    0.10458641f, 0.09109858f, 0.05080641f, -0.03276016f, -0.00840276f, 0.01312095f, 0.03629965f, 0.14075395f, 
    -0.27445528f, -0.24615113f, 0.07375738f, -0.01896864f, -0.01889390f, 0.08749604f, 0.00127362f, -0.01787210f, 
    0.04632655f, -0.02188173f, 0.15917413f, -0.07843241f, 0.15256460f, 0.59997487f, 0.14101012f, 0.24722520f, 
    -0.02575464f, -0.03263006f, 0.22209483f, 0.08354990f, 0.00229646f, 0.07372969f, 0.15014282f, 0.19169113f, 
    -0.32984167f, 0.22362325f, 0.03746060f, 0.08832654f, 0.10732279f, 0.18329991f, 0.08956030f, 0.05208275f, 
    0.21754098f, 0.29164630f, 0.10898574f, 0.09272826f, -0.02271300f, 0.29865670f, -0.08762485f, 0.00570694f, 
    -0.00442202f, -0.12613821f, 0.00644852f, -0.19637275f, 0.01869462f, 0.00715726f, 0.12787867f, 0.06719558f, 
    -0.26937872f, 0.20984936f, -0.37890577f, 0.05606410f, 0.11684443f, 0.13573137f, 0.09301008f, -0.21937573f, 
    0.09885757f, 0.04798465f, 0.17978187f, 0.08903412f, 0.07091298f, -0.15651651f, -0.01005162f, 0.12437250f, 
    0.02902706f, 0.06941520f, -0.07713015f, -0.10046110f, -0.18496868f, 0.01311697f, -0.00610523f, -0.04536002f, 
    0.21010207f, 0.14611462f, -0.12225898f, -0.04795384f, 0.04092895f, 0.00399752f, 0.07380771f, 0.15319686f, 
    -0.12180232f, -0.05171884f, -0.17696734f, -0.32076910f, 0.31722134f, 0.15317644f, 0.46615899f, 0.07808939f, 
    -0.14003736f, -0.09089366f, -0.03599090f, 0.10431201f, 0.13432945f, -0.06233530f, -0.08221444f, 0.19525385f, 
    0.32021549f, -0.17037936f, 0.07038032f, 0.29630765f, 0.21208683f, 0.18871066f, 0.12095968f, -0.00400938f, 
    0.05373286f, -0.05198832f, 0.05152582f, -0.05731952f, -0.11240623f, -0.26713091f, 0.18983984f, -0.18567187f, 
    -0.15842263f, -0.04980379f, 0.30500862f, 0.18645459f, -0.00497867f, 0.17450027f, -0.17403367f, -0.12021920f, 
    -0.18553424f, 0.28923807f, -0.19023231f, 0.05303572f, -0.02819088f, 0.23521511f, 0.24640216f, 0.26028538f, 
    -0.15152010f, 0.12896737f, 0.08979040f, 0.07476085f, -0.08678094f, -0.19021033f, -0.05161141f, 0.03477025f, 
    0.11224514f, 0.02160027f, 0.02094469f, -0.07400019f, 0.29802978f, 0.03504789f, 0.34900707f, 0.13812026f, 
    0.03860043f, -0.05676040f, 0.30922022f, 0.15933780f, 0.06041873f, -0.02974945f, 0.04945375f, 0.13180797f, 
    0.22435302f, -0.08945436f, 0.15637887f, 0.12722713f, -0.34886500f, 0.23916994f, -0.32125801f, 0.39455804f, 
    -0.11668152f, -0.01479166f, 0.06840131f, -0.16786563f, -0.01926891f, 0.01717893f, 0.01849522f, 0.18302773f, 
    0.10751745f, 0.06983662f, 0.19066875f, 0.22376454f, 0.36480638f, 0.19479030f, -0.01209191f, -0.26662460f, 
    0.10870938f, 0.22179437f, 0.15387875f, -0.04843789f, -0.02556895f, -0.01480187f, 0.03206833f, 0.02972766f, 
    -0.29944655f, -0.15620157f, -0.36246234f, -0.36355162f, 0.02143246f, 0.01626370f, 0.13979205f, 0.08052576f, 
    0.25568554f, 0.13302249f, 0.22203508f, 0.15320973f, -0.09590404f, -0.11829564f, -0.13050747f, 0.01402854f, 
    -0.20374385f, 0.01514087f, 0.05114390f, 0.05135696f, -0.29001606f, 0.40172240f, -0.06335606f, -0.12947893f, 
    -0.06884474f, -0.11449938f, 0.03641401f, 0.00272734f, -0.00985176f, 0.13996838f, 0.33874342f, 0.11129022f, 
    -0.32921764f, 0.03660568f, -0.20814931f, -0.09513664f, 0.04712985f, 0.01021868f, -0.06185603f, 0.01198213f, 
    -0.26735699f, 0.01326871f, -0.13165827f, -0.27217254f, 0.05845460f, 0.25832200f, 0.02270669f, 0.11321203f, 
    -0.06313410f, -0.18590450f, -0.01591921f, -0.03951616f, -0.15159412f, 0.11662170f, 0.07630217f, -0.04069745f, 
    -0.09481874f, -0.31046540f, -0.12983657f, -0.08862954f, 0.07080072f, 0.13054281f, 0.15329558f, -0.08806168f, 
    -0.00154902f, -0.03303773f, 0.04250342f, 0.11377151f, 0.03827635f, 0.20674700f, 0.10954189f, 0.04124972f, 
    0.31156969f, -0.07468738f, 0.06117567f, 0.21957904f, -0.19486776f, 0.27576566f, 0.13133647f, -0.04062883f, 
    -0.08553284f, -0.03853108f, 0.16471058f, 0.06583860f, -0.16539481f, -0.21008354f, -0.14166890f, -0.01582281f, 
    0.24171169f, 0.42849383f, 0.17786764f, 0.06955846f, 0.23394272f, -0.47363713f, 0.28430670f, -0.24096380f, 
    -0.07280187f, 0.09773096f, -0.04535078f, 0.07559035f, -0.04094853f, 0.02863850f, 0.12504731f, 0.29676929f, 
    -0.21370597f, -0.18357486f, 0.05462709f, -0.08773564f, -0.15374883f, -0.04965365f, -0.11195301f, -0.03327870f, 
    -0.01222069f, 0.15960202f, 0.25781584f, 0.24139392f, 0.80044776f, 0.33228248f, 0.20285602f, 0.20138144f, 
    -0.07425065f, 0.01569221f, -0.06658826f, -0.02164639f, 0.20212165f, 0.27533984f, -0.02527307f, 0.06401019f, 
    0.12540799f, 0.05814961f, -0.21257196f, -0.01131011f, 0.24998705f, 0.06197447f, 0.11345341f, 0.01363863f, 
    -0.00845802f, 0.03528659f, -0.07473432f, 0.09596588f, -0.21216020f, 0.00781556f, 0.03634619f, -0.14970993f, 
    -0.02690954f, -0.10415887f, -0.21422848f, 0.03752546f, -0.09128254f, 0.02118746f, -0.27134526f, -0.14276639f, 
    0.09656606f, 0.30828923f, 0.14779742f, -0.07241908f, 0.00499792f, -0.23978980f, -0.08055892f, -0.33449277f, 
    -0.11668304f, 0.06641541f, -0.03492742f, 0.07551462f, -0.23328297f, 0.73532194f, 0.05963983f, 0.13867013f, 
    0.01316978f, 0.08803638f, -0.09120452f, 0.21876025f, -0.11109322f, -0.04567107f, 0.04489918f, -0.24141018f, 
    -0.13835014f, 0.29528508f, -0.02490396f, 0.22022370f, -0.13636643f, -0.15078574f, -0.08847523f, -0.10728505f, 
    0.25536039f, -0.06872036f, 0.14210339f, 0.19190334f, -0.17123571f, -0.21420874f, -0.06562036f, -0.25253329f, 
    0.00319530f, 0.01988110f, -0.09499384f, -0.23087624f, 0.03530734f, -0.04988678f, 0.02266694f, 0.18362682f, 
    -0.10524232f, -0.38985643f, 0.02196950f, -0.05222774f, 0.00476983f, 0.01621539f, -0.06364108f, -0.16240934f, 
    -0.14848129f, 0.25832635f, 0.12414161f, 0.22530872f, 0.77338713f, -0.46881348f, 0.43542883f, 0.32097667f, 
    0.02156007f, 0.29542544f, 0.12555136f, 0.19344823f, 0.16731529f, 0.17030077f, -0.05531025f, 0.17413628f, 
    0.04111982f, -0.01632091f, 0.02568314f, -0.03746310f, 0.04378617f, 0.04122463f, -0.03886128f, -0.04982517f, 
    0.03272333f, 0.02760407f, -0.01208830f, -0.03041613f, -0.02701712f, 0.02197595f, 0.03072402f, 0.02629948f, 
    -0.02828396f, 0.02296074f, 0.04271626f, 0.03201904f, 0.03746404f, -0.02673037f, 0.00655869f, 0.04015717f, 
    0.01937901f, -0.02302656f, -0.05438536f, 0.04061000f, 0.02434162f, 0.03512339f, -0.02836931f, 0.04342791f, 
    0.00020904f, -0.00931154f, -0.02160778f, -0.01020664f, 0.02740385f, -0.03382142f, 0.02888769f, 0.01755771f, 
    -0.00742694f, -0.00346381f, 0.00760002f, 0.01578122f, -0.01217360f, -0.02412141f, 0.01443620f, -0.02576674f, 
    -0.03500771f, 0.02176754f, 0.02267549f, -0.04171185f, -0.04205107f, -0.02270607f, -0.02413652f, -0.03035524f, 
    0.00395453f, -0.00383082f, -0.02280355f, 0.05664907f, -0.01694308f, -0.03465366f, -0.01812302f, 0.02810113f, 
    0.00988788f, 0.02150407f, -0.04384478f, -0.03194455f, 0.00786805f, 0.00855303f, 0.00276263f, 0.00058432f, 
    0.03200018f, 0.02529835f, 0.00409993f, -0.00137374f, 0.03154431f, 0.01077376f, 0.01854970f, -0.03602163f, 
    0.04000618f, -0.02095136f, 0.01614306f, -0.03981730f, -0.03633340f, -0.01801853f, 0.00125314f, -0.04570603f, 
    -0.03918763f, 0.02295421f, -0.04426997f, -0.00109892f, 0.03835159f, -0.02284513f, -0.00698940f, -0.02762887f, 
    -0.04885794f, -0.00742524f, 0.00697501f, -0.05529712f, -0.02010477f, 0.03346445f, -0.03261125f, -0.02115223f, 
    -0.02141942f, -0.05013991f, -0.02644912f, -0.00703597f, 0.01196596f, -0.02864838f, -0.02542908f, 0.00671443f, 
    0.02084660f, -0.00641294f, 0.04289335f, 0.03466405f, 0.00002285f, 0.02114096f, -0.05642594f, -0.02150605f, 
    -0.04771177f, -0.02335370f, 0.01941375f, 0.00368042f, 0.02917175f, -0.01323592f, -0.02293744f, 0.03356576f, 
    -0.03352984f, -0.00543573f, -0.03955707f, 0.00383948f, -0.05087943f, -0.03124651f, 0.00822759f, -0.05136519f, 
    -0.05272480f, 0.00753037f, 0.02664465f, 0.01877980f, -0.04968090f, 0.02928006f, -0.02456628f, 0.02494785f, 
    -0.04380342f, 0.02573798f, 0.03830612f, 0.04795400f, -0.03693416f, -0.00450549f, 0.00738886f, 0.04083732f, 
    -0.02784980f, -0.02671533f, -0.01822354f, 0.01381520f, -0.01847180f, 0.03908508f, 0.02567884f, 0.03842624f, 
    0.01743705f, 0.03501811f, -0.02034074f, -0.04335594f, 0.00983520f, 0.02954609f, 0.00890116f, -0.02413702f, 
    0.01436459f, -0.00255370f, 0.03932323f, -0.00375493f, 0.00857266f, 0.01105088f, -0.00504251f, 0.02105854f, 
    -0.02324035f, -0.00432496f, -0.03833535f, 0.00912857f, 0.02565698f, 0.00797310f, 0.02018766f, 0.01238848f, 
    -0.03588946f, 0.02063129f, -0.03517207f, -0.05521266f, -0.01572550f, -0.02828932f, 0.00621556f, -0.02985192f, 
    -0.04285554f, -0.05040770f, -0.05358111f, 0.01753491f, 0.01827572f, 0.02457347f, -0.04196720f, -0.02450119f, 
    -0.02932038f, 0.00839503f, 0.05466066f, -0.02865508f, -0.03386070f, 0.01606202f, -0.02911757f, -0.03165328f, 
    0.01280876f, 0.00095832f, -0.03112358f, 0.00716066f, -0.03532764f, 0.03266238f, 0.04070799f, 0.00184561f, 
    0.01536418f, -0.03726984f, -0.04517657f, 0.03873377f, 0.00713605f, 0.02826649f, -0.00897826f, 0.00741002f, 
    -0.00349072f, -0.02673241f, 0.03305689f, -0.01480206f, 0.03672471f, -0.03203007f, 0.01317720f, -0.04011375f, 
    0.03099751f, 0.02586982f, 0.02676424f, 0.03393367f, 0.03240294f, -0.00755043f, 0.02446945f, 0.03047634f, 
    -0.00217782f, 0.01698652f, -0.00668017f, 0.02620595f, 0.01492512f, -0.03489320f, -0.05174919f, 0.02128892f, 
    -0.04419151f, 0.04203645f, -0.02678192f, -0.03901029f, -0.02042789f, -0.00343150f, -0.00608155f, -0.04317705f, 
    -0.02836620f, -0.02474875f, -0.05464404f, -0.00782501f, -0.02890694f, -0.02144733f, 0.03278591f, 0.04162641f, 
    -0.01869620f, -0.03915898f, 0.03635613f, -0.03512776f, 0.01854158f, 0.01000026f, -0.04001001f, -0.05143534f, 
    -0.01530806f, -0.03218132f, 0.02343334f, -0.04214004f, 0.03769051f, -0.05308265f, -0.02815026f, 0.03687380f, 
    0.00854746f, -0.01610018f, 0.03987533f, -0.05398126f, -0.04252681f, 0.03945802f, 0.01769279f, 0.02761768f, 
    0.03152160f, -0.03270392f, -0.03997508f, -0.00354415f, 0.02413386f, 0.01833810f, -0.00367984f, 0.04643220f, 
    -0.03870232f, -0.00097712f, 0.03507669f, 0.02407697f, -0.04229009f, -0.04663578f, 0.03709169f, 0.03212449f, 
    0.05569732f, -0.02871692f, -0.01267506f, -0.03213008f, -0.01410115f, -0.00807587f, -0.04317777f, -0.05758611f, 
    0.01244910f, -0.04346236f, 0.02566078f, 0.03330188f, 0.01507659f, -0.05757993f, 0.00181407f, 0.01732404f, 
    -0.05115038f, -0.02575722f, -0.03421511f, 0.01458572f, 0.02191919f, -0.03634314f, -0.04502836f, 0.01597959f, 
    0.03557134f, -0.03558264f, 0.00254721f, -0.00676295f, -0.01283463f, -0.01745501f, 0.01983747f, -0.01857664f, 
    0.02284854f, -0.05661731f, 0.00460447f, 0.00319889f, 0.01935895f, -0.05224457f, -0.00005286f, -0.02531343f, 
    -0.02758845f, -0.02139227f, -0.05090787f, -0.00332775f, 0.03243791f, -0.01143536f, -0.02691580f, -0.05421910f, 
    -0.02265175f, -0.01756554f, -0.02909088f, -0.04844756f, -0.04603555f, 0.03521417f, 0.00650662f, -0.04861394f, 
    -0.01168071f, -0.01569935f, 0.01964962f, -0.04514928f, -0.02599950f, 0.02418039f, 0.04708099f, -0.01681744f, 
    0.03423563f, 0.04375613f, -0.03199399f, -0.03887689f, -0.00232691f, 0.03366509f, 0.00526194f, 0.01627036f, 
    -0.00164616f, -0.01920465f, -0.01409559f, 0.00429571f, -0.01863293f, 0.01811656f, -0.03456676f, -0.03105096f, 
    -0.04859323f, -0.30572990f, -0.55171794f, -0.06424752f, 0.01691177f, 0.25408560f, 0.20397313f, -0.04090727f, 
    0.04431217f, -0.02402434f, -0.10322700f, 0.14627409f, -0.18641409f, 0.30316076f, 0.12672199f, -0.07513019f, 
    -0.04376419f, -0.04747040f, 0.00211650f, 0.15412237f, 0.02013513f, -0.05878528f, 0.06330923f, -0.13165644f, 
    0.03856314f, 0.43018010f, -0.08888888f, -0.07864098f, -0.03305357f, -0.09840038f, -0.18107894f, -0.12859298f, 
    -0.01169213f, -0.00470183f, 0.00325469f, -0.02208021f, 0.30416286f, 0.03594377f, 0.00436150f, 0.26890889f, 
    -0.19991656f, -0.07718843f, -0.07327615f, -0.04438084f, -0.02550933f, -0.04778996f, -0.06218407f, -0.00377050f, 
    0.09949107f, -0.08017837f, 0.11824787f, 0.17479694f, 0.07803585f, 0.07097699f, 0.12187717f, 0.10397858f, 
    -0.06347497f, 0.10175646f, 0.12537709f, 0.00889781f, 0.42317995f, 0.32344636f, -0.03486814f, -0.22830096f, 
    -0.10678091f, 0.01640276f, -0.01422839f, 0.06401134f, -0.05508860f, 0.09197016f, -0.11641846f, -0.09677440f, 
    0.36653456f, 0.24267706f, -0.22844794f, 0.25866950f, 0.11838280f, 0.13152897f, 0.07790093f, 0.06898111f, 
    0.02073874f, -0.02814699f, -0.10785811f, -0.10600862f, -0.26116499f, -0.15694845f, 0.61547571f, -0.24292898f, 
    0.08950450f, -0.09239227f, -0.22768599f, -0.01830160f, 0.01044936f, -0.00075653f, 0.06469282f, -0.03212089f, 
    0.09520957f, 0.13300738f, 0.05288620f, 0.18926740f, -0.08415972f, 0.28616270f, -0.03940222f, 0.24325599f, 
    -0.10198989f, 0.00540596f, 0.00019864f, 0.01188357f, -0.01586682f, 0.10040166f, -0.05703576f, 0.11754858f, 
    -0.01364149f, 0.03131070f, 0.08119246f, 0.11034355f, 0.01701887f, 0.04837351f, -0.10395750f, 0.01301688f, 
    -0.03535873f, 0.14089201f, 0.00018121f, -0.00755218f, -0.07443714f, 0.13176385f, -0.09632895f, 0.05827101f, 
    -0.06352437f, 0.04704693f, 0.06285547f, -0.33587205f, -0.08503466f, 0.64839578f, -0.02521902f, 0.16424792f, 
    -0.28498900f, -0.34865406f, 0.04811146f, -0.06340302f, -0.01129883f, 0.02165954f, -0.02274505f, 0.07533776f, 
    0.11160183f, 0.07722510f, 0.40186447f, 0.25782600f, 0.07157932f, 0.16698545f, 0.04568194f, -0.20451714f, 
    0.04401590f, 0.04527347f, -0.03740905f, -0.06440062f, 0.08559079f, -0.00985451f, 0.11741293f, -0.00712495f, 
    -0.04362711f, -0.08666561f, 0.09923098f, -0.00649938f, 0.01172430f, 0.19289652f, 0.12260268f, 0.12345424f, 
    0.13354233f, 0.06324476f, 0.14879832f, 0.01778728f, -0.10106967f, -0.02720056f, 0.01240427f, 0.04413541f, 
    -0.07399993f, 0.03927652f, -0.14840063f, 0.11079921f, 0.16349502f, 0.18794003f, -0.45946801f, -0.17376883f, 
    -0.17520833f, 0.10554769f, -0.01528243f, 0.03282442f, 0.03236574f, 0.14071146f, 0.05196544f, -0.13589798f, 
    -0.09481101f, -0.21298176f, -0.04329317f, 0.01984618f, -0.02875903f, 0.05483929f, 0.03914072f, -0.07899993f, 
    -0.00702072f, 0.16646938f, -0.25670946f, -0.02322471f, 0.04779243f, 0.05840988f, 0.14857535f, 0.06462829f, 
    -0.07310374f, 0.00258393f, -0.13548154f, -0.09520592f, 0.08572581f, 0.10076003f, -0.05155302f, 0.13229059f, 
    0.09175394f, -0.28732577f, 0.25547618f, 0.18343942f, 0.13139343f, 0.00336103f, -0.11501673f, 0.28209296f, 
    -0.03049094f, -0.01791510f, 0.03905889f, 0.07377580f, 0.23245335f, 0.01868455f, 0.36662778f, 0.21660249f, 
    0.08383888f, 0.08483719f, 0.18176794f, 0.28172565f, -0.15659241f, -0.05250631f, 0.04579645f, -0.09381863f, 
    -0.08995839f, 0.02687231f, -0.13552363f, 0.09472761f, 0.04704516f, 0.01072158f, 0.15842386f, 0.02720142f, 
    0.07104664f, 0.08558832f, -0.03232010f, -0.11646058f, -0.09239456f, -0.15795228f, 0.12500329f, 0.13290930f, 
    0.15655328f, 0.08548948f, -0.21694255f, 0.00933931f, -0.13210335f, -0.01321211f, 0.14574511f, 0.11307344f, 
    -0.04423932f, 0.01171080f, -0.07976305f, -0.05594649f, 0.08891616f, 0.05407520f, -0.03186758f, 0.04735424f, 
    -0.11336054f, 0.11318657f, 0.09743265f, 0.10416295f, 0.02060614f, 0.29990169f, 0.42407915f, 0.02196498f, 
    0.14465968f, -0.00152158f, -0.04665411f, 0.03744923f, -0.16517474f, 0.21284705f, -0.14874756f, 0.03981200f, 
    0.57189447f, -0.05979524f, 0.07827632f, 0.24104875f, 0.19105105f, -0.18142916f, -0.08328841f, -0.14022088f, 
    0.01124972f, -0.01792392f, -0.07949959f, 0.00224455f, 0.01925334f, 0.25884306f, 0.22027084f, -0.05251626f, 
    -0.03418408f, -0.05807143f, -0.10015666f, -0.02074792f, 0.13573037f, -0.20663685f, -0.03878384f, 0.10026088f, 
    -0.14932905f, 0.21989889f, 0.70631731f, -0.06158341f, -0.01033486f, -0.09016006f, -0.16991553f, 0.10454621f, 
    0.00866517f, -0.06812141f, -0.01168500f, 0.07328934f, -0.01729139f, 0.34898269f, -0.21358870f, -0.33663705f, 
    0.19370995f, -0.20679821f, 0.00700829f, -0.04528756f, 0.05105831f, 0.07337277f, 0.18421115f, -0.06735449f, 
    0.12422374f, 0.26595324f, -0.18115014f, -0.05310600f, -0.05947017f, 0.05862866f, -0.01715854f, 0.09741490f, 
    -0.00760483f, -0.02152361f, 0.06454584f, -0.12283327f, 0.15466160f, -0.13385975f, -0.21043500f, -0.20851643f, 
    -0.12569009f, 0.06344734f, 0.25941393f, 0.12445804f, 0.16300170f, 0.12833107f, -0.15065384f, 0.04704343f, 
    0.01994636f, 0.03398512f, 0.03176891f, -0.12151001f, -0.11492038f, 0.02887235f, -0.01177124f, 0.07953104f, 
    -0.03247861f, 0.00201312f, 0.00551919f, -0.03917179f, 0.22696896f, -0.27072835f, 0.02579591f, 0.45963582f, 
    -0.08044022f, -0.05166051f, -0.00697604f, 0.10890599f, -0.06668276f, 0.02407137f, 0.01158982f, 0.12989767f, 
    -0.01633447f, -0.00122242f, -0.02354963f, -0.03186634f, -0.02959642f, -0.00262071f, -0.00161211f, 0.03333268f, 
    -0.04185051f, 0.01382215f, -0.00346280f, -0.05511473f, -0.04177076f, -0.00349203f, 0.02022259f, 0.02994137f, 
    0.02691838f, 0.03861099f, -0.00127648f, -0.05142277f, -0.01141300f, 0.03309943f, 0.02540810f, -0.02266249f, 
    0.00373778f, -0.01412814f, 0.02431283f, -0.04485727f, 0.01430089f, -0.05287822f, -0.06324523f, -0.04548717f, 
    0.03039522f, 0.02500468f, -0.04559977f, 0.03073808f, -0.01365206f, -0.03539946f, 0.02848541f, 0.04065635f, 
    0.02942767f, -0.02845588f, 0.03347263f, 0.01325177f, -0.03539200f, 0.02857483f, -0.02102043f, -0.04000659f, 
    0.00086665f, -0.00435501f, -0.00649493f, -0.04992486f, -0.02489997f, -0.03414455f, 0.03325173f, 0.04072644f, 
    0.01439671f, 0.00262086f, -0.00950105f, -0.05086920f, 0.03782935f, 0.00177837f, -0.00344802f, 0.01359665f, 
    0.03868907f, -0.01584008f, 0.03678163f, -0.00334431f, -0.04334793f, 0.03822913f, 0.02802020f, -0.00130359f, 
    -0.05358038f, 0.01719180f, 0.01381376f, 0.02234670f, -0.04934676f, -0.04993022f, 0.02345511f, -0.05543387f, 
    0.00639571f, 0.00529761f, 0.01640171f, 0.01335925f, 0.04019359f, 0.02445639f, 0.00624645f, 0.03067754f, 
    0.02250480f, -0.03997779f, -0.03052595f, -0.02012747f, -0.03160678f, 0.03581009f, -0.05783221f, -0.05716452f, 
    0.03330968f, 0.03659383f, 0.02538707f, 0.00270129f, 0.03184499f, -0.04349367f, 0.01725529f, -0.05574918f, 
    -0.03506329f, -0.03916855f, 0.01675527f, -0.00990074f, -0.00615800f, 0.03248186f, 0.01742568f, -0.02431454f, 
    -0.01898669f, 0.01815456f, 0.00554313f, -0.03690861f, -0.02483759f, 0.03623332f, 0.00841830f, 0.04009971f, 
    -0.00242402f, 0.00463673f, -0.00613366f, 0.03750214f, 0.00515141f, 0.03295200f, 0.03608800f, -0.04371398f, 
    0.03556306f, 0.01686988f, -0.05696674f, -0.05662125f, -0.01780173f, -0.00421222f, 0.01195337f, 0.03034808f, 
    0.02220368f, 0.00313307f, -0.00093555f, 0.00140973f, 0.01392649f, -0.03501467f, -0.04840827f, -0.03908510f, 
    0.01683892f, 0.03884614f, -0.01572099f, -0.03878544f, 0.00249353f, -0.04316176f, -0.05658334f, -0.02325938f, 
    0.03595499f, 0.03675650f, -0.05097404f, -0.05626619f, 0.03104724f, -0.01852240f, 0.00689360f, 0.03375080f, 
    0.01401796f, -0.01826355f, 0.04073826f, -0.02594345f, 0.02004286f, -0.02237052f, -0.04417364f, 0.02579371f, 
    0.02645378f, -0.03571739f, -0.02553625f, 0.02146581f, -0.02074452f, 0.02400821f, 0.02453424f, 0.00875605f, 
    -0.04074391f, 0.01353016f, 0.02367117f, 0.01488180f, 0.01296869f, -0.00765813f, -0.03183099f, 0.02943370f, 
    -0.01190734f, -0.05085327f, -0.00309034f, 0.01549552f, -0.00748826f, -0.02881359f, -0.00041374f, 0.01864559f, 
    -0.05339254f, -0.01359607f, -0.01869125f, -0.06165282f, -0.03194773f, 0.02523123f, -0.02942320f, -0.00865013f, 
    0.04073766f, -0.02809718f, -0.00159295f, 0.03361470f, 0.02719241f, 0.01182816f, -0.02791598f, -0.00508596f, 
    -0.05084420f, -0.01149627f, -0.05588762f, -0.05219397f, -0.05495306f, -0.02516707f, 0.00491029f, 0.02958440f, 
    0.00777492f, 0.00958941f, -0.05202766f, 0.00754506f, -0.00438448f, -0.05548484f, -0.03512551f, -0.05800933f, 
    -0.00805542f, -0.03345909f, 0.01389833f, 0.00457286f, 0.00390980f, 0.00494609f, -0.05808330f, -0.04885900f, 
    0.04250241f, 0.00616113f, -0.00612891f, 0.02132483f, -0.02758405f, -0.05611661f, 0.02285697f, -0.01945025f, 
    -0.03713453f, -0.06072571f, -0.04553221f, -0.01615571f, 0.01354109f, -0.04031357f, 0.04008130f, -0.03154284f, 
    0.01799178f, -0.02199588f, -0.03692158f, -0.05895922f, -0.04789849f, -0.01234425f, -0.04913437f, -0.01230636f, 
    -0.00063592f, -0.05840806f, 0.03393486f, -0.05647107f, -0.01683474f, 0.01840005f, 0.00436373f, -0.00926670f, 
    0.03113659f, -0.01353894f, 0.03052639f, 0.01828809f, 0.03139791f, -0.04348908f, -0.02677435f, -0.03204118f, 
    -0.00021669f, -0.05792198f, 0.00168834f, 0.03569624f, 0.03962785f, 0.00266211f, 0.01802263f, -0.01032788f, 
    0.02702264f, 0.00698983f, 0.03647967f, -0.06011720f, 0.02772033f, 0.01488148f, -0.04305988f, -0.01811991f, 
    0.00113214f, 0.05707065f, 0.03238143f, -0.00719322f, -0.05375789f, 0.02527427f, 0.01217443f, -0.01446282f, 
    -0.03320820f, -0.01207118f, -0.00398242f, 0.00265012f, 0.00717760f, -0.04769519f, -0.04499908f, 0.03021192f, 
    -0.00562869f, -0.00358976f, 0.02239982f, -0.01841398f, -0.04890978f, -0.00856266f, 0.02233428f, -0.05358064f, 
    -0.02987004f, 0.01602805f, 0.02386996f, 0.01168127f, -0.02966062f, -0.05581364f, 0.02611071f, 0.03841497f, 
    -0.05350716f, 0.03514622f, 0.00271929f, -0.01432087f, 0.01629568f, 0.04054998f, -0.05697325f, 0.01879992f, 
    -0.04878693f, -0.01819580f, 0.01267686f, -0.00037519f, -0.05428339f, -0.04805861f, 0.01612358f, 0.02680812f, 
    -0.02692744f, 0.03242720f, -0.03664776f, -0.01058989f, -0.01700971f, 0.02444532f, -0.05846203f, 0.02583115f, 
    -0.05263742f, -0.02532043f, 0.03027091f, 0.01546416f, 0.00909407f, 0.01486807f, 0.03586085f, 0.03497743f, 
    0.01771270f, -0.05824325f, -0.02286431f, -0.05267000f, 0.03208365f, 0.00823800f, -0.02852114f, 0.02361408f, 
    0.03712283f, 0.03084360f, 0.00354901f, -0.00997515f, 0.00684376f, -0.03099252f, -0.05516690f, -0.05267930f, 
    -0.03351058f, 0.02208722f, -0.03159516f, -0.02076860f, -0.02001322f, 0.02084138f, -0.03975930f, 0.02788963f, 
    -0.02093583f, 0.02521173f, 0.03479557f, 0.03429358f, -0.05751522f, 0.03631356f, 0.03130974f, -0.02367405f, 
    0.15130006f, 0.03911548f, 0.18547966f, 0.19960272f, -0.17463300f, -0.19023517f, -0.13872172f, 0.12039222f, 
    0.13498461f, -0.01502827f, 0.17211837f, 0.01875768f, 0.04551347f, -0.00803314f, 0.03873386f, -0.03006560f, 
    -0.04503091f, -0.06489281f, 0.03134135f, 0.10263575f, -0.03025206f, 0.08050991f, -0.07307336f, -0.06077079f, 
    0.25435045f, -0.25501963f, 0.08542451f, 0.34366712f, 0.08754627f, -0.02896655f, -0.01312763f, 0.18465257f, 
    -0.23254627f, 0.05804605f, -0.13514312f, -0.20493717f, -0.26534268f, -0.41512042f, -0.09161869f, 0.10359600f, 
    0.13976800f, -0.06261432f, 0.11464046f, 0.06123565f, 0.06675960f, -0.10641503f, -0.11533448f, -0.02129318f, 
    -0.13083324f, -0.12394268f, -0.01341492f, -0.10366908f, 0.04440491f, -0.01088004f, -0.05546223f, -0.01303604f, 
    0.14956731f, 0.15512578f, 0.23752299f, 0.13909687f, -0.08639154f, 0.23476039f, 0.04107392f, -0.19015241f, 
    -0.01677399f, -0.07666419f, -0.06591249f, -0.06447044f, -0.20022105f, 0.15818729f, -0.01778823f, 0.11451542f, 
    -0.30384433f, -0.21510661f, 0.18942408f, 0.20098449f, -0.12178004f, -0.02547827f, 0.02683191f, 0.19342673f, 
    -0.14036384f, 0.06472018f, -0.02403523f, -0.12099072f, 0.34561303f, -0.31117731f, -0.12607729f, 0.20750190f, 
    0.06032653f, 0.05897687f, 0.03239333f, -0.03470892f, -0.04801726f, 0.01491342f, 0.01318164f, -0.05432345f, 
    0.00433192f, -0.30109346f, -0.07996311f, 0.12311795f, 0.01554353f, -0.13154405f, -0.15253653f, 0.14428301f, 
    -0.10224722f, -0.07218279f, -0.16848366f, -0.05121005f, 0.06620587f, 0.19734815f, -0.04542122f, 0.03754105f, 
    -0.02814217f, 0.03538013f, 0.03089150f, 0.07888246f, -0.03947337f, -0.00866607f, -0.13802087f, 0.04591718f, 
    -0.04396463f, 0.02461037f, -0.02435352f, 0.18919350f, 0.09185734f, -0.13260047f, 0.08173777f, 0.05102123f, 
    -0.05754362f, 0.15265770f, 0.03349796f, -0.18958014f, 0.10853300f, -0.21848258f, 0.58887303f, 0.15485725f, 
    0.17906702f, 0.04794275f, 0.00917996f, 0.07571335f, -0.11775348f, 0.03977134f, 0.01853112f, -0.09056517f, 
    -0.30193472f, -0.10414764f, -0.05368289f, 0.22149006f, 0.00480662f, -0.14703429f, 0.23936924f, 0.19802468f, 
    -0.01411302f, -0.03453548f, -0.13194974f, 0.17239140f, -0.23434328f, -0.01827899f, -0.33254322f, -0.41769516f, 
    0.19890660f, -0.04046317f, 0.10132222f, 0.12214895f, 0.06533337f, -0.10902075f, -0.12047325f, -0.16214953f, 
    -0.16304564f, 0.30137777f, 0.09440783f, -0.14080071f, -0.07057688f, -0.02435754f, 0.00507303f, -0.05981183f, 
    0.16687272f, 0.01177229f, -0.07567976f, 0.09301477f, -0.05000407f, -0.06920287f, -0.00933232f, -0.09074546f, 
    0.16447560f, 0.13207065f, 0.01178723f, -0.04737424f, -0.24035260f, 0.01190111f, 0.12407166f, 0.25505692f, 
    -0.27915397f, 0.16194768f, 0.12306658f, 0.15348883f, -0.08915252f, -0.08383930f, -0.08085359f, 0.15323916f, 
    0.16529372f, -0.00922661f, -0.00474123f, 0.20335299f, -0.02190298f, 0.02372509f, -0.07357002f, -0.18839760f, 
    -0.03108115f, -0.00306876f, 0.02478488f, -0.01792612f, 0.06732024f, 0.20049328f, 0.02204892f, 0.30911550f, 
    -0.31755927f, -0.21175511f, 0.07983492f, 0.26811782f, 0.09841816f, 0.14148095f, 0.09399362f, 0.10606991f, 
    0.14032011f, 0.11417447f, -0.00385252f, -0.16132030f, 0.35720170f, -0.09866472f, 0.25531182f, 0.38806069f, 
    -0.03900377f, 0.00694269f, 0.18181394f, -0.02273307f, 0.07048722f, -0.13921317f, -0.09858291f, 0.01489140f, 
    -0.18371543f, 0.13314788f, -0.13035052f, -0.10019248f, 0.05418959f, -0.01149870f, 0.09035781f, -0.06554445f, 
    -0.16249302f, -0.02235635f, 0.11509359f, 0.03747431f, -0.21831767f, 0.32824329f, 0.19763260f, 0.01162164f, 
    0.21335343f, 0.08678658f, 0.02557599f, 0.03248588f, -0.23047616f, -0.10334647f, 0.00297322f, -0.07635954f, 
    0.02314297f, 0.11361465f, -0.14063656f, -0.12325799f, 0.08366542f, -0.04429954f, 0.05831288f, -0.07365689f, 
    -0.01145173f, 0.01073923f, -0.02514781f, -0.04108893f, 0.06644623f, 0.07606217f, 0.04041322f, 0.43142104f, 
    0.01965880f, -0.03458700f, 0.02853821f, -0.08957358f, 0.15274283f, 0.17015904f, 0.17847107f, 0.15924323f, 
    -0.45288402f, -0.37669051f, -0.06326761f, 0.16583107f, -0.12678497f, -0.08452588f, -0.03794378f, -0.01180042f, 
    -0.00341713f, 0.21258672f, 0.28965980f, 0.22727904f, 0.52067506f, -0.00458333f, -0.07460209f, -0.01873522f, 
    -0.01432855f, 0.28779191f, 0.18936093f, -0.01878327f, 0.09018560f, -0.05282487f, -0.01949057f, 0.01194636f, 
    -0.01887181f, 0.07590672f, 0.17543274f, -0.07567015f, -0.07432996f, 0.05853106f, -0.14995745f, 0.11742897f, 
    -0.06250905f, -0.09762172f, -0.02287536f, -0.17946105f, 0.17115983f, 0.23847674f, 0.04461699f, 0.40542740f, 
    -0.08557511f, 0.09236497f, 0.03487509f, -0.04049798f, 0.22871466f, 0.32169154f, 0.08598056f, 0.40780604f, 
    0.22279626f, -0.05467433f, -0.07975188f, -0.15180908f, 0.08164856f, -0.12053518f, 0.07444090f, 0.06299660f, 
    -0.22781055f, 0.04789546f, 0.01959626f, -0.11690962f, 0.02884800f, 0.19918844f, -0.01087770f, -0.07324246f, 
    -0.02656268f, -0.01571972f, -0.00829444f, 0.22925562f, 0.01981859f, 0.18454936f, 0.05897236f, -0.09490383f, 
    -0.21408793f, -0.31163320f, 0.06363977f, 0.35081950f, -0.07062203f, 0.13051623f, -0.02061296f, -0.01820640f, 
    0.06846432f, -0.01969322f, 0.08437572f, -0.04276277f, -0.18914409f, 0.61799234f, 0.35908267f, 0.22929429f, 
    -0.01035108f, -0.07244990f, 0.20636339f, 0.14005843f, 0.10427976f, 0.14505397f, 0.24633409f, 0.09167627f, 
    -0.07935587f, 0.02979532f, 0.13698877f, -0.10189412f, -0.00703206f, 0.12385045f, -0.04881142f, -0.04693576f, 
    0.16279054f, 0.15586792f, 0.07273157f, -0.12046013f, 0.22838601f, 0.00833136f, 0.18530300f, 0.06371126f, 
    0.07832993f, 0.02103190f, -0.05114711f, -0.14772472f, -0.03269302f, 0.08781920f, 0.05378446f, 0.20121342f, 
    0.29879636f, -0.02044676f, 0.20635445f, 0.05363919f, 0.11779455f, 0.09110321f, -0.06720374f, -0.03478981f, 
    0.05873372f, 0.07599758f, -0.00585119f, 0.14954345f, 0.20841035f, 0.19898152f, -0.09771486f, -0.14039361f, 
    0.44281405f, 0.23350024f, 0.09331619f, 0.08725081f, -0.06388351f, -0.02532023f, -0.00165155f, -0.00390493f, 
    0.16573304f, 0.07162545f, -0.03238371f, -0.33302310f, -0.17150214f, -0.01652710f, -0.04452683f, 0.01755557f, 
    0.16372408f, -0.14780176f, -0.29445326f, -0.12906790f, -0.31273288f, -0.19798125f, 0.07779817f, 0.73068231f, 
    -0.04044600f, -0.08770557f, 0.00439035f, 0.04838209f, 0.03171496f, 0.04797547f, 0.16081774f, 0.17297348f, 
    0.18837978f, 0.03656388f, -0.23400451f, 0.08317985f, 0.08294188f, 0.13137405f, 0.02632250f, 0.11125529f, 
    -0.03644617f, 0.01847931f, 0.00270485f, 0.01408916f, -0.00650204f, 0.01935345f, 0.26937032f, 0.08249129f, 
    0.07584997f, 0.18119980f, -0.03241489f, 0.31061602f, -0.02777539f, 0.07376178f, 0.04238207f, -0.13010238f, 
    0.07320075f, 0.06748420f, 0.11651541f, -0.23512650f, 0.16665986f, 0.23956233f, 0.10426165f, -0.16985358f, 
    0.03592132f, 0.00203668f, 0.02949978f, -0.03886557f, 0.06418610f, -0.11717912f, 0.09432127f, -0.01616414f, 
    0.08808416f, 0.07133293f, -0.01277682f, -0.17651764f, 0.05805212f, 0.03831645f, 0.33356535f, 0.15585513f, 
    -0.11093505f, 0.21489437f, -0.06859694f, 0.13667843f, 0.15784122f, -0.15259659f, 0.17843769f, -0.00253374f, 
    0.13865262f, -0.20595348f, -0.05112508f, 0.32296658f, -0.25364384f, 0.10280732f, 0.08135638f, -0.25171915f, 
    0.18343320f, 0.30895457f, -0.17016236f, 0.19723688f, 0.06987014f, -0.06388451f, 0.02047506f, -0.03362111f, 
    0.05989778f, 0.14075515f, -0.23076327f, -0.20977473f, 0.18591057f, 0.09126985f, -0.08248312f, 0.13492207f, 
    -0.01994708f, -0.14014649f, -0.05067658f, -0.09864739f, -0.01795315f, 0.04771192f, -0.05711674f, -0.04861297f, 
    -0.04566461f, -0.05289201f, -0.07943553f, -0.10472222f, -0.08386065f, -0.22495605f, -0.17965093f, 0.01029187f, 
    -0.07655797f, 0.07085926f, -0.25259635f, 0.24497336f, 0.03555755f, -0.04232380f, -0.05595934f, -0.02152046f, 
    -0.04996880f, -0.00131115f, 0.16975762f, -0.01084082f, 0.20446727f, 0.01759081f, 0.63393950f, -0.08578625f, 
    0.17696631f, -0.10858054f, 0.01669598f, 0.07212985f, -0.06556688f, 0.07443155f, 0.02129720f, 0.15389216f, 
    -0.05032534f, -0.17270741f, -0.22231117f, -0.22225569f, 0.02820128f, 0.09456632f, 0.04067151f, 0.10745227f, 
    -0.02141845f, -0.17643580f, 0.17366405f, -0.12508932f, -0.01728403f, 0.16624533f, 0.01237026f, 0.06887165f, 
    0.06615749f, -0.12064365f, 0.04006336f, 0.05328187f, -0.01168004f, -0.07025196f, 0.11805310f, -0.17003803f, 
    0.17276773f, 0.14065319f, -0.01489581f, -0.11105765f, 0.08147334f, 0.02107841f, -0.02374492f, -0.16227013f, 
    0.11289543f, -0.08141410f, -0.06457118f, 0.06927346f, -0.29191175f, -0.26904249f, -0.20524074f, -0.33769020f, 
    0.26579037f, 0.11018288f, 0.02151240f, 0.01044606f, -0.06076980f, 0.00280095f, -0.11270706f, -0.05013564f, 
    -0.07661271f, -0.06989123f, 0.00138584f, 0.02696033f, -0.12377181f, 0.00858856f, -0.04815958f, -0.01465433f, 
    0.35282937f, 0.00858459f, 0.00309110f, -0.06277665f, 0.05314996f, -0.10641350f, -0.07390313f, 0.08062350f, 
    -0.15202595f, 0.05326786f, 0.20632868f, -0.05101242f, -0.03759339f, 0.07493245f, 0.01809870f, 0.07774793f, 
    0.03861873f, 0.03619100f, 0.03970619f, -0.11774976f, -0.11061052f, -0.24172665f, 0.05416366f, -0.04511036f, 
    0.00789030f, 0.03040743f, 0.18829292f, -0.09977394f, 0.08974982f, -0.52363652f, -0.20260102f, 0.22093314f, 
    -0.01048500f, 0.07876012f, -0.10413153f, -0.03593355f, 0.15518637f, -0.10035548f, 0.00192464f, 0.18835218f, 
    0.03925031f, 0.32243344f, -0.03419167f, -0.35749045f, -0.09811621f, 0.13166448f, 0.21745886f, 0.22790770f, 
    0.05580001f, -0.14218767f, 0.08180501f, -0.03593198f, -0.22425139f, 0.06863814f, 0.03762844f, -0.08990468f, 
    0.04160869f, -0.21289094f, -0.10305706f, 0.14230387f, -0.14546883f, 0.06699205f, 0.09018279f, -0.13789843f, 
    0.52612394f, -0.01504120f, -0.03440643f, 0.10204720f, 0.05698864f, -0.04702965f, -0.10177913f, -0.14079069f, 
    0.06677145f, 0.07367101f, 0.04455841f, 0.06711650f, -0.26423025f, -0.34564891f, 0.27693799f, 0.15525880f, 
    -0.03146369f, 0.12294877f, -0.04331226f, 0.05709916f, 0.09738915f, -0.00839479f, -0.07598876f, -0.05331577f, 
    -0.11511726f, -0.01566165f, 0.19383410f, -0.14871256f, -0.14150178f, 0.04072864f, 0.03525096f, -0.05961347f, 
    0.10526734f, 0.09280851f, 0.09027300f, 0.28690338f, -0.22313444f, -0.19134402f, -0.11182942f, -0.13107598f, 
    0.12060527f, 0.11343866f, -0.03159430f, 0.01801161f, -0.02953087f, 0.00353232f, 0.18263112f, -0.02393717f, 
    0.26900205f, 0.29322132f, 0.18872899f, 0.12291860f, 0.18003738f, 0.02421979f, 0.08583362f, -0.06646227f, 
    0.04584918f, 0.06196557f, -0.10959724f, 0.14752148f, 0.07291614f, 0.03901772f, -0.37729758f, 0.03173644f, 
    0.15405305f, 0.31261390f, -0.01687141f, 0.07510218f, 0.09461675f, 0.03314487f, 0.01504775f, -0.18632886f, 
    0.11306086f, -0.36376491f, -0.04664291f, -0.07982913f, -0.01128855f, 0.11690689f, -0.01122123f, 0.12147373f, 
    0.01016703f, 0.03716904f, -0.00248314f, -0.14701959f, 0.20618328f, -0.39254552f, -0.01222499f, -0.04279721f, 
    -0.18884334f, 0.13069586f, -0.04584366f, -0.12151986f, -0.18532109f, 0.02036931f, 0.00413039f, 0.10729221f, 
    0.30149665f, -0.05502366f, 0.51548797f, 0.02096985f, 0.04294705f, 0.01117707f, -0.02691404f, 0.05947820f, 
    0.08891969f, 0.01153467f, 0.09427859f, 0.06950554f, 0.11519642f, 0.20971088f, 0.16689831f, 0.06201950f, 
    0.31738392f, 0.09311748f, 0.12957059f, 0.25232160f, -0.04124315f, 0.01272048f, 0.07659309f, 0.14576143f, 
    0.20070942f, 0.09877920f, -0.04775686f, 0.21094231f, 0.05545997f, -0.00011428f, 0.11249544f, -0.07887859f, 
    0.16656709f, -0.20178379f, -0.09011859f, -0.01242935f, -0.24924511f, -0.11312725f, -0.09677035f, 0.27799380f, 
    0.06058947f, -0.08423825f, 0.02403862f, 0.11723894f, 0.10547986f, -0.08261788f, 0.18211633f, -0.02596150f, 
    0.03828406f, 0.21910322f, -0.09588248f, -0.23425761f, 0.06092612f, -0.01588257f, 0.21405417f, 0.09081240f, 
    -0.11745998f, -0.00024775f, 0.11733576f, 0.22980806f, -0.46881053f, 0.23170346f, 0.31973472f, 0.20377357f, 
    0.15032814f, -0.02733863f, -0.11597621f, -0.05246454f, 0.11137873f, -0.09202242f, 0.18627690f, 0.00232032f, 
    0.35328266f, 0.03375918f, 0.01024867f, 0.01454522f, 0.15319844f, 0.08258972f, 0.33710951f, -0.08551820f, 
    0.16522372f, -0.15256315f, -0.07137721f, 0.07936918f, -0.12781973f, -0.46497288f, 0.10109113f, -0.21158338f, 
    0.02059560f, 0.11806371f, -0.14105445f, -0.00963878f, -0.12023541f, 0.01404391f, 0.02809180f, 0.23567189f, 
    0.03683488f, -0.26201200f, -0.18080014f, -0.33025083f, 0.08840961f, -0.20213506f, -0.14507692f, -0.03742896f, 
    0.36288595f, 0.02054351f, 0.07930452f, 0.25877088f, -0.13370697f, -0.36761701f, 0.31642538f, -0.13212743f, 
    0.14097203f, -0.08657084f, 0.20208180f, 0.07365251f, 0.09825780f, -0.23040207f, -0.03138629f, -0.03744660f, 
    0.08616974f, 0.02281014f, -0.30344123f, -0.19084546f, 0.03714147f, 0.06868478f, -0.08605783f, 0.22659212f, 
    -0.10293034f, -0.06210840f, -0.03481698f, -0.08101392f, 0.09718782f, -0.15628064f, 0.07576238f, 0.25264713f, 
    -0.03775335f, 0.01755311f, -0.13385594f, -0.07479170f, 0.05320637f, -0.02400698f, -0.01823387f, 0.13443556f, 
    -0.44855440f, -0.32044140f, 0.00665077f, 0.15228648f, 0.03399451f, 0.01718226f, -0.14340663f, 0.02191829f, 
    0.16921221f, 0.04585117f, -0.03952006f, 0.06714928f, 0.22009404f, -0.22617772f, 0.17974016f, 0.04063952f, 
    0.08738999f, 0.16566503f, -0.25410819f, 0.33686474f, 0.14058651f, 0.14777291f, 0.02531142f, -0.08457027f, 
    0.31092086f, -0.39483383f, -0.00121196f, -0.00536617f, 0.02740269f, -0.00897956f, -0.02850235f, 0.01981436f, 
    0.18627122f, 0.03391125f, 0.20490737f, 0.13199976f, -0.28192359f, -0.20815073f, 0.20207348f, 0.04049223f, 
    0.07798513f, -0.07937568f, -0.17592295f, -0.19151157f, 0.10361022f, -0.02884705f, 0.10183208f, 0.02955979f, 
    0.14445606f, 0.27361253f, 0.09269475f, 0.11881787f, 0.02167507f, 0.18864223f, 0.10175546f, 0.04253260f, 
    0.04242166f, -0.11013536f, -0.08569515f, -0.01851457f, -0.02602644f, -0.34038940f, -0.28907862f, -0.05329563f, 
    0.07107638f, 0.21631123f, 0.07200082f, -0.04020805f, 0.13861084f, 0.04137279f, -0.09917151f, 0.12017468f, 
    0.23630756f, -0.44124639f, 0.06658287f, -0.38202789f, -0.02751019f, 0.00199707f, -0.17985578f, -0.23072389f, 
    0.23831381f, -0.06941145f, -0.06036083f, -0.06103655f, -0.20469919f, 0.30000585f, -0.24089836f, 0.09274889f, 
    0.00862263f, 0.14660369f, -0.01057779f, -0.07986458f, 0.17030402f, 0.12187348f, -0.20363320f, -0.09285191f, 
    0.29130936f, -0.09839986f, -0.06165196f, 0.13848354f, -0.01349858f, 0.01612103f, -0.13273026f, -0.14014548f, 
    0.23943885f, 0.08824521f, 0.05833741f, -0.07892924f, -0.00859856f, -0.37984145f, -0.29295143f, -0.34256059f, 
    -0.20855388f, 0.23670013f, -0.16782938f, 0.11543602f, 0.11127927f, 0.04804799f, 0.03523690f, 0.33784649f, 
    0.06620095f, 0.28918266f, 0.34902650f, -0.30811390f, 0.11537182f, 0.09519318f, 0.04099528f, 0.29763606f, 
    0.11900692f, -0.11720488f, -0.11315047f, 0.05198911f, -0.31318310f, -0.26499361f, 0.22048034f, -0.13337001f, 
    0.10658275f, -0.07403237f, -0.00939773f, 0.24836083f, 0.08744694f, 0.08502146f, 0.00089658f, 0.03627940f, 
    -0.32325968f, -0.24276982f, -0.07384950f, 0.28624892f, 0.03325111f, 0.04265913f, -0.11685346f, 0.11288501f, 
    0.09965430f, -0.08694705f, -0.05547608f, 0.09303406f, 0.51154560f, 0.02143442f, 0.51568109f, -0.04611713f, 
    -0.09107535f, -0.06879194f, -0.18576188f, 0.06357067f, -0.12539108f, 0.04760236f, -0.03020899f, -0.10691766f, 
    -0.11098994f, -0.40394533f, 0.38162598f, 0.03428924f, -0.07919607f, -0.04886488f, -0.09968787f, -0.14599918f, 
    -0.03781142f, 0.00696808f, 0.08069301f, 0.19145060f, 0.31668404f, -0.24112149f, -0.22600566f, 0.15984343f, 
    0.21537697f, -0.05867105f, -0.02236445f, -0.09879681f, 0.01865904f, -0.11758199f, 0.07099411f, 0.06749919f, 
    0.28693613f, 0.47426170f, 0.04186542f, -0.22240767f, 0.25911877f, 0.20125157f, 0.18718176f, 0.23982313f, 
    0.08595115f, -0.14121969f, 0.01144870f, -0.02493659f, -0.18992047f, 0.54214478f, -0.39611673f, 0.13092051f, 
    0.06908979f, -0.00583401f, 0.03832392f, -0.08338872f, 0.15312114f, 0.11146760f, -0.02417501f, -0.08354021f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02991116f, 0.01739758f, -0.00189190f, 0.04597561f, 0.00721731f, 0.23052284f, -0.03019975f, -0.03320613f, 
    0.01962302f, 0.02408917f, -0.00650956f, -0.05413042f, -0.05255648f, -0.03267779f, 0.11589663f, 0.02399402f, 
    -0.02787753f, 0.00957224f, -0.00875655f, 0.01997956f, -0.02220816f, 0.09643419f, -0.04395565f, 0.29444787f, 
    0.04788315f, 0.18404563f, 0.02332264f, -0.07599707f, -0.00593561f, 0.04104425f, 0.01053744f, 0.07866780f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.14015907f, 0.04285315f, 0.35994253f, -0.03976947f, -0.22835533f, -0.00351301f, -0.01086343f, -0.11255459f, 
    0.14634199f, 0.45291376f, -0.16076320f, 0.08961578f, 0.03362532f, -0.16309008f, 0.06795934f, -0.26246968f, 
    -0.15798318f, 0.07890060f, -0.02300234f, 0.16642429f, -0.10703047f, -0.25532833f, -0.16628245f, -0.64826548f, 
    -0.86449826f, -0.12909465f, -0.14074717f, 0.15067451f, 0.06083997f, -0.78154081f, 0.11586671f, 0.22827791f, 
    -0.13485345f, -0.03438464f, 0.41761205f, -0.01105734f, 0.15903769f, 0.35033274f, -0.07994021f, 0.00256394f, 
    -0.08773196f, -0.37822035f, -0.11859002f, -0.15758437f, -0.16121958f, -0.09778252f, -0.17288919f, -0.45218053f, 
    -0.04809683f, -0.12080163f, -0.12125637f, 0.31613943f, -0.06285864f, -0.11838157f, -0.07274657f, 0.11422872f, 
    -0.08250025f, 0.30665925f, -0.09192296f, 0.28558859f, -0.15466021f, -0.58429056f, -0.07305632f, -0.19828585f, 
    -0.13714901f, 0.13476624f, 0.36894703f, -0.71076089f, -0.55960715f, 0.18173797f, 0.11914451f, -0.13344322f, 
    -0.08425593f, 0.10379089f, -0.18133883f, -0.01330140f, 0.16989984f, 0.13744776f, 0.01080393f, -0.17334993f, 
    -0.03510323f, -0.15969835f, 0.00366571f, -0.57779706f, -0.05851785f, 0.34727061f, -0.12570976f, 0.01478420f, 
    0.27556241f, -0.08740628f, 0.07354037f, 0.12061825f, 0.13904200f, 0.22936514f, -0.36396864f, -0.13907015f, 
    -0.03943360f, -0.12112424f, -0.12486551f, 0.20588452f, 0.03574535f, -0.77742702f, 0.01344651f, 0.06130366f, 
    0.02601096f, -0.01445906f, 0.09195963f, 0.04675561f, -0.00941171f, 0.12044216f, -0.23114793f, 0.20513465f, 
    0.02468197f, 0.14266363f, 0.09219838f, -0.14554076f, 0.04386573f, -0.59752631f, -0.09582171f, -0.80424684f, 
    0.43406591f, 0.19535550f, 0.13560657f, 0.14231656f, -0.13521108f, 0.13538499f, -0.26630992f, 0.08817821f, 
    -0.10587744f, -0.18131515f, -0.03350192f, 0.29563993f, 0.13467562f, -0.55092627f, -0.12179734f, 0.13033214f, 
    0.00524653f, 0.13482426f, 0.01626561f, 0.31563622f, 0.05596223f, 0.09605736f, 0.07742916f, -0.21919341f, 
    -0.03094740f, -0.08798970f, -0.18296927f, -0.05020188f, 0.05494898f, -0.04483001f, -0.07057867f, 0.31167758f, 
    -0.35706782f, -0.47135037f, -0.02971753f, 0.04768061f, -0.04495412f, 0.12883349f, -0.16802809f, -0.10897032f, 
    -0.09787172f, 0.11335869f, -0.23433889f, 0.17486703f, -0.64845467f, -0.10074531f, -0.06301428f, -0.16237254f, 
    -0.00485267f, -0.28955537f, 0.09167840f, -0.19991268f, -0.04804998f, 0.04042117f, 0.18379515f, -0.08275060f, 
    -0.12267336f, -0.11029592f, 0.07835634f, 0.24478477f, 0.08148718f, -0.22266163f, -0.08271522f, 0.45621583f, 
    -0.12732120f, -0.04808044f, 0.06132758f, -0.37760204f, 0.13124168f, -0.30612898f, 0.41765207f, 0.48546201f, 
    -0.15149194f, 0.10048531f, 0.22079763f, -0.81760436f, 0.20206340f, -0.16738157f, -0.06876712f, 0.14876609f, 
    0.16705997f, 0.19346030f, -0.00923603f, -0.23376064f, 0.03764310f, 0.08233701f, -0.12623799f, 0.19981518f, 
    0.07313720f, -0.11106381f, 0.05439363f, -0.65443909f, -0.13764380f, -0.06242479f, -0.08963350f, 0.43920225f, 
    0.06391835f, 0.12084559f, 0.03970190f, -0.65135986f, -0.06802762f, 0.29405397f, -0.02939365f, -1.15898764f, 
    0.08280098f, 0.05785965f, 0.22095352f, -0.38730726f, 0.36679921f, -0.04250504f, 0.08987870f, 0.07090200f, 
    -0.06351746f, -0.46493778f, 0.12824228f, -0.57066578f, 0.04208676f, 0.08223136f, -0.40139779f, 0.12083065f, 
    -0.07245131f, 0.15656632f, -0.15507466f, 0.29712367f, -0.09136218f, 0.13769644f, -0.17977385f, -0.37104639f, 
    0.12348775f, -0.52548039f, 0.04858045f, 0.00381753f, -0.07254487f, 0.25049868f, 0.05638663f, 0.37720746f, 
    0.05339287f, -0.01535741f, -0.34787196f, -0.62922823f, 0.23906510f, 0.35552281f, 0.04225298f, 0.17298055f, 
    -0.03581029f, -0.57922804f, -0.11932468f, -0.72243685f, 0.02265713f, -0.07050629f, 0.50854737f, -0.10383344f, 
    -0.14982024f, 0.03464929f, -0.06124010f, -0.39179525f, -0.03390638f, -0.18735240f, 0.15658616f, -0.41162151f, 
    0.24666028f, 0.14764607f, 0.08138534f, 0.31164786f, -0.02919857f, 0.17043191f, 0.00018528f, -0.18857208f, 
    0.16401264f, -0.11943456f, 0.03156192f, 0.26834738f, 0.13202819f, 0.19171502f, 0.07849560f, 0.00410455f, 
    -0.17222531f, 0.15957806f, 0.05642743f, 0.01287297f, 0.02715152f, 0.14780052f, -0.43319911f, 0.19571920f, 
    0.13328046f, 0.12028000f, -0.14862984f, 0.23299274f, -0.07237002f, 0.45106456f, -0.06207361f, 0.13233650f, 
    -0.21079709f, -0.49041808f, 0.03913650f, -0.75023323f, 0.15306352f, -0.02035074f, -0.56777996f, 0.15288210f, 
    0.14625947f, 0.11963279f, -0.40925509f, 0.24614251f, 0.00259472f, -0.09936375f, 0.13626851f, -0.09265777f, 
    -0.02733881f, -0.82852554f, -0.13165133f, 0.12945332f, -0.08187106f, -0.11340868f, -0.02618925f, -0.24709620f, 
    -0.16383971f, -0.13524021f, -0.13067007f, -0.44537354f, 0.00731378f, 0.54657960f, 0.11001832f, -0.25446060f, 
    -0.20586644f, 0.53188199f, -0.05015621f, -0.27087963f, 0.10437115f, 0.10615452f, 0.07470503f, -0.57380348f, 
    0.15441345f, -0.17533086f, -0.87216818f, -0.26376188f, -0.31473786f, 0.38823515f, -0.03989152f, 0.09432855f, 
    0.03225077f, -0.36072901f, 0.05824962f, 0.43821552f, 0.02328867f, 0.12362564f, -0.51577431f, 0.04632967f, 
    -0.06325509f, 0.14962812f, 0.03262777f, 0.02039225f, -0.16548751f, -0.61985284f, -0.01925057f, 0.13486317f, 
    0.33844736f, -0.14212425f, 0.03516847f, 0.06706548f, 0.00234533f, 0.34813181f, -0.02147467f, -0.68126470f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.23934160f, 0.13404413f, 0.19267032f, -0.17832783f, -0.19816326f, -0.00895190f, 0.14929090f, -0.17182562f, 
    -0.03169718f, -0.05757452f, -0.02349461f, 0.13993357f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
