#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.63447100f, -0.26362336f, -1.38299417f, -1.42021525f, 0.51203269f, 1.22817504f, 1.04632998f, -0.36545953f, 
    0.61315548f, 1.93673992f, 1.82130957f, 1.67950916f, 0.89150298f, -0.36667427f, -0.29765642f, -0.11211760f, 
    0.12985203f, -0.32165617f, -1.80873406f, -0.64083409f, 0.85685241f, 1.09337449f, 0.09399953f, -0.61792672f, 
    -0.22048764f, 0.42146194f, -0.32025942f, -1.21488583f, 1.50294697f, -1.16649818f, 0.76990283f, 1.07841337f, 
    -1.32347524f, 0.26081842f, -0.13374020f, 0.17784330f, 1.69825423f, 0.61316675f, -1.26057255f, -1.28106248f, 
    -1.01080060f, -0.03979743f, -0.38202524f, -0.25889966f, 0.02394669f, 1.18818831f, -1.22075355f, 0.47727033f, 
    -0.19953249f, 0.97810030f, 0.90468174f, -0.63746202f, -0.62279582f, -0.52798051f, 1.84828687f, -1.29845178f, 
    -0.14138043f, 0.96086532f, 0.65465569f, -0.52295202f, -0.14760435f, 0.65562224f, -0.41340587f, -1.18406498f, 
    0.91689479f, 1.24580014f, -1.05507767f, 1.42241502f, -0.00308284f, -0.32786721f, 0.38541585f, 0.68877101f, 
    -1.01323831f, -0.50816011f, 0.03289033f, 0.93195015f, 0.55830097f, -1.61944926f, 0.83888519f, 0.51618862f, 
    0.55386966f, -0.65249860f, -1.32893705f, -0.74092734f, 0.33360085f, 1.39019012f, 0.27566212f, -0.65657955f, 
    -0.54415268f, -0.77651483f, -1.49391186f, -1.33136749f, -1.36052322f, 0.85769022f, -0.61965674f, 0.13730860f, 
    -0.21389985f, -0.21339943f, 0.43472999f, 0.83175212f, -1.93631816f, 1.26219738f, 0.52854156f, -0.34225127f, 
    0.47188163f, -0.10083701f, 0.03597307f, -0.39989716f, -0.80859590f, -0.31349131f, -0.28576264f, 1.17435789f, 
    1.20228386f, 1.19557607f, 0.41486627f, -0.31507772f, 0.36148015f, 0.01351273f, -1.22928655f, -0.92175978f, 
    -1.00063968f, 0.06128652f, -1.39388168f, -0.33148009f, 0.75598222f, 0.73251426f, -1.15532243f, -1.54491973f, 
    0.73760104f, -0.07938433f, 0.07424422f, 0.89602983f, 0.37199011f, 0.03160368f, -0.47211459f, -0.63355166f, 
    -1.38814270f, -0.60678732f, -0.92421496f, -1.52090383f, -0.73970640f, -0.72135174f, -0.07810075f, -0.74501234f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.35732111f, 0.83189428f, 0.00824647f, 0.15324619f, 0.11106566f, -0.13713463f, 0.26486543f, 0.04164454f, 
    0.20150271f, -0.27513403f, 0.64384252f, 0.00078376f, 0.21750632f, 0.57886612f, 0.37115529f, 0.53302580f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.73309076f, 0.30204350f, -0.19757332f, 0.04448947f, -0.23522647f, -0.00665324f, -0.08422488f, -0.08751513f, 
    -0.07886530f, -0.06883855f, 0.04243038f, -0.12127595f, 0.05578249f, 0.15799789f, 0.13574731f, -0.14432861f, 
    0.00488002f, -0.11275165f, 0.04149041f, -0.18302402f, 0.38139588f, 0.05697791f, 0.08982655f, -0.25932932f, 
    0.29929322f, -0.36253452f, -0.26663914f, -0.03045460f, 0.05820549f, 0.09406869f, 0.01399670f, 0.06796151f, 
    -0.11461162f, 0.11986241f, -0.07810996f, 0.06713864f, -0.12443753f, -0.02521068f, -0.05082443f, 0.07179665f, 
    -0.59091157f, 0.11350136f, 0.36065215f, 0.05698018f, -0.35868156f, 0.10174534f, -0.03319195f, 0.08225964f, 
    0.09427088f, 0.05917399f, -0.08184458f, -0.02974188f, 0.17690776f, -0.14455184f, -0.21171938f, -0.07820940f, 
    -0.04514038f, 0.00803612f, -0.06458392f, 0.05963431f, 0.91950852f, -0.02969495f, 0.14516273f, -0.30703938f, 
    0.21023700f, 0.02034873f, -0.11839136f, 0.07947449f, -0.19477460f, -0.06085131f, 0.16441847f, 0.01952453f, 
    -0.00118814f, 0.15539502f, 0.18063708f, 0.07606210f, -0.11477300f, 0.14625847f, -0.05382237f, -0.04679066f, 
    0.24798998f, -0.07149634f, 0.22491367f, 0.17213894f, 0.48896742f, -0.20843159f, -0.14057921f, -0.11947829f, 
    0.07110903f, -0.03699481f, -0.08260037f, -0.16306420f, 0.12812105f, -0.05237097f, -0.03753991f, -0.06292450f, 
    -0.06998261f, -0.13007471f, 0.13507175f, -0.09418463f, 0.11610053f, 0.13357897f, 0.03153868f, 0.18581808f, 
    -0.01213842f, -0.13804513f, -0.11175750f, 0.15002334f, -0.03359545f, -0.01065846f, 0.09077292f, -0.00861409f, 
    0.12214130f, -0.18506387f, -0.07317682f, 0.27915111f, 0.01950550f, -0.04037550f, -0.02181961f, -0.01112733f, 
    0.20593251f, -0.07075107f, 0.27225304f, 0.02576649f, 0.19010369f, 0.02883983f, -0.26636735f, -0.21935916f, 
    0.08550616f, -0.03702952f, -0.29750663f, 0.15960443f, 0.20354618f, 0.06292240f, -0.05598146f, -0.15371457f, 
    0.03520340f, -0.04715024f, 0.02742309f, -0.01956753f, -0.18166363f, -0.17822523f, 0.26189020f, 0.06388515f, 
    0.25458989f, -0.10144690f, 0.06421321f, 0.11176264f, 0.03305538f, -0.19166033f, 0.05523863f, -0.08943582f, 
    0.16866843f, 0.14934932f, 0.08109418f, -0.09611590f, 0.09854140f, 0.05109850f, -0.05173562f, -0.13225614f, 
    -0.20202182f, -0.42707935f, -0.03760172f, -0.01306781f, -0.33215278f, -0.08289552f, -0.11332637f, -0.08912812f, 
    0.05516011f, 0.02276192f, 0.03801112f, 0.13383085f, 0.10416461f, -0.02525550f, 0.15130712f, 0.03272067f, 
    -0.07305200f, -0.11411002f, -0.06211651f, -0.05618484f, -0.10622364f, 0.37081528f, 0.41122434f, -0.19893250f, 
    -0.54652297f, 0.08203356f, 0.17872083f, 0.01122531f, -0.04838746f, 0.10034323f, 0.18591523f, 0.00324917f, 
    0.14559110f, 0.10349852f, -0.08191334f, -0.07254857f, 0.29215166f, 0.15765718f, -0.06164660f, 0.04266892f, 
    0.34904897f, -0.50467491f, -0.27129757f, -0.09493833f, -0.51512069f, 0.08071055f, 0.01548446f, -0.01299530f, 
    0.10085971f, 0.05788451f, -0.06596731f, -0.07999692f, -0.00404778f, 0.02047072f, -0.05786344f, 0.25783828f, 
    -0.02711640f, 0.06216327f, -0.01454719f, -0.07636683f, 0.32798132f, -0.07165315f, 0.04902469f, 0.17108560f, 
    -1.16692424f, 0.07460735f, -0.05130008f, 0.04958584f, -0.19468883f, -0.08266068f, -0.17487088f, 0.21951780f, 
    0.00314969f, -0.16877563f, -0.00044445f, -0.18958883f, -0.18184116f, 0.12522656f, -0.16382569f, 0.01613200f, 
    0.24408662f, 0.17725082f, 0.24658300f, -0.31688508f, -0.24067184f, 0.08982877f, 0.18745475f, -0.11762776f, 
    0.09620869f, 0.05769860f, -0.14754051f, -0.04106051f, -0.13975923f, 0.10639399f, 0.05133799f, 0.15117873f, 
    0.09344987f, -0.08513356f, 0.15386756f, -0.03370165f, -0.28215063f, -0.91588432f, 0.26192674f, 0.07417616f, 
    -0.25941494f, 0.01611832f, -0.14263058f, 0.22092861f, -0.01150003f, 0.17961676f, 0.06659025f, -0.00227225f, 
    -0.08667414f, 0.04610934f, -0.11645969f, -0.16596942f, -0.14744514f, -0.06711993f, 0.09238745f, -0.12188847f, 
    -0.50297505f, 0.07776771f, 0.00540430f, 0.05768288f, -0.51706606f, 0.08441146f, -0.08009560f, -0.00652467f, 
    0.24404810f, -0.06644864f, 0.09071734f, -0.05189471f, -0.10831477f, -0.10838850f, -0.05783365f, -0.10323365f, 
    -0.02617556f, -0.23514038f, 0.09981814f, 0.10946623f, -0.03566518f, -0.76668209f, -0.05570724f, 0.25255463f, 
    -0.26415467f, 0.12377374f, -0.15089758f, -0.07665407f, 0.17889559f, 0.11885364f, 0.03411393f, -0.19106568f, 
    -0.05908358f, 0.02496104f, -0.04299018f, 0.13636622f, -0.05986347f, 0.03309631f, -0.06885710f, 0.02884350f, 
    0.79002911f, -0.06103751f, -0.20598879f, 0.21289164f, -0.14427370f, 0.09575079f, 0.20514114f, -0.15378608f, 
    0.21249966f, 0.04950651f, 0.09356941f, -0.21444017f, 0.05342892f, -0.02235539f, 0.06647252f, 0.11706764f, 
    -0.27038175f, 0.20193489f, -0.02548295f, 0.25098503f, 0.37656030f, 0.19571774f, 0.23460799f, 0.09741976f, 
    0.50377828f, -0.12383090f, -0.00595939f, 0.01730439f, 0.01796864f, 0.05860712f, -0.06764660f, -0.06223868f, 
    0.10491425f, 0.05616372f, 0.07983331f, -0.00465390f, 0.24658419f, -0.06556720f, 0.00110646f, 0.06032076f, 
    -0.05999396f, -0.15936370f, -0.40230781f, 0.05388834f, -0.28603899f, 0.09814055f, -0.06616717f, 0.01882974f, 
    -0.04263558f, 0.13364370f, -0.02453500f, -0.02816942f, -0.09527183f, 0.09996421f, 0.13366351f, -0.02756594f, 
    0.04078911f, 0.14115195f, -0.02011883f, 0.18771288f, -0.69719940f, -0.31114405f, -0.20235181f, -0.18019971f, 
    0.22139138f, -0.05019533f, -0.10853691f, -0.09531406f, 0.04554712f, 0.15722090f, 0.10548151f, -0.01336536f, 
    0.03033503f, -0.03591375f, 0.03450654f, 0.04830086f, -0.16849791f, -0.20779391f, -0.08435860f, -0.19118661f, 
    0.20500058f, -0.60873461f, 0.09584581f, -0.54959023f, -0.30100584f, -0.09395279f, -0.18442315f, 0.13090272f, 
    0.19176212f, -0.21614711f, -0.12772495f, -0.02194178f, -0.17621960f, 0.18656187f, -0.20558298f, -0.08194140f, 
    -0.29700696f, -0.22472361f, 0.04801224f, -0.25267348f, 0.30572709f, -0.19932196f, 0.09027734f, 0.06336601f, 
    0.21699205f, -0.03048861f, 0.02338620f, -0.20765392f, -0.06087843f, 0.00795536f, 0.28973213f, 0.11833763f, 
    -0.10831868f, -0.01411465f, -0.37792987f, -0.10287602f, -0.16015829f, 0.07365573f, -0.10411320f, 0.04221400f, 
    0.70116794f, -0.63118374f, 0.19378428f, -0.24431887f, -0.01840475f, -0.06761616f, 0.01984256f, -0.08482974f, 
    -0.11151419f, -0.10539114f, 0.09036663f, -0.10623663f, -0.03031642f, -0.09001995f, 0.07895166f, 0.11131890f, 
    0.13003013f, 0.02733460f, 0.08177263f, 0.11140770f, -0.75779253f, 0.41077369f, -0.16733520f, -0.39035708f, 
    0.20755534f, -0.08696214f, 0.11524054f, -0.05833098f, -0.07392319f, 0.03420425f, 0.03391799f, -0.27684069f, 
    -0.02602044f, -0.10011540f, -0.04998464f, -0.03732320f, -0.01834445f, 0.09573875f, -0.16765738f, 0.06220968f, 
    -0.25886893f, -0.29118478f, 0.09446272f, -0.05393976f, 0.21662143f, -0.03827883f, 0.00974730f, -0.05939526f, 
    -0.07516929f, 0.00393345f, -0.12833048f, -0.00283081f, 0.01291591f, -0.14045934f, -0.08528376f, 0.04545640f, 
    0.04017081f, -0.06931607f, 0.12591168f, -0.08982779f, 0.26969680f, -0.45460674f, -0.30342543f, 0.03584918f, 
    -0.17867887f, -0.21016775f, -0.06013731f, 0.01776237f, 0.02399278f, 0.03299946f, 0.04641276f, 0.20782636f, 
    -0.08185969f, -0.06492396f, 0.06399881f, 0.03677688f, -0.09542897f, -0.06632524f, -0.09801129f, 0.02551690f, 
    -0.02091424f, 0.34320068f, -0.12932299f, 0.08960147f, -0.25924233f, 0.16695675f, -0.04527469f, 0.11101866f, 
    -0.13265559f, 0.04120636f, 0.10502465f, -0.04026303f, -0.02056157f, 0.06476349f, -0.07255219f, -0.07834776f, 
    0.15354793f, -0.07868079f, 0.12945496f, 0.03400371f, 0.39403838f, 0.09300109f, 0.19677049f, -0.10850009f, 
    -0.26769391f, -0.08861299f, 0.16560547f, 0.12991913f, 0.13435543f, 0.28644207f, 0.21747027f, -0.05943321f, 
    0.16560149f, 0.01973170f, 0.03767797f, 0.04450513f, 0.11967069f, -0.07235993f, 0.20943531f, 0.07092617f, 
    0.01705711f, 0.39853612f, -0.09608483f, 0.11606096f, -0.13637204f, -0.07979217f, 0.05898308f, -0.04007703f, 
    -0.14580530f, 0.04281456f, 0.01546457f, 0.11181961f, 0.02646516f, -0.02945919f, 0.13654242f, 0.06392699f, 
    0.12122620f, -0.06444159f, -0.05871982f, 0.10176346f, 0.12387218f, -0.43903878f, -0.10067612f, -0.20043431f, 
    -0.13059865f, -0.02437845f, 0.07578639f, 0.06768575f, 0.09943183f, 0.26394522f, -0.05103441f, -0.12276445f, 
    0.17319700f, 0.00476166f, 0.18124275f, 0.09207395f, -0.03015667f, -0.06621827f, -0.22281478f, 0.07312392f, 
    -0.11919242f, -0.01498682f, -0.22369623f, 0.10573824f, -0.47756261f, -0.02941368f, -0.06452844f, -0.01114749f, 
    -0.01931885f, 0.00003786f, -0.15414803f, 0.05916550f, -0.07411665f, 0.06193267f, -0.02142706f, 0.01196844f, 
    0.10525110f, 0.05631210f, -0.19442403f, 0.02047942f, -0.20389658f, 0.02223321f, 0.08915254f, -0.39128518f, 
    -0.08022895f, -0.02335468f, -0.05905121f, -0.02495838f, 0.00872475f, 0.10316280f, -0.04811965f, -0.08988304f, 
    0.09450814f, 0.19026984f, -0.18541895f, -0.11108957f, 0.01836523f, -0.28642514f, -0.27887300f, -0.11607012f, 
    0.48912719f, -0.05788693f, -0.02885926f, 0.25440603f, -0.21641560f, -0.10602180f, 0.22613329f, -0.11404932f, 
    -0.04538019f, 0.21823046f, -0.06337171f, -0.01219165f, 0.17078483f, -0.00924481f, 0.04733741f, 0.04923564f, 
    -0.30967465f, -0.13644953f, 0.00282008f, 0.03662815f, 0.12644088f, -0.11239050f, 0.02578399f, -0.35208240f, 
    0.06194822f, 0.17690974f, 0.01505165f, 0.27441663f, -0.04555912f, -0.04854771f, -0.10746182f, 0.09327245f, 
    0.02172599f, -0.03698841f, -0.13984472f, 0.00901345f, -0.07885435f, 0.12254171f, -0.26300463f, -0.02812377f, 
    0.73125088f, -0.48881194f, 0.11582601f, -0.01477058f, 0.11569992f, -0.24505775f, 0.03674839f, -0.03075427f, 
    -0.10615106f, 0.08379952f, 0.00893969f, 0.15712532f, -0.06645778f, 0.03356636f, 0.06744257f, -0.01009676f, 
    -0.05142923f, -0.14601023f, 0.05227568f, 0.00185566f, 0.24546534f, 0.08647949f, 0.09579635f, -0.32429653f, 
    -0.04558649f, 0.12460745f, -0.08039236f, 0.00899405f, -0.02092035f, 0.11954036f, -0.04987273f, -0.06578182f, 
    0.05407912f, -0.04572481f, -0.21477190f, 0.03781753f, -0.21072367f, 0.05373086f, 0.09657205f, -0.08160970f, 
    -0.27634805f, -0.26679140f, -0.19766486f, -0.23781161f, -0.58485883f, 0.11515174f, -0.08716296f, 0.23854767f, 
    0.17448802f, 0.02617601f, -0.00571834f, 0.06425779f, -0.04046835f, -0.08979577f, -0.10595611f, 0.01435516f, 
    0.02435599f, 0.22320607f, 0.09592725f, 0.02121067f, -0.03385292f, 0.13162629f, -0.13280179f, -0.09000049f, 
    0.05932492f, 0.17830253f, -0.18705769f, 0.04872283f, 0.24179594f, 0.12509926f, -0.16779408f, 0.06354170f, 
    0.03263036f, 0.07458331f, 0.00408910f, -0.23486693f, 0.00740057f, -0.10307959f, -0.04596533f, -0.07579362f, 
    -0.64446932f, -0.16106763f, 0.25922170f, -0.48758310f, -0.13497028f, 0.00163797f, -0.15190147f, 0.17134434f, 
    0.16192079f, 0.10286500f, 0.02609476f, -0.09794183f, 0.03645572f, -0.16070046f, 0.07009980f, 0.15249799f, 
    -0.13438928f, -0.06103528f, 0.01927679f, -0.00226871f, 0.57129985f, 0.11306702f, -0.55803561f, -0.05383651f, 
    -0.34052870f, -0.11267710f, 0.14208044f, 0.03782615f, -0.07495891f, -0.06945529f, -0.00637108f, 0.11878803f, 
    0.11936611f, -0.05197607f, -0.02312227f, 0.09084428f, 0.04835534f, -0.18041193f, 0.12780695f, 0.00203569f, 
    0.65341777f, -0.44757122f, 0.09040979f, -0.01017191f, -0.20122428f, -0.03072666f, -0.10350943f, -0.27629322f, 
    0.19443513f, 0.00506840f, 0.04899904f, -0.20144953f, -0.07419632f, -0.05480475f, -0.05531923f, 0.06098400f, 
    -0.25715843f, 0.03094814f, 0.06026322f, 0.06229009f, 0.41106892f, -0.05304360f, 0.15218435f, 0.08974582f, 
    0.37622210f, -0.03707280f, -0.02077475f, -0.09592348f, -0.02281376f, 0.03714516f, 0.14093074f, -0.04826031f, 
    -0.12793574f, 0.03358885f, -0.11051262f, 0.02410026f, -0.14189026f, 0.10324536f, -0.34224331f, -0.10301532f, 
    -0.02520929f, 0.12122348f, 0.06421980f, 0.11778782f, 0.27466491f, -0.24398969f, -0.20287693f, -0.25135836f, 
    -0.00441521f, 0.10550866f, -0.06730824f, 0.08947952f, -0.11058450f, 0.04650329f, 0.10504609f, -0.04410740f, 
    -0.11717869f, 0.00602545f, 0.08309489f, -0.03018877f, -0.81827599f, 0.44118077f, -0.11601716f, -0.30877218f, 
    0.03296813f, -0.05367311f, 0.20061554f, 0.03791711f, 0.08289947f, 0.00898885f, 0.07094916f, -0.11222469f, 
    0.23238310f, -0.12465551f, 0.17958483f, 0.02464595f, 0.03417163f, 0.08235200f, 0.09300450f, 0.02755927f, 
    0.40913671f, 0.29660830f, 0.41188645f, 0.02702951f, 0.26979455f, -0.08847766f, -0.05281813f, -0.15369691f, 
    0.04019947f, 0.08584808f, 0.06943411f, -0.12161077f, 0.04677179f, -0.22356391f, -0.05576116f, -0.04196213f, 
    -0.22666915f, -0.08284334f, 0.02913641f, 0.01235806f, 0.50800669f, -0.18849643f, -0.04079520f, -0.45027506f, 
    -0.46880484f, 0.00263113f, 0.09612255f, 0.02348787f, -0.00373034f, -0.11353906f, 0.02562241f, 0.02780144f, 
    -0.14551184f, -0.08518805f, -0.01692437f, 0.05764251f, 0.22672975f, 0.12531345f, -0.06305157f, -0.03877733f, 
    0.14499946f, -0.22663814f, 0.03714993f, 0.01299524f, -0.12613064f, -0.34692189f, 0.03122283f, 0.04055670f, 
    -0.03125796f, -0.01442502f, 0.13182802f, -0.06023123f, 0.08516052f, -0.07143656f, -0.01565631f, 0.22061218f, 
    -0.09777050f, -0.10830729f, 0.09521203f, -0.04495183f, -0.03788152f, -0.67292446f, -0.45941061f, 0.04794286f, 
    -0.71780521f, -0.11590081f, 0.01133556f, -0.25604057f, 0.05236521f, -0.20382686f, 0.08507935f, 0.07311353f, 
    0.06714759f, 0.14880483f, -0.14889054f, -0.02304243f, -0.09141742f, 0.07825480f, -0.03814131f, -0.08520644f, 
    -0.07101054f, -0.18634930f, 0.09392367f, 0.02201040f, -0.20832068f, -0.03106312f, -0.01576292f, 0.10651106f, 
    0.00554337f, 0.08464786f, 0.00086721f, 0.00257548f, -0.17434974f, -0.00056359f, 0.11871421f, 0.01902176f, 
    -0.04294295f, 0.07647628f, 0.07204971f, -0.11562918f, -0.30791968f, -1.12186944f, -0.85790318f, 0.16114397f, 
    0.16599266f, -0.17967714f, -0.14632875f, -0.07045674f, 0.18380234f, -0.15404722f, -0.06926932f, 0.04628205f, 
    -0.01024689f, -0.03211207f, -0.02447596f, -0.00891659f, 0.02787264f, 0.09988019f, -0.08574879f, -0.04749181f, 
    -0.07156234f, -0.00311576f, -0.11137882f, 0.01924994f, 0.11681337f, -0.04197343f, -0.14377080f, -0.23478505f, 
    0.26164857f, -0.05695410f, 0.05926185f, -0.06112594f, 0.03472478f, 0.07123052f, -0.09924120f, -0.17423776f, 
    -0.03226580f, -0.05104294f, 0.15361913f, -0.02879943f, 0.65649390f, 0.45817322f, -0.07619672f, 0.01931315f, 
    0.14013009f, 0.03017603f, -0.03838661f, -0.21268219f, 0.12427110f, 0.07262661f, -0.19666637f, -0.10374383f, 
    -0.16040802f, 0.12343083f, 0.02193592f, -0.19983719f, 0.07250941f, -0.11074389f, 0.05306122f, 0.17847773f, 
    0.26529858f, -0.31718096f, 0.26232046f, -0.08429854f, 0.52650267f, -0.00807876f, 0.18001236f, 0.07898739f, 
    -0.08498191f, 0.19500093f, 0.18796134f, -0.12344477f, -0.14607193f, -0.12617573f, 0.01316349f, 0.03788869f, 
    -0.08786239f, 0.16776206f, -0.02841306f, 0.14423555f, -0.27559295f, -0.15974346f, -0.22586092f, 0.05990257f, 
    -0.26355192f, -0.01719050f, 0.12050340f, 0.01943857f, 0.05631265f, -0.02912795f, -0.11004832f, 0.09512178f, 
    0.03480730f, -0.00514886f, -0.01570890f, 0.06444736f, 0.11689985f, -0.03114712f, 0.03110035f, 0.20444991f, 
    -0.38172349f, -0.09844132f, -0.18960994f, 0.24315476f, -0.32483426f, -0.20860110f, 0.03807344f, -0.15475754f, 
    0.14441282f, 0.14811096f, -0.02217093f, 0.05998717f, -0.02174846f, 0.07585781f, -0.04567330f, -0.01037550f, 
    -0.13245636f, 0.01906644f, -0.04353201f, -0.06492366f, -0.98353904f, 0.61231333f, 0.08748723f, -0.03538860f, 
    0.00060685f, -0.09685892f, 0.04996966f, 0.00139727f, 0.06627878f, -0.12386756f, 0.03174703f, -0.08280169f, 
    -0.13211481f, 0.19313437f, -0.03732938f, 0.01845172f, -0.00232840f, -0.21519390f, 0.09010928f, 0.01974272f, 
    0.12770301f, 0.25188315f, 0.11935427f, 0.11392302f, 0.01751366f, 0.19986472f, -0.01886178f, -0.12658790f, 
    -0.02081273f, -0.22326358f, -0.01795005f, -0.01304208f, -0.16847661f, 0.12996180f, 0.03830577f, -0.15570484f, 
    0.02144384f, -0.04818643f, -0.12718943f, -0.13705637f, -0.19581111f, -0.09926639f, -0.07753122f, 0.02685872f, 
    -0.22168109f, -0.15530956f, -0.17587881f, 0.26627183f, 0.07581521f, 0.15934268f, -0.11125441f, -0.03246544f, 
    0.07472796f, -0.10836361f, 0.06674179f, 0.09276514f, 0.04208344f, -0.01351202f, 0.23813985f, 0.03549514f, 
    0.11802041f, 0.16679746f, -0.43098590f, 0.09935118f, 0.06901796f, -0.11702010f, -0.08055879f, 0.01452577f, 
    0.03534694f, 0.01212570f, -0.15453783f, -0.06363031f, -0.01740280f, -0.18874767f, 0.07836640f, -0.12292202f, 
    -0.12908170f, 0.05794016f, -0.13524990f, -0.08959338f, 0.18172106f, 0.06535019f, -0.32558697f, -0.01985371f, 
    -0.05000116f, -0.03564815f, 0.23533486f, -0.17568395f, -0.09486617f, -0.07720327f, 0.27103457f, 0.10610533f, 
    -0.07143213f, -0.07732749f, -0.03536950f, -0.12823877f, 0.00474212f, -0.07779837f, 0.14339925f, -0.04138806f, 
    -0.12492664f, -0.11407088f, -0.00765122f, -0.26654559f, -0.41892371f, -0.05391514f, -0.18421103f, -0.05106602f, 
    -0.09410734f, -0.11002162f, -0.02629540f, -0.08100821f, -0.02603905f, 0.03933296f, -0.03655481f, 0.04540024f, 
    0.03748875f, -0.00413262f, -0.09310500f, 0.07600646f, 0.13426007f, 0.38140434f, 0.14314197f, 0.19218029f, 
    -0.09183548f, 0.00685426f, 0.05032517f, -0.01269704f, -0.24363668f, -0.09787249f, 0.16633691f, -0.05037463f, 
    0.00694406f, -0.06701622f, -0.05972417f, 0.15859848f, 0.01069383f, 0.20897673f, 0.01311555f, 0.04499693f, 
    0.44001052f, -0.00965299f, 0.33842841f, -0.14588669f, 0.08458538f, -0.19177166f, -0.10269418f, -0.20714593f, 
    0.00262666f, -0.07934856f, 0.10354158f, 0.01306033f, 0.04856699f, 0.11959542f, 0.05308969f, -0.14583825f, 
    0.03730364f, -0.11643440f, 0.05914316f, -0.07883067f, 0.02049963f, 0.32248077f, 0.27746499f, 0.40594107f, 
    -0.03109931f, -0.11156759f, -0.23245406f, -0.03281043f, -0.15600628f, -0.06850594f, -0.03089285f, -0.01557975f, 
    -0.02097037f, -0.11283083f, -0.14164320f, 0.04731647f, 0.12607832f, 0.26740110f, 0.11386138f, 0.04056792f, 
    0.03771282f, 0.05316507f, -0.22231980f, 0.12292460f, 0.22180820f, 0.20762378f, 0.08495800f, 0.22274561f, 
    -0.04725497f, 0.01857210f, -0.08660341f, 0.15059350f, -0.02967920f, 0.02323820f, -0.05032811f, -0.06361042f, 
    -0.16540486f, 0.07310136f, 0.00196809f, -0.24450508f, -0.35123792f, 0.05964627f, 0.19722189f, 0.10635153f, 
    -0.01817775f, 0.08311310f, -0.03245516f, -0.14322239f, 0.17738475f, 0.09272680f, 0.05801720f, -0.08874574f, 
    0.06145727f, -0.15750711f, -0.04871786f, 0.00810007f, 0.05391880f, -0.11506762f, -0.00540620f, 0.03898260f, 
    0.42417732f, 0.47399938f, -0.28173009f, -0.84786719f, -0.01368164f, -0.31587833f, 0.00905890f, -0.19434476f, 
    0.10544585f, -0.32199672f, -0.05399533f, -0.00688608f, -0.16333243f, 0.10731275f, 0.02177225f, 0.07052141f, 
    -0.00145679f, -0.06382161f, 0.09486236f, -0.12902443f, -0.15089329f, -0.09207565f, 0.01309221f, -0.09846793f, 
    -0.16342570f, 0.13382667f, 0.10053712f, 0.13019495f, -0.04958970f, 0.10239281f, -0.06521635f, 0.04327964f, 
    0.13090497f, -0.01054273f, 0.02343085f, -0.14381665f, 0.24446517f, 0.00678847f, 0.05901583f, 0.10807679f, 
    0.26790807f, -0.24459058f, -0.32349485f, 0.28992093f, -0.30911937f, -0.27632076f, -0.14118548f, -0.02469755f, 
    -0.27297521f, -0.09707027f, 0.04360263f, 0.14016967f, 0.11774858f, -0.22100611f, 0.05296696f, 0.12896334f, 
    0.20417558f, 0.26646736f, -0.08701311f, 0.05206459f, -0.42617619f, 0.13718617f, 0.16692834f, -0.07127324f, 
    -0.10326563f, 0.00829983f, -0.04901114f, 0.01199595f, 0.18506394f, -0.03727822f, -0.00411698f, -0.10842653f, 
    0.12055250f, -0.02131439f, 0.11381241f, -0.04422016f, 0.11475696f, 0.01500843f, 0.04068151f, -0.11641908f, 
    -0.11454352f, 0.64510536f, -0.04211713f, -0.04026010f, -0.41000333f, -0.09194473f, -0.16124582f, -0.12137949f, 
    -0.01911612f, -0.16156860f, -0.18448187f, 0.00726844f, 0.01849960f, 0.08544609f, 0.07705054f, 0.00172134f, 
    -0.10173188f, -0.05807013f, -0.24917631f, 0.03829227f, -0.68170220f, 0.23009838f, 0.10113902f, 0.15209895f, 
    -0.00604864f, -0.03565912f, -0.08426625f, 0.17490998f, 0.00125318f, -0.02437540f, -0.09570064f, 0.07313433f, 
    -0.02332111f, -0.03920561f, 0.21379532f, 0.06709282f, 0.00991215f, -0.18285765f, 0.05870189f, -0.16131632f, 
    -0.63549423f, 0.29867706f, 0.06104692f, -0.28511181f, -0.23485076f, 0.11055961f, 0.13858372f, -0.03199136f, 
    -0.06461299f, 0.04623181f, 0.01758807f, 0.05743041f, -0.05002445f, 0.13331015f, -0.02607025f, -0.03205545f, 
    -0.30423695f, -0.01194335f, -0.11212220f, 0.02843542f, -1.27154803f, -0.18016009f, 0.23611188f, 0.38377643f, 
    0.29426986f, 0.05636875f, -0.14015098f, -0.14855894f, 0.07510936f, 0.18138824f, -0.19656502f, -0.04207978f, 
    0.10049777f, 0.19682932f, 0.12825380f, -0.11774572f, 0.10511670f, 0.22985144f, 0.27397260f, 0.02861176f, 
    -0.25977504f, -0.02056346f, 0.01375613f, 0.08231800f, 0.13785475f, 0.02886393f, -0.02518265f, 0.01888351f, 
    0.08416785f, 0.14659373f, 0.07051143f, -0.06228464f, 0.05999783f, -0.13420780f, 0.10821619f, -0.01742776f, 
    -0.01132395f, -0.03397816f, 0.01073489f, 0.15024057f, -0.59724712f, 0.29784071f, 0.02967374f, -0.27289870f, 
    -0.16823506f, 0.19839472f, -0.05028348f, -0.03958117f, -0.20652589f, -0.13492996f, 0.04821420f, 0.02920914f, 
    -0.10655849f, 0.01359451f, -0.18354559f, -0.05683932f, -0.15311280f, -0.12115758f, -0.09709910f, -0.15935813f, 
    -0.48148605f, -0.12064794f, -0.22569609f, 0.23849833f, 0.24473162f, 0.10900325f, 0.08399694f, 0.19420111f, 
    0.11837135f, 0.02845145f, -0.06570393f, -0.00098044f, 0.03241136f, 0.05646721f, 0.07672676f, -0.00217091f, 
    0.00346620f, 0.01393884f, 0.10939050f, -0.12358102f, -0.33531901f, 0.12407880f, 0.15115254f, 0.41300949f, 
    -0.11971770f, 0.16732830f, 0.04192870f, -0.17529711f, 0.17140232f, -0.26078695f, 0.11533306f, 0.05825519f, 
    -0.10512852f, -0.13955836f, 0.09105865f, 0.02211910f, -0.00002712f, -0.06719625f, 0.07625459f, -0.00814456f, 
    -0.11855802f, 0.11073702f, 0.17081070f, -0.15635966f, 0.14697273f, -0.08878595f, 0.07129441f, -0.21549179f, 
    0.08736807f, 0.17019019f, -0.02589029f, 0.00822496f, -0.06647196f, 0.08111072f, -0.06971539f, 0.02669049f, 
    0.04315648f, -0.12881081f, 0.03290664f, -0.07741918f, -0.15086462f, -0.07957231f, -0.01633031f, 0.33891755f, 
    0.17541933f, 0.06460416f, 0.13262314f, -0.02398771f, 0.18250738f, 0.02689096f, 0.14283526f, 0.04011895f, 
    -0.08765305f, -0.01341149f, 0.06687215f, -0.07363446f, 0.02678730f, 0.01774141f, 0.22460580f, 0.10233662f, 
    -0.65897113f, -0.21304533f, -0.07018572f, -0.14948513f, 0.13640736f, 0.12947358f, -0.12516478f, -0.14017725f, 
    -0.00131901f, -0.06347490f, 0.08085742f, 0.06299295f, -0.14552751f, 0.04262443f, -0.10004573f, 0.00381885f, 
    0.27255952f, 0.02550076f, -0.26848382f, 0.15367585f, 0.20863174f, -0.05035923f, 0.16616669f, 0.41387996f, 
    0.08853661f, 0.11657373f, 0.11252961f, 0.13973938f, -0.03233710f, -0.08206560f, -0.09523416f, 0.00637980f, 
    0.06972272f, 0.16239306f, 0.19714873f, 0.02119438f, -0.09935483f, 0.15779668f, 0.23807208f, -0.12370421f, 
    -0.63169479f, -0.02539049f, 0.00254473f, 0.01421366f, -0.21985285f, 0.15162075f, 0.08083566f, -0.07314464f, 
    -0.16413343f, -0.13349824f, -0.04641610f, 0.12825526f, 0.08576521f, -0.17520151f, 0.08862167f, 0.07340590f, 
    0.03571332f, -0.02521236f, 0.08714098f, -0.06475864f, -0.32894793f, -0.02356989f, 0.15413494f, 0.07037009f, 
    -0.13018239f, -0.11182523f, 0.01223376f, 0.15189761f, -0.09172846f, 0.08621629f, 0.00401993f, -0.02344141f, 
    -0.06936181f, -0.11064670f, -0.18329668f, -0.18894471f, -0.05336343f, -0.22171097f, 0.05076854f, 0.13811994f, 
    0.02783943f, -0.00712139f, 0.18493411f, -0.04572556f, 0.21895750f, 0.02623302f, -0.05039403f, -0.04364866f, 
    -0.07045195f, 0.15432332f, -0.06319875f, -0.21630816f, 0.01566800f, 0.09490355f, -0.02908131f, 0.01671490f, 
    -0.17418560f, -0.16016416f, -0.21238706f, -0.01104014f, 0.04633495f, 0.41500598f, 0.01797800f, 0.08707359f, 
    0.01624461f, -0.10156402f, 0.00313404f, -0.01479960f, -0.12986396f, 0.03494443f, -0.13302946f, 0.08274366f, 
    -0.11369006f, -0.02745255f, 0.19535388f, -0.28289890f, -0.14806254f, 0.08324868f, 0.09562685f, -0.10840942f, 
    -0.14814200f, 0.20061652f, 0.09406783f, 0.35621926f, 0.33942884f, 0.20954658f, 0.13683353f, 0.20462494f, 
    0.02647267f, 0.11591902f, 0.23521480f, -0.05696867f, -0.03342156f, 0.05515593f, 0.02611748f, -0.05545720f, 
    -0.07851873f, -0.05178166f, 0.01967237f, -0.06391807f, -0.05280606f, -0.20078643f, -0.21440355f, 0.24579534f, 
    -0.54913217f, 0.15675876f, 0.00808395f, -0.10142864f, 0.10265236f, 0.24404122f, 0.01535868f, 0.05663852f, 
    0.03275856f, -0.04913982f, -0.07445272f, -0.02923740f, -0.12146342f, 0.14215924f, -0.01774277f, -0.05877665f, 
    -0.31814080f, -0.37672338f, -0.21797790f, -0.10872084f, 0.07393045f, -0.08258163f, 0.00017411f, 0.12608582f, 
    -0.06764386f, -0.11420425f, -0.18070070f, 0.10224354f, 0.14434837f, 0.16806012f, 0.09611222f, -0.05235133f, 
    0.27554858f, 0.00216705f, 0.12890385f, 0.00641034f, 0.03825050f, 0.54480690f, -0.53244632f, -0.23337089f, 
    0.08012722f, 0.06386507f, 0.12222697f, 0.06874575f, -0.05068021f, -0.26350400f, 0.10376923f, -0.07186873f, 
    -0.11107270f, -0.00349198f, 0.02021180f, 0.06385327f, 0.02171003f, -0.08451273f, 0.06370874f, -0.02298814f, 
    -0.54625738f, -0.41926444f, -0.28838307f, -0.27046844f, 0.07515500f, 0.12542225f, 0.34263635f, -0.03134752f, 
    0.08261208f, -0.09952556f, -0.02544004f, 0.04026719f, 0.08900633f, -0.04224071f, 0.07827970f, 0.03332006f, 
    0.10905120f, -0.07168839f, -0.04168749f, 0.00977197f, -1.04096210f, 0.23555307f, 0.16815850f, 0.49826431f, 
    -0.29678631f, -0.12536198f, -0.01271847f, -0.08585837f, 0.03917927f, 0.05166195f, -0.00091868f, 0.00949820f, 
    -0.15410046f, 0.02093793f, -0.03281874f, 0.11880694f, -0.16187209f, -0.20567234f, -0.12803979f, -0.07509705f, 
    -0.59467751f, 0.14829074f, -0.09494208f, -0.15555529f, -0.06775647f, 0.22666277f, -0.02634096f, 0.06262087f, 
    0.11126696f, -0.12653627f, 0.23692653f, -0.10313062f, 0.12561975f, -0.04305355f, -0.00221627f, 0.22371590f, 
    0.06167394f, 0.10023452f, 0.03641772f, 0.15024906f, -0.31676400f, -0.10720362f, -0.18056001f, 0.17266735f, 
    0.28477249f, 0.03368950f, -0.20536084f, 0.03738862f, -0.03722911f, 0.15995522f, -0.01416677f, 0.03618799f, 
    0.20136805f, 0.16524242f, -0.02575517f, -0.21774232f, 0.09675466f, -0.33158317f, 0.02694187f, -0.18064249f, 
    -0.28603360f, 0.04847439f, -0.25943890f, -0.09666808f, -0.04678955f, 0.18482874f, -0.13918519f, 0.22015756f, 
    -0.03698079f, -0.06640095f, -0.00901606f, -0.02202098f, -0.04438072f, -0.00518231f, -0.09027798f, 0.07615016f, 
    -0.11901175f, 0.09482401f, 0.00651950f, -0.00901230f, -0.06309097f, 0.09524852f, -0.28536725f, -0.05571321f, 
    0.12519351f, 0.15564381f, -0.02904460f, -0.01000980f, -0.01357369f, 0.03011105f, 0.00801917f, 0.11627586f, 
    0.12370725f, -0.03369632f, 0.25474569f, -0.16784583f, -0.05768766f, 0.09480776f, -0.26444954f, -0.21569131f, 
    -0.54586518f, -0.17817298f, 0.03507241f, -0.24399772f, 0.11295956f, -0.07830652f, 0.05066510f, 0.07444709f, 
    -0.07071403f, 0.04912839f, 0.17280063f, -0.08267105f, -0.03757253f, 0.04858957f, -0.02329180f, -0.05463268f, 
    -0.05234263f, -0.27862719f, 0.21921216f, 0.05813706f, -0.53377920f, 0.73602766f, 0.07876906f, 0.23718834f, 
    -0.50494200f, -0.24020506f, 0.01543239f, 0.08430109f, 0.23242657f, 0.00793641f, 0.08065496f, -0.00658775f, 
    -0.01886755f, 0.03311843f, 0.02901198f, 0.01853301f, -0.08682401f, 0.03892985f, -0.20329629f, 0.02174583f, 
    0.40913326f, -0.46780655f, -0.17806926f, -0.03545550f, 0.01514693f, 0.00339973f, 0.17857103f, 0.26634446f, 
    -0.16355874f, 0.03091013f, -0.00305394f, 0.09704956f, 0.03287002f, 0.06642371f, -0.08904081f, -0.00166289f, 
    -0.06271233f, -0.03460222f, -0.22722812f, 0.11376514f, -0.29169858f, 0.02304153f, -0.03398811f, 0.35390750f, 
    0.03307959f, -0.04199504f, 0.23797192f, -0.22614352f, 0.25578016f, -0.20808914f, -0.11744766f, 0.09806976f, 
    0.07496300f, -0.00561769f, 0.13650584f, 0.10687302f, 0.05417557f, 0.30705240f, -0.12045298f, -0.06633153f, 
    -0.20724960f, 0.09567190f, -0.14796865f, 0.12999991f, -0.34452862f, 0.12197886f, 0.24058428f, 0.00487700f, 
    0.03668993f, 0.17097127f, 0.10454828f, 0.04302141f, -0.05702763f, 0.05874442f, -0.21849221f, -0.01825193f, 
    0.10848664f, 0.01112870f, 0.03858871f, 0.11848968f, 0.24221671f, -0.31037614f, 0.22245941f, -0.08058778f, 
    0.38635814f, 0.36224467f, 0.00274741f, -0.13462301f, 0.03887190f, -0.07617281f, -0.07987843f, -0.14279297f, 
    0.09095823f, 0.27371532f, 0.10942328f, 0.19614269f, 0.07803094f, -0.25481987f, -0.06540439f, 0.01727234f, 
    0.04409749f, -0.52426237f, 0.00115918f, -0.13661924f, 0.49490774f, -0.21218246f, -0.00878816f, -0.00592055f, 
    0.05875764f, 0.00635218f, -0.07403449f, -0.07697953f, -0.08143617f, -0.03048876f, -0.09817991f, -0.06231111f, 
    0.04560852f, 0.12830697f, -0.10103115f, 0.05389373f, 0.32215098f, -0.52443063f, 0.25397578f, 0.03418079f, 
    -0.01887529f, 0.13153972f, -0.13585016f, 0.19803604f, -0.13157918f, -0.03134638f, -0.05138492f, 0.10830382f, 
    -0.20852047f, -0.05074280f, -0.07619179f, -0.15242358f, 0.01645622f, 0.22125301f, -0.00242314f, -0.23654287f, 
    0.36236021f, -0.00534974f, -0.23884353f, 0.05378571f, 0.05552841f, 0.01013372f, 0.07278055f, 0.06374403f, 
    -0.01125418f, -0.07101394f, 0.09482694f, -0.04923073f, -0.11568435f, -0.17904401f, -0.05662414f, -0.18956114f, 
    -0.08135806f, 0.00198358f, -0.17137498f, 0.11202086f, 0.16243128f, -0.68346804f, -0.05199940f, -0.50879967f, 
    0.02249843f, 0.04694638f, 0.22485571f, 0.07563800f, 0.10571001f, -0.23857725f, 0.07591137f, 0.04410064f, 
    0.10356174f, 0.13898368f, -0.05686370f, 0.29877496f, 0.00238290f, -0.12468603f, -0.22936028f, 0.18019141f, 
    0.01214155f, 0.16434278f, -0.02900857f, -0.60750318f, 0.15455951f, -0.15946710f, -0.14917126f, -0.05162516f, 
    -0.12226131f, -0.11200747f, -0.07390235f, 0.08403644f, -0.04094841f, 0.19649573f, 0.01044999f, 0.03516650f, 
    0.03881036f, -0.08713967f, 0.00364746f, 0.05815955f, 0.46153492f, -0.36654812f, 0.06617618f, 0.10304313f, 
    0.67208737f, 0.12269149f, -0.05279076f, 0.12160251f, -0.11670905f, 0.00158026f, -0.15629150f, -0.07485643f, 
    -0.01292451f, -0.05248885f, 0.12427728f, -0.02536142f, -0.15385368f, 0.30765027f, 0.23993510f, 0.07989687f, 
    0.09179525f, -0.79662830f, -0.17927739f, -0.08353102f, -0.11517010f, -0.22329065f, 0.14289148f, 0.04647103f, 
    -0.06097441f, 0.08759107f, 0.00442992f, 0.04179481f, -0.12531735f, 0.06556425f, 0.10484824f, -0.22085284f, 
    -0.04175071f, -0.19859110f, -0.03497889f, -0.29576340f, 0.06202665f, 0.02785666f, -0.00981324f, -0.44944614f, 
    0.17895561f, -0.17447679f, 0.04668423f, 0.03236677f, -0.19902715f, -0.15788679f, -0.15185459f, -0.07489578f, 
    -0.18031275f, 0.01259790f, -0.10103605f, -0.02425655f, -0.03373681f, 0.14146897f, 0.17273381f, 0.03836907f, 
    0.13165471f, -0.41933730f, -0.09436361f, 0.13149405f, -0.12859581f, 0.12048169f, -0.06109504f, 0.00215582f, 
    -0.12175915f, -0.08120965f, -0.08358169f, 0.00755210f, 0.10198783f, -0.06431080f, 0.11285654f, 0.02977419f, 
    0.09031212f, 0.20518252f, 0.03453934f, 0.08164749f, -0.21131523f, 0.11646939f, -0.35247833f, -0.61252290f, 
    0.27274063f, 0.13473234f, -0.05166478f, 0.13218240f, -0.15942794f, 0.05285989f, -0.13208817f, -0.05270504f, 
    -0.13360763f, -0.10266344f, 0.04352388f, 0.17293915f, -0.12049393f, 0.12143371f, 0.21883667f, 0.08895092f, 
    0.38180882f, -0.32403806f, 0.21518667f, -0.08257509f, -0.07079867f, 0.00449491f, -0.06543469f, -0.13331839f, 
    -0.12428488f, 0.03983380f, -0.09293222f, 0.08087470f, 0.00148219f, 0.00283017f, -0.08484614f, -0.06222111f, 
    0.05212550f, -0.09121688f, 0.02689448f, -0.08985906f, -0.30817276f, -0.15311743f, -0.27375922f, -0.50714463f, 
    -0.28644350f, 0.03647187f, -0.16139077f, -0.12181106f, -0.04417465f, -0.22252147f, -0.25586998f, -0.07754111f, 
    -0.07310672f, 0.01344593f, -0.16397738f, -0.00191528f, -0.26870406f, -0.05570101f, -0.05266179f, 0.02225225f, 
    0.10439413f, 0.19692831f, 0.25067648f, 0.19554740f, 0.19761112f, 0.21362539f, 0.30876905f, -0.01596452f, 
    0.00024101f, -0.05284442f, -0.05098394f, -0.04868178f, -0.00932149f, -0.06972173f, -0.01414964f, -0.07277720f, 
    0.02278048f, -0.05113224f, 0.04726434f, 0.04938838f, -0.44256964f, 0.10499576f, 0.07563980f, 0.05331647f, 
    -0.14010589f, 0.04702415f, -0.25009504f, -0.05215018f, 0.14562541f, -0.09293047f, 0.00731117f, 0.02770052f, 
    -0.05576611f, 0.02718971f, -0.21388894f, 0.15058070f, 0.08539319f, 0.15594922f, -0.02147500f, -0.03227175f, 
    -0.05065338f, 0.38662568f, -0.13275383f, -0.17877948f, 0.27570689f, 0.13224539f, 0.17159264f, -0.30947489f, 
    -0.13804288f, 0.09581655f, -0.14626418f, 0.14118710f, 0.04287483f, -0.06102369f, -0.01945561f, 0.01454989f, 
    -0.04741416f, -0.03055535f, 0.03103567f, 0.04844999f, -0.01929341f, -0.21565486f, 0.05945020f, -0.30103344f, 
    -0.02920621f, -0.24504912f, 0.09260328f, 0.08517143f, 0.07852085f, -0.03231734f, 0.03585052f, 0.04266820f, 
    -0.05267361f, 0.07403268f, 0.02458534f, -0.01366812f, -0.10699239f, -0.10979038f, -0.03282379f, -0.11005092f, 
    -0.22926962f, 0.10367958f, -0.32469237f, -0.05285102f, 0.06367102f, -0.23445645f, 0.06268138f, -0.03178491f, 
    -0.00990184f, 0.04275191f, -0.02552653f, 0.03792831f, -0.24064603f, -0.07204571f, 0.03712299f, -0.02901659f, 
    0.01095509f, 0.12321968f, -0.19674358f, -0.17019679f, 0.59284514f, -1.00555408f, 0.20252800f, 0.05061148f, 
    -0.52666295f, 0.14970349f, 0.04105015f, -0.16724789f, -0.11518985f, 0.00678273f, -0.04151179f, 0.15647249f, 
    -0.08906483f, -0.01499648f, -0.22471780f, -0.01027357f, 0.19426446f, -0.12914728f, -0.03353642f, -0.01723044f, 
    -0.05699666f, 0.19727400f, 0.23701021f, 0.03766596f, 0.00074000f, -0.26132819f, 0.10492355f, 0.00165172f, 
    0.09390425f, 0.06198786f, 0.13015293f, 0.11219691f, -0.04449043f, -0.03882014f, -0.06974211f, -0.00750435f, 
    -0.01608270f, -0.06424771f, 0.11179309f, -0.06362344f, 0.00914303f, 0.18681765f, 0.48280799f, 0.01140326f, 
    0.16898577f, -0.05828327f, 0.21387956f, -0.10476774f, 0.17515865f, -0.07438199f, -0.02616803f, 0.02991167f, 
    0.18615544f, -0.02363048f, -0.29852667f, -0.08270857f, -0.08004449f, -0.04187442f, 0.05573069f, -0.10630998f, 
    -0.12278435f, 0.24302655f, 0.25310180f, 0.23080087f, 0.18069007f, 0.04500824f, -0.02797358f, 0.03073743f, 
    0.12878773f, -0.09428099f, -0.16270202f, 0.03803838f, -0.14279163f, -0.02769636f, -0.03699817f, 0.04331566f, 
    -0.02900350f, 0.04523407f, 0.07882271f, -0.16717581f, 0.03295648f, -0.00282484f, -0.24235085f, 0.12740204f, 
    0.42747977f, -0.06465709f, -0.03495293f, -0.16447423f, 0.28516716f, -0.02252379f, -0.00981391f, 0.06021360f, 
    -0.23113877f, 0.09062743f, 0.00999476f, 0.02897819f, -0.29800057f, 0.06000554f, -0.12441886f, -0.06602140f, 
    -0.20751475f, -0.25249439f, 0.06917239f, -0.07380829f, -0.09367717f, -0.02824092f, -0.08646693f, -0.03994563f, 
    -0.05814042f, -0.14052597f, -0.06550299f, -0.14085734f, 0.05752965f, -0.04852451f, -0.07133537f, -0.05622944f, 
    -0.05684577f, -0.01898546f, 0.04027382f, -0.00922100f, 0.28911456f, 0.01442275f, 0.23425882f, -0.07540459f, 
    0.36407933f, -0.02302019f, 0.03956803f, -0.17589568f, 0.06016346f, 0.00376273f, -0.09762507f, -0.05873937f, 
    -0.14466166f, -0.05260265f, 0.03288469f, -0.11881822f, 0.03649395f, 0.13792489f, -0.00126089f, -0.14303260f, 
    0.18087456f, -0.23456150f, 0.17219669f, 0.13141939f, 0.47053623f, 0.17215085f, 0.09897128f, -0.19889259f, 
    0.04438105f, 0.02891015f, -0.02290733f, -0.00860589f, -0.08247387f, -0.10547367f, -0.04927761f, -0.11011250f, 
    -0.04959611f, -0.06115199f, -0.00148036f, -0.19602850f, 0.18540944f, 0.21483631f, 0.24815413f, 0.08698901f, 
    0.33561286f, 0.08343767f, 0.12455514f, -0.03844814f, -0.16123204f, -0.02980233f, -0.08357611f, 0.00249776f, 
    -0.21278545f, -0.04451967f, -0.02694676f, -0.05035367f, -0.13470285f, -0.07330161f, 0.05890122f, 0.02238616f, 
    0.03015703f, 0.02879201f, 0.18688874f, -0.21183628f, 0.11725508f, 0.08808588f, -0.09499360f, 0.05667226f, 
    0.09753946f, -0.02253022f, -0.06513445f, 0.10134317f, 0.17340268f, 0.08864949f, -0.04392432f, 0.05403050f, 
    -0.11542031f, 0.12694938f, -0.25895101f, 0.07396108f, 0.21726266f, 0.05449128f, -0.07778280f, 0.25241461f, 
    0.37827533f, 0.17844389f, 0.23676836f, -0.24347532f, -0.10761442f, -0.04846161f, 0.07100265f, 0.00993601f, 
    0.04895199f, -0.08213820f, 0.07798495f, -0.22519225f, 0.07859366f, 0.06589098f, 0.18737724f, -0.13210055f, 
    -0.42803693f, -0.66796565f, 0.31019232f, -0.26549569f, -0.25143901f, -0.18900880f, -0.12096332f, 0.05449534f, 
    -0.05020610f, -0.12478510f, 0.09473024f, -0.00382321f, 0.08731306f, -0.07024487f, 0.05794220f, 0.08027498f, 
    -0.21939313f, -0.06741229f, -0.01511888f, 0.07049558f, 0.02467076f, 0.21757750f, -0.32265905f, 0.18593161f, 
    -0.13163576f, 0.06082531f, 0.02380502f, -0.37719107f, 0.04664973f, 0.06218476f, 0.06109719f, -0.11127944f, 
    -0.00972223f, 0.03980763f, -0.01150320f, 0.04599592f, -0.00022994f, -0.11404701f, 0.18667910f, 0.03345539f, 
    -0.40673363f, -0.04855873f, -0.45031536f, -0.64901209f, -0.50669152f, 0.04687006f, -0.04963554f, -0.19665536f, 
    0.07873105f, -0.23650596f, 0.23780736f, 0.00414183f, -0.03073244f, 0.01781972f, 0.19891457f, -0.06933976f, 
    0.02510614f, -0.23458068f, 0.11530514f, 0.03641516f, 0.11557288f, 0.27393013f, 0.05737204f, -0.16293930f, 
    0.06609618f, 0.02368501f, 0.05439432f, 0.00803679f, -0.14587010f, -0.14572321f, 0.25946882f, -0.03608947f, 
    -0.02671278f, -0.11343363f, 0.04685933f, -0.15400772f, -0.01575448f, 0.07123700f, 0.01406982f, -0.19680762f, 
    0.28989089f, 0.30065989f, 0.14644739f, -0.07198021f, -0.06304589f, -0.18225227f, -0.11578476f, 0.15707828f, 
    -0.19435687f, 0.00343733f, 0.21443276f, -0.16383578f, 0.08195619f, -0.06643999f, -0.22210695f, -0.15969208f, 
    0.03421402f, -0.25940278f, 0.21486460f, -0.08022466f, 0.18409364f, -0.16157004f, -0.02704881f, 0.05774959f, 
    0.15068829f, -0.00740366f, 0.02616829f, -0.09553621f, -0.15443777f, 0.10566544f, -0.05580814f, 0.01045610f, 
    0.00390921f, -0.13032533f, 0.01876810f, 0.11349745f, 0.08239566f, -0.04861189f, 0.13065441f, 0.24255912f, 
    0.07293677f, -0.34206164f, 0.13519225f, -0.09995418f, -0.30429327f, -0.07939762f, 0.00665455f, 0.14786145f, 
    0.09364668f, 0.01104394f, 0.07654787f, 0.15354089f, -0.01240345f, 0.10093971f, -0.01436110f, -0.01571205f, 
    -0.08640844f, -0.07144974f, 0.04107881f, -0.01694859f, 0.20246145f, 0.04992425f, 0.14503220f, -0.03950575f, 
    0.26160935f, -0.01595141f, -0.11006634f, 0.17469917f, -0.06732938f, 0.04302987f, 0.08100423f, 0.00373111f, 
    -0.23433274f, -0.11650747f, 0.20408034f, 0.12664686f, -0.01865166f, 0.01060151f, 0.13000254f, -0.08295044f, 
    -0.51453936f, -0.21610038f, 0.49898103f, -0.06770670f, 0.01840937f, -0.03438111f, 0.03088529f, 0.01983192f, 
    -0.00680446f, -0.01512288f, 0.09083501f, 0.10093375f, -0.03921589f, -0.04557566f, -0.00463643f, -0.14033169f, 
    0.07119413f, -0.00408123f, 0.04820451f, 0.06091618f, -0.27671117f, 0.02163299f, 0.09528943f, -0.08609733f, 
    0.07484916f, -0.04291570f, -0.15138869f, -0.28322101f, -0.02144889f, -0.34701389f, 0.20728992f, -0.01414519f, 
    -0.07871403f, 0.09533913f, -0.03983134f, -0.13887286f, -0.00047842f, 0.03519680f, -0.17778873f, -0.01441379f, 
    0.24331893f, 0.09346746f, 0.14955990f, 0.16344675f, 0.33139843f, -0.16835622f, -0.22105671f, 0.01056525f, 
    -0.26991192f, -0.03212665f, -0.14280799f, -0.19703189f, -0.04422716f, -0.06529671f, -0.05087637f, 0.07574986f, 
    -0.02062462f, 0.06791402f, -0.01049237f, 0.13067439f, -0.07247581f, 0.34610835f, -0.29072171f, -0.17565779f, 
    -0.45076397f, -0.33915722f, 0.05193429f, 0.02231799f, -0.06671314f, -0.17081749f, 0.06104225f, 0.09184288f, 
    0.02524601f, 0.02906668f, 0.00654110f, 0.00090826f, -0.17098404f, -0.31930420f, -0.10652710f, 0.22703753f, 
    -0.31078473f, -0.41427419f, 0.30720240f, 0.10176200f, 0.19100645f, 0.01882052f, 0.00089322f, 0.01689331f, 
    -0.09129258f, 0.03897083f, 0.03833697f, 0.00002248f, -0.04591784f, -0.01674722f, -0.01486307f, 0.00520236f, 
    -0.01951701f, 0.15328255f, -0.20028836f, 0.22983912f, -0.45179251f, -0.20687848f, 0.31353831f, -0.71003664f, 
    -0.36363545f, 0.17268209f, 0.16986744f, -0.10172202f, -0.00870474f, -0.18291900f, 0.04811294f, 0.10387675f, 
    -0.07731307f, 0.01516110f, -0.01644121f, -0.03296049f, 0.17383897f, 0.06191051f, -0.60261887f, -0.11617988f, 
    0.22008359f, -0.21801701f, -0.05226250f, 0.10618820f, -0.16616422f, -0.19801675f, -0.31109828f, -0.01981666f, 
    0.22522597f, -0.01742357f, -0.09745558f, -0.03298683f, 0.00413082f, -0.17961639f, -0.11458235f, -0.06213045f, 
    0.16826978f, -0.10512441f, 0.10905445f, -0.20220506f, -0.13639228f, -0.01038673f, 0.27759707f, -0.40106365f, 
    -0.30181006f, 0.06446922f, 0.14104113f, -0.03721976f, -0.17782696f, -0.12311044f, -0.00847727f, 0.02918189f, 
    -0.01052365f, -0.18862309f, 0.04937974f, -0.00955052f, 0.04109186f, -0.15517479f, -0.05689073f, -0.00611263f, 
    -0.53109390f, -0.27523962f, -0.30000031f, 0.21510564f, 0.37320426f, 0.28053248f, -0.11075045f, -0.05954340f, 
    0.01161406f, 0.31045347f, 0.07726894f, -0.20800894f, 0.08473822f, 0.09112117f, -0.00910388f, 0.14827049f, 
    0.16470811f, -0.06145590f, 0.01273310f, -0.19674428f, -0.33218011f, -0.50828528f, 0.39223105f, 0.02388183f, 
    0.22877878f, 0.07358958f, 0.00824185f, 0.05310695f, 0.04322695f, -0.15059660f, 0.03565273f, 0.01440685f, 
    -0.15221860f, -0.04836924f, -0.01389585f, 0.08683029f, -0.05245362f, 0.02304318f, -0.04726475f, 0.13101049f, 
    -0.43706197f, 0.01117458f, 0.20227185f, 0.03395836f, -0.39882964f, 0.05821473f, -0.03491227f, 0.05655201f, 
    -0.07666375f, 0.08500103f, 0.02893468f, 0.04672625f, 0.06357192f, 0.11305858f, 0.11759505f, -0.06450401f, 
    0.06965779f, -0.00371877f, 0.09449508f, -0.00588070f, 0.36118245f, -0.08177070f, -0.52495575f, 0.22168434f, 
    -0.24134396f, 0.05416759f, 0.14911330f, -0.00365965f, -0.07089082f, 0.16405140f, -0.06935522f, -0.00603875f, 
    -0.00558902f, 0.11841470f, -0.13439125f, 0.27403489f, -0.02002990f, -0.02392768f, 0.09763109f, 0.13057601f, 
    -0.14759551f, 0.25095600f, -0.46981558f, 0.38963443f, -0.46655664f, 0.23282999f, 0.17761907f, 0.07996511f, 
    -0.06041373f, -0.09449612f, -0.18927832f, 0.02819073f, 0.08906616f, 0.04299607f, 0.10965931f, 0.03570533f, 
    -0.01843589f, 0.08910371f, 0.05761822f, -0.12344699f, 0.76886910f, -0.86708748f, 0.41792148f, -0.10173961f, 
    0.05469139f, 0.08657928f, -0.02621467f, -0.06713922f, 0.02869075f, -0.10996966f, 0.02156996f, -0.13311088f, 
    -0.09959237f, 0.00582602f, 0.05336193f, -0.11305083f, -0.11966133f, -0.24178837f, -0.03404735f, 0.12546113f, 
    -0.42032692f, 0.15850867f, -0.31125185f, 0.21018547f, 0.48780546f, 0.02690149f, -0.03183480f, -0.16360645f, 
    0.10099588f, 0.11548166f, 0.18079786f, 0.05375583f, -0.07489126f, 0.01286932f, -0.12830371f, -0.00803515f, 
    -0.06764020f, 0.08076491f, -0.07326408f, 0.15773596f, -0.13047405f, -0.17077042f, -0.07702334f, -0.15494436f, 
    0.01865971f, 0.17539729f, 0.17245568f, 0.00421727f, -0.09355062f, 0.41856554f, -0.12915076f, -0.18829927f, 
    -0.04961605f, 0.02377233f, 0.14949368f, 0.11667816f, -0.12591803f, -0.00679451f, -0.01776542f, -0.17523982f, 
    -0.16090542f, -0.44184297f, 0.07299894f, 0.29487196f, -0.04421747f, -0.00191679f, -0.02723076f, -0.01216573f, 
    -0.01816106f, 0.26488268f, -0.24845743f, -0.02999428f, 0.04493498f, -0.03977014f, 0.08510293f, 0.09457924f, 
    -0.18079433f, 0.19394074f, -0.04195985f, -0.07346485f, 0.95238674f, -0.35258263f, -0.57385021f, -0.40860060f, 
    -0.21584697f, -0.04187078f, 0.01088383f, 0.27652815f, 0.03230796f, -0.16478775f, -0.23826173f, -0.12329216f, 
    -0.01909617f, 0.19211231f, -0.27109280f, 0.09240439f, 0.19539650f, -0.05462594f, -0.00919903f, 0.17196721f, 
    0.24179536f, -0.13282189f, 0.01727165f, -0.06911703f, -0.06882223f, 0.21062247f, -0.06777261f, -0.10909772f, 
    -0.07649518f, 0.08980616f, -0.05948250f, 0.11485053f, -0.04951866f, 0.00946941f, -0.03018251f, -0.29908916f, 
    -0.11365723f, -0.15358816f, -0.14117356f, 0.00607654f, -0.33875555f, 0.06620637f, -0.21677369f, -0.01830707f, 
    0.07253609f, -0.06918474f, -0.01055613f, -0.03953854f, -0.01279370f, 0.04875501f, -0.01003542f, 0.07636908f, 
    -0.17282084f, -0.06551635f, 0.11209850f, 0.03591147f, 0.04294304f, 0.18620621f, -0.03047842f, 0.23709995f, 
    0.56561565f, -0.05858982f, -0.19200058f, -0.09210879f, 0.11701017f, 0.02253003f, -0.00020542f, 0.18442500f, 
    -0.15432397f, 0.01046118f, 0.15538023f, 0.07778650f, 0.04014241f, 0.03231338f, 0.04392585f, 0.03507114f, 
    0.06036289f, -0.12928371f, 0.20135556f, -0.05806481f, 0.12334768f, -0.12801979f, -0.14426132f, 0.16195232f, 
    -0.24760993f, -0.25877833f, 0.19754186f, -0.07896664f, 0.01478276f, 0.02478626f, 0.01318388f, -0.04806567f, 
    0.11568799f, -0.01032132f, 0.07427705f, 0.06150070f, 0.13072330f, 0.01793754f, 0.04564949f, 0.06969358f, 
    0.02945226f, 0.24181572f, -0.03606500f, -0.04367040f, 0.18173334f, -0.04899378f, 0.16505624f, -0.00874800f, 
    0.10681107f, -0.06024917f, -0.02459017f, 0.07936084f, 0.01331535f, 0.01874322f, 0.06634730f, 0.02978536f, 
    0.23198871f, 0.23560761f, -0.01772883f, 0.17646666f, -1.49511766f, -0.72102928f, -0.27561158f, -0.43361256f, 
    -0.50792301f, 0.00667544f, 0.09416964f, -0.07434341f, -0.20333135f, 0.13170333f, 0.25582442f, 0.02061829f, 
    -0.08347135f, 0.06481739f, 0.07931255f, 0.12066481f, -0.10874581f, -0.04935257f, 0.01676514f, -0.05663305f, 
    0.15275571f, 0.33788857f, -0.22450525f, 0.23611908f, -0.13596809f, -0.14584789f, -0.05923633f, -0.03792109f, 
    -0.16249003f, -0.01370176f, -0.02607808f, -0.00996766f, 0.08179601f, -0.09402803f, 0.04836551f, -0.13950475f, 
    -0.13336734f, 0.09114413f, -0.20321734f, 0.00173019f, -0.20793737f, -0.01121539f, -0.41874266f, 0.03747500f, 
    0.04954126f, 0.02735521f, 0.00942356f, 0.00962238f, -0.04053964f, 0.01407025f, 0.05999698f, 0.02161831f, 
    0.10072778f, -0.15260054f, 0.28830403f, 0.04180688f, 0.03814309f, -0.05216829f, -0.02593393f, -0.14867690f, 
    -0.80072260f, -0.47764781f, 0.21683666f, 0.32133359f, 0.17357552f, 0.06076516f, -0.01421671f, 0.08588667f, 
    0.02025166f, -0.17415054f, -0.03014432f, 0.01173422f, 0.07517999f, 0.26827237f, -0.06762176f, 0.01784781f, 
    0.07180347f, -0.22536315f, -0.18113564f, -0.07999883f, 0.05280958f, -0.57761401f, -0.03462918f, 0.04810397f, 
    0.07422044f, -0.25165874f, 0.03438545f, -0.01830281f, -0.18571083f, -0.14979590f, -0.05418707f, -0.04185189f, 
    -0.11333372f, -0.30294952f, 0.14967291f, -0.34996361f, -0.08569390f, -0.03425533f, 0.07138585f, 0.05854173f, 
    -0.55243498f, -0.29375404f, 0.01262057f, -0.06396165f, -0.18151234f, 0.06604131f, 0.06631609f, 0.07880541f, 
    0.01606896f, 0.10298520f, 0.26550165f, 0.02642883f, 0.14993970f, -0.21403334f, -0.04255889f, 0.03806359f, 
    -0.02283414f, -0.05026544f, 0.27626869f, 0.12958059f, -0.73551214f, -0.07592630f, -0.52571583f, -0.17291002f, 
    0.21483935f, 0.01710086f, 0.07748698f, -0.19133385f, 0.07801766f, 0.29492870f, 0.05154439f, 0.10880604f, 
    -0.01999202f, -0.17026453f, 0.03520548f, 0.31571174f, 0.08930159f, 0.17509535f, -0.00205804f, 0.22278166f, 
    0.21680044f, 0.29331440f, -0.44945711f, -0.04624001f, -0.03980603f, -0.03684456f, -0.21319497f, -0.01110619f, 
    0.03068813f, 0.02760450f, 0.13318069f, -0.08962409f, 0.08381005f, -0.07921321f, 0.05384107f, 0.09800713f, 
    0.08915475f, 0.19508711f, 0.27489036f, 0.13936560f, 0.63437265f, -0.14395313f, -0.25033593f, -0.04053894f, 
    -0.07369165f, -0.27893880f, -0.08204061f, -0.05517255f, 0.12791193f, -0.07253051f, 0.01037636f, 0.14050157f, 
    -0.13469958f, -0.27145219f, -0.13113606f, -0.23471978f, -0.06822770f, -0.16901615f, -0.18727301f, -0.02515221f, 
    0.32728887f, 0.16414344f, 0.23611073f, 0.00926236f, -0.16873991f, -0.11009504f, -0.20240819f, 0.18314888f, 
    -0.02429233f, -0.11487579f, 0.14289483f, 0.02606640f, 0.08407809f, -0.06230940f, -0.04425125f, 0.03002914f, 
    -0.10345744f, 0.03470061f, -0.09678794f, 0.10578492f, -0.56355959f, -0.18395577f, 0.25129882f, 0.19333781f, 
    0.01912788f, -0.03679446f, -0.06291042f, -0.01269145f, -0.02673867f, 0.08007203f, 0.07722889f, -0.04202194f, 
    0.08331423f, -0.16333653f, 0.15694404f, -0.07697539f, 0.00605402f, 0.00955618f, -0.12321499f, 0.19533752f, 
    0.31103018f, 0.20439112f, -0.23022781f, -0.11356112f, -0.02442542f, -0.20802508f, -0.11352734f, 0.08807661f, 
    0.10520712f, -0.02969312f, 0.03528574f, -0.01749828f, -0.12312971f, -0.05234648f, 0.10592495f, -0.00272993f, 
    0.08164266f, 0.08860411f, 0.05094838f, -0.02738065f, 0.39279431f, 0.07611049f, -0.12221305f, 0.04036576f, 
    -0.09191891f, 0.07434376f, 0.18358818f, -0.08648077f, 0.28381291f, 0.15328707f, 0.03223004f, 0.05509383f, 
    0.07405128f, 0.01325728f, -0.04863427f, 0.12722340f, 0.16110200f, -0.34709483f, -0.00843333f, 0.04442960f, 
    -0.01101587f, 0.22819516f, -0.07912855f, 0.04928403f, -0.04568310f, 0.06375609f, 0.10910217f, -0.05859846f, 
    -0.07493787f, 0.01058990f, 0.09633789f, 0.08911137f, 0.01016466f, -0.09529062f, -0.03020562f, -0.08816480f, 
    0.14155371f, 0.22088480f, -0.11369482f, 0.09717251f, 0.42635548f, 0.14076866f, 0.01274462f, -0.08375861f, 
    -0.04433149f, 0.00620920f, -0.02931597f, 0.17069675f, 0.02097033f, -0.03123066f, 0.00669509f, -0.11405778f, 
    0.00379753f, -0.02342059f, -0.13104731f, -0.01286452f, -0.10504966f, -0.48649317f, -0.24338099f, -0.11364608f, 
    -0.41867900f, 0.34738243f, 0.10346211f, -0.01722030f, 0.02599771f, -0.23406051f, -0.01524338f, 0.11733631f, 
    -0.27266979f, -0.00329022f, -0.11236185f, -0.05527259f, -0.17225227f, -0.20080979f, -0.10107850f, 0.04035033f, 
    0.12285528f, 0.06242976f, 0.15413895f, -0.11037807f, 0.83464152f, -0.16036843f, -0.71482486f, -0.22180283f, 
    -0.47222179f, 0.12938382f, 0.00284839f, -0.03369293f, -0.07341082f, 0.00206786f, 0.26395682f, 0.15935840f, 
    0.09396955f, 0.05196812f, -0.01801387f, 0.08001776f, -0.03055055f, 0.01633476f, 0.01247308f, 0.10037936f, 
    -0.00362061f, -0.06986547f, 0.23125069f, 0.16945755f, 0.33208171f, -0.07245716f, -0.02265382f, 0.04175906f, 
    0.16461158f, -0.14103965f, 0.04402767f, -0.09996440f, -0.05660956f, 0.09146141f, 0.09539648f, 0.12613650f, 
    -0.04875310f, -0.01890672f, -0.10231774f, 0.11973190f, 0.18817271f, 0.00887997f, -0.28542283f, 0.05200780f, 
    -0.23525821f, 0.02938044f, 0.15479901f, 0.03577511f, -0.23397349f, -0.08861946f, -0.04245855f, -0.08552761f, 
    0.04768362f, -0.09305939f, -0.16281782f, 0.07567210f, -0.13688385f, 0.10835373f, -0.10085721f, -0.18617824f, 
    -0.24772219f, 0.92668182f, -0.25783578f, 0.02808958f, 0.34227785f, 0.30737400f, 0.02805159f, -0.10088152f, 
    -0.04813626f, -0.01548609f, 0.17252669f, 0.20329225f, -0.08088925f, -0.05181345f, 0.13266616f, 0.15723078f, 
    0.16832407f, 0.02889250f, -0.15638489f, 0.17059653f, -0.69764662f, -0.01750151f, -0.23702647f, -0.16281079f, 
    -0.18699017f, 0.18926452f, -0.14058499f, 0.24012727f, 0.12773159f, 0.20705642f, 0.04157897f, -0.08643369f, 
    -0.11816547f, 0.17910539f, -0.12428021f, -0.06493139f, 0.07816782f, 0.02991544f, 0.03372427f, 0.09387511f, 
    -0.30398640f, -0.22841822f, -0.06145640f, -0.02378873f, 0.00133251f, 0.22504668f, 0.10396934f, 0.13043430f, 
    -0.12820730f, 0.29108632f, -0.13883308f, 0.14917724f, -0.33444342f, 0.06835709f, 0.02429273f, -0.00825339f, 
    0.11409429f, 0.04974481f, -0.14209655f, -0.09385490f, -0.21293297f, 0.48388532f, -0.15872563f, 0.13288960f, 
    0.08579886f, -0.13691625f, 0.00439308f, -0.12637441f, 0.16233823f, -0.10658975f, -0.10429511f, -0.01460607f, 
    0.07318757f, -0.07662658f, -0.03939341f, 0.07878284f, -0.02760882f, -0.22912006f, -0.08387733f, 0.11110363f, 
    0.24048823f, -0.06055154f, 0.09929986f, 0.44178569f, -0.08133328f, 0.11545806f, 0.08593561f, 0.19549103f, 
    0.11947858f, -0.07315926f, -0.04451926f, -0.25056967f, -0.04454706f, 0.15638708f, -0.08250546f, 0.12095420f, 
    -0.02415717f, 0.16108587f, -0.03633889f, -0.08457917f, -0.05837926f, -0.12325542f, 0.02058851f, 0.05161347f, 
    -0.08689035f, 0.01193172f, -0.03991795f, 0.04113598f, -0.10784544f, -0.26268929f, -0.03175513f, -0.12085102f, 
    0.10427519f, -0.00319656f, 0.03402073f, -0.06325935f, -0.16186285f, -0.09197083f, -0.10079237f, 0.07450710f, 
    0.63795811f, -0.08436613f, -0.00592642f, -0.28447196f, 0.12548338f, -0.11902198f, 0.05132308f, 0.00345096f, 
    -0.05982913f, -0.28753793f, 0.08392133f, -0.01877065f, -0.03416857f, 0.10163213f, -0.12061611f, -0.14428037f, 
    -0.02731903f, 0.06716540f, -0.04637060f, -0.04735061f, -0.46811736f, -0.16490239f, -0.10720464f, -0.34579718f, 
    0.48367921f, -0.03004315f, -0.31309730f, -0.12581158f, 0.23098075f, 0.08381715f, -0.03596825f, 0.02109100f, 
    0.00396215f, 0.19534540f, 0.10284689f, 0.05563601f, 0.31391102f, -0.07557473f, -0.03348673f, -0.18716212f, 
    -0.26497898f, -0.43180037f, 0.09594206f, -0.19473042f, 0.14282815f, 0.12189663f, 0.06630308f, -0.02447707f, 
    0.05144780f, 0.04829198f, -0.08452594f, 0.06998455f, 0.03575687f, -0.07455301f, -0.16923594f, -0.16925381f, 
    -0.26180825f, 0.03208008f, -0.18887995f, -0.13495189f, -0.14600317f, 0.14470032f, -0.41239026f, -0.12685619f, 
    0.16782981f, 0.07120243f, -0.06928942f, -0.08538575f, -0.03731514f, -0.13531530f, 0.17359443f, 0.14535849f, 
    0.00550679f, -0.09409811f, -0.09231771f, 0.01516585f, -0.01057553f, 0.10452583f, 0.03779034f, -0.14349481f, 
    -0.55455905f, 0.44454479f, -0.12366157f, -0.20277420f, 0.24719371f, -0.09253212f, 0.16795610f, -0.11026131f, 
    0.03951788f, -0.02170932f, -0.01858320f, -0.04963154f, 0.04997650f, 0.02168125f, 0.14756261f, -0.02748007f, 
    -0.15931970f, 0.06173809f, -0.13617964f, -0.20140693f, 0.16556475f, 0.03910693f, -0.22936179f, -0.28117776f, 
    0.12979847f, -0.20239468f, -0.31526890f, 0.09345004f, -0.13547561f, -0.15540297f, 0.01104751f, 0.03908582f, 
    -0.06149628f, 0.07420740f, 0.03910031f, 0.19279312f, -0.19806612f, 0.02423563f, 0.20806274f, 0.09127966f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08155970f, 0.11487322f, -0.10608571f, -0.01974531f, -0.02946555f, 0.08248433f, -0.04225538f, -0.10379553f, 
    -0.03135249f, 0.03955724f, 0.13103370f, 0.04267951f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
