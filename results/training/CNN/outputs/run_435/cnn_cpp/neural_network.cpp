#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.26193309f, -1.47767210f, -0.80708724f, 0.19656655f, -0.65678412f, 0.62428749f, 0.19748741f, -0.01755449f, 
    0.63617116f, -1.26793635f, -0.67424983f, -0.43980876f, -0.43241620f, 0.49344262f, -0.41734812f, -0.10789113f, 
    0.45935747f, -0.71264660f, 0.23131944f, 0.51098812f, -0.26086077f, 1.11169696f, 0.00209992f, 0.74658614f, 
    -0.14030229f, -0.48581779f, -0.15466833f, 1.05791879f, 1.39345765f, 0.61167705f, 0.01787341f, -1.15418792f, 
    -0.76551342f, -0.10677150f, -0.33202833f, -0.10265638f, -1.12724757f, 1.00630522f, -0.38466939f, 0.79750866f, 
    -0.31508091f, -0.89203513f, -0.04642499f, -0.18817672f, -0.33872604f, -1.05286229f, -0.07423581f, 0.54425162f, 
    0.98981488f, 1.31114399f, 0.61584097f, -0.31147692f, -0.28274617f, -0.59114105f, -0.22226264f, -0.96791726f, 
    -0.76127970f, -1.03859317f, 1.07566369f, -0.87835860f, -0.18585168f, 0.24402367f, 0.16754584f, -0.06227073f, 
    0.40141952f, -0.36044770f, -0.76194108f, -1.36071074f, 0.13923572f, 0.65480590f, 0.25596529f, 0.37788388f, 
    1.04492056f, 0.60287547f, 1.12476265f, 0.78382117f, 0.29618794f, 0.32718295f, 0.32680491f, 0.15173641f, 
    0.37840459f, 0.41054964f, -1.08110356f, 0.11703128f, -1.02857399f, 0.20338944f, 0.95193678f, 0.38881755f, 
    0.34765071f, 0.86451817f, -1.09697509f, -0.85174507f, -0.77939433f, 0.42357633f, 1.48551106f, 0.31972611f, 
    0.30884418f, -0.51198864f, 0.07365713f, 0.27634662f, -0.08866295f, 0.23381202f, -1.20250869f, -0.05636088f, 
    -0.82141864f, 0.43049768f, 0.18206127f, 0.90569091f, 1.01182878f, 1.02043474f, 0.35316887f, -1.05765104f, 
    1.22505987f, -0.47109541f, 0.45014811f, 0.44950545f, -0.11784824f, -0.35620528f, 0.32661337f, 0.31187314f, 
    -1.29341531f, 0.13206732f, -1.26153696f, -0.51480949f, 0.52377129f, -0.50690711f, 1.26712835f, 0.74900162f, 
    0.34865502f, 0.03495083f, -0.77489948f, 0.79185456f, -0.79312402f, 0.66221857f, -0.09283817f, 0.72102904f, 
    -1.34799421f, 1.14587808f, 0.91170925f, -1.30996919f, 0.85069829f, 0.15148456f, -0.44739339f, -0.07353145f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27497354f, 0.44560784f, 0.44998828f, -0.15937449f, -0.20566021f, -0.18382290f, 0.05620810f, 0.34367138f, 
    0.58830500f, -0.27077514f, -0.19324911f, 0.24456154f, 0.06019541f, 0.67187542f, 0.09739762f, -0.14771843f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.22660023f, 0.30721924f, 0.39737806f, 0.13175605f, -0.01467904f, -0.12363928f, 0.21129164f, -0.07455762f, 
    0.09921084f, 0.20355330f, 0.29567355f, 0.14383288f, 0.07252233f, 0.00869968f, 0.02254047f, 0.01870342f, 
    -0.01706707f, 0.09314926f, 0.07665508f, -0.29361689f, 0.01933805f, -0.11192022f, -0.02929745f, -0.06435177f, 
    0.02104283f, 0.02547920f, 0.04419988f, 0.27613464f, -0.69528890f, -0.11367845f, 0.07023372f, 0.03124602f, 
    0.08365259f, -0.00212571f, 0.09211893f, 0.06917287f, 0.66577911f, 0.27949980f, 0.38033167f, -0.00328574f, 
    0.06532589f, -0.31789383f, -0.12783685f, 0.14527255f, -0.15921378f, 0.04799462f, 0.24753971f, 0.18443671f, 
    0.40578625f, -0.02416005f, -0.12801865f, 0.03580391f, -0.14420649f, 0.27869603f, -0.11080402f, 0.50263333f, 
    -0.05876333f, 0.17916223f, 0.01423174f, 0.18981257f, 0.07715468f, -0.00576665f, -0.29334965f, 0.05034251f, 
    -0.43858516f, -0.13307098f, -0.32246333f, -0.11480987f, -0.09031393f, -0.24533324f, 0.16869873f, -0.35416299f, 
    -0.17905663f, -0.14177752f, 0.07758129f, 0.14520259f, -0.07782468f, 0.30077276f, -0.19213346f, -0.00949037f, 
    -0.20681673f, -0.18319026f, -0.08972435f, -0.25253564f, -0.12177304f, -0.19721244f, -0.18043563f, 0.05025716f, 
    0.12262824f, 0.06999285f, 0.34649718f, 0.65948069f, 0.14747573f, 0.19386071f, 0.14336754f, 0.11361102f, 
    0.15850656f, 0.08085769f, -0.04393773f, -0.18173930f, -0.18044826f, -0.09553692f, 0.02513198f, 0.10648805f, 
    -0.20954530f, -0.27186066f, -0.12129670f, -0.09006885f, -0.22456737f, -0.21353522f, -0.17269969f, 0.02181662f, 
    -0.07695270f, 0.15140304f, 0.08453476f, -0.09449592f, -0.02581049f, -0.19115974f, -0.09577616f, 0.13925064f, 
    -0.15247598f, -0.05232991f, -0.00587869f, -0.18799177f, -0.24673271f, -0.05281069f, 0.14315385f, -0.40252909f, 
    0.12389493f, -0.29686412f, -0.29904202f, 0.01608433f, -0.04734586f, -0.21893965f, 0.08677652f, 0.36499450f, 
    -0.12706283f, -0.64002126f, -0.09096797f, 0.12577349f, 0.12618236f, 0.05404575f, -0.06212823f, 0.14762051f, 
    0.26057729f, 0.51493961f, 0.11952291f, -0.13299896f, 0.01515307f, 0.06590976f, -0.10215382f, 0.33079356f, 
    0.12129858f, 0.03388309f, 0.40807155f, 0.12743670f, -0.07441193f, -0.02325972f, -0.21576147f, -0.21027675f, 
    -0.06792855f, -0.17076284f, 0.06800552f, -0.28105018f, -0.18447848f, -0.04711722f, 0.15299311f, -0.00671413f, 
    0.06295786f, -0.17322513f, 0.09733021f, -0.40538713f, -0.31984282f, -0.26699603f, -0.05042210f, 0.05401782f, 
    0.16680457f, -0.27723902f, -0.05696050f, -0.29165167f, 0.47579920f, -0.30295455f, -0.10912239f, 0.10657528f, 
    0.21040674f, 0.10408099f, -0.08751161f, -0.05929985f, -0.08852217f, 0.35012922f, 0.05735681f, -0.23180707f, 
    0.57568145f, 0.17652050f, -0.36700898f, 0.04511323f, 0.20016173f, 0.02684125f, -0.17468227f, 0.08111288f, 
    0.22702233f, 0.21940097f, -0.23652248f, 0.15084329f, 0.21782446f, -0.14504771f, -0.24374361f, 0.34421653f, 
    -0.06099898f, -0.49158683f, -0.06850465f, 0.03482489f, 0.04083272f, -0.17323668f, 0.10668764f, 0.29508632f, 
    -0.90397698f, -0.37932289f, -0.21587443f, -0.00754855f, 0.04665719f, -0.11255590f, -0.14168723f, 0.01236221f, 
    0.15106823f, -0.14231105f, -0.02431367f, 0.14568745f, 0.05986929f, -0.19655244f, -0.15572582f, 0.32077420f, 
    0.24925825f, 0.13935728f, 0.61629593f, 0.56110871f, 0.01183072f, -0.04922557f, 0.36583999f, -0.07041913f, 
    0.35960495f, -0.00517564f, 0.13165912f, 0.02879854f, 0.10607062f, 0.08027405f, -0.01310160f, 0.00959195f, 
    0.46283823f, -0.32759938f, 0.08064446f, 0.04497752f, -1.20862901f, -0.26945478f, -0.26879501f, 0.06203446f, 
    0.06566021f, -0.24819447f, 0.00751387f, -0.07020893f, 0.33161005f, 0.28157094f, 0.19919595f, 0.14663380f, 
    0.07686889f, -0.05971323f, 0.27874207f, -0.19003376f, -0.15095380f, -0.26121792f, -0.43987960f, -0.80953985f, 
    0.20918417f, 0.02938630f, 0.01488566f, -0.33753914f, 0.01565694f, -0.06004816f, 0.01042026f, -0.06075002f, 
    -0.32039750f, 0.00836114f, 0.16094193f, 0.08241731f, -0.08671024f, -0.23905028f, 0.20487539f, 0.13561994f, 
    0.47125077f, -0.00376723f, -0.32525110f, 0.22411685f, -0.07800666f, 0.35857114f, 0.11919942f, -0.15792881f, 
    0.06316372f, -0.24667937f, -0.32706118f, 0.29362670f, 0.06186125f, 0.01209257f, 0.12248003f, 0.08868895f, 
    -0.13012722f, 0.15940320f, 0.03056825f, 0.11147644f, -0.01963384f, 0.00551774f, 0.24188477f, 0.23229742f, 
    0.22037585f, 0.11402930f, 0.10178471f, -0.31501380f, 0.22159694f, 0.11743378f, -0.39997473f, -0.00066008f, 
    -0.30423164f, 0.11522511f, -0.01672769f, 0.15440933f, -0.15409049f, -0.18465416f, -0.41080382f, -0.01890443f, 
    0.07343664f, -0.06996536f, 0.01611047f, 0.01895813f, 0.21378876f, 0.36656752f, 0.39787206f, 0.17233981f, 
    -0.03399142f, -0.07156169f, 0.02319133f, 0.25607941f, -0.07702849f, 0.12280162f, -0.76322973f, -0.18815076f, 
    -0.01582534f, -0.04765427f, -0.02509868f, -0.02335676f, 0.09730034f, -0.17325476f, 0.18678226f, -0.07515109f, 
    0.00498489f, -0.09017606f, -0.03821012f, 0.12282377f, 0.12514304f, 0.09097012f, 0.45171529f, -0.04628079f, 
    0.23033881f, 0.00275758f, -0.10463449f, -0.22230385f, 0.48389065f, 0.09029993f, 0.13414536f, -0.03299702f, 
    -0.15668648f, -0.52124876f, -0.59031886f, -0.42521143f, -0.39680102f, 0.26415572f, -0.09433316f, -0.01651330f, 
    -0.15062253f, -0.19973379f, 0.23873921f, -0.22609119f, -0.34280562f, -0.00874009f, -0.20405386f, -0.02041040f, 
    -0.19531600f, -0.18149568f, -0.03499379f, -0.34062612f, -0.04554204f, 0.11868336f, -0.13684548f, 0.28356382f, 
    -0.02706926f, -0.18149666f, -0.07862107f, -0.00734824f, -0.09199896f, 0.02913762f, -0.04586064f, 0.08231341f, 
    0.04529193f, -0.01545269f, 0.00343931f, -0.08791003f, 0.00623886f, -0.11650652f, 0.00979694f, 0.31460434f, 
    0.17078285f, 0.05649644f, -0.12699358f, -0.01774297f, 0.14580254f, 0.31986314f, 0.03985664f, 0.08442693f, 
    0.06206762f, -0.39568681f, 0.10731816f, -0.03230113f, -0.00846587f, 0.21240516f, -0.20588744f, 0.47561714f, 
    -0.02134134f, -0.04542048f, 0.12504581f, 0.00839574f, -0.05406869f, -0.08034988f, -0.15013935f, -0.19912341f, 
    -0.08241088f, 0.00121491f, -0.02976494f, 0.05514054f, -0.01465771f, 0.03364186f, 0.01527979f, 0.05996076f, 
    -0.07374532f, -0.07056297f, 0.01238689f, -0.00643868f, -0.01776990f, -0.05795227f, 0.03652403f, -0.09201837f, 
    -0.00641210f, 0.03642826f, -0.00341271f, 0.01203335f, 0.04838233f, -0.09827591f, -0.02490591f, 0.03166014f, 
    0.01415379f, -0.03006182f, 0.00537306f, 0.02700567f, 0.03591541f, -0.09254470f, -0.09249827f, 0.06472314f, 
    0.06549953f, -0.06800716f, 0.00246115f, 0.02793070f, -0.00461989f, 0.04927279f, 0.01092693f, -0.08810312f, 
    -0.05898744f, -0.04517267f, 0.05123241f, -0.06057560f, -0.00420191f, -0.08558395f, -0.08792441f, -0.08149724f, 
    -0.00985738f, 0.05517272f, -0.05370762f, -0.01756002f, -0.00187528f, 0.00484684f, 0.04114633f, 0.03250977f, 
    0.04869478f, -0.01253544f, -0.03309890f, 0.02216932f, -0.01026169f, -0.08491366f, -0.05731773f, 0.00296900f, 
    -0.09779783f, 0.05351659f, 0.02311268f, 0.01778754f, 0.04882781f, -0.02517042f, -0.01362992f, 0.00599848f, 
    0.01683163f, 0.02843106f, 0.02946362f, 0.00758897f, 0.05666560f, 0.04235305f, -0.06306423f, -0.09172674f, 
    0.02129280f, 0.04785888f, -0.02123029f, -0.02189854f, -0.08535402f, -0.04339201f, 0.05171487f, 0.06450175f, 
    0.01305958f, 0.01393200f, -0.03200745f, 0.03182681f, -0.09681101f, -0.06111003f, 0.01451353f, -0.04381508f, 
    -0.03879998f, 0.05219265f, -0.04267793f, 0.04976078f, -0.08396488f, 0.00257581f, -0.02945693f, 0.05444606f, 
    0.01193502f, -0.06949167f, -0.02042468f, 0.04219520f, 0.04699779f, -0.03547423f, 0.02476547f, 0.02739206f, 
    -0.05331329f, -0.05228144f, -0.00751135f, -0.02636002f, -0.06291001f, 0.02351213f, -0.02501745f, 0.02022794f, 
    -0.00408444f, 0.03986477f, -0.01031129f, 0.00312366f, -0.08915575f, -0.09001455f, -0.03935297f, -0.06929640f, 
    -0.05950223f, -0.03256870f, -0.00740437f, 0.01145544f, 0.00334199f, 0.06362153f, -0.09381951f, 0.01293248f, 
    -0.09230955f, 0.04286527f, -0.02872078f, 0.01315309f, -0.00406800f, 0.04912213f, 0.05030559f, -0.05224603f, 
    -1.01426160f, -0.24283454f, -0.29671609f, 0.14649437f, 0.23524140f, -0.09624814f, 0.13325533f, 0.07649864f, 
    0.06503756f, -0.26060119f, 0.25162888f, 0.12466529f, 0.11022791f, 0.08191837f, 0.18784514f, 0.16710125f, 
    -0.32907778f, -0.00296324f, 0.07561227f, 0.01013961f, -0.25477642f, 0.10054839f, -0.09445902f, 0.16875255f, 
    0.01384681f, 0.23329893f, -0.26344875f, 0.28819194f, -0.01279606f, 0.07436182f, -0.21200575f, 0.19026902f, 
    -0.27963319f, 0.16718090f, 0.17122249f, 0.15147951f, -0.33938107f, -0.19689600f, 0.15501243f, 0.02566960f, 
    -0.18307570f, -0.17309467f, 0.24208583f, 0.39173877f, 0.31026781f, 0.26254311f, 0.35129443f, 0.07776481f, 
    0.18367901f, -0.00551897f, 0.04208998f, 0.11673923f, -0.03304408f, -0.05036847f, -0.56378740f, -0.04343946f, 
    -0.27927226f, 0.07136004f, 0.02617445f, 0.04570460f, -0.39906794f, -0.16205467f, -0.06216259f, 0.01702439f, 
    0.04211839f, 0.00904223f, 0.18327643f, 0.00795857f, 0.04752837f, 0.18790925f, 0.02998214f, 0.16581254f, 
    0.10704012f, 0.49515337f, 0.43579936f, -0.11980003f, 0.22320363f, -0.18038908f, 0.02289607f, -0.12103730f, 
    -0.04857209f, -0.58365792f, -0.28505650f, -0.12452345f, -0.01209191f, -0.06565938f, -0.12933172f, 0.11744404f, 
    -0.11213409f, -0.14195143f, -0.17835155f, 0.18083254f, -0.55732137f, 0.08901060f, 0.08952957f, 0.18445885f, 
    -0.18216538f, -0.27293324f, -0.27648145f, 0.44050479f, 0.07141650f, 0.23400377f, 0.14969857f, 0.05804239f, 
    -0.10963585f, -0.20078954f, 0.28786525f, 0.14385121f, 0.11271209f, 0.04949665f, -0.10218619f, -0.32529262f, 
    -0.38383052f, -0.07795829f, -0.22779010f, -0.04376299f, 0.05067359f, 0.27014330f, -0.03444275f, -0.08603919f, 
    0.03589994f, 0.25164831f, 0.01941346f, 0.12018596f, 0.41355565f, -0.15380533f, 0.27139103f, 0.10316879f, 
    0.33823907f, -0.15102589f, -0.22167492f, 0.05042104f, -0.18028310f, 0.05831499f, 0.00998627f, -0.18118538f, 
    -0.53960031f, -0.03971279f, -0.30651060f, -0.06940722f, 0.18774113f, 0.08409913f, -0.12667447f, -0.09710545f, 
    -0.06787407f, 0.06005839f, -0.02563229f, -0.06158277f, 0.06149464f, 0.05833138f, -0.03566267f, -0.04358305f, 
    -0.04647028f, -0.08918480f, 0.03644085f, -0.06092079f, -0.05965092f, -0.02598133f, 0.05679622f, 0.03879052f, 
    -0.04132024f, -0.08679582f, -0.04191747f, -0.06614591f, -0.02622570f, -0.07808387f, -0.08140659f, 0.02828475f, 
    0.00539326f, 0.06186605f, -0.06956719f, -0.06924652f, -0.07160523f, -0.07464087f, -0.02159226f, 0.06697480f, 
    -0.02481160f, 0.00806633f, 0.05892679f, -0.08525869f, -0.00842631f, -0.02860976f, -0.01364028f, 0.01003873f, 
    -0.06690177f, 0.02315083f, 0.03822846f, 0.02266248f, 0.06010974f, -0.07338555f, -0.07914484f, -0.07068104f, 
    0.02603683f, 0.03815029f, 0.07072262f, -0.00899015f, 0.05996421f, 0.04590348f, -0.09049503f, 0.05508257f, 
    -0.07627028f, -0.01565432f, -0.05134370f, -0.02321553f, 0.07063367f, 0.05010577f, -0.01225826f, -0.05789927f, 
    -0.08810955f, -0.03674464f, -0.07629005f, -0.08875421f, -0.01280112f, -0.07644088f, 0.06080606f, -0.02228053f, 
    -0.00504797f, -0.01603722f, 0.06508238f, 0.04608203f, 0.01645559f, 0.05042242f, 0.03546898f, -0.05081165f, 
    -0.07336819f, -0.00300158f, -0.06867008f, 0.02726144f, 0.02887216f, -0.05389614f, 0.05015545f, 0.03835166f, 
    -0.05482502f, -0.04603122f, 0.06466794f, 0.03338650f, 0.03516134f, 0.00800193f, -0.08300778f, -0.03988643f, 
    -0.03588766f, -0.09006518f, -0.04200318f, 0.05556422f, 0.00661713f, 0.05032712f, 0.05625328f, 0.02840194f, 
    0.03924096f, 0.05057690f, 0.02793891f, 0.00163527f, -0.08185185f, 0.07369096f, 0.00691478f, -0.00790044f, 
    -0.08631428f, -0.04443415f, -0.06532417f, 0.00031970f, 0.02551605f, 0.01950853f, -0.03929776f, 0.02779897f, 
    -0.00703875f, 0.03040547f, -0.05315823f, 0.00785639f, -0.06313077f, -0.02053669f, -0.06614161f, -0.01070783f, 
    -0.08642989f, 0.04902798f, -0.04278509f, -0.00607988f, 0.06774277f, -0.01621729f, -0.02448351f, 0.01120255f, 
    -0.04876910f, 0.03046974f, -0.04056864f, -0.05731224f, -0.02274055f, 0.06921344f, 0.06722324f, -0.01592580f, 
    -0.29583386f, -0.19792739f, 0.66999370f, 0.15147634f, 0.11678781f, -0.15093203f, -0.23082311f, -0.03151858f, 
    0.17629117f, -0.53024203f, -0.12705182f, 0.28879410f, -0.22021186f, -0.09099115f, 0.07114242f, 0.12527420f, 
    0.12747218f, -0.06475546f, 0.23248804f, -0.02455357f, -0.10524978f, -0.16553290f, 0.45306566f, -0.09539323f, 
    0.22842243f, 0.19761983f, -0.11378867f, -0.36940175f, -0.12384642f, -0.26640585f, 0.16243212f, -0.08097383f, 
    -0.12488180f, 0.06219716f, -0.13000922f, 0.03589872f, -0.25179169f, -0.56959307f, -0.57069749f, 0.13553996f, 
    -0.20430759f, -0.09321360f, 0.12612547f, -0.20284633f, 0.13444634f, 0.21929298f, 0.08095155f, -0.07141435f, 
    -0.24306913f, -0.28618664f, 0.28583726f, 0.05206752f, 0.08655127f, 0.08577025f, -0.06010485f, 0.49476114f, 
    -0.08636778f, -0.18195923f, 0.17757824f, 0.01655312f, -0.18640459f, 0.25478145f, -0.23061094f, 0.11408808f, 
    0.28989559f, -0.38238060f, 0.13530493f, -0.10518125f, -0.28777581f, 0.30889231f, 0.07381552f, 0.01485616f, 
    0.07289977f, 0.09092979f, -0.06676509f, 0.22620545f, 0.01816012f, 0.04731022f, -0.20555082f, 0.12978838f, 
    -0.11089335f, 0.12618983f, 0.13457106f, 0.25844857f, -0.06231118f, 0.10669331f, -0.06867687f, 0.09770405f, 
    -0.17876217f, 0.24458173f, -0.19075248f, 0.03468456f, 0.64738560f, -0.26910102f, -0.21637419f, 0.11530372f, 
    0.02470906f, 0.10894371f, 0.12121044f, -0.00582204f, -0.09408559f, -0.37800986f, 0.10800678f, 0.22907317f, 
    -0.16818501f, 0.09149141f, 0.00039190f, 0.07272387f, -0.05033940f, -0.05282721f, -0.67128718f, 0.34998241f, 
    0.10196979f, 0.15435694f, -0.04937625f, -0.42850429f, 0.13226320f, -0.15800259f, 0.33500051f, -0.41622028f, 
    -0.03527964f, 0.17082310f, 0.20496939f, 0.13717617f, -0.09922252f, 0.06400158f, -0.09624174f, -0.29124251f, 
    -0.13248143f, 0.29322922f, -0.00405441f, -0.10278709f, 0.24701507f, 0.06733288f, -0.21131709f, 0.10389477f, 
    0.18624347f, -0.00832633f, 0.06965141f, -0.14347635f, 0.07155006f, 0.13343543f, -0.01973762f, -0.27746651f, 
    0.11177666f, 0.12641227f, 0.06718715f, 0.42503706f, -0.10867873f, 0.17290902f, 0.20167503f, 0.03259186f, 
    0.21653216f, 0.17544073f, 0.04872043f, 0.46891120f, 0.04931607f, 0.19083355f, -0.06082475f, -0.17756905f, 
    -0.14893302f, -0.19866838f, 0.12737034f, -0.17801392f, -0.14836173f, 0.04481179f, 0.02908058f, -0.01232249f, 
    0.07712184f, 0.08103090f, 0.21334128f, 0.13407534f, 0.38235337f, 0.02538934f, -0.14439784f, -0.17944492f, 
    -0.38179165f, 0.20969784f, 0.12656604f, 0.13128386f, -0.40504289f, -0.15652138f, -0.48189750f, -0.01733970f, 
    0.00963922f, -0.06483168f, 0.14324062f, 0.14322586f, -0.08637306f, 0.26602024f, 0.46141878f, -0.09157097f, 
    0.13545519f, 0.07550982f, -0.39116973f, -0.35017431f, -0.00512303f, 0.25902566f, 0.26195368f, -0.22884192f, 
    0.47681561f, 0.29596263f, -0.21795395f, 0.07265697f, -0.15763777f, -0.22686164f, -0.04505872f, -0.17771469f, 
    -0.25704947f, 0.22972561f, -0.13259387f, -0.12250564f, -0.08359267f, -0.01035111f, 0.18981871f, -0.00094472f, 
    -0.05374333f, 0.20159927f, -0.06661040f, 0.15328950f, 0.23043688f, -0.09240592f, 0.16165665f, -0.15732835f, 
    0.18183519f, 0.30545843f, -0.31139466f, -0.25944337f, -0.16575579f, 0.00757728f, -0.11614183f, -0.28462744f, 
    0.20452745f, 0.15832797f, 0.13872956f, 0.21544741f, 0.29363373f, 0.14285263f, 0.25406712f, 0.03900127f, 
    0.22620426f, -0.07211249f, 0.01762717f, -0.00342414f, -0.32903337f, -0.09686702f, -0.10343144f, 0.05650366f, 
    -0.14450052f, -0.24447367f, -0.05345960f, -0.17947362f, 0.08403947f, -0.04016128f, -0.12701131f, -0.08096184f, 
    -0.04325472f, 0.07768953f, -0.03039090f, 0.14049914f, 0.00033985f, -0.29927135f, -0.41425940f, -0.02447191f, 
    0.18255486f, 0.06164078f, -0.20391847f, -0.26521671f, -0.04351749f, -0.14665526f, 0.40786016f, -0.17648974f, 
    0.09845141f, -0.08813305f, 0.09548037f, 0.12671584f, -0.06717318f, -0.09923428f, 0.14788355f, 0.00601087f, 
    0.17809285f, -0.24209692f, -0.15068126f, -0.01543084f, -0.06557333f, -0.07240667f, -0.03025143f, -0.11847606f, 
    0.06846382f, -0.04905127f, -0.06056817f, 0.03929452f, -0.01956747f, -0.08381777f, -0.03272519f, -0.04277803f, 
    0.01601570f, -0.00398980f, -0.04414716f, -0.07289922f, 0.02394614f, -0.08944070f, -0.08971187f, 0.04400661f, 
    0.07287350f, -0.02355446f, 0.02583035f, -0.08651812f, 0.06990133f, -0.08817816f, -0.07136092f, -0.03724138f, 
    -0.01010935f, -0.05537396f, 0.03600898f, -0.00195390f, -0.04979414f, -0.04739001f, -0.05771649f, -0.04836287f, 
    -0.02659854f, -0.04931591f, 0.04160517f, 0.06741420f, 0.05641094f, -0.08010598f, 0.01379864f, 0.04094035f, 
    -0.06893883f, -0.08205821f, 0.02833460f, -0.03726368f, -0.01939527f, 0.01173450f, 0.00393976f, -0.00738726f, 
    -0.01206572f, -0.01163890f, -0.05846611f, -0.04345411f, 0.00009208f, 0.06642076f, -0.04840747f, -0.04040948f, 
    -0.01048719f, -0.08866711f, 0.04156379f, 0.03353826f, -0.05421435f, -0.07277614f, 0.00700200f, 0.01976074f, 
    0.07239638f, -0.09017028f, -0.02693283f, 0.06412135f, 0.01198804f, -0.00856117f, -0.05488251f, 0.03703722f, 
    -0.07679729f, -0.06595099f, -0.07225628f, 0.06208349f, 0.02716161f, -0.02664968f, -0.03723696f, -0.00183926f, 
    -0.01729040f, 0.01988160f, 0.00312274f, 0.01486145f, -0.09133022f, -0.01684805f, -0.04589264f, -0.08467367f, 
    0.00050715f, -0.07843403f, 0.01835747f, 0.00698706f, 0.07490233f, 0.02077385f, -0.00883295f, -0.01833832f, 
    -0.05844065f, 0.03668617f, -0.06743166f, -0.07988019f, 0.05732846f, 0.06148070f, -0.03834613f, 0.02250610f, 
    -0.07602154f, 0.04923686f, -0.01204687f, 0.00090911f, -0.01088689f, -0.08577041f, -0.00157550f, 0.07761200f, 
    -0.02424682f, -0.07325464f, -0.05222360f, 0.02629313f, -0.00877758f, 0.00500789f, 0.00736918f, 0.01739771f, 
    -0.01660098f, -0.00769611f, -0.05729650f, 0.04188698f, 0.06105539f, -0.05365843f, -0.06375012f, -0.01637679f, 
    0.05365442f, -0.04148890f, 0.02768196f, 0.03769488f, -0.03346305f, -0.07087549f, 0.01151508f, 0.04371868f, 
    -0.07163021f, -0.01696174f, -0.08824339f, 0.08140650f, -0.02626603f, -0.06835306f, 0.01874127f, 0.03720400f, 
    -0.16882715f, 0.07707100f, -0.10907539f, 0.11932410f, 0.02133564f, -0.13593470f, 0.14061920f, -0.35440654f, 
    0.00376835f, 0.19494066f, 0.01494876f, 0.17370336f, 0.00278395f, -0.17832239f, 0.01442160f, -0.25003681f, 
    -0.07794493f, 0.01250524f, -0.10088436f, 0.17045842f, 0.03110356f, 0.29886422f, 0.21278201f, 0.15731156f, 
    0.04582264f, 0.11453843f, -0.06571486f, -0.31091818f, 0.05707729f, -0.66771322f, 0.07925180f, 0.12743473f, 
    -0.01716301f, 0.27152321f, -0.04005385f, -0.11215606f, 0.54061413f, -0.19052741f, 0.03018214f, -0.01944133f, 
    0.11262099f, 0.07727958f, 0.09020890f, 0.28444979f, 0.05817098f, 0.01217694f, 0.22844471f, 0.04428292f, 
    0.22063662f, -0.04054805f, 0.39998060f, 0.16202292f, -0.10978460f, -0.31628951f, -0.38511726f, 0.41553560f, 
    0.11448514f, 0.03289250f, 0.10139719f, 0.22521301f, -0.08993100f, -0.02629543f, 0.06698739f, 0.10400234f, 
    -0.20612390f, -0.17197356f, 0.09850827f, -0.11187387f, -0.21466482f, -0.15967274f, 0.24407214f, 0.06522553f, 
    -0.55998313f, 0.13440622f, -0.09257592f, -0.03815198f, -0.06410286f, -0.13097806f, -0.18673790f, 0.22488613f, 
    -0.09748742f, 0.10641429f, 0.12704094f, -0.26320186f, 0.08948636f, -0.11743324f, 0.19037923f, 0.14306283f, 
    -0.18602894f, -0.59426016f, -0.14829975f, 0.05239375f, 0.06240211f, 0.00476827f, 0.07394435f, 0.09951428f, 
    0.07791930f, 0.14776072f, 0.23076232f, 0.27618456f, 0.06944820f, 0.00151391f, -0.06626622f, -0.31410897f, 
    -0.26634663f, -0.34411573f, 0.28282139f, 0.37403527f, -0.26779729f, 0.14481001f, 0.18941766f, -0.12896021f, 
    0.04897594f, -0.00553821f, 0.16206899f, -0.02635729f, -0.02799518f, 0.14535584f, 0.03911934f, 0.27876768f, 
    -0.01481742f, -0.01164564f, -0.39710504f, 0.05221084f, -0.07466487f, 0.23275727f, -0.22419792f, -0.16169223f, 
    -0.16760510f, -0.00256700f, 0.04250130f, 0.04523207f, -0.04491982f, 0.21828334f, -0.15355232f, 0.32665113f, 
    -0.18002714f, 0.04844565f, -0.14305899f, 0.33565867f, -0.11506131f, -0.10832630f, 0.09204205f, -0.13798404f, 
    0.22707674f, 0.23843403f, -0.23599105f, 0.12861140f, 0.18687940f, 0.05487594f, -0.08464524f, -0.20487662f, 
    -0.24455345f, -0.14352697f, -0.30889389f, -0.13249306f, 0.01494254f, 0.28411987f, -0.18620595f, -0.05137277f, 
    0.04893712f, -0.08830559f, -0.26084891f, -0.32127920f, 0.08481395f, 0.05242255f, 0.26566383f, 0.10241809f, 
    -0.11573230f, -0.15864959f, -0.06633765f, 0.54882556f, 0.46531111f, 0.39500001f, -0.13060635f, -0.23328504f, 
    -0.15007207f, 0.22878529f, -0.03744749f, 0.15840018f, -0.16074339f, -0.24237487f, -0.46866551f, -0.02619939f, 
    -0.10720260f, -0.13386209f, -0.06622421f, -0.05960547f, 0.16983999f, -0.00384386f, -0.57199180f, -0.53615355f, 
    0.15550150f, 0.34178281f, 0.28405195f, -0.08254603f, 0.11396559f, -0.12311004f, 0.00148303f, 0.06381750f, 
    -0.32959932f, 0.07345038f, 0.30112016f, 0.11572223f, -0.24385643f, -0.17688660f, -0.07523561f, -0.06997204f, 
    0.12477535f, -0.02540851f, 0.10698190f, -0.28968310f, -0.08633864f, 0.17550947f, 0.33341008f, 0.12781236f, 
    0.08155756f, -0.13386692f, 0.13520084f, -0.01073202f, -0.06499729f, -0.13185950f, -0.02796438f, -0.02210612f, 
    -0.21426848f, 0.09043454f, -0.37918735f, -0.19824153f, -0.06050938f, 0.09807616f, 0.08299232f, -0.01536429f, 
    -0.10035170f, 0.09253996f, 0.21073896f, -0.38024199f, 0.01012808f, 0.04154242f, 0.05889196f, 0.32157075f, 
    -0.08387467f, 0.12098584f, -0.07609419f, 0.04977583f, 0.12924792f, 0.11022194f, 0.25388992f, 0.03635523f, 
    -0.09159653f, 0.09911354f, -0.19240932f, -0.43028766f, 0.33360112f, 0.44265106f, 0.25268242f, -0.06470092f, 
    -0.47065350f, -0.30018726f, -0.03875716f, 0.09594790f, 0.07134944f, -0.36290637f, 0.21977784f, 0.06067957f, 
    0.05864050f, 0.10726450f, 0.27019063f, 0.02284404f, 0.18073674f, -0.02487901f, 0.11231112f, 0.28128782f, 
    0.26028422f, -0.13853049f, -0.00296556f, 0.07235652f, 0.12796292f, 0.10472891f, -0.06178118f, -0.13919976f, 
    0.10309934f, -0.18444730f, -0.05934941f, -0.03726042f, 0.00008977f, -0.05306003f, -0.02671365f, 0.02875210f, 
    -0.21502420f, 0.09067067f, 0.06134908f, -0.12810737f, 0.22051063f, 0.18880917f, -0.07797759f, 0.16061038f, 
    -0.04603443f, -0.39029652f, -0.24649449f, -0.01090625f, 0.13741930f, 0.28217912f, -0.06319571f, -0.02609735f, 
    0.04057723f, 0.20546325f, 0.02098855f, 0.21026903f, 0.19394235f, 0.27164459f, 0.03191019f, -0.19648680f, 
    0.03481748f, -0.23886304f, -0.14969720f, 0.18202496f, 0.06302067f, -0.17825997f, 0.22641231f, -0.07064468f, 
    0.02245216f, -0.19548449f, 0.02100210f, 0.03676565f, -0.89014471f, -0.68029118f, 0.10350458f, -0.02050742f, 
    -0.14176664f, -0.21351077f, 0.15377441f, -0.30326545f, 0.00122129f, -0.18262321f, -0.43829641f, -0.14585146f, 
    0.05817287f, -0.39668658f, -0.08829459f, 0.09417410f, -0.09032279f, -0.10018268f, -0.59563893f, -0.07553315f, 
    -0.39562851f, 0.12931935f, 0.12885718f, 0.04901721f, -0.14501522f, -0.15609920f, -0.18392138f, -0.01262675f, 
    0.07711168f, 0.02764447f, 0.22283562f, -0.04471729f, 0.14261901f, 0.04222491f, 0.21622901f, 0.25509888f, 
    -0.11338203f, 0.02708684f, 0.19052687f, 0.11412912f, 0.18855913f, 0.04016890f, 0.16499148f, 0.29606247f, 
    -0.07642549f, 0.33203036f, -0.10662853f, 0.11714834f, -0.22287425f, -0.15261589f, 0.00698282f, 0.28044701f, 
    0.23794349f, 0.07199083f, -0.44681326f, -0.53723919f, -0.28529614f, -0.03476959f, 0.09960411f, -0.28366593f, 
    -0.15591581f, 0.02484482f, -0.27426335f, 0.09987569f, 0.46655571f, -0.26915669f, 0.01607442f, 0.08034210f, 
    0.04104481f, -0.03218172f, -0.03794806f, 0.16590656f, 0.44244426f, -0.14188933f, 0.22504522f, 0.38408315f, 
    0.01234059f, -0.09915591f, -0.16494864f, 0.04507262f, 0.23229930f, -0.10884058f, -0.19093591f, -0.07156019f, 
    -0.14350931f, 0.27250925f, 0.20491362f, -0.05467796f, 0.15293491f, -0.17348672f, 0.10249086f, 0.17511337f, 
    0.20112920f, -0.16943371f, 0.19952466f, 0.15900619f, -0.00935365f, 0.32975486f, -0.02753580f, 0.95360398f, 
    -0.14038663f, -0.26188275f, -0.14678654f, 0.03152615f, -0.01489102f, 0.06196720f, -0.01375148f, 0.23543574f, 
    0.24725887f, 0.10379499f, -0.56150836f, -0.00936193f, 0.11352652f, -0.02191016f, 0.06042283f, 0.13256638f, 
    0.23383787f, -0.31215289f, 0.24136694f, 0.00890493f, -0.12633985f, -0.44787323f, 0.01512243f, -0.01083004f, 
    0.16575934f, 0.10207783f, -0.07805310f, -0.18505296f, -0.04133344f, 0.10952200f, 0.48277584f, 0.24363202f, 
    0.04936425f, 0.26957509f, -0.12689158f, 0.99468660f, -0.36967269f, -0.19582865f, 0.21742912f, -0.09399310f, 
    -0.04210193f, 0.18438482f, -0.03738156f, 0.18225415f, 0.20917864f, -0.47380349f, -0.11670911f, -0.10848726f, 
    -0.13215518f, -0.29997748f, -0.09564372f, 0.00679567f, -0.25644934f, -0.76381385f, 0.25784743f, 0.16515757f, 
    0.03272498f, 0.03789126f, 0.20870331f, -0.26975125f, 0.11586876f, 0.16657825f, -0.40218338f, 0.03750364f, 
    -0.08414094f, -0.08599953f, -0.12360892f, 0.04883822f, -0.03813431f, -0.21632068f, -0.05125920f, -0.04036602f, 
    0.05435247f, -0.01618933f, 0.06857857f, 0.09532719f, 0.05440632f, 0.16902992f, 0.06273485f, -0.12877139f, 
    -0.21826197f, -0.16758238f, -0.01073001f, 0.17247987f, -0.02554500f, 0.13392842f, 0.43594286f, 0.28258345f, 
    -0.13282363f, -0.46866569f, -0.00839347f, 0.12239721f, 0.09714082f, -0.09111987f, -0.05646969f, 0.17864951f, 
    0.13906987f, 0.02406142f, -0.16887759f, 0.07521844f, 0.12717913f, -0.06562591f, 0.16504435f, -0.34556156f, 
    0.03586181f, -0.01477441f, 0.17860207f, -0.06692393f, 0.04114788f, 0.18628435f, -0.09572253f, -0.10494646f, 
    0.14567140f, 0.06592545f, 0.32003480f, -0.21337721f, 0.57774591f, -0.39835069f, -0.03148616f, 0.17398703f, 
    0.04932662f, 0.09055234f, -0.00782622f, -0.00658011f, 0.00888655f, 0.56968677f, 0.14040715f, 0.10040265f, 
    -0.03939189f, -0.07542156f, -0.13875917f, 0.05832219f, 0.03798271f, 0.08872456f, -0.13396533f, -0.24410869f, 
    0.10044587f, 0.13373552f, -0.10949717f, -0.25183955f, -0.13403189f, 0.19566321f, 0.05946432f, -0.25433442f, 
    -0.29629192f, -0.08082885f, 0.19458482f, 0.02599146f, -0.06319296f, -0.06123427f, -0.03054687f, 0.07720143f, 
    0.16224141f, 0.56898266f, 0.17661592f, -0.08905332f, -0.03634472f, -0.08964758f, 0.04034397f, 0.19578457f, 
    -0.12871745f, 0.16760689f, -0.43666708f, -0.24558802f, 0.03368720f, -0.16796882f, 0.02389789f, -0.05659706f, 
    -0.06879387f, -0.15167573f, -0.12831071f, 0.10191766f, 0.00781910f, -0.01798531f, -0.13732935f, 0.13940650f, 
    0.11108255f, -0.04744328f, -0.06007567f, -0.08164691f, -0.10314776f, 0.15256666f, 0.11893331f, -0.05336206f, 
    0.18136449f, -0.09709471f, 0.08954094f, 0.06133841f, -0.21171297f, -0.41288063f, -0.60872978f, 0.05615185f, 
    0.23799518f, 0.07858514f, -0.00075133f, -0.05675684f, -0.16879824f, 0.31938899f, 0.13223153f, 0.10749453f, 
    -0.28759453f, -0.03111381f, -0.28829637f, 0.15791471f, 0.00388288f, -0.18167691f, 0.24270624f, -0.40645295f, 
    -0.16580486f, -0.07538636f, 0.43396065f, 0.20463488f, -0.33992520f, -0.21774963f, -0.18966697f, -0.52432132f, 
    -0.25138149f, -0.27717707f, 0.06682962f, 0.00407019f, 0.23126420f, 0.01263923f, 0.18243495f, 0.00334583f, 
    -0.08349124f, 0.26911762f, 0.23963004f, -0.11131292f, 0.11301600f, -0.12378328f, 0.04653155f, -0.01351504f, 
    0.29522908f, 0.21110469f, -0.30663410f, -0.10242356f, -0.15294984f, -0.00345583f, 0.09917745f, 0.17867863f, 
    -0.07157730f, 0.15037377f, 0.39814073f, 0.07583695f, -0.20297872f, -0.12139768f, -0.02940536f, -0.35748705f, 
    0.09372632f, -0.01041548f, -0.06594889f, 0.41608915f, 0.07807109f, -0.26284412f, 0.24785060f, -0.08112744f, 
    0.20867720f, -0.01423668f, 0.30809975f, -0.05652914f, 0.49245009f, 0.27046984f, -0.12907143f, -0.08170708f, 
    -0.03382802f, 0.18773787f, -0.03938460f, 0.10426603f, 0.08785573f, 0.02625617f, 0.13133171f, -0.66001821f, 
    0.11892191f, 0.02766605f, 0.21437149f, -0.19310753f, -0.04952311f, -0.03211201f, -0.17822051f, 0.14891204f, 
    -0.31170279f, 0.10835285f, -0.23967424f, 0.36908388f, -0.03157381f, 0.20029749f, 0.19213806f, -1.14318061f, 
    0.41247237f, 0.05629881f, 0.10700163f, 0.31531602f, -0.27182299f, 0.06812932f, -0.18315513f, 0.12500171f, 
    0.10175451f, 0.01277860f, -0.17889664f, -0.12917951f, 0.02744305f, -0.08370652f, -0.09056509f, -0.04691696f, 
    -0.15618786f, 0.10773505f, 0.00570343f, -0.14078760f, -0.75709581f, 0.09867325f, -0.21297760f, -0.14649290f, 
    0.22346099f, 0.18652661f, 0.20641273f, 0.14558731f, -0.13666004f, 0.24807391f, 0.24431282f, 0.16347568f, 
    -0.19033207f, -0.36794695f, -0.28173798f, 0.57113874f, 0.22570887f, 0.11291431f, 0.36247125f, 0.22318567f, 
    -0.00128231f, -0.03628296f, 0.31479102f, -0.05026386f, 0.69982898f, -0.30318195f, 0.20790808f, -0.17511511f, 
    -0.08343476f, -0.16030332f, -0.17209882f, -0.02783634f, -0.03141076f, 0.34213698f, -0.05920369f, -0.11237612f, 
    -0.25749069f, -0.32708436f, -0.02350321f, -0.17944004f, 0.04153061f, -0.06579173f, 0.13349317f, -0.12746820f, 
    0.13078843f, -0.10954199f, 0.06182367f, -0.15257373f, 0.09180179f, 0.14096195f, -0.04756701f, 0.36788630f, 
    0.14536284f, 0.19375366f, -0.09198435f, -0.15524943f, -0.10474961f, 0.02847117f, -0.12239707f, -0.13333221f, 
    -0.51878154f, -0.33070052f, 0.00093203f, 0.13852462f, 0.06417239f, 0.24125007f, -0.07325842f, -0.00213902f, 
    -0.12965634f, 0.46590009f, -0.15044683f, -0.08201720f, -0.23416194f, -0.03650017f, -0.05437217f, 0.01679586f, 
    0.25758755f, -0.26924348f, 0.08586878f, 0.15333615f, 0.22355962f, -0.33728358f, -0.38235044f, -0.00109497f, 
    0.14471269f, 0.10224957f, 0.07232723f, 0.21217668f, 0.36556405f, -0.09533834f, 0.28555742f, -0.10283756f, 
    0.00412886f, 0.08522693f, 0.02901021f, 0.00186175f, -0.14917022f, 0.13604471f, -0.19596784f, 0.11495232f, 
    -0.07431920f, 0.03945098f, 0.09631544f, -0.18091618f, -0.02505602f, 0.60148221f, 0.05228921f, 0.13990830f, 
    0.18472670f, -0.03117627f, -0.08023868f, -0.19421832f, -0.16216360f, 0.12079349f, -0.65873772f, 0.01850020f, 
    -0.04649024f, 0.07793662f, 0.11276630f, 0.41030863f, -0.14012183f, 0.13627265f, -0.36533871f, -0.39686075f, 
    -0.08043896f, -0.16864595f, 0.02365706f, -0.10618239f, 0.13227612f, 0.01169911f, -0.03453606f, 0.10541990f, 
    -0.24821432f, -0.13611436f, 0.10735388f, 0.19395255f, 0.13586435f, 0.07278131f, 0.10833251f, 0.15314093f, 
    -0.01931635f, -0.10795287f, 0.21688907f, -0.57156205f, 0.07167546f, -0.00380377f, 0.15822989f, -0.09548386f, 
    -0.07105090f, 0.02934814f, 0.42389578f, 0.18863940f, -0.25604945f, 0.32828817f, -0.04704059f, 0.40032664f, 
    0.03248107f, -0.15318079f, -0.01588573f, -0.21141699f, -0.05114796f, 0.46955836f, -0.11156702f, 0.07740165f, 
    0.15954633f, 0.09382268f, 0.10094509f, 0.14229877f, 0.42528903f, 0.28371805f, -0.02349378f, 0.12298398f, 
    -0.12298376f, -0.19027118f, 0.23321646f, -0.02697404f, 0.04127150f, 0.37678987f, -0.18234937f, -0.18117149f, 
    -0.07042643f, 0.00282577f, -0.03197369f, -0.01681457f, -0.01005211f, -0.00709383f, -0.41284227f, 0.00921025f, 
    -0.00375120f, 0.22919919f, -0.08501817f, 0.20878239f, -0.02999282f, -0.17104381f, -0.18923053f, -0.23148206f, 
    -0.49769384f, -0.19145034f, -0.34726995f, 0.09080178f, -0.20311430f, 0.18900830f, 0.25803804f, 0.09216294f, 
    -0.12133493f, 0.17064403f, 0.26889494f, 0.07506778f, 0.29978433f, -0.04323844f, 0.31572309f, -0.04284751f, 
    0.08793568f, -0.08141509f, -0.32832173f, -0.39308095f, 0.09582566f, -0.11058365f, 0.01243811f, 0.00080905f, 
    -0.05856279f, 0.28483653f, -0.86956614f, -0.15445030f, -0.06314521f, -0.05837626f, -0.01460443f, 0.05134350f, 
    0.06051346f, -0.08223199f, -0.08753809f, 0.20008820f, -0.02591898f, 0.01973076f, -0.08767810f, 0.10295968f, 
    0.08485988f, 0.10486893f, -0.11639111f, -0.00315114f, -0.79290468f, 0.37420544f, 0.45264599f, -0.17849617f, 
    0.27568653f, 0.10226501f, -0.08524120f, -0.01040320f, -0.26160514f, 0.50002539f, 0.31611878f, 0.33965635f, 
    0.02157001f, 0.06255255f, -0.06032293f, -0.00816883f, -0.15633352f, 0.28349537f, -0.30263418f, -0.07259177f, 
    0.26943192f, -0.04457919f, 0.26581430f, 0.07470004f, 0.08109704f, 0.10655101f, -0.19446209f, -0.70249301f, 
    -0.28223839f, -0.17043337f, 0.03512290f, 0.03949424f, -0.27994153f, -0.24252315f, -0.15250750f, -0.10728978f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.29591465f, 0.08452315f, 0.26729423f, 0.00954597f, 0.04952600f, -0.00950994f, 0.16842784f, -0.12065101f, 
    -0.08454084f, 0.08991847f, 0.22687840f, 0.23007566f, 0.12845008f, -0.00365230f, 0.00364003f, 0.29382381f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04880602f, -0.43325582f, 0.67648071f, 0.19411315f, 0.38244173f, -0.09204945f, -0.10721452f, 0.50409329f, 
    -0.21257646f, 0.61903596f, -0.16849254f, -1.04170537f, -0.19086590f, 0.08118220f, -0.33167773f, -0.25605342f, 
    0.27472156f, 0.10267417f, 0.51475227f, -0.00617863f, -0.20762792f, -0.11061247f, -0.64553350f, 0.06526914f, 
    -0.11238512f, -0.69045651f, 0.43067077f, 0.36834142f, -0.17113654f, 0.60482466f, -0.66034925f, -0.19443086f, 
    -1.78512681f, -0.97946209f, -0.13690296f, 0.02245758f, 0.08865880f, 0.21166176f, -0.04003078f, 0.38168347f, 
    0.04798709f, -0.11348692f, 0.13681705f, -0.38153130f, -0.45022893f, 0.95468813f, 0.72995842f, -0.55232465f, 
    0.48189846f, 0.25113431f, -0.13441657f, -0.01843457f, -0.64204705f, -0.08213662f, -0.01686659f, -0.92659473f, 
    0.00321470f, 0.11122322f, -0.57047057f, -0.25784552f, 0.47776306f, -0.35000315f, 0.53761190f, 0.18580905f, 
    -0.00551028f, -0.27527434f, 0.29281631f, 0.07354214f, -0.32698318f, -0.16732153f, -0.02790085f, 0.01270272f, 
    -0.14875041f, 0.40379593f, 0.11090268f, -0.48507640f, -0.18261045f, -0.31967431f, -0.11891916f, 0.86204404f, 
    0.37847880f, -0.15256512f, -0.32603005f, -0.04190989f, 0.71154612f, 0.09119063f, -0.62938356f, 0.03278628f, 
    -0.09577929f, -0.14384761f, -0.45933408f, 0.21926558f, 0.15002957f, 0.12181854f, -0.57244778f, 0.46247384f, 
    -0.30255556f, -0.47792944f, -0.64408082f, 0.08200312f, 0.32906991f, 0.12276398f, -0.73486197f, -0.77819502f, 
    0.13475588f, 0.26609990f, 0.81641543f, 0.26071405f, 0.13660410f, -0.10923412f, -0.11646251f, 0.26399288f, 
    0.70108026f, 0.15264118f, -0.32620770f, -0.13931863f, -0.31641784f, 0.01779495f, 0.08798996f, 0.71250778f, 
    -0.18802559f, 0.44831982f, -0.41657841f, -0.13031979f, -0.78605652f, -0.20467320f, -0.13474579f, -0.04177583f, 
    0.22328760f, -0.05661450f, -0.60302484f, -0.10127124f, 0.02666887f, -0.12929244f, 1.24478078f, 0.06633911f, 
    -0.23712613f, -1.32150960f, -0.00085787f, 0.35748991f, -0.02378365f, 0.19383581f, -0.45013684f, -0.41409114f, 
    0.20652460f, -0.22597466f, 0.54923588f, -0.08245996f, -0.13604188f, 0.02587989f, 0.05263654f, 0.25260547f, 
    0.20630993f, 0.09919102f, 0.24721587f, 0.86837929f, -0.50898004f, -0.75419676f, -0.27677533f, -0.36312944f, 
    -1.08465743f, 1.00903463f, -0.54790372f, -0.12351966f, -0.70728010f, -0.14542921f, 0.18117324f, -0.16918017f, 
    -0.11457781f, -0.05162109f, -0.21604110f, 0.19602503f, -0.12367371f, 0.24653357f, 0.40592253f, -0.27642900f, 
    -0.00531720f, -0.59883487f, -0.52393717f, 0.22609983f, -0.23270141f, -0.22360967f, -0.31071478f, -0.17535661f, 
    -0.24533974f, 0.01154596f, 0.40653706f, -0.26283419f, 1.03361332f, -0.04351395f, 0.25541893f, -0.83658493f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11654646f, -0.06092760f, 0.14056523f, -0.36600542f, 0.40372795f, 0.03257663f, 0.05783379f, -1.12675083f, 
    -0.32049721f, 0.54675633f, 0.57119316f, -0.08994746f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
