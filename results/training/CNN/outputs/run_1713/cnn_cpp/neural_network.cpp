#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.42095229f, 0.20043129f, -0.00858679f, 0.35697746f, -0.33438727f, 0.21677352f, -0.16042304f, -0.00142223f, 
    -0.09153832f, -0.04384277f, 0.11424988f, 0.21936099f, -0.05880124f, -0.21228316f, 0.19284137f, 0.03915866f, 
    0.01246984f, -0.02832123f, -0.22409795f, -0.02057857f, 0.31187776f, 0.10054529f, -0.07267500f, -0.12447552f, 
    -0.20673852f, 0.13666381f, 0.07022951f, -0.14994785f, 0.17086488f, -0.20053644f, 0.14920402f, -0.32585374f, 
    0.03347015f, -0.05630350f, -0.04331778f, -0.01892511f, -0.15028241f, 0.08915967f, -0.39896736f, 0.13748252f, 
    0.22268617f, 0.21994418f, 0.24069647f, -0.09638007f, -0.24388738f, 0.36111322f, 0.05658901f, 0.20112289f, 
    -0.14519899f, -0.27757782f, 0.71148133f, -0.63328153f, -0.55567503f, 0.47870585f, -0.07183683f, 0.47544202f, 
    0.44122270f, -0.26856780f, -0.30708155f, -0.24475841f, -0.10349837f, 0.35031179f, -0.29749197f, -0.25031957f, 
    -0.17732707f, 0.18590163f, 0.07114165f, 0.19459313f, 0.14568967f, -0.00733174f, -0.02587177f, -0.21207444f, 
    -0.20942347f, -0.09050395f, 0.03063618f, -0.61579829f, 0.00843814f, 0.32801586f, 0.12195128f, 0.26745534f, 
    -0.01405407f, -0.44125015f, -0.17672350f, 0.01733514f, 0.28076297f, 0.08429328f, 0.01172213f, -0.18673074f, 
    -0.20336488f, 0.49659005f, -0.29595423f, -0.11360223f, -0.20304187f, 0.08464021f, 0.14752626f, 0.02417021f, 
    0.22202814f, -0.05489827f, -0.09565759f, 0.21436255f, -0.81180400f, -0.49678862f, 0.36737931f, 0.27389732f, 
    0.45142019f, 0.40071359f, 0.39629662f, -0.08172908f, 0.14072023f, 0.13915375f, 0.12634823f, 0.04305603f, 
    0.16985944f, -0.27225447f, -0.24616805f, 0.02581647f, -0.01451470f, 0.01387933f, -0.28576079f, 0.07276783f, 
    0.10884067f, -0.02363964f, -0.10086411f, 0.01776161f, 0.10043389f, 0.75939274f, -0.27125603f, -0.29877710f, 
    0.03380816f, 0.36201298f, -0.56931108f, -0.26628318f, 0.10332905f, 0.01543825f, 0.33448508f, -0.12660483f, 
    0.11906265f, 0.06432059f, -0.39501795f, -0.10368977f, -0.22718656f, -0.07483345f, 0.03647526f, 0.23014140f, 
    -0.15532613f, -0.13745032f, -0.15899459f, 0.18359320f, 0.13835476f, 0.02552415f, -0.31006441f, 0.45009166f, 
    0.27280098f, -0.02978713f, -0.00382116f, -0.05178242f, -0.64341569f, 0.02298467f, 0.59825784f, -0.14076392f, 
    -0.39319962f, -0.09569331f, -0.19762920f, -0.09167963f, 0.16580965f, -0.00470799f, 0.60367250f, -0.23177253f, 
    -0.04835463f, 0.06950771f, -0.24196759f, 0.06384978f, -0.12437114f, -0.15330608f, -0.14690144f, -0.65828127f, 
    -0.30116892f, -0.33557162f, 0.50581473f, 0.67122680f, 0.31988993f, 0.42191461f, 0.23862092f, -0.04756903f, 
    -0.00105734f, -0.18127356f, -0.17178120f, -0.45428815f, -0.14806470f, 0.11314741f, 0.14838146f, -0.02621260f, 
    -0.08307847f, 0.05046767f, -0.21507874f, 0.06447128f, -0.05039779f, -0.21819068f, -0.27835500f, -0.29912144f, 
    0.51480556f, -0.82002026f, 0.02319690f, 0.31396094f, -0.07729243f, 0.22331344f, 0.14732307f, -0.03966698f, 
    0.01297332f, 0.10406094f, -0.06348687f, -0.08006749f, -0.05116935f, -0.14552924f, 0.33032128f, -0.23756604f, 
    -0.15831855f, 0.00630622f, -0.15568082f, -0.10099041f, -0.22470362f, -0.27157137f, -0.25795466f, -0.00688085f, 
    0.22512001f, -0.35134086f, 0.11121444f, 0.32056513f, 0.72490501f, -0.32340330f, 0.43228891f, -0.09153752f, 
    -0.20181169f, -0.06214003f, -0.43504766f, -0.27009252f, 0.30397892f, -0.22877020f, 0.28893152f, 0.03507951f, 
    0.03309931f, -0.10500495f, -0.09168411f, 0.00644841f, 0.10074565f, -0.01607768f, -0.13773559f, 0.18458368f, 
    0.06225315f, -0.28903979f, -0.71325117f, 0.50240201f, -0.14844716f, -0.82862526f, -0.00906989f, -0.08715262f, 
    -0.00296485f, -0.11455692f, 0.25905302f, 0.07833806f, -0.19595407f, -0.56240755f, 0.08847988f, -0.56779349f, 
    -0.16993146f, 0.14997865f, -0.10518345f, -0.38697630f, -0.16154718f, -0.15398596f, 0.00732900f, -0.22329165f, 
    -0.18684977f, -0.06398010f, -0.14088875f, -0.02993316f, 0.03406787f, 0.26573235f, -0.18726216f, -0.53772867f, 
    -0.37896490f, -0.54995245f, -0.30661720f, -0.04165318f, 0.32577240f, 0.36815146f, 0.11068013f, 0.05002939f, 
    0.26222521f, -0.19405644f, 0.02578821f, -0.07179285f, 0.04381442f, -0.29744428f, -0.13872474f, 0.19912434f, 
    -0.19499581f, -0.25211778f, -0.20782624f, -0.22853062f, 0.01119918f, -0.96842259f, -0.46539271f, -0.47710338f, 
    0.04435657f, -0.01659384f, -0.01771305f, -0.01175636f, 0.38049862f, 0.39575675f, -0.18465413f, -0.21661465f, 
    -0.22285709f, -0.12049897f, 0.25097221f, -0.29376084f, 0.05332226f, -0.33602849f, -0.04866504f, -0.31338042f, 
    0.06869658f, -0.42803949f, -0.37571391f, -0.25008708f, -0.37398982f, -0.81783170f, 0.56272048f, 0.61681134f, 
    -0.51726282f, -0.12483606f, -0.76122355f, -0.49155253f, -0.01975317f, 0.27780643f, -0.23927599f, -0.15478814f, 
    -0.09594943f, -0.48086676f, 0.00124296f, 0.04209090f, 0.40834332f, -0.32879117f, -0.20768850f, -0.36722761f, 
    -0.17814881f, -0.07408890f, -0.19799149f, 0.10755043f, -0.17539187f, -0.13783576f, -0.50538582f, -0.22261433f, 
    -0.55185813f, -0.90985167f, -0.57745224f, 0.14078313f, 0.22956340f, 0.19393988f, 0.42242673f, -0.07396769f, 
    -0.38205263f, -0.34443113f, -0.24665156f, -0.01884196f, 0.10358254f, 0.22591119f, 0.29849753f, 0.03556417f, 
    -0.06095845f, 0.17687298f, -0.02630120f, -0.10202176f, 0.15578860f, 0.06259326f, -0.29203585f, 0.96306109f, 
    -0.30520043f, -0.53970844f, -0.43676034f, -0.77485394f, 0.48397389f, 0.35472271f, 0.42169863f, 0.10991658f, 
    -0.13055202f, -0.16235071f, 0.43727940f, -0.02194915f, -0.10220379f, -0.17418049f, -0.19672704f, 0.25469157f, 
    0.20388277f, -0.25782248f, 0.03490435f, -0.00006871f, 0.00269565f, -0.08746272f, 0.13837329f, -0.11300563f, 
    0.21843345f, 0.27178639f, 0.02539969f, 0.04372565f, -0.15469106f, -0.06994252f, 0.17557411f, -0.12386694f, 
    -0.42150772f, 0.22006759f, 0.29385632f, -0.38288248f, -0.11832897f, -0.27871862f, 0.16688439f, -0.03391253f, 
    0.01880476f, -0.08305805f, 0.14529550f, -0.20019059f, 0.08444308f, -0.27221426f, -0.11066707f, -0.09549604f, 
    -0.23282623f, 0.96160454f, 0.68406928f, 0.29493502f, -0.17467745f, -0.41418752f, -0.35995501f, -0.52760595f, 
    -0.24630046f, -0.77492356f, -0.94173473f, 0.03884953f, -0.04335380f, -0.28488818f, -0.14067055f, 0.36488330f, 
    0.20421471f, 0.04999240f, -0.07110810f, 0.17101124f, -0.12084524f, -0.28662750f, 0.07284479f, 0.08566023f, 
    -0.01727461f, 0.18668555f, -0.90830618f, 0.39096591f, 0.19617677f, -0.41999564f, -0.34539041f, -0.15997653f, 
    0.22317277f, 0.14575961f, 0.44202474f, 0.47171471f, -0.07312601f, 0.24348922f, -0.11153813f, -0.46681046f, 
    -0.45349559f, 0.10164086f, 0.01221667f, -0.11457827f, 0.28301248f, 0.08417348f, -0.25336489f, 0.21747072f, 
    -0.16197895f, -0.17427047f, -0.33156702f, -0.19088019f, -0.25370836f, -0.11006265f, -0.01568140f, -0.03522157f, 
    0.38395309f, -0.04314639f, -0.31792739f, -0.27967611f, 0.08821579f, 0.09220361f, 0.27614981f, -0.22836709f, 
    -0.31195849f, 0.22333297f, 0.17738999f, 0.03817093f, 0.14528979f, -0.08741201f, -0.00081955f, -0.03649547f, 
    -0.13196866f, -0.14315943f, 0.08268534f, -0.44042656f, -0.30998966f, 0.12779219f, -0.67346543f, -0.42759523f, 
    -0.33550903f, -0.05447034f, 0.02644345f, -0.17500019f, -0.05718899f, -0.12445693f, -0.02686981f, 0.39437073f, 
    -0.01446395f, 0.66686344f, -0.39357725f, -0.29207698f, -0.54443401f, -0.49060240f, 0.07725552f, -0.31868696f, 
    0.02711366f, -0.11552934f, 0.24623506f, 0.35687754f, -0.18492021f, -0.75886816f, -0.67880958f, -0.34074733f, 
    -0.01207028f, -0.18531975f, -0.11878560f, -0.40815061f, -0.59213120f, -0.52316576f, -0.43066165f, -0.14177418f, 
    -0.18273662f, -0.24560878f, 0.10528567f, -0.29356101f, -0.07791787f, -0.10619234f, -0.20892239f, -0.00155242f, 
    0.03820886f, -0.09534454f, -0.19379276f, -0.27363938f, -0.31392372f, -0.22705629f, 0.32847086f, 0.65643388f, 
    0.13531339f, 0.04465159f, -0.52255440f, -0.59839535f, -0.23430908f, 0.45726332f, 0.06392033f, -0.01530654f, 
    -0.45172906f, 0.25658429f, 0.40286502f, 0.23056261f, -0.31372792f, 0.21556383f, 0.19538236f, -0.31646818f, 
    -0.32942802f, -0.15517405f, -0.25963727f, 0.06315171f, 0.20388038f, -0.14900422f, -0.05245917f, -0.81204259f, 
    -0.47630298f, -0.47929463f, -0.67559695f, -0.34488595f, 0.20126563f, -0.18806149f, -0.07993902f, 0.14407173f, 
    0.22779831f, -0.19576645f, -0.12359381f, 0.22392255f, 0.34565765f, 0.15403317f, -0.05070275f, -0.24810530f, 
    -0.13711354f, 0.00941844f, -0.02093872f, -0.22085683f, 0.30158818f, -0.22848614f, -0.19215767f, -0.12418868f, 
    -0.61796689f, 0.52722907f, -0.01819895f, -0.60863715f, 0.13783519f, -0.11403833f, 0.04842674f, 0.08102625f, 
    0.41385308f, 0.06614962f, -0.37791634f, -0.41060832f, -0.18354709f, -0.46875122f, 0.24263355f, 0.43544462f, 
    -0.26537776f, 0.15535833f, -0.22212303f, -0.12150721f, 0.07240925f, -0.29307473f, -0.15338904f, 0.08737417f, 
    0.28823987f, 0.01235312f, 0.05764094f, 0.00004754f, -0.38391465f, -0.25321609f, 0.12178821f, 0.25935018f, 
    -0.42283040f, -0.49710217f, -0.37917042f, 0.31754464f, 0.10033719f, 0.22997084f, 0.24922919f, 0.30162966f, 
    -0.27817672f, -0.34888959f, 0.07760258f, -0.06450422f, 0.11483903f, 0.29635468f, -0.13017759f, -0.16352667f, 
    -0.03489383f, -0.19666062f, 0.26260278f, 0.76625949f, 0.84914857f, -0.64213085f, -0.31725776f, -0.55577469f, 
    -0.28519043f, -0.00587385f, 0.10384441f, -0.08542771f, 0.06073257f, -0.10047873f, -0.12274930f, 0.35256064f, 
    -0.23535265f, -0.10846469f, -0.02987932f, 0.09840719f, 0.24097076f, -0.08649007f, 0.25824636f, -0.13336720f, 
    -0.23467453f, 0.11684856f, -0.20631586f, 0.12359727f, -0.52933019f, -0.28988194f, -0.01320799f, 0.11468452f, 
    0.30819693f, -0.13545468f, 0.27621880f, 0.45353606f, 0.04245273f, -0.04671609f, 0.13279729f, -0.15856558f, 
    -0.01735832f, 0.01069744f, -0.45798948f, 0.00726515f, -0.17497259f, 0.23221208f, 0.00778172f, 0.24820760f, 
    0.20208424f, 0.08931632f, -0.16079876f, 0.24685010f, 0.59948999f, -0.11724737f, -0.50707430f, -0.95551294f, 
    -0.44813120f, -0.28398624f, -0.27113530f, -0.04627256f, 0.50155324f, -0.01035035f, -0.02439766f, 0.13417044f, 
    0.51098102f, -0.03886069f, 0.16823350f, -0.01544863f, 0.09951595f, 0.11185806f, -0.18532987f, -0.07867903f, 
    -0.11391963f, -0.21473463f, -0.37467280f, 0.10448021f, 0.11503004f, -0.38251099f, -0.80197108f, 0.02036915f, 
    0.28772253f, 0.46407139f, -0.39267740f, -0.00644604f, -0.03922606f, 0.42858019f, -0.20881973f, -0.36018673f, 
    0.42142865f, -0.16309281f, -0.00312614f, 0.39338148f, -0.04039158f, -0.02646127f, -0.11673236f, -0.42642710f, 
    -0.28885740f, 0.30201527f, -0.33331606f, 0.07662755f, 0.20064932f, 0.16678064f, -0.74317372f, 0.03908342f, 
    0.47056109f, -0.05211899f, -0.06956712f, 0.07499339f, -0.61833096f, -0.28306630f, 0.52668220f, -0.26775333f, 
    0.26837158f, 0.16276275f, -0.21043062f, 0.08125098f, -0.25854838f, 0.19665335f, -0.20155889f, -0.09395996f, 
    -0.44011676f, 0.03020686f, 0.15407774f, -0.04355067f, -0.12402731f, 0.09485084f, 0.25281429f, 0.04293822f, 
    -0.50986111f, -0.66707319f, -0.68127555f, -0.55384356f, 0.31784040f, 0.16998325f, 0.10483625f, -0.01805579f, 
    0.07892530f, 0.13217580f, -0.14740580f, -0.17530259f, 0.06045743f, -0.13381347f, -0.13668993f, -0.45195976f, 
    -0.01983718f, -0.20152238f, -0.34494978f, -0.08877962f, 0.05494514f, 0.13875932f, 0.08625688f, 0.04783723f, 
    0.06001341f, -0.26505175f, 0.28147370f, 0.28045294f, 0.07546315f, -0.09865574f, 0.20600978f, -0.03313673f, 
    -0.00308581f, -0.05149494f, 0.05967410f, -0.15955171f, -0.17309740f, 0.15552752f, -0.19524086f, -0.29986513f, 
    -0.19609919f, -0.12167741f, 0.05141514f, 0.08012669f, 0.13212845f, -0.30336142f, -0.34703538f, -0.18298225f, 
    -0.32922685f, 0.41808876f, -0.62355071f, -0.50809813f, -0.08631130f, -0.11339107f, 0.09136979f, -0.11801911f, 
    0.36631900f, 0.51567835f, -0.45748758f, 0.06165011f, 0.33600646f, 0.23915744f, -0.06663364f, -0.04585386f, 
    0.09893885f, -0.07945794f, -0.10833185f, -0.30486521f, -0.32769692f, 0.27054593f, 0.41440675f, 0.08192472f, 
    -0.18452844f, 0.19207323f, -0.17209642f, -0.46555454f, -0.98875928f, -0.54451674f, 0.24721053f, -0.10104733f, 
    -0.02313347f, 0.68240303f, -0.03909603f, -0.09215211f, 0.24958146f, 0.04479193f, 0.35067222f, -0.36058521f, 
    0.04893906f, 0.33669114f, -0.25205016f, -0.42347336f, 0.20997851f, -0.36630189f, -0.19247785f, 0.12621935f, 
    0.03862330f, -0.04360279f, -0.16315015f, 0.48655760f, 0.44872615f, 0.08033473f, 0.10726621f, -0.66630536f, 
    -0.06231659f, -0.59983760f, 0.10376010f, 0.45453176f, -0.25257781f, 0.29685244f, -0.24199149f, -0.24611969f, 
    -0.15641111f, 0.00201135f, 0.05946852f, 0.07633893f, 0.02774708f, -0.06491889f, 0.13487460f, 0.02529009f, 
    -0.26356012f, -0.24849440f, 0.20615354f, 0.16072527f, 0.63388145f, 0.14311086f, -0.28940323f, -0.57579648f, 
    -0.34504876f, 0.72197658f, 0.17040773f, -0.19852921f, -0.09224813f, -0.30600047f, 0.08710662f, -0.12657076f, 
    -0.24195644f, 0.07111655f, -0.08308204f, -0.11564068f, 0.33359924f, 0.19552261f, -0.08760336f, -0.15686208f, 
    0.48260340f, -0.19618218f, -0.52288353f, -0.11196073f, -0.10846507f, -0.85890406f, -0.37983599f, -0.29507878f, 
    0.01881831f, 0.14219895f, 0.75373310f, 1.00115275f, -0.08654550f, -0.41420460f, -0.46241885f, 0.08661655f, 
    0.42412859f, -0.35115206f, -0.31896740f, -0.23277149f, -0.22353062f, -0.11059320f, -0.13210534f, -0.10910042f, 
    0.23851097f, 0.24994095f, -0.18114565f, -0.17989592f, 0.02451576f, -0.01475737f, -0.23627721f, -0.30812326f, 
    0.02235553f, 0.54311454f, 0.00890340f, -0.35410306f, -0.51134920f, -0.23640206f, 0.34193590f, 0.55102605f, 
    0.12514743f, -0.32901207f, -0.04834163f, 0.03839766f, 0.51305079f, -0.23175757f, -0.04123387f, 0.01671090f, 
    0.07796480f, -0.21747851f, 0.21931975f, 0.24196604f, 0.03717145f, -0.14916447f, 0.00032195f, -0.62152326f, 
    -0.95273304f, -0.39892164f, 0.29296458f, 0.47895816f, -0.20062336f, -0.49471983f, -0.04220814f, 0.46887702f, 
    -0.04263334f, 0.37251207f, 0.00850074f, 0.25636524f, 0.21748631f, 0.12501431f, 0.19112116f, -0.23914653f, 
    0.07833279f, -0.16781768f, -0.06021338f, -0.11995868f, -0.07336585f, 0.08350353f, -0.12198114f, -0.30161285f, 
    0.84588027f, 0.38844165f, -0.32124040f, -0.25436425f, -0.63347411f, 0.52927715f, 0.08780500f, 0.33081532f, 
    -0.34390947f, -0.45907038f, -0.25877935f, 0.13186897f, -0.15743488f, -0.07301103f, -0.18386248f, -0.04949500f, 
    -0.10289574f, 0.35881084f, -0.36679944f, -0.03677088f, 0.19191585f, -0.26368108f, -0.06195866f, 0.38278136f, 
    0.08945386f, -0.27733994f, -0.48570198f, -0.15766114f, -0.10055112f, -0.09569035f, 0.53605509f, 0.38051590f, 
    -0.05609871f, 0.06117731f, 0.03863746f, -0.23795711f, -0.15841982f, -0.12076671f, 0.21912603f, 0.25444254f, 
    0.15375829f, 0.13869518f, -0.32517022f, -0.06405579f, -0.05651915f, -0.11610927f, 0.02072135f, -0.12812144f, 
    0.31264392f, -0.09727431f, -0.65542483f, -0.48406497f, -0.47249195f, -0.12152965f, -0.43066064f, 0.51837093f, 
    -0.49044135f, -0.50960243f, -0.03205941f, -0.17563817f, -0.36419562f, -0.21271442f, 0.03400728f, -0.09508032f, 
    -0.32896781f, 0.19662553f, 0.04398710f, 0.02711982f, 0.12027317f, 0.15126580f, -0.04070329f, 0.21336859f, 
    0.29205701f, 0.00779860f, 0.22969815f, -0.66803718f, -0.22337410f, 0.06473866f, -0.51052797f, -0.42033234f, 
    -0.35896394f, -0.57999873f, -0.51186299f, -0.41054717f, -0.09000602f, -0.01328394f, -0.03106633f, -0.00615412f, 
    -0.24386442f, -0.34938967f, -0.24240707f, -0.45095587f, -0.27563822f, -0.44634074f, -0.15866344f, -0.00907132f, 
    0.10068058f, 0.00980197f, 0.24439873f, 0.08413291f, 0.68418378f, 0.07738002f, -0.39778507f, -0.24840626f, 
    -0.68287265f, 0.03686201f, -0.13313915f, 0.03535585f, 0.30588546f, 0.35727629f, 0.02012235f, 0.13383758f, 
    -0.24888866f, 0.25234160f, -0.08356363f, -0.29828146f, -0.27686360f, 0.32744375f, 0.01271898f, -0.01683668f, 
    0.10262351f, 0.05839229f, 0.19167723f, -0.10683297f, 0.04734730f, 0.20498481f, -0.51948184f, -0.20709716f, 
    0.00498315f, -0.57282025f, -0.80155486f, -0.50251925f, -0.62082124f, -0.45138913f, -0.85129374f, 0.26537234f, 
    0.29870629f, -0.04745163f, 0.47518083f, 0.01344932f, -0.09105803f, -0.21109912f, -0.01454250f, -0.21928319f, 
    -0.22655347f, -0.30182976f, -0.10405546f, -0.07939791f, 0.10074230f, -0.18161356f, -0.69947946f, -0.19936734f, 
    0.34322241f, 0.20739514f, 0.24496819f, -0.52343923f, -0.43261650f, 0.40957063f, 0.36174512f, 0.06040566f, 
    0.07031894f, 0.15954231f, 0.30866417f, -0.46640298f, -0.13281737f, -0.03804595f, 0.19814830f, -0.21399738f, 
    -0.01973870f, -0.24380231f, 0.12354231f, -0.18327303f, 0.01286796f, -0.02530583f, 0.20085214f, -0.09566762f, 
    0.15263852f, 0.34732708f, 0.18931963f, 0.00837667f, 0.12640436f, -0.06878776f, -0.23176952f, 0.46540591f, 
    0.34029657f, 0.42878184f, -0.20022467f, -0.40727907f, -0.13478866f, -0.39764187f, 0.19492720f, -0.12123771f, 
    -0.19948056f, -0.23467204f, 0.07963648f, -0.09749878f, 0.27698275f, 0.11881721f, -0.11457431f, -0.15143418f, 
    -0.54195029f, -0.38110414f, -0.00078199f, 0.44516316f, -0.38646781f, -0.06737994f, -0.38748312f, -0.01814362f, 
    -0.23861367f, 0.38421360f, 0.26512110f, 0.20452550f, 0.00770422f, 0.31026518f, 0.23531349f, -0.16217837f, 
    -0.21451013f, -0.00851874f, 0.04160552f, -0.02962456f, -0.03076486f, 0.14262366f, -0.03186223f, 0.16637191f, 
    -0.23176734f, 0.74881768f, -0.75947165f, -0.20586854f, 0.47130293f, 0.09409168f, 0.43419254f, -0.14908253f, 
    -0.14779855f, -0.07077625f, 0.13286310f, -0.20679402f, 0.23087634f, -0.25255609f, -0.11955688f, -0.09330613f, 
    0.08716856f, 0.18316472f, 0.09177998f, -0.18540478f, -0.15701599f, -0.16763605f, 0.16500774f, 0.03724684f, 
    -0.18186277f, -0.06906942f, -0.74034590f, -0.67580849f, -0.05443495f, -0.11902929f, -0.60662705f, 0.39000657f, 
    0.31715041f, -0.07973287f, -0.10277253f, 0.21992731f, -0.03750855f, 0.20384362f, 0.19069056f, 0.14458103f, 
    -0.21490912f, -0.29790640f, 0.19155097f, 0.08392095f, -0.08873814f, 0.12493128f, -0.22700205f, -0.08323184f, 
    0.25758988f, -0.26988044f, -0.24076077f, 0.06669805f, 0.28184977f, -0.14155926f, 0.01368334f, 0.11919941f, 
    0.07987058f, -0.16346386f, -0.21370250f, 0.02520409f, 0.08402169f, 0.14350429f, 0.13398260f, 0.07873960f, 
    0.09128996f, 0.07812580f, -0.01171372f, 0.07290003f, 0.22391377f, 0.03781815f, 0.12564842f, 0.06908645f, 
    0.04704527f, 0.16944863f, -0.07124820f, 0.03324308f, -0.37775698f, -0.34896550f, 0.32171610f, 0.34113485f, 
    -0.15272820f, 0.06796115f, 0.01705565f, -0.18617691f, -0.48026973f, -0.29577151f, 0.51915038f, -0.15689375f, 
    0.23165680f, -0.29715717f, -0.11263715f, -0.04016189f, 0.03535447f, 0.21195354f, 0.00356680f, -0.06173112f, 
    -0.16322297f, -0.19179398f, -0.11513775f, -0.04083687f, 0.22432590f, -0.98864216f, -0.05916953f, 0.22069347f, 
    -0.76128352f, -0.39606953f, 0.49628678f, 0.47165847f, 0.04011730f, 0.12253336f, 0.31949207f, -0.10068224f, 
    0.04854039f, 0.03810820f, 0.18439402f, -0.06122898f, 0.09069188f, -0.00389431f, -0.09282864f, -0.22024187f, 
    -0.06170844f, -0.05297732f, 0.05817065f, 0.04115081f, 0.02509079f, -0.11294241f, -0.74232519f, -0.05462540f, 
    -0.31008729f, -0.09838253f, -0.16108173f, 0.07410717f, 0.24081346f, 0.34009764f, 0.44901717f, 0.56915289f, 
    -0.07416058f, 0.04527364f, -0.18091303f, -0.06777711f, -0.05129733f, -0.44052014f, 0.05175827f, -0.17548473f, 
    0.06887963f, -0.15491097f, 0.00283868f, 0.31205311f, 0.25092456f, 0.01971157f, 0.32894781f, 0.75230861f, 
    -0.35472530f, 0.30186361f, -0.10420953f, -0.30116504f, -0.41339862f, 0.09289218f, 0.04976194f, 0.02392509f, 
    -0.04678662f, -0.00594534f, -0.03402202f, -0.11050284f, -0.31917852f, 0.27451590f, -0.02167377f, 0.10803904f, 
    -0.16472928f, -0.17645204f, -0.57134759f, -0.26418272f, -0.34839490f, -0.26832247f, -0.46086103f, -0.43158397f, 
    -0.67179680f, -0.43631396f, 0.21860477f, -0.41200164f, 0.31056130f, -0.24383321f, -0.72846496f, -0.52053130f, 
    -0.16143398f, -0.14204004f, -0.07773008f, 0.08349045f, -0.25323984f, -0.29645628f, -0.51186502f, -0.12871709f, 
    0.07943940f, -0.12615652f, 0.07206841f, 0.01571351f, -0.21548308f, 0.22659674f, -0.10766573f, -0.19629391f, 
    -0.27445582f, -0.16280849f, -0.46109474f, -0.21968441f, 0.40521976f, 0.29720184f, -0.41099826f, -0.35507679f, 
    -0.40483487f, -0.17074494f, 0.14167437f, 0.13278945f, 0.23822880f, -0.01463023f, 0.07852098f, 0.22864325f, 
    0.24225682f, 0.15750286f, -0.00495466f, 0.28726307f, -0.17680596f, -0.28869089f, 0.21284686f, 0.05590447f, 
    -0.03503220f, -0.35765198f, 0.23168308f, 0.27670282f, -0.61162102f, -0.63451791f, -0.01003607f, 0.45011798f, 
    0.22202471f, 0.09073567f, -0.30116382f, -0.45429122f, -0.07084934f, 0.53485447f, -0.14062043f, 0.19121660f, 
    -0.28541529f, -0.46310210f, -0.00765511f, -0.28018734f, 0.13563268f, -0.19382238f, -0.07322044f, 0.09784742f, 
    0.08941264f, 0.00939954f, 0.36713278f, 0.48838475f, 0.44462571f, 0.00501623f, -0.37998024f, -0.25838846f, 
    0.17342886f, 0.09248430f, -0.12973998f, -0.04766636f, 0.04510546f, -0.14193937f, -0.40975156f, 0.00956543f, 
    -0.03146178f, -0.04449333f, -0.12431462f, -0.06136560f, -0.06267399f, -0.07324746f, -0.04869605f, -0.35310718f, 
    -0.18340597f, -0.26304555f, -0.36471400f, -0.56380165f, 0.50117433f, 0.16471991f, -0.04038319f, -0.13734868f, 
    -0.32942134f, -0.24592797f, 0.22705816f, 0.16875096f, -0.00107229f, -0.04627850f, 0.19279997f, 0.21164669f, 
    -0.09841259f, -0.13059746f, -0.25103810f, -0.12364186f, -0.30922166f, 0.31138363f, 0.24208036f, -0.10102908f, 
    0.31077528f, 0.01500166f, -0.19559465f, -0.28735071f, 0.27679259f, -0.20033154f, -0.37194002f, -0.06424001f, 
    0.28189117f, -0.17659973f, -0.30569762f, 0.44120356f, 0.11029822f, -0.69071305f, 0.03257148f, -0.08190294f, 
    -0.33821997f, 0.00994639f, 0.39704663f, -0.50824475f, 0.09225043f, -0.25508654f, -0.17327285f, 0.09350608f, 
    -0.17171754f, -0.20677748f, -0.00413233f, -0.16147572f, 0.21872155f, 0.33010277f, 0.17974801f, 0.12598783f, 
    -0.04681415f, -0.26276171f, 0.32464561f, -0.29990003f, 0.19095376f, 0.26885876f, -0.04462987f, 0.05942538f, 
    0.35078317f, -0.14634509f, 0.26537159f, 0.20810843f, -0.22700995f, -0.06584066f, -0.17162535f, -0.16445406f, 
    0.05637142f, -0.29108796f, -0.03228495f, 0.04565151f, 0.17044008f, 0.26915449f, 0.13143672f, 0.16265440f, 
    -0.78779864f, -0.50398290f, 0.03470118f, -0.46812981f, 0.21969429f, 0.30350062f, 0.11638944f, 0.42044756f, 
    0.06466783f, -0.00984600f, 0.09281632f, 0.43505579f, -0.26345637f, -0.03211772f, -0.07844944f, -0.18527354f, 
    0.12584171f, 0.02384225f, 0.20649220f, -0.22906445f, -0.21701464f, 0.01746797f, 0.14752877f, 0.08823896f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00100906f, -0.06708696f, 0.09810267f, 0.27453291f, 0.39906779f, 0.38173777f, 0.14847122f, 0.16342826f, 
    0.21295366f, 0.07532666f, 0.06331192f, -0.00142426f, 0.14923093f, 0.30666673f, -0.44960794f, 0.36885121f, 
    -0.02376306f, 0.12619984f, -0.10595589f, 0.03134847f, -0.00261211f, -0.46316463f, 0.23743661f, -0.27534699f, 
    0.19901580f, 0.10229091f, 0.15289144f, 0.08050861f, 0.53896749f, 0.14827533f, 0.11659530f, -0.07816983f, 
    -0.15655544f, -0.05720519f, 0.22935140f, 0.20405197f, 0.22209194f, 0.27052554f, 0.36707422f, 0.26505977f, 
    0.31763199f, -0.05481911f, -0.22539173f, 0.02506088f, 0.27934214f, -0.16232720f, 0.21136279f, 0.16175827f, 
    0.26170495f, 0.22475971f, -0.01984979f, -0.12635517f, 0.27568403f, 0.14046332f, 0.19251424f, -0.21683852f, 
    -0.31403458f, 0.03162688f, 0.31431034f, -0.00396288f, 0.17388691f, 0.24487576f, 0.13889980f, 0.21618469f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.13779713f, -0.10406981f, -0.07580787f, -0.02559626f, 0.00397900f, 0.02563732f, 0.01640777f, 0.02923786f, 
    -0.03731839f, 0.00947958f, 0.06647756f, 0.00940079f, 0.05235407f, 0.00497074f, 0.02011831f, 0.06932297f, 
    -0.08897109f, -0.02477891f, -0.01288779f, 0.09575561f, -0.04524944f, 0.03118414f, 0.01771434f, 0.04977760f, 
    0.17535371f, -0.14287564f, -0.17572923f, 0.03148562f, -0.00265516f, -0.08742152f, 0.04638782f, -0.07838655f, 
    0.00026696f, 0.04144681f, -0.04233152f, -0.05434746f, -0.13417134f, 0.19005309f, 0.23755740f, -0.29570836f, 
    -0.14100578f, 0.04184324f, 0.03202997f, -0.06397040f, 0.00013781f, -0.03112672f, -0.03422045f, -0.17731638f, 
    0.10816219f, 0.03867540f, -0.01053037f, -0.06692192f, -0.06232104f, -0.00544798f, 0.03412472f, 0.04361190f, 
    -0.19665745f, -0.07810943f, 0.00510970f, -0.15822917f, -0.72749847f, 0.24565785f, -0.15659942f, -0.17134292f, 
    -0.04385879f, 0.00327482f, -0.00591963f, 0.02095803f, -0.04328786f, -0.05652496f, -0.02711605f, 0.01056723f, 
    -0.32334280f, 0.16061917f, 0.18854389f, -0.14381541f, -0.04253827f, -0.01142825f, -0.04289197f, 0.08860195f, 
    0.02396383f, -0.02366364f, -0.06609330f, -0.09461979f, 0.25934425f, -0.08876447f, -0.13594948f, -0.16538493f, 
    0.00573914f, -0.01803639f, 0.04272884f, -0.00693497f, -0.06501989f, 0.00740460f, 0.00426766f, 0.16915487f, 
    -0.18869625f, -0.27774748f, -0.18910225f, 0.04327889f, -0.02148010f, -0.01313519f, 0.01730538f, 0.01520057f, 
    0.11963729f, -0.05453391f, 0.02553156f, 0.01591766f, -0.16558479f, -0.50459182f, -0.07643910f, -0.27578762f, 
    0.00991882f, -0.06874929f, -0.04952308f, 0.05325115f, -0.07942629f, -0.03172396f, 0.01893239f, -0.05092364f, 
    -0.02059052f, 0.23716980f, 0.05874503f, 0.04487761f, -0.06681599f, 0.05857779f, -0.08498251f, 0.05189662f, 
    -0.11090843f, -0.10849366f, -0.00832557f, -0.05408093f, 0.08363999f, 0.08231983f, 0.11298702f, -0.19245476f, 
    -0.03163882f, -0.06496990f, -0.03776087f, 0.11275459f, -0.00175481f, -0.01176281f, 0.03787095f, -0.02939763f, 
    0.17070247f, 0.08401787f, 0.01141444f, -0.06238105f, 0.10098867f, 0.03105688f, 0.03842203f, -0.18305300f, 
    -0.02216908f, 0.07268409f, 0.04747324f, 0.06396726f, -0.03695660f, 0.10614881f, 0.03988771f, -0.06267713f, 
    -0.13169713f, 0.04988711f, -0.11078084f, 0.10013741f, -0.07783273f, -0.04165597f, -0.09991975f, -0.05270401f, 
    0.16306603f, 0.03406243f, -0.02367359f, -0.04154838f, 0.12681255f, 0.28638601f, 0.08166584f, -0.02599374f, 
    -0.00957288f, 0.03419356f, 0.09644996f, 0.04208064f, 0.04557749f, -0.43978676f, -0.41913891f, 0.05336200f, 
    0.05598612f, 0.00920246f, -0.21571293f, -0.01138894f, -0.01125636f, 0.05468813f, -0.07675464f, -0.03698634f, 
    -0.23581342f, -0.03249938f, 0.02615591f, 0.08771803f, 0.02175815f, 0.00624393f, -0.02611371f, -0.04974344f, 
    -0.00284458f, -0.04915395f, 0.02511617f, 0.08486186f, 0.07420098f, -0.09350617f, -0.18543780f, -0.08407906f, 
    0.00732753f, 0.00981708f, 0.14355347f, -0.02045062f, 0.00747412f, 0.09295730f, 0.00787025f, 0.00745317f, 
    -0.34006754f, -0.00553466f, 0.13632515f, -0.06070779f, 0.00590121f, 0.11652134f, 0.08787514f, 0.10489009f, 
    0.04066796f, 0.11419117f, 0.02904903f, -0.00412870f, 0.06903407f, 0.10141021f, -0.01923659f, 0.06886127f, 
    0.02368832f, -0.02620790f, 0.00337599f, 0.01045036f, -0.04148793f, 0.00014813f, 0.05131179f, 0.10153002f, 
    0.20062228f, 0.06441187f, -0.12735291f, 0.00920082f, 0.07529645f, 0.02548323f, -0.08139301f, -0.01939459f, 
    0.02354988f, -0.17586194f, -0.06083270f, -0.00569665f, 0.37545255f, 0.19632594f, 0.00405483f, -0.09862994f, 
    0.11507539f, 0.11453094f, 0.16170137f, 0.13744745f, -0.02833529f, -0.02971482f, -0.00847484f, -0.02184526f, 
    -0.33018094f, -0.50352442f, 0.17673945f, -0.00193282f, -0.01969221f, -0.03174136f, -0.02899074f, -0.00316668f, 
    -0.07776413f, 0.00505255f, -0.04668287f, 0.05646871f, 0.23487379f, 0.13173161f, 0.04370464f, -0.10110644f, 
    0.07809305f, 0.20053513f, -0.01344964f, -0.14425217f, -0.03526022f, 0.01445423f, 0.02290458f, 0.03772593f, 
    -0.38227889f, 0.24640001f, 0.10457621f, -0.01454442f, -0.07474233f, 0.01980795f, -0.04549272f, -0.00995199f, 
    0.03128556f, 0.03714961f, 0.16229817f, -0.20485082f, 0.10640750f, 0.04042754f, -0.29215118f, 0.02778793f, 
    0.00194582f, -0.01498083f, -0.09510844f, -0.00412917f, 0.07206469f, -0.04041975f, -0.02915835f, 0.01002670f, 
    -0.06811881f, 0.06538562f, -0.04270378f, 0.09558699f, 0.06540775f, -0.03523913f, -0.01798337f, -0.07677240f, 
    0.00352501f, -0.01376950f, -0.02863544f, 0.03533416f, -0.00533304f, 0.04282908f, -0.00615961f, -0.02065394f, 
    -0.00115611f, -0.02109315f, 0.00281104f, -0.01677040f, -0.08672975f, -0.01689257f, -0.09785929f, -0.08395037f, 
    0.18151857f, -0.03194011f, -0.06600947f, 0.00178951f, 0.04154171f, 0.03817086f, -0.16291581f, -0.08247560f, 
    -0.09054833f, -0.10544492f, -0.00780414f, 0.05202906f, 0.00121694f, 0.10039752f, -0.01054551f, -0.22279854f, 
    0.02131625f, -0.02017170f, 0.06759427f, -0.03562646f, 0.00425709f, -0.09702040f, -0.02754818f, -0.09122130f, 
    0.15388757f, 0.27116477f, 0.29663303f, -0.40168354f, -0.10550834f, 0.05861076f, -0.06630290f, 0.10406058f, 
    0.01803447f, -0.03440757f, 0.00709281f, -0.13619384f, 0.17707001f, 0.09207485f, -0.11591960f, 0.01022806f, 
    0.06413171f, 0.15069163f, -0.05069095f, -0.04637027f, 0.01855880f, -0.04766766f, -0.05320591f, 0.03620965f, 
    -0.05752895f, -0.20737164f, 0.00706146f, -0.06250700f, -0.04457564f, -0.02205941f, 0.06652378f, -0.01042847f, 
    0.05487840f, -0.04924239f, 0.02227397f, 0.14685230f, 0.04421657f, 0.08182551f, -0.07426452f, -0.01542842f, 
    -0.03721824f, -0.03263760f, 0.04069837f, -0.17190249f, -0.26562679f, -0.08051380f, 0.00444116f, -0.02703242f, 
    0.24532162f, 0.13865742f, -0.14915155f, 0.00825374f, 0.07736097f, 0.06107554f, 0.03140434f, -0.13436182f, 
    -0.11110725f, -0.05040947f, -0.09886774f, 0.10347585f, -0.22796398f, -0.13497360f, -0.05353765f, -0.08534358f, 
    0.01370610f, 0.05907229f, -0.05803712f, -0.04969563f, -0.03447800f, 0.01439873f, -0.05860572f, -0.03730886f, 
    -0.00850995f, -0.21552360f, -0.55776328f, -0.07242429f, -0.02657968f, 0.01275027f, -0.12406329f, 0.05082017f, 
    -0.14960451f, -0.03118124f, -0.12524405f, -0.02969965f, 0.35297966f, 0.04588356f, -0.45750135f, -0.13734254f, 
    -0.02142331f, -0.02694940f, 0.05776145f, -0.10964187f, -0.09945178f, -0.09791929f, -0.04201791f, -0.10032500f, 
    -0.07778028f, 0.20553124f, 0.14850228f, -0.28688487f, -0.12264775f, 0.03747446f, 0.04520389f, -0.01203677f, 
    -0.02944624f, -0.20031290f, -0.08159105f, -0.13028651f, 0.19926901f, 0.22315849f, 0.08578694f, -0.14543852f, 
    0.03939262f, 0.05741030f, 0.02358088f, -0.06402429f, 0.05157157f, -0.03018609f, -0.05235418f, 0.00459687f, 
    -0.06121212f, -0.45071656f, -0.58331919f, 0.07342915f, -0.01259944f, 0.07417307f, -0.12091687f, -0.07795900f, 
    0.00526152f, -0.00979174f, -0.03590648f, 0.03488610f, 0.12786388f, -0.02195161f, -0.14474864f, 0.03780809f, 
    0.03045179f, -0.01850690f, -0.03490373f, -0.05382273f, -0.05222616f, -0.04333999f, -0.00308240f, -0.00460295f, 
    0.33446315f, 0.19179046f, -0.11147848f, -0.18602744f, 0.07125053f, 0.10389060f, 0.04487785f, 0.06258044f, 
    -0.01576476f, 0.00935050f, 0.02584003f, 0.01909514f, 0.18846431f, 0.11778790f, 0.00270935f, -0.16687030f, 
    0.07929856f, 0.11947678f, 0.06968885f, 0.04133195f, -0.09121102f, -0.08806089f, -0.07710113f, -0.05190105f, 
    -0.06968267f, -0.25256488f, -0.15364662f, 0.08167309f, -0.07406154f, -0.08693289f, -0.16019948f, -0.01289100f, 
    -0.07174385f, -0.10513962f, -0.07801935f, 0.01236567f, 0.29510868f, 0.15236463f, -0.07573247f, -0.22819060f, 
    0.10622260f, -0.10336094f, 0.05467997f, 0.04454364f, -0.03593579f, 0.03079983f, -0.06141222f, 0.02701950f, 
    -0.04505308f, 0.20719668f, 0.42414203f, -0.21495041f, -0.21861088f, -0.00916940f, 0.08140210f, 0.00833039f, 
    -0.05178729f, -0.21967283f, 0.05219802f, -0.04046020f, -0.49347883f, -0.07679356f, 0.27512199f, -0.16723999f, 
    0.01179798f, 0.00381946f, 0.02239884f, 0.00577662f, -0.01530796f, 0.06170646f, -0.06121559f, -0.02882604f, 
    0.07640944f, 0.08382860f, 0.09010001f, -0.21987480f, -0.00719586f, -0.04672660f, -0.02291989f, -0.00492138f, 
    0.07149702f, -0.00990227f, -0.07046468f, 0.03485130f, -0.08151406f, -0.25225219f, 0.05044940f, 0.00173692f, 
    -0.05260164f, -0.03217390f, 0.06195561f, -0.04234561f, 0.01086461f, 0.06932459f, 0.06652962f, -0.00506546f, 
    0.28903690f, 0.03128904f, -0.07008804f, -0.06418775f, 0.06596524f, 0.06893825f, 0.06090618f, -0.08707894f, 
    0.07288051f, 0.03705967f, 0.05276432f, -0.01279307f, 0.02016207f, 0.06695724f, 0.03912319f, 0.07338812f, 
    -0.12157048f, -0.06464298f, 0.00251069f, 0.03152606f, -0.14555722f, -0.00560370f, -0.04193743f, -0.01816147f, 
    0.28672102f, 0.05233330f, -0.19275209f, -0.23678423f, 0.03808780f, -0.12103013f, 0.01938532f, 0.00500489f, 
    0.07667884f, -0.11334743f, -0.08473491f, 0.00087035f, -0.23801768f, -0.31272909f, -0.02004083f, 0.00286544f, 
    0.01372510f, 0.07783458f, 0.01771200f, 0.08954427f, 0.01342100f, 0.03475562f, -0.05729662f, 0.03834865f, 
    -0.08042782f, -0.08148804f, 0.13770197f, -0.05043321f, 0.07117036f, 0.04530139f, 0.05475293f, -0.01205235f, 
    -0.03817826f, -0.04747457f, -0.10454460f, -0.18581456f, -0.22330822f, -0.26785621f, 0.18038781f, -0.12387266f, 
    0.01438137f, -0.00794758f, -0.05279849f, -0.01344779f, -0.06915506f, 0.01162796f, 0.15173349f, 0.25694066f, 
    0.29336220f, 0.32797810f, -0.01351984f, -0.10333997f, 0.06338355f, 0.17397854f, 0.06097846f, 0.00458825f, 
    -0.01865729f, -0.03955402f, -0.07262800f, -0.04301158f, 0.19310729f, 0.20350029f, 0.08797316f, -0.08827455f, 
    0.03604424f, -0.05116644f, -0.06750923f, -0.22314869f, -0.01897006f, 0.05549955f, -0.00378746f, 0.03560597f, 
    -0.03758857f, -0.23506796f, -0.73178011f, 0.11087447f, 0.07455569f, -0.00470538f, -0.15186289f, -0.03178880f, 
    -0.11410900f, -0.10638300f, -0.04964814f, -0.15771063f, -0.46301165f, -0.24643627f, -0.04817080f, 0.07890020f, 
    0.00849911f, 0.05116306f, 0.02166750f, -0.01446116f, -0.01521823f, -0.07804813f, -0.00146338f, 0.07530038f, 
    -0.20738469f, -0.25416869f, -0.18571916f, 0.05886294f, -0.01682720f, 0.00079474f, -0.12590608f, -0.10972855f, 
    0.03180627f, -0.04190177f, 0.01096120f, -0.04539447f, 0.27687746f, 0.08868589f, -0.04802306f, -0.05660535f, 
    0.10727406f, -0.11030342f, -0.02842876f, 0.02428902f, -0.02333519f, -0.04034795f, -0.04514379f, -0.10445040f, 
    -0.33133778f, -0.06379760f, -0.01888012f, 0.10815386f, 0.01140809f, 0.00997609f, -0.03163606f, -0.04049906f, 
    -0.04809888f, -0.01309175f, -0.03444279f, 0.00071461f, 0.23297755f, 0.02896249f, -0.08851467f, -0.00953904f, 
    0.09925553f, -0.01525926f, 0.00602808f, -0.19243740f, 0.04929045f, -0.03205530f, -0.03583978f, 0.01941495f, 
    0.15501678f, 0.10516245f, 0.01302287f, 0.02178959f, 0.04648624f, -0.04667487f, -0.00441788f, 0.05928044f, 
    -0.07292851f, -0.05896576f, -0.03049429f, 0.00931764f, -0.00462997f, -0.00301473f, -0.02080489f, -0.01798145f, 
    0.02780583f, -0.08992930f, -0.12597276f, 0.07406431f, -0.14170678f, -0.10041267f, -0.04866224f, -0.00980583f, 
    0.40293249f, -0.06762605f, -0.18903849f, -0.03420705f, -0.11465423f, -0.11529695f, -0.09902784f, -0.17116220f, 
    0.14603083f, -0.11676319f, 0.17779595f, 0.15552859f, -0.14497671f, 0.12200141f, -0.12688355f, 0.05236480f, 
    0.08874867f, -0.01083334f, -0.00381019f, 0.12022610f, -0.03429123f, 0.02196283f, 0.06817257f, 0.05831999f, 
    0.09368294f, 0.03585733f, 0.00803434f, 0.13539946f, -0.02855496f, -0.03841842f, 0.01926420f, -0.01017244f, 
    0.04462098f, 0.08527036f, -0.07773512f, 0.19053410f, 0.07533833f, 0.33864871f, 0.05250762f, 0.21573983f, 
    0.02545288f, -0.00758573f, -0.02071118f, -0.09658940f, 0.02263164f, -0.00737142f, 0.05411065f, 0.05311724f, 
    -0.38144004f, 0.21077499f, 0.12902625f, -0.09077944f, 0.06102277f, -0.05351121f, -0.04712270f, 0.10720186f, 
    -0.02373553f, 0.05615554f, -0.10202305f, 0.00322213f, 0.07756337f, -0.05651754f, 0.16550538f, 0.19627616f, 
    -0.05291024f, 0.02841762f, -0.02497827f, 0.03143347f, 0.09312275f, -0.09910528f, -0.21036945f, -0.10478999f, 
    0.34195322f, -0.06576648f, -0.06341822f, 0.01713338f, -0.03300704f, 0.07664930f, 0.03117860f, -0.11828653f, 
    -0.01737321f, -0.26298249f, -0.01832104f, -0.10012490f, 0.04506588f, -0.07835791f, 0.02405938f, -0.18858635f, 
    0.00197150f, -0.10115760f, -0.02275908f, 0.12515220f, -0.01042009f, 0.05359349f, 0.10971274f, -0.07858627f, 
    0.08243430f, -0.04097155f, -0.16666898f, -0.00014562f, 0.05346291f, 0.01253331f, 0.02496021f, -0.03031049f, 
    -0.02585725f, 0.09411742f, -0.23002499f, -0.07287517f, -0.15767361f, -0.15434389f, 0.02927172f, -0.09601981f, 
    0.01505090f, -0.00346351f, -0.04975186f, 0.15747650f, 0.13204587f, -0.07307766f, 0.05690181f, -0.03209620f, 
    0.06274815f, -0.08127011f, -0.17212503f, -0.08582644f, -0.05061839f, 0.06088310f, -0.06431302f, -0.05216751f, 
    -0.07535434f, -0.01846405f, -0.14799449f, -0.32663229f, -0.13287646f, -0.11337209f, -0.05451894f, -0.19783351f, 
    0.21296278f, 0.00570559f, -0.08742835f, 0.17112328f, 0.01644395f, 0.04938470f, 0.05394377f, -0.09914296f, 
    0.21144310f, 0.25130317f, 0.27155086f, 0.07531800f, 0.00843812f, -0.12281848f, -0.11092554f, -0.32757461f, 
    -0.08285621f, -0.04811573f, 0.00406688f, -0.13213469f, 0.80469316f, -0.26503721f, -0.12647280f, -0.11662218f, 
    -0.00151219f, -0.10791627f, 0.08346680f, 0.02307374f, 0.00143826f, 0.13854823f, -0.11222231f, -0.00346922f, 
    0.03913539f, 0.06207419f, 0.04855765f, -0.00566541f, 0.01771396f, 0.01654737f, -0.01776319f, -0.03993105f, 
    0.04853550f, -0.22111613f, 0.13893360f, 0.03076857f, 0.28508317f, -0.11765574f, -0.11678862f, -0.42819110f, 
    -0.34552732f, -0.00510278f, 0.07375844f, -0.17939304f, -0.05994863f, 0.01569705f, -0.04553898f, -0.00597248f, 
    -0.09042646f, 0.00224624f, 0.03599135f, -0.09749837f, -0.05301631f, 0.09551176f, -0.21643688f, -0.21158849f, 
    -0.03763066f, -0.27500561f, -0.27960071f, 0.04710598f, -0.04814659f, -0.08612745f, -0.07557760f, -0.03432665f, 
    0.02934647f, 0.00026218f, 0.02316884f, 0.05378687f, -0.00473602f, -0.24390270f, -0.04677821f, -0.16853143f, 
    -0.03955743f, -0.33194801f, -0.06391130f, 0.00588026f, -0.03157138f, 0.01711880f, 0.11895967f, 0.21176007f, 
    0.01528637f, -0.20391907f, -0.05979134f, 0.03096717f, 0.11874685f, 0.09428255f, 0.09868729f, 0.14171341f, 
    0.04635271f, -0.10326129f, 0.04944209f, -0.12477943f, 0.03292175f, -0.02543353f, -0.01556955f, -0.04579819f, 
    0.03790092f, -0.07966921f, 0.16846703f, -0.12099133f, 0.06170980f, 0.01263548f, 0.03015963f, -0.02531027f, 
    -0.03647962f, -0.00124139f, -0.03870267f, 0.00878711f, -0.15937543f, 0.15206075f, 0.06699347f, 0.27264473f, 
    0.02000086f, 0.09387749f, -0.15848003f, -0.16458154f, -0.10151444f, -0.02928044f, 0.07934900f, -0.10876612f, 
    -0.23138140f, -0.01753448f, 0.03059228f, -0.20332256f, -0.02049726f, 0.04247565f, 0.06481715f, -0.12856093f, 
    0.12880187f, 0.06084630f, -0.25263527f, -0.18833230f, 0.00044948f, -0.14166830f, 0.04974351f, -0.05083360f, 
    0.06626114f, 0.02983467f, -0.01882898f, 0.09687074f, -0.06023197f, -0.04197986f, 0.10642571f, 0.07602879f, 
    0.19266281f, -0.17206013f, 0.17336118f, -0.21319413f, 0.07742716f, -0.02432431f, -0.09762247f, 0.09965427f, 
    0.11501985f, -0.12290677f, 0.06818563f, -0.03189615f, 0.08348018f, 0.11943372f, -0.06783497f, -0.01629380f, 
    0.02438720f, -0.03478984f, -0.03314215f, 0.07186437f, -0.06790674f, 0.17457268f, -0.11306845f, -0.11514229f, 
    0.01460518f, -0.26610073f, 0.02192799f, -0.02378259f, 0.13939872f, 0.18265545f, 0.06626617f, -0.27342355f, 
    0.17868753f, 0.10298616f, 0.01252808f, -0.01579801f, -0.67473328f, -0.10212724f, 0.03265652f, -0.09274513f, 
    -0.25309443f, 0.15647560f, 0.09047375f, -0.02347641f, 0.05895238f, 0.02221140f, 0.06982972f, -0.06980912f, 
    -0.43347782f, -0.07873616f, -0.20632136f, -0.10838376f, 0.19515157f, -0.04365111f, 0.04472335f, 0.18700442f, 
    -0.00966816f, -0.08313613f, 0.10219920f, 0.07600248f, 0.12706494f, 0.14953706f, 0.14305343f, -0.13714457f, 
    -0.02343078f, 0.03886333f, 0.00130940f, 0.14344001f, 0.00022844f, -0.00559349f, -0.03197841f, -0.04265213f, 
    0.26892051f, 0.15170281f, 0.09928368f, -0.05649997f, -0.02071100f, -0.02136906f, -0.04708643f, -0.02551800f, 
    -0.22185680f, -0.05169287f, 0.31306806f, -0.19932388f, 0.13268180f, 0.05359857f, -0.08366461f, -0.02102775f, 
    -0.12512454f, -0.02528618f, 0.01097968f, 0.07311718f, -0.21886969f, 0.09470162f, 0.01534774f, -0.02596231f, 
    -0.20342532f, -0.18667224f, -0.28846762f, 0.09423202f, -0.07487753f, 0.03137670f, -0.01620707f, -0.11862674f, 
    0.01447237f, 0.03439461f, -0.07408454f, 0.00878670f, 0.03224705f, 0.04813170f, 0.26348254f, -0.08490399f, 
    -0.00822346f, 0.01385848f, 0.09460621f, -0.10040125f, 0.01046953f, -0.02430695f, 0.02291243f, 0.02922121f, 
    0.37230414f, -0.31914669f, 0.00960412f, -0.07778752f, 0.01711464f, -0.02262054f, 0.04305697f, 0.03114460f, 
    -0.00246747f, 0.05786171f, 0.02326449f, -0.03187057f, 0.12968308f, -0.57812870f, 0.02389444f, -0.11453699f, 
    0.04400001f, -0.07452949f, 0.07094280f, 0.02683874f, 0.16874357f, 0.06367227f, -0.03384471f, 0.10654789f, 
    -0.54667807f, 0.18064895f, -0.05216008f, -0.09520124f, -0.06683521f, 0.04494184f, 0.05728140f, 0.12843022f, 
    0.00904689f, -0.06266548f, 0.10621329f, -0.07622319f, -0.34351543f, -0.04254057f, -0.19812347f, 0.06598445f, 
    -0.00334733f, 0.03976523f, 0.08761506f, 0.09599344f, -0.15591009f, 0.07619875f, 0.02291903f, 0.02063237f, 
    0.78434741f, -0.02345496f, 0.29275322f, -0.07491563f, -0.14025147f, -0.11308087f, 0.08099969f, -0.03112550f, 
    -0.00518938f, -0.05123219f, -0.04870883f, 0.08245154f, 0.13854730f, -0.10243317f, 0.11032613f, 0.07266312f, 
    0.05913464f, -0.06378219f, -0.04354155f, -0.06587391f, 0.08528591f, -0.02611000f, 0.07049511f, -0.16476510f, 
    0.18910609f, 0.35709316f, 0.10854590f, 0.15628673f, -0.02251473f, 0.01134129f, 0.04541929f, 0.04836037f, 
    -0.05802182f, -0.04549347f, -0.01309947f, -0.07353422f, 0.06710272f, 0.10087568f, 0.00979546f, 0.25347582f, 
    0.08647439f, 0.22746402f, -0.09292421f, 0.05327210f, 0.00762849f, 0.00160260f, -0.02267659f, -0.00183992f, 
    0.17091346f, -0.05829565f, 0.17000973f, -0.23785149f, 0.01781223f, 0.05577517f, -0.07219649f, 0.12731305f, 
    -0.03348564f, 0.07252447f, 0.01028526f, -0.10339970f, -0.02412424f, -0.04545006f, -0.06966949f, -0.12222030f, 
    -0.14373691f, -0.06219535f, -0.07170162f, 0.05195147f, -0.02277313f, -0.07183158f, 0.02127749f, 0.06924918f, 
    -0.36814386f, 0.07039317f, -0.08323669f, -0.05030519f, -0.01020348f, 0.14256397f, 0.05508028f, -0.00858737f, 
    0.02738293f, 0.09512708f, -0.07008624f, 0.14742242f, 0.41821396f, 0.28044581f, 0.24781983f, 0.23324098f, 
    0.02937024f, 0.00831723f, -0.00481343f, 0.00942136f, 0.01420338f, 0.06059570f, -0.03225739f, 0.03740127f, 
    -0.35293034f, 0.01699757f, -0.15105706f, -0.07088497f, -0.00435565f, 0.00303583f, 0.07823945f, 0.14835379f, 
    -0.13940576f, -0.04003875f, 0.08360492f, -0.00640229f, 0.48542103f, 0.19127050f, -0.14220080f, 0.09556529f, 
    -0.04124371f, -0.02375353f, -0.05841251f, 0.01404764f, -0.03523019f, 0.12622756f, -0.15215513f, 0.15554368f, 
    0.03946429f, 0.06736040f, 0.08276191f, -0.09703857f, -0.01707077f, 0.07335376f, 0.00750905f, -0.14388424f, 
    0.01577112f, -0.06103858f, 0.00038119f, -0.10046869f, 0.00481466f, -0.00328180f, 0.01354666f, 0.01519401f, 
    0.11895870f, -0.01275976f, 0.04482561f, 0.01979911f, -0.02579756f, -0.04553334f, -0.01134487f, 0.03907637f, 
    -0.17073241f, -0.09124441f, -0.20701635f, -0.39724228f, -0.12979817f, 0.05809728f, -0.09545791f, -0.02008530f, 
    0.11397219f, 0.01966638f, -0.04023827f, 0.07803416f, 0.15257095f, -0.11165595f, -0.06033652f, -0.10399828f, 
    0.03097138f, -0.01937427f, -0.06876770f, 0.03062162f, -0.12757723f, -0.01011797f, 0.05505976f, -0.03848244f, 
    -0.26920161f, 0.21655080f, 0.01629655f, -0.21721230f, 0.00440038f, 0.03335641f, -0.00385145f, -0.01632269f, 
    -0.05698706f, 0.03038353f, -0.13787003f, 0.14058799f, 0.14058617f, -0.08462478f, 0.14464553f, -0.12784639f, 
    -0.01033537f, 0.06103630f, 0.00340128f, -0.03092502f, -0.16170657f, -0.22760949f, -0.39821693f, -0.19100377f, 
    -0.02021366f, 0.13659124f, -0.18872088f, 0.20293511f, 0.03702931f, -0.19724239f, -0.12968086f, -0.00493992f, 
    -0.03247973f, 0.04229321f, -0.02095882f, -0.03002783f, -0.23246592f, 0.03677988f, -0.07853714f, 0.06749775f, 
    -0.08656192f, 0.06522047f, 0.08651538f, 0.08223969f, -0.04100605f, -0.04081756f, 0.02576539f, -0.01941978f, 
    0.16699909f, -0.31593865f, -0.26171786f, -0.00213725f, 0.04496286f, -0.00312473f, 0.13576242f, 0.07379276f, 
    -0.06056054f, 0.19889711f, -0.10032960f, 0.13948286f, 0.13030888f, 0.10168938f, 0.10258911f, 0.03885296f, 
    0.01339830f, 0.04451848f, -0.09289507f, 0.01013651f, -0.34132016f, 0.05354045f, -0.03818759f, -0.11798584f, 
    0.19175430f, 0.03600748f, 0.15462850f, -0.14209759f, -0.03319560f, 0.04745580f, -0.00879531f, -0.01382616f, 
    -0.03965299f, -0.08519521f, 0.02980006f, -0.03421856f, 0.07072463f, -0.37880141f, 0.14021868f, -0.02000140f, 
    0.03036044f, 0.03254135f, 0.16966401f, -0.22147512f, 0.08544556f, -0.03492511f, 0.03977354f, -0.06219060f, 
    0.03665412f, 0.06390031f, 0.08985349f, 0.00762138f, -0.04461904f, 0.01939371f, 0.07226946f, 0.06229232f, 
    0.05081925f, 0.00475287f, 0.03637129f, 0.04268959f, 0.25879735f, -0.12279201f, -0.15058276f, -0.07811650f, 
    -0.02171236f, -0.00961183f, 0.10838036f, -0.19094385f, 0.15927526f, 0.06500585f, 0.02632625f, -0.03198425f, 
    -0.20423777f, 0.01331613f, -0.00990526f, -0.14112790f, -0.01071034f, -0.07603659f, -0.13377121f, 0.05612333f, 
    0.00638987f, 0.02891054f, -0.07044905f, 0.11456813f, -0.09846748f, -0.07055426f, 0.02923798f, 0.03405120f, 
    -0.08318597f, -0.11657983f, -0.00927097f, -0.00669662f, -0.02083446f, -0.02624514f, 0.04916542f, -0.00302716f, 
    -0.16259752f, -0.01677642f, 0.03605540f, -0.23716193f, -0.01718425f, 0.04668363f, -0.11902990f, -0.03790393f, 
    0.05439574f, 0.09207129f, -0.02074221f, 0.06412742f, 0.13966446f, 0.04929337f, -0.25490859f, 0.06450389f, 
    0.23660573f, 0.08140440f, -0.13218391f, 0.05690333f, -0.00603480f, 0.02541999f, -0.00956742f, 0.00544927f, 
    0.07255734f, -0.10452064f, -0.05014691f, 0.08749251f, 0.03484930f, -0.02643737f, 0.00045991f, 0.10570647f, 
    -0.02281960f, -0.00864363f, -0.00470626f, -0.05072935f, -0.20413460f, 0.09492872f, 0.25534660f, 0.31813413f, 
    -0.02778836f, 0.08185124f, -0.01784842f, -0.02698150f, 0.00155249f, 0.01952533f, 0.02962559f, 0.00491166f, 
    -0.00333353f, -0.05030423f, -0.06705755f, 0.00702212f, 0.02413069f, -0.01762481f, 0.04169646f, -0.07012649f, 
    0.03605568f, 0.02506931f, -0.08589596f, 0.06084393f, -0.03181670f, -0.15711358f, 0.01544517f, 0.00259438f, 
    0.01521139f, -0.01767519f, 0.00376692f, 0.08189185f, 0.09562431f, 0.12859710f, -0.10851377f, 0.10838569f, 
    -0.17217459f, 0.08553779f, -0.01323860f, -0.06164550f, 0.01959934f, -0.02940304f, -0.01145572f, 0.03071069f, 
    -0.08099519f, 0.18870889f, 0.10927718f, 0.01024840f, -0.12125902f, 0.35321039f, -0.38933021f, -0.12654962f, 
    0.04653983f, -0.16588765f, 0.09987773f, 0.03285391f, -0.01995740f, 0.05873558f, -0.01266233f, 0.05458425f, 
    0.13865674f, 0.17034538f, 0.02027171f, 0.32291552f, -0.03181571f, 0.00947586f, 0.00238644f, -0.04119235f, 
    -0.03675916f, -0.00466461f, -0.10667513f, 0.05460719f, 0.02132530f, 0.08464012f, -0.08441170f, 0.07037649f, 
    0.07632996f, -0.00201706f, -0.12451665f, -0.06165995f, 0.10370021f, -0.02650466f, 0.09386359f, 0.15896200f, 
    -0.10638928f, 0.13470787f, 0.27397034f, 0.23330636f, -0.03247821f, -0.02323075f, 0.05462940f, 0.04467515f, 
    0.07667198f, 0.03265917f, 0.02104458f, 0.04954155f, 0.28364751f, 0.14107445f, 0.03137905f, 0.05869912f, 
    0.08613702f, -0.01586773f, -0.04028615f, -0.08657908f, -0.10505769f, -0.03674336f, -0.07372197f, 0.07057507f, 
    -0.45840639f, 0.28105706f, 0.28886801f, 0.08103158f, -0.04997899f, -0.03902834f, 0.27425548f, -0.11537348f, 
    0.02367766f, 0.01405522f, -0.02025336f, -0.02786773f, -0.33242053f, 0.50025469f, 0.16751151f, -0.05274475f, 
    -0.08376347f, -0.01974908f, 0.00219559f, -0.08286239f, 0.05925515f, -0.02538774f, -0.14363359f, 0.00985210f, 
    0.00350632f, -0.11570522f, 0.07111412f, -0.08101080f, 0.05218621f, 0.03882280f, -0.03246808f, -0.05529267f, 
    0.07360319f, 0.10199715f, 0.00413080f, 0.18447910f, -0.83510458f, -0.31522483f, 0.03220848f, -0.24832664f, 
    -0.02755926f, -0.17048879f, -0.28803664f, -0.32526192f, 0.06588610f, -0.02863694f, -0.00173011f, 0.03125174f, 
    0.33860451f, 0.28010276f, -0.10786489f, 0.13276516f, -0.07198554f, -0.02785357f, -0.07171968f, 0.09720519f, 
    0.03476528f, 0.11082100f, 0.02724984f, 0.11052962f, 0.02682347f, -0.07619964f, 0.06287228f, -0.02265461f, 
    -0.01023969f, -0.09251324f, -0.00888529f, 0.01393592f, 0.05797159f, 0.15177612f, -0.05320677f, 0.14588729f, 
    0.01963605f, -0.04809088f, -0.06370828f, 0.00224697f, 0.01675954f, -0.07410973f, 0.11973493f, -0.14180838f, 
    -0.14207722f, -0.20835538f, -0.00271147f, -0.06443800f, -0.60544783f, -0.45918712f, -0.05983024f, -0.24832721f, 
    -0.12395870f, -0.07124894f, 0.02194600f, 0.01319128f, -0.00431017f, -0.00396325f, 0.03126461f, -0.02303618f, 
    0.04388830f, -0.06389835f, -0.00130261f, -0.02885914f, -0.08762255f, 0.07752423f, -0.01046789f, -0.15208963f, 
    0.04377280f, -0.09053469f, -0.09783858f, 0.16239648f, 0.00821794f, 0.19231349f, 0.11494873f, 0.44515058f, 
    -0.01001654f, -0.11113150f, 0.03423370f, 0.19461866f, 0.02218602f, -0.00295110f, 0.02180130f, -0.01004518f, 
    0.28278634f, -0.03171831f, -0.00255562f, 0.15556216f, -0.01994151f, 0.01168838f, -0.02789633f, -0.05379055f, 
    -0.07423036f, -0.00664328f, -0.06343677f, -0.12626654f, -0.02021003f, -0.07686711f, 0.10876916f, -0.12426616f, 
    0.06300378f, -0.15005040f, -0.01854578f, 0.05633955f, -0.07638691f, 0.08677720f, -0.02871117f, -0.03717531f, 
    -0.09675082f, -0.08831948f, 0.26949272f, -0.20937964f, -0.00749711f, -0.08614263f, 0.02811235f, 0.06681029f, 
    0.05636065f, -0.07497865f, 0.03298746f, 0.02360703f, -0.09404735f, 0.11837111f, -0.04843021f, 0.06454452f, 
    0.04565217f, 0.05391597f, 0.05003861f, -0.00242805f, -0.05419894f, -0.13930973f, -0.01842103f, -0.03856361f, 
    -0.10241788f, 0.25121903f, 0.00592047f, 0.06873338f, -0.09170108f, 0.05174067f, 0.14459328f, -0.10181715f, 
    -0.00877464f, 0.13504951f, 0.01134239f, 0.05866479f, 0.16861024f, -0.06112435f, -0.04199154f, 0.19741623f, 
    -0.16516083f, 0.07288857f, -0.01502100f, 0.06456242f, -0.10373388f, 0.07608587f, -0.20265651f, 0.03512564f, 
    0.18894067f, 0.04975611f, -0.34532613f, -0.20442306f, 0.17931443f, -0.05548983f, -0.15572044f, 0.19780113f, 
    -0.06229858f, -0.00938323f, -0.12030220f, 0.05071583f, -0.17179568f, 0.40116537f, 0.44576579f, 0.06719999f, 
    -0.00999338f, 0.00757180f, 0.12887752f, -0.01121050f, 0.00584256f, -0.05975980f, 0.00433699f, -0.04300082f, 
    0.01467127f, 0.07750786f, -0.13064103f, -0.09974422f, -0.04407067f, -0.02723191f, -0.02412069f, 0.05310056f, 
    -0.05890879f, -0.06340956f, 0.04937153f, 0.06447282f, -0.09016217f, 0.07355589f, -0.09631265f, 0.05838886f, 
    -0.04886624f, 0.06068216f, -0.02609866f, -0.12341075f, 0.05924558f, -0.17009187f, -0.09677447f, 0.04582559f, 
    -0.03631571f, 0.34044242f, 0.31847110f, 0.15184528f, -0.06339838f, -0.03406795f, 0.11637675f, -0.01803287f, 
    -0.00208979f, -0.12033959f, 0.04847926f, 0.01641228f, -0.29466283f, 0.15630729f, 0.03222381f, -0.22503376f, 
    -0.03015452f, 0.04358246f, 0.04252387f, 0.01906630f, -0.01488128f, 0.04439268f, -0.08699747f, 0.06085150f, 
    -0.04815337f, 0.15872632f, 0.12238346f, -0.28732210f, 0.02570947f, -0.07279894f, -0.10792553f, 0.03573702f, 
    0.07793116f, -0.00712775f, -0.12300641f, 0.05618310f, 0.20889553f, -0.09249789f, 0.26134825f, -0.20562227f, 
    0.02348268f, -0.17363308f, 0.12331624f, 0.16664109f, 0.07176863f, 0.11187209f, -0.12942556f, -0.12195250f, 
    -0.25173819f, -0.03166321f, -0.18936291f, 0.22960101f, 0.06040968f, 0.06233378f, -0.08089821f, 0.02009521f, 
    0.00311961f, 0.00497374f, -0.00843000f, -0.01679730f, 0.04942542f, 0.03211008f, -0.01706980f, 0.11584816f, 
    -0.04056958f, -0.02094071f, 0.00546553f, 0.05568546f, 0.00237186f, 0.10333135f, 0.06463648f, 0.06463470f, 
    -0.38129053f, -0.00227716f, 0.02368568f, -0.57199353f, -0.03919784f, -0.07075110f, -0.02367169f, -0.01527367f, 
    -0.03518931f, 0.00596500f, -0.05824914f, -0.01821028f, 0.00203014f, -0.16486886f, 0.41511899f, 0.02780589f, 
    0.03680661f, 0.00058888f, 0.04831878f, 0.00991190f, 0.07830337f, -0.07550778f, 0.01030356f, -0.01996834f, 
    -0.48188144f, -0.19611940f, 0.02617268f, 0.18317986f, 0.00435236f, -0.13913617f, 0.14627463f, 0.04762436f, 
    -0.01619983f, 0.00801671f, -0.02506118f, -0.01402773f, -0.07590500f, 0.00312126f, -0.26992518f, 0.03990331f, 
    0.10239989f, 0.10833579f, -0.02449792f, -0.00552739f, -0.00447809f, -0.07745843f, -0.01862243f, -0.02815847f, 
    -0.27003682f, 0.38572526f, -0.01829151f, -0.02218464f, 0.01678446f, 0.13330491f, -0.08368874f, -0.00144574f, 
    -0.02260364f, -0.01615935f, -0.05091778f, 0.00806585f, -0.95230120f, -0.54305601f, -0.43027562f, -0.45597601f, 
    0.04427768f, 0.01274501f, 0.01136373f, -0.27428174f, 0.04277160f, -0.01294189f, -0.00475633f, -0.03570419f, 
    0.14465970f, -0.08211055f, -0.40878415f, 0.05592831f, -0.07415541f, 0.10852646f, -0.02781737f, 0.03233349f, 
    -0.03393097f, 0.00462116f, -0.01227264f, 0.07734727f, -0.37193730f, -0.08383387f, -0.10690322f, -0.13465497f, 
    0.04941469f, 0.02289951f, 0.02130079f, 0.04373567f, 0.00866589f, -0.03423709f, -0.11139572f, 0.13641128f, 
    0.06822053f, 0.01652440f, 0.02699416f, 0.10656676f, -0.02376867f, -0.09388111f, -0.00103848f, -0.06148513f, 
    -0.07049363f, 0.04872670f, -0.01005358f, 0.02990698f, -0.23097539f, 0.19937854f, -0.14482412f, 0.11743724f, 
    0.01392006f, -0.02355786f, 0.00891941f, 0.00671577f, 0.01564346f, -0.01248379f, -0.09772760f, 0.06656495f, 
    0.24020480f, 0.01738743f, 0.13927431f, 0.15951549f, -0.03618701f, -0.13840143f, 0.11082026f, 0.06054676f, 
    0.06614395f, 0.06720632f, 0.17202422f, -0.05647666f, -0.08244135f, -0.01551931f, -0.01040598f, -0.03138574f, 
    -0.02310988f, -0.06231452f, -0.04242607f, 0.03789927f, -0.07347218f, -0.00729284f, -0.00023382f, -0.01305581f, 
    0.13495190f, 0.01043423f, 0.04560705f, -0.38466352f, 0.14518757f, 0.08272269f, -0.08807918f, 0.05160673f, 
    -0.01177355f, 0.05210934f, 0.10293406f, -0.04407424f, 0.32620698f, 0.11596344f, 0.22690322f, 0.20515987f, 
    0.06293517f, -0.02574810f, 0.01715439f, -0.03841710f, 0.00622353f, -0.12064073f, 0.03350127f, 0.06275349f, 
    -0.12349033f, 0.08676802f, -0.02243827f, 0.07281099f, 0.03268032f, 0.11729745f, -0.08472189f, 0.01490253f, 
    -0.04329319f, -0.15347916f, -0.03332239f, 0.06870253f, -0.21556897f, 0.06250677f, 0.01789444f, -0.00691193f, 
    -0.04657886f, -0.04707951f, -0.11605568f, -0.06165656f, 0.00190428f, 0.13988619f, -0.12518935f, 0.12810239f, 
    -0.58371425f, -0.28507954f, -0.25402161f, -0.08331350f, -0.06485648f, -0.06627126f, -0.13704625f, 0.09965843f, 
    -0.01902392f, -0.05473465f, -0.02148284f, 0.00637639f, -0.08793060f, -0.07728422f, -0.07242220f, 0.09457333f, 
    -0.04425302f, -0.00772481f, -0.02098836f, 0.00437765f, 0.01279136f, -0.02697438f, 0.03249649f, 0.04531389f, 
    0.08323226f, 0.00400837f, -0.12637405f, -0.35382721f, 0.04039584f, -0.21935707f, -0.02210925f, -0.07732362f, 
    -0.06602889f, -0.15263982f, -0.10673099f, -0.12805817f, -0.08541414f, -0.00868900f, -0.01452808f, -0.08279070f, 
    0.04650881f, 0.00891429f, -0.00374199f, -0.05289528f, 0.05079663f, 0.08390122f, 0.01640644f, -0.01081269f, 
    -0.10209934f, 0.11509287f, 0.02754620f, -0.05827701f, 0.03584855f, 0.05908483f, -0.21140763f, 0.13627081f, 
    0.10615464f, -0.14368802f, 0.02831367f, -0.01478094f, -0.04104747f, -0.00506091f, 0.17822987f, -0.12243564f, 
    0.01283709f, 0.06350267f, 0.03275919f, 0.16788262f, 0.01354942f, -0.02993218f, 0.13500433f, 0.04102324f, 
    -0.18027444f, -0.38275036f, -0.26303363f, -0.01582098f, 0.01554666f, -0.02401801f, 0.03950033f, 0.00474792f, 
    -0.01935476f, -0.03291098f, 0.05295686f, -0.15879729f, -0.06994787f, 0.16212346f, 0.05639204f, 0.10613265f, 
    -0.04932515f, -0.00548803f, 0.07485634f, -0.12538709f, -0.03296125f, 0.10967431f, 0.12052927f, -0.02405513f, 
    -0.14005032f, -0.39519596f, -0.18216808f, 0.06495167f, -0.05929101f, 0.09634195f, -0.25336060f, -0.02757434f, 
    0.02466401f, -0.01526975f, -0.19532764f, -0.06216273f, 0.01386272f, -0.02546163f, 0.05250995f, 0.07913327f, 
    -0.14765126f, 0.13503520f, 0.07888555f, 0.02944044f, -0.09485199f, 0.17408316f, -0.10871162f, 0.00893276f, 
    -0.11189976f, 0.50301653f, -0.09270738f, 0.30217424f, -0.00528774f, -0.07252046f, 0.03652469f, 0.00942402f, 
    -0.01316938f, 0.03251058f, -0.02345644f, 0.08941006f, 0.07737498f, -0.03291611f, -0.01575632f, -0.35120910f, 
    -0.02134935f, 0.04076339f, -0.05527927f, -0.04991808f, 0.09666707f, -0.20647250f, -0.06993175f, -0.07856121f, 
    -0.48892483f, 0.33009270f, -0.24697882f, -0.63086498f, 0.22187820f, 0.11379374f, -0.11208800f, -0.00931039f, 
    -0.21335293f, -0.01735189f, -0.13980547f, -0.07926570f, -0.36280659f, 0.05584881f, -0.09052459f, 0.26649958f, 
    -0.13384867f, -0.14923096f, 0.04446708f, -0.17519468f, -0.00643277f, 0.07741439f, -0.08541863f, 0.10046060f, 
    0.32681704f, -0.17685680f, 0.12139589f, -0.23451763f, -0.28965640f, 0.01950194f, 0.00966142f, -0.00415893f, 
    -0.02930997f, 0.11237001f, -0.02717875f, 0.01163218f, 0.18192013f, 0.37019721f, -0.46975166f, -0.20331088f, 
    0.23939417f, 0.02674914f, 0.05659797f, 0.07444867f, -0.18590318f, -0.07443951f, 0.00248867f, 0.02907639f, 
    -0.55291426f, 0.25116810f, -0.11299895f, -0.07874735f, 0.11225524f, -0.08720200f, 0.03416352f, 0.01108934f, 
    -0.08417970f, 0.10286989f, -0.06665530f, -0.09596958f, -0.12563540f, 0.76975334f, 0.05922286f, 0.19176565f, 
    -0.10200211f, -0.13240631f, -0.01128136f, -0.06597723f, -0.06018173f, -0.15584792f, 0.00949385f, 0.06290669f, 
    0.39631695f, -0.21197730f, -0.06142424f, 0.10535911f, 0.07637334f, -0.03488126f, -0.13128972f, -0.01307540f, 
    -0.00397730f, 0.07666346f, 0.11025508f, 0.03909257f, 0.01136599f, -0.02474602f, 0.02913773f, 0.08507352f, 
    0.10198315f, 0.09799729f, -0.00193482f, 0.01082272f, -0.03155476f, 0.02582001f, -0.06035374f, 0.04897309f, 
    -0.08391377f, 0.00930156f, 0.00225995f, 0.16571122f, 0.04535928f, -0.00611993f, 0.00094084f, -0.08582253f, 
    -0.02397175f, 0.08635570f, -0.02820591f, 0.14596245f, 0.27801278f, -0.07022513f, 0.11039124f, -0.15053289f, 
    -0.08187994f, 0.01634742f, 0.01876565f, -0.07700842f, -0.06035552f, -0.08433918f, 0.10220198f, -0.02808388f, 
    0.43900102f, -0.12512395f, 0.00547488f, 0.22291270f, 0.04203268f, -0.06459246f, -0.02010723f, -0.02665284f, 
    0.06405906f, 0.07220700f, 0.03906186f, 0.22268164f, -0.31509611f, -0.11733355f, 0.08040061f, 0.23461056f, 
    -0.09681842f, -0.04597039f, 0.14530140f, -0.07925671f, -0.00364136f, 0.01727216f, -0.05375467f, 0.11232988f, 
    -0.07054388f, -0.15822764f, 0.09073205f, 0.01607420f, -0.12341634f, -0.01182202f, -0.09751803f, -0.06340794f, 
    0.11374997f, 0.14387143f, 0.07365794f, 0.04886080f, -0.13594343f, -0.26825586f, 0.28632927f, 0.36454576f, 
    -0.03316450f, 0.17910199f, -0.11895555f, 0.09484339f, 0.04937642f, -0.09901478f, -0.04013995f, -0.04558262f, 
    0.73999411f, 0.00128384f, 0.00495913f, 0.05222099f, 0.10601168f, 0.15683369f, 0.06465439f, 0.12191553f, 
    0.04532021f, -0.28335142f, 0.03688109f, 0.08635577f, -0.13354215f, 0.07990678f, -0.12601754f, 0.11274335f, 
    0.11733627f, 0.12966166f, 0.10592283f, -0.12951012f, 0.00846664f, 0.04430016f, -0.02535799f, 0.08258744f, 
    0.01672091f, -0.10838796f, -0.04874155f, 0.21008764f, -0.03467996f, 0.00432125f, 0.07901327f, -0.01252064f, 
    -0.00290587f, 0.01474658f, 0.12898679f, -0.05453166f, -0.10340571f, 0.00844548f, -0.07927477f, 0.12053791f, 
    0.02276570f, 0.07070189f, 0.03155854f, 0.05513890f, 0.01079851f, 0.01264485f, -0.01942358f, -0.00980158f, 
    0.13284919f, 0.14135896f, 0.13912533f, -0.17952053f, -0.20548484f, -0.16663148f, -0.18983907f, 0.00615089f, 
    -0.05343241f, -0.03577068f, 0.14544798f, 0.02634751f, 0.05219184f, -0.10507036f, -0.06394560f, 0.16590984f, 
    0.04799732f, -0.01138529f, 0.04038147f, -0.01451603f, 0.04605219f, 0.02396375f, 0.07683162f, 0.06615350f, 
    0.68100607f, -0.26275072f, -0.09719998f, -0.11212786f, 0.05130907f, -0.08096702f, -0.00126005f, -0.03360022f, 
    -0.25089175f, -0.07377671f, -0.06277003f, 0.01096358f, -0.21106111f, -0.10008819f, 0.04222374f, 0.13191709f, 
    0.10210283f, 0.12190822f, 0.10633625f, 0.12898791f, -0.07907373f, -0.12138763f, -0.00953226f, -0.10705499f, 
    -0.24277046f, -0.18800282f, 0.39172745f, -0.24598375f, -0.29023015f, 0.00874100f, -0.12981282f, -0.07872148f, 
    0.01508584f, 0.01503809f, 0.03358955f, -0.06236334f, 0.07496802f, 0.08510005f, -0.01813184f, -0.12480270f, 
    0.16948231f, 0.13235837f, 0.02762980f, -0.14405930f, -0.06772812f, -0.00420370f, 0.03044296f, 0.06640791f, 
    -0.11879025f, -0.02968827f, -0.08457575f, 0.16885801f, 0.00534022f, -0.06076344f, -0.01138224f, -0.02548549f, 
    -0.04911878f, -0.01634966f, -0.04680037f, 0.02724021f, -0.06116327f, 0.25356945f, -0.06877720f, -0.48160702f, 
    -0.08200788f, -0.13953210f, -0.00459629f, -0.02736576f, -0.18516861f, 0.09258968f, -0.25373110f, 0.01146527f, 
    0.15282226f, -0.05424644f, 0.07530878f, -0.12982351f, -0.08020556f, -0.02150276f, -0.06379031f, 0.03181783f, 
    -0.05895821f, 0.21374486f, -0.04835903f, -0.06346751f, -0.07318134f, -0.02517056f, 0.00251464f, 0.22085190f, 
    0.02572187f, -0.03907485f, 0.00993670f, -0.07010001f, 0.07181514f, 0.09995766f, 0.12053911f, 0.16376978f, 
    -0.22608455f, 0.04899858f, -0.07562061f, -0.01330397f, -0.02269559f, -0.01209273f, -0.06969315f, -0.04587419f, 
    -0.08671355f, -0.11630897f, 0.05292501f, -0.05513827f, -0.10437126f, -0.15586090f, -0.01905103f, 0.17429352f, 
    0.08008833f, 0.16590326f, 0.07534797f, -0.01797208f, 0.00597627f, 0.06444995f, -0.03638853f, -0.09606947f, 
    0.01518215f, -0.04054849f, -0.13059345f, 0.15215424f, 0.05128007f, -0.03046243f, 0.04260161f, -0.15478587f, 
    -0.02206766f, 0.09934379f, 0.02851896f, -0.00281297f, -0.05863615f, -0.40664533f, 0.15138681f, -0.15734684f, 
    -0.27075279f, -0.13409258f, -0.03454431f, 0.10763743f, -0.07604382f, 0.04990036f, -0.15153803f, -0.05184964f, 
    -0.08644436f, -0.07273410f, 0.05606316f, 0.22246024f, 0.01956391f, 0.08866823f, 0.05968542f, 0.00623212f, 
    -0.11185999f, -0.02157882f, -0.00913989f, 0.08251069f, -0.24611224f, 0.32839888f, -0.29782608f, -0.12304925f, 
    0.09150647f, 0.01425164f, 0.01107571f, 0.07146443f, -0.22118117f, 0.03415236f, 0.00573899f, -0.06637184f, 
    0.12431997f, -0.06348896f, 0.02326012f, -0.39736497f, -0.04310048f, -0.08509171f, -0.15693106f, -0.08251274f, 
    0.03954040f, -0.00760008f, 0.03554597f, -0.11065752f, -0.09673727f, -0.02027804f, -0.15972862f, -0.19882584f, 
    0.03807383f, 0.03714062f, 0.02829465f, 0.06354247f, -0.11272828f, 0.06003563f, -0.06128749f, -0.08487661f, 
    -0.19388229f, -0.13264176f, 0.23264508f, 0.24291280f, 0.10118178f, -0.07276107f, 0.19061837f, 0.00104051f, 
    -0.06154135f, 0.00572430f, 0.06175481f, -0.07199568f, -0.18726711f, 0.34326199f, -0.23346715f, -0.03036105f, 
    0.06314643f, 0.22702527f, 0.00791522f, 0.09952500f, -0.18270129f, -0.02118492f, -0.07119799f, 0.07118254f, 
    -0.05090203f, -0.05674285f, -0.04531338f, 0.09123917f, -0.05623386f, 0.00739591f, -0.06496596f, 0.01595466f, 
    0.00624823f, 0.09117754f, -0.03553443f, 0.01667270f, 0.07521080f, -0.02691944f, -0.00492204f, 0.10505360f, 
    0.00943223f, 0.00091854f, 0.00667852f, 0.02076006f, -0.08660918f, 0.07348052f, -0.10155533f, -0.01279476f, 
    -0.28846726f, -0.03321485f, 0.01377374f, 0.20935789f, -0.11562507f, 0.10703684f, -0.12147726f, -0.14746003f, 
    -0.06240262f, 0.00310898f, 0.07982249f, -0.06562407f, -0.06701173f, -0.18765609f, -0.07140685f, 0.18370298f, 
    0.01844964f, 0.15662737f, 0.09302562f, 0.14148425f, -0.02804554f, 0.03844998f, 0.06411923f, -0.10271625f, 
    0.22127545f, -0.10704254f, -0.19815136f, -0.44874215f, -0.02360104f, -0.01130365f, 0.00301446f, -0.06847119f, 
    -0.02283262f, 0.12687287f, -0.16454667f, -0.12405669f, 0.00473858f, -0.02963959f, -0.02640126f, -0.21903636f, 
    -0.02621501f, 0.17232056f, 0.12910153f, 0.01707909f, -0.06070028f, -0.03777305f, 0.04751859f, -0.13114339f, 
    -0.04970218f, -0.13027400f, -0.03505003f, -0.01091905f, 0.13558792f, 0.00678578f, 0.00258490f, 0.02485517f, 
    -0.04033746f, -0.10597356f, 0.02780916f, -0.15457526f, -0.45330441f, 0.42756027f, -0.05154528f, -0.00010153f, 
    -0.09737368f, -0.00459664f, 0.06454856f, -0.00044656f, -0.06445728f, 0.15382193f, 0.03813998f, -0.05473785f, 
    -0.16227025f, -0.00300479f, 0.09256608f, 0.12625410f, 0.13929650f, 0.07359135f, 0.00351815f, 0.09066079f, 
    -0.11414303f, 0.01467563f, -0.12421712f, 0.06301012f, -0.15084377f, -0.06707083f, -0.07640890f, -0.09695491f, 
    0.02661083f, 0.02455076f, -0.14268661f, -0.07115883f, 0.06802060f, -0.06393412f, -0.06888408f, -0.15274401f, 
    -0.23046090f, 0.09673039f, 0.01149366f, 0.16117159f, 0.00572903f, -0.09158038f, -0.04377444f, -0.06951681f, 
    -0.03926517f, -0.02465464f, 0.10768817f, 0.12639476f, 0.57506001f, -0.05777442f, 0.06458552f, 0.12184563f, 
    0.11426479f, 0.13178165f, -0.10013092f, -0.06442394f, -0.23507594f, 0.03396893f, -0.08033487f, -0.04338873f, 
    0.46479183f, -0.04366357f, -0.01363298f, 0.06152476f, 0.15191993f, 0.07311501f, -0.00050025f, -0.04197008f, 
    -0.08425766f, 0.11316139f, 0.04155953f, 0.14575104f, -0.23619176f, 0.07254880f, 0.02311947f, 0.17657579f, 
    -0.17044610f, 0.04815877f, -0.06840859f, -0.05991310f, -0.02123739f, 0.14404270f, -0.07768714f, -0.02639474f, 
    -0.01538799f, -0.07017885f, -0.05735425f, -0.02154872f, 0.10346010f, 0.00409350f, 0.02322730f, 0.14346001f, 
    -0.00037269f, -0.05989088f, -0.05388618f, -0.05057970f, 0.12060147f, 0.08468715f, -0.24300480f, 0.08396378f, 
    0.02642515f, -0.00328554f, 0.03077584f, 0.08209128f, -0.07064334f, -0.07481332f, 0.07143472f, 0.10939329f, 
    0.06489752f, -0.07409076f, -0.00088500f, 0.21546926f, -0.02820460f, -0.24208921f, 0.00699668f, -0.17321593f, 
    0.06986560f, -0.07493973f, -0.01152679f, -0.02740543f, -0.20367201f, -0.09650674f, 0.14484353f, -0.01372935f, 
    -0.18352176f, 0.10260518f, -0.09143557f, 0.08856558f, 0.17359586f, 0.02700726f, 0.03325448f, -0.05429713f, 
    0.00787416f, -0.04681452f, -0.05918940f, 0.05134645f, -0.11403406f, -0.11320502f, -0.15110107f, 0.02697455f, 
    -0.07749476f, 0.07798923f, 0.18278885f, -0.15201291f, -0.23313358f, 0.02647649f, -0.14309017f, -0.00714385f, 
    -0.03111034f, 0.04294011f, -0.04211908f, -0.06279836f, -0.11532068f, -0.03353833f, 0.04128081f, -0.08160797f, 
    -0.04680932f, 0.04490859f, -0.04542981f, -0.00044994f, 0.09533905f, -0.15987466f, 0.03277961f, -0.10219634f, 
    -0.05998045f, 0.00949516f, 0.13552260f, -0.16284628f, -0.42206395f, -0.00707220f, -0.08614311f, 0.04641024f, 
    0.11631794f, 0.02366592f, 0.01548309f, -0.02351977f, 0.12796681f, 0.00188009f, -0.04546473f, -0.11190858f, 
    -0.01541206f, 0.01991301f, 0.01584011f, 0.02228661f, 0.09218787f, 0.09103699f, 0.06061979f, -0.03640024f, 
    0.04438537f, 0.06464498f, 0.03545159f, -0.00506726f, 0.12486640f, 0.03914838f, 0.06111538f, -0.07188777f, 
    0.12650210f, -0.12275397f, -0.12047637f, -0.29855061f, 0.20041409f, 0.01885045f, -0.02561776f, -0.07050069f, 
    0.02908990f, -0.12209042f, 0.18879658f, -0.01188891f, 0.04482123f, 0.13940293f, -0.05685161f, -0.07908042f, 
    -0.03086795f, -0.08054500f, -0.09713023f, -0.14116579f, -0.19462489f, -0.02147310f, -0.05608666f, 0.20182161f, 
    -0.01138813f, -0.15302423f, 0.00857083f, -0.19645034f, -0.10317676f, 0.00061647f, -0.05642389f, 0.02053993f, 
    0.19071083f, -0.06891322f, -0.01349522f, -0.01407102f, -0.04726280f, -0.00126879f, -0.00176852f, -0.01740891f, 
    -0.11227701f, 0.08496327f, -0.05252774f, -0.09731514f, -0.05262148f, -0.37068489f, -0.01066103f, -0.61963886f, 
    -0.00835426f, 0.00296612f, 0.01931456f, 0.05535457f, 0.04959148f, 0.03290370f, -0.00656043f, -0.10157634f, 
    0.18855844f, -0.03462562f, -0.29466391f, 0.10952742f, 0.02216222f, -0.02187367f, 0.04506624f, -0.08191337f, 
    0.02000628f, -0.16627233f, 0.14298345f, -0.03591391f, -0.36329678f, -0.52692044f, -0.01018802f, 0.01176281f, 
    0.04806833f, 0.02707279f, 0.00780409f, -0.01482802f, 0.10233244f, 0.10198607f, 0.06047906f, 0.11199401f, 
    -0.14005935f, -0.19217305f, -0.06795668f, -0.07219162f, -0.00061789f, 0.00622787f, 0.02687982f, 0.02177593f, 
    -0.14591908f, 0.09425426f, -0.09146322f, -0.05000158f, 0.19262101f, -0.69451094f, 0.08810882f, 0.28796685f, 
    0.11222460f, 0.09558851f, 0.06311691f, -0.04834354f, 0.04630022f, 0.09220321f, -0.12927015f, 0.10745359f, 
    -0.04368706f, -0.06934562f, -0.09226218f, 0.02260502f, -0.08063335f, 0.01221643f, -0.06387427f, 0.03960065f, 
    0.08862160f, -0.12069426f, 0.06226018f, 0.09315910f, -0.00194975f, 0.06871403f, 0.01087799f, 0.14402592f, 
    -0.03275730f, 0.07748169f, -0.13796523f, -0.21714619f, 0.09057695f, 0.06660509f, 0.07740660f, 0.11460260f, 
    -0.14865188f, 0.03753372f, -0.04475315f, 0.07574801f, -0.17010973f, 0.05381205f, -0.00972362f, 0.05133704f, 
    0.07013252f, 0.02710833f, 0.01887927f, 0.14364788f, 0.02335700f, 0.00936463f, -0.05042610f, 0.17570747f, 
    0.06228316f, 0.02852044f, 0.02100092f, -0.12389137f, 0.01007084f, -0.05520890f, 0.03164574f, 0.11909408f, 
    -0.29791731f, 0.07359044f, 0.12487993f, 0.11030872f, -0.05710445f, -0.08842859f, -0.08045949f, 0.09910982f, 
    0.00549304f, 0.04238995f, 0.01758935f, 0.11572120f, -0.10739940f, -0.06767479f, 0.01880780f, -0.06010294f, 
    0.12004679f, -0.08140714f, -0.05861299f, -0.08396968f, -0.08150218f, -0.16058671f, 0.00890567f, 0.01450257f, 
    0.06422545f, 0.11358444f, -0.19798972f, 0.12825623f, 0.02558140f, -0.03247954f, 0.01396947f, -0.00207337f, 
    0.00777719f, 0.11152050f, -0.16794638f, 0.13484456f, 0.16852801f, 0.57208180f, 0.17417169f, 0.30443171f, 
    0.21660781f, 0.10744465f, 0.10981428f, 0.07335564f, 0.02583742f, 0.00031486f, -0.03488015f, -0.07430694f, 
    0.06729110f, -0.15256067f, -0.17427649f, -0.01176449f, 0.08166489f, -0.31075883f, 0.12763588f, 0.03092827f, 
    -0.03835829f, 0.10999528f, 0.15770650f, -0.05119208f, 0.08938543f, -0.00504908f, -0.04717098f, 0.05098961f, 
    -0.03508161f, -0.03347627f, -0.07117321f, -0.03822988f, 0.01802323f, -0.01804252f, -0.07318822f, 0.11050016f, 
    0.09203058f, 0.23517478f, 0.08715791f, 0.16620080f, -0.13967279f, -0.06094479f, -0.11886849f, 0.02142494f, 
    0.11933545f, 0.03556931f, -0.11563052f, -0.01202771f, -0.04736605f, 0.03358758f, 0.12768880f, 0.01468856f, 
    -0.05089989f, 0.01239268f, -0.02718918f, 0.08185691f, -0.01666936f, 0.01964311f, 0.00690032f, 0.14659755f, 
    -0.05667655f, -0.24244052f, -0.01101677f, 0.03353200f, 0.02015854f, 0.02643675f, -0.08381217f, -0.04315524f, 
    0.01265646f, 0.01221517f, -0.00592196f, -0.23441835f, 0.00601734f, 0.09455153f, 0.17379655f, 0.13618675f, 
    -0.17340869f, -0.05965830f, -0.00789773f, 0.01887970f, 0.09937847f, 0.02434128f, -0.00843870f, 0.04463194f, 
    -0.21019292f, -0.18659675f, -0.22837101f, 0.00088739f, 0.07474235f, -0.03055988f, -0.04788071f, 0.11176286f, 
    -0.06554491f, -0.04657758f, -0.04727433f, -0.02080001f, 0.02550197f, 0.10175764f, 0.06650801f, 0.05903196f, 
    0.03032413f, -0.09993754f, 0.06551557f, 0.02864074f, 0.06172684f, 0.16431557f, -0.03214984f, 0.02635769f, 
    0.10718130f, -0.10159469f, -0.17167382f, 0.28536156f, 0.02479256f, 0.07384014f, -0.22505704f, -0.22588246f, 
    0.06689409f, 0.04416795f, -0.05244334f, 0.05398953f, 0.09633475f, 0.06881615f, 0.09686698f, -0.00286985f, 
    -0.10992445f, 0.03313400f, -0.03232595f, 0.04342175f, 0.08721302f, -0.18000394f, -0.36309564f, 0.03740964f, 
    0.01571624f, -0.04384081f, 0.08829685f, 0.01276565f, -0.02747915f, -0.03058838f, -0.03439978f, -0.16894165f, 
    -0.09709878f, -0.04334763f, -0.04267142f, -0.03641837f, 0.13960040f, -0.17236114f, 0.06618792f, 0.15923502f, 
    -0.05446873f, -0.01564626f, -0.04073364f, 0.05971198f, -0.11511065f, -0.16179606f, -0.09446050f, -0.10764188f, 
    0.04027965f, 0.04339565f, -0.16276267f, 0.25694871f, 0.03047006f, -0.06198441f, -0.00587891f, -0.19209784f, 
    -0.07285353f, -0.10664036f, -0.07544080f, -0.00070030f, -0.01266708f, 0.07910477f, 0.06308401f, 0.13667735f, 
    0.00623545f, -0.03111877f, -0.03278048f, -0.07984976f, 0.00233180f, 0.00691173f, 0.00572717f, -0.04385477f, 
    -0.14026710f, -0.09850083f, -0.01877451f, 0.06274305f, 0.04893532f, 0.01794309f, -0.01497829f, 0.01068587f, 
    0.26569316f, 0.11763937f, -0.26261353f, 0.27442360f, 0.15762162f, -0.08076657f, 0.19140010f, -0.04011639f, 
    -0.01974444f, 0.00690945f, -0.04588885f, 0.01411310f, 0.10101558f, -0.13185619f, -0.06973304f, -0.00242622f, 
    0.02533582f, -0.07959037f, 0.14886862f, 0.07267249f, -0.08763538f, 0.08442330f, -0.24295795f, 0.06691699f, 
    0.08966429f, -0.10002860f, 0.00728623f, -0.09898138f, -0.05919530f, -0.06753618f, -0.01911436f, 0.03126673f, 
    0.08648660f, -0.06395192f, -0.11417785f, 0.20821577f, 0.05991581f, -0.02480805f, 0.00455938f, -0.02626107f, 
    0.04320573f, 0.04822343f, -0.10616528f, -0.07566921f, 0.06408785f, -0.00646951f, -0.21326354f, -0.14722882f, 
    0.09769841f, -0.00722005f, 0.00574947f, 0.04779632f, 0.13413103f, -0.27200499f, 0.15722643f, 0.17189930f, 
    -0.17114626f, -0.04671276f, -0.00304904f, -0.17459396f, -0.14220409f, -0.12748824f, -0.07290352f, -0.05458440f, 
    -0.24096838f, -0.10205298f, -0.01706995f, 0.03490026f, -0.12009648f, -0.00000301f, 0.01088388f, -0.14686812f, 
    -0.17674790f, -0.03223791f, -0.07216121f, 0.06002342f, 0.08576039f, -0.07663135f, 0.05156761f, 0.10169649f, 
    -0.07926625f, -0.06766371f, -0.06973951f, -0.01206480f, 0.00479034f, 0.03663215f, 0.02359057f, 0.06095237f, 
    -0.21547747f, 0.15948704f, -0.32524949f, 0.01567389f, 0.07230315f, -0.05059808f, -0.06120877f, -0.01073377f, 
    0.03085366f, -0.02613452f, 0.00291461f, -0.14717166f, 0.03481462f, -0.20988835f, -0.05021507f, -0.02466081f, 
    -0.03853089f, -0.01635876f, 0.09015550f, 0.00631418f, 0.06499553f, 0.01750737f, 0.00801772f, 0.00932396f, 
    0.02605438f, -0.10214086f, 0.14380567f, 0.13989654f, -0.12083708f, -0.09737608f, 0.08088419f, -0.02915505f, 
    0.00853331f, -0.01438503f, 0.06299357f, -0.01410970f, -0.00845125f, 0.10480324f, 0.10219556f, 0.11332159f, 
    -0.02426329f, -0.05312334f, -0.02603400f, -0.06114658f, -0.01559749f, -0.06484745f, 0.02397179f, 0.08058353f, 
    -0.19472210f, 0.07958795f, -0.13684586f, 0.07462073f, 0.04691823f, -0.02959708f, 0.03326101f, 0.06439853f, 
    0.06450558f, -0.09475434f, -0.19770674f, 0.05187285f, 0.12829289f, 0.25283661f, 0.29019931f, 0.17458291f, 
    -0.12100594f, -0.00614469f, 0.05158615f, 0.14052849f, 0.09626511f, 0.04528541f, 0.00050890f, -0.02084087f, 
    -0.03802234f, 0.11111742f, -0.17467970f, -0.07083010f, -0.05793136f, -0.23986100f, 0.08025436f, 0.03408879f, 
    -0.08911687f, -0.07030010f, 0.00593542f, -0.17436782f, 0.48174581f, -0.23789325f, -0.42408586f, -0.14423302f, 
    0.03824730f, -0.04130707f, 0.11197407f, 0.04251417f, 0.03460050f, -0.04599978f, -0.04689316f, 0.01624263f, 
    -0.03327093f, 0.13673531f, 0.01996460f, -0.01993284f, 0.00638466f, -0.04852530f, 0.02290698f, -0.04321125f, 
    -0.04340165f, 0.02088907f, -0.07776839f, 0.07358237f, 0.18584777f, -0.40157101f, 0.09079664f, -0.32611555f, 
    0.05202926f, 0.05770276f, 0.03784750f, -0.04265444f, 0.03140655f, -0.02525333f, 0.04074394f, 0.02113388f, 
    0.03894413f, 0.01335629f, 0.12809978f, 0.05001102f, -0.04119909f, -0.17143159f, 0.02038185f, -0.14814016f, 
    0.06474125f, -0.03001919f, 0.02094977f, 0.06129513f, 0.07211529f, 0.10445084f, 0.00730945f, 0.03480013f, 
    0.09739733f, 0.11425275f, 0.02673666f, 0.05448551f, 0.08058826f, 0.04747388f, -0.04409324f, 0.01507724f, 
    0.03647255f, 0.04258363f, 0.04516771f, 0.09990104f, -0.10159652f, -0.05027936f, -0.03255847f, 0.05292691f, 
    -0.23586304f, 0.03096349f, -0.16452929f, -0.17957203f, -0.05377395f, 0.03086152f, -0.00070590f, 0.02594988f, 
    -0.06671854f, -0.09283191f, 0.08184010f, 0.02208158f, 0.08128083f, -0.14772430f, 0.04892127f, -0.02651670f, 
    0.16166569f, 0.12632743f, -0.14026651f, 0.02984213f, -0.01296250f, -0.05740190f, 0.06695073f, 0.01729278f, 
    0.03099910f, -0.24968079f, -0.15408815f, -0.11834362f, 0.16378294f, 0.21131046f, -0.13702686f, -0.07127107f, 
    -0.01989128f, -0.07252784f, 0.04458690f, -0.08742460f, 0.11180640f, 0.00450313f, 0.00088429f, 0.42914614f, 
    -0.10755854f, -0.09583435f, 0.08910652f, 0.08991089f, -0.00888849f, -0.01311746f, 0.02770173f, -0.05055586f, 
    0.01834941f, -0.05328321f, 0.04079454f, -0.00091546f, 0.04372351f, 0.04966393f, 0.19187877f, 0.12577090f, 
    -0.25834575f, -0.06416866f, -0.09344309f, 0.00647131f, 0.01574248f, 0.03372995f, -0.03077682f, -0.03295809f, 
    -0.00378685f, -0.00019699f, -0.05208901f, -0.01726862f, 0.11764122f, -0.09973069f, -0.12250412f, -0.07333082f, 
    -0.11490292f, -0.12063053f, 0.11581145f, -0.13335608f, 0.14324373f, 0.06498323f, -0.08435933f, -0.00653463f, 
    0.04434273f, -0.04600514f, -0.00186179f, -0.01689561f, 0.04192619f, 0.00005713f, 0.13659847f, 0.30141613f, 
    -0.01437436f, 0.00229449f, -0.00686070f, -0.04703735f, 0.11113156f, 0.00333182f, 0.05327501f, 0.03733625f, 
    0.13782713f, 0.06203258f, -0.11215343f, -0.16455752f, -0.03078746f, -0.05763390f, -0.02189631f, -0.02383485f, 
    -0.07350537f, 0.01312254f, -0.10619030f, -0.08932254f, -0.15032877f, -0.07068848f, -0.10111593f, 0.00707496f, 
    0.06688835f, 0.12161794f, 0.07050771f, 0.05561123f, 0.03208284f, 0.06120908f, -0.06366431f, 0.01852896f, 
    0.01411827f, -0.11142194f, -0.07848644f, -0.18530075f, 0.02645557f, -0.10079316f, 0.08837945f, 0.02483494f, 
    -0.07321759f, -0.03619454f, 0.00811381f, 0.10218000f, -0.19000664f, -0.01969266f, -0.06462634f, 0.02197201f, 
    0.07489597f, -0.19067369f, -0.14043848f, 0.03881638f, 0.03307008f, -0.03623882f, -0.04932912f, -0.01295014f, 
    0.03811995f, 0.07904714f, 0.10857955f, -0.01977047f, 0.11808149f, 0.03480645f, -0.04657037f, -0.07641356f, 
    0.00409980f, 0.02003818f, 0.16861643f, 0.26605392f, -0.07767554f, 0.06786380f, 0.18477412f, -0.04336566f, 
    -0.14817591f, 0.14543837f, 0.05286910f, -0.30677262f, 0.04053785f, -0.13380647f, -0.01769147f, 0.15232462f, 
    -0.12553596f, 0.06975745f, -0.11504234f, -0.18421711f, -0.11573404f, -0.11851838f, 0.22871678f, 0.07931408f, 
    -0.24429911f, 0.04278725f, -0.05291589f, 0.07420219f, 0.13059460f, 0.01932238f, -0.16757829f, 0.11184060f, 
    -0.18739590f, -0.06838972f, 0.05533080f, 0.10727783f, 0.00749286f, -0.04182047f, -0.09442052f, 0.03414622f, 
    0.14773889f, -0.14106201f, 0.11762724f, 0.07886439f, 0.25803402f, -0.13638148f, 0.12346932f, -0.07128974f, 
    0.09297195f, 0.05632473f, -0.03740275f, 0.07735293f, 0.05401978f, -0.01166326f, -0.05744493f, 0.05966936f, 
    -0.06688004f, -0.24312675f, 0.10268726f, 0.17173646f, -0.01750155f, 0.01055906f, 0.02849228f, -0.06452726f, 
    0.01427713f, -0.03501558f, 0.09087923f, -0.02267391f, -0.29373649f, 0.29883754f, 0.20034423f, -0.10967606f, 
    -0.01545460f, -0.07853235f, -0.06582086f, -0.00156970f, -0.08843341f, -0.18373494f, -0.16783598f, -0.26755959f, 
    0.10278542f, -0.12027431f, 0.10006808f, 0.03476310f, 0.04127868f, 0.00581135f, 0.05437562f, 0.04823227f, 
    0.09918094f, 0.12426963f, -0.18632771f, 0.04745047f, -0.03035345f, -0.12353169f, -0.02817626f, 0.27848899f, 
    -0.11954113f, -0.03903557f, -0.12590735f, -0.21095897f, 0.03871748f, -0.04400139f, -0.06198993f, -0.03783922f, 
    -0.22143309f, 0.20239010f, 0.17452188f, -0.06466681f, 0.00016026f, -0.01850982f, 0.05629136f, 0.03173871f, 
    -0.02782141f, -0.13122545f, -0.18457738f, -0.02819498f, 0.05661018f, 0.01039100f, 0.10765339f, 0.05827107f, 
    -0.01579811f, -0.05941292f, -0.04365896f, 0.06406327f, -0.27918869f, -0.10143419f, -0.07335111f, -0.14049715f, 
    0.12167630f, -0.11174757f, 0.17664164f, -0.09480852f, 0.08205713f, -0.12084217f, 0.02694946f, 0.12623245f, 
    -0.07553609f, -0.21039385f, 0.05922380f, -0.17767912f, -0.09411234f, 0.12162299f, 0.18015598f, 0.11738028f, 
    -0.03815370f, -0.12116564f, 0.09695517f, -0.07052298f, 0.03113502f, 0.02613689f, -0.12222558f, -0.04415816f, 
    -0.15594579f, -0.01574633f, -0.28058016f, -0.15722516f, 0.10036059f, 0.00541439f, -0.04134069f, 0.15493889f, 
    -0.01689400f, -0.02720419f, -0.01533823f, -0.04455634f, -0.14252691f, -0.09709615f, -0.43171316f, -0.15374641f, 
    -0.00179799f, 0.10088826f, -0.10424644f, 0.05321924f, 0.10284007f, -0.12738223f, 0.20786300f, -0.05735624f, 
    -0.03576125f, -0.00885325f, -0.03848894f, -0.04898049f, 0.05919937f, 0.00191076f, -0.06214313f, 0.13029453f, 
    -0.11157813f, -0.05594387f, -0.20651639f, -0.27806795f, 0.04376976f, -0.05844675f, -0.18712898f, -0.10327403f, 
    0.13233407f, -0.02536883f, 0.11604216f, 0.21537811f, 0.03650537f, -0.04440926f, 0.10511239f, 0.03045289f, 
    -0.68559480f, -0.21741472f, -0.11720589f, 0.06559816f, 0.01255765f, -0.09742792f, 0.05156196f, 0.20256186f, 
    -0.04161572f, 0.00107988f, -0.10292298f, 0.03403585f, -0.03869380f, 0.02627065f, 0.06788690f, -0.12731886f, 
    0.00719999f, -0.02047517f, 0.01269903f, 0.00248057f, 0.06304572f, 0.12922998f, 0.05994541f, -0.04579195f, 
    -0.06517653f, 0.13514529f, -0.07477537f, -0.17684947f, 0.17331648f, -0.00435662f, 0.04256524f, -0.20579225f, 
    -0.14114445f, 0.18771607f, 0.11256772f, -0.19800769f, -0.00942016f, 0.07665313f, 0.16935423f, -0.03167094f, 
    0.03145340f, -0.05732929f, -0.13582768f, -0.08204933f, 0.02092616f, 0.02569431f, 0.00001289f, 0.00607360f, 
    0.19568738f, -0.03785895f, -0.23802108f, 0.42620018f, 0.03589337f, -0.03692309f, 0.04536991f, 0.06792402f, 
    0.07813849f, 0.06791675f, -0.04304604f, 0.01116737f, -0.15445724f, -0.10586563f, -0.06224486f, -0.26918390f, 
    0.15042883f, -0.06894747f, 0.07838867f, 0.07106663f, 0.01533339f, -0.02222025f, -0.07939667f, -0.01155608f, 
    -0.25386310f, 0.28109667f, 0.11798590f, 0.08378565f, -0.00251179f, -0.06203334f, -0.06397627f, 0.06901570f, 
    0.00504120f, -0.10127567f, -0.02759106f, 0.34731254f, 0.06072138f, 0.01040362f, -0.13476470f, -0.21019669f, 
    -0.01216477f, 0.06456461f, 0.03005826f, 0.05815489f, 0.05010423f, -0.01244471f, -0.05643690f, -0.08704840f, 
    -0.27429721f, 0.16394295f, -0.34663722f, 0.18086813f, 0.04596530f, -0.02049546f, -0.01642374f, 0.06337626f, 
    -0.20690538f, 0.09976706f, -0.15934882f, -0.05455859f, -0.06101471f, -0.29075423f, 0.16375186f, 0.04678646f, 
    -0.09555455f, -0.00987037f, -0.04139741f, -0.14970019f, 0.12633929f, 0.04156375f, 0.21786985f, 0.00820921f, 
    0.13981920f, 0.06055612f, -0.08639810f, -0.04013316f, -0.01313818f, -0.05628581f, -0.05545381f, 0.24798825f, 
    0.04848762f, -0.20802954f, 0.01249108f, -0.00614339f, 0.29529259f, -0.13751507f, 0.14189287f, 0.14941771f, 
    0.14690945f, -0.10694923f, 0.01281426f, 0.01258756f, 0.08233710f, -0.01176388f, 0.00175529f, 0.25477156f, 
    -0.03736037f, -0.00398862f, 0.20612942f, 0.04473571f, -0.08202054f, 0.23474203f, 0.11213242f, -0.02208013f, 
    0.08607513f, -0.05251661f, -0.04953911f, 0.00661578f, 0.06905226f, -0.10639367f, -0.01547428f, -0.19383988f, 
    0.05101635f, 0.05967732f, -0.02975900f, 0.00820017f, 0.00604451f, 0.01060844f, -0.02555309f, -0.01883966f, 
    -0.02084304f, -0.16386425f, -0.05675802f, 0.19404630f, 0.05578520f, 0.03188924f, 0.05894655f, 0.05406594f, 
    -0.24009480f, 0.00116006f, -0.12937889f, -0.35513222f, 0.00405988f, -0.13168067f, -0.04838876f, -0.08258346f, 
    0.12000852f, -0.05771047f, 0.12006122f, -0.17149679f, 0.28852695f, 0.07622144f, 0.01845042f, 0.03063010f, 
    -0.01941114f, 0.14116120f, 0.07097987f, -0.22991258f, 0.09702609f, -0.03060722f, 0.12588897f, 0.07486480f, 
    0.00159972f, -0.11355880f, -0.05358677f, -0.03484478f, 0.24360052f, -0.01589262f, -0.33839822f, 0.11959581f, 
    0.09072404f, -0.01651706f, -0.08519395f, -0.04621558f, 0.01845392f, 0.04008119f, 0.09936185f, 0.09115216f, 
    -0.14899857f, 0.24355988f, -0.01965540f, -0.28470182f, -0.03841551f, 0.03963307f, -0.08014324f, 0.10859808f, 
    0.10051694f, -0.16742967f, 0.02287811f, -0.07095946f, -0.30190426f, 0.48441485f, -0.16214713f, -0.05222072f, 
    -0.04607592f, 0.07583894f, -0.04571518f, 0.03127602f, 0.16168602f, 0.10668398f, 0.04098398f, 0.05771928f, 
    0.22384328f, -0.16939886f, 0.19357838f, 0.09032113f, -0.09062837f, -0.15293086f, -0.00839693f, 0.17622277f, 
    0.00951410f, 0.12443046f, -0.05166772f, 0.05593494f, 0.10305622f, -0.07087924f, 0.11320902f, -0.06325245f, 
    -0.02822900f, -0.05280312f, 0.01658186f, -0.04870519f, 0.07430000f, -0.15909266f, -0.04156176f, -0.07857805f, 
    -0.11087826f, 0.17544982f, -0.66169173f, -0.45908949f, 0.11075069f, 0.16935684f, -0.14400174f, -0.01848967f, 
    0.04386611f, -0.04830574f, 0.04118016f, 0.01862509f, -0.17722607f, -0.15263039f, -0.11369619f, -0.17737426f, 
    0.02548642f, -0.00918325f, -0.10078241f, -0.04316096f, 0.05943192f, 0.03850998f, -0.13727705f, 0.03269967f, 
    -0.10933421f, -0.06808153f, 0.04715221f, -0.07377615f, 0.18500280f, 0.10792916f, 0.07014979f, -0.01459853f, 
    0.06422612f, -0.00271785f, 0.05238399f, 0.08952025f, -0.00769501f, 0.10363418f, 0.15834963f, -0.10816639f, 
    0.02652107f, 0.01906665f, 0.09421384f, 0.01926315f, 0.12935640f, 0.01571695f, 0.03773003f, -0.03543942f, 
    0.19771883f, -0.21406899f, -0.18712825f, -0.07367209f, -0.12314668f, 0.05368511f, -0.04812895f, 0.02789235f, 
    0.11734449f, 0.04426544f, 0.19186260f, 0.04570063f, 0.16051386f, 0.07551342f, 0.08517136f, 0.06731328f, 
    0.21899496f, 0.08391758f, -0.05245471f, -0.36957470f, -0.08909500f, -0.02353560f, -0.00461070f, 0.00851493f, 
    0.06344728f, -0.19799741f, 0.29528505f, 0.26351786f, 0.15158635f, -0.09612806f, -0.06250269f, 0.06672307f, 
    0.05906998f, -0.04047746f, 0.05867551f, 0.04816081f, -0.41666549f, -0.08921169f, -0.21354967f, 0.16881309f, 
    -0.01532795f, -0.06312972f, 0.00021213f, 0.00641711f, -0.01648259f, -0.01900491f, 0.06192489f, 0.06322183f, 
    0.07565437f, -0.05051103f, 0.13628252f, -0.05866990f, -0.00944806f, 0.08598703f, 0.01902162f, 0.00274569f, 
    0.17858054f, 0.03494776f, 0.01813712f, -0.11446959f, -0.00911514f, -0.06953657f, 0.17938533f, -0.13735625f, 
    -0.04526941f, -0.00727130f, -0.02245075f, 0.01590619f, 0.13559954f, -0.24566369f, 0.03108271f, -0.20775168f, 
    -0.19829242f, -0.13782114f, -0.22912703f, -0.13448913f, 0.05029783f, 0.08347833f, -0.02625518f, 0.13229986f, 
    -0.06603923f, -0.00511342f, 0.06827463f, -0.14787368f, -0.04560087f, -0.05079857f, -0.04359621f, -0.05039969f, 
    -0.13963664f, -0.03713042f, 0.01943625f, 0.08974359f, 0.09633895f, 0.04646194f, 0.05856837f, -0.07892279f, 
    0.10747812f, 0.06956889f, 0.07146876f, 0.11235999f, 0.18977974f, 0.04810692f, 0.10193928f, -0.12164826f, 
    -0.03460760f, -0.00771954f, 0.09582953f, 0.13419041f, -0.80594200f, -0.17770645f, -0.31863952f, -0.11864082f, 
    0.03333071f, -0.02818460f, 0.01984070f, -0.02057139f, 0.20643751f, 0.00678803f, -0.07745875f, -0.09322869f, 
    -0.29273623f, -0.34539425f, 0.01267154f, 0.13708857f, -0.23868118f, -0.06166779f, -0.02465593f, 0.01064998f, 
    0.10747433f, 0.06359510f, 0.15518971f, -0.03063909f, 0.21051423f, -0.30222592f, -0.16442494f, 0.10684738f, 
    0.02175676f, 0.05184379f, 0.02575869f, 0.01609044f, 0.07749813f, -0.14143725f, -0.03612861f, -0.62369424f, 
    0.04529332f, 0.07025934f, 0.32006279f, -0.07184798f, -0.01488541f, 0.02052346f, 0.10306334f, -0.02155084f, 
    0.01788560f, 0.02639004f, 0.02242231f, 0.00676228f, 0.03948094f, -0.04091555f, 0.15091133f, -0.22167531f, 
    0.22635540f, -0.07675719f, 0.11027991f, -0.07545150f, -0.07741271f, 0.02142277f, 0.02360982f, -0.00579068f, 
    -0.06844820f, 0.31923434f, -0.12244736f, -0.14186776f, -0.14203465f, 0.22971985f, -0.06715961f, -0.04589178f, 
    0.19797306f, -0.03944261f, 0.11122087f, 0.07403315f, 0.02416940f, -0.05352639f, -0.15732238f, -0.05584050f, 
    0.01489159f, 0.02883585f, 0.11434208f, 0.00429632f, 0.09191412f, -0.19024426f, -0.29092038f, -0.50523597f, 
    -0.01327839f, -0.13561134f, -0.39239967f, 0.14172408f, 0.00307663f, -0.03286944f, 0.07131081f, -0.08514453f, 
    -0.03927549f, 0.04423556f, -0.08388291f, 0.19026223f, 0.06593521f, 0.25582722f, -0.00823364f, 0.10365087f, 
    -0.01381159f, -0.06843589f, -0.00987358f, 0.06342535f, 0.10954344f, 0.06948062f, -0.09452941f, 0.22280976f, 
    -0.05702309f, -0.09244248f, 0.03079516f, -0.02078044f, -0.06399705f, -0.07910065f, -0.05611214f, -0.07310942f, 
    -0.00828599f, 0.08649842f, 0.02409762f, 0.06804825f, 0.11124329f, -0.21838669f, -0.04290793f, -0.08004082f, 
    -0.06045242f, 0.16348091f, -0.15357332f, -0.00543998f, -0.08482650f, -0.02157204f, -0.02557842f, 0.05772061f, 
    0.11975554f, -0.08603454f, -0.03597044f, 0.01992090f, 0.01826593f, 0.03088603f, 0.13706455f, -0.04577665f, 
    0.02486672f, -0.07758069f, -0.00994029f, -0.18046257f, -0.04656824f, -0.04386489f, -0.11440665f, -0.08435552f, 
    -0.09584619f, -0.05159242f, -0.10143392f, -0.29000351f, 0.07563664f, -0.01816072f, -0.06042001f, -0.03918689f, 
    -0.20670873f, -0.09995234f, 0.07381277f, 0.17923702f, 0.13213547f, 0.07417936f, 0.12742908f, -0.21018201f, 
    0.01854134f, 0.13258871f, 0.07266849f, -0.00995612f, -0.11815147f, -0.18856376f, -0.02881961f, 0.26567239f, 
    -0.06846246f, -0.03487833f, 0.12009797f, -0.03141388f, 0.00051531f, -0.10109624f, 0.10283778f, 0.06563711f, 
    -0.01894811f, -0.06135042f, 0.19199206f, 0.00621296f, 0.01981101f, -0.04896266f, 0.01464287f, -0.06236821f, 
    0.13161476f, 0.01810876f, 0.10185602f, -0.00121592f, 0.01441173f, -0.18173453f, -0.34648401f, -0.02100490f, 
    -0.01220269f, -0.06050849f, 0.03279260f, 0.09755979f, -0.03289986f, 0.01594454f, -0.02725248f, 0.03324324f, 
    -0.06201617f, 0.08295291f, -0.04257501f, -0.01287047f, -0.00550329f, 0.04903113f, 0.01864138f, 0.06778860f, 
    -0.02139088f, -0.02085186f, 0.02472076f, 0.06561518f, -0.00598255f, -0.01797562f, -0.03407418f, 0.07007170f, 
    0.01674416f, -0.02811889f, 0.03368747f, 0.05932143f, 0.03413339f, 0.04124903f, 0.19588713f, 0.03549431f, 
    -0.01981994f, 0.11478814f, 0.08045614f, 0.05128220f, -0.02372624f, -0.04628091f, 0.07064466f, 0.04862667f, 
    0.18709719f, -0.04670752f, 0.23881947f, 0.08722463f, -0.31777000f, -0.13284755f, -0.03637064f, 0.12404736f, 
    0.09011060f, 0.15428729f, -0.01458630f, -0.12219267f, 0.07754896f, 0.01992555f, 0.04214246f, 0.03204321f, 
    -0.18333754f, -0.37744784f, 0.00210877f, 0.04894576f, -0.06644223f, 0.01665250f, 0.02436302f, 0.04953065f, 
    -0.04908745f, 0.02889642f, 0.15277778f, 0.11305057f, 0.19889525f, -0.11467799f, -0.05288468f, -0.07350614f, 
    -0.03519895f, -0.00187495f, 0.06724309f, 0.06181062f, 0.08097883f, 0.04978256f, -0.07098440f, -0.06849243f, 
    -0.08070111f, 0.11062428f, -0.22163457f, 0.06054540f, -0.02313795f, 0.06338663f, 0.03876372f, 0.19344161f, 
    0.04780723f, 0.03598456f, 0.05835488f, 0.13899493f, -0.43301827f, -0.41258761f, -0.35402918f, -0.31801519f, 
    -0.07922295f, 0.09666119f, -0.05884851f, 0.05668626f, 0.03647079f, -0.02112557f, 0.06167281f, -0.09766224f, 
    -0.68996257f, -0.40584272f, -0.21170513f, -0.07553355f, -0.04576000f, 0.11595414f, -0.16521107f, 0.13126920f, 
    0.05757630f, -0.02806128f, 0.00724042f, -0.04187685f, 0.13102761f, 0.32483068f, 0.01976566f, 0.14739278f, 
    0.01899296f, -0.05123551f, 0.08449326f, 0.00553706f, 0.02270750f, -0.04480147f, 0.03131076f, 0.04506097f, 
    0.06918859f, -0.04856900f, -0.05896815f, -0.02703645f, 0.02915495f, 0.00516149f, 0.05065967f, 0.06261575f, 
    -0.04767209f, 0.09134875f, 0.04788902f, -0.06067061f, 0.13981543f, -0.83909518f, -0.12647581f, -0.36473033f, 
    -0.04983959f, -0.08350348f, 0.23868820f, -0.25294170f, 0.03371855f, -0.01537824f, 0.00868062f, -0.00609916f, 
    0.08135266f, 0.04680133f, 0.10839768f, 0.06742390f, -0.02341878f, 0.00410311f, -0.00506331f, 0.03223650f, 
    0.00497885f, 0.11883252f, 0.10279896f, -0.03207631f, -0.07269458f, -0.03149786f, 0.05206497f, 0.12531328f, 
    0.03703865f, 0.02208238f, 0.02674514f, -0.01389370f, 0.09823453f, -0.04990708f, 0.12374776f, -0.01485791f, 
    -0.37822297f, 0.19953629f, 0.56227803f, 0.29741365f, 0.02407874f, -0.06288022f, -0.24649872f, 0.06487621f, 
    -0.07326940f, 0.06054796f, -0.05164965f, 0.08760592f, -0.37775606f, -0.44676533f, -0.49316010f, 0.00953459f, 
    -0.09383345f, -0.02206839f, 0.04879700f, -0.25310302f, -0.01813194f, 0.01129169f, 0.03261043f, 0.00681742f, 
    0.17161655f, 0.14027032f, -0.20463046f, -0.42721757f, -0.01261023f, 0.01010044f, 0.03823145f, 0.11098255f, 
    -0.11319564f, -0.05622073f, -0.05429814f, -0.01201425f, -0.45492584f, -0.10042281f, -0.01170317f, -0.39266694f, 
    -0.05178116f, -0.03024100f, 0.03747746f, -0.01623858f, 0.01746668f, -0.00620952f, -0.01735015f, 0.10058691f, 
    0.04716213f, -0.30461201f, 0.12847207f, 0.03627976f, -0.06293343f, -0.03010575f, 0.01014106f, 0.05757538f, 
    -0.01242615f, 0.02334648f, 0.20449911f, 0.01940063f, 0.05111463f, -0.02648650f, 0.08556977f, 0.13069531f, 
    -0.04199719f, -0.08311787f, -0.03437331f, -0.15253462f, -0.13056922f, -0.19596855f, 0.00917236f, 0.08458164f, 
    0.20241451f, -0.16522421f, -0.28758305f, -0.23628567f, 0.02935347f, 0.13980150f, 0.11448921f, 0.07535122f, 
    -0.07220815f, 0.02217940f, -0.02581735f, -0.00767642f, -0.20319615f, 0.13103075f, -0.06191227f, 0.11806249f, 
    -0.04322184f, -0.02604444f, -0.12939633f, 0.04040922f, 0.01578594f, -0.10649356f, 0.06017376f, 0.15442199f, 
    0.38468879f, 0.31730664f, -0.30479753f, -0.11246306f, -0.06813064f, -0.18353459f, 0.11592715f, 0.21311823f, 
    0.05786426f, 0.04779252f, -0.00031375f, -0.04189992f, -0.07163979f, -0.18585396f, -0.11728790f, -0.10906599f, 
    0.00241558f, 0.03064772f, -0.00924518f, 0.07381080f, -0.05978585f, 0.01939300f, 0.13023959f, 0.04686615f, 
    -0.24517411f, -0.24510752f, -0.27100918f, -0.02862143f, -0.11325908f, -0.08514459f, -0.05185499f, -0.16049364f, 
    0.04919141f, 0.04825882f, 0.04333542f, -0.13005634f, -0.59039032f, -0.07867657f, 0.04722340f, 0.19782564f, 
    0.06861990f, -0.03927262f, -0.09267230f, 0.00272286f, 0.04086808f, 0.03683163f, 0.00747155f, -0.03678356f, 
    0.00931996f, 0.02919446f, 0.07389142f, -0.00066730f, -0.01989604f, -0.00162075f, 0.03666408f, -0.04023417f, 
    -0.00133338f, -0.08139023f, -0.04911131f, 0.03845171f, -0.12958249f, 0.38849851f, 0.01704180f, -0.14876035f, 
    -0.02991236f, -0.10016734f, -0.10107424f, 0.05873145f, 0.03728440f, -0.07299393f, -0.04099550f, -0.03496762f, 
    -0.18176073f, 0.61071998f, 0.07755642f, -0.09197506f, -0.10957989f, 0.03479868f, -0.01690354f, 0.20347451f, 
    0.03383018f, 0.07848811f, -0.00993200f, -0.03672462f, 0.22043709f, -0.05023689f, -0.05476468f, -0.12852441f, 
    0.01988893f, 0.01667628f, 0.13950181f, 0.02314979f, 0.05151157f, 0.11326254f, 0.01255187f, -0.04329690f, 
    0.05550634f, -0.04344520f, 0.15878476f, -0.06136018f, 0.15854377f, -0.00415646f, 0.10658619f, -0.07831496f, 
    0.09523482f, 0.09628855f, 0.02652867f, 0.11308138f, -0.36459407f, -0.16078137f, 0.34345502f, 0.23708291f, 
    -0.01033160f, -0.05345394f, 0.05338925f, -0.23802981f, -0.06330173f, 0.09370701f, 0.13035984f, -0.03622317f, 
    0.02376601f, -0.18934436f, -0.20694248f, 0.20128326f, -0.06888743f, 0.08826157f, 0.09060519f, 0.04138626f, 
    -0.05394744f, -0.00208428f, -0.03903359f, 0.13380945f, -0.21355227f, 0.24762622f, 0.00783420f, 0.01059906f, 
    -0.10752849f, 0.02244288f, -0.11417799f, 0.09315060f, -0.00265876f, 0.04161511f, 0.00243244f, 0.02361311f, 
    -0.05682415f, -0.07938016f, 0.32336140f, -0.55298287f, 0.04328677f, -0.07229174f, 0.08565160f, -0.10625830f, 
    0.03998153f, 0.10255843f, -0.12771665f, 0.04949790f, -0.02718518f, 0.05727816f, 0.05374241f, -0.04644917f, 
    -0.04045917f, 0.01434313f, -0.02448306f, 0.07132979f, -0.00832326f, -0.00480730f, 0.15328030f, 0.08944498f, 
    -0.43138501f, -0.51275623f, -0.63223946f, -0.10627420f, 0.09948184f, -0.23557924f, -0.22033180f, -0.28186280f, 
    -0.00689531f, 0.01424639f, -0.05862973f, -0.02988546f, -0.62562364f, -0.68587524f, -0.21826632f, -0.37022284f, 
    0.03132157f, -0.17304896f, -0.12641498f, -0.24074244f, 0.00181641f, -0.04317660f, -0.01544826f, -0.02630768f, 
    0.35311535f, 0.19058417f, -0.23251848f, 0.39281955f, 0.00643776f, -0.07056783f, 0.08407537f, 0.07451206f, 
    0.12399726f, -0.04795298f, -0.14711016f, -0.04860471f, -0.65933329f, -0.73451048f, -0.38909554f, -0.06886700f, 
    -0.17905934f, -0.15037544f, -0.12456314f, -0.40200573f, 0.04839776f, -0.08728436f, -0.02178527f, 0.05733719f, 
    0.10689338f, -0.07057619f, -0.02859723f, 0.03816881f, -0.02387832f, -0.09935146f, 0.02673590f, 0.05211037f, 
    -0.09116895f, 0.10717921f, 0.04158829f, -0.12946115f, 0.14621089f, 0.01669188f, -0.20960274f, 0.03535324f, 
    -0.02023064f, -0.00953394f, -0.08011404f, -0.05389601f, -0.06143895f, -0.06922160f, 0.05276452f, -0.23933677f, 
    -0.25572166f, -0.10150362f, 0.10621754f, 0.25792602f, -0.12038349f, -0.01408153f, -0.05393127f, -0.05117166f, 
    0.00847266f, -0.03271617f, 0.06980269f, 0.04930637f, -0.14324051f, -0.03606497f, -0.05238579f, 0.00910558f, 
    0.01786075f, 0.03508621f, -0.01948163f, -0.01468180f, 0.01613279f, -0.01521249f, -0.01549787f, -0.04189238f, 
    -0.36732668f, 0.07834562f, 0.44409689f, 0.03641019f, -0.06789191f, -0.00842630f, -0.04860075f, -0.23377743f, 
    -0.08467668f, 0.01481047f, -0.11688355f, 0.18096428f, -0.00827458f, -0.08104859f, -0.08660427f, 0.00288092f, 
    -0.16611890f, -0.10727017f, -0.15196016f, -0.03912053f, -0.07186328f, -0.20704228f, -0.02809673f, -0.01319200f, 
    -0.29357120f, -0.16148084f, 0.35150596f, 0.03357469f, -0.02964470f, 0.00118906f, 0.09390835f, -0.18454216f, 
    -0.13058014f, 0.03159747f, -0.08140270f, -0.03015669f, -0.07486910f, -0.01939710f, 0.37203142f, 0.02934070f, 
    -0.05635491f, -0.01121481f, 0.00211556f, 0.00621164f, -0.00456860f, 0.07967518f, 0.05203426f, 0.14048029f, 
    -0.27466178f, -0.08438904f, 0.01979461f, 0.29440245f, -0.01286562f, -0.17304608f, -0.04071853f, 0.08833358f, 
    -0.04118488f, 0.01303717f, 0.08658738f, 0.09882862f, 0.11599769f, 0.08396803f, -0.28506759f, -0.14082466f, 
    0.00486432f, -0.04162720f, 0.11185134f, 0.05979300f, 0.09844290f, 0.11058932f, 0.24979548f, 0.08024132f, 
    -0.20064329f, -0.44499615f, -0.43464732f, -0.02467611f, -0.04143194f, 0.07451230f, -0.01281177f, -0.19033846f, 
    -0.05033633f, 0.02099440f, 0.02015221f, 0.03673185f, -0.22810769f, -0.16973341f, -0.16870466f, -0.09656766f, 
    -0.14988457f, -0.05476234f, -0.07845272f, -0.02484796f, 0.08061951f, 0.01137562f, -0.01936332f, -0.01910027f, 
    -0.19784737f, 0.26177663f, 0.43470314f, -0.16671057f, 0.07218706f, 0.05230399f, -0.06356036f, 0.03810458f, 
    0.02913359f, 0.07475346f, -0.15503441f, 0.04519752f, 0.13636099f, -0.00334691f, -0.01880109f, 0.01128424f, 
    -0.06253581f, -0.01789691f, 0.04398496f, 0.07751814f, -0.07903933f, 0.08444442f, 0.15457572f, 0.12521048f, 
    0.14166966f, 0.10881869f, -0.05796560f, -0.10356355f, 0.16329351f, -0.13854121f, 0.19075178f, -0.17444672f, 
    0.04348148f, 0.00645057f, -0.08711709f, 0.12767370f, 0.11182752f, -0.15706906f, 0.05068884f, -0.33785212f, 
    -0.05741855f, -0.06723774f, 0.09183169f, -0.03603811f, -0.06060254f, 0.04133926f, -0.06962848f, 0.00957940f, 
    0.00150050f, -0.02837218f, -0.02869611f, -0.05847750f, 0.04457790f, -0.01679324f, -0.02746476f, 0.05306832f, 
    -0.04466977f, 0.05139578f, -0.03836446f, -0.16663080f, -0.37599197f, 0.38141176f, 0.18074124f, 0.17096597f, 
    -0.08673967f, -0.02047108f, -0.11714385f, 0.01699867f, 0.03591610f, -0.04662851f, -0.14510094f, 0.09699220f, 
    0.03152730f, 0.00115682f, 0.09439627f, -0.08625886f, -0.01015524f, -0.05763605f, -0.02017111f, 0.02223776f, 
    0.03927394f, -0.00959726f, -0.01656474f, -0.02164765f, -0.00569976f, -0.00185753f, 0.03681765f, -0.06021202f, 
    0.11144044f, 0.07297416f, -0.06920328f, -0.05490892f, 0.09236421f, -0.00149061f, 0.03555839f, 0.05480529f, 
    -0.11157446f, 0.06752644f, 0.23794253f, -0.02702469f, 0.10115704f, -0.09519666f, 0.06825130f, 0.06244477f, 
    -0.10006917f, -0.06356607f, 0.05246529f, 0.06398980f, 0.30482328f, -0.21618296f, -0.00512124f, -0.08940049f, 
    -0.01218648f, 0.01275852f, -0.01440912f, -0.06914119f, 0.01843671f, 0.08701972f, -0.07739091f, -0.13196409f, 
    0.15678957f, 0.07884369f, -0.01825780f, -0.19371614f, -0.00103289f, 0.00256108f, -0.04815079f, -0.03494934f, 
    -0.07806732f, -0.03425158f, -0.15362187f, -0.24940544f, -0.06258667f, -0.17962393f, 0.07736749f, -0.19602616f, 
    0.02447151f, 0.00126166f, 0.02051602f, -0.07462444f, 0.04571585f, 0.05613700f, 0.07803778f, 0.00052993f, 
    0.05848118f, 0.11244772f, -0.03219958f, -0.00900259f, 0.00383093f, 0.04319365f, -0.05125990f, -0.10485013f, 
    -0.00653790f, -0.03155800f, 0.05689595f, -0.02721832f, 0.15455973f, -0.13803366f, -0.14654388f, -0.11949924f, 
    0.00105725f, -0.00660627f, -0.01532930f, -0.05606386f, 0.06543235f, -0.01906511f, 0.09657084f, -0.10368615f, 
    0.06129352f, -0.23877837f, -0.01094814f, -0.16304891f, 0.03477957f, 0.01981635f, -0.03054323f, 0.00511704f, 
    -0.02872482f, 0.06441626f, -0.03612410f, -0.04917561f, 0.09869166f, -0.00516958f, -0.04642124f, -0.11796179f, 
    -0.07572985f, -0.09432356f, -0.03487992f, 0.02834164f, -0.01891844f, 0.07315078f, 0.04604269f, -0.04016750f, 
    -0.44112235f, 0.07234051f, -0.24591342f, 0.12195260f, -0.09851486f, 0.03101882f, 0.00387047f, 0.02300918f, 
    0.03573722f, -0.07445977f, -0.00811891f, 0.08913188f, -0.40257320f, -0.27679527f, -0.15797591f, 0.23136412f, 
    -0.01811526f, 0.00205188f, -0.05577172f, 0.03534073f, 0.12995291f, -0.00022539f, 0.05271671f, 0.01245574f, 
    0.02661410f, -0.58631814f, -0.40588844f, -0.39623421f, -0.08865282f, -0.15375745f, 0.01419134f, -0.08387961f, 
    0.03081010f, -0.01489630f, 0.01306452f, 0.03345783f, -0.53218746f, 0.37781793f, -0.27479300f, 0.48699564f, 
    -0.03842339f, 0.16031475f, -0.00470098f, -0.03956718f, -0.06769665f, -0.03568936f, -0.16686511f, 0.08802076f, 
    -0.44893137f, -0.29558846f, -0.30084535f, -0.31350964f, 0.07359772f, 0.12334219f, 0.12388152f, 0.10059996f, 
    0.13136463f, 0.03845119f, -0.02766897f, 0.03871965f, -0.27764463f, -0.05723618f, 0.09339096f, 0.11868238f, 
    -0.11698867f, -0.02938641f, 0.14630333f, -0.00469126f, -0.11077378f, -0.05072245f, 0.04990444f, -0.14909193f, 
    0.02245658f, 0.01054330f, 0.07596524f, -0.03412184f, -0.03987622f, 0.02593288f, -0.06267551f, 0.05970712f, 
    0.06114439f, -0.02018812f, 0.00597295f, 0.04644067f, -0.67446989f, 0.62182033f, -0.26611719f, -0.13163640f, 
    0.03704942f, -0.16913964f, -0.01075651f, 0.02926205f, 0.04475546f, 0.00667767f, 0.02346142f, 0.00045635f, 
    0.23499240f, 0.00801354f, 0.11075830f, 0.04579067f, 0.00639696f, 0.03153460f, -0.05334034f, -0.02385700f, 
    0.08206768f, -0.09725323f, -0.01373590f, -0.01723079f, 0.11595214f, -0.10354662f, 0.16526295f, -0.12243821f, 
    0.00870568f, 0.02247196f, -0.02140093f, -0.00747952f, -0.00741825f, -0.03410968f, 0.01528170f, -0.09018109f, 
    -0.18971017f, -0.21169749f, -0.31442484f, -0.09632659f, 0.07621440f, -0.16349736f, 0.00590662f, 0.04217022f, 
    -0.01948593f, 0.13221930f, -0.01179319f, 0.04883017f, -0.18234086f, -0.27754122f, 0.13034685f, -0.22835161f, 
    0.08976838f, 0.00234926f, 0.08795097f, 0.16658603f, -0.00300755f, -0.07288813f, -0.06342463f, 0.02650309f, 
    -0.17251834f, 0.03300259f, -0.26352262f, 0.07953617f, -0.04932687f, 0.00016202f, -0.02585751f, -0.03351124f, 
    0.02583588f, -0.04760093f, -0.08099724f, -0.08713777f, 0.39859232f, -0.32594866f, -0.15058292f, -0.48053345f, 
    0.04296118f, 0.08411014f, 0.09568670f, 0.14533706f, 0.06200753f, -0.02022994f, 0.02455039f, 0.08218861f, 
    -0.21675873f, 0.11849474f, -0.11417047f, 0.10530323f, 0.02523948f, 0.10679158f, 0.03819385f, 0.00240830f, 
    -0.01093629f, 0.06605145f, -0.09121630f, -0.02383808f, -0.24957018f, 0.13295957f, 0.10369997f, 0.07370657f, 
    0.05670915f, 0.04648273f, 0.05423880f, 0.05615453f, -0.06552086f, 0.04902098f, 0.07549394f, 0.04084118f, 
    -0.11559048f, 0.15905927f, -0.02619913f, -0.05378139f, -0.12728219f, 0.03845530f, -0.11222569f, 0.01524424f, 
    -0.00888366f, 0.07881878f, -0.00450360f, 0.02647838f, 0.07441477f, -0.09508896f, -0.06769837f, -0.15090510f, 
    0.03118268f, -0.03142505f, 0.10430768f, -0.00596233f, -0.04981443f, -0.06482569f, 0.01444185f, -0.12282706f, 
    -0.37910914f, -0.18688880f, -0.17031126f, -0.06857496f, -0.13391764f, 0.04077946f, 0.05685655f, -0.05057565f, 
    -0.11965287f, 0.10340378f, 0.02259384f, 0.00833867f, 0.37186795f, -0.12621818f, 0.04049239f, -0.28494003f, 
    0.05361174f, 0.04363568f, 0.02389150f, -0.08940399f, 0.02508440f, 0.07005861f, 0.15175295f, -0.16107178f, 
    -0.02263129f, 0.10020716f, 0.21330948f, 0.31454864f, -0.13303035f, 0.06492085f, -0.12583596f, -0.01129308f, 
    -0.02785633f, 0.07271309f, 0.02383416f, 0.04689449f, -0.36684552f, -0.38954958f, -0.48509818f, -0.28275648f, 
    -0.05546298f, -0.07480212f, 0.07345188f, 0.00076033f, 0.00296197f, 0.04600171f, -0.01530979f, 0.01852348f, 
    -0.05675996f, 0.03327174f, -0.02716836f, -0.07146271f, -0.00591631f, -0.03610940f, -0.01092912f, -0.04617665f, 
    0.06443964f, 0.20430058f, -0.04544695f, 0.05575913f, 0.01315028f, -0.02133913f, 0.09794351f, 0.03929765f, 
    0.03688518f, -0.03089582f, 0.03339520f, 0.01632557f, -0.05337513f, -0.01769986f, 0.02422670f, 0.08349631f, 
    0.02183740f, -0.50186408f, -0.54824984f, -0.16522060f, -0.04426902f, -0.20617013f, 0.08275886f, -0.06651373f, 
    0.13317983f, -0.08275510f, -0.02771503f, -0.04486864f, 0.01689219f, 0.06284977f, 0.09952775f, -0.00509938f, 
    0.02911540f, 0.06121706f, -0.07486983f, -0.02309229f, -0.02271313f, 0.03656200f, 0.01958522f, 0.06913640f, 
    -0.12099084f, 0.05213633f, 0.12157809f, 0.10133871f, -0.08747454f, -0.08083098f, 0.10579485f, -0.03078168f, 
    -0.03971491f, 0.01891624f, -0.00277925f, -0.12503435f, 0.25079775f, 0.05138417f, -0.10589977f, -0.03972990f, 
    0.04253100f, 0.07216828f, -0.02721955f, 0.05492246f, 0.02099224f, -0.04000322f, 0.01600744f, -0.02824402f, 
    0.35343733f, -0.48974088f, 0.10827881f, -0.09860546f, -0.02633439f, 0.03561584f, -0.03115261f, -0.09523128f, 
    0.00567680f, 0.03440928f, -0.02994234f, -0.08000380f, 0.46268708f, -0.41594014f, -0.13438796f, -0.22931105f, 
    0.05766116f, 0.12097304f, 0.05524741f, -0.07053626f, 0.05416951f, 0.00212557f, -0.02874994f, -0.04383520f, 
    -0.04967502f, 0.35054079f, -0.02118367f, 0.06296404f, -0.09970942f, 0.08429997f, 0.14752163f, 0.07277940f, 
    -0.06916670f, -0.08450525f, 0.03993928f, -0.14842916f, 0.06678853f, -0.02631353f, -0.07693703f, 0.03065983f, 
    0.00172458f, 0.09023450f, -0.00694327f, -0.04614078f, 0.03780300f, 0.17569068f, -0.02041716f, 0.00106303f, 
    -0.39110142f, -0.28553212f, 0.19543543f, -0.31914169f, 0.02286235f, -0.00922755f, -0.16677125f, 0.17614666f, 
    0.04473118f, 0.00353194f, 0.02023565f, -0.00223794f, -0.33783391f, -0.36542416f, 0.03908330f, 0.44222197f, 
    -0.00867966f, 0.02882595f, -0.06759284f, 0.00739672f, -0.01439778f, -0.06830650f, 0.00905906f, 0.00253928f, 
    -0.04667402f, -0.10588539f, 0.00325023f, -0.00913767f, -0.09147312f, -0.10489319f, 0.06433355f, -0.08737005f, 
    -0.12638508f, 0.06238082f, 0.00946559f, -0.02634274f, -0.42424873f, -0.23721404f, -0.07938709f, 0.56553012f, 
    0.13713747f, 0.05849802f, 0.14037010f, 0.06254649f, -0.02665474f, -0.00415241f, -0.02414537f, -0.06971958f, 
    0.27463147f, -0.00684803f, -0.04439020f, 0.06647778f, -0.04946481f, -0.01028892f, -0.01914850f, -0.03330555f, 
    -0.07584908f, 0.03951734f, -0.08828269f, -0.06969007f, 0.02478564f, -0.13976225f, 0.16406046f, -0.28002775f, 
    0.00975113f, 0.08257062f, -0.03016819f, -0.02716387f, 0.09225462f, 0.01797863f, -0.07930329f, 0.01255417f, 
    0.28119791f, -0.46294758f, -0.22983956f, 0.01371317f, 0.09832807f, 0.04947874f, -0.06192489f, -0.04524685f, 
    0.03651481f, 0.07156981f, 0.03640738f, 0.03215149f, 0.05428575f, -0.19225883f, 0.15432359f, -0.15157498f, 
    0.06924137f, -0.02478938f, 0.01474160f, -0.03872328f, 0.06718546f, -0.15658066f, 0.09090142f, -0.01951984f, 
    0.48169148f, -0.44861287f, -0.28781512f, -0.39787552f, -0.05063384f, -0.01536439f, -0.21224076f, 0.18034771f, 
    0.14106239f, -0.01235847f, 0.08075165f, -0.00693982f, 0.00421662f, 0.00637767f, -0.02414096f, -0.02013984f, 
    -0.06759463f, -0.02811558f, -0.03946724f, -0.02625949f, -0.03729428f, 0.00731480f, 0.07253418f, 0.01550187f, 
    -0.11753943f, -0.03374298f, 0.04983983f, 0.01383625f, -0.00548000f, 0.02481746f, 0.02171414f, 0.08337773f, 
    -0.01207948f, -0.11999071f, -0.01300748f, -0.05173256f, 0.23540652f, -0.02741738f, -0.06602054f, -0.05934577f, 
    -0.05765017f, 0.08774962f, -0.04379446f, -0.02435283f, 0.10421422f, -0.01123792f, 0.03049858f, 0.08623732f, 
    0.34117299f, -0.11578753f, -0.30197755f, -0.30186972f, 0.04778067f, 0.08028070f, 0.04539995f, 0.02014264f, 
    0.01854375f, -0.03153045f, 0.07907571f, -0.12395803f, 0.10672772f, -0.01098108f, 0.09140438f, 0.15631728f, 
    -0.04289567f, -0.08154918f, 0.04021309f, -0.02453034f, 0.08567671f, 0.08213004f, 0.09704320f, 0.03433586f, 
    -0.07952324f, -0.31071016f, 0.22810532f, 0.29936180f, -0.03126158f, 0.01394251f, -0.11002181f, 0.11761398f, 
    0.03876905f, -0.11667827f, -0.01748028f, 0.00091657f, 0.05710217f, -0.18047991f, -0.00388206f, 0.00381548f, 
    0.05516456f, 0.09989581f, -0.02266901f, -0.17423311f, 0.03239265f, 0.03796231f, 0.02871940f, 0.01597653f, 
    -0.23686615f, 0.26405931f, 0.17349391f, 0.15784109f, 0.00379118f, -0.03022030f, 0.18201058f, -0.04475332f, 
    -0.01969619f, -0.15382144f, -0.03555350f, 0.04409061f, -0.01817366f, 0.05560504f, 0.00839553f, 0.08351074f, 
    0.01193623f, 0.00328936f, -0.02143775f, -0.02341649f, 0.13986155f, 0.00604409f, 0.02695070f, 0.06624955f, 
    -0.00519810f, 0.03225186f, -0.05034158f, 0.06096525f, -0.05323493f, -0.02455909f, -0.01977433f, -0.13666472f, 
    -0.09990296f, 0.13649441f, 0.03487447f, 0.06584926f, -0.23068549f, 0.13864464f, 0.02411157f, -0.08155060f, 
    0.05320863f, -0.01261183f, -0.03359123f, -0.03758533f, -0.10478991f, 0.05747979f, -0.14056100f, -0.08780996f, 
    -0.04968072f, 0.02955262f, -0.06420992f, 0.04047679f, 0.06286468f, -0.05677829f, -0.03257993f, -0.01089566f, 
    -0.00461466f, -0.04869431f, -0.11167932f, -0.12281079f, -0.00326399f, -0.16686741f, -0.14397436f, -0.16928908f, 
    -0.20918310f, -0.01138436f, 0.05041142f, 0.05567868f, -0.01404132f, 0.01104908f, 0.01734740f, -0.04943645f, 
    -0.36398649f, -0.04666051f, 0.10277183f, -0.04714415f, -0.08911999f, -0.07432657f, -0.11853633f, -0.12348206f, 
    -0.05313762f, -0.02854679f, 0.03422195f, 0.04218013f, -0.24319294f, 0.04471655f, -0.07761698f, 0.09410438f, 
    0.01394906f, -0.02582113f, -0.07638330f, -0.21410695f, 0.02710014f, 0.02826207f, -0.05858007f, -0.00437119f, 
    -0.09093154f, -0.04900730f, -0.17300355f, 0.04237169f, 0.00370587f, 0.12556911f, 0.00147043f, -0.09276240f, 
    0.02926996f, -0.20277506f, -0.02354238f, 0.06354645f, 0.17998639f, 0.00797404f, -0.01335006f, -0.29526824f, 
    0.15900180f, -0.12854739f, -0.08611063f, -0.08184609f, -0.01568457f, 0.06017622f, 0.19307566f, 0.11834738f, 
    -0.03848404f, -0.07478385f, -0.13466063f, -0.12729983f, -0.08798622f, 0.02289391f, -0.01703795f, 0.02167936f, 
    0.09293649f, 0.07124701f, 0.12137190f, 0.07314838f, 0.32438129f, 0.19306889f, 0.00426230f, -0.00223271f, 
    0.03761121f, -0.07843836f, -0.05989697f, -0.05652873f, 0.01283932f, 0.00328365f, 0.03206155f, 0.07036330f, 
    -0.02624574f, 0.14803860f, 0.09321208f, -0.12754311f, -0.02133891f, -0.08459402f, -0.00999166f, 0.05410941f, 
    -0.04864581f, -0.05801316f, -0.02233923f, -0.06600005f, 0.12248352f, -0.02139524f, -0.00317602f, -0.25295404f, 
    -0.12027149f, -0.10443119f, 0.02784463f, -0.06875090f, -0.13339721f, 0.02637084f, -0.05647305f, -0.09298949f, 
    0.27380490f, -0.12743294f, -0.06572089f, -0.02892266f, 0.01606615f, 0.00236115f, -0.00816374f, -0.06641844f, 
    0.10195461f, -0.12193398f, 0.14613169f, 0.19359027f, 0.13700637f, 0.09444057f, 0.07077909f, -0.22383678f, 
    -0.04434162f, -0.04727146f, -0.02047975f, -0.07018741f, 0.01049755f, -0.05939247f, -0.12511818f, -0.02522410f, 
    -0.02887131f, -0.07660352f, -0.14266352f, -0.12766756f, 0.09899997f, 0.05990093f, 0.04379124f, -0.02629526f, 
    -0.00098623f, 0.10877684f, -0.02510315f, -0.27201715f, 0.14951435f, 0.03165068f, -0.04589363f, 0.02276821f, 
    0.11094567f, -0.00884474f, 0.12313903f, 0.13511743f, -0.22619542f, -0.06597255f, -0.02859374f, -0.16713080f, 
    0.15100844f, -0.27925909f, 0.03022479f, -0.02804452f, 0.12289461f, 0.09544327f, 0.08145704f, 0.01969233f, 
    -0.08422179f, -0.06665642f, -0.03937714f, -0.39676332f, 0.30626765f, -0.28241360f, 0.05865592f, 0.03434934f, 
    0.31090125f, -0.02024015f, -0.08967019f, 0.01464626f, 0.09447592f, 0.03722299f, 0.11733190f, 0.10838220f, 
    -0.11945430f, -0.57474560f, -0.35826004f, 0.05423290f, -0.00184462f, 0.15117358f, 0.07988019f, -0.01699894f, 
    -0.08425976f, -0.09296545f, -0.04437012f, 0.01417027f, -0.57582551f, -0.08503333f, 0.18153542f, 0.21304828f, 
    -0.04368355f, 0.09442602f, 0.01338426f, -0.08422271f, 0.10934289f, 0.13910332f, -0.12237188f, 0.23003229f, 
    -0.20165449f, -0.12110714f, 0.02653269f, -0.04141301f, -0.06506874f, -0.00827426f, -0.04779707f, -0.06383580f, 
    -0.18990272f, -0.06744730f, -0.11927274f, -0.29442284f, -0.67438948f, -0.09418005f, 0.13128696f, 0.20893717f, 
    0.10235185f, 0.01094009f, -0.24327633f, -0.16162029f, -0.01496653f, -0.03529658f, 0.00991636f, 0.02140938f, 
    -0.11846468f, 0.03137707f, -0.07545193f, -0.01010702f, -0.00001977f, 0.13203968f, -0.04437578f, 0.10483679f, 
    -0.05157861f, -0.02524523f, -0.23814891f, -0.17216167f, -0.08670338f, -0.05995316f, -0.06282706f, -0.00871175f, 
    0.04365001f, 0.00230394f, 0.01437203f, 0.03385789f, -0.14980166f, -0.19403656f, -0.29678041f, -0.30421835f, 
    -0.25688440f, -0.34955505f, -0.20843248f, 0.01146784f, 0.02110154f, 0.18423082f, 0.11513048f, 0.09025792f, 
    0.05700516f, 0.14468166f, 0.03901123f, -0.06367885f, 0.14313677f, -0.07375383f, -0.31599915f, -0.39625528f, 
    -0.18734542f, -0.21944784f, 0.03723506f, -0.16231935f, 0.00286087f, -0.04715854f, -0.09280410f, -0.07284038f, 
    -0.34574118f, 0.33509386f, -0.04288294f, 0.14869012f, 0.04088128f, 0.00809491f, -0.15878163f, 0.03618111f, 
    0.02584575f, 0.04430702f, -0.06493672f, 0.10732270f, -0.14574555f, -0.33303040f, -0.45536590f, -0.18771474f, 
    0.16365133f, 0.16314138f, 0.18744063f, 0.09410348f, -0.10368112f, -0.11720707f, -0.05230993f, -0.03414898f, 
    0.23875730f, 0.08340884f, 0.07114030f, 0.13079630f, 0.03637506f, 0.00030226f, -0.06852460f, -0.02906005f, 
    0.08957110f, 0.04580406f, 0.11266299f, -0.05748579f, -0.05366027f, -0.09489146f, 0.01071331f, -0.15305410f, 
    -0.10462876f, -0.04382340f, -0.01755897f, -0.04080841f, -0.04610523f, 0.00889017f, -0.07495754f, -0.00662918f, 
    -0.20527233f, 0.03558197f, 0.01850164f, 0.07051642f, 0.08961215f, -0.16503054f, -0.04094693f, 0.11538266f, 
    -0.09378148f, -0.08969762f, 0.08580820f, -0.09748387f, -0.08147635f, -0.18333028f, -0.11170559f, -0.09968501f, 
    -0.01961249f, -0.09330501f, 0.05480132f, -0.03570819f, 0.07088146f, 0.09246015f, 0.09276038f, 0.12716468f, 
    -0.18847725f, -0.22822319f, -0.04520247f, 0.03835246f, 0.19723889f, 0.00389011f, 0.09799631f, 0.10933840f, 
    -0.08620541f, -0.06621400f, -0.01648039f, 0.06215233f, 0.27154055f, -0.07022642f, -0.19237064f, -0.46098486f, 
    0.11277161f, 0.23612030f, -0.11473040f, 0.00960241f, 0.21887611f, 0.00441913f, 0.01547961f, 0.08431527f, 
    0.34342879f, 0.00242492f, -0.02026641f, -0.05509359f, 0.20935507f, -0.09219547f, 0.07526160f, 0.06188388f, 
    0.02432074f, 0.02786158f, 0.06600500f, 0.07472160f, -0.20370533f, -0.52316689f, -0.20563683f, 0.07426932f, 
    0.07520304f, 0.14365859f, 0.13741423f, -0.01203561f, -0.03949289f, -0.00455548f, 0.06838782f, 0.01726312f, 
    0.02456634f, 0.00323714f, 0.03574032f, -0.06542901f, -0.02644644f, -0.03007362f, -0.07723234f, 0.00054112f, 
    0.02411446f, -0.00017590f, 0.11093417f, -0.28425848f, -0.18314725f, -0.26660299f, -0.22828731f, -0.03505085f, 
    0.07140078f, 0.12481152f, 0.00030155f, -0.00212088f, 0.00752464f, 0.09144199f, -0.00758222f, 0.12686113f, 
    0.00333039f, -0.19769597f, -0.50622869f, -0.01655570f, 0.00790699f, 0.18320358f, 0.14192149f, 0.10414456f, 
    -0.05952433f, -0.01362970f, -0.16297734f, -0.05129978f, -0.31907395f, 0.08639167f, 0.06015947f, 0.10496102f, 
    0.11860899f, -0.10346813f, -0.06717826f, -0.02090021f, -0.02216288f, -0.10964128f, 0.06694201f, -0.10281036f, 
    -0.25941232f, 0.00070995f, 0.01656532f, 0.23412231f, 0.04506118f, -0.05375628f, 0.01132316f, 0.04557904f, 
    0.04731212f, -0.00082702f, 0.11028308f, -0.15513790f, 0.11640800f, -0.07245945f, -0.07691581f, -0.04889363f, 
    -0.23981507f, 0.00291943f, 0.22100914f, 0.05924213f, 0.00815359f, -0.07945298f, 0.14317183f, 0.07410863f, 
    0.23944804f, 0.00881337f, -0.14691202f, -0.16991937f, 0.25496459f, 0.05118144f, 0.01797787f, -0.02003430f, 
    0.00482535f, 0.12135354f, 0.10971764f, 0.17991887f, 0.14469828f, -0.12851802f, -0.20375738f, -0.19369236f, 
    0.02892382f, 0.00508830f, -0.01918040f, -0.03095773f, -0.06576634f, -0.10104298f, -0.01369141f, -0.06505721f, 
    -0.78003049f, -0.13376494f, 0.18119775f, 0.31632635f, -0.13694678f, 0.04244200f, -0.09615117f, -0.02259956f, 
    0.05392446f, -0.04855336f, 0.10984642f, 0.10990834f, -0.12887293f, -0.16931055f, 0.04999861f, -0.06106443f, 
    -0.12545824f, -0.00240014f, 0.01315767f, 0.05291105f, 0.01176833f, -0.05907068f, 0.08878281f, -0.04055391f, 
    0.11002669f, -0.46560502f, -0.35915059f, 0.03547001f, 0.03617788f, -0.14903793f, 0.07084236f, -0.09019137f, 
    0.01689125f, 0.00343135f, 0.05302437f, 0.08353877f, -0.22095449f, -0.57559478f, -0.39438993f, -0.32043460f, 
    -0.07626633f, -0.04591778f, -0.01365574f, -0.01280614f, 0.03169490f, 0.06753369f, 0.08303109f, 0.07337898f, 
    -0.33112422f, 0.06436498f, 0.06384058f, 0.11416717f, 0.18132152f, 0.06345755f, 0.05558518f, 0.01987615f, 
    -0.07259616f, 0.01921402f, 0.07485064f, 0.15212724f, -0.08043167f, -0.36181164f, -0.22963752f, -0.25900158f, 
    -0.04030367f, 0.00840067f, 0.00801818f, -0.13140440f, -0.01210759f, -0.07330669f, 0.00625212f, 0.02479966f, 
    0.32642809f, 0.03162432f, -0.26715267f, -0.09173597f, 0.17706566f, -0.04262094f, -0.03971162f, -0.12162689f, 
    0.12959290f, -0.01513455f, 0.12045024f, 0.15735753f, 0.04776277f, 0.19014280f, -0.06803767f, -0.16203827f, 
    0.00444738f, -0.10063662f, -0.00519923f, -0.01655824f, -0.03244050f, 0.09312712f, -0.03699866f, 0.03683627f, 
    0.20037809f, -0.10950831f, -0.21139240f, -0.12818822f, 0.03012532f, -0.02372332f, 0.01729507f, 0.02825994f, 
    0.01928390f, -0.06560922f, 0.01021261f, 0.02425843f, -0.00259245f, 0.11455098f, 0.15020312f, -0.01151378f, 
    0.01581882f, -0.05346258f, 0.01388740f, -0.14979942f, 0.00969746f, 0.04233740f, -0.12723404f, 0.06430740f, 
    -0.13824691f, 0.04696410f, -0.18378559f, 0.20769976f, 0.06275068f, 0.08842962f, 0.07314104f, 0.16045915f, 
    -0.03332829f, -0.12459135f, -0.18635044f, -0.03522825f, -0.10254525f, -0.03679069f, -0.05879520f, -0.04854914f, 
    0.01880605f, -0.00342329f, 0.00006279f, -0.02582334f, 0.06064245f, 0.04143043f, 0.04664257f, 0.05034035f, 
    0.36249760f, 0.21487924f, -0.17437564f, 0.01460325f, -0.03314747f, -0.12385223f, 0.02412251f, -0.00161646f, 
    0.04550912f, 0.06483667f, 0.02489068f, 0.07207805f, -0.39118791f, -0.29071876f, -0.05693677f, 0.05539514f, 
    -0.08436864f, 0.04717823f, -0.01482018f, 0.10020912f, 0.03910510f, 0.14470053f, -0.06361068f, -0.06952870f, 
    -0.19299394f, -0.08597932f, -0.10991070f, 0.15998560f, -0.01940919f, 0.00945359f, 0.02698351f, 0.01821419f, 
    0.10069135f, 0.15414107f, 0.17587592f, 0.14173487f, -0.04283330f, 0.13602570f, 0.08960384f, 0.07369169f, 
    0.05155141f, 0.01748637f, -0.02962797f, -0.03066416f, -0.00827284f, -0.13409269f, -0.17054150f, -0.30349189f, 
    0.12728465f, 0.04580852f, -0.22662981f, -0.25070187f, -0.04463698f, -0.08943093f, -0.12922221f, -0.14096710f, 
    0.03141396f, 0.03558500f, -0.02522320f, 0.01818484f, 0.07353808f, -0.06419072f, -0.02257194f, -0.11891966f, 
    -0.00900635f, 0.13390857f, 0.04482830f, 0.02963343f, -0.05114008f, -0.02716947f, 0.02376095f, -0.01902316f, 
    -0.36276612f, -0.11936083f, 0.05967027f, 0.21521729f, -0.11082420f, 0.02648260f, 0.14202717f, 0.03942382f, 
    -0.00627067f, 0.12719777f, 0.02545681f, 0.14155713f, -0.34021795f, -0.04855004f, 0.02628423f, -0.01907998f, 
    -0.01403183f, -0.09661506f, -0.15628293f, -0.00931112f, -0.11234704f, -0.10437639f, -0.22869775f, -0.33913487f, 
    -0.15992025f, 0.05620547f, 0.08965362f, 0.01737938f, -0.04715975f, 0.01759836f, 0.01039045f, 0.05981462f, 
    -0.03710422f, 0.01790659f, 0.00466985f, 0.07074088f, 0.09636695f, -0.02844674f, 0.28191793f, 0.09069111f, 
    -0.04110356f, 0.20988610f, 0.08665408f, 0.20727709f, 0.16306259f, 0.05046152f, 0.15591839f, 0.05834255f, 
    -0.11065674f, 0.00698043f, -0.17394370f, -0.12472449f, 0.03495825f, 0.02974807f, 0.06874470f, -0.02797398f, 
    0.07756633f, 0.08059258f, 0.11875018f, 0.12773074f, -0.02425366f, -0.20702003f, -0.06907357f, 0.06780490f, 
    0.04457666f, 0.03985371f, 0.14805841f, 0.06583580f, 0.18053161f, -0.09944383f, 0.01370017f, 0.04302611f, 
    0.07040249f, -0.08697225f, -0.12424839f, -0.12071303f, -0.01185890f, 0.15026022f, 0.05383343f, 0.04091890f, 
    0.12078247f, -0.06210157f, 0.04258866f, 0.07884967f, 0.13748418f, -0.07406315f, -0.39742863f, 0.06984106f, 
    -0.12117863f, 0.12551373f, 0.06617343f, 0.13830976f, 0.02855618f, -0.04700717f, -0.28070101f, 0.01392591f, 
    0.09530489f, -0.36966377f, 0.06486008f, -0.29936919f, -0.06813288f, -0.00665205f, -0.04911933f, 0.23453273f, 
    0.08719990f, 0.05647538f, -0.00177882f, 0.03499966f, -0.06979492f, -0.42600891f, 0.03422611f, 0.04889278f, 
    0.03799593f, 0.00153666f, -0.05737724f, -0.16889867f, -0.02665749f, -0.05240371f, -0.06924814f, -0.03698004f, 
    -0.09885808f, 0.05943854f, 0.08252940f, 0.28068504f, -0.02649449f, 0.08805216f, -0.15064900f, -0.03142961f, 
    -0.07001064f, 0.01765662f, -0.01481570f, -0.09038305f, -0.02438685f, -0.46684745f, -0.08560149f, -0.18577009f, 
    0.10963238f, 0.05405254f, 0.10412591f, -0.04577439f, -0.00212354f, -0.11603774f, 0.04717175f, -0.06839956f, 
    -0.14210744f, -0.04742904f, -0.36639348f, 0.10883866f, 0.02066473f, -0.00985374f, 0.05645421f, -0.04967982f, 
    -0.00813127f, -0.02257198f, -0.01570534f, 0.06497867f, -0.02929843f, -0.00530107f, 0.28523961f, 0.31383118f, 
    0.02200012f, 0.04656554f, -0.05020608f, -0.01671159f, -0.02039700f, 0.10339567f, 0.16502544f, 0.06153196f, 
    0.19118838f, -0.12734434f, 0.16354315f, 0.08144888f, -0.05874786f, -0.05028913f, -0.12031915f, -0.04842053f, 
    -0.11885419f, -0.05550932f, 0.10596683f, 0.01345338f, 0.15840350f, -0.18164055f, -0.12561287f, -0.16298327f, 
    0.03709032f, 0.06911017f, -0.00210473f, 0.09659580f, 0.00062381f, -0.15635708f, -0.02084443f, 0.00976078f, 
    -0.26695558f, 0.05907395f, 0.00141255f, -0.09657945f, 0.04458810f, -0.05500680f, 0.08085924f, -0.14528656f, 
    0.07345081f, 0.11468941f, -0.05058862f, 0.09387676f, -0.01767460f, 0.30448094f, 0.06956302f, -0.12561573f, 
    -0.13330291f, -0.00823474f, 0.05843860f, -0.07568854f, 0.00488156f, 0.06812126f, 0.03977925f, 0.10192429f, 
    0.15093540f, -0.07703022f, 0.36194530f, 0.13882312f, -0.02542549f, -0.11164310f, -0.02985661f, -0.20166974f, 
    -0.01839214f, -0.00556322f, 0.08543409f, 0.12456150f, -0.52284247f, 0.17803304f, -0.33630994f, -0.00997030f, 
    -0.07805465f, -0.11258782f, 0.01342168f, -0.01886062f, 0.08546367f, 0.03049330f, 0.07400682f, 0.03344402f, 
    -0.07614201f, -0.06443199f, -0.28580907f, -0.14573854f, -0.11560099f, 0.00788607f, 0.04887015f, -0.00574905f, 
    0.04824934f, 0.00179925f, 0.08640080f, 0.07545094f, 0.00621486f, 0.00030315f, 0.36133757f, -0.57315785f, 
    0.11012773f, 0.06321909f, 0.01649736f, -0.00280466f, 0.01658372f, 0.07233690f, -0.02552427f, 0.01082273f, 
    0.04823053f, -0.24438405f, -0.10734878f, -0.17085512f, -0.03264014f, 0.10914277f, 0.09404960f, 0.00606046f, 
    0.05330447f, 0.08158544f, 0.06800582f, 0.05090811f, 0.20446914f, -0.09533159f, -0.35080430f, -0.11229882f, 
    -0.01555582f, 0.01570885f, 0.08874526f, 0.27368429f, -0.09254070f, -0.02940939f, -0.10128416f, -0.02689263f, 
    -0.40192404f, 0.12604049f, 0.14684218f, -0.04915260f, -0.04531353f, 0.02489692f, -0.09242052f, -0.21692514f, 
    0.08319274f, -0.07567152f, -0.03538977f, 0.13235466f, 0.11607468f, -0.17282198f, 0.12554550f, -0.11581527f, 
    -0.13314703f, 0.14456730f, -0.09310327f, 0.00749341f, 0.03093768f, 0.02968526f, 0.10858992f, 0.04145915f, 
    0.10046138f, 0.17739426f, -0.02044505f, -0.35811737f, -0.10511362f, -0.09392706f, -0.08772442f, -0.05015597f, 
    0.11539897f, -0.06625811f, 0.03455744f, 0.08787742f, -0.17923982f, -0.02566865f, 0.01542677f, 0.11046914f, 
    -0.09237424f, 0.09069977f, 0.04067723f, 0.14099634f, 0.07602616f, 0.06470883f, 0.08456203f, 0.02454797f, 
    -0.37669972f, 0.20770729f, -0.35024804f, 0.19473250f, 0.12157153f, -0.13506769f, 0.04086426f, 0.02575131f, 
    0.13575275f, 0.11546136f, 0.11939798f, -0.01488193f, -0.13048783f, -0.05555975f, 0.03832018f, -0.02277653f, 
    -0.16650389f, -0.04940453f, 0.07541157f, -0.00841491f, 0.16109282f, -0.02007678f, 0.04851353f, 0.08576852f, 
    -0.06903253f, 0.17251466f, -0.18149304f, 0.04072275f, 0.12189373f, -0.19857682f, 0.12810947f, -0.18660684f, 
    0.05334706f, 0.05882831f, -0.18334003f, -0.08343665f, 0.14699382f, 0.25798893f, 0.13573423f, -0.30315852f, 
    -0.06134666f, 0.11512176f, -0.03730221f, 0.00727417f, 0.13896063f, 0.04777117f, -0.06953818f, -0.03076513f, 
    -0.16801006f, 0.52944189f, -0.70158690f, 0.05605616f, -0.03480715f, -0.05187927f, 0.20165439f, -0.12587348f, 
    0.05518277f, -0.02925560f, -0.03720306f, 0.13655700f, 0.23537855f, -0.03695143f, 0.26944333f, -0.01160757f, 
    0.17491379f, -0.21262957f, 0.06063703f, 0.00722181f, -0.03626772f, 0.02514248f, -0.17275470f, 0.00412838f, 
    -0.18978719f, 0.22252132f, 0.41896728f, -0.38422662f, -0.02967481f, -0.19003887f, 0.02179897f, -0.10899348f, 
    -0.14821897f, -0.03659604f, 0.04235363f, -0.05389154f, -0.09283456f, 0.09319227f, -0.03661148f, 0.08535318f, 
    0.17886952f, -0.25372076f, -0.05417935f, -0.16887639f, -0.11660744f, -0.06333513f, -0.03186734f, -0.06300070f, 
    -0.64300615f, -0.03564877f, -0.41140896f, 0.16742299f, -0.06570825f, -0.01236267f, 0.05456411f, -0.18473947f, 
    0.00182970f, -0.10447339f, -0.14396676f, -0.11685345f, 0.17962119f, -0.03512738f, 0.18763150f, -0.20637950f, 
    -0.12294611f, -0.05931815f, 0.07574538f, 0.04368166f, -0.01494880f, 0.03321167f, 0.07089135f, 0.00164979f, 
    -0.15786156f, -0.15743093f, 0.04584818f, 0.17468746f, -0.01047292f, 0.08956967f, 0.06587443f, 0.04125059f, 
    0.05834259f, 0.05262337f, 0.03816371f, 0.26887640f, 0.08481311f, 0.01776197f, 0.20657408f, 0.06157400f, 
    0.18219894f, -0.22517456f, -0.20979874f, -0.00241728f, 0.01791692f, 0.06895365f, -0.02807705f, -0.13152651f, 
    -0.09766063f, -0.09729437f, 0.31343809f, 0.07489335f, 0.04347219f, -0.13016765f, -0.09355288f, -0.13178012f, 
    -0.06337190f, 0.13831842f, -0.02582475f, 0.03387104f, -0.25355288f, -0.17249599f, -0.54432201f, 0.07986142f, 
    0.00301643f, 0.06520379f, 0.11667347f, -0.04628262f, -0.11513445f, -0.05483807f, 0.04820406f, 0.00857389f, 
    0.04394099f, -0.07344939f, -0.03941647f, -0.03499482f, -0.08981091f, 0.03838119f, 0.07459310f, -0.11039998f, 
    -0.00975967f, 0.01644351f, -0.01422262f, 0.06542391f, -0.24301654f, 0.10730280f, 0.14631280f, -0.13175946f, 
    0.01775642f, 0.16629928f, -0.40564778f, 0.01252619f, 0.05369247f, -0.04843419f, -0.03001559f, 0.08605656f, 
    0.31622940f, -0.22741850f, 0.11934808f, 0.12195689f, 0.08471691f, -0.02355815f, 0.03422555f, -0.07572357f, 
    0.21067466f, 0.01563712f, 0.06385958f, -0.02882476f, 0.01247229f, -0.03514680f, 0.37160215f, 0.34498364f, 
    0.09846345f, -0.15415868f, -0.09497056f, -0.04387501f, 0.13610291f, 0.03915119f, 0.03902393f, 0.01749087f, 
    -0.04047444f, -0.16295286f, 0.00963865f, -0.14776364f, 0.11268837f, -0.05164098f, 0.07726824f, 0.05723403f, 
    -0.03084554f, -0.06729269f, -0.06947450f, -0.11514600f, 0.13514721f, 0.24560477f, -0.15362711f, 0.25456980f, 
    -0.25031042f, 0.05389999f, -0.12001503f, -0.01928634f, -0.01303948f, -0.00695563f, 0.06404451f, -0.04895115f, 
    -0.27104223f, -0.23466872f, -0.11266177f, -0.33503672f, -0.39336535f, 0.10343646f, -0.15016128f, 0.19891429f, 
    0.11171548f, -0.01673662f, -0.01390446f, 0.00121752f, -0.25248554f, -0.00437378f, 0.04005658f, -0.19230987f, 
    -0.22424535f, -0.13606346f, 0.04614985f, 0.11334115f, 0.03901714f, 0.11086126f, 0.09201825f, -0.01858120f, 
    -0.00160100f, 0.10816016f, 0.21516596f, -0.70271111f, 0.00247440f, -0.10122012f, 0.07948288f, -0.18941762f, 
    -0.08837393f, 0.00432104f, -0.06015688f, 0.01430329f, -0.02654827f, 0.20632181f, 0.03748919f, -0.07365589f, 
    -0.02570780f, -0.07309923f, 0.08067486f, 0.25635189f, -0.01493184f, 0.10159968f, 0.02241896f, -0.02328454f, 
    -0.48815119f, -0.05301510f, -0.11107985f, 0.35178241f, 0.04449470f, 0.08020108f, -0.08854834f, -0.06786890f, 
    0.14800033f, -0.09098846f, -0.13909554f, -0.07438864f, -0.19712283f, -0.13016406f, -0.18397009f, 0.22055079f, 
    -0.04634630f, 0.15506935f, 0.00446051f, -0.02091134f, 0.05795960f, 0.03870692f, -0.03934118f, -0.14176349f, 
    0.28349802f, 0.11522669f, 0.14985231f, 0.08744290f, -0.11302463f, -0.15601851f, -0.10150181f, -0.03041958f, 
    0.00607192f, 0.00164523f, -0.05663231f, 0.05252634f, 0.11647549f, -0.32112017f, 0.05199379f, -0.19275461f, 
    -0.00816923f, 0.01157705f, -0.03319069f, 0.01869567f, 0.05420394f, -0.00831996f, 0.10495008f, -0.01417830f, 
    -0.11455423f, -0.01852054f, -0.13683981f, -0.02821882f, -0.06392051f, -0.00409182f, -0.32472673f, 0.04917809f, 
    0.11715031f, -0.12941565f, 0.02838011f, 0.11248215f, 0.04508536f, 0.04184084f, 0.05386038f, -0.03452703f, 
    0.07590022f, 0.09947798f, 0.07189225f, -0.03657724f, 0.06371666f, 0.04708511f, 0.00342105f, 0.07836898f, 
    -0.15568756f, -0.42181605f, -0.18251732f, -0.09772915f, -0.09544309f, -0.02535676f, -0.07439192f, 0.26499683f, 
    0.07463470f, 0.00706692f, -0.01644352f, -0.09726521f, -0.04128201f, 0.25761718f, -0.15522417f, 0.07166307f, 
    -0.14546295f, 0.00009047f, -0.16056064f, -0.04802957f, -0.00817998f, 0.02149175f, -0.04515764f, 0.04984400f, 
    0.24237600f, 0.16828525f, 0.23689239f, 0.14840393f, 0.05623952f, -0.17232482f, -0.04924011f, -0.09753509f, 
    -0.11877481f, -0.09779041f, -0.09682216f, -0.14592494f, 0.00639013f, -0.00275612f, 0.05299618f, -0.10464142f, 
    0.03893301f, 0.03636206f, -0.00895226f, -0.05423286f, 0.08045979f, 0.08216501f, 0.17972223f, 0.12136291f, 
    -0.38055247f, -0.13355775f, 0.10536235f, 0.10562863f, -0.10624172f, -0.05530202f, 0.01987626f, 0.04370001f, 
    0.05368383f, 0.03447660f, 0.08212755f, 0.00307885f, 0.31201068f, -0.17550997f, 0.09484210f, 0.07873334f, 
    0.08060732f, 0.04863551f, -0.05038141f, 0.05228060f, 0.02593740f, -0.01663760f, -0.06005406f, -0.07543737f, 
    -0.05088205f, 0.02440342f, 0.05999558f, -0.47879416f, 0.05463858f, -0.19003768f, -0.01088526f, 0.04390732f, 
    0.00528766f, 0.01919942f, 0.02973042f, -0.02078643f, 0.05720311f, 0.03495991f, -0.07987348f, -0.11131740f, 
    -0.01362797f, -0.01617554f, 0.14240354f, -0.03484548f, 0.08299481f, 0.12721078f, 0.18336755f, 0.25716001f, 
    -0.10103054f, 0.08136580f, 0.05616672f, -0.06609938f, -0.04755377f, 0.11269245f, 0.23236063f, -0.06003983f, 
    0.00199374f, 0.11547251f, -0.10271907f, -0.16132168f, -0.48104790f, -0.16038239f, -0.19473878f, 0.03672061f, 
    0.02147546f, 0.08759328f, -0.03951186f, 0.03071387f, -0.00100577f, -0.11790159f, -0.09567214f, -0.17970693f, 
    -0.04907803f, 0.03124218f, 0.07660900f, 0.04000029f, 0.19878386f, -0.17908828f, 0.04047631f, -0.15298203f, 
    -0.01526974f, -0.12700677f, -0.13461347f, -0.09202640f, 0.23718366f, -0.01807804f, 0.26762855f, -0.17472199f, 
    0.03157969f, -0.12013181f, -0.27817315f, -0.03094893f, -0.12973318f, -0.02795957f, 0.00378061f, 0.10475274f, 
    -0.11630493f, -0.33553648f, -0.11256553f, -0.02309878f, -0.06188682f, 0.08858179f, -0.06521097f, -0.09805740f, 
    -0.14272466f, -0.05141360f, 0.12482619f, -0.00312555f, -0.11166462f, 0.00817640f, 0.08838770f, 0.08319347f, 
    0.15128092f, -0.08235066f, -0.08953522f, 0.15026240f, -0.12169455f, -0.26383752f, -0.07597313f, 0.06438708f, 
    -0.12024508f, 0.08265959f, 0.10170572f, 0.03792170f, 0.11975718f, 0.09686156f, -0.24646866f, -0.12798190f, 
    -0.13867012f, -0.15328805f, 0.03222531f, -0.09784979f, -0.04884852f, -0.10667691f, 0.02986435f, -0.05687714f, 
    -0.18973647f, 0.07048880f, 0.20040026f, 0.03296036f, 0.03154246f, 0.15205522f, 0.05010999f, 0.07437602f, 
    0.00826306f, -0.15422326f, 0.08408932f, -0.18492487f, 0.08508633f, -0.06864285f, 0.00761073f, -0.11629613f, 
    0.04657921f, -0.09063879f, 0.06976256f, 0.03157286f, -0.38602775f, 0.30985752f, -0.15196104f, -0.02155886f, 
    -0.04599453f, -0.06638452f, -0.05304629f, 0.17837210f, -0.03460062f, 0.01567178f, 0.14630437f, -0.00764678f, 
    0.08861474f, -0.02084004f, -0.22897515f, 0.04184617f, -0.17950210f, -0.00440706f, 0.01088461f, -0.13744646f, 
    -0.05512867f, -0.03585770f, -0.00065035f, -0.06781299f, -0.02258264f, 0.00726290f, -0.04229052f, -0.20879589f, 
    -0.04226919f, 0.02845661f, -0.04707845f, -0.01398592f, 0.01940967f, -0.03085383f, -0.21719977f, -0.20069017f, 
    -0.33587196f, 0.48184940f, -0.02816983f, 0.02372070f, 0.06149390f, 0.02840242f, -0.08701739f, 0.11804406f, 
    -0.11959217f, -0.06147462f, 0.14744174f, -0.08656837f, 0.03793888f, 0.13889542f, 0.15601848f, -0.01347153f, 
    -0.12493796f, 0.32799637f, -0.07517340f, -0.05506499f, 0.02332181f, 0.05701418f, 0.05656329f, -0.06075278f, 
    0.18600740f, -0.27226186f, 0.25288600f, -0.05744021f, 0.00137682f, 0.15903601f, 0.09248054f, 0.07999851f, 
    -0.03688483f, -0.06760990f, -0.06862555f, -0.22331914f, -0.07024980f, 0.11871036f, -0.18121295f, -0.05675947f, 
    -0.01385590f, -0.08087910f, 0.10978599f, -0.08023913f, -0.10019355f, -0.03656854f, -0.09641479f, 0.00226218f, 
    -0.26804590f, 0.29553390f, -0.36827940f, -0.09582476f, -0.02988653f, 0.03051412f, 0.02849142f, 0.07468919f, 
    -0.10594625f, -0.20380442f, -0.31910378f, -0.52724773f, 0.20226976f, -0.07950802f, 0.11401379f, -0.11682463f, 
    -0.09914456f, -0.00048801f, 0.08026221f, 0.17548850f, -0.01318082f, 0.02797564f, -0.10537399f, 0.00874237f, 
    -0.05228925f, -0.06556547f, 0.05851764f, -0.05000401f, -0.05676033f, -0.00524129f, -0.18894677f, -0.02825957f, 
    0.01717106f, 0.15982704f, -0.18472120f, -0.31344026f, -0.13842061f, -0.02299259f, 0.15752149f, 0.14490379f, 
    0.01575884f, 0.05403158f, -0.09412919f, 0.07919348f, 0.00417649f, 0.04290316f, -0.05294240f, -0.05863126f, 
    0.00438071f, 0.17684279f, 0.11547405f, 0.28732839f, -0.07886263f, 0.00345175f, -0.01061432f, -0.11410881f, 
    -0.11041696f, -0.12123349f, -0.17710613f, -0.05588467f, -0.08686579f, -0.18002255f, 0.01790969f, -0.03073127f, 
    0.07064498f, -0.03752773f, -0.12565561f, -0.06588604f, 0.02059074f, 0.03573126f, -0.06990103f, -0.08387034f, 
    0.15587413f, -0.02480522f, 0.23384176f, -0.27678308f, -0.08316098f, -0.09214493f, 0.07408475f, -0.03644808f, 
    -0.17444518f, 0.04380716f, -0.20061646f, -0.33822024f, -0.12208334f, 0.16774465f, 0.01725521f, 0.03082641f, 
    0.03604537f, 0.08837546f, 0.00716905f, 0.09715050f, -0.19094236f, -0.09270647f, -0.09698287f, -0.06558999f, 
    0.02171001f, 0.26164028f, 0.30728108f, -0.20511767f, 0.00170630f, 0.13137574f, 0.15370639f, 0.07248271f, 
    0.06754117f, 0.08108699f, 0.15986975f, -0.12915125f, -0.10690996f, -0.00899468f, -0.39376095f, -0.06240869f, 
    -0.07558973f, 0.04849742f, -0.21534397f, -0.03340738f, -0.01662041f, 0.06076159f, -0.03911897f, -0.09220798f, 
    -0.10193892f, -0.10227458f, 0.04007300f, -0.15106349f, -0.01347967f, -0.02526992f, 0.09685727f, 0.01029638f, 
    -0.24915023f, -0.16659448f, -0.22936605f, -0.03795944f, -0.00184861f, -0.07173796f, -0.15466759f, -0.19357692f, 
    -0.03246520f, -0.07906219f, 0.00927709f, 0.00731921f, -0.03004121f, 0.17368223f, 0.00610786f, -0.22490448f, 
    0.23295137f, -0.15196036f, 0.10759502f, -0.13262266f, -0.15271625f, 0.13919707f, 0.08352350f, 0.09668011f, 
    0.05852411f, -0.10294694f, 0.07581419f, 0.01045063f, 0.04100017f, -0.06109102f, 0.16966558f, 0.12941986f, 
    -0.01915674f, 0.06895530f, -0.02159308f, -0.09361743f, -0.08829197f, -0.08545930f, 0.07518684f, -0.01905028f, 
    0.04381358f, -0.21934374f, -0.08174106f, -0.01242378f, -0.26444337f, -0.02435776f, 0.11139728f, -0.11248104f, 
    -0.07752140f, 0.12052754f, -0.09420381f, 0.06425156f, -0.19041523f, 0.13736092f, -0.09325790f, 0.07562585f, 
    -0.21336725f, -0.06162303f, 0.02873097f, 0.00363073f, 0.00200079f, 0.08565384f, 0.01455801f, -0.05419961f, 
    -0.18462247f, 0.16451527f, 0.04349158f, 0.22894755f, -0.03448793f, -0.01806331f, -0.07060740f, 0.08470026f, 
    0.07249735f, -0.05229758f, 0.01440378f, 0.00502043f, -0.43784291f, 0.33794287f, -0.00100844f, 0.18989499f, 
    -0.02748047f, 0.00454623f, -0.05048660f, 0.09521583f, 0.10433462f, 0.06715254f, 0.14979956f, 0.01047240f, 
    0.20652893f, 0.17314714f, 0.08424313f, -0.14751370f, -0.20609359f, -0.01244968f, 0.14282563f, -0.08643302f, 
    0.08972466f, 0.09804228f, 0.16416413f, 0.11292528f, -0.05390219f, -0.22636949f, -0.29480204f, 0.08436088f, 
    -0.04567728f, -0.15654810f, 0.02267633f, 0.07478973f, 0.06166485f, -0.01318069f, -0.19753453f, -0.04478149f, 
    0.03523220f, 0.00670924f, 0.01834811f, -0.19260409f, -0.01933668f, -0.00948936f, 0.00434435f, 0.02425934f, 
    0.04536875f, -0.10412873f, -0.23644213f, -0.50183040f, -0.28392091f, 0.34784263f, -0.02339676f, 0.11826678f, 
    -0.12122075f, -0.00141242f, 0.01639342f, 0.08113100f, -0.02957021f, -0.08483921f, 0.09782077f, 0.09012874f, 
    0.00300260f, -0.21317770f, 0.03745024f, 0.28147817f, -0.01001043f, 0.02470009f, -0.07399781f, 0.00284713f, 
    0.08346914f, -0.09056515f, -0.12756941f, 0.00201605f, -0.00707835f, 0.10065508f, -0.39130315f, 0.04002767f, 
    -0.08642983f, 0.00426868f, -0.08177563f, -0.16219297f, 0.02646567f, 0.00352829f, 0.01973977f, 0.06122107f, 
    0.18655649f, 0.16808057f, 0.00496427f, 0.20522831f, 0.12197156f, -0.09354214f, 0.09168269f, 0.03295146f, 
    -0.20239942f, -0.18087301f, -0.17132589f, -0.21378724f, 0.29035348f, -0.27626470f, 0.23717803f, 0.09139733f, 
    0.09561639f, 0.00132936f, -0.16405436f, 0.20553260f, -0.04192556f, -0.10953441f, -0.03199273f, -0.00826230f, 
    -0.39892241f, 0.15873247f, 0.07876639f, -0.01078824f, 0.02410726f, 0.08954207f, -0.05986771f, -0.18440183f, 
    -0.02331936f, -0.03950521f, 0.08426891f, 0.03599239f, -0.58127278f, 0.22177498f, -0.21328162f, 0.03834275f, 
    0.04397618f, 0.16167364f, 0.00433380f, 0.05273937f, -0.10271847f, -0.06122814f, -0.23395370f, 0.08430067f, 
    0.15514095f, -0.26696751f, 0.33369777f, 0.32720733f, 0.03828513f, 0.13030584f, 0.07834762f, 0.14731923f, 
    0.10743726f, 0.02710399f, 0.05718981f, 0.08918258f, -0.02830344f, 0.22045788f, 0.01091655f, -0.03510138f, 
    0.08636557f, 0.09135393f, 0.00583365f, 0.03081456f, -0.06366323f, 0.15751261f, 0.06801880f, -0.04765499f, 
    -0.12336568f, -0.05989763f, -0.18200405f, 0.22686604f, 0.00352987f, 0.04333091f, 0.12951310f, 0.04978219f, 
    -0.04326024f, 0.08487377f, -0.00215520f, 0.02796897f, -0.10996968f, -0.25970280f, 0.07173859f, -0.16313644f, 
    -0.13663983f, 0.00607294f, 0.01708165f, 0.00742286f, 0.04660029f, 0.06552047f, 0.11954379f, 0.10600500f, 
    -0.01320580f, 0.10871284f, -0.07007165f, 0.07306224f, -0.04119197f, -0.13025315f, 0.21525003f, -0.04550817f, 
    0.04858875f, 0.02500998f, 0.01916951f, 0.06781216f, -0.35757816f, -0.02586384f, 0.01867269f, 0.00898313f, 
    0.01436719f, -0.00307826f, -0.13836008f, 0.01554606f, 0.02794835f, 0.13927278f, 0.05773123f, -0.14363760f, 
    -0.10129373f, -0.05156029f, 0.33816889f, -0.18620282f, -0.17944761f, 0.01156882f, -0.07393763f, 0.04976972f, 
    -0.07178725f, -0.09345768f, 0.07312282f, 0.04449641f, -0.16853748f, 0.11497302f, -0.04271960f, -0.18399005f, 
    -0.13068660f, -0.03783309f, -0.07656997f, -0.10518280f, -0.02021212f, 0.00956184f, -0.08258516f, 0.16131139f, 
    -0.35641769f, 0.08713590f, 0.10423955f, -0.16159679f, -0.03950814f, 0.24424787f, -0.04060018f, 0.01801243f, 
    -0.03250473f, 0.10430878f, 0.03436748f, 0.02251405f, -0.38645688f, 0.15739587f, -0.23233068f, 0.30860177f, 
    -0.01023407f, -0.04087526f, -0.08980707f, 0.05862948f, -0.24356198f, -0.07567178f, 0.00643707f, 0.05075897f, 
    -0.06002371f, 0.11715940f, -0.06993108f, 0.03412495f, 0.15463032f, -0.04535780f, 0.02382276f, 0.07794991f, 
    -0.16776925f, 0.15972106f, -0.19982846f, -0.18942103f, -0.19124354f, -0.13908760f, -0.18707471f, -0.16758537f, 
    0.00678630f, -0.05502930f, 0.10737699f, -0.03481083f, 0.07091220f, 0.11618558f, 0.11209997f, 0.14931361f, 
    -0.01747389f, -0.22653694f, 0.13850407f, 0.18500108f, -0.04400235f, 0.14541267f, -0.03469726f, 0.00185021f, 
    -0.02145478f, -0.08097438f, -0.03442005f, 0.02163344f, 0.52433878f, 0.11593411f, 0.12253171f, -0.13260901f, 
    0.15033223f, -0.16684271f, 0.04706010f, 0.00895547f, -0.16901332f, 0.09247899f, -0.09114320f, -0.16924970f, 
    0.15229148f, 0.15587375f, 0.08447602f, -0.20045179f, -0.09583621f, -0.02649406f, 0.01144939f, -0.07824120f, 
    0.07485277f, 0.08878595f, -0.01452924f, -0.01048955f, -0.31190872f, 0.24246497f, 0.05207750f, -0.03410662f, 
    0.10460688f, -0.11729757f, 0.07372059f, 0.16451234f, -0.31691387f, -0.31477416f, -0.17688240f, -0.45769444f, 
    -0.08926589f, -0.20695704f, -0.41474149f, 0.00451534f, 0.01284562f, 0.01111023f, 0.02422587f, -0.01751383f, 
    0.02053101f, 0.19119973f, -0.06375767f, -0.01112583f, -0.50992972f, 0.01801935f, -0.18027967f, -0.15014775f, 
    0.17566592f, 0.05012275f, -0.02331483f, 0.06870437f, -0.03257236f, -0.01767165f, -0.00847231f, 0.05871537f, 
    0.36704376f, -0.14670381f, 0.38648775f, 0.13813278f, -0.13720796f, 0.02689533f, 0.03418530f, -0.01064899f, 
    0.05684361f, -0.01856080f, 0.20004630f, 0.07191741f, 0.03336203f, 0.10497744f, -0.11987229f, 0.12006705f, 
    -0.04444276f, -0.11847496f, 0.01668524f, -0.02795866f, -0.06442623f, -0.09767278f, -0.23681606f, -0.21198067f, 
    0.01867232f, -0.04412417f, 0.16497800f, 0.05917761f, -0.12626250f, -0.15854658f, 0.09563642f, 0.09608129f, 
    0.03527946f, -0.01135806f, 0.04896241f, -0.02172607f, 0.03011019f, 0.18979047f, 0.07683960f, 0.08075818f, 
    0.06488417f, 0.12053929f, -0.04051748f, 0.05583829f, 0.07655913f, 0.13748008f, 0.10634723f, 0.11577079f, 
    -0.00371808f, -0.23020039f, -0.06313342f, 0.15091918f, -0.32394320f, 0.15525866f, -0.00881266f, 0.00607614f, 
    0.08998883f, 0.05763629f, -0.01036530f, 0.24249738f, -0.40802678f, 0.22742167f, 0.13176630f, 0.07066759f, 
    -0.02777915f, 0.08163802f, -0.13893209f, -0.00375240f, 0.11819716f, 0.06146472f, 0.11876402f, 0.02935539f, 
    -0.04425720f, 0.32206866f, -0.05301207f, -0.01874228f, -0.07349088f, -0.11856082f, 0.18239675f, 0.02658393f, 
    -0.07613640f, 0.04450181f, -0.05124347f, -0.00559000f, -0.00508471f, -0.05400578f, 0.18412977f, 0.02385191f, 
    -0.03235567f, 0.13786823f, 0.28597921f, -0.12288254f, 0.14121011f, 0.11906283f, -0.02505821f, -0.13015644f, 
    -0.49591738f, 0.21779397f, -0.26638311f, 0.25776818f, -0.14503902f, 0.10229300f, 0.04068033f, 0.18013582f, 
    -0.06510256f, 0.14673081f, -0.10282292f, 0.03321298f, -0.02380350f, 0.40367234f, -0.16499066f, -0.03393192f, 
    0.03767936f, 0.05235735f, 0.01000571f, -0.01722736f, -0.01845337f, 0.02523414f, -0.06108899f, -0.15729173f, 
    -0.38738233f, -0.09474265f, -0.26604557f, -0.00356318f, 0.09279914f, -0.00889251f, 0.08248337f, -0.10646453f, 
    0.02764985f, 0.09665497f, 0.00398079f, -0.09387758f, 0.35287082f, 0.05683435f, 0.22152954f, 0.33615291f, 
    -0.04132202f, 0.11933520f, -0.02108644f, 0.10695864f, -0.23853475f, -0.06000141f, -0.05704175f, -0.09741434f, 
    0.32284421f, -0.18520834f, 0.11325332f, 0.08702091f, 0.02817658f, 0.00080098f, -0.04124526f, 0.08994473f, 
    0.05517667f, 0.09404773f, -0.09200209f, -0.00669230f, -0.27915564f, 0.07903701f, -0.28807101f, 0.02667279f, 
    0.09317341f, 0.09841607f, 0.03171564f, -0.05557913f, 0.10477725f, 0.15761414f, 0.15777504f, 0.13162160f, 
    -0.43287265f, 0.12628128f, -0.12172811f, 0.18071951f, 0.02519881f, -0.03971252f, 0.01247262f, 0.07452615f, 
    -0.02834792f, -0.09819719f, -0.14765470f, 0.08919019f, -0.01839920f, 0.13762368f, 0.16869672f, -0.00268209f, 
    0.19197445f, -0.08746931f, 0.00841262f, 0.08300207f, -0.03557219f, 0.06667321f, -0.06161247f, 0.14424706f, 
    -0.33781987f, -0.10979190f, 0.17122591f, -0.43764457f, 0.08890900f, -0.03914784f, -0.03917951f, 0.06166908f, 
    0.04839800f, 0.04389711f, 0.23803397f, -0.01890909f, -0.12625894f, -0.25953421f, 0.15732266f, -0.01067182f, 
    0.10565721f, -0.07916762f, 0.10828550f, -0.13591509f, 0.01048434f, 0.00187348f, 0.04906460f, 0.00679813f, 
    -0.19700135f, 0.01568111f, -0.13140526f, -0.13407834f, 0.11327555f, -0.02803761f, 0.00335930f, -0.03309160f, 
    0.06000657f, 0.05677104f, 0.12288534f, 0.11984828f, -0.00214959f, -0.48147452f, 0.19250116f, -0.21831059f, 
    -0.07496463f, -0.12247602f, 0.06454998f, -0.07496843f, 0.02989645f, 0.03186289f, 0.12774469f, 0.09127804f, 
    0.02829333f, 0.13151954f, 0.35243058f, -0.47656325f, -0.24103363f, -0.01760782f, 0.12878191f, -0.00921902f, 
    -0.02686621f, -0.02216094f, -0.02108882f, -0.00606590f, -0.20103222f, -0.02156663f, 0.02533610f, 0.11697574f, 
    -0.11103160f, 0.01154996f, -0.00705524f, 0.17533313f, -0.18754880f, 0.06620511f, 0.08168160f, -0.01754010f, 
    0.08533362f, 0.21508455f, -0.01903378f, -0.00788027f, -0.06184802f, -0.05111432f, 0.07275505f, -0.00477929f, 
    0.09242269f, -0.01521357f, 0.23076589f, -0.03861770f, 0.40959051f, 0.15501469f, 0.42188734f, 0.04312668f, 
    -0.10335662f, 0.04455005f, -0.36182827f, -0.03505394f, -0.04221645f, 0.00889029f, 0.03502735f, -0.02204144f, 
    0.15733942f, -0.07164782f, -0.16729462f, -0.22845073f, 0.14687143f, 0.09382525f, 0.05978561f, -0.13407537f, 
    0.03069230f, 0.16454975f, 0.25356340f, 0.05746404f, -0.13719180f, 0.11620429f, -0.20144936f, 0.13573551f, 
    -0.13288224f, -0.11836348f, 0.22666664f, -0.02843684f, -0.05044246f, 0.07701501f, -0.02001046f, -0.00873417f, 
    -0.33968478f, -0.44633576f, -0.25987592f, -0.34665307f, -0.07897945f, -0.05524643f, 0.04494598f, 0.08664978f, 
    0.04270850f, 0.06453662f, -0.05479634f, 0.10510849f, 0.04865176f, -0.16721943f, -0.07877748f, 0.05548666f, 
    -0.13244425f, -0.04594341f, -0.00383519f, -0.09547605f, 0.05551444f, 0.01168092f, 0.09994344f, 0.02606721f, 
    0.51591003f, -0.10689685f, 0.37765217f, -0.34415400f, 0.02591853f, 0.10087632f, -0.04685083f, 0.01782617f, 
    0.00053320f, 0.07410417f, 0.28926888f, 0.04267253f, 0.06664243f, -0.08484823f, 0.02859335f, -0.45164412f, 
    -0.05599226f, -0.26966712f, -0.15446857f, -0.04124419f, 0.08718135f, 0.06981193f, -0.00693628f, -0.12212546f, 
    -0.00176782f, -0.11221152f, 0.08202148f, -0.20758927f, 0.04954519f, 0.00573289f, -0.03034046f, 0.10610025f, 
    -0.06519171f, 0.00066770f, 0.16723660f, 0.07334072f, -0.21696356f, 0.14248016f, -0.04796650f, 0.24726725f, 
    -0.14002374f, -0.05054813f, -0.00241846f, -0.25672790f, 0.01045079f, 0.00539557f, -0.15618314f, -0.05670954f, 
    0.30095348f, -0.21076070f, 0.49681604f, 0.07104679f, 0.03242949f, -0.01408121f, 0.12480384f, -0.01159646f, 
    -0.11988300f, -0.09857740f, 0.00614611f, 0.01316385f, -0.24290295f, -0.20764093f, -0.04226134f, 0.26321197f, 
    0.08036935f, 0.07498249f, -0.05939904f, 0.07468446f, 0.01109193f, -0.09951381f, 0.07672177f, -0.14271118f, 
    -0.09209948f, -0.35034639f, 0.33878157f, -0.12484275f, 0.05948762f, 0.03239665f, 0.01563933f, -0.08083759f, 
    0.05734366f, 0.07915179f, 0.02457970f, -0.12445823f, -0.18691306f, -0.21187276f, -0.12235371f, 0.36996502f, 
    0.16876553f, -0.10822880f, -0.01861005f, 0.02546904f, -0.03934275f, -0.00434558f, 0.00730933f, 0.01823023f, 
    0.13247558f, -0.37567577f, 0.32180074f, 0.21232580f, 0.17058840f, -0.08665265f, 0.02608110f, 0.07832536f, 
    -0.00914172f, 0.06893232f, 0.03426567f, -0.18103404f, -0.12258510f, 0.07552606f, -0.23123816f, -0.14082600f, 
    -0.09199283f, -0.07846313f, -0.00785989f, -0.03119547f, -0.01528869f, 0.04860004f, -0.01822876f, -0.03971267f, 
    -0.06374804f, -0.02744043f, -0.03493457f, -0.00407050f, 0.02278266f, -0.00547811f, -0.00844920f, -0.04495814f, 
    0.17900099f, -0.01490721f, -0.05373951f, 0.15665489f, -0.15145350f, -0.33298728f, 0.20006649f, 0.15791495f, 
    -0.14371252f, 0.06283314f, 0.02370538f, 0.21861553f, -0.04282823f, -0.10944793f, -0.00868877f, -0.29472935f, 
    -0.18320000f, -0.32146883f, 0.34751716f, -0.33946916f, -0.01141237f, -0.02839617f, -0.11114983f, 0.04257760f, 
    -0.05597844f, 0.14527313f, 0.15583931f, -0.02962653f, 0.34576708f, -0.12748964f, 0.12224267f, 0.31885162f, 
    -0.06277115f, -0.04749468f, 0.01875329f, 0.04241604f, -0.03142296f, -0.05333232f, -0.15391660f, -0.09292313f, 
    -0.29558334f, 0.06917667f, 0.07445090f, 0.20301060f, -0.16512229f, 0.11561359f, 0.01342699f, -0.04121364f, 
    -0.14457034f, 0.09069084f, 0.09378883f, 0.02006931f, -0.46518165f, 0.20979398f, -0.29384497f, 0.24044691f, 
    0.15720055f, 0.07292282f, 0.09044085f, 0.00021348f, -0.08157105f, 0.02855243f, -0.04029348f, -0.03374274f, 
    0.03206228f, 0.25465584f, -0.27239645f, 0.22289243f, 0.08142990f, -0.09674009f, 0.10901737f, 0.01610136f, 
    0.11327348f, 0.02955218f, 0.13380131f, -0.08370972f, -0.18884410f, -0.48953578f, 0.06899725f, 0.13720797f, 
    0.04006920f, -0.00026842f, -0.00755857f, -0.05955855f, 0.01702281f, 0.03571242f, 0.14838040f, -0.02847239f, 
    -0.06659935f, -0.00308935f, -0.05690560f, 0.11546758f, -0.07557607f, -0.01223198f, -0.06486375f, 0.05300087f, 
    -0.16474222f, 0.18121070f, -0.07148790f, -0.07936389f, -0.26080820f, 0.00463241f, -0.00243863f, 0.04248672f, 
    0.10542934f, -0.04675164f, 0.02440770f, -0.00305202f, -0.14553364f, -0.11015526f, -0.14341038f, 0.14937270f, 
    -0.02228642f, -0.15421148f, 0.11430878f, 0.11375193f, 0.07454894f, 0.11108164f, 0.06997281f, -0.12764607f, 
    -0.01756746f, -0.01778325f, -0.07139400f, -0.10678398f, -0.16292681f, -0.37056571f, -0.18435022f, -0.05688735f, 
    -0.02270586f, -0.37758198f, -0.01679264f, -0.21902189f, 0.01612504f, 0.10382924f, -0.03939188f, -0.09471317f, 
    0.02930894f, -0.28774515f, 0.29449391f, 0.26835716f, 0.12111477f, 0.07927029f, 0.07738047f, 0.06037842f, 
    -0.15980582f, -0.03533662f, -0.01171920f, 0.03328838f, -0.09352459f, -0.40394855f, 0.01515636f, 0.09976220f, 
    -0.12670928f, -0.11370727f, -0.12910746f, 0.04120724f, 0.00298050f, -0.00611726f, -0.03774215f, -0.00432026f, 
    -0.08881048f, -0.04230598f, 0.05963966f, -0.16594739f, 0.12864192f, 0.12593833f, -0.03497646f, 0.03726461f, 
    -0.05524823f, 0.10701231f, 0.14757480f, -0.05362901f, -0.14531441f, -0.08182627f, 0.18534566f, 0.17886870f, 
    -0.00631265f, -0.07516971f, -0.10937292f, -0.17557567f, -0.01908974f, -0.14527626f, 0.09349933f, -0.07170090f, 
    -0.19829486f, 0.01504959f, -0.10340685f, 0.32617083f, 0.03924926f, -0.18473604f, 0.00496043f, 0.01229591f, 
    0.05291772f, 0.03022723f, -0.09948855f, 0.00060671f, -0.26057014f, 0.07245455f, -0.28256643f, 0.27710658f, 
    -0.03675757f, -0.04982061f, 0.01350259f, 0.18852626f, -0.09186937f, 0.09205294f, -0.00081540f, -0.06321593f, 
    -0.18032469f, 0.01359753f, -0.41075855f, 0.13829511f, -0.08609682f, -0.05119992f, 0.08411876f, -0.10381442f, 
    -0.12802024f, 0.14071566f, 0.03752621f, 0.08564469f, 0.04723965f, 0.05879806f, -0.00004591f, -0.03292404f, 
    -0.00496048f, 0.07343825f, -0.06880498f, -0.02627644f, -0.07442373f, -0.01450467f, -0.10331305f, -0.12554847f, 
    -0.23409040f, 0.05342270f, 0.08540932f, 0.11129519f, 0.00254561f, -0.02894347f, 0.12167389f, -0.13154998f, 
    0.05979168f, 0.06377910f, 0.12969640f, -0.06988016f, -0.40909535f, 0.05852969f, -0.05963398f, -0.16812050f, 
    -0.03332771f, 0.02150279f, 0.14494677f, -0.16839404f, -0.11610688f, -0.13863085f, -0.10845716f, -0.04832917f, 
    -0.16711119f, -0.12888904f, -0.19779959f, -0.21491478f, 0.11143364f, 0.00133361f, -0.04041222f, -0.04735902f, 
    -0.19049564f, -0.00025683f, -0.04183208f, -0.24801983f, -0.08154215f, 0.14329460f, -0.12516907f, -0.04594871f, 
    0.03635156f, 0.02894826f, -0.04158000f, 0.10007490f, 0.01792368f, 0.03191345f, 0.03434740f, 0.03356029f, 
    0.07193797f, -0.26621079f, -0.00730696f, -0.05905655f, -0.01388601f, 0.03561937f, 0.13544416f, -0.12343758f, 
    0.02077356f, -0.03653242f, 0.00740891f, 0.02515910f, 0.02318122f, 0.07252202f, -0.10810724f, 0.16820788f, 
    0.04334388f, -0.06612621f, -0.04458390f, -0.09042227f, -0.02442084f, 0.01307588f, 0.00105027f, -0.07968230f, 
    -0.07095224f, -0.08195749f, 0.01742997f, -0.06641448f, -0.09727314f, 0.21654703f, -0.16529244f, 0.13062155f, 
    -0.12663034f, -0.10397950f, 0.00923494f, -0.14355436f, 0.05351647f, 0.04267187f, 0.01635788f, -0.13154367f, 
    0.01351103f, -0.01817568f, -0.11415128f, -0.03973610f, 0.00867483f, 0.15634049f, 0.17123832f, 0.07036697f, 
    0.02373104f, -0.06100593f, 0.16991344f, 0.10848403f, -0.10675254f, 0.06154231f, -0.07501405f, 0.10405114f, 
    -0.15424113f, -0.00610812f, 0.10018698f, 0.01525455f, -0.02580059f, 0.23147480f, -0.08377226f, 0.31184971f, 
    0.09834283f, -0.13274376f, -0.05630749f, 0.06176972f, -0.01657028f, -0.13045457f, -0.03975938f, 0.02706056f, 
    0.31693208f, 0.00849872f, 0.15694474f, -0.11090354f, -0.09950855f, 0.06941894f, -0.11482555f, 0.20110051f, 
    -0.10320704f, -0.04898746f, -0.05560672f, -0.01003170f, -0.14368168f, -0.06752668f, 0.08809370f, 0.10476398f, 
    0.07411115f, -0.07596353f, -0.02788090f, 0.19738328f, -0.11461312f, 0.12281629f, -0.14761625f, -0.16228560f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12592149f, 0.07640564f, 0.08163814f, -0.06701688f, -0.06484119f, 0.08540183f, -0.00431173f, -0.15440264f, 
    0.09298646f, -0.02532226f, 0.02855693f, -0.02176455f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
