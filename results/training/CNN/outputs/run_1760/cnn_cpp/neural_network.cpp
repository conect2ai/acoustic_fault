#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.23772301f, -0.48116234f, -0.05344570f, 0.27175999f, -0.04908355f, 0.14206751f, 0.31797791f, -0.46589717f, 
    -0.22110796f, 0.54880834f, -0.16275078f, 0.05204019f, -0.18810262f, -0.04853966f, 0.24796084f, -0.19773357f, 
    -0.08270735f, 0.17072394f, -0.25408840f, -0.26492503f, 0.04892549f, -0.30720982f, 0.18730956f, 0.25107175f, 
    -0.30696595f, -0.13935474f, -0.35184807f, -0.03338717f, 0.53241438f, -0.29395491f, 0.06700011f, 0.19476430f, 
    0.02516632f, -0.19594757f, 0.21380574f, 0.23914698f, -0.28783631f, 0.41213259f, -0.31801271f, 0.10866129f, 
    -0.24378292f, 0.14213909f, 0.06140411f, -0.23635422f, -0.34853566f, 0.27372140f, 0.11959723f, 0.22142108f, 
    0.34426692f, 0.22044961f, 0.38300464f, 0.25186607f, -0.03099163f, -0.70562154f, -0.79389352f, 0.32989347f, 
    0.29349405f, 0.03370421f, 0.19214521f, 0.05875700f, 0.30847228f, -0.26212344f, 0.33380243f, -0.06806511f, 
    -0.27462599f, -0.16869925f, 0.23855159f, -0.24167745f, -0.29762551f, 0.39296183f, -0.01018106f, 0.09447921f, 
    -0.16422144f, 0.13417049f, 0.38167363f, 0.56251812f, 0.14003326f, 0.08718812f, 0.29377279f, -0.56240463f, 
    -0.23024338f, -0.43314242f, -0.31353384f, -0.51837462f, -0.68925273f, -0.14277124f, 0.01196260f, -0.15237191f, 
    -0.09702305f, -0.10504477f, -0.06360243f, -0.23058787f, 0.28704688f, -0.15036330f, 0.08874302f, -0.02458170f, 
    0.05052099f, -0.15071876f, -0.16735253f, -0.28719616f, 0.24479130f, 0.37804627f, 0.09854947f, 0.20161845f, 
    0.43927929f, -0.19479682f, -0.09888946f, -0.36184043f, 0.05211784f, 0.09125572f, -0.19176589f, 0.26200959f, 
    0.20421149f, 0.02620456f, -0.17572671f, 0.22494942f, 0.19452119f, 0.09651981f, 0.27111027f, -0.27716860f, 
    0.08567925f, 0.11947385f, 0.08726489f, 0.13427955f, 0.56047440f, 0.04100180f, 0.79166967f, 0.45269099f, 
    -0.21873954f, -0.41665101f, 0.36705920f, -0.03289091f, -0.05901292f, -0.33115301f, -0.25926793f, 0.07795557f, 
    -0.20280947f, 0.27960831f, -0.18563332f, -0.35624596f, 0.40903583f, 0.26663074f, 0.01693488f, 0.09935092f, 
    -0.30046073f, -0.24189822f, -0.22335345f, -0.35274062f, -0.07240221f, -0.11896523f, -0.51902956f, -0.09899621f, 
    -0.21502130f, -0.15053138f, 0.00710938f, -0.22980425f, 0.00786901f, 0.05592284f, -0.37635633f, 0.00925130f, 
    0.27836865f, 0.22532715f, -0.19950303f, -0.11566458f, -0.18851839f, 0.10174302f, -0.17665304f, -0.17813469f, 
    -0.00139190f, -0.40363535f, 0.31001291f, 0.33030635f, 0.08766299f, 0.34042525f, 0.26750740f, 0.32324913f, 
    -0.43570197f, -0.99765682f, -0.52780724f, -0.28117165f, 0.74599522f, 0.39461961f, 0.80241865f, -0.64103985f, 
    -0.13882197f, -0.03775797f, -0.15240160f, -0.17308627f, -0.04303547f, -0.14109719f, 0.19288196f, 0.29764462f, 
    0.04292365f, 0.12361489f, 0.24217559f, 0.06122264f, -0.05499383f, -0.12912212f, -0.19817817f, -0.00852897f, 
    -0.31031719f, 0.89729840f, 0.69904572f, -0.66601712f, 0.02977084f, -0.24972820f, -0.38250014f, -0.00033617f, 
    0.25559789f, -0.36245880f, -0.18106991f, -0.31192398f, -0.29640904f, -0.44852325f, 0.07495839f, 0.12563042f, 
    -0.15518792f, -0.01311042f, -0.02395054f, 0.24014610f, 0.01028559f, 0.04578476f, -0.02844291f, 0.04441553f, 
    -0.09341908f, 0.45881528f, 0.60991484f, -0.02814579f, 0.14728090f, -0.04024273f, -0.47505000f, -0.11389275f, 
    -0.02676730f, 0.44226375f, 0.14260411f, -0.02045696f, 0.07827574f, -0.09231843f, 0.17225127f, 0.00347015f, 
    -0.24680389f, 0.03175958f, 0.12557392f, -0.25281733f, -0.15527922f, -0.21754810f, 0.28338650f, 0.04672167f, 
    0.09866348f, 0.11306458f, -0.43706727f, -0.05912450f, -0.08685676f, -0.13997412f, 0.45024174f, -0.28078109f, 
    -0.49390090f, 0.04429294f, -0.27595171f, 0.44044644f, -0.30558938f, 0.32229140f, -0.05284172f, -0.09041328f, 
    -0.16392492f, 0.22925276f, 0.28297284f, -0.46594942f, -0.16997862f, 0.31605127f, 0.20606717f, -0.15827529f, 
    0.15437806f, -0.12603790f, 0.31083843f, -0.52459258f, 0.30513409f, 1.02431476f, -0.38810205f, -0.24796198f, 
    -0.36699679f, -0.33548900f, 0.26868007f, 0.37129736f, 0.04515609f, -0.29773656f, -0.16936128f, -0.01215768f, 
    0.65929472f, -0.35507739f, 0.00341236f, 0.15952985f, -0.00525428f, -0.15967247f, -0.03276014f, 0.11847792f, 
    0.01317038f, -0.09559619f, -0.11609031f, 0.01351419f, -0.45405123f, -0.25285164f, -0.67885530f, -0.47376600f, 
    -0.09607469f, 0.06257773f, -0.11903789f, -0.06603630f, -0.20679258f, 0.31113037f, 0.41560480f, 0.12008157f, 
    0.27921787f, 0.04590808f, 0.00364467f, -0.15556404f, 0.06398992f, -0.15460098f, -0.18009122f, -0.17286512f, 
    -0.12801558f, -0.08880590f, 0.01056593f, -0.16409180f, -0.20796853f, 0.73631239f, 0.28003535f, -0.33075380f, 
    0.42916560f, -0.14672136f, -0.00289111f, 0.33692181f, -0.15831926f, 0.06239706f, -0.10408507f, -0.02250912f, 
    0.14732353f, -0.03948972f, -0.13510077f, -0.13249066f, 0.02827470f, -0.11379074f, 0.06512762f, -0.08516991f, 
    0.08006369f, 0.02248146f, -0.10585151f, 0.09532297f, -0.02749004f, -0.34993562f, -0.21286209f, -0.32392552f, 
    0.08386220f, 0.10295217f, 0.46797439f, 0.40889934f, 0.50235826f, -0.01100821f, 0.05349084f, 0.22620720f, 
    0.11409292f, 0.20437250f, -0.05616909f, 0.03757155f, -0.21368420f, -0.13669026f, 0.13598147f, -0.04758454f, 
    -0.32890442f, -0.33488643f, -0.12928945f, 0.23476218f, 0.11661813f, -0.01647832f, 0.17881547f, -0.07489633f, 
    0.00680732f, 0.20956096f, 0.41947123f, 0.36176655f, 0.17407209f, 0.15890868f, -0.06046402f, 0.17859581f, 
    0.09775636f, 0.18330477f, -0.37345651f, 0.13745174f, 0.24748032f, -0.26465911f, -0.26596010f, 0.05479987f, 
    -0.18062779f, 0.07319760f, -0.21257296f, -0.22902207f, 0.03958909f, -0.34880048f, -0.14828569f, 0.13023818f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08246110f, -0.10284165f, 0.04475926f, -0.15697019f, -0.01405381f, 0.02448427f, -0.06132784f, 0.03348393f, 
    0.00877277f, 0.18201903f, 0.24780953f, 0.06861998f, 0.01357536f, 0.08363388f, 0.23302145f, 0.08039296f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.20046933f, -0.04608610f, -0.16210090f, 0.00023394f, 0.09944262f, 0.11032264f, -0.15042351f, 0.01920618f, 
    -0.00109759f, 0.07444912f, -0.09750727f, 0.02560248f, 0.07166994f, 0.05551169f, -0.08770103f, 0.04602858f, 
    0.06656037f, 0.07596360f, -0.08027846f, -0.04484592f, -0.01068147f, 0.04222961f, 0.09034991f, 0.09834989f, 
    -0.32291800f, -0.31425789f, 0.05804272f, 0.08268399f, -0.21904130f, 0.06203471f, 0.06535741f, 0.11536773f, 
    0.01331988f, 0.26182741f, -0.00413337f, 0.04163293f, -0.09350954f, -0.08700453f, 0.24936651f, 0.30467975f, 
    -0.02378288f, 0.04646085f, 0.07581013f, 0.10554415f, -0.02304316f, 0.07954519f, 0.01894012f, -0.05602768f, 
    0.15051624f, 0.08976196f, 0.04233981f, -0.06861102f, 0.11276711f, -0.06743150f, -0.15838255f, -0.13060659f, 
    -0.08406658f, 0.19142391f, -0.02035105f, -0.03975677f, -0.31700277f, 0.21990867f, 0.36005917f, 0.09523427f, 
    -0.30427352f, 0.11831249f, 0.17659788f, 0.11304551f, 0.06409702f, 0.13764806f, 0.16549268f, 0.07701551f, 
    0.06877540f, 0.08537559f, -0.09226612f, 0.21572585f, -0.01002862f, -0.06584584f, -0.09605820f, -0.05745920f, 
    0.08132198f, 0.10847929f, 0.15740554f, 0.04228727f, -0.03292917f, 0.24278073f, -0.16264078f, 0.03658253f, 
    -0.04533118f, -0.07357316f, 0.04983603f, 0.02646985f, -0.25890246f, -0.07388458f, 0.05091049f, -0.02826573f, 
    0.41868174f, -0.39729139f, 0.34114140f, 0.06219273f, -0.25439715f, -0.07595099f, 0.03114942f, -0.00006930f, 
    -0.02892080f, -0.00187261f, 0.03152255f, 0.08698945f, 0.23790151f, 0.02267579f, -0.06887368f, -0.13298751f, 
    -0.11109577f, -0.08833240f, -0.02232001f, -0.10939063f, -0.06455526f, 0.07248931f, 0.02657463f, -0.03336921f, 
    0.08134927f, -0.01132556f, 0.03361657f, 0.01655850f, -0.05301562f, -0.11833422f, -0.02356444f, -0.20403214f, 
    -0.06741028f, -0.09024992f, -0.07115055f, 0.00036269f, 0.24542154f, -0.06669427f, 0.08032293f, 0.03811309f, 
    0.07452838f, -0.08999236f, 0.25106642f, -0.24080528f, 0.14411922f, 0.15673727f, -0.10895815f, 0.03843959f, 
    -0.16990863f, -0.22319967f, 0.01399417f, -0.01179636f, 0.01727449f, -0.01450197f, 0.04236184f, 0.02960126f, 
    -0.00553351f, 0.08444422f, 0.15716109f, 0.10508627f, -0.10866629f, 0.05874678f, -0.10423847f, -0.17592885f, 
    -0.05505655f, 0.12656151f, 0.02111463f, 0.16744536f, 0.02928692f, 0.20020494f, 0.06584416f, -0.10870279f, 
    -0.23623389f, 0.17129561f, -0.32320237f, -0.37268978f, 0.05158877f, 0.22906762f, -0.02148135f, 0.00281068f, 
    -0.18274829f, 0.06987298f, 0.04743531f, -0.06604794f, 0.08065721f, 0.02814247f, -0.13490790f, -0.19529234f, 
    -0.11680519f, 0.10722759f, 0.10278788f, -0.02536028f, 0.08547299f, 0.07241290f, 0.11898170f, -0.20558554f, 
    -0.40986952f, 0.25298578f, -0.03689790f, 0.01972962f, -0.00679252f, 0.25038201f, 0.18383777f, 0.16727926f, 
    -0.04568369f, -0.07199988f, 0.09341355f, 0.08994099f, -0.12521113f, 0.02078852f, -0.03352627f, 0.01129287f, 
    -0.11843120f, 0.16118883f, 0.06596085f, -0.03165170f, -0.08892307f, -0.08723669f, 0.17575639f, -0.04682507f, 
    0.39551479f, 0.11378679f, 0.17370640f, 0.02124414f, -0.03803135f, 0.02496524f, 0.10157575f, -0.11144216f, 
    0.15239358f, -0.02323686f, -0.08661980f, 0.09446000f, -0.10381666f, -0.22198579f, -0.06094151f, -0.09483439f, 
    0.01861827f, 0.08288404f, -0.03337435f, 0.09294568f, 0.09187539f, 0.02662287f, 0.01184179f, -0.13894115f, 
    -0.14684395f, -0.16919923f, -0.10432140f, -0.05218996f, 0.02879571f, 0.12067261f, 0.00787286f, -0.04001962f, 
    0.01574069f, 0.00460045f, 0.04888804f, -0.08017229f, 0.61568630f, -0.32263917f, 0.13267648f, -0.10404792f, 
    0.20052519f, -0.14895320f, -0.09569176f, -0.18313186f, 0.05395983f, -0.22939390f, 0.03933723f, 0.06104707f, 
    -0.06270298f, -0.07277112f, 0.07673886f, -0.06690858f, -0.14661287f, 0.08313534f, 0.14880718f, 0.17754747f, 
    -0.03267666f, -0.14858617f, 0.03318562f, 0.10509820f, -0.20793648f, 0.03781198f, 0.60034800f, 0.21458335f, 
    -0.02681452f, -0.02628646f, -0.21142049f, 0.00181599f, -0.04806739f, 0.03767426f, -0.00793782f, -0.18364832f, 
    0.41986331f, -0.31225088f, 0.00936988f, -0.13599342f, 0.04322163f, -0.11609131f, 0.11500272f, 0.04137488f, 
    0.03501818f, 0.06821354f, -0.18710752f, 0.04757180f, 0.05293460f, -0.03091433f, -0.10439680f, -0.01632033f, 
    -0.07031934f, -0.01951865f, 0.10601840f, -0.06581910f, -0.07513806f, 0.07519373f, 0.11331674f, 0.02606966f, 
    -0.07538149f, -0.00908728f, 0.24785063f, 0.26142931f, -0.10703679f, 0.16111411f, 0.17133032f, 0.12218697f, 
    -0.17771828f, 0.25150299f, -0.10167187f, -0.00597165f, 0.45706761f, 0.22891809f, 0.01071553f, 0.20080563f, 
    -0.02356379f, -0.20613097f, 0.11503470f, 0.06704063f, -0.03081793f, 0.07897397f, -0.05457443f, -0.05421026f, 
    -0.20115422f, 0.15834060f, 0.03386868f, 0.22220846f, -0.04991233f, -0.10987346f, 0.10899480f, 0.13567510f, 
    -0.06149993f, 0.01696301f, -0.06540000f, 0.00318593f, 0.25372183f, 0.04407625f, -0.04913435f, -0.01562145f, 
    0.03524894f, -0.02158558f, -0.04069584f, -0.07096322f, 0.15660810f, -0.05913122f, 0.10023623f, -0.01819880f, 
    -0.00040755f, -0.09772015f, 0.04279356f, 0.10556211f, -0.09306825f, -0.05579708f, 0.08649595f, 0.02904842f, 
    0.03683012f, -0.14448969f, -0.04933638f, 0.18733686f, -0.11056598f, 0.09958667f, -0.08261087f, 0.01516350f, 
    -0.02831797f, -0.10336123f, 0.07342312f, -0.00679646f, 0.18168199f, -0.05955835f, -0.14806247f, 0.01639815f, 
    0.31624693f, -0.09231160f, 0.20154458f, -0.02607480f, 0.05108723f, -0.08294167f, -0.03181871f, -0.02776556f, 
    0.09919576f, -0.01152293f, 0.07807233f, -0.16897736f, 0.19967234f, -0.32630470f, -0.20927204f, -0.11935157f, 
    -0.00087517f, 0.04841169f, -0.00859986f, -0.06658333f, 0.09989356f, -0.13055883f, -0.04019340f, -0.03399933f, 
    -0.04682332f, -0.14160593f, -0.21718094f, -0.26587200f, -0.08528709f, 0.16878578f, 0.09486550f, -0.01161611f, 
    -0.02390103f, -0.07554240f, -0.07448284f, 0.10764579f, 0.29577518f, 0.38484973f, -0.14546655f, -0.21317595f, 
    0.05432498f, 0.00739725f, 0.03060909f, 0.15849268f, 0.02946359f, -0.13481015f, 0.12129328f, 0.00617855f, 
    -0.14003427f, -0.08635876f, -0.02245120f, -0.23131216f, 0.09626492f, 0.02863146f, 0.11504659f, 0.13503557f, 
    0.16925310f, -0.18812121f, 0.01449338f, 0.03869076f, -0.26610556f, 0.09631654f, -0.36661413f, 0.13873011f, 
    0.09857302f, -0.04857646f, 0.12268668f, 0.21211588f, -0.06218768f, -0.05073162f, -0.02791550f, -0.16779903f, 
    0.05784127f, 0.02073566f, 0.20677578f, 0.12101367f, 0.13780646f, 0.15579690f, 0.03953670f, -0.02027044f, 
    0.01786387f, -0.07425854f, -0.12126426f, 0.06647530f, 0.17833412f, -0.15198965f, -0.32235444f, -0.32490423f, 
    0.11610888f, 0.07135412f, 0.14570564f, 0.18589874f, 0.01840113f, -0.01703351f, 0.03365617f, -0.01190205f, 
    -0.45840305f, 0.42305651f, -0.38091427f, 0.32997635f, 0.14922734f, 0.03193371f, 0.10626540f, 0.16560516f, 
    -0.03752538f, 0.01967999f, 0.03587395f, -0.10073232f, -0.11182681f, -0.08854268f, 0.07350421f, 0.03802769f, 
    -0.12363933f, -0.11903642f, -0.09419768f, -0.01695344f, 0.20040683f, -0.12765625f, -0.12154114f, -0.00597968f, 
    -0.01039321f, 0.20008133f, 0.08779737f, 0.04807889f, 0.19887112f, 0.02915622f, -0.09451623f, -0.02977671f, 
    0.13349035f, -0.11728166f, 0.09323657f, 0.09986532f, -0.45802554f, 0.21654947f, -0.02969255f, 0.12860475f, 
    0.17828347f, -0.05444829f, 0.13555911f, 0.16398279f, 0.07721835f, -0.01008466f, -0.08269922f, -0.03333955f, 
    0.24614909f, 0.03069350f, 0.06294190f, -0.15356226f, 0.03205412f, 0.05659344f, -0.14050306f, 0.10731437f, 
    -0.00264509f, -0.15211907f, 0.04526865f, -0.03320938f, 0.10194770f, -0.22850788f, -0.01058977f, -0.06951442f, 
    -0.06471603f, -0.09951966f, -0.12244566f, 0.10233879f, 0.09272313f, -0.23647684f, -0.05404159f, -0.02677632f, 
    0.14736718f, -0.05869196f, 0.14840102f, 0.16112603f, -0.15701805f, -0.10130613f, -0.02245750f, -0.12409533f, 
    0.15592316f, -0.02517900f, 0.06335787f, -0.02426394f, 0.14629175f, -0.03911360f, 0.08193199f, 0.16153525f, 
    -0.01489198f, 0.04834391f, 0.08358448f, -0.10215900f, -0.05850201f, 0.06936708f, -0.09881077f, 0.13529481f, 
    0.05262946f, -0.16513099f, 0.13624093f, 0.01429590f, -0.03796788f, -0.05155575f, -0.05758014f, 0.19493140f, 
    0.01348113f, 0.17627926f, 0.04272215f, 0.02395240f, 0.13457270f, 0.04073812f, 0.00257877f, 0.04250673f, 
    -0.03820576f, 0.07548708f, 0.20292172f, -0.07312105f, -0.07288404f, 0.01896403f, -0.30956957f, -0.26353267f, 
    0.04698477f, 0.44470215f, 0.22004977f, 0.19910148f, 0.03906680f, -0.18421890f, -0.07772674f, -0.02316749f, 
    0.01210817f, 0.01920558f, 0.00548624f, 0.03953712f, -0.27246949f, -0.03800910f, 0.21702376f, -0.11547368f, 
    0.07347953f, 0.08396412f, 0.02129995f, -0.05271256f, -0.01321999f, -0.13487050f, -0.16413210f, -0.07899805f, 
    -0.07240438f, -0.10220380f, 0.05778040f, 0.06684332f, -0.10782239f, -0.03397152f, 0.01877822f, 0.11222087f, 
    -0.04703133f, -0.17533271f, -0.23159738f, -0.06874931f, 0.20809521f, -0.08295432f, 0.06796122f, -0.29034609f, 
    0.09629881f, 0.09499008f, -0.00933216f, 0.00815857f, 0.04901831f, 0.25367543f, 0.09359916f, 0.06218220f, 
    -0.06093943f, -0.18707538f, -0.13020851f, -0.07896022f, -0.03883453f, -0.17550337f, 0.03727253f, -0.17586021f, 
    -0.16534287f, -0.24883686f, -0.24036634f, -0.19744927f, -0.45291898f, 0.13152207f, 0.40496245f, 0.03088342f, 
    -0.04914181f, -0.12998821f, 0.13212764f, 0.05047966f, 0.01902587f, -0.02751374f, -0.05309907f, -0.02933436f, 
    0.17527115f, 0.18150233f, 0.11787336f, -0.11988880f, 0.10220763f, -0.08238073f, -0.08849069f, 0.03130978f, 
    -0.12952954f, 0.08024483f, -0.01385121f, -0.01591959f, 0.22295968f, -0.03055379f, 0.08402558f, -0.03946384f, 
    -0.07364329f, -0.04102130f, 0.06743552f, 0.09061709f, 0.03086341f, -0.13261509f, -0.02385374f, -0.00622086f, 
    0.02256929f, -0.34960219f, -0.01217622f, 0.10216807f, -0.08592962f, 0.07732363f, -0.07513169f, 0.06466267f, 
    0.03440661f, 0.00360304f, -0.04755027f, -0.07125621f, 0.23249272f, -0.13108604f, -0.19165945f, 0.08211553f, 
    0.07786067f, 0.26491067f, -0.05106202f, -0.14611292f, 0.08620679f, 0.01484010f, 0.02326896f, 0.10745119f, 
    -0.10399360f, 0.00155781f, 0.21680716f, 0.10594372f, -0.17170127f, -0.12766014f, -0.01032253f, -0.06702512f, 
    0.11579404f, -0.01991039f, 0.07596187f, 0.06501929f, 0.16304168f, 0.15950008f, 0.04872465f, -0.07308757f, 
    -0.06671862f, -0.21692337f, 0.04858750f, -0.07335804f, 0.12879314f, 0.06989634f, 0.02145034f, -0.05308802f, 
    0.05747941f, 0.01279399f, 0.17188004f, -0.13000520f, -0.05453485f, 0.00264279f, 0.03659118f, 0.15558410f, 
    0.06045239f, 0.09023108f, 0.02862568f, -0.01633449f, 0.11738043f, 0.12571354f, -0.02787966f, -0.25709391f, 
    -0.03383966f, -0.03178450f, -0.14451925f, 0.15514950f, 0.04219472f, 0.04899197f, -0.00041575f, 0.15028994f, 
    -0.07426456f, 0.06180911f, -0.07901952f, 0.14577034f, 0.00610555f, -0.04391497f, 0.03592778f, -0.08094204f, 
    -0.22506393f, -0.18045308f, 0.05048430f, 0.05446005f, 0.09704324f, -0.01013691f, -0.07738948f, -0.09180015f, 
    0.14153576f, -0.04278229f, -0.07481075f, 0.12295707f, -0.15756460f, -0.23977493f, -0.01087150f, -0.07451913f, 
    -0.05062875f, 0.12058359f, -0.01244445f, -0.51366991f, -0.06277308f, 0.06419261f, 0.06778036f, 0.04169437f, 
    -0.19136918f, -0.05910279f, -0.10213895f, -0.11028233f, 0.06761657f, 0.25687119f, 0.11990316f, 0.12016313f, 
    0.12042622f, -0.03132686f, 0.07260936f, 0.10332491f, 0.02452372f, 0.01306821f, 0.13618360f, -0.11205033f, 
    -0.04650737f, -0.00735668f, -0.18329002f, 0.02105362f, 0.02233976f, 0.01382652f, 0.08170599f, 0.05204055f, 
    0.08724958f, -0.15111375f, -0.04260321f, -0.11457689f, 0.07193334f, 0.08664761f, -0.13445030f, 0.16097331f, 
    0.02724767f, 0.00985356f, 0.14121129f, 0.13313384f, -0.03481819f, 0.05702183f, 0.15180582f, -0.11532068f, 
    0.00320318f, 0.13149281f, 0.24757209f, 0.16868058f, -0.01286451f, 0.00183043f, -0.05135330f, -0.07184637f, 
    0.11715253f, -0.02713338f, 0.05248189f, 0.01124690f, -0.28838825f, -0.04053104f, 0.20799200f, -0.14940606f, 
    -0.03392145f, 0.00796869f, -0.16640408f, 0.19230467f, -0.11551910f, -0.03108480f, -0.04213264f, 0.18587178f, 
    0.01214061f, -0.02767168f, -0.39246941f, 0.41357151f, 0.10713246f, -0.03885777f, 0.12187588f, -0.03343914f, 
    0.07882806f, -0.06708948f, 0.10259067f, -0.07499643f, 0.01479883f, -0.08646044f, -0.26877251f, 0.04905736f, 
    -0.04062993f, -0.11954472f, 0.02720927f, -0.09551906f, -0.07903604f, -0.18495712f, -0.01484586f, -0.13229796f, 
    -0.18555620f, -0.00096972f, 0.20014952f, 0.04977410f, 0.01034957f, 0.03965133f, 0.01723763f, -0.03092433f, 
    0.06028943f, -0.01155513f, 0.02171717f, -0.12888277f, -0.20530321f, 0.04410138f, -0.36924192f, 0.07382014f, 
    0.01731707f, -0.20733796f, 0.11820037f, -0.23700759f, 0.05733633f, -0.02160902f, -0.13750638f, -0.03395179f, 
    0.13371576f, 0.17156069f, 0.24705420f, 0.01569207f, -0.09819348f, -0.18513861f, 0.01550290f, 0.06208337f, 
    0.01271630f, 0.01796466f, 0.14847741f, 0.12820971f, 0.15067998f, -0.10553450f, -0.07168350f, -0.17025219f, 
    -0.03887749f, 0.11136403f, 0.04298091f, 0.03951656f, 0.09523417f, -0.09508924f, 0.04733643f, 0.04924711f, 
    0.06258090f, 0.02160080f, 0.15281107f, 0.07636671f, 0.06800119f, -0.08244197f, -0.23643114f, -0.11226650f, 
    -0.18503989f, -0.15624709f, -0.06752174f, -0.21215697f, 0.00304563f, -0.22000661f, 0.08332568f, 0.17575544f, 
    0.11878336f, -0.05530284f, 0.06785166f, -0.06544428f, -0.03247090f, -0.01300014f, -0.04471451f, 0.14498623f, 
    -0.00837169f, 0.20172858f, -0.03760168f, 0.10052043f, 0.00295661f, 0.07487425f, 0.01017018f, -0.16373436f, 
    -0.04174273f, -0.15110610f, 0.05864078f, 0.26048353f, -0.19972375f, -0.00872078f, -0.02382372f, 0.13271113f, 
    0.22061460f, -0.07102422f, 0.11622261f, -0.12658985f, -0.16337432f, -0.10266009f, -0.34643614f, -0.18663408f, 
    -0.38221696f, -0.36371660f, -0.09583712f, 0.41785017f, 0.22649825f, -0.11949860f, -0.19538751f, 0.06135572f, 
    0.00901615f, -0.00103948f, 0.11099298f, -0.02115595f, 0.13876981f, 0.17121641f, 0.21641898f, 0.29525757f, 
    0.05604045f, 0.15767585f, 0.22107664f, 0.21442676f, -0.12107055f, 0.09782664f, 0.04319146f, 0.07243928f, 
    -0.20513801f, -0.14982095f, 0.06919070f, 0.14357346f, 0.00704392f, -0.20695937f, -0.05811925f, 0.17464152f, 
    -0.37463817f, -0.10456025f, -0.26252460f, -0.59510761f, 0.07712942f, 0.11790802f, -0.13748918f, 0.21334714f, 
    -0.13037276f, -0.02478567f, 0.07712670f, 0.10873028f, -0.03710041f, 0.31139660f, 0.28905356f, 0.12788224f, 
    0.15603180f, 0.08162008f, -0.08472046f, -0.01111551f, 0.15620098f, 0.00013446f, 0.07052168f, -0.07501499f, 
    -0.15659089f, -0.16642419f, -0.13416855f, -0.35578838f, 0.23912457f, -0.10746559f, -0.41577694f, 0.01197526f, 
    0.32608455f, 0.16570182f, -0.00894205f, -0.04622692f, -0.01175872f, 0.08445814f, -0.03984420f, 0.20287637f, 
    0.16534860f, 0.32236141f, 0.20558757f, -0.09013064f, -0.12197226f, 0.03940571f, -0.05572362f, 0.04233649f, 
    -0.06618936f, -0.15496619f, 0.08341539f, -0.00438064f, -0.37218416f, -0.20499596f, 0.03489949f, 0.12176198f, 
    -0.24584144f, -0.05775968f, 0.01937706f, -0.08627333f, -0.27976364f, -0.09215847f, -0.01213590f, -0.08556665f, 
    0.31349245f, 0.18056305f, -0.03969486f, -0.33205467f, -0.01739046f, 0.05849192f, 0.18600295f, -0.01340769f, 
    0.03062329f, -0.10556043f, 0.08271382f, -0.14204013f, 0.07268319f, -0.01559640f, 0.29737154f, -0.17838418f, 
    -0.14050718f, 0.28108189f, -0.09944357f, 0.02146678f, 0.02305470f, -0.09943498f, 0.18044934f, 0.08504058f, 
    0.30627251f, 0.06791247f, -0.14406301f, 0.15443616f, 0.05672554f, 0.12582807f, 0.10026434f, -0.17086853f, 
    0.13321136f, 0.07161483f, 0.12190743f, 0.15996923f, -0.80011213f, -0.00651970f, -0.32198778f, 0.12778790f, 
    -0.05953187f, -0.05087594f, -0.09736816f, 0.03003944f, -0.06855325f, -0.00279989f, -0.00566733f, 0.08997933f, 
    -0.31047073f, 0.16536097f, -0.30269155f, -0.09697839f, 0.15445314f, -0.03684331f, -0.05065312f, -0.34316015f, 
    -0.15244561f, 0.09767361f, -0.03971455f, -0.02286430f, -0.12510101f, -0.04265034f, 0.16663960f, 0.03243388f, 
    -0.17805992f, -0.06415343f, -0.02758247f, -0.00923130f, 0.01755643f, -0.09692678f, 0.18454400f, -0.02901656f, 
    -0.21893333f, 0.22569115f, -0.09875371f, 0.12030108f, -0.06182617f, 0.05725862f, -0.04934279f, 0.10660101f, 
    -0.10180436f, 0.07270109f, 0.15286335f, 0.25162590f, -0.12963311f, 0.12979022f, 0.03509117f, 0.14519784f, 
    0.01339472f, -0.06163428f, 0.08759384f, -0.05906035f, -0.16815715f, -0.08545053f, -0.08428037f, -0.16701028f, 
    0.47656438f, 0.12340192f, 0.41019979f, 0.04723485f, 0.13563631f, -0.27333784f, -0.00236789f, 0.14522678f, 
    -0.06233186f, 0.17871469f, 0.02169369f, -0.06793369f, -0.24185824f, -0.33725020f, 0.03133122f, 0.01473145f, 
    0.02267329f, -0.02715086f, -0.02683491f, -0.01330745f, 0.06709729f, 0.00815832f, -0.07990912f, -0.00886592f, 
    -0.07194118f, -0.20447248f, -0.16974863f, -0.06857473f, -0.01377742f, 0.02516008f, 0.04660135f, 0.01142992f, 
    -0.01615306f, -0.02235649f, -0.09619190f, -0.18083155f, 0.25403750f, -0.35588548f, 0.30241045f, -0.19915329f, 
    -0.02752816f, -0.05542668f, -0.00023975f, 0.00575702f, 0.14247233f, 0.24755256f, 0.12037260f, 0.09980087f, 
    -0.06776080f, 0.05601992f, 0.00594476f, -0.07654519f, -0.10423472f, -0.19110692f, -0.11160611f, -0.10051508f, 
    -0.06241466f, -0.06482448f, -0.07358909f, -0.18002371f, -0.20195109f, 0.19910158f, 0.58743465f, 0.20787372f, 
    0.00267154f, 0.03241640f, -0.02714935f, 0.07128181f, 0.03099039f, -0.03848050f, -0.01683349f, -0.08466882f, 
    0.27945036f, -0.48641634f, -0.07115536f, -0.26482514f, 0.05388414f, 0.02957629f, -0.02355440f, -0.05253334f, 
    0.03120973f, -0.06675600f, -0.10345197f, -0.06450301f, 0.19474058f, 0.05181789f, -0.11106978f, -0.11198670f, 
    -0.00393080f, 0.10320829f, 0.15903062f, 0.03049882f, -0.10692023f, -0.07357929f, 0.07652630f, 0.01646448f, 
    -0.13534586f, -0.19090489f, 0.06809137f, 0.09290740f, -0.14308691f, 0.03538189f, 0.11236333f, 0.15870248f, 
    -0.15104829f, 0.08786049f, -0.13354497f, -0.10053439f, 0.27339932f, 0.12389868f, -0.02775232f, -0.10956538f, 
    -0.08689356f, -0.05926693f, 0.08953907f, -0.01959209f, 0.08886885f, 0.12470504f, 0.13520771f, 0.15355246f, 
    -0.19726297f, 0.21106285f, 0.13149449f, 0.23832838f, -0.12256726f, -0.22865810f, -0.07073314f, -0.00100103f, 
    -0.02442959f, 0.11736315f, -0.02591356f, 0.11554346f, 0.01543994f, -0.01799453f, -0.05147224f, 0.10156461f, 
    0.02662586f, 0.00848365f, 0.12842220f, -0.02950987f, -0.01214164f, 0.07890449f, 0.10804172f, 0.04648681f, 
    -0.12206973f, 0.03398676f, 0.02498449f, 0.06636874f, 0.08860757f, 0.01478474f, -0.10877648f, 0.07060043f, 
    -0.22154973f, 0.03355030f, 0.09990165f, 0.03747628f, -0.19144620f, -0.10578209f, -0.11721654f, -0.02910152f, 
    -0.07474907f, -0.05964424f, -0.06954917f, -0.02461453f, 0.09048798f, -0.01374423f, 0.03947030f, 0.01729038f, 
    -0.21113232f, 0.23694894f, 0.06368732f, -0.00422090f, -0.10123857f, 0.23079191f, 0.19788387f, 0.16345955f, 
    0.06341347f, -0.01013360f, 0.03222371f, -0.04249807f, -0.08471946f, -0.02684665f, 0.07212603f, -0.08870955f, 
    -0.11073530f, -0.00520905f, -0.09023468f, 0.05768150f, 0.11232889f, -0.02754411f, 0.16548772f, 0.08622101f, 
    0.49953884f, -0.20087880f, -0.01704303f, -0.10184283f, -0.03090637f, 0.00348694f, 0.09828237f, -0.25656891f, 
    0.00052051f, 0.08198557f, 0.13271803f, 0.05313624f, 0.15499818f, -0.20470226f, -0.21064781f, 0.19504040f, 
    0.13817063f, 0.22390734f, 0.09275295f, 0.00207257f, 0.03628503f, -0.05110336f, 0.02165181f, 0.09197268f, 
    -0.28493378f, -0.20405354f, -0.29923782f, -0.20557097f, 0.10027402f, 0.11898316f, 0.12644382f, -0.15985049f, 
    -0.07972249f, 0.00490265f, 0.02832781f, -0.01388107f, 0.32898629f, -0.39633211f, -0.06767022f, 0.22696683f, 
    0.11856972f, -0.06076467f, 0.02873477f, -0.17551978f, 0.13988477f, -0.23239423f, -0.09563632f, -0.06799607f, 
    -0.16254838f, -0.20435405f, 0.12485107f, -0.08322393f, 0.00135501f, 0.09271041f, 0.13176325f, 0.20810327f, 
    -0.06050196f, 0.03107918f, 0.11224155f, 0.05175198f, 0.23834300f, -0.36449555f, 0.05922763f, 0.06229297f, 
    -0.06477658f, 0.00056304f, -0.24025416f, -0.01945203f, -0.01524934f, 0.00714590f, -0.17302105f, -0.08883393f, 
    0.23793092f, -0.40388438f, -0.20973800f, 0.20058100f, 0.02476354f, 0.01213801f, 0.23190592f, 0.04662761f, 
    -0.01275509f, -0.03579722f, 0.00243591f, -0.07688686f, -0.04821146f, 0.24619055f, -0.24959157f, -0.10398176f, 
    -0.08623362f, -0.10279185f, 0.05320670f, -0.09590094f, -0.04219551f, -0.01496048f, -0.02808533f, 0.04878788f, 
    -0.35118073f, -0.12495977f, 0.21848971f, 0.16069940f, -0.11456151f, 0.16434552f, 0.22373870f, 0.19015975f, 
    -0.03453709f, 0.05040403f, 0.01165904f, 0.03394946f, 0.15900339f, 0.28794330f, -0.16910060f, 0.03083241f, 
    -0.11041127f, -0.19306695f, 0.10792559f, 0.06674170f, 0.03719410f, 0.07731244f, -0.09558769f, -0.07039842f, 
    -0.21495342f, 0.09680903f, -0.08890023f, -0.04486270f, 0.14371359f, -0.15457100f, 0.01346944f, 0.32209486f, 
    -0.07625906f, -0.11612660f, -0.16743270f, 0.03906788f, 0.11827537f, -0.08886448f, 0.03633901f, 0.02826370f, 
    0.01315059f, 0.11207266f, -0.13216490f, -0.17698137f, 0.11465607f, -0.18984528f, -0.04291497f, -0.14487264f, 
    0.17270324f, 0.00418486f, 0.29427728f, 0.25833613f, -0.16382487f, -0.08469216f, 0.00465535f, -0.12440807f, 
    0.14884798f, -0.07107915f, -0.02116408f, 0.11944992f, -0.06376762f, 0.07829537f, 0.14303330f, 0.09066679f, 
    -0.04055725f, 0.02975283f, -0.00002211f, -0.22213106f, -0.05031488f, 0.04574805f, -0.12097628f, -0.11894102f, 
    0.12594903f, -0.05505383f, 0.15230067f, 0.00015020f, 0.01893615f, 0.02278807f, 0.00376672f, 0.01481440f, 
    0.10122034f, 0.15046100f, -0.02171085f, -0.16226874f, -0.15099145f, -0.23830643f, 0.00318126f, -0.01752387f, 
    -0.08734931f, 0.07210609f, -0.00558693f, 0.06407806f, 0.16086955f, 0.09066884f, -0.00105054f, 0.09369830f, 
    -0.11387827f, 0.06366697f, 0.06542334f, 0.18552119f, -0.05318538f, 0.10845285f, -0.05021521f, 0.05329952f, 
    0.10198898f, 0.01166938f, 0.07962715f, -0.00339504f, -0.11228617f, -0.18985185f, -0.13055409f, -0.13797109f, 
    -0.09535713f, -0.01568573f, -0.22431175f, -0.20551394f, -0.00457970f, -0.00045656f, -0.01318801f, 0.23695974f, 
    -0.03327807f, 0.05585075f, -0.04884886f, -0.18268660f, -0.10099929f, -0.11037152f, -0.15938100f, -0.20217128f, 
    -0.06936840f, 0.04767965f, -0.12085123f, 0.13728133f, -0.17473458f, 0.09861362f, 0.19531277f, 0.12570612f, 
    0.02901346f, 0.11818829f, 0.09320006f, 0.07617332f, -0.00714491f, -0.06450734f, -0.13311444f, -0.09733342f, 
    -0.01439295f, -0.21065226f, -0.21595727f, -0.11605148f, 0.03815741f, 0.10491946f, -0.00784343f, 0.27715352f, 
    0.02356846f, 0.14087290f, 0.05194495f, 0.04706611f, 0.20008676f, -0.22970279f, -0.16497540f, 0.04210980f, 
    -0.02017368f, 0.13980325f, 0.10738397f, -0.08464136f, 0.11307054f, 0.07972341f, -0.09408705f, -0.04732975f, 
    -0.12247078f, 0.16433915f, 0.32496813f, -0.09859098f, 0.10017095f, 0.03153047f, -0.00767510f, 0.11059156f, 
    -0.01342023f, 0.08883659f, -0.06255592f, 0.01380484f, -0.14707214f, 0.24326532f, 0.05495705f, -0.13854839f, 
    0.16337867f, -0.04075772f, -0.10526133f, -0.02149861f, 0.00637600f, 0.12695995f, -0.04174669f, 0.04333166f, 
    0.00323516f, -0.06175943f, -0.13971062f, -0.02151545f, 0.01824381f, 0.05429460f, 0.10886638f, -0.02155118f, 
    0.02213986f, 0.07396878f, 0.08367877f, 0.14240195f, 0.22694311f, 0.04561596f, 0.11425669f, -0.04262938f, 
    0.19690417f, 0.05956152f, -0.04746064f, 0.21357553f, -0.12217212f, 0.07711757f, 0.13271634f, 0.10276257f, 
    -0.20956998f, -0.20720793f, -0.10800914f, -0.12896658f, 0.10282478f, 0.15737517f, 0.02756053f, 0.02106046f, 
    -0.18184243f, -0.07010196f, 0.01800502f, -0.13004482f, -0.21295744f, 0.25113022f, 0.23001298f, 0.04324967f, 
    -0.06326473f, -0.02533761f, -0.08084642f, -0.26492119f, -0.18571226f, 0.15242931f, 0.05026437f, -0.03778824f, 
    -0.06666710f, -0.04881132f, -0.03768280f, -0.02508337f, -0.14065717f, -0.03150100f, 0.02883635f, 0.01120991f, 
    0.14402083f, 0.03719313f, 0.03802831f, 0.14690143f, 0.21469818f, 0.26117447f, 0.03993163f, -0.01861290f, 
    -0.12835285f, -0.04227192f, -0.11722270f, -0.17983054f, -0.14331160f, -0.14601299f, -0.02269264f, -0.05657435f, 
    0.16765812f, -0.27323064f, 0.43381864f, -0.23895214f, 0.03428689f, 0.16169775f, -0.07719499f, -0.02179795f, 
    0.05091192f, 0.14165075f, -0.07387494f, -0.17243099f, 0.08983658f, -0.23449156f, -0.01161452f, -0.25114065f, 
    -0.17944580f, 0.07485706f, -0.07647640f, 0.06725911f, 0.25580883f, 0.25888842f, 0.10397605f, 0.09319270f, 
    -0.00849519f, 0.21658386f, -0.26754043f, 0.02086708f, -0.03068046f, 0.11284497f, -0.02517336f, -0.11491423f, 
    0.17993793f, 0.06543834f, 0.09181357f, 0.08132926f, -0.05227718f, 0.03762862f, -0.04514546f, -0.05047896f, 
    -0.02476807f, 0.11294883f, -0.18068080f, -0.16876651f, 0.00954967f, -0.05052719f, -0.01459586f, 0.15059434f, 
    -0.08898910f, -0.01775424f, 0.06873178f, -0.15618093f, -0.10200965f, -0.02762901f, -0.08090257f, -0.08931376f, 
    0.04609189f, 0.04723005f, -0.03110531f, 0.16159508f, -0.07534929f, 0.16399391f, 0.07405188f, 0.02072734f, 
    -0.00754911f, -0.02083384f, -0.07592075f, -0.05946036f, 0.08969969f, -0.14078788f, -0.20535100f, -0.04117515f, 
    -0.13019352f, -0.29191136f, -0.16714641f, -0.01550144f, 0.08412163f, 0.14795971f, 0.14881741f, 0.27073133f, 
    -0.02298691f, 0.05820460f, -0.06367972f, 0.09399747f, 0.07315785f, -0.09759115f, -0.08875524f, -0.01424389f, 
    0.02307046f, -0.04877461f, 0.08468010f, 0.08147996f, 0.10854897f, -0.05452822f, -0.03798471f, -0.05660138f, 
    0.02461262f, 0.17771040f, 0.30557188f, -0.08137232f, -0.03855078f, 0.06569887f, -0.17680646f, 0.09153383f, 
    -0.08341160f, 0.01237390f, 0.04519236f, -0.08490128f, -0.13527569f, 0.00718439f, 0.14154565f, -0.06216739f, 
    -0.06794246f, -0.23949595f, -0.18426894f, -0.08021136f, 0.17493503f, 0.01450973f, -0.02203332f, 0.07685961f, 
    0.05894038f, -0.20007387f, -0.23343767f, 0.13596928f, 0.17263909f, 0.02430760f, 0.07229795f, 0.00863042f, 
    -0.00638020f, -0.02208819f, 0.01089541f, 0.18554322f, 0.39695290f, 0.05480088f, -0.22149149f, 0.04222478f, 
    0.07424804f, 0.02351010f, -0.13552932f, 0.04584098f, -0.05841830f, 0.05221525f, 0.05878419f, -0.12764269f, 
    -0.01357404f, -0.21520287f, 0.06866608f, -0.05463990f, 0.12121540f, 0.09129202f, 0.10117153f, 0.11593396f, 
    -0.10351901f, -0.08236696f, -0.04769076f, -0.09081176f, 0.03003703f, 0.16692863f, 0.15206267f, -0.15514432f, 
    -0.03915118f, -0.21726221f, -0.29010269f, -0.17668419f, 0.06179126f, 0.13782348f, -0.01701985f, -0.09824536f, 
    0.09321947f, -0.10883041f, -0.01659241f, -0.22723918f, -0.17539862f, -0.02742732f, -0.08546523f, 0.10716911f, 
    0.10234184f, 0.08665182f, 0.08901841f, 0.20673530f, 0.21216704f, 0.29854938f, 0.06340302f, -0.25208414f, 
    -0.20882522f, -0.05076355f, -0.12442732f, -0.14501342f, -0.02917510f, -0.07839333f, 0.03600340f, -0.10700610f, 
    0.40681121f, 0.03659979f, 0.19694696f, 0.03522334f, -0.17489707f, -0.11336359f, -0.11083680f, 0.00149862f, 
    -0.07003350f, 0.11731890f, -0.05503035f, -0.03837316f, -0.49661544f, 0.07936123f, -0.12331475f, -0.14224426f, 
    -0.09154440f, -0.22479022f, 0.26113561f, 0.09116160f, -0.13858826f, 0.11712425f, 0.10367791f, 0.07877087f, 
    0.27196649f, -0.16283546f, -0.01133986f, -0.31280518f, -0.06788686f, 0.19661352f, 0.26922384f, 0.25138849f, 
    -0.04553448f, -0.02245314f, -0.08750082f, -0.14450923f, 0.13607936f, 0.10379721f, -0.35225761f, -0.41012877f, 
    -0.21378744f, -0.24255741f, -0.24193725f, -0.14112787f, -0.13302980f, 0.08894745f, 0.14942513f, 0.27932522f, 
    -0.03283812f, -0.16436744f, -0.30750844f, -0.34795120f, -0.10778339f, 0.03966036f, 0.05883341f, -0.04191500f, 
    0.02548843f, -0.11073668f, 0.00568700f, 0.09664612f, -0.14273134f, 0.11695287f, -0.02374084f, -0.36137417f, 
    0.08398426f, 0.02669217f, -0.14798293f, 0.13253473f, -0.21351239f, -0.02117245f, -0.12405021f, 0.03637257f, 
    0.15566041f, 0.02113966f, 0.15697575f, 0.00947296f, 0.04672147f, 0.01688035f, 0.02089019f, 0.14660077f, 
    -0.17120075f, -0.01769006f, -0.01024509f, -0.08967000f, 0.52807444f, 0.08445591f, 0.04248047f, 0.00249991f, 
    0.11699713f, 0.14662442f, 0.18074034f, 0.02019371f, 0.21639685f, 0.00393897f, -0.01707294f, -0.03605833f, 
    -0.30120823f, 0.17942566f, -0.08192229f, -0.06863862f, 0.07764766f, 0.09774367f, -0.05935284f, 0.10357911f, 
    -0.21959236f, 0.06408171f, -0.06501961f, -0.11062495f, -0.53979135f, -0.30346397f, 0.09910358f, -0.35172555f, 
    0.15013458f, 0.19059026f, -0.16518100f, -0.09355643f, 0.16439402f, 0.17711963f, -0.13355470f, 0.24366793f, 
    -0.00623729f, 0.15482669f, -0.10266364f, 0.16496249f, 0.00802587f, 0.05577327f, 0.03503406f, 0.15420344f, 
    -0.07411467f, 0.11189890f, -0.14340168f, 0.01325789f, -0.31252068f, -0.10639775f, 0.03725702f, -0.02911912f, 
    0.21842189f, -0.08126228f, 0.11715962f, 0.20601344f, 0.01691736f, 0.01331667f, 0.16076608f, 0.11059536f, 
    0.13275778f, 0.11590897f, -0.03311037f, 0.01338198f, 0.11261804f, 0.15667360f, -0.11448734f, -0.05598199f, 
    0.15367959f, 0.01164357f, -0.00963764f, 0.01817447f, -0.04982369f, 0.02368703f, -0.06744721f, -0.27879602f, 
    -0.43575889f, -0.19389562f, 0.09314167f, -0.04959971f, -0.26411086f, -0.00075657f, 0.04139509f, 0.13490507f, 
    -0.49028078f, -0.45401898f, -0.38277608f, 0.01717168f, -0.17581961f, 0.09415412f, 0.06207298f, 0.14518596f, 
    -0.02544215f, -0.02156090f, -0.06223861f, -0.02054018f, -0.55746806f, -0.08552772f, -0.34782165f, -0.17380697f, 
    -0.08537061f, -0.05010260f, -0.16637693f, -0.07304811f, -0.01773311f, -0.09722044f, -0.08503920f, -0.04807067f, 
    -0.03959894f, 0.01435878f, -0.02206626f, -0.01080370f, 0.07406009f, 0.01390879f, 0.09145926f, 0.11901588f, 
    0.07556181f, 0.01526448f, 0.05389110f, -0.00651206f, 0.05161549f, -0.11423764f, -0.07587462f, 0.06129361f, 
    -0.01723936f, 0.13055113f, -0.11583874f, -0.06326447f, 0.07639791f, -0.03019306f, -0.03059020f, 0.04899428f, 
    0.07029519f, -0.33552173f, -0.38670895f, -0.13100126f, -0.05502260f, -0.00501121f, -0.07536072f, -0.07093842f, 
    0.07327318f, -0.04163255f, 0.14425907f, 0.20522790f, 0.22913072f, 0.15994240f, 0.07102894f, 0.13515048f, 
    0.03477749f, 0.10022038f, 0.05501732f, -0.07493488f, -0.02154939f, -0.04583299f, 0.08333593f, -0.14000686f, 
    -0.53199315f, -0.37383121f, -0.16582716f, -0.11315984f, -0.02872166f, 0.02292795f, 0.03764732f, 0.06780777f, 
    0.11665624f, 0.01490989f, 0.02555726f, -0.00861745f, -0.21431296f, -0.09207834f, -0.39780319f, 0.08010916f, 
    -0.00188179f, -0.01763677f, -0.05851796f, -0.00855975f, 0.00721065f, -0.16672254f, 0.04736511f, -0.08640569f, 
    -0.02548047f, 0.20644625f, 0.22878000f, -0.04652813f, 0.02901514f, 0.24852067f, 0.02310718f, 0.06361388f, 
    0.12040728f, -0.06616952f, 0.03771085f, -0.03937668f, 0.14209948f, 0.22074479f, -0.18001483f, -0.15501988f, 
    0.04328440f, 0.13841984f, -0.03326427f, -0.03326395f, -0.06926059f, -0.05272273f, 0.07645748f, 0.04264541f, 
    -0.27529386f, -0.08323077f, 0.00974868f, 0.26152101f, -0.02524985f, 0.11541200f, -0.14871645f, 0.09647426f, 
    0.13851215f, 0.01085200f, -0.07152179f, -0.07841821f, -0.36743227f, -0.40512615f, -0.12876251f, 0.15600426f, 
    -0.14928690f, 0.07790372f, -0.07094081f, -0.09435644f, 0.02820791f, 0.03558137f, -0.02840231f, 0.00682043f, 
    0.12566206f, 0.25579122f, 0.22649166f, -0.01796274f, 0.25649580f, 0.10605231f, 0.09305793f, 0.10630415f, 
    0.14192195f, -0.08277040f, 0.09575888f, 0.02961130f, -0.17249632f, -0.09311526f, 0.19988640f, 0.19239804f, 
    -0.07725359f, 0.12155663f, -0.12051819f, 0.14430289f, 0.08688493f, -0.03342167f, -0.19085440f, -0.04870154f, 
    0.15734340f, 0.13264185f, 0.09705831f, -0.04141720f, 0.15813833f, 0.07350931f, 0.01967078f, 0.09666372f, 
    -0.07511960f, -0.08665487f, -0.16158040f, 0.04510173f, -0.09909625f, -0.33148366f, -0.30880231f, -0.09266786f, 
    0.05398769f, 0.04226343f, -0.00276943f, -0.20531128f, 0.04825618f, -0.15043633f, -0.16810076f, -0.05184460f, 
    -0.10814626f, -0.14018476f, -0.04154950f, -0.06295700f, -0.12603712f, -0.14006025f, 0.06287274f, -0.23688944f, 
    0.15711163f, 0.06493562f, 0.10066462f, 0.02656708f, -0.26424450f, -0.24447469f, 0.04277102f, 0.07592030f, 
    0.04515044f, -0.04520661f, 0.09924032f, -0.00435545f, 0.04137959f, 0.05007697f, 0.05729053f, 0.16775522f, 
    -0.02337937f, -0.03802253f, 0.01779938f, -0.05808321f, -0.02995354f, 0.03514937f, 0.00516500f, 0.00595050f, 
    0.02579025f, 0.00924112f, -0.05076507f, -0.05182361f, 0.00754054f, -0.06958890f, -0.00467792f, 0.02985094f, 
    -0.06934308f, -0.03883330f, 0.06195291f, -0.02445792f, 0.02173728f, -0.05805064f, 0.06330623f, 0.00215178f, 
    -0.00655455f, 0.06223454f, -0.05590518f, -0.02980240f, -0.05701980f, 0.00661520f, -0.04167067f, -0.05447232f, 
    0.04369848f, 0.05856620f, 0.03719625f, 0.02693173f, 0.05018907f, -0.01225474f, -0.03633890f, -0.00528331f, 
    0.05641961f, 0.06413116f, -0.03716597f, 0.03220307f, -0.02182443f, 0.03355562f, -0.02147307f, 0.02796720f, 
    -0.00199399f, 0.00735976f, 0.04034831f, 0.02331100f, -0.00276480f, -0.06383575f, 0.02748866f, 0.00914916f, 
    -0.04739342f, 0.06152081f, -0.03760768f, 0.03596950f, -0.04535861f, -0.05111176f, -0.00162705f, -0.03471390f, 
    -0.01442672f, -0.03718386f, 0.00110676f, 0.04094448f, -0.02243468f, 0.05786378f, 0.03589916f, -0.06719627f, 
    -0.07431667f, -0.02355018f, -0.04909761f, -0.03445255f, -0.04703166f, -0.01806250f, -0.00009180f, 0.02752140f, 
    -0.04617833f, -0.03128449f, -0.05273085f, -0.04709298f, -0.01596299f, -0.04646635f, -0.04791371f, 0.06836939f, 
    -0.05907051f, -0.07758006f, -0.02191314f, -0.04468543f, -0.06364696f, -0.02300846f, 0.04456340f, -0.05581452f, 
    0.02076782f, 0.04137601f, -0.03224759f, 0.02227184f, 0.05052651f, 0.03195899f, 0.02684079f, -0.03293012f, 
    -0.00919752f, -0.02713884f, -0.04362068f, -0.04869410f, -0.02778404f, -0.02659638f, -0.08151528f, 0.04455698f, 
    -0.03878242f, 0.03743467f, -0.04519829f, 0.03877391f, 0.02447823f, -0.01951151f, -0.06923534f, 0.05700591f, 
    0.03734902f, -0.04709899f, -0.03694627f, -0.06884252f, -0.02707113f, 0.06145164f, 0.02237629f, -0.02890824f, 
    -0.04202598f, 0.06392034f, -0.05447927f, -0.03273081f, -0.02069189f, -0.05005461f, 0.03443439f, -0.07567503f, 
    0.01872495f, 0.00658470f, -0.03946555f, -0.01465899f, 0.05997603f, 0.05691621f, 0.06306084f, -0.01042111f, 
    0.01419434f, 0.05537398f, -0.01601188f, -0.01978520f, -0.01102189f, 0.05213930f, 0.00362773f, 0.03918958f, 
    0.02615497f, -0.02418467f, -0.02200711f, -0.06421060f, -0.06025633f, 0.04646517f, -0.02130592f, 0.00891393f, 
    0.00887799f, -0.05436973f, 0.00263573f, -0.01418109f, -0.04560487f, -0.07264902f, 0.01937102f, -0.05246743f, 
    0.05626089f, 0.05425035f, -0.05764535f, 0.03943871f, -0.04874587f, 0.02846257f, 0.01818303f, -0.03206459f, 
    -0.02889065f, 0.00008328f, -0.00435315f, -0.02727473f, -0.05649671f, -0.03425408f, -0.01385952f, 0.04716090f, 
    0.05144325f, -0.01341128f, -0.04398736f, 0.05809097f, -0.06247990f, -0.00244336f, 0.02710971f, -0.03661576f, 
    0.24300832f, -0.01105010f, 0.03221402f, 0.07812630f, 0.09060852f, -0.06178677f, 0.03299712f, 0.07086828f, 
    0.00057322f, 0.04496001f, 0.14482160f, 0.08802384f, 0.03566298f, -0.15413760f, -0.07928717f, 0.06133109f, 
    0.08482176f, -0.09547408f, 0.05312405f, 0.00343517f, 0.02356909f, -0.03023905f, -0.18560348f, -0.05645483f, 
    0.04282133f, 0.38631389f, 0.15461545f, -0.19545817f, 0.09712400f, -0.17900956f, 0.02473174f, 0.21672291f, 
    -0.12095572f, -0.02168097f, -0.17045696f, -0.15785678f, 0.07942191f, 0.27661327f, -0.02705538f, -0.18931490f, 
    0.12038746f, -0.14947084f, -0.03871406f, -0.09583010f, -0.06002497f, -0.01970741f, 0.04122795f, -0.03647889f, 
    -0.05613270f, -0.13946109f, 0.02292509f, 0.05947194f, 0.07122470f, 0.19515923f, 0.23126571f, 0.27756310f, 
    0.13838091f, -0.04072883f, 0.06219656f, -0.02498974f, 0.08091457f, -0.16619383f, -0.45742190f, -0.16372906f, 
    0.08210868f, 0.13466088f, 0.10123829f, -0.05544302f, -0.15835319f, -0.04417952f, -0.18113916f, -0.24620640f, 
    -0.04658920f, 0.04954615f, 0.16335124f, 0.03222449f, -0.00187292f, 0.05208411f, -0.07443545f, -0.09409786f, 
    0.04211111f, -0.18744618f, -0.12061054f, 0.00817371f, -0.27331775f, 0.15523821f, 0.52959788f, -0.12766255f, 
    -0.13918391f, -0.01092251f, -0.04405838f, -0.01327551f, 0.10113434f, 0.00601017f, 0.13110246f, 0.14096056f, 
    -0.06132264f, 0.31109628f, -0.51245016f, 0.27932674f, 0.02521208f, -0.02706123f, 0.15943821f, 0.10438383f, 
    0.08969437f, -0.11643562f, 0.02247032f, -0.02628092f, -0.21254531f, -0.28964949f, -0.15277483f, 0.20738518f, 
    0.09081185f, 0.03151232f, 0.16482642f, 0.00283548f, 0.07231602f, -0.10699864f, -0.02628905f, -0.01474329f, 
    0.06941580f, -0.08841658f, 0.09016283f, 0.03359473f, 0.01416728f, -0.03939617f, 0.03619988f, 0.12399854f, 
    0.21809100f, 0.09789873f, -0.05439439f, -0.16780110f, -0.30987650f, 0.02761558f, -0.38911363f, 0.05660961f, 
    -0.17784521f, 0.05670103f, -0.06811302f, -0.07566427f, 0.21241465f, -0.31306040f, -0.06225127f, 0.05575204f, 
    0.23395324f, 0.22985658f, 0.20891677f, 0.08224284f, 0.00087189f, -0.13041893f, -0.06231779f, -0.00887381f, 
    0.08663161f, -0.07170235f, 0.08116467f, 0.03703278f, -0.08063447f, -0.18849960f, -0.03821841f, -0.06296092f, 
    0.15743963f, -0.07176218f, 0.12449280f, 0.04626107f, -0.02266751f, -0.11188085f, -0.05493610f, -0.01352380f, 
    -0.04816174f, -0.29955056f, 0.11539499f, 0.21878061f, -0.04971026f, -0.05472455f, -0.04763466f, -0.00907796f, 
    0.07572931f, 0.03381995f, -0.07476513f, -0.13568769f, -0.10721707f, -0.11161723f, -0.08194084f, 0.14987287f, 
    0.15303546f, -0.02864569f, -0.00512832f, 0.13688336f, -0.08018662f, -0.10295594f, -0.20730522f, 0.15100452f, 
    -0.19961989f, 0.06849679f, -0.08153170f, 0.14402503f, 0.02068922f, 0.02149984f, -0.12703857f, -0.02157053f, 
    -0.03099339f, 0.20566551f, 0.05219393f, 0.13200510f, -0.06412986f, -0.03682544f, -0.11793011f, -0.09990800f, 
    -0.04456269f, -0.27807474f, 0.01884412f, 0.05444675f, -0.10571530f, -0.15150966f, -0.11994379f, -0.27716070f, 
    0.01255917f, 0.29963279f, 0.24684760f, -0.15846623f, 0.01534753f, 0.00253153f, 0.02567323f, 0.14766297f, 
    -0.03112199f, 0.03036030f, -0.13603623f, -0.00202407f, -0.10801411f, -0.10623510f, 0.27847901f, -0.06045896f, 
    -0.02137091f, -0.11660928f, 0.07439162f, 0.06553487f, -0.02332996f, 0.09772227f, -0.13925079f, 0.00158036f, 
    0.20285045f, -0.02933002f, -0.00652428f, -0.08365314f, -0.11799226f, -0.18772565f, -0.18536563f, -0.00013831f, 
    -0.07469168f, -0.13741629f, -0.21178244f, -0.06934090f, -0.03098454f, 0.06920601f, 0.40014535f, -0.27236748f, 
    0.04684203f, 0.03214226f, 0.11638048f, 0.16715714f, 0.18604669f, 0.12062928f, 0.07691482f, 0.18004754f, 
    -0.13253891f, -0.01621567f, -0.08920433f, -0.04418782f, -0.15681098f, -0.19810800f, -0.01035131f, -0.10043007f, 
    0.10979497f, 0.01582178f, -0.10537814f, -0.16979146f, -0.21335603f, 0.22031750f, 0.16855423f, -0.21586360f, 
    -0.01143511f, -0.07215331f, 0.09884349f, 0.02137777f, 0.08159145f, 0.03054368f, -0.01899552f, 0.03374885f, 
    0.35022917f, -0.34777293f, 0.28307006f, -0.12644409f, -0.01751921f, -0.00791217f, 0.09207710f, -0.02330008f, 
    0.01218740f, 0.11284493f, 0.03955466f, -0.02390626f, 0.39818779f, 0.11472611f, 0.12217169f, 0.02550786f, 
    0.01625477f, -0.06382268f, -0.15565199f, 0.07387447f, -0.01073886f, -0.00287388f, 0.01118225f, -0.06369650f, 
    -0.07809412f, -0.11312635f, -0.01061491f, -0.06066282f, -0.09327266f, 0.00911331f, -0.06118345f, -0.03523152f, 
    0.09748094f, 0.04286217f, -0.09986015f, -0.00335959f, 0.24394065f, -0.18109259f, 0.02200433f, -0.08461450f, 
    0.29790062f, 0.03822066f, 0.15063092f, -0.21473953f, 0.14216419f, 0.06910811f, 0.13601333f, 0.06317111f, 
    -0.17509647f, -0.07067707f, 0.09738243f, -0.02139346f, -0.12725863f, -0.06743599f, 0.00425966f, 0.07532292f, 
    0.07686675f, 0.23507728f, 0.13024718f, 0.07357781f, 0.30916405f, 0.11374297f, 0.09311763f, 0.11890919f, 
    -0.00858029f, 0.01725575f, -0.07019133f, 0.12496687f, -0.02149688f, 0.18666570f, 0.05196191f, 0.02195580f, 
    -0.09166103f, 0.13253948f, -0.04183140f, -0.04158628f, 0.03984520f, -0.02499849f, -0.13055940f, 0.05982988f, 
    -0.25116238f, -0.02480184f, 0.04057366f, 0.00556157f, 0.12582785f, 0.11879542f, 0.02215449f, 0.06424148f, 
    -0.06442957f, 0.04250799f, -0.04822410f, 0.05267826f, 0.01222624f, 0.05085450f, 0.26676875f, 0.00920591f, 
    -0.14881647f, 0.15612142f, 0.05282499f, 0.11020086f, -0.17346546f, 0.22288324f, 0.04961391f, 0.15710448f, 
    -0.02456730f, 0.09342346f, 0.02011038f, 0.09129269f, -0.33507660f, 0.00188357f, 0.11502120f, 0.04186615f, 
    -0.05752188f, -0.15275709f, 0.01338248f, 0.03537489f, 0.18539754f, 0.09115046f, 0.15229605f, -0.02211362f, 
    0.53368223f, 0.04931063f, 0.09134320f, 0.01065238f, 0.02196298f, -0.24621914f, 0.12081330f, 0.04088763f, 
    0.07274038f, 0.21048754f, 0.00714158f, -0.01510070f, -0.08465278f, -0.42520744f, -0.22449344f, -0.12143691f, 
    -0.05827897f, 0.11010356f, -0.01983522f, -0.13009623f, 0.01324446f, 0.08071548f, -0.03612866f, 0.18970770f, 
    -0.16130985f, -0.27423176f, -0.14473864f, -0.16530661f, -0.07320141f, 0.05515492f, 0.11988114f, -0.06931931f, 
    -0.04811783f, -0.07376740f, -0.03415260f, 0.00877082f, 0.27176464f, -0.29587442f, 0.27967954f, -0.18375126f, 
    0.04110140f, 0.07528985f, 0.05086976f, 0.05983954f, 0.10285857f, 0.17607778f, -0.10485189f, 0.18024524f, 
    -0.08019562f, -0.22169010f, -0.01949458f, -0.23683463f, -0.19377559f, -0.16180968f, 0.08841691f, 0.29083163f, 
    -0.06109828f, 0.02629834f, -0.07050944f, -0.04992050f, 0.26780155f, 0.01491276f, 0.26762071f, 0.05734501f, 
    0.10588514f, 0.10035737f, 0.08241872f, -0.06508082f, 0.09267975f, 0.18242976f, 0.00023947f, -0.11724093f, 
    0.13291784f, -0.53661191f, 0.11589959f, -0.29896030f, -0.05148153f, 0.10562813f, 0.19131164f, -0.03243769f, 
    -0.07483174f, 0.04570154f, 0.00616063f, -0.02390013f, 0.09694920f, 0.10514855f, -0.16793372f, -0.13115907f, 
    -0.11677102f, -0.05263036f, 0.07273723f, 0.06976232f, 0.00942150f, 0.03322378f, -0.03723832f, 0.07828747f, 
    -0.22862214f, -0.17917609f, -0.10668527f, -0.00664680f, -0.11263016f, 0.08102153f, 0.28770909f, 0.04006707f, 
    -0.00894858f, 0.16306685f, -0.07527704f, 0.03212156f, 0.17815110f, 0.06604505f, -0.17949472f, -0.19348738f, 
    -0.18341284f, 0.01249288f, 0.06196955f, 0.06933638f, 0.06737313f, 0.01049848f, 0.03969786f, 0.11546452f, 
    -0.32072082f, -0.02098861f, -0.00141829f, -0.02367897f, -0.09894270f, -0.08794749f, -0.03768288f, 0.11703668f, 
    -0.02568266f, 0.04267180f, 0.07056532f, 0.10135958f, 0.16579264f, 0.02839466f, 0.01370880f, 0.09050358f, 
    -0.06150939f, -0.05006843f, -0.04069505f, -0.05988931f, -0.18225418f, 0.07486105f, -0.11562526f, -0.12039959f, 
    -0.18719687f, -0.19012591f, 0.15027247f, 0.16218276f, 0.04933278f, -0.08361637f, -0.04742893f, -0.03529111f, 
    -0.06996288f, 0.18070388f, 0.06284343f, 0.17108269f, -0.15999818f, 0.11386781f, 0.07235140f, 0.02460521f, 
    -0.13366948f, 0.01967927f, -0.04181285f, -0.04196769f, -0.08599312f, -0.17070727f, 0.02733801f, -0.13443153f, 
    -0.03999062f, 0.06907780f, -0.24202676f, 0.02860136f, -0.04080317f, -0.12597021f, 0.02419754f, 0.05697050f, 
    0.04595155f, 0.05660865f, 0.06092782f, 0.12621294f, 0.17186616f, 0.10879280f, -0.20649765f, 0.00230271f, 
    0.00212139f, 0.00582893f, 0.14188425f, 0.10025150f, -0.09540079f, -0.04498667f, -0.26402497f, -0.21581924f, 
    0.00238817f, 0.03470675f, -0.03553597f, -0.10122778f, 0.18173878f, -0.07958563f, -0.08923735f, -0.07906619f, 
    -0.07342224f, 0.05769743f, 0.08438390f, 0.07161640f, 0.20210202f, 0.25877488f, 0.20590623f, 0.13680339f, 
    0.00817332f, -0.00602404f, 0.12768079f, 0.02198276f, 0.03887044f, -0.01690650f, -0.01960140f, -0.04966917f, 
    -0.16326475f, -0.16972488f, -0.16470841f, 0.02627277f, 0.20595822f, 0.11736479f, 0.17349342f, 0.18982811f, 
    0.10346358f, -0.05483493f, -0.15666112f, -0.19564627f, 0.04250655f, -0.18117414f, -0.31439480f, -0.05484784f, 
    0.03143331f, 0.06064564f, 0.06082642f, 0.15122165f, -0.08710217f, 0.16770628f, 0.14004491f, 0.03159249f, 
    0.03853514f, 0.21069999f, 0.23057619f, 0.08920387f, 0.09561973f, 0.02182426f, 0.10289174f, -0.07332462f, 
    0.03988667f, -0.16538098f, -0.08484144f, -0.06242299f, -0.35192472f, 0.22752097f, 0.22201201f, -0.05360863f, 
    -0.01803404f, 0.10127001f, -0.05278148f, 0.09133824f, -0.09275971f, -0.03427088f, 0.07238806f, 0.06195487f, 
    0.03618725f, 0.00525085f, -0.38494822f, 0.23857798f, 0.09889887f, 0.00218825f, -0.06085130f, -0.02703838f, 
    0.00163283f, -0.02328011f, 0.08193326f, 0.00372745f, 0.24104850f, -0.11758284f, -0.15535329f, 0.04514793f, 
    0.10881995f, 0.06395709f, 0.08407249f, -0.02160120f, -0.06778912f, -0.08966896f, -0.12897028f, -0.09196933f, 
    0.06375542f, -0.00518206f, 0.19087021f, 0.08542177f, -0.03493849f, 0.10997389f, 0.07456402f, 0.05342505f, 
    0.11062820f, -0.04001264f, -0.04637138f, -0.14207785f, -0.32545969f, -0.30758512f, -0.21073520f, 0.07741986f, 
    0.01565549f, -0.03622853f, 0.05522180f, -0.15836067f, 0.06725991f, -0.02838306f, 0.02830956f, 0.08026824f, 
    0.06659583f, 0.30528358f, 0.27576867f, 0.03037702f, -0.01037287f, 0.00835651f, -0.03818121f, 0.01811090f, 
    0.02999745f, 0.04341255f, 0.00018217f, 0.19419764f, 0.09510773f, -0.30629101f, -0.24246880f, -0.02787690f, 
    0.07553712f, 0.04574736f, 0.12605806f, -0.08473490f, 0.07789648f, -0.05931598f, 0.00046265f, 0.00289298f, 
    -0.08303089f, -0.09834103f, 0.00989624f, -0.06631804f, 0.08233922f, -0.02558688f, -0.12149753f, -0.04788879f, 
    -0.00327335f, 0.06050210f, 0.08443008f, -0.00240058f, -0.12891632f, -0.34608227f, -0.02371496f, -0.00125222f, 
    0.07508798f, -0.01818356f, -0.01629801f, -0.00452274f, 0.00165491f, 0.12211729f, 0.07229773f, 0.26190451f, 
    -0.03794704f, 0.15668921f, 0.12375189f, -0.09711202f, -0.03977888f, -0.10810104f, 0.00937550f, -0.11128791f, 
    -0.08043024f, -0.18476453f, -0.07995164f, -0.05316775f, 0.18878150f, 0.02092157f, -0.05237226f, -0.03311896f, 
    0.11960097f, 0.05463241f, -0.06079048f, -0.16008589f, -0.01433764f, -0.27312195f, -0.06366684f, -0.16069156f, 
    0.01728399f, -0.18470228f, -0.26183680f, -0.37084988f, -0.13249478f, 0.10996047f, -0.05163689f, -0.10247185f, 
    -0.06917270f, -0.11497368f, 0.13295668f, -0.13722348f, 0.26580060f, 0.36833757f, 0.02660761f, -0.12358062f, 
    0.10934735f, -0.07300572f, -0.03453761f, 0.30207869f, -0.07809594f, 0.04869528f, -0.00368320f, -0.00285246f, 
    0.23116028f, 0.15915278f, 0.08354744f, 0.10050005f, -0.00499695f, -0.09579866f, -0.11097980f, -0.15880612f, 
    -0.00546037f, -0.03980358f, -0.09845507f, -0.08730055f, 0.11492302f, 0.13904706f, 0.02831138f, 0.07599396f, 
    -0.04528607f, 0.03458020f, -0.03340236f, -0.22008668f, 0.24053772f, -0.16972166f, 0.11340846f, 0.11466679f, 
    0.03045030f, 0.08511988f, 0.01399517f, -0.07044798f, -0.00244994f, 0.23571016f, 0.26369035f, -0.04755060f, 
    0.07729471f, -0.01720190f, -0.06259384f, 0.03725720f, 0.44234025f, -0.00937510f, -0.26741838f, -0.13010508f, 
    0.03287966f, -0.18639979f, -0.08409528f, -0.10041922f, -0.14646140f, -0.04593069f, -0.14381553f, -0.11799228f, 
    0.41881168f, 0.00895043f, 0.08970249f, 0.12881029f, -0.13660346f, -0.19842631f, 0.06559316f, 0.05666022f, 
    -0.04060405f, -0.04631708f, -0.12714794f, -0.10990503f, 0.20853010f, 0.21699867f, 0.20530982f, 0.18347241f, 
    -0.04240924f, -0.04021002f, -0.06417439f, -0.05190977f, -0.05141924f, 0.02483930f, 0.01983286f, 0.02904708f, 
    -0.25731838f, 0.27306962f, -0.06264615f, -0.32799864f, 0.05177255f, 0.05939750f, 0.01806880f, -0.08378642f, 
    -0.14700794f, -0.19614199f, -0.07949842f, -0.06914677f, -0.21420445f, 0.03854587f, 0.13780355f, 0.06668218f, 
    0.14204766f, -0.19439667f, -0.01299358f, -0.04368250f, 0.14897582f, 0.01734155f, -0.02419810f, -0.17174521f, 
    -0.06958544f, -0.37570238f, -0.27469593f, -0.09252580f, 0.15389435f, -0.01366685f, 0.10665570f, -0.01538048f, 
    0.25315681f, 0.01254597f, 0.19592282f, 0.17359099f, 0.24696988f, 0.13532799f, 0.07996397f, 0.06309208f, 
    -0.05775755f, -0.05369838f, -0.00084816f, 0.10594108f, 0.04661796f, 0.13705710f, 0.11605093f, 0.05840382f, 
    0.32996985f, 0.19694766f, 0.10517580f, 0.08993965f, 0.07036240f, 0.03053333f, 0.06208708f, -0.04470234f, 
    0.00403405f, -0.06697903f, -0.17642555f, -0.02651122f, 0.08329625f, 0.05335583f, 0.17879841f, 0.24936028f, 
    0.01204306f, -0.02548306f, 0.06072521f, -0.04649485f, 0.37800574f, 0.07635533f, -0.01115119f, -0.02795755f, 
    0.19300315f, -0.05445804f, 0.28529200f, 0.07295016f, 0.03778166f, 0.09760082f, 0.01291772f, -0.01021447f, 
    0.06848715f, -0.02949931f, -0.04511325f, -0.05677012f, -0.39124680f, -0.00513850f, 0.16211416f, 0.09886036f, 
    -0.26325086f, -0.17362317f, 0.14445600f, 0.04544946f, 0.03244098f, -0.06503713f, 0.04582675f, -0.16499703f, 
    0.22601685f, 0.04410287f, 0.21792534f, 0.00980298f, -0.19286017f, 0.08215253f, 0.00626820f, 0.17972822f, 
    -0.30291057f, -0.06902182f, -0.26851445f, -0.12166141f, 0.07793898f, 0.03218229f, -0.17035556f, -0.40006688f, 
    0.00965735f, -0.16373517f, -0.14702344f, 0.09229452f, -0.01502615f, 0.11349844f, 0.07037959f, 0.14756808f, 
    -0.10604045f, 0.08710795f, -0.03293266f, 0.02474292f, -0.21769102f, 0.00690968f, -0.10423084f, -0.11443628f, 
    -0.01174107f, -0.03036898f, 0.00244705f, -0.07962986f, -0.12621652f, -0.01485615f, 0.16416383f, -0.01301786f, 
    0.04585406f, -0.02517602f, -0.07671989f, -0.16739480f, -0.11231314f, 0.01461238f, -0.02610247f, -0.05576750f, 
    0.17742178f, 0.11725546f, 0.03490779f, 0.13209133f, 0.11091172f, 0.03723361f, -0.09373835f, 0.16046247f, 
    -0.13192129f, 0.01457043f, 0.00123057f, -0.01628249f, 0.56646335f, 0.04923772f, 0.19928022f, 0.26329312f, 
    0.05052616f, -0.05229467f, 0.06302028f, -0.03052278f, 0.17410864f, -0.07505845f, -0.04857573f, -0.02039358f, 
    -0.11578859f, 0.02012317f, 0.12441286f, -0.09048074f, 0.16470082f, 0.02865388f, -0.12297247f, 0.06476422f, 
    0.07459982f, 0.09755623f, -0.00604893f, -0.03879758f, -0.56431448f, -0.23526409f, 0.08731943f, -0.20866901f, 
    0.00529859f, 0.23185037f, -0.01354672f, -0.07282700f, 0.08662227f, 0.06098968f, 0.05289811f, 0.04225558f, 
    0.08484684f, 0.18876368f, -0.15210062f, 0.07907623f, 0.00264022f, 0.05116968f, 0.03156655f, 0.16565359f, 
    -0.01133583f, 0.12262022f, -0.01290764f, 0.06527772f, 0.19682373f, 0.04553646f, 0.17021701f, -0.14780885f, 
    0.31127036f, 0.02369160f, -0.08359829f, 0.08360530f, 0.06128479f, -0.13481022f, 0.18707174f, -0.01309646f, 
    0.20691851f, -0.01340143f, -0.06840021f, 0.18373275f, 0.03071389f, 0.18185775f, 0.12834343f, 0.03455023f, 
    0.00260588f, 0.04976914f, -0.00947886f, 0.12659079f, -0.39172420f, 0.11763366f, -0.00705877f, -0.05869267f, 
    -0.00728159f, 0.03021448f, 0.00500157f, -0.03458198f, -0.20740269f, 0.04755908f, 0.10566176f, 0.16949238f, 
    -0.22936365f, -0.09549176f, -0.21318349f, -0.14352508f, -0.16838640f, -0.01721379f, 0.13378212f, 0.10833758f, 
    0.00743967f, -0.01837663f, -0.11665063f, -0.05899835f, -0.14460585f, 0.00544283f, -0.30057231f, -0.07533082f, 
    -0.00870905f, 0.09399657f, 0.00122835f, -0.00811555f, -0.02461502f, 0.00301698f, 0.01701788f, -0.04060216f, 
    0.01906504f, -0.05943574f, 0.21054713f, -0.14519772f, 0.04837818f, 0.01282851f, 0.03562079f, 0.08242042f, 
    0.00611111f, 0.13642061f, 0.05671249f, 0.05000793f, 0.10603826f, -0.07657509f, -0.14335541f, -0.20131475f, 
    -0.18319629f, 0.08160181f, -0.07988979f, -0.01880596f, -0.02441117f, 0.10868227f, 0.07457978f, 0.01079906f, 
    0.15860999f, 0.13866021f, -0.15436725f, -0.10458307f, 0.06216626f, -0.09470206f, 0.11599854f, -0.10256939f, 
    0.21986908f, -0.08283071f, 0.14515115f, 0.01664766f, -0.12010412f, 0.03482975f, -0.12176738f, -0.11352520f, 
    0.22299008f, 0.08583451f, -0.02528504f, -0.09909373f, 0.14882344f, -0.02170181f, 0.06316950f, 0.02305136f, 
    -0.03920117f, -0.03425745f, -0.17202248f, -0.09913944f, 0.03530120f, -0.09222671f, -0.05936810f, -0.08243930f, 
    -0.04311585f, -0.11646806f, -0.10239238f, 0.05962793f, 0.23583667f, -0.02911113f, -0.13223773f, -0.03421900f, 
    0.14877930f, -0.12210230f, -0.01620303f, 0.11959472f, 0.00949204f, 0.01688572f, 0.05306211f, 0.12042061f, 
    -0.36869463f, -0.21857738f, -0.02983743f, -0.24009907f, -0.00799912f, 0.07851186f, 0.19050136f, 0.06570274f, 
    0.12385156f, 0.12291139f, 0.04252787f, 0.03849250f, -0.41558346f, -0.01323578f, 0.22775231f, -0.06927305f, 
    -0.18206069f, -0.12053581f, 0.00826237f, 0.21434143f, 0.06924788f, 0.06178874f, -0.06202597f, -0.04909626f, 
    -0.07414742f, 0.16008969f, -0.28871217f, -0.02837609f, 0.23819141f, 0.22987032f, 0.08369091f, 0.05868919f, 
    0.01539774f, 0.08915215f, 0.09765001f, -0.00018287f, 0.25552991f, 0.07852122f, -0.09948742f, 0.07642884f, 
    -0.06328746f, -0.06498028f, -0.05507046f, 0.01325031f, 0.04620686f, 0.01524666f, -0.00898487f, -0.01875747f, 
    -0.25735784f, -0.32425863f, 0.20658764f, 0.26828346f, 0.00188023f, 0.14134561f, 0.06098363f, 0.01040034f, 
    0.06646460f, 0.02384604f, 0.05422722f, 0.15011705f, 0.12150373f, 0.09319048f, -0.42030224f, 0.24529968f, 
    -0.10700051f, 0.10414812f, 0.09291292f, 0.11118361f, -0.09144904f, -0.05962727f, 0.08562011f, 0.13039257f, 
    -0.19467658f, -0.00004679f, 0.25688994f, -0.06547581f, -0.02956918f, -0.08037181f, 0.12788539f, 0.10350718f, 
    -0.02332132f, -0.17798224f, 0.02729042f, 0.01050202f, 0.45969790f, -0.02136231f, 0.02133749f, -0.03211064f, 
    -0.04065721f, -0.08754677f, -0.09717969f, -0.03948397f, 0.07596799f, -0.06383488f, -0.06322081f, -0.09083960f, 
    0.22535208f, -0.02139634f, 0.34804079f, 0.03527077f, -0.02091216f, -0.17758515f, -0.04219117f, -0.01063235f, 
    0.00920867f, -0.09920228f, 0.14097801f, 0.10776374f, 0.33447224f, 0.20038445f, 0.20993803f, -0.01122463f, 
    -0.01493097f, -0.14693926f, 0.01698413f, 0.05392718f, -0.07222957f, -0.02377095f, -0.17241733f, -0.00801844f, 
    0.20589964f, -0.00085830f, 0.26656088f, 0.05901600f, 0.06946769f, 0.08135569f, -0.00619609f, -0.06591043f, 
    -0.06478977f, -0.05899113f, 0.06892873f, 0.00794906f, 0.10528973f, 0.01164506f, 0.20232150f, -0.12677772f, 
    0.00814310f, 0.11492006f, -0.14406817f, 0.07818905f, -0.14783876f, -0.07576177f, 0.09269110f, 0.18939370f, 
    0.28658843f, 0.16102940f, 0.02975304f, -0.34373277f, -0.21048751f, 0.20798689f, 0.17309725f, -0.02510610f, 
    -0.00577837f, -0.13430534f, -0.23714727f, -0.01564759f, 0.21621135f, 0.15994334f, -0.37697202f, -0.20322450f, 
    -0.01270372f, -0.06108054f, -0.03329320f, 0.20097156f, 0.00011010f, 0.08245303f, 0.11455866f, -0.01897060f, 
    -0.22190595f, -0.07915987f, -0.10425617f, -0.04344717f, 0.20182487f, 0.10523541f, 0.07578161f, 0.06938273f, 
    0.02075940f, -0.14845979f, 0.07126251f, -0.10711244f, -0.10340656f, 0.01084185f, -0.24223958f, 0.14616801f, 
    -0.05409272f, 0.00797420f, 0.07041015f, 0.03654057f, -0.03309232f, -0.05416467f, -0.08445187f, 0.03157111f, 
    -0.02386335f, 0.18974936f, 0.33218756f, 0.01135362f, 0.00098453f, 0.08625177f, -0.13839850f, 0.00954585f, 
    -0.11424079f, -0.05271006f, 0.05000636f, -0.02860531f, 0.35235560f, -0.17934820f, 0.01815391f, -0.00858117f, 
    0.01962436f, 0.03623841f, 0.02654508f, 0.09971004f, -0.02591892f, -0.05976954f, 0.01774682f, -0.03837735f, 
    -0.46656433f, 0.07055476f, -0.42961225f, 0.14820154f, 0.13657622f, 0.14462760f, 0.17890708f, 0.07973346f, 
    0.10782829f, 0.06886896f, -0.08530543f, -0.09109814f, -0.27563709f, -0.11319758f, -0.17566632f, 0.01053141f, 
    0.09500712f, 0.05190979f, -0.10817973f, -0.02778658f, 0.02817257f, -0.00174104f, -0.02255231f, 0.06843007f, 
    -0.12451981f, 0.10929071f, -0.04526174f, -0.03191302f, 0.01239081f, 0.08088168f, 0.07710304f, 0.15984599f, 
    -0.09371648f, 0.00008595f, 0.00717026f, 0.01925234f, -0.23992619f, 0.57565075f, -0.16608769f, 0.16260304f, 
    -0.06894918f, -0.07429621f, 0.08294692f, 0.10945133f, 0.15988898f, 0.00597898f, -0.01606875f, 0.05500875f, 
    0.30683690f, 0.14762838f, 0.15983425f, -0.03931782f, 0.08308594f, -0.14090103f, -0.03727847f, 0.00637179f, 
    0.07716578f, -0.04363582f, 0.02782872f, -0.02277591f, -0.01942147f, -0.15233217f, 0.04441155f, -0.12458836f, 
    -0.04125989f, 0.16963148f, -0.10865737f, -0.05916711f, 0.05997721f, -0.20929413f, -0.03538825f, 0.06045270f, 
    0.20953482f, -0.00997778f, 0.25187513f, 0.33960217f, -0.00866848f, -0.07188310f, 0.02800887f, -0.08737655f, 
    0.12578510f, 0.03944664f, 0.02970260f, -0.07568301f, -0.06094367f, -0.05876243f, 0.09808323f, 0.13603269f, 
    0.10407574f, 0.03399905f, 0.05963652f, -0.07356492f, 0.04783184f, -0.01203480f, -0.04019485f, -0.00555301f, 
    0.06519133f, -0.11925822f, 0.05644078f, -0.03645226f, 0.04420836f, 0.06356448f, 0.04196898f, -0.03564760f, 
    0.33759379f, 0.15004493f, 0.06957863f, 0.04497394f, -0.03311308f, -0.10099605f, -0.21328324f, 0.03479092f, 
    -0.12658058f, -0.04812399f, -0.11984929f, -0.14703156f, 0.00925528f, 0.10550666f, 0.09909187f, 0.01442951f, 
    -0.59083331f, -0.11573505f, -0.15362442f, 0.34962097f, 0.14877772f, -0.02284408f, -0.17854202f, -0.09886760f, 
    0.11358407f, 0.05352644f, 0.15134977f, 0.18270431f, -0.11972614f, 0.10541069f, 0.22441623f, 0.17919955f, 
    0.06553391f, 0.10927971f, -0.00981909f, -0.14230663f, 0.06331065f, 0.02618644f, 0.01714288f, -0.05196393f, 
    -0.11957570f, 0.12829034f, 0.16892093f, -0.13530031f, -0.01912936f, -0.15662268f, -0.20699018f, -0.08645979f, 
    -0.09031017f, 0.15860280f, -0.05914146f, 0.00574812f, -0.23550178f, 0.25996304f, -0.03119108f, 0.13632818f, 
    -0.10310853f, 0.11502429f, -0.10593381f, 0.16308473f, -0.08624322f, -0.00835882f, 0.04890976f, -0.10264027f, 
    0.11060860f, -0.10973856f, -0.25503433f, 0.06954847f, 0.15601727f, 0.24168324f, 0.09502379f, 0.11751313f, 
    0.09145678f, 0.21919017f, -0.04682441f, -0.04005215f, -0.05890691f, 0.03343904f, -0.42172194f, -0.06508666f, 
    0.10077439f, 0.02204375f, 0.03797961f, -0.02841761f, 0.00624155f, -0.07942349f, 0.04904991f, -0.03178774f, 
    -0.02206582f, 0.19751583f, 0.41488945f, 0.10778279f, 0.15760642f, 0.02530919f, -0.22433244f, 0.10092462f, 
    0.02188141f, -0.00364877f, 0.11930243f, 0.04467709f, -0.16324218f, 0.10990251f, 0.29007357f, 0.04479469f, 
    0.20357709f, -0.03238561f, -0.20861049f, -0.06169007f, -0.00243624f, 0.02394475f, -0.05055171f, 0.10471845f, 
    0.31638411f, 0.03967902f, 0.02519604f, 0.07561602f, 0.12598997f, 0.01053148f, 0.09521902f, -0.00393291f, 
    0.04517360f, -0.01315146f, 0.10152656f, 0.16692764f, 0.26128697f, -0.34637150f, 0.29254892f, 0.24496585f, 
    0.13603082f, 0.16382852f, -0.03398898f, 0.22386903f, -0.14194764f, -0.04340086f, 0.09570995f, 0.04903658f, 
    0.00373272f, -0.21614069f, -0.04317579f, -0.09714212f, 0.15058251f, 0.31384754f, 0.23476774f, -0.07436398f, 
    -0.09282088f, -0.01034885f, 0.01038398f, -0.14066483f, -0.35866880f, 0.09626018f, 0.16877909f, 0.02134254f, 
    -0.00807590f, 0.03900703f, -0.12478554f, -0.17111355f, -0.07735167f, 0.12574311f, -0.07233203f, -0.06488576f, 
    -0.20623815f, 0.06490830f, -0.24972722f, -0.21258713f, -0.10837495f, -0.08384077f, 0.01672164f, 0.07047149f, 
    0.12158455f, -0.02822007f, 0.18250461f, 0.21594322f, 0.13680340f, 0.10260297f, 0.01579653f, -0.13033375f, 
    0.00944363f, -0.09564239f, -0.02358804f, -0.05159831f, -0.01261775f, 0.13043642f, 0.19687095f, 0.07812764f, 
    -0.13851541f, 0.05956683f, -0.27302870f, 0.10246391f, 0.09505139f, -0.06875696f, -0.11526961f, 0.13565598f, 
    -0.03384566f, 0.06885535f, 0.07988534f, 0.17923433f, -0.08497698f, 0.06898693f, -0.00144799f, 0.05481813f, 
    0.11330698f, -0.08787098f, -0.03507758f, -0.12911160f, -0.20024669f, -0.08061963f, -0.18143307f, -0.14437328f, 
    -0.03704809f, -0.06095637f, 0.26978740f, 0.17710213f, -0.00552547f, -0.18990231f, 0.01175106f, 0.20621899f, 
    -0.11318077f, 0.17908159f, -0.00779325f, 0.06961057f, -0.18337198f, -0.14785306f, 0.11296985f, 0.20255333f, 
    -0.02852167f, 0.06774776f, 0.14878789f, 0.03997023f, 0.09039507f, 0.12863967f, -0.07224850f, -0.00871187f, 
    0.02706748f, -0.16662239f, -0.12213351f, 0.02083698f, 0.11421221f, 0.00963739f, 0.02439325f, 0.12590928f, 
    -0.21737462f, -0.08939520f, -0.22093187f, -0.30880934f, -0.12999432f, -0.03460656f, 0.15006927f, -0.07989495f, 
    -0.18739784f, 0.15284710f, 0.09867828f, 0.09200114f, 0.15220144f, 0.33177868f, 0.16372842f, 0.15719938f, 
    -0.07993814f, 0.15349768f, -0.10680126f, -0.11552511f, -0.01399184f, -0.27606004f, -0.09882148f, -0.19235179f, 
    0.03558008f, -0.06994011f, -0.12584920f, -0.28504452f, -0.14472280f, 0.28886372f, 0.11567853f, 0.02367041f, 
    -0.00140595f, 0.01332524f, 0.11323638f, 0.07749245f, -0.14851360f, 0.02375826f, 0.01205438f, 0.10520384f, 
    0.18360361f, -0.33963874f, 0.09632816f, -0.07192602f, -0.05371832f, 0.11363965f, -0.08870924f, 0.02646488f, 
    0.08865367f, -0.01438054f, 0.03402684f, -0.08342847f, 0.24747096f, -0.06116090f, -0.22937989f, 0.01936168f, 
    -0.13299438f, 0.01352500f, 0.06933093f, 0.01347660f, -0.20480192f, -0.07144085f, 0.04212281f, -0.03040462f, 
    0.06574497f, -0.12471297f, 0.05171672f, -0.13658871f, -0.12801677f, -0.09013364f, -0.06773098f, -0.12199096f, 
    0.02687350f, -0.03069160f, -0.09672596f, -0.16373950f, 0.14835703f, 0.06552261f, 0.01200985f, -0.03936023f, 
    -0.00847881f, 0.07064065f, 0.12664668f, -0.19811283f, 0.11948374f, 0.13034907f, -0.08104163f, -0.00848400f, 
    0.05714343f, 0.01383287f, -0.01700458f, 0.03227885f, -0.19044918f, -0.20216915f, -0.02446894f, -0.13213852f, 
    0.03781685f, 0.20258157f, 0.05996207f, 0.03976072f, -0.09732050f, 0.00506975f, -0.06709712f, 0.11262052f, 
    -0.07135000f, 0.08469813f, 0.12688115f, 0.19722477f, -0.04741735f, 0.01079228f, -0.01900223f, -0.06102095f, 
    -0.06415164f, 0.17382859f, -0.11188497f, -0.15897708f, 0.24135306f, 0.05561370f, -0.10150846f, 0.05216809f, 
    -0.20220108f, 0.04829611f, 0.07478358f, -0.04408506f, -0.13024229f, -0.08064260f, -0.04827561f, -0.08254583f, 
    0.04812287f, -0.04122515f, 0.01504094f, 0.05107294f, 0.00510350f, -0.03410461f, 0.09330143f, 0.00508722f, 
    -0.00909997f, -0.07219494f, 0.38663727f, -0.15278347f, 0.06512537f, 0.01646836f, 0.02974286f, -0.04014045f, 
    0.06309365f, 0.01408298f, 0.06981631f, -0.01720299f, 0.34190476f, -0.02818457f, 0.00836854f, -0.01597223f, 
    0.01858416f, 0.15147957f, -0.14634846f, -0.03351563f, 0.02786732f, 0.14146885f, 0.10300590f, 0.13176347f, 
    0.06857134f, -0.00334654f, -0.16008018f, 0.07496858f, -0.00065730f, 0.09664742f, -0.06354624f, -0.01934656f, 
    0.14379162f, -0.01252364f, -0.01687864f, 0.34022152f, -0.19927557f, 0.02172747f, 0.09625875f, 0.35840830f, 
    0.03960373f, 0.23776823f, -0.05635276f, 0.02846768f, 0.06147298f, -0.06389599f, -0.07563221f, -0.10157765f, 
    -0.52876741f, -0.23304759f, 0.13435993f, -0.07225195f, 0.06939896f, 0.06479769f, -0.07318930f, 0.23040903f, 
    -0.04850850f, 0.00039296f, 0.18688834f, -0.04730523f, -0.18960820f, 0.08729541f, -0.15748057f, 0.25754395f, 
    -0.12909111f, 0.01577927f, -0.12073467f, -0.18698776f, -0.03356431f, -0.07583635f, 0.05935925f, -0.16456251f, 
    -0.00309816f, 0.15407452f, -0.06904100f, -0.07752334f, 0.10729007f, 0.19868480f, 0.20377989f, 0.07395882f, 
    -0.03156035f, -0.07918656f, -0.11621340f, 0.02205918f, 0.07890662f, 0.33691880f, -0.07700115f, -0.02937501f, 
    -0.06053983f, 0.04037758f, -0.04936997f, 0.05524586f, -0.13518494f, 0.16374841f, -0.02169435f, 0.01502065f, 
    -0.21209925f, -0.00785920f, 0.28274760f, 0.07999482f, -0.14383389f, 0.21275869f, -0.00965386f, 0.13142243f, 
    0.17131412f, -0.04826536f, -0.10390446f, -0.09812183f, -0.29882732f, -0.29858083f, -0.07795665f, 0.14439653f, 
    -0.14326300f, 0.03807602f, -0.09777950f, -0.11913800f, -0.02596948f, 0.06839529f, -0.00502682f, -0.14074779f, 
    0.19736029f, 0.09035370f, 0.06492492f, -0.07716241f, 0.21447527f, 0.12687340f, 0.13164480f, 0.07734887f, 
    -0.05999647f, 0.02082228f, -0.07058550f, 0.03309974f, 0.14977989f, 0.30105257f, -0.03840226f, 0.32563004f, 
    -0.29448232f, 0.26529777f, -0.19802344f, 0.04101588f, 0.04010099f, -0.00959112f, -0.23975864f, -0.06092354f, 
    0.34685355f, -0.04418663f, 0.00515664f, 0.05013102f, 0.11122122f, -0.08625879f, -0.08863891f, -0.05904626f, 
    -0.02852052f, -0.08725455f, -0.13932937f, 0.09471226f, -0.24810024f, -0.06880595f, -0.10549530f, -0.08065612f, 
    0.08728492f, 0.07660967f, -0.18553406f, -0.07560956f, 0.11766108f, -0.23601021f, -0.12108840f, -0.03653480f, 
    0.23331037f, 0.18432522f, -0.00276641f, -0.16111147f, -0.01546879f, -0.17085598f, -0.07455556f, -0.19496678f, 
    0.00777482f, 0.08573908f, 0.13170931f, -0.06160821f, -0.01105601f, -0.05836737f, 0.07993535f, -0.10216671f, 
    0.12526251f, -0.15170486f, -0.08278020f, -0.10374884f, -0.03917335f, 0.06965016f, 0.04435633f, -0.01297790f, 
    0.23103651f, 0.03796675f, -0.16322850f, 0.08942086f, -0.06786568f, -0.15159033f, 0.00272231f, -0.06710047f, 
    -0.01365549f, -0.12429024f, 0.00100334f, -0.03133629f, 0.15908581f, 0.04135821f, 0.02031129f, -0.03274028f, 
    0.08013242f, 0.00126596f, 0.11155142f, 0.01967915f, -0.03231142f, -0.06568868f, -0.12034801f, 0.00017553f, 
    0.15703450f, -0.06982376f, -0.17835918f, -0.40646094f, 0.00553728f, 0.05412797f, -0.05040407f, -0.04383279f, 
    -0.05894138f, -0.08855280f, 0.13338669f, -0.10408705f, 0.23939463f, 0.39798069f, 0.13369906f, -0.06688764f, 
    0.17871679f, -0.12257034f, 0.06489945f, 0.14404629f, -0.01804263f, -0.02948392f, 0.13233696f, -0.10322622f, 
    0.05945019f, 0.01748438f, -0.07918379f, 0.09421060f, -0.05307246f, 0.02126176f, 0.01530594f, 0.03564489f, 
    0.08843935f, -0.03894525f, 0.00880958f, 0.04543143f, 0.27494144f, 0.07932325f, -0.28573084f, -0.03030428f, 
    0.13500246f, 0.01144370f, 0.02656599f, 0.02697372f, 0.01970245f, -0.05447781f, -0.02644742f, -0.04357886f, 
    -0.03689707f, 0.19956636f, 0.28010112f, 0.16262054f, 0.05679115f, 0.21882026f, 0.07257970f, -0.01239221f, 
    0.10194054f, -0.06251513f, 0.09386012f, 0.10000572f, -0.14530857f, -0.04438008f, 0.07372839f, -0.22460356f, 
    -0.07792101f, -0.02550254f, -0.05191731f, 0.14449970f, 0.00686066f, -0.07398200f, 0.03233365f, 0.03801909f, 
    0.04758656f, 0.22445656f, -0.39425138f, 0.40148869f, 0.13881773f, -0.24666962f, 0.07752644f, -0.07285150f, 
    0.03587989f, -0.00656796f, 0.04097455f, -0.05346607f, 0.11987369f, -0.01408692f, 0.01471731f, -0.00351364f, 
    -0.14613016f, -0.06041187f, 0.01615826f, 0.03189544f, 0.04865289f, -0.06963500f, -0.04221943f, 0.02967341f, 
    -0.11349218f, 0.12115400f, 0.15949121f, 0.03997414f, -0.03849754f, -0.01070375f, -0.13587983f, 0.09581223f, 
    0.00242213f, 0.01015308f, -0.00920742f, -0.06412672f, -0.46628797f, -0.12954287f, 0.00797361f, -0.01863241f, 
    -0.01958942f, -0.17566480f, 0.01929877f, -0.17217234f, 0.03801160f, -0.01339812f, -0.02607812f, 0.01800581f, 
    0.13023500f, 0.06393841f, 0.03673329f, 0.01352388f, -0.06864611f, -0.03626796f, -0.07434148f, -0.06557035f, 
    0.18271279f, -0.08786002f, -0.06119486f, -0.06453848f, 0.27794799f, -0.06360084f, -0.14341515f, -0.03938310f, 
    0.08766366f, -0.01439147f, 0.03620673f, 0.01409533f, 0.11611076f, -0.11571699f, 0.12773944f, -0.03165121f, 
    0.27463025f, -0.09138901f, 0.09544533f, 0.15514404f, -0.05933027f, -0.05062580f, 0.05724381f, -0.06987428f, 
    0.09689990f, -0.14367245f, -0.08833101f, -0.09088364f, 0.11396169f, -0.12229052f, 0.07104336f, 0.13342007f, 
    0.05580662f, 0.03683441f, 0.03117533f, 0.01903467f, 0.08834577f, 0.05263609f, -0.06457391f, 0.09725630f, 
    -0.07266895f, 0.08099779f, -0.20966554f, 0.00880758f, -0.04439687f, 0.00891069f, 0.02004236f, 0.18516594f, 
    0.22356522f, 0.16340062f, 0.06837904f, 0.11477387f, -0.10721386f, 0.03350317f, -0.17102571f, 0.00178087f, 
    -0.13531715f, -0.00617760f, 0.02929944f, 0.02495760f, -0.03146278f, 0.17235218f, -0.07018504f, -0.08336844f, 
    0.06991389f, -0.07674412f, 0.12287026f, 0.26017132f, 0.12114530f, -0.08280986f, 0.11308286f, -0.14595990f, 
    0.01693799f, 0.06297665f, 0.10702118f, -0.12505800f, -0.13012153f, -0.30961677f, 0.02553942f, 0.02360666f, 
    0.13176470f, 0.09127391f, 0.03424507f, -0.27347076f, 0.11777760f, 0.00763657f, -0.06588398f, 0.14947626f, 
    0.05814106f, -0.11808699f, -0.11315469f, -0.09415461f, 0.13091643f, -0.04260321f, -0.01988390f, 0.00262534f, 
    -0.07361905f, 0.12433776f, -0.09826424f, 0.05264229f, 0.19007565f, -0.12475521f, 0.14066847f, -0.20169386f, 
    0.00181199f, 0.10510888f, -0.03862207f, 0.05409359f, 0.07851864f, 0.12086413f, -0.04576154f, 0.02447773f, 
    -0.18827221f, -0.33931938f, -0.22752373f, -0.16153550f, -0.14131376f, -0.29036528f, 0.02423105f, 0.03600144f, 
    -0.07331023f, 0.02215071f, -0.01101683f, -0.21861072f, -0.34597671f, -0.04215537f, 0.13107133f, -0.09357984f, 
    -0.07637047f, 0.14138515f, 0.00900722f, -0.03994450f, 0.01103616f, 0.01923217f, -0.01990547f, -0.14526135f, 
    0.07101656f, -0.11862017f, -0.01081056f, -0.12385451f, 0.09259564f, 0.09056925f, -0.08704883f, -0.10795717f, 
    -0.00892551f, -0.04744649f, 0.13436630f, -0.02102952f, 0.27375767f, 0.16854344f, -0.06795195f, -0.08436111f, 
    -0.01607474f, 0.00449665f, 0.13716033f, 0.07631866f, -0.00249576f, 0.13471104f, -0.02158272f, -0.02837889f, 
    -0.08470634f, -0.27940163f, 0.17637059f, 0.19205081f, -0.13684627f, -0.06440591f, 0.07865252f, 0.13192560f, 
    -0.04351498f, -0.01769357f, 0.04283666f, 0.06099427f, 0.13976680f, -0.22784020f, -0.02037465f, -0.06617597f, 
    0.10376458f, 0.05742596f, 0.04439644f, 0.04558282f, -0.05054287f, 0.08352066f, 0.09270103f, 0.13682024f, 
    -0.39675057f, 0.07364696f, 0.02499994f, -0.22770607f, -0.14734127f, 0.10763722f, -0.00659904f, 0.15155751f, 
    -0.00382336f, 0.00154726f, -0.01755380f, -0.07237706f, -0.02537378f, -0.00845743f, 0.10007340f, 0.05336362f, 
    -0.03453233f, -0.06445970f, 0.10991371f, -0.11431208f, -0.01236929f, 0.12901478f, -0.07347916f, -0.10303278f, 
    -0.14288315f, -0.02586731f, 0.08429475f, -0.18684198f, -0.04808092f, 0.08845380f, -0.00205130f, 0.12497895f, 
    -0.02379130f, 0.11463271f, 0.16182017f, 0.13157263f, 0.07553672f, 0.18282169f, 0.05869575f, -0.18340041f, 
    0.07801887f, 0.02266461f, -0.02633736f, -0.03572479f, -0.06175582f, -0.01298361f, -0.08199044f, 0.09176361f, 
    0.16805410f, -0.22097063f, 0.05046020f, -0.10439983f, 0.00801660f, -0.02292652f, -0.12048457f, 0.00956382f, 
    -0.03140491f, 0.21651785f, 0.10983998f, 0.09353020f, -0.02417484f, 0.09074853f, 0.15216947f, 0.00536110f, 
    0.06439289f, -0.02821240f, -0.12865382f, 0.04468184f, -0.10783236f, 0.00443731f, -0.10094965f, 0.04274498f, 
    0.27882153f, 0.23580770f, 0.10428983f, -0.18317288f, -0.01939304f, -0.27202034f, -0.02561509f, -0.17828384f, 
    -0.01465655f, 0.27514380f, 0.26905560f, -0.15527382f, 0.30278203f, -0.05413973f, -0.21843748f, 0.16183831f, 
    -0.02285175f, 0.15620472f, 0.19774592f, -0.20123294f, -0.07250170f, -0.00869632f, -0.02072254f, 0.07916931f, 
    -0.08406604f, -0.09485693f, -0.08345653f, 0.05049483f, 0.23454560f, 0.12161798f, 0.22311430f, 0.01833951f, 
    0.05143274f, -0.04183285f, 0.00196222f, -0.01373188f, -0.23399800f, -0.17824069f, -0.12865016f, -0.11551722f, 
    -0.21133651f, 0.02084293f, 0.34773514f, 0.12811561f, 0.26197413f, 0.34562731f, -0.31792951f, -0.12060784f, 
    -0.22928789f, -0.13227542f, 0.08587410f, -0.17041971f, 0.06827624f, -0.16085786f, -0.04571757f, -0.14574911f, 
    -0.28529403f, -0.06349798f, -0.14109036f, -0.23886517f, 0.14653753f, -0.25978485f, -0.25721896f, -0.28296161f, 
    0.03832423f, 0.21705835f, 0.07795686f, 0.07293032f, -0.00194759f, -0.16809690f, 0.04895883f, -0.05955556f, 
    -0.36536565f, -0.14397947f, -0.34096646f, 0.09428953f, -0.08491892f, 0.06996584f, 0.00968566f, -0.19667754f, 
    -0.09193911f, -0.10102432f, 0.20414017f, -0.13564971f, 0.23019747f, 0.25160801f, -0.17131929f, -0.01804287f, 
    0.05470019f, -0.01091244f, 0.07025304f, 0.06633873f, -0.06079042f, -0.06001696f, 0.09885872f, 0.15599601f, 
    -0.20723985f, -0.01659603f, -0.12445094f, 0.07639916f, -0.03913572f, -0.05439402f, -0.02223963f, 0.00053464f, 
    -0.05014899f, -0.24077684f, -0.01725069f, -0.08286516f, -0.42412916f, 0.40063292f, -0.43913373f, -0.02053932f, 
    -0.20296761f, -0.02395636f, 0.00214284f, -0.03652471f, 0.08650171f, -0.03899601f, 0.14180110f, 0.21314438f, 
    -0.18239702f, 0.11948771f, 0.24817935f, -0.25470498f, 0.06850246f, 0.09497268f, -0.06434091f, 0.10251918f, 
    0.02314109f, 0.13588938f, -0.01791064f, -0.20130938f, 0.03992220f, -0.15066819f, -0.04600469f, -0.03333826f, 
    -0.03978207f, 0.18633056f, 0.03930426f, -0.03765132f, 0.07730309f, 0.07505781f, 0.01214856f, 0.09089293f, 
    0.02782160f, -0.10052604f, 0.39942500f, 0.18626410f, 0.14973587f, 0.10213339f, -0.09690003f, 0.03695286f, 
    0.10692395f, 0.26871333f, 0.07680658f, 0.10843258f, 0.04636103f, -0.04442799f, 0.07258293f, 0.08926165f, 
    -0.08838838f, 0.09050184f, 0.00026868f, 0.05581987f, 0.11116057f, 0.20782754f, 0.04534794f, 0.31887877f, 
    -0.31544811f, 0.18285941f, -0.01652687f, -0.00250410f, 0.02074041f, 0.04913933f, -0.00516635f, 0.03900979f, 
    -0.06209617f, -0.06357092f, -0.20909977f, -0.03896783f, -0.10445084f, 0.07077732f, 0.03549257f, -0.11936112f, 
    0.08780597f, 0.05484091f, -0.04638205f, -0.02245184f, 0.12717906f, 0.21518658f, 0.18771914f, 0.08914747f, 
    0.10902487f, -0.36386031f, 0.08710282f, 0.12724559f, 0.14282168f, 0.07052618f, 0.07615453f, -0.09095006f, 
    0.00244522f, 0.14063838f, 0.04278631f, 0.14563312f, 0.11295054f, -0.03217107f, 0.05584989f, 0.20954937f, 
    -0.05239329f, 0.15275557f, -0.12028905f, -0.00943703f, -0.08946466f, -0.05058851f, -0.01624941f, -0.00987523f, 
    0.08189569f, 0.10352837f, -0.07315423f, -0.11321603f, 0.05479183f, 0.13112782f, -0.05889622f, -0.11005055f, 
    0.13418294f, 0.19801460f, 0.10703044f, 0.08863933f, 0.07792366f, -0.06966055f, 0.01821129f, 0.10745656f, 
    -0.02843724f, -0.01146481f, 0.04474200f, -0.04696608f, -0.06738693f, -0.12849410f, 0.11623219f, -0.09385984f, 
    0.27931336f, 0.15446229f, 0.06856455f, 0.10443999f, -0.08645085f, -0.14055309f, 0.02609797f, 0.04369781f, 
    -0.03388140f, 0.06679939f, 0.01518616f, -0.03867795f, 0.31691149f, 0.21419230f, -0.12499487f, 0.29324660f, 
    0.16673557f, 0.07938398f, 0.10888599f, -0.05694963f, -0.10511749f, 0.03316109f, -0.10157304f, 0.03616257f, 
    0.39311865f, -0.26417029f, 0.35511744f, 0.03978136f, 0.10846253f, -0.22011182f, -0.01363526f, -0.00642632f, 
    0.01206728f, -0.09539413f, -0.05668644f, -0.09579985f, -0.18230669f, 0.02676580f, -0.15353508f, -0.09739388f, 
    -0.01240697f, 0.00905104f, -0.06454084f, -0.02459829f, 0.01150038f, 0.19710083f, 0.01829102f, 0.09962065f, 
    0.16771628f, 0.28471369f, 0.20860843f, 0.13828519f, 0.01559945f, -0.23209636f, 0.01972887f, 0.02100212f, 
    -0.16805662f, -0.14334707f, -0.15508755f, 0.05110864f, 0.29033235f, 0.06672256f, 0.34364370f, 0.02949311f, 
    0.11691937f, -0.16141273f, 0.18941273f, 0.05739758f, -0.01092536f, 0.19930810f, -0.12636144f, -0.16072841f, 
    -0.12609588f, -0.17561646f, -0.18093997f, 0.07204809f, 0.20634784f, 0.06448393f, 0.12817557f, 0.15882719f, 
    -0.12940876f, 0.03820840f, -0.16713428f, -0.03873054f, -0.28424227f, -0.12874550f, -0.02471537f, -0.13659965f, 
    -0.11904095f, 0.13170490f, -0.02431862f, -0.03962128f, -0.05968865f, 0.12096563f, 0.15065439f, -0.12587534f, 
    -0.26125115f, 0.00618583f, -0.30562258f, -0.37024054f, -0.07145786f, 0.08104897f, -0.02996139f, -0.00107190f, 
    -0.01971840f, 0.14564680f, 0.01961228f, 0.14233302f, -0.38304096f, -0.11733051f, -0.20292014f, -0.30916271f, 
    -0.13520825f, -0.05440176f, 0.04184831f, -0.03593442f, -0.05291680f, -0.15354714f, -0.05595353f, -0.09290410f, 
    0.12515271f, -0.08931895f, 0.27031711f, 0.01919634f, 0.07724297f, -0.05968553f, 0.10731540f, -0.12377113f, 
    0.06084371f, -0.05261712f, -0.03642941f, -0.02777004f, -0.20964020f, -0.15746613f, -0.08546553f, -0.04507466f, 
    -0.05851422f, 0.07482218f, -0.18414637f, -0.20860919f, 0.09938251f, 0.14092296f, 0.21045838f, 0.17470072f, 
    -0.10013729f, -0.27488992f, -0.35296187f, 0.07332683f, 0.07513252f, 0.23850767f, -0.02419604f, -0.05862562f, 
    0.14232673f, 0.04415940f, -0.04616290f, 0.19284672f, 0.01684148f, 0.10067625f, -0.10060284f, -0.16004498f, 
    -0.02510134f, 0.02221549f, -0.11231446f, 0.00754717f, -0.01090002f, 0.04006191f, 0.03945404f, -0.05261096f, 
    -0.15229255f, -0.03884527f, 0.19169171f, -0.11136221f, 0.07097135f, 0.05177079f, -0.17783111f, -0.18303753f, 
    -0.02282191f, 0.05259813f, 0.12372144f, 0.10591542f, -0.14354117f, 0.22053300f, -0.00054086f, 0.08433571f, 
    0.01227161f, 0.04427906f, -0.06571513f, -0.01874390f, -0.03793665f, -0.06265163f, 0.14537182f, 0.03280438f, 
    0.13656795f, 0.01664787f, 0.10785641f, 0.07170729f, 0.16576107f, 0.14722392f, 0.04150531f, 0.19378561f, 
    0.00596028f, 0.10625987f, -0.01740421f, 0.18791118f, 0.44468874f, 0.08207101f, -0.30017245f, -0.03346993f, 
    0.17377308f, 0.05886595f, 0.14297406f, -0.05878330f, -0.08882128f, -0.00140758f, -0.01100424f, -0.00664955f, 
    -0.09364683f, 0.17105706f, 0.25094819f, 0.06452009f, 0.11877529f, 0.11728432f, -0.06150464f, 0.11613557f, 
    0.04941293f, 0.01340257f, -0.01219237f, 0.07287407f, -0.35608703f, -0.13990654f, 0.27511442f, 0.14088960f, 
    0.13681994f, 0.07061784f, -0.16399643f, -0.11525986f, 0.08764464f, 0.09995921f, -0.08503372f, 0.10980976f, 
    0.13875015f, 0.16079174f, -0.02521025f, 0.02310316f, 0.15851155f, 0.01750278f, 0.14260523f, 0.09057527f, 
    0.00959101f, -0.05326687f, 0.04715414f, 0.20546021f, 0.15969890f, -0.02303400f, 0.26748097f, 0.16336116f, 
    0.15283185f, 0.02141548f, -0.06376260f, 0.28341454f, 0.04914612f, -0.08744774f, -0.07806620f, 0.01345709f, 
    0.19594035f, -0.00130454f, -0.12677890f, -0.07455399f, 0.15183821f, 0.04093280f, 0.03620773f, -0.00491902f, 
    0.01061281f, -0.05006291f, 0.01958637f, -0.00828274f, -0.26768178f, -0.01381005f, 0.01325254f, 0.01100490f, 
    -0.01842758f, 0.02337370f, -0.13974327f, -0.06568759f, -0.16065370f, 0.01779137f, -0.05183822f, -0.06644049f, 
    0.00355515f, -0.02165439f, -0.19619225f, -0.04030485f, -0.15241349f, -0.06394547f, -0.01337086f, -0.14204903f, 
    0.16824442f, -0.00860688f, 0.01820295f, 0.03170422f, -0.02113030f, 0.15545520f, 0.11506738f, 0.11685872f, 
    -0.05972092f, -0.10811500f, -0.13636190f, -0.08758966f, -0.07725193f, -0.12039256f, 0.03142625f, -0.09509543f, 
    0.04988233f, 0.02466462f, 0.06137200f, 0.10190494f, 0.03118768f, -0.05500229f, -0.04951513f, -0.16605753f, 
    0.06867118f, -0.04000207f, 0.01772596f, 0.20508562f, 0.22228275f, 0.01374103f, 0.18857594f, -0.03165167f, 
    0.03793671f, -0.03787161f, 0.04684119f, -0.10082632f, -0.33965278f, -0.18733144f, -0.37567115f, -0.33518115f, 
    -0.18751252f, 0.44302502f, 0.29674605f, 0.08384179f, -0.02402317f, -0.09777247f, -0.16872434f, 0.08073976f, 
    -0.00469886f, 0.00065655f, -0.02799398f, -0.10645155f, -0.27796072f, 0.17341305f, 0.34906512f, 0.13501231f, 
    0.00269814f, 0.00293546f, 0.16868369f, 0.21922897f, 0.13715909f, -0.00053019f, -0.04820050f, -0.02359518f, 
    -0.03675895f, -0.06631703f, -0.09156620f, -0.01631154f, 0.13187356f, 0.02895437f, -0.10717615f, 0.16276804f, 
    -0.26924056f, -0.17087497f, -0.18975778f, -0.54040575f, -0.10889104f, 0.19587205f, 0.05632403f, -0.06805409f, 
    0.01749744f, 0.09826175f, 0.03847118f, 0.17172889f, 0.07860730f, 0.36640146f, 0.26732185f, 0.04354872f, 
    -0.08134513f, 0.08919718f, 0.01163475f, 0.12603520f, 0.02099750f, -0.18166260f, 0.00274207f, -0.12455950f, 
    -0.14348528f, -0.15246342f, -0.20833579f, -0.27979028f, -0.13818102f, 0.30823368f, 0.32834396f, 0.03486199f, 
    0.10512475f, 0.10250516f, 0.12268268f, 0.09281628f, 0.01576878f, -0.11047859f, 0.13088639f, 0.06835711f, 
    0.06845805f, 0.07144256f, 0.01285205f, -0.01788616f, 0.06876491f, -0.01320809f, -0.15008110f, 0.02803961f, 
    -0.01291151f, 0.05320577f, -0.08309207f, -0.11321835f, -0.09327503f, -0.16166168f, 0.05658855f, 0.04550648f, 
    -0.00357374f, 0.09458398f, -0.07097865f, -0.10274781f, -0.15340415f, -0.09573943f, -0.06020287f, -0.17731450f, 
    0.19676608f, -0.08881533f, -0.07841956f, -0.13891684f, 0.05521333f, 0.01161150f, -0.05425052f, -0.08844037f, 
    0.10685162f, -0.04949141f, -0.14321795f, -0.24505021f, 0.17546289f, 0.12925695f, -0.11149544f, 0.08286821f, 
    0.07029758f, 0.21490578f, -0.06411362f, -0.13295968f, -0.02134843f, 0.06676763f, -0.00129563f, 0.15446509f, 
    0.19462569f, -0.02578541f, 0.21509060f, 0.11329890f, -0.16949514f, -0.13964097f, 0.05561442f, -0.05574919f, 
    0.18241404f, 0.07495211f, 0.05720764f, 0.13852134f, -0.26750353f, 0.06533759f, -0.08161559f, -0.08283194f, 
    -0.00065902f, -0.10714912f, -0.02539760f, 0.07351241f, 0.16682243f, 0.06202468f, 0.09410703f, 0.20591670f, 
    0.08970289f, 0.16534437f, 0.04427329f, -0.13820052f, 0.02076080f, -0.02644482f, -0.14589447f, -0.07786503f, 
    -0.07268793f, -0.00887485f, 0.04104458f, -0.15291966f, 0.08028815f, 0.01466673f, 0.03584905f, -0.10579881f, 
    -0.06097792f, -0.06838774f, -0.11400137f, 0.05977639f, 0.03547437f, 0.06651273f, 0.09979831f, 0.08389152f, 
    0.06298277f, -0.02540979f, -0.00333809f, -0.05231486f, -0.04277522f, 0.00408422f, 0.02445124f, 0.01004268f, 
    -0.05426014f, -0.06993499f, 0.03738342f, -0.08217507f, 0.05183515f, -0.02632687f, -0.03895308f, -0.01076397f, 
    -0.00211673f, -0.06532059f, 0.00700132f, -0.02101781f, 0.00151131f, 0.02702731f, -0.02064295f, 0.01424328f, 
    -0.00412736f, -0.04286988f, -0.06161382f, -0.01799097f, 0.05813466f, 0.02365907f, -0.07413432f, 0.00076768f, 
    -0.07550481f, -0.01084623f, 0.04961719f, -0.00183115f, 0.05318545f, 0.05143542f, -0.07333184f, 0.05565521f, 
    -0.00343858f, 0.00923804f, -0.03467695f, -0.07478143f, -0.00358471f, 0.03413047f, 0.01101019f, -0.03976201f, 
    -0.06002880f, -0.06812882f, -0.04288186f, -0.07310705f, 0.04090244f, -0.00909345f, 0.06423470f, 0.03558676f, 
    -0.07815853f, -0.05293145f, 0.05152615f, -0.00171881f, 0.01471048f, -0.00725615f, 0.01370071f, -0.07730952f, 
    -0.07129098f, 0.03263250f, 0.00368579f, -0.03731767f, 0.03465673f, -0.00778814f, -0.07461815f, 0.04298054f, 
    -0.04976643f, -0.03991116f, -0.06891967f, 0.01381906f, -0.02977522f, 0.03982811f, 0.02346206f, 0.00460849f, 
    -0.03366424f, 0.04733308f, -0.02325665f, -0.03972075f, -0.03312936f, 0.02097287f, -0.04382092f, 0.02934849f, 
    -0.07047307f, -0.05045499f, 0.02846165f, -0.00673266f, 0.02109403f, 0.00791094f, -0.04009214f, -0.00818224f, 
    0.01510199f, 0.02288906f, 0.00594721f, 0.01019228f, 0.04518792f, -0.04543593f, -0.01480196f, -0.01478796f, 
    -0.01693294f, 0.03104066f, -0.04072912f, 0.01402058f, -0.06543873f, 0.01767332f, -0.01674784f, -0.04365735f, 
    0.03331894f, -0.06607027f, 0.01071225f, -0.03238539f, -0.04200051f, -0.05581795f, 0.05332062f, 0.03028922f, 
    -0.04434267f, -0.03790547f, 0.00132601f, -0.06208052f, -0.04119959f, 0.03308329f, -0.05947153f, -0.05125728f, 
    0.01333187f, 0.02005785f, -0.02752491f, 0.04353366f, 0.02933495f, -0.02148951f, -0.03190047f, 0.04423145f, 
    -0.03655421f, -0.06584340f, 0.00928413f, 0.01516849f, 0.05054795f, 0.01873637f, -0.00486043f, -0.00541016f, 
    0.03663939f, -0.07548884f, 0.00623292f, -0.04394870f, -0.04269357f, 0.06627201f, 0.00547883f, -0.02476932f, 
    -0.02887524f, -0.06674948f, 0.00929813f, 0.01399027f, 0.00083196f, -0.00527409f, 0.00009963f, 0.04221737f, 
    0.00638505f, 0.04190983f, -0.04924813f, -0.02863905f, -0.00312712f, 0.03318400f, -0.07587285f, -0.04047005f, 
    0.05337673f, -0.00574030f, 0.04321629f, -0.02223997f, -0.05151857f, -0.01201826f, 0.06228837f, 0.02775148f, 
    -0.08633895f, -0.02586257f, 0.04004462f, -0.01753661f, -0.04096250f, -0.06171557f, 0.01491886f, 0.04492092f, 
    0.06878796f, 0.06517220f, -0.01101788f, 0.05332012f, -0.02693121f, -0.05405142f, -0.02332232f, 0.05097384f, 
    -0.02134485f, 0.06391012f, -0.01343164f, 0.18408683f, 0.00205908f, -0.03959220f, 0.10112725f, 0.33337459f, 
    0.04733647f, 0.13627161f, 0.10011562f, 0.03993795f, -0.16644987f, 0.02644340f, -0.14446789f, -0.11240955f, 
    -0.17819896f, -0.03414167f, 0.17929871f, 0.06640195f, -0.12767005f, 0.00281073f, 0.04459447f, -0.23459393f, 
    0.13482766f, 0.03609920f, 0.00193006f, -0.01218166f, 0.14384194f, -0.04722087f, -0.01614123f, -0.03588932f, 
    0.08790298f, -0.04649125f, 0.03977841f, 0.05318861f, -0.00063622f, 0.03192994f, 0.01731438f, -0.28895089f, 
    -0.00046989f, -0.06902666f, -0.03491075f, -0.02165234f, -0.08414318f, -0.11842909f, 0.09111753f, -0.07612768f, 
    0.02324039f, -0.07935539f, -0.02545486f, -0.12608559f, -0.05092049f, 0.00965223f, -0.04492682f, -0.09071157f, 
    0.09744217f, 0.01803311f, -0.03986919f, -0.01787676f, 0.16285931f, -0.09941238f, 0.01970975f, -0.36161691f, 
    0.16324571f, -0.00661202f, -0.11849044f, -0.11400198f, 0.03282481f, -0.03805988f, 0.06132944f, 0.02409110f, 
    -0.09548546f, -0.10771728f, 0.12550503f, -0.09504277f, -0.00816581f, 0.10196110f, 0.14168143f, 0.21527125f, 
    -0.08592305f, -0.02941629f, -0.09058302f, -0.02887122f, -0.29687640f, 0.12682638f, 0.35473210f, -0.05291241f, 
    -0.06016356f, -0.04831624f, -0.05246989f, -0.01628489f, -0.05084230f, -0.01290282f, -0.06575167f, 0.00208748f, 
    0.25214103f, 0.02238230f, 0.02635963f, 0.01236805f, 0.23984464f, -0.16617955f, 0.01558567f, 0.04975570f, 
    -0.04726335f, 0.08142295f, -0.06662516f, 0.09527980f, 0.03770107f, -0.11681087f, 0.17935726f, 0.06257332f, 
    0.05435449f, 0.06154157f, 0.01115450f, 0.02393027f, 0.07806946f, -0.02699420f, 0.01488924f, 0.00051481f, 
    0.07822311f, -0.02050747f, 0.23097935f, 0.38867041f, 0.02908268f, 0.13577718f, 0.06308337f, 0.24426241f, 
    0.02620307f, 0.22180937f, -0.08860607f, 0.06167080f, 0.08985560f, -0.40756416f, 0.10486446f, 0.14412443f, 
    0.32739010f, -0.14082414f, 0.07337007f, 0.00637064f, -0.04695453f, 0.02302053f, 0.18853140f, 0.04800740f, 
    -0.18052816f, 0.01906532f, 0.05575716f, 0.06728734f, -0.03345350f, -0.00016958f, 0.07433399f, 0.09895616f, 
    -0.08060615f, -0.12024457f, -0.06297256f, 0.02484037f, 0.19220179f, 0.01965811f, -0.00300568f, 0.05043696f, 
    -0.03894849f, -0.13678072f, -0.00176374f, -0.15609147f, -0.00419735f, -0.05055394f, 0.00491528f, -0.08937881f, 
    -0.12613556f, -0.22339657f, -0.04231275f, 0.01282029f, -0.24550949f, -0.09559766f, -0.03045996f, 0.04839888f, 
    0.03124433f, -0.01528332f, 0.05040720f, 0.14566018f, -0.03275334f, 0.04228853f, -0.02591818f, 0.03952876f, 
    -0.02924148f, -0.13915271f, -0.11627940f, -0.03369090f, -0.00246005f, -0.03775148f, -0.15944907f, -0.00111453f, 
    -0.03825267f, -0.07503743f, -0.05973049f, -0.03877509f, 0.01524296f, -0.02350116f, -0.05907352f, -0.06424799f, 
    -0.05408988f, -0.05956459f, 0.02420169f, 0.06013490f, -0.06334940f, 0.02136576f, -0.01054905f, 0.02892900f, 
    -0.08113653f, 0.06137171f, -0.04502163f, -0.05364314f, -0.03136972f, -0.01634608f, -0.00155297f, -0.00121973f, 
    -0.08271051f, -0.05297362f, -0.06038634f, -0.05211719f, -0.01822860f, -0.00082661f, 0.02198750f, -0.00112113f, 
    -0.02808330f, 0.01910022f, -0.00227996f, 0.03524665f, 0.04456305f, -0.03799807f, -0.08082176f, -0.03659967f, 
    -0.03622774f, -0.01556508f, -0.00086964f, -0.05422731f, -0.01352518f, -0.05164625f, 0.03413002f, 0.00072616f, 
    0.03551437f, -0.04622601f, 0.00317638f, 0.06617953f, -0.06660666f, -0.03277528f, -0.01201327f, 0.02315334f, 
    -0.07688638f, -0.03398393f, 0.02869700f, 0.05124451f, -0.04813217f, -0.03831558f, -0.06192366f, -0.05444658f, 
    0.04216846f, 0.04613293f, 0.03690717f, -0.03037044f, 0.05149888f, 0.00896872f, 0.01629973f, -0.04243409f, 
    0.00119357f, -0.04630707f, 0.00179004f, 0.03892363f, 0.02707352f, 0.02908094f, -0.01861334f, -0.01048359f, 
    0.06012361f, 0.03265005f, -0.07070369f, -0.05992549f, -0.04865744f, -0.03670980f, -0.02065566f, -0.02679055f, 
    -0.01276930f, -0.06452629f, -0.02981568f, -0.05696094f, -0.00600332f, -0.05193309f, 0.02782363f, -0.05366589f, 
    0.04837383f, -0.05201935f, -0.05155505f, 0.05189630f, -0.04856839f, -0.04033567f, 0.01665669f, 0.05770900f, 
    -0.01345372f, 0.01321511f, 0.01500025f, -0.07498603f, -0.08094095f, -0.07860961f, -0.07103940f, -0.02809495f, 
    -0.01957297f, 0.00168465f, 0.05738834f, 0.01389513f, -0.03510902f, 0.05138532f, -0.02923022f, 0.04096594f, 
    -0.04401103f, -0.06407844f, -0.05486788f, -0.02626910f, -0.01814563f, 0.04374636f, 0.03440528f, 0.02742972f, 
    -0.00077519f, -0.02359558f, -0.00414901f, -0.01710907f, -0.04851263f, -0.02501958f, -0.01961843f, 0.04532107f, 
    0.00405372f, -0.00483370f, -0.07429922f, -0.05657852f, 0.00944963f, -0.04193484f, 0.02083751f, 0.02571539f, 
    -0.08947994f, 0.05310151f, 0.05327299f, -0.01949483f, 0.01146931f, -0.04452265f, 0.02369758f, -0.00964801f, 
    -0.06071021f, 0.03765284f, 0.03952447f, -0.04502641f, -0.07955480f, -0.01838122f, -0.08007769f, 0.01315846f, 
    0.03562977f, -0.02047737f, -0.04589519f, -0.03849174f, -0.06806532f, 0.00732642f, 0.00338880f, 0.04883603f, 
    -0.05691553f, 0.00977661f, -0.01321411f, -0.04398966f, 0.05732264f, 0.05564072f, -0.04435384f, -0.05752376f, 
    0.01314579f, 0.01234875f, 0.02309215f, 0.01313224f, -0.00168257f, -0.02868225f, -0.02335056f, -0.02341915f, 
    -0.06708684f, 0.01364989f, 0.06255426f, 0.05252218f, -0.05565659f, 0.03008384f, 0.05006903f, 0.00514104f, 
    -0.18109605f, -0.00463724f, 0.13988629f, -0.04546692f, 0.00203637f, 0.03606177f, 0.15395312f, 0.18121259f, 
    0.08865514f, -0.01585807f, 0.04183717f, 0.25837168f, 0.16219644f, 0.04266604f, 0.12039711f, 0.12131912f, 
    -0.01929810f, -0.05657150f, 0.08758361f, 0.01187685f, -0.12606618f, -0.02479384f, -0.13986759f, -0.26462746f, 
    0.05518166f, 0.39924788f, 0.20941761f, 0.66148198f, 0.13986692f, -0.30833516f, -0.14785270f, 0.03762072f, 
    0.08509322f, 0.03636032f, 0.10801549f, 0.00775201f, -0.22297032f, -0.10508087f, 0.29933113f, 0.27048165f, 
    0.07420560f, 0.19727246f, 0.12831353f, -0.04955361f, 0.10140434f, -0.03504791f, -0.10429641f, 0.02679759f, 
    -0.34182703f, -0.39190739f, 0.06808671f, 0.17112221f, 0.02658348f, 0.05453386f, -0.03858672f, -0.00717968f, 
    -0.25608483f, 0.00408133f, -0.27113050f, -0.26069567f, 0.23569264f, -0.25976595f, -0.09719000f, -0.07875478f, 
    0.10678934f, -0.02154721f, -0.02370258f, -0.11698730f, 0.07569117f, 0.28243682f, 0.15882187f, 0.06383377f, 
    -0.03905255f, -0.05915945f, -0.12528220f, 0.01765327f, 0.12436093f, -0.09672909f, 0.12304660f, -0.13374950f, 
    -0.13789289f, -0.08777126f, -0.25270486f, -0.15948267f, -0.41042587f, 0.43708476f, 0.34691018f, 0.17461643f, 
    0.07432318f, -0.14582083f, -0.05329184f, -0.09566265f, 0.06781577f, -0.05683736f, -0.04903451f, 0.12148889f, 
    0.24645947f, -0.00564013f, 0.15212546f, -0.20418613f, 0.10544886f, -0.03798471f, -0.11414606f, 0.07964047f, 
    0.03276958f, -0.10424202f, -0.03084702f, -0.08540998f, -0.04181654f, -0.22760254f, -0.01997735f, 0.04699995f, 
    -0.10684461f, 0.01603992f, 0.20458585f, 0.13082293f, -0.05879562f, -0.16054827f, -0.00517176f, -0.08124021f, 
    0.11154088f, -0.33224553f, -0.11020804f, 0.08580493f, 0.11323139f, 0.10362480f, 0.12227623f, 0.03360306f, 
    -0.07412799f, -0.03316924f, -0.10935007f, -0.03418880f, 0.42034590f, -0.10731525f, -0.17514795f, -0.00901538f, 
    -0.21474123f, 0.27178368f, -0.29479727f, -0.12493313f, -0.14080223f, -0.02103475f, 0.10506441f, -0.01670769f, 
    0.07989612f, 0.16813761f, 0.10204252f, 0.14861506f, -0.06554439f, -0.07403723f, -0.06544113f, -0.01886057f, 
    0.08119426f, 0.07886317f, 0.00462520f, 0.19766049f, -0.26447928f, -0.06051224f, -0.00966498f, 0.06111708f, 
    0.10456061f, -0.06174278f, 0.18004252f, -0.07309312f, 0.28264374f, -0.06210947f, 0.00952280f, 0.02079470f, 
    0.19018444f, 0.18159288f, 0.14645021f, -0.23106334f, 0.04158378f, -0.22655775f, 0.02188948f, 0.14979790f, 
    -0.02859025f, 0.04223726f, -0.00135708f, 0.00794233f, -0.08441634f, 0.13080841f, -0.08928981f, -0.13043804f, 
    0.01160952f, -0.14999183f, -0.04257703f, 0.07492649f, -0.01548694f, 0.08288922f, 0.02915011f, 0.13062027f, 
    -0.02089122f, 0.10692055f, 0.20693831f, -0.01754789f, -0.05998972f, 0.07346386f, -0.02261606f, -0.05148743f, 
    -0.12354729f, -0.13001154f, -0.04697255f, -0.16072065f, -0.22919846f, 0.13066953f, 0.19827071f, 0.05707131f, 
    -0.07148939f, -0.12258500f, -0.04481213f, 0.03916965f, 0.02260393f, -0.02187769f, 0.17804889f, -0.03766518f, 
    0.43313450f, 0.04604686f, 0.17275250f, -0.07915848f, -0.14214081f, 0.04488223f, 0.13079938f, 0.00357912f, 
    -0.12119168f, 0.07746620f, -0.15780398f, -0.05788916f, -0.02426258f, -0.29589936f, -0.28108644f, -0.17576963f, 
    -0.13520114f, 0.01122272f, -0.17792346f, 0.07096016f, -0.09265023f, -0.06196887f, 0.01476779f, 0.06551274f, 
    -0.02810031f, 0.04606754f, -0.00736734f, -0.02200027f, -0.03749461f, 0.12456164f, -0.04023634f, -0.19824189f, 
    -0.05140634f, -0.09135045f, 0.01971379f, -0.00678259f, 0.13809164f, -0.10223180f, 0.40934053f, -0.10646033f, 
    -0.05965757f, -0.13268545f, 0.04145005f, -0.23257141f, 0.03727748f, -0.04527219f, -0.03122219f, 0.10012237f, 
    -0.02021877f, 0.08526577f, 0.05842876f, 0.04134391f, -0.08666892f, 0.01795571f, -0.02896551f, 0.15033194f, 
    -0.17956145f, -0.05707055f, -0.03501360f, 0.05980314f, 0.40479383f, 0.01763786f, 0.20182523f, 0.29318681f, 
    -0.02179586f, -0.11078968f, 0.06618443f, -0.15667786f, -0.05493371f, 0.04139610f, -0.02253736f, -0.06525902f, 
    0.22748546f, -0.35940313f, 0.18522295f, -0.26141071f, -0.13366765f, -0.01940402f, 0.09960531f, -0.10107784f, 
    -0.10795117f, -0.03623082f, -0.07708202f, -0.07434250f, -0.12689474f, 0.02953845f, -0.01398901f, -0.16861227f, 
    -0.05960565f, -0.04727659f, -0.01576141f, -0.02101719f, 0.00571574f, -0.03099916f, 0.11803056f, 0.19530107f, 
    -0.11427629f, 0.06303727f, -0.11725968f, -0.05150074f, -0.12353452f, -0.03113925f, 0.08352846f, 0.08343079f, 
    -0.17380962f, 0.03296105f, -0.03143853f, 0.02947023f, 0.19757143f, 0.25159571f, -0.01755787f, -0.11350165f, 
    -0.08901311f, 0.00753734f, 0.08632271f, -0.02400666f, 0.09367892f, -0.05025601f, 0.03403991f, -0.12582448f, 
    -0.02740226f, -0.10099521f, -0.22445533f, 0.17416419f, 0.03507992f, -0.04185187f, 0.05622745f, 0.11723667f, 
    0.02207185f, 0.00107322f, -0.07420117f, 0.04195801f, 0.00758398f, 0.17513388f, 0.00704035f, 0.02532809f, 
    -0.11785865f, 0.00469988f, -0.13114586f, -0.00160093f, -0.18657351f, 0.08981137f, 0.04365335f, 0.17010051f, 
    0.05568566f, 0.00380452f, -0.04905586f, 0.08151734f, -0.02607518f, 0.00364507f, 0.00683018f, -0.00833058f, 
    0.04504038f, 0.10361028f, -0.03578706f, 0.04657677f, -0.16376524f, 0.09525874f, -0.16575949f, 0.11087167f, 
    -0.08889955f, -0.05314526f, -0.00586441f, -0.16556016f, 0.17430851f, 0.00512930f, -0.06910269f, -0.11610707f, 
    0.30107331f, -0.02864889f, 0.33096218f, -0.16209306f, 0.05813276f, 0.06456569f, -0.12432119f, -0.11317988f, 
    0.07973575f, -0.11173159f, -0.13350515f, -0.07759538f, 0.13850009f, 0.07224165f, 0.03322436f, -0.07790986f, 
    -0.02208882f, 0.20845434f, 0.08942453f, 0.02543306f, 0.05948634f, 0.18213074f, 0.08092067f, 0.22312817f, 
    -0.34580624f, 0.14998822f, -0.04472928f, 0.45421970f, -0.13456157f, 0.19011156f, 0.22849752f, -0.07032710f, 
    0.23924379f, 0.04104403f, 0.01102986f, 0.12210041f, -0.18434936f, -0.18018551f, -0.01821665f, 0.04656538f, 
    0.12210261f, 0.21151665f, -0.10113618f, -0.02309527f, 0.09251329f, -0.09835275f, 0.01448162f, 0.04390441f, 
    -0.04038359f, 0.07746195f, 0.11101704f, -0.13219348f, -0.02516761f, -0.00022382f, -0.06986376f, -0.10733692f, 
    -0.06363953f, 0.15839466f, 0.03387647f, 0.07469594f, -0.04598111f, 0.12958732f, 0.06722578f, 0.35456362f, 
    -0.00861359f, -0.09112495f, 0.03858515f, 0.08459334f, 0.00674017f, -0.12394673f, -0.04977209f, 0.09517510f, 
    0.15158747f, -0.27276787f, -0.31910208f, -0.01212139f, 0.07389357f, 0.15162683f, 0.18906122f, 0.26396608f, 
    -0.03970854f, 0.04017783f, 0.06185938f, 0.12374315f, -0.12483449f, -0.31359789f, -0.17558500f, 0.21721783f, 
    -0.01298848f, -0.21740322f, 0.17297547f, 0.01315593f, -0.01018781f, 0.05200176f, -0.23278487f, -0.14971206f, 
    -0.17064948f, 0.42943904f, 0.25752041f, 0.01706990f, -0.10517621f, 0.13979891f, -0.18091643f, -0.04245052f, 
    -0.08365880f, 0.02266656f, 0.04625675f, 0.00394218f, -0.04894187f, 0.10921307f, 0.11309150f, -0.08312815f, 
    0.05659361f, -0.05640282f, 0.01782768f, -0.12867720f, 0.02955612f, 0.06194092f, 0.13111900f, 0.05482423f, 
    0.15485488f, -0.26569989f, -0.21784191f, 0.05280320f, 0.03731836f, -0.03608757f, 0.04182756f, -0.03348679f, 
    -0.11119447f, -0.08820893f, -0.07483790f, 0.10141868f, 0.41054276f, 0.39670727f, -0.23994917f, 0.05283840f, 
    -0.03086892f, 0.26093745f, -0.08516338f, -0.00118558f, -0.22238588f, 0.13007472f, 0.04607835f, -0.11063921f, 
    0.03594768f, -0.14925426f, -0.17048562f, -0.05489771f, 0.00758123f, 0.06384556f, 0.03217077f, 0.05659885f, 
    -0.05433850f, -0.17137218f, -0.13920343f, -0.12255722f, -0.13785572f, 0.18185946f, 0.12697099f, -0.03246114f, 
    0.03934581f, -0.01530094f, -0.07290253f, -0.10448632f, 0.12333041f, 0.14888789f, 0.01158666f, 0.00059307f, 
    0.18017980f, 0.22417635f, 0.16697659f, -0.18835914f, -0.05123926f, 0.00392946f, 0.06255040f, -0.05485255f, 
    0.23133852f, -0.00504500f, -0.06944157f, -0.03191846f, 0.18096700f, 0.22442895f, 0.03554478f, -0.28224242f, 
    -0.05878055f, -0.01452571f, 0.00774722f, -0.06025034f, -0.01282230f, -0.09736740f, -0.03519085f, -0.16503011f, 
    0.40313074f, -0.02441895f, 0.05246036f, -0.06054809f, 0.00015514f, 0.00239541f, 0.07494390f, -0.19292073f, 
    0.11831513f, -0.04319002f, 0.13947564f, 0.02886259f, 0.26034889f, -0.16748418f, 0.04929489f, -0.41534972f, 
    0.08801396f, -0.10598284f, -0.07789481f, -0.04386119f, 0.07050584f, 0.02063242f, -0.12743001f, -0.18208031f, 
    -0.16952209f, -0.05190859f, 0.07633108f, -0.18463519f, -0.08477560f, 0.07488495f, -0.01093264f, -0.20676598f, 
    0.01594415f, 0.01756516f, 0.04383721f, -0.17566070f, 0.16197887f, 0.34959784f, 0.04443425f, 0.09640075f, 
    0.12304209f, 0.09460137f, 0.18867861f, 0.13957167f, 0.05072569f, -0.09447920f, 0.04676827f, -0.05635575f, 
    0.11139254f, 0.09714081f, -0.01852334f, -0.22482954f, 0.05413517f, -0.01179336f, -0.00182035f, 0.09027170f, 
    -0.01830229f, -0.27255651f, -0.16555290f, -0.45944092f, 0.02528416f, 0.33011904f, 0.09022912f, 0.18388753f, 
    -0.08931091f, 0.08649950f, 0.24397352f, 0.14766900f, -0.07579821f, 0.01091106f, -0.00366495f, 0.00120130f, 
    -0.04516558f, -0.12717722f, -0.02763658f, 0.28609794f, -0.01873789f, -0.13858636f, 0.06766941f, -0.03523540f, 
    -0.10744561f, 0.16111887f, 0.08959088f, -0.12061647f, -0.29772928f, -0.26025903f, -0.43223497f, -0.03737523f, 
    -0.01288196f, -0.03206373f, 0.17381226f, 0.23514023f, 0.08401166f, 0.04637972f, -0.01584924f, 0.08176602f, 
    0.13234425f, 0.34217286f, -0.19122465f, 0.27447215f, 0.08221027f, 0.17804278f, 0.12085599f, 0.00204444f, 
    -0.01119414f, -0.03024977f, 0.01980484f, 0.04403782f, 0.08933341f, -0.11733671f, -0.05141442f, -0.13904409f, 
    -0.21749379f, -0.17279249f, -0.11507835f, -0.33445042f, 0.04098760f, 0.01533032f, 0.15877604f, -0.08267410f, 
    -0.09389702f, -0.03575874f, 0.10346894f, -0.18468918f, 0.05989796f, -0.00657398f, -0.04226742f, -0.01513913f, 
    -0.03845904f, -0.13495520f, 0.07019575f, -0.14310139f, -0.05638098f, 0.38451359f, -0.15762903f, -0.02908592f, 
    -0.02560441f, 0.27128118f, 0.07111756f, -0.15232651f, 0.05909250f, 0.08031354f, 0.00010232f, 0.09932493f, 
    0.28119966f, -0.31751212f, 0.00563607f, -0.07296025f, -0.05134359f, -0.17329879f, -0.02040783f, -0.06007129f, 
    0.10860280f, -0.06551436f, 0.07186481f, 0.03232261f, 0.02505798f, 0.09422982f, -0.04561937f, -0.02238037f, 
    0.02991302f, -0.08835189f, -0.13605897f, -0.11873097f, 0.15898192f, -0.02391218f, 0.09781594f, 0.23306762f, 
    0.19946972f, 0.08269271f, 0.07408182f, -0.19656019f, -0.09090146f, 0.07739995f, -0.08723027f, -0.45879343f, 
    0.20491421f, -0.01945035f, 0.07325601f, -0.20484778f, 0.23801102f, 0.01841977f, 0.08015408f, -0.06048688f, 
    -0.13035816f, 0.02829505f, -0.12411155f, -0.22613712f, 0.00133173f, -0.01056209f, -0.04881106f, -0.01559387f, 
    0.01355217f, 0.11215927f, 0.20276289f, 0.11440112f, -0.07317293f, 0.08674952f, 0.12684092f, 0.15782370f, 
    0.14011143f, 0.16743731f, -0.01981393f, -0.08713137f, -0.16249868f, -0.22119592f, 0.03291800f, -0.14717515f, 
    -0.13714212f, 0.07256240f, -0.06778170f, -0.04219090f, 0.16929509f, 0.11456539f, 0.28197059f, 0.12577255f, 
    0.36462003f, -0.10938186f, -0.04745711f, -0.18013556f, -0.20095669f, 0.06892578f, 0.13064840f, -0.15220374f, 
    0.20981006f, -0.05040126f, -0.03734022f, 0.24070029f, 0.16330221f, -0.03650745f, -0.23761694f, -0.07784083f, 
    -0.07290175f, 0.10668697f, -0.03803314f, -0.02753559f, 0.00008845f, 0.03673961f, -0.02237372f, 0.04273050f, 
    -0.44174695f, -0.40644807f, -0.31480339f, -0.42361158f, -0.04784033f, 0.15495408f, -0.04400026f, 0.05733920f, 
    0.08526881f, -0.00073303f, 0.17882600f, 0.16761920f, -0.10094359f, -0.04644463f, -0.11034659f, 0.03967705f, 
    -0.00352820f, -0.06728282f, -0.00576949f, -0.12735488f, -0.15510790f, -0.25889620f, -0.08137202f, -0.12214283f, 
    -0.08592997f, -0.00203015f, 0.23588130f, -0.04852442f, 0.02446502f, 0.09739740f, -0.10160220f, 0.16194151f, 
    -0.05717591f, -0.03741681f, 0.13949190f, 0.11572687f, 0.33432910f, -0.04690040f, -0.05198875f, 0.10924000f, 
    -0.07205662f, -0.00532457f, 0.05582043f, 0.20774274f, -0.00568816f, 0.06185840f, 0.02127126f, -0.15409219f, 
    -0.24530835f, -0.17710181f, -0.04089338f, 0.13979888f, -0.08216418f, -0.00333704f, 0.09601104f, 0.04401900f, 
    0.02253097f, 0.15984663f, -0.00235768f, 0.06610817f, -0.32896265f, -0.13289933f, -0.31556687f, -0.13559400f, 
    -0.06578835f, 0.02330234f, -0.10822924f, -0.10396533f, 0.20582467f, -0.00119962f, -0.07454040f, 0.00958951f, 
    -0.05102386f, 0.14421685f, 0.20167224f, 0.19688758f, 0.17039107f, 0.13476317f, 0.02891363f, 0.27234197f, 
    0.07730373f, 0.10959771f, 0.04419944f, 0.05796772f, -0.00985969f, 0.28568146f, 0.08707266f, 0.19504532f, 
    0.03488833f, -0.07294387f, 0.11175595f, 0.29319623f, -0.06699243f, 0.05561774f, -0.17638308f, 0.08491988f, 
    0.00265053f, 0.05605561f, 0.02770003f, 0.04669628f, 0.09227774f, 0.00052340f, -0.02443802f, 0.17724645f, 
    -0.09231982f, -0.13334519f, -0.18406092f, -0.10534905f, -0.02145675f, -0.24202053f, -0.07703322f, -0.21050964f, 
    -0.17115369f, 0.07350266f, -0.04153414f, -0.15908684f, -0.10446146f, -0.11987086f, -0.06994309f, -0.12700264f, 
    -0.09846888f, -0.13081448f, -0.00220379f, -0.06057894f, -0.22687985f, -0.04285026f, 0.04248837f, -0.18408231f, 
    0.30711728f, 0.10508300f, 0.07600866f, 0.14356108f, -0.15520766f, -0.14201960f, -0.12569001f, -0.21441834f, 
    -0.08041903f, 0.03231115f, -0.06560717f, -0.10164531f, 0.09863967f, 0.04179370f, -0.09191979f, -0.03505474f, 
    0.33916831f, 0.00301600f, -0.21261175f, 0.05159048f, 0.01308559f, -0.13575423f, 0.07922330f, 0.14787863f, 
    0.04429852f, -0.06796390f, 0.02232306f, -0.10125317f, 0.16953593f, 0.04002793f, -0.06282300f, 0.00949846f, 
    0.06989618f, 0.02491000f, 0.15470721f, 0.02263378f, -0.14007626f, -0.07759637f, -0.03806873f, -0.02300918f, 
    0.00386369f, -0.16320220f, -0.20728827f, -0.16750254f, 0.03177385f, 0.11954998f, 0.12415866f, -0.19747263f, 
    -0.01775224f, -0.21018891f, 0.02170970f, 0.01543627f, 0.28458917f, 0.30596870f, 0.00288773f, -0.18825859f, 
    0.03186812f, -0.14347680f, 0.05521521f, -0.00768072f, 0.00089731f, 0.07620081f, 0.12243664f, -0.03438802f, 
    0.01705746f, 0.08603881f, 0.05954992f, 0.06089603f, -0.13654293f, -0.13457896f, -0.12202919f, 0.13856247f, 
    0.13024662f, -0.03362964f, 0.06372114f, 0.13189285f, 0.09509847f, 0.09946664f, -0.39856440f, 0.01928798f, 
    0.01486257f, 0.04360386f, -0.14925033f, -0.09914798f, -0.16549954f, -0.08211703f, -0.00599076f, -0.11064851f, 
    0.04537354f, 0.28354350f, 0.22266032f, 0.06425282f, 0.13536525f, 0.15286373f, 0.05268916f, -0.22557436f, 
    0.00182138f, -0.00062735f, 0.06962539f, -0.06856323f, 0.07568903f, -0.09255439f, 0.02058976f, 0.00485377f, 
    0.05235701f, 0.01396122f, -0.03666086f, 0.05344827f, -0.10572256f, -0.03243268f, -0.04594510f, 0.05528377f, 
    -0.11140686f, 0.48526144f, -0.36220697f, 0.42375195f, 0.15903176f, -0.25172982f, -0.08916322f, -0.12085006f, 
    0.06805661f, -0.01010090f, 0.04661944f, -0.02290495f, 0.00216700f, -0.09135198f, -0.03814549f, -0.04046437f, 
    0.08058076f, -0.01292118f, -0.03411472f, -0.00949731f, 0.02163768f, 0.01150862f, -0.00302491f, -0.01670458f, 
    0.04034253f, 0.27265492f, 0.27135167f, 0.05959827f, -0.01433550f, -0.02703685f, -0.10283870f, 0.07946479f, 
    0.04889732f, -0.04354814f, 0.18798779f, 0.01938432f, -0.44341028f, -0.23297536f, 0.18792626f, 0.01266596f, 
    0.20547737f, -0.07828689f, -0.17085336f, -0.11352966f, 0.02189626f, 0.10952731f, -0.17542532f, 0.03064908f, 
    0.17002821f, 0.23221043f, -0.01878713f, 0.08727187f, 0.03650675f, 0.15294079f, 0.05887940f, -0.07013387f, 
    0.13439138f, 0.01795742f, -0.06107372f, -0.11932703f, 0.10599510f, -0.04774768f, -0.17824556f, -0.10893890f, 
    -0.01859738f, -0.08485930f, 0.01489159f, -0.02143192f, 0.06998447f, 0.01190275f, 0.16476779f, -0.08705764f, 
    0.08568643f, -0.09401493f, -0.02251960f, -0.14789537f, 0.02374756f, -0.06202709f, 0.01321934f, 0.08179788f, 
    0.11553601f, -0.00870407f, -0.00560850f, -0.08552251f, -0.13038231f, -0.33252344f, -0.08084118f, -0.05761659f, 
    -0.00406049f, 0.01094387f, -0.00794112f, 0.08978342f, 0.13193776f, 0.12229308f, -0.15861931f, 0.25517559f, 
    -0.06130594f, -0.02877491f, -0.02233991f, -0.07327270f, 0.03444881f, 0.03518895f, -0.07910930f, -0.05958726f, 
    0.04146243f, 0.01910798f, 0.00304204f, 0.03668043f, -0.05226986f, -0.06599724f, 0.03286962f, -0.01813471f, 
    -0.02524300f, -0.00142440f, -0.03855114f, 0.06232855f, -0.04683805f, -0.05198343f, -0.02976942f, -0.03877593f, 
    -0.07995425f, -0.05431551f, -0.04721967f, 0.03124296f, -0.05243381f, -0.01270169f, -0.05246798f, -0.01047442f, 
    0.03392819f, 0.00086005f, -0.00047626f, -0.00540256f, -0.04039412f, -0.03719344f, -0.03934522f, 0.00620787f, 
    0.01674675f, -0.01027816f, 0.02824461f, 0.00144080f, 0.00106650f, -0.00163011f, 0.05576793f, 0.03455674f, 
    0.03530210f, -0.02734507f, -0.05763995f, 0.01119436f, 0.05784480f, 0.01875465f, -0.06034571f, -0.03371675f, 
    -0.07086626f, 0.03844626f, -0.04441604f, -0.04548935f, 0.01568308f, -0.06863727f, -0.03449865f, -0.04517146f, 
    -0.05160521f, -0.07003789f, -0.07123791f, -0.06068370f, -0.07854483f, -0.07664756f, 0.02473317f, -0.03904831f, 
    0.07231024f, -0.02444009f, -0.01639356f, -0.01496895f, 0.05225592f, -0.02612834f, -0.07612696f, 0.00752292f, 
    0.04700071f, -0.07131210f, -0.06312977f, -0.01350618f, 0.03747377f, 0.02267078f, 0.04518016f, -0.00413099f, 
    0.04851322f, 0.02844547f, 0.00706257f, -0.01677642f, -0.01157566f, 0.02326943f, -0.01768007f, 0.03360013f, 
    0.05590212f, 0.04037994f, 0.02910621f, -0.06618892f, 0.04115331f, -0.06530037f, -0.07420342f, -0.00610625f, 
    0.04895243f, -0.02607033f, -0.02091559f, -0.01542880f, 0.00432811f, 0.05349451f, 0.00999070f, 0.00614428f, 
    -0.02232182f, -0.00412863f, -0.02129020f, 0.05491273f, -0.04515143f, -0.00727197f, 0.01182474f, -0.00970722f, 
    -0.02389330f, -0.04040341f, 0.04115732f, 0.00760644f, -0.01006460f, 0.02564184f, -0.04831815f, 0.02229376f, 
    -0.02382598f, 0.04137258f, -0.04422792f, 0.01495702f, -0.04528544f, -0.06095999f, 0.00233505f, 0.06214010f, 
    -0.04281074f, -0.07629663f, -0.07967452f, 0.01950265f, -0.06578077f, -0.01996862f, -0.06095199f, 0.01054930f, 
    -0.00763960f, -0.02468225f, -0.04539553f, -0.06365678f, 0.01607115f, 0.03719971f, 0.00293800f, -0.07021812f, 
    0.04087490f, -0.07982902f, 0.04250371f, 0.05994612f, 0.05960265f, 0.00266288f, 0.03174586f, -0.00290163f, 
    -0.03255135f, -0.03375852f, 0.03966914f, -0.07731738f, -0.01570687f, -0.07206264f, 0.01007228f, 0.03967730f, 
    -0.07399334f, 0.00519050f, 0.03447590f, -0.04669433f, -0.02007079f, 0.03738507f, 0.01745887f, -0.00793226f, 
    -0.04419786f, 0.01421979f, -0.01451256f, 0.04541057f, 0.04058052f, 0.01039592f, 0.04648582f, -0.04608300f, 
    -0.02306614f, 0.05400002f, -0.07597309f, -0.06208413f, -0.06059591f, -0.06984521f, -0.03948342f, 0.05386951f, 
    -0.14557526f, -0.14127277f, 0.02436893f, 0.13779886f, 0.01653280f, -0.06139450f, 0.06754349f, 0.19780971f, 
    0.04994306f, 0.09229898f, 0.11770575f, 0.03796479f, 0.01963501f, -0.09763154f, -0.27069849f, -0.05682985f, 
    -0.08796485f, 0.05996489f, 0.01377860f, -0.05635779f, -0.00896851f, -0.10889386f, -0.10983481f, -0.25901011f, 
    -0.01280450f, 0.42163515f, -0.00048212f, -0.15129238f, 0.01203317f, -0.14820652f, -0.09399378f, -0.07742960f, 
    0.19384140f, 0.02857067f, -0.10959125f, 0.20979749f, 0.03130758f, 0.16392174f, -0.01679275f, -0.24401812f, 
    -0.03947595f, -0.11031076f, 0.03957072f, -0.07747866f, -0.00782492f, -0.05866170f, 0.07315566f, -0.16959824f, 
    -0.09227379f, -0.12502594f, -0.02748094f, -0.01848982f, -0.03724048f, 0.02658291f, -0.10665724f, 0.14671792f, 
    -0.00309289f, -0.07821753f, -0.06233268f, 0.01797878f, 0.00192548f, -0.10075679f, -0.25873959f, -0.37175813f, 
    0.12388660f, -0.08183185f, -0.08217968f, -0.12478576f, 0.09999467f, 0.08855317f, 0.10627995f, -0.12380948f, 
    0.00355869f, 0.00222375f, 0.05322005f, -0.18728657f, 0.04087578f, 0.14484483f, -0.03589449f, 0.04462934f, 
    0.08543777f, -0.14914191f, -0.15646248f, 0.02526492f, -0.36559665f, 0.21583526f, 0.49654073f, -0.21613565f, 
    -0.08970091f, 0.07974126f, -0.02343720f, 0.00296825f, -0.04888510f, -0.11703243f, 0.14071693f, 0.04567898f, 
    -0.10905603f, -0.10670806f, -0.11673282f, 0.09238964f, 0.15205283f, -0.20343654f, -0.06435316f, 0.08520347f, 
    -0.09260043f, 0.13820045f, -0.04711895f, 0.08766419f, 0.12757392f, -0.01847423f, 0.06317401f, 0.13850141f, 
    0.08435137f, 0.02250103f, -0.10110064f, 0.08570191f, 0.03185506f, -0.05173159f, 0.04128163f, -0.00521266f, 
    0.06902727f, 0.01282887f, 0.20814186f, 0.28734276f, 0.05529124f, 0.09620181f, 0.03986600f, 0.16358843f, 
    0.06212132f, 0.06144382f, 0.01560352f, 0.06262296f, -0.01659055f, -0.33733019f, -0.09105393f, 0.12174072f, 
    0.24591629f, -0.27517042f, 0.09603377f, -0.00626652f, -0.08756175f, -0.04349845f, 0.06273283f, 0.11443977f, 
    -0.13684125f, 0.24836816f, 0.35788849f, -0.05076071f, -0.12906870f, -0.00384630f, -0.06203381f, 0.06167345f, 
    -0.11621100f, -0.03759738f, 0.15020885f, 0.08968079f, 0.27785799f, -0.08068611f, 0.03130577f, -0.13693862f, 
    -0.08503475f, -0.13584191f, 0.04448811f, -0.08023007f, 0.06818389f, -0.03821854f, -0.02350166f, -0.13283738f, 
    -0.11850493f, -0.24338129f, -0.04552505f, 0.26479748f, -0.13069734f, -0.00677658f, -0.16750807f, 0.03983673f, 
    0.11684465f, -0.06900991f, 0.09303474f, -0.03984533f, -0.09219021f, -0.13817368f, -0.06971437f, 0.27978057f, 
    -0.02748186f, -0.16498582f, -0.07485776f, 0.08601408f, -0.00269155f, 0.16258968f, 0.03562534f, 0.14242551f, 
    -0.22749957f, 0.05538004f, -0.08077741f, 0.24387144f, 0.00308397f, -0.01290489f, 0.07056211f, 0.19248931f, 
    0.01499355f, 0.08178420f, 0.07167032f, -0.07831237f, -0.30983797f, 0.01445988f, -0.06772070f, 0.19450946f, 
    0.04895111f, -0.18748938f, 0.09967910f, 0.06735181f, 0.01776497f, 0.06596591f, -0.06789867f, -0.13881819f, 
    0.06520782f, 0.00135052f, 0.01460937f, -0.18759145f, 0.19121780f, -0.22091620f, -0.16225025f, 0.12998553f, 
    0.13589366f, 0.13049699f, -0.00527851f, -0.09299245f, -0.12878990f, -0.07772180f, 0.06740864f, -0.35501438f, 
    0.02754610f, -0.02575140f, -0.13148290f, -0.06824961f, -0.20308924f, 0.01079580f, 0.06941203f, -0.00761563f, 
    0.06386047f, 0.02107215f, 0.07745772f, 0.14896499f, -0.13912567f, 0.06269883f, -0.02985437f, 0.06496802f, 
    -0.05637795f, -0.04765573f, 0.08301161f, 0.06752902f, 0.04909302f, -0.18790969f, 0.13710907f, -0.31098682f, 
    0.07264494f, 0.06271625f, 0.06218142f, -0.07107118f, 0.07133236f, 0.12012620f, -0.00386339f, 0.06866953f, 
    -0.11925995f, -0.08845864f, -0.15562983f, -0.29157770f, 0.11272637f, 0.18052350f, 0.05327847f, 0.14179689f, 
    -0.04958977f, -0.10189311f, -0.14204179f, 0.01925206f, -0.10770335f, -0.13549466f, -0.00957031f, -0.35521469f, 
    -0.14337927f, -0.02675587f, 0.03165982f, -0.16038454f, 0.10528073f, 0.06108868f, 0.18802500f, -0.01872903f, 
    0.02702981f, -0.05487941f, 0.33966762f, -0.28199857f, 0.15238807f, -0.02586332f, 0.03548348f, -0.05776347f, 
    -0.12556073f, 0.00107685f, -0.05758461f, 0.12195820f, 0.16458662f, 0.06538375f, 0.27722588f, 0.08453229f, 
    0.06583223f, 0.06483135f, -0.02968189f, 0.18102874f, -0.09642564f, 0.13660248f, -0.01453618f, 0.06866328f, 
    0.06758311f, -0.02114031f, -0.09294528f, -0.10951935f, 0.03912257f, 0.06024019f, -0.02517674f, 0.13354956f, 
    0.00670590f, 0.12572318f, 0.04203383f, 0.17446870f, -0.14792602f, -0.57013327f, 0.57480210f, -0.21688397f, 
    0.07713051f, 0.08494632f, 0.09347862f, 0.04609579f, -0.03346957f, -0.36024609f, -0.00133164f, -0.11164555f, 
    -0.25832990f, -0.02702169f, -0.07000602f, -0.12942165f, 0.05931455f, 0.16296963f, 0.05679436f, 0.00528171f, 
    0.06176016f, 0.17431837f, -0.05458515f, -0.06308062f, 0.30445269f, 0.01836132f, 0.11881223f, 0.19791098f, 
    -0.03122889f, -0.13400254f, 0.06165908f, 0.12955295f, -0.25221553f, -0.00261012f, -0.00903092f, 0.11738275f, 
    -0.13760778f, -0.15691480f, -0.12136085f, 0.16720574f, 0.01225837f, 0.05908734f, 0.00777074f, 0.09671298f, 
    -0.01724829f, 0.02713048f, 0.01344687f, 0.14435220f, 0.00911232f, 0.08456470f, 0.13907458f, 0.34310585f, 
    -0.00360545f, -0.06771505f, -0.03707265f, 0.13045770f, 0.01549189f, 0.04651434f, 0.05769151f, 0.10560978f, 
    0.05095364f, 0.04126552f, 0.09801441f, 0.02664619f, -0.03792896f, 0.02230768f, -0.08729833f, -0.12109577f, 
    0.00111052f, 0.03761811f, 0.10429510f, -0.02034564f, -0.12269535f, -0.05217953f, 0.01844330f, -0.00072845f, 
    -0.00971950f, -0.00373396f, 0.13488314f, 0.05997613f, 0.03422796f, 0.08425225f, 0.12504263f, -0.02325244f, 
    -0.19648500f, 0.09622421f, -0.01720696f, 0.16591258f, -0.04245095f, -0.02637632f, 0.02921185f, 0.11276812f, 
    -0.04730965f, 0.17876184f, -0.23659103f, -0.14888997f, -0.07780162f, -0.11581608f, -0.06859659f, -0.24431850f, 
    0.06452875f, 0.09639785f, -0.08496030f, -0.03851988f, -0.18945543f, -0.14972168f, -0.20180562f, -0.04829814f, 
    0.12468792f, 0.11807788f, 0.13323961f, 0.07459608f, -0.10818977f, -0.00441443f, -0.01744614f, -0.00013788f, 
    -0.08255550f, 0.07472859f, 0.06685822f, -0.07106511f, -0.02365787f, -0.00454398f, 0.22150491f, -0.16000868f, 
    -0.10894661f, -0.12744991f, -0.02644005f, 0.02309411f, 0.10704593f, -0.03354759f, 0.09438758f, -0.10777668f, 
    0.00534902f, -0.06198484f, -0.18757179f, -0.15722004f, -0.00158979f, -0.03133317f, 0.01353188f, 0.21850997f, 
    -0.11369175f, -0.07141936f, -0.03834180f, -0.03876575f, 0.21056290f, -0.16050000f, -0.04233205f, 0.12482262f, 
    -0.03471361f, 0.01284715f, 0.13970135f, -0.10292489f, -0.08043043f, -0.15314506f, -0.12036685f, -0.19553728f, 
    0.22990946f, -0.01468716f, 0.43378618f, -0.21764991f, -0.05577459f, -0.02296306f, -0.06034670f, -0.04798564f, 
    -0.03399424f, -0.09923701f, 0.01194212f, -0.00829613f, -0.00797579f, 0.12009633f, 0.34990487f, 0.11889020f, 
    -0.02716755f, -0.02760667f, -0.11092338f, -0.04965664f, -0.05110072f, 0.03554157f, 0.06955910f, 0.19608994f, 
    0.08993094f, 0.01385889f, -0.17458449f, -0.08474343f, -0.13672608f, -0.02050861f, -0.01001704f, -0.03723779f, 
    0.07029361f, 0.02230789f, -0.17818876f, -0.03077045f, 0.24608435f, -0.10859834f, 0.26204205f, -0.05426378f, 
    0.33954850f, 0.04659882f, 0.21112897f, 0.18630497f, 0.15604107f, -0.08428999f, 0.24867412f, 0.01220059f, 
    0.03463874f, -0.27776641f, -0.16208577f, 0.00889176f, 0.03891954f, -0.01534352f, -0.03033532f, 0.02712980f, 
    0.07806324f, 0.08549633f, -0.04601247f, -0.07243982f, -0.04535376f, 0.17193775f, 0.16659880f, 0.10085131f, 
    -0.11444603f, -0.08696068f, -0.03298913f, -0.00363092f, -0.15034936f, 0.17116706f, 0.04831888f, 0.06734725f, 
    -0.05585397f, 0.08661087f, -0.14542869f, -0.06961036f, -0.02050082f, 0.14513919f, 0.03576966f, 0.10089060f, 
    -0.09293265f, 0.15776612f, -0.05770704f, 0.20078979f, 0.03487611f, 0.13142891f, 0.04429208f, 0.14392021f, 
    -0.10839108f, -0.00800832f, -0.04136378f, -0.05048534f, 0.13792114f, -0.04643775f, 0.12706605f, 0.03755014f, 
    -0.07513902f, -0.00030093f, 0.02101040f, -0.06445509f, -0.06009355f, -0.00658760f, -0.05247515f, 0.06021545f, 
    -0.06009439f, 0.01756278f, 0.03153495f, 0.01740490f, -0.04030583f, 0.02883476f, 0.04985185f, -0.05458970f, 
    -0.01130116f, -0.05198491f, 0.02203099f, -0.06887012f, -0.05526645f, -0.00042103f, -0.04079891f, 0.02340764f, 
    -0.07000671f, -0.04470248f, 0.03098268f, -0.03579687f, 0.05841832f, 0.04074419f, 0.05381889f, -0.06572001f, 
    -0.06327464f, -0.00912945f, 0.01151521f, 0.03159814f, 0.02884533f, 0.00585235f, 0.04295939f, -0.02540227f, 
    -0.08052836f, -0.03847073f, 0.02862176f, -0.00398801f, 0.04251134f, -0.01088382f, -0.04358115f, 0.01507559f, 
    -0.02303438f, -0.04468089f, -0.04443092f, -0.00325570f, -0.04395798f, 0.03755721f, -0.05526892f, -0.02738951f, 
    -0.03853311f, -0.04874924f, -0.03568085f, 0.03139574f, -0.03707988f, 0.01665515f, 0.02687594f, 0.00295177f, 
    0.04096939f, -0.05201042f, -0.02495326f, -0.02214799f, 0.05587039f, -0.02285763f, -0.00065371f, 0.05615399f, 
    -0.06778064f, -0.01918282f, 0.00390294f, 0.02867970f, 0.00487943f, 0.02919018f, -0.01944261f, -0.04342787f, 
    0.00499094f, 0.05126711f, 0.04508822f, 0.05218622f, -0.01764652f, -0.03278514f, -0.02212245f, 0.05727939f, 
    0.05388968f, 0.02278662f, -0.00007819f, 0.04982224f, -0.07817956f, -0.07247349f, -0.02179585f, 0.04488559f, 
    -0.03949249f, 0.00845921f, 0.00533283f, -0.05344862f, -0.07127256f, -0.00343250f, -0.06996346f, 0.05024158f, 
    -0.07361810f, -0.03050574f, -0.02042862f, -0.06770331f, 0.02394778f, -0.07131056f, 0.00873361f, 0.04346076f, 
    -0.05179270f, -0.07353714f, -0.01691756f, 0.04677385f, -0.04479741f, 0.05466340f, -0.06300049f, -0.01751062f, 
    -0.01478422f, -0.00381892f, -0.06636211f, -0.04291863f, 0.02411824f, 0.02110257f, -0.06564028f, -0.04888567f, 
    -0.04327188f, -0.04752852f, -0.02166976f, -0.00100729f, -0.07424511f, -0.00890325f, -0.06988859f, 0.01867072f, 
    0.00387551f, -0.08185896f, -0.05988577f, 0.01012247f, 0.04261464f, -0.03365785f, -0.05785405f, 0.03152714f, 
    0.02683342f, -0.04142677f, 0.05626826f, 0.05760971f, 0.02151450f, -0.06951856f, 0.02302022f, 0.03894864f, 
    -0.05564383f, 0.05473669f, -0.03375001f, -0.02366659f, -0.00771645f, 0.04985579f, 0.04446105f, 0.04322916f, 
    0.01840317f, -0.00327003f, 0.03311140f, -0.03991610f, 0.04951266f, 0.00911025f, -0.08106019f, -0.06916562f, 
    -0.03222430f, 0.03356472f, 0.05178659f, 0.05375122f, -0.02374294f, 0.02124443f, -0.01797952f, 0.04249477f, 
    -0.08132325f, -0.03782201f, -0.07226490f, 0.00808806f, -0.07534220f, -0.02485645f, 0.01657853f, -0.05489949f, 
    0.04345162f, -0.01764912f, 0.00120532f, 0.05391590f, 0.04739094f, 0.00073281f, -0.00558484f, 0.05221431f, 
    0.16293468f, -0.06056229f, 0.40071651f, -0.01702600f, 0.07399272f, 0.02859160f, 0.01156831f, -0.06471470f, 
    0.00025381f, -0.14464378f, -0.03442192f, -0.04909573f, -0.24586162f, -0.05649131f, 0.15657662f, -0.01828514f, 
    0.09963106f, -0.14000079f, 0.00561367f, -0.02699612f, -0.23322622f, 0.04619102f, 0.21217199f, 0.02175022f, 
    0.32819337f, 0.07007485f, -0.25126508f, -0.14079760f, -0.07381190f, 0.09332429f, 0.09686778f, 0.16182955f, 
    0.00127166f, -0.01563292f, -0.06080741f, -0.00879306f, 0.01525822f, 0.21573351f, -0.07384631f, -0.13165098f, 
    -0.00992983f, -0.12953936f, -0.10537542f, 0.19268644f, -0.01987570f, 0.04477594f, 0.02078946f, 0.03890645f, 
    -0.20586738f, -0.14995687f, 0.02354825f, -0.08140591f, -0.07497992f, 0.06704218f, -0.07731321f, -0.00242734f, 
    0.06997982f, 0.02921607f, -0.06848169f, -0.13333021f, -0.10418247f, 0.18197276f, 0.14782429f, -0.06244413f, 
    0.07047902f, -0.03963814f, -0.13942190f, -0.11362521f, 0.05145896f, 0.09141501f, 0.16955824f, 0.04337484f, 
    0.16706161f, 0.25440273f, 0.22668111f, 0.26964772f, 0.00049805f, 0.01891037f, -0.04565321f, 0.06968533f, 
    -0.13359135f, 0.10114631f, 0.06509578f, -0.03197101f, 0.54402596f, 0.32627121f, 0.16310443f, 0.12813711f, 
    0.22220363f, 0.03067272f, 0.17045099f, -0.06668054f, 0.19747412f, 0.04255426f, -0.04200719f, -0.00270098f, 
    0.02884131f, 0.07697038f, 0.20908895f, -0.14026499f, 0.10065684f, 0.09134438f, -0.16115525f, 0.05253787f, 
    0.05503570f, 0.06105111f, -0.14405958f, -0.18526664f, -0.43814039f, -0.53165835f, 0.21235619f, 0.01011902f, 
    -0.13510519f, 0.13298151f, -0.33513695f, -0.22991914f, 0.05164037f, 0.06305484f, -0.02277995f, 0.07582864f, 
    0.13409448f, 0.09558566f, -0.29612547f, 0.10078678f, -0.01573441f, 0.09789132f, 0.00725223f, 0.11555469f, 
    0.09644810f, 0.09316030f, -0.26676920f, 0.10098100f, 0.05309878f, -0.05295925f, -0.12901711f, 0.09799623f, 
    0.02817344f, 0.13394004f, -0.24845175f, 0.12079387f, 0.16340746f, -0.05600848f, 0.18536659f, 0.02957004f, 
    0.29917318f, -0.12569299f, 0.00157519f, 0.22820440f, 0.03337414f, 0.07873192f, 0.13008414f, 0.00222082f, 
    0.09298868f, 0.11687035f, 0.03990076f, 0.20529817f, -0.34530339f, -0.01410168f, -0.12315653f, -0.07856528f, 
    -0.08945934f, -0.17684005f, -0.21864262f, -0.12217141f, -0.13160661f, 0.08838002f, 0.05360293f, 0.19520263f, 
    -0.04628126f, -0.01405523f, -0.16940874f, -0.31675708f, 0.10221013f, -0.16802371f, 0.02957210f, -0.02054484f, 
    -0.08100805f, 0.08388576f, -0.06760679f, -0.03736676f, -0.17365898f, -0.02095552f, -0.19090766f, 0.03562019f, 
    -0.09783214f, -0.04635995f, -0.20188978f, -0.10843837f, 0.07793893f, -0.01164466f, 0.15379490f, 0.04116039f, 
    -0.01079276f, 0.03020362f, 0.08329747f, -0.07254979f, 0.05678594f, -0.02255881f, 0.20108847f, -0.06380749f, 
    0.02122235f, -0.08280795f, -0.03517185f, 0.14338192f, 0.02867246f, -0.05202733f, 0.00074947f, 0.09911503f, 
    0.05149473f, -0.17337587f, 0.20654750f, -0.05018017f, -0.27341112f, -0.06138785f, -0.07875933f, -0.17355470f, 
    0.02390097f, -0.03095474f, 0.07436931f, 0.09080461f, -0.08287749f, -0.04579121f, -0.07421952f, 0.01192033f, 
    -0.05445538f, -0.03881598f, -0.07730328f, -0.03663625f, -0.02918349f, 0.23065738f, 0.06357060f, 0.08731946f, 
    0.10690793f, -0.01466320f, -0.16020596f, 0.07851142f, 0.15189849f, 0.06772836f, 0.06518935f, 0.05065008f, 
    -0.29250187f, -0.27010882f, 0.07955991f, 0.09719344f, -0.07804678f, -0.12093667f, -0.08336329f, 0.03874607f, 
    -0.14495109f, -0.08097372f, -0.03272266f, -0.30778867f, 0.31481767f, 0.02402956f, -0.00913452f, 0.00300151f, 
    0.10936192f, -0.03286840f, -0.02866996f, -0.04147540f, 0.12531263f, 0.06239108f, 0.01047183f, -0.03982943f, 
    0.07856527f, 0.25345472f, 0.12057211f, 0.16001733f, 0.06759531f, 0.05416464f, 0.01017424f, 0.06013483f, 
    -0.03565123f, -0.00553347f, -0.11266987f, -0.13205287f, 0.12219547f, 0.27053294f, 0.30552286f, 0.23910286f, 
    0.08509669f, 0.00231206f, -0.06485943f, -0.11215580f, 0.03849081f, 0.06514229f, -0.07145436f, 0.10839595f, 
    0.32901841f, 0.00085093f, 0.06372089f, -0.00466991f, 0.02147489f, 0.02940305f, 0.03133528f, 0.06576276f, 
    0.07020711f, -0.02533049f, -0.08015227f, -0.11815887f, -0.41560739f, -0.50823426f, -0.01721177f, -0.00182848f, 
    -0.13139860f, 0.04417463f, 0.04092354f, -0.02198531f, -0.16304478f, -0.20697172f, 0.08488391f, -0.07879292f, 
    0.12138133f, 0.01899150f, -0.09960330f, -0.05894314f, -0.02638365f, 0.13747315f, 0.10957536f, -0.00381796f, 
    0.12499993f, 0.10572617f, -0.13121185f, -0.18339656f, 0.19342591f, -0.05137466f, -0.14935753f, 0.05963561f, 
    -0.17912599f, 0.12709858f, -0.11515485f, -0.01661019f, 0.08165107f, -0.09040699f, 0.13405322f, 0.09427944f, 
    0.21725966f, 0.09401558f, 0.00778848f, 0.32447615f, 0.18619029f, 0.09604952f, 0.14807414f, 0.00461032f, 
    0.06904805f, 0.02577228f, 0.05087621f, 0.22857286f, -0.47288471f, -0.03533141f, -0.15682781f, -0.14704010f, 
    0.15942569f, -0.08170206f, -0.12489399f, -0.06590713f, 0.02857890f, -0.07337266f, 0.07338497f, 0.17948230f, 
    0.01637123f, 0.16196114f, -0.11508571f, -0.25166148f, 0.10108925f, -0.05028266f, -0.01357585f, -0.05004442f, 
    0.05871037f, -0.02157693f, -0.08568433f, -0.05500678f, -0.21295990f, -0.04320783f, -0.15033095f, 0.00970053f, 
    -0.00287777f, -0.02433840f, 0.03115612f, 0.00155631f, 0.10470850f, 0.00653810f, 0.02107053f, 0.03857433f, 
    0.07311637f, -0.06219902f, 0.02218083f, -0.00904785f, 0.03680255f, 0.00045687f, 0.04246255f, 0.07432160f, 
    0.12672539f, 0.15974790f, 0.11133976f, 0.17432562f, 0.33596322f, 0.00490540f, -0.10896388f, -0.03798570f, 
    0.09590481f, 0.04365280f, -0.05872399f, -0.03231662f, 0.09004464f, 0.08559720f, -0.04146817f, -0.04405408f, 
    -0.10230472f, 0.46254203f, 0.12808761f, -0.01995936f, 0.01362194f, -0.06153380f, -0.08357518f, -0.00792093f, 
    0.11469208f, 0.04888144f, 0.11418842f, 0.11513987f, -0.17136541f, 0.07379442f, 0.15818349f, 0.17276256f, 
    0.17275116f, 0.11956446f, 0.06641439f, 0.03155432f, 0.08776537f, -0.07101783f, -0.08247176f, -0.15502617f, 
    -0.22952232f, -0.19292906f, -0.30832204f, 0.02556393f, 0.06256892f, 0.07802070f, 0.09109802f, 0.17274359f, 
    -0.02257749f, -0.02036308f, -0.07680497f, -0.04974628f, -0.04140866f, -0.04037961f, -0.40743691f, -0.05225743f, 
    0.05405759f, 0.10335253f, 0.13936451f, 0.14988436f, -0.08623969f, 0.21721397f, 0.08053424f, -0.04946367f, 
    -0.17030059f, -0.03429065f, -0.01232386f, 0.00622783f, -0.08343336f, -0.01639760f, 0.00028486f, -0.08111909f, 
    0.01960325f, 0.06210725f, -0.07332181f, -0.01781120f, -0.48839438f, 0.06637855f, 0.31574026f, -0.11552133f, 
    -0.10477401f, -0.00957057f, 0.04565057f, 0.24237154f, -0.07796529f, -0.10976978f, 0.02021661f, 0.16960222f, 
    -0.00711832f, 0.16232468f, -0.44644102f, 0.26769897f, 0.11145205f, 0.01592023f, -0.17323273f, 0.00548668f, 
    0.06091597f, -0.09430955f, 0.04815118f, -0.00555921f, 0.07151262f, 0.00245408f, -0.36495999f, -0.02612004f, 
    -0.10923972f, -0.04596028f, 0.17734699f, 0.19269575f, -0.07675483f, -0.03360821f, 0.02000554f, -0.18490638f, 
    -0.04276134f, -0.19631569f, 0.15358315f, 0.11125392f, 0.14147213f, 0.09542511f, 0.07185438f, 0.02374132f, 
    0.03683090f, -0.08338897f, 0.00076698f, -0.10525125f, -0.02232231f, 0.09518759f, -0.51400489f, 0.21325414f, 
    0.00059845f, 0.13422367f, 0.00677059f, -0.12063327f, 0.00386630f, 0.03631433f, -0.09723902f, -0.06214079f, 
    -0.03493629f, 0.06794529f, 0.14031605f, -0.10744161f, -0.18431465f, -0.20076679f, -0.04640542f, 0.02306805f, 
    0.00667620f, -0.08771310f, -0.07607088f, -0.01510413f, 0.08663628f, -0.18937652f, -0.19133632f, -0.32528216f, 
    -0.01140354f, 0.10082012f, 0.00663276f, -0.02861541f, 0.23713374f, -0.13685896f, 0.04644727f, 0.00719449f, 
    0.00144832f, 0.02239001f, 0.15331759f, 0.04371095f, -0.04825840f, -0.11575139f, -0.17354439f, -0.04209856f, 
    0.04171364f, 0.08710898f, 0.03148727f, -0.10247522f, 0.09026914f, -0.16677716f, 0.01155977f, -0.06094754f, 
    0.07912762f, 0.03612588f, 0.08727176f, 0.21532708f, 0.03054799f, 0.23818056f, -0.05293684f, 0.11384483f, 
    0.29852536f, -0.10036439f, 0.41019344f, -0.16625087f, -0.13852124f, 0.08379949f, -0.15363277f, -0.17811745f, 
    0.03195666f, 0.04344064f, 0.00563079f, -0.01650484f, -0.02864973f, -0.09092552f, 0.19291128f, -0.08633078f, 
    0.00932700f, -0.02798399f, -0.10149243f, -0.10591397f, -0.01218464f, -0.02892646f, -0.06239985f, -0.09543591f, 
    -0.04550330f, 0.36949041f, 0.05555644f, -0.01296718f, -0.18937373f, -0.04925264f, -0.11757620f, 0.06626382f, 
    -0.11594719f, 0.06625526f, 0.03950276f, -0.22714993f, -0.20205571f, -0.05497012f, -0.17590176f, -0.19582710f, 
    -0.12892614f, -0.05474684f, -0.10335103f, -0.05329986f, -0.20349494f, -0.04987076f, -0.18649989f, 0.22792299f, 
    -0.08791549f, -0.04976453f, 0.03695565f, 0.06009342f, -0.06478839f, -0.14597696f, -0.00088638f, -0.11536713f, 
    -0.09847181f, -0.15567172f, -0.06543525f, -0.06998673f, -0.21929814f, 0.00096891f, 0.03396031f, 0.13374621f, 
    -0.13678174f, 0.03100394f, 0.27113023f, 0.12429439f, 0.13901122f, 0.16801237f, -0.25697780f, -0.07380519f, 
    -0.08805294f, -0.21089248f, -0.13709569f, -0.10030981f, 0.07475966f, -0.00696209f, 0.08757013f, 0.19856535f, 
    -0.15956259f, -0.07480647f, -0.03384469f, -0.11590737f, 0.36418387f, -0.17822112f, -0.14924282f, 0.02447851f, 
    0.07137238f, 0.00871855f, 0.16625525f, -0.04683491f, -0.03869491f, -0.11640298f, -0.08654280f, 0.05321040f, 
    -0.13046958f, 0.26155671f, 0.16146293f, -0.08002239f, -0.13514210f, 0.05627174f, -0.05510351f, 0.05741945f, 
    -0.12183829f, -0.13095626f, -0.07086301f, -0.11625967f, -0.02165580f, 0.26595888f, 0.18094659f, 0.03496948f, 
    0.02803495f, -0.12828316f, -0.17466539f, -0.14543097f, -0.04801223f, -0.09087026f, -0.08412804f, 0.05412969f, 
    -0.03337884f, 0.01228350f, -0.40002215f, -0.11153574f, 0.02773936f, -0.06873383f, 0.00626612f, -0.03433839f, 
    -0.02712595f, -0.01690359f, -0.14402135f, 0.06766807f, 0.16540645f, 0.44541556f, -0.07546999f, -0.02037699f, 
    0.10987984f, 0.05232449f, -0.01599123f, 0.12864275f, 0.12942612f, -0.00814986f, 0.19815828f, 0.14893831f, 
    0.14901124f, -0.19827993f, 0.09740285f, 0.07525421f, -0.03524105f, 0.10376462f, -0.00596896f, -0.03515785f, 
    0.12384665f, 0.00123575f, 0.00197818f, -0.05186665f, -0.01409281f, 0.07957231f, 0.16654271f, 0.03313425f, 
    -0.07235027f, -0.01638852f, -0.15099539f, -0.07578065f, -0.06589176f, 0.02249383f, -0.02679528f, 0.25087723f, 
    0.21528120f, 0.11112695f, 0.23579007f, 0.17584515f, -0.07423504f, -0.03947625f, -0.12730083f, 0.00450062f, 
    -0.06900428f, 0.25266051f, 0.02815706f, 0.03361571f, 0.19177666f, 0.19024302f, 0.14226145f, 0.06775390f, 
    -0.13273250f, -0.06608658f, -0.02300674f, -0.01442883f, 0.05741706f, 0.04301935f, 0.11960631f, 0.04093847f, 
    0.06943741f, 0.06704310f, -0.02415522f, -0.01903500f, 0.03089970f, -0.01270643f, -0.05692542f, -0.06420955f, 
    -0.01098355f, -0.06554931f, -0.04076706f, -0.00769059f, 0.04630859f, -0.00888353f, -0.09025189f, 0.02928564f, 
    0.00039430f, -0.05154621f, -0.02402302f, -0.03811922f, 0.02741393f, -0.02638855f, -0.00075908f, -0.01316454f, 
    -0.05949858f, 0.02437981f, -0.08574678f, 0.02430581f, 0.00665305f, 0.01100510f, 0.05481860f, -0.07048187f, 
    0.03538405f, -0.05889628f, 0.03997761f, 0.03644892f, -0.03498290f, -0.06575904f, 0.01692237f, -0.04382909f, 
    -0.00755792f, -0.00708148f, 0.06320934f, 0.03989769f, -0.00133896f, -0.01452283f, -0.01662811f, -0.01880808f, 
    -0.06063927f, 0.03459155f, -0.05876690f, -0.00733947f, -0.06466362f, 0.03242420f, -0.06516051f, 0.03094994f, 
    0.04847807f, -0.03675703f, -0.09239629f, 0.01504029f, 0.01848473f, -0.01654833f, 0.05062035f, -0.05884365f, 
    -0.00276064f, -0.02922364f, 0.02269707f, 0.00674164f, -0.03833355f, 0.03091323f, -0.05352834f, -0.02981802f, 
    0.03775312f, -0.01590713f, 0.04749996f, -0.06198453f, 0.00357060f, 0.02436780f, -0.04319882f, 0.05121668f, 
    -0.01257248f, -0.06007086f, -0.06162352f, 0.04232572f, -0.07868033f, -0.01321019f, -0.03476902f, -0.07697207f, 
    -0.00360409f, -0.06651106f, 0.05252621f, -0.02660036f, 0.02723788f, -0.07847356f, -0.06984947f, 0.01371502f, 
    0.05554697f, 0.01707065f, 0.01307148f, -0.00306298f, 0.02789273f, 0.03371836f, -0.04851143f, 0.04662369f, 
    0.01982728f, 0.00054691f, 0.04711017f, -0.00343632f, -0.06211982f, 0.00239631f, -0.06021488f, 0.04053277f, 
    0.05005537f, 0.04740449f, -0.06199773f, -0.08545037f, 0.04079804f, 0.04761222f, -0.02631684f, 0.00673860f, 
    0.00236377f, -0.04721799f, -0.06446663f, -0.05383388f, -0.02929795f, -0.01225293f, -0.04368448f, 0.02544027f, 
    0.00492457f, 0.05358479f, -0.05561360f, -0.06396364f, -0.04005487f, -0.04977577f, -0.08162174f, -0.05572619f, 
    0.05381062f, 0.01288543f, -0.07815471f, 0.02303286f, -0.06681956f, -0.08688524f, -0.01411227f, 0.00329086f, 
    0.05213549f, 0.06405828f, 0.04655083f, -0.03705874f, -0.06258637f, -0.01529377f, 0.06861392f, -0.02219829f, 
    -0.03533744f, -0.03012602f, -0.04477868f, -0.05475263f, 0.01517502f, 0.04915232f, 0.01867672f, -0.05857180f, 
    0.03992983f, 0.02115198f, -0.02123499f, -0.01173493f, -0.03810602f, -0.06716795f, -0.00850991f, -0.04149014f, 
    0.04051499f, 0.04000118f, -0.00159381f, 0.03173736f, -0.09079008f, 0.00649406f, -0.02668391f, -0.03290598f, 
    0.01778384f, -0.02244599f, -0.07259802f, -0.01829886f, 0.05128236f, 0.05242504f, 0.01226963f, -0.07367247f, 
    0.04708999f, 0.02260698f, -0.06884076f, -0.05999431f, -0.01304908f, 0.01885095f, 0.02057797f, -0.05426828f, 
    -0.26801899f, 0.10165271f, -0.10585785f, 0.09623130f, 0.06759891f, -0.11542451f, 0.07720267f, 0.01898769f, 
    0.03858380f, 0.05286615f, 0.03998250f, -0.01376508f, -0.13589767f, -0.07953613f, -0.33884174f, -0.03907350f, 
    -0.00853786f, 0.01800239f, 0.05021767f, -0.01796985f, 0.18746831f, 0.05780993f, 0.07356071f, -0.15102868f, 
    -0.32506916f, -0.07621460f, -0.09512894f, 0.06405621f, 0.06128987f, 0.19796263f, -0.09160638f, -0.09532419f, 
    0.12327899f, 0.01495829f, -0.01318163f, 0.34712473f, -0.01174681f, 0.10213697f, 0.24534415f, -0.01792054f, 
    0.15773746f, 0.01775054f, -0.01180012f, 0.08142975f, -0.11534066f, -0.15400259f, -0.20093790f, -0.36216560f, 
    0.14464724f, 0.01766415f, 0.09731004f, -0.07920795f, 0.09659774f, 0.08508421f, -0.05430287f, 0.05872126f, 
    0.09204085f, 0.09402709f, -0.05386790f, 0.00366185f, -0.20269437f, 0.20421600f, 0.18871231f, -0.13676052f, 
    0.01193051f, -0.03830098f, -0.19436416f, -0.03821160f, -0.00745056f, -0.14207436f, 0.27762538f, 0.08067274f, 
    -0.05975531f, -0.13885714f, -0.06846838f, 0.08054592f, 0.03534559f, 0.16233279f, 0.04054293f, 0.13289766f, 
    0.05152896f, 0.07832371f, -0.17370331f, 0.04794314f, -0.21114986f, 0.26140636f, -0.01945692f, -0.19941641f, 
    0.04732912f, -0.01989979f, 0.07484995f, 0.00236198f, -0.09200035f, -0.01339245f, -0.01776087f, -0.08273019f, 
    0.15227129f, -0.12034009f, 0.49661416f, 0.10726316f, 0.15549599f, -0.11715352f, -0.17160232f, 0.15938011f, 
    -0.12554206f, 0.03921818f, -0.11975691f, 0.05872686f, 0.13433377f, -0.04073974f, 0.38434517f, 0.16988538f, 
    0.05308383f, -0.06099038f, -0.10753030f, -0.03881515f, -0.01151404f, 0.01283388f, 0.08198735f, -0.14698771f, 
    0.09812953f, 0.02669629f, 0.26787889f, 0.18861532f, 0.11965865f, 0.11034442f, -0.05677582f, -0.00990122f, 
    -0.01226408f, -0.02786937f, -0.17609034f, 0.00376959f, 0.25093508f, -0.40391782f, 0.51209927f, 0.19707686f, 
    0.41095793f, -0.03680468f, 0.30566457f, 0.14117649f, -0.10063253f, -0.02062050f, 0.12041757f, -0.01799621f, 
    -0.17796527f, -0.24590838f, -0.13277881f, -0.04131553f, -0.09343697f, -0.12573662f, -0.10347721f, -0.02155533f, 
    -0.09827773f, -0.06466570f, -0.07571186f, -0.08600046f, 0.26461604f, 0.19196823f, 0.07617066f, 0.14388946f, 
    -0.03904523f, -0.02100148f, -0.03225174f, 0.12531853f, 0.01954243f, 0.01753728f, -0.10049916f, -0.06916108f, 
    -0.21202253f, 0.01429306f, -0.24502414f, -0.07780144f, -0.11163262f, -0.02912942f, -0.00773590f, -0.00023825f, 
    -0.11453105f, -0.07765564f, 0.06345171f, 0.03585275f, 0.19287634f, 0.18196358f, 0.09499574f, 0.07207966f, 
    -0.00630376f, -0.17797221f, -0.03238745f, -0.07813293f, -0.11794673f, -0.09492126f, 0.04748606f, -0.14119893f, 
    -0.09333799f, -0.10027251f, 0.06543402f, -0.07278652f, 0.03199450f, -0.10181499f, 0.05595306f, 0.08324257f, 
    0.10028952f, 0.21018150f, 0.17939812f, 0.08268987f, 0.06579854f, -0.08662876f, -0.18963225f, -0.07476596f, 
    -0.04503254f, -0.04080623f, -0.06272410f, -0.03067828f, 0.15118065f, 0.10020431f, 0.04308218f, 0.04790273f, 
    -0.30778486f, 0.07847869f, -0.30691275f, -0.13800986f, -0.03234077f, 0.14203280f, 0.00012772f, -0.19652413f, 
    0.25906309f, 0.01593939f, 0.03205157f, 0.33495748f, 0.17389795f, 0.20669101f, 0.07210007f, 0.05424671f, 
    0.06096334f, 0.09897108f, 0.15411778f, -0.19719307f, -0.11131870f, 0.00138739f, 0.04843351f, -0.11911055f, 
    -0.10399073f, -0.10072411f, -0.11185316f, -0.03131092f, 0.20013079f, 0.11109919f, -0.03338671f, 0.02371063f, 
    0.09107333f, 0.06269824f, -0.07327390f, 0.13583139f, -0.16225539f, 0.21440507f, -0.28526509f, -0.06088021f, 
    0.05442994f, 0.09972695f, -0.02794859f, 0.02285311f, -0.25307143f, -0.02325314f, 0.03114934f, -0.19904135f, 
    -0.17163116f, -0.04548828f, -0.03197352f, -0.07784999f, 0.01271526f, 0.09115398f, 0.10279059f, 0.03821769f, 
    0.16633418f, 0.11655243f, -0.02508659f, 0.01650917f, -0.29424787f, 0.12698555f, -0.10191398f, -0.26586732f, 
    -0.03100770f, 0.21201840f, 0.16070449f, 0.11747961f, -0.09152799f, -0.04832131f, -0.00719181f, -0.17142580f, 
    -0.19182086f, 0.13735145f, 0.04673419f, 0.22384237f, 0.14593430f, 0.08222733f, -0.07055743f, 0.12270275f, 
    0.01555257f, 0.00431169f, 0.07561431f, 0.12587631f, 0.14744924f, 0.02461793f, -0.17289591f, 0.11428846f, 
    0.16719741f, -0.08722688f, 0.01457038f, 0.00867185f, 0.07340766f, 0.00494041f, 0.00835793f, 0.00315150f, 
    0.00699807f, -0.02489415f, 0.30123171f, 0.30188191f, 0.17935954f, 0.05236010f, 0.00123236f, 0.09643156f, 
    -0.02037246f, -0.01802652f, -0.01602171f, 0.11375385f, -0.07685212f, -0.31407639f, -0.06481020f, 0.22102873f, 
    0.28298005f, -0.02293063f, 0.19130856f, 0.06938208f, -0.25393704f, 0.03413001f, -0.14967285f, 0.04540971f, 
    -0.12290921f, 0.16475700f, 0.18830718f, -0.22723258f, -0.01957056f, -0.08960724f, 0.11183905f, 0.20349684f, 
    -0.18181434f, -0.08773155f, 0.03097396f, -0.08024554f, 0.16654210f, -0.12038421f, -0.09487934f, -0.09344587f, 
    0.00665262f, 0.11105885f, 0.01291173f, -0.07713877f, 0.01686104f, -0.05618680f, -0.01887019f, -0.16954142f, 
    -0.18506342f, -0.05785693f, -0.02977881f, -0.11093990f, -0.11306072f, -0.07375589f, -0.01488670f, -0.03562406f, 
    0.09112753f, 0.00103903f, 0.22774021f, 0.05203183f, 0.12070649f, -0.01278074f, 0.01559250f, -0.00141224f, 
    0.03699987f, -0.01308976f, -0.00745807f, -0.04525126f, -0.13764657f, 0.02603903f, 0.01063910f, -0.03291834f, 
    -0.29485938f, 0.04841378f, -0.04349802f, 0.04548869f, 0.05261007f, -0.00218705f, 0.03362244f, 0.18153290f, 
    -0.04199499f, 0.04058252f, 0.07538862f, 0.08182006f, -0.13368799f, 0.01782239f, -0.17952141f, 0.00247980f, 
    -0.05891431f, -0.04369418f, 0.00455541f, 0.02338381f, 0.02383170f, -0.02741681f, -0.07400082f, -0.32056931f, 
    0.13488109f, 0.20064251f, 0.01633444f, -0.03670527f, 0.18128233f, -0.10146149f, -0.13310868f, -0.10870212f, 
    0.10046128f, 0.05638484f, 0.13030234f, 0.16656153f, -0.16962385f, 0.01329679f, 0.24106003f, 0.06725754f, 
    0.03296298f, 0.05411863f, 0.10209779f, -0.00711179f, -0.02229700f, 0.01520173f, -0.06371094f, -0.01127065f, 
    0.08951766f, -0.18080221f, -0.12264406f, -0.11418308f, -0.02818872f, -0.05887197f, 0.01175442f, 0.04665033f, 
    -0.04982219f, -0.04974746f, -0.19708832f, -0.04247518f, 0.04896181f, 0.00632293f, 0.18388124f, -0.38798609f, 
    0.04001980f, 0.02753810f, 0.01161675f, -0.01522952f, 0.09459774f, 0.11053689f, 0.18540944f, 0.02168649f, 
    -0.12840679f, -0.11255206f, -0.10218064f, 0.03316545f, -0.06641976f, -0.02821787f, 0.09392409f, -0.07150733f, 
    0.06596056f, -0.00908273f, -0.11227108f, -0.13442709f, -0.46151590f, 0.30347881f, 0.26018339f, -0.24843395f, 
    -0.08483163f, 0.00845029f, 0.07019260f, 0.08628567f, 0.01029380f, 0.08570216f, 0.09708292f, 0.04681364f, 
    0.30065665f, -0.16134530f, 0.13265494f, -0.09112131f, 0.05860407f, 0.04605870f, 0.05573089f, 0.07937175f, 
    -0.03583645f, 0.11328605f, 0.01896756f, 0.01123664f, 0.31354997f, -0.11420339f, 0.03065418f, 0.05088808f, 
    -0.07912045f, 0.02946482f, 0.00043835f, 0.12932716f, -0.10497065f, -0.03694430f, -0.02296639f, -0.26634467f, 
    0.01024529f, -0.26575297f, 0.08121225f, 0.13260223f, -0.03370228f, 0.12715235f, -0.01557758f, 0.12061918f, 
    0.04051972f, -0.03459809f, -0.12580319f, 0.01123078f, 0.24028875f, -0.43385488f, -0.16638975f, 0.20186217f, 
    0.08022505f, -0.04403900f, 0.04370571f, -0.12469771f, 0.05754474f, 0.08832701f, -0.03835159f, 0.02788519f, 
    -0.20594491f, -0.00714226f, 0.28385720f, -0.02996716f, -0.05326769f, -0.13876928f, 0.01002284f, 0.03540699f, 
    0.06372550f, 0.09059794f, 0.14058577f, 0.13695379f, 0.31550625f, -0.00944692f, -0.00617871f, 0.05577873f, 
    -0.00861426f, -0.02306678f, 0.01383222f, -0.03551207f, 0.09546214f, 0.03490855f, -0.03846671f, -0.19699681f, 
    -0.11686071f, -0.06365233f, -0.04182349f, -0.17576855f, 0.03483586f, -0.04455301f, -0.17609869f, 0.04200097f, 
    -0.08061191f, -0.02943606f, 0.14387484f, 0.08857576f, 0.01446200f, 0.10411880f, -0.00355671f, 0.06864443f, 
    -0.02916943f, -0.12103081f, 0.00508005f, 0.01947067f, -0.07845230f, 0.08264888f, 0.15289253f, 0.00374959f, 
    -0.20160314f, -0.13225834f, 0.25306779f, -0.03790305f, 0.03790588f, 0.15021801f, -0.04317956f, -0.01648250f, 
    -0.06353819f, -0.01687173f, 0.07097242f, 0.06283740f, 0.30170107f, -0.19985612f, -0.03247906f, -0.03034146f, 
    0.00955412f, 0.02339067f, -0.15725186f, 0.01766883f, -0.01126406f, 0.01310411f, 0.10226405f, 0.01578735f, 
    -0.19561027f, 0.54684931f, -0.02781922f, -0.16891934f, -0.08065737f, 0.00644342f, -0.09031676f, -0.05175593f, 
    0.07153060f, 0.14724998f, -0.03655946f, 0.29162478f, -0.19859233f, -0.00383345f, 0.10603810f, 0.24181400f, 
    -0.02527746f, -0.01717546f, 0.01576127f, 0.06782672f, 0.08351020f, -0.00921787f, -0.00923313f, -0.12042917f, 
    -0.32687905f, -0.26573753f, -0.09671449f, -0.13816637f, 0.16337773f, -0.11477315f, 0.10527220f, 0.07903700f, 
    -0.02028240f, -0.04905203f, 0.00871580f, -0.07642755f, -0.05364840f, 0.11957934f, 0.10465638f, 0.07770427f, 
    -0.02478427f, -0.09543309f, 0.00915397f, 0.05445263f, 0.08535068f, 0.13669108f, 0.07466883f, -0.17027172f, 
    -0.01867797f, -0.00183457f, -0.05595229f, 0.12571485f, 0.03478982f, -0.00472787f, -0.02916536f, 0.04332081f, 
    0.27172428f, 0.02781831f, 0.04862041f, 0.09971370f, -0.15213011f, 0.28983966f, 0.46511880f, -0.08567128f, 
    0.06361835f, -0.00581180f, -0.10718130f, 0.08388364f, -0.07148597f, -0.03140305f, 0.04297255f, 0.19084843f, 
    0.12046061f, -0.14886069f, -0.05476294f, -0.00354285f, -0.07135859f, -0.12820248f, -0.01390937f, 0.22300062f, 
    0.09730799f, 0.11473785f, -0.00169805f, -0.08568709f, -0.15515818f, -0.06646415f, -0.07115354f, 0.04035248f, 
    0.01668049f, -0.10533349f, -0.02693769f, -0.06512113f, 0.08039705f, -0.02975261f, -0.03916477f, -0.04754673f, 
    0.15055726f, -0.21620959f, -0.05413027f, 0.08351209f, -0.04259707f, 0.03073888f, 0.11625985f, -0.12073732f, 
    0.04909457f, 0.10581115f, -0.04711989f, 0.01975294f, 0.31672555f, 0.30030575f, -0.46524975f, 0.41490710f, 
    -0.16564268f, -0.17828043f, -0.03213920f, -0.20771234f, 0.02856831f, -0.04571131f, 0.13435730f, 0.09949914f, 
    0.09252436f, 0.04844265f, 0.37308288f, 0.21161748f, -0.08673760f, -0.10285524f, -0.01456644f, -0.11095239f, 
    -0.11406856f, -0.12028517f, 0.09565966f, 0.07714164f, -0.18118435f, -0.12369669f, -0.04522174f, -0.27406299f, 
    0.10518511f, 0.09349096f, -0.31526285f, -0.09725012f, 0.11495872f, -0.11777218f, -0.04368901f, 0.00812523f, 
    0.07488430f, 0.05558623f, 0.09345880f, -0.03200548f, 0.12644577f, -0.05146098f, -0.19473597f, -0.07516064f, 
    -0.11811453f, 0.05698721f, 0.12748429f, -0.03929447f, -0.00621602f, -0.03750607f, -0.00646385f, -0.06090770f, 
    0.13412592f, -0.10244513f, -0.01711788f, -0.10129296f, -0.04226657f, 0.14249803f, 0.13913634f, -0.01091926f, 
    0.31350231f, -0.16531275f, 0.27465457f, -0.10844260f, 0.10467732f, -0.07618725f, -0.09623016f, -0.12616189f, 
    0.06674688f, 0.02651822f, 0.01191662f, -0.09058816f, -0.09505535f, -0.32347965f, -0.08983220f, -0.23053508f, 
    0.06660347f, -0.10404467f, 0.06695488f, -0.12634447f, -0.01533316f, -0.12460913f, 0.01748721f, -0.03018090f, 
    -0.01018997f, 0.03453889f, -0.33972409f, -0.41551343f, -0.02154815f, 0.23633228f, 0.04849279f, 0.12430747f, 
    -0.07459509f, -0.01413839f, 0.00165804f, 0.01861362f, 0.16124387f, 0.29293180f, -0.22864954f, -0.36987847f, 
    -0.04402934f, -0.09949826f, -0.07633758f, 0.11531306f, -0.04349467f, -0.00841311f, 0.02850541f, 0.14672458f, 
    -0.02997728f, 0.07648366f, 0.14806160f, -0.18611094f, -0.02150894f, -0.00467806f, 0.03840760f, 0.12535633f, 
    0.07330036f, -0.10696829f, -0.01255925f, -0.03577063f, -0.32393980f, 0.26175177f, -0.20159616f, -0.02946901f, 
    0.02802931f, 0.04267409f, 0.10725576f, 0.13996103f, 0.00720403f, 0.09810977f, 0.07190756f, 0.08979243f, 
    -0.03405070f, 0.03557435f, 0.04410143f, -0.03669983f, 0.05767613f, 0.07782399f, 0.03223624f, -0.01451703f, 
    -0.13038826f, -0.08159028f, -0.08044741f, -0.05400743f, 0.49560741f, 0.05572031f, -0.38184950f, -0.19821233f, 
    0.06221968f, 0.04851183f, 0.29460490f, 0.16798691f, 0.08233710f, -0.06376622f, -0.00588298f, 0.01889461f, 
    -0.39724717f, 0.40537661f, -0.06987897f, 0.02846557f, 0.06777016f, -0.02591150f, -0.02447243f, 0.05757739f, 
    -0.03002235f, 0.11130811f, -0.02651163f, -0.09568513f, -0.16989191f, -0.29785064f, 0.26536167f, 0.07480357f, 
    0.01311002f, 0.00852965f, -0.29338446f, -0.13353582f, 0.17722979f, -0.05422669f, -0.21410494f, 0.01719382f, 
    -0.00382912f, 0.18437666f, -0.19956328f, -0.06024375f, 0.10589238f, 0.10321281f, -0.07734408f, -0.01264881f, 
    0.09504300f, 0.04996648f, 0.01497730f, 0.20718800f, -0.29375437f, -0.10351870f, 0.08392357f, 0.10483237f, 
    0.24559301f, 0.07957826f, 0.04583890f, 0.25907925f, 0.12713006f, -0.00063016f, 0.12298300f, 0.02651273f, 
    0.16360033f, -0.03764185f, 0.00078846f, -0.17789315f, 0.08862524f, 0.07902827f, -0.00445158f, -0.10862529f, 
    0.12005822f, 0.01005531f, 0.10472160f, 0.04881324f, 0.14434664f, 0.03089477f, -0.00397153f, -0.09022536f, 
    -0.04388995f, -0.14213480f, -0.15581545f, 0.06212620f, -0.13464662f, -0.12833263f, -0.05117988f, 0.16857667f, 
    0.03420846f, -0.15964969f, 0.08307429f, 0.08387505f, -0.04468591f, 0.08622911f, 0.07653409f, -0.03280212f, 
    0.18055637f, 0.08502582f, -0.07652847f, -0.15791403f, 0.20677899f, -0.02176723f, 0.11834849f, 0.17833835f, 
    -0.07385655f, -0.01191354f, -0.05540217f, 0.03341891f, -0.06364009f, -0.05096970f, 0.12971143f, -0.08965075f, 
    -0.03961023f, 0.20709339f, -0.16439924f, -0.04041864f, -0.01132761f, 0.03215804f, -0.01582785f, -0.23981985f, 
    -0.02376298f, -0.11100248f, 0.04810649f, 0.21440713f, 0.08598305f, 0.17784533f, 0.11699032f, 0.14985088f, 
    0.05170063f, -0.20427208f, -0.13704371f, -0.13136610f, -0.30268988f, -0.23287021f, -0.07806696f, -0.22155222f, 
    -0.11943203f, -0.13223477f, 0.28383413f, 0.00535269f, -0.01824791f, -0.05057175f, -0.18756108f, 0.17765996f, 
    -0.03929866f, -0.02046501f, -0.02352911f, -0.25663412f, 0.15132444f, 0.12050453f, 0.35175291f, 0.36199564f, 
    0.10105292f, 0.04477268f, 0.24586008f, 0.20511006f, -0.05759481f, 0.01451159f, -0.00856312f, -0.08075797f, 
    -0.05881975f, 0.05699481f, -0.08983061f, -0.08010426f, 0.03288715f, 0.03434678f, 0.10163920f, -0.13182703f, 
    -0.19110635f, -0.15888809f, 0.01435168f, -0.41867602f, 0.10360831f, 0.16445784f, 0.03916940f, 0.14425056f, 
    -0.12079909f, 0.03299130f, 0.11588917f, 0.14073370f, 0.11154442f, 0.14149050f, 0.15243752f, 0.18042277f, 
    0.03313623f, 0.17837256f, 0.06710821f, 0.24420464f, 0.00395275f, -0.02384051f, -0.06499585f, -0.16896564f, 
    0.03288341f, -0.05262930f, 0.08631422f, -0.14128825f, 0.04089111f, 0.04861957f, -0.09437349f, 0.12766202f, 
    0.13780606f, 0.09618504f, 0.03161689f, 0.06678683f, 0.09050384f, 0.00736884f, 0.03416260f, 0.13108590f, 
    0.37511447f, -0.10475405f, -0.03389433f, 0.17360614f, 0.03739566f, 0.12816511f, 0.10414899f, -0.12600961f, 
    0.10149994f, -0.12257404f, 0.00468875f, -0.10816673f, -0.03402349f, -0.01116829f, -0.07363703f, 0.03184924f, 
    -0.10498994f, 0.05815315f, 0.06380573f, -0.11209834f, -0.26630154f, -0.01008141f, -0.04848286f, -0.00314619f, 
    -0.01071385f, 0.16981307f, -0.07493757f, -0.29519573f, 0.00686230f, -0.00930072f, -0.08852440f, -0.00440914f, 
    -0.05356574f, -0.14309323f, -0.05680693f, -0.31577763f, -0.02440416f, 0.10295945f, 0.17207795f, -0.16523147f, 
    -0.05841229f, -0.02597909f, 0.04423947f, -0.26049367f, 0.01351826f, -0.01176473f, 0.10219353f, -0.02706685f, 
    0.25114796f, 0.10237142f, -0.13729046f, 0.03242052f, 0.08944287f, 0.02073959f, 0.02068298f, -0.12009826f, 
    0.13820183f, 0.11574487f, 0.01139301f, 0.19524883f, -0.26049083f, 0.00809103f, -0.24676667f, -0.06047143f, 
    0.01357842f, 0.04950292f, -0.03112624f, 0.06070539f, -0.01257514f, 0.01942228f, 0.16033363f, 0.23082572f, 
    0.05429781f, 0.19116516f, -0.03516727f, 0.06065550f, 0.06481948f, -0.07211328f, -0.11185449f, -0.42481560f, 
    -0.19582942f, -0.01982043f, 0.02123475f, -0.03343944f, -0.00932271f, -0.15681881f, -0.05948242f, 0.11781115f, 
    0.03259650f, 0.06595398f, -0.08960894f, -0.10649192f, 0.05605848f, 0.08028581f, 0.05617099f, 0.10528120f, 
    -0.15038809f, 0.10327458f, 0.08931819f, -0.05494722f, 0.02820269f, 0.03487419f, -0.10292612f, -0.06149078f, 
    -0.25659591f, -0.00965467f, -0.07571469f, -0.16742977f, 0.15560190f, -0.11883384f, -0.00899069f, 0.01937962f, 
    0.00346128f, 0.01534391f, -0.01512672f, 0.09520245f, 0.08597686f, -0.10067622f, 0.01880281f, -0.19224246f, 
    0.10707619f, 0.35755458f, -0.05289888f, -0.22346927f, -0.14168890f, -0.01992697f, 0.10462072f, -0.13819492f, 
    -0.02663135f, 0.12803392f, 0.05012891f, 0.08180916f, 0.09122964f, 0.11216859f, 0.12548313f, 0.19309019f, 
    0.03352086f, -0.05561755f, 0.05445800f, 0.10998022f, -0.07422736f, -0.15257055f, -0.07255348f, -0.11544517f, 
    0.08125964f, -0.03007000f, -0.02102258f, -0.14517410f, 0.00550517f, -0.01065413f, -0.02976295f, -0.13878131f, 
    -0.04809437f, -0.04333706f, -0.09841853f, 0.01884779f, 0.13649669f, 0.05056030f, 0.20115955f, 0.01871844f, 
    0.01374119f, -0.11035521f, 0.16740140f, 0.05141530f, 0.33964828f, 0.02254894f, 0.05496408f, 0.14050399f, 
    -0.06466324f, 0.01635029f, 0.03130750f, 0.06263478f, -0.00385484f, 0.08789400f, 0.20694923f, 0.19328652f, 
    0.06325933f, -0.03676368f, -0.09661019f, 0.12138191f, -0.01537505f, -0.02301926f, 0.07000065f, 0.06116934f, 
    -0.02431121f, -0.12448809f, -0.12919450f, 0.11492582f, -0.05178774f, -0.08965231f, -0.19470596f, -0.11277556f, 
    0.42016372f, -0.16697276f, 0.01300621f, 0.03884639f, -0.10861410f, -0.12406678f, 0.04469032f, 0.00092715f, 
    -0.11964821f, 0.02599193f, 0.05502371f, -0.14375596f, 0.13029069f, 0.15113255f, 0.10823090f, -0.02855437f, 
    -0.10329803f, -0.13757284f, -0.17073287f, -0.15192252f, 0.08576773f, -0.13403469f, 0.01451034f, -0.00129960f, 
    -0.28220758f, -0.13171661f, -0.03660455f, 0.00606988f, -0.03721974f, 0.06086425f, -0.00231877f, -0.07396434f, 
    0.08527676f, 0.05686340f, -0.08599511f, 0.04028431f, 0.05564095f, 0.01639575f, -0.24089891f, 0.00459250f, 
    0.11589052f, -0.01545408f, 0.25906202f, -0.18227848f, 0.04151990f, -0.05210739f, 0.17492202f, -0.10462249f, 
    -0.25621724f, -0.30236852f, 0.13446341f, -0.05856566f, -0.18283632f, -0.34038487f, -0.12182938f, 0.16648258f, 
    0.00256075f, -0.14440897f, 0.04958039f, 0.10297825f, 0.45459309f, 0.16121958f, 0.02684514f, -0.15636213f, 
    -0.06347477f, 0.01208157f, -0.17786698f, -0.00428542f, 0.27434632f, -0.03759536f, 0.06527704f, 0.12307131f, 
    0.18368992f, 0.10970731f, 0.13289268f, 0.16008610f, 0.10285030f, 0.05640940f, -0.11200400f, -0.08150797f, 
    -0.07043124f, 0.03313129f, 0.00239116f, 0.00310186f, 0.14683743f, 0.15394954f, 0.09660912f, 0.18853672f, 
    -0.11457313f, -0.02065944f, -0.03656212f, -0.13529244f, 0.05888987f, 0.13436590f, 0.13357507f, 0.04593138f, 
    -0.10348111f, 0.08724022f, -0.11214764f, 0.04405033f, -0.02008278f, 0.10763545f, 0.10691361f, 0.14268261f, 
    0.15977156f, 0.09514108f, 0.01805735f, 0.07798723f, -0.22139563f, 0.03464387f, -0.14983815f, -0.03346633f, 
    -0.07191169f, -0.10336784f, -0.08221891f, -0.11229012f, 0.12916231f, 0.18448174f, 0.16117139f, 0.07485022f, 
    -0.19913261f, -0.31483909f, 0.13759419f, 0.58549023f, 0.09215772f, -0.08778498f, -0.13537128f, -0.13802202f, 
    0.11413139f, 0.04622216f, 0.11178218f, 0.19907263f, -0.07132543f, -0.11389498f, 0.12343043f, 0.21136084f, 
    -0.02410484f, 0.16906741f, -0.07878565f, -0.09977038f, -0.01247835f, 0.03221100f, -0.02099442f, 0.06547724f, 
    -0.11420628f, -0.11706552f, 0.08376528f, -0.09302031f, -0.03800616f, -0.05801898f, -0.13322735f, -0.12925567f, 
    -0.16667992f, 0.15744610f, -0.13214283f, -0.01860238f, 0.02120135f, -0.05599665f, 0.19382855f, 0.14455032f, 
    -0.05819762f, 0.04673350f, -0.03049425f, 0.06644373f, -0.00106577f, -0.09410432f, 0.03376045f, 0.00349714f, 
    0.08109768f, -0.06743711f, -0.10445344f, 0.07174018f, 0.06930883f, -0.00026343f, 0.04912488f, 0.17124125f, 
    0.15482081f, 0.18978769f, 0.06968162f, 0.04206904f, -0.05280170f, 0.05786065f, 0.00984199f, 0.15547927f, 
    0.03014918f, 0.07371436f, 0.04116318f, 0.03398736f, -0.13865022f, -0.06280882f, -0.00994056f, -0.03152186f, 
    0.40259883f, -0.13349506f, 0.49950257f, -0.02411206f, 0.15906413f, -0.01972152f, 0.00930290f, 0.11871982f, 
    0.06995223f, 0.05125789f, 0.00330485f, 0.03789009f, 0.05846532f, 0.14199984f, 0.04957163f, -0.11085351f, 
    0.02204703f, -0.08114459f, 0.00782513f, 0.03693898f, 0.00238998f, 0.08745568f, -0.02494917f, 0.07227081f, 
    0.26544848f, 0.04271956f, 0.15477028f, 0.16608860f, -0.01777423f, -0.05505896f, 0.13574761f, 0.02687361f, 
    -0.03487198f, 0.06507112f, 0.04297246f, 0.12734750f, 0.37608957f, -0.20389114f, 0.48529619f, 0.03885677f, 
    0.18655182f, 0.00853973f, 0.14204168f, 0.15659185f, -0.00406037f, 0.11857976f, 0.13193013f, 0.11904245f, 
    -0.19417121f, -0.11269933f, -0.16536486f, 0.01183317f, 0.00401580f, 0.16249076f, 0.07677805f, 0.07850499f, 
    -0.08080193f, -0.00366591f, -0.12956585f, -0.00348294f, -0.24353176f, 0.11638859f, 0.13332677f, 0.07246711f, 
    -0.08561715f, -0.01601925f, 0.04440478f, -0.15283841f, -0.15684430f, 0.15207216f, 0.00022904f, -0.28580949f, 
    -0.18892010f, 0.09909917f, -0.16617432f, -0.29769817f, -0.23299752f, -0.00168983f, 0.06537729f, -0.01884319f, 
    -0.00266975f, 0.12405312f, 0.07240875f, 0.20078993f, 0.01691003f, 0.17492321f, 0.06386276f, -0.13513465f, 
    -0.03146854f, -0.08814994f, -0.06880175f, -0.13300130f, -0.04142993f, -0.10193838f, 0.11224791f, -0.00577920f, 
    0.04364487f, -0.01733995f, -0.18041016f, 0.07908980f, -0.03888986f, -0.08948641f, -0.16191800f, 0.11718584f, 
    0.00155232f, 0.07889438f, -0.01606245f, 0.08627429f, 0.07533640f, -0.01559019f, -0.15166301f, -0.16943656f, 
    -0.05719639f, -0.09151548f, -0.02714497f, 0.08263949f, -0.17571098f, -0.07558592f, -0.19204308f, -0.07510670f, 
    -0.04510796f, 0.22418851f, 0.17049465f, -0.22792272f, 0.04739452f, -0.01263328f, 0.14098181f, 0.09569313f, 
    -0.16830817f, -0.06546610f, 0.06793759f, -0.14590491f, -0.07391450f, 0.00690793f, 0.13297364f, -0.02129440f, 
    0.01592344f, -0.04648485f, 0.19148843f, 0.07373438f, 0.02473403f, 0.02639513f, -0.12271824f, -0.09647567f, 
    0.14513679f, -0.09931208f, -0.20679292f, -0.02860335f, 0.07987487f, -0.12764460f, 0.01180473f, 0.01535367f, 
    0.07488255f, -0.26839000f, -0.25285625f, -0.25942427f, -0.03267338f, 0.06954410f, 0.13424329f, -0.10026878f, 
    -0.01556988f, 0.05124902f, 0.18135720f, 0.18270819f, 0.02747455f, 0.08601344f, 0.00325427f, 0.10792822f, 
    -0.11000846f, -0.10426818f, -0.00167907f, 0.00861270f, -0.10029564f, -0.30745244f, -0.05124406f, -0.12902460f, 
    -0.07321694f, 0.00224769f, -0.00145342f, -0.23224647f, -0.34431168f, -0.07964074f, 0.16235052f, 0.00556772f, 
    0.03720736f, -0.04056931f, 0.12446944f, 0.16280577f, 0.01458804f, -0.04861059f, -0.01872728f, 0.08631715f, 
    0.13207456f, -0.02034222f, -0.23570845f, 0.09226263f, 0.04489668f, -0.01554099f, 0.09436165f, -0.00391425f, 
    0.02149038f, -0.05327669f, 0.05769204f, -0.12197031f, 0.20465282f, -0.01774354f, -0.18666756f, -0.11666215f, 
    -0.19747087f, 0.05561881f, 0.07055704f, 0.07924305f, -0.03122605f, -0.10286172f, 0.03805336f, -0.17398331f, 
    -0.13739365f, -0.22128698f, -0.04527123f, -0.12114007f, -0.14174978f, -0.00763961f, -0.12629978f, 0.02928815f, 
    0.02359631f, 0.03501139f, -0.02560386f, -0.24250157f, -0.15831235f, 0.14707270f, -0.28692034f, -0.03487402f, 
    0.04581562f, 0.08024082f, 0.18849021f, -0.20799418f, 0.00580895f, 0.20017615f, 0.00726581f, 0.04254603f, 
    -0.03721472f, -0.07113242f, 0.08181936f, 0.03329130f, -0.16180554f, -0.22501533f, -0.10129158f, -0.11075557f, 
    0.10335926f, 0.06986274f, 0.04102470f, 0.08448493f, 0.14957355f, -0.06778922f, -0.10569123f, -0.10604860f, 
    0.01793534f, -0.04035482f, -0.04943095f, 0.03542326f, 0.14405896f, -0.07378261f, 0.02858766f, 0.06928733f, 
    -0.04443228f, 0.02116711f, 0.03962520f, -0.14151211f, 0.17756216f, 0.11812845f, -0.20544359f, -0.08215094f, 
    -0.16431876f, -0.00230927f, 0.05295575f, -0.09160893f, 0.06478637f, -0.04110418f, -0.06584387f, -0.03489633f, 
    0.02550372f, 0.07931422f, -0.00219268f, 0.06889793f, -0.09258130f, -0.02223536f, -0.00419291f, 0.07424010f, 
    -0.33738446f, 0.46068540f, -0.40461996f, 0.16388611f, 0.01452971f, 0.03616890f, -0.01429419f, -0.01010543f, 
    0.03717131f, 0.03112902f, 0.03836111f, 0.14421667f, -0.23619194f, 0.13334325f, -0.15868811f, 0.11863223f, 
    0.00798544f, -0.02214277f, 0.08767223f, -0.08918813f, -0.04431776f, -0.07731450f, 0.00020111f, -0.16585486f, 
    -0.08983559f, -0.42083403f, 0.21976013f, 0.30259717f, 0.11549154f, -0.09090220f, -0.18042131f, 0.03894912f, 
    -0.06721250f, 0.11537267f, 0.10653026f, 0.07064085f, 0.00680212f, -0.23469216f, 0.30855545f, 0.16525851f, 
    0.11060345f, 0.01248395f, 0.00740896f, -0.00456653f, -0.06569484f, -0.02286283f, -0.05084880f, -0.19684064f, 
    0.03516110f, 0.03328077f, -0.04504225f, -0.03025226f, -0.02370832f, 0.08810271f, -0.04977339f, -0.05394081f, 
    -0.16047369f, 0.10169046f, -0.08895232f, -0.14174871f, 0.22614309f, -0.06721499f, 0.26220608f, 0.02233099f, 
    -0.03002529f, 0.03216152f, -0.06162847f, 0.02896232f, 0.07154834f, -0.07141215f, 0.21712843f, 0.06841490f, 
    0.03899806f, 0.11109210f, 0.02988521f, -0.03970661f, -0.03692461f, -0.04893773f, -0.06776699f, 0.07381688f, 
    0.03563306f, -0.02086406f, -0.04155535f, -0.10127883f, -0.22075851f, 0.10021497f, -0.05833996f, 0.14981477f, 
    0.05551038f, 0.02617750f, -0.09629015f, 0.00811219f, -0.19235879f, -0.05567095f, -0.00255748f, -0.09821063f, 
    0.54824209f, -0.34617963f, 0.30940971f, 0.02293815f, 0.17777514f, -0.07995313f, 0.12799069f, 0.03720959f, 
    -0.06976301f, -0.13961096f, -0.00789068f, 0.07068565f, 0.19784488f, 0.03908365f, 0.11632267f, 0.02269044f, 
    0.00068943f, 0.07294506f, 0.10999652f, 0.04301247f, -0.19993252f, -0.02302212f, 0.15171082f, 0.03281191f, 
    0.02737012f, 0.03138429f, 0.34275213f, 0.07878632f, -0.07313338f, -0.00310657f, -0.02789562f, 0.04800323f, 
    -0.10053388f, -0.10475142f, -0.13928647f, -0.12247591f, 0.31888631f, -0.24460556f, 0.51860785f, 0.02232747f, 
    0.25027308f, 0.02461697f, 0.41436991f, -0.00307534f, 0.16710542f, 0.02503492f, 0.10049428f, -0.02483167f, 
    -0.17223120f, -0.05688876f, -0.28062081f, 0.00913923f, -0.02675149f, -0.21305309f, -0.10189619f, 0.00947269f, 
    -0.05669535f, 0.01382550f, 0.03064807f, -0.06560848f, 0.04481234f, 0.12659915f, 0.09881146f, 0.20239849f, 
    -0.07806984f, 0.10143132f, 0.13659084f, 0.05245630f, -0.01680102f, -0.00527831f, 0.02441295f, -0.08780812f, 
    -0.14582159f, 0.08452113f, -0.10879134f, -0.08159641f, -0.06108163f, -0.02897017f, 0.04945624f, -0.07504994f, 
    -0.19036338f, -0.02496842f, 0.14019838f, 0.10813748f, 0.02870503f, 0.10472994f, -0.00010576f, -0.01223800f, 
    -0.14313583f, -0.08661386f, -0.02480691f, 0.02204139f, 0.05975310f, 0.00517369f, 0.14754447f, 0.09555192f, 
    0.07964682f, -0.13370687f, 0.04952263f, 0.17817029f, 0.01526954f, -0.17171590f, 0.02709799f, -0.06838424f, 
    0.15239587f, 0.07728873f, 0.24154015f, 0.15459931f, 0.09740270f, -0.03778797f, -0.10635578f, 0.04022102f, 
    0.18206517f, 0.22502406f, 0.04678825f, -0.05427067f, 0.03630929f, 0.02156529f, -0.15344790f, 0.05853759f, 
    -0.12107662f, 0.18890907f, 0.10283110f, 0.09148701f, 0.15545186f, 0.06394748f, -0.10849530f, 0.07861217f, 
    0.06937639f, -0.07417487f, -0.11961669f, 0.13876885f, -0.14940037f, 0.14994270f, -0.02880356f, -0.06929026f, 
    0.05841934f, -0.01031532f, 0.06265745f, 0.06613945f, -0.03077228f, -0.01043392f, -0.03664018f, 0.00271129f, 
    -0.04418264f, -0.10621347f, 0.02786328f, -0.05534925f, 0.12744677f, 0.09392696f, 0.05828580f, 0.16445342f, 
    0.05124135f, 0.06388960f, -0.03634048f, -0.05365930f, -0.01918130f, -0.09623736f, -0.29670802f, 0.00294212f, 
    0.07774352f, 0.15070960f, 0.02563743f, 0.02757586f, -0.09432248f, 0.12541021f, 0.12969324f, -0.00701268f, 
    -0.11098102f, 0.07181933f, -0.07744027f, -0.07442310f, -0.02061308f, -0.06424980f, -0.09090211f, -0.11380805f, 
    -0.06776483f, -0.16947263f, -0.14476812f, -0.14139459f, -0.22275455f, 0.11236271f, 0.26046360f, -0.06927803f, 
    -0.00345932f, 0.03431177f, 0.04565311f, 0.08057395f, -0.04479965f, 0.08802231f, 0.10749548f, 0.20749275f, 
    -0.38355574f, 0.09475634f, -0.20465016f, 0.08809402f, -0.07244941f, -0.02434508f, -0.05497576f, 0.04354208f, 
    0.07951052f, -0.00005863f, -0.04930504f, -0.02124653f, -0.04474161f, -0.20479512f, -0.17848198f, 0.04083227f, 
    0.05948852f, 0.06307467f, 0.11711251f, 0.04821905f, 0.06614196f, -0.01976266f, -0.11598515f, -0.20450044f, 
    0.09921580f, -0.01870658f, 0.10577413f, -0.09507928f, 0.07324585f, 0.08418345f, -0.00599017f, 0.07191172f, 
    -0.08309656f, -0.11347868f, 0.01878923f, -0.10505336f, -0.12790689f, 0.14278124f, -0.15108812f, -0.00886609f, 
    -0.07909545f, 0.04768290f, -0.04015332f, 0.05451663f, -0.13593794f, -0.02067025f, -0.16017835f, 0.15083131f, 
    0.15062298f, 0.27955619f, 0.04629129f, -0.08058265f, -0.14085381f, -0.12744528f, -0.08571485f, -0.18225665f, 
    0.06946757f, 0.04638658f, 0.11621691f, 0.18871368f, -0.14911373f, -0.07151117f, -0.05255001f, -0.00908550f, 
    0.17512418f, 0.05255631f, 0.17411274f, 0.12590215f, -0.01407074f, -0.10003420f, -0.05994296f, -0.02350183f, 
    -0.05110791f, -0.03999367f, 0.03285621f, 0.15003675f, 0.01122172f, -0.02578828f, -0.03561749f, -0.05285821f, 
    0.07927458f, -0.11361352f, 0.07046461f, -0.24825224f, -0.02891055f, -0.12841211f, -0.03752742f, 0.00669606f, 
    0.10835946f, -0.08336888f, -0.04036836f, 0.13332461f, -0.14979844f, -0.17815886f, -0.07926609f, -0.05552310f, 
    -0.07757632f, -0.06575752f, -0.01590687f, -0.03987185f, 0.00847046f, 0.01359679f, -0.05682438f, -0.07837741f, 
    0.01170597f, 0.03890320f, -0.00750143f, -0.05936441f, -0.02108032f, 0.05379798f, 0.02822710f, -0.06308591f, 
    -0.04767087f, -0.03440554f, -0.01503593f, 0.03439325f, -0.05810850f, -0.05719408f, 0.03307431f, -0.01956486f, 
    0.06255687f, -0.02633632f, -0.04404366f, 0.05591215f, 0.07376283f, 0.01919853f, -0.01095460f, -0.05884741f, 
    0.03179092f, -0.06445020f, -0.03642672f, -0.06126894f, -0.04663655f, -0.04430665f, -0.00095181f, 0.02231993f, 
    -0.01741001f, -0.02270822f, -0.03010694f, -0.02604781f, -0.08076689f, -0.05266506f, 0.04177112f, -0.03515198f, 
    0.07666356f, -0.06266235f, -0.01668701f, -0.03765997f, -0.00548337f, -0.01625114f, 0.00304111f, -0.03189337f, 
    0.03544599f, -0.04319564f, 0.03437110f, -0.01160620f, 0.00152990f, 0.04408101f, 0.01952619f, 0.00132444f, 
    -0.03759805f, -0.03611970f, 0.05269309f, 0.05227681f, 0.05973045f, -0.07278006f, 0.06285263f, 0.04592724f, 
    -0.02377935f, -0.02242207f, 0.04098617f, -0.00149885f, -0.07549662f, -0.05682870f, 0.04938949f, 0.01497010f, 
    -0.03857394f, -0.02796336f, -0.05008852f, 0.04473750f, -0.02523575f, -0.00029360f, 0.02963556f, -0.02645022f, 
    0.03726338f, 0.00311632f, 0.05914620f, 0.05811252f, 0.01425970f, 0.02506787f, -0.01403438f, -0.03630122f, 
    0.02994744f, -0.05878307f, 0.05548447f, -0.01430271f, -0.03085112f, -0.03316953f, 0.05594425f, -0.06866565f, 
    -0.02590571f, -0.06302685f, -0.01506313f, -0.07362364f, -0.05250130f, -0.08599697f, -0.03889072f, 0.01598567f, 
    0.00807679f, -0.02983409f, -0.04306134f, 0.02296009f, -0.03630552f, -0.06799274f, 0.00307299f, -0.04693305f, 
    0.03297383f, -0.06023229f, 0.00199959f, 0.02710443f, -0.07366557f, -0.07486473f, 0.03736864f, 0.05893857f, 
    -0.06283472f, 0.04683366f, -0.01478886f, -0.00276261f, -0.01452352f, 0.06786743f, 0.06651357f, -0.07896923f, 
    0.03263479f, 0.04794082f, -0.01584399f, 0.02475814f, 0.04865801f, 0.05887573f, -0.02857246f, 0.00892528f, 
    0.03289605f, -0.06989872f, -0.01511775f, 0.04668820f, -0.06761082f, -0.02488988f, 0.01384395f, 0.01756003f, 
    -0.04559724f, -0.07233758f, -0.05571174f, 0.03633889f, -0.01545681f, 0.06624170f, 0.02052257f, 0.03999064f, 
    0.05940059f, -0.05413663f, 0.04585527f, -0.05879055f, 0.01962754f, -0.03152025f, -0.05870403f, 0.06974210f, 
    0.02571021f, 0.03970877f, -0.05726671f, -0.04493449f, 0.02275958f, -0.07175976f, -0.03919013f, -0.07551720f, 
    -0.05406953f, -0.04343025f, -0.03254141f, -0.01615084f, -0.06012262f, -0.04399832f, -0.06823701f, -0.04703362f, 
    0.03915571f, 0.00854939f, -0.00261616f, -0.00086396f, -0.05267871f, -0.01800831f, 0.06339944f, -0.00675506f, 
    -0.03464963f, 0.05714513f, 0.12804128f, 0.02092156f, -0.07526486f, 0.21512602f, 0.05754435f, -0.02428843f, 
    0.11389580f, 0.14444481f, 0.09980689f, 0.02244700f, -0.05236201f, -0.06125644f, 0.02090727f, -0.01709780f, 
    -0.11081748f, 0.18190220f, -0.10782234f, 0.06759277f, 0.11483440f, 0.16169092f, 0.11444902f, 0.18866059f, 
    -0.24214534f, 0.05890563f, 0.23689054f, 0.48989224f, -0.13895474f, 0.10008409f, 0.03155928f, 0.07572812f, 
    -0.04448419f, 0.01770153f, 0.00286766f, -0.13697807f, -0.34688640f, -0.30914113f, -0.05200375f, 0.01379305f, 
    -0.00454410f, 0.09255070f, -0.12014420f, -0.13299756f, 0.09741705f, -0.05148385f, 0.00747048f, 0.06958046f, 
    -0.04287480f, -0.07638298f, -0.05020349f, -0.08555371f, 0.06858192f, 0.00632204f, -0.09509857f, -0.03776651f, 
    0.02308362f, 0.02778438f, 0.01102635f, -0.06991126f, -0.03385878f, -0.05788630f, 0.20318782f, 0.14900488f, 
    -0.05035927f, -0.08370369f, 0.05231741f, 0.13904530f, -0.08886109f, -0.03662240f, -0.14504348f, -0.15489979f, 
    0.06203220f, -0.36808121f, -0.29525253f, 0.08297516f, -0.00795419f, -0.05575595f, -0.07122800f, 0.27506152f, 
    -0.04717810f, 0.10989572f, 0.05364568f, -0.02463901f, -0.01541798f, -0.29012692f, 0.04281407f, 0.17609020f, 
    -0.07153879f, -0.09862335f, 0.09771352f, -0.00598661f, -0.07814550f, -0.06757051f, -0.11887267f, -0.05775409f, 
    0.12060127f, 0.12967870f, 0.26570606f, -0.05408667f, 0.01046215f, 0.03702638f, 0.11548337f, 0.01349569f, 
    -0.02246000f, -0.08603097f, -0.04732040f, -0.06665683f, -0.06167861f, 0.32277590f, -0.05980765f, -0.27037990f, 
    0.01468037f, -0.02365536f, 0.01861320f, -0.00217729f, 0.01102821f, -0.00520340f, 0.11466830f, 0.13636793f, 
    0.11082311f, -0.18191856f, -0.17530152f, 0.09656673f, -0.04914467f, 0.02265946f, 0.19186775f, -0.05228224f, 
    0.01782581f, 0.01076022f, -0.00586784f, 0.00019302f, 0.47693583f, 0.29358113f, -0.00333858f, -0.04049161f, 
    0.06593451f, 0.11458918f, 0.08048950f, 0.07211994f, 0.04011298f, 0.13215473f, 0.07927096f, 0.03630682f, 
    -0.18746257f, -0.20524265f, -0.06900013f, 0.09794787f, 0.08128775f, 0.06255466f, 0.18506049f, 0.06255297f, 
    -0.07065002f, -0.10069474f, -0.07720523f, -0.06011350f, -0.37857285f, 0.19875021f, 0.25962532f, -0.06704836f, 
    -0.05278534f, -0.02806334f, -0.16721974f, -0.17711239f, -0.12923394f, 0.15508384f, 0.03709646f, -0.05663924f, 
    -0.04121689f, 0.14206669f, 0.00658008f, -0.27227697f, -0.16788727f, 0.02250633f, -0.03168671f, -0.00237312f, 
    0.12471427f, 0.13358741f, 0.03589929f, 0.21387617f, 0.15491995f, 0.28085783f, -0.01342868f, -0.32694206f, 
    -0.13499671f, -0.09146523f, -0.08662827f, -0.15056619f, 0.05790396f, -0.16099907f, 0.01267918f, 0.08528969f, 
    -0.04678720f, 0.03092234f, -0.02885606f, -0.02524616f, 0.00812012f, -0.04115970f, 0.00490513f, -0.07471550f, 
    -0.07478344f, 0.04830330f, -0.05915809f, -0.00901927f, -0.03938774f, -0.04772967f, 0.06314414f, -0.04075074f, 
    0.04655926f, 0.05860637f, 0.01272641f, -0.02418309f, -0.01615928f, -0.01407507f, -0.07246364f, -0.06491271f, 
    0.00425807f, 0.05074007f, -0.03245196f, -0.05390907f, 0.04557446f, 0.05901325f, -0.06289500f, -0.06876671f, 
    0.04680899f, -0.06761180f, -0.01598496f, -0.07158305f, -0.01734197f, 0.04901432f, 0.05932905f, 0.04925445f, 
    0.06542437f, -0.07222292f, -0.07293262f, 0.00434670f, 0.01254913f, 0.05015724f, -0.07172719f, 0.05762294f, 
    0.05857562f, -0.03518642f, 0.06417068f, -0.02756207f, -0.04138235f, -0.03601203f, -0.01287742f, 0.02628451f, 
    0.01693750f, -0.00405963f, 0.03462984f, -0.01475830f, 0.05728940f, -0.00563638f, 0.01474679f, -0.06065544f, 
    0.02677974f, -0.02250375f, -0.01521906f, -0.03566369f, -0.07347281f, 0.03168562f, -0.05392651f, 0.01288660f, 
    -0.01661989f, 0.03605499f, 0.04634310f, -0.05138183f, -0.04748334f, 0.03995756f, 0.03508798f, 0.02441291f, 
    0.02788530f, -0.02065629f, -0.05984984f, -0.04408888f, -0.01486736f, -0.01782359f, 0.05122715f, 0.00941145f, 
    -0.06440043f, -0.02946919f, -0.05324121f, 0.04576076f, -0.06638216f, -0.00230256f, -0.07172372f, 0.05968818f, 
    -0.07297843f, 0.01176902f, -0.05312427f, -0.02286062f, 0.02518828f, -0.05725781f, 0.03634367f, -0.04606973f, 
    -0.06843417f, -0.06332324f, 0.00577513f, -0.00388553f, 0.01859909f, -0.01888625f, 0.00597641f, -0.06838107f, 
    -0.07051984f, -0.06680126f, -0.04061504f, -0.00016213f, -0.01771872f, 0.01073814f, 0.05959705f, -0.04821902f, 
    0.00245764f, -0.03066777f, 0.01739881f, -0.02637984f, -0.00364813f, 0.03763760f, -0.00664304f, 0.06005998f, 
    0.03206149f, 0.02439936f, -0.07820749f, -0.04518593f, -0.02670775f, -0.02750712f, -0.05154834f, -0.04349808f, 
    -0.01975897f, -0.07351063f, 0.01365919f, 0.04579010f, -0.03692902f, -0.01422149f, -0.07297149f, -0.00272313f, 
    -0.02339476f, -0.02599519f, -0.00219757f, -0.06348599f, 0.05204371f, -0.02018091f, 0.02217801f, -0.06042309f, 
    -0.04133171f, 0.02467487f, -0.01660985f, 0.03456213f, -0.06277415f, 0.04548196f, -0.03411787f, 0.02052101f, 
    -0.02991411f, -0.03010188f, -0.07398733f, 0.00937273f, 0.02868078f, 0.03984543f, -0.05103809f, 0.01828801f, 
    -0.03037032f, 0.05347989f, -0.04903612f, 0.03074296f, -0.04542869f, -0.02455770f, -0.01437700f, -0.03795002f, 
    -0.02884758f, 0.03843091f, -0.06243179f, 0.04183640f, -0.06265565f, 0.00987083f, 0.00570990f, -0.04798124f, 
    -0.01464652f, -0.02523547f, -0.05838700f, 0.05435158f, -0.01351871f, 0.03226961f, 0.03517640f, -0.06432047f, 
    0.28498477f, -0.10608990f, 0.10183799f, -0.03481970f, -0.03781925f, -0.11437806f, 0.03514432f, -0.04287490f, 
    0.04359568f, 0.11107337f, 0.08302012f, 0.08813968f, 0.19197603f, -0.08088265f, 0.02163102f, -0.05229215f, 
    0.04578467f, 0.14817505f, -0.14668202f, -0.06426683f, -0.02594508f, -0.03374337f, -0.26966241f, -0.08484963f, 
    0.02117250f, 0.20847774f, 0.13484368f, -0.20824608f, -0.07557476f, 0.02253553f, 0.02737138f, 0.03589658f, 
    -0.06876260f, 0.12110103f, 0.01736804f, -0.03852665f, 0.07151590f, 0.15538774f, -0.06696499f, 0.05539170f, 
    0.13982408f, 0.07867891f, 0.18730669f, 0.06670353f, 0.10498191f, 0.02251456f, 0.03568966f, 0.02974506f, 
    -0.20835100f, -0.02024502f, -0.20587154f, -0.03144911f, 0.09528438f, 0.10257453f, 0.19859451f, 0.07713086f, 
    -0.02385056f, -0.22614738f, -0.06692822f, -0.12888449f, -0.19180755f, 0.07328521f, -0.28896436f, 0.08892151f, 
    -0.13498901f, 0.02927955f, 0.19471797f, 0.18845272f, -0.03181960f, 0.26136214f, -0.03451380f, -0.01757260f, 
    -0.14322884f, 0.11371347f, 0.01674959f, 0.13324764f, -0.06276736f, -0.04396895f, -0.04147326f, -0.13479005f, 
    -0.07774092f, -0.02050642f, 0.05839280f, -0.06480040f, -0.21406569f, 0.03199182f, -0.00031151f, -0.19306454f, 
    -0.01136239f, 0.07856991f, 0.06133426f, 0.27587977f, 0.02812914f, -0.08745304f, 0.06355333f, 0.09994995f, 
    -0.32326972f, 0.17988339f, -0.57741338f, 0.26889500f, 0.09964009f, 0.08112739f, 0.03331061f, -0.02210431f, 
    0.07361597f, -0.07496024f, 0.05305070f, 0.00145527f, 0.07979006f, -0.07740932f, -0.30022481f, -0.07123555f, 
    -0.07590941f, 0.00877678f, 0.05282355f, -0.04112228f, -0.04457507f, -0.04889548f, -0.07771212f, -0.15259489f, 
    -0.11739641f, -0.04407968f, 0.16332948f, -0.11397816f, 0.07115258f, 0.00681571f, -0.05621204f, 0.01674631f, 
    0.04156121f, -0.07527536f, 0.02810931f, -0.18378030f, -0.29531437f, 0.20129263f, -0.35265940f, 0.08801259f, 
    0.02145460f, 0.11800260f, 0.06487803f, -0.03358001f, 0.14537948f, 0.02413398f, -0.05194550f, 0.08278410f, 
    0.19137688f, 0.13619079f, 0.15587455f, -0.14015599f, -0.08505489f, -0.18222970f, -0.09306337f, 0.06481753f, 
    0.07736491f, -0.00585162f, -0.02482107f, -0.03570171f, 0.08017277f, -0.17001511f, -0.23823200f, -0.14773060f, 
    0.09104577f, 0.02253165f, 0.00121377f, 0.01626049f, 0.13461007f, -0.06193986f, 0.01705631f, 0.24900137f, 
    0.08573683f, -0.03320405f, 0.15863007f, 0.14585848f, 0.03051498f, -0.01079170f, -0.12748978f, -0.08477030f, 
    -0.01322541f, 0.03502963f, 0.05943009f, -0.09610607f, 0.12266322f, -0.11836337f, 0.10423727f, 0.02454995f, 
    0.04397130f, 0.03712348f, 0.04594256f, 0.14793994f, -0.03789986f, 0.09536268f, 0.02542573f, 0.11192188f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08941629f, 0.17070322f, 0.05903390f, 0.17810488f, -0.03469722f, -0.16667345f, 0.08304445f, 0.17924044f, 
    0.06401730f, 0.21347746f, 0.01345681f, 0.04382706f, -0.03048926f, 0.07121573f, 0.10901640f, 0.13526002f, 
    0.04705507f, -0.03041900f, -0.00736916f, 0.16926080f, 0.10572509f, 0.02014575f, -0.03758352f, 0.01272065f, 
    -0.03439883f, 0.03422440f, 0.19792932f, -0.07291218f, -0.02662127f, -0.08780053f, 0.04589904f, 0.23437740f, 
    -0.01638982f, 0.02398005f, 0.06235320f, -0.08448875f, -0.12386940f, 0.17000884f, -0.08057232f, -0.04432678f, 
    0.17141624f, 0.11343332f, 0.06061047f, -0.03975675f, 0.06154476f, 0.01720694f, 0.19186185f, 0.07911496f, 
    0.02911048f, 0.03279336f, 0.16462500f, 0.14685363f, 0.17109716f, -0.00030569f, -0.10524946f, 0.21983795f, 
    0.04809233f, 0.09699924f, 0.07750821f, -0.05085673f, -0.06476506f, -0.01332874f, -0.07692703f, 0.08920340f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.34558791f, 0.07360895f, -0.12764157f, 0.02468533f, 0.04726861f, -0.28847179f, 0.17883994f, -0.09292580f, 
    -0.10648268f, 0.10802428f, -0.23211262f, 0.00725551f, 0.09794324f, -0.29242784f, 0.15821813f, 0.02887753f, 
    -0.11168473f, 0.09922490f, -0.04046531f, -0.04699151f, 0.13260029f, -0.29478157f, 0.08141234f, 0.09925230f, 
    -0.15567571f, -0.19087717f, -0.13077624f, 0.14460492f, -0.13485894f, 0.14424047f, -0.04667227f, -0.07835826f, 
    0.01037837f, -0.30705863f, 0.20316407f, 0.06817643f, 0.23284048f, 0.07339271f, -0.04270506f, -0.08962958f, 
    0.05472652f, -0.06267869f, 0.02145238f, -0.02510235f, 0.07035124f, -0.04101244f, 0.08333930f, -0.12641145f, 
    0.01003417f, -0.03502778f, -0.12861657f, 0.07603066f, 0.12746067f, 0.17795277f, 0.06063637f, 0.21681871f, 
    -0.14761290f, 0.18076521f, 0.02163880f, 0.04479396f, 0.03112832f, 0.01732977f, 0.01484875f, 0.21077359f, 
    0.23315053f, 0.06107260f, -0.17506669f, 0.37739027f, -0.12386234f, 0.33174822f, 0.23141550f, -0.30600220f, 
    -0.20241581f, 0.12458184f, -0.61830872f, 0.03865499f, -0.03861841f, 0.18968199f, 0.05743546f, -0.10535080f, 
    0.26889420f, -0.28793606f, -0.14507149f, 0.04498417f, -0.19705200f, 0.09291922f, 0.30563709f, 0.07647676f, 
    -0.21874864f, 0.16359068f, -0.18829687f, 0.06423540f, -0.00781269f, 0.46186194f, 0.02191297f, 0.10408448f, 
    -0.04404153f, 0.65589178f, -0.23875776f, -0.00958110f, 0.03260575f, -0.23889571f, -0.09224957f, -0.03373099f, 
    0.07208081f, -0.10170393f, 0.20239337f, -0.06840392f, 0.19802700f, 0.15687495f, 0.18232442f, -0.03741796f, 
    0.00023108f, 0.23205434f, -0.03178475f, 0.25933802f, -0.01676911f, 0.05368075f, 0.18359622f, -0.19307539f, 
    0.15748857f, 0.14078192f, 0.16540550f, 0.17939444f, 0.09569759f, -0.06129910f, -0.04649447f, -0.03985909f, 
    0.08394566f, -0.00709843f, -0.25622904f, -0.02468946f, -0.12165976f, 0.24511370f, -0.07361034f, -0.00243232f, 
    -0.40536487f, -0.32397008f, -0.00660112f, 0.21521839f, 0.05950533f, 0.17540489f, -0.19127136f, -0.20907278f, 
    -0.07903252f, 0.17494309f, -0.16588621f, -0.14198940f, 0.08494482f, -0.20607217f, 0.00738106f, 0.04345904f, 
    0.07692035f, -0.03428090f, -0.01096590f, 0.06211239f, 0.17477018f, 0.00534418f, -0.11852856f, -0.18038002f, 
    0.12019503f, 0.11065338f, 0.00173612f, 0.13720419f, -0.09267545f, -0.08022080f, 0.03957445f, 0.07290630f, 
    -0.21859707f, 0.06369098f, 0.05037972f, 0.00024006f, 0.08799430f, 0.02699253f, 0.09786985f, -0.01730137f, 
    -0.10599795f, -0.10234591f, -0.01902156f, -0.31086877f, -0.21069746f, -0.20629679f, 0.03724740f, 0.09914439f, 
    -0.04075806f, -0.08250694f, -0.09372210f, 0.09190740f, -0.09511705f, -0.11917265f, 0.02938749f, -0.01501804f, 
    0.00179033f, 0.12448049f, 0.19355339f, -0.28717250f, 0.25296679f, 0.27607211f, 0.16001254f, 0.09447750f, 
    -0.15215456f, -0.07670683f, 0.36506236f, 0.41519099f, 0.01706274f, 0.02488148f, -0.19964254f, 0.02454563f, 
    0.27992573f, -0.08498937f, 0.00361342f, -0.06156318f, 0.38236523f, -0.15924944f, 0.01443305f, 0.40235183f, 
    -0.00143859f, -0.08853520f, -0.01685550f, 0.13950001f, 0.20311755f, -0.04258711f, -0.01101774f, 0.07695872f, 
    -0.09871985f, -0.06554074f, 0.18282683f, -0.06570573f, 0.18052474f, 0.42957136f, 0.01668914f, 0.03132191f, 
    -0.17948091f, -0.30585712f, -0.18937331f, -0.01848633f, 0.37684104f, 0.29655966f, -0.03312101f, -0.12796277f, 
    -0.05520022f, 0.02515592f, 0.00281810f, -0.15831807f, 0.07252170f, 0.17539920f, 0.18441355f, -0.06180940f, 
    0.00831368f, 0.02502430f, 0.05623755f, -0.04970405f, -0.08846902f, -0.21609505f, -0.03689434f, 0.09826402f, 
    0.11861778f, -0.22531389f, 0.25749943f, 0.13907702f, 0.01027584f, -0.43863249f, -0.08212698f, -0.14985378f, 
    0.04877171f, 0.20598552f, -0.16246019f, 0.04888055f, 0.00231239f, -0.05010938f, 0.15650310f, -0.07242585f, 
    0.07456822f, -0.16097881f, -0.19611318f, 0.20873377f, 0.15344685f, -0.06747955f, 0.00779519f, 0.01031351f, 
    -0.05180249f, 0.06015813f, -0.02945092f, -0.19596702f, 0.01459337f, 0.10699235f, 0.12344503f, -0.04769255f, 
    0.02262519f, -0.27054074f, -0.20639984f, 0.04435350f, -0.07320207f, -0.03097937f, -0.08758336f, -0.10863906f, 
    0.14435332f, -0.04838589f, 0.04262912f, 0.08887029f, -0.23291467f, -0.27615044f, 0.11340047f, 0.08472066f, 
    0.04545097f, 0.11981821f, 0.26437286f, 0.12267239f, 0.12736653f, 0.25489935f, -0.13443989f, 0.05847463f, 
    -0.08908834f, 0.21027169f, 0.04435030f, 0.17237277f, -0.00672221f, -0.09868933f, 0.04733588f, 0.39943737f, 
    0.11978422f, 0.15836093f, 0.15833512f, 0.13948385f, 0.07896505f, -0.01709209f, 0.09275775f, 0.26773164f, 
    0.05974112f, 0.24684761f, -0.04457258f, -0.15048507f, 0.07469282f, -0.22928132f, 0.07408752f, 0.02725128f, 
    -0.12667072f, 0.08535734f, -0.17299864f, 0.04541091f, -0.06019441f, -0.05651360f, 0.05121455f, -0.20110454f, 
    0.04311028f, 0.11326063f, 0.30325720f, -0.11691323f, -0.09645765f, -0.21377125f, 0.01225805f, -0.16210952f, 
    0.11846119f, -0.08896495f, -0.17622878f, -0.02927087f, 0.08073640f, -0.28917387f, -0.00497803f, 0.07538121f, 
    -0.12396292f, 0.09929963f, 0.08227871f, 0.01290141f, -0.35527137f, -0.35802287f, 0.05321738f, 0.20377055f, 
    0.14143924f, -0.24229102f, -0.13337594f, 0.01445771f, -0.10047408f, 0.00671600f, 0.11595219f, 0.11382532f, 
    -0.11093020f, 0.02886572f, 0.18679553f, -0.14332540f, 0.10540923f, 0.04167528f, -0.05700819f, 0.12720473f, 
    -0.31783193f, -0.08872455f, 0.34749424f, -0.30014554f, -0.15665105f, 0.22271036f, -0.02610064f, -0.11979428f, 
    -0.04981012f, -0.12078735f, 0.66189694f, 0.04665174f, 0.11335046f, 0.15301965f, -0.26937053f, -0.26178709f, 
    0.22262269f, -0.23169118f, 0.37081921f, -0.14720653f, 0.26086801f, -0.02497887f, -0.10915175f, 0.12488712f, 
    -0.06088287f, -0.07388644f, 0.03996714f, 0.18995854f, 0.31788453f, -0.11595539f, 0.00504544f, 0.08981499f, 
    -0.03885012f, 0.00444154f, 0.16153666f, -0.33783451f, 0.15538156f, 0.14431097f, 0.19112606f, 0.05591257f, 
    -0.23374619f, -0.14464815f, -0.09285504f, -0.06331161f, 0.29591203f, 0.29618835f, -0.28294018f, -0.13119806f, 
    0.11945449f, -0.12103128f, -0.22074606f, -0.27145046f, -0.01347118f, 0.27312949f, 0.16292964f, -0.19475478f, 
    0.10521080f, -0.15054776f, 0.04468927f, 0.01992237f, -0.05077303f, -0.27246428f, 0.02890663f, 0.00768394f, 
    0.07267501f, -0.13976309f, -0.01266744f, 0.08263589f, 0.00669424f, 0.24087393f, 0.07666700f, 0.07623194f, 
    0.00097510f, -0.02964986f, 0.05272486f, -0.19923927f, 0.08833894f, -0.14700387f, 0.05409960f, 0.05375898f, 
    0.08987611f, -0.10124196f, -0.25938365f, 0.20612939f, -0.35287911f, -0.15036413f, 0.27395630f, -0.22761388f, 
    0.00343808f, 0.24643634f, 0.12392862f, -0.02346618f, -0.22972156f, -0.04492053f, -0.01943869f, 0.01742549f, 
    0.01702566f, 0.11523595f, -0.09749243f, 0.12746315f, 0.29547012f, -0.44280794f, -0.08955288f, 0.04613345f, 
    -0.00068817f, 0.11095217f, -0.10737847f, -0.07276150f, -0.58969414f, -0.48748410f, 0.01446513f, -0.09277251f, 
    0.06169741f, 0.12591724f, 0.08481640f, 0.14154455f, -0.22281314f, -0.15371861f, 0.16247484f, 0.21459135f, 
    0.15632668f, 0.08287568f, 0.23413996f, -0.03014018f, 0.09602540f, -0.08603802f, 0.07323374f, 0.17381191f, 
    0.00262165f, 0.00994248f, -0.16623436f, 0.30361751f, 0.11798614f, -0.17273675f, 0.17537688f, -0.14670621f, 
    0.15937537f, 0.13925423f, -0.36261961f, -0.11350773f, 0.06153903f, 0.20664810f, 0.01377780f, 0.02414548f, 
    0.18091758f, -0.26766551f, 0.10648354f, 0.17570148f, -0.10784598f, 0.25538826f, 0.06091355f, -0.11205596f, 
    -0.15796468f, 0.11395654f, 0.12368800f, -0.12119791f, -0.16928232f, 0.18149436f, -0.01280657f, 0.15405419f, 
    -0.07781241f, 0.35618076f, -0.13071008f, -0.14090584f, -0.04711268f, -0.14423430f, -0.18776785f, -0.09787744f, 
    0.34820685f, -0.15203665f, 0.09092921f, 0.10413308f, -0.10016304f, 0.06556779f, 0.23410006f, -0.04600324f, 
    0.07629105f, 0.12230910f, 0.19115625f, 0.24120066f, 0.25293750f, -0.21985887f, -0.07138370f, 0.04007758f, 
    0.10658402f, 0.00989525f, 0.07559842f, 0.12555973f, 0.09407676f, 0.16871744f, 0.06060845f, 0.05503487f, 
    0.04962692f, -0.15236366f, 0.11135042f, -0.24601290f, 0.03339320f, -0.20553827f, -0.12475184f, 0.00109520f, 
    -0.03014712f, -0.12623169f, -0.24916868f, -0.02105546f, 0.09758019f, 0.08061768f, -0.00146062f, -0.03220591f, 
    0.00691368f, 0.23721986f, 0.00532124f, -0.06525780f, -0.03269339f, -0.21341732f, -0.21512724f, -0.16268322f, 
    -0.05128132f, -0.10047980f, -0.04821196f, 0.02917466f, -0.03080960f, -0.06882119f, -0.02039108f, 0.12741102f, 
    -0.01276062f, -0.17983931f, 0.07827199f, -0.03973088f, -0.03121990f, -0.15921579f, -0.02275939f, -0.04423823f, 
    -0.05899705f, 0.14398594f, 0.02407242f, -0.04271490f, 0.01014665f, -0.00112024f, -0.05837750f, -0.24917139f, 
    -0.01438951f, 0.08546208f, 0.19613063f, -0.02341406f, -0.05967761f, 0.14378080f, -0.10984857f, -0.05636816f, 
    -0.03990154f, 0.00248302f, -0.18884626f, 0.15454790f, -0.00065672f, 0.01110005f, -0.12399471f, -0.20481430f, 
    0.00846983f, 0.15368639f, -0.05098647f, 0.05333038f, -0.22745249f, 0.09091375f, -0.01370549f, -0.03406314f, 
    0.00874927f, 0.22856569f, 0.00771979f, 0.00438083f, -0.08940712f, -0.17170304f, -0.14931056f, 0.06613413f, 
    -0.25445524f, 0.13420489f, 0.05384193f, 0.02712822f, 0.05982877f, -0.09723912f, 0.02347962f, 0.23094644f, 
    -0.04835249f, 0.04468225f, -0.16450566f, 0.19940510f, 0.18881363f, -0.04447502f, 0.01197679f, -0.07306091f, 
    -0.07908808f, 0.04570158f, 0.26580730f, 0.38563904f, 0.38197270f, 0.10673661f, -0.16789679f, -0.08314459f, 
    -0.37634948f, -0.19590566f, 0.09424210f, -0.04422726f, 0.04821031f, 0.03205631f, -0.12955526f, 0.12265452f, 
    0.14234124f, -0.13371299f, -0.23117162f, -0.22150345f, -0.09552556f, 0.01633512f, 0.13781182f, 0.00265060f, 
    0.11509874f, -0.06010176f, 0.07930175f, -0.04532222f, -0.01567422f, 0.26980701f, -0.08791338f, -0.09797076f, 
    -0.13812405f, 0.05472206f, 0.16588208f, 0.00249931f, -0.12135002f, -0.39426979f, -0.15003556f, 0.16789503f, 
    0.17029619f, 0.36885765f, -0.18768200f, 0.04028112f, -0.09279687f, -0.15466066f, -0.24686107f, -0.12709211f, 
    -0.19949380f, -0.22147539f, 0.06516078f, 0.14237560f, -0.15381838f, 0.29786047f, -0.20587233f, 0.36628854f, 
    -0.19112964f, 0.00810674f, -0.08977528f, 0.06534489f, 0.19440764f, 0.00436375f, -0.02613106f, 0.19103368f, 
    -0.10633148f, 0.22894870f, -0.17897512f, 0.05381290f, -0.32106331f, 0.03204909f, -0.03909645f, 0.06315296f, 
    0.21033566f, -0.01409404f, -0.04021098f, 0.06782557f, -0.01710129f, 0.00874324f, 0.19064511f, -0.00206881f, 
    -0.10190189f, 0.15879741f, 0.24563514f, 0.02431182f, 0.00517173f, -0.00536598f, -0.18141992f, 0.05665676f, 
    0.02313039f, -0.28729379f, -0.09434745f, -0.15196139f, -0.01461158f, 0.22866167f, 0.11870013f, -0.02110914f, 
    0.30936334f, -0.08752201f, -0.27888975f, -0.06069567f, -0.03656401f, 0.08911379f, 0.04310305f, -0.19052197f, 
    -0.13291073f, -0.04736448f, -0.08060439f, -0.10414451f, -0.04274372f, -0.24327806f, 0.26880935f, 0.08422732f, 
    -0.03837755f, 0.18233363f, 0.11511136f, -0.19938312f, -0.37061155f, -0.02112265f, 0.28705764f, -0.05170570f, 
    -0.05176899f, 0.03436737f, -0.21456520f, 0.20910577f, 0.02287761f, 0.11182615f, -0.00101992f, 0.04847075f, 
    0.03741127f, -0.11623148f, 0.12303726f, -0.23449045f, 0.16069663f, -0.14344089f, -0.22786199f, 0.08105537f, 
    -0.08622982f, 0.14989357f, 0.18087171f, -0.07319225f, 0.17367025f, 0.08453711f, -0.13108964f, -0.08961808f, 
    0.09145463f, 0.31738475f, -0.16963279f, 0.27759165f, -0.10206924f, -0.02221408f, 0.28988016f, 0.13529281f, 
    0.20293072f, 0.07693629f, 0.22302756f, -0.17255524f, 0.11001529f, -0.14905830f, 0.02286617f, -0.27144918f, 
    0.10856901f, 0.09801044f, -0.21383323f, 0.18447582f, 0.25651976f, -0.18748826f, 0.11494183f, 0.12282168f, 
    -0.16719106f, -0.13010240f, -0.08634154f, -0.15423208f, 0.08725882f, 0.14785326f, 0.12452167f, 0.08738162f, 
    0.34844100f, -0.28616962f, -0.11035638f, 0.12712859f, -0.05237189f, -0.34318313f, 0.12294418f, -0.21060133f, 
    -0.00280875f, 0.14775482f, 0.36453795f, -0.03377102f, -0.21407337f, 0.17613055f, 0.06276638f, 0.12802871f, 
    -0.02149701f, 0.04736140f, 0.05330418f, -0.27679411f, -0.00149337f, -0.05153323f, -0.00297309f, -0.07292929f, 
    0.17628831f, -0.07898234f, -0.21483107f, -0.01904967f, -0.07145851f, 0.11518481f, 0.28935993f, -0.12047963f, 
    -0.14898975f, -0.18862368f, -0.01350602f, 0.21236007f, 0.18000576f, -0.37726608f, 0.05972286f, 0.18425040f, 
    -0.04929167f, 0.22147374f, -0.00819383f, -0.06562372f, -0.04676848f, -0.03640914f, -0.07190715f, 0.09706934f, 
    -0.09912688f, -0.08052222f, -0.06173218f, -0.07709622f, -0.12206952f, 0.01859282f, 0.08949352f, -0.08281887f, 
    -0.01938021f, -0.00888847f, -0.00096370f, 0.05371413f, 0.05775733f, -0.10290812f, 0.06029360f, -0.11423518f, 
    0.06840514f, -0.09437982f, -0.12031785f, -0.07112531f, 0.06453244f, 0.00708289f, 0.08984242f, 0.02983461f, 
    0.08221503f, -0.04199136f, 0.02387999f, 0.02977352f, 0.04482229f, -0.04084967f, 0.11370031f, 0.09267682f, 
    0.03166415f, -0.10191272f, 0.02019701f, -0.14696658f, 0.02651593f, 0.04959309f, -0.15009984f, -0.09172232f, 
    0.06441697f, 0.05539570f, -0.03754719f, 0.06763355f, 0.02348271f, -0.03166931f, -0.07268966f, 0.03578918f, 
    0.07226612f, -0.15267783f, -0.08937274f, -0.11089192f, -0.15378651f, 0.05110632f, 0.01683144f, -0.08822456f, 
    -0.04822714f, 0.09321505f, -0.15339316f, -0.13786374f, -0.01679032f, -0.15007195f, 0.04588242f, -0.12607320f, 
    0.13872023f, -0.16691609f, -0.14780921f, 0.05542449f, -0.17592442f, -0.27022937f, 0.14857523f, -0.11162257f, 
    0.19443557f, 0.06677698f, 0.42443368f, -0.07639392f, -0.09892794f, 0.07359549f, 0.31748587f, 0.08171809f, 
    0.00709297f, 0.03366352f, 0.26701298f, -0.11491940f, -0.27508286f, 0.26186702f, 0.10594217f, -0.37036455f, 
    -0.08202774f, 0.16644691f, 0.30700561f, 0.04931776f, 0.03073117f, -0.15774263f, -0.01352275f, 0.16408968f, 
    0.06106561f, -0.11645416f, 0.01576041f, -0.14219069f, -0.40211210f, -0.16565673f, -0.02238014f, -0.07808800f, 
    0.08446652f, 0.12111505f, 0.13860624f, -0.04108711f, 0.05602231f, -0.00440336f, -0.15556979f, 0.16881321f, 
    -0.00437042f, 0.10427496f, -0.05702156f, 0.14555825f, -0.11956465f, 0.09143134f, -0.20422190f, 0.09594919f, 
    0.15690990f, 0.00374748f, 0.01116914f, -0.10219308f, -0.01020735f, 0.10403147f, 0.00813043f, -0.18776762f, 
    0.29304773f, -0.22342663f, 0.02423299f, -0.19472338f, 0.19168663f, 0.40867087f, -0.07494321f, 0.08818929f, 
    -0.02809695f, 0.08094539f, -0.36653385f, 0.14545406f, 0.03538317f, -0.07926359f, -0.14741836f, -0.21041417f, 
    -0.07916136f, 0.07101953f, 0.11898163f, -0.07456694f, 0.16879852f, 0.26010615f, 0.05204777f, 0.23862162f, 
    -0.06562545f, -0.11128952f, 0.08229727f, 0.15685585f, 0.13812222f, 0.08458533f, 0.10339356f, -0.30806097f, 
    0.11468811f, 0.01862777f, -0.06302655f, 0.21526863f, 0.29267737f, 0.12159620f, -0.08590844f, -0.01764600f, 
    -0.24706014f, -0.17788939f, 0.10698115f, 0.00721103f, -0.02047893f, -0.04928655f, 0.16599552f, 0.03420494f, 
    0.03856635f, 0.07839154f, -0.02551374f, -0.07226760f, 0.01471224f, -0.06141314f, 0.26431337f, 0.10834978f, 
    0.08587006f, 0.04487257f, 0.13764922f, 0.03210307f, -0.02601779f, 0.20407483f, 0.03809843f, 0.13285145f, 
    0.35539615f, -0.17546308f, -0.13599826f, 0.15276223f, -0.17838234f, -0.07566532f, -0.04686501f, -0.32636189f, 
    0.14839910f, 0.07039870f, -0.32081488f, -0.10834157f, -0.08941624f, -0.24201223f, 0.04381290f, -0.12073287f, 
    -0.06159398f, -0.22418047f, 0.00593354f, -0.16003017f, -0.14972249f, 0.38862327f, 0.18656775f, 0.02952761f, 
    -0.37771127f, -0.10671666f, -0.36014530f, -0.02236513f, 0.16606686f, 0.19791853f, -0.06004591f, -0.02188873f, 
    0.01776467f, 0.09149745f, -0.01505102f, 0.21574533f, -0.14309397f, -0.13729727f, -0.35531539f, -0.09197980f, 
    0.14899245f, -0.03045559f, 0.23083703f, 0.09446293f, 0.11369233f, -0.05942090f, -0.08969282f, 0.17485528f, 
    -0.01760978f, 0.33622810f, 0.16897528f, -0.03520074f, 0.11906208f, 0.07315388f, -0.07120871f, 0.03842952f, 
    0.05108391f, 0.00326400f, 0.17101309f, 0.11066656f, 0.11475025f, 0.11001240f, -0.00639127f, -0.17351387f, 
    0.19212571f, 0.34859633f, -0.12486899f, 0.03191732f, 0.27930662f, -0.45679826f, 0.23228365f, 0.13480178f, 
    -0.08297760f, -0.00430469f, -0.04285429f, -0.02889346f, 0.10075711f, -0.01335591f, 0.21221454f, 0.25732315f, 
    0.19993529f, -0.07630736f, -0.10463410f, 0.00923850f, 0.09692498f, -0.10679877f, 0.18920043f, 0.01015638f, 
    0.02057018f, 0.05640026f, 0.02009699f, 0.05525337f, 0.05472212f, -0.15057421f, -0.09659594f, 0.21580422f, 
    0.10953376f, 0.01617316f, 0.01477889f, -0.29285657f, -0.39245552f, 0.12281059f, -0.26137513f, 0.10482217f, 
    0.28907719f, -0.02662973f, -0.00055868f, -0.06295562f, -0.07579225f, -0.07367247f, -0.03575609f, -0.24433495f, 
    0.12138195f, 0.28044724f, 0.11484168f, 0.31839070f, 0.06129302f, -0.09779634f, -0.15734920f, 0.13618200f, 
    0.07449257f, -0.07869808f, 0.23164368f, 0.12987252f, -0.05822403f, -0.19965133f, 0.10231040f, -0.21105377f, 
    0.08833649f, -0.05632538f, 0.35554183f, -0.05141782f, 0.07498378f, -0.22083953f, -0.11058370f, 0.17679395f, 
    -0.01389033f, 0.05107769f, 0.04998818f, 0.04180741f, 0.11006060f, -0.27990109f, -0.00282947f, 0.09528352f, 
    -0.23763926f, 0.20610459f, -0.16523834f, 0.13121517f, 0.03651268f, 0.12275721f, -0.22640440f, 0.08932323f, 
    0.04882820f, -0.10150772f, 0.05585795f, -0.29654953f, 0.02493489f, -0.13223453f, -0.01674198f, -0.09555563f, 
    -0.05433441f, -0.36198148f, 0.08163795f, 0.06444982f, 0.06683610f, -0.02148571f, 0.10378610f, 0.00903147f, 
    0.09099349f, 0.18499719f, 0.01119482f, -0.08652996f, -0.04838005f, -0.24932344f, 0.04760137f, 0.08671302f, 
    0.01077451f, 0.11316849f, -0.13131411f, 0.10548742f, 0.00304849f, 0.20415506f, 0.17549016f, 0.18139775f, 
    -0.30867806f, 0.01636959f, -0.00975822f, -0.20640823f, 0.10297470f, -0.08321177f, -0.11663213f, -0.02396210f, 
    -0.13066900f, -0.08807117f, -0.01434473f, -0.18852590f, -0.01133220f, 0.11522818f, -0.07584913f, -0.09082290f, 
    0.09067526f, -0.08766622f, -0.12319022f, -0.09571945f, -0.04986999f, 0.05140380f, -0.03871171f, -0.15898500f, 
    -0.05001086f, -0.17989911f, -0.13348679f, -0.00182000f, 0.02736381f, 0.10327347f, 0.00169382f, -0.07689346f, 
    -0.05122627f, -0.10578004f, 0.01493658f, 0.13726512f, -0.06449802f, 0.12837671f, 0.08388827f, -0.01083800f, 
    0.07077321f, 0.06623758f, 0.04312712f, 0.03622000f, 0.15480508f, 0.00663783f, -0.04240936f, 0.07162240f, 
    -0.09907844f, -0.08716754f, -0.00189301f, -0.08442113f, -0.06580888f, 0.00086497f, -0.03140752f, 0.16860782f, 
    -0.08315514f, -0.02170736f, 0.01328062f, -0.16385470f, -0.07849527f, -0.12847501f, -0.03251255f, -0.14549576f, 
    -0.06055274f, 0.05429475f, -0.04195496f, 0.14975400f, 0.01219204f, 0.18606758f, 0.09145055f, 0.10835718f, 
    0.26035464f, 0.19520274f, -0.46635035f, 0.18546483f, 0.12424183f, 0.32779157f, 0.32202664f, -0.01569838f, 
    -0.12074638f, -0.22126183f, -0.64432734f, -0.05705597f, 0.00514905f, -0.08546222f, 0.23672050f, 0.17851065f, 
    0.13500346f, 0.02471209f, 0.06275697f, -0.16794205f, -0.17383160f, -0.20792693f, 0.29024687f, -0.06130550f, 
    -0.14316121f, 0.07608419f, -0.36132193f, 0.12103018f, -0.05035397f, 0.34768674f, -0.13180117f, -0.06193202f, 
    -0.10438876f, 0.35500222f, 0.16886035f, -0.26948786f, -0.18718971f, -0.02864455f, -0.20778802f, 0.04695865f, 
    0.00102930f, 0.01489222f, -0.04492063f, 0.11945600f, 0.23257834f, 0.16556489f, 0.12564328f, -0.16885765f, 
    0.01726861f, 0.18354453f, -0.15729354f, 0.17864186f, 0.06759145f, -0.25107017f, 0.37030250f, 0.01388388f, 
    0.18273704f, 0.11510108f, 0.18186532f, 0.04016647f, -0.00465202f, -0.11685484f, -0.00974734f, -0.01395575f, 
    0.07999875f, -0.16135089f, 0.23794456f, 0.13948716f, -0.09220830f, -0.14181143f, -0.10118510f, -0.09764369f, 
    0.04989143f, 0.28698862f, -0.18676496f, -0.42836285f, -0.02016824f, -0.13066640f, 0.16551036f, -0.36744258f, 
    -0.27730349f, -0.15085031f, 0.13956273f, -0.05313146f, -0.08485387f, 0.12827295f, -0.10961766f, -0.14621603f, 
    -0.17743564f, -0.03934383f, -0.01038726f, -0.09704763f, -0.05123574f, 0.15374722f, 0.11087834f, 0.02638567f, 
    0.05566205f, -0.22454210f, -0.02330683f, 0.12408236f, 0.41996184f, -0.27371874f, -0.07858893f, 0.07566652f, 
    -0.01941828f, -0.20635711f, 0.18960777f, 0.11796450f, -0.08526023f, -0.02625029f, 0.10264976f, 0.06841709f, 
    0.08531807f, 0.19359078f, 0.11220807f, -0.03391159f, 0.03085041f, 0.24180716f, -0.13009882f, 0.03195770f, 
    0.11043733f, 0.14250538f, 0.01253257f, -0.19571477f, -0.06691475f, 0.21844353f, -0.04198988f, -0.02845335f, 
    0.05803937f, 0.12157074f, 0.06740122f, -0.06582691f, 0.06277637f, -0.14938459f, -0.06850091f, 0.02281944f, 
    -0.03028325f, 0.11324867f, -0.23783782f, 0.27054194f, 0.09227737f, -0.18180759f, 0.14700809f, -0.23710920f, 
    -0.01006080f, 0.20254591f, -0.00230461f, 0.01060304f, -0.15963429f, 0.31399271f, -0.09317463f, 0.21252225f, 
    -0.16170913f, -0.20619692f, -0.38946229f, 0.17668045f, 0.27790248f, -0.06378689f, -0.10586289f, 0.08887817f, 
    0.07521816f, 0.28588685f, 0.01952352f, -0.15590471f, -0.28110886f, 0.20046042f, -0.30757734f, -0.04959560f, 
    0.27979237f, 0.09819528f, 0.18359433f, 0.09139134f, 0.27843007f, 0.22265616f, -0.00469005f, -0.14073913f, 
    0.03113996f, 0.34399211f, 0.24445371f, 0.16324432f, 0.18188931f, 0.08850868f, -0.15682964f, 0.08083723f, 
    0.13764304f, -0.16727228f, -0.00964452f, 0.03438364f, -0.01574617f, -0.13532488f, 0.04272633f, -0.22302537f, 
    0.04756393f, -0.03913395f, -0.04364745f, 0.04022307f, -0.12821320f, 0.08072302f, 0.04858004f, 0.02314874f, 
    -0.02035427f, 0.09059054f, 0.10262875f, 0.03321275f, 0.08701900f, -0.10864434f, 0.02341091f, -0.08841664f, 
    0.06784105f, -0.05131724f, -0.08848861f, -0.13160583f, -0.05280115f, -0.06308506f, -0.08768600f, -0.05449317f, 
    0.01610128f, -0.03109720f, -0.01100221f, -0.07082786f, -0.07501113f, -0.06627994f, -0.09357268f, -0.11503855f, 
    0.03451999f, -0.09868886f, -0.06415828f, -0.13547499f, 0.07248911f, 0.08697847f, -0.02702151f, -0.09444280f, 
    0.07776786f, 0.04327969f, -0.10033566f, -0.09673666f, -0.06672221f, 0.01981163f, -0.03752126f, -0.06324042f, 
    0.02431113f, 0.07248108f, -0.10408903f, 0.07315648f, -0.00658032f, 0.09324154f, -0.04796608f, 0.06093384f, 
    -0.11014601f, 0.07065751f, -0.14445528f, -0.09698887f, -0.01084253f, 0.01211369f, -0.10622692f, -0.00360768f, 
    0.24926117f, 0.15883540f, -0.48239413f, 0.09640515f, -0.29501203f, -0.00517266f, 0.17867254f, 0.05385476f, 
    0.08938389f, 0.32067886f, -0.31996894f, 0.01532174f, 0.00631316f, -0.27378243f, -0.03947968f, 0.05779636f, 
    -0.07256147f, -0.43651107f, -0.14682224f, -0.08401859f, -0.03844481f, 0.29416022f, 0.01763779f, 0.19580479f, 
    -0.40661341f, 0.20642628f, 0.12472982f, 0.09671465f, 0.11675245f, 0.04564276f, 0.05824981f, -0.11209997f, 
    0.07268708f, 0.38649440f, 0.13349190f, 0.28221470f, -0.21788143f, -0.01762421f, -0.29021344f, 0.08861059f, 
    -0.03913669f, -0.27719843f, -0.06464627f, -0.12052145f, -0.10608372f, -0.00881765f, 0.18776609f, 0.07312983f, 
    0.05326370f, -0.11883269f, 0.04426348f, 0.04700024f, 0.19245219f, -0.47913411f, -0.02740449f, -0.07383484f, 
    0.31552377f, -0.06576785f, 0.04920298f, 0.04962699f, -0.08408054f, 0.29280677f, -0.01983565f, -0.16154973f, 
    0.02914899f, -0.35074878f, -0.06283993f, -0.23155729f, -0.02006621f, 0.05335216f, 0.00730596f, -0.33208758f, 
    -0.08095019f, -0.31108800f, -0.09992009f, -0.07340396f, 0.04529123f, 0.02767812f, 0.29613942f, -0.10036790f, 
    0.11806151f, 0.14693999f, -0.09373415f, -0.13393404f, 0.01031419f, -0.10108276f, 0.32432693f, -0.30569017f, 
    0.01000403f, -0.05094518f, 0.14083286f, 0.07577337f, 0.19895819f, -0.15304774f, -0.04507986f, -0.10649698f, 
    -0.11653154f, -0.13645041f, -0.17932166f, -0.21810317f, -0.24585204f, -0.14150606f, -0.15402897f, -0.04798925f, 
    -0.12866566f, 0.11896769f, -0.06586978f, -0.04412414f, 0.00636518f, -0.16202161f, -0.18830843f, -0.08068047f, 
    0.07220966f, 0.00576431f, -0.01607778f, 0.20100537f, -0.11008732f, 0.07578803f, -0.03126503f, -0.19836317f, 
    -0.16879345f, 0.23595719f, 0.08410121f, 0.27218801f, -0.10302684f, -0.21779813f, 0.04489686f, -0.19788709f, 
    0.17920919f, -0.14308821f, -0.15198529f, 0.02540524f, -0.23364764f, 0.22092094f, -0.08585432f, -0.00487944f, 
    0.21845043f, 0.31448624f, 0.28168792f, -0.05054979f, 0.09450139f, -0.25915352f, 0.04466092f, -0.05319615f, 
    -0.19917980f, 0.19622815f, 0.21595638f, -0.12345912f, -0.14268251f, 0.18862495f, 0.03887559f, -0.06219553f, 
    -0.18663798f, -0.04059735f, -0.30729637f, -0.03864011f, 0.18506233f, -0.04346240f, -0.10363387f, 0.03188117f, 
    -0.00707328f, 0.06763966f, 0.05262407f, 0.14933589f, 0.14264549f, -0.04749958f, -0.20625883f, -0.05731906f, 
    -0.27085721f, -0.12932597f, 0.20179416f, 0.06355301f, 0.20517045f, 0.10621296f, -0.29608566f, 0.13153633f, 
    0.00967550f, 0.05858265f, -0.33731836f, 0.08259758f, 0.09345733f, 0.12703848f, 0.11657301f, -0.06844252f, 
    0.17607689f, 0.08706119f, -0.07012952f, -0.02677703f, -0.04731876f, 0.29747102f, 0.08187450f, -0.08605317f, 
    -0.06822391f, -0.29755378f, 0.28335705f, 0.04899741f, 0.08569816f, -0.07046829f, 0.09441072f, 0.01593325f, 
    0.13072594f, 0.05557859f, 0.18834135f, 0.12841424f, 0.08922569f, 0.00079267f, -0.02270704f, 0.19292164f, 
    0.13202098f, -0.10150144f, -0.17194436f, 0.22378874f, 0.10227255f, -0.18055990f, 0.14261249f, 0.02740669f, 
    -0.03158028f, 0.01790205f, 0.27437410f, -0.20503277f, 0.00112075f, -0.06641894f, 0.04273390f, -0.36141917f, 
    0.00308050f, -0.04744999f, -0.23014486f, -0.03867302f, 0.18946944f, 0.06440108f, -0.09753098f, -0.08468980f, 
    -0.20496838f, -0.08682420f, -0.27079397f, 0.07586934f, -0.18886933f, -0.21723408f, 0.32894093f, 0.20141977f, 
    -0.06110300f, -0.40725625f, 0.06456876f, 0.07101478f, 0.04962631f, 0.26850522f, -0.04843660f, -0.07085458f, 
    -0.15367913f, 0.02798279f, -0.19474950f, 0.14200418f, 0.07197890f, 0.14456788f, -0.10208886f, 0.39724460f, 
    -0.05976463f, 0.21181571f, 0.03070912f, -0.10002120f, -0.16208757f, -0.27026424f, 0.16943730f, 0.05389564f, 
    0.08464366f, -0.10873252f, -0.45217699f, 0.06199096f, 0.01997475f, -0.29567754f, -0.09649482f, 0.06468049f, 
    -0.05620882f, -0.37221012f, -0.24676009f, 0.02242889f, -0.10699637f, 0.05892761f, 0.14423354f, 0.09938557f, 
    -0.27404106f, 0.21282537f, 0.06202092f, -0.01197045f, -0.01644157f, -0.28106439f, 0.10348810f, 0.01272440f, 
    0.07806534f, -0.10587985f, -0.14902769f, 0.01963198f, -0.46146727f, 0.10760156f, -0.25311968f, -0.06156025f, 
    0.06758113f, 0.03385229f, 0.01796500f, 0.02462279f, -0.45537961f, -0.28348285f, 0.13188231f, -0.01028267f, 
    -0.12938270f, 0.16907385f, 0.18939167f, -0.10025366f, -0.16252881f, -0.17344445f, -0.09409475f, -0.16411823f, 
    0.24848679f, 0.00983988f, 0.21570271f, 0.06017667f, 0.03564632f, 0.03788718f, -0.10387184f, -0.07116053f, 
    -0.07664689f, -0.14065020f, -0.01087160f, -0.01222192f, -0.08571377f, 0.10605003f, -0.03104433f, -0.01713187f, 
    0.02829959f, -0.10493580f, -0.01847045f, -0.05141855f, 0.10025515f, -0.13168126f, -0.00217105f, -0.05644821f, 
    -0.02192087f, -0.11798099f, 0.04241682f, 0.02910310f, -0.06569508f, -0.01990264f, -0.07583914f, 0.04509954f, 
    0.00103871f, -0.12089957f, 0.05612337f, -0.14249450f, 0.04827579f, 0.10325323f, 0.01885834f, -0.06718472f, 
    0.08948493f, 0.06823026f, -0.11975415f, -0.09840617f, 0.08226460f, -0.00700112f, -0.05931023f, -0.06357028f, 
    0.01718423f, -0.01423349f, -0.09559882f, -0.00166176f, -0.05261897f, 0.11004968f, -0.05488432f, -0.09337440f, 
    -0.00468817f, -0.00466732f, 0.00256622f, 0.05117479f, -0.08670548f, -0.14535508f, -0.02121207f, -0.02673979f, 
    -0.09191287f, -0.02240651f, 0.11227967f, -0.04826371f, 0.06661299f, -0.11092961f, -0.02134253f, -0.07351145f, 
    -0.11537015f, 0.20759527f, 0.33506143f, -0.01877144f, -0.13911721f, -0.24558847f, -0.02032388f, 0.19704238f, 
    0.08901337f, 0.38271937f, 0.41770723f, -0.01125695f, 0.01246100f, -0.16708456f, -0.09027479f, 0.13566396f, 
    -0.27997601f, 0.12451090f, 0.11013778f, 0.13504742f, 0.19935021f, -0.20559579f, -0.03706177f, 0.16017620f, 
    -0.15368931f, -0.10995305f, 0.15338923f, 0.12153285f, 0.22295202f, -0.14645897f, 0.12177084f, 0.01051459f, 
    -0.09688012f, -0.10829344f, 0.11613325f, 0.15439160f, 0.23236251f, 0.19436167f, -0.11602950f, 0.00221216f, 
    -0.06105391f, -0.20815270f, -0.00933549f, -0.10880601f, 0.21894096f, -0.07012861f, 0.07480447f, 0.34378991f, 
    -0.03001933f, -0.11479902f, -0.05923938f, -0.14957653f, 0.14824161f, 0.31800720f, -0.10730895f, 0.22731991f, 
    0.00547263f, -0.14581940f, -0.10462899f, -0.14137875f, 0.07615774f, -0.00677034f, -0.05240853f, 0.00541460f, 
    0.36637437f, -0.13238266f, 0.21648434f, 0.11398596f, 0.13111769f, -0.08738340f, -0.07678316f, -0.09290352f, 
    0.00360864f, 0.13599506f, -0.31549317f, -0.10700721f, 0.09690858f, -0.11762576f, 0.19073129f, -0.12166207f, 
    -0.13891047f, 0.22558077f, -0.29985595f, -0.08720852f, -0.15262257f, -0.16250113f, 0.01281505f, 0.05101936f, 
    0.11828091f, -0.01528734f, -0.04807518f, -0.02225051f, -0.17110592f, 0.19924900f, 0.09159489f, -0.03669843f, 
    0.07834370f, -0.16844520f, 0.01127750f, 0.16978069f, 0.49712941f, -0.15766098f, -0.02427829f, -0.08957469f, 
    -0.10900185f, -0.03558750f, 0.20819807f, -0.01926085f, 0.14746657f, -0.04746594f, 0.10480551f, 0.15079191f, 
    0.10060874f, 0.18570419f, -0.02335282f, 0.15078303f, 0.16073458f, 0.09677901f, 0.25608757f, 0.40001404f, 
    -0.14382403f, 0.22988759f, 0.07528055f, -0.04234637f, -0.05579508f, 0.02386012f, -0.07456958f, 0.08657097f, 
    -0.15107252f, 0.14160196f, -0.09529620f, -0.30544665f, -0.20849372f, -0.32696053f, 0.23934139f, 0.10463015f, 
    0.17828441f, -0.06012551f, 0.51301241f, -0.00029688f, 0.02082426f, -0.19800738f, 0.00863066f, 0.21985845f, 
    -0.15545349f, 0.04604206f, 0.23240042f, -0.05725098f, 0.20106880f, -0.04219399f, -0.04951261f, 0.01018406f, 
    -0.04292876f, 0.05873354f, 0.00071192f, 0.00402125f, 0.02988479f, -0.14557537f, -0.06400567f, 0.06214938f, 
    -0.11805359f, -0.33982584f, 0.26421899f, -0.00006340f, 0.00235394f, 0.26891261f, -0.20540485f, 0.05068351f, 
    -0.12163489f, -0.28814375f, 0.00463769f, -0.09181782f, 0.24586579f, 0.20170015f, -0.35706505f, 0.00993370f, 
    -0.02186773f, -0.23901561f, -0.18243161f, -0.07658476f, -0.05024639f, 0.00726242f, -0.19201937f, -0.14576617f, 
    -0.08482472f, 0.03114243f, -0.11829800f, -0.01549699f, -0.05081134f, 0.05168866f, 0.02754448f, -0.21567488f, 
    -0.15235202f, 0.05804788f, -0.32488650f, 0.01036953f, -0.09924755f, 0.41196409f, 0.17233124f, 0.24240585f, 
    0.12371705f, -0.18215239f, 0.05903643f, -0.00682096f, -0.01500936f, 0.14366621f, 0.08889219f, 0.29418412f, 
    -0.02447950f, 0.00662284f, 0.11813235f, 0.05724733f, -0.01149171f, -0.06505325f, 0.18455078f, -0.15738890f, 
    -0.00480489f, 0.10612833f, 0.05917029f, 0.11207020f, 0.05897531f, -0.03537409f, 0.07893723f, -0.06535993f, 
    -0.03900426f, 0.22338507f, 0.06204142f, -0.11567459f, -0.23149751f, -0.18510093f, -0.04009002f, -0.10950046f, 
    0.06316719f, 0.12781455f, -0.10829137f, 0.07949277f, -0.10088996f, 0.11613589f, -0.01684323f, -0.03954089f, 
    0.02159288f, -0.20716384f, -0.14496551f, 0.08337514f, -0.03598086f, -0.28002146f, 0.18536894f, -0.15823375f, 
    0.04986746f, 0.08552588f, 0.13953762f, 0.09826163f, 0.10141270f, 0.04301801f, 0.05422975f, -0.03058417f, 
    -0.04303527f, -0.16285077f, 0.36474213f, -0.30832407f, 0.05942692f, 0.05470734f, -0.08286259f, 0.07751690f, 
    -0.14181553f, -0.19315805f, 0.50921321f, 0.36479110f, -0.03916477f, 0.05215370f, -0.00112302f, -0.02188824f, 
    0.27872297f, -0.01347524f, 0.09547365f, -0.13043781f, 0.14004585f, 0.26872352f, 0.16265686f, -0.02896855f, 
    0.06410307f, 0.03748254f, 0.23556454f, 0.04703476f, 0.17405902f, -0.06953559f, 0.04433272f, 0.04394555f, 
    -0.00219023f, -0.17992029f, -0.25535792f, -0.41804430f, 0.05199180f, 0.21669422f, 0.16103195f, 0.07600122f, 
    0.04681492f, -0.16660237f, -0.25858781f, -0.06238306f, 0.29851308f, 0.10311554f, -0.06727904f, -0.31138599f, 
    -0.02294765f, 0.08522216f, 0.19487050f, 0.01535830f, 0.01172040f, 0.39203697f, 0.16415916f, -0.11314359f, 
    0.14672950f, 0.09754647f, -0.01357904f, 0.10364527f, -0.01292204f, -0.38665158f, -0.01715334f, 0.15139626f, 
    -0.07515657f, -0.13024923f, 0.26655319f, 0.00883425f, 0.25629941f, 0.49517632f, 0.08446507f, 0.01127337f, 
    -0.11581224f, -0.17347792f, -0.17368387f, 0.18287300f, 0.08073267f, 0.19250953f, 0.10036067f, -0.31395137f, 
    0.16310039f, -0.05549054f, -0.14929651f, 0.01548662f, 0.25316972f, -0.00769548f, 0.16117637f, 0.28494030f, 
    0.08365816f, -0.06339234f, 0.17915809f, -0.14415394f, -0.13150263f, 0.42621246f, -0.10600179f, -0.32068485f, 
    -0.01986285f, 0.24596074f, -0.29472512f, -0.15041138f, 0.40067875f, -0.05907970f, 0.02178186f, -0.10700484f, 
    -0.08006823f, -0.42289162f, -0.21297771f, 0.01503058f, 0.11494768f, 0.21368538f, 0.28357807f, 0.24696255f, 
    -0.12977463f, -0.19688171f, -0.23701577f, -0.00629299f, 0.14712514f, 0.05095787f, 0.25000516f, 0.05893194f, 
    -0.18575290f, 0.24452978f, 0.06144461f, 0.11562112f, -0.03232025f, -0.05024635f, -0.09679616f, 0.38132086f, 
    -0.29047641f, 0.09553084f, 0.27773663f, -0.00188823f, 0.09433466f, -0.38000330f, 0.00751079f, 0.01348801f, 
    0.11263819f, 0.18223424f, 0.06113463f, 0.05146778f, -0.05213319f, 0.14470489f, -0.03464386f, 0.08896017f, 
    0.19815040f, -0.28614184f, -0.08977466f, 0.32131162f, 0.07633372f, 0.07045509f, -0.10924575f, -0.12116449f, 
    0.00193196f, 0.11380076f, 0.37387881f, -0.13966960f, -0.04841796f, -0.03066886f, -0.03242887f, 0.18009549f, 
    0.04894837f, -0.10760011f, -0.15213256f, 0.00947752f, -0.05556916f, 0.20743929f, -0.03128485f, 0.01977706f, 
    0.48002744f, 0.02039903f, -0.31063819f, -0.06495399f, 0.02258826f, -0.00715446f, 0.34248781f, 0.12605229f, 
    -0.01067574f, -0.11706185f, 0.32019344f, 0.15106179f, -0.03558065f, 0.03967582f, -0.06453821f, 0.12923682f, 
    -0.13753109f, 0.05699344f, -0.15380821f, -0.01982862f, -0.10022467f, -0.14731944f, -0.08945075f, 0.14886935f, 
    -0.21559957f, 0.32951576f, 0.15748613f, -0.05438967f, 0.16053975f, -0.12715068f, 0.11928739f, 0.32590288f, 
    -0.19647412f, -0.06305008f, -0.44119528f, 0.28204659f, -0.03615003f, -0.07627476f, -0.13530000f, 0.20484513f, 
    0.07516590f, 0.10135856f, -0.13414750f, -0.02260536f, 0.17480065f, -0.14817213f, 0.04498406f, 0.30962843f, 
    -0.01840637f, -0.04612764f, -0.11467250f, -0.02674834f, 0.02256674f, -0.15889828f, -0.02958320f, 0.11245658f, 
    -0.00401027f, 0.36227843f, -0.02421925f, -0.12334149f, -0.03385419f, 0.18425860f, 0.03915117f, 0.00031091f, 
    0.00390862f, -0.07472459f, -0.25545594f, -0.00028586f, -0.02734909f, 0.14038692f, 0.27497467f, -0.12465958f, 
    0.05727756f, 0.14474231f, -0.07439672f, 0.19371830f, 0.11716712f, -0.17282934f, 0.15637040f, 0.07246516f, 
    0.02705830f, -0.14466715f, 0.12583749f, 0.02239555f, -0.02726205f, -0.14331742f, -0.04545345f, -0.03505228f, 
    0.04123013f, -0.10591477f, 0.32205862f, -0.31975842f, 0.14707822f, 0.13737056f, -0.00812522f, 0.25103644f, 
    -0.06883179f, -0.15380901f, 0.07666285f, 0.30122223f, 0.08442590f, 0.20547609f, -0.26278275f, -0.14312127f, 
    0.12633821f, -0.09639553f, 0.20380585f, -0.18443492f, 0.21822827f, 0.14923416f, 0.09581405f, 0.01430065f, 
    0.09500214f, -0.07801146f, 0.20347594f, 0.27799267f, 0.30050391f, -0.07430942f, 0.11675336f, 0.02728715f, 
    -0.02058855f, -0.15205650f, -0.13681041f, -0.08014537f, -0.23338401f, 0.18911016f, 0.22216909f, 0.04774223f, 
    0.01057863f, -0.09853112f, -0.01777767f, 0.09476347f, 0.01474261f, 0.07578287f, 0.15523535f, 0.00571831f, 
    0.05411429f, -0.05564938f, 0.16131522f, -0.19469853f, 0.10214116f, 0.13890147f, 0.07210822f, -0.00889960f, 
    0.06015443f, -0.06250920f, 0.20923840f, 0.08113340f, 0.00541014f, -0.10168604f, 0.09932036f, 0.15880954f, 
    -0.00192022f, 0.06006426f, 0.04422196f, -0.00792917f, -0.06115731f, -0.04588864f, -0.04642162f, 0.08702411f, 
    0.07011215f, -0.11801449f, -0.05161275f, -0.05404387f, -0.05155308f, 0.00502230f, 0.01944198f, -0.04343923f, 
    0.07409889f, 0.00874307f, -0.05161640f, -0.07772325f, -0.07742365f, 0.00217127f, -0.03212019f, -0.00578476f, 
    -0.13680999f, -0.11008841f, -0.06297078f, -0.10674911f, 0.02817754f, 0.02381803f, 0.02952810f, 0.04403429f, 
    -0.05206610f, -0.07954329f, 0.02659774f, -0.06074787f, -0.10478730f, 0.07752617f, -0.00061437f, 0.02746689f, 
    -0.10751148f, -0.02403527f, 0.00777588f, 0.05135109f, -0.02840006f, 0.03772360f, 0.07466488f, -0.09320509f, 
    -0.00662046f, -0.05865099f, -0.05468011f, -0.00686008f, -0.02040180f, -0.05470796f, -0.11893522f, -0.01628639f, 
    -0.04945253f, -0.00104939f, -0.13216151f, 0.00292959f, 0.00843938f, -0.02087108f, 0.12181415f, -0.07481392f, 
    -0.15908365f, -0.05784296f, 0.08345342f, 0.05115819f, -0.00043314f, -0.06462974f, 0.00001052f, -0.10620231f, 
    -0.01198437f, -0.03951049f, -0.06852188f, 0.06040761f, -0.12026165f, -0.16369027f, 0.25174126f, 0.07147094f, 
    -0.14022276f, -0.19264150f, -0.06703756f, 0.15291733f, -0.18490404f, 0.07800762f, -0.08201753f, -0.01487859f, 
    0.01455327f, 0.00384564f, -0.07046118f, -0.08366264f, -0.14864285f, -0.05973081f, -0.11528742f, -0.10926502f, 
    -0.05918863f, -0.00074645f, -0.17648295f, 0.05796624f, -0.09699168f, -0.04473268f, -0.02300712f, 0.04529850f, 
    -0.14702937f, 0.03089483f, -0.10636469f, -0.09030059f, -0.14743587f, 0.09883838f, -0.08514667f, -0.00263706f, 
    -0.06324441f, -0.23561062f, -0.18538755f, 0.01640809f, -0.28574008f, 0.04737119f, -0.09337450f, 0.00802299f, 
    -0.47994229f, -0.11292867f, -0.12319079f, -0.06012512f, -0.06812997f, 0.07673021f, -0.11789864f, -0.12786913f, 
    -0.02573052f, -0.21718052f, 0.17648382f, 0.19168960f, 0.04862416f, 0.63931859f, 0.03102587f, -0.15100087f, 
    0.01810329f, 0.04476872f, -0.30847937f, 0.02227044f, -0.08155675f, 0.08921792f, 0.06808314f, 0.00227392f, 
    0.01583344f, -0.29864287f, -0.02961775f, -0.14104243f, 0.08329620f, -0.02437703f, 0.25303316f, 0.16674086f, 
    -0.08885752f, 0.05795634f, 0.27434978f, -0.33875412f, -0.16705689f, 0.46590930f, 0.00733843f, -0.19428410f, 
    0.07754667f, 0.23058701f, -0.18371192f, -0.03863605f, 0.32202086f, 0.00452859f, -0.20835125f, 0.10050231f, 
    0.03096614f, -0.26749501f, -0.07000607f, -0.01466798f, -0.10981225f, 0.11211027f, 0.14769119f, 0.31406227f, 
    -0.00999369f, -0.29467478f, -0.09031047f, -0.04489610f, 0.14588073f, 0.19771606f, 0.31039318f, 0.07606764f, 
    -0.12366144f, 0.24688472f, -0.03366149f, 0.21212992f, -0.01869708f, 0.12428537f, -0.12011011f, 0.32521355f, 
    -0.00611477f, -0.33425918f, 0.26293015f, -0.00754087f, -0.01042853f, 0.12235649f, -0.25350308f, 0.10970597f, 
    0.11478583f, 0.03146389f, -0.15399069f, 0.18652251f, -0.08267260f, -0.14809798f, -0.16764151f, -0.13126880f, 
    -0.08206550f, 0.07978531f, 0.03223675f, -0.09651698f, 0.10912982f, 0.30344680f, 0.11356153f, 0.26132697f, 
    -0.04931062f, -0.00350872f, -0.11027296f, -0.03931055f, 0.12964153f, -0.03609506f, -0.00568097f, -0.06034103f, 
    -0.07047912f, 0.05911609f, -0.16268750f, 0.12227826f, 0.27876860f, 0.15609437f, 0.12262901f, -0.07157682f, 
    -0.29516333f, 0.09373116f, -0.05085627f, 0.01038741f, -0.07709348f, -0.05593652f, 0.13185194f, -0.00457968f, 
    0.02644498f, -0.05098135f, 0.16759726f, -0.11012399f, -0.06699275f, 0.31750312f, -0.03830433f, -0.00452909f, 
    0.11842222f, -0.03650093f, -0.06447349f, 0.17679498f, -0.10667126f, 0.16585921f, -0.04686882f, 0.08850501f, 
    -0.03885249f, 0.08501662f, -0.04566294f, 0.12491646f, 0.13452464f, 0.29540905f, 0.09191703f, -0.24388979f, 
    -0.16965985f, -0.07781208f, -0.51625168f, 0.24247406f, -0.07504671f, 0.16680168f, 0.05436942f, -0.33824790f, 
    0.21107411f, 0.22269273f, -0.02815066f, -0.09373324f, 0.01802125f, 0.35278434f, -0.05146320f, 0.21886249f, 
    0.17224215f, -0.10076243f, -0.53730190f, 0.07189368f, 0.14048815f, 0.29990414f, 0.10076655f, 0.13960595f, 
    0.05136520f, 0.32427862f, -0.21504462f, -0.23474665f, -0.04911133f, -0.05595895f, -0.01028568f, 0.08864501f, 
    0.28204358f, 0.05191705f, -0.02820371f, -0.00709454f, 0.11994246f, 0.21265395f, 0.04695710f, -0.03183389f, 
    0.04890070f, 0.16942899f, -0.01579459f, 0.24645554f, 0.17447996f, 0.17826295f, 0.14603849f, -0.02548524f, 
    -0.02762979f, -0.08764415f, 0.16192868f, 0.04659718f, 0.06435121f, -0.28254107f, -0.06440347f, 0.00629043f, 
    -0.01189359f, 0.30053559f, -0.15669844f, 0.11023761f, -0.21744613f, -0.41367891f, 0.26831019f, 0.15398797f, 
    0.17122577f, 0.09470929f, 0.32498193f, -0.02669563f, 0.09676088f, -0.19404155f, 0.14636408f, 0.38792664f, 
    0.00783910f, -0.15291442f, -0.02870090f, -0.01496693f, -0.05881205f, -0.03050999f, 0.17543836f, -0.20682710f, 
    -0.26971963f, 0.20425819f, 0.05520424f, 0.05906562f, 0.06751803f, -0.21276651f, -0.00766605f, 0.22679169f, 
    0.06646641f, -0.24509268f, 0.19332537f, -0.16941845f, -0.44812751f, 0.11993402f, -0.08308794f, 0.02173493f, 
    0.29226482f, -0.00591419f, 0.17256972f, -0.02016272f, -0.19015671f, -0.17396587f, -0.10931413f, 0.11719058f, 
    -0.05341016f, -0.00706113f, 0.13017993f, 0.13158344f, -0.01805515f, -0.00462561f, -0.31173071f, -0.03678967f, 
    0.14933702f, -0.02486728f, 0.20824903f, 0.04123706f, -0.05871633f, 0.16162010f, 0.04837749f, -0.12867811f, 
    0.09669638f, -0.18591222f, -0.07244232f, 0.07121903f, -0.11126762f, -0.00843448f, -0.18216917f, -0.12503795f, 
    0.10784566f, -0.14593484f, 0.11504385f, 0.09450151f, 0.05754275f, -0.20928606f, 0.00556695f, 0.09832562f, 
    0.05021199f, 0.03362866f, 0.04888820f, 0.07922940f, -0.02439859f, -0.02629722f, -0.18314564f, -0.05786235f, 
    -0.09223477f, -0.11760794f, 0.04353295f, -0.10627426f, -0.19334681f, 0.12085491f, 0.04317309f, -0.06455077f, 
    0.02828479f, -0.01113636f, -0.04358783f, -0.09415372f, 0.01384334f, 0.09050615f, -0.06797010f, -0.02656309f, 
    -0.10123983f, 0.05296309f, 0.05596378f, 0.02697023f, 0.01267519f, -0.00441142f, -0.09785314f, 0.08893152f, 
    0.10346751f, -0.23133314f, 0.00110962f, -0.13307199f, -0.16018192f, 0.15391661f, -0.09333616f, 0.07529327f, 
    -0.20413780f, -0.15008453f, -0.10268574f, -0.22683395f, 0.02023144f, 0.02944950f, -0.03648837f, 0.02355014f, 
    0.17857435f, -0.13153329f, 0.09567264f, 0.05150569f, 0.00588753f, 0.42077380f, -0.16284949f, -0.00373076f, 
    0.06700093f, 0.08692654f, -0.27361420f, -0.11845459f, 0.10391157f, -0.28129262f, 0.03335191f, -0.12210381f, 
    -0.01409317f, 0.24457628f, -0.15309653f, 0.09447492f, -0.27019879f, 0.41638455f, -0.06393284f, -0.05304117f, 
    -0.05819438f, 0.20094539f, -0.14954206f, 0.05999083f, 0.12947968f, -0.12388466f, -0.01632405f, 0.07083025f, 
    0.10788064f, -0.06636343f, -0.18155567f, 0.34307373f, 0.37198097f, -0.16671406f, 0.06249449f, -0.00340448f, 
    -0.29035011f, -0.02577469f, 0.07081826f, 0.00660714f, -0.20210826f, -0.14800912f, 0.09302689f, 0.05507989f, 
    0.03667635f, 0.21054849f, 0.08022682f, 0.05297877f, -0.15990065f, 0.24696939f, -0.15678169f, 0.09075028f, 
    0.17225403f, 0.16980192f, 0.16412129f, -0.05843239f, 0.10261784f, 0.06559277f, -0.07105017f, 0.03378432f, 
    -0.09556086f, 0.15614685f, -0.25230530f, 0.27618799f, -0.18992954f, -0.05837107f, 0.19572365f, 0.27142772f, 
    0.02609203f, 0.44441250f, 0.03972665f, -0.00083940f, 0.00915402f, -0.23637581f, 0.09953292f, 0.30679053f, 
    0.04281871f, -0.03252165f, 0.06709592f, 0.16623515f, -0.05676971f, -0.08759025f, -0.04398780f, -0.03681174f, 
    -0.25112581f, 0.06799430f, 0.17900610f, 0.06477690f, -0.02772438f, -0.03614169f, 0.05906269f, 0.13236935f, 
    0.03490504f, 0.22362855f, 0.18190402f, 0.02600412f, 0.18232253f, 0.09390333f, -0.23934965f, -0.04116748f, 
    -0.04160529f, -0.16102481f, 0.11239503f, 0.00373607f, 0.13029365f, 0.14351426f, -0.05959322f, 0.23501067f, 
    0.02488302f, -0.22740167f, -0.12595057f, 0.25311497f, 0.21192975f, 0.13680494f, -0.13093641f, 0.19081388f, 
    -0.02641287f, 0.19446136f, -0.17580862f, -0.14069332f, 0.07719088f, -0.04685171f, 0.06966825f, -0.21306412f, 
    -0.01526887f, -0.03209084f, -0.10135259f, 0.14782283f, -0.06181459f, 0.01387022f, -0.14143537f, -0.02415018f, 
    -0.19399151f, -0.06753189f, 0.06030920f, -0.17779206f, -0.04335894f, 0.09716602f, 0.07227359f, 0.03654381f, 
    -0.05510096f, 0.18100180f, -0.15988885f, -0.12380969f, -0.08832850f, -0.18513560f, -0.00942181f, -0.04281478f, 
    0.12912314f, -0.25965279f, 0.14945704f, -0.27275255f, -0.02071697f, 0.03756975f, 0.11194881f, -0.17140178f, 
    -0.11909340f, -0.09445923f, -0.11372772f, -0.13472666f, -0.13753952f, -0.07059266f, -0.09393241f, -0.00606070f, 
    -0.13239196f, 0.04455522f, 0.12517516f, -0.12176562f, 0.08576571f, -0.03520564f, -0.09744377f, 0.29393774f, 
    0.04497154f, 0.00659297f, -0.15770046f, -0.09990567f, -0.14568974f, -0.10463841f, -0.06132931f, -0.04549078f, 
    -0.15215394f, 0.16050899f, -0.09027830f, 0.09305482f, 0.09354261f, -0.12063646f, -0.01550043f, -0.03788513f, 
    -0.19063771f, 0.18932018f, 0.47078443f, 0.13510825f, 0.07163522f, -0.51578468f, 0.10620090f, -0.06700376f, 
    0.18025874f, 0.17362404f, 0.63216019f, -0.08507653f, 0.10428939f, 0.23232383f, 0.11175837f, -0.05576346f, 
    -0.16262963f, -0.10491876f, 0.20895934f, 0.08612050f, 0.29987648f, -0.13616185f, -0.07699288f, -0.11672152f, 
    0.06468739f, 0.04571815f, 0.14826086f, -0.13007168f, -0.00723415f, 0.12825085f, -0.10642657f, 0.03098271f, 
    0.03133008f, -0.38178805f, 0.06143264f, 0.02776491f, 0.09766789f, 0.13290584f, -0.13417691f, -0.04517077f, 
    0.32293198f, 0.00718241f, 0.03719815f, 0.05073411f, 0.03017553f, -0.11107546f, -0.00595275f, 0.20015070f, 
    -0.06446375f, 0.13474937f, 0.02846928f, 0.01484741f, 0.11909100f, 0.37688929f, -0.03091592f, 0.14622092f, 
    -0.05796040f, 0.00088439f, -0.02057881f, 0.03364726f, -0.05703465f, 0.09016788f, 0.07047783f, 0.02343473f, 
    -0.13035908f, -0.13453275f, -0.03500642f, -0.10525211f, 0.05455973f, -0.03494208f, -0.07742212f, 0.03143199f, 
    0.01110684f, 0.09727027f, -0.03712280f, -0.12065262f, -0.04337953f, 0.01511499f, -0.10053976f, 0.10803743f, 
    -0.12220849f, 0.07457304f, -0.02648052f, -0.00866142f, -0.11950080f, -0.11359601f, 0.00269961f, 0.02987250f, 
    -0.11963111f, -0.08926853f, -0.02424218f, 0.06912684f, -0.12373239f, -0.10568416f, 0.02575101f, -0.12462149f, 
    -0.01951776f, -0.06286804f, -0.16432363f, -0.11261893f, -0.09373680f, -0.07091177f, -0.15149830f, 0.08769016f, 
    0.09728085f, -0.18454915f, 0.07686606f, -0.02666979f, 0.07918461f, -0.12917389f, -0.08500451f, 0.07724659f, 
    -0.07935612f, -0.04931220f, -0.08278827f, -0.05196034f, 0.00157107f, -0.01342896f, -0.04710336f, -0.08767103f, 
    0.03316003f, 0.06489650f, -0.05368533f, -0.06101782f, 0.00012535f, -0.01995540f, 0.09176809f, -0.07192332f, 
    -0.24802642f, -0.04250753f, -0.04284487f, 0.31623688f, -0.28425884f, -0.65637338f, 0.19771945f, 0.07181828f, 
    0.28483137f, 0.28557140f, 0.55216837f, -0.18937625f, -0.10371974f, 0.07757589f, 0.20032944f, 0.27049461f, 
    -0.20568670f, -0.24115853f, 0.12974456f, 0.16385807f, 0.14229323f, 0.24312906f, 0.05197730f, 0.02655214f, 
    -0.14241333f, 0.18049696f, 0.21857753f, -0.21059784f, 0.07923523f, -0.08152624f, 0.13157688f, 0.07960345f, 
    -0.09441776f, 0.15206467f, -0.03867601f, 0.02888469f, -0.44503346f, -0.02018953f, -0.17602603f, 0.07401682f, 
    0.21961610f, 0.13554582f, 0.17204402f, 0.02601802f, -0.03710567f, -0.14991133f, 0.06931210f, 0.25552258f, 
    -0.01465433f, 0.04254135f, -0.00515829f, 0.17144690f, 0.12511694f, 0.21121028f, -0.46555367f, 0.04672900f, 
    0.09296718f, -0.03833050f, 0.05005908f, 0.08321202f, 0.00051393f, 0.22414006f, -0.07762974f, 0.02564777f, 
    -0.15470552f, 0.34722415f, -0.20723078f, 0.09990935f, 0.18935867f, -0.01997013f, 0.27919075f, 0.21256845f, 
    0.02637230f, -0.30150086f, -0.42548472f, -0.01824376f, -0.00345922f, 0.23786002f, -0.03397658f, 0.24592072f, 
    -0.05558979f, -0.11562502f, 0.07934438f, 0.09770533f, 0.21611850f, -0.33309203f, 0.17304887f, -0.02846563f, 
    -0.13584600f, -0.03592410f, 0.04786117f, 0.02935375f, -0.19322808f, -0.00104515f, 0.07112332f, 0.09922654f, 
    -0.10603767f, 0.09218597f, 0.22138897f, -0.17174278f, -0.05324649f, -0.05317428f, -0.05294828f, 0.06436622f, 
    -0.00959016f, -0.13085198f, -0.03358265f, -0.06496623f, -0.07639240f, 0.09266523f, 0.11979067f, 0.06425099f, 
    0.02285249f, -0.20112312f, -0.32250795f, -0.05906180f, 0.11354000f, -0.38635716f, 0.04580055f, 0.07120411f, 
    -0.10959123f, 0.17829521f, 0.04048126f, 0.10801839f, -0.04715662f, 0.08304546f, -0.10533684f, -0.00899681f, 
    -0.32960528f, 0.30273944f, 0.02655043f, 0.22713920f, 0.08625821f, -0.06367312f, -0.00947879f, 0.07813024f, 
    -0.11134657f, 0.06771333f, 0.47537374f, -0.06245432f, -0.04496748f, 0.13323472f, -0.09061127f, -0.13430008f, 
    -0.00215468f, 0.07738960f, 0.22412629f, -0.01823149f, 0.03677103f, -0.16975866f, -0.15080227f, -0.04705373f, 
    0.07111166f, -0.14344428f, -0.03731071f, -0.10966548f, 0.18405479f, -0.11859614f, 0.08829254f, 0.25521255f, 
    -0.04757572f, -0.12770806f, 0.10255726f, -0.22755449f, 0.18786865f, -0.03797404f, 0.07243343f, -0.11307086f, 
    0.21230850f, -0.14279091f, 0.15282883f, 0.05088654f, 0.13897346f, 0.03813234f, -0.03091861f, 0.19553123f, 
    -0.08334725f, 0.02392328f, -0.26783183f, -0.17337188f, -0.02092176f, 0.12794444f, -0.13627660f, 0.04557610f, 
    -0.04323708f, 0.09091322f, 0.11100087f, 0.03839916f, -0.10161874f, 0.07568225f, -0.06105831f, -0.27316201f, 
    0.03482777f, 0.30574906f, -0.51333833f, 0.15625030f, -0.28783849f, -0.20378262f, 0.13576822f, 0.15652280f, 
    0.10948625f, 0.25340405f, -0.14222559f, -0.04862366f, -0.05616460f, -0.15852056f, 0.16592038f, 0.34392047f, 
    -0.19394785f, -0.19240761f, 0.14965412f, 0.09624969f, -0.08593114f, 0.12939993f, 0.01230081f, 0.16567808f, 
    -0.26914966f, 0.25910819f, -0.03051106f, 0.13313824f, -0.07962440f, 0.02032545f, 0.02900254f, 0.14748718f, 
    -0.00326579f, 0.32245910f, 0.26719165f, -0.02055335f, -0.21170457f, 0.04463624f, -0.33441871f, 0.00273353f, 
    -0.17953849f, -0.08979798f, 0.09353681f, -0.10006641f, 0.10385317f, 0.06377646f, -0.06575194f, 0.13350829f, 
    0.09049286f, -0.01746133f, -0.16975048f, 0.14152512f, 0.03357575f, -0.33165926f, -0.14137976f, 0.07364935f, 
    0.20925742f, -0.01643322f, 0.15242320f, -0.15390870f, 0.10769352f, 0.27139363f, -0.11103263f, -0.29781923f, 
    0.13703924f, -0.02412840f, 0.07622473f, -0.29091355f, -0.21939641f, -0.06572254f, 0.03531115f, 0.22861141f, 
    0.29678729f, 0.19972794f, 0.45001793f, 0.07306802f, 0.02013399f, -0.13448292f, -0.08634038f, 0.15080921f, 
    -0.24791174f, 0.19747621f, 0.12105026f, -0.22384921f, 0.18186475f, 0.13203596f, -0.03423648f, -0.08355620f, 
    -0.20297521f, -0.07856084f, 0.37069595f, 0.16031399f, 0.02867181f, -0.18297330f, 0.12046307f, -0.16429193f, 
    -0.12614954f, -0.37098399f, 0.23385474f, -0.08191060f, -0.28572232f, 0.19961567f, -0.23444167f, 0.12268250f, 
    -0.16836628f, -0.03815169f, 0.13373695f, 0.04331961f, 0.12673682f, 0.05210977f, -0.30962828f, 0.14456561f, 
    -0.07518066f, 0.11254572f, -0.11970460f, -0.16048677f, -0.04959980f, 0.10181642f, -0.12693499f, 0.09664702f, 
    0.13242140f, -0.01258138f, 0.13621940f, -0.03660602f, -0.13791108f, 0.24264151f, 0.12908843f, -0.24718645f, 
    0.43227634f, 0.20051722f, -0.33682105f, -0.30035302f, -0.01648247f, 0.13222142f, 0.13010180f, 0.15057071f, 
    0.09005193f, -0.04701155f, -0.08088516f, -0.01277737f, 0.11560790f, -0.30561399f, 0.22471516f, 0.08100957f, 
    -0.13162124f, 0.01788384f, 0.15889968f, -0.10354226f, 0.02024662f, 0.19292824f, 0.11324897f, -0.11825221f, 
    -0.18760921f, 0.10195223f, -0.23744230f, 0.26037911f, 0.00596367f, -0.17025931f, -0.03200865f, -0.16701709f, 
    0.05949840f, -0.21909849f, 0.24232325f, -0.02258687f, -0.07059810f, 0.12355046f, -0.12877508f, 0.06568766f, 
    -0.33104467f, -0.09512283f, 0.08637225f, -0.02065759f, 0.02159951f, 0.14276069f, -0.20046043f, 0.06532486f, 
    0.09748136f, 0.01185126f, -0.16742401f, -0.01703401f, 0.17703050f, -0.39160791f, 0.28664970f, 0.14122257f, 
    0.18324868f, 0.08264516f, 0.20777281f, -0.19429608f, -0.04410776f, 0.33859339f, -0.09435709f, -0.27406889f, 
    0.09114946f, -0.15496060f, -0.24305543f, 0.12747397f, 0.01700364f, -0.08149397f, -0.03267978f, -0.18416148f, 
    -0.14400950f, -0.05551595f, -0.10855456f, -0.31266367f, 0.01713793f, 0.32676446f, -0.25667313f, -0.10119968f, 
    -0.06809276f, -0.13682678f, 0.01468259f, -0.20575002f, 0.02145578f, 0.03038275f, 0.33045363f, -0.25841066f, 
    0.05743029f, -0.21337850f, -0.14786644f, -0.13024904f, -0.08693328f, -0.00883082f, 0.07961360f, 0.04450240f, 
    -0.09925622f, -0.03372854f, 0.04956830f, 0.10881991f, 0.09204677f, -0.16095683f, 0.06823274f, -0.00100477f, 
    0.06354547f, 0.09316427f, -0.10348800f, -0.09863199f, -0.05375845f, -0.23912576f, -0.18103628f, -0.01310772f, 
    -0.04413332f, -0.22741587f, 0.09453289f, -0.14698061f, -0.02824777f, -0.24897601f, -0.17948738f, -0.25349441f, 
    -0.38474956f, 0.02695181f, -0.04912435f, 0.16504769f, -0.01262556f, -0.07259777f, 0.06653979f, -0.24760826f, 
    0.09389094f, 0.12070854f, 0.06215395f, 0.03966350f, 0.11298108f, -0.06747267f, 0.08745468f, 0.12997071f, 
    0.17458354f, 0.06410833f, -0.03954004f, -0.14736432f, 0.09430742f, -0.41191342f, 0.33066007f, 0.00293309f, 
    -0.19883385f, 0.09281237f, -0.23587491f, 0.13451566f, -0.15119632f, 0.13998662f, -0.01586253f, -0.39368489f, 
    -0.07555076f, -0.05127180f, 0.23993506f, 0.00418598f, -0.15032309f, -0.26829454f, -0.11838965f, 0.03049588f, 
    0.05546972f, -0.37649882f, -0.00524312f, -0.05698030f, 0.10685462f, -0.40844038f, -0.19780906f, -0.02105275f, 
    -0.01859075f, -0.00536901f, 0.18499264f, -0.08341917f, -0.26053625f, -0.18001767f, -0.06098859f, 0.30323684f, 
    -0.03909146f, 0.14887641f, -0.26003039f, 0.15949596f, -0.14230810f, 0.11371763f, 0.35686284f, 0.18031201f, 
    -0.05572935f, 0.16585493f, 0.30012679f, -0.36453313f, -0.07137106f, 0.00355601f, 0.02326165f, -0.09445083f, 
    0.13585484f, 0.04291180f, -0.13811767f, -0.10492552f, 0.17342530f, 0.13101654f, 0.05955930f, 0.02104306f, 
    -0.08435124f, 0.01638157f, -0.17573985f, 0.13247699f, 0.03140096f, -0.07217709f, 0.16075133f, 0.04041928f, 
    0.08272754f, 0.08294816f, -0.09850501f, -0.04985369f, 0.18426168f, -0.17784162f, 0.15896516f, 0.13396500f, 
    -0.35278878f, -0.26083338f, 0.04108359f, -0.07660697f, 0.09138025f, 0.20636423f, -0.09815375f, -0.18034826f, 
    0.08198238f, 0.06038346f, 0.26615098f, -0.18480396f, -0.29387534f, 0.06663711f, -0.24728309f, -0.00424244f, 
    0.04417708f, -0.08191752f, 0.01760875f, -0.07857445f, 0.19249417f, 0.16917059f, -0.07922069f, 0.19730291f, 
    0.08873858f, -0.12106720f, -0.31471682f, -0.09094969f, 0.23538470f, 0.17376047f, 0.19338351f, 0.05550852f, 
    -0.14600618f, -0.02168603f, -0.10276183f, 0.05311907f, 0.10811967f, -0.11449835f, 0.09145281f, 0.02818366f, 
    0.08539836f, -0.18360727f, -0.05109514f, -0.12559918f, -0.30506536f, 0.22423962f, 0.07843519f, -0.07571258f, 
    0.29465365f, 0.07952940f, 0.39604276f, 0.03112421f, -0.02349053f, 0.02826963f, 0.03325486f, 0.20901555f, 
    -0.22084881f, 0.01047428f, 0.05822996f, -0.38435492f, 0.01697579f, -0.07323978f, 0.08681359f, 0.05625260f, 
    -0.15566362f, 0.02957014f, 0.20467849f, 0.03371465f, 0.19213790f, 0.13736647f, -0.01752874f, -0.04411167f, 
    0.07576397f, -0.06173845f, 0.14764434f, 0.06968506f, -0.36172119f, -0.02858209f, -0.02854658f, 0.03145471f, 
    0.00815738f, 0.11353640f, 0.34769133f, -0.10060687f, 0.20074382f, -0.01633632f, -0.31217140f, 0.33903369f, 
    -0.11833061f, -0.12300920f, -0.35523987f, -0.17440672f, -0.04446974f, 0.29508117f, -0.10092822f, -0.17026249f, 
    -0.01465615f, -0.11854468f, 0.00512439f, 0.02123657f, 0.04234074f, 0.05664345f, -0.01762588f, -0.17006309f, 
    0.31581211f, 0.08994097f, -0.04324020f, 0.12416242f, 0.25552085f, -0.19808638f, 0.18524933f, 0.19296534f, 
    -0.10703047f, -0.11665737f, -0.01332555f, 0.00728384f, 0.08295188f, 0.19246946f, 0.17184027f, 0.14939913f, 
    0.16914092f, -0.20340723f, -0.20009311f, 0.21284798f, 0.06034432f, -0.28282088f, 0.18104686f, -0.04714677f, 
    0.19684608f, 0.12367654f, 0.26640961f, 0.08017927f, -0.22216891f, 0.09670604f, 0.05071822f, 0.01683297f, 
    0.05687642f, 0.12836407f, -0.17785093f, -0.18566357f, 0.19043307f, 0.03266739f, -0.03900499f, -0.07496170f, 
    -0.00708111f, -0.28496623f, -0.27713087f, 0.08357151f, -0.09299952f, -0.10735790f, 0.36648843f, -0.22306798f, 
    0.06042250f, -0.17227682f, 0.28662348f, 0.11843945f, 0.17926188f, -0.19844574f, 0.14372702f, 0.01164550f, 
    0.10406828f, 0.24869569f, 0.09467965f, -0.07478101f, -0.03731875f, -0.00603436f, 0.10334286f, 0.23497610f, 
    0.17639750f, 0.24700952f, 0.12720659f, -0.05175721f, 0.19836150f, -0.42108807f, -0.09052153f, 0.23797162f, 
    0.21603166f, 0.17469114f, -0.09477148f, 0.04897176f, 0.08868137f, -0.22110753f, -0.12864698f, -0.16487733f, 
    -0.08348761f, 0.05099290f, -0.00077044f, 0.17664550f, -0.01911592f, 0.29725343f, -0.18214072f, 0.03404745f, 
    0.01230168f, 0.15619993f, -0.07362760f, 0.21166730f, 0.13527530f, -0.16017537f, -0.07742307f, 0.17478473f, 
    0.06103420f, -0.16225865f, 0.03005128f, 0.00168440f, 0.21979393f, 0.19450612f, -0.00997120f, 0.05097704f, 
    -0.00652369f, -0.14437662f, -0.13560554f, 0.06419387f, -0.04424643f, -0.05144154f, 0.04912185f, -0.16377552f, 
    0.01095445f, 0.27689999f, 0.21331415f, -0.03125286f, 0.02066625f, -0.18527000f, -0.15828541f, 0.07462201f, 
    0.22743289f, -0.15542457f, 0.22001632f, -0.08996244f, -0.04267096f, 0.24172087f, 0.09378410f, -0.05512309f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00280721f, -0.01044040f, -0.14378367f, 0.02737887f, -0.00070071f, 0.09965622f, -0.15496685f, -0.12356861f, 
    0.01815158f, -0.26508832f, -0.11111120f, 0.05705611f, -0.14125778f, 0.18723294f, -0.11448783f, 0.15052333f, 
    -0.17691842f, -0.19101442f, 0.15112601f, -0.04247219f, 0.00504184f, 0.05045035f, -0.06219493f, 0.11357878f, 
    -0.08501394f, 0.13011752f, -0.09479221f, -0.14365473f, 0.16476099f, 0.13786232f, -0.16349700f, 0.05101768f, 
    -0.02454298f, 0.03567033f, 0.07634880f, 0.00285733f, -0.02925639f, 0.25033861f, 0.12678322f, 0.15328108f, 
    -0.04690363f, -0.14910398f, 0.05860758f, -0.03273595f, 0.01263417f, 0.15399244f, -0.00155900f, -0.18607692f, 
    0.16617034f, 0.17419986f, 0.09124546f, -0.03301870f, 0.20002434f, 0.09570509f, 0.11895049f, -0.06568631f, 
    0.11883305f, 0.11060447f, -0.12670229f, 0.13637546f, 0.06383026f, 0.03316804f, 0.17380846f, 0.10447865f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.42839476f, -0.06126442f, 0.06090071f, 0.16622847f, -0.19917159f, -0.17507663f, 0.22274315f, -0.03347317f, 
    -0.57158035f, 0.11050610f, 0.04431026f, -0.06413031f, -0.05838252f, -0.42134565f, -0.12276707f, -0.00493432f, 
    0.21167707f, -0.02345322f, -0.42466149f, -0.12287318f, 0.10515887f, -0.03381539f, -0.19722056f, 0.02830684f, 
    -0.11149208f, -0.60165548f, -0.20497882f, 0.08697441f, 0.28473103f, -0.19029227f, -0.10571554f, -0.02110762f, 
    -0.54288459f, -0.10361601f, 0.06460943f, 0.16208065f, 0.22018032f, -0.18955496f, 0.01615098f, 0.19892718f, 
    0.01456957f, -0.12216485f, 0.16651370f, 0.24909994f, 0.10829722f, -0.21969171f, -0.06960402f, -0.20787245f, 
    -0.48872638f, -0.46955088f, -0.20315588f, 0.05618133f, -0.34199300f, -0.06878138f, 0.04844172f, -0.47497708f, 
    0.01029351f, -0.12364624f, 0.17165603f, -0.21324919f, 0.09737955f, 0.26658770f, -0.39690274f, -0.20161055f, 
    -0.07749408f, -0.69623244f, -0.10365456f, 0.13110794f, -0.12743163f, 0.19674349f, 0.27511650f, 0.10294406f, 
    -0.21687457f, -0.07895094f, 0.00047118f, -0.00754478f, 0.06060471f, -0.04174038f, -0.04831949f, 0.14712749f, 
    -0.31904238f, -0.27391681f, 0.05441014f, 0.06120165f, -0.12212071f, -0.25905600f, 0.05060982f, -0.03272081f, 
    -0.07912216f, -0.44107407f, -0.19570068f, 0.08162389f, -0.36890617f, -0.32512137f, -0.09765783f, 0.20815930f, 
    0.18111284f, 0.36291641f, 0.00394580f, 0.18247813f, -0.60418022f, 0.04376737f, -0.07860188f, -0.04790579f, 
    -0.02679215f, -0.01989026f, -0.44006109f, -0.10007148f, -0.17716452f, 0.15401310f, -0.03515534f, -0.00142073f, 
    0.19895300f, 0.07221259f, 0.14244649f, 0.03404769f, 0.08143001f, -0.08337759f, 0.25019774f, 0.03066744f, 
    0.18302672f, -0.07689592f, 0.10873353f, 0.44641078f, -0.09782525f, 0.18427698f, -0.19970211f, 0.04016034f, 
    0.12179542f, 0.26019993f, 0.05084335f, -0.14815119f, 0.06547392f, -0.46527198f, -0.49313533f, -0.55064011f, 
    0.19847909f, 0.01648670f, -0.07011911f, 0.25627524f, -0.22050989f, 0.03435846f, -0.07918771f, -0.08203909f, 
    -0.39575663f, 0.32239729f, 0.08263157f, -0.13921514f, 0.00447712f, 0.15529020f, 0.08618229f, 0.25434718f, 
    -0.06893665f, 0.05366976f, 0.04768495f, -0.05067775f, -0.35665467f, -0.05438418f, -0.02317473f, 0.11427318f, 
    0.05595331f, -0.32378086f, -0.00102933f, -0.52119017f, -0.01986508f, 0.07993282f, 0.02193817f, -0.22544473f, 
    -0.01631992f, -0.23148085f, 0.03533468f, -0.12689826f, 0.20544134f, 0.09516978f, 0.05230287f, -0.43656096f, 
    0.12875554f, 0.13490656f, 0.16034532f, 0.04942606f, 0.20828839f, 0.13698791f, 0.18025656f, 0.14091253f, 
    -0.12836125f, -0.43198475f, 0.14112815f, -0.68728536f, 0.20629680f, 0.17796157f, -0.11538396f, -0.19409208f, 
    0.13613640f, 0.13971102f, -0.05099009f, 0.10417753f, -0.10299692f, -0.50985706f, -0.10698359f, -0.37208766f, 
    -0.07735801f, -0.51520598f, 0.18247230f, -0.06914501f, 0.37761793f, -0.10130103f, -0.04181861f, -0.05457231f, 
    0.19026092f, 0.14056447f, -0.05044242f, -0.23628227f, -0.04666826f, 0.25355732f, -0.29352474f, 0.12599105f, 
    0.03161962f, 0.27352533f, -0.32127911f, 0.19940168f, -0.30018374f, -0.45791200f, 0.10464028f, -0.08370648f, 
    0.19810234f, -0.09214803f, 0.04855998f, -0.07829130f, 0.04430946f, -0.40882418f, 0.01349865f, -0.13727124f, 
    -0.03608441f, -0.11793339f, 0.05040388f, -0.07088047f, 0.12005618f, -0.07566103f, -0.14699931f, 0.04380908f, 
    0.12737897f, -0.31059012f, -0.46863663f, -0.12001538f, -0.24105936f, -0.05753275f, -0.20053016f, 0.15852876f, 
    -0.00485457f, 0.27646846f, -0.75987333f, -0.46108419f, 0.13124953f, 0.08126921f, -0.04351249f, -0.09243825f, 
    -0.27256703f, 0.10471768f, 0.02507470f, 0.11425918f, -0.62950408f, 0.01437128f, 0.08325199f, 0.07389112f, 
    0.01467030f, 0.03053337f, -0.17905402f, -0.13880156f, -0.05012221f, 0.15628518f, 0.08948930f, -0.15537293f, 
    -0.02535348f, -0.33140874f, -0.09040634f, 0.26849452f, 0.08509659f, 0.14444636f, -0.19950774f, -0.01185335f, 
    -0.11960311f, -0.24891160f, -0.41938722f, -0.22676162f, -0.46703827f, -0.27749330f, -0.17753237f, -0.23374191f, 
    0.03510968f, -0.21878637f, 0.05113729f, 0.09259117f, 0.18066792f, -0.07010781f, 0.13850778f, 0.07754916f, 
    -0.00506634f, -0.07873169f, 0.05308445f, -0.02945358f, 0.20122087f, -0.33950073f, -0.26395744f, 0.21024716f, 
    -0.11742349f, 0.13121110f, -0.18632637f, 0.04157383f, -0.41975102f, 0.24035345f, 0.13602047f, -0.17571774f, 
    -0.37996513f, -0.21476710f, -0.34656656f, -0.38482565f, -0.06306595f, -0.38365069f, 0.16561718f, 0.01518256f, 
    -0.09993055f, -0.16900574f, -0.42351928f, 0.11085009f, 0.12016522f, 0.00297823f, 0.00290137f, 0.00616453f, 
    -0.08955396f, -0.10788186f, -0.14172299f, 0.25086871f, -0.20442256f, -0.09902889f, -0.09331542f, -0.05741919f, 
    -0.06329264f, -0.07121287f, 0.21384089f, 0.15417805f, -0.05932939f, -0.16323829f, -0.44622836f, 0.22375904f, 
    0.02125617f, -0.02673119f, 0.42989403f, -0.27227312f, -0.09046435f, 0.24593680f, -0.02216406f, 0.03170756f, 
    -0.10763182f, -0.20602469f, -0.14430697f, 0.19568135f, -0.07560225f, 0.16414502f, 0.21029694f, 0.13219778f, 
    -0.10577478f, 0.03199119f, -0.38587734f, 0.09170282f, 0.12907234f, -0.02094851f, 0.02909463f, 0.13041919f, 
    -0.03638549f, -0.58920956f, -0.09604704f, 0.04652928f, -0.07569551f, -0.21739522f, -0.02816450f, -0.12294146f, 
    -0.14109860f, -0.44493902f, -0.01871243f, -0.03348424f, -0.08288623f, -0.36873901f, 0.08847053f, 0.22686866f, 
    -0.08823593f, 0.16436215f, -0.02654142f, -0.68834180f, 0.09746289f, 0.00932017f, -0.25240740f, 0.32070220f, 
    0.19837372f, -0.02524078f, -0.23287189f, -0.04632811f, -0.33097744f, 0.22203189f, -0.08694001f, 0.06962913f, 
    -0.49763516f, -0.21464971f, 0.06302159f, -0.15894100f, -0.05565019f, -0.02463922f, -0.27151087f, -0.51254880f, 
    -0.09275229f, 0.26684928f, -0.03091206f, -0.44068974f, 0.14295949f, 0.31632152f, -0.05874829f, -0.20781150f, 
    -0.11784820f, -0.28227541f, 0.12019707f, -0.72120726f, -0.06511015f, 0.12493987f, -0.02901731f, -0.60993826f, 
    -0.03889936f, 0.07476377f, 0.13505597f, -0.02934083f, -0.36775565f, 0.21512459f, -0.13361590f, -0.12397491f, 
    0.17240889f, -0.03753570f, -0.10393267f, 0.10192391f, 0.20481892f, 0.01316058f, -0.21129861f, 0.10294547f, 
    -0.23017603f, -0.23556663f, 0.10355456f, -0.16441052f, -0.16065058f, -0.17652740f, 0.18091096f, -0.42278931f, 
    0.10742228f, 0.05197358f, -0.06741118f, -0.19537404f, 0.20972385f, -0.07914266f, -0.21406640f, 0.17969307f, 
    0.04697600f, -0.04241514f, 0.24961568f, -0.04764252f, -0.19852255f, -0.05291262f, 0.10052914f, -0.32505363f, 
    0.18213835f, 0.13317180f, -0.32635462f, -0.02087213f, 0.13333549f, -0.51983261f, 0.29380020f, -0.33802009f, 
    -0.07986022f, 0.01409799f, -0.10347116f, 0.02847148f, 0.28418943f, -0.24700792f, -0.18466854f, 0.12618595f, 
    0.26618209f, 0.05212000f, -0.52473551f, -0.33230573f, 0.20708257f, -0.04700691f, -0.36444640f, -0.51326054f, 
    0.03913022f, -0.31392249f, 0.20291054f, 0.15529810f, -0.13535050f, -0.36197111f, -0.07842006f, 0.22375348f, 
    -0.01847605f, -0.22626631f, 0.10624617f, 0.04705834f, -0.08579492f, -0.53289717f, -0.01233964f, -0.22113390f, 
    -0.24951334f, -0.15179825f, -0.25367767f, -0.13703167f, -0.53737515f, -0.39911479f, 0.12141500f, 0.06233110f, 
    -0.27877104f, -0.29111657f, -0.07572229f, -0.73856467f, -0.12960324f, -0.15824096f, -0.34779143f, -0.22418304f, 
    0.12368897f, -0.00448541f, -0.02473238f, 0.14455675f, -0.32221100f, -0.24800472f, 0.05254145f, 0.25550592f, 
    0.19170433f, 0.29352385f, -0.15599017f, -0.27885041f, 0.09328871f, -0.52986890f, 0.19565640f, 0.03907054f, 
    -0.02110581f, 0.33302572f, -0.32860410f, 0.09356000f, -0.01626276f, 0.14250132f, -0.08475009f, -0.02758661f, 
    -0.04919960f, -0.08090211f, 0.05011056f, -0.21239981f, -0.48127577f, 0.00376582f, -0.49166921f, 0.05808973f, 
    0.09331479f, -0.18331122f, -0.23549877f, 0.04749680f, -0.50734776f, 0.06350859f, -0.21102534f, 0.12370093f, 
    -0.12767678f, -0.08846086f, 0.05885710f, -0.04036721f, 0.19608988f, -0.10060407f, -0.03164941f, 0.04624376f, 
    0.19125094f, 0.17587106f, -0.52444065f, -0.13525653f, -0.45407835f, 0.18721592f, -0.32100281f, 0.10234638f, 
    0.14551038f, -0.25062972f, -0.51582193f, 0.09137673f, 0.11898080f, -0.05023033f, -0.41039392f, -0.11030776f, 
    0.02788087f, 0.00021334f, -0.48425695f, -0.34023768f, -0.29124421f, 0.26375765f, 0.01678241f, -0.24311233f, 
    -0.07839108f, -0.34801409f, -0.00685916f, 0.05802700f, 0.02737114f, -0.09067564f, -0.14532268f, -0.21335725f, 
    -0.01271321f, -0.29753956f, -0.47597566f, -0.57268476f, 0.24782272f, -0.09421835f, 0.03645872f, 0.07395182f, 
    0.09653313f, -0.12446360f, -0.08905764f, 0.20413052f, 0.21920706f, 0.14591326f, -0.05737519f, 0.05644904f, 
    -0.11047983f, -0.05554267f, 0.22201820f, -0.12933432f, -0.21015126f, -0.13452782f, 0.04849587f, -0.35858148f, 
    0.02119228f, -0.02445449f, 0.14896338f, 0.00802176f, -0.06556349f, 0.11830918f, -0.13245688f, -0.34683073f, 
    -0.01169522f, -0.10861015f, -0.03497805f, -0.04834032f, 0.17567690f, -0.13619378f, 0.24878135f, -0.34871244f, 
    0.11988003f, -0.35681257f, -0.15304923f, 0.14327699f, -0.25657982f, -0.18158486f, -0.03532873f, -0.16591015f, 
    -0.16945893f, -0.14052537f, 0.33086160f, -0.00199244f, -0.16506991f, 0.13317417f, -0.10871171f, -0.26730907f, 
    0.14634694f, -0.26645118f, 0.13932730f, -0.58992207f, -0.03290350f, 0.12259625f, -0.45771754f, -0.15254499f, 
    -0.11704907f, 0.31486845f, -0.33420867f, -0.18529460f, -0.15970887f, 0.36011112f, 0.06008944f, 0.13089606f, 
    -0.34203970f, 0.17465180f, 0.18853866f, -0.26334208f, -0.11516888f, -0.19556588f, 0.22124594f, 0.05526426f, 
    0.01467235f, -0.20695636f, -0.39501289f, -0.11346433f, -0.36978301f, 0.20506303f, 0.03733058f, -0.27706000f, 
    -0.01220807f, 0.11329453f, -0.13159759f, -0.08404675f, -0.12806199f, 0.37294620f, 0.06873503f, 0.15796922f, 
    0.19456701f, 0.47011527f, -0.47500458f, -0.45907301f, -0.00797703f, -0.18898664f, 0.21069321f, 0.22273214f, 
    -0.00627692f, 0.13861272f, -0.23933522f, -0.19790559f, 0.06052183f, -0.20807731f, -0.44063827f, 0.25486803f, 
    0.06841419f, -0.32988235f, -0.47362617f, -0.28500929f, 0.47669882f, 0.11902656f, 0.04924674f, 0.23386061f, 
    -0.21609421f, 0.23695694f, 0.24172449f, -0.26796851f, 0.00646103f, 0.26168427f, 0.03875435f, -0.01037980f, 
    -0.00398092f, -0.26750296f, 0.00877783f, -0.15236305f, -0.44591489f, 0.18440725f, -0.10003671f, -0.58080721f, 
    0.04327260f, -0.04399602f, 0.05843030f, 0.18492299f, -0.28221938f, -0.10359553f, -0.26144320f, -0.07549046f, 
    0.06452300f, 0.08620319f, -0.27078468f, -0.57407451f, 0.07023648f, 0.20604444f, -0.09716863f, -0.06804223f, 
    -0.26850715f, -0.27386597f, -0.01171988f, -0.07800119f, -0.04626084f, -0.09041709f, -0.17979467f, -0.11133783f, 
    -0.07473750f, 0.21707654f, -0.30978441f, 0.05971944f, -0.24321717f, 0.05543030f, 0.09378475f, -0.05787266f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.14305258f, 0.10538187f, 0.09681147f, -0.07589429f, -0.05726872f, 0.07270495f, -0.04064283f, 0.03282861f, 
    -0.10486271f, 0.08381724f, -0.00607522f, -0.05945396f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
