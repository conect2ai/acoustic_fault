#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.16231588f, 0.57948661f, 0.23192526f, 0.96317518f, -0.52222121f, -0.63093805f, 0.43104136f, 0.74107516f, 
    0.45325130f, -1.02827370f, -0.17575236f, 0.68650645f, -1.20100105f, -0.40594783f, -0.19859746f, 0.60383153f, 
    0.51723498f, -0.05903237f, 0.73418117f, 0.89294398f, 0.91734314f, 0.06116575f, -0.04160164f, 0.43071505f, 
    0.59715575f, 0.03369374f, -0.46620658f, -0.89663982f, -1.39397740f, -0.06981480f, 0.90377975f, 0.55692863f, 
    0.08022669f, -0.10597169f, -0.37608573f, 0.41519195f, 0.63954943f, 0.57858348f, -0.55406034f, 1.23497736f, 
    -0.07581410f, -0.00944560f, -0.35268736f, -0.21287294f, -0.20766118f, -0.50550413f, -1.07754540f, -0.61599535f, 
    -0.30431044f, -0.52052212f, -0.60021532f, 0.68549609f, 0.54814547f, -0.53572601f, -1.58437312f, 1.09824145f, 
    0.99399549f, 0.64488751f, 0.10962384f, -0.50358588f, -0.40761113f, -0.36099693f, -0.11262298f, 0.58748901f, 
    0.89203858f, -0.25915098f, 0.41334334f, -1.13139367f, 0.30149630f, 0.28411502f, 0.03230328f, 0.05858973f, 
    1.09559953f, 0.76228082f, -0.70174628f, -0.05781689f, 0.65691394f, 0.59290272f, 0.31843120f, -0.34815627f, 
    0.40175468f, -0.87724853f, -1.47096550f, -0.66718805f, -0.10705852f, 0.90168142f, 0.79430461f, -0.18191645f, 
    -0.25998741f, -0.39811096f, -1.24205315f, 0.13279018f, 0.09848938f, 1.04503524f, 0.84697276f, 0.78264856f, 
    0.13841784f, -0.67072940f, -0.42692551f, 1.00814009f, 0.85542047f, -1.09765208f, -0.52646178f, 0.56452537f, 
    -0.43473533f, -0.34428066f, 0.39345285f, 0.24992207f, 1.13730490f, 1.18944764f, 0.44797078f, 0.08979417f, 
    0.33137980f, -0.20773108f, 0.30768436f, 0.08245581f, 0.24140744f, 0.09328498f, 1.06992185f, 0.64284343f, 
    -1.07233000f, 1.08809495f, -0.34027800f, -0.04673140f, 0.35921910f, -0.27183524f, 0.93414998f, 0.40781042f, 
    0.85888994f, 0.37710238f, 0.59253174f, 0.71832395f, -0.56992638f, -0.62352359f, 0.10624720f, -1.39514089f, 
    0.69537747f, 0.88385224f, -0.08992940f, 0.53857535f, 0.35813111f, -0.11049011f, -0.04444138f, 0.36650223f, 
    -1.01783073f, -0.80267322f, -0.89683676f, -0.39922297f, 0.93620646f, 0.40933934f, 0.18356171f, 0.07820773f, 
    0.51485538f, 0.04141963f, -1.44587541f, -1.09140050f, -0.86303073f, 0.34697086f, 0.41160643f, -0.17100595f, 
    0.29281953f, -0.00948021f, -1.01638079f, -0.00013385f, -1.00771999f, -0.35857967f, -0.79029548f, -0.92892581f, 
    -0.09702168f, -0.13304573f, 0.34456128f, 1.09272325f, 0.41954929f, 0.45893842f, -1.33867776f, -1.03649485f, 
    -0.46279216f, 0.54035079f, 0.45825046f, -0.20778207f, 1.36830795f, -0.43875968f, -0.20918618f, -0.28273478f, 
    -0.20071547f, -0.39884955f, -0.23653968f, -0.16809610f, 0.67250520f, 0.69761556f, -0.58608395f, -0.67387247f, 
    -0.41427913f, -0.81612879f, 0.35892990f, -0.49834251f, -0.69317204f, 0.33460027f, 0.73512197f, 0.68785876f, 
    0.78974050f, 0.21023090f, -0.34094948f, -1.04732049f, -0.29334918f, -0.17990437f, -0.30245045f, 0.97561491f, 
    0.23252900f, 0.21085441f, 0.45255342f, 0.16901155f, 0.53813052f, -0.32846975f, 0.64202571f, -0.46647617f, 
    0.91344059f, -0.80656809f, -0.91428530f, 0.84971786f, 0.57813436f, 0.21844988f, -0.62090236f, -0.25865620f, 
    0.04793612f, -0.53102207f, 0.33184728f, 0.11830618f, -0.70128691f, -0.73424745f, 0.83196014f, 0.11590889f, 
    -0.64993370f, 0.66151798f, -1.09327745f, 0.70998532f, -0.46857378f, -0.06015602f, 1.22149825f, 0.39350665f, 
    -0.47864580f, -0.05819425f, 0.38039798f, -0.26222721f, -1.15480018f, 0.07136039f, -0.44510937f, -0.88815439f, 
    -0.58826959f, -0.13497429f, -0.22589980f, -0.67757821f, -0.00940841f, 1.27923608f, 0.70564258f, -1.08275259f, 
    -0.32299763f, 0.00066552f, -0.46737093f, 0.42628616f, -0.37752613f, 0.73788494f, 0.22217493f, -0.51284361f, 
    0.93570280f, 0.15210424f, -1.11472750f, -0.19205877f, -0.02777087f, -0.41707084f, -0.12512639f, -0.49559319f, 
    -0.70527709f, -0.75620216f, -0.75119454f, -0.49058235f, -0.38015640f, -0.53737366f, -0.42364004f, 0.90606272f, 
    -1.47708905f, 1.07006741f, 0.75745010f, -0.67697316f, 0.37371996f, 0.10018711f, 0.06149501f, -0.58161163f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11302104f, 0.29651976f, 0.14007607f, 0.26040202f, -0.04633419f, 0.30583382f, 0.02162788f, 0.07578650f, 
    0.33730677f, 0.32688904f, -0.01158339f, -0.00274379f, 0.11478219f, 0.27222931f, 0.24428597f, 0.18553856f, 
    0.24650675f, 0.25523466f, 0.30519018f, 0.08838450f, -0.09120922f, -0.12665269f, -0.12613460f, 0.30105922f, 
    0.04760079f, 0.17308252f, -0.22573678f, 0.16834931f, -0.08611961f, 0.04805911f, 0.10810144f, -0.02526434f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.19034240f, -0.15802647f, 0.08952717f, -0.02101467f, -0.01615120f, -0.11556438f, -0.05419132f, 0.01692535f, 
    -0.16155425f, -0.00486959f, -0.07669805f, 0.10423677f, 0.03565729f, 0.01116377f, 0.00589498f, 0.10071807f, 
    -0.02752445f, 0.09078861f, -0.02339572f, -0.08615132f, -0.46741095f, -0.09766050f, -0.22662097f, 0.15246509f, 
    -0.08705744f, -0.00667362f, 0.01447026f, -0.01398228f, 0.01397441f, -0.01978952f, 0.03933430f, -0.02603736f, 
    0.09071314f, 0.02218449f, -0.06023323f, 0.03181965f, 0.06347306f, -0.08534707f, 0.06702316f, -0.09008877f, 
    0.02359548f, 0.10891156f, -0.13253377f, -0.19056356f, 0.21186572f, -0.19561991f, -0.27851310f, -0.03688320f, 
    0.00889184f, 0.01541943f, -0.04856346f, -0.02928617f, -0.00432461f, 0.02542811f, 0.08062433f, -0.02171052f, 
    -0.06411321f, -0.06748983f, -0.01282004f, 0.10829227f, -0.01591399f, 0.01022066f, 0.14169046f, -0.11213273f, 
    -0.47096807f, 0.01452949f, 0.06438684f, -0.01950395f, -0.00780364f, -0.09467079f, -0.09694253f, -0.00067684f, 
    -0.05579576f, -0.07112429f, 0.01675983f, -0.01515265f, 0.06296527f, 0.02901437f, -0.06226033f, -0.02055230f, 
    0.35088584f, -0.37455687f, 0.09164090f, 0.00648278f, 0.14815994f, -0.02174692f, -0.17892064f, 0.09317365f, 
    0.09541894f, -0.07453427f, 0.01928034f, 0.05153835f, -0.19685067f, 0.00777093f, -0.12796053f, 0.08396948f, 
    0.10978808f, 0.02725457f, -0.10134961f, 0.12832455f, -0.31498170f, -0.66208613f, -0.09472808f, 0.18112788f, 
    -0.12893024f, -0.07764815f, -0.09988270f, 0.09158630f, 0.05580605f, -0.05870584f, 0.00878105f, -0.06171113f, 
    -0.03724357f, -0.12383875f, 0.07982595f, 0.10685927f, 0.11367063f, -0.02382860f, 0.11639099f, 0.04201692f, 
    -0.05975885f, 0.10508747f, 0.29002342f, 0.16834451f, 0.07731470f, -0.07627774f, -0.25763518f, 0.11968008f, 
    -0.03970174f, -0.02264763f, 0.00985060f, 0.04979177f, -0.00415288f, 0.12059772f, -0.10086664f, 0.01027629f, 
    -0.14794004f, 0.01538706f, 0.03039672f, -0.04215626f, 0.24828580f, -0.12926996f, 0.21501912f, -0.26619175f, 
    0.12568413f, -0.09767555f, 0.01147286f, -0.01059941f, 0.02411881f, 0.04398875f, 0.06870699f, -0.10441148f, 
    -0.02095462f, -0.02124028f, -0.07010601f, 0.13177700f, 0.09826585f, -0.02969925f, -0.08826463f, -0.00995146f, 
    -0.25164303f, 0.08652046f, 0.04712732f, -0.19679061f, 0.32220098f, -0.19776377f, -0.08928713f, -0.02439443f, 
    0.07179243f, -0.04279043f, 0.00585915f, -0.05532328f, 0.09161526f, 0.04609501f, 0.01279294f, 0.02937487f, 
    0.02206965f, -0.06356361f, -0.12217571f, -0.00343043f, -0.35195193f, 0.22679874f, -0.01612972f, -0.31411651f, 
    -0.43795252f, 0.04857155f, 0.09949300f, -0.00629505f, 0.06901028f, -0.07737472f, 0.04937129f, -0.01588411f, 
    0.00796814f, 0.06861503f, -0.05895732f, -0.01425594f, -0.05614122f, 0.00401653f, 0.02692724f, -0.03336305f, 
    0.39450026f, 0.02005890f, 0.25475600f, -0.07639788f, -0.20526740f, 0.06605537f, 0.12120994f, 0.10954782f, 
    0.00792630f, 0.03694354f, -0.03685846f, -0.06360862f, -0.00886247f, -0.09161317f, -0.00866011f, 0.10695475f, 
    0.14544223f, -0.11920946f, 0.12285698f, -0.02840598f, -0.21946593f, -0.07578833f, 0.10866987f, -0.21848498f, 
    0.34870860f, -0.11412302f, -0.00864182f, -0.00744584f, 0.06930102f, 0.11668378f, -0.06852448f, 0.06992269f, 
    0.04486571f, -0.11274346f, -0.01491579f, -0.20746632f, 0.01887037f, 0.00387473f, -0.01549287f, -0.15927751f, 
    0.09624814f, 0.17991237f, -0.03402564f, -0.34699091f, 0.24880004f, -0.26138264f, -0.06106975f, 0.02366330f, 
    0.08624870f, -0.05122826f, 0.02527395f, 0.03169698f, -0.09155782f, -0.04992541f, 0.00582063f, 0.04866588f, 
    0.02258296f, 0.08531921f, 0.00181775f, -0.01506966f, -0.08580584f, -0.07804994f, 0.02164701f, -0.08534741f, 
    0.13008529f, -0.07376883f, -0.05882771f, -0.16171682f, -0.08151773f, 0.05624311f, -0.05878695f, -0.00110608f, 
    0.06292974f, -0.11606254f, 0.03287439f, -0.05169143f, 0.00642772f, 0.02593852f, 0.01536531f, -0.16977353f, 
    0.14903985f, -0.00079740f, -0.00676795f, -0.02216994f, 0.07309431f, -0.11628792f, -0.18989626f, 0.03179782f, 
    -0.03979959f, -0.01842632f, 0.01407365f, 0.02024226f, 0.00147629f, -0.06196491f, -0.02624861f, 0.05296975f, 
    0.20428516f, -0.10844382f, -0.00576239f, 0.16060518f, -0.08364801f, 0.01331084f, 0.19177143f, 0.14170034f, 
    0.07781351f, -0.05314402f, -0.09513486f, 0.04448745f, 0.03176668f, -0.08311395f, 0.06073264f, -0.01207516f, 
    0.10042364f, -0.03471536f, 0.00931643f, 0.03849557f, -0.03086505f, 0.01330467f, 0.05165827f, 0.07096539f, 
    -0.07439361f, 0.32351378f, -0.06247943f, -0.18390942f, -0.35202351f, 0.08986289f, -0.05514263f, 0.06609639f, 
    0.03865048f, -0.14060837f, 0.02843832f, 0.04063758f, -0.09613924f, 0.09869285f, 0.06125917f, 0.02194745f, 
    -0.10777645f, 0.04229297f, -0.00277977f, -0.05029937f, -0.11281115f, 0.04825487f, -0.24307512f, 0.02734538f, 
    -0.37824425f, -0.01639494f, 0.03467249f, -0.02750096f, -0.10492724f, 0.05879282f, 0.01216450f, -0.00976225f, 
    -0.00572550f, -0.04706232f, 0.05614881f, -0.03079001f, -0.07995830f, -0.00379341f, -0.09194403f, -0.01465680f, 
    0.04407313f, -0.36195692f, -0.10921025f, 0.08768976f, -0.04893786f, -0.03122064f, -0.02364452f, 0.00768407f, 
    -0.03532962f, -0.03051953f, 0.05812268f, 0.03556849f, -0.06736258f, -0.02358857f, -0.10869516f, 0.04270270f, 
    -0.03435073f, 0.10017578f, -0.01485036f, -0.10605739f, 0.25600478f, 0.05610888f, 0.00341887f, 0.04038301f, 
    0.12961051f, -0.22544694f, -0.09287860f, -0.12373037f, 0.01226241f, -0.04837717f, -0.07936122f, 0.00876997f, 
    0.03568066f, -0.13817486f, 0.00728801f, -0.10402241f, -0.01483730f, 0.02637283f, 0.19416094f, 0.00630075f, 
    0.19777317f, -0.23965712f, 0.28056100f, 0.10868397f, 0.06500793f, 0.01150266f, 0.00981415f, 0.03053843f, 
    0.17930162f, 0.07465691f, -0.21953845f, 0.10216695f, 0.06679257f, 0.04040337f, -0.02353456f, -0.01076834f, 
    -0.11667463f, -0.22028945f, 0.15037537f, -0.01262173f, 0.09142167f, -0.34459323f, 0.08588548f, 0.27202633f, 
    0.03395453f, 0.06289422f, 0.13605320f, 0.04742396f, 0.07123536f, -0.03109090f, -0.14261316f, -0.03976877f, 
    0.08845519f, 0.09074655f, 0.10688478f, -0.09190528f, 0.03114777f, -0.03236793f, 0.01202312f, -0.05468341f, 
    0.03022460f, -0.02392231f, -0.01900410f, -0.24688761f, 0.05533233f, -0.08642624f, -0.31022787f, 0.02804754f, 
    0.11159286f, -0.00115607f, -0.00847133f, -0.00278503f, -0.14768001f, 0.01937602f, -0.06970517f, 0.15375629f, 
    -0.03931285f, 0.02940098f, 0.03005233f, 0.01304644f, 0.27334380f, -0.03629036f, -0.03459939f, -0.14256459f, 
    0.04581320f, -0.07901067f, -0.07681323f, -0.26862004f, 0.02079576f, -0.03450448f, -0.09695269f, -0.00485378f, 
    0.05317932f, 0.01792662f, -0.03742578f, 0.07149217f, -0.12948644f, -0.11126096f, -0.06812223f, 0.00195837f, 
    0.10314395f, 0.05661355f, -0.04485672f, 0.01389154f, 0.02041214f, 0.10305109f, 0.04657480f, 0.03355937f, 
    -0.06865675f, -0.06222449f, 0.01208683f, 0.05261355f, 0.03922322f, -0.03071018f, 0.02706879f, 0.02489269f, 
    0.17237566f, 0.05704379f, -0.16300930f, 0.05397393f, -0.30779007f, -0.01710132f, -0.02394512f, 0.03407081f, 
    0.07273933f, -0.01153518f, -0.03845219f, -0.06814862f, -0.06321743f, -0.05466649f, -0.05972369f, 0.17819993f, 
    0.10958207f, -0.04200441f, 0.09384000f, -0.13753566f, 0.06882893f, -0.04065191f, -0.06444976f, -0.05733258f, 
    0.56621444f, 0.36851138f, 0.19387132f, -0.27180862f, 0.05632516f, 0.14447930f, -0.03027154f, -0.01298108f, 
    0.16256374f, -0.11025761f, 0.08841485f, -0.11013311f, -0.16539799f, 0.05489927f, 0.07510373f, -0.04725896f, 
    0.08488744f, 0.00743978f, 0.06869916f, 0.08790753f, 0.00863847f, -0.49699855f, 0.05174686f, 0.15992586f, 
    -0.18039727f, 0.00458450f, -0.01616617f, 0.03370998f, 0.04901419f, 0.04544543f, -0.04746243f, -0.05466174f, 
    -0.13723652f, 0.01351416f, -0.01119682f, 0.14141133f, -0.00357061f, 0.05742417f, 0.03521200f, 0.06510627f, 
    -0.07901113f, 0.14130278f, 0.00834786f, 0.04159900f, 0.35254064f, -0.04689823f, -0.03379677f, -0.07566963f, 
    0.05735959f, 0.07667580f, -0.03722439f, -0.10743460f, -0.05815111f, -0.01273417f, -0.00106787f, 0.01053546f, 
    0.07521790f, 0.06309057f, 0.09596712f, -0.01834105f, 0.06051310f, -0.16349907f, 0.15495272f, 0.07951227f, 
    0.34480932f, -0.10722509f, -0.14921451f, 0.09305466f, 0.03951138f, -0.02703892f, 0.01652374f, 0.15272276f, 
    -0.07589608f, 0.05300247f, -0.13343820f, -0.04754707f, 0.10053840f, 0.08913811f, -0.05620113f, -0.03526362f, 
    0.01655794f, -0.28638950f, 0.02716996f, 0.24591601f, 0.07481734f, 0.02894856f, -0.00062701f, -0.03027415f, 
    0.06104296f, 0.00269240f, -0.03953940f, -0.19398446f, -0.01706394f, -0.00447850f, -0.01474295f, -0.01692818f, 
    0.01041279f, 0.02688952f, 0.00071182f, -0.07467197f, 0.36405328f, -0.45490319f, 0.14360186f, -0.01107748f, 
    -0.70957285f, 0.01448512f, 0.14168313f, 0.07048225f, -0.04931351f, -0.01803233f, -0.22846237f, 0.15904918f, 
    -0.12323010f, 0.02592154f, 0.04809054f, -0.00183448f, -0.08790395f, 0.14604893f, 0.06905061f, 0.02138650f, 
    -0.23155943f, -0.00205362f, 0.17934927f, -0.05103169f, 0.26464197f, 0.02652459f, -0.15902512f, -0.08439889f, 
    -0.07617304f, 0.03682814f, 0.05870637f, 0.04846470f, -0.06302046f, 0.01485642f, -0.04091004f, -0.04249092f, 
    0.03970859f, -0.06297740f, 0.02489312f, 0.05593596f, -0.37393835f, -0.18866424f, -0.25449783f, -0.07095093f, 
    -0.24143748f, -0.02053625f, -0.06326205f, -0.15933636f, 0.13412641f, -0.00669570f, -0.05572199f, 0.03902514f, 
    -0.03963226f, -0.00192483f, -0.09247794f, -0.04926125f, -0.00202542f, -0.05986094f, -0.09282279f, 0.03808147f, 
    -0.03054323f, 0.23607458f, 0.19539554f, 0.19428352f, 0.18245837f, -0.13552716f, -0.02629861f, 0.04066810f, 
    0.00058815f, 0.08120835f, -0.07326694f, -0.01008729f, 0.05656391f, 0.10421906f, -0.08832188f, -0.01319129f, 
    -0.00080166f, 0.09308203f, -0.08563750f, -0.00536008f, 0.11570917f, 0.19406900f, -0.16457886f, 0.10800193f, 
    -0.29759482f, 0.02918553f, 0.03924266f, 0.02582011f, -0.03364839f, 0.13571712f, 0.00015894f, 0.00176735f, 
    -0.06879580f, 0.05858466f, -0.00590567f, 0.13195719f, 0.09096421f, -0.01431468f, 0.06190387f, -0.04751164f, 
    -0.00099815f, -0.32115236f, 0.13195843f, -0.01024045f, 0.17400952f, -0.07537515f, -0.02367266f, -0.10633197f, 
    -0.03927254f, -0.03897887f, -0.06922253f, 0.00609477f, -0.04776299f, -0.03066515f, -0.04674550f, -0.04797239f, 
    0.00025119f, -0.02442970f, 0.09034880f, -0.01792703f, 0.20630959f, 0.07609980f, -0.23349956f, 0.03085643f, 
    -0.12336945f, 0.09469064f, 0.06511922f, -0.03271529f, 0.11747324f, 0.13644467f, -0.14792907f, -0.15641318f, 
    0.06235332f, 0.16465294f, -0.09839565f, 0.07827646f, 0.15083495f, -0.17129399f, -0.13006507f, -0.03488392f, 
    -0.23219612f, -0.07455307f, -0.20303889f, -0.14808460f, 0.07439349f, -0.04412990f, 0.08380561f, 0.00591126f, 
    -0.13875128f, 0.05380787f, 0.00559747f, 0.03762154f, -0.01348560f, -0.11509641f, -0.07273527f, 0.06890715f, 
    -0.19345345f, 0.06444292f, 0.06886268f, -0.01322441f, -0.05178225f, -0.08150114f, 0.12170144f, 0.18700711f, 
    0.36915594f, -0.01000572f, -0.10165098f, 0.00143718f, -0.02158127f, -0.05023849f, 0.07340354f, -0.00355716f, 
    0.05773315f, 0.06892994f, -0.07620747f, -0.12612292f, -0.01655753f, -0.03992968f, 0.12408792f, -0.08827818f, 
    0.44506502f, -0.09568585f, 0.16456152f, 0.00251039f, 0.08898752f, -0.10605442f, -0.06926405f, -0.09980118f, 
    0.03864273f, -0.04997205f, 0.02526979f, 0.01364982f, -0.12248110f, 0.05130456f, 0.01973431f, -0.09603983f, 
    0.04096334f, 0.01122948f, -0.06343667f, 0.04467355f, 0.36458930f, -0.06906847f, -0.19415656f, 0.02064942f, 
    -0.30897403f, -0.08404225f, -0.04980881f, 0.00762693f, 0.02602676f, 0.08767463f, 0.00924492f, 0.01984459f, 
    -0.04550758f, -0.05758274f, 0.09071396f, 0.01926166f, 0.02926030f, -0.00585870f, -0.12655677f, 0.05434444f, 
    -0.40520591f, 0.17494361f, -0.17180897f, 0.04657414f, -0.02264552f, 0.05696337f, 0.04992097f, -0.08775912f, 
    -0.09347205f, 0.04451701f, 0.12198074f, 0.15908577f, -0.06315187f, -0.02049372f, 0.06101337f, 0.00676149f, 
    -0.07311082f, 0.04871463f, 0.01960624f, 0.10164616f, 0.43732312f, -0.10249420f, 0.03058525f, -0.35013196f, 
    -0.15265386f, 0.06178414f, -0.08675972f, -0.09367937f, 0.01397126f, 0.00395536f, -0.10476783f, -0.00284041f, 
    0.02076823f, 0.18163761f, 0.15263033f, -0.00382481f, -0.03232192f, -0.01872165f, -0.01849837f, 0.01445347f, 
    0.35053754f, 0.14918332f, 0.17182879f, 0.09047446f, 0.17344420f, -0.14391069f, -0.18212235f, -0.00743385f, 
    -0.01188733f, 0.01589837f, -0.08312168f, 0.00449534f, 0.08780944f, 0.11829793f, -0.03241341f, 0.00117739f, 
    0.07097923f, -0.02385481f, -0.07437573f, -0.07053485f, 0.05316707f, 0.28440046f, -0.16175376f, -0.09260948f, 
    0.26145458f, -0.03476987f, -0.04084304f, 0.07644078f, 0.03605201f, 0.06639642f, 0.11972426f, -0.03948086f, 
    0.04446878f, 0.12783350f, -0.22325665f, -0.00802261f, 0.05625701f, 0.04019582f, -0.10880365f, 0.12107969f, 
    0.22026496f, 0.22816415f, 0.12429536f, 0.12315888f, 0.16846728f, -0.11105919f, 0.01303279f, -0.05466389f, 
    0.05024355f, 0.09269927f, 0.05647701f, 0.05789663f, -0.04182375f, -0.02696166f, -0.03249231f, 0.08255461f, 
    0.04874110f, 0.14942174f, 0.02500062f, -0.00801618f, -0.35924867f, 0.11156842f, -0.21772420f, -0.22743726f, 
    0.02635103f, -0.05717974f, 0.18232605f, 0.00649409f, 0.00073010f, -0.00021220f, -0.10463079f, -0.05323221f, 
    0.05786018f, -0.02144325f, -0.03216434f, 0.06553890f, -0.07529781f, 0.13995235f, 0.04431608f, -0.10357960f, 
    0.32700536f, -0.02627912f, -0.19120538f, 0.06193361f, -0.07815707f, -0.00050056f, 0.08775965f, 0.02662170f, 
    0.07677607f, 0.15215778f, -0.04259446f, -0.06646495f, -0.01957514f, -0.10296313f, 0.06488667f, 0.15592779f, 
    -0.00378128f, 0.00307635f, -0.09277730f, 0.01933061f, 0.14504917f, -0.44502053f, 0.11547753f, 0.01610836f, 
    -0.01713222f, -0.05954958f, 0.09376036f, 0.11782752f, 0.12124266f, 0.04756163f, 0.01451239f, -0.01200178f, 
    0.10746810f, 0.04232147f, -0.09003499f, 0.12536146f, -0.00797422f, 0.05324536f, -0.04287010f, 0.11176733f, 
    -0.07495725f, 0.02812331f, -0.07723324f, -0.12307332f, 0.07634114f, 0.14590475f, -0.05522552f, 0.17431688f, 
    0.04325128f, 0.06310681f, -0.03245875f, -0.13364008f, 0.02943256f, 0.00277558f, 0.06889242f, -0.00725658f, 
    0.07696417f, -0.25645581f, -0.11311171f, -0.24086307f, 0.06138258f, -0.19385526f, -0.09746393f, 0.01718555f, 
    -0.22375382f, 0.12268499f, -0.14567176f, 0.06461661f, 0.07706020f, -0.10435759f, 0.03159492f, 0.06899036f, 
    0.05625196f, 0.19655034f, -0.04474888f, 0.06565983f, -0.11969613f, -0.18525495f, -0.12512195f, -0.00409087f, 
    0.22417511f, -0.56138974f, -0.06652498f, -0.20441200f, -0.17447969f, 0.04227776f, -0.08623920f, 0.02186216f, 
    -0.07272062f, -0.06230721f, 0.09214000f, 0.06895974f, -0.08506335f, -0.08132793f, 0.01729237f, -0.11616992f, 
    -0.04126651f, -0.02971376f, -0.12800427f, -0.16788386f, -0.19331828f, -0.25791571f, -0.07224307f, -0.48993307f, 
    -0.01900978f, -0.19059165f, -0.01252949f, -0.03993057f, -0.00638258f, -0.00933196f, -0.12551925f, -0.02876735f, 
    -0.04891992f, 0.02011637f, -0.19217040f, -0.15415737f, -0.13010721f, -0.00652444f, 0.04542109f, -0.10740326f, 
    0.11699446f, -0.08033433f, 0.13427101f, 0.04510063f, 0.19312988f, -0.04867211f, 0.02582796f, 0.06203905f, 
    -0.01082529f, -0.04416082f, 0.01080459f, -0.16802500f, 0.17087045f, -0.11082334f, 0.12234312f, -0.06202516f, 
    0.04442543f, -0.02992335f, -0.00085885f, 0.08434802f, 0.23134302f, 0.11412245f, 0.11374988f, 0.08983244f, 
    0.10562682f, 0.08042619f, -0.01277158f, 0.04760329f, -0.07293892f, -0.00847006f, 0.06365894f, -0.09932609f, 
    -0.06940818f, 0.05758585f, -0.18524662f, -0.05683309f, 0.02696886f, 0.00998405f, 0.10409937f, 0.03645040f, 
    0.19303367f, -0.51427138f, 0.03895315f, -0.10050329f, -0.11722814f, -0.04245258f, 0.06601371f, -0.13690695f, 
    0.04672441f, -0.01290494f, 0.07810595f, -0.01247716f, 0.05643536f, 0.00789726f, -0.15812285f, 0.07887676f, 
    0.01771848f, -0.16871093f, 0.10334228f, -0.01928474f, 0.08067410f, 0.08848933f, -0.05092142f, -0.16150220f, 
    -0.01340846f, 0.10650747f, 0.02628504f, -0.07196899f, 0.16662779f, -0.05845725f, -0.13126642f, -0.07938283f, 
    -0.04967315f, 0.15942213f, 0.03728174f, 0.04101687f, -0.07782452f, 0.00897177f, 0.16954364f, 0.02726806f, 
    -0.35095933f, 0.11022333f, -0.14003861f, -0.21225348f, -0.04917352f, 0.01562221f, 0.13357466f, -0.11434969f, 
    -0.10906746f, 0.04067296f, 0.03546018f, 0.03570695f, 0.05149414f, -0.20630285f, 0.13665052f, 0.04747195f, 
    -0.00850193f, 0.04213924f, -0.06581971f, 0.03244790f, -0.02666342f, 0.13762270f, -0.05373748f, -0.08681571f, 
    -0.27472663f, 0.05907506f, -0.00669838f, 0.01988962f, -0.04812905f, 0.01221747f, -0.00494190f, -0.08255566f, 
    0.09062359f, 0.12922987f, 0.01825417f, -0.05317184f, 0.00476872f, -0.16294648f, -0.23643546f, -0.07814366f, 
    -0.01594404f, 0.12606439f, -0.39752007f, -0.10571377f, -0.02729513f, 0.08589150f, 0.06472819f, 0.05740490f, 
    -0.06793912f, 0.04027653f, -0.01359347f, 0.06245891f, -0.01378456f, 0.03976940f, -0.03443567f, -0.00060249f, 
    0.05025757f, -0.02204787f, -0.09081405f, -0.02379786f, 0.06227077f, -0.44041592f, 0.09920789f, -0.25998530f, 
    -0.02265578f, 0.01411792f, -0.13459124f, -0.04156843f, -0.06769117f, -0.07137842f, -0.14791198f, -0.04065952f, 
    -0.06662979f, -0.15278150f, 0.08020133f, 0.02388284f, 0.02475883f, -0.17562820f, 0.14333738f, 0.01060937f, 
    -0.06680139f, -0.09975255f, -0.04402944f, -0.38512650f, -0.11183251f, -0.03199351f, 0.02717046f, 0.03927219f, 
    0.04908561f, 0.05208630f, 0.00374058f, -0.04798435f, -0.00950884f, 0.03744821f, -0.10593928f, -0.21541114f, 
    0.00812779f, -0.09377129f, -0.07760242f, -0.04537211f, 0.22202528f, 0.14014220f, 0.16816394f, -0.03494532f, 
    -0.25958160f, -0.11969481f, -0.01158493f, -0.04390653f, 0.06780403f, 0.08482755f, 0.20205824f, -0.02261249f, 
    0.17128357f, -0.10128044f, -0.01692678f, -0.00721329f, 0.04471943f, -0.03301419f, 0.03610257f, 0.18868865f, 
    0.05251557f, 0.03420005f, 0.08388262f, -0.02486500f, -0.10095659f, 0.01343942f, 0.04567259f, 0.04717930f, 
    -0.04386162f, -0.07706828f, -0.01596979f, 0.09002715f, -0.01748937f, -0.06446088f, -0.00768195f, 0.00751011f, 
    -0.13627522f, 0.06868549f, 0.07367329f, 0.03460716f, 0.36070254f, -0.09394147f, -0.21376851f, 0.06630704f, 
    -0.21467967f, -0.05173080f, 0.06986983f, -0.00359266f, -0.02146929f, -0.00826103f, -0.03251370f, -0.04360511f, 
    -0.07072985f, -0.04866630f, -0.06178900f, 0.07919258f, 0.00820658f, -0.11401765f, 0.12904978f, -0.12701771f, 
    -0.16614522f, 0.03006386f, 0.03218963f, -0.05237953f, 0.08599428f, 0.00004624f, 0.03044835f, 0.08514658f, 
    0.07097171f, -0.09953188f, -0.04365681f, 0.06505188f, 0.01141559f, 0.07144062f, -0.00850091f, -0.02818650f, 
    -0.02195666f, -0.09848662f, -0.09526195f, -0.03977479f, 0.24458876f, -0.09490927f, 0.21164927f, -0.02377993f, 
    0.26303351f, -0.17201851f, -0.08814078f, -0.16753735f, 0.08024042f, 0.02936324f, 0.03891265f, -0.04234535f, 
    -0.07533214f, -0.07168517f, 0.04477986f, -0.06639101f, -0.07029800f, -0.00554812f, 0.04261585f, 0.09361047f, 
    0.07518984f, -0.13754137f, 0.00499549f, -0.07460143f, -0.07814204f, 0.12916876f, -0.04982682f, 0.02155315f, 
    0.01851249f, 0.15616654f, -0.03692926f, -0.07666534f, 0.05491340f, 0.02822875f, -0.10590236f, -0.03603854f, 
    -0.01394025f, 0.00338888f, -0.07562139f, -0.07480476f, -0.00294985f, -0.53894717f, 0.13798240f, -0.03436628f, 
    -0.18660875f, -0.15132612f, 0.02790768f, -0.04021389f, -0.01771612f, 0.01673197f, 0.08963356f, 0.01903063f, 
    0.13008884f, -0.12890397f, -0.02143679f, 0.07075445f, 0.00953091f, 0.04138349f, 0.06295960f, -0.07089534f, 
    0.33580786f, 0.06159622f, -0.26580894f, -0.06700273f, -0.06449410f, -0.00823679f, 0.00323666f, 0.04926818f, 
    -0.02222907f, 0.05038691f, -0.05718549f, 0.03615959f, -0.01755494f, 0.03214233f, -0.02680733f, -0.01601700f, 
    -0.03229013f, -0.03060242f, 0.05597827f, -0.00760649f, -0.16988774f, 0.08782853f, -0.00847185f, -0.09302331f, 
    -0.06525687f, 0.08415111f, -0.09180263f, 0.17758751f, -0.03294096f, -0.03548492f, -0.11681011f, -0.03065991f, 
    0.03332002f, -0.08163510f, 0.01901765f, 0.08463120f, 0.00804520f, -0.00397660f, -0.18986337f, -0.02050328f, 
    0.12383782f, -0.09171577f, -0.01555165f, -0.07134014f, -0.08162874f, 0.09513958f, -0.15078351f, 0.14722064f, 
    0.09788973f, 0.01551590f, -0.03601144f, 0.03389821f, 0.05808016f, 0.07084835f, -0.01091179f, -0.07637647f, 
    -0.01863870f, 0.01761150f, 0.03953359f, -0.04754806f, 0.24330769f, -0.08533869f, 0.04742765f, 0.13545120f, 
    0.20768616f, -0.20188607f, -0.03954171f, -0.06571774f, 0.04891788f, 0.04738408f, 0.09523085f, -0.00683402f, 
    -0.04914249f, 0.01741869f, 0.00414660f, 0.04018259f, -0.10192836f, -0.03316653f, 0.00198701f, 0.00292328f, 
    0.32938755f, 0.07818297f, 0.12603088f, 0.02486190f, 0.26613674f, -0.04944346f, -0.13367644f, -0.11036958f, 
    0.11052820f, 0.09364545f, 0.01036009f, -0.02280376f, -0.01514524f, -0.06402292f, -0.02374179f, -0.00882333f, 
    -0.08244514f, -0.09283654f, -0.08239582f, -0.04403573f, 0.11544304f, 0.06149120f, -0.06281123f, -0.21596217f, 
    -0.09309618f, 0.01549868f, 0.00719038f, 0.11654717f, -0.08057825f, -0.02640834f, -0.02684169f, -0.04518474f, 
    0.09184022f, -0.15348195f, -0.01016328f, 0.00956710f, -0.02990687f, 0.12661703f, 0.04628274f, -0.04867539f, 
    0.07190018f, 0.02143818f, 0.06742302f, -0.21429497f, 0.07874039f, 0.05583415f, 0.02052803f, 0.16296019f, 
    0.00725101f, -0.10542581f, -0.03957976f, 0.07714856f, -0.03497882f, -0.04467500f, -0.04665470f, 0.00362915f, 
    -0.05229210f, 0.10752646f, -0.00374489f, 0.05085158f, 0.21740495f, 0.10336750f, -0.09875078f, -0.16297512f, 
    -0.04037485f, 0.01644462f, 0.09041116f, -0.02130324f, -0.07989825f, -0.07875990f, -0.05038407f, -0.08032318f, 
    -0.02660171f, -0.05498815f, -0.00176156f, -0.00410940f, 0.01187598f, -0.06792599f, -0.12975076f, -0.09194665f, 
    -0.28842854f, -0.03588885f, 0.08690290f, -0.07369509f, 0.00563742f, 0.12794280f, -0.06616230f, 0.12248573f, 
    0.01349937f, -0.02035129f, -0.08584942f, 0.05509491f, 0.02379038f, -0.02883426f, -0.03435079f, -0.13780515f, 
    -0.07750463f, 0.00774119f, -0.04333982f, -0.01200459f, 0.38252980f, 0.07414231f, -0.31235507f, -0.00606525f, 
    -0.13558169f, -0.10397008f, 0.01880733f, 0.03230579f, -0.01970136f, -0.04467780f, 0.02542216f, 0.07018667f, 
    0.06715246f, -0.01174273f, -0.00921078f, -0.03667837f, 0.01536399f, -0.13163045f, 0.06068052f, -0.00553822f, 
    0.27781898f, -0.01649786f, 0.12143166f, 0.10008691f, 0.14460823f, -0.19169685f, 0.00672719f, -0.12366566f, 
    0.02413908f, 0.03599460f, 0.04849646f, -0.06306796f, -0.06645636f, -0.05274972f, -0.02307549f, -0.00940291f, 
    0.00358244f, 0.02684423f, 0.03706017f, 0.05820182f, 0.50336558f, -0.13429761f, -0.10842430f, 0.13640748f, 
    -0.15432896f, -0.16688699f, 0.01904603f, -0.01995592f, -0.03763724f, -0.03122988f, 0.08814760f, -0.01975671f, 
    0.00291485f, -0.01093000f, 0.01513559f, 0.03576111f, 0.03027398f, 0.00887623f, -0.06957152f, -0.03144095f, 
    -0.34404716f, -0.19938587f, -0.12106065f, -0.23609053f, -0.28988332f, 0.10246443f, -0.05257079f, -0.10737012f, 
    -0.08426270f, 0.02439697f, -0.03618211f, 0.01419579f, -0.02499929f, 0.03284926f, -0.00343222f, -0.09827144f, 
    -0.00964796f, 0.07460812f, 0.05540697f, 0.02821136f, -0.25841120f, 0.22328477f, 0.08795884f, -0.16050793f, 
    -0.01377584f, 0.04425762f, 0.17957595f, 0.08191714f, -0.01905770f, -0.01796156f, -0.04372121f, 0.02665963f, 
    -0.00949691f, -0.06757251f, -0.07133910f, 0.09192546f, 0.02349021f, -0.02076223f, 0.01290966f, -0.01924410f, 
    -0.40670767f, -0.00033236f, -0.01042819f, -0.34355429f, -0.19559555f, 0.07591239f, 0.04317611f, 0.03560571f, 
    0.03558994f, 0.07478484f, -0.10521136f, 0.03103015f, -0.03537012f, -0.06851932f, -0.07620055f, 0.02167481f, 
    0.03946944f, 0.12762789f, 0.06791062f, 0.06403401f, 0.07818516f, -0.19860484f, -0.22785638f, -0.01840262f, 
    -0.48450422f, 0.08165653f, -0.03993208f, 0.09182703f, 0.07249976f, 0.11642464f, 0.02814798f, 0.00330587f, 
    -0.01990667f, 0.00991350f, -0.05529345f, -0.09422681f, 0.03101035f, 0.11217488f, 0.03266019f, -0.02314873f, 
    -0.05005730f, -0.20731251f, -0.00799339f, -0.15328063f, 0.05283961f, 0.13761747f, 0.08205642f, 0.03975947f, 
    -0.03021189f, -0.05103954f, 0.02202219f, 0.04399178f, -0.05516285f, -0.07880541f, -0.03637937f, 0.00146722f, 
    -0.05292666f, 0.02409201f, -0.09582153f, -0.00646389f, -0.09826314f, 0.00343319f, 0.11080644f, -0.05240843f, 
    0.01345281f, 0.00108091f, -0.06915096f, 0.00363132f, 0.02523425f, 0.02563668f, -0.02559325f, -0.05924922f, 
    0.10411552f, -0.02332247f, 0.03512698f, -0.01584403f, 0.00205393f, -0.10312171f, -0.00540509f, -0.01463677f, 
    -0.08218695f, -0.04066890f, 0.10169151f, 0.13919483f, -0.05145246f, -0.08277367f, -0.10386404f, -0.06173243f, 
    0.08947097f, 0.11727809f, -0.03323400f, -0.05640690f, -0.04266647f, 0.13440265f, -0.01882320f, -0.07492376f, 
    -0.03700746f, -0.09144475f, 0.00021127f, -0.05766905f, -0.07209121f, 0.15520774f, -0.11950184f, -0.00616832f, 
    -0.17619218f, 0.04113377f, 0.06038026f, 0.04748267f, -0.14505683f, 0.00243325f, -0.02762161f, 0.08506618f, 
    0.08680792f, -0.03116500f, -0.01911840f, 0.04131141f, -0.07412706f, -0.05234312f, 0.08228753f, -0.13189340f, 
    0.22326536f, 0.10148087f, -0.05105065f, 0.11807472f, 0.03331472f, 0.00479288f, -0.02503376f, -0.07920825f, 
    0.04067461f, 0.04550239f, -0.00232678f, -0.03982924f, 0.11192080f, 0.04731320f, -0.08980588f, 0.05063675f, 
    -0.05658565f, -0.06596292f, -0.07659537f, -0.04981240f, -0.28569254f, -0.26940107f, -0.16345994f, -0.12274797f, 
    -0.29056722f, -0.17410584f, 0.02545414f, -0.01492863f, 0.01198417f, -0.06456795f, 0.01254218f, -0.05673291f, 
    0.04645103f, 0.01540953f, 0.01163001f, -0.01419185f, -0.04288962f, 0.03339460f, 0.10768358f, -0.02037743f, 
    0.06835669f, -0.00187810f, -0.24397983f, -0.06267890f, -0.07744725f, 0.03706905f, 0.10339203f, 0.05510885f, 
    -0.07282805f, -0.05207907f, -0.01560194f, -0.09924794f, 0.05497516f, 0.00130366f, -0.08106133f, 0.01312296f, 
    0.03889513f, 0.05899318f, -0.06730399f, 0.03031812f, 0.12985003f, -0.64504576f, 0.04558132f, -0.18583046f, 
    -0.06243812f, 0.19916990f, -0.11950053f, -0.01227536f, 0.02312271f, 0.11648503f, -0.02406459f, 0.07332058f, 
    0.05480637f, 0.00175268f, -0.07230163f, 0.14065903f, -0.18010761f, -0.03811269f, -0.06685247f, -0.00708628f, 
    -0.07662076f, -0.31558624f, -0.15414593f, -0.01801204f, -0.38528344f, -0.07407300f, 0.05399931f, -0.00448944f, 
    0.04906278f, 0.00820447f, 0.00234023f, 0.02566328f, 0.05515008f, -0.01250561f, 0.06270496f, -0.01807412f, 
    -0.04343462f, 0.11393739f, 0.02050961f, -0.09019446f, -0.68215871f, 0.20819181f, 0.13895237f, -0.08696577f, 
    0.05998727f, -0.01797357f, 0.08565762f, -0.01902617f, 0.04674318f, -0.02632487f, 0.00063145f, -0.07945274f, 
    0.02918513f, -0.08707429f, 0.12260167f, -0.00515635f, -0.00523321f, -0.06926693f, 0.07516297f, 0.01076217f, 
    0.24997294f, -0.10858990f, -0.00167812f, 0.22181964f, -0.06869269f, 0.10608961f, 0.02827708f, 0.04151233f, 
    0.09967628f, -0.04205060f, -0.04151803f, 0.07827137f, -0.14040639f, -0.03338322f, -0.04303506f, -0.08889833f, 
    0.03797590f, 0.07638367f, -0.04396635f, -0.04559766f, -0.32994163f, 0.29276726f, 0.18485713f, 0.17434500f, 
    0.07660715f, 0.05818305f, 0.08441983f, -0.00341279f, -0.00869594f, 0.03034852f, -0.10735514f, -0.08433056f, 
    0.01068128f, 0.03709124f, -0.05637854f, -0.04171265f, 0.04811783f, -0.08577412f, 0.05199085f, -0.05925954f, 
    -0.50392252f, -0.70373046f, -0.28566518f, 0.03202197f, 0.06674043f, -0.01730332f, 0.00274773f, -0.06006109f, 
    0.01929664f, -0.18802224f, -0.03386277f, 0.01130879f, 0.03829896f, -0.19412379f, 0.09571663f, -0.07623544f, 
    -0.11263321f, -0.04473317f, 0.05880485f, -0.06885978f, 0.16732351f, -0.10030721f, -0.10230537f, -0.10639209f, 
    -0.02028402f, -0.03723654f, -0.18002862f, -0.01622108f, 0.09269091f, -0.07325178f, -0.04448071f, 0.03248786f, 
    0.03444633f, -0.04320537f, -0.00713688f, -0.02685770f, -0.09174933f, 0.04423448f, -0.01404117f, 0.05425780f, 
    -0.32981735f, 0.12718357f, -0.26477259f, 0.30768582f, 0.04097957f, -0.08679524f, -0.00444147f, -0.01581635f, 
    0.04814719f, -0.01774168f, -0.05820501f, -0.14511833f, -0.06922564f, 0.12077765f, -0.01172388f, 0.02559716f, 
    0.03227062f, -0.00244312f, -0.01068495f, 0.08890711f, -0.01074257f, 0.12441245f, -0.02696710f, 0.04641880f, 
    -0.05709264f, -0.14308217f, -0.01876880f, -0.06517493f, -0.00917760f, 0.11205374f, -0.07426891f, 0.02478069f, 
    0.03418622f, -0.08480003f, 0.02144551f, -0.10724282f, -0.00711746f, 0.07487530f, 0.03502867f, -0.11244233f, 
    0.44788146f, 0.12830429f, 0.03511888f, 0.00968831f, 0.04530843f, 0.08035231f, -0.07969429f, -0.07835621f, 
    0.16043408f, -0.07994317f, 0.00919794f, 0.02981949f, -0.02641534f, 0.06004893f, -0.07420098f, -0.13330124f, 
    -0.01549037f, -0.13733253f, 0.03111851f, 0.05376285f, 0.19021112f, 0.02376392f, -0.45209715f, 0.18665083f, 
    0.17748842f, 0.04125426f, 0.17539719f, 0.00846811f, -0.05565662f, -0.03517706f, 0.15324357f, -0.02532213f, 
    -0.07796074f, 0.03481242f, -0.02662013f, -0.04762403f, 0.03433143f, -0.00842152f, -0.02165512f, -0.02646264f, 
    0.00716280f, -0.41650960f, -0.26382542f, -0.12482806f, -0.08251269f, -0.11655169f, 0.02088598f, -0.02987517f, 
    0.05776417f, 0.00803170f, 0.05647567f, 0.01494381f, 0.02842216f, -0.01019431f, -0.10186949f, -0.07722371f, 
    -0.00099067f, -0.05280818f, -0.03029677f, 0.00048362f, 0.14772879f, -0.20824091f, 0.04506721f, -0.03199243f, 
    -0.07507243f, -0.05259735f, -0.19294605f, 0.08934951f, -0.05476479f, -0.01013807f, -0.06644683f, 0.06587507f, 
    0.05296704f, -0.02207827f, 0.03197915f, 0.03974695f, 0.05720398f, 0.05954323f, 0.08490530f, 0.02217529f, 
    -0.32295021f, -0.01071608f, -0.02087708f, -0.16686279f, -0.21841332f, -0.05680828f, -0.25185835f, -0.04438359f, 
    -0.00841547f, -0.06849767f, -0.06838838f, -0.17645708f, 0.01026529f, -0.06308997f, 0.00059744f, 0.05421782f, 
    0.10070731f, 0.07322787f, 0.09288243f, 0.09037267f, 0.10599498f, -0.14962372f, 0.10894949f, -0.08377241f, 
    0.15374668f, -0.09959023f, -0.01054158f, -0.02492082f, -0.09537519f, 0.01386105f, 0.02111354f, 0.09560651f, 
    0.07396726f, 0.02279275f, 0.11055142f, 0.02686206f, -0.02859443f, 0.04602756f, 0.00608937f, 0.09959693f, 
    -0.52776676f, -0.63840425f, -0.32178596f, -0.02065423f, -0.05491555f, -0.11287554f, -0.08604207f, -0.00894971f, 
    0.03106465f, -0.04465117f, -0.10354187f, -0.01649566f, 0.05021809f, -0.06095083f, -0.08509093f, -0.06725627f, 
    -0.00115231f, -0.03657316f, -0.04151874f, 0.04104167f, -0.51986969f, 0.37659067f, -0.09213460f, -0.09804194f, 
    0.21764457f, -0.04547664f, 0.08888467f, -0.01440589f, 0.03636742f, -0.04499447f, -0.07095444f, -0.00081552f, 
    0.02318753f, 0.01169502f, 0.03651008f, -0.04691003f, 0.05620020f, -0.13360047f, 0.13130307f, 0.04107221f, 
    -0.34368074f, -0.49349496f, -0.20313448f, -0.12210235f, -0.29975066f, -0.03177018f, -0.00352755f, 0.04473879f, 
    -0.01900025f, -0.11343308f, -0.05720770f, -0.00467317f, 0.11437371f, 0.04651359f, 0.06397719f, 0.12411638f, 
    -0.03720788f, -0.02618803f, -0.05929257f, 0.08751392f, -0.27959061f, 0.26173827f, 0.13282035f, -0.16071223f, 
    -0.14948553f, -0.02355915f, -0.00353408f, -0.06499374f, 0.09661010f, -0.03880389f, 0.08547191f, -0.03221338f, 
    -0.09348125f, 0.02320122f, -0.04643062f, -0.02288600f, 0.02380492f, -0.12142218f, -0.01037770f, 0.03307430f, 
    -0.05664841f, 0.03613650f, -0.02639183f, -0.07448591f, -0.15402438f, -0.08573432f, -0.18224682f, 0.03496541f, 
    -0.05139915f, 0.03883125f, -0.03341855f, 0.05203927f, -0.07080711f, 0.02562172f, 0.02032176f, 0.03029622f, 
    -0.02408507f, 0.02899070f, 0.17022781f, -0.01834890f, 0.05295999f, -0.01260049f, 0.03234182f, 0.03411911f, 
    -0.11089335f, -0.09440567f, -0.11208979f, -0.01773090f, -0.03328590f, -0.04243103f, -0.07165101f, 0.02372515f, 
    -0.00566833f, -0.04340321f, 0.11316562f, -0.04688564f, 0.03571938f, 0.03939328f, -0.01391944f, 0.02639889f, 
    0.17436630f, 0.28092468f, -0.03771908f, -0.01072167f, -0.06862056f, -0.10285449f, -0.02180279f, -0.01797917f, 
    -0.00710589f, -0.02841011f, -0.06610440f, -0.07896356f, -0.01056370f, -0.03884620f, 0.04035924f, -0.02031099f, 
    -0.04015013f, 0.13379154f, 0.05746045f, 0.03927417f, -0.03680245f, -0.25471649f, -0.07272257f, 0.23455766f, 
    0.41008198f, 0.07788967f, 0.15062936f, 0.07406519f, 0.00351087f, 0.06412588f, 0.00325272f, -0.07893879f, 
    0.03381354f, -0.27487847f, -0.05071574f, -0.02471738f, -0.03875609f, 0.00606296f, 0.05049153f, -0.10225400f, 
    0.15295707f, 0.03244895f, 0.28688017f, -0.07052212f, 0.09229077f, 0.06349175f, 0.00969051f, -0.07984383f, 
    0.05038911f, 0.03523954f, 0.08346257f, 0.01745237f, 0.00010394f, 0.02721169f, -0.04912346f, 0.00305442f, 
    -0.02248604f, -0.06587578f, -0.01137266f, 0.02832351f, 0.25033703f, 0.06779501f, 0.25935352f, 0.05691906f, 
    0.10999434f, -0.05952419f, 0.04686462f, -0.00955854f, -0.13388434f, 0.04676813f, 0.00922395f, 0.02925310f, 
    -0.07572568f, -0.05216231f, 0.03588601f, -0.04437384f, 0.05241874f, -0.00893026f, 0.10307851f, 0.01576286f, 
    0.25100350f, -0.29943958f, -0.31732699f, 0.13358086f, 0.12064744f, 0.08220583f, -0.04454187f, 0.04607226f, 
    -0.03829267f, 0.00645548f, 0.04800902f, -0.05430453f, -0.00809710f, -0.03739588f, -0.09179500f, 0.00397178f, 
    0.09317015f, 0.09602518f, -0.00306068f, -0.02970612f, -0.16195180f, -0.35013711f, -0.27371961f, 0.07668863f, 
    -0.01790573f, -0.13355266f, -0.12856601f, -0.03086988f, 0.05888079f, -0.09519611f, -0.08612709f, 0.01952556f, 
    -0.12002672f, 0.00339510f, 0.00642428f, 0.04363069f, -0.19436345f, 0.01711091f, -0.03932393f, -0.00093209f, 
    -0.00960098f, 0.13114247f, -0.15451434f, 0.00850428f, -0.23773019f, 0.00036694f, 0.00767407f, 0.05157826f, 
    -0.05136627f, 0.03756925f, -0.05692251f, 0.02808378f, 0.10242473f, 0.00721984f, 0.00054597f, 0.06487308f, 
    -0.03794429f, 0.04125676f, -0.03378711f, 0.04636027f, 0.06004158f, 0.09352057f, 0.09880300f, 0.21411598f, 
    -0.00065963f, -0.04009568f, -0.00393173f, -0.02256930f, -0.01806260f, 0.02882851f, -0.02811344f, 0.01046397f, 
    -0.00165501f, -0.03149053f, 0.05870850f, 0.01737032f, 0.09453999f, -0.01030383f, -0.06670275f, -0.06719135f, 
    -0.53877032f, 0.46371344f, -0.07029748f, -0.04890831f, -0.18920207f, -0.14220008f, -0.07946513f, 0.07606183f, 
    0.05700712f, 0.04683314f, 0.01913949f, -0.01654047f, -0.11137524f, 0.01396922f, -0.10635563f, -0.00270801f, 
    0.00533962f, -0.05225649f, 0.23227426f, 0.03960142f, 0.05922469f, 0.13191167f, 0.22918865f, 0.07913528f, 
    -0.09770646f, -0.11479428f, -0.02277599f, 0.00630765f, -0.02079164f, 0.05578079f, 0.07775708f, 0.01877498f, 
    -0.00280561f, -0.04646300f, -0.06995246f, -0.08226918f, 0.02510059f, 0.08924354f, 0.12513430f, -0.00433285f, 
    -0.27304277f, 0.03555588f, -0.04595753f, 0.08059829f, 0.34007511f, 0.07336465f, 0.16957031f, 0.01315312f, 
    0.05000561f, 0.00463821f, -0.05983916f, 0.07856658f, -0.09587060f, 0.03060473f, -0.01208155f, 0.02511870f, 
    0.02766561f, -0.00509170f, 0.10946001f, 0.00188259f, 0.23702504f, 0.08484914f, 0.05611717f, 0.29985264f, 
    0.00765761f, -0.04670812f, -0.03730283f, -0.10980521f, 0.01627629f, 0.06494802f, -0.06447854f, -0.05269689f, 
    0.00535336f, 0.04576499f, 0.02441367f, 0.00400817f, 0.03620268f, 0.05523811f, 0.04601355f, -0.01578158f, 
    0.09395881f, 0.07796924f, 0.16601446f, 0.10556725f, -0.01648053f, -0.07486451f, 0.03672129f, 0.05551538f, 
    -0.05289297f, 0.05818931f, -0.08077392f, -0.02227636f, -0.02148193f, -0.12269006f, 0.02604259f, 0.07800875f, 
    0.04302594f, 0.11543944f, 0.06990132f, 0.04350031f, 0.17474803f, 0.03058621f, -0.30861682f, 0.12841885f, 
    0.00088146f, -0.01606874f, 0.24669786f, -0.10992714f, 0.02891909f, -0.07672873f, 0.02243468f, 0.06125292f, 
    -0.12441900f, -0.07787564f, -0.00302788f, -0.03928274f, 0.06743187f, -0.00847431f, 0.08916321f, -0.04846239f, 
    -0.31806856f, -0.10216504f, -0.00529666f, -0.19230057f, -0.02737623f, -0.02393855f, 0.09260962f, -0.14700580f, 
    0.03824376f, -0.09387137f, -0.07073124f, -0.15206668f, 0.00860213f, 0.06386506f, 0.17635091f, -0.09711836f, 
    -0.01576797f, -0.13116397f, -0.16448088f, -0.12540437f, -0.04237541f, -0.07705085f, 0.06653438f, -0.05802859f, 
    0.16668890f, -0.00608799f, -0.07193449f, 0.00828362f, -0.07197703f, -0.02745963f, 0.01096198f, 0.05487971f, 
    -0.16922173f, -0.00428398f, 0.00934561f, -0.07139096f, -0.04968046f, -0.04975488f, 0.10609151f, -0.05605837f, 
    -0.08501488f, -0.24098895f, 0.06796921f, -0.01633037f, 0.09581865f, -0.03996181f, 0.07611392f, -0.03581049f, 
    -0.04656681f, 0.13700221f, 0.01341426f, -0.03105714f, -0.00871057f, -0.13743103f, -0.09724363f, 0.12624900f, 
    0.00149585f, -0.11307097f, 0.10600848f, 0.05597758f, -0.48042390f, 0.14267452f, -0.17281044f, -0.10138658f, 
    0.12515846f, 0.05786109f, -0.03325270f, 0.01613819f, 0.05849633f, 0.00265968f, 0.10444470f, 0.02724584f, 
    -0.06568382f, 0.09712935f, -0.03970746f, 0.03271059f, -0.10723776f, 0.09032532f, 0.11308245f, 0.03584236f, 
    -0.16091838f, 0.16590600f, -0.24865092f, 0.22853266f, -0.07872573f, 0.30699846f, -0.06431931f, 0.04358961f, 
    -0.00729056f, 0.09662435f, 0.00382155f, -0.06875864f, 0.02575376f, 0.01451823f, -0.01520694f, -0.03651646f, 
    -0.03194454f, 0.06765965f, -0.16032697f, -0.03959573f, -0.13869140f, 0.19530438f, -0.02294583f, 0.01166633f, 
    0.06907285f, 0.02083084f, 0.01951093f, -0.00705116f, 0.19833502f, 0.01397274f, 0.02709967f, 0.03780791f, 
    0.00553940f, -0.01518675f, -0.05104117f, -0.14756601f, -0.11174668f, 0.10680984f, -0.08090093f, -0.06123330f, 
    0.31288692f, 0.55002606f, -0.30647901f, -0.39308372f, -0.09953476f, -0.00807033f, 0.07220906f, 0.04842639f, 
    0.07905183f, -0.01671527f, 0.00481074f, 0.09760925f, -0.10694957f, 0.01518561f, 0.03501063f, -0.08355685f, 
    0.16156693f, 0.07023540f, 0.00789767f, 0.04685709f, -0.21493930f, -0.22622396f, -0.02718824f, 0.07127398f, 
    -0.10537843f, -0.24415705f, -0.10479337f, -0.03413320f, -0.03509842f, 0.00444528f, -0.12043677f, -0.02054854f, 
    0.09010673f, -0.12335584f, -0.01847897f, -0.08523492f, -0.04373078f, 0.04755194f, -0.03682248f, 0.05513415f, 
    0.40248239f, -0.18373184f, -0.03475928f, -0.16315237f, -0.18556871f, -0.04113710f, 0.02587644f, 0.07786614f, 
    -0.04841996f, 0.00865201f, -0.04720936f, 0.02603618f, 0.12742090f, -0.01317727f, -0.02914916f, 0.07353172f, 
    -0.00054110f, -0.03417350f, 0.01900703f, -0.06107206f, -0.84049475f, -0.04617276f, 0.01173816f, 0.11399310f, 
    0.31914359f, 0.05253737f, 0.04175615f, 0.05005283f, 0.11053424f, 0.06219257f, -0.02291475f, -0.04324315f, 
    0.03292783f, 0.10177441f, 0.03727267f, -0.05807329f, 0.16719086f, 0.07312530f, 0.10462063f, -0.08032061f, 
    0.01707424f, -0.03415217f, -0.21617095f, 0.16356769f, 0.25116727f, 0.05750858f, 0.03250094f, 0.09019056f, 
    0.09269895f, -0.05156626f, -0.00612552f, -0.07022268f, 0.03680128f, 0.10253435f, -0.03278070f, -0.05420460f, 
    0.09232738f, -0.07830638f, 0.07980406f, 0.00724436f, 0.20686744f, -0.12051151f, 0.10170781f, -0.02567023f, 
    -0.13563474f, -0.00235702f, -0.09685204f, 0.02680785f, -0.05023505f, -0.10058938f, 0.05181915f, 0.01629171f, 
    -0.10057753f, -0.10379656f, -0.12858747f, -0.05310441f, 0.15213449f, -0.11256291f, 0.04109180f, -0.01226483f, 
    -0.04828678f, -0.22925155f, 0.05392153f, 0.03546494f, 0.07752905f, -0.00852439f, -0.01130035f, -0.02753457f, 
    0.12260126f, 0.06053987f, 0.02686568f, 0.02836731f, -0.03141903f, -0.03418108f, 0.01219465f, 0.02852116f, 
    0.15567040f, -0.12194583f, 0.05426102f, 0.01988257f, -0.54000962f, 0.11296537f, 0.30117926f, 0.21704052f, 
    0.08291818f, 0.00197092f, 0.04370804f, 0.06592400f, -0.04227249f, -0.08926506f, 0.09252621f, -0.05157962f, 
    -0.10757895f, -0.06656887f, 0.09058444f, 0.03157834f, 0.03960535f, -0.04988695f, -0.02326420f, -0.01856201f, 
    0.12939383f, 0.15960081f, 0.08093023f, -0.02734302f, -0.02999518f, 0.04401387f, 0.01675446f, -0.10527857f, 
    0.10122275f, 0.05774048f, -0.00148399f, 0.02527118f, -0.01547875f, -0.00063884f, 0.05084042f, -0.03758831f, 
    0.10968273f, -0.05417340f, 0.02232925f, -0.05029875f, 0.19004810f, 0.30446976f, -0.09372355f, -0.18132092f, 
    -0.02325351f, 0.00473087f, -0.04022335f, 0.08549204f, 0.15857524f, -0.00340446f, -0.04281460f, 0.01712299f, 
    -0.10347514f, -0.04212779f, -0.04148864f, -0.02257682f, 0.00544609f, -0.18542641f, -0.13037387f, 0.00586151f, 
    -0.42192680f, 0.02048403f, -0.01810185f, 0.00147308f, 0.11687314f, 0.05802298f, -0.03610813f, -0.00712022f, 
    0.04451737f, 0.10632394f, 0.02174356f, 0.05626761f, -0.02288550f, -0.00436050f, -0.07103205f, -0.01319798f, 
    0.03632444f, 0.04635158f, 0.07746156f, -0.16347954f, -0.33896217f, 0.32231405f, -0.14039524f, 0.06464240f, 
    0.08900744f, 0.17557198f, -0.08299562f, 0.05159759f, 0.17733444f, 0.13145846f, -0.06824090f, 0.03071689f, 
    -0.00432912f, -0.02967628f, -0.11169624f, 0.06603640f, -0.01622973f, 0.02779599f, 0.07679065f, -0.18175793f, 
    0.10876259f, -0.11393949f, 0.21968250f, -0.01929397f, -0.15529752f, 0.04156132f, 0.15689386f, -0.07623859f, 
    0.14176099f, -0.08633541f, 0.14934076f, 0.01381562f, 0.08569227f, -0.00701934f, 0.12364324f, 0.00342111f, 
    -0.01729371f, -0.04250811f, -0.04128984f, 0.18562652f, -0.39296451f, -0.66663367f, 0.14764269f, 0.30196220f, 
    -0.07772986f, -0.26823446f, -0.03684358f, -0.02385291f, -0.16012755f, -0.01968631f, 0.09227362f, 0.09103448f, 
    -0.03932378f, -0.14120194f, 0.10140886f, 0.00960811f, -0.17182115f, 0.06807663f, -0.00056619f, 0.09484955f, 
    0.09754357f, 0.01122192f, -0.08851078f, 0.07985912f, -0.28826442f, -0.17344330f, 0.06087812f, -0.00815384f, 
    -0.02063419f, -0.11757997f, 0.05764152f, -0.02842972f, 0.03596183f, 0.05945492f, -0.09957627f, -0.13070415f, 
    0.11335555f, 0.08595546f, 0.13287303f, 0.16366792f, 0.19152544f, 0.06199694f, -0.22024038f, 0.13752043f, 
    -0.20982221f, -0.01369147f, -0.17504150f, -0.04899167f, -0.06236156f, -0.04627744f, 0.03800588f, 0.17130668f, 
    -0.05145501f, -0.05501728f, 0.06188632f, -0.08077590f, 0.07456006f, 0.09337380f, 0.04297529f, 0.02044847f, 
    -0.19096956f, 0.11637868f, 0.17765272f, 0.12687151f, -0.02157442f, -0.07046448f, -0.02083681f, -0.07186057f, 
    0.02133648f, 0.02289592f, 0.05727751f, 0.03092480f, 0.07686868f, 0.04414232f, -0.03832125f, -0.08382923f, 
    0.11642076f, 0.02667555f, -0.02739397f, 0.08527181f, -0.13383633f, -0.03851780f, -0.00918163f, -0.10976555f, 
    0.01273697f, -0.05266554f, 0.11958633f, -0.01287691f, -0.02149504f, 0.02766382f, 0.13631180f, 0.02498732f, 
    0.03203687f, -0.02202966f, -0.01720702f, 0.15311402f, 0.01706736f, -0.09798194f, -0.06409635f, -0.07137417f, 
    -0.12931687f, 0.15352841f, -0.21211658f, 0.13275222f, -0.09705049f, -0.00609497f, -0.09947871f, 0.04053261f, 
    -0.04981142f, -0.00906466f, -0.11709898f, -0.01588997f, 0.01831762f, 0.00831264f, 0.16309686f, -0.00288514f, 
    -0.11801604f, 0.11043208f, -0.02679220f, -0.06488170f, 0.28329834f, -0.20655008f, -0.06237508f, 0.05363367f, 
    0.17801811f, -0.05426553f, -0.02341208f, -0.06905551f, -0.03239761f, -0.13000882f, 0.05476580f, 0.03401460f, 
    -0.10969055f, -0.01964608f, 0.09970298f, -0.05108198f, -0.10171595f, -0.21270213f, -0.09487364f, 0.01172697f, 
    -0.28224173f, -0.12384176f, 0.05526350f, 0.13192461f, 0.08198485f, 0.18824954f, -0.18436764f, 0.24701862f, 
    -0.01552522f, 0.04594753f, -0.03244681f, -0.12607382f, -0.06520467f, 0.08675497f, 0.00368915f, 0.03073432f, 
    0.00034456f, 0.01251859f, 0.12110576f, -0.11457100f, 0.02797281f, -0.11939184f, -0.08127039f, 0.17275383f, 
    0.05704132f, 0.03475018f, 0.06607999f, -0.01509786f, 0.08233220f, 0.01885486f, 0.11425191f, 0.02037277f, 
    -0.09565774f, 0.01496653f, 0.06882729f, -0.08218622f, 0.03550098f, 0.04567318f, 0.16741949f, 0.04945478f, 
    -0.07338849f, -0.14614341f, 0.26977611f, 0.23973723f, -0.06767480f, -0.13458645f, -0.06661829f, 0.18333681f, 
    0.01839378f, -0.04951073f, 0.04956656f, 0.00222143f, 0.04298202f, -0.07101685f, 0.07642844f, 0.02433371f, 
    -0.15878822f, 0.08747572f, -0.02717125f, -0.00095821f, -0.09506115f, 0.40034992f, 0.14289536f, -0.02741693f, 
    -0.33537161f, 0.02684598f, 0.01089551f, -0.07571229f, 0.03391036f, -0.09063176f, -0.00442893f, -0.03552464f, 
    0.02401311f, 0.14622208f, 0.11253139f, -0.08948939f, 0.00092639f, -0.02973995f, -0.25308111f, 0.14040501f, 
    0.02974716f, 0.05476793f, -0.23997787f, 0.11935530f, 0.00688094f, -0.03652537f, -0.02202437f, -0.03082766f, 
    0.01843620f, -0.05125098f, 0.00323593f, 0.02185365f, 0.01694281f, -0.03051452f, 0.13130309f, 0.08425748f, 
    0.06035149f, -0.01809859f, 0.07105914f, 0.07835519f, -0.39427164f, 0.02611109f, 0.07856349f, -0.26897177f, 
    -0.07932045f, 0.14588621f, -0.01278062f, -0.06361896f, -0.12701420f, -0.17290743f, 0.05348649f, -0.08646227f, 
    -0.16213869f, -0.02623383f, -0.13078530f, -0.00821245f, -0.12157520f, -0.15060771f, -0.08232314f, -0.09321587f, 
    0.04305895f, -0.02777595f, -0.10056289f, 0.19545065f, 0.01009150f, -0.07301764f, 0.06798879f, 0.10373195f, 
    0.10400932f, 0.11062818f, 0.00405938f, -0.02835491f, 0.01629649f, 0.03494793f, -0.05970108f, 0.01451261f, 
    0.08762854f, 0.02766366f, 0.06884077f, -0.02010880f, 0.25908816f, -0.08398879f, -0.12955616f, -0.01087836f, 
    0.12236236f, -0.00393761f, -0.03358836f, 0.05558257f, 0.08957087f, -0.03050069f, -0.03101311f, 0.02584906f, 
    0.00714422f, 0.24729213f, 0.17265703f, -0.02510783f, -0.08434442f, 0.16850239f, -0.37731186f, 0.16610242f, 
    0.01572353f, 0.04761238f, -0.01570829f, 0.08074416f, -0.33078954f, -0.06795563f, 0.13915944f, -0.06662641f, 
    -0.04383981f, -0.01239088f, -0.00580628f, 0.02802462f, 0.05988690f, 0.01383999f, 0.03781896f, 0.00606530f, 
    0.13269918f, 0.09965833f, 0.02951503f, 0.05963020f, -0.54795414f, -0.12992702f, -0.19710824f, -0.09162049f, 
    -0.02778478f, 0.02260743f, 0.11432377f, 0.02334377f, 0.03166186f, -0.14513434f, 0.00831719f, 0.01899966f, 
    0.12918010f, -0.17506310f, 0.04850287f, 0.09590325f, 0.09805988f, -0.07667317f, -0.01491943f, -0.04470132f, 
    0.22190523f, 0.19139884f, 0.25212070f, -0.08222653f, -0.17399260f, -0.04195347f, -0.04531470f, -0.08788374f, 
    -0.00835167f, 0.04819477f, 0.12847576f, 0.03132132f, 0.03954462f, -0.08187439f, 0.01216311f, 0.09788271f, 
    0.00864017f, -0.04325959f, 0.08498036f, -0.02881993f, -0.26790562f, -0.20111370f, -0.08361861f, -0.08112784f, 
    0.20033887f, 0.02719327f, -0.09369561f, 0.03918143f, -0.05331652f, 0.01757764f, 0.04470017f, 0.07798929f, 
    0.04979832f, 0.13526957f, 0.06796430f, 0.15265083f, 0.02586380f, 0.00173857f, -0.24712285f, -0.03109856f, 
    -0.34370673f, -0.30638838f, 0.42659742f, 0.26369700f, -0.55324620f, 0.03054679f, 0.00684662f, -0.00535376f, 
    -0.06102093f, -0.06872942f, -0.04469335f, -0.00174626f, 0.03818043f, -0.07779817f, 0.13186751f, -0.11943281f, 
    0.02745679f, 0.04186720f, 0.04002158f, -0.02561633f, -0.13603711f, 0.12263468f, -0.01312578f, -0.02140175f, 
    -0.24365436f, 0.00387236f, -0.04551682f, -0.04089414f, -0.02043931f, 0.12496496f, -0.01626622f, -0.01728012f, 
    -0.13071303f, 0.01690889f, 0.01391542f, 0.02968405f, -0.11820611f, -0.00914467f, 0.12242062f, 0.06321458f, 
    0.02739251f, 0.20657507f, 0.07598340f, 0.09781083f, 0.10292640f, -0.01138930f, -0.09603602f, -0.04112818f, 
    -0.10584919f, 0.08231349f, -0.11149850f, -0.05174866f, -0.05162146f, -0.07954099f, 0.05597517f, 0.08825517f, 
    -0.01019134f, 0.09594493f, 0.08410171f, -0.02105268f, -0.27127165f, 0.20768204f, -0.40857419f, -0.19217819f, 
    -0.09421919f, 0.14821330f, 0.09577283f, 0.10958407f, -0.05145532f, -0.16269723f, 0.00230358f, -0.05472183f, 
    -0.04901350f, -0.10359342f, -0.06697010f, 0.03457544f, -0.09643579f, -0.04116733f, 0.03776986f, 0.01231440f, 
    -0.16127135f, 0.18204358f, 0.11599606f, -0.13148963f, -0.26779246f, 0.05036127f, -0.03680572f, 0.11528222f, 
    -0.12004016f, -0.05365595f, 0.15980032f, -0.16589576f, -0.06461187f, -0.07090508f, -0.06789238f, 0.09271470f, 
    -0.04688229f, 0.17270797f, -0.04780189f, 0.00430130f, -0.08738642f, -0.14745767f, 0.10155817f, 0.12824307f, 
    0.09694485f, -0.07315817f, -0.05821213f, 0.06706762f, -0.11202905f, 0.06143780f, 0.14045928f, -0.13228714f, 
    -0.03605343f, -0.00673354f, -0.05623757f, 0.02721057f, -0.03964096f, -0.12534697f, 0.04618703f, 0.11082423f, 
    0.03844935f, -0.01764528f, 0.09552256f, 0.13182287f, 0.08285687f, 0.07315004f, 0.08098751f, 0.02128623f, 
    -0.05092077f, 0.03288809f, 0.00667913f, -0.19961508f, 0.09007455f, -0.05568872f, 0.01825233f, 0.03901869f, 
    0.07052831f, -0.04631178f, 0.11474062f, 0.09572113f, 0.11308180f, -0.08243400f, -0.01559509f, 0.02927561f, 
    -0.23141751f, -0.11339322f, 0.04382909f, -0.03466674f, 0.09056830f, -0.02962603f, 0.00293120f, 0.12159243f, 
    0.06923655f, 0.02603514f, 0.09700284f, -0.11601418f, -0.10784088f, 0.04735479f, 0.10221643f, 0.03295565f, 
    0.25626206f, 0.11416873f, 0.14322336f, 0.02788222f, 0.11417484f, -0.00334359f, 0.05834263f, 0.05821299f, 
    -0.12343570f, -0.01493971f, -0.04603067f, -0.00403938f, -0.00416652f, 0.11014667f, 0.01269218f, 0.09728986f, 
    -0.15887362f, 0.11722428f, 0.02657161f, 0.11247899f, -0.39229381f, -0.28516266f, 0.06791490f, 0.07175199f, 
    -0.34167466f, 0.15088999f, -0.04713784f, -0.05988995f, -0.07775957f, -0.02085654f, 0.02201127f, -0.01790260f, 
    -0.00281520f, -0.00971544f, -0.11316729f, -0.09002566f, 0.00607219f, 0.07212194f, 0.00767372f, -0.01475565f, 
    -0.77003264f, -0.19265229f, -0.33012739f, -0.21095255f, 0.00870780f, 0.10763942f, 0.07309123f, 0.02854062f, 
    0.06075808f, -0.15194556f, 0.12076733f, 0.01661058f, 0.12053773f, 0.02255932f, 0.01187338f, 0.00633230f, 
    -0.02878542f, -0.11909167f, -0.04239740f, 0.07100992f, -0.53176844f, -0.18640664f, -0.28187048f, -0.10336632f, 
    -0.06685171f, 0.13110761f, 0.08841399f, -0.10568453f, 0.00843186f, -0.06832822f, 0.05428610f, 0.05027869f, 
    -0.15885168f, -0.02619281f, -0.05559352f, -0.12799522f, 0.04852602f, 0.11450233f, -0.05379145f, 0.01640413f, 
    -0.07005566f, 0.02976958f, -0.01583419f, 0.11266392f, -0.02957496f, -0.07662732f, 0.06527430f, 0.00620950f, 
    -0.10681125f, 0.13636725f, -0.04069742f, 0.11668542f, 0.13388886f, 0.08307166f, 0.00773993f, -0.09237126f, 
    -0.00770031f, -0.10485714f, -0.13293977f, 0.04868124f, 0.08595336f, 0.12416829f, 0.07038219f, 0.12672001f, 
    0.29468292f, -0.22030813f, -0.10040639f, -0.10630687f, 0.09127838f, 0.03823456f, -0.07366263f, -0.22891137f, 
    0.01100622f, 0.04402739f, 0.21288893f, -0.01787189f, 0.14488475f, -0.01187227f, -0.09332805f, -0.05676968f, 
    0.05204729f, 0.07148173f, 0.01312655f, 0.08147188f, 0.31853601f, -0.15642031f, -0.22903283f, 0.07212810f, 
    0.01305949f, 0.06593427f, -0.03000019f, -0.18569484f, -0.01660761f, 0.04815419f, -0.03514212f, 0.00085041f, 
    -0.11067604f, -0.11000711f, -0.06332330f, 0.07459275f, 0.02814843f, -0.15261896f, 0.11820091f, -0.13078156f, 
    0.10548277f, 0.05938385f, -0.07715952f, -0.03537459f, 0.01345956f, 0.14146958f, -0.00104649f, -0.05149772f, 
    0.05986810f, 0.04718911f, -0.02292518f, 0.12613487f, -0.22575684f, -0.03522070f, -0.19310638f, 0.04686156f, 
    -0.00438487f, -0.05722042f, 0.02274923f, 0.14920200f, 0.11356434f, -0.06113428f, -0.01951001f, -0.00320088f, 
    -0.00014776f, -0.12033698f, -0.05527744f, 0.08363055f, 0.02137526f, 0.06351018f, 0.06617998f, -0.06019658f, 
    -0.01906096f, -0.02609769f, 0.02414506f, -0.08982186f, -0.12695037f, 0.08530541f, 0.20132156f, 0.03937721f, 
    0.01910455f, -0.02784939f, 0.02655931f, 0.05407638f, -0.09850102f, -0.07860184f, 0.01578071f, 0.05710968f, 
    -0.13269947f, -0.02290104f, 0.13882612f, -0.04891236f, 0.05186483f, 0.11054087f, -0.08073939f, -0.01386720f, 
    0.02913955f, 0.21607283f, -0.07160093f, -0.21806523f, 0.04595882f, -0.01210524f, 0.02663805f, -0.06809338f, 
    -0.02976508f, -0.12386463f, 0.10133465f, 0.03945299f, -0.03173383f, -0.12092820f, 0.00363902f, -0.05299344f, 
    0.05356713f, 0.02289523f, 0.17477852f, -0.05344354f, -0.00270788f, -0.17263046f, 0.09575511f, 0.17467059f, 
    -0.06138052f, 0.01385683f, 0.02228677f, -0.02213719f, 0.00897400f, 0.12115037f, 0.09280346f, -0.06678408f, 
    -0.01595642f, 0.05705585f, -0.20183702f, 0.06733192f, 0.07327602f, 0.09433365f, -0.10694324f, 0.09846590f, 
    -0.42989060f, 0.01209230f, -0.05579743f, 0.03051830f, -0.00884032f, -0.05361568f, 0.07561477f, 0.03022160f, 
    -0.10329766f, -0.07513905f, 0.18406826f, 0.05991196f, 0.00778834f, -0.01983191f, -0.12903523f, -0.05672722f, 
    0.00044847f, -0.08822735f, 0.03808605f, 0.06016405f, -0.01595806f, 0.18802269f, -0.23742430f, 0.06256986f, 
    0.17274666f, 0.12085713f, -0.02503365f, -0.08329052f, 0.00759262f, 0.05544614f, 0.01879777f, 0.05137922f, 
    0.13384698f, -0.03534007f, 0.11407506f, -0.08088093f, 0.04010069f, 0.00088134f, -0.19674425f, -0.13602398f, 
    0.13410249f, 0.08149636f, 0.09329377f, 0.06193103f, -0.16498710f, -0.13483371f, -0.08336964f, 0.03032619f, 
    0.11696142f, 0.01193236f, -0.07973941f, -0.02077405f, 0.03973117f, 0.15071990f, 0.13374647f, -0.16923186f, 
    -0.11698994f, 0.06572662f, 0.07901727f, -0.08839511f, -0.02622689f, -0.08686416f, -0.10010979f, -0.00879996f, 
    0.13571104f, 0.02887580f, 0.11231718f, 0.01422835f, 0.03993541f, -0.01747356f, 0.06616960f, 0.02154267f, 
    0.05621798f, -0.05969806f, 0.01989676f, -0.13397679f, 0.02608573f, -0.14803058f, 0.09260130f, -0.02605342f, 
    -0.07840022f, 0.01083732f, 0.05367824f, -0.00789174f, 0.14059445f, 0.08960183f, 0.03636150f, -0.04587990f, 
    -0.03376908f, 0.12451720f, 0.04572960f, 0.11764161f, 0.08975447f, 0.05692881f, -0.02880314f, -0.03322221f, 
    -0.05706719f, -0.00899045f, -0.22376402f, 0.05634394f, -0.57007223f, -0.06371597f, -0.00353504f, 0.40655419f, 
    -0.10386398f, -0.09018716f, -0.07480583f, -0.07252996f, 0.00722590f, 0.15907483f, 0.15658475f, -0.05041900f, 
    0.04716109f, 0.08718212f, -0.00030366f, 0.02863225f, 0.01318850f, -0.09039579f, -0.14609182f, -0.25636986f, 
    0.10536639f, -0.05036122f, -0.14979388f, 0.28015816f, -0.04537883f, -0.05243365f, 0.09663960f, -0.09727032f, 
    -0.03990185f, -0.17496501f, 0.05245278f, -0.00167736f, -0.05102072f, 0.02572028f, -0.08036340f, -0.02808768f, 
    -0.07062694f, 0.06692032f, -0.20984206f, -0.02273964f, 0.12971725f, -0.10005245f, 0.02458761f, 0.06689078f, 
    0.00730104f, 0.01143776f, 0.15589821f, -0.02643050f, -0.11130039f, -0.11732117f, 0.04433267f, -0.05599329f, 
    0.00220444f, -0.06743928f, -0.02144477f, 0.00370681f, 0.01607695f, 0.09728406f, 0.06649756f, -0.01548601f, 
    -0.19794658f, 0.31079096f, -0.00848508f, 0.12294620f, -0.06338282f, -0.01503761f, -0.12300596f, -0.06346863f, 
    0.08426657f, -0.12033691f, 0.06918991f, 0.01627930f, -0.00379137f, 0.01093958f, 0.03673758f, 0.04289256f, 
    -0.04850009f, -0.14744627f, 0.01090391f, -0.13583840f, 0.18394731f, -0.40857738f, 0.00551167f, -0.24007262f, 
    0.06514716f, -0.15674853f, 0.10874355f, 0.02261494f, 0.00952391f, 0.01513852f, 0.04669940f, 0.02074633f, 
    0.04676617f, 0.09812252f, 0.02333410f, -0.02392245f, 0.03235293f, 0.02273288f, -0.13377056f, 0.09653857f, 
    -0.10023504f, 0.00432492f, -0.28182012f, 0.10740422f, 0.04570784f, -0.27549818f, 0.06711854f, 0.08828273f, 
    0.07064698f, 0.06065930f, -0.01003045f, -0.00164107f, 0.02106884f, -0.01544210f, 0.07067841f, -0.13731860f, 
    -0.02435855f, 0.16448535f, -0.15381736f, 0.02383893f, -0.06736311f, 0.16710752f, -0.13357711f, -0.25582623f, 
    0.08734395f, 0.07448350f, 0.01010227f, -0.08336888f, -0.11535554f, -0.04903806f, 0.02876102f, -0.02759593f, 
    -0.09599326f, -0.10348906f, 0.01589322f, -0.19358565f, -0.03213774f, 0.19284053f, 0.03096178f, 0.12790421f, 
    0.30394351f, -0.15113690f, -0.11159829f, 0.00656147f, 0.24783507f, 0.01137591f, 0.00171675f, 0.01945926f, 
    0.04399258f, 0.11377553f, 0.01273592f, 0.03900875f, -0.08968218f, -0.02429791f, -0.10090102f, 0.15161328f, 
    0.01749627f, -0.05272412f, -0.08424556f, 0.06333569f, 0.06267928f, 0.16455869f, -0.13201655f, 0.18539563f, 
    -0.15478070f, -0.02878178f, 0.04435207f, 0.01853643f, -0.03090885f, 0.02170108f, 0.00103135f, 0.02050770f, 
    0.07357325f, -0.02324416f, 0.00523127f, 0.04590710f, -0.08218787f, 0.13765839f, -0.12642531f, -0.01791560f, 
    -0.51419473f, 0.21373589f, -0.14252318f, 0.21987379f, -0.04235688f, 0.03110542f, 0.02421991f, -0.05879232f, 
    0.08257122f, -0.02524221f, 0.09521692f, -0.01618024f, 0.04733484f, -0.04380110f, -0.09163980f, 0.01107448f, 
    -0.01616758f, -0.08799687f, 0.00818228f, 0.08614461f, 0.11797738f, -0.48146585f, 0.03168978f, -0.35767290f, 
    0.11201500f, -0.04023935f, -0.00253289f, -0.01161158f, -0.09162503f, -0.10672770f, -0.05528543f, -0.05825326f, 
    0.16952956f, 0.08296654f, -0.00931603f, 0.04073315f, -0.00078932f, -0.04003040f, -0.06431823f, 0.03013779f, 
    0.29074940f, -0.59514332f, -0.15342177f, -0.04369792f, -0.16154358f, -0.10888649f, 0.12088729f, -0.05452615f, 
    -0.04310869f, 0.04761611f, -0.09027506f, 0.03576021f, 0.04423477f, 0.11954330f, 0.16216917f, 0.03822340f, 
    -0.04315758f, -0.03775559f, -0.13448897f, -0.06275200f, -0.09560497f, -0.01278185f, -0.10490404f, 0.21504569f, 
    -0.14361382f, 0.10711645f, 0.09317645f, 0.09874842f, 0.03691311f, 0.02031381f, -0.14301218f, -0.06655225f, 
    0.01819673f, 0.06449202f, -0.16322196f, 0.03809306f, -0.08321548f, 0.12890480f, -0.05475715f, -0.03301626f, 
    -0.47668812f, 0.34277639f, 0.10605478f, 0.16297927f, -0.47793087f, -0.01908549f, 0.00384090f, -0.03904099f, 
    0.09212814f, 0.01765520f, 0.05468006f, 0.09543387f, 0.04052782f, 0.02014248f, 0.00900416f, -0.08248512f, 
    -0.20558640f, -0.11926430f, -0.09499674f, -0.20116033f, -0.04109141f, 0.06742716f, 0.16348660f, 0.00750290f, 
    -0.24262030f, 0.25451279f, -0.01230238f, 0.11901772f, -0.00822734f, -0.03826893f, -0.12591980f, 0.01263074f, 
    -0.01619665f, 0.11495136f, -0.11533277f, 0.07560114f, 0.12142929f, 0.07215717f, 0.00178722f, -0.18607207f, 
    -0.26454550f, 0.09011158f, 0.03065124f, 0.15941745f, 0.01735515f, -0.00423686f, -0.02029045f, -0.03066563f, 
    0.05018572f, 0.05568318f, -0.07936939f, -0.04735171f, 0.03515367f, -0.01406418f, 0.16106474f, 0.01486538f, 
    0.08007450f, -0.21061035f, -0.00719639f, -0.20863956f, 0.36525840f, -0.38061038f, -0.06713793f, 0.17128070f, 
    0.01330067f, -0.05536690f, -0.11261702f, 0.03916973f, 0.00660913f, 0.08810785f, -0.01633629f, 0.04642372f, 
    -0.08930048f, -0.14028606f, 0.06073955f, -0.02283987f, 0.10213415f, -0.01657780f, -0.00766542f, -0.06538360f, 
    -0.12138879f, -0.26056919f, 0.03038826f, -0.13352306f, 0.16059378f, -0.03754769f, 0.06702858f, 0.11640165f, 
    -0.12480022f, -0.01679947f, -0.00528602f, -0.00904889f, 0.06227385f, 0.13522908f, 0.06555425f, -0.05762137f, 
    -0.02337201f, -0.01317421f, -0.00005868f, 0.07839329f, 0.17495784f, 0.04082678f, 0.11176650f, -0.48927420f, 
    0.29021651f, -0.04905141f, -0.12901565f, 0.02919521f, -0.07397051f, -0.06010982f, 0.08359300f, -0.13688000f, 
    0.16326050f, -0.04945580f, -0.04358744f, -0.01402580f, -0.03108421f, -0.04031655f, 0.09977087f, 0.12656863f, 
    -0.09151607f, 0.00522668f, 0.11576314f, -0.07060417f, 0.23058952f, -0.02877370f, 0.02859056f, -0.03914492f, 
    -0.07750590f, -0.01664601f, -0.09329992f, 0.02994938f, -0.09727544f, -0.01015868f, 0.07766951f, 0.05962394f, 
    0.00321917f, 0.03764720f, 0.05352672f, 0.06950436f, -0.11695463f, 0.38744056f, -0.02927730f, -0.03892377f, 
    -0.26260057f, 0.10305975f, 0.07203961f, -0.00356775f, 0.02461924f, 0.08500352f, 0.06158961f, 0.08297017f, 
    -0.13596490f, 0.09019805f, -0.18914744f, 0.09116705f, -0.03720407f, 0.08170171f, 0.12935239f, 0.04104355f, 
    -0.08173200f, -0.08510162f, -0.10989338f, 0.00258381f, 0.10860667f, -0.02535639f, 0.12148899f, -0.09957922f, 
    -0.05273480f, 0.08716692f, -0.14183332f, -0.03486523f, 0.19847520f, -0.00913032f, -0.08296290f, 0.17184985f, 
    0.04555834f, 0.10043436f, 0.07454865f, -0.00162391f, -0.03435673f, -0.21201071f, -0.01741564f, -0.11070887f, 
    0.04737866f, 0.06730261f, 0.06405817f, 0.10990752f, 0.00066452f, 0.02928323f, 0.03938736f, -0.08434934f, 
    0.04652637f, 0.05871273f, -0.09801642f, 0.00351991f, 0.08948869f, -0.08296178f, 0.18928692f, -0.05672059f, 
    -0.17523625f, 0.33954373f, 0.08973732f, 0.05473237f, -0.41770586f, -0.04904646f, 0.05514506f, 0.09420416f, 
    0.09207033f, 0.04449481f, 0.02070431f, 0.06124417f, 0.00087592f, -0.05147580f, 0.05989632f, 0.02782041f, 
    -0.11118236f, -0.04651778f, -0.02688375f, 0.13994791f, -0.18190084f, 0.01716978f, 0.00391117f, 0.09173690f, 
    0.15534236f, -0.05398470f, -0.04920586f, 0.00261128f, 0.16078156f, 0.04105049f, -0.07458436f, -0.00162483f, 
    -0.01981660f, 0.06395148f, 0.02662270f, -0.11270306f, -0.02498109f, -0.05840724f, -0.05944976f, 0.02402334f, 
    -0.18532196f, -0.34869871f, 0.00612519f, -0.22063388f, 0.30206797f, -0.02419944f, -0.02254427f, -0.02826109f, 
    -0.00804770f, 0.00256593f, -0.06571347f, -0.06327237f, -0.02715107f, 0.14429511f, -0.06383471f, 0.09814616f, 
    -0.08365583f, -0.06977613f, -0.00506324f, 0.09901177f, -0.22256207f, 0.01387259f, 0.06511543f, -0.15557688f, 
    -0.23349029f, 0.07618219f, -0.01623491f, 0.10380016f, -0.06779359f, 0.07299533f, -0.01373654f, 0.00381837f, 
    -0.03824049f, -0.13374747f, 0.02284677f, -0.01392975f, -0.07279368f, -0.04184519f, 0.09978689f, -0.00839694f, 
    -0.11727326f, -0.30672476f, -0.10526033f, 0.03868176f, -0.02543276f, 0.02169270f, -0.07230744f, 0.05781356f, 
    -0.08882827f, -0.02314060f, -0.15002052f, -0.04327653f, -0.04671002f, 0.08451107f, 0.00138479f, 0.00187887f, 
    -0.11423873f, 0.11827728f, -0.18478890f, 0.04236583f, -0.08974116f, 0.13343810f, -0.16572092f, -0.58305454f, 
    -0.01634048f, -0.06216333f, 0.03566039f, 0.10602134f, 0.03398425f, -0.01419852f, -0.12279553f, 0.06217909f, 
    -0.19858451f, -0.07985426f, 0.01178641f, 0.04838100f, -0.12074018f, 0.05577083f, 0.09407435f, 0.07275729f, 
    -0.11493345f, 0.21696247f, 0.03884690f, -0.13883735f, -0.19656222f, 0.11803685f, -0.00414887f, 0.14485288f, 
    -0.05193273f, 0.04290501f, 0.00017434f, 0.07735738f, -0.00947597f, -0.01329082f, -0.16953847f, 0.04192375f, 
    0.06746066f, -0.01685715f, 0.00437736f, 0.09421973f, 0.06817653f, -0.28504133f, -0.24727827f, 0.02761996f, 
    0.02905407f, -0.11496448f, 0.12986292f, 0.02454714f, 0.03347390f, -0.11630122f, -0.03072486f, 0.00443802f, 
    0.02009203f, 0.02176065f, 0.05073863f, 0.07740771f, 0.01976564f, 0.18557513f, -0.20656051f, 0.15755649f, 
    -0.27965888f, 0.08095162f, -0.24049944f, -0.10886654f, 0.01980489f, 0.03696478f, -0.03706988f, 0.05332049f, 
    -0.05166642f, -0.01391059f, -0.06772216f, -0.05572095f, -0.07490630f, -0.05536964f, -0.04559294f, 0.08128708f, 
    0.06971712f, 0.05990525f, 0.06441283f, 0.02683066f, 0.17219184f, -0.14870003f, 0.00351253f, 0.08827619f, 
    0.57481229f, 0.04813083f, 0.00362329f, 0.05332039f, -0.01251756f, -0.11975524f, -0.22296757f, 0.01356225f, 
    -0.05357346f, -0.03820289f, 0.07701875f, -0.06415802f, -0.12193883f, 0.17261909f, 0.09435373f, 0.14622113f, 
    -0.22743829f, 0.12665032f, -0.03820405f, -0.08995057f, -0.05478537f, 0.08797985f, -0.07491113f, 0.02330408f, 
    0.00769113f, -0.00367984f, -0.13907975f, 0.05380043f, -0.02712256f, -0.04633845f, -0.03820258f, -0.02294018f, 
    -0.01336865f, 0.01923640f, 0.01907085f, -0.01426318f, 0.17035681f, -0.22161584f, 0.11924705f, 0.06159936f, 
    0.06343642f, 0.02528606f, -0.00504778f, -0.05860418f, -0.09724270f, 0.01895222f, -0.05212948f, 0.02462204f, 
    0.01199611f, -0.09145319f, -0.00768573f, -0.11545095f, 0.02287378f, 0.00826494f, 0.15914969f, 0.04495727f, 
    -0.10358144f, -0.19540374f, -0.10159746f, -0.28039074f, -0.16526701f, 0.06713635f, 0.00033944f, 0.00586770f, 
    -0.08356585f, -0.12110788f, 0.00034639f, -0.12658295f, -0.09916873f, 0.00533467f, -0.04190165f, -0.03811541f, 
    -0.01523614f, -0.01644205f, 0.02398274f, 0.03048016f, -0.05230341f, 0.10355268f, 0.20420672f, 0.10368884f, 
    0.23177689f, 0.10011361f, 0.08686630f, -0.04082843f, -0.04446926f, -0.08098958f, -0.10751586f, 0.03162960f, 
    0.09985274f, 0.00610224f, -0.01587533f, -0.01804801f, 0.04911466f, -0.03100438f, 0.00646040f, -0.02724972f, 
    0.05106971f, 0.31102344f, -0.06249443f, -0.19045079f, -0.12267810f, -0.15212189f, -0.06835035f, -0.00963890f, 
    -0.02202944f, -0.03183115f, -0.00827775f, 0.09264543f, -0.03432813f, 0.10761697f, -0.03163471f, 0.03723921f, 
    -0.06772116f, 0.00504987f, -0.01606999f, 0.04065971f, 0.14802162f, 0.16011924f, 0.17214480f, 0.13226922f, 
    0.14848046f, -0.09710134f, 0.06036177f, -0.09517183f, -0.03439755f, -0.01700376f, 0.00185867f, 0.03951849f, 
    -0.08099762f, -0.01233709f, -0.04734209f, -0.06574608f, -0.07103644f, 0.01147779f, 0.00132083f, -0.04069570f, 
    0.03779377f, -0.00803123f, -0.08060167f, 0.12656294f, -0.10871534f, 0.13243833f, 0.00547318f, -0.01152559f, 
    -0.06704967f, 0.00936794f, -0.03470638f, 0.04031864f, 0.03135690f, -0.05338448f, -0.10633370f, 0.10793392f, 
    0.08067368f, -0.00197099f, -0.02628933f, 0.01913409f, -0.11917629f, 0.10621871f, -0.13694051f, -0.11651795f, 
    -0.18368365f, 0.10389797f, -0.03798655f, -0.13819437f, 0.10643197f, -0.02298146f, -0.09465794f, 0.01265003f, 
    -0.03321435f, -0.06513748f, 0.04235956f, -0.06406230f, -0.04561565f, 0.03469175f, 0.00031804f, 0.04929031f, 
    -0.34432954f, 0.07681138f, 0.05204397f, -0.18496434f, -0.25025508f, -0.00378644f, 0.06270633f, -0.05862971f, 
    -0.05470831f, -0.01971240f, 0.02935814f, -0.02849042f, -0.03437889f, -0.08826109f, -0.02730926f, 0.05318042f, 
    -0.01848185f, -0.06878646f, -0.06695354f, 0.03786856f, 0.16018854f, 0.09257642f, 0.28530583f, 0.13231744f, 
    0.17515928f, 0.02911977f, 0.08948037f, -0.02230220f, -0.01341504f, -0.04066924f, -0.04789835f, 0.07372309f, 
    -0.02870006f, -0.01056395f, -0.11450659f, -0.03618504f, -0.02135433f, 0.01946907f, 0.01438563f, -0.05834341f, 
    -0.05864399f, 0.09526315f, 0.08734126f, 0.04630764f, -0.04894598f, 0.07758890f, -0.00399618f, 0.00082431f, 
    0.05769951f, -0.05517559f, -0.01629107f, 0.04232405f, 0.10246452f, -0.05361804f, -0.05913096f, 0.03931744f, 
    -0.11537433f, 0.01026584f, 0.04555661f, -0.04971854f, -0.12319838f, 0.15198250f, -0.06657162f, 0.02505199f, 
    0.09899059f, -0.00886815f, 0.04052730f, -0.10964097f, 0.09114554f, -0.06020601f, 0.02602961f, 0.08760958f, 
    0.01711510f, 0.01323459f, -0.07041527f, -0.05553223f, -0.05292291f, -0.05753091f, -0.05522542f, -0.02245730f, 
    -0.40705630f, -0.00327498f, 0.01077274f, -0.19304259f, -0.32548738f, -0.01283918f, -0.01505650f, -0.01847906f, 
    -0.03690111f, -0.12920032f, -0.03549038f, -0.09764402f, -0.03646540f, -0.04261145f, -0.05415870f, -0.05187640f, 
    0.04146293f, -0.00015755f, -0.04069296f, 0.04740075f, 0.20167039f, -0.50625020f, 0.11293989f, -0.05801510f, 
    -0.21352018f, 0.02795419f, -0.06676159f, 0.00138622f, -0.04042447f, -0.07509425f, -0.10611857f, -0.05562222f, 
    -0.10195969f, 0.03057302f, -0.08222342f, -0.03736395f, -0.01243161f, -0.04855391f, -0.04095766f, -0.07178704f, 
    -0.04970786f, -0.26214203f, -0.15588184f, -0.16228348f, -0.15331027f, -0.07001784f, -0.15235344f, 0.00499313f, 
    -0.10084955f, -0.00860726f, 0.09641602f, -0.03765053f, -0.08612751f, 0.02410507f, -0.02837097f, -0.04409410f, 
    -0.04660271f, -0.10131792f, -0.02502699f, -0.03885345f, 0.27431017f, -0.33843690f, 0.08736248f, 0.11711546f, 
    -0.19861066f, 0.13193016f, -0.07063773f, -0.03032052f, -0.12880541f, 0.04336296f, -0.01917755f, 0.01955560f, 
    -0.08853336f, -0.00012900f, -0.00623949f, -0.06419974f, 0.09559603f, -0.01355759f, 0.03504146f, -0.00306021f, 
    0.15879296f, -0.02176573f, 0.28888232f, 0.00432665f, -0.01274987f, 0.06538834f, 0.04008765f, -0.03591602f, 
    -0.06693884f, -0.05365970f, -0.06992345f, 0.08314893f, -0.03362632f, 0.07905765f, -0.07046102f, 0.00082464f, 
    0.01047887f, 0.00231666f, 0.10330949f, -0.02993985f, 0.27198845f, 0.04535494f, 0.27373913f, -0.00916368f, 
    0.18414780f, -0.02649882f, 0.08365642f, -0.04952898f, 0.01500172f, -0.06689139f, -0.05871717f, -0.02297279f, 
    -0.12270620f, -0.01180544f, 0.01453211f, -0.01551316f, -0.00032105f, 0.04041500f, 0.08807396f, -0.10087851f, 
    -0.10041161f, 0.11516621f, 0.03587008f, 0.04887757f, 0.11478776f, 0.13335741f, -0.08948606f, -0.06858249f, 
    0.04043470f, -0.00192835f, 0.00491365f, 0.04162881f, -0.00564967f, -0.04362966f, 0.00066389f, -0.02514751f, 
    -0.03424867f, 0.00975266f, 0.06855254f, -0.07344948f, -0.16081980f, 0.09803566f, -0.52775985f, -0.01191348f, 
    0.10164914f, -0.03028352f, -0.08520698f, -0.04759982f, -0.03553320f, 0.00703645f, -0.09447558f, 0.12150501f, 
    0.10750364f, -0.07732671f, -0.03401667f, -0.11518706f, 0.01351441f, 0.02328349f, 0.00513300f, 0.12920597f, 
    0.04836090f, 0.29659092f, -0.14327656f, 0.14630401f, 0.07416679f, -0.10174731f, 0.09428210f, -0.06156400f, 
    0.03662790f, 0.02604603f, -0.13498925f, -0.06203781f, -0.00606750f, -0.09583776f, -0.07814933f, -0.02890339f, 
    0.07285149f, 0.08107806f, -0.06428605f, -0.00955788f, 0.12103690f, 0.26186398f, 0.06069722f, 0.18175624f, 
    0.23426563f, -0.09590486f, 0.11920591f, -0.07552509f, 0.05096487f, -0.00715799f, -0.13152349f, 0.00032094f, 
    0.00915516f, -0.01312727f, -0.00165509f, -0.02968865f, 0.05038293f, 0.06533501f, -0.02200481f, 0.07697240f, 
    -0.24626562f, 0.03855469f, -0.36036444f, 0.06058022f, 0.04552915f, -0.03287945f, -0.11262879f, 0.03377226f, 
    -0.00758334f, -0.10475404f, -0.07318606f, -0.01034022f, 0.01537170f, 0.09043994f, -0.15609801f, 0.00896101f, 
    -0.09431515f, -0.01511134f, -0.00570457f, -0.06174391f, -0.03882308f, -0.03194937f, -0.10238982f, -0.10250898f, 
    -0.11722443f, -0.11964223f, -0.04868954f, -0.01271421f, 0.00543683f, -0.04471559f, 0.05125305f, -0.01079205f, 
    -0.03263843f, -0.11876757f, -0.02259764f, 0.00922045f, -0.07042251f, -0.03554977f, -0.09334973f, -0.05025134f, 
    0.00068812f, 0.08333737f, 0.19513732f, -0.08786231f, 0.12171086f, -0.12147653f, 0.10693670f, 0.08915604f, 
    -0.01192486f, 0.02297356f, -0.03723167f, 0.00334401f, -0.07738893f, -0.06406880f, 0.01216110f, -0.03775916f, 
    0.04080658f, 0.08563786f, -0.01523306f, 0.05863183f, 0.08823270f, -0.06121045f, -0.06160843f, 0.08971327f, 
    -0.05531783f, 0.02395511f, 0.01900526f, -0.11531354f, -0.05833959f, 0.00215157f, -0.05176237f, -0.02446614f, 
    -0.07552324f, -0.05365443f, -0.06512126f, -0.11921821f, 0.04745102f, -0.00819152f, -0.06486715f, -0.04925565f, 
    0.08642220f, -0.30774257f, 0.11763825f, 0.10167982f, -0.03867597f, 0.13310498f, -0.06293897f, -0.08599444f, 
    -0.01508121f, -0.03816401f, -0.04768431f, 0.06957713f, 0.00617512f, 0.09948610f, -0.18487227f, 0.04025615f, 
    0.06894395f, 0.03289256f, -0.04628118f, 0.02664046f, 0.12594838f, 0.06548815f, 0.15675062f, 0.17410801f, 
    0.24570549f, 0.00337010f, 0.08899880f, 0.00903588f, -0.04945875f, -0.03965973f, -0.03510865f, 0.09977020f, 
    -0.03874541f, -0.02264764f, -0.10578079f, 0.01750446f, -0.05230748f, -0.11715908f, 0.01983771f, -0.00455314f, 
    -0.03186712f, -0.41625795f, 0.05252529f, -0.09619572f, -0.06913359f, 0.02276016f, -0.16338353f, -0.04638597f, 
    -0.04224336f, -0.04424415f, -0.06942209f, -0.01860012f, -0.06528243f, -0.03301619f, -0.13962784f, -0.02274492f, 
    0.09062337f, -0.02029637f, 0.02852351f, 0.00828315f, -0.29791048f, 0.27352914f, -0.23799366f, 0.13917494f, 
    0.12529567f, -0.16895899f, -0.04385494f, 0.00649681f, 0.03108435f, -0.04582820f, 0.06743472f, 0.08878464f, 
    -0.00991881f, 0.05576089f, -0.14052922f, 0.03505575f, -0.04074778f, 0.08481605f, 0.03000043f, -0.04563836f, 
    0.11832983f, 0.16880146f, 0.12958375f, 0.06130617f, 0.22006713f, -0.00816976f, -0.02463454f, -0.11410302f, 
    -0.02683718f, -0.06898153f, -0.07633983f, 0.00128257f, -0.02431189f, -0.04732070f, -0.06321457f, -0.00126003f, 
    -0.02300758f, -0.04742753f, 0.03384567f, -0.01018068f, -0.21546327f, 0.20037052f, -0.33207974f, 0.14099400f, 
    0.27002031f, -0.02073001f, -0.03840939f, -0.15891284f, 0.08957452f, -0.01317700f, -0.13617648f, 0.02499049f, 
    -0.10145812f, 0.03253581f, 0.01030700f, -0.00599374f, -0.16909140f, -0.00073707f, -0.09314830f, 0.02051547f, 
    0.19550966f, 0.05420696f, -0.12782066f, 0.03076024f, -0.02935202f, -0.01668996f, -0.01873797f, -0.00907448f, 
    0.00719876f, -0.00396167f, 0.07309069f, 0.09017548f, 0.07592436f, 0.07285311f, 0.05429272f, 0.09809624f, 
    -0.01250411f, 0.00662523f, 0.09281818f, 0.05538888f, -0.03716509f, -0.24054839f, 0.18268295f, -0.20278339f, 
    -0.14364652f, -0.01384782f, -0.07160673f, 0.03377204f, -0.13433470f, -0.13447629f, 0.05452843f, 0.02392787f, 
    0.01140512f, 0.08894709f, -0.00272759f, 0.04105752f, 0.02618560f, -0.02036986f, -0.33148676f, 0.09966774f, 
    0.19525051f, 0.20297807f, -0.06270118f, 0.10377695f, 0.17914939f, 0.11601059f, 0.04398279f, -0.09361188f, 
    -0.05694657f, -0.05395310f, 0.07287440f, -0.03199286f, -0.03388038f, 0.02102552f, -0.14562438f, -0.06375431f, 
    -0.02175125f, 0.07021217f, 0.03296480f, -0.13416564f, -0.13108490f, -0.20940422f, 0.19953060f, -0.03465089f, 
    0.07224610f, -0.07884209f, 0.00266668f, -0.01934266f, -0.11668539f, 0.01272794f, 0.00150140f, -0.07292879f, 
    0.02891603f, -0.17034744f, 0.07865278f, -0.05454099f, -0.06945204f, -0.03213855f, 0.01417461f, 0.05402777f, 
    0.22348915f, 0.09034263f, 0.15825799f, 0.04643287f, -0.03476916f, -0.05016334f, 0.08139471f, -0.11182094f, 
    -0.02917780f, -0.09110247f, 0.05859149f, 0.02911920f, -0.00085200f, -0.14756899f, 0.03422082f, -0.14896001f, 
    0.06317028f, -0.03186345f, 0.10377161f, -0.13523477f, -0.23374072f, 0.04522667f, 0.26743352f, -0.20952004f, 
    -0.19321594f, -0.02468016f, 0.02719898f, -0.04202303f, 0.02629164f, -0.04294555f, 0.01677200f, 0.00872643f, 
    0.00252271f, 0.08379627f, 0.01258029f, -0.03120659f, 0.05806911f, -0.00187030f, -0.27808660f, 0.01842869f, 
    -0.08458169f, -0.07071854f, -0.04456898f, -0.09598649f, -0.03379108f, 0.07095237f, -0.14860587f, -0.09309629f, 
    -0.04174481f, -0.07194946f, 0.10715172f, -0.00910086f, 0.02470111f, -0.02631895f, 0.11698523f, -0.04350893f, 
    0.02435979f, -0.03419607f, 0.01932331f, -0.02641970f, -0.04010769f, 0.17214884f, -0.09711269f, -0.01569425f, 
    -0.09498499f, 0.01253909f, 0.00255395f, -0.13008243f, 0.02787575f, -0.07790598f, 0.12035872f, 0.07230492f, 
    0.05715535f, 0.06955906f, 0.09701062f, -0.08428046f, 0.06758592f, -0.06110121f, 0.09115014f, -0.11641322f, 
    0.09940952f, 0.14575201f, -0.18468226f, 0.08908605f, -0.03469559f, 0.06110704f, -0.01377714f, -0.09997439f, 
    -0.03450686f, -0.06261462f, 0.04343538f, 0.04524530f, 0.05190280f, -0.07534490f, 0.04642337f, -0.01208458f, 
    -0.06574404f, 0.03507658f, 0.11883990f, -0.05786724f, -0.15016378f, -0.12055560f, 0.21202393f, -0.00546241f, 
    0.17829381f, -0.10916172f, -0.04320174f, 0.15729941f, -0.07722826f, 0.04350931f, 0.03184687f, -0.05492669f, 
    -0.04684607f, -0.07585835f, 0.06042942f, 0.00427419f, 0.03772419f, 0.00024664f, 0.01770351f, 0.02610880f, 
    0.09102944f, -0.01427876f, 0.03397932f, 0.07083227f, 0.17205490f, -0.11959127f, -0.07968790f, -0.05802216f, 
    -0.05224110f, 0.08488518f, -0.11813233f, -0.04497449f, -0.13595870f, -0.06329268f, 0.02188009f, -0.05272621f, 
    0.08322224f, 0.07334115f, 0.07776945f, -0.01728765f, 0.07226816f, 0.17432684f, -0.38470539f, 0.04523362f, 
    -0.01178341f, 0.03913008f, -0.03453423f, -0.23668030f, -0.08689129f, 0.01074653f, 0.04067207f, 0.05301449f, 
    0.03637796f, -0.02363197f, 0.11514242f, -0.06167590f, -0.16947059f, -0.05353430f, 0.05428113f, 0.00853589f, 
    0.10872347f, 0.04877432f, -0.27290243f, 0.10765797f, 0.19544518f, 0.12639144f, 0.11660731f, -0.08487096f, 
    -0.09729885f, -0.06149032f, -0.10071695f, -0.05117071f, 0.03829625f, -0.02549196f, -0.04486738f, -0.01142609f, 
    0.03943791f, 0.02550173f, 0.07169778f, -0.06399063f, 0.01535758f, -0.06008076f, -0.27714449f, 0.11338322f, 
    0.06953948f, 0.04612690f, -0.05719325f, -0.01792995f, -0.05615656f, -0.03313699f, -0.01612551f, 0.00252237f, 
    -0.07990783f, 0.11498138f, -0.00375768f, 0.03618522f, -0.05077847f, 0.01510202f, 0.07268843f, -0.02152218f, 
    0.20050535f, 0.16757500f, -0.04630025f, 0.09886822f, 0.13245358f, 0.03845131f, 0.05565600f, -0.11638488f, 
    -0.08933631f, -0.03187042f, -0.00573705f, 0.03107949f, -0.07661854f, -0.06583551f, -0.00691727f, -0.14174353f, 
    0.01254145f, 0.10603848f, 0.09922851f, -0.03622378f, 0.05897956f, -0.07996039f, 0.11545795f, -0.01306078f, 
    0.14931788f, -0.06195660f, -0.01103385f, -0.07194185f, -0.08755648f, 0.08782154f, -0.07441849f, 0.01741571f, 
    0.07292062f, -0.12792991f, 0.02029653f, -0.01989521f, -0.00637361f, 0.05163277f, 0.02405371f, 0.06241272f, 
    -0.10374003f, -0.12207334f, 0.20736392f, 0.04116984f, 0.13691786f, -0.12009421f, 0.10150904f, 0.03466513f, 
    -0.09554034f, -0.00569031f, 0.06099935f, -0.06870834f, 0.01453602f, 0.02365382f, -0.03300447f, 0.04351063f, 
    -0.06393859f, -0.01438319f, -0.01436559f, 0.02847862f, -0.25682396f, 0.23969239f, 0.13538158f, -0.21537256f, 
    -0.03437446f, 0.04951885f, 0.02598972f, -0.03543969f, 0.00024026f, -0.06215412f, 0.01820073f, -0.03241442f, 
    -0.12631142f, 0.01788591f, 0.05162288f, -0.00367993f, 0.10144854f, -0.04627283f, 0.01560941f, 0.00959487f, 
    -0.20426388f, -0.07072850f, -0.03759281f, -0.21627364f, -0.26207131f, 0.00348813f, -0.03283003f, -0.06875873f, 
    -0.02425176f, -0.08989044f, 0.04212829f, 0.01427762f, 0.03588869f, -0.05686371f, -0.08293287f, -0.08646646f, 
    -0.08005069f, -0.18630818f, -0.04602677f, 0.05278737f, -0.10239194f, -0.11280472f, -0.28232235f, -0.36417973f, 
    -0.05810419f, 0.11875428f, 0.02784664f, -0.01709057f, 0.04394315f, -0.06913868f, 0.13042267f, 0.05924100f, 
    0.00643484f, 0.07130384f, -0.01428325f, 0.06185598f, 0.04404344f, 0.09218179f, -0.00559382f, -0.02058578f, 
    -0.23307994f, 0.04223779f, -0.18782361f, -0.12387636f, -0.21078476f, -0.10249956f, 0.02172528f, -0.01197983f, 
    -0.12237521f, -0.06249498f, 0.12190975f, 0.01295528f, 0.03571860f, 0.16785036f, 0.01582838f, -0.03351704f, 
    0.09785157f, -0.08628358f, 0.04495032f, 0.00529333f, -0.30073082f, 0.02955000f, -0.09262589f, -0.33040291f, 
    -0.38769993f, 0.02849505f, 0.05407206f, -0.02505565f, 0.01094956f, -0.08589897f, 0.10595372f, -0.01503374f, 
    -0.05206279f, 0.09234403f, -0.02521485f, -0.09999768f, 0.01759277f, -0.16089240f, -0.03261123f, -0.02732716f, 
    -0.06270443f, -0.14121409f, -0.06048488f, 0.16255261f, 0.18098845f, 0.10340784f, 0.04014589f, -0.09085660f, 
    -0.06658632f, -0.04377503f, 0.06651692f, 0.03347742f, 0.14712237f, -0.03984701f, 0.09839283f, -0.05671384f, 
    0.07216080f, 0.02915932f, 0.01712566f, -0.12305820f, 0.14607346f, 0.15050259f, -0.10596465f, 0.07174119f, 
    0.06827264f, 0.01417875f, 0.06221067f, 0.03437613f, -0.01506441f, -0.00186204f, 0.06978136f, 0.14647011f, 
    -0.09092368f, 0.04192190f, -0.00313807f, -0.02561765f, -0.02753808f, 0.01197386f, 0.08495726f, 0.01659637f, 
    0.00838568f, 0.16640668f, 0.07276154f, -0.09711744f, -0.06532211f, -0.07417395f, -0.01082131f, 0.02151260f, 
    -0.06673722f, -0.04757939f, 0.09327964f, -0.00721385f, -0.06739790f, -0.03587573f, -0.07285322f, -0.06326440f, 
    0.00136073f, 0.00917174f, 0.13336118f, 0.01773963f, -0.00385930f, -0.03741525f, 0.15265562f, -0.26278472f, 
    -0.02479362f, 0.01406284f, -0.04546851f, 0.04672110f, 0.02005058f, -0.01419442f, 0.05769032f, -0.00204571f, 
    0.09103596f, -0.01488808f, 0.02048864f, -0.06874556f, -0.05277199f, -0.00043703f, -0.08257818f, -0.04695972f, 
    0.14424689f, 0.00853081f, 0.07299151f, 0.11662667f, 0.14679796f, -0.21403699f, -0.04251368f, -0.07280745f, 
    -0.18488908f, 0.17323510f, -0.08791106f, -0.05978781f, 0.00959025f, -0.05295717f, -0.02564484f, 0.08098956f, 
    -0.03193532f, -0.00687340f, 0.10866103f, -0.05427074f, -0.23920216f, -0.22217600f, 0.14197789f, -0.40588662f, 
    -0.23271544f, 0.04763576f, 0.06610570f, -0.03739983f, -0.03423431f, -0.01084215f, 0.05152785f, 0.06316359f, 
    -0.01383765f, 0.01701789f, -0.13124119f, -0.19827279f, 0.07478886f, 0.01699985f, -0.34194893f, -0.15712211f, 
    -0.16311917f, -0.09514676f, -0.09592559f, -0.03709158f, 0.17670114f, 0.10503877f, 0.02699312f, -0.11023057f, 
    -0.04607807f, 0.03282480f, 0.07264908f, 0.06040651f, -0.02906892f, 0.09773806f, 0.09668798f, -0.01242536f, 
    0.02087323f, 0.07248056f, 0.01162833f, -0.03579191f, 0.13341574f, 0.06447152f, 0.03831907f, 0.02948803f, 
    -0.07469801f, -0.16271932f, 0.10462475f, 0.01256002f, -0.14830732f, -0.05218752f, 0.07715771f, -0.11570839f, 
    0.09828794f, -0.04372022f, 0.17167024f, 0.01214614f, -0.00001875f, -0.10298268f, 0.17596975f, -0.08511890f, 
    -0.16160718f, 0.03634124f, -0.11597487f, -0.40623438f, -0.16144502f, 0.07865448f, -0.01086060f, -0.05578849f, 
    0.02906521f, -0.05522148f, 0.05769746f, 0.01867760f, -0.04193175f, -0.01627511f, -0.07284689f, -0.16501395f, 
    0.03056041f, -0.04529909f, -0.19319980f, -0.13731039f, -0.11074363f, 0.25319472f, 0.04571128f, -0.07852440f, 
    -0.04047432f, -0.14116105f, -0.05090062f, -0.09810206f, -0.16366574f, -0.16518292f, 0.08476038f, 0.03346393f, 
    -0.04561259f, 0.06249626f, -0.03728523f, -0.10277595f, 0.10091146f, 0.02116012f, -0.02954563f, -0.10270045f, 
    0.05517292f, 0.35755417f, -0.01891307f, -0.57362461f, -0.17768577f, 0.00784732f, -0.14159200f, 0.03620647f, 
    0.01424762f, 0.07197301f, -0.01142852f, -0.03227741f, 0.21867874f, -0.15225144f, -0.00953389f, 0.01878904f, 
    0.04139196f, 0.00022748f, -0.04973768f, -0.00302578f, -0.12197118f, -0.16646594f, -0.04819517f, 0.04296700f, 
    0.02506489f, -0.05942494f, 0.00339400f, -0.01379434f, -0.04327028f, 0.12685791f, 0.13435838f, -0.08037452f, 
    0.15517893f, -0.27288151f, -0.01035307f, 0.04051519f, -0.04942580f, -0.00564731f, 0.21204598f, 0.08000517f, 
    0.24470650f, -0.14667141f, 0.22230455f, -0.14716132f, -0.28660074f, 0.04338764f, 0.06025670f, 0.14881429f, 
    -0.01559343f, 0.01509816f, -0.01720158f, -0.07029121f, -0.09752578f, -0.02325292f, -0.01501819f, -0.03255724f, 
    -0.01526768f, -0.03432338f, -0.05101200f, 0.01874328f, 0.18705067f, -0.04690741f, -0.10428834f, 0.06087486f, 
    0.11408289f, 0.19155127f, -0.16110209f, -0.03772549f, -0.01141186f, 0.26525590f, -0.14027223f, 0.05544923f, 
    0.00619118f, 0.12086594f, 0.00676291f, -0.08737755f, -0.15237503f, -0.00760029f, 0.01758462f, -0.13000880f, 
    -0.50444007f, 0.29754928f, 0.25653204f, -0.08193568f, 0.17925261f, 0.05742981f, 0.09240153f, 0.00803402f, 
    0.00865597f, -0.10613953f, -0.06316537f, 0.05678847f, -0.03255092f, 0.04750501f, 0.06727870f, 0.00232968f, 
    0.07932155f, 0.01688000f, -0.14788102f, 0.12857497f, 0.09502183f, -0.21342169f, -0.08869088f, 0.19093463f, 
    0.08027537f, -0.01236580f, 0.11022855f, 0.09688783f, -0.21720040f, -0.14190756f, 0.15089121f, 0.08900403f, 
    -0.01778118f, -0.05726817f, 0.00132860f, -0.03891280f, -0.02541903f, -0.14332873f, 0.18799606f, 0.03152126f, 
    -0.15034413f, -0.33423156f, 0.06523228f, -0.17867020f, 0.19680780f, -0.03253419f, -0.06262305f, -0.10300772f, 
    0.00466599f, 0.00103412f, -0.02091260f, -0.19715960f, -0.04973192f, 0.11689753f, 0.07306460f, 0.07054240f, 
    -0.04053463f, -0.08040583f, -0.13169335f, -0.10683521f, -0.00581009f, -0.07594119f, 0.19691460f, -0.21715264f, 
    -0.19653670f, -0.07266921f, 0.04880438f, 0.07774775f, 0.07701903f, -0.00516183f, 0.03290061f, -0.06537563f, 
    0.07258424f, -0.00071842f, 0.07060878f, -0.00366628f, 0.12791081f, -0.08604412f, -0.03115917f, -0.06736732f, 
    -0.17760055f, -0.08114254f, 0.25008291f, -0.02663350f, -0.14144546f, -0.02490165f, 0.09534074f, 0.06302697f, 
    -0.01795811f, -0.05367105f, 0.00700433f, 0.01843073f, -0.01088244f, -0.02104847f, -0.02574704f, 0.09998626f, 
    -0.02170972f, 0.00508543f, -0.15217620f, -0.06983331f, 0.20631121f, -0.14017263f, -0.19452806f, 0.20463756f, 
    -0.05739843f, 0.04193502f, 0.04241419f, -0.11802283f, -0.00020694f, 0.11493899f, -0.02947783f, 0.03549604f, 
    -0.01295307f, 0.03933104f, 0.07356852f, -0.01087558f, -0.05171899f, 0.04007261f, 0.06932532f, 0.01820458f, 
    -0.12908381f, -0.12891047f, -0.27793151f, -0.00011150f, 0.04082741f, 0.15198104f, 0.04408439f, -0.02705604f, 
    -0.06387396f, 0.10086110f, 0.03048186f, -0.02989034f, 0.02570222f, 0.05687981f, -0.02509694f, -0.09317028f, 
    0.00653221f, -0.06758799f, 0.14926229f, -0.00644223f, -0.58910203f, 0.14461820f, 0.10994404f, 0.00716457f, 
    -0.03050879f, 0.01064194f, 0.01604749f, -0.01920527f, 0.00121729f, -0.07425178f, 0.08414365f, -0.02076681f, 
    -0.01254969f, 0.06462091f, -0.02459300f, 0.09377827f, -0.04553494f, 0.22137322f, 0.04482632f, 0.12371483f, 
    -0.17249614f, -0.06878215f, 0.21843970f, -0.05098089f, -0.21179770f, 0.05183587f, 0.18401439f, -0.13737333f, 
    -0.17787997f, -0.08359212f, -0.07543189f, 0.00290945f, -0.10899428f, 0.00148219f, -0.05655873f, -0.05527231f, 
    -0.08591840f, 0.13774826f, -0.13414037f, 0.03929745f, 0.25263637f, -0.41025305f, 0.17838854f, -0.02555220f, 
    -0.06048351f, -0.02035451f, -0.01802708f, -0.08634934f, 0.02916494f, 0.00803895f, -0.00157638f, -0.03849770f, 
    -0.01984698f, -0.12499800f, 0.05900485f, 0.00066016f, -0.05537738f, -0.04826503f, 0.06260077f, 0.14394759f, 
    -0.03701527f, -0.14771944f, -0.10157627f, 0.03783526f, -0.06260169f, 0.06466114f, 0.10856501f, -0.00940188f, 
    0.01987156f, -0.30878052f, 0.07735381f, 0.05308854f, -0.11797702f, 0.02286195f, -0.13821733f, 0.02927680f, 
    -0.06839983f, -0.19649163f, -0.07783316f, -0.06664163f, 0.32094738f, -0.27607957f, 0.08840750f, -0.09408935f, 
    -0.00731224f, 0.12635858f, -0.02238557f, 0.00442208f, -0.08580990f, -0.11409082f, 0.01913774f, -0.01355683f, 
    0.00551244f, 0.22638458f, 0.08042371f, 0.01206165f, -0.05136574f, 0.02788462f, 0.00756281f, 0.00581186f, 
    0.25784197f, -0.32259792f, -0.00979508f, 0.20269643f, -0.03917524f, -0.02106453f, -0.04256424f, -0.24571587f, 
    0.13152668f, 0.02858528f, -0.08770560f, 0.13527538f, -0.14712505f, -0.07771826f, -0.04092296f, -0.10669147f, 
    -0.00321977f, -0.03350035f, 0.04503387f, 0.06178934f, -0.19732608f, -0.12628952f, -0.21774785f, 0.18277290f, 
    -0.07120875f, -0.05925370f, 0.08539218f, -0.13872030f, -0.06839838f, 0.07170738f, -0.03124236f, 0.06178397f, 
    -0.00354526f, 0.07920905f, 0.17659128f, 0.03248215f, -0.07821565f, 0.01673128f, -0.01042271f, 0.02156526f, 
    -0.08214329f, -0.30632946f, -0.13410981f, 0.22360609f, 0.01428296f, -0.13344072f, 0.04473114f, 0.14215943f, 
    0.05656984f, -0.04892180f, -0.03521595f, 0.00439349f, -0.11246049f, 0.03703557f, -0.08785171f, 0.02970485f, 
    0.01843328f, 0.17950180f, 0.16703069f, 0.05481055f, 0.07824385f, -0.10997173f, 0.21683477f, -0.49093485f, 
    -0.70223999f, -0.03442577f, -0.01532395f, 0.14003630f, -0.07813802f, 0.13372973f, -0.05308585f, 0.03726341f, 
    -0.00767457f, -0.16756025f, -0.07887349f, -0.07641821f, -0.04831934f, -0.00622753f, 0.17260303f, -0.08013079f, 
    -0.38573962f, 0.15372333f, -0.18277264f, 0.05420779f, -0.28305426f, 0.14310525f, 0.06695945f, -0.10272467f, 
    -0.03282159f, -0.07347932f, -0.19586264f, -0.06678896f, -0.00897226f, -0.03292156f, 0.17139950f, 0.02197975f, 
    -0.11203097f, 0.07604586f, -0.04682098f, 0.01195206f, -0.16495764f, 0.08909886f, -0.10077721f, 0.04954135f, 
    0.00451685f, -0.12752898f, -0.03172133f, -0.04794484f, -0.09973837f, -0.06803664f, -0.02928490f, -0.06529448f, 
    0.04508399f, 0.03527814f, 0.22573386f, 0.23017825f, -0.00709639f, 0.13077767f, -0.06631687f, 0.12482879f, 
    -0.12291562f, 0.07059214f, 0.14101551f, -0.43052649f, -0.13672566f, -0.01756765f, 0.11142348f, -0.23855869f, 
    0.01003314f, 0.12144016f, -0.07755630f, 0.04406208f, -0.04847149f, -0.07341506f, -0.08091041f, 0.10597488f, 
    0.04338285f, 0.09580970f, 0.05026053f, 0.00723752f, 0.03047008f, 0.13150749f, -0.04265397f, 0.16011284f, 
    -0.31436655f, -0.02303739f, -0.00230209f, 0.08180530f, 0.01466179f, -0.11905536f, -0.10216077f, 0.11547653f, 
    0.02759248f, -0.06624766f, 0.10023535f, 0.00261672f, -0.00503156f, 0.05155782f, 0.12281253f, 0.08318842f, 
    -0.28305647f, 0.26082456f, 0.01904601f, 0.25829706f, -0.00705988f, 0.12336860f, -0.02568807f, 0.04881619f, 
    0.11662728f, 0.06000450f, -0.03597565f, -0.02906769f, 0.02912318f, 0.00068340f, 0.05665950f, 0.04477220f, 
    0.02692082f, 0.01316845f, -0.19324030f, 0.02333180f, 0.11694714f, -0.08497933f, -0.20280206f, 0.11701394f, 
    -0.30155963f, -0.10575157f, 0.00304998f, 0.17992893f, 0.11196551f, 0.04993594f, -0.01947740f, 0.00555596f, 
    0.18289670f, 0.00283397f, 0.05137530f, 0.21383986f, 0.03255455f, 0.10937345f, 0.07612336f, -0.11147296f, 
    0.57577378f, -0.61921471f, 0.06805535f, 0.03763121f, -0.07253458f, -0.07205296f, -0.04366330f, 0.02209475f, 
    0.17246717f, -0.06637263f, -0.05331201f, 0.16283798f, 0.05220829f, 0.00357433f, -0.00213450f, 0.00088285f, 
    0.03945940f, -0.07932364f, -0.00608831f, 0.10720682f, 0.21446677f, -0.18400720f, -0.17022938f, 0.02197568f, 
    -0.09508709f, -0.14201970f, 0.04238758f, 0.06633763f, -0.01963196f, 0.00276731f, 0.02725525f, -0.09829780f, 
    0.01888551f, 0.04833641f, -0.06342666f, 0.05269023f, 0.05799285f, 0.01640661f, 0.01487597f, -0.00022367f, 
    0.21817821f, -0.67113060f, 0.27565730f, -0.07376622f, -0.12332703f, -0.12502173f, 0.04771158f, -0.18070705f, 
    -0.07752487f, -0.08657034f, -0.03637345f, 0.05681118f, 0.11205363f, -0.23598127f, -0.06426253f, 0.02820967f, 
    0.07824337f, -0.05754832f, -0.09666726f, -0.01715677f, -0.63492179f, 0.53892213f, 0.07294244f, -0.05142997f, 
    0.04665036f, 0.12127021f, 0.05622274f, -0.08834320f, -0.02489879f, 0.23946342f, -0.07165950f, 0.06583259f, 
    -0.01488330f, -0.02516014f, -0.00246948f, 0.16267572f, -0.02369845f, 0.12085176f, -0.04779638f, -0.04836210f, 
    0.08256663f, -0.03680043f, 0.17696558f, 0.03674538f, -0.06503177f, -0.19498914f, 0.00780983f, -0.05454700f, 
    -0.02952548f, 0.06694525f, -0.01806635f, 0.00403346f, 0.02050795f, 0.04242545f, 0.16638565f, 0.03963144f, 
    0.07346674f, 0.01614140f, -0.04476663f, 0.04171420f, 0.75931472f, -0.02860938f, -0.43652251f, -0.28734004f, 
    -0.23603199f, 0.03231683f, -0.03040510f, 0.22852142f, 0.15553284f, -0.11383820f, -0.10599057f, -0.04734644f, 
    0.00961880f, 0.06314477f, -0.11536381f, 0.14589843f, 0.09291498f, 0.00612207f, -0.05933638f, 0.09564116f, 
    -0.09378934f, -0.11316884f, -0.13042638f, -0.07750746f, 0.07857470f, 0.03008806f, -0.00624050f, -0.00815693f, 
    -0.03363892f, 0.10903610f, 0.08071444f, -0.02946885f, 0.05991548f, 0.00221624f, -0.03229390f, 0.13111880f, 
    0.09355822f, 0.04632290f, 0.10531616f, 0.13101874f, 0.24139848f, 0.33501971f, 0.06399366f, -0.15737990f, 
    -0.01824429f, 0.10801107f, 0.02908159f, 0.13252763f, 0.07663532f, -0.03023310f, -0.04804607f, 0.05963321f, 
    0.04924143f, -0.03403873f, -0.10367519f, 0.10537706f, 0.03841687f, 0.10808779f, -0.12796359f, 0.11546350f, 
    -0.59152579f, -0.25315613f, -0.22053161f, -0.17653690f, -0.24988139f, 0.11803824f, -0.00524598f, -0.06459916f, 
    -0.08236474f, 0.03203771f, -0.10702582f, 0.08878674f, -0.08269144f, 0.09329442f, 0.03665360f, -0.03200214f, 
    0.06027787f, 0.13053711f, -0.05343441f, 0.09387709f, 0.21379486f, 0.21896832f, -0.11095613f, 0.12924793f, 
    -0.08931098f, -0.12715541f, -0.13440986f, 0.14626053f, -0.01584533f, 0.04897952f, -0.02143324f, -0.05716597f, 
    0.00863569f, -0.11778861f, -0.06193717f, 0.00157370f, 0.00339394f, 0.06850397f, 0.00476785f, -0.05223363f, 
    -0.42683265f, -0.36849189f, -0.12492040f, -0.15051423f, -0.13832970f, 0.02700556f, 0.04234390f, 0.04079347f, 
    -0.10804441f, -0.03556876f, 0.13515824f, -0.04556992f, -0.02787119f, -0.02002086f, 0.05252194f, 0.00694499f, 
    -0.20742168f, 0.05557543f, 0.11167490f, 0.06653604f, 0.29046881f, 0.09432383f, 0.07900990f, -0.12714648f, 
    -0.02968912f, 0.13911517f, -0.01104889f, 0.02428170f, -0.05293825f, -0.04161092f, 0.06066979f, -0.09765667f, 
    -0.03773309f, 0.13924681f, -0.10140859f, 0.03130988f, 0.06868710f, -0.05779231f, -0.00685702f, 0.09041222f, 
    -0.50562841f, 0.18248747f, -0.27497098f, -0.00245738f, 0.18271440f, 0.04598152f, -0.02570370f, -0.10259426f, 
    -0.03197170f, 0.08063431f, 0.04907318f, 0.00554295f, 0.05731668f, -0.07880438f, 0.07087006f, -0.06021427f, 
    -0.01077865f, 0.10181908f, 0.02087991f, -0.00476372f, -0.41678399f, -0.24089709f, 0.00630613f, 0.00872958f, 
    0.14411190f, 0.14202148f, -0.03093937f, 0.08980883f, 0.02555205f, -0.07502941f, 0.04166770f, 0.12441605f, 
    -0.03586409f, 0.03140712f, 0.03867397f, 0.08411641f, -0.01205086f, 0.04283723f, 0.06383032f, 0.07750203f, 
    -0.30462000f, -0.27880690f, -0.14430678f, -0.10644908f, 0.08939683f, 0.03549688f, 0.05334984f, 0.06713302f, 
    -0.08445712f, -0.12182601f, 0.04224188f, -0.01055822f, -0.08719350f, -0.00745120f, 0.09888439f, 0.02137533f, 
    0.00086399f, 0.07300054f, 0.04416468f, 0.07735249f, 0.26346865f, 0.06441629f, -0.00646878f, -0.00929524f, 
    -0.02882855f, -0.17454185f, -0.05860965f, -0.02324998f, -0.01542890f, -0.02439720f, -0.01138510f, 0.07973266f, 
    -0.03946959f, -0.02902434f, -0.05843761f, -0.15138446f, 0.04087428f, -0.00567600f, -0.12074295f, 0.01553422f, 
    0.19941486f, 0.07968138f, -0.15998577f, -0.02454601f, -0.08238459f, -0.08070248f, -0.05503282f, -0.06829111f, 
    0.03097158f, -0.10370690f, 0.01015183f, 0.07107271f, -0.10808768f, -0.11458915f, -0.01917736f, -0.14720359f, 
    0.01062169f, 0.05827034f, -0.01183841f, -0.01831330f, -0.50511748f, -0.24547495f, -0.00362781f, 0.09871699f, 
    0.13998580f, 0.06227032f, 0.09778424f, 0.02777904f, 0.01249039f, -0.00716605f, 0.03562210f, 0.06846048f, 
    -0.05090304f, -0.05153732f, 0.03623297f, 0.07110095f, 0.06151127f, -0.01461105f, 0.04940798f, -0.04645208f, 
    -0.63461536f, -0.50888968f, -0.29047552f, -0.12311716f, -0.22151543f, 0.06310972f, 0.00830350f, -0.16753906f, 
    -0.04090745f, -0.00812467f, 0.11003713f, -0.00498902f, -0.01163082f, 0.05050440f, 0.05124758f, 0.05225335f, 
    -0.01431704f, -0.01232691f, -0.00191265f, -0.03962649f, -0.41920874f, -0.09904877f, -0.15151890f, 0.09533040f, 
    0.04492899f, 0.02125327f, 0.06427918f, 0.00237261f, 0.01852178f, 0.19549386f, 0.08610163f, 0.00490605f, 
    -0.02233283f, 0.05691379f, 0.04493973f, 0.15763472f, -0.03103323f, 0.03967434f, -0.02302233f, 0.09811095f, 
    -0.26358202f, -0.27059981f, -0.11193305f, -0.12901618f, -0.13687317f, -0.01971650f, 0.02617726f, -0.05188670f, 
    -0.03562993f, -0.09906275f, 0.05820920f, -0.07826022f, -0.00610648f, 0.01891976f, -0.01150455f, -0.08876479f, 
    -0.04217431f, 0.12857635f, 0.06228724f, 0.11150114f, -0.40310508f, 0.14988056f, -0.24139707f, -0.10369707f, 
    0.20336023f, -0.00598903f, 0.05153800f, -0.02682045f, 0.01954698f, 0.08365774f, 0.05374209f, 0.03849557f, 
    0.07303124f, -0.05304840f, 0.13611832f, 0.03389931f, 0.00147883f, 0.18350813f, 0.01246848f, 0.03562283f, 
    0.25207302f, 0.07871774f, -0.06476184f, 0.06140430f, -0.06233707f, -0.16207600f, 0.00746001f, 0.00268906f, 
    -0.00241531f, -0.00808164f, 0.01055180f, 0.05721641f, -0.00827286f, -0.00315576f, 0.02341923f, 0.00986005f, 
    0.11144765f, 0.01445304f, -0.10295032f, 0.02916672f, 0.08980604f, -0.06044056f, -0.00149520f, -0.00643433f, 
    0.02145308f, 0.03205957f, 0.07717633f, -0.02117258f, -0.01423243f, -0.02263618f, -0.02209741f, -0.01511044f, 
    -0.02243609f, -0.03093141f, -0.02626340f, -0.05631553f, 0.01248462f, -0.12492244f, -0.07591926f, 0.07348952f, 
    0.31961989f, 0.12095020f, -0.00988091f, 0.03146206f, 0.05883687f, 0.05057665f, 0.05881446f, 0.08548955f, 
    -0.01499596f, 0.03500921f, -0.09944078f, 0.03010150f, 0.08041718f, 0.00395133f, -0.02417165f, 0.01795608f, 
    0.07269242f, -0.24500404f, -0.09056628f, 0.00483362f, -0.10971360f, 0.15167692f, 0.22062124f, -0.05625550f, 
    -0.20305438f, 0.17048824f, -0.00120873f, 0.00555724f, -0.04097343f, 0.00693032f, -0.09756379f, 0.01996297f, 
    0.05493575f, 0.15735058f, -0.06134554f, 0.05157050f, 0.07195448f, -0.03829202f, -0.18991821f, -0.10918237f, 
    -0.50956362f, -0.45293486f, 0.16063461f, 0.06614825f, 0.00765298f, 0.07202744f, -0.00614498f, 0.14962584f, 
    -0.04068783f, 0.05435104f, 0.03656659f, 0.04551491f, -0.06474871f, -0.02093406f, 0.08204492f, 0.01108784f, 
    -0.03138904f, -0.23108631f, -0.14050266f, -0.09793299f, -0.29915473f, -0.21624365f, 0.01908647f, 0.01675900f, 
    0.17642619f, 0.04350597f, 0.04697184f, 0.08038815f, -0.03215035f, -0.04679266f, -0.00501582f, 0.00906407f, 
    -0.04932074f, 0.01448359f, 0.10740496f, -0.02118708f, -0.08549546f, -0.23967709f, -0.20745705f, 0.05470096f, 
    -0.60832971f, -0.17691456f, 0.10814409f, -0.20427811f, -0.35718098f, 0.09572200f, 0.00153307f, -0.01491802f, 
    -0.01509434f, 0.11335769f, -0.00412693f, -0.01671714f, 0.00106938f, 0.02175614f, 0.00170151f, -0.04632474f, 
    -0.08524140f, -0.15608387f, -0.06237100f, -0.12426716f, -0.30433756f, -0.21428567f, -0.07803936f, -0.06696889f, 
    -0.01928603f, 0.09124165f, 0.14401449f, -0.00766593f, -0.01905864f, 0.03835409f, 0.08992152f, -0.06050561f, 
    -0.03822961f, 0.10464454f, -0.00014391f, 0.07098683f, 0.14296098f, 0.00671085f, 0.10601861f, 0.11149074f, 
    0.01226746f, 0.04140161f, 0.00226429f, -0.00425149f, 0.07310949f, -0.08036504f, -0.03601199f, 0.04376393f, 
    0.04663003f, -0.03491184f, 0.02565226f, -0.10246997f, 0.04369429f, -0.15481006f, -0.02013624f, -0.08325671f, 
    0.04369092f, 0.01189516f, 0.11673412f, -0.03280422f, 0.01129687f, 0.19754635f, 0.04958643f, -0.06337475f, 
    0.16944674f, -0.00411588f, 0.17739066f, 0.06296317f, -0.01423451f, 0.04254937f, 0.00922861f, 0.01343749f, 
    0.02348150f, 0.04364124f, 0.09036905f, 0.01837195f, 0.15280798f, 0.12909743f, 0.01640309f, 0.14143696f, 
    0.13027190f, -0.06173198f, -0.14122663f, 0.02103816f, -0.03357107f, -0.13567178f, 0.05601539f, -0.12305844f, 
    0.04144548f, -0.06197133f, -0.01865971f, 0.06341267f, 0.03740684f, -0.13027740f, 0.21345352f, 0.00680140f, 
    0.06059697f, -0.02820234f, -0.09267738f, -0.09960383f, 0.14606704f, 0.12450413f, 0.02049351f, -0.01111398f, 
    0.03064200f, 0.00097565f, -0.01400845f, 0.00509690f, -0.02649414f, 0.00785942f, -0.05906922f, -0.06699171f, 
    0.00043163f, -0.05451751f, -0.07934221f, 0.06776914f, -0.01135703f, -0.26929533f, -0.11417715f, -0.09351083f, 
    -0.25105792f, 0.05982339f, -0.04112260f, -0.11075763f, -0.14158775f, 0.05313801f, -0.05658891f, -0.10010832f, 
    -0.04744229f, 0.03220648f, 0.05625754f, 0.02721158f, -0.03562593f, 0.05938304f, -0.00609300f, 0.02831094f, 
    0.01957696f, -0.09913810f, -0.08320600f, 0.03432041f, -0.39620075f, -0.10180292f, -0.15736711f, -0.05912025f, 
    -0.21956532f, 0.10363380f, -0.00738692f, 0.05590485f, -0.06197448f, 0.02719023f, 0.10360388f, -0.02785588f, 
    0.05068948f, -0.04015137f, 0.09402959f, 0.11125270f, -0.07307082f, -0.07223435f, 0.08855000f, 0.01278404f, 
    0.06566039f, -0.10872044f, 0.06503930f, 0.11343969f, 0.13264212f, 0.02500475f, 0.04955924f, 0.05679101f, 
    -0.00750068f, -0.04096566f, 0.01855771f, 0.04094819f, -0.04280851f, 0.05605501f, -0.10207281f, -0.03603342f, 
    -0.03825528f, -0.21519148f, -0.10393336f, -0.01383204f, -0.33986029f, -0.07273474f, 0.19404605f, 0.02446621f, 
    -0.01538585f, 0.04975407f, -0.03469754f, -0.00990621f, -0.05065491f, 0.12700124f, 0.02172967f, 0.07034628f, 
    0.10034738f, -0.03853220f, 0.10816890f, -0.06621657f, 0.04192675f, 0.07905761f, 0.06531189f, 0.08321429f, 
    0.22324137f, -0.23359130f, -0.01259865f, 0.14580572f, -0.01856521f, 0.13434306f, 0.01265921f, 0.00068562f, 
    -0.03072601f, -0.00863317f, 0.10612258f, -0.06130550f, -0.08900786f, 0.06331273f, 0.10840676f, 0.04700742f, 
    -0.04845614f, 0.01474952f, -0.03502632f, 0.02961383f, -0.13274164f, 0.20005612f, -0.05585012f, 0.03469588f, 
    0.14853930f, -0.05509777f, 0.01862003f, 0.03805878f, 0.05371287f, 0.06627865f, 0.00744192f, -0.06160028f, 
    -0.06986178f, 0.07787285f, 0.14184932f, -0.00747453f, -0.05626719f, -0.02170197f, 0.10093410f, -0.08491569f, 
    0.55457050f, -0.18394537f, -0.24991935f, -0.22733547f, -0.21208483f, 0.00145132f, -0.00922821f, -0.04142109f, 
    0.03145060f, 0.08345848f, 0.15001057f, -0.01326019f, -0.00086402f, -0.00195900f, 0.02038152f, 0.01755933f, 
    -0.06228682f, -0.12556343f, -0.02633028f, -0.07607535f, 0.04708741f, -0.10506015f, 0.14373034f, 0.01785467f, 
    0.08463071f, -0.06546529f, 0.08763081f, 0.13842608f, 0.04523456f, -0.23241022f, 0.00525069f, -0.12346927f, 
    0.02074843f, 0.10501393f, -0.02497468f, -0.13209389f, -0.09393251f, -0.06546141f, -0.11488255f, 0.01264575f, 
    0.01103628f, -0.42341772f, -0.09372757f, -0.11072495f, -0.13934803f, 0.05664205f, 0.04247677f, 0.03434569f, 
    0.01621935f, -0.03680534f, 0.00847322f, -0.08123700f, 0.10663895f, 0.04211251f, -0.03283745f, -0.13066328f, 
    0.00569859f, -0.03834986f, -0.02958181f, -0.11779685f, -0.02591026f, 0.12518837f, -0.14926170f, -0.24846399f, 
    0.03152223f, -0.08938877f, -0.10308939f, 0.09999415f, -0.00788972f, -0.18894391f, -0.04575876f, 0.02020642f, 
    -0.05699931f, -0.06300364f, 0.05573104f, -0.00001016f, -0.06393026f, -0.04529565f, 0.12662452f, -0.10404853f, 
    -0.28222340f, -0.07642003f, -0.04832536f, 0.20160286f, 0.04484907f, -0.14814629f, 0.14828579f, 0.00994194f, 
    0.03518526f, -0.11134745f, 0.05457202f, -0.13600248f, 0.08072197f, 0.09252999f, 0.02013221f, 0.07644951f, 
    0.08134884f, -0.06670700f, -0.04257011f, 0.07078713f, 0.37875807f, 0.01708850f, -0.01563981f, -0.03707419f, 
    0.15143271f, 0.17519705f, 0.07460853f, -0.10824306f, 0.03409514f, -0.00822207f, 0.05491439f, 0.07079168f, 
    -0.01987690f, -0.00903604f, -0.06082060f, 0.02220375f, -0.03812774f, 0.02181340f, 0.00032386f, 0.05790726f, 
    -0.21375971f, 0.08229563f, 0.01590706f, 0.11594532f, -0.22825019f, 0.15634267f, 0.16739921f, 0.02086071f, 
    0.05275761f, 0.05368878f, 0.02683186f, 0.01972135f, -0.02460112f, 0.04355271f, 0.09306668f, -0.03217276f, 
    -0.02200025f, -0.00826355f, -0.06627892f, 0.04418958f, -0.26529109f, 0.18824407f, 0.09644091f, -0.00626894f, 
    -0.01716941f, -0.00892731f, -0.12379298f, 0.01343849f, -0.07442891f, -0.02431107f, -0.02914665f, -0.03195775f, 
    0.02550989f, -0.01079129f, -0.06687506f, -0.01363601f, -0.08692455f, -0.05122617f, -0.06593834f, 0.04669390f, 
    -0.39368111f, -0.26585588f, 0.02730154f, -0.11649921f, 0.00891447f, -0.11400443f, 0.02673344f, -0.01697151f, 
    0.05441373f, -0.03333490f, -0.17610878f, 0.17291722f, 0.09769713f, 0.05692834f, -0.02034781f, -0.10059863f, 
    -0.08107674f, -0.02512453f, -0.15560287f, 0.00211903f, -0.09342842f, 0.26427761f, -0.14940523f, 0.12125015f, 
    -0.09228912f, 0.06889662f, 0.04983246f, -0.06949357f, 0.04176154f, -0.00392380f, -0.04980880f, 0.02234862f, 
    0.00900872f, -0.01904622f, 0.10812259f, -0.01460749f, 0.07029089f, 0.04328115f, -0.13130753f, -0.03683718f, 
    0.54167724f, -0.00753336f, -0.24833293f, 0.00178072f, -0.16013795f, 0.00821770f, -0.01327343f, 0.03194432f, 
    -0.04060034f, 0.02596059f, 0.06511299f, 0.10384716f, 0.00745450f, 0.08423790f, 0.03762289f, -0.01788780f, 
    -0.05584330f, -0.06421370f, -0.05159330f, 0.06015017f, 0.44807824f, 0.12788527f, -0.19870824f, 0.01711596f, 
    -0.27481955f, -0.11487155f, -0.08590516f, 0.01325820f, 0.01636239f, -0.00537325f, -0.01689825f, -0.00428663f, 
    0.01326191f, -0.04239580f, -0.02971198f, 0.08884575f, -0.00762019f, 0.03216665f, -0.00276238f, -0.04687952f, 
    -0.41361687f, -0.24229173f, -0.19579700f, -0.21748674f, -0.33111188f, 0.04428528f, -0.02677665f, 0.12542708f, 
    0.03010925f, 0.15315972f, 0.04568658f, -0.01686895f, -0.01391502f, -0.04727143f, 0.06827921f, -0.10749616f, 
    0.00418381f, -0.05812029f, -0.06022675f, -0.01703956f, -0.63184905f, 0.21403988f, 0.06532118f, 0.06745721f, 
    0.11676878f, -0.06272000f, 0.10648601f, -0.02607874f, 0.03334126f, -0.02597078f, -0.04714286f, 0.09359876f, 
    0.05545817f, 0.08614371f, 0.01968442f, 0.01351048f, -0.00809096f, -0.03880785f, -0.00413036f, -0.05750360f, 
    -0.10560507f, 0.15741421f, 0.08127432f, 0.03796883f, -0.05628647f, 0.04975996f, -0.08276444f, 0.04328701f, 
    -0.12050202f, -0.08370857f, -0.04112329f, -0.11042493f, 0.08992475f, -0.09239042f, -0.00802738f, 0.05920080f, 
    0.09969971f, 0.03213270f, -0.08344312f, -0.05503961f, -0.10619865f, 0.20220470f, -0.04230651f, -0.02482475f, 
    -0.05992261f, 0.11536708f, -0.19017285f, 0.08385846f, -0.11783583f, -0.04491704f, 0.01971257f, 0.07148337f, 
    0.13458090f, -0.00887787f, 0.00634350f, -0.02174341f, 0.05640686f, -0.10402329f, 0.04864506f, -0.05843700f, 
    0.08910777f, 0.07596942f, -0.11663722f, -0.08893736f, -0.03511733f, -0.19503571f, -0.04380435f, 0.03034081f, 
    0.00966150f, -0.00595501f, 0.13765319f, -0.03334416f, -0.09084477f, 0.00783019f, -0.10932124f, 0.12542067f, 
    0.05445214f, 0.06733606f, 0.12342555f, 0.00040424f, 0.37395898f, 0.28911233f, -0.28994331f, -0.23005012f, 
    0.25816646f, 0.16439779f, 0.03942139f, -0.00770097f, 0.08662373f, -0.07992981f, 0.12157556f, -0.00679145f, 
    -0.01970359f, 0.01540789f, 0.05548919f, 0.02377116f, -0.03503992f, 0.02970128f, 0.01904795f, 0.06862266f, 
    -0.08437493f, 0.32234526f, -0.10133030f, 0.01124501f, 0.19526859f, 0.15648761f, -0.08875418f, -0.07087776f, 
    0.10595352f, 0.04836608f, 0.06182434f, 0.14186808f, -0.10656863f, -0.06513751f, 0.04426861f, 0.01804475f, 
    0.15798415f, 0.16211459f, -0.11749379f, -0.00614570f, -0.11536621f, 0.36000824f, -0.17876375f, 0.03059262f, 
    0.12172931f, 0.08695469f, -0.17034422f, 0.08776779f, 0.04540731f, 0.02425785f, 0.04911983f, 0.12586193f, 
    0.10273866f, 0.00934677f, 0.02209301f, 0.02841056f, 0.07777754f, -0.02414837f, -0.08992139f, 0.00304190f, 
    0.38280937f, 0.11642487f, -0.30608788f, -0.04585606f, -0.08941940f, -0.10956582f, -0.02274309f, -0.03244612f, 
    -0.08506089f, -0.02535413f, 0.11499181f, -0.04921161f, -0.06533919f, 0.00185288f, -0.05356030f, 0.03292648f, 
    0.03646601f, 0.00155879f, 0.03677541f, 0.01995152f, -0.08223929f, -0.09466422f, -0.06446908f, -0.08665445f, 
    -0.18124563f, 0.12069453f, -0.00005845f, 0.01195141f, -0.05291332f, 0.06685936f, -0.01114336f, -0.00537232f, 
    0.05228060f, -0.05555170f, -0.08877987f, 0.04604053f, 0.00650913f, 0.04653849f, -0.05467151f, -0.04275768f, 
    -0.10830953f, -0.22973551f, 0.08528834f, 0.10497802f, -0.12349187f, 0.05382840f, 0.08367252f, 0.06147989f, 
    -0.00289453f, 0.08201089f, -0.01929886f, -0.04323752f, -0.05167957f, 0.01194010f, 0.00639024f, -0.08919872f, 
    0.06892846f, -0.07002274f, -0.09712444f, 0.04880383f, -0.21998072f, 0.08360731f, 0.00957563f, -0.02051677f, 
    0.19813482f, -0.09720702f, 0.05787688f, 0.02466505f, -0.01959576f, -0.01535680f, 0.04565124f, -0.01887610f, 
    -0.08945505f, -0.03259459f, -0.09146970f, -0.08107655f, 0.00994784f, -0.01491513f, -0.03281350f, -0.07181022f, 
    -0.35041860f, -0.15789413f, -0.05217206f, -0.00658443f, -0.16075629f, 0.02110851f, -0.00441693f, -0.11200248f, 
    0.02588443f, 0.06008144f, -0.30538034f, -0.05564596f, 0.05260064f, 0.02619651f, -0.06376909f, -0.08869472f, 
    0.01155307f, -0.04194294f, -0.17556946f, -0.12839115f, 0.01892587f, -0.05258719f, -0.09929648f, -0.10388444f, 
    0.33935788f, 0.02662046f, -0.14729236f, 0.03515385f, 0.00042358f, -0.23073417f, -0.03943822f, -0.02242579f, 
    -0.02274859f, 0.02610734f, 0.07878809f, -0.00073314f, -0.04751653f, 0.03758561f, 0.16803122f, 0.10281289f, 
    0.34501842f, 0.19070673f, -0.08102760f, 0.06947946f, -0.18719776f, -0.10919134f, 0.02106790f, -0.11811476f, 
    0.05245540f, -0.05665876f, 0.22082411f, -0.09099899f, 0.05423933f, -0.08272820f, -0.00542161f, 0.09020956f, 
    -0.03111701f, -0.00166563f, 0.08851869f, 0.13631332f, 0.21247856f, -0.39914179f, -0.15078433f, 0.07480411f, 
    -0.13790764f, -0.15966748f, -0.04049848f, -0.02954915f, -0.11029791f, 0.01025161f, 0.06238345f, 0.06240598f, 
    -0.01499365f, -0.01005599f, -0.22600923f, -0.10355556f, 0.03713668f, -0.06464209f, -0.08843624f, -0.08188997f, 
    -0.00344438f, 0.05164167f, -0.12262247f, -0.16856290f, 0.03103206f, 0.06140167f, -0.18244265f, 0.00935951f, 
    -0.01336517f, -0.11548022f, 0.08071299f, 0.04579824f, 0.01863394f, 0.02416777f, -0.01342030f, 0.11573213f, 
    -0.07057828f, -0.02600455f, 0.11116972f, 0.15409735f, -0.17539583f, -0.31664440f, -0.02149769f, -0.14761417f, 
    0.26645020f, 0.08444573f, -0.15749629f, 0.00961240f, 0.10883735f, 0.04390429f, -0.09469127f, -0.09326360f, 
    0.01458396f, 0.05430558f, -0.04356107f, 0.12077428f, 0.08969852f, 0.07879121f, 0.02198107f, -0.21531396f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07916608f, 0.03876796f, -0.03327651f, -0.00348603f, 0.03881990f, 0.02026719f, 0.00845434f, -0.03756562f, 
    0.00049525f, -0.01684856f, 0.06810261f, 0.05629059f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
