#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.32535619f, 0.33955559f, 0.65023041f, -0.41142726f, -0.60272706f, -0.73825741f, -0.56770396f, 0.10927611f, 
    0.97426766f, -0.63481098f, -0.45477062f, -0.52737445f, -0.14426805f, -0.60738677f, 0.59063774f, 0.27505058f, 
    0.66339403f, -0.34733826f, 0.32543164f, -0.33186865f, -0.14632478f, -0.60765356f, -0.33344191f, -0.49751350f, 
    0.09948892f, 1.89528906f, 0.53670049f, -0.83095330f, 1.63535404f, 1.11116421f, 0.39566407f, 0.40591973f, 
    0.03734855f, 0.89486510f, 0.32856148f, -0.46647027f, 0.13991600f, -0.18209742f, 0.00199814f, -0.34135395f, 
    -0.06320883f, -0.30254346f, 0.02687224f, -0.13759761f, -0.21802078f, 0.31422338f, 0.03516508f, 0.45143446f, 
    0.26179901f, 0.30507913f, 1.59009719f, 1.25992191f, 0.12972943f, -0.63631433f, -0.30923638f, -0.08146054f, 
    0.63405585f, -0.40542397f, 0.49920845f, 0.85159200f, 0.30363527f, 0.03144246f, -0.60660869f, -0.73252273f, 
    0.17903972f, 0.00419559f, -0.01323918f, -0.23544227f, -0.12670176f, -0.24540807f, -0.01684660f, 0.19713289f, 
    0.30624375f, 0.04134281f, -0.20450437f, -0.39305595f, -1.48194623f, -0.69330609f, -0.52745563f, -0.56384492f, 
    0.91258383f, -0.65068007f, 0.10498567f, 0.76924026f, 0.39370075f, 0.23035218f, -0.30302650f, -0.32248548f, 
    0.09642523f, 0.02428049f, -0.18506208f, 0.39127472f, -0.03971121f, 0.23253274f, -0.14177950f, 0.23543186f, 
    0.25013518f, 0.57903433f, 0.31555250f, 0.22185807f, -1.05399096f, 0.48167649f, 0.65058488f, 0.38895828f, 
    -1.07210290f, -0.58378226f, 0.27982342f, -0.47726142f, -0.89478213f, -0.39196414f, -0.51997477f, 0.07330874f, 
    -0.72843981f, -0.16547480f, -0.51443154f, -0.68354511f, -0.70592493f, -0.04867161f, 0.15244259f, -0.75833821f, 
    0.31180012f, -0.17194115f, -0.08648575f, -0.01676208f, 0.24443915f, 1.27814460f, 0.76531321f, -1.16039932f, 
    -1.08704925f, -0.99922490f, -0.57192314f, 0.02169373f, -0.88970232f, -0.66818398f, -0.38923332f, 0.41113028f, 
    0.22944605f, 0.40694654f, 0.14909680f, 0.01283938f, 0.07143743f, -0.04300618f, -0.28263271f, 0.19998185f, 
    0.21527234f, 0.24387018f, 0.33006406f, 0.33127233f, 0.02342084f, 0.20982786f, 0.68808204f, -1.08899546f, 
    0.67360270f, 1.30988610f, 1.02689767f, 0.31952032f, 0.52750891f, 0.13962068f, -0.26705837f, -0.15628581f, 
    0.42725718f, 0.49893364f, -0.77930766f, 0.13123010f, 0.29046455f, 0.45288229f, 0.12541534f, -0.17290504f, 
    0.15119998f, -0.15828988f, 0.04277279f, 0.25923648f, 0.26781213f, 0.41193300f, -0.20683378f, 1.27284563f, 
    1.05247664f, 1.26080990f, -0.36411187f, -1.02046871f, 0.42996430f, -0.21644014f, -0.07778019f, -0.05476268f, 
    0.74211186f, 0.82623184f, 0.88534164f, -0.12599140f, 0.20515172f, 0.16266717f, -0.04799807f, 0.06204671f, 
    0.42872104f, 0.01545827f, -0.27963006f, 0.12950519f, 0.04397720f, -0.42267716f, 0.03086295f, 0.30706897f, 
    -0.00044459f, 0.34639829f, -1.04279280f, -1.34331965f, -0.45608357f, 1.43450296f, -0.48673019f, -0.21760626f, 
    0.31584445f, -0.02801502f, -0.37986153f, -0.33598405f, 0.51379687f, 0.45813230f, -0.43359578f, 0.08120787f, 
    -0.24418901f, 0.14164913f, 0.09378412f, 0.45253369f, 0.15744023f, 0.08896500f, -0.15764336f, 0.38102907f, 
    0.00958960f, -1.03516614f, -0.48988548f, 0.06433932f, -0.28317419f, -0.30977294f, 1.01630867f, -0.14883369f, 
    -1.27853477f, -0.93845034f, -1.08926964f, 0.44835871f, -0.00880900f, 0.04291457f, 0.87276965f, 0.41323286f, 
    0.18166791f, -0.55376339f, -0.25787497f, -0.04063129f, 0.57692468f, -0.07714652f, 0.08076625f, -0.12849309f, 
    0.12604311f, 0.30513540f, 1.49013627f, 0.82669276f, 1.29387236f, 1.03942144f, 1.29270840f, 0.03040211f, 
    -0.55873454f, -1.07898295f, -0.53697145f, -0.02185734f, 0.18450429f, 0.18557532f, -0.05629407f, -0.03497970f, 
    -0.23924747f, -0.47959226f, 0.05766851f, -0.03869065f, -0.44604626f, 0.23960464f, -0.12233515f, 0.05458222f, 
    0.22705227f, -0.13218197f, 0.15262222f, 0.89602637f, 1.03663945f, 0.74158144f, 0.65123981f, 0.33665609f, 
    0.82908577f, 0.08454288f, 0.71670735f, -0.24217756f, -0.21803795f, -0.59727561f, -0.52200538f, -0.16139874f, 
    0.23892221f, 0.07325363f, 0.38188931f, 0.06057287f, -0.31067625f, 0.56614381f, 0.49820906f, -0.46374768f, 
    -0.61715692f, -0.02484120f, -0.77417606f, 0.39256671f, -0.42914036f, 0.94047761f, -1.08904910f, -1.01666653f, 
    -1.30604064f, 0.77668667f, -0.19210099f, 0.24120757f, 0.77217829f, 0.53800732f, -0.50224286f, -0.13054512f, 
    -0.27952152f, -0.09395556f, -0.20042326f, 0.69505870f, 0.21600883f, 0.02275809f, 0.23804113f, 0.20842546f, 
    -0.17493181f, -0.31910515f, -0.29576293f, -0.38102487f, 0.42907965f, 0.20624237f, -1.42910016f, -1.61772215f, 
    -0.75479114f, -0.00983749f, -0.92023653f, 1.17080295f, 0.47868657f, -0.31194752f, 0.68041903f, 0.54330969f, 
    -0.05943217f, 0.09561341f, -0.07756676f, 0.04237617f, -0.18224612f, 0.66571540f, 0.05067911f, 0.04441500f, 
    -0.34852034f, 0.15156117f, -0.10890860f, 0.11249847f, -0.09014457f, 0.13910384f, -0.26460156f, 0.86566645f, 
    1.08040440f, 0.40327814f, 0.51605934f, -1.80503500f, 0.56961346f, -0.52629191f, -1.25345695f, -0.51248235f, 
    0.48246846f, 0.16409156f, 0.26155722f, 0.58007020f, 0.18551934f, 0.30783871f, 0.27179393f, 0.34206337f, 
    0.12232930f, 0.11751042f, -0.17984331f, 0.03087184f, 0.09711172f, 0.33730024f, 0.08713872f, -0.10232070f, 
    -0.35162210f, -0.60025930f, -0.44978809f, 0.15834270f, 0.78708738f, 0.92152601f, 0.70798260f, 0.88763452f, 
    1.04362774f, -0.52673006f, -0.42815253f, -0.26759353f, -1.03324258f, 0.22537680f, -0.29030621f, -0.66994190f, 
    -0.31769159f, -0.18557803f, -0.20643024f, -0.46677190f, -0.26808125f, -0.27501389f, -0.26265553f, -0.16224416f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.32803977f, 0.18203443f, 0.30152801f, 0.19563194f, 0.05330293f, 0.57037133f, 0.22584653f, 0.12660542f, 
    0.36642134f, 0.44312969f, 0.09352950f, 0.07282935f, 0.23663293f, 0.32999796f, 0.44779751f, 0.29029700f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.21306159f, 0.23454623f, -0.13699430f, 0.12871218f, -0.27422848f, -0.21531487f, -0.07607999f, 0.05260166f, 
    0.08430683f, -0.03490749f, -0.08040917f, -0.20108995f, 0.26802012f, 0.02513899f, -0.05554266f, 0.68698084f, 
    -0.23074409f, 0.12405220f, -0.22659780f, 0.13035558f, -0.17181557f, 0.17175661f, 0.06695912f, -0.33760953f, 
    -0.11434445f, -0.07270446f, 0.05026801f, -0.56155342f, 0.00567555f, -0.16215019f, 0.06875256f, 0.06884030f, 
    -0.07364628f, 0.17751554f, 0.15969118f, -0.09597187f, 0.29053491f, -0.13865745f, -0.02080256f, -0.15825683f, 
    0.21079327f, 0.05969675f, 0.01749235f, 0.17206600f, -0.07199679f, 0.02650723f, -0.02251128f, 0.03012294f, 
    -0.34461007f, 0.07418866f, 0.14080517f, 0.36562192f, 0.02273865f, 0.14680324f, -0.08784899f, -0.05293275f, 
    0.00773086f, -0.05932130f, -0.11471796f, -0.13109018f, -0.66056073f, -0.03017963f, 0.34205893f, -0.33513582f, 
    -0.14188838f, 0.22264278f, 0.17710559f, 0.06526580f, -0.17229052f, -0.26806092f, 0.06180118f, 0.03703834f, 
    0.01524274f, -0.25453529f, -0.37347323f, 0.48577380f, -0.02909043f, 0.07262742f, 0.18690774f, -0.18345667f, 
    -0.12624848f, -0.02682274f, 0.22416203f, -0.10768343f, -0.23586072f, 0.06457995f, 0.00835137f, -0.13234402f, 
    -0.08793861f, -0.04502592f, 0.04436148f, -0.11041729f, -0.02743301f, 0.07532016f, -0.02491739f, -0.00131045f, 
    0.50099635f, -0.45654085f, 0.09541878f, -0.45375142f, -0.17782478f, -0.07750330f, 0.35442016f, -0.22077739f, 
    -0.00485614f, 0.05566096f, 0.05424457f, 0.33880875f, -0.89448029f, -0.11350561f, 0.01015171f, -0.12896992f, 
    -0.30173713f, 0.05715847f, 0.17086475f, 0.07986904f, 0.18146682f, -0.07204008f, 0.07813694f, -0.02350357f, 
    0.45554280f, -0.21439326f, 0.15013552f, 0.16151844f, -0.28147358f, -0.27505669f, 0.15140066f, 0.19715795f, 
    -0.07313669f, 0.07358720f, -0.03306399f, -0.10555045f, 0.03267815f, -0.21819676f, -0.09310275f, -0.11439567f, 
    -0.03765077f, -0.06330280f, 0.11936642f, 0.34258246f, 0.13946913f, -0.01336680f, -0.04495991f, 0.08101670f, 
    0.83933932f, -0.00750236f, -0.05134025f, -0.55347770f, 0.02298440f, -0.13876660f, 0.05310549f, 0.05509251f, 
    -0.02882339f, 0.03680728f, -0.12817959f, 0.06735443f, -0.76527268f, 0.21149899f, 0.17923036f, -0.26643199f, 
    0.13949737f, -0.10474235f, -0.11028703f, -0.12585469f, -0.10622485f, 0.01384811f, -0.17374019f, 0.03004040f, 
    -0.03193552f, 0.05339754f, -0.18941906f, 0.12484556f, -0.14161280f, -0.13034949f, -0.04415022f, -0.10316507f, 
    -0.00163673f, -0.15142158f, 0.02874327f, -0.24968372f, 0.21745910f, 0.30913764f, 0.09624181f, -0.22225359f, 
    0.17306544f, 0.01430666f, 0.30392650f, -0.06005058f, 0.01230220f, -0.05216110f, -0.12024396f, 0.23088439f, 
    0.05530120f, -0.12539552f, -0.30632067f, -0.18585315f, 0.10663299f, 0.03349612f, -0.25022918f, -0.03164644f, 
    -0.02296905f, -0.00823663f, -0.08013188f, -0.06317105f, 0.46143889f, -0.22342835f, 0.12793671f, 0.49060196f, 
    -0.02315888f, -0.00615249f, -0.11571247f, 0.19080782f, 0.11630554f, -0.06501457f, -0.03951430f, 0.08869638f, 
    0.45828155f, 0.07999419f, 0.01698105f, -0.02766051f, -0.21145749f, -0.23077939f, -0.05195607f, -0.02559431f, 
    -0.05920069f, -0.18058200f, -0.29920101f, -0.02079495f, -0.05948564f, -0.06781794f, -0.09836253f, 0.00916796f, 
    0.08499684f, -0.16529544f, -0.10935544f, 0.00747393f, 0.23643729f, -0.19765128f, -0.05490160f, 0.17401226f, 
    -0.41930318f, -0.17502254f, -0.91773659f, -0.19470736f, -0.28152871f, 0.25708094f, 0.00008965f, 0.24666180f, 
    -0.17712495f, -0.11501889f, -0.01926782f, -0.08606414f, 0.59424949f, -0.08932255f, -0.23432492f, -0.30759701f, 
    -0.08839968f, -0.05200357f, -0.03199537f, 0.17007446f, -0.12283114f, 0.17662309f, 0.15403508f, 0.16118000f, 
    -0.00821450f, -0.12015868f, 0.23942296f, 0.16372699f, -0.27831998f, 0.10848442f, -0.06965147f, 0.13393989f, 
    0.04702609f, -0.08676245f, -0.11714819f, 0.13722570f, 0.02972820f, 0.20932700f, -0.03640382f, -0.14877066f, 
    -0.27201852f, -0.06987877f, -0.25100106f, -0.01456104f, -0.00592531f, -0.02781918f, 0.12987055f, 0.03777305f, 
    -0.46637988f, -0.74174780f, 0.22021775f, -0.27634093f, -0.00304937f, -0.21686438f, 0.08368155f, -0.07754853f, 
    -0.05938995f, 0.08250665f, 0.12872657f, -0.22423658f, -0.42012805f, 0.20654544f, -0.15331838f, -0.01279008f, 
    -0.15915157f, 0.07052248f, 0.07020482f, -0.14549927f, -0.20920739f, 0.11898171f, -0.06560217f, 0.02953418f, 
    0.17309730f, -0.09534212f, 0.30546057f, 0.29729277f, -0.13365281f, 0.03316620f, 0.09906597f, 0.00803337f, 
    -0.07591286f, -0.08629157f, 0.24113972f, -0.15956780f, 0.43507507f, 0.01486068f, 0.01531470f, 0.11220516f, 
    -0.09398874f, 0.16589089f, -0.05825311f, -0.06330822f, -0.15579414f, 0.05420084f, -0.20104536f, 0.20863457f, 
    -0.49271524f, -0.25137481f, 0.10499164f, -0.60443151f, 0.10488497f, 0.00570525f, 0.00941326f, 0.22390041f, 
    0.24170691f, 0.14565352f, 0.00259065f, -0.00326952f, 0.74644625f, -0.54756641f, -0.07309513f, -0.16453844f, 
    0.00095651f, 0.11349832f, 0.04928705f, -0.02866385f, 0.13185625f, -0.03070009f, 0.02895115f, -0.03244680f, 
    -0.26381701f, 0.35000578f, -0.13780451f, -0.19940655f, 0.07503999f, 0.07492269f, 0.01004670f, -0.08361823f, 
    0.31202084f, -0.00623065f, 0.08473515f, 0.14725941f, 0.18987206f, -0.22179964f, 0.26509374f, -0.05683251f, 
    0.21158165f, 0.21314751f, -0.34322047f, -0.05013651f, 0.11490267f, -0.13146010f, -0.13470334f, -0.14207412f, 
    -0.63906103f, 0.06828671f, -0.25034821f, 0.05014974f, -0.01864873f, -0.13710469f, 0.06098982f, 0.10694915f, 
    0.13432135f, -0.19451907f, 0.03968245f, -0.08259053f, 0.39050332f, -0.09448911f, -0.06499495f, -0.28986534f, 
    0.06090475f, -0.16233195f, 0.24253850f, 0.13382170f, -0.13277072f, 0.16243251f, 0.05727348f, -0.09643628f, 
    0.33765775f, 0.02559535f, 0.24681814f, -0.30002591f, 0.07999934f, -0.22275971f, 0.08265775f, 0.11298056f, 
    -0.05584468f, -0.11049253f, 0.14120446f, 0.02838040f, -0.41469979f, -0.00745349f, 0.17283422f, 0.26654613f, 
    -0.12109113f, -0.29195875f, -0.11434849f, 0.11773267f, -0.07695556f, -0.01094896f, 0.14142607f, -0.11767683f, 
    0.08383827f, -0.19157536f, -0.75975811f, -0.47934544f, 0.10243975f, -0.07487833f, 0.03868391f, -0.00442718f, 
    0.04925863f, 0.25081134f, 0.00466928f, -0.02263538f, -0.90379345f, 0.15113160f, -0.07437199f, -0.64849144f, 
    0.06491264f, -0.05879910f, 0.09358786f, -0.19687170f, 0.04609196f, -0.12331237f, 0.01733147f, -0.13744909f, 
    0.00178588f, -0.17423914f, 0.15244170f, -0.16784245f, 0.03048261f, -0.00573576f, 0.01885864f, -0.06333710f, 
    -0.01361039f, -0.27944171f, 0.20391180f, -0.11872515f, -0.30407652f, 0.02667974f, 0.29666981f, -0.22456709f, 
    -0.15828569f, 0.05175230f, 0.21734169f, -0.00021872f, 0.09362174f, -0.15570922f, -0.15210453f, -0.01319798f, 
    -0.49505153f, 0.60072321f, -0.11290980f, 0.08071022f, 0.02272280f, -0.04214532f, -0.24510781f, 0.07937405f, 
    -0.12400154f, 0.06536424f, -0.08953995f, 0.01618534f, 0.57024390f, -0.13877892f, -0.01158421f, -0.40871039f, 
    0.10290264f, -0.10863794f, -0.26254603f, 0.03901764f, 0.03278519f, -0.00985266f, -0.22933367f, -0.07685592f, 
    -0.11817472f, 0.32638434f, 0.01038646f, 0.14178570f, 0.18600333f, -0.03261276f, -0.00817002f, -0.10301756f, 
    -0.00187905f, 0.10109661f, -0.06367634f, -0.09529413f, -0.30115172f, 0.02844780f, 0.22157232f, -0.05294503f, 
    0.24458484f, 0.10058361f, 0.01078977f, 0.06860333f, -0.05119110f, -0.24201992f, 0.06720340f, 0.07492641f, 
    -0.17122735f, 0.15613307f, -0.07196672f, 0.25812823f, 0.00915601f, -0.17036617f, 0.19098039f, 0.10281326f, 
    -0.19105546f, 0.00383958f, -0.10219660f, -0.11738524f, 0.97010100f, -0.03381409f, 0.10518093f, 0.34574595f, 
    -0.40651053f, -0.30270666f, 0.07332431f, -0.11305155f, -0.09149319f, 0.04835851f, 0.01443181f, -0.03961087f, 
    0.63242787f, 0.12033421f, -0.73753643f, -0.05463722f, 0.33482438f, 0.15567541f, -0.09514952f, -0.27733847f, 
    -0.24904743f, -0.16403507f, -0.32544148f, -0.07922045f, 0.29010475f, 0.00406887f, 0.05716420f, 0.32354262f, 
    -0.15663105f, -0.02018582f, 0.13874611f, 0.24215163f, 0.03092895f, 0.05337106f, -0.07283848f, -0.07908185f, 
    -0.15903145f, 0.15176059f, 0.38634977f, 0.00979809f, -0.07963008f, 0.13812740f, 0.10712173f, -0.00278112f, 
    -0.00847668f, 0.04418894f, 0.14620958f, 0.16106303f, 0.23903260f, -0.12827699f, -0.30762178f, -0.33797982f, 
    -0.07105630f, -0.20217785f, 0.08606198f, -0.09933435f, 0.02627796f, -0.15882321f, -0.13776997f, -0.06632232f, 
    -0.68970823f, -0.34116289f, -0.51677346f, -0.17097306f, -0.03332072f, 0.26822349f, -0.23432040f, -0.02412329f, 
    -0.08948255f, -0.08403450f, -0.05435919f, 0.06000885f, 0.40548894f, 0.09735460f, -0.21646594f, -0.24443176f, 
    -0.28408536f, 0.02139523f, -0.02793504f, 0.23004799f, 0.20762774f, -0.08428103f, 0.09240805f, 0.09490714f, 
    -0.15995464f, 0.71229368f, 0.41313234f, 0.09525410f, 0.13542449f, -0.07994229f, -0.07002062f, 0.10398054f, 
    -0.00429811f, 0.12635261f, 0.08773976f, 0.35533956f, 0.29128277f, -0.09350047f, 0.21559377f, -0.03426268f, 
    -0.19142072f, 0.16523302f, -0.03141730f, 0.16552612f, 0.16113357f, -0.00940268f, -0.05832558f, 0.09153182f, 
    -0.62803656f, -0.14963023f, 0.09101888f, 0.31125763f, -0.04831989f, 0.19418196f, 0.11253349f, -0.12688647f, 
    0.00245782f, 0.00419941f, -0.03220283f, -0.03782376f, -0.59322625f, -0.46320242f, -0.20079301f, 0.23085913f, 
    -0.02552557f, -0.14793682f, 0.16400056f, 0.21876232f, -0.07640501f, -0.00605218f, 0.04166312f, -0.17518087f, 
    0.25526276f, 0.34919006f, -0.18537948f, 0.13100761f, -0.09924793f, -0.10085852f, 0.03876926f, -0.05009963f, 
    0.03809231f, -0.14331836f, -0.08770142f, 0.12509820f, 0.47983560f, 0.18518947f, 0.20408463f, -0.00267022f, 
    0.31814209f, -0.21975406f, -0.03690463f, 0.10321950f, -0.01519892f, -0.09157864f, -0.13094985f, -0.23450324f, 
    0.19504449f, -0.93238747f, -0.41769394f, 0.42130679f, 0.03277916f, 0.10768612f, -0.22391909f, -0.11315908f, 
    0.06234311f, -0.02284043f, -0.09529664f, -0.03196981f, -0.40104213f, -1.03426480f, -0.01700625f, 0.27576348f, 
    -0.06717210f, -0.20240325f, 0.30262715f, 0.10925324f, 0.07851814f, -0.15776256f, 0.22360069f, 0.04715703f, 
    -0.13055712f, 0.17249538f, 0.09691869f, -0.09732023f, -0.18025154f, 0.21329622f, 0.02780945f, 0.12512384f, 
    -0.06513535f, 0.20327875f, -0.02518854f, 0.00746512f, 0.12204701f, -0.18921810f, -0.15060480f, 0.14886540f, 
    -0.35084474f, -0.13165247f, -0.01947248f, -0.15626448f, -0.13531852f, 0.27127957f, -0.25739807f, 0.08107825f, 
    -1.01173699f, 0.20388368f, 0.54730171f, 0.11830615f, 0.09265277f, -0.06045246f, 0.15080623f, 0.08375584f, 
    -0.20654704f, -0.15941259f, -0.03021013f, -0.14301591f, -0.59651649f, 0.27283832f, -0.19919613f, -0.25102010f, 
    -0.03702339f, 0.00437734f, -0.05206404f, -0.21566060f, -0.07559506f, 0.00190452f, 0.22054656f, -0.13094641f, 
    0.14259484f, -0.11590273f, 0.02252115f, -0.01704097f, -0.25177076f, 0.01069747f, 0.26383469f, -0.07268579f, 
    -0.18474071f, 0.01288241f, 0.05810441f, 0.11338966f, 0.71879864f, 0.07949603f, 0.02515180f, 0.07090656f, 
    -0.00724869f, -0.00064023f, 0.15132599f, -0.08920240f, -0.16683140f, 0.00513056f, -0.01522891f, 0.07680187f, 
    -0.52611190f, -0.28333637f, 0.16066520f, -0.10234269f, 0.04144652f, -0.13297544f, -0.02757637f, -0.02431056f, 
    -0.00236920f, -0.01144543f, -0.01015227f, 0.02188735f, -0.13845526f, 0.15555298f, -0.12239669f, 0.24453028f, 
    0.06207551f, 0.15371390f, -0.04945512f, -0.04877231f, -0.17296098f, -0.01491777f, 0.01990520f, -0.15325002f, 
    0.24584185f, -0.04741286f, 0.33138233f, -0.38943702f, 0.24008048f, -0.09938210f, -0.06860125f, 0.09990984f, 
    0.08868925f, -0.03440924f, -0.06664935f, 0.17417814f, -0.13354409f, -0.11935336f, -0.10162652f, 0.01134360f, 
    -0.32304835f, -0.04469228f, 0.18642369f, -0.05541110f, -0.11397874f, 0.15609771f, -0.13215674f, -0.04035258f, 
    -0.16011874f, 0.28726780f, 0.25443327f, -0.46803567f, 0.01168367f, -0.12209883f, 0.02171482f, -0.00572195f, 
    0.04677275f, 0.02297413f, -0.23244846f, -0.19227430f, -0.31780401f, -0.62068903f, 0.03323143f, -0.35274905f, 
    0.02262844f, -0.00684487f, 0.00184403f, 0.01003129f, 0.15065908f, -0.08391759f, 0.01919098f, -0.10123297f, 
    -0.08455590f, -0.13383667f, -0.17084327f, 0.32041809f, 0.27777094f, -0.03066158f, -0.00802494f, 0.10632964f, 
    -0.10434293f, -0.06992377f, 0.11678678f, 0.01474720f, -0.19481449f, 0.38713351f, 0.46448773f, -0.32474199f, 
    0.19088635f, 0.13078725f, -0.04824332f, -0.03841906f, -0.14291929f, -0.03615687f, 0.10107780f, 0.01124517f, 
    -0.19986609f, -0.02359145f, 0.18077916f, 0.08934156f, 0.07822397f, 0.08148190f, -0.17312424f, 0.06184046f, 
    0.12211664f, -0.02382631f, -0.15354265f, 0.08107710f, 0.29209048f, 0.16111836f, -0.14726101f, -0.31341001f, 
    0.18693492f, -0.01028984f, -0.01501324f, 0.27817082f, 0.11729786f, -0.14164196f, 0.21417877f, -0.25487369f, 
    0.19323686f, -0.42389590f, -0.13172013f, 0.33610824f, -0.00446660f, -0.14180994f, -0.11761127f, -0.04035740f, 
    -0.09448461f, -0.04510612f, 0.15320861f, 0.06229415f, -0.79957980f, 0.14108719f, 0.11815351f, 0.11328226f, 
    -0.10761791f, 0.04119642f, 0.23694804f, 0.27017552f, 0.01413397f, 0.13044049f, 0.10446978f, 0.02414288f, 
    -0.54047179f, -0.09964813f, 0.49177057f, 0.24521212f, -0.26509297f, -0.11475236f, 0.06258632f, -0.16374314f, 
    0.03228806f, -0.00885438f, -0.11187170f, -0.10886627f, -0.50698310f, -0.22413208f, -0.00381933f, 0.36970475f, 
    -0.13881850f, 0.02352930f, 0.13482088f, 0.14331442f, -0.37357965f, -0.04617373f, 0.15744305f, 0.13269004f, 
    0.22434530f, -0.12892087f, 0.10109829f, 0.16049758f, 0.29163626f, -0.07994188f, -0.09704737f, -0.00679747f, 
    -0.14310399f, 0.30191219f, -0.06260154f, 0.00030601f, -0.28000796f, 0.01365462f, 0.15497760f, -0.70878452f, 
    -0.04850335f, -0.04400691f, 0.03002636f, -0.11958595f, 0.14943564f, -0.10758739f, 0.00137406f, -0.14826551f, 
    0.23061019f, -0.28648677f, -0.14556137f, 0.03762775f, -0.06231916f, -0.09909014f, -0.04473409f, 0.07229379f, 
    0.27287346f, -0.02594581f, -0.05708148f, -0.11145966f, -0.36777636f, -0.27977395f, -0.78897762f, 0.16346064f, 
    0.31231239f, 0.05037196f, 0.21816696f, 0.07855079f, 0.26920134f, 0.16425069f, 0.04295075f, 0.05383954f, 
    -0.18197249f, 0.07415209f, -0.27663058f, 0.17325656f, 0.15600103f, -0.09603126f, 0.04079254f, 0.13874592f, 
    0.16517884f, -0.19820079f, 0.03836470f, -0.57964623f, -0.14824688f, 0.00212778f, 0.16979881f, 0.29485768f, 
    -0.07803630f, -0.33471677f, 0.04976922f, 0.04265543f, -0.01287240f, -0.08418082f, -0.01258056f, -0.06295820f, 
    -0.54391283f, 0.43475717f, 0.15625910f, -0.06422136f, -0.05584573f, 0.12086073f, 0.10790030f, -0.02979331f, 
    0.17229100f, 0.08602627f, -0.19618817f, -0.00693209f, 0.14784989f, 0.21561246f, -0.22404280f, 0.21560043f, 
    0.01108780f, 0.14744245f, 0.10461488f, -0.00527915f, -0.09712972f, -0.03312423f, 0.09823220f, 0.17090319f, 
    0.01001321f, -0.18617384f, -0.10401237f, -0.07951239f, 0.07546182f, -0.06045084f, -0.20271137f, 0.16256982f, 
    0.14976951f, -0.12283667f, 0.02252075f, -0.32876083f, -0.29793856f, -0.27826482f, -0.06000219f, 0.27383864f, 
    -0.29682946f, 0.09217039f, 0.01590882f, 0.11718951f, -0.18032850f, 0.27009213f, 0.22145399f, 0.25047582f, 
    -0.05996547f, 0.05906458f, 0.02331278f, 0.27829346f, -0.21644638f, -0.03767462f, 0.18265089f, 0.01627392f, 
    0.01136537f, -0.00185691f, -0.04960026f, 0.28618732f, -0.07404095f, 0.31991276f, 0.22783388f, 0.15419640f, 
    -0.10821850f, 0.08770059f, 0.10836935f, -0.41028240f, -0.16222593f, 0.28020996f, -0.11718871f, 0.13058540f, 
    0.37544504f, 0.24584414f, -0.12910813f, -0.03078532f, 0.19439004f, 0.11232746f, -0.26735049f, -0.45318875f, 
    -0.12541954f, 0.02996498f, -0.06633792f, 0.08251844f, -0.60354811f, -0.20807011f, -0.19913344f, -0.16262740f, 
    0.06974228f, 0.10558479f, -0.22843647f, 0.05992348f, 0.07425721f, -0.11436404f, -0.08827794f, 0.00112726f, 
    0.40072221f, -0.15118381f, 0.14912216f, 0.01218607f, -0.14901818f, -0.11412826f, 0.03965056f, 0.07008065f, 
    -0.08797292f, 0.09644951f, 0.18319847f, 0.36313322f, 0.01932752f, 0.30767494f, 0.04798376f, -0.33307344f, 
    -0.03812242f, -0.13938557f, -0.25333101f, -0.28885901f, -0.09927994f, -0.11888684f, -0.13249880f, -0.37432781f, 
    -0.02772598f, 0.14506555f, 0.04155670f, 0.03270525f, 0.02968162f, -0.09455362f, 0.14994405f, -0.10697103f, 
    0.36376810f, 0.04455143f, 0.04159515f, -0.26938018f, -0.58692855f, -0.02186410f, 0.20537324f, -0.25653467f, 
    -0.41661552f, 0.02413473f, 0.14797567f, 0.15481848f, -0.06107405f, -0.04436010f, 0.02939685f, -0.01590128f, 
    -0.84043664f, 0.26210046f, 0.03841295f, 0.42520270f, 0.06281656f, 0.30263504f, -0.01969687f, 0.19883677f, 
    -0.20050232f, 0.07731893f, 0.11139541f, 0.00391326f, -0.68367720f, 0.20004173f, 0.11812559f, -0.70223391f, 
    -0.29159555f, 0.04104637f, 0.11961129f, -0.25747544f, -0.39532942f, 0.12899184f, -0.16708094f, -0.02524121f, 
    -0.10236634f, -0.38217831f, 0.08634864f, -0.39430177f, 0.08314915f, -0.26028639f, -0.00486583f, -0.00435402f, 
    -0.08780148f, 0.17958090f, 0.00451441f, 0.21064453f, 0.12486364f, -0.50220150f, -0.54646575f, 0.37281936f, 
    0.47700283f, 0.08816025f, -0.25306395f, 0.07379604f, 0.11158856f, -0.07812257f, -0.07089769f, -0.00472166f, 
    0.81607270f, -0.28999367f, -0.02223197f, -0.28482530f, 0.09662581f, 0.10477129f, 0.04634840f, -0.04212295f, 
    0.06765669f, 0.09784849f, 0.04668466f, 0.00822866f, -0.33460200f, 0.43207952f, 0.01643704f, 0.55459690f, 
    -0.09928780f, -0.09246821f, -0.00981358f, 0.00688977f, 0.02434661f, 0.10541971f, -0.18076539f, -0.37930429f, 
    0.08373312f, -0.03241243f, -0.12897199f, 0.13970546f, -0.11568780f, 0.15895084f, 0.02122400f, -0.01384008f, 
    -0.04366680f, -0.03559876f, -0.20039287f, 0.01804112f, 0.20925473f, -0.05254463f, -0.12214667f, -0.10860575f, 
    0.15215433f, -0.12449335f, 0.13323776f, -0.11070038f, 0.04557288f, -0.27513430f, -0.02175940f, -0.17073154f, 
    0.09821425f, 0.35756409f, 0.03404288f, -0.67666978f, -0.16778503f, 0.02434614f, -0.07233347f, -0.03106333f, 
    0.04117550f, 0.09291454f, 0.03716407f, -0.00373025f, -0.20811458f, 0.34645206f, 0.13556238f, 0.12964666f, 
    -0.12529363f, 0.08261304f, -0.03879622f, 0.15833649f, 0.18428344f, -0.17342952f, 0.13546272f, -0.26381269f, 
    -0.30236480f, 0.14317760f, -0.04152206f, 0.45455566f, -0.15744412f, -0.15909889f, 0.18541233f, 0.12595646f, 
    0.16556925f, -0.08508471f, 0.05360934f, -0.00303045f, -0.46342140f, -0.09065043f, 0.00875610f, -0.22082667f, 
    0.10195216f, 0.04591015f, -0.02383786f, -0.07096127f, 0.12530966f, -0.11213503f, 0.08344750f, -0.03525740f, 
    0.12343698f, 0.17476165f, 0.16101867f, -0.13110591f, 0.12517536f, 0.15933853f, 0.10914101f, 0.01180792f, 
    -0.03314314f, -0.02642154f, -0.31265742f, -0.26104724f, -0.21208480f, -0.32987228f, -0.24559964f, -0.08888861f, 
    -0.11986198f, 0.05146525f, -0.06567410f, 0.13025162f, 0.07013937f, 0.11527703f, 0.32151181f, 0.46135706f, 
    0.23400258f, 0.17863612f, -0.41709650f, 0.17419596f, 0.04033012f, -0.01431428f, -0.07002530f, 0.13033962f, 
    -0.15859477f, -0.00842447f, 0.06829520f, -0.00073459f, -0.17021957f, 0.43959811f, 0.19402823f, -0.07613511f, 
    -0.11577451f, 0.11371735f, -0.24110767f, -0.16679932f, -0.21219163f, -0.13291931f, -0.26863301f, -0.32626387f, 
    -0.58309144f, -0.17745501f, -0.35349745f, -0.07282142f, 0.06806654f, -0.09645492f, -0.16606432f, -0.04400181f, 
    0.18745053f, -0.14342253f, -0.00988521f, -0.09262297f, 0.03020801f, 0.37442201f, 0.18247183f, 0.46949446f, 
    -0.01626749f, 0.22123356f, 0.14182293f, -0.11864179f, -0.24232669f, -0.05020856f, -0.04955520f, -0.36105156f, 
    0.37261471f, -0.09877919f, 0.23072542f, 0.56349730f, 0.26160365f, -0.24308896f, 0.16229340f, -0.21373168f, 
    0.01364322f, -0.04778684f, 0.09788913f, -0.13340381f, -0.28093231f, 0.13719159f, -0.12837893f, 0.18638039f, 
    -0.27775821f, -0.23982649f, -0.21391809f, -0.05017601f, -0.03230149f, -0.02823455f, 0.06760757f, -0.12024327f, 
    0.06564153f, -0.46249089f, -0.26292413f, -0.31299254f, -0.28095740f, 0.00150138f, 0.01145538f, -0.05371048f, 
    -0.02644489f, 0.08597135f, 0.08777038f, -0.30361894f, -0.46596768f, -0.13225396f, -0.17437346f, -0.38076264f, 
    0.24847656f, 0.01903682f, 0.12990595f, 0.03144236f, 0.01746741f, -0.21059963f, 0.00976083f, -0.09880653f, 
    0.43769023f, 0.49441221f, -0.12706469f, 0.27393666f, 0.14015651f, -0.13520862f, 0.01438413f, -0.00313403f, 
    -0.05399190f, 0.03586577f, 0.03627303f, -0.10643741f, 0.19449709f, 0.18147638f, 0.11476664f, 0.32044238f, 
    -0.13160998f, -0.22013256f, -0.03361443f, -0.13256805f, -0.02452728f, 0.19451152f, -0.10811815f, -0.07401597f, 
    -0.79091448f, 0.08772244f, -0.45486581f, 0.02917823f, -0.11275800f, -0.01132549f, 0.01230839f, -0.11297305f, 
    -0.23312895f, 0.14755218f, -0.03296226f, -0.11486053f, -0.19443014f, 0.17492992f, -0.02729721f, -0.09769323f, 
    -0.25136521f, -0.08248612f, 0.13756594f, -0.08074397f, -0.00836344f, -0.14609788f, -0.15156892f, -0.01969742f, 
    0.14933231f, 0.31660753f, -0.20293148f, 0.41286373f, 0.12927634f, -0.07390721f, 0.04545761f, 0.18508020f, 
    -0.09390757f, -0.10468318f, 0.03353369f, 0.05480051f, 0.10995476f, 0.37964520f, 0.40759727f, 0.09611128f, 
    -0.03119866f, -0.02289908f, 0.12703085f, 0.05699022f, -0.09102409f, 0.16119809f, -0.19887084f, -0.02248782f, 
    0.49061894f, -1.06432092f, 0.26755136f, 0.07777419f, -0.09445856f, -0.14010508f, -0.05355683f, -0.01381900f, 
    -0.04342650f, 0.08205552f, -0.03874394f, -0.13803244f, -0.01521527f, 0.08981812f, -0.18863468f, 0.04367556f, 
    -0.09820698f, -0.10462844f, 0.16861787f, -0.18950008f, 0.12727915f, -0.07589795f, 0.00163368f, -0.11816741f, 
    -0.47391504f, -0.48830482f, 0.00509937f, -0.66563880f, 0.12325557f, 0.12009094f, -0.43611220f, 0.09927975f, 
    0.05534449f, -0.03365884f, -0.03667176f, 0.03996978f, 0.45036349f, -0.16657513f, 0.19594973f, 0.33604574f, 
    0.02691155f, -0.16246107f, -0.17242667f, -0.04790540f, 0.06302701f, -0.06268183f, 0.05772702f, -0.18337080f, 
    0.38760111f, 0.38997459f, -0.42379171f, 0.01005931f, 0.10195113f, -0.11554169f, 0.16226244f, -0.00877003f, 
    -0.01637947f, -0.07743356f, -0.22042899f, 0.00485401f, -0.40879992f, -0.02826273f, 0.57251024f, 0.00500496f, 
    -0.22873002f, 0.07404497f, 0.04895647f, 0.03803844f, -0.06485165f, -0.01073437f, -0.08097181f, -0.05978048f, 
    0.00865056f, -0.66069537f, -0.18921052f, -0.16509712f, -0.10847373f, -0.05489524f, 0.15217236f, -0.20481788f, 
    0.03115559f, -0.05644480f, -0.12012802f, -0.30374086f, 0.10290305f, 0.33996421f, -0.55184311f, -0.31471652f, 
    -0.03606823f, -0.19911526f, -0.10093635f, -0.09482048f, 0.24544798f, 0.07527269f, 0.08235372f, 0.03768929f, 
    -0.22280405f, 0.05944091f, -0.05568912f, 0.29664034f, -0.12614605f, -0.23005939f, 0.09376588f, -0.05823553f, 
    0.04863663f, 0.00245926f, -0.07165196f, 0.23450206f, 0.50379002f, 0.09388380f, -0.41954210f, 0.08501653f, 
    0.05107328f, 0.02611714f, 0.01894495f, 0.06485708f, -0.06704409f, -0.02410305f, 0.19147639f, 0.17885232f, 
    -0.45333534f, 0.14543003f, -0.01486774f, -0.14867443f, -0.07480320f, 0.01502520f, -0.05035997f, 0.04668943f, 
    0.10446732f, -0.08059789f, 0.16315359f, -0.17410822f, -0.26683822f, -0.34065270f, -0.11449456f, -0.41415182f, 
    -0.05699240f, -0.16572843f, 0.03413859f, -0.35473150f, 0.00394444f, 0.13248493f, 0.05110599f, 0.25471690f, 
    -0.52274573f, 0.05180989f, 0.08600771f, 0.46481636f, 0.23983218f, -0.05619628f, -0.03066645f, -0.04365693f, 
    0.06335678f, 0.22217011f, 0.04176313f, -0.10598700f, 0.28872564f, 0.29373884f, -0.14039026f, 0.27790537f, 
    0.16308369f, 0.11922133f, -0.17459565f, -0.11946545f, -0.09212961f, 0.04122388f, 0.24949992f, -0.26303118f, 
    -0.25003052f, 0.38062465f, -0.26037270f, -0.06549991f, 0.09448136f, 0.05209487f, -0.47877386f, -0.07350294f, 
    -0.08504182f, -0.34020102f, 0.00715504f, -0.10570874f, -0.34082937f, 0.42247573f, -0.05078831f, -0.11077059f, 
    -0.15611723f, 0.09690347f, -0.11496591f, -0.11067912f, 0.06403063f, -0.04444388f, 0.01584029f, 0.12376919f, 
    0.08762859f, -0.39494905f, -0.39533654f, 0.00687802f, 0.00266628f, -0.05573692f, -0.02447679f, -0.07843335f, 
    0.13027556f, 0.22338519f, 0.11913919f, 0.24796782f, 0.04185447f, 0.17673022f, -0.00529162f, 0.29102618f, 
    -0.07016215f, -0.06897272f, -0.13579145f, -0.15438086f, -0.16062456f, 0.08259642f, -0.08575122f, -0.23058175f, 
    0.34503767f, -0.31109422f, 0.10511396f, 0.18409178f, -0.18604968f, -0.12138315f, -0.04554697f, 0.11810550f, 
    -0.08457804f, -0.07485764f, -0.02691247f, 0.09574369f, -1.26111460f, 0.75031030f, -0.19051611f, -0.30575475f, 
    0.12834965f, -0.08942161f, 0.07997335f, -0.29448372f, -0.12570047f, -0.04376106f, 0.03819945f, 0.22125059f, 
    0.47852415f, 0.35012272f, 0.32069314f, 0.18495889f, -0.12665275f, 0.05709091f, -0.18210994f, 0.05788146f, 
    0.09369944f, 0.11881275f, 0.02166405f, -0.13698608f, 0.31121215f, -0.04037957f, 0.07563961f, -0.36777139f, 
    0.10906315f, -0.01742045f, 0.00364432f, 0.11582428f, 0.03396507f, -0.11899877f, 0.25136057f, 0.03877963f, 
    -0.08700018f, -0.40602812f, 0.13996853f, 0.08253603f, 0.03803811f, -0.04977915f, -0.06612022f, -0.22587404f, 
    -0.14906859f, 0.02846721f, 0.02919487f, 0.28208411f, -0.19348869f, 0.21736671f, 0.30119652f, 0.10300919f, 
    0.01374447f, 0.17648950f, -0.08744424f, -0.12126479f, -0.11109528f, -0.09247233f, -0.14153627f, 0.00603688f, 
    0.17565590f, 0.43514991f, -0.48937085f, -0.20120023f, 0.20062910f, -0.15530312f, -0.07560597f, -0.09143072f, 
    -0.05028449f, 0.06713574f, 0.16762827f, -0.13245007f, 0.60173231f, 0.26068449f, 0.41023079f, -0.06972776f, 
    -0.05253478f, -0.01010736f, 0.09773476f, 0.09497065f, -0.01259225f, 0.04137747f, -0.03171162f, -0.23279704f, 
    -0.84241593f, 0.27541003f, 0.54544872f, -0.15301019f, 0.12117358f, 0.22538927f, -0.03520466f, 0.14599058f, 
    0.12435435f, -0.08323772f, -0.12431690f, 0.08226743f, -0.08692573f, 0.22288674f, -0.67437488f, -0.18595023f, 
    0.13453016f, -0.20225964f, 0.02971312f, -0.05059126f, 0.23116057f, -0.07959041f, -0.24127461f, -0.07247105f, 
    -0.58701646f, 0.18143566f, -0.09674617f, -0.79953820f, 0.10182917f, -0.02806013f, -0.13616306f, -0.05172401f, 
    -0.15732880f, -0.08504295f, 0.04904082f, -0.14902245f, -0.12687987f, -0.14872919f, 0.03468635f, 0.13795103f, 
    0.05495134f, -0.08517294f, 0.12333806f, 0.18341620f, 0.18411876f, 0.08888852f, -0.09372956f, 0.07206393f, 
    -0.24199945f, -0.15075421f, 0.59931666f, -0.20152462f, -0.10222274f, -0.01634858f, 0.15746747f, 0.29012129f, 
    -0.02848782f, -0.20167020f, 0.02865308f, 0.01195171f, -0.31438169f, -0.65373242f, -0.06351577f, 0.32981202f, 
    0.02676103f, 0.04741210f, -0.17199063f, 0.07321157f, -0.20340621f, 0.07932667f, -0.01867915f, -0.02655001f, 
    0.11100467f, -0.33140400f, -0.11418647f, -0.26840389f, -0.06866794f, -0.11541636f, -0.30385467f, 0.12058092f, 
    0.07137255f, -0.21927826f, -0.03496652f, -0.43296510f, 0.04389453f, 0.05344638f, 0.16983241f, 0.07547639f, 
    0.24652673f, -0.02859787f, 0.23187488f, 0.09298116f, 0.26353106f, 0.20894194f, 0.15014768f, -0.01715916f, 
    -0.27890489f, -0.12077373f, 0.28711712f, -0.06945287f, 0.32161719f, 0.02796795f, -0.04865900f, 0.02003256f, 
    -0.04842953f, -0.13524105f, -0.27608824f, 0.20171160f, -0.86818516f, -1.01869559f, -0.44355291f, -0.07485403f, 
    0.02784375f, 0.03726479f, 0.08817446f, 0.02797606f, 0.27807218f, -0.03666507f, 0.09883748f, 0.16863137f, 
    -1.15495396f, -0.58538389f, 0.02932447f, 0.24512668f, 0.16823438f, 0.06985421f, 0.30938408f, -0.17449306f, 
    0.10101987f, 0.04645431f, -0.08365667f, 0.07242253f, 0.15343291f, -0.02103337f, 0.17923898f, 0.18979238f, 
    0.04039423f, -0.12463623f, -0.07408334f, -0.40096381f, 0.13869143f, 0.28144097f, -0.06995701f, -0.02964235f, 
    0.09648049f, 0.21043836f, -0.04504519f, 0.14876954f, -0.27468449f, 0.26770565f, 0.06561558f, -0.16407052f, 
    0.00070423f, -0.36389852f, -0.12200400f, -0.52976805f, -0.15726092f, -0.08591978f, 0.23780859f, 0.16593654f, 
    0.32039434f, 0.10398766f, -0.02585986f, 0.05612985f, 0.12969965f, 0.11466628f, 0.19327383f, 0.08796713f, 
    -0.21456632f, -0.21516888f, -0.26419681f, 0.10958857f, 0.06289831f, -0.37479424f, -0.00700791f, 0.21650530f, 
    -0.00340407f, -0.03371133f, -0.05281438f, 0.34726766f, -1.12555063f, -0.34568039f, -0.01074522f, 0.32353607f, 
    0.24909623f, 0.04125004f, -0.15950362f, -0.01954622f, -0.15533745f, 0.07308906f, -0.00595239f, 0.29389745f, 
    -0.12128494f, -0.13158335f, -0.13822682f, -0.11465104f, -0.17145118f, -0.03868832f, 0.17018600f, 0.13850617f, 
    0.00212509f, 0.17829899f, 0.28247264f, -0.05706387f, 0.40811211f, 0.06738652f, -0.21549742f, 0.04798760f, 
    0.07694836f, 0.16482385f, 0.02323542f, -0.04026269f, 0.10925338f, 0.19256251f, 0.04546066f, 0.05188287f, 
    -0.46988070f, -0.04912731f, -0.08603834f, -0.64390141f, 0.11382367f, -0.04439698f, 0.05619654f, 0.01393456f, 
    0.11997276f, 0.02141920f, 0.08657922f, 0.16152412f, -1.06097412f, -0.51925868f, -0.23219343f, -0.54043794f, 
    0.07342493f, 0.10393272f, -0.24486265f, -0.29555097f, -0.08727631f, 0.09142115f, -0.08993667f, 0.09714925f, 
    -0.10660806f, -0.26243469f, 0.02221228f, 0.17193885f, -0.11333638f, 0.00053891f, -0.07054218f, -0.31680357f, 
    -0.05451011f, -0.11534773f, 0.08547347f, 0.00392780f, 0.44757739f, -0.00992190f, 0.04715230f, -0.14837326f, 
    -0.11979482f, 0.05869005f, 0.00788698f, 0.10814168f, 0.04292607f, -0.05618520f, 0.12422114f, -0.09089007f, 
    -0.33811933f, 0.26886451f, -0.10216418f, -0.05112929f, 0.13252157f, 0.26206034f, 0.07886711f, 0.02853449f, 
    0.09093568f, 0.30592915f, 0.11011812f, 0.39532346f, 0.78366017f, -0.03337219f, -0.13755022f, 0.06912444f, 
    -0.26295024f, -0.00287575f, -0.03230979f, 0.00191515f, 0.09293071f, -0.20996426f, -0.34527591f, -0.19071768f, 
    0.00856265f, 0.36449471f, -0.08486881f, -0.49146336f, -0.26054156f, 0.23729786f, 0.15086386f, 0.00562048f, 
    0.03250527f, -0.21779360f, 0.07977017f, -0.07992875f, -0.78482491f, -0.29503566f, -0.18608354f, -0.31442535f, 
    0.22956870f, 0.06788924f, 0.16877720f, 0.15000388f, 0.13494635f, 0.04669781f, -0.01102743f, -0.07414924f, 
    0.45489654f, 0.22462462f, -0.02833402f, 0.06926725f, -0.01652251f, 0.12871084f, -0.05752930f, 0.01804583f, 
    -0.02392870f, -0.00106612f, 0.30190721f, 0.09175722f, 0.14042205f, -0.33597797f, 0.06918068f, -0.15677385f, 
    -0.22490276f, -0.02257485f, -0.26394558f, -0.04449574f, -0.13634330f, -0.13138519f, -0.02320496f, -0.09267035f, 
    0.22212808f, 0.06241265f, 0.00228888f, 0.14937179f, -0.22742726f, -0.05130094f, -0.23243508f, -0.29441988f, 
    0.38158134f, 0.10892204f, 0.18257090f, 0.15787017f, 0.16721806f, -0.07713730f, -0.44484070f, 0.27967981f, 
    0.07137652f, 0.12593257f, -0.25125435f, -0.02214282f, 0.07172366f, -0.02945583f, 0.00071277f, -0.14561769f, 
    0.27946767f, -0.24954024f, 0.33733907f, -0.13231242f, -0.01131998f, 0.11495266f, -0.03381345f, 0.00750436f, 
    -0.24532175f, 0.07337631f, 0.03486194f, 0.05440229f, 0.72980464f, -0.38218012f, 0.08731546f, -0.27322179f, 
    -0.05861113f, -0.23017998f, -0.09826344f, 0.17551711f, 0.15311354f, 0.10795839f, 0.12010668f, 0.27647117f, 
    0.42911589f, -0.19216363f, -0.18567090f, 0.27467352f, 0.00254662f, 0.05750981f, -0.12927206f, -0.02678988f, 
    -0.23356028f, 0.01390849f, -0.27770537f, 0.22778739f, 0.02581036f, -0.66607600f, 0.00128315f, 0.36074451f, 
    0.24357641f, -0.00286723f, -0.05674844f, -0.01969097f, 0.13036972f, -0.14737147f, 0.21800496f, 0.00535256f, 
    0.78761077f, 0.03974978f, -0.56113601f, 0.11524221f, 0.09470392f, -0.01918526f, 0.08106150f, -0.05161495f, 
    0.09104248f, 0.11757449f, -0.02127246f, -0.00610116f, -0.17503442f, -0.88278276f, 0.00565460f, -0.25029102f, 
    -0.08144876f, -0.16870402f, -0.09719057f, 0.06636832f, -0.22726311f, 0.05670193f, -0.10786455f, -0.12426525f, 
    -0.23617564f, 0.00264172f, -0.09507973f, 0.04110931f, -0.26853320f, 0.08565544f, -0.04329281f, -0.06724988f, 
    -0.04780318f, 0.01322989f, -0.12312580f, -0.15962586f, 0.05699017f, 0.18393533f, -0.10719974f, 0.09730312f, 
    0.24586862f, -0.20105998f, 0.23839451f, -0.09495868f, -0.05693520f, -0.02308361f, 0.16825224f, -0.06888533f, 
    0.20190144f, 0.17428254f, -0.31975225f, 0.10356436f, -0.13559248f, -0.05636163f, -0.08060351f, 0.09301633f, 
    -0.22243033f, -0.02262233f, -0.09684978f, 0.08091597f, -0.49072415f, -0.37114057f, -0.13313052f, 0.01277199f, 
    0.11771503f, 0.01627993f, 0.10263436f, 0.15044320f, 0.06540264f, -0.00960830f, -0.03600031f, 0.04189222f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19871832f, 0.02099212f, -0.15510982f, 0.07245042f, 0.01776978f, 0.03340767f, 0.04901335f, -0.12486192f, 
    -0.10836164f, -0.02501404f, 0.24710524f, 0.03706728f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
