#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.88146055f, 0.12456351f, 0.05036978f, -0.12523668f, -0.68906373f, -0.62940520f, -0.49514413f, -0.59541196f, 
    -0.88184416f, -0.57582635f, -0.06483538f, -0.16343057f, -0.25902840f, -0.51321089f, 0.30945367f, -0.04985799f, 
    0.11693375f, 0.10779113f, -0.14561917f, 0.10296786f, -0.17382403f, -0.22026654f, -0.23658401f, -0.41944626f, 
    -0.38759056f, -0.48275593f, -0.49767029f, -0.44788215f, -0.40661743f, 0.10308514f, -0.42698354f, -0.69515783f, 
    -0.20245159f, -0.40700623f, -0.46436960f, 0.00878466f, 0.05631072f, 0.17828709f, 0.30131435f, -0.38204473f, 
    -0.01763245f, -0.27510488f, -0.24487926f, -0.02621203f, -0.08819842f, 0.21085791f, 0.37057549f, 0.36547178f, 
    0.28409883f, 0.42292345f, -0.49786472f, -0.28207079f, 0.02113615f, 0.38559130f, 0.53565353f, -0.84582216f, 
    -0.08117431f, 0.07013772f, -0.36498803f, 0.26540542f, 0.48464262f, -0.10158063f, 0.15498707f, 0.08948380f, 
    -0.14966340f, 0.31515777f, 0.13331789f, -0.29711667f, -0.37515396f, -0.18510535f, 0.05076388f, 0.34511197f, 
    0.15963380f, 0.12834802f, 0.15157478f, -1.26861262f, -0.49936983f, -0.36844897f, -0.91896504f, -0.89172459f, 
    0.36229214f, -0.23130353f, -0.49659130f, 0.18086323f, -0.04050045f, -0.03606907f, 0.28086066f, 0.28294286f, 
    0.29828885f, -0.18087293f, 0.39421898f, -0.15886627f, -0.09032125f, 0.23236293f, -0.00831812f, 0.14584258f, 
    0.41738850f, 0.16596192f, -0.16500130f, 0.02653476f, -0.70449716f, -0.88981384f, -1.14583373f, -0.43480596f, 
    -1.07568657f, 1.00989676f, 0.72925377f, 0.30493960f, 0.03849396f, 0.19316933f, -0.11778545f, 0.15539476f, 
    0.25526631f, -0.07009731f, -0.38964468f, -0.32141319f, -0.18432347f, 0.07786872f, -0.09699214f, -0.08098381f, 
    -0.19758798f, -0.20578033f, 0.00122405f, 0.27570310f, -0.18055269f, -0.81140500f, -0.03478616f, 0.34508133f, 
    0.23593719f, 0.22517559f, 0.00385131f, 0.70420736f, 0.00832474f, -0.22535263f, -0.53609538f, -0.11355820f, 
    -0.15077671f, -0.01664956f, 0.15437840f, -0.09975100f, 0.01167337f, -0.15588333f, 0.36478031f, -0.24639469f, 
    -0.30191278f, 0.05522194f, -0.04633833f, 0.21761520f, 0.22312666f, -0.02048248f, -0.92943448f, -0.44313315f, 
    0.63303995f, 0.32135630f, -0.49143714f, 0.37879318f, -0.30285689f, -0.33442858f, 0.14782318f, 0.43076250f, 
    0.05816774f, -0.56357723f, 0.17482787f, -0.44398919f, 0.34369168f, 0.12782066f, 0.08953406f, -0.07101130f, 
    0.08027628f, -0.06968902f, 0.06505028f, 0.10718683f, -0.25153849f, -0.19321239f, 0.57676476f, 0.50689059f, 
    0.86941665f, -0.43659389f, -0.86961997f, -0.24871501f, -0.34234047f, -0.00506596f, 0.18099315f, -0.07842970f, 
    -0.32290560f, -0.23681547f, 0.01959980f, 0.29855776f, 0.06179482f, -0.08874242f, -0.07868674f, 0.01394156f, 
    -0.48797825f, -0.46223110f, -0.53684193f, -0.17236447f, -0.14287850f, -0.24819945f, -0.49262589f, -0.61856729f, 
    -0.19063583f, -0.57759905f, -0.27581370f, 0.07236436f, 0.17741652f, 0.67999810f, 0.20944783f, 0.14213316f, 
    -0.03974022f, 0.27334800f, 0.15659061f, 0.07823467f, 0.22340025f, 0.07921811f, 0.16957882f, 0.03183729f, 
    -0.24569769f, 0.25446060f, 0.16038875f, -0.20040011f, 0.04609465f, 0.32223195f, -0.05194696f, 0.14081457f, 
    -0.20190011f, -0.61197078f, 0.48117718f, -0.14940628f, -0.01176011f, 0.25934306f, -0.35942170f, -0.62083024f, 
    0.54741812f, -0.15863086f, -0.26465034f, 0.11149637f, -0.87645668f, 0.41755801f, -0.36897475f, -0.41961828f, 
    0.33441290f, -0.05993970f, 0.32339475f, -0.15120518f, -0.27025688f, -0.35269666f, -0.33916163f, 0.15180780f, 
    0.34354562f, -0.07471336f, 0.49498907f, -1.07532310f, -1.17941391f, -0.59509498f, -0.06469369f, -0.35678908f, 
    0.02828036f, 0.09621522f, 0.30238470f, -0.70005858f, 0.60070276f, 0.40488243f, 0.54392934f, -0.29449049f, 
    0.24282779f, 0.29262397f, -0.22679880f, -0.23960200f, -0.14400086f, -0.23679052f, -0.40623876f, -0.00398143f, 
    0.00457764f, 0.23516628f, -0.18266994f, 0.91037190f, -0.82175499f, -0.44723701f, 0.27679643f, 0.34821847f, 
    0.00208530f, 0.06481699f, 0.43384001f, -0.21785831f, -0.23418793f, -0.10582703f, -0.35512915f, 0.17520690f, 
    -0.59827763f, 0.27258205f, 0.08332466f, -0.01977444f, -0.05797789f, -0.01626973f, -0.29704413f, -0.34382033f, 
    -0.59440488f, -0.47689602f, -0.44868660f, -0.62445712f, -0.12057098f, 0.38170043f, -0.53235239f, -0.45602879f, 
    0.12648077f, 0.43145102f, -0.00199123f, 0.09890985f, 0.08302860f, 0.29499799f, -0.09694476f, -0.32037938f, 
    -0.18950199f, 0.22845660f, 0.06925685f, -0.40987104f, -0.21644583f, -0.20837934f, -0.02421167f, 0.14669622f, 
    0.31889844f, 0.19462836f, 0.33010170f, 0.08209442f, 0.12474823f, -1.48013556f, 0.44105622f, -0.05255990f, 
    0.03610177f, 0.43695310f, 0.44110486f, 0.23567531f, 0.36865902f, -0.14734536f, -0.14670081f, 0.22910185f, 
    -0.23151426f, -0.23166250f, -0.15651727f, -0.12878612f, 0.03907541f, -0.12380553f, -0.30721071f, -0.11784443f, 
    -0.01281372f, -0.08317769f, -0.20232715f, -0.23481633f, -0.22347267f, -0.65570992f, -0.34260458f, -1.02650392f, 
    0.59981388f, 0.65130448f, 0.35909778f, -0.09723206f, -0.24451138f, 0.45308605f, -0.78604084f, -0.25990397f, 
    -0.18380040f, -0.52640861f, 0.04903190f, -0.28473321f, 0.22693138f, 0.02763438f, -0.26760519f, -0.06789143f, 
    0.24001925f, 0.56246591f, 0.00810497f, -0.03593857f, -0.11726421f, -0.11979914f, -0.04315767f, -0.34579813f, 
    0.02536269f, 0.21413322f, 0.17137624f, 0.25422627f, 0.20863882f, -0.26003820f, -0.18543413f, 0.24098153f, 
    0.10940775f, 0.37470639f, 0.14538847f, -0.27644154f, -0.43396601f, 0.48848906f, -0.15782291f, -0.04254165f, 
    -0.23559999f, -0.29571143f, 0.24294612f, 0.15659608f, 0.16193978f, 0.15801699f, -0.23064822f, 0.16497990f, 
    -0.98312485f, -1.01762199f, -0.84961247f, -0.00076907f, 0.11372080f, 0.17803890f, -0.53042787f, -1.11532855f, 
    -1.10198236f, -0.85074699f, -0.36276084f, 0.05197855f, 0.03818325f, 0.69926131f, -0.39503339f, -0.13498273f, 
    -0.63452882f, -0.22904412f, 0.20879859f, -0.13228354f, -0.33676720f, -0.02695054f, -0.34154660f, 0.00213285f, 
    -0.13341993f, 0.16205701f, 0.28411859f, 0.54579854f, 0.41893563f, 0.51490963f, 0.47518259f, -0.17318945f, 
    -0.38151827f, -0.11855951f, 0.23710813f, 0.36043099f, -0.15614738f, -0.11359970f, -0.03187501f, 0.00780499f, 
    -0.15071981f, -0.13813016f, -0.13231102f, -0.06101201f, 0.01149979f, 0.36067995f, -0.16992003f, -0.12596601f, 
    -0.11211482f, -0.04388852f, -0.27193832f, 0.57687420f, -0.29121682f, -0.83221090f, -0.24838917f, -0.00744833f, 
    0.24919486f, -0.16820876f, 0.27308008f, 0.39691743f, 0.15351257f, 0.49501470f, 0.20069100f, -0.18225878f, 
    0.03171803f, -0.42684382f, -0.14914286f, -0.22006081f, 0.04317376f, -0.40288812f, 0.19467784f, 0.40035805f, 
    0.30994019f, 0.25977010f, 0.03603803f, 0.57584536f, 0.51021516f, 0.41273087f, -0.31290215f, -0.64754242f, 
    -0.51920700f, 0.42840084f, -0.10494251f, -0.01412068f, 0.13187622f, 0.64274675f, -0.46202388f, 0.09089062f, 
    -0.15880242f, -0.10266146f, -0.25446531f, -0.14403687f, 0.00534551f, 0.16428541f, 0.02868664f, -0.14105405f, 
    0.34077534f, -0.24760193f, -0.22779600f, -0.04282995f, -1.20239723f, -0.61087102f, -0.22099374f, 0.10511681f, 
    0.27495778f, 0.32833982f, 0.27506927f, 0.53092742f, 0.13256463f, 0.27099913f, 0.02994260f, 0.00344121f, 
    0.04737368f, -0.09713098f, -0.13161460f, 0.08556203f, 0.29503065f, -0.07794081f, -0.11669400f, 0.07311843f, 
    -0.08860484f, -0.00509271f, 0.01329982f, -0.09335027f, -0.04324120f, 0.64821100f, -0.44083658f, 0.10170312f, 
    0.61999077f, -0.35837540f, -0.73833638f, -0.63877910f, -0.62459034f, 0.00737202f, 0.26104510f, -0.56358969f, 
    0.21604760f, -0.36405832f, 0.08053392f, 0.39296824f, -0.31456307f, 0.16855268f, -0.31614128f, -0.03152250f, 
    -0.61095440f, 0.06122264f, -0.33754411f, -0.06038588f, -0.26576012f, 0.05820241f, -0.37073749f, -0.68160552f, 
    0.22014940f, 0.27219090f, 0.31270111f, 0.73210615f, 0.10482800f, -0.44595534f, -0.36369604f, 0.31290379f, 
    0.43145800f, 0.26233664f, 0.18968087f, -0.51775789f, -0.44982207f, -0.12554923f, -0.21792075f, 0.22239614f, 
    -0.12085284f, -0.02571873f, -0.07926496f, -0.33350500f, 0.20254643f, 0.35861439f, 0.16959472f, -1.14443624f, 
    -0.13394740f, -0.09597729f, 0.26212323f, 0.25095212f, 0.45897827f, -0.38775113f, 0.18558168f, 0.79814744f, 
    0.78057444f, -0.33725613f, 0.25668678f, -0.03508699f, 0.30948335f, -0.36454067f, -0.52058750f, 0.04101649f, 
    -0.05227836f, 0.14090921f, -0.36934593f, -0.01890143f, 0.38853306f, 0.37423924f, -0.26983190f, 0.02794298f, 
    1.34290123f, -0.20198615f, -0.44709313f, 0.09408307f, -0.38314602f, -0.57600653f, 0.80041152f, -0.48783684f, 
    0.00134145f, -0.00859326f, -0.09323237f, -0.10949157f, 0.16022781f, 0.20298930f, 0.00116296f, 0.10398390f, 
    -0.11866695f, 0.03935791f, 0.41642830f, -0.45711350f, 0.07435707f, -0.07282488f, 0.16625847f, 0.18757303f, 
    -0.02710941f, 1.40781963f, -1.03042638f, -0.54578805f, 0.02998517f, 0.31516972f, 0.06883886f, -0.27656382f, 
    -0.41754904f, -0.27543142f, -0.68633163f, -0.44531846f, -0.08707771f, 0.36844108f, -0.52963209f, -0.23595119f, 
    0.14112981f, 0.50868767f, -0.11978470f, -0.04968560f, 0.04616618f, -0.19965883f, 0.23768760f, 0.03619576f, 
    -0.21603633f, 0.35801297f, -1.00098920f, 0.04029128f, -0.20296539f, -0.98478085f, -0.64273465f, 0.16811264f, 
    0.22639081f, -0.19773178f, -0.10234215f, 0.37290010f, -0.18706363f, -0.68039757f, -0.28870285f, 0.17364866f, 
    -0.13281950f, 0.49586278f, 0.12910736f, -0.00964490f, -0.03786150f, -0.18819629f, -0.29459882f, -0.17701410f, 
    -0.25744298f, -0.02276578f, -0.09632089f, 0.50465357f, 0.84165400f, 0.45548803f, 0.33724239f, 0.33639419f, 
    -0.41719413f, -0.43943331f, -0.18824546f, -0.44466010f, -0.60048348f, -0.14614959f, -0.11578432f, -0.01438564f, 
    0.01237027f, 0.37008053f, -0.13526312f, 0.14782006f, -0.31350976f, 0.01154225f, 0.27220935f, -0.13131675f, 
    -0.03618483f, -0.10228663f, 0.24636663f, 0.04861301f, -0.58101922f, -0.79983085f, -0.62564039f, -0.35333425f, 
    0.14343341f, -0.13101415f, -0.34780002f, -0.68083805f, -0.03750287f, 0.71295530f, -0.20194139f, -0.36114308f, 
    -0.22208855f, 0.05089439f, 0.23015787f, 0.13834633f, 0.37678987f, 0.11248920f, 0.35510930f, -0.22683588f, 
    -0.15517378f, 0.01565323f, -0.01294345f, -0.37807953f, -0.22343437f, -1.21340346f, 0.08403995f, 0.34485668f, 
    -1.08911943f, -0.07699569f, -0.13026421f, -0.45019233f, -0.78834945f, -0.93937647f, -0.12192979f, -0.08297393f, 
    -0.01982064f, -0.37306586f, -0.31769246f, 0.25005019f, -0.26478463f, -0.43343422f, -0.37724039f, -0.64078498f, 
    -0.91492414f, 0.00007701f, -0.08431420f, 0.19941768f, -0.29506022f, -0.15930812f, -1.28858101f, -0.57968092f, 
    0.50310129f, 0.80700564f, 0.69441956f, -0.14203583f, -0.87220478f, -0.28088942f, 0.59244698f, 0.24879830f, 
    -0.23224725f, -0.18852720f, -0.23642939f, 0.31436622f, -0.11783804f, -0.17954750f, 0.15443239f, 0.19479594f, 
    0.22067761f, 0.19489871f, 0.16992342f, -0.20280758f, -0.12629549f, -0.24306922f, 0.07941841f, 0.03692918f, 
    0.02423621f, 0.43166104f, 0.01922755f, 0.02046936f, -0.16364938f, 0.56866533f, 0.38628212f, -0.21525314f, 
    0.25230199f, -0.20331891f, 0.30470127f, -0.01550538f, -0.32111290f, 0.12709343f, 0.17189832f, 0.22703543f, 
    -0.18514578f, 0.01275772f, 0.05867898f, 0.03915872f, 0.24209131f, 0.01201912f, -0.50351846f, -0.21691500f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.27958021f, -0.17860357f, 0.43525523f, 0.14931729f, 0.42937136f, 0.30133453f, 0.27447107f, 0.07130128f, 
    -0.12048911f, 0.21317050f, 0.66483825f, -0.21522546f, 0.09187561f, 0.23083191f, 0.32477167f, 0.31837627f, 
    -0.55147475f, 0.23653688f, 0.08251150f, 0.31022525f, 0.12710655f, 0.05028979f, 0.29353896f, 0.43334347f, 
    0.30772227f, 0.28998891f, -0.34377292f, 0.19997256f, -0.05010219f, 0.18246271f, 0.23640364f, 0.22366019f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15697667f, 0.07476965f, -0.02206160f, -0.04236312f, 0.09701307f, -0.02547840f, 0.10767666f, 0.04708578f, 
    -0.10100835f, 0.06479122f, 0.06070738f, 0.04855548f, 0.32315797f, 0.31530640f, 0.02299619f, -0.22070256f, 
    0.10166449f, 0.11621565f, 0.06414711f, -0.07608544f, 0.01895460f, -0.07714474f, -0.00017515f, -0.00208031f, 
    -0.21114348f, 0.37749067f, 0.20558186f, -0.19817112f, -0.19063736f, -0.13339093f, -0.01172300f, -0.29247394f, 
    -0.10446684f, 0.01400858f, -0.27194700f, -0.19319542f, 0.35420913f, 0.19938034f, -0.08059732f, -0.20673209f, 
    0.03634271f, 0.21794066f, 0.03932004f, -0.17453286f, 0.05147792f, 0.05275820f, 0.04272706f, 0.08942502f, 
    0.41367689f, -0.05194262f, -0.45860049f, -0.14340183f, 0.17238976f, 0.13915353f, -0.06213991f, -0.22035158f, 
    -0.09249426f, 0.01241739f, -0.07026624f, -0.01237568f, 0.02718775f, -0.32490861f, 0.01986454f, -0.30015850f, 
    -0.20393495f, -0.27239108f, 0.02837025f, 0.03399613f, -0.11255263f, -0.11998065f, -0.07897750f, -0.00717140f, 
    0.27869448f, 0.12405213f, 0.12385508f, -0.45940864f, -0.24892694f, -0.15241301f, 0.08866411f, -0.00916735f, 
    0.08952758f, -0.04805706f, -0.15355401f, -0.14620851f, 0.09363714f, 0.08528128f, -0.30161619f, 0.10869573f, 
    -0.02591749f, -0.13751969f, -0.14781274f, -0.02695794f, -0.02979944f, -0.08112402f, 0.02442191f, 0.13745804f, 
    0.08725365f, 0.14131249f, 0.01145822f, 0.04417051f, 0.03962324f, 0.06433888f, 0.07107542f, 0.05613162f, 
    -0.26683223f, -0.19701213f, -0.20618774f, 0.02889779f, -0.24497457f, 0.36576310f, 0.12924832f, -0.22374924f, 
    -0.06949519f, -0.19648066f, -0.05345944f, 0.03157217f, -0.05540041f, -0.09462129f, -0.02664772f, 0.06572722f, 
    0.41484350f, 0.12648334f, -0.46822143f, -0.20618114f, 0.09309068f, -0.04538016f, -0.15028299f, -0.22878426f, 
    -0.15456094f, -0.02895512f, -0.13657971f, -0.00151561f, -0.01858786f, -0.22453637f, -0.09361147f, 0.15286399f, 
    -0.05723901f, 0.08096776f, 0.00958428f, -0.05887320f, 0.04234399f, 0.00069419f, 0.05183572f, 0.26749277f, 
    -0.12442923f, -0.14043871f, -0.06239958f, 0.11236165f, 0.02111402f, 0.10563731f, 0.00445903f, 0.04395564f, 
    -0.04546987f, -0.08508810f, -0.15771848f, -0.27475733f, -0.04805136f, -0.22886398f, -0.33491644f, -0.21143469f, 
    -0.07386764f, 0.08510439f, 0.06524090f, 0.05117856f, -0.13178942f, 0.09861129f, 0.14868963f, 0.10405909f, 
    0.62515098f, -0.01359587f, 0.11536600f, -0.60601211f, -0.04052428f, -0.06809247f, 0.15363045f, -0.12524870f, 
    -0.02512428f, -0.08377746f, 0.00165061f, 0.02852159f, -0.10908875f, -0.14029655f, 0.06376163f, -0.05162558f, 
    -0.08565173f, 0.05061914f, -0.01978648f, 0.02359098f, -0.01536089f, 0.00580090f, 0.01403840f, -0.05843556f, 
    0.67185980f, 0.19354224f, -0.22636342f, -0.25942349f, 0.08814758f, 0.09718659f, 0.23139691f, -0.03165898f, 
    -0.06324384f, -0.05829749f, 0.00265342f, -0.03579176f, -0.60129315f, -0.25633627f, 0.03592991f, -0.00710968f, 
    0.07548723f, 0.06407297f, -0.00522826f, -0.00577099f, -0.04804258f, 0.03873921f, 0.01838451f, 0.07943006f, 
    0.00900062f, -0.34388408f, -0.10218853f, 0.02660455f, 0.10319606f, 0.07634329f, -0.00194920f, -0.17687704f, 
    -0.27867815f, -0.31353667f, -0.17312600f, -0.05321214f, -0.50266469f, -0.48154318f, 0.14593883f, 0.02764076f, 
    -0.02508866f, 0.03332620f, -0.00572036f, -0.00306046f, -0.13864087f, -0.15029384f, -0.09986418f, -0.09250475f, 
    0.16163561f, 0.01196937f, -0.00250731f, 0.01453169f, 0.05358268f, 0.05827821f, 0.14245923f, 0.02164083f, 
    -0.00913347f, -0.01340981f, -0.02749957f, -0.13917324f, -0.07160135f, 0.25875652f, 0.13409863f, -0.55278677f, 
    -0.33116159f, -0.10401431f, -0.08031177f, -0.07311450f, -0.08792518f, -0.15121624f, -0.02709404f, -0.00062678f, 
    0.16627432f, -0.07211138f, 0.29935032f, -0.07336336f, -0.16616794f, -0.11623868f, 0.09137726f, -0.03823940f, 
    0.02656631f, -0.11345048f, -0.09244402f, -0.06273976f, -0.48423535f, -0.12300835f, 0.23686372f, -0.29249063f, 
    0.01001965f, 0.12640600f, 0.02753088f, 0.01758368f, -0.19932927f, -0.06926707f, -0.13671383f, -0.38630959f, 
    -0.38237628f, -0.05188308f, -0.06085834f, -0.03887798f, -0.00068025f, -0.12037167f, 0.03941826f, -0.18501003f, 
    -0.09386668f, -0.02278316f, -0.15561138f, -0.02835394f, 0.21003711f, -0.18737349f, -0.14094104f, -0.09190144f, 
    0.06040798f, -0.14360060f, 0.07453969f, -0.04922112f, -0.04283807f, 0.11732686f, 0.00948226f, -0.02179347f, 
    0.13037214f, 0.24783529f, 0.12598366f, -0.01979294f, 0.14073518f, 0.29750669f, -0.02452084f, 0.22473577f, 
    0.00057748f, 0.03592442f, 0.10082032f, 0.05651740f, -0.27451691f, -0.21536922f, -0.03050503f, -0.07779524f, 
    -0.04425330f, -0.05469469f, -0.12151077f, 0.00305990f, 0.03484005f, 0.08598860f, 0.02663126f, -0.00088615f, 
    0.42798150f, 0.33769688f, 0.12707055f, -0.14181174f, 0.15529235f, 0.21489751f, 0.22897294f, 0.07067280f, 
    0.00084714f, 0.06489725f, 0.09519916f, 0.02005394f, 0.21807274f, 0.28160757f, -0.25750589f, -0.16255786f, 
    -0.03318479f, 0.27437508f, -0.13640237f, -0.08571521f, -0.23485197f, -0.16124348f, -0.12001878f, -0.13482524f, 
    0.56741709f, 0.38428295f, 0.36174837f, -0.62616545f, -0.02221501f, -0.17985448f, -0.06885201f, 0.01952321f, 
    -0.00779108f, -0.08093874f, -0.03347045f, -0.01604980f, -0.00130277f, -0.02421424f, 0.03411835f, 0.00685999f, 
    0.05656901f, 0.00900740f, 0.03571858f, 0.02930810f, -0.26382536f, -0.09886455f, -0.03371263f, -0.20582904f, 
    0.14227432f, -0.23735885f, -0.11933017f, -0.57449555f, -0.15179996f, -0.00131907f, -0.12925643f, 0.00161516f, 
    -0.04660035f, 0.03586658f, -0.13614418f, 0.01789287f, -0.08649077f, 0.10086964f, 0.12141254f, 0.26463157f, 
    -0.11897060f, -0.02142151f, 0.19078416f, -0.02413606f, -0.04950009f, -0.06389406f, -0.02506787f, 0.00202176f, 
    -0.31342256f, 0.04892449f, -0.08679293f, 0.01910543f, 0.08345262f, 0.13393050f, 0.19122645f, 0.08763248f, 
    -0.08009047f, -0.04587343f, 0.05496889f, 0.19152826f, -0.20858225f, 0.23777594f, 0.08165505f, 0.20005089f, 
    0.00067060f, 0.23404481f, -0.05112174f, 0.17842457f, -0.15183409f, -0.06054930f, 0.02786785f, -0.07180423f, 
    0.49730381f, 0.03189752f, -0.24574606f, -0.32427993f, -0.03728551f, 0.02379047f, 0.20845868f, -0.00355167f, 
    0.15420747f, -0.05200949f, 0.01080952f, -0.03423920f, -0.31552273f, -0.56173003f, 0.41567317f, -0.07832588f, 
    -0.08036006f, -0.03164572f, 0.09769201f, 0.16093330f, -0.02083217f, 0.02842834f, 0.07665581f, -0.03566060f, 
    -0.22437514f, 0.30269954f, -0.13126923f, -0.05590772f, -0.01171141f, 0.37660605f, 0.00512089f, -0.00787666f, 
    0.09498826f, 0.00415259f, -0.11093583f, -0.03408868f, 0.01357720f, -0.37344137f, 0.04142486f, -0.08462195f, 
    0.08718768f, 0.02610128f, -0.05264868f, 0.14663394f, -0.13442872f, -0.00466646f, -0.32702756f, -0.18349876f, 
    0.11999975f, 0.04357053f, -0.06143190f, 0.05675180f, -0.05904542f, -0.03219264f, 0.04548154f, -0.02612268f, 
    -0.16345681f, -0.14712387f, 0.11215382f, -0.07597845f, -0.67519766f, -0.16827016f, -0.33361158f, -0.26688895f, 
    0.06954138f, -0.11004808f, 0.21727751f, -0.27717912f, -0.01764249f, 0.17913489f, -0.11781334f, 0.06207734f, 
    -0.17422880f, -0.09248089f, -0.41292107f, -0.16411488f, -0.04520569f, 0.31930518f, 0.15267874f, -0.00319011f, 
    0.26944625f, 0.01894868f, 0.05400220f, 0.09098516f, 0.33499742f, -0.15694667f, -0.10675983f, 0.02190683f, 
    0.01889904f, 0.04161417f, -0.05791371f, -0.05144493f, -0.19366810f, -0.64277041f, -0.18449661f, 0.00746192f, 
    0.04895249f, 0.14234012f, 0.05094406f, 0.03577084f, 0.04985979f, -0.05463449f, 0.03568859f, 0.04620243f, 
    -0.10068682f, -0.02123101f, 0.20563604f, -0.20172979f, 0.02822020f, -0.13308994f, 0.02254017f, -0.00011304f, 
    -0.04466754f, -0.06511007f, -0.02346004f, -0.00498377f, -0.31034854f, -0.14096750f, -0.18283381f, -0.04761874f, 
    -0.37121823f, 0.05205515f, -0.25325462f, -0.27203605f, -0.16767634f, -0.04217295f, 0.03371801f, 0.00766037f, 
    0.14727458f, 0.11034167f, 0.08433760f, -0.11904990f, 0.07356294f, 0.07737502f, -0.00671618f, 0.16957961f, 
    0.08363254f, -0.12983987f, -0.02103404f, 0.07987101f, 0.03235705f, 0.06747355f, -0.07947302f, 0.02843817f, 
    0.02496227f, -0.07939721f, 0.34935871f, 0.55665749f, -0.05596217f, -0.01962713f, 0.41695759f, -0.12824848f, 
    0.06231416f, -0.05981189f, 0.03368124f, 0.00838310f, 0.34374645f, 0.35559830f, 0.06436867f, 0.43742263f, 
    -0.01597807f, -0.03382881f, -0.11216713f, 0.04536193f, 0.00194085f, 0.00589357f, 0.02311349f, -0.09808540f, 
    -0.11052558f, -0.18027976f, 0.04655703f, -0.10109799f, 0.04062232f, 0.03961946f, -0.06636992f, 0.25629002f, 
    -0.03726047f, 0.11116770f, -0.13068219f, -0.01147154f, 0.47215253f, 0.00058271f, 0.05673354f, -0.19031712f, 
    -0.05033610f, 0.07850400f, -0.17359357f, 0.07295354f, 0.09437284f, -0.01727237f, 0.07612794f, -0.08196609f, 
    0.06984596f, -0.08753233f, -0.10106014f, -0.03676559f, -0.03125769f, 0.06733380f, 0.02770421f, -0.03702619f, 
    0.01031029f, -0.14816974f, -0.10940869f, 0.14914824f, -0.17428136f, 0.07723831f, -0.46033984f, -0.73000854f, 
    0.00301807f, 0.03214225f, -0.11348169f, -0.23094727f, 0.02693892f, 0.05344084f, -0.00615696f, -0.31321219f, 
    0.21025907f, -0.01531290f, -0.13742329f, 0.13201177f, -0.00165767f, -0.02211988f, -0.07915641f, 0.10153349f, 
    0.04926809f, 0.05701958f, -0.03045659f, 0.09615596f, -0.27455166f, 0.25834417f, -0.01817667f, 0.03867489f, 
    -0.11692614f, 0.02729307f, 0.01165181f, 0.07603521f, -0.11249986f, 0.00098568f, 0.06960063f, 0.04146368f, 
    0.37662479f, 0.05165056f, 0.00781218f, -0.12823783f, -0.14262983f, -0.04786529f, -0.05967587f, 0.04866134f, 
    -0.07367409f, -0.15263347f, 0.15493393f, 0.06891745f, 0.39112428f, 0.17020625f, -0.60422373f, -0.11691975f, 
    -0.09389497f, 0.07178058f, 0.21500720f, -0.15870899f, -0.00242951f, -0.06148684f, -0.00824261f, -0.01047696f, 
    0.31957453f, 0.08648852f, 0.25111973f, 0.04261093f, 0.41137868f, -0.10838020f, -0.27622157f, -0.38662815f, 
    0.05750417f, 0.03013000f, -0.07591274f, -0.23495051f, 0.31874594f, 0.14375289f, -0.11335631f, 0.04176906f, 
    -0.04897653f, -0.17688632f, -0.02583184f, -0.22605450f, -0.07247276f, 0.04584383f, 0.00619671f, -0.02270216f, 
    -0.23568481f, 0.11194628f, 0.05380792f, 0.07373807f, 0.08081940f, -0.12866098f, -0.06140951f, -0.12322273f, 
    -0.09096587f, -0.05993701f, 0.03056328f, -0.17135903f, -0.20191230f, -0.26963380f, 0.16373506f, 0.06396790f, 
    0.26539209f, 0.08251475f, -0.03994120f, 0.52457184f, -0.04059728f, 0.01037820f, 0.09534187f, -0.07785882f, 
    -0.42055187f, 0.36289558f, -0.10619248f, -0.28830066f, 0.00612282f, -0.06330760f, 0.04183596f, 0.16623461f, 
    0.17383049f, -0.17268421f, -0.02445655f, -0.04735445f, 0.13596071f, 0.05101082f, 0.05573833f, 0.18001360f, 
    -0.04051083f, -0.00722083f, -0.17251828f, 0.02997037f, 0.32522947f, -0.00177391f, -0.01704193f, -0.13440274f, 
    -0.90148300f, -0.23211513f, 0.01259769f, -0.39841789f, 0.01083631f, 0.06169865f, -0.30796459f, -0.31147340f, 
    0.06357351f, -0.03560761f, 0.00806599f, -0.03146279f, -0.22522570f, -0.40426418f, -0.57095957f, -0.37785321f, 
    -0.07181425f, -0.07214659f, 0.08637322f, -0.08288917f, -0.00975197f, -0.13272120f, -0.05842335f, -0.10515247f, 
    0.06253610f, -0.34791705f, -0.33529276f, 0.16534355f, 0.07335059f, -0.13756278f, 0.06346942f, 0.02974949f, 
    0.00781479f, -0.05731966f, -0.04627566f, 0.04437330f, 0.21642451f, 0.15885347f, 0.17486769f, 0.54013705f, 
    -0.04152307f, -0.14720476f, 0.06782248f, 0.06455389f, 0.11619698f, -0.06785148f, 0.05945228f, 0.06842452f, 
    0.12185384f, 0.63922703f, 0.79143131f, 0.34365407f, -0.10130359f, -0.14055094f, 0.19673672f, 0.00581760f, 
    0.09410512f, -0.06772538f, 0.15476422f, -0.06240462f, -0.01130260f, 0.10100409f, -0.22624843f, 0.06077565f, 
    0.19845326f, -0.08483667f, 0.06674219f, 0.04816105f, -0.09855756f, 0.02622025f, 0.13154788f, -0.13992745f, 
    0.10729898f, -0.06904057f, 0.03310696f, 0.40524444f, 0.11541304f, 0.12443243f, -0.57868493f, 0.39070976f, 
    -0.07863501f, 0.02466058f, -0.10042101f, 0.18416610f, 0.02192130f, -0.02411393f, -0.02120141f, 0.03276583f, 
    -0.08846257f, -0.05898901f, 0.02701665f, -0.14475821f, -0.14349091f, 0.16860384f, 0.01383102f, 0.20907336f, 
    -0.08981857f, -0.10926292f, 0.13471356f, 0.01595723f, -0.02449900f, -0.00050219f, 0.00382773f, 0.12657689f, 
    -0.15379071f, -0.06346795f, 0.10637023f, -0.01012913f, -0.13827124f, -0.06700634f, 0.04181951f, -0.01630078f, 
    0.09573691f, -0.10998575f, 0.10631728f, -0.05801333f, -0.07911910f, -0.05712930f, 0.14801660f, -0.00600508f, 
    -0.16772130f, 0.26108724f, 0.15870294f, -0.13751778f, -0.10846420f, -0.00596092f, 0.11184764f, -0.03346627f, 
    0.03292839f, 0.12773095f, -0.02826546f, 0.12001678f, -0.07104107f, 0.05778982f, -0.06510711f, 0.14105041f, 
    -0.00652858f, 0.02520806f, -0.02533316f, -0.11085243f, 0.20356148f, 0.24031948f, 0.27234641f, 0.06615828f, 
    0.06750893f, -0.17552333f, 0.06303365f, -0.08288831f, -0.05193495f, -0.00324271f, 0.01614186f, -0.04586694f, 
    -0.01998046f, 0.02386162f, -0.09904118f, -0.29943117f, 0.12406620f, -0.00680411f, -0.14189963f, 0.14070876f, 
    -0.05514682f, -0.09627314f, 0.11439420f, 0.05446257f, 0.08403485f, 0.13636646f, -0.02230390f, 0.22084507f, 
    0.21929111f, 0.25795415f, -0.69297308f, 0.25052425f, -0.00377441f, 0.10782421f, 0.01768933f, 0.02098355f, 
    0.03721994f, 0.09129220f, 0.02347938f, 0.02744639f, -0.02426624f, -0.10828795f, -0.26455277f, -0.12697054f, 
    0.04835077f, 0.02169771f, -0.00630318f, 0.11839097f, -0.00134923f, 0.06641071f, -0.12425881f, 0.12024127f, 
    -0.89843565f, -0.87753642f, 0.03075320f, -0.32658610f, 0.16760691f, -0.16019283f, 0.03260964f, 0.08053970f, 
    -0.06219371f, -0.00747507f, -0.03499882f, -0.03515700f, -0.07068050f, 0.30022931f, -0.09111008f, -0.33899257f, 
    0.06274852f, -0.08186496f, -0.05599825f, 0.14527176f, -0.00474558f, 0.02711678f, -0.04201941f, 0.07224223f, 
    0.27002317f, -0.37186575f, -0.17401817f, 0.09096918f, 0.10326350f, 0.02828921f, -0.11029921f, -0.03173629f, 
    -0.03355043f, -0.24285646f, -0.26658025f, 0.03454518f, -0.32285327f, -0.00718703f, 0.08002666f, -0.18179400f, 
    0.05798348f, -0.02226797f, -0.29094502f, 0.02152674f, 0.13488804f, -0.05889715f, -0.02661036f, 0.18369964f, 
    0.06053596f, 0.06131097f, 0.10149707f, 0.24674562f, -0.02760619f, 0.01100976f, 0.05448607f, -0.00083557f, 
    0.11026910f, -0.03132148f, -0.00233915f, 0.12466501f, -1.08275342f, 0.25397646f, 0.29376483f, -0.02591636f, 
    -0.03751757f, -0.00072526f, -0.04304529f, -0.36524647f, 0.01995519f, 0.00227581f, -0.07161203f, 0.01602130f, 
    -0.05702192f, -0.16138032f, -0.10889131f, -0.17869197f, 0.06224007f, -0.07163770f, -0.01888973f, 0.06658059f, 
    -0.03871795f, -0.09202272f, 0.06337030f, -0.26482046f, -0.29795286f, -0.04574643f, -0.23414463f, 0.37911960f, 
    0.11090597f, -0.03148960f, 0.06198374f, 0.06883892f, -0.19628763f, -0.22017692f, 0.02899732f, 0.07898810f, 
    -0.69042134f, -0.03203268f, 0.04913598f, 0.06737616f, 0.03221554f, 0.08086821f, -0.13916276f, -0.11091186f, 
    -0.00222199f, -0.24277413f, 0.17035304f, -0.05282608f, -0.31051686f, 0.15831652f, -0.35919452f, 0.10392614f, 
    -0.47325477f, 0.13554248f, -0.02930052f, -0.12597367f, 0.02843735f, 0.01510889f, 0.02967984f, 0.02122955f, 
    0.10973527f, 0.13245307f, 0.52358949f, 0.30110380f, 0.13230799f, 0.10090975f, 0.05634901f, -0.01337518f, 
    0.01516719f, -0.01320927f, 0.02376294f, 0.07927468f, -0.49956122f, 0.11657731f, 0.04425146f, -0.13911295f, 
    -0.12259976f, -0.01628307f, -0.05175407f, 0.05544410f, -0.02798225f, 0.02816859f, -0.00966989f, -0.00030700f, 
    -0.23883153f, -0.67693210f, 0.05093122f, 0.20911293f, 0.05666134f, 0.06525946f, -0.02199145f, 0.13809729f, 
    0.02017176f, -0.02250712f, 0.03563208f, 0.00964033f, 0.23130572f, -0.33846089f, 0.31000489f, -0.20597431f, 
    0.28689727f, -0.01396876f, -0.12114756f, 0.00911094f, -0.07498462f, 0.01313402f, -0.20293109f, -0.06897704f, 
    -0.09567808f, 0.10664722f, -0.50025600f, 0.21118681f, -0.01230626f, 0.14653100f, -0.14534660f, 0.26403984f, 
    -0.03626833f, 0.10651951f, -0.02832162f, -0.02966170f, 0.04401770f, -0.14771529f, -0.07117545f, -0.00423930f, 
    -0.02741542f, 0.00786856f, 0.02064299f, 0.02754167f, 0.01163915f, 0.04548628f, 0.00290557f, 0.06184534f, 
    -0.22042497f, -0.18093555f, 0.02379946f, 0.30759418f, -0.15287881f, 0.07713608f, 0.05053365f, 0.22963001f, 
    0.08329399f, 0.07719400f, -0.26763397f, 0.04675624f, 0.08938683f, -0.09317808f, -0.05591107f, 0.19176053f, 
    0.04816993f, 0.13628602f, -0.10033400f, 0.01588846f, 0.04656528f, 0.08093257f, 0.00761106f, -0.12500535f, 
    0.33266994f, 0.00853490f, -0.30131349f, -0.27762178f, 0.08097576f, -0.00796618f, -0.00053995f, 0.24724650f, 
    0.03461059f, 0.01637906f, 0.02150059f, -0.11693676f, 0.21247683f, -0.23035698f, -0.09472613f, 0.31906185f, 
    0.01067277f, 0.00197967f, -0.08530437f, -0.13369262f, -0.11427504f, 0.11488468f, 0.03950415f, 0.14815760f, 
    -0.18113446f, -0.05811039f, 0.08840209f, 0.24245651f, 0.19680023f, 0.10018348f, 0.07850481f, -0.07542881f, 
    -0.06605590f, 0.05694374f, 0.06480969f, 0.08143399f, 0.22855042f, 0.73305023f, -0.33557281f, -0.14021045f, 
    0.08291389f, 0.10291708f, -0.11014418f, -0.25831866f, -0.33684587f, -0.08532330f, -0.00607356f, 0.14534691f, 
    0.06153307f, 0.14650461f, 0.24388866f, -0.40040004f, 0.04766164f, -0.28385648f, -0.03366870f, -0.04929003f, 
    -0.24165937f, -0.03377410f, -0.02574182f, -0.08084390f, 0.03807388f, -0.02841802f, 0.26074174f, 0.09516966f, 
    -0.17931943f, -0.02111637f, -0.14120778f, 0.06429859f, -0.04047652f, -0.12874831f, -0.00890285f, 0.23677815f, 
    -0.21989815f, 0.30923370f, -0.39640304f, -0.31037527f, 0.20430006f, 0.03589277f, -0.20025344f, -0.06942745f, 
    -0.12520507f, -0.03251468f, 0.07148415f, -0.14728490f, 0.26194766f, -0.18895844f, -0.16522571f, -0.13652433f, 
    -0.21421853f, 0.02336459f, -0.05157268f, -0.05184735f, 0.03575350f, 0.05692486f, 0.06728499f, -0.08146093f, 
    -0.34552911f, -0.04149641f, -0.16710921f, 0.22526729f, -0.00901740f, -0.00748964f, 0.09739427f, -0.00634370f, 
    -0.13342164f, 0.03739652f, 0.04596447f, -0.07059339f, -0.17192811f, 0.63084424f, -0.22444868f, 0.17320535f, 
    0.03704156f, 0.09969611f, 0.06030552f, -0.00350564f, 0.08859022f, 0.22876020f, -0.15097629f, -0.08286373f, 
    0.16397834f, 0.00666175f, 0.15851992f, 0.29392779f, 0.24540612f, 0.00677468f, -0.15658504f, -0.03697422f, 
    -0.06598899f, -0.11054944f, 0.14496565f, 0.04116534f, 0.50480962f, 0.02758848f, -0.12790488f, -0.36557317f, 
    0.12396774f, 0.18385190f, 0.14226721f, 0.04399194f, -0.19303361f, -0.11525895f, -0.11068695f, -0.00135470f, 
    -0.47823012f, 0.42408511f, -0.15604368f, 0.24402204f, -0.11236711f, -0.00758007f, -0.18215786f, -0.07473355f, 
    0.17635733f, -0.23065870f, 0.12248971f, 0.18135348f, 0.01487583f, -0.22974539f, 0.00019721f, -0.49638379f, 
    -0.04573958f, 0.09577292f, 0.05194651f, 0.03401420f, -0.00898144f, 0.07834767f, -0.33165666f, -0.22145076f, 
    -0.24011484f, -0.04769797f, -0.28487244f, 0.28133652f, 0.12513065f, 0.09870880f, -0.03257747f, 0.20822346f, 
    -0.06996716f, -0.08795299f, -0.06903785f, -0.02182498f, -0.02606265f, -0.08244453f, -0.28042457f, -0.36706594f, 
    -0.44479427f, -0.17166483f, -0.11839771f, -0.14711928f, -0.05016590f, -0.09933335f, 0.04980008f, 0.07826228f, 
    0.18992512f, 0.17982823f, -0.10093788f, 0.41235989f, -0.02351171f, -0.05209253f, -0.06203084f, -0.13862506f, 
    0.08219989f, 0.14056465f, -0.13551034f, 0.11251434f, -0.67508638f, 0.16344455f, -0.04163352f, -0.14156751f, 
    -0.20184970f, -0.11376894f, -0.32247323f, -0.05389491f, -0.08172356f, -0.01385314f, 0.13396055f, -0.08687250f, 
    -0.00018653f, 0.30171284f, -0.01368025f, -0.33538952f, 0.27438587f, 0.09723043f, -0.02270100f, 0.00060632f, 
    -0.39725327f, 0.06471618f, -0.17476659f, -0.02124628f, -0.19534518f, -0.12442826f, -0.17270578f, 0.23998573f, 
    -0.02093188f, -0.04229906f, -0.04062004f, 0.04261264f, 0.02697931f, 0.33043888f, 0.00952827f, 0.20508467f, 
    -0.67396700f, 0.44452521f, -0.34618410f, -0.28085291f, 0.09353239f, 0.10204075f, -0.05600935f, -0.12238015f, 
    -0.22849163f, 0.08349102f, 0.04926214f, 0.02472662f, 0.60929579f, -0.02430553f, 0.00348549f, -0.45468342f, 
    0.20655423f, 0.07379443f, -0.04374578f, 0.05564993f, -0.01780764f, 0.04785062f, -0.09525545f, -0.02561203f, 
    -1.28857303f, 0.49740404f, -0.70617765f, 0.32152179f, -0.02714019f, -0.30985168f, 0.15486930f, -0.09803452f, 
    -0.14163353f, -0.12840703f, 0.18925323f, -0.16459927f, -0.35487786f, 0.38682836f, -0.16137588f, 0.55498171f, 
    0.06759924f, -0.11261790f, -0.16309641f, -0.16689096f, -0.08756147f, 0.01492824f, -0.26512542f, -0.20737217f, 
    0.51072139f, -0.23546550f, 0.14813714f, 0.37375820f, -0.13439116f, -0.04107380f, -0.05471718f, -0.12958562f, 
    0.05921605f, -0.06199184f, 0.03527572f, 0.10917101f, 0.03622698f, -0.37938491f, 0.48070714f, 0.46270588f, 
    -0.15765901f, -0.00090306f, -0.06447098f, 0.13984178f, 0.19498383f, -0.05316886f, 0.12133536f, 0.19728787f, 
    0.03082961f, -0.11619257f, -0.17188962f, 0.09596793f, -0.03456953f, -0.09435603f, -0.11342131f, -0.17685741f, 
    0.00339963f, 0.04722081f, -0.11839970f, 0.16999139f, 0.24801926f, -0.10964526f, 0.03857152f, 0.15209776f, 
    -0.08789307f, 0.00379919f, 0.10516752f, -0.01981062f, -0.19378312f, -0.00787696f, -0.15908872f, 0.07087968f, 
    -0.10654790f, 0.69011933f, -0.10999133f, -0.42407727f, -0.13761641f, 0.05751016f, -0.00942335f, -0.16027531f, 
    0.00032780f, 0.09754803f, 0.02307183f, -0.07148479f, 0.05277525f, -0.03456469f, 0.02799490f, 0.06471130f, 
    -0.09282078f, 0.08513176f, 0.06699298f, 0.03814778f, -0.00930918f, -0.03406459f, -0.01024177f, 0.11684161f, 
    0.21927884f, 0.34937868f, 0.12582348f, 0.11642684f, 0.20353715f, 0.11296710f, 0.03121803f, -0.08200037f, 
    0.01182770f, -0.01363408f, 0.08172460f, -0.00387360f, 0.15626197f, 0.18631466f, 0.24486966f, 0.22472298f, 
    -0.04089877f, 0.00382078f, -0.11336556f, 0.10273074f, 0.11066153f, -0.08375627f, 0.00609120f, 0.02868597f, 
    0.05037045f, 0.01645856f, 0.20439890f, 0.11140727f, -0.28984821f, -0.04481883f, -0.12069605f, -0.02684053f, 
    -0.00188600f, -0.15555754f, -0.07931971f, -0.16665223f, 0.11531518f, 0.12560008f, 0.13255890f, 0.04421241f, 
    -0.18409009f, -0.45416886f, -0.09371518f, -0.06137658f, 0.16206361f, 0.06321916f, 0.03889277f, 0.04866535f, 
    0.06866226f, 0.11355028f, 0.19227149f, 0.14895223f, -0.13353254f, -0.18828829f, 0.01030863f, -0.04439984f, 
    -0.18780373f, -0.17398024f, -0.07964244f, -0.04526740f, -0.02484992f, -0.44546121f, 0.05140897f, 0.18524173f, 
    0.08039510f, -0.00121952f, 0.14481880f, -0.14272673f, 0.00997447f, -0.13175647f, -0.16181625f, -0.13942681f, 
    -0.02365204f, -0.10621866f, -0.37989706f, -0.01179691f, -0.35216394f, -0.14871953f, 0.00722708f, -0.41059870f, 
    -0.15926658f, 0.01820943f, 0.07405251f, -0.30389708f, 0.07089394f, 0.14165355f, 0.04448661f, 0.01569144f, 
    -0.03672500f, -0.06323625f, -0.08032504f, -0.15131249f, 0.01031361f, -0.10758035f, 0.22534001f, 0.15175791f, 
    0.05932669f, 0.04166685f, 0.04218400f, -0.01485560f, 0.04648395f, 0.04581686f, 0.03182067f, 0.08915930f, 
    0.27188066f, -0.07487436f, -0.13260727f, 0.02181720f, -0.00961998f, -0.09904762f, 0.07077938f, -0.08320296f, 
    -0.20526227f, 0.11984131f, -0.01468245f, 0.04667223f, 0.00517260f, -0.19231455f, 0.01660835f, -0.16043161f, 
    0.32102087f, -0.04233306f, 0.38723236f, 0.16530654f, -0.10107540f, -0.04960153f, -0.20499705f, -0.11007598f, 
    0.04611292f, -0.02467533f, 0.09102476f, -0.06624978f, 0.07677514f, -0.05608340f, 0.11947126f, -0.26116979f, 
    0.06650270f, 0.00772530f, -0.00758325f, -0.08338276f, 0.11771835f, 0.15577769f, 0.08185501f, 0.42912990f, 
    0.15900382f, 0.15866013f, -0.08443602f, -0.00339785f, 0.05005693f, 0.02762155f, -0.05836165f, 0.04780417f, 
    0.07279199f, -0.18411459f, -0.20282796f, 0.02928619f, 0.01168691f, -0.60418826f, -0.17362474f, 0.02980545f, 
    -0.00778460f, -0.09652874f, -0.03034902f, 0.00166659f, 0.03096006f, 0.09182335f, 0.09828270f, 0.22373448f, 
    -0.16207942f, -0.23708712f, 0.14082614f, 0.23720810f, -0.16749439f, -0.06819464f, -0.13746206f, -0.06986650f, 
    -0.11330587f, -0.13486232f, -0.04056746f, -0.00787420f, -0.01372459f, 0.01560745f, 0.10792167f, -0.03946539f, 
    -0.01569463f, 0.00922410f, 0.01183435f, -0.03595366f, -0.11755133f, -0.08843458f, -0.07809098f, -0.02130391f, 
    0.00475609f, 0.05329692f, 0.23498356f, -0.03493665f, -0.19532129f, 0.10067890f, -0.10434838f, 0.13135290f, 
    0.03101713f, 0.14917180f, -0.08053357f, 0.04129490f, -0.12856138f, -0.32672253f, -0.18683022f, 0.14940412f, 
    0.15966451f, 0.05573944f, 0.05210818f, 0.02476974f, 0.00167202f, 0.02614001f, -0.05581778f, 0.08960862f, 
    0.13137221f, 0.22855805f, -0.04642384f, 0.08769037f, 0.03888962f, 0.03589942f, 0.07395528f, -0.04703819f, 
    -0.11339896f, -0.39830726f, 0.03387757f, -0.08011790f, 0.08070705f, -0.14401396f, -0.05945911f, 0.04009286f, 
    0.07732649f, 0.00322479f, 0.09061792f, -0.18024606f, 0.11937515f, 0.11099304f, -0.10415515f, -0.03468687f, 
    -0.04214027f, -0.23385586f, 0.03374031f, 0.05687688f, -0.10897231f, 0.01070131f, 0.09651428f, 0.03008425f, 
    0.04581293f, 0.03945787f, 0.01995665f, -0.00366853f, 0.22955734f, 0.11810932f, 0.12313925f, 0.12382058f, 
    -0.20538865f, 0.18034704f, 0.05642716f, -0.10967055f, -0.09626505f, -0.06777436f, -0.08067887f, 0.01783494f, 
    0.17547897f, 0.18505357f, -0.40705463f, -0.13660443f, 0.03999129f, 0.17665443f, 0.14746420f, -0.08558382f, 
    -0.31136045f, -0.09465844f, -0.06354946f, -0.14014034f, 0.20589502f, 0.12693904f, -0.53632957f, -0.12800764f, 
    0.00201904f, -0.05611954f, 0.06782904f, -0.03066142f, 0.11594422f, -0.15224108f, -0.31292117f, -0.06933093f, 
    0.05070004f, -0.19022769f, -0.06251504f, 0.13352777f, -0.05536753f, -0.01819159f, -0.06223735f, 0.04561465f, 
    0.02370928f, 0.04865285f, -0.24866140f, -0.00964030f, 0.15433590f, -0.19845325f, 0.43875605f, -0.39470437f, 
    0.05396900f, 0.10421820f, -0.02553277f, -0.07428521f, 0.06188188f, -0.16244967f, 0.09530530f, -0.16479103f, 
    -0.25326043f, 0.05335797f, -0.03494959f, 0.07271978f, 0.00440835f, -0.10564611f, 0.02554122f, -0.03547735f, 
    -0.08363339f, 0.04704908f, 0.03500760f, 0.12960511f, 0.06461998f, 0.40667272f, 0.07217225f, 0.25240058f, 
    -0.00322121f, 0.17710699f, 0.00245233f, 0.15460314f, -0.03416810f, 0.02126924f, 0.03815970f, 0.00881783f, 
    -0.09521347f, -0.06483836f, 0.05818631f, 0.05362467f, -0.28399727f, 0.09708428f, -0.25894028f, -0.14712851f, 
    -0.05233475f, 0.04858863f, -0.00938044f, 0.03077746f, -0.00077985f, 0.05893521f, -0.00960222f, 0.22264102f, 
    0.04991249f, -0.23108393f, -0.05486617f, -0.20375080f, 0.06496657f, -0.12826423f, 0.07404651f, 0.12103895f, 
    -0.01082590f, -0.71490824f, 0.13430291f, 0.33620590f, -0.18384218f, -0.00249036f, -0.08214603f, -0.23725426f, 
    -0.27559397f, 0.08769677f, 0.05587671f, 0.21365975f, 0.01919643f, 0.04348944f, -0.05507855f, -0.00417577f, 
    0.17345725f, -0.01468739f, 0.06497973f, -0.10312649f, -0.04027773f, -0.18003994f, -0.12871976f, -0.10809336f, 
    0.07015989f, 0.10415310f, 0.10082430f, 0.04898863f, 0.01984951f, -0.16526742f, -0.24496724f, 0.16076948f, 
    0.04371769f, -0.02286695f, 0.07979625f, -0.20214342f, 0.05720986f, 0.14674026f, 0.11907248f, -0.10822015f, 
    0.18544425f, 0.25978747f, 0.17744185f, -0.09768979f, 0.17280643f, 0.08005115f, 0.05775776f, 0.07649475f, 
    0.14195980f, 0.01720629f, 0.24558996f, -0.03410110f, 0.20384158f, -0.10038190f, -0.11345981f, 0.04427852f, 
    0.06402843f, -0.01200534f, 0.05654589f, 0.11700451f, -0.28287962f, -0.09778304f, -0.14295328f, -0.28388733f, 
    0.23137656f, 0.10142976f, 0.20568141f, 0.04303015f, 0.04666394f, 0.01037772f, -0.02791038f, 0.02675591f, 
    -0.50437236f, -0.12987579f, -0.36423713f, -0.30390388f, -0.03338071f, 0.07234966f, -0.16368449f, -0.06823887f, 
    0.02240255f, 0.01852962f, -0.09543851f, -0.14927469f, 0.12425160f, 0.21154265f, -0.10585353f, 0.03919305f, 
    0.03699550f, -0.06612548f, -0.01676248f, 0.07086827f, 0.14019713f, -0.02560513f, -0.00977304f, 0.14589652f, 
    -0.13689198f, -0.11424644f, 0.14571373f, 0.01959876f, 0.37075099f, 0.01248081f, -0.06424753f, 0.03639325f, 
    -0.13418119f, -0.06913012f, 0.08630001f, 0.38142109f, 0.08838840f, 0.18560030f, -0.14291249f, 0.10340082f, 
    0.06781352f, 0.06932951f, 0.13348249f, -0.05961474f, 0.15234871f, -0.00743920f, 0.12735714f, -0.57135338f, 
    0.07675180f, -0.06534912f, 0.05833444f, -0.10749104f, -0.02050688f, 0.07565645f, -0.06895206f, -0.12112503f, 
    0.26675996f, 0.13988744f, -0.17694913f, -0.09494729f, 0.19772033f, 0.16183014f, 0.13898498f, 0.13153750f, 
    0.11584911f, 0.18585442f, -0.29317379f, -0.07979517f, 0.05159945f, -0.06113971f, 0.17027159f, 0.08158918f, 
    0.23679824f, 0.02609460f, -0.04090229f, -0.14671262f, 0.08405740f, 0.05537046f, 0.03150571f, -0.08478709f, 
    -0.10695492f, -0.19538386f, -0.19981979f, -0.05666032f, 0.01210577f, -0.18148305f, -0.03101288f, -0.03858163f, 
    0.03225565f, -0.03471801f, 0.05437658f, -0.00635896f, -0.23061056f, -0.37244624f, -0.37779781f, -0.75077343f, 
    -0.15046830f, -0.06910883f, -0.12440282f, -0.06444274f, -0.15538970f, -0.05259353f, -0.15068537f, -0.14798376f, 
    0.12582204f, 0.18548262f, -0.13897717f, 0.21718663f, -0.69516373f, 0.50103951f, -0.10685778f, 0.06298786f, 
    0.03174376f, -0.02011962f, -0.05982948f, -0.01765311f, 0.14150470f, -0.26602283f, -0.34836230f, -0.40835047f, 
    0.18127503f, -0.17112435f, 0.16330709f, 0.17264973f, 0.13649529f, -0.12256487f, 0.01965249f, 0.10316473f, 
    -0.09516825f, 0.08908699f, -0.20497428f, -0.02638385f, -0.07093818f, -0.01117065f, 0.03330674f, 0.17646846f, 
    -0.03437502f, -0.03313696f, -0.10122994f, 0.07537074f, 0.03948249f, 0.02723892f, 0.09797462f, 0.08518062f, 
    -0.01893631f, 0.35150325f, 0.12381534f, -0.36202028f, 0.24396250f, -0.14188240f, -0.19227107f, -0.29582682f, 
    -0.00233495f, 0.02795417f, -0.00890679f, 0.08499341f, -0.10313904f, -0.07505845f, 0.19395572f, -0.13728800f, 
    0.03575218f, -0.00086795f, -0.08994096f, 0.02769521f, 0.04696159f, -0.09200665f, -0.05015426f, 0.01410320f, 
    -0.30083153f, 0.02363254f, -0.19094768f, -0.19422224f, -0.22871177f, -0.03756736f, -0.04332251f, -0.12005082f, 
    0.13415115f, 0.16306545f, 0.27766150f, -0.21320060f, -0.12367484f, -0.03097264f, -0.54952544f, 0.17063294f, 
    0.28111753f, -0.13901979f, 0.25476709f, 0.01816005f, -0.03658846f, -0.06098094f, -0.15676360f, 0.24777788f, 
    -0.32786581f, 0.06807002f, -0.09585851f, -0.01862631f, 0.07031061f, -0.04720804f, -0.07154334f, 0.04992653f, 
    -0.01866462f, -0.09157823f, 0.06024054f, -0.04707795f, 0.26623136f, -0.21963361f, 0.41935503f, 0.29667428f, 
    0.14015266f, -0.02241795f, -0.12009944f, 0.31209400f, 0.02652624f, 0.05798325f, 0.07886213f, -0.03973121f, 
    -0.14995177f, -0.15954228f, 0.30215254f, 0.09350242f, 0.03196950f, -0.15850538f, -0.07018261f, -0.01941398f, 
    0.20270181f, -0.04042331f, -0.02081400f, 0.11742163f, -0.35915291f, -0.70018739f, 0.46287581f, 0.15129887f, 
    -0.05442296f, -0.19073018f, -0.04546195f, -0.02215820f, 0.05872880f, -0.00753823f, 0.35923690f, -0.05935236f, 
    0.33348879f, -0.31726229f, -0.08072159f, -0.22222152f, -0.01083501f, 0.05602854f, -0.03163356f, -0.09730061f, 
    0.17068304f, 0.21482222f, -0.04818968f, -0.07602056f, 0.06120866f, 0.00891375f, 0.13232285f, -0.01410101f, 
    0.20063655f, 0.11533406f, 0.03134921f, 0.04386297f, -0.03027057f, 0.03527313f, 0.11022491f, 0.13972445f, 
    -0.31672964f, 0.09039265f, -0.12844452f, -0.32437283f, -0.12112484f, -0.09199253f, -0.02133643f, -0.00726148f, 
    -0.12783077f, -0.11354730f, -0.06200637f, 0.08613386f, -0.25685439f, -0.38498887f, -0.21083619f, 0.01483164f, 
    0.21794157f, 0.07728852f, -0.04119455f, -0.01103694f, 0.05204677f, -0.07238070f, 0.01380433f, 0.05083813f, 
    -0.12328079f, 0.00825737f, 0.33076620f, -0.26063254f, 0.07171579f, -0.21710375f, 0.07201181f, 0.21550576f, 
    -0.03997654f, -0.09193453f, -0.05025085f, 0.04884389f, -0.06080550f, 0.36674228f, 0.26245478f, -0.19015233f, 
    -0.08558475f, -0.08895762f, 0.10096937f, 0.07564905f, 0.07278926f, 0.02885742f, 0.03892422f, 0.00401030f, 
    -0.16486810f, -0.58946085f, 0.56516862f, 0.26300341f, -0.03478161f, -0.12832503f, 0.06419434f, -0.00526008f, 
    0.08220194f, 0.08264475f, 0.00053585f, -0.14372888f, -0.07762742f, -0.07821462f, -0.16444652f, 0.03312953f, 
    0.11170380f, -0.06431266f, -0.01689222f, 0.08458474f, -0.26513293f, -0.03087911f, 0.08219895f, 0.26436561f, 
    -0.33633411f, -0.61467981f, -0.25035945f, 0.12449040f, -0.03982056f, 0.33881328f, 0.20293976f, -0.20934661f, 
    0.04627819f, -0.09561988f, 0.04646509f, 0.11186899f, -0.61527002f, -0.58287209f, -0.48499119f, -0.41929755f, 
    -0.07382626f, -0.39884990f, -0.59374356f, -0.21886115f, -0.14641450f, -0.06834230f, -0.09295332f, -0.07052372f, 
    0.01623777f, -0.34854496f, 0.01832596f, -0.10970737f, -0.02236937f, -0.15735149f, -0.04570825f, 0.15575857f, 
    0.00728907f, 0.05990100f, 0.01400474f, -0.16056994f, -0.93906635f, 0.02209388f, 0.53847665f, -0.21275777f, 
    -0.07462809f, -0.04012110f, -0.08268955f, -0.40102598f, -0.00949939f, 0.00323555f, -0.06348579f, 0.00171771f, 
    -0.73244476f, 0.56910062f, 0.64076096f, 0.17480546f, -0.09314992f, 0.00302146f, -0.00637719f, -0.16806105f, 
    -0.07989322f, 0.24677587f, -0.04178581f, 0.21828952f, -0.16779351f, -0.26861161f, -0.01802477f, -0.19878753f, 
    -0.01507462f, 0.10958167f, -0.13398680f, -0.01764746f, 0.08908653f, 0.10805461f, 0.00472011f, 0.13732710f, 
    -0.10307985f, -0.04506567f, 0.44702286f, 0.46473962f, -0.06435945f, -0.11262915f, 0.11669577f, -0.05433075f, 
    -0.01917922f, -0.01511484f, -0.06514089f, -0.20005889f, 0.39155746f, 0.11194605f, -0.02283801f, -0.35517040f, 
    0.04403546f, 0.08729538f, 0.01042227f, 0.12181739f, -0.07084571f, 0.20457664f, 0.05000591f, 0.13612555f, 
    -0.19836764f, 0.13676131f, 0.12950209f, -0.06797251f, 0.01499200f, -0.11121085f, -0.12029473f, -0.08984730f, 
    -0.05571994f, -0.06490158f, -0.10499365f, 0.10671467f, 0.29783028f, 0.05725259f, -0.38081047f, -0.17650984f, 
    -0.15493187f, 0.12630199f, -0.04192014f, 0.33048564f, 0.03650304f, 0.04139327f, -0.02475433f, -0.01347779f, 
    -0.44453454f, 1.05621231f, -0.24803166f, -0.16610041f, -0.08751106f, 0.06451116f, -0.30171132f, -0.08270659f, 
    0.01090305f, 0.05988760f, 0.14609714f, -0.06529167f, -0.07049216f, 0.23712003f, -0.07296585f, -0.07033616f, 
    -0.00711891f, -0.03170241f, 0.06022690f, 0.06227286f, 0.08510675f, 0.18709952f, 0.34803027f, -0.00981265f, 
    -0.11054196f, -0.03731452f, -0.05074505f, 0.05706970f, -0.03703462f, -0.12624647f, -0.11417276f, 0.13400105f, 
    0.07964642f, -0.12756422f, 0.25807068f, 0.04202682f, -0.09261870f, -0.07375167f, 0.19673027f, -0.02950244f, 
    0.03160501f, -0.00435834f, 0.08113571f, 0.05334877f, 0.25911710f, 0.18287770f, 0.35660595f, 0.03910941f, 
    -0.25194916f, -0.12273950f, 0.06848752f, 0.67153341f, 0.04354986f, 0.19767205f, 0.15606739f, -0.06919834f, 
    -0.02907104f, -0.01986554f, 0.06998985f, 0.07894897f, -0.00537816f, -0.23163834f, -0.19477499f, 0.17552781f, 
    0.03231115f, 0.02239949f, -0.07085226f, 0.00106577f, 0.03781531f, -0.14682843f, 0.13967167f, -0.19501306f, 
    -0.72203201f, -0.56730705f, -0.69595003f, 0.51957017f, -0.20694137f, -0.24982871f, -0.16709128f, -0.38252455f, 
    -0.05069292f, 0.01069508f, 0.01181801f, 0.02734563f, 0.04392714f, -0.24334192f, -0.19189064f, 0.17563537f, 
    0.08620670f, 0.13165066f, -0.01146424f, 0.03422302f, 0.04373271f, -0.01195828f, 0.01362475f, -0.10027394f, 
    0.11376411f, 0.07147694f, 0.12709305f, 0.18772024f, 0.01141395f, -0.16810162f, -0.14561637f, 0.14876506f, 
    -0.05854889f, -0.06967637f, -0.17928310f, -0.03291152f, 0.44244239f, -0.03705613f, -0.12307259f, -0.01730447f, 
    0.00934663f, -0.10817482f, 0.15166947f, 0.02109211f, 0.09180317f, 0.11430553f, 0.12999423f, -0.23786883f, 
    -0.24530275f, 0.19495833f, 0.30538628f, 0.00762377f, -0.04276580f, 0.01047375f, 0.08725570f, 0.07780235f, 
    -0.16151503f, 0.07996977f, 0.08083396f, 0.08145870f, 0.31360173f, -1.00985706f, -1.13431621f, -0.31248686f, 
    -0.18616499f, 0.09463350f, 0.19252160f, -0.01224407f, -0.02737803f, 0.10572198f, -0.07723099f, 0.01540126f, 
    -0.01115040f, -0.23836504f, 0.23416746f, 0.19820367f, 0.03921793f, -0.00837289f, -0.07271689f, 0.14468238f, 
    0.00043730f, 0.18658195f, -0.19663611f, -0.12010153f, -0.21241277f, -0.03478542f, 0.17347465f, 0.00543076f, 
    -0.03944774f, 0.02184332f, -0.10921988f, 0.04896166f, 0.22811919f, 0.30014774f, -0.02336754f, 0.22604516f, 
    0.38110477f, 0.09981117f, -0.28489381f, 0.05578743f, -0.05335460f, -0.12096032f, 0.20012583f, -0.05077296f, 
    0.06542460f, 0.06896554f, -0.14189675f, -0.09194432f, -1.00315571f, -0.20264165f, 0.18763097f, 0.00568249f, 
    -0.07709960f, -0.15954651f, -0.06149257f, -0.10925184f, 0.09839980f, -0.00502169f, 0.00855195f, 0.08377161f, 
    -0.65903658f, -0.66771841f, -0.11311787f, -0.08247371f, -0.15735434f, -0.01793194f, -0.05796002f, 0.07793375f, 
    -0.03925966f, 0.03835700f, 0.04339549f, 0.02998896f, -0.26387441f, -0.52285373f, -0.15293820f, 0.01031840f, 
    -0.00365386f, 0.15938868f, 0.22263056f, -0.03071632f, -0.00872868f, -0.15510309f, -0.02752053f, 0.02299233f, 
    -0.41465867f, -0.57089710f, -0.82379043f, -0.15337324f, -0.17396386f, 0.13807176f, 0.03720764f, 0.03815870f, 
    0.04447585f, 0.02460554f, 0.01532101f, 0.01454309f, -0.56346965f, -1.04498804f, -0.42230806f, -0.50410312f, 
    0.00831577f, -0.03921812f, 0.17376180f, -0.30998519f, 0.03226680f, -0.15946157f, 0.04901543f, -0.06068899f, 
    -0.17605332f, -0.08532391f, -0.32666269f, 0.28339785f, -0.02596080f, 0.13263695f, 0.05839419f, 0.19061962f, 
    -0.09068717f, -0.00570117f, 0.18266131f, 0.15464754f, 0.07223696f, -0.00675881f, -0.15207371f, -0.15074432f, 
    -0.00817437f, -0.00391454f, 0.08780035f, -0.00285821f, 0.06922372f, -0.02234638f, -0.02726219f, 0.01390464f, 
    -0.34863111f, -0.00183609f, -0.00797292f, 0.04903283f, 0.16052766f, 0.12556823f, 0.21285646f, 0.12964877f, 
    -0.03080494f, -0.04343908f, 0.09246290f, 0.05608063f, -0.47121865f, -0.34552407f, 0.00095332f, 0.26682603f, 
    0.14022557f, -0.12259211f, -0.12726347f, 0.01075922f, -0.02235720f, 0.02391497f, -0.01592783f, 0.04584682f, 
    0.08594281f, 0.07365718f, 0.02403561f, 0.15216285f, 0.00813422f, -0.10864534f, 0.10762599f, -0.24406695f, 
    -0.05330922f, -0.02577297f, -0.08492322f, -0.03136444f, 0.10691904f, -0.43212083f, -0.40315780f, -0.41841522f, 
    0.06948726f, 0.04557831f, -0.26161200f, 0.05315027f, 0.13570613f, 0.05661725f, 0.05523914f, -0.00746942f, 
    0.20028374f, -0.95639813f, -0.77898210f, -0.49809915f, 0.00270324f, -0.16600206f, -0.09621459f, 0.22665662f, 
    0.07006429f, 0.11260363f, 0.05458613f, 0.13729174f, 0.23078583f, 0.24501033f, -0.23116073f, 0.06686155f, 
    -0.09760781f, -0.14097637f, -0.07254300f, 0.00069904f, -0.04285699f, -0.03833493f, -0.02516935f, -0.18458986f, 
    0.38028413f, -0.29211229f, 0.05692099f, -0.05999209f, -0.33558550f, 0.28755865f, -0.13892817f, -0.02366430f, 
    0.11971892f, 0.06484428f, -0.03638425f, -0.07871316f, -0.44608659f, 0.18776906f, -0.36719480f, 0.38432914f, 
    -0.09749417f, -0.07331423f, 0.14769098f, -0.00993485f, 0.12832262f, 0.00653186f, -0.01599364f, -0.09168921f, 
    0.06692800f, -0.03788838f, -0.02894735f, -0.11615945f, 0.02841140f, 0.07138316f, -0.03232527f, -0.05965498f, 
    -0.12142199f, 0.02472653f, 0.12443759f, 0.03228046f, -0.10882671f, 0.25345519f, -0.18181178f, 0.17092285f, 
    0.01351120f, -0.07777528f, 0.01586241f, -0.12628587f, -0.07481278f, -0.08381997f, 0.01334814f, -0.09168655f, 
    -0.60727561f, -0.52841508f, -0.31589508f, 0.02629490f, -0.11756334f, -0.27271277f, 0.22609511f, -0.05581320f, 
    -0.10093490f, 0.07433106f, 0.02979281f, -0.00903927f, 0.00327051f, 0.02910642f, -0.22086664f, 0.16511761f, 
    -0.01278859f, -0.15478310f, 0.03232354f, -0.03611205f, -0.00319447f, 0.17130618f, 0.19468962f, -0.09154589f, 
    0.12737705f, 0.08173317f, 0.08779808f, -0.06469752f, 0.04407871f, 0.03508625f, 0.06813864f, -0.01191248f, 
    0.02865346f, 0.05433678f, -0.10499796f, -0.04362372f, 0.40094134f, -0.05968660f, -0.00205456f, -0.03081890f, 
    -0.00405878f, -0.05804533f, -0.10141518f, -0.00284687f, 0.16527720f, -0.00304099f, 0.15516585f, -0.14430258f, 
    0.14553906f, -0.18783160f, -0.50838023f, -0.09194797f, 0.04776206f, -0.15257120f, -0.08871721f, -0.11611488f, 
    -0.03736935f, 0.03817212f, -0.03038340f, 0.03132354f, 0.14352159f, -0.01915251f, 0.08569103f, -0.19349462f, 
    0.02710142f, 0.00013238f, -0.04017681f, -0.01086482f, -0.02594366f, 0.04428442f, -0.09693988f, -0.12705626f, 
    -0.18670046f, -0.57303572f, 0.76367170f, -0.45451516f, 0.16808920f, 0.08168527f, -0.05707365f, 0.35717034f, 
    -0.02640673f, -0.04220724f, -0.08806586f, -0.04271140f, 0.11400095f, -0.00370617f, 0.11514295f, -0.31672060f, 
    0.01831981f, -0.02202907f, -0.02251138f, -0.08563764f, 0.04867817f, 0.05715751f, 0.02140933f, -0.08596075f, 
    0.21698849f, -0.09625773f, 0.07080235f, 0.06431202f, -0.03500620f, -0.02753992f, 0.16388650f, -0.02804567f, 
    -0.14428182f, -0.24735785f, 0.16053268f, 0.07527282f, -0.10984392f, 0.11803140f, 0.22096169f, -0.05323176f, 
    -0.08544375f, 0.15639383f, 0.10310572f, -0.01923723f, -0.03653871f, 0.10279492f, -0.03121974f, 0.04129064f, 
    0.49945292f, 0.01529663f, -0.15759173f, -0.12556820f, 0.00631167f, -0.04049790f, -0.15253495f, -0.08148488f, 
    0.12829250f, -0.02579062f, -0.08194562f, -0.23373713f, -0.06519542f, -0.59262860f, 0.47266451f, 0.10589040f, 
    -0.15066822f, -0.00371758f, -0.26670980f, -0.08016020f, 0.10638481f, -0.12330765f, -0.00436543f, 0.06474686f, 
    0.13387325f, 0.21648726f, 0.23618196f, -0.16943964f, 0.05146629f, 0.07749654f, 0.03189013f, 0.07918502f, 
    -0.14778481f, -0.03286926f, -0.02755400f, -0.05186079f, 0.50423938f, -0.03851605f, 0.08021632f, -0.54726565f, 
    0.05940111f, 0.10304609f, -0.06363869f, -0.01255894f, -0.15595351f, -0.14185213f, -0.06893257f, -0.29250562f, 
    -0.18025517f, 0.01852478f, 0.16510837f, -0.05026659f, -0.07706764f, -0.01842196f, 0.03946539f, -0.03954567f, 
    0.01241835f, 0.02866947f, 0.02835298f, 0.04953925f, -0.71948487f, -0.28199059f, 0.80657357f, -0.72397012f, 
    0.19049269f, -0.29768538f, 0.26591015f, -0.02457998f, -0.06263305f, 0.02240558f, -0.04548880f, -0.01040512f, 
    -0.39995283f, -0.52027923f, -0.33614850f, -0.37339559f, 0.07150903f, 0.19624832f, 0.16054586f, 0.17329407f, 
    0.05694569f, 0.01585989f, -0.09342857f, -0.01749724f, -0.03074707f, 0.09318476f, -0.07104687f, -0.16709685f, 
    -0.02288710f, -0.18651758f, -0.13776766f, -0.00767826f, -0.00172437f, 0.05661173f, 0.02843094f, -0.05926457f, 
    0.14799871f, -0.19810995f, 0.18922512f, -0.37303501f, 0.01056798f, 0.22527768f, -0.01201188f, -0.07473490f, 
    0.05566027f, -0.00284903f, -0.09619185f, -0.13023210f, -0.24611393f, 0.03562753f, 0.17341818f, 0.67683291f, 
    -0.01870593f, -0.01582971f, -0.17300336f, -0.03702008f, -0.06334066f, -0.02216000f, 0.01194713f, -0.05024790f, 
    0.51987976f, -0.40350714f, 0.09658941f, -0.10789504f, 0.13852747f, 0.04323802f, -0.08936218f, -0.17477754f, 
    -0.16589649f, 0.08400698f, -0.02027524f, -0.07896976f, 0.12164798f, 0.06923500f, 0.11739123f, 0.09892491f, 
    0.05165602f, -0.03150884f, -0.04424830f, -0.07482329f, -0.35177556f, -0.20261800f, -0.01652678f, -0.11271951f, 
    -0.29545584f, -0.00871628f, 0.00154874f, 0.16383147f, 0.21627845f, 0.00089158f, -0.15098417f, -0.45379895f, 
    -0.02930639f, -0.06129057f, 0.02309420f, -0.02405072f, -0.10133667f, -0.58197701f, -0.36429164f, 0.07958891f, 
    -0.02114834f, -0.03476350f, -0.04242586f, -0.01964233f, -0.09179920f, 0.07664638f, 0.01070257f, 0.08484893f, 
    0.28056842f, -0.03292361f, -0.22361927f, -0.20412941f, 0.00576509f, -0.10695864f, -0.18516849f, -0.09092334f, 
    0.07745688f, 0.27569196f, 0.15919140f, 0.10790247f, -0.02303306f, -0.85501063f, -0.43126774f, 0.31050342f, 
    -0.03578046f, 0.06918799f, 0.16163664f, 0.18988448f, -0.19257398f, -0.05513880f, -0.05085119f, -0.06712934f, 
    -0.49207857f, -0.59103739f, -0.25271499f, 0.52262402f, -0.02182276f, 0.15474316f, 0.28434107f, 0.09435566f, 
    0.07262456f, 0.11116321f, 0.11094940f, 0.09533627f, 0.32023460f, 0.19962567f, -0.14545175f, -0.17069036f, 
    -0.43387169f, -0.10264363f, -0.23930547f, 0.04686404f, 0.15224731f, 0.11729718f, -0.00418419f, 0.21423174f, 
    0.06792443f, -0.02588914f, -0.05139010f, 0.17965920f, 0.17610471f, -0.38513872f, 0.02603772f, 0.23261058f, 
    -0.04562559f, -0.00150921f, 0.02591872f, -0.07342329f, -0.64253628f, -0.18908876f, -0.17613697f, 0.03700170f, 
    0.11857107f, 0.09386208f, 0.06032287f, 0.11222293f, -0.12411918f, 0.07346892f, -0.39872792f, -0.57402050f, 
    -0.16069214f, -0.15607393f, -0.10211133f, -0.07922101f, -0.08916143f, 0.02220931f, 0.07282288f, 0.06397291f, 
    0.08800551f, 0.08093891f, 0.03214225f, 0.04910109f, 0.52844828f, 0.59758586f, 0.04908439f, 0.28508529f, 
    0.02784360f, -0.06038219f, 0.00771557f, 0.16666377f, 0.17382757f, 0.06091161f, 0.00444140f, 0.07052854f, 
    0.18045919f, -0.68725407f, -0.35557082f, 0.06384639f, 0.14849906f, 0.16773681f, -0.11996480f, 0.08073223f, 
    0.04819078f, -0.14012855f, -0.11571654f, 0.03844096f, 0.00809518f, -0.08618800f, -0.07905884f, 0.12441394f, 
    -0.10132695f, 0.08522337f, 0.03264440f, -0.02633021f, -0.06949255f, -0.30689389f, -0.10926434f, -0.45058823f, 
    -0.24509697f, -0.09622883f, 0.11149538f, 0.02392409f, -0.05786213f, -0.01699713f, -0.03996446f, -0.12289717f, 
    -0.03239259f, 0.14333856f, 0.19676997f, 0.21922977f, 0.16995312f, 0.02993193f, -0.06190230f, -0.26372170f, 
    -0.06180016f, -0.05333702f, -0.01367650f, -0.04813624f, -0.19945371f, 0.04593836f, -0.24750102f, -0.23614715f, 
    0.55159479f, 0.13877453f, 0.00819596f, 0.06009905f, -0.03021853f, 0.12088976f, 0.02400759f, -0.17758413f, 
    0.02593477f, -0.03461415f, -0.02640019f, -0.03616022f, 0.07348141f, -0.07285803f, 0.02508053f, -0.27096400f, 
    -0.03386289f, 0.03931199f, 0.00531475f, -0.09128495f, -0.02055807f, 0.10369408f, 0.15572637f, 0.12730351f, 
    0.53602052f, -0.38125578f, -0.45130202f, -0.33260611f, -0.46476480f, -0.32911843f, 0.10738332f, -0.04484048f, 
    0.02429589f, -0.09191398f, 0.08917696f, 0.02210497f, -0.00737829f, 0.03298683f, 0.13476866f, -0.18583170f, 
    -0.04548386f, -0.07088703f, -0.00845625f, -0.06159498f, -0.13567019f, 0.04199051f, 0.00457268f, -0.09185460f, 
    -0.18197633f, -0.07793563f, -0.27225849f, 0.15622663f, 0.04494808f, 0.13272174f, 0.17265683f, 0.01802001f, 
    0.01780153f, 0.14995955f, 0.10165020f, 0.11719300f, -0.39753997f, 0.21358389f, -0.03749207f, 0.01491556f, 
    -0.06287637f, 0.06741951f, -0.18125226f, 0.12680779f, -0.32807466f, -0.10931914f, 0.04461183f, -0.11614349f, 
    -0.13244827f, -0.16986179f, -0.28926176f, -0.20455983f, -0.07663785f, -0.08903055f, 0.00100864f, 0.09629138f, 
    0.05438893f, -0.03732186f, 0.04994332f, -0.16525103f, 0.73967993f, -0.05845807f, 0.23987362f, -0.14815019f, 
    0.28047639f, -0.00804852f, 0.07011373f, 0.08714166f, -0.04415956f, 0.00135183f, -0.00845357f, 0.03335445f, 
    0.06923089f, -0.01439363f, 0.06364880f, -0.11608052f, -0.19748493f, -0.16749385f, -0.00286557f, 0.01966105f, 
    0.21282302f, -0.04535224f, 0.25315860f, 0.04835632f, 0.08111909f, 0.05492952f, -0.32382718f, -0.24394165f, 
    0.14407416f, -0.08015214f, 0.05249602f, 0.02223212f, 0.03620839f, 0.11073823f, 0.00445270f, 0.22631197f, 
    -0.44980404f, 0.12591906f, 0.15101263f, 0.04920344f, 0.09388148f, 0.11246393f, -0.05737941f, -0.05205905f, 
    0.05727997f, 0.00444577f, 0.09095343f, 0.18788040f, 0.07668952f, -0.35430402f, -0.07105979f, 0.47733074f, 
    0.03895607f, 0.11305808f, -0.14345944f, -0.25142595f, -0.01995823f, 0.10992094f, 0.03701339f, 0.08970305f, 
    -0.14664450f, -0.40883872f, -0.37356776f, -0.07208467f, -0.02782667f, 0.09336683f, 0.00102125f, 0.10462739f, 
    -0.13630643f, -0.09656734f, -0.09843946f, -0.10218202f, -0.31702176f, 0.10777971f, 0.16843563f, -0.04424360f, 
    -0.06661692f, -0.10476805f, 0.05278647f, -0.04268276f, 0.02562211f, -0.03269824f, 0.07424463f, -0.00594330f, 
    0.29352111f, -0.05681538f, -0.12980990f, -0.01594169f, 0.14374213f, 0.29275697f, 0.24197628f, 0.17598107f, 
    -0.08697748f, -0.03138250f, -0.15423262f, -0.10834105f, -0.23083478f, -0.78711879f, -0.47857103f, -0.88179082f, 
    0.13925330f, -0.04056653f, -0.03979351f, 0.08597804f, 0.11706600f, 0.19265142f, 0.13688226f, 0.08520343f, 
    0.44531450f, 0.29943052f, -0.23867963f, -0.60436136f, 0.23432417f, -0.29176626f, -0.02340142f, -0.30368701f, 
    0.03261407f, -0.03793864f, 0.07486838f, 0.01837848f, -0.27469748f, 0.08226236f, 0.09975930f, -0.19160798f, 
    -0.07152440f, 0.02283874f, -0.07452475f, 0.00191784f, -0.05519401f, 0.13688682f, -0.02749400f, 0.06110818f, 
    0.40321469f, 0.23922585f, -0.08293130f, -0.17261897f, 0.05586969f, -0.07898558f, 0.15525335f, 0.10666018f, 
    0.01687094f, 0.04224589f, 0.03345654f, 0.05026722f, -0.27540842f, 0.05985452f, -0.05734486f, -0.17747705f, 
    -0.13405320f, -0.34746554f, -0.04836643f, 0.17816606f, -0.03582487f, -0.07740473f, 0.01211224f, -0.07638201f, 
    -0.19927455f, -0.07960123f, 0.03287169f, 0.17778119f, 0.30887315f, 0.07193210f, -0.13031551f, 0.00936591f, 
    -0.04248011f, -0.02457004f, -0.14304064f, -0.15732656f, -0.33782989f, 0.18424028f, -0.11338119f, -0.44362175f, 
    -0.24129309f, 0.12516005f, 0.15191245f, 0.15889153f, 0.11852863f, -0.00975615f, 0.09805889f, -0.03432798f, 
    0.33085430f, 0.10492283f, 0.07606433f, -0.19740003f, -0.02008416f, -0.08214689f, -0.46868649f, 0.06498697f, 
    -0.08412585f, -0.08577659f, 0.10830061f, 0.09806190f, -0.44272289f, -0.19206557f, 0.13648178f, 0.26071167f, 
    0.19432139f, 0.29923600f, -0.10030760f, 0.14721653f, -0.11034317f, -0.13422912f, -0.13562123f, -0.28093922f, 
    -0.10110924f, -0.17471759f, -0.41768950f, -0.05439196f, -0.28851607f, 0.02638671f, -0.23175505f, 0.00853756f, 
    0.24426338f, -0.07864741f, -0.08667438f, -0.09424984f, -0.57655358f, 0.38668585f, 0.03415707f, -0.31153485f, 
    0.01795835f, -0.08522431f, 0.10385980f, -0.08061764f, 0.24973980f, 0.10391287f, 0.07266864f, 0.17990439f, 
    0.22368601f, -0.08362302f, 0.29458052f, 0.24663600f, 0.14515856f, 0.08619902f, -0.00764913f, -0.03365936f, 
    0.03530818f, 0.11000125f, 0.12516852f, 0.19487257f, -0.68320030f, -0.15636535f, -0.34003124f, 0.27627093f, 
    0.25438318f, -0.08189593f, 0.19306555f, 0.05997343f, -0.05549869f, 0.04407129f, -0.08329981f, -0.15466252f, 
    -0.03104597f, -0.05242761f, 0.69619119f, -0.28892353f, 0.19409569f, -0.46875757f, -0.06647043f, 0.08855546f, 
    -0.06167969f, -0.02457462f, -0.02879530f, -0.04750223f, -0.15833980f, -0.15661532f, 0.10969726f, 0.07972623f, 
    0.13126713f, 0.01579109f, 0.06743784f, 0.05836965f, 0.11692697f, 0.10957459f, 0.07689694f, 0.31277972f, 
    0.09629578f, -0.02095478f, 0.11294966f, -0.26319855f, 0.05559128f, -0.01917192f, 0.24147911f, -0.14680798f, 
    -0.09066631f, -0.08090831f, 0.02405194f, -0.09624672f, -0.32248482f, 0.24702461f, 0.29086116f, 0.46243191f, 
    0.04416672f, 0.08369242f, -0.21129140f, -0.12624930f, 0.15240848f, 0.03378069f, 0.32334986f, 0.03078715f, 
    -0.48442224f, -0.34145114f, -0.20192659f, -0.44271475f, 0.22903690f, -0.02662602f, -0.27658632f, 0.22679567f, 
    0.03751719f, -0.08365351f, 0.07876483f, 0.02236972f, -0.23623584f, -0.17890239f, 0.18875940f, 0.05251356f, 
    0.06683640f, 0.15198410f, -0.03022927f, -0.07300020f, -0.07744861f, -0.02159614f, 0.03017472f, -0.14703766f, 
    -0.63064766f, -0.35719690f, -0.02197599f, -0.10329424f, -0.27545053f, 0.27536991f, 0.09453052f, 0.29169357f, 
    0.06950419f, 0.01019079f, 0.06811699f, -0.03781263f, -0.21915270f, -0.74165303f, 0.20470697f, 0.01345197f, 
    0.02046468f, 0.21310990f, 0.08614262f, -0.12850493f, -0.01282897f, 0.06845565f, -0.04857907f, 0.07677992f, 
    -0.01843074f, 0.45499673f, 0.30196917f, -0.31279498f, -0.07475222f, -0.18608546f, -0.01644613f, -0.35493758f, 
    0.23927085f, -0.00193350f, -0.22405443f, 0.13565144f, -0.24275942f, 0.18542078f, -0.68210632f, -0.47723687f, 
    -0.12701221f, 0.21511963f, 0.29578710f, -0.14006889f, 0.13490851f, -0.01558074f, -0.27287194f, 0.05316350f, 
    0.09473084f, 0.28617501f, 0.22888932f, 0.56752443f, 0.09781156f, -0.11931662f, -0.25535017f, -0.12076601f, 
    0.30514276f, 0.06799331f, 0.11862625f, 0.16022635f, 0.38326883f, -0.62454545f, -0.09310000f, -0.10590468f, 
    0.08053412f, -0.02447756f, 0.02137876f, -0.07320668f, 0.05264476f, -0.15571608f, 0.07214604f, -0.01394935f, 
    -0.07802784f, -0.71047378f, 0.24981402f, -0.02327704f, 0.09641715f, 0.34168005f, -0.19833682f, -0.00376483f, 
    -0.28469428f, 0.13512842f, 0.04419843f, 0.04801029f, 0.18063723f, -0.00471714f, 0.16823870f, 0.44143355f, 
    0.02711987f, -0.04902232f, -0.12213369f, -0.25038099f, 0.00020587f, -0.28681305f, -0.19687156f, 0.03043203f, 
    -0.11522491f, -0.11339751f, -0.00050291f, -0.92359650f, 0.27460590f, -0.16444336f, 0.04741537f, -0.07549728f, 
    -0.04218373f, -0.11726015f, -0.20587847f, 0.15426242f, 0.11101460f, -0.56632864f, -0.22323434f, -0.68494231f, 
    0.08280924f, -0.37924424f, -0.02178256f, 0.06775028f, 0.00539029f, 0.05307733f, -0.08631516f, -0.16794312f, 
    -0.41066465f, 0.04134943f, -0.37660101f, 0.07900535f, -0.15119989f, 0.02387214f, 0.17586859f, -0.08672938f, 
    0.10533570f, 0.07451769f, 0.11716172f, -0.03082948f, 0.00690030f, -0.15440883f, -0.46913552f, -0.10416152f, 
    0.23193799f, 0.13152893f, 0.26524842f, -0.03958996f, -0.13768014f, -0.09557139f, -0.07995002f, -0.00772976f, 
    0.42441219f, -0.04253694f, 0.30319539f, 0.50158447f, -0.09426641f, 0.08557906f, -0.11170843f, -0.13306989f, 
    0.15540673f, -0.01350426f, 0.05648501f, 0.07411435f, -0.15000167f, 0.04625224f, -0.21982598f, -0.07549478f, 
    -0.15662678f, 0.14675653f, -0.15712422f, 0.00016543f, 0.15809181f, 0.09338912f, 0.01103617f, -0.03689454f, 
    -0.57129401f, -0.51867849f, -0.02126901f, 0.20991813f, 0.06849913f, 0.01103867f, 0.19740672f, -0.05098001f, 
    0.08378118f, 0.09940471f, 0.00526659f, -0.01532290f, -0.29332396f, -0.06282374f, -0.02951993f, 0.01434727f, 
    0.10461438f, 0.24629916f, -0.04560138f, 0.08797035f, 0.33419290f, 0.14662056f, 0.03544839f, 0.05266347f, 
    -0.06974363f, 0.07193255f, -0.30976835f, 0.02438043f, -0.01445031f, -0.09191209f, -0.11623088f, -0.05900829f, 
    0.13275281f, 0.08729635f, -0.08288293f, -0.03443522f, -0.27596048f, 0.05172255f, -0.12227747f, 0.07569087f, 
    -0.18741640f, 0.04396641f, 0.01982488f, 0.22638647f, 0.01907378f, 0.23483907f, 0.13606596f, 0.30809987f, 
    -0.34271371f, -0.14745432f, 0.16238052f, 0.08963853f, -0.08593132f, 0.12404046f, 0.15260918f, 0.02549979f, 
    0.00277040f, 0.19376485f, 0.03083427f, 0.19305775f, 0.23430897f, 0.06074391f, 0.04692797f, -0.10368659f, 
    -0.00371898f, -0.17225105f, 0.01544026f, 0.10234745f, -0.34819064f, 0.09707596f, -0.05930143f, -0.12749892f, 
    0.01748593f, -0.08748004f, 0.12796380f, 0.11366174f, 0.20491935f, 0.04991585f, -0.01551913f, 0.03370006f, 
    -0.00891995f, -0.00653641f, -0.12811540f, -0.29172981f, 0.14863744f, 0.13404447f, 0.22853161f, 0.17606905f, 
    -0.00719139f, 0.07061702f, 0.04399798f, 0.12070337f, 0.05282191f, 0.12271124f, 0.00911704f, 0.34706822f, 
    -0.03842483f, -0.45618182f, 0.35080454f, 0.11346912f, 0.01766658f, 0.14667507f, 0.19552633f, -0.06310773f, 
    -0.09319703f, 0.09161140f, 0.16921118f, 0.12942231f, 0.15766646f, -0.13332814f, -0.18416905f, -0.04863861f, 
    0.10442539f, -0.07235676f, 0.07330829f, -0.06516152f, -0.22156495f, -0.48265824f, -0.62233049f, -0.34376016f, 
    -0.17667061f, -0.00612546f, -0.23935844f, 0.17980394f, 0.00334008f, 0.00614978f, 0.02002337f, -0.19514570f, 
    -0.16073391f, 0.09707902f, 0.06829999f, 0.04271878f, 0.18454863f, -0.36205509f, 0.07087722f, 0.35088557f, 
    -0.09497052f, 0.19152795f, -0.06386302f, -0.08799379f, -0.17150383f, -0.09829852f, -0.05586844f, 0.35067278f, 
    -0.47361246f, 0.24509582f, -0.12412618f, 0.59425461f, 0.03325560f, 0.12910560f, -0.02177945f, 0.21452929f, 
    0.14568420f, -0.09811191f, -0.04820500f, 0.16955867f, -0.26483342f, 0.36147776f, 0.12771092f, -0.17772810f, 
    -0.09952922f, 0.08309619f, -0.30294615f, 0.13769469f, 0.05603041f, -0.35789779f, -0.17745633f, -0.43441227f, 
    0.04533469f, 0.29395226f, 0.14888646f, 0.22829100f, -0.06004495f, -0.15078226f, 0.14820448f, -0.10100357f, 
    0.19107288f, 0.24913374f, -0.20431313f, 0.08594032f, 0.52788329f, -0.23613982f, 0.30345550f, -0.01472781f, 
    0.00953788f, 0.10731073f, -0.03337070f, -0.02641869f, -0.08187611f, -0.04700145f, -0.44445392f, -0.42510024f, 
    -0.36318165f, -0.27533916f, 0.44723222f, 0.09224337f, -0.15271193f, 0.17101619f, -0.15881468f, 0.04023078f, 
    -0.04661935f, -0.09469678f, 0.02571345f, 0.09240367f, -0.15569203f, -0.04062843f, -0.12491313f, -0.06619608f, 
    -0.23041676f, -0.23328935f, 0.28102419f, -0.08236418f, -0.00489328f, 0.15167566f, 0.24320026f, 0.19471571f, 
    -0.30897930f, 0.18271415f, -0.62360448f, 0.11556565f, -0.08674573f, -0.02490962f, -0.32736701f, -0.12256989f, 
    0.13220130f, 0.22191906f, 0.01843256f, -0.19315152f, -0.25969860f, -0.31519631f, -0.48599628f, -0.03169087f, 
    -0.22518452f, -0.13439170f, 0.04983507f, -0.14401081f, 0.04246723f, 0.12538266f, -0.15701598f, -0.05778532f, 
    0.19180992f, 0.19618014f, 0.35079965f, -0.17001106f, -0.13325290f, 0.08216067f, 0.25545844f, -0.04852647f, 
    -0.04533296f, 0.00063296f, 0.28873056f, 0.14250220f, 0.11500033f, -0.12578689f, 0.52768952f, 0.28836963f, 
    -0.28932887f, -0.38277799f, 0.07052988f, 0.00345474f, -0.17551737f, -0.04106749f, -0.28331345f, -0.00734407f, 
    0.24734861f, -0.03733942f, 0.29686567f, -0.24634033f, 0.03109970f, -0.06202668f, -0.03402971f, 0.10505940f, 
    -0.18244767f, 0.10702612f, -0.23229691f, -0.31828380f, -0.62143987f, 0.24077050f, -0.22111714f, 0.14377409f, 
    0.05894097f, 0.03588960f, 0.07626071f, 0.13246250f, -0.31718811f, 0.06578789f, -0.01387115f, -0.27080327f, 
    -0.33411670f, 0.14154638f, -0.07608051f, 0.25098902f, -0.05762953f, -0.22951131f, 0.06933766f, -0.01082424f, 
    -0.11052306f, -0.16157128f, -0.11312371f, 0.20638996f, 0.00024062f, 0.62928396f, -0.08285990f, -0.16533653f, 
    -0.09972800f, -0.16564168f, 0.19949545f, -0.14047647f, 0.00782461f, 0.24835573f, 0.00989906f, 0.09244706f, 
    -0.42568201f, -0.21001770f, 0.72503448f, 0.24481495f, 0.07097343f, 0.23527326f, -0.06453006f, 0.02710465f, 
    -0.22623929f, 0.17355844f, 0.06120649f, 0.01143089f, -0.70203441f, 0.28170201f, -0.28815651f, 0.34001204f, 
    -0.13106082f, 0.08036321f, -0.10477926f, 0.41518179f, -0.09903203f, -0.07758600f, 0.26452243f, 0.10561617f, 
    0.21965100f, -0.04639541f, -0.19183199f, -0.01030391f, 0.03899552f, -0.06967278f, 0.02385046f, 0.21680233f, 
    -0.15040112f, 0.05039008f, -0.13612169f, -0.18370079f, -0.39276153f, -0.36740515f, -0.11100848f, -0.37645593f, 
    -0.22579041f, -0.01802794f, 0.22371355f, -0.24593243f, 0.02326225f, 0.11891284f, 0.15101585f, -0.16479608f, 
    -0.58684796f, 0.04779560f, -0.71642560f, -0.00971955f, -0.00045120f, -0.24171606f, 0.10647266f, 0.10829058f, 
    -0.05993185f, -0.03828635f, -0.12888534f, -0.09754440f, 0.20250271f, -0.05268558f, -0.40451455f, 0.00502844f, 
    -0.02288176f, -0.00008548f, 0.30261543f, -0.09461424f, 0.07223136f, 0.14324045f, 0.10260002f, -0.01950271f, 
    -0.78240550f, 0.30651304f, -0.50535607f, -0.14806226f, -0.00451568f, 0.21178135f, 0.18407579f, -0.05513814f, 
    -0.15464470f, 0.00039233f, -0.08970660f, -0.27779317f, 0.06255556f, -0.28827003f, 0.30627593f, -0.33484003f, 
    -0.27146173f, -0.63969123f, 0.16660003f, -0.01784772f, -0.34252363f, 0.06741267f, -0.16225983f, -0.14218658f, 
    -0.14661929f, -0.24590744f, -0.03623055f, -0.14723068f, -0.19439211f, -0.21263199f, -0.05726224f, -0.02507603f, 
    -0.02501831f, 0.15750447f, -0.01672362f, -0.00920363f, 0.10293341f, -0.26885140f, 0.11009248f, -0.28121707f, 
    -0.17274538f, -0.31583959f, -0.26588741f, -0.09434647f, 0.01334781f, -0.15725811f, -0.08774102f, -0.17381087f, 
    0.04974716f, 0.24729361f, -0.07296763f, 0.00747702f, -0.11640497f, 0.15228839f, 0.00137764f, -0.00010084f, 
    0.06807305f, -0.04423272f, 0.12594979f, -0.11813519f, 0.36380440f, -0.09675809f, 0.34801349f, -0.13332605f, 
    -0.00552173f, 0.04361467f, -0.02119494f, -0.21713410f, 0.08168244f, -0.08357233f, -0.03179035f, -0.15616232f, 
    -0.56844813f, -0.00179556f, -0.27095211f, -0.13121389f, -0.07455104f, -0.12376558f, 0.00371634f, 0.10540297f, 
    -0.10653527f, -0.00295314f, 0.00586269f, -0.04029899f, -0.23613751f, 0.26321608f, -0.38319686f, 0.01397191f, 
    0.23891111f, -0.12044677f, 0.14178579f, -0.25637290f, -0.12175745f, 0.11948939f, 0.03005437f, -0.09529616f, 
    -0.24160071f, 0.02186969f, -0.13098475f, 0.14552534f, 0.15465958f, 0.05363300f, 0.49158469f, -0.04033821f, 
    0.07971654f, -0.24934146f, 0.13754658f, 0.06395547f, 0.01957348f, -0.52707130f, 0.29505360f, -0.64945006f, 
    0.04579120f, 0.14301068f, -0.14048165f, 0.08835131f, 0.07695237f, 0.05785862f, 0.20412594f, 0.06508471f, 
    -0.37282574f, 0.04929294f, -0.25857282f, 0.15808977f, -0.00397375f, -0.03107129f, 0.09653907f, 0.02134049f, 
    0.03353379f, -0.03189525f, 0.00547983f, -0.12242100f, 0.40444076f, -0.09942909f, 0.54182881f, -0.19478536f, 
    -0.11911130f, -0.10446095f, -0.12247340f, 0.27904931f, -0.04435908f, 0.11844510f, -0.00123782f, -0.05661479f, 
    -0.32563010f, -0.97782904f, 0.50880951f, 0.06768944f, -0.09818845f, -0.05484034f, -0.08392610f, 0.18365875f, 
    -0.09884752f, 0.07453547f, 0.09478492f, -0.21555938f, -0.11062599f, -0.00162960f, 0.14762384f, -0.09290090f, 
    0.11169548f, 0.10253160f, 0.08666790f, 0.16526549f, 0.18057078f, 0.33886907f, 0.04051308f, 0.13885017f, 
    -0.20991537f, -0.10558686f, -0.09834392f, -0.21170105f, 0.11553752f, 0.12454922f, -0.15352605f, 0.13525543f, 
    -0.03006617f, -0.16742563f, -0.12483712f, 0.07823132f, -0.45803863f, -0.00682465f, -0.11080374f, 0.02324017f, 
    0.13450731f, 0.12475488f, 0.00928334f, -0.06252518f, 0.05536148f, 0.08256552f, 0.26443732f, 0.15954818f, 
    -0.02382374f, 0.20139748f, 0.30087265f, -0.42557368f, 0.10718653f, 0.15083198f, 0.20536417f, -0.05586128f, 
    0.06565345f, -0.07722297f, -0.10131266f, 0.09265970f, -0.10239870f, 0.40243208f, -0.06080573f, -0.08893791f, 
    -0.06175569f, 0.05756332f, -0.01958944f, 0.03445780f, -0.04831063f, -0.05899063f, -0.13075837f, -0.13728732f, 
    -0.09642421f, -0.76454985f, -0.19100288f, 0.33633924f, -0.07907163f, -0.02674553f, -0.13071267f, -0.14385693f, 
    0.03953069f, -0.02545858f, -0.03593293f, -0.04741908f, -0.01022700f, 0.31304297f, -0.00453045f, -0.19236444f, 
    -0.01986917f, -0.04003664f, 0.20306531f, -0.10435621f, 0.00921155f, -0.06038664f, -0.02177972f, -0.09589803f, 
    -0.24209027f, -0.07008673f, -0.06882480f, -0.09498851f, 0.01541856f, 0.13185745f, 0.07279620f, 0.33278069f, 
    -0.04637099f, 0.20946148f, -0.04226424f, -0.12993406f, -0.04035025f, -0.03664871f, 0.49013472f, 0.28545079f, 
    -0.21593919f, -0.02361388f, 0.06870057f, -0.14748403f, -0.13242270f, -0.10196286f, 0.15797958f, 0.05608961f, 
    -0.49497133f, -0.13848101f, -0.23936196f, -0.17665638f, -0.00759624f, 0.17161241f, -0.06841021f, -0.06366175f, 
    -0.03949323f, -0.03621676f, 0.14612728f, -0.04055694f, -0.15719619f, 0.35491696f, -0.00438468f, 0.47386804f, 
    0.32531357f, -0.11241917f, 0.35584843f, 0.14728139f, 0.00271380f, 0.01797935f, 0.05922070f, 0.25480208f, 
    -0.43808690f, 0.22374441f, -0.36364511f, 0.14512180f, 0.17785023f, -0.20423213f, 0.15007754f, -0.19937059f, 
    -0.13179375f, 0.01220938f, -0.08492467f, -0.10298558f, -0.14314117f, -0.26419356f, -0.08351271f, 0.19267933f, 
    0.11257339f, 0.03453460f, -0.02370561f, 0.08089934f, -0.01990289f, 0.05752129f, -0.05983713f, -0.20040810f, 
    0.49932104f, 0.04678248f, -0.21478415f, 0.41097912f, 0.01297739f, 0.00107315f, 0.12815726f, 0.54718524f, 
    -0.27926514f, 0.02877505f, 0.01781015f, -0.04735845f, -0.08095166f, 0.26207456f, 0.34734577f, 0.36812422f, 
    -0.29178950f, -0.08897103f, -0.24099644f, 0.15703781f, -0.06724539f, -0.11133150f, -0.12392757f, 0.00794123f, 
    0.16862653f, 0.20775349f, -0.06512824f, -0.24675308f, -0.27108404f, -0.16379277f, 0.34483185f, 0.24496324f, 
    0.06154357f, 0.03176361f, 0.15722206f, 0.07154494f, 0.68729931f, 0.39453393f, 0.32637233f, -0.33388579f, 
    0.01660486f, 0.17397100f, -0.27924299f, 0.15938210f, -0.05897987f, -0.00100398f, -0.15272160f, -0.01166037f, 
    0.16096333f, 0.35341001f, -0.56728423f, -0.21697967f, 0.02192864f, -0.37100980f, 0.21298735f, -0.08140164f, 
    0.12670141f, 0.11837067f, 0.15715502f, 0.04974172f, -0.85635507f, -0.21452254f, -0.08551942f, -0.14585900f, 
    -0.42801088f, -0.20329387f, -0.08339220f, -0.40008610f, 0.10989670f, 0.13487497f, 0.03084436f, 0.04969725f, 
    -0.05408687f, -0.34132588f, -0.11273269f, 0.17394495f, 0.14835536f, 0.10397728f, 0.05252317f, -0.09320124f, 
    -0.00457143f, 0.04102659f, 0.01461250f, 0.03838242f, -0.03147305f, 0.03058291f, -0.26379353f, -0.12598915f, 
    -0.06642288f, 0.08170820f, 0.09587988f, 0.07377900f, -0.08300524f, 0.12338524f, 0.06119894f, -0.02233204f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.26171398f, 0.22141321f, 0.07184391f, -0.13552567f, -0.14603993f, 0.02260392f, 0.04490066f, -0.18785717f, 
    0.02903401f, 0.02417621f, 0.01389191f, -0.03762630f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
