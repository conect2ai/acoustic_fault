#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.26677021f, -0.12265863f, 0.00217701f, -0.10235359f, -0.22585355f, 0.14465119f, 0.21916425f, 0.06916572f, 
    0.06576732f, 0.42695352f, 0.00211751f, 0.46798053f, -0.42898467f, -0.15655215f, -0.10477269f, -0.10989163f, 
    -0.30293006f, 0.14671098f, -0.19829901f, -0.20997304f, -0.08561405f, -0.25760400f, -0.16696353f, -0.18013412f, 
    0.06416826f, 0.39557618f, 0.25468698f, -0.29096085f, -0.30099759f, -0.25952902f, 0.04151852f, -0.07462902f, 
    0.25096247f, -0.11686847f, 0.04503055f, 0.02960832f, 0.01451389f, 0.40420082f, -0.13457653f, -0.03534234f, 
    -0.14835031f, -0.13183726f, 0.14055264f, -0.10664089f, -0.28213337f, 0.14572021f, 0.14800221f, 0.21175463f, 
    0.26032063f, 0.28284949f, -0.62847322f, -0.28052577f, 0.20893113f, 0.23960356f, 0.53941929f, 0.46013168f, 
    -0.07137196f, -0.18399179f, 0.15857077f, 0.61908239f, -0.14162152f, 0.36679557f, -0.34105933f, -0.03023946f, 
    0.24826249f, -0.40892845f, -0.08432450f, -0.01437760f, 0.09993622f, -0.30550650f, 0.13882712f, 0.32755765f, 
    -0.23827431f, 0.23453736f, -0.02520570f, -0.49133629f, -0.39418629f, -0.26944208f, -0.14647898f, -0.52040899f, 
    0.45823234f, -0.01868697f, -0.23293804f, -0.42562971f, -0.22951947f, 0.12449446f, 0.26840413f, 0.14762303f, 
    0.33645040f, 0.40984651f, -0.11860577f, -0.17546591f, -0.03472243f, -0.11282874f, -0.37861118f, -0.02156366f, 
    0.07430628f, 0.11633228f, -0.20358439f, 0.20103271f, -0.37259081f, -0.78938496f, -0.02279113f, 0.13309939f, 
    0.49720675f, -0.12060378f, -0.13487519f, 0.03019997f, 0.04389432f, -0.32023731f, -0.12240473f, -0.16715798f, 
    -0.21361962f, -0.13532755f, -0.04626293f, 0.07427377f, -0.10632991f, 0.01335546f, 0.45057631f, -0.04875391f, 
    -0.22001573f, -0.18220319f, -0.25893196f, 0.01218080f, -0.22742128f, -0.07754523f, -0.05887366f, 0.23996384f, 
    0.18468405f, -0.14137487f, 0.08843012f, 0.01367873f, -0.10417451f, -0.06265897f, -0.37675321f, -0.32188955f, 
    -0.25221434f, 0.24474429f, -0.10312192f, -0.25699756f, -0.06441619f, -0.10614208f, 0.19404803f, 0.13776194f, 
    0.20002909f, -0.29688573f, -0.37901416f, -0.33839458f, 0.31134906f, 0.41607514f, 0.16564348f, -0.84223384f, 
    -0.34512618f, 0.24381141f, 0.42795044f, -0.33139783f, -0.13647328f, -0.24169284f, -0.44013283f, -0.32572281f, 
    0.21740381f, -0.05305806f, 0.37493175f, -0.02265837f, -0.09014991f, 0.08065481f, -0.21612965f, -0.23522179f, 
    -0.31771827f, -0.28597090f, -0.17032935f, 0.08385314f, -0.04174934f, -0.14926758f, -0.21773370f, 0.00462824f, 
    0.47615877f, 0.29433152f, 0.38006076f, -0.10088066f, -0.11744051f, -0.54168326f, -0.02736565f, 0.14230351f, 
    0.16260150f, -0.20433977f, -0.18749553f, 0.11030933f, -0.06176489f, -0.10542901f, 0.13534945f, 0.19127510f, 
    0.18880947f, 0.22530207f, -0.20930882f, -0.23191243f, -0.13714479f, -0.28799534f, -0.30974069f, -0.55200315f, 
    0.61193657f, -0.66419089f, -0.70415252f, -0.52123749f, -0.81129950f, 0.46959767f, 0.25107768f, 0.39208043f, 
    0.03820412f, 0.00046367f, 0.01202933f, 0.27178434f, -0.44405219f, -0.24364656f, -0.24287213f, -0.07393209f, 
    0.07894026f, 0.06611741f, -0.13413472f, -0.17969213f, 0.08460903f, -0.11669131f, 0.00105803f, 0.05751416f, 
    -0.05948452f, 0.09246497f, -0.30004922f, -0.62938434f, -0.66840428f, -0.25976053f, 0.23415510f, -0.11872591f, 
    -0.27352643f, -0.22308815f, 0.49398425f, -0.22417569f, 0.16612215f, 0.33494675f, -0.16904637f, -0.04586202f, 
    0.09289534f, -0.03702923f, 0.04045117f, 0.09046496f, 0.03593149f, -0.03025422f, -0.04119956f, -0.24058415f, 
    0.01494321f, -0.14181077f, -0.38998187f, -1.17456818f, -0.53060275f, 0.14140163f, 0.51057720f, 0.29952198f, 
    0.72985101f, 0.23947483f, -0.27389508f, -0.18348652f, 0.17057641f, -0.00523655f, 0.21392924f, -0.17554696f, 
    0.07553273f, 0.04797043f, 0.06225922f, 0.09655166f, -0.16268159f, 0.20217714f, 0.03284459f, -0.09487873f, 
    -0.14180388f, 0.07513007f, 0.00317139f, -0.35936505f, 0.06747556f, 0.27540135f, -0.21247053f, -0.50013453f, 
    -0.08725719f, -0.63650268f, -0.55851644f, -0.33377373f, -0.36431491f, 0.06980009f, -0.27984381f, -0.11906812f, 
    -0.49161422f, -0.11184669f, 0.01731319f, -0.18250826f, 0.18254571f, 0.03782044f, -0.13193955f, 0.03717501f, 
    -0.07026459f, 0.02340064f, -0.06625861f, 0.10411941f, 0.04408037f, 0.63229764f, -0.49838027f, 0.18308547f, 
    -0.19016866f, -0.97290254f, -0.39518401f, 0.36303350f, 0.41826889f, 0.42004770f, -0.13918632f, -0.07589293f, 
    0.22519763f, 0.35072479f, -0.15314399f, 0.15157342f, -0.21482220f, 0.24699111f, 0.07403813f, -0.21290568f, 
    0.03665045f, 0.02261327f, -0.13546631f, -0.08930685f, -0.04685622f, -0.11337669f, 0.32784858f, -0.56582385f, 
    -0.59228551f, 0.48273721f, -0.03917116f, -0.00189549f, -0.27238140f, -0.42380795f, -0.57161397f, -0.25685164f, 
    0.18751675f, -0.02261805f, 0.18070152f, -0.20837142f, -0.08577466f, -0.05338379f, -0.17525558f, 0.10377531f, 
    -0.22339442f, 0.27028766f, 0.32864130f, 0.06252619f, 0.10473972f, 0.35704601f, 0.86616188f, 0.36095706f, 
    -0.63256800f, -0.00704816f, 0.02228678f, -0.15460280f, 0.33365914f, -0.32060838f, -0.23240346f, 0.14030176f, 
    -0.22473553f, 0.28916726f, -0.01996614f, -0.06329954f, 0.00660988f, -0.03196681f, -0.06012492f, -0.08790027f, 
    -0.09488661f, -0.00995392f, 0.00248331f, -0.14865224f, 0.04563756f, -0.16108060f, -0.10548210f, 0.40338230f, 
    0.56983626f, 0.40768266f, -0.00261335f, 0.31111124f, -0.13195445f, -0.25488958f, -0.27054358f, 0.06344035f, 
    0.23945442f, 0.27133095f, -0.30163676f, 0.10510043f, 0.22799906f, -0.31925803f, 0.09138349f, 0.11941994f, 
    -0.08634338f, 0.09322025f, -0.39207876f, -0.10871897f, 0.24398059f, -0.04894919f, 0.19658753f, -0.18583590f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01119141f, 0.18062465f, 0.19466020f, -0.04752112f, 0.10180448f, 0.29879075f, -0.31315500f, -0.02385153f, 
    0.25445539f, 0.08013666f, 0.16447809f, -0.27592263f, -0.05308663f, 0.03491898f, 0.16856694f, 0.36102414f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.24308613f, -0.05967482f, -0.28534526f, -0.15690668f, 0.04473191f, 0.08257766f, 0.06060179f, 0.12757023f, 
    -0.11783300f, -0.17384385f, 0.04658783f, -0.03957468f, 0.08368055f, 0.04298578f, 0.00933122f, 0.01709946f, 
    -0.10341112f, 0.04791800f, 0.01404563f, 0.00472304f, -0.05661731f, 0.01418951f, -0.01394243f, 0.05821032f, 
    -0.21938699f, -0.13800892f, 0.08926370f, -0.20856407f, -0.01672303f, -0.01579558f, -0.08663602f, -0.01163887f, 
    0.01539791f, 0.23483962f, 0.04411666f, -0.01816123f, 0.29867288f, 0.35207313f, 0.05060555f, -0.02427067f, 
    0.05693083f, 0.19315171f, 0.00504216f, 0.14826296f, 0.03187558f, 0.01948005f, -0.04770168f, -0.09353524f, 
    -0.00588222f, 0.03058754f, 0.15541564f, -0.12161607f, -0.02405760f, -0.04196714f, 0.05319605f, 0.03944030f, 
    -0.04989524f, 0.06415632f, -0.05340267f, 0.02604384f, 0.20623821f, 0.04774696f, -0.07033763f, 0.01585666f, 
    -0.09716560f, -0.00556174f, -0.03637544f, 0.00297935f, 0.00416371f, -0.06925464f, -0.04965375f, 0.17355536f, 
    0.16858788f, 0.19400397f, 0.34600592f, -0.12117597f, -0.04962987f, -0.06246128f, -0.11546933f, 0.05777023f, 
    0.03118988f, 0.06893399f, 0.00154714f, 0.11477732f, 0.00517835f, -0.14585494f, 0.02406710f, -0.00790386f, 
    0.13080442f, 0.05180303f, -0.06362858f, 0.03331615f, -0.09474225f, -0.04441439f, -0.03203099f, -0.15505685f, 
    0.40461800f, -0.24668020f, -0.15109538f, -0.20130694f, -0.00971559f, -0.13141601f, -0.07083918f, 0.07694268f, 
    -0.02644318f, -0.06359980f, -0.04025877f, -0.05239395f, 0.19134411f, 0.26595521f, 0.15110983f, -0.08864470f, 
    0.15494616f, -0.10934681f, -0.06372548f, 0.00003239f, -0.07191987f, -0.05897246f, 0.05040648f, 0.05277397f, 
    0.08908879f, 0.22686580f, -0.20141912f, -0.02652117f, 0.16161750f, 0.00812828f, -0.04100341f, 0.06457951f, 
    -0.02051088f, 0.09553958f, 0.04171467f, 0.05778765f, 0.17247826f, 0.38628727f, -0.02090963f, 0.10496885f, 
    0.04531159f, 0.03779811f, 0.05202382f, 0.17169558f, 0.07745618f, 0.12062574f, 0.07533865f, -0.04453834f, 
    -0.14137404f, -0.07366610f, -0.02355668f, 0.14725713f, -0.08673717f, -0.23086630f, 0.16984020f, 0.05430891f, 
    0.02772750f, 0.01091624f, -0.07630833f, 0.06085728f, 0.25774032f, 0.43342149f, 0.16330858f, 0.12422180f, 
    -0.06964058f, 0.00785157f, 0.14326476f, 0.12180179f, 0.09388272f, 0.01105692f, 0.05566083f, 0.08189532f, 
    0.21723969f, -0.06637140f, -0.33232582f, -0.10952324f, 0.00695120f, -0.03412348f, 0.17438982f, -0.01188870f, 
    -0.05091990f, -0.06430434f, 0.11757493f, -0.15921567f, -0.26663983f, -0.15407406f, -0.40432248f, -0.05848394f, 
    -0.09078544f, -0.03847717f, -0.05263243f, 0.06426238f, 0.13665992f, 0.10795427f, 0.00188317f, 0.02640662f, 
    -0.04279628f, 0.11339846f, 0.04226840f, 0.37029234f, -0.05120336f, -0.09835733f, -0.12703265f, -0.02427943f, 
    0.06053008f, 0.18592219f, 0.08207495f, 0.21553794f, -0.02466289f, -0.01660311f, 0.05097421f, -0.05460580f, 
    0.14937347f, -0.07563523f, 0.10951844f, 0.10583276f, 0.09726183f, 0.03495568f, 0.03882192f, 0.11978025f, 
    0.11610822f, 0.01203311f, -0.02596921f, -0.03733904f, 0.06542584f, 0.05331527f, 0.09469952f, 0.07814834f, 
    0.09813093f, 0.12922040f, 0.17187241f, 0.15390705f, -0.27690405f, -0.22930674f, -0.09918348f, -0.15296982f, 
    -0.08913180f, -0.05300742f, 0.03561463f, -0.04936173f, -0.04451926f, 0.00227048f, -0.02251704f, 0.09135416f, 
    0.18183157f, -0.04982752f, -0.15287156f, -0.06382643f, 0.18854560f, -0.03722549f, 0.14315943f, 0.05508857f, 
    0.00535470f, 0.01126296f, 0.03275718f, 0.03022632f, 0.04213071f, 0.12467267f, 0.09601998f, 0.04325045f, 
    0.18370976f, 0.06775539f, 0.16689327f, 0.04624594f, -0.04294550f, 0.03895454f, -0.03071148f, 0.03479367f, 
    -0.04102537f, -0.07835808f, -0.20656821f, -0.04072461f, 0.06122410f, 0.15363532f, -0.12322661f, 0.09977368f, 
    -0.06829508f, 0.05097464f, 0.11597791f, -0.00191843f, -0.00170517f, 0.05799889f, -0.08022267f, -0.17654653f, 
    -0.02816368f, 0.03695029f, -0.01627046f, 0.01733501f, 0.07150260f, -0.06097193f, -0.01883517f, -0.06410103f, 
    -0.34564403f, 0.10919561f, -0.09080511f, 0.21222177f, 0.01144628f, -0.00402908f, 0.16388662f, 0.00166625f, 
    0.05736580f, 0.08609290f, 0.10414883f, 0.02215879f, -0.15868439f, -0.17389253f, -0.24364340f, 0.00977348f, 
    0.00196875f, 0.09701551f, 0.11104599f, 0.21598992f, -0.01744333f, 0.01009758f, -0.05020465f, -0.10897837f, 
    -0.03566118f, 0.07045153f, 0.15598904f, -0.19691451f, -0.11189296f, -0.05487065f, 0.06869747f, 0.04858549f, 
    0.07818236f, 0.18506391f, 0.07614311f, -0.08820226f, -0.16313314f, -0.27033681f, -0.11303592f, -0.22951506f, 
    0.04984157f, 0.09908347f, -0.13386126f, -0.18454622f, -0.04210367f, -0.04802354f, -0.00738668f, 0.09671982f, 
    0.32131052f, -0.01217491f, -0.09153686f, -0.14331475f, 0.03334728f, 0.29977408f, -0.12215647f, 0.01576862f, 
    0.03638941f, 0.02793821f, 0.11301769f, 0.21092704f, -0.35124412f, -0.37905258f, -0.16520804f, -0.18844001f, 
    0.12806047f, 0.03320694f, -0.02408908f, 0.11190949f, -0.10137725f, 0.11207424f, -0.00981786f, -0.02303766f, 
    0.01390608f, 0.06337886f, 0.21476519f, 0.31603375f, 0.05656347f, 0.04869100f, -0.02859599f, 0.15029539f, 
    -0.01738782f, -0.02270204f, 0.07878077f, 0.12476221f, 0.12945347f, 0.06387491f, 0.22131474f, -0.17282148f, 
    0.03507055f, -0.03682826f, 0.04153706f, 0.08086815f, -0.05350714f, -0.06781641f, 0.08671433f, 0.03652146f, 
    -0.03154070f, -0.06371821f, -0.01935856f, 0.04612504f, 0.05932176f, -0.04002647f, -0.05820885f, 0.04483350f, 
    -0.00673343f, 0.02468024f, -0.05961690f, 0.01141224f, 0.01400817f, 0.04633497f, -0.08457786f, -0.04233566f, 
    -0.03797449f, -0.00050754f, -0.02570521f, -0.07460532f, 0.01604795f, 0.02763030f, -0.06887490f, -0.00488836f, 
    -0.05584322f, 0.03887774f, -0.08356337f, 0.03998357f, -0.06586020f, -0.00309048f, -0.03158046f, 0.04875517f, 
    -0.08009884f, -0.03867454f, -0.00321665f, 0.00795209f, -0.04839585f, -0.04187214f, -0.05045019f, -0.03886700f, 
    -0.04517637f, -0.01546577f, 0.02324728f, 0.02975699f, -0.05207021f, 0.05652261f, -0.05788848f, 0.03107850f, 
    0.04203156f, -0.03945915f, 0.02878616f, 0.04134101f, -0.07991734f, 0.05980935f, 0.03897962f, -0.00866846f, 
    -0.02968284f, 0.06237060f, 0.03983751f, 0.00987326f, -0.08207634f, -0.03994119f, -0.01419655f, 0.02612803f, 
    0.00784574f, -0.08369293f, -0.07928608f, -0.05493724f, 0.00060246f, 0.03208486f, -0.03702508f, -0.06516230f, 
    -0.00419363f, -0.03953360f, 0.04998469f, -0.00812351f, -0.07515460f, 0.04526475f, 0.01080106f, -0.06781635f, 
    -0.04453159f, -0.00909767f, -0.00035700f, 0.05514156f, -0.00843260f, 0.02955762f, 0.03218757f, -0.07748879f, 
    -0.03645347f, -0.07472362f, 0.05929684f, -0.06483043f, -0.04936608f, -0.07260090f, -0.03907534f, 0.04424408f, 
    0.05284185f, 0.00792054f, -0.03377770f, -0.00003285f, -0.06971869f, 0.03224681f, 0.04555665f, -0.02168024f, 
    0.01621619f, 0.04402677f, 0.03713941f, 0.00165216f, 0.00739943f, -0.04114947f, -0.07821625f, 0.04358761f, 
    0.00523001f, -0.05631161f, -0.00776573f, 0.00399849f, 0.03376970f, 0.02712676f, -0.07059411f, 0.00915582f, 
    -0.07263959f, 0.05424742f, 0.00064924f, -0.03172718f, -0.07086942f, -0.01574836f, -0.01075001f, -0.03564739f, 
    0.00641539f, 0.02991970f, -0.04085621f, 0.04056836f, 0.03475889f, 0.05717545f, -0.02927559f, 0.01162398f, 
    -0.02300309f, 0.04623045f, -0.04945119f, -0.06270081f, 0.00668641f, 0.03025225f, -0.06933869f, -0.02873170f, 
    0.02501849f, 0.00234759f, 0.03708304f, 0.00031277f, 0.05782415f, 0.06176483f, -0.02889833f, 0.05093529f, 
    0.01960001f, -0.01902437f, 0.04494660f, -0.02775690f, 0.04283342f, -0.03269578f, 0.00119507f, 0.02478680f, 
    0.00291891f, 0.02934365f, 0.04737202f, -0.06615641f, 0.03269366f, -0.05654280f, 0.05128796f, 0.01647570f, 
    -0.04132341f, 0.04932375f, -0.02934620f, 0.03825422f, 0.02551281f, -0.02887824f, -0.06553589f, -0.08095831f, 
    0.00432440f, -0.01296149f, -0.07143611f, 0.02307453f, -0.06512055f, -0.06997933f, 0.00060410f, 0.02409423f, 
    -0.05911380f, 0.05712483f, -0.04805201f, -0.07809113f, -0.05933504f, 0.04587885f, 0.04010738f, 0.04641298f, 
    0.24241193f, 0.07688231f, 0.07607701f, -0.19975412f, -0.10921827f, 0.01535664f, -0.08188456f, -0.11835665f, 
    0.05792320f, -0.24723996f, 0.02923616f, 0.00353876f, -0.00263107f, -0.09378441f, -0.11766672f, -0.21771395f, 
    -0.08859055f, 0.10902793f, -0.02145252f, -0.00867961f, -0.01287870f, -0.06508698f, 0.15851742f, 0.08896044f, 
    -0.21993983f, -0.10813337f, 0.17422138f, 0.07639612f, -0.30919683f, -0.07388579f, -0.12084396f, 0.00080696f, 
    0.16126788f, 0.08159891f, 0.12573653f, 0.00080361f, 0.20112267f, 0.17399822f, 0.24327542f, -0.12133157f, 
    -0.04475116f, -0.02417269f, 0.18466644f, 0.15222593f, 0.10460740f, -0.08794973f, -0.00537656f, 0.05403669f, 
    0.05364456f, 0.08365246f, 0.30415803f, -0.06602075f, 0.01600209f, -0.03553982f, 0.08025630f, 0.08672669f, 
    -0.02775387f, 0.00545914f, -0.13092981f, -0.08213654f, 0.14832699f, 0.02677162f, -0.03876903f, 0.06209715f, 
    -0.01666437f, 0.17974110f, 0.06781363f, -0.00339918f, -0.03052758f, 0.14106232f, 0.03410024f, -0.04578499f, 
    0.10015000f, 0.07723296f, 0.40035558f, -0.04358484f, 0.11039209f, -0.08137742f, 0.06921402f, 0.03323961f, 
    0.03111457f, -0.18744700f, 0.07307623f, 0.12816054f, -0.01247443f, -0.25085580f, -0.04255186f, 0.07905470f, 
    0.15840821f, 0.02376870f, -0.17577101f, -0.13252345f, -0.15890257f, -0.29245663f, 0.03422603f, -0.19737463f, 
    0.33956590f, 0.14034595f, 0.01498606f, -0.13091242f, -0.00047551f, 0.02442497f, -0.09333946f, 0.03499081f, 
    0.01587584f, -0.19992863f, -0.01855748f, -0.09905279f, 0.12467477f, -0.02642006f, 0.18761709f, 0.04358184f, 
    0.01240548f, -0.05099691f, -0.08905202f, 0.20471305f, -0.05241754f, -0.01540115f, 0.02164145f, -0.01121156f, 
    -0.03327964f, -0.36939278f, -0.03171550f, -0.01117410f, -0.20261091f, -0.10957186f, -0.05439733f, 0.00851954f, 
    0.07960421f, 0.07697190f, 0.01539028f, -0.02628963f, 0.00768487f, 0.36462805f, 0.18563633f, 0.14645040f, 
    0.04889426f, 0.02756359f, 0.01991104f, 0.13993250f, 0.13857324f, 0.04428622f, 0.04832461f, -0.03550845f, 
    0.06054748f, -0.10277740f, 0.04058081f, 0.07064962f, 0.20570536f, -0.12469897f, -0.22486711f, 0.01274742f, 
    -0.01615346f, 0.15892926f, -0.00826345f, -0.06463892f, 0.09068281f, 0.27605689f, 0.17467545f, 0.02166475f, 
    0.03229581f, 0.19447146f, 0.26031584f, 0.28646472f, 0.09828708f, -0.08880568f, -0.03348169f, 0.08778109f, 
    0.25387016f, 0.02838031f, -0.13215028f, -0.14425994f, 0.02745739f, -0.02147289f, 0.07031395f, -0.09199510f, 
    0.05189784f, -0.13496783f, 0.02034961f, -0.18325758f, -0.09146167f, 0.01562452f, 0.01299296f, 0.06955478f, 
    -0.07084156f, -0.03984955f, -0.06314698f, -0.16325921f, 0.07685964f, -0.01419412f, -0.16242294f, 0.06712107f, 
    0.17140326f, 0.22770685f, 0.35824963f, -0.29820186f, -0.19830707f, -0.05461301f, -0.28811926f, -0.08492543f, 
    -0.07877041f, -0.14926830f, 0.05681373f, -0.06612348f, 0.00087782f, -0.06946807f, 0.11598102f, -0.06430750f, 
    -0.08787905f, -0.06794183f, 0.01697463f, 0.00536096f, -0.03576262f, 0.00756152f, 0.14445753f, 0.15514839f, 
    -0.24065691f, 0.28924215f, 0.10954133f, 0.14029334f, -0.02058819f, -0.06254201f, 0.10636038f, -0.06708288f, 
    -0.04182936f, -0.06789182f, -0.04789138f, -0.01994949f, 0.30591413f, 0.09821289f, -0.04130765f, 0.18108849f, 
    -0.07002605f, -0.01864895f, 0.04689410f, 0.11550112f, -0.03983390f, 0.12611134f, -0.10682959f, -0.16484158f, 
    -0.23529673f, 0.09678175f, 0.00602218f, 0.11040559f, 0.02609848f, 0.30381280f, 0.01047836f, 0.03339962f, 
    -0.10072888f, 0.04264689f, -0.14277323f, -0.10795779f, 0.04928564f, -0.06928062f, 0.17442197f, 0.08411271f, 
    -0.05724667f, 0.13031638f, -0.00563055f, -0.02364483f, 0.14365512f, 0.02103518f, -0.01950078f, -0.12689182f, 
    -0.17570274f, -0.09690341f, -0.01824616f, 0.18860240f, 0.01904266f, 0.06371927f, -0.13185087f, 0.04008696f, 
    0.12906413f, 0.07543665f, -0.02204219f, 0.02405714f, -0.17790155f, 0.23255098f, -0.08702666f, -0.07648952f, 
    -0.01199825f, -0.10063742f, -0.16677921f, -0.38754708f, -0.04168266f, -0.15066721f, -0.08490539f, -0.06262580f, 
    0.15681094f, 0.00237543f, 0.07797206f, 0.10746253f, -0.07284077f, -0.02811950f, -0.03520907f, 0.19460331f, 
    0.02743006f, 0.04927858f, -0.10601229f, -0.16998187f, 0.06494559f, 0.11161440f, 0.09986360f, 0.12202816f, 
    -0.08796997f, 0.02502775f, 0.05536917f, -0.05861022f, 0.06054891f, -0.10788030f, -0.15192454f, -0.06882220f, 
    -0.06375430f, -0.16635770f, 0.16618538f, 0.14238600f, 0.01549360f, 0.02995512f, -0.04018121f, 0.02292946f, 
    0.02227261f, 0.04727223f, 0.05822455f, 0.06604725f, -0.06105384f, -0.23155996f, -0.12507938f, 0.12448148f, 
    0.16786999f, 0.04503924f, 0.06098511f, 0.04098966f, -0.05264354f, 0.07155412f, -0.01605955f, 0.02947986f, 
    -0.79239982f, 0.05924517f, 0.09282365f, -0.13261972f, -0.10942610f, 0.13763820f, 0.09093085f, -0.00219955f, 
    0.06161208f, 0.03490156f, 0.05686283f, 0.15754476f, 0.09852798f, -0.10100096f, 0.16175608f, 0.15742867f, 
    -0.13890013f, 0.01602969f, 0.06569765f, 0.09763710f, 0.21789031f, 0.01624851f, 0.09104607f, 0.08752812f, 
    0.01985021f, 0.02208794f, 0.29498565f, 0.13341974f, 0.12368742f, 0.00892524f, 0.13463262f, -0.01784013f, 
    -0.01648247f, -0.15927951f, 0.12667862f, -0.06321289f, -0.07855342f, 0.02654979f, -0.50996834f, 0.09064081f, 
    -0.21680734f, -0.02823121f, 0.04346068f, -0.18341878f, -0.26159933f, 0.16116814f, -0.02844171f, 0.03240629f, 
    -0.02892498f, -0.00409885f, -0.29989153f, 0.06507488f, 0.01913902f, -0.01738307f, -0.03257137f, -0.00279897f, 
    0.08033691f, 0.05696516f, -0.09671561f, -0.02422887f, 0.07708257f, 0.18153074f, -0.12216229f, 0.02634955f, 
    -0.02667992f, -0.05073269f, 0.09450539f, 0.00746115f, 0.03466580f, 0.11098641f, -0.06996569f, -0.16056322f, 
    -0.11433706f, 0.07616650f, -0.09817217f, 0.05421537f, 0.09447677f, 0.01455572f, -0.00200198f, -0.18902873f, 
    -0.01234360f, 0.05797162f, -0.04607901f, 0.08397778f, 0.05369755f, 0.15268403f, -0.11564057f, 0.23361063f, 
    -0.02617508f, -0.03344879f, 0.01374529f, 0.08532105f, -0.02667708f, 0.06531977f, -0.07419880f, 0.06734465f, 
    -0.02530127f, -0.03666018f, 0.16068007f, 0.09484350f, 0.03902536f, -0.04647433f, -0.10746054f, 0.04187784f, 
    0.04787102f, 0.08522306f, 0.09404864f, 0.11151008f, -0.12085298f, 0.01971732f, 0.15750466f, 0.17686906f, 
    -0.20362702f, 0.00315102f, 0.02460724f, 0.07368737f, -0.10553544f, -0.10700330f, -0.18918110f, -0.00399696f, 
    -0.10577001f, 0.09273720f, 0.05882116f, 0.29408374f, -0.00686348f, 0.03875997f, -0.03071840f, 0.15824623f, 
    0.03096473f, 0.10514514f, 0.12349056f, 0.01380877f, 0.25949702f, -0.07698532f, -0.06173361f, -0.05211735f, 
    -0.19920620f, 0.08815954f, 0.17731939f, 0.11161271f, 0.12700070f, 0.06573418f, -0.00591185f, 0.04506828f, 
    -0.23234816f, -0.23088886f, -0.08403041f, 0.08074163f, 0.07717956f, 0.01685342f, 0.03189992f, 0.16282226f, 
    -0.05443441f, 0.00065697f, 0.11978292f, -0.02829533f, -0.22029731f, 0.09725914f, 0.25001991f, -0.26685315f, 
    0.00596029f, 0.00280743f, -0.01622195f, -0.07254401f, 0.10683891f, 0.02284327f, 0.02004919f, 0.06287046f, 
    -0.35091722f, 0.60906672f, -0.00660721f, 0.07710171f, 0.17707533f, 0.13459378f, -0.03848502f, 0.00285160f, 
    -0.08950661f, 0.10516490f, 0.03723051f, 0.05032475f, 0.18361099f, -0.20918696f, 0.26426020f, 0.31864378f, 
    -0.02756196f, -0.09182186f, 0.07135160f, -0.07246709f, 0.05646515f, 0.01710177f, -0.08049348f, 0.03548775f, 
    0.24931663f, 0.01167593f, -0.27953586f, -0.16438708f, -0.01687570f, -0.07682338f, 0.02739524f, -0.13637054f, 
    0.01856636f, 0.04887250f, 0.06675509f, 0.02290571f, 0.02255072f, 0.14490220f, 0.28808537f, 0.06118658f, 
    0.01150830f, 0.02661130f, -0.23696189f, 0.03954922f, 0.04849649f, -0.14116091f, -0.07245609f, -0.03306204f, 
    0.31858772f, 0.03512650f, 0.01021351f, 0.21029149f, -0.10549407f, -0.08165072f, 0.05277101f, 0.07708656f, 
    0.12693632f, 0.05470997f, -0.04389306f, 0.15667807f, 0.24694680f, -0.06267985f, -0.08941122f, -0.02252005f, 
    -0.08009385f, 0.06427001f, -0.05528042f, -0.05248696f, 0.07894095f, -0.08084496f, 0.02269244f, -0.05082240f, 
    -0.23406495f, 0.05482522f, -0.03042106f, 0.25885773f, 0.15005973f, -0.08365983f, -0.04367191f, -0.14851081f, 
    0.02681450f, 0.18383035f, 0.19078551f, 0.02045636f, -0.26296324f, -0.24182531f, -0.29184794f, 0.23931149f, 
    0.04761230f, -0.00822232f, 0.05250660f, -0.17246746f, -0.02587557f, -0.20264372f, -0.17851007f, -0.21560256f, 
    -0.09139071f, 0.29439571f, 0.01645995f, -0.12433124f, 0.30558991f, -0.06958727f, -0.00542380f, -0.37385848f, 
    -0.25338697f, -0.05633597f, 0.07498879f, -0.05623694f, 0.31830493f, 0.06453304f, -0.09226497f, 0.20472838f, 
    0.05244998f, 0.05498160f, -0.03144085f, -0.23731303f, 0.13762781f, -0.10198031f, -0.09369150f, 0.14209621f, 
    0.12014389f, 0.06454958f, -0.06662901f, 0.03824715f, 0.06226743f, 0.15736160f, 0.08121496f, -0.01391004f, 
    -0.05454975f, 0.03650142f, 0.06996369f, 0.10114222f, 0.12871186f, -0.05055202f, -0.01335381f, -0.18592735f, 
    -0.01783131f, -0.06284881f, 0.14306696f, 0.08647725f, -0.01384963f, -0.10594239f, -0.11197479f, -0.21451360f, 
    0.37392405f, 0.09296810f, -0.03105532f, 0.11875027f, -0.01216419f, 0.07137316f, 0.02264138f, 0.10742357f, 
    -0.10240229f, 0.08388745f, 0.09438344f, 0.05505284f, -0.18450186f, -0.02814450f, 0.20270711f, 0.09582436f, 
    -0.17914525f, 0.05662678f, 0.22551322f, 0.16885440f, 0.22527197f, 0.10245921f, 0.05050816f, 0.24230778f, 
    0.03047758f, -0.01882018f, -0.11734120f, 0.31637245f, 0.16244052f, 0.04651197f, -0.22562169f, -0.00451618f, 
    -0.05654005f, 0.07946344f, 0.01459109f, 0.16536233f, 0.17896049f, 0.15464702f, -0.18958797f, 0.06042702f, 
    0.13002169f, 0.05950920f, 0.00816151f, -0.14505769f, 0.07684655f, 0.02443968f, -0.05052709f, 0.07052726f, 
    0.40003008f, 0.18301453f, -0.38458127f, -0.08790247f, 0.24397829f, 0.07570297f, -0.05625805f, -0.14978908f, 
    -0.08433353f, 0.11002598f, 0.03460448f, -0.06957325f, 0.39657199f, 0.29166991f, -0.15766242f, -0.10043716f, 
    0.02957868f, 0.05361157f, 0.11854319f, 0.15832581f, -0.11725575f, -0.13400875f, -0.04455880f, 0.03178927f, 
    -0.32712713f, 0.25383839f, 0.12161646f, -0.14942843f, -0.38513455f, 0.34611279f, -0.00807380f, -0.33007249f, 
    0.04441701f, -0.09085649f, -0.05350138f, -0.01501600f, 0.18265265f, -0.08401783f, -0.33463517f, -0.00563230f, 
    0.15993646f, 0.01779007f, -0.09249041f, 0.05026468f, -0.20535393f, -0.15036148f, -0.15300170f, -0.17513992f, 
    -0.33033064f, 0.08545148f, -0.21558869f, 0.22950119f, -0.16972215f, 0.02801533f, 0.02981215f, -0.02922076f, 
    -0.07483730f, -0.01544359f, 0.11593454f, 0.29496619f, -0.18406110f, -0.07005140f, 0.03656802f, 0.06739060f, 
    -0.01151537f, 0.07581950f, -0.24218321f, -0.20089811f, -0.25401318f, -0.21473409f, -0.05097520f, -0.16654079f, 
    -0.06319905f, -0.07916447f, 0.05310424f, 0.23283736f, -0.02456446f, 0.03717246f, -0.15461509f, -0.04388407f, 
    0.10643117f, 0.15178442f, 0.11078244f, 0.14850844f, -0.06122060f, 0.17589864f, -0.19837451f, -0.08953900f, 
    -0.02231473f, -0.03632720f, -0.06670570f, -0.07136485f, -0.17545858f, 0.10501500f, -0.13072245f, -0.33799458f, 
    0.17249550f, -0.11639399f, 0.12626877f, -0.34648293f, 0.00946096f, -0.02934467f, -0.07519209f, -0.00994018f, 
    0.06379770f, 0.05897288f, 0.00213756f, 0.05482908f, -0.23953488f, -0.08946018f, 0.06489168f, 0.16349019f, 
    -0.04837926f, -0.06378276f, -0.05024483f, 0.08882326f, -0.04108736f, -0.02997783f, 0.01537823f, 0.10503253f, 
    -0.00606121f, -0.00468132f, -0.14157538f, 0.04750814f, 0.05026226f, -0.05997178f, 0.05588725f, 0.09996076f, 
    0.12741198f, 0.01234051f, 0.09296764f, 0.03051978f, 0.02690941f, 0.02709443f, 0.09801597f, 0.00648482f, 
    0.02334440f, 0.02332965f, 0.05285663f, 0.13457762f, -0.11924203f, 0.03283914f, -0.06916593f, 0.02904487f, 
    -0.12377981f, 0.07958757f, -0.07707091f, 0.28962305f, -0.00693030f, -0.09702203f, 0.06859615f, 0.13341761f, 
    0.03297871f, 0.10389646f, 0.01125694f, 0.04231788f, 0.08134697f, -0.11707830f, 0.07209676f, -0.03172829f, 
    0.01547782f, 0.27417588f, 0.08751151f, 0.15777507f, 0.23279972f, 0.25377071f, 0.02233738f, 0.13976340f, 
    -0.31400836f, -0.07773024f, 0.02052640f, 0.19764666f, -0.03001994f, 0.08839066f, 0.23285449f, 0.00627233f, 
    -0.12644082f, 0.09256054f, 0.02889231f, 0.02209549f, -0.21594040f, -0.14285666f, 0.02592587f, -0.06832393f, 
    -0.02108453f, 0.13074283f, 0.06748449f, 0.02379171f, 0.05929970f, -0.09941673f, -0.05398000f, 0.12012915f, 
    -0.06912576f, 0.65016103f, 0.03782869f, -0.21677679f, 0.03170864f, 0.06209359f, 0.12282640f, -0.00941218f, 
    0.18979284f, 0.02944373f, -0.01943769f, -0.07126695f, -0.04832365f, -0.25293127f, 0.08181884f, 0.22803660f, 
    -0.10583939f, 0.13235348f, 0.03534990f, 0.03841633f, -0.02735020f, -0.05247734f, -0.14754990f, -0.07885659f, 
    0.07285363f, 0.01300025f, -0.20106749f, 0.04096020f, 0.00732275f, 0.08845605f, -0.03101638f, -0.03959506f, 
    -0.04339248f, -0.04152641f, 0.18936211f, -0.00699181f, -0.22566494f, -0.13159505f, 0.08246718f, 0.00395959f, 
    0.10751574f, 0.00539213f, -0.00262326f, -0.02913911f, -0.09468509f, -0.25720140f, -0.11652367f, -0.12286122f, 
    -0.04545785f, 0.00993385f, 0.27361271f, 0.12632589f, -0.01295484f, -0.11145706f, 0.02738721f, 0.02406912f, 
    -0.01041846f, 0.09342837f, 0.14062002f, 0.16631907f, 0.00951578f, -0.16395865f, 0.00345166f, -0.15633786f, 
    -0.00706556f, 0.13982621f, -0.19323865f, 0.12181480f, -0.04022057f, -0.12717016f, -0.04957926f, -0.18083265f, 
    0.04537512f, 0.02886704f, -0.03035863f, -0.03639033f, 0.02947556f, 0.00195945f, 0.03009391f, -0.03669955f, 
    -0.01401698f, -0.00587039f, -0.03272688f, -0.02235333f, -0.04995273f, -0.01169514f, 0.02599185f, -0.05756430f, 
    -0.00739021f, 0.04641268f, 0.01777406f, -0.01322102f, 0.00280616f, 0.06003232f, -0.06602705f, 0.06200216f, 
    0.04766975f, 0.03316738f, -0.06875496f, -0.01402556f, 0.03323198f, 0.05358147f, -0.05294817f, -0.05123800f, 
    -0.06949314f, -0.02191306f, 0.05765802f, -0.02226969f, 0.01264401f, -0.01203095f, -0.03875878f, -0.01047157f, 
    -0.04338375f, -0.00341461f, -0.00025949f, -0.03113261f, -0.07632230f, -0.03950905f, -0.00058527f, 0.05295505f, 
    -0.06523725f, -0.03363258f, -0.00093915f, -0.06934029f, -0.06708857f, 0.05351849f, -0.06523405f, -0.03312322f, 
    0.00169254f, 0.04769400f, 0.03260412f, -0.06170083f, 0.00696456f, -0.02892992f, -0.00542403f, -0.05249102f, 
    0.03756977f, -0.01073167f, -0.04978716f, 0.01773320f, 0.06220011f, 0.02288890f, -0.02685765f, 0.01838347f, 
    -0.06386514f, -0.06815214f, -0.03913595f, -0.06828815f, 0.00080160f, -0.06238255f, 0.01611517f, -0.06460647f, 
    0.05258342f, -0.05784782f, 0.06355295f, -0.04935017f, 0.02388244f, -0.04182026f, -0.05744012f, -0.02637189f, 
    -0.03774523f, -0.06938279f, -0.06910554f, -0.00105833f, -0.05246319f, -0.00457053f, -0.01734545f, -0.01937512f, 
    -0.00792140f, -0.06878382f, -0.02523916f, 0.06005416f, -0.06408613f, 0.04985184f, 0.02366976f, 0.02454009f, 
    0.01896640f, 0.00076455f, 0.01161547f, -0.03096837f, 0.04589050f, 0.05056348f, -0.03174198f, -0.00537279f, 
    0.06266936f, -0.00221416f, -0.06767963f, 0.06445147f, -0.00040317f, 0.05294660f, 0.01919599f, 0.06500798f, 
    -0.00323549f, -0.06173269f, -0.00222124f, -0.03067142f, 0.00155688f, -0.06837440f, 0.00848787f, -0.05743250f, 
    -0.02767392f, -0.00711001f, 0.03117493f, -0.03409999f, 0.04264228f, -0.00436501f, 0.00999747f, -0.07201414f, 
    0.01059992f, -0.05383844f, -0.06041308f, -0.01576426f, -0.03587361f, 0.01566499f, -0.06777038f, 0.06450108f, 
    0.06380340f, -0.00069803f, 0.03459209f, 0.06374643f, 0.01094503f, -0.06158831f, 0.01582309f, -0.03946390f, 
    -0.02535579f, 0.04076213f, -0.02339715f, -0.06871128f, 0.00889736f, 0.01620277f, 0.00000683f, -0.03895142f, 
    0.04597972f, -0.07504047f, 0.05167866f, 0.00327915f, 0.04565012f, 0.06111056f, -0.02199248f, 0.00207945f, 
    -0.03201966f, -0.03832045f, -0.02087935f, -0.02811986f, -0.02271342f, 0.03874444f, 0.00449620f, -0.05491098f, 
    0.00709214f, -0.00358844f, 0.01634037f, 0.06142478f, -0.02897472f, 0.00567317f, -0.00751029f, -0.05509700f, 
    -0.03661460f, -0.06356988f, -0.07164218f, 0.06204142f, 0.00890261f, -0.04788268f, -0.04576126f, -0.03900493f, 
    -0.02967107f, 0.06128661f, -0.07004127f, -0.07028121f, -0.02667252f, 0.02992154f, -0.01729551f, -0.06878278f, 
    -0.06611453f, -0.05281581f, 0.01595312f, 0.03406856f, 0.04376535f, 0.00109314f, -0.05877258f, 0.06548955f, 
    0.05873045f, -0.05844161f, -0.05433841f, -0.04683542f, -0.04638107f, -0.00762041f, 0.00338010f, -0.03359164f, 
    -0.01027943f, 0.02466292f, 0.02654716f, 0.03709610f, -0.03484443f, 0.05101002f, -0.03376336f, 0.00077034f, 
    -0.02933379f, -0.00239040f, 0.05467210f, -0.04417102f, 0.05926120f, 0.06243075f, -0.07226731f, -0.01708891f, 
    0.02428525f, -0.06715215f, -0.01823629f, -0.04942043f, 0.05717570f, 0.02641874f, -0.02069538f, 0.00154622f, 
    0.03190590f, -0.05224742f, 0.04561607f, 0.06470489f, 0.00201814f, 0.02297930f, -0.00608525f, -0.07000468f, 
    0.01861035f, -0.04921775f, -0.05231823f, -0.00716728f, 0.04128575f, -0.00537265f, -0.01259978f, -0.04951242f, 
    -0.01005071f, -0.05075321f, -0.01679255f, -0.02714418f, 0.04880480f, 0.04163324f, 0.00487159f, -0.03814565f, 
    0.01814891f, -0.01660259f, 0.00962359f, -0.03701441f, -0.06424849f, 0.07139945f, -0.03256989f, 0.06638055f, 
    0.00001923f, -0.06311819f, 0.01508270f, 0.00688304f, 0.02013194f, -0.05354114f, 0.00564501f, -0.05736734f, 
    0.04710605f, 0.01402907f, 0.05501982f, 0.04858707f, -0.07499905f, -0.06719889f, -0.06419180f, -0.01257090f, 
    0.03112545f, 0.04308198f, 0.06617140f, -0.07179069f, -0.07137253f, -0.07688282f, 0.06243407f, 0.04077040f, 
    -0.01501639f, -0.01709114f, -0.07308499f, -0.00223596f, 0.01183741f, -0.03254849f, -0.02276649f, 0.04124838f, 
    -0.01207820f, -0.07017216f, 0.02906015f, -0.02600407f, -0.07035378f, -0.05268647f, 0.05964421f, -0.05078502f, 
    0.04781470f, -0.06153687f, 0.04253017f, -0.00221503f, -0.06160446f, 0.04884703f, 0.04059679f, 0.00755485f, 
    -0.00763674f, -0.05866706f, -0.07566831f, -0.06103060f, -0.05522613f, -0.03730562f, -0.01134541f, 0.05402343f, 
    -0.05206081f, -0.00446528f, -0.04526067f, -0.04475734f, -0.02782203f, -0.03298573f, 0.03654991f, 0.02894418f, 
    0.03814783f, -0.00748457f, -0.00518979f, 0.06141359f, 0.03430584f, -0.05312916f, -0.03423052f, 0.04205596f, 
    -0.01249838f, 0.00510995f, -0.01174353f, -0.02337400f, -0.01411861f, 0.06511641f, 0.02558119f, 0.04287801f, 
    0.04668881f, 0.04409400f, -0.02789277f, -0.02314017f, -0.07754581f, -0.01511087f, 0.04531480f, -0.05469646f, 
    0.02036291f, -0.04680911f, 0.04105545f, 0.04302064f, 0.02189144f, -0.07769693f, 0.02927006f, -0.06142335f, 
    0.03482161f, -0.06807099f, -0.03688283f, 0.05499743f, -0.03131658f, -0.07195381f, -0.03513777f, -0.05189480f, 
    -0.06069598f, -0.01762284f, -0.06632768f, -0.00093920f, -0.01185421f, -0.02551578f, -0.03268454f, -0.04970062f, 
    0.05867539f, 0.01568108f, 0.02716978f, -0.06907552f, -0.07055307f, -0.15666154f, -0.05424199f, -0.05583736f, 
    0.10468352f, 0.06299254f, 0.06884504f, 0.19862121f, 0.11914755f, -0.08209128f, 0.05730343f, -0.17124498f, 
    -0.13010401f, -0.04417990f, -0.06144067f, 0.10188882f, 0.10168212f, -0.01573437f, -0.05738745f, 0.03417558f, 
    -0.29888400f, -0.04490708f, -0.01035855f, 0.39304620f, 0.01362467f, 0.00019613f, -0.11499032f, -0.06536111f, 
    0.19941683f, 0.07675602f, 0.01859039f, 0.13713664f, 0.03411204f, 0.16939215f, 0.14546128f, -0.26226088f, 
    -0.14131930f, -0.02400588f, 0.07676974f, -0.00309386f, 0.00162316f, -0.04648457f, 0.01274471f, 0.00416690f, 
    0.01240022f, 0.02404449f, 0.31284568f, -0.04149492f, 0.12188242f, 0.02085094f, 0.01879973f, 0.08728253f, 
    0.02609087f, 0.07336623f, -0.06159704f, 0.00030655f, -0.04414573f, -0.06573725f, -0.13457522f, -0.00793615f, 
    0.07155765f, 0.04322351f, 0.14577453f, 0.01547105f, 0.03359424f, 0.06103510f, 0.01465587f, 0.02719698f, 
    -0.01421820f, -0.08167706f, 0.08717342f, -0.12613009f, 0.14407250f, 0.02955507f, -0.06818150f, -0.06396881f, 
    -0.12957582f, -0.07389825f, -0.01970850f, 0.05221098f, -0.04433823f, -0.16384397f, -0.27384713f, -0.02310987f, 
    -0.02729473f, -0.07415678f, -0.05358779f, 0.05492156f, -0.09996819f, -0.03176963f, 0.01579206f, -0.01521433f, 
    0.39655241f, 0.24369690f, 0.29120317f, -0.17125198f, 0.01835665f, 0.03946208f, -0.06397869f, 0.10832560f, 
    -0.01252083f, 0.02943686f, 0.10428214f, -0.04949317f, 0.10767140f, 0.18801372f, 0.31682017f, -0.19763014f, 
    0.07707737f, -0.02930387f, -0.07072009f, 0.12930742f, -0.06021478f, 0.01734709f, 0.09548174f, 0.09634088f, 
    -0.04558128f, -0.31468913f, 0.14394259f, 0.18216398f, 0.10694794f, 0.03721837f, -0.07112024f, 0.00342828f, 
    0.02007025f, -0.07628791f, 0.03531156f, 0.21937865f, -0.13327149f, 0.07404459f, -0.07963201f, -0.15157874f, 
    -0.08436103f, 0.03524478f, 0.09742140f, 0.06149283f, 0.00100189f, -0.00744587f, 0.03076940f, -0.04913893f, 
    -0.15990552f, 0.14841411f, -0.18932316f, -0.08693524f, 0.12281094f, -0.14943017f, -0.10539319f, -0.11693371f, 
    0.10154333f, 0.21884769f, 0.00398510f, 0.08474003f, -0.06271670f, 0.08589340f, -0.07970288f, -0.23434760f, 
    -0.06381483f, 0.06834717f, 0.07052454f, 0.02535100f, -0.03578975f, 0.03492396f, -0.08254289f, 0.01599788f, 
    0.36771765f, 0.07813282f, -0.18191513f, -0.28009424f, -0.01995608f, 0.05695362f, -0.05362504f, -0.03943600f, 
    0.06849831f, -0.08935300f, 0.04363257f, -0.01657570f, -0.05864876f, -0.03248660f, -0.35059136f, 0.14220482f, 
    -0.02837135f, -0.04751672f, 0.11611261f, -0.03092906f, 0.11476865f, 0.17316175f, -0.04280272f, -0.00309068f, 
    -0.07224733f, -0.03043628f, -0.02906370f, -0.05152270f, -0.05875000f, 0.05362019f, -0.07177271f, -0.04552873f, 
    -0.01909816f, -0.00054570f, 0.00567237f, -0.04423648f, 0.01838925f, -0.05742680f, 0.01131449f, -0.01344827f, 
    0.00241228f, 0.00179650f, -0.03880373f, 0.03010627f, -0.04516402f, 0.03760022f, -0.01106383f, -0.04272776f, 
    -0.07175417f, 0.00629758f, -0.03047523f, -0.00074839f, 0.02456851f, 0.06558799f, -0.05329698f, -0.02468520f, 
    0.06814348f, -0.06436615f, -0.07473017f, -0.07462762f, 0.02066518f, -0.05221513f, 0.05649792f, 0.00108157f, 
    -0.00981716f, 0.01860048f, -0.00115943f, -0.06254204f, -0.01616660f, -0.01590922f, 0.04155539f, -0.05145668f, 
    -0.03003386f, -0.04990259f, -0.01331107f, 0.01525216f, -0.06896422f, 0.00308772f, -0.02606036f, -0.05237149f, 
    -0.01409032f, 0.04148124f, 0.04436408f, 0.06302269f, -0.04983909f, -0.07870300f, 0.00977322f, -0.02616034f, 
    0.01794153f, 0.03684699f, -0.07257076f, 0.01810658f, 0.01163625f, 0.03406373f, -0.01384607f, -0.07150803f, 
    0.03330413f, -0.06108599f, 0.05304015f, 0.02127638f, -0.07572997f, 0.03736971f, 0.02364046f, -0.03296442f, 
    -0.01371401f, 0.03987505f, -0.07585897f, 0.02475618f, 0.00874247f, -0.07366464f, -0.03883634f, 0.03615041f, 
    0.05358504f, 0.02192951f, -0.01579398f, 0.00259534f, 0.02551118f, 0.05225471f, 0.04493148f, 0.05312785f, 
    -0.00362612f, 0.01004412f, -0.04467658f, 0.03330280f, -0.01190897f, -0.07574078f, -0.02172584f, -0.07906392f, 
    -0.05243137f, -0.05527994f, -0.01976816f, -0.01807611f, -0.05613884f, -0.05589276f, 0.01273945f, -0.05785641f, 
    -0.02107295f, 0.01479997f, 0.01865738f, 0.04415932f, -0.06821260f, -0.04161190f, -0.03555114f, -0.04377143f, 
    -0.02303087f, -0.00894768f, -0.02024738f, 0.01230676f, -0.04783389f, -0.00046450f, 0.02753163f, -0.06714168f, 
    -0.03032580f, 0.00748276f, 0.05928718f, 0.02710922f, -0.00789657f, -0.01205284f, -0.01414858f, 0.04334669f, 
    -0.06600790f, 0.04760535f, 0.04557244f, 0.04467738f, 0.04806171f, 0.03703230f, -0.04361227f, 0.01267648f, 
    -0.04604301f, 0.04322467f, -0.03837829f, -0.00022546f, -0.04831327f, -0.07303795f, -0.07639152f, 0.06907073f, 
    -0.00609814f, -0.02141068f, 0.05952584f, -0.05425543f, 0.00761576f, 0.03789505f, 0.02517483f, 0.03086411f, 
    -0.06665864f, 0.00012987f, -0.06943709f, 0.03881630f, 0.02264571f, -0.03559796f, 0.03067308f, -0.00822063f, 
    0.03618886f, -0.06482300f, 0.03164029f, 0.05631828f, 0.04066077f, 0.05854784f, 0.02846072f, 0.03401168f, 
    -0.06580651f, -0.04514053f, 0.03271630f, 0.03638998f, -0.05895792f, -0.04323804f, 0.02685655f, 0.03847155f, 
    -0.05608547f, -0.03960164f, -0.02878129f, 0.02138314f, -0.06185143f, -0.00844867f, 0.05928358f, 0.00600299f, 
    0.07375990f, 0.09929067f, 0.18875435f, 0.07898898f, -0.03769922f, -0.06277633f, -0.07910895f, 0.03985118f, 
    0.09297217f, -0.10090008f, 0.00185751f, -0.09700239f, 0.09759115f, 0.08946615f, 0.00845663f, 0.06331785f, 
    -0.05130852f, 0.04442112f, -0.05114605f, -0.04680022f, -0.07497100f, -0.04684298f, 0.14191701f, -0.04228652f, 
    0.14361830f, 0.08547917f, 0.12923162f, 0.02031148f, 0.01716010f, -0.15199062f, -0.04075900f, -0.09080922f, 
    -0.12583922f, -0.02491833f, -0.10210635f, 0.02010544f, 0.28579918f, 0.06743146f, 0.19065714f, 0.22889064f, 
    0.06242331f, -0.05579630f, -0.00408765f, 0.20577233f, 0.17661455f, 0.09478257f, 0.06243897f, -0.04459520f, 
    -0.34153572f, 0.11900303f, -0.07517690f, 0.01964734f, -0.09251846f, 0.05015875f, -0.14518176f, -0.00775882f, 
    -0.06004337f, 0.01420008f, -0.05133709f, 0.05230198f, -0.25603005f, 0.00934529f, 0.10441718f, 0.00283353f, 
    -0.04701227f, -0.04156983f, -0.03629130f, 0.19252202f, 0.01982328f, 0.00137206f, -0.03772034f, -0.12949720f, 
    -0.16933061f, -0.02075077f, 0.07815898f, 0.08899730f, 0.04092977f, -0.03197709f, -0.01710776f, 0.01846254f, 
    0.03608447f, -0.03213188f, 0.11088569f, 0.23616691f, 0.15029782f, -0.08669150f, -0.08603000f, 0.10811093f, 
    0.00568236f, 0.03832128f, 0.03855668f, -0.04993571f, 0.10768948f, 0.05983554f, 0.14344539f, 0.16909489f, 
    -0.22231220f, 0.26109213f, 0.36899349f, 0.15290868f, 0.06706005f, -0.08188821f, -0.02039882f, -0.16376239f, 
    0.09756707f, 0.03784700f, -0.09315883f, 0.04080144f, -0.09699649f, 0.03878918f, 0.14104615f, 0.23000707f, 
    -0.07918012f, -0.02044328f, 0.07361107f, -0.11870579f, -0.00233400f, 0.03946307f, -0.10150190f, 0.00956973f, 
    0.04684803f, 0.07312284f, 0.41213074f, 0.10621267f, 0.00774052f, -0.00565945f, -0.18311664f, -0.01300524f, 
    -0.05901222f, 0.02626400f, 0.01746568f, 0.11180884f, -0.09233227f, -0.17396635f, 0.09477296f, 0.18559724f, 
    0.10164759f, -0.06840084f, -0.08631557f, -0.05659581f, -0.06231982f, 0.03073503f, -0.08509017f, 0.12329678f, 
    -0.26312518f, -0.08664214f, -0.24729632f, 0.13226967f, -0.18149717f, -0.06452005f, 0.07645749f, -0.01408082f, 
    0.04033971f, -0.08130509f, 0.03271310f, -0.19376880f, 0.21330969f, 0.05958968f, 0.21411347f, 0.15380500f, 
    -0.04229261f, 0.02172171f, 0.02524107f, 0.14415218f, 0.18096332f, -0.05706164f, 0.10134649f, 0.07710472f, 
    -0.12801054f, -0.07909148f, 0.11565210f, -0.13916911f, -0.10048889f, -0.03587652f, -0.06298458f, -0.21435933f, 
    0.04934753f, -0.09987796f, 0.08296084f, -0.00963942f, -0.05732285f, -0.18902652f, -0.22123004f, 0.00036860f, 
    -0.06448397f, 0.08467012f, -0.04978487f, 0.07276411f, 0.12215912f, 0.05555487f, -0.03041051f, -0.08292723f, 
    0.09339738f, 0.01222531f, 0.16892929f, 0.05638146f, -0.13628462f, -0.07163815f, 0.02800709f, -0.00433894f, 
    0.12217809f, 0.01851721f, 0.03896178f, 0.12502936f, 0.12946446f, 0.06039189f, -0.03175024f, -0.15668060f, 
    -0.07691347f, -0.22919030f, -0.01512726f, 0.03688730f, 0.14457911f, 0.08206224f, -0.01296593f, 0.06967562f, 
    -0.37287331f, -0.17217144f, 0.17214799f, 0.25062436f, -0.07768697f, -0.04441506f, -0.06532796f, 0.00214557f, 
    0.06956252f, 0.10714184f, 0.15299033f, 0.21119019f, -0.16120292f, 0.13857283f, 0.12328124f, -0.11533913f, 
    -0.10525155f, -0.05957371f, -0.00511967f, 0.02525987f, -0.09264054f, 0.11814650f, 0.12757118f, -0.02173199f, 
    -0.11591436f, -0.04693295f, 0.12752877f, 0.04511116f, -0.10647620f, -0.08327042f, 0.09864498f, 0.02080874f, 
    0.00104222f, 0.13627774f, 0.06125583f, -0.00999147f, -0.05273647f, -0.01623274f, 0.04587873f, 0.02727270f, 
    0.02914269f, 0.05502557f, 0.22736292f, 0.01202159f, 0.01399806f, 0.03443054f, 0.12720253f, 0.12310866f, 
    -0.22840276f, -0.18066640f, -0.00938049f, -0.12136109f, 0.11406899f, 0.10662597f, 0.17445663f, -0.08387595f, 
    0.07009956f, -0.04069288f, 0.00591611f, -0.09044895f, 0.10285214f, -0.15938623f, -0.30418140f, -0.06695426f, 
    -0.05430137f, 0.02136210f, -0.04447887f, 0.06465799f, 0.04551988f, 0.04941509f, 0.07195068f, -0.08998163f, 
    -0.03931329f, 0.01362339f, 0.21513110f, -0.11134318f, -0.05902342f, 0.03930724f, 0.01966676f, 0.01735313f, 
    0.06861555f, -0.06824633f, 0.13459605f, -0.15596959f, -0.11337800f, 0.03116834f, 0.23896159f, -0.25574216f, 
    -0.05278781f, 0.20729321f, 0.03190374f, -0.02666637f, -0.05492147f, 0.12449675f, 0.03732633f, -0.01370750f, 
    -0.22665441f, -0.10311526f, 0.24500693f, 0.10481843f, -0.05774029f, -0.09089422f, -0.02304534f, 0.07637031f, 
    0.16971764f, 0.05504135f, 0.11441840f, 0.08172607f, -0.21696509f, -0.20034492f, 0.12502964f, 0.01861759f, 
    0.07522476f, 0.07029117f, 0.09710964f, -0.12544742f, 0.05375239f, 0.02355896f, 0.06204056f, 0.12877408f, 
    -0.07032205f, 0.03131688f, -0.28690547f, -0.09812264f, 0.05716279f, -0.17665082f, 0.02975755f, 0.03845403f, 
    0.13972159f, 0.05266728f, 0.04075348f, 0.13024010f, -0.24124679f, -0.00178076f, 0.23501617f, -0.20177194f, 
    0.06605668f, 0.10075733f, 0.00826494f, -0.03939196f, 0.07032484f, 0.10276221f, -0.04473223f, 0.10315953f, 
    0.35832399f, 0.11823892f, -0.03067728f, -0.25350952f, -0.00478348f, 0.10123137f, 0.01081793f, -0.00876174f, 
    0.06126123f, -0.11069238f, -0.01134286f, -0.09357125f, -0.06265920f, -0.16226290f, -0.38205507f, 0.02982693f, 
    -0.03161978f, 0.05931417f, -0.02775144f, 0.00773580f, 0.04450417f, 0.02368382f, -0.09427226f, -0.07953402f, 
    0.09393138f, 0.14500393f, -0.01664980f, -0.34429497f, -0.08221687f, -0.02103241f, -0.07595136f, 0.01580346f, 
    -0.09620978f, -0.19193235f, -0.12073993f, -0.09299079f, 0.11373796f, -0.06122604f, 0.13922487f, -0.01523979f, 
    -0.10939067f, 0.13487363f, 0.02249663f, 0.02406575f, -0.02381921f, 0.01497017f, 0.09783888f, -0.00022630f, 
    -0.02212110f, 0.22521250f, -0.14125350f, 0.21312615f, -0.04315087f, 0.02579936f, 0.03398333f, -0.01419889f, 
    -0.03326555f, -0.02883057f, -0.05435627f, -0.02145350f, -0.07916962f, -0.04788734f, 0.04400870f, 0.14666288f, 
    0.05138132f, 0.07713870f, 0.02065245f, 0.16834369f, -0.11164209f, -0.01387796f, 0.01765677f, -0.11109055f, 
    -0.15222226f, -0.01587142f, 0.01429539f, -0.01667374f, -0.03017016f, 0.21675994f, 0.06233455f, 0.12040696f, 
    -0.02051060f, -0.02576326f, -0.05125534f, -0.05868707f, 0.08720735f, 0.08636591f, 0.08665463f, -0.07749486f, 
    -0.09465425f, 0.04471939f, -0.00860355f, -0.19919696f, 0.22824946f, -0.04835764f, -0.00002282f, -0.01827466f, 
    -0.12750892f, 0.04684447f, -0.21645905f, -0.06663147f, -0.02209671f, -0.02519888f, -0.00317636f, 0.04174443f, 
    -0.06318984f, -0.05826532f, 0.10785656f, 0.10838562f, -0.08201984f, 0.15036787f, 0.12512130f, 0.01358191f, 
    0.01717554f, -0.01342564f, 0.07155115f, -0.10999373f, -0.06580112f, 0.05100362f, -0.06391075f, -0.05918020f, 
    0.51444739f, 0.14493343f, -0.02458377f, -0.05307358f, 0.02367909f, -0.04095636f, 0.03711992f, 0.13947329f, 
    0.03641355f, -0.01820545f, -0.16129075f, 0.01529011f, 0.19858749f, 0.01808007f, -0.12273365f, 0.35612866f, 
    0.03879717f, -0.03685295f, -0.11319821f, -0.03143817f, 0.04903499f, -0.11287521f, 0.05247519f, -0.05702575f, 
    0.01487267f, -0.37685773f, -0.12909089f, 0.03413339f, -0.04961411f, 0.04947813f, 0.09963890f, -0.07438385f, 
    -0.04979662f, -0.03927794f, 0.03760455f, 0.01167414f, 0.02330820f, 0.09064201f, -0.14293548f, -0.20523703f, 
    -0.09559578f, -0.05130878f, -0.06114386f, 0.12885374f, -0.12796590f, 0.07371649f, 0.02351524f, -0.05260377f, 
    -0.25092474f, -0.21277614f, 0.29387942f, 0.04794363f, 0.03123598f, 0.11532051f, -0.02539209f, 0.04681457f, 
    0.05028226f, 0.18272755f, 0.03708143f, -0.03579481f, 0.20094989f, -0.02058903f, -0.00155008f, 0.22267246f, 
    -0.13986857f, -0.00362724f, 0.23375167f, 0.16726296f, -0.01530412f, -0.08735402f, 0.12618406f, 0.04338762f, 
    0.03649039f, 0.06122293f, -0.09595095f, 0.09363767f, -0.03579628f, -0.11503732f, 0.00747235f, 0.06977613f, 
    -0.03407520f, 0.04565323f, 0.04481808f, 0.04121402f, 0.24069214f, 0.24903215f, 0.17153515f, 0.03805423f, 
    -0.07235615f, -0.15782467f, -0.01422062f, 0.02641074f, 0.00756451f, -0.00748142f, 0.06589594f, 0.00113388f, 
    0.10943662f, 0.35713360f, 0.29025343f, -0.04359204f, 0.01207393f, -0.05248939f, -0.08875130f, 0.03398062f, 
    -0.04961347f, -0.02387524f, -0.03259283f, -0.02906989f, 0.03023870f, -0.07974842f, 0.13498226f, -0.07087276f, 
    -0.05704862f, -0.06324304f, 0.11571622f, 0.12770125f, -0.02971384f, 0.04474384f, 0.15715173f, 0.08999962f, 
    -0.25073859f, 0.23400004f, -0.00255189f, 0.25856072f, -0.07933574f, -0.07965980f, 0.11623150f, -0.05185591f, 
    0.01906682f, -0.05608174f, -0.03787666f, 0.07855652f, -0.03310533f, 0.01459548f, 0.09585003f, 0.13767695f, 
    0.02046549f, -0.11718178f, -0.04076060f, 0.09380201f, -0.17627370f, 0.13075571f, 0.12594546f, -0.06245769f, 
    -0.30131808f, 0.13108072f, -0.20836739f, 0.13996951f, -0.05684902f, 0.23746201f, 0.00325391f, -0.01443969f, 
    0.01890801f, 0.06473891f, -0.01932642f, -0.07849829f, -0.19648431f, 0.03451452f, 0.12971336f, 0.07145163f, 
    -0.08800111f, 0.15002516f, 0.21975736f, -0.05455711f, 0.14157040f, -0.05872267f, 0.11628297f, -0.04278436f, 
    -0.40058774f, -0.10972904f, -0.53466374f, 0.19972655f, 0.08756532f, 0.14848201f, 0.02906620f, 0.08285859f, 
    -0.03773899f, 0.06759876f, 0.07082102f, -0.00780744f, -0.04376296f, 0.01734265f, -0.12141153f, -0.05023001f, 
    -0.09675352f, -0.06995219f, 0.06544190f, -0.14172699f, -0.05156262f, 0.03147767f, -0.04961216f, -0.02338114f, 
    0.18855467f, 0.32063526f, 0.39263764f, 0.21531837f, 0.04395549f, 0.12845182f, 0.09938181f, 0.06564304f, 
    0.03619451f, -0.01204094f, -0.09224216f, 0.01527600f, 0.02616335f, 0.05543579f, -0.13228364f, 0.21914795f, 
    0.05321141f, -0.05462982f, 0.11551258f, -0.13026859f, 0.10305805f, -0.01436905f, -0.00170241f, 0.12937555f, 
    -0.18535335f, 0.20095584f, 0.34341270f, 0.14038189f, -0.04871548f, 0.04154251f, -0.13337056f, -0.02025175f, 
    0.02130000f, 0.02059124f, 0.06420484f, 0.08028666f, -0.16237342f, -0.53965741f, -0.17982537f, 0.01725199f, 
    0.10521296f, -0.03255970f, -0.11560370f, -0.02881744f, -0.01734532f, 0.01105292f, -0.03948764f, 0.07794256f, 
    -0.26217946f, 0.14449061f, -0.17631508f, -0.20240514f, -0.31057730f, 0.00251298f, 0.13141277f, 0.00139221f, 
    0.12184649f, -0.03484165f, -0.05151940f, 0.11293995f, 0.10560786f, -0.24734844f, 0.08301035f, 0.17032236f, 
    -0.07761846f, -0.02680545f, 0.19927537f, 0.11872867f, 0.02836909f, 0.12604260f, 0.08632883f, 0.06017255f, 
    0.07293324f, 0.01672189f, 0.24600649f, -0.04452519f, 0.13434672f, 0.06663533f, -0.08851948f, -0.00286391f, 
    0.00158259f, 0.06722063f, -0.03031443f, 0.13754341f, -0.11058321f, -0.03002054f, -0.45234323f, -0.05049989f, 
    -0.25259057f, 0.02264136f, 0.14298710f, 0.03741265f, -0.08979426f, 0.23298629f, -0.19034818f, -0.01231530f, 
    -0.04810755f, 0.02073154f, -0.27367285f, 0.25162074f, -0.04314220f, -0.10357905f, 0.02293756f, -0.02441366f, 
    0.08152843f, -0.08750814f, -0.02008080f, 0.00317644f, 0.02582181f, 0.11505178f, 0.03950925f, -0.03729601f, 
    0.06099950f, -0.04387093f, -0.00663811f, 0.10734691f, 0.02586601f, 0.05007022f, 0.07767478f, 0.01822348f, 
    -0.05552253f, 0.05707322f, -0.10992523f, -0.00841678f, -0.02411643f, 0.00511826f, 0.01587959f, -0.08645730f, 
    0.24647379f, 0.19537115f, 0.12722783f, 0.12272056f, -0.07535545f, 0.13042305f, -0.21583027f, 0.14597178f, 
    -0.09465529f, -0.02281681f, -0.01251561f, 0.02188772f, -0.08707146f, -0.00763575f, -0.10243861f, -0.02486649f, 
    0.08122475f, 0.03486894f, 0.09995452f, -0.03124524f, 0.04177569f, -0.02628011f, -0.03698467f, -0.09359875f, 
    0.05820876f, 0.14070174f, 0.05139789f, -0.02390309f, 0.13761945f, -0.02465290f, 0.12268293f, 0.27631059f, 
    -0.06672877f, 0.11933208f, 0.02898761f, -0.02507942f, -0.07647252f, -0.13518086f, -0.04791292f, 0.10570102f, 
    -0.06182261f, 0.04621285f, -0.01723607f, 0.17233957f, -0.01025164f, 0.09117864f, -0.04468375f, 0.15205254f, 
    0.15002207f, 0.00299834f, 0.05917229f, 0.01453935f, 0.09687610f, -0.08903180f, -0.10042315f, -0.02202957f, 
    -0.16095619f, -0.02866960f, 0.09240142f, -0.04485737f, 0.00190764f, 0.05051792f, -0.08439509f, -0.05100295f, 
    -0.31557450f, -0.18693055f, -0.08950548f, 0.11593277f, 0.01264284f, 0.06362277f, 0.07284231f, 0.05355708f, 
    -0.05194468f, -0.00827402f, 0.17141384f, 0.00780958f, -0.15886088f, 0.01292777f, -0.04193402f, -0.26762336f, 
    0.15636648f, -0.02002185f, 0.06117857f, -0.00517259f, 0.00598538f, 0.03038437f, -0.06995339f, -0.09751211f, 
    -0.44674924f, 0.48630184f, -0.22189620f, -0.04979578f, 0.01647403f, 0.03879846f, -0.12041327f, 0.03627620f, 
    0.03862758f, 0.02213065f, -0.08547723f, -0.06779597f, 0.09477864f, -0.20396078f, 0.12811981f, 0.12580031f, 
    0.12843862f, -0.16804902f, 0.11255192f, -0.11375885f, 0.02574789f, -0.11571488f, -0.07902066f, -0.03514307f, 
    0.45584309f, -0.04061813f, -0.19619867f, -0.10247581f, -0.02473343f, -0.03417631f, 0.03150892f, 0.00559192f, 
    -0.02393867f, 0.07378810f, -0.01657316f, 0.16080192f, -0.06823709f, -0.04927097f, 0.17464215f, -0.01105582f, 
    0.04301686f, 0.02645281f, -0.15271901f, 0.06617013f, 0.01482453f, 0.08578224f, 0.00002700f, 0.03504119f, 
    0.22320125f, 0.04572212f, 0.17970955f, 0.45425853f, 0.01508970f, 0.06677662f, 0.05403801f, 0.08268553f, 
    -0.02060350f, 0.04340960f, -0.04140867f, 0.07638353f, 0.08347609f, 0.14534239f, 0.01348257f, -0.13724948f, 
    -0.06060507f, 0.00620454f, -0.07854404f, -0.03567627f, 0.02172758f, 0.05122998f, 0.07655727f, -0.04158145f, 
    -0.08566524f, 0.16316728f, -0.04836696f, 0.04404079f, -0.02145527f, 0.00085028f, -0.03136969f, 0.00908918f, 
    0.09263781f, -0.23791669f, -0.01371875f, -0.01503274f, -0.05661812f, -0.02646725f, 0.03887132f, 0.11282953f, 
    0.07600940f, 0.19462177f, -0.07830402f, -0.03278468f, 0.02167282f, 0.02192168f, 0.17109317f, 0.01103198f, 
    0.07494540f, 0.11249965f, -0.10077336f, -0.20927890f, 0.07541272f, -0.00594808f, 0.06807597f, -0.04464354f, 
    -0.10423942f, -0.11035642f, -0.08237417f, -0.01158509f, -0.08569688f, -0.06314916f, -0.28013384f, 0.34173605f, 
    0.10235034f, 0.12141012f, -0.00178011f, 0.02793981f, -0.03783605f, 0.03067626f, 0.00945267f, -0.01029968f, 
    0.15728725f, 0.09791669f, -0.04969513f, -0.00554562f, 0.16575171f, 0.10840444f, 0.00960069f, 0.00843311f, 
    0.05693486f, 0.01547847f, 0.02284407f, 0.08679146f, 0.20346713f, 0.06794276f, 0.03855832f, 0.28744814f, 
    0.01262223f, -0.02425115f, -0.20537992f, -0.04916697f, -0.01200051f, -0.08038639f, 0.02099587f, 0.06735719f, 
    -0.01425448f, 0.19279282f, -0.06124374f, 0.24641854f, 0.02551020f, 0.15011038f, 0.07549888f, 0.09661955f, 
    -0.08103638f, -0.12861529f, 0.04857208f, -0.00564636f, 0.06254569f, 0.14477235f, 0.19192778f, 0.08217762f, 
    0.01420056f, -0.13663508f, -0.02606021f, 0.04889626f, -0.03267119f, -0.01522276f, -0.06219943f, -0.08539124f, 
    -0.29147702f, -0.27646273f, -0.21817245f, 0.03690930f, -0.06989644f, -0.04670571f, 0.05730886f, 0.02707047f, 
    -0.04018988f, 0.04237494f, 0.05455911f, -0.02503397f, -0.13786164f, 0.01164418f, -0.04756479f, 0.02474780f, 
    0.15670200f, -0.12172202f, 0.00431803f, 0.00853234f, -0.02170593f, 0.00713569f, 0.01828383f, -0.05135857f, 
    -0.14623666f, 0.30150118f, -0.41623399f, -0.06428506f, 0.05722233f, 0.08118612f, -0.11315718f, 0.08098505f, 
    -0.18362415f, -0.04035766f, -0.12087475f, -0.05097142f, 0.24493946f, 0.01377913f, 0.18169583f, 0.06850535f, 
    0.13231392f, -0.03264495f, 0.06402338f, 0.07931741f, -0.02163441f, -0.06751719f, -0.06211257f, 0.08133610f, 
    0.31429386f, -0.12133623f, 0.20313968f, -0.01116529f, 0.02564684f, -0.08262666f, 0.05563544f, 0.03783763f, 
    0.00382382f, -0.00061989f, 0.00682656f, 0.08033582f, 0.22474758f, 0.11952358f, -0.00383187f, 0.13242853f, 
    -0.04089660f, 0.12435286f, 0.09581033f, 0.10036334f, 0.07470195f, -0.03999060f, 0.20821722f, 0.03984607f, 
    -0.04331659f, 0.10693151f, 0.18354157f, 0.45485249f, -0.07321431f, -0.05467609f, 0.00878015f, 0.08666360f, 
    -0.12250116f, -0.01692815f, 0.11344072f, 0.02303641f, 0.15161897f, 0.18557189f, 0.32732520f, -0.06165329f, 
    -0.08889114f, -0.02326539f, -0.11642178f, -0.04773919f, 0.00402943f, 0.04942502f, 0.03745754f, -0.00211674f, 
    0.12271632f, 0.04650914f, -0.00201159f, 0.21608773f, 0.05393783f, -0.04111316f, -0.02144533f, -0.02590994f, 
    0.10389566f, 0.20182218f, 0.03855033f, 0.01415696f, 0.21489431f, 0.12910779f, -0.03315822f, 0.04393984f, 
    0.13451278f, -0.00735885f, 0.13627960f, 0.14624538f, 0.00353653f, 0.07348497f, -0.00522025f, -0.09293459f, 
    -0.03617016f, 0.24222964f, -0.04239907f, 0.19505884f, 0.20536920f, 0.02334134f, 0.14648126f, -0.12587219f, 
    -0.07611539f, 0.04311663f, -0.05862514f, -0.07768381f, 0.20626161f, 0.20711990f, 0.05310615f, 0.21969910f, 
    -0.01881792f, -0.25477302f, -0.20003204f, -0.12580645f, 0.05558326f, 0.05947959f, 0.00499758f, 0.10210874f, 
    -0.07956536f, -0.05349454f, -0.09530044f, 0.02534631f, -0.05991961f, 0.21914843f, -0.05482824f, 0.00664816f, 
    -0.07653645f, 0.01038341f, -0.01798813f, 0.03536319f, -0.04636003f, -0.07668136f, 0.17602199f, 0.07945281f, 
    -0.16175954f, 0.03093609f, 0.04305913f, 0.09987789f, -0.12039658f, -0.02582703f, -0.15553634f, 0.09183511f, 
    -0.10553550f, -0.20338283f, -0.01481780f, 0.10363061f, 0.12922445f, 0.14651287f, -0.15592851f, 0.07220346f, 
    0.01192326f, 0.02396175f, 0.15851995f, 0.04227857f, 0.12621766f, -0.03952506f, -0.04576826f, -0.03523923f, 
    -0.09151128f, 0.06115536f, 0.16968164f, 0.03398481f, 0.13670211f, 0.14634801f, -0.03603026f, 0.30046904f, 
    -0.17470005f, -0.02536902f, 0.00912130f, 0.12163441f, 0.07788595f, -0.08099093f, 0.00708597f, 0.06715323f, 
    -0.01072343f, 0.01408389f, 0.04979771f, -0.01588136f, -0.13342182f, 0.24532220f, -0.07920994f, -0.14573219f, 
    0.01762307f, 0.03471375f, 0.12712499f, -0.07166649f, 0.14479163f, -0.04670739f, -0.03228861f, 0.03048782f, 
    -0.14219108f, 0.21821348f, 0.16802987f, 0.19534385f, 0.05254292f, 0.14933851f, -0.09908871f, -0.07423633f, 
    -0.07577670f, 0.03544973f, -0.04687383f, -0.00664927f, 0.16183861f, -0.19101554f, -0.03525278f, 0.08454178f, 
    0.10100442f, -0.08706891f, 0.01246541f, -0.16030553f, -0.08497858f, -0.03073155f, -0.02412833f, -0.00660458f, 
    0.00904080f, 0.16721235f, -0.13435191f, -0.10802226f, -0.08943796f, 0.16964610f, 0.08769958f, 0.01599083f, 
    0.03742545f, -0.01364718f, -0.06456601f, 0.11852033f, -0.02137444f, -0.10824730f, 0.00701763f, 0.04819561f, 
    -0.07725733f, -0.17649862f, -0.27487147f, 0.00437814f, 0.09021810f, -0.08769756f, -0.15686721f, -0.12369416f, 
    -0.03816571f, 0.01959731f, 0.11160488f, 0.26668438f, 0.00997088f, -0.06710976f, 0.02313644f, 0.05728431f, 
    0.01513545f, 0.10500505f, -0.01194075f, 0.20531505f, 0.17306553f, -0.02383752f, -0.01428122f, -0.03082203f, 
    0.02985319f, 0.17706776f, -0.00895170f, -0.02284886f, -0.00926170f, 0.05764792f, -0.13068080f, -0.07799231f, 
    0.00087789f, 0.06103414f, -0.10306048f, -0.10196010f, -0.00338658f, 0.02674874f, -0.06017901f, -0.06458424f, 
    0.04205209f, -0.11911691f, -0.04882674f, 0.03930246f, -0.17207314f, -0.04267364f, 0.11724485f, -0.05070210f, 
    0.05600946f, 0.27826336f, -0.07074120f, -0.10827997f, -0.04789146f, 0.15139908f, 0.03862892f, -0.03538003f, 
    -0.16517556f, 0.10270265f, -0.20406285f, 0.09704018f, 0.03160029f, -0.00626573f, -0.00752952f, -0.07805233f, 
    -0.05311621f, -0.01646685f, -0.00642620f, -0.04772798f, 0.09818900f, -0.06380036f, -0.18239966f, 0.07549482f, 
    0.05282270f, 0.09876553f, -0.06124473f, 0.04874844f, 0.05951782f, 0.00408652f, -0.08897247f, -0.00066971f, 
    0.29067159f, -0.02762574f, 0.31679362f, 0.04155332f, 0.29313502f, 0.13446051f, 0.04822332f, 0.15894264f, 
    0.00947701f, 0.04267060f, 0.06428247f, 0.12199029f, 0.14629841f, 0.13006946f, 0.08966942f, -0.00199252f, 
    0.10580451f, -0.01281644f, -0.05621936f, 0.00697642f, 0.07230035f, 0.00898151f, 0.00764213f, -0.12184044f, 
    0.28796831f, 0.03489370f, 0.21026097f, -0.11675889f, -0.02152156f, 0.02468566f, 0.06157057f, 0.07861755f, 
    -0.06417349f, -0.06444050f, -0.04051633f, -0.04568079f, -0.18296547f, 0.13535243f, 0.04167391f, -0.02236043f, 
    0.14858428f, -0.15968139f, -0.09425247f, -0.13066870f, 0.02801274f, -0.02836693f, -0.02710989f, -0.07346132f, 
    0.33281898f, 0.17305763f, -0.00636338f, -0.23479286f, -0.05627569f, -0.07478455f, -0.04640593f, 0.09243028f, 
    -0.10520235f, 0.08484277f, -0.10754853f, 0.04127732f, 0.24634382f, 0.04177619f, 0.17912894f, 0.20988153f, 
    -0.06262229f, -0.14713034f, 0.00301359f, 0.09931086f, -0.01332564f, 0.05589989f, 0.05579609f, -0.02990011f, 
    0.14002454f, -0.31359017f, -0.24406421f, 0.26359159f, 0.17129362f, 0.11597420f, 0.06727867f, 0.04056821f, 
    0.07636280f, -0.00458908f, 0.06375710f, 0.01007995f, 0.18926126f, 0.28972980f, -0.03515088f, -0.02984236f, 
    -0.10668872f, 0.02457429f, -0.00969877f, 0.18821900f, -0.08783447f, -0.02339303f, -0.08243418f, -0.07574818f, 
    -0.08384503f, -0.12044718f, 0.40837526f, 0.09806029f, 0.17797443f, 0.03605373f, -0.10904198f, -0.05748476f, 
    0.03739119f, 0.02633718f, 0.02848634f, 0.07759823f, 0.19773789f, 0.23900582f, -0.12604433f, 0.01696081f, 
    -0.09068362f, 0.11250424f, 0.07781587f, 0.07610398f, -0.08755554f, -0.08017434f, 0.09846547f, -0.11343267f, 
    -0.05819151f, 0.01047772f, 0.07130185f, 0.09767572f, -0.07621436f, -0.02746025f, -0.04852303f, 0.06434624f, 
    -0.06495285f, 0.14066155f, -0.07488403f, -0.04114842f, -0.05048053f, 0.19023997f, 0.22116572f, 0.07218352f, 
    0.11114655f, -0.11334872f, 0.03158790f, 0.04560019f, -0.00352107f, 0.03066389f, 0.20923983f, 0.13860665f, 
    0.16988719f, 0.06277230f, 0.18821086f, -0.25664315f, -0.02526936f, 0.03546241f, -0.11465546f, 0.02359105f, 
    -0.05890900f, 0.05117768f, 0.08008589f, -0.11475706f, -0.06412264f, -0.08056878f, 0.08403480f, -0.15264986f, 
    0.06462561f, 0.04086032f, -0.02640642f, -0.03294163f, -0.09674042f, 0.04554797f, 0.17147589f, -0.01084739f, 
    -0.20094073f, -0.00766606f, 0.05482209f, -0.00181995f, 0.02812449f, -0.09258954f, -0.16971765f, -0.05460841f, 
    -0.09877051f, -0.02377190f, -0.12737188f, -0.07604184f, 0.22289035f, 0.07047968f, -0.00573038f, 0.07659451f, 
    -0.00964107f, 0.13350834f, 0.10548787f, 0.16599739f, 0.12124838f, 0.15053752f, 0.06741877f, -0.01730703f, 
    -0.20791358f, 0.15354468f, 0.02417208f, 0.15895593f, -0.05555869f, 0.09443823f, -0.00686464f, 0.18000236f, 
    0.08714099f, -0.01109732f, 0.02946687f, 0.04981636f, -0.18138884f, -0.01098142f, 0.05887109f, -0.05906461f, 
    -0.02596526f, 0.03095176f, -0.00047331f, -0.03095876f, 0.13323705f, -0.01291156f, -0.04437815f, -0.08865327f, 
    -0.33245099f, 0.05000573f, -0.02942599f, 0.02355221f, -0.08571028f, -0.08743573f, -0.03235041f, 0.04218081f, 
    0.06754758f, 0.11776452f, 0.08953602f, 0.11157250f, -0.07314131f, 0.07447714f, -0.05346784f, 0.03835792f, 
    0.00447145f, 0.01531489f, -0.00591614f, -0.23064409f, 0.06078424f, -0.04352621f, 0.21275559f, 0.10079814f, 
    0.31572533f, 0.03483490f, 0.30444381f, -0.02832439f, -0.04776437f, -0.00335997f, 0.03538061f, -0.06662584f, 
    -0.10882565f, 0.07315779f, -0.13080278f, 0.12681983f, 0.07459979f, 0.00589687f, 0.19392169f, 0.16623367f, 
    -0.11067143f, -0.03844197f, 0.08679244f, -0.11450869f, 0.00350339f, 0.00654497f, -0.00729709f, -0.01891090f, 
    -0.05846539f, -0.10723284f, -0.02782576f, 0.13268144f, 0.15747200f, -0.02122220f, -0.08265815f, 0.01805045f, 
    0.10773399f, -0.05298600f, 0.03117092f, -0.00106552f, -0.06876427f, -0.06294389f, -0.04050435f, 0.17577085f, 
    -0.07634794f, 0.13742243f, 0.06709868f, 0.18357442f, 0.06246088f, 0.10051708f, -0.07108205f, -0.03620454f, 
    -0.47783607f, 0.06789404f, 0.02003816f, -0.00486946f, -0.00751862f, -0.14665872f, 0.09892082f, -0.15012710f, 
    0.00194266f, -0.00757438f, 0.08088418f, -0.04758786f, 0.24349196f, 0.10496082f, 0.27062929f, 0.28433970f, 
    -0.20194151f, 0.01385106f, 0.25570902f, 0.28437269f, -0.03899087f, -0.06035628f, 0.10063407f, 0.03918013f, 
    -0.06924491f, -0.05775087f, -0.07165951f, -0.21121274f, 0.00044176f, 0.07309791f, -0.01336998f, -0.06056546f, 
    -0.19679184f, -0.01518609f, 0.02505715f, -0.01495933f, -0.31206009f, -0.22615243f, -0.31887200f, -0.04035137f, 
    -0.02233240f, 0.02157806f, 0.01020232f, -0.10859934f, 0.00354083f, 0.06184074f, 0.01586650f, -0.03384648f, 
    -0.13490136f, 0.14407368f, -0.17037179f, 0.05850523f, -0.06343322f, 0.03190030f, -0.09862003f, -0.11008190f, 
    -0.02906779f, -0.01934342f, -0.09233696f, -0.04417488f, -0.04179538f, -0.12242983f, 0.10342131f, -0.10733358f, 
    -0.00257201f, 0.11511607f, 0.02487261f, 0.07742108f, 0.06819836f, 0.19739853f, 0.12922946f, 0.11577471f, 
    -0.23581588f, 0.17703877f, -0.37571800f, 0.11977761f, -0.04920813f, -0.03208748f, 0.07588794f, -0.15258442f, 
    0.15548185f, 0.06774993f, 0.01523485f, 0.19535539f, -0.33822811f, -0.06271015f, -0.20841140f, 0.12488981f, 
    0.08068378f, 0.08323601f, 0.02522168f, -0.02219547f, -0.11459005f, -0.01635880f, -0.07173912f, 0.08652342f, 
    0.26280734f, 0.10350524f, 0.00826169f, 0.03281267f, 0.11049342f, 0.05442360f, 0.08790912f, 0.01769233f, 
    0.00919265f, 0.08787021f, -0.03951376f, 0.00840495f, 0.23713374f, 0.06255364f, 0.16387419f, 0.26470721f, 
    0.01167458f, 0.04807256f, 0.01905752f, -0.10375922f, 0.14818215f, -0.08597048f, 0.05995344f, -0.02751652f, 
    -0.08958200f, 0.03385106f, -0.26244673f, 0.02148616f, -0.09173318f, 0.02152466f, 0.00037433f, 0.14501607f, 
    -0.04714585f, 0.02352230f, -0.07097965f, 0.03512160f, -0.13088751f, 0.10224717f, 0.07357141f, -0.24836765f, 
    -0.03568051f, -0.15374523f, -0.03460532f, 0.01471912f, -0.05276203f, 0.06595798f, -0.16070412f, -0.16399582f, 
    0.38477704f, 0.06763946f, -0.08441649f, 0.04670547f, 0.12893653f, 0.19189245f, 0.05504109f, 0.17765975f, 
    -0.05806687f, 0.03329351f, 0.10760833f, 0.09605850f, 0.09031978f, 0.06816954f, -0.06834459f, 0.05600715f, 
    0.16523239f, -0.00514757f, -0.02514902f, -0.06860372f, 0.01887358f, -0.07843853f, -0.04631127f, -0.15069266f, 
    -0.38149095f, 0.23317069f, -0.24524756f, 0.15247831f, 0.19911596f, 0.14329958f, 0.03837669f, 0.11645969f, 
    -0.01479368f, -0.07618201f, -0.03668386f, -0.03395925f, 0.22970542f, 0.04872156f, -0.02238157f, -0.08384418f, 
    -0.04617960f, -0.06660682f, 0.01987550f, -0.08846064f, -0.10599286f, -0.06234078f, -0.02650543f, -0.05347152f, 
    0.02356657f, -0.14573655f, 0.13922302f, -0.22281922f, 0.17473444f, 0.01507906f, -0.12931471f, 0.05926071f, 
    -0.08472924f, 0.06581026f, -0.00477415f, 0.19293095f, 0.14310548f, 0.02984741f, -0.00992162f, 0.13240552f, 
    -0.16880709f, 0.12483129f, -0.02743842f, 0.09583654f, -0.09026986f, -0.01311891f, 0.08396418f, 0.06045688f, 
    0.18896995f, 0.08327294f, 0.06068749f, 0.20458747f, -0.05714187f, 0.13821439f, -0.00821635f, 0.18342912f, 
    -0.10044231f, 0.04648028f, -0.10617355f, 0.05665898f, 0.21582529f, 0.19298214f, 0.22958417f, 0.07392150f, 
    -0.07087612f, -0.10791874f, 0.04366605f, -0.02613597f, -0.04410440f, -0.00217643f, 0.10040507f, 0.12184245f, 
    0.03238420f, 0.02666293f, 0.01030452f, -0.04742882f, 0.05544526f, 0.03544646f, -0.05234931f, -0.05857780f, 
    -0.06283285f, -0.04172942f, 0.03127312f, 0.01666588f, -0.05127813f, -0.04838385f, 0.06125179f, 0.03175941f, 
    -0.06546723f, -0.00821870f, -0.01194323f, -0.02201830f, 0.06395502f, 0.04390691f, -0.05091167f, 0.03559832f, 
    0.02967345f, -0.03587664f, 0.03013934f, 0.04491252f, 0.00644586f, -0.02038479f, -0.00297562f, 0.04813327f, 
    0.01840030f, -0.05888894f, 0.04482036f, 0.01445714f, -0.06216810f, -0.01681262f, -0.04545791f, -0.00063205f, 
    -0.05220120f, 0.03286420f, 0.02233447f, 0.03554327f, 0.01737699f, -0.05146218f, 0.02174122f, -0.00304336f, 
    -0.03712831f, -0.05674471f, -0.03365533f, 0.01922193f, -0.06248110f, -0.05089631f, -0.02804228f, -0.02540833f, 
    -0.02976410f, 0.03993949f, 0.03727531f, -0.00703533f, 0.01827073f, -0.03697307f, -0.04192444f, -0.07649347f, 
    0.02470936f, -0.05858955f, 0.00053881f, 0.02038340f, -0.01144814f, 0.00185094f, 0.04040942f, 0.01466600f, 
    -0.05129603f, -0.06622899f, -0.00310609f, -0.00933192f, -0.06685276f, 0.03063541f, -0.01160260f, -0.03159113f, 
    0.06103269f, 0.06391315f, -0.00108977f, -0.02437131f, 0.04168183f, 0.05633350f, -0.06014966f, -0.04085574f, 
    -0.03683609f, 0.02815991f, -0.06872059f, -0.03645140f, 0.06319618f, -0.05149120f, -0.06888875f, 0.05343005f, 
    0.02447137f, -0.04315230f, -0.07253613f, 0.04958012f, -0.01025530f, 0.00099518f, 0.05320839f, -0.05549879f, 
    0.03313467f, -0.02142401f, -0.03948459f, -0.00980106f, 0.04958268f, 0.05503690f, -0.06031855f, 0.00035748f, 
    0.02543722f, 0.00574575f, 0.00006825f, -0.06413790f, -0.03731655f, -0.06715655f, 0.03238282f, -0.05560452f, 
    -0.05045595f, -0.02676679f, 0.02040378f, -0.04488391f, -0.01444727f, -0.02072050f, 0.00668980f, 0.01514947f, 
    0.03720358f, 0.00960138f, -0.06897636f, -0.06694344f, -0.06427712f, 0.06605305f, -0.02517680f, 0.01192068f, 
    0.00026822f, -0.03815599f, -0.02702870f, -0.03594253f, -0.02263373f, -0.02481529f, -0.04002129f, -0.03243328f, 
    0.03693477f, -0.04120897f, -0.04154508f, -0.00581377f, 0.04555445f, -0.03475949f, -0.00610087f, 0.03065701f, 
    -0.06009357f, -0.07455730f, 0.03153008f, -0.02166897f, -0.00326194f, -0.00910662f, 0.03091304f, -0.06298920f, 
    -0.05286426f, 0.02323319f, 0.05709812f, 0.03223849f, 0.03943261f, -0.06914012f, -0.00388314f, -0.02029466f, 
    -0.06619152f, -0.00728139f, 0.02889429f, -0.01159300f, -0.07522883f, -0.02300263f, 0.05497129f, -0.06580236f, 
    0.04234195f, -0.00007382f, 0.04934909f, 0.05727237f, 0.03011486f, 0.00859086f, -0.00660258f, 0.01017870f, 
    -0.01163609f, -0.01720830f, 0.05780713f, -0.06528414f, -0.04296349f, -0.05383369f, -0.02344157f, -0.04463787f, 
    0.13609721f, 0.03582078f, 0.13789448f, -0.26256827f, -0.19673882f, -0.01020157f, -0.05256791f, 0.01624471f, 
    -0.10986660f, 0.01160788f, 0.01242110f, -0.03490251f, 0.03288141f, -0.03821946f, 0.22157703f, -0.10732881f, 
    -0.08819832f, -0.02040417f, 0.05800915f, 0.09622513f, -0.03290078f, 0.15277472f, 0.03449533f, 0.18472983f, 
    -0.11406783f, 0.03138691f, -0.16495416f, 0.08860093f, -0.18345861f, -0.09403617f, -0.04547758f, 0.10730463f, 
    0.04903674f, -0.03907943f, 0.11082130f, 0.11944561f, -0.32674497f, -0.15704393f, 0.12081380f, -0.10873340f, 
    0.02670486f, 0.10614879f, 0.08542940f, 0.10495942f, -0.12760051f, 0.07425391f, 0.06159512f, 0.03011577f, 
    -0.02615312f, 0.06647942f, -0.13000621f, 0.08942936f, 0.02387909f, -0.01771084f, 0.07063283f, 0.10615408f, 
    0.13093200f, -0.05811928f, -0.01795358f, -0.08556383f, 0.04625656f, 0.01106138f, 0.03669441f, -0.06576700f, 
    0.03371536f, 0.04931290f, 0.22550917f, -0.18799838f, 0.26123881f, -0.07258343f, 0.17426454f, 0.06285960f, 
    -0.12624517f, -0.14073221f, -0.31398895f, 0.01447867f, -0.20173337f, -0.09625361f, 0.06909205f, 0.01594573f, 
    0.03589951f, 0.15739666f, 0.05233659f, -0.08873320f, -0.27880502f, 0.03977685f, 0.04147044f, -0.00932478f, 
    -0.00113777f, 0.03211820f, -0.02325240f, 0.04403476f, -0.24781531f, 0.00387432f, -0.12667635f, -0.11742994f, 
    0.46033219f, 0.19183205f, 0.14547758f, 0.02472282f, -0.11610348f, 0.09278609f, 0.01871649f, -0.02409223f, 
    0.08024672f, -0.14528672f, -0.16001342f, 0.00678836f, 0.17734765f, -0.07335583f, -0.06954890f, 0.26714247f, 
    -0.10633404f, 0.11532386f, -0.01352586f, -0.00417447f, 0.11399136f, -0.05543198f, 0.04639396f, -0.01036101f, 
    -0.02851718f, -0.51581782f, 0.11976233f, 0.01143930f, -0.04282203f, 0.02093487f, 0.17794524f, 0.11116988f, 
    0.23276335f, -0.18714982f, 0.11732487f, -0.05571137f, -0.09522472f, -0.07686935f, -0.10730959f, -0.17442243f, 
    0.00071835f, 0.03474968f, -0.18021719f, -0.00900995f, 0.00163943f, 0.15907164f, -0.04807423f, 0.05049137f, 
    -0.23848364f, -0.12522465f, 0.14983384f, -0.18140715f, 0.08322541f, 0.09666133f, -0.01564372f, 0.02316970f, 
    0.06833550f, 0.11834677f, 0.03158213f, 0.01817609f, 0.00847302f, -0.19297609f, -0.08991324f, 0.27576852f, 
    -0.21572851f, 0.01834761f, 0.30466029f, 0.12969506f, -0.11520979f, 0.05835272f, 0.12792386f, 0.15745427f, 
    0.11785288f, -0.04256092f, 0.00043425f, -0.05829933f, -0.00445152f, 0.06552065f, -0.27934599f, -0.01205012f, 
    -0.14523655f, 0.04663008f, -0.06369465f, 0.04269427f, 0.05251651f, 0.10809059f, -0.05515896f, -0.05522984f, 
    -0.06540214f, -0.24210906f, 0.06917926f, -0.03964140f, -0.05649401f, 0.12584335f, 0.05955840f, 0.07161878f, 
    0.13597465f, 0.16826625f, 0.08571921f, -0.02876544f, -0.10672306f, -0.06720995f, -0.03131569f, 0.02912259f, 
    -0.14494617f, 0.03600842f, -0.02126190f, -0.02476617f, 0.06961715f, -0.00712379f, 0.07605135f, -0.22683463f, 
    -0.00979945f, -0.03779636f, -0.03414441f, 0.12100334f, -0.09234407f, 0.11259644f, -0.02829436f, 0.05196385f, 
    -0.33060527f, 0.18570398f, -0.29112142f, 0.47738788f, 0.04986739f, 0.07868837f, 0.04777403f, 0.00782273f, 
    0.01770467f, -0.05712681f, 0.06089607f, 0.09287288f, -0.19245753f, -0.02009291f, 0.19716348f, 0.00456549f, 
    -0.03268513f, -0.10907054f, -0.01659262f, 0.02617658f, -0.08016165f, 0.09543619f, 0.00556682f, -0.00710950f, 
    -0.19563602f, -0.03622390f, 0.10046343f, 0.12068699f, -0.02747133f, 0.11159246f, 0.07033283f, 0.05459726f, 
    0.11128373f, 0.11492633f, 0.14372285f, 0.04340087f, -0.06005946f, -0.01111642f, 0.04885753f, -0.00880851f, 
    -0.03192538f, -0.06785097f, 0.15963820f, -0.09434436f, 0.18370162f, 0.03871474f, -0.01973547f, 0.06551418f, 
    -0.37303665f, -0.24117982f, -0.30710772f, 0.00296118f, 0.02377263f, 0.05795690f, -0.10430336f, 0.05040488f, 
    -0.00858113f, 0.07164605f, 0.00884237f, 0.00057704f, -0.03786651f, 0.03101301f, -0.17270714f, -0.17451906f, 
    -0.06272934f, 0.03106688f, -0.03605356f, -0.02185797f, 0.02068932f, 0.13133889f, -0.07645281f, -0.07514975f, 
    0.35090011f, 0.20408922f, 0.33512747f, -0.06767136f, -0.04543329f, 0.05260649f, 0.04629517f, 0.14641984f, 
    0.07126574f, 0.04286105f, -0.05905017f, 0.01746870f, 0.09260993f, 0.07978696f, 0.07655656f, 0.05012800f, 
    -0.08701406f, 0.08890969f, -0.01428691f, 0.00824445f, 0.05679818f, 0.04433354f, 0.05528081f, 0.01703989f, 
    -0.26530966f, -0.22778381f, 0.34484699f, 0.30962998f, -0.07058278f, -0.00433843f, 0.04133893f, 0.09939965f, 
    0.03100584f, -0.06670783f, 0.13308509f, -0.02562711f, -0.08846240f, -0.22756884f, -0.12705381f, -0.07056265f, 
    -0.09075674f, -0.09041141f, 0.14225282f, -0.03228253f, -0.07316012f, 0.08791613f, 0.05616361f, -0.01502305f, 
    -0.30115902f, 0.14406349f, -0.04134735f, -0.19268672f, -0.01877314f, 0.10817011f, 0.00274319f, 0.01921400f, 
    0.10948271f, 0.24386999f, 0.07025925f, 0.20038620f, -0.10417219f, -0.23812184f, -0.05833634f, -0.01530117f, 
    -0.18781790f, 0.03925094f, -0.00511295f, 0.12593718f, -0.03555569f, -0.05136647f, -0.03192353f, -0.03647134f, 
    0.27432665f, 0.03717312f, 0.06552450f, 0.00897156f, 0.01615820f, 0.05600304f, -0.05318024f, -0.02112298f, 
    0.02086699f, 0.13862742f, -0.04179204f, 0.16689488f, 0.16611515f, 0.09668349f, -0.15911134f, 0.05071127f, 
    -0.06664506f, 0.01681126f, 0.16005291f, 0.02401092f, -0.08351809f, 0.20310417f, -0.03562580f, 0.06912525f, 
    -0.16812994f, 0.19325916f, -0.05027495f, -0.04891592f, 0.00413891f, 0.02755907f, 0.00719365f, -0.01044836f, 
    0.04111337f, -0.08839093f, 0.07577532f, -0.00399817f, -0.24268280f, -0.16912664f, -0.04084338f, -0.01514293f, 
    0.09629679f, 0.11327758f, -0.21812534f, -0.17188537f, 0.02331085f, 0.01500337f, 0.17417839f, 0.09753016f, 
    -0.16706608f, -0.04467547f, 0.16622104f, -0.05174616f, -0.05414493f, -0.02032023f, -0.08229375f, -0.00511995f, 
    0.02382479f, -0.01322486f, 0.03732084f, 0.03275971f, 0.35036883f, 0.09712272f, -0.12971985f, 0.05116285f, 
    0.02693950f, 0.28381908f, -0.00788654f, 0.08219892f, 0.03481658f, -0.01317867f, -0.05441835f, -0.01303647f, 
    0.25229636f, 0.20739038f, 0.05431729f, -0.08239783f, 0.26153049f, -0.01626174f, 0.04484121f, -0.07197414f, 
    0.01903308f, 0.06387883f, -0.02888106f, 0.18637331f, 0.20142646f, 0.05501488f, 0.00062632f, 0.11387788f, 
    0.15545966f, -0.08490199f, -0.12830827f, -0.00574140f, 0.05259100f, -0.05032694f, 0.07354097f, -0.15213716f, 
    0.23231305f, 0.25286770f, 0.03164277f, -0.05212645f, 0.04583254f, 0.03305260f, 0.06799082f, 0.04397050f, 
    -0.11188670f, -0.01171602f, 0.04475304f, 0.08761144f, -0.11752078f, -0.04710113f, 0.06098535f, 0.03362954f, 
    0.07216937f, -0.06674220f, -0.12431525f, 0.09265892f, 0.11206351f, 0.01793172f, 0.05463286f, -0.14947952f, 
    0.11489369f, 0.07738821f, -0.00941932f, 0.06045865f, 0.15679938f, 0.12990610f, -0.18295012f, 0.08652813f, 
    0.00486734f, 0.00455752f, 0.08423874f, 0.05448921f, 0.14446981f, 0.06631297f, 0.06959050f, 0.08267406f, 
    0.16920635f, -0.20049745f, -0.02778750f, 0.04540616f, -0.10541862f, 0.09878006f, 0.02893966f, -0.08950437f, 
    0.12939058f, 0.21546423f, -0.19459389f, -0.06657245f, 0.20531912f, 0.07464943f, -0.12178236f, 0.06475858f, 
    -0.03830648f, 0.06279446f, 0.01176141f, 0.02735156f, 0.10529082f, 0.21837261f, -0.01627123f, -0.12806165f, 
    -0.01069675f, 0.03520802f, -0.03859276f, 0.13467632f, -0.03310725f, -0.03425147f, -0.08845030f, 0.00062090f, 
    -0.00614180f, 0.04276770f, 0.15701543f, 0.11950845f, 0.03186667f, -0.16490492f, -0.03104718f, 0.00605969f, 
    -0.02156906f, -0.09911592f, -0.06917811f, 0.00177334f, 0.35249341f, 0.26271865f, -0.00560304f, -0.06919459f, 
    0.07741905f, 0.11645699f, 0.18096974f, -0.02755331f, 0.01097191f, 0.00562952f, 0.10283674f, -0.00402465f, 
    -0.09826890f, 0.07762264f, -0.09792097f, 0.00432759f, 0.00439761f, 0.02955473f, 0.11339685f, 0.02888465f, 
    -0.07326718f, -0.08290208f, 0.03802143f, -0.13885839f, -0.33467552f, 0.05835556f, 0.02520652f, 0.02515068f, 
    0.04060449f, -0.00951064f, -0.04990226f, -0.00584082f, -0.05085934f, -0.07455076f, 0.06809650f, 0.02525655f, 
    -0.06770857f, 0.02327123f, 0.23646350f, 0.19592296f, -0.04997560f, -0.12532452f, -0.03586704f, -0.01426995f, 
    0.16275120f, 0.05640617f, 0.08132437f, 0.07949048f, 0.04796210f, -0.05547417f, -0.19181971f, -0.14795341f, 
    0.02330577f, -0.20710364f, 0.01520746f, -0.09547853f, 0.04832223f, 0.06112851f, 0.04943178f, 0.03361094f, 
    0.05347425f, -0.10516746f, 0.35627082f, -0.13894781f, -0.02330141f, -0.00016611f, -0.08292507f, 0.12482381f, 
    0.21720248f, 0.04783478f, 0.24978524f, 0.05864871f, -0.06563104f, -0.09374449f, 0.20186302f, -0.14189625f, 
    0.11286384f, -0.03865617f, 0.01620687f, -0.07620326f, -0.02028919f, -0.01028670f, 0.05301512f, 0.04250300f, 
    -0.00181910f, -0.01342306f, -0.06851382f, -0.09818143f, -0.00928789f, 0.00986038f, 0.02678785f, -0.00208095f, 
    -0.01653384f, 0.04833655f, 0.06938085f, 0.03439358f, 0.01157120f, 0.15188116f, -0.01901374f, 0.02268611f, 
    0.19316031f, 0.04816135f, 0.03180098f, 0.09540957f, -0.16466834f, 0.09122830f, 0.15773571f, 0.12433572f, 
    -0.01693510f, -0.07157286f, -0.01348409f, -0.05936388f, 0.07474576f, 0.03576849f, 0.13872288f, -0.12435119f, 
    0.03855667f, 0.04649660f, -0.00909497f, 0.01643507f, -0.08324891f, -0.19239694f, -0.17785974f, -0.07094138f, 
    -0.03064090f, 0.03959879f, 0.08932530f, 0.13739902f, 0.15679280f, 0.09927690f, 0.02580039f, -0.18722984f, 
    -0.36184949f, 0.07730734f, 0.07615003f, 0.06968998f, 0.08328430f, 0.06016477f, 0.05158839f, 0.05065833f, 
    0.04380269f, 0.02463457f, 0.12105978f, 0.01497804f, -0.16926068f, -0.16570514f, -0.10761381f, -0.03408663f, 
    -0.01936558f, 0.17488320f, 0.15188918f, 0.08642285f, -0.09583325f, 0.00336590f, -0.01349341f, 0.10696129f, 
    -0.00105941f, 0.34543854f, 0.22351661f, -0.23874675f, 0.02698163f, -0.15230729f, 0.00250128f, 0.23680660f, 
    -0.03886161f, 0.02358356f, -0.02299190f, 0.01647992f, -0.24920574f, -0.22660048f, 0.01170497f, -0.09927888f, 
    0.06303088f, 0.14697184f, -0.00072732f, -0.14110118f, 0.00874763f, -0.00412492f, -0.03809184f, 0.08039296f, 
    0.12289323f, 0.02831026f, -0.30161601f, 0.04021079f, -0.15690699f, -0.04072141f, 0.13456511f, -0.11180512f, 
    0.18094972f, -0.14783920f, 0.01159052f, -0.02063059f, -0.18799296f, -0.06149820f, -0.01863945f, -0.28750819f, 
    0.26089007f, 0.01684233f, 0.06175489f, -0.10425296f, -0.05858442f, 0.11723575f, -0.13684575f, 0.05024688f, 
    0.15818246f, 0.02199602f, 0.10191911f, -0.05462320f, 0.10372023f, -0.05114485f, 0.00428171f, -0.04113491f, 
    -0.04880337f, -0.01097945f, 0.09744267f, -0.00832004f, -0.18666786f, -0.22984515f, -0.09874621f, -0.20757824f, 
    0.02319162f, -0.00025025f, 0.03588356f, -0.03903065f, -0.03713575f, -0.10503194f, 0.01851064f, 0.06037849f, 
    -0.07598881f, 0.13332523f, 0.11467436f, 0.12228867f, 0.00558879f, -0.01784260f, -0.04877245f, 0.02190079f, 
    0.12805325f, -0.01924667f, 0.00637157f, -0.06862331f, -0.15293807f, 0.00539229f, 0.08100996f, 0.04725135f, 
    0.00237785f, 0.00131424f, -0.05411470f, -0.03018692f, 0.18848564f, 0.12618092f, 0.13343330f, 0.29918173f, 
    0.04741656f, 0.02683687f, 0.07118110f, -0.20549671f, -0.11315397f, -0.03537660f, -0.01515459f, -0.01719493f, 
    0.17950690f, 0.04918421f, 0.25074241f, 0.14810134f, -0.21915452f, -0.07304956f, -0.20334041f, -0.10393376f, 
    0.07332609f, 0.17095047f, 0.13789748f, 0.05589391f, -0.09269386f, 0.08499335f, -0.00759989f, -0.06686360f, 
    0.26395747f, 0.21503317f, -0.20411342f, 0.09970695f, 0.05228416f, -0.00004768f, 0.18514858f, -0.09310204f, 
    0.01806926f, -0.04951599f, 0.00299276f, -0.10335381f, 0.19088130f, 0.14395703f, -0.06538606f, 0.31802049f, 
    0.06111670f, 0.20539743f, 0.08704771f, -0.05170742f, 0.11242709f, -0.05469663f, 0.11885595f, 0.16001554f, 
    0.00013174f, 0.08480341f, -0.31019831f, -0.03506936f, 0.08776797f, 0.06945988f, 0.12217605f, 0.07485361f, 
    -0.02052491f, 0.06919655f, -0.12278412f, -0.03380567f, -0.25263190f, -0.00129100f, -0.01650940f, -0.09819634f, 
    -0.02208669f, -0.06292981f, -0.00937176f, -0.01246259f, 0.00351755f, 0.02577058f, -0.12703446f, -0.24626209f, 
    -0.08011056f, 0.01038286f, 0.02362755f, 0.29257765f, 0.13471086f, 0.08308312f, 0.04783962f, 0.05819448f, 
    0.09904233f, -0.00025797f, 0.08666369f, 0.01795668f, -0.07747648f, -0.21854182f, -0.20713559f, 0.17928664f, 
    0.10170159f, 0.08947898f, 0.10741609f, 0.03737808f, -0.10192083f, -0.17262286f, -0.06134973f, -0.12668766f, 
    -0.06639976f, 0.30670205f, -0.05059589f, -0.33979270f, -0.08051998f, -0.01935500f, 0.06555434f, 0.05835339f, 
    0.07083003f, -0.04901151f, -0.01056091f, 0.11228725f, 0.00549597f, -0.26907101f, 0.04712960f, -0.08070181f, 
    0.09080641f, -0.03704270f, -0.05032729f, -0.13402629f, -0.06207620f, 0.05218715f, 0.04545299f, 0.06552499f, 
    0.02631210f, 0.09890624f, -0.23195545f, -0.10541958f, -0.02569438f, 0.05724937f, 0.09706149f, 0.03701802f, 
    -0.04354387f, -0.10124206f, 0.03496903f, 0.12458917f, -0.08096711f, -0.17063545f, -0.09629677f, 0.08045688f, 
    0.16739868f, 0.08646508f, 0.17822114f, -0.03871541f, -0.15343708f, 0.09371205f, 0.13690053f, 0.19828977f, 
    -0.10624252f, 0.04188398f, 0.27663088f, 0.09821243f, -0.01408210f, -0.04311999f, -0.03615338f, 0.05601165f, 
    0.04546947f, -0.08026818f, 0.02180978f, 0.02757897f, -0.30718449f, 0.15042046f, -0.01124395f, -0.12980372f, 
    -0.16763806f, -0.04944678f, 0.04268827f, -0.04352403f, 0.01960262f, 0.07776018f, 0.07199406f, 0.04310363f, 
    0.14972633f, 0.08143020f, -0.16887186f, -0.04145247f, -0.15956204f, -0.19479452f, 0.08208601f, 0.05011436f, 
    0.00192875f, 0.03215101f, -0.15572616f, -0.14976634f, 0.22370115f, 0.02171602f, 0.01580419f, -0.01174830f, 
    -0.09243865f, 0.07961217f, -0.09062357f, -0.01917535f, -0.07901334f, -0.06637238f, -0.18377011f, -0.20509535f, 
    0.00118400f, 0.19760424f, 0.02238199f, 0.36730215f, -0.00821271f, -0.07128730f, 0.03727710f, -0.04436197f, 
    0.02074732f, 0.10949665f, 0.11976825f, 0.19518538f, -0.29279524f, 0.13771068f, -0.50478560f, -0.04692901f, 
    -0.00158053f, -0.13045156f, -0.02694399f, 0.08229072f, 0.06449103f, 0.15348229f, -0.10360822f, -0.09951208f, 
    -0.47193077f, -0.01630059f, 0.10478607f, 0.00698916f, 0.01226409f, -0.10412391f, -0.01495846f, 0.05166769f, 
    0.01323669f, 0.16241568f, 0.01100995f, 0.02035570f, -0.17463951f, -0.30696696f, -0.01001120f, 0.05340770f, 
    -0.03111740f, 0.02165844f, 0.21462777f, -0.21742751f, 0.17325124f, -0.02076950f, -0.08210044f, 0.07863051f, 
    -0.16628584f, -0.04915432f, -0.24770644f, -0.16126592f, 0.01969052f, -0.11229734f, 0.00610261f, 0.18672560f, 
    0.10115040f, 0.24405406f, 0.04931011f, 0.14510208f, -0.02471113f, -0.04634650f, 0.04356172f, -0.00629664f, 
    -0.03789010f, 0.01325291f, 0.22894056f, 0.07723805f, 0.24133505f, 0.10401969f, 0.12620869f, 0.17195730f, 
    0.27627105f, -0.50698560f, -0.14840338f, -0.35455549f, 0.07325830f, 0.03165179f, 0.05666031f, 0.15458016f, 
    0.03789483f, 0.10411386f, 0.05169393f, 0.05345766f, -0.09386739f, 0.12937732f, 0.17542735f, -0.52081645f, 
    0.09277194f, -0.13515538f, -0.16873609f, -0.03271852f, 0.04387197f, -0.02188779f, -0.02671226f, 0.02599534f, 
    -0.26148590f, -0.17360616f, -0.42433080f, -0.02277173f, 0.25639963f, 0.06061387f, 0.02363862f, -0.01989854f, 
    0.00874701f, -0.00266151f, 0.01008861f, -0.04919400f, 0.25493658f, -0.27807921f, -0.19846489f, -0.02986622f, 
    -0.06201460f, -0.01791411f, 0.21986125f, 0.09385780f, -0.15712495f, -0.00172140f, 0.02631625f, -0.02679733f, 
    -0.11211246f, 0.02908243f, 0.08544561f, -0.05847405f, -0.01144230f, -0.00998966f, 0.18710268f, -0.05334476f, 
    0.13448031f, 0.23893222f, 0.01272825f, 0.10420301f, -0.02573245f, -0.07516961f, -0.12701158f, -0.19450089f, 
    -0.08349261f, 0.11244919f, -0.08810432f, -0.00976123f, -0.06677413f, -0.11798348f, -0.11703561f, -0.10558920f, 
    0.46245381f, 0.26616803f, -0.08087954f, 0.08899447f, -0.01482742f, -0.00904349f, 0.18840154f, 0.08523164f, 
    0.11681204f, 0.07172574f, -0.04406440f, 0.18838206f, 0.34689724f, 0.19273873f, 0.09204623f, 0.18693109f, 
    0.06284340f, -0.01101178f, 0.10662415f, -0.03644520f, -0.11429983f, 0.00361029f, 0.03147279f, -0.04370023f, 
    0.07057675f, -0.08481562f, 0.22021009f, 0.27399462f, 0.01927639f, -0.01970118f, -0.02912452f, 0.00604926f, 
    0.08056735f, 0.10353145f, 0.10211866f, 0.07413567f, -0.07726407f, 0.09450337f, -0.15470414f, -0.06900708f, 
    0.18376964f, -0.04510302f, 0.06321464f, 0.01526854f, 0.12407689f, 0.04013630f, 0.01477096f, 0.16121440f, 
    0.21409689f, -0.15865639f, 0.28402251f, 0.04374605f, 0.09740155f, -0.05347058f, -0.01643587f, -0.10930789f, 
    0.07513251f, 0.11162819f, 0.11341833f, 0.07652513f, 0.17848033f, 0.19598368f, -0.03769445f, -0.02330131f, 
    -0.12114745f, -0.10422368f, -0.13133693f, 0.04917291f, 0.06223776f, 0.07169311f, -0.01141927f, 0.09920792f, 
    0.07122023f, -0.16776657f, 0.21063046f, 0.05571523f, 0.02786999f, -0.06706800f, -0.00851706f, 0.04277529f, 
    -0.09476181f, -0.05974788f, 0.05266437f, 0.10826004f, -0.02285773f, -0.08502672f, 0.10894696f, 0.06119730f, 
    0.10487777f, 0.12056509f, 0.01482360f, 0.28414106f, -0.19397673f, -0.03219667f, -0.08881219f, 0.11519666f, 
    -0.04174109f, -0.14065531f, 0.32644105f, 0.01775471f, 0.10054413f, 0.01641666f, 0.08440799f, -0.11411896f, 
    0.09660828f, -0.04838695f, 0.00574318f, -0.07830058f, 0.20772785f, -0.04336525f, -0.16425297f, 0.07232916f, 
    0.02627945f, -0.01792053f, 0.02690923f, -0.06765652f, 0.05825603f, 0.09276422f, -0.03195363f, 0.09637950f, 
    -0.35906506f, -0.18638276f, 0.03026981f, -0.10486466f, -0.05056684f, -0.02428505f, -0.03194767f, -0.01058092f, 
    0.01068725f, -0.00844411f, 0.06772595f, -0.04081381f, -0.27386945f, -0.08161000f, 0.27967960f, -0.37696585f, 
    -0.03329245f, 0.10292164f, 0.08149874f, -0.00353115f, 0.04081340f, 0.08426877f, 0.02154325f, -0.03066324f, 
    -0.14425819f, 0.07208744f, 0.16882960f, 0.11736105f, -0.11004169f, 0.01365682f, -0.12056118f, -0.00316161f, 
    0.13034895f, 0.11747899f, 0.11323009f, 0.11271596f, -0.07373991f, -0.06431279f, -0.00212807f, 0.17643112f, 
    0.06090932f, -0.10319494f, 0.11809161f, -0.04182123f, 0.00520541f, 0.02580984f, -0.04941706f, 0.15696114f, 
    0.21066159f, 0.17015089f, -0.21309716f, 0.00800307f, 0.10278605f, -0.15263873f, -0.06502654f, -0.02648292f, 
    0.05574650f, 0.05778203f, -0.06454021f, 0.19602473f, -0.28584439f, 0.09411061f, 0.13595332f, -0.27598375f, 
    0.01413555f, 0.08366374f, -0.11138310f, 0.09281936f, 0.10985605f, 0.16437198f, -0.06140572f, 0.04381444f, 
    0.06410845f, 0.08353413f, 0.18452090f, -0.07223011f, 0.04908910f, 0.05974630f, 0.11716364f, -0.08455475f, 
    0.09713627f, -0.02094729f, 0.05212450f, 0.01965049f, 0.00289011f, -0.00308818f, -0.06956668f, 0.03945782f, 
    0.11552154f, 0.12434293f, -0.03923132f, -0.09124997f, -0.04164835f, -0.03051088f, -0.15868047f, -0.09294470f, 
    0.06274427f, -0.07165494f, -0.04256510f, 0.06298985f, 0.07030626f, 0.06189809f, -0.03720917f, 0.03856896f, 
    -0.07240395f, 0.29043445f, -0.02917067f, -0.00048202f, -0.25301233f, -0.08434185f, -0.12833202f, -0.07680632f, 
    -0.08199739f, -0.00822756f, -0.03025711f, -0.07312739f, -0.10487625f, 0.02687735f, -0.05609901f, -0.18123236f, 
    0.09644341f, -0.08068702f, -0.36083317f, -0.10250872f, 0.05666439f, -0.07786645f, -0.04463309f, -0.08904929f, 
    -0.14609790f, -0.04239335f, -0.15663669f, -0.02071924f, 0.13240744f, -0.01722916f, 0.14384285f, 0.19431463f, 
    0.15062527f, 0.01184609f, 0.02906555f, 0.08635101f, 0.18240936f, -0.00479413f, 0.09041477f, 0.09978954f, 
    0.00900932f, 0.18570448f, -0.07851696f, 0.13839221f, 0.16214867f, 0.12238432f, 0.06002130f, 0.08373020f, 
    0.11236305f, -0.03496642f, 0.15785238f, 0.01859906f, -0.08268903f, 0.12720928f, 0.11727182f, -0.11142049f, 
    -0.00481000f, 0.01442522f, 0.10095264f, 0.03552392f, 0.02876603f, -0.07586173f, -0.02269056f, -0.18958557f, 
    0.04660904f, 0.19095966f, -0.19576141f, 0.12506627f, 0.00026509f, -0.11693837f, -0.08203045f, 0.07807835f, 
    -0.09254722f, 0.00264872f, 0.06004970f, 0.20259772f, -0.12795329f, 0.14816982f, 0.15695021f, 0.11462683f, 
    0.09416649f, 0.13210590f, 0.01543751f, -0.05081806f, 0.16776869f, 0.13887556f, 0.13380362f, 0.32702509f, 
    0.17391731f, 0.34509048f, 0.10755229f, 0.18200713f, 0.17661135f, -0.01253437f, -0.01481911f, -0.09408459f, 
    0.00703859f, 0.08037727f, -0.10923722f, 0.37088311f, 0.17138907f, -0.04549272f, 0.12045287f, 0.39203680f, 
    -0.02519326f, 0.04280298f, 0.02044142f, -0.07501944f, 0.20094472f, 0.09539165f, 0.00891205f, 0.05672917f, 
    0.15614206f, 0.14010793f, -0.01170523f, -0.03654696f, 0.10400071f, -0.06486015f, 0.18784079f, -0.08235406f, 
    0.08418306f, 0.02264800f, 0.00490775f, -0.16297403f, 0.22457922f, 0.25725299f, 0.20228831f, 0.20123112f, 
    -0.17579702f, 0.13446398f, -0.02454198f, 0.11839546f, -0.01683946f, 0.03105045f, 0.08267328f, -0.01440957f, 
    -0.47042283f, -0.42044175f, 0.22378922f, -0.04211177f, -0.05644509f, 0.10711492f, -0.25657487f, -0.28866452f, 
    0.06984077f, -0.12151706f, 0.16962638f, -0.08074959f, 0.20250802f, 0.16966775f, 0.07166023f, 0.22389556f, 
    -0.00287435f, -0.15529910f, 0.10219507f, 0.07644027f, -0.03525895f, -0.18429299f, -0.17038229f, -0.18835755f, 
    -0.27726105f, -0.06454583f, -0.20873921f, -0.07210130f, -0.04343174f, 0.00244207f, -0.13470359f, -0.09818017f, 
    -0.07948881f, 0.14424257f, -0.08525625f, 0.24249069f, -0.24835229f, -0.21378012f, 0.17092927f, -0.02412166f, 
    0.07819212f, -0.06730826f, -0.23798420f, -0.08499986f, 0.00886824f, -0.28651452f, 0.07037533f, -0.07473127f, 
    -0.19990306f, -0.00800512f, -0.20750058f, 0.17510638f, 0.07076429f, -0.01840170f, -0.06082335f, -0.10752187f, 
    0.17694677f, -0.03736542f, 0.15421069f, 0.11580194f, -0.19415526f, -0.06246115f, -0.13379221f, 0.01370898f, 
    0.16598813f, 0.09982126f, 0.02219549f, 0.00413103f, 0.17664599f, 0.10444528f, 0.20595445f, -0.09755778f, 
    -0.16080543f, -0.19069462f, -0.06265076f, -0.22445048f, 0.05827193f, -0.02995783f, 0.01537523f, -0.16302297f, 
    0.07766193f, 0.11505084f, 0.05530357f, 0.16956563f, 0.16574793f, 0.16112800f, -0.10042868f, 0.19053449f, 
    0.11569920f, 0.21530162f, -0.07220993f, 0.04201068f, 0.06324989f, -0.11003214f, -0.16769399f, -0.03590906f, 
    0.11397418f, 0.10450088f, 0.13331310f, 0.01373703f, 0.12398857f, -0.07866897f, 0.03405866f, 0.01353474f, 
    -0.01365422f, 0.05079810f, 0.13819844f, 0.16637409f, 0.09227354f, 0.04749405f, 0.07863625f, 0.21218804f, 
    0.04465569f, 0.02566711f, -0.05026680f, 0.02034358f, -0.17810175f, 0.01625853f, 0.01269196f, -0.17050327f, 
    0.04115807f, 0.14291604f, 0.11745814f, 0.12404110f, -0.02407168f, 0.05846543f, 0.05347991f, 0.09363556f, 
    -0.07609228f, -0.15026043f, -0.03514496f, 0.09337582f, 0.00097241f, -0.11568113f, -0.07497007f, -0.09994101f, 
    0.12377239f, -0.07196072f, -0.02736513f, 0.15783848f, 0.15596229f, -0.09366869f, 0.11060362f, -0.11455412f, 
    -0.23849668f, 0.05568947f, 0.06617414f, 0.05280022f, -0.00323095f, 0.08205215f, -0.04308591f, -0.00500858f, 
    -0.17890678f, 0.01281627f, 0.12027901f, 0.02838713f, -0.02613028f, 0.04316817f, 0.24307612f, 0.00276294f, 
    0.05036506f, -0.09282732f, 0.00783440f, -0.04981992f, -0.11383492f, 0.17688566f, -0.05225359f, -0.03516813f, 
    -0.17443120f, 0.34737870f, -0.26422587f, 0.26150030f, 0.24352686f, 0.20918591f, -0.03089709f, 0.15752977f, 
    0.05393796f, 0.01915205f, -0.07010163f, 0.16928293f, 0.11781418f, 0.06609557f, 0.19314824f, 0.22128417f, 
    -0.04405055f, -0.09875530f, 0.18495993f, 0.11210949f, -0.00899240f, 0.04112984f, -0.16548856f, -0.01361629f, 
    0.16503358f, -0.06883726f, 0.01981222f, 0.17799062f, 0.00508214f, -0.08612853f, -0.18343550f, 0.08203606f, 
    0.04525588f, 0.04821778f, 0.06125908f, -0.01802967f, 0.25354525f, 0.24221799f, 0.11378220f, -0.08778396f, 
    0.10706001f, 0.15895477f, -0.01120792f, 0.07021370f, 0.20059510f, -0.08539905f, 0.06644364f, -0.06897721f, 
    0.03606327f, 0.02470875f, 0.00575840f, 0.07464070f, -0.13192713f, 0.01339387f, -0.02717401f, -0.01683346f, 
    0.14842419f, -0.05828242f, -0.00369949f, -0.01154582f, -0.07922938f, -0.02537562f, 0.14726555f, -0.04942412f, 
    0.15082279f, 0.04474057f, 0.02507105f, 0.16344644f, 0.04919071f, -0.01684054f, 0.06117053f, 0.10058659f, 
    -0.04276431f, -0.04876046f, 0.00893655f, 0.03526964f, 0.04726838f, 0.04202128f, -0.03511577f, 0.02379932f, 
    0.06278441f, 0.04280373f, -0.01115543f, 0.01690792f, -0.08080915f, -0.06665733f, 0.05807349f, -0.02974814f, 
    0.01161189f, -0.04659823f, -0.02753836f, -0.00021275f, -0.00579851f, 0.02026482f, -0.02170880f, 0.00434946f, 
    0.00042394f, 0.05416963f, 0.04559432f, 0.03256547f, -0.06870355f, -0.02688806f, -0.03768490f, -0.05353398f, 
    -0.03035804f, 0.00762171f, -0.05927470f, -0.06296395f, -0.02768681f, -0.01476911f, -0.03239485f, -0.01811553f, 
    -0.01385200f, -0.02892452f, 0.05287658f, 0.03748397f, -0.07526798f, 0.04737918f, -0.05286023f, 0.04886989f, 
    0.06441668f, 0.03624946f, -0.01488030f, 0.00104031f, 0.05412617f, -0.06248304f, -0.00542010f, -0.03534563f, 
    -0.06768709f, -0.05293797f, -0.01590847f, 0.01787630f, -0.01119240f, 0.00048204f, 0.01398377f, 0.01522851f, 
    -0.05670714f, -0.04442183f, 0.01308709f, 0.00313705f, -0.02269011f, 0.01379033f, 0.03444047f, -0.04707195f, 
    -0.06988621f, 0.03351593f, 0.06078984f, -0.00261840f, -0.07413299f, -0.03335780f, 0.04118140f, -0.04471106f, 
    -0.07695491f, -0.05202948f, -0.04727060f, 0.04308239f, -0.01723529f, -0.00087001f, -0.07486665f, 0.01775956f, 
    0.02440540f, 0.01452579f, -0.00856096f, 0.00918298f, -0.04383252f, 0.04994572f, -0.01327191f, -0.00961029f, 
    0.05095555f, 0.04216311f, 0.01439032f, -0.04895855f, -0.01181759f, -0.07437011f, 0.02700757f, 0.04485384f, 
    -0.04663007f, 0.00267764f, 0.01277139f, -0.03746145f, -0.05975322f, 0.06083381f, -0.00209673f, -0.05121075f, 
    -0.01863767f, -0.07286385f, 0.04975381f, 0.02833448f, -0.01431951f, 0.03269178f, -0.04877388f, 0.04753292f, 
    -0.03156346f, 0.00164950f, -0.00119397f, 0.06122612f, -0.01850447f, -0.01632647f, -0.05510073f, -0.00323699f, 
    -0.06304783f, -0.06661835f, -0.03993694f, -0.04364582f, 0.05609008f, 0.01474977f, 0.00991109f, 0.04280902f, 
    0.05196954f, -0.05120017f, -0.07556993f, -0.06426732f, -0.01137306f, -0.01503862f, 0.04345420f, 0.00053934f, 
    0.02289990f, -0.03624129f, -0.07335016f, 0.05162125f, -0.02187586f, -0.07080583f, -0.00843965f, 0.02862512f, 
    -0.05113464f, -0.05685296f, -0.05174906f, 0.04771668f, -0.03357395f, 0.06455097f, 0.05435107f, 0.01676423f, 
    0.02503951f, -0.02281949f, 0.01639060f, -0.01457627f, 0.02956240f, 0.04012412f, -0.05023115f, -0.01046470f, 
    -0.00631238f, -0.00863298f, -0.06452075f, -0.07799663f, 0.02649100f, -0.02893496f, -0.05177837f, -0.01958610f, 
    0.04396557f, -0.03314628f, -0.06807689f, -0.02342176f, -0.00812530f, 0.04895132f, -0.06583452f, -0.05628751f, 
    -0.01564794f, 0.05988259f, -0.02491942f, -0.07907338f, 0.05799891f, -0.01902694f, -0.06271777f, 0.03530847f, 
    0.16854168f, 0.21228682f, -0.09063241f, -0.22620940f, -0.14608830f, -0.10851354f, -0.15053861f, 0.00075821f, 
    0.15008746f, -0.46137297f, -0.17881839f, -0.01848798f, 0.06728787f, -0.01744466f, 0.07824466f, -0.13739085f, 
    -0.12115071f, 0.15849774f, -0.08814663f, 0.01729980f, 0.18180272f, 0.08253679f, 0.32827705f, 0.03097640f, 
    -0.05665072f, 0.22994389f, 0.06406406f, 0.09968463f, -0.12386101f, -0.14164302f, 0.06784487f, -0.00592647f, 
    0.00757341f, 0.00115945f, -0.10348738f, 0.02542901f, 0.19016635f, 0.26544470f, 0.16073869f, 0.26702923f, 
    0.08544314f, -0.04805829f, 0.10258916f, 0.12238865f, 0.07375401f, -0.05965532f, -0.00516791f, -0.13074282f, 
    -0.27250609f, -0.04236577f, 0.21032670f, -0.03263238f, -0.11153999f, 0.11241603f, -0.02346739f, 0.01108241f, 
    -0.15256664f, 0.07366102f, -0.06736413f, 0.00109262f, -0.04921289f, 0.05872371f, 0.12685812f, 0.10038858f, 
    -0.07785355f, 0.17873633f, -0.01086361f, 0.07236712f, -0.02095749f, -0.01536460f, 0.10807081f, -0.02339134f, 
    -0.27261025f, 0.01237561f, 0.23374273f, 0.09884986f, 0.16721679f, 0.12994336f, 0.00718037f, 0.01129508f, 
    0.00010260f, -0.18935259f, 0.15330756f, 0.17595440f, 0.22326007f, -0.06276411f, -0.01372019f, -0.06822233f, 
    -0.07414283f, -0.03761845f, 0.03477182f, -0.28280595f, -0.09326266f, -0.17409375f, 0.02164718f, -0.12325963f, 
    0.07149880f, 0.14071800f, 0.02582938f, -0.16499175f, -0.01151770f, -0.11131620f, 0.10769390f, 0.08291000f, 
    0.07479376f, -0.14812124f, -0.04107090f, -0.17439747f, 0.00568028f, 0.16813296f, 0.31880993f, 0.14637868f, 
    0.08931318f, -0.05022635f, 0.04625129f, 0.02489689f, -0.00793810f, -0.05444175f, -0.07212263f, -0.10116319f, 
    -0.20310302f, -0.30937615f, 0.02286198f, 0.24378440f, 0.00156420f, 0.04509153f, -0.14413223f, 0.13750072f, 
    0.10499180f, 0.15979466f, -0.07562787f, 0.09762429f, -0.16837347f, -0.13061409f, 0.08698361f, 0.20723024f, 
    0.16939172f, -0.09393895f, 0.00776105f, 0.04660255f, -0.06666825f, -0.02253869f, -0.05855317f, 0.05223743f, 
    -0.11391939f, -0.24660218f, 0.12214706f, -0.01572154f, 0.04530991f, -0.07489233f, 0.01899140f, 0.02283629f, 
    0.10335473f, 0.26547480f, -0.03474342f, 0.01369358f, 0.17001247f, 0.05028656f, 0.26864210f, 0.09553452f, 
    -0.09020159f, 0.24163067f, 0.21970297f, 0.17130843f, 0.24024391f, -0.03105557f, 0.14327075f, 0.07582060f, 
    0.55883986f, 0.01277736f, 0.08069874f, 0.19412641f, 0.02216182f, -0.02291434f, 0.06098396f, 0.00494472f, 
    0.13205522f, -0.20451227f, -0.02000611f, -0.11945970f, 0.22322924f, 0.10209559f, 0.05833798f, 0.19777933f, 
    -0.19259311f, -0.07878464f, -0.00342851f, 0.05683820f, 0.14627309f, 0.00010266f, -0.10930540f, 0.02464430f, 
    0.07776649f, 0.11361154f, 0.21994738f, 0.02844422f, -0.04284543f, -0.12578768f, -0.04008636f, -0.11180068f, 
    0.05875770f, -0.07181326f, -0.03943459f, 0.10228274f, 0.05648743f, 0.16396092f, 0.07252092f, -0.00693979f, 
    -0.01729296f, 0.03944557f, 0.00979578f, 0.05606303f, 0.02953745f, 0.02232360f, 0.24026583f, 0.04744479f, 
    0.33204785f, 0.19906513f, 0.33879155f, 0.17140228f, -0.02158663f, -0.02444544f, 0.05239975f, -0.14930347f, 
    0.04337123f, 0.11011539f, -0.02218728f, 0.09262747f, 0.21253152f, 0.11693387f, 0.04205498f, 0.19064417f, 
    -0.02262905f, -0.12613955f, -0.06316569f, 0.26936018f, -0.01931760f, 0.02619128f, -0.13486122f, -0.13998075f, 
    -0.23508261f, -0.03878685f, 0.02601395f, -0.03145963f, -0.02110021f, 0.05049338f, -0.07350858f, 0.03564309f, 
    -0.08251207f, 0.02033473f, -0.06327313f, -0.03042193f, -0.15952428f, 0.01984810f, 0.06031475f, 0.10270265f, 
    -0.00084679f, 0.03709548f, -0.01197908f, 0.13794920f, -0.04623898f, 0.02767782f, 0.04342474f, -0.17630416f, 
    -0.24666716f, -0.18088757f, 0.06169070f, 0.11214157f, 0.11738312f, 0.09353232f, 0.01949709f, -0.03780620f, 
    -0.05753273f, -0.10233829f, -0.00036392f, 0.06494539f, 0.12771115f, -0.07018308f, -0.14502148f, -0.09388856f, 
    -0.16325963f, -0.06141957f, 0.04202307f, -0.08466545f, 0.16862172f, 0.03010335f, 0.07773707f, 0.10709067f, 
    -0.25340772f, 0.16683406f, 0.33916593f, 0.09410769f, -0.00158020f, 0.00008835f, 0.01181553f, -0.03042340f, 
    -0.02013381f, -0.09354777f, 0.01540802f, -0.11908951f, -0.16490327f, 0.01906741f, 0.24588674f, 0.07093289f, 
    -0.08042905f, -0.03489231f, 0.10340434f, -0.08906084f, -0.06317031f, -0.00379650f, -0.01097987f, -0.05954308f, 
    -0.00332268f, -0.03135744f, 0.35938230f, 0.19837885f, -0.10236948f, -0.00186485f, -0.30744386f, 0.14102727f, 
    -0.00661329f, 0.05143636f, 0.04706642f, 0.08139908f, -0.08631222f, -0.37080261f, 0.08362364f, 0.12458485f, 
    0.01445318f, -0.10724097f, -0.01627666f, -0.06449708f, -0.01658193f, -0.06602201f, -0.08439555f, 0.03599441f, 
    -0.23807652f, 0.25099611f, -0.26402649f, 0.04147094f, -0.04764200f, -0.05012843f, 0.19238326f, -0.11599045f, 
    0.12806064f, 0.01646515f, 0.01637788f, -0.06072379f, 0.13952060f, -0.02051224f, 0.16828538f, 0.08410289f, 
    0.04889240f, 0.10533652f, 0.07368546f, 0.13278107f, 0.07649682f, 0.11040565f, 0.06480400f, 0.00327967f, 
    -0.03253596f, 0.11434831f, 0.26446316f, 0.00674812f, -0.05231443f, -0.01481387f, -0.06514616f, -0.17845471f, 
    0.11562414f, -0.04033592f, 0.08832591f, 0.02108085f, 0.07435928f, 0.18616158f, -0.23166810f, 0.15266471f, 
    -0.15899993f, 0.09689937f, 0.13383870f, -0.02542932f, 0.14580713f, 0.21797827f, -0.02390130f, 0.08160696f, 
    0.28871647f, -0.22447781f, 0.10329105f, -0.11924267f, -0.23479708f, -0.15175517f, 0.02343441f, 0.01996561f, 
    0.00131810f, 0.07578459f, -0.04237160f, -0.02737535f, 0.15597828f, 0.08983393f, 0.05952520f, 0.01876119f, 
    -0.00841665f, 0.00945188f, -0.03974028f, 0.01933209f, 0.08747416f, -0.07946286f, -0.08073089f, -0.09700948f, 
    -0.04818133f, 0.01754468f, 0.18032405f, 0.33738768f, -0.06883072f, -0.07134195f, -0.09577440f, 0.00505268f, 
    -0.06007674f, 0.16454661f, 0.14003687f, 0.08380290f, 0.16366044f, 0.07989759f, 0.28980190f, -0.21007593f, 
    -0.08844852f, -0.10252216f, 0.06426493f, 0.05213636f, -0.00021901f, 0.03503900f, -0.05506713f, -0.06231518f, 
    -0.22788040f, -0.12419102f, 0.23255946f, 0.11056493f, -0.03036111f, -0.06082038f, -0.02831693f, 0.01422742f, 
    0.00052078f, 0.06618139f, -0.03455559f, 0.06146065f, -0.08744669f, -0.12989555f, -0.19009766f, -0.12642016f, 
    -0.05324086f, 0.06715853f, 0.15220705f, 0.11196131f, 0.08177912f, 0.04798450f, -0.15595253f, 0.13049252f, 
    -0.11574698f, -0.10810510f, 0.20213327f, -0.18631753f, 0.04503222f, -0.09623559f, 0.05016745f, -0.00665552f, 
    -0.03346851f, -0.05423181f, -0.00651256f, 0.16292624f, 0.02771374f, -0.03337914f, -0.19776496f, 0.10052066f, 
    0.00702955f, 0.17552963f, 0.03172618f, 0.00405845f, 0.06714482f, 0.03589698f, 0.06400453f, 0.19336702f, 
    0.25074774f, 0.09037168f, 0.23146400f, -0.24247697f, 0.02335497f, 0.06987753f, 0.18495290f, 0.03304364f, 
    -0.01160320f, 0.05428705f, 0.00834256f, 0.04751344f, -0.07764366f, 0.12762468f, 0.33072749f, -0.17701332f, 
    -0.06078156f, 0.07109430f, -0.05742002f, -0.00650686f, -0.04645725f, -0.09625534f, 0.08253121f, 0.01136729f, 
    -0.13740031f, -0.55521536f, 0.12005187f, 0.13349850f, 0.09541643f, -0.08564466f, 0.04063927f, 0.01631651f, 
    0.13102116f, 0.04498097f, 0.07228275f, 0.14831869f, -0.15111348f, 0.14434943f, 0.02994922f, -0.02654479f, 
    -0.17368717f, 0.08978025f, 0.06883297f, 0.05810631f, -0.07017856f, 0.02100106f, 0.06874930f, -0.01365589f, 
    -0.24526982f, 0.12110866f, -0.02733731f, -0.05705578f, 0.07107330f, -0.08254085f, -0.04950855f, -0.02307562f, 
    0.15919890f, 0.06632695f, -0.00667847f, -0.09550455f, -0.15792365f, -0.05123024f, -0.04286713f, -0.13301557f, 
    -0.06261321f, 0.03253504f, -0.10837248f, -0.01300405f, 0.05757135f, -0.08552920f, -0.13337214f, -0.07304446f, 
    0.34702238f, 0.02851127f, -0.27744308f, -0.39479882f, 0.05553353f, 0.13028193f, 0.02535396f, -0.09576765f, 
    0.05360101f, 0.03849188f, 0.08674686f, 0.02792438f, 0.26240069f, 0.08055577f, -0.12742077f, 0.19692996f, 
    0.12403440f, 0.01559505f, 0.02235699f, -0.02363822f, 0.00177144f, -0.05096819f, 0.00437430f, -0.00773920f, 
    0.01214330f, -0.02714763f, -0.26067856f, 0.05439298f, -0.06831408f, 0.05649780f, 0.13579896f, 0.05867082f, 
    0.01275007f, 0.14601596f, 0.03508741f, 0.20406342f, 0.07182688f, -0.12629075f, -0.04845845f, -0.16231340f, 
    -0.04919344f, -0.08112785f, -0.08524326f, 0.11251955f, -0.03069843f, -0.00554142f, -0.09455163f, -0.10365421f, 
    -0.51218283f, 0.08866440f, -0.40163136f, 0.51538110f, 0.09899306f, -0.01285260f, 0.02088924f, 0.03855210f, 
    0.00776082f, -0.11203450f, -0.07414912f, -0.01588264f, -0.05620064f, 0.03775352f, 0.23058063f, -0.10805517f, 
    -0.07397122f, -0.24328229f, 0.08712450f, -0.10456676f, 0.14167394f, -0.05953372f, -0.03477785f, 0.11434257f, 
    0.02960887f, -0.22342689f, 0.29833114f, 0.05372301f, -0.07929841f, 0.01589119f, -0.10079407f, 0.05036795f, 
    -0.02849326f, 0.11842113f, 0.24189138f, 0.09971680f, 0.01914904f, -0.08690738f, 0.08028769f, -0.14039549f, 
    0.05257924f, -0.07308596f, -0.00390254f, 0.07050841f, -0.16113803f, 0.14054456f, -0.02589806f, 0.07882179f, 
    -0.13007940f, -0.11492106f, 0.14608981f, -0.16581722f, -0.13647451f, -0.04140832f, -0.12845877f, 0.00328481f, 
    0.04521506f, -0.06584857f, 0.26405928f, 0.12398742f, 0.15573372f, -0.07927690f, -0.00394047f, 0.02986084f, 
    0.08537883f, 0.00672280f, -0.04675973f, 0.04436228f, -0.05071328f, 0.09098060f, 0.02961181f, -0.02777962f, 
    0.04638128f, 0.36781466f, 0.08836135f, -0.12538379f, -0.15277949f, -0.03059623f, 0.02509122f, -0.04014381f, 
    0.04845838f, -0.05104367f, -0.00840410f, 0.00310217f, 0.08947650f, 0.19187023f, 0.23583934f, -0.02792336f, 
    -0.05774211f, 0.01676797f, -0.04881350f, 0.04918974f, 0.05138506f, 0.15307817f, 0.04378046f, 0.04009648f, 
    -0.40177298f, -0.31205791f, 0.18200485f, 0.28064558f, -0.06916676f, -0.02746980f, 0.13641565f, 0.04125954f, 
    0.00537404f, 0.03841196f, 0.02219052f, -0.09452391f, -0.12426725f, 0.29008311f, 0.02768408f, -0.01703331f, 
    -0.00553943f, -0.15832187f, 0.07409284f, -0.09151300f, -0.01044440f, 0.04161367f, 0.12637958f, -0.02109474f, 
    0.21899873f, -0.33464846f, 0.23106922f, 0.04390923f, 0.04847002f, 0.03444384f, -0.24752925f, 0.07219373f, 
    0.14322194f, 0.12914182f, 0.00584134f, 0.07138131f, -0.11236907f, -0.02426678f, 0.04440802f, -0.16729163f, 
    -0.15017302f, 0.09793113f, -0.24766530f, -0.08336828f, 0.04513991f, -0.08277337f, -0.12033746f, -0.17181623f, 
    0.37975833f, -0.11129922f, -0.16669106f, 0.01018919f, 0.04579391f, 0.00156745f, -0.01059029f, -0.03840628f, 
    -0.10560855f, 0.16266322f, 0.17349446f, -0.15816124f, 0.23494500f, 0.04085795f, 0.15372147f, 0.18357441f, 
    0.16637920f, 0.11450715f, -0.00797609f, 0.14064123f, 0.00965145f, -0.13476251f, 0.06695426f, -0.01516205f, 
    0.34764320f, -0.12640855f, -0.14174171f, -0.26295424f, 0.05702529f, 0.01876418f, 0.02379066f, 0.14591147f, 
    0.10916252f, 0.19102463f, -0.00835226f, -0.12120048f, 0.25466135f, 0.09263852f, -0.03431661f, 0.07241400f, 
    0.07158183f, 0.25868151f, 0.11862630f, 0.00027986f, 0.07649508f, 0.10548064f, 0.11306024f, 0.04465014f, 
    0.14671102f, 0.01949333f, -0.16337383f, -0.10839133f, 0.08505648f, 0.07090750f, 0.14605781f, 0.17342253f, 
    -0.06781284f, 0.04219515f, -0.11812378f, -0.01087613f, 0.16877019f, -0.01865029f, 0.03972125f, 0.10866157f, 
    0.28160322f, 0.25182992f, 0.19174179f, 0.17463690f, -0.02960608f, -0.12421930f, -0.01775532f, -0.00931718f, 
    -0.41567877f, -0.03851902f, -0.10729755f, 0.06698696f, -0.22716470f, 0.05385404f, -0.04988762f, -0.27189612f, 
    0.00108792f, -0.17682594f, -0.09026928f, -0.05501019f, -0.03375048f, 0.03675359f, -0.04577236f, -0.07907792f, 
    -0.42646945f, -0.10301470f, -0.15897925f, -0.09013023f, 0.03940538f, -0.05424117f, 0.02935230f, 0.09499641f, 
    -0.13439767f, -0.02796254f, -0.13760948f, -0.31711921f, -0.09379674f, -0.21416377f, -0.28196391f, -0.08367601f, 
    0.03787705f, -0.04397267f, -0.11861929f, -0.29917797f, 0.07525752f, 0.00447573f, 0.06821692f, 0.08103397f, 
    0.15612429f, 0.07721057f, 0.00750360f, -0.00374609f, 0.01515486f, 0.02366342f, -0.11296798f, 0.10774501f, 
    0.25276980f, 0.20769934f, 0.10823964f, -0.14166316f, 0.14842533f, 0.01991630f, 0.05727270f, -0.14704663f, 
    0.02858962f, 0.13132691f, -0.21782780f, -0.06696245f, 0.00857539f, 0.23054373f, 0.14306217f, 0.15365100f, 
    0.16913909f, 0.14520083f, 0.01458567f, -0.24540910f, 0.03364601f, -0.16184300f, 0.04542348f, -0.01654276f, 
    0.18968558f, 0.05271020f, 0.10684308f, 0.08180413f, 0.10459235f, 0.27636528f, 0.08999045f, -0.14590965f, 
    -0.07381311f, -0.12581351f, -0.02768718f, -0.03793991f, -0.10372820f, 0.10217700f, 0.01910940f, 0.01525856f, 
    -0.20262977f, -0.27371168f, -0.48569340f, -0.33058372f, -0.04010051f, 0.05968140f, -0.02105513f, -0.06754784f, 
    -0.14402133f, -0.03807607f, 0.07652347f, 0.04325492f, -0.05153201f, -0.12764598f, -0.00026052f, 0.21193230f, 
    -0.09199110f, 0.07645988f, -0.02873771f, -0.18837303f, 0.24245037f, 0.27870995f, -0.02969422f, 0.20773494f, 
    -0.08880278f, -0.11332395f, -0.13314089f, -0.03439806f, -0.03927324f, 0.01238443f, 0.05009551f, -0.06560780f, 
    -0.28346261f, -0.24183616f, -0.36613756f, -0.25656024f, 0.04781383f, -0.02751628f, 0.02778880f, -0.12667514f, 
    0.09730431f, 0.09746117f, 0.12073971f, -0.15181930f, -0.05698985f, -0.03429877f, -0.15067771f, 0.02021793f, 
    0.11409966f, 0.10236701f, 0.06934963f, 0.04320046f, 0.19285621f, 0.02874438f, 0.08852106f, 0.05282647f, 
    0.20866299f, -0.06908575f, -0.07922473f, 0.20271985f, -0.07198062f, 0.04053389f, 0.05925347f, -0.00253752f, 
    0.02815820f, 0.22501522f, 0.05462191f, 0.10574915f, -0.05132597f, 0.19838630f, -0.04894029f, 0.02635847f, 
    -0.10532635f, 0.00242335f, -0.06515741f, 0.08337418f, -0.32583863f, -0.05137314f, -0.30488461f, -0.35053775f, 
    0.27644640f, -0.09343994f, -0.07741644f, 0.10656074f, 0.04035116f, -0.09255845f, -0.08689183f, -0.06712594f, 
    -0.06360514f, -0.03106945f, -0.13464177f, -0.02727785f, 0.16867220f, -0.04792496f, 0.15483528f, 0.12576985f, 
    -0.16813964f, -0.23862721f, -0.03737383f, 0.02343080f, 0.14884113f, 0.05461085f, -0.01897460f, 0.03456318f, 
    -0.18996620f, -0.15147962f, 0.04168760f, 0.17906593f, 0.03225493f, -0.03401583f, -0.04863820f, 0.15620311f, 
    0.08299416f, 0.04196025f, 0.07895634f, 0.00536431f, -0.24769782f, -0.05124568f, 0.16586366f, -0.15293731f, 
    0.01917125f, 0.03255820f, 0.15873483f, 0.16092072f, -0.02104829f, 0.00664462f, -0.18053599f, -0.14887124f, 
    -0.12159579f, -0.13784178f, 0.19602534f, 0.18736468f, 0.02612317f, -0.10589193f, -0.05904071f, 0.11800629f, 
    0.14456265f, 0.08253081f, 0.09241615f, 0.09605350f, 0.15941271f, -0.06230634f, -0.10404932f, 0.11062242f, 
    0.00488387f, 0.24500529f, 0.09273039f, 0.04700517f, 0.15706511f, 0.12253504f, 0.22049056f, 0.36422798f, 
    -0.18666260f, 0.11551661f, 0.13484892f, 0.09598623f, -0.05304110f, 0.00258189f, 0.19505884f, -0.04718664f, 
    0.07086664f, 0.05124505f, 0.05566620f, 0.12863825f, -0.06102525f, -0.00565490f, 0.23733598f, -0.03330380f, 
    -0.17088434f, 0.06347810f, 0.11233252f, 0.05041138f, 0.12040009f, 0.05776518f, 0.04142304f, 0.14616601f, 
    0.11989261f, 0.10630390f, 0.21620914f, 0.11673639f, -0.01938668f, 0.00121009f, -0.06335817f, 0.01284376f, 
    0.06168884f, 0.02768674f, 0.05329997f, -0.04827318f, -0.07052504f, -0.11326205f, 0.06773859f, 0.22809906f, 
    -0.00814287f, -0.05415519f, 0.18268862f, 0.06699550f, -0.07927108f, -0.08565038f, -0.06884068f, -0.00413957f, 
    -0.07060493f, 0.03918259f, -0.19888143f, -0.06897356f, 0.06602367f, 0.02630948f, -0.13441129f, -0.08845663f, 
    0.06472690f, 0.09094019f, 0.04135855f, -0.13167192f, -0.20574707f, -0.10679344f, 0.08889312f, 0.07682104f, 
    0.07584390f, -0.15557264f, -0.19514860f, 0.09022587f, 0.03686279f, -0.05457516f, -0.23032460f, -0.22613260f, 
    0.01083132f, 0.02029571f, 0.17085931f, 0.05995585f, 0.07732982f, 0.05368077f, 0.02519402f, -0.02192828f, 
    0.11853418f, 0.07140540f, 0.14561664f, 0.19643839f, 0.17143671f, -0.19118577f, -0.04216800f, 0.02343555f, 
    0.10416541f, 0.20474234f, -0.10583498f, 0.00825513f, -0.05441326f, -0.06122750f, 0.04733642f, -0.22767116f, 
    0.02805563f, 0.04383259f, -0.06256983f, 0.02959261f, 0.00696532f, -0.06642774f, -0.06080283f, -0.07486175f, 
    0.01971389f, -0.00002173f, -0.05588359f, 0.01656337f, -0.03253800f, -0.05873993f, 0.03292083f, -0.01080283f, 
    -0.07000298f, -0.03677115f, 0.01936081f, -0.02718705f, -0.03675129f, -0.07117133f, -0.03858731f, 0.05700631f, 
    -0.04069717f, -0.05109874f, -0.07649839f, 0.01477463f, -0.06584186f, -0.06113473f, 0.06406444f, -0.02503902f, 
    0.05263374f, 0.03828079f, -0.03684669f, -0.07033405f, -0.01557587f, -0.07018544f, 0.00409612f, 0.00639761f, 
    0.00133210f, -0.02691265f, -0.05351773f, -0.01136873f, 0.06563153f, -0.04063560f, -0.07546303f, 0.00128837f, 
    -0.05466925f, 0.05865506f, -0.00946647f, -0.03993672f, 0.03186796f, 0.06441030f, -0.00892613f, -0.00559781f, 
    0.06028481f, 0.04819188f, -0.02358075f, 0.01202338f, -0.03389078f, -0.06545287f, 0.01911469f, -0.07491016f, 
    -0.02823031f, -0.07800975f, -0.02908109f, 0.03474236f, 0.05543378f, 0.03562812f, -0.06281735f, -0.02514142f, 
    0.05431985f, -0.05416419f, 0.04227530f, -0.00870004f, -0.04104546f, -0.07118645f, -0.03154313f, 0.00153426f, 
    -0.01000204f, -0.01517936f, -0.05437326f, -0.05676757f, 0.03214211f, -0.07239461f, -0.07347085f, -0.01878338f, 
    0.00849369f, 0.02138931f, 0.02992687f, -0.00585238f, -0.05349301f, -0.02123177f, -0.07700107f, 0.01573628f, 
    -0.00863036f, 0.04459759f, -0.02877820f, 0.00909311f, 0.02634942f, -0.03033886f, -0.06111090f, -0.05859380f, 
    -0.01077519f, -0.00800277f, 0.02700520f, -0.06750401f, 0.01524740f, 0.03488472f, -0.04859023f, 0.01324233f, 
    -0.05174901f, 0.04579455f, -0.07270455f, 0.04809087f, -0.06753615f, 0.01171225f, 0.03678175f, 0.06169732f, 
    0.03891814f, -0.02556725f, -0.06201994f, 0.03880674f, 0.02347453f, -0.03712736f, -0.03925449f, -0.00576831f, 
    -0.01758035f, 0.02181162f, -0.07491504f, 0.00773749f, -0.07273225f, -0.00858099f, -0.02799132f, -0.04311664f, 
    0.00232900f, 0.03262895f, 0.05534821f, -0.01424106f, 0.06333775f, 0.01054283f, -0.04869242f, -0.00108580f, 
    0.00353227f, -0.04001522f, -0.00130444f, 0.02543388f, 0.05559568f, -0.05029561f, 0.02618245f, 0.04511637f, 
    0.04037113f, 0.00088910f, 0.02841628f, -0.02999287f, -0.00531002f, -0.07351840f, 0.02248604f, -0.05311178f, 
    0.06564245f, -0.03569430f, 0.03867813f, 0.02212387f, -0.01866610f, 0.04279269f, -0.07003971f, 0.00240824f, 
    -0.03427644f, 0.01458478f, -0.06458785f, -0.06863504f, 0.00323641f, -0.04182231f, 0.02932724f, 0.01801928f, 
    -0.01839003f, 0.03240364f, -0.02069039f, -0.03593637f, 0.01857148f, -0.06183207f, -0.06576893f, -0.02293989f, 
    -0.05543678f, 0.00732839f, 0.01193862f, -0.03155226f, 0.05113822f, 0.06451862f, 0.06130114f, -0.05766707f, 
    -0.02932864f, 0.07330692f, 0.13698387f, 0.19259058f, -0.06253280f, -0.02417155f, -0.03837259f, -0.01505169f, 
    0.16049360f, -0.03075058f, 0.02333568f, 0.07015415f, 0.12951957f, -0.01449931f, -0.00458558f, -0.10791343f, 
    -0.09595490f, -0.09749667f, -0.13312995f, -0.14265752f, 0.21495751f, -0.09143485f, 0.04456669f, -0.11311803f, 
    0.15216476f, -0.20655906f, 0.31349814f, -0.05059587f, -0.12633497f, -0.15500100f, -0.06307007f, 0.08119065f, 
    0.03160598f, 0.16539146f, 0.14400478f, 0.20146576f, -0.08021457f, -0.02445128f, 0.06831790f, -0.06100461f, 
    0.14686714f, 0.13930288f, 0.00550449f, 0.00648937f, 0.01347204f, 0.01864828f, -0.06877949f, -0.14524139f, 
    -0.26063347f, 0.11334849f, -0.09062016f, -0.05124158f, -0.03141234f, 0.00089773f, 0.17087175f, 0.03084829f, 
    -0.03921263f, 0.03680884f, 0.14726649f, 0.07891803f, -0.16900085f, 0.07298207f, -0.05968056f, -0.04686942f, 
    0.02065401f, 0.09220247f, -0.00210466f, 0.11410270f, -0.03815061f, 0.13735561f, 0.14411449f, 0.01282158f, 
    -0.17438999f, 0.06004288f, -0.09843919f, 0.09844480f, 0.07385952f, 0.02386032f, 0.07392264f, 0.00902191f, 
    0.06441399f, -0.06792649f, -0.12348647f, -0.02827735f, -0.03403204f, -0.25759926f, -0.12081397f, -0.02209389f, 
    -0.07380880f, -0.00261567f, 0.06419218f, -0.02872960f, 0.13106433f, 0.01998304f, 0.17607127f, -0.10679594f, 
    -0.38605914f, 0.25825599f, 0.14212057f, 0.22653471f, -0.01061111f, 0.05821998f, 0.11578026f, -0.10915984f, 
    0.00891042f, 0.03157094f, 0.11764058f, 0.00223796f, -0.18735182f, -0.13332783f, 0.07182613f, 0.00181574f, 
    -0.05222261f, 0.03518750f, 0.13456559f, 0.03197901f, -0.02979197f, 0.06918782f, 0.06623941f, 0.12010651f, 
    -0.00620838f, 0.42080015f, 0.34585696f, -0.10044387f, -0.01089204f, -0.05021692f, -0.00525282f, 0.14033864f, 
    -0.02167493f, 0.12250628f, 0.00373473f, 0.08241660f, -0.13109517f, -0.26609430f, 0.24125554f, 0.06446726f, 
    -0.01717838f, 0.09463657f, 0.02781603f, -0.08580752f, 0.01277202f, -0.03771102f, -0.03624440f, 0.02822944f, 
    0.09813286f, 0.00931977f, -0.47271529f, 0.15102586f, -0.16456313f, -0.14553258f, 0.21436258f, -0.17404486f, 
    0.16418146f, -0.02535551f, 0.03898280f, -0.11800510f, -0.08989469f, -0.10633168f, 0.21534081f, -0.04107371f, 
    0.14667238f, 0.12732129f, 0.09482861f, -0.08642927f, -0.00221950f, 0.08970314f, -0.07190800f, 0.05281661f, 
    0.18802620f, 0.05735873f, 0.20742284f, -0.02436875f, -0.04722108f, -0.04597542f, -0.05115900f, -0.12408812f, 
    0.28790936f, -0.10542697f, -0.01585149f, 0.03165301f, -0.14267352f, -0.30522949f, -0.09381477f, -0.11060772f, 
    -0.09926607f, 0.02469117f, -0.15171838f, 0.09197988f, 0.15559538f, -0.10083690f, -0.00567683f, 0.02333125f, 
    -0.21791908f, 0.16003098f, -0.19961223f, 0.22106369f, -0.00033637f, -0.00098920f, -0.03539747f, -0.01184352f, 
    0.14687195f, 0.03732871f, -0.08275460f, 0.09366397f, -0.08603675f, -0.08491156f, 0.01104368f, 0.00798074f, 
    -0.06636836f, 0.04276747f, -0.01927385f, 0.03212206f, 0.03574499f, -0.06032619f, -0.05367904f, 0.12109506f, 
    -0.05093075f, 0.14071611f, -0.38121238f, -0.02088731f, 0.00490701f, -0.01251898f, 0.19851328f, 0.15937448f, 
    0.22597989f, 0.06593058f, 0.10886965f, 0.09532238f, -0.42126742f, -0.28195649f, -0.07237042f, -0.12180062f, 
    -0.05872581f, 0.02150696f, 0.08581644f, -0.09688766f, -0.00142796f, -0.02401449f, -0.04630818f, 0.01887400f, 
    0.30846089f, 0.05492425f, -0.21453831f, -0.01942099f, 0.07292458f, 0.01465631f, 0.19174148f, 0.04351499f, 
    0.03487535f, 0.02199418f, -0.02811600f, -0.04626011f, 0.25244665f, 0.24799679f, 0.14930634f, 0.13168357f, 
    0.09588041f, 0.12999663f, -0.01145918f, 0.02284725f, 0.17846738f, 0.07187507f, 0.11993805f, 0.05079303f, 
    0.08686252f, 0.03644479f, -0.18796098f, -0.05181428f, -0.10163687f, -0.02700951f, 0.05120412f, 0.06338090f, 
    0.02123292f, 0.00790191f, 0.03112815f, -0.00201103f, -0.26003817f, 0.05215664f, 0.13786961f, -0.24611787f, 
    -0.02025148f, 0.00013610f, -0.12348764f, 0.05669245f, 0.03381255f, 0.02737871f, -0.04569523f, -0.12880231f, 
    -0.11074027f, 0.05974008f, -0.19055411f, 0.14404136f, 0.06794730f, 0.21269070f, 0.06553502f, -0.07530523f, 
    0.03153344f, -0.04131732f, 0.08519939f, -0.01101543f, 0.01926503f, 0.03243305f, -0.31884533f, 0.27355331f, 
    0.16503820f, 0.13311425f, 0.23849665f, 0.09947746f, -0.03553679f, 0.00941750f, -0.13812077f, -0.16258675f, 
    0.08549087f, 0.10282987f, -0.01097645f, -0.22672103f, -0.12064738f, 0.03859245f, 0.20482792f, 0.10850696f, 
    0.02413027f, 0.01958546f, -0.05107865f, -0.01430475f, -0.02180410f, 0.10171219f, -0.05122881f, -0.27529922f, 
    0.05985451f, 0.05192133f, -0.05393385f, -0.08344154f, -0.04071316f, 0.05166595f, -0.05648969f, -0.06942829f, 
    0.27750137f, -0.17007679f, 0.12512130f, -0.14062765f, -0.00078429f, 0.26159808f, -0.04662522f, 0.23924270f, 
    -0.15334499f, 0.04571617f, 0.05701818f, 0.09727787f, -0.07769027f, -0.24002269f, -0.11093394f, 0.02853843f, 
    0.18817298f, 0.02663356f, 0.07637090f, 0.01968429f, -0.12212077f, 0.00056126f, -0.00546771f, 0.07797741f, 
    0.02743169f, 0.02085389f, 0.02132972f, 0.41311550f, 0.04209696f, 0.11981139f, -0.13820122f, 0.11808056f, 
    -0.00581008f, 0.07964393f, -0.01919485f, 0.18014424f, 0.08673245f, 0.11635192f, 0.35072443f, -0.20231618f, 
    -0.09104942f, -0.10654570f, 0.03370429f, 0.08870406f, -0.10548446f, -0.03200243f, 0.16668481f, 0.15386789f, 
    -0.10443524f, -0.00908399f, 0.14323574f, -0.00589684f, 0.09108705f, 0.13465264f, 0.02981664f, -0.09356634f, 
    0.00688260f, 0.00878180f, -0.09200346f, -0.08867945f, -0.09787456f, -0.02491261f, -0.05724812f, 0.22329319f, 
    0.07175009f, 0.03511790f, -0.02170287f, -0.13994622f, 0.03990272f, -0.13212784f, 0.03021835f, 0.11128676f, 
    0.40023828f, -0.09943476f, 0.36938584f, -0.31792107f, -0.12532657f, -0.02388950f, -0.04469676f, 0.07513371f, 
    0.07563558f, 0.16549830f, 0.27209952f, 0.01405781f, 0.11072860f, -0.07881317f, -0.17872001f, -0.12123892f, 
    0.16693237f, 0.22026452f, 0.03964635f, 0.11662939f, 0.07948425f, -0.03888907f, -0.02391259f, -0.05052474f, 
    0.27016842f, 0.02971855f, -0.03100652f, -0.00684457f, 0.20421216f, -0.02838748f, 0.15682277f, -0.00022797f, 
    0.06262413f, -0.08226606f, 0.02647448f, -0.03888449f, 0.19272619f, 0.13874957f, -0.13084209f, 0.06240929f, 
    0.08613869f, 0.08609679f, -0.03495650f, -0.00462774f, 0.02091496f, 0.04277589f, -0.00281905f, -0.09967624f, 
    0.39851627f, 0.18670115f, 0.08757441f, 0.05408250f, 0.00946344f, 0.03067420f, 0.19409409f, -0.02312638f, 
    -0.06200654f, -0.00490298f, -0.21113497f, -0.02306884f, -0.16300452f, -0.02315859f, 0.15213695f, -0.01222012f, 
    0.06662567f, -0.02171417f, -0.11598764f, 0.15068935f, 0.04039017f, -0.08961467f, 0.05754295f, 0.04066017f, 
    -0.06437287f, -0.17380485f, -0.24565791f, 0.04112744f, 0.10874379f, 0.09697723f, 0.05898535f, 0.07018861f, 
    0.04469447f, 0.02360988f, 0.07656826f, 0.08285610f, 0.04660835f, -0.19864517f, -0.15109736f, 0.02739859f, 
    0.14515382f, -0.01957653f, 0.03504162f, 0.10353751f, -0.15058504f, 0.02787923f, -0.02503341f, 0.01139895f, 
    0.57163614f, 0.05926600f, -0.21299608f, -0.34475726f, 0.04177947f, -0.07701673f, 0.04263692f, -0.01185197f, 
    0.06390450f, -0.04101064f, -0.07915305f, 0.00855990f, 0.08544980f, 0.20365134f, 0.05795762f, -0.06661916f, 
    -0.04748600f, 0.17912214f, -0.09937588f, 0.16299462f, -0.02511278f, -0.10472848f, 0.03309727f, -0.05126110f, 
    0.02089068f, 0.04535137f, 0.03593687f, 0.17524223f, 0.00616506f, 0.11807340f, -0.10597048f, -0.05944671f, 
    -0.11406817f, -0.15964311f, 0.09740106f, -0.02258504f, 0.12573406f, 0.16794431f, -0.10142796f, 0.06518195f, 
    0.21418890f, -0.01244547f, 0.12575214f, -0.04298612f, -0.04763934f, -0.02471922f, -0.05328100f, 0.00931104f, 
    -0.25092354f, 0.20980383f, 0.11873971f, 0.00952998f, 0.01098367f, -0.11738592f, 0.06021283f, 0.04413833f, 
    0.03584747f, 0.02338796f, -0.06059749f, 0.02269371f, -0.19012906f, 0.03198168f, 0.19357790f, 0.08928289f, 
    0.08314602f, -0.09987862f, -0.09456453f, -0.01974114f, -0.00777146f, -0.09862736f, 0.08967318f, -0.00293448f, 
    0.06182605f, 0.15371174f, -0.01523581f, -0.20666386f, 0.00558639f, -0.05998068f, 0.07514998f, 0.02406416f, 
    0.11269601f, -0.31045198f, 0.01084390f, 0.00814829f, -0.05650369f, -0.01720215f, -0.00610728f, -0.04766647f, 
    -0.18303366f, 0.02252049f, -0.01216121f, 0.03748917f, 0.18042563f, -0.06460872f, 0.10476999f, 0.12630063f, 
    -0.23140228f, -0.13038583f, 0.26349711f, 0.02936943f, -0.20748718f, 0.00798442f, -0.13425082f, -0.00633437f, 
    0.23248360f, 0.15536591f, 0.28236350f, 0.09750544f, -0.06415299f, 0.16167141f, 0.04399318f, -0.25562665f, 
    -0.08879800f, 0.12839936f, 0.07353824f, 0.03288628f, -0.05518635f, -0.01397371f, 0.00128623f, -0.10385370f, 
    0.13491267f, 0.01965342f, 0.25190243f, -0.14512785f, 0.03018587f, -0.04273033f, 0.14941548f, 0.09427907f, 
    -0.14990720f, 0.08768058f, -0.17946745f, -0.07123644f, 0.22566323f, 0.08488011f, -0.03556509f, 0.13739526f, 
    0.20716533f, 0.16626699f, -0.14679511f, 0.01022990f, 0.12958542f, 0.06363007f, 0.17627956f, 0.20303634f, 
    0.12299841f, 0.02984613f, 0.19072907f, -0.26477742f, 0.14627293f, 0.06093649f, 0.05762583f, -0.06047536f, 
    -0.03199729f, -0.12619847f, -0.09807031f, 0.01081816f, -0.08011298f, -0.26056424f, -0.03075038f, 0.00626528f, 
    0.07801852f, -0.11561345f, -0.05332638f, -0.05591581f, -0.34002572f, -0.18672127f, -0.08070779f, -0.33331656f, 
    0.26254186f, -0.03388793f, -0.05301380f, -0.13690686f, -0.05849701f, 0.07568681f, -0.06569741f, 0.19123648f, 
    0.07280376f, -0.09568588f, -0.00638119f, -0.14241455f, 0.03386744f, 0.03285870f, -0.00136033f, -0.09076607f, 
    0.19853237f, 0.12284826f, -0.12523615f, 0.13913034f, -0.06364176f, -0.09796118f, -0.01305696f, -0.11712804f, 
    -0.10318830f, -0.34718639f, -0.22907065f, -0.08516031f, -0.06651735f, -0.09366367f, 0.01530484f, 0.07906252f, 
    0.01790222f, 0.01091362f, -0.07503652f, 0.16569445f, -0.05156518f, 0.27795571f, 0.05231453f, -0.14080699f, 
    0.17347609f, 0.10698682f, -0.02068373f, 0.03846163f, 0.07117824f, 0.08730279f, 0.10442460f, -0.02140942f, 
    0.11472163f, -0.06593113f, 0.04836664f, 0.02248161f, -0.00806156f, -0.17520525f, 0.02950323f, 0.10954249f, 
    0.04040480f, 0.11882308f, 0.01630949f, 0.06951538f, -0.05524215f, 0.11759931f, -0.09161889f, -0.08118051f, 
    -0.02634471f, 0.21014488f, 0.14978880f, 0.07655424f, 0.03330151f, 0.10351218f, 0.09253580f, 0.16542467f, 
    0.39803639f, 0.15917395f, -0.14045186f, -0.11669876f, -0.06379900f, 0.06259438f, 0.20311324f, 0.11610512f, 
    0.21089137f, -0.16390772f, 0.01680981f, -0.27915087f, 0.01408054f, 0.13347046f, -0.12124034f, 0.12180670f, 
    -0.08455366f, -0.00840304f, 0.02581368f, -0.05639363f, 0.00293482f, 0.08308939f, -0.08757548f, 0.11344331f, 
    -0.03559637f, 0.05100745f, 0.02069259f, -0.05087897f, 0.02268370f, 0.02238324f, -0.04135513f, -0.03056299f, 
    0.03723741f, 0.02527776f, -0.02253781f, 0.03929621f, -0.04813515f, -0.07367993f, -0.01183338f, -0.05358516f, 
    0.02009743f, -0.04103997f, 0.01747257f, -0.02872710f, -0.01702442f, -0.03264466f, -0.06421757f, -0.04979395f, 
    0.03394169f, 0.01383746f, 0.05794550f, -0.02821747f, 0.05888608f, 0.02562304f, 0.04020931f, 0.00923605f, 
    -0.00248073f, -0.05663539f, 0.01825880f, 0.01598515f, 0.02053328f, -0.02308231f, -0.01346584f, -0.00609126f, 
    -0.02246729f, 0.00462483f, 0.00884805f, -0.02629912f, -0.04205533f, -0.01840063f, -0.07567599f, 0.02827535f, 
    -0.07715724f, 0.01283453f, -0.06009055f, -0.07521488f, -0.01098400f, -0.05712186f, -0.02898356f, 0.04036095f, 
    0.04133629f, -0.03837657f, 0.04744050f, -0.07477690f, -0.00474746f, -0.03937671f, -0.07242867f, -0.06501994f, 
    0.03608532f, -0.04400926f, -0.02521951f, -0.00731063f, -0.04710444f, 0.01921589f, 0.03517761f, 0.00849591f, 
    -0.07503124f, 0.04038958f, -0.00255382f, -0.00077005f, 0.05981849f, -0.00862041f, -0.06492981f, 0.01448838f, 
    0.03271382f, -0.02207643f, 0.05146918f, -0.06883523f, 0.04729151f, -0.06279198f, -0.06911438f, -0.05831853f, 
    -0.02851730f, 0.05190660f, 0.03909811f, -0.07898400f, 0.00480707f, 0.03295647f, -0.02954728f, -0.03097163f, 
    0.04728096f, 0.00673776f, -0.05085646f, 0.03213457f, 0.05211915f, -0.01047175f, -0.00493285f, -0.00429351f, 
    -0.06112512f, 0.02080052f, -0.00091142f, 0.01812632f, -0.07270467f, -0.00894807f, 0.00148376f, 0.01107371f, 
    0.05624766f, -0.01624816f, -0.07817935f, -0.04006696f, -0.04999563f, 0.05198743f, 0.03201975f, -0.00001873f, 
    0.01584295f, -0.06978808f, 0.04890843f, 0.06365899f, -0.04720239f, -0.01248558f, -0.05468479f, 0.04750374f, 
    0.04709776f, 0.05839957f, -0.07167339f, -0.04542719f, 0.02429470f, -0.04008209f, -0.06000530f, 0.02345664f, 
    0.03635214f, 0.05619062f, 0.01917948f, -0.07531514f, 0.02486048f, -0.07037760f, 0.03579605f, -0.06075188f, 
    0.00998698f, 0.03398692f, 0.03765335f, 0.05251263f, -0.00961313f, -0.05558240f, 0.01609568f, 0.02198834f, 
    -0.05155387f, -0.03522391f, 0.04445013f, 0.02072266f, -0.06911606f, 0.04974410f, 0.00367752f, 0.01726423f, 
    -0.06523403f, 0.04215749f, 0.00253214f, -0.07152440f, -0.01320737f, 0.03068241f, -0.02540330f, -0.01547236f, 
    0.03386644f, -0.07171420f, -0.05967205f, 0.02178398f, 0.03663365f, -0.00300399f, -0.07027667f, -0.06371338f, 
    -0.05220808f, -0.07002150f, -0.04975044f, -0.01802834f, 0.00635404f, 0.06158544f, -0.02207101f, -0.04985966f, 
    -0.03206031f, 0.03210475f, 0.03102113f, -0.03745939f, 0.02002405f, -0.00353289f, -0.06072196f, -0.07315572f, 
    -0.04351049f, 0.03447205f, 0.11545632f, -0.04162316f, -0.00540522f, -0.00735909f, -0.07102551f, -0.04765108f, 
    0.10164861f, -0.11709617f, -0.06688473f, -0.23709020f, -0.10446677f, 0.01484903f, -0.00267569f, 0.04811136f, 
    0.02965006f, -0.02375915f, -0.01881870f, -0.01164756f, 0.19515915f, 0.06351466f, 0.20855756f, 0.26984808f, 
    0.29030275f, -0.15918189f, 0.42060491f, -0.29814458f, -0.14070080f, -0.00834421f, -0.11642347f, 0.01406838f, 
    0.16679670f, 0.14744830f, 0.30730596f, 0.18463743f, -0.12608939f, -0.00473103f, -0.28190786f, -0.02437703f, 
    0.08916593f, 0.20989195f, 0.06838139f, 0.12792850f, -0.10659988f, 0.15943165f, 0.02514997f, -0.04874877f, 
    0.21170521f, 0.22611992f, -0.02884763f, -0.08840158f, 0.15782782f, -0.03141687f, 0.08480080f, 0.00777511f, 
    -0.02815191f, -0.02167133f, -0.13558035f, -0.07883951f, 0.14706497f, 0.04187401f, -0.01316322f, 0.24618046f, 
    0.05698000f, 0.17055872f, -0.01240257f, -0.03446435f, 0.17008063f, 0.01979624f, -0.00156380f, 0.01080079f, 
    0.17498694f, 0.22174741f, 0.05910045f, 0.07747073f, 0.09759668f, -0.04829284f, 0.29042280f, 0.13454136f, 
    -0.02214763f, 0.16488013f, -0.15695092f, 0.07495232f, -0.23241745f, -0.07352618f, -0.07664958f, -0.05814870f, 
    0.05862362f, -0.04976611f, 0.03547560f, 0.05357076f, -0.21786311f, -0.10937313f, -0.16448066f, -0.19337036f, 
    0.01110998f, -0.35869491f, -0.19861352f, 0.00011323f, 0.10810607f, 0.09170815f, 0.05575813f, 0.11176166f, 
    0.01602528f, -0.01342776f, 0.02272798f, -0.02445344f, -0.03536649f, -0.09660339f, -0.10176405f, -0.07128071f, 
    0.12226894f, 0.03211794f, -0.03407013f, 0.04505654f, -0.05218391f, -0.11195293f, -0.00189498f, -0.03819504f, 
    0.07915822f, 0.11140914f, -0.38045663f, -0.26220971f, -0.03765586f, -0.12363864f, -0.02468994f, 0.04847196f, 
    0.08293394f, -0.04286698f, -0.02598516f, 0.09649141f, 0.11028650f, 0.00726362f, 0.19349523f, 0.07719021f, 
    0.09966496f, 0.07086542f, -0.03948438f, 0.11012942f, 0.01932729f, -0.03826756f, 0.01786606f, 0.03836105f, 
    -0.03046243f, 0.14794247f, -0.11690629f, -0.06493375f, -0.00580803f, -0.13768867f, 0.07978199f, -0.11846097f, 
    0.00177001f, -0.03185019f, 0.00891023f, 0.08026147f, -0.00942162f, 0.11945046f, 0.00743013f, 0.05025741f, 
    0.03228521f, 0.10920002f, 0.22583611f, 0.07162085f, -0.03673080f, 0.06779556f, 0.02920972f, 0.23404373f, 
    -0.02538819f, 0.23693860f, 0.16063583f, 0.13421714f, 0.01390216f, -0.04190171f, 0.06651314f, 0.00399842f, 
    0.05616798f, -0.07815058f, -0.14967394f, -0.18381883f, -0.10561331f, 0.23187400f, -0.08792420f, -0.00012264f, 
    -0.10319712f, -0.04454177f, -0.02828890f, -0.11079989f, -0.03638978f, 0.05667493f, -0.08725842f, 0.11236045f, 
    -0.09130721f, 0.07391289f, -0.29469532f, 0.02942160f, -0.04367686f, 0.07130615f, 0.03780602f, 0.06965422f, 
    0.10599344f, -0.03116199f, 0.03078550f, 0.25102234f, -0.00821713f, -0.16254766f, 0.02204146f, -0.09803721f, 
    -0.04925711f, 0.02275859f, -0.17379865f, 0.06760857f, -0.03652226f, -0.12089576f, -0.24213259f, -0.08499508f, 
    -0.37996021f, 0.08232561f, -0.37939194f, 0.21619830f, 0.02403997f, -0.04571208f, -0.00246690f, 0.01637199f, 
    0.10484554f, 0.04543260f, 0.02884425f, 0.11431147f, -0.24761909f, 0.03653578f, 0.14665480f, -0.10238145f, 
    -0.04379734f, 0.12578827f, 0.08747733f, -0.11744174f, -0.08094366f, -0.11825608f, -0.03007556f, 0.08038540f, 
    0.23930950f, -0.16857943f, 0.09839812f, -0.13438004f, 0.02782609f, -0.08515576f, 0.00763869f, 0.00194434f, 
    -0.06606428f, 0.03031879f, 0.14160854f, 0.03751459f, 0.07328223f, 0.01866024f, 0.07959538f, 0.01134779f, 
    0.00979275f, -0.02592469f, -0.08635972f, -0.05582124f, 0.00807197f, 0.03972332f, -0.03191170f, 0.13960734f, 
    -0.11260942f, -0.03607714f, 0.00506225f, -0.18782802f, -0.14059411f, -0.05498346f, -0.07116359f, 0.00510465f, 
    0.08059048f, -0.02592454f, 0.04041336f, 0.07145064f, 0.01909537f, 0.00713344f, 0.10394110f, -0.03081840f, 
    0.00310255f, -0.07056783f, -0.06870044f, 0.14451738f, -0.08763080f, 0.04468597f, -0.06745519f, -0.14339799f, 
    0.11628519f, 0.31934547f, -0.19439127f, 0.00202017f, 0.00139921f, 0.15827121f, 0.07987715f, -0.10659630f, 
    0.16304733f, -0.08181843f, -0.00382763f, 0.14084905f, 0.06483953f, 0.07590472f, -0.08693472f, 0.06008759f, 
    0.17701192f, 0.07552996f, -0.05553691f, 0.16089682f, -0.03930201f, 0.07895779f, -0.07871190f, -0.11241564f, 
    -0.33971927f, -0.12029786f, -0.13685532f, -0.08072975f, 0.00746002f, -0.03004961f, 0.19471999f, 0.10251121f, 
    -0.00222975f, 0.04289090f, -0.02197652f, -0.07691558f, -0.00588262f, 0.35328522f, -0.04077663f, -0.27191210f, 
    0.12402610f, -0.14431761f, 0.00568959f, -0.16760962f, -0.12366790f, 0.07837021f, 0.04940946f, 0.01147053f, 
    0.39233249f, -0.48643503f, 0.18874587f, -0.07995129f, 0.05568743f, 0.10836892f, -0.12403167f, 0.29431650f, 
    -0.02184410f, 0.06181670f, 0.05191156f, 0.12937258f, -0.04832172f, 0.04059748f, -0.06376737f, -0.09118524f, 
    -0.01833829f, 0.05046519f, -0.08558584f, 0.00415766f, -0.02377160f, 0.00138510f, 0.04656995f, -0.08672573f, 
    0.43266210f, -0.04702619f, -0.26337764f, 0.28313804f, 0.00030483f, 0.18911533f, 0.06425062f, 0.09907049f, 
    0.05516972f, 0.02148208f, 0.03644626f, 0.01675852f, 0.15493906f, 0.12437330f, 0.33505639f, 0.07683742f, 
    0.11320867f, -0.04641733f, 0.01035532f, 0.12729727f, -0.00557764f, -0.03523024f, 0.07411079f, 0.02973717f, 
    0.29317892f, 0.04240851f, 0.19360872f, -0.26905167f, -0.08358765f, 0.01112137f, 0.07356308f, 0.11386268f, 
    0.10817270f, 0.00506261f, 0.00007767f, -0.11077568f, 0.13019343f, 0.09242256f, 0.02157441f, 0.12294672f, 
    -0.01372053f, -0.02789657f, 0.03831250f, -0.06053851f, 0.05552184f, -0.04337060f, 0.00693501f, -0.14799419f, 
    0.22938548f, -0.01047696f, 0.36517498f, 0.09347931f, -0.07908592f, 0.02500996f, -0.05517282f, 0.11433791f, 
    -0.09637176f, 0.09908325f, -0.03340410f, 0.02623752f, 0.19393022f, 0.24485745f, -0.02427861f, -0.11119936f, 
    0.00984615f, 0.08193897f, -0.03907007f, 0.10719171f, 0.04820022f, 0.13593753f, 0.10561995f, -0.04335241f, 
    -0.64792740f, -0.01099523f, -0.01340361f, -0.08953323f, -0.21372421f, -0.26249659f, -0.06417010f, -0.01762935f, 
    0.05841480f, 0.00910966f, -0.08094754f, -0.05508908f, -0.24780999f, -0.20548554f, -0.27229097f, -0.06353925f, 
    -0.11240423f, 0.02729684f, -0.05705788f, -0.12609863f, 0.01696119f, 0.00621124f, -0.06303205f, 0.07108654f, 
    0.03296643f, 0.31147635f, 0.20040247f, -0.10317107f, -0.10884269f, -0.16492800f, 0.07635465f, -0.04191430f, 
    0.00579795f, 0.01223889f, -0.09164402f, 0.15125313f, 0.12554668f, 0.06437162f, 0.01112684f, 0.19289729f, 
    0.03635582f, 0.01720339f, 0.17145334f, 0.10727965f, 0.14485386f, 0.15528089f, 0.24035823f, 0.10190987f, 
    0.20588148f, -0.36608168f, -0.07114651f, -0.53562790f, 0.06514895f, -0.12691671f, 0.08631549f, 0.08490650f, 
    0.06297631f, -0.04624991f, -0.11427260f, 0.04066491f, -0.09089496f, 0.06765340f, 0.19602285f, -0.62554181f, 
    0.00890862f, -0.01930237f, -0.17981938f, -0.02496389f, -0.08285847f, -0.03797915f, 0.10938111f, 0.05233963f, 
    0.14204253f, -0.07341962f, -0.14155801f, -0.07868952f, 0.10862014f, -0.12479140f, -0.02390696f, -0.08109091f, 
    -0.09445542f, -0.02118013f, -0.01236250f, 0.13453263f, -0.08497123f, 0.19868307f, 0.10211318f, 0.10939707f, 
    -0.09024725f, 0.08309411f, 0.11130921f, 0.16558862f, -0.03624800f, 0.03255409f, 0.04172673f, 0.01109020f, 
    -0.26466152f, 0.14253750f, 0.09898555f, -0.03811013f, -0.05096729f, -0.19780196f, 0.17641070f, 0.00303662f, 
    0.07873674f, 0.13734220f, -0.00972174f, -0.09894271f, -0.10965531f, 0.10260520f, -0.06691571f, 0.00286668f, 
    -0.07524830f, 0.03012972f, 0.13556300f, -0.06316809f, -0.07220410f, -0.00092231f, -0.01240224f, -0.01427301f, 
    0.25039166f, 0.19742115f, -0.15349397f, -0.23235255f, -0.08972685f, -0.01251050f, 0.08123036f, -0.01646523f, 
    0.13617635f, 0.12717262f, 0.04982573f, -0.08998295f, 0.17460714f, 0.14613609f, 0.01660777f, 0.27035770f, 
    0.05121114f, 0.09487014f, -0.01513173f, -0.04350909f, -0.02421927f, 0.04657608f, -0.06826711f, -0.08270798f, 
    -0.04843235f, -0.06289113f, -0.05696621f, -0.04917793f, 0.05368947f, -0.02628776f, 0.01477064f, 0.02391858f, 
    0.06060262f, -0.02105184f, -0.07106211f, 0.04680491f, -0.03914290f, -0.04003456f, -0.06306994f, -0.02377567f, 
    -0.02325942f, 0.04561223f, -0.04668842f, -0.02751474f, -0.02188569f, 0.00498274f, -0.04857676f, 0.03585924f, 
    -0.06196113f, 0.02481594f, 0.01961328f, 0.03763125f, -0.05859387f, -0.00612920f, -0.00121430f, -0.03862771f, 
    0.04501389f, -0.06035972f, -0.01557131f, -0.05041897f, 0.01882793f, -0.03188762f, 0.01438826f, -0.07916557f, 
    0.00832169f, 0.01107097f, -0.07271592f, 0.02561760f, 0.03483990f, -0.00826117f, -0.02551546f, 0.00053150f, 
    -0.02704897f, 0.03761521f, -0.01666908f, -0.04199487f, -0.04424950f, 0.03042068f, -0.03144822f, -0.03916671f, 
    -0.02589837f, -0.06648300f, 0.01810367f, -0.05423687f, -0.00061671f, -0.04333062f, -0.05495204f, -0.05848741f, 
    0.01306415f, -0.04616808f, -0.05675590f, -0.05792025f, -0.07607681f, -0.06695468f, 0.04830507f, 0.00574082f, 
    0.01053316f, -0.07547537f, 0.05430766f, 0.07150782f, -0.06570813f, 0.02534737f, -0.00980640f, -0.03544547f, 
    -0.00657823f, -0.04595822f, 0.02170279f, -0.07785107f, 0.02270919f, -0.01234736f, -0.02267524f, 0.04834028f, 
    -0.06353395f, -0.04828047f, -0.00273084f, -0.01338388f, -0.05746882f, -0.05109254f, 0.01253364f, -0.05362524f, 
    -0.00837577f, 0.00329593f, 0.04723565f, 0.00987184f, -0.07206029f, 0.04580719f, 0.02815345f, 0.01586325f, 
    -0.03527594f, -0.01353122f, 0.04303737f, -0.06939897f, -0.04306157f, 0.04771210f, -0.07407626f, -0.04631792f, 
    0.05959209f, 0.04230173f, -0.03152834f, 0.05471610f, 0.02071855f, -0.03932133f, -0.04565909f, -0.01688078f, 
    0.00975684f, 0.03981173f, 0.05018223f, -0.08513112f, -0.08897156f, -0.03175207f, -0.03323650f, 0.03375588f, 
    -0.00327532f, 0.00264756f, -0.02460842f, -0.01075740f, 0.03809565f, 0.02385825f, -0.07145559f, -0.07013707f, 
    0.03150725f, 0.06562493f, -0.06552006f, 0.01047423f, 0.05814587f, 0.00526520f, 0.00228812f, -0.02941182f, 
    0.00919473f, 0.05434684f, 0.04500619f, -0.02701550f, 0.03203534f, 0.05104944f, -0.03534905f, -0.08116078f, 
    0.04310979f, 0.00280428f, 0.02216117f, -0.02008661f, -0.09287626f, 0.04703975f, 0.00659780f, 0.07056044f, 
    -0.01535182f, 0.00311221f, 0.00337024f, -0.05303437f, -0.06365952f, -0.05906845f, -0.04233691f, 0.05507267f, 
    -0.05638121f, -0.07326523f, 0.01954358f, -0.03044857f, 0.04422883f, 0.03719450f, -0.00226999f, -0.03544569f, 
    -0.02867319f, 0.03285532f, 0.05290213f, -0.02420367f, -0.03690399f, -0.07123488f, 0.03792469f, 0.01474296f, 
    0.01554206f, 0.03762978f, 0.04982043f, -0.04468228f, -0.07298848f, 0.01416101f, 0.01395846f, -0.05536348f, 
    -0.08683999f, 0.06436407f, -0.17649651f, 0.26906899f, 0.03353589f, -0.05442226f, -0.05393489f, 0.00256985f, 
    0.19754231f, 0.10006516f, 0.09361305f, 0.13522223f, -0.01927013f, -0.07102949f, -0.13476379f, -0.07585880f, 
    0.01896585f, -0.16988775f, -0.01446215f, 0.03284919f, -0.10483428f, -0.03957961f, -0.19299734f, -0.25175136f, 
    -0.17201167f, 0.05373792f, -0.09175484f, 0.14097576f, 0.06337763f, -0.06254687f, 0.05229418f, -0.00990558f, 
    0.07486626f, 0.12860958f, 0.00043859f, 0.12812121f, -0.13307376f, -0.01232827f, 0.02173391f, 0.04512063f, 
    -0.10271846f, -0.04423750f, -0.12408434f, -0.11187361f, -0.00129107f, -0.07873413f, -0.10315512f, 0.06495440f, 
    0.03743818f, 0.01086472f, 0.13716777f, 0.05346343f, 0.14461002f, 0.02479395f, -0.01757781f, 0.11545824f, 
    0.09064669f, 0.17924361f, 0.11410464f, 0.13828021f, -0.05533265f, -0.06672066f, 0.13114004f, 0.07832347f, 
    0.01639854f, -0.01398023f, 0.05791718f, 0.11897562f, -0.04526101f, 0.00633105f, -0.01428688f, 0.02332665f, 
    -0.09831714f, -0.12758419f, 0.06505017f, 0.17106999f, -0.03887169f, 0.04486169f, -0.15151447f, 0.09334971f, 
    0.04260842f, 0.02905370f, 0.12811850f, 0.02514771f, 0.09482404f, -0.15578021f, -0.14961228f, -0.09743951f, 
    0.00647551f, 0.04364992f, 0.01198476f, 0.08690295f, 0.05893053f, 0.15046014f, -0.10788176f, 0.03850454f, 
    -0.37265119f, 0.11855993f, 0.06728061f, 0.09572093f, -0.05174937f, -0.06040558f, 0.09438439f, 0.05427522f, 
    -0.03483925f, 0.05532665f, 0.23903057f, 0.06550054f, -0.21326986f, 0.11557478f, 0.15019016f, -0.19373828f, 
    0.11368630f, 0.09839785f, 0.09442405f, 0.09311765f, 0.04897197f, 0.06038034f, 0.01761907f, 0.02460286f, 
    -0.41314396f, 0.58843321f, 0.16484407f, -0.02330260f, 0.01203373f, 0.06378705f, -0.05437353f, 0.01167475f, 
    -0.02465958f, 0.07427323f, 0.07804159f, -0.04979336f, 0.05111112f, -0.19713134f, 0.22716720f, 0.16229942f, 
    0.01512443f, -0.13189392f, 0.13033712f, -0.14000869f, 0.01595236f, 0.05751051f, 0.06633266f, 0.06737443f, 
    0.41690433f, -0.07175837f, -0.31382629f, 0.04329933f, 0.09600778f, 0.01915465f, -0.03856812f, 0.04542898f, 
    -0.04601779f, -0.00245896f, -0.02871197f, 0.07649487f, -0.23360558f, -0.03072255f, 0.12113722f, -0.25558442f, 
    0.03005293f, 0.04408951f, -0.24918926f, -0.01998636f, 0.08627748f, -0.02440781f, -0.09625375f, -0.07017973f, 
    0.24386191f, 0.02518051f, 0.02474408f, 0.20441017f, 0.04126810f, 0.13836934f, 0.07288944f, -0.05985985f, 
    -0.06055308f, -0.01547960f, 0.05417958f, 0.09938113f, 0.13281184f, -0.06785055f, 0.06460284f, -0.11558482f, 
    -0.01091943f, 0.01273668f, -0.05484496f, -0.00828003f, -0.04049429f, -0.08368556f, 0.03314872f, -0.07026940f, 
    -0.12883624f, 0.05486605f, -0.14839965f, 0.02005345f, 0.11710900f, 0.04556589f, -0.04259208f, -0.05765943f, 
    0.01449484f, -0.01829014f, -0.06359478f, 0.05893874f, 0.09031907f, 0.09265889f, 0.13002120f, -0.06039951f, 
    -0.03444250f, 0.12813973f, 0.08781064f, 0.04668153f, -0.13573754f, -0.10845222f, 0.06603000f, -0.20078757f, 
    0.17377919f, 0.17259829f, -0.21184623f, -0.22891414f, 0.14174189f, 0.10269498f, 0.11624826f, 0.14011954f, 
    -0.08563732f, -0.03270807f, -0.12928192f, -0.24457239f, -0.39210099f, -0.30062732f, 0.11295161f, 0.25713283f, 
    0.19394608f, -0.13357097f, 0.01143745f, -0.14380771f, -0.03241607f, 0.02259678f, 0.10298735f, -0.02970925f, 
    -0.02694372f, -0.15921846f, -0.07838824f, 0.11731718f, -0.02195608f, 0.11580256f, 0.04638420f, 0.19644602f, 
    -0.02032988f, -0.04459573f, 0.02954874f, 0.15008721f, 0.05546494f, 0.07875446f, 0.23808721f, -0.15184346f, 
    -0.17836134f, 0.05333379f, -0.01317080f, 0.12123729f, -0.05505809f, 0.02325009f, -0.00468556f, 0.00500706f, 
    -0.34103656f, 0.02113783f, 0.16496502f, 0.29848158f, 0.01226172f, 0.04530381f, -0.00496974f, 0.04794509f, 
    -0.09563276f, -0.16643056f, 0.18211706f, -0.08081216f, 0.01973354f, 0.16146955f, 0.11953510f, 0.01564251f, 
    -0.00979403f, 0.11214431f, 0.00896937f, -0.06919482f, -0.07619769f, -0.09153666f, 0.12445018f, 0.15491454f, 
    -0.31207177f, -0.01461752f, -0.32172582f, 0.03083916f, -0.16811985f, -0.09755483f, 0.24747254f, -0.14254542f, 
    0.02560123f, -0.03671537f, -0.03135230f, -0.01829936f, -0.00180809f, -0.05316183f, -0.13039538f, 0.46901926f, 
    -0.04649895f, 0.00213574f, 0.19019057f, 0.07081845f, 0.05210004f, -0.07361822f, 0.07006501f, -0.12442892f, 
    0.20468879f, -0.23750921f, -0.12895541f, -0.04474304f, -0.06990746f, 0.13017339f, 0.06757397f, 0.02472216f, 
    -0.19449759f, -0.04093736f, -0.10551982f, 0.00046976f, 0.11167093f, -0.07441996f, 0.24643159f, 0.08380131f, 
    0.14590448f, 0.12852836f, 0.00998622f, 0.06045204f, 0.00795875f, -0.12375020f, -0.16085421f, -0.00776461f, 
    0.17789952f, -0.20078717f, 0.13681854f, 0.09012221f, -0.04922533f, 0.33921951f, -0.13335131f, -0.13083316f, 
    -0.10659996f, 0.05946141f, 0.07887167f, 0.08357386f, 0.11629477f, 0.00093140f, 0.11170094f, 0.12804751f, 
    0.00668249f, 0.04081392f, 0.18772279f, 0.04030260f, -0.08868445f, -0.14912635f, 0.05147584f, 0.02214423f, 
    -0.05544212f, 0.03530255f, 0.17227688f, 0.33645803f, 0.05271417f, -0.10011917f, -0.00093966f, 0.06274307f, 
    -0.07807999f, 0.13198088f, 0.24319291f, 0.12063642f, 0.31861877f, 0.13431020f, 0.42218509f, -0.04762144f, 
    -0.09067438f, -0.05700987f, -0.00715630f, 0.10610475f, 0.00017219f, -0.04160057f, 0.06448527f, -0.05426803f, 
    0.08181624f, -0.03563596f, 0.01856594f, -0.26147354f, -0.01932100f, 0.03641284f, 0.03937991f, 0.11337021f, 
    -0.07112311f, 0.13493091f, 0.03413623f, 0.04756901f, 0.01018669f, -0.20596878f, -0.05324766f, -0.05133660f, 
    -0.00797888f, 0.06904233f, -0.03770454f, 0.02109729f, -0.01155102f, 0.01576515f, 0.06947783f, 0.10877519f, 
    -0.11298008f, -0.06124074f, -0.09183715f, -0.15027161f, -0.05031194f, 0.01513804f, -0.14157979f, 0.09292852f, 
    0.08471758f, -0.00352367f, -0.03508572f, 0.02223405f, 0.10731507f, 0.04457887f, 0.30154815f, -0.02470291f, 
    0.07556527f, 0.00417892f, 0.00601265f, 0.09346686f, -0.03483966f, -0.19947401f, 0.16673213f, 0.04459747f, 
    0.10135755f, 0.07695791f, 0.17459662f, 0.08599231f, 0.14617014f, 0.07960531f, 0.02687248f, 0.11214218f, 
    0.01665636f, -0.14420751f, 0.03772051f, -0.01959798f, 0.13596660f, 0.18871401f, -0.08612785f, -0.13258891f, 
    0.03148792f, 0.03235953f, -0.14128616f, 0.08512411f, -0.09836797f, 0.06507889f, -0.04302524f, 0.02064496f, 
    0.15777393f, 0.22284366f, 0.14057313f, -0.04657909f, -0.05322227f, 0.06843033f, -0.10760399f, -0.08405739f, 
    -0.01240943f, -0.21435651f, 0.05683517f, 0.02327257f, -0.31495643f, -0.02029182f, 0.06439936f, 0.05856440f, 
    0.07213569f, 0.08344257f, -0.04496830f, 0.00993053f, -0.02329924f, -0.06839184f, 0.08183137f, -0.08769506f, 
    0.40216011f, 0.37349713f, 0.01542781f, -0.00185699f, 0.12206635f, 0.10299198f, 0.12769841f, 0.02046021f, 
    0.11136886f, 0.08512071f, 0.02677913f, 0.00527342f, 0.34356153f, 0.07273088f, 0.01587620f, 0.22336081f, 
    0.13861796f, 0.04574290f, 0.10773788f, 0.18454312f, -0.08458662f, -0.05570265f, -0.05678016f, -0.01237003f, 
    0.18044074f, -0.21218345f, 0.08458728f, 0.03316120f, 0.04097866f, -0.03441006f, 0.13629146f, -0.04681922f, 
    0.08429752f, 0.13089333f, -0.04884971f, -0.06476222f, 0.05719248f, 0.44897503f, 0.05579491f, -0.12543964f, 
    -0.05806185f, 0.07830524f, -0.07160326f, 0.02141464f, 0.01341482f, -0.04643634f, -0.01430068f, -0.06526819f, 
    -0.08255848f, -0.36719573f, 0.28250626f, 0.07966031f, -0.09728995f, 0.13162924f, -0.27176476f, 0.14137308f, 
    0.02378175f, -0.07107916f, -0.01517883f, 0.02288177f, 0.15715159f, 0.29227483f, -0.00348441f, 0.07635055f, 
    0.02515436f, -0.15285158f, 0.15996483f, 0.08488554f, -0.13716730f, -0.24848881f, 0.01754098f, -0.13803156f, 
    -0.15774831f, -0.12302463f, -0.22294341f, -0.22519642f, -0.00553584f, -0.14116448f, 0.03672333f, -0.02641556f, 
    -0.02102125f, -0.01616942f, -0.02738802f, -0.09651617f, -0.37626037f, -0.16917613f, 0.12623371f, -0.05117282f, 
    -0.05328624f, -0.05215326f, -0.09475602f, -0.01953684f, 0.12399742f, -0.15094620f, 0.03304921f, 0.04133109f, 
    -0.00000022f, 0.04945771f, 0.02512168f, 0.05159800f, -0.07638428f, -0.04098834f, 0.05498956f, -0.03020619f, 
    0.02225522f, 0.00565264f, 0.05847882f, -0.04106542f, -0.01735027f, -0.00655596f, -0.06263099f, -0.07361641f, 
    -0.03492536f, 0.05250540f, 0.02194658f, 0.05475109f, -0.00806371f, -0.05560537f, -0.06693366f, -0.02143622f, 
    -0.00071531f, 0.00850303f, -0.02219632f, 0.05937243f, 0.03000633f, -0.00793268f, 0.03872692f, -0.07060221f, 
    0.02448260f, -0.01444608f, -0.05121385f, -0.07486459f, 0.00638782f, 0.05453027f, -0.02399343f, -0.00564805f, 
    0.04487720f, -0.07597581f, 0.00191718f, -0.04262903f, 0.05637468f, -0.07509494f, 0.04785353f, -0.01353370f, 
    0.01826614f, 0.02308745f, -0.01583890f, 0.00875743f, -0.03288539f, -0.07101232f, -0.03377668f, 0.05319411f, 
    0.03747340f, 0.02371651f, -0.07139886f, 0.03887742f, -0.04994889f, -0.05930808f, 0.01683135f, -0.07349132f, 
    0.05966129f, 0.03869702f, -0.05693335f, 0.05493667f, -0.02656668f, 0.04385957f, 0.02390248f, -0.02008030f, 
    0.02012195f, 0.04484825f, 0.02225529f, -0.02455772f, 0.02447002f, 0.05387697f, 0.04071166f, 0.04900673f, 
    -0.07023627f, -0.05081981f, -0.01131556f, -0.01604703f, 0.02645347f, -0.02120794f, 0.00923710f, -0.05529061f, 
    0.05153290f, 0.05181156f, -0.06537569f, -0.06140292f, -0.00803184f, 0.04414520f, -0.01071733f, -0.01118562f, 
    0.05590390f, -0.03919930f, -0.01345588f, -0.00510286f, 0.00386748f, 0.02873723f, -0.01865555f, -0.04218673f, 
    0.04345861f, -0.05384563f, -0.02548459f, -0.02137518f, -0.02836697f, 0.03058377f, -0.02514142f, 0.04553305f, 
    0.03242181f, 0.02276964f, -0.07345925f, -0.05699790f, -0.04571972f, -0.05395504f, 0.04693913f, -0.00974165f, 
    -0.05308242f, -0.00595220f, 0.03697468f, 0.06016243f, -0.03955232f, -0.03173385f, 0.05055883f, -0.02083377f, 
    0.01315531f, -0.02294223f, -0.01523576f, -0.04733380f, -0.03642593f, -0.03119411f, -0.04445938f, -0.06818847f, 
    -0.03141570f, -0.00226326f, -0.05582242f, -0.01999588f, 0.00660092f, 0.02304252f, 0.00889065f, 0.03176036f, 
    0.00035690f, 0.04807482f, -0.03246956f, 0.00174441f, -0.05008407f, -0.06542764f, 0.01361496f, -0.04282717f, 
    -0.01134440f, 0.05564805f, -0.03360750f, 0.00716039f, -0.00025180f, -0.04852319f, 0.06111307f, -0.05176564f, 
    0.05886091f, -0.03514053f, -0.02118666f, 0.00534132f, 0.03969648f, -0.05896910f, -0.05624103f, -0.03773880f, 
    -0.04416975f, -0.01434327f, 0.04086720f, 0.05901425f, 0.04518553f, 0.05573715f, 0.04312588f, 0.00414400f, 
    -0.07571056f, -0.06702142f, 0.00852016f, -0.08328952f, -0.03023808f, -0.07702178f, 0.00123009f, -0.02594054f, 
    0.04165839f, -0.05251570f, -0.05779692f, 0.00430434f, -0.06336678f, -0.07917991f, -0.05658003f, -0.02875054f, 
    0.07114156f, -0.19033404f, 0.14678667f, -0.16215314f, -0.12953332f, -0.00547817f, 0.04414581f, 0.03287358f, 
    -0.02571266f, 0.08558640f, 0.01754691f, 0.14242515f, -0.21424383f, -0.04022686f, -0.01471787f, -0.03490129f, 
    0.10372044f, 0.13160735f, -0.05754863f, 0.00169346f, 0.07408231f, -0.04792143f, -0.01458829f, 0.10201248f, 
    -0.03861010f, -0.19650488f, 0.11496729f, 0.20846181f, -0.14887090f, -0.04745218f, -0.16360912f, 0.05217592f, 
    0.01123684f, -0.04161162f, 0.07105460f, -0.01161809f, 0.11820648f, -0.11014072f, 0.13685469f, -0.19440198f, 
    -0.03146732f, -0.02796760f, 0.04144790f, -0.08906584f, 0.17023893f, 0.01851369f, -0.10899379f, 0.03461850f, 
    0.17542988f, -0.10777406f, 0.23178650f, -0.02674241f, 0.10893400f, -0.02790210f, 0.09984220f, 0.08347643f, 
    0.13576053f, 0.04732271f, 0.01432513f, -0.01769469f, 0.15483013f, 0.04272008f, -0.03966104f, -0.14523324f, 
    0.18422015f, -0.00241682f, 0.02412691f, 0.10594106f, 0.02290989f, 0.16850735f, 0.01372287f, -0.12978913f, 
    0.20023914f, -0.13389938f, 0.30146056f, -0.29316372f, -0.02465439f, -0.07001028f, 0.02795952f, -0.14169198f, 
    -0.01665772f, 0.02191546f, 0.02387119f, 0.13044100f, -0.11866724f, 0.00773958f, -0.16022524f, -0.02761153f, 
    0.19153138f, -0.11340451f, 0.00824859f, -0.09415080f, 0.02462594f, -0.03824813f, 0.00877682f, 0.01119321f, 
    0.27662373f, 0.03412828f, 0.09664357f, -0.15836507f, -0.08883054f, 0.07332049f, -0.03675935f, 0.08063934f, 
    0.04635448f, -0.02332050f, -0.05539427f, 0.07037302f, 0.19093271f, -0.02948476f, 0.15087660f, -0.02008224f, 
    -0.13241218f, 0.04617127f, -0.05311032f, 0.07619336f, -0.05078609f, 0.07583101f, 0.02707676f, 0.07427379f, 
    0.44023964f, -0.65584749f, 0.01958994f, 0.13216637f, -0.04343088f, -0.01120159f, 0.05839301f, 0.16288263f, 
    0.16596659f, -0.01421042f, 0.07908442f, -0.01513395f, -0.02509040f, 0.33121830f, -0.12776624f, -0.12644397f, 
    -0.13520108f, -0.03969087f, 0.02969735f, 0.12330975f, 0.08108944f, 0.03859574f, 0.05317740f, 0.01487279f, 
    -0.21812463f, 0.06596625f, 0.29604292f, 0.17233707f, 0.22832498f, -0.07716579f, -0.18513986f, -0.11108307f, 
    0.09370656f, 0.00119249f, 0.00471019f, 0.01860884f, -0.07089575f, 0.07974246f, -0.19168906f, -0.06126800f, 
    0.03478005f, 0.08271378f, 0.04155600f, -0.00456588f, -0.16779143f, 0.02956862f, -0.11635802f, -0.04617059f, 
    -0.22890115f, 0.01738376f, -0.12229612f, -0.33810410f, 0.06396447f, 0.03471124f, -0.02571449f, -0.04063420f, 
    0.03682423f, 0.13902123f, 0.07054133f, -0.07331895f, -0.22650625f, -0.05912146f, 0.04201993f, 0.17385483f, 
    0.22918570f, 0.01080989f, 0.03189433f, 0.04668298f, 0.05050338f, -0.03652812f, 0.05477405f, 0.13376465f, 
    0.16256803f, 0.16496706f, 0.17495206f, -0.07664683f, -0.06359148f, 0.05532865f, -0.02432810f, 0.03911525f, 
    0.05886460f, 0.11465644f, 0.10292476f, 0.07714479f, -0.19150554f, -0.31950125f, -0.08766408f, -0.23840833f, 
    -0.00371210f, 0.22025211f, -0.12723535f, -0.12106869f, -0.09620534f, -0.19571500f, -0.01346951f, -0.11584483f, 
    0.10224622f, -0.07260247f, 0.08292355f, -0.07083955f, -0.02255124f, -0.16732542f, -0.08477420f, 0.16640863f, 
    -0.04834009f, -0.12456103f, -0.02786027f, -0.01802372f, -0.01249110f, -0.27858093f, 0.31662378f, -0.09895068f, 
    0.10695364f, -0.01194920f, 0.13474520f, -0.02428651f, 0.14603916f, 0.01099491f, 0.18023980f, 0.00283252f, 
    -0.07552042f, 0.14815924f, -0.07372971f, -0.08224990f, 0.07414547f, 0.06749844f, 0.15255666f, 0.05589657f, 
    0.04775286f, -0.07419406f, 0.04293250f, -0.00890276f, -0.12066182f, 0.14991426f, -0.01416803f, -0.19916786f, 
    0.17611217f, 0.10300290f, -0.05914680f, -0.07517674f, -0.03168518f, 0.07778202f, 0.17487404f, -0.20264889f, 
    0.16240509f, 0.13275014f, -0.23574951f, -0.15830612f, 0.02064037f, -0.13118474f, -0.00218585f, -0.17758837f, 
    -0.03061763f, -0.07835227f, -0.02020778f, 0.01228473f, -0.27712363f, -0.05762632f, 0.04208912f, -0.04387124f, 
    0.06716432f, 0.06552973f, -0.19232383f, -0.06814457f, 0.09488230f, -0.01961423f, 0.13250282f, 0.02376436f, 
    0.23412664f, 0.51381373f, 0.20351104f, 0.09921233f, 0.07857855f, 0.00980564f, 0.01952811f, -0.13283285f, 
    0.13390265f, 0.00379105f, -0.07280376f, 0.21695255f, 0.20478651f, -0.21396500f, -0.05883421f, 0.42692894f, 
    -0.06901703f, 0.05085812f, -0.04570275f, 0.07506172f, 0.06843950f, 0.12455010f, 0.13881192f, 0.01269358f, 
    0.37927341f, -0.19220059f, 0.22151169f, -0.21603768f, 0.09367983f, -0.23295003f, 0.04527745f, 0.10575886f, 
    0.08909902f, 0.19650963f, 0.07295366f, 0.05434658f, -0.11720750f, 0.31109768f, 0.01985053f, -0.15062489f, 
    0.04895203f, 0.18939047f, -0.08385635f, 0.10566486f, -0.03992894f, 0.00945552f, 0.10214710f, 0.04975734f, 
    -0.29171103f, -0.48775572f, 0.18506584f, 0.01760963f, -0.16694357f, 0.14648452f, -0.20365585f, -0.13133869f, 
    0.04011220f, 0.07498103f, 0.08552598f, -0.00910409f, 0.18889351f, 0.02208564f, -0.12536024f, 0.00783504f, 
    0.10246573f, -0.08234616f, 0.21744135f, 0.11968236f, -0.05333863f, -0.11005224f, -0.11314976f, -0.12329094f, 
    -0.12068885f, 0.00125674f, -0.13897632f, -0.22427689f, -0.00076858f, 0.02055285f, -0.07044695f, -0.01616850f, 
    -0.01167958f, -0.03848251f, -0.03276880f, 0.11340604f, -0.23091336f, -0.20149831f, 0.24026676f, 0.05741745f, 
    -0.04998082f, -0.09818714f, -0.09335466f, 0.06113483f, 0.11269369f, -0.23889698f, 0.02647914f, 0.07433154f, 
    -0.03298600f, 0.16976744f, 0.05931291f, 0.09753133f, -0.01604204f, -0.04450659f, -0.11523362f, -0.15962243f, 
    0.03818624f, 0.05071329f, -0.08099508f, -0.09201140f, -0.07595273f, -0.00187593f, 0.04038337f, -0.03423960f, 
    -0.04017159f, 0.01069865f, 0.02812048f, 0.05170492f, 0.14042403f, 0.05420098f, 0.12529424f, 0.04243490f, 
    0.20296021f, 0.01825967f, -0.15365927f, -0.24682298f, -0.04423139f, -0.03143779f, 0.09143323f, 0.18665668f, 
    -0.03771617f, 0.01067575f, 0.13809052f, 0.12061251f, -0.42960143f, -0.22291750f, 0.00377233f, -0.02409866f, 
    0.13494982f, 0.16186418f, 0.03873511f, 0.03630843f, -0.07687890f, 0.09672247f, 0.09155662f, 0.04543054f, 
    -0.04635718f, 0.08697766f, -0.12397360f, 0.01519907f, -0.04833284f, -0.08343592f, 0.10264426f, 0.00100104f, 
    0.03148387f, -0.09308221f, 0.01276633f, -0.11680339f, 0.08060131f, 0.10589297f, 0.02987038f, 0.03510401f, 
    0.00777734f, 0.04129136f, 0.03467131f, -0.18328308f, 0.09997264f, -0.04224378f, 0.20148616f, 0.00903468f, 
    -0.08992112f, 0.10413280f, -0.35350195f, 0.06867421f, 0.00205181f, 0.01481649f, 0.16749221f, 0.03773306f, 
    -0.12776935f, -0.04214047f, -0.07092071f, -0.10579987f, -0.13870630f, 0.09816937f, 0.09291560f, -0.05057272f, 
    -0.06105028f, -0.03546999f, -0.18014404f, -0.02081063f, -0.01276812f, 0.07825439f, -0.05964725f, -0.07357059f, 
    0.04510465f, 0.20099308f, 0.02272314f, 0.16481337f, -0.05746361f, 0.15934815f, 0.15975742f, -0.12862760f, 
    0.08201051f, 0.04576844f, 0.01877442f, 0.09272369f, -0.00424455f, -0.06433409f, -0.15129068f, 0.22731018f, 
    -0.04861098f, 0.07619912f, 0.06157525f, 0.10304697f, -0.02217081f, -0.01088234f, -0.07820815f, -0.11495068f, 
    -0.00329129f, 0.15722503f, -0.00543830f, -0.16410138f, -0.01194511f, -0.03242283f, 0.15785183f, 0.02678671f, 
    -0.04383760f, 0.09953495f, -0.02513537f, 0.07828496f, -0.09104425f, -0.09890550f, 0.14778998f, -0.09864623f, 
    0.04017154f, 0.13185413f, -0.03298199f, 0.00213821f, -0.11697534f, -0.00261609f, -0.03716652f, -0.05531764f, 
    0.17186266f, -0.19841392f, -0.03685923f, -0.14306238f, -0.10633200f, 0.05758230f, -0.15351966f, -0.01315226f, 
    0.01698194f, -0.09029350f, 0.09697765f, 0.00233586f, -0.11275268f, -0.05171510f, 0.02089842f, 0.04193230f, 
    0.04187205f, 0.00561667f, 0.20472513f, 0.15806648f, -0.02150526f, 0.05502947f, 0.09562191f, 0.13892691f, 
    0.11203365f, -0.05475083f, 0.11562370f, 0.23283570f, 0.00610500f, 0.03153408f, -0.09941379f, 0.03969959f, 
    0.11695178f, -0.01071011f, -0.06208597f, 0.11045426f, -0.00604015f, 0.09971298f, 0.35610211f, -0.15751182f, 
    -0.09262437f, -0.10578781f, -0.13833374f, 0.09033053f, 0.03805700f, -0.08801319f, 0.16470361f, 0.07775977f, 
    -0.19271140f, 0.19300096f, -0.25718379f, 0.18326642f, 0.00692399f, 0.00891608f, 0.00247315f, 0.03956791f, 
    0.09967582f, -0.15135700f, 0.03227265f, 0.02661272f, -0.18844420f, 0.01527968f, -0.07857952f, 0.19719012f, 
    0.06577516f, 0.13248312f, -0.08272059f, -0.03812110f, 0.02363561f, 0.04571986f, 0.18470395f, -0.01813600f, 
    -0.12007575f, 0.10546960f, -0.07125343f, -0.25312865f, 0.06435870f, -0.03894250f, 0.01513426f, -0.10506774f, 
    0.06398048f, 0.10025232f, 0.02794204f, 0.15760975f, 0.24208210f, 0.17997311f, -0.22018388f, 0.38386247f, 
    0.08066648f, 0.10821807f, -0.01836468f, 0.15902834f, -0.01552499f, -0.03130956f, -0.23983839f, -0.04137580f, 
    0.21101777f, 0.11081568f, 0.08262465f, -0.00029570f, 0.12204161f, 0.04589442f, 0.03797136f, -0.01396139f, 
    0.06163068f, 0.11710295f, 0.08522923f, 0.14711523f, 0.13470699f, 0.13251761f, 0.13881813f, 0.25162992f, 
    0.05265531f, 0.05811499f, -0.16375089f, 0.10274763f, -0.03375245f, -0.06906371f, 0.00257434f, -0.09128015f, 
    0.01843023f, 0.20386674f, 0.09522920f, 0.21968135f, 0.02482997f, 0.07828183f, -0.00057089f, 0.13021991f, 
    -0.02053705f, -0.01854970f, 0.10685656f, 0.07249685f, -0.01799071f, 0.00294352f, 0.05581266f, -0.09588776f, 
    0.00240215f, -0.12426503f, 0.04647543f, 0.01439627f, 0.06165193f, -0.01207463f, -0.01403447f, -0.10589403f, 
    -0.38291511f, -0.19026038f, -0.10757770f, 0.01546611f, 0.06070141f, 0.05011751f, -0.04325613f, 0.05404823f, 
    -0.10559358f, -0.06744833f, 0.13017797f, 0.06420220f, -0.21175520f, -0.01689436f, 0.14815609f, 0.01299670f, 
    0.09000749f, -0.21229430f, 0.03287079f, -0.11502468f, -0.08330924f, 0.03787278f, 0.00523522f, -0.14874537f, 
    -0.21694878f, 0.51431602f, -0.31927162f, 0.06961571f, 0.12808199f, 0.10086758f, -0.10976749f, 0.10739160f, 
    -0.13557380f, 0.00431339f, -0.04221772f, 0.00724820f, 0.18696795f, -0.09703688f, 0.27100748f, 0.25460112f, 
    -0.01771278f, -0.17648630f, 0.08059219f, -0.03623628f, 0.03412652f, 0.04408995f, -0.08961691f, 0.06114924f, 
    0.29319382f, -0.14292860f, 0.01300749f, 0.08433720f, 0.05613217f, -0.07645611f, -0.01514088f, 0.03692881f, 
    0.00354419f, -0.08778039f, 0.00915344f, 0.05629699f, 0.25272632f, 0.23512703f, 0.22967041f, 0.05942995f, 
    -0.04992120f, 0.08016863f, -0.02412897f, 0.01108763f, 0.12213487f, 0.01865446f, 0.10707163f, 0.01105625f, 
    -0.05615231f, 0.00158811f, 0.10382442f, 0.31705385f, -0.07649281f, 0.00663723f, 0.12751934f, -0.06287123f, 
    -0.04898587f, -0.00284225f, -0.01173150f, -0.08601136f, -0.08762141f, 0.11291379f, 0.16898562f, -0.04084552f, 
    0.10790483f, 0.06588511f, 0.04651229f, 0.01019365f, -0.01663180f, -0.01993052f, 0.04653291f, 0.06906613f, 
    -0.11168413f, -0.06391443f, -0.20078036f, 0.15353329f, 0.08462806f, -0.03577051f, 0.10150813f, -0.03916621f, 
    0.10186516f, 0.00518261f, 0.05785963f, 0.18484604f, -0.04878956f, 0.03959683f, -0.10383897f, -0.06045714f, 
    -0.01309107f, -0.01425695f, -0.06833347f, 0.01427238f, 0.03968562f, 0.02489562f, -0.01101467f, -0.11766429f, 
    0.03402182f, -0.24580447f, -0.02873627f, -0.05826416f, 0.11157250f, -0.01859469f, -0.04581547f, 0.03577591f, 
    0.01256168f, 0.03225491f, -0.03132707f, 0.13667037f, -0.11760034f, 0.04365757f, 0.25170076f, 0.01383344f, 
    -0.04918771f, -0.12323903f, 0.06609978f, -0.01538824f, 0.04921217f, 0.05032701f, -0.07988905f, 0.10018591f, 
    0.05338297f, -0.05562750f, 0.11465510f, 0.04236110f, -0.12237867f, -0.11058898f, 0.03232452f, 0.03474162f, 
    -0.08821967f, 0.03383341f, 0.10928100f, 0.07167792f, -0.10723224f, 0.09631296f, 0.02973548f, 0.01066176f, 
    0.05877505f, -0.03551837f, -0.03958541f, 0.06824501f, -0.22796839f, 0.08722642f, 0.07297270f, 0.01268562f, 
    -0.14808211f, 0.05664773f, 0.05303086f, 0.15414272f, -0.05385819f, -0.03177283f, 0.02389333f, -0.05373759f, 
    0.01278597f, -0.07598855f, 0.04499607f, 0.07718318f, 0.26172274f, -0.11347534f, 0.01630628f, 0.02908165f, 
    0.03002154f, 0.03764969f, -0.01351452f, 0.05173054f, 0.18245770f, 0.09089818f, 0.15290536f, -0.01244024f, 
    -0.30503324f, 0.29996347f, 0.03022638f, 0.08052617f, -0.08279032f, -0.06423479f, 0.03739588f, -0.14022014f, 
    -0.06299824f, 0.01017907f, 0.21115054f, 0.13505998f, -0.17977594f, -0.11700376f, 0.29636332f, -0.09196344f, 
    -0.07534001f, 0.12191667f, -0.02227689f, 0.13294993f, -0.01698995f, 0.18161422f, 0.01472311f, -0.02558353f, 
    -0.20189847f, 0.33983257f, 0.22403508f, -0.05180214f, 0.06988741f, -0.09950560f, -0.06138561f, 0.03770505f, 
    -0.00614353f, 0.15045059f, -0.06277172f, 0.09958082f, -0.10086082f, -0.00423334f, 0.29914889f, 0.19367187f, 
    -0.11905263f, -0.02119235f, 0.08438809f, -0.11225745f, -0.00649438f, 0.02735211f, 0.00267577f, -0.03382642f, 
    0.28497872f, -0.23723157f, -0.15153578f, 0.15751886f, -0.01401538f, -0.03152485f, -0.20900996f, -0.02520518f, 
    -0.03749660f, 0.05549966f, 0.10265537f, 0.01422376f, -0.11913723f, 0.02779080f, 0.13597201f, -0.19332837f, 
    0.11308955f, -0.02169743f, -0.07128685f, 0.00307454f, 0.18809754f, 0.01748196f, -0.09806154f, -0.01921349f, 
    0.18266560f, -0.08233832f, -0.04250390f, 0.06920604f, -0.01638761f, 0.04997499f, 0.01657505f, -0.05507064f, 
    0.17006770f, -0.15419096f, 0.08637753f, 0.07700321f, 0.07749694f, -0.20752423f, 0.14639375f, -0.01025707f, 
    0.06446181f, 0.04252188f, -0.04052664f, 0.04231256f, 0.12826008f, -0.18720178f, 0.01761395f, -0.07690261f, 
    0.09459700f, 0.04115714f, 0.05105879f, 0.14058709f, -0.03291061f, -0.08018283f, 0.04503997f, -0.05853201f, 
    0.08594564f, 0.07017321f, 0.09224559f, 0.17702582f, -0.04392861f, 0.14559035f, -0.09859782f, 0.01845012f, 
    0.02585487f, -0.00139252f, -0.11431860f, -0.18189202f, -0.33103812f, -0.31586352f, -0.14682753f, -0.52246958f, 
    0.28573358f, 0.05846127f, 0.02861946f, 0.05948493f, -0.15772858f, -0.18980335f, -0.14318220f, -0.06477643f, 
    -0.01029801f, 0.07964192f, -0.08495124f, -0.07110091f, 0.30727646f, 0.05048938f, 0.11691415f, 0.02086433f, 
    -0.06663756f, -0.24217485f, 0.11677973f, 0.07561775f, 0.33471143f, 0.02497588f, -0.18161409f, -0.08269281f, 
    -0.13552184f, -0.08114726f, 0.03767841f, 0.07613357f, -0.00614509f, 0.03916370f, -0.00391998f, 0.16905114f, 
    0.05016189f, 0.10155020f, 0.07097264f, 0.11247273f, -0.05058301f, 0.05177966f, 0.10745719f, -0.23464690f, 
    0.13768919f, 0.05257201f, 0.02040998f, 0.23020822f, -0.23473695f, 0.25737688f, -0.12681068f, -0.31435773f, 
    0.19583029f, -0.13864456f, 0.33578625f, 0.03073342f, 0.02342533f, -0.04483400f, 0.01947698f, 0.02389622f, 
    0.16875607f, -0.04111168f, 0.32716307f, 0.30194935f, 0.19208398f, -0.28380620f, -0.09998161f, -0.02071759f, 
    0.15467981f, 0.17961104f, 0.21683608f, -0.13251367f, 0.18504842f, 0.05972856f, 0.22201134f, 0.19527517f, 
    -0.29976264f, 0.28722301f, 0.17299679f, 0.06757297f, -0.06289716f, -0.05407004f, 0.08828568f, -0.12460140f, 
    0.10341435f, 0.03751834f, 0.10238373f, 0.10262407f, -0.02985013f, 0.01054441f, 0.20418121f, 0.10167351f, 
    -0.03016517f, 0.04583399f, 0.08796829f, 0.04106687f, -0.03934588f, 0.06914975f, 0.05957816f, 0.01907078f, 
    0.28678381f, -0.28103116f, 0.22548001f, 0.03041460f, -0.11611281f, -0.07616659f, 0.02464583f, 0.05764256f, 
    0.09500513f, 0.10915308f, -0.05217922f, -0.04226552f, -0.06005608f, 0.10430184f, 0.10143601f, 0.17674734f, 
    0.08453275f, 0.03114333f, 0.05697361f, 0.12482592f, 0.04904387f, -0.04268751f, -0.06669127f, 0.09039162f, 
    -0.08798281f, -0.28410807f, -0.22700691f, 0.16727607f, -0.04112533f, 0.27171940f, 0.00081157f, -0.22548872f, 
    0.00370247f, 0.06788665f, 0.02706252f, -0.13328822f, -0.10732313f, 0.02871194f, -0.00968278f, -0.05310370f, 
    0.22627184f, 0.00471460f, -0.06644995f, 0.09191678f, -0.07914621f, -0.17972766f, -0.19468342f, -0.19760542f, 
    -0.12141305f, -0.07253116f, 0.11981392f, -0.11448947f, 0.03548116f, -0.08267402f, 0.00609181f, -0.15120178f, 
    0.11615562f, 0.08492593f, 0.23287578f, 0.11370826f, 0.06485469f, -0.20617965f, 0.10246655f, 0.10549581f, 
    0.18744925f, 0.11651833f, -0.25473621f, -0.13195337f, -0.13802400f, -0.13934138f, 0.03659121f, 0.00011584f, 
    -0.03256475f, -0.01121769f, -0.04259938f, -0.00289031f, 0.01999019f, 0.01033277f, -0.02931580f, -0.04888449f, 
    -0.01826444f, -0.07561653f, -0.01046206f, 0.02096269f, -0.07649384f, -0.01409734f, 0.02053268f, 0.06285384f, 
    -0.00366268f, -0.03500269f, 0.04768600f, 0.05294029f, 0.06232233f, -0.06221776f, -0.05143869f, -0.06728910f, 
    -0.03306561f, -0.00921841f, -0.01797868f, -0.00054144f, 0.02825614f, -0.05309749f, -0.04745962f, -0.03362636f, 
    -0.04463145f, -0.03809712f, 0.04613557f, -0.06189475f, 0.01505015f, -0.02116885f, -0.07615963f, -0.00363763f, 
    -0.04445185f, 0.05927951f, -0.06452586f, -0.05719306f, 0.06489502f, -0.04587984f, -0.04817427f, -0.01099279f, 
    -0.03987625f, -0.02200025f, -0.05217265f, -0.04290794f, 0.04413526f, 0.05344827f, 0.02862812f, -0.05473641f, 
    -0.06732994f, -0.05442937f, 0.04126994f, 0.02476394f, -0.02956273f, -0.01643206f, 0.04627841f, -0.01083611f, 
    -0.04556585f, -0.01541414f, 0.02830513f, -0.04238146f, 0.02077681f, 0.05498716f, 0.05151442f, -0.03478284f, 
    0.02166818f, -0.00586724f, -0.02370331f, -0.03617929f, -0.03578885f, 0.00444647f, -0.01951255f, -0.06431200f, 
    0.04657386f, -0.02455244f, -0.04232587f, 0.06377960f, 0.04175545f, -0.02456390f, -0.02589690f, 0.06302334f, 
    -0.02986934f, 0.04854634f, -0.00638892f, -0.01234966f, -0.00355712f, -0.00222881f, 0.03081525f, 0.05020404f, 
    -0.05392130f, -0.04411247f, -0.00011501f, 0.05833818f, -0.07304046f, -0.06707335f, 0.00019293f, -0.05729209f, 
    0.03288446f, -0.03978827f, -0.03373328f, 0.05505296f, -0.05537149f, -0.07442949f, -0.06340123f, -0.04369755f, 
    -0.03770691f, -0.03268647f, 0.01596561f, -0.03137371f, -0.03200008f, 0.00510292f, 0.04229130f, 0.03599184f, 
    -0.03724827f, 0.05894526f, 0.00446138f, -0.01416156f, -0.07489043f, -0.05017878f, 0.00845090f, -0.04069130f, 
    0.03095099f, 0.04113615f, -0.01168385f, 0.04874834f, 0.05188312f, -0.00934792f, 0.01953093f, 0.05242383f, 
    0.05561812f, -0.04830318f, 0.04619201f, -0.01185163f, 0.03414467f, 0.03420226f, -0.05850298f, 0.00611110f, 
    0.02623834f, -0.02953478f, 0.01668291f, -0.05453006f, -0.03591563f, 0.01064058f, -0.07039291f, -0.07679331f, 
    -0.02030714f, 0.01480297f, 0.04637008f, -0.06220299f, -0.01846602f, 0.00152435f, -0.03559140f, -0.07142173f, 
    -0.01181163f, 0.02647292f, -0.04505041f, -0.03846239f, 0.01990877f, 0.02549528f, -0.03995268f, 0.01462209f, 
    0.00242669f, 0.05037542f, 0.03331332f, -0.00132955f, -0.01904673f, -0.04551522f, 0.04951452f, -0.04280042f, 
    -0.00876064f, 0.00106193f, -0.04421271f, -0.02795851f, -0.02213234f, 0.02383206f, -0.01100042f, -0.01568272f, 
    0.02425949f, -0.07178963f, 0.01789903f, -0.02844144f, -0.05121483f, -0.06886013f, -0.05908974f, 0.05389421f, 
    0.04584135f, -0.00813177f, -0.12492632f, -0.17224316f, -0.04652211f, 0.05762590f, 0.06064013f, 0.03712516f, 
    -0.02837463f, -0.06862222f, 0.07620523f, -0.00812584f, -0.01799439f, -0.02587731f, 0.02421787f, -0.04458043f, 
    -0.01266207f, 0.19522980f, 0.01869367f, -0.00732492f, -0.18262210f, -0.14466718f, -0.05771539f, -0.23397683f, 
    -0.27391997f, -0.09081244f, -0.19387567f, -0.00776503f, 0.05044862f, 0.02256018f, 0.04162072f, -0.14594480f, 
    -0.14651954f, -0.18403849f, -0.16275154f, -0.11829744f, 0.23198470f, 0.14678714f, 0.19387889f, 0.03785698f, 
    0.00143246f, -0.07611724f, 0.06286272f, 0.16543211f, 0.12239695f, 0.06557056f, -0.06103758f, 0.03145276f, 
    -0.07713816f, -0.00061199f, 0.20245023f, 0.10259422f, 0.05408373f, 0.07504417f, -0.06216802f, 0.10112897f, 
    -0.02251302f, 0.08798220f, 0.09070747f, 0.11760601f, 0.02237915f, 0.05623462f, 0.02494696f, -0.07181343f, 
    0.01263445f, -0.00964236f, 0.00001233f, 0.09278347f, -0.04573152f, 0.08259231f, -0.13645372f, -0.24725883f, 
    0.10655393f, -0.06335528f, 0.28957057f, -0.03486742f, -0.06184702f, -0.01541517f, -0.08857974f, 0.06227338f, 
    0.03287868f, -0.12332048f, 0.24785139f, 0.08921043f, 0.13481945f, 0.05538208f, -0.05137377f, 0.02284136f, 
    0.04354727f, -0.03923127f, -0.04852101f, -0.16195315f, -0.05358268f, -0.15552308f, 0.17893955f, 0.21761517f, 
    0.24262723f, 0.19579327f, 0.15855742f, -0.12420132f, -0.00658464f, -0.05964708f, -0.00639747f, -0.05029896f, 
    0.08254115f, 0.10973498f, -0.08499628f, 0.05782891f, 0.08717605f, 0.14714625f, 0.18945087f, 0.07454981f, 
    -0.06031463f, -0.14750679f, -0.07296064f, 0.10066736f, -0.00036534f, 0.09661233f, 0.03836149f, 0.00352953f, 
    0.05503432f, -0.32359174f, 0.07501433f, 0.32146528f, 0.05396349f, 0.14863947f, 0.04431460f, 0.10105693f, 
    -0.04396324f, -0.05658969f, 0.09280997f, -0.07347906f, 0.06758069f, 0.24016356f, 0.02942359f, 0.05774419f, 
    -0.14737827f, 0.01192902f, -0.05107748f, 0.04675344f, 0.02331835f, 0.03993084f, 0.05597845f, 0.00237778f, 
    -0.26080200f, -0.17140108f, 0.11864147f, 0.06905801f, -0.02114500f, 0.03672352f, -0.21840930f, -0.16859902f, 
    -0.04017965f, 0.11655716f, -0.03616553f, -0.01202612f, 0.25378481f, 0.16325893f, 0.13792193f, 0.12697816f, 
    -0.14401995f, -0.06249071f, -0.06725699f, 0.18635578f, 0.03072769f, -0.07853758f, -0.08968160f, -0.13274638f, 
    -0.11024733f, -0.04609204f, -0.03985801f, -0.16694285f, -0.01545852f, 0.00115714f, 0.05265227f, -0.17110251f, 
    0.01581362f, 0.01055862f, -0.00334789f, 0.01828228f, -0.10992245f, -0.22664197f, -0.10564201f, 0.23533764f, 
    0.05612782f, 0.03678739f, 0.10373235f, -0.08785772f, 0.09558981f, 0.01512968f, -0.03861133f, 0.05461690f, 
    -0.01397231f, -0.00577741f, -0.05587051f, -0.01348236f, 0.02657408f, 0.05591051f, 0.00848099f, 0.02581653f, 
    -0.03024287f, 0.03044090f, -0.02437820f, 0.06086459f, -0.01186792f, -0.07830939f, 0.02005381f, 0.00991017f, 
    0.01403788f, 0.03073866f, -0.03965900f, 0.04085949f, -0.03650738f, -0.06971554f, -0.05673869f, -0.03611232f, 
    -0.02076904f, 0.01993963f, 0.03453755f, -0.07366145f, -0.03849075f, -0.03295130f, -0.01645458f, -0.04781663f, 
    0.04603218f, 0.02771651f, -0.05014841f, -0.07718566f, -0.02048060f, -0.01321208f, -0.06185532f, -0.06366293f, 
    -0.00683564f, 0.01667540f, -0.00315898f, -0.07170641f, 0.00078065f, 0.02889652f, 0.01344601f, -0.03333606f, 
    0.00770973f, 0.05794251f, 0.05938706f, -0.07376615f, -0.04873959f, -0.03274539f, -0.04777344f, -0.06443118f, 
    -0.03032613f, -0.04635652f, -0.01320815f, 0.05720210f, -0.04666703f, -0.06527086f, -0.00198152f, -0.06852177f, 
    -0.04547351f, -0.07672452f, -0.04338719f, -0.05139946f, -0.00601574f, -0.05156627f, -0.02099315f, -0.03550748f, 
    0.00834395f, -0.05941700f, -0.07428856f, 0.01210544f, -0.03426815f, -0.06526700f, 0.05481942f, -0.05846352f, 
    -0.04314549f, 0.04453970f, 0.04317114f, -0.04357624f, 0.06185161f, -0.03703440f, 0.01540991f, 0.01085315f, 
    -0.02222767f, 0.02776955f, -0.08168307f, -0.02440065f, -0.00491967f, 0.01786446f, -0.00902892f, -0.02185504f, 
    -0.01617097f, -0.07203218f, 0.02660734f, 0.00015535f, -0.05298387f, -0.00339432f, -0.06435435f, 0.01787824f, 
    -0.00933139f, 0.02290572f, -0.07480589f, -0.03045165f, 0.00576473f, -0.05662053f, 0.00025206f, -0.01109412f, 
    0.00385879f, -0.00571414f, 0.03069542f, -0.03169398f, 0.03918780f, -0.06578469f, 0.06262087f, 0.05818939f, 
    -0.03023553f, 0.01763301f, 0.01376692f, 0.04790615f, 0.05689895f, -0.04443873f, 0.05811224f, 0.01656088f, 
    0.01983933f, 0.04488143f, -0.04536021f, -0.00039922f, -0.01961873f, 0.03591761f, -0.02976372f, 0.05349502f, 
    -0.07016423f, -0.06538866f, 0.02067767f, 0.03177617f, 0.00944151f, -0.04756113f, -0.07571440f, 0.04075803f, 
    0.03976084f, 0.00304208f, -0.02620504f, 0.01753745f, 0.00000167f, -0.03342869f, -0.06404244f, -0.03489062f, 
    -0.05442001f, -0.02424568f, -0.03889593f, -0.01802498f, -0.05593768f, -0.06939160f, 0.05806974f, 0.01247010f, 
    -0.02740916f, 0.03052849f, -0.02347353f, 0.02725996f, -0.00739451f, 0.03738373f, 0.05466102f, -0.01337645f, 
    0.00014414f, -0.05354128f, 0.05399567f, -0.01813133f, -0.07752439f, 0.03415076f, -0.01632686f, -0.00731616f, 
    -0.01390270f, 0.00320033f, 0.04617385f, 0.04279495f, -0.04990483f, -0.00804026f, -0.00124527f, 0.00560056f, 
    -0.04185619f, -0.02438813f, -0.02655359f, 0.04274475f, 0.04809286f, -0.01793627f, 0.04531561f, 0.02893122f, 
    0.02532790f, -0.11443847f, 0.18883315f, 0.01238330f, -0.04794821f, -0.06753982f, 0.06438858f, 0.04459332f, 
    0.13050608f, -0.01412321f, -0.03950607f, 0.05919319f, -0.18080741f, -0.00814696f, -0.04249616f, -0.06380346f, 
    0.07008536f, -0.04374369f, 0.11354084f, -0.11934389f, -0.24477133f, -0.06953564f, -0.12439126f, -0.13668926f, 
    0.10330705f, -0.11521118f, -0.03675974f, -0.13951065f, -0.04797795f, -0.04690590f, -0.08109391f, -0.06520548f, 
    0.15805626f, 0.10424308f, -0.03139821f, -0.02730682f, -0.16336469f, -0.11920238f, -0.02313748f, -0.03835148f, 
    -0.07556204f, -0.07598441f, -0.15386808f, -0.13420966f, 0.04225546f, -0.13647841f, 0.10338826f, 0.09037286f, 
    -0.00374706f, -0.24152134f, -0.27088273f, -0.07387878f, 0.08129539f, -0.14363140f, -0.01359290f, 0.01280322f, 
    0.13910992f, -0.10556998f, 0.04585202f, -0.01309025f, 0.17411743f, 0.04111707f, -0.05462694f, -0.04633991f, 
    0.10910494f, 0.03216396f, -0.15219256f, 0.14216682f, -0.08703204f, 0.01798077f, 0.09850297f, 0.07552356f, 
    -0.04100126f, 0.04541392f, 0.08438005f, -0.21086381f, -0.07774227f, 0.09717190f, 0.00863609f, 0.05873160f, 
    0.18277529f, -0.07908153f, 0.10260464f, 0.11387662f, 0.10310057f, 0.06907725f, -0.03761101f, -0.01725352f, 
    -0.06241762f, 0.03013136f, 0.02079762f, -0.07888267f, 0.14523216f, -0.00695370f, -0.13327959f, -0.05488495f, 
    -0.23023303f, -0.16985759f, -0.12644465f, 0.07031231f, -0.15777686f, -0.13533990f, 0.11076912f, -0.03573105f, 
    0.10519116f, 0.06710291f, 0.07305358f, 0.02164773f, -0.14922360f, -0.30822346f, -0.22923619f, -0.00016566f, 
    -0.11712146f, 0.07404586f, 0.00626082f, 0.13657907f, 0.05476094f, -0.15263441f, 0.03028434f, 0.01884769f, 
    0.01649944f, -0.11157307f, -0.04354153f, -0.18774663f, -0.05876093f, -0.16575553f, -0.07387958f, -0.03361451f, 
    0.20266414f, 0.00635199f, 0.12283305f, 0.08135208f, -0.05842289f, -0.10436954f, 0.02489433f, 0.00059169f, 
    0.06588428f, 0.07007452f, -0.06801846f, 0.10241998f, 0.13161768f, -0.08531202f, -0.03365094f, 0.13388307f, 
    -0.04284731f, -0.01727742f, -0.11212808f, 0.06125769f, -0.09739202f, -0.05307516f, -0.00321733f, -0.13439673f, 
    0.23106472f, 0.12324695f, -0.13319501f, -0.05858861f, -0.09086751f, 0.18393058f, 0.01116065f, -0.05962885f, 
    -0.03231683f, -0.19675730f, 0.12505670f, 0.10025255f, -0.03204156f, -0.18551056f, -0.07879081f, -0.04854096f, 
    -0.02263100f, 0.01308727f, 0.15918602f, 0.04705000f, 0.09701458f, -0.05205380f, 0.10438592f, 0.05633603f, 
    -0.12002524f, 0.06625812f, 0.01661495f, -0.05993797f, 0.01224413f, 0.05670032f, 0.11792314f, -0.01448912f, 
    -0.08863461f, 0.00868889f, 0.02392804f, -0.00974764f, 0.01480957f, -0.00546982f, -0.04289159f, -0.18059984f, 
    0.16023406f, 0.09394483f, 0.21098961f, 0.04228719f, -0.07372075f, 0.01702577f, -0.02898798f, -0.14625649f, 
    0.03178149f, -0.11205576f, 0.00674432f, -0.06171002f, -0.04387422f, -0.07181852f, -0.05874932f, 0.07979399f, 
    0.13353573f, 0.14459452f, 0.04484781f, -0.10773327f, 0.07443157f, -0.07998399f, -0.03479616f, -0.02886043f, 
    0.27850416f, -0.01584094f, 0.32709792f, -0.03172304f, -0.06664830f, 0.02984050f, -0.17014493f, -0.10663304f, 
    0.00367908f, 0.10568074f, 0.21281447f, -0.03270401f, 0.19279867f, -0.00348943f, -0.31462279f, -0.16754156f, 
    0.00568987f, 0.09258959f, 0.00657388f, 0.18331169f, 0.23794839f, 0.11482534f, 0.05480331f, -0.02672539f, 
    0.07591116f, 0.03929484f, 0.10154487f, -0.20238733f, 0.22945654f, -0.11214585f, 0.08206380f, 0.07294045f, 
    0.07176830f, 0.05873306f, -0.06063725f, 0.00939108f, 0.18825673f, -0.09363332f, -0.12806474f, -0.13531050f, 
    0.16680487f, 0.08292864f, 0.13429841f, 0.12817711f, -0.01680273f, 0.02390689f, -0.06501866f, -0.01144092f, 
    0.28589678f, 0.20332308f, 0.44967279f, 0.04203648f, 0.07696451f, -0.02527581f, 0.29773247f, 0.04010820f, 
    -0.01162938f, 0.04987976f, -0.02021984f, 0.12119342f, -0.09744705f, 0.04835331f, 0.00161934f, -0.00557298f, 
    -0.05467166f, -0.10677223f, 0.01725494f, -0.10347203f, -0.00058061f, -0.09316191f, 0.10268446f, -0.00073462f, 
    0.09520668f, -0.60097355f, -0.41762510f, -0.31086519f, -0.03317226f, -0.13368987f, -0.09477077f, 0.12775008f, 
    0.00838634f, -0.04574568f, -0.00072532f, 0.03421298f, 0.16953295f, -0.13725477f, 0.11517541f, -0.20008236f, 
    -0.09953032f, -0.09755549f, -0.08325039f, 0.09774633f, -0.01855249f, 0.13337427f, 0.07165526f, 0.11133236f, 
    0.31051317f, -0.41112927f, -0.39030501f, -0.11743373f, -0.00037079f, -0.14023234f, 0.01227882f, 0.01802948f, 
    0.02402516f, -0.01322117f, 0.09191278f, 0.02284917f, 0.07645978f, 0.43205199f, -0.02481083f, 0.01038355f, 
    -0.00705625f, 0.12267337f, 0.14144933f, 0.30359611f, -0.00046861f, 0.04071011f, 0.00586573f, -0.01720112f, 
    -0.28048500f, 0.19599245f, 0.11513735f, 0.00752451f, 0.06999518f, -0.09581295f, -0.05509213f, -0.28197208f, 
    0.01551411f, -0.01686139f, 0.00290598f, 0.07758005f, 0.05472750f, 0.27545094f, -0.09066962f, 0.11677200f, 
    0.06851615f, 0.12664549f, 0.29662678f, 0.14113955f, 0.00173348f, -0.02298147f, -0.01905511f, -0.04164990f, 
    -0.06372531f, 0.20554130f, -0.00191664f, -0.04873229f, -0.02890156f, -0.11804369f, 0.03370392f, -0.01404306f, 
    0.10819157f, -0.00431073f, 0.01579547f, 0.00775014f, -0.01412737f, 0.07372358f, 0.02190773f, 0.24231979f, 
    0.05414279f, -0.04314712f, -0.02126155f, -0.11495192f, -0.04739435f, -0.17241265f, 0.02539709f, -0.03744986f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12300983f, 0.12003581f, -0.02249986f, 0.13044342f, 0.06910315f, -0.02302689f, -0.09701078f, -0.04227084f, 
    0.03891613f, 0.00472246f, 0.24209914f, 0.06115746f, 0.03556352f, 0.27917528f, 0.02060663f, 0.15617703f, 
    0.07563747f, -0.12291420f, -0.08194742f, 0.08458305f, -0.14646174f, 0.11518138f, -0.06774123f, 0.07628682f, 
    0.11781084f, 0.02142311f, 0.14142267f, 0.10082868f, 0.17453852f, -0.01579201f, -0.16239241f, 0.08120240f, 
    0.01568282f, 0.21033551f, 0.19523460f, 0.16608384f, 0.12479191f, -0.12634094f, -0.04082286f, 0.00386816f, 
    0.15989424f, 0.17155996f, 0.04294031f, 0.20692837f, 0.06200947f, 0.00984513f, 0.03924666f, 0.02095946f, 
    -0.05299522f, 0.10178820f, -0.12368745f, -0.00845671f, 0.04655153f, 0.09911631f, 0.03733810f, 0.08096215f, 
    -0.02997662f, 0.12607905f, 0.04417948f, -0.03309163f, -0.11493523f, -0.00850723f, -0.08478203f, 0.05697915f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.09368795f, 0.01355007f, -0.05059364f, 0.05267830f, 0.26821721f, 0.23503135f, 0.09220548f, -0.04092938f, 
    0.00335855f, -0.00972208f, -0.06441289f, 0.11009275f, 0.09863163f, -0.01752272f, 0.11801276f, 0.31102511f, 
    0.23467092f, 0.19287942f, 0.20734654f, 0.00084412f, 0.13232540f, 0.08829353f, -0.03075626f, -0.09791499f, 
    0.21415341f, 0.09136380f, -0.07666417f, 0.09388541f, 0.07558968f, -0.17330714f, 0.07465630f, 0.13573256f, 
    -0.00870441f, 0.11771673f, 0.16852787f, -0.23225501f, 0.08414628f, -0.15620200f, 0.05265288f, 0.07526988f, 
    0.03184284f, 0.14646333f, -0.27725035f, -0.15184124f, -0.05064450f, -0.13309237f, 0.19879438f, -0.06469084f, 
    0.08036455f, 0.11562165f, 0.17382877f, -0.18391104f, 0.11776527f, -0.62274021f, -0.23768350f, -0.06845612f, 
    0.15891251f, -0.10374285f, -0.09409758f, -0.08837996f, -0.01250028f, -0.01099107f, -0.14580837f, -0.14284591f, 
    0.26477328f, -0.09053796f, -0.06736865f, 0.29963326f, 0.36510992f, 0.09341198f, -0.14409778f, -0.10205477f, 
    -0.12591986f, 0.01244418f, 0.12871884f, 0.07231931f, 0.03610441f, 0.03743856f, 0.20800371f, 0.07326654f, 
    0.06122536f, 0.23481071f, -0.14337035f, 0.26602161f, 0.31110257f, 0.25673214f, 0.03659566f, 0.02490562f, 
    0.15024860f, 0.11228058f, -0.25858653f, -0.15048116f, 0.31877360f, -0.23021235f, 0.15396646f, 0.19793841f, 
    0.10315945f, 0.25419608f, 0.08753928f, 0.09445237f, -0.06086681f, -0.04169627f, -0.09443440f, -0.09052365f, 
    -0.23476295f, -0.06464275f, -0.01958342f, -0.03648150f, 0.03021466f, 0.07842197f, 0.00731900f, -0.12371251f, 
    -0.08405013f, -0.10862660f, 0.12789036f, 0.23977427f, 0.08091602f, 0.08929399f, 0.01339418f, 0.01512311f, 
    0.30186754f, -0.10719566f, -0.21435747f, 0.10716410f, 0.10212347f, 0.02028185f, -0.06016243f, 0.11790553f, 
    -0.00731203f, -0.07019320f, 0.11659932f, -0.04403457f, 0.01512523f, -0.10249950f, -0.02860026f, 0.01256113f, 
    0.04427388f, -0.04108714f, -0.05527501f, -0.06970301f, 0.01981175f, -0.05476187f, -0.02973688f, -0.10738112f, 
    0.03954631f, -0.02182780f, -0.03394568f, 0.02226856f, -0.05829932f, 0.03027010f, 0.01628615f, 0.08604786f, 
    -0.04392752f, 0.01737566f, -0.10065645f, 0.04856324f, -0.09761336f, 0.01532236f, -0.04290688f, -0.01232441f, 
    -0.10277002f, -0.10572577f, 0.00039767f, -0.05446848f, -0.07460907f, 0.00522780f, -0.12030187f, -0.12404518f, 
    -0.01063807f, -0.04280414f, 0.04960708f, -0.01713999f, 0.05534990f, 0.00058843f, -0.07721728f, -0.01520702f, 
    0.00838937f, -0.06560475f, -0.11893119f, 0.00199960f, -0.01009949f, -0.09591196f, -0.07249096f, 0.02786218f, 
    -0.01231666f, 0.05583861f, -0.05808185f, -0.08488613f, -0.03763181f, 0.02205041f, -0.10714325f, -0.06840841f, 
    0.11707206f, -0.30007738f, -0.07752223f, 0.31789050f, 0.16756709f, -0.11747649f, -0.16605125f, -0.18292820f, 
    0.11282308f, 0.11270019f, 0.27767012f, -0.02802598f, 0.16903789f, 0.16298512f, 0.16512729f, -0.18494293f, 
    -0.20555735f, -0.15593657f, -0.19841591f, 0.23205985f, 0.01718149f, -0.04103868f, -0.09108286f, -0.07178059f, 
    -0.09621342f, 0.13786782f, -0.00659210f, -0.13104780f, 0.06130977f, 0.04288300f, -0.06854451f, 0.15101536f, 
    -0.04200659f, 0.21913813f, 0.03882495f, 0.40605906f, -0.02185697f, -0.07148744f, -0.01155018f, -0.10318509f, 
    0.10814326f, -0.16451795f, 0.16244584f, 0.46184328f, -0.07486761f, 0.11362588f, -0.12794498f, 0.05369796f, 
    -0.05023811f, -0.19932942f, -0.13193364f, 0.21390487f, 0.13268581f, 0.22864112f, -0.00025775f, -0.11419592f, 
    -0.02500312f, -0.03481058f, 0.12024301f, 0.05585258f, 0.23748283f, -0.06163549f, -0.19902098f, 0.39758980f, 
    0.06149917f, -0.11929812f, 0.02543974f, -0.19192679f, -0.33679318f, 0.00319436f, -0.20390341f, 0.23830864f, 
    0.11508640f, -0.11740679f, 0.10317117f, 0.00823732f, -0.08658244f, -0.13031860f, 0.23285897f, 0.11833144f, 
    0.16115479f, 0.16377331f, 0.00566185f, -0.01740093f, -0.07626589f, 0.04286656f, -0.02190307f, -0.13103570f, 
    0.07491115f, -0.00676693f, 0.07729764f, 0.09507365f, -0.20854135f, -0.01257148f, -0.05917934f, 0.01984739f, 
    0.08721442f, 0.32568491f, -0.01840166f, -0.04182533f, 0.10858092f, 0.10814769f, -0.11011745f, -0.10963412f, 
    0.00836822f, -0.16379675f, -0.08119283f, -0.03150434f, -0.04430984f, 0.05026459f, 0.02415735f, 0.00824116f, 
    -0.01382634f, -0.08601782f, 0.10483172f, 0.06545300f, 0.03172322f, -0.35235125f, -0.27970806f, 0.21308331f, 
    0.01781951f, 0.02519608f, -0.11072370f, -0.00096109f, -0.00830663f, 0.07658976f, -0.10638182f, -0.27863887f, 
    -0.03798170f, -0.09795198f, -0.03229773f, -0.02147386f, -0.02794567f, -0.20307392f, -0.02810437f, -0.15977912f, 
    0.04346476f, 0.06827217f, -0.01960380f, 0.07980487f, -0.23355250f, -0.03166982f, -0.13719417f, -0.09708212f, 
    -0.03073469f, -0.12389484f, -0.03353497f, 0.17495431f, -0.05125656f, -0.14941733f, -0.05295870f, 0.11848120f, 
    0.12601611f, 0.07031801f, -0.05706965f, -0.12690710f, 0.20999680f, 0.00768187f, -0.13573983f, 0.23275997f, 
    -0.00121553f, -0.04474452f, -0.09361859f, -0.03836625f, -0.11292041f, 0.11143127f, 0.04943841f, 0.11030810f, 
    -0.04910673f, -0.15466356f, 0.18334882f, -0.05201510f, -0.06143085f, -0.19285759f, -0.04637142f, -0.02366791f, 
    -0.02441691f, 0.04673778f, -0.01135270f, -0.04169937f, 0.07337584f, -0.06227831f, -0.10865847f, -0.09784638f, 
    0.02970188f, 0.08283807f, -0.18494220f, -0.07622461f, 0.12066894f, -0.09336152f, 0.08223339f, 0.11253687f, 
    -0.32838529f, 0.01553218f, -0.05055922f, 0.17465262f, -0.09190331f, 0.02696253f, -0.23291284f, 0.36699283f, 
    -0.01091182f, -0.09402487f, -0.22510223f, -0.06751713f, -0.12761304f, -0.01088429f, -0.26398790f, -0.14061880f, 
    0.06059326f, 0.06719648f, -0.01031912f, -0.16083021f, -0.31442833f, -0.12493675f, 0.07518789f, -0.38009351f, 
    -0.28493541f, -0.18683971f, 0.21532317f, 0.14958729f, -0.02612556f, 0.18799037f, -0.15285142f, 0.16491325f, 
    -0.09221953f, 0.03147384f, -0.07856818f, -0.14996172f, -0.15140255f, 0.06375360f, 0.07564534f, 0.10223979f, 
    0.17527676f, 0.02734004f, 0.14734736f, 0.07004846f, 0.08602586f, 0.17989643f, -0.10804775f, 0.06626759f, 
    0.00211444f, 0.12020274f, 0.21905692f, -0.46545199f, 0.04713115f, -0.08035447f, -0.07038327f, 0.09167074f, 
    0.10563033f, 0.02134825f, 0.04663678f, 0.07838766f, -0.15260611f, 0.07962053f, 0.26967144f, 0.21624230f, 
    0.00818655f, -0.05870736f, -0.00427148f, -0.05791413f, 0.03830986f, 0.02933232f, 0.06499359f, 0.05414587f, 
    -0.10608472f, -0.04718970f, 0.10842142f, 0.06032717f, -0.00733206f, -0.05533268f, -0.05604706f, -0.09496555f, 
    0.07836512f, 0.06866004f, -0.03919346f, 0.09468991f, -0.03714045f, 0.06166343f, 0.08378863f, -0.09679240f, 
    -0.09980892f, 0.00379169f, 0.04344333f, -0.03443070f, -0.04954351f, -0.15946743f, -0.06346676f, -0.11989120f, 
    0.00866680f, -0.06896482f, 0.04105118f, 0.05279077f, -0.09094632f, 0.01864548f, 0.06983136f, -0.05510330f, 
    0.03782921f, -0.10364906f, 0.02681140f, -0.10237718f, -0.02268764f, -0.03800216f, -0.06630324f, 0.02077077f, 
    -0.04843958f, -0.11279624f, -0.17329425f, -0.09241187f, -0.05228533f, -0.04850140f, -0.05704785f, 0.02137402f, 
    -0.08094528f, 0.02834165f, -0.05928354f, -0.01623546f, 0.07568062f, -0.06088309f, -0.06292421f, 0.05089207f, 
    -0.21549290f, 0.14356761f, -0.08341172f, -0.20392960f, 0.09232698f, -0.00293450f, -0.25989228f, -0.09222761f, 
    -0.08096196f, -0.12362635f, -0.14079358f, 0.03177874f, -0.05561898f, 0.02580623f, 0.17491807f, -0.18850869f, 
    -0.03425162f, 0.04207921f, -0.07675575f, 0.01909444f, -0.16823533f, -0.05214200f, 0.04464768f, 0.04574616f, 
    0.02081343f, -0.15317526f, -0.11887238f, 0.15263574f, 0.09717193f, -0.07909364f, -0.19626269f, -0.01375915f, 
    -0.05784202f, -0.06576636f, 0.26114431f, 0.18749645f, -0.18147206f, 0.00512049f, 0.03921040f, -0.10666105f, 
    0.04108341f, -0.05434052f, 0.28320208f, -0.08208589f, -0.10582781f, 0.22120246f, -0.24215887f, 0.10472991f, 
    -0.03311946f, -0.19695978f, 0.14657225f, -0.52047306f, -0.05867139f, 0.08124711f, -0.36109269f, 0.09434810f, 
    0.01754806f, -0.16918871f, 0.11476208f, -0.01140277f, -0.12380161f, 0.02580845f, 0.13323662f, 0.30624455f, 
    0.01659786f, -0.00505297f, -0.09040848f, 0.06161883f, -0.14178976f, 0.16238728f, -0.37702873f, 0.09020821f, 
    -0.07567505f, 0.04183403f, 0.23310077f, 0.10784248f, 0.04027844f, 0.35889930f, -0.01955719f, 0.12063196f, 
    0.17205386f, -0.14313075f, 0.12908639f, -0.09232892f, -0.01252639f, -0.01226512f, -0.09529763f, -0.00337551f, 
    0.22228013f, 0.04766510f, 0.16895913f, -0.17415059f, 0.23904575f, 0.08533503f, -0.05375945f, 0.04604534f, 
    0.09953620f, 0.15206495f, 0.12269900f, 0.38010907f, 0.24023700f, -0.14759225f, 0.15417163f, -0.11744750f, 
    0.24229741f, 0.06212943f, -0.15012360f, 0.03063188f, 0.08706143f, -0.27214906f, 0.20714960f, 0.08264542f, 
    0.01845357f, 0.32314986f, -0.02049814f, 0.07368976f, -0.06744715f, -0.04343968f, 0.12005932f, 0.01714803f, 
    -0.15697183f, 0.22591883f, 0.18402044f, 0.01805669f, 0.09391243f, -0.11912673f, -0.09509397f, -0.29942232f, 
    0.17212722f, -0.03965815f, 0.05825993f, -0.32435942f, -0.12702639f, 0.20255055f, 0.31479722f, 0.06536652f, 
    0.09957176f, -0.04001333f, 0.06214084f, 0.08197601f, -0.06822589f, 0.17210107f, -0.04526078f, 0.10117742f, 
    -0.00544597f, -0.15635449f, 0.00135930f, -0.20023410f, 0.02081748f, 0.13215575f, -0.11113334f, 0.02459882f, 
    0.13261576f, -0.31236175f, 0.16174163f, 0.06621892f, 0.38806075f, -0.08898421f, -0.15507084f, -0.04704352f, 
    -0.09216975f, -0.14029089f, 0.23736385f, 0.36726871f, -0.24300589f, 0.02141057f, 0.24725269f, 0.11712427f, 
    0.16089812f, 0.04185393f, 0.03745967f, -0.12108033f, 0.00070742f, -0.07174665f, -0.23377344f, 0.11710069f, 
    -0.01128818f, -0.03186261f, -0.05957514f, -0.11510361f, 0.11373967f, -0.04062387f, -0.14908615f, -0.00360499f, 
    -0.19821084f, 0.02230836f, -0.10977839f, 0.09823357f, -0.27185282f, -0.05107147f, 0.30180308f, 0.12096725f, 
    0.03412308f, 0.04479060f, -0.07433818f, 0.10369962f, -0.02298990f, -0.11451545f, -0.03482887f, -0.09479625f, 
    -0.12402734f, -0.02374047f, 0.09126154f, 0.04392621f, 0.04265437f, -0.07523387f, -0.05483305f, 0.00608062f, 
    -0.00740043f, -0.06840505f, -0.01087562f, 0.00701016f, 0.06320029f, -0.02147402f, 0.07893886f, -0.08682518f, 
    0.00922488f, -0.05358910f, -0.06224015f, 0.05292563f, -0.02155716f, -0.05347716f, 0.07699743f, -0.05373091f, 
    -0.01099388f, -0.13114114f, -0.07053978f, 0.06638703f, -0.04497330f, -0.03053661f, -0.12502748f, -0.02615674f, 
    0.03076326f, 0.03081421f, -0.05789270f, -0.07211984f, -0.03041942f, -0.07845765f, -0.07673547f, 0.08885217f, 
    -0.11430602f, -0.08313684f, -0.04333686f, 0.08364289f, -0.10998863f, -0.09221391f, -0.02298805f, -0.09807736f, 
    -0.11981463f, 0.01518627f, 0.03902898f, 0.06362712f, -0.10668339f, 0.11292817f, -0.08485457f, -0.06102256f, 
    0.16358840f, -0.07898424f, -0.10589260f, 0.15309699f, 0.15247555f, -0.21065220f, -0.09225046f, -0.30351087f, 
    0.06765037f, -0.10411794f, 0.17356481f, 0.00808590f, 0.14154567f, -0.01364475f, 0.16342559f, 0.06820210f, 
    -0.23147365f, 0.00631406f, -0.08016861f, -0.06342360f, 0.03731450f, -0.08848719f, 0.04913338f, 0.10662781f, 
    0.04753891f, 0.13516589f, 0.13470247f, -0.01191651f, 0.07135554f, -0.01416515f, -0.11809600f, 0.00445687f, 
    -0.04672261f, 0.10738489f, 0.15517171f, 0.26681075f, 0.01271976f, 0.07322711f, -0.07694203f, -0.05784433f, 
    0.14480804f, -0.04219096f, 0.14301465f, 0.32970938f, 0.03440171f, -0.05959701f, 0.10539923f, 0.16013747f, 
    -0.12806098f, -0.20647350f, -0.04854910f, 0.22049689f, -0.08142450f, 0.21103641f, 0.27988067f, 0.04531240f, 
    -0.10755141f, -0.14291908f, 0.07668418f, -0.08271052f, 0.05241364f, 0.03386072f, -0.04413779f, 0.22151634f, 
    -0.30990705f, 0.24751006f, -0.01787966f, -0.10907314f, -0.13530408f, 0.07938671f, -0.02090625f, 0.32138541f, 
    -0.01723087f, 0.03210013f, -0.00549567f, -0.01206925f, 0.03956508f, 0.00965965f, 0.05424907f, 0.15668826f, 
    -0.14208661f, -0.06157723f, 0.17177589f, 0.01330171f, -0.04804209f, 0.15190040f, -0.02916706f, 0.01947092f, 
    0.25634333f, -0.14682981f, 0.27574900f, 0.19068329f, -0.20543560f, -0.19814730f, 0.25841892f, 0.07520284f, 
    -0.06356400f, -0.07529878f, -0.03850977f, -0.13032849f, 0.05577761f, -0.09849160f, 0.27179495f, -0.02241039f, 
    0.28534180f, 0.28032115f, 0.14223731f, -0.37658265f, -0.09743515f, -0.11408136f, 0.03166746f, -0.26587781f, 
    -0.00118154f, 0.21208990f, 0.28412846f, 0.08581445f, 0.02989574f, -0.22149536f, 0.37734327f, 0.26739383f, 
    -0.16442820f, 0.20536286f, 0.10678691f, 0.00396116f, -0.08773506f, -0.05419309f, 0.11816809f, -0.27547777f, 
    -0.14127144f, 0.12735079f, -0.07918892f, 0.15924855f, -0.15599249f, 0.21322776f, -0.28933692f, 0.27270868f, 
    0.02990540f, 0.09149246f, -0.03730603f, -0.04090158f, 0.19196029f, 0.28634825f, 0.02852428f, -0.05419448f, 
    0.27884451f, 0.14004612f, -0.05459627f, -0.11520451f, -0.17047444f, -0.09990778f, 0.11210745f, -0.26414230f, 
    -0.16588198f, 0.01677004f, 0.21837604f, -0.09497996f, -0.27627978f, 0.22926013f, -0.06626015f, -0.01658245f, 
    0.10331416f, 0.20135200f, 0.20857507f, -0.02201270f, 0.05393063f, -0.05048127f, 0.16464257f, 0.05532628f, 
    0.26975963f, 0.12495529f, -0.00418481f, 0.14905442f, 0.05915530f, 0.01923990f, 0.16374096f, -0.04119282f, 
    0.02633315f, 0.27176771f, 0.14765525f, -0.01168697f, -0.10527956f, -0.20520432f, 0.11298297f, 0.14352846f, 
    0.00854856f, 0.30972657f, 0.18171409f, -0.06851237f, 0.06492088f, -0.04173819f, 0.15979952f, -0.10380968f, 
    -0.01784622f, -0.09214193f, 0.01101536f, -0.12947924f, -0.08125910f, -0.01241708f, 0.12000893f, 0.10518026f, 
    0.10029194f, -0.04466206f, 0.07568521f, -0.06624074f, -0.05901723f, 0.03104259f, 0.03629854f, 0.01799990f, 
    0.06749534f, -0.01746229f, -0.13193117f, -0.05341924f, 0.03932418f, -0.10669410f, -0.00479908f, -0.01116529f, 
    0.05441661f, 0.01165053f, -0.08137789f, 0.00004539f, -0.02242126f, -0.03736233f, 0.07465786f, 0.05789971f, 
    -0.02166203f, -0.08315658f, -0.05831918f, -0.09735487f, -0.10798309f, -0.08740542f, -0.07884777f, 0.11384702f, 
    -0.02468479f, 0.09048803f, -0.05112778f, 0.03122893f, -0.10261802f, -0.14001031f, -0.14320725f, 0.02072340f, 
    0.10916417f, 0.00525612f, -0.00717568f, -0.08932573f, -0.04275303f, -0.02247688f, -0.05150508f, 0.05456243f, 
    -0.04488349f, -0.04778382f, -0.07046683f, 0.08195923f, -0.01949336f, -0.04807544f, 0.05302876f, -0.02648052f, 
    0.26978055f, -0.12091824f, 0.07704786f, 0.15912239f, 0.40265206f, -0.14416298f, 0.30065113f, -0.25522065f, 
    -0.00092125f, 0.11167859f, 0.04600760f, 0.02381698f, 0.20512570f, -0.24639714f, 0.30212736f, 0.19201584f, 
    -0.19062193f, 0.10314488f, 0.13062672f, -0.00798001f, 0.06299983f, 0.17704913f, 0.12350716f, 0.24373078f, 
    -0.03670214f, 0.10746247f, -0.14774926f, 0.09327302f, 0.13651331f, -0.20092683f, 0.11923266f, -0.07003516f, 
    0.12255317f, 0.14155342f, -0.01768539f, 0.07386924f, -0.11703106f, 0.19780286f, -0.28498542f, -0.11231890f, 
    0.04446797f, 0.14119804f, 0.28969586f, 0.12236475f, 0.02100625f, 0.18734618f, 0.09659334f, 0.15609959f, 
    0.03856573f, -0.20676354f, 0.21314739f, 0.26822057f, 0.07108871f, -0.10255910f, 0.22301652f, 0.09516396f, 
    -0.10437144f, -0.24187860f, -0.12994805f, -0.05330485f, 0.13559300f, 0.11184520f, 0.24097012f, 0.09508925f, 
    0.01922185f, 0.12221237f, 0.05553856f, 0.00671915f, -0.14176819f, 0.01378672f, -0.20424819f, 0.00492316f, 
    0.08796210f, -0.05859972f, 0.27426857f, 0.06407576f, -0.12543504f, 0.07615066f, 0.16958678f, -0.05252330f, 
    -0.13362944f, 0.00476260f, -0.22501847f, 0.21139941f, 0.12007762f, 0.19525427f, 0.02683572f, 0.10119535f, 
    0.16287392f, 0.05980286f, -0.03077791f, -0.00510094f, 0.10130272f, -0.09645576f, 0.17471462f, 0.09778628f, 
    0.00177320f, -0.07910145f, -0.03211778f, 0.11848722f, -0.10116970f, -0.32864276f, -0.14111622f, -0.06150728f, 
    0.04101795f, -0.06552534f, 0.08728305f, 0.27347928f, -0.05728872f, 0.10117939f, -0.04245210f, 0.01348915f, 
    -0.07637177f, -0.14313804f, -0.29296467f, 0.26024893f, -0.07606266f, 0.32568371f, 0.00470186f, 0.17188637f, 
    -0.13418457f, 0.11569574f, -0.24705550f, 0.06157702f, -0.05747360f, -0.09840854f, -0.08866757f, 0.07190122f, 
    -0.00766818f, 0.15012476f, 0.06160970f, -0.22992225f, -0.12096626f, 0.16808969f, 0.36406267f, 0.40086666f, 
    -0.04876298f, 0.04604014f, -0.27413809f, 0.11411019f, -0.03762881f, -0.10465478f, 0.04005060f, -0.11899797f, 
    0.25255209f, 0.30236244f, 0.06683322f, 0.15651497f, -0.11426014f, 0.14456278f, -0.05766602f, -0.26688650f, 
    -0.24301846f, 0.12300249f, -0.01001807f, 0.15963688f, -0.14922829f, 0.14570920f, 0.16207519f, 0.08985018f, 
    0.04829884f, -0.07260770f, 0.02164291f, -0.49541801f, -0.32001036f, -0.11071904f, 0.12876920f, -0.05278495f, 
    -0.12160856f, 0.12938340f, 0.27590093f, -0.30840760f, 0.07010620f, 0.06804898f, -0.09083725f, -0.36375046f, 
    -0.03203652f, 0.15621956f, 0.22170396f, 0.06921442f, 0.10032833f, -0.26572052f, -0.20181969f, 0.12225603f, 
    0.25959232f, -0.07327151f, -0.13346916f, 0.11056089f, -0.17126232f, -0.01693066f, 0.16851319f, 0.06072697f, 
    0.02953197f, 0.06119781f, 0.01115719f, 0.15017310f, 0.10532900f, 0.11569178f, -0.07450626f, -0.23413658f, 
    -0.11019857f, 0.08281944f, 0.27327225f, 0.05087378f, -0.18699779f, 0.09843634f, -0.06329682f, -0.13745111f, 
    0.04681209f, 0.02714432f, -0.01127868f, 0.10071527f, -0.16262397f, 0.18137425f, 0.08898348f, -0.02445668f, 
    0.09233813f, 0.07858305f, 0.10003338f, 0.08178161f, 0.41885865f, 0.06124641f, -0.20092712f, -0.05042395f, 
    0.01288597f, -0.00189291f, -0.13633426f, 0.18374713f, 0.09965603f, -0.24910620f, -0.23371597f, -0.01649353f, 
    -0.14511110f, 0.00423378f, 0.10768749f, 0.40111479f, 0.07632659f, 0.23658320f, 0.04027554f, 0.10425224f, 
    0.13148789f, 0.11382166f, -0.23810415f, 0.27139080f, 0.00774823f, 0.11021157f, 0.01776772f, -0.12040718f, 
    0.05412127f, -0.07145841f, -0.34978932f, -0.04864237f, -0.03096024f, 0.12062792f, -0.17284426f, 0.10347924f, 
    0.17431450f, -0.20135985f, -0.02110225f, 0.06601050f, 0.05760209f, 0.03072668f, -0.23622349f, -0.23949426f, 
    -0.06007639f, -0.06553663f, 0.22632325f, 0.04046382f, 0.05328897f, 0.31830585f, 0.04091091f, 0.03083395f, 
    0.07672187f, -0.15841550f, 0.03552931f, 0.17530377f, -0.07274011f, 0.09872570f, -0.03414017f, -0.20033333f, 
    0.16054808f, 0.03264396f, -0.04747838f, -0.23016319f, 0.09054710f, 0.13833967f, -0.17922825f, 0.20555422f, 
    -0.05886937f, 0.14955267f, 0.17803209f, 0.37683818f, 0.11589488f, -0.06472205f, 0.11242290f, 0.04762027f, 
    0.15701899f, -0.31012189f, -0.16619691f, 0.35272062f, -0.12803300f, -0.01347002f, -0.05962707f, -0.04166856f, 
    0.07795641f, 0.14085424f, -0.25344652f, -0.09031732f, 0.12932572f, -0.02559940f, -0.11721070f, -0.15105328f, 
    0.05541656f, 0.04570051f, 0.16713634f, 0.09657037f, 0.18038964f, 0.05129665f, -0.18135914f, 0.13318960f, 
    -0.26757100f, 0.12125932f, 0.07159852f, -0.11249193f, -0.21518309f, 0.20448288f, -0.17695650f, 0.20896588f, 
    0.01616394f, 0.06010658f, -0.07581296f, -0.12999353f, -0.06148171f, 0.17419533f, 0.10605390f, -0.02577392f, 
    0.19660485f, 0.17467749f, 0.10415462f, -0.32247317f, -0.30416900f, 0.06865827f, -0.07022622f, -0.14133690f, 
    -0.06461809f, -0.28599167f, -0.00706669f, 0.09199091f, 0.28129011f, 0.23353653f, -0.27060145f, -0.20476733f, 
    -0.10164779f, 0.14419842f, 0.00897049f, 0.23106867f, -0.11312053f, -0.04254791f, 0.14777085f, 0.03766698f, 
    0.08887023f, 0.12180856f, 0.03631118f, 0.22491741f, 0.07477777f, -0.06974093f, 0.06840499f, 0.30233008f, 
    -0.02858257f, 0.21219018f, 0.24215035f, -0.36884597f, 0.10206458f, -0.20908454f, -0.39200389f, 0.11993010f, 
    -0.18466258f, 0.06061554f, 0.02304579f, -0.00211151f, -0.29328421f, -0.02577205f, 0.22388120f, 0.19318505f, 
    0.21518871f, -0.04847967f, 0.06024835f, 0.03303206f, 0.24513485f, 0.22788620f, -0.00645896f, 0.28355658f, 
    -0.10641308f, 0.04812901f, -0.05936002f, 0.04526611f, 0.00815039f, 0.14808168f, -0.15919834f, 0.10703348f, 
    0.03520717f, 0.05551847f, 0.10518405f, -0.09973615f, 0.20503403f, 0.04534791f, -0.11399248f, -0.16222502f, 
    0.03548884f, 0.08309764f, 0.09085141f, 0.01693984f, 0.24155797f, 0.16923423f, -0.15377092f, 0.13767788f, 
    -0.10339564f, 0.08939960f, 0.11964912f, -0.05163752f, -0.16613783f, -0.14059556f, 0.15978920f, -0.05570975f, 
    0.01050546f, -0.33439627f, 0.10409353f, 0.12034912f, -0.09177019f, 0.19946434f, -0.39606318f, 0.16557655f, 
    -0.10634720f, 0.06662615f, -0.11191428f, -0.25930640f, 0.02801221f, -0.04650148f, -0.32825249f, -0.10015827f, 
    0.21790777f, -0.04117007f, -0.13756266f, -0.04576696f, 0.12170649f, -0.05673268f, -0.12260357f, 0.24615157f, 
    -0.21009371f, 0.12861188f, 0.12831418f, -0.05864822f, -0.15352406f, -0.11745421f, 0.24560711f, 0.07841913f, 
    0.10382558f, 0.09410483f, -0.12075054f, -0.00910723f, 0.09016696f, -0.27148491f, 0.17283908f, -0.27770311f, 
    -0.15200248f, 0.08738010f, 0.03764209f, 0.30287546f, -0.07662228f, 0.09696867f, 0.01555248f, -0.16963646f, 
    -0.11237646f, 0.04427736f, -0.12475226f, -0.07469832f, -0.16878012f, -0.04004553f, 0.22580241f, 0.11562809f, 
    -0.04779273f, 0.15784147f, 0.00086170f, -0.07885764f, -0.02501991f, 0.01369947f, 0.15836909f, 0.06831425f, 
    0.04168876f, 0.17019577f, 0.12588328f, -0.23421583f, -0.10709897f, -0.12490640f, 0.06287040f, -0.12965682f, 
    -0.03999017f, 0.01424387f, 0.39940521f, 0.20701773f, 0.08197907f, 0.27199635f, 0.25980431f, 0.02949383f, 
    0.16214098f, 0.06260490f, 0.41408005f, 0.10441029f, 0.16873269f, 0.10261121f, 0.04523282f, 0.13442484f, 
    0.05999607f, 0.08969779f, -0.11518605f, 0.07877517f, -0.08575477f, 0.19041324f, -0.27584270f, 0.31769031f, 
    0.05947280f, 0.00745937f, 0.01506500f, -0.06260634f, 0.17652115f, 0.21180683f, 0.13236426f, 0.01406663f, 
    0.10023861f, -0.00582388f, -0.04291251f, 0.04641854f, 0.22884874f, 0.00918654f, 0.05211165f, -0.00061312f, 
    -0.03082031f, -0.08364258f, 0.13914271f, 0.08817794f, 0.24012111f, 0.13302606f, 0.13312995f, -0.00748213f, 
    0.09371982f, 0.10879899f, 0.11405997f, 0.02067424f, -0.31682014f, -0.10717402f, 0.12505871f, -0.01661581f, 
    0.31328261f, -0.21765937f, -0.06473002f, 0.00071441f, -0.09808597f, 0.26806509f, -0.27608064f, 0.18455163f, 
    -0.10261325f, 0.04854318f, -0.15139659f, -0.09397553f, 0.09845050f, -0.27423322f, 0.05214856f, 0.25626245f, 
    0.06466470f, 0.11942428f, -0.16506620f, -0.11336949f, -0.06061749f, 0.08554019f, 0.04600288f, 0.14826709f, 
    -0.03109595f, 0.24254502f, -0.02740666f, -0.15978262f, -0.07592028f, 0.21587265f, -0.30346924f, 0.05783742f, 
    -0.08966114f, -0.03497235f, -0.06092525f, -0.06954864f, -0.03270866f, 0.01230063f, -0.10770155f, 0.02839805f, 
    0.30451840f, 0.00767799f, 0.20535921f, -0.15137954f, -0.21901315f, -0.04380491f, 0.03344686f, -0.01713661f, 
    0.12317751f, -0.35931540f, 0.11838531f, 0.19595066f, 0.46867964f, 0.07474398f, -0.47617376f, -0.12851794f, 
    0.00975876f, 0.01459098f, 0.12933600f, 0.25237003f, -0.28643349f, 0.00385941f, 0.23608874f, 0.02821329f, 
    0.11269766f, 0.23760189f, 0.15259367f, 0.10294560f, 0.01058173f, 0.28358194f, -0.09357695f, -0.00896950f, 
    0.11880665f, -0.00827406f, 0.11428107f, -0.54520196f, 0.01635323f, -0.24938440f, -0.40096903f, 0.05913786f, 
    -0.16342619f, -0.00868466f, -0.02572750f, 0.00217591f, -0.26825929f, 0.08101845f, 0.09555283f, 0.12659585f, 
    -0.04787607f, 0.01182723f, 0.09106766f, 0.16569640f, -0.26872939f, -0.14424151f, -0.63282198f, -0.32831299f, 
    0.11555640f, -0.02256036f, -0.00673540f, 0.08270995f, -0.19028969f, 0.08212917f, 0.09427314f, -0.22089124f, 
    -0.11421502f, -0.21805222f, -0.16032967f, 0.19382085f, 0.11016726f, 0.08025242f, -0.08748858f, 0.28092983f, 
    0.16940023f, -0.05039877f, 0.00976000f, 0.00112531f, 0.24561203f, 0.10067923f, 0.04576318f, 0.12120404f, 
    0.07909796f, 0.01477108f, -0.02480546f, 0.38181582f, 0.29105428f, -0.14445141f, 0.03811955f, 0.03576900f, 
    0.00383806f, 0.12396281f, 0.02552812f, 0.20284395f, -0.12117680f, -0.11990728f, 0.22158732f, -0.04568094f, 
    0.00953657f, 0.06627566f, 0.01179642f, 0.21149635f, -0.08471283f, 0.43196893f, 0.16977708f, 0.14905851f, 
    -0.05348883f, 0.22356004f, -0.09260971f, -0.10932389f, -0.00906009f, 0.03071156f, -0.20283009f, 0.14003985f, 
    0.11258952f, -0.07768104f, -0.02385661f, 0.11337934f, 0.04019647f, 0.03601944f, 0.45976281f, 0.18116705f, 
    -0.02036398f, 0.03086073f, -0.01142626f, -0.08493332f, 0.09229729f, 0.03754599f, -0.18239096f, -0.11600802f, 
    -0.09394282f, 0.16886868f, 0.03654322f, 0.06906606f, 0.00458029f, -0.18864331f, -0.03445876f, -0.50474733f, 
    -0.30472502f, 0.03126139f, 0.24873473f, -0.07801134f, -0.26600546f, 0.01456083f, 0.04353631f, 0.18080804f, 
    -0.11209168f, 0.16023424f, 0.13269392f, -0.15766238f, -0.10082893f, 0.12571965f, 0.07071093f, 0.02345911f, 
    0.35404524f, -0.08302212f, 0.23517096f, 0.11708311f, 0.07402609f, 0.16895778f, -0.26002488f, 0.03586807f, 
    0.11200833f, -0.06974102f, 0.18274988f, 0.03560666f, -0.00123385f, -0.02125094f, 0.17038687f, 0.00793565f, 
    0.12893820f, 0.14718635f, 0.40012962f, 0.04277463f, 0.12938841f, 0.02891349f, -0.07034112f, 0.30549508f, 
    0.04641207f, -0.26721680f, -0.06846983f, 0.07587388f, -0.18250500f, 0.29427803f, 0.55514830f, 0.06655917f, 
    -0.00255744f, 0.05601463f, 0.19289067f, -0.05152974f, -0.03410148f, -0.18629429f, -0.29096046f, -0.38268512f, 
    -0.04192415f, -0.08918799f, 0.13151258f, 0.19218926f, 0.01009177f, -0.02462094f, 0.03840006f, -0.64732677f, 
    -0.09945333f, 0.15455960f, -0.04188476f, -0.40501294f, 0.03808434f, 0.14211090f, 0.29874176f, 0.07309348f, 
    -0.06579721f, -0.13572581f, 0.00230119f, 0.16820885f, -0.00101854f, -0.02621140f, 0.36373517f, 0.12123440f, 
    -0.13106188f, -0.34554118f, 0.16080791f, -0.13242789f, 0.08309753f, 0.05966349f, -0.10997652f, 0.16562204f, 
    -0.03527198f, 0.26133937f, -0.35708475f, 0.07389314f, -0.00944324f, 0.36207688f, -0.00803879f, -0.48690161f, 
    0.02000555f, -0.02320228f, 0.39865828f, -0.00913641f, 0.22081800f, 0.09338295f, -0.04903368f, 0.41870824f, 
    -0.04092417f, -0.02142364f, 0.05891941f, -0.13640778f, -0.06310538f, -0.09404298f, 0.05213155f, 0.07662468f, 
    0.07558148f, 0.06886974f, 0.03676843f, -0.10060429f, -0.09140834f, -0.02489182f, -0.11025544f, -0.12463558f, 
    0.03507781f, -0.12183601f, 0.05974977f, -0.00833945f, 0.02799078f, 0.04010016f, 0.00762071f, -0.06081216f, 
    -0.10636207f, -0.09102878f, -0.10720117f, -0.00226658f, -0.12706482f, -0.16841556f, 0.10416415f, -0.01142996f, 
    -0.01912746f, -0.01465652f, -0.02187093f, 0.01781942f, 0.00488431f, 0.03945574f, -0.05000224f, -0.01411255f, 
    -0.00582318f, -0.02516103f, -0.15462102f, 0.01891186f, -0.05661556f, 0.02711711f, -0.07213705f, -0.12586024f, 
    0.01851674f, -0.11075420f, -0.11029099f, -0.12143247f, -0.10953368f, -0.04360777f, -0.08046986f, -0.15171507f, 
    -0.05105103f, 0.02128591f, 0.04101581f, -0.02171442f, -0.12579024f, 0.10951957f, -0.08153730f, -0.05620683f, 
    0.01559530f, 0.07616108f, -0.03606996f, -0.33918577f, 0.49562061f, -0.03539400f, -0.03836940f, -0.12758894f, 
    -0.04711437f, 0.02905910f, -0.11525588f, -0.07380305f, -0.00168394f, 0.11041752f, 0.09385257f, 0.38119078f, 
    0.07737927f, 0.17347942f, 0.08074240f, 0.12750889f, 0.11486366f, 0.11223144f, 0.08705652f, 0.18651257f, 
    0.13798776f, 0.04799542f, -0.06674171f, 0.27299032f, -0.00411205f, 0.13695267f, -0.30036196f, -0.03776997f, 
    -0.01966992f, -0.03630904f, 0.18057525f, -0.06840640f, -0.28301659f, 0.03723581f, 0.05084782f, -0.10558672f, 
    -0.02916438f, 0.07643037f, 0.05347903f, 0.00390445f, 0.10723780f, 0.03677581f, -0.22786894f, -0.10355318f, 
    0.03888631f, -0.09762254f, -0.19195737f, -0.21344146f, -0.07413855f, 0.09498110f, -0.39522123f, 0.05538314f, 
    0.04501614f, -0.18396856f, -0.35317919f, 0.01573162f, -0.17036402f, -0.00943105f, -0.13468970f, -0.02059671f, 
    -0.07854289f, -0.13680771f, -0.01883610f, 0.05274627f, -0.12465401f, -0.10657535f, -0.09804863f, -0.02688299f, 
    0.03575408f, 0.00900359f, -0.04053228f, 0.10443664f, 0.02646203f, -0.07631720f, 0.01418635f, -0.07734476f, 
    0.05543175f, -0.11813390f, -0.01770655f, -0.10721476f, -0.06170242f, 0.02898584f, 0.05145936f, -0.08627222f, 
    -0.02077619f, -0.11682438f, -0.11348820f, 0.02804743f, -0.11988644f, -0.01033372f, 0.05659069f, 0.10080286f, 
    0.07690430f, 0.00861398f, -0.05879228f, -0.02376377f, 0.01076028f, 0.06997993f, -0.10748333f, 0.09798317f, 
    0.10418987f, -0.12317112f, -0.06244226f, 0.08940598f, -0.05670437f, -0.05085212f, -0.01069023f, -0.09628072f, 
    -0.12528490f, 0.06209635f, -0.09481575f, -0.07091094f, 0.00073125f, 0.00962712f, -0.05281329f, -0.04704656f, 
    -0.01979951f, -0.05365013f, -0.04340194f, -0.08542509f, -0.07565506f, 0.04231231f, 0.02834972f, 0.03757792f, 
    0.02723858f, 0.08781157f, 0.06481890f, 0.18060172f, 0.29263675f, -0.06011611f, -0.50455183f, -0.22171746f, 
    -0.01742472f, -0.06603186f, 0.23643920f, 0.10350069f, 0.08050564f, 0.19073744f, 0.08737417f, 0.14850381f, 
    0.07822599f, -0.18460733f, 0.11249832f, -0.05707579f, 0.10703577f, 0.10241124f, 0.07683218f, 0.28896466f, 
    0.00595409f, 0.11234540f, -0.03067497f, 0.21863750f, 0.10879871f, 0.07243814f, -0.00580290f, 0.02183607f, 
    -0.11274347f, 0.11163407f, 0.03517089f, 0.34214419f, -0.22381276f, -0.32232574f, -0.17616718f, 0.02440976f, 
    0.01759623f, -0.11847893f, 0.02023497f, 0.25139818f, -0.08936114f, 0.24875920f, 0.02123222f, 0.06027188f, 
    0.01656897f, -0.08808908f, -0.12325951f, -0.00808147f, 0.08422951f, 0.12347965f, 0.15545511f, -0.02280351f, 
    -0.19903848f, -0.07973228f, -0.42837152f, 0.03381563f, -0.10177125f, -0.00596593f, 0.13827582f, 0.13169098f, 
    -0.10176718f, -0.01197433f, 0.03384104f, -0.08734512f, -0.01354731f, 0.01011279f, 0.09387842f, 0.08719949f, 
    -0.08939299f, 0.02915426f, -0.10575002f, 0.10924217f, 0.01389750f, -0.01342592f, -0.07171202f, -0.07799314f, 
    -0.05068398f, -0.13269895f, -0.12488238f, 0.04499147f, -0.05818705f, 0.06497752f, 0.06638719f, -0.02692162f, 
    -0.09809552f, 0.03199683f, 0.03771914f, 0.08117886f, 0.08282593f, 0.10618597f, -0.04912913f, -0.05450063f, 
    -0.08272375f, -0.07710421f, 0.09067087f, -0.08536048f, -0.03900713f, -0.09462719f, -0.00384403f, -0.00291044f, 
    0.11141516f, -0.11011659f, 0.04342202f, 0.08110978f, -0.11777419f, 0.00179410f, -0.03920905f, 0.04439534f, 
    0.02370682f, -0.13582949f, -0.12121278f, -0.01087172f, 0.01308459f, -0.03955375f, -0.00212579f, -0.09670120f, 
    -0.01356321f, -0.03519299f, -0.04141259f, 0.04146922f, -0.00437149f, 0.07737535f, -0.02092358f, -0.15389831f, 
    -0.04195484f, 0.03829856f, 0.03637834f, 0.04786042f, -0.01676598f, -0.12909311f, -0.08984132f, 0.07359379f, 
    -0.06556949f, 0.01687032f, 0.02331487f, -0.05837856f, -0.05849653f, -0.19029775f, -0.01131175f, 0.03632127f, 
    -0.12372610f, -0.11551606f, -0.17111330f, -0.07374793f, -0.17135355f, 0.09083130f, 0.00290807f, 0.08302815f, 
    -0.12945324f, 0.03928524f, -0.09221609f, -0.14477137f, 0.00537343f, -0.12052062f, 0.05395234f, -0.07152551f, 
    0.01627925f, -0.10666546f, 0.04520240f, 0.04065519f, 0.07546216f, 0.01636782f, 0.00776468f, -0.08310840f, 
    0.00317129f, -0.13517994f, 0.03395299f, -0.02535999f, -0.04237005f, -0.02062766f, 0.05177585f, -0.14653410f, 
    0.05924243f, 0.03424984f, -0.16133650f, 0.08819319f, 0.10795157f, -0.11164885f, -0.11276267f, -0.02899913f, 
    0.13451804f, -0.10839245f, 0.03545238f, 0.02011363f, -0.11263816f, -0.08354855f, -0.11047688f, -0.01563033f, 
    -0.06160748f, -0.07887707f, 0.05802984f, -0.05179032f, -0.08247241f, -0.08712545f, -0.09311376f, 0.00976897f, 
    -0.08431862f, 0.10441063f, -0.00565733f, 0.04001761f, -0.09111214f, -0.13161151f, 0.05209739f, -0.01142372f, 
    0.04919092f, -0.00590278f, -0.13898970f, -0.06524903f, -0.02837985f, -0.01887269f, -0.06445986f, 0.01754011f, 
    0.04844150f, 0.05266772f, -0.05850962f, 0.03505607f, -0.07749983f, -0.03361341f, -0.09327780f, 0.01399986f, 
    0.10855755f, 0.03511701f, -0.05985941f, -0.11025636f, 0.07037769f, -0.09972916f, -0.00987275f, -0.01801783f, 
    -0.02396144f, -0.02251547f, -0.02890373f, -0.00616268f, -0.07992464f, -0.16139729f, -0.10104533f, -0.03911593f, 
    0.02425898f, -0.02191112f, 0.00501644f, -0.05388208f, 0.06040310f, -0.10198151f, -0.04704820f, -0.00271042f, 
    -0.01549696f, 0.00414960f, -0.12697476f, -0.00101306f, 0.04511764f, 0.06487337f, -0.00396112f, -0.01551617f, 
    0.02756283f, -0.05720583f, 0.08225815f, 0.18503308f, 0.33203682f, -0.12885313f, -0.29329658f, -0.37083045f, 
    0.12068714f, -0.05158430f, 0.31726944f, 0.03156800f, -0.05805271f, 0.30786839f, 0.06149520f, 0.07797398f, 
    0.01820979f, -0.08958805f, 0.02861555f, 0.12698364f, -0.02716406f, 0.10187620f, -0.00831957f, 0.38802770f, 
    0.32834587f, 0.01457866f, -0.03018875f, 0.14410654f, 0.19128507f, -0.04217039f, -0.19687553f, -0.06416833f, 
    0.06066032f, 0.00748408f, 0.02180230f, 0.28472298f, 0.28050587f, -0.06774990f, -0.16527055f, -0.06893754f, 
    -0.04516693f, 0.14947204f, -0.09695583f, 0.38277674f, 0.04315823f, 0.08473127f, 0.18629247f, -0.03975205f, 
    -0.06452136f, 0.13449721f, 0.00773392f, -0.04891325f, -0.07702041f, 0.35433409f, -0.03518511f, -0.01527332f, 
    0.03703666f, -0.04866360f, -0.12716459f, -0.12555848f, 0.09069027f, -0.08495019f, -0.00118773f, -0.05644448f, 
    -0.15049763f, 0.07901928f, -0.03946638f, -0.20467106f, -0.20669279f, -0.29353690f, -0.10395949f, -0.01355967f, 
    -0.00866559f, 0.06980838f, 0.03288008f, -0.00274758f, 0.11969886f, 0.10267965f, -0.04467443f, 0.15979363f, 
    -0.15044487f, -0.10030130f, 0.08616943f, 0.02853299f, -0.13668567f, -0.10297740f, 0.00147139f, 0.08647573f, 
    0.16692480f, 0.12233070f, -0.02587042f, 0.24131083f, -0.28010818f, 0.09891442f, -0.15518899f, 0.08682358f, 
    0.06342226f, -0.09225534f, -0.01287682f, 0.11391674f, -0.01595507f, 0.16851678f, 0.03651374f, -0.08499843f, 
    -0.03594483f, 0.00054260f, 0.07866284f, 0.04467402f, 0.06971598f, 0.11496809f, -0.01923887f, 0.18719651f, 
    0.06109053f, -0.29517877f, 0.05377613f, -0.09407140f, -0.11273929f, 0.33095276f, 0.16855933f, 0.16984010f, 
    -0.20454960f, -0.04322303f, 0.14321385f, 0.05547833f, -0.19219227f, 0.08745328f, 0.37445283f, 0.07065734f, 
    0.01716688f, -0.05062025f, 0.06147190f, 0.23276922f, 0.09910527f, 0.22899759f, 0.28935581f, -0.10765065f, 
    0.05965491f, 0.08851072f, -0.02545105f, 0.06339437f, 0.26102304f, -0.17940246f, 0.23244597f, -0.12080462f, 
    -0.05486768f, 0.25338355f, 0.05554154f, 0.37616360f, 0.32453713f, 0.15245688f, 0.00775832f, -0.07219417f, 
    -0.09133297f, 0.24120168f, -0.25839290f, -0.21051900f, 0.09574734f, -0.24071807f, 0.45938462f, 0.26753759f, 
    -0.00593911f, 0.18262933f, 0.14467447f, -0.01528975f, 0.12207001f, 0.04409018f, 0.04474735f, -0.04024180f, 
    -0.01295244f, 0.02161656f, 0.11362761f, -0.17861155f, -0.06303685f, -0.06607772f, -0.00740741f, 0.00842802f, 
    0.05146885f, -0.00552685f, 0.16024761f, 0.34515351f, -0.01585086f, 0.02056925f, 0.30645105f, -0.02895914f, 
    0.29569462f, 0.03270323f, 0.12752551f, 0.09739240f, 0.26767871f, 0.01932407f, -0.10005656f, 0.09015552f, 
    0.13009715f, 0.11078376f, 0.07626913f, 0.13380176f, -0.36134303f, 0.26742563f, -0.09392358f, 0.30152732f, 
    0.02468107f, 0.00946792f, 0.14806142f, 0.08918945f, -0.04202667f, 0.02502705f, -0.22413617f, -0.38190472f, 
    0.27008656f, 0.16256773f, 0.14949425f, 0.03437665f, -0.12773481f, 0.09106152f, -0.09574097f, -0.35268563f, 
    -0.08123788f, 0.05951581f, 0.00535437f, -0.18948849f, 0.12982535f, 0.16180162f, -0.01743471f, 0.24824616f, 
    -0.02427107f, 0.03089090f, -0.08674262f, 0.12247299f, 0.31432343f, -0.12897283f, 0.09693869f, -0.06748277f, 
    -0.06004712f, -0.13409923f, 0.02863460f, -0.00544318f, -0.00260608f, -0.12632918f, 0.27204028f, -0.01511302f, 
    0.07759911f, 0.40954188f, -0.11441359f, -0.08845431f, -0.04080192f, -0.03455824f, -0.30031517f, -0.16896835f, 
    0.32074407f, 0.27448651f, 0.14648870f, -0.01738156f, -0.03114385f, 0.00976448f, -0.31352594f, -0.21217085f, 
    -0.12226794f, 0.13705786f, 0.08732253f, -0.11693030f, 0.00533920f, 0.07544756f, -0.02571741f, -0.18633698f, 
    -0.00666352f, -0.08187713f, -0.03443078f, 0.10244790f, -0.11640810f, -0.15394098f, 0.09263398f, 0.11411318f, 
    -0.10309517f, -0.04578753f, 0.04767909f, 0.06177173f, -0.11719806f, 0.04485926f, 0.10015808f, 0.17545860f, 
    -0.06795483f, 0.06275825f, 0.00079071f, -0.04360265f, -0.02513245f, -0.02337047f, 0.06970315f, -0.21131943f, 
    0.09416582f, -0.12767598f, -0.03960526f, -0.03881834f, -0.09104104f, -0.10141979f, -0.25689542f, 0.04383872f, 
    -0.13111196f, -0.07192445f, 0.06850833f, 0.10028598f, -0.03591922f, -0.04022947f, -0.08920824f, -0.01846327f, 
    -0.08245089f, -0.09793735f, -0.01831220f, 0.04279924f, -0.10241377f, 0.04756701f, -0.11944809f, -0.05940625f, 
    -0.11989877f, -0.12187997f, -0.16645665f, 0.10134503f, -0.11327117f, 0.08517738f, -0.13969047f, 0.03714113f, 
    -0.00388937f, 0.14612399f, 0.05860113f, 0.06748459f, 0.22687669f, -0.00625476f, -0.24556334f, -0.00853509f, 
    0.11675575f, 0.12304272f, 0.21773419f, 0.09315899f, 0.19737644f, 0.28806031f, -0.15555227f, 0.45345438f, 
    -0.12741818f, -0.34129289f, -0.11809047f, -0.03346698f, 0.06034974f, -0.04370523f, 0.09651034f, 0.17068960f, 
    0.14427900f, -0.02266489f, 0.41907495f, 0.32047290f, -0.27292132f, -0.08613086f, -0.09400406f, -0.01112269f, 
    -0.11727932f, 0.13154677f, 0.24648130f, -0.00918271f, -0.23539324f, -0.35535237f, 0.10387620f, 0.06478879f, 
    0.25810045f, -0.02561659f, -0.06698571f, 0.24069332f, -0.01208007f, 0.02504710f, -0.08491278f, -0.30598047f, 
    0.07998285f, 0.06998967f, -0.42261103f, -0.10138279f, 0.10216582f, 0.06196202f, 0.16805978f, 0.04452549f, 
    -0.18771729f, -0.01583063f, 0.16707534f, 0.06840041f, -0.06578548f, 0.08614965f, 0.21972243f, -0.20832647f, 
    -0.08083788f, -0.14939326f, -0.08317534f, 0.18066527f, 0.37978676f, -0.05025666f, -0.03804612f, -0.16152674f, 
    -0.02450633f, 0.11959526f, 0.09285860f, -0.03903024f, -0.00935734f, 0.11831474f, 0.05892490f, 0.15544286f, 
    -0.14186394f, -0.07669722f, -0.08473258f, 0.13974771f, 0.15123744f, 0.00492321f, 0.06413833f, 0.34919223f, 
    0.18485054f, 0.06441938f, -0.10064329f, -0.02293609f, 0.06259078f, 0.03007411f, -0.02200297f, -0.07771727f, 
    -0.12199308f, 0.12113293f, 0.16665629f, 0.16528793f, -0.13974352f, -0.06208109f, -0.09936675f, -0.05945767f, 
    -0.06021178f, -0.12425339f, 0.05992837f, 0.25671405f, 0.10407916f, 0.04976757f, -0.22228487f, 0.00094833f, 
    -0.00897464f, -0.13083395f, -0.19834350f, 0.00453426f, -0.02478361f, 0.42271006f, 0.04449259f, -0.14223109f, 
    -0.18370077f, -0.21216196f, 0.09045737f, -0.00182233f, 0.00642275f, -0.02112646f, -0.11472756f, 0.36954188f, 
    -0.14768554f, 0.20824905f, 0.01356197f, -0.10987998f, 0.15977138f, -0.15201449f, -0.02370591f, 0.05540860f, 
    -0.09626138f, -0.07667384f, 0.07500476f, -0.12699674f, 0.06263900f, 0.00658431f, 0.09044815f, 0.19833128f, 
    0.09037184f, 0.22487801f, 0.09010458f, 0.10124113f, -0.34952834f, 0.13471420f, -0.06116159f, -0.08807510f, 
    0.01892167f, -0.01685923f, 0.16317639f, 0.32407179f, -0.33297056f, 0.05532429f, -0.49309883f, 0.13551819f, 
    -0.08163691f, 0.07323557f, 0.25252175f, -0.23598683f, -0.15686536f, -0.29649875f, -0.04766060f, -0.03360144f, 
    0.12058800f, 0.41206405f, 0.06450552f, 0.27068385f, 0.03865563f, 0.08468717f, 0.16103852f, -0.41877913f, 
    -0.07015757f, 0.20367371f, 0.11326394f, -0.07505852f, -0.03676014f, -0.14669210f, -0.29880342f, -0.01550559f, 
    0.19281146f, -0.12327702f, -0.08211967f, 0.01907589f, -0.19202894f, 0.06985432f, 0.10588950f, -0.20674746f, 
    -0.19967799f, 0.03325891f, -0.07930855f, -0.10448788f, 0.42370293f, -0.14877239f, 0.05669243f, -0.23588052f, 
    0.01948502f, 0.07420281f, -0.14037858f, 0.10648210f, 0.21045022f, -0.06863078f, 0.20367983f, 0.34061113f, 
    -0.03214218f, 0.12024339f, -0.07817622f, -0.01290438f, 0.16275540f, 0.01888068f, -0.04247488f, -0.00056259f, 
    0.07455392f, 0.22532462f, 0.03701501f, 0.33440873f, -0.22120622f, -0.18326552f, 0.16130985f, -0.04388557f, 
    -0.08700582f, 0.18256162f, 0.22821207f, -0.23088890f, -0.32335523f, -0.02741432f, -0.13035369f, -0.06150389f, 
    0.10050003f, 0.09554023f, 0.27823415f, -0.01933691f, 0.01658281f, 0.15843788f, -0.05990566f, -0.18382549f, 
    -0.07153277f, -0.13542393f, 0.01690995f, 0.18093520f, -0.00100688f, -0.27969512f, 0.28623524f, 0.18430214f, 
    -0.02358871f, 0.00477439f, -0.03665874f, -0.02073014f, -0.11580114f, -0.06327514f, 0.26089078f, -0.10345248f, 
    -0.37551811f, 0.20476066f, 0.03996785f, -0.14864981f, -0.07467542f, 0.15401822f, -0.22448203f, 0.33871296f, 
    -0.10875750f, -0.11819288f, 0.05225185f, 0.01220494f, -0.17754062f, 0.05757212f, -0.06976324f, 0.11796486f, 
    0.20457260f, -0.14489233f, 0.28649810f, 0.05941442f, -0.27436644f, 0.04449527f, 0.06969448f, -0.09485745f, 
    0.28401759f, -0.12442676f, 0.23895656f, -0.02934826f, 0.20156914f, 0.04645659f, -0.13062027f, 0.07883593f, 
    -0.00067499f, -0.06040563f, -0.02730779f, -0.05811869f, 0.07514700f, 0.00055085f, 0.39002138f, -0.09563901f, 
    0.15636405f, 0.19001094f, -0.17893787f, -0.17575626f, 0.07181799f, -0.05851532f, -0.04659287f, -0.13511631f, 
    0.02377644f, 0.32438028f, -0.05124160f, -0.34358573f, -0.00250735f, 0.09891797f, -0.23442878f, -0.05997403f, 
    -0.14766234f, 0.08800889f, 0.13900024f, -0.00351517f, 0.11514980f, 0.06979819f, 0.18816151f, -0.18906595f, 
    -0.09339086f, -0.02646817f, -0.05658820f, 0.05763698f, 0.32042807f, 0.20605209f, 0.14786331f, -0.03493025f, 
    -0.12931575f, 0.07529043f, 0.00486185f, -0.02532043f, 0.21162885f, 0.17981255f, 0.10017496f, 0.20892638f, 
    0.09745961f, -0.03745792f, 0.18008219f, -0.07830862f, 0.04296644f, 0.09778266f, 0.01767804f, -0.02943061f, 
    0.17087537f, -0.09541365f, 0.06026815f, -0.25918171f, -0.12741949f, 0.23893131f, -0.05335095f, -0.09874392f, 
    -0.01473369f, 0.24432890f, 0.26420003f, 0.26832834f, 0.15898521f, 0.03368137f, 0.11715315f, 0.01043489f, 
    -0.01431355f, -0.08870891f, -0.26087433f, -0.00060844f, -0.02759208f, -0.19270055f, -0.08876655f, 0.01551534f, 
    -0.01303482f, 0.21849321f, 0.12294981f, -0.07615995f, 0.00708245f, -0.05758192f, -0.05764813f, 0.00957543f, 
    -0.07991457f, 0.04718551f, 0.32943335f, 0.02554412f, 0.05530820f, -0.08570601f, -0.05142231f, -0.24071404f, 
    0.02674864f, -0.09827281f, -0.08109540f, -0.12554160f, 0.34777948f, 0.28211132f, 0.31616002f, 0.08815842f, 
    -0.02667619f, 0.05890309f, 0.08378340f, -0.04487387f, 0.26954114f, -0.08236991f, 0.19136398f, 0.45163399f, 
    0.04774344f, -0.05209136f, 0.26753232f, 0.02326549f, 0.13827810f, 0.22036812f, -0.09523864f, 0.03602998f, 
    0.32678705f, 0.10178454f, -0.18695483f, -0.05977479f, 0.16673687f, 0.05319585f, 0.25733322f, 0.19163191f, 
    -0.04963829f, 0.17276609f, 0.22557512f, 0.17244132f, -0.13196264f, 0.07128666f, 0.28617945f, -0.09918960f, 
    0.03088130f, -0.34445328f, -0.25420204f, -0.21937764f, -0.09685253f, -0.14914003f, -0.16470040f, -0.11568833f, 
    0.06885025f, 0.10983345f, -0.27888131f, -0.15326709f, -0.02504547f, -0.28502280f, 0.09462649f, -0.11487984f, 
    0.21045332f, -0.03589477f, 0.10543845f, 0.10789663f, 0.14610352f, -0.00355207f, -0.11841112f, -0.15152840f, 
    -0.04846914f, 0.10803021f, -0.02076305f, 0.02080930f, -0.09132604f, -0.01004596f, 0.11288582f, -0.11392526f, 
    -0.01564831f, 0.08737792f, 0.04429882f, 0.03639282f, -0.12547015f, -0.14182606f, 0.08111677f, -0.09634173f, 
    0.15987681f, 0.05790105f, -0.04081552f, 0.18766841f, -0.12324364f, 0.25028455f, -0.11496581f, 0.20316343f, 
    0.07845218f, 0.17464915f, -0.12383032f, 0.12004096f, 0.09775488f, -0.11009365f, -0.00437602f, 0.05931386f, 
    -0.12067710f, 0.08755150f, -0.06873867f, -0.31216431f, -0.10022356f, -0.12440695f, -0.22177133f, 0.09607948f, 
    0.01050201f, 0.29861668f, 0.21481097f, -0.06912028f, 0.05720475f, 0.14842740f, 0.13274130f, -0.12179270f, 
    0.11795741f, 0.08293597f, 0.07110778f, 0.01009607f, 0.08878763f, -0.15177576f, 0.01139006f, 0.11742490f, 
    0.05769822f, 0.00014095f, -0.24248263f, -0.12564330f, -0.03668080f, 0.13170066f, -0.13984936f, 0.07422912f, 
    0.06478582f, 0.03584621f, -0.05247504f, 0.02118671f, -0.34341174f, 0.14317158f, -0.06110294f, 0.08145574f, 
    0.10974365f, 0.09623724f, -0.09020206f, 0.03515458f, -0.11597699f, -0.07163729f, -0.08926640f, -0.31418577f, 
    0.26404902f, 0.08511885f, 0.04154655f, -0.06627540f, -0.10533070f, 0.08331431f, 0.10604420f, -0.30571809f, 
    -0.20527799f, 0.17323127f, 0.26917979f, 0.22173597f, -0.21188650f, 0.13334288f, -0.14873499f, 0.24850209f, 
    -0.08727962f, 0.03858097f, -0.00173834f, -0.23094529f, -0.23663484f, 0.01125141f, -0.20631313f, 0.06162959f, 
    0.06265341f, 0.11024141f, 0.26751724f, 0.24575202f, 0.08746907f, 0.17545450f, 0.13636309f, 0.05947342f, 
    0.00704416f, 0.15318415f, -0.05126580f, -0.08460553f, -0.05977802f, -0.05241952f, -0.02145915f, 0.04067262f, 
    0.28480041f, 0.09042987f, 0.05823940f, 0.11716802f, -0.18407106f, -0.10223995f, 0.07598393f, 0.31166473f, 
    -0.14061666f, 0.24342719f, -0.10911248f, 0.13032107f, 0.11044337f, 0.16792373f, -0.40598509f, -0.12342670f, 
    -0.04968419f, -0.07105695f, -0.17984304f, 0.08224414f, 0.04412062f, -0.02339415f, 0.05725301f, 0.10392135f, 
    0.23788817f, 0.23989557f, -0.16066568f, 0.12936941f, -0.08478809f, 0.27634913f, 0.03739706f, 0.14380577f, 
    0.05772357f, -0.05737438f, 0.09781072f, 0.29332057f, 0.13004997f, -0.01672108f, -0.08574790f, 0.15214834f, 
    0.07884315f, 0.05890319f, 0.04712339f, -0.30096313f, 0.04320984f, -0.30745459f, -0.20333815f, 0.06587271f, 
    0.15993522f, 0.24330285f, -0.05767957f, -0.02544948f, -0.03129383f, 0.18725960f, 0.07860066f, -0.22571161f, 
    0.07840065f, 0.09621299f, 0.13166587f, -0.12390388f, 0.02204004f, -0.19830377f, -0.11222715f, 0.31933388f, 
    0.18844897f, 0.21796389f, -0.12151000f, 0.11366149f, 0.03638005f, -0.01511589f, -0.12590429f, -0.11164007f, 
    0.04151221f, -0.08405850f, 0.00777815f, 0.11925857f, 0.00220737f, -0.12730077f, 0.09602018f, -0.02396785f, 
    0.11901194f, 0.04770094f, 0.00297585f, -0.01588200f, -0.14830664f, 0.06838284f, 0.01284345f, 0.01406995f, 
    -0.10750819f, -0.02814372f, -0.04856998f, -0.03674794f, -0.08018012f, -0.13269155f, 0.06809875f, -0.05194445f, 
    -0.05724724f, 0.03018495f, -0.00772960f, -0.04307801f, 0.09423312f, -0.03494860f, -0.10614073f, -0.13442409f, 
    -0.02639319f, -0.04266464f, -0.02956205f, 0.02031899f, -0.03876470f, -0.12356946f, -0.07884274f, -0.01905428f, 
    0.07827105f, 0.05014305f, 0.06629683f, -0.14449234f, -0.02293360f, -0.04918617f, -0.00205273f, -0.10466116f, 
    -0.04042518f, -0.07084600f, 0.07107010f, -0.06729855f, -0.00139980f, -0.10857395f, -0.02035439f, 0.05021304f, 
    0.03285496f, -0.11015064f, -0.10792604f, -0.06477760f, 0.08747135f, -0.08613829f, -0.10860659f, -0.04375716f, 
    -0.12576179f, -0.13430661f, 0.06969102f, -0.05450717f, -0.03983266f, 0.06586222f, -0.11097691f, -0.11599987f, 
    0.02752391f, -0.05082560f, 0.08710027f, 0.10809442f, -0.07305869f, 0.01617811f, 0.00115615f, -0.08901879f, 
    -0.11572703f, 0.06900027f, -0.07216632f, 0.07411087f, -0.10904662f, -0.13205789f, 0.00891128f, 0.06549080f, 
    0.02775125f, 0.02627449f, -0.01433745f, -0.10730314f, -0.13378012f, 0.02714695f, -0.06929929f, -0.10496704f, 
    -0.02882621f, -0.03973074f, -0.08027972f, -0.11705186f, 0.02942473f, -0.05483858f, -0.04516034f, 0.04091971f, 
    -0.00401751f, -0.11219058f, -0.02743999f, 0.03334149f, -0.11384692f, 0.03848689f, -0.10128086f, 0.00201154f, 
    0.07693824f, -0.04920791f, 0.02015043f, -0.07900417f, 0.07282925f, -0.13891189f, 0.06161963f, -0.12376969f, 
    -0.03719016f, -0.08736321f, -0.12571898f, -0.00472227f, -0.07403735f, 0.05376046f, -0.05279203f, -0.11942720f, 
    -0.05654982f, 0.04406894f, -0.03564854f, -0.00855880f, 0.01970176f, 0.14447014f, 0.00884048f, 0.53337431f, 
    0.01665139f, -0.07040042f, 0.12028577f, -0.09848288f, 0.27589911f, 0.18617474f, -0.09232695f, 0.26000857f, 
    0.12219460f, -0.03713134f, -0.03790956f, -0.13133715f, 0.06603269f, -0.05774312f, 0.03858648f, -0.04998763f, 
    -0.12678863f, 0.04568259f, 0.33256918f, 0.32311124f, -0.29368722f, 0.19103973f, 0.05548136f, 0.08497353f, 
    -0.06912571f, -0.10638892f, 0.15668429f, -0.23897181f, -0.18495663f, 0.14931920f, 0.21885978f, -0.05541566f, 
    0.32566985f, -0.07817790f, 0.00718009f, -0.32479444f, -0.00428444f, 0.16901350f, -0.29238001f, 0.03092515f, 
    -0.00978397f, 0.21286778f, -0.13019864f, -0.01344301f, -0.06818151f, -0.30515313f, -0.07122887f, -0.02080060f, 
    0.18790892f, 0.16321982f, 0.16441002f, 0.04151597f, -0.11561657f, 0.00654712f, 0.18734033f, -0.29177889f, 
    -0.01910989f, 0.03169112f, 0.01971576f, 0.04654507f, 0.12308623f, 0.04082315f, -0.15127251f, -0.17638737f, 
    -0.06597823f, 0.06348857f, 0.17255174f, 0.11421750f, -0.14766227f, 0.13944343f, 0.08127341f, 0.17558965f, 
    0.11548208f, -0.04191679f, -0.22474274f, 0.06201242f, -0.12510693f, 0.25099438f, 0.11451200f, 0.20733522f, 
    0.18156177f, 0.16950585f, 0.00746442f, 0.28341377f, 0.20821285f, -0.16362594f, -0.11658004f, 0.00317488f, 
    0.02506036f, 0.12065657f, 0.02346234f, 0.02232377f, -0.08978201f, -0.34524447f, -0.25095022f, -0.09437398f, 
    0.11721691f, 0.25672677f, -0.12738411f, 0.25429803f, 0.10954045f, 0.00551462f, 0.12390076f, -0.20464604f, 
    0.01271696f, 0.04507716f, -0.13485602f, 0.18277028f, 0.04249489f, -0.18472025f, 0.06089993f, 0.12917256f, 
    0.13381717f, -0.14548813f, -0.27376604f, -0.03873691f, -0.10524134f, 0.05978368f, 0.09287030f, -0.07546066f, 
    0.03723228f, 0.23864713f, 0.10584842f, 0.06525415f, -0.04571003f, 0.13323078f, -0.04323527f, -0.01859637f, 
    0.06227700f, 0.09730302f, 0.03481929f, 0.03049773f, 0.02291537f, -0.00597883f, -0.20751193f, 0.20341009f, 
    0.26063159f, 0.01856218f, 0.03170091f, -0.04292928f, -0.02488024f, 0.14672241f, 0.03559608f, -0.27762839f, 
    -0.13545555f, 0.05607413f, 0.19734439f, 0.38296899f, -0.31759635f, 0.02472334f, -0.17161520f, 0.09979874f, 
    0.11862379f, 0.08764753f, 0.08683301f, -0.16998243f, -0.30124095f, -0.29994404f, -0.19297811f, -0.07374227f, 
    0.24473576f, 0.24016792f, 0.11983056f, 0.21643217f, 0.07370615f, 0.19612275f, -0.01818858f, -0.21289845f, 
    -0.06371357f, 0.18706316f, -0.30142343f, -0.08332112f, -0.00352842f, -0.17608389f, -0.14039165f, 0.11699999f, 
    0.25748360f, 0.04597148f, -0.20691729f, -0.04588094f, -0.10641687f, 0.03897718f, -0.01147461f, -0.19757557f, 
    -0.27564743f, 0.24724478f, -0.02156046f, -0.08140654f, -0.58325016f, -0.17269702f, -0.58827770f, 0.15392071f, 
    -0.09886767f, 0.11172256f, 0.10982686f, 0.12370734f, 0.02596883f, 0.29108736f, -0.22558656f, -0.04078778f, 
    -0.02282797f, -0.11771084f, 0.05719462f, -0.05301649f, -0.14401606f, 0.14314441f, -0.05979950f, 0.17654419f, 
    0.12181307f, 0.05132589f, 0.34570670f, 0.28974617f, -0.27188364f, 0.29176268f, -0.38777769f, 0.17517544f, 
    0.05421016f, 0.01883894f, 0.13359393f, 0.26206854f, 0.11744513f, -0.11922554f, 0.02595360f, 0.07406603f, 
    0.29146096f, 0.23238719f, 0.07764178f, -0.03300267f, -0.00660225f, 0.07584391f, 0.04852660f, -0.21343239f, 
    0.02012635f, 0.10024038f, -0.08506208f, -0.25838464f, -0.10406777f, 0.29940572f, -0.05259349f, 0.09945939f, 
    -0.14336103f, 0.08659343f, 0.04668292f, 0.05462852f, -0.38419291f, 0.06138787f, 0.03823676f, -0.20992601f, 
    -0.21725348f, 0.19298828f, -0.10331687f, -0.13835202f, 0.27653787f, 0.15978657f, -0.27605495f, 0.13464977f, 
    0.11235353f, -0.09929334f, 0.10819697f, 0.11638178f, -0.01636354f, 0.12967192f, 0.17977645f, 0.38394535f, 
    -0.07395806f, -0.08053473f, 0.23382372f, 0.02140970f, 0.15876906f, 0.25895911f, -0.05362233f, 0.34059027f, 
    0.44195727f, -0.16037667f, -0.02392274f, -0.03372607f, 0.09389909f, 0.15461631f, 0.03860540f, -0.03400481f, 
    -0.05695657f, 0.13079913f, 0.16115202f, 0.05681483f, 0.13222103f, -0.04413885f, 0.08292998f, -0.06647190f, 
    -0.10369974f, 0.13905148f, -0.29644442f, -0.26642546f, 0.08261821f, -0.18690273f, 0.04643822f, -0.16721830f, 
    -0.04613421f, 0.10975327f, 0.03499307f, -0.13695900f, -0.10751475f, 0.03543604f, -0.01821147f, 0.08281986f, 
    -0.09384704f, -0.06329028f, -0.26423708f, -0.07022608f, 0.16700773f, 0.08924189f, 0.12963834f, -0.28511032f, 
    -0.11286516f, 0.04817994f, -0.05705026f, 0.04093916f, 0.01092480f, 0.20268035f, -0.28124481f, 0.18718247f, 
    0.04066929f, 0.00065379f, 0.14333488f, -0.03662438f, 0.14836967f, 0.22884695f, -0.16507016f, 0.20104451f, 
    -0.10345767f, -0.12029769f, 0.08962819f, -0.15945648f, -0.01173096f, -0.06565201f, -0.09148200f, 0.09569941f, 
    0.14017859f, -0.14013307f, 0.22001559f, -0.17231019f, -0.15780528f, 0.10408796f, 0.14427523f, 0.05534275f, 
    -0.05074786f, 0.18323335f, 0.22949205f, 0.38119063f, 0.13801491f, -0.05678323f, 0.29688287f, -0.00744577f, 
    0.25599247f, -0.20135884f, -0.17501776f, 0.02243719f, 0.08918564f, -0.00430569f, 0.04246511f, 0.00894453f, 
    0.04564472f, 0.14353575f, 0.00851817f, 0.03956744f, -0.10592116f, -0.11762113f, -0.03812578f, -0.03713025f, 
    0.02844047f, 0.13380337f, 0.31472829f, 0.06780356f, 0.01285069f, -0.08892940f, 0.19933815f, -0.28882861f, 
    -0.21123956f, 0.17738426f, -0.10090433f, 0.05966023f, 0.02662667f, -0.13276096f, 0.33678901f, 0.28919250f, 
    0.10192569f, -0.01600994f, -0.03957888f, -0.10157259f, 0.07424264f, 0.03637835f, -0.26929513f, 0.01400184f, 
    -0.02779924f, -0.29849428f, -0.01325920f, 0.07700791f, -0.06376405f, -0.23085108f, 0.12943469f, -0.04192790f, 
    -0.04227217f, 0.10503542f, 0.29970381f, 0.10422944f, -0.20478548f, 0.18014608f, 0.10575125f, -0.00455482f, 
    0.05720312f, -0.11595409f, 0.26334691f, 0.20320587f, -0.24840477f, -0.13207975f, 0.11358606f, 0.05375463f, 
    0.33411792f, -0.13245080f, 0.42174461f, -0.23626873f, 0.04572587f, -0.01441230f, -0.40751103f, -0.08411834f, 
    -0.00112846f, 0.05173193f, -0.20358816f, -0.18369555f, 0.04087182f, 0.47639903f, 0.24708632f, 0.02343326f, 
    -0.03176510f, 0.16932143f, 0.18402785f, -0.09787763f, -0.04891849f, 0.08405675f, 0.26592964f, 0.22900829f, 
    -0.19197462f, 0.01806303f, -0.06222114f, -0.28850156f, 0.15646832f, 0.12059423f, -0.11920525f, -0.07486574f, 
    -0.01162612f, -0.08609998f, 0.09558682f, -0.05696741f, -0.17461638f, -0.02856879f, 0.00035391f, -0.08453050f, 
    0.20889156f, 0.01513883f, 0.14368978f, -0.08597714f, -0.40886435f, -0.01111128f, -0.08179934f, 0.09518509f, 
    -0.01406470f, -0.15845968f, -0.14984302f, 0.20981146f, 0.44843429f, -0.18281855f, -0.24813445f, -0.16738412f, 
    -0.06727557f, -0.06461477f, -0.03490267f, 0.18022753f, -0.04141795f, 0.10492620f, 0.16016659f, -0.03577563f, 
    0.00887307f, 0.24817012f, 0.19256400f, 0.17634496f, 0.12076716f, 0.23372249f, -0.01023988f, -0.07055061f, 
    0.06655037f, -0.02370065f, 0.03086000f, -0.43316060f, 0.00972721f, -0.11182460f, 0.00445419f, -0.01281950f, 
    -0.18357702f, -0.15101147f, -0.02300239f, -0.07586454f, -0.26469871f, -0.05121970f, 0.08776641f, 0.10239235f, 
    0.12276661f, 0.03374121f, -0.08052837f, -0.01925258f, -0.45091945f, -0.08266420f, -0.11560313f, -0.02728731f, 
    -0.09700985f, 0.07993051f, 0.13745745f, 0.10594229f, 0.01456284f, 0.02092109f, -0.19703121f, -0.07466552f, 
    -0.06418377f, -0.08610665f, -0.12508245f, -0.10641412f, 0.02157687f, 0.14392136f, 0.08952111f, 0.10913279f, 
    -0.04537076f, -0.03565085f, -0.01657844f, -0.00073186f, 0.37324762f, -0.04623484f, 0.13189386f, 0.00569484f, 
    0.01664059f, -0.06982505f, -0.01950249f, 0.08489507f, 0.35517955f, 0.02212221f, 0.04597360f, -0.05543600f, 
    0.03340723f, 0.14802341f, 0.01758039f, 0.11647919f, 0.03894446f, -0.16185428f, 0.17749469f, -0.02032360f, 
    -0.02161792f, 0.19574356f, -0.20548181f, 0.09832493f, -0.07851222f, -0.05903359f, 0.13050611f, 0.19561556f, 
    -0.07929610f, 0.27264795f, -0.04044598f, 0.08958192f, 0.08274142f, 0.08504933f, 0.01894039f, -0.17865677f, 
    0.12157994f, -0.11423671f, 0.07694282f, 0.26884770f, -0.04111796f, 0.07835672f, -0.01011960f, -0.15924749f, 
    0.05221440f, -0.00420015f, -0.07322724f, 0.11055345f, 0.01519859f, 0.03647297f, 0.19431949f, -0.24277577f, 
    0.07769919f, 0.04230583f, -0.13560346f, 0.12585430f, -0.02130720f, 0.09728450f, 0.06959991f, 0.14201595f, 
    -0.09397074f, -0.08260188f, -0.24345003f, -0.03800777f, 0.09512430f, 0.01930233f, 0.08888252f, -0.03559130f, 
    -0.08455452f, 0.19833001f, -0.02779513f, 0.13893276f, 0.04462314f, 0.00602187f, 0.07696313f, 0.07257347f, 
    -0.22454461f, 0.19025856f, 0.19436835f, 0.28835747f, -0.03536236f, 0.14251249f, 0.11744313f, -0.01440416f, 
    -0.03706213f, -0.16932072f, 0.25110501f, 0.23261923f, -0.10776106f, 0.31533417f, -0.06001092f, 0.03063086f, 
    -0.05810759f, 0.06690995f, 0.20712362f, -0.11150360f, 0.01083594f, 0.04154905f, 0.02580181f, 0.31150329f, 
    0.13494502f, 0.03885279f, -0.03379200f, 0.13946748f, -0.19635193f, 0.07978878f, 0.14056453f, -0.13505849f, 
    0.06269629f, 0.07074909f, -0.08952360f, 0.02382300f, -0.14110798f, -0.07982690f, 0.01489605f, -0.28135765f, 
    -0.17006047f, -0.00073752f, -0.07978824f, 0.13450205f, 0.00364990f, 0.15557256f, -0.05676340f, 0.12062983f, 
    -0.14747339f, 0.22524886f, -0.08528332f, 0.03530731f, 0.33020303f, -0.12611534f, 0.17795426f, 0.12142672f, 
    0.05077285f, -0.04879874f, -0.23051387f, 0.03256251f, -0.02543952f, 0.07787028f, -0.28794497f, -0.11431175f, 
    -0.22675434f, 0.20407785f, 0.31718549f, 0.13099638f, -0.03212796f, 0.29560784f, 0.14256714f, 0.11127076f, 
    0.01414620f, -0.07731071f, -0.14065951f, 0.19839771f, -0.06309834f, 0.00482466f, 0.12410495f, 0.17784545f, 
    -0.11865507f, -0.07442249f, -0.13118315f, -0.02148998f, -0.06057314f, 0.00998716f, 0.27998546f, 0.33767742f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14972915f, 0.08668630f, -0.11842823f, 0.11489996f, 0.00551751f, -0.10056295f, -0.06790900f, -0.07027800f, 
    0.16955657f, 0.15120299f, 0.14083858f, -0.11237372f, 0.09637970f, -0.05617286f, 0.09369562f, -0.06176640f, 
    0.04681659f, 0.26700419f, -0.10020681f, 0.05082010f, 0.17673393f, 0.01249209f, -0.19682522f, -0.00850156f, 
    0.08629930f, 0.07418359f, 0.24222870f, -0.05372543f, -0.05164274f, -0.01913242f, -0.03323825f, 0.03448936f, 
    0.19525281f, 0.00170371f, -0.10777506f, -0.03081769f, 0.25411147f, 0.13495183f, 0.00738879f, 0.13808307f, 
    0.04559261f, 0.32499957f, 0.07710505f, 0.03653741f, 0.14979602f, 0.21704200f, 0.08224739f, 0.13239929f, 
    -0.06259199f, -0.06922181f, 0.19288635f, -0.07919551f, -0.01304640f, 0.05527984f, 0.24702530f, 0.12475249f, 
    0.18914884f, 0.14577556f, 0.02530166f, 0.06352177f, 0.28578708f, 0.00999648f, -0.04416572f, -0.01445182f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.10085777f, 0.09142815f, -0.03178595f, 0.04330362f, 0.18753392f, -0.00653471f, -0.53763700f, -0.04368248f, 
    -0.46806940f, -0.38673756f, -0.13654357f, 0.05990041f, 0.06316932f, -0.21220289f, -0.57360899f, -0.01108818f, 
    0.18097202f, 0.06716458f, 0.16786821f, 0.21335526f, -0.12902898f, -0.41734323f, -0.11862984f, 0.19078763f, 
    -0.50668609f, -0.20998508f, -0.13386269f, 0.12198991f, 0.35663939f, 0.07627557f, -0.10856117f, -0.09108607f, 
    -0.18315314f, -0.04401072f, 0.08656096f, -0.01649211f, -0.05797060f, 0.07132293f, 0.12479950f, -0.06978565f, 
    -0.12210089f, -0.32384899f, 0.07710382f, -0.14746039f, -0.00380609f, -0.08307779f, -0.27097720f, -0.02971356f, 
    0.10006524f, 0.10422862f, -0.45760575f, -0.12563854f, -0.09415456f, -0.31513429f, -0.05585179f, -0.21783252f, 
    -0.29191309f, -0.11147670f, -0.58598900f, 0.04166194f, -0.26935637f, 0.00538460f, 0.11100204f, 0.27327546f, 
    0.01085471f, 0.23794156f, 0.06338939f, 0.08354267f, -0.17519884f, -0.08701119f, -0.17054081f, 0.02828525f, 
    0.20034434f, 0.01206290f, 0.13186342f, 0.03921070f, 0.06633764f, 0.04880036f, -0.20166779f, -0.06021623f, 
    0.16360588f, 0.18907708f, -0.49819016f, 0.12028286f, -0.03746515f, 0.13868913f, -0.21030360f, -0.06322085f, 
    0.07946031f, 0.32636827f, 0.16979057f, -0.20893770f, -0.84948909f, -0.00715786f, -0.23682342f, -0.13138549f, 
    0.24767642f, -0.07391763f, -0.05260235f, -0.05037171f, 0.13905452f, -0.17164110f, 0.10928092f, -0.48787868f, 
    -0.05746838f, -0.02540534f, 0.17989892f, -0.43517369f, 0.11241897f, -0.06320579f, -0.15630442f, -0.00822859f, 
    0.09207243f, -0.32305649f, 0.06504415f, -0.05169797f, 0.06400045f, -0.42397305f, 0.21026704f, -0.25662047f, 
    -0.47752926f, 0.01160221f, -0.02375830f, -0.48140380f, 0.33680582f, 0.14942096f, 0.16332483f, 0.16928086f, 
    -0.16223544f, -0.16981056f, -0.02098136f, -0.17662372f, -0.05687499f, 0.02181407f, -0.20888205f, -0.03637920f, 
    -0.12342727f, 0.15518674f, -0.39440089f, 0.08029967f, 0.11070090f, 0.36366665f, 0.16267559f, 0.05737954f, 
    -0.06306614f, 0.04564609f, -0.51434791f, -0.39618385f, -0.06319783f, -0.66756260f, -0.56612647f, 0.29665220f, 
    -0.13088897f, -0.64564502f, 0.13337392f, 0.10577564f, -0.43276548f, 0.04565843f, -0.01980432f, -0.00432123f, 
    -0.11941919f, -0.08926727f, -0.09302049f, 0.07576185f, 0.05972611f, 0.13242830f, -0.03892460f, -0.22584833f, 
    -0.01443176f, 0.31777829f, 0.03825088f, 0.06772070f, 0.19422174f, 0.07940096f, 0.05829367f, -0.04361697f, 
    -0.09467725f, -0.26344109f, -0.04818576f, 0.08317037f, -0.07766216f, 0.14226255f, 0.04558001f, -0.11513975f, 
    0.14378645f, 0.06902684f, 0.10282014f, 0.27884951f, 0.01877388f, 0.11297890f, -0.21980570f, -0.16266300f, 
    0.23766798f, 0.03756726f, -0.06916836f, -0.19920379f, 0.15958881f, -0.22106437f, -0.17130862f, -0.12766348f, 
    -0.16512516f, -0.10366568f, -0.00918044f, 0.08984745f, -0.17177451f, 0.20072880f, 0.06070833f, 0.09073748f, 
    -0.01235234f, -0.07570928f, 0.32977656f, -0.25678122f, -0.13519254f, -0.24972576f, 0.11843742f, 0.03783073f, 
    0.20759583f, -0.28162906f, -0.31519261f, 0.14846314f, 0.00622233f, 0.03500699f, 0.21947721f, 0.02317690f, 
    -0.36866602f, -0.06776721f, 0.04325529f, 0.05770372f, -0.49106091f, -0.39442763f, 0.13864011f, 0.07266376f, 
    -0.13812889f, -0.32137075f, -0.33155796f, -0.26354894f, 0.13555975f, -0.04070300f, -0.18099497f, 0.20064437f, 
    0.06933300f, 0.16239412f, 0.10433237f, -0.12019384f, 0.08462365f, 0.34346434f, 0.01074348f, 0.13797931f, 
    -0.26095018f, -0.34511891f, -0.07309324f, 0.05666805f, -0.52598453f, 0.09629412f, -0.18277654f, 0.08989351f, 
    0.06936528f, 0.11498129f, 0.05367012f, 0.10697481f, 0.12166750f, -0.16950324f, -0.13521990f, -0.07380998f, 
    0.05273469f, 0.03321748f, -0.28336668f, -0.04180313f, 0.07386812f, -0.26753777f, 0.08045270f, -0.06622023f, 
    -0.07081460f, -0.21852121f, -0.21211456f, -0.34754536f, 0.20894009f, 0.18343320f, -0.01937668f, 0.14609870f, 
    -0.18460588f, -0.05002151f, -0.07978653f, 0.14106894f, 0.21616070f, 0.05622204f, 0.02997581f, -0.06861472f, 
    -0.32643434f, 0.03645072f, -0.13796698f, -0.00936202f, -0.08040789f, -0.02301960f, 0.17235591f, 0.06723668f, 
    0.05377518f, -0.22148618f, 0.08604261f, -0.23889443f, -0.05194845f, -0.53649586f, 0.21497440f, 0.19112830f, 
    -0.20892166f, -0.04928292f, -0.24006902f, 0.09943573f, -0.04761980f, -0.02215207f, -0.33320010f, -0.59343040f, 
    -0.37096706f, -0.10715587f, 0.07201707f, -0.01644767f, 0.00298089f, -0.01142938f, 0.12727843f, -0.10405185f, 
    -0.08555076f, 0.06796651f, -0.02285270f, 0.15106647f, 0.10770136f, 0.07582593f, -0.36514047f, -0.01708579f, 
    -0.18011357f, 0.10858416f, -0.50495523f, -0.12335148f, 0.07645137f, -0.48093864f, 0.18914914f, -0.11602800f, 
    -0.10333892f, 0.12595233f, -0.32895729f, 0.26349139f, 0.20374721f, -0.12616734f, 0.11285153f, -0.13728200f, 
    0.09987666f, -0.35135812f, 0.12918705f, 0.11099306f, -0.00043918f, 0.08184276f, -0.50411540f, -0.06426708f, 
    0.09908952f, 0.01553573f, -0.06793804f, 0.07206597f, 0.07962678f, -0.01106587f, -0.05488667f, 0.18568231f, 
    -0.13201407f, 0.01319748f, -0.01388559f, 0.16193035f, -0.06828579f, -0.42294884f, -0.26116392f, -0.24934146f, 
    0.02595524f, 0.34660819f, 0.07002958f, 0.00965775f, -0.03739920f, -0.10668665f, 0.16154727f, 0.22061001f, 
    0.06433168f, -0.50824475f, -0.01712836f, -0.05461609f, -0.23725912f, 0.14213555f, 0.06778230f, 0.12894455f, 
    0.06204438f, -0.61728370f, 0.04420739f, -0.72610390f, 0.06151742f, -0.03736285f, 0.09529141f, 0.10712091f, 
    -0.28809679f, 0.24593531f, 0.16616011f, -0.13498877f, -0.14105065f, 0.17173184f, 0.13865896f, -0.07896107f, 
    -0.10401668f, -0.45450464f, -0.34229752f, 0.00116961f, 0.03719764f, 0.18525687f, -0.05020114f, -0.50831884f, 
    0.02797186f, 0.10959911f, -0.03142681f, -0.30196062f, -0.29132453f, 0.02939286f, -0.24135202f, 0.11061601f, 
    0.05226946f, 0.07703076f, -0.01992951f, 0.00739591f, 0.03238046f, -0.01284501f, -0.71619564f, 0.14727746f, 
    -0.04281766f, 0.12536111f, -0.35590079f, 0.00728594f, -0.24705461f, 0.26493314f, 0.20320538f, 0.01297907f, 
    -0.38465476f, -0.13426416f, -0.13440998f, -0.12248972f, 0.10938132f, 0.13811781f, -0.05504064f, 0.10957298f, 
    0.22346152f, 0.11619388f, 0.22205761f, -0.02836275f, 0.10004587f, 0.14580925f, -0.41799718f, 0.02078396f, 
    -0.18103732f, -0.31387159f, 0.04140134f, -0.00978368f, 0.10487045f, -0.08578480f, 0.23204525f, 0.08791851f, 
    0.12896617f, -0.15895559f, -0.23020151f, 0.01211808f, -0.15070331f, 0.07181778f, 0.18549937f, -0.00492267f, 
    -0.00282011f, -0.24608663f, 0.18758361f, -0.28996527f, -0.18519883f, 0.14174987f, 0.24281640f, 0.15432060f, 
    0.16797554f, 0.14085589f, -0.08928891f, 0.26422969f, -0.08738366f, 0.07349525f, -0.20567344f, 0.10562356f, 
    -0.22755456f, -0.01923509f, -0.06149845f, -0.08406854f, -0.31956807f, 0.07707699f, -0.12000249f, -0.22015154f, 
    0.12443012f, -0.27219430f, 0.02322491f, -0.02299165f, -0.01696402f, 0.00053148f, 0.08218417f, -0.43727404f, 
    -0.05620376f, 0.16355906f, 0.00552239f, 0.00493956f, 0.03127382f, 0.08728102f, -0.37204188f, -0.12661505f, 
    -0.04171579f, -0.12699039f, 0.06425789f, 0.27033421f, -0.15195708f, -0.27535483f, 0.12391901f, -0.03220956f, 
    -0.12066335f, -0.04068436f, 0.06217040f, -0.40075141f, -0.32927984f, -0.36249843f, -0.08040500f, -0.01466732f, 
    0.08890917f, -0.26583156f, 0.01779107f, 0.01499600f, -0.19692683f, -0.04531204f, -0.10840399f, -0.13747671f, 
    -0.24012667f, 0.01269318f, 0.27259046f, 0.08494767f, -0.76424557f, -0.20755824f, -0.16333407f, -0.07370956f, 
    -0.12175185f, 0.01665505f, 0.13110381f, -0.34633309f, -0.34431589f, -0.07747933f, 0.31669739f, -0.07920364f, 
    0.18544668f, -0.02995929f, 0.08399538f, 0.03613564f, 0.11750188f, 0.12689103f, -0.21664263f, -0.25936577f, 
    0.19030565f, 0.01352862f, 0.01514164f, 0.23691446f, 0.09302308f, 0.05416008f, -0.31728414f, -0.61325628f, 
    0.09793367f, 0.31196645f, 0.24161585f, 0.07621932f, 0.05267579f, 0.08933415f, 0.15383053f, 0.32808632f, 
    0.26640624f, -0.00017532f, -0.18751557f, 0.10481138f, -0.08069098f, -0.10159721f, 0.01009694f, 0.06718649f, 
    -0.35462818f, -0.04398795f, 0.03541699f, 0.04604403f, -0.07705233f, -0.13496099f, -0.57276028f, -0.10060647f, 
    0.13090454f, 0.11665873f, 0.22002213f, 0.07698069f, -0.05974519f, -0.19516768f, -0.11401468f, -0.09383763f, 
    -0.39814159f, 0.16429695f, -0.26632988f, -0.07426506f, 0.28517374f, -0.09412947f, 0.29001421f, -0.30297652f, 
    0.18384905f, 0.03456086f, 0.08606094f, -0.10463160f, 0.45534298f, -0.04368947f, 0.18134882f, -0.08021779f, 
    0.13792646f, 0.02283964f, -0.05914796f, -0.11366397f, 0.04240352f, 0.16412427f, -0.19213644f, 0.05558940f, 
    -0.13384870f, 0.10382143f, 0.22664970f, -0.37169024f, -0.47319475f, 0.06577782f, 0.09519544f, 0.16692990f, 
    -0.36345044f, -0.57038909f, -0.36451867f, 0.09937941f, -0.01072904f, 0.11077934f, -0.20073466f, -0.34371588f, 
    0.06808785f, 0.06851467f, 0.13614438f, 0.23016340f, -0.24173972f, 0.06908761f, -0.21613978f, -0.43858093f, 
    0.37689745f, 0.12831266f, 0.08914556f, -0.08861060f, -0.11084801f, -0.23452160f, -0.18040681f, 0.10096991f, 
    -0.47938436f, -0.08578223f, -0.01017400f, 0.03965840f, 0.01988503f, -0.34948018f, -0.10791520f, -0.11256618f, 
    0.05314360f, -0.13609323f, -0.18102421f, 0.04114645f, 0.05423729f, -0.28182361f, 0.37521011f, -0.45969555f, 
    0.04050630f, -0.04615395f, -0.34639290f, 0.03586325f, -0.43439007f, -0.00796283f, 0.32727882f, 0.06434505f, 
    0.15195458f, -0.03754492f, 0.04973617f, 0.10964411f, 0.12622961f, -0.39788395f, -0.11947208f, -0.55852699f, 
    0.01453274f, 0.19958349f, 0.14412306f, 0.30417836f, 0.17741445f, -0.12602344f, 0.13491482f, 0.19903800f, 
    0.02682914f, 0.00672424f, 0.07501800f, 0.08171669f, -0.09662694f, 0.04230854f, 0.12864117f, 0.18706875f, 
    -0.10479078f, 0.10644692f, -0.09425016f, -0.07647374f, -0.56283838f, -0.40777269f, -0.32628319f, -0.20821738f, 
    0.28702283f, 0.06511819f, -0.10419746f, -0.19593668f, -0.04451871f, 0.03195001f, 0.14278764f, 0.00759448f, 
    -0.22889854f, 0.10762410f, -0.26074988f, 0.02973398f, -0.39365438f, 0.03018465f, 0.09067032f, 0.09256712f, 
    -0.64033186f, -0.05395031f, 0.24308330f, 0.07009839f, 0.07139353f, 0.03781735f, -0.14489028f, 0.11913811f, 
    -0.12047760f, 0.01226931f, 0.13168091f, -0.29105949f, 0.06799342f, 0.03477524f, -0.05812598f, 0.08544610f, 
    -0.32479638f, 0.08726770f, -0.07897373f, 0.05048795f, 0.09590418f, -0.46300054f, 0.04087979f, 0.30970994f, 
    0.06737775f, -0.42997921f, -0.29346493f, 0.14158264f, -0.41299531f, 0.27085686f, 0.13380457f, -0.02894497f, 
    0.14157791f, -0.03636943f, 0.22829673f, 0.05273044f, 0.00312058f, -0.35258144f, 0.12497744f, -0.05169690f, 
    0.04035522f, 0.21846732f, -0.04063012f, -0.52271235f, -0.13205500f, 0.09831828f, -0.05591757f, -0.28137460f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.05931669f, 0.05218297f, 0.03197353f, -0.05059862f, -0.11776509f, 0.01449083f, -0.00584112f, -0.19335161f, 
    0.08154754f, -0.03489135f, 0.07714309f, -0.10967538f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
